# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEX_PERST_N: length 151.7
  TOP w0.127: Q2.D 167.19,114.17 R305.1 165.71,113.43 164.85,112.57 164.85,108.18 163.62,106.95 R351.2 163.62,106.03 163.86,105.79 v1(164.54,105.79) ; R138.2 v1(70.69,56.64)
  IN2 w0.112: v4(71.36,73.13) 70.82,72.58 70.82,63.5 71.45,62.87 71.45,57.4 v1(70.69,56.64) 70.12,56.08 70.12,53.62 70.49,53.26 80.51,53.26 81.1,53.85 81.1,54.86 84.13,57.89 116.64,57.89 157.06,98.31 158.72,98.31 164.74,104.33 164.74,105.59 v1(164.54,105.79)
  BOTTOM w0.127: U1.AG10 v4(71.36,73.13)
PG_CKPWRGD_N: length 4.4
  TOP w0.127: Q3.D 314.53,49.36 v1(314.53,50.04) 315.16,50.67 R3.2 315.65,51.52 Q4.G
PG_MOS: length 6.5
  TOP w0.127: Q3.G v1(314.78,47.69) 314.78,47.12 315.04,46.86 315.93,46.86 316.31,46.48 R298.2 315.72,45.79 315.72,45.41 316.31,44.82 R297.2
PQ6_2N7002_D1_G2: length 4.3
  TOP w0.203: PQ6.6 PQ6.5 34.49,107.82 PR402.2 34.84,107.48 v5(34.84,106.54) 34.84,106.28 34.51,105.95 PR403.1
PQ6_2N7002_G1: length 5.2
  TOP w0.254: v5(30.38,106.57) 29.57,106.57 PR398.2 ; v5(30.38,106.57) 30.38,107.48 PC570.1 30.72,107.82 PQ6.2 ; v5(30.38,106.57) 30.96,106 PR399.1
PST_PE_SLOT1_N: length 22.4
  TOP w0.127: R317.2 280.11,29.73 280.13,29.72 U8.4 280.13,28.84 279.35,28.07 278.33,28.07 277.95,27.69 277.95,24.89 v1(278.46,24.38)
  IN1 w0.097: v1(278.46,24.38) 278.49,24.36 278.49,23.39 281.97,19.91 281.97,18.85 282.75,18.06 282.75,17.2 282.42,16.87 282.42,15.57 283.64,14.35 285.19,14.35 285.78,14.93 J1.A11
PST_PE_SLOT2_N: length 8.2
  TOP w0.127: U17.4 282.92,29.58 282.91,29.59 R353.2 282.55,30.21 282.27,30.48 282.27,31.44 285.83,34.99 J2.A11
PST_PE_SLOT3_N: length 8.3
  TOP w0.127: U16.4 283.18,50.04 283.16,50.05 R352.2 282.55,50.53 282.4,50.67 282.4,51.82 285.83,55.25 J3.A11
PST_PE_SLOT4_N: length 8.1
  TOP w0.127: U15.4 283.05,70.23 283.16,70.34 R350.2 282.8,70.85 282.48,71.17 282.48,72.21 285.83,75.57 J4.A11
PST_PE_SLOT5_N: length 8.5
  TOP w0.127: J9.A11 285.83,95.49 283.86,93.52 283.86,90.85 R349.2 283.31,89.47 283.13,89.3 U13.4
PU_EEP_WP_R_N: length 4.5
  BOTTOM w0.127: U6.3 38.43,63.25 v2(37.16,64.52) 37.03,64.64 R274.2
PU_EMC1412_ALERT: length 3.8
  BOTTOM w0.127: R341.2 312.37,79.25 v2(311.61,80.01) 310.66,79.07 U4.6
PU_EMC1412_TEM: length 3.3
  BOTTOM w0.127: U4.4 304.62,79.72 304.38,79.96 v2(303.94,79.96) 303.56,79.96 303.23,79.63 R302.2
PU_PCA9548_SC7: length 7.9
  TOP w0.127: R186.2 305.91,27.92 v1(305.89,27.94) 305.89,29.48 305.36,30.02 305.36,30.25 305.13,30.49 305.13,31.88 305.44,32.2 U2.20
PU_PCA9548_SD7: length 5.8
  TOP w0.127: R185.2 305.13,29.74 v1(304.89,29.98) 304.79,30.08 304.79,31.94 305.16,32.31 305.16,33.53 304.79,33.9 U2.19
PU_PE_I2C_SCL_1: length 18.2
  TOP w0.127: R202.2 v1(74.5,59.69)
  IN2 w0.112: v1(74.5,59.69) 74.88,60.07 74.88,74.42 74.68,74.63 73.87,74.63 v4(73.36,75.13)
  BOTTOM w0.114: U1.AE12 v4(73.36,75.13)
PU_PE_I2C_SDA_1: length 14.8
  TOP w0.127: R201.2 v1(66.88,53.85)
  IN2 w0.112: v1(66.88,53.85) 66.37,54.36 66.37,56.52 65.61,57.28 65.61,60.3 64.85,61.06 64.85,65.66 v4(64.37,66.14)
  BOTTOM w0.114: v4(64.37,66.14) U1.AP3
PU_PEX_NT0_PERST_N: length 147.6
  TOP w0.127: v4(64.36,65.13) 64.85,64.65 64.85,59.82 v1(64.97,59.69) R136.2 ; R305.2 165.67,112.63 165.24,112.2 165.24,107.14 v1(164.54,106.45)
  IN2 w0.112: v1(164.54,106.45) 165.01,105.99 165.01,104.22 158.83,98.04 157.17,98.04 116.75,57.62 84.24,57.62 81.37,54.75 81.37,53.74 80.62,52.99 73.28,52.99 71.51,51.23 66.72,51.23 64.29,53.66 64.29,59 v1(64.97,59.69)
  BOTTOM w0.127: U1.AP2 v4(64.36,65.13)
PU_PEX_NT1_PERST_N: length 20.1
  TOP w0.127: R137.2 v1(102.82,74.04)
  IN2 w0.112: v4(89.36,77.13) 89.44,77.13 89.87,76.71 89.87,72.92 90.15,72.64 98.25,72.64 99.04,73.44 102.22,73.44 v1(102.82,74.04)
  BOTTOM w0.127: U1.K14 v4(89.36,77.13)
PU_SPARE0: length 20.4
  TOP w0.089: v4(91.36,78.13) 91.96,77.54 97.24,77.54 97.25,77.55
  TOP w0.127: R142.2 v1(109.55,77.85) 108.8,77.1 101.41,77.1 100.96,77.55 97.25,77.55
  BOTTOM w0.127: U1.H15 v4(91.36,78.13)
PU_SPARE1: length 34.1
  TOP w0.127: v4(90.36,82.13) 90.57,82.13 91.37,81.33 98.81,81.33 99.29,81.81 105.09,81.81 105.64,82.36 115.58,82.36 119.33,86.11 v1(119.33,87.5) R141.2
  BOTTOM w0.127: U1.J18 v4(90.36,82.13)
PU_SPARE2: length 49.6
  TOP w0.127: R139.2 48.82,56.01 49.25,56.43 R140.1 v1(49.86,56.9)
  IN2 w0.089: v4(73.36,83.13) 72.85,83.65 72.85,84.33 72.45,84.73 63.73,84.73
  IN2 w0.112: v1(49.86,56.9) 49.86,71.54 63.05,84.73 63.73,84.73
  BOTTOM w0.127: U1.AE19 v4(73.36,83.13)
PU_STRAP_GEN1_COMPLIANCE_N: length 23.2
  TOP w0.127: R148.2 v1(109.55,74.04)
  IN2 w0.112: v1(109.55,74.04) 108.42,72.91 101.18,72.91 98.93,70.66 89.83,70.66 v4(89.36,71.13)
  BOTTOM w0.127: U1.K8 v4(89.36,71.13)
PU_STRAP_GEN1_GEN2: length 35
  TOP w0.127: v4(91.36,80.13) 91.88,80.64 99.77,80.64 100.03,80.9 120.98,80.9 121.71,80.18 121.71,78.4 v1(122.25,77.85) R147.2
  BOTTOM w0.127: U1.H17 v4(91.36,80.13)
PU_STRAP_HP_POLARITY_CNTL: length 41.6
  TOP w0.127: R146.2 v1(55.45,50.67)
  IN2 w0.089: v4(73.36,78.13) 72.94,77.71 63.69,77.71
  IN2 w0.112: 63.69,77.71 57.74,71.76 57.74,57.66 56.21,56.13 56.21,51.44 v1(55.45,50.67)
  BOTTOM w0.127: U1.AE15 v4(73.36,78.13)
PU_STRAP_PLL_BYPASS_N: length 39.1
  TOP w0.127: R151.2 v1(55.45,52.96)
  IN2 w0.089: v4(72.36,78.13) 71.94,78.55 64.03,78.55 63.7,78.23
  IN2 w0.112: 63.7,78.23 57.48,72 57.48,57.96 55.83,56.32 55.83,53.34 v1(55.45,52.96)
  BOTTOM w0.127: U1.AF15 v4(72.36,78.13)
PU_STRAP_PROBE_MODE_N: length 37.9
  IN2 w0.112: v4(73.36,80.13) 72.88,80.61 64.1,80.61 56.42,72.93 56.42,61.63 v1(55.96,61.16)
  BOTTOM w0.127: U1.AE17 v4(73.36,80.13) ; R150.2 52.12,61.34 52.2,61.42 v2(53.04,61.42) 54.87,61.42 55.12,61.16 v1(55.96,61.16)
PU_STRAP_SERDES_MODE_EN_N: length 36.9
  IN2 w0.112: v4(71.36,82.13) 70.13,80.9 64.02,80.9 55.96,72.84 v1(55.96,61.9)
  BOTTOM w0.127: U1.AG18 v4(71.36,82.13) ; v1(55.96,61.9) 54.51,63.35 v2(53.06,63.35) 51.56,63.35 51.15,62.94 R149.2
PU_VS0_PERST_N: length 25.4
  TOP w0.089: 96.98,75.16 96.55,74.73 89.77,74.73 v4(89.36,75.13)
  TOP w0.127: 96.98,75.16 111.81,75.16 v1(112.6,75.95) R335.2
  BOTTOM w0.127: U1.K12 v4(89.36,75.13)
PU_VS1_PERST_N: length 14.2
  TOP w0.114: 99.52,65.56 97.94,65.56 v4(97.37,66.13)
  TOP w0.127: R334.2 v1(109.55,66.42) 108.69,65.56 99.52,65.56
  BOTTOM w0.127: U1.B3 v4(97.37,66.13)
PU_VS2_PERST_N: length 47
  TOP w0.127: R333.2 v1(47.07,56.9)
  IN2 w0.089: 63.9,87.73 70.77,87.73 v4(71.36,87.13)
  IN2 w0.112: 63.9,87.73 47.37,71.19 47.37,57.2 v1(47.07,56.9)
  BOTTOM w0.127: U1.AG23 v4(71.36,87.13)
PU_VS3_PERST_N: length 24.2
  TOP w0.127: R332.2 v1(112.47,87.5) 111.46,86.49 99.52,86.49 99.37,86.63 90.87,86.63 v4(90.36,86.13)
  BOTTOM w0.127: U1.J22 v4(90.36,86.13)
REXT_A0: length 16.7
  TOP w0.127: R10.2 v1(82.12,56.77) 81.1,57.78 81.1,60.07 80.65,60.53 79.88,60.53 78.08,62.33 78.08,62.99 78.06,63.02 78.06,68.28 78.91,69.13 v4(79.36,69.13)
  BOTTOM w0.127: U1.W6 v4(79.36,69.13)
REXT_A1: length 16
  TOP w0.127: v4(73.36,69.13) 73.08,68.84 73.08,68.83 72.26,68.02 72.26,63.25 75.77,59.74 75.77,57.28 v1(76.4,56.64) R11.2
  BOTTOM w0.127: U1.AE6 v4(73.36,69.13)
REXT_A2: length 15.2
  TOP w0.127: R12.2 v1(72.59,56.77) 71.88,57.48 71.88,59.77 69.85,61.8 69.85,68.62 v4(70.36,69.13)
  BOTTOM w0.127: U1.AH6 v4(70.36,69.13)
REXT_A3: length 22.4
  TOP w0.127: R13.2 v1(69.67,51.69)
  IN2 w0.112: v4(69.36,72.13) 69.36,72.08 68.91,71.63 68.91,63.25 69.86,62.3 69.86,51.88 v1(69.67,51.69)
  BOTTOM w0.127: U1.AJ9 v4(69.36,72.13)
REXT_A4: length 21.5
  TOP w0.089: 97.08,72.01 96.8,71.73 93.77,71.73 v4(93.36,72.13)
  TOP w0.127: 97.08,72.01 100.94,72.01 101.57,71.39 111.85,71.39 v1(112.6,72.14) R309.2
  BOTTOM w0.127: U1.F9 v4(93.36,72.13)
REXT_A5: length 17.8
  TOP w0.089: 99.52,69.76 99.48,69.72 91.9,69.72 91.49,70.13 v7(91.36,70.13)
  TOP w0.127: R41.2 107.58,69.76 99.52,69.76
  BOTTOM w0.127: U1.H6 v7(91.36,70.13)
REXT_A6: length 30
  TOP w0.089: v4(88.36,69.13) 88.81,69.13 89.41,68.53 99.42,68.53 99.52,68.43
  TOP w0.127: 99.52,68.43 99.95,68.43 100.43,68.91 114.48,68.91 115.65,70.08 v1(115.65,70.23) R42.2
  BOTTOM w0.127: U1.L6 v4(88.36,69.13)
REXT_A7: length 2.1
  TOP w0.114: R43.2 83.69,69.45 v6(83.36,69.13)
  BOTTOM w0.127: U1.T6 v6(83.36,69.13)
REXT_A8: length 2.9
  TOP w0.114: R49.2 70.37,73.13 v6(70.36,73.13)
  BOTTOM w0.127: U1.AJ11 70.36,74.13 v6(70.36,73.13)
REXT_A9: length 4.5
  TOP w0.114: v7(70.36,80.13) 70.43,80.13 71.05,80.75 R50.2
  BOTTOM w0.127: U1.AJ17 v7(70.36,80.13)
REXT_A10: length 35.3
  TOP w0.089: 68.63,99.44 68.63,99.31 68.78,99.16 68.78,85.6 69.25,85.13 v4(69.36,85.13)
  TOP w0.127: v6(54.08,107.7) 61.84,107.7 68.63,100.9 68.63,99.44
  BOTTOM w0.127: R51.2 v6(54.08,107.7) ; U1.AJ21 v4(69.36,85.13)
REXT_A11: length 31.3
  TOP w0.089: v4(69.36,88.13) 69.54,88.13 69.8,88.39 69.8,90.22 70.99,91.41 70.99,91.92 70.97,91.95 70.97,99.44
  TOP w0.127: 70.97,99.44 70.97,102.44 62.71,110.69 v6(61.49,110.69)
  BOTTOM w0.127: U1.AJ24 v4(69.36,88.13) ; R52.2 v6(61.49,110.69)
REXT_A12: length 15.4
  TOP w0.089: v4(93.36,89.13) 93.75,88.74 96.57,88.74 96.72,88.9
  TOP w0.127: 96.72,88.9 99.14,88.9 99.9,88.14 105.87,88.14 v1(106.5,87.5) R311.2
  BOTTOM w0.127: U1.F25 v4(93.36,89.13)
REXT_A13: length 33.6
  TOP w0.089: 99.52,82.75 99.49,82.73 93.6,82.73 93.36,82.96 v4(93.36,83.13)
  TOP w0.127: R312.2 v1(119.33,91.31) 118.54,90.53 118.54,86.54 115.95,83.94 100.71,83.94 99.52,82.75 99.52,82.75
  BOTTOM w0.127: U1.F19 v4(93.36,83.13)
REXT_A14: length 21.4
  TOP w0.089: v4(93.36,77.13) 93.77,76.73 96.62,76.73 96.84,76.95
  TOP w0.127: 96.84,76.95 101.03,76.95 101.15,76.82 111.57,76.82 v1(112.6,77.85) R313.2
  BOTTOM w0.127: U1.F14 v4(93.36,77.13)
REXT_A15: length 27.9
  TOP w0.089: 97.08,74.02 96.79,73.73 93.77,73.73 v4(93.36,74.13)
  TOP w0.127: 97.08,74.02 101.32,74.02 101.88,74.57 118.42,74.57 v1(118.95,74.04) R314.2
  BOTTOM w0.127: U1.F11 v4(93.36,74.13)
REXT_A16: length 26.4
  TOP w0.089: 69.78,99.44 69.78,91.39 69.52,91.13 v4(69.36,91.13)
  TOP w0.127: v6(59.94,109.68) 60.09,109.52 63.09,109.52 69.78,102.84 69.78,99.44
  BOTTOM w0.127: R58.2 v6(59.94,109.68) ; U1.AJ27 v4(69.36,91.13)
REXT_A17: length 33.2
  TOP w0.127: v4(71.36,93.13) 71.83,93.6 71.83,101.98 62.43,111.38 60.99,111.38 60.53,110.92 59.46,110.92 58.73,110.19 56.19,110.19 55.65,110.72 v6(55.65,110.74)
  BOTTOM w0.127: U1.AG29 v4(71.36,93.13) ; R59.2 v6(55.65,110.74)
REXT_A18: length 36.8
  TOP w0.127: v6(55.6,112.78) 56.19,112.19 58.12,112.19 58.85,112.93 60.76,112.93 61.16,113.33 62.36,113.33 75.91,99.78 75.91,93.58 v4(76.36,93.13)
  BOTTOM w0.127: R60.2 v6(55.6,112.78) ; U1.AB29 v4(76.36,93.13)
REXT_A19: length 32.9
  TOP w0.127: v6(61.44,114.76) 62.31,114.76 78.89,98.18 78.89,93.65 v4(78.36,93.13)
  BOTTOM w0.127: R61.2 v6(61.44,114.76) ; U1.Y29 v4(78.36,93.13)
REXT_A20: length 38.4
  TOP w0.114: 83.26,99.44 82.91,99.09 82.91,93.45 82.59,93.13 v4(82.36,93.13)
  TOP w0.127: R67.2 v1(109.55,95.12) 108.36,96.32 104.19,96.32 98.6,101.9 85.73,101.9 83.26,99.44
  BOTTOM w0.127: U1.U29 v4(82.36,93.13)
REXT_A21: length 34.4
  TOP w0.114: v4(87.36,93.13) 87.29,93.13 86.9,93.52 86.9,98.58 87.76,99.44
  TOP w0.127: R68.2 v1(109.55,93.22) 108.76,94.01 102.49,94.01 100.84,95.66 100.84,97.84 98.73,99.95 88.27,99.95 87.76,99.44
  BOTTOM w0.127: U1.M29 v4(87.36,93.13)
REXT_A22: length 21.4
  TOP w0.127: R69.2 v1(106.5,91.31) 105.87,91.95 102.26,91.95 98.58,95.63 91.17,95.63 90.87,95.33 90.87,93.62 v4(91.36,93.13)
  BOTTOM w0.127: U1.H29 v4(91.36,93.13)
REXT_A23: length 15.8
  TOP w0.127: R70.2 v1(106.5,89.41) 105.87,90.04 99.65,90.04 97.99,91.69 93.93,91.69 v4(93.36,91.13)
  BOTTOM w0.127: U1.F27 v4(93.36,91.13)
REXT_B0: length 2.3
  TOP w0.114: R14.2 81.09,69.86 v6(80.36,69.13)
  BOTTOM w0.127: U1.V6 v6(80.36,69.13)
REXT_B1: length 18.5
  TOP w0.127: R15.2 v1(78.31,53.85) 77.29,54.86 77.29,59.79 74.25,62.84 74.25,68.61 74.36,68.72 v4(74.36,69.13)
  BOTTOM w0.127: U1.AD6 v4(74.36,69.13)
REXT_B2: length 12.2
  TOP w0.127: R16.2 v1(72.59,59.69) 70.41,61.87 70.41,68.18 v4(71.36,69.13)
  BOTTOM w0.127: U1.AG6 v4(71.36,69.13)
REXT_B3: length 13.4
  TOP w0.127: v1(70.69,59.69) R17.2
  IN2 w0.112: v1(70.69,59.69) 70.69,62.48 69.8,63.37 69.8,70.69 v4(69.36,71.13)
  BOTTOM w0.127: U1.AJ8 v4(69.36,71.13)
REXT_B4: length 27.9
  TOP w0.089: 99.52,70.83 98.9,70.83 98.8,70.73 93.76,70.73 v4(93.36,71.13)
  TOP w0.127: 99.52,70.83 117.64,70.83 v1(118.95,72.14) R44.2
  BOTTOM w0.127: U1.F8 v4(93.36,71.13)
REXT_B5: length 21.1
  TOP w0.089: 99.4,69.48 99.37,69.52 91.98,69.52 91.59,69.13 v4(90.36,69.13)
  TOP w0.127: 99.4,69.48 108.8,69.48 v1(109.55,70.23) R45.2
  BOTTOM w0.127: U1.J6 v4(90.36,69.13)
REXT_B6: length 18.5
  TOP w0.089: 99.52,67.74 89.13,67.74 88.93,67.94 88.93,68.33 88.62,68.63 87.81,68.63 87.36,69.08 v4(87.36,69.13)
  TOP w0.127: R46.2 v1(102.82,68.33) 102.24,67.74 99.52,67.74
  BOTTOM w0.127: U1.M6 v4(87.36,69.13)
REXT_B7: length 25.8
  TOP w0.114: 99.52,66.67 86.11,66.67 85.8,66.98 85.8,68.63 85.36,69.07 v4(85.36,69.13)
  TOP w0.127: R47.2 v1(106.38,66.42) 106.33,66.37 105.51,66.37 105.21,66.67 99.52,66.67
  BOTTOM w0.127: v4(85.36,69.13) 84.36,69.13 U1.R6
REXT_B8: length 22.2
  TOP w0.127: R53.2 v1(68.78,53.85)
  IN2 w0.112: v1(68.78,53.85) 69.42,54.48 69.42,60.27 67.9,61.8 67.9,71.65 69.08,72.84 69.08,72.85 v4(69.36,73.13)
  BOTTOM w0.127: U1.AJ10 v4(69.36,73.13)
REXT_B9: length 1.8
  TOP w0.114: R54.2 v7(69.36,79.13)
  BOTTOM w0.127: U1.AJ16 v7(69.36,79.13)
REXT_B10: length 36
  TOP w0.089: v4(69.36,84.13) 69.36,84.18 68.86,84.68 68.12,84.68 67.87,84.94 67.87,99.44
  TOP w0.127: 67.87,99.44 67.87,101.27 62.46,106.68 v6(55.5,106.68)
  BOTTOM w0.127: U1.AJ20 v4(69.36,84.13) ; R55.2 v6(55.5,106.68)
REXT_B11: length 35.3
  TOP w0.089: 68.91,99.44 68.98,99.38 68.98,87.26 69.11,87.13 v4(69.36,87.13)
  TOP w0.127: v6(55.63,108.71) 63.51,108.71 68.91,103.31 68.91,99.44
  BOTTOM w0.127: U1.AJ23 v4(69.36,87.13) ; R56.2 v6(55.63,108.71)
REXT_B12: length 12
  TOP w0.089: v4(93.36,88.13) 93.79,88.55 98.98,88.55
  TOP w0.127: 98.98,88.55 100.03,87.5 v1(102.82,87.5) R211.2
  BOTTOM w0.127: U1.F24 v4(93.36,88.13)
REXT_B13: length 32.1
  TOP w0.089: v4(93.36,82.13) 93.36,82.26 93.63,82.52 99.14,82.52 99.29,82.37 99.52,82.37
  TOP w0.127: R315.2 v1(119.33,89.41) 118.82,88.9 118.82,86.36 116.08,83.62 100.84,83.62 99.6,82.37 99.52,82.37
  BOTTOM w0.127: U1.F18 v4(93.36,82.13)
REXT_B14: length 11.7
  TOP w0.089: v4(93.36,76.13) 93.77,75.72 96.66,75.72 96.88,75.95 97.06,75.95
  TOP w0.127: R316.2 v1(102.82,75.95) 97.06,75.95
  BOTTOM w0.127: U1.F13 v4(93.36,76.13)
REXT_B15: length 12
  TOP w0.089: 97.11,72.92 97.03,72.92 96.83,72.73 93.77,72.73 v4(93.36,73.13)
  TOP w0.127: 97.11,72.92 100.99,72.92 101.78,72.14 v1(102.82,72.14) R336.2
  BOTTOM w0.127: U1.F10 v4(93.36,73.13)
REXT_B16: length 35.2
  TOP w0.089: 70.33,99.44 70.77,99.01 70.77,91.72 69.36,90.32 v4(69.36,90.13)
  TOP w0.127: 70.33,99.44 70.13,99.64 70.13,102.88 63.21,109.8 61.04,109.8 60.45,110.39 59.49,110.39 58.27,109.17 56.57,109.17 56.01,109.73 v6(54.1,109.73)
  BOTTOM w0.127: U1.AJ26 v4(69.36,90.13) ; R62.2 v6(54.1,109.73)
REXT_B17: length 27.4
  TOP w0.127: v6(59.91,111.71) 59.96,111.66 62.56,111.66 72.88,101.34 72.88,93.65 v4(72.36,93.13)
  BOTTOM w0.127: U1.AF29 v4(72.36,93.13) ; R63.2 v6(59.91,111.71)
REXT_B18: length 31
  TOP w0.127: v4(77.36,93.13) 76.83,93.67 76.83,99.3 62.38,113.74 v6(59.86,113.74)
  BOTTOM w0.127: U1.AA29 v4(77.36,93.13) ; R64.2 v6(59.86,113.74)
REXT_B19: length 40
  TOP w0.127: v6(55.6,114.81) 56.39,114.81 57.2,115.62 61.85,115.62 79.83,97.64 79.83,93.6 v4(79.36,93.13)
  BOTTOM w0.127: U1.W29 v4(79.36,93.13) ; R65.2 v6(55.6,114.81)
REXT_B20: length 34.2
  TOP w0.114: 83.92,99.44 83.8,99.31 83.8,93.55 83.38,93.13 v4(83.36,93.13)
  TOP w0.127: 83.92,99.44 86.11,101.63 98.48,101.63 104.19,95.91 105.72,95.91 v1(106.5,95.12) R71.2
  BOTTOM w0.127: U1.T29 v4(83.36,93.13)
REXT_B21: length 30.3
  TOP w0.114: v4(88.36,93.13) 88.23,93.13 87.96,93.4 87.96,98.83 88.57,99.44 ; 99.52,98.76 98.83,99.44
  TOP w0.127: 88.57,99.44 88.8,99.67 98.6,99.67 98.83,99.44 ; 99.52,98.76 100.56,97.71 100.56,95.5 102.34,93.73 106,93.73 v1(106.5,93.22) R72.2
  BOTTOM w0.127: U1.L29 v4(88.36,93.13)
REXT_B22: length 13.8
  TOP w0.127: R73.2 v1(102.82,91.31) 99.52,91.31 97.87,92.96 97.87,93.34 97.61,93.6 92.91,93.6 92.45,93.13 v4(92.36,93.13)
  BOTTOM w0.127: U1.G29 v4(92.36,93.13)
REXT_B23: length 12.2
  TOP w0.127: R74.2 v1(102.82,89.41) 99.77,89.41 98.5,90.68 93.91,90.68 v4(93.36,90.13)
  BOTTOM w0.127: U1.F26 v4(93.36,90.13)
REXT_CMU0: length 18.8
  TOP w0.127: R18.2 v1(76.4,53.72) 75.9,54.23 75.9,56.39 75.49,56.79 75.49,59.56 71.88,63.17 71.88,68.65 v4(72.36,69.13)
  BOTTOM w0.127: U1.AF6 v4(72.36,69.13)
REXT_CMU1: length 25.5
  TOP w0.089: 99.52,68.73 89.74,68.73 89.36,69.11 v4(89.36,69.13)
  TOP w0.127: 99.52,68.73 99.85,68.73 100.31,69.19 111.56,69.19 v1(112.6,70.23) R48.2
  BOTTOM w0.127: U1.K6 v4(89.36,69.13)
REXT_CMU2: length 3
  TOP w0.114: R57.2 71.05,81.71 69.78,81.71 v7(69.36,82.13)
  BOTTOM w0.127: U1.AJ18 v7(69.36,82.13)
REXT_CMU3: length 11.8
  TOP w0.089: v4(93.36,79.13) 93.77,79.53 96.67,79.53 96.83,79.38 96.87,79.38
  TOP w0.127: 96.87,79.38 100.59,79.38 100.97,79.76 v1(102.82,79.76) R337.2
  BOTTOM w0.127: U1.F16 v4(93.36,79.13)
REXT_CMU4: length 35
  TOP w0.127: v6(54.08,111.76) 55.81,111.76 56.39,111.18 58.17,111.18 59.39,112.39 60.56,112.39 61.01,111.94 62.74,111.94 73.86,100.81 73.86,93.63 v4(73.36,93.13)
  BOTTOM w0.127: R66.2 v6(54.08,111.76) ; U1.AE29 v4(73.36,93.13)
REXT_CMU5: length 33.9
  TOP w0.127: R75.2 v1(112.47,91.31) 111.15,92.63 102.51,92.63 99.9,95.24 99.9,97.28 98.5,98.68 90.17,98.68 89.87,98.38 89.87,93.63 v4(90.36,93.13)
  BOTTOM w0.127: U1.J29 v4(90.36,93.13)
RST_PE_SLOT_N: length 268.8
  TOP w0.127: v1(283.29,25.02) 283.29,25.15 282.27,26.16 U17.2 282.27,27.46 282.04,27.69 281.26,27.69 280.93,27.36 280.93,26.31 280.42,25.81 279.78,25.81 279.48,26.11 U8.2 ; v1(284.84,68.1) 284.1,68.83 282.88,68.83 282.4,68.35 U15.2 ; v1(285.07,48.01) 284.56,48.01 284.07,48.49 283.88,48.49 283.83,48.54 283.06,48.54 282.53,48.01 U16.2 ; U13.2 284.43,88.65 v1(283.8,88.01) ; Q1.G 170.86,109.79 171.27,110.21 171.27,114.17 173.86,116.76 256.19,116.76 v1(257.63,115.32) ; v1(282.81,11.76) 284.68,9.88 285.13,9.88 286.72,8.29 286.72,6.6 285.83,5.71 J5.A11
  IN1 w0.097: v1(282.81,11.76) 282.73,11.84 280.37,11.84 279.91,12.29 279.91,13.56 278.69,14.78 278.69,18.06 277.88,18.87 277.88,20.98 277.53,21.32 277.53,24.47 278.11,25.04 279.02,25.04 279.78,24.28 283.19,24.28 283.29,24.38 v1(283.29,25.02) 283.29,29.21 284.68,30.61 285.45,30.61 287.86,33.02 287.86,34.04 288.88,35.05 288.88,38.35 287.86,39.37 287.86,41.48 286.23,43.1 286.23,44.91 285.14,46 285.14,47.93 v1(285.07,48.01) 286.04,48.01 286.82,48.79 286.82,52.3 287.86,53.34 287.86,54.36 288.75,55.24 288.75,58.42 287.73,59.44 287.73,60.45 286.08,62.1 286.08,66.55 284.84,67.79 v1(284.84,68.1)
  IN3 w0.112: v1(257.63,115.32) 262.59,110.36 279.86,110.36 281.38,108.84 281.38,102.23 281.89,101.73 281.89,99.95 281,99.06 281,96.09 279.88,94.97 279.88,93.83 282.91,90.81 282.91,88.77 283.67,88.01 v1(283.8,88.01)
  BOTTOM w0.114: v1(284.84,68.1) 284.84,70.77 287.83,73.76 287.83,74.3 288.8,75.26 288.8,79.04 287.94,79.91 287.94,82.19 285.45,84.68 285.45,86.36 v1(283.8,88.01)
RST_PEX_MOS_N: length 5.6
  TOP w0.127: R348.2 166.96,110.72 166.98,110.74 Q1.D 167.89,112.25 v1(168.86,113.22) Q2.G
SLOT2_JTAG_TCK: length 4.5
  TOP w0.127: R275.2 292.43,31.75 291.83,32.35 J2.A5
SLOT2_JTAG_TDI: length 2.5
  TOP w0.127: J2.A6 290.83,31.59 R262.2
SLOT2_JTAG_TDO: length 4.5
  TOP w0.127: R263.2 289.83,31.58 J2.A7
SLOT2_JTAG_TMS: length 2.5
  TOP w0.127: R264.2 289.08,31.32 289.08,33.01 J2.A8
SLOT2_JTAG_TRST_N: length 4.9
  TOP w0.127: R261.2 287.86,41.02 287.83,40.99 J2.B9
SLOT3_JTAG_TCK: length 4.6
  TOP w0.127: R260.2 292.56,52.32 291.83,53.05 J3.A5
SLOT3_JTAG_TDI: length 2.5
  TOP w0.127: J3.A6 290.83,52.66 291.54,51.94 R257.2
SLOT3_JTAG_TDO: length 4.5
  TOP w0.127: R258.2 290.53,51.82 289.83,52.51 J3.A7
SLOT3_JTAG_TMS: length 2.5
  TOP w0.127: R259.2 289.51,52.2 288.83,52.88 J3.A8
SLOT3_JTAG_TRST_N: length 4.8
  TOP w0.127: J3.B9 287.86,58.11 R252.2
SLOT4_JTAG_TCK: length 4.6
  TOP w0.127: R251.2 292.56,72.77 291.83,73.5 J4.A5
SLOT4_JTAG_TDI: length 2.5
  TOP w0.127: R248.2 291.54,72.31 290.83,73.03 J4.A6
SLOT4_JTAG_TDO: length 4.5
  TOP w0.127: R249.2 290.53,72.39 289.83,73.09 J4.A7
SLOT4_JTAG_TMS: length 2.5
  TOP w0.127: R250.2 289.51,72.51 288.83,73.19 J4.A8
SLOT4_JTAG_TRST_N: length 4.9
  TOP w0.127: J4.B9 287.83,80.99 288.24,81.41 R247.2
SLOT5_JTAG_TCK: length 4.4
  TOP w0.127: J9.A5 291.83,93.79 292.56,93.06 R246.2
SLOT5_JTAG_TDI: length 2.4
  TOP w0.127: J9.A6 290.83,93.75 291.54,93.04 R239.2
SLOT5_JTAG_TDO: length 4.4
  TOP w0.127: R240.2 290.53,93.15 289.83,93.85 J9.A7
SLOT5_JTAG_TMS: length 2.4
  TOP w0.127: R245.2 289.51,93.53 J9.A8
SLOT5_JTAG_TRST_N: length 4.6
  TOP w0.127: J9.B9 287.83,99.9 288.01,100.08 R238.2
STRAP_I2C_SMBUS_CFG_EN_N: length 13.1
  TOP w0.127: R287.2 R288.1 v1(66.88,56.77) 65.99,56.77 65.61,57.15 65.61,63.25 65.86,63.5 65.86,65.63 v4(65.36,66.13)
  BOTTOM w0.127: U1.AN3 v4(65.36,66.13)
STRAP_I2C_SMBUS_SEL: length 13.8
  TOP w0.127: R289.2 R290.1 v1(64.97,56.77)
  BOTTOM w0.127: v1(64.97,56.77) 64.11,57.63 64.11,61.72 63.7,62.13 63.7,67.03 64.3,67.63 U1.AP4
STRAP_MGMT_CFG_EN_N: length 51
  TOP w0.127: R181.2 118.93,67.44 114.36,67.44 R182.1 v1(112.6,66.42)
  IN2 w0.112: v1(112.6,66.42) 112.6,65.81 112.31,65.52 110.86,65.52 109.16,63.81 101.8,63.81 99.05,61.07 84.8,61.07 81.61,64.26 81.61,69.88 v4(80.36,71.13)
  BOTTOM w0.127: U1.V8 v4(80.36,71.13)
STRAP_NT0_UPSTRM_PORTSEL_0: length 34.8
  TOP w0.127: v1(106.38,68.33) R133.1 108.01,67.56 109.93,67.56 110.29,67.93 R132.2
  IN2 w0.112: v1(106.38,68.33) 105.82,68.88 104.5,68.88 98.45,62.84 87.63,62.84 86.86,63.61 86.86,69.63 v4(86.36,70.13)
  BOTTOM w0.127: U1.N7 v4(86.36,70.13)
STRAP_NT0_UPSTRM_PORTSEL_1: length 19.3
  BOTTOM w0.127: U1.C2 95.92,65.63 96.37,65.18 96.37,64.29 97.66,62.99 99.33,62.99 101.72,65.38 v2(103.25,65.38) 105.34,65.38 105.51,65.2 108.85,65.2 R131.1 110,64.99 111.35,64.99 R130.2
STRAP_NT0_UPSTRM_PORTSEL_2: length 17.1
  TOP w0.127: R128.2 R129.1 v1(68.78,56.77) 68.15,57.4 68.15,61.26 67.9,61.52 67.9,68.33 67.64,68.58 65.81,68.58 v4(65.36,68.13)
  BOTTOM w0.127: U1.AN5 v4(65.36,68.13)
STRAP_NT1_UPSTRM_PORTSEL_0: length 32.5
  TOP w0.089: 97.06,79.65 96.98,79.73 89.96,79.73 v4(89.36,79.13)
  TOP w0.127: 97.06,79.65 100.26,79.65 101.12,80.52 114.89,80.52 v1(115.65,79.76) R331.1 117.03,79.25 119.31,79.25 R330.2
  BOTTOM w0.127: U1.K16 v4(89.36,79.13)
STRAP_NT1_UPSTRM_PORTSEL_1: length 21.5
  TOP w0.089: v4(90.36,76.13) 90.96,75.53 97.04,75.53 97.09,75.48
  TOP w0.127: R328.2 109.81,75.46 107.73,75.46 R329.1 v1(106.38,75.95) 105.91,75.48 97.09,75.48
  BOTTOM w0.127: U1.J13 v4(90.36,76.13)
STRAP_NT1_UPSTRM_PORTSEL_2: length 16.5
  TOP w0.089: v4(92.36,78.13) 92.77,77.73 96.7,77.73 96.95,77.98
  TOP w0.127: R326.2 106.78,77.38 104.19,77.38 104.07,77.5 R327.1 v1(102.82,77.85) 101.68,77.85 101.55,77.98 96.95,77.98
  BOTTOM w0.127: U1.G15 v4(92.36,78.13)
STRAP_REFCLK_SSC_EN0: length 33.4
  TOP w0.127: R205.2 v1(59.26,52.96)
  IN2 w0.112: v1(59.26,52.96) 58.53,53.69 58.53,70.27 63.96,75.69 70.05,75.69 70.36,76 v4(70.36,76.13)
  BOTTOM w0.127: U1.AH13 v4(70.36,76.13)
STRAP_REFCLK_SSC_EN1: length 21.6
  TOP w0.127: v4(79.36,71.13) 78.08,69.85 78.08,68.76 77.8,68.48 77.8,62.2 79.76,60.25 80.52,60.25 80.82,59.94 80.82,55.14 v1(82.12,53.85) R206.2
  BOTTOM w0.127: U1.W8 v4(79.36,71.13)
STRAP_REFCLK_SSC_EN2: length 42.5
  TOP w0.127: R207.2 52.97,54.99 v1(53.34,54.62)
  IN2 w0.089: v4(71.36,83.13) 70.77,82.54 64.05,82.54 63.91,82.4
  IN2 w0.112: v1(53.34,54.62) 54.3,55.58 54.3,73.87 62.83,82.4 63.91,82.4
  BOTTOM w0.127: U1.AG19 v4(71.36,83.13)
STRAP_REFCLK_SSC_EN3: length 39.4
  TOP w0.127: R208.2 52.48,56.71 v1(53.24,56.71)
  IN2 w0.089: 63.81,82.73 69.96,82.73 v4(70.36,83.13)
  IN2 w0.112: v1(53.24,56.71) 54.03,57.5 54.03,73.98 62.78,82.73 63.81,82.73
  BOTTOM w0.127: U1.AH19 v4(70.36,83.13)
STRAP_REFCLK_SSC_EN4: length 21.8
  TOP w0.127: R217.2 v1(106.38,74.04)
  IN2 w0.112: v4(87.36,72.13) 87.89,71.6 97.72,71.6 99.29,73.17 105.51,73.17 v1(106.38,74.04)
  BOTTOM w0.127: U1.M9 v4(87.36,72.13)
STRAP_REFCLK_SSC_EN5: length 16.2
  TOP w0.089: 96.98,78.99 96.71,78.73 92.77,78.73 v4(92.36,79.13)
  TOP w0.127: R218.2 v1(106.5,79.76) 105.74,78.99 96.98,78.99
  BOTTOM w0.127: U1.G16 v4(92.36,79.13)
STRAP_REFCLK_SSC_EN6: length 43.5
  TOP w0.127: R219.2 v1(115.65,68.33)
  IN2 w0.112: v1(115.65,68.33) 114.33,67.01 104.88,67.01 103.19,65.32 102.18,65.32 98.72,61.86 86.55,61.86 84.86,63.55 84.86,70.63 v4(85.36,71.13)
  BOTTOM w0.127: U1.P8 v4(85.36,71.13)
STRAP_REFCLK_SSC_EN7: length 12
  BOTTOM w0.127: U1.C1 95.86,64.08 97.28,62.66 99.4,62.66 100.26,63.53 103.74,63.53 v2(104.73,64.52) R220.2
STRAP_REFCLK_SSC_EN8: length 32.7
  TOP w0.127: v6(61.44,112.73) 62.43,112.73 74.88,100.28 74.88,93.47 73.82,92.42 73.82,90.59 v4(73.36,90.13)
  BOTTOM w0.127: R229.2 v6(61.44,112.73) ; U1.AE26 v4(73.36,90.13)
STRAP_REFCLK_SSC_EN9: length 46
  TOP w0.127: R230.2 v1(49.86,53.09)
  IN2 w0.089: 64.05,83.73 70.96,83.73 v4(71.36,84.13)
  IN2 w0.112: 64.05,83.73 62.84,83.73 52.4,73.3 52.4,55.63 v1(49.86,53.09)
  BOTTOM w0.127: U1.AG20 v4(71.36,84.13)
STRAP_REFCLK_SSC_EN10: length 10.5
  BOTTOM w0.127: U1.AP32 63.43,97.07 63.43,100.56 64.59,101.73 v2(64.59,102.87) R231.2
STRAP_REFCLK_SSC_EN11: length 21
  TOP w0.127: v6(54.31,105.59) 63.07,105.59 67.36,101.29 v4(67.36,97.13)
  BOTTOM w0.127: v6(54.31,105.59) 54.26,105.54 R232.2 ; U1.AL33 v4(67.36,97.13)
STRAP_REFCLK_SSC_EN12: length 29.8
  TOP w0.127: v4(90.36,84.13) 90.65,84.42 92.29,84.42 93.02,83.69 100.03,83.69 100.79,84.45 114.25,84.45 115.9,86.11 v1(115.9,87.5) R241.2
  BOTTOM w0.127: U1.J20 v4(90.36,84.13)
STRAP_REFCLK_SSC_EN13: length 21.4
  TOP w0.127: v4(90.36,88.13) 90.87,87.62 99.4,87.62 100.15,86.87 108.92,86.87 v1(109.55,87.5) R242.2
  BOTTOM w0.127: U1.J24 v4(90.36,88.13)
STRAP_REFCLK_SSC_EN14: length 29.6
  TOP w0.127: R243.2 v1(115.9,91.31) 115.1,90.51 115.1,86.96 113.73,85.59 93.03,85.59 92.57,85.13 v4(92.36,85.13)
  BOTTOM w0.127: U1.G21 v4(92.36,85.13)
STRAP_REFCLK_SSC_EN15: length 29.5
  TOP w0.127: R244.2 v1(115.9,89.41) 115.43,88.94 115.43,86.65 114,85.22 100.15,85.22 99.6,84.66 91.84,84.66 v4(91.36,85.13)
  BOTTOM w0.127: U1.H21 v4(91.36,85.13)
STRAP_REFCLK_SSC_EN16: length 39.6
  TOP w0.127: v4(78.36,92.13) 77.79,92.71 77.79,98.87 62.54,114.12 60.68,114.12 60.43,114.38 59.39,114.38 58.24,113.23 56.92,113.23 56.39,113.77 54.05,113.77 v6(54.03,113.79)
  BOTTOM w0.127: R253.2 v6(54.03,113.79) ; U1.Y28 v4(78.36,92.13)
STRAP_REFCLK_SSC_EN17: length 9.7
  BOTTOM w0.127: R254.2 v2(66.5,102.87) 64.06,100.43 64.06,97.43 U1.AP33
STRAP_REFCLK_SSC_EN18: length 42.1
  TOP w0.127: v4(80.36,91.13) 80.88,91.65 80.88,98.23 85.9,103.25 103.33,103.25 v1(109.55,97.03) R255.2
  BOTTOM w0.127: U1.V27 v4(80.36,91.13)
STRAP_REFCLK_SSC_EN19: length 44.2
  TOP w0.127: R256.2 v1(112.47,95.12) 111.52,96.08 109.22,96.08 102.55,102.74 85.89,102.74 81.26,98.12 81.26,93.23 v4(82.36,92.13)
  BOTTOM w0.127: U1.U28 v4(82.36,92.13)
STRAP_REFCLK_SSC_EN20: length 22.8
  TOP w0.127: v4(90.36,91.13) 90.85,91.62 92.58,91.62 92.86,91.9 92.86,92.35 93.09,92.58 97.61,92.58 99.65,90.55 108.41,90.55 v1(109.55,89.41) R265.2
  BOTTOM w0.127: U1.J27 v4(90.36,91.13)
STRAP_REFCLK_SSC_EN21: length 39.9
  TOP w0.127: R266.2 v1(112.47,93.22) 111.3,94.39 102.8,94.39 101.68,95.5 101.68,97.59 98.43,100.84 88.34,100.84 85.86,98.35 85.86,93.05 86.36,92.54 v4(86.36,92.13)
  BOTTOM w0.127: U1.M28 v4(86.36,92.13)
STRAP_REFCLK_SSC_EN22: length 17.5
  TOP w0.127: R267.2 v1(109.55,91.31) 108.61,92.25 102.35,92.25 99.49,95.11 99.49,95.91 98.76,96.65 96.88,96.65 v4(96.36,96.13)
  BOTTOM w0.127: U1.C32 v4(96.36,96.13)
STRAP_REFCLK_SSC_EN23: length 8.2
  BOTTOM w0.127: U1.B31 97.36,95.12 98.33,95.12 100.23,97.03 v2(102.82,97.03) R268.2
STRAP_RESERVED_17: length 24
  TOP w0.089: v4(91.36,79.13) 91.96,78.54 97.2,78.54 97.22,78.55
  TOP w0.127: R295.2 112.83,79.25 110.57,79.25 110.29,79.52 R325.2 v1(109.55,79.76) 108.35,78.55 97.22,78.55
  BOTTOM w0.127: U1.H16 v4(91.36,79.13)
STRAP_TESTMODE: length 30.4
  TOP w0.089: 96.77,76.54 91.77,76.54 v4(91.36,76.13)
  TOP w0.127: 96.77,76.54 114.34,76.54 v1(115.65,77.85) R292.1 116.52,77.62 116.79,77.34 119.31,77.34 R291.2
  BOTTOM w0.127: U1.H13 v4(91.36,76.13)
STRAP_VS0_UPSTRM_PORTSEL_0: length 38.6
  TOP w0.127: R31.2 R343.1 57.74,52.58 v1(57.35,52.96)
  IN2 w0.112: v1(57.35,52.96) 57.35,56.01 58.27,56.92 58.27,70.89 63.96,76.58 72.85,76.58 73.3,76.13 v4(73.36,76.13)
  BOTTOM w0.127: U1.AE13 v4(73.36,76.13)
STRAP_VS0_UPSTRM_PORTSEL_1: length 21
  TOP w0.089: v4(91.36,73.13) 91.96,72.54 97.04,72.54 97.06,72.55
  TOP w0.127: R32.2 109.83,71.67 107.39,71.67 107.25,71.81 R344.1 v1(106.38,72.14) 105.91,71.67 101.68,71.67 100.8,72.55 97.06,72.55
  BOTTOM w0.127: U1.H10 v4(91.36,73.13)
STRAP_VS0_UPSTRM_PORTSEL_2: length 37.2
  TOP w0.127: v4(89.36,82.13) 89.86,81.64 90.6,81.64 91.26,80.98 99.2,80.98 99.5,81.28 121.74,81.28 122.25,80.77 v1(122.25,79.76) R345.1 R33.2
  BOTTOM w0.127: U1.K18 v4(89.36,82.13)
STRAP_VS_MODE_0: length 19.5
  TOP w0.127: R177.2 80.21,56.77 79.71,57.28 79.71,58.44 R178.1 v1(80.21,59.69) 80.19,59.72 79.81,59.72 76.53,62.99 76.53,67.54 77.85,68.86 77.85,70.33 77.57,70.61 77.17,70.61 76.65,71.13 v4(76.36,71.13)
  BOTTOM w0.127: U1.AB8 v4(76.36,71.13)
STRAP_VS_MODE_1: length 46
  IN2 w0.089: v4(72.36,79.13) 71.98,78.74 63.71,78.74
  IN2 w0.112: v1(55.3,54) 55.3,56.16 57.21,58.07 57.21,72.25 63.71,78.74
  BOTTOM w0.127: R179.2 R180.1 50.95,54.34 v2(51.79,53.49) 54.79,53.49 v1(55.3,54) ; U1.AF16 v4(72.36,79.13)
THER_SEN1_DN_1: length 202.4
  TOP w0.254: U10.3 158.08,85.09 158.02,85.15 157.51,85.15 157.03,85.63 157.03,86.83 157.81,87.6 188.06,87.6 203.48,72.19 275.71,72.19 v1(275.97,72.45) ; v1(316.05,94.67) 315.93,94.79 C468.2 312.81,95.28 Q5.2
  IN1 w0.254: v1(316.05,94.67) 316.05,95 316.5,95.44 317.51,95.44 318.43,94.52 318.43,76.9 316.36,74.83 305.82,74.83 298.55,67.56 288.44,67.56 286.29,69.72 279.74,69.72 277.25,72.21 276.21,72.21 v1(275.97,72.45)
THER_SEN1_DN_2: length 176
  TOP w0.254: v1(18.62,82.45) C469.2 17.41,82.29 Q6.2 ; U10.5 158.08,84.09 158.02,84.15 144.17,84.15 130.2,70.18 130.2,69.01 v1(130.38,68.83)
  IN2 w0.254: v1(130.38,68.83) 130.19,68.64 130.19,67.62 117.29,54.72 88.52,54.72 87.7,53.9 87.7,53.69 v1(87.9,53.49)
  IN3 w0.254: v1(87.9,53.49) 87.71,53.29 87.71,52.32 85.43,50.04 64.94,50.04 63.96,51.02 63.96,52.16 61.56,54.56 57.43,54.56 54.05,57.94 52.66,57.94 46.84,63.75 40.34,63.75 22.06,82.03 19.72,82.03 19.05,82.7 18.87,82.7 v1(18.62,82.45)
THER_SEN1_DP_1: length 202.9
  TOP w0.254: v1(316.05,96.7) 315.93,96.57 C468.1 314.88,96.08 Q5.3 314.02,96.19 313.07,97.14 Q5.1 ; U10.2 158.08,85.59 158.02,85.53 157.66,85.53 157.41,85.78 157.41,86.67 157.96,87.22 187.91,87.22 203.32,71.8 275.73,71.8 v1(275.97,71.56)
  IN1 w0.254: v1(316.05,96.7) 316.05,96.32 316.55,95.82 317.67,95.82 318.81,94.68 318.81,76.74 316.52,74.45 305.98,74.45 298.71,67.18 288.29,67.18 286.13,69.34 279.58,69.34 277.09,71.83 276.24,71.83 v1(275.97,71.56)
THER_SEN1_DP_2: length 176.3
  TOP w0.254: v1(129.62,68.83) 129.82,69.04 129.82,70.34 144.01,84.53 158.02,84.53 158.08,84.59 U10.4 ; v1(18.62,83.25) C469.1 17.56,83.24 Q6.3 15.93,83.24 14.98,84.19 Q6.1
  IN2 w0.254: v1(87.14,53.49) 87.31,53.67 87.31,54.06 88.36,55.1 117.13,55.1 129.81,67.78 129.81,68.64 v1(129.62,68.83)
  IN3 w0.254: v1(18.62,83.25) 18.79,83.08 19.21,83.08 19.88,82.41 22.22,82.41 40.49,64.14 47,64.14 52.82,58.32 54.21,58.32 57.58,54.94 61.72,54.94 64.34,52.32 64.34,51.18 65.1,50.42 85.27,50.42 87.32,52.47 87.32,53.3 v1(87.14,53.49)
THER_SEN2_DN: length 373.4
  IN2 w0.254: v1(88.09,49.94) 88.37,49.66 118.41,49.66 129.2,60.44 141.93,60.44 161.27,41.1 184.48,41.1 197.89,27.69 294.11,27.69 298.25,31.83 298.25,40.71 297.36,41.6 297.36,48.17 300.76,51.57 300.76,61.18 299.24,62.71 299.24,75.36 302.19,78.31 303.68,78.31 v1(303.86,78.49)
  BOTTOM w0.254: Q27.2 19.36,60.13 C260.2 19.57,63.46 19.57,63.94 20.02,64.39 28.4,64.39 32.21,68.2 59.13,68.2 62.47,64.86 62.47,61.62 62.88,61.21 62.88,54.6 63.6,53.87 63.6,51.82 65.07,50.35 71.86,50.35 72.55,49.66 87.81,49.66 v1(88.09,49.94) ; v1(303.86,78.49) 304.04,78.31 304.31,78.31 305.07,79.07 U4.3
THER_SEN2_DP: length 373.6
  IN2 w0.254: v1(88.09,48.99) 88.37,49.28 118.57,49.28 129.35,60.06 141.77,60.06 161.11,40.72 184.32,40.72 197.74,27.3 294.27,27.3 298.63,31.67 298.63,40.86 297.74,41.76 297.74,48.01 301.14,51.41 301.14,61.34 299.62,62.87 299.62,75.2 302.34,77.93 303.66,77.93 v1(303.86,77.72)
  BOTTOM w0.254: U4.2 304.96,78.41 304.47,77.93 304.07,77.93 v1(303.86,77.72) ; v1(88.09,48.99) 87.81,49.28 72.39,49.28 71.7,49.97 64.92,49.97 63.22,51.66 63.22,53.71 62.5,54.44 62.5,61.05 62.09,61.46 62.09,64.7 58.97,67.82 32.37,67.82 28.56,64.01 20.17,64.01 19.95,63.79 19.95,63.46 C260.1 20.16,62.87 20.14,62.85 Q27.3 19.74,61.56 19.74,60.85 20.64,59.96 Q27.1
TP_A19: length 23.3
  TOP w0.127: v1(269.57,22.61) 269.57,21.72 270.84,20.45 273.13,20.45 273.86,19.71 273.86,18.62 274.93,17.55 274.93,14.48 275.85,13.56 275.85,11.84 275.54,11.53 275.54,6.86 275.83,6.57 J5.A19
TP_A32: length 20.5
  TOP w0.127: J5.A32 262.83,6.11 262.04,6.9 262.04,13.25 261.01,14.27 261.01,17.48 260.04,18.45 260.04,21.96 v1(260.68,22.61)
TP_A33: length 21.7
  TOP w0.127: v1(258.78,22.61) 259.76,21.62 259.76,18.94 258.8,17.98 258.8,16.69 259.28,16.21 260.25,16.21 260.73,15.72 260.73,14.16 261.76,13.13 261.76,6.78 261.83,6.72 J5.A33
TP_A50: length 22
  TOP w0.127: v1(241.89,22.86) 241.89,18.8 242.77,17.91 242.77,16.89 243.49,16.18 244.43,16.18 244.83,15.77 244.83,14.4 243.79,13.36 243.79,12.32 244.43,11.68 244.43,6.35 244.83,5.95 J5.A50
TP_B12: length 22
  BOTTOM w0.127: J5.B12 282.83,5.92 282.59,6.16 282.59,7.68 282.27,8 282.27,9.02 282.91,9.65 282.91,10.54 282.02,11.43 282.02,13.59 282.65,14.22 282.65,15.34 282.42,15.57 282.42,16.79 282.7,17.07 282.7,18.08 281.87,18.92 281.87,21.69 282.11,21.93 282.11,22.69 v2(281.33,23.47)
TP_B82: length 15.6
  BOTTOM w0.127: v2(206.96,15.88) 208.33,15.88 212.83,11.38 J5.B82
TP_JTAG_TCK: length 0.7
  BOTTOM w0.114: U1.AB7 v4(76.36,70.13)
TP_JTAG_TDI: length 15.7
  BOTTOM w0.114: v2(108.28,64.52) 105.82,62.05 97.13,62.05 94.86,64.32 U1.D1
TP_JTAG_TDO: length 0.7
  BOTTOM w0.114: U1.AF13 v4(72.36,76.13)
TP_JTAG_TMS: length 34
  IN2 w0.112: v4(86.36,71.13) 86.36,71.07 86.82,70.61 86.82,70.1 87.2,69.72 87.58,69.72 87.83,69.47 87.83,68.83 88.04,68.63 88.67,68.63 88.85,68.45 88.85,63.63 89.1,63.37 96.6,63.37 97.75,64.53 99.14,64.53 100.28,65.67 100.28,66.41 103.21,69.34 108.54,69.34 v1(109.55,68.33)
  BOTTOM w0.114: U1.N8 v4(86.36,71.13)
TP_P0V9_FAULT: length 4.3
  TOP w0.254: v5(14.02,115.24) 14.53,114.73 14.53,112.8 14.99,112.34 15.62,112.34 15.77,112.2 PU21.7
TP_P0V9_GH1: length 0.8
  TOP w0.254: PU15.6 31.86,100.47 v1(32.07,100.69)
TP_P0V9_GH2: length 0.8
  TOP w0.254: v1(32.07,89.03) 31.86,88.82 PU13.6
TP_P0V9_GL1: length 1.1
  TOP w0.254: v1(35.86,97.76) 35.46,97.37 PU15.36
TP_P0V9_GL2: length 1.4
  TOP w0.254: v1(35.87,86.4) 35.87,86.09 35.46,85.68 PU13.36
TP_SHPC_INT_N: length 0.7
  BOTTOM w0.127: U1.AF9 v4(72.36,72.13)
TP_STRAP_SNT0_PORTCFG0: length 0.7
  BOTTOM w0.127: U1.AD8 v6(74.36,71.13)
TP_STRAP_SNT1_PORTCFG0: length 19.7
  IN2 w0.112: v4(91.36,75.13) 91.87,74.62 103.58,74.62 104.23,75.27 108.88,75.27 v1(109.55,75.95)
  BOTTOM w0.127: U1.H12 v4(91.36,75.13)
TP_STRAP_SNT2_PORTCFG0: length 23.5
  IN1 w0.097: v4(73.36,85.13) 73.86,85.63 73.86,96.39 75.39,97.92 75.39,103.5 v1(77.93,106.05)
  BOTTOM w0.127: U1.AE21 v4(73.36,85.13)
TP_STRAP_SNT3_PORTCFG0: length 31
  IN1 w0.112: v4(89.36,87.13) 89.79,87.55 95.63,87.55 95.84,87.76 95.84,88.43 96.05,88.65 96.98,88.65 100.79,92.46 106.76,92.46 108.54,94.23 112.85,94.23 114.38,95.76 v1(114.38,97.03)
  BOTTOM w0.127: U1.K23 v4(89.36,87.13)
TP_STRAP_SNT4_PORTCFG0: length 18.9
  IN1 w0.097: v1(79.83,106.05) 77.04,103.25 77.04,98.93 74.88,96.77 74.88,90.65 v4(74.36,90.13)
  BOTTOM w0.127: U1.AD26 v4(74.36,90.13)
TP_STRAP_SNT5_PORTCFG0: length 30
  IN1 w0.097: v4(90.36,92.13) 90.84,92.61 98.68,92.61
  IN1 w0.112: v1(116.61,96.57) 115.14,98.04 108.92,98.04 107.34,96.47 102.54,96.47 98.68,92.61
  BOTTOM w0.127: U1.J28 v4(90.36,92.13)
TP_VS0_FATAL_ERR_N: length 0.7
  BOTTOM w0.127: U1.U8 v4(82.36,71.13)
TP_VS0_PEX_INTA_N: length 17.4
  IN2 w0.112: v4(90.36,77.13) 90.86,76.63 105.16,76.63 v1(106.38,77.85)
  BOTTOM w0.127: U1.J14 v4(90.36,77.13)
TP_VS1_FATAL_ERR_N: length 15.8
  BOTTOM w0.127: v2(103.99,84.58) 102.21,84.58 98.76,81.13 90.36,81.13 U1.J17
TP_VS1_PEX_INTA_N: length 10.2
  BOTTOM w0.127: v2(104.55,66.75) 101.49,66.75 100.81,66.08 100.81,64.87 99.39,63.45 98.05,63.45 U1.B1
TP_VS2_FATAL_ERR_N: length 24.1
  IN1 w0.097: v1(76.02,106.05) 75.06,105.08 75.06,98.6 72.87,96.42 72.87,84.62 v4(73.36,84.13)
  BOTTOM w0.127: U1.AE20 v4(73.36,84.13)
TP_VS2_PEX_INTA_N: length 20.5
  IN1 w0.097: v4(71.36,89.13) 70.84,89.65 70.84,96.32 71.22,96.7 72.52,96.7 74.75,98.93 74.75,105.41 v1(74.12,106.05)
  BOTTOM w0.127: U1.AG25 v4(71.36,89.13)
TP_VS3_FATAL_ERR_N: length 9.6
  BOTTOM w0.127: U1.A31 99.79,94.63 101.32,96.16 105.64,96.16 v2(106.5,97.03)
TP_VS3_PEX_INTA_N: length 24.9
  IN1 w0.097: 111.46,96.01 v1(112.47,97.03)
  IN1 w0.112: 111.46,96.01 105.49,96.01 103.33,93.85 101.17,93.85 96.95,89.64 93.14,89.64 92.79,89.28 92.79,88.55 v4(92.36,88.13)
  BOTTOM w0.127: U1.G24 v4(92.36,88.13)
TPS7A37_OUT: length 1.4
  TOP w0.254: v1(111.82,38.71) 111.57,38.96 PC536.1
  vias: v2(108.09,37.83)
UNNAMED_72_CAP_I208_B: length 5.9
  TOP w0.254: PR800.1 20.28,103.86 PC700.2 19.41,103.63 18.87,103.63 18.71,103.8 18.71,106.26 18.77,106.32 PU21.21
UNNAMED_72_CAP_I211_A: length 3.9
  TOP w0.254: PU21.19 17.77,106.39 17.68,106.3 17.68,105.92 17.08,105.32 17.08,105.09 PC701.1 17.5,104.68 PR801.1
UNNAMED_73_INDUCTORS4P_I32_1B: length 1.9
  TOP w0.254: PL2.1B v1(40.72,96.52)
  BOTTOM w0.254: PR308.1 40.74,96.54 v1(40.72,96.52)
UNNAMED_73_INDUCTORS4P_I32_2B: length 1.8
  TOP w0.254: PL2.2B v1(43.11,96.52)
  BOTTOM w0.254: v1(43.11,96.52) 42.44,96.52 PR310.1
UNNAMED_73_INDUCTORS4P_I61_1B: length 1.9
  TOP w0.254: PL3.1B v1(40.72,84.84)
  BOTTOM w0.254: PR309.1 40.77,84.79 v1(40.72,84.84)
UNNAMED_73_INDUCTORS4P_I61_2B: length 1.8
  TOP w0.254: PL3.2B v1(43.11,84.84)
  BOTTOM w0.254: v1(43.11,84.84) 42.98,84.84 42.94,84.79 PR311.1
VR_P0V9_12VIN: length 22.1
  TOP w0.254: PR400.2 v1(20.14,116.33)
  IN2 w0.254: v1(20.14,116.33) 22.67,113.81 22.67,111.9 22.38,111.62 22.38,102.75 21.79,102.16 21.79,99.06 22.57,98.29 v1(23.96,98.29)
  vias: v1(23.96,86.6) v1(24.72,98.29) v1(24.72,86.6) v1(25.48,98.29) v1(25.48,86.6) v1(26.24,98.29) v1(26.24,86.6) v1(27.01,98.29) v1(27.01,86.6) v1(27.77,98.62) v1(27.77,86.93) v1(28.53,98.29) v1(28.53,86.6) v1(30.4,98.57) v1(30.4,86.88) v1(31.42,98.57) v1(31.42,86.88) v2(28.27,88.01) v2(29.29,98.86) v2(31.19,87.63)
VR_P0V9_BT1: length 1.7
  TOP w0.254: PU15.4 32.86,100.85 32.92,100.91 PC470.2
VR_P0V9_BT2: length 1.7
  TOP w0.254: PC469.2 32.86,89.89 PU13.4
VR_P0V9_PH1: length 1.8
  TOP w0.254: PU15.7 31.36,101.42 PR305.2
VR_P0V9_PH1_R: length 1.3
  TOP w0.508: PR305.1 PC470.1
VR_P0V9_PH2: length 1.8
  TOP w0.254: PR304.2 31.36,89.74 PU13.7
VR_P0V9_PH2_R: length 1.3
  TOP w0.508: PR304.1 PC469.1
VR_P0V9_SW1: length 3.4
  TOP w0.254: PU15.43 30.86,97.37 PU15.15
  vias: v1(36.02,96.27) v1(35.97,95.26) v2(36.65,95.82)
VR_P0V9_SW1_SNB: length 1.5
  BOTTOM w0.508: PR306.2 34.62,94.25 PC471.1
VR_P0V9_SW2: length 3.3
  TOP w0.254: PU13.15 30.86,85.68 32.07,84.47
  vias: v1(35.97,84.66) v1(35.97,83.58) v2(36.66,84.2)
VR_P0V9_SW2_SNB: length 1.5
  BOTTOM w0.381: PC472.1 34.62,82.56 PR307.2
VR_P0V9A_BT: length 4.6
  TOP w0.305: PU23.14 v1(67.3,39.49)
  BOTTOM w0.508: PC587.1 66.24,41.56 v2(66.37,41.43) 67.3,40.5 v1(67.3,39.49)
VR_P0V9A_PVIN: length 21.6
  IN1 w0.305: v4(66.66,46.33) 66.66,46.02 65.42,44.77 64.3,44.77 63.64,44.11 63.64,42.38 66.08,39.94 66.08,37.35 65.22,36.5 59.34,36.5 v1(58.75,37.08)
  BOTTOM w0.305: PR426.1 66.03,47.22 66.66,46.59 v4(66.66,46.33)
  vias: v1(57.9,37.03) v1(61.96,37.3) v1(62.6,37.3) v1(63.23,37.3) v1(63.42,40.39) v1(64.42,39.5) v1(65.05,39.47) v2(64.45,41.21)
VR_P0V9A_SW: length 1.9
  BOTTOM w0.381: PC587.2 66.17,44.35 65.99,44.32 65.24,43.57 v1(65.24,43.04)
VR_P1V8A_BT: length 3.4
  TOP w0.254: v1(81.13,40.29) 80.98,40.15 PU19.14
  BOTTOM w0.305: v1(81.13,40.29) 81.54,39.88 v2(81.92,39.88) 81.98,39.88 PC546.1
VR_P1V8A_PVIN: length 13.4
  IN1 w0.305: v1(85.52,41.44) 85.52,40.23 84.79,39.5 82.75,39.5 82.47,39.22 82.47,36.99 81.84,36.36 79.96,36.36 79.45,35.85 79.45,35.18 v1(79.47,35.16)
  BOTTOM w0.305: v1(79.47,35.16) 79.47,34.56 PR370.1 v2(77.83,34.29)
  vias: v1(82.95,40.34) v1(83.72,40.35) v1(86.21,39.29)
VR_P1V8A_SW: length 1.7
  BOTTOM w0.305: v1(84.53,37.92) 83.88,37.27 PC546.2
VR_P3V3_BT: length 3.4
  TOP w0.508: v1(298.71,111.62) 297.99,111.62 v5(297.71,111.33) 297.48,111.11 PC514.1
  BOTTOM w0.305: PU17.14 v1(298.71,111.62)
VR_P3V3_PVIN: length 23.9
  TOP w0.381: v1(300.46,102.36) PR341.1
  IN3 w0.305: v1(289.89,114.55) 295.89,114.55 297.11,113.33 297.11,110.77 295.2,108.86 295.2,107.47 297.21,105.46 297.21,104.19 298.53,102.87 299.95,102.87 v1(300.46,102.36)
  vias: v1(289.13,114.55) v1(290.65,114.02) v1(291.67,115.19) v1(293.32,113.97) v1(293.27,113) v1(293.78,113.52) v1(294.44,113.52) v1(294.83,110.72) v1(295.83,111.92) v1(296.42,111.64)
VR_P3V3_STBY_BT: length 3.5
  TOP w0.305: PC496.1 310.06,88.95 310.59,89.48 v5(310.75,89.48) 311.58,89.48 v1(311.73,89.63)
  BOTTOM w0.254: v1(311.73,89.63) 311.93,89.43 PU16.14
VR_P3V3_STBY_PVIN: length 17.7
  TOP w0.305: v1(313.21,81.94) 312.9,81.64 PR324.1
  IN4 w0.305: v1(313.21,81.94) 313.21,81.94 313.21,83.19 313.84,83.82 313.84,85.27 313.13,85.98 311.46,85.98 310.49,86.94 310.49,88.54 310.87,88.93 310.87,90.53 310.36,91.03 307.01,91.03 v1(306.35,90.37)
  vias: v1(305.46,90.34) v1(307.88,90.3) v1(309.04,90.07) v5(307.16,91.44)
VR_P3V3_STBY_SW: length 1.5
  TOP w0.305: PC496.2 309.35,86.49 v6(308.97,86.11)
VR_P3V3_SW: length 2.9
  TOP w0.508: v1(296.62,108.09) 296.62,107.46 296.99,107.09 v5(297.23,107.09) 297.48,107.34 PC514.2

## Copper pours and planes (outline as drawn)
GND on TOP (solid shape): 15.11,91.21 15.11,89.99 14.99,89.87 12.98,89.87 12.83,90.02 12.83,91.01 13.18,91.36 14.96,91.36
GND on TOP (solid shape): 18.75,92.18 18.75,91.06 17.88,90.2 16.13,90.2 15.42,90.91 15.42,92.02 15.8,92.41 18.52,92.41
GND on TOP (solid shape): 34.42,99.36 34.42,97.73 34.39,97.7 32.23,97.7 32.21,97.73 32.21,99.36 32.23,99.38 34.39,99.38
GND on TOP (solid shape): 34.44,87.7 34.44,86.07 34.39,86.02 32.36,86.02 32.27,86.11 32.27,87.68 32.34,87.75 34.39,87.75
GND on TOP (solid shape): 40.44,91.76 40.44,89.29 40.24,89.09 37.34,89.09 37.24,89.19 37.24,91.91 37.32,91.99 40.21,91.99
GND on TOP (solid shape): 44.67,52.07 44.67,51.45 44.55,51.33 40.67,51.33 40.51,51.49 40.51,52.34 41,52.83 43.91,52.83
GND on TOP (solid shape): 54.13,50.85 54.13,48.31 53.93,48.11 52.45,48.11 52.02,48.54 52.02,50.83 52.2,51 53.98,51
GND on TOP (solid shape): 60.28,94.61 60.28,93.34 60.02,93.09 54.43,93.09 54.05,93.47 54.05,94.74 54.18,94.87 60.02,94.87
GND on TOP (solid shape): 64.65,36.01 64.65,35.15 64.43,34.92 62.39,34.92 62.27,35.04 62.27,36.16 62.34,36.24 64.43,36.24
GND on TOP (solid shape): 95.45,41.53 95.45,40.01 95.2,39.75 93.04,39.75 92.91,39.88 92.91,41.53 93.42,42.04 94.95,42.04
GND on TOP (solid shape): 96.78,35.03 96.78,33.93 96.57,33.73 92.84,33.73 92.61,33.96 92.61,34.77 92.99,35.15 96.65,35.15
GND on TOP (solid shape): 102.69,41.27 102.69,39.88 102.19,39.37 97.99,39.37 97.74,39.62 97.74,40.89 98.38,41.53 102.44,41.53
GND on TOP (solid shape): 293.35,64.01 293.35,62.59 293.14,62.38 291.39,62.38 291.16,62.61 291.16,63.88 291.42,64.14 293.22,64.14
GND on TOP (solid shape): 293.45,84.45 293.45,82.68 293.32,82.55 291.8,82.55 291.42,82.93 291.42,84.33 291.67,84.58 293.32,84.58
GND on TOP (solid shape): 293.57,43.69 293.57,42.16 293.45,42.04 291.16,42.04 290.91,42.29 290.91,43.56 291.16,43.81 293.45,43.81
GND on TOP (solid shape): 81.17,42.33 81.17,40.93 81.01,40.93 80.85,40.77 79.33,40.77 79.27,40.83 79.27,42.33 79.39,42.45 81.05,42.45
GND on TOP (solid shape): 15.32,103.12 15.32,101.98 15.19,101.85 13.03,101.85 12.78,102.11 12.78,103 13.03,103.25 14.43,103.25 14.43,103.25 15.19,103.25
GND on TOP (solid shape): 18.95,111.2 18.95,107.92 18.92,107.9 15.62,107.9 15.6,107.92 15.6,111.2 15.65,111.25 18.9,111.25
GND on TOP (solid shape): 68.13,39.11 69.1,39.11 69.71,38.5 69.71,35.04 69.63,34.97 67.93,34.97 67.7,35.2 67.7,38.89 67.93,39.11 68.13,39.11
GND on TOP (solid shape): 102.31,35.05 102.31,34.04 102.06,33.78 97.99,33.78 97.74,34.04 97.74,34.92 97.99,35.18 102.19,35.18
GND on TOP (solid shape): 296.78,91.44 296.78,90.25 296.67,90.14 295.3,90.14 295.05,90.4 292.41,90.4 292.25,90.55 292.25,91.49 292.3,91.54 296.67,91.54
GND on TOP (solid shape): 301.12,113.9 301.12,112.09 300.97,111.94 299.32,111.94 299.16,112.1 299.16,114.1 299.26,114.2 300.81,114.2
GND on TOP (solid shape): 313.64,92.36 313.64,90.19 313.52,90.08 311.82,90.08 311.66,90.24 311.66,92.35 311.81,92.51 313.49,92.51
GND on TOP (solid shape): 15.19,97.54 15.19,96.39 15.06,96.27 13.03,96.27 12.78,96.52 12.78,97.43 12.99,97.64 13.01,97.66 13.04,97.66 15.06,97.66
GND on TOP (solid shape): 84.28,36.3 84.28,35.43 83.89,35.05 82.08,35.05 81.89,35.24 81.89,35.64 81.89,36.53 81.91,36.56 84.02,36.56
GND on TOP (solid shape): 288.88,70.99 288.88,70.1 288.75,69.98 287.86,69.98 287.22,69.34 284.05,69.34 283.8,69.6 283.8,70.87 284.05,71.12 288.75,71.12
GND on TOP (solid shape): 290.65,104.52 290.65,102.97 290.58,102.9 288.7,102.9 288.49,103.1 288.49,103.63 288.49,103.63 288.49,104.53 288.61,104.65 290.53,104.65
GND on TOP (solid shape): 40.44,103.16 40.44,100.03 40.29,99.87 39.11,99.87 38.2,100.77 37.34,100.77 37.24,100.88 37.24,103.59 37.32,103.67 39.93,103.67
GND on TOP (solid shape): 288.62,30.48 288.75,30.35 288.75,29.46 288.62,29.34 287.61,29.34 286.34,28.07 283.8,28.07 283.54,28.32 283.54,30.23 283.8,30.48 284.48,30.48
GND on TOP (solid shape): 288.95,91.47 288.95,90.42 288.83,90.3 287.73,90.3 287.25,89.81 285.7,89.81 285.42,90.09 284.23,90.09 284.22,90.11 284.22,91.48 284.3,91.57 288.85,91.57
GND on TOP (solid shape): 25.81,100.8 25.81,100.39 25.66,100.24 22.86,100.24 22.73,100.38 22.73,100.88 22.81,100.97 23.32,100.97 23.45,101.09 23.45,101.85 23.61,102.02 24.59,102.02
GND on TOP (solid shape): 288.88,50.67 288.88,49.91 288.62,49.66 287.35,49.66 286.46,48.77 284.62,48.77 284.58,48.81 284.01,48.81 283.8,49.02 283.8,50.55 283.92,50.67 286.97,50.67 287.1,50.8 288.75,50.8
GND on TOP (solid shape): 296.75,71.12 296.88,70.99 296.88,69.72 296.75,69.6 295.35,69.6 295.09,69.86 295.09,69.98 294.13,69.98 294.13,69.98 292.3,69.98 292.18,70.1 292.18,70.99 292.3,71.12 293.22,71.12
GND on TOP (solid shape): 25.81,89.12 25.81,88.71 25.66,88.56 22.79,88.56 22.69,88.66 22.69,89.16 22.81,89.28 23.19,89.28 23.32,89.41 23.32,90.04 23.61,90.34 24.59,90.34
GND on TOP (solid shape): 64.81,46.78 65.37,46.78 66.38,45.76 66.38,44.52 66.36,44.49 63.46,44.49 62.51,45.45 61.98,45.45 61.3,46.12 61.3,46.96 61.31,46.97 61.31,47.52 61.55,47.75 63.83,47.75
GND on TOP (solid shape): 297,30.48 297.13,30.35 297.13,29.31 296.83,29.01 295.43,29.01 295.1,29.34 295.02,29.34 294.13,29.34 294.13,29.34 292.3,29.34 292.05,29.59 292.05,30.35 292.18,30.48 293.09,30.48
GND on TOP (solid shape): 296.62,50.8 296.75,50.67 296.75,49.51 296.52,49.28 295.3,49.28 295.2,49.38 295.2,49.56 295.1,49.66 295.02,49.66 294.13,49.66 294.13,49.66 292.3,49.66 292.18,49.78 292.18,50.67 292.3,50.8 293.22,50.8
GND on TOP (solid shape): 59.02,35.86 59.02,34.35 58.98,34.3 57.26,34.3 57.26,34.31 55.23,34.31 55.13,34.41 55.13,35.19 55.15,35.22 55.41,35.22 55.56,35.22 55.66,35.32 55.68,35.32 55.82,35.46 57.51,35.46 57.72,35.67 57.72,35.88 57.77,35.93 58.96,35.93
GND on TOP (solid shape): 278.31,111.35 278.31,103.18 278.29,103.13 278.23,103.11 276.92,103.11 276.77,103.26 276.77,105.26 276.91,105.4 276.91,105.41 276.99,105.49 276.99,107.47 276.77,107.68 276.77,111.13 277.02,111.38 277.81,111.38 277.82,111.39 278.27,111.39
GND on TOP (solid shape): 27.03,85.69 28.33,85.69 28.68,85.33 29.13,85.33 29.21,85.31 29.28,85.3 29.46,85.3 29.54,85.22 29.54,83.01 29.69,82.85 33.43,82.85 33.48,82.8 33.48,82.08 33.51,82.05 33.51,81.52 32.99,81 26.33,81 23.43,83.91 23.43,85.56 23.78,85.92 26.8,85.92
GND on TOP (solid shape): 60.14,90.74 60.14,89.92 60.01,89.79 57.43,89.79 57.24,89.6 55.7,89.6 51.51,86.49 47.17,80.41 45.92,79.5 45.29,79.12 44.53,78.83 43.26,78.61 33.99,78.61 33.73,78.87 33.73,79.88 34.24,80.39 38.69,80.39 39.45,81.15 46.18,81.15 50.35,86.75 52.55,88.36 54.23,89.92 54.23,90.75 54.38,90.91 59.97,90.91
GND on TOP (solid shape): 304.75,19.81 304.75,17.02 304.75,17.01 304.72,16.41 304.75,15.8 304.75,15.8 304.75,15.37 304.24,14.86 301.58,14.86 301.32,15.11 301.32,15.62 301.45,15.75 302.06,15.75 302.08,15.75 302.34,16 302.34,19.69 302.59,19.94 304.62,19.94
GND on TOP (solid shape): 287.17,24.94 287.19,24.91 287.19,24.87 287.18,24.72 287.22,24.57 287.22,24.56 287.22,23.75 286.97,23.5 284.43,23.5 284.3,23.37 284.3,22.61 284.18,22.48 283.67,22.48 283.54,22.61 283.54,23.88 283.8,24.13 283.8,24.77 284.05,25.02 287.1,25.02
GND on TOP (solid shape): 298.48,89.53 298.48,84.96 299.01,84.43 300.74,84.43 304.04,87.73 306.86,87.73 307.01,87.88 308.31,87.88 308.34,87.85 308.34,86.75 308.23,86.64 308.23,85.6 308.41,85.42 309.27,85.42 309.37,85.52 310.69,85.52 310.95,85.26 310.95,84.5 310.53,84.08 308.53,84.08 307.89,83.44 298.78,83.44 297.1,85.11 297.1,89.33 297.46,89.68 298.32,89.68
