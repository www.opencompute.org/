# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT4_RX_DN<2>: length 209.2
  IN3 w0.089: v4(84.36,95.13) 84.36,94.81 84.28,94.73 84.15,94.73 83.96,94.92 83.96,98.8 84,98.85 84,98.87
  IN3 w0.135: J4.A26 269.2,74.65 269.14,74.83 268.93,74.93 268.68,75.18 268.68,79.05 arc(268.83,79.39) 269.17,79.54 269.61,79.54 arc(269.7,79.57) 269.74,79.67 269.74,81.21 269.33,81.68 268.8,82.05 268.59,82.01 268.26,82.24 268.22,82.45 267.42,83.02 267.02,83.09 266.85,82.96 266.45,83.03 266.32,83.21 265.93,83.28 265.75,83.16 265.35,83.23 265.23,83.4 261.57,84.05 260.21,85 259.82,85.55 259.56,87.04 259.27,87.45 258.75,87.82 250.03,89.35 245.38,88.53 231.06,91.06 225.71,90.12 223.55,90.5 221.43,90.87 218.45,90.34 216.5,90.69 214.28,90.3 212.27,90.65 208.17,89.93 205.13,90.47 202.2,89.95 199.18,90.48 196.16,89.95 189.3,91.16 174.15,88.49 128.25,96.58 120.18,102.24 111.82,103.71 107.73,102.99 105.12,103.45 100.27,102.6 94.51,103.61 88.66,102.58 88.38,102.38 88.34,102.17 88.01,101.93 87.79,101.97 87.46,101.74 87.43,101.53 87.09,101.3 86.88,101.33 86.55,101.1 86.51,100.89 86.18,100.66 85.97,100.69 85.64,100.46 85.6,100.25 85.27,100.02 85.06,100.06 84.2,99.45 84.19,99.44 84.05,99.24 84,99 84,98.87
  BOTTOM w0.135: U1.R31 v4(84.36,95.13)
PE_SLOT4_RX_DN<3>: length 207.1
  IN3 w0.089: v4(85.36,95.13) 85.36,94.81 85.28,94.73 85.15,94.73 84.96,94.92 84.96,98.5 85.01,98.55 85.01,98.57
  IN3 w0.135: 85.01,98.57 85.01,98.7 85.03,98.85 85.2,99.09 85.57,99.35 85.57,99.35 85.71,99.44 85.77,99.49 86.11,99.72 86.32,99.68 86.65,99.91 86.69,100.13 87.02,100.36 87.23,100.32 87.56,100.55 87.6,100.77 87.93,101 88.14,100.96 88.48,101.19 88.51,101.4 89.34,101.98 94.67,102.92 100.27,101.93 105.12,102.79 107.73,102.33 111.77,103.04 119.95,101.6 128.03,95.94 174.2,87.81 189.35,90.48 196.12,89.28 199.08,89.8 202.16,89.26 205.18,89.8 208.27,89.25 210.37,89.62 212.37,89.97 214.28,89.64 216.07,89.95 218.07,89.6 218.12,89.61 221.44,90.19 225.72,89.44 231.12,90.39 243.46,88.21 243.57,88.06 243.42,87.23 243.67,86.88 244.27,86.77 244.62,87.02 244.77,87.84 244.92,87.95 245.57,87.84 246.32,87.97 246.48,87.86 246.73,86.4 247.08,86.15 247.69,86.26 247.93,86.61 247.68,88.07 247.79,88.23 250,88.62 254.84,87.77 255.3,87.44 255.8,86.73 256.03,85.43 256.64,84.56 256.97,84.33 257,84.14 257.33,83.91 257.53,83.94 258.37,83.35 258.88,83.27 259,83.09 259.4,83.02 259.57,83.14 259.97,83.07 260.1,82.89 260.49,82.82 260.67,82.95 261.07,82.88 261.19,82.7 261.59,82.63 261.77,82.76 262.17,82.69 263.1,82.03 263.73,81.13 263.73,79.68 arc(263.86,79.37) 264.16,79.25 264.47,79.25 arc(264.63,79.18) 264.7,79.02 264.7,75.17 264.93,74.93 265.14,74.83 265.2,74.65 J4.A30
  BOTTOM w0.135: U1.P31 v4(85.36,95.13)
PE_SLOT4_RX_DN<4>: length 194.2
  IN3 w0.089: 87.01,98.68 87.01,98.65 86.96,98.61 86.96,94.91 87.15,94.73 87.28,94.73 87.36,94.81 v4(87.36,95.13)
  IN3 w0.135: J4.A36 259.2,74.65 259.14,74.83 258.93,74.93 258.68,75.19 258.68,79.07 arc(258.82,79.42) 259.16,79.56 259.57,79.56 arc(259.67,79.6) 259.71,79.7 259.71,81.32 259.25,81.97 258.44,82.54 258.04,82.61 257.88,82.5 257.48,82.57 257.37,82.73 256.97,82.8 256.82,82.69 256.42,82.76 256.31,82.91 255.91,82.98 255.75,82.87 255.35,82.94 255.24,83.1 254.84,83.17 254.68,83.06 254.29,83.13 254.18,83.29 245.02,84.9 240.77,87.88 230.74,89.64 225.71,88.76 223.52,89.14 221.42,89.51 218.4,88.98 218.12,88.93 216.11,89.28 214.27,88.96 212.37,89.3 208.17,88.56 205.08,89.1 202.15,88.58 199.1,89.12 196.01,88.58 189.38,89.75 174.4,87.1 127.71,95.34 119.69,100.95 111.78,102.35 107.73,101.63 105.15,102.09 100.09,101.2 94.59,102.17 93.22,101.93 93.09,101.75 92.7,101.68 92.52,101.8 92.12,101.73 92,101.55 91.6,101.48 91.42,101.61 91.02,101.54 90.9,101.36 90.5,101.29 90.33,101.42 89.93,101.34 87.42,99.59 87.35,99.54 87.06,99.14 87.01,98.84 87.01,98.68
  BOTTOM w0.135: v4(87.36,95.13) U1.M31
PE_SLOT4_RX_DN<5>: length 193.5
  IN3 w0.089: v4(88.36,95.13) 88.36,94.81 88.28,94.73 88.15,94.73 87.96,94.92 87.96,98.5 88.01,98.55 88.01,98.57
  IN3 w0.135: 88.01,98.57 88.01,98.76 88.06,99.05 88.29,99.38 88.37,99.44 89.8,100.44 90.2,100.51 90.38,100.39 90.77,100.46 90.9,100.63 91.3,100.7 91.47,100.58 91.87,100.65 92,100.83 92.39,100.9 92.57,100.77 92.97,100.84 93.09,101.02 93.49,101.09 93.67,100.97 94.07,101.04 94.19,101.22 94.67,101.3 99.74,100.41 105.22,101.37 107.72,100.93 111.81,101.65 119.47,100.3 127.43,94.73 174.54,86.42 189.34,89.03 195.96,87.86 199.24,88.44 202.2,87.91 205.13,88.43 208.17,87.89 212.37,88.63 214.43,88.27 216.27,88.6 218.18,88.26 218.23,88.27 221.42,88.83 225.76,88.07 228.71,88.59 230.44,88.28 230.79,88.53 230.83,88.77 230.99,88.88 231.36,88.82 231.47,88.66 231.42,88.42 231.67,88.07 232.27,87.96 232.62,88.21 232.67,88.45 232.82,88.56 233.19,88.49 233.3,88.34 233.26,88.09 233.5,87.74 234.1,87.64 234.45,87.88 234.5,88.13 234.65,88.24 235.02,88.17 235.13,88.01 235.09,87.77 235.33,87.42 235.94,87.31 236.29,87.56 236.33,87.8 236.49,87.91 236.85,87.85 236.96,87.69 236.92,87.45 237.17,87.1 237.77,86.99 238.12,87.24 238.16,87.48 238.32,87.59 238.69,87.52 238.8,87.37 238.75,87.12 239,86.77 239.6,86.67 239.95,86.91 239.99,87.16 240.15,87.27 240.52,87.2 240.63,87.04 240.63,87.04 240.59,86.8 240.65,86.7 240.83,86.45 241.46,86.34 244.78,84.02 250.61,82.99 250.72,82.83 251.11,82.76 251.27,82.87 251.67,82.8 251.78,82.64 252.18,82.57 252.34,82.68 252.74,82.61 252.85,82.45 253.25,82.38 253.4,82.5 254.55,82.29 255.19,81.84 255.7,81.11 255.7,79.69 arc(255.66,79.59) 255.57,79.55 255.15,79.55 arc(254.82,79.42) 254.69,79.09 254.69,75.18 254.93,74.93 255.14,74.83 255.2,74.65 J4.A40
  BOTTOM w0.135: U1.L31 v4(88.36,95.13)
PE_SLOT4_RX_DN<6>: length 183.1
  IN3 w0.089: 89.01,98.72 89.01,98.7 88.96,98.65 88.96,94.91 89.15,94.73 89.28,94.73 89.36,94.81 v4(89.36,95.13)
  IN3 w0.135: 89.01,98.72 89.01,98.85 89.19,99.11 89.87,99.58 90.35,99.66 90.52,99.54 90.92,99.61 91.04,99.79 91.44,99.86 91.62,99.73 92.02,99.8 92.14,99.98 92.54,100.05 92.72,99.93 93.11,100 93.24,100.17 93.64,100.24 93.81,100.12 94.21,100.19 94.34,100.37 95.16,100.51 99.79,99.69 105.32,100.67 107.77,100.24 111.91,100.97 119.23,99.68 127.19,94.1 174.61,85.75 189.4,88.35 196.1,87.17 199.28,87.73 202.15,87.23 205.18,87.76 208.27,87.22 212.37,87.94 214.33,87.59 216.26,87.94 218.23,87.59 218.4,87.62 221.43,88.15 225.76,87.39 228.62,87.89 241.04,85.7 245.24,82.76 246.49,82.54 246.62,82.36 247.01,82.29 247.19,82.42 247.59,82.35 247.71,82.17 248.11,82.1 248.29,82.23 248.69,82.16 248.81,81.98 249.21,81.91 249.38,82.03 249.78,81.96 249.91,81.78 250.3,81.71 250.48,81.84 250.9,81.76 251.58,81.29 251.73,81.07 251.73,79.7 arc(251.69,79.6) 251.6,79.56 251.14,79.56 arc(250.81,79.42) 250.67,79.1 250.67,75.19 250.93,74.93 251.14,74.83 251.2,74.65 J4.A44
  BOTTOM w0.135: U1.K31 v4(89.36,95.13)
PE_SLOT4_RX_DN<7>: length 181.3
  IN3 w0.089: v4(90.36,95.13) 90.36,94.81 90.28,94.73 90.15,94.73 89.95,94.92 89.95,98.34 90,98.39 90,98.42
  IN3 w0.135: J4.A48 247.2,74.65 247.14,74.83 246.93,74.93 246.66,75.2 246.66,79.14 arc(246.6,79.29) 246.45,79.35 246.14,79.35 arc(245.84,79.47) 245.72,79.77 245.72,80.87 245.64,81.33 245.41,81.65 242.49,83.7 239.94,84.15 239.78,84.04 239.38,84.11 239.27,84.27 238.88,84.34 238.72,84.23 238.32,84.3 238.21,84.46 237.81,84.53 237.65,84.41 237.25,84.48 237.14,84.64 236.74,84.71 236.59,84.6 236.19,84.67 236.08,84.83 235.13,85 234.85,85.4 234.95,85.97 234.84,86.12 234.47,86.19 234.31,86.08 234.21,85.51 233.86,85.26 233.26,85.37 233.01,85.72 233.11,86.29 233.01,86.45 232.64,86.51 232.48,86.4 232.38,85.83 232.03,85.59 231.43,85.69 231.18,86.04 231.28,86.61 231.17,86.77 230.8,86.83 230.65,86.73 230.55,86.16 230.2,85.91 229.59,86.02 229.35,86.37 229.45,86.94 229.34,87.09 228.97,87.16 228.82,87.05 228.72,86.48 228.37,86.23 221.43,87.46 218.31,86.91 216.25,87.27 214.33,86.93 212.42,87.27 208.17,86.52 205.08,87.06 202.21,86.56 199.33,87.06 196.05,86.48 189.53,87.63 174.83,85.04 126.93,93.49 118.97,99.06 111.98,100.29 107.81,99.55 105.48,99.97 99.96,98.99 99.35,99.1 97.41,99.44 95.63,99.75 94.57,99.57 94.45,99.39 94.05,99.32 93.87,99.44 93.47,99.37 93.35,99.2 92.95,99.13 92.78,99.25 92.38,99.18 92.25,99 91.86,98.93 91.68,99.06 91.28,98.99 91.16,98.81 90.76,98.74 90.58,98.86 90.18,98.79 90,98.61 90,98.42
  BOTTOM w0.135: U1.J31 v4(90.36,95.13)
PE_SLOT4_RX_DN<8>: length 169.2
  IN3 w0.089: v4(91.36,95.13) 91.36,94.81 91.28,94.73 91.15,94.73 90.95,94.92 90.95,96.2 91.07,96.87 91.13,96.91 91.13,96.93
  IN3 w0.135: 91.13,96.93 91.23,97.51 91.43,97.8 92.17,98.31 92.56,98.38 92.74,98.26 93.14,98.33 93.26,98.5 93.66,98.57 93.84,98.45 94.24,98.52 94.36,98.7 96.05,99 96.45,98.93 96.58,98.75 96.97,98.68 97.15,98.8 99.52,98.39 100.09,98.28 105.54,99.24 107.8,98.85 112.09,99.6 118.72,98.44 126.68,92.87 174.94,84.36 189.6,86.94 196.04,85.81 199.28,86.38 202.11,85.88 205.09,86.4 208.17,85.86 212.33,86.59 214.24,86.26 215.23,86.43 216.21,86.6 216.23,86.6 218.28,86.24 220.74,86.67 229.97,85.05 230.08,84.89 230.48,84.82 230.64,84.93 231.04,84.86 231.15,84.7 231.55,84.63 231.71,84.74 232.1,84.67 232.21,84.51 232.61,84.44 232.77,84.55 233.17,84.48 233.28,84.33 233.68,84.26 233.84,84.37 234.23,84.3 234.35,84.14 234.74,84.07 234.9,84.18 235.3,84.11 235.41,83.95 235.81,83.88 235.97,83.99 236.37,83.92 236.48,83.76 236.87,83.69 237.03,83.8 237.43,83.73 237.54,83.57 237.94,83.5 238.1,83.61 238.75,83.5 239.08,83.27 239.12,83.08 239.45,82.85 239.64,82.88 239.97,82.65 240,82.46 240.33,82.22 240.52,82.26 241.38,81.66 241.68,80.93 241.68,79.71 arc(241.81,79.4) 242.11,79.27 242.48,79.27 arc(242.62,79.22) 242.67,79.08 242.67,75.31 242.51,75.15 242.39,75.08 242.2,75.14 J4.A53
  BOTTOM w0.135: U1.H31 v4(91.36,95.13)
PE_SLOT4_RX_DN<9>: length 169.3
  IN3 w0.089: 99.52,97.49 99.5,97.49 99.45,97.54 92.53,97.54 91.96,96.96 91.96,94.91 92.15,94.73 92.28,94.73 92.36,94.81 v4(92.36,95.13)
  IN3 w0.135: 99.52,97.49 100.42,97.49 100.8,97.55 100.98,97.43 101.38,97.5 101.5,97.68 101.9,97.75 102.08,97.62 102.47,97.69 102.6,97.87 103,97.94 103.17,97.82 103.57,97.89 103.7,98.07 104.09,98.14 104.27,98.01 104.67,98.08 104.79,98.26 105.64,98.41 106.04,98.34 106.15,98.18 106.55,98.11 106.71,98.22 107.46,98.09 108.89,98.34 109.05,98.23 109.44,98.3 109.55,98.46 109.95,98.53 110.11,98.42 110.51,98.49 110.62,98.64 112.07,98.9 118.5,97.77 126.36,92.26 175.06,83.68 175.52,83.76 175.52,83.76 175.93,83.83 175.93,83.83 176.35,83.91 189.63,86.26 196.04,85.13 199.27,85.7 202.15,85.19 205.18,85.72 208.27,85.18 210.28,85.53 212.3,85.89 214.31,85.54 216.42,85.91 220.92,85.11 221.27,85.36 221.35,85.77 221.5,85.88 221.87,85.82 221.98,85.66 221.91,85.25 222.15,84.9 222.76,84.79 223.11,85.04 223.18,85.45 223.33,85.56 223.7,85.49 223.81,85.34 223.74,84.92 223.99,84.57 224.59,84.47 224.94,84.71 225.01,85.13 225.17,85.23 225.54,85.17 225.65,85.01 225.57,84.6 225.82,84.25 226.42,84.14 226.77,84.39 226.84,84.8 227,84.91 227.37,84.85 227.48,84.69 227.4,84.28 227.65,83.93 228.25,83.82 228.6,84.07 228.68,84.48 228.83,84.59 229.2,84.52 229.31,84.37 229.24,83.95 229.48,83.6 230.58,83.41 231.19,83.52 231.84,83.4 231.96,83.23 232.36,83.16 232.54,83.28 232.94,83.21 233.06,83.03 233.46,82.96 233.64,83.09 234.03,83.02 234.16,82.84 234.55,82.77 234.73,82.89 235.13,82.82 235.25,82.65 235.65,82.58 235.83,82.7 236.28,82.62 237.03,82.09 237.61,81.27 237.67,80.91 237.67,79.68 arc(237.8,79.37) 238.1,79.25 238.51,79.25 arc(238.64,79.2) 238.69,79.08 238.69,75.32 238.51,75.15 238.39,75.08 238.2,75.14 J4.A57
  BOTTOM w0.135: U1.G31 v4(92.36,95.13)
PE_SLOT4_RX_DN<10>: length 157.4
  IN3 w0.089: v4(93.36,95.13) 93.36,94.81 93.28,94.73 93.15,94.73 92.97,94.91 92.97,96.34 93.17,96.55 99.01,96.55 99.06,96.5 99.08,96.5
  IN3 w0.135: 99.08,96.5 99.55,96.5 99.92,96.56 100.09,96.44 100.49,96.51 100.62,96.69 101.01,96.76 101.19,96.63 101.59,96.7 101.71,96.88 102.11,96.95 102.27,96.84 102.67,96.91 102.78,97.07 103.18,97.14 103.34,97.03 103.73,97.1 103.84,97.26 104.24,97.33 104.4,97.22 104.8,97.29 104.91,97.44 105.74,97.59 107.46,97.29 111.37,97.98 111.53,97.87 111.92,97.94 112.04,98.09 112.43,98.16 112.83,98.09 112.94,97.94 113.34,97.87 113.5,97.98 113.9,97.91 114.01,97.75 114.41,97.68 114.56,97.79 114.96,97.72 115.07,97.56 115.47,97.49 115.63,97.6 118.26,97.14 126.1,91.65 175.06,83.02 189.62,85.58 196.04,84.45 199.27,85.02 202.1,84.52 205.08,85.04 208.17,84.5 212.12,85.2 212.44,85.2 214.34,84.86 216.33,85.21 229.37,82.91 229.48,82.75 229.88,82.68 230.04,82.8 230.44,82.73 230.55,82.57 230.95,82.5 231.11,82.61 231.5,82.54 231.61,82.38 232.01,82.31 232.17,82.42 232.57,82.35 233.33,81.86 233.61,81.47 233.66,81.19 233.66,79.67 arc(233.78,79.37) 234.08,79.25 234.5,79.25 arc(234.62,79.2) 234.67,79.08 234.67,75.31 234.51,75.15 234.38,75.08 234.2,75.14 J4.A61
  BOTTOM w0.135: U1.F31 v4(93.36,95.13)
PE_SLOT4_RX_DN<11>: length 155.6
  IN3 w0.089: v4(94.36,95.13) 94.36,94.81 94.28,94.73 94.15,94.73 93.97,94.9 93.97,95.34 94.16,95.53 98.84,95.53 98.88,95.48 98.91,95.48
  IN3 w0.135: J4.A65 230.2,75.14 230.38,75.08 230.51,75.15 230.68,75.32 230.68,79.11 arc(230.65,79.21) 230.55,79.25 230.09,79.25 arc(229.79,79.37) 229.67,79.67 229.67,80.76 229.59,81.24 229.36,81.56 228.08,82.46 228.07,82.46 227.8,82.5 227.62,82.38 227.22,82.45 227.1,82.63 226.7,82.7 226.52,82.57 226.13,82.64 226,82.82 225.6,82.89 225.43,82.77 225.03,82.84 224.9,83.02 216.32,84.53 214.39,84.19 212.51,84.53 208.34,83.79 205.14,84.36 205.14,84.36 202.16,83.83 199.28,84.34 196.05,83.77 193.41,84.23 193.26,84.12 193.17,83.6 192.82,83.36 192.21,83.46 191.97,83.81 192.06,84.33 191.95,84.49 191.58,84.56 191.43,84.45 191.26,83.52 190.89,83.26 190.31,83.36 190.06,83.72 190.23,84.66 190.12,84.81 189.61,84.9 189.25,84.84 189.14,84.69 189.22,84.24 188.98,83.89 188.37,83.78 188.02,84.02 187.95,84.47 187.79,84.58 175.1,82.34 125.82,91.04 120.74,94.6 116.89,95.27 116.73,95.16 116.34,95.23 116.23,95.39 115.83,95.46 115.67,95.35 115.27,95.42 115.16,95.58 113.94,95.8 113.78,95.69 113.38,95.76 113.27,95.91 112.87,95.98 112.71,95.87 112.32,95.94 112.21,96.1 111.81,96.17 110.15,95.88 109.24,96.04 109.08,95.93 108.69,96 108.58,96.16 108.18,96.23 108.02,96.12 107.62,96.19 107.51,96.35 106.76,96.48 106.36,96.41 106.25,96.25 105.85,96.18 105.69,96.29 105.3,96.22 105.18,96.06 104.79,95.99 104.63,96.1 103.24,95.86 103.02,95.9 102.8,95.94 102.25,95.84 102.13,95.68 101.74,95.61 101.58,95.72 100.22,95.48 98.91,95.48
  BOTTOM w0.135: U1.E31 v4(94.36,95.13)
PE_SLOT4_RX_DN<12>: length 144.7
  IN3 w0.089: v4(95.36,92.13) 95.05,92.13 94.96,92.22 94.96,92.35 95.14,92.53 98.96,92.53 99.01,92.48 99.03,92.48
  IN3 w0.135: J4.A69 226.2,75.14 226.38,75.08 226.51,75.15 226.67,75.31 226.67,79.11 arc(226.62,79.23) 226.51,79.27 226.05,79.27 arc(225.75,79.4) 225.63,79.7 225.63,80.82 225.51,81.45 225.24,81.83 224.43,82.4 223.71,82.53 223.53,82.4 223.14,82.47 223.01,82.65 222.61,82.72 222.44,82.6 222.04,82.67 221.91,82.84 216.26,83.84 214.18,83.48 212.3,83.81 208.34,83.11 208.34,83.11 205.14,83.68 202.16,83.15 199.23,83.67 191.81,82.36 185.38,83.5 175.07,81.68 124.69,90.58 121.59,92.75 121.05,92.84 120.89,92.73 120.49,92.8 120.38,92.96 119.99,93.03 119.83,92.92 119.43,92.99 119.32,93.15 118.92,93.22 118.76,93.11 118.36,93.18 118.25,93.34 117.85,93.41 117.7,93.3 117.3,93.37 117.19,93.53 113.32,94.21 110.98,93.8 110.98,93.79 110.89,93.79 108.19,94.27 106.35,93.94 105.6,94.08 105.43,93.95 105.03,94.02 104.9,94.2 104.51,94.27 103.38,94.07 103.25,93.89 102.85,93.82 102.68,93.95 102.28,93.88 101.35,93.23 101.31,93.01 100.98,92.78 100.77,92.82 100.39,92.55 99.98,92.48 99.03,92.48
  BOTTOM w0.135: U1.D28 v4(95.36,92.13)
PE_SLOT4_RX_DN<13>: length 144.5
  IN3 w0.089: v4(95.36,91.13) 95.05,91.13 94.96,91.22 94.96,91.35 95.15,91.54 99.29,91.54 99.34,91.49 99.36,91.49
  IN3 w0.135: J4.A73 222.2,75.14 222.38,75.08 222.51,75.15 222.66,75.29 222.66,79.11 arc(222.61,79.23) 222.5,79.27 222.15,79.27 arc(221.83,79.41) 221.69,79.73 221.69,80.92 221.55,81.73 221.18,82.26 221.11,82.31 219.45,82.6 219.29,82.49 218.89,82.56 218.78,82.72 218.38,82.79 218.23,82.68 217.83,82.75 217.72,82.9 217.32,82.97 217.16,82.86 216.76,82.93 216.65,83.09 216.25,83.16 215.2,82.98 215.21,82.98 214.06,82.78 212.12,83.12 208.16,82.42 205.06,82.97 202.26,82.47 199.32,82.99 191.74,81.65 185.22,82.81 175.08,81.02 172.45,81.48 172.3,81.37 172.21,80.86 171.86,80.62 171.25,80.72 171.01,81.07 171.1,81.58 170.99,81.74 170.62,81.8 170.47,81.69 170.38,81.18 170.03,80.94 169.42,81.05 169.18,81.4 169.27,81.9 169.16,82.06 168.79,82.13 168.63,82.02 168.54,81.51 168.19,81.26 167.59,81.37 167.34,81.72 167.43,82.23 167.33,82.38 124.21,89.99 121.63,91.79 116.95,92.62 116.94,92.61 116.9,92.61 113.84,92.07 112.69,92.27 112.53,92.16 112.13,92.23 112.02,92.39 111.62,92.46 110.56,92.27 110.45,92.12 110.05,92.05 109.89,92.16 109.5,92.09 109.39,91.93 108.99,91.86 108.83,91.97 108.43,91.9 107.46,92.07 106.73,91.94 106.02,92.06 105.86,91.95 105.47,92.02 105.35,92.18 104.96,92.25 104.8,92.14 104.4,92.21 104.29,92.37 103.89,92.44 102.44,92.18 102.33,92.02 101.93,91.95 101.77,92.06 101.37,91.99 100.65,91.49 99.36,91.49
  BOTTOM w0.135: U1.D27 v4(95.36,91.13)
PE_SLOT4_RX_DN<14>: length 135.4
  IN3 w0.089: 99.52,90.49 99.5,90.49 99.45,90.53 95.15,90.53 94.96,90.35 94.96,90.22 95.05,90.13 v4(95.36,90.13)
  IN3 w0.135: 99.52,90.49 101.47,90.49 102.54,90.3 103.33,90.44 103.51,90.31 103.9,90.38 104.03,90.56 104.43,90.63 104.82,90.56 104.95,90.38 105.35,90.31 105.52,90.44 106.24,90.31 107.91,90.6 108.31,90.53 108.42,90.37 108.82,90.3 108.97,90.41 109.37,90.34 109.48,90.19 109.88,90.12 110.04,90.23 110.72,90.11 111.89,90.31 112.05,90.2 112.45,90.27 112.56,90.43 113.28,90.56 113.68,90.49 113.79,90.33 114.19,90.26 114.35,90.37 116.51,89.99 118.36,90.31 158.86,83.17 160.72,81.87 172.24,79.84 185.05,82.1 191.59,80.95 199.27,82.3 202.16,81.79 205.06,82.31 208.21,81.75 212,82.42 213.76,82.11 213.89,81.93 214.29,81.86 214.46,81.98 214.86,81.91 214.99,81.74 215.38,81.67 215.56,81.79 215.96,81.72 216.08,81.54 216.48,81.47 216.66,81.6 217.11,81.52 217.39,81.32 217.65,80.94 217.65,79.76 arc(217.8,79.41) 218.14,79.27 218.54,79.27 arc(218.65,79.23) 218.7,79.11 218.7,75.33 218.51,75.15 218.38,75.08 218.2,75.14 J4.A77
  BOTTOM w0.135: U1.D26 v4(95.36,90.13)
PE_SLOT4_RX_DN<15>: length 135.4
  IN3 w0.089: 99.52,89.5 99.5,89.5 99.45,89.54 95.16,89.54 94.96,89.35 94.96,89.22 95.05,89.13 v4(95.36,89.13)
  IN3 w0.135: 99.52,89.5 101.06,89.5 102.44,88.53 103.39,88.37 104.23,88.51 105.99,88.2 107.67,88.5 108.89,88.29 110.5,88.57 113.15,88.1 115.51,88.52 117.34,88.2 119.33,88.55 122.26,88.03 122.37,87.88 122.77,87.81 122.92,87.92 123.32,87.85 123.43,87.69 123.83,87.62 123.99,87.73 124.39,87.66 124.5,87.5 124.9,87.43 125.06,87.54 125.45,87.47 125.56,87.31 125.96,87.24 126.12,87.35 126.52,87.28 126.63,87.12 127.03,87.05 127.19,87.17 127.58,87.1 127.7,86.94 128.09,86.87 128.25,86.98 129.18,86.81 131.82,87.28 158.57,82.56 160.43,81.26 172.34,79.16 179.18,80.37 179.34,80.26 179.42,79.79 179.77,79.54 180.38,79.65 180.62,80 180.54,80.47 180.65,80.63 181.02,80.69 181.17,80.58 181.25,80.11 181.6,79.87 182.21,79.97 182.45,80.32 182.37,80.8 182.48,80.95 182.85,81.02 183,80.91 183.09,80.44 183.44,80.19 184.04,80.3 184.29,80.65 184.27,80.76 184.2,81.12 184.31,81.27 185.04,81.4 191.53,80.26 199.27,81.62 202.15,81.11 205.01,81.62 207.37,81.2 207.5,81 207.9,80.93 208.1,81.07 208.53,81 209.85,81.23 210.03,81.11 210.43,81.18 210.55,81.35 210.95,81.42 211.13,81.3 211.52,81.37 211.65,81.55 212.05,81.62 212.99,81.45 213.4,81.16 213.62,80.85 213.62,80.8 213.62,79.62 arc(213.75,79.32) 214.04,79.2 214.38,79.2 arc(214.61,79.1) 214.71,78.87 214.71,75.34 214.51,75.15 214.38,75.08 214.2,75.14 J4.A81
  BOTTOM w0.135: U1.D25 v4(95.36,89.13)
PE_SLOT4_RX_DP<0>: length 220.3
  IN3 w0.089: 81.37,95.58 81.37,95.55 81.42,95.51 81.42,94.94 81.83,94.54 82.28,94.54 82.36,94.45 v4(82.36,94.13)
  IN3 w0.135: J4.A16 278.45,74.65 278.51,74.83 278.51,74.83 278.68,74.91 278.95,75.18 278.95,78.69 arc(278.71,79.26) 278.14,79.5 278.09,79.5 arc(277.99,79.54) 277.95,79.64 277.95,81.01 277.43,81.76 277.11,81.98 273.7,84.37 270.75,84.89 270.5,85.07 270.37,85.26 270.19,86.26 270.19,86.26 270.08,86.91 269.67,87.49 269.11,87.88 267.24,88.21 261.25,89.27 250.59,91.15 245.38,90.23 231.17,92.73 225.69,91.77 221.48,92.51 221.43,92.52 218.39,91.99 216.5,92.32 214.33,91.94 212.36,92.28 208.21,91.55 206.69,91.82 206.7,91.82 205.08,92.11 202.46,91.65 202.46,91.64 202.1,91.58 199.18,92.1 196.26,91.58 189.13,92.84 173.95,90.16 128.87,98.1 120.78,103.77 111.9,105.34 107.73,104.6 105.03,105.08 100.18,104.22 93.84,105.34 88.17,104.34 82.75,100.55 82.71,100.52 82.4,100.08 82.4,100.08 81.95,99.44 81.49,98.78 81.37,98.14 81.37,95.58
  BOTTOM w0.135: U1.U30 v4(82.36,94.13)
PE_SLOT4_RX_DP<1>: length 218
  IN3 w0.089: v4(83.36,94.13) 83.36,94.45 83.28,94.54 83.07,94.54 82.77,94.83 82.77,98.65 82.72,98.7 82.72,98.72
  IN3 w0.135: 82.72,98.72 82.72,98.88 82.79,99.25 83.32,100.01 83.63,100.22 83.64,100.23 88.67,103.75 92.02,104.34 92.02,104.34 93.9,104.67 100.27,103.55 105.12,104.4 107.73,103.94 111.82,104.66 120.58,103.12 128.66,97.46 173.94,89.48 189.17,92.16 196.24,90.92 199.18,91.44 202.15,90.91 203.62,91.17 205.13,91.44 208.22,90.89 212.31,91.61 212.37,91.62 214.33,91.28 216.45,91.65 218.39,91.31 221.43,91.84 225.69,91.09 231.13,92.05 245.43,89.53 250.01,90.34 264.18,87.84 264.23,87.8 264.6,87.54 264.69,87.02 263.87,85.84 263.9,85.67 264.11,85.52 264.3,85.56 265.11,86.72 265.55,86.8 265.96,86.51 266.04,86.08 265.66,85.53 265.7,85.27 266.35,84.82 270.34,84.11 273.44,81.94 274,81.15 274,79.64 arc(273.88,79.37) 273.6,79.25 273.14,79.25 arc(273.01,79.2) 272.96,79.07 272.96,75.31 273.1,75.17 273.27,75.08 273.45,75.14 J4.A21
  BOTTOM w0.135: U1.T30 v4(83.36,94.13)
PE_SLOT4_RX_DP<2>: length 209.2
  IN3 w0.089: 83.72,98.87 83.72,98.85 83.77,98.8 83.77,94.84 84.07,94.54 84.28,94.54 84.36,94.45 v4(84.36,94.13)
  IN3 w0.135: 83.72,98.87 83.72,99.03 83.77,99.35 83.84,99.44 83.99,99.66 88.21,102.61 88.55,102.85 94.51,103.9 100.27,102.89 105.12,103.74 107.73,103.28 109.73,103.63 111.82,104 120.29,102.51 128.37,96.85 174.15,88.78 189.3,91.45 196.16,90.24 199.18,90.77 202.2,90.24 203.67,90.5 203.67,90.5 205.13,90.76 208.17,90.22 210.19,90.58 212.27,90.94 212.32,90.94 214.28,90.59 216.5,90.98 218.45,90.64 221.43,91.16 225.71,90.41 231.06,91.35 245.38,88.83 250.03,89.64 258.86,88.09 259.48,87.66 259.83,87.16 260.09,85.67 260.42,85.21 261.68,84.32 267.53,83.29 268.87,82.35 268.87,82.35 269.53,81.89 270.03,81.32 270.03,79.67 arc(269.91,79.37) 269.61,79.25 269.17,79.25 arc(269.03,79.19) 268.97,79.05 268.97,75.3 269.1,75.17 269.27,75.08 269.45,75.14 J4.A25
  BOTTOM w0.135: U1.R30 v4(84.36,94.13)
PE_SLOT4_RX_DP<3>: length 207.1
  IN3 w0.089: v4(85.36,94.13) 85.36,94.45 85.28,94.54 85.07,94.54 84.77,94.84 84.77,98.5 84.72,98.55 84.72,98.57
  IN3 w0.135: 84.72,98.57 84.72,98.75 84.72,98.75 84.76,98.97 84.99,99.29 85.2,99.44 85.4,99.58 85.41,99.58 85.61,99.72 85.61,99.72 89.22,102.25 89.29,102.26 94.67,103.21 100.27,102.23 105.12,103.08 107.73,102.62 111.77,103.33 120.06,101.87 128.14,96.21 174.2,88.1 189.35,90.77 196.12,89.57 199.08,90.1 202.16,89.55 205.18,90.09 206.78,89.81 208.27,89.54 212.37,90.27 214.28,89.93 216.07,90.24 218.07,89.89 221.44,90.48 225.72,89.73 231.12,90.68 243.62,88.47 243.87,88.12 243.72,87.3 243.83,87.14 244.2,87.08 244.36,87.18 244.5,88.01 244.85,88.26 245.57,88.13 246.39,88.27 246.74,88.03 247,86.56 247.15,86.46 247.52,86.52 247.63,86.68 247.37,88.14 247.62,88.49 250,88.91 254.95,88.04 255.51,87.65 256.07,86.84 256.3,85.55 256.85,84.77 258.48,83.63 262.28,82.96 263.31,82.24 264.02,81.22 264.02,79.68 arc(264.06,79.58) 264.16,79.54 264.47,79.54 arc(264.83,79.38) 264.98,79.02 264.98,75.29 265.1,75.17 265.27,75.08 265.45,75.14 J4.A29
  BOTTOM w0.135: U1.P30 v4(85.36,94.13)
PE_SLOT4_RX_DP<4>: length 194.3
  IN3 w0.089: v4(87.36,94.13) 87.36,94.45 87.28,94.54 87.07,94.54 86.77,94.83 86.77,98.61 86.73,98.65 86.73,98.68
  IN3 w0.135: J4.A35 259.45,75.14 259.27,75.08 259.1,75.17 258.96,75.31 258.96,79.07 arc(259.02,79.21) 259.16,79.27 259.57,79.27 arc(259.87,79.4) 260,79.7 260,81.41 259.46,82.17 258.55,82.81 245.13,85.18 240.89,88.15 230.74,89.94 225.71,89.05 221.43,89.8 218.12,89.22 216.11,89.58 214.27,89.25 212.37,89.59 208.17,88.85 205.08,89.39 202.15,88.88 199.1,89.41 196.01,88.87 189.38,90.04 174.4,87.4 127.82,95.61 119.8,101.22 111.78,102.64 107.73,101.93 105.15,102.38 100.09,101.49 94.59,102.46 89.81,101.62 87.26,99.83 87.25,99.82 87.14,99.75 86.93,99.44 86.79,99.25 86.73,98.87 86.73,98.68
  BOTTOM w0.135: U1.M30 v4(87.36,94.13)
PE_SLOT4_RX_DP<5>: length 193.6
  IN3 w0.089: 87.72,98.57 87.72,98.55 87.77,98.5 87.77,94.84 88.07,94.54 88.28,94.54 88.36,94.45 v4(88.36,94.13)
  IN3 w0.135: 87.72,98.57 87.72,98.79 87.79,99.16 87.98,99.44 88.09,99.59 89.69,100.71 94.14,101.5 94.67,101.59 99.74,100.7 105.22,101.66 107.72,101.22 111.81,101.94 119.59,100.57 127.54,95 174.54,86.71 189.34,89.32 195.96,88.15 199.24,88.73 202.2,88.21 205.13,88.72 208.17,88.19 212.37,88.93 214.43,88.56 216.27,88.89 218.18,88.55 221.42,89.12 225.76,88.36 228.71,88.88 230.37,88.59 230.53,88.7 230.57,88.94 230.92,89.19 231.52,89.08 231.77,88.73 231.73,88.48 231.84,88.33 232.2,88.26 232.36,88.37 232.4,88.62 232.75,88.86 233.36,88.76 233.6,88.4 233.56,88.16 233.67,88 234.04,87.94 234.19,88.05 234.24,88.29 234.59,88.54 235.19,88.43 235.43,88.08 235.39,87.84 235.5,87.68 235.87,87.62 236.02,87.73 236.07,87.97 236.42,88.22 237.02,88.11 237.27,87.76 237.22,87.51 237.33,87.36 237.7,87.29 237.86,87.4 237.9,87.65 238.25,87.89 238.85,87.79 239.1,87.43 239.06,87.19 239.17,87.03 239.53,86.97 239.69,87.08 239.73,87.32 240.08,87.57 240.69,87.46 240.93,87.11 240.89,86.87 241,86.71 241.58,86.61 244.89,84.29 254.66,82.57 255.4,82.05 255.99,81.2 255.99,79.69 arc(255.87,79.39) 255.57,79.27 255.15,79.27 arc(255.03,79.22) 254.97,79.09 254.97,75.3 255.1,75.17 255.27,75.08 255.45,75.14 J4.A39
  BOTTOM w0.135: U1.L30 v4(88.36,94.13)
PE_SLOT4_RX_DP<6>: length 183
  IN3 w0.089: v4(89.36,94.13) 89.36,94.45 89.28,94.54 89.07,94.54 88.77,94.83 88.77,98.65 88.72,98.7 88.72,98.72
  IN3 w0.135: 88.72,98.72 88.72,98.94 88.99,99.32 89.17,99.44 89.76,99.85 95.16,100.8 95.21,100.79 99.79,99.99 105.32,100.96 107.77,100.53 111.91,101.26 119.34,99.95 127.3,94.37 174.61,86.04 189.4,88.65 196.1,87.46 199.28,88.02 202.15,87.52 203.62,87.78 205.18,88.05 206.78,87.77 208.27,87.51 212.37,88.23 214.33,87.88 216.26,88.23 218.23,87.88 221.43,88.44 225.76,87.68 228.62,88.18 241.15,85.97 245.35,83.03 251.01,82.04 251.79,81.49 252.02,81.16 252.02,79.7 arc(251.9,79.4) 251.6,79.27 251.14,79.27 arc(251.01,79.22) 250.96,79.1 250.96,75.31 251.1,75.17 251.27,75.08 251.45,75.14 J4.A43
  BOTTOM w0.135: U1.K30 v4(89.36,94.13)
PE_SLOT4_RX_DP<7>: length 181.2
  IN3 w0.089: 89.71,98.42 89.71,98.39 89.76,98.34 89.76,94.85 90.07,94.54 90.28,94.54 90.36,94.45 v4(90.36,94.13)
  IN3 w0.135: J4.A47 247.45,75.14 247.27,75.08 247.1,75.17 246.95,75.32 246.95,79.14 arc(246.8,79.49) 246.45,79.64 246.14,79.64 arc(246.05,79.68) 246.01,79.77 246.01,80.9 245.91,81.44 245.62,81.86 242.6,83.97 235.29,85.26 235.15,85.46 235.25,86.03 235.01,86.38 234.4,86.49 234.05,86.25 233.95,85.68 233.8,85.57 233.43,85.63 233.32,85.79 233.42,86.36 233.17,86.71 232.57,86.81 232.22,86.57 232.12,86 231.96,85.89 231.59,85.95 231.49,86.11 231.59,86.68 231.34,87.03 230.74,87.14 230.39,86.89 230.29,86.32 230.13,86.21 229.76,86.28 229.65,86.43 229.75,87 229.51,87.35 228.9,87.46 228.55,87.22 228.45,86.65 228.3,86.54 221.43,87.75 218.31,87.2 216.32,87.55 216.32,87.56 216.27,87.57 214.33,87.22 212.42,87.56 208.17,86.81 205.08,87.35 202.21,86.85 199.33,87.35 196.05,86.78 189.53,87.92 174.83,85.33 127.04,93.76 119.09,99.33 111.98,100.58 107.81,99.85 105.48,100.26 99.96,99.28 95.63,100.05 92.2,99.44 90.05,99.06 89.71,98.73 89.71,98.42
  BOTTOM w0.135: U1.J30 v4(90.36,94.13)
PE_SLOT4_RX_DP<8>: length 169.2
  IN3 w0.089: 90.85,96.98 90.84,96.97 90.88,96.91 90.76,96.21 90.76,94.85 91.07,94.54 91.28,94.54 91.36,94.45 v4(91.36,94.13)
  IN3 w0.135: J4.A52 242.45,74.65 242.51,74.83 242.51,74.83 242.68,74.91 242.96,75.19 242.96,79.08 arc(242.82,79.42) 242.48,79.56 242.11,79.56 arc(242.01,79.6) 241.97,79.71 241.97,80.94 arc(241.96,80.99) 241.95,81.04 241.62,81.84 238.86,83.77 220.74,86.97 218.28,86.53 216.37,86.87 216.37,86.87 216.27,86.89 216.21,86.9 214.24,86.55 212.33,86.88 208.17,86.15 206.68,86.41 205.09,86.69 202.11,86.17 199.28,86.67 196.04,86.1 189.6,87.23 174.94,84.65 126.79,93.14 118.83,98.71 112.09,99.9 107.8,99.14 105.54,99.54 100.09,98.58 99.52,98.68 96.05,99.29 92.05,98.58 91.23,98 90.96,97.63 90.85,96.98
  BOTTOM w0.135: U1.H30 v4(91.36,94.13)
PE_SLOT4_RX_DP<9>: length 169.4
  IN3 w0.089: v4(92.36,94.13) 92.36,94.45 92.28,94.54 92.07,94.54 91.77,94.83 91.77,97.04 92.45,97.73 99.45,97.73 99.5,97.77 99.52,97.77
  IN3 w0.135: J4.A56 238.45,74.65 238.51,74.83 238.51,74.83 238.68,74.91 238.97,75.2 238.97,79.08 arc(238.84,79.4) 238.51,79.54 238.1,79.54 arc(238,79.58) 237.96,79.68 237.96,80.94 237.88,81.39 237.24,82.3 236.39,82.89 231.89,83.69 231.19,83.81 230.58,83.7 229.65,83.87 229.54,84.02 229.61,84.43 229.37,84.78 228.76,84.89 228.41,84.65 228.34,84.23 228.19,84.12 227.82,84.19 227.71,84.34 227.78,84.76 227.54,85.11 226.93,85.21 226.58,84.97 226.51,84.56 226.35,84.45 225.99,84.51 225.88,84.67 225.95,85.08 225.7,85.43 225.1,85.54 224.75,85.29 224.68,84.88 224.52,84.77 224.15,84.84 224.04,84.99 224.12,85.4 223.87,85.75 223.27,85.86 222.92,85.62 222.84,85.2 222.69,85.09 222.32,85.16 222.21,85.31 222.28,85.73 222.04,86.08 221.43,86.18 221.08,85.94 221.01,85.53 220.86,85.42 216.42,86.2 214.31,85.83 212.3,86.18 208.27,85.47 205.18,86.01 202.15,85.48 199.27,85.99 199.27,85.99 196.04,85.42 189.63,86.55 175.88,84.12 175.88,84.11 175.06,83.97 126.47,92.54 118.62,98.04 112.07,99.19 110.45,98.91 107.46,98.38 106.76,98.5 106.64,98.52 105.64,98.7 100.39,97.77 99.52,97.77
  BOTTOM w0.135: U1.G30 v4(92.36,94.13)
PE_SLOT4_RX_DP<10>: length 157.5
  IN3 w0.089: 99.08,96.78 99.06,96.78 99.01,96.74 93.09,96.74 92.78,96.42 92.78,94.83 93.07,94.54 93.28,94.54 93.36,94.45 v4(93.36,94.13)
  IN3 w0.135: 99.08,96.78 99.52,96.78 104.74,97.71 105.74,97.88 107.46,97.58 112.43,98.46 118.38,97.41 126.21,91.92 175.06,83.31 189.62,85.87 196.04,84.74 199.27,85.31 202.1,84.81 205.08,85.34 208.17,84.79 212.1,85.48 212.46,85.48 214.34,85.15 216.33,85.51 232.68,82.62 233.54,82.07 233.88,81.58 233.94,81.21 233.94,79.67 arc(233.98,79.57) 234.08,79.54 234.5,79.54 arc(234.83,79.4) 234.96,79.08 234.96,75.19 234.68,74.91 234.51,74.83 234.51,74.83 234.45,74.65 J4.A60
  BOTTOM w0.135: U1.F30 v4(93.36,94.13)
PE_SLOT4_RX_DP<11>: length 155.6
  IN3 w0.089: 98.91,95.77 98.88,95.77 98.84,95.72 94.08,95.72 93.78,95.42 93.78,94.82 94.07,94.54 94.28,94.54 94.36,94.45 v4(94.36,94.13)
  IN3 w0.135: J4.A64 230.45,74.65 230.51,74.83 230.51,74.83 230.68,74.91 230.97,75.2 230.97,79.11 arc(230.85,79.41) 230.55,79.54 230.09,79.54 arc(230,79.57) 229.96,79.67 229.96,80.79 229.86,81.35 229.56,81.77 228.19,82.73 216.32,84.82 214.39,84.48 212.51,84.82 208.34,84.08 205.17,84.64 205.11,84.64 202.16,84.12 199.28,84.63 196.05,84.06 193.35,84.54 193,84.29 192.9,83.77 192.75,83.66 192.38,83.72 192.27,83.88 192.36,84.4 192.12,84.75 191.51,84.86 191.16,84.61 191,83.69 190.82,83.56 190.48,83.63 190.37,83.79 190.53,84.73 190.28,85.08 189.61,85.19 189.09,85.1 188.84,84.75 188.92,84.3 188.81,84.15 188.44,84.08 188.29,84.19 188.21,84.64 187.86,84.89 175.1,82.64 125.93,91.31 120.85,94.87 111.81,96.46 110.15,96.17 106.76,96.77 103.24,96.15 102.8,96.23 100.19,95.77 98.91,95.77
  BOTTOM w0.135: U1.E30 v4(94.36,94.13)
PE_SLOT4_RX_DP<12>: length 144.7
  IN3 w0.089: v4(94.36,92.13) 94.68,92.13 94.77,92.22 94.77,92.42 95.07,92.72 98.97,92.72 99.02,92.77 99.03,92.77
  IN3 w0.135: J4.A68 226.45,74.65 226.51,74.83 226.51,74.83 226.68,74.91 226.96,75.19 226.96,79.11 arc(226.83,79.43) 226.51,79.56 226.05,79.56 arc(225.96,79.6) 225.92,79.7 225.92,80.85 225.78,81.56 225.44,82.04 224.54,82.67 216.26,84.14 214.18,83.77 212.3,84.1 208.34,83.4 206.79,83.68 205.14,83.97 202.16,83.44 199.23,83.96 191.81,82.65 185.38,83.79 175.07,81.97 124.8,90.85 121.75,92.99 121.7,93.02 113.37,94.49 113.32,94.5 110.93,94.08 110.92,94.08 108.19,94.56 106.35,94.24 104.51,94.56 102.17,94.15 100.28,92.83 99.96,92.77 99.03,92.77
  BOTTOM w0.135: U1.E28 v4(94.36,92.13)
PE_SLOT4_RX_DP<13>: length 144.6
  IN3 w0.089: 99.36,91.78 99.34,91.78 99.29,91.73 95.07,91.73 94.77,91.43 94.77,91.22 94.68,91.13 v4(94.36,91.13)
  IN3 w0.135: 99.36,91.78 100.56,91.78 101.26,92.27 103.89,92.73 106.73,92.23 107.46,92.36 108.43,92.19 111.62,92.75 113.84,92.36 116.89,92.9 116.95,92.91 117,92.9 121.75,92.06 121.8,92.03 124.32,90.26 167.49,82.65 167.74,82.29 167.65,81.79 167.76,81.63 168.13,81.57 168.28,81.67 168.37,82.18 168.72,82.43 169.32,82.32 169.57,81.97 169.48,81.46 169.59,81.31 169.96,81.24 170.11,81.35 170.2,81.86 170.55,82.11 171.16,82 171.4,81.65 171.31,81.14 171.42,80.98 171.79,80.92 171.95,81.03 172.04,81.54 172.39,81.78 175.08,81.31 185.22,83.1 191.74,81.95 199.32,83.28 202.26,82.76 205.06,83.26 208.16,82.71 212.12,83.41 214.06,83.07 216.25,83.45 221.22,82.58 221.38,82.47 221.82,81.84 221.98,80.95 221.98,79.73 arc(222.03,79.61) 222.15,79.56 222.5,79.56 arc(222.81,79.43) 222.95,79.11 222.95,75.17 222.68,74.91 222.51,74.83 222.51,74.83 222.45,74.65 J4.A72
  BOTTOM w0.135: U1.E27 v4(94.36,91.13)
PE_SLOT4_RX_DP<14>: length 135.4
  IN3 w0.089: v4(94.36,90.13) 94.68,90.13 94.77,90.22 94.77,90.42 95.07,90.72 99.45,90.72 99.5,90.77 99.52,90.77
  IN3 w0.135: 99.52,90.77 101.49,90.77 102.54,90.59 104.43,90.92 106.24,90.6 107.91,90.89 110.72,90.4 113.28,90.85 116.51,90.28 118.36,90.61 158.97,83.45 160.83,82.14 172.24,80.13 185.05,82.39 191.59,81.24 199.27,82.59 202.16,82.08 205.06,82.6 208.21,82.04 212,82.71 217.22,81.79 217.6,81.53 217.92,81.07 arc(217.94,81.03) 217.94,80.99 217.94,79.76 arc(218,79.62) 218.14,79.56 218.54,79.56 arc(218.85,79.43) 218.98,79.11 218.98,75.21 218.68,74.91 218.51,74.83 218.51,74.83 218.45,74.65 J4.A76
  BOTTOM w0.135: U1.E26 v4(94.36,90.13)
PE_SLOT4_RX_DP<15>: length 135.5
  IN3 w0.089: v4(94.36,89.13) 94.68,89.13 94.77,89.22 94.77,89.42 95.08,89.73 99.45,89.73 99.5,89.78 99.52,89.78
  IN3 w0.135: J4.A80 214.45,74.65 214.51,74.83 214.51,74.83 214.68,74.91 214.99,75.22 214.99,78.87 arc(214.81,79.3) 214.38,79.48 214.04,79.48 arc(213.95,79.52) 213.91,79.62 213.91,80.85 arc(213.89,80.94) 213.85,81.02 213.61,81.37 213.1,81.72 212.05,81.91 209.92,81.53 209.92,81.53 208.53,81.29 205.01,81.91 202.15,81.41 199.27,81.91 191.53,80.55 185.04,81.7 184.15,81.54 183.9,81.19 183.98,80.71 183.87,80.56 183.5,80.49 183.35,80.6 183.27,81.07 182.92,81.32 182.31,81.21 182.07,80.86 182.15,80.39 182.04,80.24 181.67,80.17 181.52,80.28 181.43,80.75 181.08,81 180.48,80.89 180.23,80.54 180.32,80.07 180.21,79.91 179.84,79.85 179.68,79.96 179.6,80.43 179.25,80.67 172.34,79.45 160.54,81.53 158.68,82.84 131.82,87.57 129.18,87.11 127.12,87.47 119.33,88.84 117.34,88.49 115.51,88.81 113.15,88.4 110.5,88.86 108.89,88.58 107.67,88.79 105.99,88.49 104.23,88.8 103.39,88.66 102.55,88.81 101.15,89.78 99.52,89.78
  BOTTOM w0.135: U1.E25 v4(94.36,89.13)
PE_SLOT4_TX_C_DN<0>: length 210.2
  IN1 w0.089: v4(82.36,98.13) 82.36,97.81 82.28,97.73 81.85,97.73 81.69,97.89 81.69,98.2 81.74,98.25 81.74,98.27
  IN1 w0.122: 81.74,98.27 81.74,99.09 82.2,99.74 82.41,99.78 82.62,100.08 82.58,100.29 82.79,100.59 83,100.63 83.21,100.93 83.18,101.14 83.57,101.7 83.87,101.91 84.08,101.87 84.38,102.08 84.42,102.29 84.72,102.5 84.93,102.46 85.23,102.67 85.27,102.89 85.57,103.1 85.78,103.06 86.08,103.27 86.12,103.48 89.19,105.63 97.86,107.16 133.48,100.88 139.83,102 200.72,91.26 200.77,91.23 200.84,91.24 203.53,91.71 206.02,91.27 209.31,91.85 211.85,91.4 213.7,91.73 216.12,91.3 218.66,91.75 220.84,91.37 222.83,91.76 224.9,91.39 226.17,91.62 226.99,91.76 226.99,91.76 229.02,91.4 230.79,91.71 232.82,91.36 235.1,91.76 237.5,91.33 240.68,91.9 243.02,91.48 245.65,91.95 247.19,91.68 249.28,92.05 251.12,91.72 252.95,92.04 259.31,90.92 262.49,91.48 271.25,89.94 271.37,89.76 271.74,89.69 271.91,89.82 272.27,89.75 272.4,89.58 272.76,89.51 272.93,89.64 273.29,89.57 273.42,89.4 273.78,89.33 273.96,89.46 274.32,89.39 274.44,89.22 274.8,89.15 274.98,89.28 275.34,89.21 275.46,89.04 275.82,88.97 276,89.1 277.07,88.91 277.07,88.91 278.58,87.76 278.78,87.48 278.78,86.93 v1(278.46,86.61)
  BOTTOM w0.135: v1(278.46,86.61) 278.82,86.26 278.82,85.46 C51.1 ; U1.U34 v4(82.36,98.13)
PE_SLOT4_TX_C_DN<1>: length 208.3
  IN1 w0.089: 83.29,99.27 83.28,99.26 83.21,99.24 83.05,99.02 82.96,98.5 82.96,97.85 83.09,97.73 83.28,97.73 83.36,97.81 v4(83.36,98.13)
  IN1 w0.122: 83.29,99.27 83.62,99.74 83.83,99.78 84.04,100.08 84,100.29 84.94,101.63 85.28,101.87 85.49,101.83 85.79,102.04 85.83,102.25 88.54,104.15 90.14,104.43 90.38,104.77 90.36,104.89 90.45,105.03 90.84,105.1 90.98,105 91,104.88 91.34,104.64 91.96,104.75 92.19,105.09 92.15,105.32 92.25,105.46 92.63,105.52 92.78,105.42 92.82,105.2 93.15,104.96 93.77,105.07 94.01,105.41 93.97,105.64 94.06,105.78 94.44,105.84 94.59,105.74 94.63,105.52 94.97,105.28 95.59,105.39 95.83,105.73 95.78,105.98 95.88,106.12 96.26,106.19 96.41,106.09 96.45,105.84 96.79,105.6 97.41,105.71 97.65,106.05 97.62,106.17 97.72,106.32 98.1,106.38 98.25,106.28 98.27,106.16 98.61,105.92 99.89,106.15 133.58,100.21 139.72,101.29 148.79,99.69 148.9,99.67 200.69,90.54 203.33,91.01 203.5,91.01 203.52,91.01 205.9,90.59 209.33,91.19 211.85,90.75 213.68,91.07 214.87,90.86 216.16,90.63 218.72,91.08 220.83,90.71 222.94,91.08 224.95,90.73 227.04,91.1 229.07,90.74 230.74,91.03 232.77,90.67 235.05,91.08 237.44,90.65 240.73,91.23 243.02,90.83 245.58,91.28 247.18,91 249.21,91.36 251.22,91 252.99,91.31 259.35,90.19 262.11,90.68 264.08,90.33 264.2,90.15 264.56,90.09 264.74,90.21 265.1,90.15 265.22,89.97 265.58,89.91 265.76,90.03 266.12,89.97 266.25,89.79 266.61,89.73 266.78,89.85 267.14,89.79 267.27,89.61 267.63,89.55 267.81,89.67 268.17,89.61 268.29,89.43 268.65,89.37 268.83,89.49 269.19,89.43 269.31,89.25 269.67,89.19 269.85,89.31 270.21,89.25 270.33,89.07 270.7,89.01 270.87,89.13 271.23,89.07 271.36,88.89 271.72,88.83 271.89,88.95 274.11,88.56 274.87,88.16 275.63,87.41 275.63,86.93 v1(275.31,86.61)
  BOTTOM w0.135: C52.1 275.67,85.46 275.67,86.26 v1(275.31,86.61) ; U1.T34 v4(83.36,98.13)
PE_SLOT4_TX_C_DN<2>: length 199.4
  IN1 w0.089: 84.4,99.27 84.39,99.26 84.32,99.24 84,98.79 83.95,98.5 83.95,97.81 84.04,97.73 84.28,97.73 84.36,97.81 v4(84.36,98.13)
  IN1 w0.122: 84.4,99.27 84.52,99.44 85.04,100.19 85.56,100.94 89.34,103.58 89.75,103.65 89.93,103.53 90.29,103.59 90.41,103.77 90.77,103.83 90.95,103.71 91.31,103.77 91.43,103.95 91.79,104.01 91.97,103.89 92.33,103.95 92.45,104.13 100.05,105.47 133.58,99.56 139.68,100.63 148.85,99.02 148.85,99.01 148.9,99.01 200.89,89.84 203.33,90.28 205.7,89.86 207.56,90.19 207.56,90.19 209.37,90.51 211.78,90.08 213.54,90.4 216.03,89.96 218.72,90.43 220.83,90.06 222.89,90.42 224.99,90.05 227.13,90.43 229.18,90.07 230.81,90.36 232.8,90.01 235.08,90.41 237.46,89.99 240.78,90.57 243.02,90.18 245.57,90.63 247.19,90.34 249.18,90.69 251.31,90.32 253.11,90.63 259.78,89.46 262.07,89.86 263.72,89.57 263.84,89.4 264.2,89.33 264.38,89.46 264.74,89.39 264.86,89.21 265.22,89.15 265.4,89.28 265.76,89.21 265.88,89.03 266.24,88.97 266.42,89.1 266.78,89.03 266.91,88.85 267.27,88.79 267.44,88.92 267.8,88.85 267.93,88.67 268.29,88.61 268.47,88.73 268.83,88.67 268.95,88.49 269.31,88.43 269.49,88.55 269.85,88.49 269.97,88.31 270.33,88.25 270.51,88.37 271.04,88.28 271.43,88 271.6,87.76 271.67,87.4 271.67,86.96 v1(271.32,86.61)
  BOTTOM w0.135: C53.1 271.68,85.46 271.68,86.26 v1(271.32,86.61) ; U1.R34 v4(84.36,98.13)
PE_SLOT4_TX_C_DN<3>: length 197.6
  IN1 w0.089: 85.37,99.11 85.36,99.09 85.29,99.08 85.02,98.69 84.96,98.4 84.96,97.81 85.05,97.73 85.28,97.73 85.36,97.81 v4(85.36,98.13)
  IN1 w0.122: v1(267.36,86.61) 267.72,86.97 267.72,87.43 267.53,87.69 266.84,88.17 266.07,88.31 265.93,88.21 265.8,87.44 265.46,87.2 264.84,87.31 264.6,87.65 264.74,88.42 264.64,88.56 264.26,88.63 264.12,88.53 263.98,87.76 263.64,87.52 263.02,87.63 262.78,87.97 262.92,88.74 262.82,88.88 261.79,89.06 260.06,88.76 253.11,89.98 251.22,89.65 249.13,90.02 247.17,89.67 245.5,89.96 243.02,89.53 240.86,89.91 237.54,89.32 235.22,89.73 232.91,89.32 230.78,89.7 229.02,89.39 227.03,89.74 225.05,89.39 223.08,89.74 221.02,89.37 218.72,89.78 216.03,89.3 213.6,89.73 211.69,89.4 209.25,89.83 205.54,89.17 203.21,89.58 200.92,89.18 148.88,98.36 148.88,98.36 139.68,99.98 133.35,98.86 100.28,104.69 97.85,104.26 97.72,104.09 97.36,104.02 97.19,104.15 96.83,104.08 96.7,103.91 96.34,103.84 96.16,103.97 95.8,103.9 95.68,103.73 95.32,103.66 95.14,103.79 94.78,103.72 94.66,103.55 94.3,103.48 94.12,103.61 93.76,103.54 93.64,103.37 93.27,103.3 93.1,103.43 92.74,103.37 92.61,103.19 92.25,103.12 92.08,103.25 91.72,103.19 91.59,103.01 91.23,102.94 91.05,103.07 90.69,103.01 90.57,102.83 90.21,102.76 90.03,102.89 89.52,102.8 89,102.43 88.96,102.22 88.66,102.01 88.45,102.04 88.15,101.83 88.11,101.62 87.81,101.41 87.59,101.45 86.44,100.64 85.6,99.44 85.37,99.11
  BOTTOM w0.135: v1(267.36,86.61) 267.72,86.26 267.72,85.46 C54.1 ; U1.P34 v4(85.36,98.13)
PE_SLOT4_TX_C_DN<4>: length 185.4
  IN1 w0.089: 87.17,99.23 87.08,99.11 86.97,98.48 86.97,97.82 87.06,97.73 87.28,97.73 87.36,97.81 v4(87.36,98.13) ; 87.17,99.23 87.24,99.24 87.25,99.26 ; 87.17,99.23 87.17,99.23 87.17,99.23
  IN1 w0.122: 87.25,99.26 88.17,100.58 88.57,100.85 88.78,100.82 89.08,101.03 89.12,101.24 90.26,102.04 90.79,102.14 90.97,102.01 91.33,102.07 91.45,102.25 91.81,102.32 91.99,102.19 92.35,102.25 92.47,102.43 92.83,102.5 93.01,102.37 93.37,102.44 93.5,102.61 93.86,102.68 94.03,102.55 94.39,102.62 94.52,102.79 94.88,102.86 95.05,102.73 95.42,102.8 95.54,102.97 95.9,103.04 96.08,102.91 96.44,102.98 96.56,103.15 96.92,103.22 97.1,103.09 97.46,103.16 97.58,103.33 97.94,103.4 98.12,103.27 98.48,103.34 98.61,103.51 100.74,103.89 133.15,98.17 139.69,99.32 201.15,88.48 203.26,88.85 205.64,88.43 209.47,89.11 210.51,88.92 211.61,88.73 213.6,89.08 216.03,88.65 218.66,89.11 221.13,88.68 223.24,89.05 225.14,88.72 227.11,89.06 229.12,88.71 230.87,89.02 232.94,88.65 235.23,89.05 237.55,88.65 240.8,89.22 242.96,88.84 245.57,89.3 247.19,89.01 249.08,89.35 251.15,88.98 253.04,89.32 260.4,87.94 260.52,87.76 260.88,87.7 261.06,87.82 261.42,87.75 261.51,87.62 261.51,87.62 261.6,87.49 261.66,87.41 261.66,86.96 v1(261.32,86.61)
  BOTTOM w0.135: C151.1 261.67,85.46 261.67,86.26 v1(261.32,86.61) ; U1.M34 v4(87.36,98.13)
PE_SLOT4_TX_C_DN<5>: length 183.2
  IN1 w0.089: 88.45,99.27 88.44,99.26 88.37,99.24 88,98.72 87.96,98.5 87.96,97.84 88.08,97.73 88.28,97.73 88.36,97.81 v4(88.36,98.13)
  IN1 w0.122: v1(257.33,86.61) 257.67,86.96 257.67,87.42 257.66,87.49 257.58,87.62 257.24,87.86 256.81,87.93 256.67,87.84 256.41,86.38 256.07,86.14 255.45,86.25 255.21,86.59 255.47,88.05 255.37,88.19 255.01,88.25 254.83,88.13 254.47,88.19 254.35,88.37 252.86,88.63 251.05,88.31 249.07,88.66 247.22,88.34 245.52,88.64 242.96,88.19 240.8,88.57 237.55,87.99 235.23,88.4 232.95,88 230.94,88.35 229.18,88.04 227.11,88.41 225.14,88.06 223.24,88.4 221.13,88.03 218.69,88.46 216.06,87.99 213.6,88.43 211.59,88.07 209.62,88.42 205.69,87.73 203.21,88.16 201.23,87.82 139.66,98.67 132.83,97.46 100.91,103.09 99.36,102.82 99.24,102.64 98.88,102.58 98.7,102.7 98.34,102.64 98.22,102.46 97.86,102.4 97.68,102.52 97.32,102.46 97.19,102.28 96.83,102.22 96.66,102.34 96.3,102.28 96.17,102.1 95.81,102.04 95.63,102.16 95.27,102.1 95.15,101.92 94.79,101.86 94.61,101.98 94.25,101.92 94.13,101.74 93.77,101.67 93.59,101.8 93.23,101.74 93.1,101.56 92.74,101.49 92.57,101.62 92.21,101.56 92.08,101.38 91.72,101.31 91.54,101.44 91.04,101.35 90.74,101.14 90.71,100.93 90.41,100.72 90.19,100.75 89.02,99.93 88.66,99.57 88.51,99.36 88.45,99.27
  BOTTOM w0.135: U1.L34 v4(88.36,98.13) ; v1(257.33,86.61) 257.68,86.26 257.68,85.46 C140.1
PE_SLOT4_TX_C_DN<6>: length 174.4
  IN1 w0.089: v4(89.36,98.13) 89.36,97.81 89.28,97.73 89.04,97.73 88.95,97.81 88.95,98.48 89.02,98.88 89.16,99.08 89.34,99.2 89.41,99.19 89.43,99.2
  IN1 w0.122: 89.43,99.2 91.37,100.56 91.85,100.65 92.03,100.52 92.39,100.59 92.51,100.77 92.87,100.83 93.05,100.7 93.41,100.77 93.53,100.95 93.89,101.01 94.07,100.88 94.43,100.95 94.56,101.13 94.92,101.19 95.09,101.06 95.45,101.13 95.58,101.31 95.94,101.37 96.12,101.24 96.48,101.31 96.6,101.49 96.96,101.55 97.14,101.43 97.5,101.49 97.62,101.67 97.98,101.73 98.16,101.61 98.52,101.67 98.64,101.85 99,101.91 99.18,101.79 99.54,101.85 99.67,102.03 101.45,102.34 132.83,96.81 139.66,98.01 148.9,96.39 148.9,96.38 201.27,87.15 203.08,87.47 205.69,87.01 209.7,87.71 210.61,87.56 211.61,87.38 213.67,87.74 215.99,87.33 218.65,87.8 221.09,87.37 223.24,87.75 225.14,87.41 227.11,87.76 229.36,87.36 231.11,87.67 232.95,87.35 235.16,87.74 237.48,87.33 240.79,87.91 242.94,87.53 245.52,87.98 247.23,87.68 249.06,88.01 251.51,87.58 252.17,87.69 252.35,87.57 252.71,87.63 252.83,87.81 253.19,87.87 253.4,87.84 253.53,87.74 253.62,87.62 253.68,87.27 253.68,86.98 v1(253.32,86.61)
  BOTTOM w0.135: C141.1 253.67,85.46 253.67,86.26 v1(253.32,86.61) ; U1.K34 v4(89.36,98.13)
PE_SLOT4_TX_C_DN<7>: length 172.8
  IN1 w0.089: v4(90.36,98.13) 90.36,97.81 90.28,97.73 90.03,97.73 89.94,97.81 89.94,98.6 90.22,98.99 90.46,99.16 90.53,99.15 90.55,99.16
  IN1 w0.122: 90.55,99.16 90.95,99.44 91.16,99.59 91.71,99.69 91.89,99.56 92.25,99.63 92.37,99.8 92.73,99.87 92.91,99.74 93.27,99.81 93.39,99.98 93.75,100.05 93.93,99.92 94.29,99.99 94.42,100.16 94.78,100.23 94.95,100.1 95.31,100.17 95.44,100.34 95.8,100.41 95.98,100.28 96.34,100.35 96.46,100.53 96.82,100.59 97,100.46 97.36,100.53 97.48,100.71 97.84,100.77 98.02,100.64 98.38,100.71 98.5,100.89 98.86,100.95 99.04,100.83 99.4,100.89 99.53,101.07 101.96,101.5 103.18,101.28 103.28,101.14 103.13,100.28 103.36,99.94 103.98,99.83 104.32,100.07 104.47,100.93 104.61,101.03 104.99,100.96 105.09,100.82 104.94,99.96 105.18,99.62 105.8,99.51 106.14,99.75 106.29,100.61 106.55,100.79 132.82,96.16 139.66,97.36 148.9,95.73 148.9,95.73 201.42,86.47 203.23,86.79 205.7,86.35 209.7,87.06 211.67,86.72 213.72,87.08 216,86.68 218.62,87.14 221.07,86.71 223.14,87.07 225.03,86.74 227.08,87.1 229.36,86.7 231.14,87.01 233.01,86.68 235.18,87.07 237.44,86.67 240.78,87.26 242.95,86.88 245.49,87.32 247.19,87.02 247.85,87.14 248.03,87.02 248.39,87.08 248.51,87.26 248.87,87.32 249.61,87.19 249.72,87.08 249.72,86.87 v1(249.35,86.61)
  BOTTOM w0.135: v1(249.35,86.61) 249.71,86.26 249.71,85.46 C142.1 ; U1.J34 v4(90.36,98.13)
PE_SLOT4_TX_C_DN<8>: length 167.6
  BOTTOM w0.089: 90.61,99.23 90.61,99.21 90.67,99.15 90.67,98.7 91.21,97.93 91.26,97.63 91.26,97.41 91.08,97.23 90.95,97.23 90.86,97.31 U1.H34
  BOTTOM w0.135: C143.1 245.98,85.46 245.98,85.79 245.89,86.25 245.44,86.91 242.05,89.28 238.12,92.03 233.98,92.76 v3(208.26,92.76) 207.57,92.76 194.26,95.42 179.7,92.51 176.53,93.15 173.35,92.51 170.18,93.15 167,92.51 163.83,93.15 160.65,92.51 148.9,94.86 142.15,93.67 127.48,96.61 120.15,101.73 104.51,104.49 101.19,103.91 98.36,104.4 93.91,103.62 91.62,102.02 90.82,100.87 90.61,99.7 90.61,99.23
PE_SLOT4_TX_C_DN<9>: length 166.4
  BOTTOM w0.089: U1.G34 91.86,97.31 91.94,97.24 92.1,97.24 92.28,97.43 92.28,97.94 92.22,98.27 91.98,98.62 91.98,99.36 91.92,99.42 91.92,99.44
  BOTTOM w0.135: 91.92,99.44 91.92,99.83 92.02,100.39 92.58,101.19 94,102.19 98.87,103.05 101.18,102.64 104.16,103.16 119.75,100.42 126.82,95.47 142.15,92.4 148.9,93.59 160.65,91.24 163.83,91.88 167,91.24 170.18,91.88 173.35,91.24 176.53,91.88 179.77,91.23 194.45,94.16 207.45,91.56 v3(210.78,91.56) 233.81,91.56 235.81,91.21 236.83,90.49 236.91,90.05 236.28,89.16 236.32,88.97 236.83,88.61 237.02,88.64 237.65,89.54 238.08,89.62 238.8,89.11 238.88,88.67 238.25,87.78 238.29,87.59 238.8,87.23 238.99,87.26 239.61,88.16 240.05,88.24 241.06,87.53 241.99,86.2 241.99,85.46 C144.1
PE_SLOT4_TX_C_DN<10>: length 154.2
  BOTTOM w0.089: 93.21,99.09 93.21,99.06 93.27,99.01 93.27,97.42 93.1,97.24 92.94,97.24 92.86,97.31 U1.F34
  BOTTOM w0.135: C145.1 237.97,85.46 237.97,85.93 237.51,86.6 233.23,89.6 228.9,90.36 v3(221.79,90.36) 207.24,90.36 194.48,92.91 179.74,89.96 176.53,90.61 173.35,89.97 170.18,90.61 167.12,89.99 163.94,90.63 160.65,89.97 148.9,92.32 142.12,91.15 126.42,94.28 119.41,99.19 104.53,101.81 101.36,101.25 99.24,101.63 94.06,100.71 93.57,100.37 93.28,99.95 93.22,99.61 93.21,99.6 93.21,99.09
PE_SLOT4_TX_C_DN<11>: length 152
  BOTTOM w0.089: 94.45,98.99 94.44,98.98 94.44,98.9 94.26,98.72 94.26,97.38 94.1,97.22 93.94,97.22 93.86,97.29 U1.E34
  BOTTOM w0.135: 94.45,98.99 94.61,99.15 95,99.42 95.11,99.44 99.56,100.23 101.47,99.89 104.81,100.48 105.35,100.38 105.6,100.02 105.46,99.2 105.57,99.04 106.19,98.93 106.34,99.04 106.49,99.86 106.85,100.12 107.72,99.96 107.97,99.6 107.83,98.78 107.94,98.62 108.56,98.51 108.71,98.62 108.86,99.44 109.22,99.7 119.07,97.96 126.08,93.05 142.15,89.83 148.9,91.03 160.65,88.67 164.12,89.37 167.12,88.77 170,89.34 173.35,88.67 176.53,89.31 179.75,88.67 194.53,91.62 206.85,89.16 v3(215.51,89.16) 228.79,89.16 230.44,88.87 233.74,86.56 234.01,86.17 234.01,85.46 C146.1
PE_SLOT4_TX_C_DN<12>: length 136.8
  BOTTOM w0.089: U1.A28 97.63,91.63 97.5,91.76 97.5,91.89 97.64,92.02 98.24,92.02 98.98,92.77 99.54,92.77 99.6,92.71 99.62,92.71
  BOTTOM w0.135: C147.1 227.69,85.46 227.69,85.89 227.65,86.09 227.38,86.48 226.67,86.98 226.1,87.08 225.93,86.95 225.53,87.02 225.4,87.2 225.01,87.27 224.83,87.14 224.43,87.21 224.31,87.39 222.84,87.65 v3(219.86,87.65) 206.72,87.65 193.97,89.9 179.8,87.1 176.53,87.75 173.35,87.12 169.96,87.8 167.11,87.23 164.16,87.82 160.17,87.02 148.9,89.27 142.56,88.01 125.89,91.34 125.45,91.65 125.24,91.61 124.91,91.84 124.87,92.05 124.54,92.28 124.32,92.25 123.99,92.48 123.96,92.69 123.63,92.92 123.41,92.89 123.08,93.12 123.04,93.33 122.71,93.56 122.5,93.53 122.17,93.76 122.13,93.97 121.16,94.66 120.62,94.75 120.44,94.63 120.04,94.7 119.92,94.87 118.81,95.07 112.2,93.9 110.52,94.2 109.31,93.99 107.79,94.25 106.15,93.97 104.46,94.26 102.48,93.92 100.84,92.77 100.79,92.71 99.62,92.71
PE_SLOT4_TX_C_DN<13>: length 134.5
  BOTTOM w0.089: U1.A27 97.55,90.63 97.45,90.73 97.45,90.83 97.65,91.03 98.72,91.03 98.93,91.24 99.44,91.24 99.5,91.19 99.52,91.19
  BOTTOM w0.135: C148.1 223.67,85.46 223.67,85.75 223.63,85.98 223.48,86.19 223.25,86.36 222.73,86.45 222.33,86.45 222.17,86.3 221.77,86.3 221.62,86.45 221.21,86.45 221.06,86.3 220.66,86.3 220.5,86.45 220.1,86.45 219.95,86.3 219.54,86.3 219.39,86.45 218.99,86.45 218.83,86.3 218.43,86.3 218.28,86.45 217.87,86.45 217.72,86.3 217.31,86.3 217.16,86.45 216.76,86.45 216.6,86.3 216.2,86.3 216.05,86.45 v3(213.42,86.45) 206.18,86.45 202.83,87.04 202.68,86.93 202.64,86.71 202.28,86.46 201.41,86.61 201.15,86.97 201.19,87.19 201.08,87.35 200.47,87.46 200.31,87.35 200.27,87.13 199.91,86.87 199.04,87.03 198.79,87.39 198.83,87.61 198.72,87.77 197.59,87.96 195.49,88.34 194.47,88.52 182.39,86.38 179.7,85.85 176.53,86.48 173.35,85.85 169.84,86.55 167.1,86 164.39,86.55 160.17,85.8 148.9,87.79 142.55,86.67 130.74,88.75 126.04,89.58 122.51,92.05 120.2,92.46 119.94,92.82 120.03,93.31 119.91,93.47 119.29,93.58 119.14,93.47 119.05,92.97 118.69,92.72 117.51,92.93 112.78,92.1 111.64,92.3 109.95,92 108,92.35 106.09,92.01 104.32,92.32 102,91.92 101.21,91.36 100.23,91.19 100.23,91.19 99.52,91.19
