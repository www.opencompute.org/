# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT2_TX_C_DN<1>: length 193.3
  IN1 w0.089: v4(98.36,70.13) 98.12,70.13 97.98,70.27 97.98,70.46 98.06,70.54 99.26,70.54 99.4,70.51 99.41,70.51 99.45,70.45 99.47,70.45
  IN1 w0.122: v1(275.31,45.97) 275.67,46.34 275.67,46.52 274.85,47.1 274.49,47.16 274.31,47.04 273.95,47.1 273.83,47.28 273.47,47.34 273.29,47.22 272.93,47.28 272.8,47.46 272.44,47.52 272.27,47.4 271.91,47.46 271.78,47.64 253.78,50.81 251.22,50.36 249.21,50.72 247.18,50.36 245.58,50.64 243.02,50.19 240.73,50.59 237.44,50.01 235.05,50.44 232.77,50.03 230.74,50.39 229.07,50.1 227.04,50.46 224.95,50.09 222.86,50.46 218.43,49.68 211.14,50.96 204.42,55.67 200.51,56.36 197.4,58.54 155.48,65.93 148.9,64.77 142.59,65.88 119.52,61.83 118.57,62 118.43,61.9 118.38,61.6 118.04,61.36 117.42,61.47 117.18,61.81 117.23,62.11 117.14,62.25 116.75,62.32 116.61,62.22 116.56,61.92 116.22,61.68 115.6,61.79 115.36,62.13 115.42,62.43 115.32,62.57 114.94,62.64 114.8,62.54 114.74,62.24 114.4,62 113.78,62.11 113.55,62.45 113.6,62.75 113.5,62.89 113.12,62.96 112.98,62.86 112.93,62.56 112.59,62.32 111.97,62.43 111.73,62.77 111.78,63.07 111.68,63.21 111.23,63.29 108.31,65.34 108.1,65.3 107.8,65.51 107.76,65.72 107.46,65.93 106.85,66.8 106.42,67.11 105.98,67.41 105.18,67.55 104.12,68.29 103.91,68.25 103.61,68.46 103.57,68.68 103.27,68.89 103.06,68.85 102.76,69.06 102.72,69.27 102.42,69.48 102.21,69.44 101.91,69.65 101.87,69.87 101.57,70.08 99.52,70.44 99.47,70.45
  BOTTOM w0.135: C32.1 275.67,44.82 275.67,45.62 v1(275.31,45.97) ; U1.A7 v4(98.36,70.13)
PE_SLOT2_TX_C_DN<2>: length 185.7
  IN1 w0.089: v4(98.36,69.13) 98.08,69.13 97.98,69.23 97.98,69.45 98.06,69.54 98.49,69.54 98.94,69.62 99.41,69.53 99.45,69.47 99.47,69.47
  IN1 w0.122: 99.47,69.47 99.52,69.46 99.61,69.45 99.91,69.24 99.95,69.02 100.25,68.81 100.46,68.85 100.76,68.64 100.8,68.43 101.1,68.22 101.31,68.25 101.61,68.04 101.65,67.83 101.95,67.62 102.16,67.66 102.46,67.45 102.5,67.24 102.8,67.03 103.01,67.06 103.77,66.53 104.4,65.63 104.75,65.39 104.79,65.17 105.09,64.96 105.3,65 105.6,64.79 105.64,64.58 105.94,64.37 106.15,64.4 109.22,62.26 109.29,62.25 118.03,60.71 142.55,65.02 148.9,63.9 155.9,65.13 197.21,57.85 200.52,55.53 204.47,54.83 210.91,50.32 218.44,49 222.9,49.78 224.99,49.41 227.13,49.79 229.18,49.43 230.81,49.72 232.8,49.37 235.08,49.77 237.46,49.35 240.78,49.93 243.02,49.54 245.57,49.99 247.19,49.7 249.18,50.05 251.31,49.68 253.92,50.14 269.82,47.33 269.94,47.16 270.3,47.09 270.48,47.22 270.84,47.15 271.62,46.61 271.64,46.53 271.64,46.34 v1(271.27,45.97)
  BOTTOM w0.135: v1(271.27,45.97) 271.63,45.62 271.63,44.82 C33.1 ; U1.A6 v4(98.36,69.13)
PE_SLOT2_TX_C_DN<3>: length 183.5
  IN1 w0.089: v4(98.36,68.13) 98.01,68.13 97.94,68.2 97.94,68.42 98.06,68.54 98.86,68.54 99.32,68.22 99.32,68.22 99.33,68.15 99.35,68.13
  IN1 w0.122: v1(267.31,45.97) 267.67,46.34 267.67,46.59 266.78,47.22 265.75,47.4 265.61,47.3 265.46,46.46 265.12,46.22 264.5,46.33 264.43,46.43 264.27,46.67 264.41,47.49 264.3,47.65 263.94,47.72 263.76,47.59 263.4,47.66 263.27,47.83 253.92,49.48 251.22,49.01 249.13,49.38 247.17,49.03 245.5,49.32 243.02,48.89 240.86,49.27 237.54,48.68 235.22,49.09 232.91,48.68 230.78,49.06 229.02,48.75 227.03,49.1 225.05,48.75 223.06,49.1 218.42,48.28 214.58,48.96 214.58,48.96 210.73,49.64 204.26,54.17 200.22,54.88 200.17,54.92 200.17,54.92 196.88,57.22 156.18,64.4 148.9,63.11 142.19,64.3 118,60.05 107.75,61.86 107.43,62.08 107.22,62.04 106.92,62.25 106.88,62.46 106.58,62.67 106.37,62.64 106.07,62.85 106.03,63.06 105.73,63.27 105.52,63.23 105.22,63.44 105.18,63.65 104.83,63.9 104.61,63.86 104.31,64.07 104.28,64.29 101.8,66.02 101.58,65.99 101.28,66.2 101.25,66.41 100.87,66.67 100.33,67.45 99.52,68.02 99.35,68.13
  BOTTOM w0.135: v1(267.31,45.97) 267.67,45.62 267.67,44.82 C34.1 ; U1.A5 v4(98.36,68.13)
PE_SLOT2_TX_C_DN<4>: length 179.8
  IN1 w0.089: v4(93.36,64.13) 93.36,64.45 93.42,64.5 93.69,64.5 93.79,64.4 93.79,63.82 93.7,63.34 93.77,62.95 93.73,62.89 93.73,62.87
  IN1 w0.122: v1(261.34,45.97) 261.7,46.34 261.7,46.51 261.66,46.77 261.53,46.95 260.52,47.66 260.16,47.72 259.98,47.6 259.62,47.66 259.5,47.84 259.14,47.9 258.96,47.78 258.6,47.84 258.47,48.02 258.11,48.08 257.94,47.96 257.58,48.02 257.45,48.2 253.91,48.82 253.91,48.82 253.53,48.76 252.44,48.57 251.16,48.34 249.08,48.71 247.19,48.37 245.57,48.66 242.96,48.2 240.8,48.58 237.55,48.01 235.23,48.41 232.94,48.01 230.87,48.38 229.12,48.07 227.11,48.42 227.11,48.42 225.14,48.08 223.39,48.39 218.69,47.56 210.16,49.06 210.1,49.1 203.79,53.52 200.1,54.17 196.74,56.52 156.15,63.68 148.9,62.4 142.01,63.61 117.86,59.37 113.95,60.06 108.31,59.07 94.84,61.44 94.16,61.92 93.81,62.41 93.8,62.46 93.73,62.87
  BOTTOM w0.135: v1(261.34,45.97) 261.7,45.62 261.7,44.82 C67.1 ; U1.F1 v4(93.36,64.13)
PE_SLOT2_TX_C_DN<5>: length 177.4
  IN1 w0.089: v4(92.36,64.13) 92.36,64.45 92.42,64.5 92.68,64.5 92.77,64.42 92.77,63.97 92.65,63.81 92.54,63.19 92.58,62.95 92.54,62.89 92.55,62.87
  IN1 w0.122: v1(257.33,45.97) 257.69,46.34 257.69,46.51 257.69,46.51 257.57,47.2 257.07,47.55 256.7,47.62 256.52,47.49 256.16,47.56 256.03,47.73 255.67,47.8 255.5,47.67 255.14,47.74 255.01,47.91 253.74,48.14 253.38,48.07 253.26,47.9 252.9,47.83 252.72,47.96 251.08,47.67 249.07,48.02 247.22,47.7 245.52,48 242.96,47.55 240.8,47.93 237.55,47.35 235.23,47.76 232.95,47.36 230.94,47.71 229.18,47.4 227.11,47.77 225.14,47.42 223.48,47.72 218.53,46.84 209.94,48.36 203.54,52.84 199.85,53.49 196.36,55.93 156.19,63.02 148.9,61.73 141.97,62.95 117.77,58.7 114.05,59.36 108.42,58.37 94.18,60.88 92.96,61.73 92.67,62.14 92.55,62.87
  BOTTOM w0.135: U1.G1 v4(92.36,64.13) ; C68.1 257.68,44.82 257.68,45.62 v1(257.33,45.97)
PE_SLOT2_TX_C_DN<6>: length 173.8
  IN1 w0.089: v4(91.36,64.13) 91.36,64.51 91.44,64.59 91.63,64.59 91.77,64.45 91.77,64 91.65,63.35 91.72,62.95 91.68,62.89 91.69,62.87
  IN1 w0.122: v1(253.32,45.97) 253.68,46.34 253.68,46.46 253.53,46.56 252.8,46.69 252.62,46.57 252.26,46.63 252.14,46.81 251.78,46.87 251.6,46.75 251.24,46.81 251.12,46.99 249.01,47.36 247.23,47.04 245.52,47.34 242.94,46.89 240.79,47.27 237.48,46.69 235.16,47.1 232.95,46.71 231.11,47.03 229.36,46.72 227.11,47.12 225.14,46.77 223.64,47.04 218.51,46.13 209.57,47.71 203.2,52.17 199.49,52.82 195.94,55.31 156.16,62.33 148.9,61.05 141.88,62.28 117.56,58.01 114.09,58.62 108.67,57.67 93.87,60.28 93.1,60.82 92.34,61.35 91.82,62.08 91.69,62.87
  BOTTOM w0.135: v1(253.32,45.97) 253.67,45.62 253.67,44.82 C69.1 ; U1.H1 v4(91.36,64.13)
PE_SLOT2_TX_C_DN<7>: length 172.3
  IN1 w0.089: 90.8,63.25 90.79,63.27 90.84,63.33 90.8,63.54 90.77,63.71 90.77,64.4 90.66,64.5 90.42,64.5 90.36,64.45 v4(90.36,64.13)
  IN1 w0.122: v1(249.35,45.97) 249.72,46.34 249.72,46.45 249.7,46.47 249.44,46.62 248.97,46.7 248.54,46.62 248.41,46.44 248.05,46.38 247.88,46.51 247.06,46.36 246.7,46.43 246.53,46.3 246.17,46.37 246.04,46.54 245.68,46.61 244.98,46.48 244.88,46.34 244.97,45.84 244.73,45.5 244.11,45.39 243.77,45.63 243.68,46.13 243.54,46.23 243.11,46.15 242.36,46.29 242.18,46.16 241.82,46.22 241.7,46.4 240.63,46.59 237.44,46.03 235.26,46.41 233.08,46.03 231.14,46.37 229.36,46.06 227.08,46.46 225.08,46.11 225.06,46.1 225.01,46.09 223.69,46.33 218.62,45.43 208.93,47.14 202.57,51.59 199.3,52.17 197.48,53.44 195.78,54.64 156.09,61.64 148.9,60.37 141.81,61.62 117.36,57.32 113.91,57.93 108.51,56.98 93.63,59.6 91.75,60.92 91.03,61.95 90.8,63.25
  BOTTOM w0.135: C70.1 249.71,44.82 249.71,45.62 v1(249.35,45.97) ; U1.J1 v4(90.36,64.13)
PE_SLOT2_TX_C_DN<8>: length 166.4
  IN1 w0.089: v4(89.36,64.13) 89.36,64.45 89.42,64.5 89.65,64.5 89.76,64.39 89.76,63.99 90.06,63.16 90.1,62.95 90.06,62.89 90.06,62.87
  IN1 w0.122: v1(190.45,53.34) 190.08,53.71 190.07,53.71 189.84,53.71 188.33,53.98 152.53,60.28 148.9,59.64 141.6,60.93 117.11,56.63 113.77,57.22 108.53,56.29 93.42,58.96 91.27,60.46 90.41,61.69 90.22,61.96 90.09,62.71 90.06,62.87
  BOTTOM w0.135: U1.K1 v4(89.36,64.13) ; v1(190.45,53.34) 190.78,53.67 191.1,53.67 191.99,53.83 194.98,55.92 196.95,56.27 202.53,56.27 206.42,55.58 211.92,51.73 232.66,51.73 236.85,51 239.54,49.12 239.57,48.9 239.91,48.67 240.12,48.71 240.45,48.48 240.49,48.26 240.82,48.03 241.03,48.07 241.36,47.84 241.4,47.63 241.73,47.39 241.94,47.43 242.27,47.2 242.31,46.99 242.64,46.75 242.86,46.79 243.35,46.45 243.6,46.09 243.69,45.57 243.69,44.82 C71.1
PE_SLOT2_TX_C_DN<9>: length 164.2
  IN1 w0.089: v4(88.36,64.13) 88.36,64.45 88.45,64.53 88.58,64.53 88.77,64.35 88.77,63.58 89.2,62.95 89.19,62.88 89.2,62.87
  IN1 w0.122: 89.2,62.87 89.2,62.87 89.41,62.57 89.43,62.51 89.6,61.57 90.65,60.07 93.12,58.34 108.5,55.63 113.71,56.55 117.04,55.96 141.5,60.26 148.9,58.95 152.4,59.57 188.15,53.27 188.91,52.73 189.88,52.06 190.69,51.91 191.41,52.04 191.86,52.35 192.27,52.43 192.64,52.43 v1(192.99,52.07)
  BOTTOM w0.135: U1.L1 v4(88.36,64.13) ; v1(192.99,52.07) 193.32,52.4 193.81,52.4 194.23,52.69 195.26,54.17 196.25,54.86 197.38,55.06 202.46,55.06 205.95,54.45 211.46,50.59 211.54,50.53 229.5,50.53 229.65,50.38 230.05,50.38 230.21,50.53 230.61,50.53 230.76,50.38 231.17,50.38 231.32,50.53 231.93,50.53 234.41,50.1 235.02,49.67 235.06,49.45 235.39,49.22 235.61,49.26 235.94,49.03 235.97,48.81 236.31,48.58 236.52,48.62 238.83,47 239.53,46 239.68,45.15 239.68,44.82 C72.1
PE_SLOT2_TX_C_DN<10>: length 160.8
  IN1 w0.089: 87.86,62.87 87.85,62.87 87.85,62.89 87.86,62.91 87.86,62.95 87.75,63.1 87.73,63.23 87.73,63.85 87.77,64.08 87.77,64.34 87.58,64.53 87.45,64.53 87.36,64.45 v4(87.36,64.13)
  IN1 w0.122: 87.86,62.87 90.14,59.6 92.83,57.72 108.63,54.94 113.74,55.84 116.89,55.28 141.36,59.58 148.9,58.25 152.51,58.89 187.62,52.69 189.49,51.39 193.38,50.7 194.4,50.88 194.62,51.03 194.86,51.38 194.95,51.87 194.95,52.32 195.07,52.44 195.29,52.44 v1(195.66,52.07)
  BOTTOM w0.135: v1(195.66,52.07) 195.96,52.37 197.05,52.37 197.71,52.84 197.71,52.84 198.36,53.29 200.06,53.59 202.22,53.59 206.03,52.92 211.08,49.39 211.16,49.33 228.24,49.33 231.23,48.8 231.68,48.49 231.72,48.28 232.05,48.05 232.26,48.08 232.63,47.83 232.66,47.62 232.99,47.38 233.21,47.42 233.54,47.19 233.58,46.98 233.91,46.75 234.12,46.78 235.37,45.9 235.66,45.5 235.69,45.32 235.69,44.82 C73.1 ; U1.M1 v4(87.36,64.13)
PE_SLOT2_TX_C_DN<11>: length 159.2
  IN1 w0.089: 87.02,62.87 87.01,62.89 87.05,62.95 86.98,63.35 86.79,63.74 86.76,63.93 86.76,64.36 86.58,64.53 86.45,64.53 86.36,64.45 v4(86.36,64.13)
  IN1 w0.122: 87.02,62.87 87.05,62.68 87.41,62.16 89.55,59.1 92.34,57.15 108.73,54.26 113.77,55.15 116.81,54.62 141.14,58.89 148.9,57.52 152.61,58.18 187.02,52.11 190.21,49.87 190.26,49.82 193.51,49.25 195.3,49.25 v1(195.66,48.9)
  BOTTOM w0.135: C74.1 231.7,44.82 231.7,45.25 231.66,45.5 231.5,45.73 230.69,46.29 230.51,46.26 230.17,45.79 229.74,45.71 229.02,46.22 228.94,46.65 229.27,47.12 229.24,47.31 228.57,47.77 228.14,47.85 228.13,47.85 227.96,47.73 227.56,47.8 227.44,47.98 226.55,48.13 226.04,48.13 225.88,47.98 225.48,47.98 225.33,48.13 210.71,48.13 210.63,48.19 205.7,51.64 205.31,51.71 205.13,51.58 204.73,51.65 204.61,51.83 204.21,51.9 204.03,51.78 203.63,51.85 203.51,52.03 202.22,52.25 201.3,52.25 199.51,51.94 197.77,50.72 196.95,49.55 196.49,49.23 195.99,49.23 v1(195.66,48.9) ; U1.N1 v4(86.36,64.13)
PE_SLOT2_TX_C_DN<12>: length 155.1
  IN1 w0.089: 86.02,62.87 86.01,62.88 86.02,62.95 85.87,63.16 85.84,63.34 85.76,63.79 85.76,64.35 85.58,64.53 85.45,64.53 85.36,64.45 v4(85.36,64.13)
  IN1 w0.122: 86.02,62.87 89.02,58.59 91.88,56.58 108.81,53.6 113.74,54.47 116.7,53.94 140.93,58.2 148.9,56.8 152.81,57.49 186.61,51.53 190.91,48.51 190.96,48.48 196.43,47.51 197.08,47.63 197.34,47.81 197.34,47.81 197.39,47.84 197.6,48.14 197.67,48.54 197.67,49.14 197.79,49.26 197.96,49.26 v1(198.32,48.9)
  BOTTOM w0.135: v1(198.32,48.9) 198.71,49.28 199.22,49.28 199.86,49.73 200.28,50.32 200.81,50.7 201.98,50.9 202.54,50.81 202.67,50.63 203.06,50.56 203.24,50.68 203.64,50.61 203.76,50.44 204.16,50.36 204.34,50.49 205.31,50.32 210.15,46.93 223.69,46.93 225.81,46.55 226.22,46.3 226.27,46.13 226.61,45.92 226.79,45.97 227.57,45.49 227.69,45.22 227.69,44.82 C75.1 ; U1.P1 v4(85.36,64.13)
PE_SLOT2_TX_C_DN<13>: length 153.8
  IN1 w0.089: 85.17,62.87 85.16,62.88 85.17,62.95 84.86,63.39 84.77,63.94 84.77,64.35 84.58,64.53 84.45,64.53 84.36,64.45 v4(84.36,64.13)
  IN1 w0.122: v1(201.12,48.77) 200.76,49.12 200.34,49.12 200.16,48.94 200.16,48.64 200.07,48.13 199.72,47.63 199.19,47.26 196.07,46.71 190.93,47.62 190.22,48.12 190.22,48.11 186.18,50.94 152.89,56.82 148.9,56.11 140.85,57.53 116.55,53.26 113.67,53.77 108.75,52.9 91.7,55.91 88.44,58.2 86.85,60.47 86.85,60.47 85.17,62.87
  BOTTOM w0.135: C76.1 223.7,44.82 223.7,45.05 223.51,45.32 223.02,45.66 222.65,45.73 222.13,45.73 222,45.59 222,44.6 221.64,44.25 220.83,44.25 220.49,44.59 220.49,45.59 220.36,45.73 214.54,45.73 214.38,45.57 213.98,45.57 213.83,45.73 213.42,45.73 213.27,45.57 212.87,45.57 212.71,45.73 212.31,45.73 212.16,45.57 211.75,45.57 211.6,45.73 211.19,45.73 211.04,45.57 210.64,45.57 210.48,45.73 209.77,45.73 205.21,48.92 204.2,49.1 201.45,49.1 v1(201.12,48.77) ; U1.R1 v4(84.36,64.13)
PE_SLOT2_TX_C_DN<14>: length 144.3
  IN1 w0.089: 84.2,62.96 84.19,62.98 84.2,63.05 83.77,63.66 83.77,64.34 83.58,64.53 83.45,64.53 83.36,64.45 v4(83.36,64.13)
  IN1 w0.122: 84.2,62.96 84.26,62.87 87.76,57.88 91.47,55.28 108.8,52.22 113.51,53.05 116.28,52.57 140.61,56.84 148.9,55.38 153.13,56.12 185.76,50.37 190.58,46.99 196.53,45.94 198.43,46.27 198.7,46.32 200.07,46.08 200.76,46.08 v1(201.12,45.72)
  BOTTOM w0.135: U1.T1 v4(83.36,64.13) ; C77.1 216.87,44.04 212.12,44.04 209.39,44.53 205.06,47.55 204.23,47.7 203.97,47.7 203.52,47.62 203.13,47.35 202.9,47.12 202.48,46.52 201.84,46.08 201.47,46.08 v1(201.12,45.72)
PE_SLOT2_TX_C_DN<15>: length 141
  IN1 w0.089: 83.46,62.87 83.45,62.88 83.46,62.95 83.33,63.13 82.77,63.94 82.77,64.35 82.58,64.53 82.45,64.53 82.36,64.45 v4(82.36,64.13)
  IN1 w0.122: v1(203.66,45.59) 203.29,45.96 203.02,45.96 202.8,45.74 202.67,45.02 202.28,44.47 201.42,44.31 200.53,44.47 200.39,44.37 200.34,44.14 200.01,43.9 199.39,44.01 199.15,44.35 199.19,44.59 199.09,44.73 194.81,45.48 194.8,45.48 190.52,46.24 185.49,49.76 153.14,55.47 148.9,54.72 140.59,56.18 116.22,51.9 113.47,52.39 108.7,51.55 91.23,54.63 87.3,57.38 83.46,62.87
  BOTTOM w0.135: C78.1 208.49,42.65 208.15,42.65 207.77,42.71 207.46,42.93 206.51,43.88 206.32,43.88 205.62,43.19 205.18,43.19 204.55,43.81 204.55,44.25 205.25,44.95 205.25,45.14 204.69,45.7 204.41,45.9 204.15,45.95 204.01,45.95 v1(203.66,45.59) ; U1.U1 v4(82.36,64.13)
PE_SLOT2_TX_C_DP<0>: length 194.3
  IN1 w0.089: v4(97.36,71.13) 97.68,71.13 97.82,71.27 97.82,71.59 98.12,71.89 98.15,71.9 98.19,71.91 98.96,72.05 99.23,72 99.29,72.04 99.31,72.04
  IN1 w0.122: 99.31,72.04 99.32,72.04 102.99,71.39 103.05,71.35 105.56,69.59 106.92,69.35 107.79,68.74 108.44,67.81 109.01,67.42 110.15,67.22 110.77,66.78 112.51,64.29 112.92,64.01 119.55,62.84 142.59,66.89 148.9,65.77 155.38,66.92 197.91,59.42 198.56,58.96 198.57,58.96 200.97,57.28 204.88,56.59 211.53,51.93 218.52,50.7 222.73,51.44 224.64,51.1 226.72,51.47 229.04,51.06 230.79,51.37 232.82,51.01 235.1,51.41 237.5,50.99 240.68,51.55 243.02,51.14 245.65,51.6 247.19,51.33 249.28,51.7 251.12,51.38 253.55,51.8 279.47,47.23 279.92,46.92 279.98,46.58 279.98,46.34 v1(280.34,45.97)
  BOTTOM w0.135: v1(280.34,45.97) 279.99,45.62 279.99,44.82 C27.1 ; U1.B8 v4(97.36,71.13)
PE_SLOT2_TX_C_DP<1>: length 193.3
  IN1 w0.089: 99.52,70.74 99.5,70.74 99.44,70.7 99.28,70.73 97.98,70.73 97.79,70.54 97.79,70.24 97.68,70.13 v4(97.36,70.13)
  IN1 w0.122: v1(276.33,45.97) 275.97,46.34 275.97,46.67 274.96,47.38 253.78,51.11 251.22,50.66 249.21,51.01 247.18,50.66 245.58,50.94 243.02,50.49 240.73,50.89 237.44,50.31 235.05,50.73 232.77,50.33 230.74,50.69 229.07,50.4 227.04,50.76 226.75,50.7 224.95,50.39 222.86,50.76 218.43,49.98 211.26,51.24 204.53,55.95 200.62,56.64 197.51,58.82 155.48,66.23 148.9,65.07 142.59,66.18 119.52,62.13 118.5,62.31 118.16,62.07 118.11,61.77 117.97,61.67 117.59,61.74 117.49,61.88 117.54,62.18 117.31,62.52 116.69,62.63 116.35,62.39 116.29,62.09 116.15,61.99 115.77,62.06 115.67,62.2 115.73,62.5 115.49,62.84 114.87,62.95 114.53,62.71 114.48,62.41 114.34,62.31 113.95,62.38 113.86,62.52 113.91,62.82 113.67,63.16 113.05,63.27 112.71,63.03 112.66,62.73 112.52,62.63 112.14,62.7 112.04,62.84 112.09,63.14 111.85,63.48 111.35,63.57 107.67,66.14 107.06,67.01 106.1,67.69 105.29,67.83 101.69,70.35 99.52,70.74
  BOTTOM w0.135: U1.B7 v4(97.36,70.13) ; v1(276.33,45.97) 275.97,45.62 275.97,44.82 C28.1
PE_SLOT2_TX_C_DP<2>: length 185.6
  IN1 w0.089: v4(97.36,69.13) 97.68,69.13 97.79,69.24 97.79,69.53 97.99,69.73 98.47,69.73 98.94,69.81 99.44,69.72 99.5,69.76 99.52,69.76
  IN1 w0.122: 99.52,69.76 99.73,69.72 103.98,66.74 104.61,65.84 109.33,62.54 109.33,62.54 118.03,61 142.55,65.31 148.9,64.19 155.9,65.43 197.32,58.12 200.64,55.8 204.58,55.11 211.02,50.6 218.44,49.29 222.9,50.08 224.99,49.71 227.13,50.09 229.18,49.73 230.81,50.01 232.8,49.66 235.08,50.06 237.46,49.64 240.78,50.23 243.02,49.83 245.57,50.28 247.19,50 249.18,50.35 251.31,49.97 253.92,50.43 270.95,47.43 271.89,46.78 271.93,46.55 271.93,46.34 v1(272.29,45.97)
  BOTTOM w0.135: U1.B6 v4(97.36,69.13) ; v1(272.29,45.97) 271.93,45.62 271.93,44.82 C29.1
PE_SLOT2_TX_C_DP<3>: length 183.4
  IN1 w0.089: v4(97.36,68.13) 97.65,68.13 97.75,68.24 97.75,68.5 97.98,68.73 98.92,68.73 98.93,68.72 99.43,68.37 99.5,68.39 99.52,68.37
  IN1 w0.122: 99.52,68.37 100.54,67.66 101.08,66.88 107.87,62.13 118,60.35 142.19,64.59 148.9,63.41 156.18,64.69 196.99,57.5 200.34,55.15 204.38,54.44 210.84,49.92 218.42,48.58 223.06,49.4 225.05,49.05 227.03,49.39 229.02,49.04 230.78,49.35 232.91,48.98 235.22,49.39 237.54,48.98 240.86,49.56 243.02,49.18 245.5,49.62 247.17,49.33 249.13,49.67 251.22,49.3 253.92,49.78 264.47,47.92 264.72,47.56 264.57,46.74 264.67,46.59 265.05,46.53 265.2,46.63 265.34,47.47 265.68,47.71 266.89,47.49 267.97,46.74 267.97,46.34 v1(268.33,45.97)
  BOTTOM w0.135: U1.B5 v4(97.36,68.13) ; v1(268.33,45.97) 267.97,45.62 267.97,44.82 C30.1
PE_SLOT2_TX_C_DP<4>: length 179.8
  IN1 w0.089: v4(93.36,65.13) 93.36,64.78 93.45,64.69 93.77,64.69 93.98,64.48 93.98,63.81 93.9,63.34 93.96,62.98 94.02,62.94 94.02,62.92
  IN1 w0.122: v1(262.36,45.97) 262,46.34 262,46.53 261.93,46.89 261.74,47.16 260.63,47.94 253.9,49.12 253.86,49.11 251.16,48.64 249.08,49 247.19,48.67 245.57,48.96 242.96,48.5 240.8,48.88 237.55,48.3 235.23,48.71 232.94,48.31 230.87,48.67 229.12,48.36 227.11,48.72 225.14,48.37 223.39,48.68 218.69,47.85 210.27,49.34 203.91,53.8 200.22,54.45 196.86,56.8 156.15,63.98 148.9,62.7 142.01,63.91 117.86,59.67 113.95,60.36 111.1,59.86 108.31,59.36 94.95,61.72 94.37,62.13 94.09,62.52 94.02,62.92
  BOTTOM w0.135: v1(262.36,45.97) 262,45.62 262,44.82 C55.1 ; U1.F2 v4(93.36,65.13)
PE_SLOT2_TX_C_DP<5>: length 177.4
  IN1 w0.089: v4(92.36,65.13) 92.36,64.81 92.48,64.69 92.76,64.69 92.96,64.5 92.96,63.91 92.83,63.74 92.74,63.19 92.77,62.98 92.83,62.94 92.83,62.92
  IN1 w0.122: 92.83,62.92 92.95,62.26 93.17,61.94 94.29,61.16 108.42,58.67 114.05,59.66 117.77,59 141.97,63.25 148.9,62.03 156.19,63.31 196.48,56.21 199.96,53.77 203.65,53.12 210.06,48.63 218.53,47.14 223.48,48.01 225.14,47.72 227.11,48.07 229.18,47.7 230.94,48.01 232.95,47.66 235.23,48.06 237.55,47.65 240.8,48.22 242.96,47.84 245.52,48.29 247.22,47.99 249.07,48.32 251.08,47.96 253.72,48.43 253.77,48.43 257.19,47.83 257.83,47.37 257.98,46.53 257.98,46.34 v1(258.35,45.97)
  BOTTOM w0.135: v1(258.35,45.97) 257.99,45.62 257.99,44.82 C56.1 ; U1.G2 v4(92.36,65.13)
PE_SLOT2_TX_C_DP<6>: length 173.8
  IN1 w0.089: 91.97,62.92 91.97,62.94 91.91,62.98 91.85,63.35 91.96,63.98 91.96,64.53 91.71,64.78 91.4,64.78 91.36,64.81 v4(91.36,65.13)
  IN1 w0.122: 91.97,62.92 92.1,62.2 92.55,61.56 93.98,60.55 108.67,57.96 114.09,58.92 117.56,58.31 141.88,62.58 148.9,61.34 156.16,62.62 196.05,55.59 199.6,53.1 203.31,52.45 209.69,47.98 218.51,46.43 223.64,47.33 225.14,47.07 227.11,47.41 229.36,47.02 231.11,47.33 232.95,47 235.16,47.39 237.48,46.98 240.79,47.57 242.94,47.19 245.52,47.64 247.23,47.34 249.01,47.66 253.64,46.84 253.97,46.61 253.97,46.34 v1(254.33,45.97)
  BOTTOM w0.135: v1(254.33,45.97) 253.98,45.62 253.98,44.82 C57.1 ; U1.H2 v4(91.36,65.13)
PE_SLOT2_TX_C_DP<7>: length 172.3
  IN1 w0.089: v4(90.36,65.13) 90.36,64.78 90.45,64.69 90.74,64.69 90.96,64.48 90.96,63.73 90.99,63.57 91.02,63.36 91.08,63.32 91.09,63.3
  IN1 w0.122: 91.09,63.3 91.3,62.07 91.96,61.13 93.74,59.88 108.51,57.28 113.91,58.23 117.36,57.62 141.81,61.92 148.9,60.66 156.09,61.93 195.89,54.92 199.41,52.45 202.69,51.87 209.05,47.42 218.62,45.73 223.69,46.62 225.01,46.39 225.03,46.4 227.08,46.76 229.36,46.35 231.14,46.67 233.08,46.33 235.26,46.71 237.44,46.33 240.63,46.89 243.11,46.45 243.61,46.54 243.95,46.3 244.04,45.8 244.18,45.7 244.56,45.76 244.66,45.9 244.57,46.41 244.81,46.75 245.68,46.9 247.06,46.66 248.97,47 249.54,46.89 249.89,46.69 250.01,46.55 250.01,46.34 v1(250.37,45.97)
  BOTTOM w0.135: v1(250.37,45.97) 250.01,45.62 250.01,44.82 C58.1 ; U1.J2 v4(90.36,65.13)
PE_SLOT2_TX_C_DP<8>: length 166.4
  IN1 w0.089: 90.35,62.92 90.34,62.94 90.29,62.98 90.24,63.21 89.95,64.02 89.95,64.47 89.73,64.69 89.48,64.69 89.36,64.81 v4(89.36,65.13)
  IN1 w0.122: 90.35,62.92 90.37,62.76 90.5,62.07 91.48,60.67 93.53,59.23 108.53,56.59 113.77,57.51 117.11,56.92 141.6,61.23 148.9,59.94 152.53,60.58 188.26,54.29 188.43,54.41 188.79,54.35 188.92,54.17 189.86,54.01 190.1,54.01 v1(190.45,54.36)
  BOTTOM w0.135: v1(190.45,54.36) 190.83,53.98 191.07,53.98 191.87,54.12 194.86,56.21 196.92,56.57 202.56,56.57 206.54,55.87 212.02,52.04 232.69,52.04 236.97,51.29 243.57,46.66 243.89,46.21 243.99,45.6 243.99,44.82 C59.1 ; U1.K2 v4(89.36,65.13)
PE_SLOT2_TX_C_DP<9>: length 164.2
  IN1 w0.089: 89.44,63.03 89.43,63.05 89.36,63.06 89.05,63.51 88.96,63.64 88.96,64.43 88.66,64.73 88.45,64.73 88.36,64.81 v4(88.36,65.13)
  IN1 w0.122: v1(192.99,53.09) 192.62,52.72 192.25,52.72 191.75,52.63 191.3,52.32 191,52.26 190.99,52.26 190.69,52.21 189.99,52.33 189.53,52.66 189.49,52.87 189.19,53.08 188.98,53.04 188.26,53.54 152.4,59.87 148.9,59.25 141.5,60.56 117.04,56.26 113.71,56.84 108.5,55.92 93.23,58.62 90.86,60.28 89.88,61.68 89.72,62.6 89.67,62.71 89.44,63.03
  BOTTOM w0.135: v1(192.99,53.09) 193.37,52.7 193.71,52.7 194.01,52.91 195.04,54.39 196.13,55.15 197.35,55.37 202.48,55.37 206.07,54.73 211.64,50.84 231.96,50.84 234.53,50.38 239.05,47.22 239.81,46.12 239.98,45.18 239.98,44.82 C60.1 ; U1.L2 v4(88.36,65.13)
PE_SLOT2_TX_C_DP<10>: length 160.8
  IN1 w0.089: 88.1,63.03 88.09,63.05 88.01,63.06 87.93,63.18 87.92,63.24 87.92,63.84 87.96,64.06 87.96,64.42 87.66,64.73 87.45,64.73 87.36,64.81 v4(87.36,65.13)
  IN1 w0.122: v1(195.66,53.09) 195.3,52.73 194.94,52.73 194.65,52.44 194.65,51.89 194.58,51.5 194.41,51.24 194.29,51.16 193.38,51 189.6,51.66 187.73,52.97 152.51,59.18 148.9,58.55 141.36,59.88 116.89,55.58 113.74,56.13 108.63,55.23 92.94,58 90.35,59.81 88.22,62.87 88.1,63.03
  BOTTOM w0.135: C61.1 235.99,44.82 235.99,45.35 235.95,45.62 235.59,46.12 231.35,49.09 228.27,49.64 211.26,49.64 206.15,53.21 202.25,53.9 200.04,53.9 198.24,53.58 197.61,53.14 196.95,52.68 196.06,52.68 v1(195.66,53.09) ; U1.M2 v4(87.36,65.13)
PE_SLOT2_TX_C_DP<11>: length 159.2
  IN1 w0.089: v4(86.36,65.13) 86.36,64.81 86.45,64.73 86.66,64.73 86.95,64.44 86.95,63.95 86.97,63.8 87.17,63.41 87.17,63.38 87.24,62.98 87.3,62.94 87.3,62.92
  IN1 w0.122: v1(195.66,49.91) 195.29,49.54 193.53,49.54 192.58,49.71 192.45,49.89 192.09,49.95 191.92,49.83 190.4,50.09 190.4,50.1 187.14,52.38 152.61,58.47 148.9,57.82 141.14,59.19 116.81,54.91 113.77,55.45 108.73,54.56 92.45,57.43 89.81,59.28 89.76,59.31 87.65,62.32 87.33,62.79 87.3,62.92
  BOTTOM w0.135: v1(195.66,49.91) 196.04,49.53 196.39,49.53 196.74,49.77 197.55,50.94 199.39,52.23 201.27,52.56 202.25,52.56 203.69,52.3 205.82,51.93 210.81,48.44 226.58,48.44 228.69,48.06 229.52,47.49 229.59,47.05 229.26,46.58 229.29,46.39 229.81,46.03 230,46.06 230.33,46.54 230.76,46.61 231.72,45.95 231.94,45.62 232.01,45.27 232.01,44.82 C62.1 ; U1.N2 v4(86.36,65.13)
PE_SLOT2_TX_C_DP<12>: length 155.1
  IN1 w0.089: 86.26,63.03 86.25,63.05 86.18,63.06 86.05,63.24 86.03,63.37 85.96,63.8 85.96,64.43 85.66,64.73 85.45,64.73 85.36,64.81 v4(85.36,65.13)
  IN1 w0.122: 86.26,63.03 89.23,58.8 92,56.86 108.81,53.89 113.74,54.76 116.7,54.24 140.93,58.5 148.9,57.09 152.81,57.78 186.72,51.8 191.08,48.75 196.43,47.81 196.97,47.9 197.18,48.05 197.32,48.26 197.38,48.56 197.38,49.26 197.67,49.55 197.96,49.55 v1(198.32,49.91)
  BOTTOM w0.135: v1(198.32,49.91) 198.66,49.58 199.12,49.58 199.64,49.95 200.06,50.54 200.69,50.99 201.98,51.21 202.66,51.1 202.72,51.08 205.43,50.61 210.25,47.23 223.72,47.23 225.91,46.85 227.82,45.7 227.99,45.28 227.99,44.82 C63.1 ; U1.P2 v4(85.36,65.13)
PE_SLOT2_TX_C_DP<13>: length 153.9
  IN1 w0.089: v4(84.36,65.13) 84.36,64.81 84.45,64.73 84.66,64.73 84.96,64.43 84.96,63.96 85.04,63.47 85.33,63.06 85.4,63.05 85.41,63.03
  IN1 w0.122: v1(201.12,49.78) 200.75,49.42 200.22,49.42 199.87,49.07 199.87,48.67 199.79,48.25 199.51,47.84 199.08,47.54 198.72,47.48 198.54,47.6 198.18,47.54 198.06,47.36 196.07,47.01 191.04,47.9 189.93,48.68 186.3,51.22 152.89,57.11 148.9,56.41 140.85,57.83 116.55,53.56 113.67,54.07 108.75,53.2 91.82,56.19 88.65,58.41 87.09,60.64 85.53,62.87 85.41,63.03
  BOTTOM w0.135: C64.1 224,44.82 224,45.15 223.73,45.54 223.14,45.95 222.89,46 222.67,46.03 222.01,46.03 221.69,45.72 221.69,44.73 221.52,44.55 220.96,44.55 220.8,44.71 220.8,45.72 220.48,46.03 209.87,46.03 205.33,49.21 204.23,49.4 201.5,49.4 v1(201.12,49.78) ; U1.R2 v4(84.36,65.13)
PE_SLOT2_TX_C_DP<14>: length 144.4
  IN1 w0.089: v4(83.36,65.13) 83.36,64.81 83.45,64.73 83.66,64.73 83.96,64.42 83.96,63.72 84.35,63.16 84.42,63.15 84.44,63.13
  IN1 w0.122: v1(201.12,46.74) 200.76,46.37 200.09,46.37 198.7,46.62 198.12,46.52 197.95,46.64 197.59,46.58 197.46,46.4 196.53,46.23 190.7,47.26 185.87,50.64 153.13,56.42 148.9,55.67 140.61,57.14 116.28,52.86 113.51,53.35 108.8,52.52 91.58,55.56 87.97,58.09 84.62,62.87 84.44,63.13
  BOTTOM w0.135: U1.T2 v4(83.36,65.13) ; C65.1 216.87,44.35 212.14,44.35 209.51,44.81 205.18,47.84 204.26,48.01 203.94,48.01 203.4,47.91 202.93,47.58 202.66,47.31 202.26,46.74 201.75,46.38 201.47,46.38 v1(201.12,46.74)
PE_SLOT2_TX_C_DP<15>: length 140.9
  IN1 w0.089: 83.7,63.03 83.68,63.05 83.61,63.06 83.49,63.24 82.96,64 82.96,64.42 82.66,64.73 82.45,64.73 82.36,64.81 v4(82.36,65.13)
  IN1 w0.122: v1(203.66,46.61) 203.3,46.25 202.9,46.25 202.53,45.89 202.4,45.14 202.11,44.73 201.42,44.61 200.46,44.78 200.12,44.54 200.08,44.31 199.94,44.21 199.56,44.27 199.46,44.42 199.5,44.65 199.26,44.99 190.63,46.51 185.6,50.04 153.14,55.76 148.9,55.02 140.59,56.48 116.22,52.2 113.47,52.68 108.7,51.84 91.35,54.9 87.51,57.59 83.81,62.87 83.7,63.03
  BOTTOM w0.135: C66.1 208.49,42.95 208.18,42.95 207.89,43 207.66,43.16 206.64,44.19 206.19,44.19 205.49,43.49 205.3,43.49 204.86,43.94 204.86,44.13 205.56,44.82 205.56,45.27 204.89,45.94 204.53,46.19 204.18,46.25 204.01,46.25 v1(203.66,46.61) ; U1.U2 v4(82.36,65.13)
PE_SLOT2_TX_DN<0>: length 6.4
  BOTTOM w0.135: C31.2 279.68,43.31 279.68,39.04 279.93,38.79 280.09,38.71 280.14,38.68 280.2,38.5 J2.B15
PE_SLOT2_TX_DN<1>: length 6.3
  BOTTOM w0.135: J2.B20 275.2,39.01 275.39,38.95 275.51,39.01 275.67,39.17 275.67,41.09 275.51,41.24 275.51,41.64 275.67,41.8 275.67,42.2 275.51,42.35 275.51,42.76 275.67,42.91 275.67,43.31 C32.2
PE_SLOT2_TX_DN<2>: length 6.3
  BOTTOM w0.135: C33.2 271.63,43.31 271.63,42.91 271.48,42.76 271.48,42.35 271.63,42.2 271.63,41.8 271.48,41.64 271.48,41.24 271.63,41.09 271.63,39.14 271.5,39.01 271.38,38.95 271.2,39.01 J2.B24
PE_SLOT2_TX_DN<3>: length 6.3
  BOTTOM w0.135: C34.2 267.67,43.31 267.67,42.91 267.51,42.76 267.51,42.35 267.67,42.2 267.67,41.8 267.51,41.64 267.51,41.24 267.67,41.09 267.67,39.18 267.51,39.01 267.38,38.95 267.2,39.01 J2.B28
PE_SLOT2_TX_DN<4>: length 6.3
  BOTTOM w0.135: J2.B34 261.2,39.01 261.38,38.95 261.51,39.01 261.7,39.21 261.7,41.09 261.54,41.24 261.54,41.64 261.7,41.8 261.7,42.2 261.54,42.35 261.54,42.76 261.7,42.91 261.7,43.31 C67.2
PE_SLOT2_TX_DN<5>: length 6.3
  BOTTOM w0.135: C68.2 257.68,43.31 257.68,42.91 257.53,42.76 257.53,42.35 257.68,42.2 257.68,41.8 257.53,41.64 257.53,41.24 257.68,41.09 257.68,39.17 257.55,39.04 257.38,38.95 257.38,38.95 257.2,39.01 J2.B38
PE_SLOT2_TX_DN<6>: length 6.3
  BOTTOM w0.135: C69.2 253.67,43.31 253.67,42.91 253.52,42.76 253.52,42.35 253.67,42.2 253.67,41.8 253.52,41.64 253.52,41.24 253.67,41.09 253.67,39.17 253.54,39.04 253.38,38.95 253.2,39.01 J2.B42
PE_SLOT2_TX_DN<7>: length 6.3
  BOTTOM w0.135: J2.B46 249.2,39.01 249.38,38.95 249.51,39.01 249.71,39.22 249.71,41.09 249.56,41.24 249.56,41.64 249.71,41.8 249.71,42.2 249.56,42.35 249.56,42.76 249.71,42.91 249.71,43.31 C70.2
PE_SLOT2_TX_DN<8>: length 6.4
  BOTTOM w0.135: J2.B51 244.2,38.5 244.14,38.68 244.14,38.68 243.96,38.77 243.69,39.04 243.69,43.31 C71.2
PE_SLOT2_TX_DN<9>: length 6.4
  BOTTOM w0.135: J2.B55 240.2,38.5 240.14,38.68 240.11,38.7 239.96,38.77 239.69,39.04 239.69,43.3 C72.2
PE_SLOT2_TX_DN<10>: length 6.4
  BOTTOM w0.135: C73.2 235.69,43.31 235.69,39.04 235.96,38.77 236.14,38.68 236.2,38.5 J2.B59
PE_SLOT2_TX_DN<11>: length 6.4
  BOTTOM w0.135: C74.2 231.69,43.33 231.69,39.05 231.95,38.79 232.13,38.7 232.2,38.5 J2.B63
PE_SLOT2_TX_DN<12>: length 6.4
  BOTTOM w0.135: J2.B67 228.2,38.5 228.14,38.69 227.99,38.76 227.69,39.06 227.69,43.31 C75.2
PE_SLOT2_TX_DN<13>: length 6.4
  BOTTOM w0.135: J2.B71 224.2,38.5 224.14,38.68 223.98,38.76 223.69,39.05 223.69,43.32 C76.2
PE_SLOT2_TX_DN<14>: length 8.1
  BOTTOM w0.135: J2.B75 220.2,38.5 220.14,38.68 219.96,38.77 219.69,39.04 219.69,41.9 219.53,42.06 219.53,42.46 219.69,42.61 219.69,43.02 219.62,43.39 219.35,43.78 218.93,44.07 218.41,44.07 C77.2
PE_SLOT2_TX_DN<15>: length 9.9
  BOTTOM w0.135: C78.2 210,42.65 210.53,42.65 211.06,42.55 211.39,42.32 211.43,42.11 211.76,41.88 211.97,41.91 212.97,41.22 214.09,41.02 214.65,41.02 214.97,40.96 215.59,40.34 215.59,40.34 215.65,40.02 215.65,39.07 215.93,38.78 216.14,38.68 216.2,38.5 J2.B79
PE_SLOT2_TX_DP<0>: length 6.3
  BOTTOM w0.135: C27.2 279.99,43.31 279.99,42.91 280.14,42.76 280.14,42.35 279.99,42.2 279.99,41.8 280.14,41.64 280.14,41.24 279.99,41.09 279.99,39.17 280.11,39.04 280.28,38.95 280.46,39.01 J2.B14
PE_SLOT2_TX_DP<1>: length 6.4
  BOTTOM w0.135: J2.B19 275.46,38.5 275.51,38.67 275.69,38.76 275.97,39.04 275.97,43.31 C28.2
PE_SLOT2_TX_DP<2>: length 6.4
  BOTTOM w0.135: C29.2 271.93,43.31 271.93,39.01 271.68,38.76 271.52,38.68 271.52,38.68 271.46,38.5 J2.B23
PE_SLOT2_TX_DP<3>: length 6.4
  BOTTOM w0.135: J2.B27 267.46,38.5 267.52,38.68 267.69,38.76 267.97,39.05 267.97,43.31 C30.2
PE_SLOT2_TX_DP<4>: length 6.4
  BOTTOM w0.135: C55.2 262,43.31 262,39.08 261.69,38.76 261.52,38.68 261.46,38.5 J2.B33
PE_SLOT2_TX_DP<5>: length 6.4
  BOTTOM w0.135: C56.2 257.99,43.31 257.99,39.04 257.73,38.79 257.52,38.68 257.46,38.5 J2.B37
PE_SLOT2_TX_DP<6>: length 6.4
  BOTTOM w0.135: C57.2 253.98,43.31 253.98,39.04 253.72,38.79 253.52,38.68 253.46,38.5 J2.B41
PE_SLOT2_TX_DP<7>: length 6.4
  BOTTOM w0.135: J2.B45 249.46,38.5 249.52,38.68 249.69,38.76 250.01,39.09 250.01,43.31 C58.2
PE_SLOT2_TX_DP<8>: length 6.3
  BOTTOM w0.135: C59.2 243.99,43.31 243.99,42.91 244.15,42.76 244.15,42.35 243.99,42.2 243.99,41.79 244.15,41.64 244.15,41.24 243.99,41.08 243.99,39.17 244.14,39.02 244.28,38.95 244.46,39.01 J2.B50
PE_SLOT2_TX_DP<9>: length 6.3
  BOTTOM w0.135: J2.B54 240.46,39.01 240.28,38.95 240.14,39.02 239.99,39.17 239.99,41.12 240.15,41.28 240.15,41.68 239.99,41.83 239.99,42.24 240.15,42.39 240.15,42.79 239.99,42.95 239.99,43.33 C60.2
PE_SLOT2_TX_DP<10>: length 6.3
  BOTTOM w0.135: J2.B58 236.46,39.01 236.28,38.95 236.14,39.02 235.99,39.17 235.99,41.09 236.15,41.24 236.15,41.64 235.99,41.8 235.99,42.2 236.15,42.35 236.15,42.76 235.99,42.91 235.99,43.31 C61.2
PE_SLOT2_TX_DP<11>: length 6.3
  BOTTOM w0.135: C62.2 231.99,43.3 231.99,42.9 232.15,42.74 232.15,42.34 231.99,42.19 231.99,41.78 232.15,41.63 232.15,41.23 231.99,41.07 231.99,39.18 232.13,39.04 232.3,38.96 232.46,39.01 J2.B62
PE_SLOT2_TX_DP<12>: length 6.3
  BOTTOM w0.135: C63.2 227.99,43.31 227.99,42.91 228.15,42.76 228.15,42.35 227.99,42.2 227.99,41.8 228.15,41.64 228.15,41.24 227.99,41.09 227.99,39.19 228.17,39.01 228.29,38.96 228.46,39.01 J2.B66
PE_SLOT2_TX_DP<13>: length 6.3
  BOTTOM w0.135: C64.2 223.99,43.3 223.99,42.9 224.15,42.75 224.15,42.34 223.99,42.19 223.99,41.78 224.15,41.63 224.15,41.23 223.99,41.07 223.99,39.18 224.16,39.01 224.28,38.95 224.46,39.01 J2.B70
PE_SLOT2_TX_DP<14>: length 8.1
  BOTTOM w0.135: C65.2 218.36,44.37 219.03,44.37 219.57,44 219.91,43.51 219.99,43.04 219.99,39.17 220.14,39.02 220.28,38.95 220.46,39.01 J2.B74
PE_SLOT2_TX_DP<15>: length 9.9
  BOTTOM w0.135: C66.2 210,42.95 210.56,42.95 211.18,42.84 213.09,41.51 214.12,41.33 214.68,41.33 215.12,41.25 215.87,40.49 215.95,40.05 215.95,39.19 216.11,39.03 216.28,38.95 216.46,39.01 J2.B78
PE_SLOT3_PRES_N: length 269.5
  TOP w0.127: v1(76.28,51.56) 75.9,51.94 75.9,53.59 75.39,54.1 R270.2
  IN2 w0.112: J3.A1 296.87,54.54 296.87,52.39 296.1,51.62 296.1,46.35 295.68,45.94 295.68,45.09 295.69,45.09 295.69,44.58 295.68,44.57 295.68,44.55 294.95,43.81 294.95,41.81 296.88,39.88 296.88,39.85 297,39.73 297,32.29 295.45,30.73 284.85,30.73 283.33,29.22 198.07,29.22 184.98,42.31 161.77,42.31 142.43,61.65 128.01,61.65 117.99,51.63 82.92,51.63 82.26,50.96 76.88,50.96 v1(76.28,51.56)
PE_SLOT3_RX_DN<0>: length 199.1
  IN3 w0.089: v4(95.36,88.13) 95.05,88.13 94.96,88.22 94.96,88.37 95.13,88.53 98.97,88.53 99.02,88.48 99.04,88.48
  IN3 w0.135: 99.04,88.48 99.96,88.48 102.74,86.54 103.7,86.37 105.59,86.7 108.43,86.2 111.4,86.72 114.54,86.17 116.96,86.6 119.27,86.19 120.87,86.47 146.8,81.9 149.11,82.31 208.47,71.84 210.49,72.2 212.79,71.79 215.06,72.19 221.17,71.11 223.89,71.59 242.88,68.24 253.36,70.09 264.5,68.13 264.61,67.97 265.01,67.9 265.17,68.01 265.57,67.94 265.68,67.78 266.08,67.71 266.24,67.82 266.63,67.75 266.75,67.59 267.14,67.52 267.3,67.63 268.85,67.36 269.19,67.12 269.51,66.66 269.68,65.69 269.91,65.36 269.88,65.17 270.11,64.84 270.3,64.8 270.87,64 271.28,63.71 271.99,63.58 272.1,63.42 272.5,63.35 272.66,63.47 273.06,63.4 273.18,63.22 273.58,63.15 273.76,63.27 274.4,63.16 274.73,62.93 274.76,62.74 275.09,62.51 275.28,62.54 275.62,62.31 275.65,62.12 275.98,61.89 276.17,61.92 276.5,61.69 276.54,61.5 276.87,61.26 277.06,61.3 277.65,60.88 277.73,60.78 277.73,59.26 arc(277.85,58.95) 278.16,58.82 278.46,58.82 arc(278.6,58.76) 278.67,58.61 278.67,54.98 278.51,54.83 278.39,54.76 278.2,54.82 J3.A17
  BOTTOM w0.135: U1.D24 v4(95.36,88.13)
PE_SLOT3_RX_DN<1>: length 197
  IN3 w0.089: v4(95.36,87.13) 95.05,87.13 94.98,87.2 94.98,87.37 95.14,87.53 99.12,87.53 99.16,87.48 99.19,87.48
  IN3 w0.135: J3.A22 273.2,54.33 273.14,54.51 272.96,54.6 272.67,54.89 272.67,58.77 arc(272.8,59.08) 273.12,59.22 273.6,59.22 arc(273.69,59.25) 273.73,59.35 273.73,60.76 273.4,61.24 272.86,61.61 272.12,61.75 271.94,61.62 271.54,61.69 271.42,61.87 269.85,62.14 269.52,62.38 269.31,62.34 268.98,62.57 268.94,62.78 268.61,63.02 268.4,62.98 268.06,63.21 268.03,63.42 267.7,63.65 267.48,63.62 267.15,63.85 267.11,64.06 266.26,64.66 266.07,64.63 265.91,64.39 265.46,64.31 265.06,64.59 264.98,65.04 265.16,65.29 265.13,65.47 264.8,65.7 264.73,66.12 265.15,66.72 265.11,66.9 264.88,67.07 264.69,67.03 264.27,66.44 263.83,66.36 263.54,66.57 263.11,67.18 262.63,67.51 252.59,69.28 242.86,67.57 223.93,70.91 221.21,70.43 215,71.52 212.74,71.12 210.44,71.53 208.47,71.18 149.18,81.63 146.87,81.23 120.92,85.8 119.25,85.51 116.89,85.92 114.43,85.49 111.34,86.03 108.43,85.52 105.59,86.02 103.69,85.69 102.44,85.91 100.2,87.48 99.19,87.48
  BOTTOM w0.135: U1.D23 v4(95.36,87.13)
PE_SLOT3_RX_DN<2>: length 190.4
  IN3 w0.089: v4(95.36,86.13) 95.05,86.13 94.98,86.2 94.98,86.37 95.16,86.54 98.99,86.54 99.04,86.49 99.06,86.49
  IN3 w0.135: J3.A26 269.2,54.33 269.14,54.51 268.99,54.58 268.68,54.89 268.68,58.78 arc(268.81,59.09) 269.12,59.22 269.58,59.22 arc(269.67,59.25) 269.7,59.33 269.7,60.8 269.56,61 268.86,61.49 268.65,61.45 268.31,61.68 268.28,61.9 267.95,62.13 267.73,62.09 267.4,62.32 267.36,62.54 266.21,63.34 265.59,63.45 265.43,63.34 265.03,63.41 264.92,63.57 264.52,63.64 264.36,63.53 263.97,63.6 263.85,63.76 261.12,64.24 260.16,64.91 259.61,65.69 259.44,66.68 259.11,67.15 258.6,67.51 252.44,68.59 242.81,66.9 223.93,70.23 221.21,69.75 215.01,70.84 212.79,70.45 210.49,70.86 208.53,70.51 149.23,80.97 146.83,80.54 120.97,85.13 120.22,85 119.23,84.83 116.87,85.24 114.27,84.79 111.19,85.33 108.39,84.84 105.55,85.34 103.7,85.01 102,85.31 100.49,86.37 99.77,86.49 99.06,86.49
  BOTTOM w0.135: U1.D22 v4(95.36,86.13)
PE_SLOT3_RX_DN<3>: length 189
  IN3 w0.089: 99.11,85.5 99.09,85.5 99.04,85.55 95.16,85.55 94.99,85.38 94.99,85.19 95.05,85.13 v4(95.36,85.13)
  IN3 w0.135: J3.A30 265.2,54.33 265.14,54.51 264.93,54.61 264.7,54.85 264.7,58.81 arc(264.64,58.93) 264.52,58.98 264.19,58.98 arc(263.86,59.11) 263.73,59.44 263.73,60.92 263.46,61.31 262.83,61.75 262.62,61.71 262.29,61.94 262.25,62.16 261.92,62.39 261.7,62.35 261.37,62.58 261.34,62.79 261.34,62.8 260.78,63.19 260.34,63.26 260.18,63.15 259.78,63.22 259.67,63.38 258.66,63.55 258.42,63.9 258.49,64.31 258.38,64.47 258.01,64.53 257.85,64.42 257.78,64.01 257.43,63.76 256.83,63.87 256.58,64.22 256.65,64.63 256.54,64.78 256.17,64.85 256.02,64.74 255.95,64.33 255.6,64.08 252.46,64.62 252.16,64.84 251.93,65.16 251.86,65.56 251.7,65.67 251.63,66.07 251.74,66.23 251.64,66.82 251.46,67.07 250.88,67.48 250.36,67.57 248.09,67.17 248.01,67.06 248.01,67.06 247.93,66.95 248.02,66.45 247.78,66.11 247.25,66.01 246.91,66.25 246.83,66.75 246.67,66.86 246.07,66.76 245.94,66.58 245.99,66.31 245.75,65.96 245.27,65.88 244.92,66.12 244.87,66.42 244.7,66.53 242.86,66.21 223.98,69.54 221.26,69.06 215.01,70.16 212.79,69.77 210.49,70.18 208.58,69.84 149.35,80.28 146.86,79.85 120.86,84.43 119.17,84.14 116.82,84.55 114.29,84.1 111.21,84.65 108.41,84.15 105.55,84.66 103.7,84.33 101.58,84.71 100.67,85.34 99.77,85.5 99.11,85.5
  BOTTOM w0.135: U1.D21 v4(95.36,85.13)
PE_SLOT3_RX_DN<4>: length 178.3
  IN3 w0.089: v4(95.36,84.13) 95.05,84.13 95,84.18 95,84.38 95.15,84.53 99.09,84.53 99.14,84.49 99.16,84.49
  IN3 w0.135: J3.A36 259.2,54.33 259.14,54.51 258.93,54.61 258.69,54.85 258.69,58.79 arc(258.82,59.09) 259.11,59.22 259.61,59.22 arc(259.69,59.25) 259.73,59.33 259.73,61 259.1,61.9 257.79,62.81 257.46,62.87 257.26,62.91 257.09,62.78 256.69,62.85 256.57,63.03 256.17,63.1 255.99,62.98 255.59,63.05 255.47,63.22 255.07,63.29 254.89,63.17 254.5,63.24 254.37,63.42 223.74,68.82 221.26,68.38 215,69.48 212.79,69.09 210.49,69.5 208.55,69.16 149.42,79.61 146.81,79.15 121,83.7 119.39,83.42 116.82,83.87 114.25,83.42 111.14,83.96 108.39,83.48 105.55,83.98 103.7,83.65 101.31,84.07 100.86,84.39 100.31,84.49 99.16,84.49
  BOTTOM w0.135: U1.D20 v4(95.36,84.13)
PE_SLOT3_RX_DN<5>: length 176.3
  IN3 w0.089: 99.13,83.48 99.11,83.48 99.06,83.53 95.14,83.53 94.99,83.37 94.99,83.19 95.05,83.13 v4(95.36,83.13)
  IN3 w0.135: J3.A40 255.2,54.33 255.14,54.51 254.93,54.61 254.71,54.84 254.71,58.77 arc(254.83,59.07) 255.13,59.19 255.56,59.19 arc(255.66,59.23) 255.7,59.32 255.7,60.59 255.63,60.96 255.44,61.24 254.62,61.81 254.41,61.78 254.07,62.01 254.04,62.22 253.28,62.75 252.88,62.82 252.7,62.7 252.31,62.77 252.18,62.94 251.78,63.01 251.61,62.89 251.21,62.96 251.09,63.14 229.03,67.03 227.02,66.67 226.23,66.81 225.99,67.16 226.06,67.56 225.94,67.73 225.69,67.78 225.54,67.67 225.46,67.25 225.1,66.99 224.61,67.08 224.35,67.44 224.43,67.86 224.32,68.02 224.07,68.06 223.92,67.95 223.85,67.56 223.48,67.3 214.96,68.8 212.78,68.41 210.48,68.82 208.61,68.49 149.41,78.93 146.78,78.46 121,83.04 119.34,82.75 116.82,83.19 114.3,82.74 111.22,83.29 108.42,82.79 105.5,83.31 103.41,82.94 100.34,83.48 99.13,83.48
  BOTTOM w0.135: U1.D19 v4(95.36,83.13)
PE_SLOT3_RX_DN<6>: length 169.7
  IN3 w0.089: 99.13,82.48 99.11,82.48 99.06,82.53 95.14,82.53 94.98,82.37 94.98,82.21 95.06,82.13 v4(95.36,82.13)
  IN3 w0.135: 99.13,82.48 101.77,82.48 103.24,82.22 105.53,82.62 108.44,82.11 110.51,82.48 110.51,82.48 111.24,82.61 114.3,82.07 116.83,82.51 119.34,82.07 120.87,82.34 146.76,77.77 149.34,78.23 208.56,67.78 210.49,68.12 212.79,67.72 212.79,67.74 214.85,68.08 226.7,65.99 227.02,65.99 228.91,66.32 245.61,63.38 245.73,63.22 246.12,63.15 246.28,63.26 246.68,63.19 246.79,63.03 247.19,62.96 247.35,63.07 247.75,63 247.87,62.83 248.27,62.76 248.45,62.88 249.14,62.76 251.49,61.11 251.71,60.8 251.71,59.35 arc(251.67,59.25) 251.57,59.22 251.11,59.22 arc(250.82,59.09) 250.69,58.79 250.69,54.85 250.93,54.61 251.14,54.51 251.2,54.33 J3.A44
  BOTTOM w0.135: U1.D18 v4(95.36,82.13)
PE_SLOT3_RX_DN<7>: length 167.5
  IN3 w0.089: v4(95.36,80.13) 95.05,80.13 94.96,80.22 94.96,80.51 95.18,80.72 95.71,80.72 95.76,80.67 95.78,80.67
  IN3 w0.135: J3.A48 247.2,54.33 247.14,54.51 246.93,54.61 246.68,54.87 246.68,58.8 arc(246.61,58.96) 246.45,59.03 246.15,59.03 arc(245.85,59.16) 245.72,59.46 245.72,60.66 245,61.7 243.8,62.54 243.16,62.65 242.99,62.52 242.59,62.59 242.46,62.77 242.07,62.84 241.89,62.72 241.49,62.79 241.37,62.97 240.97,63.04 240.79,62.91 240.39,62.98 240.27,63.16 239.87,63.23 239.7,63.1 239.3,63.17 239.17,63.35 237.63,63.62 237.02,63.52 235.25,63.83 235,64.18 235.05,64.43 234.94,64.59 234.57,64.65 234.41,64.54 234.37,64.29 234.02,64.04 233.41,64.15 233.17,64.5 233.21,64.75 233.1,64.91 232.73,64.97 232.58,64.86 232.53,64.61 232.18,64.37 231.58,64.47 231.34,64.82 231.38,65.08 231.27,65.23 230.9,65.3 230.75,65.19 230.7,64.94 230.35,64.69 229.75,64.8 229.5,65.15 229.55,65.4 229.44,65.56 229.07,65.62 228.91,65.51 228.87,65.26 228.45,64.97 214.75,67.38 212.84,67.05 211.66,67.26 210.54,67.45 208.61,67.11 149.42,77.55 146.67,77.07 120.84,81.65 119.34,81.39 116.78,81.84 114.26,81.39 111.26,81.92 108.45,81.43 105.62,81.93 102.88,81.45 102.01,81.6 99.52,81.16 96.74,80.67 95.78,80.67
  BOTTOM w0.135: U1.D17 v4(95.36,80.13)
PE_SLOT3_RX_DN<8>: length 160.1
  IN3 w0.089: v4(95.36,79.13) 95.05,79.13 94.96,79.22 94.96,79.34 95.15,79.54 98.81,79.54 98.86,79.49 98.88,79.49
  IN3 w0.135: 98.88,79.49 99.78,79.49 100.7,79.65 100.88,79.53 101.28,79.6 101.4,79.78 101.76,79.84 102.68,80.48 103.57,80.64 103.75,80.52 104.14,80.59 104.27,80.76 104.67,80.83 104.84,80.71 105.24,80.78 105.37,80.96 106.11,81.09 106.51,81.02 106.62,80.86 107.02,80.79 107.18,80.9 108.22,80.72 108.62,80.79 108.78,80.68 109.18,80.75 109.29,80.9 109.69,80.97 109.84,80.86 110.24,80.93 110.35,81.09 111.29,81.26 114.28,80.73 116.75,81.17 119.48,80.68 119.5,80.69 120.86,80.93 146.5,76.38 149.41,76.89 208.62,66.45 210.5,66.78 212.79,66.38 214.7,66.71 237.07,62.77 237.18,62.61 237.57,62.54 237.73,62.65 238.13,62.58 238.24,62.42 238.64,62.35 238.8,62.46 239.2,62.39 239.31,62.24 239.71,62.17 239.86,62.28 240.26,62.21 240.95,61.73 241.38,61.29 241.68,60.86 241.68,59.39 arc(241.82,59.06) 242.14,58.93 242.51,58.93 arc(242.63,58.88) 242.67,58.76 242.67,54.99 242.51,54.83 242.39,54.76 242.2,54.82 J3.A53
  BOTTOM w0.135: U1.D16 v4(95.36,79.13)
PE_SLOT3_RX_DN<9>: length 158
  IN3 w0.089: 97.27,78.49 97.25,78.49 97.2,78.54 95.15,78.54 94.96,78.35 94.96,78.22 95.05,78.13 v4(95.36,78.13)
  IN3 w0.135: 97.27,78.49 99.11,78.49 99.52,78.56 100.02,78.65 100.18,78.54 100.58,78.61 100.69,78.77 101.09,78.84 101.25,78.72 101.65,78.79 101.76,78.95 102.15,79.02 102.4,78.98 102.8,78.91 102.91,78.75 103.31,78.68 103.47,78.79 103.86,78.72 103.97,78.56 104.37,78.49 104.53,78.6 105.41,78.45 106.07,78.56 106.95,78.41 107.35,78.48 107.51,78.37 107.9,78.44 108.01,78.6 108.41,78.67 108.57,78.56 108.97,78.63 109.08,78.78 109.92,78.93 110.92,78.76 112.35,79.01 115.02,78.54 116.27,78.76 116.43,78.65 116.83,78.72 116.94,78.88 117.61,79 118.57,78.83 118.69,78.67 119.08,78.6 119.24,78.71 120.37,78.51 123.53,79.05 125.65,78.68 125.75,78.52 125.61,77.69 125.85,77.34 126.46,77.23 126.81,77.48 126.95,78.31 127.11,78.42 144.47,75.36 149.41,76.23 208.65,65.78 210.5,66.1 212.79,65.7 214.75,66.05 234.07,62.64 234.2,62.46 234.6,62.39 234.77,62.51 235.17,62.44 235.29,62.27 235.69,62.2 235.87,62.32 236.27,62.25 237.09,61.68 237.69,60.81 237.69,59.36 arc(237.82,59.05) 238.13,58.93 238.51,58.93 arc(238.64,58.88) 238.69,58.76 238.69,55 238.51,54.83 238.39,54.76 238.2,54.82 J3.A57
  BOTTOM w0.135: U1.D15 v4(95.36,78.13)
PE_SLOT3_RX_DN<10>: length 151.7
  IN3 w0.089: 97.25,77.49 97.23,77.49 97.18,77.54 95.15,77.54 94.96,77.34 94.96,77.22 95.05,77.13 v4(95.36,77.13)
  IN3 w0.135: J3.A61 234.2,54.82 234.38,54.76 234.51,54.83 234.67,54.99 234.67,58.76 arc(234.62,58.88) 234.5,58.93 234.1,58.93 arc(233.81,59.05) 233.68,59.35 233.68,60.77 233.12,61.57 232.04,62.32 231.65,62.39 231.49,62.28 231.09,62.35 230.98,62.51 230.58,62.58 230.42,62.47 230.02,62.54 229.91,62.7 229.52,62.77 229.36,62.66 228.96,62.73 228.85,62.89 228.45,62.96 228.29,62.85 227.89,62.92 227.78,63.08 214.72,65.38 212.46,64.98 210.27,65.37 208.75,65.1 150.02,75.45 140.59,73.79 123.09,76.89 121.75,76.66 119.24,77.1 116.72,76.65 114.64,77.02 112.51,76.65 110.83,76.94 109.45,76.7 108.33,76.9 107.86,76.81 107.75,76.66 107.35,76.59 107.19,76.7 106.79,76.63 106.31,76.71 106.15,76.6 105.75,76.67 105.64,76.83 105.24,76.9 104.2,76.72 103.65,76.81 103.49,76.7 103.09,76.77 102.98,76.93 102.58,77 102.42,76.89 102.02,76.96 101.91,77.12 101.51,77.19 101.36,77.08 100.96,77.15 100.85,77.31 99.83,77.49 97.25,77.49
  BOTTOM w0.135: U1.D14 v4(95.36,77.13)
PE_SLOT3_RX_DN<11>: length 149.3
  IN3 w0.089: v4(95.36,76.13) 95.05,76.13 94.96,76.22 94.96,76.34 95.15,76.54 97.18,76.54 97.23,76.49 97.25,76.49
  IN3 w0.135: J3.A65 230.2,54.82 230.38,54.76 230.51,54.83 230.68,55 230.68,58.79 arc(230.65,58.89) 230.55,58.93 230.13,58.93 arc(229.8,59.06) 229.67,59.39 229.67,60.71 229.43,61.05 228.26,61.87 228.07,61.83 227.74,62.07 227.7,62.26 227.37,62.49 226.86,62.58 226.7,62.47 226.3,62.54 226.19,62.7 225.79,62.77 225.63,62.66 225.23,62.73 225.12,62.88 214.78,64.71 212.42,64.29 210.21,64.68 208.67,64.41 150.85,74.6 138.9,72.5 128.11,74.42 127.37,74.29 126.51,74.44 125.71,74.58 125.56,74.48 125.46,73.94 125.18,73.74 124.59,73.85 124.38,74.15 124.47,74.65 124.36,74.8 122.37,75.15 121,74.72 118.37,75.18 115.52,74.68 113.34,75.07 111.73,74.78 111.11,74.89 110.95,74.78 110.55,74.85 110.44,75.01 110.04,75.08 109.31,74.95 108.51,75.09 108.35,74.98 107.95,75.05 107.84,75.21 107.44,75.28 106.56,75.13 106.45,74.97 106.05,74.9 105.9,75.01 105.5,74.94 105.39,74.78 104.99,74.71 104.83,74.82 104.46,74.76 104.41,74.76 103.78,74.87 103.62,74.76 103.22,74.83 103.11,74.99 102.23,75.14 101.61,75.58 101.39,75.54 101.06,75.77 101.03,75.98 100.79,76.15 99.52,76.37 98.85,76.49 97.25,76.49
  BOTTOM w0.135: U1.D13 v4(95.36,76.13)
PE_SLOT3_RX_DN<12>: length 144.7
  IN3 w0.089: 96.85,75.47 96.83,75.47 96.78,75.52 95.13,75.52 94.96,75.34 94.96,75.22 95.05,75.13 v4(95.36,75.13)
  IN3 w0.135: 96.85,75.47 98.15,75.47 99.52,75.23 99.72,75.19 100.82,74.42 100.86,74.23 101.19,74 101.38,74.03 101.71,73.8 101.74,73.61 102.07,73.38 102.26,73.41 102.59,73.18 102.59,73.17 102.97,72.9 103.7,72.78 105.58,73.11 107.93,72.69 110.51,73.15 112.13,72.86 113.77,73.15 114.69,72.99 115.74,73.17 118.14,72.75 120.62,73.19 123.59,72.66 125.27,72.96 126.9,72.67 128.97,73.04 138.13,71.42 151.44,73.77 208.62,63.69 210.19,63.96 212.4,63.57 214.93,64.02 215.34,63.95 215.45,63.79 215.85,63.72 216.01,63.83 216.41,63.76 216.52,63.6 216.91,63.53 217.07,63.64 217.47,63.57 217.58,63.41 217.98,63.34 218.14,63.45 218.54,63.38 218.65,63.23 219.05,63.16 219.2,63.27 219.6,63.2 219.71,63.04 220.11,62.97 220.27,63.08 220.67,63.01 220.78,62.85 221.18,62.78 221.34,62.89 221.73,62.82 221.84,62.66 222.24,62.59 222.4,62.7 222.8,62.63 222.91,62.47 223.31,62.4 223.47,62.52 224.58,62.32 225.12,61.94 225.68,61.13 225.68,59.36 arc(225.81,59.05) 226.11,58.93 226.54,58.93 arc(226.63,58.89) 226.67,58.79 226.67,54.99 226.51,54.83 226.38,54.76 226.2,54.82 J3.A69
  BOTTOM w0.135: U1.D12 v4(95.36,75.13)
PE_SLOT3_RX_DN<13>: length 143.3
  IN3 w0.089: v4(95.36,74.13) 95.05,74.13 94.96,74.22 94.96,74.34 95.14,74.52 96.85,74.52 96.9,74.48 96.92,74.48
  IN3 w0.135: J3.A73 222.2,54.82 222.38,54.76 222.51,54.83 222.66,54.97 222.66,58.79 arc(222.62,58.89) 222.52,58.93 222.06,58.93 arc(221.77,59.05) 221.64,59.35 221.64,60.79 221.08,61.59 220.37,62.09 219.95,62.16 219.79,62.05 219.4,62.12 219.29,62.28 218.89,62.35 218.73,62.24 218.33,62.31 218.22,62.47 217.82,62.54 217.66,62.42 217.27,62.49 217.15,62.65 215.78,62.9 215.62,62.79 215.22,62.86 215.11,63.01 214.23,63.17 213.52,63.04 213.41,62.88 213.01,62.81 212.85,62.92 212.46,62.85 212.06,62.92 211.9,62.81 211.5,62.88 211.39,63.04 210.2,63.25 208.7,62.99 152.18,72.95 137.52,70.37 129.46,71.79 128.2,71.56 128.06,71.37 128.12,71.07 127.87,70.72 127.39,70.63 127.04,70.88 126.98,71.2 126.83,71.31 125.63,71.1 122.96,71.57 121.25,71.27 121.14,71.11 121.23,70.6 120.98,70.25 120.38,70.14 120.03,70.39 119.94,70.9 119.78,71.01 118.91,70.86 117.98,71.02 117.82,70.91 117.42,70.98 117.31,71.14 116.91,71.21 115.55,70.97 115.02,71.06 114.86,70.95 114.46,71.02 114.35,71.18 113.95,71.25 112.7,71.03 111.2,71.29 109.22,70.94 107.49,71.25 106.08,71 104.97,71.2 103.42,70.92 102.95,71 102.53,71.18 102.09,71.49 101.86,71.82 101.65,71.85 101.42,72.18 101.45,72.4 101.08,72.93 100.71,73.46 99.65,74.2 99.52,74.22 98.09,74.48 96.92,74.48
  BOTTOM w0.135: U1.D11 v4(95.36,74.13)
PE_SLOT3_RX_DN<14>: length 137
  IN3 w0.089: 96.87,73.49 96.85,73.49 96.8,73.53 95.15,73.53 94.96,73.34 94.96,73.22 95.05,73.13 v4(95.36,73.13)
  IN3 w0.135: J3.A77 218.2,54.82 218.38,54.76 218.51,54.83 218.7,55.01 218.7,58.79 arc(218.66,58.89) 218.56,58.93 218.1,58.93 arc(217.8,59.05) 217.68,59.35 217.68,60.61 217.41,60.99 217.08,61.23 216.64,61.3 216.46,61.18 216.06,61.25 215.94,61.43 215.54,61.5 215.37,61.37 214.97,61.44 214.84,61.62 209.84,62.5 208.46,62.26 152.61,72.11 135.95,69.17 129.95,70.24 125.79,69.5 123.49,69.91 118.36,69 118.31,69 116.61,69.32 114.5,68.95 114.01,69.04 113.85,68.93 113.45,69 113.34,69.16 112.94,69.23 112.78,69.11 112.39,69.19 112.27,69.34 111.88,69.41 110.4,69.15 110.29,69 109.89,68.93 109.73,69.04 109.34,68.97 107.88,69.22 107.73,69.11 107.33,69.18 107.22,69.34 106.82,69.41 105.29,69.14 105.18,68.98 104.78,68.91 104.62,69.02 104.23,68.95 103.14,68.95 102.22,69.6 101.42,70.74 101.21,70.77 100.98,71.1 101.02,71.32 100.78,71.65 100.57,71.69 100.34,72.02 100.38,72.23 100.15,72.56 99.21,73.22 97.69,73.49 96.87,73.49
  BOTTOM w0.135: U1.D10 v4(95.36,73.13)
