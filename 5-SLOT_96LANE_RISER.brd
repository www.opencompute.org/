# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT5_RX_DP<2>: length 246.6
  IN3 w0.089: 63.69,92.5 63.71,92.5 63.76,92.55 67.67,92.55 67.96,92.84 67.96,93.04 68.05,93.13 v4(68.36,93.13)
  IN3 w0.135: J9.A25 269.45,95.46 269.27,95.4 269.1,95.49 268.94,95.65 268.94,99.36 arc(269,99.51) 269.15,99.57 269.61,99.57 arc(269.91,99.69) 270.03,99.99 270.03,101.51 269.63,102.08 269.14,102.43 263.53,103.42 260.41,105.6 260.08,106.06 259.82,107.54 259.52,107.98 259.01,108.33 250.37,109.85 244.23,108.77 229.58,111.34 227.95,111.05 215.63,113.23 198.43,110.2 187.49,102.54 183.99,101.92 183.99,101.92 172.91,99.96 132.62,107.07 124.89,112.48 111.74,114.8 107.9,114.12 105.39,114.56 100.16,113.64 92.96,114.91 82.69,113.1 81.53,113.3 70.37,111.33 65.96,108.25 62.37,103.12 61.77,99.75 61.96,98.7 61.59,96.61 62.08,93.85 62.45,93.32 62.8,92.82 63.17,92.56 63.2,92.56 63.53,92.5 63.69,92.5
  BOTTOM w0.135: U1.AK29 v4(68.36,93.13)
PE_SLOT5_RX_DP<3>: length 244.2
  IN3 w0.089: v4(68.36,94.13) 68.05,94.13 67.96,94.04 67.96,93.84 67.67,93.55 63.86,93.55 63.82,93.5 63.79,93.5
  IN3 w0.135: J9.A29 265.45,95.46 265.27,95.4 265.1,95.49 264.95,95.64 264.95,99.35 arc(264.77,99.78) 264.34,99.96 264.21,99.96 arc(264.05,100.02) 263.99,100.17 263.99,101.47 263.91,101.94 263.62,102.35 261.66,103.72 260.74,103.89 260.74,103.89 258.21,104.33 256.49,105.54 255.75,106.58 255.58,107.55 255.25,108.03 254.72,108.4 250.3,109.18 244.18,108.1 229.72,110.63 227.83,110.29 215.51,112.47 200.49,109.82 200.26,109.66 200.09,109.54 200.08,109.54 199.73,109.29 199.71,109.27 198.97,108.76 198.79,108.79 198.57,109.1 198.15,109.17 197.65,108.82 197.57,108.4 197.79,108.09 197.76,107.9 197.45,107.69 197.26,107.72 197.05,108.03 196.63,108.1 196.12,107.75 196.05,107.33 196.26,107.02 196.23,106.84 195.93,106.62 195.74,106.66 195.52,106.96 195.1,107.04 194.6,106.69 194.52,106.26 194.74,105.96 194.71,105.77 194.4,105.55 194.21,105.59 194,105.9 193.58,105.97 193.07,105.62 193,105.2 193.22,104.89 193.18,104.7 192.88,104.49 192.69,104.52 192.47,104.83 192.05,104.9 191.55,104.55 191.48,104.13 191.69,103.82 191.66,103.64 191.35,103.42 191.17,103.45 190.95,103.76 190.53,103.84 190.03,103.48 189.95,103.06 190.17,102.76 190.13,102.57 189.65,102.23 172.99,99.29 132.37,106.45 124.63,111.86 111.74,114.14 107.9,113.46 105.39,113.9 100.16,112.98 92.97,114.25 87.22,113.24 82.65,112.43 82.17,112.51 81.59,112.62 70.6,110.68 66.98,108.14 65.87,106.55 65.42,104.02 63.29,100.98 62.51,96.56 62.84,94.68 62.84,94.68 62.96,94.05 63.19,93.71 63.2,93.71 63.49,93.5 63.79,93.5
  BOTTOM w0.135: U1.AK30 v4(68.36,94.13)
PE_SLOT5_RX_DP<4>: length 227.1
  IN3 w0.089: v4(69.36,94.13) 69.36,94.45 69.28,94.54 69.07,94.54 68.78,94.83 68.78,98.6 68.73,98.64 68.73,98.67
  IN3 w0.135: J9.A35 259.45,95.46 259.27,95.4 259.1,95.49 258.95,95.64 258.95,99.43 arc(258.99,99.53) 259.09,99.57 259.57,99.57 arc(259.87,99.69) 260,99.99 260,101.42 259.45,102.2 258.96,102.68 258.29,103.16 254.52,103.82 252.72,105.08 252.03,106.06 251.8,107.41 251.41,107.97 250.93,108.3 250.1,108.45 244.13,107.39 229.71,109.94 227.73,109.59 215.33,111.77 200.75,109.2 189.79,101.53 173.14,98.6 132.11,105.83 124.37,111.25 111.74,113.48 107.9,112.8 105.39,113.24 100.16,112.32 92.96,113.59 82.59,111.76 82.14,111.84 81.58,111.94 70.87,110.05 67.71,107.83 66.53,106.15 66.02,103.28 66.3,101.67 67.26,100.3 68.46,99.46 68.48,99.44 68.67,99.17 68.73,98.83 68.73,98.67
  BOTTOM w0.135: U1.AJ30 v4(69.36,94.13)
PE_SLOT5_RX_DP<5>: length 224.6
  IN3 w0.089: v4(70.36,94.13) 70.36,94.45 70.28,94.54 70.07,94.54 69.76,94.84 69.76,98.83 69.71,98.88 69.71,98.9
  IN3 w0.135: 69.71,98.9 69.71,99.01 69.66,99.31 69.57,99.44 69.37,99.72 67.72,100.87 66.96,101.96 66.8,102.84 67.39,106.19 67.8,106.77 71.76,109.54 81.54,111.27 82.54,111.09 92.96,112.93 100.16,111.66 105.39,112.58 107.9,112.14 111.74,112.81 124.12,110.63 131.87,105.21 173.15,97.93 190.29,100.96 201.24,108.63 215.34,111.11 227.73,108.93 229.71,109.28 244.15,106.73 245.86,107.03 246.32,106.95 246.71,106.68 247.33,105.79 247.56,105.63 247.75,105.67 247.87,105.85 248.29,105.93 248.8,105.58 248.87,105.16 248.75,104.97 248.78,104.79 248.93,104.68 249.09,104.57 249.23,104.6 249.99,105.68 250.41,105.75 250.91,105.4 250.99,104.94 250.3,103.95 250.34,103.73 250.82,103.39 255.3,102.6 255.74,102.29 256.01,101.92 256.01,100.03 arc(255.87,99.7) 255.55,99.57 255.14,99.57 arc(255.02,99.52) 254.97,99.4 254.97,95.62 255.1,95.49 255.27,95.4 255.45,95.46 J9.A39
  BOTTOM w0.135: U1.AH30 v4(70.36,94.13)
PE_SLOT5_RX_DP<6>: length 214.6
  IN3 w0.089: v4(71.36,94.13) 71.36,94.45 71.28,94.54 71.07,94.54 70.76,94.85 70.76,98.98 70.71,99.03 70.71,99.05
  IN3 w0.135: J9.A43 251.45,95.46 251.27,95.4 251.1,95.49 250.95,95.64 250.95,99.41 arc(251,99.52) 251.11,99.57 251.57,99.57 arc(251.87,99.69) 252,99.99 252,101.55 251.5,102.05 246.29,105.69 229.71,108.61 227.61,108.24 215.21,110.43 201.49,108.01 190.47,100.29 173.21,97.25 131.62,104.58 123.86,110.02 111.74,112.15 107.9,111.48 105.39,111.92 100.16,111 92.96,112.27 82.49,110.42 81.53,110.59 73.81,109.23 70.2,106.7 68.55,104.35 68,103.96 67.63,103.43 67.54,102.94 67.65,102.3 68.24,101.47 68.28,101.44 68.28,101.44 70.32,100.01 70.64,99.55 70.66,99.44 70.71,99.19 70.71,99.05
  BOTTOM w0.135: U1.AG30 v4(71.36,94.13)
PE_SLOT5_RX_DP<7>: length 213.9
  IN3 w0.089: 71.72,98.95 71.72,98.93 71.77,98.88 71.77,94.84 72.07,94.54 72.28,94.54 72.36,94.45 v4(72.36,94.13)
  IN3 w0.135: 71.72,98.95 71.72,99.35 71.66,99.44 70.81,100.66 70.07,101.18 69.39,102.14 69.25,102.93 69.35,103.46 69.68,103.93 70.47,104.49 72.09,106.8 74.85,108.73 81.53,109.91 82.44,109.75 92.96,111.61 100.15,110.34 105.39,111.26 107.9,110.82 111.74,111.49 123.61,109.4 131.37,103.96 173.22,96.59 190.73,99.68 201.69,107.35 214.75,109.65 229.87,106.99 230.02,107.1 230.1,107.56 230.45,107.8 231.06,107.69 231.3,107.34 231.22,106.89 231.33,106.73 231.7,106.67 231.86,106.77 231.94,107.23 232.29,107.48 232.89,107.37 233.14,107.02 233.05,106.56 233.16,106.41 233.53,106.34 233.69,106.45 233.77,106.91 234.12,107.15 234.72,107.05 234.97,106.7 234.89,106.24 235,106.08 235.36,106.02 235.52,106.13 235.6,106.58 235.95,106.83 236.55,106.72 236.8,106.37 236.72,105.92 236.83,105.76 237.2,105.69 237.35,105.8 237.43,106.26 237.78,106.51 238.39,106.4 238.63,106.05 238.55,105.59 238.66,105.44 239.03,105.37 239.18,105.48 239.27,105.94 239.62,106.18 240.22,106.08 240.47,105.72 240.38,105.27 240.49,105.11 242.81,104.7 245.2,103.03 245.84,102.12 245.98,101.35 245.98,100.1 arc(246.02,99.98) 246.14,99.93 246.49,99.93 arc(246.84,99.78) 246.99,99.43 246.99,95.6 247.1,95.49 247.27,95.4 247.45,95.46 J9.A47
  BOTTOM w0.135: U1.AF30 v4(72.36,94.13)
PE_SLOT5_RX_DP<8>: length 199.9
  IN3 w0.089: v4(73.36,94.13) 73.36,94.45 73.28,94.54 73.07,94.54 72.76,94.84 72.76,98.85 72.72,98.9 72.72,98.92
  IN3 w0.135: 72.72,98.92 72.72,99.52 72.64,99.94 71.32,101.84 71.17,102.66 71.31,103.48 71.6,103.89 72.42,104.46 72.92,105.17 73.1,106.22 73.29,106.49 75.75,108.21 75.82,108.22 81.58,109.24 82.44,109.09 92.95,110.94 100.15,109.67 105.39,110.6 107.9,110.16 111.74,110.83 123.35,108.78 131.11,103.35 173.18,95.91 190.98,99.06 201.89,106.7 214.74,108.97 223.57,107.41 227.32,106.75 227.32,106.75 228.62,106.52 237.88,104.89 241.35,102.46 241.8,101.82 241.92,101.14 241.92,99.99 arc(241.96,99.89) 242.05,99.86 242.54,99.86 arc(242.84,99.73) 242.96,99.43 242.96,95.51 242.68,95.23 242.51,95.15 242.51,95.15 242.45,94.97 J9.A52
  BOTTOM w0.135: U1.AE30 v4(73.36,94.13)
PE_SLOT5_RX_DP<9>: length 197.5
  IN3 w0.089: 73.73,97.15 73.73,97.12 73.78,97.07 73.78,94.83 74.07,94.54 74.28,94.54 74.36,94.45 v4(74.36,94.13)
  IN3 w0.135: 73.73,97.15 73.73,97.69 73.84,98.3 73.18,102.06 73.1,102.51 73.31,103.74 73.48,103.98 74.87,104.96 75.09,106.22 75.43,106.7 76.91,107.74 76.98,107.75 81.53,108.55 82.33,108.41 92.95,110.28 100.15,109.01 105.39,109.94 107.9,109.5 111.73,110.17 123.09,108.17 130.9,102.71 173.18,95.25 191.32,98.46 202.18,106.06 214.38,108.21 222.05,106.86 224.73,106.39 224.73,106.39 225.25,106.3 232.47,105.02 232.71,104.67 232.6,104.03 232.71,103.88 233.08,103.81 233.23,103.92 233.35,104.56 233.7,104.81 234.3,104.7 234.54,104.35 234.43,103.71 234.54,103.55 234.91,103.49 235.06,103.6 235.18,104.24 235.53,104.48 236.73,104.27 237.3,103.87 237.78,103.18 237.96,102.21 237.96,100 arc(238,99.9) 238.1,99.86 238.55,99.86 arc(238.85,99.73) 238.97,99.43 238.97,95.52 238.68,95.23 238.51,95.15 238.51,95.15 238.45,94.97 J9.A56
  BOTTOM w0.135: U1.AD30 v4(74.36,94.13)
PE_SLOT5_RX_DP<10>: length 187
  IN3 w0.089: v4(75.36,94.13) 75.36,94.45 75.28,94.54 75.07,94.54 74.77,94.84 74.77,96.95 74.72,97 74.72,97.02
  IN3 w0.135: 74.72,97.02 74.72,100.44 75.23,103.32 75.83,104.19 76.41,104.6 76.83,105.19 77.01,106.19 77.42,106.78 78.12,107.27 78.19,107.28 81.53,107.87 82.29,107.74 92.95,109.62 100.15,108.35 105.38,109.28 107.9,108.83 111.74,109.51 122.84,107.55 130.64,102.09 173.39,94.55 191.42,97.73 202.44,105.45 213.98,107.48 229.98,104.66 233.51,102.19 233.94,101.57 233.94,99.99 arc(233.98,99.89) 234.08,99.86 234.5,99.86 arc(234.83,99.72) 234.96,99.4 234.96,95.51 234.68,95.23 234.51,95.15 234.51,95.15 234.45,94.97 J9.A60
  BOTTOM w0.135: U1.AC30 v4(75.36,94.13)
PE_SLOT5_RX_DP<11>: length 185.3
  IN3 w0.089: v4(76.36,94.13) 76.36,94.45 76.28,94.54 76.07,94.54 75.79,94.82 75.79,97.02 75.74,97.07 75.74,97.09
  IN3 w0.135: J9.A64 230.45,94.97 230.51,95.15 230.51,95.15 230.68,95.23 230.99,95.54 230.99,99.42 arc(230.86,99.73) 230.56,99.86 230.09,99.86 arc(230,99.89) 229.96,99.99 229.96,101.57 229.86,102.12 229.59,102.6 228.83,103.69 228.3,103.96 228.3,103.96 228.25,103.98 215.13,106.29 212.67,105.86 212.51,105.97 212.47,106.19 212.12,106.43 211.52,106.33 211.27,105.98 211.31,105.76 211.2,105.6 210.83,105.53 210.68,105.64 210.64,105.86 210.29,106.11 209.68,106 209.44,105.65 209.48,105.43 209.37,105.28 209,105.21 208.84,105.32 208.81,105.54 208.46,105.79 207.85,105.68 207.61,105.33 207.65,105.11 207.54,104.95 207.17,104.89 207.01,105 206.97,105.22 206.62,105.46 206.02,105.36 205.77,105.01 205.81,104.79 205.7,104.63 205.34,104.56 205.18,104.67 205.14,104.89 204.79,105.14 204.19,105.03 203.94,104.68 203.98,104.46 203.87,104.31 201.3,103.86 191.61,97.07 173.48,93.87 130.38,101.47 122.57,106.94 111.74,108.85 107.9,108.17 105.42,108.61 100.19,107.69 92.96,108.96 82.24,107.07 81.53,107.2 80.8,107.07 80.8,107.07 79.43,106.83 79.15,106.62 78.83,106.18 78.65,105.13 78.22,104.52 77.54,104.04 76.27,102.23 75.77,99.44 75.74,99.23 75.74,97.09
  BOTTOM w0.135: U1.AB30 v4(76.36,94.13)
PE_SLOT5_RX_DP<12>: length 174.8
  IN3 w0.089: v4(77.36,94.13) 77.36,94.45 77.28,94.54 77.07,94.54 76.77,94.83 76.77,96.95 76.73,97 76.73,97.02
  IN3 w0.135: J9.A68 226.45,94.97 226.51,95.15 226.51,95.15 226.68,95.23 226.98,95.53 226.98,99.41 arc(226.85,99.72) 226.53,99.86 226.08,99.86 arc(225.98,99.89) 225.94,99.99 225.94,102.24 225.26,103.21 224.32,103.87 214.74,105.56 201.63,103.25 191.9,96.44 173.53,93.2 130.13,100.85 122.31,106.32 111.74,108.19 107.88,107.51 105.41,107.95 100.19,107.02 93.04,108.28 82.1,106.35 81.07,105.63 81.03,105.6 80.56,104.93 80.15,104.35 79.47,103.87 76.96,100.29 76.81,99.44 76.73,98.94 76.73,97.02
  BOTTOM w0.135: U1.AA30 v4(77.36,94.13)
PE_SLOT5_RX_DP<13>: length 172.4
  IN3 w0.089: 77.72,96.89 77.72,96.87 77.77,96.82 77.77,94.84 78.07,94.54 78.28,94.54 78.36,94.45 v4(78.36,94.13)
  IN3 w0.135: 77.72,96.89 77.72,98.22 77.86,99.03 78.15,99.44 81.04,103.58 82.21,104.39 83.88,104.69 85.53,105.84 86.39,106.45 93.05,107.62 100.19,106.36 105.42,107.28 107.88,106.85 111.74,107.53 122,105.72 129.8,100.25 173.58,92.53 192.41,95.86 202.08,102.63 214.06,104.74 217.12,104.2 217.37,103.85 217.27,103.33 217.39,103.16 217.76,103.1 217.9,103.2 218,103.74 218.35,103.99 218.8,103.91 219.57,103.37 219.64,102.95 219.02,102.06 219.05,101.88 219.36,101.66 219.56,101.7 220.18,102.58 220.95,102.72 221.57,102.28 221.93,101.77 221.93,100.08 arc(222,99.92) 222.16,99.86 222.59,99.86 arc(222.91,99.73) 223.04,99.41 223.04,95.59 222.68,95.23 222.51,95.15 222.51,95.15 222.45,94.97 J9.A72
  BOTTOM w0.135: U1.Y30 v4(78.36,94.13)
PE_SLOT5_RX_DP<14>: length 162.3
  IN3 w0.089: v4(79.36,94.13) 79.36,94.45 79.28,94.54 79.07,94.54 78.77,94.84 78.77,96.72 78.72,96.77 78.72,96.79
  IN3 w0.135: 78.72,96.79 78.72,97.39 78.91,98.49 81.15,101.68 82.4,102.56 82.41,102.57 83.04,103.47 83.43,103.74 84.49,103.93 86.26,105.17 87.03,105.71 93.58,106.87 100.18,105.7 105.42,106.62 107.88,106.19 111.69,106.86 121.7,105.1 129.51,99.63 173.56,91.86 192.66,95.23 201.89,101.7 214.26,103.88 215.51,103.66 217.61,102.19 217.97,101.68 217.97,99.99 arc(218.01,99.89) 218.1,99.86 218.54,99.86 arc(218.83,99.73) 218.96,99.43 218.96,95.51 218.68,95.23 218.51,95.15 218.51,95.15 218.45,94.97 J9.A76
  BOTTOM w0.135: U1.W30 v4(79.36,94.13)
PE_SLOT5_RX_DP<15>: length 160.8
  IN3 w0.089: v4(80.36,94.13) 80.36,94.45 80.28,94.54 80.07,94.54 79.78,94.83 79.78,96.85 79.73,96.89 79.73,96.92
  IN3 w0.135: J9.A80 214.45,94.97 214.51,95.15 214.72,95.25 214.94,95.47 214.94,99.31 arc(214.81,99.64) 214.48,99.78 214.06,99.78 arc(213.97,99.82) 213.93,99.91 213.93,101.36 213.49,101.99 212.84,102.44 211.35,102.7 204.73,101.54 202.51,101.15 197.16,97.4 197.09,96.97 197.65,96.16 197.62,95.98 197.31,95.76 197.12,95.79 196.56,96.6 196.14,96.67 195.64,96.32 195.56,95.9 196.12,95.1 196.09,94.91 195.78,94.69 195.6,94.73 195.31,95.13 195.03,95.53 194.61,95.61 193.27,94.67 173.57,91.2 129.25,99.01 121.45,104.48 111.69,106.2 107.88,105.53 105.42,105.96 100.18,105.04 93.73,106.18 87.95,105.16 87.89,105.15 81.68,100.8 81.63,100.78 81.62,100.76 80.7,99.44 79.83,98.21 79.73,97.64 79.73,96.92
  BOTTOM w0.135: U1.V30 v4(80.36,94.13)
PE_SLOT5_TX_C_DN<0>: length 243.4
  IN1 w0.089: v4(64.36,91.13) 64.68,91.13 64.77,91.04 64.77,90.92 64.58,90.73 63.62,90.73 63.31,90.78 63.27,90.84 63.25,90.85
  IN1 w0.122: v1(275.03,106.93) 275.39,107.29 275.39,107.82 275.16,108.14 270.83,111.17 270.24,111.27 270.06,111.15 269.7,111.21 269.57,111.39 269.21,111.45 269.04,111.33 268.68,111.39 268.55,111.57 268.19,111.64 268.01,111.51 267.65,111.57 267.53,111.75 267.17,111.82 266.99,111.69 266.63,111.75 266.51,111.93 266.15,112 265.97,111.87 265.61,111.93 265.49,112.11 250.07,114.83 212.85,108.27 212.84,108.27 175.52,101.69 148.9,106.38 148.85,106.39 140.35,107.89 134,106.77 87.75,114.93 70.05,111.8 65.65,108.76 64,107.52 60.94,103.15 60.68,101.66 60.8,101.48 60.74,101.12 60.56,101 60.5,100.64 60.62,100.46 60.56,100.1 60.38,99.97 60.32,99.61 60.44,99.44 60.38,99.08 60.2,98.95 60.12,98.48 60.27,97.61 60.45,97.49 60.51,97.13 60.39,96.95 60.45,96.59 60.63,96.46 60.69,96.1 60.57,95.93 60.63,95.57 60.81,95.44 60.87,95.08 60.75,94.91 60.81,94.54 60.99,94.42 61.05,94.06 60.93,93.88 60.99,93.52 61.17,93.4 61.23,93.04 61.11,92.86 61.21,92.32 61.95,91.25 62.29,91.01 63.2,90.85 63.25,90.85
  BOTTOM w0.135: v1(275.03,106.93) 275.39,106.58 275.39,105.78 C199.1 ; U1.AP27 v4(64.36,91.13)
PE_SLOT5_TX_C_DN<1>: length 243.7
  IN1 w0.089: v4(64.36,92.13) 64.68,92.13 64.77,92.04 64.77,91.94 64.55,91.72 63.58,91.72 63.3,91.75 63.25,91.81 63.23,91.81
  IN1 w0.122: 63.23,91.81 63.2,91.82 62.93,91.85 62.32,92.28 61.96,92.8 61.88,93.22 62.01,93.4 61.94,93.76 61.76,93.89 61.7,94.25 61.83,94.42 61.76,94.78 61.58,94.91 61.48,95.48 61.61,95.66 61.54,96.02 61.37,96.15 61.3,96.51 61.43,96.68 61.36,97.04 61.19,97.17 60.99,98.3 61.05,98.68 61.23,98.8 61.3,99.16 61.17,99.34 61.23,99.7 61.41,99.83 61.48,100.19 61.35,100.36 61.86,103.23 64.59,107.13 70.34,111.17 77.7,112.47 85.56,113.86 87.64,114.22 133.81,106.08 140.16,107.2 148.85,105.67 148.85,105.67 148.9,105.66 175.57,100.96 180.19,101.77 249.79,114.05 250.43,113.93 250.52,113.79 250.45,113.38 250.69,113.04 251.31,112.93 251.65,113.17 251.72,113.58 251.86,113.68 252.24,113.61 252.34,113.47 252.27,113.06 252.51,112.72 253.13,112.61 253.47,112.85 253.54,113.26 253.68,113.36 254.06,113.29 254.16,113.15 254.09,112.74 254.32,112.4 254.94,112.29 255.28,112.53 255.36,112.94 255.5,113.04 255.88,112.97 255.98,112.83 255.9,112.42 256.14,112.08 256.76,111.97 257.1,112.21 257.17,112.62 257.31,112.72 257.69,112.65 257.79,112.51 257.72,112.1 257.96,111.76 258.58,111.65 258.92,111.89 258.99,112.3 259.13,112.4 260.32,112.19 260.44,112.01 260.8,111.95 260.98,112.07 261.34,112.01 261.46,111.83 261.82,111.77 262,111.89 262.36,111.83 262.48,111.65 262.84,111.59 263.02,111.71 263.38,111.65 263.51,111.47 263.87,111.41 264.04,111.53 264.4,111.47 264.53,111.29 264.89,111.23 265.07,111.35 265.43,111.29 265.55,111.11 265.91,111.05 266.09,111.17 266.45,111.11 266.57,110.93 266.93,110.87 267.11,110.99 267.47,110.93 267.6,110.75 267.96,110.69 268.13,110.81 268.66,110.72 272.12,108.3 272.59,107.62 272.59,107.29 v1(272.24,106.93)
  BOTTOM w0.135: v1(272.24,106.93) 272.59,106.58 272.59,105.78 C200.1 ; U1.AP28 v4(64.36,92.13)
PE_SLOT5_TX_C_DN<2>: length 230.6
  IN1 w0.089: 63.44,93.09 63.45,93.08 63.44,93 63.61,92.76 63.74,92.74 64.58,92.74 64.72,92.88 64.76,93.06 64.68,93.13 v4(64.36,93.13)
  IN1 w0.122: 63.44,93.09 62.64,94.23 61.99,97.92 62.09,98.52 62.27,98.64 62.33,99 62.21,99.18 62.27,99.54 62.45,99.67 62.51,100.03 62.39,100.2 62.45,100.56 62.63,100.69 62.7,101.05 62.57,101.23 62.63,101.59 62.81,101.71 62.88,102.07 62.75,102.25 62.97,103.47 65.27,106.76 70.68,110.54 79.17,112.04 79.17,112.04 87.66,113.54 133.9,105.38 140.17,106.49 175.49,100.25 247.03,112.87 257.13,111.09 257.25,110.91 257.61,110.85 257.79,110.97 258.15,110.91 258.27,110.73 258.63,110.67 258.81,110.79 259.17,110.73 259.29,110.55 259.65,110.49 259.83,110.61 260.19,110.55 260.32,110.37 260.68,110.31 260.85,110.43 261.21,110.37 261.34,110.19 261.7,110.13 261.88,110.25 262.24,110.19 262.36,110.01 262.72,109.95 262.9,110.07 263.26,110.01 263.38,109.83 263.74,109.77 263.92,109.89 264.28,109.83 264.4,109.65 264.76,109.59 264.94,109.71 265.3,109.65 265.43,109.47 265.79,109.41 265.96,109.53 266.94,109.36 268.82,108.04 269.04,107.73 269.04,107.29 v1(268.68,106.93)
  BOTTOM w0.135: v1(268.68,106.93) 269.04,106.58 269.04,105.78 C201.1 ; U1.AP29 v4(64.36,93.13)
PE_SLOT5_TX_C_DN<3>: length 229.1
  IN1 w0.089: 63.63,94.69 63.63,94.66 63.59,94.61 63.62,94.43 64.09,93.8 64.34,93.71 64.59,93.71 64.74,93.81 64.77,93.86 64.77,94.04 64.68,94.13 v4(64.36,94.13)
  IN1 w0.122: v1(265.13,106.93) 265.48,107.29 265.48,107.71 265.19,108.13 263.79,109.1 261.88,109.44 261.7,109.32 261.34,109.38 261.21,109.56 260.85,109.62 260.68,109.5 260.32,109.56 260.19,109.74 259.83,109.8 259.65,109.68 259.29,109.74 259.17,109.92 258.81,109.98 258.63,109.86 258.27,109.92 258.15,110.1 257.79,110.16 257.61,110.04 257.25,110.1 257.13,110.28 256.77,110.34 256.59,110.22 256.23,110.28 256.1,110.46 255.74,110.52 255.57,110.4 255.21,110.46 255.08,110.64 254.72,110.7 254.54,110.58 254.18,110.64 254.06,110.82 246.75,112.11 246.51,112.09 175.61,99.56 148.9,104.27 140.08,105.82 133.73,104.7 87.61,112.83 71.28,109.95 69.78,108.9 69.75,108.69 69.45,108.48 69.23,108.51 68.93,108.3 68.9,108.09 68.6,107.88 68.38,107.92 67.71,107.45 66.82,106.17 66.85,105.95 66.65,105.65 66.43,105.61 66.22,105.31 66.26,105.1 66.05,104.8 65.83,104.76 65.43,104.18 65.46,104.02 66.84,103.05 66.91,102.64 66.55,102.13 66.14,102.06 64.76,103.02 64.59,102.99 64.11,102.3 63.94,101.37 64.04,101.23 64.79,101.09 65.03,100.75 64.92,100.13 64.58,99.9 63.83,100.03 63.69,99.93 63.2,97.14 63.42,95.87 63.6,95.74 63.66,95.38 63.54,95.21 63.63,94.69
  BOTTOM w0.135: C202.1 265.48,105.78 265.48,106.58 v1(265.13,106.93) ; U1.AP30 v4(64.36,94.13)
PE_SLOT5_TX_C_DN<4>: length 212.8
  IN1 w0.089: v4(69.36,98.13) 69.36,97.81 69.3,97.75 69.16,97.75 68.96,97.94 68.96,99.15 69.01,99.2 69.01,99.22
  IN1 w0.122: v1(261.34,106.93) 261.7,107.29 261.7,107.73 261.34,108.24 260.51,108.82 258.74,109.15 258.56,109.03 258.2,109.09 258.08,109.27 257.72,109.34 257.54,109.21 257.18,109.28 257.06,109.46 256.7,109.52 256.52,109.4 256.16,109.47 256.04,109.65 255.68,109.71 255.5,109.59 255.14,109.66 255.02,109.83 254.66,109.9 254.48,109.78 254.12,109.84 254,110.02 253.64,110.09 253.46,109.97 253.1,110.03 252.98,110.21 252.62,110.28 252.44,110.15 252.08,110.22 251.95,110.4 251.59,110.47 251.42,110.34 251.06,110.41 250.93,110.59 246.65,111.38 175.6,98.86 148.9,103.56 148.85,103.57 139.94,105.14 133.59,104.02 87.55,112.14 71.91,109.38 70.91,108.68 70.87,108.47 70.57,108.26 70.36,108.3 69.98,108.03 69.98,108.03 69.13,107.43 69.09,107.22 68.79,107.01 68.58,107.05 67.96,106.62 67.78,106.36 67.39,104.15 67.7,102.36 68.63,101.05 68.82,100.82 69.01,100.62 69.01,99.22
  BOTTOM w0.135: v1(261.34,106.93) 261.7,106.58 261.7,105.78 C203.1 ; U1.AJ34 v4(69.36,98.13)
PE_SLOT5_TX_C_DN<5>: length 211.1
  IN1 w0.089: 70.02,99.44 70.02,99.42 69.98,99.36 70.04,99.02 69.95,98.5 69.95,97.93 70.15,97.73 70.28,97.73 70.36,97.81 v4(70.36,98.13)
  IN1 w0.122: 70.02,99.44 69.86,100.31 69.99,100.48 69.92,100.84 69.75,100.97 69.62,101.69 69.74,101.86 69.68,102.23 69.5,102.35 69.36,103.16 69.44,103.63 69.62,103.76 69.68,104.12 69.56,104.3 69.74,105.32 70.74,106.75 71.18,107.07 71.4,107.03 71.7,107.24 71.73,107.45 72.16,107.75 72.38,107.72 72.68,107.92 72.72,108.14 73.89,108.96 74.86,109.13 75,109.03 75.04,108.82 75.38,108.58 76,108.69 76.24,109.03 76.2,109.25 76.3,109.39 76.68,109.45 76.82,109.35 76.86,109.14 77.2,108.9 77.82,109.01 78.05,109.35 78.01,109.57 78.11,109.71 78.49,109.77 78.64,109.68 78.67,109.46 79.01,109.22 79.63,109.33 79.87,109.67 79.83,109.89 79.93,110.03 80.31,110.09 80.45,110 80.49,109.78 80.83,109.54 81.45,109.65 81.69,109.99 81.65,110.21 81.75,110.35 82.13,110.42 82.27,110.32 82.31,110.1 82.65,109.86 83.27,109.97 83.5,110.31 83.47,110.53 83.56,110.67 83.95,110.74 84.09,110.64 84.13,110.42 84.46,110.18 85.08,110.29 85.32,110.63 85.28,110.85 85.38,110.99 85.76,111.06 85.9,110.96 85.94,110.74 86.28,110.5 86.9,110.61 87.14,110.95 87.1,111.17 87.2,111.31 87.79,111.41 133.49,103.35 139.84,104.47 148.85,102.89 148.85,102.88 148.9,102.88 175.62,98.17 245.97,110.59 251.03,109.7 251.16,109.52 251.52,109.45 251.7,109.58 252.06,109.52 252.18,109.34 252.54,109.27 252.72,109.4 253.08,109.34 253.2,109.16 253.56,109.09 253.74,109.22 254.1,109.15 254.23,108.98 254.59,108.91 254.76,109.04 255.12,108.97 255.25,108.8 255.61,108.73 255.78,108.86 256.34,108.76 257.31,108.08 257.63,107.62 257.63,107.29 v1(257.28,106.93)
  BOTTOM w0.135: C204.1 257.63,105.78 257.63,106.58 v1(257.28,106.93) ; U1.AH34 v4(70.36,98.13)
PE_SLOT5_TX_C_DN<6>: length 199.3
  IN1 w0.089: v4(71.36,98.13) 71.36,97.81 71.28,97.73 71.15,97.73 70.94,97.93 70.94,98.46 70.8,99.27 70.81,99.33 70.87,99.37 70.88,99.39
  IN1 w0.122: v1(253.29,106.93) 253.64,107.29 253.64,107.68 253.3,108.18 252.7,108.59 252.15,108.69 251.97,108.57 251.61,108.63 251.49,108.81 251.13,108.87 250.95,108.75 250.59,108.81 250.46,108.99 250.1,109.05 249.93,108.93 249.57,108.99 249.44,109.17 249.08,109.23 248.9,109.11 248.54,109.17 248.42,109.35 248.06,109.41 247.88,109.29 247.52,109.35 247.4,109.53 247.04,109.59 246.86,109.47 246.5,109.53 246.38,109.71 245.59,109.85 175.6,97.49 148.9,102.2 148.85,102.21 139.78,103.81 133.43,102.69 89.57,110.42 77.21,108.24 77.09,108.07 76.73,108 76.55,108.13 76.19,108.06 76.07,107.89 75.71,107.82 75.53,107.95 75.17,107.88 75.05,107.71 74.68,107.64 74.51,107.77 73.99,107.67 72.36,106.46 71.48,105.21 71.24,103.87 71.3,103.57 71.08,102.34 71.2,102.16 71.14,101.8 70.96,101.68 70.9,101.32 71.06,100.42 70.88,99.44 70.88,99.39
  BOTTOM w0.135: U1.AG34 v4(71.36,98.13) ; C205.1 253.65,105.78 253.65,106.58 v1(253.29,106.93)
PE_SLOT5_TX_C_DN<7>: length 198.1
  IN1 w0.089: 71.94,99.39 71.94,99.37 71.88,99.33 71.84,99.11 71.96,98.45 71.96,97.92 72.15,97.73 72.28,97.73 72.36,97.81 v4(72.36,98.13)
  IN1 w0.122: 71.94,99.39 72.23,101.02 72.98,102.1 73.27,103.7 73.15,104.37 73.04,104.98 73.21,105.95 73.59,106.5 74.03,106.8 74.03,106.8 77.49,107.4 77.67,107.27 78.03,107.33 78.15,107.51 78.51,107.57 78.69,107.45 79.05,107.51 79.18,107.69 79.54,107.75 79.71,107.62 80.07,107.68 80.2,107.86 80.56,107.92 80.74,107.8 81.1,107.86 81.22,108.04 82.17,108.2 82.31,108.1 82.4,107.56 82.74,107.32 83.36,107.43 83.6,107.76 83.51,108.3 83.61,108.44 83.99,108.51 84.13,108.41 84.22,107.87 84.56,107.63 85.18,107.74 85.42,108.08 85.32,108.62 85.42,108.76 85.8,108.82 85.94,108.72 86.04,108.18 86.38,107.94 87,108.05 87.24,108.39 87.14,108.93 87.24,109.07 90.35,109.6 133.45,102 139.8,103.12 148.9,101.52 149.27,101.45 149.28,101.45 175.53,96.82 242.05,108.55 242.23,108.43 242.59,108.49 242.71,108.67 243.07,108.73 243.25,108.61 243.61,108.67 243.74,108.85 244.1,108.91 244.27,108.79 244.63,108.85 244.76,109.03 245.12,109.09 246.01,108.93 246.13,108.76 246.49,108.69 246.67,108.82 247.03,108.75 247.15,108.58 247.51,108.51 247.69,108.64 248.05,108.57 248.17,108.4 248.53,108.33 248.71,108.46 249.07,108.39 249.45,108.13 249.66,107.83 249.66,107.29 v1(249.3,106.93)
  BOTTOM w0.135: U1.AF34 v4(72.36,98.13) ; v1(249.3,106.93) 249.66,106.58 249.66,105.78 C206.1
PE_SLOT5_TX_C_DN<8>: length 195.9
  BOTTOM w0.089: 72.51,99.34 72.51,99.32 72.45,99.26 72.45,98.95 73.45,97.96 73.45,97.36 73.6,97.21 73.74,97.21 73.86,97.33 U1.AE34
  BOTTOM w0.135: 72.51,99.34 72.51,100.18 72.32,101.24 71.65,102.21 71.26,104.43 71.54,106.05 72.56,107.5 79.72,112.51 87.05,113.81 87.22,113.68 87.62,113.75 87.75,113.93 88.14,114 88.32,113.88 88.72,113.95 88.84,114.12 89.24,114.19 89.42,114.07 89.82,114.14 89.94,114.32 94.18,115.07 101.07,113.85 103.86,114.34 103.99,114.34 103.99,114.34 104.18,114.34 106.1,114.01 v3(107.7,113.72) 128.3,110.09 135.18,105.27 143.14,103.87 148.9,104.89 160.95,102.48 163.69,103.02 167,102.36 170.18,102.99 173.35,102.36 176.53,102.99 179.7,102.36 194.43,105.31 206.46,113.73 218.33,115.82 227.79,114.15 227.91,113.97 228.31,113.9 228.49,114.03 228.89,113.96 229.01,113.78 229.41,113.71 229.59,113.83 229.98,113.76 230.11,113.59 230.51,113.52 230.68,113.64 231.08,113.57 231.21,113.39 231.6,113.32 231.78,113.45 232.18,113.38 232.3,113.2 232.7,113.13 232.88,113.25 233.28,113.18 233.4,113.01 233.8,112.94 233.98,113.06 234.37,112.99 234.5,112.81 234.9,112.74 235.07,112.87 235.63,112.77 242.94,107.65 243.59,106.72 243.61,106.58 243.64,106.43 243.69,106.15 243.69,105.78 C207.1
PE_SLOT5_TX_C_DN<9>: length 193.7
  BOTTOM w0.089: 73.71,99.44 73.71,99.42 73.66,99.36 73.66,98.99 74.46,98.18 74.46,97.34 74.58,97.22 74.74,97.22 74.86,97.34 U1.AD34
  BOTTOM w0.135: 73.71,99.44 73.71,100.33 73.71,100.33 73.36,102.31 73.17,103.39 72.98,104.46 73.27,106.11 73.61,106.6 80,111.07 87.81,112.45 87.99,112.33 88.39,112.4 88.51,112.57 88.91,112.64 89.09,112.52 89.49,112.59 89.61,112.77 90.01,112.84 90.19,112.71 90.58,112.78 90.71,112.96 94.75,113.67 101.23,112.53 104.12,113.04 v3(104.93,112.89) 109.05,112.17 127.53,108.91 130.69,106.7 130.73,106.48 131.06,106.25 131.27,106.29 131.6,106.06 131.64,105.84 131.97,105.61 132.18,105.65 134.55,104 142.98,102.51 149.05,103.58 161.01,101.19 163.76,101.74 167,101.09 170.18,101.72 173.35,101.09 176.53,101.72 179.7,101.09 194.82,104.11 206.93,112.59 217.66,114.48 226.12,112.99 226.24,112.81 226.64,112.74 226.82,112.86 227.21,112.79 227.34,112.62 227.74,112.55 227.91,112.67 228.31,112.6 228.43,112.42 228.83,112.35 229.01,112.48 229.41,112.41 229.53,112.23 229.93,112.16 230.11,112.28 230.5,112.21 230.63,112.04 231.03,111.97 231.2,112.09 232.94,111.78 234.62,110.61 235.05,110.68 235.43,111.22 235.62,111.25 236.13,110.89 236.17,110.7 235.4,109.61 235.49,109.09 236.08,108.68 236.66,108.78 237.4,109.84 237.54,109.86 237.59,109.87 238.1,109.51 238.14,109.32 237.76,108.79 237.84,108.35 238.95,107.58 239.59,106.66 239.68,106.16 239.68,105.76 C208.1
PE_SLOT5_TX_C_DN<10>: length 180.8
  BOTTOM w0.089: U1.AC34 75.86,97.31 75.74,97.19 75.6,97.19 75.45,97.34 75.45,98.11 75.51,98.17 75.51,98.19
  BOTTOM w0.135: 75.51,98.19 75.51,98.48 75.37,98.87 74.92,99.44 74.92,100.35 75.42,103.19 75.86,103.81 76.42,104.2 77,105.04 77.2,106.18 78.11,107.48 81.69,109.98 87.58,111.02 87.76,110.9 88.15,110.97 88.28,111.14 88.68,111.21 88.85,111.09 89.25,111.16 89.38,111.34 89.77,111.41 89.95,111.28 90.35,111.35 90.47,111.53 94.91,112.31 101.37,111.17 104.33,111.69 111,110.52 v3(113.24,110.12) 126.17,107.84 129.19,105.73 129.23,105.51 129.56,105.28 129.77,105.32 130.1,105.09 130.14,104.88 130.47,104.64 130.69,104.68 133.11,102.98 143.06,101.23 148.9,102.26 160.87,99.86 163.83,100.45 167,99.82 170.18,100.45 173.35,99.82 176.53,100.45 179.7,99.82 195.22,102.92 207.4,111.45 217.17,113.17 224.6,111.86 224.72,111.68 225.12,111.61 225.3,111.74 225.69,111.67 225.82,111.49 226.22,111.42 226.39,111.54 226.79,111.47 226.92,111.3 227.31,111.23 227.49,111.35 227.89,111.28 228.01,111.1 228.41,111.03 228.59,111.16 229.99,110.91 235.13,107.31 235.63,106.6 235.69,106.25 235.69,105.78 C209.1
PE_SLOT5_TX_C_DN<11>: length 178.7
  BOTTOM w0.089: U1.AB34 76.86,97.36 76.75,97.24 76.59,97.24 76.47,97.37 76.47,98.19 76.53,98.25 76.53,98.27
  BOTTOM w0.135: C210.1 231.68,105.78 231.68,106.07 231.55,106.76 231.37,107.02 231.18,107.06 230.41,106.52 229.98,106.59 229.47,107.32 229.55,107.75 230.31,108.29 230.35,108.48 230.12,108.8 228.86,109.68 228.58,109.73 228.43,109.62 228.29,108.87 227.93,108.62 227.06,108.77 226.81,109.14 226.94,109.89 226.83,110.04 224.55,110.44 224.38,110.32 223.98,110.39 223.86,110.57 223.46,110.64 223.28,110.51 222.88,110.58 222.76,110.76 222.36,110.83 222.18,110.71 221.78,110.78 221.66,110.95 221.26,111.02 221.09,110.9 220.69,110.97 220.56,111.15 220.17,111.22 219.99,111.09 219.59,111.16 219.47,111.34 216.58,111.85 207.87,110.31 195.56,101.7 179.7,98.52 176.53,99.16 173.35,98.52 170.18,99.16 167,98.52 163.83,99.16 160.88,98.57 148.9,100.96 142.69,99.87 132.55,101.66 130.04,103.41 129.83,103.38 129.5,103.61 129.46,103.82 129.13,104.05 128.92,104.02 128.59,104.25 128.55,104.46 125.26,106.77 v3(114.97,108.58) 107.91,109.82 104.47,110.43 101.29,109.87 95.34,110.92 91.75,110.28 91.64,110.13 91.25,110.06 91.1,110.17 90.7,110.1 90.6,109.95 90.2,109.88 90.05,109.98 89.66,109.91 89.55,109.77 89.15,109.7 89.01,109.8 82,108.56 79.48,106.8 79.15,106.32 78.93,105.07 78.55,104.52 77.68,103.92 77.27,103.33 77.08,102.26 76.29,101.13 76.12,100.14 76.12,99.45 76.12,99.44 76.52,98.85 76.53,98.82 76.53,98.27
PE_SLOT5_TX_C_DN<12>: length 167.4
  BOTTOM w0.089: U1.AA34 77.86,97.31 77.74,97.19 77.68,97.19 77.45,97.43 77.45,98.27 77.5,98.32 77.5,98.35
  BOTTOM w0.135: C211.1 227.69,105.78 227.69,106.11 227.61,106.56 227.21,107.13 226.81,107.41 226.6,107.37 226.27,107.6 226.23,107.82 225.9,108.05 225.68,108.01 225.35,108.24 225.32,108.46 224.48,109.04 223.18,109.27 223,109.15 222.6,109.22 222.48,109.4 222.08,109.47 221.9,109.34 221.5,109.41 221.38,109.59 216.04,110.53 208.34,109.18 197.97,101.91 196.01,100.54 179.7,97.28 176.53,97.91 173.35,97.28 170.18,97.91 167,97.28 163.83,97.91 160.75,97.3 148.9,99.67 142.63,98.56 131.82,100.47 128.58,102.73 128.37,102.69 128.04,102.93 128,103.14 127.67,103.37 127.46,103.33 127.12,103.57 127.09,103.78 126.76,104.01 126.54,103.97 126.21,104.2 126.18,104.42 124.42,105.65 104.57,109.15 101.28,108.57 95.68,109.56 v3(92.56,109.01) 91.59,108.84 91.47,108.66 91.07,108.59 90.89,108.71 90.49,108.64 90.37,108.46 89.97,108.39 89.79,108.52 89.4,108.45 89.27,108.27 88.87,108.2 88.7,108.33 83.43,107.4 81.47,106.02 80.14,104.13 79.28,103.53 79.09,103.26 79,102.75 77.43,100.51 77.32,99.85 77.32,99.65 77.37,99.44 77.39,99.34 77.43,99.2 77.5,98.65 77.5,98.64 77.5,98.35
PE_SLOT5_TX_C_DN<13>: length 165.1
  BOTTOM w0.089: 78.52,98.45 78.52,98.42 78.46,98.37 78.46,97.41 78.66,97.22 78.77,97.22 78.86,97.31 U1.Y34
  BOTTOM w0.135: C212.1 223.67,105.78 223.67,106.93 223.64,107.12 223.33,107.33 223.04,107.28 221.93,105.7 221.38,105.6 220.92,105.92 220.78,106.69 221.58,107.83 221.55,108.02 221.37,108.14 220.45,108.31 220.28,108.18 219.88,108.25 219.75,108.43 219.36,108.5 219.18,108.37 218.78,108.44 218.66,108.62 218.26,108.69 218.08,108.57 217.68,108.64 217.56,108.81 217.16,108.88 216.98,108.76 216.59,108.83 216.46,109.01 215.54,109.17 208.72,107.97 200.5,102.22 196.4,99.35 179.7,96.01 176.53,96.64 173.35,96.01 170.18,96.64 167,96.01 163.83,96.64 160.83,96.04 148.9,98.43 142.65,97.33 130.66,99.44 130.42,99.61 127.48,101.66 127.27,101.63 126.94,101.86 126.9,102.07 126.57,102.3 126.36,102.27 126.03,102.5 125.99,102.71 125.66,102.94 125.45,102.9 125.11,103.14 125.08,103.35 123.26,104.63 104.55,107.93 101.2,107.34 96.22,108.21 v3(95.16,108.03) 91.86,107.45 91.74,107.27 91.34,107.2 91.16,107.32 90.76,107.25 90.64,107.07 90.24,107 90.06,107.13 89.67,107.06 89.54,106.88 89.14,106.81 88.97,106.94 83.48,105.97 83.04,105.66 82.14,104.38 81.43,103.88 81.07,103.36 80.95,102.68 80.72,102.35 79.69,101.63 78.79,100.34 78.66,99.62 78.66,98.95 78.52,98.81 78.52,98.45
PE_SLOT5_TX_C_DN<14>: length 154.3
  BOTTOM w0.089: U1.W34 79.86,97.29 79.81,97.23 79.64,97.23 79.45,97.42 79.45,98.25 79.94,98.73 79.94,98.93 79.99,98.98 79.99,99.01
  BOTTOM w0.135: C213.1 219.66,105.78 219.66,106.14 219.61,106.45 219.38,106.78 218.82,107.16 218.39,107.24 218.22,107.11 217.82,107.18 217.69,107.36 214.94,107.85 209.19,106.83 208.26,106.18 208.23,105.97 207.89,105.74 207.68,105.78 207.35,105.54 207.31,105.33 206.98,105.1 206.77,105.14 198.64,99.45 196.8,98.16 179.7,94.74 176.53,95.37 173.35,94.74 170.18,95.37 167,94.74 163.83,95.37 160.64,94.74 148.9,97.08 142.18,95.9 129.56,98.41 127.78,99.66 127.56,99.62 127.23,99.85 127.19,100.07 126.86,100.3 126.65,100.26 126.32,100.49 126.28,100.71 125.95,100.94 125.74,100.9 125.41,101.13 125.37,101.35 122.15,103.6 104.54,106.7 101.2,106.12 96.73,106.9 v3(93.16,106.27) 92.05,106.08 91.93,105.9 91.53,105.83 91.35,105.96 90.96,105.89 90.83,105.71 90.43,105.64 90.26,105.76 89.86,105.69 89.74,105.52 89.34,105.45 89.16,105.57 85.09,104.85 83.17,103.51 82.83,103.03 82.77,102.66 82.3,101.99 80.55,100.77 80.1,100.12 79.99,99.51 79.99,99.01
PE_SLOT5_TX_C_DN<15>: length 156.2
  BOTTOM w0.089: U1.V34 80.86,97.31 80.77,97.22 80.66,97.22 80.47,97.41 80.47,98.04 81.16,98.74 81.16,98.94 81.22,99 81.22,99.02
  BOTTOM w0.135: C214.1 215.7,105.78 215.7,106.2 215.58,106.37 215.44,106.51 214.86,106.61 214.46,106.54 214.34,106.36 213.94,106.29 213.76,106.42 213.36,106.35 213.24,106.17 212.84,106.1 212.67,106.22 212.27,106.15 212.14,105.98 211.75,105.91 211.57,106.03 211.17,105.96 211.05,105.78 210.65,105.71 210.47,105.84 210.02,105.76 209.3,105.25 209.26,105.06 209.95,104.08 209.87,103.64 209.15,103.14 208.72,103.21 208.03,104.2 207.84,104.23 207.33,103.87 207.29,103.68 207.98,102.7 207.9,102.26 207.18,101.76 206.75,101.84 206.06,102.82 205.87,102.85 205.36,102.49 205.32,102.31 206.01,101.32 205.93,100.89 205.21,100.38 204.78,100.46 204.09,101.44 203.9,101.47 200.98,99.43 197.52,97.01 179.7,93.44 176.53,94.08 173.35,93.44 170.18,94.08 167,93.44 163.83,94.08 160.62,93.44 148.9,95.78 142.23,94.61 142.12,94.61 142.12,94.61 128.44,97.33 125.41,99.46 125.19,99.42 124.86,99.65 124.82,99.86 124.49,100.1 124.28,100.06 123.95,100.29 123.91,100.5 123.58,100.74 123.37,100.7 123.04,100.93 123,101.14 120.93,102.6 114.11,103.8 104.54,105.48 101.02,104.86 97.22,105.53 v3(95.16,105.17) 92.53,104.7 92.4,104.53 92,104.46 91.83,104.58 91.43,104.51 91.31,104.33 90.91,104.26 90.73,104.39 90.33,104.32 90.21,104.14 89.81,104.07 89.63,104.19 86.83,103.7 81.42,99.91 81.27,99.7 81.23,99.44 81.22,99.4 81.22,99.02
PE_SLOT5_TX_C_DP<0>: length 243.4
  IN1 w0.089: v4(65.36,91.13) 65.05,91.13 64.96,91.04 64.96,90.84 64.66,90.54 63.6,90.54 63.49,90.56 63.28,90.59 63.22,90.55 63.2,90.56
  IN1 w0.122: v1(276.05,106.93) 275.68,107.3 275.68,107.91 275.37,108.35 270.94,111.45 250.07,115.13 212.7,108.54 175.52,101.98 148.9,106.68 140.35,108.18 134,107.06 87.75,115.22 69.94,112.08 65.48,108.99 63.79,107.73 60.67,103.26 59.82,98.48 60.93,92.2 61.74,91.04 62.18,90.74 63.15,90.57 63.15,90.57 63.2,90.56
  BOTTOM w0.135: v1(276.05,106.93) 275.69,106.58 275.69,105.78 C183.1 ; U1.AN27 v4(65.36,91.13)
PE_SLOT5_TX_C_DP<1>: length 243.7
  IN1 w0.089: v4(65.36,92.13) 65.05,92.13 64.96,92.04 64.96,91.86 64.63,91.53 63.56,91.53 63.27,91.57 63.22,91.52 63.2,91.52
  IN1 w0.122: v1(273.25,106.93) 272.88,107.3 272.88,107.71 272.33,108.51 268.77,111 260.37,112.48 259.06,112.71 258.72,112.47 258.65,112.06 258.51,111.96 258.13,112.03 258.03,112.17 258.1,112.58 257.86,112.92 257.24,113.03 256.91,112.79 256.83,112.38 256.69,112.28 256.31,112.35 256.21,112.49 256.28,112.9 256.05,113.24 255.43,113.35 255.09,113.11 255.02,112.7 254.87,112.6 254.49,112.67 254.39,112.81 254.47,113.22 254.23,113.56 253.61,113.67 253.27,113.43 253.2,113.02 253.06,112.92 252.68,112.99 252.58,113.13 252.65,113.54 252.41,113.88 251.79,113.99 251.45,113.75 251.38,113.34 251.24,113.24 250.86,113.31 250.76,113.45 250.83,113.86 250.6,114.2 249.79,114.34 175.57,101.26 148.91,105.96 148.9,105.96 140.16,107.5 133.81,106.38 87.64,114.52 85.51,114.14 77.99,112.82 70.23,111.45 64.38,107.34 61.58,103.34 60.69,98.3 61.68,92.68 62.11,92.07 62.82,91.57 63.2,91.52
  BOTTOM w0.135: C184.1 272.9,105.78 272.9,106.58 v1(273.25,106.93) ; U1.AN28 v4(65.36,92.13)
PE_SLOT5_TX_C_DP<2>: length 230.6
  IN1 w0.089: v4(65.36,93.13) 65.05,93.13 64.94,93.03 64.9,92.79 64.66,92.54 63.72,92.54 63.5,92.58 63.28,92.9 63.21,92.91 63.2,92.93
  IN1 w0.122: v1(269.7,106.93) 269.33,107.3 269.33,107.82 269.03,108.25 267.06,109.63 247.03,113.16 175.49,100.55 140.17,106.79 133.9,105.68 87.66,113.83 70.57,110.82 65.06,106.97 62.69,103.58 61.69,97.92 62.36,94.12 63.2,92.93
  BOTTOM w0.135: U1.AN29 v4(65.36,93.13) ; v1(269.7,106.93) 269.34,106.58 269.34,105.78 C185.1
PE_SLOT5_TX_C_DP<3>: length 229.1
  IN1 w0.089: v4(65.36,94.13) 65.05,94.13 64.96,94.04 64.96,93.77 64.91,93.72 64.87,93.67 64.64,93.52 64.31,93.52 63.97,93.64 63.44,94.36 63.41,94.57 63.35,94.61 63.34,94.64
  IN1 w0.122: v1(266.14,106.93) 265.77,107.3 265.77,107.8 265.4,108.34 263.91,109.38 246.76,112.4 246.47,112.38 175.61,99.85 148.9,104.56 140.08,106.12 133.73,105 87.61,113.13 71.17,110.23 67.5,107.66 65.59,104.93 65.12,104.25 65.19,103.85 66.57,102.88 66.6,102.71 66.38,102.39 66.21,102.36 64.83,103.33 64.42,103.26 63.83,102.41 63.63,101.3 63.87,100.96 64.62,100.83 64.72,100.69 64.65,100.3 64.51,100.21 63.76,100.34 63.42,100.1 62.9,97.14 63.34,94.64
  BOTTOM w0.135: C186.1 265.79,105.78 265.79,106.58 v1(266.14,106.93) ; U1.AN30 v4(65.36,94.13)
PE_SLOT5_TX_C_DP<4>: length 212.8
  IN1 w0.089: 68.72,99.22 68.72,99.2 68.77,99.15 68.77,97.87 69.08,97.56 69.25,97.56 69.36,97.45 v4(69.36,97.13)
  IN1 w0.122: 68.72,99.22 68.72,100.5 68.6,100.62 68.6,100.63 68.4,100.86 67.43,102.25 67.09,104.15 67.5,106.47 67.75,106.83 69.79,108.26 71.79,109.66 87.55,112.44 133.59,104.32 139.94,105.44 148.9,103.86 175.6,99.15 246.47,111.65 246.64,111.68 260.62,109.1 261.55,108.45 261.99,107.82 261.99,107.3 v1(262.36,106.93)
  BOTTOM w0.135: U1.AJ33 v4(69.36,97.13) ; v1(262.36,106.93) 262,106.58 262,105.78 C187.1
PE_SLOT5_TX_C_DP<5>: length 211.1
  IN1 w0.089: v4(70.36,97.13) 70.36,97.45 70.28,97.54 70.07,97.54 69.76,97.85 69.76,98.52 69.76,98.54 69.85,99.02 69.79,99.33 69.73,99.37 69.73,99.39
  IN1 w0.122: 69.73,99.39 69.72,99.44 69.06,103.16 69.46,105.44 70.53,106.96 73.78,109.24 74.93,109.44 75.27,109.2 75.31,108.99 75.45,108.89 75.83,108.95 75.93,109.09 75.89,109.31 76.13,109.65 76.75,109.76 77.09,109.52 77.12,109.31 77.26,109.21 77.65,109.27 77.74,109.42 77.71,109.63 77.94,109.97 78.56,110.08 78.9,109.85 78.94,109.63 79.08,109.53 79.46,109.59 79.56,109.74 79.52,109.95 79.76,110.29 80.38,110.4 80.72,110.17 80.76,109.95 80.9,109.85 81.28,109.92 81.38,110.06 81.34,110.28 81.58,110.61 82.2,110.72 82.54,110.49 82.57,110.27 82.72,110.17 83.1,110.24 83.2,110.38 83.16,110.6 83.4,110.94 84.01,111.04 84.35,110.81 84.39,110.59 84.53,110.49 84.91,110.56 85.01,110.7 84.97,110.92 85.21,111.26 85.83,111.37 86.17,111.13 86.21,110.91 86.35,110.81 86.73,110.88 86.83,111.02 86.79,111.24 87.03,111.58 87.79,111.71 133.49,103.65 139.84,104.77 148.9,103.17 175.62,98.46 245.97,110.89 256.45,109.04 257.52,108.29 257.92,107.72 257.92,107.3 v1(258.29,106.93)
  BOTTOM w0.135: v1(258.29,106.93) 257.94,106.58 257.94,105.78 C188.1 ; U1.AH33 v4(70.36,97.13)
PE_SLOT5_TX_C_DP<6>: length 199.3
  IN1 w0.089: 70.59,99.44 70.58,99.42 70.62,99.36 70.61,99.27 70.75,98.44 70.75,97.85 71.07,97.54 71.28,97.54 71.36,97.45 v4(71.36,97.13)
  IN1 w0.122: v1(254.31,106.93) 253.94,107.3 253.94,107.77 253.51,108.39 252.82,108.87 245.59,110.14 175.6,97.79 148.9,102.5 139.78,104.11 133.43,102.99 89.57,110.72 73.87,107.95 72.15,106.67 71.68,106 71.2,105.32 70.95,103.87 71,103.57 70.6,101.32 70.76,100.42 70.67,99.93 70.59,99.44 70.59,99.44
  BOTTOM w0.135: C189.1 253.95,105.78 253.95,106.58 v1(254.31,106.93) ; U1.AG33 v4(71.36,97.13)
PE_SLOT5_TX_C_DP<7>: length 198.1
  IN1 w0.089: v4(72.36,97.13) 72.36,97.45 72.28,97.54 72.07,97.54 71.77,97.84 71.77,98.43 71.65,99.11 71.69,99.36 71.65,99.42 71.65,99.44
  IN1 w0.122: v1(250.32,106.93) 249.95,107.3 249.95,107.92 249.66,108.34 249.19,108.67 247.15,109.03 245.12,109.39 242,108.84 175.53,97.12 149.33,101.74 149.32,101.74 139.8,103.42 133.45,102.3 90.35,109.9 87.07,109.34 86.83,109 86.93,108.46 86.83,108.32 86.45,108.25 86.31,108.35 86.21,108.89 85.87,109.13 85.26,109.02 85.02,108.69 85.11,108.15 85.01,108.01 84.63,107.94 84.49,108.04 84.39,108.58 84.06,108.82 83.44,108.71 83.2,108.37 83.29,107.83 83.19,107.69 82.81,107.63 82.67,107.73 82.58,108.27 82.24,108.51 73.92,107.08 73.91,107.08 73.38,106.71 72.93,106.07 72.74,104.98 72.97,103.7 72.71,102.21 71.95,101.13 71.69,99.67 71.65,99.44
  BOTTOM w0.135: v1(250.32,106.93) 249.96,106.58 249.96,105.78 C190.1 ; U1.AF33 v4(72.36,97.13)
PE_SLOT5_TX_C_DP<8>: length 195.9
  BOTTOM w0.089: 72.21,99.34 72.21,99.32 72.26,99.26 72.26,98.87 73.26,97.88 73.26,97.28 73.52,97.02 73.77,97.02 73.86,96.92 U1.AE33
  BOTTOM w0.135: 72.21,99.34 72.21,100.15 72.04,101.12 71.36,102.09 70.95,104.43 71.25,106.17 72.34,107.72 79.6,112.8 94.18,115.37 101.07,114.16 103.86,114.65 103.99,114.65 103.99,114.65 104.21,114.65 v3(106.15,114.31) 107.76,114.02 128.42,110.38 135.3,105.56 143.14,104.18 148.9,105.2 160.95,102.79 163.69,103.33 167,102.67 170.18,103.31 173.35,102.67 176.53,103.31 179.7,102.67 194.31,105.59 206.34,114.01 218.33,116.13 235.75,113.06 243.15,107.87 243.88,106.84 243.99,106.17 243.99,105.78 C191.1
PE_SLOT5_TX_C_DP<9>: length 193.7
  BOTTOM w0.089: U1.AD33 74.86,96.92 74.76,97.03 74.5,97.03 74.27,97.26 74.27,98.1 73.47,98.91 73.47,99.36 73.41,99.42 73.41,99.44
  BOTTOM w0.135: C192.1 239.98,105.81 239.98,106.19 239.88,106.78 239.17,107.79 238.12,108.53 238.08,108.72 238.46,109.25 238.38,109.69 237.66,110.19 237.22,110.12 236.48,109.06 236.15,109 235.77,109.27 235.72,109.54 236.49,110.63 236.41,111.07 235.69,111.57 235.25,111.5 234.88,110.96 234.69,110.93 233.05,112.08 217.66,114.79 206.81,112.88 194.7,104.4 179.7,101.4 176.53,102.04 173.35,101.4 170.18,102.04 167,101.4 163.76,102.05 161.01,101.5 149.05,103.89 142.98,102.82 134.67,104.28 127.65,109.2 v3(109.1,112.47) 104.98,113.19 104.12,113.35 101.23,112.84 94.75,113.98 79.89,111.36 73.39,106.81 72.98,106.23 72.67,104.46 73.41,100.28 73.41,99.44
PE_SLOT5_TX_C_DP<10>: length 181
  BOTTOM w0.089: U1.AC33 75.86,96.95 75.81,97 75.52,97 75.26,97.26 75.26,98.11 75.2,98.17 75.2,98.19
  BOTTOM w0.135: 75.2,98.19 75.2,98.43 75.1,98.72 74.61,99.33 74.61,100.37 75.13,103.3 75.64,104.03 75.92,104.23 76.2,104.42 76.71,105.16 76.91,106.3 77.89,107.7 81.57,110.27 94.91,112.62 101.37,111.48 104.33,112 v3(111.05,110.82) 113.29,110.42 126.29,108.13 133.23,103.27 143.06,101.54 148.9,102.57 160.87,100.17 163.83,100.77 167,100.13 170.18,100.77 173.35,100.13 176.53,100.77 179.7,100.13 195.1,103.21 207.28,111.74 217.17,113.48 230.11,111.2 235.35,107.53 235.91,106.72 235.99,106.27 235.99,105.78 C193.1
PE_SLOT5_TX_C_DP<11>: length 178.9
  BOTTOM w0.089: U1.AB33 76.86,96.95 76.76,97.05 76.51,97.05 76.28,97.29 76.28,98.19 76.22,98.25 76.22,98.27
  BOTTOM w0.135: 76.22,98.27 76.22,98.74 75.87,99.27 75.86,99.28 75.81,99.36 75.81,100.16 76,101.25 76.8,102.38 76.98,103.45 77.46,104.14 78.33,104.74 78.64,105.19 78.86,106.44 79.26,107.02 81.88,108.85 95.34,111.23 101.29,110.17 104.47,110.73 v3(107.97,110.12) 115.03,108.88 125.38,107.06 132.67,101.94 142.69,100.18 148.9,101.27 160.88,98.88 163.83,99.47 167,98.83 170.18,99.47 173.35,98.83 176.53,99.47 179.7,98.83 195.44,101.98 207.75,110.6 216.58,112.16 227.01,110.32 227.26,109.96 227.13,109.21 227.24,109.05 227.86,108.94 228.02,109.05 228.15,109.8 228.51,110.05 228.92,109.98 228.98,109.97 230.34,109.02 230.67,108.55 230.59,108.11 229.82,107.58 229.79,107.39 230.15,106.87 230.34,106.84 231.11,107.38 231.54,107.3 231.84,106.88 231.98,106.09 231.98,105.78 C194.1
PE_SLOT5_TX_C_DP<12>: length 167.4
  BOTTOM w0.089: U1.AA33 77.86,96.94 77.8,97 77.6,97 77.26,97.35 77.26,98.27 77.2,98.32 77.2,98.35
  BOTTOM w0.135: C195.1 227.99,105.78 227.99,106.14 227.9,106.68 227.43,107.35 224.6,109.33 216.04,110.84 208.22,109.46 v3(197.8,102.16) 195.89,100.83 179.7,97.59 176.53,98.23 173.35,97.59 170.18,98.23 167,97.59 163.83,98.23 160.75,97.61 148.9,99.98 142.63,98.87 131.94,100.76 124.54,105.94 104.57,109.46 101.28,108.88 95.68,109.87 92.51,109.31 83.31,107.69 81.25,106.24 79.92,104.35 79.06,103.74 78.81,103.38 78.71,102.87 77.15,100.63 77.01,99.87 77.01,99.62 77.05,99.44 77.09,99.27 77.13,99.14 77.2,98.61 77.2,98.35
PE_SLOT5_TX_C_DP<13>: length 165.1
  BOTTOM w0.089: 78.21,98.45 78.21,98.42 78.27,98.37 78.27,97.33 78.58,97.03 78.77,97.03 78.86,96.93 U1.Y33
  BOTTOM w0.135: 78.21,98.45 78.21,98.94 78.35,99.08 78.35,99.64 78.5,100.46 79.47,101.85 80.5,102.57 80.66,102.8 80.78,103.48 81.21,104.1 81.92,104.6 82.82,105.88 83.36,106.26 95.1,108.33 96.22,108.52 101.2,107.65 104.55,108.23 123.37,104.91 130.78,99.73 142.65,97.64 148.9,98.74 160.83,96.35 163.83,96.96 167,96.32 170.18,96.96 173.35,96.32 176.53,96.96 179.7,96.32 196.28,99.64 v3(200.33,102.47) 200.39,102.51 208.6,108.26 215.54,109.48 220.51,108.61 221.49,108.43 221.83,108.2 221.91,107.76 221.11,106.62 221.2,106.1 221.45,105.92 221.75,105.98 222.86,107.56 223.28,107.63 223.4,107.65 223.92,107.29 223.98,106.96 223.98,105.78 C196.1
PE_SLOT5_TX_C_DP<14>: length 154.5
  BOTTOM w0.089: U1.W33 79.86,96.92 79.75,97.04 79.56,97.04 79.26,97.34 79.26,98.33 79.75,98.81 79.75,98.93 79.69,98.98 79.69,99.01
  BOTTOM w0.135: C197.1 219.97,105.78 219.97,106.16 219.9,106.57 219.6,106.99 218.94,107.45 214.94,108.16 209.07,107.12 v3(198.46,99.7) 196.68,98.44 179.7,95.05 176.53,95.69 173.35,95.05 170.18,95.69 167,95.05 163.83,95.69 160.64,95.05 148.9,97.39 142.18,96.21 129.68,98.7 122.27,103.89 104.54,107.01 101.2,106.42 96.73,107.21 93.11,106.57 87.07,105.51 87.07,105.51 84.97,105.14 82.95,103.73 82.54,103.15 82.48,102.78 82.08,102.21 80.34,100.99 79.81,100.24 79.69,99.54 79.69,99.01
PE_SLOT5_TX_C_DP<15>: length 156.2
  BOTTOM w0.089: U1.V33 80.86,96.91 80.75,97.03 80.58,97.03 80.28,97.33 80.28,98.12 80.97,98.82 80.97,98.94 80.91,99 80.91,99.02
  BOTTOM w0.135: C198.1 216,105.78 216,106.3 215.81,106.56 215.59,106.79 214.86,106.92 209.9,106.05 209.02,105.43 208.94,104.99 209.63,104.01 209.6,103.82 209.08,103.46 208.89,103.49 208.2,104.48 207.77,104.55 207.05,104.05 206.97,103.61 207.66,102.63 207.63,102.44 207.11,102.08 206.92,102.11 206.23,103.1 205.8,103.18 205.08,102.67 205,102.23 205.69,101.25 205.66,101.06 205.14,100.7 204.95,100.74 204.26,101.72 203.83,101.8 v3(200.81,99.68) 197.39,97.29 179.7,93.75 176.53,94.39 173.35,93.75 170.18,94.39 167,93.75 163.83,94.39 160.62,93.75 148.9,96.09 142.21,94.91 142.15,94.91 128.56,97.62 123.18,101.39 121.05,102.88 104.54,105.79 101.02,105.17 97.22,105.84 95.11,105.47 94.82,105.42 88.18,104.25 86.71,103.99 81.2,100.13 80.98,99.82 80.92,99.44 80.91,99.43 80.91,99.02
PE_SLOT5_TX_DN<0>: length 9
  BOTTOM w0.135: J9.B15 280.2,99.46 280.14,99.64 279.97,99.72 279.68,100.01 279.68,101.47 279.68,101.47 279.6,101.62 279.45,101.76 275.97,103.26 275.39,103.84 275.39,104.27 C199.2
PE_SLOT5_TX_DN<1>: length 7.8
  BOTTOM w0.135: J9.B20 275.2,99.97 275.38,99.91 275.51,99.97 275.67,100.14 275.67,101.39 275.49,101.67 274.65,102.13 274.44,102.07 274.08,102.27 274.02,102.47 273.67,102.67 273.36,103 273.14,103.01 272.86,103.3 272.87,103.52 272.59,103.81 272.59,104.27 C200.2
PE_SLOT5_TX_DN<2>: length 7.5
  BOTTOM w0.135: C201.2 269.04,104.27 269.04,103.87 269.28,103.54 269.24,103.33 269.48,103 269.69,102.97 269.93,102.63 270.29,102.44 270.35,102.23 270.7,102.04 270.91,102.1 271.49,101.78 271.65,101.53 271.65,100.12 271.51,99.97 271.38,99.91 271.2,99.97 J9.B24
PE_SLOT5_TX_DN<3>: length 7.1
  BOTTOM w0.135: J9.B28 267.2,99.97 267.38,99.91 267.51,99.97 267.69,100.16 267.69,101.2 266.88,102.21 266.66,102.24 266.41,102.55 266.43,102.77 266.18,103.08 265.96,103.11 265.71,103.42 265.74,103.64 265.48,103.95 265.48,104.27 C202.2
PE_SLOT5_TX_DN<4>: length 6.3
  BOTTOM w0.135: C203.2 261.7,104.27 261.7,103.87 261.54,103.72 261.54,103.31 261.7,103.16 261.7,102.76 261.54,102.6 261.54,102.2 261.7,102.05 261.7,100.17 261.51,99.97 261.38,99.91 261.2,99.97 J9.B34
PE_SLOT5_TX_DN<5>: length 6.3
  BOTTOM w0.135: C204.2 257.63,104.27 257.63,103.87 257.48,103.72 257.48,103.31 257.63,103.16 257.63,102.76 257.48,102.6 257.48,102.2 257.63,102.05 257.63,100.1 257.51,99.97 257.38,99.91 257.2,99.97 J9.B38
PE_SLOT5_TX_DN<6>: length 6.3
  BOTTOM w0.135: C205.2 253.65,104.27 253.65,103.87 253.49,103.72 253.49,103.31 253.65,103.16 253.65,102.76 253.49,102.6 253.49,102.2 253.65,102.05 253.65,100.09 253.55,100 253.38,99.91 253.2,99.97 J9.B42
PE_SLOT5_TX_DN<7>: length 6.3
  BOTTOM w0.135: C206.2 249.66,104.27 249.66,103.87 249.51,103.72 249.51,103.31 249.66,103.16 249.66,102.76 249.51,102.6 249.51,102.2 249.66,102.05 249.66,100.13 249.51,99.97 249.38,99.91 249.2,99.97 J9.B46
PE_SLOT5_TX_DN<8>: length 6.4
  BOTTOM w0.135: J9.B51 244.2,99.46 244.14,99.64 243.92,99.75 243.69,99.98 243.69,104.27 C207.2
PE_SLOT5_TX_DN<9>: length 6.4
  BOTTOM w0.135: J9.B55 240.2,99.46 240.14,99.64 239.92,99.75 239.69,99.98 239.69,104.29 C208.2
PE_SLOT5_TX_DN<10>: length 6.4
  BOTTOM w0.135: J9.B59 236.2,99.46 236.14,99.64 235.92,99.75 235.69,99.98 235.69,104.27 C209.2
PE_SLOT5_TX_DN<11>: length 6.4
  BOTTOM w0.135: J9.B63 232.2,99.46 232.14,99.64 231.92,99.75 231.69,99.98 231.69,104.26 C210.2
PE_SLOT5_TX_DN<12>: length 6.4
  BOTTOM w0.135: C211.2 227.69,104.27 227.69,99.98 227.92,99.75 228.14,99.64 228.2,99.46 J9.B67
