# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Nets (continued)
PE_SLV_RX_DP<14>: C89.2(B) J8.20
PE_SLV_RX_DP<15>: C90.2(B) J8.23
PE_SLV_TX_DN<0>: J7.48 U1.AL11
PE_SLV_TX_DN<1>: J7.45 U1.AL12
PE_SLV_TX_DN<2>: J7.42 U1.AL13
PE_SLV_TX_DN<3>: J7.39 U1.AL14
PE_SLV_TX_DN<4>: J7.36 U1.AL15
PE_SLV_TX_DN<5>: J7.33 U1.AL16
PE_SLV_TX_DN<6>: J7.30 U1.AL17
PE_SLV_TX_DN<7>: J7.27 U1.AL18
PE_SLV_TX_DN<8>: J8.48 U1.AL19
PE_SLV_TX_DN<9>: J8.45 U1.AL20
PE_SLV_TX_DN<10>: J8.42 U1.AL21
PE_SLV_TX_DN<11>: J8.39 U1.AL22
PE_SLV_TX_DN<12>: J8.36 U1.AL23
PE_SLV_TX_DN<13>: J8.33 U1.AL24
PE_SLV_TX_DN<14>: J8.30 U1.AL25
PE_SLV_TX_DN<15>: J8.27 U1.AL26
PE_SLV_TX_DP<0>: J7.49 U1.AK11
PE_SLV_TX_DP<1>: J7.46 U1.AK12
PE_SLV_TX_DP<2>: J7.43 U1.AK13
PE_SLV_TX_DP<3>: J7.40 U1.AK14
PE_SLV_TX_DP<4>: J7.37 U1.AK15
PE_SLV_TX_DP<5>: J7.34 U1.AK16
PE_SLV_TX_DP<6>: J7.31 U1.AK17
PE_SLV_TX_DP<7>: J7.28 U1.AK18
PE_SLV_TX_DP<8>: J8.49 U1.AK19
PE_SLV_TX_DP<9>: J8.46 U1.AK20
PE_SLV_TX_DP<10>: J8.43 U1.AK21
PE_SLV_TX_DP<11>: J8.40 U1.AK22
PE_SLV_TX_DP<12>: J8.37 U1.AK23
PE_SLV_TX_DP<13>: J8.34 U1.AK24
PE_SLV_TX_DP<14>: J8.31 U1.AK25
PE_SLV_TX_DP<15>: J8.28 U1.AK26
PE_WAKE_N: J5.B11 R5.1 R6.1 R7.1 R8.1 R370.1
PEX8796_GPIO0: R115.1 R190.2(B) U1.AH14
PEX8796_GPIO1: R189.2(B) R269.1 U1.AF8
PEX8796_GPIO2: R188.2(B) R270.1 U1.AE11
PEX8796_GPIO3: R187.2(B) R271.1 U1.AG12
PEX_EEP_CS_N: R113.1 U1.AG14
PEX_EEP_CS_R_N: R113.2(B) R272.2(B) U6.1
PEX_EEP_HOLD_N: R310.2(B) U6.7
PEX_EEP_SCLK: R116.2(B) U1.AM5
PEX_EEP_SCLK_R: R116.1 U6.6
PEX_EEP_SI: R117.2(B) U1.J11
PEX_EEP_SI_R: R117.1 U6.5
PEX_EEP_SO: R114.1 U1.AA8
PEX_EEP_SO_R: R114.2(B) R273.2(B) U6.2
PEX_I2C_ADDR: R134.2(B) R135.1 U1.K11
PEX_PERST_N: Q2.D R138.2(B) R305.1 R351.2(B) U1.AG10
PG_CKPWRGD_N: Q3.D Q4.G R3.2(B)
PG_MOS: Q3.G R297.2(B) R298.2(B)
PQ6_2N7002_D1_G2: PQ6.5 PQ6.6 PR402.2(B) PR403.1
PQ6_2N7002_G1: PC570.1 PQ6.2 PR398.2(B) PR399.1
PST_PE_SLOT1_N: J1.A11 R317.2(B) U8.4(Y)
PST_PE_SLOT2_N: J2.A11 R353.2(B) U17.4(Y)
PST_PE_SLOT3_N: J3.A11 R352.2(B) U16.4(Y)
PST_PE_SLOT4_N: J4.A11 R350.2(B) U15.4(Y)
PST_PE_SLOT5_N: J9.A11 R349.2(B) U13.4(Y)
PU_EEP_WP_R_N: R274.2(B) U6.3(WP)
PU_EMC1412_ALERT: R341.2(B) U4.6
PU_EMC1412_TEM: R302.2(B) U4.4
PU_PCA9548_SC7: R186.2(B) U2.20
PU_PCA9548_SD7: R185.2(B) U2.19
PU_PE_I2C_SCL_1: R202.2(B) U1.AE12
PU_PE_I2C_SDA_1: R201.2(B) U1.AP3
PU_PEX_NT0_PERST_N: R136.2(B) R305.2(B) U1.AP2
PU_PEX_NT1_PERST_N: R137.2(B) U1.K14
PU_SPARE0: R142.2(B) U1.H15
PU_SPARE1: R141.2(B) U1.J18
PU_SPARE2: R139.2(B) R140.1 U1.AE19
PU_STRAP_GEN1_COMPLIANCE_N: R148.2(B) U1.K8
PU_STRAP_GEN1_GEN2: R147.2(B) U1.H17
PU_STRAP_HP_POLARITY_CNTL: R146.2(B) U1.AE15
PU_STRAP_PLL_BYPASS_N: R151.2(B) U1.AF15
PU_STRAP_PROBE_MODE_N: R150.2(B) U1.AE17
PU_STRAP_SERDES_MODE_EN_N: R149.2(B) U1.AG18
PU_VS0_PERST_N: R335.2(B) U1.K12
PU_VS1_PERST_N: R334.2(B) U1.B3
PU_VS2_PERST_N: R333.2(B) U1.AG23
PU_VS3_PERST_N: R332.2(B) U1.J22
REXT_A0: R10.2(B) U1.W6
REXT_A1: R11.2(B) U1.AE6
REXT_A2: R12.2(B) U1.AH6
REXT_A3: R13.2(B) U1.AJ9
REXT_A4: R309.2(B) U1.F9
REXT_A5: R41.2(B) U1.H6
REXT_A6: R42.2(B) U1.L6
REXT_A7: R43.2(B) U1.T6
REXT_A8: R49.2(B) U1.AJ11
REXT_A9: R50.2(B) U1.AJ17
REXT_A10: R51.2(B) U1.AJ21
REXT_A11: R52.2(B) U1.AJ24
REXT_A12: R311.2(B) U1.F25
REXT_A13: R312.2(B) U1.F19
REXT_A14: R313.2(B) U1.F14
REXT_A15: R314.2(B) U1.F11
REXT_A16: R58.2(B) U1.AJ27
REXT_A17: R59.2(B) U1.AG29
REXT_A18: R60.2(B) U1.AB29
REXT_A19: R61.2(B) U1.Y29
REXT_A20: R67.2(B) U1.U29
REXT_A21: R68.2(B) U1.M29
REXT_A22: R69.2(B) U1.H29
REXT_A23: R70.2(B) U1.F27
REXT_B0: R14.2(B) U1.V6
REXT_B1: R15.2(B) U1.AD6
REXT_B2: R16.2(B) U1.AG6
REXT_B3: R17.2(B) U1.AJ8
REXT_B4: R44.2(B) U1.F8
REXT_B5: R45.2(B) U1.J6
REXT_B6: R46.2(B) U1.M6
REXT_B7: R47.2(B) U1.R6
REXT_B8: R53.2(B) U1.AJ10
REXT_B9: R54.2(B) U1.AJ16
REXT_B10: R55.2(B) U1.AJ20
REXT_B11: R56.2(B) U1.AJ23
REXT_B12: R211.2(B) U1.F24
REXT_B13: R315.2(B) U1.F18
REXT_B14: R316.2(B) U1.F13
REXT_B15: R336.2(B) U1.F10
REXT_B16: R62.2(B) U1.AJ26
REXT_B17: R63.2(B) U1.AF29
REXT_B18: R64.2(B) U1.AA29
REXT_B19: R65.2(B) U1.W29
REXT_B20: R71.2(B) U1.T29
REXT_B21: R72.2(B) U1.L29
REXT_B22: R73.2(B) U1.G29
REXT_B23: R74.2(B) U1.F26
REXT_CMU0: R18.2(B) U1.AF6
REXT_CMU1: R48.2(B) U1.K6
REXT_CMU2: R57.2(B) U1.AJ18
REXT_CMU3: R337.2(B) U1.F16
REXT_CMU4: R66.2(B) U1.AE29
REXT_CMU5: R75.2(B) U1.J29
RST_PE_SLOT_N: J5.A11 Q1.G U8.2 U13.2 U15.2 U16.2 U17.2
RST_PEX_MOS_N: Q1.D Q2.G R348.2(B)
SLOT2_JTAG_TCK: J2.A5 R275.2(B)
SLOT2_JTAG_TDI: J2.A6 R262.2(B)
SLOT2_JTAG_TDO: J2.A7 R263.2(B)
SLOT2_JTAG_TMS: J2.A8 R264.2(B)
SLOT2_JTAG_TRST_N: J2.B9 R261.2(B)
SLOT3_JTAG_TCK: J3.A5 R260.2(B)
SLOT3_JTAG_TDI: J3.A6 R257.2(B)
SLOT3_JTAG_TDO: J3.A7 R258.2(B)
SLOT3_JTAG_TMS: J3.A8 R259.2(B)
SLOT3_JTAG_TRST_N: J3.B9 R252.2(B)
SLOT4_JTAG_TCK: J4.A5 R251.2(B)
SLOT4_JTAG_TDI: J4.A6 R248.2(B)
SLOT4_JTAG_TDO: J4.A7 R249.2(B)
SLOT4_JTAG_TMS: J4.A8 R250.2(B)
SLOT4_JTAG_TRST_N: J4.B9 R247.2(B)
SLOT5_JTAG_TCK: J9.A5 R246.2(B)
SLOT5_JTAG_TDI: J9.A6 R239.2(B)
SLOT5_JTAG_TDO: J9.A7 R240.2(B)
SLOT5_JTAG_TMS: J9.A8 R245.2(B)
SLOT5_JTAG_TRST_N: J9.B9 R238.2(B)
STRAP_I2C_SMBUS_CFG_EN_N: R287.2(B) R288.1 U1.AN3
STRAP_I2C_SMBUS_SEL: R289.2(B) R290.1 U1.AP4
STRAP_MGMT_CFG_EN_N: R181.2(B) R182.1 U1.V8
STRAP_NT0_UPSTRM_PORTSEL_0: R132.2(B) R133.1 U1.N7
STRAP_NT0_UPSTRM_PORTSEL_1: R130.2(B) R131.1 U1.C2
STRAP_NT0_UPSTRM_PORTSEL_2: R128.2(B) R129.1 U1.AN5
STRAP_NT1_UPSTRM_PORTSEL_0: R330.2(B) R331.1 U1.K16
STRAP_NT1_UPSTRM_PORTSEL_1: R328.2(B) R329.1 U1.J13
STRAP_NT1_UPSTRM_PORTSEL_2: R326.2(B) R327.1 U1.G15
STRAP_REFCLK_SSC_EN0: R205.2(B) U1.AH13
STRAP_REFCLK_SSC_EN1: R206.2(B) U1.W8
STRAP_REFCLK_SSC_EN2: R207.2(B) U1.AG19
STRAP_REFCLK_SSC_EN3: R208.2(B) U1.AH19
STRAP_REFCLK_SSC_EN4: R217.2(B) U1.M9
STRAP_REFCLK_SSC_EN5: R218.2(B) U1.G16
STRAP_REFCLK_SSC_EN6: R219.2(B) U1.P8
STRAP_REFCLK_SSC_EN7: R220.2(B) U1.C1
STRAP_REFCLK_SSC_EN8: R229.2(B) U1.AE26
STRAP_REFCLK_SSC_EN9: R230.2(B) U1.AG20
STRAP_REFCLK_SSC_EN10: R231.2(B) U1.AP32
STRAP_REFCLK_SSC_EN11: R232.2(B) U1.AL33
STRAP_REFCLK_SSC_EN12: R241.2(B) U1.J20
STRAP_REFCLK_SSC_EN13: R242.2(B) U1.J24
STRAP_REFCLK_SSC_EN14: R243.2(B) U1.G21
STRAP_REFCLK_SSC_EN15: R244.2(B) U1.H21
STRAP_REFCLK_SSC_EN16: R253.2(B) U1.Y28
STRAP_REFCLK_SSC_EN17: R254.2(B) U1.AP33
STRAP_REFCLK_SSC_EN18: R255.2(B) U1.V27
STRAP_REFCLK_SSC_EN19: R256.2(B) U1.U28
STRAP_REFCLK_SSC_EN20: R265.2(B) U1.J27
STRAP_REFCLK_SSC_EN21: R266.2(B) U1.M28
STRAP_REFCLK_SSC_EN22: R267.2(B) U1.C32
STRAP_REFCLK_SSC_EN23: R268.2(B) U1.B31
STRAP_RESERVED_17: R295.2(B) R325.2(B) U1.H16
STRAP_TESTMODE: R291.2(B) R292.1 U1.H13
STRAP_VS0_UPSTRM_PORTSEL_0: R31.2(B) R343.1 U1.AE13
STRAP_VS0_UPSTRM_PORTSEL_1: R32.2(B) R344.1 U1.H10
STRAP_VS0_UPSTRM_PORTSEL_2: R33.2(B) R345.1 U1.K18
STRAP_VS_MODE_0: R177.2(B) R178.1 U1.AB8
STRAP_VS_MODE_1: R179.2(B) R180.1 U1.AF16
THER_SEN1_DN_1: C468.2(B) Q5.2(E) U10.3
THER_SEN1_DN_2: C469.2(B) Q6.2(E) U10.5
THER_SEN1_DP_1: C468.1 Q5.1 Q5.3 U10.2
THER_SEN1_DP_2: C469.1 Q6.1 Q6.3 U10.4
THER_SEN2_DN: C260.2(B) Q27.2(E) U4.3
THER_SEN2_DP: C260.1 Q27.1 Q27.3 U4.2
TP_A19: J5.A19
TP_A32: J5.A32
TP_A33: J5.A33
TP_A50: J5.A50
TP_B12: J5.B12
TP_B82: J5.B82
TP_JTAG_TCK: U1.AB7
TP_JTAG_TDI: U1.D1
TP_JTAG_TDO: U1.AF13
TP_JTAG_TMS: U1.N8
TP_P0V9_FAULT: PU21.7
TP_P0V9_GH1: PU15.6
TP_P0V9_GH2: PU13.6
TP_P0V9_GL1: PU15.36
TP_P0V9_GL2: PU13.36
TP_PE_SLOT1_A19: J1.A19
TP_PE_SLOT1_A32: J1.A32
TP_PE_SLOT1_A33: J1.A33
TP_PE_SLOT1_A50: J1.A50
TP_PE_SLOT1_B82: J1.B82
TP_SHPC_INT_N: U1.AF9
TP_STRAP_SNT0_PORTCFG0: U1.AD8
TP_STRAP_SNT1_PORTCFG0: U1.H12
TP_STRAP_SNT2_PORTCFG0: U1.AE21
TP_STRAP_SNT3_PORTCFG0: U1.K23
TP_STRAP_SNT4_PORTCFG0: U1.AD26
TP_STRAP_SNT5_PORTCFG0: U1.J28
TP_VS0_FATAL_ERR_N: U1.U8
TP_VS0_PEX_INTA_N: U1.J14
TP_VS1_FATAL_ERR_N: U1.J17
TP_VS1_PEX_INTA_N: U1.B1
TP_VS2_FATAL_ERR_N: U1.AE20
TP_VS2_PEX_INTA_N: U1.AG25
TP_VS3_FATAL_ERR_N: U1.A31
TP_VS3_PEX_INTA_N: U1.G24
TPS7A37_OUT: PC536.1 PC537.1 PC538.1 PR355.1 PU18.1 SHORT105.1
UNNAMED_72_CAP_I208_B: PC700.2(B) PR800.1 PU21.21
UNNAMED_72_CAP_I211_A: PC701.1 PR801.1 PU21.19
UNNAMED_73_INDUCTORS4P_I32_1B: PL2.1B PR308.1
UNNAMED_73_INDUCTORS4P_I32_2B: PL2.2B PR310.1
UNNAMED_73_INDUCTORS4P_I61_1B: PL3.1B PR309.1
UNNAMED_73_INDUCTORS4P_I61_2B: PL3.2B PR311.1
VR_P0V9_12VIN: PC453.1 PC454.1 PC455.1 PC456.1 PC457.1 PC458.1 PC459.1 PC460.1 PC461.1 PC462.1 PC463.1 PC464.1 PC465.1 PC466.1 PC559.1 PL10.2 PL510.2 PR400.2(B) PU13.8 PU13.9 PU13.10 PU13.11 PU13.12 PU13.13 PU13.14 PU13.42 PU15.8 PU15.9 PU15.10 PU15.11 PU15.12 PU15.13 PU15.14 PU15.42
VR_P0V9_BT1: PC470.2(B) PU15.4
VR_P0V9_BT2: PC469.2(B) PU13.4
VR_P0V9_PH1: PR305.2(B) PU15.7
VR_P0V9_PH1_R: PC470.1 PR305.1
VR_P0V9_PH2: PR304.2(B) PU13.7
VR_P0V9_PH2_R: PC469.1 PR304.1
VR_P0V9_SW1: PL2.1A PR306.1 PU15.15 PU15.29 PU15.30 PU15.31 PU15.32 PU15.33 PU15.34 PU15.35 PU15.43
VR_P0V9_SW1_SNB: PC471.1 PR306.2(B)
VR_P0V9_SW2: PL3.1A PR307.1 PU13.15 PU13.29 PU13.30 PU13.31 PU13.32 PU13.33 PU13.34 PU13.35 PU13.43
VR_P0V9_SW2_SNB: PC472.1 PR307.2(B)
VR_P0V9A_BT: PC587.1 PU23.14
VR_P0V9A_PVIN: PC584.1 PC585.1 PC586.1 PC588.1 PC1585.1 PC1586.1 PC1588.1 PC1589.1 PL20.1 PR426.1 PU23.13
VR_P0V9A_SW: PC587.2(B) PL11.1 PU23.12
VR_P1V8A_BT: PC546.1 PU19.14
VR_P1V8A_PVIN: PC543.1 PC545.1 PC548.1 PC550.1 PL9.1 PR370.1 PU19.12
VR_P1V8A_SW: PC546.2(B) PL8.1 PU19.11
VR_P3V3_BT: PC514.1 PU17.14
VR_P3V3_PVIN: PC511.1 PC515.1 PC517.1 PC519.1 PC520.1 PC521.1 PC523.1 PC1523.1 PL7.1 PL12.1 PR341.1 PU17.13
VR_P3V3_STBY_BT: PC496.1 PU16.14
VR_P3V3_STBY_PVIN: PC493.1 PC495.1 PC498.1 PC620.1 PC621.1 PC1621.1 PL5.1 PR324.1 PU16.12
VR_P3V3_STBY_SW: PC496.2(B) PL4.1 PU16.11
VR_P3V3_SW: PC514.2(B) PL6.1 PU17.12

Pads without a net: H1 MG1 MG2 MG3 MG4; J2 A19 A32 A33 A50 B17 B31 B48 B82; J3 A19 A32 A33 A50 B17 B31 B48 B82; J4 A19 A32 A33 A50 B17 B31 B48 B82; J9 A19 A32 A33 A50 B17 B31 B48 B82; NOREF#9 1; NOREF#18 1; NOREF#19 1; NOREF#46 1; NOREF#64 1; NOREF#98 1; NOREF#114 1; NOREF#115 1; NOREF#116 1; PU13 38; PU20 4 5; PU22 4 5; U1 AA1 AA2 AA4 AA5 AB27 AB28 AC1 AC2 AC4 AC5 AD1 AD2 AD4 AD5 AE1 AE2 AE4 AE5 AE7 AE8 AE27 AE28 AF1 AF2 AF4 AF5 AG1 AG2 AG4 AG5 AG9 AG11 AG17 AG21 AG24 AG27 AH1 AH2 AH4 AH5 AH7 AH8 AH9 AH11 AH17 AH21 AH24 AH27 AJ1 AJ2 AJ4 AJ5 AK1 AK2 AK4 AK5 AK7 AK8 AK9 AK10 AL7 AL8 AL9 AL10 AN7 AN8 AN9 AN10 AP7 AP8 AP9 AP10 G7 G11 G14 G18 G22 G26 G27 G28 H7 H11 H14 H18 H22 H26 J7 J8 L7 L8 L27 L28 R27 R28 T7 T8 V1 V2 V4 V5 W1 W2 W4 W5 W27 W28 Y1 Y2 Y4 Y5 Y7 Y8; U8 1; U13 1; U15 1; U16 1; U17 1; U18 1; U19 1; U20 1; U21 1; U47 1

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 3498 vias
v2: diameter 0.635, hole 0.318, TOP to BOTTOM, 74 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 120 vias
v4: diameter 0.483, hole 0.254, TOP to BOTTOM, 912 vias
v5: diameter 0.762, hole 0.381, TOP to BOTTOM, 34 vias
v6: diameter 0.762, hole 0.254, TOP to BOTTOM, 32 vias
v7: diameter 0.66, hole 0.254, TOP to BOTTOM, 6 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
GND: length 1054.2
  TOP w0.178: v1(310.34,52.63) 310.06,52.63 309.8,52.89 U9.4
  TOP w0.203: PR376.1 52.7,101.65 55.43,101.65 56.96,100.13 64.43,100.13 64.71,99.85 65.81,99.85 v1(66.04,100.08)
  TOP w0.254: PU13.37 34.18,86.18 ; v4(73.36,72.13) 72.89,71.65 71.45,71.65 R49.1 ; R14.1 80.88,71.43 C284.2 ; PR356.2 110.35,40.75 v1(110.35,41.17) ; PC580.2 71.99,37.07 v1(72.37,37.45) ; U10.6 163.57,82.61 v1(163.68,82.5) ; C419.2 74.88,72.63 C417.2 ; C12.2 92.56,85.62 93.07,86.13 v4(93.36,86.13) ; U15.3 283.05,68.06 283.14,68.15 v1(283.72,68.15) ; C295.2 89.87,77.65 C367.2 ; C367.2 89.85,77.65 v4(89.36,78.13) ; C367.2 89.85,76.63 C409.2 89.85,76.63 C320.2 ; C401.2 C407.2 74.89,78.62 C387.2 C350.2 ; C325.2 74.89,84.63 C328.2 C354.2 ; C338.2 89.84,85.63 C342.2 ; C323.2 72.88,75.63 C403.2 ; U13.3 284.19,89.3 v1(283.8,88.9) ; C347.2 87.87,80.73 C311.2 87.84,81.66 C340.2 87.84,83.63 C427.2 87.84,84.63 C336.2 ; PU13.5 32.36,87.49 ; PU15.37 34.18,97.87 ; PC489.2 313.94,89.49 v1(313.97,89.46) ; PU15.5 32.36,99.25
  TOP w0.305: PC570.2 31.58,108.56 PQ6.1 32.44,108.47 v1(32.81,108.11) 32.82,108.1 32.82,107.51 33.16,107.17 PQ6.4 33.56,106.69 33.71,106.55 PR403.2 33.07,105.33 PR399.2 ; v1(21.87,113.13) 22.03,113.13 PC567.2 ; PC576.2 22.89,110.71 v1(23.14,110.46) ; PC566.2 v1(16.97,114.5) PC573.2 ; v1(23.14,109.47) 22.89,109.72 PR409.2 ; PR315.2 315.85,85.44 315.83,85.47 v1(315.83,85.62) ; U2.12 300.89,39.32 v1(300.43,38.86)
  TOP w0.356: C454.2 281.4,88.55 U18.3
  TOP w0.381: R166.1 v1(114.76,74.04) ; C345.2 U1.N14 v4(86.36,77.13) 86.86,77.62 C364.2 ; C331.2 85.89,88.6 v4(86.36,88.13) ; C447.2 79.84,72.65 v4(79.36,73.13) ; v4(72.36,80.13) 72.87,79.62 C405.2 ; v4(73.36,79.13) 72.88,78.65 C363.2 ; v4(80.36,89.13) U1.W26 C422.2 ; C350.2 74.86,79.64 v4(74.36,80.13) 74.87,80.63 C352.2 ; C450.2 v1(118.8,34.54) ; v4(77.36,75.13) 77.84,74.65 C404.2 ; C415.2 74.87,74.64 v4(74.36,74.13) 74.87,73.63 C417.2 ; C443.2 77.85,88.62 v4(77.36,88.13) 77.85,87.64 C271.2 77.86,87.63 v4(78.36,87.13) 78.87,86.63 C287.2 78.89,86.61 v4(79.36,86.13) 79.84,85.65 C274.2 ; C413.2 87.87,76.62 v4(88.36,76.13) 87.86,75.63 C366.2 ; C269.2 83.85,83.61 v4(83.36,83.13) 82.88,82.65 C270.2 82.39,82.13 v4(82.36,82.13) ; C449.2 74.86,86.63 v4(74.36,86.13) 74.87,85.63 C354.2 ; C360.2 72.87,83.63 v4(72.36,84.13) ; v4(82.36,90.13) 81.89,90.61 C15.2 ; v4(84.36,82.13) 84.39,82.13 C294.2 84.88,82.65 v4(85.36,83.13) 85.84,83.6 C365.2 ; v4(89.36,78.13) 89.85,78.61 C319.2 89.86,78.63 v4(90.36,79.13) ; C310.2 83.88,90.61 v4(84.36,90.13) 83.88,89.65 C399.2 ; C428.2 78.89,88.61 v4(79.36,88.13) ; R329.2 v1(108.66,75.95) ; C398.2 80.88,80.64 v4(80.36,80.13) 79.83,80.67 C434.2 ; v4(72.36,92.13) 71.9,91.67 C286.2 ; R72.1 v1(108.66,93.22) ; C396.2 80.87,78.64 v4(80.36,78.13) 79.87,78.63 C438.2 79.84,78.65 v4(79.36,79.13) 78.88,79.61 C436.2 ; C277.2 76.86,86.63 v4(76.36,87.13) ; C435.2 76.88,77.61 v4(77.36,77.13) 77.85,76.65 C424.2 77.86,76.63 v4(78.36,76.13) 78.87,75.63 C444.2 79.36,75.15 v4(79.36,75.13) 79.84,74.65 C426.2 80.34,74.13 v4(80.36,74.13) 80.88,74.64 C402.2 ; C439.2 74.89,89.65 v4(75.36,90.13) 74.88,90.61 C312.2 ; R311.1 v1(108.66,87.5) ; R48.1 v1(114.76,70.23) ; R47.1 v1(108.66,66.42) ; C386.2 82.87,89.63 v4(83.36,89.13) ; C418.2 81.86,75.64 v4(82.36,75.13) 82.87,74.63 C275.2 83.36,74.14 v4(83.36,74.13) 83.84,73.66 C273.2 83.86,73.63 v4(84.36,73.13) ; v4(72.36,90.13) 72.86,89.63 C324.2 72.89,89.6 v4(73.36,89.13) 73.86,88.64 C314.2 ; C391.2 v4(73.36,72.13) ; R346.2 v1(114.76,68.33) ; v1(312.62,44.83) R286.2 R284.2 ; PR323.2 v1(315.83,85.62) ; C456.2 v1(280.89,31.01) ; C393.2 85.88,81.65 v4(86.36,82.13) ; v4(80.36,83.13) 80.85,82.64 C410.2 ; R315.1 121.44,89.41 v1(121.7,89.15) ; R337.1 v1(105.49,79.76) ; C21.2 78.89,82.6 v4(79.36,82.13) ; PC468.2 35.08,101.45 35.53,101.9 v1(35.53,102.08) ; v4(77.36,86.13) 77.85,85.64 C296.2 ; R230.1 v1(47.83,53.09) ; R323.2 v1(105.49,93.22) ; PC564.2 15.29,114.73 v1(15.8,115.24) ; C359.2 88.91,72.67 v4(89.36,73.13) 89.84,72.65 C293.2 ; C408.2 80.85,86.65 v4(80.36,87.13) 79.87,87.62 C285.2 ; C329.2 86.84,89.66 v4(86.36,90.13) ; v4(70.36,78.13) 70.36,78.08 69.48,77.2 R54.1 ; v4(73.36,73.13) 72.88,73.61 C361.2 ; R71.1 v1(108.66,95.12) ; C282.2 82.88,80.61 v4(83.36,80.13) 83.85,79.65 C283.2 83.87,79.63 v4(84.36,79.13) ; R46.1 v1(105.49,68.33) ; C470.2 v1(301.45,25.53) ; v1(305.87,30.23) 305.82,30.28 305.82,30.66 R80.2 ; v1(283.67,47.88) 283.18,47.39 U16.3 ; v4(86.36,86.13) 86.87,85.63 C335.2 ; v4(86.36,86.13) U1.N22 C299.2 85.85,85.61 v4(85.36,85.13) 84.88,84.64 C280.2 ; v4(86.36,86.13) 86.86,86.63 C433.2 ; R13.1 69.67,54.1 69.17,54.61 v1(68.78,54.61) R129.2 ; C425.2 74.87,75.63 v4(74.36,76.13) 74.87,76.63 C401.2 ; C440.2 78.88,77.61 v4(79.36,77.13) 79.84,76.65 C442.2 79.87,76.63 v4(80.36,76.13) 80.87,76.64 C416.2 ; R282.2 v1(315.16,44.83) ; v4(78.36,85.13) 78.86,84.63 C276.2 ; C362.2 85.84,71.65 v4(85.36,72.13) 84.88,71.64 C389.2 ; v4(69.36,70.13) 69.87,70.63 C288.2 ; C291.2 v4(71.36,79.13) ; v1(282.86,64.01) 282.86,64.59 282.69,64.76 U19.3 ; C458.2 89.61,80.37 v4(89.36,80.13) 88.89,80.61 C349.2 88.84,80.61 v4(88.36,80.13) 87.84,80.65 C347.2 ; R45.1 v1(111.71,70.23) ; C327.2 75.86,82.63 v4(76.36,83.13) 76.87,83.63 C353.2 ; R321.2 v1(114.63,89.41) ; R313.1 v1(114.76,77.85) ; R57.1 72.13,81.9 v4(72.36,82.13) ; v1(64.71,37.26) PC584.2 ; R167.1 v1(117.93,72.14) ; R294.2 v1(314.28,32.44) ; v1(292.27,7.04) 292.27,6.38 292.83,5.83 J5.A4 ; R211.1 v1(105.49,87.5) ; C429.2 89.86,82.62 v4(90.36,83.13) ; R219.1 v1(117.93,68.33) ; U47.3 276.41,22.21 v1(276.68,22.48) ; v4(89.36,89.13) 88.87,89.63 C333.2 88.85,89.64 v4(88.36,90.13) ; v4(88.36,88.13) 87.88,88.61 C397.2 ; R217.1 v1(108.66,74.04) ; C355.2 79.85,83.65 v4(79.36,84.13) ; v4(76.36,85.13) 76.86,84.63 C278.2 ; v4(87.36,71.13) 87.85,71.62 C318.2 87.86,71.63 v4(88.36,72.13) U1.L9 C358.2 ; v1(302.57,21.67) 302.73,21.5 U22.3 ; R182.2 v1(114.89,66.42) ; C394.2 80.85,84.65 v4(80.36,85.13) ; v4(90.36,87.13) 89.87,87.62 C316.2 ; v4(78.36,89.13) 77.86,89.64 C445.2 ; C406.2 78.86,73.63 v4(78.36,74.13) 77.87,73.63 C437.2 ; C403.2 72.86,76.63 v4(72.36,77.13) ; C10.2 81.91,72.68 v4(82.36,73.13) 81.84,73.65 C414.2 ; C431.2 86.87,87.63 v4(86.36,88.13) ; R44.1 v1(121.24,72.14) ; C390.2 81.87,87.64 v4(82.36,88.13) 81.89,88.6 C388.2 ; R10.1 v1(82.12,54.61) ; R42.1 v1(117.93,70.23) ; R345.2 v1(124.41,79.76) ; v4(72.36,85.13) 72.86,84.63 C313.2 ; C448.2 76.86,80.62 v4(76.36,80.13) ; v1(35.46,90.26) 35.46,90.01 PC467.2 ; R241.1 v1(118.06,87.5) ; C300.2 85.85,73.65 v4(85.36,74.13) 84.89,74.6 C22.2 84.87,74.63 v4(84.36,75.13) 83.87,75.63 C292.2 83.84,75.65 v4(83.36,76.13) 83.36,76.16 C272.2 82.86,76.63 v4(82.36,77.13) 81.86,77.63 C432.2 ; R309.1 v1(114.76,72.14) ; v4(78.36,80.13) 77.87,79.63 C446.2 77.85,79.61 v4(77.36,79.13) 76.89,78.65 C411.2 ; C348.2 74.87,87.63 v4(74.36,88.13) 74.87,88.63 C441.2 ; R133.2 v1(108.66,68.33) ; PC481.2 v1(48.34,89.15) ; R218.1 v1(108.66,79.76) ; R288.2 v1(66.88,54.61) ; R318.2 v1(70.69,51.69) ; U21.3 v1(283.65,85.08) ; R82.2 v1(309.45,42.42) ; C356.2 87.86,74.63 v4(88.36,74.13) 87.86,73.63 C357.2 ; v1(280.75,28.29) 280.13,27.67 U8.3 ; R320.2 v1(45.52,54.05) ; v1(281.38,52.07) 281.76,51.69 C455.2 ; R208.1 v1(50.75,56.9) ; C160.2 158.29,81.18 v1(157.15,82.32) ; v4(76.36,76.13) 76.87,75.63 C420.2 ; R175.2 v1(67.77,53.85) ; v4(91.36,77.13) 90.86,77.64 C295.2 ; R312.1 v1(121.49,91.31) ; v4(86.36,79.13) 86.86,79.63 C343.2 ; v4(86.36,79.13) 86.87,78.63 C395.2 ; v4(86.36,79.13) 85.87,78.63 C351.2 ; PC487.2 47.58,88.57 v1(47.58,89.15) ; R265.1 v1(111.71,89.41) ; R176.2 v1(117.93,66.42) ; C322.2 72.88,77.62 v4(73.36,77.13) ; C430.2 84.88,80.61 v4(85.36,80.13) 84.89,79.65 C9.2 ; C13.2 91.84,90.66 v4(91.36,91.13) ; v4(86.36,88.13) 85.86,87.63 C301.2 85.84,87.6 v4(85.36,87.13) 84.89,86.65 C16.2 84.86,86.63 v4(84.36,86.13) 83.87,85.63 C17.2 83.85,85.61 v4(83.36,85.13) 82.89,84.65 C18.2 82.39,84.13 v4(82.36,84.13) 81.85,83.62 C392.2 ; C223.2 v1(308.7,34.31) ; v4(77.36,90.13) 76.88,90.61 C14.2 ; C419.2 74.86,72.63 v4(74.36,72.13) ; R73.1 v1(105.49,91.31) ; v1(118.47,42.11) 118.7,42.11 119.12,41.69 U12.4 ; R53.1 v1(68.78,51.69) ; C342.2 89.84,85.65 v4(89.36,86.13) ; C289.2 82.88,72.61 v4(83.36,72.13) 82.89,71.66 C376.2 82.89,71.61 v4(83.36,71.13) 82.84,70.61 R43.1 ; v4(80.36,72.13) 80.87,71.62 C284.2 ; C400.2 81.87,85.64 v4(82.36,86.13) 82.86,86.63 C268.2 82.88,86.65 v4(83.36,87.13) 83.84,87.61 C281.2 83.86,87.63 v4(84.36,88.13) 84.84,88.61 C326.2 ; PC488.2 v1(48.92,99.39) ; C297.2 76.88,82.61 v4(77.36,82.13) ; R319.2 v1(118.06,74.04) ; R2.2 312.75,51.94 v1(313.13,51.56) ; R135.2 v1(118.06,75.95) ; R69.1 v1(108.66,91.31) ; R50.1 U1.AE18 v4(73.36,82.13) 72.89,82.61 C317.2 ; R170.1 v1(50.75,58.8) ; R165.1 v1(61.04,51.42) ; PC543.2 v1(84.79,42.29) ; R327.2 v1(105.49,77.85) ; PC485.2 v1(49.86,90.45) ; R244.1 v1(118.06,89.41) ; R314.1 v1(121.24,74.04) ; v4(79.36,90.13) 78.88,90.61 C298.2 ; R168.1 v1(64.97,51.69) ; PC542.2 78.61,35.09 v1(78.78,35.26) ; R164.1 v1(105.49,70.23) R41.1 ; R140.2 v1(47.83,56.9) ; C320.2 89.87,75.63 v4(90.36,75.13) ; R331.2 v1(118.06,79.76) ; U17.3 282.92,27.8 v1(282.4,28.32) ; v4(75.36,93.13) 74.98,92.75 C457.2 ; R242.1 v1(111.71,87.5) ; R292.2 v1(118.06,77.85) ; R336.1 v1(105.49,72.14) ; R343.2 v1(58.37,51.42) ; v4(89.36,83.13) 89.84,83.6 C315.2 ; C377.2 78.87,71.62 ; 78.87,71.62 78.86,71.62 v4(78.36,71.13) ; 78.87,71.62 v4(78.36,72.13) ; R325.1 v1(111.71,79.76) ; PR340.2 v1(302.46,106.3) ; R205.1 v1(59.89,51.42) ; C423.2 72.89,85.65 v4(73.36,86.13) 73.81,86.58 C11.2 ; R322.2 v1(105.49,95.12) ; R76.1 v1(303.61,47.62) ; R316.1 v1(105.49,75.95) ; v4(86.36,75.13) 85.87,75.63 C279.2 85.85,75.65 v4(85.36,76.13) 85.36,76.15 C20.2 84.87,76.63 v4(84.36,77.13) 83.87,77.62 C290.2 83.85,77.65 v4(83.36,78.13) 82.88,78.61 C19.2 82.87,78.63 v4(82.36,79.13) 81.85,79.64 C412.2 ; v1(315.55,32.44) 315.55,32.92 C452.2 ; R70.1 v1(108.66,89.41) ; R344.2 v1(108.66,72.14) ; R84.2 v1(310.59,42.42) ; R74.1 v1(105.49,89.41) ; C321.2 76.86,71.63 v4(76.36,72.13) 76.87,72.64 C421.2 ; R255.1 v1(111.71,97.03) ; U20.3 v1(283.53,44.56) ; R207.1 v1(50.75,54.99) ; R243.1 v1(118.06,91.31)
  TOP w0.457: v1(64.76,47.47) 65.48,47.47 PC581.1 ; PC541.2 83.01,34.21 84.03,34.21 v1(84.43,33.81) ; v1(48.92,99.39) 49.07,99.24 PC480.2 v1(50.57,99.24) ; PC558.2 v1(20.07,99.54) ; v1(70.7,47.31) PC583.2
  TOP w0.508: J5.A71 223.83,6.54 v1(223.33,7.04) ; R173.2 74.5,51.82 v1(74.37,51.69) 74.37,50.77 C368.2 ; v1(216.23,82.55) 215.6,83.19 R198.1 ; v1(233.32,7.04) 232.83,6.55 J5.A62 ; C462.2 v1(286.82,65.13) ; J5.A42 252.83,6.55 v1(252.33,7.04) ; C251.2 C250.2 v1(296.52,12.19) ; v1(56.21,98.93) 56.29,98.86 C382.2 PC483.2 ; J5.A41 253.83,6.55 v1(254.32,7.04) ; v1(239.33,7.04) 239.83,6.54 J5.A55 ; v1(256.32,7.04) 256.83,6.53 J5.A38 ; R200.1 214.12,43.05 v1(215.19,41.99) ; C252.2 287.99,23.75 v1(288.62,24.38) ; Q1.S 169.9,111.89 v1(168.86,111.89) ; v1(306.91,22.35) 306.57,22.01 Q7.S ; R197.1 v1(214.73,102.98) ; C248.2 v1(286.84,64.39) ; J5.A31 263.83,6.07 264.33,6.57 v1(264.33,7.04) ; C253.2 C254.2 v1(284.43,11.81) ; J5.A54 240.83,6.53 v1(241.34,7.04) ; v1(280.75,22.48) 280.75,22.75 C159.2 ; v1(235.31,7.04) 235.83,6.53 J5.A59 ; R267.1 v1(111.71,91.31) ; R266.1 v1(114.63,93.22) ; v1(268.34,7.04) 267.83,6.53 J5.A27 ; R15.1 v1(78.31,51.69) ; v1(231.33,7.04) 231.83,6.54 J5.A63 ; v1(260.33,7.04) 260.83,6.55 J5.A34 ; J5.A18 276.83,5.99 277.33,6.49 v1(277.33,7.04) ; v1(272.33,7.04) 271.83,6.54 J5.A23 ; J5.A49 245.83,5.97 246.32,6.47 v1(246.32,7.04) ; v1(216.03,62.31) 215.34,62.99 R199.1 ; v1(229.33,7.04) 228.83,6.54 J5.A66 ; J5.A45 249.83,6.53 v1(250.33,7.04) ; R68.1 v1(111.71,93.22) ; R111.1 v1(68.78,57.53) ; R174.2 v1(76.4,57.53) ; C241.2 v1(287.22,84.58) ; J5.A67 227.83,6.55 v1(227.34,7.04) ; J5.A51 243.83,6.55 v1(243.34,7.04) ; J5.A74 220.83,6.54 v1(221.33,7.04) ; C156.2 v1(287.35,29.59) ; J5.A37 257.83,6.53 v1(258.33,7.04) ; v1(311.4,42.42) 311.35,42.37 U7.4 ; J5.A58 236.83,6.54 v1(237.33,7.04) ; R358.1 292.56,12.06 292.83,12.33 J1.A4 ; v1(215.6,7.04) 215.83,6.82 J5.A79 ; PC572.2 v1(18.87,116.33) ; R112.1 v1(78.31,57.53) ; v1(248.32,7.04) 248.83,6.53 J5.A46 ; C459.2 v1(286.21,84.96) ; J5.A28 266.83,6.54 v1(266.33,7.04) ; R75.1 v1(114.63,91.31) ; PC568.2 v1(21.41,116.33) ; Q2.S 169.9,115.32 v1(168.86,115.32) ; R256.1 v1(114.63,95.12) ; C234.2 v1(284.68,103.25) ; J5.A20 274.83,6.54 v1(274.33,7.04) ; R17.1 v1(70.69,57.53) ; v1(280.47,71.65) C453.2 ; R12.1 v1(72.59,54.61) ; R178.2 v1(80.21,57.53) ; v1(77.03,51.68) 77.03,51.95 76.68,52.3 R18.1 ; J5.A75 219.83,6.53 v1(219.31,7.04) ; C460.2 v1(279.1,90.68) ; v1(225.34,7.04) 224.83,6.53 J5.A70 ; R206.1 v1(82.12,51.69) ; R16.1 v1(72.59,57.53) ; C454.2 282.04,88.54 v1(282.14,88.65) ; v1(270.34,7.04) 270.83,6.55 J5.A24 ; C158.2 v1(286.84,44.2) ; v1(279.33,7.04) 279.83,6.55 J5.A15 ; v1(217.31,7.04) 216.83,6.55 J5.A78 ; C139.2 278.1,31.01 v1(278.08,30.99) ; C467.2 v1(15.83,86.36) ; C461.2 v1(286.82,45.07) ; R324.1 v1(78.31,54.61) ; R67.1 v1(111.71,95.12) ; R290.2 v1(64.97,54.61) ; C465.2 19.38,100.71 v1(19.66,100.43) ; R11.1 v1(76.4,54.61) ; R169.1 v1(80.21,51.69) ; C157.2 v1(288.37,29.59)
  TOP w0.762: Q4.S v1(317.1,53.78) ; CON1.4 v1(191.84,109.78) ; Q3.S v1(317.14,49.59)
  IN1 w0.089: 67.49,99.42 67.51,99.4 67.51,99.32 67.94,98.89 67.94,95.88 68.11,95.71 69.66,95.71 69.96,95.41 69.96,81.77 70.26,81.47 79.71,81.47 79.83,81.6 79.83,81.92 79.62,82.13 v4(79.36,82.13)
  IN1 w0.203: v1(66.04,100.08) 66.27,99.85 67.06,99.85 67.49,99.42
  IN2 w0.089: 63.2,88.77 63.22,88.77 63.28,88.71 73.74,88.71 73.98,88.47 73.98,81.44 74.48,80.94 77.65,80.94 77.97,80.62 77.97,77.73 v4(77.36,77.13)
  IN2 w0.178: 63.2,88.77 62.43,88.77 43.16,69.49 43.16,55.42 v1(42.98,55.24)
  BOTTOM w0.127: 76.42,69.19 v4(76.36,69.13)
  BOTTOM w0.254: R254.1 66.5,107.09 v2(66.52,107.11) ; PC506.2 302.83,114.79 PR333.2 303.1,113.54 v1(303.99,113.54) ; v1(42.98,55.24) 43.13,55.09 43.13,54.86 42.95,54.69 39.21,54.69 36.22,51.69 36.22,47.3 36.74,46.79 37.14,46.79 PR435.2 ; PR401.2 16.87,114.6 v1(16.97,114.5) ; PC539.2 79.68,41.33 ; U4.5 v1(308.39,79.72)
  BOTTOM w0.305: PC578.2 PR414.2 ; PR406.2 31.48,106.23 31.98,106.73 31.98,107.11 PQ7.1
  BOTTOM w0.356: U1.AP31 64.42,95.07 ; U1.U32 82.31,96.07 ; U1.P32 85.31,96.07 ; U1.F32 93.31,96.07 ; U1.F7 93.31,70.19 ; U1.AJ32 69.42,96.07 ; U1.AB6 76.42,69.19 ; U1.K32 89.31,96.07 ; U1.F21 93.31,85.07 ; U1.AJ19 69.42,83.07 ; U1.D33 95.31,97.07 ; U1.A34 98.31,98.07 ; v1(77.37,36.38) 76.99,36.75 PR361.2 ; J8.13 11.7,72.73 v1(11.69,72.74) ; U1.F20 93.31,84.07 ; U1.D30 95.31,94.07 ; U1.D32 95.31,96.07 ; U1.AL31 67.42,95.07 ; U1.AD13 74.42,76.19 ; U1.D31 95.31,95.07 ; U1.H32 91.31,96.07 ; U1.T32 83.31,96.07 ; U1.AN31 65.42,95.07 ; U1.M32 87.31,96.07 ; U1.F22 93.31,86.07 ; U1.D34 95.31,98.07
  BOTTOM w0.381: U1.B4 v4(97.36,67.13) ; U1.AM6 v4(66.36,69.13) ; U1.F3 v4(93.36,66.13) ; U1.V23 v4(80.36,87.13) U1.W24 v4(79.36,88.13) U1.Y25 v4(78.36,89.13) U1.AA26 v4(77.36,90.13) ; U1.AM12 v4(66.36,75.13) ; U1.P21 v4(85.36,85.13) U1.N22 v4(86.36,86.13) ; v4(73.36,79.13) U1.AE16 v4(74.36,80.13) U1.AD17 ; 89.31,96.07 v4(89.36,96.13) ; U1.L3 v4(88.36,66.13) ; U1.B29 v4(97.36,93.13) ; U1.AM7 v4(66.36,70.13) ; v1(17.1,74.54) 17.08,74.53 J8.35 ; J7.47 v1(17.21,40.08) ; U1.C13 v4(96.36,76.13) ; v4(86.36,75.13) U1.N12 v4(85.36,76.13) U1.P13 v4(84.36,77.13) U1.R14 v4(83.36,78.13) U1.T15 v4(82.36,79.13) U1.U16 ; U1.E2 v4(94.36,65.13) ; PC511.2 295.59,113.44 v1(295.38,113.65) ; U1.AE32 v4(73.36,96.13) ; v4(78.36,72.13) U1.Y9 v4(79.36,73.13) U1.W10 v4(80.36,74.13) U1.V11 ; 69.42,96.07 v4(69.36,96.13) ; J7.26 16.86,52.68 v1(17.1,52.91) ; U1.V29 v4(80.36,93.13) ; v1(17.17,78.14) 17.16,78.13 J8.29 ; U1.AJ7 v4(69.36,70.13) ; U1.K28 v4(89.36,92.13) ; U1.K3 v4(89.36,66.13) ; U1.J3 v4(90.36,66.13) ; U1.AH10 v4(71.43,74.2) ; U1.W18 v4(79.36,82.13) U1.Y19 v4(78.36,83.13) ; U1.U3 v4(82.36,66.13) ; U1.AM30 v4(66.36,94.13) ; R63.1 v1(57.35,111.71) ; U1.R18 v4(84.36,82.13) U1.P19 v4(85.36,83.13) ; U1.AG32 v4(71.36,96.13) ; 69.42,83.07 v4(69.36,83.13) ; U1.F28 v4(93.36,92.13) ; v4(76.36,76.13) U1.AB13 v4(77.36,77.13) U1.AA14 ; U1.C24 v4(96.36,88.13) ; v1(17.35,45.67) 17.15,45.48 J7.38 ; U1.AB21 v4(76.36,85.13) ; U1.AD24 v4(74.36,88.13) U1.AE25 v4(73.36,89.13) ; 93.31,96.07 v4(93.36,96.13) ; PR414.2 34.23,108.76 PQ7.4 33.16,108.45 v1(32.81,108.11) 32.81,107.54 32.43,107.15 PQ7.1 ; U1.C14 v4(96.36,77.13) ; U1.C12 v4(96.36,75.13) ; U1.AL6 v4(67.36,69.13) ; U1.F12 v4(93.36,75.13) ; U1.N26 v4(86.36,90.13) ; U1.Y32 v4(78.36,96.13) ; v4(86.36,79.13) U1.N16 v4(85.36,80.13) U1.P17 ; U1.C18 v4(96.36,82.13) ; v1(290.27,7.08) 290.17,6.98 290.17,6.12 289.83,5.78 J5.B7 ; J8.44 16.95,69.13 v1(17.1,68.98) ; R131.2 v1(110.95,64.52) ; U1.AJ22 v4(69.36,86.13) ; R61.1 v1(57.35,114.76) ; U1.V15 v4(80.36,78.13) U1.W14 v4(79.36,77.13) U1.Y13 v4(78.36,76.13) U1.AA12 v4(77.36,75.13) U1.AB11 v4(76.36,74.13) ; U1.AA7 v4(77.36,70.13) ; v4(83.36,83.13) U1.T19 v4(82.36,82.13) U1.U18 ; v1(17.17,79.89) 17.13,79.93 J8.26 ; U1.AC29 v4(75.36,93.13) ; U1.AP6 v4(65.36,70.13) ; U1.H3 v4(91.36,66.13) ; 85.31,96.07 v4(85.36,96.13) ; v1(11.61,41.9) 11.64,41.87 J7.7 ; U1.C6 v4(96.36,69.13) ; U1.C22 v4(96.36,86.13) ; U1.A4 v4(98.36,67.13) ; U1.AM15 v4(66.36,78.13) ; 95.31,96.07 v4(95.36,96.13) ; J7.13 11.67,45.48 v1(11.66,45.48) ; U1.G17 v4(92.36,80.13) ; 74.42,76.19 v4(74.36,76.13) ; J8.4 11.71,67.33 v1(11.69,67.3) ; U1.AM11 v4(66.36,74.13) ; U1.L22 v4(88.36,86.13) ; U1.C20 v4(96.36,84.13) ; U1.C4 v4(96.36,67.13) ; U1.AM17 v4(66.36,80.13) ; v4(64.47,98.42) 64.47,98.03 U1.AP34 ; U1.AH16 v4(71.36,79.13) ; J8.16 11.73,74.53 v1(11.69,74.49) ; R56.1 v1(51.51,108.71) ; U1.M3 v4(87.36,66.13) ; J7.32 v1(17.32,49.08) ; U1.AN6 v4(65.36,69.13) ; 87.31,96.07 v4(87.36,96.13) ; U1.AM25 v4(66.36,89.13) ; J8.50 17.23,65.53 v1(17.27,65.57) ; C451.2 121.11,41.71 v1(121.41,42.01) ; U1.AE22 v4(73.36,86.13) ; U1.V13 v4(80.36,76.13) U1.W12 v4(79.36,75.13) U1.Y11 v4(78.36,74.13) ; U1.AB17 v4(76.36,80.13) ; v1(11.58,40.04) 11.62,40.08 J7.4 ; PC534.2 v1(115.68,39.51) ; v1(47.83,54.99) 47.98,55.14 R180.2 ; U1.AJ25 v4(69.36,89.13) ; U1.E29 v4(94.36,93.13) ; U1.C11 v4(96.36,74.13) ; U1.G3 v4(92.36,66.13) ; U1.V3 v4(80.36,66.13) ; PR424.2 v1(71.75,44.57) ; U1.AM29 v4(66.36,93.13) ; U1.AL1 v4(67.36,64.13) ; U1.AM18 v4(66.36,82.13) ; J7.35 17.02,47.27 v1(17.22,47.07) ; U1.AB32 v4(76.36,96.13) ; U1.C7 v4(96.36,70.13) ; U1.W32 v4(79.36,96.13) ; U1.L24 v4(88.36,88.13) ; U1.F23 v4(93.36,87.13) ; v4(79.36,90.13) U1.W26 v4(80.36,89.13) U1.V25 ; v4(77.36,79.13) U1.AA16 v4(78.36,80.13) U1.Y17 ; U1.V19 v4(80.36,83.13) U1.W20 v4(79.36,84.13) U1.Y21 v4(78.36,85.13) U1.AA22 v4(77.36,86.13) U1.AB23 v4(76.36,87.13) ; v1(37.97,64.95) 38.41,64.52 U6.4 ; U1.AF7 v4(72.36,70.13) ; U1.AM26 v4(66.36,90.13) ; R52.1 v1(57.35,110.69) ; PR408.2 18.82,111.12 v1(18.29,110.58) ; U1.AP1 v4(64.36,64.13) ; U1.F29 v4(93.36,93.13) ; U1.AJ6 v4(69.36,69.13) ; U1.AB9 v4(76.36,72.13) ; U1.AD32 v4(74.36,96.13) ; U1.C9 v4(96.36,72.13) ; U1.N14 v4(86.36,77.13) ; U1.AM31 v4(66.36,95.13) ; 67.42,95.07 v4(67.36,95.13) ; J8.1 11.71,65.53 v1(11.69,65.55) ; U1.AL3 v4(67.36,66.13) ; U1.AJ15 v4(70.36,79.13) ; U1.U10 v4(82.36,73.13) U1.T9 v4(83.36,72.13) ; U1.AK3 v4(69.36,67.13) ; U1.AM28 v4(66.36,92.13) ; U1.AM14 v4(66.36,77.13) ; U1.C8 v4(96.36,71.13) ; U1.C15 v4(96.36,78.13) ; U1.T17 v4(83.36,80.13) U1.R16 v4(84.36,79.13) ; U1.U6 v4(82.36,69.13) ; R229.1 v1(57.35,112.73) ; 95.31,97.07 v4(95.36,97.13) ; 98.31,98.07 v4(98.36,98.13) ; U1.C10 v4(96.36,73.13) ; U1.F6 v4(93.36,69.13) ; U1.AE18 v4(73.36,82.13) ; 93.31,70.19 v4(93.36,70.13) ; U1.G6 v4(92.36,69.13) ; U1.AC32 v4(75.36,96.13) ; 95.31,95.07 v4(95.36,95.13) ; U1.A1 v4(98.36,64.13) ; U1.U24 v4(82.36,88.13) U1.T25 v4(83.36,89.13) U1.R26 v4(84.36,90.13) ; U1.L32 v4(88.36,96.13) ; U1.L9 v4(88.36,72.13) ; U1.AD3 v4(75.36,67.13) ; 93.31,84.07 v4(93.36,84.13) ; U1.U14 v4(82.36,77.13) U1.T13 v4(83.36,76.13) U1.R12 v4(84.36,75.13) U1.P11 v4(85.36,74.13) ; U1.T3 v4(83.36,66.13) ; v1(11.69,70.9) 11.71,70.93 J8.10 ; U1.P28 v4(85.36,91.13) ; R231.1 v1(65.24,105.81) R254.1 ; U1.AK6 v4(68.36,69.13) ; R232.1 v1(51.51,105.54) ; U1.AJ28 v4(69.36,92.13) ; U1.AA28 v4(77.36,92.13) ; v4(84.36,88.13) U1.R24 v4(83.36,87.13) U1.T23 v4(82.36,86.13) U1.U22 ; U1.AM23 v4(66.36,87.13) ; U1.AM9 v4(67.36,72.13) ; U1.AM20 v4(66.36,84.13) ; U1.C26 v4(96.36,90.13) ; U1.AA32 v4(77.36,96.13) ; U1.K19 v4(89.36,83.13) ; U1.Y3 v4(79.36,67.13) ; U1.E32 v4(94.36,96.13) ; J7.41 16.88,43.68 v1(17.1,43.9) ; U1.U12 v4(82.36,75.13) U1.T11 v4(83.36,74.13) U1.R10 v4(84.36,73.13) U1.P9 v4(85.36,72.13) ; v4(89.36,73.13) U1.K10 v4(88.36,74.13) U1.L11 ; U1.AK31 v4(68.36,95.13) ; U1.E3 v4(94.36,66.13) ; R220.1 v1(107.39,64.52) ; U1.K22 v4(89.36,86.13) ; U1.AD22 v4(74.36,86.13) ; U1.AH25 v4(70.36,89.13) ; U1.AL2 v4(67.36,65.13) ; U1.U26 v4(82.36,90.13) ; U1.N6 v4(86.36,69.13) ; U1.AM19 v4(66.36,83.13) ; U1.AN1 v4(65.36,64.13) ; v1(11.69,69.16) 11.72,69.13 J8.7 ; U1.AF3 v4(73.36,67.13) ; U1.AJ12 v4(70.36,75.13) ; U1.AF32 v4(72.36,96.13) ; 93.31,86.07 v4(93.36,86.13) ; v4(86.36,88.13) U1.N24 v4(85.36,87.13) U1.P23 v4(84.36,86.13) U1.R22 v4(83.36,85.13) U1.T21 v4(82.36,84.13) U1.U20 ; U1.AD9 v4(74.36,72.13) ; v1(11.61,43.65) 11.64,43.68 J7.10 ; v1(17.1,70.73) 16.9,70.93 J8.41 ; U1.K7 v4(89.36,70.13) ; U1.R3 v4(84.36,66.13) ; U1.L26 v4(88.36,90.13) ; 95.31,98.07 v4(95.36,98.13) ; U1.C17 v4(96.36,80.13) ; U1.D29 v4(95.36,93.13) ; U1.C23 v4(96.36,87.13) ; R66.1 v1(51.51,111.76) ; U1.AM3 v4(66.36,66.13) ; U1.C27 v4(96.36,91.13) ; U1.H28 v4(91.36,92.13) ; U1.R32 v4(84.36,96.13) ; U1.C29 v4(96.36,93.13) ; v4(76.36,83.13) U1.AB19 v4(77.36,82.13) U1.AA18 ; U1.N29 v4(86.36,93.13) ; U1.G32 v4(92.36,96.13) ; U1.J32 v4(90.36,96.13) ; U1.AG7 v4(71.36,70.13) ; J8.47 17.26,67.33 v1(17.27,67.31) ; U1.L17 v4(88.36,80.13) ; R51.1 v1(51.51,107.7) ; U1.AK32 v4(68.36,96.13) ; U1.AK33 v4(68.36,97.13) ; J7.44 v1(17.23,41.87) ; U1.P3 v4(85.36,66.13) ; v1(17.1,72.64) 17.01,72.73 J8.38 ; J7.22 11.72,50.87 v1(11.69,50.84) ; U1.AJ3 v4(69.36,66.13) ; R64.1 v1(57.35,113.74) ; U1.E1 v4(94.36,64.13) ; U1.AL4 v4(67.36,67.13) ; U1.C28 v4(96.36,92.13) ; U1.AM10 v4(66.36,73.13) ; 95.31,94.07 v4(95.36,94.13) ; 93.31,85.07 v4(93.36,85.13) ; 65.42,95.07 v4(65.36,95.13) ; U1.AL5 v4(67.36,68.13) ; R60.1 v1(51.51,112.78) ; U1.N3 v4(86.36,66.13) ; U1.AE14 v4(73.36,77.13) ; R253.1 v1(51.51,113.79) ; U1.AJ29 v4(69.36,93.13) ; U1.V21 v4(80.36,85.13) U1.W22 v4(79.36,86.13) U1.Y23 v4(78.36,87.13) U1.AA24 v4(77.36,88.13) ; U1.D4 v4(95.36,67.13) ; U1.AH28 v4(70.36,92.13) ; J7.50 v1(17.19,38.28) ; U1.G12 v4(92.36,75.13) ; U1.AN2 v4(65.36,65.13) ; 64.42,95.07 v4(64.36,95.13) ; J7.25 v1(11.65,52.68) ; U1.V17 v4(80.36,80.13) U1.W16 v4(79.36,79.13) ; R171.1 v1(47.85,57.89) ; U1.K15 v4(89.36,78.13) ; U1.H27 v4(91.36,91.13) ; J8.22 11.72,78.13 v1(11.69,78.09) ; U1.AE10 v4(73.36,73.13) ; U1.AG3 v4(71.36,66.13) ; PR369.2 77.49,36.25 v1(77.37,36.38) ; U1.AC26 v4(75.36,90.13) ; J8.32 17.09,76.33 v1(17.1,76.32) ; U1.C16 v4(96.36,79.13) ; 82.31,96.07 v4(82.36,96.13) ; U1.AM21 v4(66.36,85.13) ; U1.V28 v4(80.36,92.13) ; U1.AH12 v4(71.36,76.13) ; v1(11.69,49.09) 11.7,49.08 J7.19 ; U1.N18 v4(86.36,82.13) ; R268.1 v1(105.49,97.03) ; U1.AD11 v4(74.36,74.13) ; U1.AB3 v4(77.36,67.13) ; J8.19 11.71,76.33 v1(11.69,76.35) ; U1.AJ13 v4(69.36,76.13) ; U1.AH3 v4(71.36,67.13) ; R58.1 v1(57.35,109.68) ; U1.AH29 v4(70.36,93.13) ; U1.E4 v4(94.36,67.13) ; J7.1 11.61,38.28 v1(11.58,38.3) ; U1.AM27 v4(66.36,91.13) ; C256.2 43.24,58.44 44.02,57.66 v1(44.02,56.26) ; U1.K25 v4(89.36,89.13) ; U1.L13 v4(88.36,76.13) ; U1.C25 v4(96.36,89.13) ; U1.V9 v4(80.36,72.13) ; U1.AM16 v4(66.36,79.13) ; U1.V32 v4(80.36,96.13) ; U1.C19 v4(96.36,83.13) ; J7.16 11.71,47.27 v1(11.66,47.23) ; U1.N32 v4(86.36,96.13) ; U1.AE3 v4(73.36,66.13) ; U1.C5 v4(96.36,68.13) ; 91.31,96.07 v4(91.36,96.13) ; J8.25 v1(11.72,79.93) ; U1.AH20 v4(70.36,84.13) ; U1.AF28 v4(72.36,92.13) ; U1.AM13 v4(66.36,76.13) ; R62.1 v1(51.51,109.73) ; U1.F15 v4(93.36,78.13) ; U1.A29 v4(98.36,93.13) ; U1.C21 v4(96.36,85.13) ; 83.31,96.07 v4(83.36,96.13) ; U1.AA3 v4(77.36,66.13) ; R55.1 v1(51.51,106.68) ; U1.AM24 v4(66.36,88.13) ; R65.1 v1(51.51,114.81) ; U1.AM22 v4(66.36,86.13) ; R59.1 v1(51.51,110.74) ; U1.AK34 v4(68.36,98.13) ; U1.AC3 v4(75.36,66.13) ; U1.AM8 v4(66.36,71.13) ; U1.W3 v4(79.36,66.13) ; U1.AH32 v4(70.36,96.13) ; J7.29 v1(17.22,50.87)
  BOTTOM w0.457: PC508.1 297.32,103.43 v1(296.65,103.43) ; v1(33.82,98.57) 34.23,98.97 PR297.2 ; PC493.2 v1(308.69,92.17) ; PC491.2 309.9,83.58 v1(309.17,83.58) ; v1(32.8,98.57) 32.8,98.78 PR303.2 ; PC492.2 314.2,83.64 v1(314.2,82.98) ; v1(33.82,86.88) 34.23,87.29 PR295.2 ; v1(301.93,102.92) PC510.2 ; PR302.2 32.8,87.1 v1(32.8,86.88)
  BOTTOM w0.508: v1(223.33,7.04) 222.83,6.54 J5.B72 ; J5.B60 234.83,6.55 v1(235.31,7.04) ; J5.B77 217.83,6.53 v1(217.31,7.04) ; C226.2 312.9,52.78 v1(313.87,51.82) ; v1(256.32,7.04) 255.83,6.55 J5.B39 ; v1(241.34,7.04) 241.83,6.55 J5.B53 ; v1(292.27,7.04) 292.27,6.48 292.83,5.93 J5.A4 ; v1(281.87,7.04) 281.83,7 J5.B13 ; v1(250.33,7.04) 250.83,6.55 J5.B44 ; v1(254.32,7.04) 254.83,6.53 J5.B40 ; J5.B22 272.83,6.54 v1(272.33,7.04) ; J5.B35 259.83,6.53 v1(260.33,7.04) ; C215.2 v1(309.83,59.31) ; v1(225.34,7.04) 225.83,6.55 J5.B69 ; J5.B16 278.83,6.53 v1(279.33,7.04) ; v1(276.3,7.04) 276.3,6.48 276.83,5.95 J5.A18 ; J5.B57 237.83,6.54 v1(237.33,7.04) ; J5.B68 226.83,6.53 v1(227.34,7.04) ; J5.B26 268.83,6.55 v1(268.34,7.04) ; v1(229.33,7.04) 229.83,6.54 J5.B65 ; J5.B80 214.83,6.26 v1(215.6,7.04) ; v1(248.32,7.04) 247.83,6.55 J5.B47 ; v1(233.32,7.04) 233.83,6.53 J5.B61 ; J5.B73 221.83,6.54 v1(221.33,7.04) ; J5.B43 251.83,6.53 v1(252.33,7.04) ; v1(266.33,7.04) 265.83,6.54 J5.B29 ; J5.B25 269.83,6.53 v1(270.34,7.04) ; v1(245.31,7.04) 245.31,6.46 245.83,5.94 J5.A49 ; v1(219.31,7.04) 218.83,6.55 J5.B76 ; v1(258.33,7.04) 258.83,6.55 J5.B36 ; C224.2 v1(313.77,50.8) ; J5.B32 v1(262.83,7.04) ; J5.B21 273.83,6.54 v1(274.33,7.04) ; J5.B56 238.83,6.54 v1(239.33,7.04) ; PR397.2 15.49,109.82 v1(16.25,110.58) ; v1(231.33,7.04) 230.83,6.54 J5.B64 ; C259.2 v1(307.16,76.2) ; C222.2 304.01,56.64 v1(303.35,56.64) ; C380.2 v1(55.04,102.36) 53.49,102.36 PR503.1 ; J5.B52 242.83,6.53 v1(243.34,7.04) ; C372.2 v1(46.79,58.12)
  vias: v1(0.76,104.98) v1(0.76,99.9) v1(0.76,94.82) v1(0.76,89.74) v1(0.76,84.66) v1(3.58,33.17) v1(8.66,33.17) v1(9.93,79.9) v1(9.93,78.15) v1(9.93,76.31) v1(9.93,74.57) v1(9.96,72.71) v1(9.96,70.96) v1(9.98,69.1) v1(9.98,67.35) v1(9.96,52.67) v1(9.96,50.92) v1(9.96,49.06) v1(9.96,47.31) v1(9.98,45.45) v1(9.98,43.71) v1(9.96,41.85) v1(9.96,40.1) v1(11.38,117.48) v1(13.03,102.87) v1(13.03,102.23) v1(13.03,97.41) v1(13.03,96.65) v1(13.08,90.88) v1(13.08,90.12) v1(13.74,33.17) v1(16.25,108.55) v1(16.26,90.47) v1(16.46,117.48) v1(17.07,90.47) v1(17.86,90.47) v1(18.29,108.55) v1(18.82,33.17) v1(18.87,73.89) v1(18.87,72.15) v1(19.48,83.97) v1(19.64,37.7) v1(19.64,35.96) v1(20.17,67.31) v1(20.17,65.56) v1(20.32,83.29) v1(20.27,42.63) v1(20.27,40.89) v1(20.45,78.08) v1(20.45,76.33) v1(20.63,46.8) v1(20.63,45.05) v1(21.54,117.48) v1(21.57,73.78) v1(21.57,72.04) v1(22.94,88.81) v1(22.97,100.47) v1(22.96,67.31) v1(22.96,65.56) v1(23.7,45.07) v1(23.7,43.32) v1(23.9,33.17) v1(24.11,95.29) v1(24.11,83.6) v1(24.42,103.01) v1(24.42,97.35) v1(24.42,91.33) v1(24.42,85.66) v1(24.92,100.5) v1(24.92,95.26) v1(24.92,88.81) v1(24.92,83.58) v1(25.18,97.35) v1(25.18,85.66) v1(25.38,60.18) v1(25.38,58.44) v1(25.56,100.5) v1(25.56,88.81) v1(25.76,95.29) v1(25.76,83.6) v1(25.76,67.31) v1(25.76,65.56) v1(25.94,97.35) v1(25.94,85.66) v1(25.99,103.11) v1(25.99,102.35) v1(25.99,91.43) v1(25.99,90.67) v1(26.62,117.48) v1(26.57,95.29) v1(26.57,83.6) v1(26.7,97.35) v1(26.75,94.61) v1(26.7,85.66) v1(26.75,82.93) v1(27.26,103.34) v1(27.26,93.98) v1(27.26,91.66) v1(27.26,82.3) v1(27.51,95.47) v1(27.51,83.78) v1(27.64,94.74) v1(27.64,83.06) v1(27.76,93.47) v1(27.76,81.79) v1(27.95,103.34) v1(27.87,96.25) v1(27.95,91.66) v1(27.87,84.57) v1(28.27,94.23) v1(28.27,82.55) v1(28.43,96.63) v1(28.43,95.87) v1(28.4,95) v1(28.43,84.95) v1(28.43,84.19) v1(28.4,83.31) v1(28.53,93.47) v1(28.53,81.79) v1(29.03,94.23) v1(29.03,92.96) v1(29.03,82.55) v1(29.03,81.28) v1(28.98,33.17) v1(29.22,103.14) v1(29.22,91.45) v1(29.41,93.6) v1(29.41,81.92) v1(29.8,92.93) v1(29.8,81.24) v1(30.21,93.51) v1(30.21,81.83) v1(30.56,103.34) v1(30.59,93) v1(30.59,91.63) v1(30.59,81.32) v1(30.97,93.51) v1(30.97,81.83) v1(31.35,93) v1(31.35,81.32) v1(31.7,117.48) v1(31.73,93.51) v1(31.73,81.83) v1(31.95,56.37) v1(31.95,54.63) v1(32.11,93) v1(32.11,81.32) v1(32.49,93.51) v1(32.49,81.83) v1(32.87,93) v1(32.87,81.32) v1(33.25,93.51) v1(33.25,81.83) v1(33.99,58.28) v1(33.99,56.53) v1(34.34,79.83) v1(35.89,60.18) v1(35.89,58.44) v1(36.78,117.48) v1(36.88,78.97) v1(38.3,78.94) v1(38.43,44.2) v1(39.09,43.94) v1(39.5,100.43) v1(39.83,78.94) v1(40.16,102.35) v1(40.16,101.59) v1(40.16,100.83) v1(40.16,91.71) v1(40.16,90.94) v1(40.16,90.18) v1(40.16,89.42) v1(41.23,52.58) v1(41.38,92.61) v1(41.35,91.95) v1(41.86,117.48) v1(41.86,79.25) v1(41.89,52.58) v1(42.11,91.44) v1(42.93,91.47) v1(42.95,33.17) v1(43.11,52.58) v1(43.77,52.58) v1(43.77,43.38) v1(44.53,43.38) v1(45.29,79.63) v1(45.29,43.38) v1(45.29,41.22) v1(45.26,39.07) v1(45.92,80.26) v1(46.03,39.07) v1(46.05,43.38) v1(46.05,41.22) v1(46.43,80.9) v1(46.94,117.48) v1(47.58,82.04) v1(48.03,33.17) v1(52.02,117.48) v1(52.27,37.21) v1(52.27,36.45) v1(53.11,33.17) v1(53.78,50.44) v1(53.78,49.78) v1(53.78,49.06) v1(53.78,48.38) v1(55.58,94.49) v1(55.58,93.47) v1(55.55,90.63) v1(55.55,89.92) v1(56.32,35.22) v1(56.98,35.22) v1(57.1,117.48) v1(57.13,90.63) v1(57.13,89.89) v1(57.23,94.49) v1(57.29,93.4) v1(58.19,33.17) v1(58.88,94.49) v1(58.88,93.47) v1(58.88,90.63) v1(59.85,63.32) v1(60.56,57.76) v1(61.48,39.87) v1(61.47,39.07) v1(61.58,46.7) v1(61.94,47.26) v1(61.86,46.04) v1(62.18,117.48) v1(62.32,46.7) v1(62.65,46.09) v1(62.67,47.26) v1(63.03,46.65) v1(63.27,33.17) v1(63.36,47.24) v1(63.36,46.04) v1(63.46,45.33) v1(63.79,46.57) v1(64.12,47.16) v1(64.09,45.97) v1(64.21,66.75) v1(64.4,35.91) v1(64.4,35.25) v1(64.5,46.5) v1(64.88,45.94) v1(65.26,46.52) v1(65.65,45.97) v1(66.12,57.53) v1(66.14,53.82) v1(66.88,60.83) v1(67.26,117.48) v1(68.03,38.85) v1(68.01,38.19) v1(68.01,37.2) v1(68.01,36.52) v1(68.02,35.71) v1(68.35,33.17) v1(72.34,117.48) v1(73.43,33.17) v1(73.86,59.33) v1(77.42,117.48) v1(78.51,33.17) v1(78.94,40.23) v1(80.92,41.95) v1(80.92,41.06) v1(82.12,60.58) v1(82.5,117.48) v1(82.83,35.31) v1(83.46,36.02) v1(83.46,35.34) v1(83.59,33.17) v1(84.05,36.3) v1(84.07,35.64) v1(86.54,55.07) v1(86.51,54.36) v1(86.54,52.96) v1(86.87,56.41) v1(87.53,56.39) v1(87.58,117.48) v1(88.67,33.17) v1(89.25,39.3) v1(89.94,39.3) v1(90.4,41.38) v1(92.66,117.48) v1(93.3,41.15) v1(93.68,41.78) v1(93.75,33.17) v1(94.06,41.15) v1(94.44,41.78) v1(94.82,41.15) v1(95.71,34.59) v1(95.71,33.91) v1(96.34,34.59) v1(96.34,33.91) v1(97.74,117.48) v1(97.99,39.75) v1(98.12,34.67) v1(98.12,34.04) v1(98.83,33.17) v1(101.3,34.8) v1(101.3,34.16) v1(101.42,40.26) v1(101.42,39.62) v1(102.06,39.62) v1(102.06,34.8) v1(102.19,40.26) v1(102.82,117.48) v1(103.91,33.17) v1(105.36,34.8) v1(105.36,34.16) v1(106.25,34.8) v1(106.25,34.16) v1(107.9,117.48) v1(108.85,40.46) v1(108.99,33.17) v1(109.69,41.17) v1(111.09,35.97) v1(112.79,40.87) v1(112.98,117.48) v1(113.42,38.28) v1(113.88,40.94) v1(114.06,38.28) v1(114.07,33.17) v1(118.06,117.48) v1(119.15,33.17) v1(123.14,117.48) v1(124.23,33.17) v1(128.22,117.48) v1(129.31,33.17) v1(133.3,117.48) v1(138.38,117.48) v1(143.28,33.17) v1(143.46,117.48) v1(148.36,33.17) v1(148.54,117.48) v1(153.44,33.17) v1(153.62,117.48) v1(158.52,33.17) v1(158.7,117.48) v1(163.6,33.17) v1(163.78,117.48) v1(165.79,82.04) v1(168.86,117.48) v1(169.1,32.25) v1(169.81,26.85) v1(169.81,16) v1(173.36,14.67) v1(173.94,117.48) v1(178.44,14.67) v1(179.02,117.48) v1(183.52,14.67) v1(184.1,117.48) v1(188.6,14.67) v1(189.18,117.48) v1(191.21,54.85) v1(191.21,52.85) v1(193.68,14.67) v1(193.75,53.58) v1(193.75,51.58) v1(194.26,117.48) v1(196.42,53.58) v1(196.42,51.58) v1(196.42,50.4) v1(196.42,48.4) v1(199.09,50.4) v1(199.09,48.4) v1(199.19,13.93) v1(199.34,117.48) v1(201.63,95.2) v1(201.88,50.27) v1(201.88,48.27) v1(201.88,47.23) v1(201.88,45.23) v1(204.42,117.48) v1(204.42,47.1) v1(204.42,45.1) v1(204.49,12.19) v1(207.87,36.77) v1(209.5,117.48) v1(209.95,11.18) v1(213.6,7.04) v1(214.58,117.48) v1(219.66,117.48) v1(224.74,117.48) v1(229.82,117.48) v1(234.9,117.48) v1(239.98,117.48) v1(245.06,117.48) v1(248.81,106.17) v1(248.78,65.53) v1(248.86,85.85) v1(248.86,45.21) v1(250.14,117.48) v1(250.81,106.17) v1(250.78,65.53) v1(250.86,85.85) v1(250.86,45.21) v1(252.8,106.17) v1(252.82,85.85) v1(252.82,65.53) v1(252.82,45.21) v1(254.8,106.17) v1(254.82,85.85) v1(254.82,65.53) v1(254.82,45.21) v1(255.22,117.48) v1(256.78,106.17) v1(256.84,85.85) v1(256.78,65.53) v1(256.84,45.21) v1(258.78,106.17) v1(258.84,85.85) v1(258.78,65.53) v1(258.84,45.21) v1(260.3,117.48) v1(260.85,106.17) v1(260.82,85.85) v1(260.82,65.53) v1(260.85,45.21) v1(262.85,106.17) v1(262.82,85.85) v1(262.82,65.53) v1(262.85,45.21) v1(264.63,106.17) v1(265.38,117.48) v1(266.63,106.17) v1(266.82,65.53) v1(266.82,45.21) v1(266.87,85.85) v1(268.19,106.17) v1(268.82,65.53) v1(268.82,45.21) v1(268.87,85.85) v1(270.19,106.17) v1(270.46,117.48) v1(270.83,85.85) v1(270.78,45.21) v1(270.86,65.53) v1(271.75,106.17) v1(272.83,85.85) v1(272.78,45.21) v1(272.86,65.53) v1(273.75,106.17) v1(274.54,106.17) v1(274.82,85.85) v1(274.79,65.53) v1(274.82,45.21) v1(275.54,117.48) v1(276.54,106.17) v1(276.82,85.85) v1(276.79,65.53) v1(276.82,45.21) v1(277.51,109.51) v1(277.51,107.27) v1(277.51,105.04) v1(277.97,85.85) v1(278.19,109.51) v1(278.19,107.27) v1(278.19,105.04) v1(278.83,65.53) v1(278.83,45.21) v1(279.55,73.05) v1(279.97,85.85) v1(280.24,9.14) v1(280.62,117.48) v1(280.83,65.53) v1(280.83,45.21) v1(282.45,116.11) v1(282.4,10.16) v1(283.01,8.56) v1(283.16,116.11) v1(283.92,115.82) v1(283.93,112) v1(283.93,111.34) v1(283.99,113.41) v1(283.99,112.76) v1(284.43,28.57) v1(284.56,24.38) v1(285.07,49.02) v1(285.19,24.38) v1(285.34,110.27) v1(285.34,109.31) v1(285.37,108.24) v1(285.37,107.17) v1(285.37,106.21) v1(285.37,105.14) v1(285.7,117.48) v1(286.08,29.08) v1(286.06,7.06) v1(286.21,49.4) v1(286.72,90.04) v1(286.97,70.23) v1(287.22,69.6) v1(287.48,90.68) v1(287.48,49.91) v1(287.73,70.23) v1(288.09,66.01) v1(288.49,90.68) v1(288.49,70.23) v1(288.49,49.91) v1(288.7,86.39) v1(288.72,47.83) v1(288.88,104.14) v1(288.88,103.38) v1(290.73,116.09) v1(290.73,115.43) v1(290.78,117.48) v1(291.06,28.83) v1(291.49,66.01) v1(291.54,63.63) v1(291.54,62.87) v1(291.8,84.07) v1(291.8,83.19) v1(291.8,43.31) v1(291.8,42.55) v1(292.18,86.36) v1(292.43,29.59) v1(292.56,90.68) v1(292.56,70.23) v1(292.56,49.91) v1(292.89,111.87) v1(292.89,111.24) v1(292.96,104.53) v1(292.99,45.9) v1(293.24,105.14) v1(293.34,104) v1(293.45,29.59) v1(293.57,90.68) v1(293.57,70.23) v1(293.57,49.91) v1(293.7,104.53) v1(293.78,21.44) v1(293.93,105.13) v1(294.08,104) v1(294.23,105.71) v1(294.39,104.58) v1(294.46,29.59) v1(294.59,90.68) v1(294.59,70.23) v1(294.59,49.91) v1(294.74,105.14) v1(294.77,104.05) v1(294.87,105.86) v1(294.87,26.52) v1(295.15,104.58) v1(295.5,105.11) v1(295.56,103.99) v1(295.81,115.86) v1(295.81,115.2) v1(295.86,117.48) v1(295.91,104.61) v1(295.89,7.98) v1(296.29,105.11) v1(296.39,104.17) v1(297.31,10.52) v1(297.59,89.43) v1(297.59,87.25) v1(297.59,85.06) v1(298.22,89.43) v1(298.22,87.25) v1(298.22,85.06) v1(299.42,115.22) v1(299.42,114.59) v1(299.42,113.9) v1(299.42,112.91) v1(299.44,112.25) v1(299.54,55.68) v1(299.54,53.52) v1(299.52,51.36) v1(299.52,44.6) v1(299.87,21.39) v1(300.13,30.33) v1(300.53,12.19) v1(300.79,44.58) v1(300.81,9.17) v1(300.94,117.48) v1(301.6,91.23) v1(302.39,30.33) v1(302.46,47.6) v1(302.59,15.75) v1(302.72,26.97) v1(303.86,85.16) v1(304.01,87.3) v1(304.17,44.17) v1(304.24,19.3) v1(304.24,18.54) v1(304.24,17.27) v1(304.37,83.69) v1(304.37,60.83) v1(304.5,85.16) v1(304.65,87.3) v1(305.13,85.16) v1(305.28,87.3) v1(305.26,54.86) v1(305.26,53.47) v1(305.26,52.07) v1(305.46,92.02) v1(305.46,91.34) v1(305.77,85.16) v1(305.92,87.3) v1(305.89,9.17) v1(306.02,117.48) v1(306.22,47.62) v1(306.54,60.81) v1(306.66,54.86) v1(306.71,53.49) v1(306.66,52.07) v1(307.82,44.68) v1(308.18,54.86) v1(308.18,53.47) v1(308.18,52.07) v1(308.28,84.2) v1(308.69,60.83) v1(308.74,47.62) v1(308.91,84.43) v1(309.42,28.65) v1(309.54,85.37) v1(309.49,84.7) v1(310.13,84.68) v1(310.24,30.48) v1(310.77,84.68) v1(310.97,9.17) v1(311.1,117.48) v1(311.33,32.44) v1(311.94,91.05) v1(311.94,90.34) v1(312.9,31.62) v1(314.89,30.02) v1(315.75,54.74) v1(315.77,78.13) v1(315.77,56.44) v1(316.05,9.17) v1(316.18,117.48) v1(317.86,57.38) v1(320.83,117.47) v1(321.29,112.17) v1(321.29,107.09) v1(321.29,102.01) v1(321.29,96.93) v1(321.29,91.85) v1(321.29,86.77) v1(321.29,81.69) v1(321.29,76.61) v1(321.29,71.53) v1(321.29,66.45) v1(321.29,61.37) v1(321.29,56.29) v1(321.29,51.21) v1(321.29,46.13) v1(321.29,41.05) v1(321.29,35.97) v1(321.29,30.89) v1(321.29,25.81) v1(321.29,20.73) v1(321.29,15.65) v1(321.29,10.57) v2(25.66,94.36) v2(25.94,82.4) v2(51.31,39.44) v2(66.53,35.69) v2(88.99,36.65) v2(277.4,104.33) v4(65.74,98.4) v4(66.63,98.4) v4(68.36,71.13) v4(69.36,80.13) v4(71.36,85.13) v4(72.36,91.13) v4(72.36,88.13) v4(82.36,91.13) v4(84.36,91.13) v4(86.36,91.13) v4(88.36,71.13) v4(89.36,91.13) v4(90.36,71.13) v4(91.36,83.13) v4(91.36,82.13) v4(92.36,70.13) v5(25.87,82.45) v5(26.69,93.32) v5(50.05,34.83) v5(53.4,88.45) v5(102.05,41.1) v5(289.26,108.56) v5(303.65,15.15) v5(306.3,84.06)
GND_L:
  vias: v1(-18.72,363.74) v1(-18.72,362.74) v1(-18.72,361.74) v1(-18.72,360.74) v1(-18.72,359.74) v1(-18.72,358.74) v1(-18.72,357.74) v1(-18.72,356.74) v1(-18.72,355.74) v1(-18.72,354.74) v1(-18.72,353.74) v1(-18.72,352.74) v1(-18.72,351.74) v1(-18.72,350.74) v1(-18.72,349.74) v1(-18.72,348.74) v1(-18.72,347.74) v1(-18.72,346.74) v1(-18.72,345.74) v1(-18.72,344.74) v1(-18.72,343.74) v1(-18.72,342.74) v1(-18.72,341.74) v1(-18.72,340.74) v1(-18.72,339.74) v1(-18.72,338.74) v1(-18.72,337.74) v1(-18.72,336.74) v1(-18.72,335.74) v1(-18.72,334.74) v1(-18.72,333.74) v1(-18.72,332.74) v1(-18.72,331.74) v1(-18.72,330.74) v1(-18.72,329.74) v1(-18.72,328.74) v1(-18.72,327.74) v1(-18.72,326.74) v1(-18.72,325.74) v1(-18.72,324.74) v1(-18.72,323.74) v1(-18.72,322.74) v1(-18.72,321.74) v1(-18.72,320.74) v1(-18.72,319.74) v1(-18.72,318.74) v1(-18.72,317.74) v1(-18.72,316.74) v1(-18.72,315.74) v1(-18.72,314.74) v1(-18.72,313.74) v1(-18.72,312.74) v1(-18.72,311.74) v1(-18.72,310.74) v1(-18.72,309.74) v1(-18.72,308.74) v1(-18.72,307.74) v1(-18.72,306.74) v1(-18.72,305.74) v1(-18.72,304.74) v1(-18.72,303.74) v1(-18.72,302.74) v1(-18.72,301.74) v1(-18.72,300.74) v1(-18.72,299.74) v1(-18.72,298.74) v1(-18.72,297.74) v1(-18.72,296.74) v1(-18.72,295.74) v1(-18.72,294.74) v1(-18.72,293.74) v1(-18.72,292.74) v1(-18.72,291.74) v1(-18.72,290.74) v1(-18.72,289.74) v1(-18.72,288.74) v1(-18.72,287.74) v1(-18.72,286.74) v1(-18.72,285.74) v1(-18.72,284.74) v1(-18.72,283.74) v1(-18.72,282.74) v1(-18.72,281.74) v1(-18.72,280.74) v1(-18.72,279.74) v1(-18.72,278.74) v1(-18.72,277.74) v1(-18.72,276.74) v1(-18.72,275.74) v1(-18.72,274.74) v1(-18.72,273.74) v1(-18.72,272.74) v1(-18.72,271.74) v1(-18.72,270.74) v1(-18.72,269.74) v1(-18.72,268.74) v1(-18.72,267.74) v1(-18.72,266.74) v1(-18.72,265.74) v1(-18.72,264.74) v1(-18.72,263.74) v1(-18.72,262.74) v1(-18.72,261.74) v1(-18.72,260.74) v1(-18.72,259.74) v1(-18.72,258.74) v1(-18.72,257.74) v1(-18.72,256.74) v1(-18.72,255.74) v1(-18.72,254.74) v1(-18.72,253.74) v1(-18.72,252.74) v1(-18.72,251.74) v1(-18.72,250.74) v1(-18.72,249.74) v1(-18.72,248.74) v1(-18.72,247.74) v1(-18.72,246.74) v1(-18.72,245.74) v1(-18.72,244.74) v1(-18.72,243.74) v1(-18.72,242.74) v1(-18.72,241.74) v1(-18.72,240.74) v1(-18.72,239.74) v1(-18.72,238.74) v1(-18.72,237.74) v1(-18.72,236.74) v1(-18.72,235.74) v1(-18.72,234.74) v1(-18.72,233.74) v1(-18.72,232.74) v1(-18.72,231.74) v1(-18.72,230.74) v1(-18.72,229.74) v1(-18.72,228.74) v1(-18.72,227.74) v1(-18.72,226.74) v1(-18.72,225.74) v1(-18.72,224.74) v1(-18.72,223.74) v1(-18.72,222.74) v1(-18.72,221.74) v1(-18.72,220.74) v1(-18.72,219.74) v1(-18.72,218.74) v1(-18.72,217.74) v1(-18.72,216.74) v1(-18.72,215.74) v1(-18.72,214.74) v1(-18.72,213.74) v1(-18.72,212.74) v1(-18.72,211.74) v1(-18.72,210.74) v1(-18.72,209.74) v1(-18.72,208.74) v1(-18.72,207.74) v1(-18.72,206.74) v1(-18.72,205.74) v1(-18.72,204.74) v1(-18.72,203.74) v1(-18.72,202.74) v1(-18.72,201.74) v1(-18.72,200.74) v1(-18.72,199.74) v1(-18.72,198.74) v1(-18.72,197.74) v1(-18.72,196.74) v1(-18.72,195.74) v1(-18.72,194.74) v1(-18.72,193.74) v1(-18.72,192.74) v1(-18.72,191.74) v1(-18.72,190.74) v1(-18.72,189.74) v1(-18.72,188.74) v1(-18.72,187.74) v1(-18.72,186.74) v1(-18.72,185.74) v1(-18.72,184.74) v1(-18.72,183.74) v1(-18.72,182.74) v1(-18.72,181.74) v1(-18.72,180.74) v1(-18.72,179.74) v1(-18.72,178.74) v1(-18.72,177.74) v1(-18.72,176.74) v1(-18.72,175.74) v1(-18.72,174.74) v1(-18.72,173.74) v1(-18.72,172.74) v1(-18.72,171.74) v1(-18.72,170.74) v1(-18.72,169.74) v1(-18.72,168.74) v1(-18.72,167.74) v1(-18.72,166.74) v1(-18.72,165.74) v1(-18.72,164.74) v1(-18.72,163.74) v1(-18.72,162.74) v1(-18.72,161.74) v1(-18.72,160.74) v1(-18.72,159.74) v1(-18.72,158.74) v1(-18.72,157.74) v1(-18.72,156.74) v1(-18.72,155.74) v1(-18.72,154.74) v1(-18.72,153.74) v1(-18.72,152.74) v1(-18.72,151.74) v1(-18.72,150.74) v1(-18.72,149.74) v1(-18.72,148.74) v1(-18.72,147.74) v1(-18.72,146.74) v1(-18.72,145.74) v1(-18.72,144.74) v1(-18.72,143.74) v1(-18.72,142.74) v1(-18.72,141.74) v1(-18.72,140.74) v1(-18.72,139.74) v1(-18.72,138.74) v1(-18.72,137.74) v1(-18.72,136.74) v1(-18.72,135.74) v1(-18.72,134.74) v1(-18.72,133.74) v1(-18.72,132.74) v1(-18.72,131.74) v1(-18.72,130.74) v1(-18.72,129.74) v1(-18.72,128.74) v1(-18.72,127.74) v1(-18.72,126.74) v1(-18.72,125.74) v1(-18.72,124.74) v1(-18.72,123.74) v1(-18.72,122.74) v1(-18.72,121.74) v1(-18.72,120.74) v1(-18.72,119.74) v1(-18.72,118.74) v1(-18.72,117.74) v1(-18.72,116.74) v1(-18.72,115.74) v1(-18.72,114.74) v1(-18.72,113.74) v1(-18.72,112.74) v1(-18.72,111.74) v1(-18.72,110.74) v1(-18.72,109.74) v1(-18.72,108.74) v1(-18.72,107.74) v1(-18.72,106.74) v1(-18.72,105.74) v1(-18.72,104.74) v1(-18.72,103.74) v1(-18.72,102.74) v1(-18.72,101.74) v1(-18.72,100.74) v1(-18.72,99.74) v1(-18.72,98.74) v1(-18.72,97.74) v1(-18.72,96.74) v1(-18.72,95.74) v1(-18.72,94.74) v1(-18.72,93.74) v1(-18.72,92.74) v1(-18.72,91.74) v1(-18.72,90.74) v1(-18.72,89.74) v1(-18.72,88.74) v1(-18.72,87.74) v1(-18.72,86.74) v1(-18.72,85.74) v1(-18.72,84.74) v1(-18.72,83.74) v1(-18.72,82.74) v1(-18.72,81.74) v1(-18.72,80.74) v1(-18.72,79.74) v1(-18.72,78.74) v1(-18.72,77.74) v1(-18.72,76.74) v1(-18.72,75.74) v1(-18.72,74.74) v1(-18.72,73.74) v1(-18.72,72.74) v1(-18.72,71.74) v1(-18.72,70.74) v1(-18.72,69.74) v1(-18.72,68.74) v1(-18.72,67.74) v1(-18.72,66.74) v1(-18.72,65.74) v1(-18.72,64.74) v1(-18.72,63.74) v1(-18.72,62.74) v1(-18.72,61.74) v1(-18.72,60.74) v1(-18.72,59.74) v1(-18.72,58.74) v1(-18.72,57.74) v1(-18.72,56.74) v1(-18.72,55.74) v1(-18.72,54.74) v1(-18.72,53.74) v1(-18.72,52.74) v1(-18.72,51.74) v1(-18.72,50.74) v1(-18.72,49.74) v1(-18.72,48.74) v1(-18.72,47.74) v1(-18.72,46.74) v1(-18.72,45.74) v1(-18.72,44.74) v1(-18.72,43.74) v1(-18.72,42.74) v1(-18.72,41.74) v1(-18.72,40.74) v1(-18.72,39.74) v1(-18.72,38.74) v1(-18.72,37.74) v1(-18.72,36.74) v1(-18.72,35.74) v1(-18.72,34.74) v1(-18.72,33.74) v1(-18.72,32.74) v1(-18.72,31.74) v1(-18.72,30.74) v1(-18.72,29.74) v1(-18.72,28.74) v1(-18.72,27.74) v1(-18.72,26.74) v1(-18.72,25.74) v1(-18.72,24.74) v1(-18.72,23.74) v1(-18.72,22.74) v1(-18.72,21.74) v1(-18.72,20.74) v1(-18.72,19.74) v1(-18.72,18.74) v1(-18.72,17.74) v1(-18.72,16.74) v1(-18.72,15.74) v1(-18.72,14.74) v1(-18.72,13.74) v1(-18.72,12.74) v1(-18.72,11.74) v1(-18.72,10.74) v1(-18.72,9.74) v1(-18.72,8.74) v1(-18.72,7.74) v1(-18.72,6.74) v1(-18.72,5.74) v1(-18.72,4.74) v1(-18.72,3.74) v1(-18.72,2.74) v1(-18.72,1.74) v1(-18.72,0.74) v1(-18.72,-0.26) v1(-18.72,-1.26) v1(-18.72,-2.26) v1(-18.72,-3.26) v1(-18.72,-4.26) v1(-18.72,-5.26) v1(-18.72,-6.26) v1(-18.72,-7.26) v1(-18.72,-8.26) v1(-17.1,65.8) v1(-17.1,64.8) v1(-17.1,63.8) v1(-17.1,62.8) v1(-17.1,61.8) v1(-17.1,60.8) v1(-17.1,59.8) v1(-17.1,58.8) v1(-17.1,57.8) v1(-17.1,56.8) v1(-17.1,55.8) v1(-17.1,54.8) v1(-17.1,53.8) v1(-17.1,52.8) v1(-17.1,51.8) v1(-17.1,50.8) v1(-16.97,299.48) v1(-16.97,298.48) v1(-16.97,297.48) v1(-16.97,296.48) v1(-16.97,295.48) v1(-16.97,294.48) v1(-16.97,293.48) v1(-16.97,292.48) v1(-16.97,291.48) v1(-16.97,290.48) v1(-16.97,289.48) v1(-16.97,288.48) v1(-16.97,287.48) v1(-16.97,286.48) v1(-16.97,285.48) v1(-16.97,284.48) v1(-16.97,237.38) v1(-16.97,236.38) v1(-16.97,235.38) v1(-16.97,234.38) v1(-16.97,233.38) v1(-16.97,232.38) v1(-16.97,231.38) v1(-16.97,230.38) v1(-16.97,229.38) v1(-16.97,228.38) v1(-16.97,227.38) v1(-16.97,4.21) v1(-16.97,3.21) v1(-16.97,2.21) v1(-16.97,1.21) v1(-16.97,0.21) v1(-16.97,-0.79) v1(-16.97,-1.79) v1(-16.97,-2.79) v1(-16.97,-3.79) v1(-16.97,-4.79) v1(-16.97,-5.79) v1(-16.97,-6.79) v1(-16.97,-7.79) v1(-16.85,180.36) v1(-16.85,179.36) v1(-16.85,178.36) v1(-16.85,177.36) v1(-16.85,176.36) v1(-16.85,175.36) v1(-16.85,174.36) v1(-16.85,173.36) v1(-16.85,172.36) v1(-16.85,171.36) v1(-16.85,170.36) v1(-16.85,122.95) v1(-16.85,121.95) v1(-16.85,120.95) v1(-16.85,119.95) v1(-16.85,118.95) v1(-16.85,117.95) v1(-16.85,116.95) v1(-16.85,115.95) v1(-16.85,114.95) v1(-16.85,113.95) v1(-16.85,112.95) v1(-16.72,363.74) v1(-16.72,362.74) v1(-16.72,361.74) v1(-16.72,360.74) v1(-16.72,359.74) v1(-16.72,358.74) v1(-16.72,357.74) v1(-16.72,356.74) v1(-16.72,355.74) v1(-16.72,354.74) v1(-16.72,353.74) v1(-16.72,352.74) v1(-16.72,351.74) v1(-16.72,350.74) v1(-16.72,349.74) v1(-16.72,348.74) v1(-16.72,347.74) v1(-16.72,346.74) v1(-15.1,65.8) v1(-15.1,64.8) v1(-15.1,63.8) v1(-15.1,62.8) v1(-15.1,61.8) v1(-15.1,60.8) v1(-15.1,59.8) v1(-15.1,58.8) v1(-15.1,57.8) v1(-15.1,56.8) v1(-15.1,55.8) v1(-15.1,54.8) v1(-15.1,53.8) v1(-15.1,52.8) v1(-15.1,51.8) v1(-15.1,50.8) v1(-14.97,299.48) v1(-14.97,298.48) v1(-14.97,297.48) v1(-14.97,296.48) v1(-14.97,295.48) v1(-14.97,294.48) v1(-14.97,293.48) v1(-14.97,292.48) v1(-14.97,291.48) v1(-14.97,290.48) v1(-14.97,289.48) v1(-14.97,288.48) v1(-14.97,287.48) v1(-14.97,286.48) v1(-14.97,285.48) v1(-14.97,284.48) v1(-14.97,237.38) v1(-14.97,236.38) v1(-14.97,235.38) v1(-14.97,234.38) v1(-14.97,233.38) v1(-14.97,232.38) v1(-14.97,231.38) v1(-14.97,230.38) v1(-14.97,229.38) v1(-14.97,228.38) v1(-14.97,227.38) v1(-14.97,4.21) v1(-14.97,3.21) v1(-14.97,2.21) v1(-14.97,1.21) v1(-14.97,0.21) v1(-14.97,-0.79) v1(-14.97,-1.79) v1(-14.97,-2.79) v1(-14.97,-3.79) v1(-14.97,-4.79) v1(-14.97,-5.79) v1(-14.97,-6.79) v1(-14.97,-7.79) v1(-14.85,180.36) v1(-14.85,179.36) v1(-14.85,178.36) v1(-14.85,177.36) v1(-14.85,176.36) v1(-14.85,175.36) v1(-14.85,174.36) v1(-14.85,173.36) v1(-14.85,172.36) v1(-14.85,171.36) v1(-14.85,170.36) v1(-14.85,122.95) v1(-14.85,121.95) v1(-14.85,120.95) v1(-14.85,119.95) v1(-14.85,118.95) v1(-14.85,117.95) v1(-14.85,116.95) v1(-14.85,115.95) v1(-14.85,114.95) v1(-14.85,113.95) v1(-14.85,112.95) v1(-14.72,363.74) v1(-14.72,362.74) v1(-14.72,361.74) v1(-14.72,360.74) v1(-14.72,359.74) v1(-14.72,358.74) v1(-14.72,357.74) v1(-14.72,356.74) v1(-14.72,355.74) v1(-14.72,354.74) v1(-14.72,353.74) v1(-14.72,352.74) v1(-14.72,351.74) v1(-14.72,350.74) v1(-14.72,349.74) v1(-14.72,348.74) v1(-14.72,347.74) v1(-14.72,346.74) v1(-13.1,65.8) v1(-13.1,64.8) v1(-13.1,63.8) v1(-13.1,62.8) v1(-13.1,61.8) v1(-13.1,60.8) v1(-13.1,59.8) v1(-13.1,58.8) v1(-13.1,57.8) v1(-13.1,56.8) v1(-13.1,55.8) v1(-13.1,54.8) v1(-13.1,53.8) v1(-13.1,52.8) v1(-13.1,51.8) v1(-13.1,50.8) v1(-12.97,299.48) v1(-12.97,298.48) v1(-12.97,297.48) v1(-12.97,296.48) v1(-12.97,295.48) v1(-12.97,294.48) v1(-12.97,293.48) v1(-12.97,292.48) v1(-12.97,291.48) v1(-12.97,290.48) v1(-12.97,289.48) v1(-12.97,288.48) v1(-12.97,287.48) v1(-12.97,286.48) v1(-12.97,285.48) v1(-12.97,284.48) v1(-12.97,237.38) v1(-12.97,236.38) v1(-12.97,235.38) v1(-12.97,234.38) v1(-12.97,233.38) v1(-12.97,232.38) v1(-12.97,231.38) v1(-12.97,230.38) v1(-12.97,229.38) v1(-12.97,228.38) v1(-12.97,227.38) v1(-12.97,4.21) v1(-12.97,3.21) v1(-12.97,2.21) v1(-12.97,1.21) v1(-12.97,0.21) v1(-12.97,-0.79) v1(-12.97,-1.79) v1(-12.97,-2.79) v1(-12.97,-3.79) v1(-12.97,-4.79) v1(-12.97,-5.79) v1(-12.97,-6.79) v1(-12.97,-7.79) v1(-12.85,180.36) v1(-12.85,179.36) v1(-12.85,178.36) v1(-12.85,177.36) v1(-12.85,176.36) v1(-12.85,175.36) v1(-12.85,174.36) v1(-12.85,173.36) v1(-12.85,172.36) v1(-12.85,171.36) v1(-12.85,170.36) v1(-12.85,122.95) v1(-12.85,121.95) v1(-12.85,120.95) v1(-12.85,119.95) v1(-12.85,118.95) v1(-12.85,117.95) v1(-12.85,116.95) v1(-12.85,115.95) v1(-12.85,114.95) v1(-12.85,113.95) v1(-12.85,112.95) v1(-12.72,363.74) v1(-12.72,362.74) v1(-12.72,361.74) v1(-12.72,360.74) v1(-12.72,359.74) v1(-12.72,358.74) v1(-12.72,357.74) v1(-12.72,356.74) v1(-12.72,355.74) v1(-12.72,354.74) v1(-12.72,353.74) v1(-12.72,352.74) v1(-12.72,351.74) v1(-12.72,350.74) v1(-12.72,349.74) v1(-12.72,348.74) v1(-12.72,347.74) v1(-12.72,346.74) v1(-11.1,65.8) v1(-11.1,64.8) v1(-11.1,63.8) v1(-11.1,62.8) v1(-11.1,61.8) v1(-11.1,60.8) v1(-11.1,59.8) v1(-11.1,58.8) v1(-11.1,57.8) v1(-11.1,56.8) v1(-11.1,55.8) v1(-11.1,54.8) v1(-11.1,53.8) v1(-11.1,52.8) v1(-11.1,51.8) v1(-11.1,50.8) v1(-10.97,299.48) v1(-10.97,298.48) v1(-10.97,297.48) v1(-10.97,296.48) v1(-10.97,295.48) v1(-10.97,294.48) v1(-10.97,293.48) v1(-10.97,292.48) v1(-10.97,291.48) v1(-10.97,290.48) v1(-10.97,289.48) v1(-10.97,288.48) v1(-10.97,287.48) v1(-10.97,286.48) v1(-10.97,285.48) v1(-10.97,284.48) v1(-10.97,237.38) v1(-10.97,236.38) v1(-10.97,235.38) v1(-10.97,234.38) v1(-10.97,233.38) v1(-10.97,232.38) v1(-10.97,231.38) v1(-10.97,230.38) v1(-10.97,229.38) v1(-10.97,228.38) v1(-10.97,227.38) v1(-10.97,4.21) v1(-10.97,3.21) v1(-10.97,2.21) v1(-10.97,1.21) v1(-10.97,0.21) v1(-10.97,-0.79) v1(-10.97,-1.79) v1(-10.97,-2.79) v1(-10.97,-3.79) v1(-10.97,-4.79) v1(-10.97,-5.79) v1(-10.97,-6.79) v1(-10.97,-7.79) v1(-10.85,180.36) v1(-10.85,179.36) v1(-10.85,178.36) v1(-10.85,177.36) v1(-10.85,176.36) v1(-10.85,175.36) v1(-10.85,174.36) v1(-10.85,173.36) v1(-10.85,172.36) v1(-10.85,171.36) v1(-10.85,170.36) v1(-10.85,122.95) v1(-10.85,121.95) v1(-10.85,120.95) v1(-10.85,119.95) v1(-10.85,118.95) v1(-10.85,117.95) v1(-10.85,116.95) v1(-10.85,115.95) v1(-10.85,114.95) v1(-10.85,113.95) v1(-10.85,112.95) v1(-10.72,363.74) v1(-10.72,362.74) v1(-10.72,361.74) v1(-10.72,360.74) v1(-10.72,359.74) v1(-10.72,358.74) v1(-10.72,357.74) v1(-10.72,356.74) v1(-10.72,355.74) v1(-10.72,354.74) v1(-10.72,353.74) v1(-10.72,352.74) v1(-10.72,351.74) v1(-10.72,350.74) v1(-10.72,349.74) v1(-10.72,348.74) v1(-10.72,347.74) v1(-10.72,346.74) v1(-9.1,65.8) v1(-9.1,64.8) v1(-9.1,63.8) v1(-9.1,62.8) v1(-9.1,61.8) v1(-9.1,60.8) v1(-9.1,59.8) v1(-9.1,58.8) v1(-9.1,57.8) v1(-9.1,56.8) v1(-9.1,55.8) v1(-9.1,54.8) v1(-9.1,53.8) v1(-9.1,52.8) v1(-9.1,51.8) v1(-9.1,50.8) v1(-8.97,299.48) v1(-8.97,298.48) v1(-8.97,297.48) v1(-8.97,296.48) v1(-8.97,295.48) v1(-8.97,294.48) v1(-8.97,293.48) v1(-8.97,292.48) v1(-8.97,291.48) v1(-8.97,290.48) v1(-8.97,289.48) v1(-8.97,288.48) v1(-8.97,287.48) v1(-8.97,286.48) v1(-8.97,285.48) v1(-8.97,284.48) v1(-8.97,237.38) v1(-8.97,236.38) v1(-8.97,235.38) v1(-8.97,234.38) v1(-8.97,233.38) v1(-8.97,232.38) v1(-8.97,231.38) v1(-8.97,230.38) v1(-8.97,229.38) v1(-8.97,228.38) v1(-8.97,227.38) v1(-8.97,4.21) v1(-8.97,3.21) v1(-8.97,2.21) v1(-8.97,1.21) v1(-8.97,0.21) v1(-8.97,-0.79) v1(-8.97,-1.79) v1(-8.97,-2.79) v1(-8.97,-3.79) v1(-8.97,-4.79) v1(-8.97,-5.79) v1(-8.97,-6.79) v1(-8.97,-7.79) v1(-8.85,180.36) v1(-8.85,179.36) v1(-8.85,178.36) v1(-8.85,177.36) v1(-8.85,176.36) v1(-8.85,175.36) v1(-8.85,174.36) v1(-8.85,173.36) v1(-8.85,172.36) v1(-8.85,171.36) v1(-8.85,170.36) v1(-8.85,122.95) v1(-8.85,121.95) v1(-8.85,120.95) v1(-8.85,119.95) v1(-8.85,118.95) v1(-8.85,117.95) v1(-8.85,116.95) v1(-8.85,115.95) v1(-8.85,114.95) v1(-8.85,113.95) v1(-8.85,112.95) v1(-8.72,363.74) v1(-8.72,362.74) v1(-8.72,361.74) v1(-8.72,360.74) v1(-8.72,359.74) v1(-8.72,358.74) v1(-8.72,357.74) v1(-8.72,356.74) v1(-8.72,355.74) v1(-8.72,354.74) v1(-8.72,353.74) v1(-8.72,352.74) v1(-8.72,351.74) v1(-8.72,350.74) v1(-8.72,349.74) v1(-8.72,348.74) v1(-8.72,347.74) v1(-8.72,346.74) v1(-7.1,65.8) v1(-7.1,64.8) v1(-7.1,63.8) v1(-7.1,62.8) v1(-7.1,61.8) v1(-7.1,60.8) v1(-7.1,59.8) v1(-7.1,58.8) v1(-7.1,57.8) v1(-7.1,56.8) v1(-7.1,55.8) v1(-7.1,54.8) v1(-7.1,53.8) v1(-7.1,52.8) v1(-7.1,51.8) v1(-7.1,50.8) v1(-6.97,299.48) v1(-6.97,298.48) v1(-6.97,297.48) v1(-6.97,296.48) v1(-6.97,295.48) v1(-6.97,294.48) v1(-6.97,293.48) v1(-6.97,292.48) v1(-6.97,291.48) v1(-6.97,290.48) v1(-6.97,289.48) v1(-6.97,288.48) v1(-6.97,287.48) v1(-6.97,286.48) v1(-6.97,285.48) v1(-6.97,284.48) v1(-6.97,237.38) v1(-6.97,236.38) v1(-6.97,235.38) v1(-6.97,234.38) v1(-6.97,233.38) v1(-6.97,232.38) v1(-6.97,231.38) v1(-6.97,230.38) v1(-6.97,229.38) v1(-6.97,228.38) v1(-6.97,227.38) v1(-6.97,4.21) v1(-6.97,3.21) v1(-6.97,2.21) v1(-6.97,1.21) v1(-6.97,0.21) v1(-6.97,-0.79) v1(-6.97,-1.79) v1(-6.97,-2.79) v1(-6.97,-3.79) v1(-6.97,-4.79) v1(-6.97,-5.79) v1(-6.97,-6.79) v1(-6.97,-7.79) v1(-6.85,180.36) v1(-6.85,179.36) v1(-6.85,178.36) v1(-6.85,177.36) v1(-6.85,176.36) v1(-6.85,175.36) v1(-6.85,174.36) v1(-6.85,173.36) v1(-6.85,172.36) v1(-6.85,171.36) v1(-6.85,170.36) v1(-6.85,122.95) v1(-6.85,121.95) v1(-6.85,120.95) v1(-6.85,119.95) v1(-6.85,118.95) v1(-6.85,117.95) v1(-6.85,116.95) v1(-6.85,115.95) v1(-6.85,114.95) v1(-6.85,113.95) v1(-6.85,112.95) v1(-6.72,363.74) v1(-6.72,362.74) v1(-6.72,361.74) v1(-6.72,358.74) v1(-6.72,357.74) v1(-6.72,356.74) v1(-6.72,355.74) v1(-6.72,354.74) v1(-6.72,353.74) v1(-6.72,352.74) v1(-6.72,351.74) v1(-6.72,348.74) v1(-6.72,347.74) v1(-6.72,346.74) v1(-4.96,65.8) v1(-4.96,64.8) v1(-4.96,63.8) v1(-4.96,62.8) v1(-4.96,61.8) v1(-4.96,60.8) v1(-4.96,59.8) v1(-4.96,58.8) v1(-4.96,57.8) v1(-4.96,56.8) v1(-4.96,55.8) v1(-4.96,54.8) v1(-4.96,53.8) v1(-4.96,52.8) v1(-4.96,51.8) v1(-4.96,50.8) v1(-4.83,299.48) v1(-4.83,298.48) v1(-4.83,297.48) v1(-4.83,296.48) v1(-4.83,295.48) v1(-4.83,294.48) v1(-4.83,293.48) v1(-4.83,292.48) v1(-4.83,291.48) v1(-4.83,290.48) v1(-4.83,289.48) v1(-4.83,288.48) v1(-4.83,287.48) v1(-4.83,286.48) v1(-4.83,285.48) v1(-4.83,284.48) v1(-4.83,237.38) v1(-4.83,236.38) v1(-4.83,235.38) v1(-4.83,234.38) v1(-4.83,233.38) v1(-4.83,232.38) v1(-4.83,231.38) v1(-4.83,230.38) v1(-4.83,229.38) v1(-4.83,228.38) v1(-4.83,227.38) v1(-4.83,4.21) v1(-4.83,3.21) v1(-4.83,-1.79) v1(-4.83,-6.79) v1(-4.83,-7.79) v1(-4.7,180.36) v1(-4.7,179.36) v1(-4.7,178.36) v1(-4.7,177.36) v1(-4.7,176.36) v1(-4.7,175.36) v1(-4.7,174.36) v1(-4.7,173.36) v1(-4.7,172.36) v1(-4.7,171.36) v1(-4.7,170.36) v1(-4.7,122.95) v1(-4.7,121.95) v1(-4.7,120.95) v1(-4.7,119.95) v1(-4.7,118.95) v1(-4.7,117.95) v1(-4.7,116.95) v1(-4.7,115.95) v1(-4.7,114.95) v1(-4.7,113.95) v1(-4.7,112.95) v1(-4.58,363.74) v1(-4.58,362.74) v1(-4.58,357.74) v1(-4.58,356.74) v1(-4.58,355.74) v1(-4.58,354.74) v1(-4.58,353.74) v1(-4.58,352.74) v1(-4.58,347.74) v1(-4.58,346.74) v1(-2.97,363.74) v1(-2.97,362.74) v1(-2.97,361.74) v1(-2.97,360.74) v1(-2.97,359.74) v1(-2.97,358.74) v1(-2.97,357.74) v1(-2.97,356.74) v1(-2.97,355.74) v1(-2.97,354.74) v1(-2.97,353.74) v1(-2.97,352.74) v1(-2.97,351.74) v1(-2.97,350.74) v1(-2.97,349.74) v1(-2.97,348.74) v1(-2.97,347.74) v1(-2.97,346.74) v1(-2.97,345.74) v1(-2.97,344.74) v1(-2.97,343.74) v1(-2.97,342.74) v1(-2.97,341.74) v1(-2.97,340.74) v1(-2.97,339.74) v1(-2.97,338.74) v1(-2.97,337.74) v1(-2.97,336.74) v1(-2.97,335.74) v1(-2.97,334.74) v1(-2.97,333.74) v1(-2.97,332.74) v1(-2.97,331.74) v1(-2.97,330.74) v1(-2.97,329.74) v1(-2.97,328.74) v1(-2.97,327.74) v1(-2.97,326.74) v1(-2.97,325.74) v1(-2.97,324.74) v1(-2.97,323.74) v1(-2.97,322.74) v1(-2.97,321.74) v1(-2.97,320.74) v1(-2.97,319.74) v1(-2.97,318.74) v1(-2.97,317.74) v1(-2.97,316.74) v1(-2.97,315.74) v1(-2.97,314.74) v1(-2.97,313.74) v1(-2.97,312.74) v1(-2.97,311.74) v1(-2.97,310.74) v1(-2.97,309.74) v1(-2.97,308.74) v1(-2.97,307.74) v1(-2.97,306.74) v1(-2.97,305.74) v1(-2.97,304.74) v1(-2.97,303.74) v1(-2.97,302.74) v1(-2.97,301.74) v1(-2.97,300.74) v1(-2.97,299.74) v1(-2.97,298.74) v1(-2.97,297.74) v1(-2.97,296.74) v1(-2.97,295.74) v1(-2.97,294.74) v1(-2.97,293.74) v1(-2.97,292.74) v1(-2.97,291.74) v1(-2.97,290.74) v1(-2.97,289.74) v1(-2.97,288.74) v1(-2.97,287.74) v1(-2.97,286.74) v1(-2.97,285.74) v1(-2.97,284.74) v1(-2.97,283.74) v1(-2.97,282.74) v1(-2.97,281.74) v1(-2.97,280.74) v1(-2.97,279.74) v1(-2.97,278.74) v1(-2.97,277.74) v1(-2.97,276.74) v1(-2.97,275.74) v1(-2.97,274.74) v1(-2.97,273.74) v1(-2.97,272.74) v1(-2.97,271.74) v1(-2.97,270.74) v1(-2.97,269.74) v1(-2.97,268.74) v1(-2.97,267.74) v1(-2.97,266.74) v1(-2.97,265.74) v1(-2.97,264.74) v1(-2.97,263.74) v1(-2.97,262.74) v1(-2.97,261.74) v1(-2.97,260.74) v1(-2.97,259.74) v1(-2.97,258.74) v1(-2.97,257.74) v1(-2.97,256.74) v1(-2.97,255.74) v1(-2.97,254.74) v1(-2.97,253.74) v1(-2.97,252.74) v1(-2.97,251.74) v1(-2.97,250.74) v1(-2.97,249.74) v1(-2.97,248.74) v1(-2.97,247.74) v1(-2.97,246.74) v1(-2.97,245.74) v1(-2.97,244.74) v1(-2.97,243.74) v1(-2.97,242.74) v1(-2.97,241.74) v1(-2.97,240.74) v1(-2.97,239.74) v1(-2.97,238.74) v1(-2.97,237.74) v1(-2.97,236.74) v1(-2.97,235.74) v1(-2.97,234.74) v1(-2.97,233.74) v1(-2.97,232.74) v1(-2.97,231.74) v1(-2.97,230.74) v1(-2.97,229.74) v1(-2.97,228.74) v1(-2.97,227.74) v1(-2.97,226.74) v1(-2.97,225.74) v1(-2.97,224.74) v1(-2.97,223.74) v1(-2.97,222.74) v1(-2.97,221.74) v1(-2.97,220.74) v1(-2.97,219.74) v1(-2.97,218.74) v1(-2.97,217.74) v1(-2.97,216.74) v1(-2.97,215.74) v1(-2.97,214.74) v1(-2.97,213.74) v1(-2.97,212.74) v1(-2.97,211.74) v1(-2.97,210.74) v1(-2.97,209.74) v1(-2.97,208.74) v1(-2.97,207.74) v1(-2.97,206.74) v1(-2.97,205.74) v1(-2.97,204.74) v1(-2.97,203.74) v1(-2.97,202.74) v1(-2.97,201.74) v1(-2.97,200.74) v1(-2.97,199.74) v1(-2.97,198.74) v1(-2.97,197.74) v1(-2.97,196.74) v1(-2.97,195.74) v1(-2.97,194.74) v1(-2.97,193.74) v1(-2.97,192.74) v1(-2.97,191.74) v1(-2.97,190.74) v1(-2.97,189.74) v1(-2.97,188.74) v1(-2.97,187.74) v1(-2.97,186.74) v1(-2.97,185.74) v1(-2.97,184.74) v1(-2.97,183.74) v1(-2.97,182.74) v1(-2.97,181.74) v1(-2.97,180.74) v1(-2.97,179.74) v1(-2.97,178.74) v1(-2.97,177.74) v1(-2.97,176.74) v1(-2.97,175.74) v1(-2.97,174.74) v1(-2.97,173.74) v1(-2.97,172.74) v1(-2.97,171.74) v1(-2.97,170.74) v1(-2.97,169.74) v1(-2.97,168.74) v1(-2.97,167.74) v1(-2.97,166.74) v1(-2.97,165.74) v1(-2.97,164.74) v1(-2.97,163.74) v1(-2.97,162.74) v1(-2.97,161.74) v1(-2.97,160.74) v1(-2.97,159.74) v1(-2.97,158.74) v1(-2.97,157.74) v1(-2.97,156.74) v1(-2.97,155.74) v1(-2.97,154.74) v1(-2.97,153.74) v1(-2.97,152.74) v1(-2.97,151.74) v1(-2.97,150.74) v1(-2.97,149.74) v1(-2.97,148.74) v1(-2.97,147.74) v1(-2.97,146.74) v1(-2.97,145.74) v1(-2.97,144.74) v1(-2.97,143.74) v1(-2.97,142.74) v1(-2.97,141.74) v1(-2.97,140.74) v1(-2.97,139.74) v1(-2.97,138.74) v1(-2.97,137.74) v1(-2.97,136.74) v1(-2.97,135.74) v1(-2.97,134.74) v1(-2.97,133.74) v1(-2.97,132.74) v1(-2.97,131.74) v1(-2.97,130.74) v1(-2.97,129.74) v1(-2.97,128.74) v1(-2.97,127.74) v1(-2.97,126.74) v1(-2.97,125.74) v1(-2.97,124.74) v1(-2.97,123.74) v1(-2.97,122.74) v1(-2.97,121.74) v1(-2.97,120.74) v1(-2.97,119.74) v1(-2.97,118.74) v1(-2.97,117.74) v1(-2.97,116.74) v1(-2.97,115.74) v1(-2.97,114.74) v1(-2.97,113.74) v1(-2.97,112.74) v1(-2.97,111.74) v1(-2.97,110.74) v1(-2.97,109.74) v1(-2.97,108.74) v1(-2.97,107.74) v1(-2.97,106.74) v1(-2.97,105.74) v1(-2.97,104.74) v1(-2.97,103.74) v1(-2.97,102.74) v1(-2.97,101.74) v1(-2.97,100.74) v1(-2.97,99.74) v1(-2.97,98.74) v1(-2.97,97.74) v1(-2.97,96.74) v1(-2.97,95.74) v1(-2.97,94.74) v1(-2.97,93.74) v1(-2.97,92.74) v1(-2.97,91.74) v1(-2.97,90.74) v1(-2.97,89.74) v1(-2.97,88.74) v1(-2.97,87.74) v1(-2.97,86.74) v1(-2.97,85.74) v1(-2.97,84.74) v1(-2.97,83.74) v1(-2.97,82.74) v1(-2.97,81.74) v1(-2.97,80.74) v1(-2.97,79.74) v1(-2.97,78.74) v1(-2.97,77.74) v1(-2.97,76.74) v1(-2.97,75.74) v1(-2.97,74.74) v1(-2.97,73.74) v1(-2.97,72.74) v1(-2.97,71.74) v1(-2.97,70.74) v1(-2.97,69.74) v1(-2.97,68.74) v1(-2.97,67.74) v1(-2.97,66.74) v1(-2.97,65.74) v1(-2.97,64.74) v1(-2.97,63.74) v1(-2.97,62.74) v1(-2.97,61.74) v1(-2.97,60.74) v1(-2.97,59.74) v1(-2.97,58.74) v1(-2.97,57.74) v1(-2.97,56.74) v1(-2.97,55.74) v1(-2.97,54.74) v1(-2.97,53.74) v1(-2.97,52.74) v1(-2.97,51.74) v1(-2.97,50.74) v1(-2.97,49.74) v1(-2.97,48.74) v1(-2.97,47.74) v1(-2.97,46.74) v1(-2.97,45.74) v1(-2.97,44.74) v1(-2.97,43.74) v1(-2.97,42.74) v1(-2.97,41.74) v1(-2.97,40.74) v1(-2.97,39.74) v1(-2.97,38.74) v1(-2.97,37.74) v1(-2.97,36.74) v1(-2.97,35.74) v1(-2.97,34.74) v1(-2.97,33.74) v1(-2.97,32.74) v1(-2.97,31.74) v1(-2.97,30.74) v1(-2.97,29.74) v1(-2.97,28.74) v1(-2.97,27.74) v1(-2.97,26.74) v1(-2.97,25.74) v1(-2.97,24.74) v1(-2.97,23.74) v1(-2.97,22.74) v1(-2.97,21.74) v1(-2.97,20.74) v1(-2.97,19.74) v1(-2.97,18.74) v1(-2.97,17.74) v1(-2.97,16.74) v1(-2.97,15.74) v1(-2.97,14.74) v1(-2.97,13.74) v1(-2.97,12.74) v1(-2.97,11.74) v1(-2.97,10.74) v1(-2.97,9.74) v1(-2.97,8.74) v1(-2.97,7.74) v1(-2.97,6.74) v1(-2.97,5.74) v1(-2.97,4.74) v1(-2.97,3.74) v1(-2.97,2.74) v1(-2.97,1.74) v1(-2.97,0.74) v1(-2.97,-0.26) v1(-2.97,-1.26) v1(-2.97,-2.26) v1(-2.97,-3.26) v1(-2.97,-4.26) v1(-2.97,-5.26) v1(-2.97,-6.26) v1(-2.97,-7.26) v1(-2.97,-8.26)
