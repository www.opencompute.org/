# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT3_RX_DN<15>: length 135
  IN3 w0.089: v4(95.36,72.13) 95.05,72.13 94.96,72.22 94.96,72.34 95.14,72.53 96.8,72.53 96.85,72.48 96.87,72.48
  IN3 w0.135: 96.87,72.48 97.68,72.48 98.87,72.27 99.79,71.62 100.84,70.13 100.8,69.91 101.03,69.58 101.25,69.55 101.5,69.18 101.65,68.33 102.03,67.78 102.79,67.25 104.66,67.25 106.06,67.5 107.94,67.17 109.67,67.47 111.37,67.17 113.32,67.52 113.9,67.41 114.01,67.26 114.41,67.19 114.57,67.3 116.09,67.03 116.58,67.11 116.74,67 117.14,67.07 117.25,67.23 117.65,67.3 117.8,67.19 118.2,67.26 118.31,67.42 119.55,67.64 120.14,67.53 120.25,67.38 120.65,67.31 120.81,67.42 121.66,67.27 122.23,67.37 122.39,67.26 122.47,66.77 122.84,66.51 123.14,66.57 123.45,66.62 123.68,66.95 123.59,67.48 123.71,67.66 125.48,67.97 126.11,67.86 126.22,67.7 126.62,67.63 126.78,67.74 127.18,67.67 127.29,67.51 127.69,67.44 127.85,67.55 130.02,67.17 153.34,71.28 208.65,61.53 209.89,61.75 210.25,61.68 210.61,61.62 210.74,61.44 211.13,61.37 211.31,61.5 211.71,61.43 211.83,61.25 212.23,61.18 212.41,61.3 213,61.2 213.44,60.89 213.64,60.6 213.64,59.29 arc(213.76,58.99) 214.06,58.87 214.57,58.87 arc(214.67,58.83) 214.71,58.73 214.71,55.02 214.51,54.83 214.38,54.76 214.2,54.82 J3.A81
  BOTTOM w0.135: U1.D9 v4(95.36,72.13)
PE_SLOT3_RX_DP<0>: length 199.2
  IN3 w0.089: 99.04,88.77 99.02,88.77 98.97,88.72 95.05,88.72 94.77,88.45 94.77,88.26 94.64,88.13 v4(94.36,88.13)
  IN3 w0.135: J3.A16 278.45,54.33 278.51,54.51 278.51,54.51 278.68,54.59 278.95,54.86 278.95,58.61 arc(278.81,58.96) 278.46,59.11 278.16,59.11 arc(278.06,59.15) 278.01,59.26 278.01,60.87 277.86,61.09 277.12,61.6 274.51,63.43 271.39,63.98 271.07,64.2 269.95,65.8 269.78,66.78 269.4,67.32 268.96,67.63 253.36,70.38 242.88,68.53 223.89,71.88 221.17,71.4 215.05,72.48 212.79,72.08 210.49,72.49 208.47,72.13 149.11,82.6 146.8,82.19 120.87,86.76 119.27,86.48 116.96,86.89 114.54,86.46 111.4,87.02 108.43,86.49 105.59,86.99 103.7,86.66 102.85,86.81 100.05,88.77 99.04,88.77
  BOTTOM w0.135: U1.E24 v4(94.36,88.13)
PE_SLOT3_RX_DP<1>: length 196.9
  IN3 w0.089: 99.19,87.77 99.16,87.77 99.12,87.72 95.06,87.72 94.79,87.45 94.79,87.21 94.71,87.13 v4(94.36,87.13)
  IN3 w0.135: 99.19,87.77 100.29,87.77 102.55,86.18 103.7,85.98 105.59,86.31 108.43,85.81 111.34,86.33 114.43,85.78 116.89,86.22 119.25,85.8 120.92,86.09 146.87,81.52 149.18,81.93 208.47,71.47 210.44,71.82 212.74,71.41 215.01,71.81 221.21,70.72 223.93,71.2 242.86,67.86 252.59,69.58 262.74,67.79 263.31,67.39 263.74,66.77 263.9,66.67 264.11,66.7 264.52,67.3 264.95,67.37 265.38,67.07 265.45,66.66 265.03,66.06 265.06,65.87 265.39,65.64 265.47,65.23 265.29,64.97 265.32,64.76 265.53,64.62 265.74,64.65 265.9,64.89 266.33,64.96 269.97,62.42 272.05,62.05 272.97,61.89 273.6,61.44 274.02,60.85 274.02,59.35 arc(273.89,59.05) 273.6,58.93 273.12,58.93 arc(273,58.88) 272.96,58.77 272.96,55.01 273.13,54.83 273.27,54.76 273.45,54.82 J3.A21
  BOTTOM w0.135: U1.E23 v4(94.36,87.13)
PE_SLOT3_RX_DP<2>: length 190.4
  IN3 w0.089: v4(94.36,86.13) 94.73,86.13 94.79,86.19 94.79,86.45 95.08,86.73 98.99,86.73 99.04,86.78 99.06,86.78
  IN3 w0.135: J3.A25 269.45,54.82 269.27,54.76 269.16,54.82 268.97,55.01 268.97,58.78 arc(269.01,58.89) 269.12,58.93 269.58,58.93 arc(269.87,59.05) 269.99,59.33 269.99,60.89 269.76,61.21 266.32,63.62 261.23,64.51 260.37,65.12 259.89,65.8 259.71,66.79 259.32,67.35 258.71,67.78 252.44,68.89 242.81,67.19 223.93,70.52 221.21,70.04 215.01,71.13 212.79,70.74 210.49,71.15 208.53,70.8 149.23,81.26 146.83,80.83 120.97,85.43 119.93,85.24 119.23,85.12 116.87,85.54 114.89,85.19 114.27,85.08 111.19,85.62 108.39,85.13 105.55,85.63 103.7,85.3 102.11,85.58 100.6,86.64 99.8,86.78 99.06,86.78
  BOTTOM w0.135: U1.E22 v4(94.36,86.13)
PE_SLOT3_RX_DP<3>: length 189
  IN3 w0.089: v4(94.36,85.13) 94.72,85.13 94.8,85.21 94.8,85.46 95.08,85.74 99.04,85.74 99.09,85.79 99.11,85.79
  IN3 w0.135: 99.11,85.79 99.8,85.79 100.79,85.61 101.7,84.98 103.7,84.62 105.55,84.95 108.41,84.44 111.21,84.94 114.29,84.4 116.82,84.84 119.17,84.43 120.86,84.72 146.86,80.14 149.35,80.58 208.58,70.13 210.49,70.47 212.79,70.06 215.01,70.45 221.26,69.35 223.98,69.83 242.86,66.5 244.77,66.84 245.13,66.58 245.18,66.29 245.34,66.18 245.58,66.22 245.69,66.38 245.64,66.65 245.9,67.02 246.74,67.17 247.09,66.92 247.18,66.42 247.32,66.32 247.62,66.37 247.72,66.52 247.63,67.02 247.77,67.22 247.92,67.43 250.36,67.86 250.99,67.75 251.67,67.27 251.91,66.93 252.2,65.28 252.36,65.04 252.58,64.89 255.53,64.38 255.69,64.49 255.76,64.9 256.11,65.15 256.71,65.05 256.96,64.7 256.89,64.29 257,64.13 257.36,64.07 257.52,64.18 257.59,64.59 257.94,64.83 258.54,64.73 258.79,64.38 258.72,63.97 258.83,63.81 260.89,63.46 263,61.98 262.99,61.98 263.66,61.52 264.02,61.01 264.02,59.44 arc(264.07,59.32) 264.19,59.27 264.52,59.27 arc(264.85,59.13) 264.98,58.81 264.98,54.97 265.1,54.85 265.27,54.76 265.45,54.82 J3.A29
  BOTTOM w0.135: U1.E21 v4(94.36,85.13)
PE_SLOT3_RX_DP<4>: length 178.4
  IN3 w0.089: 99.16,84.77 99.14,84.77 99.09,84.72 95.07,84.72 94.81,84.46 94.81,84.22 94.72,84.13 v4(94.36,84.13)
  IN3 w0.135: 99.16,84.77 100.33,84.77 100.97,84.66 101.42,84.35 103.7,83.94 105.55,84.27 108.39,83.77 111.14,84.26 114.25,83.71 115.53,83.93 116.82,84.16 119.39,83.71 121,83.99 146.81,79.44 149.42,79.9 208.55,69.45 210.49,69.79 212.79,69.39 215,69.78 221.26,68.67 223.74,69.11 257.2,63.21 257.9,63.08 259.3,62.1 260.01,61.09 260.01,59.33 arc(259.9,59.05) 259.61,58.93 259.11,58.93 arc(259.02,58.89) 258.98,58.79 258.98,54.97 259.1,54.85 259.27,54.76 259.45,54.82 J3.A35
  BOTTOM w0.135: U1.E20 v4(94.36,84.13)
PE_SLOT3_RX_DP<5>: length 176.4
  IN3 w0.089: 99.13,83.77 99.11,83.77 99.06,83.72 95.07,83.72 94.8,83.45 94.8,83.22 94.71,83.13 v4(94.36,83.13)
  IN3 w0.135: 99.13,83.77 100.36,83.77 103.41,83.23 105.5,83.6 108.42,83.09 111.22,83.58 114.3,83.04 115.51,83.25 115.52,83.25 116.82,83.48 118.13,83.25 119.34,83.04 121,83.33 146.78,78.75 149.41,79.22 208.61,68.78 210.48,69.11 212.78,68.7 214.96,69.09 223.41,67.6 223.59,67.72 223.66,68.12 224.01,68.37 224.49,68.28 224.73,67.93 224.66,67.51 224.77,67.34 225.03,67.3 225.2,67.41 225.27,67.83 225.62,68.08 226.1,67.99 226.36,67.62 226.29,67.23 226.4,67.07 227.02,66.96 229.04,67.32 253.39,63.02 255.64,61.45 255.9,61.07 255.98,60.62 255.98,59.32 arc(255.86,59.03) 255.56,58.9 255.13,58.9 arc(255.03,58.86) 254.99,58.77 254.99,54.96 255.1,54.85 255.27,54.76 255.45,54.82 J3.A39
  BOTTOM w0.135: U1.E19 v4(94.36,83.13)
PE_SLOT3_RX_DP<6>: length 169.9
  IN3 w0.089: 99.13,82.76 99.11,82.76 99.06,82.72 95.06,82.72 94.79,82.44 94.79,82.19 94.73,82.13 v4(94.36,82.13)
  IN3 w0.135: 99.13,82.76 101.8,82.76 103.24,82.51 105.53,82.92 108.44,82.4 110.46,82.76 110.46,82.76 111.24,82.9 114.3,82.36 116.83,82.8 119.34,82.36 120.87,82.63 146.76,78.06 149.34,78.52 208.56,68.07 210.49,68.41 212.74,68.02 212.74,68.02 214.85,68.37 226.72,66.28 226.89,66.28 226.89,66.28 227.02,66.28 228.91,66.62 248.38,63.18 249.25,63.03 251.69,61.32 252,60.89 252,59.35 arc(251.87,59.05) 251.57,58.93 251.11,58.93 arc(251.02,58.89) 250.98,58.79 250.98,54.97 251.1,54.85 251.27,54.76 251.45,54.82 J3.A43
  BOTTOM w0.135: U1.E18 v4(94.36,82.13)
PE_SLOT3_RX_DP<7>: length 167.4
  IN3 w0.089: v4(94.36,80.13) 94.68,80.13 94.77,80.22 94.77,80.58 95.1,80.91 95.71,80.91 95.76,80.96 95.78,80.96
  IN3 w0.135: J3.A47 247.45,54.82 247.27,54.76 247.1,54.85 246.97,54.98 246.97,58.8 arc(246.81,59.17) 246.45,59.32 246.15,59.32 arc(246.05,59.36) 246.01,59.46 246.01,60.75 245.2,61.91 243.91,62.81 243.1,62.95 237.63,63.92 237.02,63.81 235.41,64.09 235.3,64.24 235.35,64.5 235.1,64.85 234.5,64.95 234.15,64.71 234.1,64.46 233.95,64.35 233.58,64.41 233.47,64.57 233.52,64.82 233.27,65.17 232.67,65.28 232.32,65.03 232.27,64.78 232.12,64.67 231.75,64.74 231.64,64.89 231.68,65.14 231.44,65.49 230.83,65.6 230.48,65.36 230.44,65.1 230.28,64.99 229.92,65.06 229.81,65.21 229.85,65.47 229.61,65.82 229,65.92 228.65,65.68 228.61,65.43 228.39,65.27 214.8,67.67 214.75,67.68 212.84,67.34 212.84,67.34 210.54,67.75 208.61,67.4 149.42,77.84 146.67,77.36 120.84,81.95 119.34,81.68 116.78,82.13 114.26,81.69 111.26,82.22 108.45,81.72 105.62,82.22 102.88,81.74 102.01,81.89 99.52,81.46 96.71,80.96 95.78,80.96
  BOTTOM w0.135: U1.E17 v4(94.36,80.13)
PE_SLOT3_RX_DP<8>: length 160.1
  IN3 w0.089: 98.88,79.78 98.86,79.78 98.81,79.73 95.07,79.73 94.77,79.42 94.77,79.25 94.65,79.13 v4(94.36,79.13)
  IN3 w0.135: J3.A52 242.45,54.33 242.51,54.51 242.51,54.51 242.68,54.59 242.96,54.87 242.96,58.76 arc(242.83,59.08) 242.51,59.22 242.14,59.22 arc(242.02,59.26) 241.97,59.39 241.97,60.95 241.6,61.48 241.13,61.95 240.37,62.48 214.7,67.01 212.79,66.67 210.5,67.07 208.62,66.74 149.41,77.18 146.5,76.67 120.86,81.22 119.48,80.98 116.75,81.46 114.28,81.02 111.29,81.55 108.22,81.01 106.11,81.38 102.57,80.76 101.65,80.11 99.75,79.78 98.88,79.78
  BOTTOM w0.135: U1.E16 v4(94.36,79.13)
PE_SLOT3_RX_DP<9>: length 158
  IN3 w0.089: v4(94.36,78.13) 94.68,78.13 94.77,78.22 94.77,78.42 95.07,78.73 97.2,78.73 97.25,78.77 97.27,78.77
  IN3 w0.135: J3.A56 238.45,54.33 238.51,54.51 238.51,54.51 238.68,54.59 238.97,54.88 238.97,58.76 arc(238.84,59.08) 238.51,59.22 238.13,59.22 arc(238.02,59.26) 237.98,59.36 237.98,60.9 237.29,61.88 236.38,62.52 235.8,62.62 214.75,66.34 212.79,65.99 210.5,66.4 208.65,66.07 149.41,76.52 144.47,75.65 127.04,78.72 126.69,78.48 126.55,77.64 126.39,77.53 126.02,77.6 125.91,77.75 126.06,78.59 125.81,78.94 123.53,79.34 120.37,78.8 117.61,79.29 115.02,78.83 112.35,79.3 110.92,79.05 109.92,79.22 108.91,79.05 106.95,78.7 106.07,78.86 105.41,78.74 103.05,79.16 102.47,79.26 102.45,79.26 102.15,79.31 99.52,78.85 99.09,78.77 97.27,78.77
  BOTTOM w0.135: U1.E15 v4(94.36,78.13)
PE_SLOT3_RX_DP<10>: length 151.8
  IN3 w0.089: 97.25,77.77 97.23,77.77 97.18,77.73 95.07,77.73 94.77,77.42 94.77,77.22 94.68,77.13 v4(94.36,77.13)
  IN3 w0.135: 97.25,77.77 99.86,77.77 103.58,77.12 103.64,77.11 104.2,77.01 105.24,77.19 106.79,76.92 108.33,77.19 109.45,76.99 110.83,77.24 112.51,76.94 114.64,77.31 116.72,76.95 119.24,77.39 119.29,77.38 121.75,76.95 123.09,77.19 140.59,74.08 150.02,75.75 208.75,65.39 210.27,65.66 212.46,65.27 214.72,65.67 232.16,62.6 233.32,61.78 233.97,60.86 233.97,59.35 arc(234.01,59.25) 234.1,59.22 234.5,59.22 arc(234.83,59.08) 234.96,58.76 234.96,54.87 234.68,54.59 234.51,54.51 234.51,54.51 234.45,54.33 J3.A60
  BOTTOM w0.135: U1.E14 v4(94.36,77.13)
PE_SLOT3_RX_DP<11>: length 149.4
  IN3 w0.089: 97.25,76.78 97.23,76.78 97.18,76.73 95.07,76.73 94.77,76.42 94.77,76.26 94.64,76.13 v4(94.36,76.13)
  IN3 w0.135: J3.A64 230.45,54.33 230.51,54.51 230.51,54.51 230.68,54.59 230.97,54.88 230.97,58.79 arc(230.85,59.09) 230.55,59.22 230.13,59.22 arc(230.01,59.26) 229.96,59.39 229.96,60.8 229.64,61.25 227.48,62.76 214.78,65 212.42,64.58 210.21,64.97 208.67,64.7 150.85,74.9 138.9,72.79 128.11,74.71 127.37,74.58 125.64,74.89 125.3,74.65 125.2,74.1 125.12,74.04 124.76,74.11 124.68,74.22 124.77,74.72 124.53,75.06 122.35,75.45 120.98,75.02 118.37,75.48 115.52,74.97 113.34,75.36 111.73,75.08 110.04,75.37 109.31,75.24 108.56,75.38 108.44,75.4 107.44,75.57 104.43,75.04 102.34,75.41 100.91,76.42 99.52,76.66 98.87,76.78 97.25,76.78
  BOTTOM w0.135: U1.E13 v4(94.36,76.13)
PE_SLOT3_RX_DP<12>: length 144.7
  IN3 w0.089: 96.85,75.76 96.83,75.76 96.78,75.71 95.05,75.71 94.77,75.42 94.77,75.22 94.68,75.13 v4(94.36,75.13)
  IN3 w0.135: 96.85,75.76 98.17,75.76 99.52,75.52 99.83,75.47 102.88,73.33 102.88,73.32 103.08,73.17 103.7,73.07 105.58,73.4 107.93,72.99 110.51,73.44 112.13,73.16 113.77,73.44 114.69,73.28 115.74,73.47 118.14,73.04 120.62,73.48 123.59,72.96 125.27,73.25 126.9,72.97 128.97,73.33 138.13,71.72 151.44,74.06 208.62,63.98 210.19,64.26 212.4,63.87 214.93,64.31 224.69,62.59 225.32,62.15 225.97,61.23 225.97,59.36 arc(226.01,59.26) 226.11,59.22 226.54,59.22 arc(226.83,59.09) 226.96,58.79 226.96,54.87 226.68,54.59 226.51,54.51 226.51,54.51 226.45,54.33 J3.A68
  BOTTOM w0.135: U1.E12 v4(94.36,75.13)
PE_SLOT3_RX_DP<13>: length 143.3
  IN3 w0.089: v4(94.36,74.13) 94.64,74.13 94.77,74.26 94.77,74.42 95.06,74.71 96.85,74.71 96.9,74.76 96.92,74.76
  IN3 w0.135: 96.92,74.76 98.12,74.76 99.52,74.52 99.77,74.47 100.92,73.67 102.3,71.69 102.67,71.43 103.03,71.28 103.42,71.21 104.97,71.49 106.08,71.29 107.49,71.54 109.22,71.23 111.2,71.58 112,71.44 112.7,71.32 113.95,71.54 115.55,71.26 116.91,71.5 118.91,71.15 119.85,71.31 120.2,71.07 120.29,70.56 120.45,70.45 120.82,70.51 120.93,70.67 120.84,71.18 121.08,71.53 122.96,71.86 125.63,71.39 126.9,71.62 127.25,71.37 127.3,71.05 127.46,70.94 127.7,70.98 127.81,71.13 127.76,71.43 128.03,71.83 129.46,72.08 137.52,70.66 152.18,73.24 208.7,63.28 210.2,63.54 212.46,63.15 214.23,63.46 219.34,62.56 220.48,62.36 221.29,61.79 221.93,60.88 221.93,59.35 arc(221.97,59.25) 222.06,59.22 222.52,59.22 arc(222.82,59.09) 222.95,58.79 222.95,54.85 222.68,54.59 222.51,54.51 222.51,54.51 222.45,54.33 J3.A72
  BOTTOM w0.135: U1.E11 v4(94.36,74.13)
PE_SLOT3_RX_DP<14>: length 137
  IN3 w0.089: v4(94.36,73.13) 94.64,73.13 94.77,73.26 94.77,73.42 95.07,73.72 96.8,73.72 96.85,73.77 96.87,73.77
  IN3 w0.135: 96.87,73.77 97.72,73.77 99.32,73.49 99.52,73.35 100.35,72.77 102.42,69.81 103.23,69.24 104.2,69.24 106.82,69.7 109.34,69.26 111.88,69.71 114.5,69.24 116.61,69.61 118.34,69.29 123.49,70.2 125.79,69.8 129.95,70.53 135.95,69.46 152.61,72.4 208.46,62.55 209.84,62.79 217.19,61.5 217.62,61.2 217.97,60.7 217.97,59.35 arc(218.01,59.25) 218.1,59.22 218.56,59.22 arc(218.86,59.09) 218.98,58.79 218.98,54.89 218.68,54.59 218.51,54.51 218.51,54.51 218.45,54.33 J3.A76
  BOTTOM w0.135: U1.E10 v4(94.36,73.13)
PE_SLOT3_RX_DP<15>: length 135
  IN3 w0.089: v4(94.36,72.13) 94.65,72.13 94.77,72.25 94.77,72.42 95.06,72.72 96.8,72.72 96.85,72.77 96.87,72.77
  IN3 w0.135: 96.87,72.77 97.71,72.77 98.98,72.54 100,71.83 101.77,69.29 101.92,68.44 102.24,67.99 102.88,67.54 104.63,67.54 106.06,67.79 107.94,67.46 109.67,67.77 111.37,67.47 113.32,67.81 116.09,67.32 119.55,67.93 121.66,67.56 122.3,67.67 122.65,67.43 122.74,66.94 122.91,66.82 123.28,66.88 123.38,67.02 123.28,67.54 123.54,67.92 125.48,68.26 130.02,67.46 153.34,71.57 208.65,61.82 209.89,62.04 213.11,61.47 213.65,61.1 213.93,60.7 213.93,59.29 arc(213.97,59.2) 214.06,59.16 214.57,59.16 arc(214.87,59.03) 214.99,58.73 214.99,54.9 214.68,54.59 214.51,54.51 214.51,54.51 214.45,54.33 J3.A80
  BOTTOM w0.135: U1.E9 v4(94.36,72.13)
PE_SLOT3_TX_C_DN<0>: length 190.8
  IN1 w0.089: v4(98.36,88.13) 98.05,88.13 97.98,88.2 97.98,88.37 98.17,88.56 98.65,88.56 99.01,88.62 99.41,88.55 99.45,88.49 99.47,88.49
  IN1 w0.122: 99.47,88.49 99.9,88.41 100.98,88.22 102.57,88.5 104.8,88.11 107.9,88.65 111.23,88.07 114.29,88.61 117.75,88 119.89,88.38 122.01,88 126.89,84.58 130.98,83.86 137.33,84.98 148.9,82.94 218.72,70.63 223.3,71.44 225.12,71.12 227.29,71.5 229.34,71.14 230.79,71.39 232.82,71.04 235.1,71.44 237.5,71.01 240.68,71.58 243.02,71.16 245.65,71.63 247.19,71.36 249.28,71.73 251.12,71.4 252.76,71.69 255.74,71.16 258.74,71.8 271.73,69.52 271.85,69.34 272.21,69.27 272.39,69.4 272.75,69.34 272.87,69.16 273.24,69.09 273.41,69.22 273.77,69.16 273.9,68.98 274.26,68.91 274.43,69.04 274.79,68.97 274.92,68.8 275.28,68.73 275.46,68.86 275.82,68.79 275.94,68.62 276.3,68.55 276.48,68.68 276.84,68.61 276.96,68.44 277.32,68.37 277.5,68.5 277.92,68.42 279.44,67.36 279.66,67.05 279.69,66.88 279.69,66.66 v1(279.33,66.29)
  BOTTOM w0.135: C43.1 279.68,65.14 279.68,65.94 v1(279.33,66.29) ; U1.A24 v4(98.36,88.13)
PE_SLOT3_TX_C_DN<1>: length 189
  IN1 w0.089: 99.47,87.21 99.45,87.22 99.41,87.27 98.86,87.37 98.62,87.54 98.15,87.54 98,87.38 98,87.18 98.05,87.13 v4(98.36,87.13)
  IN1 w0.122: 99.47,87.21 99.52,87.2 108.63,85.6 112.92,86.35 115.83,85.84 116.17,86.08 116.27,86.68 116.41,86.78 116.79,86.71 116.89,86.57 116.79,85.97 117.03,85.63 117.64,85.52 117.98,85.76 118.09,86.36 118.23,86.46 118.61,86.39 118.71,86.25 118.6,85.65 118.84,85.31 130.98,83.17 137.33,84.29 148.9,82.25 218.72,69.94 223.17,70.72 224.95,70.41 227.04,70.78 229.07,70.42 230.74,70.71 232.77,70.35 235.05,70.76 237.44,70.33 240.73,70.91 243.02,70.51 245.58,70.96 247.18,70.68 249.21,71.04 251.22,70.68 252.99,70.99 255.79,70.5 258.55,70.99 258.62,71 266.92,69.54 267.04,69.36 267.4,69.3 267.58,69.42 267.94,69.36 268.07,69.18 268.43,69.12 268.6,69.24 268.96,69.18 269.09,69 269.45,68.94 269.63,69.06 269.99,69 270.11,68.82 270.47,68.76 270.65,68.88 271.01,68.82 271.13,68.64 271.49,68.58 271.67,68.7 272.03,68.64 272.15,68.46 272.51,68.4 272.69,68.52 273.05,68.46 273.18,68.28 273.54,68.22 273.71,68.34 273.72,68.34 274.18,68.26 275.04,67.8 275.57,67.18 275.65,66.75 275.65,66.66 v1(275.29,66.29)
  BOTTOM w0.135: U1.A23 v4(98.36,87.13) ; C44.1 275.64,65.14 275.64,65.94 v1(275.29,66.29)
PE_SLOT3_TX_C_DN<2>: length 181.9
  IN1 w0.089: v4(98.36,86.13) 98.07,86.13 97.98,86.22 97.98,86.37 98.15,86.54 98.59,86.54 98.77,86.67 99.3,86.57 99.34,86.52 99.37,86.51
  IN1 w0.122: v1(271.35,66.29) 271.71,66.66 271.71,66.83 271.6,67.44 271.43,67.68 271.02,67.98 270.42,68.08 270.24,67.96 269.88,68.02 269.76,68.2 269.4,68.26 269.22,68.14 268.86,68.2 268.74,68.38 268.38,68.44 268.2,68.32 267.84,68.38 267.72,68.56 267.36,68.62 267.18,68.5 266.82,68.56 266.69,68.74 266.33,68.8 266.16,68.68 265.8,68.74 265.67,68.92 265.31,68.98 265.13,68.86 264.77,68.92 264.65,69.1 264.29,69.16 264.11,69.04 263.75,69.1 263.63,69.28 258.15,70.24 255.83,69.84 253.11,70.31 251.31,70 249.18,70.37 247.19,70.02 245.57,70.31 243.02,69.86 240.78,70.25 237.46,69.67 235.08,70.09 232.8,69.69 230.81,70.04 229.18,69.75 227.13,70.11 224.99,69.73 223.12,70.06 218.68,69.28 148.9,81.58 137.56,83.58 131.21,82.46 112.99,85.67 108.56,84.89 99.52,86.49 99.37,86.51
  BOTTOM w0.135: U1.A22 v4(98.36,86.13) ; v1(271.35,66.29) 271.71,65.94 271.71,65.14 C45.1
PE_SLOT3_TX_C_DN<3>: length 180.9
  IN1 w0.089: v4(98.36,85.13) 98.05,85.13 97.98,85.2 97.98,85.37 98.17,85.55 98.99,85.55 99.44,85.63 99.5,85.59 99.52,85.59
  IN1 w0.122: v1(267.31,66.29) 267.67,66.66 267.67,66.83 267.63,67.09 266.81,67.9 266.05,68.04 265.91,67.94 265.66,66.48 265.32,66.24 264.7,66.35 264.46,66.69 264.72,68.14 264.62,68.28 263.97,68.4 263.79,68.27 263.43,68.34 263.3,68.51 262.94,68.57 262.77,68.45 262.41,68.51 262.28,68.69 261.92,68.75 261.74,68.63 261.38,68.69 261.26,68.87 260.9,68.93 260.72,68.8 260.36,68.87 260.24,69.04 259.88,69.11 259.7,68.98 259.34,69.04 259.21,69.22 258.85,69.28 258.68,69.16 258.32,69.22 258.19,69.4 257.83,69.46 256.04,69.14 253.11,69.66 251.22,69.33 249.13,69.7 247.17,69.35 245.5,69.64 243.02,69.21 240.86,69.59 237.54,69 235.22,69.41 232.91,69 230.78,69.38 229.02,69.07 227.03,69.42 225.05,69.07 223.19,69.4 218.48,68.57 148.9,80.84 137.33,82.88 130.98,81.76 112.82,84.96 108.37,84.18 101.39,85.41 101.21,85.28 100.85,85.35 100.73,85.52 99.92,85.66 99.57,85.6 99.57,85.6 99.52,85.59
  BOTTOM w0.135: U1.A21 v4(98.36,85.13) ; C46.1 267.67,65.14 267.67,65.94 v1(267.31,66.29)
PE_SLOT3_TX_C_DN<4>: length 171.4
  IN1 w0.089: 99.52,84.57 99.5,84.56 99.44,84.6 99.02,84.53 98.15,84.53 97.98,84.37 97.98,84.2 98.05,84.13 v4(98.36,84.13)
  IN1 w0.122: v1(261.32,66.29) 261.66,66.64 261.66,67.09 261.51,67.3 261.17,67.54 260.28,67.7 260.1,67.58 259.74,67.64 259.62,67.82 259.26,67.88 259.08,67.76 258.72,67.82 258.59,68 258.23,68.06 258.06,67.94 257.7,68 257.57,68.18 257.21,68.24 257.04,68.12 256.68,68.18 256.55,68.36 256.19,68.42 256.01,68.3 255.65,68.36 255.53,68.54 255.17,68.6 254.99,68.48 254.63,68.54 254.51,68.72 254.15,68.78 253.97,68.66 253.61,68.72 253.48,68.9 253,68.98 251.17,68.66 249.08,69.03 247.19,68.69 245.57,68.98 242.96,68.52 240.8,68.9 237.55,68.33 235.23,68.73 232.94,68.33 230.87,68.7 229.12,68.39 227.11,68.74 225.14,68.4 223.24,68.73 218.45,67.89 148.9,80.15 137.33,82.19 130.98,81.07 112.74,84.29 107.72,83.4 100.32,84.71 99.52,84.57
  BOTTOM w0.135: C115.1 261.67,65.14 261.67,65.94 v1(261.32,66.29) ; U1.A20 v4(98.36,84.13)
PE_SLOT3_TX_C_DN<5>: length 169.3
  IN1 w0.089: 99.52,83.57 99.5,83.57 99.44,83.61 99.01,83.53 98.04,83.53 97.97,83.46 97.97,83.21 98.05,83.13 v4(98.36,83.13)
  IN1 w0.122: v1(257.28,66.29) 257.64,66.66 257.64,66.86 257.59,67.13 257.23,67.38 256.31,67.55 256.16,67.45 256.02,66.6 255.68,66.36 255.56,66.38 255.56,66.39 255.06,66.47 254.82,66.81 254.96,67.59 254.77,67.86 254.41,67.93 254.24,67.8 253.88,67.86 253.75,68.04 252.72,68.22 251.23,67.96 249.07,68.34 247.22,68.02 245.52,68.32 242.96,67.87 240.8,68.25 237.55,67.67 235.23,68.08 232.95,67.68 230.94,68.03 229.18,67.72 227.11,68.09 225.14,67.74 223.24,68.08 218.45,67.23 148.9,79.5 137.47,81.51 131.12,80.39 112.9,83.6 107.43,82.64 106.97,82.72 106.8,82.6 106.43,82.66 106.31,82.84 105.95,82.9 105.77,82.78 105.41,82.84 105.29,83.02 104.93,83.08 104.75,82.96 104.39,83.02 104.27,83.2 103.91,83.26 103.73,83.14 103.37,83.2 103.24,83.38 102.88,83.44 102.71,83.32 102.35,83.38 102.22,83.56 101.86,83.62 101.68,83.5 101.32,83.56 101.2,83.74 100.84,83.8 99.52,83.57
  BOTTOM w0.135: U1.A19 v4(98.36,83.13) ; v1(257.28,66.29) 257.63,65.94 257.63,65.14 C116.1
PE_SLOT3_TX_C_DN<6>: length 163.3
  IN1 w0.089: 99.52,82.58 99.5,82.58 99.44,82.62 99.23,82.58 98.98,82.54 98.11,82.54 97.98,82.41 97.98,82.2 98.05,82.13 v4(98.36,82.13)
  IN1 w0.122: 99.52,82.58 100.79,82.81 101.38,82.7 101.5,82.52 101.86,82.46 102.04,82.59 102.4,82.52 102.53,82.34 102.89,82.28 103.06,82.4 103.42,82.34 103.55,82.16 103.91,82.1 104.09,82.22 104.45,82.16 104.57,81.98 104.93,81.92 105.11,82.04 105.47,81.98 105.59,81.8 105.95,81.74 106.13,81.86 106.56,81.79 112.98,82.92 131.08,79.73 137.43,80.85 148.85,78.83 148.85,78.83 148.9,78.83 218.4,66.57 223.24,67.43 225.14,67.09 227.11,67.44 229.36,67.04 231.11,67.35 232.95,67.03 235.16,67.42 237.48,67.01 240.79,67.59 242.94,67.21 245.52,67.66 247.23,67.36 249.07,67.69 250.47,67.44 250.59,67.26 250.95,67.2 251.13,67.32 251.49,67.26 251.85,67.32 252.03,67.2 252.39,67.26 252.51,67.44 252.9,67.51 253.38,67.42 253.62,67.26 253.68,66.95 253.68,66.66 v1(253.32,66.29)
  BOTTOM w0.135: C117.1 253.67,65.14 253.67,65.94 v1(253.32,66.29) ; U1.A18 v4(98.36,82.13)
PE_SLOT3_TX_C_DN<7>: length 161.7
  IN1 w0.089: 99.52,80.7 99.5,80.7 99.44,80.74 99.16,80.69 98.71,80.77 98.12,80.77 97.98,80.63 97.98,80.2 98.05,80.13 v4(98.36,80.13)
  IN1 w0.122: 99.52,80.7 100.57,80.89 100.75,80.76 101.11,80.83 101.23,81.01 101.59,81.07 101.77,80.94 102.13,81.01 102.26,81.19 102.62,81.25 102.79,81.12 103.15,81.19 103.28,81.37 103.64,81.43 104,81.37 104.12,81.19 104.48,81.12 104.66,81.25 106.1,80.99 108.98,81.5 109.12,81.4 109.21,80.92 109.55,80.68 110.17,80.79 110.4,81.13 110.32,81.61 110.42,81.76 110.8,81.82 110.94,81.72 111.02,81.24 111.36,81 111.98,81.11 112.22,81.45 112.14,81.93 112.23,82.08 113.14,82.24 131.06,79.07 137.41,80.19 148.85,78.18 148.85,78.18 148.9,78.17 218.39,65.92 223.14,66.75 225.03,66.42 227.08,66.78 229.36,66.38 231.14,66.69 233.08,66.35 235.26,66.73 237.44,66.35 240.74,66.93 241.88,66.73 242,66.55 242.36,66.49 242.54,66.61 242.9,66.55 244.22,66.78 244.39,66.66 244.76,66.72 244.88,66.9 245.36,66.98 245.8,66.9 245.93,66.73 246.29,66.66 246.47,66.79 247.22,66.65 248.99,66.97 249.34,66.97 249.59,66.86 249.64,66.81 249.64,66.66 v1(249.28,66.29)
  BOTTOM w0.135: C118.1 249.63,65.14 249.63,65.94 v1(249.28,66.29) ; U1.A17 v4(98.36,80.13)
PE_SLOT3_TX_C_DN<8>: length 157.2
  BOTTOM w0.089: 98.98,79.79 98.97,79.77 98.97,79.69 98.5,79.22 97.65,79.22 97.46,79.42 97.46,79.54 97.55,79.63 U1.A16
  BOTTOM w0.135: C119.1 245.92,65.14 245.92,65.77 244.58,67.68 240.66,70.43 229.54,72.39 212.75,72.39 205.1,73.74 197.47,79.08 182.05,81.8 179.7,81.33 176.53,81.97 173.35,81.33 170.18,81.97 166.61,81.25 163.43,81.89 160.65,81.33 158.04,81.86 154.86,81.22 150.93,82.01 148.9,81.6 137.97,79.67 v3(118.9,83.05) 117.57,83.28 114.51,82.74 113.56,82.57 111.44,82.95 109.9,82.68 107.72,83.06 105.78,82.72 103.61,83.1 102.16,82.85 101.77,82.57 101.66,82.46 98.98,79.79
PE_SLOT3_TX_C_DN<9>: length 154.7
  BOTTOM w0.089: U1.A15 97.58,78.63 97.49,78.54 97.49,78.39 97.64,78.23 98.5,78.23 98.55,78.29 98.58,78.29
  BOTTOM w0.135: C120.1 241.94,65.14 241.94,65.85 241.59,66.34 240.86,66.86 240.82,67.05 241.47,67.96 241.39,68.4 240.67,68.91 240.23,68.83 239.59,67.91 239.4,67.88 236.64,69.81 228.82,71.19 211.95,71.19 204.41,72.52 196.64,77.96 182.13,80.52 179.73,80.06 176.53,80.7 173.35,80.06 170.18,80.7 166.72,80.01 163.54,80.64 160.65,80.06 157.93,80.61 154.4,79.91 151.05,80.58 151.05,80.58 150.59,80.66 138.03,78.44 120.52,81.54 v3(120.42,81.56) 119.62,81.7 117.57,81.34 114.11,80.73 112.25,81.05 110.17,80.69 107.85,81.1 106.12,80.79 104.14,81.14 103.13,80.96 102.5,80.85 101.38,80.07 100.2,78.89 99.47,78.37 98.99,78.29 98.58,78.29
PE_SLOT3_TX_C_DN<10>: length 147.3
  BOTTOM w0.089: U1.A14 97.6,77.63 97.49,77.52 97.49,77.39 97.66,77.22 98.42,77.22 98.48,77.27 98.5,77.27
  BOTTOM w0.135: 98.5,77.27 99.62,77.27 100.28,77.39 101.25,78.07 102.35,78.84 104.6,79.24 107.64,78.7 111.01,79.29 114.05,78.76 116.44,79.18 118.86,78.75 121.49,79.22 123.81,78.81 126.44,79.27 138.02,77.22 150.56,79.43 151.06,79.35 151.07,79.34 154.39,78.68 157.81,79.36 160.65,78.79 163.65,79.39 166.83,78.76 170.18,79.43 173.35,78.79 176.53,79.43 179.7,78.79 182.06,79.27 196.15,76.78 203.84,71.4 205.33,71.14 v3(205.33,71.13) 211.84,69.99 228.05,69.99 233.78,68.98 237.49,66.38 237.97,65.69 237.97,65.14 C121.1
PE_SLOT3_TX_C_DN<11>: length 144.9
  BOTTOM w0.089: 98.7,76.28 98.68,76.28 98.62,76.23 97.65,76.23 97.49,76.39 97.49,76.53 97.59,76.63 U1.A13
  BOTTOM w0.135: 98.7,76.28 100.02,76.28 101.25,76.5 101.5,76.54 102.1,76.96 104.49,77.38 107.68,76.82 109.2,77.09 110.87,76.79 113.97,77.34 116.73,76.85 119.63,77.37 122.93,76.78 123.58,76.9 128.26,77.72 138.63,75.89 151.15,78.1 154.39,77.45 157.64,78.1 160.65,77.5 163.83,78.13 167,77.5 170.18,78.13 173.35,77.5 176.53,78.13 179.7,77.5 182.26,78.01 195.32,75.71 203.17,70.21 v3(207.38,69.47) 211.26,68.79 227.95,68.79 230.79,68.28 231.42,67.85 231.49,67.41 230.99,66.69 231.02,66.5 231.54,66.14 231.72,66.17 232.23,66.89 232.66,66.97 233.5,66.38 234.01,65.66 234.01,65.14 C122.1
PE_SLOT3_TX_C_DN<12>: length 138.2
  BOTTOM w0.089: 99.01,75.29 98.99,75.29 98.93,75.23 97.64,75.23 97.5,75.38 97.5,75.55 97.58,75.63 U1.A12
  BOTTOM w0.135: 99.01,75.29 101.76,75.29 104.39,74.83 106.86,75.26 108.5,74.97 111.1,75.43 114.16,74.89 117.23,75.43 118.48,75.21 119.63,75.41 121.37,75.11 125.66,75.86 128.77,76.41 138.74,74.65 151.14,76.84 154.49,76.21 157.69,76.85 160.65,76.25 163.83,76.89 167,76.25 170.18,76.89 173.35,76.25 176.53,76.89 179.7,76.25 182.33,76.78 194.84,74.57 202.69,69.08 v3(204.27,68.8) 211.15,67.58 227.57,67.58 228.61,66.86 229.44,66.27 229.48,66.24 229.71,65.91 229.97,65.54 229.97,65.14 C123.1
PE_SLOT3_TX_C_DN<13>: length 135.9
  BOTTOM w0.089: 99.52,74.28 99.5,74.28 99.44,74.22 97.61,74.22 97.49,74.35 97.49,74.52 97.59,74.63 U1.A11
  BOTTOM w0.135: C124.1 226.04,65.14 226.04,65.44 225.75,65.85 224.99,66.38 224.45,66.38 224.13,66.07 224.13,65.34 224,65.2 223.37,65.2 223.24,65.34 223.24,66.07 222.92,66.38 211.05,66.38 202.22,67.94 v3(201.1,68.72) 194.37,73.44 182.46,75.54 179.7,74.98 176.53,75.62 173.35,74.98 170.18,75.62 167,74.98 163.83,75.62 160.65,74.98 157.74,75.57 154.56,74.93 151.33,75.58 138.95,73.4 129.63,75.04 127.63,74.69 126.49,74.49 122.37,73.76 118.47,73.07 116.48,73.42 113.75,72.94 110.75,73.47 107.83,72.96 105.24,73.41 103.65,73.13 101.5,73.51 101.25,73.69 100.57,74.17 99.96,74.28 99.52,74.28
PE_SLOT3_TX_C_DN<14>: length 128
  BOTTOM w0.089: U1.A10 97.61,73.63 97.51,73.53 97.51,73.32 97.6,73.23 98.13,73.23 98.42,73.18 98.79,72.92 99.44,72.92 99.5,72.97 99.52,72.97
  BOTTOM w0.135: C125.1 219.67,64.67 219.06,64.67 218.57,65.01 217.59,65.18 209.59,65.18 208.02,65.46 207.9,65.64 207.5,65.71 207.32,65.58 206.92,65.65 206.8,65.83 206.4,65.9 206.22,65.78 205.83,65.85 205.7,66.02 205.3,66.09 205.13,65.97 202.11,66.5 v3(198.54,69) 193.8,72.32 182.59,74.29 179.7,73.72 176.53,74.35 173.35,73.71 170.18,74.35 167,73.71 163.83,74.35 160.65,73.71 157.65,74.31 154.48,73.68 151.54,74.27 139.31,72.11 131.57,73.48 128.61,72.96 127.16,72.7 118.54,71.18 116.51,71.54 114.27,71.14 112.85,71.39 111.11,71.08 108.87,71.48 107.31,71.2 105.42,71.54 103.41,71.18 101.74,71.48 101.47,71.67 100.79,72.34 100.16,72.97 99.52,72.97
PE_SLOT3_TX_C_DN<15>: length 122.1
  BOTTOM w0.089: 99.76,71.41 99.74,71.43 99.66,71.43 99.08,72.01 98.58,72.01 98.38,72.21 97.58,72.21 97.42,72.37 97.42,72.56 97.5,72.63 U1.A9
  BOTTOM w0.135: C126.1 208.82,63.47 208.63,63.47 207.94,63.6 207.82,63.77 207.42,63.84 207.25,63.72 206.85,63.79 206.72,63.97 206.33,64.04 206.15,63.91 202.89,64.49 201.81,65.24 201.38,65.16 200.85,64.42 200.67,64.38 200.15,64.75 200.12,64.93 200.64,65.68 200.56,66.12 199.84,66.62 199.41,66.54 198.88,65.8 198.7,65.76 198.18,66.12 198.15,66.31 198.67,67.06 198.59,67.49 193.33,71.18 182.84,73.03 179.75,72.41 176.53,73.05 173.35,72.42 170.18,73.05 167,72.42 163.83,73.05 160.65,72.42 157.48,73.05 154.38,72.43 151.83,72.94 151.73,72.96 139.65,70.83 132.06,72.17 v3(125.77,71.06) 123.67,70.69 116.36,69.4 115.62,69.53 113.91,69.23 112.1,69.55 110.32,69.23 108.57,69.54 107.17,69.3 105.51,69.59 103.73,69.27 101.74,69.62 101.1,70.07 99.76,71.41
PE_SLOT3_TX_C_DP<0>: length 190.8
  IN1 w0.089: v4(97.36,88.13) 97.68,88.13 97.79,88.24 97.79,88.45 98.09,88.75 98.63,88.75 99.01,88.81 99.44,88.74 99.5,88.78 99.52,88.78
  IN1 w0.122: 99.52,88.78 99.95,88.7 100.98,88.52 102.57,88.8 104.8,88.4 107.9,88.95 111.23,88.36 114.29,88.9 117.75,88.29 119.89,88.67 122.12,88.28 127,84.86 130.98,84.16 137.33,85.28 148.9,83.24 218.72,70.93 223.3,71.74 225.12,71.42 227.29,71.8 229.34,71.44 230.79,71.69 232.82,71.33 235.1,71.73 237.5,71.31 240.68,71.87 243.02,71.46 245.65,71.92 247.19,71.65 249.28,72.02 251.12,71.7 252.76,71.98 255.74,71.46 258.74,72.1 278.04,68.7 279.65,67.57 279.93,67.16 279.98,66.9 279.98,66.66 v1(280.34,66.29)
  BOTTOM w0.135: v1(280.34,66.29) 279.99,65.94 279.99,65.14 C39.1 ; U1.B24 v4(97.36,88.13)
PE_SLOT3_TX_C_DP<1>: length 188.9
  IN1 w0.089: 99.52,87.5 99.5,87.5 99.44,87.46 98.94,87.55 98.68,87.73 98.07,87.73 97.81,87.46 97.81,87.27 97.67,87.13 v4(97.36,87.13)
  IN1 w0.122: 99.52,87.5 108.63,85.89 112.92,86.65 115.76,86.15 115.9,86.25 116.01,86.85 116.34,87.09 116.96,86.98 117.2,86.64 117.1,86.04 117.2,85.9 117.58,85.83 117.72,85.93 117.82,86.53 118.16,86.77 118.78,86.66 119.02,86.32 118.91,85.72 119.01,85.58 130.98,83.47 137.33,84.59 148.9,82.54 218.72,70.24 223.17,71.02 224.95,70.71 226.75,71.02 227.04,71.08 229.07,70.72 230.74,71.01 232.77,70.65 235.05,71.05 237.44,70.63 240.73,71.21 243.02,70.81 245.58,71.26 247.18,70.98 249.21,71.33 251.22,70.98 252.99,71.29 254.42,71.04 255.79,70.8 258.62,71.29 274.28,68.54 275.23,68.03 275.85,67.31 275.94,66.78 275.94,66.66 v1(276.3,66.29)
  BOTTOM w0.135: v1(276.3,66.29) 275.95,65.94 275.95,65.14 C40.1 ; U1.B23 v4(97.36,87.13)
PE_SLOT3_TX_C_DP<2>: length 181.8
  IN1 w0.089: 99.42,86.8 99.4,86.8 99.34,86.76 98.73,86.87 98.53,86.73 98.07,86.73 97.79,86.45 97.79,86.23 97.69,86.13 v4(97.36,86.13)
  IN1 w0.122: v1(272.37,66.29) 272,66.66 272,66.86 271.88,67.56 271.64,67.89 271.13,68.25 258.15,70.54 255.83,70.13 253.11,70.61 251.31,70.29 249.18,70.67 247.19,70.32 245.57,70.6 243.02,70.15 240.78,70.55 237.46,69.96 235.08,70.38 232.8,69.98 230.81,70.33 229.18,70.05 227.13,70.41 224.99,70.03 223.12,70.36 218.68,69.58 148.9,81.88 137.56,83.88 131.21,82.76 112.99,85.97 108.56,85.19 99.52,86.78 99.42,86.8
  BOTTOM w0.135: v1(272.37,66.29) 272.01,65.94 272.01,65.14 C41.1 ; U1.B22 v4(97.36,86.13)
PE_SLOT3_TX_C_DP<3>: length 180.8
  IN1 w0.089: v4(97.36,85.13) 97.71,85.13 97.79,85.22 97.79,85.45 98.09,85.74 98.97,85.74 99.41,85.82 99.45,85.88 99.47,85.88
  IN1 w0.122: 99.47,85.88 99.52,85.89 99.92,85.96 108.37,84.47 112.82,85.26 130.98,82.06 137.33,83.18 148.9,81.14 218.48,68.87 223.19,69.7 225.05,69.37 227.03,69.71 228.07,69.53 229.02,69.36 230.78,69.67 232.91,69.3 235.22,69.71 237.54,69.3 240.86,69.88 243.02,69.5 245.5,69.94 247.17,69.65 249.13,69.99 251.22,69.62 253.11,69.96 256.04,69.44 257.83,69.76 264.02,68.69 264.79,68.55 265.02,68.21 264.77,66.76 264.87,66.62 265.25,66.55 265.39,66.65 265.65,68.11 265.98,68.34 266.95,68.18 267.9,67.23 267.97,66.85 267.97,66.66 v1(268.33,66.29)
  BOTTOM w0.135: v1(268.33,66.29) 267.97,65.94 267.97,65.14 C42.1 ; U1.B21 v4(97.36,85.13)
PE_SLOT3_TX_C_DP<4>: length 171.3
  IN1 w0.089: 99.47,84.85 99.45,84.85 99.41,84.79 99.19,84.75 99.01,84.72 98.07,84.72 97.79,84.45 97.79,84.2 97.72,84.13 v4(97.36,84.13)
  IN1 w0.122: 99.47,84.85 100.32,85 107.72,83.7 112.74,84.59 130.98,81.37 137.33,82.49 148.9,80.45 218.45,68.18 223.24,69.03 225.14,68.69 227.11,69.04 229.12,68.68 230.87,68.99 232.94,68.63 235.23,69.03 237.55,68.62 240.8,69.2 242.96,68.82 245.57,69.28 247.19,68.99 249.08,69.32 251.17,68.96 253,69.28 261.28,67.82 261.33,67.78 261.72,67.51 261.95,67.18 261.95,66.67 v1(262.33,66.29)
  BOTTOM w0.135: v1(262.33,66.29) 261.98,65.94 261.98,65.14 C103.1 ; U1.B20 v4(97.36,84.13)
PE_SLOT3_TX_C_DP<5>: length 169.2
  IN1 w0.089: 99.47,83.86 99.45,83.85 99.41,83.8 99.13,83.75 99,83.72 97.96,83.72 97.78,83.54 97.78,83.2 97.71,83.13 v4(97.36,83.13)
  IN1 w0.122: 99.47,83.86 100.84,84.1 107.43,82.94 112.9,83.9 131.12,80.69 137.47,81.81 148.9,79.79 218.45,67.53 223.24,68.38 225.14,68.04 227.11,68.39 229.18,68.02 230.94,68.33 232.95,67.98 235.23,68.38 237.55,67.97 240.8,68.54 242.96,68.16 245.52,68.61 247.22,68.31 249.07,68.64 251.23,68.26 252.72,68.52 254.94,68.13 255.27,67.66 255.13,66.88 255.23,66.74 255.61,66.67 255.75,66.77 255.9,67.62 256.24,67.86 257.34,67.66 257.85,67.31 257.93,66.89 257.93,66.66 v1(258.29,66.29)
  BOTTOM w0.135: C104.1 257.94,65.14 257.94,65.94 v1(258.29,66.29) ; U1.B19 v4(97.36,83.13)
PE_SLOT3_TX_C_DP<6>: length 163.2
  IN1 w0.089: 99.47,82.87 99.45,82.87 99.41,82.81 99.19,82.77 98.97,82.73 98.03,82.73 97.79,82.49 97.79,82.19 97.73,82.13 v4(97.36,82.13)
  IN1 w0.122: v1(254.33,66.29) 253.97,66.66 253.97,66.98 253.96,67.03 253.89,67.43 253.5,67.7 252.9,67.81 252.46,67.73 251.49,67.56 249.07,67.99 247.23,67.66 245.52,67.96 242.94,67.51 240.79,67.89 237.48,67.3 235.16,67.71 232.95,67.32 231.11,67.65 229.36,67.34 227.11,67.73 225.14,67.39 223.24,67.72 220.8,67.29 218.4,66.87 148.9,79.12 137.43,81.15 131.08,80.03 112.98,83.22 106.56,82.09 100.79,83.1 99.52,82.88 99.47,82.87
  BOTTOM w0.135: v1(254.33,66.29) 253.98,65.94 253.98,65.14 C105.1 ; U1.B18 v4(97.36,82.13)
PE_SLOT3_TX_C_DP<7>: length 161.6
  IN1 w0.089: v4(97.36,80.13) 97.71,80.13 97.79,80.21 97.79,80.71 98.04,80.96 98.72,80.96 99.16,80.89 99.41,80.93 99.45,80.99 99.47,80.99
  IN1 w0.122: 99.47,80.99 99.52,81 103.64,81.73 106.1,81.29 109.05,81.81 109.39,81.57 109.47,81.09 109.62,80.99 110,81.06 110.1,81.2 110.01,81.68 110.25,82.02 110.87,82.13 111.21,81.89 111.29,81.41 111.43,81.31 111.81,81.38 111.91,81.52 111.83,82 112.06,82.34 113.14,82.53 131.06,79.37 137.41,80.49 148.9,78.47 218.39,66.21 223.14,67.05 225.03,66.72 227.08,67.08 229.36,66.67 231.14,66.99 233.08,66.65 235.26,67.03 237.44,66.65 240.74,67.23 242.9,66.85 245.36,67.28 247.22,66.95 248.97,67.26 249.4,67.26 249.76,67.11 249.93,66.94 249.93,66.66 v1(250.29,66.29)
  BOTTOM w0.135: U1.B17 v4(97.36,80.13) ; v1(250.29,66.29) 249.94,65.94 249.94,65.14 C106.1
PE_SLOT3_TX_C_DP<8>: length 157.2
  BOTTOM w0.089: 99.2,79.57 99.18,79.55 99.1,79.55 98.58,79.03 97.57,79.03 97.27,79.34 97.27,79.54 97.18,79.63 U1.B16
  BOTTOM w0.135: 99.2,79.57 101.88,82.25 101.97,82.34 102.28,82.56 103.61,82.79 105.78,82.41 107.72,82.75 109.9,82.37 111.44,82.64 113.56,82.26 v3(114.56,82.44) 117.57,82.97 118.85,82.75 137.97,79.36 148.9,81.29 150.93,81.7 154.86,80.91 158.04,81.55 160.65,81.02 163.43,81.58 166.61,80.94 170.18,81.66 173.35,81.02 176.53,81.66 179.7,81.02 182.05,81.49 197.35,78.79 204.98,73.45 212.72,72.09 229.52,72.09 240.54,70.14 242.21,68.98 242.25,68.76 242.58,68.53 242.79,68.57 243.12,68.34 243.16,68.12 243.49,67.89 243.7,67.93 244.37,67.46 245.62,65.67 245.62,65.14 C107.1
PE_SLOT3_TX_C_DP<9>: length 154.7
  BOTTOM w0.089: U1.B15 97.18,78.63 97.3,78.51 97.3,78.31 97.56,78.04 98.5,78.04 98.55,77.98 98.58,77.98
  BOTTOM w0.135: 98.58,77.98 99.04,77.98 99.04,77.99 99.59,78.09 100.39,78.65 101.58,79.83 102.61,80.56 103.13,80.65 104.14,80.83 106.12,80.48 107.85,80.79 110.17,80.38 112.25,80.74 114.11,80.42 v3(117.63,81.04) 119.62,81.39 120.37,81.26 138.03,78.13 150.59,80.35 150.99,80.28 151,80.27 151.04,80.27 154.4,79.59 157.93,80.3 160.65,79.75 163.54,80.33 166.72,79.7 170.18,80.39 173.35,79.75 176.53,80.39 179.73,79.75 182.13,80.21 196.52,77.67 204.29,72.23 211.92,70.88 228.79,70.88 236.53,69.52 236.98,69.2 237.01,68.99 237.34,68.76 237.56,68.8 239.33,67.55 239.77,67.63 240.41,68.55 240.6,68.58 241.11,68.22 241.15,68.04 240.5,67.12 240.58,66.68 241.37,66.12 241.63,65.76 241.63,65.14 C108.1
PE_SLOT3_TX_C_DP<10>: length 147.3
  BOTTOM w0.089: U1.B14 97.18,77.63 97.3,77.51 97.3,77.31 97.58,77.03 98.42,77.03 98.48,76.97 98.5,76.97
  BOTTOM w0.135: C109.1 237.67,65.14 237.67,65.59 237.27,66.16 236.94,66.39 236.73,66.35 236.4,66.58 236.36,66.8 233.66,68.69 228.03,69.68 211.82,69.68 205.54,70.79 205.28,70.83 205.28,70.84 203.73,71.11 196.03,76.49 182.07,78.96 179.7,78.48 176.53,79.12 173.35,78.48 170.18,79.12 166.83,78.45 163.65,79.08 160.65,78.48 157.81,79.05 154.39,78.37 151.06,79.03 151.01,79.04 150.99,79.05 150.56,79.12 138.02,76.91 126.44,78.96 125.3,78.76 v3(125.3,78.76) 123.81,78.5 121.49,78.91 118.86,78.44 116.44,78.87 114.05,78.45 111.01,78.98 107.64,78.39 104.6,78.93 102.47,78.55 101.25,77.69 100.4,77.1 99.68,76.97 99.67,76.97 98.5,76.97
PE_SLOT3_TX_C_DP<11>: length 144.9
  BOTTOM w0.089: 98.7,75.98 98.68,75.98 98.62,76.03 97.57,76.03 97.3,76.31 97.3,76.51 97.18,76.63 U1.B13
  BOTTOM w0.135: 98.7,75.98 100.05,75.98 101.25,76.19 101.62,76.25 102.21,76.67 104.49,77.07 107.68,76.51 109.2,76.78 110.87,76.48 113.97,77.03 116.73,76.54 119.63,77.06 122.63,76.53 122.93,76.47 v3(123.63,76.6) 128.26,77.41 138.63,75.58 151.15,77.79 154.39,77.14 157.64,77.79 160.65,77.19 163.83,77.82 167,77.19 170.18,77.82 173.35,77.19 176.53,77.82 179.7,77.19 182.27,77.7 195.2,75.42 203.05,69.92 207.33,69.17 211.23,68.48 227.92,68.48 229.17,68.26 229.29,68.08 229.69,68.01 229.87,68.14 230.67,68 231.14,67.67 231.17,67.48 230.67,66.76 230.74,66.33 231.47,65.82 231.9,65.9 232.4,66.62 232.59,66.65 233.29,66.16 233.71,65.56 233.71,65.14 C110.1
PE_SLOT3_TX_C_DP<12>: length 138.2
  BOTTOM w0.089: 99.01,74.99 98.99,74.99 98.93,75.04 97.56,75.04 97.31,75.3 97.31,75.5 97.18,75.63 U1.B12
  BOTTOM w0.135: 99.01,74.99 101.73,74.99 104.39,74.52 106.86,74.95 108.5,74.66 111.1,75.12 114.16,74.58 117.23,75.12 118.48,74.9 119.63,75.1 121.37,74.8 v3(125.72,75.56) 128.77,76.1 138.74,74.34 151.13,76.53 154.5,75.9 157.69,76.54 160.65,75.94 163.83,76.58 167,75.94 170.18,76.58 173.35,75.94 176.53,76.58 179.7,75.94 182.33,76.47 194.72,74.28 202.57,68.79 204.22,68.5 211.13,67.28 227.47,67.28 228.33,66.68 228.37,66.47 228.7,66.23 228.91,66.27 229.26,66.02 229.67,65.44 229.67,65.14 C111.1
PE_SLOT3_TX_C_DP<13>: length 135.9
  BOTTOM w0.089: 99.52,73.97 99.5,73.97 99.44,74.03 97.54,74.03 97.3,74.27 97.3,74.51 97.18,74.63 U1.B11
  BOTTOM w0.135: C112.1 225.73,65.14 225.73,65.35 225.53,65.63 224.89,66.08 224.57,66.08 224.44,65.94 224.44,65.21 224.13,64.9 223.25,64.9 222.93,65.21 222.93,65.94 222.8,66.08 222.13,66.08 221.98,65.92 221.57,65.92 221.42,66.08 211.02,66.08 202.1,67.65 200.92,68.47 194.25,73.15 182.47,75.23 179.7,74.67 176.53,75.31 173.35,74.67 170.18,75.31 167,74.67 163.83,75.31 160.65,74.67 157.74,75.26 154.56,74.62 151.33,75.27 138.95,73.09 129.63,74.73 126.55,74.19 v3(122.42,73.46) 118.47,72.76 116.48,73.11 113.75,72.63 110.75,73.16 107.83,72.65 105.24,73.11 103.65,72.82 101.38,73.22 100.45,73.88 99.93,73.97 99.52,73.97
PE_SLOT3_TX_C_DP<14>: length 128
  BOTTOM w0.089: U1.B10 97.18,73.63 97.32,73.49 97.32,73.24 97.53,73.04 98.11,73.04 98.35,73 98.73,72.73 99.44,72.73 99.5,72.67 99.52,72.67
  BOTTOM w0.135: C113.1 219.67,64.36 218.96,64.36 218.45,64.72 217.56,64.88 209.57,64.88 205.07,65.67 205.07,65.67 201.99,66.21 198.36,68.75 193.68,72.03 182.59,73.98 179.7,73.4 176.53,74.04 173.35,73.4 170.18,74.04 167,73.4 163.83,74.04 160.65,73.4 157.65,74 154.48,73.37 151.53,73.96 139.31,71.8 131.91,73.11 131.57,73.17 v3(128.66,72.65) 118.54,70.87 116.51,71.23 114.27,70.83 112.85,71.08 111.11,70.77 108.87,71.17 107.31,70.89 105.42,71.23 103.41,70.87 101.62,71.19 101.27,71.44 100.58,72.13 100.03,72.67 99.52,72.67
PE_SLOT3_TX_C_DP<15>: length 122.1
  BOTTOM w0.089: 99.54,71.2 99.53,71.21 99.53,71.29 99,71.82 98.5,71.82 98.3,72.02 97.5,72.02 97.23,72.29 97.23,72.52 97.12,72.63 U1.B9
  BOTTOM w0.135: 99.54,71.2 100.91,69.84 101.62,69.34 103.73,68.96 104.67,69.13 105.51,69.28 107.12,69 107.17,68.99 108.57,69.23 110.32,68.92 112.1,69.24 113.91,68.92 115.62,69.22 116.36,69.09 v3(123.73,70.39) 125.82,70.76 132.06,71.86 139.65,70.52 151.73,72.65 154.38,72.12 157.48,72.74 160.65,72.11 163.83,72.74 167,72.11 170.18,72.74 173.35,72.11 176.53,72.74 179.75,72.1 182.84,72.72 193.21,70.89 198.32,67.32 198.35,67.13 197.83,66.38 197.9,65.95 198.62,65.44 199.06,65.52 199.58,66.27 199.77,66.3 200.29,65.94 200.32,65.75 199.8,65 199.87,64.57 200.59,64.06 201.03,64.14 201.55,64.89 201.74,64.92 202.77,64.2 208.6,63.17 208.92,63.17 C114.1
PE_SLOT3_TX_DN<0>: length 6.4
  BOTTOM w0.135: J3.B15 280.2,58.82 280.14,59 280.14,59 279.95,59.09 279.68,59.36 279.68,63.63 C43.2
PE_SLOT3_TX_DN<1>: length 6.3
  BOTTOM w0.135: J3.B20 275.2,59.33 275.4,59.26 275.54,59.33 275.64,59.44 275.64,61.41 275.49,61.56 275.49,61.96 275.64,62.12 275.64,62.52 275.49,62.67 275.49,63.08 275.64,63.23 275.64,63.63 C44.2
PE_SLOT3_TX_DN<2>: length 6.3
  BOTTOM w0.135: C45.2 271.73,63.61 271.73,63.2 271.58,63.05 271.58,62.65 271.73,62.49 271.73,62.09 271.58,61.94 271.58,61.53 271.73,61.38 271.73,59.56 271.5,59.33 271.38,59.27 271.2,59.33 J3.B24
PE_SLOT3_TX_DN<3>: length 6.3
  BOTTOM w0.135: J3.B28 267.2,59.33 267.39,59.27 267.51,59.33 267.67,59.49 267.67,61.41 267.51,61.56 267.51,61.96 267.67,62.12 267.67,62.52 267.51,62.67 267.51,63.08 267.67,63.23 267.67,63.63 C46.2
PE_SLOT3_TX_DN<4>: length 6.3
  BOTTOM w0.135: J3.B34 261.2,59.33 261.38,59.27 261.53,59.35 261.67,59.49 261.67,61.41 261.52,61.56 261.52,61.96 261.67,62.12 261.67,62.52 261.52,62.67 261.52,63.08 261.67,63.23 261.67,63.63 C115.2
PE_SLOT3_TX_DN<5>: length 6.3
  BOTTOM w0.135: J3.B38 257.2,59.33 257.37,59.28 257.58,59.38 257.68,59.49 257.68,61.35 257.53,61.51 257.53,61.91 257.68,62.06 257.68,62.47 257.53,62.62 257.53,63.03 257.68,63.18 257.68,63.58 C116.2
PE_SLOT3_TX_DN<6>: length 6.3
  BOTTOM w0.135: C117.2 253.67,63.63 253.67,63.23 253.52,63.08 253.52,62.67 253.67,62.52 253.67,62.12 253.52,61.96 253.52,61.56 253.67,61.41 253.67,59.48 253.54,59.34 253.39,59.27 253.2,59.33 J3.B42
PE_SLOT3_TX_DN<7>: length 6.3
  BOTTOM w0.135: J3.B46 249.2,59.33 249.38,59.27 249.51,59.33 249.63,59.46 249.63,61.41 249.48,61.56 249.48,61.96 249.63,62.12 249.63,62.52 249.48,62.67 249.48,63.08 249.63,63.23 249.63,63.63 C118.2
PE_SLOT3_TX_DN<8>: length 7.4
  BOTTOM w0.135: C119.2 246,63.71 246,59.72 arc(245.76,59.13) 245.17,58.89 244.72,58.89 arc(244.65,58.87) 244.59,58.83 J3.B51
PE_SLOT3_TX_DN<9>: length 7.4
  BOTTOM w0.135: J3.B55 240.59,58.83 arc(240.65,58.87) 240.72,58.89 241.17,58.89 arc(241.76,59.13) 242,59.72 242,63.7 C120.2
PE_SLOT3_TX_DN<10>: length 7.4
  BOTTOM w0.135: J3.B59 236.59,58.83 arc(236.65,58.87) 236.72,58.89 237.17,58.89 arc(237.76,59.13) 238,59.72 238,63.66 C121.2
PE_SLOT3_TX_DN<11>: length 7.4
  BOTTOM w0.135: J3.B63 232.59,58.83 arc(232.65,58.87) 232.72,58.89 233.17,58.89 arc(233.76,59.13) 234,59.72 234,63.62 C122.2
PE_SLOT3_TX_DN<12>: length 7.4
  BOTTOM w0.135: J3.B67 228.59,58.83 arc(228.65,58.87) 228.72,58.89 229.17,58.89 arc(229.76,59.13) 230,59.72 230,63.66 C123.2
PE_SLOT3_TX_DN<13>: length 7.4
  BOTTOM w0.135: C124.2 226,63.6 226,59.72 arc(225.76,59.13) 225.17,58.89 224.72,58.89 arc(224.65,58.87) 224.59,58.83 J3.B71
PE_SLOT3_TX_DN<14>: length 9
  BOTTOM w0.135: J3.B75 220.59,58.83 arc(220.65,58.87) 220.72,58.89 221.17,58.89 arc(221.76,59.13) 222,59.72 222,64.31 221.47,64.84 221,64.84 C125.2
PE_SLOT3_TX_DN<15>: length 12.7
  BOTTOM w0.135: C126.2 210.33,63.58 211.14,63.58 217.34,61.33 217.93,60.73 217.93,60.73 218,60.35 218,59.72 arc(217.76,59.13) 217.17,58.89 216.72,58.89 arc(216.65,58.87) 216.59,58.83 J3.B79
PE_SLOT3_TX_DP<0>: length 6.3
  BOTTOM w0.135: C39.2 279.99,63.63 279.99,63.23 280.14,63.08 280.14,62.67 279.99,62.52 279.99,62.12 280.14,61.96 280.14,61.56 279.99,61.41 279.99,59.49 280.13,59.35 280.28,59.27 280.46,59.33 J3.B14
PE_SLOT3_TX_DP<1>: length 6.4
  BOTTOM w0.135: C40.2 275.95,63.63 275.95,59.31 275.72,59.08 275.51,58.98 275.46,58.82 J3.B19
PE_SLOT3_TX_DP<2>: length 6.4
  BOTTOM w0.135: J3.B23 271.46,58.82 271.52,59 271.68,59.08 272.04,59.44 272.04,63.66 C41.2
PE_SLOT3_TX_DP<3>: length 6.4
  BOTTOM w0.135: J3.B27 267.46,58.82 267.51,58.99 267.69,59.08 267.97,59.36 267.97,63.63 C42.2
PE_SLOT3_TX_DP<4>: length 6.4
  BOTTOM w0.135: C103.2 261.98,63.63 261.98,59.36 261.71,59.1 261.52,59 261.52,59 261.46,58.82 J3.B33
PE_SLOT3_TX_DP<5>: length 6.4
  BOTTOM w0.135: J3.B37 257.46,58.82 257.52,59.01 257.76,59.13 257.99,59.36 257.99,63.68 C104.2
PE_SLOT3_TX_DP<6>: length 6.4
  BOTTOM w0.135: J3.B41 253.46,58.82 253.51,58.99 253.72,59.09 253.98,59.35 253.98,63.63 C105.2
PE_SLOT3_TX_DP<7>: length 6.4
  BOTTOM w0.135: C106.2 249.94,63.63 249.94,59.33 249.69,59.08 249.52,59 249.46,58.82 J3.B45
PE_SLOT3_TX_DP<8>: length 7.4
  BOTTOM w0.135: J3.B50 244.39,59.64 arc(244.34,59.35) 244.58,59.19 245.17,59.19 arc(245.54,59.35) 245.7,59.72 245.7,60.84 245.54,60.99 245.54,61.39 245.7,61.55 245.7,61.95 245.54,62.1 245.54,62.51 245.7,62.66 245.7,63.56 C107.2
PE_SLOT3_TX_DP<9>: length 7.4
  BOTTOM w0.135: J3.B54 240.38,59.63 arc(240.33,59.35) 240.56,59.19 241.17,59.19 arc(241.54,59.35) 241.7,59.72 241.7,60.84 241.54,60.99 241.54,61.39 241.7,61.55 241.7,61.95 241.54,62.1 241.54,62.51 241.7,62.66 241.7,63.57 C108.2
PE_SLOT3_TX_DP<10>: length 7.4
  BOTTOM w0.135: J3.B58 236.36,59.6 arc(236.31,59.34) 236.53,59.19 237.17,59.19 arc(237.54,59.35) 237.69,59.72 237.69,60.84 237.54,60.99 237.54,61.39 237.69,61.55 237.69,61.95 237.54,62.1 237.54,62.51 237.69,62.66 237.69,63.61 C109.2
PE_SLOT3_TX_DP<11>: length 7.4
  BOTTOM w0.135: C110.2 233.69,63.65 233.69,62.66 233.54,62.51 233.54,62.1 233.69,61.95 233.69,61.55 233.54,61.39 233.54,60.99 233.69,60.84 233.69,59.72 arc(233.54,59.35) 233.17,59.19 232.5,59.19 arc(232.29,59.33) 232.34,59.58 J3.B62
PE_SLOT3_TX_DP<12>: length 7.4
  BOTTOM w0.135: J3.B66 228.36,59.61 arc(228.31,59.34) 228.53,59.19 229.17,59.19 arc(229.54,59.35) 229.69,59.72 229.69,60.84 229.54,60.99 229.54,61.39 229.69,61.55 229.69,61.95 229.54,62.1 229.54,62.51 229.69,62.66 229.69,63.61 C111.2
PE_SLOT3_TX_DP<13>: length 7.4
  BOTTOM w0.135: J3.B70 224.34,59.58 arc(224.29,59.33) 224.5,59.19 225.17,59.19 arc(225.54,59.35) 225.7,59.72 225.7,60.84 225.54,60.99 225.54,61.39 225.7,61.55 225.7,61.95 225.54,62.1 225.54,62.51 225.7,62.66 225.7,63.67 C112.2
PE_SLOT3_TX_DP<14>: length 9
  BOTTOM w0.135: J3.B74 220.34,59.58 arc(220.29,59.33) 220.5,59.19 221.17,59.19 arc(221.54,59.35) 221.7,59.72 221.7,60.84 221.54,61 221.54,61.4 221.7,61.55 221.7,61.96 221.54,62.11 221.54,62.51 221.7,62.67 221.7,63.07 221.54,63.22 221.54,63.63 221.7,63.78 221.7,64.18 221.34,64.54 220.98,64.54 220.82,64.38 C113.2
PE_SLOT3_TX_DP<15>: length 12.6
  BOTTOM w0.135: J3.B78 216.34,59.58 arc(216.29,59.33) 216.5,59.19 217.17,59.19 arc(217.54,59.35) 217.7,59.72 217.7,60.33 217.65,60.59 217.17,61.06 216.42,61.33 216.23,61.24 215.85,61.38 215.76,61.58 215.38,61.71 215.18,61.62 214.8,61.76 214.71,61.96 214.33,62.09 214.13,62 213.75,62.14 213.66,62.34 213.28,62.47 213.08,62.38 212.71,62.52 212.61,62.72 212.23,62.85 212.04,62.76 211.66,62.9 211.57,63.1 211.08,63.27 210.43,63.27 C114.2
PE_SLOT4_PRES_N: length 291.4
  TOP w0.127: R269.2 v1(73.61,51.69)
  IN2 w0.112: v1(73.61,51.69) 74.34,52.42 118.03,52.42 127.79,62.18 142.65,62.18 161.99,42.84 185.2,42.84 198.29,29.74 283.11,29.74 284.63,31.26 295.23,31.26 296.48,32.51 296.48,33.93 296.11,34.29 295.35,34.29 294.97,34.67 294.97,35.56 296.61,37.2 296.61,39.77 294.46,41.92 294.46,45.09 295.84,46.46 295.84,51.86 296.6,52.63 296.6,53.98 295.97,54.61 295.61,54.61 294.97,55.24 294.97,56.01 296.88,57.91 296.88,74.85 J4.A1
PE_SLOT4_RX_DN<0>: length 220.3
  IN3 w0.089: v4(82.36,95.13) 82.36,94.81 82.28,94.73 81.91,94.73 81.61,95.02 81.61,95.51 81.66,95.55 81.66,95.58
  IN3 w0.135: J4.A17 278.2,75.14 278.39,75.08 278.51,75.15 278.67,75.3 278.67,78.69 arc(278.51,79.06) 278.14,79.21 278.09,79.21 arc(277.79,79.34) 277.67,79.64 277.67,80.92 277.22,81.56 276.95,81.75 276.73,81.71 276.4,81.94 276.36,82.16 276.03,82.39 275.82,82.35 275.49,82.58 275.45,82.79 275.12,83.03 274.91,82.99 274.58,83.22 274.54,83.43 273.58,84.1 273.19,84.17 273.03,84.06 272.63,84.13 272.52,84.29 272.12,84.36 271.96,84.25 271.56,84.32 271.45,84.48 270.64,84.62 270.3,84.86 270.1,85.14 270.03,85.54 269.87,85.65 269.8,86.05 269.91,86.21 269.81,86.79 269.47,87.28 269,87.61 267.19,87.93 267.03,87.82 266.64,87.89 266.52,88.05 266.13,88.12 265.97,88 265.57,88.07 265.46,88.23 265.06,88.3 264.9,88.19 264.5,88.26 264.39,88.42 264,88.49 263.84,88.38 263.44,88.45 263.33,88.61 262.93,88.68 262.77,88.57 262.37,88.64 262.26,88.8 261.86,88.87 261.71,88.76 261.31,88.83 261.2,88.98 250.59,90.86 245.38,89.94 231.17,92.44 225.69,91.48 221.43,92.23 218.39,91.69 216.5,92.03 215.44,91.84 214.33,91.65 212.36,91.99 208.21,91.26 205.08,91.81 204.31,91.68 203.59,91.55 202.87,91.43 202.1,91.29 199.18,91.8 196.26,91.29 189.13,92.55 173.95,89.87 128.76,97.83 120.67,103.5 111.9,105.05 107.73,104.31 105.03,104.79 100.18,103.93 93.84,105.05 88.28,104.07 82.91,100.31 82.91,100.31 82.63,99.91 82.36,99.52 82.39,99.3 82.16,98.97 81.95,98.94 81.76,98.67 81.66,98.11 81.66,95.58
  BOTTOM w0.135: U1.U31 v4(82.36,95.13)
PE_SLOT4_RX_DN<1>: length 218
  IN3 w0.089: v4(83.36,95.13) 83.36,94.81 83.28,94.73 83.15,94.73 82.96,94.91 82.96,98.65 83.01,98.7 83.01,98.72
  IN3 w0.135: 83.01,98.72 83.01,98.86 83.06,99.14 83.52,99.8 83.8,99.99 83.8,99.99 88.78,103.48 89.18,103.55 89.35,103.42 89.75,103.49 89.88,103.67 90.27,103.74 90.45,103.62 90.85,103.69 90.97,103.87 91.37,103.94 91.55,103.81 91.95,103.88 92.07,104.06 93.9,104.38 100.27,103.26 105.12,104.11 107.73,103.65 111.82,104.37 120.47,102.85 128.54,97.19 173.94,89.19 189.17,91.87 196.24,90.62 199.18,91.14 202.15,90.62 205.13,91.14 208.22,90.6 212.36,91.33 212.37,91.33 214.33,90.99 215.41,91.18 216.45,91.36 218.39,91.01 221.43,91.55 225.69,90.8 231.13,91.76 245.43,89.24 250.01,90.05 264.06,87.57 264.34,87.37 264.39,87.09 263.57,85.91 263.64,85.5 264.04,85.22 264.47,85.3 265.28,86.46 265.48,86.5 265.7,86.35 265.73,86.14 265.35,85.6 265.44,85.11 266.24,84.55 266.61,84.48 266.61,84.48 266.92,84.43 266.92,84.43 267.22,84.37 268.03,84.23 268.16,84.05 268.55,83.98 268.73,84.11 269.13,84.04 269.25,83.86 269.65,83.79 269.83,83.91 270.23,83.84 271.4,83.02 271.43,82.81 271.77,82.58 271.98,82.62 272.31,82.38 272.35,82.17 272.68,81.94 272.89,81.98 273.24,81.74 273.71,81.05 273.71,79.65 arc(273.68,79.57) 273.6,79.54 273.14,79.54 arc(272.81,79.4) 272.67,79.07 272.67,75.19 272.93,74.93 273.14,74.83 273.2,74.65 J4.A22
  BOTTOM w0.135: U1.T31 v4(83.36,95.13)
