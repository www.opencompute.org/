# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT5_TX_DN<13>: length 6.4
  BOTTOM w0.135: C212.2 223.69,104.26 223.69,99.98 223.92,99.75 224.14,99.64 224.2,99.46 J9.B71
PE_SLOT5_TX_DN<14>: length 6.4
  BOTTOM w0.135: J9.B75 220.2,99.46 220.14,99.64 219.92,99.75 219.69,99.98 219.69,104.25 C213.2
PE_SLOT5_TX_DN<15>: length 6.4
  BOTTOM w0.135: J9.B79 216.2,99.46 216.14,99.64 216.12,99.65 215.92,99.75 215.69,99.98 215.69,104.28 C214.2
PE_SLOT5_TX_DP<0>: length 8.9
  BOTTOM w0.135: J9.B14 280.46,99.97 280.28,99.91 280.15,99.97 279.99,100.14 279.99,101.55 279.85,101.81 279.62,102.02 278.2,102.63 278.12,102.83 277.75,102.99 277.55,102.91 277.18,103.07 277.1,103.27 276.73,103.43 276.52,103.35 276.14,103.52 275.69,103.97 275.69,104.27 C183.2
PE_SLOT5_TX_DP<1>: length 7.9
  BOTTOM w0.135: C184.2 272.9,104.27 272.9,103.93 273.86,102.91 275.7,101.9 275.97,101.48 275.97,100.01 275.69,99.72 275.52,99.64 275.46,99.46 J9.B19
PE_SLOT5_TX_DP<2>: length 7.6
  BOTTOM w0.135: C185.2 269.34,104.27 269.34,103.97 270.14,102.87 271.7,102.01 271.96,101.63 271.96,100 271.69,99.72 271.52,99.64 271.46,99.46 J9.B23
PE_SLOT5_TX_DP<3>: length 7.2
  BOTTOM w0.135: J9.B27 267.46,99.46 267.52,99.64 267.69,99.72 268,100.03 268,101.3 267.04,102.5 267.03,102.5 265.79,104.06 265.79,104.27 C186.2
PE_SLOT5_TX_DP<4>: length 6.4
  BOTTOM w0.135: J9.B33 261.46,99.46 261.52,99.64 261.69,99.72 262,100.04 262,104.27 C187.2
PE_SLOT5_TX_DP<5>: length 6.4
  BOTTOM w0.135: C188.2 257.94,104.27 257.94,99.98 257.69,99.72 257.52,99.64 257.46,99.46 J9.B37
PE_SLOT5_TX_DP<6>: length 6.4
  BOTTOM w0.135: J9.B41 253.46,99.46 253.52,99.64 253.73,99.75 253.95,99.96 253.95,104.27 C189.2
PE_SLOT5_TX_DP<7>: length 6.4
  BOTTOM w0.135: C190.2 249.96,104.27 249.96,100 249.69,99.72 249.52,99.64 249.46,99.46 J9.B45
PE_SLOT5_TX_DP<8>: length 6.3
  BOTTOM w0.135: C191.2 243.99,104.27 243.99,103.87 244.15,103.72 244.15,103.31 243.99,103.16 243.99,102.75 244.15,102.6 244.15,102.2 243.99,102.04 243.99,100.11 244.11,100 244.28,99.91 244.46,99.97 J9.B50
PE_SLOT5_TX_DP<9>: length 6.3
  BOTTOM w0.135: J9.B54 240.46,99.97 240.28,99.91 240.11,100 239.99,100.11 239.99,102.08 240.15,102.24 240.15,102.64 239.99,102.79 239.99,103.2 240.15,103.35 240.15,103.75 239.99,103.91 239.99,104.26 C192.2
PE_SLOT5_TX_DP<10>: length 6.3
  BOTTOM w0.135: C193.2 235.99,104.27 235.99,103.87 236.15,103.72 236.15,103.31 235.99,103.16 235.99,102.76 236.15,102.6 236.15,102.2 235.99,102.05 235.99,100.11 236.11,100 236.28,99.91 236.46,99.97 J9.B58
PE_SLOT5_TX_DP<11>: length 6.3
  BOTTOM w0.135: J9.B62 232.46,99.97 232.28,99.91 232.11,100 231.99,100.11 231.99,102.06 232.15,102.21 232.15,102.62 231.99,102.77 231.99,103.17 232.15,103.33 232.15,103.73 231.99,103.88 231.99,104.29 C194.2
PE_SLOT5_TX_DP<12>: length 6.3
  BOTTOM w0.135: J9.B66 228.46,99.97 228.28,99.91 228.11,100 227.99,100.11 227.99,102.05 228.15,102.2 228.15,102.6 227.99,102.76 227.99,103.16 228.15,103.31 228.15,103.72 227.99,103.87 227.99,104.27 C195.2
PE_SLOT5_TX_DP<13>: length 6.3
  BOTTOM w0.135: C196.2 223.99,104.29 223.99,103.88 224.15,103.73 224.15,103.33 223.99,103.17 223.99,102.77 224.15,102.62 224.15,102.21 223.99,102.06 223.99,100.11 224.11,100 224.28,99.91 224.46,99.97 J9.B70
PE_SLOT5_TX_DP<14>: length 6.3
  BOTTOM w0.135: J9.B74 220.46,99.97 220.28,99.91 220.11,100 219.99,100.11 219.99,102.07 220.15,102.23 220.15,102.63 219.99,102.78 219.99,103.19 220.15,103.34 220.15,103.74 219.99,103.9 219.99,104.3 C197.2
PE_SLOT5_TX_DP<15>: length 6.3
  BOTTOM w0.135: J9.B78 216.46,99.97 216.28,99.91 216.1,100 215.99,100.11 215.99,102.04 216.15,102.19 216.15,102.59 215.99,102.75 215.99,103.15 216.15,103.3 216.15,103.71 215.99,103.86 215.99,104.26 C198.2
PE_SLV_RX_C_DN<0>: length 68.2
  TOP w0.089: 64.71,73.54 64.71,73.56 64.77,73.62 64.77,74.04 64.68,74.13 v4(64.36,74.13)
  TOP w0.135: 64.71,73.54 64.71,72.99 64.53,71.97 63.45,70.43 60.86,66.73 59.39,65.7 52.53,60.9 47.71,60.05 39.5,54.3 35.41,48.46 34.66,47.39 34.73,46.95 35.32,46.54 35.35,46.35 35.14,46.04 34.95,46.01 34.36,46.42 33.93,46.35 33.12,45.2 26.25,40.38 25.27,40.21 25.09,40.33 24.7,40.26 24.57,40.09 24.17,40.02 23.99,40.14 23.59,40.07 23.47,39.89 22.91,39.79 21.96,39.12 v3(20.86,38.93) 20.86,38.93 20.03,38.79 19.09,38.95 18.97,39.13 18.57,39.2 18.39,39.07 17.97,39.15 17.84,39.33 17.45,39.4 17.27,39.27 16.84,39.35 15.44,39.35 C35.1
  BOTTOM w0.135: U1.AP11 v4(64.36,74.13)
PE_SLV_RX_C_DN<1>: length 66.7
  TOP w0.089: v4(64.36,75.13) 64.75,75.13 64.8,75.08 64.8,74.88 64.64,74.73 63.66,74.73 63.26,74.32 63.26,73.92 63.2,73.86 63.2,73.84
  TOP w0.135: 63.2,73.84 63.2,73.51 63.02,72.44 62.9,71.81 59.91,67.53 v3(54.84,63.99) 52.26,62.18 47.2,61.28 38.6,55.27 32.12,46 25.99,41.71 25.27,41.58 25.09,41.71 24.69,41.64 24.57,41.46 24.17,41.39 24,41.52 23.6,41.45 23.47,41.27 23.08,41.2 22.9,41.32 22.5,41.25 22.38,41.08 21.97,41 21.1,40.39 19.98,40.19 19.06,40.36 18.15,40.52 17.16,41.21 16.51,41.33 15.49,41.33 C36.1
  BOTTOM w0.135: U1.AP12 v4(64.36,75.13)
PE_SLV_RX_C_DN<2>: length 66
  TOP w0.089: 63.44,75.79 63.46,75.79 63.52,75.73 64.66,75.73 64.8,75.87 64.8,76.07 64.74,76.13 v4(64.36,76.13)
  TOP w0.135: 63.44,75.79 63.13,75.79 62.88,75.61 62.17,74.6 61.98,73.48 61.76,72.28 59.04,68.4 51.86,63.36 v3(49.76,62.99) 48.07,62.7 46.62,62.44 37.88,56.32 31.26,46.87 25.96,43.15 23.88,42.79 20.99,43.3 20.86,43.47 20.46,43.54 20.29,43.42 19.62,43.54 19,43.43 18.82,43.55 18.42,43.48 18.3,43.31 17.31,43.13 15.72,43.41 15.44,43.41 C37.1
  BOTTOM w0.135: U1.AP13 v4(64.36,76.13)
PE_SLV_RX_C_DN<3>: length 65.2
  TOP w0.089: 63.36,76.78 63.38,76.78 63.44,76.72 64.58,76.72 64.73,76.88 64.73,77.08 64.68,77.13 v4(64.36,77.13)
  TOP w0.135: C38.1 15.44,45.44 15.82,45.44 17.36,45.17 17.79,45.25 18.2,45.54 18.43,45.87 18.39,46.08 18.62,46.41 18.84,46.45 19.54,47.45 19.76,48.73 20,49.06 19.96,49.28 20.19,49.61 20.41,49.65 20.65,49.99 20.61,50.2 20.84,50.53 21.05,50.57 21.81,51.64 21.86,51.72 22.81,52.69 23.46,53.27 25.47,54.05 28.29,54.55 31.79,53.93 32.56,54.07 v3(42.29,60.88) 46.14,63.58 51.39,64.5 58.18,69.26 60.63,72.75 60.8,73.72 60.94,74.53 62.27,76.42 62.66,76.7 63.08,76.77 63.08,76.78 63.36,76.78
  BOTTOM w0.135: U1.AP14 v4(64.36,77.13)
PE_SLV_RX_C_DN<4>: length 64.2
  TOP w0.089: 63.4,77.79 63.42,77.79 63.48,77.73 64.7,77.73 64.8,77.83 64.8,78.01 64.68,78.13 v4(64.36,78.13)
  TOP w0.135: 63.4,77.79 62.71,77.79 62.7,77.78 62.23,77.7 61.59,77.25 59.73,74.6 59.58,73.72 59.5,73.28 57.26,70.08 50.92,65.64 40.45,63.79 39.34,63.6 30.05,57.09 29.97,56.66 30.18,56.36 30.15,56.17 29.84,55.96 29.66,55.99 29.45,56.29 29.01,56.37 28.11,55.74 25.17,55.22 25.11,55.21 25.04,55.17 22.83,54.32 20.68,52.4 v3(19.66,50.94) 18.82,49.75 18.61,49.71 18.38,49.38 18.41,49.16 18.18,48.83 17.27,48.19 17.05,48.23 16.72,48 16.68,47.78 16.37,47.57 15.7,47.45 15.47,47.45 C91.1
  BOTTOM w0.135: U1.AP15 v4(64.36,78.13)
PE_SLV_RX_C_DN<5>: length 62.6
  TOP w0.089: 63.44,78.78 63.47,78.78 63.52,78.72 64.58,78.72 64.73,78.88 64.73,79.08 64.68,79.13 v4(64.36,79.13)
  TOP w0.135: C92.1 15.44,49.51 16.07,49.51 16.53,49.59 17.56,50.31 17.81,50.67 17.77,50.88 18.01,51.21 18.22,51.25 18.45,51.58 18.41,51.79 18.64,52.12 18.86,52.16 19.09,52.49 19.05,52.68 19.3,53.04 19.5,53.07 20.41,54.38 20.65,54.61 22.61,55.86 24.82,56.49 27.66,56.99 38.67,64.7 v3(44.38,65.71) 50.45,66.78 56.37,70.93 58.33,73.72 58.37,73.96 58.42,74.25 61.42,78.54 62.78,78.78 62.79,78.78 63.44,78.78
  BOTTOM w0.135: v4(64.36,79.13) U1.AP16
PE_SLV_RX_C_DN<6>: length 63.9
  TOP w0.089: 63.42,79.78 63.44,79.78 63.5,79.72 64.64,79.72 64.8,79.88 64.8,80.06 64.73,80.13 v4(64.36,80.13)
  TOP w0.135: C93.1 15.44,51.54 15.99,51.54 16.64,51.65 17.05,51.94 17.86,53.09 17.82,53.31 18.05,53.64 18.26,53.67 18.5,54.01 18.46,54.22 18.69,54.55 18.9,54.59 19.39,55.28 22.2,57.25 26.52,58.01 27.37,58.61 27.41,58.79 26.95,59.44 27.03,59.88 27.54,60.24 27.98,60.16 28.05,60.06 28.43,59.51 28.62,59.48 37.62,65.78 v3(41.53,66.47) 50.07,67.98 54.9,71.37 60.25,79 61.12,79.61 62.08,79.78 62.08,79.78 63.42,79.78
  BOTTOM w0.135: v4(64.36,80.13) U1.AP17
PE_SLV_RX_C_DN<7>: length 62
  TOP w0.135: C94.1 15.44,53.57 15.92,53.57 16.32,53.64 16.67,53.89 16.89,54.2 16.85,54.41 17.08,54.74 17.29,54.78 17.53,55.11 17.49,55.32 17.72,55.65 17.93,55.69 18.65,56.72 19.42,57.25 19.45,57.47 19.78,57.7 20,57.66 20.33,57.89 20.37,58.11 20.7,58.34 20.91,58.3 24.86,61.06 29.94,61.96 v3(34.49,65.14) 36.98,66.89 49.6,69.12 51.82,70.67 51.82,70.67 52.3,71.01 54.04,72.23 57.27,76.84 57.3,76.89 59.35,79.8 60.83,80.84 62.61,81.15 64.54,81.15 64.71,81.32 64.71,81.78 v4(64.36,82.13)
  BOTTOM w0.135: U1.AP18 v4(64.36,82.13)
PE_SLV_RX_C_DN<8>: length 60.4
  TOP w0.089: 63.66,82.78 63.68,82.78 63.73,82.73 64.58,82.73 64.73,82.88 64.73,83.08 64.68,83.13 v4(64.36,83.13)
  TOP w0.135: 63.66,82.78 62.99,82.78 61.02,82.44 58.44,80.63 56.43,77.76 53.3,73.29 48.91,70.21 36.53,68.03 34.26,67.29 32.57,66.74 30.59,66.1 30.42,66.19 30.18,66.92 29.79,67.12 29.19,66.93 28.99,66.53 29.23,65.8 29.14,65.63 28.22,65.33 27.56,65.21 27.38,65.34 26.98,65.27 26.86,65.09 25.91,64.92 24.45,65.08 23.2,64.85 21.58,65.14 v3(20.89,65.02) 20.21,64.9 19.49,65.03 19.36,65.2 18.97,65.27 18.79,65.15 18.39,65.22 17.24,65.02 16.16,65.21 16.04,65.38 15.64,65.45 15.46,65.33 15.06,65.4 14.93,65.42 14.68,65.42 C95.1
  BOTTOM w0.135: U1.AP19 v4(64.36,83.13)
PE_SLV_RX_C_DN<9>: length 57.8
  TOP w0.089: 63.2,83.78 63.22,83.78 63.28,83.72 64.58,83.72 64.76,83.91 64.76,84.05 64.68,84.13 v4(64.36,84.13)
  TOP w0.135: 63.2,83.78 61.39,83.78 60.81,83.68 57.46,81.33 55.57,78.62 52.45,74.17 49.36,72.01 45.1,70.86 v3(20.23,68.39) 18,68.17 17.83,68.31 17.43,68.27 17.29,68.1 16.89,68.06 16.4,67.71 16,67.64 15.82,67.77 15.42,67.7 15.3,67.52 14.93,67.46 14.68,67.46 C96.1
  BOTTOM w0.135: U1.AP20 v4(64.36,84.13)
PE_SLV_RX_C_DN<10>: length 58.8
  TOP w0.089: v4(64.36,85.13) 64.73,85.13 64.8,85.06 64.8,84.86 64.66,84.72 63.27,84.72 63.22,84.78 63.2,84.78
  TOP w0.135: 63.2,84.78 61.4,84.78 61.4,84.78 60.04,84.54 56.5,82.06 54.7,79.49 51.63,75.1 48.76,73.09 45.41,72.21 v3(25.64,70.24) 23.94,70.08 21.67,69.85 21.5,69.99 21.1,69.95 20.97,69.78 20.56,69.74 20.42,69.86 20.38,70.25 20.04,70.53 19.41,70.47 19.13,70.13 19.17,69.74 19.05,69.59 18.6,69.54 16.94,69.84 16.16,69.7 15.98,69.82 15.59,69.75 15.46,69.58 15.06,69.51 14.96,69.49 14.68,69.49 C97.1
  BOTTOM w0.135: U1.AP21 v4(64.36,85.13)
PE_SLV_RX_C_DN<11>: length 57.6
  TOP w0.089: v4(64.36,86.13) 64.68,86.13 64.73,86.08 64.73,85.88 64.58,85.73 63.25,85.73 63.2,85.79
  TOP w0.135: C98.1 14.68,71.52 15.08,71.52 16.71,71.81 v3(17.4,71.69) 18.4,71.51 19.9,71.77 22.7,71.28 23.6,71.37 23.74,71.53 24.14,71.57 24.31,71.43 24.71,71.47 24.85,71.64 25.25,71.67 25.41,71.54 25.82,71.57 25.95,71.74 26.36,71.78 26.52,71.64 45.18,73.39 48.23,74.2 50.79,75.99 53.84,80.35 55.47,82.67 59.21,85.29 62.01,85.79 63.2,85.79
  BOTTOM w0.135: U1.AP22 v4(64.36,86.13)
PE_SLV_RX_C_DN<12>: length 59.2
  TOP w0.089: v4(64.36,87.13) 64.68,87.13 64.73,87.08 64.73,86.88 64.58,86.72 63.28,86.72 63.22,86.78 63.2,86.78
  TOP w0.135: 63.2,86.78 61.69,86.78 61.69,86.78 58.52,86.22 54.52,83.42 53.42,81.84 49.99,76.95 47.6,75.27 44.88,74.57 30.24,73.26 28.06,73.64 27.93,73.82 27.53,73.89 27.36,73.77 26.96,73.84 26.84,74.01 26.44,74.08 26.26,73.96 25.22,74.14 24.86,73.89 24.76,73.33 24.61,73.22 24.24,73.28 24.13,73.44 24.23,74 23.98,74.36 23.19,74.5 v3(20.16,74.63) 19.86,74.64 18.84,74.69 18.2,74.53 17.49,74.03 16.97,73.9 16.65,73.82 16.47,73.93 16.07,73.83 15.96,73.65 15.57,73.55 14.68,73.55 C99.1
  BOTTOM w0.135: U1.AP23 v4(64.36,87.13)
PE_SLV_RX_C_DN<13>: length 57.3
  TOP w0.089: 63.22,87.78 63.24,87.78 63.3,87.73 64.58,87.73 64.73,87.88 64.73,88.08 64.68,88.13 v4(64.36,88.13)
  TOP w0.135: 63.22,87.78 61.99,87.78 61.98,87.78 57.71,87.02 53.68,84.2 53.42,84 53.35,83.95 49.15,77.85 47.05,76.38 44.33,75.73 31.51,74.62 29.29,75.01 29.17,75.19 28.77,75.26 28.6,75.14 28.2,75.21 28.07,75.38 27.68,75.45 27.5,75.33 25.78,75.63 v3(22.1,75.78) 19.87,75.88 18.86,76.05 18.35,75.96 18.17,76.09 17.77,76.02 17.65,75.84 16.2,75.58 14.68,75.58 C100.1
  BOTTOM w0.135: U1.AP24 v4(64.36,88.13)
PE_SLV_RX_C_DN<14>: length 59.2
  TOP w0.089: 63.96,88.79 63.98,88.79 64.04,88.73 64.67,88.73 64.83,88.88 64.83,89.06 64.75,89.13 v4(64.36,89.13)
  TOP w0.135: 63.96,88.79 61.91,88.79 61.9,88.78 v3(59.67,88.39) 57.98,88.09 56.72,87.87 53.42,85.56 52.59,84.98 48.17,78.66 46.46,77.47 44,76.91 33.58,76.08 24.03,78.14 23.65,77.9 23.54,77.36 23.38,77.26 23.01,77.34 22.91,77.5 23.03,78.04 22.79,78.41 20.35,78.94 19.63,78.81 19.29,78.58 19.08,78.61 18.75,78.38 18.71,78.17 18.05,77.71 16.46,77.43 15.4,77.62 14.68,77.62 C101.1
  BOTTOM w0.135: U1.AP25 v4(64.36,89.13)
PE_SLV_RX_C_DN<15>: length 57.6
  TOP w0.089: 64.04,89.78 64.06,89.78 64.11,89.72 64.63,89.72 64.8,89.89 64.8,90.04 64.71,90.13 v4(64.36,90.13)
  TOP w0.135: C102.1 14.68,79.65 15.07,79.65 15.49,79.72 16.8,80.65 17.46,80.76 18.63,80.52 18.81,80.64 19.2,80.56 19.32,80.38 19.72,80.3 19.9,80.41 20.29,80.33 20.41,80.15 33.67,77.41 43.17,78.13 44.65,78.39 46.03,78.63 47.31,79.53 51.73,85.84 55.86,88.73 56.48,88.84 61.82,89.78 v3(63.6,89.78) 64.04,89.78
  BOTTOM w0.135: U1.AP26 v4(64.36,90.13)
PE_SLV_RX_C_DP<0>: length 68.2
  TOP w0.089: v4(65.36,74.13) 65.05,74.13 64.96,74.04 64.96,73.62 65.02,73.56 65.02,73.54
  TOP w0.135: C23.1 15.44,39.04 16.81,39.04 20.07,38.47 22.05,38.82 23.03,39.51 25.11,39.87 v3(25.95,40.02) 26.37,40.09 32.44,44.35 33.34,44.98 34.11,46.07 34.29,46.1 34.88,45.69 35.31,45.77 35.68,46.28 35.6,46.72 35.01,47.13 34.98,47.31 39.72,54.08 47.82,59.76 52.65,60.61 58.1,64.43 61.08,66.52 63.45,69.9 64.82,71.86 65.02,72.97 65.02,73.54
  BOTTOM w0.135: U1.AN11 v4(65.36,74.13)
PE_SLV_RX_C_DP<1>: length 66.7
  TOP w0.089: 63.51,73.84 63.51,73.86 63.45,73.92 63.45,74.24 63.74,74.54 64.72,74.54 64.99,74.8 64.99,75.07 65.05,75.13 v4(65.36,75.13)
  TOP w0.135: C24.1 15.38,41.02 16.48,41.02 17.04,40.92 18.03,40.23 19.98,39.89 21.22,40.1 22.09,40.71 26.11,41.42 32.34,45.78 38.82,55.05 47.32,61 52.38,61.89 v3(56.35,64.67) 60.13,67.31 63.19,71.69 63.28,72.18 63.33,72.5 63.5,73.46 63.51,73.46 63.51,73.84
  BOTTOM w0.135: U1.AN12 v4(65.36,75.13)
PE_SLV_RX_C_DP<2>: length 66
  TOP w0.089: 63.44,75.48 63.46,75.48 63.52,75.54 64.74,75.54 64.99,75.79 64.99,76.07 65.05,76.13 v4(65.36,76.13)
  TOP w0.135: 63.44,75.48 63.23,75.48 63.09,75.39 62.46,74.49 62.24,73.22 62.05,72.16 59.26,68.18 51.98,63.08 v3(48.17,62.41) 46.73,62.15 38.1,56.1 31.47,46.65 26.07,42.87 23.88,42.48 19.62,43.23 18.93,43.11 17.31,42.82 15.7,43.11 15.44,43.11 C25.1
  BOTTOM w0.135: U1.AN13 v4(65.36,76.13)
PE_SLV_RX_C_DP<3>: length 65.2
  TOP w0.089: 63.36,76.47 63.38,76.47 63.44,76.53 64.65,76.53 64.92,76.8 64.92,77.06 64.99,77.13 v4(65.36,77.13)
  TOP w0.135: C26.1 15.44,45.14 15.79,45.14 16.54,45.01 17.36,44.86 17.91,44.96 18.42,45.32 19.83,47.33 20.05,48.61 20.66,49.47 22.06,51.47 22.1,51.53 23.02,52.47 23.63,53.01 25.56,53.76 28.29,54.24 31.79,53.62 32.68,53.78 39.53,58.57 v3(41.01,59.61) 46.26,63.29 51.51,64.21 58.4,69.04 60.92,72.63 61.11,73.72 61.23,74.41 62.49,76.21 62.78,76.41 63.13,76.47 63.36,76.47
  BOTTOM w0.135: U1.AN14 v4(65.36,77.13)
PE_SLV_RX_C_DP<4>: length 64.2
  TOP w0.089: 63.4,77.48 63.42,77.48 63.48,77.54 64.78,77.54 64.99,77.75 64.99,78.04 65.08,78.13 v4(65.36,78.13)
  TOP w0.135: 63.4,77.48 62.75,77.48 62.35,77.41 61.81,77.03 60.02,74.48 59.89,73.72 59.79,73.16 57.48,69.86 51.04,65.35 39.46,63.31 38.82,62.87 30.33,56.92 30.3,56.73 30.5,56.43 30.43,56 29.91,55.64 29.48,55.71 29.27,56.01 29.08,56.04 28.23,55.45 25.23,54.92 22.99,54.05 v3(21.75,52.95) 20.91,52.2 18.4,48.61 16.49,47.28 15.73,47.14 15.41,47.14 C79.1
  BOTTOM w0.135: U1.AN15 v4(65.36,78.13)
PE_SLV_RX_C_DP<5>: length 62.6
  TOP w0.089: v4(65.36,79.13) 64.98,79.13 64.92,79.07 64.92,78.8 64.66,78.53 63.52,78.53 63.47,78.48 63.44,78.48
  TOP w0.135: 63.44,78.48 62.83,78.48 61.6,78.26 58.71,74.13 58.7,74.03 58.67,73.9 58.64,73.72 58.62,73.6 56.59,70.71 50.57,66.49 v3(42.87,65.13) 38.79,64.41 33.34,60.6 27.78,56.7 24.88,56.19 22.74,55.58 20.84,54.37 20.64,54.18 19.41,52.42 19.22,52.15 19.22,52.15 17.78,50.09 16.65,49.3 16.1,49.2 15.44,49.2 C80.1
  BOTTOM w0.135: v4(65.36,79.13) U1.AN16
PE_SLV_RX_C_DP<6>: length 63.9
  TOP w0.089: 63.42,79.48 63.44,79.48 63.5,79.53 64.72,79.53 64.99,79.8 64.99,80.07 65.05,80.13 v4(65.36,80.13)
  TOP w0.135: C81.1 15.43,51.23 16.02,51.23 16.76,51.36 17.27,51.72 19.08,54.31 19.61,55.06 22.32,56.96 26.64,57.72 27.65,58.43 27.73,58.86 27.27,59.51 27.31,59.7 27.61,59.92 27.8,59.88 28.26,59.23 28.69,59.16 37.74,65.49 v3(40.07,65.9) 50.19,67.69 55.12,71.15 60.47,78.78 61.24,79.32 62.13,79.48 63.42,79.48
  BOTTOM w0.135: U1.AN17 v4(65.36,80.13)
PE_SLV_RX_C_DP<7>: length 62
  TOP w0.135: C82.1 15.44,53.27 15.94,53.27 16.44,53.35 16.89,53.67 18.87,56.5 24.98,60.78 30.06,61.67 v3(33.26,63.91) 37.1,66.6 49.72,68.83 51.99,70.42 54.26,72.01 57.52,76.67 57.54,76.7 59.57,79.58 60.95,80.55 62.64,80.85 64.67,80.85 65.02,81.19 65.02,81.78 v4(65.36,82.13)
  BOTTOM w0.135: U1.AN18 v4(65.36,82.13)
PE_SLV_RX_C_DP<8>: length 60.4
  TOP w0.089: v4(65.36,83.13) 65,83.13 64.92,83.06 64.92,82.8 64.66,82.54 63.73,82.54 63.68,82.48 63.66,82.48
  TOP w0.135: 63.66,82.48 63.01,82.48 61.14,82.15 58.66,80.41 56.65,77.54 53.52,73.07 49.03,69.93 36.6,67.73 34.35,67 32.66,66.45 30.56,65.77 30.17,65.97 29.93,66.71 29.76,66.79 29.41,66.68 29.32,66.51 29.56,65.77 29.36,65.38 28.29,65.03 25.92,64.61 24.46,64.77 23.2,64.55 v3(22.63,64.65) 21.58,64.83 20.21,64.59 18.39,64.91 17.24,64.71 14.91,65.12 14.91,65.12 14.68,65.12 C83.1
  BOTTOM w0.135: U1.AN19 v4(65.36,83.13)
PE_SLV_RX_C_DP<9>: length 57.9
  TOP w0.089: v4(65.36,84.13) 65.01,84.13 64.95,84.07 64.95,83.83 64.66,83.53 63.28,83.53 63.22,83.48 63.2,83.48
  TOP w0.135: C84.1 14.68,67.15 14.96,67.15 16.52,67.42 17,67.76 v3(22.13,68.27) 45.15,70.56 49.49,71.73 52.67,73.95 55.79,78.4 57.68,81.11 60.93,83.39 61.42,83.48 63.2,83.48
  BOTTOM w0.135: U1.AN20 v4(65.36,84.13)
PE_SLV_RX_C_DP<10>: length 58.8
  TOP w0.089: 63.2,84.48 63.22,84.48 63.27,84.53 64.74,84.53 64.99,84.78 64.99,85.07 65.05,85.13 v4(65.36,85.13)
  TOP w0.135: 63.2,84.48 61.45,84.48 60.16,84.25 56.72,81.84 54.92,79.27 51.85,74.88 48.89,72.81 45.46,71.91 v3(28.11,70.18) 27.47,70.12 24.27,69.8 23.97,69.77 20.47,69.42 20.13,69.71 20.09,70.09 19.94,70.21 19.57,70.18 19.45,70.03 19.49,69.64 19.21,69.3 18.59,69.24 16.94,69.53 16.09,69.38 14.99,69.18 14.68,69.18 C85.1
  BOTTOM w0.135: U1.AN21 v4(65.36,85.13)
PE_SLV_RX_C_DP<11>: length 57.5
  TOP w0.089: 63.2,85.48 63.21,85.48 63.27,85.54 64.66,85.54 64.92,85.8 64.92,86.06 65,86.13 v4(65.36,86.13)
  TOP w0.135: 63.2,85.48 62.03,85.48 59.33,85.01 55.69,82.45 54.06,80.13 51.01,75.77 49.68,74.84 49.04,74.4 48.36,73.92 45.23,73.09 22.68,70.97 19.9,71.47 v3(19.17,71.34) 18.4,71.2 16.71,71.5 15.1,71.21 14.68,71.21 C86.1
  BOTTOM w0.135: U1.AN22 v4(65.36,86.13)
PE_SLV_RX_C_DP<12>: length 59.2
  TOP w0.089: v4(65.36,87.13) 64.98,87.13 64.92,87.07 64.92,86.8 64.66,86.53 63.28,86.53 63.22,86.48 63.2,86.48
  TOP w0.135: C87.1 14.68,73.25 15.61,73.25 v3(16.59,73.49) 17.12,73.62 17.61,73.75 18.33,74.25 18.87,74.38 23.16,74.2 23.8,74.09 23.91,73.93 23.81,73.37 24.06,73 24.68,72.89 25.04,73.15 25.14,73.71 25.3,73.82 30.22,72.95 44.93,74.27 47.73,74.99 50.21,76.73 53.42,81.31 54.74,83.2 58.64,85.93 61.74,86.48 63.2,86.48
  BOTTOM w0.135: U1.AN23 v4(65.36,87.13)
PE_SLV_RX_C_DP<13>: length 57.3
  TOP w0.089: v4(65.36,88.13) 64.99,88.13 64.92,88.06 64.92,87.8 64.66,87.54 63.3,87.54 63.24,87.48 63.22,87.48
  TOP w0.135: C88.1 14.68,75.28 16.23,75.28 v3(17.06,75.43) 18.86,75.74 19.83,75.57 25.75,75.33 29.96,74.59 31.5,74.32 44.37,75.43 47.18,76.09 49.37,77.63 53.42,83.51 53.57,83.74 53.86,83.95 57.83,86.73 62.04,87.48 63.22,87.48
  BOTTOM w0.135: U1.AN24 v4(65.36,88.13)
PE_SLV_RX_C_DP<14>: length 59.2
  TOP w0.089: v4(65.36,89.13) 65.09,89.13 65.02,89.05 65.02,88.8 64.75,88.54 64.04,88.54 63.98,88.48 63.96,88.48
  TOP w0.135: 63.96,88.48 61.96,88.48 59.72,88.09 v3(58.04,87.79) 56.84,87.58 53.42,85.18 52.81,84.76 48.39,78.45 46.59,77.19 44.05,76.6 33.56,75.77 24.09,77.82 23.93,77.71 23.81,77.18 23.44,76.94 22.82,77.07 22.58,77.44 22.7,77.98 22.6,78.14 20.35,78.63 19.75,78.52 18.17,77.42 16.46,77.12 15.37,77.31 14.68,77.31 C89.1
  BOTTOM w0.135: U1.AN25 v4(65.36,89.13)
PE_SLV_RX_C_DP<15>: length 57.6
  TOP w0.089: 64.04,89.48 64.06,89.48 64.11,89.53 64.71,89.53 64.99,89.81 64.99,90.06 65.06,90.13 v4(65.36,90.13)
  TOP w0.135: C90.1 14.68,79.34 15.09,79.34 15.61,79.43 16.92,80.36 17.45,80.45 33.65,77.11 43.21,77.83 44.96,78.14 46.15,78.35 47.53,79.31 51.95,85.62 55.98,88.44 56.11,88.46 57.13,88.65 61.85,89.48 v3(62.21,89.48) 64.04,89.48
  BOTTOM w0.135: U1.AN26 v4(65.36,90.13)
PE_SLV_RX_DN<0>: length 6
  TOP w0.135: v1(10.82,39.55) 11.03,39.34 v3(11.78,39.34) 13.92,39.34 C35.2
  BOTTOM w0.135: J7.3 12.3,39.48 12.15,39.33 11.05,39.33 v1(10.82,39.55)
PE_SLV_RX_DN<1>: length 9.2
  TOP w0.135: C36.2 13.93,41.38 13.28,41.38 v3(12.77,41.34) 10.31,41.13 9.43,41.13 v1(9.2,41.36)
  BOTTOM w0.135: J7.6 12.29,41.27 12.14,41.13 9.42,41.13 v1(9.2,41.36)
PE_SLV_RX_DN<2>: length 6
  TOP w0.135: v1(10.85,43.16) 11.08,42.93 v3(11.48,42.93) 11.92,42.93 13.29,43.41 13.93,43.41 C37.2
  BOTTOM w0.135: J7.9 12.29,43.08 12.14,42.93 11.08,42.93 v1(10.85,43.16)
PE_SLV_RX_DN<3>: length 9.3
  TOP w0.135: C38.2 13.93,45.44 13.29,45.44 11.24,44.73 v3(10.26,44.73) 9.45,44.73 v1(9.22,44.96)
  BOTTOM w0.135: v1(9.22,44.96) 9.46,44.73 12.16,44.73 12.31,44.87 J7.12
PE_SLV_RX_DN<4>: length 6.1
  TOP w0.135: v1(10.9,46.74) 11.16,46.48 11.53,46.48 v3(11.76,46.6) 11.76,46.61 13.38,47.47 13.92,47.47 C91.2
  BOTTOM w0.135: J7.15 12.31,46.68 12.16,46.53 11.11,46.53 v1(10.9,46.74)
PE_SLV_RX_DN<5>: length 9.6
  TOP w0.135: C92.2 13.95,49.53 13.59,49.53 13.12,49.45 v3(12.55,49.02) 12.05,48.63 11.23,48.34 9.43,48.34 v1(9.2,48.57)
  BOTTOM w0.135: J7.18 12.28,48.48 12.13,48.33 9.44,48.33 v1(9.2,48.57)
PE_SLV_RX_DN<6>: length 6.3
  TOP w0.135: C93.2 13.9,51.51 13.36,51.51 13.01,51.36 11.92,50.37 11.48,50.12 11.15,50.12 v1(10.92,50.35)
  BOTTOM w0.135: v1(10.92,50.35) 11.14,50.13 12.15,50.13 12.3,50.27 J7.21
PE_SLV_RX_DN<7>: length 9.8
  TOP w0.135: v1(9.2,52.18) 9.43,51.95 11.16,51.95 11.96,52.28 12.86,53.17 13.52,53.59 13.95,53.59 C94.2
  BOTTOM w0.135: J7.24 12.32,52.08 12.17,51.93 9.44,51.93 v1(9.2,52.18)
PE_SLV_RX_DN<8>: length 5.4
  TOP w0.135: C95.2 13.17,65.42 12.97,65.42 11.94,66.39 11.37,66.58 11.15,66.58 v1(10.92,66.81)
  BOTTOM w0.135: v1(10.92,66.81) 11.15,66.58 12.09,66.58 12.24,66.73 J8.3
PE_SLV_RX_DN<9>: length 8.6
  TOP w0.135: v1(9.22,68.61) 9.45,68.38 10.43,68.38 12.05,68.04 v3(12.46,67.75) 12.88,67.46 12.89,67.46 13.17,67.46 C96.2
  BOTTOM w0.135: J8.6 12.26,68.53 12.11,68.38 9.45,68.38 v1(9.22,68.61)
PE_SLV_RX_DN<10>: length 5.2
  TOP w0.135: C97.2 13.17,69.49 12.97,69.49 11.46,70.19 11.15,70.19 v1(10.92,70.41)
  BOTTOM w0.135: v1(10.92,70.41) 11.16,70.18 12.14,70.18 12.28,70.33 J8.9
PE_SLV_RX_DN<11>: length 8.5
  TOP w0.135: v1(9.2,72.22) 9.43,71.99 10.21,71.99 v3(12.37,71.62) 12.88,71.53 12.93,71.52 13.17,71.52 C98.2
  BOTTOM w0.135: J8.12 12.3,72.13 12.15,71.98 9.44,71.98 v1(9.2,72.22)
PE_SLV_RX_DN<12>: length 5
  TOP w0.135: v1(10.92,74) 11.15,73.77 11.37,73.77 12.87,73.55 13.17,73.55 C99.2
  BOTTOM w0.135: J8.15 12.3,73.93 12.15,73.78 11.14,73.78 v1(10.92,74)
PE_SLV_RX_DN<13>: length 8.5
  TOP w0.135: C100.2 13.18,75.6 v3(12.05,75.6) 9.4,75.6 v1(9.17,75.82)
  BOTTOM w0.135: v1(9.17,75.82) 9.42,75.58 12.15,75.58 12.3,75.73 J8.18
PE_SLV_RX_DN<14>: length 5
  TOP w0.135: v1(10.92,77.6) 11.15,77.37 11.37,77.37 12.92,77.62 13.17,77.62 C101.2
  BOTTOM w0.135: v1(10.92,77.6) 11.15,77.38 12.15,77.38 12.29,77.53 J8.21
PE_SLV_RX_DN<15>: length 8.6
  TOP w0.135: v1(9.17,79.41) 9.4,79.18 9.99,79.18 13.02,79.65 13.17,79.65 C102.2
  BOTTOM w0.135: v1(9.17,79.41) 9.4,79.18 12.14,79.18 12.29,79.33 J8.24
PE_SLV_RX_DP<0>: length 6
  TOP w0.135: v1(10.82,38.79) 11.07,39.04 v3(13.25,39.04) 13.93,39.04 C23.2
  BOTTOM w0.135: J7.2 12.31,38.87 12.16,39.02 11.06,39.02 v1(10.82,38.79)
PE_SLV_RX_DP<1>: length 9.2
  TOP w0.135: C24.2 13.93,41.08 13.29,41.08 12.8,41.03 10.32,40.82 v3(10.18,40.82) 9.43,40.82 v1(9.2,40.59)
  BOTTOM w0.135: v1(9.2,40.59) 9.43,40.82 12.17,40.82 12.31,40.68 J7.5
PE_SLV_RX_DP<2>: length 6
  TOP w0.135: C25.2 13.93,43.11 13.35,43.11 v3(12.89,42.95) 11.97,42.63 11.08,42.63 v1(10.85,42.4)
  BOTTOM w0.135: v1(10.85,42.4) 11.07,42.62 12.17,42.62 12.32,42.48 J7.8
PE_SLV_RX_DP<3>: length 9.3
  TOP w0.135: C26.2 13.93,45.14 13.35,45.14 v3(12.91,44.99) 11.29,44.43 9.45,44.43 v1(9.22,44.2)
  BOTTOM w0.135: v1(9.22,44.2) 9.44,44.42 12.17,44.42 12.32,44.27 J7.11
PE_SLV_RX_DP<4>: length 6.1
  TOP w0.135: C79.2 13.93,47.17 13.46,47.17 v3(13.17,47.02) 11.9,46.34 11.9,46.33 11.61,46.18 11.1,46.18 v1(10.9,45.98)
  BOTTOM w0.135: J7.14 12.32,46.08 12.18,46.22 11.14,46.22 v1(10.9,45.98)
PE_SLV_RX_DP<5>: length 9.6
  TOP w0.135: v1(9.2,47.81) 9.42,48.03 v3(10.07,48.03) 11.28,48.03 12.19,48.36 13.25,49.16 13.62,49.23 13.91,49.23 C80.2
  BOTTOM w0.135: J7.17 12.3,47.87 12.16,48.02 9.41,48.02 v1(9.2,47.81)
PE_SLV_RX_DP<6>: length 6.3
  TOP w0.135: C81.2 13.96,51.21 13.43,51.21 13.18,51.1 12.64,50.61 12.64,50.61 12.1,50.12 11.9,50 11.56,49.81 11.15,49.81 v1(10.92,49.58)
  BOTTOM w0.135: v1(10.92,49.58) 11.16,49.82 12.18,49.82 12.33,49.68 J7.20
PE_SLV_RX_DP<7>: length 9.8
  TOP w0.135: C82.2 13.91,53.29 13.61,53.29 13.05,52.93 12.17,52.07 12.17,52.06 12.13,52.02 11.22,51.64 9.43,51.64 v1(9.2,51.41)
  BOTTOM w0.135: J7.23 12.34,51.48 12.19,51.62 9.41,51.62 v1(9.2,51.41)
PE_SLV_RX_DP<8>: length 5.4
  TOP w0.135: v1(10.92,66.04) 11.15,66.27 11.32,66.27 11.78,66.12 12.85,65.12 13.17,65.12 C83.2
  BOTTOM w0.135: v1(10.92,66.04) 11.15,66.27 12.1,66.27 12.25,66.13 J8.2
PE_SLV_RX_DP<9>: length 8.6
  TOP w0.135: C84.2 13.17,67.15 12.79,67.15 12.71,67.21 11.92,67.76 v3(11.02,67.95) 10.4,68.08 9.45,68.08 v1(9.22,67.85)
  BOTTOM w0.135: J8.5 12.24,67.93 12.1,68.07 9.45,68.07 v1(9.22,67.85)
PE_SLV_RX_DP<10>: length 5.2
  TOP w0.135: v1(10.92,69.65) 11.15,69.88 11.4,69.88 12.9,69.18 13.17,69.18 C85.2
  BOTTOM w0.135: v1(10.92,69.65) 11.15,69.87 12.15,69.87 12.3,69.73 J8.8
PE_SLV_RX_DP<11>: length 8.5
  TOP w0.135: v1(9.2,71.46) 9.43,71.68 10.18,71.68 v3(10.66,71.6) 12.88,71.22 12.9,71.21 13.17,71.21 C86.2
  BOTTOM w0.135: v1(9.2,71.46) 9.41,71.67 12.18,71.67 12.33,71.53 J8.11
PE_SLV_RX_DP<12>: length 5
  TOP w0.135: v1(10.92,73.23) 11.15,73.46 11.35,73.46 12.85,73.25 13.17,73.25 C87.2
  BOTTOM w0.135: J8.14 12.3,73.33 12.16,73.47 11.16,73.47 v1(10.92,73.23)
PE_SLV_RX_DP<13>: length 8.5
  TOP w0.135: v1(9.17,75.06) 9.4,75.29 v3(10.14,75.29) 13.15,75.29 C88.2
  BOTTOM w0.135: v1(9.17,75.06) 9.38,75.27 12.16,75.27 12.31,75.13 J8.17
PE_SLV_RX_DP<14>: length 5
  TOP w0.135: C89.2 13.17,77.31 12.94,77.31 11.39,77.07 11.15,77.07 v1(10.92,76.84)
  BOTTOM w0.135: v1(10.92,76.84) 11.16,77.07 12.16,77.07 12.31,76.93 J8.20
PE_SLV_RX_DP<15>: length 8.6
  TOP w0.135: C90.2 13.17,79.34 13.05,79.34 10.02,78.87 9.4,78.87 v1(9.17,78.64)
  BOTTOM w0.135: J8.23 12.29,78.73 12.14,78.87 9.4,78.87 v1(9.17,78.64)
PE_SLV_TX_DN<0>: length 69.4
  IN1 w0.089: 63.81,73.76 63.83,73.76 63.88,73.71 67.56,73.71 67.72,73.86 67.72,74.04 67.63,74.13 v4(67.36,74.13)
  IN1 w0.122: 63.81,73.76 63.15,73.76 62.79,73.7 62.4,73.43 57.89,66.98 41.02,55.17 35.72,47.6 26.56,41.19 26.04,40.44 25.23,39.87 24.42,39.3 24.2,39.34 23.9,39.13 23.87,38.92 23.55,38.7 23.34,38.73 23.04,38.52 23,38.31 22.56,38 22.35,38.04 22.05,37.83 22.01,37.62 21.1,36.98 20.63,36.98 v1(20.4,37.21)
  BOTTOM w0.135: U1.AL11 v4(67.36,74.13) ; J7.48 16.51,39.48 16.66,39.33 17.05,39.33 17.68,38.95 18.91,37.41 18.94,37.38 19.47,36.99 19.56,36.96 20.14,36.96 v1(20.4,37.21)
PE_SLV_TX_DN<1>: length 67
  IN1 w0.089: 63.77,74.79 63.79,74.79 63.84,74.73 67.59,74.73 67.74,74.89 67.74,75.04 67.65,75.13 v4(67.36,75.13)
  IN1 w0.122: v1(21.03,42.14) 21.27,41.9 22.19,41.9 22.9,42.03 23.02,42.21 23.38,42.27 23.56,42.14 23.92,42.21 24.04,42.39 24.4,42.45 24.58,42.32 24.94,42.39 25.06,42.57 25.42,42.63 25.6,42.51 27.43,42.83 35.24,48.29 40.45,55.74 57.23,67.49 61.95,74.23 62.59,74.68 63.14,74.78 63.17,74.79 63.77,74.79
  BOTTOM w0.135: v1(21.03,42.14) 20.83,41.94 20.44,41.94 20.02,41.8 17.37,41.32 16.94,41.13 16.69,41.13 16.54,41.27 J7.45 ; U1.AL12 v4(67.36,75.13)
PE_SLV_TX_DN<2>: length 66.7
  IN1 w0.089: 63.73,75.78 63.75,75.78 63.8,75.73 67.58,75.73 67.73,75.88 67.73,76.01 67.61,76.13 v4(67.36,76.13)
  IN1 w0.122: 63.73,75.78 63.09,75.78 62.63,75.7 61.41,74.85 56.66,68.06 39.88,56.32 35.69,50.34 34.01,49.16 33.79,49.19 33.49,48.98 33.46,48.77 33.16,48.56 32.13,47.09 28.88,44.82 28.35,44.72 28.17,44.85 27.81,44.78 27.68,44.61 27.21,44.52 27.03,44.65 26.67,44.58 26.55,44.41 26.18,44.34 24.7,44.34 v1(24.46,44.58)
  BOTTOM w0.135: v1(24.46,44.58) 24.23,44.35 23.49,44.35 v3(22.39,44.12) 20.09,43.64 19.47,43.5 17.02,42.93 16.64,42.93 16.49,43.08 J7.42 ; U1.AL13 v4(67.36,76.13)
PE_SLV_TX_DN<3>: length 68.9
  IN1 w0.089: 63.9,76.79 63.92,76.79 63.98,76.74 67.59,76.74 67.74,76.89 67.74,77.04 67.65,77.13 v4(67.36,77.13)
  IN1 w0.122: 63.9,76.79 63.16,76.79 62.67,76.7 60.82,75.41 56.08,68.64 36.27,54.77 31.94,54.01 28.18,54.67 25.59,54.21 23.83,52.98 23.25,52.16 23.04,52.12 22.83,51.82 22.87,51.61 22.66,51.31 22.39,49.78 22.47,49.29 22.35,49.11 22.41,48.75 22.59,48.63 22.65,48.27 22.53,48.09 22.59,47.73 22.77,47.6 22.84,47.24 22.74,46.68 22.46,46.29 22.25,46.14 21.85,46.07 21.62,46.07 v1(21.39,46.3)
  BOTTOM w0.135: U1.AL14 v4(67.36,77.13) ; J7.39 16.52,44.87 16.67,44.73 16.94,44.73 17.87,45.18 20.11,45.77 v3(20.59,46.02) 20.75,46.1 21.19,46.1 v1(21.39,46.3)
PE_SLV_TX_DN<4>: length 65.6
  IN1 w0.089: v4(67.36,78.13) 67.64,78.13 67.73,78.04 67.73,77.9 67.56,77.73 63.9,77.73 63.85,77.78 63.83,77.78
  IN1 w0.122: 63.83,77.78 63.11,77.78 63,77.76 62.68,77.71 60.19,75.96 55.42,69.15 38.06,57 37.85,57.03 37.55,56.82 37.51,56.61 37.02,56.26 35.8,56.05 35.62,56.17 35.26,56.11 35.14,55.93 34.78,55.87 34.6,55.99 34.24,55.93 34.12,55.75 33.47,55.64 32.96,55.64 v1(32.72,55.88)
  BOTTOM w0.135: v1(32.72,55.88) 32.49,55.65 30.28,55.65 25.48,54.8 24.37,54.03 v3(20.41,49.51) 20.1,49.15 19.37,48.42 19.37,48.42 19.29,48.34 18.31,47.22 17.41,46.59 17.08,46.53 16.67,46.53 16.53,46.68 J7.36 ; U1.AL15 v4(67.36,78.13)
PE_SLV_TX_DN<5>: length 65.3
  IN1 w0.089: v4(67.36,79.13) 67.63,79.13 67.74,79.02 67.74,78.88 67.59,78.73 63.75,78.73 63.7,78.78 63.68,78.78
  IN1 w0.122: v1(34.75,57.78) 34.98,57.55 35.65,57.55 36.19,57.65 36.31,57.82 36.67,57.89 36.85,57.76 38.08,57.98 38.54,58.3 38.58,58.52 38.88,58.73 39.09,58.69 39.39,58.9 39.43,59.11 39.73,59.32 39.94,59.28 54.74,69.64 59.52,76.47 62.72,78.71 63.11,78.78 63.68,78.78
  BOTTOM w0.135: v1(34.75,57.78) 34.52,57.56 v3(34,57.56) 32.61,57.56 31.77,57.41 25.4,56.29 23.42,54.9 17.71,48.38 17.32,48.35 16.95,48.35 16.92,48.33 16.65,48.33 16.5,48.48 J7.33 ; v4(67.36,79.13) U1.AL16
PE_SLV_TX_DN<6>: length 64.7
  IN1 w0.089: v4(67.36,80.13) 67.62,80.13 67.74,80.01 67.74,79.89 67.58,79.73 63.91,79.73 63.86,79.78 63.84,79.78
  IN1 w0.122: 63.84,79.78 63.14,79.78 62.73,79.71 58.97,77.08 54.42,70.58 40.82,61.05 40.6,61.09 40.3,60.88 40.27,60.67 39.97,60.46 39.75,60.49 39.45,60.28 39.42,60.07 38.99,59.77 38.21,59.63 38.03,59.76 37.67,59.7 37.55,59.52 37.19,59.46 36.89,59.46 v1(36.65,59.69)
  BOTTOM w0.135: v1(36.65,59.69) 36.43,59.46 v3(35.58,59.46) 32.52,59.46 24.91,57.49 22.78,56 17.56,50.33 17.37,50.2 17.31,50.2 17.3,50.19 16.94,50.13 16.65,50.13 16.51,50.27 J7.30 ; v4(67.36,80.13) U1.AL17
PE_SLV_TX_DN<7>: length 64.6
  IN1 w0.089: 67.11,81.58 67.13,81.58 67.18,81.53 67.5,81.53 67.73,81.77 67.73,82 67.6,82.13 v4(67.36,82.13)
  IN1 w0.122: 67.11,81.58 66.69,81.58 63.2,80.97 63.19,80.97 63.13,80.96 63.12,80.95 58.38,77.63 54.08,71.5 40.1,61.71 31.86,60.26 31.69,60.38 31.33,60.32 31.2,60.14 30.74,60.06 30.56,60.18 30.2,60.12 30.08,59.94 29.57,59.85 29.4,59.98 29.04,59.91 28.91,59.74 27.28,59.45 26.38,59.45 v1(26.14,59.69)
  BOTTOM w0.135: v1(26.14,59.69) 25.91,59.46 25.2,59.46 21.57,56.92 v3(20.3,55.5) 17.17,51.97 16.92,51.93 16.68,51.93 16.54,52.08 J7.27 ; U1.AL18 v4(67.36,82.13)
PE_SLV_TX_DN<8>: length 60.4
  IN1 w0.089: 63.86,82.78 63.88,82.78 63.93,82.72 67.64,82.72 67.83,82.91 67.83,83.02 67.72,83.13 v4(67.36,83.13)
  IN1 w0.122: v1(18.04,66.82) 18.27,66.59 18.54,66.59 18.75,66.55 19.06,66.34 19.27,66.04 19.48,66 19.69,65.7 19.65,65.49 19.86,65.18 19.95,65.13 21.4,64.11 25.86,63.32 27.97,63.69 32.8,67.08 36.88,69.93 40.7,70.89 47.28,72.05 62.48,82.68 63.05,82.78 63.86,82.78
  BOTTOM w0.135: U1.AL19 v4(67.36,83.13) ; v1(18.04,66.82) 17.79,66.58 16.69,66.58 16.54,66.73 J8.48
PE_SLV_TX_DN<9>: length 61.1
  IN1 w0.089: 63.77,83.78 63.79,83.78 63.84,83.72 67.58,83.72 67.77,83.92 67.77,84.04 67.68,84.13 v4(67.36,84.13)
  IN1 w0.122: 63.77,83.78 63.07,83.78 62.47,83.67 47,72.84 36.98,71.07 27.48,64.41 27.01,64.33 27,64.33 25.96,64.15 25.06,64.31 24.97,64.44 24.46,64.53 24.32,64.44 23.91,64.51 23.81,64.65 23.55,64.7 23.41,64.6 23.19,64.63 22.49,65.13 22.21,65.52 22.12,66.07 21.93,66.34 21.66,66.53 21.39,66.58 21.17,66.58 v1(20.93,66.81)
  BOTTOM w0.135: v1(20.93,66.81) 20.7,66.59 20.14,66.59 19.47,67.05 19.12,67.55 18.25,68.16 17.02,68.38 16.69,68.38 16.55,68.53 J8.45 ; U1.AL20 v4(67.36,84.13)
PE_SLV_TX_DN<10>: length 61.5
  IN1 w0.089: 63.72,84.78 63.75,84.78 63.8,84.73 67.58,84.73 67.77,84.92 67.77,85.04 67.68,85.13 v4(67.36,85.13)
  IN1 w0.122: v1(23.73,66.81) 23.96,66.58 24.18,66.58 24.44,66.53 24.82,66.27 25.06,65.93 25.13,65.53 25.29,65.3 25.53,65.13 25.76,65.09 27.14,65.33 27.83,65.81 27.86,65.99 28.21,66.24 28.39,66.2 28.74,66.45 28.77,66.63 29.12,66.87 29.3,66.84 36.33,71.76 46.61,73.58 62.47,84.67 63.07,84.78 63.72,84.78
  BOTTOM w0.135: U1.AL21 v4(67.36,85.13) ; v1(23.73,66.81) 23.48,66.57 22.79,66.57 22.38,66.85 21.76,67.75 20.7,68.49 v3(19.22,69.52) 18.73,69.87 17,70.17 16.99,70.18 16.67,70.18 16.52,70.33 J8.42
PE_SLV_TX_DN<11>: length 61.1
  IN1 w0.089: 63.88,85.78 63.9,85.78 63.95,85.73 67.58,85.73 67.77,85.92 67.77,86.04 67.68,86.13 v4(67.36,86.13)
  IN1 w0.122: v1(26.52,66.81) 26.76,66.58 27.01,66.58 27.37,66.64 27.74,66.9 27.77,67.08 28.12,67.33 28.3,67.29 28.65,67.54 28.68,67.72 29.03,67.96 29.21,67.93 35.73,72.49 46.35,74.37 62.51,85.68 63.05,85.78 63.88,85.78
  BOTTOM w0.135: v1(26.52,66.81) 26.27,66.57 25.94,66.57 25.62,66.62 25.07,67.01 24.32,68.08 v3(20.53,70.73) 20.04,71.08 18.49,71.35 17.73,71.89 17.21,71.98 16.71,71.98 16.56,72.13 J8.39 ; U1.AL22 v4(67.36,86.13)
PE_SLV_TX_DN<12>: length 58.7
  IN1 w0.089: v4(67.36,87.13) 67.68,87.13 67.77,87.04 67.77,86.92 67.58,86.73 63.91,86.73 63.86,86.78 63.84,86.78
  IN1 w0.122: 63.84,86.78 63.03,86.78 62.26,86.64 46.07,75.31 25.03,71.6 24.86,71.72 24.5,71.66 24.37,71.48 23.83,71.39 23.47,71.41 23.33,71.57 22.96,71.59 22.8,71.45 21.85,71.51 21.4,71.59 21.07,71.82 20.84,72.14 20.73,72.76 20.33,73.15 19.88,73.15 v1(19.64,73.4)
  BOTTOM w0.135: v1(19.64,73.4) 19.41,73.17 19.08,73.17 17.12,73.78 16.7,73.78 16.56,73.93 J8.36 ; U1.AL23 v4(67.36,87.13)
PE_SLV_TX_DN<13>: length 58.6
  IN1 w0.089: 63.67,87.78 63.69,87.78 63.74,87.73 67.59,87.73 67.77,87.92 67.77,88.04 67.68,88.13 v4(67.36,88.13)
  IN1 w0.122: 63.67,87.78 63.06,87.78 62.71,87.72 62.71,87.72 62.32,87.65 45.85,76.12 25.89,72.6 25.32,72.7 25.2,72.88 24.84,72.94 24.66,72.82 24.3,72.88 24.18,73.06 23.82,73.12 23.64,73 23.28,73.06 22.56,73.06 v1(22.33,73.29)
  BOTTOM w0.135: J8.33 16.64,75.73 16.79,75.58 17.34,75.58 19.3,75.06 v3(19.74,74.78) 19.81,74.73 20.62,74.21 21.2,73.33 21.65,73.07 22.11,73.07 v1(22.33,73.29) ; U1.AL24 v4(67.36,88.13)
PE_SLV_TX_DN<14>: length 57.8
  IN1 w0.089: v4(67.36,89.13) 67.68,89.13 67.77,89.04 67.77,88.92 67.57,88.72 63.73,88.72 63.68,88.77 63.66,88.77
  IN1 w0.122: 63.66,88.77 63.05,88.77 62.35,88.65 45.69,76.98 35.01,75.1 24.95,76.87 24.83,77.05 24.47,77.11 24.29,76.99 23.93,77.05 23.81,77.23 23.45,77.29 23.27,77.17 22.27,77.34 21.45,77.34 v1(21.21,77.58)
  BOTTOM w0.135: U1.AL25 v4(67.36,89.13) ; v1(21.21,77.58) 20.96,77.34 v3(20.21,77.34) 16.73,77.34 16.54,77.53 J8.30
PE_SLV_TX_DN<15>: length 57.9
  IN1 w0.089: 63.82,89.77 63.84,89.77 63.89,89.72 67.58,89.72 67.77,89.92 67.77,90.04 67.68,90.13 v4(67.36,90.13)
  IN1 w0.122: v1(17.93,79.39) 18.17,79.16 19.37,79.16 20.1,79.03 20.28,79.15 20.64,79.09 20.76,78.91 21.12,78.85 21.3,78.97 21.66,78.91 21.78,78.73 36.42,76.15 45.37,77.73 62.41,89.66 63.05,89.77 63.82,89.77
  BOTTOM w0.135: J8.27 16.5,79.33 16.66,79.16 17.71,79.16 v1(17.93,79.39) ; U1.AL26 v4(67.36,90.13)
PE_SLV_TX_DP<0>: length 69.4
  IN1 w0.089: 63.81,73.47 63.83,73.47 63.88,73.52 67.64,73.52 67.91,73.79 67.91,74.02 68.02,74.13 v4(68.36,74.13)
  IN1 w0.122: v1(20.4,36.45) 20.63,36.68 21.19,36.68 24.59,39.06 26.25,40.23 26.77,40.98 35.93,47.39 41.23,54.96 58.1,66.77 62.61,73.22 62.9,73.42 63.17,73.47 63.81,73.47
  BOTTOM w0.135: J7.49 16.5,38.87 16.64,39.02 16.97,39.02 17.48,38.72 18.67,37.23 18.73,37.15 19.33,36.71 19.51,36.65 20.19,36.65 v1(20.4,36.45) ; U1.AK11 v4(68.36,74.13)
PE_SLV_TX_DP<1>: length 67
  IN1 w0.089: 63.77,74.49 63.79,74.49 63.84,74.54 67.67,74.54 67.93,74.81 67.93,75.02 68.05,75.13 v4(68.36,75.13)
  IN1 w0.122: v1(21.03,41.38) 21.27,41.61 22.22,41.61 25.65,42.22 27.54,42.55 35.45,48.08 40.66,55.53 57.44,67.28 62.16,74.02 62.71,74.41 63.19,74.49 63.2,74.49 63.77,74.49
  BOTTOM w0.135: J7.46 16.54,40.68 16.69,40.82 17.01,40.82 17.46,41.03 20.09,41.51 20.49,41.63 20.78,41.63 v1(21.03,41.38) ; U1.AK12 v4(68.36,75.13)
PE_SLV_TX_DP<2>: length 66.7
  IN1 w0.089: 63.73,75.49 63.75,75.49 63.8,75.54 67.66,75.54 67.92,75.8 67.92,76 68.05,76.13 v4(68.36,76.13)
  IN1 w0.122: v1(24.46,43.81) 24.7,44.05 26.21,44.05 29,44.54 32.34,46.88 33.37,48.35 34.17,48.92 35.9,50.13 40.09,56.11 56.87,67.85 61.62,74.64 62.74,75.42 63.12,75.49 63.73,75.49
  BOTTOM w0.135: v1(24.46,43.81) 24.23,44.04 23.52,44.04 22.45,43.82 20.16,43.34 20.16,43.34 v3(19.54,43.2) 17.05,42.62 16.66,42.62 16.51,42.48 J7.43 ; U1.AK13 v4(68.36,76.13)
PE_SLV_TX_DP<3>: length 68.8
  IN1 w0.089: 63.9,76.5 63.92,76.5 63.98,76.55 67.67,76.55 67.93,76.81 67.93,77.02 68.05,77.13 v4(68.36,77.13)
  IN1 w0.122: v1(21.39,45.54) 21.62,45.78 21.87,45.78 22.36,45.86 22.67,46.08 23.01,46.57 23.13,47.24 22.69,49.78 22.94,51.19 24.04,52.77 25.71,53.94 28.18,54.37 31.94,53.71 36.39,54.49 56.29,68.43 61.03,75.2 62.79,76.43 62.79,76.43 63.19,76.5 63.9,76.5
  BOTTOM w0.135: v1(21.39,45.54) 21.13,45.8 20.82,45.8 20.73,45.75 20.22,45.49 v3(19.13,45.2) 17.98,44.89 17.01,44.42 16.66,44.42 16.51,44.27 J7.40 ; U1.AK14 v4(68.36,77.13)
PE_SLV_TX_DP<4>: length 65.6
  IN1 w0.089: v4(68.36,78.13) 68.02,78.13 67.92,78.03 67.92,77.82 67.64,77.54 63.9,77.54 63.85,77.49 63.83,77.49
  IN1 w0.122: 63.83,77.49 63.14,77.49 62.96,77.46 62.8,77.43 60.4,75.75 57.18,71.16 55.63,68.94 37.13,55.99 33.5,55.35 32.95,55.35 v1(32.72,55.12)
  BOTTOM w0.135: U1.AK15 v4(68.36,78.13) ; v1(32.72,55.12) 32.49,55.35 v3(31.85,55.35) 30.31,55.35 25.6,54.51 24.58,53.8 20.64,49.31 20.32,48.94 19.67,48.29 19.67,48.29 19.51,48.13 18.52,46.99 17.52,46.3 17.1,46.22 16.68,46.22 16.53,46.08 J7.37
PE_SLV_TX_DP<5>: length 65.3
  IN1 w0.089: 63.68,78.49 63.7,78.49 63.75,78.54 67.67,78.54 67.93,78.8 67.93,79.02 68.05,79.13 v4(68.36,79.13)
  IN1 w0.122: v1(34.75,57.02) 34.98,57.26 35.67,57.26 38.19,57.7 54.95,69.43 59.73,76.26 62.83,78.43 63.13,78.49 63.68,78.49
  BOTTOM w0.135: U1.AK16 v4(68.36,79.13) ; v1(34.75,57.02) 34.52,57.25 32.64,57.25 v3(31.82,57.11) 25.52,56 23.62,54.67 17.85,48.08 16.93,48.02 16.65,48.02 16.5,47.87 J7.34
PE_SLV_TX_DP<6>: length 64.7
  IN1 w0.089: v4(68.36,80.13) 68.05,80.13 67.93,80.02 67.93,79.81 67.66,79.54 63.91,79.54 63.86,79.49 63.84,79.49
  IN1 w0.122: 63.84,79.49 63.16,79.49 63.01,79.46 62.85,79.43 59.18,76.87 54.63,70.37 39.1,59.5 37.21,59.16 36.89,59.16 v1(36.65,58.93)
  BOTTOM w0.135: v1(36.65,58.93) 36.43,59.16 v3(34.27,59.16) 32.56,59.16 25.04,57.21 22.99,55.77 17.76,50.1 17.49,49.92 17.21,49.87 17.17,49.82 16.65,49.82 16.5,49.68 J7.31 ; U1.AK17 v4(68.36,80.13)
PE_SLV_TX_DP<7>: length 64.6
  IN1 w0.089: 67.11,81.29 67.13,81.29 67.18,81.34 67.58,81.34 67.92,81.69 67.92,82 68.05,82.13 v4(68.36,82.13)
  IN1 w0.122: v1(26.14,58.93) 26.37,59.16 27.33,59.16 27.33,59.16 40.22,61.43 54.29,71.29 58.59,77.42 60.89,79.03 63.24,80.68 63.24,80.68 66.71,81.29 67.11,81.29
  BOTTOM w0.135: U1.AK18 v4(68.36,82.13) ; J7.28 16.55,51.48 16.7,51.62 16.95,51.62 17.33,51.69 v3(19.16,53.75) 20.53,55.29 21.77,56.69 25.29,59.16 25.91,59.16 v1(26.14,58.93)
PE_SLV_TX_DP<8>: length 60.5
  IN1 w0.089: v4(68.36,83.13) 68.11,83.13 68.02,83.04 68.02,82.83 67.72,82.53 63.93,82.53 63.88,82.48 63.86,82.48
  IN1 w0.122: 63.86,82.48 63.08,82.48 63.08,82.48 62.6,82.4 47.39,71.77 40.76,70.6 37,69.66 33.09,66.93 28.08,63.41 25.86,63.02 21.28,63.83 19.78,64.89 19.76,64.9 19.65,64.97 18.85,66.13 18.64,66.27 18.52,66.29 18.27,66.29 v1(18.04,66.06)
  BOTTOM w0.135: v1(18.04,66.06) 17.82,66.27 16.69,66.27 16.55,66.13 J8.49 ; U1.AK19 v4(68.36,83.13)
PE_SLV_TX_DP<9>: length 61.2
  IN1 w0.089: v4(68.36,84.13) 68.05,84.13 67.96,84.04 67.96,83.84 67.66,83.53 63.84,83.53 63.79,83.48 63.77,83.48
  IN1 w0.122: v1(20.93,66.05) 21.17,66.29 21.36,66.29 21.55,66.25 21.72,66.13 21.84,65.96 21.94,65.41 22.28,64.92 23.08,64.36 25.96,63.85 27.59,64.14 32.56,67.62 37.1,70.79 47.11,72.56 62.59,83.39 63.09,83.48 63.77,83.48
  BOTTOM w0.135: J8.46 16.54,67.93 16.69,68.07 16.99,68.07 18.13,67.87 18.9,67.33 19.26,66.83 20.04,66.28 20.7,66.28 v1(20.93,66.05) ; U1.AK20 v4(68.36,84.13)
PE_SLV_TX_DP<10>: length 61.6
  IN1 w0.089: 63.72,84.49 63.75,84.49 63.8,84.54 67.66,84.54 67.96,84.84 67.96,85.04 68.05,85.13 v4(68.36,85.13)
  IN1 w0.122: 63.72,84.49 63.1,84.49 62.58,84.4 46.73,73.3 36.44,71.48 27.26,65.05 25.76,64.79 25.42,64.85 25.08,65.09 24.85,65.41 24.78,65.81 24.61,66.06 24.33,66.26 24.16,66.29 23.96,66.29 v1(23.73,66.05)
  BOTTOM w0.135: U1.AK21 v4(68.36,85.13) ; v1(23.73,66.05) 23.52,66.26 22.69,66.26 22.16,66.63 21.54,67.53 v3(20.52,68.24) 19.05,69.27 18.61,69.58 16.94,69.87 16.68,69.87 16.53,69.73 J8.43
PE_SLV_TX_DP<11>: length 61.2
  IN1 w0.089: 63.88,85.48 63.9,85.48 63.95,85.54 67.66,85.54 67.96,85.84 67.96,86.04 68.05,86.13 v4(68.36,86.13)
  IN1 w0.122: v1(26.52,66.05) 26.75,66.28 27.04,66.28 27.48,66.36 35.84,72.22 46.46,74.09 62.62,85.4 63.07,85.48 63.88,85.48
  BOTTOM w0.135: J8.40 16.57,71.53 16.72,71.67 17.18,71.67 17.61,71.6 18.37,71.06 19.92,70.79 20.34,70.49 21.14,69.93 v3(21.62,69.59) 24.1,67.86 24.85,66.79 25.5,66.33 25.92,66.26 26.31,66.26 v1(26.52,66.05) ; U1.AK22 v4(68.36,86.13)
PE_SLV_TX_DP<12>: length 58.7
  IN1 w0.089: v4(68.36,87.13) 68.05,87.13 67.96,87.04 67.96,86.84 67.66,86.54 63.91,86.54 63.86,86.49 63.84,86.49
  IN1 w0.122: v1(19.64,72.64) 19.86,72.86 20.21,72.86 20.46,72.61 20.56,72.03 20.86,71.61 21.28,71.31 21.82,71.22 23.85,71.09 46.19,75.03 62.37,86.37 63.05,86.48 63.05,86.49 63.84,86.49
  BOTTOM w0.135: v1(19.64,72.64) 19.41,72.87 19.03,72.87 17.08,73.47 16.7,73.47 16.55,73.33 J8.37 ; U1.AK23 v4(68.36,87.13)
PE_SLV_TX_DP<13>: length 58.7
  IN1 w0.089: 63.67,87.49 63.69,87.49 63.74,87.54 67.67,87.54 67.96,87.84 67.96,88.04 68.05,88.13 v4(68.36,88.13)
  IN1 w0.122: 63.67,87.49 63.08,87.49 62.43,87.38 45.96,75.84 25.89,72.31 23.25,72.77 22.57,72.77 v1(22.33,72.53)
  BOTTOM w0.135: U1.AK24 v4(68.36,88.13) ; v1(22.33,72.53) 22.09,72.76 21.57,72.76 20.98,73.1 v3(20.69,73.54) 20.4,73.99 19.17,74.78 17.3,75.27 16.77,75.27 16.62,75.13 J8.34
PE_SLV_TX_DP<14>: length 57.8
  IN1 w0.089: 63.66,88.48 63.68,88.48 63.73,88.53 67.65,88.53 67.96,88.84 67.96,89.04 68.05,89.13 v4(68.36,89.13)
  IN1 w0.122: 63.66,88.48 63.08,88.48 62.77,88.43 62.47,88.37 45.8,76.7 35.01,74.8 22.24,77.05 21.44,77.05 v1(21.21,76.82)
  BOTTOM w0.135: J8.31 16.55,76.93 16.65,77.03 v3(18.93,77.03) 21,77.03 v1(21.21,76.82) ; U1.AK25 v4(68.36,89.13)
PE_SLV_TX_DP<15>: length 58
  IN1 w0.089: 63.82,89.48 63.84,89.48 63.89,89.53 67.65,89.53 67.96,89.84 67.96,90.04 68.05,90.13 v4(68.36,90.13)
  IN1 w0.122: v1(17.93,78.63) 18.17,78.87 19.35,78.87 36.42,75.86 45.49,77.46 62.52,89.38 62.66,89.41 63.07,89.48 63.82,89.48
  BOTTOM w0.135: J8.28 16.45,78.73 16.59,78.86 17.71,78.86 v1(17.93,78.63) ; U1.AK26 v4(68.36,90.13)
PE_WAKE_N: length 132.9
  TOP w0.127: R8.1 285.83,44.07 v1(285.7,44.2) ; v1(281.84,24.94) 282.4,24.38 282.4,23.26 R370.1 ; v1(285.57,64.39) 285.83,64.14 R7.1 ; R6.1 v1(285.34,83.97) ; R5.1 v1(282.4,103.25)
  IN1 w0.097: v1(282.4,103.25) 286.69,98.96 286.69,95.68 285.5,94.49 285.5,90.25 285.34,90.09 v1(285.34,83.97) ; v1(285.7,44.2) 285.7,39.72 286.97,38.46 286.97,34.82 281.76,29.62 281.76,25.02 v1(281.84,24.94) 279.73,24.94 279.2,25.48 277.93,25.48 275.85,23.39 275.85,18.97 276.66,18.16 276.66,14.45 277.78,13.34 277.78,11.99 278.51,11.25 283.27,11.25 283.44,11.42 283.44,11.94 v1(283.54,12.04)
  IN2 w0.112: v1(285.34,83.97) 285.34,80.75 286.87,79.21 286.87,78.18 288.88,76.17 288.88,75.49 290.04,74.32 290.04,65.92 288.05,63.93 286.04,63.93 v1(285.57,64.39) 285.57,60.19 286.87,58.89 286.87,55.03 285.19,53.35 285.19,49.91 285.7,49.4 v1(285.7,44.2)
  BOTTOM w0.127: J5.B11 285.83,5.84 286.56,6.58 286.56,8.54 285.19,9.91 284.68,9.91 283.8,10.79 283.8,11.79 v1(283.54,12.04)
PEX8796_GPIO0: length 39.3
  TOP w0.127: R115.1 R190.2 v1(57.74,50.67)
  IN2 w0.089: 63.58,77.09 64.01,77.52 69.98,77.52 v4(70.36,77.13)
  IN2 w0.112: 63.58,77.09 58.01,71.52 58.01,57.29 56.72,56.01 56.72,51.69 v1(57.74,50.67)
  BOTTOM w0.127: U1.AH14 v4(70.36,77.13)
PEX8796_GPIO1: length 24.2
  TOP w0.127: R269.1 R189.2 v1(72.59,53.85) 71.6,54.84 71.6,59.51 68.91,62.2 68.91,69.42 69.14,69.65 71.71,69.65 71.93,69.88 71.93,70.41 72.36,70.84 v4(72.36,71.13)
  BOTTOM w0.127: U1.AF8 v4(72.36,71.13)
PEX8796_GPIO2: length 20.6
  TOP w0.127: R270.1 R188.2 v1(74.5,56.64)
  IN2 w0.112: v4(73.36,74.13) 73.52,74.13 73.86,73.79 73.86,61.01 73.4,60.55 73.4,57.74 v1(74.5,56.64)
  BOTTOM w0.127: U1.AE11 v4(73.36,74.13)
PEX8796_GPIO3: length 36.9
  TOP w0.127: v1(59.77,50.67) R271.1 R187.2
  IN2 w0.112: v4(71.36,75.13) 70.91,74.68 64.21,74.68 59.01,69.47 59.01,54.61 60.36,53.26 60.36,50.88 60.14,50.67 v1(59.77,50.67)
  BOTTOM w0.127: U1.AG12 v4(71.36,75.13)
PEX_EEP_CS_N: length 3.6
  TOP w0.127: v7(71.36,77.13) 70.87,76.63 70.23,76.63 69.85,76.25 R113.1
  BOTTOM w0.114: U1.AG14 v7(71.36,77.13)
PEX_EEP_CS_R_N: length 69.9
  TOP w0.127: v1(60.04,64.18) 62,65.56 63.45,68.04 64.82,70.38 66.64,72.25 R113.2
  BOTTOM w0.114: U6.1 38.3,60.71 37.54,61.47 R272.2 35.66,61.96 35.51,62.1 33.66,62.1 33.22,62.53 33.22,65.74 34.28,66.8 50.4,66.8 50.51,66.69 50.51,65.81 50.63,65.7 51.02,65.7 51.13,65.81 51.13,66.76 51.25,66.87 51.64,66.87 51.76,66.76 51.76,65.81 51.87,65.7 52.27,65.7 52.38,65.81 52.38,66.76 52.49,66.87 52.89,66.87 53,66.76 53,65.81 53.12,65.7 53.51,65.7 53.62,65.81 53.62,66.69 53.74,66.8 54.13,66.8 54.25,66.69 54.25,65.81 54.36,65.7 54.75,65.7 54.87,65.81 54.87,66.76 54.98,66.87 55.38,66.87 55.49,66.76 55.49,65.84 55.61,65.72 56,65.72 56.11,65.84 56.11,66.69 56.23,66.8 57.09,66.8 57.64,66.25 57.64,66.09 56.6,65.04 56.6,64.88 56.88,64.6 57.04,64.6 58.19,65.75 58.37,65.75 58.65,65.47 58.65,65.36 57.48,64.19 57.48,64.03 57.76,63.75 57.92,63.75 58.94,64.77 59.13,64.77 59.71,64.18 v1(60.04,64.18)
PEX_EEP_HOLD_N: length 3.8
  BOTTOM w0.114: U6.7 46.81,61.98 v2(47.11,62.27) 47.32,62.48 R310.2
PEX_EEP_SCLK: length 10.5
  TOP w0.127: R116.2 v1(66.88,59.69)
  IN2 w0.112: v4(66.36,68.13) 65.86,67.63 65.86,60.71 v1(66.88,59.69)
  BOTTOM w0.114: U1.AM5 v4(66.36,68.13)
PEX_EEP_SCLK_R: length 64.3
  TOP w0.127: v1(66.94,57.51) 66.94,58.08 R116.1
  IN3 w0.112: v1(60.54,58.62) 66.14,58.62 66.94,57.82 v1(66.94,57.51)
  BOTTOM w0.114: U6.6 46.81,63.25 46.97,63.4 46.97,63.84 47.09,63.97 47.54,63.97 47.66,63.86 47.66,63.29 47.77,63.18 48.16,63.18 48.28,63.29 48.28,63.86 48.39,63.97 48.79,63.97 48.9,63.86 48.9,63.34 49.02,63.23 49.41,63.23 49.52,63.34 49.52,63.86 49.64,63.97 50.03,63.97 50.15,63.86 50.15,63.34 50.26,63.23 50.65,63.23 50.77,63.34 50.77,63.57 v2(51.03,63.83) 51.12,63.92 54.93,63.92 56.78,62.07 56.78,54.47 56.89,54.36 57.29,54.36 57.4,54.47 57.4,61.02 57.6,61.21 57.87,61.21 58.02,61.07 58.02,54.47 58.14,54.36 58.53,54.36 58.64,54.47 58.64,59.83 58.81,59.99 59.15,59.99 59.27,59.88 59.27,54.47 59.38,54.36 59.77,54.36 59.89,54.47 59.89,58.42 60.09,58.62 v1(60.54,58.62)
PEX_EEP_SI: length 23.8
  TOP w0.127: R117.2 v1(82.12,59.69)
  IN1 w0.097: v4(90.36,74.13) 89.76,73.52 89.76,71.95 89.33,71.53 84,71.53 83.87,71.4 83.87,70.61 83.35,70.09 82.56,70.09 81.06,68.59 81.06,62.05 81.33,61.77 81.33,60.48 v1(82.12,59.69)
  BOTTOM w0.114: U1.J11 v4(90.36,74.13)
PEX_EEP_SI_R: length 56.1
  TOP w0.127: R117.1 82.78,57.49 82.78,52.77 82.88,52.67 82.88,51.56 80.6,49.28 63.89,49.28 v1(63.4,49.76)
  BOTTOM w0.114: U6.5 55.35,64.52 61.15,58.72 61.15,58.05 61.18,58.02 61.18,57.5 61.15,57.47 61.15,52.27 63.4,50.01 v1(63.4,49.76)
PEX_EEP_SO: length 69.2
  IN3 w0.112: v4(77.36,71.13) 76.85,70.61 63.76,70.61 62.92,69.77 62.92,64.67 60.54,62.29 v6(59.85,62.29)
  BOTTOM w0.114: v6(59.85,62.29) 58.44,62.29 55.55,65.18 49.73,65.18 49.61,65.29 49.61,66.18 49.5,66.29 49.1,66.29 48.99,66.18 48.99,65.29 48.88,65.18 48.48,65.18 48.37,65.29 48.37,66.18 48.25,66.29 47.86,66.29 47.75,66.18 47.75,65.29 47.63,65.18 47.24,65.18 47.12,65.29 47.12,66.18 47.01,66.29 46.61,66.29 46.5,66.18 46.5,65.29 46.39,65.18 45.99,65.18 45.88,65.29 45.88,66.18 45.76,66.29 45.37,66.29 45.26,66.18 45.26,65.29 45.14,65.18 44.75,65.18 44.63,65.29 44.63,66.18 44.52,66.29 44.13,66.29 44.01,66.18 44.01,65.29 43.9,65.18 43.5,65.18 43.39,65.29 43.39,66.18 43.27,66.29 42.88,66.29 42.77,66.18 42.77,65.29 42.65,65.18 42.26,65.18 42.14,65.29 42.14,66.18 42.03,66.29 34.49,66.29 33.73,65.53 33.73,62.87 33.99,62.61 R114.1 ; U1.AA8 v4(77.36,71.13)
PEX_EEP_SO_R: length 5.9
  BOTTOM w0.114: U6.2 37.67,61.98 v2(37.16,62.48) 37.16,62.99 36.53,63.63 R273.2 R114.2
PEX_I2C_ADDR: length 32.4
  TOP w0.089: v4(89.36,74.13) 89.77,74.54 96.78,74.54 96.8,74.55
  TOP w0.127: R134.2 119.18,75.31 117.15,75.31 R135.1 v1(115.65,75.95) 114.58,74.88 101.5,74.88 101.17,74.55 96.8,74.55
  BOTTOM w0.127: U1.K11 v4(89.36,74.13)
