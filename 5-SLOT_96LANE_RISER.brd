# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PD_STRAP_RESERVED_5: length 25.7
  TOP w0.089: v4(92.36,72.13) 92.64,72.13 93.24,71.54 98.79,71.54 98.81,71.55
  TOP w0.127: 98.81,71.55 101.01,71.55 101.45,71.11 114.62,71.11 v1(115.65,72.14) R167.2
  BOTTOM w0.127: U1.G9 v4(92.36,72.13)
PD_STRAP_RESERVED_6: length 16.8
  TOP w0.127: R168.2 v1(64.97,53.85)
  BOTTOM w0.127: v1(64.97,53.85) 63.83,54.99 63.83,61.61 63.43,62.01 63.43,67.07 63.83,67.48 63.83,67.69 64.77,68.63 U1.AP5
PD_STRAP_RESERVED_7: length 22.6
  TOP w0.127: v4(75.36,72.13) 75.39,72.13 75.9,71.63 75.9,70.92 76.2,70.61 76.66,70.61 76.86,70.41 76.86,68.83 76.18,68.15 76.18,62.84 79.43,59.59 79.43,54.64 v1(80.21,53.85) R169.2
  BOTTOM w0.127: U1.AC9 v4(75.36,72.13)
PD_STRAP_RESERVED_8: length 39.5
  TOP w0.127: R170.2 52.63,58.8 v1(53.29,59.46)
  IN2 w0.089: v4(72.36,83.13) 71.95,83.54 64.19,83.54 64.04,83.39 63.71,83.39
  IN2 w0.112: v1(53.29,59.46) 53.29,73.61 63.07,83.39 63.71,83.39
  BOTTOM w0.127: U1.AF19 v4(72.36,83.13)
PD_STRAP_RESERVED_9: length 41.4
  IN2 w0.112: v4(70.36,82.13) 69.5,81.27 64.01,81.27 55.45,72.71 55.45,60.88 v1(55.96,60.38)
  BOTTOM w0.127: U1.AH18 v4(70.36,82.13) ; v1(55.96,60.38) 55.02,60.38 54.69,60.71 48.97,60.71 v2(48.59,60.33) R171.2
PD_STRAP_RESERVED_10: length 22.6
  TOP w0.127: R172.2 R173.1 v1(74.5,53.72)
  IN2 w0.112: v4(72.36,73.13) 72.49,73.13 72.85,72.77 72.85,60.73 73.13,60.45 73.13,55.09 v1(74.5,53.72)
  BOTTOM w0.127: U1.AF10 v4(72.36,73.13)
PD_STRAP_RESERVED_11: length 13.1
  TOP w0.127: v4(74.36,70.13) 73.89,69.66 73.89,62.2 v1(76.4,59.69) R174.1
  BOTTOM w0.127: U1.AD7 v4(74.36,70.13)
PD_STRAP_RESERVED_12: length 19
  TOP w0.127: v4(65.36,67.13) 65.8,67.56 66.75,67.56 66.88,67.44 66.88,61.65 67.87,60.66 67.87,57.29 68.32,56.84 68.32,52.85 R175.1 v1(67.77,51.69)
  BOTTOM w0.127: U1.AN4 v4(65.36,67.13)
PD_STRAP_RESERVED_13: length 46
  TOP w0.127: R176.1 v1(115.77,66.42)
  IN2 w0.112: v4(80.36,70.13) 81.23,69.26 81.23,64.27 84.69,60.81 99.16,60.81 101.91,63.55 111.3,63.55 113.01,65.26 114.61,65.26 v1(115.77,66.42)
  BOTTOM w0.127: U1.V7 v4(80.36,70.13)
PD_STRAP_RESERVED_15: length 16.6
  TOP w0.127: v4(75.36,70.13) 75.36,68.99 74.7,68.33 74.7,63.37 77.67,60.4 77.67,57.4 v1(78.31,56.77) R324.2
  BOTTOM w0.127: U1.AC7 v4(75.36,70.13)
PD_STRAP_SNT0_PORTCFG1: length 22.4
  TOP w0.127: R318.1 v1(70.69,53.85)
  IN2 w0.112: v4(72.36,74.13) 71.83,73.6 71.83,54.99 v1(70.69,53.85)
  BOTTOM w0.127: U1.AF11 v4(72.36,74.13)
PD_STRAP_SNT1_PORTCFG1: length 27.6
  TOP w0.089: 97.08,73.55 97.06,73.54 90.77,73.54 v4(90.36,73.13)
  TOP w0.127: R319.1 v1(115.65,74.04) 114.76,73.15 101.8,73.15 101.4,73.55 97.08,73.55
  BOTTOM w0.127: U1.J10 v4(90.36,73.13)
PD_STRAP_SNT2_PORTCFG1: length 50.8
  TOP w0.127: R320.1 v1(47.07,53.09)
  IN2 w0.112: v1(47.07,53.09) 48.85,54.86 48.85,71.93 63.55,86.63 71.86,86.63 v4(72.36,87.13)
  BOTTOM w0.127: U1.AF23 v4(72.36,87.13)
PD_STRAP_SNT3_PORTCFG1: length 22.6
  TOP w0.127: v4(92.36,89.13) 92.9,89.66 98.88,89.66 100.03,88.52 111.58,88.52 v1(112.47,89.41) R321.1
  BOTTOM w0.127: U1.G25 v4(92.36,89.13)
PD_STRAP_SNT4_PORTCFG1: length 31.3
  TOP w0.127: v4(85.36,92.13) 84.86,92.64 84.86,98.62 87.58,101.35 98.33,101.35 102.06,97.61 102.06,95.89 v1(102.82,95.12) R322.1
  BOTTOM w0.127: U1.N28 v4(85.36,92.13)
PD_STRAP_SNT5_PORTCFG1: length 29
  TOP w0.114: v4(89.36,90.13) 89.87,90.63 89.87,92.63 88.87,93.63
  TOP w0.127: R323.1 v1(102.82,93.22) 102.44,93.22 100.28,95.38 100.28,97.54 98.5,99.31 89.74,99.31 88.87,98.44 88.87,93.63
  BOTTOM w0.127: U1.K26 v4(89.36,90.13)
PD_VOE_N: length 30.4
  TOP w0.127: U9.22 303.46,54.89 v1(303.35,54.99) ; v1(305.25,57.4) 305.3,57.35 U9.19 ; v1(302.97,49.66) 303.46,49.17 R76.2 304.52,50.08 304.76,50.08 305.3,50.62 U9.32 ; v1(303.35,52.32) 303.52,52.49 U9.28 ; v1(308.81,48.51) 308.81,49.3 307.7,50.41 U9.38 ; v1(307.8,57.28) 307.7,57.18 U9.13
  IN2 w0.112: v1(307.8,57.28) 307.16,57.91 305.76,57.91 v1(305.25,57.4) 303.84,55.99 303.84,55.47 v1(303.35,54.99) 304.12,54.23 304.12,53.09 v1(303.35,52.32) 303.82,51.86 303.82,50.5 v1(302.97,49.66) 304.12,48.51 v1(308.81,48.51)
PE_CPU_RX_DN<0>: length 12.2
  TOP w0.135: J5.A17 277.83,5.8 278.17,6.15 278.17,7.45 v1(277.83,7.8)
  IN4 w0.122: v1(277.83,7.8) 278.19,8.16 278.19,8.6 277.71,11.3 277.71,13.67 277.96,13.91 278.15,14.01 278.15,14.01 278.21,14.17 J1.A17
PE_CPU_RX_DN<1>: length 12.3
  TOP w0.135: J5.A22 272.83,5.8 273.17,6.15 273.17,7.45 v1(272.82,7.8)
  IN4 w0.122: v1(272.82,7.8) 273.19,8.16 273.19,8.55 273.25,8.92 273.12,9.09 273.19,9.45 273.37,9.58 273.43,9.94 273.3,10.11 273.37,10.47 273.55,10.6 273.66,11.23 273.66,11.59 273.5,11.75 273.5,12.11 273.66,12.27 273.66,13.57 273.53,13.69 273.4,13.76 273.21,13.69 J1.A22
PE_CPU_RX_DN<2>: length 12.2
  TOP w0.135: J5.A26 268.83,5.8 269.17,6.15 269.17,7.46 v1(268.84,7.8)
  IN4 w0.122: J1.A26 269.21,13.69 269.38,13.75 269.47,13.7 269.63,13.55 269.63,12.11 269.48,11.96 269.48,11.59 269.63,11.44 269.63,11.07 269.56,10.66 269.38,10.54 269.32,10.18 269.44,10 269.38,9.64 269.2,9.51 269.14,9.15 269.26,8.98 269.2,8.62 269.2,8.16 v1(268.84,7.8)
PE_CPU_RX_DN<3>: length 12.2
  TOP w0.135: v1(264.82,7.8) 265.17,7.45 265.17,6.18 264.83,5.83 J5.A30
  IN4 w0.122: v1(264.82,7.8) 265.18,8.16 265.18,8.6 265.25,8.96 265.12,9.14 265.19,9.5 265.36,9.62 265.43,9.98 265.3,10.16 265.37,10.52 265.54,10.64 265.61,11.03 265.61,11.4 265.46,11.55 265.46,11.92 265.61,12.07 265.61,13.57 265.52,13.66 265.36,13.74 265.21,13.69 J1.A30
PE_CPU_RX_DN<4>: length 12.2
  TOP w0.135: v1(258.83,7.8) 259.17,7.46 259.17,6.15 258.83,5.8 J5.A36
  IN4 w0.122: v1(258.83,7.8) 259.19,8.16 259.19,8.89 259.25,9.25 259.13,9.42 259.19,9.78 259.37,9.91 259.43,10.27 259.31,10.45 259.37,10.81 259.55,10.93 259.65,11.5 259.65,11.87 259.5,12.02 259.5,12.39 259.65,12.54 259.65,13.53 259.5,13.68 259.38,13.74 259.37,13.75 259.21,13.69 J1.A36
PE_CPU_RX_DN<5>: length 12.2
  TOP w0.135: J5.A40 254.83,5.8 255.17,6.15 255.17,7.44 v1(254.81,7.8)
  IN4 w0.122: J1.A40 255.21,13.69 255.36,13.74 255.39,13.73 255.51,13.67 255.64,13.54 255.64,12.21 255.48,12.05 255.48,11.69 255.64,11.54 255.64,11.17 255.54,10.64 255.37,10.52 255.3,10.16 255.43,9.98 255.36,9.62 255.19,9.49 255.12,9.13 255.25,8.96 255.18,8.56 255.18,8.16 v1(254.81,7.8)
PE_CPU_RX_DN<6>: length 12.3
  TOP w0.135: J5.A44 250.83,5.8 251.17,6.15 251.17,7.45 v1(250.83,7.8)
  IN4 w0.122: J1.A44 251.21,13.69 251.36,13.74 251.38,13.73 251.51,13.67 251.7,13.48 251.7,12.48 251.55,12.33 251.55,11.96 251.7,11.81 251.7,11.44 251.55,10.6 251.38,10.48 251.31,10.12 251.44,9.94 251.37,9.58 251.2,9.46 251.13,9.1 251.26,8.92 251.19,8.54 251.19,8.16 v1(250.83,7.8)
PE_CPU_RX_DN<7>: length 12.2
  TOP w0.135: J5.A48 246.83,5.8 247.17,6.15 247.17,7.44 v1(246.81,7.8)
  IN4 w0.122: v1(246.81,7.8) 247.18,8.16 247.18,8.73 247.24,9.09 247.11,9.27 247.18,9.63 247.36,9.76 247.42,10.12 247.3,10.29 247.36,10.65 247.54,10.78 247.63,11.29 247.63,11.66 247.47,11.81 247.47,12.18 247.63,12.33 247.63,13.49 247.37,13.75 247.21,13.69 J1.A48
PE_CPU_RX_DN<8>: length 12.2
  TOP w0.135: v1(241.84,7.8) 242.17,7.46 242.17,6.15 241.83,5.8 J5.A53
  IN4 w0.122: J1.A53 242.21,14.17 242.15,14.01 242.15,14.01 241.99,13.93 241.71,13.64 241.71,11.33 242.2,8.56 242.2,8.16 v1(241.84,7.8)
PE_CPU_RX_DN<9>: length 12.2
  TOP w0.135: J5.A57 237.83,5.8 238.17,6.15 238.17,7.45 v1(237.82,7.8)
  IN4 w0.122: v1(237.82,7.8) 238.18,8.16 238.18,8.45 237.69,11.22 237.69,13.64 237.98,13.92 238.15,14.01 238.21,14.17 J1.A57
PE_CPU_RX_DN<10>: length 12.2
  TOP w0.135: v1(233.81,7.8) 234.17,7.44 234.17,6.15 233.83,5.8 J5.A61
  IN4 w0.122: v1(233.81,7.8) 234.17,8.16 234.17,8.46 233.69,11.16 233.69,13.63 234,13.93 234.15,14.01 234.15,14.01 234.21,14.17 J1.A61
PE_CPU_RX_DN<11>: length 12.2
  TOP w0.135: J5.A65 229.83,5.8 230.17,6.15 230.17,7.45 v1(229.82,7.8)
  IN4 w0.122: J1.A65 230.21,14.17 230.15,14.01 230.15,14.01 229.96,13.91 229.73,13.69 229.73,11.16 230.18,8.61 230.18,8.16 v1(229.82,7.8)
PE_CPU_RX_DN<12>: length 12.2
  TOP w0.135: J5.A69 225.83,5.8 226.17,6.15 226.17,7.46 v1(225.83,7.8)
  IN4 w0.122: v1(225.83,7.8) 226.2,8.16 226.2,8.64 225.72,11.34 225.72,13.67 225.96,13.91 226.15,14.01 226.15,14.01 226.21,14.17 J1.A69
PE_CPU_RX_DN<13>: length 12.2
  TOP w0.135: J5.A73 221.83,5.8 222.17,6.15 222.17,7.45 v1(221.82,7.8)
  IN4 w0.122: J1.A73 222.21,14.17 222.15,14.01 222.07,13.97 221.96,13.91 221.65,13.61 221.65,11.6 222.18,8.61 222.18,8.16 v1(221.82,7.8)
PE_CPU_RX_DN<14>: length 12.2
  TOP w0.135: v1(217.81,7.8) 218.17,7.43 218.17,6.15 217.83,5.8 J5.A77
  IN4 w0.122: v1(217.81,7.8) 218.17,8.16 218.17,8.77 217.72,11.33 217.72,13.67 217.96,13.91 218.15,14.01 218.15,14.01 218.21,14.17 J1.A77
PE_CPU_RX_DN<15>: length 12.3
  TOP w0.135: v1(214.1,7.8) 214.45,7.45 214.45,7.28 214.2,6.26 214.2,5.89 213.83,5.52 J5.A81
  IN4 w0.122: v1(214.1,7.8) 214.46,8.16 214.46,8.43 213.65,13.01 213.65,13.61 213.83,13.79 213.96,13.91 214.08,13.97 214.07,13.97 214.15,14.01 214.21,14.17 J1.A81
PE_CPU_RX_DP<0>: length 12.3
  TOP w0.135: v1(278.84,7.8) 278.48,7.44 278.48,6.15 278.83,5.8 J5.A16
  IN4 w0.122: J1.A16 278.45,13.7 278.28,13.75 278.21,13.71 278.13,13.67 278,13.55 278,12.37 278.16,12.21 278.16,11.85 278,11.7 278,11.33 278.12,10.67 278.3,10.55 278.36,10.19 278.24,10.01 278.3,9.65 278.48,9.53 278.54,9.17 278.42,8.99 278.48,8.63 278.48,8.16 v1(278.84,7.8)
PE_CPU_RX_DP<1>: length 12.2
  TOP w0.135: v1(273.84,7.8) 273.48,7.44 273.48,6.15 273.83,5.8 J5.A21
  IN4 w0.122: J1.A21 273.45,14.17 273.49,14.04 273.71,13.93 273.95,13.69 273.95,11.2 273.48,8.53 273.48,8.16 v1(273.84,7.8)
PE_CPU_RX_DP<2>: length 12.2
  TOP w0.135: v1(269.85,7.8) 269.48,7.43 269.48,6.15 269.83,5.8 J5.A25
  IN4 w0.122: v1(269.85,7.8) 269.49,8.16 269.49,8.59 269.92,11.04 269.92,13.67 269.65,13.94 269.5,14.02 269.45,14.17 J1.A25
PE_CPU_RX_DP<3>: length 12.2
  TOP w0.135: J5.A29 265.83,5.81 265.48,6.15 265.48,7.44 v1(265.84,7.8)
  IN4 w0.122: J1.A29 265.45,14.17 265.51,13.99 265.69,13.9 265.91,13.69 265.91,11 265.48,8.57 265.48,8.16 v1(265.84,7.8)
PE_CPU_RX_DP<4>: length 12.2
  TOP w0.135: v1(259.84,7.8) 259.48,7.44 259.48,6.15 259.83,5.8 J5.A35
  IN4 w0.122: v1(259.84,7.8) 259.48,8.16 259.48,8.86 259.94,11.47 259.94,13.65 259.67,13.92 259.5,14 259.45,14.17 J1.A35
PE_CPU_RX_DP<5>: length 12.2
  TOP w0.135: J5.A39 255.83,5.8 255.48,6.15 255.48,7.45 v1(255.83,7.8)
  IN4 w0.122: J1.A39 255.45,14.17 255.51,14 255.68,13.91 255.93,13.66 255.93,11.14 255.47,8.53 255.47,8.16 v1(255.83,7.8)
PE_CPU_RX_DP<6>: length 12.2
  TOP w0.135: J5.A43 251.83,5.8 251.48,6.15 251.48,7.44 v1(251.84,7.8)
  IN4 w0.122: v1(251.84,7.8) 251.48,8.16 251.48,8.51 251.99,11.42 251.99,13.6 251.68,13.91 251.51,14 251.45,14.17 J1.A43
PE_CPU_RX_DP<7>: length 12.2
  TOP w0.135: v1(247.83,7.8) 247.48,7.45 247.48,6.15 247.83,5.8 J5.A47
  IN4 w0.122: v1(247.83,7.8) 247.47,8.16 247.47,8.71 247.92,11.26 247.92,13.61 247.53,14 247.5,14.01 247.45,14.17 J1.A47
PE_CPU_RX_DP<8>: length 12.2
  TOP w0.135: J5.A52 242.83,5.8 242.48,6.15 242.48,7.43 v1(242.85,7.8)
  IN4 w0.122: v1(242.85,7.8) 242.49,8.16 242.49,8.58 242.43,8.95 242.55,9.12 242.49,9.48 242.31,9.61 242.25,9.97 242.37,10.14 242.31,10.5 242.13,10.63 242,11.36 242,11.72 242.15,11.88 242.15,12.24 242,12.4 242,13.52 242.17,13.69 242.29,13.75 242.45,13.69 J1.A52
PE_CPU_RX_DP<9>: length 12.3
  TOP w0.135: J5.A56 238.83,5.8 238.48,6.15 238.48,7.44 v1(238.84,7.8)
  IN4 w0.122: J1.A56 238.45,13.69 238.28,13.75 238.28,13.75 238.15,13.68 237.99,13.52 237.99,12.29 238.14,12.13 238.14,11.77 237.99,11.61 237.99,11.25 238.12,10.52 238.29,10.4 238.36,10.04 238.23,9.86 238.3,9.5 238.47,9.37 238.54,9.01 238.41,8.84 238.48,8.48 238.48,8.16 v1(238.84,7.8)
PE_CPU_RX_DP<10>: length 12.2
  TOP w0.135: v1(234.82,7.8) 234.48,7.46 234.48,6.15 234.83,5.8 J5.A60
  IN4 w0.122: v1(234.82,7.8) 234.46,8.16 234.46,8.49 234.4,8.85 234.52,9.03 234.46,9.39 234.28,9.51 234.22,9.87 234.34,10.05 234.28,10.41 234.1,10.53 233.99,11.19 233.99,11.56 234.14,11.71 234.14,12.07 233.99,12.23 233.99,13.51 234.17,13.69 234.28,13.75 234.45,13.69 J1.A60
PE_CPU_RX_DP<11>: length 12.2
  TOP w0.135: J5.A64 230.83,5.8 230.48,6.15 230.48,7.44 v1(230.84,7.8)
  IN4 w0.122: J1.A64 230.45,13.69 230.28,13.75 230.28,13.75 230.13,13.67 230.03,13.57 230.03,12.22 230.18,12.07 230.18,11.7 230.03,11.55 230.03,11.18 230.12,10.68 230.29,10.55 230.36,10.19 230.23,10.01 230.3,9.65 230.47,9.53 230.54,9.17 230.41,8.99 230.48,8.63 230.48,8.16 v1(230.84,7.8)
PE_CPU_RX_DP<12>: length 12.3
  TOP w0.135: J5.A68 226.83,5.8 226.48,6.15 226.48,7.43 v1(226.85,7.8)
  IN4 w0.122: J1.A68 226.45,13.7 226.28,13.75 226.28,13.75 226.13,13.67 226.01,13.55 226.01,12.4 226.16,12.25 226.16,11.88 226.01,11.73 226.01,11.36 226.13,10.71 226.3,10.58 226.37,10.22 226.24,10.05 226.31,9.69 226.48,9.56 226.55,9.2 226.42,9.02 226.49,8.66 226.49,8.16 v1(226.85,7.8)
PE_CPU_RX_DP<13>: length 12.3
  TOP w0.135: J5.A72 222.83,5.8 222.48,6.15 222.48,7.45 v1(222.84,7.8)
  IN4 w0.122: J1.A72 222.45,13.7 222.28,13.75 222.27,13.74 222.21,13.71 222.13,13.67 221.95,13.49 221.95,12.67 222.1,12.52 222.1,12.15 221.95,12 221.95,11.63 222.11,10.68 222.29,10.56 222.35,10.2 222.23,10.02 222.29,9.66 222.47,9.54 222.53,9.18 222.41,9 222.47,8.64 222.47,8.16 v1(222.84,7.8)
PE_CPU_RX_DP<14>: length 12.2
  TOP w0.135: v1(218.82,7.8) 218.48,7.46 218.48,6.15 218.83,5.8 J5.A76
  IN4 w0.122: J1.A76 218.45,13.7 218.28,13.75 218.13,13.67 218.01,13.55 218.01,12.39 218.16,12.24 218.16,11.87 218.01,11.72 218.01,11.35 218.1,10.84 218.28,10.72 218.34,10.36 218.22,10.18 218.28,9.82 218.46,9.7 218.52,9.34 218.4,9.16 218.46,8.8 218.46,8.16 v1(218.82,7.8)
PE_CPU_RX_DP<15>: length 12.3
  TOP w0.135: J5.A80 214.83,5.57 214.5,5.89 214.5,6.22 214.76,7.24 214.76,7.45 v1(215.11,7.8)
  IN4 w0.122: v1(215.11,7.8) 214.75,8.16 214.75,8.46 214.62,9.19 214.75,9.37 214.68,9.73 214.51,9.86 214.44,10.22 214.57,10.39 214.5,10.75 214.33,10.88 214.26,11.24 214.39,11.42 214.32,11.78 214.15,11.9 213.95,13.03 213.95,13.49 214.13,13.67 214.28,13.75 214.28,13.75 214.45,13.7 J1.A80
PE_CPU_TX_DN<0>: length 17.1
  BOTTOM w0.135: J5.B15 279.83,5.8 280.17,6.15 280.17,6.81 280.03,7.63 279.25,8.75 279.15,9.29 279.3,10.13 279.18,10.31 279.25,10.71 279.43,10.83 279.5,11.23 279.37,11.41 279.44,11.81 279.62,11.93 279.69,12.33 279.69,13.5 280.65,14.47 280.65,15.96 280.5,16.11 280.5,16.52 280.65,16.67 280.65,18.03 280.51,18.17 280.38,18.24 280.2,18.18 J1.B15
PE_CPU_TX_DN<1>: length 16.9
  BOTTOM w0.135: J1.B20 275.2,18.69 275.14,18.52 274.94,18.42 274.67,18.15 274.67,14.43 275.7,13.4 275.7,12.28 275.34,10.22 275.55,9.03 275.17,6.92 275.17,6.15 274.83,5.8 J5.B20
PE_CPU_TX_DN<2>: length 16.9
  BOTTOM w0.135: J5.B24 270.83,5.8 271.17,6.15 271.17,6.8 271.59,9.19 271.35,10.56 271.65,12.27 271.65,13.37 270.67,14.35 270.67,18.15 270.91,18.39 271.11,18.49 271.14,18.51 271.2,18.69 J1.B24
PE_CPU_TX_DN<3>: length 16.9
  BOTTOM w0.135: J1.B28 267.2,18.69 267.14,18.52 266.94,18.42 266.67,18.15 266.67,14.43 267.64,13.46 267.64,12.37 267.32,10.56 267.55,9.25 267.17,7.1 267.17,6.15 266.83,5.8 J5.B28
PE_CPU_TX_DN<4>: length 16.9
  BOTTOM w0.135: J1.B34 261.2,18.69 261.14,18.51 260.92,18.4 260.67,18.15 260.67,14.25 261.68,13.24 261.68,12.34 261.52,11.39 261.34,10.37 261.56,9.13 261.17,6.96 261.17,6.15 260.83,5.8 J5.B34
PE_CPU_TX_DN<5>: length 16.8
  BOTTOM w0.135: J1.B38 257.2,18.69 257.14,18.51 256.92,18.4 256.7,18.18 256.7,14.29 257.66,13.34 257.66,12.39 257.49,11.44 257.3,10.37 257.55,8.94 257.17,6.8 257.17,6.15 256.83,5.8 J5.B38
PE_CPU_TX_DN<6>: length 16.8
  BOTTOM w0.135: J1.B42 253.2,18.69 253.14,18.51 252.92,18.4 252.7,18.18 252.7,14.34 253.64,13.4 253.64,12.43 253.3,10.48 253.52,9.2 253.17,7.22 253.17,6.15 252.83,5.8 J5.B42
PE_CPU_TX_DN<7>: length 16.8
  BOTTOM w0.135: J1.B46 249.2,18.69 249.14,18.51 248.92,18.4 248.7,18.18 248.7,14.38 249.64,13.44 249.64,12.4 249.31,10.52 249.52,9.32 249.17,7.35 249.17,6.15 248.83,5.8 J5.B46
PE_CPU_TX_DN<8>: length 16.9
  BOTTOM w0.135: J5.B51 243.83,5.8 244.17,6.15 244.17,6.95 243.94,8.26 243.77,8.38 243.7,8.78 243.82,8.95 243.75,9.35 243.98,10.62 243.84,11.36 243.67,11.48 243.6,11.88 243.72,12.06 243.65,12.46 243.65,13.42 244.67,14.43 244.67,16.08 244.51,16.24 244.51,16.64 244.67,16.79 244.67,18.01 244.51,18.17 244.38,18.24 244.2,18.18 J1.B51
PE_CPU_TX_DN<9>: length 16.8
  BOTTOM w0.135: J5.B55 239.83,5.8 240.17,6.15 240.17,7.04 239.99,8.07 239.82,8.19 239.75,8.59 239.87,8.77 239.8,9.17 240.04,10.51 239.88,11.39 239.7,11.51 239.63,11.91 239.76,12.09 239.69,12.48 239.69,13.59 240.63,14.53 240.63,15.98 240.48,16.14 240.48,16.54 240.63,16.69 240.63,18.05 240.51,18.17 240.38,18.24 240.2,18.18 J1.B55
PE_CPU_TX_DN<10>: length 16.9
  BOTTOM w0.135: J1.B59 236.2,18.18 236.38,18.24 236.51,18.17 236.65,18.03 236.65,16.86 236.5,16.71 236.5,16.3 236.65,16.15 236.65,14.33 235.71,13.39 235.71,12.48 235.79,12.05 235.66,11.88 235.73,11.48 235.91,11.36 236.09,10.35 235.83,8.85 235.9,8.45 235.77,8.28 235.84,7.88 236.02,7.76 236.17,6.88 236.17,6.15 235.83,5.8 J5.B59
PE_CPU_TX_DN<11>: length 16.9
  BOTTOM w0.135: J5.B63 231.83,5.8 232.17,6.15 232.17,7.22 232.04,7.98 231.86,8.1 231.79,8.5 231.92,8.68 231.85,9.08 232.07,10.32 231.9,11.27 231.72,11.39 231.65,11.79 231.78,11.97 231.67,12.6 231.67,13.61 232.67,14.61 232.67,16.16 232.51,16.31 232.51,16.72 232.67,16.87 232.67,18.02 232.51,18.17 232.38,18.24 232.2,18.18 J1.B63
PE_CPU_TX_DN<12>: length 16.9
  BOTTOM w0.135: J1.B67 228.2,18.18 228.38,18.24 228.55,18.15 228.68,18.03 228.68,16.82 228.52,16.67 228.52,16.26 228.68,16.11 228.68,14.61 227.66,13.59 227.66,12.4 227.73,12 227.61,11.82 227.68,11.42 227.86,11.3 228.01,10.41 227.86,9.53 227.93,9.13 227.8,8.96 227.87,8.56 228.05,8.43 228.17,7.72 228.17,6.15 227.83,5.8 J5.B67
PE_CPU_TX_DN<13>: length 16.9
  BOTTOM w0.135: J1.B71 224.2,18.18 224.38,18.24 224.51,18.17 224.67,18.01 224.67,16.74 224.52,16.59 224.52,16.19 224.67,16.03 224.67,14.58 223.67,13.58 223.67,12.54 223.75,12.09 223.62,11.91 223.7,11.51 223.87,11.39 224.04,10.41 223.83,9.22 223.9,8.82 223.78,8.65 223.85,8.25 224.03,8.12 224.17,7.29 224.17,6.15 223.83,5.8 J5.B71
PE_CPU_TX_DN<14>: length 16.9
  BOTTOM w0.135: J5.B75 219.83,5.8 220.17,6.15 220.17,6.69 219.92,8.14 219.74,8.26 219.67,8.66 219.8,8.84 219.72,9.24 219.93,10.37 219.81,11 219.64,11.13 219.57,11.53 219.69,11.7 219.62,12.1 219.62,13.39 220.62,14.39 220.62,16.21 220.47,16.37 220.47,16.77 220.62,16.92 220.62,18.06 220.51,18.17 220.38,18.24 220.2,18.18 J1.B75
PE_CPU_TX_DN<15>: length 17
  BOTTOM w0.135: J5.B79 215.83,5.54 216.17,5.89 216.17,7.46 215.99,8.49 216.12,9.2 216,9.38 216.07,9.78 216.24,9.9 216.32,10.32 216.04,11.15 215.84,11.25 215.72,11.63 215.81,11.83 215.67,12.24 215.67,13.46 216.69,14.48 216.69,16.19 216.54,16.35 216.54,16.75 216.69,16.9 216.69,17.99 216.51,18.17 216.38,18.24 216.2,18.18 J1.B79
PE_CPU_TX_DP<0>: length 17.1
  BOTTOM w0.135: J1.B14 280.46,18.69 280.52,18.51 280.69,18.43 280.96,18.15 280.96,14.34 279.99,13.38 279.99,12.3 279.8,11.18 279.46,9.29 279.54,8.87 280.32,7.75 280.48,6.83 280.48,6.15 280.83,5.8 J5.B14
PE_CPU_TX_DP<1>: length 16.9
  BOTTOM w0.135: J1.B19 275.46,18.18 275.27,18.24 275.12,18.17 274.98,18.03 274.98,16.74 275.13,16.58 275.13,16.18 274.98,16.03 274.98,14.56 276.01,13.53 276.01,12.25 275.92,11.74 276.04,11.57 275.97,11.17 275.79,11.05 275.65,10.22 275.86,9.03 275.77,8.56 275.9,8.39 275.83,7.99 275.65,7.86 275.48,6.89 275.48,6.15 275.83,5.8 J5.B19
PE_CPU_TX_DP<2>: length 16.9
  BOTTOM w0.135: J1.B23 271.46,18.18 271.28,18.24 271.09,18.14 270.98,18.03 270.98,16.74 271.13,16.58 271.13,16.18 270.98,16.03 270.98,14.47 271.96,13.49 271.96,12.24 271.89,11.84 272.01,11.67 271.94,11.27 271.77,11.14 271.66,10.56 271.9,9.19 271.83,8.75 271.95,8.57 271.88,8.17 271.7,8.05 271.48,6.78 271.48,6.15 271.83,5.8 J5.B23
PE_CPU_TX_DP<3>: length 16.9
  BOTTOM w0.135: J5.B27 267.83,5.8 267.48,6.15 267.48,7.07 267.67,8.15 267.85,8.27 267.92,8.67 267.79,8.85 267.86,9.25 267.63,10.56 267.75,11.25 267.93,11.37 268,11.77 267.88,11.95 267.95,12.34 267.95,13.59 266.98,14.56 266.98,16.03 267.13,16.18 267.13,16.58 266.98,16.74 266.98,18.03 267.12,18.17 267.27,18.24 267.46,18.18 J1.B27
PE_CPU_TX_DP<4>: length 16.9
  BOTTOM w0.135: J5.B33 261.83,5.8 261.48,6.15 261.48,6.94 261.67,8.03 261.85,8.15 261.92,8.55 261.8,8.73 261.87,9.13 261.65,10.37 261.79,11.21 261.97,11.34 262.04,11.73 261.92,11.91 261.99,12.31 261.99,13.37 260.97,14.38 260.97,16.05 261.12,16.21 261.12,16.61 260.97,16.76 260.97,18.02 261.11,18.15 261.28,18.24 261.46,18.18 J1.B33
PE_CPU_TX_DP<5>: length 16.9
  BOTTOM w0.135: J1.B37 257.46,18.18 257.28,18.24 257.11,18.15 257.01,18.06 257.01,16.71 257.16,16.55 257.16,16.15 257.01,16 257.01,14.42 257.96,13.46 257.96,12.36 257.89,11.96 258.02,11.78 257.95,11.39 257.77,11.26 257.61,10.37 257.86,8.94 257.79,8.54 257.92,8.37 257.85,7.97 257.67,7.84 257.48,6.77 257.48,6.15 257.83,5.8 J5.B37
PE_CPU_TX_DP<6>: length 16.9
  BOTTOM w0.135: J1.B41 253.46,18.18 253.28,18.24 253.11,18.15 253.01,18.06 253.01,16.71 253.16,16.55 253.16,16.15 253.01,16 253.01,14.47 253.95,13.53 253.95,12.4 253.88,12 254,11.83 253.93,11.43 253.76,11.31 253.61,10.48 253.83,9.2 253.76,8.8 253.89,8.63 253.82,8.23 253.64,8.11 253.48,7.19 253.48,6.15 253.83,5.8 J5.B41
PE_CPU_TX_DP<7>: length 16.9
  BOTTOM w0.135: J5.B45 249.83,5.8 249.48,6.15 249.48,7.32 249.64,8.23 249.82,8.35 249.89,8.75 249.76,8.92 249.83,9.32 249.62,10.52 249.75,11.28 249.93,11.4 250,11.8 249.88,11.98 249.95,12.38 249.95,13.57 249.01,14.51 249.01,16 249.16,16.15 249.16,16.55 249.01,16.71 249.01,18.06 249.11,18.15 249.28,18.24 249.46,18.18 J1.B45
PE_CPU_TX_DP<8>: length 16.9
  BOTTOM w0.135: J5.B50 244.83,5.8 244.48,6.15 244.48,6.98 244.06,9.35 244.28,10.62 243.96,12.48 243.96,13.29 244.97,14.31 244.97,18.14 244.69,18.43 244.52,18.51 244.46,18.69 J1.B50
PE_CPU_TX_DP<9>: length 16.8
  BOTTOM w0.135: J1.B54 240.46,18.69 240.52,18.51 240.69,18.43 240.93,18.18 240.93,14.41 239.99,13.47 239.99,12.51 240.35,10.51 240.11,9.17 240.48,7.06 240.48,6.15 240.83,5.8 J5.B54
PE_CPU_TX_DP<10>: length 16.8
  BOTTOM w0.135: J1.B58 236.46,18.69 236.52,18.51 236.52,18.51 236.69,18.43 236.96,18.15 236.96,14.2 236.02,13.26 236.02,12.51 236.4,10.35 236.14,8.85 236.48,6.91 236.48,6.15 236.83,5.8 J5.B58
PE_CPU_TX_DP<11>: length 16.9
  BOTTOM w0.135: J1.B62 232.46,18.69 232.52,18.51 232.52,18.51 232.69,18.43 232.97,18.14 232.97,14.48 231.97,13.48 231.97,12.63 232.38,10.32 232.16,9.08 232.48,7.25 232.48,6.15 232.83,5.8 J5.B62
PE_CPU_TX_DP<12>: length 16.9
  BOTTOM w0.135: J5.B66 228.83,5.8 228.48,6.15 228.48,7.77 228.47,7.77 228.16,9.53 228.32,10.42 227.97,12.42 227.97,13.46 228.98,14.48 228.98,18.15 228.73,18.4 228.52,18.51 228.46,18.69 J1.B66
PE_CPU_TX_DP<13>: length 16.9
  BOTTOM w0.135: J1.B70 224.46,18.69 224.52,18.51 224.69,18.43 224.98,18.13 224.98,14.46 223.97,13.45 223.97,12.57 224.35,10.41 224.14,9.22 224.48,7.32 224.48,6.15 224.83,5.8 J5.B70
PE_CPU_TX_DP<14>: length 16.8
  BOTTOM w0.135: J5.B74 220.83,5.8 220.48,6.15 220.48,6.72 220.03,9.24 220.23,10.37 219.93,12.13 219.93,13.26 220.93,14.27 220.93,18.18 220.69,18.43 220.52,18.51 220.46,18.69 J1.B74
PE_CPU_TX_DP<15>: length 16.9
  BOTTOM w0.135: J1.B78 216.46,18.69 216.52,18.51 216.69,18.43 216.99,18.12 216.99,14.35 215.98,13.34 215.98,12.29 216.63,10.34 216.3,8.49 216.48,7.49 216.48,5.9 216.83,5.55 J5.B78
PE_SLOT2_PRES_N: length 261.3
  TOP w0.127: R271.2 v1(59.77,48.64)
  IN2 w0.112: v1(59.77,48.64) 60.99,49.86 61.6,49.86 62.7,50.96 74.54,50.96 74.88,51.31 74.88,51.82 75.22,52.15 118.13,52.15 127.9,61.92 142.54,61.92 161.88,42.58 185.09,42.58 198.18,29.48 283.22,29.48 284.74,31 295.34,31 296.74,32.4 296.74,34.34 J2.A1
PE_SLOT2_RX_DN<0>: length 203.1
  IN3 w0.089: v4(95.36,71.13) 95.03,71.13 94.96,71.2 94.96,71.38 95.13,71.55 98.73,71.55 99,71.28 99,71.21 99.02,71.2
  IN3 w0.135: 99.02,71.2 99.19,71.02 99.88,70.04 100.2,68.23 100.43,67.9 100.39,67.69 100.62,67.36 100.84,67.32 101.07,66.99 101.03,66.77 101.26,66.44 101.48,66.41 101.84,65.88 102.79,65.22 103.84,65.22 104.96,65.42 106.27,65.19 107.6,65.42 109.56,65.08 112.05,65.51 113.65,65.23 115.11,65.49 115.88,65.36 115.99,65.2 116.38,65.13 116.54,65.24 116.94,65.17 117.05,65.01 117.45,64.94 117.61,65.05 119.07,64.79 127.65,66.3 138.31,64.42 148.19,66.17 151.71,65.55 156.6,66.41 200.56,58.65 210.28,51.85 213.88,51.22 215.55,51.51 235.62,47.97 237.74,48.35 241.26,47.73 250.35,49.33 262.6,47.17 267.19,43.95 269.83,43.48 269.94,43.33 270.34,43.25 270.5,43.37 270.9,43.3 271.01,43.14 271.4,43.07 271.56,43.18 271.96,43.11 272.07,42.95 272.47,42.88 272.63,42.99 273.03,42.92 273.14,42.76 273.54,42.69 273.69,42.8 274.09,42.73 274.2,42.57 274.6,42.5 274.76,42.61 275.24,42.53 277.22,41.15 277.71,40.44 277.71,38.98 arc(277.83,38.68) 278.13,38.56 278.4,38.56 arc(278.59,38.48) 278.67,38.29 278.67,34.64 278.55,34.53 278.39,34.44 278.2,34.5 J2.A17
  BOTTOM w0.135: U1.D8 v4(95.36,71.13)
PE_SLOT2_RX_DN<1>: length 202.4
  IN3 w0.089: v4(95.36,70.13) 95.05,70.13 94.94,70.24 94.94,70.36 95.12,70.54 98.64,70.54 99.13,70.05 99.13,69.57 99.08,69.52 99.08,69.5
  IN3 w0.135: J2.A22 273.2,34.01 273.14,34.19 272.93,34.29 272.69,34.54 272.69,38.47 arc(272.82,38.79) 273.14,38.92 273.6,38.92 arc(273.69,38.96) 273.73,39.06 273.73,40.51 273.24,41.22 272.09,42.02 271.69,42.09 271.53,41.98 271.14,42.05 271.03,42.21 270.63,42.28 270.47,42.17 270.07,42.24 269.96,42.4 269.56,42.47 269.4,42.36 269.01,42.43 268.89,42.58 264.92,43.29 264.84,43.4 264.77,43.5 264.67,43.64 264.79,44.33 264.69,44.49 264.32,44.55 264.16,44.44 264.04,43.75 263.69,43.5 260.99,43.98 260.18,44.55 259.82,45.07 259.58,46.42 259.25,46.89 258.85,47.17 250.35,48.67 241.26,47.07 237.74,47.69 235.55,47.3 215.56,50.83 215.52,50.8 215.44,50.81 213.88,50.54 210.06,51.21 205.16,54.64 200.31,58.04 156.64,65.74 151.7,64.86 148.12,65.49 138.31,63.76 127.66,65.64 109.27,62.4 103.13,63.48 100.32,65.45 100.27,65.48 99.56,66.5 99.52,66.57 99.08,67.23 99.08,69.5
  BOTTOM w0.135: U1.D7 v4(95.36,70.13)
PE_SLOT2_RX_DN<2>: length 197.9
  IN3 w0.089: 96.73,64.72 96.73,64.74 96.78,64.79 96.78,69.34 96.6,69.52 95.13,69.52 94.96,69.34 94.96,69.22 95.05,69.13 v4(95.36,69.13)
  IN3 w0.135: 96.73,64.72 96.73,64.47 96.78,64.17 97.1,63.71 98.61,62.65 98.94,62.42 106.08,61.16 127.68,64.97 138.35,63.09 148.19,64.82 151.7,64.2 156.64,65.08 200.06,57.42 209.84,50.57 213.83,49.87 215.44,50.15 235.5,46.61 237.62,46.99 241.09,46.37 250.23,47.99 254.81,47.18 255.27,46.86 255.56,46.44 255.83,44.91 256.16,44.44 256.98,43.86 261.19,43.12 261.3,42.96 261.7,42.89 261.86,43 262.26,42.93 262.37,42.77 262.77,42.7 262.93,42.82 263.32,42.75 263.44,42.59 263.83,42.52 263.99,42.63 264.39,42.56 267.23,42.06 267.28,42.05 268.15,41.89 269.21,41.15 269.69,40.67 269.69,39.03 arc(269.65,38.93) 269.56,38.9 269.12,38.9 arc(268.82,38.77) 268.7,38.47 268.7,34.52 268.93,34.29 269.14,34.19 269.2,34.01 J2.A26
  BOTTOM w0.135: U1.D6 v4(95.36,69.13)
PE_SLOT2_RX_DN<3>: length 195.6
  IN3 w0.089: 95.71,64.7 95.71,64.72 95.76,64.77 95.76,68.4 95.63,68.53 95.14,68.53 94.96,68.34 94.96,68.22 95.05,68.13 v4(95.36,68.13)
  IN3 w0.135: 95.71,64.7 95.71,64.54 95.82,63.91 96.38,63.11 96.73,62.87 98.14,61.88 106.08,60.5 127.69,64.31 138.36,62.43 148.2,64.16 151.7,63.54 156.59,64.41 199.79,56.79 209.54,49.96 213.88,49.2 215.49,49.48 235.56,45.94 237.67,46.32 241.17,45.7 243.81,46.16 244.01,46.02 244.09,45.56 244.44,45.32 245.04,45.42 245.11,45.52 245.29,45.77 245.21,46.21 245.36,46.41 245.61,46.46 245.85,46.29 246.05,45.18 246.42,44.92 246.97,45.02 247.11,45.21 247.11,45.21 247.24,45.4 247.04,46.53 247.23,46.8 250.23,47.33 250.79,47.23 251.3,46.87 251.52,46.55 251.83,44.82 252.23,44.25 253.03,43.69 258.46,42.73 258.47,42.73 258.49,42.73 258.6,42.57 259,42.5 259.16,42.61 259.55,42.54 259.66,42.38 260.06,42.31 260.22,42.42 260.62,42.35 260.74,42.18 261.14,42.11 261.32,42.23 262.15,42.08 263.39,41.21 263.7,40.77 263.7,39.03 arc(263.83,38.73) 264.13,38.61 264.47,38.61 arc(264.64,38.54) 264.71,38.36 264.71,34.51 264.93,34.29 265.14,34.19 265.2,34.01 J2.A30
  BOTTOM w0.135: U1.D5 v4(95.36,68.13)
PE_SLOT2_RX_DN<4>: length 186.2
  IN3 w0.089: v4(93.36,67.13) 93.36,67.45 93.41,67.5 93.62,67.5 93.75,67.36 93.75,63.62 93.7,63.58 93.7,63.55
  IN3 w0.135: 93.7,63.55 93.7,62.82 93.78,62.41 94.62,61.82 100.3,60.82 105.97,59.82 127.68,63.65 138.36,61.76 148.19,63.5 151.69,62.88 156.55,63.74 199.52,56.16 209.31,49.31 213.78,48.52 215.49,48.82 235.61,45.27 236.69,45.46 237.67,45.64 258.27,42.01 259.25,41.32 259.68,40.7 259.68,39.03 arc(259.64,38.93) 259.55,38.9 259.12,38.9 arc(258.82,38.77) 258.69,38.47 258.69,34.53 258.93,34.29 259.14,34.19 259.2,34.01 J2.A36
  BOTTOM w0.135: U1.F4 v4(93.36,67.13)
PE_SLOT2_RX_DN<5>: length 184.4
  IN3 w0.089: v4(92.36,67.13) 92.36,67.45 92.42,67.51 92.61,67.51 92.75,67.36 92.75,62.94 92.7,62.89 92.7,62.87
  IN3 w0.135: 92.7,62.87 92.7,62.41 92.94,62.07 92.98,62.04 94.11,61.25 105.97,59.16 127.57,62.97 138.4,61.06 148.34,62.81 151.8,62.2 156.5,63.03 199.25,55.49 208.93,48.71 213.89,47.84 215.54,48.13 235.7,44.58 237.73,44.93 251.46,42.51 251.57,42.36 251.52,42.05 251.77,41.69 252.26,41.6 252.62,41.86 252.68,42.16 252.85,42.28 253.88,42.1 255.34,41.07 255.75,40.49 255.75,39.03 arc(255.71,38.93) 255.61,38.9 255.13,38.9 arc(254.83,38.77) 254.71,38.47 254.71,34.52 254.93,34.29 255.14,34.19 255.2,34.01 J2.A40
  BOTTOM w0.135: U1.G4 v4(92.36,67.13)
PE_SLOT2_RX_DN<6>: length 180.5
  IN3 w0.089: 91.72,62.87 91.72,62.89 91.77,62.94 91.77,67.34 91.62,67.49 91.41,67.49 91.36,67.45 v4(91.36,67.13)
  IN3 w0.135: 91.72,62.87 91.72,62.64 91.81,62.12 92.09,61.73 93.59,60.68 105.97,58.5 127.49,62.29 138.32,60.38 148.34,62.15 151.89,61.52 156.38,62.31 159.45,61.77 159.5,61.76 159.5,61.76 199.02,54.79 208.57,48.1 213.96,47.15 215.59,47.44 235.7,43.9 237.72,44.25 249.49,42.18 251.33,40.89 251.71,40.35 251.71,39.03 arc(251.67,38.93) 251.57,38.9 251.11,38.9 arc(250.82,38.77) 250.69,38.47 250.69,34.53 250.93,34.29 251.14,34.19 251.2,34.01 J2.A44
  BOTTOM w0.135: U1.H4 v4(91.36,67.13)
PE_SLOT2_RX_DN<7>: length 178.1
  IN3 w0.089: 90.72,63.07 90.72,63.09 90.76,63.14 90.76,67.35 90.6,67.52 90.44,67.52 90.36,67.45 v4(90.36,67.13)
  IN3 w0.135: J2.A48 247.2,34.01 247.14,34.19 246.93,34.29 246.68,34.55 246.68,38.51 arc(246.61,38.66) 246.46,38.73 246.25,38.73 arc(245.87,38.88) 245.72,39.26 245.72,40.38 245.22,41.09 244.51,41.59 243.95,41.69 243.91,41.7 241.88,42.05 241.64,42.4 241.68,42.65 241.57,42.81 241.2,42.87 241.05,42.76 241,42.52 240.65,42.27 240.05,42.38 239.8,42.73 239.85,42.97 239.74,43.13 239.37,43.19 239.21,43.09 239.17,42.84 238.82,42.59 238.14,42.71 237.96,42.97 238.01,43.3 237.91,43.45 237.54,43.52 237.38,43.41 237.38,43.4 237.34,43.16 236.97,42.9 215.29,46.73 213.94,46.49 213.84,46.49 208.34,47.46 208.28,47.47 198.71,54.17 156.33,61.64 151.88,60.86 148.37,61.48 138.33,59.71 127.5,61.63 105.97,57.83 93.04,60.11 91.43,61.24 90.81,62.12 90.72,62.67 90.72,63.07
  BOTTOM w0.135: U1.J4 v4(90.36,67.13)
PE_SLOT2_RX_DN<8>: length 174.3
  IN3 w0.089: 89.72,63.07 89.72,63.09 89.77,63.14 89.77,67.46 89.7,67.54 89.43,67.54 89.36,67.47 v4(89.36,67.13)
  IN3 w0.135: J2.A53 242.2,34.5 242.39,34.44 242.56,34.53 242.67,34.65 242.67,38.44 arc(242.62,38.58) 242.48,38.63 242.1,38.63 arc(241.81,38.76) 241.68,39.06 241.68,40.3 241.4,40.7 239.95,41.72 239.55,41.79 239.39,41.67 239,41.74 238.89,41.9 238.49,41.97 238.33,41.86 237.93,41.93 237.82,42.09 226.61,44.07 215.31,46.06 203.39,43.96 199.45,44.65 188.61,52.24 188.42,52.2 188.09,52.44 188.06,52.63 187.73,52.86 187.54,52.83 187.2,53.06 187.17,53.25 186.84,53.48 186.65,53.45 186.32,53.68 186.28,53.87 182.93,56.22 156.2,60.93 151.97,60.18 148.37,60.82 138.29,59.04 127.46,60.95 106,57.17 92.8,59.49 90.83,60.87 89.72,62.45 89.72,63.07
  BOTTOM w0.135: U1.K4 v4(89.36,67.13)
PE_SLOT2_RX_DN<9>: length 171.9
  IN3 w0.089: 88.73,63.07 88.73,63.1 88.77,63.15 88.77,67.44 88.67,67.54 88.42,67.54 88.36,67.48 v4(88.36,67.13)
  IN3 w0.135: J2.A57 238.2,34.5 238.39,34.44 238.56,34.53 238.69,34.66 238.69,38.44 arc(238.63,38.58) 238.49,38.63 238.07,38.63 arc(237.77,38.76) 237.64,39.06 237.64,40.86 237.59,41.16 237.44,41.38 237.21,41.54 236.58,41.65 235.96,41.76 235.8,41.65 235.4,41.72 235.29,41.88 234.89,41.95 234.73,41.84 234.33,41.91 234.22,42.06 215.32,45.4 203.32,43.28 199.15,44.02 189.47,50.8 188.96,50.89 188.06,51.52 187.86,51.49 187.53,51.72 187.5,51.91 187.17,52.14 186.98,52.11 186.65,52.34 186.61,52.53 186.28,52.76 186.09,52.73 185.76,52.96 185.73,53.15 182.12,55.68 156.21,60.25 152.01,59.51 148.36,60.15 138.27,58.37 127.45,60.28 106.02,56.5 92.49,58.88 90.31,60.41 88.73,62.67 88.73,63.07
  BOTTOM w0.135: U1.L4 v4(88.36,67.13)
PE_SLOT2_RX_DN<10>: length 168.7
  IN3 w0.089: 87.73,63.2 87.73,63.22 87.77,63.27 87.77,67.38 87.6,67.55 87.43,67.55 87.36,67.49 v4(87.36,67.13)
  IN3 w0.135: J2.A61 234.2,34.5 234.39,34.44 234.56,34.53 234.67,34.65 234.67,38.44 arc(234.62,38.56) 234.5,38.61 234.08,38.61 arc(233.78,38.73) 233.66,39.03 233.66,40.45 233.34,40.91 232.09,41.78 231.27,41.92 231.11,41.81 230.72,41.88 230.61,42.04 230.21,42.11 230.05,42 229.65,42.07 229.54,42.23 215.53,44.7 203.49,42.58 198.85,43.39 189.25,50.11 188.06,50.32 187.42,50.77 187.23,50.74 186.9,50.97 186.86,51.16 186.53,51.39 186.34,51.36 186.01,51.59 185.98,51.78 185.65,52.01 185.46,51.98 185.12,52.21 185.09,52.4 181.18,55.14 156.19,59.55 152.11,58.83 148.45,59.47 138.29,57.68 127.42,59.6 105.79,55.79 92.14,58.2 89.8,59.83 87.73,62.79 87.73,63.2
  BOTTOM w0.135: U1.M4 v4(87.36,67.13)
PE_SLOT2_RX_DN<11>: length 166.3
  IN3 w0.089: v4(86.36,67.13) 86.36,67.49 86.42,67.54 86.66,67.54 86.78,67.42 86.78,63.17 86.73,63.12 86.73,63.1
  IN3 w0.135: J2.A65 230.2,34.5 230.39,34.44 230.56,34.53 230.68,34.66 230.68,38.47 arc(230.65,38.57) 230.55,38.61 230.06,38.61 arc(229.77,38.73) 229.64,39.03 229.64,40.88 229.3,41.37 228.96,41.61 228.02,41.78 227.87,41.67 227.47,41.74 227.36,41.9 226.96,41.97 226.8,41.85 226.4,41.92 226.29,42.08 225.89,42.15 225.73,42.04 225.34,42.11 225.23,42.27 224.83,42.34 224.67,42.23 224.27,42.3 224.16,42.46 223.76,42.53 223.6,42.42 223.21,42.49 223.09,42.65 215.45,43.99 203.56,41.9 198.57,42.78 188.96,49.5 187.16,49.82 180.31,54.62 156.14,58.88 152.11,58.17 148.47,58.81 138.32,57.02 127.42,58.94 105.65,55.1 91.78,57.55 89.12,59.41 89.08,59.44 86.8,62.7 86.73,62.8 86.73,63.1
  BOTTOM w0.135: U1.N4 v4(86.36,67.13)
PE_SLOT2_RX_DN<12>: length 163.3
  IN3 w0.089: 85.73,63.17 85.73,63.2 85.77,63.24 85.77,67.41 85.63,67.55 85.43,67.55 85.36,67.49 v4(85.36,67.13)
  IN3 w0.135: 85.73,63.17 85.73,62.9 85.75,62.87 88.48,58.96 88.52,58.93 91.33,56.97 105.65,54.44 127.42,58.28 138.32,56.36 148.47,58.15 152.17,57.5 156.09,58.19 180.08,53.95 186.85,49.22 188.71,48.89 198.32,42.16 199.99,41.86 200.11,41.71 200.5,41.64 200.66,41.75 201.06,41.68 201.17,41.52 201.57,41.45 201.73,41.56 202.13,41.49 202.24,41.33 202.63,41.26 202.79,41.37 203.88,41.18 215.38,43.21 222,42.04 222.11,41.88 222.51,41.81 222.67,41.92 223.07,41.85 223.18,41.69 223.57,41.62 223.73,41.73 225.03,41.51 225.33,41.29 225.68,40.8 225.68,39.19 arc(225.86,38.76) 226.29,38.58 226.54,38.58 arc(226.64,38.54) 226.69,38.43 226.69,34.66 226.55,34.53 226.38,34.44 226.2,34.5 J2.A69
  BOTTOM w0.135: U1.P4 v4(85.36,67.13)
PE_SLOT2_RX_DN<13>: length 165.2
  IN3 w0.089: 84.72,63.13 84.72,63.15 84.77,63.2 84.77,67.34 84.58,67.54 84.45,67.54 84.36,67.45 v4(84.36,67.13)
  IN3 w0.135: J2.A73 222.2,34.5 222.38,34.44 222.51,34.51 222.68,34.67 222.68,38.46 arc(222.62,38.58) 222.5,38.63 222.06,38.63 arc(221.77,38.76) 221.64,39.06 221.64,40.52 221.27,41.04 220.6,41.51 220.2,41.58 220.04,41.47 219.65,41.54 219.54,41.7 219.14,41.77 218.98,41.66 218.58,41.73 218.47,41.89 218.07,41.96 217.91,41.85 217.52,41.92 217.4,42.08 215.06,42.49 203.48,40.45 196.47,41.69 195.03,42.69 194.96,43.11 195.11,43.33 195.13,43.36 195.09,43.55 194.79,43.76 194.6,43.73 194.43,43.48 194.01,43.41 193.51,43.76 193.43,44.18 193.6,44.43 193.57,44.61 193.26,44.83 193.08,44.8 192.9,44.55 192.48,44.48 191.98,44.83 191.91,45.25 192.08,45.5 192.05,45.68 191.74,45.9 191.55,45.86 191.38,45.62 190.96,45.54 190.46,45.9 190.38,46.32 190.55,46.56 190.52,46.75 190.21,46.96 190.03,46.93 189.86,46.69 189.43,46.61 188.93,46.96 188.86,47.38 189.03,47.63 189,47.82 188.69,48.03 188.5,48 188.33,47.75 187.91,47.68 179.83,53.34 156.12,57.52 152.21,56.83 148.52,57.48 138.35,55.69 127.41,57.62 105.65,53.78 90.95,56.37 87.7,58.65 86.73,60.03 86.54,60.06 86.31,60.39 86.34,60.59 86.11,60.92 85.92,60.95 85.69,61.28 85.72,61.47 85.49,61.8 85.3,61.84 85.07,62.17 85.1,62.36 84.75,62.87 84.72,62.9 84.72,63.13
  BOTTOM w0.135: U1.R4 v4(84.36,67.13)
PE_SLOT2_RX_DN<14>: length 157.1
  IN3 w0.089: v4(83.36,67.13) 83.36,67.48 83.45,67.56 83.65,67.56 83.76,67.46 83.76,63.17 83.71,63.12 83.71,63.1
  IN3 w0.135: 83.71,63.1 83.71,62.91 83.74,62.87 86.81,58.48 90.74,55.73 105.7,53.09 127.5,56.93 138.37,55.01 148.51,56.82 152.27,56.16 156.11,56.84 178.49,52.89 178.53,52.86 195.14,41.23 196.98,40.91 197.1,40.75 197.49,40.68 197.65,40.79 198.05,40.72 198.16,40.56 198.56,40.49 198.72,40.6 199.12,40.53 199.23,40.37 199.62,40.3 199.78,40.42 203.46,39.77 212.9,41.43 214.65,41.12 214.76,40.96 215.16,40.89 215.32,41 215.71,40.93 215.83,40.78 216.22,40.71 216.38,40.82 217.25,40.66 217.65,40.09 217.65,39.04 arc(217.79,38.72) 218.11,38.58 218.56,38.58 arc(218.66,38.54) 218.7,38.45 218.7,34.67 218.55,34.53 218.38,34.44 218.2,34.5 J2.A77
  BOTTOM w0.135: U1.T4 v4(83.36,67.13)
PE_SLOT2_RX_DN<15>: length 155.8
  IN3 w0.089: v4(82.36,67.13) 82.36,67.47 82.45,67.55 82.62,67.55 82.77,67.41 82.77,63.09 82.72,63.04 82.72,63.02
  IN3 w0.135: 82.72,63.02 82.72,62.93 82.76,62.87 86.2,57.96 90.2,55.16 105.7,52.43 127.38,56.25 138.27,54.32 148.51,56.13 152.17,55.48 156.01,56.16 178.03,52.27 194.89,40.46 203.42,38.96 203.98,39.09 204.14,38.98 204.54,39.07 204.64,39.24 205.43,39.42 205.61,39.3 205.7,38.78 206.05,38.54 206.65,38.65 206.9,39 206.81,39.51 206.92,39.67 207.93,39.84 208.09,39.73 208.49,39.8 208.6,39.96 209,40.03 209.16,39.92 209.55,39.99 209.66,40.15 210.06,40.22 210.22,40.11 210.62,40.18 210.73,40.34 211.13,40.41 211.29,40.3 211.68,40.37 211.8,40.53 212.96,40.73 213.41,40.65 213.54,40.56 213.66,40.39 213.66,39 arc(213.78,38.71) 214.08,38.58 214.36,38.58 arc(214.58,38.49) 214.67,38.27 214.67,34.66 214.53,34.51 214.39,34.44 214.38,34.44 214.2,34.5 J2.A81
  BOTTOM w0.135: U1.U4 v4(82.36,67.13)
PE_SLOT2_RX_DP<0>: length 203.1
  IN3 w0.089: 99.22,71.4 99.2,71.42 99.14,71.42 98.81,71.74 95.05,71.74 94.77,71.46 94.77,71.24 94.65,71.13 v4(94.36,71.13)
  IN3 w0.135: J2.A16 278.45,34.01 278.51,34.19 278.73,34.29 278.95,34.52 278.95,38.29 arc(278.79,38.68) 278.4,38.84 278.13,38.84 arc(278.04,38.88) 278,38.98 278,40.53 277.42,41.35 275.35,42.8 274.69,42.92 269.88,43.77 267.31,44.22 262.71,47.44 250.35,49.62 241.26,48.02 237.74,48.64 235.62,48.26 215.55,51.8 213.88,51.51 210.39,52.12 200.73,58.89 200.67,58.93 156.6,66.7 151.71,65.84 148.19,66.46 138.31,64.72 127.65,66.6 119.07,65.08 115.11,65.78 113.65,65.52 112.05,65.81 109.56,65.37 107.6,65.71 106.27,65.48 104.96,65.71 103.81,65.51 102.88,65.51 102.05,66.09 100.47,68.34 100.15,70.15 99.52,71.06 99.41,71.21 99.22,71.4
  BOTTOM w0.135: U1.E8 v4(94.36,71.13)
PE_SLOT2_RX_DP<1>: length 202.3
  IN3 w0.089: 99.36,69.5 99.36,69.52 99.32,69.57 99.32,70.13 98.72,70.73 95.04,70.73 94.75,70.44 94.75,70.21 94.67,70.13 v4(94.36,70.13)
  IN3 w0.135: 99.36,69.5 99.36,67.32 99.52,67.08 99.8,66.66 100.48,65.69 103.24,63.76 109.27,62.69 127.66,65.93 138.31,64.05 148.12,65.79 151.7,65.16 156.64,66.03 200.42,58.31 210.17,51.49 213.89,50.83 215.43,51.1 215.45,51.1 215.48,51.13 235.55,47.59 237.74,47.98 241.26,47.36 250.35,48.96 258.97,47.44 259.46,47.09 259.85,46.53 260.09,45.18 260.39,44.75 261.1,44.25 263.62,43.81 263.78,43.92 263.9,44.61 264.25,44.85 264.85,44.75 265.1,44.4 264.98,43.7 265.06,43.59 265.08,43.55 272.2,42.29 273.44,41.43 274.02,40.6 274.02,39.06 arc(273.89,38.76) 273.6,38.63 273.14,38.63 arc(273.02,38.58) 272.98,38.47 272.98,34.65 273.1,34.53 273.27,34.44 273.45,34.5 J2.A21
  BOTTOM w0.135: U1.E7 v4(94.36,70.13)
PE_SLOT2_RX_DP<2>: length 197.8
  IN3 w0.089: 97.01,64.72 97.01,64.74 96.97,64.79 96.97,69.42 96.68,69.71 95.06,69.71 94.77,69.42 94.77,69.28 94.62,69.13 v4(94.36,69.13)
  IN3 w0.135: 97.01,64.72 97.01,64.49 97.05,64.28 97.31,63.91 98.77,62.88 98.79,62.87 99.05,62.69 106.08,61.45 127.68,65.26 138.35,63.38 148.19,65.11 151.7,64.49 156.64,65.37 200.17,57.69 209.95,50.84 213.83,50.16 215.44,50.44 235.5,46.9 237.62,47.28 241.09,46.67 250.23,48.28 254.93,47.45 255.48,47.07 255.83,46.56 256.1,45.03 256.37,44.64 257.1,44.14 267.28,42.34 267.33,42.33 268.27,42.17 269.39,41.38 269.98,40.79 269.98,39.03 arc(269.85,38.73) 269.56,38.61 269.12,38.61 arc(269.03,38.57) 268.99,38.47 268.99,34.64 269.1,34.53 269.27,34.44 269.45,34.5 J2.A25
  BOTTOM w0.135: U1.E6 v4(94.36,69.13)
PE_SLOT2_RX_DP<3>: length 195.5
  IN3 w0.089: v4(94.36,68.13) 94.64,68.13 94.77,68.26 94.77,68.42 95.07,68.72 95.71,68.72 95.95,68.48 95.95,64.77 96,64.72 96,64.7
  IN3 w0.135: J2.A29 265.45,34.5 265.27,34.44 265.1,34.53 265,34.63 265,38.36 arc(264.84,38.74) 264.47,38.9 264.13,38.9 arc(264.03,38.93) 263.99,39.03 263.99,40.86 263.6,41.42 262.26,42.36 261.25,42.53 258.52,43.02 258.51,43.02 253.15,43.96 252.44,44.46 252.1,44.94 251.8,46.66 251.5,47.08 250.91,47.5 250.23,47.62 247.06,47.06 246.74,46.6 246.94,45.47 246.81,45.28 246.49,45.22 246.31,45.35 246.13,46.34 246.11,46.46 245.68,46.76 245.19,46.67 244.91,46.28 244.99,45.84 244.88,45.68 244.51,45.62 244.35,45.73 244.27,46.19 243.87,46.47 241.17,45.99 237.67,46.61 235.56,46.23 215.49,49.77 213.88,49.49 209.65,50.23 199.91,57.06 156.59,64.7 151.7,63.83 148.2,64.45 138.36,62.72 127.69,64.6 106.08,60.79 98.25,62.15 97.23,62.87 97.07,62.98 96.59,63.31 96.09,64.02 96,64.56 96,64.7
  BOTTOM w0.135: U1.E5 v4(94.36,68.13)
PE_SLOT2_RX_DP<4>: length 186.2
  IN3 w0.089: v4(93.36,68.13) 93.36,67.81 93.49,67.69 93.7,67.69 93.94,67.44 93.94,63.62 93.99,63.58 93.99,63.55
  IN3 w0.135: 93.99,63.55 93.99,62.84 94.04,62.57 94.73,62.09 105.97,60.11 127.68,63.94 138.36,62.05 148.19,63.79 151.69,63.17 156.55,64.03 199.64,56.43 209.42,49.58 213.78,48.81 215.49,49.11 235.61,45.56 237.67,45.93 258.38,42.28 259.45,41.53 259.97,40.79 259.97,39.03 arc(259.85,38.73) 259.55,38.61 259.12,38.61 arc(259.02,38.57) 258.98,38.47 258.98,34.65 259.1,34.53 259.27,34.44 259.45,34.5 J2.A35
  BOTTOM w0.135: U1.F5 v4(93.36,68.13)
PE_SLOT2_RX_DP<5>: length 184.4
  IN3 w0.089: v4(92.36,68.13) 92.36,67.78 92.45,67.7 92.69,67.7 92.94,67.44 92.94,62.94 92.99,62.89 92.99,62.87
  IN3 w0.135: J2.A39 255.45,34.5 255.27,34.44 255.1,34.53 254.99,34.64 254.99,38.47 arc(255.03,38.57) 255.13,38.61 255.61,38.61 arc(255.91,38.73) 256.03,39.03 256.03,40.58 255.55,41.28 253.99,42.37 252.78,42.58 252.42,42.33 252.36,42.02 252.19,41.91 251.94,41.95 251.82,42.12 251.87,42.42 251.63,42.77 237.73,45.22 235.7,44.87 215.54,48.42 213.89,48.13 209.04,48.99 199.36,55.76 156.5,63.32 151.8,62.49 148.34,63.1 138.4,61.35 127.57,63.26 105.97,59.45 94.23,61.52 93.15,62.27 92.99,62.5 92.99,62.87
  BOTTOM w0.135: U1.G5 v4(92.36,68.13)
PE_SLOT2_RX_DP<6>: length 180.5
  IN3 w0.089: v4(91.36,68.13) 91.36,67.79 91.47,67.69 91.7,67.69 91.96,67.42 91.96,62.94 92.01,62.89 92.01,62.87
  IN3 w0.135: J2.A43 251.45,34.5 251.27,34.44 251.1,34.53 250.98,34.65 250.98,38.47 arc(251.02,38.57) 251.11,38.61 251.57,38.61 arc(251.87,38.73) 252,39.03 252,40.44 251.54,41.1 249.6,42.45 237.72,44.55 235.7,44.19 215.59,47.73 213.96,47.45 208.69,48.38 199.13,55.07 159.55,62.05 159.55,62.05 159.5,62.05 156.43,62.6 156.38,62.61 151.89,61.81 148.34,62.44 138.32,60.67 127.49,62.58 105.97,58.79 93.7,60.95 92.3,61.93 92.08,62.23 92.01,62.66 92.01,62.87
  BOTTOM w0.135: U1.H5 v4(91.36,68.13)
PE_SLOT2_RX_DP<7>: length 178.1
  IN3 w0.089: v4(90.36,68.13) 90.36,67.78 90.44,67.71 90.67,67.71 90.95,67.43 90.95,63.14 91,63.09 91,63.07
  IN3 w0.135: 91,63.07 91,62.7 91.08,62.24 91.64,61.45 93.15,60.39 105.97,58.13 127.5,61.92 138.33,60 148.37,61.77 151.88,61.15 156.33,61.94 198.82,54.44 203.66,51.06 208.39,47.74 213.87,46.78 213.92,46.78 215.29,47.02 236.9,43.21 237.07,43.33 237.12,43.58 237.47,43.82 238.07,43.71 238.32,43.36 238.26,43.04 238.3,42.98 238.75,42.9 238.91,43.01 238.95,43.25 239.3,43.5 239.9,43.39 240.15,43.04 240.11,42.79 240.22,42.64 240.58,42.57 240.74,42.68 240.78,42.93 241.13,43.17 241.74,43.07 241.98,42.72 241.94,42.47 242.05,42.32 243.96,41.98 244,41.97 244.62,41.86 245.43,41.3 246.01,40.47 246.01,39.26 arc(246.08,39.08) 246.25,39.01 246.46,39.01 arc(246.82,38.87) 246.97,38.51 246.97,34.66 247.1,34.53 247.27,34.44 247.45,34.5 J2.A47
  BOTTOM w0.135: U1.J5 v4(90.36,68.13)
PE_SLOT2_RX_DP<8>: length 174.3
  IN3 w0.089: 90.01,63.07 90.01,63.09 89.96,63.14 89.96,67.54 89.78,67.73 89.47,67.73 89.36,67.83 v4(89.36,68.13)
  IN3 w0.135: 90.01,63.07 90.01,62.54 91.04,61.07 92.91,59.76 106,57.46 127.46,61.24 138.29,59.33 148.37,61.11 151.97,60.48 156.2,61.22 183.05,56.49 188.78,52.47 199.56,44.93 203.39,44.25 215.31,46.35 237.87,42.37 240.06,41.99 241.61,40.9 241.97,40.39 241.97,39.06 arc(242.01,38.96) 242.1,38.92 242.48,38.92 arc(242.82,38.78) 242.96,38.44 242.96,34.53 242.73,34.29 242.51,34.19 242.45,34.01 J2.A52
  BOTTOM w0.135: U1.K5 v4(89.36,68.13)
PE_SLOT2_RX_DP<9>: length 171.9
  IN3 w0.089: v4(88.36,68.13) 88.36,67.81 88.45,67.73 88.75,67.73 88.96,67.51 88.96,63.15 89.01,63.1 89.01,63.07
  IN3 w0.135: 89.01,63.07 89.01,62.76 90.52,60.62 92.6,59.16 106.02,56.79 127.45,60.57 138.27,58.66 148.36,60.44 152.01,59.8 156.21,60.54 182.23,55.95 189.07,51.16 189.58,51.07 199.26,44.29 203.32,43.57 215.32,45.69 237.32,41.81 237.64,41.59 237.86,41.27 237.93,40.88 237.93,39.06 arc(237.97,38.96) 238.07,38.92 238.49,38.92 arc(238.83,38.78) 238.97,38.44 238.97,34.54 238.73,34.29 238.51,34.19 238.45,34.01 J2.A56
  BOTTOM w0.135: U1.L5 v4(88.36,68.13)
PE_SLOT2_RX_DP<10>: length 168.8
  IN3 w0.089: 88.01,63.2 88.01,63.22 87.96,63.27 87.96,67.46 87.68,67.74 87.43,67.74 87.36,67.81 v4(87.36,68.13)
  IN3 w0.135: 88.01,63.2 88.01,62.88 88.03,62.87 90,60.04 92.25,58.47 105.79,56.08 127.42,59.89 138.29,57.97 148.45,59.77 152.11,59.12 156.19,59.84 181.29,55.42 188.17,50.6 189.36,50.38 198.96,43.67 203.49,42.87 215.53,44.99 229.59,42.51 232.2,42.05 233.54,41.11 233.94,40.54 233.94,39.03 arc(233.98,38.93) 234.08,38.9 234.5,38.9 arc(234.83,38.76) 234.96,38.44 234.96,34.53 234.73,34.29 234.51,34.19 234.45,34.01 J2.A60
  BOTTOM w0.135: U1.M5 v4(87.36,68.13)
PE_SLOT2_RX_DP<11>: length 166.3
  IN3 w0.089: v4(86.36,68.13) 86.36,67.81 86.45,67.73 86.73,67.73 86.97,67.5 86.97,63.17 87.02,63.12 87.02,63.1
  IN3 w0.135: 87.02,63.1 87.02,62.89 87.03,62.87 89.29,59.65 91.9,57.82 105.65,55.39 127.42,59.23 138.32,57.31 148.47,59.1 152.11,58.46 156.14,59.17 180.42,54.89 187.27,50.09 189.08,49.78 198.68,43.05 203.56,42.19 215.45,44.29 223.14,42.93 229.07,41.89 229.51,41.58 229.93,40.97 229.93,39.03 arc(229.97,38.93) 230.06,38.9 230.55,38.9 arc(230.85,38.77) 230.97,38.47 230.97,34.54 230.73,34.29 230.51,34.19 230.45,34.01 J2.A64
  BOTTOM w0.135: U1.N5 v4(86.36,68.13)
PE_SLOT2_RX_DP<12>: length 163.3
  IN3 w0.089: 86.01,63.17 86.01,63.2 85.96,63.24 85.96,67.49 85.71,67.74 85.44,67.74 85.36,67.81 v4(85.36,68.13)
  IN3 w0.135: 86.01,63.17 86.01,62.99 86.1,62.87 88.69,59.17 91.44,57.24 105.65,54.73 127.42,58.57 138.32,56.65 148.47,58.44 152.17,57.79 156.09,58.48 180.19,54.23 186.96,49.49 188.82,49.16 198.43,42.43 203.88,41.47 215.38,43.5 222.05,42.32 222.05,42.32 225.14,41.78 225.54,41.5 225.97,40.89 225.97,39.19 arc(226.06,38.96) 226.29,38.87 226.54,38.87 arc(226.85,38.74) 226.98,38.43 226.98,34.54 226.72,34.29 226.51,34.19 226.45,34.01 J2.A68
  BOTTOM w0.135: U1.P5 v4(85.36,68.13)
PE_SLOT2_RX_DP<13>: length 165.2
  IN3 w0.089: 85.01,63.13 85.01,63.15 84.96,63.2 84.96,67.42 84.66,67.73 84.45,67.73 84.36,67.81 v4(84.36,68.13)
  IN3 w0.135: 85.01,63.13 85.01,62.99 85.1,62.87 87.9,58.86 91.07,56.64 105.65,54.07 127.41,57.91 138.35,55.98 148.52,57.77 152.21,57.12 156.12,57.81 179.94,53.61 187.98,47.98 188.16,48.02 188.34,48.26 188.76,48.34 189.26,47.98 189.33,47.56 189.16,47.32 189.2,47.13 189.5,46.92 189.69,46.95 189.86,47.19 190.28,47.27 190.78,46.92 190.86,46.5 190.69,46.25 190.72,46.06 191.03,45.85 191.21,45.88 191.39,46.13 191.81,46.2 192.31,45.85 192.38,45.43 192.21,45.18 192.24,44.99 192.55,44.78 192.74,44.81 192.91,45.06 193.33,45.13 193.83,44.78 193.91,44.36 193.73,44.11 193.77,43.93 194.07,43.71 194.26,43.75 194.43,43.99 194.85,44.07 195.36,43.71 195.43,43.29 195.35,43.17 195.34,43.17 195.26,43.05 195.29,42.86 196.58,41.96 203.48,40.74 215.06,42.78 220.71,41.79 221.48,41.25 221.93,40.61 221.93,39.06 arc(221.97,38.96) 222.06,38.92 222.5,38.92 arc(222.83,38.78) 222.96,38.46 222.96,34.55 222.68,34.27 222.51,34.19 222.51,34.19 222.45,34.01 J2.A72
  BOTTOM w0.135: U1.R5 v4(84.36,68.13)
PE_SLOT2_RX_DP<14>: length 157.1
  IN3 w0.089: v4(83.36,68.13) 83.36,67.85 83.46,67.75 83.73,67.75 83.95,67.54 83.95,63.17 84,63.12 84,63.1
  IN3 w0.135: J2.A76 218.45,34.01 218.51,34.19 218.72,34.29 218.98,34.55 218.98,38.45 arc(218.86,38.75) 218.56,38.87 218.11,38.87 arc(217.99,38.92) 217.94,39.04 217.94,40.28 217.69,40.54 217.42,40.93 212.9,41.72 203.46,40.06 195.26,41.51 178.65,53.14 178.62,53.16 156.11,57.13 152.27,56.45 148.51,57.11 138.37,55.3 127.5,57.22 105.7,53.38 90.86,56 87.02,58.69 84.09,62.87 84,63 84,63.1
  BOTTOM w0.135: U1.T5 v4(83.36,68.13)
PE_SLOT2_RX_DP<15>: length 155.8
  IN3 w0.089: 83,63.02 83,63.04 82.96,63.09 82.96,67.49 82.7,67.74 82.43,67.74 82.36,67.81 v4(82.36,68.13)
  IN3 w0.135: J2.A80 214.45,34.01 214.51,34.19 214.7,34.28 214.96,34.54 214.96,38.27 arc(214.79,38.69) 214.36,38.87 214.08,38.87 arc(213.99,38.91) 213.95,39 213.95,40.48 213.75,40.77 213.53,40.92 212.96,41.02 206.75,39.93 206.5,39.58 206.59,39.06 206.48,38.91 206.12,38.84 205.96,38.95 205.87,39.47 205.49,39.73 203.42,39.25 195.01,40.74 178.14,52.55 156.01,56.45 152.17,55.77 148.51,56.42 138.27,54.61 127.38,56.54 105.7,52.72 90.31,55.43 86.4,58.17 83.11,62.87 83,63.02
  BOTTOM w0.135: U1.U5 v4(82.36,68.13)
PE_SLOT2_TX_C_DN<0>: length 194.3
  IN1 w0.089: v4(98.36,71.13) 98.09,71.13 98.01,71.21 98.01,71.51 98.2,71.7 98.22,71.72 98.96,71.85 99.08,71.83 99.2,71.81 99.24,71.75 99.26,71.75
  IN1 w0.122: 99.26,71.75 99.62,71.68 99.75,71.51 100.11,71.44 100.29,71.57 100.65,71.5 100.77,71.33 101.13,71.26 101.31,71.39 102.88,71.11 102.88,71.11 103.24,70.86 103.28,70.64 103.58,70.43 103.79,70.47 104.09,70.26 104.13,70.05 104.43,69.84 104.64,69.87 105.44,69.31 106.8,69.07 107.58,68.53 108.23,67.6 108.89,67.14 110.04,66.94 110.56,66.57 110.77,66.27 110.73,66.06 110.94,65.76 111.15,65.72 111.36,65.42 111.33,65.21 111.53,64.91 111.75,64.87 112.3,64.08 112.81,63.73 119.55,62.54 142.59,66.59 148.9,65.48 155.38,66.62 197.8,59.14 198.38,58.73 198.4,58.72 199.17,58.18 200.85,57 204.77,56.31 211.42,51.65 218.52,50.4 222.73,51.14 224.64,50.81 226.72,51.17 229.04,50.77 230.79,51.07 232.82,50.72 235.1,51.12 237.5,50.69 240.68,51.26 243.02,50.84 245.65,51.31 247.19,51.04 249.28,51.41 251.12,51.08 253.55,51.51 279.35,46.96 279.65,46.75 279.69,46.56 279.69,46.34 v1(279.33,45.97)
  BOTTOM w0.135: v1(279.33,45.97) 279.68,45.62 279.68,44.82 C31.1 ; U1.A8 v4(98.36,71.13)
