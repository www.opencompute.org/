# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
85OHM_BOT_10INCH_DP: length 254
  BOTTOM w0.135: U43.2 -14.94,9.77 -14.94,12.62 -14.35,13.46 -13.48,13.62 -10.29,13.06 -10.16,13.14 -10.05,13.78 -10.17,13.95 -17.32,15.21 -17.64,15.67 -17.51,16.4 -17.08,16.7 -8.83,15.24 -8.68,15.34 -8.57,15.98 -8.67,16.12 -17.6,17.7 -17.86,18.07 -17.71,18.91 -17.33,19.18 -8.84,17.68 -8.67,17.8 -8.57,18.36 -8.72,18.57 -17.42,20.11 -17.7,20.51 -17.56,21.33 -17.17,21.6 -8.78,20.12 -8.57,20.26 -8.48,20.73 -8.63,21.02 -17.73,22.62 -18.03,23.05 -17.92,23.71 -17.9,23.84 -17.52,24.1 -8.51,22.51 -8.32,22.64 -8.21,23.23 -8.32,23.39 -17.67,25.03 -17.95,25.43 -17.85,26.21 -17.45,26.53 -8.61,24.97 -8.4,25.12 -8.3,25.69 -8.41,25.84 -17.56,27.48 -17.84,27.87 -17.72,28.57 -17.7,28.69 -17.33,28.95 -8.32,27.36 -8.15,27.48 -8.05,28.05 -8.18,28.25 -17.73,29.93 -18,30.3 -17.85,31.14 -17.46,31.41 -8.3,29.8 -8.1,29.93 -8.01,30.48 -8.15,30.68 -17.67,32.36 -17.92,32.72 -17.77,33.58 -17.39,33.84 -8.25,32.23 -8.07,32.36 -7.97,32.93 -8.1,33.12 -17.61,34.79 -17.9,35.21 -17.75,36.04 -17.4,36.28 -8.34,34.69 -8.07,34.87 -7.99,35.35 -8.13,35.56 -17.61,37.23 -17.88,37.62 -17.72,38.45 -17.33,38.71 -8.03,37.07 -7.81,37.23 -7.73,37.69 -7.93,37.97 -17.76,39.7 -18.03,40.1 -17.97,40.49 -17.9,40.88 -17.46,41.18 -7.85,39.48 -7.64,39.63 -7.55,40.15 -7.7,40.37 -15.02,41.66 -15.27,42.02 -15.06,43.23 -15.06,45.46 U45.1
85OHM_L1_5INCH_DN: length 127
  IN1 w0.122: v1(-6.85,319.85) -7.09,320.08 -7.09,320.87 -7.31,322.13 -8.03,323.15 -12.52,323.94 -12.71,324.2 -12.63,324.65 -12.38,324.82 -4.26,323.38 -3.91,323.63 -3.76,324.48 -4.01,324.83 -12.42,326.32 -12.59,326.55 -12.5,327.07 -12.32,327.19 -5.91,326.06 -4.23,325.77 -3.87,326.02 -3.72,326.85 -3.98,327.22 -5.18,327.43 -13.01,328.81 -13.17,329.04 -13.13,329.29 -13.13,329.29 -13.08,329.53 -12.87,329.68 -6.3,328.52 -5.23,328.34 -4.87,328.59 -4.73,329.42 -4.98,329.78 -6.01,329.96 -6.18,329.99 -13.03,331.2 -13.17,331.4 -13.07,331.94 -12.88,332.07 -4.51,330.6 -4.17,330.84 -4.02,331.66 -4.3,332.05 -12.94,333.58 -13.09,333.79 -13.01,334.27 -12.77,334.44 -8.67,333.72 -4.33,332.96 -3.88,333.27 -3.76,333.96 -4.07,334.4 -12.89,335.96 -13,336.1 -12.89,336.69 -12.71,336.82 -4.25,335.33 -3.98,335.52 -3.88,335.59 -3.73,336.43 -3.98,336.77 -7.41,337.38 -7.51,337.52 -7.4,338.18 -7.4,339.74 v1(-7.16,339.98)
  BOTTOM w0.135: v1(-7.16,339.98) -7.39,340.21 -7.39,340.62 U27.2 ; U23.1 -7.08,319.21 -7.08,319.62 v1(-6.85,319.85)
85OHM_L1_5INCH_DP: length 127
  IN1 w0.122: v1(-7.92,339.98) -7.69,339.74 -7.69,338.21 -7.82,337.45 -7.58,337.11 -4.15,336.51 -4.04,336.36 -4.15,335.76 -4.19,335.73 -4.32,335.64 -12.77,337.13 -13.16,336.86 -13.3,336.03 -13.06,335.69 -4.24,334.13 -4.07,333.89 -4.15,333.44 -4.4,333.26 -12.83,334.75 -13.28,334.44 -13.4,333.72 -13.11,333.31 -4.47,331.78 -4.33,331.59 -4.43,331.01 -4.58,330.91 -12.95,332.38 -13.34,332.11 -13.48,331.33 -13.2,330.94 -6.06,329.68 -6.06,329.68 -5.64,329.6 -5.15,329.51 -5.04,329.35 -5.14,328.76 -5.3,328.64 -6.18,328.8 -12.94,329.99 -13.35,329.7 -13.48,328.97 -13.18,328.54 -5.18,327.13 -4.15,326.95 -4.03,326.78 -4.14,326.19 -4.3,326.08 -5.07,326.21 -12.39,327.5 -12.76,327.24 -12.9,326.48 -12.59,326.05 -4.18,324.56 -4.07,324.41 -4.17,323.8 -4.33,323.69 -12.45,325.13 -12.89,324.81 -13.01,324.13 -12.69,323.68 -8.2,322.88 -7.59,322.01 -7.38,320.85 -7.38,320.08 v1(-7.61,319.85)
  BOTTOM w0.135: U23.2 -7.38,319.21 -7.38,319.61 v1(-7.61,319.85) ; v1(-7.92,339.98) -7.7,340.2 -7.7,340.62 U27.1
85OHM_L1_10INCH_DN: length 254
  IN1 w0.122: v1(-8.18,129.79) -7.94,130.03 -7.94,130.8 -8.15,131.96 -8.76,132.83 -13.26,133.62 -13.58,134.08 -13.46,134.76 -13.01,135.07 -4.89,133.64 -4.74,133.75 -4.63,134.36 -4.74,134.51 -13.15,136 -13.46,136.43 -13.33,137.19 -12.95,137.45 -4.86,136.03 -4.7,136.14 -4.6,136.73 -4.71,136.9 -13.74,138.49 -14.04,138.92 -13.91,139.65 -13.5,139.94 -4.82,138.41 -4.64,138.53 -4.54,139.08 -4.68,139.28 -13.89,140.91 -14.2,141.36 -14.08,142.07 -13.66,142.36 -4.77,140.79 -4.58,140.93 -4.49,141.45 -4.64,141.66 -4.64,141.66 -13.71,143.26 -14.04,143.74 -13.93,144.38 -13.45,144.71 -4.7,143.17 -4.55,143.27 -4.45,143.85 -4.59,144.05 -13.73,145.66 -13.88,145.87 -14.03,146.08 -13.97,146.43 -13.9,146.77 -13.44,147.1 -4.66,145.55 -4.51,145.65 -4.41,146.22 -4.55,146.43 -13.61,148.02 -13.77,148.25 -13.77,148.25 -13.93,148.49 -13.8,149.23 -13.44,149.49 -4.75,147.96 -4.56,148.09 -4.48,148.59 -4.65,148.84 -13.46,150.39 -13.74,150.79 -13.6,151.55 -13.19,151.83 -8.92,151.08 -4.88,150.37 -4.61,150.55 -4.52,151.04 -4.65,151.23 -13.42,152.77 -13.74,153.22 -13.61,153.96 -13.22,154.23 -4.66,152.72 -4.52,152.82 -4.41,153.44 -4.52,153.59 -13.46,155.17 -13.73,155.56 -13.59,156.34 -13.2,156.61 -4.59,155.09 -4.41,155.22 -4.31,155.8 -4.43,155.96 -13.34,157.54 -13.65,157.98 -13.53,158.68 -13.09,158.98 -4.66,157.5 -4.41,157.67 -4.33,158.12 -4.5,158.37 -13.32,159.92 -13.56,160.27 -13.41,161.09 -13.03,161.36 -4.57,159.87 -4.44,159.96 -4.4,159.99 -4.3,160.59 -4.4,160.74 -7.84,161.34 -8.08,161.68 -7.94,162.44 -7.94,163.98 v1(-8.18,164.21)
  BOTTOM w0.135: U31.1 -7.95,164.85 -7.95,164.44 v1(-8.18,164.21) ; v1(-8.18,129.79) -7.94,129.56 -7.94,129.16 U35.2
85OHM_L1_10INCH_DP: length 254
  IN1 w0.122: v1(-7.42,129.79) -7.65,130.03 -7.65,130.82 -7.87,132.08 -8.59,133.1 -13.09,133.89 -13.27,134.15 -13.19,134.59 -12.94,134.76 -4.82,133.33 -4.47,133.58 -4.32,134.42 -4.57,134.78 -12.98,136.26 -13.15,136.5 -13.06,137.02 -12.88,137.14 -4.79,135.72 -4.43,135.97 -4.29,136.8 -4.54,137.16 -13.57,138.76 -13.73,138.99 -13.69,139.24 -13.65,139.48 -13.44,139.63 -4.75,138.1 -4.56,138.23 -4.38,138.36 -4.23,139.15 -4.51,139.55 -13.72,141.17 -13.9,141.43 -13.81,141.9 -13.6,142.05 -4.71,140.48 -4.31,140.76 -4.18,141.52 -4.4,141.83 -4.4,141.83 -4.47,141.93 -13.54,143.53 -13.73,143.81 -13.66,144.2 -13.38,144.4 -4.63,142.86 -4.28,143.1 -4.14,143.92 -4.42,144.31 -13.56,145.92 -13.72,146.15 -13.64,146.6 -13.38,146.79 -4.59,145.24 -4.24,145.48 -4.1,146.29 -4.38,146.7 -13.44,148.29 -13.53,148.42 -13.63,148.55 -13.58,148.81 -13.54,149.06 -13.37,149.18 -4.69,147.65 -4.3,147.92 -4.17,148.66 -4.48,149.1 -13.29,150.65 -13.43,150.85 -13.34,151.38 -13.13,151.52 -4.81,150.06 -4.34,150.38 -4.21,151.11 -4.48,151.49 -13.25,153.04 -13.43,153.29 -13.34,153.79 -13.16,153.92 -4.59,152.41 -4.25,152.65 -4.1,153.5 -4.35,153.86 -13.29,155.43 -13.42,155.63 -13.33,156.17 -13.13,156.3 -4.52,154.79 -4.15,155.04 -4,155.86 -4.26,156.23 -13.17,157.8 -13.34,158.05 -13.26,158.5 -13.02,158.67 -4.59,157.19 -4.14,157.5 -4.02,158.19 -4.33,158.63 -13.15,160.19 -13.25,160.34 -13.15,160.92 -12.96,161.05 -4.5,159.56 -4.13,159.82 -3.99,160.66 -4.23,161.01 -7.67,161.61 -7.77,161.75 -7.65,162.41 -7.65,163.98 v1(-7.42,164.21)
  BOTTOM w0.135: v1(-7.42,164.21) -7.65,164.44 -7.65,164.85 U31.2 ; U35.1 -7.64,129.16 -7.64,129.57 v1(-7.42,129.79)
85OHM_L3_5INCH_DN: length 127
  TOP w0.135: U25.1 -7.39,279.02 -7.39,278.61 v1(-7.16,278.38) ; U29.2 -7.39,257.76 -7.39,258.17 v1(-7.16,258.4)
  IN3 w0.135: v1(-7.16,258.4) -7.4,258.64 -7.4,259.51 -7.16,260.85 -7.41,261.2 -14.12,262.39 -14.27,262.6 -14.18,263.12 -13.97,263.27 -5.12,261.71 -4.64,262.04 -4.52,262.73 -4.82,263.15 -14.23,264.81 -14.4,265.05 -14.3,265.61 -14.15,265.71 -7.01,264.45 -5.11,264.12 -4.69,264.41 -4.57,265.15 -4.86,265.57 -13.15,267.03 -13.25,267.18 -13.15,267.77 -12.96,267.91 -4.98,266.5 -4.56,266.8 -4.43,267.53 -4.73,267.95 -12.55,269.33 -12.73,269.58 -12.65,270.02 -12.52,270.11 -12.38,270.21 -5.09,268.92 -4.64,269.24 -4.51,269.96 -4.8,270.37 -12.87,271.79 -13.08,272.09 -13,272.54 -12.79,272.69 -5.03,271.32 -4.58,271.64 -4.56,271.76 -4.46,272.31 -4.78,272.77 -13.36,274.28 -13.5,274.48 -13.41,274.96 -13.13,275.16 -4.96,273.71 -4.62,273.95 -4.47,274.8 -4.73,275.17 -4.84,275.19 -4.84,275.19 -6.31,275.45 -6.89,275.85 -7.4,276.57 -7.4,278.15 v1(-7.16,278.38)
85OHM_L3_5INCH_DP: length 127
  TOP w0.135: v1(-7.92,258.4) -7.69,258.17 -7.69,257.77 U29.1 ; v1(-7.92,278.38) -7.69,278.62 -7.69,279.02 U25.2
  IN3 w0.135: v1(-7.92,278.38) -7.69,278.15 -7.69,276.48 -7.1,275.64 -6.42,275.17 -4.89,274.9 -4.77,274.73 -4.88,274.12 -5.03,274.02 -13.22,275.46 -13.67,275.14 -13.78,274.53 -13.8,274.42 -13.73,274.32 -13.52,274.02 -4.95,272.51 -4.76,272.24 -4.84,271.81 -5.1,271.62 -12.85,272.99 -13.26,272.71 -13.38,272.02 -13.21,271.78 -13.04,271.53 -4.97,270.11 -4.82,269.89 -4.9,269.4 -5.15,269.23 -12.45,270.51 -12.91,270.18 -13.03,269.52 -12.72,269.07 -4.9,267.69 -4.74,267.46 -4.82,266.96 -5.05,266.8 -13.02,268.21 -13.41,267.94 -13.56,267.11 -13.32,266.77 -5.03,265.31 -4.87,265.08 -4.96,264.58 -5.18,264.42 -7.01,264.74 -14.22,266.01 -14.56,265.77 -14.7,264.99 -14.4,264.55 -4.98,262.89 -4.82,262.66 -4.9,262.21 -5.18,262.02 -14.03,263.58 -14.44,263.29 -14.57,262.53 -14.29,262.13 -7.57,260.94 -7.46,260.79 -7.69,259.53 -7.69,258.64 v1(-7.92,258.4)
85OHM_L3_10INCH_DN: length 254
  TOP w0.135: U33.1 -7.95,71.37 -7.95,71.78 v1(-8.18,72.01) ; v1(-8.18,106.43) -7.94,106.66 -7.94,107.06 U37.2
  IN3 w0.135: v1(-8.18,72.01) -7.94,72.25 -7.94,73.14 -7.72,74.4 -7.83,74.55 -14.54,75.74 -14.83,76.14 -14.69,76.9 -14.29,77.19 -5.44,75.63 -5.16,75.82 -5.08,76.27 -5.24,76.5 -14.65,78.16 -14.95,78.6 -14.81,79.38 -14.47,79.62 -5.44,78.03 -5.21,78.19 -5.12,78.69 -5.28,78.91 -14.67,80.57 -14.93,80.95 -14.78,81.78 -14.44,82.02 -5.4,80.43 -5.21,80.56 -5.11,81.09 -5.28,81.33 -14.45,82.95 -14.72,83.32 -14.57,84.15 -14.23,84.39 -5.43,82.84 -5.28,82.94 -5.23,83.21 -5.18,83.48 -5.37,83.74 -14.32,85.32 -14.59,85.7 -14.44,86.52 -14.08,86.77 -5.4,85.24 -5.26,85.35 -5.22,85.57 -5.15,85.93 -5.29,86.13 -14.26,87.71 -14.56,88.14 -14.43,88.89 -14.03,89.17 -5.36,87.64 -5.15,87.79 -5.06,88.27 -5.24,88.53 -14.16,90.1 -14.45,90.52 -14.33,91.25 -13.9,91.55 -5.35,90.04 -5.16,90.18 -5.07,90.72 -5.22,90.93 -13.94,92.47 -14.22,92.87 -14.08,93.66 -13.71,93.92 -5.34,92.45 -5.12,92.6 -5.03,93.15 -5.15,93.32 -13.76,94.84 -14.05,95.26 -13.92,96 -13.51,96.29 -5.31,94.85 -5.13,94.98 -5.03,95.54 -5.16,95.73 -13.45,97.19 -13.79,97.69 -13.67,98.35 -13.25,98.65 -5.41,97.27 -5.16,97.45 -5.07,97.93 -5.22,98.15 -13.69,99.64 -14.04,100.14 -13.92,100.82 -13.52,101.11 -5.35,99.67 -5.09,99.85 -5.02,100.28 -5.2,100.55 -13.78,102.06 -14.06,102.46 -13.93,103.19 -13.74,103.32 -13.47,103.5 -5.28,102.06 -5.14,102.16 -5.03,102.78 -5.15,102.95 -6.68,103.22 -7.35,103.69 -7.94,104.53 -7.94,106.19 v1(-8.18,106.43)
85OHM_L3_10INCH_DP: length 254
  TOP w0.135: U37.1 -7.64,107.06 -7.64,106.65 v1(-7.42,106.43) ; U33.2 -7.65,71.37 -7.65,71.78 v1(-7.42,72.01)
  IN3 w0.135: v1(-7.42,72.01) -7.65,72.25 -7.65,73.12 -7.41,74.46 -7.66,74.81 -14.38,76 -14.52,76.21 -14.43,76.73 -14.22,76.88 -5.37,75.32 -4.9,75.65 -4.78,76.34 -5.07,76.76 -14.48,78.42 -14.65,78.66 -14.55,79.22 -14.4,79.32 -5.37,77.73 -4.95,78.02 -4.82,78.75 -5.11,79.18 -14.5,80.83 -14.63,81.01 -14.52,81.61 -14.37,81.72 -5.33,80.13 -4.94,80.4 -4.81,81.16 -5.11,81.59 -14.29,83.21 -14.41,83.39 -14.31,83.98 -14.16,84.09 -5.36,82.54 -5.02,82.78 -4.88,83.55 -5.2,84 -14.15,85.58 -14.28,85.77 -14.18,86.35 -14.01,86.47 -5.34,84.94 -4.99,85.18 -4.85,86 -5.12,86.39 -14.09,87.98 -14.26,88.21 -14.17,88.72 -13.97,88.86 -5.3,87.34 -4.88,87.62 -4.76,88.34 -5.08,88.79 -13.99,90.37 -14.15,90.59 -14.07,91.08 -13.83,91.25 -5.29,89.74 -4.9,90.01 -4.76,90.79 -5.05,91.19 -13.77,92.73 -13.92,92.94 -13.82,93.49 -13.64,93.62 -5.27,92.14 -4.86,92.43 -4.72,93.21 -4.99,93.59 -13.59,95.1 -13.74,95.33 -13.65,95.84 -13.44,95.99 -5.24,94.54 -4.86,94.81 -4.72,95.61 -4.99,95.99 -13.28,97.45 -13.49,97.75 -13.41,98.19 -13.19,98.35 -5.34,96.97 -4.9,97.28 -4.88,97.4 -4.77,98 -5.06,98.41 -13.53,99.9 -13.74,100.21 -13.66,100.66 -13.45,100.8 -5.29,99.36 -4.83,99.68 -4.81,99.8 -4.71,100.35 -5.04,100.81 -13.61,102.32 -13.75,102.53 -13.67,103.02 -13.4,103.2 -5.22,101.76 -4.87,102 -4.72,102.84 -4.98,103.21 -5.1,103.23 -5.1,103.23 -6.57,103.49 -7.15,103.89 -7.65,104.62 -7.65,106.19 v1(-7.42,106.43)
85OHM_TOP_5INCH_DN: length 127
  TOP w0.135: U26.2 -14.93,340.62 -14.93,338.38 -15.14,337.17 -14.89,336.81 -7.57,335.52 -7.42,335.3 -7.51,334.78 -7.72,334.63 -17.34,336.33 -17.77,336.02 -17.91,335.24 -17.77,335.05 -17.63,334.85 -7.63,333.09 -7.4,332.76 -7.48,332.3 -7.66,332.18 -17.21,333.86 -17.6,333.6 -17.75,332.76 -17.48,332.38 -7.91,330.69 -7.7,330.39 -7.79,329.89 -7.93,329.79 -17.05,331.39 -17.43,331.13 -17.58,330.31 -17.29,329.91 -8.27,328.32 -8.09,328.05 -8.18,327.52 -8.33,327.41 -17.2,328.98 -17.59,328.71 -17.74,327.87 -17.47,327.5 -8.54,325.92 -8.44,325.77 -8.55,325.14 -8.7,325.04 -16.96,326.49 -17.38,326.2 -17.51,325.47 -17.19,325.01 -10.04,323.74 -9.92,323.57 -10.04,322.94 -10.16,322.85 -13.35,323.42 -14.22,323.26 -14.81,322.42 -14.81,319.58 U5.1
85OHM_TOP_5INCH_DP: length 127
  TOP w0.135: U5.2 -14.51,319.58 -14.51,322.33 -14.04,322.98 -13.35,323.11 -10.09,322.53 -9.86,322.69 -9.76,322.76 -9.6,323.65 -9.87,324.02 -17.01,325.28 -17.19,325.54 -17.1,326.02 -16.89,326.17 -8.63,324.72 -8.27,324.96 -8.12,325.85 -8.37,326.2 -17.3,327.78 -17.41,327.94 -17.31,328.53 -17.13,328.66 -8.26,327.09 -7.9,327.34 -7.77,328.13 -8.09,328.59 -17.12,330.19 -17.25,330.38 -17.2,330.66 -17.15,330.95 -16.98,331.07 -7.86,329.46 -7.69,329.59 -7.68,329.59 -7.51,329.71 -7.38,330.46 -7.56,330.72 -7.74,330.97 -17.31,332.66 -17.43,332.83 -17.37,333.13 -17.32,333.42 -17.14,333.54 -7.58,331.86 -7.2,332.12 -7.08,332.83 -7.45,333.36 -17.45,335.13 -17.59,335.32 -17.49,335.85 -17.27,336 -7.65,334.31 -7.23,334.61 -7.1,335.37 -7.39,335.79 -14.71,337.09 -14.82,337.24 -14.63,338.35 -14.63,340.62 U26.1
85OHM_TOP_10INCH_DN: length 254
  TOP w0.135: U30.1 -14.81,129.16 -14.81,132 -14.22,132.84 -13.35,133 -10.16,132.44 -10.04,132.52 -9.92,133.16 -10.04,133.33 -17.19,134.59 -17.51,135.05 -17.38,135.78 -16.96,136.08 -8.7,134.62 -8.55,134.72 -8.44,135.36 -8.54,135.5 -17.47,137.08 -17.74,137.45 -17.59,138.29 -17.2,138.56 -8.71,137.06 -8.54,137.18 -8.44,137.74 -8.59,137.95 -17.29,139.49 -17.58,139.89 -17.43,140.71 -17.05,140.98 -8.65,139.5 -8.44,139.64 -8.36,140.11 -8.5,140.4 -17.6,142 -17.91,142.43 -17.79,143.09 -17.77,143.22 -17.39,143.48 -8.38,141.89 -8.19,142.02 -8.09,142.61 -8.2,142.77 -17.54,144.41 -17.83,144.81 -17.72,145.59 -17.32,145.91 -8.49,144.35 -8.27,144.5 -8.17,145.07 -8.28,145.22 -17.44,146.86 -17.71,147.25 -17.59,147.95 -17.57,148.07 -17.2,148.33 -8.2,146.74 -8.02,146.86 -7.92,147.43 -8.06,147.63 -17.61,149.31 -17.87,149.68 -17.72,150.52 -17.33,150.79 -8.17,149.18 -7.98,149.31 -7.88,149.86 -8.02,150.06 -17.54,151.74 -17.79,152.1 -17.64,152.96 -17.27,153.22 -8.12,151.61 -7.94,151.74 -7.84,152.31 -7.98,152.5 -17.48,154.17 -17.77,154.59 -17.63,155.42 -17.27,155.66 -8.21,154.07 -7.95,154.25 -7.86,154.73 -8.01,154.94 -17.48,156.61 -17.75,157 -17.6,157.83 -17.21,158.09 -7.9,156.45 -7.68,156.61 -7.6,157.07 -7.8,157.35 -17.63,159.08 -17.91,159.48 -17.84,159.87 -17.77,160.26 -17.34,160.56 -7.72,158.86 -7.51,159.01 -7.42,159.53 -7.57,159.75 -14.89,161.04 -15.14,161.4 -14.93,162.61 -14.93,164.85 U34.2
85OHM_TOP_10INCH_DP: length 254
  TOP w0.135: U30.2 -14.51,129.16 -14.51,131.91 -14.04,132.57 -13.35,132.69 -10.09,132.11 -9.86,132.27 -9.86,132.27 -9.76,132.35 -9.6,133.23 -9.87,133.6 -17.01,134.87 -17.19,135.12 -17.1,135.6 -16.89,135.75 -8.63,134.3 -8.27,134.54 -8.12,135.43 -8.37,135.78 -17.3,137.36 -17.41,137.52 -17.31,138.11 -17.13,138.24 -8.64,136.74 -8.26,137.01 -8.12,137.81 -8.42,138.23 -17.12,139.77 -17.25,139.96 -17.15,140.53 -16.98,140.65 -8.58,139.17 -8.16,139.47 -8.04,140.16 -8.29,140.67 -17.43,142.28 -17.58,142.51 -17.49,143.04 -17.32,143.15 -8.31,141.57 -7.91,141.84 -7.76,142.68 -8.02,143.05 -17.37,144.69 -17.51,144.89 -17.44,145.42 -17.24,145.58 -8.42,144.03 -7.99,144.32 -7.85,145.14 -8.11,145.5 -17.26,147.13 -17.39,147.32 -17.29,147.89 -17.13,148.01 -8.13,146.42 -7.75,146.68 -7.6,147.5 -7.88,147.9 -17.43,149.59 -17.55,149.76 -17.45,150.34 -17.26,150.47 -8.1,148.85 -7.7,149.13 -7.56,149.93 -7.84,150.34 -17.37,152.02 -17.47,152.17 -17.36,152.78 -17.19,152.9 -8.05,151.29 -7.66,151.56 -7.52,152.38 -7.8,152.77 -17.3,154.45 -17.45,154.66 -17.35,155.24 -17.2,155.34 -8.14,153.74 -7.67,154.07 -7.54,154.81 -7.83,155.22 -17.31,156.89 -17.43,157.07 -17.32,157.65 -17.14,157.77 -7.83,156.13 -7.41,156.43 -7.28,157.14 -7.62,157.63 -17.45,159.36 -17.59,159.55 -17.49,160.08 -17.27,160.24 -7.65,158.54 -7.23,158.84 -7.1,159.6 -7.39,160.03 -14.71,161.32 -14.82,161.47 -14.63,162.58 -14.63,164.85 U34.1
AT24C64_A0: length 5.3
  TOP w0.127: R281.2 315.16,45.5 315.8,44.86 315.8,43.43 315.65,43.29 R282.1 v1(315.16,42.57) U7.1
AT24C64_A1: length 5.4
  TOP w0.127: R283.2 v1(313.89,44.83) 314.28,44.83 314.53,44.58 314.53,43.56 314.26,43.29 R284.1 313.89,41.12
AT24C64_A2: length 4.9
  TOP w0.127: R285.2 312.12,45.07 312.12,43.8 R286.1 v1(312.62,42.49) U7.3
CLK_100M_CPU1_PE_FG_DN: length 93.6
  TOP w0.135: v1(316.46,55.97) 316.2,55.7 v3(314.45,55.7) 312.07,55.7 310.42,54.05 309.87,54.05 309.83,54.09 U9.7 ; v1(280.62,9.91) 280.93,9.6 280.93,6.78 281.17,6.53 281.17,6.15 280.83,5.8 J5.A14
  IN2 w0.135: v1(280.62,9.91) 280.92,9.61 280.92,9.22 281.29,8.86 282.39,8.86 283.36,9.83 295,9.83 296.31,11.14 297.35,11.14 299.68,13.47 301.94,13.47 303.33,14.86 303.33,19.38 305.89,21.95 305.89,23.75 307.42,25.27 314.17,25.27 318.88,29.98 318.88,54.22 317.41,55.69 316.73,55.69 v1(316.46,55.97)
CLK_100M_CPU1_PE_FG_DP: length 93.5
  TOP w0.135: J5.A13 281.83,5.8 281.48,6.15 281.48,6.66 281.23,6.91 281.23,9.63 v1(281.51,9.91) ; v1(316.46,55.13) 316.2,55.4 v3(312.9,55.4) 312.19,55.4 310.54,53.75 309.89,53.75 309.83,53.69 U9.6
  IN2 w0.135: v1(281.51,9.91) 281.21,9.61 281.21,9.34 281.41,9.14 282.27,9.14 283.24,10.12 283.65,10.12 283.78,10.25 284.19,10.25 284.32,10.12 284.73,10.12 284.86,10.25 285.27,10.25 285.41,10.12 285.81,10.12 285.95,10.25 286.35,10.25 286.49,10.12 286.89,10.12 287.03,10.25 287.43,10.25 287.57,10.12 287.97,10.12 288.11,10.25 288.51,10.25 288.65,10.12 289.06,10.12 289.19,10.25 289.6,10.25 289.73,10.12 294.88,10.12 296.19,11.43 297.23,11.43 299.56,13.76 301.83,13.76 303.04,14.98 303.04,19.5 305.61,22.06 305.61,23.87 307.3,25.56 314.06,25.56 318.59,30.1 318.59,48.69 318.46,48.83 318.46,49.23 318.59,49.37 318.59,49.77 318.46,49.91 318.46,50.32 318.59,50.45 318.59,50.86 318.46,50.99 318.46,51.4 318.59,51.53 318.59,51.94 318.46,52.08 318.46,52.48 318.59,52.62 318.59,53.02 318.46,53.16 318.46,53.56 318.59,53.7 318.59,54.1 318.06,54.64 317.86,54.64 317.58,54.93 317.58,55.12 317.29,55.41 316.73,55.41 v1(316.46,55.13)
CLK_100M_PEX8796_DN: length 2.6
  TOP w0.135: R127.1 305.11,49.47 305.11,49.58 305.51,49.99 305.79,49.99 306.07,50.27 306.07,50.55 306.11,50.58 U9.34
CLK_100M_PEX8796_DP: length 2.6
  TOP w0.135: R126.1 304.8,49.45 304.8,49.71 305.39,50.29 305.67,50.29 305.77,50.39 305.77,50.52 305.71,50.58 U9.33
CLK_100M_PEX8796_R_DN: length 262.5
  TOP w0.135: R127.2 305.11,48.06 305.11,47.93 v1(305.41,47.62)
  IN3 w0.089: 66.74,62.87 66.74,62.89 66.79,62.94 66.79,64.42 66.67,64.53 66.45,64.53 66.36,64.45 v4(66.36,64.13)
  IN3 w0.135: v1(305.41,47.62) 305.11,47.33 305.11,46.91 306.2,45.36 306.2,44.75 305.7,43.41 305.7,43.4 304.91,41.27 299.33,34.76 297.69,30.25 295.47,28.03 285.44,28.03 284.55,27.14 234.54,27.14 223.97,28.08 200.67,32.75 193.47,34.68 186.12,37.26 176.04,40.37 140.72,45.1 135.61,44.64 134.34,44.77 121.61,48.74 87.95,54.66 84.34,57.19 81.43,58.18 78.2,58.48 75.81,58.94 74.72,60.29 67.79,61.44 67.19,61.91 66.79,62.5 66.74,62.58 66.74,62.87
  BOTTOM w0.135: U1.AM1 v4(66.36,64.13)
CLK_100M_PEX8796_R_DP: length 262.5
  TOP w0.135: v1(304.52,47.62) 304.8,47.9 304.8,48.09 R126.2
  IN3 w0.089: 67.03,62.87 67.03,62.89 66.98,62.94 66.98,64.5 66.75,64.73 66.45,64.73 66.36,64.81 v7(66.36,65.13)
  IN3 w0.135: v1(304.52,47.62) 304.83,47.32 304.83,46.82 305.28,46.18 305.25,46 305.48,45.67 305.65,45.64 305.91,45.27 305.91,44.8 305.66,44.12 305.5,44.05 305.36,43.67 305.43,43.51 305.43,43.5 305.29,43.11 305.12,43.03 304.98,42.66 305.06,42.49 304.66,41.42 299.08,34.9 297.44,30.41 295.35,28.32 285.32,28.32 284.43,27.43 234.55,27.43 224.01,28.37 200.74,33.03 193.55,34.95 186.21,37.54 176.1,40.65 140.73,45.39 135.61,44.93 134.4,45.05 121.67,49.02 88.06,54.93 84.47,57.45 81.49,58.46 78.25,58.76 77.11,58.98 76.54,59.09 75.97,59.21 74.87,60.56 71.06,61.19 70.95,61.34 70.55,61.4 70.41,61.3 70.01,61.36 69.9,61.51 69.51,61.57 69.36,61.47 68.96,61.53 68.86,61.68 68.46,61.75 68.31,61.64 67.91,61.71 67.41,62.11 67.03,62.67 67.03,62.87
  BOTTOM w0.135: U1.AM2 v7(66.36,65.13)
CLK_100M_SLOT1_DN: length 2.1
  TOP w0.135: U9.37 307.3,50.33 307.62,50.01 307.62,49.47 R340.1
CLK_100M_SLOT1_DP: length 2.2
  TOP w0.135: R143.1 307.32,49.45 307.32,49.89 307,50.2 307,50.48 306.9,50.58 U9.36
CLK_100M_SLOT1_R_DN: length 63.8
  TOP w0.135: R340.2 307.63,48.08 307.63,47.92 v1(307.93,47.62)
  IN2 w0.135: v1(307.93,47.62) 307.62,47.32 307.62,46.66 309.23,45.05 309.23,43.34 308.81,42.93 308.81,40.39 307.93,39.5 307.93,27.81 306.66,26.54 305.26,26.54 304.62,25.91 304.62,22.1 301.3,18.77 301.3,14.86 300.84,14.4 299.21,14.4 297.81,13 296.43,13 295.89,12.45 295.89,12.07 294.69,10.87 282.42,10.87 281.73,11.56 281.73,13.46 281.51,13.68 281.39,13.75 281.2,13.69 J1.A14
CLK_100M_SLOT1_R_DP: length 63.7
  TOP w0.135: R143.2 307.33,48.08 307.33,47.92 v1(307.04,47.62)
  IN2 w0.135: J1.A13 281.45,14.18 281.51,14 281.51,14 281.68,13.92 282.02,13.58 282.02,11.68 282.54,11.16 284.81,11.16 284.95,11.3 285.35,11.3 285.49,11.16 285.89,11.16 286.03,11.3 286.43,11.3 286.57,11.16 286.97,11.16 287.11,11.3 287.51,11.3 287.65,11.16 288.05,11.16 288.19,11.3 288.6,11.3 288.73,11.16 289.14,11.16 289.27,11.3 289.68,11.3 289.81,11.16 294.57,11.16 295.6,12.19 295.6,12.57 296.32,13.28 297.69,13.28 299.09,14.69 300.72,14.69 301.01,14.98 301.01,18.89 304.34,22.22 304.34,26.03 305.14,26.83 306.54,26.83 307.64,27.93 307.64,39.62 308.53,40.51 308.53,43.05 308.94,43.46 308.94,44.93 307.34,46.54 307.34,47.32 v1(307.04,47.62)
CLK_100M_SLOT2_DN: length 2.7
  TOP w0.135: R125.1 302.33,52.3 302.69,52.3 303.31,52.91 303.81,52.91 303.83,52.89 U9.27
CLK_100M_SLOT2_DP: length 2.7
  TOP w0.135: R124.1 302.33,52.6 302.57,52.6 303.18,53.22 303.76,53.22 303.84,53.29 U9.26
CLK_100M_SLOT2_R_DN: length 43.3
  TOP w0.135: R125.2 300.82,52.3 299.8,52.3 v1(299.53,52.03)
  BOTTOM w0.135: v1(299.53,52.03) 299.27,52.3 298.88,52.3 297.26,50.67 297.26,31.83 296.27,30.84 283.19,30.84 281.64,32.39 281.64,33.86 281.51,33.99 281.38,34.06 281.2,34 J2.A14
CLK_100M_SLOT2_R_DP: length 43.3
  TOP w0.135: v1(299.53,52.87) 299.8,52.6 300.82,52.6 R124.2
  BOTTOM w0.135: v1(299.53,52.87) 299.27,52.6 298.76,52.6 296.95,50.8 296.95,31.95 296.14,31.14 283.31,31.14 282.73,31.73 282.73,31.94 282.44,32.23 282.23,32.23 281.94,32.51 281.94,33.99 281.69,34.25 281.52,34.33 281.46,34.51 J2.A13
CLK_100M_SLOT3_DN: length 2.6
  TOP w0.135: U9.24 303.8,54.09 303.75,54.14 302.99,54.14 302.67,54.46 302.33,54.46 R123.1
CLK_100M_SLOT3_DP: length 2.6
  TOP w0.135: U9.23 303.79,54.49 303.75,54.44 303.11,54.44 302.79,54.76 302.33,54.76 R122.1
CLK_100M_SLOT3_R_DN: length 24.7
  TOP w0.135: v1(299.55,54.19) 299.81,54.46 300.82,54.46 R123.2
  BOTTOM w0.135: J3.A14 281.2,54.32 281.38,54.38 281.51,54.31 281.64,54.18 281.64,52.7 283.16,51.18 295.71,51.18 298.99,54.46 299.28,54.46 v1(299.55,54.19)
CLK_100M_SLOT3_R_DP: length 24.7
  TOP w0.135: R122.2 300.82,54.76 299.81,54.76 v1(299.55,55.03)
  BOTTOM w0.135: J3.A13 281.46,54.83 281.52,54.65 281.69,54.57 281.94,54.31 281.94,52.83 282.45,52.32 282.66,52.32 282.95,52.04 282.95,51.82 283.28,51.49 295.59,51.49 298.86,54.76 299.28,54.76 v1(299.55,55.03)
CLK_100M_SLOT4_DN: length 3.2
  TOP w0.135: U9.18 305.71,56.45 305.74,56.49 305.74,57.68 305.28,58.14 305.28,58.43 R121.1
CLK_100M_SLOT4_DP: length 3.2
  TOP w0.135: R120.1 305.59,58.43 305.59,58.27 306.05,57.81 306.05,56.54 306.11,56.48 U9.17
CLK_100M_SLOT4_R_DN: length 37.2
  TOP w0.135: R121.2 305.28,59.94 305.28,60.58 v1(305.02,60.84)
  BOTTOM w0.135: v1(305.02,60.84) 305.28,61.11 305.28,61.7 299.42,67.56 286.89,67.56 286.01,66.67 283.52,66.67 281.66,68.53 281.66,71.04 281.51,71.19 281.51,71.6 281.66,71.75 281.66,72.43 281.51,72.58 281.51,72.98 281.66,73.14 281.66,74.48 281.51,74.63 281.38,74.7 281.2,74.64 J4.A14
CLK_100M_SLOT4_R_DP: length 37.4
  TOP w0.135: v1(305.85,60.84) 305.59,60.58 305.59,59.94 R120.2
  BOTTOM w0.135: v1(305.85,60.84) 305.59,61.11 305.59,61.82 299.55,67.86 286.76,67.86 285.88,66.98 283.64,66.98 281.97,68.66 281.97,74.61 281.69,74.89 281.52,74.97 281.46,75.15 J4.A13
CLK_100M_SLOT5_DN: length 3.2
  TOP w0.135: U9.15 306.9,56.56 306.96,56.62 306.96,57.66 307.47,58.17 307.47,58.43 R119.1
CLK_100M_SLOT5_DP: length 3.2
  TOP w0.135: U9.14 307.3,56.62 307.27,56.66 307.27,57.53 307.77,58.04 307.77,58.43 R118.1
CLK_100M_SLOT5_R_DN: length 52.1
  TOP w0.135: R119.2 307.47,59.94 307.47,60.56 v1(307.2,60.83)
  BOTTOM w0.135: v1(307.2,60.83) 307.47,61.09 307.47,61.34 298.45,70.36 298.45,80.09 296.37,82.17 296.37,85.52 293.98,87.91 286.77,87.91 283.34,91.34 283.12,91.34 282.84,91.62 282.84,91.84 282.45,92.23 282.23,92.23 281.95,92.51 281.95,92.73 281.66,93.01 281.66,94.82 281.55,94.93 281.38,95.02 281.2,94.96 J9.A14
CLK_100M_SLOT5_R_DP: length 52.2
  TOP w0.135: R118.2 307.77,59.94 307.77,60.56 v1(308.04,60.83)
  BOTTOM w0.135: J9.A13 281.46,95.47 281.52,95.29 281.73,95.18 281.97,94.94 281.97,93.14 286.89,88.21 294.11,88.21 296.67,85.65 296.67,82.3 298.75,80.22 298.75,70.49 307.77,61.47 307.77,61.09 v1(308.04,60.83)
CLK_BUF_CKPWRGD: length 8.8
  TOP w0.127: Q4.D 314.28,53.3 v1(314.28,54.13) 314.28,54.28 313.77,54.78 312.45,54.78 311.72,54.05 R4.2 310.78,52.15 310.08,52.15 309.74,52.49 U9.3
CLK_BUF_HIBW_BYPM_LOBW_N: length 6.5
  TOP w0.178: U9.2 309.68,52.09 310.08,51.69 310.34,51.69
  TOP w0.254: v1(311.72,48.31) R1.2 R2.1 311.1,51.94 310.85,51.69 310.34,51.69
CPLD_PWRBRK_N: length 123.6
  TOP w0.127: U20.2 283.41,45.21 v1(283.54,45.34) ; U18.2 280.75,86.87 281.89,85.72 U21.2 283.47,85.72 v1(283.72,85.98) ; U19.2 v1(283.54,65.41) ; U47.2 275.03,22.86 v1(274.65,22.48)
  IN1 w0.097: v1(274.65,22.48) 274.65,22.86 286.72,34.92 286.72,38.35 284.68,40.39 284.68,44.83 284.18,45.34 v1(283.54,45.34)
  IN2 w0.112: v1(283.54,45.34) 283.16,45.72 283.16,51.69 286.61,55.14 286.61,58.78 284.18,61.21 284.18,64.77 v1(283.54,65.41) 284.76,66.62 289.49,66.62 289.66,66.8 289.66,69.19 288.99,69.86 288.99,70.9 289.78,71.69 289.78,74.21 289.14,74.85 287.3,74.85 286.61,75.55 286.61,79.1 284.18,81.53 284.18,85.52 v1(283.72,85.98)
  BOTTOM w0.127: J5.B30 264.83,5.58 263.7,6.71 263.7,11.9 263.98,12.18 263.98,13.63 262.99,14.62 262.99,15.88 263.5,16.38 264.36,16.38 264.87,16.89 264.87,18.03 265.76,18.92 265.76,20.07 266.96,21.26 273.43,21.26 v1(274.65,22.48) 275.92,23.75 R37.2
CPLD_SLOT1_PWRBRK_N: length 10.3
  TOP w0.127: R39.1 278.97,22.1 v1(278.59,22.48) 278.32,22.21 U47.4 277.56,22.21 277.06,21.72 274.42,21.72 R40.1 274.14,22.21 274.14,23.88 275.03,24.77 R361.2
CPLD_SLOT1_PWRBRK_R1_N: length 3.9
  TOP w0.127: R39.2 280.16,22.1 J1.B12
CPLD_SLOT1_PWRBRK_R2_N: length 11.9
  TOP w0.127: J1.B30 264.83,21.52 266.8,23.5 271.84,23.5 R40.2
CPLD_SLOT2_PWRBRK_N: length 6.2
  TOP w0.127: U20.4 284.95,44.56 285.07,44.45 285.07,44.07 284.81,43.81 R216.1 R221.1 v1(282.81,43.45)
  BOTTOM w0.127: v1(282.81,43.45) 282.27,43.99 R38.2
CPLD_SLOT2_PWRBRK_R1_N: length 3.7
  TOP w0.127: J2.B12 284.81,41.74 R216.2
CPLD_SLOT2_PWRBRK_R2_N: length 20.2
  TOP w0.127: R221.2 267.73,42.65 J2.B30
CPLD_SLOT3_PWRBRK_N: length 5.2
  TOP w0.127: R214.1 R215.1 283.64,63.8 v1(283.64,64.29) 283.64,64.36 284.03,64.76 U19.4
  BOTTOM w0.127: v1(283.64,64.29) 282.8,65.13 R362.2
CPLD_SLOT3_PWRBRK_R1_N: length 3.6
  TOP w0.127: R214.2 284.81,62.06 J3.B12
CPLD_SLOT3_PWRBRK_R2_N: length 20.1
  TOP w0.127: J3.B30 267.6,62.85 R215.2
CPLD_SLOT4_PWRBRK_N: length 5.6
  TOP w0.127: v1(281.54,84.18) 281.74,83.97 R213.1 R212.1 283.54,84.25 284.37,85.08 U21.4
  BOTTOM w0.127: v1(281.54,84.18) 282.4,85.04 R77.2
CPLD_SLOT4_PWRBRK_R1_N: length 3.1
  TOP w0.127: R212.2 283.54,81.11 J4.B12
CPLD_SLOT4_PWRBRK_R2_N: length 18.8
  TOP w0.127: J4.B30 267.6,83.17 R213.2
CPLD_SLOT5_PWRBRK_N: length 5.1
  TOP w0.127: R195.1 R196.1 281.77,91.29 281.38,90.91 v1(280.95,90.91) 280.95,91.46 U18.4
  BOTTOM w0.127: v1(280.95,90.91) 281.11,90.75 R363.2
CPLD_SLOT5_PWRBRK_R1_N: length 9.5
  TOP w0.127: R195.2 283.41,93.6 283.67,93.85 283.67,95.5 282.35,96.82 282.35,98.04 282.83,98.52 J9.B12
CPLD_SLOT5_PWRBRK_R2_N: length 24
  TOP w0.127: R196.2 281.53,92.96 268.05,92.96 267.79,93.22 267.79,94.61 266.75,95.66 266.75,99.09 265.94,99.9 265.64,99.9 J9.B30
EMC1413_ADDR: length 4.1
  TOP w0.127: R35.2 162.84,82.55 v1(162.76,82.63) 162.21,83.19 162.21,84.35 162.44,84.59 U10.7
EMC1413_ALERT_N: length 4.9
  TOP w0.127: U10.8 162.18,85.09 161.77,84.68 161.77,82.8 v1(161.6,82.63) 161.83,82.4 R36.2
I2C_MUX_ADD_A0: length 6.9
  TOP w0.127: R83.2 R84.1 310.36,43.96 310.08,43.69 310.08,41.78 v1(309.96,41.66) 309.3,41.66 308.04,40.4 U2.1
I2C_MUX_ADD_A1: length 7.2
  TOP w0.127: U2.2 307.39,40.99 307.52,41.13 308.37,41.13 308.94,41.7 308.94,43.69 309.22,43.96 R82.1 309.96,44.47 v1(309.96,44.7) 309.96,44.94 R81.2
I2C_MUX_ADD_A2: length 4.1
  TOP w0.127: R80.1 R79.2 v1(306.66,32.58) 306.09,33.15 U2.21
I2C_MUX_RST_N: length 6.9
  TOP w0.127: R78.2 308.43,44.48 308.21,44.25 v1(308.21,43.79) 308.66,43.33 308.66,41.99 308.08,41.41 307.17,41.41 306.74,40.98 U2.3
I2C_PCA9548_SC0_SLOT5_R_SCL: length 3.3
  TOP w0.127: U2.5 305.44,41.84 v1(305.89,42.29) 306.02,42.42 R20.1
I2C_PCA9548_SC0_SLOT5_SCL: length 61.6
  TOP w0.127: R224.1 292.03,89.55 292.3,89.28 292.3,88.39 292.22,88.31 Q13.D 292.22,87.08 v1(292.94,86.36) ; R20.2 306.02,44.09 v1(305.4,44.71) 305.41,44.71 306.02,45.32 R96.2
  IN2 w0.112: v1(305.4,44.71) 305.4,45.33 305.13,45.59 302.02,45.59 300.94,46.67 300.94,49.54 302.09,50.69 302.09,72.1 305.1,75.11 305.1,80.38 304.14,81.33 300.14,81.33 295.11,86.36 v1(292.94,86.36)
I2C_PCA9548_SC1_SLOT4_R_SCL: length 3.5
  TOP w0.127: U2.7 304.14,41.12 v1(303.73,41.53) 303.1,42.16 R22.1
I2C_PCA9548_SC1_SLOT4_SCL: length 39.4
  TOP w0.127: v1(292.22,66.04) 292.22,66.14 Q14.D 292.22,69.01 292.03,69.2 R222.1 ; R22.2 303.1,44.07 v1(303.73,44.7) R98.2
  BOTTOM w0.114: v1(303.73,44.7) 303.86,44.83 303.86,45.09 303.44,45.5 299.23,45.5 298.33,46.4 298.33,48.88 301.07,51.61 301.07,62.15 296.89,66.33 292.51,66.33 v1(292.22,66.04)
I2C_PCA9548_SC2_SLOT3_R_SCL: length 3.6
  TOP w0.127: R24.1 v1(301.45,42.42) 301.45,42.29 302.84,40.9 U2.9
I2C_PCA9548_SC2_SLOT3_SCL: length 17.6
  TOP w0.127: R24.2 v1(301.45,44.7) R100.2 ; R226.1 292.03,49.04 292.43,48.64 292.43,48.01 292.22,47.8 Q15.D 293.27,46.86 v1(293.35,46.94)
  IN3 w0.112: v1(293.35,46.94) 297.35,46.94 298.16,46.13 299.13,46.13 299.24,46.01 299.24,45.45 299.35,45.34 299.62,45.34 299.73,45.45 299.73,46.01 299.84,46.13 300.11,46.13 300.22,46.01 300.22,45.45 300.33,45.34 300.6,45.34 300.72,45.45 300.72,46.01 300.83,46.13 301.27,46.13 301.45,45.95 v1(301.45,44.7)
I2C_PCA9548_SC3_SLOT2_R_SCL: length 7.4
  TOP w0.127: U2.11 301.54,40.93 301.25,41.22 300.76,41.22 300.67,41.13 300.66,41.13 300.05,40.52 v1(300.05,39.95) 299.37,39.95 298.96,40.37 298.96,42.96 R26.1
I2C_PCA9548_SC3_SLOT2_SCL: length 26.5
  TOP w0.127: R26.2 299.16,44.17 298.91,44.42 298.91,44.76 v1(298.88,44.81) 299.16,45.09 R102.2 ; v1(295.56,26.26) 295.56,26.43 295.55,26.43 295.55,26.65 295.23,26.98 R228.1 294.69,27.16 294.32,26.8 Q21.D
  BOTTOM w0.114: v1(295.56,26.26) 295.56,26.34 297.46,28.24 297.46,30.44 297.58,30.56 297.58,30.57 298.53,31.53 298.53,42.63 298.54,42.64 298.54,44.46 v1(298.88,44.81)
I2C_PCA9548_SC4_SLOT1_R_SCL: length 3.9
  TOP w0.127: U2.14 301.54,33.96 301.1,33.53 300.81,33.53 v1(299.8,32.51) 299.54,32.26 R339.1
I2C_PCA9548_SC4_SLOT1_SCL: length 15.1
  TOP w0.127: R307.1 296.6,23.11 Q20.D v1(299.88,22.1) ; R339.2 v1(299.54,29.97) R145.2
  BOTTOM w0.127: v1(299.88,22.1) 298.78,23.2 298.78,26.42 299.54,27.18 v1(299.54,29.97)
I2C_PCA9548_SC5_3V3_PE_SCL: length 188.1
  TOP w0.127: v1(200.86,95.25) 200.86,96.16 192.56,104.47 192.56,112.8 191.58,113.78 CON1.2 ; U12.7 120.42,37.33 120.65,37.57 122.26,37.57 R234.2 R194.2 122.86,36.34 123.22,36.7 124.65,36.7 Q25.S 126.03,35.33 v1(126.8,35.33)
  IN1 w0.097: v1(126.8,35.33) 126.72,35.41 126.72,39.52 130.8,43.6 140.5,43.6 144.32,39.79 154.04,39.79 156.16,41.91 202.02,41.91 207.74,36.2 v1(208.36,36.2)
  IN2 w0.112: v1(208.36,36.2) 208.61,36.2 209.12,36.7 209.12,87 v1(200.86,95.25)
I2C_PCA9548_SC5_P1V8_SCL: length 64.1
  TOP w0.127: v1(120.45,42.16) 120.42,42.13 U12.2
  IN1 w0.097: v4(84.36,71.13) 84.84,70.66 84.84,66.85 84.53,66.55 82.04,66.55 81.78,66.29 81.78,62.57 85.42,58.93 85.42,57.1 86.61,55.9 87.42,55.9 90.75,52.57 99.05,52.57 101.17,50.44 113.38,50.44 120.29,43.53 120.29,42.32 v1(120.45,42.16)
  BOTTOM w0.114: v1(120.45,42.16) 120.09,41.81 R277.2 ; U1.R8 v4(84.36,71.13)
I2C_PCA9548_SC5_PE_R_SCL: length 3.8
  TOP w0.127: U2.16 v1(302.84,31.88) 302.83,31.87 302.06,31.87 R28.1
I2C_PCA9548_SC5_PE_SCL: length 193.8
  TOP w0.127: R104.2 v1(301.83,29.97) R28.2 ; v1(125.7,37.56) 125.04,37.56 Q25.D 124.49,38.12 R234.1
  IN3 w0.112: v1(301.83,29.97) 301.7,29.97 301.44,29.71 301.44,29.07 300.81,28.45 298.1,28.45 296.63,26.98 287.87,26.98 286.62,25.74 281.43,25.74 281.06,25.36 190.8,25.36 178.64,37.53 157.8,37.53 143.24,43.57 129.24,43.57 126.39,40.72 126.39,38.02 125.93,37.56 v1(125.7,37.56)
I2C_PCA9548_SC6_3V3_CLK_R_SCL: length 7
  TOP w0.127: U9.9 309.7,54.89 313.23,58.42 v1(313.23,58.67) 314.05,57.86 R90.2
I2C_PCA9548_SC6_3V3_CLK_SCL: length 38.1
  TOP w0.127: Q19.S 314.34,28.45 314.55,28.66 R236.2 314.91,29.34 315.47,29.89 v1(315.47,30.36) R193.2 ; v1(317.98,58.17) 315.67,58.17 315.31,57.81 R90.1
  BOTTOM w0.114: v1(317.98,58.17) 318.85,57.3 318.85,33.67 317.28,32.1 317.28,31.94 317.57,31.65 317.57,31.44 317.37,31.24 317.2,31.24 316.88,31.56 316.74,31.56 315.54,30.36 v1(315.47,30.36)
I2C_PCA9548_SC6_CLK_R_SCL: length 3.4
  TOP w0.127: U2.18 304.14,33.76 304.72,33.18 v1(304.72,32.64) 304.12,32.04 R30.1
I2C_PCA9548_SC6_CLK_SCL: length 241.3
  TOP w0.127: R106.2 v1(304.12,29.97) 303.86,29.97 303.73,30.1 303.73,30.61 303.96,30.84 R30.2 ; R280.2 312.88,32.8 v1(312.88,32.4) 313.42,31.86 313.42,29.67 R236.1 313.75,28.56 313.51,28.32 313.51,26.54 314.74,25.32 Q19.D ; v1(279.47,72.4) 279.21,72.14 278.53,72.14 276.88,70.48 202.64,70.48 190.82,82.3 190.81,82.3 190.17,82.93 R183.1
  IN1 w0.097: v1(279.47,72.4) 279.47,72.4 279.82,72.4 280.01,72.59 285.42,72.59 285.59,72.41 286.33,71.67 297.13,71.67 301.81,76.35 304.91,76.35 306.38,77.82 313.31,77.82 314.12,78.64 315,78.64 315.31,78.32 315.31,77.87 v1(314.78,77.34)
  IN2 w0.112: v1(312.88,32.4) 312.88,32.83 313.83,33.78 313.83,38.03 317.95,42.16 317.95,47.5 316.18,49.28 316.18,53.47 314.53,55.12 314.53,59.44 312.47,61.49 309.45,61.49 308.89,62.05 307.31,62.05 304.08,65.29 304.08,70.83 310.82,77.57 314.56,77.57 v1(314.78,77.34)
  IN3 w0.112: v1(312.88,32.4) 311.7,31.23 305.37,31.23 v1(304.12,29.97)
  BOTTOM w0.114: R299.1 v1(314.78,77.34)
I2C_PCA9548_SC6_FRU_SCL: length 2.2
  TOP w0.127: U7.6 v1(312.62,34.54) 313.13,34.04 R280.1
I2C_PCA9548_SC6_SEN1_SCL: length 8.8
  TOP w0.127: R183.2 167.81,81.9 v1(166.64,81.9) 165.48,83.06 165.48,85.45 164.84,86.09 U10.10
I2C_PCA9548_SC6_SEN2_SCL: length 4.6
  BOTTOM w0.127: R299.2 312.75,77.34 v2(311.61,76.2) 310.85,76.96 310.85,77.6 310.68,77.76 U4.8
I2C_PCA9548_SD0_SLOT5_R_SDA: length 4.4
  TOP w0.127: U2.4 306.09,40.89 307.05,41.85 v1(307.8,41.85) 307.8,42.53 R19.1
I2C_PCA9548_SD0_SLOT5_SDA: length 68.2
  TOP w0.127: R19.2 v1(307.16,44.7) R95.2 ; v1(287.86,86.36) 288.03,86.53 Q16.D 288.03,88.71 288.22,88.9 R225.1
  IN2 w0.112: v1(287.86,86.36) 288.98,87.48 294.44,87.48 300.27,81.65 304.27,81.65 305.41,80.51 305.41,74.98 302.4,71.97 302.4,50.56 301.26,49.41 301.26,46.8 302.15,45.91 305.26,45.91 306.47,44.7 v1(307.16,44.7)
I2C_PCA9548_SD1_SLOT4_R_SDA: length 4.7
  TOP w0.127: R21.1 304.54,43.16 304.27,43.43 v1(303.99,43.43) 303.94,43.38 303.94,42.72 304.79,41.87 U2.6
I2C_PCA9548_SD1_SLOT4_SDA: length 44
  TOP w0.127: R21.2 304.88,44.2 304.54,44.54 v1(304.54,44.74) 304.88,45.09 R97.2 ; R223.1 288.22,68.66 288.03,68.47 Q17.D 288.03,66.81 v1(288.83,66.01)
  BOTTOM w0.114: v1(288.83,66.01) 289.51,66.7 292.34,66.7 292.35,66.71 297.05,66.71 301.45,62.31 301.45,62 301.45,62 301.45,51.45 298.71,48.72 298.71,46.56 299.38,45.89 303.67,45.89 304.54,45.02 v1(304.54,44.74)
I2C_PCA9548_SD2_SLOT3_R_SDA: length 5.7
  TOP w0.127: U2.8 303.49,40.88 302.73,41.64 302.3,44.4 v1(302.34,44.45) R23.1
I2C_PCA9548_SD2_SLOT3_SDA: length 20.8
  TOP w0.127: R23.2 302.21,46.63 v1(302.21,46.99) 301.32,47.88 R99.2 ; R227.1 288.35,48.49 288.16,48.3 Q18.D 290.98,46.86 291.29,46.56 291.29,46.1 291.54,45.85 v1(291.67,45.85)
  IN3 w0.112: v1(291.67,45.85) 291.67,46.02 293.17,47.53 297.2,47.53 298.27,46.46 301.68,46.46 v1(302.21,46.99)
I2C_PCA9548_SD3_SLOT2_R_SDA: length 5.4
  TOP w0.127: R25.1 299.54,42.4 v1(299.54,41.91) 299.77,41.68 301.42,41.68 302.19,40.91 U2.10
I2C_PCA9548_SD3_SLOT2_SDA: length 34.9
  TOP w0.127: R101.2 300.31,44.96 v1(300.15,44.81) 300.15,44.5 300.31,44.35 R25.2 ; Q24.D 288.77,26.8 R233.1 v1(289.13,26.16)
  BOTTOM w0.114: v1(289.13,26.16) 289.89,25.4 296.37,25.4 297.96,26.99 297.96,30.42 298.91,31.37 298.91,42.47 300.15,43.71 v1(300.15,44.81)
I2C_PCA9548_SD4_SLOT1_R_SDA: length 5.1
  TOP w0.127: R338.1 298.53,32.26 299.29,33.02 299.29,33.91 v1(299.8,34.42) 300.31,33.91 300.69,33.91 300.89,34.11 U2.13
I2C_PCA9548_SD4_SLOT1_SDA: length 17.5
  TOP w0.127: v1(293.79,22.1) Q23.D 290.51,23.11 R308.1 ; R338.2 298.53,30.23 v1(298.78,29.97) 298.53,29.72 R144.2
  BOTTOM w0.127: v1(293.79,22.1) 294.93,23.24 296.09,23.24 298.02,25.17 298.02,26.42 299.04,27.43 299.04,29.72 v1(298.78,29.97)
I2C_PCA9548_SD5_3V3_PE_SDA: length 183.8
  TOP w0.127: CON1.3 189.4,111.78 189,111.38 189,107.87 189.64,107.24 189.64,106.68 200.1,96.22 v1(200.1,95.25) ; U12.6 119.77,37.37 120.37,37.97 121.57,37.97 121.99,38.4 121.99,39.56 122.32,39.9 R235.2 R209.2 123.65,42.02 Q26.S 123.84,40.63 v1(123.78,40.56)
  IN1 w0.097: v1(208.35,37.32) 207.98,37.32 203.09,42.21 156.01,42.21 153.89,40.09 144.44,40.09 140.63,43.9 129.15,43.9 127.23,41.98 125.19,41.98 v1(123.78,40.56)
  IN2 w0.112: v1(208.35,37.32) 208.35,87.01 v1(200.1,95.25)
I2C_PCA9548_SD5_P1V8_SDA: length 63.1
  TOP w0.127: U12.3 119.77,42.9 v1(119.55,43.12)
  IN1 w0.097: v4(84.36,70.13) 84.31,70.13 83.87,69.7 83.87,67.92 83.57,67.61 82.04,67.61 81.48,67.06 81.48,62.44 85.12,58.81 85.12,56.97 86.49,55.6 87.29,55.6 90.7,52.19 98.89,52.19 100.94,50.14 113.26,50.14 119.55,43.85 v1(119.55,43.12)
  BOTTOM w0.114: R278.2 119.08,42.65 v1(119.55,43.12) ; U1.R7 v4(84.36,70.13)
I2C_PCA9548_SD5_PE_R_SDA: length 3.5
  TOP w0.127: U2.15 302.19,33.58 301.75,33.15 v1(301.75,33.02) 301.75,32.71 R27.1
I2C_PCA9548_SD5_PE_SDA: length 194.6
  TOP w0.127: v1(125.81,39.14) 125.46,39.14 Q26.D 124.07,39.1 R235.1 ; R27.2 v1(300.69,29.97) R103.2
  IN3 w0.112: v1(125.81,39.14) 125.81,43.2 125.92,43.31 126.2,43.31 126.32,43.2 126.32,42.78 126.43,42.67 127.84,42.67 129.05,43.88 143.63,43.88 158.2,37.85 178.77,37.85 190.88,25.73 280.98,25.73 281.3,26.05 286.49,26.05 287.74,27.29 296.5,27.29 297.97,28.76 300.68,28.76 301.12,29.2 301.12,29.58 301.12,29.72 300.87,29.97 v1(300.69,29.97)
I2C_PCA9548_SD6_3V3_CLK_R_SDA: length 5.8
  TOP w0.127: U9.8 309.93,54.49 312.1,56.66 v1(313.26,56.66) R89.2
I2C_PCA9548_SD6_3V3_CLK_SDA: length 39.4
  TOP w0.127: v1(316.05,57.28) 315.77,57.28 315.16,56.66 R89.1 ; R204.2 v1(310.9,30.2) 310.67,29.97 310.34,29.97 310.07,29.7 R237.2 310.07,28.53 310.15,28.45 Q22.S
  BOTTOM w0.114: v1(316.05,57.28) 317.07,57.28 318.47,55.88 318.47,33.91 315.88,31.32 313.78,31.32 312.66,30.2 v1(310.9,30.2)
I2C_PCA9548_SD6_CLK_R_SDA: length 5.5
  TOP w0.127: U2.17 303.49,31.12 302.97,30.61 v1(302.97,29.86) R29.1
I2C_PCA9548_SD6_CLK_SDA: length 241.2
  TOP w0.127: R279.2 v1(311.99,32.41) 311.99,30.46 R237.1 310.87,28.56 311.1,28.32 Q22.D ; R29.2 v1(302.97,27.69) 302.97,27.54 R105.2 ; R184.1 190.67,81.92 202.48,70.1 277.03,70.1 278.69,71.75 279.35,71.75 v1(279.47,71.63)
  IN1 w0.097: v1(314.78,78.11) 314.01,78.11 313.43,77.52 306.5,77.52 305.03,76.05 301.93,76.05 297.26,71.37 286.21,71.37 285.29,72.29 280.14,72.29 v1(279.47,71.63)
  IN2 w0.112: v1(314.78,78.11) 314.57,77.89 310.69,77.89 303.73,70.93 303.73,65.18 307.18,61.74 308.76,61.74 309.32,61.18 312.34,61.18 314.22,59.31 314.22,54.99 315.87,53.34 315.87,49.15 317.64,47.37 317.64,42.29 313.51,38.16 313.51,33.91 312.02,32.41 v1(311.99,32.41)
  IN3 w0.112: v1(311.99,32.41) 311.99,32 311.53,31.55 305.23,31.55 305.18,31.5 304.48,31.5 303.56,30.57 303.56,28.27 v1(302.97,27.69)
  BOTTOM w0.114: R300.1 314.53,78.36 v1(314.78,78.11)
I2C_PCA9548_SD6_FRU_SDA: length 3.3
  TOP w0.127: U7.5 311.35,35.31 v1(310.59,34.54) 311.29,33.85 R279.1
I2C_PCA9548_SD6_SEN1_SDA: length 9.6
  TOP w0.127: U10.9 164.6,85.59 164.85,85.34 164.85,82.7 v1(164.47,82.33) 165.55,81.25 168.18,81.25 R184.2
I2C_PCA9548_SD6_SEN2_SDA: length 3.3
  BOTTOM w0.127: U4.7 311.3,78.41 v2(311.61,78.11) 311.86,78.36 R300.2
I2C_PE_SCL: length 12.5
  TOP w0.127: v1(298.52,10.49) 298.53,10.5 298.53,11.03 R86.1
  IN1 w0.097: v1(292.3,7.87) 292.3,7.97 293.52,9.19 294.68,9.48 295.92,9.48 v1(298.52,10.49)
  BOTTOM w0.114: J5.B5 291.83,5.94 291.54,6.22 291.54,7.11 v1(292.3,7.87)
I2C_PE_SCL_R: length 29.7
  TOP w0.127: v1(299.8,12.19) 299.79,12.19 298.63,12.19 R86.2 ; U2.22 306.74,33.39 307.67,32.46 R87.2 307.44,31.64 307.16,31.37 307.16,30.45 308.15,29.46 v1(308.69,29.46)
  BOTTOM w0.114: v1(299.8,12.19) 299.29,12.7 299.29,13.13 301.33,15.18 301.33,18.19 304.38,21.23 304.38,22.89 308.07,26.58 308.07,28.98 308.56,29.46 v1(308.69,29.46)
I2C_PE_SDA: length 12
  TOP w0.127: v1(296.6,10.52) 297.24,11.16 R85.1
  IN1 w0.097: v1(292.24,8.7) 293.32,9.78 295.86,9.78 v1(296.6,10.52)
  BOTTOM w0.114: v1(292.24,8.7) 290.83,7.28 J5.B6
I2C_PE_SDA_R: length 29.5
  TOP w0.127: R85.2 297.51,12.06 298.27,12.83 v1(300.31,12.83) ; U2.23 307.39,33.68 308.69,32.38 R88.2 308.92,31.64 309.23,31.34 309.23,29.22 308.69,28.68 v1(308.69,28.57)
  BOTTOM w0.114: v1(308.69,28.57) 308.69,26.67 308.45,26.44 308.45,26.42 304.76,22.73 304.76,21.39 304.76,21.08 301.72,18.03 301.72,14.97 300.31,13.56 v1(300.31,12.83)
I2C_SC5_2N7002_G_SCL: length 3.4
  TOP w0.127: v5(123.84,33.93) Q25.G 123.6,35.62 R161.2
I2C_SC6_2N7002_G_SCL: length 2.1
  TOP w0.254: Q19.G 316.24,28.16 v1(315.7,28.7) R160.2
I2C_SD5_2N7002_G_SDA: length 3.8
  TOP w0.127: Q26.G 125.45,42.31 R191.2 v5(125.45,45.67)
I2C_SD6_2N7002_G_SDA: length 1.9
  TOP w0.254: R163.2 v1(311.84,28.7) 312.05,28.49 Q22.G
I2C_SLOT1_2N7002_G_SCL: length 2.2
  TOP w0.127: R301.2 296.26,24.28 v1(296.5,24.51) 297.23,24.51 Q20.G
I2C_SLOT1_2N7002_G_SDA: length 2.2
  TOP w0.127: R342.2 290.17,24.28 v1(290.4,24.51) 291.14,24.51 Q23.G
I2C_SLOT1_3V3_SCL: length 9.5
  TOP w0.127: J1.B5 291.83,20.35 292.05,20.57 293.85,20.57 R303.2 R307.2 296.88,21.95 297.09,22.16 Q20.S
I2C_SLOT1_3V3_SDA: length 5.8
  TOP w0.127: J1.B6 290.83,20.07 289.13,21.77 R304.2 R308.2 290.65,21.95 290.87,22.16 Q23.S
I2C_SLOT2_2N7002_G_SCL: length 2.7
  TOP w0.254: Q21.G 293.79,25.19 v1(294.45,24.52) R162.2
I2C_SLOT2_2N7002_G_SDA: length 2.7
  TOP w0.254: R192.2 288.86,25.02 288.37,25.02 288.11,24.77 v1(287.69,24.77) Q24.G
I2C_SLOT2_3V3_SCL: length 16.3
  TOP w0.127: Q21.S 294.72,27.75 294.93,27.96 R228.2 R203.2 296.24,28.32 295.99,28.57 293.7,28.57 v1(293.45,28.83)
  IN1 w0.097: v1(293.45,28.83) 292.91,29.36 292.91,31.14 291.8,32.26 291.8,33.78 292.81,34.8 292.81,35.92 291.83,36.9 J2.B5
I2C_SLOT2_3V3_SDA: length 15
  TOP w0.127: v1(290.4,28.83) 290.15,28.57 R210.2 R233.2 288.62,27.96 288.41,27.75 Q24.S
  IN1 w0.097: v1(290.4,28.83) 289.89,29.34 289.89,33.78 290.83,34.72 J2.B6
I2C_SLOT3_2N7002_G_SCL: length 2.1
  TOP w0.254: Q15.G 295.07,45.26 v1(295.07,44.83) 294.95,44.7 R107.2
I2C_SLOT3_2N7002_G_SDA: length 2.2
  TOP w0.254: Q18.G 289.76,45.32 v1(289.76,44.83) 289.89,44.7 R153.2
I2C_SLOT3_3V3_SCL: length 14.3
  TOP w0.127: Q15.S 294.42,48.18 293.81,48.79 R156.2 R226.2 292.83,48.62 v1(293.07,48.39)
  IN1 w0.097: v1(293.07,48.39) 292.05,49.4 292.05,51.82 291.92,51.94 291.92,54.23 292.69,54.99 292.69,57.22 J3.B5
I2C_SLOT3_3V3_SDA: length 15.2
  TOP w0.127: v1(289.15,48.39) R227.2 R159.2 290.13,48.77 290.36,48.54 Q18.S
  IN1 w0.097: J3.B6 290.72,54.93 290.05,53.88 289,49.91 289,49.02 v1(289.15,48.39)
I2C_SLOT4_2N7002_G_SCL: length 2.1
  TOP w0.254: Q14.G 295.18,65.48 v1(295.18,65.15) 295.05,65.02 R94.2
I2C_SLOT4_2N7002_G_SDA: length 4.4
  TOP w0.254: Q17.G 289.23,65.23 v1(289.23,63.86) 290.38,65 R152.2
I2C_SLOT4_3V3_SCL: length 15.4
  TOP w0.127: v1(292.79,68.73) 292.83,68.78 R222.2 R155.2 293.81,69.28 294.42,68.67 Q14.S
  BOTTOM w0.114: v1(292.79,68.73) 292.05,69.47 292.05,71.28 292.17,71.4 292.72,71.4 292.84,71.51 292.84,71.91 292.72,72.02 292.04,72.02 291.92,72.14 291.92,74.68 292.69,75.44 292.69,77.54 J4.B5
I2C_SLOT4_3V3_SDA: length 15.7
  TOP w0.127: Q17.S 290.23,68.73 290,68.96 R158.2 R223.2 v1(289.02,68.71)
  BOTTOM w0.114: J4.B6 290.83,75.61 289.89,74.68 289.89,73.15 290.02,73.03 290.02,69.7 v1(289.02,68.71)
I2C_SLOT5_2N7002_G_SCL: length 2.2
  TOP w0.254: R93.2 294.97,85.34 v1(295.1,85.47) 295.1,85.88 Q13.G
I2C_SLOT5_2N7002_G_SDA: length 3.1
  TOP w0.254: R108.2 290.18,85.02 v1(289.38,85.02) 289.38,85.71 Q16.G
I2C_SLOT5_3V3_SCL: length 18.3
  TOP w0.127: Q13.S 294.42,88.8 293.81,89.41 R154.2 R224.2 292.83,89.13 v1(292.94,89.03)
  BOTTOM w0.114: v1(292.94,89.03) 292.05,89.92 292.05,91.35 292.16,91.46 293.44,91.46 293.55,91.58 293.55,91.97 293.44,92.09 292.16,92.09 292.05,92.2 292.05,92.59 292.16,92.71 292.8,92.71 292.91,92.82 292.91,93.22 292.8,93.33 292.16,93.33 291.97,93.52 291.97,95.05 292.69,95.76 292.69,97.86 J9.B5
I2C_SLOT5_3V3_SDA: length 15.6
  TOP w0.127: Q16.S 290.23,89.18 290,89.41 R157.2 R225.2 v1(289.02,89.05)
  BOTTOM w0.114: J9.B6 290.83,95.81 290.02,95 290.02,90.04 v1(289.02,89.05)
JTAG_R_TCK: length 4.4
  TOP w0.127: R306.1 293.45,11.95 293.7,12.19 293.7,13.21 292.69,14.22 292.54,14.22 J1.A5
JTAG_R_TDI: length 1.8
  TOP w0.127: J1.A6 291.67,12.09 R347.1
JTAG_R_TDO: length 3.8
  TOP w0.127: J1.A7 289.83,12.76 289.33,12.26 289.33,11.77 R354.1
JTAG_R_TMS: length 1.8
  TOP w0.127: J1.A8 288.83,12.15 288.12,11.45 R355.1
JTAG_TCK: length 8.5
  TOP w0.127: J5.A5 291.83,5.94 291.65,6.11 291.65,9.74 R358.2 R306.2
JTAG_TDI: length 8.4
  TOP w0.127: J5.A6 290.83,5.76 291.27,6.2 291.27,9.93 290.78,10.41 R359.2 R347.2
JTAG_TDO: length 8.9
  TOP w0.127: J5.A7 289.83,5.6 290.89,6.66 290.89,9.65 R357.2 R354.2
JTAG_TMS: length 9.3
  TOP w0.127: J5.A8 288.83,5.95 289.64,6.76 289.64,9.65 289.13,10.16 288.6,10.16 R355.2 R356.2
JTAG_TRST_N: length 21.9
  TOP w0.127: R360.2 284.94,21.4 286.01,20.33 287.22,20.33 287.8,19.76 287.8,19.75 287.83,19.72 J1.B9
  BOTTOM w0.114: J1.B9 286.84,16.45 286.84,14.58 285.91,13.65 285.91,11.06 287.83,9.14 J5.B9
PCA9617_EN: length 4.1
  TOP w0.127: v5(116.74,37.29) 116.69,37.24 R276.1 R296.2 118.58,35.83 U12.5
PCIE_SLOT1_WAKE_N: length 5.7
  TOP w0.127: J1.B11 285.83,17.91 282.91,20.83 R370.2
PCIE_SLOT2_WAKE_N: length 4.9
  TOP w0.127: R8.2 J2.B11
PCIE_SLOT3_WAKE_N: length 4.8
  TOP w0.127: R7.2 J3.B11
PCIE_SLOT4_WAKE_N: length 4.9
  TOP w0.127: J4.B11 285.83,82.22 286.21,82.6 R6.2
PCIE_SLOT5_WAKE_N: length 5.3
  TOP w0.127: J9.B11 285.83,100.63 283.94,102.52 R5.2
PCIE_X1_SLOT_PRES_N: length 24.6
  TOP w0.127: J1.B17 277.46,17.43 275.82,19.08 275.82,19.81 275.39,20.24 274.17,20.24 273.41,21.01 272.06,21.01 271.33,21.74 R34.2
  BOTTOM w0.127: J5.B17 277.83,5.72 276.81,6.73 276.81,7.95 277.83,8.97 277.83,13.34 276.86,14.3 276.86,16.47 J1.B17
PCIE_X4_SLOT_PRES_N: length 15.1
  BOTTOM w0.127: J5.B31 263.83,5.87 263.43,6.27 263.43,12.01 263.7,12.29 263.7,13.51 262.71,14.5 262.71,16.32 J1.B31
PCIE_X8_SLOT_PRES_N: length 16.7
  BOTTOM w0.127: J5.B48 246.83,5.61 245.82,6.61 245.82,13.59 246.83,14.59 J1.B48
PCIE_X16_SLOT_PRES_N: length 131.2
  TOP w0.127: R34.1 272.13,21.95 272.59,21.49 273.84,21.49 v1(274.6,20.73) ; v1(300.31,15.37) R9.1 300.92,14.73 301.12,14.53 301.12,11.35 299.53,9.77 296.46,9.77 v1(295.56,8.86) 295.1,8.41 295.1,6.68 295.83,5.95 J5.A1
  IN2 w0.112: J1.B81 213.83,19.95 214.33,20.45 274.02,20.45 274.3,20.73 v1(274.6,20.73) 274.88,20.45 283.67,20.45 284.05,20.07 285.57,20.07 286.08,20.57 295.61,20.57 297.13,19.05 297.13,15.82 296.95,15.65 296.54,15.65 J1.A1 297.18,14.93 297.51,15.27 300.2,15.27 v1(300.31,15.37)
  BOTTOM w0.127: J1.B81 212.88,16.49 212.88,14.25 213.69,13.44 v1(213.69,8.71) 213.13,8.15 213.13,6.5 213.83,5.81 J5.B81
PD_FRU_WP: length 5.3
  TOP w0.127: R293.2 314.05,31.77 313.79,32.03 313.79,33.71 313.94,33.85 R294.1 314.66,34.23 v1(314.66,34.54) 313.89,35.31 313.89,35.84
PD_JTAG_TRST_N: length 38
  TOP w0.127: R346.1 v1(112.6,68.33)
  IN2 w0.112: v1(112.6,68.33) 111.9,67.62 104.87,67.62 103.01,65.76 102,65.76 98.54,62.3 87.06,62.3 85.85,63.52 85.85,69.64 v4(85.36,70.13)
  BOTTOM w0.114: U1.P7 v4(85.36,70.13)
PD_SLOT2_B81: length 5.7
  TOP w0.127: J2.B81 213.83,40.76 212.78,41.8 R200.2
PD_SLOT3_B81: length 4.9
  TOP w0.127: J3.B81 213.8,58.1 R199.2
PD_SLOT4_B81: length 4.8
  TOP w0.127: R198.2 213.93,81.89 213.83,81.79 J4.B81
PD_SLOT5_B81: length 5
  TOP w0.127: R197.2 213.93,98.81 J9.B81
PD_STRAP_RESERVED_0: length 9.9
  TOP w0.127: R111.2 v1(68.78,59.69)
  IN2 w0.112: v1(68.78,59.69) 68.78,60.25 66.88,62.15 66.88,66.61 v4(66.36,67.13)
  BOTTOM w0.127: U1.AM4 v4(66.36,67.13)
PD_STRAP_RESERVED_1: length 14.1
  TOP w0.127: R112.2 v1(78.31,59.69) 78.31,60.3 75.87,62.74 75.87,70.41 75.36,70.92 v4(75.36,71.13)
  BOTTOM w0.127: U1.AC8 v4(75.36,71.13)
PD_STRAP_RESERVED_2: length 13.8
  TOP w0.089: v4(91.36,71.13) 92.8,71.13 93.39,70.54 98.75,70.54 99.06,70.23 99.52,70.23
  TOP w0.127: 99.52,70.23 v1(102.82,70.23) R164.2
  BOTTOM w0.127: U1.H8 v4(91.36,71.13)
PD_STRAP_RESERVED_3: length 30.8
  TOP w0.127: R165.2 v1(61.67,52.83)
  IN2 w0.112: v1(61.67,52.83) 61.67,68.45 65.86,72.64 68.15,72.64 69.17,73.66 71.55,73.66 71.92,74.03 71.92,74.69 v4(72.36,75.13)
  BOTTOM w0.127: U1.AF12 v4(72.36,75.13)
PD_STRAP_RESERVED_4: length 30.7
  TOP w0.127: R166.2 v1(112.6,74.04)
  IN2 w0.112: v4(87.36,70.13) 88.24,70.13 88.85,69.52 88.85,68.83 89.05,68.63 99.06,68.63 99.65,69.22 99.65,70.48 101.8,72.64 111.2,72.64 v1(112.6,74.04)
  BOTTOM w0.127: U1.M7 v4(87.36,70.13)
