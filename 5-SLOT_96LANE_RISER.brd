# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 40.21,45.21 40.66,45.21 46.15,45.21 46.31,45.06 46.31,36.06 46.31,36.04 46.71,35.64 50.55,35.64 50.9,35.99 50.9,37.34 51,37.44 52.48,37.44 52.55,37.36 52.55,35.03 51.74,34.21 45.09,34.21 43.64,35.66 43.64,41.27 41.23,43.69 38.05,43.69 37.8,43.94 37.8,44.96 38.18,45.34 40.08,45.34
GND on TOP (solid shape): 87.91,57.61 87.91,54.99 86.92,54 86.92,53.84 86.91,53.81 86.89,53.78 86.76,53.49 86.89,53.19 86.91,53.17 86.92,53.14 86.92,52.76 86.64,52.48 85.55,52.48 85.27,52.76 85.27,58.01 85.52,58.27 87.25,58.27
GND on TOP (solid shape): 27.03,97.37 28.33,97.37 28.68,97.02 29.13,97.02 29.21,96.99 29.28,96.99 29.52,96.99 29.57,96.96 29.59,96.91 29.59,94.83 29.62,94.8 29.62,94.7 29.72,94.6 33.4,94.6 33.46,94.58 33.48,94.53 33.48,93.77 33.51,93.74 33.51,93.21 32.99,92.68 26.33,92.68 23.43,95.59 23.43,97.24 23.78,97.6 26.8,97.6
GND on TOP (solid shape): 284.18,115.95 284.18,113.79 284.8,113.17 286.91,113.17 288.19,111.88 290.46,111.88 291.31,112.73 292.54,112.73 293.12,112.15 293.12,111.13 292.49,110.51 292.49,108.73 292.94,108.29 293.85,108.29 295.1,107.05 296.29,107.05 297.33,106 297.33,104.63 296.61,103.91 296.09,103.91 295.93,103.76 293.96,103.76 293.96,103.76 293.19,103.76 292.69,104.27 292.69,104.78 292.56,104.9 290.91,104.9 290.89,104.89 288.1,104.89 287.1,103.89 284.43,103.89 283.51,104.8 283.51,110.22 283.25,110.49 282.3,110.49 282.19,110.59 282.19,116.23 282.32,116.35 283.77,116.35
GND on TOP (solid shape): 91.03,41.1 91.03,40.55 90.98,40.49 90.24,40.49 90.19,40.44 90.19,39.31 90.19,39.2 90.04,39.05 89.15,39.05 88.87,39.33 88.87,39.52 88.88,39.53 88.9,39.68 88.88,39.83 88.87,39.84 88.87,40.18 88.88,40.19 88.9,40.34 88.88,40.49 88.87,40.5 88.87,40.84 88.88,40.85 88.9,41 88.88,41.15 88.87,41.16 88.87,41.43 89.08,41.64 90.5,41.64
GND on TOP (solid shape): 282.36,7.45 283.26,9.11 285.14,9.25 286.12,8.26 286.18,8.12 286.23,7.97 286.31,7.88 286.31,6.79 285.95,6.43 285.9,6.43 285.79,6.54 285.79,7.45 284.33,8.92 282.87,7.45 282.87,1.5 282.85,1.45 282.79,1.43 282.58,1.43 282.54,1.45 282.51,1.5 282.51,5.95 282.43,5.95 282.38,5.97 282.36,6.02
GND on TOP (solid shape): outline of 172 points within 0.59,108 11,117.73
GND on TOP (solid shape): 320.78,117.74 321.32,117.51 321.54,116.97 321.54,9.68 321.32,9.14 320.78,8.92 297.74,8.92 296.52,8.43 295.96,7.24 295.96,7.21 295.89,7.14 295.61,7.14 295.5,7.19 295.46,7.3 296.18,8.81 297.74,9.42 320.78,9.42 320.96,9.5 321.03,9.68 321.03,116.97 320.96,117.15 320.78,117.23 2,117.23 1.3,116.94 1.02,116.24 1.02,34.44 1.03,34.28 1.05,34.15 1.09,34.03 1.15,33.92 1.24,33.79 1.3,33.71 1.38,33.64 1.51,33.56 1.62,33.5 1.75,33.46 1.87,33.43 2.03,33.42 29.75,33.42 29.91,33.31 30.08,33.2 30.15,33.03 30,32.92 2.02,32.92 1.81,32.93 1.61,32.97 1.43,33.03 1.25,33.12 1.08,33.23 0.95,33.35 0.83,33.49 0.71,33.66 0.62,33.84 0.56,34.02 0.52,34.21 0.51,34.42 0.51,116.24 0.94,117.3 2,117.74
GND on TOP (solid shape): outline of 343 points within 28,32.9 43,42.9
GND on TOP (solid shape): outline of 343 points within 128,32.9 143,42.9
GND on TOP (solid shape): outline of 343 points within 172.05,105 187.05,115
GND on TOP (solid shape): outline of 343 points within 305.25,62.77 320.25,72.77
GND on TOP (solid shape): outline of 343 points within 305.25,102 320.25,112
GND on TOP (solid shape): outline of 343 points within 305.25,11.41 320.25,21.41
GND on TOP (solid shape): outline of 370 points within 140.84,1.43 213.18,33.42
GND on BOTTOM (solid shape): 50.07,81.43 50.07,78.99 49.84,78.77 45.43,78.77 45.07,79.12 45.07,80.12 47.45,82.5 49,82.5
GND on BOTTOM (solid shape): 81.25,42.4 81.25,40.88 81.09,40.71 79.39,40.71 79.27,40.82 79.27,42.37 79.37,42.48 81.18,42.48
GND on BOTTOM (solid shape): 95.45,41.53 95.45,40.01 95.2,39.75 93.04,39.75 92.91,39.88 92.91,41.53 93.42,42.04 94.95,42.04
GND on BOTTOM (solid shape): 96.78,35.03 96.78,33.93 96.57,33.73 92.84,33.73 92.61,33.96 92.61,34.77 92.99,35.15 96.65,35.15
GND on BOTTOM (solid shape): 109.3,34.92 109.3,33.91 109.17,33.78 105.23,33.78 104.98,34.04 104.98,34.92 105.11,35.05 109.17,35.05
GND on BOTTOM (solid shape): 296.06,115.96 296.06,115.1 295.83,114.87 293.75,114.87 293.67,114.94 293.67,116.06 293.8,116.19 295.83,116.19
GND on BOTTOM (solid shape): 298.48,91.21 298.48,83.23 298.4,83.16 297.18,83.16 297.1,83.23 297.1,91.21 297.21,91.31 298.37,91.31
GND on BOTTOM (solid shape): 44.29,94.6 44.29,91.81 43.56,91.08 41.45,91.08 41.02,91.52 41.02,94.36 41.4,94.74 44.15,94.74
GND on BOTTOM (solid shape): 60.16,90.78 60.16,89.67 59.95,89.46 54.42,89.46 54.19,89.69 54.19,90.78 54.32,90.91 60.03,90.91
GND on BOTTOM (solid shape): 102.31,35.05 102.31,34.04 102.06,33.78 97.99,33.78 97.74,34.04 97.74,34.92 97.99,35.18 102.19,35.18
GND on BOTTOM (solid shape): 110.71,41.2 110.71,39.67 110.66,39.62 109.26,39.62 109.21,39.57 108.24,39.57 108.17,39.65 108.17,40.13 109.47,41.44 110.46,41.44
GND on BOTTOM (solid shape): 301.12,116.06 301.12,112.48 300.63,112 299.54,112 299.53,111.99 299.33,111.99 299.11,112.21 299.11,115.91 299.34,116.14 301.04,116.14
GND on BOTTOM (solid shape): 60.1,94.69 60.1,93.34 59.89,93.14 54.31,93.14 54.13,93.32 54.13,94.69 54.26,94.82 59.97,94.82
GND on BOTTOM (solid shape): 98.63,40.51 102.31,40.51 102.44,40.39 102.44,39.62 102.19,39.37 97.99,39.37 97.74,39.62 97.74,40.64 97.99,40.89 98.25,40.89
GND on BOTTOM (solid shape): 44.67,52.44 44.67,51.45 44.53,51.31 40.69,51.31 40.51,51.49 40.51,52.5 40.97,52.96 44.15,52.96
GND on BOTTOM (solid shape): 69.66,39.79 69.66,36.14 68.5,34.98 64.28,34.98 64.09,35.18 64.09,36.06 64.21,36.19 65.49,36.19 67.77,38.47 67.77,39.15 68.48,39.86 69.6,39.86
GND on BOTTOM (solid shape): 313.67,92.1 313.67,91.79 313.66,91.79 313.66,90.24 313.51,90.09 311.59,90.09 311.56,90.1 311.53,90.11 311.4,90.24 311.4,92.05 311.51,92.15 313.62,92.15
GND on BOTTOM (solid shape): 291.01,116.61 291.01,115.39 290.81,115.19 289.15,115.19 289.13,115.21 289.13,115.57 288.88,115.82 288.37,115.82 288.24,115.95 288.24,116.46 288.62,116.84 290.78,116.84
GND on BOTTOM (solid shape): 297.79,106.59 297.79,105.18 296.52,103.91 295.8,103.91 295.63,103.74 293.12,103.74 292.71,104.15 292.71,104.99 293.38,105.66 293.84,105.66 294.12,105.94 294.2,105.94 294.2,106.02 294.79,106.61 297.76,106.61
GND on BOTTOM (solid shape): 283.54,116.33 284.05,116.33 284.18,116.2 284.18,113.54 284.28,113.44 284.28,112.65 284.15,112.52 283.59,112.52 282.47,113.64 282.47,115.38 282.08,115.77 281.61,115.77 281.54,115.85 281.54,116.32 281.56,116.34 283.53,116.34
GND on BOTTOM (solid shape): 91.52,41.4 91.52,35.73 90.5,34.72 82.98,34.72 82.56,35.14 82.56,35.53 83.62,36.58 83.92,36.58 83.92,36.59 84.1,36.59 84.11,36.6 84.4,36.6 85.84,38.03 87.77,38.03 89.74,40.01 89.74,41.66 89.99,41.91 91.01,41.91
GND on BOTTOM (solid shape): 27.06,97.37 28.15,97.37 28.73,96.79 29.42,96.79 29.67,96.53 29.67,94.7 29.78,94.6 32.75,94.6 32.82,94.53 32.82,93.92 32.89,93.85 32.89,93.74 33.36,93.74 33.51,93.59 33.51,93.21 33.06,92.76 26.26,92.76 23.43,95.59 23.43,97.6 23.53,97.7 26.73,97.7
GND on BOTTOM (solid shape): 310.95,85.93 311,85.9 311.02,85.85 311.02,84.91 311.02,84.6 310.83,84.41 309.28,84.41 308.57,83.7 308.27,83.7 308.03,83.94 308.03,84.32 308.18,84.48 308.58,84.48 308.71,84.6 308.8,84.6 308.8,84.69 309,84.9 309,85.35 309.58,85.93
GND on BOTTOM (solid shape): 27.11,85.64 29.75,85.64 29.8,85.59 29.8,83.43 30.31,82.92 32.75,82.92 32.82,82.84 32.82,82.23 32.82,82.23 32.82,82.14 32.92,82.04 33.48,82.04 33.61,81.92 33.61,81.41 33.28,81.08 26.26,81.08 23.43,83.91 23.43,85.92 23.53,86.02 26.73,86.02
GND on BOTTOM (solid shape): 114.36,40.97 114.36,39.45 114.28,39.37 114.28,38.48 114.36,38.4 114.36,38.23 114.13,38 113.98,38 113.93,37.95 113.93,36.4 113.83,36.3 112.36,36.3 112.33,36.32 112.33,37.97 112.41,38.05 112.81,38.05 113.42,38.66 113.42,39.98 113.3,40.09 112.45,40.09 112.43,40.11 112.43,41.02 112.6,41.19 114.15,41.19
GND on BOTTOM (solid shape): 305.74,93.12 305.74,90.95 305.64,90.85 305.58,90.85 305.56,90.84 305.54,90.85 305.42,90.85 305.31,90.83 305.3,90.83 305.18,90.83 305.15,90.79 305.12,90.79 304.32,89.99 302.16,89.99 301.5,90.65 301.5,90.93 301.45,90.98 300.71,90.98 300.69,91.01 300.69,91.9 300.81,92.02 301.22,92.02 301.86,91.39 301.86,91.21 302.16,90.91 303.1,90.91 303.73,91.54 303.73,93.09 303.86,93.22 305.64,93.22
GND on BOTTOM (solid shape): 31.5,91.22 31.5,90.92 31.38,90.8 30.82,90.8 30.41,90.39 29.7,90.39 29.64,90.44 29.64,90.45 29.55,90.57 29.44,90.65 29.43,90.66 28.99,91.1 28.99,91.3 28.91,91.38 28.14,91.38 28.02,91.25 28.02,89.55 27.94,89.47 27.18,89.47 27.15,89.5 27.15,90.08 27.05,90.19 26.09,90.19 25.51,90.77 24.72,90.77 24.39,91.1 23.53,91.1 23.48,91.15 23.48,91.71 23.68,91.91 30.82,91.91
GND on BOTTOM (solid shape): 31.5,102.91 31.5,102.68 31.45,102.63 30.89,102.63 30.33,102.07 29.7,102.07 29.69,102.08 29.58,102.25 29.42,102.36 29.4,102.37 28.99,102.78 28.99,102.98 28.85,103.12 28.09,103.12 28.02,103.05 28.02,101.23 27.97,101.18 27.21,101.18 27.15,101.23 27.15,101.82 27.12,101.86 26.1,101.86 25.6,102.36 24.58,102.36 24.33,102.11 23.83,102.11 23.7,102.23 23.7,102.74 24.55,103.59 30.82,103.59
GND on BOTTOM (solid shape): 278.38,111.28 278.38,109.68 278.36,109.51 278.38,109.36 278.38,109.35 278.38,107.45 278.36,107.27 278.38,107.13 278.38,107.11 278.38,105.21 278.36,105.03 278.38,104.89 278.38,104.88 278.38,104.39 278.1,104.1 276.98,104.1 276.77,104.31 276.77,105.26 276.99,105.47 276.99,107.47 276.77,107.68 276.77,111.1 276.78,111.13 276.79,111.16 277.02,111.38 277.03,111.39 278.27,111.39
GND on BOTTOM (solid shape): 54.05,50.75 54.05,49 54.92,48.13 63.45,48.13 64.64,46.94 65.46,46.94 65.92,46.47 65.92,45.1 64.88,44.06 63.69,44.06 62.45,42.82 61.53,42.82 61.09,42.37 61.09,40.6 61.71,39.97 61.71,38.72 61.27,38.28 53.22,38.28 52.67,37.73 52.67,36.53 52.66,36.46 52.67,36.4 52.67,36.25 52.71,36.12 52.72,36.08 52.71,36.05 52.69,36 52.68,35.94 52.66,35.83 52.68,35.71 52.68,35.7 52.68,35.31 52.2,34.83 45.57,34.83 44.78,35.61 44.78,41.4 42.14,44.04 40.74,44.04 40.62,44.17 40.62,44.96 40.77,45.11 44.81,45.11 45.34,45.64 45.34,46.56 45.59,46.81 46.36,46.81 46.46,46.71 46.46,43.76 46.86,43.36 51.46,43.36 51.77,43.66 51.77,51.03 52,51.26 53.54,51.26
GND on BOTTOM (solid shape): 282.59,8.38 283.75,9.34 285.25,9.19 285.45,9.19 286.25,8.4 286.25,6.77 286.21,6.73 285.88,6.73 285.79,6.82 285.79,7.45 285.74,7.82 285.61,8.15 285.61,8.16 284.26,8.91 282.99,8.03 282.87,7.94 282.74,7.98 282.59,8.13
GND on BOTTOM (solid shape): 309.22,55.55 310.54,55.55 310.69,55.4 310.69,54.61 310.58,54.5 308.93,54.5 308.92,54.48 308.86,54.48 308.59,54.21 308.59,53.92 308.58,53.91 308.56,53.75 308.58,53.59 308.59,53.58 308.59,53.31 308.69,53.21 308.69,53.06 308.97,52.78 310.57,52.78 310.77,52.58 310.77,52.5 310.8,52.47 310.8,51.79 310.65,51.64 310.5,51.64 310.41,51.66 310.34,51.67 309.89,51.67 309.87,51.68 309.64,51.71 309.41,51.64 308.69,51.64 308.23,51.18 305.18,51.18 304.8,51.56 304.8,52.32 304.75,52.37 304.75,52.53 304.4,52.53 304.39,52.54 304.24,52.56 304.09,52.54 304.08,52.53 303.88,52.53 303.84,52.58 303.84,53.21 303.94,53.32 304.24,53.32 304.31,53.32 304.38,53.34 304.65,53.34 304.66,53.35 304.75,53.35 304.75,54.31 304.4,54.31 304.32,54.33 304.24,54.34 303.89,54.34 303.83,54.36 303.81,54.41 303.81,55.07 303.84,55.1 304.24,55.1 304.32,55.1 304.4,55.12 304.75,55.12 304.75,55.3 304.78,55.32 304.78,55.75 304.9,55.88 308.89,55.88
GND on BOTTOM (solid shape): outline of 108 points within 140.85,9.56 212.51,33.42
GND on BOTTOM (solid shape): outline of 343 points within 28,32.9 43,42.9
GND on BOTTOM (solid shape): outline of 343 points within 128,32.9 143,42.9
GND on BOTTOM (solid shape): outline of 343 points within 172.05,105 187.05,115
GND on BOTTOM (solid shape): outline of 343 points within 305.25,62.77 320.25,72.77
GND on BOTTOM (solid shape): outline of 343 points within 305.25,102 320.25,112
GND on BOTTOM (solid shape): outline of 343 points within 305.25,11.41 320.25,21.41
GND on GND (solid shape): outline of 22913 points within 0.51,5.69 321.54,117.74
GND on IN1 (solid shape): 308.48,54.99 308.48,51.97 308.26,51.74 305.13,51.74 304.85,52.02 304.85,54.86 305.13,55.14 308.33,55.14
GND on IN1 (solid shape): outline of 115 points within 140.85,5.69 213.18,33.42
GND on IN1 (solid shape): 320.78,117.74 321.32,117.51 321.54,116.97 321.54,9.68 321.32,9.14 320.78,8.92 297.74,8.92 296.48,8.39 295.96,7.14 295.96,5.69 295.45,5.69 295.45,7.14 296.12,8.75 297.74,9.42 320.78,9.42 320.96,9.5 321.03,9.68 321.03,116.97 320.96,117.15 320.78,117.23 2,117.23 1.3,116.94 1.02,116.24 1.02,34.44 1.03,34.28 1.05,34.15 1.09,34.03 1.15,33.92 1.24,33.79 1.3,33.71 1.38,33.64 1.51,33.56 1.62,33.5 1.75,33.46 1.87,33.43 2.03,33.42 29.75,33.42 29.91,33.31 30.08,33.2 30.15,33.03 30,32.92 2.02,32.92 1.81,32.93 1.61,32.97 1.43,33.03 1.25,33.12 1.08,33.23 0.95,33.35 0.83,33.49 0.71,33.66 0.62,33.84 0.56,34.02 0.52,34.21 0.51,34.42 0.51,116.24 0.94,117.3 2,117.74
GND on GND1 (solid shape): outline of 22735 points within 0.51,5.69 321.54,117.74
GND on IN2 (solid shape): outline of 115 points within 140.85,5.66 213.18,33.42
GND on IN2 (solid shape): 320.78,117.74 321.32,117.51 321.54,116.97 321.54,9.68 321.32,9.14 320.78,8.92 297.74,8.92 296.48,8.39 295.96,7.14 295.96,5.69 295.45,5.69 295.45,7.14 296.12,8.75 297.74,9.42 320.78,9.42 320.96,9.5 321.03,9.68 321.03,116.97 320.96,117.15 320.78,117.23 2,117.23 1.3,116.94 1.02,116.24 1.02,34.44 1.03,34.28 1.05,34.15 1.09,34.03 1.15,33.92 1.24,33.79 1.3,33.71 1.38,33.64 1.51,33.56 1.62,33.5 1.75,33.46 1.87,33.43 2.03,33.42 29.75,33.42 29.91,33.31 30.08,33.2 30.15,33.03 30,32.92 2.02,32.92 1.81,32.93 1.61,32.97 1.43,33.03 1.25,33.12 1.08,33.23 0.95,33.35 0.83,33.49 0.71,33.66 0.62,33.84 0.56,34.02 0.52,34.21 0.51,34.42 0.51,116.24 0.94,117.3 2,117.74
GND on VCC (solid shape): outline of 6168 points within 124.35,5.69 321.03,98.68
GND on IN3 (solid shape): outline of 115 points within 140.85,5.69 213.18,33.42
GND on IN3 (solid shape): 320.78,117.74 321.32,117.51 321.54,116.97 321.54,9.68 321.32,9.14 320.78,8.92 297.74,8.92 296.48,8.39 295.96,7.14 295.96,5.69 295.45,5.69 295.45,7.14 296.12,8.75 297.74,9.42 320.78,9.42 320.96,9.5 321.03,9.68 321.03,116.97 320.96,117.15 320.78,117.23 2,117.23 1.3,116.94 1.02,116.24 1.02,34.44 1.03,34.28 1.05,34.15 1.09,34.03 1.15,33.92 1.24,33.79 1.3,33.71 1.38,33.64 1.51,33.56 1.62,33.5 1.75,33.46 1.87,33.43 2.03,33.42 29.75,33.42 29.91,33.31 30.08,33.2 30.15,33.03 30,32.92 2.02,32.92 1.81,32.93 1.61,32.97 1.43,33.03 1.25,33.12 1.08,33.23 0.95,33.35 0.83,33.49 0.71,33.66 0.62,33.84 0.56,34.02 0.52,34.21 0.51,34.42 0.51,116.24 0.94,117.3 2,117.74
GND on GND2 (solid shape): outline of 22735 points within 0.51,5.69 321.54,117.74
GND on IN4 (solid shape): outline of 115 points within 140.85,5.69 213.18,33.42
GND on IN4 (solid shape): 320.78,117.74 321.32,117.51 321.54,116.97 321.54,9.68 321.32,9.14 320.78,8.92 297.74,8.92 296.48,8.39 295.96,7.14 295.96,5.69 295.45,5.69 295.45,7.14 296.12,8.75 297.74,9.42 320.78,9.42 320.96,9.5 321.03,9.68 321.03,116.97 320.96,117.15 320.78,117.23 2,117.23 1.3,116.94 1.02,116.24 1.02,34.44 1.03,34.28 1.05,34.15 1.09,34.03 1.15,33.92 1.24,33.79 1.3,33.71 1.38,33.64 1.51,33.56 1.62,33.5 1.75,33.46 1.87,33.43 2.03,33.42 29.75,33.42 29.91,33.31 30.08,33.2 30.15,33.03 30,32.92 2.02,32.92 1.81,32.93 1.61,32.97 1.43,33.03 1.25,33.12 1.08,33.23 0.95,33.35 0.83,33.49 0.71,33.66 0.62,33.84 0.56,34.02 0.52,34.21 0.51,34.42 0.51,116.24 0.94,117.3 2,117.74
GND on GND3 (solid shape): outline of 23689 points within 0.51,5.69 321.54,117.74
GND_L on IN2 (solid shape): outline of 723 points within -19.49,-9.03 -2.51,364.68
GND_L on IN4 (solid shape): outline of 723 points within -19.49,-9.03 -2.51,364.68
P0V9 on TOP (solid shape): outline of 230 points within 43.54,81.7 61.09,104.01
P0V9 on BOTTOM (solid shape): outline of 336 points within 43.54,81.79 61.95,101.98
P0V9 on IN1 (solid shape): outline of 799 points within 42.75,81.81 59.49,102.26
P0V9 on IN2 (solid shape): outline of 770 points within 43.51,81.58 59.51,102.23
P0V9 on VCC1 (solid shape): 103.96,102.64 103.96,60.43 99.92,56.39 58.35,56.39 44.02,70.72 44.02,99.31 65.66,99.31 65.66,99.26 65.68,99.2 65.7,99.15 65.72,99.1 65.76,99.06 65.8,99.02 65.84,98.99 65.89,98.96 65.95,98.94 66,98.93 66.06,98.93 66.11,98.94 66.17,98.95 66.22,98.97 66.26,99 66.31,99.04 66.34,99.08 66.38,99.13 66.4,99.18 66.41,99.23 66.42,99.29 66.42,99.34 66.41,99.4 66.4,99.45 66.38,99.5 66.34,99.55 66.31,99.59 66.26,99.62 66.22,99.65 66.17,99.68 66.11,99.69 66.06,99.7 66,99.69 65.95,99.68 65.89,99.67 65.84,99.64 65.8,99.61 65.76,99.57 65.72,99.52 65.7,99.48 65.68,99.42 65.66,99.37 65.66,99.31 44.02,99.31 44.02,102.13 45.4,103.5 103.1,103.5
P0V9 on IN3 (solid shape): outline of 22158 points within 43.7,68.45 92.91,103.63
P0V9_A on TOP (solid shape): 42.01,51.08 43.23,51.08 43.23,51.08 43.54,51.08 43.54,51.08 44.76,51.08 44.76,51.08 46.03,51.08 46.1,51 46.1,45.54 46.08,45.49 46.03,45.47 40.77,45.47 40.72,45.52 40.72,46.48 40.85,46.61 40.85,47.88 39.96,48.77 39.96,49 39.96,49.02 39.96,50.93 40.07,51.04 40.48,51.04 40.51,51.08 41.71,51.08 41.71,51.08 42.01,51.08
P0V9_A on BOTTOM (solid shape): 46.1,51 46.1,47.47 46,47.37 45.75,47.37 44.99,46.61 44.99,45.8 44.65,45.47 40.96,45.47 40.9,45.49 40.88,45.54 40.88,47.32 40.14,48.06 40.07,48.12 39.99,48.18 39.97,48.21 39.96,48.24 39.96,50.8 40.21,51.05 46.05,51.05
P0V9_A on VCC (solid shape): outline of 368 points within 38.25,33.42 110.06,90.3
P0V9_AGND on BOTTOM (solid shape): 13.99,113.38 13.99,111.99 14.23,111.76 15.85,111.76 17.37,113.28 17.7,113.28 17.75,113.23 17.76,113.2 17.76,113.18 17.76,113 17.83,112.83 17.83,111.27 17.58,111.02 17.58,110.43 18.22,109.79 19.96,109.79 20.63,109.12 20.63,108.03 20.57,107.97 20.35,107.97 20.19,108.13 20.19,108.13 19.33,108.99 18.55,108.99 18.51,109 18.14,109.04 17.84,108.8 17.84,108.79 17.38,108.33 17.38,108.33 17.2,108.15 16.71,108.15 16.69,108.18 16.69,108.81 16.57,108.95 16.4,109.04 16.38,109.04 16.21,109.22 16.21,109.78 16.77,110.34 16.77,110.82 16.49,111.1 16,111.1 15.22,110.31 14.91,110.31 14.78,110.19 14.78,108.99 15.04,108.74 15.04,107.29 14.43,106.68 13.64,106.68 11.91,108.41 11.91,109.96 13.08,111.13 13.08,112.19 13.26,112.37 13.26,113.61 13.41,113.77 13.61,113.77
P0V9A_AGND on TOP (solid shape): 68.74,44.11 68.74,41.42 68.72,41.39 67.19,41.39 67.12,41.47 67.12,44.08 67.17,44.13 68.72,44.13
P0V9A_AGND on BOTTOM (solid shape): 69.93,45.09 69.93,44.2 70.31,43.81 71.83,43.81 72.21,43.43 72.21,42.67 71.96,42.42 69.55,42.42 68.91,43.05 68.91,44.96 69.17,45.21 69.8,45.21
P0V9A_OUT on TOP (solid shape): 51.77,51.05 51.77,48.26 53.03,47 53.03,45.43 53.03,45.42 53.03,39.14 51.61,37.72 50.88,37.72 50.57,37.41 50.57,36.11 50.37,35.91 46.82,35.91 46.56,36.17 46.56,45.14 46.64,45.21 46.64,47.17 46.64,47.4 46.64,49.2 46.64,49.43 46.64,51.13 46.94,51.44 51.39,51.44
P0V9A_OUT on BOTTOM (solid shape): 51.51,51.05 51.51,43.94 51.26,43.69 46.93,43.69 46.75,43.87 46.75,51.24 47.07,51.56 51,51.56
P1V8 on TOP (solid shape): 84.91,58.42 84.91,52.91 84.63,52.63 83.56,52.63 83.22,52.96 83.22,58.59 83.44,58.8 84.53,58.8
P1V8 on BOTTOM (solid shape): 106.88,40.13 106.88,37.59 107.27,37.21 110.19,37.21 110.44,36.96 110.44,35.94 110.06,35.56 104.98,35.56 104.47,36.07 104.47,40.13 104.85,40.51 106.5,40.51
P1V8 on BOTTOM (solid shape): 45.8,60.96 45.8,55.12 45.67,54.99 44.65,54.99 44.4,55.24 44.4,55.92 44.52,56.2 44.47,56.49 44.46,56.51 44.46,57.84 44.4,57.91 44.4,57.91 43.77,58.55 43.77,60.96 44.02,61.21 45.54,61.21
P1V8 on IN1 (solid shape): outline of 25819 points within 44.15,35.94 125.35,92.75
P1V8_A on TOP (solid shape): 102.24,38.68 102.24,35.69 101.98,35.43 97.36,35.43 97.11,35.69 97.11,38.23 97.74,38.86 102.06,38.86
P1V8_A on BOTTOM (solid shape): 102.24,38.76 102.24,35.66 102.01,35.43 101.42,35.43 101.3,35.31 97.36,35.31 97.11,35.56 97.11,38.23 97.74,38.86 102.14,38.86
P1V8_A on IN2 (solid shape): outline of 24493 points within 56.85,71.41 104.73,103.5
P1V8_A on VCC (solid shape): 128.09,94 128.09,40.51 127.61,39.25 127.44,37.9 127.92,35.64 129.28,33.77 129.32,33.62 129.22,33.51 129.13,33.48 129.06,33.42 124.48,33.42 124.23,33.53 123.98,33.42 119.4,33.42 119.15,33.53 118.9,33.42 114.32,33.42 114.07,33.53 113.82,33.42 109.24,33.42 108.99,33.53 108.74,33.42 104.16,33.42 103.91,33.53 103.66,33.42 99.08,33.42 98.83,33.53 98.58,33.42 96.8,33.42 96.75,33.45 96.72,33.5 96.72,39.52 97.08,39.88 97.11,39.88 97.33,39.98 97.44,40.2 97.44,40.23 110.57,53.36 110.57,90.02 109.78,90.81 59.23,90.81 59.19,90.81 59.17,90.84 58.88,90.98 58.59,90.84 58.56,90.81 58.53,90.81 57.97,90.81 57.55,91.22 57.54,91.27 57.55,91.29 57.58,91.36 57.58,91.44 57.48,91.69 57.23,91.8 57.15,91.79 57.08,91.76 57.03,91.76 56.99,91.78 56.85,91.93 56.85,102.89 57.46,103.5 118.59,103.5
P1V8A_AGND on TOP (solid shape): 81.63,39.86 81.63,35.75 81.61,35.72 81.41,35.72 81.36,35.77 81.36,36.13 81.36,36.2 81.33,36.28 81.33,36.56 81.3,36.59 81.18,36.59 81.18,36.59 80.29,36.59 80.24,36.64 80.24,38.97 80.34,39.07 81.26,39.07 81.26,39.08 81.33,39.15 81.33,39.38 81.36,39.46 81.36,39.53 81.36,39.81 81.38,39.87 81.44,39.89 81.61,39.89
P1V8A_AGND on BOTTOM (solid shape): 81.23,37.83 81.23,37.71 81.22,37.68 81.2,37.65 80.95,37.4 80.36,37.4 80.26,37.3 80.26,36.1 80.24,36.05 80.19,36.02 79.99,35.98 79.81,35.87 79.25,35.87 79.12,36 79.12,36.96 78.97,37.12 78.84,37.12 78.66,37.29 78.66,37.62 78.86,37.83 80.11,37.83 80.31,38.03 81.03,38.03
P1V8A_OUT on TOP (solid shape): 92.66,39.24 96.22,39.24 96.6,38.86 96.6,36.2 95.96,35.56 92.66,35.56 91.77,34.67 89.87,34.67 89.36,35.18 89.36,37.59 89.87,38.1 90.25,38.1 90.5,38.35 90.5,40.01 90.63,40.13 91.77,40.13
P3V3 on TOP (solid shape): 282.02,70.99 282.02,69.34 281.76,69.09 279.99,69.09 279.6,69.47 279.6,70.87 279.86,71.12 281.89,71.12
P3V3 on TOP (solid shape): 277.7,116.76 277.7,111.76 277.57,111.63 275.03,111.63 274.65,112.01 274.65,116.33 275.16,116.84 277.62,116.84
P3V3 on TOP (solid shape): 289,96.77 289,96.74 288.85,96.23 288.99,95.71 289,95.69 289,95.5 288.68,95.18 288.66,95.18 287.85,94.27 288.55,93.28 288.57,93.27 288.88,92.96 288.88,92.7 288.88,91.95 288.75,91.82 284.3,91.82 284.23,91.9 284.23,93.37 286.72,95.86 286.72,96.82 286.97,97.08 288.7,97.08
P3V3 on TOP (solid shape): 288.62,76.33 288.62,74.91 288.61,74.86 288.57,74.84 287.86,74.01 288.34,73.04 288.35,73.04 288.86,72.53 288.86,71.5 288.74,71.37 282.91,71.37 282.84,71.44 282.84,71.92 285.97,75.06 285.98,75.06 286.21,75.06 286.46,75.31 286.46,75.33 286.66,75.7 286.65,76.12 286.65,76.13 286.97,76.45 286.97,76.5 286.99,76.56 287.05,76.58 288.37,76.58
P3V3 on TOP (solid shape): 289,35.94 289,35.78 288.99,35.76 288.85,35.25 288.99,34.75 289,34.73 289,34.67 288.51,34.18 288.5,34.18 287.91,33.59 287.98,32.77 287.99,32.75 287.99,32.64 288.52,32.11 288.52,31.43 288.62,31.33 288.62,30.86 288.49,30.73 284.64,30.73 284.58,30.73 284.57,30.75 282.77,30.75 282.65,30.86 282.65,31.37 285.67,34.39 285.7,34.4 285.73,34.41 285.85,34.4 285.98,34.42 286.46,34.42 286.72,34.67 286.72,35.81 287.1,36.2 288.75,36.2
P3V3 on TOP (solid shape): 288.88,56.26 288.88,55.8 288.87,55.79 288.85,55.57 288.87,55.36 288.88,55.35 288.88,54.61 288.82,54.55 288.79,54.55 287.88,53.8 288.36,52.72 288.37,52.71 288.88,52.2 288.88,51.94 288.88,51.18 288.75,51.05 282.91,51.05 282.78,51.18 282.78,51.69 285.81,54.72 285.84,54.72 286.53,55.09 286.63,55.86 286.63,55.9 286.65,55.94 287.1,56.39 288.75,56.39
P3V3 on BOTTOM (solid shape): 277.7,116.71 277.7,111.89 277.46,111.64 276.79,111.64 276.78,111.63 275.03,111.63 274.65,112.01 274.65,116.46 275.16,116.97 277.45,116.97
P3V3 on BOTTOM (solid shape): 115.42,39.07 115.56,38.94 116.47,38.94 116.52,38.92 116.54,38.86 116.54,37.25 115.75,36.46 114.35,36.46 114.21,36.6 114.21,37.69 114.69,38.18 114.69,38.56 114.62,38.63 114.62,39.02 114.72,39.12 115.36,39.12
P3V3 on BOTTOM (solid shape): 313.51,60.07 313.51,59.53 313.46,59.41 313.34,59.38 312.63,59.05 312.64,58.28 312.65,58.12 312.52,58.04 310.72,58.04 310.59,58.17 310.59,60.2 310.72,60.33 313.26,60.33
P3V3 on VCC1 (solid shape): outline of 27844 points within 1.02,5.69 321.03,117.23
P3V3_AGND on TOP (solid shape): 300.15,108.83 300.15,108.48 300.2,108.43 301.73,108.43 301.83,108.53 301.91,108.53 302.01,108.44 302.01,108.11 301.45,107.55 301.45,106.72 301.4,106.66 300.65,106.66 300.59,106.73 300.59,107.62 300.58,107.62 299.22,107.62 299.09,107.76 299.09,108.53 298.86,108.76 298.86,109.37 299.05,109.56 299.42,109.56
P3V3_AGND on BOTTOM (solid shape): 300.13,109.68 300.13,107.01 300.08,106.96 298.6,106.96 298.55,107.01 298.55,109.68 298.6,109.73 300.08,109.73
P3V3_BUF_VDDR on BOTTOM (solid shape): 312.07,54.69 312.07,52.88 311.89,52.7 311.02,52.7 310.67,53.06 310.61,53.06 310.59,53.07 310.33,53.14 310.07,53.06 309.2,53.06 308.84,53.42 308.84,54.1 308.97,54.23 310.85,54.23 311.35,54.74 312.02,54.74
P3V3_CLK_BUF_VDD on BOTTOM (solid shape): outline of 120 points within 304.24,55.88 312.37,58.29
P3V3_CLK_BUF_VDD on IN1 (solid shape): outline of 471 points within 301.96,48.53 313.53,58.83
P3V3_MB on TOP (solid shape): outline of 225 points within 285.45,1.54 291.29,22.86
P3V3_MB on BOTTOM (solid shape): outline of 570 points within 285.98,1.43 292.18,22.12
P3V3_MB on VCC1 (solid shape): 291.54,21.61 291.54,19.03 290.73,18.21 290.67,18.13 290.65,18.03 290.65,14.35 290.67,14.25 290.73,14.17 291.42,13.48 291.42,11.92 291.24,11.74 291.18,11.65 291.16,11.56 291.16,5.76 291.14,5.71 291.09,5.69 286.37,5.69 286.32,5.71 286.3,5.76 286.3,6.73 286.3,6.76 286.32,6.78 286.44,7.06 286.32,7.34 286.3,7.36 286.3,7.39 286.3,7.45 286.13,8.25 285.66,8.9 285.63,8.94 285.19,9.38 285.19,15.21 285.33,15.37 285.44,15.56 285.47,15.59 285.51,15.6 285.68,15.6 285.79,16.19 285.68,16.78 285.5,16.78 285.46,16.79 285.44,16.82 285.33,17 285.19,17.16 285.19,21.58 285.71,22.1 291.06,22.1
P3V3_MB on IN3 (solid shape): outline of 713 points within 285.19,5.69 291.54,22.1
P3V3_MB on IN4 (solid shape): outline of 713 points within 285.19,5.69 291.54,22.1
P3V3_OUT on TOP (solid shape): 281.84,115.78 281.84,110.41 282.09,110.16 282.83,110.16 282.91,110.08 282.91,104.52 281.84,103.45 281.84,103.44 281.56,103.16 278.66,103.16 278.56,103.26 278.56,104.69 278.7,105.04 278.56,105.39 278.56,106.92 278.7,107.27 278.56,107.63 278.56,109.16 278.7,109.51 278.56,109.86 278.56,116.53 278.79,116.76 280.86,116.76
P3V3_OUT on BOTTOM (solid shape): 281.23,116.56 281.23,115.6 281.38,115.44 281.69,115.44 282.03,115.1 282.03,114.89 282.04,114.88 282.04,113.61 283.25,112.4 283.25,110.83 283.38,110.69 284.53,110.69 284.61,110.62 284.61,105.85 283.41,104.65 282.95,104.65 281.76,103.47 279.52,103.47 279.52,103.47 278.83,103.47 278.8,103.48 278.78,103.49 278.64,103.63 278.64,104.79 278.65,104.81 278.7,105.04 278.65,105.27 278.64,105.29 278.64,107.02 278.65,107.04 278.7,107.27 278.65,107.51 278.64,107.52 278.64,109.26 278.65,109.28 278.7,109.51 278.65,109.74 278.64,109.76 278.64,116.66 278.74,116.76 281.03,116.76
P3V3_STBY on TOP (solid shape): 291.92,50.67 291.92,49.78 291.8,49.66 289.26,49.66 289.13,49.78 289.13,50.67 289.26,50.8 291.8,50.8
P3V3_STBY on TOP (solid shape): 287.48,103.45 287.48,100.3 287.25,100.08 286.44,100.08 286.2,100.32 286.2,102.18 286.01,102.37 286.01,103.48 286.04,103.52 287.42,103.52
P3V3_STBY on TOP (solid shape): 291.92,91.44 291.92,90.42 291.8,90.3 291.55,90.3 291.55,90.3 291.28,90.3 291.28,90.3 289.33,90.3 289.21,90.42 289.21,91.52 289.26,91.57 291.8,91.57
P3V3_STBY on TOP (solid shape): 298.53,93.45 298.53,90.04 298.42,89.94 297.35,89.94 297.33,89.92 297.26,89.92 297.13,90.04 297.13,91.84 297.13,93.45 297.31,93.62 298.35,93.62
P3V3_STBY on TOP (solid shape): 286.84,63.14 286.93,63.14 287.22,63.14 287.33,63.04 287.33,62.31 287.52,62.12 287.52,61.03 287.52,61.02 287.52,59.47 287.35,59.31 286.36,59.31 286.16,59.51 286.16,62.15 286.41,62.41 286.41,63.09 286.46,63.14 286.76,63.14
P3V3_STBY on TOP (solid shape): 286.84,42.94 286.93,42.95 287.2,42.95 287.31,42.84 287.31,41.9 287.48,41.73 287.48,39.37 287.22,39.12 286.36,39.12 286.16,39.32 286.16,41.73 286.34,41.91 286.34,42.17 286.34,42.88 286.41,42.95 286.76,42.95
P3V3_STBY on TOP (solid shape): 287.08,83.48 287.22,83.46 287.37,83.48 287.38,83.48 287.69,83.48 287.73,83.44 287.73,82.68 287.73,81.41 287.48,81.15 287.48,80.01 287.22,79.76 286.46,79.76 286.21,80.01 286.21,81.92 286.72,82.42 286.72,82.68 286.72,82.68 286.72,83.44 286.76,83.48 287.07,83.48
P3V3_STBY on IN3 (solid shape): outline of 10952 points within 283.41,28.83 298.91,103
P3V3_STBY_AGND on TOP (solid shape): 312.8,87.2 313.97,87.2 314.2,86.97 314.2,86.61 314.07,86.48 313.94,86.48 313.79,86.33 313.79,85.62 313.66,85.49 312.78,85.49 312.65,85.62 312.65,86.59 312.29,86.94 311.78,86.94 311.68,87.04 311.68,87.32 311.81,87.45 312.55,87.45
P3V3_STBY_AGND on BOTTOM (solid shape): 311.47,89.26 311.53,89.23 311.55,89.18 311.55,88.9 311.56,88.8 311.6,88.71 311.61,88.69 311.61,88.54 311.65,88.5 311.65,88.44 312.57,88.44 312.64,88.38 312.64,86.36 312.6,86.35 312.6,86.16 312.57,86.1 312.52,86.08 311.52,86.08 311.52,85.22 311.5,85.16 311.45,85.14 311.3,85.14 311.28,85.17 311.28,86.01 311.27,86.02 311.27,86.16 311.28,86.23 311.28,89.25 311.28,89.26
P3V3_STBY_MB on TOP (solid shape): 284.41,22.07 284.41,21.49 285.88,20.02 286.2,20.02 286.21,20.01 287.1,20.01 287.48,19.63 287.48,19.05 287.1,18.67 285.83,18.67 283.41,21.08 283.41,21.47 283.42,22.1 283.52,22.2 284.28,22.2
P3V3_STBY_MB on BOTTOM (solid shape): 285.57,13.97 285.57,12.57 285.45,12.45 284.05,12.45 283.92,12.57 283.92,13.97 284.05,14.1 285.45,14.1
P3V3_STBY_MB on IN1 (solid shape): outline of 6637 points within 281.13,11.43 317.07,47.62
P3V3_STBY_OUT on TOP (solid shape): 299.82,92.89 299.82,91.57 299.82,91.44 299.87,91.39 300.4,91.39 300.96,90.83 300.96,85.32 300.47,84.82 299.12,84.82 298.88,85.06 298.88,92.86 298.99,92.96 299.75,92.96
P3V3_STBY_OUT on BOTTOM (solid shape): 300.35,92.1 300.35,90.78 300.44,90.7 301.19,90.7 301.22,90.67 301.22,89.72 302.76,88.19 302.76,82.33 302.46,82.04 299.29,82.04 298.88,82.45 298.88,92.1 299.04,92.25 300.2,92.25
P12V on TOP (solid shape): 286.84,115.7 286.84,113.88 286.72,113.75 284.98,113.75 284.43,114.3 284.43,115.7 284.68,115.95 286.59,115.95
P12V on TOP (solid shape): 55.41,37.2 55.41,35.57 55.31,35.47 54.9,35.47 54.85,35.42 54.85,34.69 54.77,34.61 53.32,34.61 52.94,34.99 52.94,37.02 53.28,37.36 55.25,37.36
P12V on TOP (solid shape): 292.43,104.57 292.43,104.16 293.09,103.5 293.09,103.5 293.14,103.45 295.68,103.45 297.49,101.65 297.49,94.18 296.88,93.57 296.88,92 296.88,91.95 296.75,91.82 293.35,91.82 293.27,91.9 293.27,93.45 293.28,93.48 293.34,93.53 293.4,93.59 293.46,93.64 293.51,93.71 293.56,93.78 293.6,93.85 293.63,93.93 293.66,94.01 293.67,94.09 293.68,94.18 293.68,94.26 293.67,94.34 293.65,94.42 293.63,94.5 293.6,94.58 293.56,94.65 293.51,94.72 293.46,94.79 293.4,94.85 293.33,94.9 293.27,94.95 293.22,94.97 292.83,95.36 296.68,95.36 296.68,97.07 294.98,97.07 294.98,95.36 292.83,95.36 292.76,95.43 292.76,99.16 293.57,99.97 293.57,100.31 293.6,100.36 293.63,100.43 293.66,100.51 293.67,100.59 293.68,100.67 293.68,100.76 293.67,100.84 293.66,100.92 293.63,101 293.6,101.07 293.57,101.12 293.57,101.14 293.52,101.21 293.46,101.28 293.4,101.35 293.33,101.4 293.28,101.43 293.19,101.52 293.09,101.52 293.04,101.54 292.96,101.56 292.87,101.57 292.79,101.57 292.7,101.56 292.62,101.54 292.56,101.52 291.72,101.52 291.24,102.01 291.24,104.47 291.42,104.65 292.36,104.65
P12V on TOP (solid shape): 292.43,104.57 292.43,104.16 293.09,103.5 293.09,103.5 293.14,103.45 295.68,103.45 297.49,101.65 297.49,94.18 296.88,93.57 296.88,92 296.88,91.95 296.75,91.82 293.35,91.82 293.27,91.9 293.27,93.45 293.28,93.48 293.34,93.53 293.4,93.59 293.46,93.64 293.51,93.71 293.56,93.78 293.6,93.85 293.63,93.93 293.66,94.01 293.67,94.09 293.68,94.18 293.68,94.26 293.67,94.34 293.65,94.42 293.63,94.5 293.6,94.58 293.56,94.65 293.51,94.72 293.46,94.79 293.4,94.85 293.33,94.9 293.27,94.95 293.22,94.97 292.93,95.26 292.93,95.36 296.68,95.36 296.68,97.07 294.98,97.07 294.98,95.36 292.93,95.36 292.93,99.33 293.57,99.97 293.57,100.31 293.6,100.36 293.63,100.43 293.66,100.51 293.67,100.59 293.68,100.67 293.68,100.76 293.67,100.84 293.66,100.92 293.63,101 293.6,101.07 293.57,101.12 293.57,101.14 293.52,101.21 293.46,101.28 293.4,101.35 293.33,101.4 293.28,101.43 293.19,101.52 293.09,101.52 293.04,101.54 292.96,101.56 292.87,101.57 292.79,101.57 292.7,101.56 292.62,101.54 292.56,101.52 291.72,101.52 291.24,102.01 291.24,104.47 291.42,104.65 292.36,104.65
P12V on TOP (solid shape): outline of 522 points within 292.69,30.73 305.39,84.45
P12V on TOP (solid shape): outline of 629 points within 1.45,85.59 18.37,106.36
P12V on BOTTOM (solid shape): 89.36,41.15 89.36,40.13 88.34,39.12 87.07,39.12 86.82,39.37 86.82,41.4 86.95,41.53 88.98,41.53
P12V on BOTTOM (solid shape): 287.99,116.71 287.99,116.08 287.86,115.95 287.49,115.95 286.99,115.45 286.99,114.13 286.78,113.92 284.81,113.92 284.43,114.3 284.43,116.46 284.81,116.84 287.86,116.84
P12V on BOTTOM (solid shape): 23.42,90.84 24.16,90.84 24.64,90.36 25.48,90.36 25.94,89.91 26.8,89.91 26.85,89.86 26.85,89.47 26.71,89.33 22.89,89.33 22.56,89.66 22.56,90.68 22.77,90.89 23.37,90.89
P12V on BOTTOM (solid shape): 25.91,101.61 25.99,101.61 26,101.6 26.18,101.6 26.18,101.59 26.78,101.59 26.83,101.57 26.85,101.51 26.85,101.32 26.54,101.02 24.46,101.02 23.01,101.02 22.81,101.22 22.81,101.73 22.94,101.85 24.46,101.85 24.59,101.98 25.55,101.98
P12V on IN1 (solid shape): outline of 946 points within 1.4,86.54 14.2,106.78
P12V on VCC (solid shape): outline of 18986 points within 1.02,22.61 321.03,117.23
P12V on IN4 (solid shape): outline of 148383 points within 1.14,20.32 320.9,117.1
P12V_MB on TOP (solid shape): 298.78,19.94 301.83,19.94 302.08,19.68 302.08,16.13 301.96,16 299.8,16 296.53,12.74 296.05,12.74 295.35,12.04 295.35,9.42 294.77,8.84 294.77,6.22 295.19,5.8 295.19,1.51 295.15,1.47 294.52,1.47 294.49,1.48 294.47,1.5 294.45,1.51 294.45,1.55 294.45,5.64 294.21,5.64 294.21,1.55 294.2,1.51 294.19,1.5 294.17,1.48 294.13,1.47 293.55,1.47 293.51,1.48 293.5,1.5 293.48,1.51 293.47,1.55 293.47,5.89 292.86,6.5 292.86,9.19 293.83,10.17 293.96,10.17 293.96,12.01 294.01,12.06 294.01,13.46 293.39,14.08 296.68,14.08 296.68,15.79 294.98,15.79 294.98,14.08 293.39,14.08 292.94,14.54 292.94,14.54 292.94,18.03 293.83,18.92 293.83,19.81 294.46,20.45 298.27,20.45
P12V_MB on BOTTOM (solid shape): outline of 205 points within 292.86,1.43 300.94,20.07
P12V_MB on VCC1 (solid shape): 303.1,21.61 303.1,10.01 302.51,9.42 301.13,9.42 301.1,9.43 301.08,9.44 300.81,9.55 300.55,9.44 300.53,9.43 300.5,9.42 297.74,9.42 296.63,9.14 295.8,8.35 295.59,8.21 295.5,7.98 295.52,7.88 295.55,7.8 295.48,7.47 295.45,7.14 295.45,5.76 295.43,5.71 295.38,5.69 291.75,5.69 291.69,5.71 291.67,5.76 291.67,11.45 291.85,11.63 291.91,11.71 291.92,11.81 291.92,13.59 291.91,13.69 291.85,13.77 291.16,14.46 291.16,17.93 291.98,18.74 292.03,18.83 292.05,18.92 292.05,21.61 292.92,22.48 302.23,22.48
P12V_MB on IN3 (solid shape): outline of 973 points within 291.16,5.69 303.1,22.48
P12V_MB on IN4 (solid shape): outline of 1133 points within 291.16,5.69 303.1,22.48
P12V_PSU on TOP (solid shape): 303.15,93.07 303.15,90.37 303.1,90.32 302.06,90.32 301.96,90.42 301.96,90.84 301.96,90.87 301.98,90.89 302.11,91.2 302.02,91.52 302.01,91.54 302.01,91.72 302.02,91.73 302.02,92.93 302.29,93.19 303.02,93.19
P12V_PSU on TOP (solid shape): 10.96,88.94 11.54,88.36 12.36,88.39 15.06,88.39 15.32,88.14 15.32,87 15.19,86.87 14.22,86.87 14.22,86.79 14.17,86.74 14.17,85.93 13.72,85.47 8.59,85.47 7.7,86.36 7.7,89.66 8.21,90.17 9.73,90.17
P12V_PSU on BOTTOM (solid shape): 303.18,92.84 303.18,91.49 302.92,91.24 302.29,91.24 302.16,91.36 302.16,91.54 301.88,91.82 301.88,92.63 302.39,93.14 302.87,93.14
P12V_PSU on IN2 (solid shape): outline of 6749 points within 7.7,21.01 300.05,90.17
P12V_PSU on IN3 (solid shape): 11.38,88.39 12.52,88.39 13.3,87.62 13.3,85.86 13.16,85.72 9.6,85.72 7.7,87.63 7.7,89.53 8.33,90.17 9.6,90.17
P12V_PSU on IN3 (solid shape): outline of 2667 points within 299.39,22.23 320.63,93.24
VCC_P5V_1 on BOTTOM (solid shape): 31.52,102.25 31.52,101.82 30.3,100.6 28.89,100.6 28.33,101.16 28.33,101.51 28.35,101.57 28.4,101.59 28.96,101.59 29.04,101.67 29.04,101.97 29.14,102.07 29.32,102.07 29.37,102.02 29.37,101.92 29.38,101.92 29.42,101.88 29.42,101.71 29.52,101.61 30.28,101.61 30.96,102.3 31.47,102.3
VCC_P5V_2 on BOTTOM (solid shape): 31.6,90.41 31.6,90.03 31.4,89.83 31.17,89.83 30.3,88.97 29.25,88.97 28.9,89.32 28.48,89.32 28.33,89.47 28.33,89.83 28.35,89.88 28.4,89.91 29,89.91 29,90.32 29.09,90.41 29.29,90.41 29.44,90.26 29.44,90.11 29.62,89.93 30.38,89.93 30.95,90.49 31.52,90.49
TPS7A37_OUT on BOTTOM (solid shape): 112.13,39.12 113.02,39.12 113.07,39.09 113.09,39.04 113.09,38.71 112.74,38.35 112.28,38.35 112.05,38.13 112.05,36.58 111.97,36.5 111.11,36.5 111.09,36.52 111.09,37.31 110.78,37.62 109.28,37.62 109.26,37.64 108.57,37.64 108.56,37.63 107.86,37.63 107.73,37.75 107.73,39 107.96,39.23 108.25,39.23 108.27,39.24 110.76,39.24 111.09,39.57 111.67,39.57
VR_P0V9_12VIN on TOP (solid shape): 27.93,101.75 27.93,101.1 28.45,100.57 30.74,100.57 30.98,100.33 30.98,99.95 30.98,99.91 30.99,99.85 30.99,99.45 31.05,99.4 31.88,99.4 31.93,99.38 31.95,99.33 31.95,97.83 31.88,97.75 29.28,97.75 29.24,97.75 29.15,97.73 27.26,97.73 26.96,98.03 23.78,98.03 23.17,97.42 23.17,97.4 23.17,97.4 23.17,95.48 23.17,95.48 23.17,93.47 23.83,92.82 23.83,91.08 23.17,90.42 22.56,90.42 21.79,89.66 21.79,89.03 22.57,88.25 25.97,88.25 26.14,88.43 26.14,90.18 26.3,90.34 27.66,90.34 27.8,90.2 27.8,89.51 28.42,88.89 30.76,88.89 30.98,88.67 30.98,88.27 30.98,88.22 30.99,88.17 30.99,87.77 31.05,87.72 31.95,87.72 31.98,87.7 31.98,86.21 31.85,86.08 28.75,86.08 28.72,86.04 27.26,86.04 26.96,86.35 23.81,86.35 23.19,85.72 19.45,85.72 18.87,86.3 18.87,89.74 19.28,90.14 19.28,98.27 19.43,98.42 20.25,98.42 21.76,99.94 25.97,99.94 26.14,100.11 26.14,101.87 26.3,102.02 27.66,102.02
VR_P0V9_12VIN on BOTTOM (solid shape): 28.24,99.53 31.04,99.53 31.68,98.89 31.68,98.44 31.44,98.2 30.62,98.2 29.56,97.14 28.91,97.14 28.33,97.73 27.26,97.73 26.96,98.03 23.7,98.03 23.56,98.17 23.56,99.93 23.62,99.99 27.79,99.99
VR_P0V9_12VIN on BOTTOM (solid shape): 28.83,87.95 31.51,87.95 31.83,87.63 31.83,86.74 31.63,86.54 30.19,86.54 30.18,86.53 30.02,86.53 29.59,86.1 27.21,86.1 26.96,86.35 23.4,86.35 23.32,86.42 23.32,88.2 23.43,88.3 28.48,88.3
VR_P0V9_SW1 on TOP (solid shape): 39.7,97.92 39.7,96.85 39.4,96.85 39.4,96.19 39.7,96.19 39.7,94.41 38.9,93.61 34,93.61 33.73,93.87 33.73,94.76 33.63,94.86 29.92,94.86 29.85,94.94 29.85,97.3 29.95,97.4 34.37,97.4 34.42,97.35 34.42,97.15 34.6,96.97 36.21,96.97 36.43,97.18 36.43,98.07 36.53,98.17 39.45,98.17
VR_P0V9_SW1 on BOTTOM (solid shape): 36.96,96.48 36.96,95.27 36.69,95 35.89,95 35.51,95.38 34.11,95.38 33.99,95.5 33.99,96.52 34.11,96.65 36.79,96.65
VR_P0V9_SW2 on TOP (solid shape): 39.7,86.36 39.7,85.12 39.42,85.12 39.42,84.53 39.7,84.53 39.7,82.72 38.9,81.92 34,81.92 33.81,82.11 33.81,83.06 33.69,83.18 30.09,83.18 29.92,83.34 29.92,85.59 30.05,85.72 34.37,85.72 34.42,85.66 34.42,85.46 34.6,85.28 35.86,85.28 36.4,85.83 36.4,86.36 36.53,86.49 39.57,86.49
VR_P0V9_SW2 on BOTTOM (solid shape): 37.02,84.84 37.02,83.48 36.86,83.31 35.89,83.31 35.51,83.69 34.11,83.69 33.99,83.82 33.99,84.84 34.11,84.96 36.9,84.96
VR_P0V9A_PVIN on TOP (solid shape): outline of 88 points within 56.17,34.56 67.25,41.57
VR_P0V9A_PVIN on BOTTOM (solid shape): 65.01,41.78 65.01,40.43 65.57,39.87 66.46,39.87 66.5,39.86 66.52,39.85 66.53,39.83 66.54,39.79 66.54,39.49 66.54,39.45 66.55,39.36 66.57,39.28 66.59,39.2 66.63,39.12 66.67,39.05 66.7,39.02 66.7,38.08 65.12,36.5 63.25,36.5 62.82,36.07 57.61,36.07 57.35,36.32 57.35,37.26 64.32,37.26 64.33,37.21 64.34,37.15 64.36,37.1 64.39,37.05 64.42,37.01 64.46,36.97 64.51,36.94 64.56,36.91 64.61,36.89 64.66,36.88 64.72,36.88 64.78,36.89 64.83,36.9 64.88,36.92 64.93,36.95 64.97,36.99 65.01,37.03 65.04,37.07 65.06,37.13 65.08,37.18 65.09,37.23 65.09,37.29 65.08,37.34 65.06,37.4 65.04,37.45 65.01,37.5 64.97,37.54 64.93,37.57 64.88,37.6 64.83,37.62 64.78,37.64 64.72,37.64 64.66,37.64 64.61,37.63 64.56,37.61 64.51,37.59 64.46,37.56 64.42,37.52 64.39,37.47 64.36,37.42 64.34,37.37 64.33,37.32 64.32,37.26 57.35,37.26 57.35,37.72 57.48,37.85 61.46,37.85 62.14,38.52 62.14,40.15 61.52,40.77 61.52,42.02 61.76,42.26 62.57,42.26 63.02,42.71 64.09,42.71
VR_P0V9A_SW on TOP (solid shape): 62.6,44.84 62.6,44.42 62.9,44.11 66.69,44.11 66.74,44.09 66.76,44.04 66.76,42 66.74,41.98 63.74,41.98 62.7,40.93 62.5,40.73 58.43,40.73 58.36,40.81 58.36,44.69 58.57,44.9 62.54,44.9
VR_P1V8A_PVIN on TOP (solid shape): 84.3,41.88 84.3,41.18 84.42,41.07 85.18,41.07 85.37,41.26 85.34,41.29 85.34,41.62 85.44,41.72 86.64,41.72 87.05,41.31 87.05,39.27 86.8,39.02 85.2,39.02 84.84,38.66 82.04,38.66 81.92,38.79 81.92,42.21 82.12,42.42 83.77,42.42
VR_P1V8A_PVIN on BOTTOM (solid shape): 83.77,42.2 83.77,42.2 83.77,41.63 84.41,41 86.26,41 86.44,40.82 86.44,39.29 86.23,39.09 85.68,39.09 85.41,39.36 84.04,39.36 83.64,39.75 83.16,39.75 82.2,40.72 82.2,40.84 82.22,40.86 82.22,42.43 82.37,42.58 83.39,42.58
VR_P1V8A_SW on TOP (solid shape): 86.19,38.36 86.69,38.36 86.95,38.1 86.95,35.05 86.82,34.92 84.91,34.92 84.79,35.05 84.79,36.32 84.25,36.86 81.97,36.86 81.89,36.94 81.89,38.26 81.99,38.36 86.18,38.36
VR_P3V3_PVIN on TOP (solid shape): outline of 85 points within 287.58,108.85 298.32,115.7
VR_P3V3_PVIN on BOTTOM (solid shape): outline of 87 points within 287.61,109.51 298.65,116.84
VR_P3V3_STBY_PVIN on TOP (solid shape): outline of 140 points within 303.42,88.41 310.61,93.01
VR_P3V3_STBY_PVIN on BOTTOM (solid shape): 308.08,93.19 308.08,91.11 308.2,90.98 309.17,90.98 309.25,91.06 309.25,92 309.37,92.13 310.85,92.13 311.02,91.95 311.02,89.36 311.02,89.36 311.02,88.06 311,88 310.95,87.98 309.45,87.98 309.07,88.37 309.07,88.52 308.32,89.27 308.32,89.39 308.31,89.4 308.31,89.81 308.18,89.94 305.36,89.94 305.23,90.07 305.23,90.47 305.32,90.56 305.35,90.58 305.38,90.58 305.5,90.57 305.61,90.6 305.62,90.6 305.87,90.6 306.02,90.75 306.02,93.09 306.27,93.34 307.93,93.34
VR_P3V3_STBY_SW on BOTTOM (solid shape): 308.68,88.21 308.71,88.21 308.73,88.19 309.19,87.73 309.34,87.73 309.35,87.73 310.95,87.73 311.02,87.66 311.02,86.26 311,86.23 309.35,86.23 308.58,85.47 308.58,84.86 308.53,84.81 306.43,84.81 306.37,84.86 306.37,85.13 306.38,85.14 306.4,85.29 306.38,85.44 306.37,85.45 306.37,87.07 306.38,87.09 306.43,87.3 306.38,87.51 306.37,87.52 306.37,88.16 306.43,88.21
VR_P3V3_SW on BOTTOM (solid shape): 294.08,110.46 294.08,109.86 294.82,109.13 298.15,109.13 298.17,109.1 298.17,107.07 298.15,107.02 298.09,106.99 294.31,106.99 294.11,106.79 294.11,106.3 293.98,106.17 289.81,106.17 289.74,106.25 289.74,110.23 289.74,110.24 289.74,110.41 289.89,110.57 293.98,110.57

Small or netless copper shapes (teardrops, artwork): 207 on TOP, 3 on BOTTOM, 1 on GND, 2 on IN1, 1 on GND1, 2 on IN2, 2 on VCC, 1 on VCC1, 2 on IN3, 1 on GND2, 2 on IN4, 1 on GND3

## Text on the board
Ref Des/Silkscreen Bottom: (P0 PCIe 3AB) | Sliver_1 | (P0 PCIe 3CD) | Sliver_2 | PWR_Conn
User.Comments: CR_TEST_2 | CR_TEST_1 | CR_PCIE_1 | CR_UNNAMED_1 | CR_P1V05_PCH_STBY_1 | CR_P3V3_1
Ref Des/Silkscreen Top: A | B | C | D | E | F | H | G | J | K | L | Riser Slot5 (PLX PCIe P16) | Riser Slot4 (PLX PCIe P20) | J3 | Riser Slot3 (PLX PCIe P12) | Riser Slot2 (PLX PCIe P4) | Riser Slot1 (P1 PCIe 1ABCD) | J4 | J2 | J9 | J1 | PCB-5RSMOXLC-P0 REV:P0
User.26: FIGURE | SIZE | 10.0 | 16.0 | 22.0 | 24.0 | 28.0 | 41.0 | 44.0 | 174.0 | 221.0 | 47.0 | 95.0 | 119.0 | 158.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +4.0/-0.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 263 | 4157 | 28 | 80 | 30 | 4 | 820 | 76 | 2 | 10 | 6
