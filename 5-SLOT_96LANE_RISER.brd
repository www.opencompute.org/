# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R303  -  [R0402]  295.23 22.35 270 top
R304  -  [R0402]  289.13 22.35 270 top
R305  -  [R0402]  166.45 113.03 270 top
R306  -  [R0402]  293.45 11.05 270 top
R307  -  [R0402]  296.24 22.35 270 top
R308  -  [R0402]  290.15 22.35 270 top
R309  -  [R0402]  113.74 72.14 180 top
R310  -  [R0402]  48.85 62.48 180 bottom
R311  -  [R0402]  107.65 87.5 180 top
R312  -  [R0402]  120.47 91.31 180 top
R313  -  [R0402]  113.74 77.85 180 top
R314  -  [R0402]  120.22 74.04 180 top
R315  -  [R0402]  120.47 89.41 180 top
R316  -  [R0402]  104.47 75.95 180 top
R317  -  [R0402]  280.11 30.61 270 top
R318  -  [R0402]  70.69 52.7 270 top
R319  -  [R0402]  116.92 74.04 0 top
R320  -  [R0402]  45.92 53.09 180 top
R321  -  [R0402]  113.62 89.41 0 top
R322  -  [R0402]  104.47 95.12 0 top
R323  -  [R0402]  104.47 93.22 0 top
R324  -  [R0402]  78.31 55.63 90 top
R325  -  [R0402]  110.69 79.76 180 top
R326  -  [R0402]  107.65 77.85 180 top
R327  -  [R0402]  104.47 77.85 0 top
R328  -  [R0402]  110.69 75.95 180 top
R329  -  [R0402]  107.65 75.95 0 top
R330  -  [R0402]  120.22 79.76 180 top
R331  -  [R0402]  116.92 79.76 0 top
R332  -  [R0402]  113.62 87.5 180 top
R333  -  [R0402]  45.92 56.9 0 top
R334  -  [R0402]  110.69 66.42 180 top
R335  -  [R0402]  113.74 75.95 180 top
R336  -  [R0402]  104.47 72.14 180 top
R337  -  [R0402]  104.47 79.76 180 top
R338  -  [R0402]  298.53 31.24 270 top
R339  -  [R0402]  299.54 31.24 270 top
R340  -  [R0402]  307.93 48.77 270 top
R341  -  [R0402]  313.26 79.25 180 bottom
R342  -  [R0402]  289.76 23.75 0 top
R343  -  [R0402]  57.74 51.82 270 top
R344  -  [R0402]  107.65 72.14 0 top
R345  -  [R0402]  123.39 79.76 0 top
R346  -  [R0402]  113.74 68.33 0 top
R347  -  [R0402]  291.67 11.05 270 top
R348  -  [R0402]  166.45 111.12 270 top
R349  -  [R0402]  282.91 90.3 0 top
R350  -  [R0402]  283.16 71.25 270 top
R351  -  [R0402]  163.22 106.45 0 top
R352  -  [R0402]  283.16 50.93 270 top
R353  -  [R0402]  282.91 30.61 270 top
R354  -  [R0402]  289 11.05 270 top
R355  -  [R0402]  288.11 11.05 270 top
R356  -  [R0402]  287.22 11.05 270 top
R357  -  [R0402]  289.89 11.05 270 top
R358  -  [R0402]  292.56 11.05 270 top
R359  -  [R0402]  290.78 11.05 270 top
R360  -  [R0402]  284.94 22.35 270 top
R361  -  [R0402]  276.81 24.77 180 top
R362  -  [R0402]  282.4 66.17 0 bottom
R363  -  [R0402]  281.51 89.66 180 bottom
R370  -  [R0402]  282.91 22.35 270 top
SHORT1  -  [SHORT0805]  278.08 116.2 180 top
SHORT2  -  [SHORT0805]  278.08 114.3 180 top
SHORT3  -  [SHORT0805]  278.15 114.29 180 bottom
SHORT4  -  [SHORT0805]  278.08 112.39 180 top
SHORT5  -  [SHORT0805]  96.72 37.34 0 top
SHORT6  -  [SHORT0805]  46.76 50.29 180 bottom
SHORT7  -  [SHORT0805]  46.76 50.29 180 top
SHORT8  -  [SHORT0805]  46.76 48.26 180 top
SHORT9  -  [SHORT0805]  46.76 46.23 180 top
SHORT10  -  [SHORT0805]  46.76 48.26 180 bottom
SHORT11  -  [SHORT0805]  278.14 116.15 180 bottom
SHORT12  -  [SHORT0805]  278.14 112.43 180 bottom
SHORT105  -  [SHORT0603]  110.78 36.88 180 bottom
U1  -  [BGA1156]  81.36 81.13 90 bottom
U2  -  [TSSOP24_P0-65W5-6H1-2]  304.47 37.34 270 top
U4  -  [MSOP8_P0-65H1-1]  307.8 78.74 0 bottom
U5  -  [DELTAL_COUPON_7P]  -14.65 317.93 0 top
U6  -  [SOIC8]  42.24 62.61 0 bottom
U7  -  [SOIC8]  313.26 38.48 270 top
U8  -  [SC70-5XB]  279.48 27.94 90 top
U9  -  [VFQFPN40_P0-4_EPAD]  306.71 53.49 180 top
U10  -  [MSOP10_P0-5W4-4_3X3]  161.37 85.09 0 top
U12  -  [TSSOP8_D65_1D2]  120.09 38.48 180 top
U13  -  [SC70-5XB]  283.8 88.65 180 top
U15  -  [SC70-5XB]  282.4 68.58 90 top
U16  -  [SC70-5XB]  282.53 48.26 90 top
U17  -  [SC70-5XB]  282.27 27.94 90 top
U18  -  [SC70-5XB]  280.75 90.81 90 top
U19  -  [SC70-5XB]  283.54 65.41 0 top
U20  -  [SC70-5XB]  283.54 45.21 0 top
U21  -  [SC70-5XB]  283.8 85.72 0 top
U22  -  [SC70-5XA]  302.08 21.97 90 top
U23  -  [DELTAL_COUPON_7P]  -7.23 317.56 180 bottom
U25  -  [DELTAL_COUPON_7P]  -7.54 280.67 180 top
U26  -  [DELTAL_COUPON_7P]  -14.78 342.26 180 top
U27  -  [DELTAL_COUPON_7P]  -7.54 342.26 0 bottom
U29  -  [DELTAL_COUPON_7P]  -7.54 256.11 0 top
U30  -  [DELTAL_COUPON_7P]  -14.65 127.51 0 top
U31  -  [DELTAL_COUPON_7P]  -7.8 166.5 0 bottom
U33  -  [DELTAL_COUPON_7P]  -7.8 69.72 0 top
U34  -  [DELTAL_COUPON_7P]  -14.78 166.5 180 top
U35  -  [DELTAL_COUPON_7P]  -7.8 127.51 180 bottom
U37  -  [DELTAL_COUPON_7P]  -7.8 108.71 180 top
U39  -  [DELTAL_COUPON_7P]  -14.78 223.39 0 bottom
U41  -  [DELTAL_COUPON_7P]  -13.82 198.91 180 bottom
U43  -  [DELTAL_COUPON_7P]  -14.78 8.13 180 bottom
U45  -  [DELTAL_COUPON_7P]  -14.91 47.12 0 bottom
U47  -  [SC70-5XB]  276.68 22.86 0 top

## Library data of the parts
C1-C8 C302-C309 C330 C332 C334 C337 C339 C341 C344 C346 C368-C375 PC492 PC510 PC542 PC565 PC575 PC583 = CAP: part number: CAP_0603-1UF,CAP-63F00001-D0,X7R,10%,25V
C9-C15 C310-C316 C350 C352 C376 C377 C386-C449 = O-CAP: part number: O-CAP_O0402-0.1UF,CAP-42E000D1-D0,X7R,10%,16V
C16-C22 C268-C301 C317-C329 C331 C333 C335 C336 C338 C340 C342 C343 C345 C347-C349 C351 C353-C367 = O-CAP: part number: O-CAP_O0402-0.01UF,CAP-42E00D01-D0,X7R,10%,16V
C23-C138 C140-C151 C183-C214 = CAP: part number: CAP_0402-0.22UF,CAP-42E00D22-D0,X7R,10%,16V
C139 C153 C154 C156-C160 C216-C223 C225 C227 C229 C230 C232-C234 C236 C237 C239-C241 C243 C244 C246-C248 C250 C251 C253-C259 C450-C456 C458-C462 C465 C467 C470 PC487 PC488 PC500 PC502 PC522 PC532 PC537 PC551 PC553 PC569 PC570 PC577 PC578 PC592 PC593 = CAP: part number: CAP_0402-0.1UF,CAP-42E000D1-D0,X7R,10%,16V
C152 C228 C235 C242 C249 = CAP: part number: CAP_0805-10UF,CAP-85E00010-D0,X6S,10%,16V
C155 C215 C224 C226 C231 C238 C245 C252 = CAP: part number: CAP_0603-10UF,CAP-63C00010-E0,X7T,20%,6.3V
C168 C169 C473-C480 = CAP: part number: CAP_0805-22UF,CAP-85E00022-E0,X6S,20%,16V
C260 C468 C469 PC504 PC527 PC555 PC562 PC597 = CAP: part number: CAP_0402-2200PF,CAP-42GD0022-D0,X7R,10%,50V
C378-C385 C457 PC477-PC486 PC552 PC554 PC556 PC557 PC1592 PC1594 PC1595 PC2596 = CAP: part number: CAP_0603-22UF,CAP-63B00022-E0,X6S,20%,4V
C463 C464 C466 PC515 PC517 PC519-PC521 PC523 PC545 PC548 PC550 PC585 PC586 PC620 PC621 PC1523 PC1588 PC1589 PC1621 = CAP: part number: CAP_1206-22UF,CAP-C6F00022-E0,X6S,20%,25V
C471 PC505 PC524 PC526 PC529-PC531 PC533 PC535 PC538 PC612-PC615 PC623 PC1531 PC1533 PC1623 PC2531 PC2533 = CAP: part number: CAP_0805-22UF,CAP-85C00022-E0,X6S,20%,6.3V
CON1 = HEADER1X4: part number: HEADER1X4_-HEADER1X4S_P2_RA,COH-004SM200-00,IO,,
D1 = LED_2P: part number: LED_2P_-LTST-C193KGKT-5A,LED-S1SG000V-00,IC,,
H1 = HEATSINK_4P: part number: HEATSINK_4P_-HEATSINK_4P_SF41720001,SNK-073143AL-02,EMPTY,,
J1-J4 J9 = PCIE_X16: part number: PCIE_X16_-2EG08213-9ADM-JF,COB-PCE164DV-03,IO,,
J5 = GF_PCIE_X16: part number: GF_PCIE_X16_-GF_PCIE_X16,,,,
J6 = PWR2X6: part number: PWR2X6_-2NH_PWR2X6,COP-012D0003-02,IO,,,
J7 J8 = SLIVER_X8_50P: part number: SLIVER_X8_50P_-2292055-1,COS-SLV050SR-00,IO,,
L1 = BEAD: part number: BEAD_-600,BED-06002012-00,IC,25%,,
ME1 = DUMMY_SYMBOL_NO_PIN: part number: DUMMY_SYMBOL_NO_PIN_-LABEL20X4_SST21X5,MEDUMMY5,EMPTY,,
ME4 = DUMMY_SYMBOL_NO_PIN: part number: DUMMY_SYMBOL_NO_PIN_-LABEL_32X6_FULL,MEDUMMY7,EMPTY,,
ME5 = DUMMY_SYMBOL_NO_PIN: part number: DUMMY_SYMBOL_NO_PIN_-ZT_LOG_6X16,MEDUMMY3,EMPTY,,
MH1 MH8 = STANDOFF: part number: STANDOFF_-HOLE_C10D5-6B10_NPB_STANDOFF,TSW-AM3L5P1P-00,IO,,
MH2-MH7 = SCREW_NP_5VIA: part number: SCREW_NP_5VIA_-C10D4XC10D6.5_5V,TEMP_C10D4XC10D6.5_L5,EMPTY,,
PC453 PC454 PC493 PC511 PC534 PC543 PC563 PC574 PC584 = CAP: part number: CAP_0402-0.1UF,CAP-42F000D1-D0,X7R,10%,25V
PC455 PC456 = CAP: part number: CAP_0603-1UF,CAP-63F00001-D0,EMPTY,10%,25V
PC457-PC466 = CAP: part number: CAP_1206-10UF,CAP-C6F00010-D0,X7R,10%,25V
PC467 PC468 = CAP: part number: CAP_0402-1UF,CAP-42D00001-D0,X6S,10%,10V
PC469 PC470 PC473 PC474 = CAP: part number: CAP_0603-0.22UF,CAP-63F00D22-D0,X7R,10%,25V
PC471 PC472 = CAP: part number: CAP_0402-1000PF,CAP-42G0D001-D0,EMPTY,10%,50V
PC475 PC476 PC660 PC661 = CAPP: part number: CAPP_-470UF,CAP-THA00470-E0,POLCAP,20%,2V
PC489 PC506 = CAP: part number: CAP_0402-0.01UF,CAP-42G00D01-D0,X7R,10%,50V
PC491 PC508 PC541 PC581 = CAP: part number: CAP_0603-2.2UF,CAP-63D002D2-D0,X7R,10%,10V
PC495 PC498 PC588 PC1585 PC1586 = CAP: part number: CAP_1206-10UF,CAP-C6F00010-D0,EMPTY,10%,25V
PC496 PC514 PC546 PC558 PC587 = CAP: part number: CAP_0603-0.1UF,CAP-63G000D1-D0,X7R,10%,50V
PC497 PC547 = CAP: part number: CAP_0402-33PF,CAP-42G0033P-C0,NP0,5%,50V
PC499 PC518 PC536 PC567 = CAP: part number: CAP_0402-0.01UF,CAP-42E00D01-D0,X7R,10%,16V
PC501 PC503 = CAP: part number: CAP_0805-22UF,CAP-85C00022-E0,EMPTY,20%,6.3V
PC509 PC582 = CAP: part number: CAP_0402-100PF,CAP-42GD0001-C0,NP0,5%,50V
PC516 PC589 = CAP: part number: CAP_0402-150PF,CAP-42G0150P-C0,NP0,5%,50V
PC539 PC560 PC580 = CAP: part number: CAP_0402-1000PF,CAP-42G0D001-D0,X7R,10%,50V
PC549 PC591 = CAP: part number: CAP_0402-6800PF,CAP-42FD0068-D0,X7R,10%,25V
PC559 = CAPP: part number: CAPP_-270UF,CAP-PLE00270-E0,POLCAP,20%,16V
PC561 PC564 PC566 PC573 PC576 = CAP: part number: CAP_0402-220P,CAP-42G0220P-D0,X7R,10%,50V
PC568 PC571 PC572 PC579 = CAP: part number: CAP_0603-4.7UF,CAP-63C004D7-D0,X6S,10%,6.3V
PC594-PC596 PC598-PC600 PC1596 PC1598-PC1600 = CAP: part number: CAP_0805-47UF,CAP-85B00047-E0,X6S,20%,4V
PC700 PC701 = CAP: part number: CAP_0603-0.22UF,CAP-63F00D22-D0,EMPTY,10%,25V
PL2 PL3 = INDUCTOR_S4P: part number: INDUCTOR_S4P_-330NH_SMPM91X130,IND-P390331A-F0,IC,15%,32A,
PL4 = INDUCTOR: part number: INDUCTOR_-4.7UH,IND-C063T4R7-M0,IC,20%,5.5A,
PL5 PL7 PL9 PL10 PL12 PL20 PL510 = BEAD: part number: BEAD_-22,BED-00222012-00,IC,25%,,
PL6 = INDUCTOR: part number: INDUCTOR_-1UH,IND-C104T1R0-M0,IC,20%,18A,
PL8 = INDUCTOR: part number: INDUCTOR_-2.2UH,IND-C053T2R2-M0,IC,20%,5.5A,
PL11 = INDUCTOR: part number: INDUCTOR_-0.45UH,IND-C104TR45-M0,IC,20%,25A,
PQ6 PQ7 = 2N7002DW: part number: 2N7002DW_-2N7002KDW,MOS-2N7002DW-00,IC,,,
PR143 PR295-PR297 PR317 PR328 PR374 PR390 PR392 PR409 PR430 PR432 R38 R77 R274 R283 R285 R302 R310 R361-R363 = RES: part number: RES_0402-10K,RES-4200010K-B0,IC,1%,1/16W
PR298 PR299 PR310 PR311 PR321 PR353 PR357 PR366 PR376 PR378 PR394 PR395 PR418 PR434 PR435 PR800 PR801 R5-R8 R19-R30 R34 R40 R85 R86 R89 R90 R113 R114 R116 R117 R196 R213 R215 R221 R276 R298 R306 R338 R339 R347 R354 R355 R370 = RES: part number: RES_0402-0,RES-42000000-C0,IC,5%,1A
PR300 PR301 PR304 PR305 PR323 PR324 PR329 PR340 PR341 PR348 PR369 PR370 PR375 PR397 PR424 PR426 = RES: part number: RES_0603-0,RES-63000000-C0,IC,5%,1A
PR302 PR303 PR320 PR367 R39 R115 R195 R212 R214 R216 R222-R228 R233-R237 R269-R271 R297 R305 R307 R308 R358 = RES: part number: RES_0402-0,RES-42000000-C0,EMPTY,5%,1A
PR306 PR307 = RES: part number: RES_0805-2.2,RES-850002D2-B0,EMPTY,1%,1/8W
PR308 PR309 = RES: part number: RES_0402-4.02K,RES-4204D02K-B0,IC,1%,1/16W
PR314 PR332 = RES: part number: RES_0402-47K,RES-4200047K-B0,IC,1%,1/16W
PR315 PR333 = RES: part number: RES_0402-6.98K,RES-4206D98K-B0,IC,1%,1/16W
PR322 PR339 PR423 = RES: part number: RES_0402-39.2K,RES-42039D2K-B0,IC,1%,1/16W
PR325 PR336 PR363 PR420 R1-R4 R35 R36 R95-R106 R144 R145 R154-R159 R185 R186 R193 R194 R201-R204 R209 R210 R277 R278 R303 R304 R341 R348 = RES: part number: RES_0402-4.7K,RES-42004D7K-B0,IC,1%,1/16W
PR326 PR343 PR344 = RES: part number: RES_0402-2.2K,RES-42002D2K-B0,IC,1%,1/16W
PR327 PR346 PR373 PR431 = RES: part number: RES_0402-120,RES-42000120-B0,IC,1%,1/16W
PR330 = RES: part number: RES_0805-0,RES-85000000-C0,IC,5%,2A
PR342 PR372 = RES: part number: RES_0402-4.99K,RES-4204D99K-F0,IC,0.1%,1/16W
PR345 PR347 PR387 PR428 PR429 = RES: part number: RES_0402-12.4K,RES-42012D4K-B0,IC,1%,1/16W
PR355 PR403 PR406 = RES: part number: RES_0402-18.7K,RES-42018D7K-B0,IC,1%,1/16W
PR356 = RES: part number: RES_0402-37.4K,RES-42037D4K-B0,IC,1%,1/16W
PR361 = RES: part number: RES_0402-6.34K,RES-4206D34K-B0,EMPTY,1%,1/16W
PR368 = RES: part number: RES_0402-36.5K,RES-42036D5K-B0,IC,1%,1/16W
PR371 = RES: part number: RES_0402-3.32K,RES-4203D32K-B0,IC,1%,1/16W
PR377 PR503 = RES: part number: RES_0603-100,RES-63000100-B0,IC,1%,1/10W
PR382 R110 = RES: part number: RES_0402-300,RES-42000300-B0,IC,1%,1/16W
PR383 = RES: part number: RES_0402-10.2K,RES-42010D2K-B0,IC,1%,1/16W
PR385 PR399 PR410 PR414 = RES: part number: RES_0402-20K,RES-4200020K-B0,IC,1%,1/16W
PR389 PR504 = RES: part number: RES_0402-10,RES-42000010-B0,IC,1%,1/16W
PR391 R37 R109 R281 R293 R360 = RES: part number: RES_0402-10K,RES-4200010K-B0,EMPTY,1%,1/16W
PR393 PR411 = RES: part number: RES_0402-20K,RES-4200020K-B0,EMPTY,1%,1/16W
PR396 = RES: part number: RES_0402-4.99K,RES-4204D99K-F0,EMPTY,0.1%,1/16W
PR398 PR413 = RES: part number: RES_0402-15K,RES-4200015K-B0,IC,1%,1/16W
PR400 = RES: part number: RES_0603-2.2,RES-630002D2-C0,IC,5%,1/10W
PR401 R346 = RES: part number: RES_0402-1.5K,RES-42001D5K-B0,IC,1%,1/16W
PR402 PR405 = RES: part number: RES_0402-49.9K,RES-42049D9K-B0,IC,1%,1/16W
PR404 = RES: part number: RES_0402-7.5K,RES-42007D5K-B0,IC,1%,1/16W
PR407 = RES: part number: RES_0603-0,RES-63000000-C0,EMPTY,5%,1A
PR408 = RES: part number: RES_0402-2.7K,RES-42002D7K-B0,IC,1%,1/16W
PR427 = RES: part number: RES_0402-5.6K,RES-42005D6K-B0,IC,1%,1/16W
PR433 PR505 R76 R93 R94 R107 R108 R135 R152 R153 R160-R163 R178 R180 R191 R192 R282 R290 R292 R294 R301 R342 = RES: part number: RES_0402-100,RES-42000100-B0,IC,1%,1/16W
PU13 PU15 = NCP5339: part number: NCP5339_-NCP5339MNTXG,ICP-NCP5339M-00,IC,,
PU16 PU19 = IR3823_1: part number: IR3823_1_-IR3823MTRPBF,ICP-IR3823MT-00,IC,,,
PU17 PU23 = IR3895: part number: IR3895_-IR3895MTPRPBF,ICP-IR3895MT-00,IC,,
PU18 = TPS7A37: part number: TPS7A37_-TPS7A3701DRVR,ICP-TPS7A370-P0,IC,,,
PU20 PU22 = NCP716MTG50TBG: part number: NCP716MTG50TBG_-NCP716MTG50TBG,ICP-NCP716MT-00,IC,,
PU21 = NCP81234: part number: NCP81234_-NCP81234MNTXG,ICP-NCP81234-00,IC,,
Q1-Q4 Q7 Q13-Q26 = 2N7002: part number: 2N7002_-2N7002,MOS-002N7002-00,IC,,,
Q5 Q6 Q27 = NPN: part number: NPN_-MMBT3904LT1G,BJT-MMBT3904-00,IC,,,
R9 R33 R134 R172 R177 R179 R181 R289 R291 = RES: part number: RES_0402-1K,RES-4200001K-B0,EMPTY,1%,1/16W
R10-R18 R41-R75 R111 R112 R164-R171 R173-R176 R205-R208 R211 R217-R220 R229-R232 R241-R244 R253-R256 R265-R268 R309 R311-R316 R318-R325 R336 R337 R345 = RES: part number: RES_0402-3K,RES-4200003K-B0,IC,1%,1/16W
R31 R32 R128 R130 R132 R136-R139 R141 R142 R146-R151 R197-R200 R272 R273 R287 R326 R328 R330 R332-R335 = RES: part number: RES_0402-1K,RES-4200001K-B0,IC,1%,1/16W
R78 R81 = RES: part number: RES_0402-8.2K,RES-42008D2K-B0,IC,1%,1/16W
R79 R83 = RES: part number: RES_0402-8.2K,RES-42008D2K-B0,EMPTY,1%,1/16W
R80 R84 = RES: part number: RES_0402-475,RES-42000475-B0,IC,1%,1/16W
R82 = RES: part number: RES_0402-475,RES-42000475-B0,EMPTY,1%,1/16W
R87 R88 R187-R190 R238-R240 R245-R252 R257-R264 R275 R295 R296 R317 R349-R353 R356 R357 R359 = RES: part number: RES_0402-4.7K,RES-42004D7K-B0,EMPTY,1%,1/16W
R91 R92 = RES: part number: RES_0402-2.2,RES-420002D2-B0,IC,1%,1/16W
R118-R127 R143 R340 = RES: part number: RES_0402-27.4,RES-420027D4-B0,IC,1%,1/16W
R129 R131 R133 R140 R182 R284 R286 R288 R327 R329 R331 = RES: part number: RES_0402-100,RES-42000100-B0,EMPTY,1%,1/16W
R183 R184 R279 R280 R299 R300 = RES: part number: RES_0402-22,RES-42000022-B0,IC,1%,1/16W
R343 R344 = RES: part number: RES_0402-3K,RES-4200003K-B0,EMPTY,1%,1/16W
SHORT1-SHORT12 = SHORT: part number: SHORT_-0805,,,,,
SHORT105 = SHORT: part number: SHORT_-0603,,,,,
U1 = PEX8796: part number: PEX8796_-PEX8796-AB80BIG,ICC-PEX8796A-00,IC,,
U2 = PCA9548: part number: PCA9548_-PCA9548APW,ICC-PCA9548A-00,IC,,
U4 = EMC1412: part number: EMC1412_-EMC1412-1-ACZL-TR,ICC-EMC14121-00,IC,,
U5 U23 U25-U27 U29-U31 U33-U35 U37 U39 U41 U43 U45 = COUPON_7P: part number: COUPON_7P_-COUPON,,EMPTY,,
U6 = AT25256B: part number: AT25256B_-AT25256B-SSHL-T,ICM-AT25256B-00,IC,,
U7 = AT24C64D: part number: AT24C64D_-AT24C64D-SSHM-T,ICM-AT24C64D-00,IC,,
U8 U13 U15-U17 = SN74LVC1G17: part number: SN74LVC1G17_-SN74LVC1G17DCKR,ICC-LVC1G17D-00,IC,,,
U9 = 9ZXL0651AKLFT: part number: 9ZXL0651AKLFT_-9ZXL0651AKLFT,ICC-9ZXL0651-00,IC,,
U10 = EMC1413AAIZLTR: part number: EMC1413AAIZLTR_-EMC1413-A-AIZL-TR,ICC-EMC1413A-00,IC,,
U12 = PCA9617: part number: PCA9617_-PCA9617ADP,ICC-PCA9617A-00,IC,,
U18-U21 U47 = SN74LVC1G07: part number: SN74LVC1G07_-SN74LVC1G07DCKR,ICC-LVC1G07D-00,IC,,,
U22 = NC7SZ08P5X: part number: NC7SZ08P5X_-NC7SZ08P5X,ICC-NC7SZ08P-00,IC,,,

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
B2012
  rect 1.118x1.372 smd: 1(-0.95,0) 2(0.95,0)
BGA1156
  round 0.49 smd: A1(-16.5,16.5) A2(-15.5,16.5) A3(-14.5,16.5) A4(-13.5,16.5) A5(-12.5,16.5) A6(-11.5,16.5) A7(-10.5,16.5) A8(-9.5,16.5) A9(-8.5,16.5) A10(-7.5,16.5) A11(-6.5,16.5) A12(-5.5,16.5) A13(-4.5,16.5) A14(-3.5,16.5) A15(-2.5,16.5) A16(-1.5,16.5) A17(-0.5,16.5) A18(0.5,16.5) A19(1.5,16.5) A20(2.5,16.5) A21(3.5,16.5) A22(4.5,16.5) A23(5.5,16.5) A24(6.5,16.5) A25(7.5,16.5) A26(8.5,16.5) A27(9.5,16.5) A28(10.5,16.5) A29(11.5,16.5) A30(12.5,16.5) A31(13.5,16.5) A32(14.5,16.5) A33(15.5,16.5) A34(16.5,16.5) AA1(-16.5,-3.5) AA2(-15.5,-3.5) AA3(-14.5,-3.5) AA4(-13.5,-3.5) AA5(-12.5,-3.5) AA6(-11.5,-3.5) AA7(-10.5,-3.5) AA8(-9.5,-3.5) AA9(-8.5,-3.5) AA10(-7.5,-3.5) AA11(-6.5,-3.5) AA12(-5.5,-3.5) AA13(-4.5,-3.5) AA14(-3.5,-3.5) AA15(-2.5,-3.5) AA16(-1.5,-3.5) AA17(-0.5,-3.5) AA18(0.5,-3.5) AA19(1.5,-3.5) AA20(2.5,-3.5) AA21(3.5,-3.5) AA22(4.5,-3.5) AA23(5.5,-3.5) AA24(6.5,-3.5) AA25(7.5,-3.5) AA26(8.5,-3.5) AA27(9.5,-3.5) AA28(10.5,-3.5) AA29(11.5,-3.5) AA30(12.5,-3.5) AA31(13.5,-3.5) AA32(14.5,-3.5) AA33(15.5,-3.5) AA34(16.5,-3.5) AB1(-16.5,-4.5) AB2(-15.5,-4.5) AB3(-14.5,-4.5) AB4(-13.5,-4.5) AB5(-12.5,-4.5) AB6(-11.5,-4.5) AB7(-10.5,-4.5) AB8(-9.5,-4.5) AB9(-8.5,-4.5) AB10(-7.5,-4.5) AB11(-6.5,-4.5) AB12(-5.5,-4.5) AB13(-4.5,-4.5) AB14(-3.5,-4.5) AB15(-2.5,-4.5) AB16(-1.5,-4.5) AB17(-0.5,-4.5) AB18(0.5,-4.5) AB19(1.5,-4.5) AB20(2.5,-4.5) AB21(3.5,-4.5) AB22(4.5,-4.5) AB23(5.5,-4.5) AB24(6.5,-4.5) AB25(7.5,-4.5) AB26(8.5,-4.5) AB27(9.5,-4.5) AB28(10.5,-4.5) AB29(11.5,-4.5) AB30(12.5,-4.5) AB31(13.5,-4.5) AB32(14.5,-4.5) AB33(15.5,-4.5) AB34(16.5,-4.5) AC1(-16.5,-5.5) AC2(-15.5,-5.5) AC3(-14.5,-5.5) AC4(-13.5,-5.5) AC5(-12.5,-5.5) AC6(-11.5,-5.5) AC7(-10.5,-5.5) AC8(-9.5,-5.5) AC9(-8.5,-5.5) AC10(-7.5,-5.5) AC11(-6.5,-5.5) AC12(-5.5,-5.5) AC13(-4.5,-5.5) AC14(-3.5,-5.5) AC15(-2.5,-5.5) AC16(-1.5,-5.5) AC17(-0.5,-5.5) AC18(0.5,-5.5) AC19(1.5,-5.5) AC20(2.5,-5.5) AC21(3.5,-5.5) AC22(4.5,-5.5) AC23(5.5,-5.5) AC24(6.5,-5.5) AC25(7.5,-5.5) AC26(8.5,-5.5) AC27(9.5,-5.5) AC28(10.5,-5.5) AC29(11.5,-5.5) AC30(12.5,-5.5) AC31(13.5,-5.5) AC32(14.5,-5.5) AC33(15.5,-5.5) AC34(16.5,-5.5) AD1(-16.5,-6.5) AD2(-15.5,-6.5) AD3(-14.5,-6.5) AD4(-13.5,-6.5) AD5(-12.5,-6.5) AD6(-11.5,-6.5) AD7(-10.5,-6.5) AD8(-9.5,-6.5) AD9(-8.5,-6.5) AD10(-7.5,-6.5) AD11(-6.5,-6.5) AD12(-5.5,-6.5) AD13(-4.5,-6.5) AD14(-3.5,-6.5) AD15(-2.5,-6.5) AD16(-1.5,-6.5) AD17(-0.5,-6.5) AD18(0.5,-6.5) AD19(1.5,-6.5) AD20(2.5,-6.5) AD21(3.5,-6.5) AD22(4.5,-6.5) AD23(5.5,-6.5) AD24(6.5,-6.5) AD25(7.5,-6.5) AD26(8.5,-6.5) AD27(9.5,-6.5) AD28(10.5,-6.5) AD29(11.5,-6.5) AD30(12.5,-6.5) AD31(13.5,-6.5) AD32(14.5,-6.5) AD33(15.5,-6.5) AD34(16.5,-6.5) AE1(-16.5,-7.5) AE2(-15.5,-7.5) AE3(-14.5,-7.5) AE4(-13.5,-7.5) AE5(-12.5,-7.5) AE6(-11.5,-7.5) AE7(-10.5,-7.5) AE8(-9.5,-7.5) AE9(-8.5,-7.5) AE10(-7.5,-7.5) AE11(-6.5,-7.5) AE12(-5.5,-7.5) AE13(-4.5,-7.5) AE14(-3.5,-7.5) AE15(-2.5,-7.5) AE16(-1.5,-7.5) AE17(-0.5,-7.5) AE18(0.5,-7.5) AE19(1.5,-7.5) AE20(2.5,-7.5) AE21(3.5,-7.5) AE22(4.5,-7.5) AE23(5.5,-7.5) AE24(6.5,-7.5) AE25(7.5,-7.5) AE26(8.5,-7.5) AE27(9.5,-7.5) AE28(10.5,-7.5) AE29(11.5,-7.5) AE30(12.5,-7.5) AE31(13.5,-7.5) AE32(14.5,-7.5) AE33(15.5,-7.5) AE34(16.5,-7.5) AF1(-16.5,-8.5) AF2(-15.5,-8.5) AF3(-14.5,-8.5) AF4(-13.5,-8.5) AF5(-12.5,-8.5) AF6(-11.5,-8.5) AF7(-10.5,-8.5) AF8(-9.5,-8.5) AF9(-8.5,-8.5) AF10(-7.5,-8.5) AF11(-6.5,-8.5) AF12(-5.5,-8.5) AF13(-4.5,-8.5) AF14(-3.5,-8.5) AF15(-2.5,-8.5) AF16(-1.5,-8.5) AF17(-0.5,-8.5) AF18(0.5,-8.5) AF19(1.5,-8.5) AF20(2.5,-8.5) AF21(3.5,-8.5) AF22(4.5,-8.5) AF23(5.5,-8.5) AF24(6.5,-8.5) AF25(7.5,-8.5) AF26(8.5,-8.5) AF27(9.5,-8.5) AF28(10.5,-8.5) AF29(11.5,-8.5) AF30(12.5,-8.5) AF31(13.5,-8.5) AF32(14.5,-8.5) AF33(15.5,-8.5) AF34(16.5,-8.5) AG1(-16.5,-9.5) AG2(-15.5,-9.5) AG3(-14.5,-9.5) AG4(-13.5,-9.5) AG5(-12.5,-9.5) AG6(-11.5,-9.5) AG7(-10.5,-9.5) AG8(-9.5,-9.5) AG9(-8.5,-9.5) AG10(-7.5,-9.5) AG11(-6.5,-9.5) AG12(-5.5,-9.5) AG13(-4.5,-9.5) AG14(-3.5,-9.5) AG15(-2.5,-9.5) AG16(-1.5,-9.5) AG17(-0.5,-9.5) AG18(0.5,-9.5) AG19(1.5,-9.5) AG20(2.5,-9.5) AG21(3.5,-9.5) AG22(4.5,-9.5) AG23(5.5,-9.5) AG24(6.5,-9.5) AG25(7.5,-9.5) AG26(8.5,-9.5) AG27(9.5,-9.5) AG28(10.5,-9.5) AG29(11.5,-9.5) AG30(12.5,-9.5) AG31(13.5,-9.5) AG32(14.5,-9.5) AG33(15.5,-9.5) AG34(16.5,-9.5) AH1(-16.5,-10.5) AH2(-15.5,-10.5) AH3(-14.5,-10.5) AH4(-13.5,-10.5) AH5(-12.5,-10.5) AH6(-11.5,-10.5) AH7(-10.5,-10.5) AH8(-9.5,-10.5) AH9(-8.5,-10.5) AH10(-7.5,-10.5) AH11(-6.5,-10.5) AH12(-5.5,-10.5) AH13(-4.5,-10.5) AH14(-3.5,-10.5) AH15(-2.5,-10.5) AH16(-1.5,-10.5) AH17(-0.5,-10.5) AH18(0.5,-10.5) AH19(1.5,-10.5) AH20(2.5,-10.5) AH21(3.5,-10.5) AH22(4.5,-10.5) AH23(5.5,-10.5) AH24(6.5,-10.5) AH25(7.5,-10.5) AH26(8.5,-10.5) AH27(9.5,-10.5) AH28(10.5,-10.5) AH29(11.5,-10.5) AH30(12.5,-10.5) AH31(13.5,-10.5) AH32(14.5,-10.5) AH33(15.5,-10.5) AH34(16.5,-10.5) AJ1(-16.5,-11.5) AJ2(-15.5,-11.5) AJ3(-14.5,-11.5) AJ4(-13.5,-11.5) AJ5(-12.5,-11.5) AJ6(-11.5,-11.5) AJ7(-10.5,-11.5) AJ8(-9.5,-11.5) AJ9(-8.5,-11.5) AJ10(-7.5,-11.5) AJ11(-6.5,-11.5) AJ12(-5.5,-11.5) AJ13(-4.5,-11.5) AJ14(-3.5,-11.5) AJ15(-2.5,-11.5) AJ16(-1.5,-11.5) AJ17(-0.5,-11.5) AJ18(0.5,-11.5) AJ19(1.5,-11.5) AJ20(2.5,-11.5) AJ21(3.5,-11.5) AJ22(4.5,-11.5) AJ23(5.5,-11.5) AJ24(6.5,-11.5) AJ25(7.5,-11.5) AJ26(8.5,-11.5) AJ27(9.5,-11.5) AJ28(10.5,-11.5) AJ29(11.5,-11.5) AJ30(12.5,-11.5) AJ31(13.5,-11.5) AJ32(14.5,-11.5) AJ33(15.5,-11.5) AJ34(16.5,-11.5) AK1(-16.5,-12.5) AK2(-15.5,-12.5) AK3(-14.5,-12.5) AK4(-13.5,-12.5) AK5(-12.5,-12.5) AK6(-11.5,-12.5) AK7(-10.5,-12.5) AK8(-9.5,-12.5) AK9(-8.5,-12.5) AK10(-7.5,-12.5) AK11(-6.5,-12.5) AK12(-5.5,-12.5) AK13(-4.5,-12.5) AK14(-3.5,-12.5) AK15(-2.5,-12.5) AK16(-1.5,-12.5) AK17(-0.5,-12.5) AK18(0.5,-12.5) AK19(1.5,-12.5) AK20(2.5,-12.5) AK21(3.5,-12.5) AK22(4.5,-12.5) AK23(5.5,-12.5) AK24(6.5,-12.5) AK25(7.5,-12.5) AK26(8.5,-12.5) AK27(9.5,-12.5) AK28(10.5,-12.5) AK29(11.5,-12.5) AK30(12.5,-12.5) AK31(13.5,-12.5) AK32(14.5,-12.5) AK33(15.5,-12.5) AK34(16.5,-12.5) AL1(-16.5,-13.5) AL2(-15.5,-13.5) AL3(-14.5,-13.5) AL4(-13.5,-13.5) AL5(-12.5,-13.5) AL6(-11.5,-13.5) AL7(-10.5,-13.5) AL8(-9.5,-13.5) AL9(-8.5,-13.5) AL10(-7.5,-13.5) AL11(-6.5,-13.5) AL12(-5.5,-13.5) AL13(-4.5,-13.5) AL14(-3.5,-13.5) AL15(-2.5,-13.5) AL16(-1.5,-13.5) AL17(-0.5,-13.5) AL18(0.5,-13.5) AL19(1.5,-13.5) AL20(2.5,-13.5) AL21(3.5,-13.5) AL22(4.5,-13.5) AL23(5.5,-13.5) AL24(6.5,-13.5) AL25(7.5,-13.5) AL26(8.5,-13.5) AL27(9.5,-13.5) AL28(10.5,-13.5) AL29(11.5,-13.5) AL30(12.5,-13.5) AL31(13.5,-13.5) AL32(14.5,-13.5) AL33(15.5,-13.5) AL34(16.5,-13.5) AM1(-16.5,-14.5) AM2(-15.5,-14.5) AM3(-14.5,-14.5) AM4(-13.5,-14.5) AM5(-12.5,-14.5) AM6(-11.5,-14.5) AM7(-10.5,-14.5) AM8(-9.5,-14.5) AM9(-8.5,-14.5) AM10(-7.5,-14.5) AM11(-6.5,-14.5) AM12(-5.5,-14.5) AM13(-4.5,-14.5) AM14(-3.5,-14.5) AM15(-2.5,-14.5) AM16(-1.5,-14.5) AM17(-0.5,-14.5) AM18(0.5,-14.5) AM19(1.5,-14.5) AM20(2.5,-14.5) AM21(3.5,-14.5) AM22(4.5,-14.5) AM23(5.5,-14.5) AM24(6.5,-14.5) AM25(7.5,-14.5) AM26(8.5,-14.5) AM27(9.5,-14.5) AM28(10.5,-14.5) AM29(11.5,-14.5) AM30(12.5,-14.5) AM31(13.5,-14.5) AM32(14.5,-14.5) AM33(15.5,-14.5) AM34(16.5,-14.5) AN1(-16.5,-15.5) AN2(-15.5,-15.5) AN3(-14.5,-15.5) AN4(-13.5,-15.5) AN5(-12.5,-15.5) AN6(-11.5,-15.5) AN7(-10.5,-15.5) AN8(-9.5,-15.5) AN9(-8.5,-15.5) AN10(-7.5,-15.5) AN11(-6.5,-15.5) AN12(-5.5,-15.5) AN13(-4.5,-15.5) AN14(-3.5,-15.5) AN15(-2.5,-15.5) AN16(-1.5,-15.5) AN17(-0.5,-15.5) AN18(0.5,-15.5) AN19(1.5,-15.5) AN20(2.5,-15.5) AN21(3.5,-15.5) AN22(4.5,-15.5) AN23(5.5,-15.5) AN24(6.5,-15.5) AN25(7.5,-15.5) AN26(8.5,-15.5) AN27(9.5,-15.5) AN28(10.5,-15.5) AN29(11.5,-15.5) AN30(12.5,-15.5) AN31(13.5,-15.5) AN32(14.5,-15.5) AN33(15.5,-15.5) AN34(16.5,-15.5) AP1(-16.5,-16.5) AP2(-15.5,-16.5) AP3(-14.5,-16.5) AP4(-13.5,-16.5) AP5(-12.5,-16.5) AP6(-11.5,-16.5) AP7(-10.5,-16.5) AP8(-9.5,-16.5) AP9(-8.5,-16.5) AP10(-7.5,-16.5) AP11(-6.5,-16.5) AP12(-5.5,-16.5) AP13(-4.5,-16.5) AP14(-3.5,-16.5) AP15(-2.5,-16.5) AP16(-1.5,-16.5) AP17(-0.5,-16.5) AP18(0.5,-16.5) AP19(1.5,-16.5) AP20(2.5,-16.5) AP21(3.5,-16.5) AP22(4.5,-16.5) AP23(5.5,-16.5) AP24(6.5,-16.5) AP25(7.5,-16.5) AP26(8.5,-16.5) AP27(9.5,-16.5) AP28(10.5,-16.5) AP29(11.5,-16.5) AP30(12.5,-16.5) AP31(13.5,-16.5) AP32(14.5,-16.5) AP33(15.5,-16.5) AP34(16.5,-16.5) B1(-16.5,15.5) B2(-15.5,15.5) B3(-14.5,15.5) B4(-13.5,15.5) B5(-12.5,15.5) B6(-11.5,15.5) B7(-10.5,15.5) B8(-9.5,15.5) B9(-8.5,15.5) B10(-7.5,15.5) B11(-6.5,15.5) B12(-5.5,15.5) B13(-4.5,15.5) B14(-3.5,15.5) B15(-2.5,15.5) B16(-1.5,15.5) B17(-0.5,15.5) B18(0.5,15.5) B19(1.5,15.5) B20(2.5,15.5) B21(3.5,15.5) B22(4.5,15.5) B23(5.5,15.5) B24(6.5,15.5) B25(7.5,15.5) B26(8.5,15.5) B27(9.5,15.5) B28(10.5,15.5) B29(11.5,15.5) B30(12.5,15.5) B31(13.5,15.5) B32(14.5,15.5) B33(15.5,15.5) B34(16.5,15.5) C1(-16.5,14.5) C2(-15.5,14.5) C3(-14.5,14.5) C4(-13.5,14.5) C5(-12.5,14.5) C6(-11.5,14.5) C7(-10.5,14.5) C8(-9.5,14.5) C9(-8.5,14.5) C10(-7.5,14.5) C11(-6.5,14.5) C12(-5.5,14.5) C13(-4.5,14.5) C14(-3.5,14.5) C15(-2.5,14.5) C16(-1.5,14.5) C17(-0.5,14.5) C18(0.5,14.5) C19(1.5,14.5) C20(2.5,14.5) C21(3.5,14.5) C22(4.5,14.5) C23(5.5,14.5) C24(6.5,14.5) C25(7.5,14.5) C26(8.5,14.5) C27(9.5,14.5) C28(10.5,14.5) C29(11.5,14.5) C30(12.5,14.5) C31(13.5,14.5) C32(14.5,14.5) C33(15.5,14.5) C34(16.5,14.5) D1(-16.5,13.5) D2(-15.5,13.5) D3(-14.5,13.5) D4(-13.5,13.5) D5(-12.5,13.5) D6(-11.5,13.5) D7(-10.5,13.5) D8(-9.5,13.5) D9(-8.5,13.5) D10(-7.5,13.5) D11(-6.5,13.5) D12(-5.5,13.5) D13(-4.5,13.5) D14(-3.5,13.5) D15(-2.5,13.5) D16(-1.5,13.5) D17(-0.5,13.5) D18(0.5,13.5) D19(1.5,13.5) D20(2.5,13.5) D21(3.5,13.5) D22(4.5,13.5) D23(5.5,13.5) D24(6.5,13.5) D25(7.5,13.5) D26(8.5,13.5) D27(9.5,13.5) D28(10.5,13.5) D29(11.5,13.5) D30(12.5,13.5) D31(13.5,13.5) D32(14.5,13.5) D33(15.5,13.5) D34(16.5,13.5) E1(-16.5,12.5) E2(-15.5,12.5) E3(-14.5,12.5) E4(-13.5,12.5) E5(-12.5,12.5) E6(-11.5,12.5) E7(-10.5,12.5) E8(-9.5,12.5) E9(-8.5,12.5) E10(-7.5,12.5) E11(-6.5,12.5) E12(-5.5,12.5) E13(-4.5,12.5) E14(-3.5,12.5) E15(-2.5,12.5) E16(-1.5,12.5) E17(-0.5,12.5) E18(0.5,12.5) E19(1.5,12.5) E20(2.5,12.5) E21(3.5,12.5) E22(4.5,12.5) E23(5.5,12.5) E24(6.5,12.5) E25(7.5,12.5) E26(8.5,12.5) E27(9.5,12.5) E28(10.5,12.5) E29(11.5,12.5) E30(12.5,12.5) E31(13.5,12.5) E32(14.5,12.5) E33(15.5,12.5) E34(16.5,12.5) F1(-16.5,11.5) F2(-15.5,11.5) F3(-14.5,11.5) F4(-13.5,11.5) F5(-12.5,11.5) F6(-11.5,11.5) F7(-10.5,11.5) F8(-9.5,11.5) F9(-8.5,11.5) F10(-7.5,11.5) F11(-6.5,11.5) F12(-5.5,11.5) F13(-4.5,11.5) F14(-3.5,11.5) F15(-2.5,11.5) F16(-1.5,11.5) F17(-0.5,11.5) F18(0.5,11.5) F19(1.5,11.5) F20(2.5,11.5) F21(3.5,11.5) F22(4.5,11.5) F23(5.5,11.5) F24(6.5,11.5) F25(7.5,11.5) F26(8.5,11.5) F27(9.5,11.5) F28(10.5,11.5) F29(11.5,11.5) F30(12.5,11.5) F31(13.5,11.5) F32(14.5,11.5) F33(15.5,11.5) F34(16.5,11.5) G1(-16.5,10.5) G2(-15.5,10.5) G3(-14.5,10.5) G4(-13.5,10.5) G5(-12.5,10.5) G6(-11.5,10.5) G7(-10.5,10.5) G8(-9.5,10.5) G9(-8.5,10.5) G10(-7.5,10.5) G11(-6.5,10.5) G12(-5.5,10.5) G13(-4.5,10.5) G14(-3.5,10.5) G15(-2.5,10.5) G16(-1.5,10.5) G17(-0.5,10.5) G18(0.5,10.5) G19(1.5,10.5) G20(2.5,10.5) G21(3.5,10.5) G22(4.5,10.5) G23(5.5,10.5) G24(6.5,10.5) G25(7.5,10.5) G26(8.5,10.5) G27(9.5,10.5) G28(10.5,10.5) G29(11.5,10.5) G30(12.5,10.5) G31(13.5,10.5) G32(14.5,10.5) G33(15.5,10.5) G34(16.5,10.5) H1(-16.5,9.5) H2(-15.5,9.5) H3(-14.5,9.5) H4(-13.5,9.5) H5(-12.5,9.5) H6(-11.5,9.5) H7(-10.5,9.5) H8(-9.5,9.5) H9(-8.5,9.5) H10(-7.5,9.5) H11(-6.5,9.5) H12(-5.5,9.5) H13(-4.5,9.5) H14(-3.5,9.5) H15(-2.5,9.5) H16(-1.5,9.5) H17(-0.5,9.5) H18(0.5,9.5) H19(1.5,9.5) H20(2.5,9.5) H21(3.5,9.5) H22(4.5,9.5) H23(5.5,9.5) H24(6.5,9.5) H25(7.5,9.5) H26(8.5,9.5) H27(9.5,9.5) H28(10.5,9.5) H29(11.5,9.5) H30(12.5,9.5) H31(13.5,9.5) H32(14.5,9.5) H33(15.5,9.5) H34(16.5,9.5) J1(-16.5,8.5) J2(-15.5,8.5) J3(-14.5,8.5) J4(-13.5,8.5) J5(-12.5,8.5) J6(-11.5,8.5) J7(-10.5,8.5) J8(-9.5,8.5) J9(-8.5,8.5) J10(-7.5,8.5) J11(-6.5,8.5) J12(-5.5,8.5) J13(-4.5,8.5) J14(-3.5,8.5) J15(-2.5,8.5) J16(-1.5,8.5) J17(-0.5,8.5) J18(0.5,8.5) J19(1.5,8.5) J20(2.5,8.5) J21(3.5,8.5) J22(4.5,8.5) J23(5.5,8.5) J24(6.5,8.5) J25(7.5,8.5) J26(8.5,8.5) J27(9.5,8.5) J28(10.5,8.5) J29(11.5,8.5) J30(12.5,8.5) J31(13.5,8.5) J32(14.5,8.5) J33(15.5,8.5) J34(16.5,8.5) K1(-16.5,7.5) K2(-15.5,7.5) K3(-14.5,7.5) K4(-13.5,7.5) K5(-12.5,7.5) K6(-11.5,7.5) K7(-10.5,7.5) K8(-9.5,7.5) K9(-8.5,7.5) K10(-7.5,7.5) K11(-6.5,7.5) K12(-5.5,7.5) K13(-4.5,7.5) K14(-3.5,7.5) K15(-2.5,7.5) K16(-1.5,7.5) K17(-0.5,7.5) K18(0.5,7.5) K19(1.5,7.5) K20(2.5,7.5) K21(3.5,7.5) K22(4.5,7.5) K23(5.5,7.5) K24(6.5,7.5) K25(7.5,7.5) K26(8.5,7.5) K27(9.5,7.5) K28(10.5,7.5) K29(11.5,7.5) K30(12.5,7.5) K31(13.5,7.5) K32(14.5,7.5) K33(15.5,7.5) K34(16.5,7.5) L1(-16.5,6.5) L2(-15.5,6.5) L3(-14.5,6.5) L4(-13.5,6.5) L5(-12.5,6.5) L6(-11.5,6.5) L7(-10.5,6.5) L8(-9.5,6.5) L9(-8.5,6.5) L10(-7.5,6.5) L11(-6.5,6.5) L12(-5.5,6.5) L13(-4.5,6.5) L14(-3.5,6.5) L15(-2.5,6.5) L16(-1.5,6.5) L17(-0.5,6.5) L18(0.5,6.5) L19(1.5,6.5) L20(2.5,6.5) L21(3.5,6.5) L22(4.5,6.5) L23(5.5,6.5) L24(6.5,6.5) L25(7.5,6.5) L26(8.5,6.5) L27(9.5,6.5) L28(10.5,6.5) L29(11.5,6.5) L30(12.5,6.5) L31(13.5,6.5) L32(14.5,6.5) L33(15.5,6.5) L34(16.5,6.5) M1(-16.5,5.5) M2(-15.5,5.5) M3(-14.5,5.5) M4(-13.5,5.5) M5(-12.5,5.5) M6(-11.5,5.5) M7(-10.5,5.5) M8(-9.5,5.5) M9(-8.5,5.5) M10(-7.5,5.5) M11(-6.5,5.5) M12(-5.5,5.5) M13(-4.5,5.5) M14(-3.5,5.5) M15(-2.5,5.5) M16(-1.5,5.5) M17(-0.5,5.5) M18(0.5,5.5) M19(1.5,5.5) M20(2.5,5.5) M21(3.5,5.5) M22(4.5,5.5) M23(5.5,5.5) M24(6.5,5.5) M25(7.5,5.5) M26(8.5,5.5) M27(9.5,5.5) M28(10.5,5.5) M29(11.5,5.5) M30(12.5,5.5) M31(13.5,5.5) M32(14.5,5.5) M33(15.5,5.5) M34(16.5,5.5) N1(-16.5,4.5) N2(-15.5,4.5) N3(-14.5,4.5) N4(-13.5,4.5) N5(-12.5,4.5) N6(-11.5,4.5) N7(-10.5,4.5) N8(-9.5,4.5) N9(-8.5,4.5) N10(-7.5,4.5) N11(-6.5,4.5) N12(-5.5,4.5) N13(-4.5,4.5) N14(-3.5,4.5) N15(-2.5,4.5) N16(-1.5,4.5) N17(-0.5,4.5) N18(0.5,4.5) N19(1.5,4.5) N20(2.5,4.5) N21(3.5,4.5) N22(4.5,4.5) N23(5.5,4.5) N24(6.5,4.5) N25(7.5,4.5) N26(8.5,4.5) N27(9.5,4.5) N28(10.5,4.5) N29(11.5,4.5) N30(12.5,4.5) N31(13.5,4.5) N32(14.5,4.5) N33(15.5,4.5) N34(16.5,4.5) P1(-16.5,3.5) P2(-15.5,3.5) P3(-14.5,3.5) P4(-13.5,3.5) P5(-12.5,3.5) P6(-11.5,3.5) P7(-10.5,3.5) P8(-9.5,3.5) P9(-8.5,3.5) P10(-7.5,3.5) P11(-6.5,3.5) P12(-5.5,3.5) P13(-4.5,3.5) P14(-3.5,3.5) P15(-2.5,3.5) P16(-1.5,3.5) P17(-0.5,3.5) P18(0.5,3.5) P19(1.5,3.5) P20(2.5,3.5) P21(3.5,3.5) P22(4.5,3.5) P23(5.5,3.5) P24(6.5,3.5) P25(7.5,3.5) P26(8.5,3.5) P27(9.5,3.5) P28(10.5,3.5) P29(11.5,3.5) P30(12.5,3.5) P31(13.5,3.5) P32(14.5,3.5) P33(15.5,3.5) P34(16.5,3.5) R1(-16.5,2.5) R2(-15.5,2.5) R3(-14.5,2.5) R4(-13.5,2.5) R5(-12.5,2.5) R6(-11.5,2.5) R7(-10.5,2.5) R8(-9.5,2.5) R9(-8.5,2.5) R10(-7.5,2.5) R11(-6.5,2.5) R12(-5.5,2.5) R13(-4.5,2.5) R14(-3.5,2.5) R15(-2.5,2.5) R16(-1.5,2.5) R17(-0.5,2.5) R18(0.5,2.5) R19(1.5,2.5) R20(2.5,2.5) R21(3.5,2.5) R22(4.5,2.5) R23(5.5,2.5) R24(6.5,2.5) R25(7.5,2.5) R26(8.5,2.5) R27(9.5,2.5) R28(10.5,2.5) R29(11.5,2.5) R30(12.5,2.5) R31(13.5,2.5) R32(14.5,2.5) R33(15.5,2.5) R34(16.5,2.5) T1(-16.5,1.5) T2(-15.5,1.5) T3(-14.5,1.5) T4(-13.5,1.5) T5(-12.5,1.5) T6(-11.5,1.5) T7(-10.5,1.5) T8(-9.5,1.5) T9(-8.5,1.5) T10(-7.5,1.5) T11(-6.5,1.5) T12(-5.5,1.5) T13(-4.5,1.5) T14(-3.5,1.5) T15(-2.5,1.5) T16(-1.5,1.5) T17(-0.5,1.5) T18(0.5,1.5) T19(1.5,1.5) T20(2.5,1.5) T21(3.5,1.5) T22(4.5,1.5) T23(5.5,1.5) T24(6.5,1.5) T25(7.5,1.5) T26(8.5,1.5) T27(9.5,1.5) T28(10.5,1.5) T29(11.5,1.5) T30(12.5,1.5) T31(13.5,1.5) T32(14.5,1.5) T33(15.5,1.5) T34(16.5,1.5) U1(-16.5,0.5) U2(-15.5,0.5) U3(-14.5,0.5) U4(-13.5,0.5) U5(-12.5,0.5) U6(-11.5,0.5) U7(-10.5,0.5) U8(-9.5,0.5) U9(-8.5,0.5) U10(-7.5,0.5) U11(-6.5,0.5) U12(-5.5,0.5) U13(-4.5,0.5) U14(-3.5,0.5) U15(-2.5,0.5) U16(-1.5,0.5) U17(-0.5,0.5) U18(0.5,0.5) U19(1.5,0.5) U20(2.5,0.5) U21(3.5,0.5) U22(4.5,0.5) U23(5.5,0.5) U24(6.5,0.5) U25(7.5,0.5) U26(8.5,0.5) U27(9.5,0.5) U28(10.5,0.5) U29(11.5,0.5) U30(12.5,0.5) U31(13.5,0.5) U32(14.5,0.5) U33(15.5,0.5) U34(16.5,0.5) V1(-16.5,-0.5) V2(-15.5,-0.5) V3(-14.5,-0.5) V4(-13.5,-0.5) V5(-12.5,-0.5) V6(-11.5,-0.5) V7(-10.5,-0.5) V8(-9.5,-0.5) V9(-8.5,-0.5) V10(-7.5,-0.5) V11(-6.5,-0.5) V12(-5.5,-0.5) V13(-4.5,-0.5) V14(-3.5,-0.5) V15(-2.5,-0.5) V16(-1.5,-0.5) V17(-0.5,-0.5) V18(0.5,-0.5) V19(1.5,-0.5) V20(2.5,-0.5) V21(3.5,-0.5) V22(4.5,-0.5) V23(5.5,-0.5) V24(6.5,-0.5) V25(7.5,-0.5) V26(8.5,-0.5) V27(9.5,-0.5) V28(10.5,-0.5) V29(11.5,-0.5) V30(12.5,-0.5) V31(13.5,-0.5) V32(14.5,-0.5) V33(15.5,-0.5) V34(16.5,-0.5) W1(-16.5,-1.5) W2(-15.5,-1.5) W3(-14.5,-1.5) W4(-13.5,-1.5) W5(-12.5,-1.5) W6(-11.5,-1.5) W7(-10.5,-1.5) W8(-9.5,-1.5) W9(-8.5,-1.5) W10(-7.5,-1.5) W11(-6.5,-1.5) W12(-5.5,-1.5) W13(-4.5,-1.5) W14(-3.5,-1.5) W15(-2.5,-1.5) W16(-1.5,-1.5) W17(-0.5,-1.5) W18(0.5,-1.5) W19(1.5,-1.5) W20(2.5,-1.5) W21(3.5,-1.5) W22(4.5,-1.5) W23(5.5,-1.5) W24(6.5,-1.5) W25(7.5,-1.5) W26(8.5,-1.5) W27(9.5,-1.5) W28(10.5,-1.5) W29(11.5,-1.5) W30(12.5,-1.5) W31(13.5,-1.5) W32(14.5,-1.5) W33(15.5,-1.5) W34(16.5,-1.5) Y1(-16.5,-2.5) Y2(-15.5,-2.5) Y3(-14.5,-2.5) Y4(-13.5,-2.5) Y5(-12.5,-2.5) Y6(-11.5,-2.5) Y7(-10.5,-2.5) Y8(-9.5,-2.5) Y9(-8.5,-2.5) Y10(-7.5,-2.5) Y11(-6.5,-2.5) Y12(-5.5,-2.5) Y13(-4.5,-2.5) Y14(-3.5,-2.5) Y15(-2.5,-2.5) Y16(-1.5,-2.5) Y17(-0.5,-2.5) Y18(0.5,-2.5) Y19(1.5,-2.5) Y20(2.5,-2.5) Y21(3.5,-2.5) Y22(4.5,-2.5) Y23(5.5,-2.5) Y24(6.5,-2.5) Y25(7.5,-2.5) Y26(8.5,-2.5) Y27(9.5,-2.5) Y28(10.5,-2.5) Y29(11.5,-2.5) Y30(12.5,-2.5) Y31(13.5,-2.5) Y32(14.5,-2.5) Y33(15.5,-2.5) Y34(16.5,-2.5)
C0402
  rect 0.457x0.508 smd: 1(-0.4,0) 2(0.4,0)
C0402_P1
  custom 0.145x0.145 smd: 1(-0.48,0) 2(0.48,0)
C0603
  rect 0.813x0.711 smd: 1(-0.737,0) 2(0.737,0)
C0805
  rect 1.118x1.372 smd: 1(-0.95,0) 2(0.95,0)
C1206
  rect 1.168x1.575 smd: 1(-1.473,0) 2(1.473,0)
DELTAL_COUPON_7P
  round 0.66 smd: 1(-0.504,1.301) 2(0.497,1.301)
  round 1.143 hole 1.041: 3(-1.274,-2.498) 4(1.266,-2.498) 5(-1.274,3.852) 6(1.266,3.852)
  custom 0.743x0.743 smd: 7(-0.009,-0.37)
  round 0.508 hole 0.406: 8(-1.27,0.457) 9(-1.27,-0.762) 10(-0.025,-0.762) 11(1.27,-0.762) 12(1.27,0.457)
EC_F80_H8
  oval 3.302x1.397 smd: 1(-2.464,0) 2(2.464,0)
GF_PCIE_X16
  rect 0.762x3.2 smd: A1(-11.5,-3.42) B81(70.5,-3.42)
  rect 0.762x4.216 smd: A2(-10.5,-3.92) A3(-9.5,-3.92) A4(-8.5,-3.92) A5(-7.5,-3.92) A6(-6.5,-3.92) A7(-5.5,-3.92) A8(-4.5,-3.92) A9(-3.5,-3.92) A10(-2.5,-3.92) A11(-1.5,-3.92) A12(1.5,-3.92) A13(2.5,-3.92) A14(3.5,-3.92) A15(4.5,-3.92) A16(5.5,-3.92) A17(6.5,-3.92) A18(7.5,-3.92) A19(8.5,-3.92) A20(9.5,-3.92) A21(10.5,-3.92) A22(11.5,-3.92) A23(12.5,-3.92) A24(13.5,-3.92) A25(14.5,-3.92) A26(15.5,-3.92) A27(16.5,-3.92) A28(17.5,-3.92) A29(18.5,-3.92) A30(19.5,-3.92) A31(20.5,-3.92) A32(21.5,-3.92) A33(22.5,-3.92) A34(23.5,-3.92) A35(24.5,-3.92) A36(25.5,-3.92) A37(26.5,-3.92) A38(27.5,-3.92) A39(28.5,-3.92) A40(29.5,-3.92) A41(30.5,-3.92) A42(31.5,-3.92) A43(32.5,-3.92) A44(33.5,-3.92) A45(34.5,-3.92) A46(35.5,-3.92) A47(36.5,-3.92) A48(37.5,-3.92) A49(38.5,-3.92) A50(39.5,-3.92) A51(40.5,-3.92) A52(41.5,-3.92) A53(42.5,-3.92) A54(43.5,-3.92) A55(44.5,-3.92) A56(45.5,-3.92) A57(46.5,-3.92) A58(47.5,-3.92) A59(48.5,-3.92) A60(49.5,-3.92) A61(50.5,-3.92) A62(51.5,-3.92) A63(52.5,-3.92) A64(53.5,-3.92) A65(54.5,-3.92) A66(55.5,-3.92) A67(56.5,-3.92) A68(57.5,-3.92) A69(58.5,-3.92) A70(59.5,-3.92) A71(60.5,-3.92) A72(61.5,-3.92) A73(62.5,-3.92) A74(63.5,-3.92) A75(64.5,-3.92) A76(65.5,-3.92) A77(66.5,-3.92) A78(67.5,-3.92) A79(68.5,-3.92) A80(69.5,-3.92) A81(70.5,-3.92) A82(71.5,-3.92) B1(-11.5,-3.92) B2(-10.5,-3.92) B3(-9.5,-3.92) B4(-8.5,-3.92) B5(-7.5,-3.92) B6(-6.5,-3.92) B7(-5.5,-3.92) B8(-4.5,-3.92) B9(-3.5,-3.92) B10(-2.5,-3.92) B11(-1.5,-3.92) B12(1.5,-3.92) B13(2.5,-3.92) B14(3.5,-3.92) B15(4.5,-3.92) B16(5.5,-3.92) B17(6.5,-3.92) B18(7.5,-3.92) B19(8.5,-3.92) B20(9.5,-3.92) B21(10.5,-3.92) B22(11.5,-3.92) B23(12.5,-3.92) B24(13.5,-3.92) B25(14.5,-3.92) B26(15.5,-3.92) B27(16.5,-3.92) B28(17.5,-3.92) B29(18.5,-3.92) B30(19.5,-3.92) B31(20.5,-3.92) B32(21.5,-3.92) B33(22.5,-3.92) B34(23.5,-3.92) B35(24.5,-3.92) B36(25.5,-3.92) B37(26.5,-3.92) B38(27.5,-3.92) B39(28.5,-3.92) B40(29.5,-3.92) B41(30.5,-3.92) B42(31.5,-3.92) B43(32.5,-3.92) B44(33.5,-3.92) B45(34.5,-3.92) B46(35.5,-3.92) B47(36.5,-3.92) B48(37.5,-3.92) B49(38.5,-3.92) B50(39.5,-3.92) B51(40.5,-3.92) B52(41.5,-3.92) B53(42.5,-3.92) B54(43.5,-3.92) B55(44.5,-3.92) B56(45.5,-3.92) B57(46.5,-3.92) B58(47.5,-3.92) B59(48.5,-3.92) B60(49.5,-3.92) B61(50.5,-3.92) B62(51.5,-3.92) B63(52.5,-3.92) B64(53.5,-3.92) B65(54.5,-3.92) B66(55.5,-3.92) B67(56.5,-3.92) B68(57.5,-3.92) B69(58.5,-3.92) B70(59.5,-3.92) B71(60.5,-3.92) B72(61.5,-3.92) B73(62.5,-3.92) B74(63.5,-3.92) B75(64.5,-3.92) B76(65.5,-3.92) B77(66.5,-3.92) B78(67.5,-3.92) B79(68.5,-3.92) B80(69.5,-3.92) B82(71.5,-3.92)
GND_C10D4_6-5B10_OB5
  round 4.013 hole 4.013 unplated: (0,0)
  round 0.762 hole 0.559: 2(-3.5,0) 3(-2.475,2.475) 4(0,3.5) 5(2.475,2.475) 6(3.5,0)
HEADER1X4S2NH_P2H2_RA
  round 1.194 hole 1.194 unplated: (-2,-0.013) (2,-0.013)
  rect 1.041x2.032 smd: 1(-3,-3.188) 2(-1,-3.188) 3(1,-3.188) 4(3,-3.188)
HEATSINK_4P_SF41720001
  round 4.674 hole 4.42: MG1(0,0) MG2(107.6,0) MG3(0,-63) MG4(107.6,-63)
HOLE_C10D5-6B10_NPB_STANDOFF
  round 10.008 hole 5.613: 1(0,0)
IND_PA4390_SMPM91X130_4P
  rect 3.302x3.023 smd: 1A(-3.85,0) 2A(3.85,0)
  rect 0.254x0.508 smd: 1B(-2.327,0) 2B(2.327,0)
IND_PCMB053T
  rect 2.007x2.515 smd: 1(-2.5,0) 2(2.5,0)
IND_PCMB104T
  rect 4.115x4.115 smd: 1(-4.75,0) 2(4.75,0)
IND_PCMC063T
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
LED0603
  rect 0.813x0.813 smd: A(-0.75,0) C(0.75,0)
MSOP8_P0-65H1-1
  rect 1.6x0.305 smd: 1(-2,0.975) 2(-2,0.325) 3(-2,-0.325) 4(-2,-0.975) 5(2,-0.975) 6(2,-0.325) 7(2,0.325) 8(2,0.975)
MSOP10_P0-5W4-4_3X3
  rect 1.422x0.279 smd: 1(-2.2,1) 2(-2.2,0.5) 3(-2.2,0) 4(-2.2,-0.5) 5(-2.2,-1) 6(2.2,-1) 7(2.2,-0.5) 8(2.2,0) 9(2.2,0.5) 10(2.2,1)
PCIE_X16D_H11
  round 2.413 hole 2.413 unplated: (-1.25,-11.65) (-1.25,-84.8)
  rect 1.194x1.194 hole 0.711: A1(0,0)
  round 1.194 hole 0.711: A2(2,-1) A3(0,-2) A4(2,-3) A5(0,-4) A6(2,-5) A7(0,-6) A8(2,-7) A9(0,-8) A10(2,-9) A11(0,-10) A12(2,-13) A13(0,-14) A14(2,-15) A15(0,-16) A16(2,-17) A17(0,-18) A18(2,-19) A19(0,-20) A20(2,-21) A21(0,-22) A22(2,-23) A23(0,-24) A24(2,-25) A25(0,-26) A26(2,-27) A27(0,-28) A28(2,-29) A29(0,-30) A30(2,-31) A31(0,-32) A32(2,-33) A33(0,-34) A34(2,-35) A35(0,-36) A36(2,-37) A37(0,-38) A38(2,-39) A39(0,-40) A40(2,-41) A41(0,-42) A42(2,-43) A43(0,-44) A44(2,-45) A45(0,-46) A46(2,-47) A47(0,-48) A48(2,-49) A49(0,-50) A50(2,-51) A51(0,-52) A52(2,-53) A53(0,-54) A54(2,-55) A55(0,-56) A56(2,-57) A57(0,-58) A58(2,-59) A59(0,-60) A60(2,-61) A61(0,-62) A62(2,-63) A63(0,-64) A64(2,-65) A65(0,-66) A66(2,-67) A67(0,-68) A68(2,-69) A69(0,-70) A70(2,-71) A71(0,-72) A72(2,-73) A73(0,-74) A74(2,-75) A75(0,-76) A76(2,-77) A77(0,-78) A78(2,-79) A79(0,-80) A80(2,-81) A81(0,-82) A82(2,-83) B1(-2.5,0) B2(-4.5,-1) B3(-2.5,-2) B4(-4.5,-3) B5(-2.5,-4) B6(-4.5,-5) B7(-2.5,-6) B8(-4.5,-7) B9(-2.5,-8) B10(-4.5,-9) B11(-2.5,-10) B12(-4.5,-13) B13(-2.5,-14) B14(-4.5,-15) B15(-2.5,-16) B16(-4.5,-17) B17(-2.5,-18) B18(-4.5,-19) B19(-2.5,-20) B20(-4.5,-21) B21(-2.5,-22) B22(-4.5,-23) B23(-2.5,-24) B24(-4.5,-25) B25(-2.5,-26) B26(-4.5,-27) B27(-2.5,-28) B28(-4.5,-29) B29(-2.5,-30) B30(-4.5,-31) B31(-2.5,-32) B32(-4.5,-33) B33(-2.5,-34) B34(-4.5,-35) B35(-2.5,-36) B36(-4.5,-37) B37(-2.5,-38) B38(-4.5,-39) B39(-2.5,-40) B40(-4.5,-41) B41(-2.5,-42) B42(-4.5,-43) B43(-2.5,-44) B44(-4.5,-45) B45(-2.5,-46) B46(-4.5,-47) B47(-2.5,-48) B48(-4.5,-49) B49(-2.5,-50) B50(-4.5,-51) B51(-2.5,-52) B52(-4.5,-53) B53(-2.5,-54) B54(-4.5,-55) B55(-2.5,-56) B56(-4.5,-57) B57(-2.5,-58) B58(-4.5,-59) B59(-2.5,-60) B60(-4.5,-61) B61(-2.5,-62) B62(-4.5,-63) B63(-2.5,-64) B64(-4.5,-65) B65(-2.5,-66) B66(-4.5,-67) B67(-2.5,-68) B68(-4.5,-69) B69(-2.5,-70) B70(-4.5,-71) B71(-2.5,-72) B72(-4.5,-73) B73(-2.5,-74) B74(-4.5,-75) B75(-2.5,-76) B76(-4.5,-77) B77(-2.5,-78) B78(-4.5,-79) B79(-2.5,-80) B80(-4.5,-81) B81(-2.5,-82) B82(-4.5,-83)
PQFN16_IR3823
  rect 0.305x0.66 smd: 1(0.45,-1.75) 2(0.95,-1.75) 3(1.45,-1.75) 4(1.95,-1.75) 5(2.45,-1.75) 6(2.95,-1.75)
  rect 0.66x0.305 smd: 7(3.4,-1) 8(3.4,-0.5) 9(3.4,0) 13(0,0) 14(0,-0.5) 15(0,-1)
  rect 0.787x1.067 smd: 10(3.39,0.95)
  rect 1.524x1.626 smd: 11(1.895,1.23)
  rect 1.321x1.626 smd: 12(0.26,1.23)
  rect 2.438x1.422 smd: 16(1.7,-0.5)
PQFN17_IR3895
  rect 0.305x0.711 smd: 1(-1.95,-3.15) 2(-1.3,-3.15) 3(-0.65,-3.15) 4(0,-3.15) 5(0.65,-3.15) 6(1.3,-3.15) 7(1.95,-3.15)
  rect 0.711x0.305 smd: 8(2.45,-2.32) 9(2.45,-1.67) 10(2.45,-1.02) 14(-2.45,-1.02) 15(-2.45,-1.67) 16(-2.45,-2.32)
  custom 0.263x0.263 smd: 11(2.5,1.16)
  custom 0.533x0.533 smd: 12(0.28,2.76)
  custom 0.405x0.405 smd: 13(-2.5,1.16)
  rect 2.692x1.549 smd: 17(0,-1.66)
PWR2X6D2NH_P3W3H8-9_RA
  round 3.023 hole 3.023 unplated: (-12.85,-4.32) (-2.15,-4.32)
  rect 1.549x1.549 hole 1.041: 1(0,0)
  round 1.549 hole 1.041: 2(-3,0) 3(-6,0) 4(-9,0) 5(-12,0) 6(-15,0) 7(0,3) 8(-3,3) 9(-6,3) 10(-9,3) 11(-12,3) 12(-15,3)
QFN28_P0-5_EPAD
  rect 0.864x0.305 smd: 1(-2.45,1.5) 2(-2.45,1) 3(-2.45,0.5) 4(-2.45,0) 5(-2.45,-0.5) 6(-2.45,-1) 7(-2.45,-1.5) 15(2.45,-1.5) 16(2.45,-1) 17(2.45,-0.5) 18(2.45,0) 19(2.45,0.5) 20(2.45,1) 21(2.45,1.5)
  rect 0.305x0.864 smd: 8(-1.5,-2.45) 9(-1,-2.45) 10(-0.5,-2.45) 11(0,-2.45) 12(0.5,-2.45) 13(1,-2.45) 14(1.5,-2.45) 22(1.5,2.45) 23(1,2.45) 24(0.5,2.45) 25(0,2.45) 26(-0.5,2.45) 27(-1,2.45) 28(-1.5,2.45)
  rect 3.302x3.302 smd: 29(0,0)
QFN40_NCP5339
  rect 0.635x0.254 smd: 1(-2.835,2.25) 2(-2.835,1.75) 3(-2.835,1.25) 4(-2.835,0.75) 5(-2.835,0.25) 6(-2.835,-0.25) 7(-2.835,-0.75) 8(-2.835,-1.25) 9(-2.835,-1.75) 10(-2.835,-2.25) 21(2.835,-2.25) 22(2.835,-1.75) 23(2.835,-1.25) 24(2.835,-0.75) 25(2.835,-0.25) 26(2.835,0.25) 27(2.835,0.75) 28(2.835,1.25) 29(2.835,1.75) 30(2.835,2.25)
  rect 0.254x0.635 smd: 11(-2.25,-2.835) 12(-1.75,-2.835) 13(-1.25,-2.835) 14(-0.75,-2.835) 15(-0.25,-2.835) 16(0.25,-2.835) 17(0.75,-2.835) 18(1.25,-2.835) 19(1.75,-2.835) 20(2.25,-2.835) 31(2.25,2.835) 32(1.75,2.835) 33(1.25,2.835) 34(0.75,2.835) 35(0.25,2.835) 36(-0.25,2.835) 37(-0.75,2.835) 38(-1.25,2.835) 39(-1.75,2.835) 40(-2.25,2.835)
  rect 1.676x2.184 smd: 41(-1.45,1.2) 42(-1.45,-1.2)
  rect 2.565x4.572 smd: 43(1,0)
R0402
  rect 0.457x0.508 smd: 1(-0.4,0) 2(0.4,0)
R0603
  rect 0.813x0.711 smd: 1(-0.737,0) 2(0.737,0)
R0805
  rect 1.118x1.372 smd: 1(-0.95,0) 2(0.95,0)
SC70-5XA
  rect 0.508x0.406 smd: 1(-0.95,0.65) 2(-0.95,0) 3(-0.95,-0.65) 4(0.95,-0.65) 5(0.95,0.65)
SC70-5XB
  rect 0.914x0.406 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0.65)
SHORT0603
  custom 0.178x0.178 smd: 1(-0.749,0)
  rect 0.813x0.711 smd: 2(0.749,0)
SHORT0805
  custom 0.343x0.343 smd: 1(-0.94,0)
  rect 1.118x1.372 smd: 2(0.94,0)
SLIVER_X8_RA
  round 1.118 hole 1.118 unplated: (-8.425,0.965) (8.375,2.965)
  rect 0.356x1.422 smd: 1(-7.225,5.115) 2(-6.625,5.115) 3(-6.025,5.115) 4(-5.425,5.115) 5(-4.825,5.115) 6(-4.225,5.115) 7(-3.625,5.115) 8(-3.025,5.115) 9(-2.425,5.115) 10(-1.825,5.115) 11(-1.225,5.115) 12(-0.625,5.115) 13(-0.025,5.115) 14(0.575,5.115) 15(1.175,5.115) 16(1.775,5.115) 17(2.375,5.115) 18(2.975,5.115) 19(3.575,5.115) 20(4.175,5.115) 21(4.775,5.115) 22(5.375,5.115) 23(5.975,5.115) 24(6.575,5.115) 25(7.175,5.115) 26(7.175,8.065) 27(6.575,8.065) 28(5.975,8.065) 29(5.375,8.065) 30(4.775,8.065) 31(4.175,8.065) 32(3.575,8.065) 33(2.975,8.065) 34(2.375,8.065) 35(1.775,8.065) 36(1.175,8.065) 37(0.575,8.065) 38(-0.025,8.065) 39(-0.625,8.065) 40(-1.225,8.065) 41(-1.825,8.065) 42(-2.425,8.065) 43(-3.025,8.065) 44(-3.625,8.065) 45(-4.225,8.065) 46(-4.825,8.065) 47(-5.425,8.065) 48(-6.025,8.065) 49(-6.625,8.065) 50(-7.225,8.065)
  round 1.626 hole 1.118: G1(-9.775,4.565) G4(9.725,-0.585)
  round 1.016 hole 0.61: G2(-9.775,1.411) G3(9.725,2.565)
SOIC8
  rect 1.727x0.559 smd: 1(-2.642,1.905) 2(-2.642,0.635) 3(-2.642,-0.635) 4(-2.642,-1.905) 5(2.642,-1.905) 6(2.642,-0.635) 7(2.642,0.635) 8(2.642,1.905)
SON6E_D65_D8
  rect 0.305x0.711 smd: 1(-0.65,-1.05) 2(0,-1.05) 3(0.65,-1.05) 4(0.65,1.05) 5(0,1.05) 6(-0.65,1.05)
  rect 1.727x1.016 smd: 7(0,0)
SOT23
  rect 0.914x0.813 smd: 1(-1,0.95) 2(-1,-0.95) 3(1,0)
SOT23_GDS
  rect 1.422x1.016 smd: D(1.1,0) G(-1.1,0.95) S(-1.1,-0.95)
SOT363
  rect 0.61x0.432 smd: 1(-0.95,0.65) 2(-0.95,0) 3(-0.95,-0.65) 4(0.95,-0.65) 5(0.95,0) 6(0.95,0.65)
TAJ_SX
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
TSSOP8_D65_1D2
  rect 0.457x1.93 smd: 1(-0.975,-2.108) 2(-0.325,-2.108) 3(0.325,-2.108) 4(0.975,-2.108) 5(0.975,2.108) 6(0.325,2.108) 7(-0.325,2.108) 8(-0.975,2.108)
TSSOP24_P0-65W5-6H1-2
  rect 1.6x0.305 smd: 1(-2.8,3.575) 2(-2.8,2.925) 3(-2.8,2.275) 4(-2.8,1.625) 5(-2.8,0.975) 6(-2.8,0.325) 7(-2.8,-0.325) 8(-2.8,-0.975) 9(-2.8,-1.625) 10(-2.8,-2.275) 11(-2.8,-2.925) 12(-2.8,-3.575) 13(2.8,-3.575) 14(2.8,-2.925) 15(2.8,-2.275) 16(2.8,-1.625) 17(2.8,-0.975) 18(2.8,-0.325) 19(2.8,0.325) 20(2.8,0.975) 21(2.8,1.625) 22(2.8,2.275) 23(2.8,2.925) 24(2.8,3.575)
unnamed#2
  round 0.991 smd: 1(0,0)
VFQFPN40_P0-4_EPAD
  custom 0.044x0.044 smd: 1(-2.45,1.8) 2(-2.45,1.4) 3(-2.45,1) 4(-2.45,0.6) 5(-2.45,0.2) 6(-2.45,-0.2) 7(-2.45,-0.6) 8(-2.45,-1) 9(-2.45,-1.4) 10(-2.45,-1.8) 11(-1.8,-2.45) 12(-1.4,-2.45) 13(-1,-2.45) 14(-0.6,-2.45) 15(-0.2,-2.45) 16(0.2,-2.45) 17(0.6,-2.45) 18(1,-2.45) 19(1.4,-2.45) 20(1.8,-2.45) 21(2.45,-1.8) 22(2.45,-1.4) 23(2.45,-1) 24(2.45,-0.6) 25(2.45,-0.2) 26(2.45,0.2) 27(2.45,0.6) 28(2.45,1) 29(2.45,1.4) 30(2.45,1.8) 31(1.8,2.45) 32(1.4,2.45) 33(1,2.45) 34(0.6,2.45) 35(0.2,2.45) 36(-0.2,2.45) 37(-0.6,2.45) 38(-1,2.45) 39(-1.4,2.45) 40(-1.8,2.45)
  rect 3.607x3.607 smd: 41(0,0)
WDFN6_P0-65H0-8_EP
  rect 0.406x0.457 smd: 1(-0.65,-0.925) 2(0,-0.925) 3(0.65,-0.925) 4(0.65,0.925) 5(0,0.925) 6(-0.65,0.925)
  rect 1.727x0.965 smd: EP(0,0)

## Nets
