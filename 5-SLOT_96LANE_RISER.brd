# Allegro board 5-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT4_TX_C_DN<14>: length 123.8
  BOTTOM w0.089: U1.A26 97.52,89.63 97.42,89.73 97.42,89.81 97.66,90.04 99.44,90.04 99.5,89.99 99.52,89.99
  BOTTOM w0.135: C149.1 217.64,84.68 216.67,84.68 214.99,85.17 214.59,85.17 214.44,85.01 214.03,85.01 213.88,85.17 213.48,85.17 213.32,85.01 212.92,85.01 212.77,85.17 202.68,85.17 v3(196.42,86.27) 194.22,86.66 192.55,86.95 182.45,85.17 179.59,84.6 176.53,85.21 173.35,84.58 169.76,85.3 167.02,84.75 164.26,85.3 160.46,84.54 160.36,84.54 148.9,86.56 147.2,86.26 141.99,85.34 125.66,88.22 123.87,89.51 118.5,90.46 116.31,90.07 114.17,90.45 112.19,90.1 110.78,90.35 109.55,90.13 108.39,90.33 107.12,90.11 105.82,90.34 104.04,90.03 102.51,90.3 100.75,89.99 100.75,89.99 99.52,89.99
PE_SLOT4_TX_C_DN<15>: length 118.7
  BOTTOM w0.089: 99.52,88.7 99.5,88.7 99.44,88.76 98.96,88.76 98.69,89.03 97.64,89.03 97.42,88.81 97.42,88.71 97.5,88.63 U1.A25
  BOTTOM w0.135: C150.1 208.49,83.29 v3(207.43,83.29) 206.42,83.29 204.94,83.55 204.76,83.42 204.37,83.49 204.24,83.67 203.85,83.74 203.67,83.62 203.27,83.69 203.15,83.86 198.8,84.63 196.06,85.11 195.18,84.96 195.07,84.8 195.22,83.95 194.96,83.59 194.1,83.44 193.73,83.69 193.58,84.54 193.43,84.65 192.81,84.54 192.7,84.38 192.85,83.54 192.6,83.17 191.73,83.02 191.37,83.27 191.22,84.12 191.06,84.23 188.74,83.82 185.68,83.28 182.45,83.95 179.56,83.37 176.53,83.97 173.23,83.31 170.2,83.92 167.11,83.37 164,83.92 160.48,83.3 148.9,85.34 141.88,84.1 125.02,87.09 124.14,87.7 120.53,88.34 119.4,88.14 117.86,88.41 116.1,88.1 113.34,88.59 110.61,88.11 108.57,88.47 106.96,88.18 105.19,88.5 103.61,88.22 100.85,88.7 100.1,88.7 100.08,88.7 100.05,88.7 99.52,88.7
PE_SLOT4_TX_C_DP<0>: length 210.2
  IN1 w0.089: v4(82.36,97.13) 82.36,97.45 82.28,97.54 81.78,97.54 81.5,97.81 81.5,98.2 81.45,98.25 81.45,98.27
  IN1 w0.122: v1(279.48,86.61) 279.07,87.02 279.07,87.57 278.8,87.96 277.23,89.16 277.16,89.19 262.49,91.78 259.31,91.22 252.95,92.34 251.12,92.02 249.28,92.34 247.19,91.97 245.65,92.24 243.02,91.78 240.68,92.19 237.5,91.63 235.1,92.05 232.82,91.65 230.79,92.01 229.02,91.7 226.99,92.06 226.11,91.9 224.9,91.69 222.83,92.05 220.83,91.66 218.66,92.05 216.12,91.6 213.7,92.03 211.85,91.7 209.31,92.15 206.02,91.57 203.53,92.01 203.5,92 200.84,91.53 200.84,91.54 139.83,102.3 133.48,101.18 97.86,107.46 89.07,105.91 83.36,101.91 81.45,99.18 81.45,98.27
  BOTTOM w0.135: v1(279.48,86.61) 279.12,86.26 279.12,85.46 C47.1 ; U1.U33 v4(82.36,97.13)
PE_SLOT4_TX_C_DP<1>: length 208.3
  IN1 w0.089: v4(83.36,97.13) 83.36,97.45 83.28,97.54 83.01,97.54 82.77,97.77 82.77,98.52 82.87,99.1 83.05,99.35 83.04,99.42 83.05,99.44
  IN1 w0.122: 83.05,99.44 84.73,101.84 88.43,104.43 89.97,104.7 90.07,104.84 90.05,104.96 90.28,105.3 90.9,105.41 91.24,105.17 91.26,105.05 91.41,104.95 91.79,105.02 91.89,105.16 91.84,105.39 91.96,105.56 91.96,105.56 92.08,105.72 92.7,105.83 93.04,105.59 93.08,105.37 93.22,105.27 93.6,105.34 93.7,105.48 93.66,105.71 93.78,105.88 93.89,106.04 94.51,106.15 94.86,105.91 94.9,105.69 95.04,105.59 95.42,105.66 95.52,105.8 95.48,106.05 95.59,106.22 95.59,106.22 95.71,106.39 96.33,106.5 96.67,106.26 96.72,106.01 96.86,105.91 97.24,105.98 97.34,106.12 97.32,106.24 97.55,106.58 98.17,106.69 98.51,106.45 98.53,106.33 98.67,106.23 99.89,106.45 133.58,100.51 139.72,101.59 148.84,99.98 148.84,99.98 148.9,99.97 200.69,90.84 203.31,91.3 203.51,91.3 203.56,91.3 205.9,90.89 209.33,91.49 211.85,91.05 213.68,91.37 216.16,90.93 218.72,91.38 220.83,91.01 222.94,91.38 224.95,91.03 227.04,91.4 229.07,91.04 230.74,91.33 232.77,90.97 235.05,91.37 237.44,90.95 240.73,91.53 243.02,91.13 245.58,91.58 247.18,91.3 249.21,91.65 251.22,91.3 252.99,91.61 259.35,90.49 262.11,90.98 264.25,90.6 274.21,88.84 275.05,88.4 275.92,87.54 275.92,87.53 275.92,87.02 v1(276.33,86.61)
  BOTTOM w0.135: C48.1 275.97,85.46 275.97,86.26 v1(276.33,86.61) ; U1.T33 v4(83.36,97.13)
PE_SLOT4_TX_C_DP<2>: length 199.4
  IN1 w0.089: 84.16,99.44 84.15,99.42 84.16,99.35 83.82,98.86 83.76,98.52 83.76,97.74 83.96,97.54 84.28,97.54 84.36,97.45 v4(84.36,97.13)
  IN1 w0.122: v1(272.34,86.61) 271.96,87 271.96,87.43 271.88,87.88 271.64,88.21 271.16,88.56 262.07,90.16 259.78,89.76 253.11,90.93 251.31,90.61 249.18,90.99 247.19,90.64 245.57,90.92 243.02,90.47 240.78,90.87 237.46,90.28 235.08,90.7 232.8,90.3 230.81,90.65 229.18,90.37 227.13,90.73 224.99,90.35 222.89,90.72 220.83,90.36 218.72,90.73 216.03,90.25 213.54,90.69 211.78,90.38 209.37,90.81 205.7,90.16 203.33,90.58 200.89,90.14 148.9,99.3 139.68,100.93 133.58,99.85 100.05,105.76 89.22,103.86 85.36,101.15 84.16,99.44
  BOTTOM w0.135: C49.1 271.98,85.46 271.98,86.26 v1(272.34,86.61) ; U1.R33 v4(84.36,97.13)
PE_SLOT4_TX_C_DP<3>: length 197.6
  IN1 w0.089: 85.13,99.28 85.12,99.26 85.13,99.19 84.84,98.77 84.77,98.42 84.77,97.74 84.97,97.54 85.28,97.54 85.36,97.45 v4(85.36,97.13)
  IN1 w0.122: 85.13,99.28 85.25,99.44 86.23,100.85 89.41,103.08 100.28,104.99 133.35,99.16 139.68,100.28 148.93,98.65 148.93,98.64 200.92,89.48 203.21,89.88 205.54,89.47 209.25,90.12 211.69,89.69 213.6,90.03 216.03,89.6 218.72,90.08 221.02,89.67 223.08,90.03 225.05,89.69 227.03,90.03 229.02,89.68 230.78,89.99 232.91,89.62 235.22,90.03 237.54,89.62 240.86,90.2 243.02,89.82 245.5,90.26 247.17,89.97 249.13,90.31 251.22,89.94 253.11,90.28 260.06,89.05 261.79,89.36 262.99,89.15 263.23,88.81 263.09,88.04 263.19,87.9 263.57,87.83 263.71,87.93 263.85,88.7 264.19,88.94 264.81,88.83 265.05,88.49 264.91,87.72 265.01,87.58 265.39,87.51 265.53,87.61 265.67,88.38 266.01,88.62 266.96,88.45 267.74,87.9 268.01,87.52 268.01,86.98 v1(268.38,86.61)
  BOTTOM w0.135: C50.1 268.02,85.46 268.02,86.26 v1(268.38,86.61) ; U1.P33 v4(85.36,97.13)
PE_SLOT4_TX_C_DP<4>: length 185.4
  IN1 w0.089: 87.01,99.43 87,99.41 87.01,99.34 86.9,99.18 86.78,98.5 86.78,97.74 86.98,97.54 87.28,97.54 87.36,97.45 v4(87.36,97.13)
  IN1 w0.122: v1(262.33,86.61) 261.95,87 261.95,87.5 261.59,88.02 253.04,89.61 251.15,89.28 249.08,89.64 247.19,89.31 245.57,89.6 242.96,89.14 240.8,89.52 237.55,88.94 235.23,89.35 232.94,88.95 230.87,89.31 229.12,89 227.11,89.36 225.14,89.01 223.24,89.35 221.13,88.98 218.66,89.41 216.03,88.95 213.6,89.38 211.61,89.03 211.61,89.03 209.47,89.4 205.64,88.73 203.26,89.15 201.15,88.78 139.69,99.62 133.15,98.47 100.74,104.19 90.15,102.32 88.95,101.48 87.96,100.79 87.01,99.43
  BOTTOM w0.135: v1(262.33,86.61) 261.98,86.26 261.98,85.46 C127.1 ; U1.M33 v4(87.36,97.13)
PE_SLOT4_TX_C_DP<5>: length 183.1
  IN1 w0.089: 88.21,99.44 88.2,99.42 88.21,99.35 87.82,98.8 87.77,98.52 87.77,97.76 88,97.54 88.28,97.54 88.36,97.45 v4(88.36,97.13)
  IN1 w0.122: v1(258.35,86.61) 257.96,87 257.96,87.44 257.94,87.6 257.79,87.83 257.36,88.13 256.74,88.24 256.4,88.01 256.14,86.55 256,86.45 255.62,86.52 255.52,86.66 255.78,88.12 255.54,88.45 252.86,88.93 251.05,88.61 249.07,88.96 247.22,88.63 245.52,88.93 242.96,88.48 240.8,88.86 237.55,88.29 235.23,88.7 232.95,88.3 230.94,88.65 229.18,88.34 227.11,88.71 225.14,88.36 223.24,88.7 221.13,88.32 218.69,88.75 216.06,88.29 213.6,88.72 211.59,88.37 209.62,88.72 207.63,88.37 205.69,88.02 203.21,88.46 201.23,88.11 139.66,98.96 132.83,97.76 100.91,103.39 90.93,101.63 88.83,100.16 88.43,99.76 88.21,99.44
  BOTTOM w0.135: U1.L33 v4(88.36,97.13) ; C128.1 257.99,85.46 257.99,86.26 v1(258.35,86.61)
PE_SLOT4_TX_C_DP<6>: length 174.5
  IN1 w0.089: 89.26,99.44 89.24,99.43 89.23,99.36 89.03,99.21 88.84,98.95 88.76,98.5 88.76,97.74 88.96,97.54 89.28,97.54 89.36,97.45 v4(89.36,97.13)
  IN1 w0.122: 89.26,99.44 91.26,100.84 101.45,102.64 132.83,97.11 139.66,98.31 148.95,96.67 148.95,96.67 201.27,87.45 203.08,87.77 205.69,87.3 209.7,88.01 211.61,87.67 213.67,88.04 215.99,87.63 218.65,88.09 221.09,87.66 223.24,88.04 225.14,87.71 227.11,88.05 229.36,87.66 231.11,87.97 232.95,87.64 235.16,88.03 237.48,87.62 240.79,88.21 242.94,87.83 245.52,88.28 247.23,87.98 249.06,88.3 251.51,87.87 253.19,88.17 253.51,88.11 253.74,87.95 253.89,87.73 253.97,87.3 253.97,86.98 v1(254.33,86.61)
  BOTTOM w0.135: U1.K33 v4(89.36,97.13) ; C129.1 253.98,85.46 253.98,86.26 v1(254.33,86.61)
PE_SLOT4_TX_C_DP<7>: length 172.7
  IN1 w0.089: 90.39,99.4 90.37,99.39 90.35,99.32 90.08,99.13 89.75,98.66 89.75,97.74 89.95,97.54 90.28,97.54 90.36,97.45 v4(90.36,97.13)
  IN1 w0.122: 90.39,99.4 90.44,99.44 91.05,99.87 101.96,101.79 103.35,101.55 103.59,101.21 103.43,100.35 103.53,100.21 103.91,100.14 104.05,100.24 104.21,101.1 104.55,101.34 105.16,101.23 105.4,100.89 105.25,100.03 105.35,99.89 105.73,99.82 105.87,99.92 106.02,100.78 106.48,101.1 132.82,96.45 139.66,97.66 148.95,96.02 148.95,96.02 201.42,86.77 203.23,87.09 205.7,86.65 209.7,87.36 211.67,87.01 213.72,87.37 216,86.97 218.62,87.44 221.07,87.01 223.14,87.37 225.03,87.04 227.08,87.4 229.36,87 231.14,87.31 233.01,86.98 235.18,87.36 237.44,86.97 240.78,87.55 242.95,87.17 245.49,87.62 247.19,87.32 248.87,87.62 249.76,87.46 250.02,87.2 250.02,86.97 v1(250.37,86.61)
  BOTTOM w0.135: v1(250.37,86.61) 250.01,86.26 250.01,85.46 C130.1 ; U1.J33 v4(90.36,97.13)
PE_SLOT4_TX_C_DP<8>: length 167.6
  BOTTOM w0.089: 90.91,99.23 90.91,99.21 90.86,99.15 90.86,98.76 91.39,98 91.45,97.65 91.45,97.33 91.16,97.04 90.95,97.04 90.86,96.95 U1.H33
  BOTTOM w0.135: 90.91,99.23 90.91,99.67 91.1,100.75 91.84,101.8 94.03,103.33 95.87,103.66 96.05,103.53 96.45,103.6 96.57,103.78 96.97,103.85 97.15,103.72 97.54,103.8 97.67,103.97 98.36,104.09 101.19,103.6 104.51,104.18 120.04,101.45 127.36,96.32 142.15,93.36 148.9,94.55 160.65,92.2 163.83,92.83 167,92.2 170.18,92.83 173.35,92.2 176.53,92.83 179.7,92.2 194.26,95.11 207.54,92.46 v3(209.83,92.46) 233.95,92.46 238,91.74 239.47,90.71 239.51,90.5 239.84,90.27 240.05,90.31 240.38,90.07 240.42,89.86 240.75,89.63 240.96,89.67 241.29,89.43 241.33,89.22 241.66,88.99 241.88,89.03 245.22,86.69 245.61,86.13 245.67,85.77 245.67,85.46 C131.1
PE_SLOT4_TX_C_DP<9>: length 166.4
  BOTTOM w0.089: U1.G33 91.86,96.97 91.95,97.05 92.18,97.05 92.47,97.35 92.47,97.95 92.4,98.34 92.17,98.68 92.17,99.36 92.22,99.42 92.22,99.44
  BOTTOM w0.135: C132.1 241.68,85.46 241.68,86.1 240.84,87.31 239.98,87.91 239.79,87.88 239.17,86.99 238.73,86.91 238.01,87.42 237.93,87.85 238.56,88.75 238.52,88.93 238.01,89.29 237.82,89.26 237.2,88.37 236.76,88.29 236.04,88.8 235.96,89.23 236.59,90.13 236.55,90.31 235.69,90.92 233.79,91.25 233.22,91.25 233.07,91.1 232.66,91.1 232.51,91.25 232.1,91.25 231.95,91.1 231.55,91.1 231.39,91.25 230.99,91.25 230.84,91.1 230.43,91.1 230.28,91.25 v3(209.03,91.25) 207.42,91.25 194.45,93.85 179.77,90.91 176.53,91.56 173.35,90.93 170.18,91.56 167,90.93 163.83,91.56 160.65,90.93 148.9,93.28 142.15,92.09 126.7,95.18 119.63,100.13 104.16,102.86 101.18,102.33 98.87,102.74 98.3,102.64 98.17,102.46 97.78,102.39 97.6,102.51 97.2,102.44 97.08,102.27 96.68,102.2 96.5,102.32 94.12,101.9 92.8,100.97 92.31,100.28 92.22,99.8 92.22,99.44
PE_SLOT4_TX_C_DP<10>: length 154.3
  BOTTOM w0.089: 93.52,99.09 93.52,99.06 93.46,99.01 93.46,97.34 93.18,97.05 92.94,97.05 92.86,96.98 U1.F33
  BOTTOM w0.135: C133.1 237.67,85.46 237.67,85.84 237.29,86.38 236.91,86.65 236.7,86.61 236.37,86.84 236.33,87.05 236,87.29 235.78,87.25 235.45,87.48 235.42,87.69 235.09,87.93 234.87,87.89 234.54,88.12 234.5,88.33 233.11,89.31 228.88,90.05 v3(218.55,90.05) 207.21,90.05 194.48,92.6 179.74,89.65 176.53,90.29 173.35,89.66 170.18,90.29 167.12,89.68 163.94,90.32 160.65,89.66 148.9,92.01 142.12,90.84 126.3,93.99 119.3,98.9 104.53,101.5 101.36,100.94 99.24,101.32 98.84,101.25 98.71,101.07 98.32,101 98.14,101.12 97.74,101.05 97.62,100.88 97.22,100.81 97.04,100.93 94.18,100.43 93.79,100.15 93.57,99.83 93.52,99.56 93.52,99.09
PE_SLOT4_TX_C_DP<11>: length 152
  BOTTOM w0.089: U1.E33 93.86,96.94 93.96,97.03 94.18,97.03 94.45,97.3 94.45,98.64 94.57,98.76 94.65,98.76 94.67,98.78
  BOTTOM w0.135: C134.1 233.71,85.46 233.71,86.07 233.52,86.34 233.19,86.57 232.98,86.53 232.64,86.76 232.61,86.98 232.28,87.21 232.06,87.17 231.73,87.4 231.69,87.62 231.36,87.85 231.15,87.81 230.82,88.04 230.78,88.25 230.32,88.58 228.76,88.85 v3(213.44,88.85) 206.82,88.85 194.53,91.31 179.75,88.35 176.53,89 173.35,88.36 170,89.03 167.12,88.46 164.12,89.06 160.65,88.36 148.9,90.71 142.15,89.52 125.96,92.76 118.95,97.67 109.29,99.38 109.13,99.27 108.99,98.45 108.63,98.19 107.76,98.35 107.5,98.71 107.65,99.53 107.54,99.68 106.92,99.79 106.77,99.68 106.62,98.86 106.26,98.61 105.39,98.76 105.14,99.13 105.28,99.95 105.17,100.1 104.81,100.17 101.47,99.58 99.56,99.92 99.16,99.85 99.04,99.67 98.64,99.6 98.46,99.72 98.06,99.65 97.94,99.48 97.54,99.41 97.36,99.53 96.86,99.44 95.12,99.13 94.8,98.91 94.67,98.78
PE_SLOT4_TX_C_DP<12>: length 136.8
  BOTTOM w0.089: 99.62,93.01 99.6,93.01 99.54,92.96 98.9,92.96 98.16,92.21 97.56,92.21 97.31,91.96 97.31,91.73 97.21,91.63 U1.B28
  BOTTOM w0.135: C135.1 227.99,85.46 227.99,85.91 227.94,86.2 227.94,86.21 227.6,86.69 226.79,87.26 222.86,87.96 v3(217.82,87.96) 206.74,87.96 193.97,90.21 179.8,87.41 176.53,88.07 173.35,87.43 169.96,88.11 167.11,87.54 164.16,88.13 160.17,87.33 148.9,89.59 142.56,88.32 126.01,91.62 121.28,94.95 118.81,95.38 112.2,94.21 110.52,94.51 109.31,94.29 107.79,94.56 106.15,94.28 104.46,94.57 102.37,94.2 100.67,93.01 99.62,93.01
PE_SLOT4_TX_C_DP<13>: length 134.5
  BOTTOM w0.089: U1.B27 97.13,90.63 97.26,90.75 97.26,90.91 97.57,91.22 98.64,91.22 98.85,91.43 99.44,91.43 99.5,91.49 99.52,91.49
  BOTTOM w0.135: 99.52,91.49 100.18,91.49 101.09,91.65 101.88,92.21 104.32,92.63 106.09,92.32 108,92.66 109.95,92.31 111.64,92.61 112.78,92.41 117.51,93.24 118.62,93.05 118.77,93.15 118.86,93.65 119.04,93.78 119.04,93.78 119.22,93.9 120.09,93.75 120.22,93.57 120.35,93.38 120.26,92.89 120.37,92.74 122.63,92.34 126.16,89.87 130.8,89.05 142.55,86.98 148.9,88.1 160.17,86.11 164.39,86.86 167.1,86.31 169.84,86.86 173.35,86.16 176.53,86.8 179.7,86.16 182.33,86.68 194.47,88.83 195.54,88.64 197.64,88.26 198.89,88.04 199.15,87.68 199.11,87.46 199.22,87.31 199.84,87.2 199.99,87.31 200.03,87.53 200.39,87.78 201.26,87.63 201.52,87.26 201.48,87.04 201.59,86.89 202.21,86.78 202.36,86.89 202.4,87.11 202.76,87.36 206.21,86.75 v3(210.65,86.75) 222.76,86.75 223.37,86.65 223.7,86.41 223.92,86.1 223.98,85.77 223.98,85.46 C136.1
PE_SLOT4_TX_C_DP<14>: length 123.8
  BOTTOM w0.089: U1.B26 97.15,89.63 97.23,89.71 97.23,89.89 97.58,90.23 99.44,90.23 99.5,90.29 99.52,90.29
  BOTTOM w0.135: 99.52,90.29 100.7,90.29 102.51,90.61 104.04,90.34 105.82,90.65 107.12,90.42 108.39,90.64 109.55,90.44 110.78,90.66 112.19,90.41 114.17,90.76 116.31,90.38 118.5,90.77 123.94,89.81 123.97,89.8 124,89.79 125.78,88.51 141.99,85.65 148.9,86.87 160.38,84.85 160.43,84.85 164.26,85.61 167.02,85.06 169.76,85.61 173.35,84.89 176.53,85.53 179.59,84.91 182.4,85.47 192.55,87.26 v3(194.27,86.96) 196.47,86.57 202.7,85.47 215.04,85.47 216.71,84.99 217.64,84.99 C137.1
PE_SLOT4_TX_C_DP<15>: length 118.7
  BOTTOM w0.089: U1.B25 97.17,88.63 97.23,88.7 97.23,88.89 97.56,89.22 98.77,89.22 99.04,88.95 99.44,88.95 99.5,89.01 99.52,89.01
  BOTTOM w0.135: 99.52,89.01 100.88,89.01 103.61,88.53 105.19,88.81 106.96,88.49 108.57,88.78 110.61,88.42 113.34,88.9 116.1,88.41 117.86,88.72 119.4,88.45 120.53,88.65 124.26,87.99 125.14,87.37 141.88,84.41 148.9,85.65 160.48,83.61 164,84.23 167.11,83.68 170.2,84.23 173.23,83.62 176.53,84.28 179.56,83.68 182.45,84.26 185.69,83.59 v3(188.69,84.12) 191.13,84.55 191.49,84.3 191.64,83.45 191.8,83.34 192.42,83.45 192.53,83.61 192.38,84.45 192.63,84.82 193.5,84.97 193.86,84.72 194.01,83.87 194.17,83.76 194.79,83.87 194.9,84.03 194.75,84.87 195,85.23 196.06,85.42 206.44,83.59 208.49,83.59 C138.1
PE_SLOT4_TX_DN<0>: length 6.5
  BOTTOM w0.135: C51.2 278.82,83.95 278.82,83.74 279.68,80.92 279.68,79.69 279.97,79.4 280.14,79.32 280.2,79.14 J4.B15
PE_SLOT4_TX_DN<1>: length 6.3
  BOTTOM w0.135: C52.2 275.67,83.95 275.67,83.55 275.51,83.4 275.51,82.99 275.67,82.84 275.67,82.44 275.51,82.28 275.51,81.88 275.67,81.73 275.67,79.82 275.51,79.65 275.38,79.59 275.2,79.65 J4.B20
PE_SLOT4_TX_DN<2>: length 6.3
  BOTTOM w0.135: C53.2 271.68,83.95 271.68,83.55 271.53,83.4 271.53,82.99 271.68,82.84 271.68,82.44 271.53,82.28 271.53,81.88 271.68,81.73 271.68,79.83 271.51,79.65 271.38,79.59 271.2,79.65 J4.B24
PE_SLOT4_TX_DN<3>: length 6.3
  BOTTOM w0.135: J4.B28 267.2,79.65 267.38,79.59 267.55,79.68 267.72,79.84 267.72,81.73 267.56,81.88 267.56,82.28 267.72,82.44 267.72,82.84 267.56,82.99 267.56,83.4 267.72,83.55 267.72,83.95 C54.2
PE_SLOT4_TX_DN<4>: length 6.3
  BOTTOM w0.135: J4.B34 261.2,79.65 261.38,79.59 261.51,79.65 261.67,79.82 261.67,81.73 261.52,81.88 261.52,82.28 261.67,82.44 261.67,82.84 261.52,82.99 261.52,83.4 261.67,83.55 261.67,83.95 C151.2
PE_SLOT4_TX_DN<5>: length 6.3
  BOTTOM w0.135: C140.2 257.68,83.95 257.68,83.55 257.53,83.4 257.53,82.99 257.68,82.84 257.68,82.44 257.53,82.28 257.53,81.88 257.68,81.73 257.68,79.83 257.51,79.65 257.38,79.59 257.2,79.65 J4.B38
PE_SLOT4_TX_DN<6>: length 6.3
  BOTTOM w0.135: C141.2 253.67,83.95 253.67,83.55 253.52,83.4 253.52,82.99 253.67,82.84 253.67,82.44 253.52,82.28 253.52,81.88 253.67,81.73 253.67,79.81 253.53,79.67 253.38,79.59 253.2,79.65 J4.B42
PE_SLOT4_TX_DN<7>: length 6.3
  BOTTOM w0.135: J4.B46 249.2,79.65 249.38,79.59 249.51,79.65 249.71,79.86 249.71,81.73 249.56,81.88 249.56,82.28 249.71,82.44 249.71,82.84 249.56,82.99 249.56,83.4 249.71,83.55 249.71,83.95 C142.2
PE_SLOT4_TX_DN<8>: length 7.4
  BOTTOM w0.135: J4.B51 244.59,79.15 arc(244.65,79.19) 244.72,79.21 245.17,79.21 arc(245.76,79.45) 246,80.04 246,83.98 246.33,84.31 C143.2
PE_SLOT4_TX_DN<9>: length 7.4
  BOTTOM w0.135: J4.B55 240.59,79.15 arc(240.65,79.19) 240.72,79.21 241.17,79.21 arc(241.76,79.45) 242,80.04 242,83.97 C144.2
PE_SLOT4_TX_DN<10>: length 7.4
  BOTTOM w0.135: J4.B59 236.59,79.15 arc(236.65,79.19) 236.72,79.21 237.17,79.21 arc(237.76,79.45) 238,80.04 238,83.98 C145.2
PE_SLOT4_TX_DN<11>: length 7.4
  BOTTOM w0.135: C146.2 234,83.94 234,80.04 arc(233.76,79.45) 233.17,79.21 232.72,79.21 arc(232.65,79.19) 232.59,79.15 J4.B63
PE_SLOT4_TX_DN<12>: length 6.4
  BOTTOM w0.135: J4.B67 228.2,79.14 228.14,79.32 227.96,79.41 227.69,79.68 227.69,83.95 C147.2
PE_SLOT4_TX_DN<13>: length 6.4
  BOTTOM w0.135: J4.B71 224.2,79.14 224.14,79.32 224.14,79.32 223.98,79.4 223.69,79.69 223.69,83.94 C148.2
PE_SLOT4_TX_DN<14>: length 7.7
  BOTTOM w0.135: J4.B75 220.2,79.14 220.14,79.32 220.14,79.32 219.96,79.41 219.69,79.68 219.69,83.21 219.53,83.36 219.53,83.76 219.69,83.92 219.69,84.46 219.43,84.71 219.17,84.71 C149.2
PE_SLOT4_TX_DN<15>: length 10.4
  BOTTOM w0.135: J4.B79 216.2,79.14 216.14,79.32 215.93,79.42 215.67,79.68 215.67,80.97 215.54,81.74 215.08,82.4 214.06,83.12 213.1,83.29 211.12,83.29 210.96,83.13 210.56,83.13 210.41,83.29 210,83.29 C150.2
PE_SLOT4_TX_DP<0>: length 6.4
  BOTTOM w0.135: C47.2 279.12,83.95 279.12,83.79 279.33,83.1 279.52,83 279.64,82.61 279.54,82.42 279.66,82.03 279.85,81.93 279.97,81.54 279.87,81.35 279.99,80.97 279.99,79.82 280.15,79.65 280.28,79.59 280.46,79.65 J4.B14
PE_SLOT4_TX_DP<1>: length 6.4
  BOTTOM w0.135: C48.2 275.97,83.95 275.97,79.69 275.69,79.4 275.52,79.32 275.46,79.14 J4.B19
PE_SLOT4_TX_DP<2>: length 6.4
  BOTTOM w0.135: J4.B23 271.46,79.14 271.52,79.32 271.69,79.4 271.98,79.7 271.98,83.95 C49.2
PE_SLOT4_TX_DP<3>: length 6.4
  BOTTOM w0.135: C50.2 268.02,83.95 268.02,79.72 267.73,79.43 267.52,79.32 267.46,79.14 J4.B27
PE_SLOT4_TX_DP<4>: length 6.4
  BOTTOM w0.135: J4.B33 261.46,79.14 261.52,79.32 261.69,79.4 261.98,79.69 261.98,83.95 C127.2
PE_SLOT4_TX_DP<5>: length 6.4
  BOTTOM w0.135: C128.2 257.99,83.95 257.99,79.71 257.69,79.4 257.52,79.32 257.46,79.14 J4.B37
PE_SLOT4_TX_DP<6>: length 6.4
  BOTTOM w0.135: J4.B41 253.46,79.14 253.52,79.32 253.71,79.42 253.98,79.68 253.98,83.95 C129.2
PE_SLOT4_TX_DP<7>: length 6.4
  BOTTOM w0.135: C130.2 250.01,83.95 250.01,79.73 249.69,79.4 249.52,79.32 249.46,79.14 J4.B45
PE_SLOT4_TX_DP<8>: length 7.4
  BOTTOM w0.135: C131.2 245.7,83.93 245.7,82.98 245.54,82.83 245.54,82.42 245.7,82.27 245.7,81.87 245.54,81.71 245.54,81.31 245.7,81.16 245.7,80.04 arc(245.54,79.67) 245.17,79.51 244.53,79.51 arc(244.31,79.66) 244.36,79.92 J4.B50
PE_SLOT4_TX_DP<9>: length 7.4
  BOTTOM w0.135: J4.B54 240.36,79.92 arc(240.31,79.66) 240.53,79.51 241.17,79.51 arc(241.54,79.67) 241.7,80.04 241.7,81.16 241.54,81.31 241.54,81.71 241.7,81.87 241.7,82.27 241.54,82.42 241.54,82.83 241.7,82.98 241.7,83.94 C132.2
PE_SLOT4_TX_DP<10>: length 7.4
  BOTTOM w0.135: C133.2 237.69,83.93 237.69,82.98 237.54,82.83 237.54,82.42 237.69,82.27 237.69,81.87 237.54,81.71 237.54,81.31 237.69,81.16 237.69,80.04 arc(237.54,79.67) 237.17,79.51 236.53,79.51 arc(236.31,79.66) 236.36,79.92 J4.B58
PE_SLOT4_TX_DP<11>: length 7.4
  BOTTOM w0.135: J4.B62 232.36,79.92 arc(232.31,79.66) 232.53,79.51 233.17,79.51 arc(233.54,79.67) 233.69,80.04 233.69,81.16 233.54,81.31 233.54,81.71 233.69,81.87 233.69,82.27 233.54,82.42 233.54,82.83 233.69,82.98 233.69,83.97 C134.2
PE_SLOT4_TX_DP<12>: length 6.3
  BOTTOM w0.135: C135.2 227.99,83.95 227.99,83.55 228.15,83.4 228.15,82.99 227.99,82.84 227.99,82.44 228.15,82.28 228.15,81.88 227.99,81.73 227.99,79.81 228.14,79.66 228.28,79.59 228.46,79.65 J4.B66
PE_SLOT4_TX_DP<13>: length 6.3
  BOTTOM w0.135: C136.2 223.99,83.97 223.99,83.56 224.15,83.41 224.15,83.01 223.99,82.85 223.99,82.45 224.15,82.3 224.15,81.89 223.99,81.74 223.99,79.82 224.16,79.65 224.28,79.59 224.46,79.65 J4.B70
PE_SLOT4_TX_DP<14>: length 7.7
  BOTTOM w0.135: C137.2 219.12,85.01 219.56,85.01 219.99,84.58 219.99,79.81 220.14,79.66 220.28,79.59 220.46,79.65 J4.B74
PE_SLOT4_TX_DP<15>: length 10.4
  BOTTOM w0.135: C138.2 210,83.59 213.12,83.59 214.18,83.41 215.29,82.62 215.83,81.86 215.98,81 215.98,79.81 216.11,79.67 216.28,79.59 216.46,79.65 J4.B78
PE_SLOT5_PRES_N: length 346.9
  TOP w0.127: R115.2 v1(56.59,48.65)
  IN2 w0.112: v1(56.59,48.65) 57.06,48.18 59.96,48.18 61.38,49.6 61.71,49.6 62.81,50.7 82.37,50.7 83.03,51.36 118.09,51.36 128.12,61.39 142.32,61.39 161.66,42.05 184.87,42.05 197.96,28.95 283.44,28.95 284.96,30.47 295.56,30.47 297.27,32.18 297.27,39.85 297.16,39.96 297.16,39.98 295.25,41.89 295.25,43.74 295.95,44.44 295.95,44.46 295.95,44.47 295.95,45.2 295.95,45.2 295.95,45.83 296.36,46.24 296.36,51.43 297.38,52.45 297.38,81.03 296.52,81.89 288.9,81.89 286.76,84.03 286.76,88.75 285.62,89.89 285.62,90.63 286.56,91.57 295.33,91.57 296.67,92.91 296.67,95.37 J9.A1
PE_SLOT5_RX_DN<0>: length 260.3
  IN3 w0.089: 63.76,90.78 63.78,90.78 63.83,90.74 67.62,90.74 67.77,90.88 67.77,91.04 67.68,91.13 v4(67.36,91.13)
  IN3 w0.135: J9.A17 278.2,95.46 278.39,95.4 278.51,95.47 278.68,95.64 278.68,99.25 arc(278.59,99.47) 278.37,99.56 278.1,99.56 arc(277.8,99.68) 277.67,99.98 277.67,101.46 277.46,101.76 276.96,102.12 276.74,102.08 276.41,102.31 276.37,102.53 275.48,103.15 275.08,103.22 274.91,103.1 274.51,103.17 274.38,103.35 273.99,103.42 273.81,103.29 273.41,103.36 273.29,103.54 272.89,103.61 272.71,103.49 272.31,103.56 272.19,103.73 271.79,103.8 271.61,103.68 271.22,103.75 271.09,103.93 270.69,104 270.54,103.88 270.14,103.96 270.03,104.11 269.05,104.29 267.8,105.16 267.47,105.64 267.14,107.5 266.85,107.9 266.48,108.17 266,108.25 265.84,108.14 265.44,108.21 265.33,108.37 264.93,108.44 264.77,108.33 264.37,108.4 264.26,108.56 263.87,108.63 263.71,108.52 263.31,108.59 263.2,108.74 250.12,111.05 246.18,110.35 231.16,113 226.96,112.26 215.42,114.29 198.12,111.24 187.19,103.59 172.71,101.03 133.01,108.03 125.28,113.44 111.75,115.83 107.91,115.15 105.39,115.59 100.15,114.67 92.83,115.96 82.67,114.17 81.54,114.37 69.63,112.27 64.62,108.76 61.03,103.63 60.87,102.69 60.99,102.52 60.92,102.12 60.74,101.99 60.67,101.6 60.8,101.42 60.73,101.02 60.55,100.9 60.48,100.5 60.67,99.42 60.56,98.81 60.69,98.64 60.62,98.24 60.44,98.11 60.37,97.72 60.49,97.54 60.42,97.14 60.24,97.02 60.17,96.62 60.38,95.44 60.56,95.32 60.63,94.92 60.5,94.74 60.57,94.34 60.75,94.22 60.82,93.82 60.7,93.64 60.78,93.19 61.21,92.57 61.42,92.54 61.65,92.21 61.62,91.99 61.85,91.66 63.05,90.86 63.07,90.86 63.2,90.82 63.35,90.79 63.36,90.78 63.76,90.78
  BOTTOM w0.135: U1.AL27 v4(67.36,91.13)
PE_SLOT5_RX_DN<1>: length 260.7
  IN3 w0.089: 63.71,91.78 63.73,91.78 63.78,91.73 67.58,91.73 67.77,91.92 67.77,92.04 67.68,92.13 v4(67.36,92.13)
  IN3 w0.135: J9.A22 273.2,94.97 273.14,95.15 272.93,95.25 272.67,95.51 272.67,99.38 arc(272.8,99.7) 273.12,99.83 273.6,99.83 arc(273.69,99.87) 273.73,99.96 273.73,101.4 273.72,101.42 273.41,101.85 272.44,102.54 271.68,102.67 271.5,102.55 271.1,102.62 270.98,102.79 270.58,102.86 270.4,102.74 270.01,102.81 269.88,102.99 269.48,103.06 269.31,102.93 268.91,103 268.78,103.18 268.39,103.25 268.21,103.13 267.81,103.2 267.69,103.37 266.44,103.59 264.29,105.1 263.77,105.84 263.5,107.36 263.2,107.8 262.69,108.16 250.42,110.32 243.98,109.18 242.74,109.4 242.62,109.42 242.37,109.77 242.43,110.1 242.32,110.26 241.95,110.32 241.8,110.21 241.74,109.89 241.39,109.64 240.79,109.75 240.54,110.1 240.6,110.43 240.49,110.58 240.12,110.65 239.97,110.54 239.91,110.21 239.56,109.96 238.96,110.07 238.71,110.42 238.77,110.75 238.66,110.9 238.29,110.97 238.13,110.86 238.08,110.53 237.73,110.29 237.12,110.39 236.88,110.74 236.94,111.07 236.83,111.23 236.46,111.29 236.3,111.18 236.24,110.86 235.89,110.61 235.29,110.72 235.04,111.07 235.1,111.4 234.99,111.55 234.62,111.62 234.47,111.51 234.41,111.18 234.06,110.93 233.46,111.04 233.21,111.39 233.27,111.72 233.16,111.87 232.79,111.94 232.64,111.83 232.58,111.5 232.23,111.26 231.63,111.36 231.38,111.71 231.44,112.04 231.33,112.2 230.96,112.26 230.8,112.15 230.75,111.83 230.38,111.57 229.59,111.71 227.95,111.42 215.42,113.63 206.9,112.13 204.77,111.76 198.38,110.63 187.43,102.96 172.74,100.36 132.76,107.41 125.03,112.83 111.75,115.17 107.91,114.49 105.39,114.93 100.16,114.01 92.94,115.28 87.52,114.33 82.72,113.48 81.53,113.69 69.9,111.64 69.45,111.33 65.38,108.48 63.1,105.23 63.14,105.01 62.91,104.68 62.7,104.65 62.46,104.31 62.5,104.1 62.27,103.77 62.06,103.73 61.83,103.4 61.67,102.53 61.8,102.35 61.73,101.96 61.55,101.83 61.48,101.43 61.6,101.26 61.53,100.86 61.35,100.73 61.28,100.34 61.49,99.16 61.27,97.9 61.4,97.72 61.32,97.32 61.15,97.2 61.04,96.56 61.16,95.87 61.33,95.75 61.4,95.35 61.28,95.17 61.35,94.78 61.53,94.65 61.6,94.25 61.47,94.08 61.47,94.08 61.54,93.68 62.56,92.23 63.09,91.86 63.2,91.84 63.6,91.78 63.71,91.78
  BOTTOM w0.135: U1.AL28 v4(67.36,92.13)
PE_SLOT5_RX_DN<2>: length 246.5
  IN3 w0.089: 63.69,92.79 63.71,92.79 63.76,92.74 67.59,92.74 67.77,92.92 67.77,93.04 67.68,93.13 v4(67.36,93.13)
  IN3 w0.135: J9.A26 269.2,94.97 269.14,95.15 268.93,95.25 268.66,95.53 268.66,99.36 arc(268.8,99.71) 269.15,99.86 269.61,99.86 arc(269.7,99.89) 269.74,99.99 269.74,101.42 269.42,101.87 269.02,102.15 267.22,102.47 267.04,102.35 266.64,102.42 266.52,102.6 266.12,102.67 265.94,102.54 265.54,102.61 265.42,102.79 265.02,102.86 264.84,102.74 264.45,102.81 264.32,102.98 263.42,103.14 260.2,105.4 259.81,105.95 259.55,107.42 259.31,107.77 258.9,108.06 250.37,109.56 244.23,108.48 229.58,111.05 227.95,110.76 215.63,112.93 207.09,111.43 198.54,109.93 187.61,102.27 184.04,101.64 172.91,99.67 132.5,106.8 124.78,112.21 111.74,114.51 107.9,113.83 105.39,114.27 100.16,113.35 92.96,114.62 82.69,112.81 81.53,113.01 70.48,111.06 66.17,108.05 63.92,104.82 63.95,104.61 63.72,104.28 63.51,104.24 63.28,103.91 63.31,103.7 63.08,103.37 62.87,103.33 62.64,103 62.45,101.95 62.58,101.77 62.51,101.37 62.33,101.25 62.26,100.85 62.38,100.67 62.31,100.28 62.14,100.15 62.07,99.75 62.25,98.69 62.08,97.71 62.2,97.53 62.13,97.13 61.95,97.01 61.88,96.61 61.96,96.16 62.14,96.03 62.21,95.64 62.09,95.46 62.16,95.06 62.34,94.94 62.41,94.54 62.28,94.36 62.35,93.96 63.01,93.03 63.28,92.83 63.55,92.79 63.69,92.79
  BOTTOM w0.135: U1.AL29 v4(67.36,93.13)
PE_SLOT5_RX_DN<3>: length 244.1
  IN3 w0.089: v4(67.36,94.13) 67.68,94.13 67.77,94.04 67.77,93.92 67.59,93.74 63.86,93.74 63.82,93.79 63.79,93.79
  IN3 w0.135: J9.A30 265.2,94.97 265.14,95.15 264.93,95.25 264.66,95.52 264.66,99.35 arc(264.57,99.58) 264.34,99.67 264.21,99.67 arc(263.85,99.82) 263.7,100.17 263.7,101.45 263.64,101.83 263.41,102.15 261.55,103.45 260.81,103.58 260.63,103.46 260.23,103.53 260.11,103.71 259.71,103.78 259.53,103.65 259.13,103.72 259.01,103.9 259.01,103.9 258.09,104.06 257.76,104.29 257.55,104.26 257.22,104.49 257.18,104.7 256.28,105.33 256.05,105.66 255.84,105.7 255.6,106.03 255.64,106.24 255.48,106.47 255.31,107.44 255.04,107.83 254.61,108.13 250.3,108.89 244.18,107.81 229.72,110.34 227.83,110 215.51,112.18 200.6,109.55 199.88,109.04 199.04,108.45 198.62,108.53 198.4,108.84 198.22,108.87 197.91,108.65 197.88,108.47 198.09,108.16 198.02,107.74 197.52,107.39 197.1,107.46 196.88,107.77 196.69,107.8 196.38,107.59 196.35,107.4 196.57,107.09 196.49,106.67 195.99,106.32 195.57,106.39 195.36,106.7 195.17,106.73 194.86,106.52 194.83,106.33 195.04,106.02 194.97,105.6 194.47,105.25 194.05,105.33 193.83,105.63 193.64,105.67 193.34,105.45 193.3,105.26 193.52,104.96 193.44,104.54 192.94,104.18 192.52,104.26 192.31,104.57 192.12,104.6 191.81,104.38 191.78,104.2 192,103.89 191.92,103.47 191.42,103.12 191,103.19 190.78,103.5 190.6,103.53 190.29,103.32 190.26,103.13 190.47,102.82 190.4,102.4 189.77,101.96 172.99,98.99 132.25,106.18 124.52,111.59 111.74,113.84 107.9,113.17 105.39,113.61 100.16,112.69 92.97,113.96 87.5,112.99 82.65,112.14 81.59,112.32 70.71,110.41 67.19,107.94 66.14,106.44 65.7,103.97 65.7,103.97 65.69,103.91 64.84,102.69 64.88,102.48 64.65,102.15 64.44,102.11 64.2,101.78 64.24,101.57 64.01,101.24 63.8,101.2 63.57,100.87 63.39,99.85 63.51,99.67 63.44,99.27 63.26,99.15 63.19,98.75 63.32,98.57 63.25,98.18 63.07,98.05 63,97.65 63.12,97.48 63.05,97.08 62.88,96.96 62.81,96.56 63,95.43 63.18,95.31 63.25,94.91 63.13,94.73 63.23,94.16 63.4,93.92 63.58,93.79 63.79,93.79
  BOTTOM w0.135: U1.AL30 v4(67.36,94.13)
PE_SLOT5_RX_DN<4>: length 227.1
  IN3 w0.089: v4(69.36,95.13) 69.36,94.81 69.28,94.73 69.15,94.73 68.97,94.91 68.97,98.6 69.02,98.64 69.02,98.67
  IN3 w0.135: 69.02,98.67 69.02,98.86 68.94,99.28 68.67,99.67 67.47,100.51 66.58,101.78 66.31,103.28 66.38,103.67 66.56,103.8 66.63,104.2 66.51,104.37 66.58,104.77 66.75,104.9 66.82,105.29 66.7,105.47 66.8,106.04 67.91,107.63 68.24,107.86 68.45,107.82 68.79,108.05 68.82,108.27 69.15,108.5 69.37,108.46 69.7,108.69 69.74,108.9 70.98,109.78 81.58,111.65 82.59,111.47 92.96,113.3 100.16,112.03 105.39,112.95 107.9,112.51 111.74,113.18 124.26,110.98 132,105.56 173.14,98.31 189.91,101.26 200.86,108.93 215.33,111.48 227.73,109.3 229.71,109.64 244.13,107.1 250.1,108.16 250.82,108.03 251.2,107.76 251.52,107.3 251.76,105.94 252.51,104.88 254.41,103.55 254.77,103.48 254.89,103.31 255.29,103.24 255.47,103.36 255.86,103.29 255.99,103.11 256.39,103.04 256.56,103.17 256.96,103.1 257.09,102.92 257.48,102.85 257.66,102.97 257.66,102.97 258.18,102.88 258.78,102.46 259.23,102.02 259.71,101.32 259.71,99.99 arc(259.67,99.89) 259.57,99.86 259.09,99.86 arc(258.79,99.73) 258.67,99.43 258.67,95.52 258.93,95.25 259.14,95.15 259.2,94.97 J9.A36
  BOTTOM w0.135: U1.AJ31 v4(69.36,95.13)
PE_SLOT5_RX_DN<5>: length 224.6
  IN3 w0.089: v4(70.36,95.13) 70.36,94.81 70.28,94.73 70.15,94.73 69.95,94.92 69.95,98.83 70,98.88 70,98.9
  IN3 w0.135: J9.A40 255.2,94.97 255.14,95.15 254.93,95.25 254.68,95.5 254.68,99.4 arc(254.81,99.72) 255.14,99.86 255.55,99.86 arc(255.67,99.9) 255.72,100.03 255.72,101.83 255.54,102.09 255.19,102.33 254.18,102.51 254.17,102.51 254,102.38 253.6,102.45 253.48,102.63 253.08,102.7 252.9,102.58 252.5,102.65 252.38,102.83 251.98,102.9 251.8,102.77 251.41,102.84 251.28,103.02 250.71,103.12 250.08,103.56 250,104.01 250.69,105.01 250.65,105.24 250.34,105.45 250.15,105.42 249.47,104.43 249.4,104.34 249.02,104.27 248.52,104.62 248.44,105.04 248.57,105.22 248.54,105.41 248.23,105.62 248.04,105.59 247.91,105.41 247.49,105.33 247.13,105.59 246.5,106.47 246.21,106.68 245.86,106.74 244.15,106.44 229.71,108.98 227.73,108.64 215.34,110.82 208.35,109.59 201.35,108.35 190.41,100.69 173.15,97.64 131.75,104.94 124.01,110.36 111.74,112.52 107.9,111.85 105.39,112.29 100.16,111.37 92.96,112.64 82.54,110.8 81.54,110.98 71.87,109.27 71.02,108.68 70.98,108.46 70.65,108.23 70.44,108.27 70.11,108.04 70.07,107.82 69.74,107.59 69.53,107.63 69.2,107.4 69.16,107.18 68.83,106.95 68.61,106.99 68.01,106.57 67.67,106.08 67.43,104.75 67.56,104.57 67.49,104.18 67.31,104.05 67.09,102.84 67.23,102.08 67.93,101.08 69.58,99.92 69.92,99.44 69.93,99.42 70,99.03 70,98.9
  BOTTOM w0.135: U1.AH31 v4(70.36,95.13)
PE_SLOT5_RX_DN<6>: length 214.6
  IN3 w0.089: 70.99,99.05 70.99,99.03 70.95,98.98 70.95,94.93 71.15,94.73 71.28,94.73 71.36,94.81 v4(71.36,95.13)
  IN3 w0.135: 70.99,99.05 70.99,99.21 70.95,99.44 70.91,99.66 70.53,100.22 68.44,101.68 67.93,102.41 67.83,102.94 67.9,103.31 68.21,103.75 68.76,104.14 68.99,104.47 69.21,104.51 69.44,104.84 69.4,105.05 69.63,105.38 69.84,105.42 70.08,105.75 70.04,105.96 70.41,106.5 70.74,106.73 70.95,106.69 71.28,106.92 71.32,107.13 71.65,107.37 71.87,107.33 72.2,107.56 72.24,107.77 72.57,108 72.78,107.97 73.11,108.2 73.15,108.41 73.92,108.96 81.53,110.3 82.49,110.13 92.96,111.97 100.16,110.71 105.39,111.63 107.9,111.19 111.74,111.86 123.75,109.74 131.51,104.31 173.21,96.96 190.58,100.02 201.61,107.74 215.21,110.14 227.61,107.95 229.71,108.32 246.18,105.42 249.4,103.16 249.45,102.92 249.78,102.69 250.01,102.74 250.32,102.52 250.36,102.29 250.69,102.05 250.93,102.1 251.31,101.83 251.71,101.43 251.71,99.99 arc(251.67,99.89) 251.57,99.86 251.11,99.86 arc(250.8,99.72) 250.67,99.41 250.67,95.52 250.93,95.25 251.14,95.15 251.2,94.97 J9.A44
  BOTTOM w0.135: U1.AG31 v4(71.36,95.13)
PE_SLOT5_RX_DN<7>: length 213.8
  IN3 w0.089: v4(72.36,95.13) 72.36,94.81 72.28,94.73 72.15,94.73 71.96,94.91 71.96,98.88 72.01,98.93 72.01,98.95
  IN3 w0.135: J9.A48 247.2,94.97 247.14,95.15 246.93,95.25 246.7,95.48 246.7,99.43 arc(246.64,99.58) 246.49,99.64 246.14,99.64 arc(245.82,99.78) 245.69,100.1 245.69,101.33 245.57,102 245,102.82 244.76,102.99 244.54,102.95 244.21,103.18 244.18,103.4 243.84,103.63 243.63,103.59 243.3,103.82 243.26,104.03 242.7,104.43 242.28,104.5 242.12,104.39 241.73,104.46 241.61,104.62 240.33,104.85 240.08,105.2 240.16,105.66 240.05,105.81 239.68,105.88 239.53,105.77 239.45,105.31 239.1,105.07 238.49,105.17 238.25,105.52 238.33,105.98 238.22,106.14 237.85,106.2 237.7,106.09 237.61,105.64 237.26,105.39 236.66,105.5 236.42,105.85 236.5,106.3 236.39,106.46 236.02,106.53 235.86,106.42 235.78,105.96 235.43,105.71 234.83,105.82 234.58,106.17 234.66,106.63 234.56,106.78 234.19,106.85 234.03,106.74 233.95,106.28 233.6,106.04 233,106.14 232.75,106.5 232.83,106.95 232.72,107.11 232.35,107.17 232.2,107.06 232.12,106.61 231.77,106.36 231.16,106.47 230.92,106.82 231,107.28 230.89,107.43 230.52,107.5 230.37,107.39 230.29,106.93 229.93,106.69 214.77,109.36 214.74,109.36 201.8,107.08 190.84,99.4 173.22,96.3 131.26,103.69 123.5,109.13 111.74,111.2 107.9,110.53 105.39,110.97 100.15,110.04 92.96,111.31 82.44,109.46 81.53,109.62 74.96,108.46 74.18,107.91 74.14,107.7 73.81,107.47 73.6,107.5 73.27,107.27 73.23,107.06 72.9,106.83 72.68,106.87 72.29,106.59 71.95,106.1 71.99,105.89 71.76,105.56 71.55,105.52 71.31,105.19 71.35,104.98 71.12,104.65 70.91,104.61 70.67,104.28 69.89,103.73 69.62,103.35 69.55,102.93 69.67,102.26 70.28,101.38 71.01,100.87 72.01,99.45 72.01,98.95
  BOTTOM w0.135: U1.AF31 v4(72.36,95.13)
PE_SLOT5_RX_DN<8>: length 199.8
  IN3 w0.089: v4(73.36,95.13) 73.36,94.81 73.28,94.73 73.15,94.73 72.95,94.92 72.95,98.85 73,98.9 73,98.92
  IN3 w0.135: 73,98.92 73,99.55 72.91,100.06 72.66,100.41 72.7,100.63 72.47,100.96 72.25,101 71.59,101.95 71.46,102.67 71.59,103.37 71.81,103.68 72.63,104.26 73.19,105.06 73.2,105.12 73.37,106.11 73.5,106.28 75.87,107.94 81.58,108.95 82.44,108.8 92.95,110.65 100.15,109.38 105.39,110.31 107.9,109.86 111.74,110.54 123.24,108.51 131,103.08 173.18,95.62 191.09,98.79 202.01,106.43 214.74,108.67 223.52,107.13 223.63,106.97 224.03,106.9 224.19,107.01 224.59,106.94 224.7,106.78 225.1,106.71 225.26,106.82 225.65,106.75 225.76,106.59 226.16,106.52 226.32,106.63 226.72,106.56 226.83,106.4 227.23,106.33 227.39,106.45 228.45,106.26 228.85,106.19 228.96,106.03 229.36,105.96 229.52,106.07 229.92,106 230.03,105.84 230.42,105.77 230.58,105.88 230.98,105.81 231.09,105.65 231.49,105.58 231.65,105.69 232.05,105.62 232.16,105.46 232.56,105.39 232.71,105.51 233.11,105.44 233.22,105.28 233.62,105.21 233.78,105.32 234.18,105.25 234.29,105.09 234.69,105.02 234.85,105.13 235.24,105.06 235.35,104.9 235.75,104.83 235.91,104.94 236.31,104.87 236.42,104.71 236.82,104.64 236.98,104.75 237.77,104.61 241.15,102.25 241.53,101.7 241.63,101.12 241.63,99.99 arc(241.76,99.69) 242.05,99.57 242.54,99.57 arc(242.63,99.53) 242.67,99.43 242.67,95.63 242.51,95.47 242.39,95.4 242.2,95.46 J9.A53
  BOTTOM w0.135: U1.AE31 v4(73.36,95.13)
PE_SLOT5_RX_DN<9>: length 197.5
  IN3 w0.089: v4(74.36,95.13) 74.36,94.81 74.28,94.73 74.15,94.73 73.97,94.91 73.97,97.07 74.02,97.12 74.02,97.15
  IN3 w0.135: 74.02,97.15 74.02,97.66 74.13,98.3 73.95,99.31 74.06,99.47 73.99,99.87 73.83,99.98 73.76,100.38 73.87,100.54 73.8,100.94 73.65,101.05 73.58,101.45 73.69,101.6 73.62,102 73.46,102.11 73.39,102.51 73.49,103.07 73.49,103.07 73.58,103.63 73.69,103.78 74.02,104.01 74.21,103.98 74.54,104.21 74.58,104.4 75.13,104.79 75.37,106.11 75.63,106.49 76.11,106.83 76.33,106.79 76.66,107.02 76.7,107.23 77.03,107.47 81.53,108.26 82.33,108.12 92.95,109.99 100.15,108.72 105.39,109.65 107.9,109.2 111.73,109.88 122.98,107.9 130.78,102.44 173.18,94.96 191.43,98.19 202.29,105.79 214.38,107.92 222,106.58 222.11,106.42 222.51,106.35 222.67,106.46 223.07,106.39 223.18,106.23 223.57,106.16 223.73,106.27 224.13,106.2 224.24,106.04 224.64,105.97 224.8,106.08 225.86,105.9 226.26,105.83 226.37,105.67 226.77,105.6 226.93,105.71 227.33,105.64 227.44,105.48 227.84,105.41 228,105.52 228.39,105.45 228.51,105.29 228.9,105.22 229.06,105.33 229.46,105.26 229.57,105.1 229.97,105.03 230.13,105.15 230.52,105.08 230.64,104.92 231.03,104.85 231.19,104.96 232.3,104.76 232.41,104.61 232.29,103.96 232.54,103.61 233.14,103.51 233.49,103.75 233.61,104.4 233.76,104.5 234.13,104.44 234.24,104.28 234.13,103.64 234.37,103.29 234.98,103.18 235.33,103.43 235.44,104.07 235.6,104.18 236.62,104 237.1,103.67 237.51,103.07 237.67,102.18 237.67,100 arc(237.8,99.69) 238.1,99.57 238.55,99.57 arc(238.65,99.53) 238.69,99.43 238.69,95.64 238.51,95.47 238.39,95.4 238.2,95.46 J9.A57
  BOTTOM w0.135: U1.AD31 v4(74.36,95.13)
PE_SLOT5_RX_DN<10>: length 186.9
  IN3 w0.089: v4(75.36,95.13) 75.36,94.81 75.28,94.73 75.15,94.73 74.96,94.92 74.96,96.95 75,97 75,97.02
  IN3 w0.135: J9.A61 234.2,95.46 234.38,95.4 234.51,95.47 234.67,95.63 234.67,99.4 arc(234.62,99.52) 234.5,99.57 234.08,99.57 arc(233.78,99.69) 233.66,99.99 233.66,101.48 233.31,101.98 229.87,104.39 225.81,105.11 225.65,105 225.25,105.07 225.14,105.23 224.74,105.3 224.58,105.18 224.18,105.25 224.07,105.41 223.67,105.48 223.52,105.37 223.12,105.44 223.01,105.6 222.61,105.67 222.45,105.56 222.05,105.63 221.94,105.79 221.54,105.86 221.38,105.75 220.99,105.82 220.88,105.98 220.48,106.05 220.32,105.94 219.92,106.01 219.81,106.16 219.41,106.23 219.25,106.12 218.86,106.19 218.74,106.35 218.35,106.42 218.19,106.31 217.79,106.38 217.68,106.54 217.28,106.61 217.12,106.5 216.72,106.57 216.61,106.73 216.22,106.8 216.06,106.69 215.66,106.76 215.55,106.92 215.15,106.99 214.99,106.88 214.59,106.95 214.48,107.1 213.98,107.19 202.55,105.18 191.53,97.46 173.39,94.25 130.53,101.82 122.73,107.28 111.74,109.22 107.9,108.54 105.38,108.98 100.15,108.06 92.95,109.33 82.29,107.45 81.53,107.58 78.24,107 77.63,106.57 77.28,106.08 77.1,105.08 76.62,104.39 76.04,103.98 75.5,103.21 75.4,102.65 75.52,102.48 75.45,102.08 75.28,101.95 75.21,101.56 75.33,101.38 75.26,100.98 75.08,100.86 75,100.41 75,97.02
  BOTTOM w0.135: U1.AC31 v4(75.36,95.13)
PE_SLOT5_RX_DN<11>: length 185.2
  IN3 w0.089: v4(76.36,95.13) 76.36,94.81 76.28,94.73 76.15,94.73 75.98,94.9 75.98,97.02 76.02,97.07 76.02,97.09
  IN3 w0.135: J9.A65 230.2,95.46 230.38,95.4 230.51,95.47 230.7,95.66 230.7,99.42 arc(230.66,99.53) 230.56,99.57 230.09,99.57 arc(229.79,99.69) 229.67,99.99 229.67,101.55 229.59,102.01 229.58,102.02 229.35,102.45 228.64,103.46 228.28,103.64 228.28,103.64 228.16,103.7 228.16,103.7 227.54,103.81 227.38,103.7 226.98,103.77 226.87,103.93 226.47,104 226.31,103.89 225.92,103.96 225.81,104.12 225.41,104.19 225.25,104.08 224.85,104.15 224.74,104.31 224.34,104.38 224.18,104.26 223.79,104.33 223.67,104.49 223.28,104.56 223.12,104.45 222.72,104.52 222.61,104.68 222.21,104.75 222.05,104.64 221.65,104.71 221.54,104.87 221.14,104.94 220.99,104.83 220.59,104.9 220.48,105.06 220.08,105.13 219.92,105.02 219.52,105.09 219.41,105.24 219.01,105.32 218.85,105.2 218.46,105.27 218.35,105.43 217.95,105.5 217.79,105.39 217.39,105.46 217.28,105.62 216.88,105.69 216.75,105.6 216.31,105.67 216.21,105.81 215.13,106 212.6,105.55 212.25,105.8 212.21,106.02 212.05,106.13 211.68,106.06 211.57,105.91 211.61,105.69 211.37,105.34 210.77,105.23 210.42,105.48 210.38,105.7 210.22,105.81 209.85,105.74 209.74,105.59 209.78,105.36 209.54,105.01 208.93,104.91 208.58,105.15 208.54,105.37 208.39,105.48 208.02,105.42 207.91,105.26 207.95,105.04 207.7,104.69 207.1,104.58 206.75,104.83 206.71,105.05 206.56,105.16 206.19,105.09 206.08,104.94 206.12,104.72 205.87,104.37 205.27,104.26 204.92,104.51 204.88,104.73 204.72,104.84 204.35,104.77 204.25,104.61 204.28,104.39 204.04,104.04 201.42,103.58 191.73,96.8 173.48,93.58 130.33,101.19 130.27,101.2 122.46,106.67 111.74,108.56 107.9,107.88 105.42,108.32 100.19,107.39 92.96,108.67 82.24,106.78 81.53,106.9 81.36,106.87 81.19,106.84 80.85,106.78 80.85,106.78 80.72,106.6 80.32,106.53 80.15,106.66 79.54,106.55 79.35,106.42 79.1,106.07 78.92,105.02 78.42,104.31 77.74,103.83 77.21,103.07 77.25,102.86 77.01,102.53 76.8,102.49 76.54,102.11 76.07,99.44 76.02,99.21 76.02,97.09
  BOTTOM w0.135: U1.AB31 v4(76.36,95.13)
PE_SLOT5_RX_DN<12>: length 174.7
  IN3 w0.089: 77.01,97.02 77.01,97 76.96,96.95 76.96,94.91 77.15,94.73 77.28,94.73 77.36,94.81 v4(77.36,95.13)
  IN3 w0.135: J9.A69 226.2,95.46 226.38,95.4 226.51,95.47 226.69,95.64 226.69,99.41 arc(226.64,99.52) 226.53,99.57 226.08,99.57 arc(225.78,99.69) 225.66,99.99 225.66,102.15 225.05,103.01 224.21,103.6 223.27,103.76 223.11,103.65 222.71,103.72 222.6,103.88 222.2,103.95 222.04,103.84 221.65,103.91 221.54,104.07 221.14,104.14 220.98,104.03 220.58,104.1 220.47,104.26 220.07,104.33 219.91,104.22 219.52,104.29 219.4,104.45 219.01,104.52 218.85,104.4 218.45,104.48 218.34,104.63 217.94,104.7 217.78,104.59 217.38,104.66 217.27,104.82 216.88,104.89 216.72,104.78 216.32,104.85 216.21,105.01 215.81,105.08 215.65,104.97 215.25,105.04 215.14,105.2 214.74,105.27 201.74,102.98 192.01,96.17 173.53,92.91 130.01,100.58 122.2,106.05 111.74,107.9 107.88,107.22 105.41,107.65 100.19,106.73 93.04,107.99 85.41,106.64 85.3,106.48 84.9,106.41 84.74,106.53 84.34,106.46 84.23,106.3 83.84,106.23 83.68,106.34 83.28,106.27 83.17,106.11 82.77,106.04 82.61,106.15 82.21,106.08 81.23,105.39 80.35,104.14 79.67,103.66 78.65,102.2 78.68,101.98 78.45,101.65 78.24,101.61 78.01,101.28 78.05,101.07 77.81,100.74 77.6,100.7 77.24,100.18 77.01,98.91 77.01,97.02
  BOTTOM w0.135: U1.AA31 v4(77.36,95.13)
PE_SLOT5_RX_DN<13>: length 172.4
  IN3 w0.089: v4(78.36,95.13) 78.36,94.81 78.28,94.73 78.15,94.73 77.96,94.92 77.96,96.82 78.01,96.87 78.01,96.89
  IN3 w0.135: 78.01,96.89 78.01,98.19 78.13,98.92 78.5,99.44 78.73,99.77 78.94,99.81 79.18,100.14 79.14,100.35 79.37,100.68 79.58,100.72 79.81,101.05 79.78,101.27 80.01,101.6 80.22,101.63 80.45,101.96 80.42,102.18 81.25,103.37 82.32,104.12 83.99,104.42 84.32,104.65 84.54,104.61 84.87,104.84 84.91,105.05 85.24,105.29 85.45,105.25 85.78,105.48 85.82,105.69 86.51,106.18 93.05,107.33 100.19,106.07 105.42,106.99 107.88,106.56 111.74,107.24 121.89,105.45 129.69,99.98 173.58,92.24 192.53,95.59 202.19,102.36 205.04,102.86 205.2,102.75 205.6,102.82 205.71,102.98 206.11,103.05 206.27,102.94 206.67,103.01 206.78,103.16 207.17,103.23 207.33,103.12 207.73,103.19 207.84,103.35 208.24,103.42 208.4,103.31 208.8,103.38 208.91,103.54 209.31,103.61 209.46,103.5 209.86,103.57 209.97,103.73 210.37,103.8 210.53,103.69 210.93,103.76 211.04,103.92 211.44,103.99 211.6,103.88 211.99,103.95 212.1,104.1 212.5,104.17 212.66,104.06 213.06,104.13 213.17,104.29 214.06,104.45 216.95,103.94 217.06,103.78 216.97,103.26 217.23,102.9 217.83,102.79 218,102.91 218.17,103.03 218.26,103.57 218.42,103.68 218.69,103.63 219.3,103.2 219.34,103.02 218.72,102.13 218.79,101.71 219.29,101.36 219.73,101.43 220.34,102.32 220.88,102.41 221.37,102.07 221.64,101.68 221.64,100.08 arc(221.79,99.72) 222.16,99.57 222.59,99.57 arc(222.7,99.52) 222.75,99.41 222.75,95.7 222.51,95.47 222.38,95.4 222.2,95.46 J9.A73
  BOTTOM w0.135: U1.Y31 v4(78.36,95.13)
PE_SLOT5_RX_DN<14>: length 162.4
  IN3 w0.089: v4(79.36,95.13) 79.36,94.81 79.28,94.73 79.15,94.73 78.96,94.92 78.96,96.72 79.01,96.77 79.01,96.79
  IN3 w0.135: J9.A77 218.2,95.46 218.38,95.4 218.51,95.47 218.67,95.63 218.67,99.43 arc(218.63,99.53) 218.54,99.57 218.1,99.57 arc(217.8,99.69) 217.68,99.99 217.68,101.59 217.4,101.98 216.33,102.73 216.14,102.7 215.81,102.93 215.77,103.12 215.4,103.39 214.26,103.59 213.81,103.51 213.7,103.35 213.3,103.28 213.14,103.39 212.74,103.32 212.63,103.16 212.23,103.09 212.07,103.2 202,101.43 201.67,101.19 201.64,101 201.31,100.77 201.11,100.8 200.78,100.57 200.75,100.38 200.42,100.15 200.23,100.18 199.9,99.95 199.86,99.76 199.53,99.53 199.34,99.56 199.01,99.33 198.98,99.14 198.65,98.91 198.46,98.94 198.12,98.71 198.09,98.52 197.76,98.29 197.57,98.32 197.24,98.09 197.2,97.9 196.87,97.67 196.68,97.7 192.77,94.96 173.56,91.57 129.4,99.36 121.59,104.82 111.69,106.57 107.88,105.9 105.42,106.33 100.18,105.41 93.58,106.57 87.14,105.44 86.43,104.94 86.39,104.72 86.06,104.49 85.85,104.53 85.51,104.3 85.48,104.08 85.15,103.85 84.93,103.89 84.6,103.66 83.54,103.47 83.25,103.26 82.61,102.35 81.35,101.47 81.09,101.1 81.13,100.89 80.9,100.56 80.69,100.52 80.45,100.19 80.49,99.98 80.26,99.65 80.05,99.61 79.82,99.28 79.85,99.06 79.62,98.73 79.41,98.7 79.19,98.38 79.01,97.36 79.01,96.79
  BOTTOM w0.135: U1.W31 v4(79.36,95.13)
PE_SLOT5_RX_DN<15>: length 160.8
  IN3 w0.089: v4(80.36,95.13) 80.36,94.81 80.28,94.73 80.15,94.73 79.97,94.91 79.97,96.85 80.02,96.89 80.02,96.92
  IN3 w0.135: J9.A81 214.2,95.46 214.38,95.4 214.55,95.49 214.66,95.59 214.66,99.31 arc(214.6,99.44) 214.48,99.49 214.06,99.49 arc(213.76,99.62) 213.64,99.91 213.64,101.27 213.28,101.78 212.73,102.17 211.35,102.41 210.94,102.34 210.94,102.34 210.82,102.16 210.42,102.09 210.25,102.22 209.85,102.15 209.72,101.97 209.33,101.9 209.15,102.02 208.75,101.95 208.63,101.78 208.23,101.71 208.05,101.83 207.65,101.76 207.53,101.58 207.13,101.51 206.95,101.64 206.56,101.57 206.43,101.39 206.03,101.32 205.86,101.44 205.46,101.37 205.34,101.2 204.94,101.13 204.76,101.25 202.62,100.87 202.29,100.64 202.26,100.45 201.93,100.22 201.74,100.25 201.41,100.02 201.37,99.83 201.04,99.6 200.85,99.63 200.52,99.4 200.49,99.21 200.16,98.98 199.96,99.01 199.63,98.78 199.6,98.59 199.27,98.36 199.08,98.39 198.75,98.16 198.71,97.97 198.38,97.74 198.19,97.77 197.42,97.24 197.39,97.04 197.95,96.23 197.88,95.81 197.37,95.46 196.95,95.53 196.39,96.34 196.2,96.37 195.9,96.16 195.86,95.97 196.43,95.16 196.35,94.74 195.85,94.39 195.43,94.47 194.87,95.27 194.68,95.3 193.38,94.4 173.57,90.9 129.14,98.74 121.34,104.2 111.69,105.91 107.88,105.24 105.42,105.67 100.18,104.75 93.73,105.89 88,104.88 81.83,100.55 81.38,99.92 81.42,99.7 81.19,99.37 80.97,99.34 80.74,99 80.78,98.79 80.55,98.46 80.33,98.42 80.1,98.09 80.02,97.61 80.02,96.92
  BOTTOM w0.135: U1.V31 v4(80.36,95.13)
PE_SLOT5_RX_DP<0>: length 260.3
  IN3 w0.089: 63.76,90.5 63.78,90.5 63.83,90.55 67.7,90.55 67.96,90.81 67.96,91.04 68.05,91.13 v4(68.36,91.13)
  IN3 w0.135: J9.A16 278.45,94.97 278.51,95.15 278.51,95.15 278.68,95.23 278.97,95.52 278.97,99.25 arc(278.79,99.67) 278.37,99.85 278.1,99.85 arc(278,99.89) 277.96,99.98 277.96,101.55 277.67,101.97 275.59,103.42 270.08,104.4 270.08,104.4 269.16,104.56 268.01,105.37 267.74,105.76 267.41,107.61 267.06,108.11 266.59,108.44 250.12,111.34 246.18,110.65 231.16,113.29 226.96,112.55 215.42,114.59 198.01,111.52 187.08,103.86 172.71,101.32 133.12,108.3 125.39,113.71 111.75,116.12 107.91,115.44 105.39,115.89 100.15,114.96 92.83,116.26 82.67,114.46 82.15,114.55 81.54,114.66 69.52,112.54 64.42,108.97 60.76,103.74 60.19,100.5 60.38,99.42 59.88,96.62 60.51,93.08 61.64,91.45 62.94,90.59 63,90.58 63.29,90.51 63.34,90.5 63.76,90.5
  BOTTOM w0.135: U1.AK27 v4(68.36,91.13)
PE_SLOT5_RX_DP<1>: length 260.6
  IN3 w0.089: v4(68.36,92.13) 68.05,92.13 67.96,92.04 67.96,91.84 67.66,91.54 63.78,91.54 63.73,91.49 63.71,91.49
  IN3 w0.135: 63.71,91.49 63.58,91.49 63.2,91.55 62.98,91.58 62.35,92.02 61.27,93.57 60.74,96.56 61.2,99.16 60.99,100.34 61.55,103.51 65.17,108.68 69.78,111.91 81.53,113.98 82.17,113.87 82.72,113.77 87.24,114.57 87.24,114.57 92.94,115.58 100.16,114.3 105.39,115.23 107.91,114.78 111.75,115.46 125.14,113.1 132.87,107.68 172.74,100.66 187.31,103.23 198.27,110.9 204.72,112.04 206.85,112.41 215.42,113.92 227.95,111.71 229.59,112 230.32,111.87 230.48,111.99 230.54,112.32 230.89,112.57 231.5,112.46 231.74,112.11 231.68,111.78 231.79,111.63 232.16,111.56 232.32,111.67 232.37,112 232.72,112.24 233.33,112.14 233.57,111.79 233.52,111.46 233.63,111.3 233.99,111.24 234.15,111.35 234.21,111.67 234.56,111.92 235.16,111.81 235.41,111.46 235.35,111.13 235.46,110.98 235.83,110.91 235.98,111.02 236.04,111.35 236.39,111.6 236.99,111.49 237.24,111.14 237.18,110.81 237.29,110.66 237.66,110.59 237.81,110.7 237.87,111.03 238.22,111.27 238.83,111.17 239.07,110.82 239.01,110.49 239.12,110.33 239.49,110.27 239.65,110.38 239.7,110.7 240.05,110.95 240.66,110.84 240.9,110.49 240.85,110.16 240.95,110.01 241.32,109.94 241.48,110.05 241.54,110.38 241.89,110.63 242.49,110.52 242.74,110.17 242.68,109.84 242.79,109.69 243.98,109.47 250.42,110.61 262.8,108.43 263.4,108.01 263.77,107.48 264.04,105.95 264.49,105.31 266.55,103.87 272.55,102.81 273.62,102.06 273.96,101.58 273.98,101.54 arc(274.01,101.5) 274.02,101.45 274.02,99.96 arc(273.89,99.67) 273.6,99.54 273.12,99.54 arc(273.01,99.49) 272.96,99.38 272.96,95.63 273.1,95.49 273.27,95.4 273.45,95.46 J9.A21
  BOTTOM w0.135: U1.AK28 v4(68.36,92.13)
