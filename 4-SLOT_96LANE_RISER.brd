# Allegro board 4-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT3_RX_DP<8>: length 169.2
  IN3 w0.089: v4(91.36,94.13) 91.36,94.45 91.28,94.54 91.07,94.54 90.76,94.85 90.76,96.21 90.88,96.91 90.84,96.97 90.85,96.98
  IN3 w0.135: 90.85,96.98 90.96,97.63 91.23,98 92.05,98.58 96.05,99.29 99.52,98.68 100.09,98.58 105.54,99.54 107.8,99.14 112.09,99.9 118.83,98.71 126.79,93.14 174.94,84.65 189.6,87.23 196.04,86.1 199.28,86.67 202.11,86.17 205.09,86.69 206.68,86.41 208.17,86.15 212.33,86.88 214.24,86.55 216.21,86.9 216.37,86.87 216.37,86.87 218.28,86.53 220.74,86.97 238.86,83.77 241.62,81.84 241.95,81.04 arc(241.96,80.99) 241.97,80.94 241.97,79.71 arc(242.01,79.6) 242.11,79.56 242.48,79.56 arc(242.82,79.42) 242.96,79.08 242.96,75.19 242.68,74.91 242.51,74.83 242.51,74.83 242.45,74.65 J3.A52
  BOTTOM w0.135: U1.H30 v4(91.36,94.13)
PE_SLOT3_RX_DP<9>: length 169.3
  IN3 w0.089: 99.52,97.77 99.5,97.77 99.45,97.73 92.45,97.73 91.77,97.04 91.77,94.83 92.07,94.54 92.28,94.54 92.36,94.45 v4(92.36,94.13)
  IN3 w0.135: 99.52,97.77 100.39,97.77 105.64,98.7 106.64,98.52 106.76,98.5 107.46,98.38 110.45,98.91 112.07,99.19 118.62,98.04 126.47,92.54 175.06,83.97 175.88,84.11 175.88,84.12 189.63,86.55 196.04,85.42 199.27,85.99 199.27,85.99 202.15,85.48 205.18,86.01 208.27,85.47 212.3,86.18 214.31,85.83 216.42,86.2 220.86,85.42 221.01,85.53 221.08,85.94 221.43,86.18 222.04,86.08 222.28,85.73 222.21,85.31 222.32,85.16 222.69,85.09 222.84,85.2 222.92,85.62 223.27,85.86 223.87,85.75 224.12,85.4 224.04,84.99 224.15,84.84 224.52,84.77 224.68,84.88 224.75,85.29 225.1,85.54 225.7,85.43 225.95,85.08 225.88,84.67 225.99,84.51 226.35,84.45 226.51,84.56 226.58,84.97 226.93,85.21 227.54,85.11 227.78,84.76 227.71,84.34 227.82,84.19 228.19,84.12 228.34,84.23 228.41,84.65 228.76,84.89 229.37,84.78 229.61,84.43 229.54,84.02 229.65,83.87 230.58,83.7 231.19,83.81 231.89,83.69 236.39,82.89 237.24,82.3 237.88,81.39 237.97,80.85 237.97,79.67 arc(238.01,79.57) 238.11,79.54 238.51,79.54 arc(238.84,79.4) 238.97,79.08 238.97,75.2 238.68,74.91 238.51,74.83 238.51,74.83 238.45,74.65 J3.A56
  BOTTOM w0.135: U1.G30 v4(92.36,94.13)
PE_SLOT3_RX_DP<10>: length 157.4
  IN3 w0.089: 99.08,96.78 99.06,96.78 99.01,96.74 93.09,96.74 92.78,96.42 92.78,94.83 93.07,94.54 93.28,94.54 93.36,94.45 v4(93.36,94.13)
  IN3 w0.135: J3.A60 234.45,74.65 234.51,74.83 234.51,74.83 234.68,74.91 234.96,75.19 234.96,79.08 arc(234.83,79.4) 234.5,79.54 234.1,79.54 arc(234.01,79.57) 233.97,79.67 233.97,81.07 233.88,81.58 233.54,82.07 232.68,82.62 216.33,85.51 214.34,85.15 212.46,85.48 212.1,85.48 208.17,84.79 205.08,85.34 202.1,84.81 199.27,85.31 196.04,84.74 189.62,85.87 175.06,83.31 126.21,91.92 118.38,97.41 112.43,98.46 107.46,97.58 105.74,97.88 104.74,97.71 99.52,96.78 99.08,96.78
  BOTTOM w0.135: U1.F30 v4(93.36,94.13)
PE_SLOT3_RX_DP<11>: length 155.6
  IN3 w0.089: 98.91,95.77 98.88,95.77 98.84,95.72 94.08,95.72 93.78,95.42 93.78,94.82 94.07,94.54 94.28,94.54 94.36,94.45 v4(94.36,94.13)
  IN3 w0.135: 98.91,95.77 100.19,95.77 102.8,96.23 103.24,96.15 106.76,96.77 110.15,96.17 111.81,96.46 120.85,94.87 125.93,91.31 175.1,82.64 187.86,84.89 188.21,84.64 188.29,84.19 188.44,84.08 188.81,84.15 188.92,84.3 188.84,84.75 189.09,85.1 189.61,85.19 190.28,85.08 190.53,84.73 190.37,83.79 190.48,83.63 190.82,83.56 191,83.69 191.16,84.61 191.51,84.86 192.12,84.75 192.36,84.4 192.27,83.88 192.38,83.72 192.75,83.66 192.9,83.77 193,84.29 193.35,84.54 196.05,84.06 199.28,84.63 202.16,84.12 205.11,84.64 205.17,84.64 208.34,84.08 212.51,84.82 214.39,84.48 216.32,84.82 228.19,82.73 229.56,81.77 229.86,81.35 229.96,80.79 229.96,79.67 arc(230,79.57) 230.09,79.54 230.55,79.54 arc(230.85,79.41) 230.97,79.11 230.97,75.2 230.68,74.91 230.51,74.83 230.51,74.83 230.45,74.65 J3.A64
  BOTTOM w0.135: U1.E30 v4(94.36,94.13)
PE_SLOT3_RX_DP<12>: length 144.7
  IN3 w0.089: v4(94.36,92.13) 94.68,92.13 94.77,92.22 94.77,92.42 95.07,92.72 98.97,92.72 99.02,92.77 99.03,92.77
  IN3 w0.135: 99.03,92.77 99.96,92.77 100.28,92.83 102.17,94.15 104.51,94.56 106.35,94.24 108.19,94.56 110.92,94.08 110.93,94.08 113.32,94.5 113.37,94.49 121.7,93.02 121.75,92.99 124.8,90.85 175.07,81.97 185.38,83.79 191.81,82.65 199.23,83.96 202.16,83.44 205.14,83.97 206.79,83.68 208.34,83.4 212.3,84.1 214.18,83.77 216.26,84.14 224.54,82.67 225.44,82.04 225.78,81.56 225.97,80.6 225.97,79.7 arc(226,79.6) 226.1,79.56 226.51,79.56 arc(226.83,79.43) 226.96,79.11 226.96,75.19 226.68,74.91 226.51,74.83 226.51,74.83 226.45,74.65 J3.A68
  BOTTOM w0.135: U1.E28 v4(94.36,92.13)
PE_SLOT3_RX_DP<13>: length 144.6
  IN3 w0.089: 99.36,91.78 99.34,91.78 99.29,91.73 95.07,91.73 94.77,91.43 94.77,91.22 94.68,91.13 v4(94.36,91.13)
  IN3 w0.135: 99.36,91.78 100.56,91.78 101.26,92.27 103.89,92.73 106.73,92.23 107.46,92.36 108.43,92.19 111.62,92.75 113.84,92.36 116.89,92.9 116.95,92.91 117,92.9 121.75,92.06 121.8,92.03 124.32,90.26 167.49,82.65 167.74,82.29 167.65,81.79 167.76,81.63 168.13,81.57 168.28,81.67 168.37,82.18 168.72,82.43 169.32,82.32 169.57,81.97 169.48,81.46 169.59,81.31 169.96,81.24 170.11,81.35 170.2,81.86 170.55,82.11 171.16,82 171.4,81.65 171.31,81.14 171.42,80.98 171.79,80.92 171.95,81.03 172.04,81.54 172.39,81.78 175.08,81.31 185.22,83.1 191.74,81.95 199.32,83.28 202.26,82.76 205.06,83.26 208.16,82.71 212.12,83.41 214.06,83.07 216.25,83.45 221.22,82.58 221.38,82.47 221.82,81.84 221.98,80.95 221.98,79.73 arc(222.03,79.61) 222.15,79.56 222.5,79.56 arc(222.81,79.43) 222.95,79.11 222.95,75.17 222.68,74.91 222.51,74.83 222.51,74.83 222.45,74.65 J3.A72
  BOTTOM w0.135: U1.E27 v4(94.36,91.13)
PE_SLOT3_RX_DP<14>: length 135.4
  IN3 w0.089: 99.52,90.77 99.5,90.77 99.45,90.72 95.07,90.72 94.77,90.42 94.77,90.22 94.68,90.13 v4(94.36,90.13)
  IN3 w0.135: 99.52,90.77 101.49,90.77 102.54,90.59 104.43,90.92 106.24,90.6 107.91,90.89 110.72,90.4 113.28,90.85 116.51,90.28 118.36,90.61 158.97,83.45 160.83,82.14 172.24,80.13 185.05,82.39 191.59,81.24 199.27,82.59 202.16,82.08 205.06,82.6 208.21,82.04 212,82.71 217.22,81.79 217.6,81.53 217.92,81.07 arc(217.97,80.95) 217.99,80.82 217.99,79.7 arc(218.04,79.6) 218.14,79.56 218.54,79.56 arc(218.85,79.43) 218.98,79.11 218.98,75.21 218.68,74.91 218.51,74.83 218.51,74.83 218.45,74.65 J3.A76
  BOTTOM w0.135: U1.E26 v4(94.36,90.13)
PE_SLOT3_RX_DP<15>: length 135.5
  IN3 w0.089: 99.52,89.78 99.5,89.78 99.45,89.73 95.08,89.73 94.77,89.42 94.77,89.22 94.68,89.13 v4(94.36,89.13)
  IN3 w0.135: J3.A80 214.45,74.65 214.51,74.83 214.51,74.83 214.68,74.91 214.99,75.22 214.99,78.87 arc(214.81,79.3) 214.38,79.48 214.04,79.48 arc(213.95,79.52) 213.91,79.62 213.91,80.85 arc(213.89,80.94) 213.85,81.02 213.61,81.37 213.1,81.72 212.05,81.91 209.92,81.53 209.92,81.53 208.53,81.29 205.01,81.91 202.15,81.41 199.27,81.91 191.53,80.55 185.04,81.7 184.15,81.54 183.9,81.19 183.98,80.71 183.87,80.56 183.5,80.49 183.35,80.6 183.27,81.07 182.92,81.32 182.31,81.21 182.07,80.86 182.15,80.39 182.04,80.24 181.67,80.17 181.52,80.28 181.43,80.75 181.08,81 180.48,80.89 180.23,80.54 180.32,80.07 180.21,79.91 179.84,79.85 179.68,79.96 179.6,80.43 179.25,80.67 172.34,79.45 160.54,81.53 158.68,82.84 131.82,87.57 129.18,87.11 127.12,87.47 119.33,88.84 117.34,88.49 115.51,88.81 113.15,88.4 110.5,88.86 108.89,88.58 107.67,88.79 105.99,88.49 104.23,88.8 103.39,88.66 102.55,88.81 101.15,89.78 99.52,89.78
  BOTTOM w0.135: U1.E25 v4(94.36,89.13)
PE_SLOT3_TX_C_DN<0>: length 210.2
  IN1 w0.089: v4(82.36,98.13) 82.36,97.81 82.28,97.73 81.85,97.73 81.69,97.89 81.69,98.2 81.74,98.25 81.74,98.27
  IN1 w0.122: v1(278.46,86.61) 278.78,86.93 278.78,87.48 278.58,87.76 277.07,88.91 277.07,88.91 276,89.1 275.82,88.97 275.46,89.04 275.34,89.21 274.98,89.28 274.8,89.15 274.44,89.22 274.32,89.39 273.96,89.46 273.78,89.33 273.42,89.4 273.29,89.57 272.93,89.64 272.76,89.51 272.4,89.58 272.27,89.75 271.91,89.82 271.74,89.69 271.37,89.76 271.25,89.94 262.49,91.48 259.31,90.92 252.95,92.04 251.12,91.72 249.28,92.05 247.19,91.68 245.65,91.95 243.02,91.48 240.68,91.9 237.5,91.33 235.1,91.76 232.82,91.36 230.79,91.71 229.02,91.4 226.99,91.76 226.99,91.76 226.17,91.62 224.9,91.39 222.83,91.76 220.84,91.37 218.66,91.75 216.12,91.3 213.7,91.73 211.85,91.4 209.31,91.85 206.02,91.27 203.53,91.71 200.84,91.24 200.77,91.23 200.72,91.26 139.83,102 133.48,100.88 97.86,107.16 89.19,105.63 86.12,103.48 86.08,103.27 85.78,103.06 85.57,103.1 85.27,102.89 85.23,102.67 84.93,102.46 84.72,102.5 84.42,102.29 84.38,102.08 84.08,101.87 83.87,101.91 83.57,101.7 83.18,101.14 83.21,100.93 83,100.63 82.79,100.59 82.58,100.29 82.62,100.08 82.41,99.78 82.2,99.74 81.74,99.09 81.74,98.27
  BOTTOM w0.135: C43.1 278.82,85.46 278.82,86.26 v1(278.46,86.61) ; U1.U34 v4(82.36,98.13)
PE_SLOT3_TX_C_DN<1>: length 208.3
  IN1 w0.089: 83.29,99.27 83.28,99.26 83.21,99.24 83.05,99.02 82.96,98.5 82.96,97.85 83.09,97.73 83.28,97.73 83.36,97.81 v4(83.36,98.13)
  IN1 w0.122: 83.29,99.27 83.62,99.74 83.83,99.78 84.04,100.08 84,100.29 84.94,101.63 85.28,101.87 85.49,101.83 85.79,102.04 85.83,102.25 88.54,104.15 90.14,104.43 90.38,104.77 90.36,104.89 90.45,105.03 90.84,105.1 90.98,105 91,104.88 91.34,104.64 91.96,104.75 92.19,105.09 92.15,105.32 92.25,105.46 92.63,105.52 92.78,105.42 92.82,105.2 93.15,104.96 93.77,105.07 94.01,105.41 93.97,105.64 94.06,105.78 94.44,105.84 94.59,105.74 94.63,105.52 94.97,105.28 95.59,105.39 95.83,105.73 95.78,105.98 95.88,106.12 96.26,106.19 96.41,106.09 96.45,105.84 96.79,105.6 97.41,105.71 97.65,106.05 97.62,106.17 97.72,106.32 98.1,106.38 98.25,106.28 98.27,106.16 98.61,105.92 99.89,106.15 133.58,100.21 139.72,101.29 148.79,99.69 148.9,99.67 200.69,90.54 203.33,91.01 203.5,91.01 203.52,91.01 205.9,90.59 209.33,91.19 211.85,90.75 213.68,91.07 214.87,90.86 216.16,90.63 218.72,91.08 220.83,90.71 222.94,91.08 224.95,90.73 227.04,91.1 229.07,90.74 230.74,91.03 232.77,90.67 235.05,91.08 237.44,90.65 240.73,91.23 243.02,90.83 245.58,91.28 247.18,91 249.21,91.36 251.22,91 252.99,91.31 259.35,90.19 262.11,90.68 264.08,90.33 264.2,90.15 264.56,90.09 264.74,90.21 265.1,90.15 265.22,89.97 265.58,89.91 265.76,90.03 266.12,89.97 266.25,89.79 266.61,89.73 266.78,89.85 267.14,89.79 267.27,89.61 267.63,89.55 267.81,89.67 268.17,89.61 268.29,89.43 268.65,89.37 268.83,89.49 269.19,89.43 269.31,89.25 269.67,89.19 269.85,89.31 270.21,89.25 270.33,89.07 270.7,89.01 270.87,89.13 271.23,89.07 271.36,88.89 271.72,88.83 271.89,88.95 274.11,88.56 274.87,88.16 275.63,87.41 275.63,86.93 v1(275.31,86.61)
  BOTTOM w0.135: U1.T34 v4(83.36,98.13) ; v1(275.31,86.61) 275.67,86.26 275.67,85.46 C44.1
PE_SLOT3_TX_C_DN<2>: length 199.4
  IN1 w0.089: 84.4,99.27 84.39,99.26 84.32,99.24 84,98.79 83.95,98.5 83.95,97.81 84.04,97.73 84.28,97.73 84.36,97.81 v4(84.36,98.13)
  IN1 w0.122: 84.4,99.27 84.52,99.44 85.04,100.19 85.56,100.94 89.34,103.58 89.75,103.65 89.93,103.53 90.29,103.59 90.41,103.77 90.77,103.83 90.95,103.71 91.31,103.77 91.43,103.95 91.79,104.01 91.97,103.89 92.33,103.95 92.45,104.13 100.05,105.47 133.58,99.56 139.68,100.63 148.85,99.02 148.85,99.01 148.9,99.01 200.89,89.84 203.33,90.28 205.7,89.86 207.56,90.19 207.56,90.19 209.37,90.51 211.78,90.08 213.54,90.4 216.03,89.96 218.72,90.43 220.83,90.06 222.89,90.42 224.99,90.05 227.13,90.43 229.18,90.07 230.81,90.36 232.8,90.01 235.08,90.41 237.46,89.99 240.78,90.57 243.02,90.18 245.57,90.63 247.19,90.34 249.18,90.69 251.31,90.32 253.11,90.63 259.78,89.46 262.07,89.86 263.72,89.57 263.84,89.4 264.2,89.33 264.38,89.46 264.74,89.39 264.86,89.21 265.22,89.15 265.4,89.28 265.76,89.21 265.88,89.03 266.24,88.97 266.42,89.1 266.78,89.03 266.91,88.85 267.27,88.79 267.44,88.92 267.8,88.85 267.93,88.67 268.29,88.61 268.47,88.73 268.83,88.67 268.95,88.49 269.31,88.43 269.49,88.55 269.85,88.49 269.97,88.31 270.33,88.25 270.51,88.37 271.04,88.28 271.43,88 271.6,87.76 271.67,87.4 271.67,86.96 v1(271.32,86.61)
  BOTTOM w0.135: C45.1 271.68,85.46 271.68,86.26 v1(271.32,86.61) ; U1.R34 v4(84.36,98.13)
PE_SLOT3_TX_C_DN<3>: length 197.6
  IN1 w0.089: 85.37,99.11 85.36,99.09 85.29,99.08 85.02,98.69 84.96,98.4 84.96,97.81 85.05,97.73 85.28,97.73 85.36,97.81 v4(85.36,98.13)
  IN1 w0.122: v1(267.36,86.61) 267.72,86.97 267.72,87.43 267.53,87.69 266.84,88.17 266.07,88.31 265.93,88.21 265.8,87.44 265.46,87.2 264.84,87.31 264.6,87.65 264.74,88.42 264.64,88.56 264.26,88.63 264.12,88.53 263.98,87.76 263.64,87.52 263.02,87.63 262.78,87.97 262.92,88.74 262.82,88.88 261.79,89.06 260.06,88.76 253.11,89.98 251.22,89.65 249.13,90.02 247.17,89.67 245.5,89.96 243.02,89.53 240.86,89.91 237.54,89.32 235.22,89.73 232.91,89.32 230.78,89.7 229.02,89.39 227.03,89.74 225.05,89.39 223.08,89.74 221.02,89.37 218.72,89.78 216.03,89.3 213.6,89.73 211.69,89.4 209.25,89.83 205.54,89.17 203.21,89.58 200.92,89.18 148.88,98.36 148.88,98.36 139.68,99.98 133.35,98.86 100.28,104.69 97.85,104.26 97.72,104.09 97.36,104.02 97.19,104.15 96.83,104.08 96.7,103.91 96.34,103.84 96.16,103.97 95.8,103.9 95.68,103.73 95.32,103.66 95.14,103.79 94.78,103.72 94.66,103.55 94.3,103.48 94.12,103.61 93.76,103.54 93.64,103.37 93.27,103.3 93.1,103.43 92.74,103.37 92.61,103.19 92.25,103.12 92.08,103.25 91.72,103.19 91.59,103.01 91.23,102.94 91.05,103.07 90.69,103.01 90.57,102.83 90.21,102.76 90.03,102.89 89.52,102.8 89,102.43 88.96,102.22 88.66,102.01 88.45,102.04 88.15,101.83 88.11,101.62 87.81,101.41 87.59,101.45 86.44,100.64 85.6,99.44 85.37,99.11
  BOTTOM w0.135: C46.1 267.72,85.46 267.72,86.26 v1(267.36,86.61) ; U1.P34 v4(85.36,98.13)
PE_SLOT3_TX_C_DN<4>: length 185.4
  IN1 w0.089: v4(87.36,98.13) 87.36,97.81 87.28,97.73 87.06,97.73 86.97,97.82 86.97,98.48 87.08,99.11 87.17,99.23 ; 87.17,99.23 87.24,99.24 87.25,99.26 ; 87.17,99.23 87.17,99.23 87.17,99.23
  IN1 w0.122: 87.25,99.26 88.17,100.58 88.57,100.85 88.78,100.82 89.08,101.03 89.12,101.24 90.26,102.04 90.79,102.14 90.97,102.01 91.33,102.07 91.45,102.25 91.81,102.32 91.99,102.19 92.35,102.25 92.47,102.43 92.83,102.5 93.01,102.37 93.37,102.44 93.5,102.61 93.86,102.68 94.03,102.55 94.39,102.62 94.52,102.79 94.88,102.86 95.05,102.73 95.42,102.8 95.54,102.97 95.9,103.04 96.08,102.91 96.44,102.98 96.56,103.15 96.92,103.22 97.1,103.09 97.46,103.16 97.58,103.33 97.94,103.4 98.12,103.27 98.48,103.34 98.61,103.51 100.74,103.89 133.15,98.17 139.69,99.32 201.15,88.48 203.26,88.85 205.64,88.43 209.47,89.11 210.51,88.92 211.61,88.73 213.6,89.08 216.03,88.65 218.66,89.11 221.13,88.68 223.24,89.05 225.14,88.72 227.11,89.06 229.12,88.71 230.87,89.02 232.94,88.65 235.23,89.05 237.55,88.65 240.8,89.22 242.96,88.84 245.57,89.3 247.19,89.01 249.08,89.35 251.15,88.98 253.04,89.32 260.4,87.94 260.52,87.76 260.88,87.7 261.06,87.82 261.42,87.75 261.51,87.62 261.51,87.62 261.6,87.49 261.66,87.41 261.66,86.96 v1(261.32,86.61)
  BOTTOM w0.135: C115.1 261.67,85.46 261.67,86.26 v1(261.32,86.61) ; U1.M34 v4(87.36,98.13)
PE_SLOT3_TX_C_DN<5>: length 183.2
  IN1 w0.089: 88.45,99.27 88.44,99.26 88.37,99.24 88,98.72 87.96,98.5 87.96,97.84 88.08,97.73 88.28,97.73 88.36,97.81 v4(88.36,98.13)
  IN1 w0.122: 88.45,99.27 88.51,99.36 88.66,99.57 89.02,99.93 90.19,100.75 90.41,100.72 90.71,100.93 90.74,101.14 91.04,101.35 91.54,101.44 91.72,101.31 92.08,101.38 92.21,101.56 92.57,101.62 92.74,101.49 93.1,101.56 93.23,101.74 93.59,101.8 93.77,101.67 94.13,101.74 94.25,101.92 94.61,101.98 94.79,101.86 95.15,101.92 95.27,102.1 95.63,102.16 95.81,102.04 96.17,102.1 96.3,102.28 96.66,102.34 96.83,102.22 97.19,102.28 97.32,102.46 97.68,102.52 97.86,102.4 98.22,102.46 98.34,102.64 98.7,102.7 98.88,102.58 99.24,102.64 99.36,102.82 100.91,103.09 132.83,97.46 139.66,98.67 201.23,87.82 203.21,88.16 205.69,87.73 209.62,88.42 211.59,88.07 213.6,88.43 216.06,87.99 218.69,88.46 221.13,88.03 223.24,88.4 225.14,88.06 227.11,88.41 229.18,88.04 230.94,88.35 232.95,88 235.23,88.4 237.55,87.99 240.8,88.57 242.96,88.19 245.52,88.64 247.22,88.34 249.07,88.66 251.05,88.31 252.86,88.63 254.35,88.37 254.47,88.19 254.83,88.13 255.01,88.25 255.37,88.19 255.47,88.05 255.21,86.59 255.45,86.25 256.07,86.14 256.41,86.38 256.67,87.84 256.81,87.93 257.24,87.86 257.58,87.62 257.66,87.49 257.67,87.42 257.67,86.96 v1(257.33,86.61)
  BOTTOM w0.135: v1(257.33,86.61) 257.68,86.26 257.68,85.46 C116.1 ; U1.L34 v4(88.36,98.13)
PE_SLOT3_TX_C_DN<6>: length 174.4
  IN1 w0.089: v4(89.36,98.13) 89.36,97.81 89.28,97.73 89.04,97.73 88.95,97.81 88.95,98.48 89.02,98.88 89.16,99.08 89.34,99.2 89.41,99.19 89.43,99.2
  IN1 w0.122: 89.43,99.2 91.37,100.56 91.85,100.65 92.03,100.52 92.39,100.59 92.51,100.77 92.87,100.83 93.05,100.7 93.41,100.77 93.53,100.95 93.89,101.01 94.07,100.88 94.43,100.95 94.56,101.13 94.92,101.19 95.09,101.06 95.45,101.13 95.58,101.31 95.94,101.37 96.12,101.24 96.48,101.31 96.6,101.49 96.96,101.55 97.14,101.43 97.5,101.49 97.62,101.67 97.98,101.73 98.16,101.61 98.52,101.67 98.64,101.85 99,101.91 99.18,101.79 99.54,101.85 99.67,102.03 101.45,102.34 132.83,96.81 139.66,98.01 148.9,96.39 148.9,96.38 201.27,87.15 203.08,87.47 205.69,87.01 209.7,87.71 210.61,87.56 211.61,87.38 213.67,87.74 215.99,87.33 218.65,87.8 221.09,87.37 223.24,87.75 225.14,87.41 227.11,87.76 229.36,87.36 231.11,87.67 232.95,87.35 235.16,87.74 237.48,87.33 240.79,87.91 242.94,87.53 245.52,87.98 247.23,87.68 249.06,88.01 251.51,87.58 252.17,87.69 252.35,87.57 252.71,87.63 252.83,87.81 253.19,87.87 253.4,87.84 253.53,87.74 253.62,87.62 253.68,87.27 253.68,86.98 v1(253.32,86.61)
  BOTTOM w0.135: v1(253.32,86.61) 253.67,86.26 253.67,85.46 C117.1 ; U1.K34 v4(89.36,98.13)
PE_SLOT3_TX_C_DN<7>: length 172.8
  IN1 w0.089: 90.55,99.16 90.53,99.15 90.46,99.16 90.22,98.99 89.94,98.6 89.94,97.81 90.03,97.73 90.28,97.73 90.36,97.81 v4(90.36,98.13)
  IN1 w0.122: v1(249.35,86.61) 249.72,86.87 249.72,87.08 249.61,87.19 248.87,87.32 248.51,87.26 248.39,87.08 248.03,87.02 247.85,87.14 247.19,87.02 245.49,87.32 242.95,86.88 240.78,87.26 237.44,86.67 235.18,87.07 233.01,86.68 231.14,87.01 229.36,86.7 227.08,87.1 225.03,86.74 223.14,87.07 221.07,86.71 218.62,87.14 216,86.68 213.72,87.08 211.67,86.72 209.7,87.06 205.7,86.35 203.23,86.79 201.42,86.47 148.9,95.73 148.9,95.73 139.66,97.36 132.82,96.16 106.55,100.79 106.29,100.61 106.14,99.75 105.8,99.51 105.18,99.62 104.94,99.96 105.09,100.82 104.99,100.96 104.61,101.03 104.47,100.93 104.32,100.07 103.98,99.83 103.36,99.94 103.13,100.28 103.28,101.14 103.18,101.28 101.96,101.5 99.53,101.07 99.4,100.89 99.04,100.83 98.86,100.95 98.5,100.89 98.38,100.71 98.02,100.64 97.84,100.77 97.48,100.71 97.36,100.53 97,100.46 96.82,100.59 96.46,100.53 96.34,100.35 95.98,100.28 95.8,100.41 95.44,100.34 95.31,100.17 94.95,100.1 94.78,100.23 94.42,100.16 94.29,99.99 93.93,99.92 93.75,100.05 93.39,99.98 93.27,99.81 92.91,99.74 92.73,99.87 92.37,99.8 92.25,99.63 91.89,99.56 91.71,99.69 91.16,99.59 90.95,99.44 90.55,99.16
  BOTTOM w0.135: C118.1 249.71,85.46 249.71,86.26 v1(249.35,86.61) ; U1.J34 v4(90.36,98.13)
PE_SLOT3_TX_C_DN<8>: length 167.6
  BOTTOM w0.089: U1.H34 90.86,97.31 90.95,97.23 91.08,97.23 91.26,97.41 91.26,97.63 91.21,97.93 90.67,98.7 90.67,99.15 90.61,99.21 90.61,99.23
  BOTTOM w0.135: 90.61,99.23 90.61,99.7 90.82,100.87 91.62,102.02 93.91,103.62 98.36,104.4 101.19,103.91 104.51,104.49 120.15,101.73 127.48,96.61 135.05,95.09 141.8,96.28 160.65,92.51 163.83,93.15 167,92.51 170.18,93.15 173.35,92.51 176.53,93.15 179.7,92.51 194.26,95.42 207.57,92.76 233.98,92.76 238.12,92.03 242.05,89.28 243.25,88.44 v3(244.73,87.4) 245.44,86.91 245.89,86.25 245.98,85.79 245.98,85.46 C119.1
PE_SLOT3_TX_C_DN<9>: length 166.4
  BOTTOM w0.089: 91.92,99.44 91.92,99.42 91.98,99.36 91.98,98.62 92.22,98.27 92.28,97.94 92.28,97.43 92.1,97.24 91.94,97.24 91.86,97.31 U1.G34
  BOTTOM w0.135: 91.92,99.44 91.92,99.83 92.02,100.39 92.58,101.19 94,102.19 98.87,103.05 101.18,102.64 104.16,103.16 119.75,100.42 126.82,95.47 135.71,93.69 142.46,94.88 160.65,91.24 163.89,91.89 167.07,91.25 170.18,91.88 171.83,91.55 173.35,91.24 176.53,91.88 179.77,91.23 194.45,94.16 207.45,91.56 v3(208.15,91.56) 233.81,91.56 235.81,91.21 236.83,90.49 236.91,90.05 236.28,89.16 236.32,88.97 236.83,88.61 237.02,88.64 237.65,89.54 238.08,89.62 238.8,89.11 238.88,88.67 238.25,87.78 238.29,87.59 238.8,87.23 238.99,87.26 239.61,88.16 240.05,88.24 241.06,87.53 241.99,86.2 241.99,85.46 C120.1
PE_SLOT3_TX_C_DN<10>: length 154.2
  BOTTOM w0.089: 93.21,99.09 93.21,99.06 93.27,99.01 93.27,97.42 93.1,97.24 92.94,97.24 92.86,97.31 U1.F34
  BOTTOM w0.135: 93.21,99.09 93.21,99.6 93.22,99.61 93.28,99.95 93.57,100.37 94.06,100.71 99.24,101.63 101.36,101.25 104.53,101.81 119.41,99.19 126.42,94.28 135.62,92.44 142.41,93.62 160.65,89.97 163.95,90.63 167.13,90 170.18,90.61 173.35,89.97 176.53,90.61 179.74,89.96 194.48,92.91 207.24,90.36 v3(213.5,90.36) 228.9,90.36 233.23,89.6 237.51,86.6 237.97,85.93 237.97,85.46 C121.1
PE_SLOT3_TX_C_DN<11>: length 152
  BOTTOM w0.089: U1.E34 93.86,97.29 93.94,97.22 94.1,97.22 94.26,97.38 94.26,98.72 94.44,98.9 94.44,98.98 94.45,98.99
  BOTTOM w0.135: C122.1 234.01,85.46 234.01,86.17 233.74,86.56 230.44,88.87 228.79,89.16 v3(218.15,89.16) 206.85,89.16 194.53,91.62 179.75,88.67 176.53,89.31 173.35,88.67 170,89.34 167.12,88.77 164.12,89.37 160.65,88.67 142.46,92.31 135.71,91.12 126.08,93.05 119.07,97.96 109.22,99.7 108.86,99.44 108.71,98.62 108.56,98.51 107.94,98.62 107.83,98.78 107.97,99.6 107.72,99.96 106.85,100.12 106.49,99.86 106.34,99.04 106.19,98.93 105.57,99.04 105.46,99.2 105.6,100.02 105.35,100.38 104.81,100.48 101.47,99.89 99.56,100.23 95.11,99.44 95,99.42 94.61,99.15 94.45,98.99
PE_SLOT3_TX_C_DN<12>: length 136.8
  BOTTOM w0.089: U1.A28 97.63,91.63 97.5,91.76 97.5,91.89 97.64,92.02 98.24,92.02 98.98,92.77 99.54,92.77 99.6,92.71 99.62,92.71
  BOTTOM w0.135: C123.1 227.69,85.46 227.69,85.89 227.65,86.09 227.38,86.48 226.67,86.98 226.1,87.08 225.93,86.95 225.53,87.02 225.4,87.2 225.01,87.27 224.83,87.14 224.43,87.21 224.31,87.39 222.84,87.65 v3(212.92,87.65) 206.72,87.65 193.97,89.9 179.8,87.1 176.53,87.75 173.35,87.12 169.96,87.8 167.11,87.23 164.16,87.82 160.17,87.02 142.79,90.5 136.44,89.23 125.89,91.34 125.45,91.65 125.24,91.61 124.91,91.84 124.87,92.05 124.54,92.28 124.32,92.25 123.99,92.48 123.96,92.69 123.63,92.92 123.41,92.89 123.08,93.12 123.04,93.33 122.71,93.56 122.5,93.53 122.17,93.76 122.13,93.97 121.16,94.66 120.62,94.75 120.44,94.63 120.04,94.7 119.92,94.87 118.81,95.07 112.2,93.9 110.52,94.2 109.31,93.99 107.79,94.25 106.15,93.97 104.46,94.26 102.48,93.92 100.84,92.77 100.79,92.71 99.62,92.71
PE_SLOT3_TX_C_DN<13>: length 134.5
  BOTTOM w0.089: 99.52,91.19 99.5,91.19 99.44,91.24 98.93,91.24 98.72,91.03 97.65,91.03 97.45,90.83 97.45,90.73 97.55,90.63 U1.A27
  BOTTOM w0.135: C124.1 223.67,85.46 223.67,85.75 223.63,85.98 223.48,86.19 223.25,86.36 222.73,86.45 222.33,86.45 222.17,86.3 221.77,86.3 221.62,86.45 221.21,86.45 221.06,86.3 220.66,86.3 220.5,86.45 220.1,86.45 219.95,86.3 219.54,86.3 219.39,86.45 218.99,86.45 218.83,86.3 218.43,86.3 218.28,86.45 217.87,86.45 217.72,86.3 217.31,86.3 217.16,86.45 216.76,86.45 216.6,86.3 216.2,86.3 216.05,86.45 v3(207.8,86.45) 206.18,86.45 202.83,87.04 202.68,86.93 202.64,86.71 202.28,86.46 201.41,86.61 201.15,86.97 201.19,87.19 201.08,87.35 200.47,87.46 200.31,87.35 200.27,87.13 199.91,86.87 199.04,87.03 198.79,87.39 198.83,87.61 198.72,87.77 194.47,88.52 182.39,86.38 179.7,85.85 176.53,86.48 173.35,85.85 169.84,86.55 167.1,86 164.39,86.55 160.17,85.8 142.39,88.94 136.04,87.82 126.04,89.58 122.51,92.05 120.2,92.46 119.94,92.82 120.03,93.31 119.91,93.47 119.29,93.58 119.14,93.47 119.05,92.97 118.69,92.72 117.51,92.93 112.78,92.1 111.64,92.3 109.95,92 108,92.35 106.09,92.01 104.32,92.32 102,91.92 101.21,91.36 100.23,91.19 100.23,91.19 99.52,91.19
PE_SLOT3_TX_C_DN<14>: length 123.8
  BOTTOM w0.089: U1.A26 97.52,89.63 97.42,89.73 97.42,89.81 97.66,90.04 99.44,90.04 99.5,89.99 99.52,89.99
  BOTTOM w0.135: 99.52,89.99 100.75,89.99 100.75,89.99 102.51,90.3 104.04,90.03 105.82,90.34 107.12,90.11 108.39,90.33 109.55,90.13 110.78,90.35 112.19,90.1 114.17,90.45 116.31,90.07 118.5,90.46 123.87,89.51 125.66,88.22 135.99,86.4 142.78,87.6 142.9,87.62 160.36,84.54 160.46,84.54 164.26,85.3 167.02,84.75 169.76,85.3 173.35,84.58 176.53,85.21 179.59,84.6 182.45,85.17 192.55,86.95 202.68,85.17 v3(203.89,85.17) 212.77,85.17 212.92,85.01 213.32,85.01 213.48,85.17 213.88,85.17 214.03,85.01 214.44,85.01 214.59,85.17 214.99,85.17 216.67,84.68 217.64,84.68 C125.1
PE_SLOT3_TX_C_DN<15>: length 118.7
  BOTTOM w0.089: 99.52,88.7 99.5,88.7 99.44,88.76 98.96,88.76 98.69,89.03 97.64,89.03 97.42,88.81 97.42,88.71 97.5,88.63 U1.A25
  BOTTOM w0.135: C126.1 208.49,83.29 206.42,83.29 204.94,83.55 204.76,83.42 204.37,83.49 204.24,83.67 203.85,83.74 203.67,83.62 203.27,83.69 203.15,83.86 v3(200.3,84.36) 198.21,84.73 196.06,85.11 195.18,84.96 195.07,84.8 195.22,83.95 194.96,83.59 194.1,83.44 193.73,83.69 193.58,84.54 193.43,84.65 192.81,84.54 192.7,84.38 192.85,83.54 192.6,83.17 191.73,83.02 191.37,83.27 191.22,84.12 191.06,84.23 185.68,83.28 182.45,83.95 179.56,83.37 176.53,83.97 173.23,83.31 170.2,83.92 167.11,83.37 164,83.92 160.24,83.26 143.01,86.3 136.23,85.1 125.02,87.09 124.58,87.39 124.56,87.41 124.14,87.7 120.53,88.34 119.4,88.14 117.86,88.41 116.1,88.1 113.34,88.59 110.61,88.11 108.57,88.47 106.96,88.18 105.19,88.5 103.61,88.22 100.85,88.7 100.1,88.7 100.08,88.7 100.05,88.7 99.52,88.7
PE_SLOT3_TX_C_DP<0>: length 210.2
  IN1 w0.089: v4(82.36,97.13) 82.36,97.45 82.28,97.54 81.78,97.54 81.5,97.81 81.5,98.2 81.45,98.25 81.45,98.27
  IN1 w0.122: 81.45,98.27 81.45,99.18 83.36,101.91 89.07,105.91 97.86,107.46 133.48,101.18 139.83,102.3 200.84,91.54 200.84,91.53 203.5,92 203.53,92.01 206.02,91.57 209.31,92.15 211.85,91.7 213.7,92.03 216.12,91.6 218.66,92.05 220.83,91.66 222.83,92.05 224.9,91.69 226.11,91.9 226.99,92.06 229.02,91.7 230.79,92.01 232.82,91.65 235.1,92.05 237.5,91.63 240.68,92.19 243.02,91.78 245.65,92.24 247.19,91.97 249.28,92.34 251.12,92.02 252.95,92.34 259.31,91.22 262.49,91.78 277.16,89.19 277.23,89.16 278.8,87.96 279.07,87.57 279.07,87.02 v1(279.48,86.61)
  BOTTOM w0.135: U1.U33 v4(82.36,97.13) ; C39.1 279.12,85.46 279.12,86.26 v1(279.48,86.61)
PE_SLOT3_TX_C_DP<1>: length 208.3
  IN1 w0.089: v4(83.36,97.13) 83.36,97.45 83.28,97.54 83.01,97.54 82.77,97.77 82.77,98.52 82.87,99.1 83.05,99.35 83.04,99.42 83.05,99.44
  IN1 w0.122: v1(276.33,86.61) 275.92,87.02 275.92,87.53 275.92,87.54 275.05,88.4 274.21,88.84 264.25,90.6 262.11,90.98 259.35,90.49 252.99,91.61 251.22,91.3 249.21,91.65 247.18,91.3 245.58,91.58 243.02,91.13 240.73,91.53 237.44,90.95 235.05,91.37 232.77,90.97 230.74,91.33 229.07,91.04 227.04,91.4 224.95,91.03 222.94,91.38 220.83,91.01 218.72,91.38 216.16,90.93 213.68,91.37 211.85,91.05 209.33,91.49 205.9,90.89 203.56,91.3 203.51,91.3 203.31,91.3 200.69,90.84 148.9,99.97 148.84,99.98 148.84,99.98 139.72,101.59 133.58,100.51 99.89,106.45 98.67,106.23 98.53,106.33 98.51,106.45 98.17,106.69 97.55,106.58 97.32,106.24 97.34,106.12 97.24,105.98 96.86,105.91 96.72,106.01 96.67,106.26 96.33,106.5 95.71,106.39 95.59,106.22 95.59,106.22 95.48,106.05 95.52,105.8 95.42,105.66 95.04,105.59 94.9,105.69 94.86,105.91 94.51,106.15 93.89,106.04 93.78,105.88 93.66,105.71 93.7,105.48 93.6,105.34 93.22,105.27 93.08,105.37 93.04,105.59 92.7,105.83 92.08,105.72 91.96,105.56 91.96,105.56 91.84,105.39 91.89,105.16 91.79,105.02 91.41,104.95 91.26,105.05 91.24,105.17 90.9,105.41 90.28,105.3 90.05,104.96 90.07,104.84 89.97,104.7 88.43,104.43 84.73,101.84 83.05,99.44
  BOTTOM w0.135: C40.1 275.97,85.46 275.97,86.26 v1(276.33,86.61) ; U1.T33 v4(83.36,97.13)
PE_SLOT3_TX_C_DP<2>: length 199.4
  IN1 w0.089: 84.16,99.44 84.15,99.42 84.16,99.35 83.82,98.86 83.76,98.52 83.76,97.74 83.96,97.54 84.28,97.54 84.36,97.45 v4(84.36,97.13)
  IN1 w0.122: 84.16,99.44 85.36,101.15 89.22,103.86 100.05,105.76 133.58,99.85 139.68,100.93 148.9,99.3 200.89,90.14 203.33,90.58 205.7,90.16 209.37,90.81 211.78,90.38 213.54,90.69 216.03,90.25 218.72,90.73 220.83,90.36 222.89,90.72 224.99,90.35 227.13,90.73 229.18,90.37 230.81,90.65 232.8,90.3 235.08,90.7 237.46,90.28 240.78,90.87 243.02,90.47 245.57,90.92 247.19,90.64 249.18,90.99 251.31,90.61 253.11,90.93 259.78,89.76 262.07,90.16 271.16,88.56 271.64,88.21 271.88,87.88 271.96,87.43 271.96,87 v1(272.34,86.61)
  BOTTOM w0.135: v1(272.34,86.61) 271.98,86.26 271.98,85.46 C41.1 ; U1.R33 v4(84.36,97.13)
PE_SLOT3_TX_C_DP<3>: length 197.6
  IN1 w0.089: 85.13,99.28 85.12,99.26 85.13,99.19 84.84,98.77 84.77,98.42 84.77,97.74 84.97,97.54 85.28,97.54 85.36,97.45 v4(85.36,97.13)
  IN1 w0.122: 85.13,99.28 85.25,99.44 86.23,100.85 89.41,103.08 100.28,104.99 133.35,99.16 139.68,100.28 148.93,98.65 148.93,98.64 200.92,89.48 203.21,89.88 205.54,89.47 209.25,90.12 211.69,89.69 213.6,90.03 216.03,89.6 218.72,90.08 221.02,89.67 223.08,90.03 225.05,89.69 227.03,90.03 229.02,89.68 230.78,89.99 232.91,89.62 235.22,90.03 237.54,89.62 240.86,90.2 243.02,89.82 245.5,90.26 247.17,89.97 249.13,90.31 251.22,89.94 253.11,90.28 260.06,89.05 261.79,89.36 262.99,89.15 263.23,88.81 263.09,88.04 263.19,87.9 263.57,87.83 263.71,87.93 263.85,88.7 264.19,88.94 264.81,88.83 265.05,88.49 264.91,87.72 265.01,87.58 265.39,87.51 265.53,87.61 265.67,88.38 266.01,88.62 266.96,88.45 267.74,87.9 268.01,87.52 268.01,86.98 v1(268.38,86.61)
  BOTTOM w0.135: v1(268.38,86.61) 268.02,86.26 268.02,85.46 C42.1 ; U1.P33 v4(85.36,97.13)
PE_SLOT3_TX_C_DP<4>: length 185.4
  IN1 w0.089: v4(87.36,97.13) 87.36,97.45 87.28,97.54 86.98,97.54 86.78,97.74 86.78,98.5 86.9,99.18 87.01,99.34 87,99.41 87.01,99.43
  IN1 w0.122: v1(262.33,86.61) 261.95,87 261.95,87.5 261.59,88.02 253.04,89.61 251.15,89.28 249.08,89.64 247.19,89.31 245.57,89.6 242.96,89.14 240.8,89.52 237.55,88.94 235.23,89.35 232.94,88.95 230.87,89.31 229.12,89 227.11,89.36 225.14,89.01 223.24,89.35 221.13,88.98 218.66,89.41 216.03,88.95 213.6,89.38 211.61,89.03 211.61,89.03 209.47,89.4 205.64,88.73 203.26,89.15 201.15,88.78 139.69,99.62 133.15,98.47 100.74,104.19 90.15,102.32 88.95,101.48 87.96,100.79 87.01,99.43
  BOTTOM w0.135: v1(262.33,86.61) 261.98,86.26 261.98,85.46 C103.1 ; U1.M33 v4(87.36,97.13)
PE_SLOT3_TX_C_DP<5>: length 183.1
  IN1 w0.089: 88.21,99.44 88.2,99.42 88.21,99.35 87.82,98.8 87.77,98.52 87.77,97.76 88,97.54 88.28,97.54 88.36,97.45 v4(88.36,97.13)
  IN1 w0.122: v1(258.35,86.61) 257.96,87 257.96,87.44 257.94,87.6 257.79,87.83 257.36,88.13 256.74,88.24 256.4,88.01 256.14,86.55 256,86.45 255.62,86.52 255.52,86.66 255.78,88.12 255.54,88.45 252.86,88.93 251.05,88.61 249.07,88.96 247.22,88.63 245.52,88.93 242.96,88.48 240.8,88.86 237.55,88.29 235.23,88.7 232.95,88.3 230.94,88.65 229.18,88.34 227.11,88.71 225.14,88.36 223.24,88.7 221.13,88.32 218.69,88.75 216.06,88.29 213.6,88.72 211.59,88.37 209.62,88.72 207.63,88.37 205.69,88.02 203.21,88.46 201.23,88.11 139.66,98.96 132.83,97.76 100.91,103.39 90.93,101.63 88.83,100.16 88.43,99.76 88.21,99.44
  BOTTOM w0.135: C104.1 257.99,85.46 257.99,86.26 v1(258.35,86.61) ; U1.L33 v4(88.36,97.13)
PE_SLOT3_TX_C_DP<6>: length 174.5
  IN1 w0.089: v4(89.36,97.13) 89.36,97.45 89.28,97.54 88.96,97.54 88.76,97.74 88.76,98.5 88.84,98.95 89.03,99.21 89.23,99.36 89.24,99.43 89.26,99.44
  IN1 w0.122: 89.26,99.44 91.26,100.84 101.45,102.64 132.83,97.11 139.66,98.31 148.95,96.67 148.95,96.67 201.27,87.45 203.08,87.77 205.69,87.3 209.7,88.01 211.61,87.67 213.67,88.04 215.99,87.63 218.65,88.09 221.09,87.66 223.24,88.04 225.14,87.71 227.11,88.05 229.36,87.66 231.11,87.97 232.95,87.64 235.16,88.03 237.48,87.62 240.79,88.21 242.94,87.83 245.52,88.28 247.23,87.98 249.06,88.3 251.51,87.87 253.19,88.17 253.51,88.11 253.74,87.95 253.89,87.73 253.97,87.3 253.97,86.98 v1(254.33,86.61)
  BOTTOM w0.135: U1.K33 v4(89.36,97.13) ; v1(254.33,86.61) 253.98,86.26 253.98,85.46 C105.1
PE_SLOT3_TX_C_DP<7>: length 172.7
  IN1 w0.089: v4(90.36,97.13) 90.36,97.45 90.28,97.54 89.95,97.54 89.75,97.74 89.75,98.66 90.08,99.13 90.35,99.32 90.37,99.39 90.39,99.4
  IN1 w0.122: 90.39,99.4 90.44,99.44 91.05,99.87 101.96,101.79 103.35,101.55 103.59,101.21 103.43,100.35 103.53,100.21 103.91,100.14 104.05,100.24 104.21,101.1 104.55,101.34 105.16,101.23 105.4,100.89 105.25,100.03 105.35,99.89 105.73,99.82 105.87,99.92 106.02,100.78 106.48,101.1 132.82,96.45 139.66,97.66 148.95,96.02 148.95,96.02 201.42,86.77 203.23,87.09 205.7,86.65 209.7,87.36 211.67,87.01 213.72,87.37 216,86.97 218.62,87.44 221.07,87.01 223.14,87.37 225.03,87.04 227.08,87.4 229.36,87 231.14,87.31 233.01,86.98 235.18,87.36 237.44,86.97 240.78,87.55 242.95,87.17 245.49,87.62 247.19,87.32 248.87,87.62 249.76,87.46 250.02,87.2 250.02,86.97 v1(250.37,86.61)
  BOTTOM w0.135: v1(250.37,86.61) 250.01,86.26 250.01,85.46 C106.1 ; U1.J33 v4(90.36,97.13)
PE_SLOT3_TX_C_DP<8>: length 167.6
  BOTTOM w0.089: 90.91,99.23 90.91,99.21 90.86,99.15 90.86,98.76 91.39,98 91.45,97.65 91.45,97.33 91.16,97.04 90.95,97.04 90.86,96.95 U1.H33
  BOTTOM w0.135: C107.1 245.67,85.46 245.67,85.77 245.61,86.13 245.22,86.69 v3(243.07,88.19) 241.88,89.03 241.66,88.99 241.33,89.22 241.29,89.43 240.96,89.67 240.75,89.63 240.42,89.86 240.38,90.07 240.05,90.31 239.84,90.27 239.51,90.5 239.47,90.71 238,91.74 233.95,92.46 207.54,92.46 194.26,95.11 179.7,92.2 176.53,92.83 173.35,92.2 170.18,92.83 167,92.2 163.83,92.83 160.65,92.2 141.79,95.97 135.05,94.78 127.36,96.32 120.04,101.45 104.51,104.18 101.19,103.6 98.36,104.09 97.67,103.97 97.54,103.8 97.15,103.72 96.97,103.85 96.57,103.78 96.45,103.6 96.05,103.53 95.87,103.66 94.03,103.33 91.84,101.8 91.1,100.75 90.91,99.67 90.91,99.23
PE_SLOT3_TX_C_DP<9>: length 166.4
  BOTTOM w0.089: 92.22,99.44 92.22,99.42 92.17,99.36 92.17,98.68 92.4,98.34 92.47,97.95 92.47,97.35 92.18,97.05 91.95,97.05 91.86,96.97 U1.G33
  BOTTOM w0.135: C108.1 241.68,85.46 241.68,86.1 240.84,87.31 239.98,87.91 239.79,87.88 239.17,86.99 238.73,86.91 238.01,87.42 237.93,87.85 238.56,88.75 238.52,88.93 238.01,89.29 237.82,89.26 237.2,88.37 236.76,88.29 236.04,88.8 235.96,89.23 236.59,90.13 236.55,90.31 235.69,90.92 233.79,91.25 233.22,91.25 233.07,91.1 232.66,91.1 232.51,91.25 232.1,91.25 231.95,91.1 231.55,91.1 231.39,91.25 230.99,91.25 230.84,91.1 230.43,91.1 230.28,91.25 v3(210.56,91.25) 207.42,91.25 194.45,93.85 179.77,90.91 176.53,91.56 173.35,90.93 170.18,91.56 167.07,90.94 163.89,91.58 160.65,90.93 142.45,94.57 135.71,93.38 126.7,95.18 119.63,100.13 104.16,102.86 101.18,102.33 98.87,102.74 98.3,102.64 98.17,102.46 97.78,102.39 97.6,102.51 97.2,102.44 97.08,102.27 96.68,102.2 96.5,102.32 94.12,101.9 92.8,100.97 92.31,100.28 92.22,99.8 92.22,99.44
PE_SLOT3_TX_C_DP<10>: length 154.3
  BOTTOM w0.089: 93.52,99.09 93.52,99.06 93.46,99.01 93.46,97.34 93.18,97.05 92.94,97.05 92.86,96.98 U1.F33
  BOTTOM w0.135: C109.1 237.67,85.46 237.67,85.84 237.29,86.38 236.91,86.65 236.7,86.61 236.37,86.84 236.33,87.05 236,87.29 235.78,87.25 235.45,87.48 235.42,87.69 235.09,87.93 234.87,87.89 234.54,88.12 234.5,88.33 233.11,89.31 228.88,90.05 v3(215.91,90.05) 207.21,90.05 194.48,92.6 179.74,89.65 176.53,90.29 173.35,89.66 170.18,90.29 167.13,89.68 163.95,90.32 160.65,89.66 142.4,93.31 135.62,92.13 126.3,93.99 119.3,98.9 104.53,101.5 101.36,100.94 99.24,101.32 98.84,101.25 98.71,101.07 98.32,101 98.14,101.12 97.74,101.05 97.62,100.88 97.22,100.81 97.04,100.93 94.18,100.43 93.79,100.15 93.57,99.83 93.52,99.56 93.52,99.09
PE_SLOT3_TX_C_DP<11>: length 152
  BOTTOM w0.089: 94.67,98.78 94.65,98.76 94.57,98.76 94.45,98.64 94.45,97.3 94.18,97.03 93.96,97.03 93.86,96.94 U1.E33
  BOTTOM w0.135: 94.67,98.78 94.8,98.91 95.12,99.13 96.86,99.44 97.36,99.53 97.54,99.41 97.94,99.48 98.06,99.65 98.46,99.72 98.64,99.6 99.04,99.67 99.16,99.85 99.56,99.92 101.47,99.58 104.81,100.17 105.17,100.1 105.28,99.95 105.14,99.13 105.39,98.76 106.26,98.61 106.62,98.86 106.77,99.68 106.92,99.79 107.54,99.68 107.65,99.53 107.5,98.71 107.76,98.35 108.63,98.19 108.99,98.45 109.13,99.27 109.29,99.38 114.12,98.52 118.95,97.67 125.96,92.76 135.7,90.81 142.45,92 160.65,88.36 164.12,89.06 167.12,88.46 170,89.03 171.62,88.71 173.35,88.36 176.53,89 179.75,88.35 194.53,91.31 206.82,88.85 v3(220.28,88.85) 228.76,88.85 230.32,88.58 230.78,88.25 230.82,88.04 231.15,87.81 231.36,87.85 231.69,87.62 231.73,87.4 232.06,87.17 232.28,87.21 232.61,86.98 232.64,86.76 232.98,86.53 233.19,86.57 233.52,86.34 233.71,86.07 233.71,85.46 C110.1
PE_SLOT3_TX_C_DP<12>: length 136.8
  BOTTOM w0.089: U1.B28 97.21,91.63 97.31,91.73 97.31,91.96 97.56,92.21 98.16,92.21 98.9,92.96 99.54,92.96 99.6,93.01 99.62,93.01
  BOTTOM w0.135: C111.1 227.99,85.46 227.99,85.91 227.94,86.2 227.94,86.21 227.6,86.69 226.79,87.26 222.86,87.96 v3(215.49,87.96) 206.74,87.96 193.97,90.21 179.8,87.41 176.53,88.07 173.35,87.43 169.96,88.11 167.11,87.54 164.16,88.13 160.17,87.33 142.79,90.81 136.44,89.54 126.01,91.62 121.28,94.95 118.81,95.38 112.2,94.21 110.52,94.51 109.31,94.29 107.79,94.56 106.15,94.28 104.46,94.57 102.37,94.2 100.67,93.01 99.62,93.01
PE_SLOT3_TX_C_DP<13>: length 134.5
  BOTTOM w0.089: 99.52,91.49 99.5,91.49 99.44,91.43 98.85,91.43 98.64,91.22 97.57,91.22 97.26,90.91 97.26,90.75 97.13,90.63 U1.B27
  BOTTOM w0.135: 99.52,91.49 100.18,91.49 101.09,91.65 101.88,92.21 104.32,92.63 106.09,92.32 108,92.66 109.95,92.31 111.64,92.61 112.78,92.41 117.51,93.24 118.62,93.05 118.77,93.15 118.86,93.65 119.04,93.78 119.04,93.78 119.22,93.9 120.09,93.75 120.22,93.57 120.35,93.38 120.26,92.89 120.37,92.74 121.5,92.54 122.63,92.34 126.16,89.87 136.04,88.13 142.39,89.25 160.17,86.11 164.39,86.86 167.1,86.31 169.84,86.86 173.35,86.16 176.53,86.8 179.7,86.16 182.33,86.68 194.47,88.83 198.89,88.04 199.15,87.68 199.11,87.46 199.22,87.31 199.84,87.2 199.99,87.31 200.03,87.53 200.39,87.78 201.26,87.63 201.52,87.26 201.48,87.04 201.59,86.89 202.21,86.78 202.36,86.89 202.4,87.11 202.76,87.36 206.21,86.75 v3(210.45,86.75) 222.76,86.75 223.37,86.65 223.7,86.41 223.92,86.1 223.98,85.77 223.98,85.46 C112.1
PE_SLOT3_TX_C_DP<14>: length 123.8
  BOTTOM w0.089: 99.52,90.29 99.5,90.29 99.44,90.23 97.58,90.23 97.23,89.89 97.23,89.71 97.15,89.63 U1.B26
  BOTTOM w0.135: 99.52,90.29 100.7,90.29 102.51,90.61 104.04,90.34 105.82,90.65 107.12,90.42 108.39,90.64 109.55,90.44 110.78,90.66 112.19,90.41 114.17,90.76 116.31,90.38 118.5,90.77 123.99,89.8 125.78,88.51 135.99,86.71 142.72,87.9 142.9,87.93 160.38,84.85 160.43,84.85 164.26,85.61 167.02,85.06 169.76,85.61 173.35,84.89 176.53,85.53 179.59,84.91 182.4,85.47 192.55,87.26 202.7,85.47 v3(206.18,85.47) 215.04,85.47 216.71,84.99 217.64,84.99 C113.1
PE_SLOT3_TX_C_DP<15>: length 118.7
  BOTTOM w0.089: 99.52,89.01 99.5,89.01 99.44,88.95 99.04,88.95 98.77,89.22 97.56,89.22 97.23,88.89 97.23,88.7 97.17,88.63 U1.B25
  BOTTOM w0.135: 99.52,89.01 100.88,89.01 103.61,88.53 105.19,88.81 106.96,88.49 108.57,88.78 110.61,88.42 113.34,88.9 116.1,88.41 117.86,88.72 119.4,88.45 120.53,88.65 124.26,87.99 124.74,87.66 124.74,87.65 125.14,87.37 136.23,85.41 143.01,86.61 160.24,83.57 164,84.23 167.11,83.68 170.2,84.23 173.23,83.62 176.53,84.28 179.56,83.68 182.45,84.26 185.69,83.59 191.13,84.55 191.49,84.3 191.64,83.45 191.8,83.34 192.42,83.45 192.53,83.61 192.38,84.45 192.63,84.82 193.5,84.97 193.86,84.72 194.01,83.87 194.17,83.76 194.79,83.87 194.9,84.03 194.75,84.87 195,85.23 196.06,85.42 v3(198.27,85.03) 206.44,83.59 208.49,83.59 C114.1
PE_SLOT3_TX_DN<0>: length 6.5
  BOTTOM w0.135: J3.B15 280.2,79.14 280.14,79.32 279.97,79.4 279.68,79.69 279.68,80.92 278.82,83.74 278.82,83.95 C43.2
PE_SLOT3_TX_DN<1>: length 6.3
  BOTTOM w0.135: J3.B20 275.2,79.65 275.38,79.59 275.51,79.65 275.67,79.82 275.67,81.73 275.51,81.88 275.51,82.28 275.67,82.44 275.67,82.84 275.51,82.99 275.51,83.4 275.67,83.55 275.67,83.95 C44.2
PE_SLOT3_TX_DN<2>: length 6.3
  BOTTOM w0.135: J3.B24 271.2,79.65 271.38,79.59 271.51,79.65 271.68,79.83 271.68,81.73 271.53,81.88 271.53,82.28 271.68,82.44 271.68,82.84 271.53,82.99 271.53,83.4 271.68,83.55 271.68,83.95 C45.2
PE_SLOT3_TX_DN<3>: length 6.3
  BOTTOM w0.135: J3.B28 267.2,79.65 267.38,79.59 267.55,79.68 267.72,79.84 267.72,81.73 267.56,81.88 267.56,82.28 267.72,82.44 267.72,82.84 267.56,82.99 267.56,83.4 267.72,83.55 267.72,83.95 C46.2
PE_SLOT3_TX_DN<4>: length 6.3
  BOTTOM w0.135: J3.B34 261.2,79.65 261.38,79.59 261.51,79.65 261.67,79.82 261.67,81.73 261.52,81.88 261.52,82.28 261.67,82.44 261.67,82.84 261.52,82.99 261.52,83.4 261.67,83.55 261.67,83.95 C115.2
PE_SLOT3_TX_DN<5>: length 6.3
  BOTTOM w0.135: J3.B38 257.2,79.65 257.38,79.59 257.51,79.65 257.68,79.83 257.68,81.73 257.53,81.88 257.53,82.28 257.68,82.44 257.68,82.84 257.53,82.99 257.53,83.4 257.68,83.55 257.68,83.95 C116.2
PE_SLOT3_TX_DN<6>: length 6.3
  BOTTOM w0.135: J3.B42 253.2,79.65 253.38,79.59 253.53,79.67 253.67,79.81 253.67,81.73 253.52,81.88 253.52,82.28 253.67,82.44 253.67,82.84 253.52,82.99 253.52,83.4 253.67,83.55 253.67,83.95 C117.2
PE_SLOT3_TX_DN<7>: length 6.3
  BOTTOM w0.135: J3.B46 249.2,79.65 249.38,79.59 249.51,79.65 249.71,79.86 249.71,81.73 249.56,81.88 249.56,82.28 249.71,82.44 249.71,82.84 249.56,82.99 249.56,83.4 249.71,83.55 249.71,83.95 C118.2
PE_SLOT3_TX_DN<8>: length 7.4
  BOTTOM w0.135: C119.2 246.33,84.31 246,83.98 246,80.04 arc(245.76,79.45) 245.17,79.21 244.72,79.21 arc(244.65,79.19) 244.59,79.15 J3.B51
PE_SLOT3_TX_DN<9>: length 7.4
  BOTTOM w0.135: J3.B55 240.59,79.15 arc(240.65,79.19) 240.72,79.21 241.17,79.21 arc(241.76,79.45) 242,80.04 242,83.97 C120.2
PE_SLOT3_TX_DN<10>: length 7.4
  BOTTOM w0.135: C121.2 238,83.98 238,80.04 arc(237.76,79.45) 237.17,79.21 236.72,79.21 arc(236.65,79.19) 236.59,79.15 J3.B59
PE_SLOT3_TX_DN<11>: length 7.4
  BOTTOM w0.135: C122.2 234,83.94 234,80.04 arc(233.76,79.45) 233.17,79.21 232.72,79.21 arc(232.65,79.19) 232.59,79.15 J3.B63
PE_SLOT3_TX_DN<12>: length 6.4
  BOTTOM w0.135: C123.2 227.69,83.95 227.69,79.68 227.96,79.41 228.14,79.32 228.2,79.14 J3.B67
PE_SLOT3_TX_DN<13>: length 6.4
  BOTTOM w0.135: C124.2 223.69,83.94 223.69,79.69 223.98,79.4 224.14,79.32 224.14,79.32 224.2,79.14 J3.B71
PE_SLOT3_TX_DN<14>: length 7.7
  BOTTOM w0.135: C125.2 219.17,84.71 219.43,84.71 219.69,84.46 219.69,83.92 219.53,83.76 219.53,83.36 219.69,83.21 219.69,79.68 219.96,79.41 220.14,79.32 220.14,79.32 220.2,79.14 J3.B75
PE_SLOT3_TX_DN<15>: length 10.4
  BOTTOM w0.135: C126.2 210,83.29 210.41,83.29 210.56,83.13 210.96,83.13 211.12,83.29 213.1,83.29 214.06,83.12 215.08,82.4 215.54,81.74 215.67,80.97 215.67,79.68 215.93,79.42 216.14,79.32 216.2,79.14 J3.B79
PE_SLOT3_TX_DP<0>: length 6.4
  BOTTOM w0.135: C39.2 279.12,83.95 279.12,83.79 279.33,83.1 279.52,83 279.64,82.61 279.54,82.42 279.66,82.03 279.85,81.93 279.97,81.54 279.87,81.35 279.99,80.97 279.99,79.82 280.15,79.65 280.28,79.59 280.46,79.65 J3.B14
PE_SLOT3_TX_DP<1>: length 6.4
  BOTTOM w0.135: J3.B19 275.46,79.14 275.52,79.32 275.69,79.4 275.97,79.69 275.97,83.95 C40.2
PE_SLOT3_TX_DP<2>: length 6.4
  BOTTOM w0.135: C41.2 271.98,83.95 271.98,79.7 271.69,79.4 271.52,79.32 271.46,79.14 J3.B23
PE_SLOT3_TX_DP<3>: length 6.4
  BOTTOM w0.135: C42.2 268.02,83.95 268.02,79.72 267.73,79.43 267.52,79.32 267.46,79.14 J3.B27
PE_SLOT3_TX_DP<4>: length 6.4
  BOTTOM w0.135: C103.2 261.98,83.95 261.98,79.69 261.69,79.4 261.52,79.32 261.46,79.14 J3.B33
PE_SLOT3_TX_DP<5>: length 6.4
  BOTTOM w0.135: C104.2 257.99,83.95 257.99,79.71 257.69,79.4 257.52,79.32 257.46,79.14 J3.B37
PE_SLOT3_TX_DP<6>: length 6.4
  BOTTOM w0.135: C105.2 253.98,83.95 253.98,79.68 253.71,79.42 253.52,79.32 253.46,79.14 J3.B41
PE_SLOT3_TX_DP<7>: length 6.4
  BOTTOM w0.135: C106.2 250.01,83.95 250.01,79.73 249.69,79.4 249.52,79.32 249.46,79.14 J3.B45
PE_SLOT3_TX_DP<8>: length 7.4
  BOTTOM w0.135: C107.2 245.7,83.93 245.7,82.98 245.54,82.83 245.54,82.42 245.7,82.27 245.7,81.87 245.54,81.71 245.54,81.31 245.7,81.16 245.7,80.04 arc(245.54,79.67) 245.17,79.51 244.53,79.51 arc(244.31,79.66) 244.36,79.92 J3.B50
PE_SLOT3_TX_DP<9>: length 7.4
  BOTTOM w0.135: C108.2 241.7,83.94 241.7,82.98 241.54,82.83 241.54,82.42 241.7,82.27 241.7,81.87 241.54,81.71 241.54,81.31 241.7,81.16 241.7,80.04 arc(241.54,79.67) 241.17,79.51 240.53,79.51 arc(240.31,79.66) 240.36,79.92 J3.B54
PE_SLOT3_TX_DP<10>: length 7.4
  BOTTOM w0.135: C109.2 237.69,83.93 237.69,82.98 237.54,82.83 237.54,82.42 237.69,82.27 237.69,81.87 237.54,81.71 237.54,81.31 237.69,81.16 237.69,80.04 arc(237.54,79.67) 237.17,79.51 236.53,79.51 arc(236.31,79.66) 236.36,79.92 J3.B58
PE_SLOT3_TX_DP<11>: length 7.4
  BOTTOM w0.135: C110.2 233.69,83.97 233.69,82.98 233.54,82.83 233.54,82.42 233.69,82.27 233.69,81.87 233.54,81.71 233.54,81.31 233.69,81.16 233.69,80.04 arc(233.54,79.67) 233.17,79.51 232.53,79.51 arc(232.31,79.66) 232.36,79.92 J3.B62
PE_SLOT3_TX_DP<12>: length 6.3
  BOTTOM w0.135: J3.B66 228.46,79.65 228.28,79.59 228.14,79.66 227.99,79.81 227.99,81.73 228.15,81.88 228.15,82.28 227.99,82.44 227.99,82.84 228.15,82.99 228.15,83.4 227.99,83.55 227.99,83.95 C111.2
PE_SLOT3_TX_DP<13>: length 6.3
  BOTTOM w0.135: J3.B70 224.46,79.65 224.28,79.59 224.16,79.65 223.99,79.82 223.99,81.74 224.15,81.89 224.15,82.3 223.99,82.45 223.99,82.85 224.15,83.01 224.15,83.41 223.99,83.56 223.99,83.97 C112.2
PE_SLOT3_TX_DP<14>: length 7.7
  BOTTOM w0.135: C113.2 219.12,85.01 219.56,85.01 219.99,84.58 219.99,79.81 220.14,79.66 220.28,79.59 220.46,79.65 J3.B74
PE_SLOT3_TX_DP<15>: length 10.4
  BOTTOM w0.135: C114.2 210,83.59 213.12,83.59 214.18,83.41 215.29,82.62 215.83,81.86 215.98,81 215.98,79.81 216.11,79.67 216.28,79.59 216.46,79.65 J3.B78
PE_SLOT4_PRES_N: length 350.9
  TOP w0.114: v1(69.85,48.61) 69.53,48.29 58.68,48.29 57.71,49.25 57.71,51.89 57.43,52.17 56.46,52.17 R115.2
  IN2 w0.112: J4.A1 296.67,95.37 296.67,92.91 295.33,91.57 286.56,91.57 285.62,90.63 285.62,89.89 286.76,88.75 286.76,84.03 288.9,81.89 296.52,81.89 297.38,81.03 297.38,52.45 296.36,51.43 296.36,46.24 295.95,45.83 295.95,45.2 295.95,45.2 295.95,44.47 295.95,44.46 295.95,44.44 295.25,43.74 295.25,41.89 297.16,39.98 297.16,39.96 297.27,39.85 297.27,32.18 295.56,30.47 283.05,30.47 281.53,28.95 197.96,28.95 184.87,42.05 161.66,42.05 142.32,61.39 128.12,61.39 118.09,51.36 71.46,51.36 69.85,49.76 v1(69.85,48.61)
PE_SLOT4_RX_DN<0>: length 260.3
  IN3 w0.089: 63.76,90.78 63.78,90.78 63.83,90.74 67.62,90.74 67.77,90.88 67.77,91.04 67.68,91.13 v4(67.36,91.13)
  IN3 w0.135: 63.76,90.78 63.36,90.78 63.35,90.79 63.2,90.82 63.07,90.86 63.05,90.86 61.85,91.66 61.62,91.99 61.65,92.21 61.42,92.54 61.21,92.57 60.78,93.19 60.7,93.64 60.82,93.82 60.75,94.22 60.57,94.34 60.5,94.74 60.63,94.92 60.56,95.32 60.38,95.44 60.17,96.62 60.24,97.02 60.42,97.14 60.49,97.54 60.37,97.72 60.44,98.11 60.62,98.24 60.69,98.64 60.56,98.81 60.67,99.42 60.48,100.5 60.55,100.9 60.73,101.02 60.8,101.42 60.67,101.6 60.74,101.99 60.92,102.12 60.99,102.52 60.87,102.69 61.03,103.63 64.62,108.76 69.63,112.27 81.54,114.37 82.67,114.17 92.83,115.96 100.15,114.67 105.39,115.59 107.91,115.15 111.75,115.83 125.28,113.44 133.01,108.03 172.71,101.03 187.19,103.59 198.12,111.24 215.42,114.29 226.96,112.26 231.16,113 246.18,110.35 250.12,111.05 263.2,108.74 263.31,108.59 263.71,108.52 263.87,108.63 264.26,108.56 264.37,108.4 264.77,108.33 264.93,108.44 265.33,108.37 265.44,108.21 265.84,108.14 266,108.25 266.48,108.17 266.85,107.9 267.14,107.5 267.47,105.64 267.8,105.16 269.05,104.29 270.03,104.11 270.14,103.96 270.54,103.88 270.69,104 271.09,103.93 271.22,103.75 271.61,103.68 271.79,103.8 272.19,103.73 272.31,103.56 272.71,103.49 272.89,103.61 273.29,103.54 273.41,103.36 273.81,103.29 273.99,103.42 274.38,103.35 274.51,103.17 274.91,103.1 275.08,103.22 275.48,103.15 276.37,102.53 276.41,102.31 276.74,102.08 276.96,102.12 277.46,101.76 277.67,101.46 277.67,99.98 arc(277.8,99.68) 278.1,99.56 278.37,99.56 arc(278.59,99.47) 278.68,99.25 278.68,95.64 278.51,95.47 278.39,95.4 278.2,95.46 J4.A17
  BOTTOM w0.135: U1.AL27 v4(67.36,91.13)
PE_SLOT4_RX_DN<1>: length 260.6
  IN3 w0.089: 63.71,91.78 63.73,91.78 63.78,91.73 67.58,91.73 67.77,91.92 67.77,92.04 67.68,92.13 v4(67.36,92.13)
  IN3 w0.135: J4.A22 273.2,94.97 273.14,95.15 272.93,95.25 272.67,95.51 272.67,99.38 arc(272.8,99.7) 273.12,99.83 273.55,99.83 arc(273.65,99.87) 273.69,99.96 273.69,101.46 273.41,101.85 272.44,102.54 271.68,102.67 271.5,102.55 271.1,102.62 270.98,102.79 270.58,102.86 270.4,102.74 270.01,102.81 269.88,102.99 269.48,103.06 269.31,102.93 268.91,103 268.78,103.18 268.39,103.25 268.21,103.13 267.81,103.2 267.69,103.37 266.44,103.59 264.29,105.1 263.77,105.84 263.5,107.36 263.2,107.8 262.69,108.16 250.42,110.32 243.98,109.18 242.74,109.4 242.62,109.42 242.37,109.77 242.43,110.1 242.32,110.26 241.95,110.32 241.8,110.21 241.74,109.89 241.39,109.64 240.79,109.75 240.54,110.1 240.6,110.43 240.49,110.58 240.12,110.65 239.97,110.54 239.91,110.21 239.56,109.96 238.96,110.07 238.71,110.42 238.77,110.75 238.66,110.9 238.29,110.97 238.13,110.86 238.08,110.53 237.73,110.29 237.12,110.39 236.88,110.74 236.94,111.07 236.83,111.23 236.46,111.29 236.3,111.18 236.24,110.86 235.89,110.61 235.29,110.72 235.04,111.07 235.1,111.4 234.99,111.55 234.62,111.62 234.47,111.51 234.41,111.18 234.06,110.93 233.46,111.04 233.21,111.39 233.27,111.72 233.16,111.87 232.79,111.94 232.64,111.83 232.58,111.5 232.23,111.26 231.63,111.36 231.38,111.71 231.44,112.04 231.33,112.2 230.96,112.26 230.8,112.15 230.75,111.83 230.38,111.57 229.59,111.71 227.95,111.42 215.42,113.63 206.9,112.13 204.77,111.76 198.38,110.63 187.43,102.96 172.74,100.36 132.76,107.41 125.03,112.83 111.75,115.17 107.91,114.49 105.39,114.93 100.16,114.01 92.94,115.28 87.52,114.33 82.72,113.48 81.53,113.69 69.9,111.64 69.45,111.33 65.38,108.48 63.1,105.23 63.14,105.01 62.91,104.68 62.7,104.65 62.46,104.31 62.5,104.1 62.27,103.77 62.06,103.73 61.83,103.4 61.67,102.53 61.8,102.35 61.73,101.96 61.55,101.83 61.48,101.43 61.6,101.26 61.53,100.86 61.35,100.73 61.28,100.34 61.49,99.16 61.27,97.9 61.4,97.72 61.32,97.32 61.15,97.2 61.04,96.56 61.16,95.87 61.33,95.75 61.4,95.35 61.28,95.17 61.35,94.78 61.53,94.65 61.6,94.25 61.47,94.08 61.47,94.08 61.54,93.68 62.56,92.23 63.09,91.86 63.2,91.84 63.6,91.78 63.71,91.78
  BOTTOM w0.135: U1.AL28 v4(67.36,92.13)
PE_SLOT4_RX_DN<2>: length 246.4
  IN3 w0.089: 63.69,92.79 63.71,92.79 63.76,92.74 67.59,92.74 67.77,92.92 67.77,93.04 67.68,93.13 v4(67.36,93.13)
  IN3 w0.135: J4.A26 269.2,94.97 269.14,95.15 268.93,95.25 268.66,95.53 268.66,99.36 arc(268.8,99.71) 269.15,99.86 269.54,99.86 arc(269.64,99.89) 269.68,99.99 269.68,101.51 269.42,101.87 269.02,102.15 267.22,102.47 267.04,102.35 266.64,102.42 266.52,102.6 266.12,102.67 265.94,102.54 265.54,102.61 265.42,102.79 265.02,102.86 264.84,102.74 264.45,102.81 264.32,102.98 263.42,103.14 260.2,105.4 259.81,105.95 259.55,107.42 259.31,107.77 258.9,108.06 250.37,109.56 244.23,108.48 229.58,111.05 227.95,110.76 215.63,112.93 207.09,111.43 198.54,109.93 187.61,102.27 184.04,101.64 172.91,99.67 132.5,106.8 124.78,112.21 111.74,114.51 107.9,113.83 105.39,114.27 100.16,113.35 92.96,114.62 82.69,112.81 81.53,113.01 70.48,111.06 66.17,108.05 63.92,104.82 63.95,104.61 63.72,104.28 63.51,104.24 63.28,103.91 63.31,103.7 63.08,103.37 62.87,103.33 62.64,103 62.45,101.95 62.58,101.77 62.51,101.37 62.33,101.25 62.26,100.85 62.38,100.67 62.31,100.28 62.14,100.15 62.07,99.75 62.25,98.69 62.08,97.71 62.2,97.53 62.13,97.13 61.95,97.01 61.88,96.61 61.96,96.16 62.14,96.03 62.21,95.64 62.09,95.46 62.16,95.06 62.34,94.94 62.41,94.54 62.28,94.36 62.35,93.96 63.01,93.03 63.28,92.83 63.55,92.79 63.69,92.79
  BOTTOM w0.135: U1.AL29 v4(67.36,93.13)
