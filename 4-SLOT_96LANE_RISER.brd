# Allegro board 4-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT4_TX_C_DN<10>: length 180.6
  BOTTOM w0.089: U1.AC34 75.86,97.31 75.74,97.19 75.6,97.19 75.45,97.34 75.45,98.11 75.51,98.17 75.51,98.19
  BOTTOM w0.135: 75.51,98.19 75.51,98.48 75.37,98.87 74.92,99.44 74.92,100.35 75.42,103.19 75.86,103.81 76.42,104.2 77,105.04 77.2,106.18 78.11,107.48 81.69,109.98 87.58,111.02 87.76,110.9 88.15,110.97 88.28,111.14 88.68,111.21 88.85,111.09 89.25,111.16 89.38,111.34 89.77,111.41 89.95,111.28 90.35,111.35 90.47,111.53 94.91,112.31 101.37,111.17 104.33,111.69 126.17,107.84 129.19,105.73 129.23,105.51 129.56,105.28 129.77,105.32 130.1,105.09 130.14,104.88 130.47,104.64 130.69,104.68 131.53,104.09 136.45,103.22 140.5,103.94 160.87,99.86 160.88,99.86 163.7,100.48 167,99.82 170.18,100.45 173.35,99.82 176.53,100.45 179.7,99.82 195.22,102.92 207.4,111.45 217.17,113.17 v3(220.64,112.56) 224.6,111.86 224.72,111.68 225.12,111.61 225.3,111.74 225.69,111.67 225.82,111.49 226.22,111.42 226.39,111.54 226.79,111.47 226.92,111.3 227.31,111.23 227.49,111.35 227.89,111.28 228.01,111.1 228.41,111.03 228.59,111.16 229.99,110.91 235.13,107.31 235.63,106.6 235.69,106.25 235.69,105.78 C145.1
PE_SLOT4_TX_C_DN<11>: length 178.5
  BOTTOM w0.089: U1.AB34 76.86,97.36 76.75,97.24 76.59,97.24 76.47,97.37 76.47,98.19 76.53,98.25 76.53,98.27
  BOTTOM w0.135: 76.53,98.27 76.53,98.82 76.52,98.85 76.12,99.44 76.12,99.45 76.12,100.14 76.29,101.13 77.08,102.26 77.27,103.33 77.68,103.92 78.55,104.52 78.93,105.07 79.15,106.32 79.48,106.8 82,108.56 89.01,109.8 89.15,109.7 89.55,109.77 89.66,109.91 90.05,109.98 90.2,109.88 90.6,109.95 90.7,110.1 91.1,110.17 91.25,110.06 91.64,110.13 91.75,110.28 95.34,110.92 101.29,109.87 104.47,110.43 125.26,106.77 128.55,104.46 128.59,104.25 128.92,104.02 129.13,104.05 129.46,103.82 129.5,103.61 129.83,103.38 130.04,103.41 130.98,102.76 136.07,101.86 140.5,102.64 160.88,98.57 163.83,99.16 167,98.52 170.18,99.16 173.35,98.52 176.53,99.16 179.7,98.52 195.56,101.7 207.87,110.31 v3(212.77,111.18) 216.58,111.85 219.47,111.34 219.59,111.16 219.99,111.09 220.17,111.22 220.56,111.15 220.69,110.97 221.09,110.9 221.26,111.02 221.66,110.95 221.78,110.78 222.18,110.71 222.36,110.83 222.76,110.76 222.88,110.58 223.28,110.51 223.46,110.64 223.86,110.57 223.98,110.39 224.38,110.32 224.55,110.44 226.83,110.04 226.94,109.89 226.81,109.14 227.06,108.77 227.93,108.62 228.29,108.87 228.43,109.62 228.58,109.73 228.86,109.68 230.12,108.8 230.35,108.48 230.31,108.29 229.55,107.75 229.47,107.32 229.98,106.59 230.41,106.52 231.18,107.06 231.37,107.02 231.55,106.76 231.68,106.07 231.68,105.78 C146.1
PE_SLOT4_TX_C_DN<12>: length 167.5
  BOTTOM w0.089: U1.AA34 77.86,97.31 77.74,97.19 77.68,97.19 77.45,97.43 77.45,98.27 77.5,98.32 77.5,98.35
  BOTTOM w0.135: C147.1 227.69,105.78 227.69,106.11 227.61,106.56 227.21,107.13 226.81,107.41 226.6,107.37 226.27,107.6 226.23,107.82 225.9,108.05 225.68,108.01 225.35,108.24 225.32,108.46 224.48,109.04 223.18,109.27 223,109.15 222.6,109.22 222.48,109.4 222.08,109.47 221.9,109.34 221.5,109.41 221.38,109.59 v3(220.11,109.81) 217.46,110.28 216.04,110.53 208.34,109.18 196.01,100.54 179.7,97.28 176.53,97.91 173.35,97.28 170.18,97.91 167,97.28 163.83,97.91 160.75,97.3 141.8,101.09 135.05,99.9 131.82,100.47 128.58,102.73 128.37,102.69 128.04,102.93 128,103.14 127.67,103.37 127.46,103.33 127.12,103.57 127.09,103.78 126.76,104.01 126.54,103.97 126.21,104.2 126.18,104.42 124.42,105.65 104.57,109.15 101.28,108.57 95.68,109.56 91.59,108.84 91.47,108.66 91.07,108.59 90.89,108.71 90.49,108.64 90.37,108.46 89.97,108.39 89.79,108.52 89.4,108.45 89.27,108.27 88.87,108.2 88.7,108.33 83.43,107.4 81.47,106.02 80.14,104.13 79.28,103.53 79.09,103.26 79,102.75 77.43,100.51 77.32,99.85 77.32,99.65 77.37,99.44 77.39,99.34 77.43,99.2 77.5,98.65 77.5,98.64 77.5,98.35
PE_SLOT4_TX_C_DN<13>: length 165.1
  BOTTOM w0.089: U1.Y34 78.86,97.31 78.77,97.22 78.66,97.22 78.46,97.41 78.46,98.37 78.52,98.42 78.52,98.45
  BOTTOM w0.135: C148.1 223.67,105.78 223.67,106.93 223.64,107.12 223.33,107.33 223.04,107.28 221.93,105.7 221.38,105.6 220.92,105.92 220.78,106.69 221.58,107.83 221.55,108.02 221.37,108.14 220.45,108.31 220.28,108.18 219.88,108.25 219.75,108.43 219.36,108.5 219.18,108.37 218.78,108.44 218.66,108.62 218.26,108.69 218.08,108.57 217.68,108.64 217.56,108.81 217.16,108.88 216.98,108.76 216.59,108.83 216.46,109.01 215.41,109.19 v3(212.82,108.74) 208.8,108.03 196.4,99.35 179.7,96.01 176.53,96.64 173.35,96.01 170.18,96.64 167,96.01 163.83,96.64 160.83,96.04 141.79,99.85 135.06,98.67 130.66,99.44 127.48,101.66 127.27,101.63 126.94,101.86 126.9,102.07 126.57,102.3 126.36,102.27 126.03,102.5 125.99,102.71 125.66,102.94 125.45,102.9 125.11,103.14 125.08,103.35 123.26,104.63 104.55,107.93 101.2,107.34 96.22,108.21 91.86,107.45 91.74,107.27 91.34,107.2 91.16,107.32 90.76,107.25 90.64,107.07 90.24,107 90.06,107.13 89.67,107.06 89.54,106.88 89.14,106.81 88.97,106.94 83.48,105.97 83.04,105.66 82.14,104.38 81.43,103.88 81.07,103.36 80.95,102.68 80.72,102.35 79.69,101.63 78.79,100.34 78.66,99.62 78.66,98.95 78.52,98.81 78.52,98.45
PE_SLOT4_TX_C_DN<14>: length 154.3
  BOTTOM w0.089: 79.99,99.01 79.99,98.98 79.94,98.93 79.94,98.73 79.45,98.25 79.45,97.42 79.64,97.23 79.81,97.23 79.86,97.29 U1.W34
  BOTTOM w0.135: C149.1 219.66,105.78 219.66,106.14 219.61,106.45 219.38,106.78 218.82,107.16 218.39,107.24 218.22,107.11 217.82,107.18 217.69,107.36 214.94,107.85 209.19,106.83 208.26,106.18 208.23,105.97 207.89,105.74 207.68,105.78 207.35,105.54 207.31,105.33 206.98,105.1 206.77,105.14 v3(203.75,103.03) 196.8,98.16 179.7,94.74 176.53,95.37 173.35,94.74 170.18,95.37 167,94.74 163.83,95.37 160.64,94.74 141.8,98.5 135.06,97.32 129.56,98.41 127.78,99.66 127.56,99.62 127.23,99.85 127.19,100.07 126.86,100.3 126.65,100.26 126.32,100.49 126.28,100.71 125.95,100.94 125.74,100.9 125.41,101.13 125.37,101.35 122.15,103.6 104.54,106.7 101.2,106.12 96.73,106.9 92.05,106.08 91.93,105.9 91.53,105.83 91.35,105.96 90.96,105.89 90.83,105.71 90.43,105.64 90.26,105.76 89.86,105.69 89.74,105.52 89.34,105.45 89.16,105.57 85.09,104.85 83.17,103.51 82.83,103.03 82.77,102.66 82.3,101.99 80.55,100.77 80.1,100.12 79.99,99.51 79.99,99.01
PE_SLOT4_TX_C_DN<15>: length 156.2
  BOTTOM w0.089: U1.V34 80.86,97.31 80.77,97.22 80.66,97.22 80.47,97.41 80.47,98.04 81.16,98.74 81.16,98.94 81.22,99 81.22,99.02
  BOTTOM w0.135: C150.1 215.7,105.78 215.7,106.2 215.58,106.37 215.44,106.51 214.86,106.61 214.46,106.54 214.34,106.36 213.94,106.29 213.76,106.42 213.36,106.35 213.24,106.17 212.84,106.1 212.67,106.22 212.27,106.15 212.14,105.98 211.75,105.91 211.57,106.03 211.17,105.96 211.05,105.78 210.65,105.71 210.47,105.84 210.02,105.76 209.3,105.25 209.26,105.06 209.95,104.08 209.87,103.64 209.15,103.14 208.72,103.21 208.03,104.2 207.84,104.23 207.33,103.87 207.29,103.68 207.98,102.7 207.9,102.26 207.18,101.76 206.75,101.84 206.06,102.82 205.87,102.85 205.36,102.49 205.32,102.31 206.01,101.32 205.93,100.89 205.21,100.38 204.78,100.46 204.09,101.44 203.9,101.47 201.34,99.68 v3(199.43,98.34) 197.52,97.01 179.7,93.44 176.53,94.08 173.35,93.44 170.18,94.08 167,93.44 163.83,94.08 160.62,93.44 141.8,97.2 135.06,96.01 128.44,97.33 125.41,99.46 125.19,99.42 124.86,99.65 124.82,99.86 124.49,100.1 124.28,100.06 123.95,100.29 123.91,100.5 123.58,100.74 123.37,100.7 123.04,100.93 123,101.14 120.93,102.6 104.54,105.48 101.02,104.86 97.22,105.53 92.53,104.7 92.4,104.53 92,104.46 91.83,104.58 91.43,104.51 91.31,104.33 90.91,104.26 90.73,104.39 90.33,104.32 90.21,104.14 89.81,104.07 89.63,104.19 86.83,103.7 81.42,99.91 81.27,99.7 81.23,99.44 81.22,99.4 81.22,99.02
PE_SLOT4_TX_C_DP<0>: length 243.4
  IN1 w0.089: v4(65.36,91.13) 65.05,91.13 64.96,91.04 64.96,90.84 64.66,90.54 63.6,90.54 63.49,90.56 63.28,90.59 63.22,90.55 63.2,90.56
  IN1 w0.122: v1(276.05,106.93) 275.68,107.3 275.68,107.91 275.37,108.35 270.94,111.45 250.07,115.13 212.7,108.54 175.52,101.98 148.9,106.68 140.35,108.18 134,107.06 87.75,115.22 69.94,112.08 65.48,108.99 63.79,107.73 60.67,103.26 59.82,98.48 60.93,92.2 61.74,91.04 62.18,90.74 63.15,90.57 63.15,90.57 63.2,90.56
  BOTTOM w0.135: U1.AN27 v4(65.36,91.13) ; v1(276.05,106.93) 275.69,106.58 275.69,105.78 C47.1
PE_SLOT4_TX_C_DP<1>: length 243.7
  IN1 w0.089: 63.2,91.52 63.22,91.52 63.27,91.57 63.56,91.53 64.63,91.53 64.96,91.86 64.96,92.04 65.05,92.13 v4(65.36,92.13)
  IN1 w0.122: v1(273.25,106.93) 272.88,107.3 272.88,107.71 272.33,108.51 268.77,111 260.37,112.48 259.06,112.71 258.72,112.47 258.65,112.06 258.51,111.96 258.13,112.03 258.03,112.17 258.1,112.58 257.86,112.92 257.24,113.03 256.91,112.79 256.83,112.38 256.69,112.28 256.31,112.35 256.21,112.49 256.28,112.9 256.05,113.24 255.43,113.35 255.09,113.11 255.02,112.7 254.87,112.6 254.49,112.67 254.39,112.81 254.47,113.22 254.23,113.56 253.61,113.67 253.27,113.43 253.2,113.02 253.06,112.92 252.68,112.99 252.58,113.13 252.65,113.54 252.41,113.88 251.79,113.99 251.45,113.75 251.38,113.34 251.24,113.24 250.86,113.31 250.76,113.45 250.83,113.86 250.6,114.2 249.79,114.34 175.57,101.26 148.91,105.96 148.9,105.96 140.16,107.5 133.81,106.38 87.64,114.52 85.51,114.14 77.99,112.82 70.23,111.45 64.38,107.34 61.58,103.34 60.69,98.3 61.68,92.68 62.11,92.07 62.82,91.57 63.2,91.52
  BOTTOM w0.135: C48.1 272.9,105.78 272.9,106.58 v1(273.25,106.93) ; U1.AN28 v4(65.36,92.13)
PE_SLOT4_TX_C_DP<2>: length 230.6
  IN1 w0.089: 63.2,92.93 63.21,92.91 63.28,92.9 63.5,92.58 63.72,92.54 64.66,92.54 64.9,92.79 64.94,93.03 65.05,93.13 v4(65.36,93.13)
  IN1 w0.122: 63.2,92.93 62.36,94.12 61.69,97.92 62.69,103.58 65.06,106.97 70.57,110.82 87.66,113.83 133.9,105.68 140.17,106.79 175.49,100.55 247.03,113.16 267.06,109.63 269.03,108.25 269.33,107.82 269.33,107.3 v1(269.7,106.93)
  BOTTOM w0.135: C49.1 269.34,105.78 269.34,106.58 v1(269.7,106.93) ; U1.AN29 v4(65.36,93.13)
PE_SLOT4_TX_C_DP<3>: length 229.1
  IN1 w0.089: v4(65.36,94.13) 65.05,94.13 64.96,94.04 64.96,93.77 64.91,93.72 64.87,93.67 64.64,93.52 64.31,93.52 63.97,93.64 63.44,94.36 63.41,94.57 63.35,94.61 63.34,94.64
  IN1 w0.122: 63.34,94.64 62.9,97.14 63.42,100.1 63.76,100.34 64.51,100.21 64.65,100.3 64.72,100.69 64.62,100.83 63.87,100.96 63.63,101.3 63.83,102.41 64.42,103.26 64.83,103.33 66.21,102.36 66.38,102.39 66.6,102.71 66.57,102.88 65.19,103.85 65.12,104.25 65.59,104.93 67.5,107.66 71.17,110.23 87.61,113.13 133.73,105 140.08,106.12 148.9,104.56 175.61,99.85 246.47,112.38 246.76,112.4 263.91,109.38 265.4,108.34 265.77,107.8 265.77,107.3 v1(266.14,106.93)
  BOTTOM w0.135: U1.AN30 v4(65.36,94.13) ; C50.1 265.79,105.78 265.79,106.58 v1(266.14,106.93)
PE_SLOT4_TX_C_DP<4>: length 212.8
  IN1 w0.089: 68.72,99.22 68.72,99.2 68.77,99.15 68.77,97.87 69.08,97.56 69.25,97.56 69.36,97.45 v4(69.36,97.13)
  IN1 w0.122: v1(262.36,106.93) 261.99,107.3 261.99,107.82 261.55,108.45 260.62,109.1 246.64,111.68 246.47,111.65 175.6,99.15 148.9,103.86 139.94,105.44 133.59,104.32 87.55,112.44 71.79,109.66 69.79,108.26 67.75,106.83 67.5,106.47 67.09,104.15 67.43,102.25 68.4,100.86 68.6,100.63 68.6,100.62 68.72,100.5 68.72,99.22
  BOTTOM w0.135: v1(262.36,106.93) 262,106.58 262,105.78 C127.1 ; U1.AJ33 v4(69.36,97.13)
PE_SLOT4_TX_C_DP<5>: length 211.1
  IN1 w0.089: 69.73,99.39 69.73,99.37 69.79,99.33 69.85,99.02 69.76,98.54 69.76,98.52 69.76,97.85 70.07,97.54 70.28,97.54 70.36,97.45 v4(70.36,97.13)
  IN1 w0.122: 69.73,99.39 69.72,99.44 69.06,103.16 69.46,105.44 70.53,106.96 73.78,109.24 74.93,109.44 75.27,109.2 75.31,108.99 75.45,108.89 75.83,108.95 75.93,109.09 75.89,109.31 76.13,109.65 76.75,109.76 77.09,109.52 77.12,109.31 77.26,109.21 77.65,109.27 77.74,109.42 77.71,109.63 77.94,109.97 78.56,110.08 78.9,109.85 78.94,109.63 79.08,109.53 79.46,109.59 79.56,109.74 79.52,109.95 79.76,110.29 80.38,110.4 80.72,110.17 80.76,109.95 80.9,109.85 81.28,109.92 81.38,110.06 81.34,110.28 81.58,110.61 82.2,110.72 82.54,110.49 82.57,110.27 82.72,110.17 83.1,110.24 83.2,110.38 83.16,110.6 83.4,110.94 84.01,111.04 84.35,110.81 84.39,110.59 84.53,110.49 84.91,110.56 85.01,110.7 84.97,110.92 85.21,111.26 85.83,111.37 86.17,111.13 86.21,110.91 86.35,110.81 86.73,110.88 86.83,111.02 86.79,111.24 87.03,111.58 87.79,111.71 133.49,103.65 139.84,104.77 148.9,103.17 175.62,98.46 245.97,110.89 256.45,109.04 257.52,108.29 257.92,107.72 257.92,107.3 v1(258.29,106.93)
  BOTTOM w0.135: U1.AH33 v4(70.36,97.13) ; v1(258.29,106.93) 257.94,106.58 257.94,105.78 C128.1
PE_SLOT4_TX_C_DP<6>: length 199.3
  IN1 w0.089: v4(71.36,97.13) 71.36,97.45 71.28,97.54 71.07,97.54 70.75,97.85 70.75,98.44 70.61,99.27 70.62,99.36 70.58,99.42 70.59,99.44
  IN1 w0.122: 70.59,99.44 70.59,99.44 70.67,99.93 70.76,100.42 70.6,101.32 71,103.57 70.95,103.87 71.2,105.32 71.68,106 72.15,106.67 73.87,107.95 89.57,110.72 133.43,102.99 139.78,104.11 148.9,102.5 175.6,97.79 245.59,110.14 252.82,108.87 253.51,108.39 253.94,107.77 253.94,107.3 v1(254.31,106.93)
  BOTTOM w0.135: C129.1 253.95,105.78 253.95,106.58 v1(254.31,106.93) ; U1.AG33 v4(71.36,97.13)
PE_SLOT4_TX_C_DP<7>: length 198.1
  IN1 w0.089: 71.65,99.44 71.65,99.42 71.69,99.36 71.65,99.11 71.77,98.43 71.77,97.84 72.07,97.54 72.28,97.54 72.36,97.45 v4(72.36,97.13)
  IN1 w0.122: 71.65,99.44 71.69,99.67 71.95,101.13 72.71,102.21 72.97,103.7 72.74,104.98 72.93,106.07 73.38,106.71 73.91,107.08 73.92,107.08 82.24,108.51 82.58,108.27 82.67,107.73 82.81,107.63 83.19,107.69 83.29,107.83 83.2,108.37 83.44,108.71 84.06,108.82 84.39,108.58 84.49,108.04 84.63,107.94 85.01,108.01 85.11,108.15 85.02,108.69 85.26,109.02 85.87,109.13 86.21,108.89 86.31,108.35 86.45,108.25 86.83,108.32 86.93,108.46 86.83,109 87.07,109.34 90.35,109.9 133.45,102.3 139.8,103.42 149.32,101.74 149.33,101.74 175.53,97.12 242,108.84 245.12,109.39 247.15,109.03 249.19,108.67 249.66,108.34 249.95,107.92 249.95,107.3 v1(250.32,106.93)
  BOTTOM w0.135: U1.AF33 v4(72.36,97.13) ; v1(250.32,106.93) 249.96,106.58 249.96,105.78 C130.1
PE_SLOT4_TX_C_DP<8>: length 195.6
  BOTTOM w0.089: U1.AE33 73.86,96.92 73.77,97.02 73.52,97.02 73.26,97.28 73.26,97.88 72.26,98.87 72.26,99.26 72.21,99.32 72.21,99.34
  BOTTOM w0.135: C131.1 243.99,105.78 243.99,106.17 243.88,106.84 243.15,107.87 235.75,113.06 v3(220.34,115.77) 218.33,116.13 206.34,114.01 194.31,105.59 179.7,102.67 176.53,103.31 173.35,102.67 170.18,103.31 167,102.67 163.69,103.33 160.95,102.79 140.03,106.97 136.01,106.26 133.72,106.67 128.42,110.38 104.21,114.65 103.99,114.65 103.99,114.65 103.86,114.65 101.07,114.16 94.18,115.37 79.6,112.8 72.34,107.72 71.25,106.17 70.95,104.43 71.36,102.09 72.04,101.12 72.21,100.15 72.21,99.34
PE_SLOT4_TX_C_DP<9>: length 193.4
  BOTTOM w0.089: 73.41,99.44 73.41,99.42 73.47,99.36 73.47,98.91 74.27,98.1 74.27,97.26 74.5,97.03 74.76,97.03 74.86,96.92 U1.AD33
  BOTTOM w0.135: 73.41,99.44 73.41,100.28 72.67,104.46 72.98,106.23 73.39,106.81 79.89,111.36 94.75,113.98 101.23,112.84 104.12,113.35 127.65,109.2 132.36,105.9 133.09,105.39 135.86,104.9 140.18,105.66 161.01,101.5 163.76,102.05 167,101.4 170.18,102.04 173.35,101.4 176.53,102.04 179.7,101.4 194.7,104.4 206.81,112.88 217.66,114.79 223.03,113.84 v3(225.29,113.44) 233.05,112.08 234.69,110.93 234.88,110.96 235.25,111.5 235.69,111.57 236.41,111.07 236.49,110.63 235.72,109.54 235.77,109.27 236.15,109 236.48,109.06 237.22,110.12 237.49,110.16 237.66,110.19 238.38,109.69 238.46,109.25 238.08,108.72 238.12,108.53 238.64,108.16 239.17,107.79 239.88,106.78 239.98,106.19 239.98,105.81 C132.1
PE_SLOT4_TX_C_DP<10>: length 180.7
  BOTTOM w0.089: 75.2,98.19 75.2,98.17 75.26,98.11 75.26,97.26 75.52,97 75.81,97 75.86,96.95 U1.AC33
  BOTTOM w0.135: C133.1 235.99,105.78 235.99,106.27 235.91,106.72 235.35,107.53 230.11,111.2 v3(218.35,113.27) 217.17,113.48 207.28,111.74 195.1,103.21 179.7,100.13 176.53,100.77 173.35,100.13 170.18,100.77 167,100.13 163.7,100.79 160.87,100.17 140.5,104.25 136.45,103.53 131.65,104.38 126.29,108.13 104.33,112 101.37,111.48 94.91,112.62 81.57,110.27 77.89,107.7 76.91,106.3 76.71,105.16 76.2,104.42 75.92,104.23 75.64,104.03 75.13,103.3 74.61,100.37 74.61,99.33 75.1,98.72 75.2,98.43 75.2,98.19
PE_SLOT4_TX_C_DP<11>: length 178.6
  BOTTOM w0.089: 76.22,98.27 76.22,98.25 76.28,98.19 76.28,97.29 76.51,97.05 76.76,97.05 76.86,96.95 U1.AB33
  BOTTOM w0.135: 76.22,98.27 76.22,98.74 75.87,99.27 75.86,99.28 75.81,99.36 75.81,100.16 76,101.25 76.8,102.38 76.98,103.45 77.46,104.14 78.33,104.74 78.64,105.19 78.86,106.44 79.26,107.02 81.88,108.85 95.34,111.23 101.29,110.17 104.47,110.73 125.38,107.06 131.1,103.05 136.07,102.17 140.5,102.95 160.88,98.88 163.83,99.47 167,98.83 170.18,99.47 173.35,98.83 176.53,99.47 179.7,98.83 195.44,101.98 207.75,110.6 v3(210.29,111.05) 216.58,112.16 227.01,110.32 227.26,109.96 227.13,109.21 227.24,109.05 227.86,108.94 228.02,109.05 228.15,109.8 228.51,110.05 228.92,109.98 228.98,109.97 230.34,109.02 230.67,108.55 230.59,108.11 229.82,107.58 229.79,107.39 230.15,106.87 230.34,106.84 231.11,107.38 231.54,107.3 231.84,106.88 231.98,106.09 231.98,105.78 C134.1
PE_SLOT4_TX_C_DP<12>: length 167.4
  BOTTOM w0.089: 77.2,98.35 77.2,98.32 77.26,98.27 77.26,97.35 77.6,97 77.8,97 77.86,96.94 U1.AA33
  BOTTOM w0.135: 77.2,98.35 77.2,98.61 77.13,99.14 77.09,99.27 77.05,99.44 77.01,99.62 77.01,99.87 77.15,100.63 78.71,102.87 78.81,103.38 79.06,103.74 79.92,104.35 81.25,106.24 83.31,107.69 95.68,109.87 101.28,108.88 104.57,109.46 124.54,105.94 128.76,102.98 131.94,100.76 135.05,100.21 141.8,101.4 160.75,97.61 163.83,98.23 167,97.59 170.18,98.23 173.35,97.59 176.53,98.23 179.7,97.59 195.89,100.83 208.22,109.46 216.04,110.84 v3(217.51,110.58) 224.6,109.33 227.43,107.35 227.9,106.68 227.99,106.14 227.99,105.78 C135.1
PE_SLOT4_TX_C_DP<13>: length 165.1
  BOTTOM w0.089: 78.21,98.45 78.21,98.42 78.27,98.37 78.27,97.33 78.58,97.03 78.77,97.03 78.86,96.93 U1.Y33
  BOTTOM w0.135: 78.21,98.45 78.21,98.94 78.35,99.08 78.35,99.64 78.5,100.46 79.47,101.85 80.5,102.57 80.66,102.8 80.78,103.48 81.21,104.1 81.92,104.6 82.82,105.88 83.36,106.26 96.22,108.52 101.2,107.65 104.55,108.23 123.37,104.91 130.78,99.73 135.06,98.98 141.8,100.16 160.83,96.35 163.83,96.96 165.48,96.63 167,96.32 170.18,96.96 173.35,96.32 176.53,96.96 179.7,96.32 196.28,99.64 208.68,108.32 v3(210.53,108.64) 215.41,109.5 220.51,108.61 221.49,108.43 221.83,108.2 221.91,107.76 221.11,106.62 221.2,106.1 221.45,105.92 221.75,105.98 222.86,107.56 223.28,107.63 223.4,107.65 223.92,107.29 223.98,106.96 223.98,105.78 C136.1
PE_SLOT4_TX_C_DP<14>: length 154.5
  BOTTOM w0.089: U1.W33 79.86,96.92 79.75,97.04 79.56,97.04 79.26,97.34 79.26,98.33 79.75,98.81 79.75,98.93 79.69,98.98 79.69,99.01
  BOTTOM w0.135: C137.1 219.97,105.78 219.97,106.16 219.9,106.57 219.6,106.99 218.94,107.45 214.94,108.16 209.07,107.12 v3(205.48,104.6) 196.68,98.44 179.7,95.05 176.53,95.69 173.35,95.05 170.18,95.69 167,95.05 163.83,95.69 160.64,95.05 141.8,98.81 135.06,97.63 129.68,98.7 127.95,99.91 122.27,103.89 104.54,107.01 101.2,106.42 96.73,107.21 87.07,105.51 87.07,105.51 84.97,105.14 82.95,103.73 82.54,103.15 82.48,102.78 82.08,102.21 80.34,100.99 79.81,100.24 79.69,99.54 79.69,99.01
PE_SLOT4_TX_C_DP<15>: length 156.2
  BOTTOM w0.089: 80.91,99.02 80.91,99 80.97,98.94 80.97,98.82 80.28,98.12 80.28,97.33 80.58,97.03 80.75,97.03 80.86,96.91 U1.V33
  BOTTOM w0.135: C138.1 216,105.78 216,106.3 215.81,106.56 215.59,106.79 214.86,106.92 209.9,106.05 209.02,105.43 208.94,104.99 209.63,104.01 209.6,103.82 209.08,103.46 208.89,103.49 208.2,104.48 207.77,104.55 207.05,104.05 206.97,103.61 207.66,102.63 207.63,102.44 207.11,102.08 206.92,102.11 206.23,103.1 205.8,103.18 205.08,102.67 205,102.23 205.69,101.25 205.66,101.06 205.14,100.7 204.95,100.74 204.26,101.72 203.83,101.8 v3(201.17,99.93) 199.25,98.59 197.39,97.29 179.7,93.75 176.53,94.39 173.35,93.75 170.18,94.39 167,93.75 163.83,94.39 160.62,93.75 141.8,97.51 135.06,96.32 128.56,97.62 121.05,102.88 104.54,105.79 102.73,105.47 102.73,105.47 101.02,105.17 97.22,105.84 94.82,105.42 88.18,104.25 86.71,103.99 81.2,100.13 80.98,99.82 80.92,99.44 80.91,99.43 80.91,99.02
PE_SLOT4_TX_DN<0>: length 9
  BOTTOM w0.135: C51.2 275.39,104.27 275.39,103.84 275.97,103.26 279.45,101.76 279.6,101.62 279.68,101.47 279.68,101.47 279.68,100.01 279.97,99.72 280.14,99.64 280.2,99.46 J4.B15
PE_SLOT4_TX_DN<1>: length 7.8
  BOTTOM w0.135: C52.2 272.59,104.27 272.59,103.81 272.87,103.52 272.86,103.3 273.14,103.01 273.36,103 273.67,102.67 274.02,102.47 274.08,102.27 274.44,102.07 274.65,102.13 275.49,101.67 275.67,101.39 275.67,100.14 275.51,99.97 275.38,99.91 275.2,99.97 J4.B20
PE_SLOT4_TX_DN<2>: length 7.5
  BOTTOM w0.135: J4.B24 271.2,99.97 271.38,99.91 271.51,99.97 271.65,100.12 271.65,101.53 271.49,101.78 270.91,102.1 270.7,102.04 270.35,102.23 270.29,102.44 269.93,102.63 269.69,102.97 269.48,103 269.24,103.33 269.28,103.54 269.04,103.87 269.04,104.27 C53.2
PE_SLOT4_TX_DN<3>: length 7.1
  BOTTOM w0.135: J4.B28 267.2,99.97 267.38,99.91 267.51,99.97 267.69,100.16 267.69,101.2 266.88,102.21 266.66,102.24 266.41,102.55 266.43,102.77 266.18,103.08 265.96,103.11 265.71,103.42 265.74,103.64 265.48,103.95 265.48,104.27 C54.2
PE_SLOT4_TX_DN<4>: length 6.3
  BOTTOM w0.135: J4.B34 261.2,99.97 261.38,99.91 261.51,99.97 261.7,100.17 261.7,102.05 261.54,102.2 261.54,102.6 261.7,102.76 261.7,103.16 261.54,103.31 261.54,103.72 261.7,103.87 261.7,104.27 C139.2
PE_SLOT4_TX_DN<5>: length 6.3
  BOTTOM w0.135: C140.2 257.63,104.27 257.63,103.87 257.48,103.72 257.48,103.31 257.63,103.16 257.63,102.76 257.48,102.6 257.48,102.2 257.63,102.05 257.63,100.1 257.51,99.97 257.38,99.91 257.2,99.97 J4.B38
PE_SLOT4_TX_DN<6>: length 6.3
  BOTTOM w0.135: J4.B42 253.2,99.97 253.38,99.91 253.55,100 253.65,100.09 253.65,102.05 253.49,102.2 253.49,102.6 253.65,102.76 253.65,103.16 253.49,103.31 253.49,103.72 253.65,103.87 253.65,104.27 C141.2
PE_SLOT4_TX_DN<7>: length 6.3
  BOTTOM w0.135: C142.2 249.66,104.27 249.66,103.87 249.51,103.72 249.51,103.31 249.66,103.16 249.66,102.76 249.51,102.6 249.51,102.2 249.66,102.05 249.66,100.13 249.51,99.97 249.38,99.91 249.2,99.97 J4.B46
PE_SLOT4_TX_DN<8>: length 6.4
  BOTTOM w0.135: J4.B51 244.2,99.46 244.14,99.64 243.92,99.75 243.69,99.98 243.69,104.27 C143.2
PE_SLOT4_TX_DN<9>: length 6.4
  BOTTOM w0.135: C144.2 239.69,104.29 239.69,99.98 239.92,99.75 240.14,99.64 240.2,99.46 J4.B55
PE_SLOT4_TX_DN<10>: length 6.4
  BOTTOM w0.135: J4.B59 236.2,99.46 236.14,99.64 235.92,99.75 235.69,99.98 235.69,104.27 C145.2
PE_SLOT4_TX_DN<11>: length 6.4
  BOTTOM w0.135: J4.B63 232.2,99.46 232.14,99.64 231.92,99.75 231.69,99.98 231.69,104.26 C146.2
PE_SLOT4_TX_DN<12>: length 6.4
  BOTTOM w0.135: C147.2 227.69,104.27 227.69,99.98 227.92,99.75 228.14,99.64 228.2,99.46 J4.B67
PE_SLOT4_TX_DN<13>: length 6.4
  BOTTOM w0.135: C148.2 223.69,104.26 223.69,99.98 223.92,99.75 224.14,99.64 224.2,99.46 J4.B71
PE_SLOT4_TX_DN<14>: length 6.4
  BOTTOM w0.135: J4.B75 220.2,99.46 220.14,99.64 219.92,99.75 219.69,99.98 219.69,104.25 C149.2
PE_SLOT4_TX_DN<15>: length 6.4
  BOTTOM w0.135: J4.B79 216.2,99.46 216.14,99.64 216.12,99.65 215.92,99.75 215.69,99.98 215.69,104.28 C150.2
PE_SLOT4_TX_DP<0>: length 8.9
  BOTTOM w0.135: J4.B14 280.46,99.97 280.28,99.91 280.15,99.97 279.99,100.14 279.99,101.55 279.85,101.81 279.62,102.02 278.2,102.63 278.12,102.83 277.75,102.99 277.55,102.91 277.18,103.07 277.1,103.27 276.73,103.43 276.52,103.35 276.14,103.52 275.69,103.97 275.69,104.27 C47.2
PE_SLOT4_TX_DP<1>: length 7.9
  BOTTOM w0.135: J4.B19 275.46,99.46 275.52,99.64 275.69,99.72 275.97,100.01 275.97,101.48 275.7,101.9 273.86,102.91 272.9,103.93 272.9,104.27 C48.2
PE_SLOT4_TX_DP<2>: length 7.6
  BOTTOM w0.135: C49.2 269.34,104.27 269.34,103.97 270.14,102.87 271.7,102.01 271.96,101.63 271.96,100 271.69,99.72 271.52,99.64 271.46,99.46 J4.B23
PE_SLOT4_TX_DP<3>: length 7.2
  BOTTOM w0.135: J4.B27 267.46,99.46 267.52,99.64 267.69,99.72 268,100.03 268,101.3 267.04,102.5 267.03,102.5 265.79,104.06 265.79,104.27 C50.2
PE_SLOT4_TX_DP<4>: length 6.4
  BOTTOM w0.135: C127.2 262,104.27 262,100.04 261.69,99.72 261.52,99.64 261.46,99.46 J4.B33
PE_SLOT4_TX_DP<5>: length 6.4
  BOTTOM w0.135: C128.2 257.94,104.27 257.94,99.98 257.69,99.72 257.52,99.64 257.46,99.46 J4.B37
PE_SLOT4_TX_DP<6>: length 6.4
  BOTTOM w0.135: C129.2 253.95,104.27 253.95,99.96 253.73,99.75 253.52,99.64 253.46,99.46 J4.B41
PE_SLOT4_TX_DP<7>: length 6.4
  BOTTOM w0.135: J4.B45 249.46,99.46 249.52,99.64 249.69,99.72 249.96,100 249.96,104.27 C130.2
PE_SLOT4_TX_DP<8>: length 6.3
  BOTTOM w0.135: J4.B50 244.46,99.97 244.28,99.91 244.11,100 243.99,100.11 243.99,102.04 244.15,102.2 244.15,102.6 243.99,102.75 243.99,103.16 244.15,103.31 244.15,103.72 243.99,103.87 243.99,104.27 C131.2
PE_SLOT4_TX_DP<9>: length 6.3
  BOTTOM w0.135: C132.2 239.99,104.26 239.99,103.91 240.15,103.75 240.15,103.35 239.99,103.2 239.99,102.79 240.15,102.64 240.15,102.24 239.99,102.08 239.99,100.11 240.11,100 240.28,99.91 240.46,99.97 J4.B54
PE_SLOT4_TX_DP<10>: length 6.3
  BOTTOM w0.135: C133.2 235.99,104.27 235.99,103.87 236.15,103.72 236.15,103.31 235.99,103.16 235.99,102.76 236.15,102.6 236.15,102.2 235.99,102.05 235.99,100.11 236.11,100 236.28,99.91 236.46,99.97 J4.B58
PE_SLOT4_TX_DP<11>: length 6.3
  BOTTOM w0.135: J4.B62 232.46,99.97 232.28,99.91 232.11,100 231.99,100.11 231.99,102.06 232.15,102.21 232.15,102.62 231.99,102.77 231.99,103.17 232.15,103.33 232.15,103.73 231.99,103.88 231.99,104.29 C134.2
PE_SLOT4_TX_DP<12>: length 6.3
  BOTTOM w0.135: J4.B66 228.46,99.97 228.28,99.91 228.11,100 227.99,100.11 227.99,102.05 228.15,102.2 228.15,102.6 227.99,102.76 227.99,103.16 228.15,103.31 228.15,103.72 227.99,103.87 227.99,104.27 C135.2
PE_SLOT4_TX_DP<13>: length 6.3
  BOTTOM w0.135: J4.B70 224.46,99.97 224.28,99.91 224.11,100 223.99,100.11 223.99,102.06 224.15,102.21 224.15,102.62 223.99,102.77 223.99,103.17 224.15,103.33 224.15,103.73 223.99,103.88 223.99,104.29 C136.2
PE_SLOT4_TX_DP<14>: length 6.3
  BOTTOM w0.135: J4.B74 220.46,99.97 220.28,99.91 220.11,100 219.99,100.11 219.99,102.07 220.15,102.23 220.15,102.63 219.99,102.78 219.99,103.19 220.15,103.34 220.15,103.74 219.99,103.9 219.99,104.3 C137.2
PE_SLOT4_TX_DP<15>: length 6.3
  BOTTOM w0.135: C138.2 215.99,104.26 215.99,103.86 216.15,103.71 216.15,103.3 215.99,103.15 215.99,102.75 216.15,102.59 216.15,102.19 215.99,102.04 215.99,100.11 216.1,100 216.28,99.91 216.46,99.97 J4.B78
PE_SLV_RX_DN<0>: length 68.5
  IN1 w0.089: 63.81,73.76 63.83,73.76 63.88,73.71 67.56,73.71 67.72,73.86 67.72,74.04 67.63,74.13 v4(67.36,74.13)
  IN1 w0.122: 63.81,73.76 63.15,73.76 62.79,73.7 62.4,73.43 57.89,66.98 42.04,55.88 39.89,54.23 39.86,54.21 38.3,52.61 38.31,52.63 33.43,45.65 23.05,38.38 22.83,38.42 22.53,38.21 22.5,38 22.2,37.79 21.98,37.82 21.68,37.62 21.65,37.4 21.28,37.15 20.34,36.98 19.99,36.98 v1(19.76,37.21)
  BOTTOM w0.135: U1.AL11 v4(67.36,74.13) ; J7.48 16.51,38.13 16.66,37.98 17.17,37.98 18.9,36.98 19.53,36.98 v1(19.76,37.21)
PE_SLV_RX_DN<1>: length 67.6
  IN1 w0.089: v4(67.36,75.13) 67.65,75.13 67.74,75.04 67.74,74.89 67.59,74.73 63.84,74.73 63.79,74.79 63.77,74.79
  IN1 w0.122: 63.77,74.79 63.17,74.79 63.14,74.78 62.59,74.68 61.95,74.23 57.23,67.49 40.42,55.73 38.85,54.43 37.75,53.2 32.97,46.37 28.01,42.9 25.88,42.52 25.7,42.65 25.34,42.59 25.22,42.41 24.86,42.34 24.68,42.47 24.32,42.41 24.2,42.23 23.84,42.16 23.66,42.29 23.3,42.23 23.17,42.05 22.36,41.9 21.27,41.9 v1(21.03,42.14)
  BOTTOM w0.135: J7.45 16.54,39.92 16.69,39.78 16.94,39.78 17.37,39.97 19.94,41.75 20.46,41.91 20.8,41.91 v1(21.03,42.14) ; U1.AL12 v4(67.36,75.13)
PE_SLV_RX_DN<2>: length 67.1
  IN1 w0.089: 63.73,75.78 63.75,75.78 63.8,75.73 67.58,75.73 67.73,75.88 67.73,76.01 67.61,76.13 v4(67.36,76.13)
  IN1 w0.122: v1(24.46,44.58) 24.72,44.32 25.34,44.32 29.55,45.06 32.16,46.89 34.05,49.6 34.02,49.81 34.23,50.11 34.44,50.15 34.65,50.45 34.61,50.66 34.82,50.96 35.04,51 36.3,52.8 36.69,53.35 37.96,54.75 39.32,55.92 56.66,68.06 61.41,74.85 62.63,75.7 63.09,75.78 63.73,75.78
  BOTTOM w0.135: v1(24.46,44.58) 24.21,44.32 23.36,44.32 v3(20.74,43.78) 20.09,43.64 17.74,41.88 17.02,41.58 16.64,41.58 16.49,41.73 J7.42 ; U1.AL13 v4(67.36,76.13)
PE_SLV_RX_DN<3>: length 69.3
  IN1 w0.089: v4(67.36,77.13) 67.65,77.13 67.74,77.04 67.74,76.89 67.59,76.74 63.98,76.74 63.92,76.79 63.9,76.79
  IN1 w0.122: 63.9,76.79 63.16,76.79 62.67,76.7 60.82,75.41 56.08,68.64 41.84,58.67 35.28,54.89 33.8,54.31 31.7,53.94 30.79,54.1 30.66,54.28 30.3,54.34 30.13,54.22 29.77,54.28 29.64,54.46 29.28,54.52 29.1,54.4 28.74,54.46 28.62,54.64 28.26,54.7 28.08,54.58 27.41,54.7 25.69,54.39 23.77,53.05 22.92,51.83 22.57,49.85 22.85,48.24 22.54,46.5 22.42,46.32 22.14,46.13 21.79,46.07 21.62,46.07 v1(21.39,46.3)
  BOTTOM w0.135: J7.39 16.52,43.52 16.67,43.38 16.94,43.38 17.87,43.83 20.11,45.77 20.7,46.08 21.16,46.08 v1(21.39,46.3) ; U1.AL14 v4(67.36,77.13)
PE_SLV_RX_DN<4>: length 66.6
  IN1 w0.089: 63.83,77.78 63.85,77.78 63.9,77.73 67.56,77.73 67.73,77.9 67.73,78.04 67.64,78.13 v4(67.36,78.13)
  IN1 w0.122: v1(32.72,55.88) 32.96,55.64 33.33,55.64 35.65,56.05 36.03,56.31 36.07,56.53 36.37,56.74 36.58,56.7 36.88,56.91 36.92,57.12 37.22,57.33 37.43,57.29 37.73,57.5 37.77,57.72 38.07,57.93 38.28,57.89 38.49,58.03 39.01,58.32 39.28,58.43 41.43,59.35 55.42,69.15 60.19,75.96 62.68,77.71 63,77.76 63.11,77.78 63.83,77.78
  BOTTOM w0.135: v1(32.72,55.88) 32.49,55.65 30.28,55.65 25.43,54.79 23.98,53.78 18.57,46.05 17.41,45.24 17.08,45.18 16.67,45.18 16.53,45.33 J7.36 ; U1.AL15 v4(67.36,78.13)
PE_SLV_RX_DN<5>: length 66.3
  IN1 w0.089: v4(67.36,79.13) 67.63,79.13 67.74,79.02 67.74,78.88 67.59,78.73 63.75,78.73 63.7,78.78 63.68,78.78
  IN1 w0.122: v1(34.75,57.78) 34.99,57.54 35.43,57.54 36.69,57.76 37.15,58.09 37.19,58.3 37.49,58.51 37.7,58.48 38,58.69 38.04,58.9 38.34,59.11 38.55,59.07 38.85,59.28 38.89,59.49 39.19,59.7 39.4,59.67 39.56,59.78 39.6,59.8 40.09,60.03 40.23,60.09 40.74,60.27 41.87,60.63 54.74,69.64 59.52,76.47 62.72,78.71 63.11,78.78 63.68,78.78
  BOTTOM w0.135: v4(67.36,79.13) U1.AL16 ; v1(34.75,57.78) 34.52,57.56 32.61,57.56 v3(30.97,57.27) 28.91,56.9 25.16,56.24 23.22,54.89 18.02,47.46 17.47,47.07 16.92,46.98 16.65,46.98 16.5,47.13 J7.33
PE_SLV_RX_DN<6>: length 65.7
  IN1 w0.089: v4(67.36,80.13) 67.62,80.13 67.74,80.01 67.74,79.89 67.58,79.73 63.91,79.73 63.86,79.78 63.84,79.78
  IN1 w0.122: v1(36.65,59.69) 36.86,59.49 37.22,59.49 37.45,59.53 37.86,59.81 37.9,60.03 38.2,60.24 38.41,60.2 38.71,60.41 38.75,60.62 39.05,60.83 39.26,60.79 39.56,61 39.6,61.22 39.9,61.43 40.11,61.39 40.38,61.58 40.44,61.62 40.83,61.82 40.85,61.83 43.54,62.96 54.42,70.58 58.97,77.08 62.73,79.71 63.14,79.78 63.84,79.78
  BOTTOM w0.135: U1.AL17 v4(67.36,80.13) ; v1(36.65,59.69) 36.43,59.46 34.6,59.46 28.95,58.46 28.95,58.47 v3(27.14,58.14) 25.27,57.82 22.36,55.78 17.65,49.05 17.37,48.85 16.94,48.78 16.65,48.78 16.51,48.92 J7.30
PE_SLV_RX_DN<7>: length 65.5
  IN1 w0.089: v4(67.36,82.13) 67.6,82.13 67.73,82 67.73,81.77 67.5,81.53 67.18,81.53 67.13,81.58 67.11,81.58
  IN1 w0.122: v1(30.86,62.89) 31.1,62.66 31.37,62.66 32.05,62.78 32.18,62.95 32.54,63.02 32.72,62.89 33.08,62.96 33.2,63.13 33.56,63.2 33.74,63.07 34.57,63.22 35.12,63.61 35.16,63.82 35.46,64.03 35.67,63.99 35.85,64.12 36.11,64.3 38.86,65.26 38.89,65.26 44.19,65.93 48.07,67.29 51.08,69.39 54.08,71.5 58.38,77.63 63.12,80.95 63.13,80.96 63.19,80.97 63.2,80.97 66.69,81.58 67.11,81.58
  BOTTOM w0.135: v4(67.36,82.13) U1.AL18 ; v1(30.86,62.89) 30.63,62.66 29.75,62.66 v3(27.3,60.94) 25.68,59.81 21.79,57.09 17.33,50.71 17.21,50.63 16.92,50.58 16.68,50.58 16.54,50.73 J7.27
PE_SLV_RX_DN<8>: length 60.6
  IN1 w0.089: 63.86,82.78 63.88,82.78 63.93,82.72 67.64,82.72 67.83,82.91 67.83,83.02 67.72,83.13 v4(67.36,83.13)
  IN1 w0.122: v1(18.98,60.76) 19.18,60.55 19.75,60.55 24.06,61.31 24.18,61.49 24.54,61.55 24.72,61.43 25.08,61.49 25.2,61.67 25.56,61.73 25.74,61.61 26.16,61.68 30.11,64.45 30.12,64.45 32.78,65.74 44.11,68.43 44.29,68.55 52.4,73.09 56.94,78.27 56.93,78.26 59.23,80.4 59.26,80.43 62.48,82.68 63.05,82.78 63.86,82.78
  BOTTOM w0.135: v1(18.98,60.76) 18.75,60.53 16.79,60.53 16.64,60.67 J8.72 ; U1.AL19 v4(67.36,83.13)
PE_SLV_RX_DN<9>: length 60.4
  IN1 w0.089: v4(67.36,84.13) 67.68,84.13 67.77,84.04 67.77,83.92 67.58,83.72 63.84,83.72 63.79,83.78 63.77,83.78
  IN1 w0.122: 63.77,83.78 63.07,83.78 62.47,83.67 58.41,80.83 58.39,80.81 56.59,79.29 56.67,79.37 51.51,74.23 44.35,69.85 41.75,68.92 32.29,67.25 28.37,64.51 28.01,64.44 27.83,64.57 27.47,64.5 27.35,64.33 23.57,63.66 22.25,63.89 21.66,63.89 v1(21.41,64.14)
  BOTTOM w0.135: J8.69 16.55,62.47 16.7,62.32 17.45,62.32 18.33,62.48 20.24,63.81 20.75,63.9 20.76,63.91 21.19,63.91 v1(21.41,64.14) ; U1.AL20 v4(67.36,84.13)
PE_SLV_RX_DN<10>: length 59.5
  IN1 w0.089: 63.72,84.78 63.75,84.78 63.8,84.73 67.58,84.73 67.77,84.92 67.77,85.04 67.68,85.13 v4(67.36,85.13)
  IN1 w0.122: v1(23.32,65.66) 23.55,65.43 23.84,65.43 24.54,65.31 25.07,65.4 25.19,65.58 25.55,65.64 25.73,65.52 26.21,65.6 26.33,65.78 26.69,65.84 26.87,65.72 27.23,65.78 27.35,65.96 27.71,66.02 27.89,65.9 28.6,66.02 31.46,68.02 32.2,68.15 46.61,73.58 62.47,84.67 63.07,84.78 63.72,84.78
  BOTTOM w0.135: U1.AL21 v4(67.36,85.13) ; J8.66 16.47,64.27 16.62,64.13 17.23,64.13 18.82,64.41 20.32,65.46 21.44,65.65 22.71,65.43 23.09,65.43 v1(23.32,65.66)
PE_SLV_RX_DN<11>: length 59.1
  IN1 w0.089: v4(67.36,86.13) 67.68,86.13 67.77,86.04 67.77,85.92 67.58,85.73 63.95,85.73 63.9,85.78 63.88,85.78
  IN1 w0.122: 63.88,85.78 63.05,85.78 62.51,85.68 46.35,74.37 31.22,68.88 30.23,68.7 29.78,68.39 29.57,68.43 29.27,68.22 29.23,68 28.93,67.79 28.72,67.83 28.42,67.62 28.38,67.41 28.08,67.2 25.91,66.81 25.47,66.81 v1(25.22,67.06)
  BOTTOM w0.135: J8.63 16.5,66.07 16.65,65.93 18.9,65.93 19.86,66.6 22.79,67.12 24.43,66.83 25,66.83 v1(25.22,67.06) ; U1.AL22 v4(67.36,86.13)
PE_SLV_RX_DN<12>: length 58.5
  IN1 w0.089: v4(67.36,87.13) 67.68,87.13 67.77,87.04 67.77,86.92 67.58,86.73 63.91,86.73 63.86,86.78 63.84,86.78
  IN1 w0.122: 63.84,86.78 63.03,86.78 62.26,86.64 46.07,75.31 29.93,69.58 29.59,69.45 28.81,69.21 23.26,68.23 23.09,68.35 22.73,68.29 22.6,68.11 22.24,68.05 22.07,68.17 21.7,68.11 21.58,67.93 20.79,67.79 19.41,67.79 v1(19.13,68.07)
  BOTTOM w0.135: U1.AL23 v4(67.36,87.13) ; v1(19.13,68.07) 18.89,67.84 17.84,67.84 17.22,67.73 16.63,67.73 16.48,67.87 J8.60
PE_SLV_RX_DN<13>: length 58.7
  IN1 w0.089: v4(67.36,88.13) 67.68,88.13 67.77,88.04 67.77,87.92 67.59,87.73 63.74,87.73 63.69,87.78 63.67,87.78
  IN1 w0.122: v1(20.86,69.75) 21.11,69.49 21.67,69.49 24.15,69.06 24.51,69.12 24.63,69.3 24.99,69.36 25.17,69.24 25.53,69.3 25.65,69.48 26.01,69.54 26.19,69.42 26.55,69.48 26.67,69.66 27.03,69.72 27.21,69.6 27.68,69.68 27.9,69.71 28.25,69.86 28.7,70.02 45.8,76.09 62.32,87.65 63.06,87.78 63.67,87.78
  BOTTOM w0.135: v1(20.86,69.75) 20.63,69.53 16.61,69.53 16.46,69.67 J8.57 ; U1.AL24 v4(67.36,88.13)
PE_SLV_RX_DN<14>: length 58.5
  IN1 w0.089: 63.66,88.77 63.68,88.77 63.73,88.72 67.57,88.72 67.77,88.92 67.77,89.04 67.68,89.13 v4(67.36,89.13)
  IN1 w0.122: 63.66,88.77 63.05,88.77 62.35,88.65 45.69,76.98 29.08,71.24 27.93,70.94 27.35,71.04 27.23,71.22 26.87,71.28 26.69,71.16 26.22,71.24 25.29,71.08 25.11,71.2 24.75,71.14 24.63,70.96 24.18,70.89 23.3,70.89 v1(23.06,71.12)
  BOTTOM w0.135: v1(23.06,71.12) 22.84,70.89 21.91,70.89 19.43,71.33 16.61,71.33 16.46,71.47 J8.54 ; U1.AL25 v4(67.36,89.13)
PE_SLV_RX_DN<15>: length 58.2
  IN1 w0.089: v4(67.36,90.13) 67.68,90.13 67.77,90.04 67.77,89.92 67.58,89.72 63.89,89.72 63.84,89.77 63.82,89.77
  IN1 w0.122: 63.82,89.77 63.05,89.77 62.41,89.66 45.04,77.5 25.26,73.22 23.64,72.94 22.36,73.17 22.23,73.35 21.87,73.41 21.7,73.29 21.34,73.35 21.21,73.53 20.85,73.59 20.67,73.47 20.04,73.58 19.52,73.58 v1(19.28,73.81)
  BOTTOM w0.135: J8.51 16.49,73.27 16.64,73.13 17.61,73.13 18.7,73.58 19.05,73.58 v1(19.28,73.81) ; U1.AL26 v4(67.36,90.13)
PE_SLV_RX_DP<0>: length 68.6
  IN1 w0.089: 63.81,73.47 63.83,73.47 63.88,73.52 67.64,73.52 67.91,73.79 67.91,74.02 68.02,74.13 v4(68.36,74.13)
  IN1 w0.122: v1(19.76,36.45) 20,36.69 20.37,36.69 21.4,36.87 33.64,45.44 38.51,52.4 40.07,54 42.21,55.65 58.1,66.77 62.61,73.22 62.9,73.42 63.17,73.47 63.81,73.47
  BOTTOM w0.135: U1.AK11 v4(68.36,74.13) ; v1(19.76,36.45) 19.53,36.68 18.82,36.68 17.09,37.67 16.64,37.67 16.5,37.52 J7.49
PE_SLV_RX_DP<1>: length 67.6
  IN1 w0.089: 63.77,74.49 63.79,74.49 63.84,74.54 67.67,74.54 67.93,74.81 67.93,75.02 68.05,75.13 v4(68.36,75.13)
  IN1 w0.122: 63.77,74.49 63.2,74.49 63.19,74.49 62.71,74.41 62.16,74.02 57.44,67.28 40.6,55.49 39.06,54.22 37.98,53.02 33.18,46.16 28.13,42.62 25.93,42.24 25.93,42.24 22.38,41.61 21.27,41.61 v1(21.03,41.38)
  BOTTOM w0.135: J7.46 16.54,39.33 16.69,39.47 17.01,39.47 17.52,39.71 20.07,41.47 20.51,41.61 20.8,41.61 v1(21.03,41.38) ; U1.AK12 v4(68.36,75.13)
PE_SLV_RX_DP<2>: length 67.2
  IN1 w0.089: 63.73,75.49 63.75,75.49 63.8,75.54 67.66,75.54 67.92,75.8 67.92,76 68.05,76.13 v4(68.36,76.13)
  IN1 w0.122: 63.73,75.49 63.12,75.49 62.74,75.42 61.62,74.64 56.87,67.85 39.5,55.69 38.17,54.54 36.9,53.15 35.21,50.74 35.2,50.73 34.36,49.53 34.36,49.53 32.37,46.68 29.66,44.79 25.37,44.03 24.68,44.03 v1(24.46,43.81)
  BOTTOM w0.135: v1(24.46,43.81) 24.26,44.02 23.4,44.02 v3(22.25,43.78) 20.22,43.36 17.89,41.61 17.08,41.27 16.66,41.27 16.51,41.13 J7.43 ; U1.AK13 v4(68.36,76.13)
PE_SLV_RX_DP<3>: length 69.3
  IN1 w0.089: v4(68.36,77.13) 68.05,77.13 67.93,77.02 67.93,76.81 67.67,76.55 63.98,76.55 63.92,76.5 63.9,76.5
  IN1 w0.122: 63.9,76.5 63.19,76.5 62.79,76.43 62.79,76.43 61.03,75.2 56.29,68.43 42.38,58.69 42,58.42 35.42,54.64 35.38,54.62 33.9,54.04 33.8,54.01 31.7,53.64 27.41,54.4 26.61,54.26 25.8,54.12 23.98,52.84 23.19,51.71 22.86,49.85 23.15,48.24 22.82,46.39 22.63,46.11 22.26,45.85 21.82,45.78 21.62,45.78 v1(21.39,45.54)
  BOTTOM w0.135: v1(21.39,45.54) 21.16,45.77 20.77,45.77 20.28,45.52 18.04,43.57 17.01,43.07 16.66,43.07 16.51,42.92 J7.40 ; U1.AK14 v4(68.36,77.13)
PE_SLV_RX_DP<4>: length 66.6
  IN1 w0.089: 63.83,77.49 63.85,77.49 63.9,77.54 67.64,77.54 67.92,77.82 67.92,78.03 68.02,78.13 v4(68.36,78.13)
  IN1 w0.122: v1(32.72,55.12) 32.95,55.35 33.35,55.35 35.77,55.77 38.61,57.76 38.63,57.78 39.15,58.06 39.4,58.16 41.57,59.1 55.63,68.94 57.18,71.16 60.4,75.75 62.8,77.43 62.96,77.46 63.14,77.49 63.83,77.49
  BOTTOM w0.135: v4(68.36,78.13) U1.AK15 ; v1(32.72,55.12) 32.49,55.35 30.31,55.35 25.55,54.51 24.2,53.56 18.79,45.83 17.52,44.95 17.1,44.87 16.68,44.87 16.53,44.73 J7.37
PE_SLV_RX_DP<5>: length 66.3
  IN1 w0.089: v4(68.36,79.13) 68.05,79.13 67.93,79.02 67.93,78.8 67.67,78.54 63.75,78.54 63.7,78.49 63.68,78.49
  IN1 w0.122: 63.68,78.49 63.13,78.49 62.98,78.46 62.83,78.43 59.73,76.26 54.95,69.43 42.38,60.63 42,60.37 40.84,59.99 40.21,59.77 39.73,59.54 36.8,57.49 35.46,57.25 34.98,57.25 v1(34.75,57.02)
  BOTTOM w0.135: v1(34.75,57.02) 34.52,57.25 v3(33.19,57.25) 32.64,57.25 31.02,56.97 25.28,55.96 23.44,54.67 18.24,47.25 17.59,46.78 16.95,46.67 16.65,46.67 16.5,46.52 J7.34 ; U1.AK16 v4(68.36,79.13)
PE_SLV_RX_DP<6>: length 65.7
  IN1 w0.089: 63.84,79.49 63.86,79.49 63.91,79.54 67.66,79.54 67.93,79.81 67.93,80.02 68.05,80.13 v4(68.36,80.13)
  IN1 w0.122: v1(36.65,58.93) 36.92,59.19 37.24,59.19 37.57,59.25 40.57,61.36 40.97,61.56 43.68,62.7 54.63,70.37 59.18,76.87 62.85,79.43 63.16,79.49 63.84,79.49
  BOTTOM w0.135: v1(36.65,58.93) 36.43,59.16 34.62,59.16 v3(29.01,58.16) 27.19,57.84 25.39,57.53 22.58,55.56 17.87,48.83 17.49,48.57 16.96,48.47 16.65,48.47 16.5,48.33 J7.31 ; U1.AK17 v4(68.36,80.13)
PE_SLV_RX_DP<7>: length 65.5
  IN1 w0.089: v4(68.36,82.13) 68.05,82.13 67.92,82 67.92,81.69 67.58,81.34 67.18,81.34 67.13,81.29 67.11,81.29
  IN1 w0.122: 67.11,81.29 66.71,81.29 63.24,80.68 63.24,80.68 60.89,79.03 58.59,77.42 54.29,71.29 48.21,67.03 44.37,65.68 44.34,65.65 44.27,65.64 38.93,64.97 36.25,64.04 36.02,63.88 36.02,63.88 34.69,62.94 31.4,62.36 31.1,62.36 v1(30.86,62.13)
  BOTTOM w0.135: U1.AK18 v4(68.36,82.13) ; J7.28 16.55,50.13 16.7,50.27 16.95,50.27 17.33,50.34 17.55,50.49 22.01,56.87 v3(25.85,59.56) 27.47,60.69 29.85,62.36 30.63,62.36 v1(30.86,62.13)
PE_SLV_RX_DP<8>: length 60.5
  IN1 w0.089: 63.86,82.48 63.88,82.48 63.93,82.53 67.72,82.53 68.02,82.83 68.02,83.04 68.11,83.13 v4(68.36,83.13)
  IN1 w0.122: 63.86,82.48 63.08,82.48 63.08,82.48 62.6,82.4 59.43,80.19 57.13,78.04 52.59,72.86 44.43,68.29 44.17,68.15 32.88,65.46 30.25,64.19 26.28,61.41 19.77,60.26 19.24,60.26 v1(18.98,59.99)
  BOTTOM w0.135: U1.AK19 v4(68.36,83.13) ; v1(18.98,59.99) 18.75,60.22 16.71,60.22 16.57,60.07 J8.73
PE_SLV_RX_DP<9>: length 60.3
  IN1 w0.089: v4(68.36,84.13) 68.05,84.13 67.96,84.04 67.96,83.84 67.66,83.53 63.84,83.53 63.79,83.48 63.77,83.48
  IN1 w0.122: v1(21.41,63.37) 21.64,63.6 22.23,63.6 23.57,63.36 28.49,64.23 32.4,66.97 41.75,68.62 41.82,68.63 44.48,69.59 51.69,74 56.78,79.07 58.58,80.59 62.59,83.39 63.09,83.48 63.77,83.48
  BOTTOM w0.135: v1(21.41,63.37) 21.19,63.6 20.8,63.6 20.36,63.52 18.45,62.19 17.5,62.02 16.63,62.02 16.49,61.87 J8.70 ; U1.AK20 v4(68.36,84.13)
PE_SLV_RX_DP<10>: length 59.4
  IN1 w0.089: v4(68.36,85.13) 68.05,85.13 67.96,85.04 67.96,84.84 67.66,84.54 63.8,84.54 63.75,84.49 63.72,84.49
  IN1 w0.122: 63.72,84.49 63.1,84.49 62.58,84.4 46.73,73.3 32.27,67.87 31.57,67.75 28.72,65.75 24.54,65.01 23.81,65.14 23.56,65.14 v1(23.32,64.9)
  BOTTOM w0.135: v1(23.32,64.9) 23.09,65.13 22.68,65.13 21.44,65.34 20.44,65.17 18.94,64.12 17.26,63.82 16.66,63.82 16.51,63.67 J8.67 ; U1.AK21 v4(68.36,85.13)
PE_SLV_RX_DP<11>: length 59.2
  IN1 w0.089: v4(68.36,86.13) 68.05,86.13 67.96,86.04 67.96,85.84 67.66,85.54 63.95,85.54 63.9,85.48 63.88,85.48
  IN1 w0.122: v1(25.22,66.29) 25.45,66.52 25.93,66.52 28.19,66.92 30.35,68.43 31.3,68.6 46.46,74.09 62.62,85.4 63.07,85.48 63.88,85.48
  BOTTOM w0.135: v1(25.22,66.29) 25,66.52 24.4,66.52 22.79,66.81 19.98,66.31 18.99,65.62 16.63,65.62 16.48,65.47 J8.64 ; U1.AK22 v4(68.36,86.13)
PE_SLV_RX_DP<12>: length 58.6
  IN1 w0.089: 63.84,86.49 63.86,86.49 63.91,86.54 67.66,86.54 67.96,86.84 67.96,87.04 68.05,87.13 v4(68.36,87.13)
  IN1 w0.122: 63.84,86.49 63.05,86.49 63.05,86.48 62.37,86.37 46.19,75.03 29.7,69.18 29.68,69.18 28.9,68.93 28.86,68.92 20.84,67.5 20.82,67.5 19.32,67.5 v1(19.13,67.31)
  BOTTOM w0.135: v1(19.13,67.31) 18.91,67.53 17.87,67.53 17.24,67.42 16.62,67.42 16.48,67.27 J8.61 ; U1.AK23 v4(68.36,87.13)
PE_SLV_RX_DP<13>: length 58.7
  IN1 w0.089: 63.67,87.49 63.69,87.49 63.74,87.54 67.67,87.54 67.96,87.84 67.96,88.04 68.05,88.13 v4(68.36,88.13)
  IN1 w0.122: 63.67,87.49 63.08,87.49 62.43,87.38 45.91,75.81 28.36,69.59 28.01,69.44 27.73,69.39 24.15,68.76 21.64,69.2 21.07,69.2 v1(20.86,68.99)
  BOTTOM w0.135: v1(20.86,68.99) 20.62,69.22 16.62,69.22 16.47,69.07 J8.58 ; U1.AK24 v4(68.36,88.13)
PE_SLV_RX_DP<14>: length 58.6
  IN1 w0.089: v4(68.36,89.13) 68.05,89.13 67.96,89.04 67.96,88.84 67.65,88.53 63.73,88.53 63.68,88.48 63.66,88.48
  IN1 w0.122: 63.66,88.48 63.08,88.48 62.77,88.43 62.47,88.37 45.8,76.7 29.14,70.95 29.16,70.96 28,70.66 27.88,70.65 26.22,70.95 26.22,70.95 24.21,70.59 23.3,70.59 v1(23.06,70.36)
  BOTTOM w0.135: U1.AK25 v4(68.36,89.13) ; v1(23.06,70.36) 22.84,70.59 21.88,70.59 19.41,71.02 16.59,71.02 16.44,70.87 J8.55
PE_SLV_RX_DP<15>: length 58.3
  IN1 w0.089: 63.82,89.48 63.84,89.48 63.89,89.53 67.65,89.53 67.96,89.84 67.96,90.04 68.05,90.13 v4(68.36,90.13)
  IN1 w0.122: v1(19.28,73.05) 19.52,73.29 20.02,73.29 23.64,72.65 25.32,72.94 45.16,77.23 45.54,77.49 62.52,89.38 62.66,89.41 63.07,89.48 63.82,89.48
  BOTTOM w0.135: J8.52 16.49,72.67 16.64,72.82 17.67,72.82 18.76,73.28 19.05,73.28 v1(19.28,73.05) ; U1.AK26 v4(68.36,90.13)
PE_SLV_TX_C_DN<0>: length 67.4
  TOP w0.089: v4(64.36,74.13) 64.68,74.13 64.77,74.04 64.77,73.62 64.71,73.56 64.71,73.54
  TOP w0.135: 64.71,73.54 64.71,72.99 62.4,69 61.75,67.88 60.54,66.52 v3(58.84,64.97) 55.8,62.19 54.82,61.83 52.7,60.77 51.37,60.41 45.86,58.8 45.02,58.35 43.59,57.28 43.56,57.26 40.39,54.29 40.37,54.29 36.14,48.24 35.93,48.2 35.69,47.87 35.73,47.66 35.15,46.83 26.4,40.7 26.31,40.69 26.05,40.32 26.13,39.91 26.02,39.76 25.4,39.65 25.24,39.76 25.17,40.17 24.81,40.42 22.84,40.07 21.3,39 20.3,38.82 20.12,38.95 19.72,38.88 19.6,38.7 19.2,38.63 19.03,38.75 18.63,38.68 18.5,38.51 18.11,38.44 17.72,38.17 16.76,38 15.44,38 C167.1
  BOTTOM w0.135: U1.AP11 v4(64.36,74.13)
PE_SLV_TX_C_DN<1>: length 66.1
  TOP w0.089: 63.2,73.84 63.2,73.86 63.26,73.92 63.26,74.32 63.66,74.73 64.64,74.73 64.8,74.88 64.8,75.08 64.75,75.13 v4(64.36,75.13)
  TOP w0.135: 63.2,73.84 63.2,73.67 v3(62.01,70.97) 61.51,69.85 61.35,69.6 61.27,69.48 59.59,67.64 59.59,67.64 58.06,66 57.39,65.29 54.16,62.89 51.54,61.77 51.18,61.64 51.15,61.63 48.06,60.77 45.5,59.99 45.45,59.97 44.91,59.71 44.57,59.54 41.82,57.48 41.8,57.46 39.19,55.04 37.47,52.58 36.03,50.52 35.12,49.21 34.89,49.17 34.59,48.75 34.64,48.52 33.83,47.37 26,41.89 22.26,41.23 21.09,40.41 20.09,40.24 19.91,40.36 19.51,40.29 19.39,40.11 18.99,40.04 18.81,40.17 18.41,40.1 18.29,39.92 17.89,39.85 16.87,40.03 15.44,40.03 C168.1
  BOTTOM w0.135: U1.AP12 v4(64.36,75.13)
PE_SLV_TX_C_DN<2>: length 67.1
  TOP w0.089: v4(64.36,76.13) 64.74,76.13 64.8,76.07 64.8,75.87 64.66,75.73 63.52,75.73 63.46,75.79 63.44,75.79
  TOP w0.135: 63.44,75.79 63.13,75.79 62.88,75.61 62.17,74.6 62.1,74.21 62.09,74.18 60.6,70.77 59.27,69.09 57.85,67.55 56.28,66 54.48,64.66 51.71,63.31 51.53,63.25 48.9,62.3 47.26,61.79 45.49,61.34 44.09,60.68 43.66,60.46 v3(41.5,58.78) 40.87,58.28 40.86,58.27 40,57.5 38.04,55.75 34.18,50.23 33.99,50.2 33.68,50.42 33.25,50.34 32.89,49.83 32.96,49.39 33.27,49.17 33.3,48.99 32.59,47.97 25.65,43.11 23.56,42.74 23.01,42.84 22.67,43.08 21.24,43.33 21.12,43.51 20.72,43.58 20.54,43.45 20.15,43.52 19.67,43.44 18.66,42.73 18.45,42.77 18.12,42.54 18.08,42.33 17.75,42.09 16.89,41.94 16.21,42.06 15.44,42.06 C169.1
  BOTTOM w0.135: U1.AP13 v4(64.36,76.13)
PE_SLV_TX_C_DN<3>: length 65.8
  TOP w0.089: v4(64.36,77.13) 64.68,77.13 64.73,77.08 64.73,76.88 64.58,76.72 63.44,76.72 63.38,76.78 63.36,76.78
  TOP w0.135: C170.1 15.44,44.09 15.82,44.09 17.36,43.82 17.79,43.9 18.2,44.19 18.43,44.52 18.39,44.73 18.62,45.06 18.84,45.1 19.54,46.1 19.76,47.38 20,47.71 19.96,47.93 20.19,48.26 20.41,48.3 20.65,48.64 20.61,48.85 20.84,49.18 21.05,49.22 23.37,52.52 25.58,54.07 28.48,54.58 32.17,53.93 32.84,54.05 32.84,54.05 33.49,54.16 35.59,55.63 36.38,56.19 37.94,57.36 38.43,57.74 41.46,60.44 42.93,61.46 42.93,61.46 43.97,62 43.97,62 44.35,62.17 45.05,62.5 46.94,62.97 48.36,63.41 49.92,63.98 52.81,65.35 54.93,66.65 56.07,67.51 v3(56.74,68.21) 57.67,69.17 59.97,72.15 60.85,73.99 60.94,74.53 62.27,76.42 62.66,76.7 63.08,76.77 63.08,76.78 63.36,76.78
  BOTTOM w0.135: U1.AP14 v4(64.36,77.13)
PE_SLV_TX_C_DN<4>: length 64.5
  TOP w0.089: 63.4,77.79 63.42,77.79 63.48,77.73 64.7,77.73 64.8,77.83 64.8,78.01 64.68,78.13 v4(64.36,78.13)
  TOP w0.135: C171.1 15.44,46.13 15.92,46.13 16.35,46.2 16.68,46.44 16.72,46.65 17.05,46.88 17.27,46.84 18.18,47.48 18.41,47.81 18.38,48.03 18.61,48.36 18.82,48.4 v3(21.16,51.74) 22.13,53.12 25.11,55.21 25.17,55.22 28.11,55.74 29.01,56.37 29.45,56.29 29.66,55.99 29.84,55.96 30.15,56.17 30.18,56.36 29.97,56.66 30.02,56.94 30.02,57.08 30.15,57.17 35.82,61.14 37.24,61.55 40.2,62.41 40.2,62.42 43,63.18 49.54,65.47 50.93,65.96 50.94,65.96 51.38,66.1 53.13,67.11 55.16,68.57 55.3,68.7 56.32,69.84 57.99,71.55 58.86,72.68 58.88,72.71 59.74,74.61 59.77,74.65 61.59,77.25 62.23,77.7 62.7,77.78 62.71,77.79 63.4,77.79
  BOTTOM w0.135: U1.AP15 v4(64.36,78.13)
PE_SLV_TX_C_DN<5>: length 62.8
  TOP w0.089: 63.44,78.78 63.47,78.78 63.52,78.72 64.58,78.72 64.73,78.88 64.73,79.08 64.68,79.13 v4(64.36,79.13)
  TOP w0.135: 63.44,78.78 62.79,78.78 62.78,78.78 61.42,78.54 58.71,74.66 58.6,74.51 58.6,74.51 58.56,74.45 58.53,74.4 58.03,73.66 57.83,73.39 57.37,72.82 55.2,70.4 52.58,68.26 52.41,68.15 52.38,68.13 52.38,68.13 52.28,68.06 52.14,67.97 51.22,67.42 51.14,67.38 49.3,66.78 49.3,66.78 45.72,65.52 v3(44.65,65.14) 42.14,64.25 37.49,62.94 37.48,62.92 36.13,62.56 36.13,62.56 35.69,62.44 35.62,62.42 34.95,62.09 34.86,62.05 34.85,62.02 27.66,56.99 24.73,56.47 20.99,53.86 20,52.45 19.5,51.72 19.3,51.69 19.05,51.33 19.09,51.14 18.86,50.81 18.64,50.77 18.41,50.44 18.45,50.23 18.22,49.9 18.01,49.86 17.77,49.53 17.81,49.32 17.56,48.96 16.53,48.24 16.07,48.16 15.44,48.16 C172.1
  BOTTOM w0.135: U1.AP16 v4(64.36,79.13)
PE_SLV_TX_C_DN<6>: length 64.1
  TOP w0.089: 63.42,79.78 63.44,79.78 63.5,79.72 64.64,79.72 64.8,79.88 64.8,80.06 64.73,80.13 v4(64.36,80.13)
  TOP w0.135: C173.1 15.44,50.19 16.01,50.19 16.64,50.3 17.05,50.59 17.86,51.74 17.82,51.96 18.05,52.29 18.26,52.32 18.5,52.66 18.46,52.87 18.69,53.2 18.9,53.24 19.92,54.68 24.04,57.57 26.52,58.01 27.37,58.61 27.41,58.79 26.95,59.44 27.03,59.88 27.54,60.24 27.98,60.16 28.43,59.51 28.62,59.48 33.82,63.12 34.41,63.34 34.48,63.36 34.5,63.37 35.31,63.58 35.39,63.6 35.49,63.63 35.5,63.63 v3(38.64,64.52) 38.64,64.52 41.5,65.32 41.78,65.4 49.47,68.12 50.93,68.68 52.18,69.5 54.76,71.72 56.45,73.59 56.6,73.78 56.66,73.86 60.28,79.02 61.12,79.61 62.08,79.78 62.08,79.78 63.42,79.78
  BOTTOM w0.135: U1.AP17 v4(64.36,80.13)
PE_SLV_TX_C_DN<7>: length 62.5
  TOP w0.135: C174.1 15.44,52.22 15.92,52.22 16.34,52.3 16.66,52.52 16.89,52.85 16.85,53.06 17.08,53.39 17.29,53.43 17.53,53.76 17.49,53.98 17.72,54.31 17.93,54.34 18.65,55.37 19.42,55.9 19.45,56.12 19.78,56.35 20,56.31 20.33,56.54 20.37,56.76 20.7,56.99 20.91,56.95 23.18,58.54 24.79,60.84 29.41,64.08 v3(31.65,64.47) 33.48,64.8 34.92,65.12 38.61,65.96 44.2,67.82 44.87,67.98 49.75,69.56 50.82,70.08 51.42,70.5 53.41,72.16 54.68,73.5 56.42,75.62 57.27,76.84 57.29,76.87 57.3,76.89 59.35,79.8 60.83,80.84 62.61,81.15 64.54,81.15 64.71,81.32 64.71,81.78 v4(64.36,82.13)
  BOTTOM w0.135: U1.AP18 v4(64.36,82.13)
PE_SLV_TX_C_DN<8>: length 60.4
  TOP w0.089: v4(64.36,83.13) 64.68,83.13 64.73,83.08 64.73,82.88 64.58,82.73 63.73,82.73 63.68,82.78 63.66,82.78
  TOP w0.135: C175.1 14.8,60.22 15.23,60.22 15.76,60.13 16.09,59.9 16.3,59.93 16.64,59.7 16.67,59.49 17.42,58.96 18.06,58.85 19.05,59.03 20.02,59.7 20.05,59.92 20.39,60.15 20.6,60.11 20.93,60.34 20.97,60.56 21.3,60.79 21.51,60.75 v3(24.36,62.75) 27.56,64.98 27.56,64.98 31.78,65.78 49.38,70.74 49.62,70.85 50.99,71.8 51.14,71.9 52.48,73.08 52.68,73.28 52.85,73.45 54.77,75.61 55.23,76.13 55.75,76.79 58.44,80.63 61.02,82.44 62.02,82.62 62.19,82.78 63.66,82.78
  BOTTOM w0.135: U1.AP19 v4(64.36,83.13)
