# Allegro board 4-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
85OHM_L1_5INCH_DN: length 127
  IN1 w0.122: v1(-6.85,319.85) -7.09,320.08 -7.09,320.87 -7.31,322.13 -8.03,323.15 -12.52,323.94 -12.71,324.2 -12.63,324.65 -12.38,324.82 -4.26,323.38 -3.91,323.63 -3.76,324.48 -4.01,324.83 -12.42,326.32 -12.59,326.55 -12.5,327.07 -12.32,327.19 -5.91,326.06 -4.23,325.77 -3.87,326.02 -3.72,326.85 -3.98,327.22 -5.18,327.43 -13.01,328.81 -13.17,329.04 -13.13,329.29 -13.13,329.29 -13.08,329.53 -12.87,329.68 -6.3,328.52 -5.23,328.34 -4.87,328.59 -4.73,329.42 -4.98,329.78 -6.01,329.96 -6.18,329.99 -13.03,331.2 -13.17,331.4 -13.07,331.94 -12.88,332.07 -4.51,330.6 -4.17,330.84 -4.02,331.66 -4.3,332.05 -12.94,333.58 -13.09,333.79 -13.01,334.27 -12.77,334.44 -8.67,333.72 -4.33,332.96 -3.88,333.27 -3.76,333.96 -4.07,334.4 -12.89,335.96 -13,336.1 -12.89,336.69 -12.71,336.82 -4.25,335.33 -3.98,335.52 -3.88,335.59 -3.73,336.43 -3.98,336.77 -7.41,337.38 -7.51,337.52 -7.4,338.18 -7.4,339.74 v1(-7.16,339.98)
  BOTTOM w0.135: v1(-7.16,339.98) -7.39,340.21 -7.39,340.62 U27.2 ; U23.1 -7.08,319.21 -7.08,319.62 v1(-6.85,319.85)
85OHM_L1_5INCH_DP: length 127
  IN1 w0.122: v1(-7.61,319.85) -7.38,320.08 -7.38,320.85 -7.59,322.01 -8.2,322.88 -12.69,323.68 -13.01,324.13 -12.89,324.81 -12.45,325.13 -4.33,323.69 -4.17,323.8 -4.07,324.41 -4.18,324.56 -12.59,326.05 -12.9,326.48 -12.76,327.24 -12.39,327.5 -5.07,326.21 -4.3,326.08 -4.14,326.19 -4.03,326.78 -4.15,326.95 -5.18,327.13 -13.18,328.54 -13.48,328.97 -13.35,329.7 -12.94,329.99 -6.18,328.8 -5.3,328.64 -5.14,328.76 -5.04,329.35 -5.15,329.51 -5.64,329.6 -6.06,329.68 -6.06,329.68 -13.2,330.94 -13.48,331.33 -13.34,332.11 -12.95,332.38 -4.58,330.91 -4.43,331.01 -4.33,331.59 -4.47,331.78 -13.11,333.31 -13.4,333.72 -13.28,334.44 -12.83,334.75 -4.4,333.26 -4.15,333.44 -4.07,333.89 -4.24,334.13 -13.06,335.69 -13.3,336.03 -13.16,336.86 -12.77,337.13 -4.32,335.64 -4.19,335.73 -4.15,335.76 -4.04,336.36 -4.15,336.51 -7.58,337.11 -7.82,337.45 -7.69,338.21 -7.69,339.74 v1(-7.92,339.98)
  BOTTOM w0.135: v1(-7.92,339.98) -7.7,340.2 -7.7,340.62 U27.1 ; U23.2 -7.38,319.21 -7.38,319.61 v1(-7.61,319.85)
85OHM_L1_10INCH_DN: length 254
  IN1 w0.122: v1(-8.18,164.21) -7.94,163.98 -7.94,162.44 -8.08,161.68 -7.84,161.34 -4.4,160.74 -4.3,160.59 -4.4,159.99 -4.44,159.96 -4.57,159.87 -13.03,161.36 -13.41,161.09 -13.56,160.27 -13.32,159.92 -4.5,158.37 -4.33,158.12 -4.41,157.67 -4.66,157.5 -13.09,158.98 -13.53,158.68 -13.65,157.98 -13.34,157.54 -4.43,155.96 -4.31,155.8 -4.41,155.22 -4.59,155.09 -13.2,156.61 -13.59,156.34 -13.73,155.56 -13.46,155.17 -4.52,153.59 -4.41,153.44 -4.52,152.82 -4.59,152.77 -4.66,152.72 -13.22,154.23 -13.61,153.96 -13.74,153.22 -13.42,152.77 -4.65,151.23 -4.52,151.04 -4.61,150.55 -4.88,150.37 -13.19,151.83 -13.6,151.55 -13.74,150.79 -13.46,150.39 -4.65,148.84 -4.48,148.59 -4.56,148.09 -4.75,147.96 -13.44,149.49 -13.8,149.23 -13.93,148.49 -13.77,148.25 -13.77,148.25 -13.61,148.02 -4.55,146.43 -4.41,146.22 -4.51,145.65 -4.66,145.55 -13.44,147.1 -13.9,146.77 -13.97,146.43 -14.03,146.08 -13.88,145.87 -13.73,145.66 -4.59,144.05 -4.45,143.85 -4.55,143.27 -4.7,143.17 -13.45,144.71 -13.93,144.38 -14.04,143.74 -13.71,143.26 -4.64,141.66 -4.64,141.66 -4.49,141.45 -4.58,140.93 -4.68,140.86 -4.77,140.79 -13.66,142.36 -14.08,142.07 -14.2,141.36 -13.89,140.91 -4.68,139.28 -4.54,139.08 -4.64,138.53 -4.82,138.41 -13.5,139.94 -13.91,139.65 -14.04,138.92 -13.74,138.49 -4.71,136.9 -4.6,136.73 -4.7,136.14 -4.86,136.03 -12.95,137.45 -13.33,137.19 -13.46,136.43 -13.15,136 -4.74,134.51 -4.63,134.36 -4.74,133.75 -4.89,133.64 -13.01,135.07 -13.46,134.76 -13.58,134.08 -13.26,133.62 -8.76,132.83 -8.15,131.96 -7.94,130.8 -7.94,130.03 v1(-8.18,129.79)
  BOTTOM w0.135: U31.1 -7.95,164.85 -7.95,164.44 v1(-8.18,164.21) ; U35.2 -7.94,129.16 -7.94,129.56 v1(-8.18,129.79)
85OHM_L1_10INCH_DP: length 254
  IN1 w0.122: v1(-7.42,129.79) -7.65,130.03 -7.65,130.82 -7.87,132.08 -8.59,133.1 -13.09,133.89 -13.27,134.15 -13.19,134.59 -12.94,134.76 -4.82,133.33 -4.47,133.58 -4.32,134.42 -4.57,134.78 -12.98,136.26 -13.15,136.5 -13.06,137.02 -12.88,137.14 -4.79,135.72 -4.43,135.97 -4.29,136.8 -4.54,137.16 -13.57,138.76 -13.73,138.99 -13.69,139.24 -13.65,139.48 -13.44,139.63 -4.75,138.1 -4.56,138.23 -4.38,138.36 -4.23,139.15 -4.51,139.55 -13.72,141.17 -13.9,141.43 -13.81,141.9 -13.6,142.05 -4.71,140.48 -4.31,140.76 -4.18,141.52 -4.4,141.83 -4.4,141.83 -4.47,141.93 -13.54,143.53 -13.73,143.81 -13.66,144.2 -13.38,144.4 -4.63,142.86 -4.28,143.1 -4.14,143.92 -4.42,144.31 -13.56,145.92 -13.72,146.15 -13.64,146.6 -13.38,146.79 -4.59,145.24 -4.24,145.48 -4.1,146.29 -4.38,146.7 -13.44,148.29 -13.53,148.42 -13.63,148.55 -13.58,148.81 -13.54,149.06 -13.37,149.18 -4.69,147.65 -4.3,147.92 -4.17,148.66 -4.48,149.1 -13.29,150.65 -13.43,150.85 -13.34,151.38 -13.13,151.52 -4.81,150.06 -4.34,150.38 -4.21,151.11 -4.48,151.49 -13.25,153.04 -13.43,153.29 -13.34,153.79 -13.16,153.92 -4.59,152.41 -4.25,152.65 -4.1,153.5 -4.35,153.86 -13.29,155.43 -13.42,155.63 -13.33,156.17 -13.13,156.3 -4.52,154.79 -4.15,155.04 -4,155.86 -4.26,156.23 -13.17,157.8 -13.34,158.05 -13.26,158.5 -13.02,158.67 -4.59,157.19 -4.14,157.5 -4.02,158.19 -4.33,158.63 -13.15,160.19 -13.25,160.34 -13.15,160.92 -12.96,161.05 -4.5,159.56 -4.13,159.82 -3.99,160.66 -4.23,161.01 -7.67,161.61 -7.77,161.75 -7.65,162.41 -7.65,163.98 v1(-7.42,164.21)
  BOTTOM w0.135: U35.1 -7.64,129.16 -7.64,129.57 v1(-7.42,129.79) ; v1(-7.42,164.21) -7.65,164.44 -7.65,164.85 U31.2
85OHM_L3_5INCH_DN: length 127
  TOP w0.135: v1(-7.16,278.38) -7.39,278.61 -7.39,279.02 U25.1 ; U29.2 -7.39,257.76 -7.39,258.17 v1(-7.16,258.4)
  IN3 w0.135: v1(-7.16,278.38) -7.4,278.15 -7.4,276.57 -6.89,275.85 -6.31,275.45 -4.84,275.19 -4.84,275.19 -4.73,275.17 -4.47,274.8 -4.62,273.95 -4.96,273.71 -13.13,275.16 -13.41,274.96 -13.5,274.48 -13.36,274.28 -4.78,272.77 -4.46,272.31 -4.56,271.76 -4.58,271.64 -5.03,271.32 -12.79,272.69 -13,272.54 -13.08,272.09 -12.87,271.79 -4.8,270.37 -4.51,269.96 -4.64,269.24 -5.09,268.92 -12.38,270.21 -12.52,270.11 -12.65,270.02 -12.73,269.58 -12.55,269.33 -4.73,267.95 -4.43,267.53 -4.56,266.8 -4.98,266.5 -12.96,267.91 -13.15,267.77 -13.25,267.18 -13.15,267.03 -4.86,265.57 -4.57,265.15 -4.69,264.41 -5.11,264.12 -7.01,264.45 -14.15,265.71 -14.3,265.61 -14.4,265.05 -14.23,264.81 -4.82,263.15 -4.52,262.73 -4.64,262.04 -5.12,261.71 -13.97,263.27 -14.18,263.12 -14.27,262.6 -14.12,262.39 -7.41,261.2 -7.16,260.85 -7.4,259.51 -7.4,258.64 v1(-7.16,258.4)
85OHM_L3_5INCH_DP: length 127
  TOP w0.135: U29.1 -7.69,257.77 -7.69,258.17 v1(-7.92,258.4) ; v1(-7.92,278.38) -7.69,278.62 -7.69,279.02 U25.2
  IN3 w0.135: v1(-7.92,278.38) -7.69,278.15 -7.69,276.48 -7.1,275.64 -6.42,275.17 -4.89,274.9 -4.77,274.73 -4.88,274.12 -5.03,274.02 -13.22,275.46 -13.67,275.14 -13.78,274.53 -13.8,274.42 -13.73,274.32 -13.52,274.02 -4.95,272.51 -4.76,272.24 -4.84,271.81 -5.1,271.62 -12.85,272.99 -13.26,272.71 -13.38,272.02 -13.21,271.78 -13.04,271.53 -4.97,270.11 -4.82,269.89 -4.9,269.4 -5.15,269.23 -12.45,270.51 -12.91,270.18 -13.03,269.52 -12.72,269.07 -4.9,267.69 -4.74,267.46 -4.82,266.96 -5.05,266.8 -13.02,268.21 -13.41,267.94 -13.56,267.11 -13.32,266.77 -5.03,265.31 -4.87,265.08 -4.96,264.58 -5.18,264.42 -7.01,264.74 -14.22,266.01 -14.56,265.77 -14.7,264.99 -14.4,264.55 -4.98,262.89 -4.82,262.66 -4.9,262.21 -5.18,262.02 -14.03,263.58 -14.44,263.29 -14.57,262.53 -14.29,262.13 -7.57,260.94 -7.46,260.79 -7.69,259.53 -7.69,258.64 v1(-7.92,258.4)
85OHM_L3_10INCH_DN: length 254
  TOP w0.135: v1(-8.18,72.01) -7.95,71.78 -7.95,71.37 U33.1 ; U37.2 -7.94,107.06 -7.94,106.66 v1(-8.18,106.43)
  IN3 w0.135: v1(-8.18,72.01) -7.94,72.25 -7.94,73.14 -7.72,74.4 -7.83,74.55 -14.54,75.74 -14.83,76.14 -14.69,76.9 -14.29,77.19 -5.44,75.63 -5.16,75.82 -5.08,76.27 -5.24,76.5 -14.65,78.16 -14.95,78.6 -14.81,79.38 -14.47,79.62 -5.44,78.03 -5.21,78.19 -5.12,78.69 -5.28,78.91 -14.67,80.57 -14.93,80.95 -14.78,81.78 -14.44,82.02 -5.4,80.43 -5.21,80.56 -5.11,81.09 -5.28,81.33 -14.45,82.95 -14.72,83.32 -14.57,84.15 -14.23,84.39 -5.43,82.84 -5.28,82.94 -5.23,83.21 -5.18,83.48 -5.37,83.74 -14.32,85.32 -14.59,85.7 -14.44,86.52 -14.08,86.77 -5.4,85.24 -5.26,85.35 -5.22,85.57 -5.15,85.93 -5.29,86.13 -14.26,87.71 -14.56,88.14 -14.43,88.89 -14.03,89.17 -5.36,87.64 -5.15,87.79 -5.06,88.27 -5.24,88.53 -14.16,90.1 -14.45,90.52 -14.33,91.25 -13.9,91.55 -5.35,90.04 -5.16,90.18 -5.07,90.72 -5.22,90.93 -13.94,92.47 -14.22,92.87 -14.08,93.66 -13.71,93.92 -5.34,92.45 -5.12,92.6 -5.03,93.15 -5.15,93.32 -13.76,94.84 -14.05,95.26 -13.92,96 -13.51,96.29 -5.31,94.85 -5.13,94.98 -5.03,95.54 -5.16,95.73 -13.45,97.19 -13.79,97.69 -13.67,98.35 -13.25,98.65 -5.41,97.27 -5.16,97.45 -5.07,97.93 -5.22,98.15 -13.69,99.64 -14.04,100.14 -13.92,100.82 -13.52,101.11 -5.35,99.67 -5.09,99.85 -5.02,100.28 -5.2,100.55 -13.78,102.06 -14.06,102.46 -13.93,103.19 -13.74,103.32 -13.47,103.5 -5.28,102.06 -5.14,102.16 -5.03,102.78 -5.15,102.95 -6.68,103.22 -7.35,103.69 -7.94,104.53 -7.94,106.19 v1(-8.18,106.43)
85OHM_L3_10INCH_DP: length 254
  TOP w0.135: U33.2 -7.65,71.37 -7.65,71.78 v1(-7.42,72.01) ; U37.1 -7.64,107.06 -7.64,106.65 v1(-7.42,106.43)
  IN3 w0.135: v1(-7.42,72.01) -7.65,72.25 -7.65,73.12 -7.41,74.46 -7.66,74.81 -14.38,76 -14.52,76.21 -14.43,76.73 -14.22,76.88 -5.37,75.32 -4.9,75.65 -4.78,76.34 -5.07,76.76 -14.48,78.42 -14.65,78.66 -14.55,79.22 -14.4,79.32 -5.37,77.73 -4.95,78.02 -4.82,78.75 -5.11,79.18 -14.5,80.83 -14.63,81.01 -14.52,81.61 -14.37,81.72 -5.33,80.13 -4.94,80.4 -4.81,81.16 -5.11,81.59 -14.29,83.21 -14.41,83.39 -14.31,83.98 -14.16,84.09 -5.36,82.54 -5.02,82.78 -4.88,83.55 -5.2,84 -14.15,85.58 -14.28,85.77 -14.18,86.35 -14.01,86.47 -5.34,84.94 -4.99,85.18 -4.85,86 -5.12,86.39 -14.09,87.98 -14.26,88.21 -14.17,88.72 -13.97,88.86 -5.3,87.34 -4.88,87.62 -4.76,88.34 -5.08,88.79 -13.99,90.37 -14.15,90.59 -14.07,91.08 -13.83,91.25 -5.29,89.74 -4.9,90.01 -4.76,90.79 -5.05,91.19 -13.77,92.73 -13.92,92.94 -13.82,93.49 -13.64,93.62 -5.27,92.14 -4.86,92.43 -4.72,93.21 -4.99,93.59 -13.59,95.1 -13.74,95.33 -13.65,95.84 -13.44,95.99 -5.24,94.54 -4.86,94.81 -4.72,95.61 -4.99,95.99 -13.28,97.45 -13.49,97.75 -13.41,98.19 -13.19,98.35 -5.34,96.97 -4.9,97.28 -4.88,97.4 -4.77,98 -5.06,98.41 -13.53,99.9 -13.74,100.21 -13.66,100.66 -13.45,100.8 -5.29,99.36 -4.83,99.68 -4.81,99.8 -4.71,100.35 -5.04,100.81 -13.61,102.32 -13.75,102.53 -13.67,103.02 -13.4,103.2 -5.22,101.76 -4.87,102 -4.72,102.84 -4.98,103.21 -5.1,103.23 -5.1,103.23 -6.57,103.49 -7.15,103.89 -7.65,104.62 -7.65,106.19 v1(-7.42,106.43)
85OHM_TOP_5INCH_DN: length 127
  TOP w0.135: U5.1 -14.81,319.58 -14.81,322.42 -14.22,323.26 -13.35,323.42 -10.16,322.85 -10.04,322.94 -9.92,323.57 -10.04,323.74 -17.19,325.01 -17.51,325.47 -17.38,326.2 -16.96,326.49 -8.7,325.04 -8.55,325.14 -8.44,325.77 -8.54,325.92 -17.47,327.5 -17.74,327.87 -17.59,328.71 -17.2,328.98 -8.33,327.41 -8.18,327.52 -8.09,328.05 -8.27,328.32 -17.29,329.91 -17.58,330.31 -17.43,331.13 -17.05,331.39 -7.93,329.79 -7.79,329.89 -7.7,330.39 -7.91,330.69 -17.48,332.38 -17.75,332.76 -17.6,333.6 -17.21,333.86 -7.66,332.18 -7.48,332.3 -7.4,332.76 -7.63,333.09 -17.63,334.85 -17.77,335.05 -17.91,335.24 -17.84,335.63 -17.77,336.02 -17.34,336.33 -7.72,334.63 -7.51,334.78 -7.42,335.3 -7.57,335.52 -14.89,336.81 -15.14,337.17 -14.93,338.38 -14.93,340.62 U26.2
85OHM_TOP_5INCH_DP: length 127
  TOP w0.135: U26.1 -14.63,340.62 -14.63,338.35 -14.82,337.24 -14.71,337.09 -7.39,335.79 -7.1,335.37 -7.23,334.61 -7.65,334.31 -17.27,336 -17.49,335.85 -17.59,335.32 -17.45,335.13 -7.45,333.36 -7.08,332.83 -7.2,332.12 -7.58,331.86 -17.14,333.54 -17.32,333.42 -17.37,333.13 -17.43,332.83 -17.31,332.66 -7.74,330.97 -7.56,330.72 -7.38,330.46 -7.51,329.71 -7.68,329.59 -7.69,329.59 -7.86,329.46 -16.98,331.07 -17.15,330.95 -17.2,330.66 -17.25,330.38 -17.12,330.19 -8.09,328.59 -7.77,328.13 -7.9,327.34 -8.26,327.09 -17.13,328.66 -17.31,328.53 -17.41,327.94 -17.3,327.78 -8.37,326.2 -8.12,325.85 -8.27,324.96 -8.63,324.72 -16.89,326.17 -17.1,326.02 -17.19,325.54 -17.01,325.28 -9.87,324.02 -9.6,323.65 -9.76,322.76 -9.86,322.69 -10.09,322.53 -13.35,323.11 -14.04,322.98 -14.51,322.33 -14.51,319.58 U5.2
85OHM_TOP_10INCH_DN: length 254
  TOP w0.135: U30.1 -14.81,129.16 -14.81,132 -14.22,132.84 -13.35,133 -10.16,132.44 -10.04,132.52 -9.92,133.16 -10.04,133.33 -17.19,134.59 -17.51,135.05 -17.38,135.78 -16.96,136.08 -8.7,134.62 -8.55,134.72 -8.44,135.36 -8.54,135.5 -17.47,137.08 -17.74,137.45 -17.59,138.29 -17.2,138.56 -8.71,137.06 -8.54,137.18 -8.44,137.74 -8.59,137.95 -17.29,139.49 -17.58,139.89 -17.43,140.71 -17.05,140.98 -8.65,139.5 -8.44,139.64 -8.36,140.11 -8.5,140.4 -17.6,142 -17.91,142.43 -17.79,143.09 -17.77,143.22 -17.39,143.48 -8.38,141.89 -8.19,142.02 -8.09,142.61 -8.2,142.77 -17.54,144.41 -17.83,144.81 -17.72,145.59 -17.32,145.91 -8.49,144.35 -8.27,144.5 -8.17,145.07 -8.28,145.22 -17.44,146.86 -17.71,147.25 -17.59,147.95 -17.57,148.07 -17.2,148.33 -8.2,146.74 -8.02,146.86 -7.92,147.43 -8.06,147.63 -17.61,149.31 -17.87,149.68 -17.72,150.52 -17.33,150.79 -8.17,149.18 -7.98,149.31 -7.88,149.86 -8.02,150.06 -17.54,151.74 -17.79,152.1 -17.64,152.96 -17.27,153.22 -8.12,151.61 -7.94,151.74 -7.84,152.31 -7.98,152.5 -17.48,154.17 -17.77,154.59 -17.63,155.42 -17.27,155.66 -8.21,154.07 -7.95,154.25 -7.86,154.73 -8.01,154.94 -17.48,156.61 -17.75,157 -17.6,157.83 -17.21,158.09 -7.9,156.45 -7.68,156.61 -7.6,157.07 -7.8,157.35 -17.63,159.08 -17.91,159.48 -17.84,159.87 -17.77,160.26 -17.34,160.56 -7.72,158.86 -7.51,159.01 -7.42,159.53 -7.57,159.75 -14.89,161.04 -15.14,161.4 -14.93,162.61 -14.93,164.85 U34.2
85OHM_TOP_10INCH_DP: length 254
  TOP w0.135: U30.2 -14.51,129.16 -14.51,131.91 -14.04,132.57 -13.35,132.69 -10.09,132.11 -9.86,132.27 -9.86,132.27 -9.76,132.35 -9.6,133.23 -9.87,133.6 -17.01,134.87 -17.19,135.12 -17.1,135.6 -16.89,135.75 -8.63,134.3 -8.27,134.54 -8.12,135.43 -8.37,135.78 -17.3,137.36 -17.41,137.52 -17.31,138.11 -17.13,138.24 -8.64,136.74 -8.26,137.01 -8.12,137.81 -8.42,138.23 -17.12,139.77 -17.25,139.96 -17.15,140.53 -16.98,140.65 -8.58,139.17 -8.16,139.47 -8.04,140.16 -8.29,140.67 -17.43,142.28 -17.58,142.51 -17.49,143.04 -17.32,143.15 -8.31,141.57 -7.91,141.84 -7.76,142.68 -8.02,143.05 -17.37,144.69 -17.51,144.89 -17.44,145.42 -17.24,145.58 -8.42,144.03 -7.99,144.32 -7.85,145.14 -8.11,145.5 -17.26,147.13 -17.39,147.32 -17.29,147.89 -17.13,148.01 -8.13,146.42 -7.75,146.68 -7.6,147.5 -7.88,147.9 -17.43,149.59 -17.55,149.76 -17.45,150.34 -17.26,150.47 -8.1,148.85 -7.7,149.13 -7.56,149.93 -7.84,150.34 -17.37,152.02 -17.47,152.17 -17.36,152.78 -17.19,152.9 -8.05,151.29 -7.66,151.56 -7.52,152.38 -7.8,152.77 -17.3,154.45 -17.45,154.66 -17.35,155.24 -17.2,155.34 -8.14,153.74 -7.67,154.07 -7.54,154.81 -7.83,155.22 -17.31,156.89 -17.43,157.07 -17.32,157.65 -17.14,157.77 -7.83,156.13 -7.41,156.43 -7.28,157.14 -7.62,157.63 -17.45,159.36 -17.59,159.55 -17.49,160.08 -17.27,160.24 -7.65,158.54 -7.23,158.84 -7.1,159.6 -7.39,160.03 -14.71,161.32 -14.82,161.47 -14.63,162.58 -14.63,164.85 U34.1
AT24C64_A0: length 5.3
  TOP w0.127: U7.1 v1(315.16,42.57) R282.1 315.65,43.29 315.8,43.43 315.8,44.86 315.16,45.5 R281.2
AT24C64_A1: length 5.4
  TOP w0.127: R283.2 v1(313.89,44.83) 314.28,44.83 314.53,44.58 314.53,43.56 314.26,43.29 R284.1 313.89,41.12
AT24C64_A2: length 4.9
  TOP w0.127: U7.3 v1(312.62,42.49) R286.1 312.12,43.8 312.12,45.07 R285.2
AT24C64_WP: length 5.1
  TOP w0.127: 313.89,35.84 313.89,35.31 v1(314.66,34.54) 314.66,34.23 R294.1 313.94,33.85 313.79,33.71 313.79,32.25 R293.2
CLK_100M_CPU1_PE_FG_DN: length 84.4
  TOP w0.135: J5.A14 280.83,5.8 281.17,6.15 281.17,6.53 280.87,6.83 280.87,8.81 282.53,10.46 282.53,13.34 v1(282.27,13.59) ; v1(316.46,55.97) 316.2,55.7 312.07,55.7 310.42,54.05 309.87,54.05 309.83,54.09 U3.7
  BOTTOM w0.135: v1(316.46,55.97) 316.2,55.7 315.29,55.7 314.81,55.22 314.81,54.05 316.21,52.65 316.21,42.19 309.32,35.31 309.32,32.26 307.16,30.09 307.16,27.98 296.37,17.2 284.46,17.2 282.53,15.26 282.53,13.84 v1(282.27,13.59)
CLK_100M_CPU1_PE_FG_DP: length 84.4
  TOP w0.135: v1(316.46,55.13) 316.2,55.4 312.19,55.4 310.54,53.75 309.89,53.75 309.83,53.69 U3.6 ; v1(283.08,13.59) 282.83,13.34 282.83,10.34 281.18,8.69 281.18,6.96 281.48,6.66 281.48,6.15 281.83,5.8 J5.A13
  BOTTOM w0.135: v1(316.46,55.13) 316.2,55.4 315.42,55.4 315.11,55.09 315.11,54.18 316.51,52.78 316.51,42.06 309.63,35.18 309.63,32.13 307.46,29.96 307.46,27.86 296.5,16.89 287.93,16.89 287.77,16.74 287.37,16.74 287.22,16.89 286.81,16.89 286.66,16.74 286.25,16.74 286.1,16.89 285.7,16.89 285.54,16.74 285.14,16.74 284.99,16.89 284.58,16.89 283.62,15.93 283.62,15.71 283.34,15.43 283.12,15.43 282.83,15.14 282.83,13.84 v1(283.08,13.59)
CLK_100M_PEX8796_DN: length 2.6
  TOP w0.135: U3.34 306.11,50.58 306.07,50.55 306.07,50.27 305.79,49.99 305.51,49.99 305.11,49.58 305.11,49.47 R127.1
CLK_100M_PEX8796_DP: length 2.6
  TOP w0.135: U3.33 305.71,50.58 305.77,50.52 305.77,50.39 305.67,50.29 305.39,50.29 304.8,49.71 304.8,49.45 R126.1
CLK_100M_PEX8796_R_DN: length 264.6
  TOP w0.135: v1(305.41,47.62) 305.11,47.93 305.11,48.06 R127.2
  IN3 w0.089: v4(66.36,64.13) 66.36,64.45 66.45,64.53 66.67,64.53 66.79,64.42 66.79,62.94 66.74,62.89 66.74,62.87
  IN3 w0.135: 66.74,62.87 66.74,62.59 66.83,62.32 67.14,62.05 67.23,61.99 87.49,53.82 87.95,53.68 121.21,46.79 134.35,44.77 135.61,44.64 140.72,45.1 140.72,45.1 176.04,40.37 186.12,37.26 193.47,34.68 200.67,32.75 223.97,28.08 234.54,27.14 282.66,27.14 284.53,25.27 294.77,25.27 296.32,26.82 296.32,28.88 297.69,30.25 299.33,34.76 304.91,41.27 305.7,43.4 305.7,43.41 306.2,44.75 306.2,45.36 305.11,46.91 305.11,47.33 v1(305.41,47.62)
  BOTTOM w0.135: U1.AM1 v4(66.36,64.13)
CLK_100M_PEX8796_R_DP: length 264.5
  TOP w0.135: R126.2 304.8,48.09 304.8,47.9 v1(304.52,47.62)
  IN3 w0.089: 67.03,62.87 67.03,62.89 66.98,62.94 66.98,64.5 66.75,64.73 66.45,64.73 66.36,64.81 v4(66.36,65.13)
  IN3 w0.135: 67.03,62.87 67.03,62.53 67.34,62.26 87.58,54.09 87.59,54.09 88.02,53.96 121.26,47.07 134.38,45.06 135.61,44.93 140.73,45.39 176.1,40.65 186.21,37.54 193.55,34.95 200.74,33.03 224.01,28.37 234.55,27.43 282.78,27.43 284.65,25.56 294.65,25.56 296.03,26.94 296.03,29 296.52,29.49 297.44,30.41 299.08,34.9 301.83,38.11 301.82,38.32 302.06,38.6 302.26,38.61 302.96,39.43 302.94,39.67 303.19,39.97 303.43,39.98 304.66,41.42 305.06,42.49 304.98,42.66 305.12,43.03 305.29,43.11 305.43,43.5 305.43,43.51 305.36,43.67 305.5,44.05 305.66,44.12 305.91,44.8 305.91,45.27 305.65,45.64 305.48,45.67 305.25,46 305.28,46.18 304.83,46.82 304.83,47.32 v1(304.52,47.62)
  BOTTOM w0.135: U1.AM2 v4(66.36,65.13)
CLK_100M_SLOT1_DN: length 2.7
  TOP w0.135: U3.27 303.83,52.89 303.81,52.91 303.31,52.91 302.69,52.3 302.33,52.3 R125.1
CLK_100M_SLOT1_DP: length 2.7
  TOP w0.135: R124.1 302.33,52.6 302.57,52.6 303.18,53.22 303.76,53.22 303.84,53.29 U3.26
CLK_100M_SLOT1_R_DN: length 43.3
  TOP w0.135: v1(299.53,52.03) 299.8,52.3 300.82,52.3 R125.2
  BOTTOM w0.135: v1(299.53,52.03) 299.27,52.3 298.88,52.3 297.26,50.67 297.26,31.83 296.27,30.84 283.19,30.84 281.64,32.39 281.64,33.86 281.51,33.99 281.38,34.06 281.2,34 J1.A14
CLK_100M_SLOT1_R_DP: length 43.3
  TOP w0.135: R124.2 300.82,52.6 299.8,52.6 v1(299.53,52.87)
  BOTTOM w0.135: v1(299.53,52.87) 299.27,52.6 298.76,52.6 296.95,50.8 296.95,31.95 296.14,31.14 283.31,31.14 282.73,31.73 282.73,31.94 282.44,32.23 282.23,32.23 281.94,32.51 281.94,33.99 281.69,34.25 281.52,34.33 281.46,34.51 J1.A13
CLK_100M_SLOT2_DN: length 2.6
  TOP w0.135: R123.1 302.33,54.46 302.67,54.46 302.99,54.14 303.75,54.14 303.8,54.09 U3.24
CLK_100M_SLOT2_DP: length 2.6
  TOP w0.135: R122.1 302.33,54.76 302.79,54.76 303.11,54.44 303.75,54.44 303.79,54.49 U3.23
CLK_100M_SLOT2_R_DN: length 24.7
  TOP w0.135: v1(299.55,54.19) 299.81,54.46 300.82,54.46 R123.2
  BOTTOM w0.135: v1(299.55,54.19) 299.28,54.46 298.99,54.46 295.71,51.18 283.16,51.18 281.64,52.7 281.64,54.18 281.51,54.31 281.38,54.38 281.2,54.32 J2.A14
CLK_100M_SLOT2_R_DP: length 24.7
  TOP w0.135: R122.2 300.82,54.76 299.81,54.76 v1(299.55,55.03)
  BOTTOM w0.135: J2.A13 281.46,54.83 281.52,54.65 281.69,54.57 281.94,54.31 281.94,52.83 282.45,52.32 282.66,52.32 282.95,52.04 282.95,51.82 283.28,51.49 295.59,51.49 298.86,54.76 299.28,54.76 v1(299.55,55.03)
CLK_100M_SLOT3_DN: length 3.2
  TOP w0.135: U3.18 305.71,56.45 305.74,56.49 305.74,57.68 305.28,58.14 305.28,58.43 R121.1
CLK_100M_SLOT3_DP: length 3.2
  TOP w0.135: R120.1 305.59,58.43 305.59,58.27 306.05,57.81 306.05,56.54 306.11,56.48 U3.17
CLK_100M_SLOT3_R_DN: length 37.2
  TOP w0.135: R121.2 305.28,59.94 305.28,60.58 v1(305.02,60.84)
  BOTTOM w0.135: J3.A14 281.2,74.64 281.38,74.7 281.51,74.63 281.66,74.48 281.66,73.14 281.51,72.98 281.51,72.58 281.66,72.43 281.66,71.75 281.51,71.6 281.51,71.19 281.66,71.04 281.66,68.53 283.52,66.67 286.01,66.67 286.89,67.56 299.42,67.56 305.28,61.7 305.28,61.11 v1(305.02,60.84)
CLK_100M_SLOT3_R_DP: length 37.4
  TOP w0.135: v1(305.85,60.84) 305.59,60.58 305.59,59.94 R120.2
  BOTTOM w0.135: v1(305.85,60.84) 305.59,61.11 305.59,61.82 299.55,67.86 286.76,67.86 285.88,66.98 283.64,66.98 281.97,68.66 281.97,74.61 281.69,74.89 281.52,74.97 281.46,75.15 J3.A13
CLK_100M_SLOT4_DN: length 3.2
  TOP w0.135: R119.1 307.47,58.43 307.47,58.17 306.96,57.66 306.96,56.62 306.9,56.56 U3.15
CLK_100M_SLOT4_DP: length 3.2
  TOP w0.135: U3.14 307.3,56.62 307.27,56.66 307.27,57.53 307.77,58.04 307.77,58.43 R118.1
CLK_100M_SLOT4_R_DN: length 52.1
  TOP w0.135: R119.2 307.47,59.94 307.47,60.56 v1(307.2,60.83)
  BOTTOM w0.135: v1(307.2,60.83) 307.47,61.09 307.47,61.34 298.45,70.36 298.45,80.09 296.37,82.17 296.37,85.52 293.98,87.91 286.77,87.91 283.34,91.34 283.12,91.34 282.84,91.62 282.84,91.84 282.45,92.23 282.23,92.23 281.95,92.51 281.95,92.73 281.66,93.01 281.66,94.82 281.55,94.93 281.38,95.02 281.2,94.96 J4.A14
CLK_100M_SLOT4_R_DP: length 52.2
  TOP w0.135: R118.2 307.77,59.94 307.77,60.56 v1(308.04,60.83)
  BOTTOM w0.135: v1(308.04,60.83) 307.77,61.09 307.77,61.47 298.75,70.49 298.75,80.22 296.67,82.3 296.67,85.65 294.11,88.21 286.89,88.21 281.97,93.14 281.97,94.94 281.73,95.18 281.52,95.29 281.46,95.47 J4.A13
CLK_BUF_CKPWRGD: length 8.8
  TOP w0.127: Q4.D 314.28,53.3 v1(314.28,54.13) 314.28,54.28 313.77,54.78 312.45,54.78 311.72,54.05 R4.2 310.78,52.15 310.08,52.15 309.74,52.49 U3.3
CLK_BUF_HIBW_BYPM_LOBW_N: length 6.5
  TOP w0.178: U3.2 309.68,52.09 310.08,51.69 310.34,51.69
  TOP w0.254: 310.34,51.69 310.85,51.69 311.1,51.94 R2.1 R1.2 v1(311.72,48.31)
CPLD_PWRBRK_N: length 130.4
  TOP w0.127: v1(283.54,45.34) 283.41,45.21 U20.2 ; U19.2 v1(283.54,65.41) ; U18.2 280.75,86.87 281.89,85.72 U21.2 283.47,85.72 v1(283.72,85.98)
  IN1 w0.097: v1(263.81,8.36) 264.7,7.47 264.7,6.36 265.12,5.93 277.97,5.93 278.6,6.56 278.6,7.56 279.68,8.64 281.26,8.64 282.49,9.88 282.49,12.26 281.04,13.72 281.04,29.25 286.72,34.92 286.72,38.35 284.68,40.39 284.68,44.83 284.18,45.34 v1(283.54,45.34)
  IN2 w0.112: v1(283.72,85.98) 284.18,85.52 284.18,81.53 286.61,79.1 286.61,75.55 287.3,74.85 289.14,74.85 289.78,74.21 289.78,71.69 288.99,70.9 288.99,69.86 289.66,69.19 289.66,66.8 289.49,66.62 284.76,66.62 v1(283.54,65.41) 284.18,64.77 284.18,61.21 286.61,58.78 286.61,55.14 283.16,51.69 283.16,45.72 v1(283.54,45.34)
  BOTTOM w0.114: J5.B30 264.83,7.34 v1(263.81,8.36) ; v1(283.54,45.34) 283.92,45.72 R309.2
CPLD_SLOT1_PWRBRK_N: length 5.7
  TOP w0.127: v1(282.81,43.45) R221.1 R216.1 284.81,43.81 285.07,44.07 285.07,44.45 284.95,44.56 U20.4
  BOTTOM w0.114: v1(282.81,43.45) 282.4,43.87 R306.2
CPLD_SLOT1_PWRBRK_R1_N: length 3.7
  TOP w0.127: J1.B12 284.81,41.74 R216.2
CPLD_SLOT1_PWRBRK_R2_N: length 20.2
  TOP w0.127: J1.B30 267.73,42.65 R221.2
CPLD_SLOT2_PWRBRK_N: length 4.6
  TOP w0.127: U19.4 284.03,64.76 283.64,64.36 v1(283.64,64.29) 283.64,63.8 R215.1 R214.1
  BOTTOM w0.114: v1(283.64,64.29) 282.53,65.41 R308.2
CPLD_SLOT2_PWRBRK_R1_N: length 3.6
  TOP w0.127: R214.2 284.81,62.06 J2.B12
CPLD_SLOT2_PWRBRK_R2_N: length 20.1
  TOP w0.127: J2.B30 267.6,62.85 R215.2
CPLD_SLOT3_PWRBRK_N: length 6.1
  TOP w0.127: v1(281.54,84.18) 281.74,83.97 R213.1 R212.1 283.54,84.25 284.37,85.08 U21.4
  BOTTOM w0.114: v1(281.54,84.18) 282.14,84.79 R305.2
CPLD_SLOT3_PWRBRK_R1_N: length 3.1
  TOP w0.127: J3.B12 283.54,81.11 R212.2
CPLD_SLOT3_PWRBRK_R2_N: length 18.8
  TOP w0.127: R213.2 267.6,83.17 J3.B30
CPLD_SLOT4_PWRBRK_N: length 5.2
  TOP w0.127: R195.1 R196.1 281.77,91.29 281.38,90.91 v1(280.95,90.91) 280.95,91.46 U18.4
  BOTTOM w0.114: v1(280.95,90.91) 280.98,90.87 R307.2
CPLD_SLOT4_PWRBRK_R1_N: length 9.5
  TOP w0.127: J4.B12 282.83,98.52 282.35,98.04 282.35,96.82 283.67,95.5 283.67,93.85 283.41,93.6 R195.2
CPLD_SLOT4_PWRBRK_R2_N: length 24
  TOP w0.127: R196.2 281.53,92.96 268.05,92.96 267.79,93.22 267.79,94.61 266.75,95.66 266.75,99.09 265.94,99.9 265.64,99.9 J4.B30
EMC1412_ADDR: length 3.3
  BOTTOM w0.127: R302.2 303.23,79.63 303.56,79.96 v2(303.94,79.96) 304.38,79.96 304.62,79.72 U4.4
EMC1412_ALERT: length 3.7
  BOTTOM w0.114: 311.63,79.98 312.01,79.98 312.62,79.38 R301.2
  BOTTOM w0.127: U4.6 310.66,79.07 v2(311.61,80.01) 311.63,79.98
EMC1413_ADDR: length 4.7
  TOP w0.114: U10.7 163.56,84.58 162.66,84.58 162.21,84.12 162.21,82.78 162.46,82.52 v1(162.82,82.52) 162.82,81.76 162.68,81.63 R303.2
EMC1413_ALERT_N: length 5.1
  TOP w0.114: R304.2 v1(161.49,82.63) 161.47,82.65 161.47,84.25 162.31,85.09 U10.8
I2C_MUX_ADD_A0: length 6.9
  TOP w0.127: R83.2 R84.1 310.36,43.96 310.08,43.69 310.08,41.78 v1(309.96,41.66) 309.3,41.66 308.04,40.4 U2.1
I2C_MUX_ADD_A1: length 6.9
  TOP w0.127: R81.2 309.96,44.94 v1(309.96,44.7) 309.96,44.47 R82.1 309.22,43.96 308.94,43.69 308.94,42.26 307.78,41.1 307.51,41.1 307.39,40.99 U2.2
I2C_MUX_ADD_A2: length 4.1
  TOP w0.127: R80.1 R79.2 v1(306.66,32.58) 306.09,33.15 U2.21
I2C_MUX_RST_N: length 6.4
  TOP w0.127: R78.2 308.43,44.48 308.21,44.25 v1(308.21,43.79) 308.38,43.61 308.38,42.26 307.5,41.38 307.14,41.38 306.74,40.98 U2.3
I2C_PCA9548_2N7002_G2_SCL: length 2.1
  TOP w0.254: R160.2 v1(315.7,28.7) 316.24,28.16 Q19.G
I2C_PCA9548_2N7002_G2_SDA: length 1.9
  TOP w0.254: R163.2 v1(311.84,28.7) 312.05,28.49 Q22.G
I2C_PCA9548_2N7002_G_SCL: length 3.3
  TOP w0.254: Q20.G 123.84,34.09 v5(123.86,34.07) 123.81,34.02 123.34,34.02 122.81,34.54 R161.2
I2C_PCA9548_2N7002_G_SDA: length 3.2
  TOP w0.254: Q23.G 125.45,42.31 R191.2 126.34,43.43 126.76,43.85 v5(126.9,43.85)
I2C_PCA9548_SC0_SLOT4_R_SCL: length 3.3
  TOP w0.114: R20.1 306.02,42.39 v1(305.89,42.27) 305.44,41.81 U2.5
I2C_PCA9548_SC0_SLOT4_SCL: length 61.4
  TOP w0.114: v1(292.94,86.36) 292.22,87.08 Q13.D 292.22,89.38 292.03,89.57 R224.1 ; R20.2 306.02,44.09 v1(305.4,44.71) 305.41,44.71 306.02,45.32 R96.2
  IN2 w0.112: v1(292.94,86.36) 295.12,86.36 296.31,85.18 296.31,85 300.16,81.15 303.99,81.15 305.1,80.05 305.1,75.11 302.09,72.1 302.09,50.69 300.94,49.54 300.94,46.67 302.02,45.59 305.13,45.59 305.4,45.33 v1(305.4,44.71)
I2C_PCA9548_SC1_SLOT3_R_SCL: length 3.5
  TOP w0.114: U2.7 304.14,41.12 v1(303.73,41.53) 303.1,42.16 R22.1
I2C_PCA9548_SC1_SLOT3_SCL: length 39.4
  TOP w0.114: R222.1 292.03,69.2 292.22,69.01 Q14.D 292.22,66.04 v1(292.22,66.04) ; R98.2 v1(303.73,44.7) 303.1,44.07 R22.2
  BOTTOM w0.114: v1(303.73,44.7) 303.86,44.83 303.86,45.09 303.44,45.5 299.23,45.5 298.33,46.4 298.33,48.88 301.07,51.61 301.07,62.15 296.89,66.33 292.51,66.33 v1(292.22,66.04)
I2C_PCA9548_SC2_SLOT2_R_SCL: length 3.6
  TOP w0.114: U2.9 302.84,40.9 301.45,42.29 v1(301.45,42.42) R24.1
I2C_PCA9548_SC2_SLOT2_SCL: length 17.6
  TOP w0.114: v1(293.35,46.94) 293.27,46.86 Q15.D 292.22,47.8 292.43,48.01 292.43,48.64 292.03,49.04 R226.1 ; R100.2 v1(301.45,44.7) R24.2
  IN3 w0.112: v1(293.35,46.94) 297.35,46.94 298.16,46.13 299.13,46.13 299.24,46.01 299.24,45.45 299.35,45.34 299.62,45.34 299.73,45.45 299.73,46.01 299.84,46.13 300.11,46.13 300.22,46.01 300.22,45.45 300.33,45.34 300.6,45.34 300.72,45.45 300.72,46.01 300.83,46.13 301.27,46.13 301.45,45.95 v1(301.45,44.7)
I2C_PCA9548_SC3_SLOT1_R_SCL: length 7.2
  TOP w0.114: U2.11 301.54,40.93 301.25,41.22 300.76,41.22 300.67,41.13 300.66,41.13 300.05,40.52 v1(300.05,39.95) 299.54,39.95 299.03,40.46 299.03,43.03 R26.1
I2C_PCA9548_SC3_SLOT1_SCL: length 26.9
  TOP w0.114: R26.2 299.16,44.3 299.06,44.41 299.06,44.61 298.91,44.76 v1(298.88,44.81) 299.14,45.06 299.14,45.43 R102.2 ; R228.1 292.03,28.65 292.22,28.46 Q21.D v1(293.35,26.54)
  BOTTOM w0.114: v1(293.35,26.54) 293.36,26.53 295.26,26.53 297.46,28.73 297.46,30.44 297.58,30.56 297.58,30.57 298.53,31.53 298.53,42.63 298.54,42.64 298.54,44.46 v1(298.88,44.81)
I2C_PCA9548_SC5_3V3_PE_SCL: length 186.9
  TOP w0.114: CON1.2 191.74,113.78 192.75,112.76 192.75,104.31 200.86,96.19 200.86,95.25 v1(200.92,95.2) ; v1(125.84,36.9) 125.84,35.84 Q20.S 124.74,36.75 123.22,36.75 122.82,36.34 R194.2 R234.2 122.28,37.54 120.78,37.54 120.42,37.18 U12.7
  IN1 w0.097: v1(208.36,36.2) 202.64,41.91 151.59,41.91 148.69,44.81 130.48,44.81 126.29,40.61 126.29,37.35 v1(125.84,36.9)
  IN2 w0.112: v1(200.92,95.2) 209.12,87 209.12,36.7 208.61,36.2 v1(208.36,36.2)
I2C_PCA9548_SC5_P1V8_SCL: length 63.4
  TOP w0.114: U12.2 120.42,42.39 v1(120.45,42.42)
  IN1 w0.097: v4(84.36,71.13) 84.84,70.66 84.84,66.85 84.53,66.55 82.04,66.55 81.78,66.29 81.78,62.57 85.42,58.93 85.42,57.9 90.62,52.7 97.98,52.7 101.35,49.33 113.67,49.33 120.45,42.55 v1(120.45,42.42)
  BOTTOM w0.114: R277.2 120.09,41.88 120.45,42.24 v1(120.45,42.42) ; U1.R8 v4(84.36,71.13)
I2C_PCA9548_SC5_PE_R_SCL: length 3.8
  TOP w0.114: R28.1 302.06,31.87 302.83,31.87 v1(302.84,31.88) U2.16
I2C_PCA9548_SC5_PE_SCL: length 198.3
  TOP w0.114: R104.2 v1(301.83,29.97) R28.2 ; R234.1 124.62,38.12 Q20.D 125.45,37.95 v1(125.7,37.69)
  IN3 w0.112: v1(301.83,29.97) 301.7,29.97 301.44,29.71 301.44,29.07 300.81,28.45 298.1,28.45 297.26,27.61 297.26,24.64 295.99,23.37 283.67,23.37 281.67,25.36 190.8,25.36 178.64,37.53 154.19,37.53 152.35,39.37 146.95,39.37 142.83,43.49 128.78,43.49 126.34,41.05 126.34,38.2 v1(125.7,37.69)
I2C_PCA9548_SC6_3V3_CLK_R_SCL: length 7
  TOP w0.114: R90.2 314.05,57.86 v1(313.23,58.67) 313.23,58.42 309.7,54.89 U3.9
I2C_PCA9548_SC6_3V3_CLK_SCL: length 38.1
  TOP w0.114: Q19.S 314.34,28.45 314.55,28.66 R236.2 314.91,29.34 315.47,29.89 v1(315.47,30.36) R193.2 ; v1(317.98,58.17) 315.67,58.17 315.31,57.81 R90.1
  BOTTOM w0.114: v1(317.98,58.17) 318.85,57.3 318.85,33.67 317.28,32.1 317.28,31.94 317.57,31.65 317.57,31.44 317.37,31.24 317.2,31.24 316.88,31.56 316.74,31.56 315.54,30.36 v1(315.47,30.36)
I2C_PCA9548_SC6_CLK_R_SCL: length 3.4
  TOP w0.114: R30.1 304.12,32.04 v1(304.72,32.64) 304.72,33.18 304.14,33.76 U2.18
I2C_PCA9548_SC6_CLK_SCL: length 241.5
  TOP w0.114: R183.1 190.17,82.93 202.62,70.48 276.88,70.48 278.53,72.14 279.21,72.14 v1(279.47,72.4) ; R280.2 312.88,32.8 v1(312.88,32.4) 313.42,31.86 313.42,29.67 R236.1 313.75,28.56 313.51,28.32 313.51,26.16 314.36,25.32 Q19.D ; R106.2 v1(304.12,29.97) 303.86,29.97 303.73,30.1 303.73,30.61 303.96,30.84 R30.2
  IN1 w0.097: v1(279.47,72.4) 279.47,72.4 279.82,72.4 280.01,72.59 285.42,72.59 285.59,72.41 286.33,71.67 297.13,71.67 301.81,76.35 304.91,76.35 306.38,77.82 313.31,77.82 314.12,78.64 315,78.64 315.31,78.32 315.31,77.87 v1(314.78,77.34)
  IN2 w0.112: v1(312.88,32.4) 312.88,32.83 313.83,33.78 313.83,38.03 317.95,42.16 317.95,47.5 316.18,49.28 316.18,53.47 314.53,55.12 314.53,59.44 312.47,61.49 309.45,61.49 308.89,62.05 307.31,62.05 304.08,65.29 304.08,70.83 310.82,77.57 314.56,77.57 v1(314.78,77.34)
  IN3 w0.112: v1(312.88,32.4) 311.7,31.23 305.37,31.23 v1(304.12,29.97)
  BOTTOM w0.114: R299.1 v1(314.78,77.34)
I2C_PCA9548_SC6_EMC1053_SCL: length 9.1
  TOP w0.114: v1(166.64,81.9) 165.97,82.58 165.97,85.42 165.3,86.09 U10.10
  TOP w0.127: R183.2 167.81,81.9 v1(166.64,81.9)
I2C_PCA9548_SC6_EMC1412_SCL: length 4.6
  BOTTOM w0.127: U4.8 310.68,77.76 310.85,77.6 310.85,76.96 v2(311.61,76.2) 312.75,77.34 R299.2
I2C_PCA9548_SC6_FRU_SCL: length 2.2
  TOP w0.127: U7.6 v1(312.62,34.54) 313.13,34.04 R280.1
I2C_PCA9548_SD0_SLOT4_R_SDA: length 4.2
  TOP w0.114: R19.1 307.16,43.14 307.77,42.53 307.77,42.36 v1(307.6,42.19) 307.29,41.88 306.93,41.88 306.09,41.04 U2.4
I2C_PCA9548_SD0_SLOT4_SDA: length 68.1
  TOP w0.114: R225.1 288.22,88.9 288.03,88.71 Q16.D 288.03,86.53 v1(287.86,86.36) ; R95.2 v1(307.16,44.7) R19.2
  IN2 w0.112: v1(287.86,86.36) 288.98,87.48 294.45,87.48 296.62,85.31 296.62,85.13 300.29,81.47 304.12,81.47 305.41,80.18 305.41,74.98 302.4,71.97 302.4,50.56 301.26,49.41 301.26,46.8 302.15,45.91 305.26,45.91 306.47,44.7 v1(307.16,44.7)
I2C_PCA9548_SD1_SLOT3_R_SDA: length 4.7
  TOP w0.114: U2.6 304.79,41.84 303.94,42.7 303.94,43.36 v1(303.99,43.41) 304.27,43.41 304.54,43.14 304.85,43.14 R21.1
I2C_PCA9548_SD1_SLOT3_SDA: length 44
  TOP w0.114: R223.1 288.22,68.66 288.03,68.47 Q17.D 288.03,66.81 v1(288.83,66.01) ; R97.2 304.88,45.09 v1(304.54,44.74) 304.54,44.54 304.88,44.2 R21.2
  BOTTOM w0.114: v1(304.54,44.74) 304.54,45.02 303.67,45.89 299.38,45.89 298.71,46.56 298.71,48.72 301.45,51.45 301.45,62 301.45,62 301.45,62.31 297.05,66.71 292.35,66.71 292.34,66.7 289.51,66.7 v1(288.83,66.01)
I2C_PCA9548_SD2_SLOT2_R_SDA: length 5.7
  TOP w0.114: U2.8 303.49,40.88 302.73,41.65 302.3,44.4 v1(302.34,44.45) R23.1
I2C_PCA9548_SD2_SLOT2_SDA: length 20.9
  TOP w0.114: R99.2 301.32,47.88 v1(302.21,46.99) 302.21,46.63 R23.2 ; v1(291.67,45.85) 291.44,45.85 291.29,46 291.29,46.57 291,46.86 Q18.D 288.16,48.2 288.35,48.39 R227.1
  IN3 w0.112: v1(291.67,45.85) 291.67,46.02 293.17,47.53 297.2,47.53 298.27,46.46 301.68,46.46 v1(302.21,46.99)
I2C_PCA9548_SD3_SLOT1_R_SDA: length 5.4
  TOP w0.114: R25.1 299.54,42.4 v1(299.54,41.91) 299.77,41.68 301.42,41.68 302.19,40.91 U2.10
I2C_PCA9548_SD3_SLOT1_SDA: length 32.9
  TOP w0.114: R101.2 300.31,44.96 v1(300.15,44.81) 300.15,44.5 300.31,44.35 R25.2 ; v1(289.16,26.54) Q24.D 288.03,27.75 288.22,27.94 R233.1
  BOTTOM w0.114: v1(289.16,26.54) 290.3,25.4 294.87,25.4 297.96,28.49 297.96,30.42 298.91,31.37 298.91,42.47 300.15,43.71 v1(300.15,44.81)
I2C_PCA9548_SD5_3V3_PE_SDA: length 183.8
  TOP w0.114: v1(123.78,40.69) 123.84,40.75 Q23.S 122.7,40.87 R209.2 R235.2 122.32,39.9 121.99,39.56 121.99,38.4 121.57,37.97 120.37,37.97 119.77,37.37 U12.6 ; CON1.3 189.25,111.78 188.62,111.15 188.62,108.44 192.07,104.99 192.07,104.28 200.1,96.25 v1(200.1,96.24)
  IN1 w0.097: v1(208.35,36.96) 203.09,42.21 151.71,42.21 148.82,45.11 130.36,45.11 126.37,41.12 124.21,41.12 v1(123.78,40.69)
  IN2 w0.112: v1(208.35,36.96) 208.35,87.01 200.1,95.25 v1(200.1,96.24)
I2C_PCA9548_SD5_P1V8_SDA: length 62.2
  TOP w0.114: v1(119.29,43.01) 119.77,42.54 U12.3
  IN1 w0.097: v1(119.29,43.01) 113.77,48.54 101.58,48.54 97.79,52.32 89.99,52.32 85.12,57.2 85.12,58.81 81.48,62.44 81.48,67.06 82.04,67.61 83.57,67.61 83.87,67.92 83.87,69.7 84.31,70.13 v4(84.36,70.13)
  BOTTOM w0.114: v1(119.29,43.01) 119.36,42.95 119.36,41.78 119.08,41.5 R278.2 ; U1.R7 v4(84.36,70.13)
I2C_PCA9548_SD5_PE_R_SDA: length 3.5
  TOP w0.114: U2.15 302.19,33.58 301.75,33.15 v1(301.75,33.02) 301.75,32.71 R27.1
I2C_PCA9548_SD5_PE_SDA: length 198.4
  TOP w0.114: R235.1 124.07,39.1 Q23.D 125.26,39.82 v1(125.81,39.27) ; R103.2 v1(300.69,29.97) R27.2
  IN3 w0.112: v1(300.69,29.97) 300.87,29.97 301.12,29.72 301.12,29.58 301.12,29.2 300.68,28.76 297.97,28.76 296.94,27.74 296.94,24.77 295.86,23.68 283.8,23.68 281.8,25.68 190.93,25.68 178.77,37.85 154.51,37.85 152.6,39.75 147.02,39.75 142.96,43.8 128.46,43.8 125.81,41.15 125.81,40.61 125.7,40.5 125.16,40.5 125.05,40.39 125.05,39.99 125.16,39.88 125.7,39.88 125.81,39.77 v1(125.81,39.27)
I2C_PCA9548_SD6_3V3_CLK_R_SDA: length 5.8
  TOP w0.114: R89.2 v1(313.26,56.66) 312.1,56.66 309.93,54.49 U3.8
I2C_PCA9548_SD6_3V3_CLK_SDA: length 39.4
  TOP w0.114: Q22.S 310.15,28.45 310.07,28.53 R237.2 310.07,29.7 310.34,29.97 310.67,29.97 v1(310.9,30.2) R204.2 ; R89.1 315.16,56.66 315.77,57.28 v1(316.05,57.28)
  BOTTOM w0.114: v1(316.05,57.28) 317.07,57.28 318.47,55.88 318.47,33.91 315.88,31.32 313.78,31.32 312.66,30.2 v1(310.9,30.2)
I2C_PCA9548_SD6_CLK_R_SDA: length 5.5
  TOP w0.114: U2.17 303.49,31.12 302.97,30.61 v1(302.97,29.86) R29.1
I2C_PCA9548_SD6_CLK_SDA: length 241.2
  TOP w0.114: R279.2 v1(311.99,32.41) 311.99,30.46 R237.1 310.87,28.56 311.1,28.32 Q22.D ; R184.1 190.65,81.92 202.47,70.1 277.03,70.1 278.69,71.75 279.35,71.75 v1(279.47,71.63) ; R105.2 302.97,27.54 v1(302.97,27.69) R29.2
  IN1 w0.097: v1(279.47,71.63) 280.14,72.29 285.29,72.29 286.21,71.37 297.26,71.37 301.93,76.05 305.03,76.05 306.5,77.52 313.43,77.52 314.01,78.11 v1(314.78,78.11)
  IN2 w0.112: v1(314.78,78.11) 314.57,77.89 310.69,77.89 303.73,70.93 303.73,65.18 307.18,61.74 308.76,61.74 309.32,61.18 312.34,61.18 314.22,59.31 314.22,54.99 315.87,53.34 315.87,49.15 317.64,47.37 317.64,42.29 313.51,38.16 313.51,33.91 312.02,32.41 v1(311.99,32.41)
  IN3 w0.112: v1(302.97,27.69) 303.56,28.27 303.56,30.57 304.54,31.55 311.53,31.55 311.99,32 v1(311.99,32.41)
  BOTTOM w0.114: R300.1 314.53,78.36 v1(314.78,78.11)
I2C_PCA9548_SD6_EMC1053_SDA: length 10.9
  TOP w0.114: U10.9 165.21,85.59 165.56,85.24 165.56,82.83 165.06,82.33 v1(164.47,82.33)
  TOP w0.127: R184.2 168.18,81.25 165.55,81.25 v1(164.47,82.33)
I2C_PCA9548_SD6_EMC1412_SDA: length 3.3
  BOTTOM w0.127: R300.2 311.86,78.36 v2(311.61,78.11) 311.3,78.41 U4.7
I2C_PCA9548_SD6_FRU_SDA: length 3.3
  TOP w0.127: R279.1 311.29,33.85 v1(310.59,34.54) 311.35,35.31 U7.5
I2C_PE_SCL: length 8.8
  BOTTOM w0.114: R86.1 v2(291.92,10.79) 291.54,10.41 291.54,6.22 291.83,5.94 J5.B5
I2C_PE_SCL_R: length 33.8
  TOP w0.114: U2.22 306.74,33.39 307.8,32.33 R87.2 307.45,31.64 307.34,31.53 307.34,30.34 308.22,29.46 v1(308.69,29.46)
  BOTTOM w0.114: R86.2 294.51,15.43 297.18,15.43 308.8,27.05 v2(309.2,27.05) 310.08,27.94 310.08,29.03 309.65,29.46 v1(308.69,29.46)
I2C_PE_SDA: length 8.8
  BOTTOM w0.114: R85.1 v2(290.02,10.79) 290.83,9.99 J5.B6
I2C_PE_SDA_R: length 33.6
  TOP w0.114: v1(308.69,28.57) 309.63,29.51 309.63,31.29 309.28,31.64 R88.2 308.81,32.12 307.39,33.55 U2.23
  BOTTOM w0.114: v1(308.69,28.57) 308.69,27.46 297.03,15.8 294.31,15.8 292.08,13.56 290.3,13.56 290.02,13.28 R85.2
I2C_SLOT1_2N7002_G_SCL: length 2.4
  TOP w0.254: Q21.G 295.15,24.86 v1(295.15,24.51) 295.02,24.38 R162.2
I2C_SLOT1_2N7002_G_SDA: length 2.4
  TOP w0.254: R192.2 289.54,24.38 v1(289.41,24.51) 289.41,24.77 Q24.G
I2C_SLOT1_3V3_SCL: length 14.4
  TOP w0.114: v1(293.07,28.07) 292.83,28.3 R228.2 R203.2 293.81,28.1 Q21.S
  IN1 w0.097: J1.B5 291.83,36.9 292.81,35.92 292.81,34.8 291.86,33.85 291.86,29.27 v1(293.07,28.07)
I2C_SLOT1_3V3_SDA: length 15.6
  TOP w0.114: v1(289.02,28.07) R233.2 R210.2 290,28.48 290.23,28.25 Q24.S
  IN1 w0.097: J1.B6 290.83,34.72 289.89,33.78 289.89,28.94 v1(289.02,28.07)
I2C_SLOT2_2N7002_G_SCL: length 2.1
  TOP w0.254: Q15.G 295.07,45.26 v1(295.07,44.83) 294.95,44.7 R107.2
I2C_SLOT2_2N7002_G_SDA: length 2.2
  TOP w0.254: Q18.G 289.76,45.32 v1(289.76,44.83) 289.89,44.7 R153.2
I2C_SLOT2_3V3_SCL: length 14.3
  TOP w0.114: v1(293.07,48.39) 292.83,48.62 R226.2 R156.2 293.81,48.79 294.42,48.18 Q15.S
  IN1 w0.097: J2.B5 292.69,57.22 292.69,54.99 291.92,54.23 291.92,51.94 292.05,51.82 292.05,49.4 v1(293.07,48.39)
I2C_SLOT2_3V3_SDA: length 15.2
  TOP w0.114: v1(289.15,48.39) R227.2 R159.2 290.13,48.72 290.36,48.49 Q18.S
  IN1 w0.097: v1(289.15,48.39) 289,49.02 289,49.91 290.05,53.88 290.72,54.93 J2.B6
I2C_SLOT3_2N7002_G_SCL: length 2.1
  TOP w0.254: R94.2 295.05,65.02 v1(295.18,65.15) 295.18,65.48 Q14.G
I2C_SLOT3_2N7002_G_SDA: length 4.4
  TOP w0.254: R152.2 290.38,65 v1(289.23,63.86) 289.23,65.23 Q17.G
I2C_SLOT3_3V3_SCL: length 15.4
  TOP w0.114: v1(292.79,68.73) 292.83,68.78 R222.2 R155.2 293.81,69.28 294.42,68.67 Q14.S
  BOTTOM w0.114: J3.B5 292.69,77.54 292.69,75.44 291.92,74.68 291.92,72.14 292.04,72.02 292.72,72.02 292.84,71.91 292.84,71.51 292.72,71.4 292.17,71.4 292.05,71.28 292.05,69.47 v1(292.79,68.73)
I2C_SLOT3_3V3_SDA: length 15.7
  TOP w0.114: v1(289.02,68.71) R223.2 R158.2 290,68.96 290.23,68.73 Q17.S
  BOTTOM w0.114: J3.B6 290.83,75.61 289.89,74.68 289.89,73.15 290.02,73.03 290.02,69.7 v1(289.02,68.71)
I2C_SLOT4_2N7002_G_SCL: length 2.2
  TOP w0.254: Q13.G 295.1,85.88 v1(295.1,85.47) 294.97,85.34 R93.2
I2C_SLOT4_2N7002_G_SDA: length 3.1
  TOP w0.254: R108.2 290.18,85.02 v1(289.38,85.02) 289.38,85.71 Q16.G
I2C_SLOT4_3V3_SCL: length 18.3
  TOP w0.114: Q13.S 294.42,88.8 293.81,89.41 R154.2 R224.2 292.83,89.13 v1(292.94,89.03)
  BOTTOM w0.114: v1(292.94,89.03) 292.05,89.92 292.05,91.35 292.16,91.46 293.44,91.46 293.55,91.58 293.55,91.97 293.44,92.09 292.16,92.09 292.05,92.2 292.05,92.59 292.16,92.71 292.8,92.71 292.91,92.82 292.91,93.22 292.8,93.33 292.16,93.33 291.97,93.52 291.97,95.05 292.69,95.76 292.69,97.86 J4.B5
I2C_SLOT4_3V3_SDA: length 15.6
  TOP w0.114: v1(289.02,89.05) R225.2 R157.2 290,89.41 290.23,89.18 Q16.S
  BOTTOM w0.114: J4.B6 290.83,95.81 290.02,95 290.02,90.04 v1(289.02,89.05)
PCA9617_EN: length 3.9
  TOP w0.114: U12.5 118.58,35.83 R296.2 R211.1 v5(116.66,37.08)
PCIE_SLOT1_WAKE_N: length 4.9
  TOP w0.127: R5.2 J1.B11
PCIE_SLOT2_WAKE_N: length 4.8
  TOP w0.127: R6.2 J2.B11
PCIE_SLOT3_WAKE_N: length 4.9
  TOP w0.127: J3.B11 285.83,82.22 286.21,82.6 R7.2
PCIE_SLOT4_WAKE_N: length 5.3
  TOP w0.127: R8.2 283.94,102.52 285.83,100.63 J4.B11
PCIE_X16_SLOT_PRES_N: length 114.5
  TOP w0.114: v1(293.76,12.5) R9.1 295.1,11.16 295.1,6.35 295.83,5.62 J5.A1
  IN2 w0.112: v1(293.76,12.5) 291.62,10.36 281.74,10.36 279.08,7.7 v1(277.37,7.7) 276.86,7.19 276.86,6.78 275.97,5.89 264.82,5.89 264.44,6.27 264.44,7.16 263.9,7.7 v1(263.78,7.7) 263.32,7.24 263.32,6.57 262.87,6.12 247.58,6.12 247.27,6.43 247.27,7.21 246.71,7.77 v1(246.38,7.77) 245.78,7.18 245.78,6.74 245.14,6.1 214.17,6.1 213.56,6.71 v1(213.56,7.04)
  BOTTOM w0.114: J5.B48 246.83,5.75 247.14,6.07 247.14,7.01 v1(246.38,7.77) ; v1(263.78,7.7) 264.36,7.11 264.36,6.05 263.83,5.51 J5.B31 ; v1(213.56,7.04) 213.83,6.78 J5.B81 ; v1(277.37,7.7) 278.13,6.94 278.13,5.94 277.83,5.64 J5.B17
PD_JTAG_TRST_N: length 38.7
  TOP w0.114: R346.1 v1(112.6,68.33)
  IN2 w0.112: v1(112.6,68.33) 111.9,67.62 102.26,67.62 99.44,64.8 99.44,63.68 98.07,62.3 87.06,62.3 85.85,63.52 85.85,69.64 v4(85.36,70.13)
  BOTTOM w0.114: U1.P7 v4(85.36,70.13)
PD_SLOT1_B81: length 5.7
  TOP w0.127: J1.B81 213.83,40.76 212.78,41.8 R200.2
PD_SLOT2_B81: length 4.9
  TOP w0.127: R199.2 213.8,58.1 J2.B81
PD_SLOT3_B81: length 4.8
  TOP w0.127: R198.2 213.93,81.89 213.83,81.79 J3.B81
PD_SLOT4_B81: length 5
  TOP w0.127: J4.B81 213.93,98.81 R197.2
PD_STRAP_RESERVED_0: length 28.4
  IN2 w0.112: v1(54.89,49.73) 56.06,50.9 56.06,58.9 55.53,59.43 55.53,62.41 60.66,67.54 65.96,67.54 v4(66.36,67.13)
  BOTTOM w0.114: R111.2 v1(54.89,49.73)
  BOTTOM w0.127: U1.AM4 v4(66.36,67.13)
PD_STRAP_RESERVED_1: length 28.2
  TOP w0.114: v1(63.34,51.79) 63.5,51.64 R112.2
  IN2 w0.089: 74.5,62.87 74.52,62.88 74.52,62.93 75.94,64.36 75.94,70.55 v6(75.36,71.13)
  IN2 w0.112: 74.5,62.87 71.78,60.15 69.93,60.15 68.73,58.95 67.46,58.95 64.4,55.89 64.4,53.79 63.66,53.05 63.66,52.11 v1(63.34,51.79)
  BOTTOM w0.127: U1.AC8 v6(75.36,71.13)
PD_STRAP_RESERVED_2: length 13.8
  TOP w0.089: v4(92.36,71.13) 92.55,70.94 92.99,70.94 93.39,70.54 99.5,70.54
  TOP w0.127: R164.2 v1(102.82,70.23) 102.16,70.23 101.84,70.55 99.51,70.55 99.5,70.54
  BOTTOM w0.127: U1.H8 91.36,71.13 v4(92.36,71.13)
PD_STRAP_RESERVED_3: length 35.1
  IN2 w0.112: v4(72.36,75.13) 71.91,74.68 63.09,74.68 52.65,64.24 52.65,57.14 54.05,55.73 54.05,55.5 v6(54.14,55.42)
  BOTTOM w0.114: R165.2 54.31,55.24 v6(54.14,55.42)
  BOTTOM w0.127: U1.AF12 v4(72.36,75.13)
PD_STRAP_RESERVED_4: length 30.7
  TOP w0.127: R166.2 v1(112.6,74.04)
  IN2 w0.112: v4(87.36,70.13) 88.24,70.13 88.85,69.52 88.85,68.83 89.05,68.63 99.06,68.63 99.65,69.22 99.65,70.48 101.8,72.64 111.2,72.64 v1(112.6,74.04)
  BOTTOM w0.127: U1.M7 v4(87.36,70.13)
PD_STRAP_RESERVED_5: length 22.5
  TOP w0.089: v4(92.36,72.13) 92.64,72.13 93.24,71.54 98.79,71.54 98.81,71.55
  TOP w0.127: R167.2 v1(112.6,72.14) 111.57,71.11 101.45,71.11 101.01,71.55 98.81,71.55
  BOTTOM w0.127: U1.G9 v4(92.36,72.13)
PD_STRAP_RESERVED_6: length 25.7
  IN2 w0.112: v4(64.36,68.13) 60.59,68.13 55.03,62.57 55.03,55.07 54.08,54.12 v1(54.08,53.93)
  BOTTOM w0.114: v1(54.08,53.93) 54.08,53.84 54.43,53.49 54.43,51.59 v2(54.74,51.28) 55.79,51.28 R168.2
  BOTTOM w0.127: U1.AP5 v4(64.36,68.13)
PD_STRAP_RESERVED_7: length 30.8
  IN2 w0.089: 75.96,62.87 75.98,62.88 75.98,62.93 76.52,63.47 76.52,68.38 76.98,68.83 76.98,71.07 76.47,71.58 75.74,71.58 75.36,71.96 v4(75.36,72.13)
  IN2 w0.112: 75.96,62.87 72.45,59.35 70.19,59.35 69.05,58.21 67.78,58.21 65.11,55.54 65.11,52.64 v6(64.72,52.25)
  BOTTOM w0.114: v6(64.72,52.25) 64.72,52.13 63.51,50.93 R169.2
  BOTTOM w0.127: U1.AC9 v4(75.36,72.13)
PD_STRAP_RESERVED_8: length 48.2
  TOP w0.114: v1(49.48,52.5) 50.29,52.5 R170.2
  IN2 w0.089: 63.91,82.4 64.05,82.54 71.77,82.54 v4(72.36,83.13)
  IN2 w0.112: 63.91,82.4 62.83,82.4 48.34,67.91 48.34,54.32 48.82,53.83 48.82,53.16 v1(49.48,52.5)
  BOTTOM w0.127: U1.AF19 v4(72.36,83.13)
PD_STRAP_RESERVED_9: length 44
  IN2 w0.112: v4(70.36,82.13) 69.93,81.7 63.17,81.7 48.6,67.13 48.6,54.6 v6(49.35,53.85)
  BOTTOM w0.114: R171.2 50.37,52.83 v6(49.35,53.85)
  BOTTOM w0.127: U1.AH18 v4(70.36,82.13)
PD_STRAP_RESERVED_10: length 30.3
  TOP w0.114: R173.1 54.97,58.06 54.97,58.66 55.1,58.78 R172.2 54.09,59.21 v6(53.93,59.37)
  IN2 w0.089: 63.2,71.24 63.69,71.73 69.52,71.73 70.94,73.15 70.94,73.52 71.03,73.61 71.86,73.61 72.34,73.13 v4(72.36,73.13)
  IN2 w0.112: v6(53.93,59.37) 53.9,59.4 53.9,63.11 62.02,71.24 63.2,71.24
  BOTTOM w0.127: U1.AF10 v4(72.36,73.13)
PD_STRAP_RESERVED_11: length 26.6
  IN2 w0.089: 72.12,63.05 72.13,63.07 72.19,63.07 73.97,64.85 73.97,69.73 v4(74.36,70.13)
  IN2 w0.112: v1(62.5,53.21) 62.01,53.71 62.01,54.62 67.13,59.74 68.4,59.74 70.16,61.5 70.57,61.5 72.12,63.05
  BOTTOM w0.114: R174.1 60.63,53.88 61.84,53.88 v1(62.5,53.21)
  BOTTOM w0.127: U1.AD7 v4(74.36,70.13)
PD_STRAP_RESERVED_12: length 24
  TOP w0.114: v6(58.32,51.59) 58.6,51.87 58.6,52.7 R175.1
  IN2 w0.112: v6(58.32,51.59) 58.48,51.75 58.48,52.82 57.32,53.98 57.32,61.13 62.79,66.6 65.05,66.6 65.36,66.91 v4(65.36,67.13)
  BOTTOM w0.127: U1.AN4 v4(65.36,67.13)
PD_STRAP_RESERVED_13: length 3.6
  TOP w0.114: R176.1 77.73,69.87 77.88,69.72 78.96,69.72 v6(79.36,70.13)
  BOTTOM w0.127: U1.V7 80.36,70.13 v6(79.36,70.13)
PD_STRAP_RESERVED_15: length 28.5
  TOP w0.114: R324.2 60.67,52.43 v1(61.5,52.43)
  IN2 w0.089: v4(75.36,70.13) 75.75,69.74 75.75,64.44 74.38,63.07 74.33,63.07 74.31,63.05
  IN2 w0.112: 74.31,63.05 74.32,63.05 71.67,60.41 69.82,60.41 68.62,59.22 67.35,59.22 64.08,55.94 64.08,53.86 63.37,53.15 63.37,52.84 62.95,52.43 v1(61.5,52.43)
  BOTTOM w0.127: U1.AC7 v4(75.36,70.13)
PD_STRAP_SNT0_PORTCFG1: length 33.5
  TOP w0.114: R318.1 53.89,56.64 v6(53.81,56.73)
  IN2 w0.112: v4(72.36,74.13) 72.28,74.22 70.31,74.22 69.75,73.66 62.61,73.66 52.91,63.97 52.91,57.25 53.43,56.73 v6(53.81,56.73)
  BOTTOM w0.127: U1.AF11 v4(72.36,74.13)
PD_STRAP_SNT1_PORTCFG1: length 27.6
  TOP w0.089: 97.08,73.55 97.06,73.54 90.77,73.54 v4(90.36,73.13)
  TOP w0.127: 97.08,73.55 101.4,73.55 101.8,73.15 114.76,73.15 v1(115.65,74.04) R319.1
  BOTTOM w0.127: U1.J10 v4(90.36,73.13)
PD_STRAP_SNT2_PORTCFG1: length 51.3
  TOP w0.114: R320.1 43.3,54.26 44.13,55.09 44.13,55.51 v6(45.49,56.87)
  IN2 w0.112: v6(45.49,56.87) 45.49,57.48 45.04,57.93 45.04,68.12 63.55,86.63 71.86,86.63 v4(72.36,86.13)
  BOTTOM w0.127: U1.AF23 v4(72.36,86.13)
PD_STRAP_SNT3_PORTCFG1: length 22.6
  TOP w0.127: v4(92.36,89.13) 92.9,89.66 98.88,89.66 100.03,88.52 111.58,88.52 v1(112.47,89.41) R321.1
  BOTTOM w0.127: U1.G25 v4(92.36,89.13)
PD_STRAP_SNT4_PORTCFG1: length 32.2
  TOP w0.114: 85.83,93.83 86.36,93.29 v4(86.36,91.13)
  TOP w0.127: 85.83,93.83 85.83,99.59 87.58,101.35 98.76,101.35 102.06,98.04 102.06,95.89 v1(102.82,95.12) R322.1
  BOTTOM w0.127: U1.N28 v4(86.36,91.13)
PD_STRAP_SNT5_PORTCFG1: length 29
  TOP w0.114: v4(89.36,90.13) 89.87,90.63 89.87,92.63 88.87,93.63
  TOP w0.127: R323.1 v1(102.82,93.22) 102.44,93.22 100.28,95.38 100.28,97.54 98.5,99.31 89.74,99.31 88.87,98.44 88.87,93.63
  BOTTOM w0.127: U1.K26 v4(89.36,90.13)
PD_VOE_N: length 21.1
  TOP w0.127: v1(303.35,52.32) 303.52,52.49 U3.28 ; U3.19 305.3,57.35 v1(305.25,57.4) ; v1(307.8,57.28) 307.7,57.18 U3.13 ; v1(302.97,49.66) 303.46,49.17 R76.2 304.52,50.08 304.76,50.08 305.3,50.62 U3.32 ; v1(303.35,54.99) 303.46,54.89 U3.22
  IN2 w0.112: v1(302.97,49.66) 303.82,50.5 303.82,51.86 v1(303.35,52.32) 304.12,53.09 304.12,54.23 v1(303.35,54.99) 303.84,55.47 303.84,55.99 v1(305.25,57.4) 305.76,57.91 307.16,57.91 v1(307.8,57.28)
PE_CPU_RX_C_DN<0>: length 219.3
  BOTTOM w0.089: 81.2,64.15 81.2,64.17 81.26,64.23 81.26,64.93 81.15,65.03 80.95,65.03 80.86,64.95 U1.V1
  BOTTOM w0.135: 81.2,64.15 81.2,63.97 81.21,63.96 81.24,63.75 81.49,63.4 82.25,62.87 83.64,62.62 88.09,61.97 97.75,61.48 97.88,61.47 97.89,61.47 98.01,61.35 100.36,61.35 102.86,61.22 114.81,63.33 124.82,70.34 134.76,72.09 154.39,68.63 155.69,67.73 v3(157.15,66.7) 165.25,61.03 170.64,60.08 203.29,37.21 210.3,32.3 267.07,22.29 275.63,16.29 275.66,16.08 275.99,15.85 276.21,15.89 276.54,15.66 276.58,15.44 276.91,15.21 277.12,15.25 277.28,15.13 277.29,15.13 277.66,14.87 278.02,14.36 278.18,13.42 278.18,12.69 C35.1
PE_CPU_RX_C_DN<1>: length 217
  BOTTOM w0.089: U1.W1 79.86,64.95 79.95,65.03 80.08,65.03 80.28,64.84 80.28,64.24 80.22,64.19 80.22,64.16
  BOTTOM w0.135: 80.22,64.16 80.22,64 80.28,63.65 81.14,62.42 82.25,61.65 82.89,61.53 87.06,60.89 102.22,59.71 115.07,61.98 115.87,62.53 125.4,69.21 134.66,70.84 152.99,67.59 v3(156.78,64.94) 164.55,59.5 170.98,58.36 209.83,31.16 209.83,31.16 262.3,21.9 266.04,19.28 266.47,19.36 266.79,19.82 266.98,19.85 267.5,19.49 267.53,19.31 267.21,18.85 267.29,18.41 270.59,16.09 270.63,15.88 270.96,15.65 271.17,15.69 271.51,15.45 271.54,15.24 271.87,15.01 272.09,15.05 272.58,14.7 273.03,14.05 273.18,13.23 273.18,12.69 C36.1
PE_CPU_RX_C_DN<2>: length 213.1
  BOTTOM w0.089: U1.Y1 78.86,64.95 78.95,65.03 79.17,65.03 79.26,64.94 79.26,64.12 79.21,64.06 79.21,64.04
  BOTTOM w0.135: C37.1 269.17,12.69 269.17,13.36 269.04,14.06 268.49,14.85 267.96,15.22 267.74,15.18 267.41,15.42 267.37,15.63 267.04,15.86 266.82,15.83 266.49,16.06 266.45,16.27 259.44,21.18 v3(253.35,22.26) 234.48,25.58 209.38,30.01 171.44,56.57 164.18,57.85 151.68,66.6 134.61,69.61 126.07,68.11 115.45,60.67 100.57,58.04 84.63,60.12 82.03,60.46 80.78,61.34 79.27,63.49 79.21,63.85 79.21,63.85 79.21,64.04
