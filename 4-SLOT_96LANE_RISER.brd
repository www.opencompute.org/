# Allegro board 4-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLV_TX_C_DN<9>: length 59.5
  TOP w0.089: v4(64.36,84.13) 64.68,84.13 64.76,84.05 64.76,83.91 64.58,83.72 63.28,83.72 63.22,83.78 63.2,83.78
  TOP w0.135: 63.2,83.78 61.39,83.78 60.81,83.68 59.14,82.51 57.7,81.5 57.09,81.07 54.41,77.25 53.53,76.18 53.34,75.95 51.96,74.33 51.79,74.13 50.69,73.12 49.9,72.57 48.92,71.89 48.92,71.89 v3(37.35,68.69) 31.1,66.97 29.4,66.58 29.01,66.51 27.49,66.24 27.31,66.36 26.91,66.29 26.79,66.12 26.16,66.01 22.26,63.27 22.21,62.97 21.1,62.2 20.11,62.02 18.8,62.26 18.67,62.43 18.28,62.5 18.1,62.38 17.7,62.45 16.6,62.26 16.2,62.26 16.05,62.41 15.64,62.41 15.49,62.26 14.8,62.26 C176.1
  BOTTOM w0.135: U1.AP20 v4(64.36,84.13)
PE_SLV_TX_C_DN<10>: length 60.3
  TOP w0.089: 63.2,84.78 63.22,84.78 63.27,84.72 64.66,84.72 64.8,84.86 64.8,85.06 64.73,85.13 v4(64.36,85.13)
  TOP w0.135: 63.2,84.78 61.4,84.78 61.4,84.78 60.04,84.54 56,81.7 53.03,77.45 52.46,76.76 51.01,75.09 50.16,74.32 48.76,73.34 46.99,72.62 44.93,72.08 40.03,70.91 35.1,70.02 v3(31.07,69.5) 29.99,69.36 29.11,69.21 27.54,68.93 27.29,68.57 27.39,68.02 27.28,67.86 26.91,67.8 26.75,67.9 26.66,68.46 26.29,68.71 24.08,68.32 24.01,68.31 18.74,64.62 18.35,64.55 18.17,64.68 17.77,64.61 17.65,64.43 16.83,64.29 15.98,64.29 15.83,64.44 15.42,64.44 15.27,64.29 14.8,64.29 C177.1
  BOTTOM w0.135: U1.AP21 v4(64.36,85.13)
PE_SLV_TX_C_DN<11>: length 58.4
  TOP w0.089: 63.2,85.79 63.25,85.73 64.58,85.73 64.73,85.88 64.73,86.08 64.68,86.13 v4(64.36,86.13)
  TOP w0.135: C178.1 14.8,66.32 15.45,66.32 16.14,66.2 16.32,66.32 16.72,66.25 16.84,66.07 17.24,66 17.56,66.06 17.68,66.24 18.08,66.31 18.26,66.18 18.32,66.19 19.08,66.33 20.02,66.99 20.06,67.2 20.39,67.43 20.61,67.4 23.54,69.45 v3(24.7,69.66) 44.71,73.27 46.1,73.64 47.92,74.31 49.24,75.23 49.68,75.55 50.3,76.24 52.63,79.04 52.91,79.4 55.47,82.68 59.21,85.29 62.01,85.79 63.2,85.79
  BOTTOM w0.135: U1.AP22 v4(64.36,86.13)
PE_SLV_TX_C_DN<12>: length 59.2
  TOP w0.089: 63.2,86.78 63.22,86.78 63.28,86.72 64.58,86.72 64.73,86.88 64.73,87.08 64.68,87.13 v4(64.36,87.13)
  TOP w0.135: 63.2,86.78 61.69,86.78 61.69,86.78 58.52,86.22 54.53,83.43 51.7,79.81 49.17,76.8 47.23,75.38 45.81,74.82 44.05,74.46 44.03,74.46 43.93,74.45 43.93,74.45 v3(38.89,73.76) 36.79,73.48 34.8,73.25 32.8,73.01 28.8,72.54 27.24,72.27 26.99,71.91 27.03,71.67 26.92,71.51 26.55,71.45 26.4,71.56 26.36,71.79 25.99,72.05 25.16,71.9 22.25,72.41 21.3,72.12 18.8,70.36 18.59,70.4 18.26,70.17 18.22,69.96 17.89,69.72 17.67,69.76 17.34,69.53 17.31,69.32 16.98,69.08 16.76,69.12 16.43,68.89 16.39,68.68 16.06,68.45 15.53,68.35 14.8,68.35 C179.1
  BOTTOM w0.135: U1.AP23 v4(64.36,87.13)
PE_SLV_TX_C_DN<13>: length 57.9
  TOP w0.089: 63.22,87.78 63.24,87.78 63.3,87.73 64.58,87.73 64.73,87.88 64.73,88.08 64.68,88.13 v4(64.36,88.13)
  TOP w0.135: C180.1 14.8,70.38 15.43,70.38 15.7,70.43 16.03,70.66 16.07,70.88 16.4,71.11 16.61,71.07 17.01,71.35 18.48,71.61 18.87,71.88 18.91,72.09 19.24,72.32 19.45,72.29 20.72,73.17 21.62,73.55 22.27,73.66 23.04,73.52 23.22,73.65 23.62,73.58 23.74,73.4 25.21,73.14 28.86,73.78 v3(32.24,74.22) 44.08,75.75 45.57,76.08 47.72,77.24 48.11,77.59 48.11,77.59 48.93,78.51 49.7,79.47 50.5,80.43 50.92,80.92 50.96,80.97 51.61,81.9 51.88,82.26 52.62,83.35 52.67,83.41 52.76,83.54 52.91,83.66 52.98,83.72 53.12,83.84 53.14,83.85 53.24,83.94 53.24,83.94 53.27,83.94 54.22,84.58 57.71,87.02 61.98,87.78 61.99,87.78 63.22,87.78
  BOTTOM w0.135: U1.AP24 v4(64.36,88.13)
PE_SLV_TX_C_DN<14>: length 59
  TOP w0.089: 63.96,88.79 63.98,88.79 64.04,88.73 64.67,88.73 64.83,88.88 64.83,89.06 64.75,89.13 v4(64.36,89.13)
  TOP w0.135: C181.1 14.8,72.42 15.22,72.42 15.64,72.49 16.09,72.8 16.48,73.37 16.44,73.58 16.67,73.91 16.89,73.95 17.12,74.28 18.21,75.04 18.63,75.12 18.76,75.29 19.15,75.36 19.33,75.24 22.99,75.88 23.86,75.73 24.11,75.37 24.06,75.06 24.17,74.9 24.54,74.84 24.69,74.94 24.75,75.26 25.11,75.51 25.46,75.45 25.51,75.44 v3(26.22,75.44) 26.93,75.43 29.1,75.57 35.59,75.98 40.44,76.51 43.57,76.94 45.16,77.27 47.15,78.41 47.5,78.73 47.85,79.15 47.86,79.16 49.58,81.2 49.99,81.68 49.99,81.69 51.87,84.37 52.83,85.14 56.72,87.87 61.9,88.78 61.91,88.79 63.96,88.79
  BOTTOM w0.135: U1.AP25 v4(64.36,89.13)
PE_SLV_TX_C_DN<15>: length 57.2
  TOP w0.089: 64.04,89.78 64.06,89.78 64.11,89.72 64.63,89.72 64.8,89.89 64.8,90.04 64.71,90.13 v4(64.36,90.13)
  TOP w0.135: 64.04,89.78 61.8,89.78 61.79,89.78 55.86,88.73 52.91,86.67 52.49,86.37 52.21,86.18 52.18,86.17 50.99,85.2 50.25,84.28 48.43,81.7 46.98,79.98 46.86,79.88 46.18,79.27 45.19,78.7 42.59,78.06 40.44,77.74 34.96,77.44 24.27,77.22 23.96,77.22 23.26,77.16 21.64,77.02 v3(20.51,76.82) 18,76.38 17.1,75.74 16.89,75.78 16.56,75.54 16.52,75.33 16.19,75.09 15.98,75.13 15.65,74.9 15.61,74.68 15.29,74.45 14.8,74.45 C182.1
  BOTTOM w0.135: U1.AP26 v4(64.36,90.13)
PE_SLV_TX_C_DP<0>: length 67.5
  TOP w0.089: 65.02,73.54 65.02,73.56 64.96,73.62 64.96,74.04 65.05,74.13 v4(65.36,74.13)
  TOP w0.135: C151.1 15.44,37.69 16.78,37.69 17.84,37.88 18.22,38.15 20.23,38.5 21.42,38.71 22.96,39.79 24.74,40.1 24.89,39.99 24.96,39.58 25.33,39.33 26.2,39.48 26.45,39.84 26.38,40.25 26.49,40.41 26.52,40.41 26.58,40.45 35.37,46.61 40.59,54.07 43.77,57.03 45.2,58.11 45.98,58.51 51.44,60.11 52.81,60.49 53.9,61.03 54.94,61.54 55.96,61.92 59.05,64.74 59.44,65.1 60.76,66.31 v3(61.14,66.74) 61.99,67.7 62.62,68.78 62.66,68.85 65.02,72.91 65.02,73.54
  BOTTOM w0.135: U1.AN11 v4(65.36,74.13)
PE_SLV_TX_C_DP<1>: length 66.1
  TOP w0.089: v4(65.36,75.13) 65.05,75.13 64.99,75.07 64.99,74.8 64.72,74.54 63.74,74.54 63.45,74.24 63.45,73.92 63.51,73.86 63.51,73.84
  TOP w0.135: 63.51,73.84 63.51,73.67 63.48,73.55 v3(63.32,73.19) 62.62,71.61 62.29,70.85 61.78,69.71 61.71,69.6 61.52,69.3 59.8,67.44 59.8,67.44 58.27,65.79 57.59,65.06 57.59,65.05 54.31,62.62 51.65,61.49 51.26,61.34 51.26,61.34 49.82,60.94 48.15,60.48 45.58,59.69 44.75,59.3 42,57.23 39.43,54.84 37.72,52.4 36.28,50.34 34.04,47.15 26.12,41.6 22.38,40.94 21.21,40.13 20.01,39.91 17.89,39.54 16.84,39.73 15.44,39.73 C152.1
  BOTTOM w0.135: U1.AN12 v4(65.36,75.13)
PE_SLV_TX_C_DP<2>: length 67.1
  TOP w0.089: 63.44,75.48 63.46,75.48 63.52,75.54 64.74,75.54 64.99,75.79 64.99,76.07 65.05,76.13 v4(65.36,76.13)
  TOP w0.135: 63.44,75.48 63.23,75.48 63.09,75.39 62.46,74.48 62.4,74.14 62.38,74.07 61.06,71.07 60.86,70.61 59.5,68.89 58.07,67.34 56.48,65.77 54.64,64.4 51.85,63.04 49,62.01 47.34,61.5 45.6,61.05 43.85,60.22 v3(43.57,60.01) 41.06,58.04 40.2,57.27 38.27,55.55 35.46,51.54 34.35,49.96 33.92,49.88 33.61,50.09 33.42,50.06 33.21,49.75 33.24,49.57 33.55,49.35 33.63,48.92 32.81,47.75 25.77,42.82 23.56,42.43 22.9,42.55 22.55,42.79 20.15,43.21 19.79,43.15 17.87,41.81 16.89,41.63 16.18,41.76 15.44,41.76 C153.1
  BOTTOM w0.135: U1.AN13 v4(65.36,76.13)
PE_SLV_TX_C_DP<3>: length 65.8
  TOP w0.089: 63.36,76.47 63.38,76.47 63.44,76.53 64.65,76.53 64.92,76.8 64.92,77.06 64.99,77.13 v4(65.36,77.13)
  TOP w0.135: C154.1 15.44,43.79 15.79,43.79 16.54,43.66 17.36,43.51 17.91,43.61 18.42,43.97 19.83,45.98 20.05,47.26 20.66,48.12 23.58,52.3 25.7,53.78 28.49,54.27 32.17,53.62 33.61,53.88 36.55,55.94 38.63,57.5 41.64,60.2 43.09,61.19 44.11,61.72 v3(44.48,61.9) 45.15,62.21 47.02,62.67 48.46,63.12 50.03,63.68 52.72,64.94 55.1,66.4 56.27,67.28 56.96,68 57.9,68.97 58.81,70.14 59.43,70.95 60.22,71.96 60.25,72.02 61.12,73.86 61.15,73.94 61.23,74.41 62.49,76.21 62.78,76.41 63.13,76.47 63.36,76.47
  BOTTOM w0.135: U1.AN14 v4(65.36,77.13)
PE_SLV_TX_C_DP<4>: length 64.5
  TOP w0.089: 63.4,77.48 63.42,77.48 63.48,77.54 64.78,77.54 64.99,77.75 64.99,78.04 65.08,78.13 v4(65.36,78.13)
  TOP w0.135: 63.4,77.48 62.75,77.48 62.35,77.41 61.81,77.03 60.03,74.49 60.02,74.47 59.15,72.57 59.12,72.51 58.22,71.35 56.54,69.63 55.52,68.49 55.51,68.48 55.35,68.33 53.31,66.86 51.5,65.82 51.04,65.68 49.64,65.19 43.1,62.89 40.28,62.12 35.96,60.86 31.52,57.75 30.33,56.92 30.3,56.73 30.5,56.43 30.43,56 29.91,55.64 29.48,55.71 29.27,56.01 29.08,56.04 28.23,55.45 25.23,54.92 22.35,52.9 21.41,51.56 v3(19.76,49.21) 18.4,47.26 16.47,45.91 15.94,45.82 15.44,45.82 C155.1
  BOTTOM w0.135: U1.AN15 v4(65.36,78.13)
PE_SLV_TX_C_DP<5>: length 62.7
  TOP w0.089: v4(65.36,79.13) 64.98,79.13 64.92,79.07 64.92,78.8 64.66,78.53 63.52,78.53 63.47,78.48 63.44,78.48
  TOP w0.135: C156.1 15.44,47.85 16.1,47.85 16.65,47.95 17.78,48.74 19.22,50.8 19.22,50.8 19.41,51.07 20.25,52.27 21.21,53.64 24.84,56.18 27.78,56.7 35.1,61.83 35.73,62.13 35.77,62.14 36.21,62.26 36.32,62.29 37.68,62.66 37.69,62.68 42.23,63.96 v3(47.04,65.66) 49.4,66.5 51.27,67.1 51.37,67.16 52.31,67.71 52.46,67.81 52.58,67.9 52.76,68.01 55.41,70.17 57.58,72.6 57.6,72.62 57.68,72.72 57.7,72.74 57.99,73.1 58.07,73.21 58.28,73.48 58.72,74.15 58.78,74.24 58.79,74.24 58.96,74.48 58.98,74.51 61.6,78.26 62.83,78.48 63.44,78.48
  BOTTOM w0.135: U1.AN16 v4(65.36,79.13)
PE_SLV_TX_C_DP<6>: length 64.1
  TOP w0.089: v4(65.36,80.13) 65.05,80.13 64.99,80.07 64.99,79.8 64.72,79.53 63.5,79.53 63.44,79.48 63.42,79.48
  TOP w0.135: 35.47,63.31 35.46,63.31 35.47,63.31 ; 35.47,63.31 35.47,63.31 35.58,63.34 35.58,63.34 v3(41.58,65.03) 41.87,65.11 49.58,67.83 51.07,68.41 52.37,69.26 54.97,71.5 54.98,71.51 56.68,73.4 56.82,73.56 56.9,73.67 60.5,78.81 61.24,79.32 62.13,79.48 63.42,79.48 ; 35.47,63.31 35.34,63.27 34.68,63.1 34.57,63.07 34.52,63.05 33.97,62.85 28.69,59.16 28.26,59.23 27.8,59.88 27.61,59.92 27.31,59.7 27.27,59.51 27.73,58.86 27.65,58.43 26.64,57.72 24.16,57.28 20.14,54.47 17.27,50.37 16.76,50.01 16.04,49.89 15.44,49.89 C157.1
  BOTTOM w0.135: U1.AN17 v4(65.36,80.13)
PE_SLV_TX_C_DP<7>: length 62.5
  TOP w0.135: C158.1 15.44,51.92 15.94,51.92 16.46,52.01 16.87,52.3 18.18,54.17 18.87,55.15 23.39,58.32 25.01,60.62 29.53,63.79 31.71,64.17 33.54,64.5 v3(34.99,64.83) 38.69,65.67 38.71,65.67 44.28,67.52 44.95,67.69 49.8,69.25 49.88,69.28 50.95,69.8 50.99,69.83 51.35,70.08 51.61,70.26 53.56,71.88 53.64,71.95 54.9,73.29 54.92,73.31 56.65,75.43 56.67,75.45 57.52,76.67 57.54,76.7 59.57,79.58 60.95,80.55 62.64,80.85 64.67,80.85 65.02,81.19 65.02,81.78 v4(65.36,82.13)
  BOTTOM w0.135: U1.AN18 v4(65.36,82.13)
PE_SLV_TX_C_DP<8>: length 60.3
  TOP w0.089: v4(65.36,83.13) 65,83.13 64.92,83.06 64.92,82.8 64.66,82.54 63.73,82.54 63.68,82.48 63.66,82.48
  TOP w0.135: 63.66,82.48 63.01,82.48 61.14,82.15 58.66,80.41 55.99,76.61 55.46,75.93 54.98,75.4 53.07,73.24 52.9,73.06 52.68,72.85 51.34,71.67 49.77,70.58 49.48,70.46 31.85,65.48 28.15,64.78 27.68,64.69 v3(26.55,63.91) 20.77,59.86 19.17,58.74 18.06,58.54 17.3,58.68 16.5,59.24 15.64,59.84 15.21,59.92 14.8,59.92 C159.1
  BOTTOM w0.135: U1.AN19 v4(65.36,83.13)
PE_SLV_TX_C_DP<9>: length 59.4
  TOP w0.089: v4(65.36,84.13) 65.01,84.13 64.95,84.07 64.95,83.83 64.66,83.53 63.28,83.53 63.22,83.48 63.2,83.48
  TOP w0.135: C160.1 14.8,61.95 16.63,61.95 17.7,62.14 18.74,61.96 18.74,61.95 20.11,61.71 21.22,61.91 22.48,62.79 22.54,63.1 26.28,65.72 29.46,66.28 31.17,66.67 v3(39.91,69.08) 49.06,71.61 50.89,72.9 51.99,73.9 52.19,74.13 53.58,75.75 53.77,75.99 54.65,77.05 54.66,77.07 57.31,80.85 57.57,81.04 57.88,81.25 57.88,81.25 60.93,83.39 61.42,83.48 63.2,83.48
  BOTTOM w0.135: U1.AN20 v4(65.36,84.13)
PE_SLV_TX_C_DP<10>: length 60.3
  TOP w0.089: v4(65.36,85.13) 65.05,85.13 64.99,85.07 64.99,84.78 64.74,84.53 63.27,84.53 63.22,84.48 63.2,84.48
  TOP w0.135: 63.2,84.48 61.45,84.48 60.16,84.25 56.22,81.48 53.27,77.27 53.2,77.18 52.69,76.57 51.23,74.88 50.36,74.09 48.91,73.07 47.08,72.33 45,71.79 45,71.79 40.09,70.61 35.16,69.72 v3(33.87,69.55) 30.04,69.05 29.16,68.91 29.17,68.91 29.16,68.91 27.72,68.66 27.61,68.5 27.71,67.94 27.46,67.58 26.84,67.47 26.47,67.73 26.38,68.28 26.22,68.39 24.13,68.02 18.86,64.34 16.86,63.98 14.8,63.98 C161.1
  BOTTOM w0.135: U1.AN21 v4(65.36,85.13)
PE_SLV_TX_C_DP<11>: length 58.4
  TOP w0.089: v4(65.36,86.13) 65,86.13 64.92,86.06 64.92,85.8 64.66,85.54 63.27,85.54 63.21,85.48 63.2,85.48
  TOP w0.135: C162.1 14.8,66.01 15.42,66.01 17.24,65.69 18.19,65.86 18.19,65.86 18.25,65.87 18.31,65.88 18.37,65.89 19.2,66.04 23.66,69.16 v3(27.3,69.82) 44.77,72.97 46.19,73.35 48.07,74.04 49.42,74.99 49.88,75.32 50.53,76.04 52.87,78.85 52.91,78.9 55.69,82.45 59.33,85.01 62.03,85.48 63.2,85.48
  BOTTOM w0.135: U1.AN22 v4(65.36,86.13)
PE_SLV_TX_C_DP<12>: length 59.2
  TOP w0.089: 63.2,86.48 63.22,86.48 63.28,86.53 64.66,86.53 64.92,86.8 64.92,87.07 64.98,87.13 v4(65.36,87.13)
  TOP w0.135: 63.2,86.48 61.74,86.48 58.64,85.93 54.74,83.2 52.91,80.86 51.93,79.61 49.38,76.57 47.38,75.11 45.9,74.52 44.99,74.34 44.11,74.16 44.09,74.16 44.07,74.16 v3(41.49,73.81) 36.83,73.18 34.83,72.94 33.62,72.8 28.84,72.24 27.42,71.99 27.31,71.83 27.35,71.6 27.1,71.24 26.48,71.13 26.12,71.38 26.08,71.62 25.92,71.73 25.16,71.59 22.27,72.1 21.44,71.84 17.96,69.4 17.96,69.4 16.18,68.16 15.56,68.05 14.8,68.05 C163.1
  BOTTOM w0.135: U1.AN23 v4(65.36,87.13)
PE_SLV_TX_C_DP<13>: length 57.9
  TOP w0.089: 63.22,87.48 63.24,87.48 63.3,87.54 64.66,87.54 64.92,87.8 64.92,88.06 64.99,88.13 v4(65.36,88.13)
  TOP w0.135: C164.1 14.8,70.08 15.45,70.08 15.82,70.14 17.13,71.06 18.6,71.32 20.87,72.91 21.7,73.25 22.27,73.35 25.21,72.83 28.9,73.48 32.28,73.92 v3(35.05,74.28) 44.13,75.45 45.68,75.79 47.9,76.99 48.36,77.41 48.34,77.39 49.16,78.31 49.17,78.32 49.93,79.28 50.73,80.23 51.15,80.73 51.2,80.79 51.86,81.72 52.12,82.08 52.87,83.17 52.92,83.24 52.99,83.33 53.1,83.43 53.12,83.44 53.17,83.49 53.32,83.61 53.33,83.61 53.34,83.62 53.38,83.66 53.42,83.68 54.39,84.32 57.83,86.73 62.04,87.48 63.22,87.48
  BOTTOM w0.135: U1.AN24 v4(65.36,88.13)
PE_SLV_TX_C_DP<14>: length 58.9
  TOP w0.089: v4(65.36,89.13) 65.09,89.13 65.02,89.05 65.02,88.8 64.75,88.54 64.04,88.54 63.98,88.48 63.96,88.48
  TOP w0.135: 63.96,88.48 61.96,88.48 56.84,87.58 53.08,84.95 53.01,84.9 52.1,84.16 50.24,81.51 50.23,81.49 49.82,81.01 48.09,78.96 48.08,78.95 48.08,78.95 47.72,78.52 47.33,78.16 45.27,76.98 43.62,76.64 40.48,76.21 35.62,75.68 v3(29.12,75.27) 26.94,75.13 26.22,75.13 25.48,75.14 25.4,75.15 25.18,75.19 25.02,75.08 24.97,74.77 24.61,74.51 23.99,74.62 23.73,74.98 23.79,75.3 23.68,75.45 22.99,75.58 19.38,74.94 18.33,74.75 17.34,74.06 16.31,72.58 15.76,72.2 15.25,72.11 14.8,72.11 C165.1
  BOTTOM w0.135: U1.AN25 v4(65.36,89.13)
PE_SLV_TX_C_DP<15>: length 57.2
  TOP w0.089: v4(65.36,90.13) 65.06,90.13 64.99,90.06 64.99,89.81 64.71,89.53 64.11,89.53 64.06,89.48 64.04,89.48
  TOP w0.135: C166.1 14.8,74.14 15.38,74.14 18.12,76.09 20.56,76.52 21.62,76.71 21.66,76.72 v3(23.29,76.86) 23.99,76.92 24.27,76.92 34.91,77.13 34.97,77.14 40.46,77.44 40.49,77.44 42.13,77.68 42.67,77.76 45.27,78.4 45.35,78.43 46.36,79.03 47.22,79.79 48.67,81.51 50.5,84.1 51.21,84.99 52.38,85.93 52.66,86.12 52.91,86.29 55.98,88.44 61.85,89.48 64.04,89.48
  BOTTOM w0.135: U1.AN26 v4(65.36,90.13)
PE_SLV_TX_DN<0>: length 6
  TOP w0.135: C167.2 13.9,37.97 v3(11.51,37.97) 11.05,37.97 v1(10.82,38.2)
  BOTTOM w0.135: v1(10.82,38.2) 11.05,37.98 12.15,37.98 12.3,38.13 J7.3
PE_SLV_TX_DN<1>: length 9.2
  TOP w0.135: v1(9.2,40.01) 9.43,39.78 10.31,39.78 v3(10.78,39.82) 12.67,39.98 13.28,40.03 13.93,40.03 C168.2
  BOTTOM w0.135: v1(9.2,40.01) 9.42,39.78 12.14,39.78 12.29,39.92 J7.6
PE_SLV_TX_DN<2>: length 6
  TOP w0.135: C169.2 13.93,42.06 13.29,42.06 11.92,41.58 11.08,41.58 v1(10.85,41.81)
  BOTTOM w0.135: J7.9 12.29,41.73 12.14,41.58 11.08,41.58 v1(10.85,41.81)
PE_SLV_TX_DN<3>: length 9.3
  TOP w0.135: v1(9.22,43.61) 9.45,43.38 v3(10.13,43.38) 11.24,43.38 12.14,43.69 13.3,44.09 13.93,44.09 C170.2
  BOTTOM w0.135: v1(9.22,43.61) 9.46,43.38 12.16,43.38 12.31,43.52 J7.12
PE_SLV_TX_DN<4>: length 6.1
  TOP w0.135: C171.2 13.93,46.13 13.39,46.13 11.58,45.16 11.13,45.16 v1(10.9,45.39)
  BOTTOM w0.135: J7.15 12.31,45.33 12.16,45.18 11.11,45.18 v1(10.9,45.39)
PE_SLV_TX_DN<5>: length 9.6
  TOP w0.135: C172.2 13.93,48.16 13.43,48.16 12.77,47.78 12.54,47.65 12.05,47.28 11.24,46.99 v3(10.13,46.99) 9.43,46.99 v1(9.2,47.22)
  BOTTOM w0.135: v1(9.2,47.22) 9.44,46.98 12.13,46.98 12.28,47.13 J7.18
PE_SLV_TX_DN<6>: length 6.2
  TOP w0.135: C173.2 13.93,50.19 13.56,50.19 12.96,49.92 12.02,49.07 11.48,48.77 11.15,48.77 v1(10.92,49)
  BOTTOM w0.135: J7.21 12.3,48.92 12.15,48.78 11.14,48.78 v1(10.92,49)
PE_SLV_TX_DN<7>: length 9.8
  TOP w0.135: C174.2 13.93,52.22 13.48,52.22 12.86,51.82 11.96,50.93 11.16,50.6 9.43,50.6 v1(9.2,50.83)
  BOTTOM w0.135: J7.24 12.32,50.73 12.17,50.58 9.44,50.58 v1(9.2,50.83)
PE_SLV_TX_DN<8>: length 5.2
  TOP w0.135: v1(10.92,60.76) 11.15,60.53 11.47,60.53 12.71,60.22 13.29,60.22 C175.2
  BOTTOM w0.135: v1(10.92,60.76) 11.15,60.53 12.09,60.53 12.24,60.68 12.24,60.67 J8.3
PE_SLV_TX_DN<9>: length 8.6
  TOP w0.135: C176.2 13.29,62.26 12.02,62.26 11.48,62.33 v3(9.99,62.33) 9.45,62.33 v1(9.22,62.56)
  BOTTOM w0.135: v1(9.22,62.56) 9.45,62.33 12.11,62.33 12.26,62.47 J8.6
PE_SLV_TX_DN<10>: length 5.2
  TOP w0.135: C177.2 13.29,64.29 12.7,64.29 11.84,64.14 11.15,64.14 v1(10.92,64.36)
  BOTTOM w0.135: J8.9 12.31,64.27 12.16,64.13 11.16,64.13 v1(10.92,64.36)
PE_SLV_TX_DN<11>: length 8.7
  TOP w0.135: v1(9.2,66.17) 9.43,65.94 v3(9.96,65.94) 11.32,65.94 11.98,66.17 12.41,66.32 13.29,66.32 C178.2
  BOTTOM w0.135: v1(9.2,66.17) 9.44,65.93 12.21,65.93 12.36,66.07 J8.12
PE_SLV_TX_DN<12>: length 5.3
  TOP w0.135: C179.2 13.29,68.35 12.92,68.35 11.54,67.72 11.15,67.72 v1(10.92,67.94)
  BOTTOM w0.135: J8.15 12.07,67.87 11.93,67.73 11.14,67.73 v1(10.92,67.94)
PE_SLV_TX_DN<13>: length 8.9
  TOP w0.135: v1(9.17,69.77) 9.4,69.55 v3(10.15,69.55) 11.33,69.55 12.08,69.91 13.03,70.37 13.05,70.38 13.29,70.38 C180.2
  BOTTOM w0.135: J8.18 12.09,69.67 11.95,69.53 9.42,69.53 v1(9.17,69.77)
PE_SLV_TX_DN<14>: length 5.5
  TOP w0.135: C181.2 13.29,72.42 13.08,72.42 12.55,72.17 11.99,71.6 11.48,71.34 11.42,71.32 11.15,71.32 v1(10.92,71.55)
  BOTTOM w0.135: v1(10.92,71.55) 11.15,71.33 11.95,71.33 12.1,71.47 J8.21
PE_SLV_TX_DN<15>: length 9.3
  TOP w0.135: v1(9.17,73.36) 9.4,73.13 9.78,73.13 10.1,73.26 10.37,73.51 10.76,74.16 11.27,74.54 11.7,74.69 12.36,74.66 12.83,74.45 13.29,74.45 C182.2
  BOTTOM w0.135: v1(9.17,73.36) 9.4,73.13 11.83,73.13 11.98,73.27 J8.24
PE_SLV_TX_DP<0>: length 6
  TOP w0.135: C151.2 13.95,37.67 v3(13.26,37.67) 11.05,37.67 v1(10.82,37.44)
  BOTTOM w0.135: J7.2 12.31,37.52 12.16,37.67 11.06,37.67 v1(10.82,37.44)
PE_SLV_TX_DP<1>: length 9.2
  TOP w0.135: C152.2 13.93,39.73 13.29,39.73 v3(12.7,39.67) 10.32,39.47 9.43,39.47 v1(9.2,39.24)
  BOTTOM w0.135: v1(9.2,39.24) 9.43,39.47 12.17,39.47 12.31,39.33 J7.5
PE_SLV_TX_DP<2>: length 6
  TOP w0.135: C153.2 13.93,41.76 13.35,41.76 11.97,41.27 11.08,41.27 v1(10.85,41.05)
  BOTTOM w0.135: v1(10.85,41.05) 11.07,41.27 12.17,41.27 12.32,41.13 J7.8
PE_SLV_TX_DP<3>: length 9.3
  TOP w0.135: v1(9.22,42.85) 9.45,43.08 11.29,43.08 v3(12.33,43.44) 13.35,43.79 13.93,43.79 C154.2
  BOTTOM w0.135: v1(9.22,42.85) 9.44,43.07 12.17,43.07 12.32,42.92 J7.11
PE_SLV_TX_DP<4>: length 6.1
  TOP w0.135: v1(10.9,44.63) 11.13,44.86 11.66,44.86 13.46,45.82 13.93,45.82 C155.2
  BOTTOM w0.135: J7.14 12.32,44.73 12.18,44.87 11.14,44.87 v1(10.9,44.63)
PE_SLV_TX_DP<5>: length 9.5
  TOP w0.135: C156.2 13.93,47.85 13.51,47.85 v3(12.92,47.52) 12.71,47.4 12.19,47.01 11.3,46.69 9.43,46.69 v1(9.2,46.46)
  BOTTOM w0.135: v1(9.2,46.46) 9.41,46.67 12.16,46.67 12.3,46.52 J7.17
PE_SLV_TX_DP<6>: length 6.3
  TOP w0.135: v1(10.92,48.23) 11.15,48.46 11.56,48.46 12.2,48.82 13.12,49.66 13.63,49.89 13.93,49.89 C157.2
  BOTTOM w0.135: J7.20 12.33,48.33 12.18,48.47 11.16,48.47 v1(10.92,48.23)
PE_SLV_TX_DP<7>: length 9.8
  TOP w0.135: C158.2 13.93,51.92 13.57,51.92 13.05,51.58 12.13,50.67 11.22,50.29 9.43,50.29 v1(9.2,50.06)
  BOTTOM w0.135: v1(9.2,50.06) 9.41,50.27 12.19,50.27 12.34,50.13 J7.23
PE_SLV_TX_DP<8>: length 5.2
  TOP w0.135: C159.2 13.29,59.92 12.67,59.92 11.43,60.22 11.15,60.22 v1(10.92,59.99)
  BOTTOM w0.135: v1(10.92,59.99) 11.15,60.22 12.12,60.22 12.27,60.07 J8.2
PE_SLV_TX_DP<9>: length 8.6
  TOP w0.135: C160.2 13.29,61.95 v3(12.44,61.95) 11.99,61.95 11.46,62.03 9.45,62.03 v1(9.22,61.8)
  BOTTOM w0.135: J8.5 12.22,61.87 12.07,62.02 9.45,62.02 v1(9.22,61.8)
PE_SLV_TX_DP<10>: length 5.2
  TOP w0.135: C161.2 13.29,63.98 12.73,63.98 11.86,63.83 11.15,63.83 v1(10.92,63.6)
  BOTTOM w0.135: v1(10.92,63.6) 11.15,63.82 12.25,63.82 12.4,63.67 J8.8
PE_SLV_TX_DP<11>: length 8.7
  TOP w0.135: v1(9.2,65.41) 9.43,65.63 11.37,65.63 v3(12.08,65.88) 12.46,66.01 13.29,66.01 C162.2
  BOTTOM w0.135: v1(9.2,65.41) 9.41,65.62 12.18,65.62 12.33,65.47 J8.11
PE_SLV_TX_DP<12>: length 5.3
  TOP w0.135: v1(10.92,67.18) 11.15,67.41 11.61,67.41 12.98,68.05 13.29,68.05 C163.2
  BOTTOM w0.135: J8.14 12.07,67.27 11.93,67.42 11.16,67.42 v1(10.92,67.18)
PE_SLV_TX_DP<13>: length 8.8
  TOP w0.135: C164.2 13.29,70.08 13.12,70.08 12.88,69.96 v3(12.21,69.64) 11.4,69.24 9.4,69.24 v1(9.17,69.01)
  BOTTOM w0.135: v1(9.17,69.01) 9.38,69.22 11.95,69.22 12.09,69.07 J8.17
PE_SLV_TX_DP<14>: length 5.5
  TOP w0.135: C165.2 13.29,72.11 13.15,72.11 13.03,72.06 12.73,71.91 12.18,71.36 11.58,71.05 11.46,71.02 11.15,71.02 v1(10.92,70.79)
  BOTTOM w0.135: v1(10.92,70.79) 11.16,71.02 11.95,71.02 12.1,70.87 J8.20
PE_SLV_TX_DP<15>: length 9.3
  TOP w0.135: v1(9.17,72.59) 9.4,72.82 9.84,72.82 10.26,73 10.61,73.31 10.99,73.96 11.41,74.27 11.75,74.38 12.28,74.36 12.77,74.14 13.29,74.14 C166.2
  BOTTOM w0.135: v1(9.17,72.59) 9.4,72.82 11.83,72.82 11.98,72.67 J8.23
PE_WAKE_N: length 117.7
  TOP w0.127: v1(285.57,64.39) 285.83,64.14 R6.1 ; R8.1 v1(282.4,103.25) ; R7.1 v1(285.34,83.97) ; R5.1 285.83,44.07 v1(285.7,44.2)
  IN1 w0.097: v1(282.4,103.25) 286.69,98.96 286.69,95.68 285.5,94.49 285.5,90.25 285.34,90.09 v1(285.34,83.97) ; v1(285.7,44.2) 285.7,39.72 286.97,38.46 286.97,34.82 281.76,29.62 281.76,19.84 284.63,16.97 v1(284.63,12.57)
  IN2 w0.112: v1(285.7,44.2) 285.7,49.4 285.19,49.91 285.19,53.35 286.87,55.03 286.87,58.89 285.57,60.19 v1(285.57,64.39) 286.04,63.93 288.05,63.93 290.04,65.92 290.04,74.32 288.88,75.49 288.88,76.17 286.87,78.18 286.87,79.21 285.34,80.75 v1(285.34,83.97)
  BOTTOM w0.114: J5.B11 285.83,5.69 286.7,6.56 286.7,8.45 284.63,10.52 v1(284.63,12.57)
PEX8796_GPIO0: length 39.2
  TOP w0.114: R115.1 54.8,53.04 R190.2 54.41,54.43 52.99,54.43 v6(52.63,54.79)
  IN2 w0.089: 63.58,77.09 64.01,77.52 69.98,77.52 v4(70.36,77.13)
  IN2 w0.112: 63.58,77.09 51.86,65.37 51.86,55.56 v6(52.63,54.79)
  BOTTOM w0.127: U1.AH14 v4(70.36,77.13)
PEX8796_GPIO1: length 25.4
  TOP w0.114: R269.1 57.66,56.91 R189.2 58.83,56.69 v6(60.1,56.69)
  IN2 w0.112: v6(72.36,71.13) 72,71.13 71.53,70.66 70.46,70.66 69.53,69.73 69.3,69.73 68.84,69.27 68.84,64.19 61.85,57.2 60.61,57.2 v6(60.1,56.69)
  BOTTOM w0.127: U1.AF8 v6(72.36,71.13)
PEX8796_GPIO2: length 29.8
  TOP w0.114: R188.2 60.3,55.38 60.87,55.96 61.62,55.96 61.62,55.95 v1(61.62,55.95) 61.62,56.2 v5(62.31,56.88) 62.78,56.41 R270.1
  IN2 w0.089: 72.98,66 72.98,73.74 v4(73.36,74.13)
  IN2 w0.112: 72.98,66 72.98,65.07 71.21,63.31 70.96,63.31 68.33,60.68 67.11,60.68 62.38,55.95 v1(61.62,55.95)
  BOTTOM w0.127: U1.AE11 v4(73.36,74.13)
PEX8796_GPIO3: length 39.6
  IN2 w0.112: v6(52.61,56.09) 52.12,56.58 52.12,64.74 63.96,76.58 70.56,76.58 70.82,76.33 70.82,75.69 71.36,75.14 v4(71.36,75.13)
  BOTTOM w0.114: R271.1 54.8,53.04 R187.2 54.8,54.35 54.45,54.69 53.39,54.69 52.61,55.47 v6(52.61,56.09)
  BOTTOM w0.127: U1.AG12 v4(71.36,75.13)
PEX_EEP_CS_N: length 2.2
  TOP w0.114: R113.1 70.64,77.85 v4(71.36,77.13)
  BOTTOM w0.114: U1.AG14 v4(71.36,77.13)
PEX_EEP_CS_R_N: length 59.6
  TOP w0.114: v4(69.36,77.13) 69.4,77.17 R113.2
  IN1 w0.097: v1(58.73,63.53) 59.39,64.19 59.39,67.34 63.6,71.55 68.73,71.55 68.96,71.78 68.96,76.71 69.36,77.11 v4(69.36,77.13)
  BOTTOM w0.114: U6.1 38.2,60.71 37.44,61.47 R272.2 35.66,61.96 35.51,62.1 33.9,62.1 33.22,62.78 33.22,65.74 34.28,66.8 48.97,66.8 v2(49.61,66.17) 50.08,65.7 56.66,65.7 58.73,63.63 v1(58.73,63.53)
PEX_EEP_HOLD_N: length 3.8
  BOTTOM w0.114: U6.7 46.81,61.98 v2(47.11,62.27) 47.32,62.48 R143.2
PEX_EEP_SCLK: length 15.4
  IN2 w0.112: v4(67.36,68.13) 66.85,67.62 66.85,63.71 61.53,59.11 61.49,58.57 v6(60.91,58.06)
  BOTTOM w0.114: R116.2 60.17,58.8 v6(60.91,58.06) ; U1.AM5 v4(67.36,68.13)
PEX_EEP_SCLK_R: length 40.2
  BOTTOM w0.114: R116.1 57.95,59.56 54.42,59.56 54.31,59.68 54.31,63.13 54.19,63.25 53.79,63.25 53.67,63.13 53.67,59.96 53.56,59.85 53.15,59.85 53.04,59.96 53.04,63.51 52.92,63.63 52.52,63.63 52.4,63.51 52.4,57.98 52.29,57.86 51.81,57.86 51.69,57.98 51.69,63.73 51.59,63.83 v2(51.03,63.83) 50.77,63.57 50.77,63.34 50.65,63.23 50.26,63.23 50.15,63.34 50.15,63.86 50.03,63.97 49.64,63.97 49.52,63.86 49.52,63.34 49.41,63.23 49.02,63.23 48.9,63.34 48.9,63.86 48.79,63.97 48.39,63.97 48.28,63.86 48.28,63.29 48.16,63.18 47.77,63.18 47.66,63.29 47.66,63.86 47.54,63.97 47.09,63.97 46.97,63.84 46.97,63.4 46.81,63.25 U6.6
PEX_EEP_SI: length 12.1
  TOP w0.114: R117.2 81.98,69.74 v4(82.36,70.13)
  IN1 w0.097: v4(90.36,74.13) 89.76,73.52 89.76,72.89 88.39,71.53 84,71.53 83.87,71.4 83.87,70.61 83.35,70.09 82.4,70.09 v4(82.36,70.13)
  BOTTOM w0.114: U1.J11 v4(90.36,74.13)
PEX_EEP_SI_R: length 44.6
  TOP w0.114: v4(78.36,69.13) 78.91,68.58 81.25,68.58 R117.1
  IN3 w0.112: v1(57.56,62.26) 58.32,62.26 62.08,66.01 62.08,67.44 64.21,69.57 77.92,69.57 v4(78.36,69.13)
  BOTTOM w0.114: U6.5 46.36,64.52 46.47,64.63 46.47,65.16 46.58,65.28 46.98,65.28 47.09,65.16 47.09,64.63 47.21,64.52 47.6,64.52 47.71,64.63 47.71,65.16 47.83,65.28 48.22,65.28 48.34,65.16 48.34,64.63 48.45,64.52 53.98,64.52 v2(54,64.54) 54.03,64.52 55.3,64.52 v1(57.56,62.26)
PEX_EEP_SO: length 54.3
  IN3 w0.112: v4(77.36,71.13) 76.92,70.69 63.83,70.69 58.09,64.94 v1(58.09,62.97)
  BOTTOM w0.114: U1.AA8 v4(77.36,71.13) ; R114.1 34.2,62.61 33.73,63.08 33.73,65.53 34.49,66.29 48.36,66.29 49.48,65.18 v2(52.07,65.18) 55.88,65.18 v1(58.09,62.97)
PEX_EEP_SO_R: length 5.9
  BOTTOM w0.114: U6.2 37.67,61.98 v2(37.16,62.48) 37.16,62.99 36.53,63.63 R273.2 R114.2
PEX_I2C_ADDR: length 32.4
  TOP w0.089: 96.8,74.55 96.78,74.54 89.77,74.54 v4(89.36,74.13)
  TOP w0.127: 96.8,74.55 101.17,74.55 101.5,74.88 114.58,74.88 v1(115.65,75.95) R135.1 117.15,75.31 119.18,75.31 R134.2
  BOTTOM w0.127: U1.K11 v4(89.36,74.13)
PEX_PERST_N: length 171.6
  TOP w0.127: v1(164.5,105.14) 163.62,106.03 R351.2 163.62,106.95 v5(164.48,107.81) 164.85,108.18 164.85,112.57 165.71,113.43 R276.1 167.19,114.17 Q2.D
  IN2 w0.112: v4(71.36,73.13) 68.84,70.6 68.09,70.6 67.87,70.38 67.87,63.6 61.74,57.47 60.03,57.47 59.42,56.86 59.42,56.23 v1(59.64,56.01) 59.97,55.68 59.97,51.37 60.99,50.35 61.88,50.35 62.79,51.27 63.49,51.27 63.86,51.64 64.82,51.64 71.2,58.01 115.12,58.01 155.41,98.31 158.72,98.31 164.74,104.33 164.74,104.91 v1(164.5,105.14)
  BOTTOM w0.114: v1(59.64,56.01) 59.47,56.18 R138.2
  BOTTOM w0.127: U1.AG10 v4(71.36,73.13)
PG_CKPWRGD_N: length 4.4
  TOP w0.127: Q4.G 315.65,51.52 R3.2 315.16,50.67 v1(314.53,50.04) 314.53,49.36 Q3.D
PG_MOS: length 6.5
  TOP w0.127: Q3.G v1(314.78,47.69) 314.78,47.12 315.04,46.86 315.93,46.86 316.31,46.48 R298.2 315.72,45.79 315.72,45.41 316.31,44.82 R297.2
PQ6_2N7002_D1_G2: length 4.3
  TOP w0.203: PR403.1 34.51,105.95 34.84,106.28 v5(34.84,106.54) 34.84,107.48 PR402.2 34.49,107.82 PQ6.5 PQ6.6
PQ6_2N7002_G1: length 5.2
  TOP w0.254: v5(30.38,106.57) 30.96,106 PR399.1 ; v5(30.38,106.57) 29.57,106.57 PR398.2 ; v5(30.38,106.57) 30.38,107.48 PC570.1 30.72,107.82 PQ6.2
PST_PE_SLOT1_N: length 8.2
  TOP w0.114: J1.A11 285.83,35.05 282.27,31.5 282.27,30.35 282.42,30.21 R353.2 282.91,29.72 282.92,29.7 U17.4
PST_PE_SLOT2_N: length 8.3
  TOP w0.127: U16.4 283.18,50.04 283.16,50.05 R352.2 282.55,50.53 282.4,50.67 282.4,51.82 285.83,55.25 J2.A11
PST_PE_SLOT3_N: length 8.1
  TOP w0.127: J3.A11 285.83,75.57 282.48,72.21 282.48,71.17 282.8,70.85 R350.2 283.16,70.34 283.05,70.23 U15.4
PST_PE_SLOT4_N: length 8.5
  TOP w0.127: U13.4 283.13,89.3 283.31,89.47 R349.2 283.86,90.85 283.86,93.52 285.83,95.49 J4.A11
PU_EEP_WP_R_N: length 4.5
  BOTTOM w0.127: R274.2 37.03,64.64 v2(37.16,64.52) 38.43,63.25 U6.3
PU_PCA9548_SC4: length 6.1
  TOP w0.127: U2.14 301.54,33.96 299.54,31.97 v1(299.54,30.93) R145.2
PU_PCA9548_SC7: length 8.1
  TOP w0.127: U2.20 305.44,33.75 305.57,33.62 305.57,32.33 305.13,31.88 305.13,30.49 305.36,30.25 305.36,30.02 305.89,29.48 v1(305.89,27.94) 305.91,27.92 R186.2
PU_PCA9548_SD4: length 6.3
  TOP w0.114: 300.89,34.16 298.78,32.05 v1(298.78,29.97)
  TOP w0.127: v1(298.78,29.97) 298.53,29.72 R144.2 ; U2.13 300.89,34.16
PU_PCA9548_SD7: length 5.8
  TOP w0.127: U2.19 304.79,33.9 305.23,33.46 305.23,32.38 304.79,31.94 304.79,30.08 v1(304.89,29.98) 305.13,29.74 R185.2
PU_PE_I2C_SCL_1: length 12.6
  TOP w0.114: R202.2 71.75,72.54 71.86,72.64 71.86,73.38 71.68,73.56 69.04,73.56 68.86,73.74 68.86,75.31 69.17,75.62 71.63,75.62 71.88,75.36 71.88,74.88 72.09,74.68 72.91,74.68 v4(73.36,75.13)
  BOTTOM w0.114: U1.AE12 v4(73.36,75.13)
PU_PE_I2C_SDA_1: length 17.2
  TOP w0.114: R201.2 58.37,54.35 v1(58.47,54.25)
  IN2 w0.112: v7(64.37,66.14) 63.14,66.14 57.79,60.78 57.79,54.94 v1(58.47,54.25)
  BOTTOM w0.114: v7(64.37,66.14) U1.AP3
PU_PEX_NT0_PERST_N: length 158.1
  TOP w0.114: v1(59.92,58.04) 59.21,58.75 R136.2
  TOP w0.127: v1(164.62,106.55) 165.24,107.17 165.24,112.2 165.67,112.63 R276.2
  IN2 w0.112: v1(164.62,106.55) 165.01,106.17 165.01,104.22 158.83,98.04 155.52,98.04 115.23,57.75 71.37,57.75 64.97,51.36 64.33,51.36 62.8,49.82 61.15,49.82 58.93,52.04 58.93,54.64 58.75,54.81 58.75,56.77 59.92,57.94 v1(59.92,58.04) 59.92,60.69 v4(64.36,65.13)
  BOTTOM w0.127: U1.AP2 v4(64.36,65.13)
PU_PEX_NT1_PERST_N: length 20.1
  TOP w0.127: R137.2 v1(102.82,74.04)
  IN2 w0.112: v4(89.36,77.13) 89.44,77.13 89.87,76.71 89.87,72.92 90.15,72.64 98.25,72.64 99.04,73.44 102.22,73.44 v1(102.82,74.04)
  BOTTOM w0.127: U1.K14 v4(89.36,77.13)
PU_SPARE0: length 20.4
  TOP w0.089: 97.25,77.55 97.24,77.54 91.96,77.54 v4(91.36,78.13)
  TOP w0.127: R142.2 v1(109.55,77.85) 108.8,77.1 101.41,77.1 100.96,77.55 97.25,77.55
  BOTTOM w0.127: U1.H15 v4(91.36,78.13)
PU_SPARE1: length 34.1
  TOP w0.127: v4(90.36,82.13) 91.16,81.33 98.81,81.33 99.04,81.56 114.78,81.56 119.33,86.11 v1(119.33,87.5) R141.2
  BOTTOM w0.127: U1.J18 v4(90.36,82.13)
PU_SPARE2: length 54.5
  IN2 w0.089: 63.73,84.73 72.45,84.73 72.85,84.33 72.85,83.65 v4(73.36,83.13)
  IN2 w0.112: 63.73,84.73 63.05,84.73 45.31,66.99 45.31,58.07 45.98,57.4 45.98,56.62 46.66,55.94 46.66,53.31 v1(46.33,52.98)
  BOTTOM w0.114: v1(46.33,52.98) 46.81,53.46 R139.2 R140.1
  BOTTOM w0.127: U1.AE19 v4(73.36,83.13)
PU_STRAP_GEN1_COMPLIANCE_N: length 23.2
  TOP w0.127: R148.2 v1(109.55,74.04)
  IN2 w0.112: v1(109.55,74.04) 108.42,72.91 101.18,72.91 98.93,70.66 89.83,70.66 v4(89.36,71.13)
  BOTTOM w0.127: U1.K8 v4(89.36,71.13)
PU_STRAP_GEN1_GEN2: length 35
  TOP w0.127: v4(91.36,80.13) 91.88,80.64 99.77,80.64 100.03,80.9 120.98,80.9 121.71,80.18 121.71,78.4 v1(122.25,77.85) R147.2
  BOTTOM w0.127: U1.H17 v4(91.36,80.13)
PU_STRAP_HP_POLARITY_CNTL: length 46.8
  IN2 w0.089: 63.2,80.19 63.73,80.72 72.47,80.72 72.84,80.35 72.84,78.65 v4(73.36,78.13)
  IN2 w0.112: 63.2,80.19 49.95,66.94 49.95,58.55 49.35,57.95 v6(49.35,56.72)
  BOTTOM w0.114: v6(49.35,56.72) 48.67,56.03 48.67,54.74 49.07,54.33 49.76,54.33 49.99,54.1 R146.2
  BOTTOM w0.127: U1.AE15 v4(73.36,78.13)
PU_STRAP_PLL_BYPASS_N: length 38.5
  IN2 w0.089: 63.57,78.37 63.91,78.71 71.78,78.71 v4(72.36,78.13)
  IN2 w0.112: v1(49.99,57.86) 50.55,57.86 51.26,58.58 51.26,60.17 50.48,60.95 50.48,65.28 63.57,78.37
  BOTTOM w0.114: R151.2 50.62,57.23 v1(49.99,57.86)
  BOTTOM w0.127: U1.AF15 v4(72.36,78.13)
PU_STRAP_PROBE_MODE_N: length 45.4
  TOP w0.114: R150.2 49.96,54.1 v6(49.25,54.81)
  IN2 w0.112: v4(73.36,80.13) 73.36,80.46 72.78,81.04 63.26,81.04 49.68,67.46 49.68,58.66 48.87,57.84 48.87,55.2 v6(49.25,54.81)
  BOTTOM w0.127: U1.AE17 v4(73.36,80.13)
PU_STRAP_SERDES_MODE_EN_N: length 42
  IN2 w0.112: v1(49.2,58.85) 49.15,58.9 49.15,67.3 63.18,81.33 70.56,81.33 v4(71.36,82.13)
  BOTTOM w0.114: v1(49.2,58.85) 49.2,60.27 v2(50.07,61.14)
  BOTTOM w0.127: v2(50.07,61.14) 51.15,62.22 R149.2 ; U1.AG18 v4(71.36,82.13)
PU_VOE_N: length 3.2
  TOP w0.114: R77.2 307.14,48.91 v1(306.91,49.15) 307.7,49.94 U3.38
PU_VS0_PERST_N: length 25.4
  TOP w0.089: v4(89.36,75.13) 89.77,74.73 96.55,74.73 96.98,75.16
  TOP w0.127: R335.2 v1(112.6,75.95) 111.81,75.16 96.98,75.16
  BOTTOM w0.127: U1.K12 v4(89.36,75.13)
PU_VS1_PERST_N: length 8.4
  TOP w0.114: v1(103.15,68.13) 103.5,68.48 R334.2
  TOP w0.127: v1(103.15,68.13) 101.7,66.67 97.92,66.67 v4(97.37,66.13)
  BOTTOM w0.127: U1.B3 v4(97.37,66.13)
PU_VS2_PERST_N: length 57.9
  TOP w0.114: v1(46.81,52.4) 46.63,52.22 45.52,52.22 44.36,53.38 R333.2
  IN2 w0.089: v4(72.36,87.13) 72.36,87.23 71.86,87.73 63.9,87.73
  IN2 w0.112: 63.9,87.73 44.78,68.6 44.78,55.68 45.04,55.42 45.04,54.72 44.93,54.62 44.93,52.96 45.49,52.4 v1(46.81,52.4)
  BOTTOM w0.127: U1.AG23 v4(72.36,87.13)
PU_VS3_PERST_N: length 24.2
  TOP w0.127: v4(90.36,86.13) 90.87,86.63 99.37,86.63 99.52,86.49 111.46,86.49 v1(112.47,87.5) R332.2
  BOTTOM w0.127: U1.J22 v4(90.36,86.13)
REXT_A0: length 34.3
  TOP w0.114: v1(103.38,66.14) 103.38,66.32 103.61,66.55 R10.2
  IN2 w0.112: v1(103.38,66.14) 103.38,65.79 98.04,60.44 84.49,60.44 78.97,65.96 78.97,68.83 79.27,69.13 v4(79.36,69.13)
  BOTTOM w0.127: U1.W6 v4(79.36,69.13)
REXT_A1: length 23.3
  TOP w0.114: R11.2 60.25,53.54 v6(61.5,54.8)
  IN2 w0.089: 71.15,62.87 73.76,65.48 73.76,68.73 v4(73.36,69.13)
  IN2 w0.112: v6(61.5,54.8) 61.8,54.8 67.02,60.01 68.29,60.01 71.14,62.87 71.15,62.87
  BOTTOM w0.127: U1.AE6 v4(73.36,69.13)
REXT_A2: length 25.3
  TOP w0.114: v1(61.42,50.83) 61.32,50.93 R12.2
  IN2 w0.112: v1(61.42,50.83) 60.27,51.98 60.27,55.99 61.21,56.94 61.96,56.94 69.8,64.78 69.8,68.57 v4(70.36,69.13)
  BOTTOM w0.127: U1.AH6 v4(70.36,69.13)
REXT_A3: length 27.1
  IN2 w0.089: 63.2,72.03 63.48,72.03 63.98,72.53 68.96,72.53 v4(69.36,72.13)
  IN2 w0.112: 63.2,72.03 62.02,72.03 53.44,63.45 53.44,58.51 v6(53.91,58.05)
  BOTTOM w0.114: R13.2 54.02,57.91 53.91,58.03 v6(53.91,58.05)
  BOTTOM w0.127: U1.AJ9 v4(69.36,72.13)
REXT_A4: length 18.5
  TOP w0.089: 97.08,72.01 96.8,71.73 93.77,71.73 v4(93.36,72.13)
  TOP w0.127: 97.08,72.01 100.94,72.01 101.57,71.39 108.8,71.39 v1(109.55,72.14) R40.2
  BOTTOM w0.127: U1.F9 v4(93.36,72.13)
REXT_A5: length 19.7
  TOP w0.089: v4(91.36,69.13) 91.51,69.13 91.9,69.52 99.52,69.52
  TOP w0.114: 99.52,69.52 v5(100.08,68.96) 100.58,69.46 108.59,69.46 R41.2
  BOTTOM w0.127: U1.H6 v4(91.36,69.13)
REXT_A6: length 20.3
  TOP w0.089: 99.52,70.05 99.34,70.05 99,69.71 89.04,69.71 88.46,69.13 v4(88.36,69.13)
  TOP w0.114: 99.52,70.05 100.71,70.05 101.04,69.73 105.88,69.73 v1(106.38,70.23)
  TOP w0.127: R42.2 v1(106.38,70.23)
  BOTTOM w0.127: U1.L6 v4(88.36,69.13)
REXT_A7: length 2.2
  TOP w0.114: v6(83.36,69.13) 82.96,69.53 R43.2
  BOTTOM w0.127: U1.T6 v6(83.36,69.13)
REXT_A8: length 1.5
  TOP w0.114: v4(69.36,74.13) 69.66,74.42 R49.2
  BOTTOM w0.127: U1.AJ11 v4(69.36,74.13)
REXT_A9: length 43.7
  TOP w0.089: 68.25,99.16 67.75,98.66 67.75,82.2 68.74,81.2 69.88,81.2 70.36,80.72 v4(70.36,80.13)
  TOP w0.127: v6(55.5,106.68) 57.12,106.68 57.63,107.19 58.5,107.19 58.78,106.91 60.58,106.91 61.09,107.42 64.49,107.42 65.99,105.92 65.99,104.46 68.48,101.97 68.48,99.39 68.25,99.16
  BOTTOM w0.114: R50.2 v6(55.5,106.68)
  BOTTOM w0.127: U1.AJ17 v4(70.36,80.13)
REXT_A10: length 35
  TOP w0.089: 71.03,98.7 70.94,98.61 70.94,86.36 69.71,85.13 v4(69.36,85.13)
  TOP w0.114: 63.66,110.74 v6(61.93,110.74)
  TOP w0.127: 63.66,110.74 64.24,110.74 68.54,106.45 68.54,105 71.03,102.51 71.03,98.7
  BOTTOM w0.114: R51.2 v6(61.93,110.74)
  BOTTOM w0.127: U1.AJ21 v4(69.36,85.13)
REXT_A11: length 30.2
  TOP w0.089: 70.13,98.73 69.94,98.54 69.94,90.3 69.75,90.1 69.75,88.27 69.62,88.13 v4(69.36,88.13)
  TOP w0.127: v6(60.38,109.73) 60.43,109.68 64.34,109.68 67.98,106.04 67.98,104.66 70.13,102.51 70.13,98.73
  BOTTOM w0.114: R52.2 v6(60.38,109.73)
  BOTTOM w0.127: U1.AJ24 v4(69.36,88.13)
REXT_A12: length 15.4
  TOP w0.089: 96.72,88.9 96.57,88.74 93.75,88.74 v4(93.36,89.13)
  TOP w0.127: R31.2 v1(106.5,87.5) 105.87,88.14 99.9,88.14 99.14,88.9 96.72,88.9
  BOTTOM w0.127: U1.F25 v4(93.36,89.13)
REXT_A13: length 33.5
  TOP w0.089: v4(93.36,83.13) 93.43,83.13 93.85,82.71 99.19,82.71 99.29,82.8 99.52,82.8
  TOP w0.114: 99.52,82.8 114.84,82.8 118.52,86.49 118.52,90.51 v1(119.33,91.31)
  TOP w0.127: R32.2 v1(119.33,91.31)
  BOTTOM w0.127: U1.F19 v4(93.36,83.13)
REXT_A14: length 21.4
  TOP w0.089: v4(93.36,77.13) 93.77,76.73 96.62,76.73 96.84,76.95
  TOP w0.127: R33.2 v1(112.6,77.85) 111.57,76.82 101.15,76.82 101.03,76.95 96.84,76.95
  BOTTOM w0.127: U1.F14 v4(93.36,77.13)
REXT_A15: length 27.9
  TOP w0.089: v4(93.36,74.13) 93.77,73.73 96.79,73.73 97.08,74.02
  TOP w0.127: R34.2 v1(118.95,74.04) 118.42,74.57 101.88,74.57 101.32,74.02 97.08,74.02
  BOTTOM w0.127: U1.F11 v4(93.36,74.13)
REXT_A16: length 25.9
  TOP w0.089: v4(69.36,91.13) 69.36,91.45 68.98,91.83 68.98,98.55 69.31,98.89
  TOP w0.127: v6(61.9,108.71) 61.95,108.76 64.47,108.76 67.41,105.82 67.41,104.3 69.42,102.3 69.42,99 69.31,98.89
  BOTTOM w0.114: R58.2 v6(61.9,108.71)
  BOTTOM w0.127: U1.AJ27 v4(69.36,91.13)
REXT_A17: length 33.8
  TOP w0.127: v6(55.65,110.74) 56.12,111.21 57.98,111.21 58.12,111.07 61.41,111.07 61.75,111.42 63.98,111.42 68.82,106.57 68.82,105.12 71.88,102.06 71.88,93.65 v4(71.36,93.13)
  BOTTOM w0.114: R59.2 v6(55.65,110.74)
  BOTTOM w0.127: U1.AG29 v4(71.36,93.13)
REXT_A18: length 37.6
  TOP w0.127: v4(76.36,93.13) 75.91,93.58 75.91,99.82 69.98,105.75 69.98,107.19 63.7,113.46 61.37,113.46 60.78,112.88 58.93,112.88 58.55,113.26 56.08,113.26 v6(55.6,112.78)
  BOTTOM w0.114: R60.2 v6(55.6,112.78)
  BOTTOM w0.127: U1.AB29 v4(76.36,93.13)
REXT_A19: length 40.5
  TOP w0.127: v6(54.03,113.79) 54.05,113.77 55.91,113.77 57.58,115.44 62.95,115.44 70.94,107.45 70.94,106.12 78.89,98.18 78.89,93.65 v4(78.36,93.13)
  BOTTOM w0.114: R61.2 v6(54.03,113.79)
  BOTTOM w0.127: U1.Y29 v4(78.36,93.13)
REXT_A20: length 39.3
  TOP w0.114: v1(109.55,95.12) 109.55,95.36 107.43,97.48 103.03,101.89 85.43,101.89 81.64,98.09 81.64,93.52 82.03,93.13 v4(82.36,93.13)
  TOP w0.127: R67.2 v1(109.55,95.12)
  BOTTOM w0.127: U1.U29 v4(82.36,93.13)
REXT_A21: length 33.6
  TOP w0.089: v4(87.36,93.13) 87.44,93.13 87.78,93.47 87.78,98.83 88.39,99.44
  TOP w0.114: v1(109.55,93.22) 108.66,94.11 102.64,94.11 101.25,95.5 101.25,97.69 99.04,99.9 88.85,99.9 88.39,99.44
  TOP w0.127: R68.2 v1(109.55,93.22)
  BOTTOM w0.127: U1.M29 v4(87.36,93.13)
REXT_A22: length 21.4
  TOP w0.127: R69.2 v1(106.5,91.31) 105.87,91.95 102.26,91.95 98.58,95.63 91.17,95.63 90.87,95.33 90.87,93.62 v4(91.36,93.13)
  BOTTOM w0.127: U1.H29 v4(91.36,93.13)
REXT_A23: length 15.8
  TOP w0.127: R70.2 v1(106.5,89.41) 105.87,90.04 99.65,90.04 97.99,91.69 93.93,91.69 v4(93.36,91.13)
  BOTTOM w0.127: U1.F27 v4(93.36,91.13)
REXT_B0: length 2.4
  TOP w0.114: v6(80.36,69.13) 80.91,69.67 R14.2
  BOTTOM w0.127: U1.V6 v6(80.36,69.13)
REXT_B1: length 27.1
  IN2 w0.112: v4(74.36,69.13) 74.8,68.69 74.8,64.16 71.88,61.24 70.27,61.24 68.51,59.48 67.24,59.48 63.59,55.83 63.59,53.75 63.07,53.23 63.07,52.94 62.82,52.7 61.93,52.7 61.36,53.26 v6(61.28,53.26)
  BOTTOM w0.114: v6(61.28,53.26) R15.2
  BOTTOM w0.127: U1.AD6 v4(74.36,69.13)
REXT_B2: length 25.3
  IN2 w0.089: 68.65,62.87 70.82,65.03 70.82,68.58 v4(71.36,69.13)
  IN2 w0.112: 68.65,62.87 67.3,61.52 66.91,61.52 62.07,56.67 61.32,56.67 60.53,55.88 60.53,52.59 v6(61.51,51.61)
  BOTTOM w0.114: v6(61.51,51.61) 60.98,51.61 R16.2
  BOTTOM w0.127: U1.AG6 v4(71.36,69.13)
REXT_B3: length 44.7
  TOP w0.089: v4(70.36,71.13) 70.36,72.11 69.83,72.64 69.22,72.64 68.91,72.95 68.91,73.33 68.56,73.69 68.05,73.69 67.9,73.84 67.9,80.15 66.75,81.29 66.75,90.42 66.55,90.63 66.12,90.63 65.86,90.88 65.86,91.26
  TOP w0.114: v6(60.58,105.59) 61.16,105 64.3,105 67.63,101.68 67.63,99.68 67.03,99.09 67.03,98.48 65.86,97.31 65.86,91.26
  BOTTOM w0.114: R17.2 59.36,105.59 v6(60.58,105.59) ; U1.AJ8 v4(70.36,71.13)
REXT_B4: length 24.6
  TOP w0.089: 99.52,70.83 98.9,70.83 98.8,70.73 93.76,70.73 v4(93.36,71.13)
  TOP w0.127: R44.2 v1(115.65,72.14) 115.09,71.58 112.44,71.58 111.69,70.83 99.52,70.83
  BOTTOM w0.127: U1.F8 v4(93.36,71.13)
REXT_B5: length 32.3
  TOP w0.089: v4(90.36,69.13) 90.36,68.9 90.55,68.71 99.01,68.71
  TOP w0.114: 99.01,68.71 99.51,68.21 v5(101.53,68.21) 101.91,68.21 102.9,69.2 110.79,69.2 112.42,70.83
  TOP w0.127: R45.2 v1(118.95,72.14) 117.64,70.83 112.42,70.83
  BOTTOM w0.127: U1.J6 v4(90.36,69.13)
REXT_B6: length 23.9
  TOP w0.114: v4(87.36,69.13) 87.36,68.95 87.61,68.71 88.6,68.71 88.85,68.45 88.85,67.82 88.95,67.72 94.52,67.72 94.79,67.44 94.79,66.52 95.89,65.43 106.1,65.43 106.5,65.84 106.5,66.24 v1(106.43,66.32)
  TOP w0.127: R46.2 106.53,66.42 v1(106.43,66.32)
  BOTTOM w0.127: U1.M6 v4(87.36,69.13)
REXT_B7: length 1.4
  TOP w0.114: R47.2 84.65,69.42 v4(84.36,69.13)
  BOTTOM w0.127: U1.R6 v4(84.36,69.13)
REXT_B8: length 29
  IN2 w0.089: 63.88,72.72 68.84,72.72 69.25,73.13 v4(69.36,73.13)
  IN2 w0.112: 63.88,72.72 62.05,72.72 53.18,63.85 53.18,57.64 v1(53.4,57.41)
  BOTTOM w0.114: v1(53.4,57.41) 53.78,57.41 54.55,56.64 R53.2
  BOTTOM w0.127: U1.AJ10 v4(69.36,73.13)
REXT_B9: length 42.3
  TOP w0.089: 67.77,99.44 67.34,99.01 67.34,97.87 66.94,97.47 66.94,81.74 67.22,81.46 68.2,81.46 68.9,80.76 68.9,79.84 69.36,79.38 v4(69.36,79.13)
  TOP w0.114: v6(54.31,105.59) 54.51,105.79 57.1,105.79 57.53,106.22 61.04,106.22 61.52,105.74 63.94,105.74 67.9,101.79 67.9,99.57 67.77,99.44
  BOTTOM w0.114: v6(54.31,105.59) 53.08,105.59 R54.2
  BOTTOM w0.127: U1.AJ16 v4(69.36,79.13)
REXT_B10: length 39
  TOP w0.089: 68.79,98.88 68.79,84.66 69.31,84.13 v4(69.36,84.13)
  TOP w0.127: 68.79,98.88 68.79,98.94 68.85,99.01 68.99,99.14 68.99,99.14 69.09,99.24 69.09,102.15 67.13,104.1 67.13,105.69 64.85,107.98 61.19,107.98 60.81,108.36 58.1,108.36 57.98,108.24 57.14,108.24 56.59,107.7 v6(54.08,107.7)
  BOTTOM w0.114: R55.2 v6(54.08,107.7)
  BOTTOM w0.127: U1.AJ20 v4(69.36,84.13)
REXT_B11: length 39.1
  TOP w0.089: 70.75,98.82 70.75,87.64 70.24,87.13 v4(69.36,87.13)
  TOP w0.127: 70.75,98.82 70.75,102.4 68.26,104.89 68.26,106.15 64.46,109.96 60.99,109.96 60.62,110.32 58.03,110.32 57.94,110.24 57.63,110.24 57.12,109.73 v6(54.1,109.73)
  BOTTOM w0.114: R56.2 v6(54.1,109.73)
  BOTTOM w0.127: U1.AJ23 v4(69.36,87.13)
REXT_B12: length 12
  TOP w0.089: 98.98,88.55 93.79,88.55 v4(93.36,88.13)
  TOP w0.127: 98.98,88.55 100.03,87.5 v1(102.82,87.5) R35.2
  BOTTOM w0.127: U1.F24 v4(93.36,88.13)
REXT_B13: length 31.9
  TOP w0.089: 99.52,82.52 93.72,82.52 93.36,82.16 v4(93.36,82.13)
  TOP w0.114: v1(119.33,89.41) 118.79,88.87 118.79,86.35 114.96,82.52 99.52,82.52
  TOP w0.127: R36.2 v1(119.33,89.41)
  BOTTOM w0.127: U1.F18 v4(93.36,82.13)
REXT_B14: length 11.7
  TOP w0.089: 97.06,75.95 96.88,75.95 96.66,75.72 93.77,75.72 v4(93.36,76.13)
  TOP w0.127: R37.2 v1(102.82,75.95) 97.06,75.95
  BOTTOM w0.127: U1.F13 v4(93.36,76.13)
REXT_B15: length 12
  TOP w0.089: 97.11,72.92 97.03,72.92 96.83,72.73 93.77,72.73 v4(93.36,73.13)
  TOP w0.127: R38.2 v1(102.82,72.14) 101.78,72.14 100.99,72.92 97.11,72.92
  BOTTOM w0.127: U1.F10 v4(93.36,73.13)
REXT_B16: length 34
  TOP w0.089: v4(69.36,90.13) 69.51,90.13 69.75,90.37 69.75,98.78
  TOP w0.127: 69.75,98.78 69.75,102.36 67.69,104.42 67.69,105.93 64.23,109.4 60.89,109.4 60.62,109.13 58.03,109.13 57.98,109.18 56.1,109.18 v6(55.63,108.71)
  BOTTOM w0.114: R62.2 v6(55.63,108.71)
  BOTTOM w0.127: U1.AJ26 v4(69.36,90.13)
REXT_B17: length 28
  TOP w0.127: v4(72.36,93.13) 72.88,93.65 72.88,101.55 69.1,105.33 69.1,106.74 64.15,111.69 60.42,111.69 v6(60.35,111.76)
  BOTTOM w0.114: R63.2 v6(60.35,111.76)
  BOTTOM w0.127: U1.AF29 v4(72.36,93.13)
REXT_B18: length 31.5
  TOP w0.114: 64.02,113.59 63.81,113.79 v6(60.3,113.79)
  TOP w0.127: 64.02,113.59 70.26,107.35 70.26,105.87 76.83,99.3 76.83,93.67 v4(77.36,93.13)
  BOTTOM w0.114: R64.2 v6(60.3,113.79)
  BOTTOM w0.127: U1.AA29 v4(77.36,93.13)
REXT_B19: length 40.9
  TOP w0.127: v6(55.6,114.81) 55.93,114.81 56.85,115.72 63.07,115.72 71.39,107.4 71.39,106.08 79.83,97.64 79.83,93.6 v4(79.36,93.13)
  BOTTOM w0.114: R65.2 v6(55.6,114.81)
  BOTTOM w0.127: U1.W29 v4(79.36,93.13)
REXT_B20: length 36.9
  TOP w0.114: v4(83.36,93.13) 83.17,93.13 82.86,93.45 82.86,98.94 85.54,101.62 102.91,101.62 106.65,97.88 106.65,95.27 v1(106.5,95.12)
  TOP w0.127: R71.2 v1(106.5,95.12)
  BOTTOM w0.127: U1.T29 v4(83.36,93.13)
REXT_B21: length 29.9
  TOP w0.089: 88.88,99.44 87.97,98.54 87.97,93.56 88.36,93.17 v4(88.36,93.13)
  TOP w0.114: v1(106.5,93.22) 105.89,93.83 102.49,93.83 100.94,95.38 100.94,97.56 98.91,99.59 89.03,99.59 88.88,99.44
  TOP w0.127: R72.2 v1(106.5,93.22)
  BOTTOM w0.127: U1.L29 v4(88.36,93.13)
REXT_B22: length 13.8
  TOP w0.127: v4(92.36,93.13) 92.45,93.13 92.91,93.6 97.61,93.6 97.87,93.34 97.87,92.96 99.52,91.31 v1(102.82,91.31) R73.2
  BOTTOM w0.127: U1.G29 v4(92.36,93.13)
REXT_B23: length 12.2
  TOP w0.127: R74.2 v1(102.82,89.41) 99.77,89.41 98.5,90.68 93.91,90.68 v4(93.36,90.13)
  BOTTOM w0.127: U1.F26 v4(93.36,90.13)
REXT_CMU0: length 20.7
  IN2 w0.089: 69,62.87 71.78,65.64 71.78,68.22
  IN2 w0.112: 69,62.87 69,62.85 67.37,61.21 66.98,61.21 62.18,56.41 61.43,56.41 61.04,56.02 v1(61.04,55.45) ; 71.78,68.22 72.36,68.81 v6(72.36,69.13)
  BOTTOM w0.114: R18.2 60.91,55.45 v1(61.04,55.45)
  BOTTOM w0.127: U1.AF6 v6(72.36,69.13)
REXT_CMU1: length 26.5
  TOP w0.089: v4(89.36,69.13) 89.36,69.03 89.88,68.52 98.62,68.52 99.52,67.61
  TOP w0.114: 99.52,67.61 101.98,67.61 103.29,68.92
  TOP w0.127: R48.2 v1(112.6,70.23) 111.29,68.92 103.29,68.92
  BOTTOM w0.127: U1.K6 v4(89.36,69.13)
REXT_CMU2: length 34.7
  TOP w0.089: 68.26,98.77 67.94,98.45 67.94,82.89 68.31,82.52 68.98,82.52 v4(69.36,82.13)
  TOP w0.127: v6(60.35,107.7) 64.73,107.7 66.27,106.16 66.27,104.57 68.76,102.08 68.76,99.24 68.29,98.77 68.26,98.77
  BOTTOM w0.114: R57.2 v6(60.35,107.7)
  BOTTOM w0.127: U1.AJ18 v4(69.36,82.13)
REXT_CMU3: length 11.8
  TOP w0.089: v4(93.36,79.13) 93.77,79.53 96.67,79.53 96.83,79.38 96.87,79.38
  TOP w0.127: 96.87,79.38 100.59,79.38 100.97,79.76 v1(102.82,79.76) R39.2
  BOTTOM w0.127: U1.F16 v4(93.36,79.13)
REXT_CMU4: length 35.4
  TOP w0.127: v6(54.08,111.76) 56.52,111.76 56.99,112.23 58.11,112.23 58.24,112.36 60.6,112.36 60.79,112.17 64.07,112.17 69.38,106.86 69.38,105.45 73.86,100.97 73.86,93.63 v4(73.36,93.13)
  BOTTOM w0.114: R66.2 v6(54.08,111.76)
  BOTTOM w0.127: U1.AE29 v4(73.36,93.13)
REXT_CMU5: length 33.9
  TOP w0.127: R75.2 v1(112.47,91.31) 111.15,92.63 102.51,92.63 99.9,95.24 99.9,97.28 98.5,98.68 90.17,98.68 89.87,98.38 89.87,93.63 v4(90.36,93.13)
  BOTTOM w0.127: U1.J29 v4(90.36,93.13)
RST_PE_SLOT_N: length 251.4
  TOP w0.114: v1(282.27,28.17) U17.2 282.27,24.77 285.32,21.72 285.32,9.78 286.72,8.38 286.72,6.73 285.83,5.84 J5.A11 ; U16.2 282.53,48.01 283.16,48.64 283.8,48.64 284.43,48.01 v1(285.07,48.01) ; v1(257.63,115.32) 256.19,116.76 173.86,116.76 171.29,114.19 171.29,110.23 170.86,109.79 Q1.G ; U13.2 284.43,88.65 v1(283.8,88.01) ; U15.2 282.4,68.35 282.92,68.87 284.07,68.87 v1(284.84,68.1)
  IN1 w0.097: v1(284.84,68.1) 284.84,67.79 286.08,66.55 286.08,62.1 287.73,60.45 287.73,59.44 288.75,58.42 288.75,55.24 287.86,54.36 287.86,53.34 286.82,52.3 286.82,48.79 286.04,48.01 v1(285.07,48.01) 285.14,47.93 285.14,46 286.23,44.91 286.23,43.1 287.86,41.48 287.86,39.37 288.88,38.35 288.88,35.05 287.86,34.04 287.86,33.02 285.45,30.61 284.59,30.61 282.27,28.29 v1(282.27,28.17)
  IN3 w0.112: v1(257.63,115.32) 262.59,110.36 279.86,110.36 281.38,108.84 281.38,102.23 281.89,101.73 281.89,99.95 281,99.06 281,96.09 279.88,94.97 279.88,93.83 282.91,90.81 282.91,88.77 283.67,88.01 v1(283.8,88.01)
  BOTTOM w0.114: v1(283.8,88.01) 285.45,86.36 285.45,84.68 287.94,82.19 287.94,79.91 288.8,79.04 288.8,75.26 287.83,74.3 287.83,73.76 284.84,70.77 v1(284.84,68.1)
RST_PEX_MOS_N: length 5.6
  TOP w0.114: R348.2 166.96,110.72 166.98,110.74 Q1.D 167.89,112.38 168.73,113.22 v1(168.86,113.22) Q2.G
SLOT1_JTAG_TCK: length 4.5
  TOP w0.114: J1.A5 291.83,32.99 292.43,32.38 R275.2
SLOT1_JTAG_TDI: length 2.5
  TOP w0.114: J1.A6 290.83,31.59 R262.2
SLOT1_JTAG_TDO: length 4.5
  TOP w0.114: R263.2 289.83,31.58 J1.A7
SLOT1_JTAG_TMS: length 2.5
  TOP w0.114: R264.2 288.83,31.56 J1.A8
SLOT1_JTAG_TRST_N: length 4.9
  TOP w0.127: R261.2 287.86,41.02 287.83,40.99 J1.B9
SLOT2_JTAG_TCK: length 4.6
  TOP w0.127: J2.A5 291.83,53.05 292.56,52.32 R260.2
SLOT2_JTAG_TDI: length 2.5
  TOP w0.127: J2.A6 290.83,52.66 291.54,51.94 R257.2
SLOT2_JTAG_TDO: length 4.5
  TOP w0.127: R258.2 290.53,51.82 289.83,52.51 J2.A7
SLOT2_JTAG_TMS: length 2.5
  TOP w0.127: R259.2 289.51,52.2 288.83,52.88 J2.A8
SLOT2_JTAG_TRST_N: length 4.8
  TOP w0.127: J2.B9 287.86,58.11 R252.2
SLOT3_JTAG_TCK: length 4.6
  TOP w0.127: R251.2 292.56,72.77 291.83,73.5 J3.A5
SLOT3_JTAG_TDI: length 2.5
  TOP w0.127: J3.A6 290.83,73.03 291.54,72.31 R248.2
SLOT3_JTAG_TDO: length 4.5
  TOP w0.127: J3.A7 289.83,73.09 290.53,72.39 R249.2
SLOT3_JTAG_TMS: length 2.5
  TOP w0.127: J3.A8 288.83,73.19 289.51,72.51 R250.2
SLOT3_JTAG_TRST_N: length 4.9
  TOP w0.127: R247.2 288.24,81.41 287.83,80.99 J3.B9
SLOT4_JTAG_TCK: length 4.4
  TOP w0.114: R246.2 292.56,93.06 291.83,93.79 J4.A5
SLOT4_JTAG_TDI: length 2.4
  TOP w0.114: R239.2 291.54,93.04 290.83,93.75 J4.A6
SLOT4_JTAG_TDO: length 4.4
  TOP w0.114: R240.2 290.53,93.15 289.83,93.85 J4.A7
SLOT4_JTAG_TMS: length 2.4
  TOP w0.114: J4.A8 289.51,93.53 R245.2
SLOT4_JTAG_TRST_N: length 4.6
  TOP w0.114: J4.B9 287.83,99.9 288.01,100.08 R238.2
STRAP_I2C_SMBUS_CFG_EN_N: length 15.8
  IN2 w0.112: v6(58.85,57.58) 58.32,58.12 58.32,60.55 63.43,65.66 64.82,65.66 65.29,66.13 v4(65.36,66.13)
  BOTTOM w0.114: v6(58.85,57.58) 58.75,57.48 R288.1 R287.2
  BOTTOM w0.127: U1.AN3 v4(65.36,66.13)
STRAP_I2C_SMBUS_SEL: length 24
  IN2 w0.112: v4(64.36,67.13) 61.44,67.13 56.32,62.01 56.32,53.83 56.68,53.47 57.2,53.47 57.96,52.7 v1(57.96,52.45)
  BOTTOM w0.114: R289.2 R290.1 57.96,53.33 v1(57.96,52.45)
  BOTTOM w0.127: U1.AP4 v4(64.36,67.13)
STRAP_MGMT_CFG_EN_N: length 47.7
  TOP w0.114: v1(112.6,66.42) 111.71,65.53 110.69,65.53 110.29,65.93 R181.2
  TOP w0.127: R182.1 v1(112.6,66.42)
  IN2 w0.112: v1(112.6,66.42) 112.1,66.92 102.53,66.92 100.05,64.44 100.05,63.4 97.72,61.07 84.8,61.07 81.61,64.26 81.61,68.58 80.76,69.43 80.76,70.3 80.36,70.69 v4(80.36,71.13)
  BOTTOM w0.127: U1.V8 v4(80.36,71.13)
