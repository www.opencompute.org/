# Allegro board 4-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT1_TX_DN<6>: length 6.3
  BOTTOM w0.135: J1.B42 253.2,39.01 253.38,38.95 253.54,39.04 253.67,39.17 253.67,41.09 253.52,41.24 253.52,41.64 253.67,41.8 253.67,42.2 253.52,42.35 253.52,42.76 253.67,42.91 253.67,43.31 C205.2
PE_SLOT1_TX_DN<7>: length 6.3
  BOTTOM w0.135: C206.2 249.71,43.31 249.71,42.91 249.56,42.76 249.56,42.35 249.71,42.2 249.71,41.8 249.56,41.64 249.56,41.24 249.71,41.09 249.71,39.22 249.51,39.01 249.38,38.95 249.2,39.01 J1.B46
PE_SLOT1_TX_DN<8>: length 6.4
  BOTTOM w0.135: J1.B51 244.2,38.5 244.14,38.68 244.14,38.68 243.96,38.77 243.69,39.04 243.69,43.31 C207.2
PE_SLOT1_TX_DN<9>: length 6.4
  BOTTOM w0.135: C208.2 239.69,43.3 239.69,39.04 239.96,38.77 240.11,38.7 240.14,38.68 240.2,38.5 J1.B55
PE_SLOT1_TX_DN<10>: length 6.4
  BOTTOM w0.135: J1.B59 236.2,38.5 236.14,38.68 235.96,38.77 235.69,39.04 235.69,43.31 C209.2
PE_SLOT1_TX_DN<11>: length 6.4
  BOTTOM w0.135: J1.B63 232.2,38.5 232.13,38.7 231.95,38.79 231.69,39.05 231.69,43.33 C210.2
PE_SLOT1_TX_DN<12>: length 6.4
  BOTTOM w0.135: C211.2 227.69,43.31 227.69,39.06 227.99,38.76 228.14,38.69 228.2,38.5 J1.B67
PE_SLOT1_TX_DN<13>: length 6.4
  BOTTOM w0.135: C212.2 223.69,43.32 223.69,39.05 223.98,38.76 224.14,38.68 224.14,38.68 224.2,38.5 J1.B71
PE_SLOT1_TX_DN<14>: length 8.1
  BOTTOM w0.135: C213.2 218.41,44.07 218.93,44.07 219.35,43.78 219.62,43.39 219.69,43.02 219.69,42.61 219.53,42.46 219.53,42.06 219.69,41.9 219.69,39.04 219.96,38.77 220.14,38.68 220.2,38.5 J1.B75
PE_SLOT1_TX_DN<15>: length 9.9
  BOTTOM w0.135: C214.2 210,42.65 210.53,42.65 211.06,42.55 211.39,42.32 211.43,42.11 211.76,41.88 211.97,41.91 212.97,41.22 214.09,41.02 214.65,41.02 214.97,40.96 215.59,40.34 215.59,40.34 215.65,40.02 215.65,39.07 215.93,38.78 216.14,38.68 216.2,38.5 J1.B79
PE_SLOT1_TX_DP<0>: length 6.3
  BOTTOM w0.135: J1.B14 280.46,39.01 280.28,38.95 280.11,39.04 279.99,39.17 279.99,41.09 280.14,41.24 280.14,41.64 279.99,41.8 279.99,42.2 280.14,42.35 280.14,42.76 279.99,42.91 279.99,43.31 C183.2
PE_SLOT1_TX_DP<1>: length 6.4
  BOTTOM w0.135: J1.B19 275.46,38.5 275.51,38.67 275.69,38.76 275.97,39.04 275.97,43.31 C184.2
PE_SLOT1_TX_DP<2>: length 6.4
  BOTTOM w0.135: C185.2 271.93,43.31 271.93,39.01 271.68,38.76 271.52,38.68 271.52,38.68 271.46,38.5 J1.B23
PE_SLOT1_TX_DP<3>: length 6.4
  BOTTOM w0.135: C186.2 267.97,43.31 267.97,39.05 267.69,38.76 267.52,38.68 267.46,38.5 J1.B27
PE_SLOT1_TX_DP<4>: length 6.4
  BOTTOM w0.135: J1.B33 261.46,38.5 261.52,38.68 261.69,38.76 262,39.08 262,43.31 C187.2
PE_SLOT1_TX_DP<5>: length 6.4
  BOTTOM w0.135: J1.B37 257.46,38.5 257.52,38.68 257.73,38.79 257.99,39.04 257.99,43.31 C188.2
PE_SLOT1_TX_DP<6>: length 6.4
  BOTTOM w0.135: C189.2 253.98,43.31 253.98,39.04 253.72,38.79 253.52,38.68 253.46,38.5 J1.B41
PE_SLOT1_TX_DP<7>: length 6.4
  BOTTOM w0.135: C190.2 250.01,43.31 250.01,39.09 249.69,38.76 249.52,38.68 249.46,38.5 J1.B45
PE_SLOT1_TX_DP<8>: length 6.3
  BOTTOM w0.135: J1.B50 244.46,39.01 244.28,38.95 244.14,39.02 243.99,39.17 243.99,41.08 244.15,41.24 244.15,41.64 243.99,41.79 243.99,42.2 244.15,42.35 244.15,42.76 243.99,42.91 243.99,43.31 C191.2
PE_SLOT1_TX_DP<9>: length 6.3
  BOTTOM w0.135: J1.B54 240.46,39.01 240.28,38.95 240.14,39.02 239.99,39.17 239.99,41.12 240.15,41.28 240.15,41.68 239.99,41.83 239.99,42.24 240.15,42.39 240.15,42.79 239.99,42.95 239.99,43.33 C192.2
PE_SLOT1_TX_DP<10>: length 6.3
  BOTTOM w0.135: C193.2 235.99,43.31 235.99,42.91 236.15,42.76 236.15,42.35 235.99,42.2 235.99,41.8 236.15,41.64 236.15,41.24 235.99,41.09 235.99,39.17 236.14,39.02 236.28,38.95 236.46,39.01 J1.B58
PE_SLOT1_TX_DP<11>: length 6.3
  BOTTOM w0.135: C194.2 231.99,43.3 231.99,42.9 232.15,42.74 232.15,42.34 231.99,42.19 231.99,41.78 232.15,41.63 232.15,41.23 231.99,41.07 231.99,39.18 232.13,39.04 232.3,38.96 232.46,39.01 J1.B62
PE_SLOT1_TX_DP<12>: length 6.3
  BOTTOM w0.135: J1.B66 228.46,39.01 228.29,38.96 228.17,39.01 227.99,39.19 227.99,41.09 228.15,41.24 228.15,41.64 227.99,41.8 227.99,42.2 228.15,42.35 228.15,42.76 227.99,42.91 227.99,43.31 C195.2
PE_SLOT1_TX_DP<13>: length 6.3
  BOTTOM w0.135: C196.2 223.99,43.3 223.99,42.9 224.15,42.75 224.15,42.34 223.99,42.19 223.99,41.78 224.15,41.63 224.15,41.23 223.99,41.07 223.99,39.18 224.16,39.01 224.28,38.95 224.46,39.01 J1.B70
PE_SLOT1_TX_DP<14>: length 8.1
  BOTTOM w0.135: J1.B74 220.46,39.01 220.28,38.95 220.14,39.02 219.99,39.17 219.99,43.04 219.91,43.51 219.57,44 219.03,44.37 218.36,44.37 C197.2
PE_SLOT1_TX_DP<15>: length 9.9
  BOTTOM w0.135: C198.2 210,42.95 210.56,42.95 211.18,42.84 213.09,41.51 214.12,41.33 214.68,41.33 215.12,41.25 215.87,40.49 215.95,40.05 215.95,39.19 216.11,39.03 216.28,38.95 216.46,39.01 J1.B78
PE_SLOT2_PRES_N: length 283.3
  TOP w0.114: v1(69.25,49.04) 67.93,49.04 65.32,51.65 65.32,52.76 64.38,53.7 64.38,54.1 63.63,54.86 R270.2
  IN2 w0.112: J2.A1 296.87,54.54 296.87,52.39 296.1,51.62 296.1,46.35 295.68,45.94 295.68,45.09 295.69,45.09 295.69,44.58 295.68,44.57 295.68,44.55 294.95,43.81 294.95,41.81 296.88,39.88 296.88,39.85 297,39.73 297,32.29 295.45,30.73 282.94,30.73 281.43,29.22 198.07,29.22 184.98,42.31 161.77,42.31 142.43,61.65 128.01,61.65 117.99,51.63 70.96,51.63 69.25,49.92 v1(69.25,49.04)
PE_SLOT2_RX_DN<0>: length 199.1
  IN3 w0.089: 99.04,88.48 99.02,88.48 98.97,88.53 95.13,88.53 94.96,88.37 94.96,88.22 95.05,88.13 v4(95.36,88.13)
  IN3 w0.135: J2.A17 278.2,54.82 278.39,54.76 278.51,54.83 278.67,54.98 278.67,58.61 arc(278.6,58.76) 278.46,58.82 278.16,58.82 arc(277.85,58.95) 277.73,59.26 277.73,60.78 277.65,60.88 277.06,61.3 276.87,61.26 276.54,61.5 276.5,61.69 276.17,61.92 275.98,61.89 275.65,62.12 275.62,62.31 275.28,62.54 275.09,62.51 274.76,62.74 274.73,62.93 274.4,63.16 273.76,63.27 273.58,63.15 273.18,63.22 273.06,63.4 272.66,63.47 272.5,63.35 272.1,63.42 271.99,63.58 271.28,63.71 270.87,64 270.3,64.8 270.11,64.84 269.88,65.17 269.91,65.36 269.68,65.69 269.51,66.66 269.19,67.12 268.85,67.36 267.3,67.63 267.14,67.52 266.75,67.59 266.63,67.75 266.24,67.82 266.08,67.71 265.68,67.78 265.57,67.94 265.17,68.01 265.01,67.9 264.61,67.97 264.5,68.13 253.36,70.09 242.88,68.24 223.89,71.59 221.17,71.11 215.06,72.19 212.79,71.79 210.49,72.2 208.47,71.84 149.11,82.31 146.8,81.9 120.87,86.47 119.27,86.19 116.96,86.6 114.54,86.17 111.4,86.72 108.43,86.2 105.59,86.7 103.7,86.37 102.74,86.54 99.96,88.48 99.04,88.48
  BOTTOM w0.135: U1.D24 v4(95.36,88.13)
PE_SLOT2_RX_DN<1>: length 196.9
  IN3 w0.089: v4(95.36,87.13) 95.05,87.13 94.98,87.2 94.98,87.37 95.14,87.53 99.12,87.53 99.16,87.48 99.19,87.48
  IN3 w0.135: 99.19,87.48 100.2,87.48 102.44,85.91 103.69,85.69 105.59,86.02 108.43,85.52 111.34,86.03 114.43,85.49 116.89,85.92 119.25,85.51 120.92,85.8 146.87,81.23 149.18,81.63 208.47,71.18 210.44,71.53 212.74,71.12 215,71.52 221.21,70.43 223.93,70.91 242.86,67.57 252.59,69.28 262.63,67.51 263.11,67.18 263.54,66.57 263.83,66.36 264.27,66.44 264.69,67.03 264.88,67.07 265.11,66.9 265.15,66.72 264.73,66.12 264.8,65.7 265.13,65.47 265.16,65.29 264.98,65.04 265.06,64.59 265.46,64.31 265.91,64.39 266.07,64.63 266.26,64.66 267.11,64.06 267.15,63.85 267.48,63.62 267.7,63.65 268.03,63.42 268.06,63.21 268.4,62.98 268.61,63.02 268.94,62.78 268.98,62.57 269.31,62.34 269.52,62.38 269.85,62.14 271.42,61.87 271.54,61.69 271.94,61.62 272.12,61.75 272.49,61.68 272.49,61.68 272.86,61.61 273.4,61.24 273.69,60.83 273.69,59.35 arc(273.65,59.25) 273.55,59.22 273.12,59.22 arc(272.8,59.08) 272.67,58.77 272.67,54.89 272.96,54.6 273.14,54.51 273.2,54.33 J2.A22
  BOTTOM w0.135: U1.D23 v4(95.36,87.13)
PE_SLOT2_RX_DN<2>: length 190.4
  IN3 w0.089: 99.06,86.49 99.04,86.49 98.99,86.54 95.16,86.54 94.98,86.37 94.98,86.2 95.05,86.13 v4(95.36,86.13)
  IN3 w0.135: J2.A26 269.2,54.33 269.14,54.51 268.99,54.58 268.68,54.89 268.68,58.78 arc(268.81,59.09) 269.12,59.22 269.58,59.22 arc(269.67,59.25) 269.7,59.33 269.7,60.8 269.56,61 268.86,61.49 268.65,61.45 268.31,61.68 268.28,61.9 267.95,62.13 267.73,62.09 267.4,62.32 267.36,62.54 266.21,63.34 265.59,63.45 265.43,63.34 265.03,63.41 264.92,63.57 264.52,63.64 264.36,63.53 263.97,63.6 263.85,63.76 261.12,64.24 260.16,64.91 259.61,65.69 259.44,66.68 259.11,67.15 258.6,67.51 252.44,68.59 242.81,66.9 223.93,70.23 221.21,69.75 215.01,70.84 212.79,70.45 210.49,70.86 208.53,70.51 149.23,80.97 146.83,80.54 120.97,85.13 120.22,85 119.23,84.83 116.87,85.24 114.27,84.79 111.19,85.33 108.39,84.84 105.55,85.34 103.7,85.01 102,85.31 100.49,86.37 99.77,86.49 99.06,86.49
  BOTTOM w0.135: U1.D22 v4(95.36,86.13)
PE_SLOT2_RX_DN<3>: length 189
  IN3 w0.089: 99.11,85.5 99.09,85.5 99.04,85.55 95.16,85.55 94.99,85.38 94.99,85.19 95.05,85.13 v4(95.36,85.13)
  IN3 w0.135: 99.11,85.5 99.77,85.5 100.67,85.34 101.58,84.71 103.7,84.33 105.55,84.66 108.41,84.15 111.21,84.65 114.29,84.1 116.82,84.55 119.17,84.14 120.86,84.43 146.86,79.85 149.35,80.28 208.58,69.84 210.49,70.18 212.79,69.77 215.01,70.16 221.26,69.06 223.98,69.54 242.86,66.21 244.7,66.53 244.87,66.42 244.92,66.12 245.27,65.88 245.75,65.96 245.99,66.31 245.94,66.58 246.07,66.76 246.67,66.86 246.83,66.75 246.91,66.25 247.25,66.01 247.78,66.11 248.02,66.45 247.93,66.95 248.01,67.06 248.01,67.06 248.09,67.17 250.36,67.57 250.88,67.48 251.46,67.07 251.64,66.82 251.74,66.23 251.63,66.07 251.7,65.67 251.86,65.56 251.93,65.16 252.16,64.84 252.46,64.62 255.6,64.08 255.95,64.33 256.02,64.74 256.17,64.85 256.54,64.78 256.65,64.63 256.58,64.22 256.83,63.87 257.43,63.76 257.78,64.01 257.85,64.42 258.01,64.53 258.38,64.47 258.49,64.31 258.42,63.9 258.66,63.55 259.67,63.38 259.78,63.22 260.18,63.15 260.34,63.26 260.78,63.19 261.34,62.8 261.34,62.79 261.37,62.58 261.7,62.35 261.92,62.39 262.25,62.16 262.29,61.94 262.62,61.71 262.83,61.75 263.46,61.31 263.73,60.92 263.73,59.44 arc(263.86,59.11) 264.19,58.98 264.52,58.98 arc(264.64,58.93) 264.7,58.81 264.7,54.85 264.93,54.61 265.14,54.51 265.2,54.33 J2.A30
  BOTTOM w0.135: U1.D21 v4(95.36,85.13)
PE_SLOT2_RX_DN<4>: length 178.3
  IN3 w0.089: v4(95.36,84.13) 95.05,84.13 95,84.18 95,84.38 95.15,84.53 99.09,84.53 99.14,84.49 99.16,84.49
  IN3 w0.135: J2.A36 259.2,54.33 259.14,54.51 258.93,54.61 258.69,54.85 258.69,58.79 arc(258.82,59.09) 259.11,59.22 259.56,59.22 arc(259.64,59.25) 259.67,59.33 259.67,61.08 259.1,61.9 257.79,62.81 257.26,62.91 257.09,62.78 256.69,62.85 256.57,63.03 256.17,63.1 255.99,62.98 255.59,63.05 255.47,63.22 255.07,63.29 254.89,63.17 254.5,63.24 254.37,63.42 223.74,68.82 221.26,68.38 215,69.48 212.79,69.09 210.49,69.5 208.55,69.16 149.42,79.61 146.81,79.15 121,83.7 119.39,83.42 116.82,83.87 114.25,83.42 111.14,83.96 108.39,83.48 105.55,83.98 103.7,83.65 101.31,84.07 100.86,84.39 100.31,84.49 99.16,84.49
  BOTTOM w0.135: U1.D20 v4(95.36,84.13)
PE_SLOT2_RX_DN<5>: length 176.3
  IN3 w0.089: v4(95.36,83.13) 95.05,83.13 94.99,83.19 94.99,83.37 95.14,83.53 99.06,83.53 99.11,83.48 99.13,83.48
  IN3 w0.135: J2.A40 255.2,54.33 255.14,54.51 254.93,54.61 254.71,54.84 254.71,58.77 arc(254.83,59.07) 255.13,59.19 255.56,59.19 arc(255.66,59.23) 255.7,59.32 255.7,60.59 255.63,60.96 255.44,61.24 254.62,61.81 254.41,61.78 254.07,62.01 254.04,62.22 253.28,62.75 252.88,62.82 252.7,62.7 252.31,62.77 252.18,62.94 251.78,63.01 251.61,62.89 251.21,62.96 251.09,63.14 229.03,67.03 227.02,66.67 226.23,66.81 225.99,67.16 226.06,67.56 225.94,67.73 225.69,67.78 225.54,67.67 225.46,67.25 225.1,66.99 224.61,67.08 224.35,67.44 224.43,67.86 224.32,68.02 224.07,68.06 223.92,67.95 223.85,67.56 223.48,67.3 214.96,68.8 212.78,68.41 210.48,68.82 208.61,68.49 149.41,78.93 146.78,78.46 121,83.04 119.34,82.75 116.82,83.19 114.3,82.74 111.22,83.29 108.42,82.79 105.5,83.31 103.41,82.94 100.34,83.48 99.13,83.48
  BOTTOM w0.135: U1.D19 v4(95.36,83.13)
PE_SLOT2_RX_DN<6>: length 169.7
  IN3 w0.089: v4(95.36,82.13) 95.06,82.13 94.98,82.21 94.98,82.37 95.14,82.53 99.06,82.53 99.11,82.48 99.13,82.48
  IN3 w0.135: 99.13,82.48 101.77,82.48 103.24,82.22 105.53,82.62 108.44,82.11 110.51,82.48 110.51,82.48 111.24,82.61 114.3,82.07 116.83,82.51 119.34,82.07 120.87,82.34 146.76,77.77 149.34,78.23 208.56,67.78 210.49,68.12 212.79,67.72 212.79,67.74 214.85,68.08 226.7,65.99 227.02,65.99 228.91,66.32 245.61,63.38 245.73,63.22 246.12,63.15 246.28,63.26 246.68,63.19 246.79,63.03 247.19,62.96 247.35,63.07 247.75,63 247.87,62.83 248.27,62.76 248.45,62.88 249.14,62.76 251.49,61.11 251.66,60.87 251.66,59.35 arc(251.62,59.25) 251.53,59.22 251.11,59.22 arc(250.82,59.09) 250.69,58.79 250.69,54.85 250.93,54.61 251.14,54.51 251.2,54.33 J2.A44
  BOTTOM w0.135: U1.D18 v4(95.36,82.13)
PE_SLOT2_RX_DN<7>: length 167.5
  IN3 w0.089: v4(95.36,80.13) 95.05,80.13 94.96,80.22 94.96,80.51 95.18,80.72 95.71,80.72 95.76,80.67 95.78,80.67
  IN3 w0.135: J2.A48 247.2,54.33 247.14,54.51 246.93,54.61 246.68,54.87 246.68,58.8 arc(246.61,58.96) 246.45,59.03 246.15,59.03 arc(245.85,59.16) 245.72,59.46 245.72,60.66 245,61.7 243.8,62.54 243.16,62.65 242.99,62.52 242.59,62.59 242.46,62.77 242.07,62.84 241.89,62.72 241.49,62.79 241.37,62.97 240.97,63.04 240.79,62.91 240.39,62.98 240.27,63.16 239.87,63.23 239.7,63.1 239.3,63.17 239.17,63.35 237.63,63.62 237.02,63.52 235.25,63.83 235,64.18 235.05,64.43 234.94,64.59 234.57,64.65 234.41,64.54 234.37,64.29 234.02,64.04 233.41,64.15 233.17,64.5 233.21,64.75 233.1,64.91 232.73,64.97 232.58,64.86 232.53,64.61 232.18,64.37 231.58,64.47 231.34,64.82 231.38,65.08 231.27,65.23 230.9,65.3 230.75,65.19 230.7,64.94 230.35,64.69 229.75,64.8 229.5,65.15 229.55,65.4 229.44,65.56 229.07,65.62 228.91,65.51 228.87,65.26 228.45,64.97 214.75,67.38 212.84,67.05 211.66,67.26 210.54,67.45 208.61,67.11 149.42,77.55 146.67,77.07 120.84,81.65 119.34,81.39 116.78,81.84 114.26,81.39 111.26,81.92 108.45,81.43 105.62,81.93 102.88,81.45 102.01,81.6 99.52,81.16 96.74,80.67 95.78,80.67
  BOTTOM w0.135: U1.D17 v4(95.36,80.13)
PE_SLOT2_RX_DN<8>: length 160.1
  IN3 w0.089: v4(95.36,79.13) 95.05,79.13 94.96,79.22 94.96,79.34 95.15,79.54 98.81,79.54 98.86,79.49 98.88,79.49
  IN3 w0.135: 98.88,79.49 99.78,79.49 100.7,79.65 100.88,79.53 101.28,79.6 101.4,79.78 101.76,79.84 102.68,80.48 103.57,80.64 103.75,80.52 104.14,80.59 104.27,80.76 104.67,80.83 104.84,80.71 105.24,80.78 105.37,80.96 106.11,81.09 106.51,81.02 106.62,80.86 107.02,80.79 107.18,80.9 108.22,80.72 108.62,80.79 108.78,80.68 109.18,80.75 109.29,80.9 109.69,80.97 109.84,80.86 110.24,80.93 110.35,81.09 111.29,81.26 114.28,80.73 116.75,81.17 119.48,80.68 119.5,80.69 120.86,80.93 146.5,76.38 149.41,76.89 208.62,66.45 210.5,66.78 212.79,66.38 214.7,66.71 237.07,62.77 237.18,62.61 237.57,62.54 237.73,62.65 238.13,62.58 238.24,62.42 238.64,62.35 238.8,62.46 239.2,62.39 239.31,62.24 239.71,62.17 239.86,62.28 240.26,62.21 240.95,61.73 241.38,61.29 241.68,60.86 241.68,59.39 arc(241.82,59.06) 242.14,58.93 242.51,58.93 arc(242.63,58.88) 242.67,58.76 242.67,54.99 242.51,54.83 242.39,54.76 242.2,54.82 J2.A53
  BOTTOM w0.135: U1.D16 v4(95.36,79.13)
PE_SLOT2_RX_DN<9>: length 158
  IN3 w0.089: 97.27,78.49 97.25,78.49 97.2,78.54 95.15,78.54 94.96,78.35 94.96,78.22 95.05,78.13 v4(95.36,78.13)
  IN3 w0.135: J2.A57 238.2,54.82 238.39,54.76 238.51,54.83 238.69,55 238.69,58.76 arc(238.64,58.88) 238.51,58.93 238.13,58.93 arc(237.82,59.05) 237.69,59.36 237.69,60.81 237.09,61.68 236.27,62.25 235.87,62.32 235.69,62.2 235.29,62.27 235.17,62.44 234.77,62.51 234.6,62.39 234.2,62.46 234.07,62.64 214.75,66.05 212.79,65.7 210.5,66.1 208.65,65.78 149.41,76.23 144.47,75.36 127.11,78.42 126.95,78.31 126.81,77.48 126.46,77.23 125.85,77.34 125.61,77.69 125.75,78.52 125.65,78.68 123.53,79.05 120.37,78.51 119.24,78.71 119.08,78.6 118.69,78.67 118.57,78.83 117.61,79 116.94,78.88 116.83,78.72 116.43,78.65 116.27,78.76 115.02,78.54 112.35,79.01 110.92,78.76 109.92,78.93 109.08,78.78 108.97,78.63 108.57,78.56 108.41,78.67 108.01,78.6 107.9,78.44 107.51,78.37 107.35,78.48 106.95,78.41 106.07,78.56 105.41,78.45 104.53,78.6 104.37,78.49 103.97,78.56 103.86,78.72 103.47,78.79 103.31,78.68 102.91,78.75 102.8,78.91 102.4,78.98 102.15,79.02 101.76,78.95 101.65,78.79 101.25,78.72 101.09,78.84 100.69,78.77 100.58,78.61 100.18,78.54 100.02,78.65 99.52,78.56 99.11,78.49 97.27,78.49
  BOTTOM w0.135: U1.D15 v4(95.36,78.13)
PE_SLOT2_RX_DN<10>: length 151.7
  IN3 w0.089: v4(95.36,77.13) 95.05,77.13 94.96,77.22 94.96,77.34 95.15,77.54 97.18,77.54 97.23,77.49 97.25,77.49
  IN3 w0.135: J2.A61 234.2,54.82 234.38,54.76 234.51,54.83 234.67,54.99 234.67,58.76 arc(234.62,58.88) 234.5,58.93 234.1,58.93 arc(233.81,59.05) 233.68,59.35 233.68,60.77 233.12,61.57 232.04,62.32 231.65,62.39 231.49,62.28 231.09,62.35 230.98,62.51 230.58,62.58 230.42,62.47 230.02,62.54 229.91,62.7 229.52,62.77 229.36,62.66 228.96,62.73 228.85,62.89 228.45,62.96 228.29,62.85 227.89,62.92 227.78,63.08 214.72,65.38 212.46,64.98 210.27,65.37 208.75,65.1 150.02,75.45 140.59,73.79 123.09,76.89 121.75,76.66 119.24,77.1 116.72,76.65 114.64,77.02 112.51,76.65 110.83,76.94 109.45,76.7 108.33,76.9 107.86,76.81 107.75,76.66 107.35,76.59 107.19,76.7 106.79,76.63 106.31,76.71 106.15,76.6 105.75,76.67 105.64,76.83 105.24,76.9 104.2,76.72 103.65,76.81 103.49,76.7 103.09,76.77 102.98,76.93 102.58,77 102.42,76.89 102.02,76.96 101.91,77.12 101.51,77.19 101.36,77.08 100.96,77.15 100.85,77.31 99.83,77.49 97.25,77.49
  BOTTOM w0.135: U1.D14 v4(95.36,77.13)
PE_SLOT2_RX_DN<11>: length 149.3
  IN3 w0.089: 97.25,76.49 97.23,76.49 97.18,76.54 95.15,76.54 94.96,76.34 94.96,76.22 95.05,76.13 v4(95.36,76.13)
  IN3 w0.135: J2.A65 230.2,54.82 230.38,54.76 230.51,54.83 230.68,55 230.68,58.79 arc(230.65,58.89) 230.55,58.93 230.13,58.93 arc(229.8,59.06) 229.67,59.39 229.67,60.71 229.43,61.05 228.26,61.87 228.07,61.83 227.74,62.07 227.7,62.26 227.37,62.49 226.86,62.58 226.7,62.47 226.3,62.54 226.19,62.7 225.79,62.77 225.63,62.66 225.23,62.73 225.12,62.88 214.78,64.71 212.42,64.29 210.21,64.68 208.67,64.41 150.85,74.6 138.9,72.5 128.11,74.42 127.37,74.29 126.51,74.44 125.71,74.58 125.56,74.48 125.46,73.94 125.18,73.74 124.59,73.85 124.38,74.15 124.47,74.65 124.36,74.8 122.37,75.15 121,74.72 118.37,75.18 115.52,74.68 113.34,75.07 111.73,74.78 111.11,74.89 110.95,74.78 110.55,74.85 110.44,75.01 110.04,75.08 109.31,74.95 108.51,75.09 108.35,74.98 107.95,75.05 107.84,75.21 107.44,75.28 106.56,75.13 106.45,74.97 106.05,74.9 105.9,75.01 105.5,74.94 105.39,74.78 104.99,74.71 104.83,74.82 104.46,74.76 104.41,74.76 103.78,74.87 103.62,74.76 103.22,74.83 103.11,74.99 102.23,75.14 101.61,75.58 101.39,75.54 101.06,75.77 101.03,75.98 100.79,76.15 99.52,76.37 98.85,76.49 97.25,76.49
  BOTTOM w0.135: U1.D13 v4(95.36,76.13)
PE_SLOT2_RX_DN<12>: length 144.7
  IN3 w0.089: 96.85,75.47 96.83,75.47 96.78,75.52 95.13,75.52 94.96,75.34 94.96,75.22 95.05,75.13 v4(95.36,75.13)
  IN3 w0.135: J2.A69 226.2,54.82 226.38,54.76 226.51,54.83 226.67,54.99 226.67,58.79 arc(226.63,58.89) 226.54,58.93 226.11,58.93 arc(225.81,59.05) 225.68,59.36 225.68,61.13 225.12,61.94 224.58,62.32 223.47,62.52 223.31,62.4 222.91,62.47 222.8,62.63 222.4,62.7 222.24,62.59 221.84,62.66 221.73,62.82 221.34,62.89 221.18,62.78 220.78,62.85 220.67,63.01 220.27,63.08 220.11,62.97 219.71,63.04 219.6,63.2 219.2,63.27 219.05,63.16 218.65,63.23 218.54,63.38 218.14,63.45 217.98,63.34 217.58,63.41 217.47,63.57 217.07,63.64 216.91,63.53 216.52,63.6 216.41,63.76 216.01,63.83 215.85,63.72 215.45,63.79 215.34,63.95 214.93,64.02 212.4,63.57 210.19,63.96 208.62,63.69 151.44,73.77 138.13,71.42 128.97,73.04 126.9,72.67 125.27,72.96 123.59,72.66 120.62,73.19 118.14,72.75 115.74,73.17 114.69,72.99 113.77,73.15 112.13,72.86 110.51,73.15 107.93,72.69 105.58,73.11 103.7,72.78 102.97,72.9 102.59,73.17 102.59,73.18 102.26,73.41 102.07,73.38 101.74,73.61 101.71,73.8 101.38,74.03 101.19,74 100.86,74.23 100.82,74.42 99.72,75.19 99.52,75.23 98.15,75.47 96.85,75.47
  BOTTOM w0.135: U1.D12 v4(95.36,75.13)
PE_SLOT2_RX_DN<13>: length 143.2
  IN3 w0.089: v4(95.36,74.13) 95.05,74.13 94.96,74.22 94.96,74.34 95.14,74.52 96.85,74.52 96.9,74.48 96.92,74.48
  IN3 w0.135: 96.92,74.48 98.09,74.48 99.52,74.22 99.65,74.2 100.71,73.46 101.08,72.93 101.45,72.4 101.42,72.18 101.65,71.85 101.86,71.82 102.09,71.49 102.53,71.18 102.95,71 103.42,70.92 104.97,71.2 106.08,71 107.49,71.25 109.22,70.94 111.2,71.29 112.7,71.03 113.95,71.25 114.35,71.18 114.46,71.02 114.86,70.95 115.02,71.06 115.55,70.97 116.91,71.21 117.31,71.14 117.42,70.98 117.82,70.91 117.98,71.02 118.91,70.86 119.78,71.01 119.94,70.9 120.03,70.39 120.38,70.14 120.98,70.25 121.23,70.6 121.14,71.11 121.25,71.27 122.96,71.57 125.63,71.1 126.83,71.31 126.98,71.2 127.04,70.88 127.39,70.63 127.87,70.72 128.12,71.07 128.06,71.37 128.2,71.56 129.46,71.79 137.52,70.37 152.18,72.95 208.7,62.99 210.2,63.25 211.39,63.04 211.5,62.88 211.9,62.81 212.06,62.92 212.46,62.85 212.85,62.92 213.01,62.81 213.41,62.88 213.52,63.04 214.23,63.17 215.11,63.01 215.22,62.86 215.62,62.79 215.78,62.9 217.15,62.65 217.27,62.49 217.66,62.42 217.82,62.54 218.22,62.47 218.33,62.31 218.73,62.24 218.89,62.35 219.29,62.28 219.4,62.12 219.79,62.05 219.95,62.16 220.37,62.09 221.08,61.59 221.68,60.73 221.68,59.35 arc(221.81,59.05) 222.1,58.93 222.52,58.93 arc(222.62,58.89) 222.66,58.79 222.66,54.97 222.51,54.83 222.38,54.76 222.2,54.82 J2.A73
  BOTTOM w0.135: U1.D11 v4(95.36,74.13)
PE_SLOT2_RX_DN<14>: length 137
  IN3 w0.089: v4(95.36,73.13) 95.05,73.13 94.96,73.22 94.96,73.34 95.15,73.53 96.8,73.53 96.85,73.49 96.87,73.49
  IN3 w0.135: J2.A77 218.2,54.82 218.38,54.76 218.51,54.83 218.7,55.01 218.7,58.79 arc(218.66,58.89) 218.56,58.93 218.1,58.93 arc(217.8,59.05) 217.68,59.35 217.68,60.61 217.41,60.99 217.08,61.23 216.64,61.3 216.46,61.18 216.06,61.25 215.94,61.43 215.54,61.5 215.37,61.37 214.97,61.44 214.84,61.62 209.84,62.5 208.46,62.26 152.61,72.11 135.95,69.17 129.95,70.24 125.79,69.5 123.49,69.91 118.36,69 118.31,69 116.61,69.32 114.5,68.95 114.01,69.04 113.85,68.93 113.45,69 113.34,69.16 112.94,69.23 112.78,69.11 112.39,69.19 112.27,69.34 111.88,69.41 110.4,69.15 110.29,69 109.89,68.93 109.73,69.04 109.34,68.97 107.88,69.22 107.73,69.11 107.33,69.18 107.22,69.34 106.82,69.41 105.29,69.14 105.18,68.98 104.78,68.91 104.62,69.02 104.23,68.95 103.14,68.95 102.22,69.6 101.42,70.74 101.21,70.77 100.98,71.1 101.02,71.32 100.78,71.65 100.57,71.69 100.34,72.02 100.38,72.23 100.15,72.56 99.21,73.22 97.69,73.49 96.87,73.49
  BOTTOM w0.135: U1.D10 v4(95.36,73.13)
PE_SLOT2_RX_DN<15>: length 135
  IN3 w0.089: 96.87,72.48 96.85,72.48 96.8,72.53 95.14,72.53 94.96,72.34 94.96,72.22 95.05,72.13 v4(95.36,72.13)
  IN3 w0.135: 96.87,72.48 97.68,72.48 98.87,72.27 99.79,71.62 100.84,70.13 100.8,69.91 101.03,69.58 101.25,69.55 101.5,69.18 101.65,68.33 102.03,67.78 102.79,67.25 104.66,67.25 106.06,67.5 107.94,67.17 109.67,67.47 111.37,67.17 113.32,67.52 113.9,67.41 114.01,67.26 114.41,67.19 114.57,67.3 116.09,67.03 116.58,67.11 116.74,67 117.14,67.07 117.25,67.23 117.65,67.3 117.8,67.19 118.2,67.26 118.31,67.42 119.55,67.64 120.14,67.53 120.25,67.38 120.65,67.31 120.81,67.42 121.66,67.27 122.23,67.37 122.39,67.26 122.47,66.77 122.84,66.51 123.14,66.57 123.45,66.62 123.68,66.95 123.59,67.48 123.71,67.66 125.48,67.97 126.11,67.86 126.22,67.7 126.62,67.63 126.78,67.74 127.18,67.67 127.29,67.51 127.69,67.44 127.85,67.55 130.02,67.17 153.34,71.28 208.65,61.53 209.89,61.75 210.25,61.68 210.61,61.62 210.74,61.44 211.13,61.37 211.31,61.5 211.71,61.43 211.83,61.25 212.23,61.18 212.41,61.3 213,61.2 213.44,60.89 213.64,60.6 213.64,59.29 arc(213.76,58.99) 214.06,58.87 214.57,58.87 arc(214.67,58.83) 214.71,58.73 214.71,55.02 214.51,54.83 214.38,54.76 214.2,54.82 J2.A81
  BOTTOM w0.135: U1.D9 v4(95.36,72.13)
PE_SLOT2_RX_DP<0>: length 199.2
  IN3 w0.089: 99.04,88.77 99.02,88.77 98.97,88.72 95.05,88.72 94.77,88.45 94.77,88.26 94.64,88.13 v4(94.36,88.13)
  IN3 w0.135: J2.A16 278.45,54.33 278.51,54.51 278.51,54.51 278.68,54.59 278.95,54.86 278.95,58.61 arc(278.81,58.96) 278.46,59.11 278.16,59.11 arc(278.06,59.15) 278.01,59.26 278.01,60.87 277.86,61.09 277.12,61.6 274.51,63.43 271.39,63.98 271.07,64.2 269.95,65.8 269.78,66.78 269.4,67.32 268.96,67.63 253.36,70.38 242.88,68.53 223.89,71.88 221.17,71.4 215.05,72.48 212.79,72.08 210.49,72.49 208.47,72.13 149.11,82.6 146.8,82.19 120.87,86.76 119.27,86.48 116.96,86.89 114.54,86.46 111.4,87.02 108.43,86.49 105.59,86.99 103.7,86.66 102.85,86.81 100.05,88.77 99.04,88.77
  BOTTOM w0.135: U1.E24 v4(94.36,88.13)
PE_SLOT2_RX_DP<1>: length 196.9
  IN3 w0.089: v4(94.36,87.13) 94.71,87.13 94.79,87.21 94.79,87.45 95.06,87.72 99.12,87.72 99.16,87.77 99.19,87.77
  IN3 w0.135: J2.A21 273.45,54.82 273.27,54.76 273.13,54.83 272.96,55.01 272.96,58.77 arc(273,58.88) 273.12,58.93 273.55,58.93 arc(273.85,59.05) 273.97,59.35 273.97,60.92 273.6,61.44 272.97,61.89 272.05,62.05 269.97,62.42 266.33,64.96 265.9,64.89 265.74,64.65 265.53,64.62 265.32,64.76 265.29,64.97 265.47,65.23 265.39,65.64 265.06,65.87 265.03,66.06 265.45,66.66 265.38,67.07 264.95,67.37 264.52,67.3 264.11,66.7 263.9,66.67 263.74,66.77 263.31,67.39 262.74,67.79 252.59,69.58 242.86,67.86 223.93,71.2 221.21,70.72 215.01,71.81 212.74,71.41 210.44,71.82 208.47,71.47 149.18,81.93 146.87,81.52 120.92,86.09 119.25,85.8 116.89,86.22 114.43,85.78 111.34,86.33 108.43,85.81 105.59,86.31 103.7,85.98 102.55,86.18 100.29,87.77 99.19,87.77
  BOTTOM w0.135: U1.E23 v4(94.36,87.13)
PE_SLOT2_RX_DP<2>: length 190.4
  IN3 w0.089: 99.06,86.78 99.04,86.78 98.99,86.73 95.08,86.73 94.79,86.45 94.79,86.19 94.73,86.13 v4(94.36,86.13)
  IN3 w0.135: J2.A25 269.45,54.82 269.27,54.76 269.16,54.82 268.97,55.01 268.97,58.78 arc(269.01,58.89) 269.12,58.93 269.58,58.93 arc(269.87,59.05) 269.99,59.33 269.99,60.89 269.76,61.21 266.32,63.62 261.23,64.51 260.37,65.12 259.89,65.8 259.71,66.79 259.32,67.35 258.71,67.78 252.44,68.89 242.81,67.19 223.93,70.52 221.21,70.04 215.01,71.13 212.79,70.74 210.49,71.15 208.53,70.8 149.23,81.26 146.83,80.83 120.97,85.43 119.93,85.24 119.23,85.12 116.87,85.54 114.89,85.19 114.27,85.08 111.19,85.62 108.39,85.13 105.55,85.63 103.7,85.3 102.11,85.58 100.6,86.64 99.8,86.78 99.06,86.78
  BOTTOM w0.135: U1.E22 v4(94.36,86.13)
PE_SLOT2_RX_DP<3>: length 189
  IN3 w0.089: 99.11,85.79 99.09,85.79 99.04,85.74 95.08,85.74 94.8,85.46 94.8,85.21 94.72,85.13 v4(94.36,85.13)
  IN3 w0.135: 99.11,85.79 99.8,85.79 100.79,85.61 101.7,84.98 103.7,84.62 105.55,84.95 108.41,84.44 111.21,84.94 114.29,84.4 116.82,84.84 119.17,84.43 120.86,84.72 146.86,80.14 149.35,80.58 208.58,70.13 210.49,70.47 212.79,70.06 215.01,70.45 221.26,69.35 223.98,69.83 242.86,66.5 244.77,66.84 245.13,66.58 245.18,66.29 245.34,66.18 245.58,66.22 245.69,66.38 245.64,66.65 245.9,67.02 246.74,67.17 247.09,66.92 247.18,66.42 247.32,66.32 247.62,66.37 247.72,66.52 247.63,67.02 247.77,67.22 247.92,67.43 250.36,67.86 250.99,67.75 251.67,67.27 251.91,66.93 252.2,65.28 252.36,65.04 252.58,64.89 255.53,64.38 255.69,64.49 255.76,64.9 256.11,65.15 256.71,65.05 256.96,64.7 256.89,64.29 257,64.13 257.36,64.07 257.52,64.18 257.59,64.59 257.94,64.83 258.54,64.73 258.79,64.38 258.72,63.97 258.83,63.81 260.89,63.46 263,61.98 262.99,61.98 263.66,61.52 264.02,61.01 264.02,59.44 arc(264.07,59.32) 264.19,59.27 264.52,59.27 arc(264.85,59.13) 264.98,58.81 264.98,54.97 265.1,54.85 265.27,54.76 265.45,54.82 J2.A29
  BOTTOM w0.135: U1.E21 v4(94.36,85.13)
PE_SLOT2_RX_DP<4>: length 178.4
  IN3 w0.089: 99.16,84.77 99.14,84.77 99.09,84.72 95.07,84.72 94.81,84.46 94.81,84.22 94.72,84.13 v4(94.36,84.13)
  IN3 w0.135: J2.A35 259.45,54.82 259.27,54.76 259.1,54.85 258.98,54.97 258.98,58.79 arc(259.02,58.89) 259.11,58.93 259.56,58.93 arc(259.84,59.05) 259.96,59.33 259.96,61.17 259.3,62.1 257.9,63.08 257.2,63.21 223.74,69.11 221.26,68.67 215,69.78 212.79,69.39 210.49,69.79 208.55,69.45 149.42,79.9 146.81,79.44 121,83.99 119.39,83.71 116.82,84.16 114.25,83.71 111.14,84.26 108.39,83.77 105.55,84.27 103.7,83.94 101.42,84.35 100.97,84.66 100.33,84.77 99.16,84.77
  BOTTOM w0.135: U1.E20 v4(94.36,84.13)
PE_SLOT2_RX_DP<5>: length 176.4
  IN3 w0.089: 99.13,83.77 99.11,83.77 99.06,83.72 95.07,83.72 94.8,83.45 94.8,83.22 94.71,83.13 v4(94.36,83.13)
  IN3 w0.135: J2.A39 255.45,54.82 255.27,54.76 255.1,54.85 254.99,54.96 254.99,58.77 arc(255.03,58.86) 255.13,58.9 255.56,58.9 arc(255.86,59.03) 255.98,59.32 255.98,60.62 255.9,61.07 255.64,61.45 253.39,63.02 229.04,67.32 227.02,66.96 226.4,67.07 226.29,67.23 226.36,67.62 226.1,67.99 225.62,68.08 225.27,67.83 225.2,67.41 225.03,67.3 224.77,67.34 224.66,67.51 224.73,67.93 224.49,68.28 224.01,68.37 223.66,68.12 223.59,67.72 223.41,67.6 214.96,69.09 212.78,68.7 210.48,69.11 208.61,68.78 149.41,79.22 146.78,78.75 121,83.33 119.34,83.04 118.13,83.25 116.82,83.48 115.52,83.25 115.51,83.25 114.3,83.04 111.22,83.58 108.42,83.09 105.5,83.6 103.41,83.23 100.36,83.77 99.13,83.77
  BOTTOM w0.135: U1.E19 v4(94.36,83.13)
PE_SLOT2_RX_DP<6>: length 169.8
  IN3 w0.089: 99.13,82.76 99.11,82.76 99.06,82.72 95.06,82.72 94.79,82.44 94.79,82.19 94.73,82.13 v4(94.36,82.13)
  IN3 w0.135: 99.13,82.76 101.8,82.76 103.24,82.51 105.53,82.92 108.44,82.4 110.46,82.76 110.46,82.76 111.24,82.9 114.3,82.36 116.83,82.8 119.34,82.36 120.87,82.63 146.76,78.06 149.34,78.52 208.56,68.07 210.49,68.41 212.74,68.02 212.74,68.02 214.85,68.37 226.72,66.28 226.89,66.28 226.89,66.28 227.02,66.28 228.91,66.62 248.38,63.18 249.25,63.03 251.69,61.32 251.95,60.96 251.95,59.35 arc(251.83,59.05) 251.53,58.93 251.11,58.93 arc(251.02,58.89) 250.98,58.79 250.98,54.97 251.1,54.85 251.27,54.76 251.45,54.82 J2.A43
  BOTTOM w0.135: U1.E18 v4(94.36,82.13)
PE_SLOT2_RX_DP<7>: length 167.4
  IN3 w0.089: 95.78,80.96 95.76,80.96 95.71,80.91 95.1,80.91 94.77,80.58 94.77,80.22 94.68,80.13 v4(94.36,80.13)
  IN3 w0.135: J2.A47 247.45,54.82 247.27,54.76 247.1,54.85 246.97,54.98 246.97,58.8 arc(246.81,59.17) 246.45,59.32 246.15,59.32 arc(246.05,59.36) 246.01,59.46 246.01,60.75 245.2,61.91 243.91,62.81 243.1,62.95 237.63,63.92 237.02,63.81 235.41,64.09 235.3,64.24 235.35,64.5 235.1,64.85 234.5,64.95 234.15,64.71 234.1,64.46 233.95,64.35 233.58,64.41 233.47,64.57 233.52,64.82 233.27,65.17 232.67,65.28 232.32,65.03 232.27,64.78 232.12,64.67 231.75,64.74 231.64,64.89 231.68,65.14 231.44,65.49 230.83,65.6 230.48,65.36 230.44,65.1 230.28,64.99 229.92,65.06 229.81,65.21 229.85,65.47 229.61,65.82 229,65.92 228.65,65.68 228.61,65.43 228.39,65.27 214.8,67.67 214.75,67.68 212.84,67.34 212.84,67.34 210.54,67.75 208.61,67.4 149.42,77.84 146.67,77.36 120.84,81.95 119.34,81.68 116.78,82.13 114.26,81.69 111.26,82.22 108.45,81.72 105.62,82.22 102.88,81.74 102.01,81.89 99.52,81.46 96.71,80.96 95.78,80.96
  BOTTOM w0.135: U1.E17 v4(94.36,80.13)
PE_SLOT2_RX_DP<8>: length 160.1
  IN3 w0.089: v4(94.36,79.13) 94.65,79.13 94.77,79.25 94.77,79.42 95.07,79.73 98.81,79.73 98.86,79.78 98.88,79.78
  IN3 w0.135: 98.88,79.78 99.75,79.78 101.65,80.11 102.57,80.76 106.11,81.38 108.22,81.01 111.29,81.55 114.28,81.02 116.75,81.46 119.48,80.98 120.86,81.22 146.5,76.67 149.41,77.18 208.62,66.74 210.5,67.07 212.79,66.67 214.7,67.01 240.37,62.48 241.13,61.95 241.6,61.48 241.97,60.95 241.97,59.39 arc(242.02,59.26) 242.14,59.22 242.51,59.22 arc(242.83,59.08) 242.96,58.76 242.96,54.87 242.68,54.59 242.51,54.51 242.51,54.51 242.45,54.33 J2.A52
  BOTTOM w0.135: U1.E16 v4(94.36,79.13)
PE_SLOT2_RX_DP<9>: length 158
  IN3 w0.089: 97.27,78.77 97.25,78.77 97.2,78.73 95.07,78.73 94.77,78.42 94.77,78.22 94.68,78.13 v4(94.36,78.13)
  IN3 w0.135: J2.A56 238.45,54.33 238.51,54.51 238.51,54.51 238.68,54.59 238.97,54.88 238.97,58.76 arc(238.84,59.08) 238.51,59.22 238.13,59.22 arc(238.02,59.26) 237.98,59.36 237.98,60.9 237.29,61.88 236.38,62.52 235.8,62.62 214.75,66.34 212.79,65.99 210.5,66.4 208.65,66.07 149.41,76.52 144.47,75.65 127.04,78.72 126.69,78.48 126.55,77.64 126.39,77.53 126.02,77.6 125.91,77.75 126.06,78.59 125.81,78.94 123.53,79.34 120.37,78.8 117.61,79.29 115.02,78.83 112.35,79.3 110.92,79.05 109.92,79.22 108.91,79.05 106.95,78.7 106.07,78.86 105.41,78.74 103.05,79.16 102.47,79.26 102.45,79.26 102.15,79.31 99.52,78.85 99.09,78.77 97.27,78.77
  BOTTOM w0.135: U1.E15 v4(94.36,78.13)
PE_SLOT2_RX_DP<10>: length 151.8
  IN3 w0.089: v4(94.36,77.13) 94.68,77.13 94.77,77.22 94.77,77.42 95.07,77.73 97.18,77.73 97.23,77.77 97.25,77.77
  IN3 w0.135: J2.A60 234.45,54.33 234.51,54.51 234.51,54.51 234.68,54.59 234.96,54.87 234.96,58.76 arc(234.83,59.08) 234.5,59.22 234.1,59.22 arc(234.01,59.25) 233.97,59.35 233.97,60.86 233.32,61.78 232.16,62.6 214.72,65.67 212.46,65.27 210.27,65.66 208.75,65.39 150.02,75.75 140.59,74.08 123.09,77.19 121.75,76.95 119.29,77.38 119.24,77.39 116.72,76.95 114.64,77.31 112.51,76.94 110.83,77.24 109.45,76.99 108.33,77.19 106.79,76.92 105.24,77.19 104.2,77.01 103.64,77.11 103.58,77.12 99.86,77.77 97.25,77.77
  BOTTOM w0.135: U1.E14 v4(94.36,77.13)
PE_SLOT2_RX_DP<11>: length 149.4
  IN3 w0.089: 97.25,76.78 97.23,76.78 97.18,76.73 95.07,76.73 94.77,76.42 94.77,76.26 94.64,76.13 v4(94.36,76.13)
  IN3 w0.135: J2.A64 230.45,54.33 230.51,54.51 230.51,54.51 230.68,54.59 230.97,54.88 230.97,58.79 arc(230.85,59.09) 230.55,59.22 230.13,59.22 arc(230.01,59.26) 229.96,59.39 229.96,60.8 229.64,61.25 227.48,62.76 214.78,65 212.42,64.58 210.21,64.97 208.67,64.7 150.85,74.9 138.9,72.79 128.11,74.71 127.37,74.58 125.64,74.89 125.3,74.65 125.2,74.1 125.12,74.04 124.76,74.11 124.68,74.22 124.77,74.72 124.53,75.06 122.35,75.45 120.98,75.02 118.37,75.48 115.52,74.97 113.34,75.36 111.73,75.08 110.04,75.37 109.31,75.24 108.56,75.38 108.44,75.4 107.44,75.57 104.43,75.04 102.34,75.41 100.91,76.42 99.52,76.66 98.87,76.78 97.25,76.78
  BOTTOM w0.135: U1.E13 v4(94.36,76.13)
PE_SLOT2_RX_DP<12>: length 144.7
  IN3 w0.089: v4(94.36,75.13) 94.68,75.13 94.77,75.22 94.77,75.42 95.05,75.71 96.78,75.71 96.83,75.76 96.85,75.76
  IN3 w0.135: J2.A68 226.45,54.33 226.51,54.51 226.51,54.51 226.68,54.59 226.96,54.87 226.96,58.79 arc(226.83,59.09) 226.54,59.22 226.11,59.22 arc(226.01,59.26) 225.97,59.36 225.97,61.23 225.32,62.15 224.69,62.59 214.93,64.31 212.4,63.87 210.19,64.26 208.62,63.98 151.44,74.06 138.13,71.72 128.97,73.33 126.9,72.97 125.27,73.25 123.59,72.96 120.62,73.48 118.14,73.04 115.74,73.47 114.69,73.28 113.77,73.44 112.13,73.16 110.51,73.44 107.93,72.99 105.58,73.4 103.7,73.07 103.08,73.17 102.88,73.32 102.88,73.33 99.83,75.47 99.52,75.52 98.17,75.76 96.85,75.76
  BOTTOM w0.135: U1.E12 v4(94.36,75.13)
PE_SLOT2_RX_DP<13>: length 143.3
  IN3 w0.089: 96.92,74.76 96.9,74.76 96.85,74.71 95.06,74.71 94.77,74.42 94.77,74.26 94.64,74.13 v4(94.36,74.13)
  IN3 w0.135: 96.92,74.76 98.12,74.76 99.52,74.52 99.77,74.47 100.92,73.67 102.3,71.69 102.67,71.43 103.03,71.28 103.42,71.21 104.97,71.49 106.08,71.29 107.49,71.54 109.22,71.23 111.2,71.58 112,71.44 112.7,71.32 113.95,71.54 115.55,71.26 116.91,71.5 118.91,71.15 119.85,71.31 120.2,71.07 120.29,70.56 120.45,70.45 120.82,70.51 120.93,70.67 120.84,71.18 121.08,71.53 122.96,71.86 125.63,71.39 126.9,71.62 127.25,71.37 127.3,71.05 127.46,70.94 127.7,70.98 127.81,71.13 127.76,71.43 128.03,71.83 129.46,72.08 137.52,70.66 152.18,73.24 208.7,63.28 210.2,63.54 212.46,63.15 214.23,63.46 219.34,62.56 220.48,62.36 221.29,61.79 221.97,60.82 221.97,59.35 arc(222.01,59.25) 222.1,59.22 222.52,59.22 arc(222.82,59.09) 222.95,58.79 222.95,54.85 222.68,54.59 222.51,54.51 222.51,54.51 222.45,54.33 J2.A72
  BOTTOM w0.135: U1.E11 v4(94.36,74.13)
PE_SLOT2_RX_DP<14>: length 137
  IN3 w0.089: v4(94.36,73.13) 94.64,73.13 94.77,73.26 94.77,73.42 95.07,73.72 96.8,73.72 96.85,73.77 96.87,73.77
  IN3 w0.135: J2.A76 218.45,54.33 218.51,54.51 218.51,54.51 218.68,54.59 218.98,54.89 218.98,58.79 arc(218.86,59.09) 218.56,59.22 218.1,59.22 arc(218.01,59.25) 217.97,59.35 217.97,60.7 217.62,61.2 217.19,61.5 209.84,62.79 208.46,62.55 152.61,72.4 135.95,69.46 129.95,70.53 125.79,69.8 123.49,70.2 118.34,69.29 116.61,69.61 114.5,69.24 111.88,69.71 109.34,69.26 106.82,69.7 104.2,69.24 103.23,69.24 102.42,69.81 100.35,72.77 99.52,73.35 99.32,73.49 97.72,73.77 96.87,73.77
  BOTTOM w0.135: U1.E10 v4(94.36,73.13)
PE_SLOT2_RX_DP<15>: length 135
  IN3 w0.089: 96.87,72.77 96.85,72.77 96.8,72.72 95.06,72.72 94.77,72.42 94.77,72.25 94.65,72.13 v4(94.36,72.13)
  IN3 w0.135: J2.A80 214.45,54.33 214.51,54.51 214.51,54.51 214.68,54.59 214.99,54.9 214.99,58.73 arc(214.87,59.03) 214.57,59.16 214.06,59.16 arc(213.97,59.2) 213.93,59.29 213.93,60.7 213.65,61.1 213.11,61.47 209.89,62.04 208.65,61.82 153.34,71.57 130.02,67.46 125.48,68.26 123.54,67.92 123.28,67.54 123.38,67.02 123.28,66.88 122.91,66.82 122.74,66.94 122.65,67.43 122.3,67.67 121.66,67.56 119.55,67.93 116.09,67.32 113.32,67.81 111.37,67.47 109.67,67.77 107.94,67.46 106.06,67.79 104.63,67.54 102.88,67.54 102.24,67.99 101.92,68.44 101.77,69.29 100,71.83 98.98,72.54 97.71,72.77 96.87,72.77
  BOTTOM w0.135: U1.E9 v4(94.36,72.13)
PE_SLOT2_TX_C_DN<0>: length 190.8
  IN1 w0.089: 99.47,88.49 99.45,88.49 99.41,88.55 99.01,88.62 98.65,88.56 98.17,88.56 97.98,88.37 97.98,88.2 98.05,88.13 v4(98.36,88.13)
  IN1 w0.122: 99.47,88.49 99.9,88.41 100.98,88.22 102.57,88.5 104.8,88.11 107.9,88.65 111.23,88.07 114.29,88.61 117.75,88 119.89,88.38 120.95,88.19 122.01,88 126.89,84.58 146.59,81.11 152.94,82.23 218.72,70.63 221.06,71.05 223.3,71.44 225.12,71.12 227.29,71.5 229.34,71.14 230.79,71.39 232.82,71.04 235.1,71.44 237.5,71.01 240.68,71.58 243.02,71.16 245.65,71.63 247.19,71.36 249.28,71.73 251.12,71.4 252.76,71.69 255.74,71.16 258.74,71.8 271.73,69.52 271.85,69.34 272.21,69.27 272.39,69.4 272.75,69.34 272.87,69.16 273.24,69.09 273.41,69.22 273.77,69.16 273.9,68.98 274.26,68.91 274.43,69.04 274.79,68.97 274.92,68.8 275.28,68.73 275.46,68.86 275.82,68.79 275.94,68.62 276.3,68.55 276.48,68.68 276.84,68.61 276.96,68.44 277.32,68.37 277.5,68.5 277.92,68.42 279.44,67.36 279.66,67.05 279.69,66.88 279.69,66.66 v1(279.33,66.29)
  BOTTOM w0.135: v1(279.33,66.29) 279.68,65.94 279.68,65.14 C31.1 ; U1.A24 v4(98.36,88.13)
PE_SLOT2_TX_C_DN<1>: length 189
  IN1 w0.089: v4(98.36,87.13) 98.05,87.13 98,87.18 98,87.38 98.15,87.54 98.62,87.54 98.86,87.37 99.41,87.27 99.45,87.22 99.47,87.21
  IN1 w0.122: 99.47,87.21 99.52,87.2 108.63,85.6 112.92,86.35 115.83,85.84 116.17,86.08 116.27,86.68 116.41,86.78 116.79,86.71 116.89,86.57 116.79,85.97 117.03,85.63 117.64,85.52 117.98,85.76 118.09,86.36 118.23,86.46 118.61,86.39 118.71,86.25 118.6,85.65 118.84,85.31 146.59,80.42 152.94,81.54 218.72,69.94 220.99,70.34 223.17,70.72 224.95,70.41 227.04,70.78 229.07,70.42 230.74,70.71 232.77,70.35 235.05,70.76 237.44,70.33 240.73,70.91 243.02,70.51 245.58,70.96 247.18,70.68 249.21,71.04 251.22,70.68 252.99,70.99 255.79,70.5 258.55,70.99 258.62,71 266.92,69.54 267.04,69.36 267.4,69.3 267.58,69.42 267.94,69.36 268.07,69.18 268.43,69.12 268.6,69.24 268.96,69.18 269.09,69 269.45,68.94 269.63,69.06 269.99,69 270.11,68.82 270.47,68.76 270.65,68.88 271.01,68.82 271.13,68.64 271.49,68.58 271.67,68.7 272.03,68.64 272.15,68.46 272.51,68.4 272.69,68.52 273.05,68.46 273.18,68.28 273.54,68.22 273.71,68.34 273.72,68.34 274.18,68.26 275.04,67.8 275.57,67.18 275.65,66.75 275.65,66.66 v1(275.29,66.29)
  BOTTOM w0.135: C32.1 275.64,65.14 275.64,65.94 v1(275.29,66.29) ; U1.A23 v4(98.36,87.13)
PE_SLOT2_TX_C_DN<2>: length 181.9
  IN1 w0.089: v4(98.36,86.13) 98.07,86.13 97.98,86.22 97.98,86.37 98.15,86.54 98.59,86.54 98.77,86.67 99.3,86.57 99.34,86.52 99.37,86.51
  IN1 w0.122: v1(271.35,66.29) 271.71,66.66 271.71,66.83 271.6,67.44 271.43,67.68 271.02,67.98 270.42,68.08 270.24,67.96 269.88,68.02 269.76,68.2 269.4,68.26 269.22,68.14 268.86,68.2 268.74,68.38 268.38,68.44 268.2,68.32 267.84,68.38 267.72,68.56 267.36,68.62 267.18,68.5 266.82,68.56 266.69,68.74 266.33,68.8 266.16,68.68 265.8,68.74 265.67,68.92 265.31,68.98 265.13,68.86 264.77,68.92 264.65,69.1 264.29,69.16 264.11,69.04 263.75,69.1 263.63,69.28 258.15,70.24 255.83,69.84 253.11,70.31 251.31,70 249.18,70.37 247.19,70.02 245.57,70.31 243.02,69.86 240.78,70.25 237.46,69.67 235.08,70.09 232.8,69.69 230.81,70.04 229.18,69.75 227.13,70.11 224.99,69.73 223.12,70.06 218.68,69.28 153.17,80.83 146.82,79.71 112.99,85.67 108.56,84.89 99.52,86.49 99.37,86.51
  BOTTOM w0.135: U1.A22 v4(98.36,86.13) ; C33.1 271.71,65.14 271.71,65.94 v1(271.35,66.29)
PE_SLOT2_TX_C_DN<3>: length 180.9
  IN1 w0.089: 99.52,85.59 99.5,85.59 99.44,85.63 98.99,85.55 98.17,85.55 97.98,85.37 97.98,85.2 98.05,85.13 v4(98.36,85.13)
  IN1 w0.122: v1(267.31,66.29) 267.67,66.66 267.67,66.83 267.63,67.09 266.81,67.9 266.05,68.04 265.91,67.94 265.66,66.48 265.32,66.24 264.7,66.35 264.46,66.69 264.72,68.14 264.62,68.28 263.97,68.4 263.79,68.27 263.43,68.34 263.3,68.51 262.94,68.57 262.77,68.45 262.41,68.51 262.28,68.69 261.92,68.75 261.74,68.63 261.38,68.69 261.26,68.87 260.9,68.93 260.72,68.8 260.36,68.87 260.24,69.04 259.88,69.11 259.7,68.98 259.34,69.04 259.21,69.22 258.85,69.28 258.68,69.16 258.32,69.22 258.19,69.4 257.83,69.46 256.04,69.14 253.11,69.66 251.22,69.33 249.13,69.7 247.17,69.35 245.5,69.64 243.02,69.21 240.86,69.59 237.54,69 235.22,69.41 232.91,69 230.78,69.38 229.02,69.07 227.03,69.42 225.05,69.07 223.19,69.4 220.89,68.99 220.89,68.99 218.48,68.57 152.93,80.13 146.58,79.01 112.82,84.96 108.37,84.18 101.39,85.41 101.21,85.28 100.85,85.35 100.73,85.52 99.92,85.66 99.57,85.6 99.57,85.6 99.52,85.59
  BOTTOM w0.135: v1(267.31,66.29) 267.67,65.94 267.67,65.14 C34.1 ; U1.A21 v4(98.36,85.13)
PE_SLOT2_TX_C_DN<4>: length 171.4
  IN1 w0.089: v4(98.36,84.13) 98.05,84.13 97.98,84.2 97.98,84.37 98.15,84.53 99.02,84.53 99.44,84.6 99.5,84.56 99.52,84.57
  IN1 w0.122: 99.52,84.57 100.32,84.71 107.72,83.4 112.74,84.29 146.58,78.32 152.93,79.44 218.45,67.89 220.9,68.32 223.24,68.73 225.14,68.4 227.11,68.74 229.12,68.39 230.87,68.7 232.94,68.33 235.23,68.73 237.55,68.33 240.8,68.9 242.96,68.52 245.57,68.98 247.19,68.69 249.08,69.03 251.17,68.66 253,68.98 253.48,68.9 253.61,68.72 253.97,68.66 254.15,68.78 254.51,68.72 254.63,68.54 254.99,68.48 255.17,68.6 255.53,68.54 255.65,68.36 256.01,68.3 256.19,68.42 256.55,68.36 256.68,68.18 257.04,68.12 257.21,68.24 257.57,68.18 257.7,68 258.06,67.94 258.23,68.06 258.59,68 258.72,67.82 259.08,67.76 259.26,67.88 259.62,67.82 259.74,67.64 260.1,67.58 260.28,67.7 261.17,67.54 261.51,67.3 261.66,67.09 261.66,66.64 v1(261.32,66.29)
  BOTTOM w0.135: v1(261.32,66.29) 261.67,65.94 261.67,65.14 C67.1 ; U1.A20 v4(98.36,84.13)
PE_SLOT2_TX_C_DN<5>: length 169.3
  IN1 w0.089: 99.52,83.57 99.5,83.57 99.44,83.61 99.01,83.53 98.04,83.53 97.97,83.46 97.97,83.21 98.05,83.13 v4(98.36,83.13)
  IN1 w0.122: 99.52,83.57 100.84,83.8 101.2,83.74 101.32,83.56 101.68,83.5 101.86,83.62 102.22,83.56 102.35,83.38 102.71,83.32 102.88,83.44 103.24,83.38 103.37,83.2 103.73,83.14 103.91,83.26 104.27,83.2 104.39,83.02 104.75,82.96 104.93,83.08 105.29,83.02 105.41,82.84 105.77,82.78 105.95,82.9 106.31,82.84 106.43,82.66 106.8,82.6 106.97,82.72 107.43,82.64 112.9,83.6 146.73,77.64 153.08,78.76 218.45,67.23 220.89,67.66 223.24,68.08 225.14,67.74 227.11,68.09 229.18,67.72 230.94,68.03 232.95,67.68 235.23,68.08 237.55,67.67 240.8,68.25 242.96,67.87 245.52,68.32 247.22,68.02 249.07,68.34 251.23,67.96 252.72,68.22 253.75,68.04 253.88,67.86 254.24,67.8 254.41,67.93 254.77,67.86 254.96,67.59 254.82,66.81 255.06,66.47 255.56,66.39 255.56,66.38 255.68,66.36 256.02,66.6 256.16,67.45 256.31,67.55 257.23,67.38 257.59,67.13 257.64,66.86 257.64,66.66 v1(257.28,66.29)
  BOTTOM w0.135: v1(257.28,66.29) 257.63,65.94 257.63,65.14 C68.1 ; U1.A19 v4(98.36,83.13)
PE_SLOT2_TX_C_DN<6>: length 163.3
  IN1 w0.089: 99.52,82.58 99.5,82.58 99.44,82.62 99.23,82.58 98.98,82.54 98.11,82.54 97.98,82.41 97.98,82.2 98.05,82.13 v4(98.36,82.13)
  IN1 w0.122: 99.52,82.58 100.79,82.81 101.38,82.7 101.5,82.52 101.86,82.46 102.04,82.59 102.4,82.52 102.53,82.34 102.89,82.28 103.06,82.4 103.42,82.34 103.55,82.16 103.91,82.1 104.09,82.22 104.45,82.16 104.57,81.98 104.93,81.92 105.11,82.04 105.47,81.98 105.59,81.8 105.95,81.74 106.13,81.86 106.56,81.79 112.98,82.92 146.68,76.98 153.03,78.1 218.4,66.57 220.87,67.01 223.24,67.43 225.14,67.09 227.11,67.44 229.36,67.04 231.11,67.35 232.95,67.03 235.16,67.42 237.48,67.01 240.79,67.59 242.94,67.21 245.52,67.66 247.23,67.36 249.07,67.69 250.47,67.44 250.59,67.26 250.95,67.2 251.13,67.32 251.49,67.26 251.85,67.32 252.03,67.2 252.39,67.26 252.51,67.44 252.9,67.51 253.38,67.42 253.62,67.26 253.68,66.95 253.68,66.66 v1(253.32,66.29)
  BOTTOM w0.135: C69.1 253.67,65.14 253.67,65.94 v1(253.32,66.29) ; U1.A18 v4(98.36,82.13)
PE_SLOT2_TX_C_DN<7>: length 161.7
  IN1 w0.089: v4(98.36,80.13) 98.05,80.13 97.98,80.2 97.98,80.63 98.12,80.77 98.71,80.77 99.16,80.69 99.44,80.74 99.5,80.7 99.52,80.7
  IN1 w0.122: v1(249.28,66.29) 249.64,66.66 249.64,66.81 249.59,66.86 249.34,66.97 248.99,66.97 247.22,66.65 246.47,66.79 246.29,66.66 245.93,66.73 245.8,66.9 245.36,66.98 244.88,66.9 244.76,66.72 244.39,66.66 244.22,66.78 242.9,66.55 242.54,66.61 242.36,66.49 242,66.55 241.88,66.73 240.74,66.93 237.44,66.35 235.26,66.73 233.08,66.35 231.14,66.69 229.36,66.38 227.08,66.78 225.03,66.42 223.14,66.75 220.81,66.34 218.39,65.92 153.02,77.44 146.67,76.32 113.14,82.24 112.23,82.08 112.14,81.93 112.22,81.45 111.98,81.11 111.36,81 111.02,81.24 110.94,81.72 110.8,81.82 110.42,81.76 110.32,81.61 110.4,81.13 110.17,80.79 109.55,80.68 109.21,80.92 109.12,81.4 108.98,81.5 106.1,80.99 104.66,81.25 104.48,81.12 104.12,81.19 104,81.37 103.64,81.43 103.28,81.37 103.15,81.19 102.79,81.12 102.62,81.25 102.26,81.19 102.13,81.01 101.77,80.94 101.59,81.07 101.23,81.01 101.11,80.83 100.75,80.76 100.57,80.89 99.57,80.71 99.57,80.71 99.52,80.7
  BOTTOM w0.135: U1.A17 v4(98.36,80.13) ; v1(249.28,66.29) 249.63,65.94 249.63,65.14 C70.1
PE_SLOT2_TX_C_DN<8>: length 156.7
  BOTTOM w0.089: U1.A16 97.55,79.63 97.46,79.54 97.46,79.42 97.65,79.22 98.5,79.22 98.97,79.69 98.97,79.77 98.98,79.79
  BOTTOM w0.135: C71.1 245.92,65.14 245.92,65.77 244.58,67.68 240.66,70.43 229.54,72.39 212.75,72.39 205.1,73.74 197.47,79.08 v3(184.46,81.38) 182.05,81.8 179.7,81.33 176.53,81.97 173.35,81.33 170.18,81.97 166.61,81.25 163.43,81.89 161.07,81.42 157.93,82.05 157.36,81.93 157.36,81.93 156.91,81.84 153.84,82.46 125.31,83.51 117.11,83.2 113.56,82.57 111.44,82.95 109.9,82.68 107.72,83.06 105.78,82.72 103.61,83.1 102.16,82.85 101.77,82.57 101.66,82.46 98.98,79.79
PE_SLOT2_TX_C_DN<9>: length 154.2
  BOTTOM w0.089: 98.58,78.29 98.55,78.29 98.5,78.23 97.64,78.23 97.49,78.39 97.49,78.54 97.58,78.63 U1.A15
  BOTTOM w0.135: 98.58,78.29 98.99,78.29 99.47,78.37 100.2,78.89 101.38,80.07 102.5,80.85 103.13,80.96 104.14,81.14 106.12,80.79 107.85,81.1 110.17,80.69 112.25,81.05 114.11,80.73 121.47,81.98 121.5,81.98 122.24,82.02 125.59,81.96 125.89,81.96 131.52,82.01 153.01,81.29 156.96,80.59 157.83,80.74 160.94,80.12 163.54,80.64 166.72,80.01 170.18,80.7 173.35,80.06 176.53,80.7 179.73,80.06 182.13,80.52 v3(188.45,79.4) 196.64,77.96 204.41,72.52 211.95,71.19 228.82,71.19 236.64,69.81 239.4,67.88 239.59,67.91 240.23,68.83 240.67,68.91 241.39,68.4 241.47,67.96 240.82,67.05 240.86,66.86 241.59,66.34 241.94,65.85 241.94,65.14 C72.1
PE_SLOT2_TX_C_DN<10>: length 147.2
  BOTTOM w0.089: 98.5,77.27 98.48,77.27 98.42,77.22 97.66,77.22 97.49,77.39 97.49,77.52 97.6,77.63 U1.A14
  BOTTOM w0.135: 98.5,77.27 99.62,77.27 100.28,77.39 101.25,78.07 102.35,78.84 104.6,79.24 107.64,78.7 111.01,79.29 114.05,78.76 116.44,79.18 117.19,79.05 118.14,79.1 118.78,79.41 120.21,80.51 122.25,80.75 124.89,80.66 129.81,80.66 141.53,80.23 152.3,80.11 156.92,79.18 157.81,79.36 160.65,78.79 163.65,79.39 166.83,78.76 170.18,79.43 173.35,78.79 176.53,79.43 179.7,78.79 182.06,79.27 v3(183.29,79.05) 196.15,76.78 203.84,71.4 211.84,69.99 228.05,69.99 233.78,68.98 237.49,66.38 237.97,65.69 237.97,65.14 C73.1
PE_SLOT2_TX_C_DN<11>: length 144.9
  BOTTOM w0.089: 98.7,76.28 98.68,76.28 98.62,76.23 97.65,76.23 97.49,76.39 97.49,76.53 97.59,76.63 U1.A13
  BOTTOM w0.135: C74.1 234.01,65.14 234.01,65.66 233.5,66.38 232.66,66.97 232.23,66.89 231.72,66.17 231.54,66.14 231.02,66.5 230.99,66.69 231.49,67.41 231.42,67.85 230.79,68.28 227.95,68.79 v3(213.17,68.79) 211.26,68.79 203.16,70.21 195.31,75.71 182.26,78.01 179.7,77.5 176.53,78.13 173.35,77.5 170.18,78.13 167,77.5 163.83,78.13 160.65,77.5 157.77,78.08 156.41,77.8 152.44,78.6 148.04,78.69 127.66,79.39 127.36,79.33 124.34,78.8 121.89,78.85 120.58,78.6 118.07,77.07 117.87,77.06 116.73,76.85 113.97,77.34 110.87,76.79 109.2,77.09 107.68,76.82 104.49,77.38 102.1,76.96 101.5,76.54 101.25,76.5 100.02,76.28 98.7,76.28
PE_SLOT2_TX_C_DN<12>: length 138.3
  BOTTOM w0.089: U1.A12 97.58,75.63 97.5,75.55 97.5,75.38 97.64,75.23 98.93,75.23 98.99,75.29 99.01,75.29
  BOTTOM w0.135: 99.01,75.29 101.76,75.29 104.39,74.83 106.86,75.26 108.5,74.97 111.1,75.43 114.16,74.89 117.23,75.43 118.1,75.28 120.66,76.84 124.6,77.18 126.27,77.47 128.3,78.02 147.75,77.41 150.59,77.39 152.29,77.2 156.22,76.46 157.01,76.62 157.91,76.8 160.65,76.25 163.83,76.89 167,76.25 170.18,76.89 173.35,76.25 176.53,76.89 179.7,76.25 182.33,76.78 194.84,74.57 202.69,69.08 211.15,67.58 v3(217.12,67.58) 227.57,67.58 228.61,66.86 229.44,66.27 229.48,66.24 229.71,65.91 229.97,65.54 229.97,65.14 C75.1
PE_SLOT2_TX_C_DN<13>: length 136.3
  BOTTOM w0.089: U1.A11 97.59,74.63 97.49,74.52 97.49,74.35 97.61,74.22 99.44,74.22 99.5,74.28 99.52,74.28
  BOTTOM w0.135: 99.52,74.28 99.96,74.28 100.57,74.17 101.25,73.69 101.5,73.51 103.65,73.13 105.24,73.41 107.83,72.96 110.75,73.47 113.75,72.94 116.48,73.42 118.48,73.07 118.95,73.15 121.51,74.87 122.08,75.44 128.04,76.49 129.01,76.66 149.28,76 151.93,75.98 156.11,75.15 157.97,75.52 160.65,74.98 163.83,75.62 167,74.98 170.18,75.62 173.35,74.98 176.53,75.62 179.7,74.98 182.46,75.54 194.37,73.44 202.22,67.94 211.05,66.38 v3(213.83,66.38) 222.92,66.38 223.24,66.07 223.24,65.34 223.37,65.2 224,65.2 224.13,65.34 224.13,66.07 224.45,66.38 224.99,66.38 225.75,65.85 226.04,65.44 226.04,65.14 C76.1
PE_SLOT2_TX_C_DN<14>: length 128.5
  BOTTOM w0.089: 99.52,72.97 99.5,72.97 99.44,72.92 98.79,72.92 98.42,73.18 98.13,73.23 97.6,73.23 97.51,73.32 97.51,73.53 97.61,73.63 U1.A10
  BOTTOM w0.135: C77.1 219.67,64.67 219.06,64.67 218.57,65.01 217.59,65.18 v3(212.02,65.18) 209.59,65.18 208.02,65.46 207.9,65.64 207.5,65.71 207.32,65.58 206.92,65.65 206.8,65.83 206.4,65.9 206.22,65.78 205.83,65.85 205.7,66.02 205.3,66.09 205.13,65.97 202.11,66.5 193.8,72.32 182.59,74.29 179.7,73.72 176.53,74.35 173.35,73.71 170.18,74.35 167,73.71 163.84,74.35 160.67,73.71 159.34,73.98 157.89,74.27 154.96,73.68 147.11,74.83 140.41,74.83 130.04,75.29 129.86,75.3 127.68,75.1 127.62,75.08 124.61,74.13 121.02,71.62 120.09,71.45 120.09,71.45 119.78,71.4 119.78,71.4 118.54,71.18 116.51,71.54 114.27,71.14 112.85,71.39 111.11,71.08 108.87,71.48 107.31,71.2 105.42,71.54 103.41,71.18 101.74,71.48 101.47,71.67 100.79,72.34 100.16,72.97 99.52,72.97
