# Allegro board 4-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
STRAP_NT0_UPSTRM_PORTSEL_0: length 35.4
  TOP w0.127: v1(106.54,68.38) 106.59,68.33 R133.1 108.01,67.56 109.93,67.56 110.29,67.93 R132.2
  IN2 w0.112: v4(86.36,70.13) 86.86,69.63 86.86,63.61 87.63,62.84 98.15,62.84 99.07,63.77 99.07,64.81 103.15,68.88 106.03,68.88 v1(106.54,68.38)
  BOTTOM w0.127: U1.N7 v4(86.36,70.13)
STRAP_NT0_UPSTRM_PORTSEL_1: length 17.7
  BOTTOM w0.114: R130.2 R131.1
  BOTTOM w0.127: R131.1 108.85,65.2 105.51,65.2 104.6,66.12 v2(104.6,67.44) 104.56,67.4 101.35,67.4 99.13,65.18 96.37,65.18 95.92,65.63 U1.C2
STRAP_NT0_UPSTRM_PORTSEL_2: length 29.7
  TOP w0.114: v1(53.97,53.24) 53.97,53.15 54.43,52.68 54.43,51.59 v5(54.8,51.22) 55.02,51 R128.2 R129.1
  IN2 w0.112: v4(65.36,68.13) 64.64,68.86 60.71,68.86 54.76,62.91 54.76,55.26 54.27,54.77 53.78,54.77 53.5,54.49 53.5,53.71 v1(53.97,53.24)
  BOTTOM w0.127: U1.AN5 v4(65.36,68.13)
STRAP_NT1_UPSTRM_PORTSEL_0: length 32.5
  TOP w0.089: v4(89.36,79.13) 89.96,79.73 96.98,79.73 97.06,79.65
  TOP w0.127: R330.2 119.31,79.25 117.03,79.25 R331.1 v1(115.65,79.76) 114.89,80.52 101.12,80.52 100.26,79.65 97.06,79.65
  BOTTOM w0.127: U1.K16 v4(89.36,79.13)
STRAP_NT1_UPSTRM_PORTSEL_1: length 21.5
  TOP w0.089: v4(90.36,76.13) 90.96,75.53 97.04,75.53 97.09,75.48
  TOP w0.127: 97.09,75.48 105.91,75.48 v1(106.38,75.95) R329.1 107.73,75.46 109.81,75.46 R328.2
  BOTTOM w0.127: U1.J13 v4(90.36,76.13)
STRAP_NT1_UPSTRM_PORTSEL_2: length 16.5
  TOP w0.089: 96.95,77.98 96.7,77.73 92.77,77.73 v4(92.36,78.13)
  TOP w0.127: 96.95,77.98 101.55,77.98 101.68,77.85 v1(102.82,77.85) R327.1 104.07,77.5 104.19,77.38 106.78,77.38 R326.2
  BOTTOM w0.127: U1.G15 v4(92.36,78.13)
STRAP_REFCLK_SSC_EN0: length 35.4
  TOP w0.114: R205.2 55.32,55.36 54.62,56.06 53.74,56.06 v1(53.25,55.57)
  IN2 w0.112: v4(70.36,76.13) 69.93,75.69 63.73,75.69 52.39,64.35 52.39,57.03 53.25,56.16 v1(53.25,55.57)
  BOTTOM w0.127: U1.AH13 v4(70.36,76.13)
STRAP_REFCLK_SSC_EN1: length 36.4
  TOP w0.114: R206.2 103.46,67.56 102.72,66.83 v1(102.72,66.45)
  IN2 w0.112: v1(102.72,66.45) 102.72,65.51 97.92,60.71 84.71,60.71 79.91,65.51 79.91,70.74 79.52,71.13 v4(79.36,71.13)
  BOTTOM w0.127: U1.W8 v4(79.36,71.13)
STRAP_REFCLK_SSC_EN2: length 44
  IN2 w0.089: v4(71.36,83.13) 70.8,83.69 64.34,83.69 64.04,83.39 63.71,83.39
  IN2 w0.112: v1(47.04,57.84) 47.1,57.9 47.1,58.05 45.83,59.32 45.83,66.15 63.07,83.39 63.71,83.39
  BOTTOM w0.114: R207.2 47.12,56.96 47.12,57.75 v1(47.04,57.84)
  BOTTOM w0.127: U1.AG19 v4(71.36,83.13)
STRAP_REFCLK_SSC_EN3: length 45.3
  TOP w0.114: R208.2 47.56,53.44 v6(47.55,53.44)
  IN2 w0.089: 63.81,82.73 69.96,82.73 v4(70.36,83.13)
  IN2 w0.112: v6(47.55,53.44) 47.61,53.5 47.61,54.12 48.07,54.58 48.07,68.02 62.78,82.73 63.81,82.73
  BOTTOM w0.127: U1.AH19 v4(70.36,83.13)
STRAP_REFCLK_SSC_EN4: length 21.8
  TOP w0.127: R217.2 v1(106.38,74.04)
  IN2 w0.112: v4(87.36,72.13) 87.89,71.6 97.72,71.6 99.29,73.17 105.51,73.17 v1(106.38,74.04)
  BOTTOM w0.127: U1.M9 v4(87.36,72.13)
STRAP_REFCLK_SSC_EN5: length 16.2
  TOP w0.089: 96.98,78.99 96.71,78.73 92.77,78.73 v4(92.36,79.13)
  TOP w0.127: R218.2 v1(106.5,79.76) 105.74,78.99 96.98,78.99
  BOTTOM w0.127: U1.G16 v4(92.36,79.13)
STRAP_REFCLK_SSC_EN6: length 44.2
  TOP w0.127: R219.2 v1(115.65,68.33)
  IN2 w0.112: v4(85.36,71.13) 84.86,70.63 84.86,63.55 86.55,61.86 98.09,61.86 99.76,63.54 99.76,64.53 102.57,67.34 114.66,67.34 v1(115.65,68.33)
  BOTTOM w0.127: U1.P8 v4(85.36,71.13)
STRAP_REFCLK_SSC_EN7: length 11.6
  BOTTOM w0.127: R220.2 105.49,64.03 104.88,64.03 v2(104.83,63.98) 104.78,64.03 104.27,64.03 103.79,63.55 100.28,63.55 99.98,63.25 96.69,63.25 95.86,64.08 U1.C1
STRAP_REFCLK_SSC_EN8: length 33.1
  TOP w0.127: v4(73.36,90.13) 73.82,90.59 73.82,92.42 74.88,93.47 74.88,100.45 69.7,105.64 69.7,105.64 69.66,105.68 69.66,106.97 63.86,112.78 v6(61.88,112.78)
  BOTTOM w0.114: R229.2 v6(61.88,112.78)
  BOTTOM w0.127: U1.AE26 v4(73.36,90.13)
STRAP_REFCLK_SSC_EN9: length 45.9
  TOP w0.114: R230.2 v5(46.82,56.64) 46.82,57.09 v1(46.43,57.48)
  IN2 w0.089: v4(71.36,84.13) 71.36,84.31 71.14,84.54 63.82,84.54 63.37,84.09 63.2,84.09
  IN2 w0.112: 63.2,84.09 45.57,66.46 45.57,58.57 46.41,57.73 46.41,57.51 v1(46.43,57.48)
  BOTTOM w0.127: U1.AG20 v4(71.36,84.13)
STRAP_REFCLK_SSC_EN10: length 10.5
  BOTTOM w0.127: U1.AP32 63.43,97.07 63.43,100.56 64.59,101.73 v2(64.59,102.87) R231.2
STRAP_REFCLK_SSC_EN11: length 16.7
  TOP w0.089: 68.18,99.42 67.54,98.78 67.54,97.31 v4(67.36,97.13)
  TOP w0.114: 68.18,99.42 68.18,101.89 63.38,106.68 61.98,106.68
  TOP w0.127: 61.98,106.68 v6(61.77,106.68)
  BOTTOM w0.114: R232.2 v6(61.77,106.68)
  BOTTOM w0.127: U1.AL33 v4(67.36,97.13)
STRAP_REFCLK_SSC_EN12: length 29.8
  TOP w0.127: R241.2 v1(115.9,87.5) 115.9,86.11 114.25,84.45 100.79,84.45 100.03,83.69 93.02,83.69 92.29,84.42 90.65,84.42 v4(90.36,84.13)
  BOTTOM w0.127: U1.J20 v4(90.36,84.13)
STRAP_REFCLK_SSC_EN13: length 21.4
  TOP w0.127: R242.2 v1(109.55,87.5) 108.92,86.87 100.15,86.87 99.4,87.62 90.87,87.62 v4(90.36,88.13)
  BOTTOM w0.127: U1.J24 v4(90.36,88.13)
STRAP_REFCLK_SSC_EN14: length 29.6
  TOP w0.127: R243.2 v1(115.9,91.31) 115.1,90.51 115.1,86.96 113.73,85.59 93.03,85.59 92.57,85.13 v4(92.36,85.13)
  BOTTOM w0.127: U1.G21 v4(92.36,85.13)
STRAP_REFCLK_SSC_EN15: length 29.5
  TOP w0.127: v4(91.36,85.13) 91.84,84.66 99.6,84.66 100.15,85.22 114,85.22 115.43,86.65 115.43,88.94 v1(115.9,89.41) R244.2
  BOTTOM w0.127: U1.H21 v4(91.36,85.13)
STRAP_REFCLK_SSC_EN16: length 33.6
  TOP w0.114: v6(61.88,114.81) 63.19,114.81 63.4,114.6
  TOP w0.127: 63.4,114.6 70.66,107.34 70.66,105.99 77.79,98.87 77.79,92.71 v4(78.36,92.13)
  BOTTOM w0.114: R253.2 v6(61.88,114.81)
  BOTTOM w0.127: U1.Y28 v4(78.36,92.13)
STRAP_REFCLK_SSC_EN17: length 9.7
  BOTTOM w0.127: R254.2 v2(66.5,102.87) 64.06,100.43 64.06,97.43 U1.AP33
STRAP_REFCLK_SSC_EN18: length 42.1
  TOP w0.127: v4(80.36,91.13) 80.81,91.57 80.81,98.15 85.9,103.25 103.33,103.25 v1(109.55,97.03) R255.2
  BOTTOM w0.127: U1.V27 v4(80.36,91.13)
STRAP_REFCLK_SSC_EN19: length 44.3
  TOP w0.127: R256.2 v1(112.47,95.12) 111.52,96.08 109.22,96.08 102.55,102.74 85.89,102.74 81.1,97.96 81.1,93.39 v4(82.36,92.13)
  BOTTOM w0.127: U1.U28 v4(82.36,92.13)
STRAP_REFCLK_SSC_EN20: length 22.8
  TOP w0.127: v4(90.36,91.13) 90.85,91.62 92.58,91.62 92.86,91.9 92.86,92.35 93.09,92.58 97.61,92.58 99.65,90.55 108.41,90.55 v1(109.55,89.41) R265.2
  BOTTOM w0.127: U1.J27 v4(90.36,91.13)
STRAP_REFCLK_SSC_EN21: length 39.7
  TOP w0.127: R266.2 v1(112.47,93.22) 111.3,94.39 102.8,94.39 101.68,95.5 101.68,97.92 98.76,100.84 88.34,100.84 86.79,99.29 86.79,94.56 v4(86.36,94.13)
  BOTTOM w0.127: U1.M28 86.36,92.13 v4(86.36,94.13)
STRAP_REFCLK_SSC_EN22: length 16.6
  TOP w0.127: R267.2 v1(109.55,91.31) 108.61,92.25 102.35,92.25 98.47,96.13 v4(96.36,96.13)
  BOTTOM w0.127: U1.C32 v4(96.36,96.13)
STRAP_REFCLK_SSC_EN23: length 8.2
  BOTTOM w0.127: R268.2 v2(102.82,97.03) 100.23,97.03 98.33,95.12 97.36,95.12 U1.B31
STRAP_RESERVED_17: length 24
  TOP w0.089: v4(91.36,79.13) 91.96,78.54 97.2,78.54 97.22,78.55
  TOP w0.127: 97.22,78.55 108.35,78.55 v1(109.55,79.76) R325.2 110.29,79.52 110.57,79.25 112.83,79.25 R295.2
  BOTTOM w0.127: U1.H16 v4(91.36,79.13)
STRAP_TESTMODE: length 30.4
  TOP w0.089: 96.77,76.54 91.77,76.54 v4(91.36,76.13)
  TOP w0.127: 96.77,76.54 114.34,76.54 v1(115.65,77.85) R292.1 116.52,77.62 116.79,77.34 119.31,77.34 R291.2
  BOTTOM w0.127: U1.H13 v4(91.36,76.13)
STRAP_VS0_UPSTRM_PORTSEL_0: length 42.3
  IN2 w0.089: v4(73.36,76.13) 72.93,76.57 72.93,77.22 72.49,77.65 72.09,77.65 71.75,77.98 71.75,78.29 71.52,78.52 64.2,78.52 63.6,77.93 63.6,77.62
  IN2 w0.112: v1(49.46,55.78) 49.85,56.17 49.85,56.35 51.53,58.03 51.53,60.34 50.74,61.12 50.74,64.76 63.6,77.62
  BOTTOM w0.114: R343.2 49.86,55.37 v1(49.46,55.78)
  BOTTOM w0.127: U1.AE13 v4(73.36,76.13)
STRAP_VS0_UPSTRM_PORTSEL_1: length 17.4
  TOP w0.089: 97.06,72.55 97.04,72.54 91.96,72.54 v4(91.36,73.13)
  TOP w0.127: R344.2 v1(106.38,72.14) 105.91,71.67 101.68,71.67 100.8,72.55 97.06,72.55
  BOTTOM w0.127: U1.H10 v4(91.36,73.13)
STRAP_VS0_UPSTRM_PORTSEL_2: length 36.2
  TOP w0.127: R345.2 v1(122.25,79.76) 122.25,80.77 121.74,81.28 99.5,81.28 99.2,80.98 90.93,80.98 89.78,82.13 v4(89.36,82.13)
  BOTTOM w0.127: U1.K18 v4(89.36,82.13)
STRAP_VS_MODE_0: length 28.2
  TOP w0.114: R178.1 63.97,53.05 v1(64.14,52.88) 63.73,52.46 R177.2
  IN2 w0.089: v4(76.36,71.13) 76.36,70.75 76.79,70.33 76.79,68.96 76.33,68.5 76.33,63.55 75.85,63.07 75.79,63.07 75.78,63.05
  IN2 w0.112: v1(64.14,52.88) 64.69,53.42 64.69,55.49 67.74,58.55 69.01,58.55 70.08,59.61 72.34,59.61 75.78,63.05
  BOTTOM w0.127: U1.AB8 v4(76.36,71.13)
STRAP_VS_MODE_1: length 39.9
  TOP w0.114: v1(50.8,58.88) 51.06,58.62 51.06,57.56 50.62,57.12 R179.2 R180.1
  IN2 w0.112: v4(72.36,79.13) 71.84,79.65 63.91,79.65 50.21,65.96 50.21,59.47 v1(50.8,58.88)
  BOTTOM w0.127: U1.AF16 v4(72.36,79.13)
THER_SEN2_DN: length 384.8
  TOP w0.254: v6(18.77,83.25) C260.2 16.87,83.25 16.42,83.71 Q25.2
  IN2 w0.254: v1(303.86,78.49) 303.68,78.31 302.19,78.31 299.24,75.36 299.24,62.71 300.76,61.18 300.76,51.57 297.36,48.17 297.36,41.6 298.25,40.71 298.25,31.83 296.93,30.51 296.93,23.96 296.08,23.11 285.3,23.11 280.73,27.69 197.89,27.69 184.48,41.1 161.27,41.1 141.93,60.44 129.2,60.44 114.09,45.34 79.85,45.34 79.17,44.65 75.41,44.65 v1(75.27,44.79)
  IN3 w0.254: v6(18.77,83.25) 19.02,83.01 19.79,83.01 20.23,82.57 23.94,82.57 35.59,70.92 45.51,70.92 53.48,62.95 55.25,62.95 57.14,61.06 62.62,61.06 74.35,49.33 74.35,44.99 74.69,44.65 75.13,44.65 v1(75.27,44.79)
  BOTTOM w0.254: v1(303.86,78.49) 304.04,78.31 304.31,78.31 305.07,79.07 U4.3
THER_SEN2_DP: length 386.6
  TOP w0.254: Q25.3 15.7,83.24 16.42,82.51 Q25.1 17.41,82.29 C260.1 v1(18.77,82.45)
  IN2 w0.254: v1(303.86,77.72) 303.66,77.93 302.34,77.93 299.62,75.2 299.62,62.87 301.14,61.34 301.14,51.41 297.74,48.01 297.74,41.76 298.63,40.86 298.63,31.67 297.31,30.35 297.31,23.8 296.24,22.73 285.14,22.73 280.57,27.3 197.74,27.3 184.32,40.72 161.11,40.72 141.77,60.06 129.35,60.06 114.25,44.96 80.01,44.96 79.32,44.27 75.41,44.27 v1(75.27,44.13)
  IN3 w0.254: v1(75.27,44.13) 75.13,44.27 74.53,44.27 73.97,44.83 73.97,49.17 62.46,60.68 56.98,60.68 55.09,62.57 53.32,62.57 45.36,70.54 35.43,70.54 23.78,82.18 20.07,82.18 19.63,82.63 18.94,82.63 v1(18.77,82.45)
  BOTTOM w0.254: U4.2 304.96,78.41 304.47,77.93 304.07,77.93 v1(303.86,77.72)
THER_SEN_DN_1: length 202.5
  TOP w0.254: v1(275.97,72.45) 275.71,72.19 203.48,72.19 188.22,87.45 157.55,87.45 157.08,86.98 157.08,85.63 157.55,85.15 158.02,85.15 158.08,85.09 U10.3 ; v1(317.81,95.54) 317.53,95.82 316.9,95.82 C468.2 316.14,95.06 Q5.2
  IN1 w0.254: v1(317.81,95.54) 318.17,95.9 318.53,95.9 318.79,95.64 318.79,77.26 316.36,74.83 305.82,74.83 298.55,67.56 288.44,67.56 286.29,69.72 279.74,69.72 277.25,72.21 276.21,72.21 v1(275.97,72.45)
THER_SEN_DN_2: length 173.4
  TOP w0.254: U10.5 158.08,84.09 158.02,84.15 156.45,84.15 154.83,85.77 144.8,85.77 143.72,84.69 143.72,84.26 v1(144.02,83.96)
  IN2 w0.254: v1(144.02,83.96) 143.72,83.66 143.72,81.41 116.62,54.31 69.84,54.31 65.51,49.98 v1(65.51,49.71)
  IN3 w0.254: v1(23.8,79.83) 23.77,79.79 23.77,79.43 33.99,69.22 44.43,69.22 52.63,61.02 55.2,61.02 56.56,59.66 61.93,59.66 66.31,55.28 66.31,50.78 65.51,49.98 v1(65.51,49.71)
  BOTTOM w0.254: Q6.2 21.57,80.41 C469.2 22.7,80.14 23.06,80.14 23.38,79.83 v1(23.8,79.83)
THER_SEN_DP_1: length 202.9
  TOP w0.254: v1(275.97,71.56) 275.73,71.8 203.32,71.8 188.06,87.07 157.71,87.07 157.46,86.82 157.46,85.78 157.71,85.53 158.02,85.53 158.08,85.59 U10.2 ; Q5.1 314.45,96.96 Q5.3 315.86,96.01 316.26,96.41 C468.1 316.9,96.2 317.37,96.2 v1(317.81,96.64)
  IN1 w0.254: v1(275.97,71.56) 276.24,71.83 277.09,71.83 279.58,69.34 286.13,69.34 288.29,67.18 298.71,67.18 305.98,74.45 316.52,74.45 319.17,77.1 319.17,95.8 318.69,96.28 318.17,96.28 v1(317.81,96.64)
THER_SEN_DP_2: length 176.1
  TOP w0.254: U10.4 158.08,84.59 158.02,84.53 156.61,84.53 154.99,86.15 144.64,86.15 143.34,84.85 143.34,84.27 v1(143.03,83.96)
  IN2 w0.254: v1(65.04,50.25) 65.24,50.25 69.68,54.69 116.46,54.69 143.34,81.56 143.34,83.66 v1(143.03,83.96)
  IN3 w0.254: v1(23.11,79.13) 23.53,79.13 33.83,68.83 44.28,68.83 52.47,60.64 55.04,60.64 56.4,59.28 61.77,59.28 65.93,55.13 65.93,50.93 65.24,50.25 v1(65.04,50.25)
  BOTTOM w0.254: v1(23.11,79.13) 23.11,79.56 22.92,79.74 22.56,79.74 C469.1 21.12,79.61 Q6.3 20.27,79.81 Q6.1
TP_A19: length 9.6
  TOP w0.114: v1(276.18,12.45) 276.81,11.81 276.81,6.6 275.83,5.62 J5.A19
TP_A32: length 9.6
  TOP w0.114: J5.A32 262.83,6.01 263.16,6.34 263.16,11.7 262.71,12.14 v1(262.71,12.83)
TP_A33: length 8.2
  TOP w0.114: v1(262.59,11.18) 262.89,10.87 262.89,6.93 261.83,5.87 J5.A33
TP_A50: length 9.1
  TOP w0.114: J5.A50 244.83,5.86 245.8,6.83 245.8,9.17 245.44,9.53 245.44,11.56 v1(245.06,11.94)
TP_B12: length 9.1
  BOTTOM w0.114: v2(283.03,12.19) 283.03,10.29 282.4,9.65 282.4,7.37 282.83,6.94 J5.B12
TP_B82: length 9.7
  BOTTOM w0.114: v2(211.48,12.7) 212.83,11.36 J5.B82
TP_JTAG_TCK: length 0.7
  BOTTOM w0.114: U1.AB7 v6(76.36,70.13)
TP_JTAG_TDI: length 15.1
  BOTTOM w0.114: U1.D1 94.86,64.32 96.32,62.87 104.7,62.87 105.41,63.57 107.25,63.57 v2(108.33,64.66)
TP_JTAG_TDO: length 0.7
  BOTTOM w0.114: U1.AF13 v4(72.36,76.13)
TP_JTAG_TMS: length 33.5
  IN2 w0.112: v4(86.36,71.13) 86.36,71.07 86.82,70.61 86.82,70.1 87.2,69.72 87.58,69.72 87.83,69.47 87.83,68.83 88.04,68.63 88.67,68.63 88.85,68.45 88.85,63.63 89.1,63.37 96.6,63.37 102.57,69.34 108.54,69.34 v1(109.55,68.33)
  BOTTOM w0.114: U1.N8 v4(86.36,71.13)
TP_P0V9_FAULT: length 4.3
  TOP w0.254: v5(14.02,115.24) 14.53,114.73 14.53,112.8 14.99,112.34 15.62,112.34 15.77,112.2 PU21.7
TP_P0V9_GH1: length 0.8
  TOP w0.254: PU15.6 31.86,100.47 v1(32.07,100.69)
TP_P0V9_GH2: length 0.8
  TOP w0.254: v1(32.07,89.03) 31.86,88.82 PU13.6
TP_P0V9_GL1: length 1.1
  TOP w0.254: PU15.36 35.46,97.37 v1(35.86,97.76)
TP_P0V9_GL2: length 1.4
  TOP w0.254: PU13.36 35.46,85.68 35.87,86.09 v1(35.87,86.4)
TP_PCIE_X16_SLOT_JTAG_TCK: length 12.2
  TOP w0.114: v1(294.21,14.1) 293.57,14.1 291.52,12.04 291.52,6.25 291.83,5.94 J5.A5
TP_PCIE_X16_SLOT_JTAG_TDI: length 11.3
  TOP w0.114: v1(291.8,14.48) 291.15,13.83 291.15,6.08 290.83,5.76 J5.A6
TP_PCIE_X16_SLOT_JTAG_TDO: length 11.8
  TOP w0.114: v1(289.76,14.48) 290.78,13.46 290.78,6.73 289.83,5.78 J5.A7
TP_PCIE_X16_SLOT_JTAG_TMS: length 10.2
  TOP w0.114: J5.A8 288.83,5.54 289.55,6.26 289.55,9.65 288.81,10.39 288.81,12.51 v1(288.37,12.95)
TP_PE_SLOT_TRST_N: length 9.8
  BOTTOM w0.114: J5.B9 287.83,9.18 286.34,10.67 v2(286.34,12.7)
TP_SHPC_INT_N: length 0.7
  BOTTOM w0.127: U1.AF9 v4(72.36,72.13)
TP_STRAP_SNT0_PORTCFG0: length 0.7
  BOTTOM w0.127: U1.AD8 v4(74.36,71.13)
TP_STRAP_SNT1_PORTCFG0: length 19.7
  IN2 w0.112: v4(91.36,75.13) 91.87,74.62 103.58,74.62 104.23,75.27 108.88,75.27 v1(109.55,75.95)
  BOTTOM w0.127: U1.H12 v4(91.36,75.13)
TP_STRAP_SNT2_PORTCFG0: length 23.5
  IN1 w0.097: v4(73.36,85.13) 73.86,85.63 73.86,96.39 75.39,97.92 75.39,103.5 v1(77.93,106.05)
  BOTTOM w0.127: U1.AE21 v4(73.36,85.13)
TP_STRAP_SNT3_PORTCFG0: length 31
  IN1 w0.112: v4(89.36,87.13) 89.79,87.55 95.63,87.55 95.84,87.76 95.84,88.43 96.05,88.65 96.98,88.65 100.79,92.46 106.76,92.46 108.54,94.23 112.85,94.23 114.38,95.76 v1(114.38,97.03)
  BOTTOM w0.127: U1.K23 v4(89.36,87.13)
TP_STRAP_SNT4_PORTCFG0: length 18.9
  IN1 w0.097: v4(74.36,90.13) 74.88,90.65 74.88,96.77 77.04,98.93 77.04,103.25 v1(79.83,106.05)
  BOTTOM w0.127: U1.AD26 v4(74.36,90.13)
TP_STRAP_SNT5_PORTCFG0: length 30
  IN1 w0.097: 98.68,92.61 90.84,92.61 v4(90.36,92.13)
  IN1 w0.112: v1(116.61,96.57) 115.14,98.04 108.92,98.04 107.34,96.47 102.54,96.47 98.68,92.61
  BOTTOM w0.127: U1.J28 v4(90.36,92.13)
TP_VS0_FATAL_ERR_N: length 0.7
  BOTTOM w0.127: U1.U8 v4(82.36,71.13)
TP_VS0_PEX_INTA_N: length 17.4
  IN2 w0.112: v1(106.38,77.85) 105.16,76.63 90.86,76.63 v4(90.36,77.13)
  BOTTOM w0.127: U1.J14 v4(90.36,77.13)
TP_VS1_FATAL_ERR_N: length 15.8
  BOTTOM w0.127: U1.J17 90.36,81.13 98.76,81.13 102.21,84.58 v2(103.99,84.58)
TP_VS1_PEX_INTA_N: length 6.9
  BOTTOM w0.114: 99.51,64.06 99.08,63.63 97.86,63.63 U1.B1
  BOTTOM w0.127: 99.51,64.06 103.02,64.06 v2(103.1,64.14)
TP_VS2_FATAL_ERR_N: length 24.1
  IN1 w0.097: v1(76.02,106.05) 75.06,105.08 75.06,98.6 72.87,96.42 72.87,84.62 v4(73.36,84.13)
  BOTTOM w0.127: U1.AE20 v4(73.36,84.13)
TP_VS2_PEX_INTA_N: length 20.5
  IN1 w0.097: v1(74.12,106.05) 74.75,105.41 74.75,98.93 72.52,96.7 71.22,96.7 70.84,96.32 70.84,89.65 v4(71.36,89.13)
  BOTTOM w0.127: U1.AG25 v4(71.36,89.13)
TP_VS3_FATAL_ERR_N: length 9.6
  BOTTOM w0.127: v2(106.5,97.03) 105.64,96.16 101.32,96.16 99.79,94.63 U1.A31
TP_VS3_PEX_INTA_N: length 24.9
  IN1 w0.097: 111.46,96.01 v1(112.47,97.03)
  IN1 w0.112: 111.46,96.01 105.49,96.01 103.33,93.85 101.17,93.85 96.95,89.64 93.14,89.64 92.79,89.28 92.79,88.55 v4(92.36,88.13)
  BOTTOM w0.127: U1.G24 v4(92.36,88.13)
TPS7A37_OUT: length 1.4
  TOP w0.254: PC536.1 111.57,39.22 111.82,38.96 v1(111.82,38.71)
  vias: v2(108.09,37.83)
UNNAMED_77_CAP_I208_B: length 5.9
  TOP w0.254: PU21.21 18.77,106.32 18.71,106.26 18.71,103.8 18.87,103.63 19.41,103.63 PC700.2 20.28,103.86 PR800.1
UNNAMED_77_CAP_I211_A: length 3.9
  TOP w0.254: PU21.19 17.77,106.39 17.68,106.3 17.68,105.92 17.08,105.32 17.08,105.09 PC701.1 17.5,104.68 PR801.1
UNNAMED_78_INDUCTORS4P_I32_1B: length 1.9
  TOP w0.254: PL2.1B v1(40.72,96.52)
  BOTTOM w0.254: PR308.1 40.74,96.54 v1(40.72,96.52)
UNNAMED_78_INDUCTORS4P_I32_2B: length 1.8
  TOP w0.254: v1(43.09,96.54) 43.11,96.52 PL2.2B
  BOTTOM w0.254: PR310.1 v1(43.09,96.54)
UNNAMED_78_INDUCTORS4P_I61_1B: length 1.9
  TOP w0.254: PL3.1B v1(40.72,84.84)
  BOTTOM w0.254: v1(40.72,84.84) 40.77,84.79 PR309.1
UNNAMED_78_INDUCTORS4P_I61_2B: length 1.8
  TOP w0.254: v1(43.09,84.79) 44.2,84.79 PL3.2B
  BOTTOM w0.254: PR311.1 v1(43.09,84.79)
VR_P0V9_12VIN: length 21.9
  TOP w0.254: PR400.2 v1(20.14,116.33)
  IN2 w0.254: v1(23.96,98.29) 22.57,98.29 21.79,99.06 21.79,102.16 22.47,102.84 22.47,114 v1(20.14,116.33)
  vias: v1(23.96,86.6) v1(24.72,98.29) v1(24.72,86.6) v1(25.48,98.29) v1(25.48,86.6) v1(26.24,98.29) v1(26.24,86.6) v1(27.01,98.29) v1(27.01,86.6) v1(27.77,98.62) v1(27.77,86.93) v1(28.53,98.29) v1(28.53,86.6) v1(30.4,98.57) v1(30.4,86.88) v1(31.42,98.57) v1(31.42,86.88)
VR_P0V9_BT1: length 1.7
  TOP w0.254: PU15.4 32.86,100.85 32.92,100.91 PC470.2
VR_P0V9_BT2: length 1.7
  TOP w0.254: PC469.2 32.86,89.89 PU13.4
VR_P0V9_PH1: length 1.8
  TOP w0.254: PU15.7 31.36,101.42 PR305.2
VR_P0V9_PH1_R: length 1.3
  TOP w0.508: PR305.1 PC470.1
VR_P0V9_PH2: length 1.8
  TOP w0.254: PR304.2 31.36,89.74 PU13.7
VR_P0V9_PH2_R: length 1.3
  TOP w0.508: PR304.1 PC469.1
VR_P0V9_SW1: length 1.5
  TOP w0.254: 30.59,96.88 30.1,97.37 PU15.15
  vias: v1(36.02,96.27) v1(35.97,95.26) v2(36.55,95.76)
VR_P0V9_SW1_SNB: length 1.5
  BOTTOM w0.508: PR306.2 34.62,94.25 PC471.1
VR_P0V9_SW2: length 0.8
  TOP w0.254: PU13.15 29.86,85.68 30.03,85.51
  vias: v1(35.97,84.66) v1(35.97,83.58) v2(36.53,84.15)
VR_P0V9_SW2_SNB: length 1.5
  BOTTOM w0.381: PC472.1 34.62,82.56 PR307.2
VR_P0V9A_BT: length 4.6
  TOP w0.305: PU23.14 v1(67.3,39.49)
  BOTTOM w0.508: v2(66.37,41.43) 67.3,40.5 v1(67.3,39.49)
  BOTTOM w0.635: v2(66.37,41.43) 66.24,41.56 PC587.1
VR_P0V9A_PVIN: length 21.5
  IN1 w0.305: v4(66.66,46.33) 66.66,46.02 65.42,44.77 64.3,44.77 63.64,44.11 63.64,42.38 66.08,39.94 66.08,37.35 65.3,36.58 59.26,36.58 v1(58.75,37.08)
  BOTTOM w0.305: PR426.1 66.03,47.22 66.66,46.59 v4(66.66,46.33)
  vias: v1(57.9,37.03) v1(61.96,37.3) v1(62.6,37.3) v1(63.23,37.3) v1(63.42,40.39) v1(64.42,39.5) v1(65.05,39.47) v2(64.45,41.21)
VR_P0V9A_SW: length 1.8
  BOTTOM w0.381: v1(65.24,43.04) 65.24,43.57 65.97,44.3 PC587.2
VR_P1V8A_BT: length 3.4
  TOP w0.254: PU19.14 80.98,40.15 v1(81.13,40.29)
  BOTTOM w0.305: v1(81.13,40.29) 81.54,39.88 v2(81.92,39.88) 81.98,39.88 PC546.1
VR_P1V8A_PVIN: length 12.3
  IN1 w0.305: v1(79.47,35.16) 79.45,35.18 79.45,35.85 79.96,36.36 81.84,36.36 82.47,36.99 82.47,37.92 85.52,40.97 v1(85.52,41.44)
  BOTTOM w0.305: v2(77.83,34.29) PR370.1 79.47,34.56 v1(79.47,35.16)
  vias: v1(82.95,40.34) v1(83.72,40.35) v1(86.21,39.29)
VR_P1V8A_SW: length 1.7
  BOTTOM w0.305: PC546.2 83.88,37.27 v1(84.53,37.92)
VR_P3V3_BT: length 3.4
  TOP w0.508: v1(298.71,111.62) 297.99,111.62 v5(297.71,111.33) 297.48,111.11 PC514.1
  BOTTOM w0.305: PU17.14 v1(298.71,111.62)
VR_P3V3_PVIN: length 23.9
  TOP w0.381: v1(300.46,102.36) PR341.1
  IN3 w0.305: v1(300.46,102.36) 299.95,102.87 298.53,102.87 297.21,104.19 297.21,105.46 295.2,107.47 295.2,108.86 297.11,110.77 297.11,113.33 295.89,114.55 v1(289.89,114.55)
  vias: v1(289.13,114.55) v1(290.65,114.02) v1(291.67,115.19) v1(293.32,113.97) v1(293.27,113) v1(293.78,113.52) v1(294.44,113.52) v1(294.83,110.72) v1(295.83,111.92) v1(296.42,111.64)
VR_P3V3_STBY_BT: length 3.5
  TOP w0.305: PC496.1 310.06,88.95 310.59,89.48 v5(310.75,89.48) 311.58,89.48 v1(311.73,89.63)
  BOTTOM w0.254: PU16.14 311.93,89.43 v1(311.73,89.63)
VR_P3V3_STBY_PVIN: length 17.7
  TOP w0.305: v1(313.21,81.94) 312.9,81.64 PR324.1
  IN4 w0.305: v1(306.35,90.37) 307.01,91.03 310.36,91.03 310.87,90.53 310.87,88.93 310.49,88.54 310.49,86.94 311.46,85.98 313.13,85.98 313.84,85.27 313.84,83.82 313.21,83.19 313.21,81.94 v1(313.21,81.94)
  vias: v1(305.46,90.34) v1(307.88,90.3) v1(309.04,90.07) v5(307.16,91.44)
VR_P3V3_STBY_SW: length 1.5
  TOP w0.305: PC496.2 309.35,86.49 v6(308.97,86.11)
VR_P3V3_SW: length 2.8
  TOP w0.508: PC514.2 297.48,107.34 v5(297.23,107.09) 296.62,107.7 v1(296.62,108.09)

## Copper pours and planes (outline as drawn)
GND on TOP (solid shape): 15.11,91.21 15.11,89.99 14.99,89.87 12.98,89.87 12.83,90.02 12.83,91.01 13.18,91.36 14.96,91.36
GND on TOP (solid shape): 18.75,92.18 18.75,91.06 17.88,90.2 16.13,90.2 15.42,90.91 15.42,92.02 15.8,92.41 18.52,92.41
GND on TOP (solid shape): 34.42,99.36 34.42,97.73 34.39,97.7 32.23,97.7 32.21,97.73 32.21,99.36 32.23,99.38 34.39,99.38
GND on TOP (solid shape): 34.44,87.7 34.44,86.07 34.39,86.02 32.36,86.02 32.27,86.11 32.27,87.68 32.34,87.75 34.39,87.75
GND on TOP (solid shape): 40.44,91.76 40.44,89.29 40.24,89.09 37.34,89.09 37.24,89.19 37.24,91.91 37.32,91.99 40.21,91.99
GND on TOP (solid shape): 44.67,52.07 44.67,51.45 44.55,51.33 40.67,51.33 40.51,51.49 40.51,52.34 41,52.83 43.91,52.83
GND on TOP (solid shape): 54.13,50.85 54.13,48.31 53.93,48.11 52.45,48.11 52.02,48.54 52.02,50.83 52.2,51 53.98,51
GND on TOP (solid shape): 60.28,94.61 60.28,93.34 60.02,93.09 54.43,93.09 54.05,93.47 54.05,94.74 54.18,94.87 60.02,94.87
GND on TOP (solid shape): 64.65,36.01 64.65,35.15 64.43,34.92 62.39,34.92 62.27,35.04 62.27,36.16 62.34,36.24 64.43,36.24
GND on TOP (solid shape): 95.45,41.53 95.45,40.01 95.2,39.75 93.04,39.75 92.91,39.88 92.91,41.53 93.42,42.04 94.95,42.04
GND on TOP (solid shape): 96.78,35.03 96.78,33.93 96.57,33.73 92.84,33.73 92.61,33.96 92.61,34.77 92.99,35.15 96.65,35.15
GND on TOP (solid shape): 102.69,41.27 102.69,39.88 102.19,39.37 97.99,39.37 97.74,39.62 97.74,40.89 98.38,41.53 102.44,41.53
GND on TOP (solid shape): 293.35,64.01 293.35,62.59 293.14,62.38 291.39,62.38 291.16,62.61 291.16,63.88 291.42,64.14 293.22,64.14
GND on TOP (solid shape): 293.45,84.45 293.45,82.68 293.32,82.55 291.8,82.55 291.42,82.93 291.42,84.33 291.67,84.58 293.32,84.58
GND on TOP (solid shape): 293.57,43.69 293.57,42.16 293.45,42.04 291.16,42.04 290.91,42.29 290.91,43.56 291.16,43.81 293.45,43.81
GND on TOP (solid shape): 81.17,42.33 81.17,40.93 81.01,40.93 80.85,40.77 79.33,40.77 79.27,40.83 79.27,42.33 79.39,42.45 81.05,42.45
GND on TOP (solid shape): 15.32,103.12 15.32,101.98 15.19,101.85 13.03,101.85 12.78,102.11 12.78,103 13.03,103.25 14.43,103.25 14.43,103.25 15.19,103.25
GND on TOP (solid shape): 18.95,111.2 18.95,107.92 18.92,107.9 15.62,107.9 15.6,107.92 15.6,111.2 15.65,111.25 18.9,111.25
GND on TOP (solid shape): 68.13,39.11 69.1,39.11 69.71,38.5 69.71,35.04 69.63,34.97 67.93,34.97 67.7,35.2 67.7,38.89 67.93,39.11 68.13,39.11
GND on TOP (solid shape): 296.78,91.44 296.78,90.25 296.67,90.14 295.3,90.14 295.05,90.4 292.41,90.4 292.25,90.55 292.25,91.49 292.3,91.54 296.67,91.54
GND on TOP (solid shape): 301.12,113.9 301.12,112.09 300.97,111.94 299.32,111.94 299.16,112.1 299.16,114.1 299.26,114.2 300.81,114.2
GND on TOP (solid shape): 313.64,92.36 313.64,90.19 313.52,90.08 311.82,90.08 311.66,90.24 311.66,92.35 311.81,92.51 313.49,92.51
GND on TOP (solid shape): 15.19,97.54 15.19,96.39 15.06,96.27 13.03,96.27 12.78,96.52 12.78,97.43 12.99,97.64 13.01,97.66 13.04,97.66 15.06,97.66
GND on TOP (solid shape): 84.28,36.3 84.28,35.43 83.89,35.05 82.08,35.05 81.89,35.24 81.89,35.64 81.89,36.53 81.91,36.56 84.02,36.56
GND on TOP (solid shape): 288.88,70.99 288.88,70.1 288.75,69.98 287.86,69.98 287.22,69.34 284.05,69.34 283.8,69.6 283.8,70.87 284.05,71.12 288.75,71.12
GND on TOP (solid shape): 40.44,103.16 40.44,100.03 40.29,99.87 39.11,99.87 38.2,100.77 37.34,100.77 37.24,100.88 37.24,103.59 37.32,103.67 39.93,103.67
GND on TOP (solid shape): 288.62,30.48 288.75,30.35 288.75,29.46 288.62,29.34 287.61,29.34 286.34,28.07 283.8,28.07 283.54,28.32 283.54,30.23 283.8,30.48 284.48,30.48
GND on TOP (solid shape): 288.95,91.47 288.95,90.42 288.83,90.3 287.73,90.3 287.25,89.81 285.7,89.81 285.42,90.09 284.23,90.09 284.22,90.11 284.22,91.48 284.3,91.57 288.85,91.57
GND on TOP (solid shape): 290.65,104.39 290.65,102.97 290.58,102.9 288.7,102.9 288.49,103.1 288.49,103.63 288.5,104.27 288.49,104.52 288.62,104.65 290.4,104.65
GND on TOP (solid shape): 25.81,100.8 25.81,100.39 25.66,100.24 22.86,100.24 22.73,100.38 22.73,100.88 22.81,100.97 23.32,100.97 23.45,101.09 23.45,101.85 23.61,102.02 24.59,102.02
GND on TOP (solid shape): 288.88,50.67 288.88,49.91 288.62,49.66 287.35,49.66 286.46,48.77 284.81,48.77 284.56,49.02 283.92,49.02 283.8,49.15 283.8,50.55 283.92,50.67 286.97,50.67 287.1,50.8 288.75,50.8
GND on TOP (solid shape): 296.75,71.12 296.88,70.99 296.88,69.72 296.75,69.6 295.35,69.6 295.09,69.86 295.09,69.98 294.13,69.98 294.13,69.98 292.3,69.98 292.18,70.1 292.18,70.99 292.3,71.12 293.22,71.12
GND on TOP (solid shape): 25.81,89.12 25.81,88.71 25.66,88.56 22.79,88.56 22.69,88.66 22.69,89.16 22.81,89.28 23.19,89.28 23.32,89.41 23.32,90.04 23.61,90.34 24.59,90.34
GND on TOP (solid shape): 64.81,46.78 65.37,46.78 66.38,45.76 66.38,44.52 66.36,44.49 63.46,44.49 62.51,45.45 61.98,45.45 61.3,46.12 61.3,46.96 61.31,46.97 61.31,47.52 61.55,47.75 63.83,47.75
GND on TOP (solid shape): 297,30.48 297.13,30.35 297.13,29.31 296.83,29.01 295.43,29.01 295.1,29.34 295.02,29.34 294.13,29.34 294.13,29.34 292.3,29.34 292.05,29.59 292.05,30.35 292.18,30.48 293.09,30.48
GND on TOP (solid shape): 296.62,50.8 296.75,50.67 296.75,49.51 296.52,49.28 295.3,49.28 295.2,49.38 295.2,49.56 295.1,49.66 295.02,49.66 294.13,49.66 294.13,49.66 292.3,49.66 292.18,49.78 292.18,50.67 292.3,50.8 293.22,50.8
GND on TOP (solid shape): 59.02,35.86 59.02,34.35 58.98,34.3 57.26,34.3 57.26,34.31 55.23,34.31 55.13,34.41 55.13,35.19 55.15,35.22 55.41,35.22 55.56,35.22 55.66,35.32 55.68,35.32 55.82,35.46 57.51,35.46 57.72,35.67 57.72,35.88 57.77,35.93 58.96,35.93
GND on TOP (solid shape): 278.31,111.35 278.31,103.18 278.29,103.13 278.23,103.11 276.92,103.11 276.77,103.26 276.77,105.26 276.91,105.4 276.91,105.41 276.99,105.49 276.99,107.47 276.77,107.68 276.77,111.13 277.02,111.38 277.81,111.38 277.82,111.39 278.27,111.39
GND on TOP (solid shape): 102.31,35.05 102.31,34.04 102.06,33.78 97.99,33.78 97.74,34.04 97.74,34.92 97.99,35.18 98.36,35.18 98.4,35.13 98.4,35.13 99.62,35.13 99.62,35.13 99.67,35.18 99.75,35.18 99.8,35.13 99.8,35.13 101.02,35.13 101.02,35.13 101.06,35.18 102.09,35.18 102.19,35.18
GND on TOP (solid shape): 60.14,90.74 60.14,89.92 60.01,89.79 57.43,89.79 57.24,89.6 55.7,89.6 51.51,86.49 50.12,85.22 47.58,81.53 45.92,79.76 45.16,79.25 42.62,78.61 33.99,78.61 33.73,78.87 33.73,79.88 34.24,80.39 38.69,80.39 39.45,81.15 46.18,81.15 50.35,86.75 52.55,88.36 54.23,89.92 54.23,90.75 54.38,90.91 59.97,90.91
GND on TOP (solid shape): 27.03,85.69 28.33,85.69 28.68,85.33 29.13,85.33 29.21,85.31 29.28,85.3 29.52,85.3 29.54,85.3 29.57,85.28 29.57,82.93 29.62,82.88 33.4,82.88 33.4,81.41 32.99,81 26.33,81 23.43,83.91 23.43,85.56 23.78,85.92 26.8,85.92
GND on TOP (solid shape): 298.48,89.53 298.48,84.96 299.01,84.43 300.74,84.43 304.04,87.73 306.86,87.73 307.01,87.88 308.31,87.88 308.34,87.85 308.34,86.75 308.23,86.64 308.23,85.6 308.41,85.42 309.27,85.42 309.37,85.52 310.69,85.52 310.95,85.26 310.95,84.5 310.53,84.08 308.53,84.08 307.89,83.44 298.78,83.44 297.1,85.11 297.1,89.33 297.46,89.68 298.32,89.68
GND on TOP (solid shape): 40.21,45.21 40.66,45.21 46.15,45.21 46.31,45.06 46.31,36.06 46.31,36.04 46.71,35.64 50.55,35.64 50.9,35.99 50.9,37.34 51,37.44 52.48,37.44 52.55,37.36 52.55,35.03 51.74,34.21 45.09,34.21 43.64,35.66 43.64,41.27 41.23,43.69 38.05,43.69 37.8,43.94 37.8,44.83 38.3,45.34 40.08,45.34
GND on TOP (solid shape): 27.03,97.37 28.33,97.37 28.68,97.02 29.13,97.02 29.21,96.99 29.28,96.99 29.52,96.99 29.57,96.96 29.59,96.91 29.59,94.83 29.62,94.8 29.62,94.7 29.72,94.6 33.4,94.6 33.46,94.58 33.48,94.53 33.48,93.77 33.51,93.74 33.51,93.21 32.99,92.68 26.33,92.68 23.43,95.59 23.43,97.24 23.78,97.6 26.8,97.6
GND on TOP (solid shape): 284.18,115.95 284.18,113.79 284.8,113.17 286.91,113.17 288.19,111.88 290.46,111.88 291.31,112.73 292.54,112.73 293.12,112.15 293.12,111.13 292.49,110.51 292.49,108.73 292.94,108.29 293.85,108.29 295.1,107.05 296.29,107.05 297.33,106 297.33,104.63 296.61,103.91 296.09,103.91 295.93,103.76 293.96,103.76 293.96,103.76 293.19,103.76 292.69,104.27 292.69,104.78 292.56,104.9 290.91,104.9 290.91,104.9 288.49,104.9 287.48,103.89 284.43,103.89 283.51,104.8 283.51,110.22 283.25,110.49 282.3,110.49 282.19,110.59 282.19,116.23 282.32,116.35 283.77,116.35
GND on TOP (solid shape): 91.03,41.1 91.03,40.55 90.98,40.49 90.24,40.49 90.19,40.44 90.19,39.31 90.19,39.2 90.04,39.05 89.15,39.05 88.87,39.33 88.87,39.52 88.88,39.53 88.9,39.68 88.88,39.83 88.87,39.84 88.87,40.18 88.88,40.19 88.9,40.34 88.88,40.49 88.87,40.5 88.87,40.84 88.88,40.85 88.9,41 88.88,41.15 88.87,41.16 88.87,41.43 89.08,41.64 90.5,41.64
GND on TOP (solid shape): 282.36,7.45 283.26,9.11 285.14,9.25 286.12,8.26 286.18,8.12 286.23,7.97 286.31,7.88 286.31,6.79 285.95,6.43 285.9,6.43 285.79,6.54 285.79,7.45 284.33,8.92 282.87,7.45 282.87,1.5 282.85,1.45 282.79,1.43 282.58,1.43 282.54,1.45 282.51,1.5 282.51,5.95 282.43,5.95 282.38,5.97 282.36,6.02
GND on TOP (solid shape): outline of 172 points within 0.59,108 11,117.73
GND on TOP (solid shape): 320.78,117.74 321.32,117.51 321.54,116.97 321.54,9.68 321.32,9.14 320.78,8.92 297.74,8.92 296.52,8.43 295.96,7.24 295.96,7.21 295.89,7.14 295.61,7.14 295.5,7.19 295.46,7.3 296.18,8.81 297.74,9.42 320.78,9.42 320.96,9.5 321.03,9.68 321.03,116.97 320.96,117.15 320.78,117.23 2,117.23 1.3,116.94 1.02,116.24 1.02,34.44 1.03,34.28 1.05,34.15 1.09,34.03 1.15,33.92 1.24,33.79 1.3,33.71 1.38,33.64 1.51,33.56 1.62,33.5 1.75,33.46 1.87,33.43 2.03,33.42 29.75,33.42 29.91,33.31 30.08,33.2 30.15,33.03 30,32.92 2.02,32.92 1.81,32.93 1.61,32.97 1.43,33.03 1.25,33.12 1.08,33.23 0.95,33.35 0.83,33.49 0.71,33.66 0.62,33.84 0.56,34.02 0.52,34.21 0.51,34.42 0.51,116.24 0.94,117.3 2,117.74
GND on TOP (solid shape): outline of 343 points within 28,32.9 43,42.9
GND on TOP (solid shape): outline of 343 points within 128,32.9 143,42.9
GND on TOP (solid shape): outline of 343 points within 172.05,105 187.05,115
GND on TOP (solid shape): outline of 343 points within 305.25,62.77 320.25,72.77
GND on TOP (solid shape): outline of 343 points within 305.25,102 320.25,112
GND on TOP (solid shape): outline of 343 points within 305.25,11.41 320.25,21.41
GND on TOP (solid shape): outline of 370 points within 140.84,1.43 213.18,33.42
GND on BOTTOM (solid shape): 44.4,94.61 44.4,91.92 43.56,91.08 41.43,91.08 41.15,91.36 41.15,94.28 41.61,94.74 44.27,94.74
GND on BOTTOM (solid shape): 50.07,81.43 50.07,78.99 49.84,78.77 45.43,78.77 45.07,79.12 45.07,80.12 47.45,82.5 49,82.5
GND on BOTTOM (solid shape): 81.25,42.4 81.25,40.88 81.09,40.71 79.39,40.71 79.27,40.82 79.27,42.37 79.37,42.48 81.18,42.48
GND on BOTTOM (solid shape): 96.78,35.03 96.78,33.93 96.57,33.73 92.84,33.73 92.61,33.96 92.61,34.77 92.99,35.15 96.65,35.15
GND on BOTTOM (solid shape): 109.3,34.92 109.3,33.91 109.17,33.78 105.23,33.78 104.98,34.04 104.98,34.92 105.11,35.05 109.17,35.05
GND on BOTTOM (solid shape): 296.06,115.96 296.06,115.1 295.83,114.87 293.75,114.87 293.67,114.94 293.67,116.06 293.8,116.19 295.83,116.19
GND on BOTTOM (solid shape): 298.48,91.21 298.48,83.23 298.4,83.16 297.18,83.16 297.1,83.23 297.1,91.21 297.21,91.31 298.37,91.31
GND on BOTTOM (solid shape): 95.16,41.82 95.45,41.53 95.45,40.01 95.2,39.75 93.04,39.75 92.91,39.88 92.91,41.53 93.42,42.04 93.94,42.04
GND on BOTTOM (solid shape): 60.16,90.78 60.16,89.67 59.95,89.46 54.42,89.46 54.19,89.69 54.19,90.78 54.32,90.91 60.03,90.91
GND on BOTTOM (solid shape): 98.63,40.51 102.31,40.51 102.44,40.39 102.44,39.62 102.19,39.37 97.99,39.37 97.74,39.62 97.74,40.64 97.99,40.89 98.25,40.89
GND on BOTTOM (solid shape): 110.71,41.2 110.71,39.67 110.66,39.62 109.26,39.62 109.21,39.57 108.24,39.57 108.17,39.65 108.17,40.13 109.47,41.44 110.46,41.44
GND on BOTTOM (solid shape): 301.12,116.06 301.12,112.48 300.63,112 299.54,112 299.53,111.99 299.33,111.99 299.11,112.21 299.11,115.91 299.34,116.14 301.04,116.14
GND on BOTTOM (solid shape): 60.1,94.69 60.1,93.34 59.89,93.14 54.31,93.14 54.13,93.32 54.13,94.69 54.26,94.82 59.97,94.82
GND on BOTTOM (solid shape): 44.67,52.44 44.67,51.45 44.53,51.31 40.69,51.31 40.51,51.49 40.51,52.5 40.97,52.96 44.15,52.96
GND on BOTTOM (solid shape): 69.66,39.79 69.66,36.14 68.5,34.98 64.28,34.98 64.09,35.18 64.09,36.06 64.21,36.19 65.49,36.19 67.77,38.47 67.77,39.15 68.48,39.86 69.6,39.86
GND on BOTTOM (solid shape): 102.31,35.05 102.31,34.04 102.06,33.78 97.99,33.78 97.74,34.04 97.74,34.92 97.87,35.05 101.4,35.05 101.53,35.18 102.11,35.18 102.19,35.18
GND on BOTTOM (solid shape): 313.67,92.1 313.67,91.79 313.66,91.79 313.66,90.24 313.51,90.09 311.59,90.09 311.56,90.1 311.53,90.11 311.4,90.24 311.4,92.05 311.51,92.15 313.62,92.15
GND on BOTTOM (solid shape): 291.01,116.61 291.01,115.39 290.81,115.19 289.15,115.19 289.13,115.21 289.13,115.57 288.88,115.82 288.37,115.82 288.24,115.95 288.24,116.46 288.62,116.84 290.78,116.84
GND on BOTTOM (solid shape): 297.79,106.59 297.79,105.18 296.52,103.91 295.8,103.91 295.63,103.74 293.12,103.74 292.71,104.15 292.71,104.99 293.38,105.66 293.84,105.66 294.12,105.94 294.2,105.94 294.2,106.02 294.79,106.61 297.76,106.61
GND on BOTTOM (solid shape): 283.54,116.33 284.05,116.33 284.18,116.2 284.18,113.54 284.28,113.44 284.28,112.65 284.15,112.52 283.59,112.52 282.47,113.64 282.47,115.38 282.08,115.77 281.61,115.77 281.54,115.85 281.54,116.32 281.56,116.34 283.53,116.34
GND on BOTTOM (solid shape): 91.52,41.4 91.52,35.73 90.5,34.72 82.98,34.72 82.56,35.14 82.56,35.53 83.62,36.58 83.92,36.58 83.92,36.59 84.1,36.59 84.11,36.6 84.4,36.6 85.84,38.03 87.77,38.03 89.74,40.01 89.74,41.66 89.99,41.91 91.01,41.91
GND on BOTTOM (solid shape): 27.06,97.37 28.15,97.37 28.73,96.79 29.42,96.79 29.67,96.53 29.67,94.7 29.78,94.6 32.75,94.6 32.82,94.53 32.82,93.92 32.89,93.85 32.89,93.74 33.36,93.74 33.51,93.59 33.51,93.21 33.06,92.76 26.26,92.76 23.43,95.59 23.43,97.6 23.53,97.7 26.73,97.7
GND on BOTTOM (solid shape): 310.95,85.93 311,85.9 311.02,85.85 311.02,84.91 311.02,84.6 310.83,84.41 309.28,84.41 308.57,83.7 308.27,83.7 308.03,83.94 308.03,84.32 308.18,84.48 308.58,84.48 308.71,84.6 308.8,84.6 308.8,84.69 309,84.9 309,85.35 309.58,85.93
GND on BOTTOM (solid shape): 27.11,85.64 29.75,85.64 29.8,85.59 29.8,83.43 30.31,82.92 32.75,82.92 32.82,82.84 32.82,82.23 32.82,82.23 32.82,82.07 32.89,81.99 33.5,81.99 33.66,81.84 33.66,81.28 33.45,81.08 27.84,81.08 25.73,83.19 24.42,83.19 23.43,84.18 23.43,85.92 23.53,86.02 26.73,86.02
GND on BOTTOM (solid shape): 114.36,40.97 114.36,39.45 114.28,39.37 114.28,38.48 114.36,38.4 114.36,38.23 114.13,38 113.98,38 113.93,37.95 113.93,36.4 113.83,36.3 112.36,36.3 112.33,36.32 112.33,37.97 112.41,38.05 112.81,38.05 113.42,38.66 113.42,39.98 113.3,40.09 112.45,40.09 112.43,40.11 112.43,41.02 112.6,41.19 114.15,41.19
GND on BOTTOM (solid shape): 305.74,93.12 305.74,90.95 305.64,90.85 305.58,90.85 305.56,90.84 305.54,90.85 305.42,90.85 305.31,90.83 305.3,90.83 305.18,90.83 305.15,90.79 305.12,90.79 304.32,89.99 302.16,89.99 301.5,90.65 301.5,90.93 301.45,90.98 300.71,90.98 300.69,91.01 300.69,91.9 300.81,92.02 301.22,92.02 301.86,91.39 301.86,91.21 302.16,90.91 303.1,90.91 303.73,91.54 303.73,93.09 303.86,93.22 305.64,93.22
GND on BOTTOM (solid shape): 31.5,91.22 31.5,90.92 31.38,90.8 30.82,90.8 30.41,90.39 29.7,90.39 29.64,90.44 29.64,90.45 29.55,90.57 29.44,90.65 29.43,90.66 28.99,91.1 28.99,91.3 28.91,91.38 28.14,91.38 28.02,91.25 28.02,89.55 27.94,89.47 27.18,89.47 27.15,89.5 27.15,90.08 27.05,90.19 26.09,90.19 25.51,90.77 24.72,90.77 24.39,91.1 23.53,91.1 23.48,91.15 23.48,91.71 23.68,91.91 30.82,91.91
GND on BOTTOM (solid shape): 31.5,102.91 31.5,102.68 31.45,102.63 30.89,102.63 30.33,102.07 29.7,102.07 29.69,102.08 29.58,102.25 29.42,102.36 29.4,102.37 28.99,102.78 28.99,102.98 28.85,103.12 28.09,103.12 28.02,103.05 28.02,101.23 27.97,101.18 27.21,101.18 27.15,101.23 27.15,101.82 27.12,101.86 26.1,101.86 25.6,102.36 24.58,102.36 24.33,102.11 23.83,102.11 23.7,102.23 23.7,102.74 24.55,103.59 30.82,103.59
GND on BOTTOM (solid shape): 278.38,111.28 278.38,109.68 278.36,109.51 278.38,109.36 278.38,109.35 278.38,107.45 278.36,107.27 278.38,107.13 278.38,107.11 278.38,105.21 278.36,105.03 278.38,104.89 278.38,104.88 278.38,104.39 278.1,104.1 276.98,104.1 276.77,104.31 276.77,105.26 276.99,105.47 276.99,107.47 276.77,107.68 276.77,111.1 276.78,111.13 276.79,111.16 277.02,111.38 277.03,111.39 278.27,111.39
GND on BOTTOM (solid shape): 54.05,50.75 54.05,49 54.92,48.13 63.45,48.13 64.64,46.94 65.46,46.94 65.92,46.47 65.92,45.1 64.88,44.06 63.69,44.06 62.45,42.82 61.53,42.82 61.09,42.37 61.09,40.6 61.71,39.97 61.71,38.72 61.27,38.28 53.22,38.28 52.67,37.73 52.67,36.53 52.66,36.46 52.67,36.4 52.67,36.25 52.71,36.12 52.72,36.08 52.71,36.05 52.69,36 52.68,35.94 52.66,35.83 52.68,35.71 52.68,35.7 52.68,35.31 52.2,34.83 45.57,34.83 44.78,35.61 44.78,41.4 42.14,44.04 40.74,44.04 40.62,44.17 40.62,44.96 40.77,45.11 44.81,45.11 45.34,45.64 45.34,46.56 45.59,46.81 46.36,46.81 46.46,46.71 46.46,43.76 46.86,43.36 51.46,43.36 51.77,43.66 51.77,51.03 52,51.26 53.54,51.26
GND on BOTTOM (solid shape): 282.59,8.38 283.75,9.34 285.25,9.19 285.45,9.19 286.25,8.4 286.25,6.77 286.21,6.73 285.88,6.73 285.79,6.82 285.79,7.45 285.74,7.82 285.61,8.15 285.61,8.16 284.26,8.91 282.99,8.03 282.87,7.94 282.74,7.98 282.59,8.13
GND on BOTTOM (solid shape): 309.22,55.55 310.54,55.55 310.69,55.4 310.69,54.61 310.58,54.5 308.93,54.5 308.92,54.48 308.86,54.48 308.59,54.21 308.59,53.92 308.58,53.91 308.56,53.75 308.58,53.59 308.59,53.58 308.59,53.31 308.69,53.21 308.69,53.06 308.97,52.78 310.57,52.78 310.77,52.58 310.77,52.5 310.8,52.47 310.8,51.79 310.65,51.64 310.5,51.64 310.41,51.66 310.34,51.67 309.89,51.67 309.87,51.68 309.64,51.71 309.41,51.64 308.69,51.64 308.23,51.18 305.18,51.18 304.8,51.56 304.8,52.32 304.75,52.37 304.75,52.53 304.4,52.53 304.39,52.54 304.24,52.56 304.09,52.54 304.08,52.53 303.88,52.53 303.84,52.58 303.84,53.21 303.94,53.32 304.24,53.32 304.31,53.32 304.38,53.34 304.65,53.34 304.66,53.35 304.75,53.35 304.75,54.31 304.4,54.31 304.32,54.33 304.24,54.34 303.89,54.34 303.83,54.36 303.81,54.41 303.81,55.07 303.84,55.1 304.24,55.1 304.32,55.1 304.4,55.12 304.75,55.12 304.75,55.3 304.78,55.32 304.78,55.75 304.9,55.88 308.89,55.88
GND on BOTTOM (solid shape): outline of 108 points within 140.85,9.56 212.51,33.42
GND on BOTTOM (solid shape): outline of 343 points within 28,32.9 43,42.9
GND on BOTTOM (solid shape): outline of 343 points within 128,32.9 143,42.9
GND on BOTTOM (solid shape): outline of 343 points within 172.05,105 187.05,115
GND on BOTTOM (solid shape): outline of 343 points within 305.25,62.77 320.25,72.77
GND on BOTTOM (solid shape): outline of 343 points within 305.25,102 320.25,112
GND on BOTTOM (solid shape): outline of 343 points within 305.25,11.41 320.25,21.41
GND on GND (solid shape): outline of 19689 points within 0.51,5.69 321.54,117.74
GND on IN1 (solid shape): 308.48,54.99 308.48,51.97 308.26,51.74 305.13,51.74 304.85,52.02 304.85,54.86 305.13,55.14 308.33,55.14
GND on IN1 (solid shape): outline of 115 points within 140.85,5.69 213.18,33.42
GND on IN1 (solid shape): 320.78,117.74 321.32,117.51 321.54,116.97 321.54,9.68 321.32,9.14 320.78,8.92 297.74,8.92 296.48,8.39 295.96,7.14 295.96,5.69 295.45,5.69 295.45,7.14 296.12,8.75 297.74,9.42 320.78,9.42 320.96,9.5 321.03,9.68 321.03,116.97 320.96,117.15 320.78,117.23 2,117.23 1.3,116.94 1.02,116.24 1.02,34.44 1.03,34.28 1.05,34.15 1.09,34.03 1.15,33.92 1.24,33.79 1.3,33.71 1.38,33.64 1.51,33.56 1.62,33.5 1.75,33.46 1.87,33.43 2.03,33.42 29.75,33.42 29.91,33.31 30.08,33.2 30.15,33.03 30,32.92 2.02,32.92 1.81,32.93 1.61,32.97 1.43,33.03 1.25,33.12 1.08,33.23 0.95,33.35 0.83,33.49 0.71,33.66 0.62,33.84 0.56,34.02 0.52,34.21 0.51,34.42 0.51,116.24 0.94,117.3 2,117.74
GND on GND1 (solid shape): outline of 21186 points within 0.51,5.69 321.54,117.74
GND on IN2 (solid shape): outline of 115 points within 140.85,5.66 213.18,33.42
GND on IN2 (solid shape): 320.78,117.74 321.32,117.51 321.54,116.97 321.54,9.68 321.32,9.14 320.78,8.92 297.74,8.92 296.48,8.39 295.96,7.14 295.96,5.69 295.45,5.69 295.45,7.14 296.12,8.75 297.74,9.42 320.78,9.42 320.96,9.5 321.03,9.68 321.03,116.97 320.96,117.15 320.78,117.23 2,117.23 1.3,116.94 1.02,116.24 1.02,34.44 1.03,34.28 1.05,34.15 1.09,34.03 1.15,33.92 1.24,33.79 1.3,33.71 1.38,33.64 1.51,33.56 1.62,33.5 1.75,33.46 1.87,33.43 2.03,33.42 29.75,33.42 29.91,33.31 30.08,33.2 30.15,33.03 30,32.92 2.02,32.92 1.81,32.93 1.61,32.97 1.43,33.03 1.25,33.12 1.08,33.23 0.95,33.35 0.83,33.49 0.71,33.66 0.62,33.84 0.56,34.02 0.52,34.21 0.51,34.42 0.51,116.24 0.94,117.3 2,117.74
GND on VCC (solid shape): outline of 4063 points within 128.6,5.69 321.03,95.89
GND on IN3 (solid shape): outline of 115 points within 140.85,5.69 213.18,33.42
GND on IN3 (solid shape): 320.78,117.74 321.32,117.51 321.54,116.97 321.54,9.68 321.32,9.14 320.78,8.92 297.74,8.92 296.48,8.39 295.96,7.14 295.96,5.69 295.45,5.69 295.45,7.14 296.12,8.75 297.74,9.42 320.78,9.42 320.96,9.5 321.03,9.68 321.03,116.97 320.96,117.15 320.78,117.23 2,117.23 1.3,116.94 1.02,116.24 1.02,34.44 1.03,34.28 1.05,34.15 1.09,34.03 1.15,33.92 1.24,33.79 1.3,33.71 1.38,33.64 1.51,33.56 1.62,33.5 1.75,33.46 1.87,33.43 2.03,33.42 29.75,33.42 29.91,33.31 30.08,33.2 30.15,33.03 30,32.92 2.02,32.92 1.81,32.93 1.61,32.97 1.43,33.03 1.25,33.12 1.08,33.23 0.95,33.35 0.83,33.49 0.71,33.66 0.62,33.84 0.56,34.02 0.52,34.21 0.51,34.42 0.51,116.24 0.94,117.3 2,117.74
GND on GND2 (solid shape): outline of 21188 points within 0.51,5.69 321.54,117.74
GND on IN4 (solid shape): outline of 115 points within 140.85,5.69 213.18,33.42
GND on IN4 (solid shape): 320.78,117.74 321.32,117.51 321.54,116.97 321.54,9.68 321.32,9.14 320.78,8.92 297.74,8.92 296.48,8.39 295.96,7.14 295.96,5.69 295.45,5.69 295.45,7.14 296.12,8.75 297.74,9.42 320.78,9.42 320.96,9.5 321.03,9.68 321.03,116.97 320.96,117.15 320.78,117.23 2,117.23 1.3,116.94 1.02,116.24 1.02,34.44 1.03,34.28 1.05,34.15 1.09,34.03 1.15,33.92 1.24,33.79 1.3,33.71 1.38,33.64 1.51,33.56 1.62,33.5 1.75,33.46 1.87,33.43 2.03,33.42 29.75,33.42 29.91,33.31 30.08,33.2 30.15,33.03 30,32.92 2.02,32.92 1.81,32.93 1.61,32.97 1.43,33.03 1.25,33.12 1.08,33.23 0.95,33.35 0.83,33.49 0.71,33.66 0.62,33.84 0.56,34.02 0.52,34.21 0.51,34.42 0.51,116.24 0.94,117.3 2,117.74
GND on GND3 (solid shape): outline of 22014 points within 0.51,5.69 321.54,117.74
GND_L on IN2 (solid shape): outline of 739 points within -19.49,-9.03 -2.51,364.68
GND_L on IN4 (solid shape): outline of 739 points within -19.49,-9.03 -2.51,364.68
P0V9 on TOP (solid shape): outline of 230 points within 43.54,81.7 61.09,104.01
P0V9 on BOTTOM (solid shape): outline of 336 points within 43.54,81.79 61.95,101.98
P0V9 on IN1 (solid shape): outline of 801 points within 42.75,81.81 59.49,102.26
P0V9 on IN2 (solid shape): outline of 774 points within 42.75,81.58 59.51,102.23
P0V9 on VCC1 (solid shape): 103.96,102.64 103.96,60.43 99.92,56.39 58.35,56.39 44.02,70.72 44.02,99.31 65.66,99.31 65.66,99.26 65.68,99.2 65.7,99.15 65.72,99.1 65.76,99.06 65.8,99.02 65.84,98.99 65.89,98.96 65.95,98.94 66,98.93 66.06,98.93 66.11,98.94 66.17,98.95 66.22,98.97 66.26,99 66.31,99.04 66.34,99.08 66.37,99.13 66.4,99.18 66.41,99.23 66.42,99.29 66.42,99.34 66.41,99.4 66.4,99.45 66.37,99.5 66.34,99.55 66.31,99.59 66.26,99.62 66.22,99.65 66.17,99.68 66.11,99.69 66.06,99.7 66,99.69 65.95,99.68 65.89,99.67 65.84,99.64 65.8,99.61 65.76,99.57 65.72,99.52 65.7,99.48 65.68,99.42 65.66,99.37 65.66,99.31 44.02,99.31 44.02,102.13 45.4,103.5 103.1,103.5
P0V9 on IN3 (solid shape): outline of 22220 points within 41.35,68.45 92.91,103.63
P0V9_A on TOP (solid shape): 42.01,51.08 43.23,51.08 43.23,51.08 43.54,51.08 43.54,51.08 44.76,51.08 44.76,51.08 46.03,51.08 46.1,51 46.1,45.54 46.08,45.49 46.03,45.47 40.77,45.47 40.72,45.52 40.72,47.62 39.96,48.39 39.96,49 39.96,49.02 39.96,50.93 40.07,51.04 40.48,51.04 40.51,51.08 41.71,51.08 41.71,51.08 42.01,51.08
P0V9_A on BOTTOM (solid shape): 46.1,51 46.1,47.47 46,47.37 45.75,47.37 44.99,46.61 44.99,45.8 44.65,45.47 40.96,45.47 40.9,45.49 40.88,45.54 40.88,47.32 40.14,48.06 40.07,48.12 39.99,48.18 39.97,48.21 39.96,48.24 39.96,50.8 40.21,51.05 46.05,51.05
P0V9_A on VCC (solid shape): outline of 468 points within 38.18,33.42 110.06,90.3
P0V9_AGND on BOTTOM (solid shape): 13.99,113.38 13.99,111.99 14.23,111.76 15.85,111.76 17.37,113.28 17.7,113.28 17.75,113.23 17.76,113.2 17.76,113.18 17.76,113 17.83,112.83 17.83,111.27 17.58,111.02 17.58,110.43 18.22,109.79 19.96,109.79 20.63,109.12 20.63,108.03 20.57,107.97 20.35,107.97 20.19,108.13 20.19,108.13 19.33,108.99 18.55,108.99 18.51,109 18.14,109.04 17.84,108.8 17.84,108.79 17.38,108.33 17.38,108.33 17.2,108.15 16.71,108.15 16.69,108.18 16.69,108.81 16.57,108.95 16.4,109.04 16.38,109.04 16.21,109.22 16.21,109.78 16.77,110.34 16.77,110.82 16.49,111.1 16,111.1 15.22,110.31 14.91,110.31 14.78,110.19 14.78,108.99 15.04,108.74 15.04,107.29 14.43,106.68 13.64,106.68 11.91,108.41 11.91,109.96 13.08,111.13 13.08,112.19 13.26,112.37 13.26,113.61 13.41,113.77 13.61,113.77
P0V9A_AGND on TOP (solid shape): 68.74,44.11 68.74,41.42 68.72,41.39 67.19,41.39 67.12,41.47 67.12,44.08 67.17,44.13 68.72,44.13
P0V9A_AGND on BOTTOM (solid shape): 70.18,44.96 70.18,43.94 70.69,43.43 71.71,43.43 71.83,43.31 71.83,42.55 71.71,42.42 69.17,42.42 68.91,42.67 68.91,45.09 69.04,45.21 69.93,45.21
P0V9A_OUT on TOP (solid shape): 51.77,51.05 51.77,48.26 53.03,47 53.03,45.43 53.03,45.42 53.03,39.14 51.61,37.72 50.88,37.72 50.57,37.41 50.57,36.11 50.37,35.91 46.82,35.91 46.56,36.17 46.56,45.14 46.64,45.21 46.64,47.17 46.64,47.4 46.64,49.2 46.64,49.43 46.64,51.13 46.94,51.44 51.39,51.44
P0V9A_OUT on BOTTOM (solid shape): 51.51,51.05 51.51,43.94 51.26,43.69 46.93,43.69 46.75,43.87 46.75,51.24 47.07,51.56 51,51.56
P1V8 on BOTTOM (solid shape): 106.88,40.13 106.88,37.59 107.27,37.21 110.19,37.21 110.44,36.96 110.44,35.94 110.06,35.56 104.98,35.56 104.47,36.07 104.47,40.13 104.85,40.51 106.5,40.51
P1V8 on BOTTOM (solid shape): 45.8,60.96 45.8,58.45 44.99,57.63 44.99,56.62 45.42,56.18 45.65,56.18 45.92,55.91 45.92,54.74 45.8,54.61 45.42,54.61 45.29,54.74 45.29,55.37 43.77,56.9 43.77,60.96 44.02,61.21 45.54,61.21
P1V8 on IN1 (solid shape): outline of 25477 points within 44.15,35.94 125.35,92.75
P1V8_A on TOP (solid shape): 102.24,38.68 102.24,35.69 101.98,35.43 97.36,35.43 97.11,35.69 97.11,38.23 97.74,38.86 102.06,38.86
P1V8_A on BOTTOM (solid shape): 102.24,38.76 102.24,35.66 102.01,35.43 101.42,35.43 101.3,35.31 97.36,35.31 97.11,35.56 97.11,38.23 97.74,38.86 102.14,38.86
P1V8_A on IN2 (solid shape): outline of 27590 points within 56.08,68.07 122.63,103.5
P1V8_A on VCC (solid shape): outline of 100 points within 56.47,33.42 129.3,103.5
P1V8A_AGND on TOP (solid shape): 81.63,39.86 81.63,35.75 81.61,35.72 81.41,35.72 81.36,35.77 81.36,36.13 81.36,36.2 81.33,36.28 81.33,36.56 81.3,36.59 81.18,36.59 81.18,36.59 80.29,36.59 80.24,36.64 80.24,38.97 80.34,39.07 81.26,39.07 81.26,39.08 81.33,39.15 81.33,39.38 81.36,39.46 81.36,39.53 81.36,39.81 81.38,39.87 81.44,39.89 81.61,39.89
P1V8A_AGND on BOTTOM (solid shape): 81.23,37.83 81.23,37.71 81.22,37.68 81.2,37.65 80.95,37.4 80.36,37.4 80.26,37.3 80.26,36.1 80.24,36.05 80.19,36.02 79.99,35.98 79.81,35.87 79.25,35.87 79.12,36 79.12,36.96 78.97,37.12 78.84,37.12 78.66,37.29 78.66,37.62 78.86,37.83 80.11,37.83 80.31,38.03 81.03,38.03
P1V8A_OUT on TOP (solid shape): 92.66,39.24 96.22,39.24 96.6,38.86 96.6,36.2 95.96,35.56 92.66,35.56 91.77,34.67 89.87,34.67 89.36,35.18 89.36,37.59 89.87,38.1 90.25,38.1 90.5,38.35 90.5,40.01 90.63,40.13 91.77,40.13
P3V3 on TOP (solid shape): 282.02,70.99 282.02,69.34 281.76,69.09 279.99,69.09 279.6,69.47 279.6,70.87 279.86,71.12 281.89,71.12
P3V3 on TOP (solid shape): 277.7,116.76 277.7,111.76 277.57,111.63 275.03,111.63 274.65,112.01 274.65,116.33 275.16,116.84 277.62,116.84
P3V3 on TOP (solid shape): 289,35.94 289,35.46 289,35.46 288.98,35.25 289,35.05 289,35.05 289,34.67 287.99,33.66 287.99,33.39 287.98,33.25 287.99,33.12 287.99,32.64 288.52,32.11 288.52,31.43 288.62,31.33 288.62,30.86 288.49,30.73 284.58,30.73 284.57,30.75 282.77,30.75 282.65,30.86 282.65,31.37 285.67,34.39 285.7,34.4 285.73,34.41 285.85,34.4 285.98,34.42 286.46,34.42 286.72,34.67 286.72,35.81 287.1,36.2 288.75,36.2
