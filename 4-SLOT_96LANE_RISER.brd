# Allegro board 4-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT4_RX_DN<3>: length 244.1
  IN3 w0.089: 63.79,93.79 63.82,93.79 63.86,93.74 67.59,93.74 67.77,93.92 67.77,94.04 67.68,94.13 v4(67.36,94.13)
  IN3 w0.135: J4.A30 265.2,94.97 265.14,95.15 264.93,95.25 264.66,95.52 264.66,99.35 arc(264.57,99.58) 264.34,99.67 264.21,99.67 arc(263.85,99.82) 263.7,100.17 263.7,101.45 263.64,101.83 263.41,102.15 261.55,103.45 260.81,103.58 260.63,103.46 260.23,103.53 260.11,103.71 259.71,103.78 259.53,103.65 259.13,103.72 259.01,103.9 259.01,103.9 258.09,104.06 257.76,104.29 257.55,104.26 257.22,104.49 257.18,104.7 256.28,105.33 256.05,105.66 255.84,105.7 255.6,106.03 255.64,106.24 255.48,106.47 255.31,107.44 255.04,107.83 254.61,108.13 250.3,108.89 244.18,107.81 229.72,110.34 227.83,110 215.51,112.18 200.6,109.55 199.88,109.04 199.04,108.45 198.62,108.53 198.4,108.84 198.22,108.87 197.91,108.65 197.88,108.47 198.09,108.16 198.02,107.74 197.52,107.39 197.1,107.46 196.88,107.77 196.69,107.8 196.38,107.59 196.35,107.4 196.57,107.09 196.49,106.67 195.99,106.32 195.57,106.39 195.36,106.7 195.17,106.73 194.86,106.52 194.83,106.33 195.04,106.02 194.97,105.6 194.47,105.25 194.05,105.33 193.83,105.63 193.64,105.67 193.34,105.45 193.3,105.26 193.52,104.96 193.44,104.54 192.94,104.18 192.52,104.26 192.31,104.57 192.12,104.6 191.81,104.38 191.78,104.2 192,103.89 191.92,103.47 191.42,103.12 191,103.19 190.78,103.5 190.6,103.53 190.29,103.32 190.26,103.13 190.47,102.82 190.4,102.4 189.77,101.96 172.99,98.99 132.25,106.18 124.52,111.59 111.74,113.84 107.9,113.17 105.39,113.61 100.16,112.69 92.97,113.96 87.5,112.99 82.65,112.14 81.59,112.32 70.71,110.41 67.19,107.94 66.14,106.44 65.7,103.97 65.7,103.97 65.69,103.91 64.84,102.69 64.88,102.48 64.65,102.15 64.44,102.11 64.2,101.78 64.24,101.57 64.01,101.24 63.8,101.2 63.57,100.87 63.39,99.85 63.51,99.67 63.44,99.27 63.26,99.15 63.19,98.75 63.32,98.57 63.25,98.18 63.07,98.05 63,97.65 63.12,97.48 63.05,97.08 62.88,96.96 62.81,96.56 63,95.43 63.18,95.31 63.25,94.91 63.13,94.73 63.23,94.16 63.4,93.92 63.58,93.79 63.79,93.79
  BOTTOM w0.135: U1.AL30 v4(67.36,94.13)
PE_SLOT4_RX_DN<4>: length 227
  IN3 w0.089: v4(69.36,95.13) 69.36,94.81 69.28,94.73 69.15,94.73 68.97,94.91 68.97,98.6 69.02,98.64 69.02,98.67
  IN3 w0.135: 69.02,98.67 69.02,98.86 68.94,99.28 68.67,99.67 67.47,100.51 66.58,101.78 66.31,103.28 66.38,103.67 66.56,103.8 66.63,104.2 66.51,104.37 66.58,104.77 66.75,104.9 66.82,105.29 66.7,105.47 66.8,106.04 67.91,107.63 68.24,107.86 68.45,107.82 68.79,108.05 68.82,108.27 69.15,108.5 69.37,108.46 69.7,108.69 69.74,108.9 70.98,109.78 81.58,111.65 82.59,111.47 92.96,113.3 100.16,112.03 105.39,112.95 107.9,112.51 111.74,113.18 124.26,110.98 132,105.56 173.14,98.31 189.91,101.26 200.86,108.93 215.33,111.48 227.73,109.3 229.71,109.64 244.13,107.1 250.1,108.16 250.73,108.05 251.26,107.67 251.52,107.3 251.76,105.94 252.51,104.88 254.41,103.55 254.77,103.48 254.89,103.31 255.29,103.24 255.47,103.36 255.86,103.29 255.99,103.11 256.39,103.04 256.56,103.17 256.96,103.1 257.09,102.92 257.48,102.85 257.66,102.97 257.66,102.97 258.18,102.88 258.78,102.46 259.23,102.02 259.68,101.37 259.68,99.99 arc(259.64,99.89) 259.54,99.86 259.09,99.86 arc(258.79,99.73) 258.67,99.43 258.67,95.52 258.93,95.25 259.14,95.15 259.2,94.97 J4.A36
  BOTTOM w0.135: U1.AJ31 v4(69.36,95.13)
PE_SLOT4_RX_DN<5>: length 224.5
  IN3 w0.089: 70,98.9 70,98.88 69.95,98.83 69.95,94.92 70.15,94.73 70.28,94.73 70.36,94.81 v4(70.36,95.13)
  IN3 w0.135: J4.A40 255.2,94.97 255.14,95.15 254.93,95.25 254.68,95.5 254.68,99.4 arc(254.81,99.72) 255.14,99.86 255.53,99.86 arc(255.62,99.89) 255.66,99.99 255.66,101.91 255.54,102.09 255.19,102.33 254.18,102.51 254.17,102.51 254,102.38 253.6,102.45 253.48,102.63 253.08,102.7 252.9,102.58 252.5,102.65 252.38,102.83 251.98,102.9 251.8,102.77 251.41,102.84 251.28,103.02 250.71,103.12 250.08,103.56 250,104.01 250.69,105.01 250.65,105.24 250.34,105.45 250.15,105.42 249.47,104.43 249.4,104.34 249.02,104.27 248.52,104.62 248.44,105.04 248.57,105.22 248.54,105.41 248.23,105.62 248.04,105.59 247.91,105.41 247.49,105.33 247.13,105.59 246.5,106.47 246.21,106.68 245.86,106.74 244.15,106.44 229.71,108.98 227.73,108.64 215.34,110.82 208.35,109.59 201.35,108.35 190.41,100.69 173.15,97.64 131.75,104.94 124.01,110.36 111.74,112.52 107.9,111.85 105.39,112.29 100.16,111.37 92.96,112.64 82.54,110.8 81.54,110.98 71.87,109.27 71.02,108.68 70.98,108.46 70.65,108.23 70.44,108.27 70.11,108.04 70.07,107.82 69.74,107.59 69.53,107.63 69.2,107.4 69.16,107.18 68.83,106.95 68.61,106.99 68.01,106.57 67.67,106.08 67.43,104.75 67.56,104.57 67.49,104.18 67.31,104.05 67.09,102.84 67.23,102.08 67.93,101.08 69.58,99.92 69.92,99.44 69.93,99.42 70,99.03 70,98.9
  BOTTOM w0.135: U1.AH31 v4(70.36,95.13)
PE_SLOT4_RX_DN<6>: length 214.6
  IN3 w0.089: 70.99,99.05 70.99,99.03 70.95,98.98 70.95,94.93 71.15,94.73 71.28,94.73 71.36,94.81 v4(71.36,95.13)
  IN3 w0.135: J4.A44 251.2,94.97 251.14,95.15 250.93,95.25 250.67,95.52 250.67,99.41 arc(250.8,99.72) 251.11,99.86 251.54,99.86 arc(251.64,99.89) 251.68,99.99 251.68,101.46 251.31,101.83 250.93,102.1 250.69,102.05 250.36,102.29 250.32,102.52 250.01,102.74 249.78,102.69 249.45,102.92 249.4,103.16 246.18,105.42 229.71,108.32 227.61,107.95 215.21,110.14 201.61,107.74 190.58,100.02 173.21,96.96 131.51,104.31 123.75,109.74 111.74,111.86 107.9,111.19 105.39,111.63 100.16,110.71 92.96,111.97 82.49,110.13 81.53,110.3 73.92,108.96 73.15,108.41 73.11,108.2 72.78,107.97 72.57,108 72.24,107.77 72.2,107.56 71.87,107.33 71.65,107.37 71.32,107.13 71.28,106.92 70.95,106.69 70.74,106.73 70.41,106.5 70.04,105.96 70.08,105.75 69.84,105.42 69.63,105.38 69.4,105.05 69.44,104.84 69.21,104.51 68.99,104.47 68.76,104.14 68.21,103.75 67.9,103.31 67.83,102.94 67.93,102.41 68.44,101.68 70.53,100.22 70.91,99.66 70.95,99.44 70.99,99.21 70.99,99.05
  BOTTOM w0.135: U1.AG31 v4(71.36,95.13)
PE_SLOT4_RX_DN<7>: length 213.8
  IN3 w0.089: 72.01,98.95 72.01,98.93 71.96,98.88 71.96,94.91 72.15,94.73 72.28,94.73 72.36,94.81 v4(72.36,95.13)
  IN3 w0.135: J4.A48 247.2,94.97 247.14,95.15 246.93,95.25 246.7,95.48 246.7,99.43 arc(246.64,99.58) 246.49,99.64 246.14,99.64 arc(245.82,99.78) 245.69,100.1 245.69,101.33 245.57,102 245,102.82 244.76,102.99 244.54,102.95 244.21,103.18 244.18,103.4 243.84,103.63 243.63,103.59 243.3,103.82 243.26,104.03 242.7,104.43 242.28,104.5 242.12,104.39 241.73,104.46 241.61,104.62 240.33,104.85 240.08,105.2 240.16,105.66 240.05,105.81 239.68,105.88 239.53,105.77 239.45,105.31 239.1,105.07 238.49,105.17 238.25,105.52 238.33,105.98 238.22,106.14 237.85,106.2 237.7,106.09 237.61,105.64 237.26,105.39 236.66,105.5 236.42,105.85 236.5,106.3 236.39,106.46 236.02,106.53 235.86,106.42 235.78,105.96 235.43,105.71 234.83,105.82 234.58,106.17 234.66,106.63 234.56,106.78 234.19,106.85 234.03,106.74 233.95,106.28 233.6,106.04 233,106.14 232.75,106.5 232.83,106.95 232.72,107.11 232.35,107.17 232.2,107.06 232.12,106.61 231.77,106.36 231.16,106.47 230.92,106.82 231,107.28 230.89,107.43 230.52,107.5 230.37,107.39 230.29,106.93 229.93,106.69 214.77,109.36 214.74,109.36 201.8,107.08 190.84,99.4 173.22,96.3 131.26,103.69 123.5,109.13 111.74,111.2 107.9,110.53 105.39,110.97 100.15,110.04 92.96,111.31 82.44,109.46 81.53,109.62 74.96,108.46 74.18,107.91 74.14,107.7 73.81,107.47 73.6,107.5 73.27,107.27 73.23,107.06 72.9,106.83 72.68,106.87 72.29,106.59 71.95,106.1 71.99,105.89 71.76,105.56 71.55,105.52 71.31,105.19 71.35,104.98 71.12,104.65 70.91,104.61 70.67,104.28 69.89,103.73 69.62,103.35 69.55,102.93 69.67,102.26 70.28,101.38 71.01,100.87 72.01,99.45 72.01,98.95
  BOTTOM w0.135: U1.AF31 v4(72.36,95.13)
PE_SLOT4_RX_DN<8>: length 199.8
  IN3 w0.089: v4(73.36,95.13) 73.36,94.81 73.28,94.73 73.15,94.73 72.95,94.92 72.95,98.85 73,98.9 73,98.92
  IN3 w0.135: 73,98.92 73,99.55 72.91,100.06 72.66,100.41 72.7,100.63 72.47,100.96 72.25,101 71.59,101.95 71.46,102.67 71.59,103.37 71.81,103.68 72.63,104.26 73.19,105.06 73.2,105.12 73.37,106.11 73.5,106.28 75.87,107.94 81.58,108.95 82.44,108.8 92.95,110.65 100.15,109.38 105.39,110.31 107.9,109.86 111.74,110.54 123.24,108.51 131,103.08 173.18,95.62 191.09,98.79 202.01,106.43 214.74,108.67 223.52,107.13 223.63,106.97 224.03,106.9 224.19,107.01 224.59,106.94 224.7,106.78 225.1,106.71 225.26,106.82 225.65,106.75 225.76,106.59 226.16,106.52 226.32,106.63 226.72,106.56 226.83,106.4 227.23,106.33 227.39,106.45 228.45,106.26 228.85,106.19 228.96,106.03 229.36,105.96 229.52,106.07 229.92,106 230.03,105.84 230.42,105.77 230.58,105.88 230.98,105.81 231.09,105.65 231.49,105.58 231.65,105.69 232.05,105.62 232.16,105.46 232.56,105.39 232.71,105.51 233.11,105.44 233.22,105.28 233.62,105.21 233.78,105.32 234.18,105.25 234.29,105.09 234.69,105.02 234.85,105.13 235.24,105.06 235.35,104.9 235.75,104.83 235.91,104.94 236.31,104.87 236.42,104.71 236.82,104.64 236.98,104.75 237.37,104.68 237.77,104.61 241.15,102.25 241.59,101.62 241.69,101.03 241.69,99.99 arc(241.82,99.69) 242.11,99.57 242.54,99.57 arc(242.63,99.53) 242.67,99.43 242.67,95.63 242.51,95.47 242.39,95.4 242.2,95.46 J4.A53
  BOTTOM w0.135: U1.AE31 v4(73.36,95.13)
PE_SLOT4_RX_DN<9>: length 197.4
  IN3 w0.089: v4(74.36,95.13) 74.36,94.81 74.28,94.73 74.15,94.73 73.97,94.91 73.97,97.07 74.02,97.12 74.02,97.15
  IN3 w0.135: 74.02,97.15 74.02,97.66 74.13,98.3 73.95,99.31 74.06,99.47 73.99,99.87 73.83,99.98 73.76,100.38 73.87,100.54 73.8,100.94 73.65,101.05 73.58,101.45 73.69,101.6 73.62,102 73.46,102.11 73.39,102.51 73.49,103.07 73.49,103.07 73.58,103.63 73.69,103.78 74.02,104.01 74.21,103.98 74.54,104.21 74.58,104.4 75.13,104.79 75.37,106.11 75.63,106.49 76.11,106.83 76.33,106.79 76.66,107.02 76.7,107.23 77.03,107.47 81.53,108.26 82.33,108.12 92.95,109.99 100.15,108.72 105.39,109.65 107.9,109.2 111.73,109.88 122.98,107.9 130.78,102.44 173.18,94.96 191.43,98.19 202.29,105.79 214.38,107.92 222,106.58 222.11,106.42 222.51,106.35 222.67,106.46 223.07,106.39 223.18,106.23 223.57,106.16 223.73,106.27 224.13,106.2 224.24,106.04 224.64,105.97 224.8,106.08 225.86,105.9 226.26,105.83 226.37,105.67 226.77,105.6 226.93,105.71 227.33,105.64 227.44,105.48 227.84,105.41 228,105.52 228.39,105.45 228.51,105.29 228.9,105.22 229.06,105.33 229.46,105.26 229.57,105.1 229.97,105.03 230.13,105.15 230.52,105.08 230.64,104.92 231.03,104.85 231.19,104.96 232.3,104.76 232.41,104.61 232.29,103.96 232.54,103.61 233.14,103.51 233.49,103.75 233.61,104.4 233.76,104.5 234.13,104.44 234.24,104.28 234.13,103.64 234.37,103.29 234.98,103.18 235.33,103.43 235.44,104.07 235.6,104.18 236.62,104 237.1,103.67 237.51,103.07 237.71,101.98 237.71,99.99 arc(237.83,99.69) 238.13,99.57 238.55,99.57 arc(238.65,99.53) 238.69,99.43 238.69,95.64 238.51,95.47 238.39,95.4 238.2,95.46 J4.A57
  BOTTOM w0.135: U1.AD31 v4(74.36,95.13)
PE_SLOT4_RX_DN<10>: length 186.9
  IN3 w0.089: 75,97.02 75,97 74.96,96.95 74.96,94.92 75.15,94.73 75.28,94.73 75.36,94.81 v4(75.36,95.13)
  IN3 w0.135: 75,97.02 75,100.41 75.08,100.86 75.26,100.98 75.33,101.38 75.21,101.56 75.28,101.95 75.45,102.08 75.52,102.48 75.4,102.65 75.5,103.21 76.04,103.98 76.62,104.39 77.1,105.08 77.28,106.08 77.63,106.57 78.24,107 81.53,107.58 82.29,107.45 92.95,109.33 100.15,108.06 105.38,108.98 107.9,108.54 111.74,109.22 122.73,107.28 130.53,101.82 173.39,94.25 191.53,97.46 202.55,105.18 213.98,107.19 214.48,107.1 214.59,106.95 214.99,106.88 215.15,106.99 215.55,106.92 215.66,106.76 216.06,106.69 216.22,106.8 216.61,106.73 216.72,106.57 217.12,106.5 217.28,106.61 217.68,106.54 217.79,106.38 218.19,106.31 218.35,106.42 218.74,106.35 218.86,106.19 219.25,106.12 219.41,106.23 219.81,106.16 219.92,106.01 220.32,105.94 220.48,106.05 220.88,105.98 220.99,105.82 221.38,105.75 221.54,105.86 221.94,105.79 222.05,105.63 222.45,105.56 222.61,105.67 223.01,105.6 223.12,105.44 223.52,105.37 223.67,105.48 224.07,105.41 224.18,105.25 224.58,105.18 224.74,105.3 225.14,105.23 225.25,105.07 225.65,105 225.81,105.11 229.87,104.39 233.31,101.98 233.71,101.4 233.71,99.99 arc(233.84,99.69) 234.13,99.57 234.5,99.57 arc(234.62,99.52) 234.67,99.4 234.67,95.63 234.51,95.47 234.38,95.4 234.2,95.46 J4.A61
  BOTTOM w0.135: U1.AC31 v4(75.36,95.13)
PE_SLOT4_RX_DN<11>: length 185.2
  IN3 w0.089: 76.02,97.09 76.02,97.07 75.98,97.02 75.98,94.9 76.15,94.73 76.28,94.73 76.36,94.81 v4(76.36,95.13)
  IN3 w0.135: J4.A65 230.2,95.46 230.38,95.4 230.51,95.47 230.7,95.66 230.7,99.42 arc(230.66,99.53) 230.56,99.57 230.09,99.57 arc(229.79,99.69) 229.67,99.99 229.67,101.55 229.59,102.01 229.58,102.02 229.35,102.45 228.64,103.46 228.28,103.64 228.28,103.64 228.16,103.7 228.16,103.7 227.54,103.81 227.38,103.7 226.98,103.77 226.87,103.93 226.47,104 226.31,103.89 225.92,103.96 225.81,104.12 225.41,104.19 225.25,104.08 224.85,104.15 224.74,104.31 224.34,104.38 224.18,104.26 223.79,104.33 223.67,104.49 223.28,104.56 223.12,104.45 222.72,104.52 222.61,104.68 222.21,104.75 222.05,104.64 221.65,104.71 221.54,104.87 221.14,104.94 220.99,104.83 220.59,104.9 220.48,105.06 220.08,105.13 219.92,105.02 219.52,105.09 219.41,105.24 219.01,105.32 218.85,105.2 218.46,105.27 218.35,105.43 217.95,105.5 217.79,105.39 217.39,105.46 217.28,105.62 216.88,105.69 216.75,105.6 216.31,105.67 216.21,105.81 215.13,106 212.6,105.55 212.25,105.8 212.21,106.02 212.05,106.13 211.68,106.06 211.57,105.91 211.61,105.69 211.37,105.34 210.77,105.23 210.42,105.48 210.38,105.7 210.22,105.81 209.85,105.74 209.74,105.59 209.78,105.36 209.54,105.01 208.93,104.91 208.58,105.15 208.54,105.37 208.39,105.48 208.02,105.42 207.91,105.26 207.95,105.04 207.7,104.69 207.1,104.58 206.75,104.83 206.71,105.05 206.56,105.16 206.19,105.09 206.08,104.94 206.12,104.72 205.87,104.37 205.27,104.26 204.92,104.51 204.88,104.73 204.72,104.84 204.35,104.77 204.25,104.61 204.28,104.39 204.04,104.04 201.42,103.58 191.73,96.8 173.48,93.58 130.33,101.19 130.27,101.2 122.46,106.67 111.74,108.56 107.9,107.88 105.42,108.32 100.19,107.39 92.96,108.67 82.24,106.78 81.53,106.9 81.36,106.87 81.19,106.84 80.85,106.78 80.85,106.78 80.72,106.6 80.32,106.53 80.15,106.66 79.54,106.55 79.35,106.42 79.1,106.07 78.92,105.02 78.42,104.31 77.74,103.83 77.21,103.07 77.25,102.86 77.01,102.53 76.8,102.49 76.54,102.11 76.07,99.44 76.02,99.21 76.02,97.09
  BOTTOM w0.135: U1.AB31 v4(76.36,95.13)
PE_SLOT4_RX_DN<12>: length 174.7
  IN3 w0.089: v4(77.36,95.13) 77.36,94.81 77.28,94.73 77.15,94.73 76.96,94.91 76.96,96.95 77.01,97 77.01,97.02
  IN3 w0.135: J4.A69 226.2,95.46 226.38,95.4 226.51,95.47 226.69,95.64 226.69,99.41 arc(226.64,99.52) 226.53,99.57 226.12,99.57 arc(225.82,99.69) 225.7,99.99 225.7,102.08 225.05,103.01 224.21,103.6 223.27,103.76 223.11,103.65 222.71,103.72 222.6,103.88 222.2,103.95 222.04,103.84 221.65,103.91 221.54,104.07 221.14,104.14 220.98,104.03 220.58,104.1 220.47,104.26 220.07,104.33 219.91,104.22 219.52,104.29 219.4,104.45 219.01,104.52 218.85,104.4 218.45,104.48 218.34,104.63 217.94,104.7 217.78,104.59 217.38,104.66 217.27,104.82 216.88,104.89 216.72,104.78 216.32,104.85 216.21,105.01 215.81,105.08 215.65,104.97 215.25,105.04 215.14,105.2 214.74,105.27 201.74,102.98 192.01,96.17 173.53,92.91 130.01,100.58 122.2,106.05 111.74,107.9 107.88,107.22 105.41,107.65 100.19,106.73 93.04,107.99 85.41,106.64 85.3,106.48 84.9,106.41 84.74,106.53 84.34,106.46 84.23,106.3 83.84,106.23 83.68,106.34 83.28,106.27 83.17,106.11 82.77,106.04 82.61,106.15 82.21,106.08 81.23,105.39 80.35,104.14 79.67,103.66 78.65,102.2 78.68,101.98 78.45,101.65 78.24,101.61 78.01,101.28 78.05,101.07 77.81,100.74 77.6,100.7 77.24,100.18 77.01,98.91 77.01,97.02
  BOTTOM w0.135: U1.AA31 v4(77.36,95.13)
PE_SLOT4_RX_DN<13>: length 172.4
  IN3 w0.089: v4(78.36,95.13) 78.36,94.81 78.28,94.73 78.15,94.73 77.96,94.92 77.96,96.82 78.01,96.87 78.01,96.89
  IN3 w0.135: 78.01,96.89 78.01,98.19 78.13,98.92 78.5,99.44 78.73,99.77 78.94,99.81 79.18,100.14 79.14,100.35 79.37,100.68 79.58,100.72 79.81,101.05 79.78,101.27 80.01,101.6 80.22,101.63 80.45,101.96 80.42,102.18 81.25,103.37 82.32,104.12 83.99,104.42 84.32,104.65 84.54,104.61 84.87,104.84 84.91,105.05 85.24,105.29 85.45,105.25 85.78,105.48 85.82,105.69 86.51,106.18 93.05,107.33 100.19,106.07 105.42,106.99 107.88,106.56 111.74,107.24 121.89,105.45 129.69,99.98 173.58,92.24 192.53,95.59 202.19,102.36 205.04,102.86 205.2,102.75 205.6,102.82 205.71,102.98 206.11,103.05 206.27,102.94 206.67,103.01 206.78,103.16 207.17,103.23 207.33,103.12 207.73,103.19 207.84,103.35 208.24,103.42 208.4,103.31 208.8,103.38 208.91,103.54 209.31,103.61 209.46,103.5 209.86,103.57 209.97,103.73 210.37,103.8 210.53,103.69 210.93,103.76 211.04,103.92 211.44,103.99 211.6,103.88 211.99,103.95 212.1,104.1 212.5,104.17 212.66,104.06 213.06,104.13 213.17,104.29 214.06,104.45 216.95,103.94 217.06,103.78 216.97,103.26 217.23,102.9 217.83,102.79 218,102.91 218.17,103.03 218.26,103.57 218.42,103.68 218.69,103.63 219.3,103.2 219.34,103.02 218.72,102.13 218.79,101.71 219.29,101.36 219.73,101.43 220.34,102.32 220.88,102.41 221.37,102.07 221.7,101.6 221.7,100.03 arc(221.83,99.7) 222.16,99.57 222.59,99.57 arc(222.7,99.52) 222.75,99.41 222.75,95.7 222.51,95.47 222.38,95.4 222.2,95.46 J4.A73
  BOTTOM w0.135: U1.Y31 v4(78.36,95.13)
PE_SLOT4_RX_DN<14>: length 162.4
  IN3 w0.089: 79.01,96.79 79.01,96.77 78.96,96.72 78.96,94.92 79.15,94.73 79.28,94.73 79.36,94.81 v4(79.36,95.13)
  IN3 w0.135: 79.01,96.79 79.01,97.36 79.19,98.38 79.41,98.7 79.62,98.73 79.85,99.06 79.82,99.28 80.05,99.61 80.26,99.65 80.49,99.98 80.45,100.19 80.69,100.52 80.9,100.56 81.13,100.89 81.09,101.1 81.35,101.47 82.61,102.35 83.25,103.26 83.54,103.47 84.6,103.66 84.93,103.89 85.15,103.85 85.48,104.08 85.51,104.3 85.85,104.53 86.06,104.49 86.39,104.72 86.43,104.94 87.14,105.44 93.58,106.57 100.18,105.41 105.42,106.33 107.88,105.9 111.69,106.57 121.59,104.82 129.4,99.36 173.56,91.57 192.77,94.96 196.68,97.7 196.87,97.67 197.2,97.9 197.24,98.09 197.57,98.32 197.76,98.29 198.09,98.52 198.12,98.71 198.46,98.94 198.65,98.91 198.98,99.14 199.01,99.33 199.34,99.56 199.53,99.53 199.86,99.76 199.9,99.95 200.23,100.18 200.42,100.15 200.75,100.38 200.78,100.57 201.11,100.8 201.31,100.77 201.64,101 201.67,101.19 202,101.43 212.07,103.2 212.23,103.09 212.63,103.16 212.74,103.32 213.14,103.39 213.3,103.28 213.7,103.35 213.81,103.51 214.26,103.59 215.4,103.39 215.77,103.12 215.81,102.93 216.14,102.7 216.33,102.73 217.4,101.98 217.68,101.59 217.68,99.99 arc(217.8,99.69) 218.1,99.57 218.54,99.57 arc(218.63,99.53) 218.67,99.43 218.67,95.63 218.51,95.47 218.38,95.4 218.2,95.46 J4.A77
  BOTTOM w0.135: U1.W31 v4(79.36,95.13)
PE_SLOT4_RX_DN<15>: length 160.8
  IN3 w0.089: v4(80.36,95.13) 80.36,94.81 80.28,94.73 80.15,94.73 79.97,94.91 79.97,96.85 80.02,96.89 80.02,96.92
  IN3 w0.135: J4.A81 214.2,95.46 214.38,95.4 214.55,95.49 214.66,95.59 214.66,99.31 arc(214.6,99.44) 214.48,99.49 214.06,99.49 arc(213.76,99.62) 213.64,99.91 213.64,101.27 213.28,101.78 212.73,102.17 211.35,102.41 210.94,102.34 210.94,102.34 210.82,102.16 210.42,102.09 210.25,102.22 209.85,102.15 209.72,101.97 209.33,101.9 209.15,102.02 208.75,101.95 208.63,101.78 208.23,101.71 208.05,101.83 207.65,101.76 207.53,101.58 207.13,101.51 206.95,101.64 206.56,101.57 206.43,101.39 206.03,101.32 205.86,101.44 205.46,101.37 205.34,101.2 204.94,101.13 204.76,101.25 202.62,100.87 202.29,100.64 202.26,100.45 201.93,100.22 201.74,100.25 201.41,100.02 201.37,99.83 201.04,99.6 200.85,99.63 200.52,99.4 200.49,99.21 200.16,98.98 199.96,99.01 199.63,98.78 199.6,98.59 199.27,98.36 199.08,98.39 198.75,98.16 198.71,97.97 198.38,97.74 198.19,97.77 197.42,97.24 197.39,97.04 197.95,96.23 197.88,95.81 197.37,95.46 196.95,95.53 196.39,96.34 196.2,96.37 195.9,96.16 195.86,95.97 196.43,95.16 196.35,94.74 195.85,94.39 195.43,94.47 194.87,95.27 194.68,95.3 193.38,94.4 173.57,90.9 129.14,98.74 121.34,104.2 111.69,105.91 107.88,105.24 105.42,105.67 100.18,104.75 93.73,105.89 88,104.88 81.83,100.55 81.38,99.92 81.42,99.7 81.19,99.37 80.97,99.34 80.74,99 80.78,98.79 80.55,98.46 80.33,98.42 80.1,98.09 80.02,97.61 80.02,96.92
  BOTTOM w0.135: U1.V31 v4(80.36,95.13)
PE_SLOT4_RX_DP<0>: length 260.3
  IN3 w0.089: v4(68.36,91.13) 68.05,91.13 67.96,91.04 67.96,90.81 67.7,90.55 63.83,90.55 63.78,90.5 63.76,90.5
  IN3 w0.135: 63.76,90.5 63.34,90.5 63.29,90.51 63,90.58 62.94,90.59 61.64,91.45 60.51,93.08 59.88,96.62 60.38,99.42 60.19,100.5 60.76,103.74 64.42,108.97 69.52,112.54 81.54,114.66 82.15,114.55 82.67,114.46 92.83,116.26 100.15,114.96 105.39,115.89 107.91,115.44 111.75,116.12 125.39,113.71 133.12,108.3 172.71,101.32 187.08,103.86 198.01,111.52 215.42,114.59 226.96,112.55 231.16,113.29 246.18,110.65 250.12,111.34 266.59,108.44 267.06,108.11 267.41,107.61 267.74,105.76 268.01,105.37 269.16,104.56 270.08,104.4 270.08,104.4 275.59,103.42 277.67,101.97 277.96,101.55 277.96,99.98 arc(278,99.89) 278.1,99.85 278.37,99.85 arc(278.79,99.67) 278.97,99.25 278.97,95.52 278.68,95.23 278.51,95.15 278.51,95.15 278.45,94.97 J4.A16
  BOTTOM w0.135: U1.AK27 v4(68.36,91.13)
PE_SLOT4_RX_DP<1>: length 260.6
  IN3 w0.089: v4(68.36,92.13) 68.05,92.13 67.96,92.04 67.96,91.84 67.66,91.54 63.78,91.54 63.73,91.49 63.71,91.49
  IN3 w0.135: J4.A21 273.45,95.46 273.27,95.4 273.1,95.49 272.96,95.63 272.96,99.38 arc(273.01,99.49) 273.12,99.54 273.55,99.54 arc(273.85,99.67) 273.98,99.96 273.98,101.51 arc(273.97,101.55) 273.96,101.58 273.62,102.06 272.55,102.81 266.55,103.87 264.49,105.31 264.04,105.95 263.77,107.48 263.4,108.01 262.8,108.43 250.42,110.61 243.98,109.47 242.79,109.69 242.68,109.84 242.74,110.17 242.49,110.52 241.89,110.63 241.54,110.38 241.48,110.05 241.32,109.94 240.95,110.01 240.85,110.16 240.9,110.49 240.66,110.84 240.05,110.95 239.7,110.7 239.65,110.38 239.49,110.27 239.12,110.33 239.01,110.49 239.07,110.82 238.83,111.17 238.22,111.27 237.87,111.03 237.81,110.7 237.66,110.59 237.29,110.66 237.18,110.81 237.24,111.14 236.99,111.49 236.39,111.6 236.04,111.35 235.98,111.02 235.83,110.91 235.46,110.98 235.35,111.13 235.41,111.46 235.16,111.81 234.56,111.92 234.21,111.67 234.15,111.35 233.99,111.24 233.63,111.3 233.52,111.46 233.57,111.79 233.33,112.14 232.72,112.24 232.37,112 232.32,111.67 232.16,111.56 231.79,111.63 231.68,111.78 231.74,112.11 231.5,112.46 230.89,112.57 230.54,112.32 230.48,111.99 230.32,111.87 229.59,112 227.95,111.71 215.42,113.92 206.85,112.41 204.72,112.04 198.27,110.9 187.31,103.23 172.74,100.66 132.87,107.68 125.14,113.1 111.75,115.46 107.91,114.78 105.39,115.23 100.16,114.3 92.94,115.58 87.24,114.57 87.24,114.57 82.72,113.77 82.17,113.87 81.53,113.98 69.78,111.91 65.17,108.68 61.55,103.51 60.99,100.34 61.2,99.16 60.74,96.56 61.27,93.57 62.35,92.02 62.98,91.58 63.2,91.55 63.58,91.49 63.71,91.49
  BOTTOM w0.135: U1.AK28 v4(68.36,92.13)
PE_SLOT4_RX_DP<2>: length 246.5
  IN3 w0.089: 63.69,92.5 63.71,92.5 63.76,92.55 67.67,92.55 67.96,92.84 67.96,93.04 68.05,93.13 v4(68.36,93.13)
  IN3 w0.135: J4.A25 269.45,95.46 269.27,95.4 269.1,95.49 268.94,95.65 268.94,99.36 arc(269,99.51) 269.15,99.57 269.54,99.57 arc(269.84,99.69) 269.97,99.99 269.97,101.6 269.63,102.08 269.14,102.43 263.53,103.42 260.41,105.6 260.08,106.06 259.82,107.54 259.52,107.98 259.01,108.33 250.37,109.85 244.23,108.77 229.58,111.34 227.95,111.05 215.63,113.23 198.43,110.2 187.49,102.54 183.99,101.92 183.99,101.92 172.91,99.96 132.62,107.07 124.89,112.48 111.74,114.8 107.9,114.12 105.39,114.56 100.16,113.64 92.96,114.91 82.69,113.1 81.53,113.3 70.37,111.33 65.96,108.25 62.37,103.12 61.77,99.75 61.96,98.7 61.59,96.61 62.08,93.85 62.45,93.32 62.8,92.82 63.17,92.56 63.2,92.56 63.53,92.5 63.69,92.5
  BOTTOM w0.135: U1.AK29 v4(68.36,93.13)
PE_SLOT4_RX_DP<3>: length 244.2
  IN3 w0.089: v4(68.36,94.13) 68.05,94.13 67.96,94.04 67.96,93.84 67.67,93.55 63.86,93.55 63.82,93.5 63.79,93.5
  IN3 w0.135: J4.A29 265.45,95.46 265.27,95.4 265.1,95.49 264.95,95.64 264.95,99.35 arc(264.77,99.78) 264.34,99.96 264.21,99.96 arc(264.05,100.02) 263.99,100.17 263.99,101.47 263.91,101.94 263.62,102.35 261.66,103.72 260.74,103.89 260.74,103.89 258.21,104.33 256.49,105.54 255.75,106.58 255.58,107.55 255.25,108.03 254.72,108.4 250.3,109.18 244.18,108.1 229.72,110.63 227.83,110.29 215.51,112.47 200.49,109.82 200.26,109.66 200.09,109.54 200.08,109.54 199.73,109.29 199.71,109.27 198.97,108.76 198.79,108.79 198.57,109.1 198.15,109.17 197.65,108.82 197.57,108.4 197.79,108.09 197.76,107.9 197.45,107.69 197.26,107.72 197.05,108.03 196.63,108.1 196.12,107.75 196.05,107.33 196.26,107.02 196.23,106.84 195.93,106.62 195.74,106.66 195.52,106.96 195.1,107.04 194.6,106.69 194.52,106.26 194.74,105.96 194.71,105.77 194.4,105.55 194.21,105.59 194,105.9 193.58,105.97 193.07,105.62 193,105.2 193.22,104.89 193.18,104.7 192.88,104.49 192.69,104.52 192.47,104.83 192.05,104.9 191.55,104.55 191.48,104.13 191.69,103.82 191.66,103.64 191.35,103.42 191.17,103.45 190.95,103.76 190.53,103.84 190.03,103.48 189.95,103.06 190.17,102.76 190.13,102.57 189.65,102.23 172.99,99.29 132.37,106.45 124.63,111.86 111.74,114.14 107.9,113.46 105.39,113.9 100.16,112.98 92.97,114.25 87.22,113.24 82.65,112.43 82.17,112.51 81.59,112.62 70.6,110.68 66.98,108.14 65.87,106.55 65.42,104.02 63.29,100.98 62.51,96.56 62.84,94.68 62.84,94.68 62.96,94.05 63.19,93.71 63.2,93.71 63.49,93.5 63.79,93.5
  BOTTOM w0.135: U1.AK30 v4(68.36,94.13)
PE_SLOT4_RX_DP<4>: length 227
  IN3 w0.089: 68.73,98.67 68.73,98.64 68.78,98.6 68.78,94.83 69.07,94.54 69.28,94.54 69.36,94.45 v4(69.36,94.13)
  IN3 w0.135: J4.A35 259.45,95.46 259.27,95.4 259.1,95.49 258.95,95.64 258.95,99.43 arc(258.99,99.53) 259.09,99.57 259.54,99.57 arc(259.84,99.69) 259.97,99.99 259.97,101.46 259.45,102.2 258.96,102.68 258.29,103.16 254.52,103.82 252.72,105.08 252.03,106.06 251.8,107.41 251.47,107.88 250.84,108.32 250.1,108.45 244.13,107.39 229.71,109.94 227.73,109.59 215.33,111.77 200.75,109.2 189.79,101.53 173.14,98.6 132.11,105.83 124.37,111.25 111.74,113.48 107.9,112.8 105.39,113.24 100.16,112.32 92.96,113.59 82.59,111.76 82.14,111.84 81.58,111.94 70.87,110.05 67.71,107.83 66.53,106.15 66.02,103.28 66.3,101.67 67.26,100.3 68.46,99.46 68.48,99.44 68.67,99.17 68.73,98.83 68.73,98.67
  BOTTOM w0.135: U1.AJ30 v4(69.36,94.13)
PE_SLOT4_RX_DP<5>: length 224.5
  IN3 w0.089: 69.71,98.9 69.71,98.88 69.76,98.83 69.76,94.84 70.07,94.54 70.28,94.54 70.36,94.45 v4(70.36,94.13)
  IN3 w0.135: 69.71,98.9 69.71,99.01 69.66,99.31 69.57,99.44 69.37,99.72 67.72,100.87 66.96,101.96 66.8,102.84 67.39,106.19 67.8,106.77 71.76,109.54 81.54,111.27 82.54,111.09 92.96,112.93 100.16,111.66 105.39,112.58 107.9,112.14 111.74,112.81 124.12,110.63 131.87,105.21 173.15,97.93 190.29,100.96 201.24,108.63 215.34,111.11 227.73,108.93 229.71,109.28 244.15,106.73 245.86,107.03 246.32,106.95 246.71,106.68 247.33,105.79 247.56,105.63 247.75,105.67 247.87,105.85 248.29,105.93 248.8,105.58 248.87,105.16 248.75,104.97 248.78,104.79 248.93,104.68 249.09,104.57 249.23,104.6 249.99,105.68 250.41,105.75 250.91,105.4 250.99,104.94 250.3,103.95 250.34,103.73 250.82,103.39 255.3,102.6 255.74,102.29 255.95,102 255.95,99.99 arc(255.82,99.69) 255.53,99.57 255.14,99.57 arc(255.02,99.52) 254.97,99.4 254.97,95.62 255.1,95.49 255.27,95.4 255.45,95.46 J4.A39
  BOTTOM w0.135: U1.AH30 v4(70.36,94.13)
PE_SLOT4_RX_DP<6>: length 214.5
  IN3 w0.089: 70.71,99.05 70.71,99.03 70.76,98.98 70.76,94.85 71.07,94.54 71.28,94.54 71.36,94.45 v4(71.36,94.13)
  IN3 w0.135: J4.A43 251.45,95.46 251.27,95.4 251.1,95.49 250.95,95.64 250.95,99.41 arc(251,99.52) 251.11,99.57 251.54,99.57 arc(251.84,99.69) 251.96,99.99 251.96,101.58 251.5,102.05 246.29,105.69 229.71,108.61 227.61,108.24 215.21,110.43 201.49,108.01 190.47,100.29 173.21,97.25 131.62,104.58 123.86,110.02 111.74,112.15 107.9,111.48 105.39,111.92 100.16,111 92.96,112.27 82.49,110.42 81.53,110.59 73.81,109.23 70.2,106.7 68.55,104.35 68,103.96 67.63,103.43 67.54,102.94 67.65,102.3 68.24,101.47 68.28,101.44 68.28,101.44 70.32,100.01 70.64,99.55 70.66,99.44 70.71,99.19 70.71,99.05
  BOTTOM w0.135: U1.AG30 v4(71.36,94.13)
PE_SLOT4_RX_DP<7>: length 213.9
  IN3 w0.089: 71.72,98.95 71.72,98.93 71.77,98.88 71.77,94.84 72.07,94.54 72.28,94.54 72.36,94.45 v4(72.36,94.13)
  IN3 w0.135: J4.A47 247.45,95.46 247.27,95.4 247.1,95.49 246.99,95.6 246.99,99.43 arc(246.84,99.78) 246.49,99.93 246.14,99.93 arc(246.02,99.98) 245.98,100.1 245.98,101.35 245.84,102.12 245.2,103.03 242.81,104.7 240.49,105.11 240.38,105.27 240.47,105.72 240.22,106.08 239.62,106.18 239.27,105.94 239.18,105.48 239.03,105.37 238.66,105.44 238.55,105.59 238.63,106.05 238.39,106.4 237.78,106.51 237.43,106.26 237.35,105.8 237.2,105.69 236.83,105.76 236.72,105.92 236.8,106.37 236.55,106.72 235.95,106.83 235.6,106.58 235.52,106.13 235.36,106.02 235,106.08 234.89,106.24 234.97,106.7 234.72,107.05 234.12,107.15 233.77,106.91 233.69,106.45 233.53,106.34 233.16,106.41 233.05,106.56 233.14,107.02 232.89,107.37 232.29,107.48 231.94,107.23 231.86,106.77 231.7,106.67 231.33,106.73 231.22,106.89 231.3,107.34 231.06,107.69 230.45,107.8 230.1,107.56 230.02,107.1 229.87,106.99 214.75,109.65 201.69,107.35 190.73,99.68 173.22,96.59 131.37,103.96 123.61,109.4 111.74,111.49 107.9,110.82 105.39,111.26 100.15,110.34 92.96,111.61 82.44,109.75 81.53,109.91 74.85,108.73 72.09,106.8 70.47,104.49 69.68,103.93 69.35,103.46 69.25,102.93 69.39,102.14 70.07,101.18 70.81,100.66 71.66,99.44 71.72,99.35 71.72,98.95
  BOTTOM w0.135: U1.AF30 v4(72.36,94.13)
PE_SLOT4_RX_DP<8>: length 199.8
  IN3 w0.089: 72.72,98.92 72.72,98.9 72.76,98.85 72.76,94.84 73.07,94.54 73.28,94.54 73.36,94.45 v4(73.36,94.13)
  IN3 w0.135: 72.72,98.92 72.72,99.52 72.64,99.94 71.32,101.84 71.17,102.66 71.31,103.48 71.6,103.89 72.42,104.46 72.92,105.17 73.1,106.22 73.29,106.49 75.75,108.21 75.82,108.22 81.58,109.24 82.44,109.09 92.95,110.94 100.15,109.67 105.39,110.6 107.9,110.16 111.74,110.83 123.35,108.78 131.11,103.35 173.18,95.91 190.98,99.06 201.89,106.7 214.74,108.97 223.57,107.41 227.32,106.75 227.32,106.75 228.62,106.52 237.88,104.89 241.35,102.46 241.86,101.73 241.98,101.05 241.98,99.99 arc(242.02,99.89) 242.11,99.86 242.54,99.86 arc(242.84,99.73) 242.96,99.43 242.96,95.51 242.68,95.23 242.51,95.15 242.51,95.15 242.45,94.97 J4.A52
  BOTTOM w0.135: U1.AE30 v4(73.36,94.13)
PE_SLOT4_RX_DP<9>: length 197.5
  IN3 w0.089: 73.73,97.15 73.73,97.12 73.78,97.07 73.78,94.83 74.07,94.54 74.28,94.54 74.36,94.45 v4(74.36,94.13)
  IN3 w0.135: 73.73,97.15 73.73,97.69 73.84,98.3 73.18,102.06 73.1,102.51 73.31,103.74 73.48,103.98 74.87,104.96 75.09,106.22 75.43,106.7 76.91,107.74 76.98,107.75 81.53,108.55 82.33,108.41 92.95,110.28 100.15,109.01 105.39,109.94 107.9,109.5 111.73,110.17 123.09,108.17 130.9,102.71 173.18,95.25 191.32,98.46 202.18,106.06 214.38,108.21 222.05,106.86 224.73,106.39 224.73,106.39 225.25,106.3 232.47,105.02 232.71,104.67 232.6,104.03 232.71,103.88 233.08,103.81 233.23,103.92 233.35,104.56 233.7,104.81 234.3,104.7 234.54,104.35 234.43,103.71 234.54,103.55 234.91,103.49 235.06,103.6 235.18,104.24 235.53,104.48 236.73,104.27 237.3,103.87 237.78,103.18 237.99,102.01 237.99,99.99 arc(238.03,99.89) 238.13,99.86 238.55,99.86 arc(238.85,99.73) 238.97,99.43 238.97,95.52 238.68,95.23 238.51,95.15 238.51,95.15 238.45,94.97 J4.A56
  BOTTOM w0.135: U1.AD30 v4(74.36,94.13)
PE_SLOT4_RX_DP<10>: length 187
  IN3 w0.089: v4(75.36,94.13) 75.36,94.45 75.28,94.54 75.07,94.54 74.77,94.84 74.77,96.95 74.72,97 74.72,97.02
  IN3 w0.135: J4.A60 234.45,94.97 234.51,95.15 234.51,95.15 234.68,95.23 234.96,95.51 234.96,99.4 arc(234.83,99.72) 234.5,99.86 234.13,99.86 arc(234.04,99.89) 234,99.99 234,101.49 233.51,102.19 229.98,104.66 213.98,107.48 202.44,105.45 191.42,97.73 173.39,94.55 130.64,102.09 122.84,107.55 111.74,109.51 107.9,108.83 105.38,109.28 100.15,108.35 92.95,109.62 82.29,107.74 81.53,107.87 78.19,107.28 78.12,107.27 77.42,106.78 77.01,106.19 76.83,105.19 76.41,104.6 75.83,104.19 75.23,103.32 74.72,100.44 74.72,97.02
  BOTTOM w0.135: U1.AC30 v4(75.36,94.13)
PE_SLOT4_RX_DP<11>: length 185.3
  IN3 w0.089: 75.74,97.09 75.74,97.07 75.79,97.02 75.79,94.82 76.07,94.54 76.28,94.54 76.36,94.45 v4(76.36,94.13)
  IN3 w0.135: 75.74,97.09 75.74,99.23 75.77,99.44 76.27,102.23 77.54,104.04 78.22,104.52 78.65,105.13 78.83,106.18 79.15,106.62 79.43,106.83 80.8,107.07 80.8,107.07 81.53,107.2 82.24,107.07 92.96,108.96 100.19,107.69 105.42,108.61 107.9,108.17 111.74,108.85 122.57,106.94 130.38,101.47 173.48,93.87 191.61,97.07 201.3,103.86 203.87,104.31 203.98,104.46 203.94,104.68 204.19,105.03 204.79,105.14 205.14,104.89 205.18,104.67 205.34,104.56 205.7,104.63 205.81,104.79 205.77,105.01 206.02,105.36 206.62,105.46 206.97,105.22 207.01,105 207.17,104.89 207.54,104.95 207.65,105.11 207.61,105.33 207.85,105.68 208.46,105.79 208.81,105.54 208.84,105.32 209,105.21 209.37,105.28 209.48,105.43 209.44,105.65 209.68,106 210.29,106.11 210.64,105.86 210.68,105.64 210.83,105.53 211.2,105.6 211.31,105.76 211.27,105.98 211.52,106.33 212.12,106.43 212.47,106.19 212.51,105.97 212.67,105.86 215.13,106.29 228.25,103.98 228.3,103.96 228.3,103.96 228.83,103.69 229.59,102.6 229.86,102.12 229.96,101.57 229.96,99.99 arc(230,99.89) 230.09,99.86 230.56,99.86 arc(230.86,99.73) 230.99,99.42 230.99,95.54 230.68,95.23 230.51,95.15 230.51,95.15 230.45,94.97 J4.A64
  BOTTOM w0.135: U1.AB30 v4(76.36,94.13)
PE_SLOT4_RX_DP<12>: length 174.8
  IN3 w0.089: v4(77.36,94.13) 77.36,94.45 77.28,94.54 77.07,94.54 76.77,94.83 76.77,96.95 76.73,97 76.73,97.02
  IN3 w0.135: 76.73,97.02 76.73,98.94 76.81,99.44 76.96,100.29 79.47,103.87 80.15,104.35 80.56,104.93 81.03,105.6 81.07,105.63 82.1,106.35 93.04,108.28 100.19,107.02 105.41,107.95 107.88,107.51 111.74,108.19 122.31,106.32 130.13,100.85 173.53,93.2 191.9,96.44 201.63,103.25 214.74,105.56 224.32,103.87 225.26,103.21 225.99,102.17 225.99,99.99 arc(226.03,99.89) 226.12,99.86 226.53,99.86 arc(226.85,99.72) 226.98,99.41 226.98,95.53 226.68,95.23 226.51,95.15 226.51,95.15 226.45,94.97 J4.A68
  BOTTOM w0.135: U1.AA30 v4(77.36,94.13)
PE_SLOT4_RX_DP<13>: length 172.4
  IN3 w0.089: 77.72,96.89 77.72,96.87 77.77,96.82 77.77,94.84 78.07,94.54 78.28,94.54 78.36,94.45 v4(78.36,94.13)
  IN3 w0.135: J4.A72 222.45,94.97 222.51,95.15 222.51,95.15 222.68,95.23 223.04,95.59 223.04,99.41 arc(222.91,99.73) 222.59,99.86 222.16,99.86 arc(222.04,99.91) 221.99,100.03 221.99,101.69 221.57,102.28 220.95,102.72 220.18,102.58 219.56,101.7 219.36,101.66 219.05,101.88 219.02,102.06 219.64,102.95 219.57,103.37 218.8,103.91 218.35,103.99 218,103.74 217.9,103.2 217.76,103.1 217.39,103.16 217.27,103.33 217.37,103.85 217.12,104.2 214.06,104.74 202.08,102.63 192.41,95.86 173.58,92.53 129.8,100.25 122,105.72 111.74,107.53 107.88,106.85 105.42,107.28 100.19,106.36 93.05,107.62 86.39,106.45 85.53,105.84 83.88,104.69 82.21,104.39 81.04,103.58 78.15,99.44 77.86,99.03 77.72,98.22 77.72,96.89
  BOTTOM w0.135: U1.Y30 v4(78.36,94.13)
PE_SLOT4_RX_DP<14>: length 162.3
  IN3 w0.089: v4(79.36,94.13) 79.36,94.45 79.28,94.54 79.07,94.54 78.77,94.84 78.77,96.72 78.72,96.77 78.72,96.79
  IN3 w0.135: 78.72,96.79 78.72,97.39 78.91,98.49 81.15,101.68 82.4,102.56 82.41,102.57 83.04,103.47 83.43,103.74 84.49,103.93 86.26,105.17 87.03,105.71 93.58,106.87 100.18,105.7 105.42,106.62 107.88,106.19 111.69,106.86 121.7,105.1 129.51,99.63 173.56,91.86 192.66,95.23 201.89,101.7 214.26,103.88 215.51,103.66 217.61,102.19 217.97,101.68 217.97,99.99 arc(218.01,99.89) 218.1,99.86 218.54,99.86 arc(218.83,99.73) 218.96,99.43 218.96,95.51 218.68,95.23 218.51,95.15 218.51,95.15 218.45,94.97 J4.A76
  BOTTOM w0.135: U1.W30 v4(79.36,94.13)
PE_SLOT4_RX_DP<15>: length 160.8
  IN3 w0.089: 79.73,96.92 79.73,96.89 79.78,96.85 79.78,94.83 80.07,94.54 80.28,94.54 80.36,94.45 v4(80.36,94.13)
  IN3 w0.135: 79.73,96.92 79.73,97.64 79.83,98.21 80.7,99.44 81.62,100.76 81.63,100.78 81.68,100.8 87.89,105.15 87.95,105.16 93.73,106.18 100.18,105.04 105.42,105.96 107.88,105.53 111.69,106.2 121.45,104.48 129.25,99.01 173.57,91.2 193.27,94.67 194.61,95.61 195.03,95.53 195.31,95.13 195.6,94.73 195.78,94.69 196.09,94.91 196.12,95.1 195.56,95.9 195.64,96.32 196.14,96.67 196.56,96.6 197.12,95.79 197.31,95.76 197.62,95.98 197.65,96.16 197.09,96.97 197.16,97.4 202.51,101.15 204.73,101.54 211.35,102.7 212.84,102.44 213.49,101.99 213.93,101.36 213.93,99.91 arc(213.97,99.82) 214.06,99.78 214.48,99.78 arc(214.81,99.64) 214.94,99.31 214.94,95.47 214.72,95.25 214.51,95.15 214.45,94.97 J4.A80
  BOTTOM w0.135: U1.V30 v4(80.36,94.13)
PE_SLOT4_TX_C_DN<0>: length 243.4
  IN1 w0.089: 63.25,90.85 63.27,90.84 63.31,90.78 63.62,90.73 64.58,90.73 64.77,90.92 64.77,91.04 64.68,91.13 v4(64.36,91.13)
  IN1 w0.122: v1(275.03,106.93) 275.39,107.29 275.39,107.82 275.16,108.14 270.83,111.17 270.24,111.27 270.06,111.15 269.7,111.21 269.57,111.39 269.21,111.45 269.04,111.33 268.68,111.39 268.55,111.57 268.19,111.64 268.01,111.51 267.65,111.57 267.53,111.75 267.17,111.82 266.99,111.69 266.63,111.75 266.51,111.93 266.15,112 265.97,111.87 265.61,111.93 265.49,112.11 250.07,114.83 212.85,108.27 212.84,108.27 175.52,101.69 148.9,106.38 148.85,106.39 140.35,107.89 134,106.77 87.75,114.93 70.05,111.8 65.65,108.76 64,107.52 60.94,103.15 60.68,101.66 60.8,101.48 60.74,101.12 60.56,101 60.5,100.64 60.62,100.46 60.56,100.1 60.38,99.97 60.32,99.61 60.44,99.44 60.38,99.08 60.2,98.95 60.12,98.48 60.27,97.61 60.45,97.49 60.51,97.13 60.39,96.95 60.45,96.59 60.63,96.46 60.69,96.1 60.57,95.93 60.63,95.57 60.81,95.44 60.87,95.08 60.75,94.91 60.81,94.54 60.99,94.42 61.05,94.06 60.93,93.88 60.99,93.52 61.17,93.4 61.23,93.04 61.11,92.86 61.21,92.32 61.95,91.25 62.29,91.01 63.2,90.85 63.25,90.85
  BOTTOM w0.135: U1.AP27 v4(64.36,91.13) ; v1(275.03,106.93) 275.39,106.58 275.39,105.78 C51.1
PE_SLOT4_TX_C_DN<1>: length 243.7
  IN1 w0.089: 63.23,91.81 63.25,91.81 63.3,91.75 63.58,91.72 64.55,91.72 64.77,91.94 64.77,92.04 64.68,92.13 v4(64.36,92.13)
  IN1 w0.122: 63.23,91.81 63.2,91.82 62.93,91.85 62.32,92.28 61.96,92.8 61.88,93.22 62.01,93.4 61.94,93.76 61.76,93.89 61.7,94.25 61.83,94.42 61.76,94.78 61.58,94.91 61.48,95.48 61.61,95.66 61.54,96.02 61.37,96.15 61.3,96.51 61.43,96.68 61.36,97.04 61.19,97.17 60.99,98.3 61.05,98.68 61.23,98.8 61.3,99.16 61.17,99.34 61.23,99.7 61.41,99.83 61.48,100.19 61.35,100.36 61.86,103.23 64.59,107.13 70.34,111.17 77.7,112.47 85.56,113.86 87.64,114.22 133.81,106.08 140.16,107.2 148.85,105.67 148.85,105.67 148.9,105.66 175.57,100.96 180.19,101.77 249.79,114.05 250.43,113.93 250.52,113.79 250.45,113.38 250.69,113.04 251.31,112.93 251.65,113.17 251.72,113.58 251.86,113.68 252.24,113.61 252.34,113.47 252.27,113.06 252.51,112.72 253.13,112.61 253.47,112.85 253.54,113.26 253.68,113.36 254.06,113.29 254.16,113.15 254.09,112.74 254.32,112.4 254.94,112.29 255.28,112.53 255.36,112.94 255.5,113.04 255.88,112.97 255.98,112.83 255.9,112.42 256.14,112.08 256.76,111.97 257.1,112.21 257.17,112.62 257.31,112.72 257.69,112.65 257.79,112.51 257.72,112.1 257.96,111.76 258.58,111.65 258.92,111.89 258.99,112.3 259.13,112.4 260.32,112.19 260.44,112.01 260.8,111.95 260.98,112.07 261.34,112.01 261.46,111.83 261.82,111.77 262,111.89 262.36,111.83 262.48,111.65 262.84,111.59 263.02,111.71 263.38,111.65 263.51,111.47 263.87,111.41 264.04,111.53 264.4,111.47 264.53,111.29 264.89,111.23 265.07,111.35 265.43,111.29 265.55,111.11 265.91,111.05 266.09,111.17 266.45,111.11 266.57,110.93 266.93,110.87 267.11,110.99 267.47,110.93 267.6,110.75 267.96,110.69 268.13,110.81 268.66,110.72 272.12,108.3 272.59,107.62 272.59,107.29 v1(272.24,106.93)
  BOTTOM w0.135: v1(272.24,106.93) 272.59,106.58 272.59,105.78 C52.1 ; U1.AP28 v4(64.36,92.13)
PE_SLOT4_TX_C_DN<2>: length 230.6
  IN1 w0.089: 63.44,93.09 63.45,93.08 63.44,93 63.61,92.76 63.74,92.74 64.58,92.74 64.72,92.88 64.76,93.06 64.68,93.13 v4(64.36,93.13)
  IN1 w0.122: v1(268.68,106.93) 269.04,107.29 269.04,107.73 268.82,108.04 266.94,109.36 265.96,109.53 265.79,109.41 265.43,109.47 265.3,109.65 264.94,109.71 264.76,109.59 264.4,109.65 264.28,109.83 263.92,109.89 263.74,109.77 263.38,109.83 263.26,110.01 262.9,110.07 262.72,109.95 262.36,110.01 262.24,110.19 261.88,110.25 261.7,110.13 261.34,110.19 261.21,110.37 260.85,110.43 260.68,110.31 260.32,110.37 260.19,110.55 259.83,110.61 259.65,110.49 259.29,110.55 259.17,110.73 258.81,110.79 258.63,110.67 258.27,110.73 258.15,110.91 257.79,110.97 257.61,110.85 257.25,110.91 257.13,111.09 247.03,112.87 175.49,100.25 140.17,106.49 133.9,105.38 87.66,113.54 79.17,112.04 79.17,112.04 70.68,110.54 65.27,106.76 62.97,103.47 62.75,102.25 62.88,102.07 62.81,101.71 62.63,101.59 62.57,101.23 62.7,101.05 62.63,100.69 62.45,100.56 62.39,100.2 62.51,100.03 62.45,99.67 62.27,99.54 62.21,99.18 62.33,99 62.27,98.64 62.09,98.52 61.99,97.92 62.64,94.23 63.44,93.09
  BOTTOM w0.135: v1(268.68,106.93) 269.04,106.58 269.04,105.78 C53.1 ; U1.AP29 v4(64.36,93.13)
PE_SLOT4_TX_C_DN<3>: length 229.1
  IN1 w0.089: 63.63,94.69 63.63,94.66 63.59,94.61 63.62,94.43 64.09,93.8 64.34,93.71 64.59,93.71 64.74,93.81 64.77,93.86 64.77,94.04 64.68,94.13 v4(64.36,94.13)
  IN1 w0.122: 63.63,94.69 63.54,95.21 63.66,95.38 63.6,95.74 63.42,95.87 63.2,97.14 63.69,99.93 63.83,100.03 64.58,99.9 64.92,100.13 65.03,100.75 64.79,101.09 64.04,101.23 63.94,101.37 64.11,102.3 64.59,102.99 64.76,103.02 66.14,102.06 66.55,102.13 66.91,102.64 66.84,103.05 65.46,104.02 65.43,104.18 65.83,104.76 66.05,104.8 66.26,105.1 66.22,105.31 66.43,105.61 66.65,105.65 66.85,105.95 66.82,106.17 67.71,107.45 68.38,107.92 68.6,107.88 68.9,108.09 68.93,108.3 69.23,108.51 69.45,108.48 69.75,108.69 69.78,108.9 71.28,109.95 87.61,112.83 133.73,104.7 140.08,105.82 148.9,104.27 175.61,99.56 246.51,112.09 246.75,112.11 254.06,110.82 254.18,110.64 254.54,110.58 254.72,110.7 255.08,110.64 255.21,110.46 255.57,110.4 255.74,110.52 256.1,110.46 256.23,110.28 256.59,110.22 256.77,110.34 257.13,110.28 257.25,110.1 257.61,110.04 257.79,110.16 258.15,110.1 258.27,109.92 258.63,109.86 258.81,109.98 259.17,109.92 259.29,109.74 259.65,109.68 259.83,109.8 260.19,109.74 260.32,109.56 260.68,109.5 260.85,109.62 261.21,109.56 261.34,109.38 261.7,109.32 261.88,109.44 263.79,109.1 265.19,108.13 265.48,107.71 265.48,107.29 v1(265.13,106.93)
  BOTTOM w0.135: U1.AP30 v4(64.36,94.13) ; C54.1 265.48,105.78 265.48,106.58 v1(265.13,106.93)
PE_SLOT4_TX_C_DN<4>: length 212.8
  IN1 w0.089: 69.01,99.22 69.01,99.2 68.96,99.15 68.96,97.94 69.16,97.75 69.3,97.75 69.36,97.81 v4(69.36,98.13)
  IN1 w0.122: v1(261.34,106.93) 261.7,107.29 261.7,107.73 261.34,108.24 260.51,108.82 258.74,109.15 258.56,109.03 258.2,109.09 258.08,109.27 257.72,109.34 257.54,109.21 257.18,109.28 257.06,109.46 256.7,109.52 256.52,109.4 256.16,109.47 256.04,109.65 255.68,109.71 255.5,109.59 255.14,109.66 255.02,109.83 254.66,109.9 254.48,109.78 254.12,109.84 254,110.02 253.64,110.09 253.46,109.97 253.1,110.03 252.98,110.21 252.62,110.28 252.44,110.15 252.08,110.22 251.95,110.4 251.59,110.47 251.42,110.34 251.06,110.41 250.93,110.59 246.65,111.38 175.6,98.86 148.9,103.56 148.85,103.57 139.94,105.14 133.59,104.02 87.55,112.14 71.91,109.38 70.91,108.68 70.87,108.47 70.57,108.26 70.36,108.3 69.98,108.03 69.98,108.03 69.13,107.43 69.09,107.22 68.79,107.01 68.58,107.05 67.96,106.62 67.78,106.36 67.39,104.15 67.7,102.36 68.63,101.05 68.82,100.82 69.01,100.62 69.01,99.22
  BOTTOM w0.135: U1.AJ34 v4(69.36,98.13) ; v1(261.34,106.93) 261.7,106.58 261.7,105.78 C139.1
PE_SLOT4_TX_C_DN<5>: length 211.1
  IN1 w0.089: 70.02,99.44 70.02,99.42 69.98,99.36 70.04,99.02 69.95,98.5 69.95,97.93 70.15,97.73 70.28,97.73 70.36,97.81 v4(70.36,98.13)
  IN1 w0.122: 70.02,99.44 69.86,100.31 69.99,100.48 69.92,100.84 69.75,100.97 69.62,101.69 69.74,101.86 69.68,102.23 69.5,102.35 69.36,103.16 69.44,103.63 69.62,103.76 69.68,104.12 69.56,104.3 69.74,105.32 70.74,106.75 71.18,107.07 71.4,107.03 71.7,107.24 71.73,107.45 72.16,107.75 72.38,107.72 72.68,107.92 72.72,108.14 73.89,108.96 74.86,109.13 75,109.03 75.04,108.82 75.38,108.58 76,108.69 76.24,109.03 76.2,109.25 76.3,109.39 76.68,109.45 76.82,109.35 76.86,109.14 77.2,108.9 77.82,109.01 78.05,109.35 78.01,109.57 78.11,109.71 78.49,109.77 78.64,109.68 78.67,109.46 79.01,109.22 79.63,109.33 79.87,109.67 79.83,109.89 79.93,110.03 80.31,110.09 80.45,110 80.49,109.78 80.83,109.54 81.45,109.65 81.69,109.99 81.65,110.21 81.75,110.35 82.13,110.42 82.27,110.32 82.31,110.1 82.65,109.86 83.27,109.97 83.5,110.31 83.47,110.53 83.56,110.67 83.95,110.74 84.09,110.64 84.13,110.42 84.46,110.18 85.08,110.29 85.32,110.63 85.28,110.85 85.38,110.99 85.76,111.06 85.9,110.96 85.94,110.74 86.28,110.5 86.9,110.61 87.14,110.95 87.1,111.17 87.2,111.31 87.79,111.41 133.49,103.35 139.84,104.47 148.85,102.89 148.85,102.88 148.9,102.88 175.62,98.17 245.97,110.59 251.03,109.7 251.16,109.52 251.52,109.45 251.7,109.58 252.06,109.52 252.18,109.34 252.54,109.27 252.72,109.4 253.08,109.34 253.2,109.16 253.56,109.09 253.74,109.22 254.1,109.15 254.23,108.98 254.59,108.91 254.76,109.04 255.12,108.97 255.25,108.8 255.61,108.73 255.78,108.86 256.34,108.76 257.31,108.08 257.63,107.62 257.63,107.29 v1(257.28,106.93)
  BOTTOM w0.135: v1(257.28,106.93) 257.63,106.58 257.63,105.78 C140.1 ; U1.AH34 v4(70.36,98.13)
PE_SLOT4_TX_C_DN<6>: length 199.3
  IN1 w0.089: v4(71.36,98.13) 71.36,97.81 71.28,97.73 71.15,97.73 70.94,97.93 70.94,98.46 70.8,99.27 70.81,99.33 70.87,99.37 70.88,99.39
  IN1 w0.122: 70.88,99.39 70.88,99.44 71.06,100.42 70.9,101.32 70.96,101.68 71.14,101.8 71.2,102.16 71.08,102.34 71.3,103.57 71.24,103.87 71.48,105.21 72.36,106.46 73.99,107.67 74.51,107.77 74.68,107.64 75.05,107.71 75.17,107.88 75.53,107.95 75.71,107.82 76.07,107.89 76.19,108.06 76.55,108.13 76.73,108 77.09,108.07 77.21,108.24 89.57,110.42 133.43,102.69 139.78,103.81 148.85,102.21 148.85,102.21 148.9,102.2 175.6,97.49 245.59,109.85 246.38,109.71 246.5,109.53 246.86,109.47 247.04,109.59 247.4,109.53 247.52,109.35 247.88,109.29 248.06,109.41 248.42,109.35 248.54,109.17 248.9,109.11 249.08,109.23 249.44,109.17 249.57,108.99 249.93,108.93 250.1,109.05 250.46,108.99 250.59,108.81 250.95,108.75 251.13,108.87 251.49,108.81 251.61,108.63 251.97,108.57 252.15,108.69 252.7,108.59 253.3,108.18 253.64,107.68 253.64,107.29 v1(253.29,106.93)
  BOTTOM w0.135: U1.AG34 v4(71.36,98.13) ; v1(253.29,106.93) 253.65,106.58 253.65,105.78 C141.1
PE_SLOT4_TX_C_DN<7>: length 198.1
  IN1 w0.089: v4(72.36,98.13) 72.36,97.81 72.28,97.73 72.15,97.73 71.96,97.92 71.96,98.45 71.84,99.11 71.88,99.33 71.94,99.37 71.94,99.39
  IN1 w0.122: 71.94,99.39 72.23,101.02 72.98,102.1 73.27,103.7 73.15,104.37 73.04,104.98 73.21,105.95 73.59,106.5 74.03,106.8 74.03,106.8 77.49,107.4 77.67,107.27 78.03,107.33 78.15,107.51 78.51,107.57 78.69,107.45 79.05,107.51 79.18,107.69 79.54,107.75 79.71,107.62 80.07,107.68 80.2,107.86 80.56,107.92 80.74,107.8 81.1,107.86 81.22,108.04 82.17,108.2 82.31,108.1 82.4,107.56 82.74,107.32 83.36,107.43 83.6,107.76 83.51,108.3 83.61,108.44 83.99,108.51 84.13,108.41 84.22,107.87 84.56,107.63 85.18,107.74 85.42,108.08 85.32,108.62 85.42,108.76 85.8,108.82 85.94,108.72 86.04,108.18 86.38,107.94 87,108.05 87.24,108.39 87.14,108.93 87.24,109.07 90.35,109.6 133.45,102 139.8,103.12 148.9,101.52 149.27,101.45 149.28,101.45 175.53,96.82 242.05,108.55 242.23,108.43 242.59,108.49 242.71,108.67 243.07,108.73 243.25,108.61 243.61,108.67 243.74,108.85 244.1,108.91 244.27,108.79 244.63,108.85 244.76,109.03 245.12,109.09 246.01,108.93 246.13,108.76 246.49,108.69 246.67,108.82 247.03,108.75 247.15,108.58 247.51,108.51 247.69,108.64 248.05,108.57 248.17,108.4 248.53,108.33 248.71,108.46 249.07,108.39 249.45,108.13 249.66,107.83 249.66,107.29 v1(249.3,106.93)
  BOTTOM w0.135: v1(249.3,106.93) 249.66,106.58 249.66,105.78 C142.1 ; U1.AF34 v4(72.36,98.13)
PE_SLOT4_TX_C_DN<8>: length 195.6
  BOTTOM w0.089: U1.AE34 73.86,97.33 73.74,97.21 73.6,97.21 73.45,97.36 73.45,97.96 72.45,98.95 72.45,99.26 72.51,99.32 72.51,99.34
  BOTTOM w0.135: 72.51,99.34 72.51,100.18 72.32,101.24 71.65,102.21 71.26,104.43 71.54,106.05 72.56,107.5 79.72,112.51 87.05,113.81 87.22,113.68 87.62,113.75 87.75,113.93 88.14,114 88.32,113.88 88.72,113.95 88.84,114.12 89.24,114.19 89.42,114.07 89.82,114.14 89.94,114.32 94.18,115.07 101.07,113.85 103.86,114.34 103.99,114.34 103.99,114.34 104.18,114.34 128.3,110.09 133.6,106.38 136.01,105.95 140.03,106.66 160.95,102.48 163.69,103.02 167,102.36 170.18,102.99 173.35,102.36 176.53,102.99 179.7,102.36 194.43,105.31 206.46,113.73 218.33,115.82 v3(222.67,115.05) 227.79,114.15 227.91,113.97 228.31,113.9 228.49,114.03 228.89,113.96 229.01,113.78 229.41,113.71 229.59,113.83 229.98,113.76 230.11,113.59 230.51,113.52 230.68,113.64 231.08,113.57 231.21,113.39 231.6,113.32 231.78,113.45 232.18,113.38 232.3,113.2 232.7,113.13 232.88,113.25 233.28,113.18 233.4,113.01 233.8,112.94 233.98,113.06 234.37,112.99 234.5,112.81 234.9,112.74 235.07,112.87 235.63,112.77 242.94,107.65 243.59,106.72 243.61,106.58 243.64,106.43 243.69,106.15 243.69,105.78 C143.1
PE_SLOT4_TX_C_DN<9>: length 193.4
  BOTTOM w0.089: 73.71,99.44 73.71,99.42 73.66,99.36 73.66,98.99 74.46,98.18 74.46,97.34 74.58,97.22 74.74,97.22 74.86,97.34 U1.AD34
  BOTTOM w0.135: C144.1 239.68,105.76 239.68,106.16 239.59,106.66 238.95,107.58 238.71,107.74 237.84,108.35 237.76,108.79 238.14,109.32 238.1,109.51 237.59,109.87 237.54,109.86 237.4,109.84 236.66,108.78 236.08,108.68 235.49,109.09 235.4,109.61 236.17,110.7 236.13,110.89 235.62,111.25 235.43,111.22 235.05,110.68 234.62,110.61 232.94,111.78 231.2,112.09 231.03,111.97 230.63,112.04 230.5,112.21 230.11,112.28 229.93,112.16 229.53,112.23 229.41,112.41 229.01,112.48 228.83,112.35 228.43,112.42 228.31,112.6 227.91,112.67 227.74,112.55 227.34,112.62 227.21,112.79 226.82,112.86 226.64,112.74 226.24,112.81 226.12,112.99 225.24,113.14 v3(222.97,113.54) 217.66,114.48 206.93,112.59 194.82,104.11 179.7,101.09 176.53,101.72 173.35,101.09 170.18,101.72 167,101.09 163.76,101.74 161.01,101.19 140.18,105.35 135.86,104.59 132.97,105.1 132.18,105.65 131.97,105.61 131.64,105.84 131.6,106.06 131.27,106.29 131.06,106.25 130.73,106.48 130.69,106.7 127.53,108.91 104.12,113.04 101.23,112.53 94.75,113.67 90.71,112.96 90.58,112.78 90.19,112.71 90.01,112.84 89.61,112.77 89.49,112.59 89.09,112.52 88.91,112.64 88.51,112.57 88.39,112.4 87.99,112.33 87.81,112.45 80,111.07 73.61,106.6 73.27,106.11 72.98,104.46 73.17,103.39 73.36,102.31 73.71,100.33 73.71,100.33 73.71,99.44
