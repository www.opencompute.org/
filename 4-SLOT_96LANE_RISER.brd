# Allegro board 4-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT2_TX_C_DN<15>: length 122.6
  BOTTOM w0.089: 99.76,71.41 99.74,71.43 99.66,71.43 99.08,72.01 98.58,72.01 98.38,72.21 97.58,72.21 97.42,72.37 97.42,72.56 97.5,72.63 U1.A9
  BOTTOM w0.135: C78.1 208.82,63.47 208.63,63.47 207.94,63.6 207.82,63.77 207.42,63.84 207.25,63.72 206.85,63.79 206.72,63.97 206.33,64.04 206.15,63.91 v3(204.42,64.22) 202.89,64.49 201.81,65.24 201.38,65.16 200.85,64.42 200.67,64.38 200.15,64.75 200.12,64.93 200.64,65.68 200.56,66.12 199.84,66.62 199.41,66.54 198.88,65.8 198.7,65.76 198.18,66.12 198.15,66.31 198.67,67.06 198.59,67.49 193.33,71.18 188.91,71.96 185.9,72.49 179.78,72.4 176.53,73.05 173.35,72.42 170.18,73.05 167,72.42 164.08,73 160.73,72.33 157.53,72.97 154.81,72.43 146.49,73.42 144.47,73.45 130.18,73.91 127.91,73.78 125.53,73.11 124.65,72.68 121.63,70.32 121.62,70.32 116.36,69.4 115.62,69.53 113.91,69.23 112.1,69.55 110.32,69.23 108.57,69.54 107.17,69.3 105.51,69.59 103.73,69.27 101.74,69.62 101.1,70.07 99.76,71.41
PE_SLOT2_TX_C_DP<0>: length 190.8
  IN1 w0.089: v4(97.36,88.13) 97.68,88.13 97.79,88.24 97.79,88.45 98.09,88.75 98.63,88.75 99.01,88.81 99.44,88.74 99.5,88.78 99.52,88.78
  IN1 w0.122: 99.52,88.78 99.95,88.7 100.98,88.52 102.57,88.8 104.8,88.4 107.9,88.95 111.23,88.36 114.29,88.9 117.75,88.29 119.89,88.67 122.12,88.28 127,84.86 146.59,81.41 152.94,82.53 218.72,70.93 223.3,71.74 225.12,71.42 227.29,71.8 229.34,71.44 230.79,71.69 232.82,71.33 235.1,71.73 237.5,71.31 240.68,71.87 243.02,71.46 245.65,71.92 247.19,71.65 249.28,72.02 251.12,71.7 252.76,71.98 255.74,71.46 258.74,72.1 278.04,68.7 279.65,67.57 279.93,67.16 279.98,66.9 279.98,66.66 v1(280.34,66.29)
  BOTTOM w0.135: U1.B24 v4(97.36,88.13) ; v1(280.34,66.29) 279.99,65.94 279.99,65.14 C27.1
PE_SLOT2_TX_C_DP<1>: length 188.9
  IN1 w0.089: 99.52,87.5 99.5,87.5 99.44,87.46 98.94,87.55 98.68,87.73 98.07,87.73 97.81,87.46 97.81,87.27 97.67,87.13 v4(97.36,87.13)
  IN1 w0.122: 99.52,87.5 108.63,85.89 112.92,86.65 115.76,86.15 115.9,86.25 116.01,86.85 116.34,87.09 116.96,86.98 117.2,86.64 117.1,86.04 117.2,85.9 117.58,85.83 117.72,85.93 117.82,86.53 118.16,86.77 118.78,86.66 119.02,86.32 118.91,85.72 119.01,85.58 146.59,80.71 152.94,81.83 218.72,70.24 223.17,71.02 224.95,70.71 226.75,71.02 227.04,71.08 229.07,70.72 230.74,71.01 232.77,70.65 235.05,71.05 237.44,70.63 240.73,71.21 243.02,70.81 245.58,71.26 247.18,70.98 249.21,71.33 251.22,70.98 252.99,71.29 254.42,71.04 255.79,70.8 258.62,71.29 274.28,68.54 275.23,68.03 275.85,67.31 275.94,66.78 275.94,66.66 v1(276.3,66.29)
  BOTTOM w0.135: C28.1 275.95,65.14 275.95,65.94 v1(276.3,66.29) ; U1.B23 v4(97.36,87.13)
PE_SLOT2_TX_C_DP<2>: length 181.8
  IN1 w0.089: v4(97.36,86.13) 97.69,86.13 97.79,86.23 97.79,86.45 98.07,86.73 98.53,86.73 98.73,86.87 99.34,86.76 99.4,86.8 99.42,86.8
  IN1 w0.122: 99.42,86.8 99.52,86.78 108.56,85.19 112.99,85.97 146.82,80.01 153.17,81.13 218.68,69.58 223.12,70.36 224.99,70.03 227.13,70.41 229.18,70.05 230.81,70.33 232.8,69.98 235.08,70.38 237.46,69.96 240.78,70.55 243.02,70.15 245.57,70.6 247.19,70.32 249.18,70.67 251.31,70.29 253.11,70.61 255.83,70.13 258.15,70.54 271.13,68.25 271.64,67.89 271.88,67.56 272,66.86 272,66.66 v1(272.37,66.29)
  BOTTOM w0.135: U1.B22 v4(97.36,86.13) ; v1(272.37,66.29) 272.01,65.94 272.01,65.14 C29.1
PE_SLOT2_TX_C_DP<3>: length 180.8
  IN1 w0.089: 99.47,85.88 99.45,85.88 99.41,85.82 98.97,85.74 98.09,85.74 97.79,85.45 97.79,85.22 97.71,85.13 v4(97.36,85.13)
  IN1 w0.122: 99.47,85.88 99.52,85.89 99.92,85.96 108.37,84.47 112.82,85.26 146.58,79.3 152.93,80.42 218.48,68.87 223.19,69.7 225.05,69.37 227.03,69.71 228.07,69.53 229.02,69.36 230.78,69.67 232.91,69.3 235.22,69.71 237.54,69.3 240.86,69.88 243.02,69.5 245.5,69.94 247.17,69.65 249.13,69.99 251.22,69.62 253.11,69.96 256.04,69.44 257.83,69.76 264.02,68.69 264.79,68.55 265.02,68.21 264.77,66.76 264.87,66.62 265.25,66.55 265.39,66.65 265.65,68.11 265.98,68.34 266.95,68.18 267.9,67.23 267.97,66.85 267.97,66.66 v1(268.33,66.29)
  BOTTOM w0.135: U1.B21 v4(97.36,85.13) ; C30.1 267.97,65.14 267.97,65.94 v1(268.33,66.29)
PE_SLOT2_TX_C_DP<4>: length 171.3
  IN1 w0.089: 99.47,84.85 99.45,84.85 99.41,84.79 99.19,84.75 99.01,84.72 98.07,84.72 97.79,84.45 97.79,84.2 97.72,84.13 v4(97.36,84.13)
  IN1 w0.122: v1(262.33,66.29) 261.95,66.67 261.95,67.18 261.72,67.51 261.33,67.78 261.28,67.82 253,69.28 251.17,68.96 249.08,69.32 247.19,68.99 245.57,69.28 242.96,68.82 240.8,69.2 237.55,68.62 235.23,69.03 232.94,68.63 230.87,68.99 229.12,68.68 227.11,69.04 225.14,68.69 223.24,69.03 218.45,68.18 152.93,79.74 146.58,78.62 112.74,84.59 107.72,83.7 100.32,85 99.47,84.85
  BOTTOM w0.135: U1.B20 v4(97.36,84.13) ; C55.1 261.98,65.14 261.98,65.94 v1(262.33,66.29)
PE_SLOT2_TX_C_DP<5>: length 169.2
  IN1 w0.089: v4(97.36,83.13) 97.71,83.13 97.78,83.2 97.78,83.54 97.96,83.72 99,83.72 99.13,83.75 99.41,83.8 99.45,83.85 99.47,83.86
  IN1 w0.122: v1(258.29,66.29) 257.93,66.66 257.93,66.89 257.85,67.31 257.34,67.66 256.24,67.86 255.9,67.62 255.75,66.77 255.61,66.67 255.23,66.74 255.13,66.88 255.27,67.66 254.94,68.13 252.72,68.52 251.23,68.26 249.07,68.64 247.22,68.31 245.52,68.61 242.96,68.16 240.8,68.54 237.55,67.97 235.23,68.38 232.95,67.98 230.94,68.33 229.18,68.02 227.11,68.39 225.14,68.04 223.24,68.38 218.45,67.53 153.08,79.06 146.73,77.94 112.9,83.9 107.43,82.94 100.84,84.1 99.47,83.86
  BOTTOM w0.135: C56.1 257.94,65.14 257.94,65.94 v1(258.29,66.29) ; U1.B19 v4(97.36,83.13)
PE_SLOT2_TX_C_DP<6>: length 163.2
  IN1 w0.089: v4(97.36,82.13) 97.73,82.13 97.79,82.19 97.79,82.49 98.03,82.73 98.97,82.73 99.19,82.77 99.41,82.81 99.45,82.87 99.47,82.87
  IN1 w0.122: v1(254.33,66.29) 253.97,66.66 253.97,66.98 253.96,67.03 253.89,67.43 253.5,67.7 252.9,67.81 252.46,67.73 251.49,67.56 249.07,67.99 247.23,67.66 245.52,67.96 242.94,67.51 240.79,67.89 237.48,67.3 235.16,67.71 232.95,67.32 231.11,67.65 229.36,67.34 227.11,67.73 225.14,67.39 223.24,67.72 218.4,66.87 153.03,78.39 146.68,77.27 112.98,83.22 106.56,82.09 100.79,83.1 99.52,82.88 99.47,82.87
  BOTTOM w0.135: C57.1 253.98,65.14 253.98,65.94 v1(254.33,66.29) ; U1.B18 v4(97.36,82.13)
PE_SLOT2_TX_C_DP<7>: length 161.6
  IN1 w0.089: 99.47,80.99 99.45,80.99 99.41,80.93 99.16,80.89 98.72,80.96 98.04,80.96 97.79,80.71 97.79,80.21 97.71,80.13 v4(97.36,80.13)
  IN1 w0.122: v1(250.29,66.29) 249.93,66.66 249.93,66.94 249.76,67.11 249.4,67.26 248.97,67.26 247.22,66.95 245.36,67.28 242.9,66.85 240.74,67.23 237.44,66.65 235.26,67.03 233.08,66.65 231.14,66.99 229.36,66.67 227.08,67.08 225.03,66.72 223.14,67.05 218.39,66.21 153.02,77.74 146.67,76.62 113.14,82.53 112.06,82.34 111.83,82 111.91,81.52 111.81,81.38 111.43,81.31 111.29,81.41 111.21,81.89 110.87,82.13 110.25,82.02 110.01,81.68 110.1,81.2 110,81.06 109.62,80.99 109.47,81.09 109.39,81.57 109.05,81.81 106.1,81.29 103.64,81.73 99.52,81 99.47,80.99
  BOTTOM w0.135: v1(250.29,66.29) 249.94,65.94 249.94,65.14 C58.1 ; U1.B17 v4(97.36,80.13)
PE_SLOT2_TX_C_DP<8>: length 156.6
  BOTTOM w0.089: U1.B16 97.18,79.63 97.27,79.54 97.27,79.34 97.57,79.03 98.58,79.03 99.1,79.55 99.18,79.55 99.2,79.57
  BOTTOM w0.135: 99.2,79.57 101.88,82.25 101.97,82.34 102.28,82.56 103.61,82.79 105.78,82.41 107.72,82.75 109.9,82.37 111.44,82.64 113.56,82.26 117.14,82.9 125.31,83.21 153.8,82.15 156.91,81.53 157.93,81.74 161.07,81.11 163.43,81.58 166.61,80.94 170.18,81.66 173.35,81.02 176.53,81.66 179.7,81.02 182.05,81.49 v3(186.59,80.69) 197.35,78.79 204.98,73.45 212.72,72.09 229.52,72.09 240.54,70.14 242.21,68.98 242.25,68.76 242.58,68.53 242.79,68.57 243.12,68.34 243.16,68.12 243.49,67.89 243.7,67.93 244.37,67.46 245.62,65.67 245.62,65.14 C59.1
PE_SLOT2_TX_C_DP<9>: length 154.2
  BOTTOM w0.089: U1.B15 97.18,78.63 97.3,78.51 97.3,78.31 97.56,78.04 98.5,78.04 98.55,77.98 98.58,77.98
  BOTTOM w0.135: C60.1 241.63,65.14 241.63,65.76 241.37,66.12 240.58,66.68 240.5,67.12 241.15,68.04 241.11,68.22 240.6,68.58 240.41,68.55 239.77,67.63 239.33,67.55 237.56,68.8 237.34,68.76 237.01,68.99 236.98,69.2 236.53,69.52 228.79,70.88 211.92,70.88 204.29,72.23 196.52,77.67 v3(190.16,78.79) 182.13,80.21 179.73,79.75 176.53,80.39 173.35,79.75 170.18,80.39 166.72,79.7 163.54,80.33 160.94,79.81 157.83,80.43 156.96,80.28 152.98,80.98 131.52,81.71 125.89,81.65 125.59,81.65 122.25,81.72 121.53,81.68 121.51,81.67 114.11,80.42 112.25,80.74 110.17,80.38 107.85,80.79 106.12,80.48 104.14,80.83 103.13,80.65 102.61,80.56 101.58,79.83 100.39,78.65 99.59,78.09 99.04,77.99 99.04,77.98 98.58,77.98
PE_SLOT2_TX_C_DP<10>: length 147.2
  BOTTOM w0.089: U1.B14 97.18,77.63 97.3,77.51 97.3,77.31 97.58,77.03 98.42,77.03 98.48,76.97 98.5,76.97
  BOTTOM w0.135: 98.5,76.97 99.67,76.97 99.68,76.97 100.4,77.1 101.25,77.69 102.47,78.55 104.6,78.93 107.64,78.39 111.01,78.98 114.05,78.45 116.44,78.87 117.06,78.76 117.2,78.74 118.22,78.79 118.94,79.14 120.33,80.21 122.27,80.45 124.88,80.36 129.81,80.36 141.52,79.93 152.26,79.8 156.92,78.87 157.81,79.05 160.65,78.48 163.65,79.08 166.83,78.45 170.18,79.12 173.35,78.48 176.53,79.12 179.7,78.48 182.07,78.96 v3(185.03,78.43) 196.03,76.49 203.73,71.11 211.82,69.68 228.03,69.68 233.66,68.69 236.36,66.8 236.4,66.58 236.73,66.35 236.94,66.39 237.27,66.16 237.67,65.59 237.67,65.14 C61.1
PE_SLOT2_TX_C_DP<11>: length 144.9
  BOTTOM w0.089: 98.7,75.98 98.68,75.98 98.62,76.03 97.57,76.03 97.3,76.31 97.3,76.51 97.18,76.63 U1.B13
  BOTTOM w0.135: C62.1 233.71,65.14 233.71,65.56 233.29,66.16 232.59,66.65 232.4,66.62 231.9,65.9 231.47,65.82 230.74,66.33 230.67,66.76 231.17,67.48 231.14,67.67 230.67,68 229.87,68.14 229.69,68.01 229.29,68.08 229.17,68.26 227.92,68.48 v3(215,68.48) 211.23,68.48 203.04,69.93 195.19,75.42 182.27,77.7 179.7,77.19 176.53,77.82 173.35,77.19 170.18,77.82 167,77.19 163.83,77.82 160.65,77.19 157.77,77.76 156.41,77.49 152.41,78.29 147.99,78.38 127.65,79.08 127.41,79.03 124.37,78.5 123.14,78.52 121.92,78.54 120.69,78.31 118.22,76.81 117.92,76.76 116.73,76.54 113.97,77.03 110.87,76.48 109.2,76.78 107.68,76.51 104.49,77.07 102.21,76.67 101.62,76.25 101.25,76.19 100.05,75.98 98.7,75.98
PE_SLOT2_TX_C_DP<12>: length 138.3
  BOTTOM w0.089: 99.01,74.99 98.99,74.99 98.93,75.04 97.56,75.04 97.31,75.3 97.31,75.5 97.18,75.63 U1.B12
  BOTTOM w0.135: 99.01,74.99 101.73,74.99 104.39,74.52 106.86,74.95 108.5,74.66 111.1,75.12 114.16,74.58 117.23,75.12 118.05,74.98 118.26,75.02 120.75,76.54 124.63,76.88 124.65,76.88 124.65,76.88 126.32,77.17 126.35,77.18 128.34,77.71 147.74,77.11 147.81,77.11 148.69,77.1 150.57,77.08 152.25,76.9 156.22,76.15 157.91,76.49 160.65,75.94 163.83,76.58 167,75.94 170.18,76.58 173.35,75.94 176.53,76.58 179.7,75.94 182.33,76.47 194.72,74.28 202.57,68.79 211.13,67.28 v3(218.77,67.28) 227.47,67.28 228.33,66.68 228.37,66.47 228.7,66.23 228.91,66.27 229.26,66.02 229.67,65.44 229.67,65.14 C63.1
PE_SLOT2_TX_C_DP<13>: length 136.3
  BOTTOM w0.089: 99.52,73.97 99.5,73.97 99.44,74.03 97.54,74.03 97.3,74.27 97.3,74.51 97.18,74.63 U1.B11
  BOTTOM w0.135: 99.52,73.97 99.93,73.97 100.45,73.88 101.38,73.22 103.65,72.82 105.24,73.11 107.83,72.65 110.75,73.16 113.75,72.63 116.48,73.11 118.48,72.76 119.07,72.87 121.7,74.63 122.23,75.16 128.09,76.19 129.03,76.36 149.27,75.69 151.9,75.68 156.11,74.84 157.97,75.21 160.65,74.67 163.83,75.31 167,74.67 170.18,75.31 173.35,74.67 176.53,75.31 179.7,74.67 182.47,75.23 194.25,73.15 202.1,67.65 211.02,66.08 v3(215.79,66.08) 221.42,66.08 221.57,65.92 221.98,65.92 222.13,66.08 222.8,66.08 222.93,65.94 222.93,65.21 223.25,64.9 224.13,64.9 224.44,65.21 224.44,65.94 224.57,66.08 224.89,66.08 225.53,65.63 225.73,65.35 225.73,65.14 C64.1
PE_SLOT2_TX_C_DP<14>: length 128.5
  BOTTOM w0.089: 99.52,72.67 99.5,72.67 99.44,72.73 98.73,72.73 98.35,73 98.11,73.04 97.53,73.04 97.32,73.24 97.32,73.49 97.18,73.63 U1.B10
  BOTTOM w0.135: C65.1 219.67,64.36 218.96,64.36 218.45,64.72 217.56,64.88 v3(213.82,64.88) 209.57,64.88 201.99,66.21 193.68,72.03 182.59,73.98 179.7,73.4 176.53,74.04 173.35,73.4 170.18,74.04 167,73.4 163.84,74.04 160.67,73.4 157.89,73.96 154.96,73.37 154.86,73.39 154.86,73.39 147.09,74.52 140.4,74.52 129.87,74.99 127.71,74.79 124.75,73.86 121.14,71.33 118.54,70.87 116.51,71.23 114.27,70.83 112.85,71.08 111.11,70.77 108.87,71.17 107.31,70.89 105.42,71.23 103.41,70.87 101.62,71.19 101.27,71.44 100.58,72.13 100.03,72.67 99.52,72.67
PE_SLOT2_TX_C_DP<15>: length 122.6
  BOTTOM w0.089: 99.54,71.2 99.53,71.21 99.53,71.29 99,71.82 98.5,71.82 98.3,72.02 97.5,72.02 97.23,72.29 97.23,72.52 97.12,72.63 U1.B9
  BOTTOM w0.135: C66.1 208.92,63.17 208.6,63.17 v3(205.86,63.65) 204.36,63.92 202.77,64.2 201.74,64.92 201.55,64.89 201.03,64.14 200.59,64.06 199.87,64.57 199.8,65 200.32,65.75 200.29,65.94 199.77,66.3 199.58,66.27 199.06,65.52 198.62,65.44 197.9,65.95 197.83,66.38 198.35,67.13 198.32,67.32 193.21,70.89 188.91,71.65 185.88,72.18 179.75,72.1 176.53,72.74 173.35,72.11 170.18,72.74 167,72.11 164.08,72.69 160.73,72.02 157.53,72.66 154.82,72.12 146.47,73.12 144.46,73.14 130.18,73.61 127.96,73.48 125.63,72.83 124.81,72.42 121.75,70.03 116.36,69.09 115.62,69.22 113.91,68.92 112.1,69.24 110.32,68.92 108.57,69.23 107.17,68.99 107.12,69 105.51,69.28 104.67,69.13 103.73,68.96 101.62,69.34 100.91,69.84 99.54,71.2
PE_SLOT2_TX_DN<0>: length 6.4
  BOTTOM w0.135: C31.2 279.68,63.63 279.68,59.36 279.95,59.09 280.14,59 280.14,59 280.2,58.82 J2.B15
PE_SLOT2_TX_DN<1>: length 6.3
  BOTTOM w0.135: C32.2 275.64,63.63 275.64,63.23 275.49,63.08 275.49,62.67 275.64,62.52 275.64,62.12 275.49,61.96 275.49,61.56 275.64,61.41 275.64,59.44 275.54,59.33 275.4,59.26 275.2,59.33 J2.B20
PE_SLOT2_TX_DN<2>: length 6.3
  BOTTOM w0.135: C33.2 271.73,63.61 271.73,63.2 271.58,63.05 271.58,62.65 271.73,62.49 271.73,62.09 271.58,61.94 271.58,61.53 271.73,61.38 271.73,59.56 271.5,59.33 271.38,59.27 271.2,59.33 J2.B24
PE_SLOT2_TX_DN<3>: length 6.3
  BOTTOM w0.135: J2.B28 267.2,59.33 267.39,59.27 267.51,59.33 267.67,59.49 267.67,61.41 267.51,61.56 267.51,61.96 267.67,62.12 267.67,62.52 267.51,62.67 267.51,63.08 267.67,63.23 267.67,63.63 C34.2
PE_SLOT2_TX_DN<4>: length 6.3
  BOTTOM w0.135: J2.B34 261.2,59.33 261.38,59.27 261.53,59.35 261.67,59.49 261.67,61.41 261.52,61.56 261.52,61.96 261.67,62.12 261.67,62.52 261.52,62.67 261.52,63.08 261.67,63.23 261.67,63.63 C67.2
PE_SLOT2_TX_DN<5>: length 6.3
  BOTTOM w0.135: J2.B38 257.2,59.33 257.37,59.28 257.58,59.38 257.68,59.49 257.68,61.35 257.53,61.51 257.53,61.91 257.68,62.06 257.68,62.47 257.53,62.62 257.53,63.03 257.68,63.18 257.68,63.58 C68.2
PE_SLOT2_TX_DN<6>: length 6.3
  BOTTOM w0.135: J2.B42 253.2,59.33 253.39,59.27 253.54,59.34 253.67,59.48 253.67,61.41 253.52,61.56 253.52,61.96 253.67,62.12 253.67,62.52 253.52,62.67 253.52,63.08 253.67,63.23 253.67,63.63 C69.2
PE_SLOT2_TX_DN<7>: length 6.3
  BOTTOM w0.135: C70.2 249.63,63.63 249.63,63.23 249.48,63.08 249.48,62.67 249.63,62.52 249.63,62.12 249.48,61.96 249.48,61.56 249.63,61.41 249.63,59.46 249.51,59.33 249.38,59.27 249.2,59.33 J2.B46
PE_SLOT2_TX_DN<8>: length 7.4
  BOTTOM w0.135: C71.2 246,63.71 246,59.72 arc(245.76,59.13) 245.17,58.89 244.72,58.89 arc(244.65,58.87) 244.59,58.83 J2.B51
PE_SLOT2_TX_DN<9>: length 7.4
  BOTTOM w0.135: C72.2 242,63.7 242,59.72 arc(241.76,59.13) 241.17,58.89 240.72,58.89 arc(240.65,58.87) 240.59,58.83 J2.B55
PE_SLOT2_TX_DN<10>: length 7.4
  BOTTOM w0.135: C73.2 238,63.66 238,59.72 arc(237.76,59.13) 237.17,58.89 236.72,58.89 arc(236.65,58.87) 236.59,58.83 J2.B59
PE_SLOT2_TX_DN<11>: length 7.4
  BOTTOM w0.135: J2.B63 232.59,58.83 arc(232.65,58.87) 232.72,58.89 233.17,58.89 arc(233.76,59.13) 234,59.72 234,63.62 C74.2
PE_SLOT2_TX_DN<12>: length 7.4
  BOTTOM w0.135: C75.2 230,63.66 230,59.72 arc(229.76,59.13) 229.17,58.89 228.72,58.89 arc(228.65,58.87) 228.59,58.83 J2.B67
PE_SLOT2_TX_DN<13>: length 7.4
  BOTTOM w0.135: C76.2 226,63.6 226,59.72 arc(225.76,59.13) 225.17,58.89 224.72,58.89 arc(224.65,58.87) 224.59,58.83 J2.B71
PE_SLOT2_TX_DN<14>: length 9
  BOTTOM w0.135: C77.2 221,64.84 221.47,64.84 222,64.31 222,59.72 arc(221.76,59.13) 221.17,58.89 220.72,58.89 arc(220.65,58.87) 220.59,58.83 J2.B75
PE_SLOT2_TX_DN<15>: length 12.7
  BOTTOM w0.135: C78.2 210.33,63.58 211.14,63.58 217.34,61.33 217.93,60.73 217.93,60.73 218,60.35 218,59.72 arc(217.76,59.13) 217.17,58.89 216.72,58.89 arc(216.65,58.87) 216.59,58.83 J2.B79
PE_SLOT2_TX_DP<0>: length 6.3
  BOTTOM w0.135: J2.B14 280.46,59.33 280.28,59.27 280.13,59.35 279.99,59.49 279.99,61.41 280.14,61.56 280.14,61.96 279.99,62.12 279.99,62.52 280.14,62.67 280.14,63.08 279.99,63.23 279.99,63.63 C27.2
PE_SLOT2_TX_DP<1>: length 6.4
  BOTTOM w0.135: J2.B19 275.46,58.82 275.51,58.98 275.72,59.08 275.95,59.31 275.95,63.63 C28.2
PE_SLOT2_TX_DP<2>: length 6.4
  BOTTOM w0.135: C29.2 272.04,63.66 272.04,59.44 271.68,59.08 271.52,59 271.46,58.82 J2.B23
PE_SLOT2_TX_DP<3>: length 6.4
  BOTTOM w0.135: C30.2 267.97,63.63 267.97,59.36 267.69,59.08 267.51,58.99 267.46,58.82 J2.B27
PE_SLOT2_TX_DP<4>: length 6.4
  BOTTOM w0.135: J2.B33 261.46,58.82 261.52,59 261.52,59 261.71,59.1 261.98,59.36 261.98,63.63 C55.2
PE_SLOT2_TX_DP<5>: length 6.4
  BOTTOM w0.135: C56.2 257.99,63.68 257.99,59.36 257.76,59.13 257.52,59.01 257.46,58.82 J2.B37
PE_SLOT2_TX_DP<6>: length 6.4
  BOTTOM w0.135: C57.2 253.98,63.63 253.98,59.35 253.72,59.09 253.51,58.99 253.46,58.82 J2.B41
PE_SLOT2_TX_DP<7>: length 6.4
  BOTTOM w0.135: J2.B45 249.46,58.82 249.52,59 249.69,59.08 249.94,59.33 249.94,63.63 C58.2
PE_SLOT2_TX_DP<8>: length 7.4
  BOTTOM w0.135: C59.2 245.7,63.56 245.7,62.66 245.54,62.51 245.54,62.1 245.7,61.95 245.7,61.55 245.54,61.39 245.54,60.99 245.7,60.84 245.7,59.72 arc(245.54,59.35) 245.17,59.19 244.58,59.19 arc(244.34,59.35) 244.39,59.64 J2.B50
PE_SLOT2_TX_DP<9>: length 7.4
  BOTTOM w0.135: J2.B54 240.38,59.63 arc(240.33,59.35) 240.56,59.19 241.17,59.19 arc(241.54,59.35) 241.7,59.72 241.7,60.84 241.54,60.99 241.54,61.39 241.7,61.55 241.7,61.95 241.54,62.1 241.54,62.51 241.7,62.66 241.7,63.57 C60.2
PE_SLOT2_TX_DP<10>: length 7.4
  BOTTOM w0.135: C61.2 237.69,63.61 237.69,62.66 237.54,62.51 237.54,62.1 237.69,61.95 237.69,61.55 237.54,61.39 237.54,60.99 237.69,60.84 237.69,59.72 arc(237.54,59.35) 237.17,59.19 236.53,59.19 arc(236.31,59.34) 236.36,59.6 J2.B58
PE_SLOT2_TX_DP<11>: length 7.4
  BOTTOM w0.135: C62.2 233.69,63.65 233.69,62.66 233.54,62.51 233.54,62.1 233.69,61.95 233.69,61.55 233.54,61.39 233.54,60.99 233.69,60.84 233.69,59.72 arc(233.54,59.35) 233.17,59.19 232.5,59.19 arc(232.29,59.33) 232.34,59.58 J2.B62
PE_SLOT2_TX_DP<12>: length 7.4
  BOTTOM w0.135: J2.B66 228.36,59.61 arc(228.31,59.34) 228.53,59.19 229.17,59.19 arc(229.54,59.35) 229.69,59.72 229.69,60.84 229.54,60.99 229.54,61.39 229.69,61.55 229.69,61.95 229.54,62.1 229.54,62.51 229.69,62.66 229.69,63.61 C63.2
PE_SLOT2_TX_DP<13>: length 7.4
  BOTTOM w0.135: J2.B70 224.34,59.58 arc(224.29,59.33) 224.5,59.19 225.17,59.19 arc(225.54,59.35) 225.7,59.72 225.7,60.84 225.54,60.99 225.54,61.39 225.7,61.55 225.7,61.95 225.54,62.1 225.54,62.51 225.7,62.66 225.7,63.67 C64.2
PE_SLOT2_TX_DP<14>: length 9
  BOTTOM w0.135: J2.B74 220.34,59.58 arc(220.29,59.33) 220.5,59.19 221.17,59.19 arc(221.54,59.35) 221.7,59.72 221.7,60.84 221.54,61 221.54,61.4 221.7,61.55 221.7,61.96 221.54,62.11 221.54,62.51 221.7,62.67 221.7,63.07 221.54,63.22 221.54,63.63 221.7,63.78 221.7,64.18 221.34,64.54 220.98,64.54 220.82,64.38 C65.2
PE_SLOT2_TX_DP<15>: length 12.6
  BOTTOM w0.135: C66.2 210.43,63.27 211.08,63.27 211.57,63.1 211.66,62.9 212.04,62.76 212.23,62.85 212.61,62.72 212.71,62.52 213.08,62.38 213.28,62.47 213.66,62.34 213.75,62.14 214.13,62 214.33,62.09 214.71,61.96 214.8,61.76 215.18,61.62 215.38,61.71 215.76,61.58 215.85,61.38 216.23,61.24 216.42,61.33 217.17,61.06 217.65,60.59 217.7,60.33 217.7,59.72 arc(217.54,59.35) 217.17,59.19 216.5,59.19 arc(216.29,59.33) 216.34,59.58 J2.B78
PE_SLOT3_PRES_N: length 313.5
  TOP w0.114: v1(67.61,50.15) 67.25,50.15 65.6,51.8 65.6,52.85 64.65,53.81 64.65,54.22 63.24,55.63 63.24,57.01 62.77,57.48 59.79,57.48 59.03,58.24 57.63,58.24 R269.2
  IN2 w0.112: J3.A1 296.88,74.85 296.88,57.91 294.97,56.01 294.97,55.24 295.61,54.61 295.97,54.61 296.6,53.98 296.6,52.63 295.84,51.86 295.84,46.46 294.46,45.09 294.46,41.92 296.61,39.77 296.61,37.2 294.97,35.56 294.97,34.67 295.35,34.29 296.11,34.29 296.48,33.93 296.48,32.51 295.23,31.26 282.72,31.26 281.21,29.74 198.29,29.74 185.2,42.84 161.99,42.84 142.65,62.18 127.79,62.18 118.03,52.42 70.63,52.42 68.37,50.15 v1(67.61,50.15)
PE_SLOT3_RX_DN<0>: length 220.3
  IN3 w0.089: v4(82.36,95.13) 82.36,94.81 82.28,94.73 81.91,94.73 81.61,95.02 81.61,95.51 81.66,95.55 81.66,95.58
  IN3 w0.135: 81.66,95.58 81.66,98.11 81.76,98.67 81.95,98.94 82.16,98.97 82.39,99.3 82.36,99.52 82.63,99.91 82.91,100.31 82.91,100.31 88.28,104.07 93.84,105.05 100.18,103.93 105.03,104.79 107.73,104.31 111.9,105.05 120.67,103.5 128.76,97.83 173.95,89.87 189.13,92.55 196.26,91.29 199.18,91.8 202.1,91.29 202.87,91.43 203.59,91.55 204.31,91.68 205.08,91.81 208.21,91.26 212.36,91.99 214.33,91.65 215.44,91.84 216.5,92.03 218.39,91.69 221.43,92.23 225.69,91.48 231.17,92.44 245.38,89.94 250.59,90.86 261.2,88.98 261.31,88.83 261.71,88.76 261.86,88.87 262.26,88.8 262.37,88.64 262.77,88.57 262.93,88.68 263.33,88.61 263.44,88.45 263.84,88.38 264,88.49 264.39,88.42 264.5,88.26 264.9,88.19 265.06,88.3 265.46,88.23 265.57,88.07 265.97,88 266.13,88.12 266.52,88.05 266.64,87.89 267.03,87.82 267.19,87.93 269,87.61 269.47,87.28 269.81,86.79 269.91,86.21 269.8,86.05 269.87,85.65 270.03,85.54 270.1,85.14 270.3,84.86 270.64,84.62 271.45,84.48 271.56,84.32 271.96,84.25 272.12,84.36 272.52,84.29 272.63,84.13 273.03,84.06 273.19,84.17 273.58,84.1 274.54,83.43 274.58,83.22 274.91,82.99 275.12,83.03 275.45,82.79 275.49,82.58 275.82,82.35 276.03,82.39 276.36,82.16 276.4,81.94 276.73,81.71 276.95,81.75 277.22,81.56 277.67,80.92 277.67,79.64 arc(277.79,79.34) 278.09,79.21 278.14,79.21 arc(278.51,79.06) 278.67,78.69 278.67,75.3 278.51,75.15 278.39,75.08 278.2,75.14 J3.A17
  BOTTOM w0.135: U1.U31 v4(82.36,95.13)
PE_SLOT3_RX_DN<1>: length 218
  IN3 w0.089: v4(83.36,95.13) 83.36,94.81 83.28,94.73 83.15,94.73 82.96,94.91 82.96,98.65 83.01,98.7 83.01,98.72
  IN3 w0.135: J3.A22 273.2,74.65 273.14,74.83 272.93,74.93 272.67,75.19 272.67,79.07 arc(272.81,79.4) 273.14,79.54 273.56,79.54 arc(273.64,79.57) 273.68,79.66 273.68,81.1 273.24,81.74 272.89,81.98 272.68,81.94 272.35,82.17 272.31,82.38 271.98,82.62 271.77,82.58 271.43,82.81 271.4,83.02 270.23,83.84 269.83,83.91 269.65,83.79 269.25,83.86 269.13,84.04 268.73,84.11 268.55,83.98 268.16,84.05 268.03,84.23 267.22,84.37 266.92,84.43 266.92,84.43 266.61,84.48 266.61,84.48 266.24,84.55 265.44,85.11 265.35,85.6 265.73,86.14 265.7,86.35 265.48,86.5 265.28,86.46 264.47,85.3 264.04,85.22 263.64,85.5 263.57,85.91 264.39,87.09 264.34,87.37 264.06,87.57 250.01,90.05 245.43,89.24 231.13,91.76 225.69,90.8 221.43,91.55 218.39,91.01 216.45,91.36 215.41,91.18 214.33,90.99 212.37,91.33 212.36,91.33 208.22,90.6 205.13,91.14 202.15,90.62 199.18,91.14 196.24,90.62 189.17,91.87 173.94,89.19 128.54,97.19 120.47,102.85 111.82,104.37 107.73,103.65 105.12,104.11 100.27,103.26 93.9,104.38 92.07,104.06 91.95,103.88 91.55,103.81 91.37,103.94 90.97,103.87 90.85,103.69 90.45,103.62 90.27,103.74 89.88,103.67 89.75,103.49 89.35,103.42 89.18,103.55 88.78,103.48 83.8,99.99 83.52,99.8 83.06,99.14 83.01,98.86 83.01,98.72
  BOTTOM w0.135: U1.T31 v4(83.36,95.13)
PE_SLOT3_RX_DN<2>: length 209.1
  IN3 w0.089: 84,98.87 84,98.85 83.96,98.8 83.96,94.92 84.15,94.73 84.28,94.73 84.36,94.81 v4(84.36,95.13)
  IN3 w0.135: 84,98.87 84,99 84.05,99.24 84.19,99.44 84.2,99.45 85.06,100.06 85.27,100.02 85.6,100.25 85.64,100.46 85.97,100.69 86.18,100.66 86.51,100.89 86.55,101.1 86.88,101.33 87.09,101.3 87.43,101.53 87.46,101.74 87.79,101.97 88.01,101.93 88.34,102.17 88.38,102.38 88.52,102.48 88.66,102.58 94.51,103.61 100.27,102.6 105.12,103.45 107.73,102.99 111.82,103.71 120.18,102.24 128.25,96.58 174.15,88.49 189.3,91.16 196.16,89.95 199.18,90.48 202.2,89.95 205.13,90.47 208.17,89.93 212.27,90.65 214.28,90.3 216.5,90.69 218.45,90.34 221.43,90.87 223.55,90.5 225.71,90.12 231.06,91.06 245.38,88.53 250.03,89.35 258.75,87.82 259.27,87.45 259.56,87.04 259.82,85.55 260.21,85 261.57,84.05 265.23,83.4 265.35,83.23 265.75,83.16 265.93,83.28 266.32,83.21 266.45,83.03 266.85,82.96 267.02,83.09 267.42,83.02 268.22,82.45 268.26,82.24 268.59,82.01 268.8,82.05 269.33,81.68 269.68,81.28 269.68,79.67 arc(269.64,79.57) 269.55,79.54 269.17,79.54 arc(268.83,79.39) 268.68,79.05 268.68,75.18 268.93,74.93 269.14,74.83 269.2,74.65 J3.A26
  BOTTOM w0.135: U1.R31 v4(84.36,95.13)
PE_SLOT3_RX_DN<3>: length 207.1
  IN3 w0.089: v4(85.36,95.13) 85.36,94.81 85.28,94.73 85.15,94.73 84.96,94.92 84.96,98.5 85.01,98.55 85.01,98.57
  IN3 w0.135: J3.A30 265.2,74.65 265.14,74.83 264.93,74.93 264.7,75.17 264.7,79.02 arc(264.63,79.18) 264.47,79.25 264.16,79.25 arc(263.86,79.37) 263.73,79.68 263.73,81.13 263.1,82.03 262.17,82.69 261.77,82.76 261.59,82.63 261.19,82.7 261.07,82.88 260.67,82.95 260.49,82.82 260.1,82.89 259.97,83.07 259.57,83.14 259.4,83.02 259,83.09 258.88,83.27 258.37,83.35 257.53,83.94 257.33,83.91 257,84.14 256.97,84.33 256.64,84.56 256.03,85.43 255.8,86.73 255.3,87.44 254.84,87.77 250,88.62 247.79,88.23 247.68,88.07 247.93,86.61 247.69,86.26 247.08,86.15 246.73,86.4 246.48,87.86 246.32,87.97 245.57,87.84 244.92,87.95 244.77,87.84 244.62,87.02 244.27,86.77 243.67,86.88 243.42,87.23 243.57,88.06 243.46,88.21 231.12,90.39 225.72,89.44 221.44,90.19 218.12,89.61 218.07,89.6 216.07,89.95 214.28,89.64 212.37,89.97 210.37,89.62 208.27,89.25 205.18,89.8 202.16,89.26 199.08,89.8 196.12,89.28 189.35,90.48 174.2,87.81 128.03,95.94 119.95,101.6 111.77,103.04 107.73,102.33 105.12,102.79 100.27,101.93 94.67,102.92 89.34,101.98 88.51,101.4 88.48,101.19 88.14,100.96 87.93,101 87.6,100.77 87.56,100.55 87.23,100.32 87.02,100.36 86.69,100.13 86.65,99.91 86.32,99.68 86.11,99.72 85.77,99.49 85.57,99.35 85.57,99.35 85.2,99.09 85.03,98.85 85.01,98.7 85.01,98.57
  BOTTOM w0.135: U1.P31 v4(85.36,95.13)
PE_SLOT3_RX_DN<4>: length 194.2
  IN3 w0.089: v4(87.36,95.13) 87.36,94.81 87.28,94.73 87.15,94.73 86.96,94.91 86.96,98.61 87.01,98.65 87.01,98.68
  IN3 w0.135: J3.A36 259.2,74.65 259.14,74.83 258.93,74.93 258.68,75.19 258.68,79.07 arc(258.82,79.42) 259.16,79.56 259.56,79.56 arc(259.65,79.6) 259.69,79.7 259.69,81.34 259.25,81.97 258.44,82.54 258.04,82.61 257.88,82.5 257.48,82.57 257.37,82.73 256.97,82.8 256.82,82.69 256.42,82.76 256.31,82.91 255.91,82.98 255.75,82.87 255.35,82.94 255.24,83.1 254.84,83.17 254.68,83.06 254.29,83.13 254.18,83.29 245.02,84.9 240.77,87.88 230.74,89.64 225.71,88.76 223.52,89.14 221.42,89.51 218.4,88.98 218.12,88.93 216.11,89.28 214.27,88.96 212.37,89.3 208.17,88.56 205.08,89.1 202.15,88.58 199.1,89.12 196.01,88.58 189.38,89.75 174.4,87.1 127.71,95.34 119.69,100.95 111.78,102.35 107.73,101.63 105.15,102.09 100.09,101.2 94.59,102.17 93.22,101.93 93.09,101.75 92.7,101.68 92.52,101.8 92.12,101.73 92,101.55 91.6,101.48 91.42,101.61 91.02,101.54 90.9,101.36 90.5,101.29 90.33,101.42 89.93,101.34 87.42,99.59 87.35,99.54 87.06,99.14 87.01,98.84 87.01,98.68
  BOTTOM w0.135: v4(87.36,95.13) U1.M31
PE_SLOT3_RX_DN<5>: length 193.5
  IN3 w0.089: v4(88.36,95.13) 88.36,94.81 88.28,94.73 88.15,94.73 87.96,94.92 87.96,98.5 88.01,98.55 88.01,98.57
  IN3 w0.135: J3.A40 255.2,74.65 255.14,74.83 254.93,74.93 254.69,75.18 254.69,79.09 arc(254.82,79.42) 255.15,79.55 255.57,79.55 arc(255.66,79.59) 255.7,79.69 255.7,81.11 255.19,81.84 254.55,82.29 253.4,82.5 253.25,82.38 252.85,82.45 252.74,82.61 252.34,82.68 252.18,82.57 251.78,82.64 251.67,82.8 251.27,82.87 251.11,82.76 250.72,82.83 250.61,82.99 244.78,84.02 241.46,86.34 240.83,86.45 240.65,86.7 240.59,86.8 240.63,87.04 240.63,87.04 240.52,87.2 240.15,87.27 239.99,87.16 239.95,86.91 239.6,86.67 239,86.77 238.75,87.12 238.8,87.37 238.69,87.52 238.32,87.59 238.16,87.48 238.12,87.24 237.77,86.99 237.17,87.1 236.92,87.45 236.96,87.69 236.85,87.85 236.49,87.91 236.33,87.8 236.29,87.56 235.94,87.31 235.33,87.42 235.09,87.77 235.13,88.01 235.02,88.17 234.65,88.24 234.5,88.13 234.45,87.88 234.1,87.64 233.5,87.74 233.26,88.09 233.3,88.34 233.19,88.49 232.82,88.56 232.67,88.45 232.62,88.21 232.27,87.96 231.67,88.07 231.42,88.42 231.47,88.66 231.36,88.82 230.99,88.88 230.83,88.77 230.79,88.53 230.44,88.28 228.71,88.59 225.76,88.07 221.42,88.83 218.23,88.27 218.18,88.26 216.27,88.6 214.43,88.27 212.37,88.63 208.17,87.89 205.13,88.43 202.2,87.91 199.24,88.44 195.96,87.86 189.34,89.03 174.54,86.42 127.43,94.73 119.47,100.3 111.81,101.65 107.72,100.93 105.22,101.37 99.74,100.41 94.67,101.3 94.19,101.22 94.07,101.04 93.67,100.97 93.49,101.09 93.09,101.02 92.97,100.84 92.57,100.77 92.39,100.9 92,100.83 91.87,100.65 91.47,100.58 91.3,100.7 90.9,100.63 90.77,100.46 90.38,100.39 90.2,100.51 89.8,100.44 88.37,99.44 88.29,99.38 88.06,99.05 88.01,98.76 88.01,98.57
  BOTTOM w0.135: U1.L31 v4(88.36,95.13)
PE_SLOT3_RX_DN<6>: length 183
  IN3 w0.089: v4(89.36,95.13) 89.36,94.81 89.28,94.73 89.15,94.73 88.96,94.91 88.96,98.65 89.01,98.7 89.01,98.72
  IN3 w0.135: J3.A44 251.2,74.65 251.14,74.83 250.93,74.93 250.67,75.19 250.67,79.1 arc(250.81,79.42) 251.14,79.56 251.54,79.56 arc(251.63,79.6) 251.67,79.7 251.67,81.16 251.58,81.29 250.9,81.76 250.48,81.84 250.3,81.71 249.91,81.78 249.78,81.96 249.38,82.03 249.21,81.91 248.81,81.98 248.69,82.16 248.29,82.23 248.11,82.1 247.71,82.17 247.59,82.35 247.19,82.42 247.01,82.29 246.62,82.36 246.49,82.54 245.24,82.76 241.04,85.7 228.62,87.89 225.76,87.39 221.43,88.15 218.4,87.62 218.23,87.59 216.26,87.94 214.33,87.59 212.37,87.94 208.27,87.22 205.18,87.76 202.15,87.23 199.28,87.73 196.1,87.17 189.4,88.35 174.61,85.75 127.19,94.1 119.23,99.68 111.91,100.97 107.77,100.24 105.32,100.67 99.79,99.69 95.16,100.51 94.34,100.37 94.21,100.19 93.81,100.12 93.64,100.24 93.24,100.17 93.11,100 92.72,99.93 92.54,100.05 92.14,99.98 92.02,99.8 91.62,99.73 91.44,99.86 91.04,99.79 90.92,99.61 90.52,99.54 90.35,99.66 89.87,99.58 89.19,99.11 89.01,98.85 89.01,98.72
  BOTTOM w0.135: v4(89.36,95.13) U1.K31
PE_SLOT3_RX_DN<7>: length 181.3
  IN3 w0.089: v4(90.36,95.13) 90.36,94.81 90.28,94.73 90.15,94.73 89.95,94.92 89.95,98.34 90,98.39 90,98.42
  IN3 w0.135: 90,98.42 90,98.61 90.18,98.79 90.58,98.86 90.76,98.74 91.16,98.81 91.28,98.99 91.68,99.06 91.86,98.93 92.25,99 92.38,99.18 92.78,99.25 92.95,99.13 93.35,99.2 93.47,99.37 93.87,99.44 94.05,99.32 94.45,99.39 94.57,99.57 95.63,99.75 97.41,99.44 99.35,99.1 99.96,98.99 105.48,99.97 107.81,99.55 111.98,100.29 118.97,99.06 126.93,93.49 174.83,85.04 189.53,87.63 196.05,86.48 199.33,87.06 202.21,86.56 205.08,87.06 208.17,86.52 212.42,87.27 214.33,86.93 216.25,87.27 218.31,86.91 221.43,87.46 228.37,86.23 228.72,86.48 228.82,87.05 228.97,87.16 229.34,87.09 229.45,86.94 229.35,86.37 229.59,86.02 230.2,85.91 230.55,86.16 230.65,86.73 230.8,86.83 231.17,86.77 231.28,86.61 231.18,86.04 231.43,85.69 232.03,85.59 232.38,85.83 232.48,86.4 232.64,86.51 233.01,86.45 233.11,86.29 233.01,85.72 233.26,85.37 233.86,85.26 234.21,85.51 234.31,86.08 234.47,86.19 234.84,86.12 234.95,85.97 234.85,85.4 235.13,85 236.08,84.83 236.19,84.67 236.59,84.6 236.74,84.71 237.14,84.64 237.25,84.48 237.65,84.41 237.81,84.53 238.21,84.46 238.32,84.3 238.72,84.23 238.88,84.34 239.27,84.27 239.38,84.11 239.78,84.04 239.94,84.15 242.49,83.7 245.41,81.65 245.64,81.33 245.72,80.87 245.72,79.77 arc(245.84,79.47) 246.14,79.35 246.45,79.35 arc(246.6,79.29) 246.66,79.14 246.66,75.2 246.93,74.93 247.14,74.83 247.2,74.65 J3.A48
  BOTTOM w0.135: U1.J31 v4(90.36,95.13)
PE_SLOT3_RX_DN<8>: length 169.2
  IN3 w0.089: v4(91.36,95.13) 91.36,94.81 91.28,94.73 91.15,94.73 90.95,94.92 90.95,96.2 91.07,96.87 91.13,96.91 91.13,96.93
  IN3 w0.135: J3.A53 242.2,75.14 242.39,75.08 242.51,75.15 242.67,75.31 242.67,79.08 arc(242.62,79.22) 242.48,79.27 242.11,79.27 arc(241.81,79.4) 241.68,79.71 241.68,80.93 241.38,81.66 240.52,82.26 240.33,82.22 240,82.46 239.97,82.65 239.64,82.88 239.45,82.85 239.12,83.08 239.08,83.27 238.75,83.5 238.1,83.61 237.94,83.5 237.54,83.57 237.43,83.73 237.03,83.8 236.87,83.69 236.48,83.76 236.37,83.92 235.97,83.99 235.81,83.88 235.41,83.95 235.3,84.11 234.9,84.18 234.74,84.07 234.35,84.14 234.23,84.3 233.84,84.37 233.68,84.26 233.28,84.33 233.17,84.48 232.77,84.55 232.61,84.44 232.21,84.51 232.1,84.67 231.71,84.74 231.55,84.63 231.15,84.7 231.04,84.86 230.64,84.93 230.48,84.82 230.08,84.89 229.97,85.05 220.74,86.67 218.28,86.24 216.23,86.6 216.21,86.6 215.23,86.43 214.24,86.26 212.33,86.59 208.17,85.86 205.09,86.4 202.11,85.88 199.28,86.38 196.04,85.81 189.6,86.94 174.94,84.36 126.68,92.87 118.72,98.44 112.09,99.6 107.8,98.85 105.54,99.24 100.09,98.28 99.52,98.39 97.15,98.8 96.97,98.68 96.58,98.75 96.45,98.93 96.05,99 94.36,98.7 94.24,98.52 93.84,98.45 93.66,98.57 93.26,98.5 93.14,98.33 92.74,98.26 92.56,98.38 92.17,98.31 91.43,97.8 91.23,97.51 91.13,96.93
  BOTTOM w0.135: U1.H31 v4(91.36,95.13)
PE_SLOT3_RX_DN<9>: length 169.3
  IN3 w0.089: 99.52,97.49 99.5,97.49 99.45,97.54 92.53,97.54 91.96,96.96 91.96,94.91 92.15,94.73 92.28,94.73 92.36,94.81 v4(92.36,95.13)
  IN3 w0.135: 99.52,97.49 100.42,97.49 100.8,97.55 100.98,97.43 101.38,97.5 101.5,97.68 101.9,97.75 102.08,97.62 102.47,97.69 102.6,97.87 103,97.94 103.17,97.82 103.57,97.89 103.7,98.07 104.09,98.14 104.27,98.01 104.67,98.08 104.79,98.26 105.64,98.41 106.04,98.34 106.15,98.18 106.55,98.11 106.71,98.22 107.46,98.09 108.89,98.34 109.05,98.23 109.44,98.3 109.55,98.46 109.95,98.53 110.11,98.42 110.51,98.49 110.62,98.64 112.07,98.9 118.5,97.77 126.36,92.26 175.06,83.68 175.52,83.76 175.52,83.76 175.93,83.83 175.93,83.83 176.35,83.91 189.63,86.26 196.04,85.13 199.27,85.7 202.15,85.19 205.18,85.72 208.27,85.18 210.28,85.53 212.3,85.89 214.31,85.54 216.42,85.91 220.92,85.11 221.27,85.36 221.35,85.77 221.5,85.88 221.87,85.82 221.98,85.66 221.91,85.25 222.15,84.9 222.76,84.79 223.11,85.04 223.18,85.45 223.33,85.56 223.7,85.49 223.81,85.34 223.74,84.92 223.99,84.57 224.59,84.47 224.94,84.71 225.01,85.13 225.17,85.23 225.54,85.17 225.65,85.01 225.57,84.6 225.82,84.25 226.42,84.14 226.77,84.39 226.84,84.8 227,84.91 227.37,84.85 227.48,84.69 227.4,84.28 227.65,83.93 228.25,83.82 228.6,84.07 228.68,84.48 228.83,84.59 229.2,84.52 229.31,84.37 229.24,83.95 229.48,83.6 230.58,83.41 231.19,83.52 231.84,83.4 231.96,83.23 232.36,83.16 232.54,83.28 232.94,83.21 233.06,83.03 233.46,82.96 233.64,83.09 234.03,83.02 234.16,82.84 234.55,82.77 234.73,82.89 235.13,82.82 235.25,82.65 235.65,82.58 235.83,82.7 236.28,82.62 237.03,82.09 237.61,81.27 237.68,80.82 237.68,79.67 arc(237.81,79.37) 238.11,79.25 238.51,79.25 arc(238.64,79.2) 238.69,79.08 238.69,75.32 238.51,75.15 238.39,75.08 238.2,75.14 J3.A57
  BOTTOM w0.135: U1.G31 v4(92.36,95.13)
PE_SLOT3_RX_DN<10>: length 157.4
  IN3 w0.089: v4(93.36,95.13) 93.36,94.81 93.28,94.73 93.15,94.73 92.97,94.91 92.97,96.34 93.17,96.55 99.01,96.55 99.06,96.5 99.08,96.5
  IN3 w0.135: 99.08,96.5 99.55,96.5 99.92,96.56 100.09,96.44 100.49,96.51 100.62,96.69 101.01,96.76 101.19,96.63 101.59,96.7 101.71,96.88 102.11,96.95 102.27,96.84 102.67,96.91 102.78,97.07 103.18,97.14 103.34,97.03 103.73,97.1 103.84,97.26 104.24,97.33 104.4,97.22 104.8,97.29 104.91,97.44 105.74,97.59 107.46,97.29 111.37,97.98 111.53,97.87 111.92,97.94 112.04,98.09 112.43,98.16 112.83,98.09 112.94,97.94 113.34,97.87 113.5,97.98 113.9,97.91 114.01,97.75 114.41,97.68 114.56,97.79 114.96,97.72 115.07,97.56 115.47,97.49 115.63,97.6 118.26,97.14 126.1,91.65 175.06,83.02 189.62,85.58 196.04,84.45 199.27,85.02 202.1,84.52 205.08,85.04 208.17,84.5 212.12,85.2 212.44,85.2 214.34,84.86 216.33,85.21 229.37,82.91 229.48,82.75 229.88,82.68 230.04,82.8 230.44,82.73 230.55,82.57 230.95,82.5 231.11,82.61 231.5,82.54 231.61,82.38 232.01,82.31 232.17,82.42 232.57,82.35 233.33,81.86 233.61,81.47 233.68,81.04 233.68,79.67 arc(233.81,79.37) 234.1,79.25 234.5,79.25 arc(234.62,79.2) 234.67,79.08 234.67,75.31 234.51,75.15 234.38,75.08 234.2,75.14 J3.A61
  BOTTOM w0.135: U1.F31 v4(93.36,95.13)
PE_SLOT3_RX_DN<11>: length 155.6
  IN3 w0.089: v4(94.36,95.13) 94.36,94.81 94.28,94.73 94.15,94.73 93.97,94.9 93.97,95.34 94.16,95.53 98.84,95.53 98.88,95.48 98.91,95.48
  IN3 w0.135: 98.91,95.48 100.22,95.48 101.58,95.72 101.74,95.61 102.13,95.68 102.25,95.84 102.8,95.94 103.24,95.86 104.63,96.1 104.79,95.99 105.18,96.06 105.3,96.22 105.69,96.29 105.85,96.18 106.25,96.25 106.36,96.41 106.76,96.48 107.51,96.35 107.62,96.19 108.02,96.12 108.18,96.23 108.58,96.16 108.69,96 109.08,95.93 109.24,96.04 110.15,95.88 111.81,96.17 112.21,96.1 112.32,95.94 112.71,95.87 112.87,95.98 113.27,95.91 113.38,95.76 113.78,95.69 113.94,95.8 115.16,95.58 115.27,95.42 115.67,95.35 115.83,95.46 116.23,95.39 116.34,95.23 116.73,95.16 116.89,95.27 120.74,94.6 125.82,91.04 175.1,82.34 187.79,84.58 187.95,84.47 188.02,84.02 188.37,83.78 188.98,83.89 189.22,84.24 189.14,84.69 189.25,84.84 189.61,84.9 190.12,84.81 190.23,84.66 190.06,83.72 190.31,83.36 190.89,83.26 191.26,83.52 191.43,84.45 191.58,84.56 191.95,84.49 192.06,84.33 191.97,83.81 192.21,83.46 192.82,83.36 193.17,83.6 193.26,84.12 193.41,84.23 196.05,83.77 199.28,84.34 202.16,83.83 205.14,84.36 205.14,84.36 208.34,83.79 212.51,84.53 214.39,84.19 216.32,84.53 224.9,83.02 225.03,82.84 225.43,82.77 225.6,82.89 226,82.82 226.13,82.64 226.52,82.57 226.7,82.7 227.1,82.63 227.22,82.45 227.62,82.38 227.8,82.5 228.08,82.46 228.08,82.46 229.36,81.56 229.59,81.24 229.67,80.76 229.67,79.67 arc(229.79,79.37) 230.09,79.25 230.55,79.25 arc(230.65,79.21) 230.68,79.11 230.68,75.32 230.51,75.15 230.38,75.08 230.2,75.14 J3.A65
  BOTTOM w0.135: U1.E31 v4(94.36,95.13)
PE_SLOT3_RX_DN<12>: length 144.6
  IN3 w0.089: v4(95.36,92.13) 95.05,92.13 94.96,92.22 94.96,92.35 95.14,92.53 98.96,92.53 99.01,92.48 99.03,92.48
  IN3 w0.135: 99.03,92.48 99.98,92.48 100.39,92.55 100.77,92.82 100.98,92.78 101.31,93.01 101.35,93.23 102.28,93.88 102.68,93.95 102.85,93.82 103.25,93.89 103.38,94.07 104.51,94.27 104.9,94.2 105.03,94.02 105.43,93.95 105.6,94.08 106.35,93.94 108.19,94.27 110.89,93.79 110.98,93.79 110.98,93.8 113.32,94.21 117.19,93.53 117.3,93.37 117.7,93.3 117.85,93.41 118.25,93.34 118.36,93.18 118.76,93.11 118.92,93.22 119.32,93.15 119.43,92.99 119.83,92.92 119.99,93.03 120.38,92.96 120.49,92.8 120.89,92.73 121.05,92.84 121.59,92.75 124.69,90.58 175.07,81.68 185.38,83.5 191.81,82.36 199.23,83.67 202.16,83.15 205.14,83.68 208.34,83.11 208.34,83.11 212.3,83.81 214.18,83.48 216.26,83.84 221.91,82.84 222.04,82.67 222.44,82.6 222.61,82.72 223.01,82.65 223.14,82.47 223.53,82.4 223.71,82.53 224.43,82.4 225.24,81.83 225.51,81.45 225.68,80.57 225.68,79.7 arc(225.8,79.4) 226.1,79.27 226.51,79.27 arc(226.62,79.23) 226.67,79.11 226.67,75.31 226.51,75.15 226.38,75.08 226.2,75.14 J3.A69
  BOTTOM w0.135: U1.D28 v4(95.36,92.13)
PE_SLOT3_RX_DN<13>: length 144.5
  IN3 w0.089: v4(95.36,91.13) 95.05,91.13 94.96,91.22 94.96,91.35 95.15,91.54 99.29,91.54 99.34,91.49 99.36,91.49
  IN3 w0.135: J3.A73 222.2,75.14 222.38,75.08 222.51,75.15 222.66,75.29 222.66,79.11 arc(222.61,79.23) 222.5,79.27 222.15,79.27 arc(221.83,79.41) 221.69,79.73 221.69,80.92 221.55,81.73 221.18,82.26 221.11,82.31 219.45,82.6 219.29,82.49 218.89,82.56 218.78,82.72 218.38,82.79 218.23,82.68 217.83,82.75 217.72,82.9 217.32,82.97 217.16,82.86 216.76,82.93 216.65,83.09 216.25,83.16 215.2,82.98 215.21,82.98 214.06,82.78 212.12,83.12 208.16,82.42 205.06,82.97 202.26,82.47 199.32,82.99 191.74,81.65 185.22,82.81 175.08,81.02 172.45,81.48 172.3,81.37 172.21,80.86 171.86,80.62 171.25,80.72 171.01,81.07 171.1,81.58 170.99,81.74 170.62,81.8 170.47,81.69 170.38,81.18 170.03,80.94 169.42,81.05 169.18,81.4 169.27,81.9 169.16,82.06 168.79,82.13 168.63,82.02 168.54,81.51 168.19,81.26 167.59,81.37 167.34,81.72 167.43,82.23 167.33,82.38 124.21,89.99 121.63,91.79 116.95,92.62 116.94,92.61 116.9,92.61 113.84,92.07 112.69,92.27 112.53,92.16 112.13,92.23 112.02,92.39 111.62,92.46 110.56,92.27 110.45,92.12 110.05,92.05 109.89,92.16 109.5,92.09 109.39,91.93 108.99,91.86 108.83,91.97 108.43,91.9 107.46,92.07 106.73,91.94 106.02,92.06 105.86,91.95 105.47,92.02 105.35,92.18 104.96,92.25 104.8,92.14 104.4,92.21 104.29,92.37 103.89,92.44 102.44,92.18 102.33,92.02 101.93,91.95 101.77,92.06 101.37,91.99 100.65,91.49 99.36,91.49
  BOTTOM w0.135: U1.D27 v4(95.36,91.13)
PE_SLOT3_RX_DN<14>: length 135.4
  IN3 w0.089: 99.52,90.49 99.5,90.49 99.45,90.53 95.15,90.53 94.96,90.35 94.96,90.22 95.05,90.13 v4(95.36,90.13)
  IN3 w0.135: 99.52,90.49 101.47,90.49 102.54,90.3 103.33,90.44 103.51,90.31 103.9,90.38 104.03,90.56 104.43,90.63 104.82,90.56 104.95,90.38 105.35,90.31 105.52,90.44 106.24,90.31 107.91,90.6 108.31,90.53 108.42,90.37 108.82,90.3 108.97,90.41 109.37,90.34 109.48,90.19 109.88,90.12 110.04,90.23 110.72,90.11 111.89,90.31 112.05,90.2 112.45,90.27 112.56,90.43 113.28,90.56 113.68,90.49 113.79,90.33 114.19,90.26 114.35,90.37 116.51,89.99 118.36,90.31 158.86,83.17 160.72,81.87 172.24,79.84 185.05,82.1 191.59,80.95 199.27,82.3 202.16,81.79 205.06,82.31 208.21,81.75 212,82.42 213.76,82.11 213.89,81.93 214.29,81.86 214.46,81.98 214.86,81.91 214.99,81.74 215.38,81.67 215.56,81.79 215.96,81.72 216.08,81.54 216.48,81.47 216.66,81.6 217.11,81.52 217.39,81.32 217.68,80.91 arc(217.7,80.87) 217.71,80.82 217.71,79.7 arc(217.83,79.4) 218.14,79.27 218.54,79.27 arc(218.65,79.23) 218.7,79.11 218.7,75.33 218.51,75.15 218.38,75.08 218.2,75.14 J3.A77
  BOTTOM w0.135: U1.D26 v4(95.36,90.13)
PE_SLOT3_RX_DN<15>: length 135.4
  IN3 w0.089: v4(95.36,89.13) 95.05,89.13 94.96,89.22 94.96,89.35 95.16,89.54 99.45,89.54 99.5,89.5 99.52,89.5
  IN3 w0.135: 99.52,89.5 101.06,89.5 102.44,88.53 103.39,88.37 104.23,88.51 105.99,88.2 107.67,88.5 108.89,88.29 110.5,88.57 113.15,88.1 115.51,88.52 117.34,88.2 119.33,88.55 122.26,88.03 122.37,87.88 122.77,87.81 122.92,87.92 123.32,87.85 123.43,87.69 123.83,87.62 123.99,87.73 124.39,87.66 124.5,87.5 124.9,87.43 125.06,87.54 125.45,87.47 125.56,87.31 125.96,87.24 126.12,87.35 126.52,87.28 126.63,87.12 127.03,87.05 127.19,87.17 127.58,87.1 127.7,86.94 128.09,86.87 128.25,86.98 129.18,86.81 131.82,87.28 158.57,82.56 160.43,81.26 172.34,79.16 179.18,80.37 179.34,80.26 179.42,79.79 179.77,79.54 180.38,79.65 180.62,80 180.54,80.47 180.65,80.63 181.02,80.69 181.17,80.58 181.25,80.11 181.6,79.87 182.21,79.97 182.45,80.32 182.37,80.8 182.48,80.95 182.85,81.02 183,80.91 183.09,80.44 183.44,80.19 184.04,80.3 184.29,80.65 184.27,80.76 184.2,81.12 184.31,81.27 185.04,81.4 191.53,80.26 199.27,81.62 202.15,81.11 205.01,81.62 207.37,81.2 207.5,81 207.9,80.93 208.1,81.07 208.53,81 209.85,81.23 210.03,81.11 210.43,81.18 210.55,81.35 210.95,81.42 211.13,81.3 211.52,81.37 211.65,81.55 212.05,81.62 212.99,81.45 213.4,81.16 213.62,80.85 213.62,80.8 213.62,79.62 arc(213.75,79.32) 214.04,79.2 214.38,79.2 arc(214.61,79.1) 214.71,78.87 214.71,75.34 214.51,75.15 214.38,75.08 214.2,75.14 J3.A81
  BOTTOM w0.135: U1.D25 v4(95.36,89.13)
PE_SLOT3_RX_DP<0>: length 220.3
  IN3 w0.089: v4(82.36,94.13) 82.36,94.45 82.28,94.54 81.83,94.54 81.42,94.94 81.42,95.51 81.37,95.55 81.37,95.58
  IN3 w0.135: 81.37,95.58 81.37,98.14 81.49,98.78 81.95,99.44 82.4,100.08 82.4,100.08 82.71,100.52 82.75,100.55 88.17,104.34 93.84,105.34 100.18,104.22 105.03,105.08 107.73,104.6 111.9,105.34 120.78,103.77 128.87,98.1 173.95,90.16 189.13,92.84 196.26,91.58 199.18,92.1 202.1,91.58 202.46,91.64 202.46,91.65 205.08,92.11 206.7,91.82 206.69,91.82 208.21,91.55 212.36,92.28 214.33,91.94 216.5,92.32 218.39,91.99 221.43,92.52 221.48,92.51 225.69,91.77 231.17,92.73 245.38,90.23 250.59,91.15 261.25,89.27 267.24,88.21 269.11,87.88 269.67,87.49 270.08,86.91 270.19,86.26 270.19,86.26 270.37,85.26 270.5,85.07 270.75,84.89 273.7,84.37 277.11,81.98 277.43,81.76 277.95,81.01 277.95,79.64 arc(277.99,79.54) 278.09,79.5 278.14,79.5 arc(278.71,79.26) 278.95,78.69 278.95,75.18 278.68,74.91 278.51,74.83 278.51,74.83 278.45,74.65 J3.A16
  BOTTOM w0.135: U1.U30 v4(82.36,94.13)
PE_SLOT3_RX_DP<1>: length 218
  IN3 w0.089: 82.72,98.72 82.72,98.7 82.77,98.65 82.77,94.83 83.07,94.54 83.28,94.54 83.36,94.45 v4(83.36,94.13)
  IN3 w0.135: 82.72,98.72 82.72,98.88 82.79,99.25 83.32,100.01 83.63,100.22 83.64,100.23 88.67,103.75 92.02,104.34 92.02,104.34 93.9,104.67 100.27,103.55 105.12,104.4 107.73,103.94 111.82,104.66 120.58,103.12 128.66,97.46 173.94,89.48 189.17,92.16 196.24,90.92 199.18,91.44 202.15,90.91 203.62,91.17 205.13,91.44 208.22,90.89 212.31,91.61 212.37,91.62 214.33,91.28 216.45,91.65 218.39,91.31 221.43,91.84 225.69,91.09 231.13,92.05 245.43,89.53 250.01,90.34 264.18,87.84 264.23,87.8 264.6,87.54 264.69,87.02 263.87,85.84 263.9,85.67 264.11,85.52 264.3,85.56 265.11,86.72 265.55,86.8 265.96,86.51 266.04,86.08 265.66,85.53 265.7,85.27 266.35,84.82 270.34,84.11 273.44,81.94 273.97,81.19 273.97,79.66 arc(273.85,79.37) 273.56,79.25 273.14,79.25 arc(273.01,79.2) 272.96,79.07 272.96,75.31 273.1,75.17 273.27,75.08 273.45,75.14 J3.A21
  BOTTOM w0.135: U1.T30 v4(83.36,94.13)
PE_SLOT3_RX_DP<2>: length 209.1
  IN3 w0.089: v4(84.36,94.13) 84.36,94.45 84.28,94.54 84.07,94.54 83.77,94.84 83.77,98.8 83.72,98.85 83.72,98.87
  IN3 w0.135: 83.72,98.87 83.72,99.03 83.77,99.35 83.84,99.44 83.99,99.66 88.21,102.61 88.55,102.85 94.51,103.9 100.27,102.89 105.12,103.74 107.73,103.28 109.73,103.63 111.82,104 120.29,102.51 128.37,96.85 174.15,88.78 189.3,91.45 196.16,90.24 199.18,90.77 202.2,90.24 203.67,90.5 203.67,90.5 205.13,90.76 208.17,90.22 210.19,90.58 212.27,90.94 212.32,90.94 214.28,90.59 216.5,90.98 218.45,90.64 221.43,91.16 225.71,90.41 231.06,91.35 245.38,88.83 250.03,89.64 258.86,88.09 259.48,87.66 259.83,87.16 260.09,85.67 260.42,85.21 261.68,84.32 267.53,83.29 268.87,82.35 268.87,82.35 269.53,81.89 269.97,81.39 269.97,79.67 arc(269.85,79.37) 269.55,79.25 269.17,79.25 arc(269.03,79.19) 268.97,79.05 268.97,75.3 269.1,75.17 269.27,75.08 269.45,75.14 J3.A25
  BOTTOM w0.135: U1.R30 v4(84.36,94.13)
PE_SLOT3_RX_DP<3>: length 207.1
  IN3 w0.089: v4(85.36,94.13) 85.36,94.45 85.28,94.54 85.07,94.54 84.77,94.84 84.77,98.5 84.72,98.55 84.72,98.57
  IN3 w0.135: J3.A29 265.45,75.14 265.27,75.08 265.1,75.17 264.98,75.29 264.98,79.02 arc(264.83,79.38) 264.47,79.54 264.16,79.54 arc(264.06,79.58) 264.02,79.68 264.02,81.22 263.31,82.24 262.28,82.96 258.48,83.63 256.85,84.77 256.3,85.55 256.07,86.84 255.51,87.65 254.95,88.04 250,88.91 247.62,88.49 247.37,88.14 247.63,86.68 247.52,86.52 247.15,86.46 247,86.56 246.74,88.03 246.39,88.27 245.57,88.13 244.85,88.26 244.5,88.01 244.36,87.18 244.2,87.08 243.83,87.14 243.72,87.3 243.87,88.12 243.62,88.47 231.12,90.68 225.72,89.73 221.44,90.48 218.07,89.89 216.07,90.24 214.28,89.93 212.37,90.27 208.27,89.54 206.78,89.81 205.18,90.09 202.16,89.55 199.08,90.1 196.12,89.57 189.35,90.77 174.2,88.1 128.14,96.21 120.06,101.87 111.77,103.33 107.73,102.62 105.12,103.08 100.27,102.23 94.67,103.21 89.29,102.26 89.22,102.25 85.61,99.72 85.61,99.72 85.41,99.58 85.4,99.58 85.2,99.44 84.99,99.29 84.76,98.97 84.72,98.75 84.72,98.75 84.72,98.57
  BOTTOM w0.135: U1.P30 v4(85.36,94.13)
PE_SLOT3_RX_DP<4>: length 194.3
  IN3 w0.089: v4(87.36,94.13) 87.36,94.45 87.28,94.54 87.07,94.54 86.77,94.83 86.77,98.61 86.73,98.65 86.73,98.68
  IN3 w0.135: 86.73,98.68 86.73,98.87 86.79,99.25 86.93,99.44 87.14,99.75 87.25,99.82 89.81,101.62 94.59,102.46 100.09,101.49 105.15,102.38 107.73,101.93 111.78,102.64 119.8,101.22 127.82,95.61 174.4,87.4 189.38,90.04 196.01,88.87 199.1,89.41 202.15,88.88 205.08,89.39 208.17,88.85 212.37,89.59 214.27,89.25 216.11,89.58 218.12,89.22 221.43,89.8 225.71,89.05 230.74,89.94 240.89,88.15 245.13,85.18 258.55,82.81 259.46,82.17 259.98,81.43 259.98,79.7 arc(259.86,79.4) 259.56,79.27 259.16,79.27 arc(259.02,79.21) 258.96,79.07 258.96,75.31 259.1,75.17 259.27,75.08 259.45,75.14 J3.A35
  BOTTOM w0.135: U1.M30 v4(87.36,94.13)
PE_SLOT3_RX_DP<5>: length 193.6
  IN3 w0.089: v4(88.36,94.13) 88.36,94.45 88.28,94.54 88.07,94.54 87.77,94.84 87.77,98.5 87.72,98.55 87.72,98.57
  IN3 w0.135: J3.A39 255.45,75.14 255.27,75.08 255.1,75.17 254.97,75.3 254.97,79.09 arc(255.03,79.22) 255.15,79.27 255.57,79.27 arc(255.87,79.39) 255.99,79.69 255.99,81.2 255.4,82.05 254.66,82.57 244.89,84.29 241.58,86.61 241,86.71 240.89,86.87 240.93,87.11 240.69,87.46 240.08,87.57 239.73,87.32 239.69,87.08 239.53,86.97 239.17,87.03 239.06,87.19 239.1,87.43 238.85,87.79 238.25,87.89 237.9,87.65 237.86,87.4 237.7,87.29 237.33,87.36 237.22,87.51 237.27,87.76 237.02,88.11 236.42,88.22 236.07,87.97 236.02,87.73 235.87,87.62 235.5,87.68 235.39,87.84 235.43,88.08 235.19,88.43 234.59,88.54 234.24,88.29 234.19,88.05 234.04,87.94 233.67,88 233.56,88.16 233.6,88.4 233.36,88.76 232.75,88.86 232.4,88.62 232.36,88.37 232.2,88.26 231.84,88.33 231.73,88.48 231.77,88.73 231.52,89.08 230.92,89.19 230.57,88.94 230.53,88.7 230.37,88.59 228.71,88.88 225.76,88.36 221.42,89.12 218.18,88.55 216.27,88.89 214.43,88.56 212.37,88.93 208.17,88.19 205.13,88.72 202.2,88.21 199.24,88.73 195.96,88.15 189.34,89.32 174.54,86.71 127.54,95 119.59,100.57 111.81,101.94 107.72,101.22 105.22,101.66 99.74,100.7 94.67,101.59 94.14,101.5 89.69,100.71 88.09,99.59 87.98,99.44 87.79,99.16 87.72,98.79 87.72,98.57
  BOTTOM w0.135: U1.L30 v4(88.36,94.13)
PE_SLOT3_RX_DP<6>: length 182.9
  IN3 w0.089: v4(89.36,94.13) 89.36,94.45 89.28,94.54 89.07,94.54 88.77,94.83 88.77,98.65 88.72,98.7 88.72,98.72
  IN3 w0.135: J3.A43 251.45,75.14 251.27,75.08 251.1,75.17 250.96,75.31 250.96,79.1 arc(251.01,79.22) 251.14,79.27 251.54,79.27 arc(251.84,79.4) 251.96,79.7 251.96,81.25 251.79,81.49 251.01,82.04 245.35,83.03 241.15,85.97 228.62,88.18 225.76,87.68 221.43,88.44 218.23,87.88 216.26,88.23 214.33,87.88 212.37,88.23 208.27,87.51 206.78,87.77 205.18,88.05 203.62,87.78 202.15,87.52 199.28,88.02 196.1,87.46 189.4,88.65 174.61,86.04 127.3,94.37 119.34,99.95 111.91,101.26 107.77,100.53 105.32,100.96 99.79,99.99 95.21,100.79 95.16,100.8 89.76,99.85 89.17,99.44 88.99,99.32 88.72,98.94 88.72,98.72
  BOTTOM w0.135: U1.K30 v4(89.36,94.13)
PE_SLOT3_RX_DP<7>: length 181.2
  IN3 w0.089: 89.71,98.42 89.71,98.39 89.76,98.34 89.76,94.85 90.07,94.54 90.28,94.54 90.36,94.45 v4(90.36,94.13)
  IN3 w0.135: 89.71,98.42 89.71,98.73 90.05,99.06 92.2,99.44 95.63,100.05 99.96,99.28 105.48,100.26 107.81,99.85 111.98,100.58 119.09,99.33 127.04,93.76 174.83,85.33 189.53,87.92 196.05,86.78 199.33,87.35 202.21,86.85 205.08,87.35 208.17,86.81 212.42,87.56 214.33,87.22 216.27,87.57 216.32,87.56 216.32,87.55 218.31,87.2 221.43,87.75 228.3,86.54 228.45,86.65 228.55,87.22 228.9,87.46 229.51,87.35 229.75,87 229.65,86.43 229.76,86.28 230.13,86.21 230.29,86.32 230.39,86.89 230.74,87.14 231.34,87.03 231.59,86.68 231.49,86.11 231.59,85.95 231.96,85.89 232.12,86 232.22,86.57 232.57,86.81 233.17,86.71 233.42,86.36 233.32,85.79 233.43,85.63 233.8,85.57 233.95,85.68 234.05,86.25 234.4,86.49 235.01,86.38 235.25,86.03 235.15,85.46 235.29,85.26 242.6,83.97 245.62,81.86 245.91,81.44 246.01,80.9 246.01,79.77 arc(246.05,79.68) 246.14,79.64 246.45,79.64 arc(246.8,79.49) 246.95,79.14 246.95,75.32 247.1,75.17 247.27,75.08 247.45,75.14 J3.A47
  BOTTOM w0.135: U1.J30 v4(90.36,94.13)
