# Allegro board 4-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_SLOT1_RX_DN<6>: length 180.4
  IN3 w0.089: v4(91.36,67.13) 91.36,67.45 91.41,67.49 91.62,67.49 91.77,67.34 91.77,62.94 91.72,62.89 91.72,62.87
  IN3 w0.135: J1.A44 251.2,34.01 251.14,34.19 250.93,34.29 250.69,34.53 250.69,38.47 arc(250.82,38.77) 251.11,38.9 251.54,38.9 arc(251.64,38.93) 251.68,39.03 251.68,40.39 251.33,40.89 249.49,42.18 237.72,44.25 235.7,43.9 215.59,47.44 213.96,47.15 208.57,48.1 199.02,54.79 189.8,56.41 189.8,56.42 188.55,56.63 188.54,56.63 188.49,56.64 188.49,56.65 188.17,56.7 187.74,56.61 173.01,54.01 126.84,62.15 106.06,58.48 93.59,60.68 92.09,61.73 91.81,62.12 91.72,62.64 91.72,62.87
  BOTTOM w0.135: U1.H4 v4(91.36,67.13)
PE_SLOT1_RX_DN<7>: length 178.1
  IN3 w0.089: v4(90.36,67.13) 90.36,67.45 90.44,67.52 90.6,67.52 90.76,67.35 90.76,63.14 90.72,63.09 90.72,63.07
  IN3 w0.135: J1.A48 247.2,34.01 247.14,34.19 246.93,34.29 246.68,34.55 246.68,38.51 arc(246.61,38.66) 246.46,38.73 246.25,38.73 arc(245.87,38.88) 245.72,39.26 245.72,40.38 245.22,41.09 244.51,41.59 243.95,41.69 243.91,41.7 241.88,42.05 241.64,42.4 241.68,42.65 241.57,42.81 241.2,42.87 241.05,42.76 241,42.52 240.65,42.27 240.05,42.38 239.8,42.73 239.85,42.97 239.74,43.13 239.37,43.19 239.21,43.09 239.17,42.84 238.82,42.59 238.14,42.71 237.96,42.97 238.01,43.3 237.91,43.45 237.54,43.52 237.38,43.41 237.38,43.4 237.34,43.16 236.97,42.9 215.29,46.73 213.94,46.49 213.84,46.49 208.34,47.46 208.28,47.47 198.71,54.17 189.09,55.87 188.87,55.91 188.87,55.91 188.27,56.01 173.09,53.33 126.84,61.49 106.06,57.82 93.04,60.11 91.43,61.24 90.81,62.12 90.72,62.67 90.72,63.07
  BOTTOM w0.135: U1.J4 v4(90.36,67.13)
PE_SLOT1_RX_DN<8>: length 173.7
  IN3 w0.089: 89.72,63.07 89.72,63.09 89.77,63.14 89.77,67.46 89.7,67.54 89.43,67.54 89.36,67.47 v4(89.36,67.13)
  IN3 w0.135: J1.A53 242.2,34.5 242.39,34.44 242.56,34.53 242.67,34.65 242.67,38.44 arc(242.62,38.58) 242.48,38.63 242.1,38.63 arc(241.81,38.76) 241.68,39.06 241.68,40.3 241.4,40.7 239.95,41.72 239.55,41.79 239.39,41.67 239,41.74 238.89,41.9 238.49,41.97 238.33,41.86 237.93,41.93 237.82,42.09 226.61,44.07 215.31,46.06 203.39,43.96 199.45,44.65 188.61,52.24 188.42,52.2 188.09,52.44 188.06,52.63 187.73,52.86 187.54,52.83 187.2,53.06 187.17,53.25 186.84,53.48 186.65,53.45 186.32,53.68 186.28,53.87 185.84,54.18 184.69,54.38 184.61,54.37 173.91,52.49 127.87,60.6 107.2,56.96 92.8,59.49 91.34,60.51 90.83,60.87 89.72,62.45 89.72,63.07
  BOTTOM w0.135: U1.K4 v4(89.36,67.13)
PE_SLOT1_RX_DN<9>: length 171.3
  IN3 w0.089: v4(88.36,67.13) 88.36,67.48 88.42,67.54 88.67,67.54 88.77,67.44 88.77,63.15 88.73,63.1 88.73,63.07
  IN3 w0.135: J1.A57 238.2,34.5 238.39,34.44 238.56,34.53 238.69,34.66 238.69,38.44 arc(238.63,38.58) 238.49,38.63 238.1,38.63 arc(237.8,38.76) 237.67,39.06 237.67,40.69 237.59,41.16 237.44,41.38 237.21,41.54 236.58,41.65 235.96,41.76 235.8,41.65 235.4,41.72 235.29,41.88 234.89,41.95 234.73,41.84 234.33,41.91 234.22,42.06 215.32,45.4 203.32,43.28 199.15,44.02 189.47,50.8 188.96,50.89 186.28,52.76 186.09,52.73 185.76,52.96 185.73,53.15 185.2,53.52 184.36,53.67 173.82,51.81 127.79,59.93 107.18,56.29 99.87,57.58 92.54,58.88 91.25,59.78 91.06,59.74 90.73,59.98 90.69,60.17 90.36,60.4 89.97,60.97 89.78,61 89.54,61.33 89.58,61.52 89.35,61.85 89.16,61.89 88.92,62.22 88.96,62.41 88.73,62.74 88.73,63.07
  BOTTOM w0.135: U1.L4 v4(88.36,67.13)
PE_SLOT1_RX_DN<10>: length 168
  IN3 w0.089: v4(87.36,67.13) 87.36,67.49 87.43,67.55 87.6,67.55 87.77,67.38 87.77,63.27 87.73,63.22 87.73,63.2
  IN3 w0.135: 87.73,63.2 87.73,62.79 87.79,62.7 88.38,61.86 88.8,61.26 89.77,59.87 89.8,59.83 91.01,58.99 92.23,58.13 107.03,55.53 127.95,59.22 174,51.1 183.74,52.81 184.76,52.63 184.8,52.61 185.09,52.4 185.12,52.21 185.46,51.98 185.65,52.01 185.98,51.78 186.01,51.59 186.34,51.36 186.53,51.39 186.86,51.16 186.9,50.97 187.23,50.74 187.42,50.77 188.06,50.32 189.25,50.11 198.85,43.39 203.49,42.58 215.53,44.7 229.54,42.23 229.65,42.07 230.05,42 230.21,42.11 230.61,42.04 230.72,41.88 231.11,41.81 231.27,41.92 232.09,41.78 233.34,40.91 233.68,40.42 233.68,39.03 arc(233.8,38.73) 234.1,38.61 234.5,38.61 arc(234.62,38.56) 234.67,38.44 234.67,34.65 234.56,34.53 234.39,34.44 234.2,34.5 J1.A61
  BOTTOM w0.135: U1.M4 v4(87.36,67.13)
PE_SLOT1_RX_DN<11>: length 165.6
  IN3 w0.089: 86.73,63.1 86.73,63.12 86.78,63.17 86.78,67.42 86.66,67.54 86.42,67.54 86.36,67.49 v4(86.36,67.13)
  IN3 w0.135: 86.73,63.1 86.73,62.8 86.8,62.7 89.08,59.44 91.78,57.55 99.5,56.19 107.2,54.83 127.87,58.47 175.46,50.08 180.57,50.98 182.61,50.62 182.71,50.47 182.68,50.25 182.92,49.9 183.53,49.79 183.88,50.04 183.91,50.26 184.07,50.37 188.96,49.5 198.57,42.78 203.56,41.9 215.45,43.99 223.09,42.65 223.21,42.49 223.6,42.42 223.76,42.53 224.16,42.46 224.27,42.3 224.67,42.23 224.83,42.34 225.23,42.27 225.34,42.11 225.73,42.04 225.89,42.15 226.29,42.08 226.4,41.92 226.8,41.85 226.96,41.97 227.36,41.9 227.47,41.74 227.87,41.67 228.02,41.78 228.96,41.61 229.3,41.37 229.69,40.82 229.69,39.03 arc(229.81,38.73) 230.11,38.61 230.55,38.61 arc(230.65,38.57) 230.68,38.47 230.68,34.66 230.56,34.53 230.39,34.44 230.2,34.5 J1.A65
  BOTTOM w0.135: U1.N4 v4(86.36,67.13)
PE_SLOT1_RX_DN<12>: length 161.9
  IN3 w0.089: 85.73,63.17 85.73,63.2 85.77,63.24 85.77,67.41 85.63,67.55 85.43,67.55 85.36,67.49 v4(85.36,67.13)
  IN3 w0.135: 85.73,63.17 85.73,62.9 85.82,62.76 88.48,58.96 91.44,56.89 95.43,56.19 103.24,54.81 107.17,54.12 127.87,57.77 181.61,48.3 186.77,49.21 188.75,48.86 198.32,42.16 199.99,41.86 200.11,41.71 200.5,41.64 200.66,41.75 201.06,41.68 201.17,41.52 201.57,41.45 201.73,41.56 202.13,41.49 202.24,41.33 202.63,41.26 202.79,41.37 203.88,41.18 215.38,43.21 222,42.04 222.11,41.88 222.51,41.81 222.67,41.92 223.07,41.85 223.18,41.69 223.57,41.62 223.73,41.73 225.03,41.51 225.33,41.29 225.68,40.8 225.68,39.19 arc(225.86,38.76) 226.29,38.58 226.54,38.58 arc(226.64,38.54) 226.69,38.43 226.69,34.66 226.55,34.53 226.38,34.44 226.2,34.5 J1.A69
  BOTTOM w0.135: U1.P4 v4(85.36,67.13)
PE_SLOT1_RX_DN<13>: length 163.7
  IN3 w0.089: 84.72,63.13 84.72,63.15 84.77,63.2 84.77,67.34 84.58,67.54 84.45,67.54 84.36,67.45 v4(84.36,67.13)
  IN3 w0.135: 84.72,63.13 84.72,62.9 84.75,62.87 85.1,62.36 85.07,62.17 85.3,61.84 85.49,61.8 85.72,61.47 85.69,61.28 85.92,60.95 86.11,60.92 86.34,60.59 86.31,60.39 86.54,60.06 86.73,60.03 87.2,59.36 87.7,58.65 91.07,56.29 107.3,53.43 127.85,57.04 182.08,47.48 186.57,48.27 186.74,48.24 187.23,48.15 187.91,47.68 188.33,47.75 188.5,48 188.69,48.03 189,47.82 189.03,47.63 188.86,47.38 188.93,46.96 189.43,46.61 189.86,46.69 190.03,46.93 190.21,46.96 190.52,46.75 190.55,46.56 190.38,46.32 190.46,45.9 190.96,45.54 191.38,45.62 191.55,45.86 191.74,45.9 192.05,45.68 192.08,45.5 191.91,45.25 191.98,44.83 192.48,44.48 192.9,44.55 193.08,44.8 193.26,44.83 193.57,44.61 193.6,44.43 193.43,44.18 193.51,43.76 194.01,43.41 194.43,43.48 194.6,43.73 194.79,43.76 195.09,43.55 195.13,43.36 195.11,43.33 194.96,43.11 195.03,42.69 196.47,41.69 203.48,40.45 215.06,42.49 217.4,42.08 217.52,41.92 217.91,41.85 218.07,41.96 218.47,41.89 218.58,41.73 218.98,41.66 219.14,41.77 219.54,41.7 219.65,41.54 220.04,41.47 220.2,41.58 220.6,41.51 221.27,41.04 221.68,40.46 221.68,39.06 arc(221.81,38.76) 222.1,38.63 222.5,38.63 arc(222.62,38.58) 222.68,38.46 222.68,34.67 222.51,34.51 222.38,34.44 222.2,34.5 J1.A73
  BOTTOM w0.135: U1.R4 v4(84.36,67.13)
PE_SLOT1_RX_DN<14>: length 154.9
  IN3 w0.089: 83.71,63.1 83.71,63.12 83.76,63.17 83.76,67.46 83.65,67.56 83.45,67.56 83.36,67.48 v4(83.36,67.13)
  IN3 w0.135: J1.A77 218.2,34.5 218.38,34.44 218.55,34.53 218.7,34.67 218.7,38.45 arc(218.66,38.54) 218.56,38.58 218.11,38.58 arc(217.81,38.71) 217.68,39.01 217.68,40.04 217.25,40.66 216.38,40.82 216.22,40.71 215.83,40.78 215.71,40.93 215.32,41 215.16,40.89 214.76,40.96 214.65,41.12 212.9,41.43 203.46,39.77 199.78,40.42 199.62,40.3 199.23,40.37 199.12,40.53 198.72,40.6 198.56,40.49 198.16,40.56 198.05,40.72 197.65,40.79 197.49,40.68 197.1,40.75 196.98,40.91 192.18,41.76 185.97,46.1 128.08,56.31 107.61,52.7 90.85,55.65 86.81,58.48 83.74,62.87 83.71,62.91 83.71,63.1
  BOTTOM w0.135: U1.T4 v4(83.36,67.13)
PE_SLOT1_RX_DN<15>: length 153.3
  IN3 w0.089: v4(82.36,67.13) 82.36,67.47 82.45,67.55 82.62,67.55 82.77,67.41 82.77,63.09 82.72,63.04 82.72,63.02
  IN3 w0.135: J1.A81 214.2,34.5 214.38,34.44 214.39,34.44 214.53,34.51 214.67,34.66 214.67,38.27 arc(214.58,38.49) 214.36,38.58 214.08,38.58 arc(213.78,38.71) 213.66,39 213.66,40.39 213.54,40.56 213.41,40.65 212.96,40.73 211.8,40.53 211.68,40.37 211.29,40.3 211.13,40.41 210.73,40.34 210.62,40.18 210.22,40.11 210.06,40.22 209.66,40.15 209.55,39.99 209.16,39.92 209,40.03 208.6,39.96 208.49,39.8 208.09,39.73 207.93,39.84 206.92,39.67 206.81,39.51 206.9,39 206.65,38.65 206.05,38.54 205.7,38.78 205.61,39.3 205.43,39.42 204.64,39.24 204.54,39.07 204.14,38.98 203.98,39.09 203.42,38.96 203,39.03 195.16,40.42 194.64,40.51 194.64,40.51 192.23,40.93 187.04,43.64 179.91,46.04 173.43,47.53 170.33,48.16 127.98,55.63 107.57,52.03 101.06,53.18 101.06,53.18 92.5,54.69 90.33,55.07 86.2,57.96 82.76,62.87 82.72,62.93 82.72,63.02
  BOTTOM w0.135: U1.U4 v4(82.36,67.13)
PE_SLOT1_RX_DP<0>: length 203.1
  IN3 w0.089: 99.22,71.4 99.2,71.42 99.14,71.42 98.81,71.74 95.05,71.74 94.77,71.46 94.77,71.24 94.65,71.13 v4(94.36,71.13)
  IN3 w0.135: J1.A16 278.45,34.01 278.51,34.19 278.73,34.29 278.95,34.52 278.95,38.29 arc(278.79,38.68) 278.4,38.84 278.13,38.84 arc(278.04,38.88) 278,38.98 278,40.53 277.42,41.35 275.35,42.8 274.69,42.92 269.88,43.77 267.31,44.22 262.71,47.44 250.35,49.62 241.26,48.02 237.74,48.64 235.62,48.26 215.55,51.8 213.88,51.51 210.39,52.12 200.73,58.89 200.67,58.93 187.54,61.24 186.89,61.36 171.51,58.64 127.02,66.49 119.07,65.08 115.11,65.78 113.49,65.5 113.11,65.56 112.74,65.63 111.89,65.78 109.56,65.37 107.6,65.71 106.27,65.48 104.96,65.71 103.81,65.51 102.88,65.51 102.05,66.09 100.47,68.34 100.15,70.15 99.52,71.06 99.41,71.21 99.22,71.4
  BOTTOM w0.135: U1.E8 v4(94.36,71.13)
PE_SLOT1_RX_DP<1>: length 202.5
  IN3 w0.089: v4(94.36,70.13) 94.67,70.13 94.75,70.21 94.75,70.44 95.04,70.73 98.72,70.73 99.32,70.13 99.32,69.57 99.36,69.52 99.36,69.5
  IN3 w0.135: J1.A21 273.45,34.5 273.27,34.44 273.1,34.53 272.98,34.65 272.98,38.47 arc(273.02,38.58) 273.14,38.63 273.56,38.63 arc(273.86,38.76) 273.98,39.06 273.98,40.66 273.44,41.43 272.2,42.29 265.08,43.55 265.06,43.59 264.98,43.7 265.1,44.4 264.85,44.75 264.25,44.85 263.9,44.61 263.78,43.92 263.62,43.81 261.1,44.25 260.39,44.75 260.09,45.18 259.85,46.53 259.46,47.09 258.97,47.44 250.35,48.96 241.26,47.36 237.74,47.98 235.55,47.59 215.48,51.13 215.45,51.1 215.43,51.1 213.89,50.83 210.17,51.49 200.42,58.31 187.23,60.63 185.12,60.26 171.77,57.91 127.09,65.79 126.83,65.79 109.27,62.69 101.84,64 101.49,64.25 99.8,66.66 99.36,67.32 99.36,69.5
  BOTTOM w0.135: U1.E7 v4(94.36,70.13)
PE_SLOT1_RX_DP<2>: length 197.8
  IN3 w0.089: v4(94.36,69.13) 94.62,69.13 94.77,69.28 94.77,69.42 95.06,69.71 96.68,69.71 96.97,69.42 96.97,64.79 97.01,64.74 97.01,64.72
  IN3 w0.135: 97.01,64.72 97.01,64.49 97.05,64.28 97.31,63.91 98.77,62.88 98.79,62.87 99.05,62.69 106.08,61.45 126.02,64.97 126.85,65.11 126.87,65.12 126.87,65.12 126.96,65.13 171.99,57.2 187.48,59.93 188.18,59.81 200.17,57.69 209.95,50.84 213.83,50.16 215.44,50.44 235.5,46.9 237.62,47.28 241.09,46.67 250.23,48.28 254.93,47.45 255.48,47.07 255.83,46.56 256.1,45.03 256.37,44.64 257.1,44.14 267.28,42.34 267.33,42.33 268.27,42.17 269.39,41.38 269.98,40.79 269.98,39.03 arc(269.85,38.73) 269.56,38.61 269.12,38.61 arc(269.03,38.57) 268.99,38.47 268.99,34.64 269.1,34.53 269.27,34.44 269.45,34.5 J1.A25
  BOTTOM w0.135: U1.E6 v4(94.36,69.13)
PE_SLOT1_RX_DP<3>: length 195.5
  IN3 w0.089: v4(94.36,68.13) 94.64,68.13 94.77,68.26 94.77,68.42 95.07,68.72 95.71,68.72 95.95,68.48 95.95,64.77 96,64.72 96,64.7
  IN3 w0.135: J1.A29 265.45,34.5 265.27,34.44 265.1,34.53 265,34.63 265,38.36 arc(264.84,38.74) 264.47,38.9 264.13,38.9 arc(264.03,38.93) 263.99,39.03 263.99,40.86 263.6,41.42 262.26,42.36 261.25,42.53 258.52,43.02 258.51,43.02 253.15,43.96 252.44,44.46 252.1,44.94 251.8,46.66 251.5,47.08 250.91,47.5 250.23,47.62 247.06,47.06 246.74,46.6 246.94,45.47 246.81,45.28 246.49,45.22 246.31,45.35 246.13,46.34 246.11,46.46 245.68,46.76 245.19,46.67 244.91,46.28 244.99,45.84 244.88,45.68 244.51,45.62 244.35,45.73 244.27,46.19 243.87,46.47 241.17,45.99 237.67,46.61 235.56,46.23 215.49,49.77 213.88,49.49 209.65,50.23 199.91,57.06 188.82,59.01 187.72,59.21 187.1,59.1 172.26,56.48 170.91,56.72 170.9,56.72 143.41,61.57 126.96,64.47 126.76,64.44 126.75,64.44 126.64,64.42 126.08,64.32 107.53,61.04 106.14,60.8 106.08,60.79 105.88,60.82 98.25,62.15 98.23,62.16 98.18,62.2 96.9,63.1 96.59,63.31 96.09,64.02 96,64.56 96,64.7
  BOTTOM w0.135: U1.E5 v4(94.36,68.13)
PE_SLOT1_RX_DP<4>: length 186.2
  IN3 w0.089: v4(93.36,68.13) 93.36,67.81 93.49,67.69 93.7,67.69 93.94,67.44 93.94,63.62 93.99,63.58 93.99,63.55
  IN3 w0.135: J1.A35 259.45,34.5 259.27,34.44 259.1,34.53 258.98,34.65 258.98,38.47 arc(259.02,38.57) 259.12,38.61 259.55,38.61 arc(259.85,38.73) 259.97,39.03 259.97,40.79 259.45,41.53 258.38,42.28 237.67,45.93 235.61,45.56 215.49,49.11 213.78,48.81 209.42,49.58 199.64,56.43 188.09,58.47 188.07,58.47 188.06,58.47 172.64,55.75 126.96,63.81 105.97,60.11 94.73,62.09 94.04,62.57 93.99,62.84 93.99,63.55
  BOTTOM w0.135: U1.F5 v4(93.36,68.13)
PE_SLOT1_RX_DP<5>: length 184.3
  IN3 w0.089: v4(92.36,68.13) 92.36,67.78 92.45,67.7 92.69,67.7 92.94,67.44 92.94,62.94 92.99,62.89 92.99,62.87
  IN3 w0.135: J1.A39 255.45,34.5 255.27,34.44 255.1,34.53 254.99,34.64 254.99,38.47 arc(255.03,38.57) 255.13,38.61 255.52,38.61 arc(255.82,38.73) 255.94,39.03 255.94,40.71 255.55,41.28 253.99,42.37 252.78,42.58 252.42,42.33 252.36,42.02 252.19,41.91 251.94,41.95 251.82,42.12 251.87,42.42 251.63,42.77 237.73,45.22 235.7,44.87 215.54,48.42 213.89,48.13 209.04,48.99 199.36,55.76 188.34,57.71 186.77,57.43 172.92,54.99 126.91,63.11 126.72,63.11 126.63,63.09 105.97,59.45 94.23,61.52 93.15,62.27 92.99,62.5 92.99,62.87
  BOTTOM w0.135: U1.G5 v4(92.36,68.13)
PE_SLOT1_RX_DP<6>: length 180.4
  IN3 w0.089: 92.01,62.87 92.01,62.89 91.96,62.94 91.96,67.42 91.7,67.69 91.47,67.69 91.36,67.79 v4(91.36,68.13)
  IN3 w0.135: 92.01,62.87 92.01,62.66 92.08,62.23 92.3,61.93 93.7,60.95 106.06,58.77 126.84,62.44 173.01,54.3 187.68,56.89 188.16,56.99 188.53,56.93 188.54,56.93 188.6,56.92 189.85,56.7 189.85,56.7 199.13,55.07 208.69,48.38 213.96,47.45 215.59,47.73 235.7,44.19 237.72,44.55 249.6,42.45 251.54,41.1 251.96,40.48 251.96,39.03 arc(251.84,38.73) 251.54,38.61 251.11,38.61 arc(251.02,38.57) 250.98,38.47 250.98,34.65 251.1,34.53 251.27,34.44 251.45,34.5 J1.A43
  BOTTOM w0.135: U1.H5 v4(91.36,68.13)
PE_SLOT1_RX_DP<7>: length 178.1
  IN3 w0.089: v4(90.36,68.13) 90.36,67.78 90.44,67.71 90.67,67.71 90.95,67.43 90.95,63.14 91,63.09 91,63.07
  IN3 w0.135: J1.A47 247.45,34.5 247.27,34.44 247.1,34.53 246.97,34.66 246.97,38.51 arc(246.82,38.87) 246.46,39.01 246.25,39.01 arc(246.08,39.08) 246.01,39.26 246.01,40.47 245.43,41.3 244.62,41.86 244,41.97 243.99,41.97 243.96,41.98 242.05,42.32 241.94,42.47 241.98,42.72 241.74,43.07 241.13,43.17 240.78,42.93 240.74,42.68 240.58,42.57 240.22,42.64 240.11,42.79 240.15,43.04 239.9,43.39 239.3,43.5 238.95,43.25 238.91,43.01 238.75,42.9 238.3,42.98 238.26,43.04 238.32,43.36 238.07,43.71 237.47,43.82 237.12,43.58 237.07,43.33 236.9,43.21 215.29,47.02 213.92,46.78 213.87,46.78 208.39,47.74 203.66,51.06 198.82,54.44 190.49,55.91 188.87,56.2 188.27,56.3 173.09,53.63 126.84,61.78 106.06,58.11 93.15,60.39 91.64,61.45 91.08,62.24 91,62.7 91,63.07
  BOTTOM w0.135: U1.J5 v4(90.36,68.13)
PE_SLOT1_RX_DP<8>: length 173.7
  IN3 w0.089: 90.01,63.07 90.01,63.09 89.96,63.14 89.96,67.54 89.78,67.73 89.47,67.73 89.36,67.83 v4(89.36,68.13)
  IN3 w0.135: J1.A52 242.45,34.01 242.51,34.19 242.73,34.29 242.96,34.53 242.96,38.44 arc(242.82,38.78) 242.48,38.92 242.1,38.92 arc(242.01,38.96) 241.97,39.06 241.97,40.39 241.61,40.9 240.06,41.99 237.87,42.37 215.31,46.35 203.39,44.25 199.56,44.93 188.78,52.47 186.45,54.1 186,54.42 185.95,54.46 184.7,54.68 184.56,54.66 173.91,52.78 127.87,60.9 107.2,57.25 92.91,59.76 91.04,61.07 90.01,62.54 90.01,63.07
  BOTTOM w0.135: U1.K5 v4(89.36,68.13)
PE_SLOT1_RX_DP<9>: length 171.3
  IN3 w0.089: 89.01,63.07 89.01,63.1 88.96,63.15 88.96,67.51 88.75,67.73 88.45,67.73 88.36,67.81 v4(88.36,68.13)
  IN3 w0.135: J1.A56 238.45,34.01 238.51,34.19 238.73,34.29 238.97,34.54 238.97,38.44 arc(238.83,38.78) 238.49,38.92 238.1,38.92 arc(238,38.96) 237.96,39.06 237.96,40.71 237.86,41.27 237.64,41.59 237.32,41.81 215.32,45.69 203.32,43.57 199.26,44.29 189.58,51.07 189.07,51.16 185.31,53.79 184.38,53.95 184.38,53.96 184.36,53.96 173.82,52.1 127.79,60.22 107.18,56.59 92.65,59.15 90.57,60.61 89.01,62.83 89.01,63.07
  BOTTOM w0.135: U1.L5 v4(88.36,68.13)
PE_SLOT1_RX_DP<10>: length 168.1
  IN3 w0.089: 88.01,63.2 88.01,63.22 87.96,63.27 87.96,67.46 87.68,67.74 87.43,67.74 87.36,67.81 v4(87.36,68.13)
  IN3 w0.135: J1.A60 234.45,34.01 234.51,34.19 234.73,34.29 234.96,34.53 234.96,38.44 arc(234.83,38.76) 234.5,38.9 234.1,38.9 arc(234,38.93) 233.96,39.03 233.96,40.51 233.54,41.11 232.2,42.05 229.59,42.51 215.53,44.99 203.49,42.87 198.96,43.67 189.36,50.38 188.17,50.6 184.96,52.84 184.87,52.91 183.74,53.11 174,51.39 127.95,59.51 107.03,55.82 92.34,58.4 91.78,58.79 90,60.04 89.08,61.35 89.08,61.36 88.61,62.03 88.01,62.88 88.01,63.2
  BOTTOM w0.135: U1.M5 v4(87.36,68.13)
PE_SLOT1_RX_DP<11>: length 165.7
  IN3 w0.089: v4(86.36,68.13) 86.36,67.81 86.45,67.73 86.73,67.73 86.97,67.5 86.97,63.17 87.02,63.12 87.02,63.1
  IN3 w0.135: 87.02,63.1 87.02,62.89 87.03,62.87 88.16,61.26 89.29,59.65 91.9,57.82 107.2,55.12 117.49,56.93 117.49,56.93 127.87,58.76 175.46,50.37 180.57,51.27 182.77,50.89 183.02,50.54 182.98,50.32 183.09,50.16 183.46,50.1 183.61,50.21 183.65,50.42 184,50.67 189.08,49.78 198.68,43.05 201.12,42.62 201.12,42.62 203.56,42.19 215.45,44.29 223.14,42.93 229.07,41.89 229.51,41.58 229.98,40.91 229.98,39.03 arc(230.02,38.93) 230.11,38.9 230.55,38.9 arc(230.85,38.77) 230.97,38.47 230.97,34.54 230.73,34.29 230.51,34.19 230.45,34.01 J1.A64
  BOTTOM w0.135: U1.N5 v4(86.36,68.13)
PE_SLOT1_RX_DP<12>: length 161.9
  IN3 w0.089: v4(85.36,68.13) 85.36,67.81 85.44,67.74 85.71,67.74 85.96,67.49 85.96,63.24 86.01,63.2 86.01,63.17
  IN3 w0.135: 86.01,63.17 86.01,62.99 86.1,62.87 88.69,59.17 91.55,57.16 99.41,55.78 107.17,54.41 127.87,58.06 181.61,48.59 186.77,49.5 188.87,49.13 198.43,42.43 203.88,41.47 215.38,43.5 222.05,42.32 222.05,42.32 225.14,41.78 225.54,41.5 225.97,40.89 225.97,39.19 arc(226.06,38.96) 226.29,38.87 226.54,38.87 arc(226.85,38.74) 226.98,38.43 226.98,34.54 226.72,34.29 226.51,34.19 226.45,34.01 J1.A68
  BOTTOM w0.135: U1.P5 v4(85.36,68.13)
PE_SLOT1_RX_DP<13>: length 163.7
  IN3 w0.089: 85.01,63.13 85.01,63.15 84.96,63.2 84.96,67.42 84.66,67.73 84.45,67.73 84.36,67.81 v4(84.36,68.13)
  IN3 w0.135: 85.01,63.13 85.01,62.99 85.1,62.87 86.9,60.29 87.9,58.86 91.19,56.56 107.3,53.72 127.85,57.33 182.08,47.77 186.57,48.56 186.79,48.52 187.34,48.43 187.98,47.98 188.16,48.02 188.34,48.26 188.76,48.34 189.26,47.98 189.33,47.56 189.16,47.32 189.2,47.13 189.5,46.92 189.69,46.95 189.86,47.19 190.28,47.27 190.78,46.92 190.86,46.5 190.69,46.25 190.72,46.06 191.03,45.85 191.21,45.88 191.39,46.13 191.81,46.2 192.31,45.85 192.38,45.43 192.21,45.18 192.24,44.99 192.55,44.78 192.74,44.81 192.91,45.06 193.33,45.13 193.83,44.78 193.91,44.36 193.73,44.11 193.77,43.93 194.07,43.71 194.26,43.75 194.43,43.99 194.85,44.07 195.36,43.71 195.43,43.29 195.35,43.17 195.34,43.17 195.26,43.05 195.29,42.86 196.58,41.96 203.48,40.74 215.06,42.78 220.71,41.79 221.48,41.25 221.97,40.55 221.97,39.06 arc(222.01,38.96) 222.1,38.92 222.5,38.92 arc(222.83,38.78) 222.96,38.46 222.96,34.55 222.68,34.27 222.51,34.19 222.51,34.19 222.45,34.01 J1.A72
  BOTTOM w0.135: U1.R5 v4(84.36,68.13)
PE_SLOT1_RX_DP<14>: length 155
  IN3 w0.089: v4(83.36,68.13) 83.36,67.85 83.46,67.75 83.73,67.75 83.95,67.54 83.95,63.17 84,63.12 84,63.1
  IN3 w0.135: J1.A76 218.45,34.01 218.51,34.19 218.72,34.29 218.98,34.55 218.98,38.45 arc(218.86,38.75) 218.56,38.87 218.11,38.87 arc(218.01,38.91) 217.97,39.01 217.97,40.13 217.42,40.93 212.9,41.72 203.46,40.06 197.03,41.19 192.29,42.03 186.09,46.37 128.08,56.6 107.61,52.99 90.96,55.92 87.02,58.69 84.09,62.87 84,63 84,63.1
  BOTTOM w0.135: U1.T5 v4(83.36,68.13)
PE_SLOT1_RX_DP<15>: length 153.3
  IN3 w0.089: 83,63.02 83,63.04 82.96,63.09 82.96,67.49 82.7,67.74 82.43,67.74 82.36,67.81 v4(82.36,68.13)
  IN3 w0.135: J1.A80 214.45,34.01 214.51,34.19 214.7,34.28 214.96,34.54 214.96,38.27 arc(214.79,38.69) 214.36,38.87 214.08,38.87 arc(213.99,38.91) 213.95,39 213.95,40.48 213.75,40.77 213.53,40.92 212.96,41.02 206.75,39.93 206.5,39.58 206.59,39.06 206.48,38.91 206.12,38.84 205.96,38.95 205.87,39.47 205.49,39.73 203.41,39.25 196.27,40.51 194.69,40.79 192.32,41.21 187.15,43.91 179.99,46.32 176.1,47.21 173.49,47.81 170.39,48.44 170.38,48.44 127.98,55.92 107.57,52.32 94.66,54.6 94.66,54.6 90.44,55.34 86.4,58.17 83.11,62.87 83.06,62.94 83,63.02
  BOTTOM w0.135: U1.U5 v4(82.36,68.13)
PE_SLOT1_TX_C_DN<0>: length 194.3
  IN1 w0.089: v4(98.36,71.13) 98.09,71.13 98.01,71.21 98.01,71.51 98.2,71.7 98.22,71.72 98.96,71.85 99.08,71.83 99.2,71.81 99.24,71.75 99.26,71.75
  IN1 w0.122: v1(279.33,45.97) 279.69,46.34 279.69,46.56 279.65,46.75 279.35,46.96 253.55,51.51 251.12,51.08 249.28,51.41 247.19,51.04 245.65,51.31 243.02,50.84 240.68,51.26 237.5,50.69 235.1,51.12 232.82,50.72 230.79,51.07 229.04,50.77 226.72,51.17 224.64,50.81 222.73,51.14 218.52,50.4 211.42,51.65 204.77,56.31 200.85,57 199.17,58.18 198.4,58.72 198.09,58.94 197.8,59.14 155.38,66.62 149.03,67.74 119.55,62.54 112.81,63.73 112.3,64.08 111.75,64.87 111.53,64.91 111.33,65.21 111.36,65.42 111.15,65.72 110.94,65.76 110.73,66.06 110.77,66.27 110.56,66.57 110.04,66.94 108.89,67.14 108.23,67.6 107.58,68.53 106.8,69.07 105.44,69.31 104.64,69.87 104.43,69.84 104.13,70.05 104.09,70.26 103.79,70.47 103.58,70.43 103.28,70.64 103.24,70.86 102.88,71.11 102.88,71.11 101.31,71.39 101.13,71.26 100.77,71.33 100.65,71.5 100.29,71.57 100.11,71.44 99.75,71.51 99.62,71.68 99.26,71.75
  BOTTOM w0.135: v1(279.33,45.97) 279.68,45.62 279.68,44.82 C199.1 ; U1.A8 v4(98.36,71.13)
PE_SLOT1_TX_C_DN<1>: length 193.3
  IN1 w0.089: 99.47,70.45 99.45,70.45 99.41,70.51 99.4,70.51 99.26,70.54 98.06,70.54 97.98,70.46 97.98,70.27 98.12,70.13 v4(98.36,70.13)
  IN1 w0.122: 99.47,70.45 99.52,70.44 101.57,70.08 101.87,69.87 101.91,69.65 102.21,69.44 102.42,69.48 102.72,69.27 102.76,69.06 103.06,68.85 103.27,68.89 103.57,68.68 103.61,68.46 103.91,68.25 104.12,68.29 105.18,67.55 105.98,67.41 106.42,67.11 106.85,66.8 107.46,65.93 107.76,65.72 107.8,65.51 108.1,65.3 108.31,65.34 111.23,63.29 111.68,63.21 111.78,63.07 111.73,62.77 111.97,62.43 112.59,62.32 112.93,62.56 112.98,62.86 113.12,62.96 113.5,62.89 113.6,62.75 113.55,62.45 113.78,62.11 114.4,62 114.74,62.24 114.8,62.54 114.94,62.64 115.32,62.57 115.42,62.43 115.36,62.13 115.6,61.79 116.22,61.68 116.56,61.92 116.61,62.22 116.75,62.32 117.14,62.25 117.23,62.11 117.18,61.81 117.42,61.47 118.04,61.36 118.38,61.6 118.43,61.9 118.57,62 119.52,61.83 149.13,67.05 155.48,65.93 197.4,58.54 200.51,56.36 204.42,55.67 211.14,50.96 218.43,49.68 222.86,50.46 224.95,50.09 227.04,50.46 229.07,50.1 230.74,50.39 232.77,50.03 235.05,50.44 237.44,50.01 240.73,50.59 243.02,50.19 245.58,50.64 247.18,50.36 249.21,50.72 251.22,50.36 253.78,50.81 271.78,47.64 271.91,47.46 272.27,47.4 272.44,47.52 272.8,47.46 272.93,47.28 273.29,47.22 273.47,47.34 273.83,47.28 273.95,47.1 274.31,47.04 274.49,47.16 274.85,47.1 275.67,46.52 275.67,46.34 v1(275.31,45.97)
  BOTTOM w0.135: U1.A7 v4(98.36,70.13) ; C200.1 275.67,44.82 275.67,45.62 v1(275.31,45.97)
PE_SLOT1_TX_C_DN<2>: length 185.7
  IN1 w0.089: v4(98.36,69.13) 98.08,69.13 97.98,69.23 97.98,69.45 98.06,69.54 98.49,69.54 98.94,69.62 99.41,69.53 99.45,69.47 99.47,69.47
  IN1 w0.122: 99.47,69.47 99.52,69.46 99.61,69.45 99.91,69.24 99.95,69.02 100.25,68.81 100.46,68.85 100.76,68.64 100.8,68.43 101.1,68.22 101.31,68.25 101.61,68.04 101.65,67.83 101.95,67.62 102.16,67.66 102.46,67.45 102.5,67.24 102.8,67.03 103.01,67.06 103.77,66.53 104.4,65.63 104.75,65.39 104.79,65.17 105.09,64.96 105.3,65 105.6,64.79 105.64,64.58 105.94,64.37 106.15,64.4 109.22,62.26 109.29,62.25 118.07,60.7 149.55,66.25 155.9,65.13 197.21,57.85 200.52,55.53 204.47,54.83 210.91,50.32 218.44,49 222.9,49.78 224.99,49.41 227.13,49.79 229.18,49.43 230.81,49.72 232.8,49.37 235.08,49.77 237.46,49.35 240.78,49.93 243.02,49.54 245.57,49.99 247.19,49.7 249.18,50.05 251.31,49.68 253.92,50.14 269.82,47.33 269.94,47.16 270.3,47.09 270.48,47.22 270.84,47.15 271.62,46.61 271.64,46.53 271.64,46.34 v1(271.27,45.97)
  BOTTOM w0.135: v1(271.27,45.97) 271.63,45.62 271.63,44.82 C201.1 ; U1.A6 v4(98.36,69.13)
PE_SLOT1_TX_C_DN<3>: length 183.5
  IN1 w0.089: v4(98.36,68.13) 98.01,68.13 97.94,68.2 97.94,68.42 98.06,68.54 98.86,68.54 99.32,68.22 99.32,68.22 99.33,68.15 99.35,68.13
  IN1 w0.122: 99.35,68.13 99.52,68.02 100.33,67.45 100.87,66.67 101.25,66.41 101.28,66.2 101.58,65.99 101.8,66.02 104.28,64.29 104.31,64.07 104.61,63.86 104.83,63.9 105.18,63.65 105.22,63.44 105.52,63.23 105.73,63.27 106.03,63.06 106.07,62.85 106.37,62.64 106.58,62.67 106.88,62.46 106.92,62.25 107.22,62.04 107.43,62.08 107.75,61.86 118.41,59.98 149.83,65.52 156.18,64.4 196.88,57.22 200.17,54.92 200.17,54.92 200.22,54.88 204.26,54.17 210.73,49.64 214.58,48.96 214.58,48.96 218.42,48.28 223.06,49.1 225.05,48.75 227.03,49.1 229.02,48.75 230.78,49.06 232.91,48.68 235.22,49.09 237.54,48.68 240.86,49.27 243.02,48.89 245.5,49.32 247.17,49.03 249.13,49.38 251.22,49.01 253.92,49.48 263.27,47.83 263.4,47.66 263.76,47.59 263.94,47.72 264.3,47.65 264.41,47.49 264.27,46.67 264.5,46.33 265.12,46.22 265.46,46.46 265.61,47.3 265.75,47.4 266.78,47.22 267.67,46.59 267.67,46.34 v1(267.31,45.97)
  BOTTOM w0.135: v1(267.31,45.97) 267.67,45.62 267.67,44.82 C202.1 ; U1.A5 v4(98.36,68.13)
PE_SLOT1_TX_C_DN<4>: length 179.8
  IN1 w0.089: v4(93.36,64.13) 93.36,64.45 93.42,64.5 93.69,64.5 93.79,64.4 93.79,63.82 93.7,63.34 93.77,62.95 93.73,62.89 93.73,62.87
  IN1 w0.122: v1(261.34,45.97) 261.7,46.34 261.7,46.51 261.66,46.77 261.53,46.95 260.52,47.66 260.16,47.72 259.98,47.6 259.62,47.66 259.5,47.84 259.14,47.9 258.96,47.78 258.6,47.84 258.47,48.02 258.11,48.08 257.94,47.96 257.58,48.02 257.45,48.2 253.91,48.82 253.91,48.82 253.53,48.76 252.44,48.57 251.16,48.34 249.08,48.71 247.19,48.37 245.57,48.66 242.96,48.2 240.8,48.58 237.55,48.01 235.23,48.41 232.94,48.01 230.87,48.38 229.12,48.07 227.11,48.42 227.11,48.42 225.14,48.08 223.39,48.39 218.69,47.56 210.16,49.06 210.1,49.1 203.79,53.52 200.1,54.17 196.74,56.52 156.15,63.68 149.8,64.8 118.44,59.27 113.95,60.06 108.31,59.07 94.84,61.44 94.15,61.93 93.85,62.35 93.81,62.46 93.73,62.87
  BOTTOM w0.135: C203.1 261.7,44.82 261.7,45.62 v1(261.34,45.97) ; U1.F1 v4(93.36,64.13)
PE_SLOT1_TX_C_DN<5>: length 177.4
  IN1 w0.089: v4(92.36,64.13) 92.36,64.45 92.42,64.5 92.68,64.5 92.77,64.42 92.77,63.97 92.65,63.81 92.54,63.19 92.58,62.95 92.54,62.89 92.55,62.87
  IN1 w0.122: 92.55,62.87 92.67,62.14 92.96,61.73 94.18,60.88 108.42,58.37 114.05,59.36 118.39,58.59 149.84,64.14 156.19,63.02 196.36,55.93 199.85,53.49 203.54,52.84 209.94,48.36 218.53,46.84 223.48,47.72 225.14,47.42 227.11,47.77 229.18,47.4 230.94,47.71 232.95,47.36 235.23,47.76 237.55,47.35 240.8,47.93 242.96,47.55 245.52,48 247.22,47.7 249.07,48.02 251.08,47.67 252.72,47.96 252.9,47.83 253.26,47.9 253.38,48.07 253.74,48.14 255.01,47.91 255.14,47.74 255.5,47.67 255.67,47.8 256.03,47.73 256.16,47.56 256.52,47.49 256.7,47.62 257.07,47.55 257.57,47.2 257.69,46.51 257.69,46.51 257.69,46.34 v1(257.33,45.97)
  BOTTOM w0.135: C204.1 257.68,44.82 257.68,45.62 v1(257.33,45.97) ; U1.G1 v4(92.36,64.13)
PE_SLOT1_TX_C_DN<6>: length 173.8
  IN1 w0.089: v4(91.36,64.13) 91.36,64.51 91.44,64.59 91.63,64.59 91.77,64.45 91.77,64 91.65,63.35 91.72,62.95 91.68,62.89 91.69,62.87
  IN1 w0.122: 91.69,62.87 91.82,62.08 92.34,61.35 93.1,60.82 93.87,60.28 108.67,57.67 114.09,58.62 118.27,57.88 149.81,63.44 156.16,62.33 195.94,55.31 199.49,52.82 203.2,52.17 209.57,47.71 218.51,46.13 223.64,47.04 225.14,46.77 227.11,47.12 229.36,46.72 231.11,47.03 232.95,46.71 235.16,47.1 237.48,46.69 240.79,47.27 242.94,46.89 245.52,47.34 247.23,47.04 249.01,47.36 251.12,46.99 251.24,46.81 251.6,46.75 251.78,46.87 252.14,46.81 252.26,46.63 252.62,46.57 252.8,46.69 253.53,46.56 253.68,46.46 253.68,46.34 v1(253.32,45.97)
  BOTTOM w0.135: v1(253.32,45.97) 253.67,45.62 253.67,44.82 C205.1 ; U1.H1 v4(91.36,64.13)
PE_SLOT1_TX_C_DN<7>: length 172.3
  IN1 w0.089: 90.8,63.25 90.79,63.27 90.84,63.33 90.8,63.54 90.77,63.71 90.77,64.4 90.66,64.5 90.42,64.5 90.36,64.45 v4(90.36,64.13)
  IN1 w0.122: v1(249.35,45.97) 249.72,46.34 249.72,46.45 249.7,46.47 249.44,46.62 248.97,46.7 248.54,46.62 248.41,46.44 248.05,46.38 247.88,46.51 247.06,46.36 246.7,46.43 246.53,46.3 246.17,46.37 246.04,46.54 245.68,46.61 244.98,46.48 244.88,46.34 244.97,45.84 244.73,45.5 244.11,45.39 243.77,45.63 243.68,46.13 243.54,46.23 243.11,46.15 242.36,46.29 242.18,46.16 241.82,46.22 241.7,46.4 240.63,46.59 237.44,46.03 235.26,46.41 233.08,46.03 231.14,46.37 229.36,46.06 227.08,46.46 225.08,46.11 225.06,46.1 225.01,46.09 223.69,46.33 218.62,45.43 208.93,47.14 202.57,51.59 199.3,52.17 197.48,53.44 195.78,54.64 156.09,61.64 149.74,62.76 118.15,57.19 113.91,57.93 108.51,56.98 93.63,59.6 91.75,60.92 91.03,61.95 90.8,63.25
  BOTTOM w0.135: C206.1 249.71,44.82 249.71,45.62 v1(249.35,45.97) ; U1.J1 v4(90.36,64.13)
PE_SLOT1_TX_C_DN<8>: length 166.4
  IN1 w0.089: v4(89.36,64.13) 89.36,64.45 89.42,64.5 89.65,64.5 89.76,64.39 89.76,63.99 90.06,63.16 90.1,62.95 90.06,62.89 90.06,62.87
  IN1 w0.122: v1(190.45,53.34) 190.08,53.71 190.07,53.71 189.84,53.71 188.33,53.98 152.53,60.28 146.18,61.4 118.11,56.45 113.77,57.22 108.53,56.29 93.42,58.96 91.27,60.46 90.41,61.69 90.22,61.96 90.09,62.71 90.06,62.87
  BOTTOM w0.135: C207.1 243.69,44.82 243.69,45.57 243.6,46.09 243.35,46.45 242.86,46.79 242.64,46.75 242.31,46.99 242.27,47.2 241.94,47.43 241.73,47.39 241.4,47.63 241.36,47.84 241.03,48.07 240.82,48.03 240.49,48.26 240.45,48.48 240.12,48.71 239.91,48.67 239.57,48.9 239.54,49.12 236.85,51 232.66,51.73 211.92,51.73 206.42,55.58 202.53,56.27 196.95,56.27 194.98,55.92 191.99,53.83 191.1,53.67 190.78,53.67 v1(190.45,53.34) ; U1.K1 v4(89.36,64.13)
PE_SLOT1_TX_C_DN<9>: length 164.2
  IN1 w0.089: 89.2,62.87 89.19,62.88 89.2,62.95 88.77,63.58 88.77,64.35 88.58,64.53 88.45,64.53 88.36,64.45 v4(88.36,64.13)
  IN1 w0.122: 89.2,62.87 89.2,62.87 89.41,62.57 89.43,62.51 89.6,61.57 90.65,60.07 93.12,58.34 108.5,55.63 113.71,56.55 118.13,55.77 146.05,60.69 152.4,59.57 188.15,53.27 188.91,52.73 189.88,52.06 190.69,51.91 191.41,52.04 191.86,52.35 192.27,52.43 192.64,52.43 v1(192.99,52.07)
  BOTTOM w0.135: C208.1 239.68,44.82 239.68,45.15 239.53,46 238.83,47 236.52,48.62 236.31,48.58 235.97,48.81 235.94,49.03 235.61,49.26 235.39,49.22 235.06,49.45 235.02,49.67 234.41,50.1 231.93,50.53 231.32,50.53 231.17,50.38 230.76,50.38 230.61,50.53 230.21,50.53 230.05,50.38 229.65,50.38 229.5,50.53 211.54,50.53 211.46,50.59 205.95,54.45 202.46,55.06 197.38,55.06 196.25,54.86 195.26,54.17 194.23,52.69 193.81,52.4 193.32,52.4 v1(192.99,52.07) ; U1.L1 v4(88.36,64.13)
PE_SLOT1_TX_C_DN<10>: length 160.8
  IN1 w0.089: 87.86,62.87 87.85,62.87 87.85,62.89 87.86,62.91 87.86,62.95 87.75,63.1 87.73,63.23 87.73,63.85 87.77,64.08 87.77,64.34 87.58,64.53 87.45,64.53 87.36,64.45 v4(87.36,64.13)
  IN1 w0.122: 87.86,62.87 90.14,59.6 92.83,57.72 108.63,54.94 113.74,55.84 118.13,55.06 146.15,60.01 152.51,58.89 187.62,52.69 189.49,51.39 193.38,50.7 194.4,50.88 194.62,51.03 194.86,51.38 194.95,51.87 194.95,52.32 195.07,52.44 195.29,52.44 v1(195.66,52.07)
  BOTTOM w0.135: C209.1 235.69,44.82 235.69,45.32 235.66,45.5 235.37,45.9 234.12,46.78 233.91,46.75 233.58,46.98 233.54,47.19 233.21,47.42 232.99,47.38 232.66,47.62 232.63,47.83 232.26,48.08 232.05,48.05 231.72,48.28 231.68,48.49 231.23,48.8 228.24,49.33 211.16,49.33 211.08,49.39 206.03,52.92 202.22,53.59 200.06,53.59 198.36,53.29 197.71,52.84 197.71,52.84 197.05,52.37 195.96,52.37 v1(195.66,52.07) ; U1.M1 v4(87.36,64.13)
PE_SLOT1_TX_C_DN<11>: length 159.2
  IN1 w0.089: 87.02,62.87 87.01,62.89 87.05,62.95 86.98,63.35 86.79,63.74 86.76,63.93 86.76,64.36 86.58,64.53 86.45,64.53 86.36,64.45 v4(86.36,64.13)
  IN1 w0.122: 87.02,62.87 87.05,62.68 87.41,62.16 89.55,59.1 92.34,57.15 108.73,54.26 113.77,55.15 118.27,54.36 146.26,59.3 152.61,58.18 187.02,52.11 190.21,49.87 190.26,49.82 193.51,49.25 195.3,49.25 v1(195.66,48.9)
  BOTTOM w0.135: v1(195.66,48.9) 195.99,49.23 196.49,49.23 196.95,49.55 197.77,50.72 199.51,51.94 201.3,52.25 202.22,52.25 203.51,52.03 203.63,51.85 204.03,51.78 204.21,51.9 204.61,51.83 204.73,51.65 205.13,51.58 205.31,51.71 205.7,51.64 210.63,48.19 210.71,48.13 225.33,48.13 225.48,47.98 225.88,47.98 226.04,48.13 226.55,48.13 227.44,47.98 227.56,47.8 227.96,47.73 228.13,47.85 228.14,47.85 228.57,47.77 229.24,47.31 229.27,47.12 228.94,46.65 229.02,46.22 229.74,45.71 230.17,45.79 230.51,46.26 230.69,46.29 231.5,45.73 231.66,45.5 231.7,45.25 231.7,44.82 C210.1 ; U1.N1 v4(86.36,64.13)
PE_SLOT1_TX_C_DN<12>: length 155.1
  IN1 w0.089: v4(85.36,64.13) 85.36,64.45 85.45,64.53 85.58,64.53 85.76,64.35 85.76,63.79 85.84,63.34 85.87,63.16 86.02,62.95 86.01,62.88 86.02,62.87
  IN1 w0.122: v1(198.32,48.9) 197.96,49.26 197.79,49.26 197.67,49.14 197.67,48.54 197.6,48.14 197.39,47.84 197.34,47.81 197.34,47.81 197.08,47.63 196.43,47.51 190.96,48.48 190.91,48.51 186.61,51.53 152.81,57.49 146.46,58.6 118.36,53.65 113.74,54.47 108.81,53.6 91.88,56.58 89.02,58.59 86.02,62.87
  BOTTOM w0.135: C211.1 227.69,44.82 227.69,45.22 227.57,45.49 226.79,45.97 226.61,45.92 226.27,46.13 226.22,46.3 225.81,46.55 223.69,46.93 210.15,46.93 205.31,50.32 204.34,50.49 204.16,50.36 203.76,50.44 203.64,50.61 203.24,50.68 203.06,50.56 202.67,50.63 202.54,50.81 201.98,50.9 200.81,50.7 200.28,50.32 199.86,49.73 199.22,49.28 198.71,49.28 v1(198.32,48.9) ; U1.P1 v4(85.36,64.13)
PE_SLOT1_TX_C_DN<13>: length 153.8
  IN1 w0.089: v4(84.36,64.13) 84.36,64.45 84.45,64.53 84.58,64.53 84.77,64.35 84.77,63.94 84.86,63.39 85.17,62.95 85.16,62.88 85.17,62.87
  IN1 w0.122: v1(201.12,48.77) 200.76,49.12 200.34,49.12 200.16,48.94 200.16,48.64 200.07,48.13 199.72,47.63 199.19,47.26 196.07,46.71 190.93,47.62 190.22,48.12 190.22,48.11 186.18,50.94 152.89,56.82 146.54,57.94 118.29,52.96 113.67,53.77 108.75,52.9 91.7,55.91 88.44,58.2 86.85,60.47 86.85,60.47 85.17,62.87
  BOTTOM w0.135: U1.R1 v4(84.36,64.13) ; v1(201.12,48.77) 201.45,49.1 204.2,49.1 205.21,48.92 209.77,45.73 210.48,45.73 210.64,45.57 211.04,45.57 211.19,45.73 211.6,45.73 211.75,45.57 212.16,45.57 212.31,45.73 212.71,45.73 212.87,45.57 213.27,45.57 213.42,45.73 213.83,45.73 213.98,45.57 214.38,45.57 214.54,45.73 220.36,45.73 220.49,45.59 220.49,44.59 220.83,44.25 221.64,44.25 222,44.6 222,45.59 222.13,45.73 222.65,45.73 223.02,45.66 223.51,45.32 223.7,45.05 223.7,44.82 C212.1
PE_SLOT1_TX_C_DN<14>: length 144.3
  IN1 w0.089: v4(83.36,64.13) 83.36,64.45 83.45,64.53 83.58,64.53 83.77,64.34 83.77,63.66 84.2,63.05 84.19,62.98 84.2,62.96
  IN1 w0.122: 84.2,62.96 84.26,62.87 87.76,57.88 91.47,55.28 108.8,52.22 113.51,53.05 118.27,52.22 146.78,57.24 153.42,56.07 185.76,50.37 190.58,46.99 196.53,45.94 198.43,46.27 198.7,46.32 200.07,46.08 200.76,46.08 v1(201.12,45.72)
  BOTTOM w0.135: v1(201.12,45.72) 201.47,46.08 201.84,46.08 202.48,46.52 202.9,47.12 203.13,47.35 203.52,47.62 203.97,47.7 204.23,47.7 205.06,47.55 209.39,44.53 212.12,44.04 216.87,44.04 C213.1 ; U1.T1 v4(83.36,64.13)
PE_SLOT1_TX_C_DN<15>: length 141
  IN1 w0.089: v4(82.36,64.13) 82.36,64.45 82.45,64.53 82.58,64.53 82.77,64.35 82.77,63.94 83.33,63.13 83.46,62.95 83.45,62.88 83.46,62.87
  IN1 w0.122: 83.46,62.87 87.3,57.38 91.23,54.63 108.7,51.55 113.47,52.39 118.22,51.55 146.79,56.59 153.14,55.47 185.49,49.76 190.52,46.24 194.8,45.48 194.81,45.48 199.09,44.73 199.19,44.59 199.15,44.35 199.39,44.01 200.01,43.9 200.34,44.14 200.39,44.37 200.53,44.47 201.42,44.31 202.28,44.47 202.67,45.02 202.8,45.74 203.02,45.96 203.29,45.96 v1(203.66,45.59)
  BOTTOM w0.135: U1.U1 v4(82.36,64.13) ; v1(203.66,45.59) 204.01,45.95 204.15,45.95 204.41,45.9 204.69,45.7 205.25,45.14 205.25,44.95 204.55,44.25 204.55,43.81 205.18,43.19 205.62,43.19 206.32,43.88 206.51,43.88 207.46,42.93 207.77,42.71 208.15,42.65 208.49,42.65 C214.1
PE_SLOT1_TX_C_DP<0>: length 194.3
  IN1 w0.089: v4(97.36,71.13) 97.68,71.13 97.82,71.27 97.82,71.59 98.12,71.89 98.15,71.9 98.19,71.91 98.96,72.05 99.23,72 99.29,72.04 99.31,72.04
  IN1 w0.122: v1(280.34,45.97) 279.98,46.34 279.98,46.58 279.92,46.92 279.47,47.23 253.55,51.8 251.12,51.38 249.28,51.7 247.19,51.33 245.65,51.6 243.02,51.14 240.68,51.55 237.5,50.99 235.1,51.41 232.82,51.01 230.79,51.37 229.04,51.06 226.72,51.47 224.64,51.1 222.73,51.44 218.52,50.7 211.53,51.93 204.88,56.59 200.97,57.28 198.57,58.96 198.56,58.96 197.91,59.42 155.38,66.92 149.03,68.04 119.55,62.84 112.92,64.01 112.51,64.29 110.77,66.78 110.15,67.22 109.01,67.42 108.44,67.81 107.79,68.74 106.92,69.35 105.56,69.59 103.05,71.35 102.99,71.39 99.32,72.04 99.31,72.04
  BOTTOM w0.135: v1(280.34,45.97) 279.99,45.62 279.99,44.82 C183.1 ; U1.B8 v4(97.36,71.13)
PE_SLOT1_TX_C_DP<1>: length 193.3
  IN1 w0.089: v4(97.36,70.13) 97.68,70.13 97.79,70.24 97.79,70.54 97.98,70.73 99.28,70.73 99.44,70.7 99.5,70.74 99.52,70.74
  IN1 w0.122: 99.52,70.74 101.69,70.35 105.29,67.83 106.1,67.69 107.06,67.01 107.67,66.14 111.35,63.57 111.85,63.48 112.09,63.14 112.04,62.84 112.14,62.7 112.52,62.63 112.66,62.73 112.71,63.03 113.05,63.27 113.67,63.16 113.91,62.82 113.86,62.52 113.95,62.38 114.34,62.31 114.48,62.41 114.53,62.71 114.87,62.95 115.49,62.84 115.73,62.5 115.67,62.2 115.77,62.06 116.15,61.99 116.29,62.09 116.35,62.39 116.69,62.63 117.31,62.52 117.54,62.18 117.49,61.88 117.59,61.74 117.97,61.67 118.11,61.77 118.16,62.07 118.5,62.31 119.52,62.13 149.13,67.35 155.48,66.23 197.51,58.82 200.62,56.64 204.53,55.95 211.26,51.24 218.43,49.98 222.86,50.76 224.95,50.39 226.75,50.7 227.04,50.76 229.07,50.4 230.74,50.69 232.77,50.33 235.05,50.73 237.44,50.31 240.73,50.89 243.02,50.49 245.58,50.94 247.18,50.66 249.21,51.01 251.22,50.66 253.78,51.11 274.96,47.38 275.97,46.67 275.97,46.34 v1(276.33,45.97)
  BOTTOM w0.135: U1.B7 v4(97.36,70.13) ; v1(276.33,45.97) 275.97,45.62 275.97,44.82 C184.1
PE_SLOT1_TX_C_DP<2>: length 185.6
  IN1 w0.089: 99.52,69.76 99.5,69.76 99.44,69.72 98.94,69.81 98.47,69.73 97.99,69.73 97.79,69.53 97.79,69.24 97.68,69.13 v4(97.36,69.13)
  IN1 w0.122: 99.52,69.76 99.73,69.72 103.98,66.74 104.61,65.84 109.33,62.54 109.33,62.54 118.07,61 149.55,66.55 155.9,65.43 197.32,58.12 200.64,55.8 204.58,55.11 211.02,50.6 218.44,49.29 222.9,50.08 224.99,49.71 227.13,50.09 229.18,49.73 230.81,50.01 232.8,49.66 235.08,50.06 237.46,49.64 240.78,50.23 243.02,49.83 245.57,50.28 247.19,50 249.18,50.35 251.31,49.97 253.92,50.43 270.95,47.43 271.89,46.78 271.93,46.55 271.93,46.34 v1(272.29,45.97)
  BOTTOM w0.135: U1.B6 v4(97.36,69.13) ; C185.1 271.93,44.82 271.93,45.62 v1(272.29,45.97)
PE_SLOT1_TX_C_DP<3>: length 183.4
  IN1 w0.089: 99.52,68.37 99.5,68.39 99.43,68.37 98.93,68.72 98.92,68.73 97.98,68.73 97.75,68.5 97.75,68.24 97.65,68.13 v4(97.36,68.13)
  IN1 w0.122: 99.52,68.37 100.54,67.66 101.08,66.88 107.87,62.13 118.41,60.27 149.83,65.81 156.18,64.69 196.99,57.5 200.34,55.15 204.38,54.44 210.84,49.92 218.42,48.58 223.06,49.4 225.05,49.05 227.03,49.39 229.02,49.04 230.78,49.35 232.91,48.98 235.22,49.39 237.54,48.98 240.86,49.56 243.02,49.18 245.5,49.62 247.17,49.33 249.13,49.67 251.22,49.3 253.92,49.78 264.47,47.92 264.72,47.56 264.57,46.74 264.67,46.59 265.05,46.53 265.2,46.63 265.34,47.47 265.68,47.71 266.89,47.49 267.97,46.74 267.97,46.34 v1(268.33,45.97)
  BOTTOM w0.135: U1.B5 v4(97.36,68.13) ; v1(268.33,45.97) 267.97,45.62 267.97,44.82 C186.1
PE_SLOT1_TX_C_DP<4>: length 179.8
  IN1 w0.089: 94.02,62.92 94.02,62.94 93.96,62.98 93.9,63.34 93.98,63.81 93.98,64.48 93.77,64.69 93.45,64.69 93.36,64.78 v4(93.36,65.13)
  IN1 w0.122: 94.02,62.92 94.09,62.51 94.36,62.14 94.95,61.72 108.31,59.36 113.95,60.36 118.44,59.57 149.8,65.1 156.15,63.98 196.86,56.8 200.22,54.45 203.91,53.8 210.27,49.34 218.69,47.85 223.39,48.68 225.14,48.37 227.11,48.72 229.12,48.36 230.87,48.67 232.94,48.31 235.23,48.71 237.55,48.3 240.8,48.88 242.96,48.5 245.57,48.96 247.19,48.67 249.08,49 251.16,48.64 253.86,49.11 253.9,49.12 260.63,47.94 261.74,47.16 261.93,46.89 262,46.53 262,46.34 v1(262.36,45.97)
  BOTTOM w0.135: C187.1 262,44.82 262,45.62 v1(262.36,45.97) ; U1.F2 v4(93.36,65.13)
PE_SLOT1_TX_C_DP<5>: length 177.4
  IN1 w0.089: 92.83,62.92 92.83,62.94 92.77,62.98 92.74,63.19 92.83,63.74 92.96,63.91 92.96,64.5 92.76,64.69 92.48,64.69 92.36,64.81 v4(92.36,65.13)
  IN1 w0.122: v1(258.35,45.97) 257.98,46.34 257.98,46.53 257.83,47.37 257.19,47.83 253.77,48.43 253.72,48.43 251.08,47.96 249.07,48.32 247.22,47.99 245.52,48.29 242.96,47.84 240.8,48.22 237.55,47.65 235.23,48.06 232.95,47.66 230.94,48.01 229.18,47.7 227.11,48.07 225.14,47.72 223.48,48.01 218.53,47.14 210.06,48.63 203.65,53.12 199.96,53.77 196.48,56.21 156.19,63.31 149.84,64.43 118.39,58.89 114.05,59.66 108.42,58.67 94.29,61.16 93.17,61.94 92.95,62.26 92.83,62.92
  BOTTOM w0.135: v1(258.35,45.97) 257.99,45.62 257.99,44.82 C188.1 ; U1.G2 v4(92.36,65.13)
PE_SLOT1_TX_C_DP<6>: length 173.8
  IN1 w0.089: v4(91.36,65.13) 91.36,64.81 91.4,64.78 91.71,64.78 91.96,64.53 91.96,63.98 91.85,63.35 91.91,62.98 91.97,62.94 91.97,62.92
  IN1 w0.122: v1(254.33,45.97) 253.97,46.34 253.97,46.61 253.64,46.84 249.01,47.66 247.23,47.34 245.52,47.64 242.94,47.19 240.79,47.57 237.48,46.98 235.16,47.39 232.95,47 231.11,47.33 229.36,47.02 227.11,47.41 225.14,47.07 223.64,47.33 218.51,46.43 209.69,47.98 203.31,52.45 199.6,53.1 196.05,55.59 156.16,62.62 149.81,63.74 118.27,58.18 114.09,58.92 108.67,57.96 93.98,60.55 92.55,61.56 92.1,62.2 91.97,62.92
  BOTTOM w0.135: U1.H2 v4(91.36,65.13) ; v1(254.33,45.97) 253.98,45.62 253.98,44.82 C189.1
PE_SLOT1_TX_C_DP<7>: length 172.3
  IN1 w0.089: 91.09,63.3 91.08,63.32 91.02,63.36 90.99,63.57 90.96,63.73 90.96,64.48 90.74,64.69 90.45,64.69 90.36,64.78 v4(90.36,65.13)
  IN1 w0.122: 91.09,63.3 91.3,62.07 91.96,61.13 93.74,59.88 108.51,57.28 113.91,58.23 118.15,57.48 149.74,63.05 156.09,61.93 195.89,54.92 199.41,52.45 202.69,51.87 209.05,47.42 218.62,45.73 223.69,46.62 225.01,46.39 225.03,46.4 227.08,46.76 229.36,46.35 231.14,46.67 233.08,46.33 235.26,46.71 237.44,46.33 240.63,46.89 243.11,46.45 243.61,46.54 243.95,46.3 244.04,45.8 244.18,45.7 244.56,45.76 244.66,45.9 244.57,46.41 244.81,46.75 245.68,46.9 247.06,46.66 248.97,47 249.54,46.89 249.89,46.69 250.01,46.55 250.01,46.34 v1(250.37,45.97)
  BOTTOM w0.135: C190.1 250.01,44.82 250.01,45.62 v1(250.37,45.97) ; U1.J2 v4(90.36,65.13)
PE_SLOT1_TX_C_DP<8>: length 166.4
  IN1 w0.089: 90.35,62.92 90.34,62.94 90.29,62.98 90.24,63.21 89.95,64.02 89.95,64.47 89.73,64.69 89.48,64.69 89.36,64.81 v4(89.36,65.13)
  IN1 w0.122: v1(190.45,54.36) 190.1,54.01 189.86,54.01 188.92,54.17 188.79,54.35 188.43,54.41 188.26,54.29 152.53,60.58 146.18,61.7 118.11,56.75 113.77,57.51 108.53,56.59 93.53,59.23 91.48,60.67 90.5,62.07 90.37,62.76 90.35,62.92
  BOTTOM w0.135: v1(190.45,54.36) 190.83,53.98 191.07,53.98 191.87,54.12 194.86,56.21 196.92,56.57 202.56,56.57 206.54,55.87 212.02,52.04 232.69,52.04 236.97,51.29 243.57,46.66 243.89,46.21 243.99,45.6 243.99,44.82 C191.1 ; U1.K2 v4(89.36,65.13)
PE_SLOT1_TX_C_DP<9>: length 164.2
  IN1 w0.089: v4(88.36,65.13) 88.36,64.81 88.45,64.73 88.66,64.73 88.96,64.43 88.96,63.64 89.05,63.51 89.36,63.06 89.43,63.05 89.44,63.03
  IN1 w0.122: v1(192.99,53.09) 192.62,52.72 192.25,52.72 191.75,52.63 191.3,52.32 191,52.26 190.99,52.26 190.69,52.21 189.99,52.33 189.53,52.66 189.49,52.87 189.19,53.08 188.98,53.04 188.26,53.54 152.4,59.87 146.05,60.99 118.13,56.06 113.71,56.84 108.5,55.92 93.23,58.62 90.86,60.28 89.88,61.68 89.72,62.6 89.67,62.71 89.44,63.03
  BOTTOM w0.135: U1.L2 v4(88.36,65.13) ; C192.1 239.98,44.82 239.98,45.18 239.81,46.12 239.05,47.22 234.53,50.38 231.96,50.84 211.64,50.84 206.07,54.73 202.48,55.37 197.35,55.37 196.13,55.15 195.04,54.39 194.01,52.91 193.71,52.7 193.37,52.7 v1(192.99,53.09)
PE_SLOT1_TX_C_DP<10>: length 160.8
  IN1 w0.089: v4(87.36,65.13) 87.36,64.81 87.45,64.73 87.66,64.73 87.96,64.42 87.96,64.06 87.92,63.84 87.92,63.24 87.93,63.18 88.01,63.06 88.09,63.05 88.1,63.03
  IN1 w0.122: v1(195.66,53.09) 195.3,52.73 194.94,52.73 194.65,52.44 194.65,51.89 194.58,51.5 194.41,51.24 194.29,51.16 193.38,51 189.6,51.66 187.73,52.97 152.51,59.18 146.15,60.3 118.13,55.36 113.74,56.13 108.63,55.23 92.94,58 90.35,59.81 88.22,62.87 88.1,63.03
  BOTTOM w0.135: U1.M2 v4(87.36,65.13) ; C193.1 235.99,44.82 235.99,45.35 235.95,45.62 235.59,46.12 231.35,49.09 228.27,49.64 211.26,49.64 206.15,53.21 202.25,53.9 200.04,53.9 198.24,53.58 197.61,53.14 196.95,52.68 196.06,52.68 v1(195.66,53.09)
PE_SLOT1_TX_C_DP<11>: length 159.2
  IN1 w0.089: v4(86.36,65.13) 86.36,64.81 86.45,64.73 86.66,64.73 86.95,64.44 86.95,63.95 86.97,63.8 87.17,63.41 87.17,63.38 87.24,62.98 87.3,62.94 87.3,62.92
  IN1 w0.122: 87.3,62.92 87.33,62.79 87.65,62.32 89.76,59.31 89.81,59.28 92.45,57.43 108.73,54.56 113.77,55.45 118.27,54.66 146.26,59.59 152.61,58.47 187.14,52.38 190.4,50.1 190.4,50.09 191.92,49.83 192.09,49.95 192.45,49.89 192.58,49.71 193.53,49.54 195.29,49.54 v1(195.66,49.91)
  BOTTOM w0.135: C194.1 232.01,44.82 232.01,45.27 231.94,45.62 231.72,45.95 230.76,46.61 230.33,46.54 230,46.06 229.81,46.03 229.29,46.39 229.26,46.58 229.59,47.05 229.52,47.49 228.69,48.06 226.58,48.44 210.81,48.44 205.82,51.93 203.69,52.3 202.25,52.56 201.27,52.56 199.39,52.23 197.55,50.94 196.74,49.77 196.39,49.53 196.04,49.53 v1(195.66,49.91) ; U1.N2 v4(86.36,65.13)
PE_SLOT1_TX_C_DP<12>: length 155.1
  IN1 w0.089: 86.26,63.03 86.25,63.05 86.18,63.06 86.05,63.24 86.03,63.37 85.96,63.8 85.96,64.43 85.66,64.73 85.45,64.73 85.36,64.81 v4(85.36,65.13)
  IN1 w0.122: v1(198.32,49.91) 197.96,49.55 197.67,49.55 197.38,49.26 197.38,48.56 197.32,48.26 197.18,48.05 196.97,47.9 196.43,47.81 191.08,48.75 186.72,51.8 152.81,57.78 146.46,58.9 118.36,53.95 113.74,54.76 108.81,53.89 92,56.86 89.23,58.8 86.26,63.03
  BOTTOM w0.135: C195.1 227.99,44.82 227.99,45.28 227.82,45.7 225.91,46.85 223.72,47.23 210.25,47.23 205.43,50.61 202.72,51.08 202.66,51.1 201.98,51.21 200.69,50.99 200.06,50.54 199.64,49.95 199.38,49.76 199.12,49.58 198.66,49.58 v1(198.32,49.91) ; U1.P2 v4(85.36,65.13)
PE_SLOT1_TX_C_DP<13>: length 153.9
  IN1 w0.089: 85.41,63.03 85.4,63.05 85.33,63.06 85.04,63.47 84.96,63.96 84.96,64.43 84.66,64.73 84.45,64.73 84.36,64.81 v4(84.36,65.13)
  IN1 w0.122: v1(201.12,49.78) 200.75,49.42 200.22,49.42 199.87,49.07 199.87,48.67 199.79,48.25 199.51,47.84 199.08,47.54 198.72,47.48 198.54,47.6 198.18,47.54 198.06,47.36 196.07,47.01 191.04,47.9 189.93,48.68 186.3,51.22 152.89,57.11 146.54,58.23 118.29,53.25 113.67,54.07 108.75,53.2 91.82,56.19 88.65,58.41 87.09,60.64 85.53,62.87 85.41,63.03
  BOTTOM w0.135: C196.1 224,44.82 224,45.15 223.73,45.54 223.14,45.95 222.89,46 222.67,46.03 222.01,46.03 221.69,45.72 221.69,44.73 221.52,44.55 220.96,44.55 220.8,44.71 220.8,45.72 220.48,46.03 209.87,46.03 205.33,49.21 204.23,49.4 201.5,49.4 v1(201.12,49.78) ; U1.R2 v4(84.36,65.13)
PE_SLOT1_TX_C_DP<14>: length 144.2
  IN1 w0.089: 84.44,63.13 84.42,63.15 84.35,63.16 83.96,63.72 83.96,64.42 83.66,64.73 83.45,64.73 83.36,64.81 v4(83.36,65.13)
  IN1 w0.122: 84.44,63.13 84.62,62.87 87.97,58.09 91.58,55.56 108.8,52.52 113.51,53.35 118.27,52.51 146.78,57.54 153.13,56.42 185.87,50.64 190.7,47.26 196.53,46.23 198.7,46.62 200.09,46.37 200.76,46.37 v1(201.12,46.74)
  BOTTOM w0.135: U1.T2 v4(83.36,65.13) ; C197.1 216.87,44.35 212.14,44.35 209.51,44.81 205.18,47.84 204.26,48.01 203.94,48.01 203.4,47.91 202.93,47.58 202.66,47.31 202.26,46.74 201.75,46.38 201.47,46.38 v1(201.12,46.74)
PE_SLOT1_TX_C_DP<15>: length 140.9
  IN1 w0.089: v4(82.36,65.13) 82.36,64.81 82.45,64.73 82.66,64.73 82.96,64.42 82.96,64 83.49,63.24 83.61,63.06 83.68,63.05 83.7,63.03
  IN1 w0.122: 83.7,63.03 83.81,62.87 87.51,57.59 91.35,54.9 108.7,51.84 113.47,52.68 118.22,51.85 146.79,56.88 153.14,55.76 185.6,50.04 190.63,46.51 199.26,44.99 199.5,44.65 199.46,44.42 199.56,44.27 199.94,44.21 200.08,44.31 200.12,44.54 200.46,44.78 201.42,44.61 202.11,44.73 202.4,45.14 202.53,45.89 202.9,46.25 203.3,46.25 v1(203.66,46.61)
  BOTTOM w0.135: C198.1 208.49,42.95 208.18,42.95 207.89,43 207.66,43.16 206.64,44.19 206.19,44.19 205.49,43.49 205.3,43.49 204.86,43.94 204.86,44.13 205.56,44.82 205.56,45.27 204.89,45.94 204.53,46.19 204.18,46.25 204.01,46.25 v1(203.66,46.61) ; U1.U2 v4(82.36,65.13)
PE_SLOT1_TX_DN<0>: length 6.4
  BOTTOM w0.135: C199.2 279.68,43.31 279.68,39.04 279.93,38.79 280.09,38.71 280.14,38.68 280.2,38.5 J1.B15
PE_SLOT1_TX_DN<1>: length 6.3
  BOTTOM w0.135: J1.B20 275.2,39.01 275.39,38.95 275.51,39.01 275.67,39.17 275.67,41.09 275.51,41.24 275.51,41.64 275.67,41.8 275.67,42.2 275.51,42.35 275.51,42.76 275.67,42.91 275.67,43.31 C200.2
PE_SLOT1_TX_DN<2>: length 6.3
  BOTTOM w0.135: J1.B24 271.2,39.01 271.38,38.95 271.5,39.01 271.63,39.14 271.63,41.09 271.48,41.24 271.48,41.64 271.63,41.8 271.63,42.2 271.48,42.35 271.48,42.76 271.63,42.91 271.63,43.31 C201.2
PE_SLOT1_TX_DN<3>: length 6.3
  BOTTOM w0.135: J1.B28 267.2,39.01 267.38,38.95 267.51,39.01 267.67,39.18 267.67,41.09 267.51,41.24 267.51,41.64 267.67,41.8 267.67,42.2 267.51,42.35 267.51,42.76 267.67,42.91 267.67,43.31 C202.2
PE_SLOT1_TX_DN<4>: length 6.3
  BOTTOM w0.135: C203.2 261.7,43.31 261.7,42.91 261.54,42.76 261.54,42.35 261.7,42.2 261.7,41.8 261.54,41.64 261.54,41.24 261.7,41.09 261.7,39.21 261.51,39.01 261.38,38.95 261.2,39.01 J1.B34
PE_SLOT1_TX_DN<5>: length 6.3
  BOTTOM w0.135: C204.2 257.68,43.31 257.68,42.91 257.53,42.76 257.53,42.35 257.68,42.2 257.68,41.8 257.53,41.64 257.53,41.24 257.68,41.09 257.68,39.17 257.55,39.04 257.38,38.95 257.38,38.95 257.2,39.01 J1.B38
