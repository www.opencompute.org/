# Allegro board 4-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P0V9: length 192.5
  TOP w0.203: PR378.1 52.7,101.32 55.3,101.32 56.82,99.8 64.29,99.8 64.57,99.52 65.84,99.52 v4(66.04,99.31)
  TOP w0.381: v4(79.36,87.13) 79.85,86.65 C287.1 ; C418.1 80.87,75.64 v4(80.36,75.13) 79.87,75.63 C444.1 79.84,75.65 v4(79.36,76.13) 78.88,76.61 C442.1 78.87,76.63 v4(78.36,77.13) ; C276.1 79.85,84.65 v4(79.36,85.13) ; v4(86.36,87.13) 85.86,86.63 C16.1 ; C18.1 U1.R21 v4(84.36,85.13) ; v4(85.36,86.13) 84.89,85.65 C299.1 ; v4(77.36,83.13) 77.84,82.65 C297.1 ; v4(78.36,79.13) 78.87,78.63 C438.1 78.88,78.61 v4(79.36,78.13) 79.84,77.65 C440.1 79.86,77.63 v4(80.36,77.13) 80.87,77.63 C432.1 ; C408.1 81.87,86.63 v4(82.36,87.13) 82.86,87.63 C281.1 82.88,87.65 v4(83.36,88.13) 82.87,88.63 C388.1 82.85,88.64 v4(82.36,89.13) 81.89,89.61 C386.1 ; v4(80.36,73.13) 79.86,73.63 C406.1 79.85,73.65 v4(79.36,74.13) 78.88,74.61 C426.1 78.87,74.63 v4(78.36,75.13) 77.87,75.63 C420.1 77.85,75.64 v4(77.36,76.13) 77.36,76.15 C424.1 76.86,76.63 v4(76.36,77.13) ; v4(80.36,73.13) 80.82,72.68 C10.1 ; v4(80.36,73.13) 80.88,73.65 C414.1 ; C277.1 77.85,86.64 v4(77.36,87.13) ; v4(79.36,83.13) 79.85,82.64 C21.1 79.87,82.63 v4(80.36,82.13) ; v4(82.36,83.13) 81.86,82.62 C410.1 ; C390.1 80.86,87.64 v4(80.36,88.13) 79.86,88.63 C428.1 ; C289.1 83.84,72.65 v4(83.36,73.13) 82.88,73.62 C273.1 82.86,73.63 v4(82.36,74.13) 81.85,74.64 C402.1 ; v4(80.36,84.13) 80.86,83.64 C392.1 ; v4(76.36,79.13) 76.87,79.63 C446.1 76.89,79.65 v4(77.36,80.13) 77.82,80.59 C448.1 ; v4(83.36,82.13) 83.84,82.61 C270.1 83.86,82.62 v4(84.36,83.13) ; C434.1 78.87,80.63 v4(79.36,80.13) ; C394.1 81.87,84.64 v4(82.36,85.13) 82.87,85.63 C17.1 82.89,85.65 v4(83.36,86.13) 83.84,86.61 C268.1 83.86,86.63 v4(84.36,87.13) 84.86,87.63 C301.1 84.88,87.64 v4(85.36,88.13) ; v4(85.36,79.13) 85.85,79.61 C9.1 85.86,79.63 v4(86.36,80.13) 85.84,80.65 C430.1 ; C396.1 81.86,78.64 v4(82.36,78.13) 82.87,77.62 C290.1 82.89,77.61 v4(83.36,77.13) 83.85,76.65 C272.1 83.86,76.63 v4(84.36,76.13) 84.87,75.63 C279.1 85.36,75.15 v4(85.36,75.13) 85.36,75.12 C22.1 85.87,74.63 v4(86.36,74.13) ; C271.1 76.86,87.63 v4(76.36,88.13) ; v4(78.36,88.13) 78.87,87.62 C285.1 ; C282.1 83.84,80.65 v4(84.36,80.13) ; v4(76.36,75.13) 76.87,74.63 C404.1 76.88,74.61 v4(77.36,74.13) ; C436.1 79.86,79.63 v4(80.36,79.13) 80.88,79.65 C412.1 ; v4(83.36,84.13) 82.89,83.65 C269.1 ; v4(85.36,77.13) 85.84,76.65 C20.1 85.87,76.63 v4(86.36,76.13) ; C400.1 80.85,85.65 v4(80.36,86.13) ; C416.1 81.86,76.64 v4(82.36,76.13) 82.38,76.13 C292.1 82.88,75.62 v4(83.36,75.13) 83.84,74.65 C275.1 84.34,74.13 v4(84.36,74.13) 84.86,73.63 C300.1 ; C274.1 U1.Y22 v4(78.36,86.13) ; C278.1 77.85,84.65 v4(77.36,85.13) ; v4(79.36,89.13) 78.89,89.6 C422.1 ; v4(86.36,83.13) 85.86,82.63 C294.1 85.84,82.61 v4(85.36,82.13) ; v4(86.36,85.13) U1.N21 C280.1 ; C398.1 81.84,80.66 v4(82.36,80.13) 82.87,79.63 C283.1 82.89,79.61 v4(83.36,79.13) 83.84,78.65 C19.1 ; v4(76.36,86.13) U1.AB22 C296.1
  IN1 w0.089: 67.18,99.24 67.27,99.24 67.75,98.75 67.75,95.8 68.03,95.52 69.58,95.52 69.77,95.33 69.77,81.69 70.18,81.28 79.79,81.28 79.99,81.48 79.99,81.94 80.18,82.13 v4(80.36,82.13)
  IN1 w0.203: 67.18,99.24 66.93,99.49 66.22,99.49 v4(66.04,99.31)
  BOTTOM w0.381: 82.21,82.97 v4(82.36,83.13) ; 82.21,82.97 U1.U19 ; 82.21,82.97 U1.T20 v4(83.36,84.13) U1.R21 v4(84.36,85.13) U1.P22 v4(85.36,86.13) U1.N23 v4(86.36,87.13) ; v4(83.36,79.13) U1.T16 v4(82.36,80.13) U1.U17 ; U1.N21 v4(86.36,85.13) ; v4(79.36,89.13) U1.W25 v4(80.36,88.13) U1.V24 ; U1.V16 v4(80.36,79.13) U1.W15 v4(79.36,78.13) U1.Y14 v4(78.36,77.13) U1.AA13 v4(77.36,76.13) U1.AB12 v4(76.36,75.13) ; U1.AB18 v4(76.36,82.13) ; v4(77.36,83.13) U1.AA19 v4(78.36,82.13) U1.Y18 ; U1.U11 v4(82.36,74.13) U1.T10 v4(83.36,73.13) ; U1.W17 v4(79.36,80.13) U1.Y16 v4(78.36,79.13) ; v4(86.36,76.13) U1.N13 v4(85.36,77.13) U1.P14 ; v4(86.36,83.13) U1.N19 v4(85.36,82.13) U1.P18 ; U1.U15 v4(82.36,78.13) U1.T14 v4(83.36,77.13) U1.R13 v4(84.36,76.13) U1.P12 v4(85.36,75.13) U1.N11 v4(86.36,74.13) ; v4(76.36,79.13) U1.AB16 v4(77.36,80.13) U1.AA17 ; U1.U23 v4(82.36,87.13) U1.T24 v4(83.36,88.13) ; v4(85.36,88.13) U1.P24 v4(84.36,87.13) U1.R23 v4(83.36,86.13) U1.T22 v4(82.36,85.13) U1.U21 ; v4(78.36,88.13) U1.Y24 v4(79.36,87.13) U1.W23 v4(80.36,86.13) U1.V22 ; U1.R17 v4(84.36,80.13) U1.P16 v4(85.36,79.13) ; v4(84.36,83.13) U1.R19 v4(83.36,82.13) U1.T18 ; v4(79.36,74.13) U1.W11 v4(80.36,75.13) U1.V12 ; v4(77.36,74.13) U1.AA11 v4(78.36,75.13) U1.Y12 v4(79.36,76.13) U1.W13 v4(80.36,77.13) U1.V14 ; U1.V20 v4(80.36,84.13) U1.W21 v4(79.36,85.13) U1.Y22 v4(78.36,86.13) U1.AA23 v4(77.36,87.13) U1.AB24 v4(76.36,88.13) ; U1.AA21 v4(77.36,85.13) U1.AB22 v4(76.36,86.13) ; U1.N17 v4(86.36,80.13) ; v4(79.36,83.13) U1.W19 v4(80.36,82.13) U1.V18 ; U1.V10 v4(80.36,73.13) ; v4(84.36,74.13) U1.R11 v4(83.36,75.13) U1.T12 v4(82.36,76.13) U1.U13 ; U1.AB14 v4(76.36,77.13) ; U1.U25 v4(82.36,89.13)
  vias: v1(44.15,88.39) v1(44.15,87.12) v1(44.27,100.33) v1(44.27,99.06) v1(44.27,82.3) v1(45.04,100.33) v1(45.04,99.06) v1(45.16,88.39) v1(45.16,87.12) v1(45.29,82.3) v1(45.8,100.33) v1(45.8,99.06) v1(46.18,88.39) v1(46.18,87.12) v1(46.31,82.3) v1(46.81,101.35) v1(46.81,100.33) v1(46.81,99.06) v1(47.58,93.73) v1(47.58,92.58) v1(47.58,91.44) v1(47.58,90.3) v1(47.83,101.35) v1(47.83,100.33) v1(47.85,84.54) v1(47.96,97.54) v1(47.96,96.65) v1(47.96,95.63) v1(48.16,85.17) v1(48.85,100.33) v1(48.81,97.9) v1(48.97,96.65) v1(48.97,95.63) v1(49.99,96.65) v1(49.99,95.63) v1(50.5,88.9) v1(50.88,91.19) v1(50.88,90.17) v1(51,96.65) v1(51,95.63) v1(51.26,99.31) v1(51.26,98.04) v1(51.39,94.74) v1(51.39,93.47) v1(51.77,89.03) v1(51.89,92.2) v1(51.89,91.19) v1(51.89,90.17) v1(52.27,99.31) v1(52.27,98.04) v1(52.27,97.03) v1(52.27,96.01) v1(52.27,95) v1(52.27,93.73) v1(52.91,92.2) v1(52.91,91.19) v1(52.91,90.17) v1(53.29,99.31) v1(53.29,98.04) v1(53.29,97.03) v1(53.29,96.01) v1(53.29,95) v1(53.29,93.73) v1(53.8,92.33) v1(54.31,99.31) v1(54.31,98.04) v1(54.31,97.03) v1(55.58,97.41) v1(55.58,96.39) v1(55.58,95.38) v1(55.58,92.46) v1(55.58,91.44) v1(56.21,97.92) v1(57.23,96.52) v1(57.23,95.38) v1(57.23,92.46) v1(57.23,91.44) v1(58.88,96.44) v1(58.88,95.43) v1(58.88,92.46) v1(58.88,91.44)
P0V9_A: length 216.6
  TOP w0.381: v4(87.36,89.13) 87.86,89.63 C333.1 ; C393.1 86.87,81.64 v4(87.36,82.13) ; C425.1 75.84,75.61 v4(75.36,75.13) ; v4(75.36,82.13) 74.89,82.61 C327.1 74.89,82.65 v4(75.36,83.13) ; v4(74.36,77.13) 73.87,76.63 C403.1 ; C417.1 75.84,73.6 v4(75.36,73.13) ; C358.1 86.86,72.63 v4(86.36,73.13) 85.86,72.63 C362.1 ; C326.1 83.88,88.65 v4(84.36,89.13) ; C357.1 86.89,73.61 v4(87.36,73.13) ; v4(75.36,78.13) 75.84,78.61 C387.1 ; v4(88.36,83.13) 88.87,82.62 C429.1 ; C441.1 75.85,88.64 v4(75.36,89.13) ; v4(77.36,73.13) 77.84,72.65 C421.1 ; C328.1 75.85,84.65 v4(75.36,85.13) ; C331.1 86.87,88.63 v4(87.36,88.13) ; v4(75.36,74.13) 75.85,74.61 C415.1 ; v4(84.36,78.13) 84.87,78.63 C351.1 ; v4(74.36,83.13) 73.87,83.63 C360.1 ; v4(77.36,78.13) 77.84,77.65 C435.1 ; C366.1 86.89,75.61 v4(87.36,75.13) ; v4(86.36,89.13) 85.88,89.62 C329.1 ; v4(87.36,80.13) 86.88,80.62 C347.1 ; C409.1 88.86,76.63 v4(88.36,77.13) 88.86,77.62 C367.1 ; C449.1 75.85,86.64 v4(75.36,87.13) ; v4(87.36,74.13) 86.89,74.61 C356.1 ; C433.1 87.85,86.62 v4(87.36,86.13) ; C350.1 75.84,79.61 v4(75.36,79.13) ; C363.1 73.87,78.63 v4(74.36,79.13) 73.87,79.62 C405.1 ; C419.1 75.86,72.63 v4(76.36,73.13) 76.87,73.63 C437.1 ; v4(78.36,78.13) 77.86,78.63 C411.1 ; C342.1 88.87,85.63 v4(88.36,85.13) 88.87,84.63 C338.1 ; v4(75.36,88.13) 75.85,87.65 C348.1 ; C352.1 75.83,80.59 v4(75.36,80.13) ; C445.1 76.88,89.61 v4(77.36,89.13) 76.89,88.66 C443.1 ; C340.1 86.88,82.65 v4(87.36,83.13) ; v4(85.36,78.13) 84.88,77.64 C345.1 ; v4(87.36,76.13) 86.89,76.61 C413.1 ; v4(75.36,77.13) 75.85,77.61 C407.1 ; v4(88.36,73.13) 88.85,73.62 C359.1 ; C349.1 88.86,79.63 v4(88.36,79.13) ; v4(78.36,73.13) 78.86,72.63 C447.1 ; C365.1 84.87,83.63 v4(84.36,84.13) ; C401.1 75.85,76.61 v4(75.36,76.13) ; v4(87.36,84.13) 86.89,84.61 C336.1 ; v4(87.36,78.13) 87.84,78.61 C395.1 ; C335.1 87.84,85.61 v4(87.36,85.13) ; v4(87.36,87.13) 87.85,87.62 C431.1 ; C397.1 88.84,88.65 v4(88.36,89.13) ; v4(85.36,73.13) 84.87,72.63 C389.1 ; C343.1 87.84,79.61 v4(87.36,79.13) ; v4(86.36,84.13) 86.87,83.63 C427.1 ; C399.1 84.87,89.62 v4(85.36,89.13) ; v4(75.36,86.13) 75.85,85.65 C354.1 ; C325.1 75.85,83.64 v4(75.36,84.13) ; C324.1 73.86,89.63 v4(74.36,89.13) ; v4(76.36,89.13) 75.87,89.63 C439.1 ; v4(78.36,84.13) 78.86,83.64 C355.1 ; v4(77.36,84.13) 77.84,83.65 C353.1 ; v4(87.36,77.13) 87.84,77.61 C364.1 ; C423.1 73.87,85.63 v4(74.36,85.13) ; C391.1 73.87,72.64 v4(74.36,73.13) 73.87,73.62 C361.1
  IN2 w0.089: 63.2,88.46 63.22,88.46 63.28,88.52 73.66,88.52 73.76,88.42 73.76,81.38 74.4,80.75 77.4,80.75 77.78,80.37 77.78,78.53 77.37,78.13 v4(77.36,78.13)
  IN2 w0.178: 63.2,88.46 62.56,88.46 43.46,69.36 43.46,55.5 v1(43.69,55.27)
  BOTTOM w0.254: PR434.2 37.15,47.17 36.86,47.17 36.6,47.42 36.6,51.54 39.37,54.31 43.13,54.31 43.51,54.69 43.51,55.09 v1(43.69,55.27)
  BOTTOM w0.381: U1.AD10 v4(74.36,73.13) ; U1.AD10 v4(75.36,74.13) U1.AC11 v4(75.36,75.13) U1.AC12 v4(75.36,76.13) U1.AC13 v4(75.36,77.13) U1.AC14 v4(75.36,78.13) U1.AC15 ; U1.AD10 v4(75.36,73.13) U1.AC10 v4(76.36,73.13) U1.AB10 v4(77.36,73.13) U1.AA10 v4(78.36,73.13) U1.Y10 ; U1.P10 v4(85.36,73.13) U1.N10 v4(86.36,73.13) U1.M10 v4(87.36,73.13) U1.L10 ; v4(86.36,78.13) U1.N15 v4(85.36,78.13) U1.P15 v4(84.36,78.13) U1.R15 ; v4(86.36,78.13) U1.M14 v4(87.36,77.13) ; v4(86.36,78.13) U1.M15 ; U1.AC17 v4(75.36,80.13) U1.AC16 v4(75.36,79.13) U1.AC15 ; v4(74.36,85.13) U1.AD21 v4(75.36,85.13) ; v4(87.36,82.13) U1.L19 v4(88.36,83.13) ; v4(87.36,82.13) U1.M19 v4(87.36,83.13) U1.M20 ; v4(87.36,82.13) U1.M18 ; U1.AD25 v4(74.36,89.13) ; U1.AD25 v4(75.36,89.13) U1.AC25 v4(76.36,89.13) U1.AB25 v4(77.36,89.13) U1.AA25 ; U1.AD25 v4(75.36,88.13) U1.AC24 v4(75.36,87.13) U1.AC23 v4(75.36,86.13) U1.AC22 v4(75.36,85.13) ; v4(75.36,85.13) U1.AC21 v4(75.36,84.13) U1.AC20 v4(75.36,83.13) U1.AC19 v4(75.36,82.13) U1.AC18 ; v4(76.36,84.13) U1.AB20 v4(77.36,84.13) U1.AA20 v4(78.36,84.13) U1.Y20 ; U1.M15 v4(87.36,79.13) U1.M16 ; U1.M15 v4(87.36,78.13) U1.L14 ; v4(87.36,77.13) U1.M13 v4(87.36,76.13) U1.M12 v4(87.36,75.13) U1.M11 v4(87.36,74.13) U1.L10 ; v4(87.36,77.13) U1.L14 ; U1.M20 v4(87.36,84.13) U1.M21 v4(87.36,85.13) U1.M22 v4(87.36,86.13) U1.M23 v4(87.36,87.13) U1.M24 v4(87.36,88.13) U1.M25 ; U1.M20 v4(86.36,84.13) U1.N20 v4(85.36,84.13) U1.P20 v4(84.36,84.13) U1.R20 ; U1.AD19 v4(74.36,83.13) ; U1.Y15 v4(78.36,78.13) U1.AA15 v4(77.36,78.13) U1.AB15 v4(76.36,78.13) U1.AC15 ; U1.L14 v4(88.36,77.13) ; U1.L10 v4(88.36,73.13) ; U1.AD16 v4(74.36,79.13) ; U1.M17 v4(87.36,80.13) U1.L16 v4(88.36,79.13) ; v4(88.36,89.13) U1.L25 v4(87.36,89.13) U1.M25 ; U1.M25 v4(86.36,89.13) U1.N25 v4(85.36,89.13) U1.P25 v4(84.36,89.13) U1.R25 ; U1.L21 v4(88.36,85.13) ; U1.AD14 v4(74.36,77.13)
  vias: v1(40.34,50.67) v1(40.34,49.91) v1(40.44,49.15) v1(40.72,48.51) v1(41.35,49.4) v1(41.35,48.77) v1(41.35,48.13) v1(41.78,47.12) v1(41.86,50.8) v1(41.86,46.38) v1(41.86,45.72) v1(42.5,49.4) v1(42.5,48.77) v1(42.5,48.13) v1(42.67,47.12) v1(43.18,48.44) v1(43.38,50.8) v1(43.38,46.35) v1(43.38,45.72) v1(43.87,49.4) v1(43.89,48.77) v1(43.89,48.13) v1(43.87,47.12) v1(44.53,49.4) v1(44.53,48.77) v1(44.53,48.13) v1(44.53,47.12)
P0V9_AGND: length 4.6
  TOP w0.305: v1(17.58,113.03) 17.77,112.83 PU21.3
  TOP w0.381: PR393.2 v1(13.54,113.51) ; v1(14.4,106.96) 13.39,106.96 PR394.1 ; PR395.1 v1(13.79,110.75) ; PR396.1 v1(12.28,109.68)
P0V9_CNFG: length 2.2
  TOP w0.203: PR394.2 13.31,108.07 14.3,109.07 PU21.12
P0V9_COMP1: length 2.8
  TOP w0.254: PC562.2 22.36,108.76 PC561.2 20.76,108.76 20.45,109.06 19.72,109.06 PU21.24
P0V9_COMP1_RC: length 3.1
  TOP w0.254: PR387.2 24.35,107.77 v5(24.38,107.8) 24.38,108.26 23.91,108.73 PC562.1
P0V9_DLY1: length 2
  TOP w0.203: PR393.1 14.36,112.02 14.82,111.57 PU21.8
P0V9_DRVON: length 27.7
  TOP w0.203: v1(32.81,106.67) 32.31,107.17 PQ6.3 ; PC573.1 v1(16.99,113.7) 16.94,113.65 16.94,112.9 17.27,112.57 PU21.4
  IN1 w0.254: v1(16.99,113.7) 17.47,114.17 20.02,114.17 21.92,112.27 21.92,109.47 22.63,108.76 25.4,108.76 26.11,108.05 31.39,108.05 32.68,106.77 32.71,106.77 v1(32.81,106.67)
  BOTTOM w0.254: v1(16.99,113.7) 16.89,113.8 PR401.1 PR404.1
  BOTTOM w0.381: PQ7.6 33.56,107.15 33.08,106.67 v1(32.81,106.67)
P0V9_EN1: length 4
  TOP w0.203: PC566.1 17.82,113.7 18.26,113.25 v1(18.26,113.1) 18.27,113.09 PU21.2
  BOTTOM w0.254: v1(18.26,113.1) 18.72,113.56 PR391.2 PR392.2
P0V9_FB1: length 8.7
  TOP w0.254: PR383.2 21.03,107.02 v1(20.68,107.37) 20.68,108.2 20.31,108.57 PU21.23 ; PR383.2 22.12,107.02 PC560.2 ; PR383.2 21.41,107.57 21.41,107.57 PC561.1 22.17,107.96 PR387.1
  BOTTOM w0.254: PR385.1 20.1,107.66 20.4,107.37 v1(20.68,107.37)
P0V9_FB1_RC: length 2.2
  TOP w0.254: PC560.1 23.66,106.78 v1(24.05,106.39) 23.45,105.79 PR382.2
P0V9_FSET: length 2
  TOP w0.203: PR396.2 13.54,109.01 13.54,109.01 13.69,109.01 14.24,109.57 PU21.11
P0V9_ILIMT1: length 3.9
  TOP w0.254: PU21.26 20.66,110.07 v1(20.93,110.33) 21.29,110.33 PC576.1
  BOTTOM w0.254: PR408.1 PR410.1 20.91,110.32 v1(20.93,110.33)
P0V9_IS1_N: length 35.8
  TOP w0.254: PU21.20 18.27,106.4 18.33,106.34 18.33,103.64 19.58,102.39 PC700.1 v1(20.45,102.39)
  BOTTOM w0.254: PR310.2 42.11,97.65 42.11,97.95 PC473.2 42.09,99.05 42.09,102.01 39.71,104.39 37.85,104.39 v2(37.42,104.83) 36.96,104.37 34.17,104.37 33.94,104.6 22.96,104.6 21.97,103.61 21.05,103.61 20.58,103.13 20.58,102.51 v1(20.45,102.39)
P0V9_IS1_P: length 29.3
  TOP w0.254: PR800.2 21.69,102.99 v1(21.09,102.4)
  BOTTOM w0.254: PR308.2 41.73,97.64 41.73,97.93 PC473.1 41.71,99.02 41.71,101.85 39.55,104.01 38.99,104.01 v2(38.71,103.73) 38.46,103.99 34.01,103.99 33.78,104.22 23.12,104.22 22.13,103.23 21.21,103.23 20.96,102.97 20.96,102.53 v1(21.09,102.4)
P0V9_IS2_N: length 53.8
  TOP w0.254: PU21.18 17.27,106.09 15.98,104.8 PC701.2 15.42,104.32 v1(15.42,103.63)
  BOTTOM w0.254: PR311.2 42.11,83.68 42.11,83.38 PC474.2 42.11,82.3 42.11,81.31 40.69,79.88 36.37,79.88 35.46,78.97 31.47,78.97 v2(31.26,78.75) 31.04,78.97 27.38,78.97 24.33,82.02 23.06,82.02 21.24,83.84 21.24,92.86 17.55,96.54 17.55,99.33 15.5,101.39 15.5,103.56 v1(15.42,103.63)
P0V9_IS2_P: length 49
  TOP w0.254: PR801.2 v1(16.05,103.63)
  BOTTOM w0.254: v1(16.05,103.63) 15.88,103.45 15.88,101.55 17.93,99.49 17.93,96.7 21.62,93.01 21.62,84 23.22,82.4 24.49,82.4 27.54,79.35 32.08,79.35 v2(32.36,79.63) 32.64,79.35 35.3,79.35 36.22,80.26 40.53,80.26 41.73,81.46 41.73,82.29 PC474.1 41.73,83.4 41.73,83.69 PR309.2
P0V9_OTP1: length 3.4
  TOP w0.254: PU21.25 20.89,109.57 v1(21.06,109.4) 21.35,109.4 PR409.1
  BOTTOM w0.254: PR411.1 21.64,109.98 v1(21.06,109.4)
P0V9_PG1: length 405.7
  TOP w0.114: R297.1 316.31,42.93 317.45,41.78 317.45,25.53 315.29,23.37 305.13,23.37 301.75,19.99 U22.2 301.75,17.07 301.58,16.89 297.51,16.89 v1(293.45,20.95)
  TOP w0.203: PU21.5 16.77,112.56 16.31,113.03 v1(15.59,113.03)
  TOP w0.254: PC564.1 15.29,113.33 v1(15.59,113.03)
  IN2 w0.112: v1(293.45,20.95) 292.69,21.72 284.7,21.72 280.06,26.36 197.34,26.36 183.93,39.78 160.72,39.78 141.38,59.12 129.93,59.12 114.09,43.28 75.94,43.28 75.72,43.06 74.83,43.06 73.41,44.48 73.41,45.59 70.97,48.03 64.52,48.03 64.42,47.93 53.99,47.93 53.98,47.92 53.59,47.92 53.58,47.93 53.37,47.93 49.48,51.82 45.37,51.82 42.5,54.69 42.5,64.27 18.12,88.65 15.44,88.65 14.3,89.79 14.3,104.9 13.03,106.17 13.03,111.89 13.79,112.65 15.22,112.65 v1(15.59,113.03)
  BOTTOM w0.254: PR390.2 15.41,112.85 v1(15.59,113.03)
P0V9_PG_LED: length 2.1
  TOP w0.114: U22.4 301.1,15.27 v1(300.69,14.86) 300.69,14.72 Q7.G
P0V9_PG_LED_H: length 2.4
  TOP w0.114: D1.A 304.04,12.08 304.27,12.3 v1(304.27,12.45) 303.91,12.8 R110.1
P0V9_PG_LED_N: length 5.1
  TOP w0.114: D1.C 302.86,10.16 R109.2 301.58,10.37 v1(301.58,11.99) 300.85,11.99 Q7.D
P0V9_PWM1: length 30.4
  TOP w0.254: v1(35.9,99.68) 35.58,99.37 PU15.40 ; PU21.22 19.86,107.92 19.86,107.14 v4(19.48,106.75)
  IN1 w0.254: v4(19.48,106.75) 18.92,106.75 18.29,106.12 18.29,103.35 21.92,99.72 26.37,99.72 27.13,100.48 29.87,100.48 31.5,102.11 32.64,102.11 33.48,101.27 33.48,99.95 33.75,99.68 v1(35.9,99.68)
  BOTTOM w0.254: PR297.1 35.67,99.45 v1(35.9,99.68) 35.92,99.71 PR296.2
P0V9_PWM2: length 40.9
  TOP w0.254: PU13.40 35.35,87.68 v1(35.67,88) ; PU21.17 16.77,106.53 16.33,106.1 v4(15.8,106.1)
  IN1 w0.254: v4(15.8,106.1) 16.79,105.11 16.79,99.77 21.29,95.28 21.29,88.9 22.18,88.01 26.29,88.01 27.09,88.81 29.83,88.81 31.47,90.45 32.63,90.45 33.48,89.6 33.48,88.93 34.58,87.82 35.49,87.82 v1(35.67,88)
  BOTTOM w0.254: PR143.2 35.92,88.25 v1(35.67,88) 35.26,88 PR295.1
P0V9_SENSE1_N: length 39.2
  TOP w0.254: PR376.2 51.37,101.68 50.73,101.68 v1(50.47,101.93)
  IN1 w0.254: v1(50.47,101.93) 50.19,101.65 49.87,101.65 47.18,104.34 24.41,104.34 23.04,105.71 20.04,105.71 v1(20.02,105.74)
  BOTTOM w0.254: PR503.2 51.34,101.68 50.73,101.68 v1(50.47,101.93) ; PR389.1 16.94,107.46 17.54,106.86 PR385.2 18.31,106.86 19.46,105.71 19.99,105.71 v1(20.02,105.74)
P0V9_SENSE1_P: length 38.8
  TOP w0.254: PR378.2 51.37,101.3 50.74,101.3 v1(50.47,101.03) ; v1(20.07,105.08) 20.15,105.08 20.4,105.33 21.41,105.33 21.41,105.33 PR383.1 21.7,106.22 22.13,105.79 PR382.1
  IN1 w0.254: v1(20.07,105.08) 20.27,105.08 20.52,105.33 22.88,105.33 24.25,103.96 47.02,103.96 49.71,101.27 50.23,101.27 v1(50.47,101.03)
  BOTTOM w0.254: v1(50.47,101.03) 50.74,101.3 51.34,101.3 PR377.2
P0V9_SS: length 1.8
  TOP w0.203: PU21.10 13.67,110.07 13.56,109.95 PR395.2
P0V9_VCC5V: length 13
  TOP w0.254: PU21.28 20.09,111.07 20.27,111.25 20.27,111.38 20.52,111.63
  TOP w0.508: 20.52,111.63 v1(21.03,112.14) 21.03,113.28 21.41,113.67 PC568.1
  BOTTOM w0.254: v1(21.03,112.14) 21.03,113.2 18.02,116.2 16,116.2 15.26,115.46 PR404.2
P0V9_VCIN1: length 8.9
  TOP w0.254: PU15.2 33.86,100.45 ; PC468.1 34.28,101.62 v1(34.76,102.1) 34.76,102.81 PR301.2 ; PU15.39 35.64,98.87 v1(35.87,98.64)
  TOP w0.305: 33.86,100.45 33.86,100.87 34.28,101.29 PC468.1
  IN1 w0.254: v1(34.76,102.1) 34.76,101.81 36.58,99.99 36.58,99.1 36.12,98.64 v1(35.87,98.64)
P0V9_VCIN2: length 8.3
  TOP w0.254: PU13.39 v1(35.69,87.18) ; 33.86,89.19 33.86,89.19 PU13.2
  TOP w0.305: PC467.1 34.28,89.6 33.86,89.19
  TOP w0.381: PR300.2 v1(34.78,90.4) 34.78,90.28 34.28,89.78 PC467.1
  IN1 w0.254: v1(35.69,87.18) 35.95,87.18 36.4,87.64 36.4,88.53 34.78,90.16 v1(34.78,90.4)
P0V9_VIN: length 3.2
  TOP w0.305: PU21.1 18.77,112.76 18.87,112.86
  TOP w0.457: 18.87,112.86 PC572.1
  TOP w0.508: PR400.1 PC572.1
P0V9_VREF: length 4.2
  TOP w0.254: PU21.27 20.27,110.57 20.88,111.17 v1(21,111.17) 21.5,111.67 PC567.1
  BOTTOM w0.254: PR411.2 21.2,111.17 v1(21,111.17) 20.32,111.17 PR410.2
P0V9_ZCD_EN1_N: length 6.2
  TOP w0.254: PU15.1 34.36,100.29 34.52,100.45 34.72,100.45 v1(34.96,100.21)
  BOTTOM w0.254: PR303.1 v2(33.25,102.07) 33.7,102.07 34.15,101.62 PR298.2 34.15,100.66 34.61,100.21 v1(34.96,100.21)
P0V9_ZCD_EN2_N: length 5.9
  TOP w0.254: PU13.1 34.73,88.27 v1(34.98,88.52)
  BOTTOM w0.254: v1(34.98,88.52) 34.76,88.52 34.15,89.14 PR299.2 34.15,89.68 33.49,90.35 v2(33.16,90.35) 32.9,90.09 32.9,88.7 PR302.1
P0V9A_AGND: length 8.1
  TOP w0.305: v1(67.94,42.76) PU23.4 69.45,42.77 70.16,42.77 v1(70.32,42.93) 71.96,42.93 PR423.2
  BOTTOM w0.254: PR424.1 69.48,43.73 PR504.1 69.82,42.79 70.18,42.79 v1(70.32,42.93) 70.55,42.69 PC582.2
P0V9A_COMP: length 6.6
  TOP w0.254: PU23.3 69.82,42.11 70.05,42.34 70.71,42.34 PC589.1 72.53,42.03 72.78,42.28 72.78,43.28 v5(73.2,43.7) 73.44,43.46 PR427.1
P0V9A_COMP_RC: length 2.6
  TOP w0.254: PR427.2 74.24,41.47 v5(74.01,41.23) 73.03,41.23 PC591.1
P0V9A_EN: length 7.3
  TOP w0.203: PU23.15 67.95,39.79 68.28,39.46 69.25,39.46 70.11,38.6 70.11,38.07 v1(70.19,37.99)
  TOP w0.254: v1(70.19,37.99) 70.8,37.39 PC580.1
  BOTTOM w0.254: v1(70.19,37.99) 70.13,37.93 v2(70.13,37.11) 70.35,36.89 70.71,36.89 71.02,37.19 PR418.2
P0V9A_FB: length 7.8
  TOP w0.254: PR432.1 72.47,40.04 v5(72.25,40.26) 72.24,40.28 PR431.1 PC589.2 ; PC591.2 71.25,41.46 PC589.2 ; PC589.2 70.84,41.23 70.57,40.96 70.46,40.96 v1(70.31,40.81) PU23.1
  BOTTOM w0.254: PR429.2 69.46,41.66 v1(70.31,40.81)
P0V9A_FB_RC: length 2.8
  TOP w0.254: PC597.1 71.91,39.02 v5(71.17,38.29) 71.02,38.44 PR431.2
P0V9A_OUT: length 51.9
  IN1 w0.254: v1(71.74,45.36) 71.08,44.71 71.08,43.93 74.25,40.76 74.25,37.7 70.44,33.9 50.48,33.9 47.96,36.42 47.96,46.23 v1(48.85,47.12)
  BOTTOM w0.254: PR430.2 70,47.1 v1(71.74,45.36)
  vias: v1(48.85,50.42) v1(48.85,49.15) v1(48.85,47.88) v1(49.61,50.42) v1(49.61,49.15) v1(49.61,47.88) v1(49.61,47.12) v2(48.85,46.23)
P0V9A_PG: length 261.6
  TOP w0.114: v1(291.48,20.89) 295.99,16.38 301.96,16.38 302.4,16.83 U22.1
  TOP w0.254: v1(72.3,45.95) 72.01,45.95 71.44,46.52 PR420.2 70.98,46.79 69.75,45.56 69.75,44.83 69.63,44.71 PU23.7
  IN2 w0.112: v1(72.3,45.95) 72.33,45.92 72.33,45.07 74.67,42.73 75.99,42.73 76.28,43.02 114.2,43.02 130.04,58.85 141.27,58.85 160.61,39.51 183.82,39.51 197.23,26.1 279.95,26.1 284.84,21.21 291.16,21.21 v1(291.48,20.89)
P0V9A_RT: length 2.8
  TOP w0.254: PU23.5 69.83,43.41 70.3,43.88 v5(70.76,43.88) 71.88,43.88 PR423.1
P0V9A_SENSE_R_N: length 60.8
  TOP w0.254: v1(39.51,46.54) 39.93,46.12 PR505.1
  BOTTOM w0.254: PR435.1 38.53,46.74 39.32,46.74 v1(39.51,46.54) 39.61,46.44 39.61,44.08 40.48,43.21 41,43.21 43.66,40.54 43.66,35.13 44.98,33.8 72.06,33.8 73.28,35.02 73.28,36.47 74.05,37.24 74.05,39.67 v2(73.59,40.13) 73.51,40.21 70.05,40.21 69.28,40.98 68.9,40.98 68.43,41.45 68.43,41.61 PR429.1 68.53,41.8 68.53,43.29 PR504.2 68.34,43.48 PR428.1
P0V9A_SENSE_R_P: length 51.8
  TOP w0.254: v1(39.51,47.43) 39.7,47.24 PR433.1 ; PR432.2 73.46,38.57 v1(73.37,38.47) 73.12,38.22 PC597.2
  BOTTOM w0.254: PR434.1 38.46,47.28 39.36,47.28 v1(39.51,47.43) 39.99,46.95 39.99,44.24 40.64,43.59 41.16,43.59 44.04,40.7 44.04,35.28 45.14,34.19 71.91,34.19 72.9,35.18 72.9,36.63 73.67,37.4 73.67,38.17 v1(73.37,38.47)
P0V9A_VCC: length 9
  TOP w0.254: PU23.10 67.3,46.21 v1(67.41,46.33) ; v6(70.79,45.42) 70.79,45 69.84,44.06 PU23.6
  TOP w0.381: v1(67.41,46.33) 67.41,47.02 PC581.2
  IN1 w0.254: v1(67.41,46.33) 67.41,45.59 68.06,44.95 70.31,44.95 v6(70.79,45.42)
P0V9A_VIN: length 4.1
  TOP w0.254: v1(68.12,46.3) 67.95,46.13 PU23.9
  TOP w0.381: v1(68.12,46.3) 68.41,46.59 PC583.1
  BOTTOM w0.508: v1(68.12,46.3) 68.12,47.2 PR426.2
P0V9A_VREF: length 2.2
  TOP w0.254: PU23.2 70.08,41.46 70.25,41.63 v1(70.31,41.63)
  BOTTOM w0.254: PC582.1 70.56,41.89 70.31,41.64 v1(70.31,41.63)
P0V9A_VSNS: length 4.5
  TOP w0.254: PU23.8 68.6,45.67 69.03,46.09 v1(69.49,46.09)
  BOTTOM w0.254: PR428.2 68.34,45.38 69.04,46.08 69.48,46.08 v1(69.49,46.09) 69.49,46.56 69.2,46.85 PR430.1
P1V8: length 184.5
  TOP w0.254: v4(90.36,78.13) 90.84,78.61 C295.1 ; C286.1 71.83,91.66 v4(71.36,92.13) ; v1(55.5,58.55) 55.9,58.95 R172.1
  TOP w0.381: C12.1 90.86,85.62 v4(90.36,85.13) ; v4(80.36,90.13) 79.86,90.64 C298.1 ; C13.1 90.86,90.63 v4(90.36,90.13) ; R333.1 45.16,54.55 v1(45.52,54.91) ; R189.1 56.88,55.54 v1(56.86,55.54) ; R128.1 56.87,51.13 56.59,51.41 v1(56.59,51.71) ; R147.1 v1(124.41,77.85) ; R201.1 57.57,54.99 v1(56.86,54.27) ; R188.1 59.49,55.21 v1(59.21,55.5) ; R291.1 v1(121.24,77.85) v1(121.24,79.76) R330.1 ; R179.1 v1(51.42,56.01) ; C288.1 70.87,70.63 v4(71.36,71.13) 70.94,71.55 R202.1 ; R134.1 v1(121.24,75.95) ; v4(90.36,72.13) 90.36,72.1 C293.1 ; v1(105.82,68.33) 105.67,68.48 R334.1 ; R332.1 v1(114.63,87.5) ; v4(71.36,85.13) 70.87,84.63 C11.1 ; C377.1 79.84,71.65 v4(79.36,72.13) ; R328.1 v1(111.71,75.95) ; R150.1 v1(51.42,53.47) ; v4(78.36,90.13) 77.86,90.63 C14.1 ; R136.1 v1(56.86,58.11) ; R148.1 v1(111.71,74.04) ; R141.1 v1(121.49,87.5) ; C284.1 81.86,71.62 v4(82.36,72.13) ; v4(83.36,90.13) 82.86,90.63 C15.1 ; v1(62.54,51.71) 62.71,51.87 R177.1 ; C368.1 v1(60.1,49.53) ; R137.1 v1(105.49,74.04) ; R295.1 114.14,79.18 113.6,78.64 112.22,78.64 111.71,78.13 v1(111.71,77.85) R142.1 ; C291.1 71.86,77.63 v4(71.36,78.13) ; v4(84.36,72.13) 83.87,71.63 C376.1 ; R335.1 v1(114.76,75.95) ; C371.1 v1(116.94,70.21) ; C375.1 v1(52.17,51.94) ; R190.1 v1(55.6,53.42) ; v1(121.07,39.14) U12.1 ; R132.1 R181.1 ; R326.1 v1(108.66,77.85)
  TOP w0.457: R351.1 140.44,106.45 v1(121.49,87.5)
  TOP w0.508: v1(111.71,68.33) R132.1
  IN1 w0.508: 106.66,44.07 106.83,44.25 114.5,44.25 119.61,39.14 v1(121.07,39.14)
  IN2 w0.508: v1(114.63,87.5) 115.39,88.27 120.73,88.27 v1(121.49,87.5) 121.49,80.01 v1(121.24,79.76)
  BOTTOM w0.254: U1.AG22 v4(71.36,85.13)
  BOTTOM w0.381: U1.J15 v4(90.36,78.13) ; U1.W9 v4(79.36,72.13) ; C368.1 v1(60.1,49.53) ; R289.1 v1(56.86,54.27) ; C375.1 v1(52.17,51.94) ; U1.AG8 v4(71.36,71.13) ; U1.J9 v4(90.36,72.13) ; R278.1 R277.1 C451.1 121.11,39.37 121.07,39.33 v1(121.07,39.14) ; U1.U9 v4(82.36,72.13) ; v1(115.73,66.38) 114.75,65.41 R130.1 110.31,65.42 110.31,65.91 109.15,67.08 106.92,67.08 105.82,68.18 v1(105.82,68.33) ; R138.1 v1(56.86,55.54) ; U1.Y26 v4(78.36,90.13) ; R139.1 v1(47.61,54.74) ; U1.R9 v4(84.36,72.13) ; U1.J21 v4(90.36,85.13) ; R190.1 v1(55.6,53.42) ; R179.1 v1(51.42,56.01) ; R136.1 v1(56.86,58.11) ; U1.AG15 v4(71.36,78.13) ; R273.1 R274.1 34.86,64.97 35.42,65.53 40.72,65.53 42.37,63.88 42.37,61.34 43,60.71 U6.8 46.69,60.71 47.19,61.21 48.59,61.21 49.25,61.87 R143.1 R149.1 ; U1.AG28 v4(71.36,92.13) ; U1.T26 v4(83.36,90.13) ; 44.02,59.94 38.05,59.94 37.21,60.78 35.18,60.78 34.86,61.11 R272.1 ; R150.1 v1(51.42,53.47) ; U1.V26 v4(80.36,90.13) ; U1.J26 v4(90.36,90.13)
  vias: v1(45.54,55.68) v1(104.98,39.88) v1(104.98,38.86) v1(104.98,37.85) v1(104.98,36.96) v1(106,39.88) v1(106,38.86) v1(106,37.85) v1(106,36.83)
P1V8_A: length 24.1
  TOP w0.381: C320.1 88.86,75.63 v4(88.36,75.13) ; C319.1 88.86,78.63 v4(88.36,78.13) ; v4(74.36,75.13) 73.86,75.63 C323.1 ; v4(74.36,84.13) 73.86,84.63 C313.1 ; C322.1 73.86,77.63 v4(74.36,78.13) ; C318.1 86.86,71.63 v4(86.36,72.13) ; C317.1 73.87,82.63 v4(74.36,82.13) ; v4(77.36,72.13) 77.84,71.66 C321.1 ; v4(74.36,87.13) 73.86,87.64 C314.1 ; v4(88.36,84.13) 88.87,83.63 C315.1 ; C457.1 76.13,91.54 75.84,91.26 C312.1 75.87,90.63 v4(76.36,90.13) ; v4(88.36,82.13) 88.83,81.66 C311.1 89.05,81.41 89.76,81.41 C458.1 ; C310.1 84.86,90.63 v4(85.36,90.13) ; C316.1 88.86,87.62 v4(88.36,87.13)
  BOTTOM w0.356: U1.AD12 74.42,75.19 ; U1.B30 97.31,94.07
  BOTTOM w0.381: U1.AD18 v4(74.36,82.13) ; U1.L23 v4(88.36,87.13) ; U1.AA9 v4(77.36,72.13) ; U1.AN32 v4(65.36,96.13) ; U1.AD20 v4(74.36,84.13) ; U1.N9 v4(86.36,72.13) ; 74.42,75.19 v4(74.36,75.13) ; U1.P26 v4(85.36,90.13) ; U1.L15 v4(88.36,78.13) ; U1.AB26 v4(76.36,90.13) ; 97.31,94.07 v4(97.36,94.13) ; U1.L12 v4(88.36,75.13) ; U1.AD23 v4(74.36,87.13) ; U1.L20 v4(88.36,84.13) ; U1.AD15 v4(74.36,78.13) ; U1.L18 v4(88.36,82.13)
  vias: v1(57.74,103) v1(57.74,102.23) v1(57.74,101.47) v1(58.5,103) v1(58.5,102.23) v1(58.5,101.47) v1(59.26,103) v1(59.26,102.23) v1(59.26,101.47) v1(99.01,37.52) v1(98.99,36.78) v1(99.75,36.78) v1(99.77,37.52) v1(100.53,37.52) v1(100.51,36.78) v1(101.35,38.4) v1(101.3,37.52) v1(101.27,35.97) v1(101.83,36.96) v1(115.42,70.23) v1(116.26,70.26) v1(117.65,70.23) v1(117.68,68.45)
P1V8_EN: length 3.3
  TOP w0.254: PR353.2 115.05,39.68 v1(115.66,40.28)
  BOTTOM w0.254: PU18.4 115.62,40.25 v1(115.66,40.28)
P1V8_FB: length 5.6
  TOP w0.254: v1(111.36,41.2) 111.36,40.81 110.77,40.22 PC536.2 110.77,39.73 110.44,39.4 PR356.1
  BOTTOM w0.254: v1(111.36,41.2) PR355.2 111.79,40.14 112.33,39.6 PU18.2
P1V8A_AGND: length 5.1
  TOP w0.254: v1(78.92,37.5) 78.75,37.33 PR368.2
  TOP w0.305: v1(80.98,37.83) 80.73,37.58 PU19.4 79,37.58 v1(78.92,37.5)
  BOTTOM w0.305: PR372.1 78.04,37.73 v2(78.39,38.07) 78.92,37.55 v1(78.92,37.5)
P1V8A_COMP: length 4.4
  TOP w0.254: PU19.3 78.45,38.08 78.27,38.26 PC547.1 77.48,38.26 v5(76.99,37.77) 76.04,37.77 PR371.1
P1V8A_COMP_RC: length 2.9
  TOP w0.254: PR371.2 74.96,39.17 v5(75.19,39.4) 75.53,39.05 PC549.1
P1V8A_EN: length 27.6
  TOP w0.254: PU19.15 80.48,40.17 v1(80.36,40.29)
  IN1 w0.254: v1(75.78,34.28) 75.85,34.28 76.63,35.06 76.63,40.43 78.36,42.16 79.81,42.16 80.06,41.91 80.06,40.59 v1(80.36,40.29)
  IN3 w0.112: v1(80.36,40.29) 79.96,40.69 78.79,40.69 77.93,39.83 77.93,35.59 77.17,34.82 76.33,34.82 v1(75.78,34.28)
  BOTTOM w0.114: v1(75.78,34.28) 75.15,34.9 PR357.2 75.15,36.44 PR361.1
  BOTTOM w0.254: v1(80.36,40.29) 80.36,39.58 80.11,39.33 PC539.1
P1V8A_FB: length 7.7
  TOP w0.254: PC549.2 78.23,39.05 PC547.2 ; PC547.2 78.39,39.06 78.74,39.4 78.92,39.4 v1(78.94,39.43) 79.02,39.43 79.37,39.08 PU19.1 ; PC547.2 PR373.1 78.22,40.04 PR374.1
  BOTTOM w0.254: PR372.2 v2(77.19,39.67) 78.69,39.67 v1(78.94,39.43)
P1V8A_FB_RC: length 3.3
  TOP w0.254: PR373.2 78.24,41.7 77.68,42.26 v5(77.29,42.26) PC555.1
P1V8A_OUT:
  vias: v5(93.32,37.34)
P1V8A_PG: length 191.3
  TOP w0.114: R211.2 116.64,35.05 v1(115.77,35.05) ; PU19.6 79.73,36.04 79.48,35.79 78.67,35.79 77.78,34.9 76.12,34.9 v1(75.87,35.15) 75.37,35.64 PR363.2
  IN3 w0.112: v1(115.77,35.05) 115.29,35.53 113.59,35.53 113.17,35.12 109.39,35.12 107.39,37.11 107.39,41.78 106.41,42.76 80.81,42.76 79.07,41.02 78.67,41.02 76.86,39.21 76.86,35.56 76.45,35.15 v1(75.87,35.15) 75.23,35.79 v1(70.18,35.79) 68.62,34.23 45.86,34.23 44.46,35.63 44.46,40.95 40.11,45.3 36.83,45.3 33.78,48.35 33.78,51.18 28.76,56.2 28.76,70.89 19.29,80.37 16.39,80.37 14.35,82.4 14.35,104.37 13.59,105.13 13.59,109.43 14.47,110.31 14.47,113.17 16.58,115.29 v1(17.04,115.29)
  BOTTOM w0.127: PR392.1 17.66,114.67 v1(17.04,115.29)
  BOTTOM w0.254: PR418.1 70.78,36.39 v1(70.18,35.79)
P1V8A_RT: length 1.7
  TOP w0.254: PU19.5 79.28,37.08 78.74,36.53 PR368.1
P1V8A_SS: length 5.6
  TOP w0.254: v1(78.97,38.62) 79,38.58 PU19.2
  BOTTOM w0.254: v1(78.97,38.62) 79.19,38.39 PR367.1 80.11,38.39 80.34,38.62 v2(80.86,38.62) 81.04,38.62 81.64,38.03 81.64,37.18 81.35,36.9 PR366.2
P1V8A_VCC: length 4.3
  TOP w0.254: v1(81.13,35.34) 80.98,35.48 PU19.8
  TOP w0.305: PC541.1 81.38,35.08 v1(81.13,35.34)
  BOTTOM w0.254: v1(81.13,35.34) 81.38,35.34 v2(82.04,36) 81.94,36.1 PR366.1
P1V8A_VIN: length 4.7
  TOP w0.254: PU19.7 80.48,35.61 v1(80.24,35.36)
  TOP w0.305: v1(80.24,35.36) 80.08,35.21 PC542.1
  BOTTOM w0.305: v2(81.99,33.91) 81.05,33.91 PR370.2 80.24,34.73 v1(80.24,35.36)
P1V8A_VSENSE_R: length 27.5
  TOP w0.254: v1(75.29,41.4) 75.29,41.37 75.66,41 PC555.2 PR374.2 ; PR375.1 v1(97.08,40.23)
  IN1 w0.254: v1(97.08,40.23) 92.69,40.23 89.44,43.48 76.96,43.48 75.29,41.81 v1(75.29,41.4)
P3V3: length 63.7
  TOP w0.254: v1(75.84,35.95) 75.35,36.44 PR363.1 ; v1(72.81,45.33) 72.81,46.22 PR420.1
  TOP w0.356: U17.5 281.62,30.19 C456.1 ; C455.1 281.88,50.41 U16.5 ; C454.1 282,87.74 282.26,88 U13.5
  TOP w0.381: R3.1 v1(317.2,50.67) ; v1(316.28,32.38) 316.28,32.11 315.97,31.79 R193.1 ; R204.1 310.9,31.88 310.57,32.21 v1(310.57,32.46) ; R194.1 v1(121.8,35.54) 121.72,35.46 R161.1 ; v1(121.11,34.54) C450.1 120.37,34.64 121.07,35.34 U12.8 ; R296.1 v1(117.68,34.29) ; R191.1 v1(123.6,43.43) ; R160.1 v1(316.5,30.12) ; v1(313.01,28.7) 312.64,29.06 R163.1 ; v1(280.89,30.21) C456.1 ; R4.1 312.52,53.49 312.74,53.71 313.6,53.71 v1(313.64,53.75) ; R209.1 v1(122.51,42.55) ; U22.5 302.4,14.63 C470.1
  TOP w0.508: R154.1 294.61,89.77 294.84,89.53 v1(295.35,89.53) ; v1(291.67,48.39) 290.93,49.13 R159.1 ; v1(295.35,48.77) 294.99,48.77 R156.1 ; R348.1 v1(165.71,111.53) ; R158.1 290.8,69.45 v1(291.54,68.71) ; v1(291.59,28.11) 290.87,28.83 R210.1 ; v1(281.89,90.68) 282.27,90.3 R349.1 ; R109.1 v1(299.75,10.16) ; R108.1 v1(292.18,85.34) R93.1 ; v1(295.48,69.09) 294.99,69.09 R155.1 ; v1(295.35,28.45) 295.1,28.45 294.72,28.83 R203.1 ; v1(281,50.53) C455.1 ; C470.1 R110.2 304.65,14.27 v1(304.66,14.27) ; R94.1 v1(292.94,65.02) R152.1 ; v1(281.38,87.07) C454.1 ; v1(291.54,89.03) 290.8,89.77 R157.1 ; R192.1 v1(292.43,24.38) R162.1 ; v1(308.18,47.5) 307.8,47.88 R77.1 ; R153.1 v1(292.81,44.7) R107.1
  TOP w0.762: CON1.1 v1(188.17,115.78)
  BOTTOM w0.254: v1(304.22,105.78) 304.16,105.72 PR336.1 ; v1(13.87,114.25) 14.61,113.51 PR390.1
  BOTTOM w0.381: v1(281.89,90.68) 281.78,90.57 R307.1 ; R306.1 282.4,49.13 v1(281,50.53) ; v1(281.38,87.07) 281.69,86.76 R305.1 ; R308.1 281.62,66.31 280.24,67.69 v1(280.24,70.87)
  vias: v1(115.86,38.1) v1(115.86,37.44) v1(275.41,116.2) v1(275.41,115.44) v1(275.41,114.68) v1(275.41,113.92) v1(275.41,113.16) v1(275.41,112.39) v1(276.18,116.2) v1(276.18,115.44) v1(276.18,114.68) v1(276.18,113.92) v1(276.18,113.16) v1(276.18,112.39) v1(281,70.87) v1(285.57,32.26) v1(285.7,73.03) v1(285.83,52.58) v1(286.08,93.34) v1(287.35,31.88) v1(287.48,92.84) v1(287.48,52.2) v1(287.73,72.9) v1(288.24,92.84) v1(288.24,31.88) v1(288.49,72.52) v1(288.49,52.2) v1(311.2,60.02) v1(311.99,59.94) v1(312.78,59.74)
P3V3_AGND: length 6.3
  TOP w0.254: v1(301.75,108.32) 301.85,108.21 PR344.1
  BOTTOM w0.254: PR339.2 304.03,106.86 303.78,107.11 303.2,107.11 302,108.32 v1(301.75,108.32)
  BOTTOM w0.305: v1(301.75,108.32) 301.72,108.35 PU17.4 v1(299.35,108.35)
  vias: v5(299.24,109.12)
P3V3_BUF_VDDA: length 5.9
  TOP w0.178: U3.1 309.5,51.69 309.68,51.51 v1(309.68,51.21)
  BOTTOM w0.508: R92.2 311.77,49.91 311.51,50.16 C224.1 310.69,49.99 v2(310.16,49.99) 310.16,50.42 310.34,50.6 C225.1 309.72,51.16 v1(309.68,51.21)
P3V3_BUF_VDDR: length 1
  TOP w0.178: U3.5 v1(310.11,53.29)
  vias: v2(309.15,53.75)
P3V3_CLK_BUF_VDD: length 21.3
  TOP w0.178: U3.21 303.8,55.29 303.35,55.73 v1(303.35,55.75) ; v1(306.53,50.16) 306.51,50.19 U3.35 ; U3.29 303.81,52.09 303.35,51.64 v1(303.35,51.56) ; U3.16 v1(306.51,57.28) ; U3.39 308.11,50.37 308.24,50.23 ; U3.25 303.38,53.69 v1(303.35,53.66) ; v1(304.5,57.28) 304.9,56.87 U3.20 ; v1(308.56,57.28) 308.11,56.82 U3.12
  TOP w0.203: v1(304.37,50.55) 304.62,50.55 304.9,50.83 U3.31
  TOP w0.508: R1.1 312.52,50.27 313,49.78 v1(313.51,49.78) ; v1(309.56,48.91) C220.1 308.81,49.02 308.24,49.59 308.24,50.23
  BOTTOM w0.381: v1(313.23,54.31) 313.16,54.38 R91.1
  BOTTOM w0.508: v1(313.51,49.78) 313.28,49.55 R92.1 ; v1(304.37,50.55) 304.48,50.65 C221.1 ; C218.1 303.52,53.83 v1(303.35,53.66) ; v1(303.35,55.75) 303.74,55.75 303.88,55.61 C222.1 ; C219.1 303.75,51.56 v1(303.35,51.56) ; v1(306.53,50.16) 307.02,50.65 C216.1
  vias: v2(305.97,57.94)
P3V3_COMP: length 4.7
  BOTTOM w0.254: PU17.3 301.35,109 301.45,108.9 301.94,108.9 302.12,109.08 PC516.1 302.43,108.75 v2(303.46,107.72) 303.46,108.8 PR342.1
P3V3_COMP_RC: length 3.2
  BOTTOM w0.254: PC518.1 304.61,110.29 v2(305.34,110.29) 305.34,110.03 PR342.2
P3V3_EN: length 9.1
  TOP w0.254: PR332.2 302.07,113.92 301.6,113.45 v1(301.6,113.12)
  BOTTOM w0.114: v2(302.59,116.08) 302.34,116.08 302.04,115.78 PC506.1
  BOTTOM w0.203: PU17.15 299.36,111.31 299.69,111.64 300.86,111.64 301.6,112.38 v1(301.6,113.12)
  BOTTOM w0.254: v1(301.6,113.12) 301.6,113.29 302.03,113.73 PR333.1 302.03,114.79 PC506.1
P3V3_FB: length 6.3
  TOP w0.254: PR344.2 302.44,109.65 v6(301.73,110.36)
  BOTTOM w0.254: PC516.2 303.38,109.88 PC518.2 ; PC516.2 302.39,109.88 301.91,110.36 v6(301.73,110.36) 301.66,110.3 PU17.1 ; PC516.2 PR346.1 302.45,110.86 PR347.1
P3V3_FB_RC: length 1.9
  BOTTOM w0.254: PR346.2 302.36,111.69 v6(302.36,112.27) 302.39,112.29 302.9,112.29 PC527.1
P3V3_MB:
  vias: v1(288.37,9.27) v1(288.37,8.51) v1(288.37,7.75) v1(288.37,7.11) v1(289,9.27) v1(289,8.51) v1(289,7.75) v1(289,7.11) v2(287.99,10.79)
P3V3_OUT: length 59.9
  TOP w0.254: PR348.2 304.22,116.84 281.63,116.84 281.05,116.26 PC1531.1 ; PR345.2 302.66,105.39 v1(302.49,105.56)
  IN3 w0.254: v1(280.05,115.55) 281.33,116.84 299.09,116.84 303.05,112.89 303.05,106.12 v1(302.49,105.56)
  vias: v1(278.87,109.51) v1(278.87,107.27) v1(278.87,105.04) v1(279.55,109.51) v1(279.55,107.27) v1(279.55,105.04) v1(280.05,114.87) v1(280.05,114.11) v1(280.05,113.34) v1(280.05,112.61) v1(280.05,111.87) v2(279.02,104.04)
P3V3_PG: length 569.5
  TOP w0.114: v1(114.21,34.9) 115.05,35.74 PR353.1 ; R298.1 v1(317.2,45.57)
  IN2 w0.112: v1(317.2,45.57) 316.69,46.08 316.69,47.37 315.8,48.26 313.13,48.26 312.17,49.22 312.17,56.31 310.52,57.97 309.4,57.97 308.18,59.18 303.96,59.18 303.28,59.87 303.28,71.25 310.64,78.61 312.12,78.61 318.09,84.58 318.09,93.22 313.13,98.17 309.78,98.17 304.85,103.1 v1(302.82,103.1) 302.82,101.57 301.42,100.18 298.91,100.18 297.49,101.6 175.46,101.6 169.92,107.14 127.9,107.14 118.92,116.12 39.99,116.12 37.85,113.98 v1(37.85,113.69)
  IN3 w0.112: v1(114.21,34.9) 113.3,33.99 109.88,33.99 108.43,35.43 93.3,35.43 91.67,33.81 85.7,33.81 84.96,34.54 83.95,34.54 83.14,33.73 80.57,33.73 79.99,34.32 78.46,34.32 77.93,33.78 75.29,33.78 v1(74.78,34.29) 74.27,33.78 45.68,33.78 44.02,35.44 44.02,40.77 39.93,44.86 36.65,44.86 33.34,48.17 33.34,50.99 28.32,56.01 28.32,70.59 19,79.91 15.93,79.91 13.9,81.94 13.9,104.03 13.14,104.8 13.14,111.25 12.8,111.59 12.8,114.91 13.92,116.03 17.25,116.03 v1(17.9,115.38) 18.23,115.38 19,114.6 22.3,114.6 24.51,116.81 34.72,116.81 v1(37.85,113.69)
  BOTTOM w0.114: PR391.1 18.01,115.38 v1(17.9,115.38) ; v1(74.78,34.29) 74.35,34.72 PR357.1 ; v1(302.82,103.1) 303.36,103.64 PR336.2 303.35,104.91 301.92,104.91 301.17,105.66 301.17,106.22 301,106.4 PU17.7
P3V3_RT: length 2.9
  BOTTOM w0.254: PU17.5 301.56,107.7 301.9,107.35 v2(302.08,107.35) 302.25,107.35 303.05,106.55 PR339.1
P3V3_SENSE_R: length 4.2
  TOP w0.254: PR348.1 v1(305.13,113.16)
  BOTTOM w0.254: v1(305.13,113.16) 304.7,113.16 304.18,112.63 PC527.2 PR347.2
P3V3_STBY: length 35.2
  TOP w0.508: R239.1 v1(291.54,90.68) ; R249.1 v1(290.53,70.23) ; R262.1 v1(291.42,29.59) ; R264.1 v1(289.38,29.59) ; R245.1 v1(289.51,90.68) ; R252.1 v1(287.86,64.39) ; R248.1 v1(291.54,70.23) ; R240.1 v1(290.53,90.68) ; R250.1 v1(289.51,70.23) ; R263.1 v1(290.4,29.59) ; R247.1 v1(288.24,84.58) ; R261.1 v1(287.86,44.2)
  BOTTOM w0.254: PR317.1 318.39,87.52 318.39,92.41 317.45,93.34 311.86,93.34 310.77,94.44 300,94.44 v1(298.15,92.58)
  vias: v1(289.51,49.91) v1(290.53,49.91) v1(291.54,49.91) v1(297.38,93.34) v1(297.38,92.58) v1(297.38,91.82) v1(298.15,93.34) v1(298.15,91.82)
P3V3_STBY_AGND: length 6
  TOP w0.254: v1(313.99,86.86) 314.25,87.12 v5(314.73,87.12) 314.76,87.12 315.32,87.69 PR326.1
  BOTTOM w0.305: v1(311.93,87.2) 312.18,86.95 PU16.4 313.91,86.95 v1(313.99,86.86) 314.79,86.07 PR322.2
P3V3_STBY_COMP: length 4
  BOTTOM w0.254: PU16.3 314.46,87.45 314.64,87.63 PC497.1 315.45,87.63 v2(315.83,87.25) 316.95,87.25 PR325.1
P3V3_STBY_COMP_RC: length 2.4
  BOTTOM w0.254: PR325.2 317.77,88.25 v2(317.58,88.44) 316.46,88.44 PC499.1
P3V3_STBY_EN: length 11.8
  TOP w0.254: PC489.1 312.8,88.69 312.55,88.95 v1(312.55,89.66) ; v1(315.85,83.39) PR315.1 315.15,84.17 PR314.2
  IN1 w0.254: v1(315.85,83.39) 315.85,83.89 312.55,87.2 v1(312.55,89.66)
  BOTTOM w0.254: v1(312.55,89.66) 312.43,89.54 PU16.15
P3V3_STBY_FB: length 6.8
  TOP w0.254: PR326.2 315.32,88.49 314.91,88.9 v5(314.71,88.9) 314.5,88.69 v1(313.94,88.69)
  BOTTOM w0.254: PC497.2 314.68,88.41 PC499.2 ; PC497.2 314.46,88.43 314.22,88.67 313.97,88.67 v1(313.94,88.69) 313.87,88.69 313.62,88.45 PU16.1 ; PC497.2 PR327.1 314.69,89.4 PR328.1
P3V3_STBY_FB_RC: length 1.9
  BOTTOM w0.254: PR327.2 314.61,90.24 v6(314.61,90.82) 314.63,90.84 315.15,90.84 PC504.1
P3V3_STBY_MB: length 309.2
  TOP w0.254: 160.35,85.83 160.09,86.09 U10.1
  TOP w0.305: U2.24 308.04,33.79 308.33,33.51 308.63,33.51
  TOP w0.356: U20.5 285.82,45.86 C461.1
  TOP w0.381: R96.1 R95.1 R78.1 R81.1 v1(309.45,46.86) ; R79.1 v1(306.66,30.23) ; R100.1 R101.1 v1(300.31,46.99) 300.31,47.77 R99.1 ; R145.1 R144.1 v1(298.53,27.81) ; U21.5 285.84,86.37 285.85,86.38 ; R87.1 R88.1 308.81,30.35 v1(308.69,30.23) ; R186.1 305.11,27.79 v1(305.13,27.81) R185.1 ; v1(313.89,47.12) R283.1 R281.1 ; R102.1 v1(299.16,46.99) ; 160.35,85.83 160.35,81.02 C261.1 160.54,80.83 R304.1 R303.1 163.22,80.83 ; R103.1 v1(300.69,27.81) ; C462.1 285.71,66.05 U19.5 ; R285.1 v1(312.62,47.12) ; v1(302.98,47) R98.1 R97.1 ; R105.1 304.26,27.67 v1(304.12,27.81) R106.1 ; R293.1 v1(314.28,30.3) ; R104.1 v1(301.83,27.81) ; R83.1 v1(310.59,46.86)
  TOP w0.508: C462.1 285.83,67.97 v1(285.75,68.05) ; 308.63,33.51 C223.1 v1(310.47,33.51) ; 285.85,86.38 C459.1 v1(286.21,87.12) ; v1(316.23,33.85) C452.1 315.42,34.8 315.16,35.05 U7.8 ; v1(286.86,45.87) C461.1 ; 163.22,80.83 163.27,80.77 190.63,80.77 202.41,68.99 272.92,68.99 274.32,67.59 280.32,67.59 v1(280.87,68.15) ; U18.5 279.91,92.09 C460.1 v1(278.23,92.09)
  IN1 w0.508: v1(286.21,87.12) 287.22,88.14 294.08,88.14 296.5,85.72 296.5,82.8 297.77,81.53 298.91,81.53 v1(300.81,79.63) ; v1(285.75,68.05) 287.35,66.45 287.35,65.79 288.14,65 291.49,65 294.59,61.9 297.08,61.9 300.2,65.02 v1(300.81,65.02) 301.45,64.39 301.45,46.99 ; v1(286.86,45.87) 287.48,45.87 289.38,43.97 295.51,43.97 297.4,45.87 298.38,45.87
  IN2 w0.508: v1(280.87,68.15) 281.79,69.06 285.12,69.06 285.75,68.43 v1(285.75,68.05) ; v1(278.23,92.09) 281.97,92.09 286.21,87.86 v1(286.21,87.12)
  IN4 w0.508: v1(300.81,65.02) v1(300.81,79.63)
  BOTTOM w0.381: 305.49,77.09 305.49,77.58 305.68,77.76 U4.1 ; R309.1 286.72,45.72 v1(286.86,45.87)
  BOTTOM w0.508: R302.1 301.94,76.98 302.72,76.2 C259.1 305.49,77.09 ; R302.1 v1(300.81,79.63) ; R302.1 301.94,80.63 302.34,81.03 311.86,81.03 312.62,80.26 313.13,80.26 313.66,79.74 R301.1
  BOTTOM w0.762: J5.B10 286.83,5.89 287.26,6.32 287.26,8.73 285.45,10.54 285.45,13.16 286.59,14.3
  vias: v1(287.48,14.86) v1(288.24,14.86)
P3V3_STBY_OUT:
  vias: v1(299.21,91.77) v1(299.34,89.43) v1(299.31,87.25) v1(299.31,85.06) v1(299.95,87.25) v1(299.95,85.06) v1(299.97,89.43) v2(301.07,82.3)
P3V3_STBY_PG: length 7.8
  BOTTOM w0.114: PU16.6 313.18,85.35 314.17,84.35 317.73,84.35 v2(317.83,84.45) 319,85.62 PR317.2
P3V3_STBY_RT: length 2.7
  BOTTOM w0.254: PR322.1 314.52,85.27 v2(314.05,85.75) 314.05,86.02 313.63,86.45 PU16.5
P3V3_STBY_SS: length 5.3
  TOP w0.254: PR320.2 311.51,86.46 311.25,86.72 311.25,87.5 311.84,88.09 v5(311.99,88.09) 312.87,88.09 PR321.1 313.72,87.75 v1(313.94,87.98)
  BOTTOM w0.254: PU16.2 313.91,87.95 v1(313.94,87.98)
P3V3_STBY_VIN: length 4.8
  TOP w0.305: PR324.2 312.75,83.11 v5(313.36,83.72) 313.36,84.04 v1(312.67,84.73)
  BOTTOM w0.254: v1(312.67,84.73) 312.43,84.98 PU16.7
  BOTTOM w0.305: PC492.1 312.83,84.58 v1(312.67,84.73)
P3V3_STBY_VSENSE_R: length 21.1
  TOP w0.254: PR329.1 300.86,93.8 301.65,94.59 310.85,94.59 312.22,93.22 314.63,93.22 315.8,92.05 316.28,92.05 v1(316.78,91.55)
  BOTTOM w0.254: v1(316.78,91.55) 316.42,91.2 PC504.2 PR328.2
P3V3_VCC: length 8.4
  IN3 w0.254: v1(301.75,105.75) 301.36,106.15 299.44,106.15 v6(298.43,105.13)
  BOTTOM w0.254: PU17.6 301.31,107.05 301.75,106.61 v1(301.75,105.75) ; PU17.10 298.43,105.62 v6(298.43,105.13)
  BOTTOM w0.381: PC508.2 299.16,104.27 298.43,105 v6(298.43,105.13)
P3V3_VIN: length 4.2
  TOP w0.381: PR341.2 298.98,104.39 v6(299.72,105.13)
  BOTTOM w0.254: PU17.9 299.36,105.49 v6(299.72,105.13)
  BOTTOM w0.381: PC510.1 300.46,103.97 299.72,104.71 v6(299.72,105.13)
P3V3_VREF: length 1.8
  TOP w0.254: v1(301.7,109.43) 301.37,109.1 PC509.1
  BOTTOM w0.254: PU17.2 301.49,109.65 v1(301.7,109.43)
P3V3_VSNS: length 5.2
  TOP w0.254: PR343.2 299.82,106.78 300.87,105.73 v5(300.87,105.7) 300.87,105.12 v1(300.65,104.9) 301.43,104.9 PR345.1
  BOTTOM w0.254: PU17.8 300.01,105.78 300.65,105.14 v1(300.65,104.9)
P5V_STBY_VCC: length 3.3
  TOP w0.254: PR320.1 311.71,84.53 v6(311.79,84.45)
  BOTTOM w0.254: v6(311.79,84.45) 311.93,84.6 PU16.8
  BOTTOM w0.305: v6(311.79,84.45) 311.79,84.43 311.53,84.17 PC491.1
P12V: length 2.6
  TOP w0.254: v1(303.61,114.72) PR332.1
  TOP w0.305: PR402.1 34.59,109.28 v1(34.44,109.43)
  BOTTOM w0.305: PR405.1 33.93,109.43 v1(34.44,109.43)
  vias: v1(1.91,93.78) v1(2.03,92.76) v1(1.96,88.9) v1(2.08,87.88) v1(3.48,88.72) v1(3.61,87.71) v1(3.66,96.24) v1(3.79,95.22) v1(4.42,98.91) v1(4.55,97.89) v1(5.21,88.87) v1(5.34,87.86) v1(6.48,89.53) v1(6.61,88.52) v1(7.19,104.65) v1(7.32,91.95) v1(7.44,101.98) v1(7.44,95.12) v1(7.57,104.01) v1(7.57,100.58) v1(7.57,99.06) v1(7.57,97.92) v1(7.57,94.11) v1(7.57,92.96) v1(7.7,96.01) v1(7.82,103.12) v1(8.21,97.16) v1(8.59,102.62) v1(8.59,99.95) v1(8.71,93.85) v1(9.35,103.12) v1(9.48,96.9) v1(9.6,93.47) v1(9.73,102.49) v1(9.86,100.33) v1(9.86,99.57) v1(9.98,94.49) v1(10.11,96.01) v1(10.24,105.16) v1(10.24,104.27) v1(10.24,103.38) v1(10.24,101.73) v1(10.24,97.92) v1(10.24,92.58) v1(13.03,100.2) v1(13.03,99.31) v1(13.03,94.36) v1(13.03,93.47) v1(22.81,89.79) v1(22.94,101.47) v1(53.17,36.46) v1(53.17,35.83) v1(53.81,37.1) v1(53.81,36.46) v1(53.81,35.83) v1(88.39,41) v1(88.39,40.34) v1(88.39,39.68) v1(158.07,112.83) v1(158.19,111.81) v1(158.27,115.54) v1(158.4,114.53) v1(160.91,115.77) v1(161.04,114.76) v1(161.11,113.26) v1(161.24,112.24) v1(163.15,115.65) v1(163.27,114.63) v1(195.51,112.73) v1(195.56,115.7) v1(195.63,111.71) v1(195.68,114.68) v1(197.66,113.67) v1(197.79,112.65) v1(198.93,115.82) v1(199.06,114.81) v1(280.11,31.75) v1(284.68,115.32) v1(284.68,114.55) v1(285.24,114.91) v1(285.24,114.22) v1(285.27,115.62) v1(292.94,103.12) v1(293.45,31.88) v1(293.57,103.12) v1(293.57,92.84) v1(293.57,72.64) v1(293.57,52.2) v1(294.46,31.88) v1(294.59,92.84) v1(294.59,72.64) v1(294.59,52.2) v1(295.61,83.95) v1(295.61,83.19) v1(295.61,63.75) v1(295.61,62.87) v1(295.86,43.18) v1(295.86,42.42) v1(295.86,33.53) v1(295.86,32.77) v1(295.99,94.49) v1(295.99,93.73) v1(295.99,53.72) v1(295.99,52.96) v1(296.11,74.3) v1(296.11,73.28)
P12V_MB: length 3.3
  BOTTOM w0.508: J5.B1 295.83,5.7 295.05,6.48
  vias: v1(293.19,8.64) v1(293.19,7.87) v1(293.19,7.11) v1(293.83,8.64) v1(293.83,7.87) v1(293.83,7.11) v1(294.46,8.64) v1(294.46,7.87) v1(294.46,7.11) v2(293.83,10.57)
P12V_PSU: length 0.7
  TOP w0.254: v1(314.93,82.95) 314.86,83.03 PR314.1
  vias: v1(12.4,86.74) v1(13.03,87.25) v1(13.03,86.36) v1(300.31,25.53) v1(300.31,24.38) v1(301.45,25.53) v1(301.45,24.38) v1(302.24,92.2) v1(302.54,92.91) v1(302.94,92.23)
VCC_P5V_1: length 18.7
  TOP w0.305: v1(29.15,105.88) 28.36,106.67 PR398.1
  TOP w0.457: v1(36.24,101.9) 36.25,101.9 PR301.1
  IN2 w0.254: v1(29.15,105.88) 29.92,105.11 29.92,102.6 v1(29.22,101.89)
  BOTTOM w0.305: v1(29.15,105.88) 29.34,105.69 32.54,105.69 PR407.1
  BOTTOM w0.381: PC569.1 31.91,102.05
  BOTTOM w0.457: PR298.1 35.17,101.15 PR296.1 35.92,101.44 36.24,101.76 v1(36.24,101.9) 36.24,102.47 v2(35.97,102.75) 35.88,102.83 32.68,102.83 31.91,102.05
VCC_P5V_2: length 44.3
  TOP w0.457: PR300.1 v1(36.25,90.28)
  IN3 w0.254: v1(29.19,90.21) 28.53,90.87 28.53,92.08 28.27,92.33 24.84,92.33 21.79,95.38 21.79,102.36 23.83,104.39 34.44,104.39 35.4,105.1 v1(35.51,105.79)
  BOTTOM w0.305: PR413.1 34.81,106.48 PR407.2 34.27,105.79 v1(35.51,105.79)
  BOTTOM w0.457: PC577.1 31.55,90.24 32.61,91.3 35.53,91.3 36.25,90.58 v1(36.25,90.28) 36.25,89.8 PR143.1 35.17,89.47 PR299.1
2N7002_G1_D2: length 6.7
  BOTTOM w0.254: PR406.1 30.89,107.31 31.37,107.8 PQ7.2 PQ7.3 32.02,108.67 PR405.2 32.95,110.22 33.15,110.41 v2(35.16,110.41)
2N7002_G2_R: length 5.1
  BOTTOM w0.254: PQ7.5 34.66,107.8 PR414.1 PC578.1 35.82,107.95 36.7,107.95 36.96,107.7 v2(36.96,107.26) 36.71,107.01 PR413.2
85OHM_BOT_5INCH_DN: length 127
  BOTTOM w0.135: U39.1 -14.93,221.74 -14.93,219.5 -15.14,218.3 -14.89,217.94 -7.57,216.64 -7.42,216.43 -7.51,215.91 -7.72,215.76 -17.34,217.46 -17.77,217.15 -17.91,216.37 -17.63,215.98 -7.8,214.24 -7.6,213.96 -7.68,213.51 -7.9,213.35 -17.21,214.99 -17.6,214.73 -17.75,213.89 -17.48,213.51 -8.58,211.94 -8.43,211.72 -8.53,211.17 -8.7,211.05 -17.11,212.53 -17.51,212.26 -17.65,211.44 -17.38,211.05 -7.76,209.35 -7.61,209.14 -7.7,208.58 -7.87,208.46 -17.17,210.1 -17.6,209.8 -17.72,209.08 -17.4,208.62 -7.89,206.94 -7.78,206.92 -7.73,206.91 -7.66,206.81 -7.61,206.73 -7.72,206.12 -7.86,206.02 -16.12,207.47 -16.55,207.18 -16.68,206.45 -16.35,205.99 -9.21,204.73 -9.09,204.56 -9.2,203.92 -9.32,203.83 -12.51,204.4 -13.41,204.24 -13.97,203.44 -13.97,200.55 U41.2
85OHM_BOT_5INCH_DP: length 127
  BOTTOM w0.135: U39.2 -14.63,221.75 -14.63,219.48 -14.82,218.37 -14.71,218.21 -7.39,216.92 -7.1,216.5 -7.23,215.73 -7.65,215.44 -17.27,217.13 -17.49,216.97 -17.59,216.44 -17.45,216.26 -7.62,214.52 -7.28,214.03 -7.41,213.33 -7.83,213.03 -17.14,214.67 -17.32,214.54 -17.43,213.96 -17.31,213.79 -10.18,212.53 -8.4,212.22 -8.11,211.79 -8.25,210.99 -8.63,210.73 -17.04,212.21 -17.23,212.08 -17.33,211.51 -17.2,211.33 -7.58,209.63 -7.28,209.21 -7.42,208.4 -7.8,208.14 -17.09,209.78 -17.32,209.62 -17.4,209.15 -17.23,208.9 -7.56,207.19 -7.48,207.09 -7.46,207.04 -7.41,206.98 -7.29,206.8 -7.44,205.94 -7.61,205.82 -7.79,205.7 -16.05,207.15 -16.27,207 -16.35,206.52 -16.18,206.26 -9.03,205 -8.76,204.63 -8.92,203.74 -9.25,203.51 -12.51,204.09 -13.24,203.96 -13.67,203.34 -13.67,200.56 U41.1
85OHM_BOT_10INCH_DN: length 254
  BOTTOM w0.135: U45.2 -14.75,45.47 -14.75,43.2 -14.95,42.09 -14.84,41.94 -7.52,40.65 -7.22,40.22 -7.36,39.46 -7.78,39.16 -17.39,40.86 -17.62,40.7 -17.71,40.17 -17.58,39.98 -7.75,38.25 -7.41,37.76 -7.53,37.05 -7.96,36.75 -17.26,38.39 -17.45,38.27 -17.55,37.69 -17.43,37.51 -7.96,35.84 -7.67,35.43 -7.79,34.69 -8.27,34.36 -17.33,35.96 -17.48,35.86 -17.58,35.28 -17.43,35.07 -7.93,33.39 -7.65,33 -7.79,32.18 -8.18,31.91 -17.32,33.52 -17.49,33.4 -17.6,32.79 -17.49,32.64 -7.97,30.96 -7.68,30.55 -7.82,29.75 -8.22,29.47 -17.39,31.09 -17.57,30.96 -17.67,30.38 -17.56,30.21 -8.01,28.52 -7.73,28.12 -7.87,27.3 -8.25,27.04 -17.26,28.63 -17.42,28.51 -17.52,27.94 -17.39,27.75 -8.23,26.12 -7.98,25.76 -8.12,24.94 -8.54,24.65 -17.37,26.2 -17.56,26.04 -17.64,25.51 -17.49,25.31 -8.15,23.67 -7.89,23.3 -8.04,22.46 -8.44,22.19 -17.45,23.77 -17.62,23.66 -17.71,23.13 -17.55,22.9 -8.42,21.29 -8.17,20.78 -8.29,20.09 -8.71,19.79 -17.1,21.27 -17.28,21.15 -17.38,20.58 -17.24,20.39 -8.54,18.85 -8.25,18.43 -8.39,17.63 -8.77,17.36 -17.26,18.86 -17.43,18.73 -17.54,18.14 -17.42,17.98 -8.49,16.4 -8.25,16.05 -8.4,15.16 -8.76,14.92 -17.01,16.37 -17.23,16.22 -17.32,15.74 -17.14,15.49 -9.99,14.22 -9.73,13.85 -9.88,12.97 -9.99,12.89 -9.99,12.89 -10.22,12.73 -13.48,13.31 -14.17,13.19 -14.63,12.53 -14.63,9.78 U43.1
85OHM_BOT_10INCH_DP: length 254
  BOTTOM w0.135: U45.1 -15.06,45.46 -15.06,43.23 -15.27,42.02 -15.02,41.66 -7.7,40.37 -7.55,40.15 -7.64,39.63 -7.85,39.48 -17.46,41.18 -17.9,40.88 -18.03,40.1 -17.76,39.7 -7.93,37.97 -7.73,37.69 -7.81,37.23 -8.03,37.07 -17.33,38.71 -17.72,38.45 -17.88,37.62 -17.61,37.23 -8.13,35.56 -7.99,35.35 -8.07,34.87 -8.34,34.69 -17.4,36.28 -17.75,36.04 -17.9,35.21 -17.61,34.79 -8.1,33.12 -7.97,32.93 -8.07,32.36 -8.25,32.23 -17.39,33.84 -17.77,33.58 -17.92,32.72 -17.67,32.36 -8.15,30.68 -8.01,30.48 -8.1,29.93 -8.3,29.8 -17.46,31.41 -17.85,31.14 -18,30.3 -17.73,29.93 -8.18,28.25 -8.05,28.05 -8.15,27.48 -8.32,27.36 -17.33,28.95 -17.7,28.69 -17.72,28.57 -17.84,27.87 -17.56,27.48 -8.41,25.84 -8.3,25.69 -8.4,25.12 -8.61,24.97 -17.45,26.53 -17.85,26.21 -17.95,25.43 -17.67,25.03 -8.32,23.39 -8.21,23.23 -8.32,22.64 -8.51,22.51 -17.52,24.1 -17.9,23.84 -17.92,23.71 -18.03,23.05 -17.73,22.62 -8.63,21.02 -8.48,20.73 -8.57,20.26 -8.78,20.12 -17.17,21.6 -17.56,21.33 -17.7,20.51 -17.42,20.11 -8.72,18.57 -8.57,18.36 -8.67,17.8 -8.84,17.68 -17.33,19.18 -17.71,18.91 -17.86,18.07 -17.6,17.7 -8.67,16.12 -8.57,15.98 -8.68,15.34 -8.83,15.24 -17.08,16.7 -17.51,16.4 -17.64,15.67 -17.32,15.21 -10.17,13.95 -10.05,13.78 -10.16,13.14 -10.29,13.06 -13.48,13.62 -14.35,13.46 -14.94,12.62 -14.94,9.77 U43.2
