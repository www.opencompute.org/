# Allegro board 4-SLOT_96LANE_RISER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PE_CPU_RX_C_DN<3>: length 210.9
  BOTTOM w0.089: U1.AA1 77.86,64.95 77.95,65.03 78.18,65.03 78.27,64.95 78.27,64.24 78.21,64.19 78.21,64.16
  BOTTOM w0.135: C38.1 265.15,12.69 265.15,13.57 265,14.43 264.43,15.25 263.69,15.77 263.48,15.73 263.15,15.96 263.11,16.17 262.78,16.41 262.57,16.37 262.24,16.6 262.2,16.81 257.13,20.36 v3(248.93,21.81) 208.86,28.88 171.22,55.24 163.19,56.65 150.41,65.61 134.6,68.39 126.71,67 115.62,59.23 100.57,56.58 92.44,57.64 81.74,59.29 80.56,60.12 80.09,60.45 78.34,62.95 78.21,63.67 78.21,64.16
PE_CPU_RX_C_DN<4>: length 206.8
  BOTTOM w0.089: U1.AC1 75.86,64.95 75.95,65.03 76.1,65.03 76.27,64.87 76.27,64.17 76.21,64.11 76.21,64.09
  BOTTOM w0.135: C91.1 259.16,12.69 259.16,13.3 259.03,14.02 258.52,14.75 258.08,15.05 257.87,15.01 257.54,15.25 257.5,15.46 257.17,15.69 256.96,15.66 256.63,15.89 256.59,16.1 v3(253.97,17.93) 250.6,20.29 208.35,27.74 171.07,53.85 160.49,55.71 147.45,64.85 134.66,67.16 127.31,65.86 115.93,57.89 100.57,55.18 92.29,56.21 92.29,56.21 87.54,57.05 87.53,57.05 81.16,58.18 79.24,59.52 78.81,60.12 76.26,63.77 76.21,63.82 76.21,64.09
PE_CPU_RX_C_DN<5>: length 204.4
  BOTTOM w0.089: U1.AD1 74.86,64.95 74.95,65.03 75.15,65.03 75.28,64.91 75.28,64.02 75.23,63.96 75.23,63.94
  BOTTOM w0.135: C92.1 255.17,12.69 255.17,13.24 255.05,13.94 254.52,14.7 254.08,15.01 253.87,14.97 253.53,15.2 253.5,15.41 253.17,15.64 252.95,15.61 252.62,15.84 252.58,16.05 v3(250.47,17.53) 248.9,18.63 247.49,19.62 207.78,26.62 170.95,52.41 159.98,54.35 146.47,63.81 134.52,65.91 127.97,64.76 116.39,56.64 100.91,53.92 100.7,53.92 100.69,53.92 100.56,53.92 98.05,54.26 98.05,54.26 93.58,54.77 93.56,54.77 80.68,57.04 78.37,58.66 75.34,62.99 75.23,63.63 75.23,63.94
PE_CPU_RX_C_DN<6>: length 202
  BOTTOM w0.089: U1.AE1 73.86,64.95 73.95,65.03 74.17,65.03 74.26,64.95 74.26,64.12 74.2,64.06 74.2,64.04
  BOTTOM w0.135: C93.1 251.16,12.69 251.16,13.11 251.02,13.88 250.55,14.55 249.65,15.18 249.44,15.15 249.11,15.38 249.07,15.59 248.74,15.82 248.52,15.78 248.19,16.02 248.16,16.23 v3(246.73,17.23) 245.27,18.25 244.24,18.97 207.03,25.53 188.85,38.26 175.29,47.75 173.04,49.33 170.78,50.91 165.23,51.89 159.55,52.89 145.45,62.77 134.54,64.69 128.41,63.54 116.89,55.48 100.57,52.6 96.45,53.11 94.35,53.41 93.86,53.5 80.21,55.9 77.51,57.8 74.46,62.14 74.21,63.6 74.2,63.6 74.2,64.04
PE_CPU_RX_C_DN<7>: length 199.7
  BOTTOM w0.089: 73.21,63.94 73.21,63.96 73.27,64.01 73.27,64.89 73.13,65.03 72.95,65.03 72.86,64.95 U1.AF1
  BOTTOM w0.135: C94.1 247.17,12.69 247.17,13.13 247.05,13.79 246.66,14.36 246.01,14.81 245.79,14.77 245.46,15 245.42,15.22 245.09,15.45 244.88,15.41 244.55,15.64 244.51,15.86 244.18,16.09 243.97,16.05 243.64,16.28 243.6,16.5 240.99,18.32 206.51,24.4 170.57,49.56 v3(162.73,50.95) 158.81,51.64 144.41,61.72 134.69,63.43 128.98,62.42 117.08,54.09 100.88,51.24 100.69,51.26 100.69,51.26 100.56,51.27 99.21,51.45 99.17,51.46 96.44,51.82 96.44,51.82 89.69,53.01 88.4,53.24 87.45,53.41 85.66,53.72 79.74,54.76 79.74,54.77 78.11,55.91 76.64,56.94 76.04,57.8 75.18,59.02 73.54,61.36 73.21,63.26 73.21,63.94
PE_CPU_RX_C_DN<8>: length 196.1
  BOTTOM w0.089: U1.AG1 71.86,64.95 71.95,65.03 72.13,65.03 72.28,64.89 72.28,63.99 72.22,63.93 72.22,63.91
  BOTTOM w0.135: C95.1 242.17,12.69 242.17,13.03 242.05,13.68 241.62,14.3 241.01,14.72 240.8,14.68 240.47,14.91 240.43,15.13 240.1,15.36 239.89,15.32 239.56,15.55 239.52,15.77 236.47,17.9 205.92,23.29 170.43,48.13 v3(165.56,48.99) 158.44,50.25 143.6,60.64 134.78,62.2 129.48,61.26 117.61,52.95 100.91,50.01 96.25,50.63 79.27,53.63 75.78,56.07 72.65,60.55 72.22,62.96 72.22,63.91
PE_CPU_RX_C_DN<9>: length 193.7
  BOTTOM w0.089: U1.AH1 70.86,64.95 70.95,65.03 71.08,65.03 71.26,64.85 71.26,63.96 71.2,63.91 71.2,63.88
  BOTTOM w0.135: 71.2,63.88 71.2,62.56 71.69,59.82 73.45,57.3 74.92,55.21 78.8,52.49 96.62,49.35 100.49,48.81 100.71,48.8 100.95,48.78 118.11,51.8 118.11,51.8 118.18,51.85 118.18,51.85 129.96,60.1 134.74,60.94 142.61,59.55 157.99,48.78 v3(160.71,48.3) 170.37,46.6 205.23,22.19 233.21,17.25 233.58,16.99 234.91,16.07 234.94,15.85 235.28,15.62 235.49,15.66 235.82,15.43 235.86,15.21 236.19,14.98 236.4,15.02 236.73,14.79 236.77,14.57 237.1,14.34 237.31,14.38 237.65,14.14 238.09,13.52 238.18,13 238.18,12.69 C96.1
PE_CPU_RX_C_DN<10>: length 191.1
  BOTTOM w0.089: U1.AJ1 69.86,64.95 69.95,65.03 70.08,65.03 70.27,64.84 70.27,63.84 70.21,63.78 70.21,63.76
  BOTTOM w0.135: 70.21,63.76 70.21,62.47 70.84,58.94 72.59,56.44 74.05,54.35 78.33,51.35 96.48,48.15 96.78,48.1 100.56,47.55 100.77,47.52 118.7,50.68 130.45,58.91 134.87,59.69 141.95,58.44 157.55,47.52 v3(163.9,46.4) 170.02,45.32 204.65,21.05 230.16,16.56 230.84,16.08 231.42,15.68 231.75,15.44 231.79,15.23 232.12,15 232.33,15.04 232.66,14.81 232.7,14.59 233.03,14.36 233.25,14.4 233.78,14.03 234.05,13.63 234.16,13 234.16,12.69 C97.1
PE_CPU_RX_C_DN<11>: length 188.8
  BOTTOM w0.089: U1.AK1 68.86,64.95 68.95,65.03 69.08,65.03 69.28,64.83 69.28,63.76 69.22,63.7 69.22,63.68
  BOTTOM w0.135: 69.22,63.68 69.22,61.45 69.77,58.38 71.27,56.24 73.19,53.48 77.86,50.21 96.76,46.88 100.79,46.28 119.3,49.55 131.07,57.79 134.83,58.45 141.34,57.3 157.07,46.29 v3(159.89,45.79) 169.09,44.17 180.64,36.09 180.91,36.04 181.05,36.02 204.11,19.86 227.27,15.78 227.93,15.32 227.97,15.1 228.3,14.87 228.51,14.91 228.84,14.68 228.88,14.46 229.21,14.23 229.43,14.27 229.78,14.02 230.11,13.56 230.18,13.16 230.18,12.69 C98.1
PE_CPU_RX_C_DN<12>: length 197
  BOTTOM w0.089: U1.AP7 65.18,70.63 65.27,70.54 65.27,70.42 65.09,70.23 64.53,70.23 64.47,70.29 64.45,70.29
  BOTTOM w0.135: 64.45,70.29 63.97,70.29 63.35,69.68 63.2,68.8 63.05,67.95 63.05,67.95 62.88,67 63.06,65.97 63.2,65.2 63.47,63.64 64.01,62.87 65.67,60.5 66.13,60.42 66.79,60.87 66.97,60.84 67.33,60.33 67.3,60.14 66.65,59.68 66.57,59.25 70.14,54.15 77.38,49.08 87.25,47.34 87.25,47.34 97.06,45.61 99.01,45.31 101,45 119.94,48.34 131.78,56.63 133.47,56.93 135,57.2 140.59,56.21 156.99,44.72 v3(162.68,43.72) 168.71,42.66 180.06,34.71 180.53,34.63 180.87,34.57 203.44,18.76 223.88,15.16 225.78,13.82 226.1,13.36 226.16,13.02 226.16,12.69 C99.1
PE_CPU_RX_C_DN<13>: length 194.5
  BOTTOM w0.089: U1.AP8 65.18,71.63 65.27,71.54 65.27,71.42 65.09,71.24 64.47,71.24 64.41,71.29 64.39,71.29
  BOTTOM w0.135: 64.39,71.29 63.61,71.29 63.2,71.02 62.82,70.77 62.57,70.44 62.16,69.85 61.66,66.99 62.39,62.82 68.87,53.57 76.91,47.94 100.86,43.72 120.37,47.16 132.2,55.44 135.11,55.95 139.52,55.17 156.01,43.62 v3(159.06,43.08) 167.67,41.57 179.19,33.5 180.21,33.32 202.53,17.69 221.09,14.41 221.79,13.93 222.11,13.47 222.18,13.08 222.18,12.69 C100.1
PE_CPU_RX_C_DN<14>: length 194
  BOTTOM w0.089: U1.AP9 65.18,72.63 65.27,72.54 65.27,72.42 65.08,72.22 64.23,72.22 64.18,72.28 64.15,72.28
  BOTTOM w0.135: C101.1 218.16,12.69 218.16,12.95 218.12,13.2 217.88,13.54 217.47,13.83 201.52,16.64 179.64,31.96 178.69,32.13 177.6,32.32 165.79,40.59 v3(162.54,41.16) 155.61,42.38 147.27,48.23 139.03,54 135.16,54.68 133,54.3 121.19,46.03 101.01,42.47 76.44,46.8 67.54,53.03 61.3,61.94 60.4,67.06 60.98,70.35 61.89,71.64 62.63,72.16 63.3,72.28 64.15,72.28
PE_CPU_RX_C_DN<15>: length 191.8
  BOTTOM w0.089: 64.46,73.29 64.48,73.29 64.54,73.23 65.08,73.23 65.27,73.42 65.27,73.54 65.18,73.63 U1.AP10
  BOTTOM w0.135: C102.1 214.17,12.69 214.17,12.87 214.09,12.98 213.97,13.16 201.09,15.43 179.63,30.46 176.82,30.96 165.25,39.06 v3(162.05,39.62) 158.79,40.2 158.64,40.09 158.55,39.61 158.19,39.36 157.57,39.47 157.32,39.83 157.4,40.3 157.29,40.46 151.99,41.4 151.83,41.29 151.73,40.7 151.37,40.44 150.75,40.55 150.5,40.91 150.6,41.5 150.49,41.66 150.12,41.73 149.97,41.62 149.86,41.02 149.5,40.77 148.88,40.88 148.63,41.24 148.73,41.83 148.62,41.99 138.72,43.74 129.49,43.91 128.28,43.7 121.63,44.87 101.03,41.24 75.97,45.66 66.29,52.44 60.23,61.09 59.18,67.05 59.85,70.82 61.02,72.51 62.16,73.3 63.16,73.48 63.23,73.47 64.23,73.29 64.46,73.29
PE_CPU_RX_C_DP<0>: length 219.3
  BOTTOM w0.089: 81.51,64.15 81.51,64.17 81.45,64.23 81.45,65.01 81.23,65.23 80.95,65.23 80.86,65.31 U1.V2
  BOTTOM w0.135: 81.51,64.15 81.51,64.01 81.53,63.87 81.71,63.62 82.37,63.15 83.69,62.92 88.12,62.27 97.77,61.79 97.9,61.78 97.9,61.78 102.84,61.53 108.77,62.57 108.77,62.57 114.69,63.62 124.7,70.63 134.76,72.4 154.51,68.92 v3(155.86,67.98) 157.32,66.95 162.14,63.58 165.37,61.31 170.76,60.36 203.39,37.51 210.42,32.58 267.19,22.57 277.88,15.09 278.3,14.48 278.49,13.44 278.49,12.69 C23.1
PE_CPU_RX_C_DP<1>: length 217
  BOTTOM w0.089: 80.53,64.16 80.53,64.19 80.47,64.24 80.47,64.91 80.16,65.23 79.95,65.23 79.86,65.31 U1.W2
  BOTTOM w0.135: 80.53,64.16 80.53,64.03 80.57,63.77 81.36,62.64 82.37,61.93 82.94,61.83 87.1,61.2 102.2,60.02 114.95,62.26 115.69,62.78 115.69,62.78 125.29,69.5 134.66,71.15 153.11,67.88 v3(155.55,66.17) 156.95,65.19 164.67,59.79 171.1,58.65 209.95,31.45 209.95,31.45 262.42,22.19 266.11,19.61 266.3,19.64 266.62,20.1 267.05,20.18 267.77,19.67 267.85,19.23 267.53,18.77 267.56,18.59 272.8,14.92 273.32,14.17 273.48,13.26 273.48,12.69 C24.1
PE_CPU_RX_C_DP<2>: length 213.2
  BOTTOM w0.089: U1.Y2 78.86,65.31 78.95,65.23 79.25,65.23 79.45,65.02 79.45,64.12 79.51,64.06 79.51,64.04
  BOTTOM w0.135: C25.1 269.47,12.69 269.47,13.39 269.33,14.18 268.71,15.07 259.56,21.47 v3(251.76,22.85) 209.5,30.29 171.56,56.86 167.86,57.51 167.86,57.51 164.3,58.14 151.8,66.89 134.61,69.92 125.96,68.4 115.33,60.95 107.95,59.65 100.56,58.35 86.99,60.12 82.15,60.75 81,61.56 79.56,63.61 79.51,63.9 79.51,64.04
PE_CPU_RX_C_DP<3>: length 211
  BOTTOM w0.089: 78.52,64.16 78.52,64.19 78.46,64.24 78.46,65.02 78.26,65.23 77.95,65.23 77.86,65.31 U1.AA2
  BOTTOM w0.135: 78.52,64.16 78.52,63.7 78.63,63.07 80.31,60.67 81.09,60.12 81.86,59.59 92.48,57.95 100.56,56.88 108.03,58.2 115.5,59.52 126.59,67.29 134.6,68.7 150.53,65.89 163.31,56.94 167.26,56.24 171.34,55.53 208.98,29.17 233.05,24.92 v3(247.23,22.42) 257.25,20.65 264.65,15.47 265.29,14.55 265.46,13.6 265.46,12.69 C26.1
PE_CPU_RX_C_DP<4>: length 206.9
  BOTTOM w0.089: U1.AC2 75.86,65.31 75.95,65.23 76.18,65.23 76.46,64.95 76.46,64.17 76.51,64.11 76.51,64.09
  BOTTOM w0.135: C79.1 259.46,12.69 259.46,13.33 259.32,14.13 258.74,14.97 v3(252.74,19.17) 250.72,20.58 208.47,28.03 171.19,54.14 165.83,55.08 160.61,56 147.57,65.14 134.66,67.47 127.19,66.15 115.81,58.18 108.18,56.83 100.56,55.49 92.34,56.51 92.34,56.51 81.27,58.47 79.45,59.74 79.19,60.12 76.51,63.94 76.51,64.09
PE_CPU_RX_C_DP<5>: length 204.5
  BOTTOM w0.089: U1.AD2 74.86,65.31 74.95,65.23 75.23,65.23 75.47,64.98 75.47,64.02 75.53,63.96 75.53,63.94
  BOTTOM w0.135: 75.53,63.94 75.53,63.65 75.63,63.11 77.72,60.12 78.59,58.88 80.8,57.33 93.61,55.07 98.08,54.57 100.56,54.22 100.69,54.22 100.7,54.22 100.89,54.22 108.58,55.58 116.27,56.93 127.85,65.05 134.52,66.22 146.59,64.09 160.1,54.64 171.07,52.7 207.9,26.91 247.61,19.91 v3(249.07,18.88) 254.74,14.92 255.33,14.06 255.47,13.27 255.47,12.69 C80.1
PE_CPU_RX_C_DP<6>: length 202
  BOTTOM w0.089: U1.AE2 73.86,65.31 73.95,65.23 74.25,65.23 74.45,65.02 74.45,64.12 74.51,64.06 74.51,64.04
  BOTTOM w0.135: 74.51,64.04 74.51,63.65 74.75,62.26 77.73,58.02 80.33,56.19 92.16,54.11 94.39,53.71 96.49,53.41 100.56,52.91 116.77,55.77 116.78,55.77 128.29,63.83 134.54,65 145.57,63.05 159.66,53.18 170.9,51.2 179.99,44.84 207.15,25.82 244.36,19.26 v3(245.45,18.5) 250.77,14.77 251.31,14 251.46,13.14 251.46,12.69 C81.1
PE_CPU_RX_C_DP<7>: length 199.6
  BOTTOM w0.089: U1.AF2 72.86,65.31 72.95,65.23 73.21,65.23 73.46,64.97 73.46,64.01 73.52,63.96 73.52,63.94
  BOTTOM w0.135: 73.52,63.94 73.52,63.28 73.83,61.48 75.4,59.24 76.86,57.15 79.86,55.05 83.91,54.34 84.16,54.3 84.25,54.28 96.48,52.12 96.48,52.12 97.29,52.01 99.22,51.77 99.25,51.76 100.39,51.61 100.6,51.58 100.73,51.57 100.73,51.56 100.88,51.55 108.92,52.96 116.96,54.38 128.86,62.71 134.69,63.74 144.53,62.01 158.93,51.93 v3(161.48,51.48) 170.69,49.85 206.62,24.69 241.11,18.61 246.88,14.57 247.34,13.91 247.47,13.16 247.47,12.69 C82.1
PE_CPU_RX_C_DP<8>: length 196.2
  BOTTOM w0.089: U1.AG2 71.86,65.31 71.95,65.23 72.21,65.23 72.47,64.97 72.47,63.99 72.53,63.93 72.53,63.91
  BOTTOM w0.135: C83.1 242.47,12.69 242.47,13.05 242.34,13.8 241.84,14.52 236.59,18.19 221.25,20.89 206.03,23.57 170.55,48.42 v3(164.18,49.54) 158.56,50.53 143.72,60.92 134.78,62.51 129.36,61.55 117.49,53.24 100.9,50.32 96.3,50.93 79.39,53.92 76,56.29 74.54,58.38 72.93,60.67 72.53,62.99 72.53,63.91
PE_CPU_RX_C_DP<9>: length 193.6
  BOTTOM w0.089: U1.AH2 70.86,65.31 70.95,65.23 71.16,65.23 71.45,64.93 71.45,63.96 71.51,63.91 71.51,63.88
  BOTTOM w0.135: 71.51,63.88 71.51,62.59 71.74,61.26 71.98,59.94 73.67,57.52 75.14,55.43 78.92,52.78 96.67,49.65 100.52,49.11 100.93,49.09 117.99,52.09 118.01,52.1 118.03,52.12 129.84,60.39 134.74,61.25 142.73,59.84 158.11,49.07 v3(159.34,48.86) 164.23,47.99 170.49,46.89 205.35,22.47 219.27,20.02 233.33,17.54 237.87,14.36 238.37,13.64 238.48,13.03 238.48,12.69 C84.1
PE_CPU_RX_C_DP<10>: length 191.2
  BOTTOM w0.089: U1.AJ2 69.86,65.31 69.95,65.23 70.16,65.23 70.46,64.92 70.46,63.84 70.52,63.78 70.52,63.76
  BOTTOM w0.135: C85.1 234.47,12.69 234.47,13.03 234.34,13.75 234,14.24 230.28,16.85 204.77,21.34 170.14,45.61 v3(162.48,46.96) 157.67,47.81 142.07,58.73 134.87,60 130.34,59.2 118.58,50.97 118.58,50.97 100.77,47.83 100.56,47.86 96.83,48.4 96.82,48.4 96.53,48.45 78.45,51.64 74.27,54.57 72.81,56.65 71.12,59.06 70.52,62.5 70.52,63.76
PE_CPU_RX_C_DP<11>: length 188.8
  BOTTOM w0.089: 69.53,63.68 69.53,63.7 69.47,63.76 69.47,64.91 69.16,65.23 68.95,65.23 68.86,65.31 U1.AK2
  BOTTOM w0.135: C86.1 230.48,12.69 230.48,13.18 230.39,13.68 230,14.24 227.39,16.07 204.23,20.15 181.17,36.3 180.76,36.38 169.21,44.46 v3(158.46,46.36) 157.19,46.58 141.46,57.59 134.83,58.76 130.95,58.08 125.01,53.92 125.01,53.92 119.18,49.84 100.78,46.59 96.81,47.18 77.98,50.5 73.41,53.7 71.64,56.24 70.05,58.5 69.53,61.48 69.53,63.68
PE_CPU_RX_C_DP<12>: length 196.9
  BOTTOM w0.089: U1.AN7 65.55,70.63 65.46,70.54 65.46,70.34 65.17,70.04 64.53,70.04 64.47,69.99 64.45,69.99
  BOTTOM w0.135: 64.45,69.99 64.09,69.99 63.63,69.53 63.35,67.9 63.35,67.9 63.19,67 63.2,66.98 63.76,63.76 64.39,62.87 64.62,62.53 64.83,62.5 65.06,62.17 65.03,61.95 65.85,60.78 66.06,60.74 66.71,61.2 67.15,61.12 67.66,60.4 67.58,59.96 66.93,59.5 66.89,59.32 70.36,54.37 77.5,49.37 97.11,45.91 101,45.31 119.82,48.63 131.66,56.92 132.57,57.08 134.18,57.37 135,57.51 140.71,56.5 148.91,50.76 157.11,45.01 v3(161.21,44.29) 168.83,42.95 180.18,35 180.99,34.85 203.56,19.05 224,15.44 226,14.04 226.39,13.48 226.47,13.04 226.47,12.69 C87.1
PE_CPU_RX_C_DP<13>: length 194.5
  BOTTOM w0.089: U1.AN8 65.55,71.63 65.46,71.54 65.46,71.34 65.17,71.05 64.47,71.05 64.41,70.99 64.39,70.99
  BOTTOM w0.135: C88.1 222.48,12.69 222.48,13.11 222.4,13.59 222.01,14.15 221.21,14.7 202.65,17.98 180.33,33.61 179.31,33.79 167.79,41.86 v3(157.55,43.66) 156.13,43.91 139.64,55.46 135.11,56.26 132.08,55.73 120.26,47.45 100.86,44.03 77.03,48.23 69.09,53.79 63.54,61.71 63.58,61.92 63.35,62.25 63.14,62.29 62.68,62.94 61.97,66.99 62.21,68.36 62.45,69.73 62.82,70.26 63.03,70.55 63.2,70.66 63.7,70.99 64.39,70.99
PE_CPU_RX_C_DP<14>: length 193.9
  BOTTOM w0.089: U1.AN9 65.55,72.63 65.46,72.54 65.46,72.34 65.16,72.03 64.23,72.03 64.18,71.98 64.15,71.98
  BOTTOM w0.135: 64.15,71.98 63.33,71.98 63.2,71.95 62.75,71.87 62.11,71.42 61.27,70.23 60.71,67.06 61.59,62.06 62.05,61.41 62.26,61.37 62.5,61.04 62.46,60.83 67.76,53.25 76.56,47.09 101.01,42.78 121.07,46.32 132.88,54.59 135.16,54.99 139.15,54.28 155.73,42.67 v3(161.19,41.71) 165.91,40.88 171.85,36.73 171.85,36.72 177.72,32.61 179.76,32.25 201.64,16.93 217.59,14.12 218.1,13.76 218.41,13.32 218.47,12.98 218.47,12.69 C89.1
PE_CPU_RX_C_DP<15>: length 191.8
  BOTTOM w0.089: 64.46,72.98 64.48,72.98 64.54,73.04 65.16,73.04 65.46,73.34 65.46,73.54 65.55,73.63 U1.AN10
  BOTTOM w0.135: 64.46,72.98 64.18,72.98 64.18,72.99 63.2,73.16 63.16,73.17 62.28,73.01 61.24,72.29 60.13,70.71 59.49,67.05 60.52,61.21 61.01,60.51 61.23,60.47 61.46,60.14 61.42,59.93 66.51,52.66 76.09,45.95 101.03,41.55 121.63,45.18 128.28,44.01 128.88,44.11 129.47,44.22 138.75,44.04 148.8,42.27 149.05,41.91 148.95,41.31 149.06,41.16 149.43,41.09 149.58,41.2 149.69,41.79 150.05,42.05 150.67,41.94 150.92,41.58 150.82,40.98 150.93,40.83 151.3,40.76 151.45,40.87 151.56,41.46 151.92,41.72 157.47,40.74 157.73,40.38 157.64,39.9 157.75,39.75 158.12,39.68 158.28,39.79 158.36,40.26 158.72,40.52 v3(160.5,40.2) 165.37,39.35 176.94,31.24 179.75,30.75 201.21,15.72 214.14,13.44 214.47,12.98 214.48,12.96 214.48,12.69 C90.1
PE_CPU_RX_DN<0>: length 8.6
  TOP w0.135: v1(277.83,10.41) 278.17,10.07 278.17,6.15 277.83,5.8 J5.A17
  BOTTOM w0.135: v1(277.83,10.41) 278.18,10.77 278.18,11.18 C35.2
PE_CPU_RX_DN<1>: length 8.6
  TOP w0.135: J5.A22 272.83,5.8 273.17,6.15 273.17,10.09 v1(272.82,10.44)
  BOTTOM w0.135: v1(272.82,10.44) 273.18,10.79 273.18,11.18 C36.2
PE_CPU_RX_DN<2>: length 8.6
  TOP w0.135: v1(268.81,10.44) 269.17,10.08 269.17,6.15 268.83,5.8 J5.A26
  BOTTOM w0.135: C37.2 269.17,11.18 269.17,10.79 v1(268.81,10.44)
PE_CPU_RX_DN<3>: length 8.6
  TOP w0.135: v1(264.8,10.44) 265.17,10.06 265.17,6.18 264.83,5.83 J5.A30
  BOTTOM w0.135: v1(264.8,10.44) 265.15,10.79 265.15,11.18 C38.2
PE_CPU_RX_DN<4>: length 8.6
  TOP w0.135: v1(258.8,10.46) 259.17,10.09 259.17,6.15 258.83,5.8 J5.A36
  BOTTOM w0.135: C91.2 259.16,11.18 259.16,10.82 v1(258.8,10.46)
PE_CPU_RX_DN<5>: length 8.6
  TOP w0.135: v1(254.81,10.46) 255.17,10.1 255.17,6.15 254.83,5.8 J5.A40
  BOTTOM w0.135: v1(254.81,10.46) 255.17,10.82 255.17,11.18 C92.2
PE_CPU_RX_DN<6>: length 8.6
  TOP w0.135: v1(250.8,10.52) 251.17,10.14 251.17,6.15 250.83,5.8 J5.A44
  BOTTOM w0.135: C93.2 251.16,11.18 251.16,10.87 v1(250.8,10.52)
PE_CPU_RX_DN<7>: length 8.6
  TOP w0.135: v1(246.81,10.52) 247.17,10.15 247.17,6.15 246.83,5.8 J5.A48
  BOTTOM w0.135: C94.2 247.17,11.18 247.17,10.87 v1(246.81,10.52)
PE_CPU_RX_DN<8>: length 8.6
  TOP w0.135: J5.A53 241.83,5.8 242.17,6.15 242.17,10.13 v1(241.81,10.49)
  BOTTOM w0.135: v1(241.81,10.49) 242.17,10.85 242.17,11.18 C95.2
PE_CPU_RX_DN<9>: length 8.6
  TOP w0.135: J5.A57 237.83,5.8 238.17,6.15 238.17,10.19 v1(237.82,10.54)
  BOTTOM w0.135: C96.2 238.18,11.18 238.18,10.9 v1(237.82,10.54)
PE_CPU_RX_DN<10>: length 8.6
  TOP w0.135: J5.A61 233.83,5.8 234.17,6.15 234.17,10.15 v1(233.81,10.52)
  BOTTOM w0.135: C97.2 234.16,11.18 234.16,10.87 v1(233.81,10.52)
PE_CPU_RX_DN<11>: length 8.6
  TOP w0.135: v1(229.82,10.52) 230.17,10.16 230.17,6.15 229.83,5.8 J5.A65
  BOTTOM w0.135: C98.2 230.18,11.18 230.18,10.87 v1(229.82,10.52)
PE_CPU_RX_DN<12>: length 8.6
  TOP w0.135: v1(225.81,10.49) 226.17,10.12 226.17,6.15 225.83,5.8 J5.A69
  BOTTOM w0.135: v1(225.81,10.49) 226.16,10.85 226.16,11.18 C99.2
PE_CPU_RX_DN<13>: length 8.6
  TOP w0.135: J5.A73 221.83,5.8 222.17,6.15 222.17,10.06 v1(221.82,10.41)
  BOTTOM w0.135: v1(221.82,10.41) 222.18,10.77 222.18,11.18 C100.2
PE_CPU_RX_DN<14>: length 8.6
  TOP w0.135: J5.A77 217.83,5.8 218.17,6.15 218.17,10.15 v1(217.78,10.54)
  BOTTOM w0.135: C101.2 218.16,11.18 218.16,10.92 v1(217.78,10.54)
PE_CPU_RX_DN<15>: length 8.6
  TOP w0.135: v1(213.82,10.54) 214.2,10.16 214.2,6.22 213.83,5.85 J5.A81
  BOTTOM w0.135: v1(213.82,10.54) 214.17,10.9 214.17,11.18 C102.2
PE_CPU_RX_DP<0>: length 8.6
  TOP w0.135: v1(278.84,10.41) 278.48,10.05 278.48,6.15 278.83,5.8 J5.A16
  BOTTOM w0.135: v1(278.84,10.41) 278.49,10.77 278.49,11.18 C23.2
PE_CPU_RX_DP<1>: length 8.6
  TOP w0.135: J5.A21 273.83,5.8 273.48,6.15 273.48,10.08 v1(273.84,10.44)
  BOTTOM w0.135: v1(273.84,10.44) 273.48,10.79 273.48,11.18 C24.2
PE_CPU_RX_DP<2>: length 8.6
  TOP w0.135: J5.A25 269.83,5.8 269.48,6.15 269.48,10.09 v1(269.83,10.44)
  BOTTOM w0.135: C25.2 269.47,11.18 269.47,10.79 v1(269.83,10.44)
PE_CPU_RX_DP<3>: length 8.6
  TOP w0.135: J5.A29 265.83,5.81 265.48,6.15 265.48,10.11 v1(265.81,10.44)
  BOTTOM w0.135: v1(265.81,10.44) 265.46,10.79 265.46,11.18 C26.2
PE_CPU_RX_DP<4>: length 8.6
  TOP w0.135: J5.A35 259.83,5.8 259.48,6.15 259.48,10.13 v1(259.82,10.46)
  BOTTOM w0.135: C79.2 259.46,11.18 259.46,10.82 v1(259.82,10.46)
PE_CPU_RX_DP<5>: length 8.6
  TOP w0.135: v1(255.83,10.46) 255.48,10.11 255.48,6.15 255.83,5.8 J5.A39
  BOTTOM w0.135: v1(255.83,10.46) 255.47,10.82 255.47,11.18 C80.2
PE_CPU_RX_DP<6>: length 8.6
  TOP w0.135: v1(251.82,10.52) 251.48,10.18 251.48,6.15 251.83,5.8 J5.A43
  BOTTOM w0.135: C81.2 251.46,11.18 251.46,10.87 v1(251.82,10.52)
PE_CPU_RX_DP<7>: length 8.6
  TOP w0.135: v1(247.83,10.52) 247.48,10.17 247.48,6.15 247.83,5.8 J5.A47
  BOTTOM w0.135: v1(247.83,10.52) 247.47,10.87 247.47,11.18 C82.2
PE_CPU_RX_DP<8>: length 8.6
  TOP w0.135: v1(242.83,10.49) 242.48,10.14 242.48,6.15 242.83,5.8 J5.A52
  BOTTOM w0.135: C83.2 242.47,11.18 242.47,10.85 v1(242.83,10.49)
PE_CPU_RX_DP<9>: length 8.6
  TOP w0.135: J5.A56 238.83,5.8 238.48,6.15 238.48,10.18 v1(238.84,10.54)
  BOTTOM w0.135: v1(238.84,10.54) 238.48,10.9 238.48,11.18 C84.2
PE_CPU_RX_DP<10>: length 8.6
  TOP w0.135: v1(234.82,10.52) 234.48,10.17 234.48,6.15 234.83,5.8 J5.A60
  BOTTOM w0.135: C85.2 234.47,11.18 234.47,10.87 v1(234.82,10.52)
PE_CPU_RX_DP<11>: length 8.6
  TOP w0.135: v1(230.84,10.52) 230.48,10.16 230.48,6.15 230.83,5.8 J5.A64
  BOTTOM w0.135: v1(230.84,10.52) 230.48,10.87 230.48,11.18 C86.2
PE_CPU_RX_DP<12>: length 8.6
  TOP w0.135: v1(226.82,10.49) 226.48,10.15 226.48,6.15 226.83,5.8 J5.A68
  BOTTOM w0.135: C87.2 226.47,11.18 226.47,10.85 v1(226.82,10.49)
PE_CPU_RX_DP<13>: length 8.6
  TOP w0.135: v1(222.84,10.41) 222.48,10.06 222.48,6.15 222.83,5.8 J5.A72
  BOTTOM w0.135: v1(222.84,10.41) 222.48,10.77 222.48,11.18 C88.2
PE_CPU_RX_DP<14>: length 8.6
  TOP w0.135: v1(218.8,10.54) 218.48,10.22 218.48,6.15 218.83,5.8 J5.A76
  BOTTOM w0.135: v1(218.8,10.54) 218.47,10.87 218.47,11.18 C89.2
PE_CPU_RX_DP<15>: length 8.6
  TOP w0.135: J5.A80 214.83,5.9 214.5,6.22 214.5,10.21 v1(214.83,10.54)
  BOTTOM w0.135: C90.2 214.48,11.18 214.48,10.9 v1(214.83,10.54)
PE_CPU_TX_DN<0>: length 235.6
  TOP w0.089: 80.86,65.59 80.86,65.61 80.91,65.67 80.91,67.33 80.71,67.54 80.45,67.54 80.36,67.45 v4(80.36,67.13)
  TOP w0.135: 80.86,65.59 80.86,65.04 81.15,64.23 81.19,64.15 81.64,63.57 81.68,63.52 82.07,63.25 83.34,63.03 103.27,62.25 109.04,63.27 114.85,64.3 125.64,71.85 139.54,74.3 149.6,72.53 157.47,67.02 158.37,66.39 173.5,55.79 184.61,53.83 194,47.25 194,47.25 203.4,40.68 207.28,35.13 212.14,31.73 269.22,21.67 v3(272.98,19.03) 277.27,16.03 277.3,15.82 277.63,15.59 277.85,15.62 278.18,15.39 278.22,15.18 278.55,14.95 278.76,14.98 279.09,14.75 279.13,14.54 279.46,14.31 279.67,14.35 280.07,14.07 280.55,13.39 280.67,12.67 280.67,12.06 v1(280.32,11.71)
  BOTTOM w0.135: U1.V4 v4(80.36,67.13) ; J5.B15 279.83,5.8 280.17,6.15 280.17,7.51 280.67,10.33 280.67,11.35 v1(280.32,11.71)
PE_CPU_TX_DN<1>: length 233.8
  TOP w0.089: 79.71,65.46 79.77,65.51 79.77,67.35 79.58,67.54 79.45,67.54 79.36,67.45 v4(79.36,67.13)
  TOP w0.135: v1(274.83,7.8) 275.19,8.16 275.19,10.27 275,11.33 274.4,12.18 273.79,12.61 273.57,12.57 273.24,12.8 273.21,13.02 272.87,13.25 272.66,13.21 272.33,13.44 272.29,13.65 v3(271.57,14.16) 271.57,14.16 268.82,16.09 267.36,17.11 267.28,17.55 267.71,18.16 267.67,18.34 267.16,18.7 266.97,18.67 266.54,18.06 266.11,17.98 265.39,18.49 265.31,18.93 265.74,19.53 265.7,19.72 265.19,20.08 265,20.05 264.58,19.44 264.14,19.36 260.45,21.94 212.1,30.47 211.39,30.65 210.84,31.04 210.84,31.04 208.9,32.4 206.34,34.19 202.31,39.95 184.39,52.49 178.52,53.53 178.52,53.53 172.52,54.59 148.54,71.38 139.3,73 126.04,70.67 123.51,68.89 123.49,68.88 115.42,63.23 115.4,63.21 115.21,63.08 102.72,60.88 85.37,61.76 85.18,61.77 82.64,62.08 80.82,62.95 79.82,64.04 79.71,64.66 79.71,65.46
  BOTTOM w0.135: J5.B20 274.83,5.8 275.17,6.15 275.17,7.46 v1(274.83,7.8) ; U1.W4 v4(79.36,67.13)
PE_CPU_TX_DN<2>: length 227.2
  TOP w0.089: v4(78.36,67.13) 78.36,67.45 78.45,67.54 78.58,67.54 78.77,67.34 78.77,65.58 78.71,65.52
  TOP w0.135: 78.71,65.52 78.71,64.63 78.89,63.65 79.95,62.23 80.02,62.19 81.1,61.65 81.1,61.65 82.34,61.04 84.7,60.62 84.76,60.61 86.37,60.32 102.31,59.54 115.65,61.9 126.51,69.5 138.59,71.63 146.12,70.31 147.86,70 171.44,53.49 183.63,51.34 192.42,45.18 201.21,39.02 204.95,33.69 211.02,29.44 257.18,21.3 v3(263.65,16.77) 268.46,13.4 268.5,13.19 268.83,12.96 269.04,12.99 269.37,12.76 269.41,12.55 269.74,12.32 269.95,12.35 270.45,12 271,11.22 271.17,10.25 271.17,8.16 v1(270.82,7.8)
  BOTTOM w0.135: v1(270.82,7.8) 271.17,7.44 271.17,6.15 270.83,5.8 J5.B24 ; U1.Y4 v4(78.36,67.13)
PE_CPU_TX_DN<3>: length 224.9
  TOP w0.089: 77.71,63.66 77.76,63.71 77.76,67.4 77.63,67.54 77.45,67.54 77.36,67.45 v4(77.36,67.13)
  TOP w0.135: 77.71,63.66 77.71,62.71 77.96,62.35 81.36,59.97 83.65,59.57 86.58,59.05 96.23,58.16 100.96,58.09 100.97,58.09 100.99,58.09 116.12,60.76 126.89,68.3 138.13,70.28 146.91,68.73 170.21,52.41 183.15,50.13 199.25,38.86 202.89,33.67 210.55,28.3 254.05,20.62 256.55,18.88 v3(258.66,17.4) 264.26,13.48 264.3,13.26 264.63,13.03 264.84,13.07 265.18,12.84 265.21,12.62 265.54,12.39 265.76,12.43 266.36,12.01 267.01,11.08 267.16,10.23 267.16,8.16 v1(266.8,7.8)
  BOTTOM w0.135: J5.B28 266.83,5.8 267.17,6.15 267.17,7.43 v1(266.8,7.8) ; U1.AA4 v4(77.36,67.13)
PE_CPU_TX_DN<4>: length 220.6
  TOP w0.089: v4(75.36,67.13) 75.36,67.45 75.45,67.54 75.58,67.54 75.76,67.35 75.76,65.52 75.71,65.46 75.71,65.44
  TOP w0.135: 75.71,65.44 75.71,64.7 76.03,62.88 76.76,61.83 80.72,59.06 82.64,58.56 84.99,57.95 91.05,57.31 95.63,56.96 99.72,56.8 100.54,56.79 100.57,56.79 116.58,59.62 116.59,59.62 116.6,59.62 116.64,59.66 116.64,59.66 116.65,59.66 127.36,67.16 137.56,68.96 146.4,67.4 169.36,51.33 182.71,48.97 198.4,37.98 202.03,32.8 210.08,27.16 211.35,26.93 v3(214.41,26.39) 247.83,20.5 250.73,18.47 253.35,16.64 258.56,12.99 258.59,12.81 258.95,12.55 259.13,12.58 259.47,12.35 259.51,12.14 259.84,11.91 260.05,11.94 260.52,11.61 260.98,10.95 261.16,9.92 261.16,8.16 v1(260.81,7.8)
  BOTTOM w0.135: J5.B34 260.83,5.8 261.17,6.15 261.17,7.44 v1(260.81,7.8) ; U1.AC4 v4(75.36,67.13)
PE_CPU_TX_DN<5>: length 218.1
  TOP w0.089: 74.71,65.39 74.71,65.42 74.77,65.47 74.77,67.34 74.58,67.54 74.45,67.54 74.36,67.45 v4(74.36,67.13)
  TOP w0.135: v1(256.82,7.8) 257.18,8.16 257.18,9.75 256.98,10.87 256.44,11.64 256.11,11.87 255.9,11.83 255.57,12.06 255.53,12.27 255.2,12.51 254.99,12.47 254.65,12.7 254.62,12.91 249.68,16.37 246.66,18.48 244.75,19.82 v3(220.88,24.03) 217.58,24.61 209.54,26.03 200.98,32.03 197.49,37 182.16,47.74 168.93,50.07 145.97,66.15 137.26,67.69 127.99,66.05 116.93,58.31 100.02,55.32 88.35,56.3 88.35,56.3 84.1,56.8 80.17,58.01 76.25,60.72 74.91,62.62 74.71,63.76 74.71,65.39
  BOTTOM w0.135: U1.AD4 v4(74.36,67.13) ; J5.B38 256.83,5.8 257.17,6.15 257.17,7.45 v1(256.82,7.8)
PE_CPU_TX_DN<6>: length 215.7
  TOP w0.089: 73.71,65.4 73.71,65.42 73.77,65.48 73.77,67.34 73.58,67.54 73.45,67.54 73.36,67.45 v4(73.36,67.13)
  TOP w0.135: 73.71,65.4 73.71,62.42 75.13,60.4 75.62,59.7 79.51,57.02 80.68,56.6 83.6,55.55 99.44,54 117.4,57.17 128.47,64.92 137.15,66.45 145.1,65.04 168.08,48.95 181.46,46.59 189.02,41.3 196.59,36 199.84,31.36 209.02,24.9 223.61,22.33 v3(226.84,21.76) 241.62,19.15 250.48,12.95 250.51,12.74 250.85,12.5 251.06,12.54 251.39,12.31 251.43,12.1 251.76,11.87 251.97,11.9 252.46,11.56 253.01,10.77 253.16,9.92 253.16,8.16 v1(252.81,7.8)
  BOTTOM w0.135: U1.AE4 v4(73.36,67.13) ; v1(252.81,7.8) 253.17,7.44 253.17,6.15 252.83,5.8 J5.B42
PE_CPU_TX_DN<7>: length 213.2
  TOP w0.089: v4(72.36,67.13) 72.36,67.45 72.45,67.54 72.58,67.54 72.77,67.35 72.77,65.51 72.71,65.45 72.71,65.43
  TOP w0.135: 72.71,65.43 72.71,62.84 72.79,62.38 72.88,61.89 75.37,58.34 78.31,56.27 79.73,55.65 81.74,54.76 83.34,54.34 95.26,53.14 99.27,52.74 118.11,56.06 129.18,63.81 136.92,65.18 144.51,63.84 167.37,47.83 181.03,45.42 188.38,40.28 188.38,40.28 195.72,35.14 199.01,30.44 v3(203.32,27.42) 208.55,23.76 238.78,18.43 246.53,13.01 246.57,12.79 246.9,12.56 247.11,12.6 247.44,12.37 247.48,12.15 247.81,11.92 248.03,11.96 248.61,11.55 249.06,10.91 249.18,10.26 249.18,8.16 v1(248.82,7.8)
  BOTTOM w0.135: U1.AF4 v4(72.36,67.13) ; J5.B46 248.83,5.8 249.17,6.15 249.17,7.45 v1(248.82,7.8)
PE_CPU_TX_DN<8>: length 209.8
  TOP w0.089: v4(71.36,67.13) 71.36,67.45 71.45,67.54 71.58,67.54 71.77,67.35 71.77,65.64 71.71,65.58 71.71,65.56
  TOP w0.135: v1(243.82,7.8) 244.17,8.16 244.17,9.65 243.95,10.92 243.42,11.67 242.98,11.98 242.76,11.94 242.43,12.18 242.39,12.39 242.06,12.62 241.85,12.58 241.52,12.82 241.48,13.03 234.41,17.98 208.08,22.62 v3(204.47,25.15) 198.15,29.57 194.86,34.28 180.61,44.25 166.68,46.7 144.12,62.5 136.5,63.85 130,62.7 119,55 98.84,51.44 83.26,53.05 78.7,54.43 77.28,55.42 74.64,57.27 71.88,61.21 71.71,62.19 71.71,65.56
  BOTTOM w0.135: U1.AG4 v4(71.36,67.13) ; v1(243.82,7.8) 244.17,7.44 244.17,6.15 243.83,5.8 J5.B51
PE_CPU_TX_DN<9>: length 207.5
  TOP w0.089: 70.71,65.51 70.71,65.53 70.77,65.59 70.77,67.35 70.58,67.54 70.45,67.54 70.36,67.45 v4(70.36,67.13)
  TOP w0.135: 70.71,65.51 70.71,61.84 70.97,60.39 73.84,56.28 75.07,55.42 75.42,55.17 77.46,53.75 77.48,53.74 78.09,53.31 80.56,52.45 83.54,51.69 84.64,51.5 98.8,50.19 119.77,53.89 130.64,61.5 136.2,62.48 143.72,61.16 166.06,45.51 180.3,43 193.35,33.87 196.63,29.17 207.61,21.49 v3(217.01,19.83) 231.31,17.31 236.78,13.48 236.82,13.27 237.15,13.03 237.37,13.07 237.7,12.84 237.73,12.63 238.07,12.39 238.28,12.43 238.61,12.2 238.65,11.99 238.98,11.76 239.19,11.79 239.64,11.48 240.06,10.87 240.18,10.19 240.18,8.16 v1(239.83,7.8)
  BOTTOM w0.135: v1(239.83,7.8) 240.17,7.46 240.17,6.15 239.83,5.8 J5.B55 ; U1.AH4 v4(70.36,67.13)
PE_CPU_TX_DN<10>: length 204.8
  TOP w0.089: v4(69.36,67.13) 69.36,67.45 69.45,67.54 69.58,67.54 69.77,67.34 69.77,65.51 69.72,65.45 69.72,65.43
  TOP w0.135: 69.72,65.43 69.72,61.55 69.97,60.11 70.02,59.86 73.12,55.42 73.26,55.23 73.3,55.19 77.55,52.21 81.59,50.78 85.23,50.14 85.21,50.14 98.5,48.9 120.27,52.74 131.03,60.27 135.67,61.09 143.66,59.68 165.49,44.39 179.83,41.87 192.49,33 195.87,28.17 207,20.37 v3(208.73,20.07) 228.33,16.61 232.99,13.35 233.03,13.14 233.36,12.91 233.57,12.94 233.9,12.71 233.94,12.5 234.27,12.27 234.48,12.3 235.38,11.67 235.95,10.86 236.17,9.62 236.17,8.16 v1(235.82,7.8)
  BOTTOM w0.135: U1.AJ4 v4(69.36,67.13) ; J5.B59 235.83,5.8 236.17,6.15 236.17,7.44 v1(235.82,7.8)
PE_CPU_TX_DN<11>: length 204.8
  TOP w0.089: 68.71,65.87 68.71,65.89 68.77,65.95 68.77,67.34 68.58,67.54 68.45,67.54 68.36,67.45 v4(68.36,67.13)
  TOP w0.135: 68.71,65.87 68.71,61.47 69.3,58.12 71.19,55.42 71.32,55.25 71.64,54.78 76.85,51.14 80.73,49.66 84.53,48.98 98.55,47.69 121.05,51.66 131.33,58.85 135.35,59.56 143.37,58.15 164.72,43.2 179.27,40.63 191.14,32.32 194.58,27.41 v3(199.87,23.71) 206.21,19.26 223.85,16.15 223.97,15.98 224.37,15.91 224.55,16.03 224.95,15.96 226.11,15.15 226.55,15.22 226.78,15.55 226.96,15.58 227.48,15.22 227.51,15.03 227.28,14.71 227.36,14.27 228.08,13.77 228.52,13.84 228.74,14.17 228.93,14.2 229.45,13.84 229.48,13.65 229.25,13.33 229.33,12.89 229.72,12.61 229.76,12.4 230.09,12.17 230.31,12.21 230.64,11.98 230.67,11.76 231,11.53 231.22,11.57 231.73,11.21 232.09,10.7 232.18,10.17 232.18,8.16 v1(231.83,7.8)
  BOTTOM w0.135: U1.AK4 v4(68.36,67.13) ; J5.B63 231.83,5.8 232.17,6.15 232.17,7.46 v1(231.83,7.8)
PE_CPU_TX_DN<12>: length 202.2
  TOP w0.089: v4(67.36,70.13) 67.68,70.13 67.77,70.04 67.77,63.57 67.71,63.51 67.71,63.49
  TOP w0.135: v1(227.81,7.8) 228.17,8.16 228.17,9.91 227.97,11.04 227.62,11.53 222.42,15.18 205.75,18.12 v3(194.52,25.98) 193.72,26.55 190.28,31.45 178.8,39.49 164.08,42.09 142.74,57.03 135.36,58.33 131.85,57.71 121.57,50.52 98.16,46.39 98.09,46.38 84.26,47.73 80.39,48.42 76.18,50.03 70.88,53.74 69.52,55.68 68.16,57.62 68.04,58.34 67.71,60.18 67.71,63.49
  BOTTOM w0.135: U1.AL7 v4(67.36,70.13) ; J5.B67 227.83,5.8 228.17,6.15 228.17,7.44 v1(227.81,7.8)
PE_CPU_TX_DN<13>: length 201.5
  TOP w0.089: v4(67.36,71.13) 67.68,71.13 67.77,71.04 67.77,70.92 67.58,70.73 66.97,70.73 66.75,70.51 66.75,63.27 66.7,63.22 66.7,63.2
  TOP w0.135: 66.7,63.2 66.7,62.33 66.37,60.48 66.74,58.41 66.74,58.39 66.75,58.37 66.76,58.34 66.77,58.28 66.79,58.16 67.02,57.03 69.88,52.94 75.68,48.88 80.06,47.18 83.09,46.64 97.96,45.14 122.16,49.4 132.29,56.49 133.7,56.74 135.11,56.99 142.25,55.73 163.27,41.01 178.32,38.36 186.65,32.53 189.42,30.59 192.85,25.68 v3(202.39,19) 205.39,16.91 219.2,14.47 223.42,11.51 224.05,10.62 224.18,9.87 224.18,8.16 v1(223.83,7.8)
  BOTTOM w0.135: v1(223.83,7.8) 224.17,7.45 224.17,6.15 223.83,5.8 J5.B71 ; U1.AL8 v4(67.36,71.13)
PE_CPU_TX_DN<14>: length 201.2
  TOP w0.089: 65.72,63.2 65.72,63.22 65.78,63.27 65.78,71.38 66.12,71.72 67.57,71.72 67.77,71.92 67.77,72.04 67.68,72.13 v4(67.36,72.13)
  TOP w0.135: v1(219.81,7.8) 220.17,8.16 220.17,10.29 220.06,10.9 219.71,11.4 216.35,13.75 204.77,15.79 v3(199.47,19.5) 197.06,21.2 192.1,24.67 188.56,29.72 177.85,37.22 162.45,39.94 141.6,54.53 135.25,55.65 132.99,55.25 123.07,48.3 98.14,43.91 84.89,45.1 79.4,46.07 75.26,47.69 68.84,52.03 65.88,56.26 65.41,58.95 65.19,60.17 65.72,63.06 65.72,63.2
  BOTTOM w0.135: U1.AL9 v4(67.36,72.13) ; v1(219.81,7.8) 220.17,7.44 220.17,6.15 219.83,5.8 J5.B75
PE_CPU_TX_DN<15>: length 200.8
  TOP w0.089: v4(67.36,73.13) 67.68,73.13 67.77,73.04 67.77,72.92 67.57,72.72 65.8,72.72 65.17,72.09 65.17,71.58 64.56,70.08 64.56,69.74 64.5,69.68 64.5,69.66
  TOP w0.135: v1(215.83,7.8) 216.18,8.16 216.18,9.7 216.01,10.69 215.63,11.23 212.9,13.14 204.28,14.66 v3(191.74,23.44) 190.97,23.98 187.41,29.06 177.38,36.08 161.91,38.81 141.2,53.31 135.36,54.34 133.55,54.02 123.78,47.18 99.69,42.93 98.36,42.7 98.25,42.69 84.22,43.9 84.19,43.9 79.48,44.73 76.68,45.77 76.12,46.01 75.26,46.36 73.82,46.96 73.8,46.98 67.92,51.09 64.55,55.9 63.16,63.81 63.12,64.09 63.24,66.46 63.24,66.48 63.41,68.17 63.9,69.03 64.26,69.35 64.5,69.55 64.5,69.66
  BOTTOM w0.135: U1.AL10 v4(67.36,73.13) ; v1(215.83,7.8) 216.17,7.45 216.17,5.89 215.83,5.54 J5.B79
PE_CPU_TX_DP<0>: length 235.5
  TOP w0.089: 81.16,65.59 81.16,65.61 81.1,65.67 81.1,67.41 80.79,67.73 80.45,67.73 80.36,67.81 v4(80.36,68.13)
  TOP w0.135: 81.16,65.59 81.16,65.09 81.44,64.33 81.88,63.76 82.19,63.54 83.37,63.33 95.36,62.87 103.21,62.56 103.25,62.56 110.44,63.83 114.73,64.58 125.52,72.14 139.54,74.61 149.72,72.82 157.65,67.27 158.55,66.64 173.62,56.08 184.73,54.12 203.62,40.89 207.5,35.35 212.26,32.02 269.34,21.95 v3(270.81,20.93) 280.29,14.29 280.83,13.51 280.98,12.7 280.98,12.06 v1(281.33,11.71)
  BOTTOM w0.135: v1(281.33,11.71) 280.98,11.35 280.98,10.3 280.48,7.48 280.48,6.15 280.83,5.8 J5.B14 ; U1.V5 v4(80.36,68.13)
PE_CPU_TX_DP<1>: length 233.8
  TOP w0.089: v4(79.36,68.13) 79.36,67.81 79.45,67.73 79.66,67.73 79.96,67.43 79.96,65.53 80.01,65.48 80.01,65.46
  TOP w0.135: v1(275.85,7.8) 275.49,8.16 275.49,10.29 275.29,11.45 274.62,12.39 269.79,15.78 v3(269,16.34) 267.64,17.29 267.6,17.47 268.03,18.08 267.95,18.52 267.23,19.03 266.79,18.95 266.37,18.34 266.18,18.31 265.67,18.67 265.63,18.85 266.06,19.46 265.98,19.9 265.26,20.41 264.82,20.33 264.4,19.72 264.21,19.69 260.57,22.23 212.16,30.77 211.52,30.94 211.01,31.29 211.01,31.29 206.56,34.41 202.53,40.17 184.51,52.78 172.64,54.87 148.66,71.66 139.3,73.31 125.92,70.95 123.34,69.15 123.32,69.13 123.31,69.13 115.24,63.48 115.23,63.47 115.08,63.37 102.7,61.19 85.37,62.07 85.2,62.08 82.72,62.37 81,63.19 80.1,64.18 80.01,64.69 80.01,65.46
  BOTTOM w0.135: J5.B19 275.83,5.8 275.48,6.15 275.48,7.44 v1(275.85,7.8) ; U1.W5 v4(79.36,68.13)
PE_CPU_TX_DP<2>: length 227.3
  TOP w0.089: 79.02,65.52 79.02,65.54 78.96,65.6 78.96,67.42 78.66,67.73 78.45,67.73 78.36,67.81 v4(78.36,68.13)
  TOP w0.135: v1(271.83,7.8) 271.48,8.16 271.48,10.28 271.29,11.34 270.67,12.22 v3(261.29,18.8) 257.3,21.59 211.14,29.72 205.17,33.91 201.43,39.24 183.75,51.63 171.56,53.78 147.98,70.29 138.59,71.94 126.39,69.79 115.53,62.19 102.29,59.85 86.4,60.62 84.97,60.88 84.96,60.88 84.81,60.91 84.8,60.91 82.44,61.33 81.24,61.93 81.21,61.94 80.16,62.47 79.17,63.77 79.02,64.66 79.02,65.52
  BOTTOM w0.135: v1(271.83,7.8) 271.48,7.45 271.48,6.15 271.83,5.8 J5.B23 ; U1.Y5 v4(78.36,68.13)
PE_CPU_TX_DP<3>: length 225
  TOP w0.089: v4(77.36,68.13) 77.36,67.81 77.45,67.73 77.71,67.73 77.95,67.48 77.95,63.74 78.01,63.68 78.01,63.66
  TOP w0.135: 78.01,63.66 78.01,62.81 78.18,62.57 81.48,60.26 83.91,59.83 86.62,59.35 96.25,58.46 100.94,58.39 116,61.05 126.77,68.59 138.13,70.59 147.03,69.02 170.33,52.7 183.27,50.42 199.47,39.08 203.11,33.88 210.67,28.59 254.17,20.91 v3(256.72,19.13) 266.58,12.23 267.3,11.2 267.46,10.25 267.46,8.16 v1(267.82,7.8)
  BOTTOM w0.135: U1.AA5 v4(77.36,68.13) ; v1(267.82,7.8) 267.48,7.46 267.48,6.15 267.83,5.8 J5.B27
PE_CPU_TX_DP<4>: length 220.7
  TOP w0.089: v4(75.36,68.13) 75.36,67.86 75.49,67.73 75.66,67.73 75.95,67.43 75.95,65.52 76.01,65.46 76.01,65.44
  TOP w0.135: v1(261.82,7.8) 261.47,8.16 261.47,9.95 261.27,11.07 260.74,11.83 250.91,18.72 247.95,20.79 v3(211.41,27.23) 210.2,27.44 202.25,33.02 198.62,38.2 182.83,49.26 169.48,51.61 146.52,67.69 137.56,69.27 127.24,67.45 116.47,59.91 116.46,59.91 116.46,59.9 100.54,57.1 100.53,57.1 99.73,57.11 95.64,57.27 91.08,57.61 85.04,58.25 82.89,58.81 80.85,59.34 76.98,62.05 76.65,62.52 76.32,63 76.01,64.72 76.01,65.44
  BOTTOM w0.135: J5.B33 261.83,5.8 261.48,6.15 261.48,7.46 v1(261.82,7.8) ; U1.AC5 v4(75.36,68.13)
PE_CPU_TX_DP<5>: length 218.2
  TOP w0.089: v4(74.36,68.13) 74.36,67.81 74.45,67.73 74.66,67.73 74.96,67.42 74.96,65.47 75.02,65.42 75.02,65.39
  TOP w0.135: v1(257.84,7.8) 257.48,8.16 257.48,9.78 257.27,10.99 256.66,11.85 244.87,20.11 v3(217.63,24.91) 209.65,26.32 201.2,32.25 197.71,37.22 182.28,48.03 169.05,50.36 146.09,66.44 137.26,68 127.87,66.34 116.81,58.59 100.01,55.63 88.38,56.6 84.16,57.1 80.31,58.29 76.47,60.94 75.2,62.74 75.02,63.79 75.02,65.39
  BOTTOM w0.135: U1.AD5 v4(74.36,68.13) ; J5.B37 257.83,5.8 257.48,6.15 257.48,7.44 v1(257.84,7.8)
PE_CPU_TX_DP<6>: length 215.7
  TOP w0.089: v4(73.36,68.13) 73.36,67.81 73.45,67.73 73.66,67.73 73.96,67.42 73.96,65.48 74.02,65.42 74.02,65.4
  TOP w0.135: 74.02,65.4 74.02,62.52 74.92,61.23 75.84,59.92 79.66,57.29 80.92,56.84 80.92,56.84 83.67,55.85 99.42,54.31 117.28,57.46 128.35,65.2 137.15,66.76 145.22,65.33 168.2,49.24 181.58,46.88 196.81,36.22 200.06,31.58 209.13,25.19 v3(223.66,22.63) 241.74,19.44 252.68,11.78 253.3,10.89 253.47,9.95 253.47,8.16 v1(253.82,7.8)
  BOTTOM w0.135: U1.AE5 v4(73.36,68.13) ; v1(253.82,7.8) 253.48,7.46 253.48,6.15 253.83,5.8 J5.B41
PE_CPU_TX_DP<7>: length 213.3
  TOP w0.089: 73.02,65.43 73.02,65.45 72.96,65.51 72.96,67.42 72.66,67.73 72.45,67.73 72.36,67.81 v4(72.36,68.13)
  TOP w0.135: v1(249.84,7.8) 249.48,8.16 249.48,10.29 249.35,11.02 248.83,11.77 238.9,18.72 208.67,24.05 v3(201.31,29.21) 199.23,30.66 195.94,35.36 181.15,45.71 167.49,48.12 144.63,64.13 136.92,65.49 129.06,64.1 117.99,56.35 99.26,53.04 91.32,53.84 83.39,54.64 81.84,55.05 79.96,55.88 78.46,56.54 75.59,58.55 73.17,62.01 73.02,62.87 73.02,65.43
  BOTTOM w0.135: J5.B45 249.83,5.8 249.48,6.15 249.48,7.44 v1(249.84,7.8) ; U1.AF5 v4(72.36,68.13)
PE_CPU_TX_DP<8>: length 209.9
  TOP w0.089: 72.02,65.56 72.02,65.58 71.96,65.64 71.96,67.43 71.66,67.73 71.45,67.73 71.36,67.81 v4(71.36,68.13)
  TOP w0.135: v1(244.83,7.8) 244.48,8.16 244.48,9.68 244.24,11.04 243.64,11.89 234.52,18.27 208.2,22.91 v3(207.06,23.71) 204.65,25.4 198.37,29.79 195.08,34.5 180.73,44.54 166.8,46.99 144.24,62.79 136.5,64.16 129.88,62.99 118.88,55.28 98.83,51.75 83.32,53.35 78.83,54.71 77.81,55.42 76.14,56.6 76.13,56.6 74.86,57.49 72.17,61.33 72.02,62.22 72.02,65.56
  BOTTOM w0.135: U1.AG5 v4(71.36,68.13) ; J5.B50 244.83,5.8 244.48,6.15 244.48,7.45 v1(244.83,7.8)
PE_CPU_TX_DP<9>: length 207.5
  TOP w0.089: 71.02,65.51 71.02,65.53 70.96,65.59 70.96,67.43 70.66,67.73 70.45,67.73 70.36,67.81 v4(70.36,68.13)
  TOP w0.135: v1(240.84,7.8) 240.49,8.16 240.49,10.22 240.35,10.99 239.86,11.7 231.43,17.6 v3(220.1,19.59) 217.06,20.13 207.73,21.78 196.85,29.39 193.56,34.09 180.42,43.29 166.18,45.8 155.01,53.62 143.84,61.45 136.2,62.79 130.52,61.79 119.65,54.18 109.21,52.34 98.78,50.5 84.68,51.8 83.6,51.99 80.64,52.74 78.23,53.58 77.64,54 77.63,54 74.06,56.5 71.26,60.5 71.07,61.54 71.02,61.87 71.02,65.51
  BOTTOM w0.135: v1(240.84,7.8) 240.48,7.44 240.48,6.15 240.83,5.8 J5.B54 ; U1.AH5 v4(70.36,68.13)
PE_CPU_TX_DP<10>: length 204.9
  TOP w0.089: 70.02,65.43 70.02,65.45 69.97,65.51 69.97,67.42 69.66,67.73 69.45,67.73 69.36,67.81 v4(69.36,68.13)
  TOP w0.135: v1(236.83,7.8) 236.48,8.16 236.48,9.65 236.24,10.98 235.6,11.89 228.45,16.9 v3(212.14,19.78) 208.79,20.37 207.12,20.66 196.09,28.39 192.7,33.22 179.95,42.15 165.61,44.68 143.78,59.97 135.67,61.4 130.91,60.56 120.15,53.03 98.49,49.21 85.28,50.44 85.28,50.44 81.66,51.07 77.69,52.48 73.5,55.42 73.49,55.42 70.3,59.98 70.25,60.28 70.02,61.58 70.02,65.43
  BOTTOM w0.135: v1(236.83,7.8) 236.48,7.45 236.48,6.15 236.83,5.8 J5.B58 ; U1.AJ5 v4(69.36,68.13)
PE_CPU_TX_DP<11>: length 204.7
  TOP w0.089: 69.02,65.87 68.96,65.92 68.96,67.42 68.66,67.73 68.45,67.73 68.36,67.81 v4(68.36,68.13)
  TOP w0.135: 69.02,65.87 69.02,61.5 69.59,58.24 71.57,55.42 71.86,55 76.99,51.41 80.81,49.95 84.57,49.28 98.54,48 120.94,51.95 131.21,59.14 135.35,59.87 143.49,58.43 164.84,43.49 179.39,40.92 191.36,32.54 194.8,27.63 200.04,23.96 v3(202.64,22.13) 206.33,19.55 223.9,16.45 223.9,16.46 225.07,16.25 226.18,15.47 226.37,15.5 226.6,15.83 227.03,15.9 227.76,15.4 227.83,14.96 227.61,14.64 227.64,14.45 228.15,14.09 228.34,14.12 228.57,14.45 229,14.52 229.73,14.02 229.8,13.58 229.57,13.26 229.61,13.07 231.95,11.43 232.38,10.82 232.49,10.2 232.49,8.16 v1(232.84,7.8)
  BOTTOM w0.135: J5.B62 232.83,5.8 232.48,6.15 232.48,7.44 v1(232.84,7.8) ; U1.AK5 v4(68.36,68.13)
PE_CPU_TX_DP<12>: length 202.2
  TOP w0.089: v4(68.36,70.13) 68.05,70.13 67.96,70.04 67.96,63.55 68.02,63.49
  TOP w0.135: v1(228.83,7.8) 228.47,8.16 228.47,9.94 228.26,11.16 227.84,11.75 222.54,15.47 205.87,18.41 v3(197.07,24.57) 193.94,26.77 190.5,31.67 178.92,39.78 164.19,42.38 142.86,57.32 135.36,58.64 131.73,58 121.45,50.81 109.8,48.75 98.14,46.7 98.08,46.69 84.3,48.04 80.47,48.72 76.32,50.3 71.1,53.96 68.45,57.74 68.39,58.11 68.02,60.2 68.02,63.49
  BOTTOM w0.135: J5.B66 228.83,5.8 228.48,6.15 228.48,7.45 v1(228.83,7.8) ; U1.AK7 v4(68.36,70.13)
PE_CPU_TX_DP<13>: length 201.5
  TOP w0.089: v4(68.36,71.13) 68.05,71.13 67.96,71.04 67.96,70.84 67.66,70.54 67.05,70.54 66.94,70.43 66.94,63.27 67,63.22 67,63.2
  TOP w0.135: v1(224.84,7.8) 224.49,8.16 224.49,9.9 224.34,10.74 223.64,11.73 219.32,14.76 205.51,17.19 v3(204.94,17.59) 193.07,25.9 189.64,30.81 178.44,38.64 163.39,41.3 142.37,56.02 135.11,57.3 132.17,56.78 122.04,49.69 97.95,45.44 83.13,46.95 80.14,47.47 75.82,49.15 70.1,53.16 67.31,57.15 67.07,58.31 67.05,58.44 66.68,60.49 67,62.3 67,63.2
  BOTTOM w0.135: U1.AK8 v4(68.36,71.13) ; J5.B70 224.83,5.8 224.48,6.15 224.48,7.44 v1(224.84,7.8)
PE_CPU_TX_DP<14>: length 201.2
  TOP w0.089: 66.02,63.2 66.02,63.22 65.97,63.27 65.97,71.3 66.2,71.53 67.65,71.53 67.96,71.84 67.96,72.04 68.05,72.13 v4(68.36,72.13)
  TOP w0.135: 66.02,63.2 66.02,63.03 65.5,60.17 65.6,59.61 65.78,58.58 66.17,56.38 69.06,52.25 75.4,47.96 79.48,46.37 84.93,45.41 91.53,44.81 98.13,44.21 122.95,48.59 132.87,55.54 135.25,55.96 141.72,54.82 162.57,40.22 177.97,37.51 188.78,29.94 192.31,24.89 v3(197.23,21.45) 204.89,16.08 216.47,14.04 219.93,11.62 220.35,11.02 220.47,10.31 220.47,8.16 v1(220.83,7.8)
  BOTTOM w0.135: v1(220.83,7.8) 220.48,7.45 220.48,6.15 220.83,5.8 J5.B74 ; U1.AK9 v4(68.36,72.13)
PE_CPU_TX_DP<15>: length 200.8
  TOP w0.089: v4(68.36,73.13) 68.05,73.13 67.96,73.04 67.96,72.84 67.65,72.53 65.88,72.53 65.36,72.01 65.36,71.54 64.75,70.04 64.75,69.74 64.8,69.68 64.8,69.66
  TOP w0.135: 64.8,69.66 64.8,69.55 64.69,69.31 64.46,69.12 64.14,68.83 63.7,68.07 63.55,66.45 63.42,64.07 64.84,56.02 68.14,51.31 73.97,47.23 73.97,47.23 76.24,46.29 76.79,46.06 79.56,45.02 84.24,44.2 98.28,42.99 99.64,43.23 123.66,47.47 133.43,54.31 135.36,54.65 141.31,53.6 162.03,39.1 177.5,36.37 187.63,29.28 191.19,24.2 191.91,23.69 v3(194.34,21.99) 204.4,14.95 213.02,13.43 215.85,11.45 216.3,10.81 216.49,9.73 216.49,8.16 v1(216.84,7.8)
  BOTTOM w0.135: U1.AK10 v4(68.36,73.13) ; v1(216.84,7.8) 216.48,7.44 216.48,5.9 216.83,5.55 J5.B78
PE_SLOT1_PRES_N: length 270.3
  IN2 w0.112: J1.A1 296.74,34.34 296.74,32.4 295.34,31 282.83,31 281.32,29.48 198.18,29.48 185.09,42.58 161.88,42.58 142.54,61.92 127.9,61.92 118.13,52.15 70.92,52.15 v1(68.46,49.69)
  BOTTOM w0.114: v1(68.46,49.69) 68.29,49.51 67.55,49.51 66.87,50.19 66.87,50.53 65.91,51.5 64.68,51.5 63.86,50.68 63.86,49.09 63.21,48.44 58.72,48.44 57.71,49.45 57.71,51.89 57.43,52.17 56.46,52.17 R271.2
PE_SLOT1_RX_DN<0>: length 203.1
  IN3 w0.089: 99.02,71.2 99,71.21 99,71.28 98.73,71.55 95.13,71.55 94.96,71.38 94.96,71.2 95.03,71.13 v4(95.36,71.13)
  IN3 w0.135: 99.02,71.2 99.19,71.02 99.88,70.04 100.2,68.23 100.43,67.9 100.39,67.69 100.62,67.36 100.84,67.32 101.07,66.99 101.03,66.77 101.26,66.44 101.48,66.41 101.84,65.88 102.79,65.22 103.84,65.22 104.96,65.42 106.27,65.19 107.6,65.42 109.56,65.08 111.89,65.49 113.49,65.2 115.11,65.49 115.88,65.36 115.99,65.2 116.38,65.13 116.54,65.24 116.94,65.17 117.05,65.01 117.45,64.94 117.61,65.05 119.07,64.79 127.02,66.19 171.51,58.35 186.89,61.06 187.43,60.97 200.56,58.65 210.28,51.85 213.88,51.22 215.55,51.51 235.62,47.97 237.74,48.35 241.26,47.73 250.35,49.33 262.6,47.17 267.19,43.95 269.83,43.48 269.94,43.33 270.34,43.25 270.5,43.37 270.9,43.3 271.01,43.14 271.4,43.07 271.56,43.18 271.96,43.11 272.07,42.95 272.47,42.88 272.63,42.99 273.03,42.92 273.14,42.76 273.54,42.69 273.69,42.8 274.09,42.73 274.2,42.57 274.6,42.5 274.76,42.61 275.24,42.53 277.22,41.15 277.71,40.44 277.71,38.98 arc(277.83,38.68) 278.13,38.56 278.4,38.56 arc(278.59,38.48) 278.67,38.29 278.67,34.64 278.55,34.53 278.39,34.44 278.2,34.5 J1.A17
  BOTTOM w0.135: U1.D8 v4(95.36,71.13)
PE_SLOT1_RX_DN<1>: length 202.6
  IN3 w0.089: v4(95.36,70.13) 95.05,70.13 94.94,70.24 94.94,70.36 95.12,70.54 98.64,70.54 99.13,70.05 99.13,69.57 99.08,69.52 99.08,69.5
  IN3 w0.135: J1.A22 273.2,34.01 273.14,34.19 272.93,34.29 272.69,34.54 272.69,38.47 arc(272.82,38.79) 273.14,38.92 273.56,38.92 arc(273.65,38.96) 273.69,39.06 273.69,40.57 273.24,41.22 272.09,42.02 271.69,42.09 271.53,41.98 271.14,42.05 271.03,42.21 270.63,42.28 270.47,42.17 270.07,42.24 269.96,42.4 269.56,42.47 269.4,42.36 269.01,42.43 268.89,42.58 264.92,43.29 264.84,43.4 264.77,43.5 264.67,43.64 264.79,44.33 264.69,44.49 264.32,44.55 264.16,44.44 264.04,43.75 263.69,43.5 260.99,43.98 260.18,44.55 259.82,45.07 259.58,46.42 259.25,46.89 258.85,47.17 250.35,48.67 241.26,47.07 237.74,47.69 235.55,47.3 215.56,50.83 215.52,50.8 215.44,50.81 213.88,50.54 210.06,51.21 205.16,54.64 200.31,58.04 187.23,60.34 185.17,59.98 171.77,57.62 127.06,65.5 126.86,65.5 109.27,62.4 101.73,63.73 101.28,64.04 99.56,66.5 99.08,67.23 99.08,69.5
  BOTTOM w0.135: U1.D7 v4(95.36,70.13)
PE_SLOT1_RX_DN<2>: length 197.9
  IN3 w0.089: 96.73,64.72 96.73,64.74 96.78,64.79 96.78,69.34 96.6,69.52 95.13,69.52 94.96,69.34 94.96,69.22 95.05,69.13 v4(95.36,69.13)
  IN3 w0.135: 96.73,64.72 96.73,64.47 96.78,64.17 97.1,63.71 98.61,62.65 98.94,62.42 106.08,61.16 126.07,64.68 126.89,64.83 126.9,64.83 126.96,64.84 171.99,56.91 187.48,59.64 188.02,59.54 200.06,57.42 209.84,50.57 213.83,49.87 215.44,50.15 235.5,46.61 237.62,46.99 241.09,46.37 250.23,47.99 254.81,47.18 255.27,46.86 255.56,46.44 255.83,44.91 256.16,44.44 256.98,43.86 261.19,43.12 261.3,42.96 261.7,42.89 261.86,43 262.26,42.93 262.37,42.77 262.77,42.7 262.93,42.82 263.32,42.75 263.44,42.59 263.83,42.52 263.99,42.63 264.39,42.56 267.23,42.06 267.28,42.05 268.15,41.89 269.21,41.15 269.69,40.67 269.69,39.03 arc(269.65,38.93) 269.56,38.9 269.12,38.9 arc(268.82,38.77) 268.7,38.47 268.7,34.52 268.93,34.29 269.14,34.19 269.2,34.01 J1.A26
  BOTTOM w0.135: U1.D6 v4(95.36,69.13)
PE_SLOT1_RX_DN<3>: length 195.6
  IN3 w0.089: 95.71,64.7 95.71,64.72 95.76,64.77 95.76,68.4 95.63,68.53 95.14,68.53 94.96,68.34 94.96,68.22 95.05,68.13 v4(95.36,68.13)
  IN3 w0.135: 95.71,64.7 95.71,64.54 95.82,63.91 96.38,63.11 96.73,62.87 97.99,61.98 98.09,61.89 105.83,60.54 105.96,60.52 105.99,60.5 106.08,60.5 106.19,60.52 126.13,64.03 126.69,64.13 126.69,64.13 126.77,64.15 126.81,64.15 126.96,64.18 170.79,56.45 170.8,56.45 172.26,56.19 187.15,58.82 187.72,58.92 188.79,58.73 188.79,58.73 199.79,56.79 209.54,49.96 213.88,49.2 215.49,49.48 235.56,45.94 237.67,46.32 241.17,45.7 243.81,46.16 244.01,46.02 244.09,45.56 244.44,45.32 245.04,45.42 245.11,45.52 245.29,45.77 245.21,46.21 245.36,46.41 245.61,46.46 245.85,46.29 246.05,45.18 246.42,44.92 246.97,45.02 247.11,45.21 247.11,45.21 247.24,45.4 247.04,46.53 247.23,46.8 250.23,47.33 250.79,47.23 251.3,46.87 251.52,46.55 251.83,44.82 252.23,44.25 253.03,43.69 258.46,42.73 258.47,42.73 258.49,42.73 258.6,42.57 259,42.5 259.16,42.61 259.55,42.54 259.66,42.38 260.06,42.31 260.22,42.42 260.62,42.35 260.74,42.18 261.14,42.11 261.32,42.23 262.15,42.08 263.39,41.21 263.7,40.77 263.7,39.03 arc(263.83,38.73) 264.13,38.61 264.47,38.61 arc(264.64,38.54) 264.71,38.36 264.71,34.51 264.93,34.29 265.14,34.19 265.2,34.01 J1.A30
  BOTTOM w0.135: U1.D5 v4(95.36,68.13)
PE_SLOT1_RX_DN<4>: length 186.2
  IN3 w0.089: 93.7,63.55 93.7,63.58 93.75,63.62 93.75,67.36 93.62,67.5 93.41,67.5 93.36,67.45 v4(93.36,67.13)
  IN3 w0.135: J1.A36 259.2,34.01 259.14,34.19 258.93,34.29 258.69,34.53 258.69,38.47 arc(258.82,38.77) 259.12,38.9 259.55,38.9 arc(259.64,38.93) 259.68,39.03 259.68,40.7 259.25,41.32 258.27,42.01 237.67,45.64 236.69,45.46 235.61,45.27 215.49,48.82 213.78,48.52 209.31,49.31 199.52,56.16 188.06,58.18 172.64,55.46 126.96,63.52 105.97,59.82 94.62,61.82 93.78,62.41 93.7,62.82 93.7,63.55
  BOTTOM w0.135: U1.F4 v4(93.36,67.13)
PE_SLOT1_RX_DN<5>: length 184.3
  IN3 w0.089: v4(92.36,67.13) 92.36,67.45 92.42,67.51 92.61,67.51 92.75,67.36 92.75,62.94 92.7,62.89 92.7,62.87
  IN3 w0.135: 92.7,62.87 92.7,62.41 92.94,62.07 94.11,61.25 105.97,59.16 126.75,62.82 126.88,62.82 172.92,54.69 186.86,57.15 188.34,57.41 199.25,55.49 208.93,48.71 213.89,47.84 215.54,48.13 235.7,44.58 237.73,44.93 251.46,42.51 251.57,42.36 251.52,42.05 251.77,41.69 252.26,41.6 252.62,41.86 252.68,42.16 252.85,42.28 253.36,42.19 253.88,42.1 255.34,41.07 255.66,40.62 255.66,39.03 arc(255.62,38.93) 255.52,38.9 255.13,38.9 arc(254.83,38.77) 254.71,38.47 254.71,34.52 254.93,34.29 255.14,34.19 255.2,34.01 J1.A40
  BOTTOM w0.135: U1.G4 v4(92.36,67.13)
