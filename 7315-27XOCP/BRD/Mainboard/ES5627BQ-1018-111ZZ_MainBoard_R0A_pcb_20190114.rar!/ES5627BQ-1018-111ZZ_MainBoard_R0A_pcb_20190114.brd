# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
QSFP_2X1X38DP_19D5W73D3L
  round 2.489 hole 2.489 unplated: (0,0) (19,0)
  round 0.762 hole 0.371: 1B1(2.5,1.23) 1B2(3.3,1.93) 1B3(4.1,0.53) 1B4(4.9,1.23) 1B5(5.7,1.93) 1B6(6.5,0.53) 1B7(7.3,1.23) 1B8(8.1,1.93) 1B9(8.9,0.53) 1B10(9.7,1.23) 1B11(10.5,1.93) 1B12(11.3,0.53) 1B13(12.1,1.23) 1B14(12.9,1.93) 1B15(13.7,0.53) 1B16(14.5,1.23) 1B17(15.3,1.93) 1B18(16.1,0.53) 1B19(16.9,1.23) 1B20(16.9,5.23) 1B21(16.1,4.53) 1B22(15.3,5.93) 1B23(14.5,5.23) 1B24(13.7,4.53) 1B25(12.9,5.93) 1B26(12.1,5.23) 1B27(11.3,4.53) 1B28(10.5,5.93) 1B29(9.7,5.23) 1B30(8.9,4.53) 1B31(8.1,5.93) 1B32(7.3,5.23) 1B33(6.5,4.53) 1B34(5.7,5.93) 1B35(4.9,5.23) 1B36(4.1,4.53) 1B37(3.3,5.93) 1B38(2.5,5.23) 1T1(2.5,9.23) 1T2(3.3,9.93) 1T3(4.1,8.53) 1T4(4.9,9.23) 1T5(5.7,9.93) 1T6(6.5,8.53) 1T7(7.3,9.23) 1T8(8.1,9.93) 1T9(8.9,8.53) 1T10(9.7,9.23) 1T11(10.5,9.93) 1T12(11.3,8.53) 1T13(12.1,9.23) 1T14(12.9,9.93) 1T15(13.7,8.53) 1T16(14.5,9.23) 1T17(15.3,9.93) 1T18(16.1,8.53) 1T19(16.9,9.23) 1T20(16.9,13.23) 1T21(16.1,12.53) 1T22(15.3,13.93) 1T23(14.5,13.23) 1T24(13.7,12.53) 1T25(12.9,13.93) 1T26(12.1,13.23) 1T27(11.3,12.53) 1T28(10.5,13.93) 1T29(9.7,13.23) 1T30(8.9,12.53) 1T31(8.1,13.93) 1T32(7.3,13.23) 1T33(6.5,12.53) 1T34(5.7,13.93) 1T35(4.9,13.23) 1T36(4.1,12.53) 1T37(3.3,13.93) 1T38(2.5,13.23)
  custom 0.381x0.381 hole 1.049: G1(0,-44.3) G2(0,-35.3) G3(0,-26.3) G4(0,-17.3) G5(0,-6.6) G19(19,-6.6) G20(19,-17.3) G21(19,-26.3) G22(19,-35.3) G23(19,-44.3)
  round 0.965 hole 0.559: G6(0,4.85) G7(0,8.85) G8(0,12.85) G9(4.7,16.65) G10(9.5,16.65) G11(14.3,16.65) G12(19,12.85) G13(19,8.85) G14(19,4.85)
  round 1.321 hole 0.8: G15(4.38,-1.45) G16(7.88,-1.45) G17(11.38,-1.45) G18(14.88,-1.45)
RC0402
  rect 0.559x0.539 smd: 1(0,0.454) 2(0,-0.454)
RC0402_22X22_8OCT
  custom 0.14x0.14 smd: 1(0,0.5) 2(0,-0.5)
RC0603
  rect 0.813x0.813 smd: 1(0,0.762) 2(0,-0.762)
RC0805
  rect 1.27x1.016 smd: 1(0,1.016) 2(0,-1.016)
RC1210
  rect 2.54x1.651 smd: 1(0,1.524) 2(0,-1.524)
RJ45_2X3X8DP_45D21W28D45L
  round 3.251 hole 3.251 unplated: (0,0) (39.37,0)
  rect 1.27x1.27 hole 0.94: A1(1.27,6.35) B1(10.16,15.49) C1(15.24,6.35) D1(24.13,15.49) E1(29.21,6.35) F1(38.1,15.49)
  round 1.27 hole 0.94: A2(2.54,8.89) A3(3.81,6.35) A4(5.08,8.89) A5(6.35,6.35) A6(7.62,8.89) A7(8.89,6.35) A8(10.16,8.89) B2(8.89,12.95) B3(7.62,15.49) B4(6.35,12.95) B5(5.08,15.49) B6(3.81,12.95) B7(2.54,15.49) B8(1.27,12.95) C2(16.51,8.89) C3(17.78,6.35) C4(19.05,8.89) C5(20.32,6.35) C6(21.59,8.89) C7(22.86,6.35) C8(24.13,8.89) D2(22.86,12.95) D3(21.59,15.49) D4(20.32,12.95) D5(19.05,15.49) D6(17.78,12.95) D7(16.51,15.49) D8(15.24,12.95) E2(30.48,8.89) E3(31.75,6.35) E4(33.02,8.89) E5(34.29,6.35) E6(35.56,8.89) E7(36.83,6.35) E8(38.1,8.89) F2(36.83,12.95) F3(35.56,15.49) F4(34.29,12.95) F5(33.02,15.49) F6(31.75,12.95) F7(30.48,15.49) F8(29.21,12.95)
  round 2.032 hole 1.6: G1(-2.79,-4.57) G2(-2.03,9.14) G3(-2.79,15.49) G4(12.7,17.27) G5(26.67,17.27) G6(42.16,11.43) G7(41.4,5.84) G8(42.16,-4.57)
SC70_D65X1D9_6SP_1D25W2LD95H_1
  rect 0.381x0.559 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
SO8_1D27X5D2_8SP_3D9W4D9L
  rect 2.286x0.635 smd: 1(-2.6,1.905) 2(-2.6,0.635) 3(-2.6,-0.635) 4(-2.6,-1.905) 5(2.6,-1.905) 6(2.6,-0.635) 7(2.6,0.635) 8(2.6,1.905)
SO8_1D27X5D3_8SP_3D9W4D9L
  rect 1.524x0.635 smd: 1(-2.65,1.905) 2(-2.65,0.635) 3(-2.65,-0.635) 4(-2.65,-1.905) 5(2.65,-1.905) 6(2.65,-0.635) 7(2.65,0.635) 8(2.65,1.905)
SOCKET_BATT_14D65_2SP_AC_MEGA_2
  rect 3.683x3.175 smd: A(0,-14.9) C(0,14.904)
SOD123_3D28_2SP_AC
  rect 1.27x0.889 smd: A(0,-1.64) C(0,1.64)
SOD323_2D3_2SP_1D85W1D25L
  rect 0.559x0.813 smd: A(-1.15,0) C(1.15,0)
SOIC_1D27X5D3_16SP_10L
  rect 1.651x0.508 smd: 1(-2.718,4.445) 2(-2.718,3.175) 3(-2.718,1.905) 4(-2.718,0.635) 5(-2.718,-0.635) 6(-2.718,-1.905) 7(-2.718,-3.175) 8(-2.718,-4.445) 9(2.718,-4.445) 10(2.718,-3.175) 11(2.718,-1.905) 12(2.718,-0.635) 13(2.718,0.635) 14(2.718,1.905) 15(2.718,3.175) 16(2.718,4.445)
SOIC_1D27X5D16_8SP_5D1L
  rect 1.778x0.508 smd: 1(-2.718,1.905) 2(-2.718,0.635) 3(-2.718,-0.635) 4(-2.718,-1.905) 5(2.718,-1.905) 6(2.718,-0.635) 7(2.718,0.635) 8(2.718,1.905)
SOIC_1D27X5D165_8SP_3D9W4D9L
  rect 1.651x0.508 smd: 1(-2.582,1.905) 2(-2.582,0.635) 3(-2.582,-0.635) 4(-2.582,-1.905) 5(2.582,-1.905) 6(2.582,-0.635) 7(2.582,0.635) 8(2.582,1.905)
SOP_1D27X5D24_8SP_5L
  rect 1.778x0.508 smd: 1(-2.794,1.905) 2(-2.794,0.635) 3(-2.794,-0.635) 4(-2.794,-1.905) 5(2.794,-1.905) 6(2.794,-0.635) 7(2.794,0.635) 8(2.794,1.905)
SOP_1D27X5D28_8SP_3D9W4D9L_G1
  rect 1.524x0.508 smd: 1(-2.64,1.905) 2(-2.64,0.635) 3(-2.64,-0.635) 4(-2.64,-1.905) 5(2.64,-1.905) 6(2.64,-0.635) 7(2.64,0.635) 8(2.64,1.905)
  rect 2.286x2.794 smd: G1(0,0)
SOP_1D27X5D165_8SP_3D9W_G95X130
  rect 1.651x0.508 smd: 1(-2.582,1.905) 2(-2.582,0.635) 3(-2.582,-0.635) 4(-2.582,-1.905) 5(2.582,-1.905) 6(2.582,-0.635) 7(2.582,0.635) 8(2.582,1.905)
  rect 2.413x3.302 smd: G1(0,0)
SOP_1D27X9D5_16SP_10D31W7D49L
  rect 1.651x0.635 smd: 1(-4.75,4.445) 2(-4.75,3.175) 3(-4.75,1.905) 4(-4.75,0.635) 5(-4.75,-0.635) 6(-4.75,-1.905) 7(-4.75,-3.175) 8(-4.75,-4.445) 9(4.75,-4.445) 10(4.75,-3.175) 11(4.75,-1.905) 12(4.75,-0.635) 13(4.75,0.635) 14(4.75,1.905) 15(4.75,3.175) 16(4.75,4.445)
SOT23_3SP_A1_A2_C
  rect 1.016x1.016 smd: A1(-1.016,-1.016) A2(1.016,-1.016) C(0,1.016)
SOT23_D95X2D2_3SP_2D92W1D3L_GSD
  rect 1.016x1.397 smd: D(0,1.1) G(-0.95,-1.1) S(0.95,-1.1)
SOT23_D95X2D6_5SP_2D9W1D6L
  rect 0.635x1.016 smd: 1(-0.95,-1.3) 2(0,-1.3) 3(0.95,-1.3) 4(0.95,1.3) 5(-0.95,1.3)
SOT23_D95X2D35_5SP_1D6W2D9L
  rect 0.635x1.27 smd: 1(-0.95,-1.175) 2(0,-1.175) 3(0.95,-1.175) 4(0.95,1.175) 5(-0.95,1.175)
SOT23_D95X2D_3SP_1D3W2D9L_C1C2A
  rect 0.813x0.889 smd: A(0,1) C1(-0.95,-1) C2(0.95,-1)
SSOP20
  rect 0.305x1.778 smd: 1(-2.972,-3.81) 2(-2.311,-3.81) 3(-1.651,-3.81) 4(-0.991,-3.81) 5(-0.33,-3.81) 6(0.33,-3.81) 7(0.991,-3.81) 8(1.651,-3.81) 9(2.311,-3.81) 10(2.972,-3.81) 11(2.972,3.81) 12(2.311,3.81) 13(1.651,3.81) 14(0.991,3.81) 15(0.33,3.81) 16(-0.33,3.81) 17(-0.991,3.81) 18(-1.651,3.81) 19(-2.311,3.81) 20(-2.972,3.81)
SW_4D5X8D3_4SP_6WL4D3H
  rect 1.219x1.118 smd: 1(-4.15,2.25) 2(4.15,2.25) 3(-4.15,-2.25) 4(4.15,-2.25)
SW_5DX7D5X4D1_4SP_7W
  rect 1.524x2.032 smd: 1(2.5,-4.1) 2(-2.5,-4.1)
  rect 2.54x2.54 smd: 3(3.75,0) 4(-3.75,0)
SW_PUSH_3D75X1D5_4SP_3D5W3D6L
  round 0.813 hole 0.813 unplated: (0,0.9) (0,-0.9)
  rect 1.27x1.016 smd: 1(-1.875,0.75) 2(1.875,0.75) 3(-1.875,-0.75) 4(1.875,-0.75)
TP_30C0D0C_OSP
  round 0.762 smd: 1(0,0)
TQFP_D5X13D4_80SP_12WL
  rect 1.524x0.254 smd: 1(-6.7,4.75) 2(-6.7,4.25) 3(-6.7,3.75) 4(-6.7,3.25) 5(-6.7,2.75) 6(-6.7,2.25) 7(-6.7,1.75) 8(-6.7,1.25) 9(-6.7,0.75) 10(-6.7,0.25) 11(-6.7,-0.25) 12(-6.7,-0.75) 13(-6.7,-1.25) 14(-6.7,-1.75) 15(-6.7,-2.25) 16(-6.7,-2.75) 17(-6.7,-3.25) 18(-6.7,-3.75) 19(-6.7,-4.25) 20(-6.7,-4.75) 41(6.7,-4.75) 42(6.7,-4.25) 43(6.7,-3.75) 44(6.7,-3.25) 45(6.7,-2.75) 46(6.7,-2.25) 47(6.7,-1.75) 48(6.7,-1.25) 49(6.7,-0.75) 50(6.7,-0.25) 51(6.7,0.25) 52(6.7,0.75) 53(6.7,1.25) 54(6.7,1.75) 55(6.7,2.25) 56(6.7,2.75) 57(6.7,3.25) 58(6.7,3.75) 59(6.7,4.25) 60(6.7,4.75)
  rect 0.254x1.524 smd: 21(-4.75,-6.7) 22(-4.25,-6.7) 23(-3.75,-6.7) 24(-3.25,-6.7) 25(-2.75,-6.7) 26(-2.25,-6.7) 27(-1.75,-6.7) 28(-1.25,-6.7) 29(-0.75,-6.7) 30(-0.25,-6.7) 31(0.25,-6.7) 32(0.75,-6.7) 33(1.25,-6.7) 34(1.75,-6.7) 35(2.25,-6.7) 36(2.75,-6.7) 37(3.25,-6.7) 38(3.75,-6.7) 39(4.25,-6.7) 40(4.75,-6.7) 61(4.75,6.7) 62(4.25,6.7) 63(3.75,6.7) 64(3.25,6.7) 65(2.75,6.7) 66(2.25,6.7) 67(1.75,6.7) 68(1.25,6.7) 69(0.75,6.7) 70(0.25,6.7) 71(-0.25,6.7) 72(-0.75,6.7) 73(-1.25,6.7) 74(-1.75,6.7) 75(-2.25,6.7) 76(-2.75,6.7) 77(-3.25,6.7) 78(-3.75,6.7) 79(-4.25,6.7) 80(-4.75,6.7)
TSSOP_D65X5D8_28SP_4D4W9D7L1D2H
  rect 1.549x0.406 smd: 1(-2.9,4.225) 2(-2.9,3.575) 3(-2.9,2.925) 4(-2.9,2.275) 5(-2.9,1.625) 6(-2.9,0.975) 7(-2.9,0.325) 8(-2.9,-0.325) 9(-2.9,-0.975) 10(-2.9,-1.625) 11(-2.9,-2.275) 12(-2.9,-2.925) 13(-2.9,-3.575) 14(-2.9,-4.225) 15(2.9,-4.225) 16(2.9,-3.575) 17(2.9,-2.925) 18(2.9,-2.275) 19(2.9,-1.625) 20(2.9,-0.975) 21(2.9,-0.325) 22(2.9,0.325) 23(2.9,0.975) 24(2.9,1.625) 25(2.9,2.275) 26(2.9,2.925) 27(2.9,3.575) 28(2.9,4.225)
TSSOP_D65X5D775_8SP_3L
  rect 1.397x0.381 smd: 1(-2.887,1.035) 2(-2.887,0.385) 3(-2.887,-0.265) 4(-2.887,-0.915) 5(2.887,-0.915) 6(2.887,-0.265) 7(2.887,0.385) 8(2.887,1.035)
TSSOP_D65X5D775_16SP_4D4W5L1D2H
  rect 1.524x0.254 smd: 1(-2.887,2.275) 2(-2.887,1.625) 3(-2.887,0.975) 4(-2.887,0.325) 5(-2.887,-0.325) 6(-2.887,-0.975) 7(-2.887,-1.625) 8(-2.887,-2.275) 9(2.887,-2.275) 10(2.887,-1.625) 11(2.887,-0.975) 12(2.887,-0.325) 13(2.887,0.325) 14(2.887,0.975) 15(2.887,1.625) 16(2.887,2.275)
TSSOP_D65X5D775_24SP_4D4W7D8L
  rect 1.524x0.381 smd: 1(-2.887,3.575) 2(-2.887,2.925) 3(-2.887,2.275) 4(-2.887,1.625) 5(-2.887,0.975) 6(-2.887,0.325) 7(-2.887,-0.325) 8(-2.887,-0.975) 9(-2.887,-1.625) 10(-2.887,-2.275) 11(-2.887,-2.925) 12(-2.887,-3.575) 13(2.887,-3.575) 14(2.887,-2.925) 15(2.887,-2.275) 16(2.887,-1.625) 17(2.887,-0.975) 18(2.887,-0.325) 19(2.887,0.325) 20(2.887,0.975) 21(2.887,1.625) 22(2.887,2.275) 23(2.887,2.925) 24(2.887,3.575)
unnamed#2
  round 1.016 smd: (0,0)
US8_D5X2D8_8SP_2D1W2D4L
  rect 1.016x0.254 smd: 1(-1.4,0.75) 2(-1.4,0.25) 3(-1.4,-0.25) 4(-1.4,-0.75) 5(1.4,-0.75) 6(1.4,-0.25) 7(1.4,0.25) 8(1.4,0.75)
USB_2D5_4SP_14D8W14L
  rect 1.016x3.048 smd: 1(-3.5,4.21) 2(-1,4.21) 3(1,4.21) 4(3.5,4.21)
  oval 1.524x3.048 hole 1.016x2.54: G1(-6.4,0) G2(6.4,0)
XFMR_1D27X8D76_16SP_12D7L
  rect 1.905x0.762 smd: 1(-4.38,4.445) 2(-4.38,3.175) 3(-4.38,1.905) 4(-4.38,0.635) 5(-4.38,-0.635) 6(-4.38,-1.905) 7(-4.38,-3.175) 8(-4.38,-4.445) 9(4.38,-4.445) 10(4.38,-3.175) 11(4.38,-1.905) 12(4.38,-0.635) 13(4.38,0.635) 14(4.38,1.905) 15(4.38,3.175) 16(4.38,4.445)
XFMR_1D27X14D46_24SP_17D55W
  rect 0.762x2.54 smd: 1(-6.985,-7.23) 2(-5.715,-7.23) 3(-4.445,-7.23) 4(-3.175,-7.23) 5(-1.905,-7.23) 6(-0.635,-7.23) 7(0.635,-7.23) 8(1.905,-7.23) 9(3.175,-7.23) 10(4.445,-7.23) 11(5.715,-7.23) 12(6.985,-7.23) 13(6.985,7.23) 14(5.715,7.23) 15(4.445,7.23) 16(3.175,7.23) 17(1.905,7.23) 18(0.635,7.23) 19(-0.635,7.23) 20(-1.905,7.23) 21(-3.175,7.23) 22(-4.445,7.23) 23(-5.715,7.23) 24(-6.985,7.23)

## Nets
2V5RC01: CB417.2 RB181.2
AGND_VCC1V0: C291.2 C324.2 C336.2 C337.2 C338.2 C339.2 C352.2 CB404.2 R530.1 R531.2 R533.1 R534.1 R535.1 R554.1 R560.2 R567.1 R578.1 R600.1 RB176.1 U33.17(GND_1) U33.20(GND_2) U33.22(GND_3) U33.G1(PWPD)
AGND_VCC3V3: R488.1 R492.2 R498.1 R504.1 R512.2 U31.7(GND)
GND: C2.2 C3.2 C4.2 C7.2 C8.2 C9.2 C16.1 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.1 C27.2 C28.2 C29.2 C30.2 C31.1 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C41.2 C42.1 C43.2 C44.1 C45.2 C47.2 C48.2 C49.2 C50.2 C52.2 C53.2 C54.2 C55.1 C56.2 C57.2 C58.1 C59.1 C60.1 C61.2 C62.2 C63.1 C64.1 C68.2 C69.2 C83.2 C84.1 C86.2 C89.2 C90.2 C91.2 C93.2 C94.2 C95.2 C97.1 C99.2 C100.2 C101.1 C102.2 C104.2 C106.1 C107.1 C108.2 C109.2 C110.1 C112.1 C114.2 C115.1 C117.1 C118.2 C121.2 C122.1 C123.1 C128.2 C129.2 C131.1 C132.2 C133.2 C134.2 C135.2 C136.1 C137.2 C139.2 C140.2 C143.2 C144.2 C145.1 C146.2 C149.2 C151.2 C152.2 C153.1 C154.2 C157.1 C158.2 C159.2 C161.2 C164.2 C165.2 C166.2 C167.1 C168.2 C169.2 C172.2 C174.1 C175.2 C176.2 C177.2 C178.2 C179.2 C182.1 C183.1 C184.2 C186.2 C188.1 C189.1 C190.1 C191.1 C193.2 C194.2 C195.1 C196.2 C197.2 C198.2 C199.2 C200.2 C201.1 C202.2 C203.2 C204.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C217.2 C218.2 C219.2 C220.2 C223.2 C224.1 C225.2 C226.2 C227.1 C230.1 C231.2 C235.2 C236.2 C237.1 C238.1 C240.1 C244.2 C245.2 C247.2 C248.2 C249.2 C250.2 C251.1 C252.1 C253.2 C254.2 C255.2 C256.2 C257.2 C258.C C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.C C274.2 C276.2 C277.2 C279.2 C280.2 C281.1 C282.1 C284.2 C285.2 C286.2 C287.1 C288.2 C289.2 C292.2 C293.2 C294.1 C295.1 C296.2 C297.2 C298.2 C300.2 C301.1 C302.2 C303.2 C304.2 C307.1 C308.1 C309.2 C311.2 C312.2 C313.2 C314.C C316.2 C317.2 C318.1 C319.2 C320.2 C321.2 C322.2 C325.2 C326.2 C327.2 C328.2 C329.2 C330.1 C332.2 C333.2 C334.2 C340.2 C341.2 C342.2 C343.2 C344.2 C345.2 C346.2 C347.2 C349.2 C350.2 C351.2 C353.C C354.2 C355.2 C357.1 C358.1 C359.2 C360.2 C362.1 C363.1 C364.1 C365.1 C366.1 C367.1 C368.1 C369.1 C370.1 C371.2 C372.2 C373.2 C374.2 C375.C C376.2 C378.C C379.C C380.1 C381.2 C383.2 C387.1 C388.1 C389.1 C390.1 C391.1 C392.1 C393.1 C394.2 C395.1 C396.1 C397.1 C398.1 C399.1 C400.1 C401.1 C402.1 C403.2 C405.1 C407.1 C408.1 C409.1 C411.2 C412.C C416.1 C420.2 C421.2 C422.2 C423.2 C425.1 C426.1 C427.2 C428.2 C429.1 C430.1 C431.C C433.2 C435.2 C437.2 C438.2 C439.2 C440.2 C441.2 C443.C C444.2 C446.2 C447.2 C449.2 C451.2 C452.2 C453.2 C454.2 C458.C C459.2 C461.2 C463.2 C464.2 C465.2 C466.2 C467.2 C468.2 C469.2 C470.2 C471.2 C472.2 C473.2 C474.2 C475.2 C476.1 C477.2 C478.2 C479.2 C481.2 C482.2 C483.1 C485.2 C486.2 C487.1 C488.1 C489.1 C493.1 C495.C C496.C C497.C C498.1 C499.1 C500.1 C501.1 C502.1 C503.1 C504.1 C506.2 C508.1 C509.1 C511.2 C512.2 C513.2 C514.2 C516.2 C517.2 C518.2 C519.2 C521.2 C522.2 C523.2 C524.2 C525.2 C528.2 C529.2 C530.2 C531.2 C532.2 C533.2 C534.2 C535.2 C536.2 C539.2 C540.2 C541.2 C544.2 C545.2 C546.2 C547.2 C549.2 C550.2 C551.2 C552.2 C553.2 C554.2 C555.2 C556.2 C557.2 C558.2 C559.2 C560.2 C561.2 C562.2 C563.2 C564.2 C565.2 C566.2 C569.2 C570.2 C571.2 C573.2 C574.2 C575.2 C576.2 C589.2 C590.2 C591.2 C592.2 C593.2 C594.2 C595.2 C596.2 C597.2 C598.2 C599.2 C600.2 C601.2 C602.2 C603.2 C604.2 C605.2 C606.2 C607.2 C608.2 C609.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C617.2 C618.2 C619.2 C620.2 C621.2 C622.2 C623.2 C624.2 C625.2 C626.2 C627.2 C628.2 C629.2 C630.2 C631.2 C632.2 C633.2 C634.2 C635.2 C636.2 C637.2 C638.2 C639.2 C640.2 C641.2 C642.2 C643.2 C644.2 C645.2 C646.2 C647.2 C648.2 C649.2 C650.2 C651.2 C652.2 C653.2 C654.2 C655.2 C656.2 C657.2 C658.2 C659.2 C660.2 C661.2 C662.2 C663.2 C664.2 C665.2 C666.2 C667.2 C668.2 C669.2 C670.2 C671.2 C672.2 C673.2 C674.2 C675.2 C676.2 C677.2 C678.2 C679.2 C680.2 C681.2 C682.2 C683.2 C684.2 C685.2 C686.2 C687.2 C688.2 C689.2 C690.2 C691.2 C692.2 C693.2 C694.2 C711.1 C712.1 C713.1 C714.1 C715.2 C716.2 C717.2 C718.2 C724.2 C725.2 C735.2 C736.2 C737.1 C738.1 C739.1 C753.2 C754.1 C773.1 C775.2 C776.1 C777.2 C778.2 C779.2 C781.2 C783.2 C785.2 C796.2 C797.2 C798.2 C799.2 C800.2 C801.2 C802.2 C803.2 C804.2 C805.2 C806.2 C807.2 C808.2 C809.2 C810.2 C811.2 C812.2 C813.2 C814.2 C815.2 C816.2 C817.2 C818.2 C819.2 C820.2 C821.2 C822.2 C823.2 C824.2 C825.2 C826.2 C827.2 C828.2 C829.2 C830.2 C831.2 C832.2 C833.2 C834.2 C835.2 C836.2 C837.2 C838.2 C839.2 C840.2 C841.2 C842.2 C843.2 C844.2 C845.2 C846.2 C847.C C848.1 C849.2 C850.2 C851.1 C852.C C853.2 C854.2 C855.2 C856.2 C857.2 C858.2 C859.2 C860.2 C864.2 C865.2 C866.2 C867.2 C868.2 C869.2 C870.2 C871.2 C872.2 C873.2 C874.2 C875.2 C876.2 C877.2 C878.2 C879.2 C880.1 C881.2 C882.2 C883.2 C884.1 C885.2 C886.2 C887.2 C888.2 C889.1 C890.1 C891.1 C892.1 C893.1 C894.2 C895.1 C896.1 C898.2 C899.2 C900.2 C901.2 C914.1 C915.2 C916.2 C917.2 C918.2 C919.1 C922.1 C923.1 C924.1 C925.2 C926.2 C927.2 C928.2 C929.2 C930.2 C931.2 C932.2 C933.2 C934.2 C935.2 C936.2 C937.2 C938.2 C939.2 C940.2 C941.2 C942.2 C943.2 C944.2 C945.2 C946.2 C947.2 C948.2 C949.2 C952.1 C953.1 C954.1 C955.1 C956.1 C957.1 C958.1 C959.1 C960.2 C961.2 C962.2 C963.2 C964.2 C965.2 C966.2 C967.2 C968.2 C969.2 C970.2 C971.2 C972.2 C973.2 C974.2 C975.2 C976.2 C977.2 C978.2 C979.2 C980.2 C981.2 C982.2 C983.2 C984.1 C985.1 C986.2 C989.1 C990.1 C991.1 C992.1 C993.2 C994.2 C995.2 C996.2 C997.2 C998.2 C999.2 C1000.2 C1001.2 C1002.2 C1003.2 C1004.2 CB2.2 CB3.2 CB4.2 CB5.2 CB6.2 CB7.1 CB8.1 CB9.2 CB10.1 CB12.2 CB13.2 CB21.1 CB24.1 CB25.2 CB26.2 CB27.1 CB28.2 CB29.2 CB30.1 CB31.2 CB32.2 CB33.1 CB34.2 CB35.2 CB36.1 CB38.2 CB39.2 CB42.2 CB43.2 CB44.2 CB45.2 CB46.2 CB47.2 CB48.2 CB49.2 CB50.1 CB51.2 CB52.2 CB53.2 CB54.2 CB55.2 CB56.2 CB57.2 CB58.1 CB59.2 CB60.1 CB61.2 CB62.2 CB63.2 CB64.1 CB68.1 CB69.2 CB70.2 CB71.1 CB72.2 CB75.2 CB76.2 CB77.2 CB80.1 CB81.2 CB82.2 CB85.1 CB86.1 CB90.2 CB92.2 CB101.2 CB104.2 CB108.2 CB109.2 CB110.2 CB113.2 CB114.2 CB118.2 CB119.2 CB120.2 CB121.2 CB122.2 CB124.2 CB125.2 CB128.2 CB129.2 CB130.2 CB131.2 CB134.2 CB135.1 CB136.2 CB138.2 CB139.2 CB140.2 CB141.2 CB152.2 CB153.2 CB154.2 CB155.2 CB156.1 CB157.2 CB159.2 CB160.2 CB161.2 CB162.2 CB166.1 CB167.2 CB170.2 CB172.2 CB173.2 CB175.2 CB176.2 CB177.2 CB181.2 CB182.2 CB183.2 CB185.2 CB186.2 CB193.2 CB195.2 CB196.2 CB197.2 CB198.2 CB199.2 CB201.2 CB202.2 CB203.2 CB205.2 CB206.2 CB208.2 CB209.2 CB210.2 CB211.2 CB212.2 CB213.2 CB214.2 CB217.2 CB218.2 CB221.2 CB224.2 CB225.2 CB226.2 CB227.2 CB228.2 CB229.2 CB230.2 CB231.2 CB232.2 CB233.2 CB234.2 CB235.2 CB236.2 CB239.2 CB240.2 CB241.2 CB242.2 CB243.2 CB244.2 CB246.2 CB247.2 CB253.2 CB254.2 CB257.2 CB258.2 CB260.2 CB261.2 CB262.2 CB263.2 CB265.2 CB266.2 CB267.2 CB268.2 CB269.2 CB270.2 CB271.2 CB273.2 CB274.2 CB275.2 CB276.2 CB277.2 CB278.2 CB279.2 CB280.2 CB281.2 CB282.2 CB284.2 CB285.2 CB286.2 CB287.2 CB288.2 CB290.2 CB291.2 CB292.2 CB293.2 CB294.2 CB295.2 CB296.2 CB297.2 CB299.2 CB300.2 CB308.2 CB310.2 CB311.2 CB312.2 CB313.2 CB314.2 CB315.2 CB316.2 CB317.2 CB318.2 CB319.C CB320.C CB321.1 CB322.1 CB323.1 CB324.2 CB325.C CB326.C CB327.1 CB328.C CB330.2 CB331.2 CB332.2 CB333.2 CB334.2 CB335.2 CB336.2 CB337.2 CB338.2 CB339.2 CB340.2 CB345.1 CB346.C CB347.C CB348.2 CB350.1 CB352.2 CB353.1 CB354.1 CB355.2 CB356.2 CB357.2 CB358.2 CB359.1 CB360.2 CB361.2 CB362.2 CB363.2 CB364.1 CB365.2 CB366.1 CB367.2 CB369.2 CB370.2 CB371.2 CB372.2 CB373.2 CB374.1 CB375.2 CB376.1 CB377.2 CB378.2 CB379.1 CB380.2 CB381.1 CB383.2 CB384.1 CB385.1 CB386.2 CB387.1 CB389.2 CB390.1 CB391.2 CB392.2 CB393.2 CB394.2 CB395.2 CB396.2 CB397.2 CB398.1 CB399.1 CB400.2 CB401.2 CB402.1 CB403.2 CB405.2 CB406.1 CB407.2 CB409.2 CB410.1 CB411.2 CB412.2 CB413.1 CB414.2 CB415.2 CB416.1 CB417.1 CB418.2 CB419.1 CB420.2 CB421.2 CB422.C CB423.2 CB424.2 CB425.2 CB426.2 CB427.2 CB429.2 CB430.2 CB431.2 CB432.2 CB433.2 CB434.1 CB435.1 CB436.2 CB437.2 CB438.2 CB439.2 CB442.2 CB443.1 CB444.1 CB445.1 CB446.1 CB447.1 CB448.2 CB449.2 CB450.2 CB451.2 CB452.2 CB453.2 CB454.2 CB456.2 CB457.2 CB458.1 CB459.2 CB460.2 CB461.2 CB462.2 CB463.2 CB464.1 CB465.2 CB466.2 CB467.2 CB468.2 CB469.1 CB470.2 CB471.2 CB472.2 CB473.2 CB474.2 CB475.2 CB476.1 CB477.2 CB478.2 CB479.2 CB480.2 CB481.2 CB482.2 CB483.2 CB484.2 CB485.2 CB486.1 CB487.2 CB488.2 CB489.2 CB490.2 CB491.1 CB492.2 CB493.2 CB494.1 CB495.2 CB496.2 CB497.2 CB498.2 CB499.2 CB501.2 CB502.2 CB503.2 CB504.2 CB505.2 CB506.2 CB507.2 CB508.2 CB510.2 CB512.2 CB513.2 CB514.2 CB515.2 CB516.2 CB517.2 CB518.2 CB519.1 CB520.2 CB521.1 CB523.2 CB524.2 CB525.2 CB526.2 CB527.2 CB529.2 CB530.1 CB531.2 CB532.2 CB533.2 CB534.2 CB535.2 CB536.2 CB537.2 CB538.2 CB539.2 CB540.2 CB541.2 CB542.2 CB543.2 CB544.2 CB545.2 CB546.2 CB547.2 CB548.1 CB549.2 CB550.1 CB551.1 CB552.1 CB553.2 CB554.2 CB555.2 CB556.2 CB557.2 CB558.2 CB559.1 CB560.2 CB561.1 CB562.1 CB563.1 CB565.2 CB566.2 CB567.2 CB568.1 CB569.2 CB570.1 CB571.2 CB572.1 CB573.2 CB574.2 CB576.1 CB577.1 CB579.2 CB580.2 CB581.2 CB582.2 CB583.2 CB584.2 CB585.1 CB587.C CB588.C CB589.2 CB590.2 CB591.2 CB592.2 CB593.1 CB594.1 CB595.2 CB596.2 CB597.2 CB598.2 CB599.2 CB600.2 CB601.2 CB602.1 CB603.2 CB604.2 CB605.1 CB606.1 CB608.1 CB609.2 CB610.2 CB611.2 CB612.2 CB613.2 CB614.1 CB615.2 CB616.2 CB617.1 CB618.1 CB619.2 CB620.2 CB621.2 CB622.2 CB623.2 CB624.2 CB625.2 CB626.2 CB627.2 CB628.2 CB629.2 CB630.2 CB631.2 CB632.1 CB633.1 CB634.1 CB635.1 CB636.1 CB637.1 CB638.1 CB639.1 CB640.2 CB641.1 CB642.2 CB643.2 CB644.2 CB645.2 CB646.1 CB647.1 CB648.1 CB649.1 CB650.1 CB651.1 CB652.1 CB653.1 CB654.2 CB655.1 CB656.1 CB657.1 CB658.1 CB659.1 CB660.1 CB661.2 CB662.2 CB663.1 CB664.1 CB665.1 CB666.1 CB667.1 CB673.1 CB674.1 CB675.1 CB676.1 CB677.1 CB678.1 CB679.1 CB680.1 CB682.1 CB683.1 CB684.1 CB685.1 CB688.1 CB689.1 CB690.1 CB691.1 CB692.1 CB693.1 CB694.1 CB695.1 CB696.1 CB697.1 CB698.1 CB699.1 CB700.1 CB701.1 CB702.1 CB703.1 CB704.1 CB705.1 CB706.1 CB707.2 CB708.2 CB712.1 CB713.1 CB714.1 CB715.1 CB716.1 CB717.1 CB718.1 CB719.1 CB720.1 CB721.1 CB722.1 CB723.1 CB724.1 CB725.1 CB726.1 CB727.1 CB728.1 CB729.1 CB731.2 CB732.1 CB733.1 CB734.1 CB735.1 CB738.1 CB740.1 CB741.1 CB742.1 CB743.1 CB744.1 CB745.1 CB746.1 CB747.1 CB748.1 CB749.1 CB750.1 CB751.1 CB752.1 CB756.1 CB757.2 CB758.1 CB759.1 CB765.1 CB766.1 CB767.1 CB768.1 CB769.1 CB770.1 CB771.1 CB772.1 CB773.1 CB774.1 CB775.1 CB783.C CB786.2 CB787.2 CB788.2 CB789.2 CB793.2 CB796.2 CB797.2 CB799.2 CB800.2 CB801.2 CB806.2 CB807.2 CB808.2 CB809.2 CB810.2 CB811.2 CB812.2 CB813.2 CB814.2 CB815.2 CB816.2 CB817.2 CB818.2 CB819.2 CB820.2 CB821.2 CB822.2 CB827.2 CB828.2 CB829.2 CB832.2 CB833.2 CB834.2 CB835.2 CB836.2 CB837.2 CB838.2 CB839.2 CB840.2 CB841.2 CB842.2 CB843.2 CB844.2 CB845.2 CB846.2 CB847.2 CB848.2 CB849.2 CB852.2 CB853.2 CB854.2 CB855.2 CB856.2 CB857.2 CB858.2 CB859.2 CB860.2 CB861.2 CB862.2 CB863.2 CB864.2 CB865.2 CB866.2 CB867.2 CB868.2 CB869.2 CB870.2 CB871.2 CB872.2 CB873.2 CB874.2 CB875.2 CB876.2 CB877.2 CB878.2 CB879.2 CB880.2 CB881.2 CB883.2 CB892.1 CB893.1 CB894.1 CB895.1 CB896.2 CB898.1 CB899.2 CB900.2 CB901.2 CB902.2 CB903.1 CB904.2 CB905.2 CB906.2 CB907.2 CB908.2 CB909.2 CB910.2 CB911.2 CB912.2 CB913.2 CB915.2 CB916.2 CB917.2 CB918.2 CB919.2 CB920.2 CB922.1 CB923.1 CB926.2 CB927.2 CB928.2 CB929.2 CB930.2 CB931.2 CB937.1 CB938.2 CB942.1 CB949.2 CB950.1 CB951.2 CB952.2 CB953.1 CB954.1 CB956.1 CB957.1 CB958.1 CB959.2 CB962.1 CB972.C CB973.1 CB974.2 CB975.2 CB976.1 CB977.1 CB978.1 CB979.1 CB980.1 CB981.1 CB982.1 CB983.1 CB984.1 CB985.2 CB986.2 CB987.2 CB994.2 CB995.2 CB996.2 CB997.2 CB998.2 CB999.1 CB1000.1 CB1001.2 CB1002.2 CB1003.2 CB1004.2 CB1005.2 CB1006.2 CB1007.2 CB1008.2 CB1010.2 CB1011.1 CB1012.1 CB1013.2 CB1014.2 CB1015.2 CB1016.2 CB1017.2 CB1018.2 CB1019.1 CB1020.2 CB1021.1 CB1022.2 CB1023.2 CB1024.2 CB1025.1 CB1026.2 CB1027.1 CB1028.2 CB1029.2 CB1030.2 CB1031.2 CB1032.2 CB1033.2 CB1034.2 CB1035.1 CB1036.1 CB1037.2 CB1038.2 CB1039.2 CB1040.2 CB1041.2 CB1042.2 CB1043.2 CB1044.2 CB1045.2 CB1046.1 CB1047.1 CB1048.2 CB1049.2 CB1050.2 CB1051.2 CB1052.2 CB1053.2 CB1054.2 CB1057.2 CB1058.2 CB1063.1 CB1064.1 CB1065.2 CB1066.2 CB1067.2 CB1068.2 CB1069.1 CB1070.1 CB1071.2 CB1072.2 CB1073.2 CB1074.2 CB1075.1 CB1076.1 CB1077.2 CB1078.2 CB1079.2 CB1080.2 CB1081.2 CB1082.2 CB1083.1 CB1084.1 CB1085.1 CB1086.1 CB1087.1 CB1088.1 CB1089.1 CB1090.1 CB1091.1 CB1094.2 CB1095.2 CB1096.2 CB1097.2 CB1098.2 CB1099.2 CB1100.2 CB1101.2 CB1102.2 CB1103.2 CB1104.1 CB1105.1 CB1106.1 CB1107.1 CB1108.2 CB1109.1 CB1110.1 CB1111.1 CB1112.1 CB1113.1 CB1114.1 CB1115.2 CB1116.2 CB1117.2 CB1118.2 CB1119.2 CB1120.2 CB1121.2 CB1122.2 CB1123.2 CB1124.2 CB1125.2 CB1126.2 CB1127.2 CB1128.2 CB1129.2 CB1130.2 CB1131.2 CB1132.2 CB1133.2 CB1134.2 CB1135.2 CB1136.2 CB1137.2 CB1138.2 CB1139.2 CB1140.2 CB1141.2 CB1142.2 CB1143.2 CB1144.2 CB1145.2 CB1146.2 CB1147.2 CB1148.2 CB1149.2 CB1150.2 CB1151.2 CB1152.2 CB1153.2 CB1154.2 CB1155.2 CB1156.2 CB1157.2 CB1158.2 CB1159.2 CB1160.2 CB1161.2 CB1162.2 CB1163.2 CB1164.2 CB1165.2 CB1166.2 CB1167.2 CB1168.2 CB1169.2 CB1170.2 CB1171.2 CB1172.2 CB1173.2 CB1174.2 CB1175.2 CB1176.2 CB1177.2 CB1178.2 CB1179.2 CB1180.2 CB1188.2 CB1195.2 CB1200.2 CB1211.2 CB1212.2 CB1217.2 CB1218.2 CB1221.2 CB1224.2 CB1227.2 CB1228.1 CB1229.1 CONN2.2 CONN6.2 CONN6.5 CONN6.8 CONN6.11 CONN6.12 CONN6.14 CONN6.17 CONN6.20 CONN6.23 CONN6.24 CONN28.2 CONN28.10 CONN41.6 CONN44.8 CONN53_PF.1B1(VSS_1_1B) CONN53_PF.1B4(VSS_2_1B) CONN53_PF.1B7(VSS_3_1B) CONN53_PF.1B13(VSS_4_1B) CONN53_PF.1B16(VSS_5_1B) CONN53_PF.1B19(VSS_6_1B) CONN53_PF.1B20(VSS_7_1B) CONN53_PF.1B23(VSS_8_1B) CONN53_PF.1B26(VSS_9_1B) CONN53_PF.1B32(VSS_10_1B) CONN53_PF.1B35(VSS_11_1B) CONN53_PF.1B38(VSS_12_1B) CONN53_PF.1T1(VSS_1_1T) CONN53_PF.1T4(VSS_2_1T) CONN53_PF.1T7(VSS_3_1T) CONN53_PF.1T13(VSS_4_1T) CONN53_PF.1T16(VSS_5_1T) CONN53_PF.1T19(VSS_6_1T) CONN53_PF.1T20(VSS_7_1T) CONN53_PF.1T23(VSS_8_1T) CONN53_PF.1T26(VSS_9_1T) CONN53_PF.1T32(VSS_10_1T) CONN53_PF.1T35(VSS_11_1T) CONN53_PF.1T38(VSS_12_1T) CONN54_PF.1L1(VEET#1L1) CONN54_PF.1L10(VEER#1L10) CONN54_PF.1L11(VEER#1L11) CONN54_PF.1L14(VEER#1L14) CONN54_PF.1L17(VEET#1L17) CONN54_PF.1L20(VEET#1L20) CONN54_PF.1T1(VEET#1T1) CONN54_PF.1T10(VEER#1T10) CONN54_PF.1T11(VEER#1T11) CONN54_PF.1T14(VEER#1T14) CONN54_PF.1T17(VEET#1T17) CONN54_PF.1T20(VEET#1T20) CONN54_PF.2L1(VEET#2L1) CONN54_PF.2L10(VEER#2L10) CONN54_PF.2L11(VEER#2L11) CONN54_PF.2L14(VEER#2L14) CONN54_PF.2L17(VEET#2L17) CONN54_PF.2L20(VEET#2L20) CONN54_PF.2T1(VEET#2T1) CONN54_PF.2T10(VEER#2T10) CONN54_PF.2T11(VEER#2T11) CONN54_PF.2T14(VEER#2T14) CONN54_PF.2T17(VEET#2T17) CONN54_PF.2T20(VEET#2T20) CONN54_PF.3L1(VEET#3L1) CONN54_PF.3L10(VEER#3L10) CONN54_PF.3L11(VEER#3L11) CONN54_PF.3L14(VEER#3L14) CONN54_PF.3L17(VEET#3L17) CONN54_PF.3L20(VEET#3L20) CONN54_PF.3T1(VEET#3T1) CONN54_PF.3T10(VEER#3T10) CONN54_PF.3T11(VEER#3T11) CONN54_PF.3T14(VEER#3T14) CONN54_PF.3T17(VEET#3T17) CONN54_PF.3T20(VEET#3T20) CONN54_PF.4L1(VEET#4L1) CONN54_PF.4L10(VEER#4L10) CONN54_PF.4L11(VEER#4L11) CONN54_PF.4L14(VEER#4L14) CONN54_PF.4L17(VEET#4L17) CONN54_PF.4L20(VEET#4L20) CONN54_PF.4T1(VEET#4T1) CONN54_PF.4T10(VEER#4T10) CONN54_PF.4T11(VEER#4T11) CONN54_PF.4T14(VEER#4T14) CONN54_PF.4T17(VEET#4T17) CONN54_PF.4T20(VEET#4T20) CONN54_PF.5L1(VEET#5L1) CONN54_PF.5L10(VEER#5L10) CONN54_PF.5L11(VEER#5L11) CONN54_PF.5L14(VEER#5L14) CONN54_PF.5L17(VEET#5L17) CONN54_PF.5L20(VEET#5L20) CONN54_PF.5T1(VEET#5T1) CONN54_PF.5T10(VEER#5T10) CONN54_PF.5T11(VEER#5T11) CONN54_PF.5T14(VEER#5T14) CONN54_PF.5T17(VEET#5T17) CONN54_PF.5T20(VEET#5T20) CONN54_PF.6L1(VEET#6L1) CONN54_PF.6L10(VEER#6L10) CONN54_PF.6L11(VEER#6L11) CONN54_PF.6L14(VEER#6L14) CONN54_PF.6L17(VEET#6L17) CONN54_PF.6L20(VEET#6L20) CONN54_PF.6T1(VEET#6T1) CONN54_PF.6T10(VEER#6T10) CONN54_PF.6T11(VEER#6T11) CONN54_PF.6T14(VEER#6T14) CONN54_PF.6T17(VEET#6T17) CONN54_PF.6T20(VEET#6T20) CONN55_PF.1L1(VEET#1L1) CONN55_PF.1L10(VEER#1L10) CONN55_PF.1L11(VEER#1L11) CONN55_PF.1L14(VEER#1L14) CONN55_PF.1L17(VEET#1L17) CONN55_PF.1L20(VEET#1L20) CONN55_PF.1T1(VEET#1T1) CONN55_PF.1T10(VEER#1T10) CONN55_PF.1T11(VEER#1T11) CONN55_PF.1T14(VEER#1T14) CONN55_PF.1T17(VEET#1T17) CONN55_PF.1T20(VEET#1T20) CONN55_PF.2L1(VEET#2L1) CONN55_PF.2L10(VEER#2L10) CONN55_PF.2L11(VEER#2L11) CONN55_PF.2L14(VEER#2L14) CONN55_PF.2L17(VEET#2L17) CONN55_PF.2L20(VEET#2L20) CONN55_PF.2T1(VEET#2T1) CONN55_PF.2T10(VEER#2T10) CONN55_PF.2T11(VEER#2T11) CONN55_PF.2T14(VEER#2T14) CONN55_PF.2T17(VEET#2T17) CONN55_PF.2T20(VEET#2T20) CONN55_PF.3L1(VEET#3L1) CONN55_PF.3L10(VEER#3L10) CONN55_PF.3L11(VEER#3L11) CONN55_PF.3L14(VEER#3L14) CONN55_PF.3L17(VEET#3L17) CONN55_PF.3L20(VEET#3L20) CONN55_PF.3T1(VEET#3T1) CONN55_PF.3T10(VEER#3T10) CONN55_PF.3T11(VEER#3T11) CONN55_PF.3T14(VEER#3T14) CONN55_PF.3T17(VEET#3T17) CONN55_PF.3T20(VEET#3T20) CONN55_PF.4L1(VEET#4L1) CONN55_PF.4L10(VEER#4L10) CONN55_PF.4L11(VEER#4L11) CONN55_PF.4L14(VEER#4L14) CONN55_PF.4L17(VEET#4L17) CONN55_PF.4L20(VEET#4L20) CONN55_PF.4T1(VEET#4T1) CONN55_PF.4T10(VEER#4T10) CONN55_PF.4T11(VEER#4T11) CONN55_PF.4T14(VEER#4T14) CONN55_PF.4T17(VEET#4T17) CONN55_PF.4T20(VEET#4T20) CONN55_PF.5L1(VEET#5L1) CONN55_PF.5L10(VEER#5L10) CONN55_PF.5L11(VEER#5L11) CONN55_PF.5L14(VEER#5L14) CONN55_PF.5L17(VEET#5L17) CONN55_PF.5L20(VEET#5L20) CONN55_PF.5T1(VEET#5T1) CONN55_PF.5T10(VEER#5T10) CONN55_PF.5T11(VEER#5T11) CONN55_PF.5T14(VEER#5T14) CONN55_PF.5T17(VEET#5T17) CONN55_PF.5T20(VEET#5T20) CONN55_PF.6L1(VEET#6L1) CONN55_PF.6L10(VEER#6L10) CONN55_PF.6L11(VEER#6L11) CONN55_PF.6L14(VEER#6L14) CONN55_PF.6L17(VEET#6L17) CONN55_PF.6L20(VEET#6L20) CONN55_PF.6T1(VEET#6T1) CONN55_PF.6T10(VEER#6T10) CONN55_PF.6T11(VEER#6T11) CONN55_PF.6T14(VEER#6T14) CONN55_PF.6T17(VEET#6T17) CONN55_PF.6T20(VEET#6T20) CONN56.11 CONN56.12 CONN56.13 CONN56.14 CONN56.17 CONN56.18 CONN56.23 CONN56.24 CONN56.29 CONN56.30 CONN56.G1 CONN56.G2 CONN57.2 CONN57.10 CONN58.10 D2.A J2.A1(GND(FIXED)1) J2.A11(GND(FIXED)2) J2.A21(GND(FIXED)3) J2.A31(GND(FIXED)4) J2.A38(USB_6_7_OC#) J2.A41(GND(FIXED)5) J2.A51(GND(FIXED)6) J2.A57(GND1) J2.A60(GND(FIXED)7) J2.A66(GND2) J2.A70(GND(FIXED)8) J2.A80(GND(FIXED)9) J2.A90(GND(FIXED)10) J2.A100(GND(FIXED)11) J2.A110(GND(FIXED)12) J2.B1(GND(FIXED)13) J2.B11(GND(FIXED)14) J2.B21(GND(FIXED)15) J2.B31(GND(FIXED)16) J2.B38(USB_4_5_OC#) J2.B41(GND(FIXED)17) J2.B51(GND(FIXED)18) J2.B60(GND(FIXED)19) J2.B70(GND(FIXED)20) J2.B80(GND(FIXED)21) J2.B90(GND(FIXED)22) J2.B100(GND(FIXED)23) J2.B110(GND(FIXED)24) J2.C1(GND(FIXED)25) J2.C2(GND3) J2.C5(GND4) J2.C8(GND5) J2.C11(GND(FIXED)26) J2.C14(GND6) J2.C18(RSVD4) J2.C21(GND(FIXED)27) J2.C25(RSVD5) J2.C28(RSVD6) J2.C31(GND(FIXED)28) J2.C41(GND(FIXED)29) J2.C44(GND_C44) J2.C48(RSVD9) J2.C51(GND(FIXED)30) J2.C60(GND(FIXED)31) J2.C70(GND(FIXED)32) J2.C73(GND7) J2.C76(GND8) J2.C80(GND(FIXED)33) J2.C84(GND9) J2.C87(GND10) J2.C90(GND(FIXED)34) J2.C93(GND11) J2.C96(GND12) J2.C100(GND(FIXED)35) J2.C103(GND13) J2.C110(GND(FIXED)36) J2.D1(GND(FIXED)37) J2.D2(GND25) J2.D5(GND14) J2.D8(GND15) J2.D11(GND(FIXED)38) J2.D14(GND16) J2.D18(RSVD17) J2.D21(GND(FIXED)39) J2.D25(RSVD19) J2.D28(RSVD20) J2.D31(GND(FIXED)40) J2.D41(GND(FIXED)41) J2.D44(GND_D44) J2.D48(RSVD24) J2.D51(GND(FIXED)42) J2.D60(GND(FIXED)43) J2.D67(GND17) J2.D70(GND(FIXED)44) J2.D73(GND18) J2.D76(GND19) J2.D80(GND(FIXED)45) J2.D84(GND20) J2.D87(GND21) J2.D90(GND(FIXED)46) J2.D93(GND22) J2.D96(GND23) J2.D100(GND(FIXED)47) J2.D103(GND24) J2.D110(GND(FIXED)48) J2.G1(GND_SH1) J2.G2(GND_SH2) J2.G3(GND_SH3) J2.G4(GND_SH4) J3.1(GND_0) J3.3(GND_1) J3.9(GND_2) J3.15(GND_3) J3.21(GND_4) J3.27(GND_5) J3.33(GND_6) J3.39(GND_7) J3.45(GND_8) J3.51(GND_9) J3.57(GND_10) J3.69(PEDET_OC_PCIE/GND_SATA) J3.71(GND_11) J3.73(GND_12) J3.75(GND_13) J3.G1(SH1) J3.G2(SH2) J4.C J5.3 L10.2 L54.2 LB79.2 LB83.2 LED33.C OSC1.2(GND) OSC2.2(GND) OSC3.2(GND) OSC5.2(GND) OSC6.2(GND1) OSC6.4(GND2) OSC7.2(GND) OSCB1.2(GND1) OSCB1.4(GND2) P1.AA1(GND_AA1) P1.AA2(GND_AA2) P1.AA5(GND_AA5) P1.AA8(GND_AA8) P1.AA11(GND_AA11) P1.AA14(GND_AA14) P1.AA17(GND_AA17) P1.AB2(GND_AB2) P1.B2(GND_B2) P1.B5(GND_B5) P1.B8(GND_B8) P1.B11(GND_B11) P1.B14(GND_B14) P1.B17(GND_B17) P1.C21(GND_C21) P1.D18(GND_D18) P1.E1(GND_E1) P1.E2(GND_E2) P1.E7(GND_E7) P1.E19(GND_E19) P1.F3(GND_F3) P1.F9(GND_F9) P1.F11(GND_F11) P1.F13(GND_F13) P1.F15(GND_F15) P1.F21(GND_F21) P1.G1(GND_G1) P1.G2(GND_G2) P1.H5(GND_H5) P1.H11(GND_H11) P1.H18(GND_H18) P1.J1(GND_J1) P1.J2(GND_J2) P1.J6(GND_J6) P1.J8(GND_J8) P1.K5(GND_K5) P1.K7(GND_K7) P1.K9(GND_K9) P1.K11(GND_K11) P1.K15(GND_K15) P1.K21(GND_K21) P1.L1(GND_L1) P1.L2(GND_2) P1.L6(GND_L6) P1.L8(GND_L8) P1.L10(GND_L10) P1.L12(GND_12) P1.L18(GND_L18) P1.M3(GND_M3) P1.M5(GND_M5) P1.M9(GND_M9) P1.N1(GND_N1) P1.N2(GND_N2) P1.N4(GND_N4) P1.N6(GND_N6) P1.N10(GND_N10) P1.P9(GND_P9) P1.P11(GND_P11) P1.P16(GND_P16) P1.P18(GND_P18) P1.P21(GND_P21) P1.R1(GND_R1) P1.R2(GND_R2) P1.R6(GND_R6) P1.R12(GND_R12) P1.T4(GND_T4) P1.U1(GND_U1) P1.U2(GND_U2) P1.U3(GND_U3) P1.U10(GND_U10) P1.U17(GND_U17) P1.U21(GND_U21) P1.V5(GND_V5) P1.V8(GND_V8) P1.V11(GND_V11) P1.V14(GND_V14) P1.V19(GND_V19) P1.W1(GND_W1) P1.W2(GND_W2) P1.Y21(GND_Y21) Q1.S Q3.S Q4.S QB7.S R14.2 R15.2 R16.2 R18.2 R19.2 R41.2 R45.2 R52.1 R56.1 R57.1 R65.1 R67.2 R69.2 R70.2 R71.1 R73.1 R80.2 R96.1 R100.2 R108.2 R111.1 R117.1 R137.2 R139.2 R166.1 R167.1 R169.1 R185.1 R186.2 R190.1 R195.2 R237.1 R238.1 R256.1 R270.1 R288.2 R289.2 R300.2 R313.2 R317.2 R322.1 R324.2 R335.2 R337.2 R338.1 R350.1 R352.1 R357.1 R358.1 R359.1 R360.1 R377.2 R378.2 R390.2 R394.1 R395.2 R403.1 R404.1 R405.1 R428.2 R434.2 R439.2 R443.1 R449.1 R455.2 R456.2 R460.1 R464.1 R472.1 R479.1 R481.2 R482.2 R486.2 R488.2 R489.2 R495.1 R499.1 R500.1 R501.1 R502.2 R508.1 R509.1 R510.2 R514.1 R516.1 R519.1 R529.1 R530.2 R541.1 R545.1 R550.2 R551.1 R553.1 R561.1 R562.1 R564.1 R565.1 R571.2 R573.1 R574.1 R576.1 R582.2 R585.1 R593.2 R594.2 R596.1 R606.2 R607.1 R608.1 R613.1 R616.1 R617.2 R620.1 R625.2 R626.1 R629.2 R632.1 R637.2 R639.2 R640.2 R641.2 R642.1 R653.1 R659.1 R660.1 R663.2 R664.2 R672.1 R675.2 R677.1 R681.2 R682.2 R683.2 R685.2 R690.1 R693.1 R753.1 R764.1 R773.1 R795.1 R800.2 R808.1 R854.1 R856.1 R953.1 R1019.1 R1042.1 R1043.1 R1045.1 R1047.1 R1051.1 R1059.1 R1063.2 R1066.1 R1069.1 R1070.2 R1081.2 R1083.1 R1085.1 R1087.1 R1089.2 R1090.2 R1095.1 R1096.1 R1099.1 R1101.1 R1103.1 R1113.1 R1115.1 R1117.1 R1118.2 R1125.1 R1126.1 R1129.1 R1189.2 R1195.1 R1307.2 R1308.2 R1309.2 R1318.1 R1321.2 R1322.1 R1347.2 R1362.2 R1363.2 R1364.2 R1365.2 R1366.2 R1367.2 R1382.2 R1383.2 R1394.2 R1395.2 R1396.2 R1399.2 R1400.2 R1401.2 R1402.2 R1403.2 R1408.2 R1409.2 R1415.1 R1416.2 R1419.2 R1421.2 R1423.2 R1424.1 R1425.1 R1438.1 R1440.2 R1448.2 R1450.2 R1452.1 R1453.2 R1457.1 R1459.1 R1461.1 R1463.1 R1467.1 R1468.1 R1470.1 R1480.2 R1483.2 R1486.2 R1489.2 R1505.2 R1506.2 RB1.2 RB3.2 RB5.2 RB7.1 RB13.1 RB21.1 RB25.2 RB26.2 RB27.2 RB29.1 RB30.2 RB33.2 RB35.2 RB37.1 RB40.1 RB45.2 RB47.1 RB78.1 RB89.1 RB98.1 RB103.1 RB105.1 RB113.1 RB118.1 RB121.1 RB125.1 RB126.1 RB127.1 RB128.1 RB148.2 RB153.2 RB167.1 RB171.2 RB172.1 RB173.2 RB186.1 RB187.1 RB193.2 RB194.2 RB195.2 RB196.2 RB202.2 RB207.1 RB208.1 RB209.2 RB227.1 RB228.2 RB262.2 RB275.2 RB280.1 RB323.2 RB328.2 RB329.2 RB332.2 RB385.2 RB386.2 RB387.2 RB388.2 RB389.2 RB390.2 RB391.2 RB392.2 RB393.2 RB394.2 RB395.2 RB396.2 RB397.2 RB398.2 RB399.2 RB400.2 RB401.2 RB402.2 RB403.2 RB404.2 RB405.2 RB406.2 RB407.2 RB408.2 RB409.2 RB410.2 RB411.2 RB412.2 RB413.2 RB414.2 RB415.2 RB416.2 RB417.2 RB418.2 RB419.2 RB420.2 RB421.2 RB422.2 RB423.2 RB424.2 RB425.2 RB426.2 RB427.2 RB428.2 RB429.2 RB430.2 RB431.2 RB432.2 RB652.1 RB653.2 RB657.2 RB661.2 RB663.2 RB667.1 RB671.2 RB672.2 RB685.1 RB686.2 RB714.1 RB728.2 RB739.2 RB741.2 RB742.1 RB743.1 RB758.1 RB759.2 RB1226.2 RB1228.2 RB1233.1 RB1234.2 RB1252.1 RB1267.2 RB1269.2 RB1295.2 RB1306.1 RB1308.1 RJ1.C4 RJ1.C5 RJ1.F4 RJ1.F5 SW1.3 SW1.4 SWB1.2 SWB1.3 SWB1.4 SWB2.3 SWB2.4 U5.3(GND) U6.4(PGND) U6.8(GND) U6.11(PWPD) U7.8(DVSS1) U7.26(DVSS2) U7.43(DVSS3) U7.48(AVSS2) U7.49(AVSS1) U7.64(AVSS3) U7.G1(GND) U8.4(VSS) U9.A1(GNDIO_1) U9.A18(GNDIO_2) U9.B2(GNDIO_4) U9.B17(GNDIO_3) U9.G8(GNDINT_1) U9.H7(GNDINT_2) U9.H8(GNDIO_7) U9.H9(GNDIO_8) U9.H10(GNDIO_5) U9.H11(GNDIO_6) U9.J8(GNDINT_4) U9.J10(GNDINT_3) U9.K9(GNDINT_6) U9.K11(GNDINT_5) U9.L8(GNDIO_11) U9.L9(GNDIO_12) U9.L10(GNDIO_9) U9.L11(GNDIO_10) U9.L12(GNDINT_7) U9.M11(GNDINT_8) U9.U2(GNDIO_14) U9.U17(GNDIO_13) U9.V1(GNDIO_15) U9.V7(GNDIO_17) U9.V18(GNDIO_16) U10.12(GND) U14.A2(VSSQ1) U14.A8(VSSQ2) U14.B2(VSS1) U14.C9(VSSQ3) U14.D2(VSSQ4) U14.D8(VSSQ5) U14.E1(VSS2) U14.E3(VSSQ6) U14.E8(VSSQ7) U14.E9(VSS3) U14.F1(VSSQ8) U14.G8(VSS4) U14.H1(VSSQ9) U14.H9(VSSQ10) U14.K1(VSS5) U14.K9(VSS6) U14.M9(VSS7) U14.N1(VSS8) U14.T1(VSS9) U15.A2(VSSQ1) U15.A8(VSSQ2) U15.B2(VSS1) U15.C9(VSSQ3) U15.D2(VSSQ4) U15.D8(VSSQ5) U15.E1(VSS2) U15.E3(VSSQ6) U15.E8(VSSQ7) U15.E9(VSS3) U15.F1(VSSQ8) U15.G8(VSS4) U15.H1(VSSQ9) U15.H9(VSSQ10) U15.K1(VSS5) U15.K9(VSS6) U15.M9(VSS7) U15.N1(VSS8) U15.T1(VSS9) U16.A2(VSSQ1) U16.A8(VSSQ2) U16.B2(VSS1) U16.C9(VSSQ3) U16.D2(VSSQ4) U16.D8(VSSQ5) U16.E1(VSS2) U16.E3(VSSQ6) U16.E8(VSSQ7) U16.E9(VSS3) U16.F1(VSSQ8) U16.G8(VSS4) U16.H1(VSSQ9) U16.H9(VSSQ10) U16.K1(VSS5) U16.K9(VSS6) U16.M9(VSS7) U16.N1(VSS8) U16.T1(VSS9) U17.A2(VSSQ1) U17.A8(VSSQ2) U17.B2(VSS1) U17.C9(VSSQ3) U17.D2(VSSQ4) U17.D8(VSSQ5) U17.E1(VSS2) U17.E3(VSSQ6) U17.E8(VSSQ7) U17.E9(VSS3) U17.F1(VSSQ8) U17.G8(VSS4) U17.H1(VSSQ9) U17.H9(VSSQ10) U17.K1(VSS5) U17.K9(VSS6) U17.M9(VSS7) U17.N1(VSS8) U17.T1(VSS9) U18.4(GND) U19.2(GND) U20.10(GND) U21.8(GND) U22.4(GND) U23.12(GND) U23.G1 U24.11(TEST) U24.G1(VSS(FLAG)) U27.4(GND) U29.4(GND) U30.4(PGND_1) U30.13(PGND_2) U31.8(PGND) U31.G1(PAD) U32.2(PGND#1) U32.4(GND#2) U32.5(PGND#2) U32.6(PGND#3) U32.7(PGND#4) U32.8(PGND#5) U32.9(PGND#6) U32.10(PGND#7) U32.G1(PWRPD) U34.4(GND) U34.G1 U35.2(PGND#1) U35.4(GND#2) U35.5(PGND#2) U35.6(PGND#3) U35.7(PGND#4) U35.8(PGND#5) U35.9(PGND#6) U35.10(PGND#7) U35.G1(PWRPD) U36.1(GND) U36.G1 U37.4(GND) U38.3(PGND) U39.4(PGND_1) U39.13(PGND_2) U40.A5(SRD_AGND#7) U40.A9(SRD_AGND#8) U40.A13(SRD_AGND#1) U40.A17(SRD_AGND#2) U40.A21(SRD_AGND#3) U40.A25(SRD_AGND#4) U40.A29(SRD_AGND#5) U40.A33(SRD_AGND#6) U40.AA1(VSS#1) U40.AA4(VSS#13) U40.AA5(SRD_AGND#11) U40.AA6(SRD_AGND#12) U40.AA7(VSS#14) U40.AA10(VSS#2) U40.AA11(DDRC_AVSS) U40.AA13(VSS#3) U40.AA15(VSS#4) U40.AA17(VSS#5) U40.AA19(VSS#6) U40.AA21(VSS#7) U40.AA23(VSS#8) U40.AA25(VSS#9) U40.AA27(VSS#10) U40.AA28(SRD_AGND#9) U40.AA29(SRD_AGND#10) U40.AA31(UC_PLL_AGND) U40.AA32(VSS#11) U40.AA36(VSS#12) U40.AB10(VSS#15) U40.AB12(VSS#16) U40.AB14(VSS#17) U40.AB16(VSS#18) U40.AB18(VSS#19) U40.AB20(VSS#20) U40.AB22(VSS#21) U40.AB24(VSS#22) U40.AB26(VSS#23) U40.AB28(VSS#24) U40.AC3(VSS#32) U40.AC6(VSS#33) U40.AC9(VSS#34) U40.AC13(VSS#25) U40.AC15(VSS#26) U40.AC17(VSS#27) U40.AC21(VSS#28) U40.AC23(VSS#29) U40.AC25(VSS#30) U40.AC27(VSS#31) U40.AD1(VSS#35) U40.AD11(VSS#36) U40.AD12(VSS#37) U40.AD14(VSS#38) U40.AD16(VSS#39) U40.AD18(VSS#40) U40.AD20(VSS#41) U40.AD22(VSS#42) U40.AD24(VSS#43) U40.AD26(SYNCE_0_PLL_AGND) U40.AD28(VSS#44) U40.AE5(VSS#52) U40.AE8(VSS#53) U40.AE13(VSS#45) U40.AE15(VSS#46) U40.AE17(VSS#47) U40.AE19(VSS#48) U40.AE21(VSS#49) U40.AE23(VSS#50) U40.AE25(SYNCE_1_PLL_AGND) U40.AE31(VSS#51) U40.AF3(VSS#63) U40.AF12(VSS#54) U40.AF14(VSS#55) U40.AF16(VSS#56) U40.AF17(DDRB_AVSS) U40.AF18(VSS#57) U40.AF20(VSS#58) U40.AF22(VSS#59) U40.AF24(VSS#60) U40.AF26(VSS#61) U40.AF29(VSS#62) U40.AG1(VSS#64) U40.AG7(VSS#74) U40.AG10(VSS#65) U40.AG13(VSS#66) U40.AG15(VSS#67) U40.AG19(VSS#68) U40.AG22(VSS#69) U40.AG23(VSS#70) U40.AG25(VSS#71) U40.AG27(VSS#72) U40.AG34(VSS#73) U40.AH5(VSS#78) U40.AH20(VSS#75) U40.AH25(VSS#76) U40.AH26(DDRA_AVSS) U40.AH37(VSS#77) U40.AJ3(VSS#84) U40.AJ6(VSS#86) U40.AJ9(VSS#87) U40.AJ12(VSS#79) U40.AJ15(VSS#80) U40.AJ18(VSS#81) U40.AJ21(VSS#82) U40.AJ27(VSS#83) U40.AJ30(VSS#85) U40.AK1(VSS#88) U40.AL5(VSS#97) U40.AL8(VSS#98) U40.AL11(VSS#89) U40.AL14(VSS#90) U40.AL17(VSS#91) U40.AL20(VSS#92) U40.AL23(VSS#93) U40.AL26(VSS#94) U40.AL29(VSS#95) U40.AL32(VSS#96) U40.AM3(VSS#99) U40.AN1(VSS#100) U40.AN7(VSS#111) U40.AN10(VSS#101) U40.AN13(VSS#102) U40.AN16(VSS#103) U40.AN19(VSS#104) U40.AN22(VSS#105) U40.AN25(VSS#106) U40.AN28(VSS#107) U40.AN31(VSS#108) U40.AN34(VSS#109) U40.AN35(VSS#110) U40.AP5(VSS#112) U40.AR3(VSS#119) U40.AR6(VSS#124) U40.AR9(VSS#125) U40.AR12(VSS#113) U40.AR15(VSS#114) U40.AR18(VSS#115) U40.AR21(VSS#116) U40.AR24(VSS#117) U40.AR27(VSS#118) U40.AR30(VSS#120) U40.AR33(VSS#121) U40.AR36(VSS#122) U40.AR37(VSS#123) U40.AT1(VSS#126) U40.AU2(VSS#130) U40.AU5(VSS#137) U40.AU8(VSS#138) U40.AU11(VSS#127) U40.AU14(VSS#128) U40.AU17(VSS#129) U40.AU20(VSS#131) U40.AU23(VSS#132) U40.AU26(VSS#133) U40.AU29(VSS#134) U40.AU32(VSS#135) U40.AU35(VSS#136) U40.B1(SRD_AGND#13) U40.B5(SRD_AGND#21) U40.B9(SRD_AGND#22) U40.B13(SRD_AGND#14) U40.B17(SRD_AGND#15) U40.B21(SRD_AGND#16) U40.B25(SRD_AGND#17) U40.B29(SRD_AGND#18) U40.B33(SRD_AGND#19) U40.B37(SRD_AGND#20) U40.C4(SRD_AGND#31) U40.C8(SRD_AGND#32) U40.C12(SRD_AGND#23) U40.C16(SRD_AGND#24) U40.C20(SRD_AGND#25) U40.C24(SRD_AGND#26) U40.C25(SRD_AGND#27) U40.C26(SRD_AGND#28) U40.C30(SRD_AGND#29) U40.C34(SRD_AGND#30) U40.D4(SRD_AGND#40) U40.D8(SRD_AGND#41) U40.D12(SRD_AGND#33) U40.D16(SRD_AGND#34) U40.D20(SRD_AGND#35) U40.D24(SRD_AGND#36) U40.D26(SRD_AGND#37) U40.D30(SRD_AGND#38) U40.D34(SRD_AGND#39) U40.E1(SRD_AGND#42) U40.E2(SRD_AGND#53) U40.E3(SRD_AGND#64) U40.E4(SRD_AGND#73) U40.E5(SRD_AGND#74) U40.E6(SRD_AGND#75) U40.E7(SRD_AGND#76) U40.E8(SRD_AGND#77) U40.E9(SRD_AGND#78) U40.E10(SRD_AGND#43) U40.E11(SRD_AGND#44) U40.E12(SRD_AGND#45) U40.E13(SRD_AGND#46) U40.E14(SRD_AGND#47) U40.E15(SRD_AGND#48) U40.E16(SRD_AGND#49) U40.E17(SRD_AGND#50) U40.E18(SRD_AGND#51) U40.E19(SRD_AGND#52) U40.E20(SRD_AGND#54) U40.E21(SRD_AGND#55) U40.E22(SRD_AGND#56) U40.E23(SRD_AGND#57) U40.E24(SRD_AGND#58) U40.E25(SRD_AGND#59) U40.E26(SRD_AGND#60) U40.E27(SRD_AGND#61) U40.E28(SRD_AGND#62) U40.E29(SRD_AGND#63) U40.E30(SRD_AGND#65) U40.E31(SRD_AGND#66) U40.E32(SRD_AGND#67) U40.E33(SRD_AGND#68) U40.E34(SRD_AGND#69) U40.E35(SRD_AGND#70) U40.E36(SRD_AGND#71) U40.E37(SRD_AGND#72) U40.F1(SRD_AGND#79) U40.F5(SRD_AGND#87) U40.F9(SRD_AGND#88) U40.F13(SRD_AGND#80) U40.F17(SRD_AGND#81) U40.F21(SRD_AGND#82) U40.F25(SRD_AGND#83) U40.F29(SRD_AGND#84) U40.F33(SRD_AGND#85) U40.F37(SRD_AGND#86) U40.G1(SRD_AGND#89) U40.G5(SRD_AGND#97) U40.G9(SRD_AGND#98) U40.G13(SRD_AGND#90) U40.G17(SRD_AGND#91) U40.G21(SRD_AGND#92) U40.G25(SRD_AGND#93) U40.G29(SRD_AGND#94) U40.G33(SRD_AGND#95) U40.G37(SRD_AGND#96) U40.H4(SRD_AGND#118) U40.H8(SRD_AGND#119) U40.H9(SRD_AGND#120) U40.H10(SRD_AGND#99) U40.H11(SRD_AGND#100) U40.H12(SRD_AGND#101) U40.H13(SRD_AGND#102) U40.H14(SRD_AGND#103) U40.H15(SRD_AGND#104) U40.H16(SRD_AGND#105) U40.H17(SRD_AGND#106) U40.H18(SRD_AGND#107) U40.H19(SRD_AGND#108) U40.H20(SRD_AGND#109) U40.H21(SRD_AGND#110) U40.H22(SRD_AGND#111) U40.H23(SRD_AGND#112) U40.H24(SRD_AGND#113) U40.H25(SRD_AGND#114) U40.H26(SRD_AGND#115) U40.H30(SRD_AGND#116) U40.H34(SRD_AGND#117) U40.J4(SRD_AGND#128) U40.J8(SRD_AGND#129) U40.J12(SRD_AGND#121) U40.J16(SRD_AGND#122) U40.J20(SRD_AGND#123) U40.J24(SRD_AGND#124) U40.J26(SRD_AGND#125) U40.J30(SRD_AGND#126) U40.J34(SRD_AGND#127) U40.K1(SRD_AGND#130) U40.K2(SRD_AGND#133) U40.K3(SRD_AGND#140) U40.K4(SRD_AGND#149) U40.K5(SRD_AGND#150) U40.K6(SRD_AGND#151) U40.K7(SRD_AGND#152) U40.K8(SRD_AGND#153) U40.K12(SRD_AGND#131) U40.K16(SRD_AGND#132) U40.K20(SRD_AGND#134) U40.K24(SRD_AGND#135) U40.K26(SRD_AGND#136) U40.K27(SRD_AGND#137) U40.K28(SRD_AGND#138) U40.K29(SRD_AGND#139) U40.K30(SRD_AGND#141) U40.K31(SRD_AGND#142) U40.K32(SRD_AGND#143) U40.K33(SRD_AGND#144) U40.K34(SRD_AGND#145) U40.K35(SRD_AGND#146) U40.K36(SRD_AGND#147) U40.K37(SRD_AGND#148) U40.L1(SRD_AGND#154) U40.L2(SRD_AGND#165) U40.L5(SRD_AGND#179) U40.L6(SRD_AGND#180) U40.L7(SRD_AGND#181) U40.L8(SRD_AGND#182) U40.L9(SRD_AGND#183) U40.L10(SRD_AGND#155) U40.L11(SRD_AGND#156) U40.L12(SRD_AGND#157) U40.L13(SRD_AGND#158) U40.L14(SRD_AGND#159) U40.L15(SRD_AGND#160) U40.L16(SRD_AGND#161) U40.L17(SRD_AGND#162) U40.L18(SRD_AGND#163) U40.L19(SRD_AGND#164) U40.L20(SRD_AGND#166) U40.L21(SRD_AGND#167) U40.L22(SRD_AGND#168) U40.L23(SRD_AGND#169) U40.L24(SRD_AGND#170) U40.L25(SRD_AGND#171) U40.L26(SRD_AGND#172) U40.L28(NIFE_SRD_REFCLK_Q05_N) U40.L29(NIFE_SRD_REFCLK_Q05_P) U40.L30(SRD_AGND#173) U40.L31(SRD_AGND#174) U40.L32(SRD_AGND#175) U40.L33(SRD_AGND#176) U40.L36(SRD_AGND#177) U40.L37(SRD_AGND#178) U40.M3(SRD_AGND#191) U40.M4(SRD_AGND#196) U40.M5(SRD_AGND#197) U40.M8(SRD_AGND#198) U40.M9(SRD_AGND#199) U40.M10(SRD_AGND#184) U40.M14(SRD_AGND#185) U40.M15(NIF_SRD_REFCLK_Q00_N) U40.M16(NIF_SRD_REFCLK_Q00_P) U40.M21(SRD_AGND#186) U40.M24(SRD_AGND#187) U40.M27(SRD_AGND#188) U40.M28(SRD_AGND#189) U40.M29(SRD_AGND#190) U40.M30(SRD_AGND#192) U40.M33(SRD_AGND#193) U40.M34(SRD_AGND#194) U40.M35(SRD_AGND#195) U40.N5(SRD_AGND#211) U40.N10(SRD_AGND#200) U40.N12(SRD_AGND#201) U40.N13(SRD_AGND#202) U40.N17(SRD_AGND#203) U40.N18(SRD_AGND#204) U40.N19(SRD_AGND#205) U40.N20(SRD_AGND#206) U40.N22(NIF_LCPLL_AGND) U40.N25(SRD_AGND#207) U40.N26(SRD_AGND#208) U40.N28(SRD_AGND#209) U40.N33(SRD_AGND#210) U40.P5(SRD_AGND#215) U40.P10(SRD_AGND#212) U40.P12(VSS#139) U40.P14(VSS#140) U40.P16(VSS#141) U40.P18(VSS#142) U40.P20(VSS#143) U40.P24(VSS#144) U40.P26(VSS#145) U40.P28(SRD_AGND#213) U40.P33(SRD_AGND#214) U40.R1(SRD_AGND#216) U40.R2(SRD_AGND#218) U40.R5(SRD_AGND#225) U40.R6(SRD_AGND#226) U40.R7(SRD_AGND#227) U40.R10(SRD_AGND#217) U40.R11(VSS#146) U40.R13(VSS#147) U40.R15(VSS#148) U40.R17(VSS#149) U40.R19(VSS#150) U40.R21(VSS#151) U40.R23(VSS#152) U40.R25(VSS#153) U40.R27(VSS#154) U40.R28(SRD_AGND#219) U40.R31(SRD_AGND#220) U40.R32(SRD_AGND#221) U40.R33(SRD_AGND#222) U40.R36(SRD_AGND#223) U40.R37(SRD_AGND#224) U40.T3(SRD_AGND#231) U40.T4(SRD_AGND#237) U40.T5(SRD_AGND#238) U40.T8(SRD_AGND#239) U40.T9(SRD_AGND#240) U40.T10(SRD_AGND#228) U40.T12(VSS#155) U40.T14(VSS#156) U40.T16(VSS#157) U40.T18(VSS#158) U40.T20(VSS#159) U40.T22(VSS#160) U40.T24(VSS#161) U40.T25(VSS#162) U40.T26(VSS#163) U40.T28(SRD_AGND#229) U40.T29(SRD_AGND#230) U40.T30(SRD_AGND#232) U40.T31(SRD_AGND#233) U40.T33(SRD_AGND#234) U40.T34(SRD_AGND#235) U40.T35(SRD_AGND#236) U40.U5(SRD_AGND#243) U40.U10(SRD_AGND#241) U40.U11(VSS#164) U40.U14(NIFE_LCPLL1_AGND) U40.U15(VSS#165) U40.U17(VSS#166) U40.U19(VSS#167) U40.U21(VSS#168) U40.U23(VSS#169) U40.U27(VSS#170) U40.U33(SRD_AGND#242) U40.V5(SRD_AGND#246) U40.V10(SRD_AGND#244) U40.V14(VSS#171) U40.V16(VSS#172) U40.V20(VSS#173) U40.V22(VSS#174) U40.V24(NIFE_LCPLL0_AGND) U40.V26(VSS#175) U40.V33(SRD_AGND#245) U40.W1(SRD_AGND#247) U40.W2(SRD_AGND#249) U40.W5(SRD_AGND#253) U40.W6(SRD_AGND#254) U40.W7(SRD_AGND#255) U40.W10(SRD_AGND#248) U40.W11(VSS#176) U40.W15(VSS#177) U40.W17(C_PLL_AGND) U40.W21(VSS#178) U40.W23(VSS#179) U40.W27(VSS#180) U40.W28(SRD_AGND#250) U40.W29(SRD_AGND#251) U40.W36(SRD_AGND#252) U40.Y1(SRD_AGND#256) U40.Y2(SRD_AGND#258) U40.Y3(SRD_AGND#261) U40.Y4(SRD_AGND#267) U40.Y5(SRD_AGND#268) U40.Y7(SRD_AGND#269) U40.Y8(SRD_AGND#270) U40.Y9(SRD_AGND#271) U40.Y10(SRD_AGND#257) U40.Y12(VSS#181) U40.Y14(VSS#182) U40.Y16(VSS#183) U40.Y20(VSS#184) U40.Y22(VSS#185) U40.Y24(VSS#186) U40.Y26(VSS#187) U40.Y27(SRD_AGND#259) U40.Y29(SRD_AGND#260) U40.Y30(VSS#188) U40.Y33(SRD_AGND#262) U40.Y34(SRD_AGND#263) U40.Y35(SRD_AGND#264) U40.Y36(SRD_AGND#265) U40.Y37(SRD_AGND#266) U41.3(PGND) U42.3(PGND) U44.2(PGND#1) U44.4(GND#2) U44.5(PGND#2) U44.6(PGND#3) U44.7(PGND#4) U44.8(PGND#5) U44.9(PGND#6) U44.10(PGND#7) U44.G1(PWRPD) U47.2(NC1) U47.3(NC2) U47.4(NC3) U47.12(GND) U47.13(NC4) U47.14(NC5) U47.17(NC6) U47.G1 U48.8(PGND) U48.G1(PAD) U50.5(REF 2_1) U50.8(REF 2_2) U51.8(GND) U52.D4(VSS#1) U52.D5(VSS#2) U52.D6(VSS#3) U52.E4(VSS#4) U52.E5(VSS#5) U52.E6(VSS#6) U52.F1(TXD#0) U52.F4(VSS#7) U52.F5(VSS#8) U52.F6(VSS#9) U52.G2(TXD#1) U52.G3(TXD#2) U52.G4(VSS#10) U52.G5(VSS#11) U52.G6(VSS#12) U52.H1(TXD#4) U52.H2(TXD#3) U52.H3(TXD#5) U52.H4(VSS#13) U52.H5(VSS#14) U52.H6(VSS#15) U52.H7(VSSC) U52.J1(TXD#6) U52.J2(TXD#7) U52.J4(VSS#16) U52.J5(VSS#17) U52.J6(VSS#18) U52.K4(VSS#19) U52.K5(VSS#20) U52.K6(VSS#21) U52.L5(VSS#22) U52.L6(VSS#23) U55.3(GND1) U55.8(GND2) U55.G1 U55.G2 U55.G3 U56.3(GND1) U56.8(GND2) U56.G1 U56.G2 U56.G3 U66.4(GND1) U66.G1(GND PAD) U68.2(DGND_1) U68.6(TGND) U68.7(RGND) U68.12(AGND) U68.15(PLLGND_1) U68.16(PLLGND_2) U68.27(DGND_2) U68.33(DGND_3) U68.62(DGND_4) U68.69(DGND_5) U68.70(DGND_6) U68.71(DGND_7) U69.1(VSS_1) U69.4(VSS_2) U69.7(VSS_3) U69.13(VSS_4) U69.16(VSS_5) U69.19(VSS_6) U69.20(VSS_7) U69.23(VSS_8) U69.26(VSS_9) U69.32(VSS_10) U69.35(VSS_11) U69.38(VSS_12) U71.1(GND1) U71.5(GND2) U71.10(AGND) U71.11(GND3) U71.13(TEST) U71.15(GND4) U71.25(GND5) U71.35(GND6) U71.47(GND7) U71.51(GND8) U72.4(GND-1) U72.11(GND-2) U72.18(GND-3) U72.25(GND4) U73.3(GND1) U73.8(GND2) U73.G1 U73.G2 U73.G3 U75.3(GND1) U75.8(GND2) U75.G1 U75.G2 U75.G3 U77.G1(VSS) U79.1(GND) U79.17(GNDPAD) U80.10(GND) U81.3(GND) U85.5(GND) U86.5(GND) U87.5(GND) U88.5(GND) UB1.1(VEE_1) UB1.7(VEE_2) UB1.11(VEE_3) UB1.15(VEE_4) UB1.18(VEE_5) UB1.24(VEE_6) UB1.27(VEE_7) UB1.30(VEE_8) UB1.G1(EPAD) UB2.3(GND) UB5.A2(VSSQ1) UB5.A8(VSSQ2) UB5.B2(VSS1) UB5.C9(VSSQ3) UB5.D2(VSSQ4) UB5.D8(VSSQ5) UB5.E1(VSS2) UB5.E3(VSSQ6) UB5.E8(VSSQ7) UB5.E9(VSS3) UB5.F1(VSSQ8) UB5.G8(VSS4) UB5.H1(VSSQ9) UB5.H9(VSSQ10) UB5.K1(VSS5) UB5.K9(VSS6) UB5.M9(VSS7) UB5.N1(VSS8) UB5.T1(VSS9) UB6.A2(VSSQ1) UB6.A8(VSSQ2) UB6.B2(VSS1) UB6.C9(VSSQ3) UB6.D2(VSSQ4) UB6.D8(VSSQ5) UB6.E1(VSS2) UB6.E3(VSSQ6) UB6.E8(VSSQ7) UB6.E9(VSS3) UB6.F1(VSSQ8) UB6.G8(VSS4) UB6.H1(VSSQ9) UB6.H9(VSSQ10) UB6.K1(VSS5) UB6.K9(VSS6) UB6.M9(VSS7) UB6.N1(VSS8) UB6.T1(VSS9) UB8.12(GND) UB9.15(GND) UB12.12(GND) UB13.12(GND) UB14.5(GND) UB14.G1(G_PAD) UB16.12(GND) UB17.12(GND) UB70.3(GND) UB71.3(GND) X1.2(GND1) X1.4(GND2)
GND_USB: CONNB2.4(GND) LB83.1 LB84.2
GND_VCC1P2: QB4.S QB5.S R569.1 R571.1 R635.2 R649.2 U35.1(GND#1)
GND_VCC1V: Q2.S Q5.S R782.2 R784.1 R785.2 RB228.1 U44.1(GND#1)
GND_VCC1V_RH: Q2.D R538.2
GND_VCC1V_RH_R: R537.1 R538.1
GND_VCC1V_RL: Q5.D R521.2
GND_VCC1V_RL_R: R520.1 R521.1
GND_VCC2P5: QB2.S QB6.S R489.1 R507.2 R547.1 R588.2 U32.1(GND#1)
GND_XO: C484.1 OCXO1.7(GND) OCXO2.3(GND) R800.1
GNDP: CONN53_PF.G1(GND1) CONN53_PF.G2(GND2) CONN53_PF.G3(GND3) CONN53_PF.G22(GND22) CONN53_PF.G23(GND23) CONN54_PF.G1(GND1) CONN54_PF.G2(GND2) CONN54_PF.G3(GND3) CONN54_PF.G22(GND22) CONN54_PF.G23(GND23) CONN54_PF.G24(GND24) CONN54_PF.G37(GND37) CONN54_PF.G38(GND38) CONN54_PF.G39(GND39) CONN54_PF.G52(GND52) CONN54_PF.G53(GND53) CONN54_PF.G54(GND54) CONN54_PF.G67(GND67) CONN54_PF.G68(GND68) CONN54_PF.G69(GND69) CONN54_PF.G82(GND82) CONN54_PF.G83(GND83) CONN54_PF.G84(GND84) CONN54_PF.G97(GND97) CONN54_PF.G98(GND98) CONN54_PF.G99(GND99) CONN55_PF.G1(GND1) CONN55_PF.G2(GND2) CONN55_PF.G3(GND3) CONN55_PF.G22(GND22) CONN55_PF.G23(GND23) CONN55_PF.G24(GND24) CONN55_PF.G37(GND37) CONN55_PF.G38(GND38) CONN55_PF.G39(GND39) CONN55_PF.G52(GND52) CONN55_PF.G53(GND53) CONN55_PF.G54(GND54) CONN55_PF.G67(GND67) CONN55_PF.G68(GND68) CONN55_PF.G69(GND69) CONN55_PF.G82(GND82) CONN55_PF.G83(GND83) CONN55_PF.G84(GND84) CONN55_PF.G97(GND97) CONN55_PF.G98(GND98) CONN55_PF.G99(GND99) CONNB2.G1 CONNB2.G2 H14.1 H14.2 H14.3 H14.4 H14.5 H14.6 H14.7 H14.8 J1_PF.1(GND_1) J1_PF.2(GND_2) J1_PF.3(GND_3) J1_PF.4(GND_4) J1_PF.5(GND_5) J1_PF.11(GND_11) J1_PF.12(GND_12) RJ1.G1 RJ1.G2 RJ1.G3 RJ1.G6 RJ1.G7 RJ1.G8
V0P6_VTT_VIN: C23.1 C32.1 R48.2 R55.2 R58.2 U6.10(VIN)
VBUS_5V: CB962.2 CB972.A CB974.1 CONNB2.1(VBUS) LB82.2 LB85.2
VCC1V0_ADDR: R578.2 R579.1 U33.28(ADDR-TRISE)
VCC1V0_COMP: C331.1 R643.2 U33.11(COMP)
VCC1V0_COMP_R: C335.1 R643.1
VCC1V0_CSP1: U33.3(CSP1) U39.1(IOUT)
VCC1V0_CSP2: U30.1(IOUT) U33.4(CSP2)
VCC1V0_CSP3: R577.1 U33.5(CSP3)
VCC1V0_CSP4: R589.1 U33.6(CSP4)
VCC1V0_IMAX: R531.1 R532.1 U33.32(F-IMAX)
VCC1V0_IMON: CB404.1 RB176.2 U33.2(IMON)
VCC1V0_ISUM: R644.2 U33.12(ISUM)
VCC1V0_O-USR: R525.2 R554.2 U33.30(O-USR)
