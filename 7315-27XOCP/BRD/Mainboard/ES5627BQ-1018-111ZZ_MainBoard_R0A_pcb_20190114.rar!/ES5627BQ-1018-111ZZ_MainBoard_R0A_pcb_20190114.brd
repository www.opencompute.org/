# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Nets (continued)
VCC1V0_OCP: R559.1 R560.1 U33.1(OCL-R)
VCC1V0_PG: R646.1 TPB38.1 U33.18(VR_RDY)
VCC1V0_PMB_ALERT_N: R599.1 U33.25(PMB_ALERT#)
VCC1V0_PMB_CLK: RB17.1 RB18.2 RB718.1 U33.24(PMB_CLK)
VCC1V0_PMB_CLK_R: CONN2.3 RB18.1
VCC1V0_PMB_DIO: RB15.2 RB16.1 RB724.1 U33.26(PMB_DIO)
VCC1V0_PMB_DIO_R: CONN2.1 RB15.1
VCC1V0_PWM1: U33.38(PWM1) U39.12(PWM)
VCC1V0_PWM2: U30.12(PWM) U33.37(PWM2)
VCC1V0_RESET#: R628.1 U33.21(RESET#)
VCC1V0_SLEW: R567.2 R568.1 U33.29(SLEW-MODE)
VCC1V0_TMAX: R535.2 R536.1 U33.31(VBOOT)
VCC1V0_TSENSE: C274.1 C291.1 C340.1 R533.2 U30.11(TAO) U33.40(TSEN) U39.11(TAO)
VCC1V0_V3R3: C339.1 R577.2 R589.2 R628.2 R665.2
VCC1V0_V3R3_O: C337.1 R665.1 U33.14(V3R3)
VCC1V0_V5: C352.1 R645.1 U33.15(V5)
VCC1V0_V12: C338.1 R666.2 U33.16(VIN)
VCC1V0_VR_FAULT_N: R590.1 U33.27(VR_FAULT#)
VCC1V0_VREF: CB348.1 CB527.1 R636.2 U30.2(REFIN) U39.2(REFIN)
VCC1V0_VREF13: C331.2 C335.2 C336.1 R525.1 R532.2 R536.2 R559.2 R568.2 R579.2 R636.1 R644.1 U33.13(VREF)
VCC1V0_VRHOT_N: R647.1 U33.19(VR_HOT#)
VCC1V0_VSN: R614.2 U33.10(VSN)
VCC1V0_VSP: R605.2 U33.9(VSP)
VCC1V0_VSW6_5: CB578.1 L31.1 U39.6(VSW)
VCC1V0_VSW6_5_C: CB578.2 RB202.1
VCC1V0_VSW6_6: CB388.1 L23.1 U30.6(VSW)
VCC1V0_VSW6_6_C: CB388.2 RB173.1
VCC1V0_VSW6_VIN: C307.2 C318.2 C392.2 C405.2 CB366.2 CB413.2 CB550.2 CB618.2 L92.1 L93.1 U30.7(VIN) U39.7(VIN)
VCC1V2_BST_C: C305.1 R566.2
VCC1V2_EN: CB487.1 R592.2 RB187.2 U35.36(EN)
VCC1V2_LL: L19.1 R566.1 RB174.1 RB183.2 U35.16(LL#1) U35.17(LL#2) U35.18(LL#3) U35.19(LL#4) U35.20(LL#5) U35.21(LL#6) U35.22(LL#7) U35.23(LL#8) U35.24(LL#9) U35.25(LL#10) U35.26(LL#11) U35.27(LL#12) U35.28(LL#13)
VCC1V2_LL_R: CB408.2 CB500.2 RB174.2
VCC1V2_MODE: R660.2 R669.1 U35.39(MODE)
VCC1V2_PGOOD: CONN34.1 R570.1 R669.2 U35.32(PGOOD)
VCC1V2_RF: R649.1 U35.38(RF)
VCC1V2_TAP: CB456.1 RB183.1
VCC1V2_TRIP: R569.2 U35.35(TRIP)
VCC1V2_VBST: C305.2 U35.30(VBST)
VCC1V2_VDD: C357.2 R686.2 U35.40(VDD)
VCC1V2_VFB: CB500.1 R602.2 R612.2 R627.2 R635.1 U35.37(VFB)
VCC1V2_VFB_H: R611.2 R612.1
VCC1V2_VFB_L: R601.2 R602.1
VCC1V2_VIN: C351.1 C365.2 C380.2 CB545.1 CB570.2 CB594.2 L36.1 U35.11(VIN#1) U35.12(VIN#2) U35.13(VIN#3) U35.14(VIN#4) U35.15(VIN#5)
VCC1V2_VREG: C358.2 R570.2 U35.3(VREG)
VCC1V_ENABLE: CB757.1 R779.2 RB227.2 U44.36(EN)
VCC1V_FB: CB776.1 R520.2 R537.2 R782.1 R791.2 U44.37(VFB)
VCC1V_FB_R_R: R791.1 R792.2
VCC1V_LL: L43.2 R746.1 RB214.2 RB218.1 U44.16(LL#1) U44.17(LL#2) U44.18(LL#3) U44.19(LL#4) U44.20(LL#5) U44.21(LL#6) U44.22(LL#7) U44.23(LL#8) U44.24(LL#9) U44.25(LL#10) U44.26(LL#11) U44.27(LL#12) U44.28(LL#13)
VCC1V_LL_C: C448.1 R746.2
VCC1V_LL_R: CB686.2 CB776.2 RB218.2
VCC1V_LL_SNUBBER: CB731.1 RB214.1
VCC1V_MODE: R773.2 R783.1 U44.39(MODE)
VCC1V_PGOOD: CONN46.1 R758.1 R783.2 U44.32(PGOOD)
VCC1V_RF: R785.1 U44.38(RF)
VCC1V_TRIP: R784.2 U44.35(TRIP)
VCC1V_VBST: C448.2 U44.30(VBST)
VCC1V_VREG: C447.1 R758.2 U44.3(VREG)
VCC2V5_EN: CB400.1 RB167.2 RB168.2 U32.36(EN)
VCC2V5_LL: L28.2 R610.2 RB181.1 RB189.2 U32.16(LL#1) U32.17(LL#2) U32.18(LL#3) U32.19(LL#4) U32.20(LL#5) U32.21(LL#6) U32.22(LL#7) U32.23(LL#8) U32.24(LL#9) U32.25(LL#10) U32.26(LL#11) U32.27(LL#12) U32.28(LL#13)
VCC2V5_LL_R: C306.1 CB509.2 RB189.1
VCC2V5_MODE: R603.1 R616.2 U32.39(MODE)
VCC2V5_PGOOD: CONN31.1 R603.2 RB159.2 U32.32(PGOOD)
VCC2V5_RF: R507.1 U32.38(RF)
VCC2V5_TRIP: R588.1 U32.35(TRIP)
VCC2V5_VDD: C279.1 R490.2 U32.40(VDD)
VCC2V5_VFB: C306.2 R547.2 R558.2 R780.2 R781.2 U32.37(VFB)
VCC2V5_VFB_H: R781.1 RB233.2
VCC2V5_VFB_L: R780.1 RB232.2
VCC3V3_PCH_DRVH: D3.C R623.2 U31.13(DRVH)
VCC3V3_PCH_DRVH_A_R: D3.A R623.1 U38.1(TG)
VCC3V3_PCH_DRVL: R622.2 U31.11(DRVL)
VCC3V3_PCH_DRVL_A_R: R622.1 U38.4(BG)
VCC3V3_PCH_EN_R: CB383.1 R499.2 RB155.1 U31.2(EN)
VCC3V3_PCH_MODE: R504.2 R513.1 U31.5(MODE)
VCC3V3_PCH_RF: R512.1 U31.4(RF)
VCC3V3_PCH_SW: C310.2 L29.1 RB188.1 RB191.2 U31.12(SW) U38.5(VSW)
VCC3V3_PCH_SW_C: CB584.1 RB191.1
VCC3V3_PCH_TRIP: R492.1 U31.1(TRIP)
VCC3V3_PCH_VBST: R546.2 U31.14(VBST)
VCC3V3_PCH_VBST_R: C310.1 R546.1
VCC3V3_PCH_VFB: C275.1 R497.2 R498.2 U31.3(VFB)
VCC3V3_PCH_VFB_S: CB522.1 R496.1 R497.1
VCC3V3_PCH_VIN: C362.2 C363.2 C364.2 C376.1 CB561.2 CB562.2 CB563.2 CB579.1 L26.1 L27.1 U38.2(VIN)
VCC3V3_PCH_VREG_VDRV: R587.1 U31.10(VDRV)
VCC3V3_PCH_VREG_VREG: C309.1 R522.1 R587.2 U31.9(VREG)
VCC3V3_PGOOD: CONN13.1 R513.2 R522.2 U31.16(PGOOD)
VCC3V3_TAP: C275.2 CB522.2 RB188.2
VCC5P0: C256.1 C257.1 C261.1 C264.1 C302.1 C317.1 CONN24.1 FB12.1 L21.2 L24.1 LEDB12.A R4.1 R645.2 R678.2 R1301.1 R1302.1 R1303.1 RB154.2 RB190.2
VCC5P0_BODE: C361.1 R667.2 R678.1
VCC5P0_MON: C19.1 R4.2 R15.1 U7.4(MON4)
VCC5P0_VIN: C298.1 C311.1 C312.1 L22.1 U34.2(IN)
VCC5V0_VDD5_5: CB572.2 RB190.1 RB192.1 U39.5(VDD)
VCC5V0_VDD5_6: CB381.2 RB154.1 RB162.1 U30.5(VDD)
VCC5V_STBY: C844.1 C845.1 C846.1 CB1102.1 FB12.2 J2.B84(VCC_5V_SBY1) J2.B85(VCC_5V_SBY2) J2.B86(VCC_5V_SBY3) J2.B87(VCC_5V_SBY4)
VCC12: C44.2 C489.2 CB4.1 CB24.2 CB31.1 CONN6.3 CONN6.4 CONN6.15 CONN6.16 FB17.1 L20.2 L26.2 L27.2 L36.2 L37.2 L38.2 L40.2 L92.2 L93.2 R6.1 R490.1 R556.1 R666.1 R686.1 R765.1 R797.1
VCC12_MON: C21.1 R6.2 R18.1 U7.2(MON2)
VCC12V_53315_VDD: C446.1 R765.2 U44.40(VDD)
VCC12V_53315_VIN: C408.2 C409.2 C411.1 C429.2 C430.2 CB654.1 L40.1 U44.11(VIN#1) U44.12(VIN#2) U44.13(VIN#3) U44.14(VIN#4) U44.15(VIN#5)
VCC12V_STBY: C847.A C848.2 C849.1 C850.1 C851.2 C852.A FB17.2 J2.A104(VCC_12V_1) J2.A105(VCC_12V_2) J2.A106(VCC_12V_3) J2.A107(VCC_12V_4) J2.A108(VCC_12V_5) J2.A109(VCC_12V_6) J2.B104(VCC_12V_7) J2.B105(VCC_12V_8) J2.B106(VCC_12V_9) J2.B107(VCC_12V_10) J2.B108(VCC_12V_11) J2.B109(VCC_12V_12) J2.C104(VCC_12V_13) J2.C105(VCC_12V_14) J2.C106(VCC_12V_15) J2.C107(VCC_12V_16) J2.C108(VCC_12V_17) J2.C109(VCC_12V_18) J2.D104(VCC_12V_19) J2.D105(VCC_12V_20) J2.D106(VCC_12V_21) J2.D107(VCC_12V_22) J2.D108(VCC_12V_23) J2.D109(VCC_12V_24)
VCC33_GPS: C464.1 C465.1 C466.1 CONN44.2 L49.2
VCC33_GPS_ANT: C468.1 C469.1 C470.1 L50.2 R766.2
VCC_CLKIN_2V5: CB1178.1 CB1179.1 CB1180.1 LB109.2 P1.H10(VCC_CLKIN8A_H10) P1.N12(VCC_CLKIN3A_N12) P1.P7(VCC_CLKIN3B_P7)
VCC_GPS_ANT: CONN44.1 R754.1 R766.1
VCCA_H_GXB_2V5: CB1152.1 CB1153.1 CB1154.1 CB1155.1 CB1156.1 LB107.2 P1.H3(VCCH_GXB_H3) P1.J3(VCCA_GXB_J3) P1.P3(VCCH_GXB_P3) P1.R3(VCCA_GXB_R3) P1.W3(VCCA_GXB_W3)
VCCD_PLL_1V2: CB1120.1 CB1121.1 CB1122.1 CB1123.1 CB1124.1 CB1146.1 LB104.2 P1.E18(VCCD_PLL_E18) P1.G3(VCCD_PLL_G3) P1.M4(VCCD_PLL_M4) P1.R4(VCCD_PLL_R4) P1.U4(VCCD_PLL_U4) P1.V18(VCCD_PLL_V18)
VCCL_GXB_1V2: CB1147.1 CB1148.1 CB1149.1 CB1150.1 CB1151.1 LB106.2 P1.K3(VCCL_GXB_K3) P1.L3(VCCL_GXB_L3) P1.N3(VCCL_GXB_N3) P1.T3(VCCL_GXB_T3) P1.V3(VCCL_GXB_V3)
VDD0P6: C43.1 C54.1 C63.2 C64.2 C73.1 C74.2 C75.2 C76.1 C77.1 C78.2 C79.1 C80.1 C81.1 C82.1 C84.2 C85.2 C86.1 C87.1 C88.2 C89.1 C90.1 C91.1 C92.1 C93.1 C94.1 C95.1 C96.1 C102.1 C113.1 C119.2 C126.1 C130.1 C142.1 C164.1 CB52.1 CB53.1 CB54.1 CB55.1 CB56.1 CB57.1 CB58.2 CB59.1 CB60.2 CB61.1 CB62.1 CB63.1 CB64.2 CB65.1 CB66.1 CB67.2 CB68.2 CB69.1 CB70.1 CB71.2 CB73.1 CB74.2 CB75.1 CB76.1 CB77.1 CB78.2 CB79.1 CB80.2 CB81.1 CB82.1 CB83.1 CB84.1 CB85.2 CB86.2 CB87.1 CB110.1 CB125.1 CB135.2 CB156.2 CB166.2 CB176.1 CB202.1 CONN8.1 R53.2 R140.1 R141.1 R142.1 R143.1 R144.1 R145.1 R146.1 R147.1 R148.1 R149.1 R150.1 R151.1 R152.1 R153.1 R154.1 R155.1 R156.1 R157.1 R158.1 R163.1 R179.1 R187.1 R197.1 R209.1 R221.1 R226.1 R243.1 R255.1 R267.1 R274.1 R292.1 R305.1 R1019.2 RB48.1 RB49.1 RB50.1 RB51.1 RB52.1 RB53.1 RB54.1 RB55.1 RB56.1 RB57.1 RB58.1 RB59.1 RB60.1 RB61.1 RB62.1 RB63.1 RB64.1 RB65.1 RB66.1 RB67.1 RB68.1 RB69.1 RB70.1 RB71.1 RB72.1 RB73.1 RB74.1 RB75.1 RB76.1 RB77.1 RB79.1 RB80.1 RB81.1 RB82.1 RB83.1 RB85.1 RB86.1 RB90.1 RB91.1 RB92.1 RB95.1 RB96.1 RB99.1 RB100.1 RB101.1 RB102.1 RB107.1 RB110.1 RB111.1 RB112.1 RB115.1 RB116.1 U6.3(VO) U6.5(VOSNS)
VDD0P6_MON: C35.1 R53.1 U7.62(MON12)
VDD0P6_PGOOD: CONN3.1 R58.1 U6.9(PGOOD)
VDD1P0: C314.A C353.A C366.2 C367.2 C368.2 C369.2 C407.2 C412.A C426.2 C431.A C443.A C452.1 C453.1 C753.1 C754.2 CB425.1 CB431.1 CB437.1 CB442.1 CB443.2 CB444.2 CB445.2 CB446.2 CB447.2 CB449.1 CB457.1 CB459.1 CB460.1 CB461.1 CB462.1 CB465.1 CB471.1 CB498.1 CB501.1 CB506.1 CB507.1 CB508.1 CB510.1 CB986.1 CB987.1 CONN40.1 L41.2 L42.2 L43.1 L44.1 L45.1 LB23.1 LB24.1 LB25.1 R118.2 R691.2 R694.2 R1499.1 U40.AC11(DDRC_VDDC#1) U40.AC12(DDRC_VDDC#2) U40.AD10(DDRC_VDDC#3) U40.AF19(DDRB_VDDC#2) U40.AF25(DDRA_VDDC#2) U40.AF27(DDRA_VDDC#3) U40.AG18(DDRB_VDDC#3) U40.AG20(DDRB_VDDC#1) U40.AG24(DDRA_VDDC#1)
VDD1P0_MARGIN HIGH: P1.C16(IO_B7_C16/DIFFIO_T35P/DQ2T) R299.2
VDD1P0_MARGIN HIGH_R: C157.2 Q2.G R299.1 R300.1
VDD1P0_MARGIN LOW: P1.C15(IO_B7_C15/DIFFIO_T33N/DQ2T) R334.2
VDD1P0_MARGIN LOW_R: C182.2 Q5.G R334.1 R335.1
VDD1P0_MON: C83.1 R118.1 U7.55(MON7)
VDD1P0_ROV: C273.A C296.1 C297.1 C300.1 C301.2 C327.1 C328.1 C329.1 C330.2 C378.A C379.A CB346.A CB347.A CB405.1 CB406.2 CB407.1 CB422.A CB432.1 CB433.1 CB450.1 CB451.1 CB452.1 CB467.1 CB468.1 CB473.1 CB474.1 CB475.1 CB476.2 CB477.1 CB482.1 CB483.1 CB484.1 CB485.1 CB491.2 CB492.1 CB496.1 CB497.1 CB502.1 CB503.1 CB504.1 CB505.1 CB512.1 CB513.1 CB514.1 CB515.1 CB516.1 CB517.1 CB518.1 CB519.2 CB520.1 CB521.2 CB530.2 CB532.1 CB533.1 CB534.1 CB535.1 CB538.1 CB540.1 CB541.1 CB542.1 CB543.1 CB549.1 CB553.1 CB554.1 CB555.1 CB556.1 CB558.1 CB565.1 CB566.1 CB567.1 CB568.2 CB569.1 CB571.1 CB573.1 CB580.1 CB581.1 CB582.1 CB583.1 CB587.A CB588.A CB589.1 CB590.1 CB591.1 CB592.1 CB599.1 CB600.1 CB609.1 CB610.1 CB611.1 CB612.1 CB613.1 CB615.1 CB616.1 CB619.1 CB620.1 CB621.1 CB622.1 CB623.1 CB624.1 CB625.1 CB626.1 CB627.1 CB628.1 CB629.1 CB630.1 CB631.1 CB640.1 CB643.1 CB644.1 CB645.1 CONN29.1 L23.2 L31.2 R95.2 R565.2 R604.2 R626.2 U40.AA12(VDDC#1) U40.AA14(VDDC#2) U40.AA16(VDDC#3) U40.AA18(VDDC#4) U40.AA20(VDDC#5) U40.AA22(VDDC#6) U40.AA24(VDDC#7) U40.AA26(VDDC#8) U40.AB13(VDDC#9) U40.AB15(VDDC#10) U40.AB17(VDDC#11) U40.AB19(VDDC#12) U40.AB21(VDDC#13) U40.AB23(VDDC#14) U40.AB25(VDDC#15) U40.AB27(VDDC#16) U40.AC14(VDDC#17) U40.AC16(VDDC#18) U40.AC20(VDDC#19) U40.AC22(VDDC#20) U40.AC24(VDDC#21) U40.AC26(VDDC#22) U40.AC28(VDDC#23) U40.AD13(VDDC#24) U40.AD15(VDDC#25) U40.AD17(VDDC#26) U40.AD19(VDDC#27) U40.AD21(VDDC#28) U40.AD23(VDDC#29) U40.AE12(VDDC#30) U40.AE14(VDDC#31) U40.AE16(VDDC#32) U40.AE18(VDDC#33) U40.AE20(VDDC#34) U40.AE22(VDDC#35) U40.AE24(VDDC#36) U40.AF13(VDDC#37) U40.AF15(VDDC#38) U40.AF23(VDDC#39) U40.AG11(VDDC#40) U40.AG12(VDDC#41) U40.AG14(VDDC#42) U40.AG16(VDDC#43) U40.P11(VDDC#44) U40.P13(VDDC#45) U40.P15(VDDC#46) U40.P17(VDDC#47) U40.P19(VDDC#48) U40.P21(VDDC#49) U40.P25(VDDC#50) U40.P27(VDDC#51) U40.R12(VDDC#52) U40.R14(VDDC#53) U40.R16(VDDC#54) U40.R18(VDDC#55) U40.R20(VDDC#56) U40.R22(VDDC#57) U40.R24(VDDC#58) U40.R26(VDDC#59) U40.T11(VDDC#60) U40.T15(VDDC#61) U40.T17(VDDC#62) U40.T19(VDDC#63) U40.T21(VDDC#64) U40.T23(VDDC#65) U40.T27(VDDC#66) U40.U16(VDDC#67) U40.U18(VDDC#68) U40.U20(VDDC#69) U40.U22(VDDC#70) U40.V11(VDDC#71) U40.V15(VDDC#72) U40.V17(VDDC#73) U40.V21(VDDC#74) U40.V23(VDDC#75) U40.V27(VDDC#76) U40.W12(VDDC#77) U40.W14(VDDC#78) U40.W16(VDDC#79) U40.W20(VDDC#80) U40.W22(VDDC#81) U40.W24(VDDC#82) U40.W26(VDDC#83) U40.Y11(VDDC#84) U40.Y13(VDDC#85) U40.Y15(VDDC#86) U40.Y21(VDDC#87) U40.Y23(VDDC#88)
VDD1P0_ROV_MON: C61.1 R95.1 U7.57(MON9)
VDD1P2_DDR: C36.1 C41.1 C287.2 C288.1 C289.1 CB338.1 CB339.1 CB340.1 CB360.1 CB361.1 CB362.1 CB371.1 CB372.1 CB373.1 CONN23.1 L19.2 LB20.2 LB21.1 LB22.2 R49.1 R68.2 R634.1 U6.2(VLDOIN)
VDD1P2_DDR_ABC: C251.2 C252.2 C253.1 C254.1 C255.1 CB331.1 CB332.1 CB333.1 CB335.1 CB336.1 CB337.1 CB350.2 CB352.1 CB353.2 CB354.2 CB355.1 CB356.1 CB357.1 CB358.1 CB359.2 CB363.1 CB364.2 CB365.1 CB367.1 CB369.1 CB370.1 CB374.2 CB375.1 CB376.2 CB377.1 CB378.1 CB379.2 CB384.2 CB385.2 CB386.1 CB387.2 CB389.1 CB390.2 CB391.1 CB392.1 CB393.1 CB395.1 CB396.1 CB397.1 CB398.2 CB399.2 CB401.1 CB402.2 CB403.1 CB409.1 CB410.2 CB411.1 CB412.1 CB414.1 CB415.1 CB416.2 CB418.1 CB419.2 CB420.1 CB426.1 CB427.1 CB434.2 CB435.2 CB436.1 CB470.1 CB486.2 CB493.1 CB499.1 CB526.1 CB536.1 CB537.1 LB22.1 U40.AB2(DDR_VDDO#1) U40.AB5(DDR_VDDO#2) U40.AB8(DDR_VDDO#3) U40.AD4(DDR_VDDO#4) U40.AD7(DDR_VDDO#5) U40.AE2(DDR_VDDO#6) U40.AF6(DDR_VDDO#7) U40.AF9(DDR_VDDO#8) U40.AG4(DDR_VDDO#9) U40.AH2(DDR_VDDO#13) U40.AH8(DDR_VDDO#15) U40.AH11(DDR_VDDO#10) U40.AH14(DDR_VDDO#11) U40.AH17(DDR_VDDO#12) U40.AH29(DDR_VDDO#14) U40.AK4(DDR_VDDO#24) U40.AK7(DDR_VDDO#25) U40.AK10(DDR_VDDO#16) U40.AK13(DDR_VDDO#17) U40.AK16(DDR_VDDO#18) U40.AK19(DDR_VDDO#19) U40.AK22(DDR_VDDO#20) U40.AK25(DDR_VDDO#21) U40.AK28(DDR_VDDO#22) U40.AK31(DDR_VDDO#23) U40.AL2(DDR_VDDO#26) U40.AM6(DDR_VDDO#35) U40.AM9(DDR_VDDO#36) U40.AM12(DDR_VDDO#27) U40.AM15(DDR_VDDO#28) U40.AM18(DDR_VDDO#29) U40.AM21(DDR_VDDO#30) U40.AM24(DDR_VDDO#31) U40.AM27(DDR_VDDO#32) U40.AM30(DDR_VDDO#33) U40.AM33(DDR_VDDO#34) U40.AN4(DDR_VDDO#37) U40.AP2(DDR_VDDO#41) U40.AP6(DDR_VDDO#48) U40.AP8(DDR_VDDO#49) U40.AP11(DDR_VDDO#38) U40.AP14(DDR_VDDO#39) U40.AP17(DDR_VDDO#40) U40.AP20(DDR_VDDO#42) U40.AP23(DDR_VDDO#43) U40.AP26(DDR_VDDO#44) U40.AP29(DDR_VDDO#45) U40.AP32(DDR_VDDO#46) U40.AP35(DDR_VDDO#47) U40.AT4(DDR_VDDO#60) U40.AT7(DDR_VDDO#61) U40.AT10(DDR_VDDO#50) U40.AT13(DDR_VDDO#51) U40.AT16(DDR_VDDO#52) U40.AT19(DDR_VDDO#53) U40.AT22(DDR_VDDO#54) U40.AT25(DDR_VDDO#55) U40.AT28(DDR_VDDO#56) U40.AT31(DDR_VDDO#57) U40.AT34(DDR_VDDO#58) U40.AT37(DDR_VDDO#59)
VDD1P2_DDR_MARGIN_HIGH: P1.D4(IO_B8_D4/DIFFIO_T7P) R72.2
VDD1P2_DDR_MARGIN_HIGH_D: QB4.D R611.1
VDD1P2_DDR_MARGIN_HIGH_R: C42.2 QB4.G R67.1 R72.1
VDD1P2_DDR_MARGIN_LOW: P1.B10(IO_B7_B10/DIFFIO_T21P/DQS4T/CQ5) R112.2
VDD1P2_DDR_MARGIN_LOW_D: QB5.D R601.1
VDD1P2_DDR_MARGIN_LOW_R: C97.2 QB5.G R100.1 R112.1
VDD1P2_DDR_MON: C45.1 R68.1 U7.59(MON11)
VDD1P2_DDR_VDD: C73.2 C74.1 C75.1 C76.2 C77.2 C78.1 C79.2 C80.2 C81.2 C82.2 C85.1 C87.2 C88.1 C92.2 C96.2 C113.2 C119.1 C126.2 C128.1 C130.2 C142.2 C154.1 C158.1 C159.1 C161.1 C169.1 C172.1 C177.1 C178.1 C186.1 C198.1 C258.A CB65.2 CB66.2 CB67.1 CB73.2 CB74.1 CB78.1 CB79.2 CB83.2 CB84.2 CB87.2 CB118.1 CB119.1 CB122.1 CB124.1 CB131.1 CB134.1 CB139.1 CB172.1 CB173.1 CB175.1 CB181.1 CB182.1 CB185.1 CB193.1 CB196.1 CB197.1 CB198.1 CB199.1 CB205.1 CB206.1 CB214.1 CB217.1 CB221.1 CB229.1 CB231.1 CB236.1 CB244.1 CB258.1 CB262.1 CB263.1 CB265.1 CB270.1 CB273.1 CB274.1 CB276.1 CB277.1 CB279.1 CB280.1 CB284.1 CB285.1 CB287.1 CB288.1 CB292.1 CB296.1 CB297.1 CB300.1 CB320.A CB325.A LB20.1 R250.2 R269.2 R301.2 RB46.2 RB94.2 RB104.2 RB108.2 RB117.2 RB119.2 RB120.2 RB122.2 RB124.2 U14.B3(VDD1) U14.B9(VDD2) U14.D1(VDD3) U14.G7(VDD4) U14.J1(VDD5) U14.J9(VDD6) U14.L1(VDD7) U14.L9(VDD8) U14.R1(VDD9) U14.T9(VDD10) U15.B3(VDD1) U15.B9(VDD2) U15.D1(VDD3) U15.G7(VDD4) U15.J1(VDD5) U15.J9(VDD6) U15.L1(VDD7) U15.L9(VDD8) U15.R1(VDD9) U15.T9(VDD10) U16.B3(VDD1) U16.B9(VDD2) U16.D1(VDD3) U16.G7(VDD4) U16.J1(VDD5) U16.J9(VDD6) U16.L1(VDD7) U16.L9(VDD8) U16.R1(VDD9) U16.T9(VDD10) U17.B3(VDD1) U17.B9(VDD2) U17.D1(VDD3) U17.G7(VDD4) U17.J1(VDD5) U17.J9(VDD6) U17.L1(VDD7) U17.L9(VDD8) U17.R1(VDD9) U17.T9(VDD10) UB5.B3(VDD1) UB5.B9(VDD2) UB5.D1(VDD3) UB5.G7(VDD4) UB5.J1(VDD5) UB5.J9(VDD6) UB5.L1(VDD7) UB5.L9(VDD8) UB5.R1(VDD9) UB5.T9(VDD10) UB6.B3(VDD1) UB6.B9(VDD2) UB6.D1(VDD3) UB6.G7(VDD4) UB6.J1(VDD5) UB6.J9(VDD6) UB6.L1(VDD7) UB6.L9(VDD8) UB6.R1(VDD9) UB6.T9(VDD10)
VDD1P2_DDR_VDDQ: C151.1 C152.1 C165.1 C166.1 C179.1 C184.1 C200.1 C203.1 C204.1 CB208.1 CB209.1 CB210.1 CB211.1 CB212.1 CB213.1 CB218.1 CB226.1 CB227.1 CB228.1 CB230.1 CB232.1 CB233.1 CB234.1 CB235.1 CB241.1 CB242.1 CB243.1 CB246.1 CB247.1 CB253.1 CB254.1 CB257.1 CB260.1 CB261.1 CB266.1 CB267.1 CB268.1 CB271.1 CB275.1 CB278.1 CB281.1 CB282.1 CB286.1 CB290.1 CB291.1 CB299.1 CB308.1 CB312.1 CB313.1 CB314.1 CB315.1 CB316.1 CB317.1 CB318.1 CB319.A CB324.1 CB326.A CB328.A CB330.1 CB334.1 LB21.2 U14.A1(VDDQ1) U14.A9(VDDQ2) U14.C1(VDDQ3) U14.D9(VDDQ4) U14.F2(VDDQ5) U14.F8(VDDQ6) U14.G1(VDDQ7) U14.G9(VDDQ8) U14.J2(VDDQ9) U14.J8(VDDQ10) U15.A1(VDDQ1) U15.A9(VDDQ2) U15.C1(VDDQ3) U15.D9(VDDQ4) U15.F2(VDDQ5) U15.F8(VDDQ6) U15.G1(VDDQ7) U15.G9(VDDQ8) U15.J2(VDDQ9) U15.J8(VDDQ10) U16.A1(VDDQ1) U16.A9(VDDQ2) U16.C1(VDDQ3) U16.D9(VDDQ4) U16.F2(VDDQ5) U16.F8(VDDQ6) U16.G1(VDDQ7) U16.G9(VDDQ8) U16.J2(VDDQ9) U16.J8(VDDQ10) U17.A1(VDDQ1) U17.A9(VDDQ2) U17.C1(VDDQ3) U17.D9(VDDQ4) U17.F2(VDDQ5) U17.F8(VDDQ6) U17.G1(VDDQ7) U17.G9(VDDQ8) U17.J2(VDDQ9) U17.J8(VDDQ10) UB5.A1(VDDQ1) UB5.A9(VDDQ2) UB5.C1(VDDQ3) UB5.D9(VDDQ4) UB5.F2(VDDQ5) UB5.F8(VDDQ6) UB5.G1(VDDQ7) UB5.G9(VDDQ8) UB5.J2(VDDQ9) UB5.J8(VDDQ10) UB6.A1(VDDQ1) UB6.A9(VDDQ2) UB6.C1(VDDQ3) UB6.D9(VDDQ4) UB6.F2(VDDQ5) UB6.F8(VDDQ6) UB6.G1(VDDQ7) UB6.G9(VDDQ8) UB6.J2(VDDQ9) UB6.J8(VDDQ10)
VDD1P8: C211.1 C212.1 C225.1 C226.1 C236.1 C265.1 C267.1 C277.1 C346.1 C374.1 C461.1 C471.1 C474.1 C478.1 C917.1 C918.1 CB1036.2 CB1058.1 CONN10.1 L2.1 L12.2 L13.2 L16.2 L17.2 L18.2 L30.2 L33.2 L46.2 L47.2 L48.2 L52.2 L95.1 L103.1 L108.1 L109.1 LB6.1 LB110.1 R3.2 R416.1 U23.1(VOUT1) U23.18(VOUT2) U23.19(VOUT3) U23.20(VOUT4)
VDD1P8_FB: R347.2 R385.2 R394.2 R416.2 U23.16(FB)
VDD1P8_FB_H: R346.2 R385.1
VDD1P8_FB_L: R347.1 R348.2
VDD1P8_MARGIN_HIGH: P1.F8(IO_B8_F8/DIFFIO_T8P) R132.2
VDD1P8_MARGIN_HIGH_D: QB7.D R346.1
VDD1P8_MARGIN_HIGH_R: C115.2 QB7.G R132.1 R137.1
VDD1P8_MARGIN_LOW: P1.AA16(IO_B4_AA16/DIFFIO_B28N/DQ2B) R287.2
VDD1P8_MARGIN_LOW_D: Q1.D R348.1
VDD1P8_MARGIN_LOW_R: C145.2 Q1.G R287.1 R288.1
VDD1P8_MON: C17.1 R3.1 U7.6(MON6)
VDD1P8_PG: CONN16.1 R421.2 U23.9(PG)
VDD1P8_SS: C193.1 U23.15(SS)
VDD1P8_VIN: C213.1 C223.1 C231.1 L9.2 U23.5(VIN1) U23.6(VIN2) U23.7(VIN3) U23.8(VIN4)
VDD1P25: C459.1 C481.1 C482.1 CB783.A CONN45.1 L51.1 R801.2 U47.1(VOUT1) U47.18(VOUT2) U47.19(VOUT3) U47.20(VOUT4)
VDD1P25_FB: R795.2 R801.1 R803.2 R804.2 U47.16(FB)
VDD1P25_FB_H: R804.1 R805.2
VDD1P25_FB_L: R802.2 R803.1
VDD1P25_MARGIN_HIGH: P1.AB18(IO_B4_AB18/DIFFIO_B29N/DQ2B) R312.2
VDD1P25_MARGIN_HIGH_D: Q3.D R805.1
VDD1P25_MARGIN_HIGH_R: C167.2 Q3.G R312.1 R313.1
VDD1P25_MARGIN_LOW: P1.AB16(IO_B4_AB16/DIFFIO_B27N) R323.2
VDD1P25_MARGIN_LOW_D: Q4.D R802.1
VDD1P25_MARGIN_LOW_R: C174.2 Q4.G R323.1 R324.1
VDD1P25_PG: CONN43.1 R196.2 R732.1 U47.9(PG)
VDD1P25_PG_R: R196.1 U7.42(PWM3/GPI3)
VDD1P25_SS: C467.1 U47.15(SS)
VDD1P25_VIN: C428.1 C435.1 L91.2 U47.5(VIN1) U47.6(VIN2) U47.7(VIN3) U47.8(VIN4)
VDD3P3: C146.1 C153.2 C188.2 C191.2 C230.2 C262.1 C308.2 C319.1 C325.1 C334.1 C350.1 C371.1 C381.1 C394.1 C472.1 C473.1 C477.1 C487.2 C488.2 C938.1 C939.1 C940.1 C941.1 CB2.1 CB3.1 CB6.1 CB10.2 CB49.1 CB50.2 CB321.2 CB322.2 CB323.2 CB327.2 CB797.1 CB883.1 CB949.1 CB951.1 CB975.1 CB1047.2 CB1057.1 CB1200.1 CB1211.1 CB1217.1 CB1221.1 CB1224.1 CB1227.1 CONN32.1 L1.1 L7.2 L15.2 L29.2 L49.1 L50.1 L96.1 L105.1 L106.1 L107.1 LB1.1 LB4.1 LB5.1 LB8.1 LB113.1 LB114.1 LB115.1 LB116.1 OSC7.1(EN) R1.1 R48.1 R55.1 R66.2 R182.2 R232.2 R340.1 R356.1 R384.1 R424.1 R435.1 R496.2 R518.2 R526.2 R528.2 R542.1 R544.2 R552.2 R563.2 R575.2 R584.2 R595.2 R619.2 R631.2 R651.1 R652.2 R657.1 R658.2 R1082.1 R1084.1 R1086.1 R1088.2 R1092.2 R1094.1 R1097.1 R1098.1 R1100.1 R1102.1 R1108.1 R1110.1 R1112.1 R1114.1 R1116.1 R1120.2 R1124.1 R1127.1 R1128.1 R1187.1 R1188.1 R1368.1 R1414.2 R1417.2 R1418.2 R1420.1 R1422.1 R1437.2 R1497.1 R1498.1 RB16.2 RB17.2 RB245.1 RB263.1 RB264.1 RB265.1 RB266.1 RB267.1 RB268.1 RB269.1 RB270.1 RB274.1 RB291.1 RB292.1 RB293.1 RB294.1 RB295.1 RB296.1 RB297.1 RB577.1 RB580.1 RB581.1 RB584.1 RB586.1 RB589.1 RB590.1 RB593.1 RB594.1 RB597.1 RB598.1 RB601.1 RB602.1 RB606.1 RB607.1 RB610.1 RB611.1 RB614.1 RB615.1 RB623.1 RB624.1 RB627.1 RB628.1 RB631.1 RB632.1 RB635.1 RB636.1 RB641.1 RB643.1 RB646.1 RB647.1 RB651.1 RB654.1 RB658.1 RB659.2 RB660.1 RB664.1 RB670.1 RB673.1 RB675.1 RB681.1 RB691.1 RB700.1 RB705.1 RB711.1 RB719.1 RB725.1 RB729.1 RB730.1 RB740.1 RB1256.2 RB1266.1 RB1268.1 RB1274.1 RB1275.1 U24.5(VDDA33_0) U24.10(VDDA33_1) U24.15(VDD33(REG)) U24.23(VDD33(IO)) U24.29(VDDA33_2) U24.36(VDDPLLREF/VDDA33) U50.2(REF1_1) U50.3(REF1_2) U77.14(VDD1) U77.21(VDD2) U77.61(VDD3) U77.80(VDD4) UB8.24(VDD) UB12.24(VDD) UB13.24(VDD) UB16.24(VDD)
VDD3P3_2304: C320.1 C321.1 L25.1 U37.6(VDD)
VDD3P3_MON: C18.1 R1.2 R14.1 U7.5(MON5)
VDD3P3_OCXO: C313.1 C332.1 C333.1 L25.2 L32.1 R557.2 R674.1 R676.2 U36.5(OUT_1) U36.6(OUT_2) U36.7(OUT_3)
VDD3P3_XO: C484.2 L32.2 OCXO1.3(VCC) OCXO2.6(VCC)
VDD5V_TOD_1PPS: C522.1 C525.1 C528.1 L55.2 R853.2 RB273.2 U51.16(VCC)
VDD33_MINI_OSC5: C131.2 C136.2 C137.1 L7.1 OSC2.4(VDD) R210.1
VDD_3V3_1204: C922.2 C923.2 C925.1 LB115.2 U79.5(VCC)
VDD_30773: C924.2 C927.1 LB116.2 OSC7.4(VDD)
VDD_DRI_1V8: C916.1 C928.1 CB1195.1 L103.2 U77.12(VDD_DRI)
VDD_Q01: CB1100.1 CB1101.1 LB95.1 U69.30(VCC1)
VDD_Q02: CB899.1 CB907.1 CONN53_PF.1T30(VCC1_1T) LB67.1
VDD_Q03: CB900.1 CB904.1 CONN53_PF.1B30(VCC1_1B) LB62.1
VDD_RX_Q01: CB1098.1 CB1099.1 LB94.1 U69.10(VCC_RX)
VDD_RX_Q02: CB908.1 CB911.1 CONN53_PF.1T10(VCC_RX_1T) LB68.1
VDD_RX_Q03: CB909.1 CB910.1 CONN53_PF.1B10(VCC_RX_1B) LB63.1
VDD_TX_Q01: CB1094.1 CB1095.1 LB93.1 U69.29(VCC_TX)
VDD_TX_Q02: CB902.1 CB905.1 CONN53_PF.1T29(VCC_TX_1T) LB69.1
VDD_TX_Q03: CB901.1 CB906.1 CONN53_PF.1B29(VCC_TX_1B) LB64.1
VDDH_1&4_3V3: C944.1 C945.1 L105.2 U77.38(VDDH1) U77.73(VDDH4)
VDDH_2_3V3: C943.1 L106.2 U77.40(VDDH2)
VDDH_3_3V3: C942.1 L107.2 U77.69(VDDH3)
VDDL_1_1V8: C934.1 L109.2 U77.39(VDDL1)
VDDL_2&6_1V8: C929.1 C930.1 C931.1 C932.1 C933.1 CB1188.1 LB110.2 U77.41(VDDL2) U77.47(VDDL3) U77.53(VDDL4) U77.54(VDDL5) U77.55(VDDL6)
VDDL_7&9_1V8: C935.1 C936.1 C937.1 L108.2 U77.62(VDDL7) U77.68(VDDL8) U77.72(VDDL9)
VDDO_3P3: C270.1 CB394.1 CB454.1 CB472.1 CB478.1 CB523.1 CB544.1 L15.1 R481.1 U40.AA37(IO_VDDO_3P3#1) U40.AB32(IO_VDDO_3P3#2) U40.AE37(IO_VDDO_3P3#3) U40.AF31(IO_VDDO_3P3#4) U40.AG35(IO_VDDO_3P3#5) U40.AM34(IO_VDDO_3P3#6)
VDDO_3V3: C946.1 C947.1 C948.1 C949.1 CB1212.1 LB113.2 U77.44(VDDO_6_7) U77.50(VDDO_4_5) U77.58(VDDO_2_3) U77.65(VDDO_0_1)
VDDO_FC: C266.1 CB345.2 CB380.1 CB421.1 L13.1 RB147.1 RB150.1 RB175.1 U40.AJ36(FC_SYNCE_VDDO#1) U40.AP36(FC_SYNCE_VDDO#2)
1PPS_FPGA_IN: R1353.2 R1373.1
1PPS_FPGA_IN_R: P1.M21(CLKIO5_M21/DIFFCLK_2P) R1353.1
1PPS_GPS_IN: CONN44.6 R1351.1 RB1261.1
1PPS_GPS_IN_FPGA: P1.G19(IO_B6_G19/DIFFIO_R1N/DQ2R) R1351.2
1PPS_IN_T_MUX: P1.L22(CLKIO6_L22/DIFFCLK_3N) RB277.2
1PPS_IN_T_WP: RB276.2 RB1259.2
1PPS_OUT_BKUP: P1.B13(IO_B7_B13/DIFFIO_T28P/DQ4T) R254.2
1PPS_OUT_ISO_OTC_TO_RJ: R474.2 U51.15(1D)
1PPS_OUT_ISO_OTC_TO_RJ_R: R474.1 R1172.1
1PPS_OUT_N: D7.1 F6.2 RB317.2 RB325.2 U54.4(LINE 4 IN)
1PPS_OUT_N_A: CB896.1 LB61.2 R858.1 RB317.1 U51.7(2B)
1PPS_OUT_N_A_R: R858.2 U51.13(1Z)
1PPS_OUT_N_R: F6.1 RJ1.C3
1PPS_OUT_P: D6.1 F5.2 RB316.2 RB325.1 U54.3(LINE 3 IN)
1PPS_OUT_P_A: CB895.2 LB60.2 R857.1 RB316.1 U51.6(2A)
1PPS_OUT_P_A_R: R857.2 U51.14(1Y)
1PPS_OUT_P_R: F5.1 RJ1.C6
1PPS_RESERVE: J2.A49(EXCD0_CPPE#) R138.2
1PPS_RESERVE_R: P1.R19(IO_B5_R19/DIFFIO_R41P/DQ3R) R138.1
2.048MHZ_BITS_RCLK_IN: R332.1 R1236.1 RB1260.2
4KHZ_1588_SYNC0: R62.2 R1186.2
4KHZ_1588_SYNC0_R: P1.C5(IO_B8_C5/DIFFIO_T7N/DQ3T) R62.1
10G_KR_RX0_N: J2.C50(DDI3_PAIR3-) U40.W4(NIFE_TX_47_N)
10G_KR_RX0_P: J2.C49(DDI3_PAIR3+) U40.W3(NIFE_TX_47_P)
10G_KR_RX1_N: J2.C43(DDI3_PAIR1-) U40.V2(NIFE_TX_46_N)
10G_KR_RX1_P: J2.C42(DDI3_PAIR1+) U40.V1(NIFE_TX_46_P)
10G_KR_TX0_N: CB511.1 J2.D50(DDI2_PAIR3-)
10G_KR_TX0_P: CB528.1 J2.D49(DDI2_PAIR3+)
10G_KR_TX1_N: CB607.1 J2.D43(DDI2_PAIR1-)
10G_KR_TX1_P: CB586.1 J2.D42(DDI2_PAIR1+)
10MHZ_GPS_IN/RESET: CONN44.4 R85.2
10MHZ_GPS_IN_FPGA: P1.L21(CLKIO7_L21/DIFFCLK_3P) R85.1
25MHZ_1PPS_FPGA_IN: R1350.2 R1372.1
25MHZ_1PPS_FPGA_IN_R: P1.M22(CLKIO4_M22/DIFFCLK_2N) R1350.1
25MHZ_1204: R1371.1 R1439.2
25MHZ_30773: R1369.2 RB1271.2
25MHZ_30773_R: R1369.1 U37.3(Y0)
1588_CPU_OUT: P1.V20(IO_B5_V20/DIFFIO_R43P/DQ3R) R183.1
1588_TO_CPU: P1.W20(IO_B5_W20/DIFFIO_R45P/DQ3R) R193.1
1588_UART_FROM_CPU: R183.2 R1310.1
1588_UART_TO_CPU: J2.A102(SER1_RX) R193.2
2304_OE: R674.2 R675.1 U37.2(OE)
30773_GPIO1: RB1276.1 RB1282.2
30773_GPIO2: RB1277.1 RB1283.2
30773_GPIO5: RB1268.2 RB1269.1 RB1280.1 RB1284.2
30773_GPIO6: RB1266.2 RB1267.1 RB1281.1 RB1285.2
30773_GPIO7: RB1278.1 RB1286.1
30773_GPIO8: RB1279.1 RB1287.1
30773_I2C_SPI_CS: RB1256.1 RB1295.1 U9.F10(IO_2_F10/DIFFIO_T17N) U77.20(GPIO0_IF)
30773_SCL_FP: R98.2 R1497.2 RB1297.2 U77.16(SCK_SCL)
30773_SCL_FP_R: P1.N15(IO_B5_N15/DIFFIO_R46N) R87.1 R98.1
30773_SDA_FP: R110.2 R1498.2 RB1299.1 U77.18(SI_SDA)
30773_SDA_FP_R: P1.N20(IO_B5_N20/DIFFIO_R30N) R110.1 R116.1
33931_SCL: P1.F18(IO_B6_F18/DIFFIO_R1P/DQ2R) R306.1
33931_SCL_R: R306.2 R307.2 U10.11(SC3)
33931_SDA: P1.H7(IO_B8_H7/DIFFIO_T3P) R294.1
33931_SDA_R: R294.2 R295.2 U10.10(SD3)
88470_1588_I2C_SCL: R120.2 R650.1
88470_1588_I2C_SDA: P1.J13(IO_B7_J13/DIFFIO_T23P/DQ4T) R668.1
88470_I2C_SCL: R74.2 R656.1
88470_I2C_SCL_R: R74.1 U9.A2(IO_2_A2/DIFFIO_T2P)
88470_I2C_SDA: R654.1 U9.A4(IO_2_A4/DIFFIO_T5P)
ALARM_G: P1.B12(IO_B7_B12/DIFFIO_T28N/DQ4T) RB1293.2
ALARM_G_R: CB1228.2 LEDB15.C2 RB1293.1
ALARM_R: P1.B16(IO_B7_B16/DIFFIO_T35N/DQS0T/CQ1) RB1294.2
ALARM_R_R: CB1229.2 LEDB15.C1 RB1294.1
ALE_SET: P1.Y15(IO_B4_Y15/DIFFIO_B25N/DM2B) R1123.1
AP7362_ADJ: CONN36.1 R689.1
AP7362_ADJ_R: R676.1 R677.2 R689.2 U36.8(ADJ/NC)
AP7362_EN: RB184.2 RB186.2 U36.2(EN)
AP7362_VIN: C316.1 C322.1 L24.2 RB184.1 U36.3(IN_1) U36.4(IN_2)
B2B_PROCHOT_N: J2.B35(THRM#) R1291.1
BCM88470_C_PLL_BYP_CLK0: RB194.1 U40.Y18(C_PLL_BYP_CLK0)
BCM88470_C_PLL_BYP_CLK1: RB195.1 U40.W18(C_PLL_BYP_CLK1)
BCM88470_DDRA_AUX_0: TPB28.1 U40.AK23(DDRA_AUX_0)
BCM88470_DDRA_AUX_1: TPB29.1 U40.AH24(DDRA_AUX_1)
BCM88470_DDRA_PLL_CLK_MON: TPB34.1 U40.AG29(DDRA_PLL_CLK_MON)
BCM88470_DDRA_VREF_MON: TPB26.1 U40.AH28(DDRA_VREF_MON)
BCM88470_DDRB_AUX_0: TPB27.1 U40.AJ17(DDRB_AUX_0)
BCM88470_DDRB_AUX_1: TPB31.1 U40.AH18(DDRB_AUX_1)
BCM88470_DDRC_AUX_0: TPB30.1 U40.AK8(DDRC_AUX_0)
BCM88470_DDRC_AUX_1: TPB36.1 U40.AD9(DDRC_AUX_1)
BCM88470_FTEST_0: R607.2 U40.AF30(FTEST_0)
BCM88470_FTEST_1: R573.2 U40.AH30(FTEST_1)
BCM88470_FTEST_2: R608.2 U40.AG30(FTEST_2)
BCM88470_LED_CLK: R679.1 U40.AA30(LED_CLK)
BCM88470_LED_DATA: R661.2 U40.AB30(LED_DATA)
BCM88470_MDC_0: TPB39.1 U40.AD36(MDC_0)
BCM88470_MDIO_0: TPB37.1 U40.AD37(MDIO_0)
BCM88470_NIF_LCPLL_BYP_CLK: RB209.1 U40.N21(NIF_LCPLL_BYP_CLK)
BCM88470_NIFE_LCPLL0_BYP_CLK: R681.1 U40.U24(NIFE_LCPLL0_BYP_CLK)
BCM88470_NIFE_LCPLL1_BYP_CLK: RB196.1 U40.V12(NIFE_LCPLL1_BYP_CLK)
BCM88470_PVTMON_A_AIO: TPB42.1 U40.N24(PVTMON_A_AIO)
BCM88470_PVTMON_B_AIO: TPB41.1 U40.N14(PVTMON_B_AIO)
BCM88470_ROV0: P1.AA15(IO_B4_AA15/DIFFIO_B27P/DQS2B/CQ) R500.2 U40.AL34(ROV_0)
BCM88470_ROV1: P1.R17(IO_B5_R17/DIFFIO_R49N/DM3R/BWS#) R516.2 U40.AJ34(ROV_1)
BCM88470_ROV2: P1.V21(IO_B5_V21/DIFFIO_R43N/DQ3R) R508.2 U40.AK34(ROV_2)
BCM88470_SCAN: R574.2 U40.AH31(SCAN_MODE)
BCM88470_SPI_CLK: TPB33.1 U40.AD35(SPI_CLK)
BCM88470_SPI_MISO: TPB32.1 U40.AE35(SPI_MISO)
BCM88470_SPI_MOSI: TPB40.1 U40.AC34(SPI_MOSI)
BCM88470_SPI_SSN: TPB35.1 U40.AD34(SPI_SSN)
BCM88470_TEST_0: R501.2 U40.AL35(TEST_0)
BCM88470_TEST_1: RB172.2 U40.AM35(TEST_1)
BCM88470_TEST_2: R561.2 U40.AH35(TEST_2)
BCM88470_TEST_3: R509.2 U40.AK35(TEST_3)
BCM88470_TEST_4: R562.2 U40.AJ35(TEST_4)
BCM88470_THERM_DIODE_VDD3P3: RB236.2 U40.D25(THERM_DIODE_VDD3P3)
BCM88470_UC_PLL_BYPCLK0: R682.1 U40.V31(UC_PLL_BYP_CLK0)
BCM88470_UC_PLL_BYPCLK1: RB193.1 U40.Y31(UC_PLL_BYP_CLK1)
BITS_1P8: CB1035.2 CB1037.1 CB1038.1 CB1039.1 CB1040.1 CB1041.1 CB1042.1 CB1043.1 CB1044.1 CB1045.1 CB1076.2 CB1078.1 L95.2 L99.1 U68.1(DVDD1V8_1) U68.23(DVDD1V8_2) U68.36(DVDD1V8_3) U68.65(DVDD1V8_4)
BITS_3P3: CB1046.2 CB1048.1 CB1049.1 CB1050.1 CB1051.1 CB1052.1 CB1053.1 CB1054.1 CB1064.2 CB1066.1 CB1070.2 CB1072.1 L96.2 L97.1 L98.1 U68.21(DVDD3V3_1) U68.28(DVDD3V3_2) U68.80(DVDD3V3_3)
BITS_A: P1.G14(IO_B7_G14/DIFFIO_T27N) RB669.2
BITS_A_R: CB950.2 LEDB4.C1 RB669.1
BITS_ACK0: R1108.2 U68.35(A\C\K\0\)
BITS_ACK1: R1110.2 U68.38(A\C\K\1\)
BITS_ADD0: R1198.1 U68.44(ADDR0)
BITS_ADD1: RB1199.1 U68.45(ADDR1)
BITS_ADD2: RB1200.1 U68.46(ADDR2)
BITS_ADD3: RB1201.1 U68.47(ADDR3)
BITS_ADD4: R1202.1 U68.48(ADDR4)
BITS_ADD5: RB1203.1 U68.49(ADDR5)
BITS_ADD6: RB1204.1 U68.50(ADDR6)
BITS_ADD7: RB1205.1 U68.51(ADDR7)
BITS_ADD8: R1207.1 U68.53(ADDR8)
BITS_ADD9: RB1206.1 U68.57(ADDR9)
BITS_ADD10: RB1208.1 U68.58(ADDR10)
BITS_ADD11: RB1209.1 U68.60(ADDR11)
BITS_ADD_0: P1.A1(IO_B8_A1/DIFFIO_T13N) R1198.2
BITS_ADD_1: P1.A2(IO_B8_A2/DIFFIO_T16N/DQ5T) RB1199.2
BITS_ADD_2: P1.A3(IO_B8_A3/DIFFIO_T16P/DQ5T) RB1200.2
BITS_ADD_3: P1.A5(IO_B8_A5/DIFFIO_T17P) RB1201.2
BITS_ADD_4: P1.D7(IO_B8_D7/DIFFIO_T10P/DQ3T) R1202.2
BITS_ADD_5: P1.B22(IO_B6_B22/DIFFIO_R12N) RB1203.2
BITS_ADD_6: P1.D21(IO_B6_D21/DIFFIO_R14P/DM2R) RB1204.2
BITS_ADD_7: P1.E20(IO_B6_E20/DIFFIO_R17N) RB1205.2
BITS_ADD_8: P1.E21(IO_B6_E21/DIFFIO_R15P) R1207.2
BITS_ADD_9: P1.F20(IO_B6_F20/DIFFIO_R17P) RB1206.2
BITS_ADD_10: P1.H15(IO_B6_H15/DIFFIO_R3P) RB1208.2
BITS_ADD_11: P1.H16(IO_B6_H16/DIFFIO_R3N) RB1209.2
BITS_ALE: R1123.2 R1124.2 R1125.2 U68.56(ALE)
BITS_CHOKE_RRING: F4.2 U60.4 UB10.13 UB10.14 UB10.15 UB10.16
BITS_CHOKE_RTIP: F3.2 U60.3 UB10.1 UB10.2 UB10.3 UB10.4
BITS_CHOKE_TRING: F2.2 U59.4 UB10.9 UB10.10 UB10.11 UB10.12
BITS_CHOKE_TTIP: F1.2 U59.3 UB10.5 UB10.6 UB10.7 UB10.8
BITS_CS: R1116.2 R1117.2 RB1212.2 U68.68(CS)
BITS_CS_IN: P1.A13(IO_B7_A13/DIFFIO_T30N) RB1212.1
BITS_DA0: R1160.2 U68.40(DATA0)
BITS_DA1: R1161.2 U68.41(DATA1)
BITS_DA2: R1162.2 U68.54(DATA2)
BITS_DA3: R1163.2 U68.55(DATA3)
BITS_DA4: R1164.2 U68.61(DATA4)
BITS_DA5: R1165.2 U68.63(DATA5)
BITS_DA6: R1166.2 U68.64(DATA6)
BITS_DA7: R1167.2 U68.66(DATA7)
BITS_DATA0: P1.AA7(IO_B3_AA7/DIFFIO_B11P) R1160.1
BITS_DATA1: P1.AA9(IO_B3_AA9/DIFFIO_B13N/DQ5B) R1161.1
BITS_DATA2: P1.AB11(IO_B3_AB11/DIFFIO_B18N) R1162.1
BITS_DATA3: P1.AB7(IO_B3_AB7/DIFFIO_B11N) R1163.1
BITS_DATA4: P1.W7(IO_B3_W7/DIFFIO_B8P/DQ3B) R1164.1
BITS_DATA5: P1.W9(IO_B3_W9/DIFFIO_B12P/DQ5B) R1165.1
BITS_DATA6: P1.Y10(IO_B3_Y10/DIFFIO_B16P/DQS5B/CQ5) R1166.1
BITS_DATA7: P1.Y12(IO_B3_Y12/DIFFIO_B17N/DQ5B) R1167.1
BITS_G: P1.G12(IO_B7_G12/DIFFIO_T20N) RB662.2
BITS_G_R: CB942.2 LEDB4.C2 RB662.1
BITS_GPIO0: R1096.2 R1097.2 U68.73(GPIO0)
BITS_GPIO1: R1098.2 R1099.2 U68.72(GPIO1)
BITS_GPIO2: R1100.2 R1101.2 U68.74(GPIO2)
BITS_GPIO3: R1102.2 R1103.2 U68.75(GPIO3)
BITS_PCLK: R1088.1 R1089.1 U68.39(PCLK)
BITS_RCLK_R: R332.2 R1237.2 U68.24(RXSERCLK/RXLINECLK)
BITS_RD: R1112.2 R1113.2 RB1210.2 U68.42(R\D\)
BITS_RD_IN: P1.Y16(IO_B4_Y16/DIFFIO_B28P/DQ2B) RB1210.1
BITS_RDY_O: P1.J12(IO_B7_J12/DIFFIO_T25N) R1119.1
BITS_RDY_R: R1118.1 R1119.2 R1120.1 U68.43(R\D\Y\)
BITS_REST: P1.W13(IO_B4_W13/DIFFIO_B20P/DQ4B) R1091.1
BITS_RJ48_RRING: F4.1 RJ1.D1
BITS_RJ48_RTIP: F3.1 RJ1.D2
BITS_RJ48_TRING: F2.1 RJ1.D4
BITS_RJ48_TTIP: F1.1 RJ1.D5
BITS_RLOS: R333.2 R1079.1 U68.25(RXLOS)
BITS_RRING: R843.2 R943.2 U50.7(I/O_4) U68.8(RRING)
BITS_RRING_R: R943.1 U53.3(TIB)
BITS_RST: R1090.1 R1091.2 R1092.1 U68.52(R\E\S\E\T\)
BITS_RT_R: C518.1 R842.1 R843.1
BITS_RTIP: R842.2 R944.2 U50.1(I/O_1) U68.9(RTIP)
BITS_RTIP_R: R944.1 U53.1(TIA)
BITS_RVDD3V3: CB1063.2 CB1065.1 CB1067.1 CB1068.1 L97.2 U68.10(RVDD3V3)
BITS_RXCAS: P1.D14(IO_B7_D14/DIFFIO_T31P/DQ2T) RB1216.2
BITS_RXCAS_R: RB1216.1 U68.19(RXCASYNC)
BITS_RXCRCS: P1.D15(IO_B7_D15/DIFFIO_T33P) RB1217.2
BITS_RXCRCS_R: RB1217.1 U68.22(RXCRCSYNC)
BITS_RXS: P1.N21(IO_B5_N21/DIFFIO_R29P/DQ1R) RB1220.1
BITS_RXS_R: RB1220.2 U68.20(RXSYNC/RXNEG)
BITS_RXSCLK: R1128.2 R1129.2 R1131.2 U68.18(RXCHN4/RXSCLK)
BITS_RXSER: P1.M15(IO_B5_M15/DIFFIO_R36N) RB1218.2
BITS_RXSER_R: RB1218.1 U68.26(RXSER/RXPOS)
BITS_TCLK_2M: P1.D9(IO_B8_D9/DIFFIO_T5P/DQ3T) R1404.1
BITS_TCLK_2M_R: R1404.2 U77.43(HPOUT7P)
BITS_TCLK_R: R1018.2 R1236.2 U68.29(TXSERCLK/TXLINECLK)
BITS_TRING: R947.2 U50.4(I/O_2) U68.3(TRING)
BITS_TRING_R: R947.1 U53.8(ROB)
BITS_TRR_R: C573.1 U53.2(TIC)
BITS_TRT_R: C637.1 U53.7(ROC)
BITS_TTIP: C538.1 U68.5(TTIP)
BITS_TVDD3V3: CB1069.2 CB1071.1 CB1073.1 CB1074.1 L98.2 U68.4(TVDD3V3)
BITS_TXMSYNC: R1126.2 R1127.2 R1130.2 U68.31(TXMSYNC)
BITS_TXON: R1093.2 R1094.2 R1095.2 U68.79(TXON)
BITS_TXS: P1.P15(IO_B5_P15/DIFFIO_R46P) RB1221.1
BITS_TXS_R: RB1221.2 U68.32(TXSYNC/TXNEG)
BITS_TXSER: P1.N17(IO_B5_N17/DIFFIO_R32P/DQ1R) RB1219.2
BITS_TXSER_R: RB1219.1 U68.30(TXSER/TXPOS)
BITS_TYPE0: R1086.2 R1087.2 RB1215.1 U68.78(PTYPE0)
BITS_TYPE1: R1084.2 R1085.2 RB1213.1 U68.77(PTYPE1)
BITS_TYPE2: R1082.2 R1083.2 RB1214.1 U68.76(PTYPE2)
BITS_TYPE-0: P1.C14(IO_B7_C14/DIFFIO_T31N) RB1215.2
BITS_TYPE-1: P1.C11(IO_B7_C11/DIFFIO_T24P) RB1213.2
BITS_TYPE-2: P1.C10(IO_B7_C10/DIFFIO_T24N/DQ4T) RB1214.2
BITS_VDD1V8: CB1075.2 CB1077.1 CB1079.1 CB1080.1 CB1081.1 CB1082.1 L99.2 U68.11(AVDD1V8) U68.13(VDDPLL1V8_1) U68.14(VDDPLL1V8_2)
BITS_WR: R1114.2 R1115.2 RB1211.2 U68.67(W\R\)
BITS_WR_IN: P1.Y19(IO_B4_Y19/DIFFIO_B36N/DQ2B) RB1211.1
BITS_XFMR_R_RRING: U53.14(TOB) U60.1
BITS_XFMR_R_RTIP: U53.16(TOA) U60.2
BITS_XFMR_R_TRING: U53.9(RIB) U59.1
BITS_XFMR_R_TTIP: U53.11(RIA) U59.2
BITS_XFMR_TTIP: C538.2 R948.2 U50.6(I/O_3)
BITS_XFMR_TTIP_R: R948.1 U53.6(ROA)
BOARD_ID0: RB9.1 RB25.1 U9.E11(IO_2_E11/DIFFIO_T19N)
BOARD_ID1: RB10.1 RB26.1 U9.E12(IO_2_E12)
BOARD_ID2: RB11.1 RB27.1 U9.E13(IO_2_E13/DIFFIO_T25N)
BODE PLOT_1V2: CB408.1 R627.1 R634.2
BODE PLOT_2V5: CB509.1 R558.1 R572.2
BOOT9_5: C348.1 U39.9(BOOT)
BOOT9_6: C283.1 U30.9(BOOT)
BOOT__R8_5: R670.2 U39.8(BOOT_R)
BOOT__R8_5_R: C348.2 R670.1
BOOT__R8_6: R515.2 U30.8(BOOT_R)
BOOT__R8_6_R: C283.2 R515.1
BPCAP: C109.1 C110.2 U7.47(BPCAP)
BS_PLL_AVDD1P8: C454.1 CB595.1 CB596.1 CB597.1 L46.1 U40.U31(BS_PLL_AVDD1P8)
BS_VCC5P0: CB440.1 U34.1(BS)
BU_CPLD2_TDO: R349.1 U22.2(2B)
BU_CPLD2_TDO_R: R349.2 U19.3(B0)
BU_SEL: R316.1 R317.1 U19.6(S)
C_PLL_BYPASS: R544.1 R545.2 U40.AK32(C_PLL_BYPASS)
CLK_BITS_MCLK: R192.1 TPB7.1
CLK_BITS_OSC_MCLK: R192.2 R204.2 U68.17(MCLKIN)
CLK_BITS_OSC_R: OSC2.3(OUTPUT) R204.1
CLK_BITS_TCLK: P1.AA6(IO_B3_AA6/DIFFIO_B10P/DQ3B) R1018.1 R1237.1
COM_CTREF: J2.A14(GBE0_CTREF) R1335.2 R1336.2 R1337.2 R1338.2
COM_LPC_AD0: R1313.1 U72.26(LAD0)
COM_LPC_AD1: R1314.1 U72.23(LAD1)
COM_LPC_AD2: R1315.1 U72.20(LAD2)
COM_LPC_AD3: R1316.1 U72.17(LAD3)
COM_LPC_CLK: R1317.1 U72.21(LCLK)
COM_LPC_FRAME: R1312.1 U72.22(LFRAME#)
COM_LPC_SERIRQ: R1311.1 U72.27(SERIRQ)
COM_TYPE0: R1304.2 R1307.1 U9.A14(IO_2_A14)
COM_TYPE1: R1305.2 R1308.1 U9.A15(IO_2_A15/DIFFIO_T22N)
COM_TYPE2: R1306.2 R1309.1 U9.A17(IO_2_A17)
COMA_INT: RB758.2 U52.L4(COMA)
COME_GPO3: J2.B63(GPO3) P1.H20(IO_B6_H20/DIFFIO_R19P/DQ0R)
COME_MANLAN_ACT: J2.B2(GBE0_ACT#) R1476.2 RB1300.1
COME_MANLAN_ACT_D_LED: LEDB13.A R1473.2
COME_MANLAN_ACT_LED: LEDB13.C R1476.1
COME_MANLAN_LINK: J2.A8(GBE0_LINK#) R1495.2
COME_MANLAN_LINK100: J2.A4(GBE0_LINK100#) R1496.2
COME_MANLAN_LINK1000: J2.A5(GBE0_LINK1000#) R1494.2
COME_MANLAN_LINK1000_D_LED: LEDB14.A R1474.2
COME_MANLAN_LINK1000_LED: LEDB14.C R1477.1
COME_MANLAN_LINK_ALL: R1477.2 R1494.1 R1495.1 R1496.1 RB1301.1
COME_SUS_S3_N: J2.A15(SUS_S3#) R1507.2
COME_SUS_S3_N_F: P1.H21(IO_B6_H21/DIFFIO_R19N) R1507.1
COME_SUS_S5_N: J2.A24(SUS_S5#) R1508.2
COME_SUS_S5_N_F: P1.J16(IO_B6_J16/DIFFIO_R6P) R1508.1
COME_WDT: J2.B27(WDT) P1.U7(IO_B3_U7/PLL6_CLKOUTP)
COML_S_ATA_ACT_N: D10.C2 J2.A28(S_ATA_ACT#) R1292.1
CONFIG_SET0: R1036.2 R1195.2 U52.D8(CONFIG#0)
CONFIG_SET1: R1037.2 R1043.2 U52.E9(CONFIG#1)
CONFIG_SET2: R1038.2 R1054.2 U52.F8(CONFIG#2)
CONFIG_SET3: R1039.2 R1044.2 R1055.2 R1056.2 U52.G7(CONFIG#3)
CONFIG_SET4: R1040.2 R1051.2 U52.F9(CONFIG#4)
CONFIG_SET5: R1041.2 R1045.2 U52.G9(CONFIG#5)
CONFIG_SET6: R1042.2 R1050.2 R1052.2 R1053.2 U52.G8(CONFIG#6)
CONN41_1_FPGA: CONN41.1 R1443.2
CONN41_2_FPGA: CONN41.2 R1444.2
CONN41_3_FPGA: CONN41.3 R1445.2
CONN41_4_FPGA: CONN41.4 R1446.2
CONN_1PPS_OUT_TO_RJ: P1.R13(IO_B4_R13/DIFFIO_B19P/DQ4B) R1172.2
CONN_JTAG_TCK: CONN28.1 R633.1 R641.1
CONN_JTAG_TDI: CONN28.3 R609.1 R621.2
CONN_JTAG_TDO: CONN28.9 R548.2 R555.1
CONN_JTAG_TMS: CONN28.5 R586.1 R597.2
CORE _CPLL_LOCK: R528.1 R529.2 U40.AK33(C_PLL_LOCK)
CPLD1_25M_OUT: C58.2 P1.A9(CLKIO8_A9/DIFFCLK_5N) R76.2
CPLD1_25M_OUT_R: OSC1.3(OUT) R69.1 R76.1
CPLD1_TCK_R: R355.2 U20.18(1Y1)
CPLD1_TMS_R: R419.2 U20.9(2Y1)
CPLD2_3V3: CB28.1 CB44.1 CB45.1 CB51.1 CB72.1 CB92.1 CB104.1 CB108.1 CB121.1 CB138.1 CB155.1 CB162.1 CB170.1 CB224.1 CB225.1 CB239.1 CB240.1 FB1.2 FB2.2 U9.A3(VCCIO2_4) U9.A16(VCCIO2_1) U9.C1(VCCIO1_1) U9.C18(VCCIO3_4) U9.G9(VCCIO2_3) U9.G10(VCCIO2_2) U9.J7(VCCIO1_2) U9.J12(VCCIO3_2) U9.K7(VCCIO1_3) U9.K12(VCCIO3_3) U9.M9(VCCIO4_2) U9.M10(VCCIO4_3) U9.T1(VCCIO1_4) U9.T18(VCCIO3_1) U9.V3(VCCIO4_1) U9.V16(VCCIO4_4)
CPLD2_25M_OUT: C101.2 R178.2 U9.J6(IO_1_J6/CLK0)
CPLD2_25M_OUT_R: OSC3.3(OUT) R178.1 R186.1
CPLD2_INT: P1.A10(IO_B7_A10/DIFFIO_T21N/DQ4T) R264.1 U9.K13(IO_3_K13/CLK2)
CPLD2_TCK: R302.2 R389.1
CPLD2_TCK_R: R389.2 U20.16(1Y2)
CPLD2_TDO: R318.2 U19.4(A)
CPLD2_TMS: R311.2 R397.1
CPLD2_TMS_R: R397.2 U20.7(2Y2)
CPLD23_INT_CPU: J2.A85(GPI3) P1.AB15(IO_B4_AB15/DIFFIO_B22N/DQ4B)
CPLD_FPGA_R_S1: R89.2 U9.F9(IO_2_F9/DIFFIO_T11P)
CPLD_FPGA_R_S2: R75.2 U9.G12(IO_3_G12/DIFFIO_R9N)
CPLD_FPGA_R_S3: R244.2 U9.F13(IO_3_F13/DIFFIO_R6P)
CPLD_FPGA_R_S4: R233.2 U9.H13(IO_3_H13/DIFFIO_R13P)
CPLD_FPGA_R_SCL: R181.2 U9.D12(IO_2_D12/DIFFIO_T22P)
CPLD_FPGA_R_SDA: R191.2 U9.M14(IO_3_M14/DIFFIO_R25P)
CPLD_FPGA_S1: P1.T21(IO_B5_T21/DIFFIO_R38P/DQ1R) R89.1
CPLD_FPGA_S2: P1.W22(IO_B5_W22/DIFFIO_R47N/DQ3R) R75.1
CPLD_FPGA_S3: P1.Y22(IO_B5_Y22/DIFFIO_R47P/DQ3R) R244.1
CPLD_FPGA_S4: P1.A21(IO_B6_A21/DIFFIO_R11P/DQ2R) R233.1
CPLD_FPGA_SCL: P1.D17(IO_B7_D17/DIFFIO_T36N) R181.1
CPLD_FPGA_SDA: P1.C12(IO_B7_C12/DIFFIO_T29N/DM2T) R191.1
CPLD_RJ_UART_RX_R: P1.B20(IO_B6_B20/DIFFIO_R9P/DQ2R) R205.1
CPLD_RST: P1.Y14(IO_B4_Y14/DIFFIO_B23N/DQ4B) U9.M12(IO_3_M12/DIFFIO_R23P)
CPLD_UART1_RX_R: P1.B21(IO_B6_B21/DIFFIO_R9N/DQS2R/CQ3R) R310.1
CPLD_VDD1P8: C864.1 C865.1 C866.1 C875.1 C877.1 CB13.1 CB101.1 CB109.1 CB113.1 CB114.1 CB128.1 CB129.1 CB140.1 CB153.1 CB161.1 CONN6.22 U9.G11(VCCINT_1) U9.H12(VCCINT_2) U9.J9(VCCINT_3) U9.J11(VCCINT_4) U9.K8(VCCINT_5) U9.K10(VCCINT_6) U9.L7(VCCINT_7) U9.M8(VCCINT_8) U71.12(VCORE1) U71.37(VCORE2) U71.49(VREGOUT) U71.64(VCORE3)
CPLD_VDD1P8_PG: CONN5.4 R134.2
CPLD_VDD1P8_PG_R: R134.1 U7.32(PWM2/GPI2)
CPLL_25M_R_CLK_N: CB1060.2 U40.V18(C_PLL_REFCLK_N)
CPLL_25M_R_CLK_P: CB1059.2 U40.V19(C_PLL_REFCLK_P)
CPLL_25M_REFCLK_N: CB1060.1 R401.1
CPLL_25M_REFCLK_P: CB1059.1 R402.1
CPLL_AVDD1P8: C372.1 CB531.1 CB559.2 CB560.1 L33.1 U40.Y17(C_PLL_AVDD1P8)
CPU_CTS_N: RB333.2 UB9.13(R1IN)
CPU_CTS_N_A: CB912.1 LB65.1 RB333.1
CPU_CTS_N_L: CB928.1 LB65.2 LB75.2 RJ1.F8
CPU_FPGA_PCIE_REFCLK_N: P1.N7(REFCLK0N_N7/DIFFCLK_0N) R1506.1 R1511.1
CPU_FPGA_PCIE_REFCLK_P: P1.M7(REFCLK0P_M7/DIFFCLK_0P,CLKIO20) R1505.1 R1510.1
CPU_FPGA_PCIE_TX_N: J2.A62(PCIE_TX2-) P1.Y1(GXB_RX0N)
CPU_FPGA_PCIE_TX_P: J2.A61(PCIE_TX2+) P1.Y2(GXB_RX0P)
CPU_MPHY_MDC: J2.C46(DDI3_PAIR2+) RB255.2
CPU_MPHY_MDC_R: RB255.1 RB256.1 U52.L3(MDC)
CPU_MPHY_MDIO: J2.D46(DDI2_PAIR2+) RB242.2
CPU_MPHY_MDIO_R: RB242.1 RB254.1 U52.M1(MDIO)
CPU_MPHY_SGMII_TX_0_N: C542.1 U52.A4(S_IN-)
CPU_MPHY_SGMII_TX_0_P: C548.1 U52.A3(S_IN+)
CPU_MPHY_SGMII_TX_0_S_N: C542.2 J2.D27(DDI1_PAIR0-)
CPU_MPHY_SGMII_TX_0_S_P: C548.2 J2.D26(DDI1_PAIR0+)
CPU_PEX_PCIEA_TX_0_N: J2.A69(PCIE_TX0-) U40.W34(PCIE_RX0_N)
CPU_PEX_PCIEA_TX_0_P: J2.A68(PCIE_TX0+) U40.W35(PCIE_RX0_P)
CPU_PROCHOT: P1.A19(IO_B7_A19/DIFFIO_T37P/DQ2T) R1291.2
CPU_RS232_C1+: CB914.2 UB9.1(C1+)
CPU_RS232_C1-: CB914.1 UB9.3(C1-)
CPU_RS232_C2+: CB921.2 UB9.4(C2+)
CPU_RS232_C2-: CB921.1 UB9.5(C2-)
CPU_RS232_CTS_N: RB322.1 UB9.12(R1OUT)
CPU_RS232_RTS_N: RB321.1 UB9.11(T1IN)
CPU_RS232_RXD: RB318.1 RB1304.1 UB9.9(R2OUT)
CPU_RS232_TXD: RB319.1 RB320.1 UB9.10(T2IN)
CPU_RS232_V+: CB922.2 UB9.2(V+)
CPU_RS232_V-: CB923.2 UB9.6(V-)
CPU_RTS_N: RB334.2 UB9.14(T1OUT)
CPU_RTS_N_A: CB913.1 LB66.1 RB334.1
CPU_RTS_N_L: CB929.1 LB66.2 LB76.2 RJ1.F1
CPU_RXD: RB336.2 UB9.8(R2IN)
CPU_RXD_A: CB916.1 LB71.1 RB336.1
CPU_RXD_L: CB931.1 LB71.2 LB78.2 RJ1.F6
CPU_TCK: U21.9(3A) U71.16(ADBUS0)
CPU_TDI: U21.12(4A) U71.17(ADBUS1)
CPU_TDO: U21.7(2A) U71.18(ADBUS2)
CPU_THERMALTRIP: J2.A35(THRMTRIP#) P1.AB6(IO_B3_AB6/DIFFIO_B10N/DM5B/BWS#)
CPU_TMS: U21.4(1A) U71.19(ADBUS3)
CPU_TXD: RB335.2 UB9.7(T2OUT)
CPU_TXD_A: CB915.1 LB70.1 RB335.1
CPU_TXD_L: CB930.1 LB70.2 LB77.2 RJ1.F3
CPU_UART1_TX_R: P1.D20(IO_B6_D20/DIFFIO_R10N) R259.1
DDR_A_RES_NEG: RB179.2 U40.AJ23(DDRA_RES_NEG)
DDR_A_RES_POS: RB180.2 U40.AH23(DDRA_RES_POS)
DDR_A_RES_VDD: RB180.1 U40.AH22(DDRA_RES_VDD)
DDR_A_RES_VSS: RB179.1 U40.AJ22(DDRA_RES_VSS)
DDR_AB_AVDD1P8: C271.1 CB423.1 CB424.1 CB430.1 CB448.1 CB458.2 CB463.1 CB464.2 CB466.1 L16.1 U40.AF21(DDRB_V_ANALOG1P8#2) U40.AF28(DDRA_V_ANALOG1P8#1) U40.AG17(DDRB_AVDD1P8) U40.AG21(DDRB_V_ANALOG1P8#1) U40.AG26(DDRA_AVDD1P8) U40.AG28(DDRA_V_ANALOG1P8#2)
DDR_ABC_AVDD1P8: C349.1 CB429.1 CB453.1 CB469.2 CB479.1 CB524.1 CB525.1 CB539.1 L30.1 U40.AB11(DDRC_AVDD1P8) U40.AE11(DDRC_V_ANALOG1P8#1) U40.AF11(DDRC_V_ANALOG1P8#2)
DDR_C_RES_NEG: RB178.2 U40.AH10(DDRC_RES_NEG)
DDR_C_RES_POS: RB185.2 U40.AE10(DDRC_RES_POS)
DDR_C_RES_VDD: RB185.1 U40.AF10(DDRC_RES_VDD)
DDR_C_RES_VSS: RB178.1 U40.AJ10(DDRC_RES_VSS)
DDR_GEN_FSEL0: RB3.1 UB1.14(FSEL0)
DDR_GEN_FSEL1: RB5.1 UB1.17(FSEL1)
DDR_GEN_OUT0_N: RB28.2 RB29.2 UB1.3(NQ0)
DDR_GEN_OUT0_P: RB39.2 RB40.2 UB1.2(Q0)
DDR_GEN_OUT1_N: RB6.2 RB7.2 UB1.6(NQ1)
DDR_GEN_OUT1_P: RB12.2 RB13.2 UB1.5(Q1)
DDR_GEN_OUT2_N: RB21.2 RB22.2 UB1.22(NQ2)
DDR_GEN_OUT2_P: RB37.2 RB38.2 UB1.23(Q2)
DDR_GEN_SEL: RB45.1 UB1.32(CLK_SEL)
DDR_GEN_VCCA: CB43.1 CB47.1 CB48.1 LB8.2 UB1.28(VCCA)
DDR_GEN_VCCO: CB25.1 CB26.1 CB32.1 CB34.1 LB4.2 UB1.4(VCCO_1) UB1.21(VCCO_2)
DDR_GEN_VDD: CB5.1 CB9.1 CB42.1 CB46.1 LB1.2 UB1.16(VCC_1) UB1.31(VCC_2)
DDR_GEN_XTAL_IN: CB7.2 OSCB1.1 UB1.9(XTAL_IN)
DDR_GEN_XTAL_OUT: RB2.2 UB1.10(XTAL_OUT)
DDR_GEN_XTAL_OUT_R: CB8.2 OSCB1.3 RB2.1
DDRA_100M_N: CB344.1 RB28.1
DDRA_100M_P: CB343.1 RB39.1
DDRA_100M_REFCLK_N: CB344.2 RB145.1 U40.AK24(DDRA_REFCLK_N)
DDRA_100M_REFCLK_P: CB343.2 RB145.2 U40.AJ24(DDRA_REFCLK_P)
DDRA_A0: RB50.2 U40.AU21(DDRA_A3_A6A11) UB5.P3(A0) UB6.P3(A0)
DDRA_A1: RB56.2 U40.AK21(DDRA_A7) UB5.P7(A1) UB6.P7(A1)
DDRA_A2: R142.2 U40.AT20(DDRA_A1_A1A9) UB5.R3(A2) UB6.R3(A2)
DDRA_A3: RB55.2 U40.AR25(DDRA_BA0_A2BA0) UB5.N7(A3) UB6.N7(A3)
DDRA_A4: RB51.2 U40.AU22(DDRA_A4_A13A12) UB5.N3(A4) UB6.N3(A4)
DDRA_A5: R144.2 U40.AM23(DDRA_BA1_A5BA1) UB5.P8(A5) UB6.P8(A5)
DDRA_A6: R141.2 U40.AR20(DDRA_A0_A7A8) UB5.P2(A6) UB6.P2(A6)
DDRA_A7: R145.2 U40.AM22(DDRA_A12) UB5.R8(A7) UB6.R8(A7)
DDRA_A8: R140.2 U40.AN21(DDRA_A11) UB5.R2(A8) UB6.R2(A8)
DDRA_A9: RB57.2 U40.AL21(DDRA_A8) UB5.R7(A9) UB6.R7(A9)
DDRA_A10: RB52.2 U40.AU24(DDRA_A6) UB5.M3(A10) UB6.M3(A10)
DDRA_A11: RB48.2 U40.AN20(DDRA_A9) UB5.T2(A11) UB6.T2(A11)
DDRA_A12: RB54.2 U40.AP21(DDRA_A13) UB5.M7(A12) UB6.M7(A12)
DDRA_A13: RB58.2 U40.AL22(DDRA_A10) UB5.T8(A13) UB6.T8(A13)
DDRA_ACT_N: R163.2 U40.AT24(DDRA_ACT_ABI_N) UB5.L3(ACT) UB6.L3(ACT)
DDRA_ALERT0: TPB43.1 U40.AT27(DDRA_ALERT_N_0) UB5.P9(ALERT)
DDRA_ALERT1: TPB44.1 U40.AM25(DDRA_ALERT_N_1) UB6.P9(ALERT)
DDRA_BA0: RB101.2 U40.AT21(DDRA_A2_A0A10) UB5.N2(BA0) UB6.N2(BA0)
DDRA_BA1: R146.2 U40.AT26(DDRA_BG0_A4BA2) UB5.N8(BA1) UB6.N8(BA1)
DDRA_BG0: R143.2 U40.AT23(DDRA_A5_A14A15) UB5.M2(BG0) UB6.M2(BG0)
DDRA_CAS_N: R226.2 U40.AU25(DDRA_CAS_N) UB5.M8(\\C\A\S/A15) UB6.M8(\\C\A\S/A15)
DDRA_CK_N: R305.2 U40.AP24(DDRA_CK_N) UB5.K8(\\C\K\) UB6.K8(\\C\K\)
DDRA_CK_P: R292.2 U40.AP25(DDRA_CK_P) UB5.K7(CK) UB6.K7(CK)
DDRA_CKE: R274.2 U40.AL24(DDRA_CKE) UB5.K2(CKE) UB6.K2(CKE)
DDRA_CS_N0: RB53.2 U40.AU27(DDRA_CS_N_0) UB5.L7(CS)
DDRA_CS_N1: RB59.2 U40.AN24(DDRA_CS_N_1) UB6.L7(CS)
DDRA_DBI_N0: U40.AN32(DDRA_DBI_N_0) UB5.E7(\N\F\/\L\D\M\/L\D\B\I\)
DDRA_DBI_N1: U40.AP30(DDRA_DBI_N_1) UB5.E2(\N\F\/\U\D\M\/U\D\B\I\)
DDRA_DBI_N2: U40.AJ25(DDRA_DBI_N_2) UB6.E7(\N\F\/\L\D\M\/L\D\B\I\)
DDRA_DBI_N3: U40.AJ28(DDRA_DBI_N_3) UB6.E2(\N\F\/\U\D\M\/U\D\B\I\)
DDRA_DQ0: U40.AR35(DDRA_DQ_2) UB5.G2(DQ0)
DDRA_DQ1: U40.AR32(DDRA_DQ_6) UB5.F7(DQ1)
DDRA_DQ2: U40.AT35(DDRA_DQ_4) UB5.H3(DQ2)
DDRA_DQ3: U40.AP34(DDRA_DQ_0) UB5.H7(DQ3)
DDRA_DQ4: U40.AP33(DDRA_DQ_3) UB5.H2(DQ4)
DDRA_DQ5: U40.AT33(DDRA_DQ_5) UB5.H8(DQ5)
DDRA_DQ6: U40.AN33(DDRA_DQ_1) UB5.J3(DQ6)
DDRA_DQ7: U40.AP31(DDRA_DQ_7) UB5.J7(DQ7)
DDRA_DQ8: U40.AU34(DDRA_DQ_8) UB5.A3(DQ8)
DDRA_DQ9: U40.AR29(DDRA_DQ_13) UB5.B8(DQ9)
DDRA_DQ10: U40.AT32(DDRA_DQ_10) UB5.C3(DQ10)
DDRA_DQ11: U40.AT29(DDRA_DQ_14) UB5.C7(DQ11)
DDRA_DQ12: U40.AU33(DDRA_DQ_9) UB5.C2(DQ12)
DDRA_DQ13: U40.AR28(DDRA_DQ_15) UB5.C8(DQ13)
DDRA_DQ14: U40.AR31(DDRA_DQ_11) UB5.D3(DQ14)
DDRA_DQ15: U40.AP28(DDRA_DQ_12) UB5.D7(DQ15)
DDRA_DQ16: U40.AM29(DDRA_DQ_16) UB6.G2(DQ0)
DDRA_DQ17: U40.AL28(DDRA_DQ_18) UB6.F7(DQ1)
DDRA_DQ18: U40.AN29(DDRA_DQ_19) UB6.H3(DQ2)
DDRA_DQ19: U40.AL25(DDRA_DQ_23) UB6.H7(DQ3)
DDRA_DQ20: U40.AN30(DDRA_DQ_17) UB6.H2(DQ4)
DDRA_DQ21: U40.AM28(DDRA_DQ_20) UB6.H8(DQ5)
DDRA_DQ22: U40.AN26(DDRA_DQ_22) UB6.J3(DQ6)
DDRA_DQ23: U40.AM26(DDRA_DQ_21) UB6.J7(DQ7)
DDRA_DQ24: U40.AK26(DDRA_DQ_31) UB6.A3(DQ8)
DDRA_DQ25: U40.AM32(DDRA_DQ_29) UB6.B8(DQ9)
DDRA_DQ26: U40.AH27(DDRA_DQ_25) UB6.C3(DQ10)
DDRA_DQ27: U40.AK30(DDRA_DQ_24) UB6.C7(DQ11)
DDRA_DQ28: U40.AJ26(DDRA_DQ_30) UB6.C2(DQ12)
DDRA_DQ29: U40.AK29(DDRA_DQ_26) UB6.C8(DQ13)
DDRA_DQ30: U40.AK27(DDRA_DQ_28) UB6.D3(DQ14)
DDRA_DQ31: U40.AJ29(DDRA_DQ_27) UB6.D7(DQ15)
DDRA_DQS0_N: U40.AU36(DDRA_DQS0_WCK01_N) UB5.F3(\\L\D\Q\S\)
DDRA_DQS0_P: U40.AT36(DDRA_DQS0_WCK01_P) UB5.G3(LDQS)
DDRA_DQS1_N: U40.AU30(DDRA_DQS1_N) UB5.A7(\\U\D\Q\S\)
DDRA_DQS1_P: U40.AU31(DDRA_DQS1_P) UB5.B7(UDQS)
DDRA_DQS2_N: U40.AN27(DDRA_DQS2_WCK23_N) UB6.F3(\\L\D\Q\S\)
DDRA_DQS2_P: U40.AP27(DDRA_DQS2_WCK23_P) UB6.G3(LDQS)
DDRA_DQS3_N: U40.AM31(DDRA_DQS3_N) UB6.A7(\\U\D\Q\S\)
DDRA_DQS3_P: U40.AL31(DDRA_DQS3_P) UB6.B7(UDQS)
DDRA_ODT: R255.2 U40.AU28(DDRA_ODT) UB5.K3(ODT) UB6.K3(ODT)
DDRA_PAR: RB49.2 U40.AR26(DDRA_PAR) UB5.T3(PAR) UB6.T3(PAR)
DDRA_RAS_N: R243.2 U40.AR22(DDRA_RAS_N) UB5.L8(\\R\A\S/A16) UB6.L8(\\R\A\S/A16)
DDRA_RST_N: RB98.2 U40.AR23(DDRA_RESET_N) UB5.P1(RESET) UB6.P1(RESET)
DDRA_TEN: RB103.2 RB108.1 UB5.N9(TEN) UB6.N9(TEN)
DDRA_VREF_1: CB186.1 CB201.1 RB118.2 RB122.1 RB124.1 UB5.M1(VREFCA)
DDRA_VREF_2: C143.1 C149.1 R256.2 R301.1 UB6.M1(VREFCA)
DDRA_WE_N: RB112.2 U40.AP22(DDRA_WE_N) UB5.L2(\\W\E/A14) UB6.L2(\\W\E/A14)
DDRA_ZQ_1: R322.2 UB5.F9(ZQ)
DDRA_ZQ_2: RB126.2 UB6.F9(ZQ)
DDRB_100M_N: CB342.1 RB6.1
DDRB_100M_P: CB341.1 RB12.1
DDRB_100M_REFCLK_N: CB342.2 RB146.1 U40.AK18(DDRB_REFCLK_N)
DDRB_100M_REFCLK_P: CB341.2 RB146.2 U40.AL18(DDRB_REFCLK_P)
DDRB_A0: R156.2 U14.P3(A0) U15.P3(A0) U40.AN9(DDRB_A6)
DDRB_A1: R150.2 U14.P7(A1) U15.P7(A1) U40.AH12(DDRB_A10)
DDRB_A2: RB67.2 U14.R3(A2) U15.R3(A2) U40.AJ11(DDRB_A0_A7A8)
DDRB_A3: R151.2 U14.N7(A3) U15.N7(A3) U40.AL9(DDRB_A2_A0A10)
DDRB_A4: R155.2 U14.N3(A4) U15.N3(A4) U40.AP7(DDRB_A5_A14A15)
DDRB_A5: RB60.2 U14.P8(A5) U15.P8(A5) U40.AJ16(DDRB_BA1_A5BA1)
DDRB_A6: RB91.2 U14.P2(A6) U15.P2(A6) U40.AK9(DDRB_A1_A1A9)
DDRB_A7: RB61.2 U14.R8(A7) U15.R8(A7) U40.AH15(DDRB_A7)
DDRB_A8: RB83.2 U14.R2(A8) U15.R2(A8) U40.AN8(DDRB_A4_A13A12)
DDRB_A9: R149.2 U14.R7(A9) U15.R7(A9) U40.AH13(DDRB_A9)
DDRB_A10: R154.2 U14.M3(A10) U15.M3(A10) U40.AK11(DDRB_A13)
DDRB_A11: R158.2 U14.T2(A11) U15.T2(A11) U40.AM8(DDRB_A3_A6A11)
DDRB_A12: R152.2 U14.M7(A12) U15.M7(A12) U40.AJ14(DDRB_A12)
DDRB_A13: R148.2 U14.T8(A13) U15.T8(A13) U40.AH16(DDRB_A8)
DDRB_ACT_N: R153.2 U14.L3(ACT) U15.L3(ACT) U40.AR7(DDRB_ACT_ABI_N)
DDRB_ALERT0: TPB45.1 U15.P9(ALERT) U40.AT8(DDRB_ALERT_N_0)
DDRB_ALERT1: TPB46.1 U14.P9(ALERT) U40.AK15(DDRB_ALERT_N_1)
DDRB_BA0: RB95.2 U14.N2(BA0) U15.N2(BA0) U40.AP9(DDRB_BA0_A2BA0)
DDRB_BA1: RB62.2 U14.N8(BA1) U15.N8(BA1) U40.AJ13(DDRB_A11)
DDRB_BG0: RB66.2 U14.M2(BG0) U15.M2(BG0) U40.AR8(DDRB_BG0_A4BA2)
DDRB_CAS_N: RB63.2 U14.M8(\\C\A\S/A15) U15.M8(\\C\A\S/A15) U40.AT6(DDRB_CAS_N)
DDRB_CK_N: RB111.2 U14.K8(\\C\K\) U15.K8(\\C\K\) U40.AM10(DDRB_CK_N)
DDRB_CK_P: RB115.2 U14.K7(CK) U15.K7(CK) U40.AM11(DDRB_CK_P)
DDRB_CKE: RB81.2 U14.K2(CKE) U15.K2(CKE) U40.AL15(DDRB_CKE)
DDRB_CS_N0: RB65.2 U15.L7(CS) U40.AU7(DDRB_CS_N_0)
DDRB_CS_N1: R147.2 U14.L7(CS) U40.AL13(DDRB_CS_N_1)
DDRB_DBI_N0: U15.E7(\N\F\/\L\D\M\/L\D\B\I\) U40.AT18(DDRB_DBI_N_0)
DDRB_DBI_N1: U15.E2(\N\F\/\U\D\M\/U\D\B\I\) U40.AT11(DDRB_DBI_N_1)
DDRB_DBI_N2: U14.E7(\N\F\/\L\D\M\/L\D\B\I\) U40.AN15(DDRB_DBI_N_2)
DDRB_DBI_N3: U14.E2(\N\F\/\U\D\M\/U\D\B\I\) U40.AM20(DDRB_DBI_N_3)
DDRB_DQ0: U15.G2(DQ0) U40.AR17(DDRB_DQ_5)
DDRB_DQ1: U15.F7(DQ1) U40.AT17(DDRB_DQ_4)
DDRB_DQ2: U15.H3(DQ2) U40.AT15(DDRB_DQ_7)
DDRB_DQ3: U15.H7(DQ3) U40.AU18(DDRB_DQ_3)
DDRB_DQ4: U15.H2(DQ4) U40.AR16(DDRB_DQ_6)
DDRB_DQ5: U15.H8(DQ5) U40.AP19(DDRB_DQ_2)
DDRB_DQ6: U15.J3(DQ6) U40.AU19(DDRB_DQ_0)
DDRB_DQ7: U15.J7(DQ7) U40.AR19(DDRB_DQ_1)
DDRB_DQ8: U15.A3(DQ8) U40.AU9(DDRB_DQ_12)
DDRB_DQ9: U15.B8(DQ9) U40.AU13(DDRB_DQ_9)
DDRB_DQ10: U15.C3(DQ10) U40.AR11(DDRB_DQ_13)
DDRB_DQ11: U15.C7(DQ11) U40.AT14(DDRB_DQ_8)
DDRB_DQ12: U15.C2(DQ12) U40.AM14(DDRB_DQ_15)
DDRB_DQ13: U15.C8(DQ13) U40.AR14(DDRB_DQ_10)
DDRB_DQ14: U15.D3(DQ14) U40.AR13(DDRB_DQ_11)
DDRB_DQ15: U15.D7(DQ15) U40.AN14(DDRB_DQ_14)
DDRB_DQ16: U14.G2(DQ0) U40.AP13(DDRB_DQ_16)
DDRB_DQ17: U14.F7(DQ1) U40.AN12(DDRB_DQ_18)
DDRB_DQ18: U14.H3(DQ2) U40.AM13(DDRB_DQ_23)
DDRB_DQ19: U14.H7(DQ3) U40.AR10(DDRB_DQ_17)
DDRB_DQ20: U14.H2(DQ4) U40.AP12(DDRB_DQ_19)
DDRB_DQ21: U14.H8(DQ5) U40.AN11(DDRB_DQ_21)
DDRB_DQ22: U14.J3(DQ6) U40.AP10(DDRB_DQ_20)
DDRB_DQ23: U14.J7(DQ7) U40.AK17(DDRB_DQ_22)
DDRB_DQ24: U14.A3(DQ8) U40.AP16(DDRB_DQ_29)
DDRB_DQ25: U14.B8(DQ9) U40.AM19(DDRB_DQ_26)
DDRB_DQ26: U14.C3(DQ10) U40.AK20(DDRB_DQ_24)
DDRB_DQ27: U14.C7(DQ11) U40.AM17(DDRB_DQ_31)
DDRB_DQ28: U14.C2(DQ12) U40.AP15(DDRB_DQ_28)
DDRB_DQ29: U14.C8(DQ13) U40.AJ19(DDRB_DQ_30)
DDRB_DQ30: U14.D3(DQ14) U40.AH21(DDRB_DQ_25)
DDRB_DQ31: U14.D7(DQ15) U40.AJ20(DDRB_DQ_27)
DDRB_DQS0_N: U15.F3(\\L\D\Q\S\) U40.AU15(DDRB_DQS0_WCK01_N)
DDRB_DQS0_P: U15.G3(LDQS) U40.AU16(DDRB_DQS0_WCK01_P)
DDRB_DQS1_N: U15.A7(\\U\D\Q\S\) U40.AT12(DDRB_DQS1_N)
DDRB_DQS1_P: U15.B7(UDQS) U40.AU12(DDRB_DQS1_P)
DDRB_DQS2_N: U14.F3(\\L\D\Q\S\) U40.AL16(DDRB_DQS2_WCK23_N)
DDRB_DQS2_P: U14.G3(LDQS) U40.AM16(DDRB_DQS2_WCK23_P)
DDRB_DQS3_N: U14.A7(\\U\D\Q\S\) U40.AN17(DDRB_DQS3_N)
DDRB_DQS3_P: U14.B7(UDQS) U40.AN18(DDRB_DQS3_P)
DDRB_ODT: RB80.2 U14.K3(ODT) U15.K3(ODT) U40.AT9(DDRB_ODT)
DDRB_PAR: R157.2 U14.T3(PAR) U15.T3(PAR) U40.AU6(DDRB_PAR)
DDRB_RAS_N: RB64.2 U14.L8(\\R\A\S/A16) U15.L8(\\R\A\S/A16) U40.AL10(DDRB_RAS_N)
DDRB_RST_N: R237.2 U14.P1(RESET) U15.P1(RESET) U40.AL12(DDRB_RESET_N)
DDRB_TEN: R269.1 R270.2 U14.N9(TEN) U15.N9(TEN)
DDRB_VREF_1: CB183.1 CB195.1 RB105.2 RB117.1 RB120.1 U15.M1(VREFCA)
DDRB_VREF_2: CB177.1 CB203.1 RB113.2 RB119.1 U14.M1(VREFCA)
