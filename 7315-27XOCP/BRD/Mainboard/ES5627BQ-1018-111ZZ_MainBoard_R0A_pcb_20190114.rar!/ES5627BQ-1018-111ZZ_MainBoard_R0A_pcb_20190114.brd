# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_USB: length 1.7
  BOTTOM w0.508: v2(83.53,18.9) 83.59,18.9 84.1,18.39 84.8,18.39 84.99,18.2
GND_VCC1P2: length 91.9
  TOP w0.254: v1(122.5,177.59) 122.5,176.84 U35.1
  TOP w0.381: QB4.S 85.17,205.41 85.01,205.24 84.85,205.24 84.76,205.33 v1(84.76,205.28) ; QB5.S v1(83.63,225.46)
  TOP w0.508: R635.2 126.87,175.99 R649.2
  S5 w0.381: v1(120.4,187.97) 125.81,182.56 125.81,179.38 126.01,179.17
  S14 w0.381: v1(120.4,187.97) 117.39,187.97 110.22,195.14 94.43,195.14 94.42,195.15 91.88,195.15 86.72,200.3 85.89,200.3 85.19,201.01 85.19,201.01 84.01,202.19 84.01,204.47 84.76,205.22 v1(84.76,205.28) 84.76,205.94 84.2,206.5 81.31,206.5 79.12,208.69 79.12,212.85 79.65,213.38 79.65,215.5 79.25,215.9 79.25,217.42 80.77,218.95 80.77,220.04 81.28,220.55 82.41,221.68 82.41,224.38 83.49,225.46 v1(83.63,225.46)
  BOTTOM w0.381: v1(122.5,177.59) 122.5,178.4 v2(122.36,178.54)
  vias: v1(127.68,176.87) v1(127.68,176.19) v1(127.78,171.26) v1(128.47,171.26)
GND_VCC1V: length 222.8
  TOP w0.254: v1(116.91,100.18) 116.4,100.68 U44.1
  TOP w0.381: v1(109.64,95.35) 109.44,95.35 109.06,95.73 R784.1 ; R782.2 v1(113.5,95.98) ; R785.2 v1(114.77,95.43)
  TOP w0.508: Q5.S 84.12,231.64 v1(83.91,231.85) ; Q2.S 83.97,234.67 v1(83.09,233.78)
  S14 w0.508: v1(109.64,95.35) 109.42,95.12 106.8,95.12 105.25,96.67 105.25,100.23 107.66,102.64 107.66,108.76 109.87,110.97 115.39,110.97 120.39,115.97 129.51,115.97 131.26,117.72 131.26,135.33 134.85,138.92 134.85,145.69 133.7,146.85 133.7,151.67 135.68,153.65 135.68,166.27 129.87,172.07 129.87,173.02 130.48,173.63 130.48,180.81 125.37,185.91 115.91,185.91 109.65,192.18 87.25,192.18 83.46,195.96 83.46,198.41 75.62,206.26 75.62,220.47 79.02,223.87 79.02,231.25 81.56,233.78 v1(83.09,233.78) 83.91,232.95 v1(83.91,231.85)
  BOTTOM w0.127: v1(83.09,233.78) 82.45,234.41 v2(82.45,235.11)
GND_VCC1V_RH: length 199.1
  TOP w0.127: v1(81.5,231.71) 81.5,231.71 81.5,231.68 81.94,232.13 81.94,233.69 Q2.D
  S14 w0.127: v1(81.5,231.71) 81.5,231.71 81.5,231.68 80.15,230.34 80.15,223.08 80.69,222.54 80.69,221.86 76.71,217.88 76.71,207.71 85.52,198.89 87.18,198.89 91.76,194.31 109.17,194.31 116.39,187.09 127.47,187.09 130.17,184.38 130.17,183.29 131.35,182.11 131.35,171.34 137.64,165.05 137.64,145.59 136.92,144.87 136.92,139.22 132.3,134.59 132.3,114.43 125.7,107.83 125.7,102.69 122.84,99.83 119.69,99.83 117.62,97.76 113,97.76 v1(112.49,98.27)
  BOTTOM w0.127: v1(81.5,231.71) 80.99,232.22 v2(80.99,232.89) ; R538.2 v1(112.49,98.27)
GND_VCC1V_RH_R: length 5.2
  TOP w0.254: R537.1 112.49,96.49 v1(111.98,95.98)
  BOTTOM w0.203: R537.1 112.82,96.67 113,96.85 113,98.91 v2(113.5,99.41)
  BOTTOM w0.254: v1(111.98,95.98) 112.49,96.49 R537.1
GND_VCC1V_RL: length 197.7
  TOP w0.127: Q5.D 81.92,228.49 v1(81.84,228.41)
  S14 w0.127: v1(111.6,98.27) 112.36,97.51 117.73,97.51 119.7,99.48 122.85,99.48 125.95,102.58 125.95,107.72 132.55,114.33 132.55,134.49 137.24,139.18 137.24,144.66 138,145.42 138,165.28 131.66,171.62 131.66,182.25 130.67,183.25 130.67,184.62 127.89,187.4 116.64,187.4 109.47,194.56 91.92,194.56 87.33,199.16 85.76,199.16 76.96,207.96 76.96,217.55 81.72,222.31 81.72,228.16 81.84,228.28 v1(81.84,228.41)
  BOTTOM w0.127: R521.2 111.47,98.14 v1(111.6,98.27) ; v2(81.05,230.67) 80.99,230.6 80.99,229.26 v1(81.84,228.41)
GND_VCC1V_RL_R: length 3.2
  TOP w0.254: v1(111.22,95.98) 111.47,96.24 R520.1
  BOTTOM w0.254: v1(111.22,95.98) 111.47,96.24 R520.1 111.47,96.67 110.91,96.67 v2(110.2,97.38)
GND_VCC2P5: length 138.4
  TOP w0.254: U32.1 37.7,191.1 v1(37.32,191.48)
  TOP w0.381: QB2.S 141.34,231.11 v1(141.33,231.12)
  TOP w0.508: v1(44.1,196.44) 44.1,195.48 R588.2 ; v1(35.33,195.74) R507.2 v1(36.22,196.7) ; 34.4,190.46 35.03,190.46 v1(35.67,191.1) ; v1(39.72,195.68) 39.73,195.66 R547.1 ; v1(83.79,221.78) 83.78,221.78 QB6.S
  S7 w0.381: v1(39.72,195.68) 40.16,195.23 44.54,195.23 46.26,196.95 57.88,196.95 70.58,209.65 71.65,209.65 83.78,221.78 v1(83.79,221.78)
  S12 w0.508: v1(141.33,231.12) 139.53,231.12 137.12,233.53 127.54,233.53 124.65,236.41 95.49,236.41 95.37,236.29 91.88,236.29 88.55,232.95 87,232.95 84.1,230.06 84.1,229.12 82.65,227.67 82.65,222.91 v1(83.79,221.78)
  BOTTOM w0.508: v1(37.32,191.48) 37.05,191.75 37.05,193.2 v2(36.94,193.31)
  vias: v1(36.54,191.11)
GND_XO: length 12.9
  TOP w0.508: R800.1 v1(264.25,106.14) ; R800.1 265.13,106.29 OCXO1.7 ; R800.1 v1(265.27,105.13) ; C484.1 v1(243.35,131.85)
  TOP w1.27: OCXO2.3 247.78,124.38 247.78,124.38 v1(247.7,124.38) v1(247.7,125.53)
GNDP: length 118.8
  G4 w0.381: 1.78,19.81 J1_PF.2 ; J1_PF.2 2.74,20.76 ; J1_PF.2 2.74,18.86 ; J1_PF.2 3.69,19.81 ; 1.78,28.81 J1_PF.3 ; J1_PF.3 3.69,28.81 ; J1_PF.3 2.74,27.86 ; J1_PF.3 2.74,29.76 ; CONNB2.G2 83.78,10.6 ; CONNB2.G2 82.83,8.9 ; CONNB2.G2 81.89,10.6 ; CONNB2.G2 82.83,12.3 ; 95.63,8.9 CONNB2.G1 ; CONNB2.G1 96.58,10.6 ; CONNB2.G1 95.63,12.3 ; CONNB2.G1 94.69,10.6 ; RJ1.G8 267.14,4.61 ; RJ1.G8 268.33,3.42 ; RJ1.G8 267.14,2.23 ; RJ1.G8 265.95,3.42 ; 21.74,14.36 J1_PF.12 ; J1_PF.12 21.74,16.26 ; J1_PF.12 20.78,15.31 ; J1_PF.12 22.69,15.31 ; 221,3.42 RJ1.G1 ; RJ1.G1 222.19,2.23 ; RJ1.G1 222.19,4.61 ; RJ1.G1 223.38,3.42 ; J1_PF.1 3.69,10.81 ; J1_PF.1 1.78,10.81 ; J1_PF.1 2.74,9.86 ; J1_PF.1 2.74,11.76 ; 1.78,37.81 J1_PF.4 ; J1_PF.4 2.74,36.86 ; J1_PF.4 2.74,38.76 ; 1.78,48.51 J1_PF.5 ; J1_PF.5 2.74,49.46 ; J1_PF.5 2.74,47.56
  G6 w0.381: J1_PF.3 2.74,29.76 ; J1_PF.3 3.69,28.81 ; J1_PF.3 2.74,27.86 ; J1_PF.3 1.78,28.81 ; J1_PF.5 2.74,49.46 ; J1_PF.5 2.74,47.56 ; J1_PF.5 3.69,48.51 ; J1_PF.5 1.78,48.51 ; J1_PF.4 2.74,38.76 ; J1_PF.4 3.69,37.81 ; J1_PF.4 1.78,37.81 ; J1_PF.4 2.74,36.86 ; 222.95,15.94 RJ1.G2 ; RJ1.G2 224.14,17.13 ; RJ1.G2 222.95,18.32 ; RJ1.G2 221.76,17.13 ; 21.74,23.36 J1_PF.11 ; J1_PF.11 20.78,24.31 ; J1_PF.11 22.69,24.31 ; J1_PF.11 21.74,25.26 ; 2.74,9.86 J1_PF.1 ; J1_PF.1 1.78,10.81 ; J1_PF.1 3.69,10.81 ; J1_PF.1 2.74,11.76 ; J1_PF.12 21.74,16.26 ; J1_PF.12 21.74,14.36 ; J1_PF.12 20.78,15.31 ; J1_PF.12 22.69,15.31 ; 94.69,10.6 CONNB2.G1 ; CONNB2.G1 96.58,10.6 ; CONNB2.G1 95.63,12.3 ; CONNB2.G1 95.63,8.9 ; RJ1.G7 267.57,13.83 ; RJ1.G7 266.38,15.02 ; RJ1.G7 266.38,12.64 ; RJ1.G1 222.19,4.61 ; RJ1.G1 223.38,3.42 ; RJ1.G1 221,3.42 ; RJ1.G1 222.19,2.23 ; 267.14,2.23 RJ1.G8 ; RJ1.G8 265.95,3.42 ; RJ1.G8 267.14,4.61 ; RJ1.G8 268.33,3.42 ; 2.74,18.86 J1_PF.2 ; J1_PF.2 1.78,19.81 ; J1_PF.2 3.69,19.81 ; J1_PF.2 2.74,20.76 ; 267.14,18.23 RJ1.G6 ; RJ1.G6 267.14,20.61 ; RJ1.G6 268.33,19.42 ; CONNB2.G2 82.83,12.3 ; CONNB2.G2 81.89,10.6 ; CONNB2.G2 83.78,10.6 ; CONNB2.G2 82.83,8.9 ; RJ1.G3 223.38,23.48 ; RJ1.G3 222.19,24.67 ; RJ1.G3 221,23.48 ; RJ1.G3 222.19,22.29
  G10 w0.381: 222.19,2.23 RJ1.G1 ; RJ1.G1 222.19,4.61 ; RJ1.G1 221,3.42 ; RJ1.G1 223.38,3.42 ; 267.14,2.23 RJ1.G8 ; RJ1.G8 267.14,4.61 ; RJ1.G8 268.33,3.42 ; RJ1.G8 265.95,3.42
  BOTTOM w0.254: H14.3 7.52,75.15 v2(7.52,79.35)
  vias: v1(1.36,68.17) v1(1.36,65.5) v1(1.36,63.09) v1(3.65,77.7) v1(3.65,76.81) v1(3.65,75.74) v1(4.54,77.7) v1(5.43,77.7)
V0P6_VTT_VIN: length 7.9
  TOP w0.127: v1(64.87,188.9) 62.94,188.9
  TOP w0.381: R58.2 64.77,189.61 ; R58.2 64.08,190.3 ; R58.2 64.77,190.86 ; 63.78,188.22 C32.1 62.94,188.9 ; 62.75,190.05 C23.1
  TOP w0.508: C23.1 62.06,189.65 62.32,189.4
  BOTTOM w0.127: v1(64.87,188.9) 64.7,189.08 v2(63.91,189.08)
VBUS_5V: length 4
  BOTTOM w0.254: 101.15,20.91 CB962.2
  BOTTOM w0.508: LB85.2 99.76,22.1 100.42,21.44
  vias: v2(98.39,20.99)
VCC1V0_ADDR: length 7
  TOP w0.254: R579.1 119.78,126.26 119.47,125.96 117.95,125.96 117.49,126.41 R578.2 116.93,127.15 ; 116.93,127.15 v1(116.93,127.16) ; 116.93,127.15 116.54,127.15 116.21,126.82 U33.28
  BOTTOM w0.127: v1(116.93,127.16) 116.66,127.16 v2(115.71,126.21)
VCC1V0_COMP: length 5
  TOP w0.254: U33.11 109.61,122.58 v1(108.68,121.64) 108.3,122.02 C331.1 107.66,122 R643.2
  BOTTOM w0.254: v1(108.68,121.64) v2(107.88,121.64)
VCC1V0_COMP_R: length 2.6
  TOP w0.254: C335.1 R643.1 107.66,119.81 v1(107.28,119.43)
  BOTTOM w0.254: v1(107.28,119.43) v2(107.28,118.63)
VCC1V0_CSP1: length 35.6
  TOP w0.254: U33.3 109.13,126.82 108.91,127.05 v1(108.66,127.05) ; v1(94.83,119.35) 95.51,118.68 U39.1
  S9 w0.203: v1(94.83,119.35) 94.66,119.17 94.13,119.17 92.58,117.62 92.58,115.56 95.28,112.86 99.92,112.86 101.01,113.95 101.01,118.11 101.29,118.39 102.86,118.39 105.06,120.58 105.06,123.82 108.28,127.05 v1(108.66,127.05)
  BOTTOM w0.254: v2(94.12,119.72) 94.48,119.35 v1(94.83,119.35)
VCC1V0_CSP2: length 26
  TOP w0.254: U30.1 95.59,134.43 95.49,134.52 94.91,135.1 v1(94.91,135.23) ; U33.4 108.8,126.33 v1(108.75,126.37)
  S9 w0.203: v1(108.75,126.37) 109.38,126.99 109.38,128.31 107.36,130.32 105.61,130.32 104.37,129.08 97.09,129.08 96.61,129.55 96.61,133.53 v1(94.91,135.23)
  BOTTOM w0.127: v2(94.91,136.17) v1(94.91,135.23)
VCC1V0_CSP3: length 4.4
  TOP w0.254: R577.1 108.16,126.17 108.16,126.17 v1(108.65,125.67) 108.8,125.82 U33.5
  BOTTOM w0.254: v1(108.65,125.67) 106.93,125.67 v2(106.9,125.7)
VCC1V0_CSP4: length 3.2
  TOP w0.254: U33.6 109.12,125.33 v1(108.78,124.98) 107.82,124.98 R589.1
  BOTTOM w0.254: v1(108.78,124.98) v2(109.57,124.98)
VCC1V0_IMAX: length 4.7
  TOP w0.254: R531.1 R532.1 v1(114.9,129.87) 114.36,129.33 U33.32
  BOTTOM w0.254: v1(114.9,129.87) v2(114.11,129.87)
VCC1V0_IMON: length 5.8
  TOP w0.254: v1(108.78,127.73) 109.19,127.33 U33.2
  BOTTOM w0.254: v1(108.78,127.73) 107.66,127.73 107.6,127.67 107.47,127.67 v2(107.41,127.61)
  BOTTOM w0.381: CB404.1 110.48,128.11 RB176.2 110.52,127.75 110.19,127.42 109.19,127.42 108.87,127.73 v1(108.78,127.73)
VCC1V0_ISUM: length 3.8
  TOP w0.254: U33.12 110.86,122.11 110.65,121.89 110,121.89 v1(109.44,121.33) R644.2
  BOTTOM w0.254: v2(109.67,120.57) 109.44,120.8 v1(109.44,121.33)
VCC1V0_O-USR: length 5.2
  TOP w0.254: R525.2 118.2,129.77 117.49,129.06 R554.2 v1(116.81,128.75) 115.88,127.82 U33.30
  BOTTOM w0.127: v1(116.81,128.75) 117.41,128.75 v2(117.62,128.96)
VCC1V0_OCP: length 6.6
  TOP w0.254: R559.1 105.88,128.04 v1(106.29,128.45) 106.33,128.49 R560.1 109.39,128.49 109.61,128.26 U33.1
  BOTTOM w0.127: v1(106.29,128.45) 105.38,128.45 v2(104.97,128.04)
VCC1V0_PG: length 4.1
  TOP w0.254: R646.1 114.56,121.33 v1(114.11,121.33) 113.86,121.57 U33.18
  BOTTOM w0.254: TPB38.1 114.57,121.33 v1(114.11,121.33)
VCC1V0_PMB_ALERT_N: length 3.8
  TOP w0.254: R599.1 117.81,124.31 v1(117.02,125.1) 116.45,125.1 116.34,125.21 116.29,125.21 116.17,125.33 U33.25
  BOTTOM w0.127: v1(117.02,125.1) 117.92,125.1 v2(118.08,124.94)
VCC1V0_PMB_CLK: length 207
  TOP w0.127: v1(169.32,248.38) 169.3,248.38 168.79,247.88 167.83,247.88 166.56,249.15 RB18.2 RB17.1 ; RB718.1 v1(172.56,241.59)
  TOP w0.254: U33.24 116.18,124.82 116.74,124.26 116.89,124.26 116.89,124.27 v1(116.89,124.27)
  S7 w0.127: v1(169.32,248.38) 171.1,246.61 171.1,243.05 v1(172.56,241.59) 173.64,240.51 173.64,238.43 167.92,232.71 165.59,232.71 154.71,221.84 148.94,221.84 142.21,215.11 142.21,197.3 145.25,194.25 v1(145.25,193.71)
  S16 w0.127: v1(145.25,193.71) 148.96,190.01 154.48,190.01 157.51,186.98 157.51,176.36 158.08,175.79 158.08,171.02 169.72,159.38 169.72,149.64 166.94,146.85 166.68,146.85 166.34,146.52 166.34,144.06 161.76,139.48 142.5,139.48 141.46,138.44 138.63,138.44 129.95,129.77 125.31,129.77 119.81,124.27 v1(116.89,124.27)
VCC1V0_PMB_CLK_R: length 5.4
  TOP w0.127: CONN2.3 164.77,255.18 166.56,253.39 RB18.1
VCC1V0_PMB_DIO: length 200.2
  TOP w0.127: v1(168.55,248.42) 169.61,249.48 RB15.2 RB16.1 ; RB724.1 v1(172.56,240.45)
  TOP w0.254: v1(116.49,125.77) 116.43,125.82 U33.26
  S7 w0.127: v1(168.55,248.42) 168.55,248.14 170.53,246.16 170.53,242.68 172.56,240.65 v1(172.56,240.45) 172.56,240.18 171.03,238.65 171.03,237.27 169.76,236 167.16,236 153.7,222.54 147.92,222.54 140.68,215.3 140.68,201.05 141.18,200.55 141.18,196.98 v1(144.45,193.71)
  S16 w0.254: v1(116.49,125.77) 119.98,125.77 125.31,131.1 129.76,131.1 138.15,139.49 141.39,139.49 142.08,140.18 160.94,140.18 164.68,143.93 164.68,149.98 166.72,152.01 166.72,159.07 156.33,169.46 156.33,174.41 155.1,175.64 155.1,184.76 150.42,189.44 148.37,189.44 144.45,193.36 v1(144.45,193.71)
  BOTTOM w0.127: v2(173.32,239.88) 173.13,239.88 v1(172.56,240.45)
VCC1V0_PMB_DIO_R: length 8.4
  TOP w0.127: RB15.1 169.61,254.46 169.85,254.7 CONN2.1 v1(169.85,259.6)
  BOTTOM w0.127: v1(169.85,259.6) 169.88,259.58 v2(169.88,258.39)
VCC1V0_PWM1: length 22.8
  TOP w0.254: U33.38 111.36,129.38 111.62,129.64 v1(111.62,129.72) ; U39.12 101.14,118.68 101.29,118.82 101.29,119.23
  TOP w0.508: 101.29,119.23 101.29,120.09 v1(101.44,120.24)
  S7 w0.203: v1(101.44,120.24) 101.44,120.88 102.52,121.96 102.52,123.61 103.5,124.58 103.5,128.5 104.99,129.99 107.2,129.99 108.12,129.08 111.24,129.08 111.62,129.46 v1(111.62,129.72)
  BOTTOM w0.127: v2(111.62,130.5) v1(111.62,129.72)
VCC1V0_PWM2: length 19.7
  TOP w0.254: v1(101.06,135.86) 101.29,135.63 101.29,134.62 101.09,134.43 U30.12 ; U33.37 111.86,129.04 v1(112.28,129.46)
  S7 w0.203: v1(112.28,129.46) 112.31,129.49 112.31,131.86 107.67,136.5 101.69,136.5 v1(101.06,135.86)
  BOTTOM w0.127: v2(100.27,135.86) v1(101.06,135.86)
VCC1V0_RESET#: length 5.8
  TOP w0.254: U33.21 116.07,123.33 117.38,122.02 v1(119.09,122.02) R628.1
  BOTTOM w0.254: v1(119.09,122.02) 118.83,121.76 v2(118.83,120.99)
VCC1V0_SLEW: length 6.5
  TOP w0.254: U33.29 116.08,127.33 116.61,127.86 v1(117.19,127.86) 117.44,127.61 R567.2 117.87,127.79 118.25,128.17 119.22,128.17 R568.1
  BOTTOM w0.254: v2(115.86,128.24) 116.23,127.86 v1(117.19,127.86)
VCC1V0_TMAX: length 4.7
  TOP w0.254: R536.1 R535.2 v1(116.17,129.51) 116.04,129.39 115.23,129.39 114.86,129.02 U33.31
  BOTTOM w0.127: v1(116.17,129.51) v2(116.17,130.3)
VCC1V0_TSENSE: length 39.7
  TOP w0.254: v1(109.44,129.87) 109.74,130.17 C291.1 110.91,130.68 R533.2 110.36,130.14 U33.40 ; C340.1 v1(102.33,120.37) 101.79,119.83 101.79,118.69 101.28,118.18 U39.11 ; C274.1 102.48,135.2 102.05,135.2 101.67,134.82 101.67,134.38 101.21,133.93 U30.11
  TOP w0.508: v1(102.2,135.74) 102.76,135.74 C274.1
  S7 w0.203: v1(109.44,129.87) 108.75,129.87 v1(104.79,133.83)
  S14 w0.203: v1(104.79,133.83) 104.79,132.53 101.24,128.98 101.24,124.81 102.33,123.72 v1(102.33,120.37)
  S14 w0.508: v1(104.79,133.83) 104.36,133.83 102.45,135.74 v1(102.2,135.74)
  BOTTOM w0.127: v1(104.79,133.83) 104.79,133.41 v2(106.18,132.02)
VCC1V0_V3R3: length 3.3
  TOP w0.381: v1(121.38,121) C339.1 R628.2
  TOP w0.508: R665.2 v1(111.73,116.13)
  BOTTOM w0.381: v2(112.31,115.54) v1(111.73,116.13)
  vias: v1(105.07,126.87) v1(105.07,126.08) v1(105.07,125.32)
VCC1V0_V3R3_O: length 5.7
  TOP w0.254: U33.14 111.86,121.47 v1(111.73,121.33) 111.47,121.08 C337.1 111.8,120.64 112.11,120.34 112.11,119.4 111.73,119.02 R665.1
  BOTTOM w0.254: v2(111.73,120.53) v1(111.73,121.33)
VCC1V0_V5: length 5.6
  TOP w0.254: U33.15 112.36,121.53 v1(112.51,121.38) 112.51,121 R645.1 113.12,120.64 113.43,120.34 113.43,119.15 113.38,119.1 C352.1
  BOTTOM w0.254: v1(112.51,121.38) v2(112.51,122.28)
VCC1V0_V12: length 6.8
  TOP w0.254: R666.2 115.15,118.97 114.72,119.4 114.72,120.17 114.24,120.64 C338.1 113.99,120.64 113.36,121.27 v1(113.34,121.27) 113.34,121.61 112.86,122.09 U33.16
  BOTTOM w0.254: v2(113.5,119.77) 113.34,119.94 v1(113.34,121.27)
VCC1V0_VR_FAULT_N: length 4
  TOP w0.254: R590.1 117.87,125.33 117.43,125.78 117.36,125.78 116.81,126.34 v1(116.81,126.46) 116.67,126.33 U33.27
  BOTTOM w0.254: v1(116.81,126.46) 117.45,126.46 v2(117.82,126.84)
VCC1V0_VREF: length 57.8
  TOP w0.203: R636.2 v1(106.7,129.33)
  TOP w0.254: v1(94.83,118.59) 95.25,118.18 U39.2 ; U30.2 95.3,133.93 v1(94.83,134.39)
  S9 w0.203: v1(94.83,118.59) 94.66,118.77 94.3,118.77 92.91,117.38 92.91,115.8 95.43,113.28 99.81,113.28 100.61,114.08 100.61,118.29 101.12,118.79 102.69,118.79 104.65,120.75 104.65,123.99 106.9,126.24 106.9,129.13 v1(106.7,129.33) 106.7,129.64 106.42,129.92 105.78,129.92 104.54,128.67 96.92,128.67 96.21,129.39 96.21,133.36 95.17,134.39 v1(94.83,134.39)
  BOTTOM w0.127: v2(92.01,135.4) 93.97,135.4 94.83,134.54 v1(94.83,134.39)
  BOTTOM w0.254: v1(94.83,134.39) 95.09,134.14 CB348.1 ; v1(94.83,118.59) 94.89,118.64 CB527.1
VCC1V0_VREF13: length 19.2
  TOP w0.203: v1(104.21,127.28) 104.31,127.38 R559.2 104.31,129.31 R636.1
  TOP w0.254: U33.13 111.36,121.91 110.79,121.33 v1(110.19,121.33)
  TOP w0.508: R536.2 v1(117.19,132.08) ; v1(120.69,128.29) R568.2 R579.2 ; C336.1 110.19,120.91 v1(110.19,121.33) ; v1(109.44,119.06) R644.1 ; v1(105.83,121.02) 105.84,121.01 C335.2 106.77,121.14 C331.2 ; R525.1 118.2,132.05 ; R532.2 v1(114.9,133.07)
  S7 w0.203: v1(105.83,121.02) 105.83,121.52 105.22,122.13 105.22,124.28 104.46,125.04 104.46,127.02 v1(104.21,127.28)
  BOTTOM w0.127: v2(121.48,128.12) 121.31,128.29 v1(120.69,128.29)
  vias: v1(116.02,133.09)
VCC1V0_VRHOT_N: length 4.8
  TOP w0.254: R647.1 v1(116.82,121.32) 116.24,121.89 114.58,121.89 114.36,122.11 U33.19
  BOTTOM w0.254: v1(116.82,121.32) 116.82,121.79 v2(116.54,122.07)
VCC1V0_VSN: length 3
  TOP w0.254: R614.2 v1(108.36,123.04) 108.65,123.33 U33.10
  BOTTOM w0.254: v1(108.36,123.04) v2(109.29,123.04)
VCC1V0_VSP: length 2.8
  TOP w0.254: R605.2 108.17,124.05 v1(108.36,123.86) 108.4,123.83 U33.9
  BOTTOM w0.254: v1(108.36,123.86) v2(107.57,123.86)
VCC1V0_VSW6_5: length 3.7
  BOTTOM w0.254: v2(92.42,114.4) 93.67,114.4 v1(94.89,115.62)
  BOTTOM w0.508: CB578.1 v1(94.89,115.62)
VCC1V0_VSW6_5_C: length 3.9
  BOTTOM w0.508: RB202.1 93.62,113.06 v2(94.58,114.02) 95.27,114.71 CB578.2
VCC1V0_VSW6_6: length 3
  BOTTOM w0.254: v2(92.84,130.68) 92.86,130.71 94.45,130.71 v1(94.91,131.16)
  BOTTOM w0.508: v1(94.91,131.16) 94.96,131.11 CB388.1
VCC1V0_VSW6_6_C: length 3.1
  BOTTOM w0.508: RB173.1 95.22,128.5 94.58,129.13 v2(94.58,129.31) 95.47,130.2 CB388.2
VCC1V0_VSW6_VIN: length 1.9
  TOP w0.508: 100.75,127.25 100.5,126.99 C307.2 101.06,126.59 ; C392.2 99.89,111.61
  vias: v1(101.36,123.92) v1(101.36,123.19) v1(101.82,125.19) v1(102.76,125.47) v1(102.76,124.69) v1(102.84,115.82) v1(102.89,114.83) v1(103.63,113.18) v1(103.81,115.37) v1(103.78,114.63) v1(103.81,113.89) v1(104.5,116.03) v1(104.5,115.34) v1(104.6,113.92) v1(104.78,114.66) v2(105.85,114.74)
VCC1V2_BST_C: length 3.1
  TOP w0.254: v1(124.33,167.95) C305.1
  TOP w0.508: v1(124.33,167.95) 124.19,167.81 R566.2
  BOTTOM w0.254: v2(124.88,167.05) 124.33,167.6 v1(124.33,167.95)
VCC1V2_EN: length 8.4
  TOP w0.127: R592.2 124.54,171.71 124.54,173.56 124.17,173.93 v1(123.94,173.93) 123.59,173.93 123.56,173.91 U35.36
  BOTTOM w0.127: v2(123.06,175.94) 123.8,175.19 123.8,174.07 v1(123.94,173.93) 123.84,173.83 RB187.2 CB487.1
VCC1V2_LL: length 3.2
  BOTTOM w0.381: RB183.2 117.47,170.96
  BOTTOM w0.508: v1(120.01,168.19) 120.08,168.11 RB174.1
  vias: v1(115.82,170.6) v1(115.82,169.71) v1(115.82,168.95) v1(115.82,168.19) v1(115.92,167.36) v1(116.96,170.6) v1(116.96,169.71) v1(116.96,168.95) v1(116.96,168.19) v1(118.1,170.6) v1(119.3,170.63) v1(120.01,170.73) v1(120.01,169.71) v1(120.01,168.95) v1(120.77,169.69) v2(118.52,168.76)
VCC1V2_LL_R: length 9
  BOTTOM w0.254: CB500.2 126.05,173.05 123.32,170.31 122.82,170.31 v2(122.75,170.25) 122.67,170.17 CB408.2 RB174.2
VCC1V2_MODE: length 6.9
  TOP w0.254: U35.39 123.55,175.41 123.89,175.74
  TOP w0.508: R669.1 125.47,178.35 125.78,178.04 R660.2 v1(125.09,177.71) 123.94,176.57 123.94,175.8 123.89,175.74
  BOTTOM w0.127: v1(125.09,177.71) 125.64,178.26 v2(126.15,178.26)
VCC1V2_PGOOD: length 24.8
  TOP w0.127: U35.32 122.3,171.23 122.42,171.11 124.2,171.11 124.68,170.63 124.68,170.02 125.17,169.53 R570.1 125.34,170.09 v1(125.21,170.22)
  TOP w0.254: v1(127.98,179.04) 127.92,178.98 R669.2
  S16 w0.254: v1(127.98,179.04) 126.97,179.04 126.08,178.15 126.08,171.08 v1(125.21,170.22)
  BOTTOM w0.305: CONN34.1 130.64,168.82 126.33,168.82 v2(125.8,169.35) 125.21,169.94 v1(125.21,170.22)
VCC1V2_RF: length 4.6
  TOP w0.254: U35.38 123.69,174.91
  TOP w0.381: R649.1 124.47,175.57 124.47,175.39 v1(124.31,175.24) 123.98,174.91 123.69,174.91
  BOTTOM w0.381: v1(124.31,175.24) 124.31,175.91 v2(124.89,176.49)
VCC1V2_TAP: length 3.3
  BOTTOM w0.381: RB183.1 CB456.1 121.28,171.62 v2(120.95,171.29)
VCC1V2_TRIP: length 9.7
  TOP w0.254: v1(123.94,173.14) 123.68,173.41 U35.35
  TOP w0.381: R569.2 v1(126.61,167.5)
  S12 w0.254: v1(126.61,167.5) 126.61,169.87 125.19,171.3 125.19,172.31 124.36,173.14 v1(123.94,173.14)
  BOTTOM w0.254: v2(124.81,173.14) 123.95,173.14 v1(123.94,173.14)
VCC1V2_VBST: length 6.1
  TOP w0.254: 121.3,171.04 U35.30
  TOP w0.381: C305.2 124.2,169.66 v1(124.2,170.22) 123.89,170.53 121.8,170.53 121.3,171.04
  BOTTOM w0.254: v2(123.98,168.79) 124.2,169.01 v1(124.2,170.22)
VCC1V2_VDD: length 6.8
  TOP w0.254: U35.40 123.15,175.91 123.31,176.06
  TOP w0.508: 123.31,176.06 123.31,177.59 v1(123.69,177.97) C357.2 123.95,178.86 125.24,180.15 R686.2
  BOTTOM w0.381: v2(124.27,178.51) 124.24,178.51 v1(123.69,177.97)
VCC1V2_VFB: length 9
  TOP w0.254: R602.2 R612.2 R627.2 R635.1 v1(124.43,174.46) 123.61,174.46 123.56,174.41 U35.37
  BOTTOM w0.254: v2(126.8,176.47) 125.87,176.47 125.14,175.73 R635.1 v1(124.43,174.46)
VCC1V2_VFB_H: length 3.3
  TOP w0.254: R612.1 v1(126.74,173.14) R611.2
  BOTTOM w0.254: v1(126.74,173.14) 127.51,173.14 v2(128.29,172.36)
VCC1V2_VFB_L: length 2.2
  TOP w0.254: R601.2 v1(126.74,172.13) R602.1
  BOTTOM w0.254: v2(126.16,171.59) 126.69,172.13 v1(126.74,172.13)
VCC1V2_VIN: length 4.9
  TOP w0.254: U35.11 117.3,177.85 117.19,177.96 ; 115.29,175.19 115.58,174.91 U35.15
  TOP w0.381: 117.21,178.48 CB545.1 118.03,179.11
  BOTTOM w0.381: 117.47,178.48 CB545.1 118.03,179.06
  vias: v1(115.34,181.52) v1(115.34,180.82) v1(115.34,179.99) v1(115.34,179.17) v1(115.34,178.34) v1(116.11,181.52) v1(116.11,180.83) v1(116.11,179.99) v1(116.11,179.17) v1(116.23,183.04) v1(116.17,182.28) v2(116.81,178.15)
VCC1V2_VREG: length 17.4
  TOP w0.127: v1(125.44,167.87) 125.34,167.97 R570.2
  TOP w0.254: v1(121.07,177.76) 121.07,177.38 121.3,177.16 U35.3
  TOP w0.381: v1(121.07,177.76) 121.07,177.79 122.14,178.86 C358.2
  S5 w0.254: v1(121.07,177.76) 121.07,176.17 122.9,174.34 122.9,172.44 123.79,171.55 124.93,171.55 125.95,170.53 125.95,168.37 v1(125.44,167.87)
  BOTTOM w0.381: v1(121.07,177.76) 121.1,177.74 v2(121.1,176.85)
VCC1V_ENABLE: length 12.2
  TOP w0.254: U44.36 113.38,99.37 112.9,98.89 111.2,98.89 v1(110.84,98.52)
  TOP w0.508: v1(110.84,98.52) 110.82,98.51 110.82,97.95 R779.2
  BOTTOM w0.127: CB757.1 111.4,100.96 109.72,102.64 v2(109.72,103.96)
  BOTTOM w0.381: CB757.1 110.84,99.16 110.78,99.21 RB227.2 110.84,98.58 v1(110.84,98.52)
VCC1V_FB: length 10.3
  TOP w0.254: R791.2 114.01,95.63 114.04,95.65 114.04,97.3 113.76,97.58 R782.1 ; U44.37 113.88,99.28 113.5,98.91 v1(113.5,98.52) R782.1 ; R520.2 R537.2 R782.1
  BOTTOM w0.254: v2(115.08,97.58) R782.1 v1(113.5,98.52)
VCC1V_FB_R_R: length 4
  TOP w0.254: v1(112.58,93.6) 112.58,93.63 112.49,93.72 R791.1 111.04,94.71 R792.2
  BOTTOM w0.127: v2(113.75,93.64) 113.73,93.67 112.64,93.67 v1(112.58,93.6)
VCC1V_LL: length 18.5
  TOP w0.381: v1(106.21,104.44) 107.79,106.02 L43.2
  TOP w0.508: R746.1 106.26,102.21 106.77,102.72
  BOTTOM w0.254: RB218.1 110.47,95.29 109.6,96.16 109.6,97.1 106.23,100.47 v2(106.06,100.47) 105.86,100.67 105.86,104.09 v1(106.21,104.44) ; v1(112.11,107.8) v2(111.09,107.8)
  BOTTOM w0.508: RB214.2 v1(112.11,107.8)
VCC1V_LL_C: length 4.3
  TOP w0.254: R746.2 107.28,99.92 C448.1 v1(107.79,101.39)
  BOTTOM w0.127: v1(107.79,101.39) 106.66,102.52 v2(106.65,102.52)
VCC1V_LL_R: length 8.5
  BOTTOM w0.254: v2(115.82,92.69) 115.82,95.31 114.46,96.67 CB776.2 113.42,96.67 112.81,96.07 CB686.2 112.8,95.29 RB218.2
VCC1V_LL_SNUBBER: length 3.3
  BOTTOM w0.381: CB731.1 111.22,101.95 v2(110.94,102.23)
  BOTTOM w0.508: RB214.1 111.6,103.48 110.94,102.82 v2(110.94,102.23)
VCC1V_MODE: length 5.5
  TOP w0.254: U44.39 114.88,99.31 v1(115.41,98.78) 115.79,98.78 116.04,98.52 R773.2 116.08,98 116.31,98 117.31,97 R783.1
  BOTTOM w0.127: v1(115.41,98.78) 115.64,98.78 v2(116.07,99.21)
VCC1V_PGOOD: length 25.4
  TOP w0.254: U44.32 110.46,100.68 110.08,100.3 110.08,99.85 109.39,99.16 R758.1 109,98.83 108.3,98.12 108.3,97.25 v1(107.79,96.75) ; CONN46.1 119.68,96.7 R783.2
  S7 w0.254: v1(107.79,96.75) 108.26,96.27 108.26,95.47 109.06,94.67 113.48,94.67 113.94,94.21 116.52,94.21 117.37,95.06 CONN46.1
  BOTTOM w0.254: v2(108.26,97.4) 108.26,97.22 v1(107.79,96.75)
VCC1V_RF: length 5.5
  TOP w0.254: U44.38 114.38,98.66 v1(114.39,98.65) 114.77,98.27 R785.1
  BOTTOM w0.381: v1(114.39,98.65) 114.39,99.31 114.8,99.72 v2(114.8,101.65)
VCC1V_TRIP: length 6.5
  TOP w0.254: R784.2 109.06,97.76 v1(109.78,98.49) 110.57,99.27 112.7,99.27 112.88,99.45 U44.35
  BOTTOM w0.381: v1(109.78,98.49) 109.78,98.55 v2(109.03,99.3)
VCC1V_VBST: length 3.8
  TOP w0.254: C448.2 109.29,100.45 v1(109.29,101.34) 110.1,101.34 110.44,101.68 U44.30
  BOTTOM w0.127: v1(109.29,101.34) 108.7,101.93 v2(108.68,101.93)
VCC1V_VREG: length 16.5
  TOP w0.254: v1(117.59,101.42) 117.57,101.45 116.93,101.45 116.7,101.68 U44.3
  TOP w0.381: R758.2 108.1,98.83 107.66,98.4 v1(107.66,98.27)
  S16 w0.381: v1(107.66,98.27) 109.73,100.34 114.68,100.34 115.76,101.42 v1(117.59,101.42)
  BOTTOM w0.508: 118.85,101.3 C447.1 ; 118.85,101.3 118.73,101.42 v1(117.59,101.42) ; 118.85,101.3 v2(118.85,102.57)
VCC2V5_EN: length 5.6
  TOP w0.254: v1(41.15,192.8) 40.85,192.49 40.85,191.85 U32.36
  BOTTOM w0.508: v2(40.61,194.03) 40.99,193.65 40.99,192.96 v1(41.15,192.8) 40.67,192.31 CB400.1 39.7,192.01 RB168.2 RB167.2
VCC2V5_LL: length 4.8
  BOTTOM w0.508: v2(47.65,188.63) 47.15,189.14 47.15,190.23 v1(46.98,190.4) RB181.1 46.31,190.83 RB189.2
VCC2V5_LL_R: length 13.3
  TOP w0.381: v1(43.08,196.57) 43.08,195.66 C306.1
  BOTTOM w0.508: v1(43.08,196.57) 42.27,195.76 CB509.2 ; v1(43.08,196.57) 43.46,196.95 v2(43.46,197.9) ; v1(43.08,196.57) 43.08,196.19 43.57,195.69 46.24,195.69 46.89,195.04 47.15,195.04 47.85,194.34 47.85,193.93 46.72,192.8 RB189.1
VCC2V5_MODE: length 14.7
  TOP w0.254: U32.39 39.37,192.35 39.05,192.67 v1(39.02,192.67)
  TOP w0.508: v1(47.21,196) R616.2 45.12,196 R603.1
  S7 w0.508: v1(39.02,192.67) 39.76,192.67 41.18,194.09 44.54,194.09 46.45,196 v1(47.21,196)
  BOTTOM w0.381: v2(46.57,197.71) 46.57,196.63 v1(47.21,196)
VCC2V5_PGOOD: length 27.1
  TOP w0.254: U32.32 43.42,191.1 43.52,191.2 43.52,192.22 44.5,193.19 44.5,193.63 45.07,194.2 R603.2 45.68,194.53 v1(45.96,194.25)
  S12 w0.254: CONN31.1 46.87,195.11 46.01,194.25 v1(45.96,194.25)
  BOTTOM w0.381: v1(45.96,194.25) 45.22,194.98 35.21,194.98 v2(34.7,194.47) 34.32,194.09 34.32,190.27 RB159.2
VCC2V5_RF: length 6.7
  TOP w0.254: U32.38 39.87,193.08 39.62,193.33 v1(39.23,193.33) 36.74,193.33 36.22,193.85 R507.1
  BOTTOM w0.508: v2(38.64,194.22) 38.64,193.92 v1(39.23,193.33)
VCC2V5_TRIP: length 6.2
  TOP w0.254: U32.35 41.37,192.25 41.64,192.52 42.68,192.52 v1(42.84,192.69) 43.41,193.25 R588.1
  BOTTOM w0.127: v2(44.9,194.19) 44.35,194.19 v1(42.84,192.69)
VCC2V5_VDD: length 7.6
  TOP w0.254: 38.08,192.62 U32.40
  TOP w0.381: v1(35.54,193.43) 34.45,193.43 R490.2
  TOP w0.508: v1(35.54,193.43) C279.1 36.58,192.37 36.84,192.62 38.08,192.62
  BOTTOM w0.127: v2(35.14,192.57) 35.14,193.04 v1(35.54,193.43)
VCC2V5_VFB: length 9.8
  TOP w0.254: U32.37 40.37,193.01 40.69,193.33 41.69,193.33 v1(41.77,193.26) ; R781.2 38.46,194.05 R780.2 39.58,194.1 R547.2
  TOP w0.381: R547.2 40.3,193.95 40.5,194.15 R558.2 41.53,194.15 41.73,193.95 C306.2 42.27,193.77 42.02,193.51 v1(41.77,193.26)
  BOTTOM w0.381: v2(42.5,193.82) 42.43,193.82 42.43,193.83 42.51,193.83 42.51,193.84 42.35,193.84 v1(41.77,193.26)
VCC2V5_VFB_H: length 2.5
  TOP w0.254: R781.1 37.5,194.98 37.5,195.67 v1(37.49,195.68) 37.5,195.68 RB233.2
  BOTTOM w0.381: v1(37.49,195.68) 37.3,195.87 v2(37.3,196.63)
VCC2V5_VFB_L: length 2.6
  TOP w0.254: RB232.2 38.51,195.75 38.51,195.74 v1(38.51,195.68) 38.51,195.68 38.51,195.67 R780.1
  BOTTOM w0.381: v1(38.51,195.68) 38.51,195.74 39.31,196.54 v2(39.28,196.54)
VCC3V3_PCH_DRVH: length 10.8
  TOP w0.254: v1(167.76,128.24) 167.49,128.5 U31.13
  TOP w0.508: R623.2 165.72,122.14 166.11,122.53 D3.C 167.71,123.37 167.71,128.19 v1(167.76,128.24)
  BOTTOM w0.508: v2(167.92,126.72) 167.92,128.07 v1(167.76,128.24)
VCC3V3_PCH_DRVH_A_R: length 6.2
  TOP w0.381: U38.1 166.59,118.82 166.87,119.1 v1(166.87,119.48) D3.A 166.11,120.23 165.72,120.62 R623.1
  BOTTOM w0.508: v1(166.87,119.48) 166.46,119.88 v2(166.46,121.38)
VCC3V3_PCH_DRVL: length 8.6
  TOP w0.254: U31.11 165.47,126.47 v1(165.22,126.22)
  TOP w0.508: R622.2 165.22,123.79 v1(165.22,126.22)
  BOTTOM w0.508: v2(166.45,127.93) 166.46,127.93 166.46,127.46 v1(165.22,126.22)
VCC3V3_PCH_DRVL_A_R: length 4.1
  TOP w0.381: U38.4 163.55,119.21 163.57,119.23 v1(163.6,119.23) 163.57,119.26 R622.1
  BOTTOM w0.254: v2(165,119.54) 163.92,119.54 v1(163.6,119.23)
VCC3V3_PCH_EN_R: length 6.4
  TOP w0.254: U31.2 165.47,131.69 v1(165.85,132.07) R499.2
  BOTTOM w0.254: v2(168.18,133.7) 167.47,132.99 RB155.1
  BOTTOM w0.508: CB383.1 166.03,131.9 v1(165.85,132.07) 166.59,132.81 RB155.1
VCC3V3_PCH_MODE: length 11
  TOP w0.254: U31.5 163.57,130.16 v1(163.57,130.65)
  TOP w0.508: R504.2 R513.1 170.59,131.54 v1(170.59,131.54)
  S12 w0.508: v1(163.57,130.65) 163.63,130.72 167.1,130.72 167.67,131.29 169.38,131.29 169.64,131.54 v1(170.59,131.54)
  BOTTOM w0.127: v2(164.18,129.89) 164.18,130.04 v1(163.57,130.65)
VCC3V3_PCH_RF: length 5.1
  TOP w0.254: U31.4 164.47,131.15 164.2,131.41 163.18,131.41 v1(163.15,131.44) 163.01,131.31 R512.1
  BOTTOM w0.127: v1(163.15,131.44) 163.11,131.48 v2(161.56,131.48)
VCC3V3_PCH_SW: length 26.2
  TOP w0.254: U31.12 165.97,127.23 166.87,126.33
  TOP w0.508: 166.87,126.33 C310.2 v1(165.98,125.7)
  S12 w0.508: v1(165.98,125.7) 165.94,125.7 162.15,121.91 v1(162.15,121.62)
  BOTTOM w0.508: RB191.2 162.65,121.12 v1(162.15,121.62) ; v1(165.98,125.7) 165.09,124.81 161.07,124.81 159.41,126.46 v2(159.41,126.53) 159.41,132.5 160.05,133.13 RB188.1
VCC3V3_PCH_SW_C: length 4.7
  BOTTOM w0.508: v2(160.24,122.72) 160.24,120.5 RB191.1 160.62,118.84 CB584.1
VCC3V3_PCH_TRIP: length 5
  TOP w0.254: R492.1 v1(167.12,131.96) 167.12,131.8 166.08,130.76 U31.1
  BOTTOM w0.127: v1(167.12,131.96) 167.16,131.93 167.16,130.53 v2(166.46,129.84)
VCC3V3_PCH_VBST: length 3.3
  TOP w0.254: U31.14 v1(168.01,129.01) 169.02,129.01 R546.2
  BOTTOM w0.127: v1(168.01,129.01) 168.2,128.81 v2(168.88,128.81)
VCC3V3_PCH_VBST_R: length 9.3
  TOP w0.508: v1(165.98,124.18) C310.1 ; R546.1 v1(170.55,127.99)
  S12 w0.508: v1(165.98,124.18) 166.14,124.18 168.04,126.07 168.04,126.08 169.95,127.99 v1(170.55,127.99)
  BOTTOM w0.508: v2(167.11,124.36) 166.16,124.36 v1(165.98,124.18)
VCC3V3_PCH_VFB: length 7.1
  TOP w0.254: U31.3 164.97,131.79 v1(164.84,131.92) R498.2 163.87,132.86 ; 163.87,132.86 R497.2 ; 163.87,132.86 164.3,133.29 164.3,134.54 164.05,134.8 C275.1
  BOTTOM w0.127: v2(164.75,133.07) 164.75,132.01 v1(164.84,131.92)
VCC3V3_PCH_VFB_S: length 6.5
  TOP w0.508: R497.1 162.97,133.77 R496.1 162.43,132.52 v1(162.74,132.21)
  BOTTOM w0.254: v2(163.29,135.35) 163.29,133.58 162.85,133.13 CB522.1
  BOTTOM w0.508: CB522.1 162.46,132.49 v1(162.74,132.21)
VCC3V3_PCH_VIN: length 8.5
  TOP w0.127: C363.2 172.78,118.84 v1(173.41,119.47) ; v1(170.74,119.47) 170.75,119.46 C362.2
  TOP w0.508: C376.1 v1(169.04,116.53)
  BOTTOM w0.127: v1(173.41,119.47) 172.78,118.84 C363.2
  BOTTOM w0.254: v2(169.26,119.8) 170.41,119.8 v1(170.74,119.47)
  BOTTOM w0.508: C376.1 v1(169.04,116.53)
  vias: v1(170.74,120.23) v1(171.63,121.12) v1(171.63,120.23) v1(171.63,119.47) v1(172.52,121.12) v1(172.52,120.23) v1(172.52,119.47) v1(173.41,121.12) v1(173.41,120.23) v1(174.3,121.12) v1(174.3,120.23) v1(174.3,119.47) v1(175.19,121.12) v1(175.19,120.23) v1(175.19,119.47)
VCC3V3_PCH_VREG_VDRV: length 6.1
  TOP w0.254: R587.1 164.2,124.18 164.51,124.48 v1(164.51,125.7) 164.51,126.38 164.97,126.85 U31.10
  BOTTOM w0.508: v1(164.51,125.7) 164.49,125.71 v2(164.49,127.35)
VCC3V3_PCH_VREG_VREG: length 14.7
  TOP w0.254: R522.1 v1(169.74,129.84) ; C309.1 R587.2 v1(163.69,126.59) 163.82,126.59 164.47,127.23 U31.9
  S12 w0.508: v1(163.69,126.59) 164.2,127.1 167.69,127.1 169.74,129.15 v1(169.74,129.84)
  BOTTOM w0.127: v1(169.74,129.84) 169.98,130.08 v2(170.78,130.08)
  BOTTOM w0.508: v2(162.94,125.78) 162.94,125.84 v1(163.69,126.59)
VCC3V3_PGOOD: length 11.4
  TOP w0.254: R513.2 R522.2 168.26,130.53 v1(167.74,130.01) U31.16
  S12 w0.254: CONN13.1 172.62,130.66 168.81,130.66 168.16,130.01 v1(167.74,130.01)
  BOTTOM w0.127: v2(168.18,131.29) 168.18,130.44 v1(167.74,130.01)
VCC3V3_TAP: length 4.4
  TOP w0.508: v1(161.66,134.01) 161.65,134.02 161.65,134.37 162.08,134.8 C275.2
  BOTTOM w0.508: v2(161.13,135.23) 160.97,135.07 RB188.2 161.63,134.04 v1(161.66,134.01) 161.69,134.04 CB522.2
VCC5P0: length 324.7
  TOP w0.381: R645.2 112.87,119.4 v1(112.51,119.05) ; R4.1 v1(231.84,233.84)
  TOP w0.508: v1(161.77,251.27) 161.77,256.95 159.47,259.25 LEDB12.A ; R678.2 242.12,169.79 242.12,169.8 ; v1(245.4,170.65) 245.41,170.64 C264.1 ; 244.32,170.64 v1(244.31,170.65)
  S5 w0.508: v1(176.56,154.72) 176.5,154.66 176.5,151.99 173.08,148.58 173.08,145.69 171.73,144.34 171.73,139.87 167.85,135.99 156.11,135.99 151.73,131.61 149.71,131.61 145.35,127.25 141.6,127.25 140.11,125.77 140.11,118.91 141.51,117.51 v1(142.78,117.51) ; v1(96.87,120.88) 97.25,121.26 97.25,124.27 96.84,124.67 96.84,135.66 v1(96.87,135.68)
  S9 w0.381: 235.88,168.37 CONN24.1 ; CONN24.1 237.76,168.37 ; CONN24.1 236.82,169.31 ; CONN24.1 236.82,167.43
  S12 w0.381: v1(161.77,251.27) 168.59,251.27 169.32,252 196.69,252 207.91,240.78 208.71,240.78 208.73,240.8 208.74,240.8 209.16,241.23 209.17,241.24 209.77,241.84 212.12,241.84 219.76,234.2 231.49,234.2 v1(231.84,233.84) 231.92,233.84 233.83,231.93 233.83,229.91 234.41,229.33 235.85,229.33 236.74,228.45 236.74,223.15 236.39,222.8 236.39,215.09 241.01,210.47 241.01,208.13 239.93,207.05 235.36,207.05 230.17,201.85 230.17,199.46 227.89,197.19 227.89,196.27 220.28,188.65 220.28,185.09 219.87,184.69 219.87,166.03 v1(219.29,165.45)
  S16 w0.508: v1(142.78,117.51) 142.07,116.81 121.58,116.81 120.78,117.61 113.95,117.61 v1(112.51,119.05) 111.22,120.34 108.32,120.34 106.54,122.12 98.11,122.12 v1(96.87,120.88)
  BOTTOM w0.381: RB154.2 v1(96.87,135.68) v2(96.87,136.6)
  BOTTOM w0.508: 174.93,157.35 174.87,157.35 174.21,156.69 173.06,156.69 172.58,156.21 R1302.1 171.58,155.03 R1301.1 ; 174.93,157.35 174.93,158.9 173.72,160.1 R1303.1 ; 174.93,157.35 175.7,157.35 176.64,156.42 176.64,155.76 176.6,155.71 v1(176.6,155.47) ; v1(96.87,120.88) RB190.2
  vias: v1(177.62,155.47) v1(177.64,154.72) v1(216.16,150.24) v1(216.18,148.68) v1(217.33,150.27) v1(217.34,148.71) v1(218.55,150.27) v1(218.56,148.71) v1(242.33,171.54) v1(242.37,172.52) v1(242.35,170.64) v1(243.42,171.54) v1(243.44,170.64) v1(243.46,172.52) v1(244.31,171.62) v1(245.4,171.62)
VCC5P0_BODE: length 3.7
  TOP w0.508: C361.1 R667.2 242.91,165.46 v1(242.41,165.96) 242.12,166.25 R678.1
  BOTTOM w0.254: v2(241.52,165.96) v1(242.41,165.96)
VCC5P0_MON: length 12.8
  TOP w0.254: v1(233.08,223.18) U7.4 233.08,224.99 232.02,226.05 C19.1 231.54,226.66 231.3,226.9 231.3,228.56 231.67,228.93 R15.1 231.37,229.37 231.29,229.37 230.95,229.7 230.95,231.89 231.3,232.25 R4.2
  BOTTOM w0.127: v1(233.08,223.18) 233.08,224.58 v2(233.2,224.7)
VCC5P0_VIN: length 2.1
  TOP w0.508: 254.1,161.68 C311.1 ; 255.12,161.71 C312.1
  BOTTOM w0.254: v1(258.79,162.53) 258.92,162.66 259.55,162.66 259.55,162.66 v2(259.57,162.66)
VCC5V0_VDD5_5: length 5.7
  TOP w0.254: v1(94.89,116.41) 95.16,116.68 U39.5
  BOTTOM w0.254: v2(94.07,116.05) 94.43,116.41 v1(94.89,116.41)
  BOTTOM w0.508: RB190.1 CB572.2 96.28,116.43 96.1,116.61 RB192.1 95.39,116.41 v1(94.89,116.41)
VCC5V0_VDD5_6: length 7
  TOP w0.254: v1(94.89,132.23) 95.08,132.43 U30.5
  BOTTOM w0.381: v2(93.03,132.65) 93.73,131.95 94.61,131.95 v1(94.89,132.23) 95.59,132.23 RB162.1 96.03,131.8 CB381.2 RB154.1
VCC5V_STBY: length 1.9
  BOTTOM w0.508: C845.1 183.05,146.65 183.17,146.77 ; 183.32,145.65 C846.1 ; 183.16,147.67 C844.1
  vias: v1(185.53,144.06) v1(185.89,147.04) v1(185.89,146.34) v1(186.31,144.04) v1(186.66,146.34) v1(187.05,144.06) v2(187.29,147.29)
VCC12: length 227.5
  TOP w0.254: R6.1 v1(234.38,233.93)
  TOP w0.508: CONN6.4 58.37,229.27 ; CONN6.4 57.04,227.94 ; CONN6.4 58.37,226.6 ; CONN6.4 59.71,227.94 ; 57.04,233.44 CONN6.16 ; CONN6.16 59.71,233.44 ; CONN6.16 58.37,232.1 ; CONN6.16 58.37,234.77 ; CONN6.15 62.57,234.77 ; CONN6.15 61.24,233.44 ; CONN6.15 62.57,232.1 ; CONN6.15 63.91,233.44 ; 29.94,193.33 32.56,195.95 R490.1 ; 61.24,227.94 CONN6.3 ; CONN6.3 63.91,227.94 ; CONN6.3 62.57,226.6 ; CONN6.3 62.57,229.27 ; CB4.1 v1(61.69,224.51) ; CB31.1 v1(58.83,224.51) ; CB24.2 v1(57.81,224.51) ; C489.2 v1(154.71,90.71) ; C44.2 v1(62.7,224.51) ; R666.1 v1(115.15,116.13) ; R556.1 v1(158.23,127.48)
  V3 w0.762: 58.37,226.6 CONN6.4 ; CONN6.4 58.37,229.27 ; CONN6.4 59.71,227.94 ; CONN6.4 57.04,227.94 ; 62.57,226.6 CONN6.3 ; CONN6.3 63.91,227.94 ; CONN6.3 62.57,229.27 ; CONN6.3 61.24,227.94 ; 62.57,232.1 CONN6.15 ; CONN6.15 63.91,233.44 ; CONN6.15 61.24,233.44 ; CONN6.15 62.57,234.77 ; 57.04,233.44 CONN6.16 ; CONN6.16 58.37,234.77 ; CONN6.16 59.71,233.44 ; CONN6.16 58.37,232.1
  S12 w0.381: v1(234.38,233.93) 234.48,233.83 234.48,233.76 236.71,231.52 237.64,231.52 239.01,230.15 239.01,227.78 238.28,227.05 238.28,214.64 242.27,210.66 242.27,185.45 229.36,172.54 227.3,172.54 224.36,169.6 224.36,167.74 222.67,166.06 222.67,161.66 223.09,161.24 223.09,149.24 215.69,141.84 215.69,139.47 211.13,134.91 200.5,134.91 194.21,128.62 194.21,122.88 196.12,120.97 v1(196.25,120.97) v1(197.01,120.97) v1(197.78,120.97)
  BOTTOM w0.254: v2(64.14,222.76) 64.14,223.9 63.88,224.16 ; 56.9,224.03 56.13,223.27 v2(56.13,223.14)
  BOTTOM w0.381: v2(124.36,100.68) 124.17,100.49 v1(124.17,99.29)
  BOTTOM w0.508: 57.04,233.44 CONN6.16 ; CONN6.16 59.71,233.44 ; CONN6.16 58.37,232.1 ; CONN6.16 58.37,234.77 ; CONN6.4 59.71,227.94 ; CONN6.4 57.04,227.94 ; CONN6.4 58.37,229.27 ; CONN6.4 58.37,226.6 ; CONN6.3 62.57,229.27 ; CONN6.3 63.91,227.94 ; CONN6.3 61.24,227.94 ; CONN6.3 62.57,226.6 ; 62.57,232.1 CONN6.15 ; CONN6.15 62.57,234.77 ; CONN6.15 63.91,233.44 ; CONN6.15 61.24,233.44
  vias: v1(27.78,190.22) v1(27.78,189.39) v1(27.78,188.57) v1(27.78,187.81) v1(28.67,191.23) v1(28.67,190.35) v1(28.73,189.46) v1(28.73,188.57) v1(28.73,187.81) v1(29.62,191.23) v1(29.62,190.28) v1(29.62,189.46) v1(29.68,188.63) v1(29.68,187.87) v1(57.12,231.75) v1(57.12,230.86) v1(57.12,229.97) v1(57.18,236.07) v1(57.18,235.18) v1(57.81,225.4) v1(58,231.75) v1(58,230.86) v1(58,229.97) v1(58.07,236.07) v1(58.07,235.18) v1(58.83,225.4) v1(59.91,231.75) v1(59.91,230.86) v1(59.91,229.97) v1(59.97,236.07) v1(59.97,235.18) v1(60.8,231.75) v1(60.8,230.86) v1(60.8,229.97) v1(60.86,236.07) v1(60.86,235.18) v1(61.69,225.4) v1(62.7,231.75) v1(62.7,230.86) v1(62.7,229.97) v1(62.7,225.4) v1(62.77,236.07) v1(62.77,235.18) v1(63.59,231.75) v1(63.59,230.86) v1(63.59,229.97) v1(63.66,236.07) v1(63.66,235.18) v1(107.31,116.64) v1(108.14,115.64) v1(108.18,116.56) v1(108.2,114.71) v1(108.23,113.92) v1(108.7,117.52) v1(109.22,114.43) v1(109.67,115.72) v1(109.79,116.71) v1(111.15,186.54) v1(111.15,185.84) v1(111.15,185.07) v1(111.15,184.25) v1(112.23,186.54) v1(112.17,185.84) v1(112.17,185.07) v1(112.17,184.25) v1(113.25,186.54) v1(113.25,185.84) v1(113.25,185.07) v1(113.25,184.25) v1(120.51,97.48) v1(121.25,97.48) v1(123.36,113.46) v1(123.36,112.7) v1(123.36,111.94) v1(123.41,111.22) v1(124.12,113.46) v1(124.12,112.7) v1(124.12,111.94) v1(124.17,111.22) v1(124.17,110.46) v1(124.17,109.7) v1(124.88,113.46) v1(124.88,112.7) v1(124.88,111.94) v1(124.93,111.22) v1(124.93,110.46) v1(124.93,109.7) v1(126.97,182.56) v1(126.98,181.8) v1(127.82,181.81) v1(128.24,181.07) v1(128.3,180.31) v1(129,180.31) v1(152.6,90.73) v1(152.57,89.96) v1(153.29,90.73) v1(153.26,89.96) v1(154,90.7) v1(153.97,89.94) v1(157.23,127.51) v1(157.23,126.49) v1(158.24,126.49) v1(163.67,113.89) v1(163.67,113.13) v1(164.43,113.89) v1(164.43,113.13) v1(165.19,113.89) v1(165.19,113.13) v1(165.95,113.89) v1(165.95,113.13) v1(169.2,125.06) v1(169.2,124.3) v1(169.97,125.95) v1(169.97,125.06) v1(169.97,124.3) v1(170.73,126.72) v1(170.73,125.95) v1(170.73,125.06) v1(170.73,124.3) v1(171.49,126.72) v1(171.49,124.3) v1(171.55,125.94) v1(171.55,125.05) v1(172.31,126.7) v1(172.27,125.94) v1(172.27,125.05) v1(172.25,124.3) v1(173,124.3) v1(196.25,120.21) v1(196.25,119.44) v1(197.01,120.21) v1(197.01,119.44) v1(197.78,120.21) v1(197.78,119.44) v1(198.6,120.21) v1(198.6,119.44) v1(199.31,119.86) v2(57.28,238.89) v2(60.45,238.89) v2(63.5,238.89)
VCC12_MON: length 10.9
  TOP w0.254: R6.2 234.38,231.77 233.92,231.31 233.92,229.2 234.06,229.07 R18.1 234.56,229.07 235.1,228.54 235.1,226.99 234.77,226.66 C21.1 234.38,225.94 234.22,225.78 v1(234.22,225.78) 234.08,225.64 U7.2
  BOTTOM w0.127: v1(234.22,225.78) 234.28,225.84 v2(234.28,226.79)
VCC12V_53315_VDD: length 8
  TOP w0.254: C446.1 R765.2 116.75,98.6 v1(116.74,98.59) 115.79,99.54 115.56,99.54 115.38,99.72 U44.40
  BOTTOM w0.127: v1(116.74,98.59) 116.74,97.27 v2(117.31,96.7)
VCC12V_53315_VIN: length 4.7
  TOP w0.254: U44.11 117.42,105.68 v1(117.57,105.83)
  TOP w0.381: v1(114.52,108.81) C411.1 113.83,108.36 v1(114.14,108.05)
  BOTTOM w0.381: v1(114.14,108.05) 113.83,108.36 C411.1 v1(114.52,108.81)
  vias: v1(115.41,108.81) v1(115.41,107.8) v1(117.44,109.07) v1(117.44,108.3) v1(117.38,106.72) v1(118.71,106.65) v1(119.98,106.53) v1(120.03,104.49) v1(122.01,106.65) v1(122.47,108.43) v1(122.47,107.67) v1(122.52,105.51) v1(122.52,104.49) v1(123.54,107.26) v1(123.54,106.5) v1(123.54,105.51) v1(123.54,104.49) v2(114.65,106.91)
VCC12V_STBY: length 3.5
  TOP w0.254: 206.09,148.31 206.4,148.31 206.55,148.45 C850.1 ; 206.04,148.89 C850.1 ; C850.1 206.55,149.37 206.28,149.64 206.09,149.64
  BOTTOM w0.508: v1(197.45,140.94) 197.5,140.89 C849.1
  vias: v1(195.44,150.54) v1(195.44,149.65) v1(195.86,153.9) v1(195.94,153.01) v1(196.43,150.57) v1(196.43,149.68) v1(196.69,153.9) v1(196.74,153.03) v1(197.32,138.78) v1(197.32,138.08) v1(197.4,150.54) v1(197.4,149.65) v1(197.45,141.7) v1(197.7,153.95) v1(197.7,153.01) v1(204.37,151.1) v1(204.54,149.37) v1(204.51,148.49) v1(205.44,148.46) v1(205.46,149.3) v2(199.74,151.04)
VCC33_GPS: length 3.6
  TOP w0.508: 212.29,101.96 C464.1 ; v1(212.17,104.04) 212.23,103.99 C466.1 ; 212.47,102.97 C465.1
  BOTTOM w0.127: v2(212.31,105.51) 212.31,104.18 v1(212.17,104.04)
VCC33_GPS_ANT: length 4.2
  TOP w0.508: C468.1 204.47,101.79 204.48,101.8 ; 204.52,100.79 204.51,100.78 C469.1 ; R766.2 204.13,98.98 ; C470.1 204.45,99.76 204.54,99.85
  BOTTOM w0.127: v2(206.59,106.08) 206.59,104.94 v1(206.53,104.87)
VCC_CLKIN_2V5: length 4.7
  TOP w0.127: P1.H10 v4(101.29,218.46)
  TOP w0.508: P1.N12 v4(107.29,221.46) ; P1.P7 v4(108.29,215.46)
  BOTTOM w0.254: CB1180.1 101.82,218.99 v4(101.29,218.46)
  BOTTOM w0.305: v4(107.29,221.46) 107.04,221.71 CB1179.1
  BOTTOM w0.508: CB1178.1 85.37,223.08 v1(85.16,222.87)
  vias: v1(87.03,223.65) v1(87.03,222.92) v2(86.25,223.37)
VCC_GPS_ANT: length 6.7
  TOP w0.508: CONN44.1 206.56,98.05 v1(206.28,97.76) 206.28,97.7 205.99,97.41 R754.1 205.04,97.42 R766.1
  BOTTOM w0.127: v2(207.48,97.38) 206.66,97.38 v1(206.28,97.76)
VCCA_H_GXB_2V5: length 8.9
  TOP w0.381: P1.R3 v4(109.29,211.46) ; P1.H3 v4(101.29,211.46) ; P1.J3 v4(102.29,211.46) ; P1.P3 v4(108.29,211.46)
  TOP w0.508: P1.W3 v4(113.29,211.46)
  BOTTOM w0.305: v4(101.29,211.46) 100.89,211.06 CB1156.1 ; v4(108.29,211.46) 108.72,211.02 CB1154.1 108.85,211.02 v4(109.29,211.46) ; CB1153.1 113.01,211.73 v4(113.29,211.46) ; v4(102.29,211.46) 102.04,211.71 CB1155.1
  BOTTOM w0.381: v1(88.35,206.75) 87.91,206.32 CB1152.1 87.39,205.79 87.15,206.03
  vias: v1(87.29,206.76) v1(87.8,207.39) v2(87.05,207.88)
VCCD_PLL_1V2: length 9.9
  TOP w0.381: P1.G3 v4(100.29,211.46) ; P1.M4 v4(106.29,212.46)
  TOP w0.508: P1.E18 v4(98.29,227.46) ; P1.V18 v4(112.29,227.46) ; P1.R4 v4(109.29,212.46) ; P1.U4 v4(111.29,212.46)
  BOTTOM w0.254: v4(109.29,212.46) 108.8,212.95 CB1121.1 ; CB1123.1 112.6,227.14 v4(112.29,227.46) ; v2(89.44,238.67) 88.8,238.67 88.48,238.35
  BOTTOM w0.305: v4(111.29,212.46) 110.99,212.17 CB1146.1 ; v4(106.29,212.46) 106.02,212.19 CB1122.1 ; CB1124.1 100.03,211.2 v4(100.29,211.46)
  BOTTOM w0.508: v1(85.06,236.89) 84.81,236.65 CB1120.1
  vias: v1(85.82,236.89) v1(86.71,236.89) v1(87.72,236.89)
VCCL_GXB_1V2: length 8.5
  TOP w0.381: P1.N3 v4(107.29,211.46) ; P1.L3 v4(104.29,211.46) ; P1.K3 v4(103.29,211.46)
  TOP w0.508: P1.V3 v4(112.29,211.46) ; P1.T3 v4(110.29,211.46)
  BOTTOM w0.254: v4(107.29,211.46) 106.75,210.92 CB1149.1
  BOTTOM w0.305: v4(104.29,211.46) 103.83,211 CB1150.1 103.75,211 v4(103.29,211.46) ; v4(112.29,211.46) 112.03,211.2 CB1148.1
  BOTTOM w0.381: CB1151.1 110.02,211.19 v4(110.29,211.46)
  BOTTOM w0.508: CB1147.1 106.56,208.04 v1(106.77,208.25) ; 107.53,207.3 v2(107.53,206.6)
  vias: v1(106.77,207.39)
VDD0P6: length 339
  TOP w0.254: U6.3 66.5,184.33 v1(66.62,184.21) ; R53.2 241.39,223.3 v1(241.46,223.24)
  TOP w0.381: C76.1 v1(26,176.86) R163.1 ; R149.1 v1(61.43,176.63) C89.1 ; R292.1 22.98,165.2 22.95,165.17 R305.1 C164.1 22.86,163.6 22.22,164.24 v1(22.22,164.28) ; R292.1 22.98,166.09 23.23,166.34 23.82,166.34 23.91,166.44 R274.1 R255.1 ; R292.1 22.55,165.63 v1(22.16,165.25) ; R147.1 v1(55.34,176.63) C87.1 ; C94.1 v1(66.51,176.63) R154.1 ; C102.1 v1(54.32,176.63) C86.1 ; R179.1 R187.1 v1(76.8,173.45) C119.2 C113.1 ; R158.1 70.58,176.6 v1(70.63,176.65) 70.58,176.71 C85.2 ; R148.1 v1(60.42,176.63) C88.2 ; C82.1 32.12,176.88 v1(32.07,176.83) ; C84.2 69.59,176.68 v1(69.56,176.65) R157.1 ; C126.1 R209.1 R197.1 v1(76.77,172.44) ; R144.1 27.04,176.78 v1(27.02,176.81) C77.1 ; C79.1 29.05,176.86 v1(29.02,176.83) 29.18,176.68 R146.1 ; C78.2 v1(28.03,176.83) 28.06,176.81 R145.1 ; R155.1 v1(67.53,176.63) C95.1 ; C96.1 v1(68.55,176.63) R156.1 ; v1(23.97,176.81) 23.99,176.78 R142.1 ; C90.1 v1(62.45,176.63) R150.1 ; C91.1 v1(63.47,176.63) R151.1 ; C74.2 v1(22.95,176.81) 22.85,176.71 R141.1 ; v1(30.06,176.81) 30.09,176.83 C80.1 ; R267.1 v1(76.8,167.36) C142.1 ; R153.1 v1(65.5,176.63) C93.1 ; C54.1 C43.1 ; C92.1 v1(64.48,176.63) R152.1 ; R221.1 v1(76.8,170.41) C130.1 ; v1(31.05,176.76) 31.11,176.81 C81.1 ; R143.1 25.01,176.83 v1(24.98,176.86) C75.2 ; R243.1 R226.1 23.01,170.36 25.72,173.07 25.72,173.15 v1(26.13,173.56) ; R140.1 21.91,176.71 v1(22.01,176.81) 22.06,176.86 C73.1
  TOP w0.508: v1(70.01,184.06) 69.92,184.15 R1019.2 ; v1(70.83,183.36) 70.65,183.18 C63.2
  S9 w0.254: v1(241.46,223.24) 242.92,223.24 244.06,222.1 244.06,219.49 243.55,218.98 241.39,218.98 240.76,218.35 240.76,213.4 241.46,212.7 241.46,208.06 240.88,207.49 235.17,207.49 233.07,209.59 226.85,209.59 224.95,211.49 220.37,211.49 219.67,210.79 206.72,210.79 203.02,207.09 197.94,207.09 196.18,205.33 192.78,205.33 191.81,206.3 176.74,206.3 168.51,198.07 142.37,198.07 138.59,194.28 117.35,194.28 105.15,182.09 102.07,182.09 96.61,176.63 v1(94.68,176.63)
  S12 w0.127: 52.75,178.05 50.74,178.05
  S12 w0.508: CONN8.1 38.17,173.56 ; CONN8.1 36.29,173.56 ; CONN8.1 37.23,172.62 ; CONN8.1 37.23,174.5
  BOTTOM w0.127: v1(241.46,223.24) 241.46,222.64 v2(241.15,222.33)
  BOTTOM w0.254: RB116.1 85.34,165.28 85.34,161.59 RB102.1
  BOTTOM w0.381: CB57.1 24.1,176.93 v1(23.97,176.81) RB53.1 ; RB79.1 94.71,176.6 v1(94.68,176.63) ; RB58.1 29.05,176.81 v1(29.02,176.83) ; CB69.1 v1(87.47,176.68) RB72.1 ; RB81.1 v1(67.53,176.63) C95.1 ; C84.2 69.59,176.68 v1(69.56,176.65) R157.1 ; RB55.1 v1(26,176.86) C76.1 ; RB90.1 RB85.1 CB110.1 83.73,172.69 v1(83.48,172.44) ; C74.2 v1(22.95,176.81) RB52.1 ; RB100.1 RB96.1 77.18,169.69 v1(76.8,169.69) ; v1(12.97,169.95) 12.97,169.36 CB156.2 CB166.2 RB101.1 ; RB59.1 32.1,176.81 v1(32.07,176.83) 32.12,176.88 C82.1 ; RB48.1 18.89,176.63 v1(18.3,177.21) 18.66,177.57 CB52.1 ; C130.1 v1(76.8,170.41) R221.1 ; RB80.1 v1(66.51,176.63) C94.1 ; C96.1 v1(68.55,176.63) RB82.1 ; C91.1 v1(63.47,176.63) R151.1 ; CB73.1 81.32,177.06 v1(81.7,176.68) ; v1(13.81,165.07) 14.06,165.33 CB202.1 RB112.1 ; C75.2 v1(24.98,176.86) RB54.1 ; CB63.1 31.08,176.78 v1(31.05,176.76) ; v1(74.54,172.67) 74.05,172.67 RB83.1 ; R158.1 70.58,176.6 v1(70.63,176.65) 70.58,176.71 C85.2 ; RB61.1 61.43,174.3 v1(61.43,176.63) C89.1 ; C77.1 v1(27.02,176.81) RB56.1 ; C142.1 v1(76.8,167.36) R267.1 ; v1(76.77,172.44) 76.11,171.77 C126.1 ; RB51.1 21.94,176.73 v1(22.01,176.81) 22.06,176.86 C73.1 ; CB75.1 v1(90.52,176.65) RB75.1 ; v1(89.5,176.68) RB74.1 ; RB76.1 v1(91.66,176.65) CB76.1 ; CB71.2 92.68,176.68 v1(92.65,176.65) 92.68,176.63 RB77.1 ; RB111.1 RB115.1 65.34,164.93 v4(65.48,164.79) ; C88.2 v1(60.42,176.63) R148.1 ; RB57.1 v1(28.03,176.83) C78.2 ; R152.1 v1(64.48,176.63) C92.1 ; CB67.2 v1(85.44,176.65) RB70.1 ; CB70.1 v1(88.48,176.71) RB73.1 ; RB68.1 v1(83.4,176.65) CB65.1 ; R153.1 v1(65.5,176.63) C93.1 ; v1(74.54,169.39) 74.46,169.47 RB95.1 ; R150.1 v1(62.45,176.63) C90.1 ; RB69.1 v1(84.42,176.65) CB66.1 ; RB86.1 82.26,176.35 v1(82.59,176.68) 82.34,176.93 CB74.2 ; CB62.1 v1(30.06,176.81) ; CB53.1 CB54.1 21.05,176.88 v1(21.02,176.86) 20.92,176.76 RB50.1 RB49.1 ; CB68.2 v1(86.45,176.71) RB71.1 ; RB91.1 v1(74.51,170.41)
  BOTTOM w0.508: C64.2 68.76,184.98 v1(68.67,184.88) ; v1(86.48,166.8) 86.39,166.8 86,167.19 RB99.1 ; v1(86.45,166.01) 85.88,165.44 RB116.1 RB110.1
  vias: v1(67.39,183.82) v1(68.35,184.06) v1(69.24,184.06) v1(70.83,184.88) v1(70.83,184.06)
VDD0P6_MON: length 9.3
  TOP w0.254: v1(240.49,224.7) R53.1 239.88,223.93 239.79,223.84 238.07,223.84 237.76,224.15 C35.1 237.02,224.44 236.75,224.17 236.75,223.08 235.92,222.24 U7.62
  BOTTOM w0.127: v2(240.12,225.97) 240.12,225.07 v1(240.49,224.7)
VDD0P6_PGOOD: length 11.2
  TOP w0.254: R58.1 65.68,189.74 v1(65.43,189.49) 66,188.92 U6.9
  S12 w0.381: v1(65.43,189.49) 65.43,189.57 59.61,189.57 arc(58.84,189.72) CONN3.1
  BOTTOM w0.127: v2(64.86,190.73) 64.86,190.06 v1(65.43,189.49)
VDD1P0: length 253.4
  TOP w0.254: v1(241.78,214.21) 241.72,214.28 R118.2
  TOP w0.381: v4(37.7,124.65) U40.AG20 ; U40.AF25 v4(32.7,123.65) ; v1(16.95,112.69) 16.94,112.69 R691.2 ; v4(48.7,121.65) U40.AD10 ; v4(33.7,124.65) U40.AG24 ; U40.AC11 v4(47.7,120.65) ; C754.2 96.82,105.61 ; 5.81,104.95 C426.2 6.44,105.61 ; C407.2 6.44,108.43 ; C407.2 5.76,109.12 ; C407.2 7,109.12 ; v4(46.7,120.65) U40.AC12 ; v4(40.7,124.65) U40.AG18 ; R694.2 v1(16.78,109.75) ; v4(30.7,123.65) U40.AF27 ; v4(39.7,123.65) U40.AF19
  S9 w0.254: v1(225.96,207.62) 226.6,206.98 241.14,206.98 242.28,208.13 242.28,213.71 v1(241.78,214.21)
  S12 w0.254: CONN40.1 115.94,111.91 129.44,125.42 129.44,127.99 136.65,135.2 144.8,135.2 146.33,133.66 150.83,133.66 153.96,136.8 169.38,136.8 169.92,137.33 175.3,137.33 175.6,137.64 186.07,137.64 188.72,140.28 189.66,140.28 190.12,140.74 190.12,144.28 194.5,148.66 199.9,148.66 215.07,163.83 215.07,196.84 219.01,200.78 221.54,200.78 223.92,203.16 223.92,204.58 225.96,206.62 v1(225.96,207.62)
  V18 w0.508: CONN40.1 106.72,111.91 ; CONN40.1 104.84,111.91 ; CONN40.1 105.78,112.85 ; CONN40.1 105.78,110.97
  BOTTOM w0.305: CB508.1 49.22,121.16 CB501.1
  BOTTOM w0.381: CB510.1 46.2,120.15 v4(46.7,120.65) ; v4(39.7,123.65) 39.2,123.15 CB471.1 ; v4(39.7,123.65) 39.2,124.15 CB442.1 ; v4(39.7,123.65) 39.7,123.65 CB457.1 40.2,124.15 v4(40.7,124.65) 40.79,124.65 CB437.1 ; CB462.1 32.7,123.66 v4(32.7,123.65) CB461.1 ; C366.2 82.62,103.76 82.9,104.04 ; CB447.2 83.61,104.57 v1(83.66,104.62) ; v4(46.7,120.65) 46.2,121.14 CB498.1 ; v4(46.7,120.65) 46.7,120.65 CB506.1 47.7,120.66 v4(47.7,120.65) 47.7,120.65 CB507.1 48.2,121.15 v4(48.7,121.65) 49.19,121.15 CB508.1 ; CB460.1 30.7,123.66 v4(30.7,123.65) 30.2,123.15 CB459.1 ; CB449.1 34.19,124.15 v4(33.7,124.65) 33.19,125.15 CB431.1 ; CB425.1 37.7,124.65 v4(37.7,124.65) 38.19,124.15 CB465.1 ; v1(78.58,104.37) v2(78.58,103.5)
  BOTTOM w0.508: v1(81.25,104.62) 81.6,104.26 C367.2 ; 82.26,107.41 CB445.2 ; 109.74,93.4 R1499.1 ; 80.23,107.34 CB443.2 ; C368.2 80.58,104.52 v1(80.48,104.62) ; v1(84.42,107.8) 84.24,107.98 CB446.2 ; 79.57,104.24 C369.2 ; 81.25,107.39 CB444.2 ; CONN40.1 106.72,111.91 ; CONN40.1 104.84,111.91 ; CONN40.1 105.78,110.97
  vias: v1(6.44,107.82) v1(6.47,107.03) v1(6.49,106.3) v1(78.58,108.18) v1(78.58,107.41) v1(78.58,106.65) v1(78.58,105.89) v1(78.58,105.13) v1(79.34,108.18) v1(79.34,107.41) v1(79.34,106.65) v1(79.34,105.89) v1(79.34,105.13) v1(80.48,105.38) v1(81.25,105.38) v1(82.13,105.38) v1(82.13,104.68) v1(82.9,105.38) v1(82.9,104.68) v1(83.66,106.91) v1(83.66,106.14) v1(83.66,105.38) v1(84.42,106.91) v1(84.42,106.14) v1(84.42,105.38) v1(84.42,104.62) v1(84.67,93.44) v1(85.31,105.38) v1(85.31,104.62) v1(85.37,93.44) v1(86.13,93.44) v1(86.2,105.38) v1(86.2,104.62) v1(86.96,93.44) v1(87.6,108.94) v1(87.6,108.18) v1(87.6,107.41) v1(87.6,106.65) v1(87.79,93.44) v1(97.81,105.64) v1(97.93,107.24) v1(97.91,106.45) v1(98.72,107.19) v1(98.72,106.42) v1(98.95,105.64) v1(99.61,107.19) v1(99.61,106.42) v1(99.91,101.7) v1(99.91,100.81) v1(99.97,105.64) v1(100.45,108.07) v1(100.45,107.19) v1(100.45,106.42) v1(100.55,104.62) v1(100.55,103.6) v1(101.29,104.11) v1(101.95,103.6) v1(103.09,103.6) v1(104.11,103.6) v1(105.76,91.03) v1(106.52,90.9) v1(107.28,90.9) v2(104.97,106.53)
