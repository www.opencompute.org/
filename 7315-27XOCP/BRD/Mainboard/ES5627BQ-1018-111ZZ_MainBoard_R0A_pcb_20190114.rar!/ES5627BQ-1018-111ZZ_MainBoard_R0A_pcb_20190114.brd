# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N62372733: length 3.3
  TOP w0.127: RB1260.1 160.66,177.92 U77.10
N62372774: length 7.8
  TOP w0.127: v1(156.27,176.87) 156.27,176.47 156.82,175.92 U77.6 158.86,175.92 160.05,174.72 160.05,174.34 160.64,173.76 RB1261.2
  BOTTOM w0.127: v2(157.75,176.34) 157.22,176.87 v1(156.27,176.87)
N62372807: length 6.4
  TOP w0.127: U77.79 156.17,172.32 156.68,171.8 158.14,171.8 v1(158.91,171.04) 159.16,171.04 159.38,170.82 R1372.2
  BOTTOM w0.127: v2(159.92,172.37) 159.92,172.06 v1(158.91,171.04)
N62372810: length 6.6
  TOP w0.127: v1(155.67,173.58) U77.78 155.67,172.31 156.43,171.55 157.64,171.55 158.36,170.82 R1373.2
  BOTTOM w0.127: v2(156.66,174.78) 156.66,174.57 v1(155.67,173.58)
N62385003: length 90.8
  TOP w0.127: P1.T8 v4(110.29,216.46) ; v1(164.68,169.77) 164.58,169.67 R1410.1
  S14 w0.127: v4(110.29,216.46) 110.75,216 111.41,216 111.89,215.51 111.89,215.3 112.27,214.92 113.5,214.92 113.82,214.6 113.82,214.22 114.14,213.9 114.46,213.9 114.77,213.59 114.77,212.19 115.79,211.17 115.79,208.51 120.89,203.4 120.89,202.94 125.28,198.55 144.22,198.55 151.41,191.36 161.69,191.36 166.59,186.46 166.59,171.68 v1(164.68,169.77)
N62385006: length 90.6
  TOP w0.127: R1411.1 v1(164.66,170.69) ; P1.T7 v4(110.29,215.46)
  S14 w0.127: v1(164.66,170.69) 164.08,171.27 164.08,173.48 165.47,174.87 165.47,186.43 161.49,190.41 149.13,190.41 147.09,192.44 144.75,192.44 140.44,196.75 120.01,196.75 113.95,202.81 113.95,204.19 113.23,204.91 113.23,206.76 110.8,209.19 110.8,214.95 v4(110.29,215.46)
N62385009: length 87.7
  TOP w0.127: R1412.1 v1(164.79,171.7) ; P1.V6 v4(112.29,214.46)
  S14 w0.127: v1(164.79,171.7) 166.19,173.11 166.19,186.47 161.68,190.98 149.95,190.98 143.42,197.51 120.43,197.51 115.95,202 115.95,203.74 114.68,205.01 114.68,206.56 113.74,207.51 113.74,209.29 112.84,210.18 112.84,213.9 v4(112.29,214.46)
N62385012: length 86.9
  TOP w0.127: P1.U6 v4(111.29,214.46) ; R1413.1 v1(164.79,172.72)
  S14 w0.127: v4(111.29,214.46) 111.78,213.97 111.78,208.77 114.35,206.2 114.35,204.74 115.31,203.77 115.31,202 120.18,197.13 142.91,197.13 149.38,190.66 161.62,190.66 165.82,186.46 165.82,173.75 v1(164.79,172.72)
N62385145: length 5.9
  TOP w0.127: RB1262.1 160.11,170.19 160.11,170.85 159.92,171.04 159.92,171.49 159.03,172.37 159.03,172.82 157.94,173.92 U77.2
N62385148: length 5.7
  TOP w0.127: RB1263.1 160.64,170.71 160.18,171.17 160.18,171.61 159.35,172.44 159.35,173.52 158.45,174.42 U77.3
N62385151: length 5.2
  TOP w0.127: RB1264.1 159.67,172.67 159.67,173.77 158.52,174.92 U77.4
N62385154: length 4.7
  TOP w0.127: U77.5 158.53,175.42 159.99,173.96 159.99,173.37 RB1265.1
N62388298: length 5.6
  TOP w0.127: R1416.1 v1(159.73,181.46) 158.68,180.42 U77.15
  BOTTOM w0.127: v1(159.73,181.46) 159.54,181.46 v2(158.52,182.47)
N62390159: length 6.5
  TOP w0.127: U77.35 149.67,184.69 149.82,184.83 R1417.1 149.61,185.8 149.32,186.09 149.32,188.06 v1(149.63,188.38)
  BOTTOM w0.127: v2(149,189.39) 149.63,188.76 v1(149.63,188.38)
N62390162: length 6.9
  TOP w0.127: v1(150.52,188.25) 150.78,188 151.29,188 151.54,187.74 151.54,186.22 151.12,185.8 R1418.1 150.83,184.94 150.17,184.28 U77.34
  BOTTOM w0.127: v1(150.52,188.25) 150.9,188.63 v2(150.9,188.95)
N62390762: length 4.1
  TOP w0.127: v1(154.14,182.66) 154.17,182.69 U77.26 154.17,184.15 155.03,185.01 R1419.1
  BOTTOM w0.127: v1(154.14,182.66) v2(154.14,183.49)
N62408192: length 11.6
  TOP w0.127: C915.1 156.07,184.91 155.84,184.68 v1(155.84,184.61) 156.17,184.29 U77.22 ; U77.13 156.56,179.42 v1(156.56,179.42)
  S14 w0.127: v1(155.84,184.61) 155.78,184.61 155.35,184.19 155.35,182.03 155.86,181.52 155.86,180.12 v1(156.56,179.42)
  BOTTOM w0.254: v1(155.84,184.61) 156.18,184.95 156.18,186.03 v2(156.87,186.73)
N62470038: length 10.2
  TOP w0.254: LB114.2 v1(45.13,205.12)
  TOP w0.508: U81.6 44.34,210.47 C926.1 C919.2 44.34,206.59 CB1218.1 44.21,206.31 LB114.2
  BOTTOM w0.508: v1(45.13,205.12) 48.35,205.12 v2(48.44,205.2)
N62472864: length 4.6
  TOP w0.095: U81.5 40.48,210.78 40.29,210.59 40.29,209.38 40.1,209.19 40.1,209.02 40.49,208.63 R1424.2 40.49,207.6 R1426.2
N62472867: length 4.5
  TOP w0.095: R1427.2 39.49,207.58 R1425.2 39.87,208.98 39.87,209.28 40.06,209.48 40.06,210.63 39.92,210.78 U81.4
N62744061: length 5.4
  TOP w0.254: U79.7 105.86,180.67 106.26,181.07
  TOP w0.381: v1(106.26,181.05) 106.26,181.07 107.5,182.31 R1437.1 107.74,182.33 R1438.2
  BOTTOM w0.254: v1(106.26,181.05) 105.5,181.81 v2(105.5,181.9)
N62745262: length 2.7
  TOP w0.127: U79.6 106.41,180.17 107.28,181.04 R1439.1
N62745869: length 4
  TOP w0.254: U79.2 103.56,176.69 R1440.1
  TOP w0.508: v1(104.31,176.63) 104.29,176.65 R1440.1
  BOTTOM w0.254: v2(105.25,176.57) 104.37,176.57 v1(104.31,176.63)
N62747426: length 5.8
  TOP w0.095: U79.9 104.56,182.33 104.43,182.47 104.43,182.7 104.57,182.85 105.06,182.85 105.37,183.17 105.37,183.41 R360.2 105.62,183.93 105.54,183.93 105.29,184.18 105.29,185.93 R402.2
N62747432: length 5.8
  TOP w0.095: R401.2 105.06,185.89 105.06,184.2 104.83,183.98 104.73,183.98 R359.2 105.03,183.31 105.03,183.15 104.96,183.08 104.48,183.08 104.2,182.8 104.2,182.5 104.06,182.37 U79.10
N62747438: length 5.5
  TOP w0.095: U79.11 103.56,182.38 103.43,182.51 103.43,182.8 103.2,183.03 103.06,183.03 102.96,183.12 102.96,183.22 R358.2 103.48,183.79 103.03,184.24 103.03,185.89 R400.2
N62747447: length 5.5
  TOP w0.095: U79.12 103.06,182.38 103.2,182.52 103.2,182.7 103.1,182.8 102.96,182.8 102.73,183.03 102.73,183.32 R357.2 102.32,183.79 102.8,184.27 102.8,185.86 R399.2
N62754686: length 3.8
  TOP w0.127: RB1272.1 151.8,169.07 151.35,168.62 OSC7.3
N62757272: length 4.5
  TOP w0.254: U77.29 152.67,184.12 152.75,184.2 152.75,185.52 RB1274.2
  TOP w0.508: v1(151.52,185.35) 152.2,186.03 RB1274.2
  BOTTOM w0.127: v2(152.33,185.65) 152.02,185.35 v1(151.52,185.35)
N62757275: length 4.7
  TOP w0.254: 153.38,185.27 153.76,185.65 RB1275.2 ; 153.38,185.27 153.17,185.05 U77.28 ; 153.38,185.27 v1(153.38,185.21)
  BOTTOM w0.127: v1(153.38,185.21) 153.38,185.71 154.18,186.51 v2(154.18,186.94)
N62922114: length 51.9
  TOP w0.127: U77.25 154.67,184.14 155.16,184.63 155.16,184.76 155.54,185.14 155.54,193.82 v1(153.81,195.55)
  TOP w0.381: RB1276.2 v1(124.81,210.73)
  S14 w0.127: v1(124.81,210.73) 124.81,210.67 126.53,208.94 134.15,208.94 134.45,209.24 138.29,209.24 142.08,205.46 143.91,205.46 v1(153.81,195.55)
  BOTTOM w0.127: v1(124.81,210.73) 125.31,211.24 126.01,211.24 v2(126.84,210.41)
N62922117: length 49.6
  TOP w0.127: v1(154.02,184.76) 153.67,184.41 U77.27 ; RB1277.2 v1(124.87,209.71)
  S7 w0.127: v1(154.02,184.76) 153.33,184.07 151.96,184.07 151.25,183.36 146.52,183.36 146.02,182.85 143.46,182.85 142.1,184.21 142.1,186.56 129.19,199.47 129.19,203.93 126.33,206.79 126.33,208.74 125.36,209.71 v1(124.87,209.71)
  BOTTOM w0.127: v1(154.02,184.76) 154.02,184.82 154.46,185.27 v2(155.1,185.27)
N62922800: length 7.1
  TOP w0.127: RB1278.2 148.81,185.32 149.19,184.94 v1(149.19,184.63) 149.17,184.61 U77.36
  BOTTOM w0.127: v1(149.19,184.63) 150.27,184.63 150.97,185.33 150.97,186.16 152.2,187.4 v2(152.2,187.55)
N62922803: length 5.4
  TOP w0.127: U77.74 153.67,171.78 v1(153.63,171.75)
  BOTTOM w0.127: v2(155.67,172.67) 155.05,172.67 154.58,172.2 154.09,172.2 v1(153.63,171.75) 154.08,171.3 154.08,170.74 RB1279.2
N62922934: length 47.2
  TOP w0.127: U77.31 151.67,184.18 v1(151.29,184.57) ; RB1280.2 125.38,211.68 v1(125.25,211.81)
  S7 w0.127: v1(125.25,211.81) 127.02,210.03 127.02,207.05 129.63,204.44 129.63,199.81 142.5,186.94 142.5,185.68 143.7,184.48 146.06,184.48 146.62,183.92 150.64,183.92 v1(151.29,184.57)
  BOTTOM w0.127: v1(125.25,211.81) 126.27,211.81 v2(127.03,212.57)
N62922937: length 52.1
  TOP w0.127: U77.30 v1(152.17,184.69) ; RB1281.2 124.81,216.86 v1(124.83,216.88)
  S7 w0.127: v1(152.17,184.69) 152.17,185.9 151.66,186.41 143.68,186.41 130.01,200.07 130.01,211.7 v1(124.83,216.88)
  BOTTOM w0.127: v2(126.58,217.59) 125.88,216.88 v1(124.83,216.88)
N62922967: length 7.6
  TOP w0.127: P1.AB5 116.88,213.96 119.51,211.33 119.51,210.94 v1(119.73,210.73) 119.74,210.74 RB1282.1
  BOTTOM w0.127: v2(120.68,211.11) 120.3,210.73 v1(119.73,210.73)
N62923015: length 8.8
  TOP w0.127: RB1283.1 119.88,209.75 v1(119.73,209.9) ; P1.Y5 v4(114.29,213.46)
  BOTTOM w0.127: v1(119.73,209.9) v2(118.77,210.86) 116.68,210.86 114.29,213.25 v4(114.29,213.46)
N62923052: length 19
  TOP w0.127: v1(125.38,212.7) RB1284.1 ; P1.Y6 v4(114.29,214.46)
  BOTTOM w0.127: v4(114.29,214.46) 114.78,213.97 115.92,213.97 116.6,213.28 118.22,213.28 118.65,213.71 120.68,213.71 121.22,213.17 122.59,213.17 123.07,213.65 124.43,213.65 v1(125.38,212.7) 126.33,212.7 127.03,213.4 129.57,213.4 v2(129.89,213.08)
N62923103: length 12.8
  TOP w0.127: v1(119.73,216.95) 119.82,216.86 RB1285.1 ; P1.T9 v4(110.29,217.46)
  S7 w0.127: v1(119.73,216.95) 119.13,217.55 118.14,217.55 117.54,216.95 110.8,216.95 v4(110.29,217.46)
  BOTTOM w0.127: v2(119.41,217.71) 119.73,217.4 v1(119.73,216.95)
N62923170: length 6.4
  TOP w0.127: P1.AB17 116.05,226.22 v1(120.06,226.22) 120.24,226.4 RB1286.2
  BOTTOM w0.127: v2(121.31,226.16) 120.13,226.16 v1(120.06,226.22)
N62923212: length 7.5
  TOP w0.127: P1.AB19 116.45,227.96 116.78,227.63 119.71,227.63 v1(119.84,227.51) RB1287.2
  BOTTOM w0.127: v2(117.88,227.24) 118.46,227.81 119.54,227.81 v1(119.84,227.51)
N63099887: length 12.1
  TOP w0.127: P1.T17 v4(110.29,226.46)
  BOTTOM w0.127: R1447.1 110.71,235.48 v2(110.71,234.29) 110.71,233.37 109.45,232.11 109.45,230.87 108.8,230.23 108.8,228.13 108.93,228 109.57,228 109.82,227.75 109.82,226.93 v4(110.29,226.46)
N63099890: length 11
  TOP w0.127: P1.T18 v4(110.29,227.46)
  BOTTOM w0.127: v4(110.29,227.46) 110.29,227.79 109.69,228.38 109.69,229.74 110.59,230.64 110.59,231.63 112.3,233.33 v2(112.36,233.33) 112.36,233.91 111.22,235.05 R1448.1
N63099969: length 13.3
  TOP w0.127: v1(101.95,234.22) 102.39,234.67 102.39,235.61 R1449.1 ; P1.F16 v4(99.29,225.46)
  BOTTOM w0.127: v4(99.29,225.46) 99.29,225.46 99.34,225.46 99.72,225.84 99.72,228.83 99.95,229.05 100.58,229.05 100.87,229.33 100.87,231.44 102.33,232.9 v2(102.33,233.27) 101.95,233.65 v1(101.95,234.22)
N63099973: length 13.1
  TOP w0.127: P1.F17 v4(99.29,226.46)
  BOTTOM w0.127: v4(99.29,226.46) 98.83,226.91 98.83,227.49 98.47,227.85 97.59,227.85 97.56,227.87 97.18,227.87 96.87,228.19 96.87,232.13 95.02,233.97 v2(94.83,233.97) 94.53,234.27 94.53,235.34 94.26,235.61 R1450.1
N63100208: length 11.1
  TOP w0.127: v1(119.6,229.52) R1451.2 ; P1.W19 v4(113.29,228.46)
  BOTTOM w0.127: v4(113.29,228.46) 113.75,228 116.74,228 117.69,228.95 119.03,228.95 v1(119.6,229.52) 119.66,229.46 v2(121.69,229.46)
N63100211: length 9.4
  TOP w0.127: P1.Y20 v4(114.29,229.46) ; v1(118.77,229.46) 118.77,229.59 119.73,230.54 R1452.2
  BOTTOM w0.127: v4(114.29,229.46) 115.03,229.46 115.73,228.76 116.93,228.76 117.63,229.46 v1(118.77,229.46) 118.77,229.93 118.67,230.03 v2(118.2,230.03)
N63138975: length 10.8
  TOP w0.127: R1445.1 90.83,231.05 v1(90.9,230.99) 91.34,230.99 93.12,229.21 93.12,227.63 P1.A17
  BOTTOM w0.127: v1(90.9,230.99) 89.17,230.99 88.44,230.26 v2(88.1,230.26)
N63138992: length 9
  TOP w0.127: P1.A18 93.56,228.18 93.56,229.72 v1(92.74,230.54) 92.74,230.6 91.28,232.06 R1446.1
  BOTTOM w0.127: v2(92.23,231.62) 92.23,231.05 v1(92.74,230.54)
N63139056: length 32.4
  TOP w0.127: P1.AB21 116.36,230.53 v1(116.36,230.6) ; v1(90.9,234.22) 90.77,234.1 R1443.1
  S7 w0.127: v1(116.36,230.6) 114.39,232.57 106.55,232.57 105.94,232.32 97.12,232.32 95.79,233.65 91.47,233.65 v1(90.9,234.22)
  BOTTOM w0.127: v1(90.9,234.22) 89.75,234.22 88.74,233.21 v2(87.79,233.21)
N63139092: length 27.4
  TOP w0.127: P1.R15 v4(109.29,224.46) ; R1444.1 v1(90.9,233.08)
  BOTTOM w0.127: v2(89.75,232.57) 90.26,233.08 v1(90.9,233.08) 91.78,233.08 92.32,232.53 92.87,232.53 95.85,229.55 95.85,227.81 96.42,227.24 96.42,226.1 97.82,224.7 97.82,224 97.95,223.87 108.74,223.87 109.29,224.42 v4(109.29,224.46)
N63180384: length 7.5
  TOP w0.127: v1(152.46,170.82) 152.26,171.02 152.26,172.04 152.17,172.13 U77.71
  BOTTOM w0.127: TP52.1 153.37,166.8 v2(153.03,167.13) 152.59,167.58 152.59,170.69 v1(152.46,170.82)
N63293528: length 13.4
  BOTTOM w0.508: C986.1 v2(101.25,251.11) 93.53,251.11 arc(91.66,250.74) NUT1.1
N63368767: length 5
  TOP w0.127: v3(186.99,141.56) 187.29,141.86 187.48,141.86 187.59,141.75 187.59,140.77 187.44,140.63 J2.A88
  BOTTOM w0.127: R1510.2 185.42,141.87 186.67,141.87 v3(186.99,141.56)
N63368769: length 5.3
  TOP w0.127: v3(186.99,142.37) 187.19,142.17 187.6,142.17 187.89,141.88 187.89,140.6 187.94,140.56 J2.A89
  BOTTOM w0.127: R1511.2 185.09,142.54 185.45,142.18 186.8,142.18 v3(186.99,142.37)
N63587082: length 13.4
  BOTTOM w0.127: R1479.1 208.42,27.93 207.06,29.29 204.98,29.29 v2(204.7,29.01) 204.71,28.99 204.65,28.93 204.65,26.52 205.69,25.47 R1478.2 206.4,24.28 206.05,23.93 U85.4
N63589715: length 8.7
  S9 w0.127: v1(208.31,18.45) 206.94,17.09 v1(205.44,17.09)
  BOTTOM w0.127: v1(208.31,18.45) 208.34,18.42 R1482.1 ; U86.4 205.9,15.33 206.3,15.74 R1481.2 205.7,16.83 v1(205.44,17.09) 204.6,17.09 v2(204.56,17.05)
N63590191: length 5.4
  TOP w0.127: U87.4 228.2,41.98 227.93,42.26 v1(227.93,42.77) 227.93,43.29 227.83,43.39 R1484.2 228.82,43.74 R1485.1
  BOTTOM w0.127: v1(227.93,42.77) 228.31,43.16 v2(228.31,44.17)
N63590681: length 10.7
  BOTTOM w0.127: v2(223.17,44.61) 223.17,44.28 223.68,43.77 R1487.2 225.76,43.77 R1488.1 225.79,42.18 227.52,40.45 227.52,38.9 228.25,38.17 U88.4
N63973491: length 5.2
  TOP w0.127: J2.B24 155.44,146.1 v1(154.77,146.77)
  BOTTOM w0.127: v2(154.94,145.2) 154.94,146.6 v1(154.77,146.77) R1500.1 RB1303.1
N63973866: length 6.4
  TOP w0.508: R1501.2 RB1305.2 RB1306.2 v1(122.33,220.95) R1502.2 R1501.2
  BOTTOM w0.127: v1(122.33,220.95) 121.38,221.9 v2(121.38,222.03)
N63974703: length 4.8
  TOP w0.508: RB1308.2 111.46,203.18 v1(111.41,203.24) RB1307.2 R1503.2 R1504.2
  BOTTOM w0.127: v1(111.41,203.24) 110.84,202.66 v2(110.84,202.09)
N635794501: length 8.8
  BOTTOM w0.127: U85.1 205.57,20.12 208.42,22.97 R1479.2 209.35,25.46 v2(209.9,26.01)
N635896801: length 10.1
  BOTTOM w0.127: R1482.2 208.34,16.42 207.91,15.99 207.91,13.33 206.1,11.52 U86.1 203.54,11.52 203.29,11.28 v2(203.29,10.26)
N635901561: length 11.8
  TOP w0.127: R1485.2 v1(228.83,45.58) ; U87.1 v1(227.55,38.17)
  S12 w0.127: v1(228.83,45.58) 228.68,45.43 228.68,39.3 v1(227.55,38.17)
  BOTTOM w0.127: v1(228.83,45.58) 228.76,45.66 v2(228.76,46.9)
N635906461: length 9.8
  S7 w0.127: v1(229.18,42.79) 227.59,44.38 226.93,44.38 v1(225.79,45.52)
  BOTTOM w0.127: U88.1 229.15,42.77 v1(229.18,42.79) ; v2(224.67,48.64) 224.95,48.37 224.95,46.37 v1(225.79,45.52) R1488.2

## Copper pours and planes (outline as drawn)
AGND_VCC1V0 on TOP: 107.89,133.37 107.66,133.14 107.66,129.39 107.92,129.13 108.7,129.13 108.93,129.36 108.93,131.29 109.41,131.77 113.81,131.77 114.06,132.03 114.06,133.07 113.76,133.37
AGND_VCC1V0 on BOTTOM: 105.73,130.63 105.73,125.09 106.67,124.15 106.67,121.26 106.86,121.07 106.86,118.04 108.26,116.65 112.02,116.65 112.84,115.82 114.21,115.82 115.03,116.63 118.23,116.63 119.22,117.62 119.22,117.64 121.25,117.64 124.04,120.43 124.04,128.88 120.83,132.09 118.24,132.09 116.96,133.37 113.73,133.37 113.43,133.07 107.76,133.07 107.25,132.56 107.25,132.15 ; 1 cut-out
AGND_VCC1V0 on S14: 108.36,114.08 107.09,115.35 107.09,133 107.66,133.58 117.57,133.58 119.09,132.05 119.92,132.05 123.28,128.69 123.28,120.43 116.93,114.08 ; 1 cut-out
AGND_VCC3V3 on TOP: 169.53,135.22 169.53,133.19 169.41,133.07 168.52,133.07 168.39,132.94 168.39,132.43 168.26,132.3 167.88,132.3 167.76,132.43 167.76,133.57 167.5,133.83 166.61,133.83 166.49,133.95 166.49,134.72 166.23,134.97 165.51,134.97 165.32,134.78 165.32,134.47 164.94,134.08 164.75,134.08 164.62,134.21 164.62,134.78 164.24,135.16 164.24,135.99 164.24,135.99 168.77,135.99
GND on TOP (solid shape): 130.01,168.69 130.01,167.1 129.76,166.85 127.98,166.85 127.75,167.08 127.75,168.82 127.88,168.95 129.02,168.95 129.75,168.95
GND on TOP (solid shape): 94.72,99.92 96.33,99.92 96.33,99.73 96.62,99.45 98.09,99.45 98.13,99.49 99.51,99.49 99.91,99.08 99.91,98.57 99.84,98.5 98.75,98.5 98.52,98.27 98.52,98.26 98.1,97.84 96.5,97.84 96.36,97.7 96.36,97.38 94.2,97.38 94.2,97.01 94.14,96.99 94.12,97 93.54,97 93.44,97.1 93.44,97.71 93.36,97.79 91.28,97.79 91.11,97.95 91.11,99.4 91.18,99.47 91.21,99.45 91.49,99.42 91.75,99.54 93.36,99.54 93.41,99.59 93.41,100.25 93.46,100.3 94.34,100.3
GND on TOP (solid shape): 33.2,192.99 33.2,191.17 33.18,191.17 33.18,189.9 33.3,189.9 33.3,189.19 33.51,189.19 33.64,189.07 35.64,189.07 35.64,188.47 36.46,188.47 36.46,189.19 36.69,189.19 36.86,189.37 36.88,189.37 37.14,189.48 37.31,189.7 38.92,189.7 39.01,189.79 39.01,190.88 39.23,191.1 42.15,191.1 42.27,190.97 42.27,189.71 42.02,189.46 42.02,186.02 40.11,186.02 40.11,186.03 39.46,186.03 38.95,186.54 37.43,186.54 37.3,186.66 37.32,186.68 37.32,186.94 36.94,187.32 35.75,187.32 35.75,187.31 35.5,187.06 35.03,187.06 34.95,186.98 31.27,186.98 31.14,187.11 31.14,192.63 31.64,193.13 33.06,193.13
GND on TOP (solid shape): 124.44,183.06 124.44,181.89 124.07,181.52 124.07,180 123.94,179.87 123.28,179.87 122.7,179.87 121.89,179.87 121.66,179.87 121.28,179.49 121.28,178.73 120.9,178.35 120.9,178.27 120.87,178.26 120.55,177.87 120.69,177.39 120.69,177.22 120.9,177.02 120.9,175.96 120.92,175.94 122.17,175.94 122.29,175.81 122.29,173.01 122.17,172.89 117.59,172.89 117.47,173.01 117.47,175.3 117.7,175.53 117.7,177.43 117.98,177.71 118.48,177.71 118.74,177.97 119.25,177.97 119.37,178.09 119.37,179.24 119.63,179.49 119.63,183.3 119.75,183.43 124.07,183.43
GND on TOP (solid shape): 142.94,262.68 143.04,262.6 142.98,262.49 141.84,261.74 141,260.65 138.13,257.78 136.61,257.78 136.61,258.34 134.66,258.34 134.04,258.96 133.52,258.96 131.82,260.65 8.43,260.65 7.2,260.84 5.97,260.65 3.05,260.65 3.05,185.31 1.73,182.28 3.05,179.25 3.05,176.44 3.01,176.37 2.93,176.34 1.72,175.36 2.9,174.34 2.98,174.32 3.01,174.24 3.01,169.46 2.87,169.1 3.01,168.73 3.01,167.86 3.05,167.83 3.05,79.49 2.87,79.31 1.17,79.31 1.02,79.47 1.02,262.5 1.07,262.63 1.2,262.68
GND on TOP (solid shape): 221.68,7.08 222.34,5.05 222.31,4.97 222.24,4.94 220.97,2.5 223.67,3.05 265.66,3.05 266.92,1.91 268.45,2.63 268.56,2.68 268.63,2.58 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 220.05,5.86 219.31,6.66 219.31,7.12 219.78,7.12 219.78,8.22 219.96,8.36 220.12,8.54
GND on BOTTOM (solid shape): 123.39,172.83 123.44,172.76 123.5,172.69 123.69,172.5 124.17,172.5 124.17,172.07 123.44,171.34 122.65,171.34 122.34,171.64 122.34,172.99 122.45,173.09 123.13,173.09
GND on BOTTOM (solid shape): 268.63,20.26 268.56,20.16 268.45,20.21 267.7,20.84 266.73,20.89 266.64,20.91 266.6,20.99 266.6,48.22 267.82,49.43 268.63,49.43
GND on BOTTOM (solid shape): 124.2,182.92 124.2,179.62 123.89,179.31 122.01,179.31 121.68,178.98 121.66,178.98 121.14,178.46 121.11,178.46 120.53,178.2 120.4,177.58 120.4,177.57 120.4,176.85 120.76,176.24 121.47,176.26 121.48,176.27 121.58,176.27 121.79,176.06 121.79,174.35 121.76,174.35 121.76,174.04 121.76,174.03 121.72,173.84 121.75,173.65 121.76,173.62 121.66,173.52 120.26,173.52 118.74,173.52 118.23,173.52 118.1,173.52 117.85,173.78 117.85,177.08 118.84,178.07 119.33,178.07 119.33,178.09 119.37,178.09 119.5,178.22 119.5,179.24 119.75,179.49 119.75,183.3 119.78,183.33 123.79,183.33
GND on BOTTOM (solid shape): 201.3,9.86 201.43,9.86 201.82,9.49 202.16,9.08 202.18,9.05 217.84,9.05 217.84,9.01 218.83,8.04 220.12,8.54 221.68,7.08 222.34,5.05 222.31,4.97 222.24,4.94 220.97,2.5 223.67,3.05 265.66,3.05 266.92,1.91 268.45,2.63 268.56,2.68 268.63,2.58 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 200.48,7.94 200.46,8.02 200.53,8.09 201.24,8.76 201.27,9.74
GND on V3 (solid shape): 201.3,9.86 201.43,9.86 201.82,9.49 202.16,9.08 202.18,9.05 217.84,9.05 217.84,9.01 218.83,8.04 220.12,8.54 221.68,7.08 222.34,5.05 222.31,4.97 222.24,4.94 220.97,2.5 223.67,3.05 265.66,3.05 266.92,1.91 268.45,2.63 268.56,2.68 268.63,2.58 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 200.48,7.94 200.46,8.02 200.53,8.09 201.24,8.76 201.27,9.74
GND on S5 (solid shape): 201.3,9.86 201.43,9.86 201.82,9.49 202.16,9.08 202.18,9.05 217.84,9.05 217.84,9.01 218.83,8.04 220.12,8.54 221.68,7.08 222.34,5.05 222.31,4.97 222.24,4.94 220.97,2.5 223.67,3.05 265.66,3.05 266.92,1.91 268.45,2.63 268.56,2.68 268.63,2.58 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 200.48,7.94 200.46,8.02 200.53,8.09 201.24,8.76 201.27,9.74
GND on S7 (solid shape): 201.3,9.86 201.43,9.86 201.82,9.49 202.16,9.08 202.18,9.05 217.84,9.05 217.84,9.01 218.83,8.04 220.12,8.54 221.68,7.08 222.34,5.05 222.31,4.97 222.24,4.94 220.97,2.5 223.67,3.05 265.66,3.05 266.92,1.91 268.45,2.63 268.56,2.68 268.63,2.58 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 200.48,7.94 200.46,8.02 200.53,8.09 201.24,8.76 201.27,9.74
GND on S9 (solid shape): 268.55,51.66 268.63,51.56 268.63,20.26 268.56,20.16 268.45,20.21 267.7,20.84 266.73,20.89 266.64,20.91 266.6,20.99 266.6,21.12 266.98,21.5 266.98,44.31 266.59,44.69 266.6,44.69 266.6,49.38 267.6,50.12 268.28,51.16 268.29,51.19 268.29,51.23 268.32,51.26 268.33,51.29 268.39,51.43 268.43,51.59
GND on S9 (solid shape): 201.3,9.86 201.43,9.86 201.82,9.49 202.16,9.08 202.18,9.05 217.84,9.05 217.84,9.01 218.83,8.04 220.12,8.54 221.68,7.08 222.34,5.05 222.31,4.97 222.24,4.94 220.97,2.5 223.67,3.05 265.66,3.05 266.92,1.91 268.45,2.63 268.56,2.68 268.63,2.58 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 200.48,7.94 200.46,8.02 200.53,8.09 201.24,8.76 201.27,9.74
GND on S12 (solid shape): 268.55,51.66 268.63,51.56 268.63,20.26 268.56,20.16 268.45,20.21 267.7,20.84 266.73,20.89 266.64,20.91 266.6,20.99 266.6,21.12 266.98,21.5 266.98,44.31 266.59,44.69 266.6,44.69 266.6,49.38 267.6,50.12 268.28,51.16 268.29,51.19 268.29,51.23 268.32,51.26 268.33,51.29 268.39,51.43 268.43,51.59
GND on S12 (solid shape): 201.3,9.86 201.43,9.86 201.82,9.49 202.16,9.08 202.18,9.05 217.84,9.05 217.84,9.01 218.83,8.04 220.12,8.54 221.68,7.08 222.34,5.05 222.31,4.97 222.24,4.94 220.97,2.5 223.67,3.05 265.66,3.05 266.92,1.91 268.45,2.63 268.56,2.68 268.63,2.58 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 200.48,7.94 200.46,8.02 200.53,8.09 201.24,8.76 201.27,9.74
GND on S14 (solid shape): 201.3,9.86 201.43,9.86 201.82,9.49 202.16,9.08 202.18,9.05 217.84,9.05 217.84,9.01 218.83,8.04 220.12,8.54 221.68,7.08 222.34,5.05 222.31,4.97 222.24,4.94 220.97,2.5 223.67,3.05 265.66,3.05 266.92,1.91 268.45,2.63 268.56,2.68 268.63,2.58 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 200.48,7.94 200.46,8.02 200.53,8.09 201.24,8.76 201.27,9.74
GND on S16 (solid shape): 201.3,9.86 201.43,9.86 201.82,9.49 202.16,9.08 202.18,9.05 217.84,9.05 217.84,9.01 218.83,8.04 220.12,8.54 221.68,7.08 222.34,5.05 222.31,4.97 222.24,4.94 220.97,2.5 223.67,3.05 265.66,3.05 266.92,1.91 268.45,2.63 268.56,2.68 268.63,2.58 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 200.48,7.94 200.46,8.02 200.53,8.09 201.24,8.76 201.27,9.74
GND on TOP: 153.89,115.92 154.02,116.05 157.83,116.05 158.46,115.42 159.73,115.42 159.99,115.16 166.72,115.16 167.61,114.27 167.62,114.27 167.72,114.18 169.6,114.18 169.89,114.46 169.89,115.92 169.95,115.99 175.92,115.99 176.05,115.86 176.05,111.41 175.73,111.09 171.61,111.09 171.35,111.35 166.65,111.35 166.59,111.41 166.59,114.15 166.21,114.53 163.41,114.53 163.03,114.15 163.03,111.48 162.91,111.35 159.29,111.35 158.91,110.97 154.33,110.97 153.89,111.41 ; 1 cut-out
GND on TOP: 43.72,156.69 39.4,156.69 38.64,155.93 38.64,151.23 39.53,150.34 40.86,150.34 43.84,153.32 43.84,156.56
GND on TOP: 128.9,118.51 129.82,117.59 134.61,117.59 134.98,117.22 134.98,116.77 135.17,116.58 136.69,116.58 137.66,117.55 137.66,122.15 137.79,122.27 137.79,131.34 138.08,131.63 138.08,132.88 137.82,133.13 137.82,134.02 131.22,134.02 128.9,131.7
GND on TOP: 72.23,99.67 72.61,100.05 72.61,102.46 72.23,102.84 68.44,102.84 68.4,102.89 67.15,102.89 67.03,102.77 67.03,100.59 67.96,99.67
GND on TOP: 38.95,171.04 40.92,169.07 44.67,169.07 45.11,169.52 45.11,173.33 46.7,174.91 46.7,181.14 47.65,182.09 47.65,182.92 47.53,183.04 46.96,183.04 45.43,181.52 41.88,181.52 38.95,178.6
GND on TOP: 154.96,90.19 154.76,89.99 154.76,89.68 154.43,89.35 152.6,89.35 151.98,89.97 151.98,91.92 151.53,92.38 150.64,92.38 150.13,91.87 150.13,85.01 151.22,83.92 153.89,83.92 154.33,84.36 154.33,86.89 154.45,87.02 154.45,88.67 154.84,89.05 155.6,89.05 155.72,89.18 155.72,90.07 155.6,90.19
GND on TOP: 25.15,140.44 23.94,140.44 23.84,140.54 23.84,141.82 24.31,142.29 24.66,142.29 24.88,142.51 24.88,144.05 24.78,144.15 24.77,144.15 24.56,144.15 24.18,144.52 24.18,145.25 24.45,145.52 27.24,145.52 27.35,145.41 27.35,144.9 27.3,144.85 26.71,144.85 26.64,144.78 26.64,143.84 26.63,143.84 26.63,142.29 25.28,140.93 25.28,140.57
GND on TOP: 99.41,147.44 99.41,145.9 99.56,145.74 100.14,145.74 100.17,145.72 109.03,145.72 109.03,147.57 108.93,147.67 99.63,147.67
GND on TOP: 69.26,119.86 72.52,119.86 72.69,119.69 72.69,116.26 72.48,116.06 69.43,116.06 69.03,116.46 69.03,119.63
GND on TOP: 83.66,102.59 79.98,102.59 79.59,102.21 79.59,98.27 79.98,97.89 83.79,97.89 84.04,98.14 84.04,102.21
GND on TOP: 52.12,90.74 52.2,90.66 52.2,88.88 51.95,88.62 46.82,88.62 46.57,88.87 46.57,90.65 46.66,90.74
GND on TOP: 112.5,105.78 112.23,105.51 112.23,100.91 112.47,100.67 114.82,100.67 115,100.84 115,101.79 115.26,102.05 117.72,102.05 117.91,101.86 121.97,101.86 122.24,101.6 123.49,101.6 123.92,102.03 123.92,103.22 123.66,103.48 118.08,103.48 117.95,103.6 117.95,104.11 116.78,105.28 115.43,105.28 114.94,105.78
GND on TOP: 173.12,103.65 171.39,103.65 171.39,103.73 170.86,104.26 170.22,104.26 169.84,103.88 169.31,103.88 169.31,104.42 168.04,104.42 167.92,104.54 167.92,106.07 168.17,106.32 173.12,106.32 173.38,106.07 173.38,103.91
GND on TOP: 104.31,99.21 100.63,99.21 100.45,99.03 100.45,97.23 100.9,96.77 104.28,96.77 104.61,97.1 104.61,98.91
GND on TOP: 185.7,130.09 186.16,129.63 189,129.63 189.8,130.43 189.8,134.25 189.38,134.68 186.25,134.68 185.7,134.13
GND on TOP: 113.1,92.73 112.59,92.22 112.59,89.58 113.17,89 119.8,89 121.01,90.21 121.01,92.14 120.41,92.73
GND on TOP: 202.4,222.59 202.4,224.88 202.15,225.13 200.24,225.13 199.99,224.88 199.99,222.72 200.31,222.4 202.21,222.4
GND on TOP: 61.67,189.34 61.67,188.22 62.46,187.43 62.46,186.92 62.61,186.77 63.27,186.77 64.18,187.68 71.57,187.68 71.85,187.4 71.85,186.31 71.34,185.8 70.45,185.8 70.32,185.93 70.32,186.2 70.2,186.33 68.04,186.33 67.91,186.2 67.05,186.2 67.02,186.23 65.22,186.23 64.68,185.69 61.48,185.69 61.42,185.63 61.42,185.09 61.38,185.06 60.97,185.06 60.86,185.17 60.86,189.74 60.96,189.84 61.43,189.84 61.43,189.58
GND on TOP: 66.54,116.26 66.41,116.13 66.34,116.05 65.47,116.05 65.42,116 65.42,115.34 65.13,115.05 63.57,115.05 63.57,115.06 63.39,115.24 63.39,116.05 63.14,116.31 63.14,116.74 63.21,116.81 63.21,119.23 62.51,119.92 62.51,120.81 62.64,120.94 63.4,120.94 63.59,120.75 63.59,120.05 64.54,119.1 65.69,119.1 66.54,118.25
GND on TOP: 15.75,137.26 15.75,138.66 16.26,139.17 16.26,140.97 16.27,140.98 16.27,144.77 17.02,145.51 17.56,145.51 17.95,145.12 18.22,145.12 19.1,144.23 19.1,141.72 18.73,141.35 17.95,141.35 17.36,140.76 17.36,139.39 17.64,139.11 17.64,137.42 16.73,136.51 15.58,136.51 15.46,136.62 15.46,136.97
GND on TOP: 170.3,133.19 170.3,134.72 170.43,134.85 171.8,134.85 172.11,134.53 172.11,132.12 171.92,131.93 171.56,131.93
GND on TOP: 26.42,90.72 26.42,89.46 26.09,89.13 18.32,89.13 18.02,89.43 18.02,90.81 18.25,91.03 26.1,91.03
GND on TOP: 75.81,112.39 75.53,112.11 75.53,109.83 75.91,109.45 83.86,109.45 83.89,109.47 84.45,109.47 84.67,109.7 84.67,112.11 84.39,112.39
GND on TOP: 156.36,104.54 156.36,106.19 156.61,106.45 157.12,106.45 157.38,106.19 162.2,106.19 162.33,106.07 162.33,103.91 162.2,103.78 158.01,103.78 157.88,103.91 157.88,104.42 156.49,104.42
GND on TOP: 159.76,130.4 158.23,130.4 157.98,130.14 157.98,129 158.23,128.75 159.88,128.75 160.01,128.87 160.01,130.14
GND on TOP: 68.65,182.17 69.12,181.71 70.04,181.71 70.08,181.67 70.08,181.18 69.27,180.37 63.5,180.37 62.92,180.95 62.92,181.77 63.09,181.94 63.09,182.07 63.2,182.17
GND on TOP: 84.2,126.85 84.2,123.29 83.7,122.78 71.34,122.78 71.21,122.91 71.21,127.35 71.47,127.61 75.03,127.61 75.4,127.23 79.52,127.23 79.68,127.07 83.98,127.07
GND on TOP: 8.6,110.18 8.73,110.31 8.73,113.54 8.14,114.12 7.84,114.12 7.36,114.6 3.72,114.6 3.47,114.35 3.47,110.82 3.78,110.51 6.87,110.51 7.2,110.18
GND on TOP: 136.68,242.1 132.3,242.1 131.66,241.46 131.66,238.92 132.36,238.22 136.43,238.22 137.06,238.86 137.06,241.72
GND on TOP: 202.4,225.77 202.4,228.05 202.15,228.31 200.24,228.31 199.99,228.05 199.99,225.89 200.31,225.57 202.21,225.57
GND on TOP: 87.85,86.69 84.27,86.69 83.85,86.27 83.85,73.89 84.04,73.7 85.18,73.7 85.37,73.89 85.37,74.46 85.5,74.58 85.69,74.58 86.07,74.97 86.07,76.68 87.34,77.95 87.53,77.95 88.51,78.93 88.51,86.03
GND on TOP: 128.62,156.44 124.81,156.44 123.92,155.55 118.08,155.55 117.44,156.18 111.6,156.18 109.19,158.6 109.19,161.9 108.68,162.41 105.5,162.41 105.38,162.28 105.38,157.2 106.12,156.45 107.38,156.45 112.94,150.89 131.65,150.89 132.93,152.18 132.93,162.91 129.43,166.41 126.77,166.41 126.33,166.85 123.28,166.85 122.77,166.34 122.77,165.2 123.29,164.69 125,164.69 125.48,164.21 126.24,164.21 126.62,163.83 126.62,163.51 129.76,160.37 129.76,157.58
GND on TOP: 230.85,137.39 230.85,134.47 230.72,134.34 228.57,134.34 228.44,134.21 228.44,133.58 229.33,132.69 233.9,132.69 234.28,133.07 234.28,133.7 233.9,134.08 232.76,134.08 232.38,134.47 232.38,137.13 232.63,137.39 233.52,137.39 234.03,137.89 234.03,143.86 233.14,144.75 228.69,144.75 228.44,144.5 228.44,139.8
GND on TOP: 200.63,216.43 200.63,218.72 200.37,218.97 198.47,218.97 198.21,218.72 198.21,216.56 198.53,216.24 200.43,216.24
GND on TOP: 96.03,109.88 95.85,110.06 95.85,112.11 96.61,112.88 96.61,120.37 97.09,120.85 97.09,127.71 96.57,128.23 96.57,134.81 96.14,134.81 94.12,136.83 94.12,139.76 95.07,140.71 110.82,140.71 112.62,138.91 112.62,134.51 112.09,133.98 105.62,133.98 105.17,134.43 105.17,135.74 104.3,136.61 100.73,136.61 99.91,135.79 99.91,132.28 99.41,131.77 99.41,127.23 99.28,127.1 99.25,127.1 99.18,127.02 99.18,126.06 99.66,125.58 99.66,124.43 99.89,124.2 99.89,117.7 99.58,117.4 99.58,113.15 98.77,112.34 98.77,112.14 98.72,112.09 98.11,112.09 98.03,112.01 98.03,111.17 98.06,111.15 98.14,111.15 98.14,109.88
GND on TOP: 210.49,111.53 210.45,111.57 208.8,111.57 208.64,111.41 208.64,110.26 208.78,110.12 210.43,110.12 210.49,110.19
GND on TOP: 5.99,102.21 7.51,102.21 7.69,102.03 7.69,101.65 7.76,101.57 8.75,101.57 8.83,101.65 8.83,104.85 8.73,104.95 7.2,104.95 6.98,104.72 6.98,103.73 6.85,103.6 6.06,103.6 5.99,103.68 5.99,104.11 5.87,104.23 5.67,104.23 5.52,104.07 5.52,102.68
GND on TOP: 95.52,105.26 93.39,105.26 92.8,105.84 92.8,106.98 93.11,107.29 95.49,107.29 95.72,107.06 95.72,105.46
GND on TOP: 32.64,90.04 32.64,93.58 33.02,93.96 40.13,93.96 40.39,93.7 40.39,89.96 39.91,89.48 35.8,89.48 35.55,89.74 32.95,89.74
GND on TOP: 122.01,109.98 117.61,109.98 117.06,110.53 117.06,111.99 117.39,112.32 121.78,112.32 122.22,111.88 122.22,110.18
GND on TOP: outline of 113 points within 143.32,53.57 268.63,262.68
GND on TOP: 215.28,110.05 216.93,110.05 217.18,110.3 217.18,111.32 216.93,111.57 215.28,111.57 215.15,111.44 215.15,110.17
GND on TOP: 75.44,139.8 75.95,140.31 85.35,140.31 85.6,140.06 85.6,135.74 85.47,135.61 75.86,135.61 75.44,136.03
GND on TOP: 202.4,219.35 202.4,221.64 202.15,221.89 200.24,221.89 199.99,221.64 199.99,219.48 200.31,219.16 202.21,219.16
GND on TOP: 163.32,128.63 162.99,128.3 162.99,128.12 162.81,127.94 162.64,127.94 162.48,127.79 162.48,126.72 162.59,126.62 163.07,126.62 163.47,127.03 163.7,127.03 164.08,127.41 164.08,128.63 164.08,128.63
GND on TOP: 56.9,96.37 65.79,96.37 66.04,96.12 66.04,92.69 62.36,89 56.9,89 56.52,89.39 56.52,95.99
GND on TOP: 106.52,131.67 105.48,131.67 105.38,131.57 104.56,131.57 104.38,131.39 104.38,130.3 104.54,130.15 106.52,130.15 106.77,130.4 106.77,131.42
GND on TOP: 18.4,95.39 17.54,94.54 15.95,94.54 15.72,94.76 15.72,100.28 15.88,100.43 18.2,100.43 18.4,100.24
GND on TOP: 252.76,168.62 248.52,168.62 247.85,169.3 246.28,169.3 246.08,169.09 246.08,168.47 245.92,168.32 245.03,168.32 244.97,168.25 244.97,167.6 244.98,167.59 244.98,165.95 245.89,165.05 247.52,165.05 248.17,164.4 248.17,158.79 249.49,157.47 257.9,157.47 258.31,157.87 258.31,159.49 257.96,159.84 251.54,159.84 250.58,160.8 250.55,160.8 250.55,164.24 251.33,165.02 251.73,165.02 253.09,166.39 253.09,168.29
GND on TOP: 31.75,141.33 29.1,141.33 28.97,141.2 28.97,137.12 29.21,136.88 31.63,136.88 32.01,137.26 32.01,141.07
GND on BOTTOM: 104.04,164.88 102.77,164.88 102.33,164.44 102.33,157.01 102.52,156.82 104.17,156.82 104.55,157.2 104.55,164.37
GND on BOTTOM: 175.86,115.99 170.02,115.99 169.89,115.86 169.89,111.8 170.21,111.48 175.86,111.48 176.18,111.8 176.18,115.61 175.86,115.92
GND on BOTTOM: 84.17,99.67 82.67,99.67 82.67,99.69 82.59,99.69 82.29,100 82.29,102.31 81.75,102.84 78.55,102.84 77.69,101.98 77.69,94.46 77.94,94.21 80.48,94.21 80.86,94.59 80.86,96.62 81.5,97.25 83.4,97.25 84.29,98.14 84.29,99.54
GND on BOTTOM: 208.82,152.63 207.67,151.48 207.67,148.5 207.55,148.37 207.55,147.04 202.66,147.04 202.53,147.17 200.75,147.17 198.09,144.5 198.09,140.62 198.34,140.37 198.97,140.37 199.16,140.18 199.16,135.74 199.42,135.48 201.01,135.48 203.04,137.51 208.94,137.51 213.58,142.15 213.58,158.28 213.01,158.85 209.71,158.85 208.82,157.96
GND on BOTTOM: 109.26,147.7 98.81,147.7 98.27,147.15 98.27,146.09 98.6,145.76 109.23,145.76 109.78,146.31 109.78,147.18
GND on BOTTOM: 126.58,155.93 119.47,155.93 119.22,156.18 111.98,156.18 111.47,155.67 111.47,153.13 112.11,152.5 117.19,152.5 117.82,153.13 126.08,153.13 127.09,154.15 127.09,155.42
GND on BOTTOM: 99.58,137.28 104.41,137.28 104.82,137.69 104.82,139.47 104.74,139.55 99.61,139.55 99.3,139.24 99.3,137.56
GND on BOTTOM: 100.93,96.87 104.23,96.87 104.24,96.89 104.52,96.89 104.59,96.95 104.59,100.07 104.41,100.25 100.55,100.25 100.37,100.07 100.37,97.43
GND on BOTTOM: 19.27,153.74 18.96,154.05 16.17,154.05 15.98,153.86 15.98,150.75 16.19,150.54 19.07,150.54 19.27,150.74
GND on BOTTOM: 201.77,216.18 201.77,217 201.7,217.07 199.29,217.07 199.1,216.87 199.1,216.18 199.36,215.92 201.51,215.92
GND on BOTTOM: 39.97,189.14 39.72,189.39 39.72,190.22 39.46,190.47 37.94,190.47 36.73,189.27 33.94,189.27 32.03,191.17 32.03,192.19 31.78,192.44 30.64,192.44 30.45,192.25 30.45,187.3 30.83,186.92 35.46,186.92 35.91,186.47 36.86,186.47 36.86,177.46 38.2,176.12 46.38,176.12 46.76,176.5 46.76,181.71 46.64,181.84 46.26,181.84 46.07,182.03 46.07,183.61 45.88,183.8 43.84,183.8 41.94,185.71 41.94,188.69 41.49,189.14
GND on BOTTOM: 160.68,93.62 160.42,93.88 160.42,96.16 160.93,96.67 171.6,96.67 171.98,96.29 171.98,94 171.6,93.62
GND on BOTTOM: 84.8,127.12 85.18,126.74 85.18,124.71 86.07,123.82 86.07,121.49 86.02,121.43 82.37,121.43 81.82,121.98 81.82,122.49 81.47,122.83 72.51,122.83 72.03,123.31 72.03,126.79 72.36,127.12
GND on BOTTOM: 76.2,140.82 85.35,140.82 85.6,140.57 85.6,135.74 85.47,135.61 75.95,135.61 75.44,136.12 75.44,140.06
GND on BOTTOM: 230.15,155.09 224.52,155.09 223.7,154.26 223.7,149.77 223.78,149.69 227.48,149.69 228.27,148.89 228.27,142.36 227.67,141.76 226.2,141.76 226.13,141.83 223.67,141.83 223.1,142.4 223.1,144.56 221.79,145.87 221.79,147.3 219.76,147.3 219.61,147.15 219.61,143.81 224.53,138.89 229.35,138.89 231.06,140.59 231.06,145.64 231.12,145.71 230.86,145.96 230.86,150.01 230.8,150.08 230.8,154.43
GND on BOTTOM: outline of 267 points within 1.02,1.02 268.63,262.68 ; 11 cut-outs
GND on BOTTOM: 100.14,13.04 99.88,13.29 99.88,16.72 100.01,16.85 106.49,16.85 107,17.36 107,22.69 106.74,22.95 104.46,22.95 104.2,23.2 104.2,25.1 104.13,25.18 104,25.18 103.8,25.38 103.8,25.69 103.99,25.88 103.99,28.19 104.07,28.28 104.84,28.28 104.91,28.2 104.91,27.54 104.93,27.53 104.93,27.02 104.91,27.01 104.91,26.17 105.73,25.36 105.73,24.47 105.9,24.29 105.9,23.61 105.93,23.58 107.5,23.58 109.28,21.8 109.28,13.55 108.77,13.04
GND on BOTTOM: 109.76,86.27 110.46,86.97 113.57,86.97 114.27,87.67 114.27,91.6 115.22,92.56 118.09,92.56 120.17,94.63 120.17,100.06 120,100.22 120,101.7 120.19,101.89 121.51,101.89 122.07,102.45 127.43,102.45 128.75,101.12 128.75,95.11 116.27,82.63 110.42,82.63 109.76,83.29
GND on BOTTOM: 52.87,158.65 53.39,158.13 53.39,152.08 53.36,152.04 48.66,152.04 47.83,152.87 47.83,157.33 47.84,157.33 48.48,157.96 51.65,157.96 51.91,158.21 51.91,158.6 51.96,158.65
GND on BOTTOM: 152.42,89.25 152.42,87.04 152.7,86.76 154.33,86.76 154.45,86.89 154.45,89.2 154.28,89.38 152.55,89.38
GND on BOTTOM: 108.09,177.98 108.74,177.33 109.76,177.33 111.15,178.72 113.82,178.72 114.52,179.42 114.52,183.49 114.2,183.8 108.38,183.8 108.1,183.52 108.09,183.52
GND on BOTTOM: 97.76,135.99 99.28,135.99 100.5,134.77 101.01,134.77 101.18,134.59 101.18,131.24 100.83,130.88 100.83,129.39 100.98,129.23 100.98,126.79 100.99,126.78 99.94,125.73 99.94,119.76 99.33,119.15 99.33,114.66 99.06,114.39 99.06,109.88 95.86,109.88 94.77,110.97 94.77,112.96 94.92,113.12 95.38,113.12 96.26,113.99 96.36,113.99 96.36,115.29 96.49,115.42 97.37,115.42 97.54,115.58 97.54,120.14 97.46,120.22 97.46,124.72 97.09,125.09 97.09,127.2 97.37,127.48 97.37,129.46 97.12,129.72 96.51,129.72 96.38,129.84 96.38,130.63 96.46,130.71 97.4,130.71 97.53,130.83 97.53,135.76
GND on BOTTOM: 75.66,109.7 76.04,109.32 84.17,109.32 84.67,109.83 84.67,111.86 84.17,112.37 75.91,112.37 75.66,112.11
GND on BOTTOM: 71.21,154.15 64.99,154.15 64.86,154.28 64.86,158.34 64.48,158.72 64.48,160.63 64.67,160.82 66.2,160.82 66.26,160.75 66.26,159.36 66.64,158.98 67.53,158.98 68.04,159.48 68.55,159.48 68.8,159.23 68.8,158.34 69.05,158.09 71.21,158.09 71.34,158.21 71.34,162.02 71.47,162.15 72.61,162.15 72.74,162.02 72.74,155.67
GND on G2: 1.02,6.52 1.02,262.5 1.07,262.63 1.2,262.68 268.45,262.68 268.58,262.63 268.63,262.5 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 198.72,8.55 197.54,7 197.54,5.11 196.82,4.02 113.95,4.02 113.23,5.11 113.23,7 111.61,8.62 109.99,7 109.99,5.11 109.27,4.02 23.96,4.02 23.83,4.07 23.78,4.2 23.78,4.8 23.13,6.37 21.56,7.02 4.5,7.02 3.76,6.89 3.1,6.52 ; 1 cut-out
GND on V3, S5, V18: outline of 267 points within 1.02,1.02 268.63,262.68
GND on V3, S14: 268.63,20.26 268.56,20.16 268.45,20.21 267.7,20.84 266.73,20.89 266.64,20.91 266.6,20.99 266.6,49.38 267.6,50.12 268.28,51.16 268.29,51.19 268.29,51.23 268.32,51.26 268.33,51.29 268.39,51.43 268.43,51.59 268.55,51.66 268.63,51.56
GND on G4: 1.02,76.62 1.02,262.5 1.07,262.63 1.2,262.68 268.45,262.68 268.58,262.63 268.63,262.5 268.63,11.38 267.61,10.36 224.4,10.36 208.64,26.12 206.04,26.12 201.82,21.89 15.81,21.89 3.79,33.91 3.79,62.02 7.2,65.43 7.2,73.24 2.39,78.05 2.39,77.99 ; 4 cut-outs
GND on S5: 99.25,134.62 99.25,127.61 99.27,127.59 99.27,127.11 99.58,126.79 99.58,124.38 100.04,123.92 100.04,118.21 99.33,117.5 99.33,110.94 98.72,110.34 96.97,110.34 96.49,110.82 96.49,112.37 97.46,113.34 97.46,124.72 97.09,125.09 97.09,127.2 97.37,127.48 97.37,127.86 97.5,127.99 97.5,134.64 97.7,134.85 99.03,134.85
GND on G6: 5.26,49.77 5.55,50.38 4.94,50.1 4.66,50.38 4.66,55.9 4.76,56 5.42,56.67 4.66,57.22 4.66,57.66 7.95,60.95 7.95,65.8 12.6,70.45 12.6,75.81 9.92,78.49 1.02,78.49 1.02,262.5 1.07,262.63 1.2,262.68 268.45,262.68 268.58,262.63 268.63,262.5 268.63,21.32 268.63,21.31 268.53,21.41 266,21.41 265.25,20.66 265.25,13.73 263.98,12.46 226.87,12.46 225.76,13.58 225.76,24.45 223.31,26.9 223.31,28.47 220.6,31.17 200.05,31.17 195.76,26.87 15.48,26.87 6.48,35.87 6.48,42.24 6.53,42.29 6.53,48.51 ; 1 cut-out
GND on S7: outline of 284 points within 1.02,1.02 268.63,262.68
GND on G8, G13, G15: 1.2,1.02 1.07,1.07 1.02,1.2 1.02,262.5 1.07,262.63 1.2,262.68 268.45,262.68 268.58,262.63 268.63,262.5 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 198.72,8.55 197.54,7 197.54,5.11 196.82,4.02 113.95,4.02 113.23,5.11 113.23,7 111.61,8.62 109.99,7 109.99,5.11 109.27,4.02 23.96,4.02 23.83,4.07 23.78,4.2 23.78,4.8 23.13,6.37 21.56,7.02 4.5,7.02 2.93,6.37 2.28,4.8 2.28,1.02 ; 2 cut-outs
GND on S9: outline of 262 points within 1.02,1.02 268.63,262.68
GND on G11: 1.2,1.02 1.07,1.07 1.02,1.2 1.02,262.5 1.07,262.63 1.2,262.68 268.45,262.68 268.58,262.63 268.63,262.5 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 198.72,8.55 197.54,7 197.54,5.11 196.82,4.02 113.95,4.02 113.23,5.11 113.23,7 111.61,8.62 109.99,7 109.99,5.11 109.27,4.02 23.96,4.02 23.83,4.07 23.78,4.2 23.78,4.8 23.13,6.37 21.56,7.02 4.5,7.02 2.93,6.37 2.28,4.8 2.28,1.02 ; 2 cut-outs
GND on S12: outline of 274 points within 1.02,1.02 268.63,262.68
GND on S14: 96.87,135.99 99.28,135.99 100.5,134.77 101.01,134.77 101.18,134.59 101.18,133.17 101.03,133.02 99.84,133.02 99.83,133 99.44,133 99.25,132.81 99.25,127.61 99.27,127.59 99.27,127.11 99.58,126.79 100.98,126.79 101.06,126.72 101.06,124.69 100.89,124.52 100.89,119.8 101.21,119.48 101.21,117.98 101.13,117.9 99.74,117.9 99.33,117.5 99.33,111.86 99.48,111.71 101.18,111.71 101.24,111.66 101.24,110.08 101.08,109.93 99.56,109.93 99.15,110.34 96.97,110.34 96.49,110.82 96.49,112.09 96.64,112.24 97.37,112.24 97.5,112.37 97.5,114.02 97.37,114.15 96.61,114.15 96.36,114.4 96.36,115.29 96.49,115.42 97.37,115.42 97.63,115.67 97.63,120.37 97.46,120.53 97.46,124.72 97.09,125.09 97.09,127.2 97.37,127.48 97.37,128.88 96.99,129.26 96.36,129.26 96.23,129.39 96.23,130.4 96.36,130.53 97.37,130.53 97.5,130.66 97.5,135.23 97.37,135.35 96.87,135.35 96.74,135.48 96.74,135.86
GND on S14: 85.02,137.69 85.6,137.11 85.6,135.74 85.47,135.61 80.31,135.61 80.22,135.67 80.24,135.78 82.14,137.69
GND on S14: outline of 259 points within 1.02,1.02 268.63,262.68
GND on S16: outline of 267 points within 1.02,1.02 268.63,262.68 ; 3 cut-outs
GND on G17, G19: 1.2,1.02 1.07,1.07 1.02,1.2 1.02,262.5 1.07,262.63 1.2,262.68 268.45,262.68 268.58,262.63 268.63,262.5 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 198.72,8.55 197.54,7 197.54,5.11 196.82,4.02 113.95,4.02 113.23,5.11 113.23,7 111.61,8.62 109.99,7 109.99,5.11 109.27,4.02 23.96,4.02 23.83,4.07 23.78,4.2 23.78,4.8 23.13,6.37 21.56,7.02 4.5,7.02 2.93,6.37 2.28,4.8 2.28,1.02 ; 2 cut-outs
GND on V18: outline of 102 points within 143.32,53.57 268.63,262.68
GND on V18: 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 200.48,7.94 200.46,8.02 200.53,8.09 201.24,8.76 201.27,9.74 201.3,9.86 201.43,9.86 201.82,9.49 202.16,9.08 202.18,9.05 217.84,9.05 217.84,9.01 218.83,8.04 220.12,8.54 221.68,7.08 222.34,5.05 222.31,4.97 222.24,4.94 220.97,2.5 223.67,3.05 265.66,3.05 266.92,1.91 268.45,2.63 268.56,2.68 268.63,2.58 268.63,1.2 268.58,1.07 268.45,1.02
GND_USB on BOTTOM: 87.62,19.94 85.08,19.94 84.83,19.69 84.83,14.1 85.08,13.85 86.48,13.85 86.73,14.1 86.73,17.27 87.75,18.29 87.75,19.81
GND_VCC1P2 on TOP (solid shape): 128.01,177.08 128.01,175.94 127.88,175.81 126.61,175.81 126.48,175.94 126.48,177.08 126.59,177.18 127.35,177.18 127.43,177.18 127.53,177.21 127.88,177.21
GND_VCC1P2 on TOP (solid shape): 129.15,171.36 129.15,169.97 129.02,169.84 127.75,169.84 127.25,169.33 127.02,169.33 126.23,169.33 126.15,169.41 126.15,170.35 126.28,170.47 127.12,170.47 127.35,170.7 127.35,170.94 127.35,170.95 127.37,171.11 127.35,171.27 127.35,171.27 127.35,171.46 127.42,171.54 128.97,171.54
GND_VCC1P2 on S5: 128.62,179.3 123.03,179.3 122.01,178.28 122.01,175.99 127.73,170.28 129,170.28 130.14,171.42 130.14,177.77
GND_VCC1V on BOTTOM: 117.42,100.32 117.28,100.47 116.73,100.47 116.53,100.27 116.53,97.7 116.83,97.41 118.91,97.41 119.18,97.67 119.18,100.24 119.09,100.32
GND_VCC1V on S5: 116.65,100.53 118.35,100.53 119.35,99.54 119.35,98.14 119.73,97.76 119.73,96.11 119.22,95.6 116.55,95.6 116.42,95.48 116.42,93.44 116.04,93.06 109.82,93.06 109.44,93.44 109.44,96.62 109.82,97 114.39,97 116.3,98.91 116.3,100.18
GND_VCC2P5 on TOP (solid shape): 37.47,191.84 37.47,191.82 37.49,191.65 37.57,191.5 37.57,191.49 37.57,191.35 37.42,191.2 37.39,191.21 36.89,191.16 36.66,190.71 36.66,190.69 36.43,190.46 35.62,190.46 34.98,189.83 33.94,189.83 33.94,191.17 33.88,191.17 33.84,191.2 33.85,191.26 33.94,191.35 36.18,191.35 36.19,191.37 36.44,191.37 36.96,191.89 37.42,191.89
GND_VCC2P5 on S9: 44.42,196.95 34.64,196.95 33.43,195.74 33.43,192.25 35.33,190.35 38.83,190.35 44.1,195.62 44.35,195.62 44.61,195.87 44.61,196.76
GND_XO on S5: 247.23,132.43 243.42,132.43 243.04,132.05 243.04,130.66 246.13,127.57 246.13,124.71 247.27,123.57 248.67,123.57 248.67,124.97 248.7,125 249.77,123.92 263.87,123.92 264.13,123.67 264.13,111.61 263.36,110.84 263.36,105.51 264.51,104.37 265.52,104.37 266.82,105.66 266.82,129.23 265.52,130.53 249.14,130.53
GNDP on TOP (solid shape): outline of 228 points within 3.7,68.7 10.7,75.7
GNDP on BOTTOM (solid shape): outline of 228 points within 3.7,68.7 10.7,75.7
GNDP on G4: 1.2,1.02 1.07,1.07 1.02,1.2 1.02,76.55 2.48,78.01 9.62,78.01 12.28,75.35 12.28,70.65 7.65,66.01 7.65,61.25 4.41,58.01 4.41,50.26 6.25,48.42 6.25,35.15 15.08,26.32 195.99,26.32 200.31,30.64 220.37,30.64 222.66,28.36 222.66,26.71 225.14,24.23 225.14,12.67 226.15,11.66 264.38,11.66 265.65,12.93 265.65,18.58 265.59,18.64 265.59,20.17 266.16,20.74 268.25,20.74 268.63,20.36 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.5,7.02 201.47,7.07 201.47,7.02 201.24,7.02 200.53,7.85 198.72,8.55 197.54,7 197.54,5.11 196.82,4.02 113.95,4.02 113.23,5.11 113.23,7.76 112.36,8.63 110.83,8.63 109.99,7.79 109.99,5.11 109.27,4.02 23.96,4.02 23.83,4.07 23.78,4.2 23.78,4.8 23.13,6.37 21.56,7.02 4.5,7.02 2.93,6.37 2.28,4.8 2.28,1.02
GNDP on G6: 1.2,1.02 1.07,1.07 1.02,1.2 1.02,76.55 2.48,78.01 9.62,78.01 12.28,75.35 12.28,70.65 7.65,66.01 7.65,61.25 4.41,58.01 4.41,50.26 6.25,48.42 6.25,35.15 15.08,26.32 195.99,26.32 200.31,30.64 220.37,30.64 222.66,28.36 222.66,26.71 225.14,24.23 225.14,12.67 226.15,11.66 264.38,11.66 265.65,12.93 265.65,18.58 265.59,18.64 265.59,20.17 266.16,20.74 268.25,20.74 268.63,20.36 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 198.72,8.55 197.54,7 197.54,5.11 196.82,4.02 113.95,4.02 113.23,5.11 113.23,8.07 112.8,8.49 112.8,8.49 112.49,8.79 110.57,8.79 110.15,8.38 110.15,7.9 109.99,7.74 109.99,5.11 109.27,4.02 23.96,4.02 23.83,4.07 23.78,4.2 23.78,4.8 23.13,6.37 21.56,7.02 4.5,7.02 2.93,6.37 2.28,4.8 2.28,1.02
GNDP on G10: 1.2,1.02 1.07,1.07 1.02,1.2 1.02,76.55 2.48,78.01 9.62,78.01 12.28,75.35 12.28,70.65 7.65,66.01 7.65,61.25 4.41,58.01 4.41,50.26 6.25,48.42 6.25,35.15 15.08,26.32 195.99,26.32 200.31,30.64 220.37,30.64 222.66,28.36 222.66,26.71 225.14,24.23 225.14,12.67 226.15,11.66 264.38,11.66 265.65,12.93 265.65,18.58 265.59,18.64 265.59,20.17 266.16,20.74 268.25,20.74 268.63,20.36 268.63,1.2 268.58,1.07 268.45,1.02 220.32,1.02 220.32,4.8 219.67,6.37 218.1,7.02 201.24,7.02 200.53,7.85 198.72,8.55 197.54,7 197.54,5.11 196.88,4.12 196.82,4.02 113.95,4.02 113.23,5.11 113.23,7.95 112.47,8.71 110.43,8.71 109.99,8.27 109.99,5.11 109.27,4.02 23.96,4.02 23.83,4.07 23.78,4.2 23.78,4.8 23.13,6.37 21.56,7.02 4.5,7.02 2.93,6.37 2.28,4.8 2.28,1.02 ; 1 cut-out
V0P6_VTT_VIN on TOP: 62.56,190.69 62.44,190.81 62.15,190.81 61.93,191.04 61.93,192.08 61.98,192.13 64.92,192.13 65.05,192 65.05,190.81 64.97,190.73 64.36,190.73 64.34,190.71 64.34,189.89 64.39,189.84 64.9,189.84 64.97,189.77 64.97,189.41 65.61,188.78 65.61,188.02 65.56,187.96 63.45,187.96 63.4,188.02 63.4,188.57 63.32,188.65 62.26,188.65 62.05,188.85 62.05,189.57 62.11,189.62 62.44,189.62 62.56,189.74
VBUS_5V on BOTTOM: 92.26,19.83 94.42,19.83 94.8,20.21 96.22,20.21 98.71,22.71 98.71,24.86 98.83,24.99 100.17,24.99 100.17,24.1 100.3,23.98 100.3,21.93 100.49,21.74 102.43,21.74 103.01,22.32 106.58,22.32 106.71,22.2 106.71,20.1 106.26,19.66 102.78,19.66 102.25,19.12 102.25,18.39 101.95,18.08 98.64,18.08 98.14,17.57 98.14,13.56 97.55,12.98 92.64,12.98 92.01,13.61 92.01,19.58
VCC1V0_V3R3 on TOP: 104.94,124.81 106.21,124.81 106.47,125.07 106.47,127.23 106.34,127.35 104.94,127.35 104.69,127.1 104.69,125.07
VCC1V0_V3R3 on S12: 117.82,118.97 121.19,118.97 121.95,119.73 121.95,128.31 118.52,131.73 106.26,131.73 104.17,129.64 104.17,118.53 106.84,115.86 112.49,115.86 113.82,117.19 113.82,125.38 114.96,126.53 116.74,126.53 117.44,125.83 117.44,119.35
VCC1V0_VREF13 on TOP: 118.51,131.29 118.08,131.29 117.69,131.67 116.88,131.67 116.27,132.28 114.57,132.28 114.39,132.46 114.39,133.27 114.67,133.55 117.85,133.55 119.02,132.38 119.02,131.8
VCC1V0_VREF13 on S7: 114.54,131.33 117.24,128.64 117.24,122.81 116.42,121.99 106.06,121.99 104.97,120.9 104.97,119.76 106.77,117.96 117.82,117.96 121,121.13 121,131.54 118.96,133.58 114.9,133.58 114.54,133.22
VCC1V0_VSW6_5 on TOP: 96.36,116.18 96.36,113.26 93.56,110.46 88.74,110.46 88.36,110.84 88.36,114.78 89.88,116.3 96.23,116.3
VCC1V0_VSW6_6 on TOP: 94.33,132.18 96.36,132.18 96.36,129.26 95.98,128.88 92.04,128.88 88.23,132.69 88.23,135.99 88.61,136.37 92.8,136.37 94.2,134.97 94.2,132.31
VCC1V0_VSW6_VIN on TOP: 98.9,109.9 103.44,109.9 104.51,110.97 104.51,112.82 104.99,113.31 105.68,113.31 106.19,113.81 106.19,116.02 106.18,116.03 106.18,116.12 105.97,116.33 100.24,116.33 100.22,116.3 100.22,113.13 98.9,111.81
