# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PSU1_A: length 361.3
  TOP w0.127: P1.M17 v4(106.29,226.46)
  S14 w0.127: v4(106.29,226.46) 106.23,226.46 105.78,226.91 105.12,226.91 104.75,227.29 104.75,230.05 105.49,230.79 105.49,237.89 106.08,238.48 v1(106.14,238.48)
  S16 w0.127: v1(106.14,238.48) 103.41,241.21 86.01,241.21 78.84,234.05 78.84,224.16 74.43,219.75 74.43,218.68 72.96,217.2 71.62,217.2 65.4,210.98 64.86,210.98 62.64,208.76 62.64,208.49 62.64,207.76 60.17,205.28 54.1,205.28 53.14,206.25 38.1,206.25 36.58,204.72 29.49,204.72 13.06,188.29 13.06,175.85 8.53,171.32 8.53,168.6 8.22,168.3 8.22,163.56 4.66,160 4.66,153.36 4.45,153.15 4.45,143.98 5.55,142.87 5.55,136.85 6.49,135.91 6.49,114.92 5.21,113.64 5.21,100.7 4.41,99.9 4.41,93.36 3.85,92.8 3.85,81.18 7.38,77.65 9.05,77.65 11.48,75.21 11.48,69.29 7.95,65.75 7.95,63.11 2.73,57.89 2.73,54.35 4.46,52.63 4.46,50.04 6.75,47.76 8.62,47.76 17.57,38.81 17.57,21.54 19.7,19.4 28.35,19.4 35.14,12.61 46.83,12.61 v1(47.4,12.04)
  BOTTOM w0.127: v1(106.14,238.48) 106.14,238.92 v2(105.63,239.43) ; RB723.2 v1(47.4,12.04)
PSU1_A_R: length 7.4
  BOTTOM w0.127: CB977.2 RB723.1 47.4,9.05 v2(48.48,7.97) 49.67,6.78 LEDB9.C1
PSU1_G: length 9.8
  TOP w0.127: RB732.2 120.2,218.89 119.98,219.11 v1(119.98,219.24) ; P1.Y11 v4(114.29,219.46)
  S7 w0.127: v4(114.29,219.46) 114.7,219.05 117.57,219.05 117.82,218.79 119.54,218.79 v1(119.98,219.24)
  BOTTOM w0.127: v1(119.98,219.24) 120.81,219.24 v2(121.63,220.06)
PSU1_G_R: length 364.8
  TOP w0.127: CB978.2 v1(122.33,218.89) RB732.1
  S5 w0.127: v1(122.33,218.89) 120.66,217.23 120.66,213.92 119.06,212.32 119.06,210.32 117.15,208.4 110.6,208.4 110.02,208.99 105.71,208.99 105.54,208.82 101.58,208.82 101.39,209 95.94,209 94.94,210 93.66,210 93.03,210.63 90.07,210.63 88.05,208.61 85.24,208.61 84.28,209.58 82.81,209.58 81.26,208.03 78.46,208.03 77.06,209.42 70.64,209.42 69.4,208.19 v1(68.23,208.19)
  S16 w0.127: v1(68.23,208.19) 65.72,208.19 62.53,205 46.74,205 46,205.74 43.87,205.74 43.13,205 41.81,205 41.15,205.66 38.4,205.66 36.32,203.58 29.31,203.58 13.41,187.68 13.41,175.52 9.68,171.79 9.68,169.07 8.73,168.12 8.73,163.29 4.92,159.48 4.92,153.08 4.7,152.87 4.7,144.08 5.81,142.98 5.81,137.18 6.75,136.24 6.75,114.82 5.46,113.53 5.46,100.3 4.84,99.68 4.84,93.01 4.11,92.28 4.11,81.63 7.66,78.08 9.1,78.08 11.8,75.38 11.8,69.24 8.37,65.81 8.37,63.07 2.99,57.69 2.99,54.56 5.48,52.07 10.28,52.07 10.48,51.87 10.48,50.36 10.49,50.35 10.49,46.29 17.97,38.81 17.97,21.55 19.78,19.75 28.51,19.75 35.4,12.86 48.92,12.86 v1(49.75,12.04)
  BOTTOM w0.127: v2(49.75,13.12) v1(49.75,12.04) 49.75,9.56 51.17,8.14 LEDB9.C2 ; v2(123.41,219.24) 122.67,219.24 v1(122.33,218.89)
PSU1_SCL: length 177.9
  TOP w0.127: CONN5.17 14.2,238.16 v1(14.39,238.34) ; v1(171.61,249.21) 171.74,249.07 RB674.1
  S7 w0.127: v1(14.39,238.34) 13.68,239.05 13.68,240.13 24.92,251.37 78.4,251.37 86.82,242.95 104.32,242.95 111.6,250.23 136.05,250.23 137.19,251.37 155.67,251.37 157,250.04 170.78,250.04 v1(171.61,249.21)
  BOTTOM w0.127: v2(171.39,250.12) 171.61,249.91 v1(171.61,249.21)
PSU1_SCL_R: length 10.8
  TOP w0.127: v1(165.95,246.54) 166.51,245.99 UB16.11 168.72,245.99 169.95,247.22 169.95,247.75 170.27,248.07 RB674.2 170.83,247.76 171.1,247.5 173.19,247.5 173.31,247.61 RB675.2
  BOTTOM w0.127: v2(166.02,245.46) 166.02,246.48 v1(165.95,246.54)
PSU1_SDA: length 176.8
  TOP w0.127: RB680.1 v1(172.49,246.99) ; CONN5.19 v1(14.38,239.43)
  S7 w0.127: v1(172.49,246.99) 169.95,249.53 154.21,249.53 152.87,250.86 137.76,250.86 136.62,249.72 112.68,249.72 105.4,242.44 86.38,242.44 77.96,250.86 25.81,250.86 v1(14.38,239.43)
  BOTTOM w0.127: v1(172.49,246.99) v2(172.49,248.51)
PSU1_SDA_R: length 11.2
  TOP w0.127: v1(165.26,246.54) 165.26,246.16 166.08,245.34 UB16.10 168.79,245.34 170.44,246.99 RB680.2 170.83,246.74 171.1,246.48 172.8,246.48 RB681.2
  BOTTOM w0.127: v1(165.26,246.54) 165.07,246.73 v2(165.07,247.62)
PSU2_A: length 376.1
  TOP w0.127: v1(102.7,238.81) 102.09,238.81 101.57,238.29 101.57,235.37 v1(101.88,235.05) ; P1.L13 v4(105.29,222.46)
  S9 w0.127: v4(105.29,222.46) 105.29,222.64 103.72,224.2 103.72,225.78 102.76,226.74 102.76,231.13 102.43,231.46 102.43,234.42 101.88,234.97 v1(101.88,235.05)
  S16 w0.127: v1(102.7,238.81) 101.89,239.62 86.96,239.62 79.87,232.53 79.87,223.34 76.86,220.33 76.86,219.55 73.16,215.85 73.16,214.41 72.06,213.3 72.06,211.93 71.32,211.2 70.1,211.2 68.86,209.96 68.86,207.87 67.93,206.94 66.23,206.94 63.63,204.34 47.4,204.34 46.56,203.5 44.42,203.5 43.28,204.65 42.37,204.65 40.87,203.15 29.62,203.15 13.82,187.35 13.82,175.6 13.67,175.45 13.67,175.42 10.45,172.21 10.45,169.03 8.98,167.56 8.98,162.83 5.93,159.78 5.93,153.03 4.96,152.05 4.96,144.19 6.12,143.02 6.12,137.25 7,136.37 7,114.71 5.72,113.43 5.72,99.04 6.52,98.24 6.52,93.85 4.44,91.77 4.44,82.08 8.06,78.45 9.27,78.45 12.15,75.57 12.15,69.2 8.71,65.76 8.71,62.96 3.27,57.52 3.27,54.91 5.78,52.4 10.34,52.4 10.79,51.95 10.79,46.46 18.35,38.89 18.35,21.69 19.94,20.1 28.67,20.1 35.65,13.12 49.75,13.12 51.21,11.66 v1(57.62,11.66)
  BOTTOM w0.127: RB733.2 57.99,11.28 v1(57.62,11.66) 57.62,12.93 v2(57.75,13.05)
PSU2_A_R: length 9.5
  BOTTOM w0.127: LEDB10.C1 56.67,9.5 v2(57.12,9.94) 57.55,10.38 RB733.1 CB979.2
PSU2_G: length 7.4
  TOP w0.127: RB734.2 96.99,235.18 v1(97.96,234.21) 99.79,232.38 P1.F22
  BOTTOM w0.127: v1(97.96,234.21) 98.71,233.46 v2(98.9,233.46)
PSU2_G_R: length 351
  TOP w0.127: CB980.2 RB734.1 96.99,237.61 v1(96.97,237.64)
  S16 w0.127: v1(96.97,237.64) 95.84,236.51 91.28,236.51 88.13,233.36 86.22,233.36 82.32,229.46 82.32,220.86 74.58,213.12 74.58,211.69 71.23,208.33 69.96,208.33 67.87,206.25 66.62,206.25 64.29,203.91 48.49,203.91 47.32,202.74 30,202.74 14.18,186.92 14.18,175.96 14.07,175.86 14.07,175.5 13.92,175.34 13.92,175.31 10.71,172.1 10.71,168.93 9.24,167.46 9.24,162.53 6.19,159.48 6.19,152.91 5.21,151.93 5.21,144.69 6.45,143.44 6.45,137.35 7.3,136.5 7.3,114.66 5.97,113.32 5.97,99.15 6.77,98.35 6.77,93.65 5.1,91.97 5.1,82.1 8.32,78.88 9.33,78.88 12.64,75.57 12.64,71.75 13.38,71.02 13.38,68.48 10.07,65.17 10.07,63.92 3.63,57.47 3.63,55.06 5.93,52.76 10.54,52.76 11.14,52.15 11.14,46.61 18.69,39.07 18.69,21.82 20.08,20.42 28.92,20.42 35.84,13.5 50.07,13.5 51.4,12.16 57.94,12.16 58.26,11.85 v1(58.26,8.23)
  BOTTOM w0.127: LEDB10.C2 58.17,8.14 v1(58.26,8.23) 58.64,8.61 v2(59.34,8.61)
PSU2_SCL: length 185.8
  TOP w0.127: RB690.1 172.43,245.91 v1(172.49,245.97) ; CONN5.18 v1(9.3,238.16)
  S7 w0.127: v1(9.3,238.16) 23.14,252 78.91,252 87.46,243.46 103.31,243.46 111.56,251.71 136.47,251.71 136.76,252 156.68,252 158.02,250.67 165.51,250.67 166.4,251.56 170.27,251.56 173.13,248.7 173.13,246.61 v1(172.49,245.97)
  BOTTOM w0.127: v1(172.49,245.97) 173.57,245.97 v2(173.64,245.91)
PSU2_SCL_R: length 7.7
  TOP w0.127: UB16.9 168.86,244.69 v1(169.89,245.72) 170.08,245.91 RB690.2 170.83,245.59 170.84,245.59 171.1,245.34 172.74,245.34 RB691.2
  BOTTOM w0.127: v2(169.89,246.92) v1(169.89,245.72)
PSU2_SDA: length 188.2
  TOP w0.127: RB699.1 v1(172.49,244.83) ; CONN5.20 v1(9.3,239.43)
  S7 w0.127: v1(172.49,244.83) 173.76,246.1 173.76,248.8 170.13,252.44 163.69,252.44 163.14,252.99 111.09,252.99 102.07,243.97 87.77,243.97 78.75,252.99 22.86,252.99 v1(9.3,239.43)
  BOTTOM w0.127: v2(173.57,243.75) v1(172.49,244.83)
PSU2_SDA_R: length 8.1
  TOP w0.127: RB700.2 172.8,244.32 170.97,244.32 170.83,244.46 RB699.2 v1(169.76,244.83) 168.97,244.04 UB16.8
  BOTTOM w0.127: v2(171.42,245.27) 170.97,244.83 v1(169.76,244.83)
PSU_MONITOR_RESET_N: length 92.2
  TOP w0.127: UB16.3 167.12,240.79 166.74,240.41 166.74,238.39 v1(168.24,236.89) ; P1.C22 v1(96.29,231.46)
  S9 w0.127: v1(96.29,231.46) 96.29,233 95.2,234.09 95.2,235.38 96.62,236.8 97,236.8 97.61,237.41 97.61,239.26 100.82,242.48 100.82,242.48 101.27,242.92 121.69,242.92 122.2,243.43 138.94,243.43 140.02,242.35 144.24,242.35 144.24,242.35 144.74,242.35 144.74,242.35 145.51,242.35 149.13,238.73 153.81,238.73 154.23,238.73 155.43,237.53 165.36,237.53 165.71,237.87 167.26,237.87 v1(168.24,236.89)
  BOTTOM w0.127: v1(168.24,236.89) 168.24,236.32 v2(168.65,235.91)
PSU_MONITOR_SCL: length 13.5
  TOP w0.127: R245.1 v1(157.14,235.73) 159,237.59 162.91,237.59 163.58,238.26 163.58,240.46 163.25,240.79 UB16.22
  BOTTOM w0.127: v2(157.13,237.21) 157.13,235.75 v1(157.14,235.73)
PSU_MONITOR_SCL_R: length 9.2
  TOP w0.127: R245.2 v1(157.14,233.02) R246.2 157.41,232.29 157.7,232 157.7,229.46 156.25,228.01 U10.7
  BOTTOM w0.127: v2(157.57,233.91) 157.14,233.48 v1(157.14,233.02)
PSU_MONITOR_SDA: length 8
  TOP w0.127: v1(158.44,235.7) 158.41,235.67 R227.1 ; RB731.2 v1(157.51,240.51)
  S5 w0.127: v1(158.44,235.7) 158.44,237.04 157.51,237.97 v1(157.51,240.51)
  BOTTOM w0.127: v1(158.44,235.7) 158.44,236.13 v2(158.94,236.62)
PSU_MONITOR_SDA_R: length 10
  TOP w0.127: U10.6 156.9,227.52 158.97,229.59 158.97,232.08 158.82,232.23 158.48,232.23 R228.2 v1(158.41,233.14) R227.2
  BOTTOM w0.127: v2(158.65,231.62) 158.65,232.91 v1(158.41,233.14)
PUC5_I2C_ADD_0: length 17.7
  TOP w0.127: v4(24.7,123.65) U40.AF33 ; R584.1 14.26,125.33 16.64,125.33 16.8,125.49 R585.2 17.51,125.83 v1(17.54,125.8)
  S7 w0.127: v1(17.54,125.8) 18.2,125.8 19.81,124.18 24.16,124.18 v4(24.7,123.65)
  BOTTOM w0.127: 16.23,128.98 17.07,128.14 17.07,126.27
  BOTTOM w0.13: 16.23,128.98 16.23,129.79 v2(16.21,129.82) ; v1(17.54,125.8) 17.07,126.27
PUC6_I2C_ADD_1: length 26.1
  TOP w0.127: R658.1 14.26,118.21 15.71,118.21 15.89,118.39 R659.2 15.06,118.72 v1(15.03,118.69) ; v4(25.7,122.65) U40.AE32
  BOTTOM w0.127: 20.2,115.88 19.92,115.61 18.89,115.61 18.61,115.88 18.02,115.88 17.05,114.91 17.05,114.27 v2(16.73,113.95) 15.71,114.97 15.71,115.48
  BOTTOM w0.13: v1(15.03,118.69) 15.71,118 15.71,115.48 ; 20.2,115.88 20.2,118.7 20.74,119.25 24.86,119.25 25.26,119.65 25.26,122.21 v4(25.7,122.65)
PUC_00: length 10.3
  TOP w0.127: R632.2 17.5,121.77 v1(17.53,121.73) 19.07,121.73 20.27,122.93 20.49,123.15 U40.AF37
  TOP w0.13: R631.1 14.26,122.27 16.61,122.27 16.8,122.07 R632.2
  BOTTOM w0.127: v1(17.53,121.73) 16.75,120.95 v2(16.15,120.95)
PUC_01: length 21
  TOP w0.127: U40.AG37 21.2,124.41 17.74,127.87 16.81,127.87 R564.2 16.8,127.52 16.64,127.36 14.96,127.36 v1(14.49,127.83) 14.46,127.86 R563.1
  BOTTOM w0.127: v1(14.49,127.83) 14.44,127.88 14.44,132.23 14.72,132.51 15.39,132.51 15.9,133.02 15.9,136.39 16.14,136.64 16.14,136.64 v2(17.07,137.57)
PUC_02: length 21.3
  TOP w0.127: R575.1 14.26,126.34 16.64,126.34 16.8,126.51 R576.2 17.29,126.85 v1(17.54,127.09) ; v4(25.7,123.65) U40.AF32
  S7 w0.127: v1(17.54,127.09) 19.84,124.79 21.12,124.79 21.46,125.12 24.9,125.12 25.15,124.88 25.15,124.2 v4(25.7,123.65)
  BOTTOM w0.127: v2(16.32,132.38) 16.32,130.62 16.94,130 16.94,128.68 17.54,128.08 v1(17.54,127.09)
PUC_03: length 18.3
  TOP w0.127: v4(25.7,124.65) U40.AG32 ; v1(17.54,124.78) 17.51,124.81 R596.2 16.8,124.47 16.64,124.31 14.26,124.31 R595.1
  S12 w0.127: v4(25.7,124.65) 25.38,124.65 24.86,124.12 22.61,124.12 21.55,123.05 20.2,123.05 18.48,124.78 v1(17.54,124.78)
  BOTTOM w0.127: v2(16.37,127.92) 16.79,127.5 16.79,125.53 v1(17.54,124.78)
PUC_04: length 24.8
  TOP w0.127: R617.1 8.12,122.78 v1(8.26,122.64) ; v4(23.7,122.65) U40.AE34
  S7 w0.127: v4(23.7,122.65) 23.48,122.65 22.99,122.15 19.32,122.15 18.21,123.26 8.87,123.26 v1(8.26,122.64)
  BOTTOM w0.127: v2(2.89,121.45) 3.08,121.45 5.4,123.77 7.13,123.77 v1(8.26,122.64)
PUC_07: length 24.2
  TOP w0.127: v1(8.24,120.26) 7.75,120.75 R637.1 ; v4(24.7,121.65) U40.AD33
  S7 w0.127: v1(8.24,120.26) 8.24,120.38 8.87,121.02 9.75,121.02 9.99,121.26 21.89,121.26 22.24,120.9 22.24,120.42 22.52,120.14 23.01,120.14 23.24,120.37 23.24,120.88 23.6,121.24 24.29,121.24 v4(24.7,121.65)
  BOTTOM w0.127: v2(4.86,120.25) 4.85,120.25 5.44,120.84 7.66,120.84 v1(8.24,120.26)
PUC_08: length 24
  TOP w0.127: v4(23.7,123.65) U40.AF34 ; v1(8.26,123.76) 8.22,123.8 R606.1
  S7 w0.127: v4(23.7,123.65) 23.22,123.17 19.34,123.17 18.23,124.27 8.77,124.27 v1(8.26,123.76)
  BOTTOM w0.127: v2(2.7,125.16) 3.72,124.14 7.88,124.14 v1(8.26,123.76)
PUC_09: length 25.1
  TOP w0.127: v4(22.7,123.65) U40.AF35 ; R582.1 7.56,125.83 v1(8.26,126.53)
  S7 w0.127: v1(8.26,126.53) 8.26,126.37 8.77,125.86 10.05,125.86 10.62,125.29 18.06,125.29 19.7,123.65 v4(22.7,123.65)
  BOTTOM w0.127: v2(3.07,130.76) 3.07,130.41 5.05,128.43 5.05,127.85 5.54,127.35 7.43,127.35 v1(8.26,126.53)
PUC_10: length 21.5
  TOP w0.127: R653.2 10.71,120.12 10.82,120.24 13.62,120.24 13.75,120.1 R652.1 13.99,119.73 14.48,120.22 v1(14.57,120.22) ; v4(24.7,122.65) U40.AE33
  BOTTOM w0.127: 15.97,118.55 15.97,118.1 15.97,118.1 15.97,117.74 v2(16.61,117.09) 16.61,117.53 17.16,118.08 19.48,118.08 19.94,118.54 19.94,119
  BOTTOM w0.13: v4(24.7,122.65) 24.27,122.22 24.27,120.55 23.84,120.11 23.49,120.11 22.86,119.48 20.42,119.48 19.94,119 ; v1(14.57,120.22) 14.57,119.95 15.97,118.55
PUC_11: length 28.2
  TOP w0.127: U40.AF36 21.71,123.64 20.11,123.64 19.22,122.75 v1(17.54,122.75) 17.51,122.78 R620.2 16.8,123.13
  TOP w0.13: 16.8,123.13 16.65,123.28 14.26,123.28 R619.1
  BOTTOM w0.127: v1(17.54,122.75) 17,122.21 14.51,122.21 13.81,121.51 13.81,111.92 16.6,109.13 v2(16.6,108.37)
PWR_OK: length 120.8
  TOP w0.127: P1.V7 v4(112.29,215.46)
  S14 w0.127: v1(155.98,148.94) 155.98,149.29 160.52,153.82 160.52,160.31 170.46,170.25 170.46,185.16 162.56,193.07 152.64,193.07 144.97,200.74 142.16,200.74 v1(141.51,201.39)
  S16 w0.127: v4(112.29,215.46) 112.76,214.98 116.61,214.98 118.27,213.33 118.27,212.51 119.47,211.3 120.81,211.3 121.06,211.05 121.06,206.79 121.82,206.03 132.11,206.03 133.06,205.08 138.65,205.08 141.51,202.22 v1(141.51,201.39)
  BOTTOM w0.127: R1500.2 155.48,148.44 v1(155.98,148.94) 156.18,149.13 v2(156.87,149.13) ; v2(140.3,201.33) 141.44,201.33 v1(141.51,201.39)
QSFP1_R: length 0.6
  BOTTOM w0.508: CB1096.1 12.03,43.15
  vias: v2(20.16,47.98)
QSFP2_R: length 1.3
  TOP w0.508: 214.65,82.7 CB920.1 215.36,82.08
  vias: v1(209.77,81.89) v1(210.53,81.89) v1(211.29,81.89) v2(212.31,82.27)
QSFP3_R: length 6.8
  TOP w0.508: CB919.1 201.75,80.39 ; CB919.1 202.54,79.8 203.17,80.43 ; CB919.1 202.34,80.62
  BOTTOM w0.508: v1(203.42,82.9) 204.56,81.76 v2(207.04,81.76)
QSFP_INT_P01: length 274.7
  TOP w0.127: v4(111.15,231.58) 110.79,231.22 P1.U22
  S7 w0.127: v1(68.42,221.27) 69.82,221.27 71.02,222.48 71.02,223.93 74.55,227.46 75.58,227.46 82.73,234.6 85.56,234.6 86.52,233.65 89.12,233.65 90.39,232.38 94.45,232.38 95.98,230.86 110.23,230.86 110.96,231.58 v4(111.15,231.58)
  S14 w0.127: v1(70.7,204.19) 71.5,204.99 73.34,204.99 73.56,205.21 73.56,210.93 70.6,213.89 70.6,219.09 v1(68.42,221.27)
  S16 w0.127: v1(22.83,61.82) 22.42,61.82 19.27,64.97 19.27,73.23 15.59,76.91 15.59,89.32 10.63,94.27 10.63,96.49 9.36,97.76 9.36,112.73 10.89,114.25 10.89,117.51 12.65,119.27 12.65,138.49 16.04,141.88 16.04,150.34 15.54,150.85 15.54,155.09 12.54,158.09 12.54,165.43 14.44,167.34 14.44,172.7 17.49,175.74 17.49,177.9 18.06,178.47 18.06,185.65 18.06,185.86 18.06,185.86 18.06,186.57 31.42,199.92 66.44,199.92 v1(70.7,204.19)
  BOTTOM w0.127: RB1222.1 21.2,59.49 v2(22.1,60.39) 22.83,61.12 v1(22.83,61.82) ; v2(67.4,220.63) 67.78,220.63 v1(68.42,221.27)
QSFP_INT_P01_R: length 13.9
  TOP w0.127: v1(13.15,56.64) 12.84,56.33 U69.28
  BOTTOM w0.127: v1(13.15,56.64) 14.21,55.57 19.96,55.57 20.5,56.12 20.5,57.25 20.2,57.55 RB1223.2 21.19,58.41 RB1222.2 21.2,57.38 v2(21.2,57.38)
QSFP_INT_P02: length 352.1
  TOP w0.127: P1.C20 v4(96.29,229.46)
  S5 w0.127: v1(171.65,213.69) 174.04,211.3 205.81,211.3 220.12,196.98 220.12,161.84 217.9,159.61 217.9,146.4 215.8,144.31 215.8,136.99 215.48,136.66 215.48,120.27 211.48,116.27 207.19,116.27 206.29,115.37 206.29,111.08 202.11,106.91 199.42,106.91 195.29,102.78 195.29,91.14 193.97,89.82 193.97,85.05 199.86,79.16 199.86,73.27 198.65,72.06 198.65,62.14 200.95,59.84 200.95,55.25 201.79,54.41 201.79,51.56 203.11,50.24 203.96,50.24 v1(207.99,46.2)
  S14 w0.127: v1(171.65,213.69) 170.97,214.37 170.97,229.39 169.07,231.29 167.79,231.29 164.81,234.27 164.81,237.1 161.29,240.61 161.29,242.53 157.6,246.21 154.6,246.21 150.81,250 138.93,250 138.33,250.59 136.27,250.59 135.46,249.78 133.86,249.78 133.43,250.22 107.72,250.22 105.2,247.69 102.72,247.69 93.56,238.54 93.56,235.87 93.18,235.49 93.18,234.13 95.7,231.62 95.7,230.05 v4(96.29,229.46)
  BOTTOM w0.127: v2(170.65,214.28) 171.24,213.69 v1(171.65,213.69) ; RB308.1 207.92,46.28 v1(207.99,46.2)
QSFP_INT_P02_R: length 25.2
  S7 w0.127: CONN53_PF.1T28 210.59,65.82 211.28,65.12 211.28,63.02 210.56,62.29 210.56,60.58 208.41,58.43 208.41,57.54 209.2,56.75 209.2,55.33 206.92,53.06 206.92,51.36 v1(209.15,49.14)
  BOTTOM w0.127: v2(209.52,49.95) 209.52,49.5 v1(209.15,49.14) 208.93,48.92 RB309.2 RB308.2
QSFP_INT_P03: length 360.4
  TOP w0.127: P1.C19 v4(96.29,228.46)
  S5 w0.127: v1(209.97,46.1) 209.97,53.71 211.4,55.13 211.4,57.15 210.59,57.95 210.59,58.58 211.48,59.47 211.48,59.92 210.47,60.93 203.61,60.93 201.58,62.96 201.58,73.23 201.89,73.55 201.89,75.46 206.94,80.5 206.94,87.54 203.19,91.29 197.51,91.29 196.48,92.32 196.48,102.5 198.91,104.94 203.91,104.94 205.71,106.73 205.71,108.94 207.64,110.88 207.64,111.69 207.79,111.85 208.61,111.85 216.54,119.78 216.54,136.17 216.82,136.45 216.82,143.42 222.41,149.01 222.41,159.17 221.22,160.35 221.22,197.44 213.13,205.52 213.13,206.92 210.15,209.9 208.75,209.9 205.58,213.08 194.47,213.08 193.7,213.84 179.66,213.84 179.4,214.09 173.37,214.09 168.75,218.71 v1(167.72,218.71)
  S14 w0.127: v4(96.29,228.46) 96.74,228.91 96.74,232.19 94.94,233.99 94.94,236.78 95.33,237.17 95.33,238.25 95.75,238.67 96.12,238.67 103.88,246.43 106.9,246.43 109.09,248.62 109.28,248.69 136.73,248.69 136.87,248.83 147.39,248.83 155.93,240.28 156.82,240.28 157.2,239.9 158.98,239.9 163.58,235.31 163.58,231.57 166.24,228.9 167.16,228.9 169.07,226.99 169.07,220.07 167.73,218.73 167.73,218.71 v1(167.72,218.71)
  BOTTOM w0.127: RB311.1 209.95,46.12 v1(209.97,46.1) ; v1(167.72,218.71) 168.57,218.71 v2(168.75,218.54)
QSFP_INT_P03_R: length 16.2
  S16 w0.127: v1(211.09,48.92) 210.09,49.92 210.09,53.82 211.36,55.09 211.36,57.03 210.59,57.8 CONN53_PF.1B28
  BOTTOM w0.127: RB311.2 RB312.2 210.96,48.79 v1(211.09,48.92) 211.09,49.68 211.37,49.96 v2(212.69,49.96)
QSFP_MODE_P01: length 269
  TOP w0.127: v1(11.66,57.29) 11.09,57.29 10.44,56.64 U69.31 ; P1.T19 v4(110.29,228.46)
  S7 w0.127: v1(11.66,57.29) 11.66,64.06 14.95,67.35 14.95,75.29 16.91,77.25 16.91,87.61 12.22,92.3 12.22,95.05 8.62,98.65 7.46,98.65 2.82,103.29 2.82,126.43 2.4,126.85 2.4,170.54 11.83,179.97 11.83,185.21 31.52,204.9 37.05,204.9 39.16,207.01 47.91,207.01 60.58,219.68 68.59,219.68 71.59,222.69 71.59,223.52 75.01,226.94 75.43,226.94 81.59,233.11 89.05,233.11 90.17,231.99 93.78,231.99 95.83,229.94 102.68,229.94 103.62,229 109.74,229 v4(110.29,228.46)
  BOTTOM w0.127: v1(11.66,57.29) 11.45,57.5 11.45,60.35 v2(12.09,61)
QSFP_MODE_P02: length 293
  TOP w0.127: P1.R20 v4(109.29,229.46)
  S5 w0.127: v1(151.3,219.45) 152.93,221.08 167.92,221.08 174.02,214.98 180.18,214.98 180.56,214.6 194.97,214.6 195.61,213.97 205.63,213.97 209.03,210.56 210.38,210.56 214.15,206.79 214.15,205.44 221.88,197.71 221.88,173.15 225.01,170.03 225.01,161.57 225.24,161.34 225.24,159.21 223.74,157.71 223.74,147.23 221.01,144.5 218.76,144.5 217.37,143.11 217.37,136.07 217.2,135.9 217.2,119.25 210.09,112.14 210.09,109.76 204.56,104.24 199.21,104.24 197.14,102.17 197.14,93.06 198.02,92.17 203.24,92.17 207.68,87.73 207.68,79.22 205.82,77.36 205.82,72.46 206.65,71.62 206.65,69.04 CONN53_PF.1T31
  S14 w0.127: v1(151.3,219.45) 148.24,219.45 143.79,223.9 141.77,223.9 139.73,225.95 139.73,227.8 134.19,233.33 125.63,233.33 124.43,234.54 120.74,234.54 120.49,234.29 117.57,234.29 114.33,231.05 110.88,231.05 v4(109.29,229.46)
  BOTTOM w0.127: v2(150.27,217.65) 150.27,218.42 v1(151.3,219.45)
QSFP_MODE_P03: length 309.4
  TOP w0.127: P1.P22 v4(108.29,231.46)
  S5 w0.127: CONN53_PF.1B31 207.14,60.55 203.57,60.55 201.32,62.8 201.32,73.5 201.58,73.76 201.58,75.81 206.62,80.85 206.62,87.41 203.25,90.78 197.32,90.78 196.16,91.94 196.16,102.63 198.78,105.26 203.81,105.26 205.32,106.76 205.32,109.01 207.22,110.91 207.22,114.52 208.05,115.35 211.66,115.35 216.22,119.91 216.22,136.31 216.5,136.58 216.5,143.86 221.77,149.13 221.77,158.79 220.9,159.66 220.9,197.31 205.45,212.76 194.02,212.76 193.32,213.46 179.23,213.46 179.04,213.65 173.15,213.65 169.92,216.89 168.35,216.89 166.69,218.54 158.58,218.54 v1(157.57,219.56)
  S14 w0.127: v1(157.57,219.56) 147.55,229.58 147.55,235.99 145.19,238.35 123.18,238.35 121.08,240.45 115.73,240.45 113.76,238.48 113.76,237.25 110.84,234.33 110.84,234.01 v4(108.29,231.46)
  BOTTOM w0.127: v2(156.94,220.32) 157.57,219.68 v1(157.57,219.56)
QSFP_P01_SCL: length 173.4
  TOP w0.127: U69.11 13.24,49.49 14.81,47.91 16.67,47.91 v1(16.73,47.98)
  S14 w0.127: v1(158.91,18.2) 157.18,19.94 68.14,19.94 60.19,27.89 38.55,27.89 37.13,29.31 21.35,29.31 16.73,33.93 v1(16.73,47.98)
  BOTTOM w0.127: v2(158.91,19.72) 158.91,18.21 v1(158.91,18.2) RB655.1 ; RB1224.1 16.75,48 v1(16.73,47.98)
QSFP_P01_SCL_R: length 14.1
  BOTTOM w0.127: UB17.11 172.41,16.56 170.18,18.79 165.4,18.79 v2(164.87,18.26) 164.82,18.2 RB656.2 163.22,17.95 162.97,17.69 161.18,17.69 RB655.2
QSFP_P01_SDA: length 174.9
  TOP w0.127: U69.12 14.04,51.83 13.81,51.6 13.81,50.01 15.18,48.64 16.25,48.64 16.67,49.06 v1(16.73,49.06)
  S14 w0.127: v1(16.73,49.06) 18.3,47.48 18.3,33.6 21.86,30.05 41.16,30.05 42.18,29.03 60.72,29.03 69.27,20.48 157.66,20.48 159.55,18.59 159.55,17.57 v1(159.05,17.07)
  BOTTOM w0.127: RB665.1 159.05,17.06 v1(159.05,17.07) 158.55,17.56 v2(157.76,17.56) ; RB1225.1 16.75,49.04 v1(16.73,49.06)
QSFP_P01_SDA_R: length 15
  BOTTOM w0.127: UB17.10 172.27,15.91 169.94,18.23 169.03,18.23 167.3,16.51 v2(166.66,16.51) 166.11,17.06 RB666.2 163.22,16.79 162.88,16.46 161.28,16.46 RB665.2
QSFP_P02_SCL: length 74.4
  S7 w0.127: v1(204.86,45.41) 204.86,45.29 204.37,44.8 204.37,42.64 207.41,39.6 207.41,29.85 194.14,16.58 193.07,16.58 v1(193.01,16.61)
  S12 w0.127: CONN53_PF.1T11 210.59,61.6 211.74,60.45 217.17,60.45 217.9,59.73 217.9,57.52 216.94,56.56 212.64,56.56 210.25,54.18 210.25,49.15 208.4,47.29 206.01,47.29 204.86,46.14 v1(204.86,45.41)
  BOTTOM w0.127: RB326.1 204.97,45.3 v1(204.86,45.41) ; RB703.1 192.97,16.64 v1(193.01,16.61) 193.67,16.61 v2(194.5,17.45)
QSFP_P02_SCL_R: length 14.7
  BOTTOM w0.127: RB703.2 191.01,16.14 190.85,15.97 189.21,15.97 188.72,16.46 RB697.2 188.59,16.64 v2(186.72,18.51) 182.53,18.51 180.57,16.56 UB17.14
QSFP_P02_SDA: length 77
  S7 w0.127: v1(205.98,45.34) 205.78,45.34 205.07,46.05 204.51,46.05 203.8,45.34 203.8,42.26 206.85,39.21 206.85,30.3 194.78,18.23 v1(193.1,18.23)
  S12 w0.127: v1(205.98,45.34) 206.39,44.93 214.57,44.93 216.22,46.58 216.22,53.03 220.25,57.06 220.25,58.9 218.14,61.01 212.49,61.01 CONN53_PF.1T12
  BOTTOM w0.127: v2(194.61,19.73) v1(193.1,18.23) RB679.1 ; RB327.1 v1(205.98,45.34)
QSFP_P02_SDA_R: length 14.8
  BOTTOM w0.127: RB679.2 191.14,17.72 190.91,17.5 189.2,17.5 188.85,17.85 RB689.2 188.46,18.23 187.35,19.34 182.21,19.34 182,19.13 v2(182,19.12) 181.99,19.12 180.08,17.21 UB17.13
QSFP_P03_SCL: length 64.1
  S7 w0.127: v1(192.75,13.8) 193.84,13.8 194.95,14.91 201.03,14.91 203.23,17.12 203.23,23.19 205.69,25.65 208.02,25.65 209.36,27 209.36,38.02 216.55,45.21 216.55,46.91 214.52,48.94 v1(213.99,48.94)
  BOTTOM w0.127: RB330.1 214.01,48.92 v1(213.99,48.94) 213.99,51.69 212.41,53.26 210.8,53.26 210.59,53.47 CONN53_PF.1B11 ; RB1242.1 192.71,13.85 v1(192.75,13.8) 193.02,13.8 v2(193.92,12.9)
QSFP_P03_SCL_R: length 13.5
  BOTTOM w0.127: RB1242.2 191.01,13.58 190.67,13.24 189.15,13.24 188.72,13.67 RB1244.2 186.5,13.85 v2(186.46,13.88) 181.23,13.88 179.85,15.26 UB17.16
QSFP_P03_SDA: length 55.8
  S7 w0.127: v1(193.26,15.15) 193.87,15.15 208.18,29.46 208.18,37.9 215.79,45.51 215.79,46.89 215.02,47.66 213.16,47.66 v1(211.95,48.87)
  S12 w0.127: v1(211.95,48.87) 213.05,49.96 213.05,52.45 CONN53_PF.1B12
  BOTTOM w0.127: RB1243.1 193.23,15.18 v1(193.26,15.15) 193.32,15.21 v2(194.4,15.21) ; RB331.1 211.98,48.84 v1(211.95,48.87)
QSFP_P03_SDA_R: length 13.5
  BOTTOM w0.127: RB1243.2 191.01,14.8 190.84,14.63 188.97,14.63 188.72,14.87 RB1245.2 188.21,15.18 187.99,14.96 v2(182.53,14.96) 181.19,14.96 180.25,15.91 UB17.15
QSFP_PRSNT_P01: length 258.2
  TOP w0.127: U69.27 13.64,57.12 v1(13.35,57.4) ; P1.A20 v4(94.29,229.46)
  S7 w0.127: v4(94.29,229.46) 94.29,229.66 92.39,231.56 89.94,231.56 88.9,232.6 86.55,232.6 86.36,232.41 83.49,232.41 83.17,232.1 82.34,232.1 82.2,232.23 81.35,232.23 75.59,226.48 74.91,226.48 71.97,223.54 71.97,222.62 68.27,218.92 62.26,218.92 49.71,206.38 39.41,206.38 37.61,204.57 31.95,204.57 12.32,184.94 12.32,179.95 2.66,170.29 2.66,127.03 3.49,126.2 3.49,103.8 8.25,99.03 9.02,99.03 12.79,95.26 12.79,92.89 17.42,88.27 17.42,76.7 15.97,75.24 15.97,67.33 12.79,64.15 12.79,57.96 v1(13.35,57.4)
  BOTTOM w0.127: v1(13.35,57.4) 13.71,57.05 13.71,56.51 14.26,55.95 19.68,55.95 20,56.28 20,57.09 19.18,57.91 RB1227.1 19.16,58.4 v2(18.05,58.4)
QSFP_PRSNT_P02: length 375.9
  TOP w0.127: P1.B19 v4(95.29,228.46)
  S5 w0.127: CONN53_PF.1T27 211.48,66.21 211.48,68.23 211.04,68.68 209.83,68.68 207.72,70.79 207.72,73.43 208.54,74.24 208.54,74.99 208.05,75.47 208.05,76.62 208.7,77.27 208.7,88.15 203.73,93.13 198.66,93.13 198.09,93.7 198.09,101.68 199.57,103.16 207.29,103.16 210.98,106.84 210.98,111.58 218.09,118.69 218.09,121.19 219.61,122.72 219.61,135.99 220.95,137.32 220.95,140.94 224.95,144.94 224.95,157.58 227.1,159.74 227.1,161.26 227.64,161.8 228.47,161.8 228.76,162.09 228.76,169.03 222.9,174.88 222.9,198.03 214.98,205.96 214.98,207.19 210.5,211.67 210.08,211.67 209.27,211.67 205.25,215.68 199.04,215.68 198.09,216.63 193.96,216.63 192.31,218.29 178.74,218.29 178.29,217.84 175.16,217.84 v1(174.65,218.35)
  S14 w0.127: v1(174.65,218.35) 174.78,218.48 174.78,232.46 174.31,232.93 174.31,234.16 169.81,238.67 168.3,238.67 165.7,241.27 165.7,242.8 160.11,248.38 155.37,248.38 151.5,252.25 135.99,252.25 135.16,253.08 134.15,253.08 133.41,252.35 104.98,252.35 91.18,238.55 91.18,236.79 90.07,235.68 90.07,233 90.88,232.19 92.26,232.19 94.79,229.66 94.79,229.04 95.29,228.54 v4(95.29,228.46)
  BOTTOM w0.127: CONN53_PF.1T27 211.84,65.66 211.84,63.63 210.57,62.36 210.57,61.34 211.46,60.45 217.3,60.45 217.81,59.94 217.81,54.62 217.09,53.91 217.09,51.97 215.03,49.91 RB310.1 ; v2(173.89,217.59) v1(174.65,218.35)
QSFP_PRSNT_P03: length 318.1
  TOP w0.127: P1.V22 v4(112.29,231.46)
  S5 w0.127: CONN53_PF.1B27 211.39,58.87 211.86,59.34 211.86,60.11 210.69,61.28 210.69,62.4 211.53,63.25 211.53,63.97 210.51,65 209.07,65 208.18,65.89 208.18,66.39 209.07,67.28 209.07,68.49 208.63,68.93 208.61,68.93 207.21,70.33 207.21,70.35 207.13,70.43 207.13,78.05 208.12,79.04 208.12,87.91 203.54,92.49 198.15,92.49 197.58,93.06 197.58,101.99 199.51,103.92 207.29,103.92 210.47,107.1 210.47,111.89 217.58,119.01 217.58,135.66 218.66,136.73 218.66,139.35 218.02,139.99 218.02,143.04 218.91,143.93 220.88,143.93 224.31,147.36 224.31,157.71 225.87,159.27 225.87,161.52 226.1,161.75 226.1,163 226.03,163.08 226.03,171.04 222.32,174.75 222.32,197.9 214.47,205.75 214.47,206.98 210.29,211.16 209.06,211.16 205.87,214.35 195.74,214.35 195.1,214.98 193.32,214.98 191.91,216.4 180.43,216.4 180.11,216.08 173.56,216.08 168.2,221.43 145.25,221.43 142.15,224.54 v1(142.14,224.54)
  S7 w0.127: CONN53_PF.1B27 211.39,55.25 210.34,54.2 210.34,50.21 210.71,49.84 212.64,49.84 213,49.48 v1(213,48.92)
  S14 w0.127: v1(142.14,224.54) 142.14,224.54 140.18,226.5 140.18,228.12 134.46,233.84 125.7,233.84 124.68,234.86 121.38,234.86 120.2,236.03 115.06,236.03 114.01,234.99 114.01,233.18 v4(112.29,231.46)
  BOTTOM w0.127: v1(142.14,224.54) 142.16,224.51 144.22,224.51 v2(144.25,224.54) ; RB313.1 v1(213,48.92)
QSFP_RST_P01_N: length 279.6
  TOP w0.127: U69.9 11.64,49.9 8.65,46.91 6.85,46.91 v1(6.8,46.96) ; P1.A22 93.83,231.92 93.83,233.26 92.8,234.29 v1(92.48,234.29) 92.23,234.29 90.87,235.65 RB1228.1
  S7 w0.127: v1(92.48,234.29) 91.85,234.29 90.64,235.49 82.45,235.49 v1(76.93,229.97)
  S16 w0.127: v1(76.93,229.97) 76.93,227.03 71.51,221.61 71.51,220.15 65.23,213.87 64.13,213.87 62.99,215.01 52.7,215.01 49.15,218.57 38.23,218.57 34.41,214.75 34.41,209.43 32.83,207.85 28.38,207.85 10.3,189.77 10.3,177.74 2.33,169.77 2.33,161.26 1.91,160.84 1.91,142.92 2.33,142.5 2.33,60.95 2.12,60.74 2.12,54 3.88,52.25 3.88,49.88 v1(6.8,46.96)
  BOTTOM w0.127: v1(92.48,234.29) 92.1,234.29 91.38,235.01 89.68,235.01 v2(89.06,235.64)
QSFP_RST_P02_N: length 355.9
  TOP w0.127: P1.D22 v4(97.29,231.46)
  S5 w0.127: v1(167.16,219.27) 167.16,219.27 167.16,219.36 167.18,219.34 168.96,219.34 173.7,214.6 179.67,214.6 180.05,214.22 194.28,214.22 194.91,213.59 205.61,213.59 208.96,210.24 210.32,210.24 213.71,206.86 213.71,205.49 221.6,197.6 221.6,169.69 222.47,168.82 222.47,161.39 223.1,160.75 223.1,149.2 217.07,143.16 217.07,136.17 216.92,136.02 216.92,119.37 209.71,112.15 209.71,109.89 204.44,104.62 199.19,104.62 196.86,102.29 196.86,92.7 197.89,91.67 203.35,91.67 207.32,87.7 207.32,80.34 202.19,75.21 202.19,73.38 201.83,73.02 201.83,66.52 203.36,65 208.56,65 208.99,64.57 CONN53_PF.1T9
  S14 w0.127: v4(97.29,231.46) 97.29,232.09 95.24,234.13 95.24,235.32 96.32,236.4 96.93,236.4 97.62,237.09 97.62,238.63 97.62,239.37 104.27,246.02 107.21,246.02 109.63,248.44 136.84,248.44 136.98,248.57 146.14,248.57 154.97,239.75 156.49,239.75 157.99,238.25 159.73,238.25 162.62,235.36 162.62,235.36 162.76,235.22 162.76,230.23 166.95,226.03 167.52,226.03 168.62,224.93 168.62,220.74 v1(167.16,219.27)
  S16 w0.127: v1(207.46,45.59) 207.46,49.68 209.61,51.83 209.61,52.39 208.34,53.66 208.34,54.68 208.88,55.22 208.88,56.46 208.3,57.04 208.3,58.27 208.99,58.95 CONN53_PF.1T9
  BOTTOM w0.127: v2(166.05,219.15) 166.17,219.27 v1(167.16,219.27) ; v1(207.46,45.59) 207.97,45.08 RB323.1
QSFP_RST_P03_N: length 313.1
  TOP w0.127: v4(108.98,231.54) 108.98,231.15 P1.R22
  S5 w0.127: v1(152.05,219.15) 155.06,219.15 156.94,217.27 159.35,217.27 159.79,217.71 166.68,217.71 168.18,216.22 169.94,216.22 173.67,212.49 180.38,212.49 181.32,211.55 206.11,211.55 220.52,197.15 220.52,159.02 221.14,158.4 221.14,148.94 216.18,143.99 216.18,136.81 215.84,136.46 215.84,120.07 211.63,115.86 207.42,115.86 206.66,115.1 206.66,110.89 202.35,106.58 199.66,106.58 195.74,102.65 195.74,91.13 194.39,89.79 194.39,85.01 200.31,79.09 200.31,73.15 199.05,71.89 199.05,62.25 201.31,59.99 201.31,57.69 202.66,56.35 208.51,56.35 208.99,55.88 CONN53_PF.1B9
  S14 w0.127: v1(152.05,219.15) 152.05,219.6 151.3,220.35 148.01,220.35 141.91,226.44 141.91,227.99 138.78,231.12 138.78,232.13 137.51,233.4 136.55,233.4 135.03,234.92 125.5,234.92 125.12,235.3 121.76,235.3 120.37,236.7 113.84,236.7 111.57,234.43 111.57,234.13 v4(108.98,231.54)
  BOTTOM w0.127: RB328.1 205.88,48.64 205.26,49.27 v2(205.26,49.82) 205.86,50.42 208.53,50.42 209.58,51.46 209.58,53.52 CONN53_PF.1B9 ; v2(152.87,220) 152.87,219.97 v1(152.05,219.15)
QSFP_SEL_P01: length 7.3
  TOP w0.127: U69.8 10.84,49.82 9.75,48.74 v1(9.3,48.74)
  BOTTOM w0.127: v2(7.78,48.8) 9.24,48.8 v1(9.3,48.74) 9.18,48.62 RB1226.1
QSFP_SEL_P02: length 25.2
  S7 w0.127: CONN53_PF.1T8 208.19,61.78 209.32,60.64 209.32,59.73 208.14,58.54 208.14,57.35 208.94,56.55 208.94,55.46 206.66,53.17 206.66,50.99 208.05,49.59 208.05,48.35 v1(205.98,46.28)
  BOTTOM w0.127: v2(203.8,46.33) 205.93,46.33 v1(205.98,46.28) 206.98,45.29 RB332.1
QSFP_SEL_P03: length 9
  S12 w0.127: v1(206.98,48.79) 206.98,53.06 208.19,54.27 CONN53_PF.1B8
  BOTTOM w0.127: v2(207.16,49.68) 207.16,48.98 v1(206.98,48.79) 206.9,48.71 RB329.1
QSP01_P02_A0: length 8.5
  TOP w0.127: UB16.1 169.01,239.49 169.19,239.3 v1(169.26,239.3) 169.26,239.24 170.2,238.29 RB728.1 170.84,238.25 170.84,237.84 170.97,237.72 172.88,237.72 173.31,238.15 RB729.2
  BOTTOM w0.127: v2(167.73,240.23) 168.33,240.23 v1(169.26,239.3)
QSP01_P02_A1: length 9.2
  TOP w0.127: UB16.2 168.02,240.13 169.38,240.13 v1(170.15,239.37) RB739.1 170.83,239 170.97,238.86 172.13,238.86 172.25,238.74 172.76,238.74 173.31,239.29 RB740.2
  BOTTOM w0.127: v1(170.15,239.37) 168.81,238.03 v2(167.92,238.03)
QSP01_P02_A2: length 5.2
  TOP w0.127: RB741.1 RB730.2 159.26,241.44 v1(160.62,241.44) UB16.21
  BOTTOM w0.127: v1(160.62,241.44) 160.77,241.59 v2(161.64,241.59)
QSP01_P02_R_SDA: length 4
  TOP w0.127: UB16.23 v1(160.75,240.14) 160.37,240.51 RB731.1
  BOTTOM w0.127: v1(160.75,240.14) 161.26,239.63 161.26,239.54 v2(161.27,239.54)
RESCAL0: length 21.9
  TOP w0.254: U40.N27 v4(30.7,109.65)
  BOTTOM w0.127: v4(30.7,109.65) 30.33,110.01 29.09,110.01 28.17,109.09 28.17,107.29 27.99,107.11 26.47,107.11 26.16,106.81 26.16,94.01 v2(25.78,93.62)
  BOTTOM w0.381: v4(30.7,109.65) 31.21,109.13 RB208.2
RESCAL1: length 14.8
  TOP w0.381: U40.N11 v4(47.7,109.65)
  BOTTOM w0.127: v2(60.71,107.14) 59.74,108.1 50.25,108.1 49.21,109.14 RB207.2
  BOTTOM w0.381: RB207.2 48.2,109.14 v4(47.7,109.65)
RESET_BUTTON_RST: length 396
  TOP w0.127: v1(72.04,204.44) 72.85,203.63 79.14,203.63 80.62,205.11 81.15,205.11 81.68,205.64 RB727.2 CB973.2 83.69,205.64 84.03,205.29 DB7.A ; P1.AA13 v4(115.29,222.46)
  S7 w0.127: v4(115.29,222.46) 114.8,221.97 106.07,221.97 104.61,220.51 93.12,220.51 92.8,220.19 89.94,220.19 88.8,219.05 84.3,219.05 83.19,217.93 83.19,215.58 81.91,214.31 81.91,211.04 v1(80.4,209.53)
  S16 w0.127: v1(106.01,8.42) 104.85,7.26 78.78,7.26 74.9,11.15 61.21,11.15 59.81,12.55 51.72,12.55 50.45,13.82 46.57,13.82 45.56,14.83 36.86,14.83 26.58,25.11 26.58,42.31 23.4,45.5 23.4,62.08 21.12,64.35 21.12,72.59 18.85,74.86 18.85,76.06 15.88,79.03 15.88,89.43 11.45,93.87 11.45,96.19 9.68,97.95 9.68,107.58 12.34,110.24 12.34,115.11 13.49,116.26 13.49,132.49 14,132.99 14,139.06 16.58,141.65 16.58,148.49 17.42,149.32 17.42,154.45 13.05,158.82 13.05,165.07 15.01,167.04 15.01,172.48 18.82,176.29 18.82,185.17 32.41,198.75 67.16,198.75 72.04,203.64 v1(72.04,204.44) 72.57,204.98 73.99,204.98 77.09,208.08 77.13,208.08 78.58,209.53 v1(80.4,209.53)
  BOTTOM w0.127: v1(106.01,8.42) 106.06,8.47 SWB1.1 ; v2(71.66,203.43) 71.66,204.06 v1(72.04,204.44)
RESET_MAC88470: length 184.6
  TOP w0.127: P1.E17 v4(98.29,226.46) ; J2.B54 v1(170.44,146.44)
  S12 w0.127: v1(169.92,208.79) 170.34,208.38 170.34,196 172.05,194.28 172.05,192.77 177,187.82 177,165.5 171.4,159.89 171.4,147.4 v1(170.44,146.44)
  S14 w0.127: v4(98.29,226.46) 98.85,227.02 98.85,232.41 98.58,232.69 98.58,236.21 98.84,236.47 99.81,236.47 100.52,237.18 100.52,238.76 103.75,241.99 106.82,241.99 110.99,246.15 131.7,246.15 132.84,245.01 135.86,245.01 136.27,244.6 145.52,244.6 153.49,236.63 153.49,234.19 153.21,233.91 153.21,229.29 154.86,227.63 159.21,227.63 164.24,222.6 164.24,214.48 v1(169.92,208.79)
  BOTTOM w0.127: v2(171.54,209.27) 170.4,209.27 v1(169.92,208.79) ; R1492.2 169.57,147.31 v1(170.44,146.44)
RJ_STACKING_SYNC_N0: length 20
  S12 w0.108: RJ1.B2 234.44,21.51 234.44,22.01 233.69,22.76 233.69,25.15 232.12,26.72 228.34,26.72 227.93,27.12 227.93,27.67 v3(227.54,28.06)
  BOTTOM w0.095: RB1237.2 226.6,32.2 226.44,32.04 226.44,31.39 226.76,31.07 RB1240.1 226.76,30.58 226.42,30.25 226.42,27.98 227.05,27.35 227.71,27.35 227.93,27.58 227.93,27.67 v3(227.54,28.06)
RJ_STACKING_SYNC_N1: length 19.5
  TOP w0.095: RB1239.2 226.03,32.19 226.19,32.03 226.19,31.4 225.85,31.06 RB1241.2 225.85,30.55 226.19,30.21 226.19,29.99 225.84,29.64 225.29,29.64 224.75,29.1 224.75,28.5 v3(224.39,28.14)
  S12 w0.108: RJ1.B4 232,21.61 232,21.91 231.2,22.71 231.2,22.9 231.2,24.69 230.49,25.4 225.56,25.4 224.78,26.18 224.78,27.75 v3(224.39,28.14)
RJ_STACKING_SYNC_N2: length 21.7
  S9 w0.108: RJ1.B6 229.55,21.7 229.55,21.99 229.47,22.07 228.02,22.07 227.73,21.78 227.73,20.47 226.89,19.63 222.53,19.63 220.88,17.98 220.88,14.06 220.24,13.42 218.64,13.42 v3(218.27,13.06)
  BOTTOM w0.095: v3(218.27,13.06) 218.23,13.09 RB1246.1 216.33,13.09 RB1248.2
RJ_STACKING_SYNC_N3: length 13.8
  S9 w0.108: RJ1.B8 226.63,21.32 226.63,22.06 226.39,22.3 224.25,22.3 222.89,20.93 220.7,20.93 v3(220.3,20.54)
  BOTTOM w0.095: RB1250.2 216.75,21.85 216.95,21.85 217.29,21.51 RB1251.2 217.85,21.51 217.95,21.61 217.95,21.76 218.04,21.85 218.37,21.85 219.29,20.93 219.91,20.93 v3(220.3,20.54)
RJ_STACKING_SYNC_P0: length 20
  S12 w0.108: RJ1.B1 234.31,22.65 234.13,22.65 233.92,22.86 233.92,25.25 232.22,26.95 228.43,26.95 228.16,27.22 228.16,27.67 v3(228.55,28.06)
  BOTTOM w0.095: v3(228.55,28.06) 228.16,27.67 228.16,27.48 227.8,27.12 226.95,27.12 226.2,27.88 226.2,30.21 225.85,30.56 RB1240.2 225.85,31.02 226.21,31.39 226.21,32.03 226.05,32.2 RB1236.2
RJ_STACKING_SYNC_P1: length 19.6
  TOP w0.095: v3(225.4,28.14) 224.98,28.56 224.98,29 225.38,29.41 225.93,29.41 226.42,29.89 226.42,30.23 226.76,30.57 RB1241.1 226.76,31.18 226.42,31.52 226.42,32.04 226.56,32.19 RB1238.2
  S12 w0.108: RJ1.B3 232.6,22.55 232.25,22.2 232.03,22.2 231.43,22.8 231.43,24.79 230.59,25.63 225.65,25.63 225.01,26.27 225.01,27.75 v3(225.4,28.14)
RJ_STACKING_SYNC_P2: length 21.8
  S9 w0.108: v3(218.27,14.07) 218.69,13.65 220.14,13.65 220.65,14.16 220.65,18.08 222.43,19.86 226.79,19.86 227.5,20.56 227.5,21.87 227.93,22.3 229.51,22.3 230.06,22.85 RJ1.B5
  BOTTOM w0.095: v3(218.27,14.07) 218.2,14 RB1246.2 216.44,14 RB1247.2
RJ_STACKING_SYNC_P3: length 13.7
  S9 w0.108: v3(220.3,21.56) 220.7,21.16 222.79,21.16 224.16,22.53 226.57,22.53 RJ1.B7
  BOTTOM w0.095: v3(220.3,21.56) 219.91,21.16 219.38,21.16 218.46,22.08 218.04,22.08 217.95,22.18 217.95,22.33 217.85,22.42 RB1251.1 217.35,22.42 217.01,22.08 216.73,22.08 RB1249.2
RJ_UART_RX: length 233.4
  TOP w0.127: v1(91.77,238.1) 91.89,237.98 R205.2 ; v1(235.68,150.59) 235.78,150.7 RB318.2
  S14 w0.127: v1(235.68,150.59) 234.79,151.48 234.79,158.21 233.39,159.61 219.8,159.61 218.66,160.75 218.66,173.84 217.75,174.74 217.75,204.42 208.61,213.56 195.5,213.56 194.74,214.33 182.61,214.33 182.11,214.82 177.29,214.82 173.76,218.35 173.76,225.27 174.03,225.54 174.03,227.73 173.76,228 173.76,233.91 169.51,238.16 167.35,238.16 157.64,247.88 155.16,247.88 151.35,251.69 139.27,251.69 139.22,251.74 107.55,251.74 104.68,248.87 102.22,248.87 91.77,238.43 v1(91.77,238.1)
  BOTTOM w0.127: v1(91.77,238.1) 91.66,238.21 v2(91.66,239.24)
RLOS_FPGA: length 6.4
  TOP w0.127: P1.AB20 118.35,228.96 v1(118.85,228.46) 118.91,228.51 R414.1
  BOTTOM w0.127: v1(118.85,228.46) 119.91,228.46 v2(119.98,228.38)
RLOS_FPGA_R: length 79.4
  TOP w0.127: R414.2 122.46,228.51 v1(122.46,228.51) ; R333.1 v1(191.56,236.69)
  S9 w0.127: v1(122.46,228.51) 123.73,228.51 127.37,232.16 135.39,232.16 137.66,229.88 144.78,229.88 147.1,227.56 165.26,227.56 166.05,228.35 166.46,228.35 167.41,229.3 168.02,229.3 172.81,234.1 174.91,234.1 v1(175.03,234.22)
  BOTTOM w0.127: v1(191.56,236.69) 190.8,237.45 189.48,237.45 188.32,238.61 v2(187.54,238.61) 182.21,238.61 181.48,237.87 178.68,237.87 v1(175.03,234.22)
RS0_01: length 22.8
  S16 w0.127: v1(35.48,39.36) 34.95,38.83 34.46,38.83 33.45,39.85 33.45,45.55 32.07,46.93 32.07,48.27 32.77,48.96 32.77,49.77 32.02,50.52 32.02,51.16 33.41,52.55 CONN54_PF.1T7
  BOTTOM w0.127: RB416.1 34.96,38.84 v1(35.48,39.36) 35.99,39.87 v2(35.99,40.4) RB340.1
RS0_02: length 16.4
  S16 w0.127: CONN54_PF.1L7 31.01,49.34 31.55,48.81 31.55,46.61 30.42,45.49 30.42,40.18 v1(31.02,39.59)
  BOTTOM w0.127: RB338.1 v1(31.02,39.59) 31.48,39.59 v2(31.95,39.11) 31.95,38.86 31.36,38.26 RB414.1
RS0_03: length 21.6
  S7 w0.127: CONN54_PF.2T7 47.66,52.75 46.19,51.28 46.19,50.7 47.01,49.88 47.01,48.92 46.28,48.19 46.28,47.56 47.92,45.92 47.92,41.39 v1(49.94,39.37)
  BOTTOM w0.127: RB344.1 v2(50.3,40.4) 50.3,39.72 v1(49.94,39.37) 49.29,38.71 RB420.1
RS0_04: length 18.6
  S16 w0.127: CONN54_PF.2L7 45.26,50.68 44.77,50.19 43.04,50.19 42.21,49.35 42.21,48.51 44.82,45.9 44.82,40.89 v1(44.57,40.64)
  BOTTOM w0.127: v1(44.57,40.64) 44.8,40.4 RB342.1 45.48,40.05 v2(46.41,39.11) 46.41,38.86 45.82,38.27 RB418.1
RS0_05: length 23.1
  S12 w0.127: CONN54_PF.3T7 61.91,53.59 62.4,53.11 63.74,53.11 65.65,51.2 65.65,48.74 62.58,45.67 62.58,40.98 v1(64.19,39.37)
  BOTTOM w0.127: RB388.1 63.54,38.71 v1(64.19,39.37) 64.55,39.72 v2(64.55,40.4) RB348.1
RS0_06: length 18.2
  S7 w0.127: CONN54_PF.3L7 58.56,51.6 56.48,49.53 56.48,48.44 59.07,45.84 59.07,40.46 v1(58.97,40.36)
  BOTTOM w0.127: RB386.1 59.82,38.27 v2(60.66,39.11) 60.66,39.91 60.17,40.4 RB346.1 59.02,40.4 v1(58.97,40.36)
RS0_07: length 22.2
  S12 w0.127: CONN54_PF.4T7 77.66,53.11 77.99,53.11 79.57,51.53 79.57,48.41 76.83,45.67 76.83,40.98 v1(78.44,39.37)
  BOTTOM w0.127: RB352.1 v2(78.8,40.4) 78.8,39.72 v1(78.44,39.37) 77.79,38.71 RB392.1
RS0_08: length 18.2
  S7 w0.127: CONN54_PF.4L7 72.81,51.6 70.73,49.53 70.73,48.44 73.32,45.84 73.32,40.46 v1(73.22,40.36)
  BOTTOM w0.127: v1(73.22,40.36) 73.27,40.4 RB350.1 74.52,40.4 74.91,40.01 v2(74.91,39.11) 74.07,38.27 RB390.1
RS0_09: length 22.5
  S12 w0.127: CONN54_PF.5T7 92.24,52.78 92.57,52.78 93.82,51.54 93.82,48.41 91.08,45.67 91.08,44.12 91.41,43.79 91.41,42.97 91.08,42.64 91.08,41.75 92.69,40.14 v1(92.69,39.37)
  BOTTOM w0.127: RB396.1 92.04,38.71 v1(92.69,39.37) 93.05,39.72 v2(93.05,40.4) RB356.1
RS0_10: length 17.9
  S7 w0.127: v1(87.47,40.36) 87.57,40.46 87.57,45.84 84.98,48.44 84.98,49.53 87.06,51.6 CONN54_PF.5L7
  BOTTOM w0.127: v1(87.47,40.36) 87.52,40.4 RB354.1 89.16,39.47 v2(89.16,39.11) 88.32,38.27 RB394.1
RS0_11: length 23.1
  S12 w0.127: CONN54_PF.6T7 104.66,53.59 105.15,53.11 106.49,53.11 108.4,51.2 108.4,48.74 105.33,45.67 105.33,40.98 v1(106.94,39.37)
  BOTTOM w0.127: RB400.1 106.29,38.71 v1(106.94,39.37) 107.3,39.72 v2(107.3,40.4) RB360.1
RS0_12: length 18.4
  S7 w0.127: CONN54_PF.6L7 101.22,51.6 99.81,50.2 99.81,50.11 99.23,49.53 99.23,48.44 101.82,45.84 101.82,40.46 v1(101.72,40.36)
  BOTTOM w0.127: v1(101.72,40.36) 101.77,40.4 RB358.1 102.84,40.4 103.41,39.83 v2(103.41,39.11) 103.41,38.75 102.93,38.27 RB398.1
RS0_13: length 22.7
  S12 w0.127: v1(123.24,39.37) 121.63,40.98 121.63,45.67 124.25,48.29 124.25,51.66 122.8,53.11 121.45,53.11 120.96,53.59 CONN55_PF.1T7
  BOTTOM w0.127: RB424.1 122.59,38.71 v1(123.24,39.37) 123.6,39.72 v2(123.6,40.4) RB364.1
RS0_14: length 17.9
  S7 w0.127: v1(118.02,40.36) 118.12,40.46 118.12,45.87 115.56,48.44 115.56,49.56 117.61,51.6 CONN55_PF.1L7
  BOTTOM w0.127: RB422.1 118.78,38.52 v2(119.64,39.38) 119.64,39.74 118.98,40.4 RB362.1 118.07,40.4 v1(118.02,40.36)
RS0_15: length 22.7
  S12 w0.127: v1(137.49,39.37) 135.88,40.98 135.88,41.95 136.55,42.62 136.55,44.17 135.88,44.85 135.88,45.67 138.5,48.29 138.5,51.66 137.04,53.11 136.71,53.11 CONN55_PF.2T7
  BOTTOM w0.127: RB368.1 v2(137.85,40.4) 137.85,39.72 v1(137.49,39.37) 136.84,38.71 RB428.1
RS0_16: length 18.2
  S7 w0.127: CONN55_PF.2L7 131.86,51.6 129.81,49.56 129.81,48.44 132.37,45.87 132.37,40.46 v1(132.27,40.36)
  BOTTOM w0.127: RB426.1 133.12,38.27 v2(133.96,39.11) 133.96,39.91 133.47,40.4 RB366.1 132.32,40.4 v1(132.27,40.36)
RS0_17: length 22.1
  S14 w0.127: CONN55_PF.3T7 150.96,53.11 151.29,53.11 152.75,51.66 152.75,48.29 150.13,45.67 150.13,40.98 v1(151.74,39.37)
  BOTTOM w0.127: RB432.1 151.09,38.71 v1(151.74,39.37) 152.1,39.72 v2(152.1,40.4) RB372.1
RS0_18: length 18.2
  S7 w0.127: v1(146.52,40.36) 146.62,40.46 146.62,45.87 144.06,48.44 144.06,49.56 146.11,51.6 CONN55_PF.3L7
  BOTTOM w0.127: RB430.1 147.37,38.27 v2(148.21,39.11) 148.21,39.91 147.72,40.4 RB370.1 146.57,40.4 v1(146.52,40.36)
RS0_19: length 22.2
  S14 w0.127: CONN55_PF.4T7 163.71,54.37 165.35,52.73 165.92,52.73 167,51.66 167,48.29 164.38,45.67 164.38,40.98 v1(165.99,39.37)
  BOTTOM w0.127: RB376.1 v2(166.35,40.4) 166.35,39.72 v1(165.99,39.37) 165.34,38.71 RB404.1
RS0_20: length 17.3
  S7 w0.127: CONN55_PF.4L7 160.36,51.6 158.31,49.56 158.31,48.44 160.87,45.87 160.87,40.46 v1(160.77,40.36)
  BOTTOM w0.127: RB374.1 160.82,40.4 v1(160.77,40.36) 160.77,39.33 v2(160.81,39.29) 160.81,38.99 RB402.1
RS0_21: length 22.5
  S14 w0.127: CONN55_PF.5T7 179.46,53.11 179.79,53.11 181.25,51.66 181.25,48.29 178.63,45.67 178.63,44.13 179.04,43.72 179.04,43.12 178.63,42.71 178.63,40.98 v1(180.24,39.37)
  BOTTOM w0.127: RB408.1 179.59,38.71 v1(180.24,39.37) 180.6,39.72 v2(180.6,40.4) RB380.1
RS0_22: length 18.2
  S7 w0.127: v1(175.02,40.36) 175.12,40.46 175.12,45.87 172.56,48.44 172.56,49.56 174.61,51.6 CONN55_PF.5L7
  BOTTOM w0.127: RB406.1 175.87,38.27 v2(176.71,39.11) 176.71,39.94 176.25,40.4 RB378.1 175.07,40.4 v1(175.02,40.36)
RS0_23: length 22.7
  S14 w0.127: CONN55_PF.6T7 192.21,54.6 192.21,53.98 193.09,53.11 194.04,53.11 195.5,51.66 195.5,48.29 192.88,45.67 192.88,43.98 193.2,43.66 193.2,42.71 192.88,42.39 192.88,41.15 194.49,39.53 v1(194.49,39.37)
  BOTTOM w0.127: RB412.1 193.84,38.71 v1(194.49,39.37) 194.85,39.72 v2(194.85,40.4) RB384.1
RS0_24: length 18.2
  S7 w0.127: CONN55_PF.6L7 188.86,51.6 186.81,49.56 186.81,48.44 189.37,45.87 189.37,40.46 v1(189.27,40.36)
  BOTTOM w0.127: RB410.1 190.12,38.27 v2(190.96,39.11) 190.96,39.91 190.47,40.4 RB382.1 189.32,40.4 v1(189.27,40.36)
RS1_01: length 22.2
  S16 w0.127: CONN54_PF.1T9 35,53.89 35,52.05 34.4,51.44 34.4,50.59 35.31,49.68 36.07,49.68 36.7,49.06 36.7,48.36 34.57,46.24 34.57,43.22 33.87,42.51 33.87,40.22 v1(34.72,39.36)
  BOTTOM w0.127: RB415.1 33.62,38.26 v1(34.72,39.36) 34.42,39.66 v2(33.94,39.66) 33.67,39.66 RB339.1
RS1_02: length 23.5
  S14 w0.127: v1(29.24,39.59) 29.24,40.06 23.03,46.27 23.03,48.86 24.05,49.88 27.74,49.88 29.41,51.55 CONN54_PF.1L9
  BOTTOM w0.127: RB337.1 v1(29.24,39.59) 28.87,39.59 v2(28.4,39.11) 28.4,38.55 28.69,38.26 RB413.1
RS1_03: length 22.1
  S9 w0.127: CONN54_PF.2T9 50.92,52.25 50.92,49.87 52.62,48.17 52.62,42.81 v1(49.18,39.37)
  BOTTOM w0.127: RB419.1 48.08,38.27 v1(49.18,39.37) 49.18,39.39 v2(48.28,40.28) 48.26,40.28 48.14,40.4 RB343.1
RS1_04: length 18.2
  S14 w0.127: CONN54_PF.2L9 43.66,51.47 42.21,50.01 42.21,48.49 44.77,45.92 44.77,42.09 43.7,41.02 v1(43.7,39.59)
  BOTTOM w0.127: RB341.1 v1(43.7,39.59) 43.33,39.59 v2(42.86,39.11) 42.86,38.56 43.15,38.27 RB417.1
RS1_05: length 22.2
  S7 w0.127: CONN54_PF.3T9 63.51,52.22 62.92,51.62 62.92,50.56 63.57,49.91 64.07,49.91 64.91,49.07 64.91,48.38 62.32,45.79 62.32,40.48 v1(63.43,39.37)
  BOTTOM w0.127: RB347.1 62.39,40.4 62.52,40.28 v2(62.52,40.28) 62.52,40.27 v1(63.43,39.37) 62.33,38.27 RB387.1
RS1_06: length 17.9
  S7 w0.127: v1(56.99,40.33) 58.74,42.09 58.74,45.79 56.23,48.31 56.23,49.78 57.91,51.47 CONN54_PF.3L9
  BOTTOM w0.127: RB385.1 57.95,38.27 v2(57.11,39.11) 56.99,39.23 v1(56.99,40.33) 57.06,40.4 RB345.1
RS1_07: length 22.1
  S7 w0.127: v1(77.68,39.37) 76.57,40.48 76.57,45.79 79.16,48.38 79.16,49.07 78.32,49.91 77.86,49.91 77.17,50.6 77.17,51.44 77.76,52.03 77.76,53.9 CONN54_PF.4T9
  BOTTOM w0.127: RB351.1 76.12,40.04 v2(76.8,40.04) 77.01,40.04 v1(77.68,39.37) 76.58,38.27 RB391.1
RS1_08: length 17.9
  S7 w0.127: CONN54_PF.4L9 72.16,51.47 70.48,49.78 70.48,48.31 72.99,45.79 72.99,42.09 v1(71.24,40.33)
  BOTTOM w0.127: RB389.1 72.2,38.27 v2(71.36,39.11) 71.24,39.23 v1(71.24,40.33) 71.31,40.4 RB349.1
RS1_09: length 22.9
  S7 w0.127: CONN54_PF.5T9 92.01,53.9 92.01,51.84 91.42,51.25 91.42,50.2 91.71,49.91 92.57,49.91 93.41,49.07 93.41,48.38 90.82,45.79 90.82,44.35 90.26,43.79 90.26,41.04 v1(91.93,39.37)
  BOTTOM w0.127: RB395.1 90.83,38.27 v1(91.93,39.37) 91.57,39.72 90.9,39.72 90.9,39.75 ; 90.9,39.75 90.67,39.75 RB355.1 ; 90.9,39.75 v2(90.96,39.75)
RS1_10: length 17.9
  S7 w0.127: v1(85.49,40.33) 87.24,42.09 87.24,45.79 84.73,48.31 84.73,49.78 86.41,51.47 CONN54_PF.5L9
  BOTTOM w0.127: RB393.1 86.45,38.27 v2(85.61,39.11) 85.49,39.23 v1(85.49,40.33) 85.56,40.4 RB353.1
RS1_11: length 22.2
  S7 w0.127: v1(106.18,39.37) 105.07,40.48 105.07,45.79 107.66,48.38 107.66,49.07 106.82,49.91 106.26,49.91 105.67,50.5 105.67,51.62 106.26,52.22 CONN54_PF.6T9
  BOTTOM w0.127: RB359.1 104.95,40.4 v2(105.27,40.09) 105.46,40.09 v1(106.18,39.37) 105.08,38.27 RB399.1
RS1_12: length 17.9
  S7 w0.127: CONN54_PF.6L9 100.66,51.47 98.98,49.78 98.98,48.31 101.54,45.74 101.54,42.14 v1(99.74,40.33)
  BOTTOM w0.127: RB397.1 100.7,38.27 v2(99.86,39.11) 99.74,39.23 v1(99.74,40.33) 99.81,40.4 RB357.1
RS1_13: length 22.5
  S7 w0.127: v1(122.48,39.37) 121.37,40.48 121.37,45.79 123.96,48.38 123.96,49.07 123.13,49.91 122.26,49.91 121.83,50.34 121.83,51.49 122.56,52.22 CONN55_PF.1T9
  BOTTOM w0.127: RB423.1 121.38,38.27 v1(122.48,39.37) 122.21,39.64 121.64,39.64 v2(121.57,39.7) 120.87,40.4 RB363.1
RS1_14: length 17.9
  S7 w0.127: v1(116.04,40.33) 117.84,42.14 117.84,45.77 115.28,48.33 115.28,49.78 116.96,51.47 CONN55_PF.1L9
  BOTTOM w0.127: RB361.1 116.11,40.4 v1(116.04,40.33) 116.04,39.23 v2(116.16,39.11) 117,38.27 RB421.1
RS1_15: length 22.8
  S7 w0.127: v1(136.73,39.37) 136.73,40.7 135.03,42.4 135.03,43.6 135.62,44.19 135.62,45.79 138.21,48.38 138.21,49.07 137.38,49.91 136.89,49.91 136.08,50.72 136.08,51.49 136.81,52.22 CONN55_PF.2T9
  BOTTOM w0.127: RB427.1 135.63,38.27 v1(136.73,39.37) 135.82,40.27 v2(135.82,40.3) 135.72,40.4 RB367.1
RS1_16: length 18.1
  S7 w0.127: CONN55_PF.2L9 131.21,51.47 129.53,49.78 129.53,48.33 132.09,45.77 132.09,41.8 130.62,40.33 v1(130.29,40.33)
  BOTTOM w0.127: RB365.1 130.36,40.4 v1(130.29,40.33) 130.29,39.23 v2(130.41,39.11) 130.41,39.11 RB425.1
RS1_17: length 22.5
  S7 w0.127: v1(150.98,39.37) 149.87,40.48 149.87,45.79 152.46,48.38 152.46,49.07 151.47,50.06 150.61,50.06 150.33,50.34 150.33,51.49 151.06,52.22 CONN55_PF.3T9
  BOTTOM w0.127: RB371.1 149.89,40.4 v2(150.09,40.2) 150.15,40.2 v1(150.98,39.37) 149.88,38.27 RB431.1
RS1_18: length 17.9
  S7 w0.127: CONN55_PF.3L9 145.46,51.47 143.78,49.78 143.78,48.33 146.34,45.77 146.34,42.14 v1(144.54,40.33)
  BOTTOM w0.127: RB369.1 144.61,40.4 v1(144.54,40.33) 144.54,39.23 v2(144.66,39.11) 144.66,39.11 RB429.1
RS1_19: length 22.3
  S7 w0.127: v1(165.23,39.37) 164.12,40.48 164.12,45.79 166.71,48.38 166.71,49.07 165.88,49.91 165.39,49.91 164.58,50.71 164.58,51.49 165.31,52.22 CONN55_PF.4T9
  BOTTOM w0.127: RB403.1 164.13,38.27 v1(165.23,39.37) 165.23,39.47 v2(164.32,40.39) 164.3,40.4 RB375.1
RS1_20: length 17.9
  S7 w0.127: CONN55_PF.4L9 159.71,51.47 158.03,49.78 158.03,48.33 160.59,45.77 160.59,42.14 v1(158.79,40.33)
  BOTTOM w0.127: RB401.1 159.75,38.27 v2(158.91,39.11) 158.79,39.23 v1(158.79,40.33) 158.86,40.4 RB373.1
