# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
VCC1V0_VSW6_VIN on TOP: 103.7,130.02 101.67,132.05 100.22,132.05 100.12,131.95 100.12,124.56 100.3,124.38 100.3,123.01 100.52,122.78 102.53,122.78 103.7,123.95
VCC1V0_VSW6_VIN on BOTTOM: 103.65,112.19 106.14,114.68 106.14,120.67 105.38,121.43 105.38,128.57 103.98,129.97 102.2,129.97 101.82,129.59 101.82,125.96 100.63,124.76 100.63,119.86 99.93,119.16 99.93,114.43 100.25,114.1 100.25,109.95 100.29,109.91 100.88,109.91 100.95,109.98 101.07,109.86 103.33,109.86 103.65,110.18 ; 1 cut-out
VCC1V0_VSW6_VIN on V3: 104.99,112.49 102.12,112.49 100.55,114.07 100.55,125.12 101.92,126.49 104.28,126.49 106.09,124.69 106.09,113.59
VCC1V2_LL on TOP (solid shape): 116.58,174.44 116.58,172.38 116.83,172.13 120.26,172.13 120.39,172 120.39,170.98 121.15,170.22 121.49,170.22 121.62,170.09 123.56,170.09 123.56,168.95 123.44,168.82 122.65,168.82 122.17,168.82 120.39,167.05 115.44,167.05 115.31,167.17 115.31,174.28 115.54,174.51 116.5,174.51
VCC1V2_LL on BOTTOM (solid shape): 120.87,170.35 120.87,167.63 120.41,167.17 115.66,167.17 115.52,167.31 115.52,170.89 115.74,171.11 120.11,171.11
VCC1V2_VIN on TOP (solid shape): outline of 84 points within 115.05,174.78 118.61,183.56
VCC1V2_VIN on BOTTOM (solid shape): 118.48,183.43 118.48,183.26 118.36,183.26 118.36,181.73 118.48,181.73 118.48,180.96 118.36,180.96 118.36,179.44 118.48,179.44 118.48,179.11 118.36,178.98 117.72,178.98 117.59,178.86 117.59,178.25 117.24,177.89 116.59,177.89 116.5,177.94 116.5,178.04 115.99,178.83 115.6,177.97 115.61,177.92 115.56,177.89 115.46,177.89 115.05,178.3 115.05,183.06 115.56,183.56 118.35,183.56
VCC1V_LL on TOP: 106.26,102.66 106.26,108.68 106.65,109.07 111.6,109.07 112.87,107.8 113.53,107.8 113.99,107.34 113.99,106.45 113.94,106.4 111.73,106.4 111.6,106.27 111.6,102.59 111.57,102.56 106.37,102.56
VCC2V5_LL on TOP (solid shape): 45.7,191.96 45.7,191.2 45.7,191.02 45.8,190.92 47.61,190.92 47.65,190.88 47.65,184.63 45.43,182.41 40.86,182.41 40.24,183.03 40.24,184.19 40.25,184.19 40.25,185.32 40.32,185.38 42.53,185.38 42.65,185.51 42.65,189.19 42.68,189.22 43.8,189.22 44.31,189.73 44.31,191.52 44.46,191.65 44.56,191.83 44.56,191.84 44.81,192.09 45.58,192.09
VCC3V3_PCH_SW on TOP: 162.3,122.78 161.26,122.78 158.97,125.07 154.33,125.07 154.02,124.75 154.02,117.45 154.91,116.56 159.99,116.56 160.43,116.11 160.43,116.06 161.26,115.23 162.83,115.23 162.88,115.29 162.88,122.19
VCC3V3_PCH_VIN on TOP: 172.2,121.51 175.63,121.51 176.01,121.13 176.01,117.38 175.99,117.38 175.86,117.26 170.02,117.26 169.83,117.07 169.83,116.24 169.89,116.17 169.79,116.17 169.53,115.92 169.53,115.44 169.37,115.28 168.7,115.28 168.58,115.16 166.89,115.16 166.23,115.82 166.23,117.6 166.3,117.66 167.01,117.66 168.01,118.66 168.01,122.02 168.3,122.31 171.4,122.31
VCC3V3_PCH_VIN on BOTTOM: 175.54,121.77 168.05,121.77 166.84,120.56 166.84,116.69 167.67,115.86 169.57,115.86 169.83,116.11 169.83,117.07 170.02,117.26 175.86,117.26 175.92,117.32 175.92,121.38
VCC5P0 on TOP: 258.15,174.92 240.34,174.92 239.35,173.93 239.35,170.33 240.08,169.6 245.68,169.6 245.71,169.63 245.9,169.63 246.41,170.14 247.86,170.14 248.15,169.85 252.92,169.85 252.92,169.87 254.38,171.33 258.11,171.33 258.64,171.86 258.64,174.43
VCC5P0 on BOTTOM: 178.84,155.99 176.24,155.99 175.67,155.42 175.67,151.17 176.18,150.66 178.91,150.66 179.23,150.98 179.23,155.61
VCC5P0 on BOTTOM: 221.86,154.59 216.11,154.59 215.74,154.22 215.74,148.46 216.18,148.03 221.81,148.03 222.06,148.28 222.06,149.64 222.37,149.95 222.37,154.08
VCC5P0 on S9: 175.86,156.18 175.86,153.64 181.38,148.12 218.66,148.12 219.42,148.88 219.42,150.72 223.87,155.17 245.84,155.17 249.27,158.6 249.27,170.66 246.6,173.33 239.49,173.33 239.49,173.2 238.47,173.2 231.11,165.83 203.42,165.83 195.29,157.71 177.38,157.71
VCC5P0_VIN on TOP: 259.08,162.78 257.57,162.78 257.42,162.94 255.87,162.94 255.36,162.43 251.35,162.43 251.15,162.23 251.15,161.64 251.33,161.45 255.73,161.45 256.01,161.17 257.74,161.17 257.9,161.01 259.05,161.01 259.13,161.09 259.13,162.74
VCC5V_STBY on TOP: 187.14,147.27 185.33,147.27 185.23,147.17 185.23,143.7 185.52,143.4 187,143.4 187.16,143.57 187.16,147.25
VCC5V_STBY on BOTTOM: 181.87,151.61 182.3,151.19 182.3,148.52 182.94,148.52 183.16,148.31 183.16,145.38 182.93,145.15 182.93,143.67 183.26,143.34 187.04,143.34 189.39,145.69 189.39,153.07 187.52,154.94 182.29,154.94 181.87,154.52
VCC12 on TOP (solid shape): 110.68,117.92 110.68,115.49 108.75,113.55 107.01,113.55 106.8,113.76 106.8,117.79 107.15,118.15 110.46,118.15
VCC12 on TOP (solid shape): 166.21,114.02 166.21,111.16 166.07,111.02 163.55,111.02 163.29,111.29 163.29,114.02 163.41,114.15 166.08,114.15
VCC12 on TOP (solid shape): 154.15,92.33 154.15,91.72 154.21,91.67 154.84,91.67 154.91,91.6 154.91,90.97 154.97,90.9 154.97,90.46 154.84,90.33 154.27,90.33 154.27,89.89 154.02,89.63 152.43,89.63 152.17,89.89 152.17,92.24 152.34,92.4 154.07,92.4
VCC12 on S7 (solid shape): 64.48,235.81 64.48,225.02 63.66,224.19 57.31,224.19 56.55,224.95 56.55,235.88 57.24,236.57 63.72,236.57
VCC12 on S12 (solid shape): 64.48,235.81 64.48,225.02 63.66,224.19 57.31,224.19 56.55,224.95 56.55,235.88 57.24,236.57 63.72,236.57
VCC12 on TOP: 191.48,121.89 191.16,121.57 191.16,118.27 191.54,117.89 199.04,117.89 199.55,118.4 199.55,121.57 199.23,121.89
VCC12 on TOP: 128.01,182.89 126.89,182.89 126.69,182.69 126.69,180.11 127.07,179.73 129.21,179.73 129.51,180.02 129.51,181.39
VCC12 on TOP: 120.16,97.69 120.16,99.53 120.23,99.6 121.4,99.6 121.59,99.41 121.59,97.19 121.45,97.05 120.29,97.05 120.16,97.18 120.17,97.19 120.17,97.68
VCC12 on TOP: 113.69,186.79 111.03,186.79 110.84,186.6 110.84,181.65 111.47,181.01 113.5,181.01 114.01,181.52 114.01,186.47
VCC12 on TOP: 122.81,109.48 122.93,109.36 125.52,109.36 125.96,109.8 125.97,109.8 125.97,113.79 125.64,114.12 123.03,114.12 122.81,113.9
VCC12 on TOP: 30.19,193.65 29.24,193.65 27.21,191.62 27.21,187.42 28.22,186.41 30.51,186.41 30.83,186.73 30.83,193.01
VCC12 on TOP: 63.72,236.57 57.24,236.57 56.55,235.88 56.55,224.95 57.31,224.19 63.66,224.19 64.48,225.02 64.48,235.81
VCC12 on TOP: 173.34,126.08 173.34,123.29 173.01,122.96 168.67,122.96 168.39,123.24 168.39,126.41 169.05,127.07 172.35,127.07
VCC12 on TOP: 159.89,128.4 156.84,128.4 156.46,128.02 156.46,126.24 156.72,125.98 159.26,125.98 159.89,126.62
VCC12 on BOTTOM: 63.77,239.27 57.12,239.27 56.52,238.66 56.52,224.16 57.02,223.65 64.01,223.65 64.52,224.16 64.52,238.52
VCC12 on V3: 36.86,172.95 69.31,172.95 71.72,175.36 113.88,175.36 116.04,173.2 116.04,153.71 118.27,151.48 124.54,151.48 127.09,148.94 127.09,130.34 125.12,128.37 109.57,128.37 107.66,126.46 107.66,118.62 107.09,118.04 107.09,113.61 107.66,113.04 107.66,104.62 111.92,104.62 122.55,93.98 139.89,93.98 147.54,86.33 154.65,86.33 156.24,87.92 156.24,92.11 156.3,92.17 156.3,93.44 160.81,97.95 191.35,97.95 194.47,101.06 194.47,113.51 198.66,117.7 199.29,117.7 200.41,118.82 200.41,123.89 198.66,125.64 198.66,131.93 196.82,133.77 178.5,133.77 175.2,137.06 175.2,162.29 172.45,165.03 161.25,165.03 159.16,167.12 159.16,198.74 156.38,201.52 137.95,201.52 137.92,201.49 126.23,201.49 125.31,202.41 83.4,202.41 80.04,205.78 80.04,221.02 75.59,225.46 67.15,225.46 65.18,227.43 65.18,236.19 64.74,236.64 57.31,236.64 56.54,235.87 56.54,227.62 46.29,217.36 43.15,217.36 37.35,211.57 37.35,201.12 27.59,191.36 27.59,182.22
VCC12 on S9: 119.8,96.77 121.96,96.77 127.55,102.36 127.55,113.66 126.58,114.63 122.72,114.63 119.09,111 119.09,97.48
VCC12V_53315_VIN on TOP: 119.6,104.49 118.01,104.49 117.9,104.61 117.76,104.69 117.75,104.69 116.93,105.51 116.91,105.51 116.78,105.64 115.69,105.64 115.66,105.66 115.66,106.4 115.64,106.42 114.39,106.42 114.35,106.46 114.35,107.63 113.94,108.05 113.94,108.15 114.14,108.35 114.24,108.35 114.27,108.38 114.27,109.19 114.39,109.32 117.57,109.32 118.07,108.81 118.07,108.81 119.6,108.81 119.6,108.81 120.49,108.81 120.49,108.81 122.01,108.81 122.01,108.81 122.24,108.81 122.24,108.79 123.82,108.79 123.92,108.68 123.92,104.49 123.66,104.24 122.34,104.24 122.09,104.49 120.49,104.49 120.23,104.24 119.85,104.24
VCC12V_53315_VIN on BOTTOM: 114.27,108.43 114.27,109.19 114.39,109.32 117.57,109.32 118.08,108.81 123.79,108.81 124.04,108.56 124.04,104.62 123.66,104.24 118.2,104.24 116.93,105.51 115.79,105.51 115.66,105.64 115.66,106.27 115.54,106.4 114.27,106.4 114.14,106.53 114.14,107.54 113.63,108.05 113.63,108.28 113.73,108.38 114.21,108.38
VCC12V_STBY on TOP: 198.14,157.96 195.44,157.96 195.27,157.78 195.27,137.2 190.72,132.65 190.72,124.69 191.04,124.37 194.28,124.37 194.85,124.94 194.85,127.76 196.5,129.41 198.75,129.41 199.84,130.5 199.84,137.41 198.09,139.16 198.09,140.59 198.31,140.82 198.31,142.03 198.19,142.16 198.19,146.2 198.75,146.76 204.97,146.76 206.15,147.94 206.15,152.02 206.02,152.14 201.34,152.14 200.14,150.95 198.36,150.95 198.19,151.13 198.19,157.91
VCC12V_STBY on BOTTOM: 194.99,148.94 195.71,148.22 195.71,137.01 195.98,136.74 195.98,135.68 196.43,135.23 197.64,135.23 197.77,135.35 197.77,144.45 201.45,148.13 206.39,148.13 206.57,148.31 206.57,154.94 207.05,155.42 207.05,157.02 204.99,159.08 196.99,159.08 194.99,157.07
VCC33_GPS on TOP: 211.84,98.75 211.84,97.65 211.92,97.57 214.7,97.57 214.9,97.76 214.9,100.7 214.5,101.1 212.9,101.1 212.55,101.45 212.55,104.37 212.67,104.5 213.82,104.5 213.94,104.62 213.94,105.51 213.82,105.64 211.28,105.64 211.27,105.64 210.92,105.3 210.92,99.66
VCC33_GPS_ANT on TOP: 203.47,99.37 203.47,98.79 203.55,98.71 204.37,98.71 204.56,98.91 205.45,98.91 206.27,99.72 206.27,101.82 206.47,102.02 206.51,102.02 210.76,106.27 210.76,107.28 210.67,107.37 207.44,107.37 204.26,104.19 204.26,99.5 204.14,99.37
VCC_CLKIN_2V5 on BOTTOM: 84.34,222.41 84.34,220.65 84.55,220.45 87.26,220.45 87.36,220.54 87.36,223.79 87.36,223.79 87.36,224.04 87.21,224.18 85.13,224.18 85.11,224.17 85.11,223.18
VCC_CLKIN_2V5 on S16: 108.04,221.84 96.3,221.84 93.76,224.38 85.46,224.38 84.5,223.41 84.5,217.97 86.25,216.21 87.97,216.21 88.81,215.37 91.73,215.37 92.4,216.03 102.3,216.03 103.53,214.79 108.23,214.79 108.49,215.05 108.49,221.4
VCCA_H_GXB_2V5 on BOTTOM: 84.14,208.26 84.14,206.7 85.05,205.78 87.28,205.78 87.34,205.85 87.34,206.28 87.53,206.47 88.52,206.47 88.71,206.66 88.71,208.2 88.58,208.32 84.2,208.32
VCCA_H_GXB_2V5 on S16: 113.54,211.61 113.09,212.06 95.02,212.06 91.7,208.74 89.62,208.74 88.94,208.06 87.29,208.06 86.97,207.73 86.97,204.69 88.03,203.63 106.47,203.63 107.34,204.49 111.44,204.49 113.54,206.59
VCCD_PLL_1V2 on BOTTOM: 88.04,236 88.67,236.64 88.67,239.3 88.29,239.68 85.06,239.68 84.61,239.24 84.61,236.76 85.37,236
VCCD_PLL_1V2 on S5: 102.33,235.62 90.83,235.62 88.8,237.65 84.55,237.65 84.23,237.34 84.23,234.16 90.08,228.31 90.08,228.27 91.38,226.97 102.85,226.97 104.61,225.21 104.61,215.17 103.72,214.28 100.68,214.28 99.91,213.52 99.91,210.73 100.49,210.15 111.59,210.15 111.79,210.35 111.79,212.24 111.57,212.46 111.57,212.51 111.32,212.76 111.15,212.76 110.77,213.14 110.77,213.65 111.17,214.05 112.71,214.05 113.07,214.41 113.07,228.67 113.06,228.68 113.06,231.83 111.79,233.11 104.84,233.11
VCCL_GXB_1V2 on BOTTOM: 110.9,207.11 111.1,207.31 111.1,208.71 111.04,208.77 105.96,208.77 105.82,208.63 105.82,207.49 106.2,207.11
VCCL_GXB_1V2 on S12: 114.46,211.05 113.73,211.78 101.91,211.78 101.82,211.68 101.82,207.57 102.35,207.03 113.66,207.03 114.46,207.83
VDD0P6 on TOP: 68.17,185.98 69.19,185.98 69.42,185.75 69.42,185.3 69.43,185.28 69.43,184.69 69.57,184.56 70.27,184.56 70.29,184.58 70.29,185.17 70.31,185.19 71.1,185.19 71.21,185.07 71.21,183.3 70.82,182.9 70.04,182.9 70.04,183.55 69.92,183.68 69.1,183.68 68.98,183.56 68.98,182.91 68.98,182.9 68.81,182.73 66.09,182.73 66.03,182.8 66.03,184.28 66.33,184.59 67.16,184.59 67.39,184.81 67.39,185.65 67.53,185.79 67.98,185.79
VDD0P6 on S12: 22.32,163.93 22.57,164.18 22.57,165.33 22.19,165.71 21.56,165.71 21.3,165.96 20.67,165.96 19.52,167.1 19.52,172.04 20.79,173.31 33.25,173.31 35.06,171.5 42.48,171.5 44.3,173.31 64.33,173.31 65.22,172.43 65.22,164.31 65.52,164.01 86.63,164.01 87.24,164.61 87.24,166.47 86.73,166.98 82.82,166.98 81.73,168.07 81.73,170.84 82.55,171.66 85.58,171.66 86.38,172.46 98.06,172.46 100.1,174.51 100.1,177.7 97.43,180.38 88.6,180.38 88.54,180.31 83.43,180.31 83.32,180.42 76.82,180.42 72.04,185.2 67.47,185.2 66.96,184.69 66.39,184.69 65.94,184.25 65.94,184.06 65.43,183.55 58.27,183.55 58.17,183.65 35.87,183.65 32.73,180.52 23.21,180.52 22.37,179.68 19.21,179.68 16.61,177.09 16.53,177.09 11.97,172.53 11.97,164.5 12.54,163.93
VDD1P0 on TOP (solid shape): 88.38,93.39 88.38,90.9 88.03,90.55 80.8,90.55 80.42,90.93 80.42,93.13 81.02,93.72 88.05,93.72
VDD1P0 on TOP: 74.51,99.03 73.88,99.67 73.88,108.05 74.32,108.49 84.1,108.49 85.61,110 95.55,110 96.49,109.07 103.22,109.07 104.64,107.64 104.64,100.51 104.49,100.35 99.69,100.35 99.63,100.4 99.63,102.03 100.17,102.56 100.17,104.75 99.79,105.13 96.49,105.13 96.47,105.14 96.07,105.14 95.95,105.26 95.95,107.21 95.65,107.52 92.9,107.52 88.66,103.27 79.62,103.27 78.96,102.61 78.96,99.54 78.45,99.03
VDD1P0 on TOP: 5.15,109.18 5.15,104.92 5.32,104.75 5.91,104.75 5.99,104.82 5.99,105.33 6.09,105.43 8.68,105.43 8.83,105.59 8.83,109.55 8.78,109.6 7.1,109.6 6.9,109.4 6.9,108.71 6.85,108.66 6.01,108.66 5.93,108.73 5.93,109.29 5.87,109.36 5.32,109.36
VDD1P0 on TOP: 101.93,87.06 103.47,85.52 108.5,85.52 110.71,87.73 110.71,92 110.25,92.45 107.86,92.45 107.69,92.28 107.69,91.56 107.41,91.29 102.84,91.29 101.93,90.38
VDD1P0 on BOTTOM: 112.74,93.29 110.15,93.29 110,93.44 109.25,93.44 108.85,93.85 108.85,94.13 108.46,94.52 106.3,94.52 103.88,92.1 103.88,90.42 104.56,89.74 113.07,89.74 113.68,90.35 113.68,92.35
VDD1P0 on BOTTOM: 99.13,99.79 99.69,100.35 99.94,100.35 100.27,100.68 100.27,101.22 100.47,101.42 104.33,101.42 104.61,101.7 104.61,102.59 104.28,102.92 104.28,104.29 104.27,104.3 104.27,105.56 104.69,105.98 104.69,106.02 105.38,106.02 107.79,108.43 107.79,112.62 107.53,112.88 104.61,112.88 104.36,112.62 104.36,110.21 103.72,109.57 100.3,109.57 99.85,109.13 99.85,108.18 99.34,107.67 96.74,107.67 94.99,109.42 86.99,109.42 85.84,108.28 79.77,108.28 79.54,108.51 78.45,108.51 77.61,107.67 77.61,103.86 78.3,103.17 87.9,103.17 91.28,99.79
VDD1P0 on S7: 84.47,108.84 78.4,108.84 76.9,107.34 76.9,93.41 77.82,92.49 88.04,92.49 88.48,92.94 88.48,106.78 86.39,108.87 84.51,108.87
VDD1P0 on S16: 40.73,125.32 30.83,125.32 30.45,124.94 30.45,113.26 34.94,108.76 34.94,102.82 35.53,102.23 98.06,102.23 99.81,100.48 102.53,100.48 104.82,102.77 104.82,107.57 102.68,109.7 75.78,109.7 71.21,114.27 59.02,114.27 58.39,114.91 41.49,114.91 40.61,115.8 40.61,116.91 40.91,117.22 47.64,117.22 48.99,118.56 48.99,124.05 48.35,124.69 41.37,124.69
VDD1P0 on V18: 28.27,119.9 25.75,117.38 7.52,117.38 5.3,115.16 5.3,93.63 29.56,93.63 31.4,95.48 31.4,107.03 32.1,107.73 74.39,107.73 80.55,101.57 80.55,91.16 82.83,88.87 110.39,88.87 110.61,89.09 119.48,89.09 123.81,93.42 123.81,111.05 100.09,134.77 29.63,134.77 28.27,133.4
VDD1P0_ROV on G10 (solid shape): outline of 24638 points within 19.88,94.69 93.36,132.27
VDD1P0_ROV on TOP: 85.98,135.23 86.96,134.25 86.96,132.81 88.73,131.04 88.74,131.04 93.22,126.56 93.22,121.14 84.84,112.75 76.62,112.75 73.45,115.92 73.45,119.91 73.14,120.22 71.34,120.22 71.19,120.37 71.19,121.77 71.39,121.97 75.23,121.97 75.48,121.71 79.37,121.71 79.59,121.49 83.87,121.49 84.58,122.2 84.58,127.04 83.25,128.37 75.58,128.37 75.4,128.55 71.57,128.55 71.36,128.75 71.36,132.61 73.99,135.23
VDD1P0_ROV on BOTTOM: 76.33,135.23 85.98,135.23 86.03,135.18 91.83,135.18 92.93,134.08 92.93,129.31 96.99,125.24 96.99,122.65 96.21,121.87 94.08,121.87 84.97,112.75 77.22,112.75 73.92,116.06 73.92,120.37 74.42,120.88 86.2,120.88 86.45,121.13 86.45,124.03 85.56,124.91 85.56,127.23 85.18,127.61 82.64,127.61 82.01,128.24 74.53,128.24 74.3,128.47 74.3,133.2
VDD1P0_ROV on V3: 32.86,97.48 32.04,98.3 32.04,102.46 32.24,102.46 32.24,104 32.04,104 32.04,106.27 31.83,106.47 31.72,106.56 31.59,106.59 20.37,106.59 19.79,107.17 19.79,118.22 21.49,119.92 21.49,124.56 21.94,125 47.71,125 48.03,124.68 48.03,119.86 48.06,119.72 48.15,119.62 48.74,119.02 48.85,118.94 48.99,118.91 64.61,118.91 64.74,118.94 64.85,119.02 66.33,120.5 66.42,120.61 66.45,120.75 66.45,130.91 70.71,135.16 86.07,135.16 86.95,134.29 86.99,134.29 93.23,128.04 93.23,119.85 87.27,113.88 87.18,113.77 87.15,113.64 87.15,98.02 86.65,97.52 60.53,97.48 ; 8 cut-outs
VDD1P0_ROV on S5: 77.22,112.75 84.84,112.75 94.1,122.02 96.18,122.02 96.87,122.7 96.87,124.38 96.03,125.22 95.09,125.22 94.2,126.11 94.2,134.72 93.69,135.23 78.49,135.23 74.3,131.04 74.3,115.67
VDD1P0_ROV on S7: 79.31,135.23 93.56,135.23 93.95,134.85 93.95,128.7 97.27,125.37 97.27,122.58 96.79,122.1 94.18,122.1 84.84,112.75 79.25,112.75 79.12,112.88 79.12,115.29 78.23,116.18 74.55,116.18 73.92,116.82 73.92,129.83
VDD1P0_ROV on S9: 74.39,124.83 74.39,114.93 76.44,112.88 85.06,112.88 94.71,122.53 96.74,122.53 97.37,123.16 97.37,125.58 94.07,128.88 94.07,134.97 93.72,135.33 84.89,135.33 82.43,132.88 78.76,132.88 75.31,129.43 75.31,125.76
VDD1P0_ROV on S12: 77.22,112.75 84.84,112.75 93.22,121.14 93.22,134.81 92.8,135.23 79.38,135.23 79.36,135.21 78.31,135.21 75.02,131.93 75.02,127.14 76.46,125.7 76.46,122.79 74.3,120.63 74.3,115.67
VDD1P0_ROV on S14: 25.33,104.64 24.28,105.7 24.28,114.26 28.87,118.85 29.37,118.85 29.37,120.73 29.39,120.76 29.39,125.9 29.71,126.22 42.12,126.22 44.03,124.31 48.37,124.31 48.52,124.46 49.97,123.02 49.97,117.12 42.92,117.12 41.55,118.49 41.55,121.24 40.71,122.08 38.72,122.08 38.14,121.5 38.13,121.5 38.13,116.58 40.25,114.46 60.4,114.46 60.88,113.99 67.99,113.99 73.92,119.92 73.92,130.43 74.08,130.59 74.08,130.6 74.31,130.83 75.45,130.83 79.85,135.23 93.43,135.23 93.95,134.72 93.95,128.45 97.17,125.22 97.17,122.27 96.82,121.92 94,121.92 80.59,108.5 44.04,108.5 40.18,104.64 ; 1 cut-out
VDD1P0_ROV on S16: 77.22,112.75 84.84,112.75 93.22,121.14 96.87,121.14 97.53,121.79 97.53,125.17 93.82,128.88 93.82,134.85 93.43,135.23 79.25,135.23 74.3,130.28 74.3,115.67
VDD1P2_DDR on TOP (solid shape): 125.1,163.17 125.1,162.78 125.09,162.77 125.09,162.67 125.18,162.58 125.69,162.58 127.09,161.18 127.09,157.22 126.82,156.95 122.89,156.95 122.76,156.82 112.11,156.82 110.71,158.21 110.71,163.17 111.39,163.84 124.43,163.84
VDD1P2_DDR on BOTTOM: 123.28,162.02 122.27,163.04 111.85,163.04 110.58,161.77 110.58,157.71 111.34,156.94 119.47,156.94 119.73,156.69 131.16,156.69 131.72,157.25 131.72,161.27 130.97,162.02
VDD1P2_DDR_ABC on TOP: 99.13,144.63 99.13,141.86 99.7,141.28 108.58,141.28 109.02,141.73 109.02,144.71 108.91,144.83 99.33,144.83
VDD1P2_DDR_ABC on BOTTOM: 123.37,151.77 118.32,151.77 118.02,151.47 118.02,148.03 118.03,148.01 118.03,147.08 118.2,146.91 124.04,146.91 124.27,147.14 124.27,150.86
VDD1P2_DDR_ABC on BOTTOM: 99.13,144.5 99.13,140.66 99.41,140.38 104.74,140.38 105.55,139.57 108.45,139.57 108.87,139.99 108.87,144.12 108.11,144.88 99.51,144.88
VDD1P2_DDR_ABC on V3: 48.09,125.52 47.98,125.61 47.84,125.64 20.41,125.64 19.97,126.09 19.97,138.08 23.08,141.2 23.08,145.51 27.71,150.15 124.11,150.15 125.31,148.94 125.31,130.91 124.3,129.89 92.36,129.89 86.45,135.8 70.58,135.8 70.44,135.77 70.33,135.68 65.93,131.28 65.84,131.17 65.81,131.04 65.81,120.88 64.02,119.08 49.58,119.08 48.67,119.99 48.67,124.81 48.64,124.95 48.55,125.06 ; 2 cut-outs
VDD1P2_DDR_VDD on TOP: 45.42,166.98 40.73,166.98 40.67,166.91 40.67,164.5 40.73,164.44 43.53,164.44 43.65,164.56 43.65,165.2 43.91,165.45 45.47,165.45 45.56,165.54 45.56,166.84
VDD1P2_DDR_VDD on TOP: 79.49,165.33 79.7,165.53 79.7,166.49 79.44,166.75 75.23,166.75 75.12,166.65 75.12,165.48 75.28,165.33
VDD1P2_DDR_VDD on BOTTOM: 110.28,166.6 110.63,166.25 114.74,166.25 115.09,166.6 115.09,176.69 114.52,177.26 110.84,177.26 110.28,176.71
VDD1P2_DDR_VDD on BOTTOM: 59.15,154.15 58.51,154.79 58.51,157.96 58.77,158.21 63.97,158.21 64.1,158.09 64.1,154.4 63.85,154.15
VDD1P2_DDR_VDD on V18: 101.13,180.24 22.75,180.24 21.78,179.26 21.75,179.26 12.86,170.37 12.86,153.07 16.13,149.8 30.16,149.8 30.19,149.77 105.44,149.77 106.65,148.56 114.27,148.56 115.79,150.09 115.79,173.84 115.41,174.22 107.15,174.22
VDD1P2_DDR_VDDQ on TOP: 113,170.03 111.09,170.03 110.07,171.04 105.25,171.04 104.74,170.53 104.74,164.95 105.25,164.44 109.82,164.44 110.58,165.2 113.12,165.2 113.63,165.71 113.63,169.39
VDD1P2_DDR_VDDQ on TOP: 40.73,163.1 40.61,162.98 40.61,160.63 40.8,160.44 45.69,160.44 46.13,160.88 46.13,162.85 45.88,163.1
VDD1P2_DDR_VDDQ on BOTTOM: 57.97,157.72 57.97,152.23 57.62,151.89 54.25,151.89 54.04,152.09 54.04,157.43 54.52,157.91 57.78,157.91
VDD1P2_DDR_VDDQ on V3: 31.91,150.78 31.02,151.67 31.02,154.85 29.37,156.5 17.87,156.5 17.55,156.82 17.55,170.4 19.02,171.87 69.82,171.87 72.29,174.34 113.25,174.34 114.39,173.2 114.39,154.15 111.03,150.78 ; 3 cut-outs
VDD1P8 on BOTTOM (solid shape): 163.47,182.36 163.47,180.95 162.62,180.1 162.05,180.1 161.98,180.16 161.98,182.54 162.06,182.62 163.21,182.62
VDD1P8 on TOP: outline of 108 points within 19.08,112.75 118.14,157.13
VDD1P8 on TOP: 146.87,188.43 144.88,188.43 144.64,188.67 143.01,188.67 142.84,188.5 142.84,187.42 142.95,187.3 145.93,187.3 146.06,187.17 146.88,187.17 147.2,187.49 147.2,188.18 146.93,188.45 146.88,188.45
VDD1P8 on TOP: 9.55,139.55 7.01,139.55 6.63,139.16 6.63,135.74 6.89,135.48 7.65,135.48 7.71,135.42 7.71,134.91 7.84,134.78 8.09,134.78 8.47,135.16 9.55,135.16 9.68,135.29 9.68,139.42
VDD1P8 on TOP: 172.05,177.84 171.29,177.84 171.22,177.77 171.22,175.17 171.42,174.98 174.15,174.98 174.4,175.23 174.4,177.96 173.89,178.47 172.56,178.47 172.05,177.96
VDD1P8 on TOP: 7.76,99.9 7.76,93.83 8.12,93.47 10.68,93.47 11.22,94 11.22,100.51 10.98,100.75 9.93,100.75 9.16,99.97 7.84,99.97
VDD1P8 on BOTTOM: 203.15,217.95 203.15,218.77 203,218.92 198.43,218.92 198.28,218.77 198.28,217.93 198.4,217.8 203,217.8
VDD1P8 on V3: 172.88,222.73 167.8,217.65 167.8,205.39 161.9,199.5 161.9,167.47 162.53,166.85 165.89,166.85 166.05,167.01 175.76,167.01 178.34,169.58 178.34,202.73 185.89,210.28 209.32,210.28 210.85,211.81 210.85,221.9 210.02,222.73
VDD1P8 on V3: 3.27,138.15 3.27,94.52 5.62,92.17 9.3,92.17 10.89,93.76 10.89,104.34 10.96,104.42 10.96,108.23 14.29,111.55 14.29,136.65 14.52,136.88 16.28,136.88 21.43,142.02 21.43,145.13 26.83,150.53 28.98,150.53 30.38,151.93 30.38,154.72 29.05,156.06 17.55,156.06 16.41,154.91 16.41,147.29 11.4,142.28 7.39,142.28
VDD1P8 on S5: 131.09,169.52 126.27,164.69 125.44,164.69 115.15,154.4 110.76,154.4 108.4,152.04 108.4,146.68 114.52,140.56 122.27,140.56 132.55,150.85 132.55,156.71 137.48,161.63 143.28,161.63 146.22,164.57 146.59,164.57 146.59,172.06 145.06,173.58 145.06,185.07 145.82,185.84 150.52,185.84 154.71,181.65 155.35,181.65 155.35,171.3 153.59,169.53 153.59,167 153.85,166.74 158.75,166.74 159.8,167.8 164.49,167.8 173.7,177.01 173.7,187.57 170.93,190.33 142.46,190.33 141.96,190.84 135.74,190.84 131.09,186.18
VDD1P8 on S14: 10.61,93.44 5.2,93.44 3.88,94.76 3.88,138.81 4.51,139.44 8.93,139.44 9.11,139.27 9.11,137.34 7.89,136.12 7.83,136.12 5.72,134.01 5.72,125.47 6.09,125.1 5.99,124.99 5.99,124.41 6.14,124.25 6.14,123.82 5.72,123.4 5.72,116.18 7.37,114.53 7.37,103.1 7.32,103.05 7.32,99.92 7.82,99.42 10.25,99.42 11.09,98.58 11.09,93.93
VDD1P8_VIN on TOP: 118.13,134.86 118.13,137.96 118.05,138.03 116.07,138.03 116.02,138.08 116.02,138.74 115.94,138.82 114.14,138.82 114.02,138.71 114.02,136.13 113.25,135.35 113.25,134.53 113.31,134.47 117.73,134.47
VDD1P25 on TOP: 99.41,94.46 95.98,94.46 95.6,94.84 95.6,95.35 95.34,95.6 94.96,95.6 94.83,95.73 94.83,96.75 96.87,96.75 96.99,96.87 96.99,97.64 99.03,97.64 99.15,97.51 99.15,96.87 99.28,96.75 100.04,96.75 100.55,96.24 102.58,96.24 102.96,95.86 102.96,93.7 102.58,93.32 99.79,93.32 99.53,93.57 99.53,94.33
VDD1P25 on TOP: 89.75,94.08 90.01,94.33 90.01,95.98 89.5,96.49 88.74,96.49 87.98,97.25 84.55,97.25 84.42,97.13 84.42,94.46 84.8,94.08
VDD1P25 on BOTTOM: 88.36,96.24 91.53,96.24 92.04,96.75 96.1,96.75 96.99,97.64 98.57,97.64 98.75,97.46 99.53,97.46 100.81,96.18 102.71,96.18 102.96,95.93 102.96,93.52 102.51,93.06 100.27,93.06 99.66,92.45 99.66,88.67 99.23,88.24 84.67,88.24 83.91,89 83.91,97.13 84.42,97.64 86.96,97.64
VDD1P25_FB on TOP (solid shape): 94.52,93.62 94.73,93.42 95.51,93.42 95.54,93.39 95.54,92.9 95.53,92.88 93.9,92.88 93.72,93.06 93.72,94.37 93.8,94.46 94.52,94.46
VDD1P25_VIN on TOP (solid shape): 96.84,104.09 97.55,104.09 97.55,103.5 96.93,103.5 96.43,103 96.43,101.99 97.67,100.76 98.24,100.76 98.24,99.92 98.06,99.74 97.13,99.74 96.97,99.9 96.97,100.31 96.93,100.34 96.93,100.49 96.78,100.49 96.72,100.56 94.99,100.56 94.89,100.66 94.89,101.8 94.93,101.81 95.2,101.95 95.35,102.21 95.63,102.49 95.63,104.33 95.79,104.49 96.43,104.49
VDD3P3 on TOP (solid shape): 176.81,248 176.81,237.08 176.37,236.64 174.08,236.64 173.96,236.76 173.96,237.36 174.62,238.03 174.62,248.38 176.43,248.38
VDD3P3 on TOP (solid shape): 110.46,176.92 110.46,175.61 109.95,175.11 108.87,175.11 108.58,175.39 108.58,176.02 108.84,176.28 108.84,176.91 108.97,177.04 108.97,177.05 110.33,177.05
VDD3P3 on TOP (solid shape): 199.04,213.21 199.27,213.21 199.27,212.5 200.12,212.5 200.12,212.06 199.8,211.74 196.62,211.74 196.43,211.94 196.43,213.27 196.56,213.4 198.85,213.4
VDD3P3 on TOP (solid shape): 199.14,238.89 199.42,238.61 199.8,238.61 199.86,238.54 199.86,236 199.74,235.87 198.78,235.87 198.72,235.94 198.72,236.45 196.94,238.22 196.94,239.3 197.2,239.56 199.14,239.56
VDD3P3 on TOP: 139,118.31 139,130.67 139.04,130.71 139.55,130.71 139.64,130.8 139.64,133.35 139.64,133.35 139.64,134.69 139.79,134.85 143.44,134.85 146.78,131.51 147.42,131.51 148.38,130.55 148.38,120.24 148.3,120.24 145.99,117.93 139.38,117.93
VDD3P3 on TOP: 65.05,192.89 64.95,192.79 60.92,192.79 60.68,193.04 60.68,194.74 61,195.06 64.61,195.06 65.05,194.62
VDD3P3 on TOP: 238.68,72.86 235.31,72.86 235.22,72.77 235.22,71.2 235.72,70.7 238.48,70.7 238.78,71 238.78,72.76
VDD3P3 on TOP: 211.47,106.36 213.88,106.36 214.01,106.49 214.01,107.38 213.63,107.76 213.63,109.67 213.75,109.79 214.01,109.79 214.26,110.05 214.26,111.44 214.13,111.57 211.42,111.57 211.34,111.5 211.34,109.03 211.59,108.78 211.85,108.78 211.98,108.65 211.98,107.81 211.9,107.74 211.42,107.74 211.34,107.66 211.34,107.51 211.42,107.43 211.42,106.42
VDD3P3 on TOP: 30.74,141.58 29.47,141.58 29.23,141.83 29.23,143.75 29.03,143.95 28.51,143.95 28.41,144.04 28.41,144.75 28.31,144.85 27.71,144.85 27.69,144.88 27.69,145.27 27.82,145.39 30.74,145.39 31.12,145.01 31.12,141.96
VDD3P3 on TOP: 170.78,177.9 169.57,177.9 169.51,177.84 169.51,175.23 169.76,174.98 170.78,174.98 171.03,175.23 171.03,177.65
VDD3P3 on TOP: 89.53,194.89 89.59,194.83 92.35,194.83 92.52,194.99 92.52,195.47 92.58,195.54 93.54,195.54 93.72,195.72 93.72,196.23 93.27,196.67 89.84,196.67 89.53,196.35
VDD3P3 on BOTTOM: 238.21,72.85 235.31,72.85 235.22,72.75 235.22,71.2 235.73,70.69 238.34,70.69 238.41,70.76 238.41,72.64
VDD3P3 on BOTTOM: 143.86,170.42 143.86,169.77 144.11,169.52 145.89,169.52 146.14,169.77 146.14,170.52 144.12,170.52 144.12,170.52 143.96,170.52
VDD3P3 on S14: 7.76,166.04 10.72,163.08 10.72,161.55 10.73,161.54 10.73,159.79 15.46,155.06 15.46,146.43 16.23,145.65 18.58,145.65 19.9,146.97 19.9,157.58 18.89,158.6 18.63,158.6 13.2,164.03 13.2,168.65 17.77,173.23 17.92,173.23 18.25,173.56 34.66,173.56 35.88,174.77 35.88,177.11 35.45,177.54 10.68,177.54 7.76,174.62
VDD3P3 on V18: outline of 91 points within 4.81,17.82 246.54,239.79 ; 1 cut-out
VDD3P3_OCXO on BOTTOM: 235.01,146.13 231.88,146.13 231.34,145.59 231.34,142.47 231.65,142.16 234.78,142.16 235.16,142.55 235.16,145.98
VDD3P3_OCXO on S5: 237.33,147.55 233.26,147.55 232.38,146.66 232.38,136.24 241.65,126.97 243.93,126.97 244.44,127.48 244.44,128.24 242.41,130.27 242.41,132.31 243.42,133.32 243.42,137.89 237.96,143.36 237.96,146.91
VDD3P3_XO on TOP: 249.39,134.34 244.82,134.34 244.77,134.29 244.77,132.13 244.57,131.93 244.57,130.66 244.95,130.27 249.39,130.27 250.03,130.91 250.03,133.7
VDD3P3_XO on S7: 263.65,135.1 245.71,135.1 244.69,134.08 244.69,130.4 246.22,128.88 261.84,128.88 261.84,128.87 263.56,128.87 264.29,128.14 264.29,113.79 264.03,113.54 258.73,113.54 258.48,113.28 258.48,111.22 258.7,111 265.68,111 266.54,111.85 266.54,132.21
VDD5V_TOD_1PPS on TOP: 240.1,95.42 239.38,95.42 239.24,95.27 239.24,94.46 238.85,94.07 238.85,90.69 239.24,90.3 239.24,89.92 239.46,89.69 239.93,89.69 240.06,89.81 240.06,93.91 240.22,94.07 240.22,95.3
VDD_3V3_1204 on TOP: 106.72,180.01 106.39,179.68 105.95,179.68 105.88,179.61 105.88,178.83 105.53,178.47 105.53,176.23 105.76,175.99 106.86,175.99 107.15,176.28 107.15,179.85 107,180.01
VDD_DRI_1V8 on TOP: 160.11,180.69 159.48,180.69 159.1,180.31 159.1,178.6 159.16,178.53 160.05,178.53 160.24,178.72 160.24,180.57
VDD_Q01 on BOTTOM: 11.07,55.87 11.07,55.09 9.87,53.9 9.87,52.51 10.56,51.83 10.56,50.87 10.54,50.86 10.54,49.88 10.27,49.61 10.06,49.61 9.96,49.51 9.96,48.18 10.04,48.11 12.41,48.11 12.55,48.24 12.55,50.1 11.62,51.03 11.62,53.03 11.78,53.19 11.78,54.58 11.65,54.71 11.65,56.65 11.38,56.92 11.04,56.92 10.92,56.81 10.92,56.02
VDD_Q02 on TOP: 212,79.45 209.68,79.45 209.62,79.39 209.62,77.95 210.2,77.37 210.2,75.56 209.57,74.93 209.57,74.14 209.69,74.01 210.84,74.01 211.14,74.32 211.14,76.12 211.34,76.32 211.34,77.52 211.45,77.62 211.5,77.62 211.54,77.66 211.78,77.66 212.31,78.19 212.31,79.42 212.29,79.44 212.02,79.44
VDD_Q03 on TOP: 197.7,80.3 197.58,80.17 197.58,75.35 197.89,75.04 199.1,75.04 199.23,75.16 199.23,77.57 199.36,77.7 199.36,77.76 199.42,77.82 199.42,80.3
VDD_RX_Q01 on BOTTOM: 14.19,48.55 13.29,48.55 13.29,47.45 13.05,47.21 13.05,45.06 13.11,44.99 15.65,44.99 15.65,46.2 15.27,46.58 14.51,46.58 14.13,46.96 14.13,48.11 14.19,48.17
VDD_RX_Q02 on TOP: 215.87,79.47 213.26,79.47 213.2,79.41 213.2,78.27 214.02,77.44 214.02,74.78 214.28,74.52 215.29,74.52 215.48,74.71 215.48,75.79 215.1,76.17 215.1,77.63 215.48,78.01 215.74,78.01 215.87,78.14
VDD_RX_Q03 on TOP: 203.52,79.45 203.52,79.45 203.45,79.38 203.45,78.11 203.62,77.95 204.27,77.95 204.56,77.66 204.56,75.92 204.55,75.91 204.66,75.79 204.66,74.88 204.64,74.85 204.64,73.25 204.87,73.02 205.6,73.02 205.83,73.25 205.83,77.85 206.16,78.18 206.16,79.37 206.08,79.45
VDD_TX_Q01 on BOTTOM: 18.43,55.24 13.81,55.24 12.59,56.46 12.59,56.88 12.49,56.98 11.97,56.98 11.88,56.89 11.88,56.1 13.33,54.66 13.33,54.33 13.73,53.92 18.3,53.92 18.63,54.25 18.63,55.04
VDD_TX_Q02 on BOTTOM: 212.03,79.47 209.49,79.47 209.41,79.4 209.41,76.55 210.04,75.92 211.12,75.92 211.37,76.17 211.37,77.67 211.5,77.8 211.88,77.8 212.08,78 212.08,79.42
VDD_TX_Q03 on TOP: 206.64,79.47 206.6,79.43 206.6,78.03 206.22,77.65 206.21,77.65 206.21,73.23 206.42,73.02 207,73.02 207.25,73.28 207.25,76.07 207.48,76.3 207.48,77.67 207.84,78.03 209.17,78.03 209.27,78.13 209.27,79.44 209.24,79.47
VDDH_1&4_3V3 on S5: 149.19,185.39 146.4,185.39 145.89,184.88 145.89,173.96 149.7,170.15 153.51,170.15 153.76,170.41 153.76,173.84 153.13,174.47 148.81,174.47 148.43,174.85 148.43,182.73 149.57,183.87 149.57,185.01
VDDL_2&6_1V8 on TOP: 143.53,186.79 143.53,186.02 144.03,185.52 144.49,185.52 144.75,185.27 144.75,184.25 145.13,183.87 145.13,183.55 145.38,183.3 145.82,183.3 146.02,183.49 146.02,184.99 145.77,185.24 145.77,185.96 145.51,186.22 144.81,186.22 144.68,186.34 144.68,186.66 144.49,186.85 143.59,186.85
VDDL_2&6_1V8 on S14: 142.55,174.51 143.18,173.87 147.3,173.87 148.31,174.88 148.31,179.22 146.41,181.12 146.41,185.49 145.96,185.94 143.59,185.94 142.55,184.89
VDDL_7&9_1V8 on S16: 153.59,172.44 146.67,172.44 146.36,172.13 146.36,170.82 146.78,170.39 154.09,170.39 154.27,170.58 154.27,171.76
VDDO_3P3 on TOP: 26.93,136.25 22.23,136.25 21.97,136.5 21.97,138.28 23.37,139.68 25.15,139.68 25.53,140.06 25.53,140.67 25.64,140.78 25.64,140.89 27,142.24 27,143.25 27.23,143.49 28.58,143.49 28.63,143.44 28.63,141.75 27.6,140.71 27.6,136.92
VDDO_3P3 on V18: outline of 146 points within 15.03,118.3 26.96,139.06
VDDO_3V3 on S9: 146.52,173.33 148.17,171.68 148.17,171.17 148.68,170.66 149.57,170.66 149.83,170.91 149.83,172.57 147.29,175.11 145.25,175.11 145,175.36 145,177.14 145.89,178.03 145.89,178.79 145,179.68 145,180.57 145.25,180.82 145.63,180.82 146.02,181.2 146.02,181.71 145.76,181.96 143.6,181.96 143.35,181.71 143.35,173.84 144.24,172.95 144.87,172.95 145.25,173.33
VDDO_FC on TOP: 21.34,138.53 21.34,136.38 21.21,136.25 20.32,136.25 20.2,136.38 20.2,139.34 22.48,141.63 22.48,143.99 22.46,144.01 22.46,144.73 22.22,144.97 22.22,146.41 22.37,146.56 24,146.56 24.1,146.46 24.1,145.87 23.95,145.73 23.95,142.38 23.46,141.89 23.46,140.66
VDDO_FC on S9: 20.84,131.52 20.84,126.49 21.1,126.24 21.94,126.24 22.22,126.51 22.22,131.42 21.76,131.87 21.2,131.87
VDDO_FC on S12: 18.96,138.71 18.74,138.48 18.74,136.52 18.48,136.27 17.52,136.27 15.56,134.31 15.56,126.67 16.04,126.18 17.95,126.18 19.14,124.99 21.12,124.99 21.43,125.3 21.43,125.8 21.56,125.93 21.72,125.93 21.9,126.11 21.9,126.87 20.93,127.84 19.97,127.84 19.55,128.27 17.44,128.27 17.31,128.39 17.31,131.98 19.57,134.24 20.26,134.24 21.81,135.79 21.81,138.33 21.43,138.71
(no net) on TOP: 72.29,68.3 72.29,67.53 71.53,66.77 71.53,63.34 71.27,63.09 69.87,63.09 69.75,63.22 69.75,68.3 69.87,68.42 72.16,68.42
(no net) on TOP: 118.61,183.56 118.61,183.3 118.61,181.78 118.61,181.02 118.61,179.49 118.61,179.24 118.36,178.98 117.72,178.98 117.41,178.68 117.41,178.03 117.37,177.98 117.4,177.95 117.4,176.22 117.29,176.11 116.93,176.11 116.93,175.4 116.83,175.3 116.66,175.3 116.66,174.88 116.56,174.78 115.26,174.78 115.05,174.98 115.05,183.05 115.56,183.56
(no net) on TOP: 43.9,63.09 42.25,63.09 42,63.34 42,64.61 42.12,64.74 42.76,64.74 42.76,66.77 42.12,67.41 42.12,68.3 42.25,68.42 43.9,68.42 44.03,68.3 44.03,63.22
(no net) on TOP: 127.88,168.95 127.75,168.82 127.75,167.08 127.98,166.85 129.76,166.85 130.01,167.1 130.01,168.69 129.75,168.95
(no net) on TOP: 79.17,72.97 79.42,72.72 80.69,72.72 80.95,72.46 80.95,71.61 81.01,71.54 82.1,71.54 82.16,71.6 82.16,74.3 81.84,74.62 79.36,74.62 79.17,74.43
(no net) on TOP: 115.61,68.3 115.61,67.53 114.85,66.77 114.85,63.34 114.6,63.09 113.2,63.09 113.07,63.22 113.07,68.3 113.2,68.42 115.49,68.42
(no net) on TOP: 59.78,68.3 59.78,67.53 59.02,66.77 59.02,63.34 58.76,63.09 57.36,63.09 57.24,63.22 57.24,68.3 57.36,68.42 59.65,68.42
(no net) on TOP: 115.81,69.06 110.41,69.06 110.31,69.15 110.31,69.7 110.24,69.76 109.61,69.76 109.52,69.86 109.52,70.33 110.03,70.84 112.95,70.84 113.2,71.09 113.2,73.25 113.46,73.5 116.25,73.5 116.63,73.12 116.63,69.69 116.54,69.6 115.96,69.6 115.9,69.54 115.9,69.19 115.91,69.18 115.91,69.16
(no net) on TOP: 167.09,69.06 161.65,69.06 161.52,69.18 161.52,69.44 161.24,69.73 160.76,69.73 160.76,70.33 161.27,70.84 164.19,70.84 164.45,71.09 164.45,73.25 164.7,73.5 167.49,73.5 167.87,73.12 167.87,69.69 167.75,69.57 167.09,69.57
(no net) on TOP: 43.1,72.72 43.36,72.46 43.36,71.45 43.48,71.32 44.44,71.32 44.56,71.45 44.56,74.94 43.97,75.54 40.99,75.54 40.67,75.22 40.67,72.81 40.76,72.72
(no net) on TOP: 128.3,69.06 122.98,69.06 122.9,69.14 122.9,69.5 122.77,69.63 122.15,69.63 122.09,69.7 122.09,70.33 122.6,70.84 125.52,70.84 125.77,71.09 125.77,73.25 126.03,73.5 128.82,73.5 129.2,73.12 129.2,69.69 129.13,69.62 128.42,69.62 128.36,69.57 128.36,69.12
(no net) on TOP: 220.54,122.14 222.32,122.14 222.77,122.59 222.77,125.74 222.32,126.2 220.54,126.2 220.28,125.95 220.28,122.39
(no net) on TOP: 186.92,63.34 186.92,64.61 187.05,64.74 187.69,64.74 187.69,66.77 187.05,67.41 187.05,68.3 187.18,68.42 188.83,68.42 188.96,68.3 188.96,63.22 188.95,63.21 188.95,62.91 188.75,62.71 187.56,62.71
(no net) on TOP: 81.49,63.09 79.84,63.09 79.59,63.34 79.59,64.61 79.72,64.74 80.35,64.74 80.35,66.77 79.72,67.41 79.72,68.51 79.84,68.64 81.56,68.64 81.62,68.58 81.62,63.22
(no net) on TOP: 35.08,69.06 29.49,69.06 29.36,69.18 29.36,69.44 29.23,69.57 28.6,69.57 28.6,70.33 29.11,70.84 32.03,70.84 32.28,71.09 32.28,73.25 32.54,73.5 35.33,73.5 35.71,73.12 35.71,69.69 35.58,69.57 35.08,69.57
(no net) on TOP: 128.19,68.3 128.19,67.53 127.43,66.77 127.43,63.34 127.17,63.09 125.77,63.09 125.65,63.22 125.65,68.3 125.77,68.42 128.06,68.42
(no net) on TOP: 166.86,68.3 166.86,67.68 166.02,66.84 166.02,63.26 165.84,63.09 164.45,63.09 164.32,63.22 164.32,68.3 164.45,68.42 166.73,68.42
(no net) on TOP: 85.06,69.06 84.93,69.06 84.73,69.26 79.64,69.26 79.46,69.44 79.46,69.57 79.4,69.63 78.76,69.63 78.7,69.7 78.7,70.33 78.85,70.47 82.91,70.47 83.32,70.89 83.32,73 83.82,73.5 85.43,73.5 85.81,73.12 85.81,69.69 85.69,69.57 85.12,69.57 85.06,69.5
(no net) on TOP: 151.05,63.09 149.4,63.09 149.14,63.34 149.14,64.61 149.27,64.74 149.9,64.74 149.9,66.77 149.27,67.41 149.27,68.3 149.4,68.42 151.05,68.42 151.17,68.3 151.17,63.22
(no net) on TOP: 84.49,67.23 84.03,66.77 84.03,63.34 83.78,63.09 82.38,63.09 82.26,63.22 82.26,68.39 82.51,68.64 84.42,68.64 84.49,68.57
(no net) on TOP: 192.13,68.3 192.13,67.53 191.37,66.77 191.37,63.34 191.12,63.09 189.72,63.09 189.59,63.22 189.59,68.3 189.72,68.42 192,68.42
(no net) on TOP: 66.66,72.97 66.92,72.72 68.19,72.72 68.44,72.46 68.44,71.6 68.52,71.52 69.53,71.52 69.65,71.64 69.65,74.3 69.33,74.62 66.85,74.62 66.66,74.43
(no net) on TOP: 29.95,73.03 29.96,73.04 30.69,73.04 30.85,72.88 30.85,71.45 30.97,71.32 31.93,71.32 32.05,71.45 32.05,74.87 31.82,75.1 27.77,75.1 27.52,74.86 27.52,73.28 27.76,73.03
(no net) on TOP: 68.99,63.09 67.33,63.09 67.08,63.34 67.08,64.61 67.21,64.74 67.84,64.74 67.84,66.77 67.21,67.41 67.21,68.3 67.33,68.42 68.99,68.42 69.11,68.3 69.11,63.22
(no net) on TOP: 175.39,72.72 175.65,72.46 175.65,71.45 175.77,71.32 176.73,71.32 176.85,71.45 176.85,74.3 176.54,74.62 173.04,74.62 172.94,74.52 172.94,73.63 173.86,72.72
(no net) on TOP: 127.88,175.81 128.01,175.94 128.01,177.08 127.88,177.21 126.61,177.21 126.48,177.08 126.48,175.94 126.61,175.81
(no net) on TOP: 31.39,63.09 29.74,63.09 29.49,63.34 29.49,64.61 29.62,64.74 30.25,64.74 30.25,66.77 29.62,67.41 29.62,68.3 29.74,68.42 31.39,68.42 31.52,68.3 31.52,63.22
(no net) on TOP: 179.5,68.3 179.5,67.53 178.73,66.77 178.73,63.34 178.48,63.09 177.08,63.09 176.96,63.22 176.96,68.3 177.08,68.42 179.37,68.42
(no net) on TOP: 47.59,69.06 42,69.06 41.87,69.18 41.87,69.44 41.74,69.57 41.11,69.57 41.11,70.33 41.62,70.84 46.03,70.84 46.25,71.06 46.25,73.36 46.4,73.5 47.84,73.5 48.22,73.12 48.22,69.69 48.09,69.57 47.59,69.57
(no net) on TOP: 111.51,72.72 111.77,72.46 111.77,71.45 111.89,71.32 112.85,71.32 112.97,71.45 112.97,74.3 112.66,74.62 109.54,74.62 109.44,74.52 109.44,72.9 109.62,72.72
(no net) on TOP: 117.59,172.89 117.47,173.01 117.47,175.3 117.7,175.53 117.7,177.43 117.98,177.71 118.48,177.71 118.74,177.97 119.25,177.97 119.37,178.09 119.37,179.24 119.63,179.49 119.63,183.3 119.75,183.43 124.07,183.43 124.44,183.06 124.44,181.89 124.07,181.52 124.07,180 123.94,179.87 121.66,179.87 121.28,179.49 121.28,178.73 120.9,178.35 120.9,175.96 120.92,175.94 122.17,175.94 122.29,175.81 122.29,173.01 122.17,172.89
(no net) on TOP: 34.52,67.36 33.93,66.77 33.93,63.34 33.68,63.09 32.28,63.09 32.16,63.22 32.16,68.3 32.28,68.42 34.43,68.42 34.52,68.34
(no net) on TOP: 127.09,157.22 127.09,161.18 125.69,162.58 125.18,162.58 125.09,162.67 125.09,162.77 125.1,162.78 125.1,163.17 124.43,163.84 111.39,163.84 110.71,163.17 110.71,158.21 112.11,156.82 122.76,156.82 122.89,156.95 126.82,156.95
(no net) on TOP: 163.56,63.09 161.91,63.09 161.65,63.34 161.65,64.61 161.78,64.74 162.41,64.74 162.41,66.77 161.78,67.41 161.78,68.3 161.91,68.42 163.56,68.42 163.68,68.3 163.68,63.22
(no net) on TOP: 56.48,63.09 54.82,63.09 54.57,63.34 54.57,64.61 54.7,64.74 55.33,64.74 55.33,66.77 54.7,67.41 54.7,68.3 54.82,68.42 56.48,68.42 56.6,68.3 56.6,63.22
(no net) on TOP: 154.5,69.06 149.14,69.06 149.02,69.18 149.02,69.44 148.74,69.72 148.25,69.72 148.25,70.33 148.76,70.84 151.68,70.84 151.94,71.09 151.94,73.25 152.19,73.5 154.98,73.5 155.37,73.12 155.37,69.69 155.24,69.57 154.5,69.57
(no net) on TOP: 179.71,69.06 174.29,69.06 174.16,69.18 174.16,69.44 173.88,69.72 173.4,69.72 173.4,70.33 173.91,70.84 176.83,70.84 177.08,71.09 177.08,73.25 177.34,73.5 180.13,73.5 180.51,73.12 180.51,69.69 180.38,69.57 179.71,69.57
(no net) on TOP: 154.35,68.3 154.35,67.83 153.59,67.07 153.59,63.34 153.33,63.09 151.94,63.09 151.81,63.22 151.81,68.3 151.94,68.42 154.22,68.42
(no net) on TOP: 124.89,63.09 123.23,63.09 122.98,63.34 122.98,64.61 123.11,64.74 123.74,64.74 123.74,66.77 123.11,67.41 123.11,68.3 123.23,68.42 124.89,68.42 125.01,68.3 125.01,63.22
(no net) on TOP: 126.23,169.33 127.25,169.33 127.75,169.84 129.02,169.84 129.15,169.97 129.15,171.36 128.97,171.54 127.42,171.54 127.35,171.46 127.35,170.7 127.12,170.47 126.28,170.47 126.15,170.35 126.15,169.41
(no net) on TOP: 112.31,63.09 110.66,63.09 110.41,63.34 110.41,64.61 110.53,64.74 111.17,64.74 111.17,66.77 110.53,67.41 110.53,68.3 110.66,68.42 112.31,68.42 112.44,68.3 112.44,63.22
(no net) on TOP: 60.16,69.06 54.57,69.06 54.44,69.18 54.44,69.44 54.32,69.57 53.68,69.57 53.68,70.33 54.19,70.84 57.11,70.84 57.11,70.84 58.49,70.84 58.82,71.17 58.82,73.36 58.96,73.5 60.41,73.5 60.79,73.12 60.79,69.69 60.67,69.57 60.16,69.57
(no net) on TOP: 133.02,62.97 131.37,62.97 131.12,63.22 131.12,64.49 131.25,64.62 131.88,64.62 131.88,65.26 131.99,65.37 131.99,66.78 131.42,67.35 131.42,68.3 133.02,68.3 133.15,68.17 133.15,63.09
(no net) on TOP: 136.33,68.17 136.33,67.41 135.56,66.65 135.56,63.22 135.31,62.97 133.91,62.97 133.79,63.09 133.79,68.17 133.91,68.3 136.2,68.3
(no net) on TOP: 176.19,63.09 174.54,63.09 174.29,63.34 174.29,64.61 174.42,64.74 175.05,64.74 175.05,66.77 174.42,67.41 174.42,68.3 174.54,68.42 176.19,68.42 176.32,68.3 176.32,63.22
(no net) on TOP: 55.68,72.72 55.93,72.46 55.93,71.74 56.13,71.54 57.06,71.54 57.14,71.62 57.14,74.75 56.71,75.18 53.49,75.18 53.21,74.91 53.21,73.34 53.84,72.72
(no net) on TOP: 192.37,69.06 186.92,69.06 186.8,69.18 186.8,69.44 186.59,69.65 186.04,69.65 186.04,70.33 186.54,70.84 189.46,70.84 189.72,71.09 189.72,72.82 190.4,73.5 192.77,73.5 193.15,73.12 193.15,69.69 193.08,69.62 192.49,69.62 192.37,69.5
(no net) on TOP: 116.58,172.38 116.83,172.13 120.26,172.13 120.39,172 120.39,170.98 121.15,170.22 123.44,170.22 123.56,170.09 123.56,168.95 123.44,168.82 122.65,168.82 122.17,168.82 120.39,167.05 115.44,167.05 115.31,167.17 115.31,174.28 115.54,174.51 116.5,174.51 116.58,174.44
(no net) on TOP: 72.67,69.06 67.08,69.06 66.95,69.18 66.95,69.44 66.83,69.57 66.19,69.57 66.19,70.33 66.7,70.84 70.86,70.84 71.28,71.25 71.28,73.38 71.4,73.5 72.92,73.5 73.3,73.12 73.3,69.69 73.18,69.57 72.67,69.57
(no net) on TOP: 47.2,68.3 47.2,67.53 46.44,66.77 46.44,63.34 46.19,63.09 44.79,63.09 44.66,63.22 44.66,68.3 44.79,68.42 47.08,68.42
(no net) on BOTTOM: 59.78,68.5 59.78,67.53 59.02,66.77 59.02,66.01 59.65,65.37 59.65,64.61 59.9,64.36 59.9,63.22 59.78,63.09 58.13,63.09 57.62,63.6 57.62,68.5 57.77,68.65 59.63,68.65
(no net) on BOTTOM: 120.11,171.11 120.87,170.35 120.87,167.63 120.41,167.17 115.66,167.17 115.52,167.31 115.52,170.89 115.74,171.11
(no net) on BOTTOM: 72.29,68.5 72.29,67.53 71.53,66.77 71.53,66.01 72.16,65.37 72.16,64.61 72.41,64.36 72.41,63.22 72.29,63.09 70.64,63.09 70.13,63.6 70.13,68.5 70.28,68.65 72.13,68.65
(no net) on BOTTOM: 163.71,68.65 161.93,68.65 161.87,68.59 161.87,67.32 162.38,66.81 162.38,64.97 162.19,64.78 161.74,64.78 161.68,64.71 161.68,63.38 161.99,63.06 163.58,63.06 163.65,63.13 163.65,63.38 163.71,63.44
(no net) on BOTTOM: 109.52,69.84 109.52,70.33 110.03,70.84 112.95,70.84 113.2,71.09 113.2,72.11 114.34,73.25 116.22,73.25 116.63,72.84 116.63,69.85 116.43,69.64 116.02,69.64 115.87,69.49 115.87,69.39 115.77,69.29 110.61,69.29 110.51,69.39 110.51,69.46 110.25,69.73 109.63,69.73
(no net) on BOTTOM: 192.13,68.5 192.13,67.53 191.37,66.77 191.37,66.01 192,65.37 192,64.61 192.26,64.36 192.26,63.22 192.13,63.09 190.48,63.09 189.97,63.6 189.97,68.5 190.13,68.65 191.98,68.65
(no net) on BOTTOM: 154.35,68.5 154.35,67.53 153.51,66.69 153.51,64.68 153.69,64.49 154.34,64.49 154.48,64.36 154.48,63.22 154.35,63.09 152.7,63.09 152.19,63.6 152.19,68.5 152.34,68.65 154.2,68.65
(no net) on BOTTOM: 56.63,68.65 54.85,68.65 54.79,68.59 54.79,67.32 55.29,66.81 55.29,64.97 55.1,64.78 54.66,64.78 54.6,64.71 54.6,63.38 54.91,63.06 56.5,63.06 56.56,63.13 56.56,63.38 56.63,63.44
(no net) on BOTTOM: 148.25,69.57 148.25,70.33 148.76,70.84 151.68,70.84 151.94,71.09 151.94,72.11 153.08,73.25 154.96,73.25 155.37,72.84 155.37,69.85 155.16,69.64 154.76,69.64 154.6,69.49 154.6,69.39 154.5,69.29 149.35,69.29 149.24,69.39 149.24,69.46 149.14,69.57
(no net) on BOTTOM: 44.06,68.65 42.28,68.65 42.21,68.59 42.21,67.32 42.72,66.81 42.72,64.82 42.65,64.75 42.06,64.75 42.02,64.71 42.02,63.38 42.34,63.06 43.93,63.06 43.99,63.13 43.99,63.38 44.06,63.44
(no net) on BOTTOM: 31.55,68.65 29.77,68.65 29.7,68.59 29.7,67.32 30.21,66.81 30.21,64.97 30.02,64.78 29.58,64.78 29.51,64.71 29.51,63.38 29.83,63.06 31.42,63.06 31.48,63.13 31.48,63.38 31.55,63.44
(no net) on BOTTOM: 47.2,68.5 47.2,67.53 46.44,66.77 46.44,66.01 47.08,65.37 47.08,64.61 47.33,64.36 47.33,63.22 47.2,63.09 45.55,63.09 45.05,63.6 45.05,68.5 45.2,68.65 47.05,68.65
(no net) on BOTTOM: 41.11,69.57 41.11,70.33 41.62,70.84 44.54,70.84 44.79,71.09 44.79,72.11 45.93,73.25 47.81,73.25 48.22,72.84 48.22,69.85 48.02,69.64 47.61,69.64 47.46,69.49 47.46,69.39 47.36,69.29 42.2,69.29 42.1,69.39 42.1,69.46 42,69.57
(no net) on BOTTOM: 160.76,69.57 160.76,70.33 161.27,70.84 164.19,70.84 164.45,71.09 164.45,72.11 165.59,73.25 167.47,73.25 167.87,72.84 167.87,69.85 167.67,69.64 167.27,69.64 167.11,69.49 167.11,69.39 167.01,69.29 161.85,69.29 161.75,69.39 161.75,69.46 161.65,69.57
(no net) on BOTTOM: 128.19,68.5 128.19,67.53 127.43,66.77 127.43,66.01 127.95,65.48 127.41,65.48 127.33,65.4 127.33,64.77 127.4,64.71 127.97,64.71 128.31,64.36 128.31,63.22 128.19,63.09 126.54,63.09 126.03,63.6 126.03,68.5 126.18,68.65 128.03,68.65
(no net) on BOTTOM: 122.34,171.64 122.34,172.99 122.45,173.09 123.13,173.09 123.51,172.71 124,172.71 124.17,172.53 124.17,171.69 123.82,171.34 122.65,171.34
(no net) on BOTTOM: 28.6,69.57 28.6,70.33 29.11,70.84 32.03,70.84 32.28,71.09 32.28,72.11 33.43,73.25 35.3,73.25 35.71,72.84 35.71,69.85 35.51,69.64 35.1,69.64 34.95,69.49 34.95,69.39 34.85,69.29 29.69,69.29 29.59,69.39 29.59,69.46 29.49,69.57
(no net) on BOTTOM: 133.18,68.53 131.4,68.53 131.33,68.47 131.33,67.2 131.84,66.69 131.84,64.85 131.65,64.66 131.21,64.66 131.14,64.59 131.14,63.26 131.46,62.94 133.05,62.94 133.11,63 133.11,63.26 133.18,63.32
(no net) on BOTTOM: 78.7,69.75 78.7,70.33 79.21,70.84 82.13,70.84 82.38,71.09 82.38,72.11 83.53,73.25 85.06,73.25 85.31,73 85.31,72.21 85.77,71.75 85.77,69.64 85.51,69.39 85.05,69.39 84.95,69.29 79.79,69.29 79.79,69.58 79.68,69.7 78.76,69.7
(no net) on BOTTOM: 125.04,68.65 123.26,68.65 123.2,68.59 123.2,67.32 123.7,66.81 123.7,64.97 123.51,64.78 123.07,64.78 123.01,64.71 123.01,63.38 123.32,63.06 124.91,63.06 124.97,63.13 124.97,63.38 125.04,63.44
(no net) on BOTTOM: 166.86,68.5 166.86,67.79 166.02,66.95 166.02,65.89 166.33,65.57 166.53,65.57 166.66,65.45 166.66,64.48 166.99,64.16 166.99,63.22 166.86,63.09 165.21,63.09 164.7,63.6 164.7,68.5 164.85,68.65 166.71,68.65
(no net) on BOTTOM: 53.68,69.57 53.68,70.33 54.19,70.84 57.11,70.84 57.36,71.09 57.36,72.11 58.51,73.25 60.39,73.25 61.18,72.46 61.18,70.23 60.59,69.64 60.18,69.64 60.03,69.49 60.03,69.39 59.93,69.29 54.77,69.29 54.67,69.39 54.67,69.46 54.57,69.57
(no net) on BOTTOM: 122.09,69.76 122.09,70.66 122.26,70.84 125.52,70.84 125.77,71.09 125.77,72.11 126.92,73.25 128.8,73.25 129.2,72.84 129.2,69.85 129,69.64 128.59,69.64 128.44,69.49 128.44,69.39 128.34,69.29 123.18,69.29 123.16,69.31 123.16,69.5 122.96,69.7 122.15,69.7
(no net) on BOTTOM: 186.04,69.76 186.04,70.33 186.54,70.84 189.46,70.84 189.72,71.09 189.72,72.95 190.02,73.25 192.74,73.25 193.15,72.84 193.15,69.85 192.94,69.64 192.54,69.64 192.39,69.49 192.39,69.39 192.28,69.29 187.14,69.29 187.1,69.25 187.04,69.25 186.97,69.19 186.85,69.19 186.72,69.31 186.72,69.63 186.66,69.7 186.1,69.7
(no net) on BOTTOM: 179.5,68.5 179.5,67.53 178.73,66.77 178.73,66.01 179.37,65.37 179.37,64.61 179.62,64.36 179.62,63.22 179.5,63.09 177.84,63.09 177.34,63.6 177.34,68.5 177.49,68.65 179.34,68.65
(no net) on BOTTOM: 136.33,68.38 136.33,67.41 135.56,66.65 135.56,65.89 136.2,65.25 136.2,64.49 136.45,64.24 136.45,63.09 136.33,62.97 134.67,62.97 134.17,63.47 134.17,68.38 134.32,68.53 136.17,68.53
(no net) on BOTTOM: 130.23,69.7 130.23,70.21 130.74,70.71 133.66,70.71 133.91,70.97 133.91,71.98 135.06,73.13 136.93,73.13 137.34,72.72 137.34,69.72 137.14,69.52 136.73,69.52 136.58,69.37 136.58,69.27 136.48,69.16 131.54,69.16 131.07,69.63 130.29,69.63
(no net) on BOTTOM: 84.48,68.54 84.48,67.48 84.03,67.03 84.03,67.02 83.91,66.89 83.91,65.6 83.87,65.55 83.87,64.71 83.97,64.61 84.67,64.61 84.92,64.36 84.92,63.22 84.8,63.09 83.15,63.09 82.64,63.6 82.64,68.5 82.79,68.65 84.37,68.65
(no net) on BOTTOM: 151.2,68.65 149.42,68.65 149.36,68.59 149.36,67.32 149.87,66.81 149.87,64.97 149.68,64.78 149.23,64.78 149.17,64.71 149.17,63.38 149.49,63.06 151.07,63.06 151.14,63.13 151.14,63.38 151.2,63.44
(no net) on BOTTOM: 176.35,68.65 174.57,68.65 174.5,68.59 174.5,67.32 175.01,66.81 175.01,64.97 174.82,64.78 174.38,64.78 174.31,64.71 174.31,63.38 174.63,63.06 176.22,63.06 176.28,63.13 176.28,63.38 176.35,63.44
(no net) on BOTTOM: 119.78,183.33 119.75,183.3 119.75,179.49 119.5,179.24 119.5,178.22 119.37,178.09 118.86,178.09 117.85,177.08 117.85,173.78 118.1,173.52 121.66,173.52 121.79,173.65 121.79,176.06 121.58,176.27 121,176.27 120.69,176.57 120.69,178.02 121.66,178.98 121.68,178.98 122.01,179.31 123.89,179.31 124.2,179.62 124.2,182.92 123.79,183.33
(no net) on BOTTOM: 69.14,68.65 67.36,68.65 67.3,68.59 67.3,67.32 67.8,66.81 67.8,64.97 67.61,64.78 67.17,64.78 67.11,64.71 67.11,63.38 67.42,63.06 69.01,63.06 69.07,63.13 69.07,63.38 69.14,63.44
(no net) on BOTTOM: 115.05,183.06 115.56,183.56 115.56,183.56 118.35,183.56 118.48,183.43 118.48,179.11 118.36,178.98 117.72,178.98 117.59,178.86 117.59,178.25 117.24,177.89 115.46,177.89 115.05,178.3
