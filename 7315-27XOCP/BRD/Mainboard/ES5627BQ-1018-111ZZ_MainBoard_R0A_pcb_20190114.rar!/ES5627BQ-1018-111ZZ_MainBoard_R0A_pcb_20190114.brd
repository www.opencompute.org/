# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_TXD_A: length 5.8
  TOP w0.254: LB70.1 248.94,152.04 v1(248.25,152.04) CB915.1 246.49,152.04 RB335.1
  BOTTOM w0.254: v1(248.25,152.04) 249.07,152.04 249.9,152.88 v2(250.66,152.88)
CPU_TXD_L: length 152.1
  TOP w0.254: LB70.2 v1(251.81,152.37)
  S5 w0.254: v1(257.84,35.51) 258.59,34.76 258.59,25.43 RJ1.F3
  S16 w0.254: v1(257.84,35.51) 258.16,35.83 258.16,37.19 258.27,37.3 258.27,45.9 254.51,49.66 254.51,51.97 254.97,52.43 254.97,57.58 246.98,65.57 246.98,92.81 245.58,94.21 245.58,97 243.97,98.62 243.97,108.23 237.97,114.22 237.97,115.85 238.66,116.54 238.66,136.81 239.29,137.44 239.29,140.73 245.6,147.03 249.11,147.03 251.17,149.09 251.17,151.74 v1(251.81,152.37)
  BOTTOM w0.254: v1(257.84,35.51) 257.84,35.4 258.51,34.73 CB930.1 258.74,32.94 LB77.2 ; v2(252.82,152.37) v1(251.81,152.37)
CPU_UART1_TX_R: length 11.6
  TOP w0.127: v1(95.88,234.41) 94.94,235.35 R259.1 ; P1.D20 v4(97.29,229.46)
  S14 w0.127: v4(97.29,229.46) 97.73,229.9 97.73,232.56 v1(95.88,234.41)
  BOTTOM w0.127: v2(96.74,236.38) 96.26,236.38 95.35,235.47 95.35,234.91 95.85,234.41 v1(95.88,234.41)
DDR_A_RES_NEG: length 1.5
  TOP w0.254: v4(34.7,126.65) U40.AJ23
  BOTTOM w0.254: RB179.2 35.19,126.15 v4(34.7,126.65)
DDR_A_RES_POS: length 1.5
  TOP w0.254: U40.AH23 v4(34.7,125.65)
  BOTTOM w0.254: v4(34.7,125.65) 35.19,125.15 RB180.2
DDR_A_RES_VDD: length 1.5
  TOP w0.254: U40.AH22 v4(35.7,125.65)
  BOTTOM w0.254: RB180.1 36.19,125.15 v4(35.7,125.65)
DDR_A_RES_VSS: length 1.5
  TOP w0.254: v4(35.7,126.65) U40.AJ22
  BOTTOM w0.254: RB179.1 36.19,126.15 v4(35.7,126.65)
DDR_AB_AVDD1P8: length 12.4
  TOP w0.381: v4(31.7,124.65) U40.AG26 ; v4(36.7,124.65) U40.AG21 ; v4(41.7,124.65) U40.AG17 ; v4(36.7,123.65) U40.AF21 ; v4(29.7,124.65) U40.AG28 ; v4(29.7,123.65) U40.AF28
  BOTTOM w0.381: v4(41.7,124.65) 41.2,124.15 CB458.2 ; CB466.1 29.22,123.17 v4(29.7,123.65) 29.2,124.14 CB448.1 29.23,124.18 v4(29.7,124.65) 29.7,124.66 CB430.1 ; v4(31.7,124.65) 31.7,124.66 CB423.1 ; CB424.1 36.7,124.65 v4(36.7,124.65) 36.7,124.65 CB464.2 36.7,123.65 v4(36.7,123.65) 36.2,123.15 CB463.1 ; v1(54.23,139.42) 53.67,139.42 v2(53.33,139.09)
  vias: v1(54.23,138.66)
DDR_ABC_AVDD1P8: length 9.3
  TOP w0.381: U40.AF11 v4(47.7,123.65) ; U40.AE11 v4(47.7,122.65) ; U40.AB11 v4(47.7,119.65)
  BOTTOM w0.305: CB453.1 48.19,124.16 48.19,125.15 CB429.1
  BOTTOM w0.381: v2(60.73,117.19) v1(60.73,118.02) ; CB479.1 48.19,122.15 v4(47.7,122.65) 47.2,123.14 CB469.2 v4(47.7,123.65) CB453.1 ; CB524.1 47.2,119.15 v4(47.7,119.65) 47.71,119.65 CB525.1 48.15,119.1 CB539.1
  vias: v1(59.82,118.06) v1(60.42,118.97)
DDR_C_RES_NEG: length 1.4
  TOP w0.381: U40.AH10 v4(48.7,125.65)
  BOTTOM w0.381: v4(48.7,125.65) RB178.2
DDR_C_RES_POS: length 1.4
  TOP w0.381: v4(48.7,122.65) U40.AE10
  BOTTOM w0.381: RB185.2 48.7,122.65 v4(48.7,122.65)
DDR_C_RES_VDD: length 1.4
  TOP w0.381: v4(48.7,123.65) U40.AF10
  BOTTOM w0.381: v4(48.7,123.65) 48.2,123.15 RB185.1
DDR_C_RES_VSS: length 1.4
  TOP w0.381: v4(48.7,126.65) U40.AJ10
  BOTTOM w0.381: v4(48.7,126.65) RB178.1
DDR_GEN_FSEL0: length 3.6
  TOP w0.127: RB3.1 85.46,185.05 v1(85.44,185.07) 85.71,185.34 UB1.14
  BOTTOM w0.127: v1(85.44,185.07) 85.18,185.33 v2(85.18,186.28)
DDR_GEN_FSEL1: length 5.3
  TOP w0.127: UB1.17 88.05,187.16 88.26,186.95 88.26,185.62 v1(88.77,185.11) 89.29,184.59 RB5.1
  BOTTOM w0.127: v2(89.78,185.86) 89.52,185.86 v1(88.77,185.11)
DDR_GEN_OUT0_N: length 5.9
  TOP w0.095: RB28.2 77.64,188.91 arc(77.77,189.23) 78.09,189.36 79.49,189.36 arc(79.82,189.23) RB29.2 80.3,188.91 80.45,189.05 80.45,189.27 80.51,189.33 80.92,189.33 81.39,189.8 81.92,189.8 82.06,189.66 UB1.3
DDR_GEN_OUT0_P: length 5.9
  TOP w0.095: UB1.2 82,190.16 81.86,190.03 81.29,190.03 80.83,189.56 80.54,189.56 80.45,189.65 80.45,189.84 80.24,190.05 RB40.2 arc(79.82,189.73) 79.49,189.59 78.07,189.59 arc(77.77,189.72) 77.64,190.03 RB39.2
DDR_GEN_OUT1_N: length 6.2
  TOP w0.095: UB1.6 81.91,188.16 81.82,188.25 81.68,188.25 81.37,187.94 81.37,187.63 80.82,187.08 80.41,187.08 RB7.2 arc(79.91,186.8) 79.82,186.94 79.68,187.08 78.12,187.08 arc(77.8,186.95) RB6.2
DDR_GEN_OUT1_P: length 6.2
  TOP w0.095: UB1.5 81.96,188.66 81.78,188.48 81.59,188.48 81.14,188.03 81.14,187.73 80.72,187.31 80.41,187.31 RB13.2 arc(79.92,187.61) 79.84,187.49 79.66,187.31 78.12,187.31 arc(77.8,187.44) RB12.2
DDR_GEN_OUT2_N: length 5.3
  TOP w0.095: UB1.22 88.05,189.66 88.18,189.79 88.3,189.79 arc(88.45,189.82) 88.58,189.91 88.63,189.96 arc(88.76,190.05) 88.91,190.08 89.2,190.08 RB21.2 89.6,189.73 90,190.13 91.53,190.13 RB22.2
DDR_GEN_OUT2_P: length 5.3
  TOP w0.095: UB1.23 88.05,190.16 88.18,190.02 88.3,190.02 arc(88.36,190.03) 88.42,190.07 88.47,190.12 arc(88.67,190.26) 88.91,190.3 89.08,190.3 RB37.2 89.6,190.76 90.01,190.36 91.54,190.36 RB38.2
DDR_GEN_SEL: length 3.9
  TOP w0.254: RB45.1 82.16,193.11 v1(82.76,192.51) 83.21,192.07 UB1.32
  BOTTOM w0.127: v2(82.58,193.77) 82.58,192.69 v1(82.76,192.51)
DDR_GEN_VCCA: length 2.7
  TOP w0.254: 85.21,192.16 UB1.28
  TOP w0.381: CB43.1 85.72,193.04
  BOTTOM w0.127: v2(87.98,192.31) 88.48,192.31 v1(89.12,192.95)
DDR_GEN_VCCO: length 28.5
  TOP w0.254: v1(81.5,189.08) 81.58,189.16 UB1.4 ; UB1.21 87.9,189.16 88.4,188.65
  TOP w0.508: v1(93.77,187.37) 93.67,187.37 93.66,187.38 LB4.2 CB26.1 CB25.1 89.58,187.58 CB32.1 88.4,188.65
  S5 w0.508: v1(93.77,187.37) 93.67,187.37 93.66,187.38 93.14,187.38 90.01,184.25 82.77,184.25 81.5,185.52 v1(81.5,189.08)
  BOTTOM w0.305: v1(81.5,189.08) 81.45,189.13 CB34.1
  BOTTOM w0.508: v2(92.49,187.33) 92.53,187.37 v1(93.77,187.37)
DDR_GEN_VDD: length 19.7
  TOP w0.203: UB1.16 86.71,185.77 86.77,185.71 86.77,185.14 86.71,185.07 v1(86.8,184.99)
  TOP w0.254: 83.71,192.52 UB1.31
  TOP w0.508: v1(84.45,192.54) CB46.1 83.92,193.73 83.72,193.53 CB42.1 83.18,193.05 83.71,192.52 ; LB1.2 86.88,184.03 CB9.1
  S5 w0.508: v1(84.45,192.54) 85.21,192.54 87.6,190.15 87.6,185.79 v1(86.8,184.99)
  BOTTOM w0.127: v2(84.48,193.71) 84.48,192.57 v1(84.45,192.54)
  BOTTOM w0.381: CB5.1 86.92,184.86 v1(86.8,184.99)
DDR_GEN_XTAL_IN: length 8.8
  TOP w0.127: UB1.9 83.21,186.21 82.42,185.42 CB7.2 81.71,184.28 80.93,183.5 80.93,181.33 82.02,180.23 OSCB1.1
DDR_GEN_XTAL_OUT: length 2.2
  TOP w0.127: UB1.10 83.71,185.07 83.43,184.8 RB2.2
DDR_GEN_XTAL_OUT_R: length 2.8
  TOP w0.127: RB2.1 CB8.2 84.45,182.37 OSCB1.3
DDRA_100M_N: length 91.3
  TOP w0.095: v3(75.22,188.97) 75.53,189.28 arc(75.62,189.34) 75.73,189.36 76.27,189.36 arc(76.6,189.23) RB28.1
  S5 w0.108: v3(73.5,161.87) 73.21,161.58 72.98,161.58 arc(72.81,161.61) 72.67,161.71 70.85,163.53 arc(70.53,164) 70.42,164.55 70.42,173.19 arc(70.58,173.95) 71.01,174.59 71.79,175.38 arc(72.26,176.09) 72.43,176.93 72.43,185.2 arc(72.49,185.33) 72.62,185.39 arc(72.75,185.44) 72.8,185.57 72.8,185.82 arc(72.75,185.95) 72.62,186 arc(72.49,186.06) 72.43,186.19 72.43,186.43 arc(72.49,186.56) 72.62,186.62 arc(72.75,186.67) 72.8,186.8 72.8,187.05 arc(72.75,187.18) 72.62,187.23 arc(72.49,187.29) 72.43,187.42 72.43,187.82 arc(72.5,188.14) 72.68,188.41 73.24,188.97 arc(73.27,189) 73.31,189.03 arc(73.71,189.28) 74.18,189.36 74.83,189.36 arc(75.11,189.25) v3(75.22,188.97)
  BOTTOM w0.095: CB344.1 31.35,138.46 arc(31.25,138.61) 31.21,138.79 31.21,138.86 arc(31.22,138.91) 31.25,138.95 33.03,140.73 34.58,142.28 arc(36.93,143.85) 39.7,144.4 50.05,144.4 arc(55.58,145.5) 60.26,148.63 62.04,150.41 arc(64.86,152.29) 68.19,152.96 69.78,152.96 arc(71.1,153.22) 72.21,153.96 73.81,155.56 arc(74.48,156.57) 74.72,157.75 74.72,160.83 arc(74.66,161.11) 74.51,161.34 74.43,161.42 arc(74.23,161.55) 74.01,161.59 73.94,161.59 arc(73.93,161.59) 73.92,161.59 arc(73.78,161.63) 73.66,161.71 v3(73.5,161.87)
DDRA_100M_P: length 91.1
  TOP w0.095: v3(75.22,189.99) 75.53,189.68 arc(75.62,189.61) 75.73,189.59 76.27,189.59 arc(76.6,189.73) RB39.1
  S5 w0.108: v3(73.5,161.06) 73.21,161.35 72.98,161.35 arc(72.73,161.4) 72.51,161.55 70.69,163.37 arc(70.32,163.91) 70.2,164.55 70.2,173.19 arc(70.36,174.04) 70.84,174.75 71.63,175.54 arc(72.05,176.18) 72.2,176.93 72.2,187.82 arc(72.28,188.23) 72.52,188.57 73.15,189.2 73.15,189.2 arc(73.63,189.49) 74.18,189.59 74.83,189.59 arc(75.11,189.71) v3(75.22,189.99)
  BOTTOM w0.095: CB343.1 30.84,138.49 arc(30.95,138.65) 30.98,138.83 30.98,138.86 arc(31.01,139) 31.09,139.11 31.29,139.32 31.29,139.5 31.49,139.71 31.68,139.71 31.88,139.91 31.88,140.1 32.08,140.3 32.27,140.3 32.47,140.5 32.47,140.69 32.68,140.89 32.87,140.89 34.42,142.44 arc(36.84,144.06) 39.7,144.63 50.05,144.63 arc(55.49,145.71) 60.09,148.79 61.88,150.57 arc(64.77,152.51) 68.19,153.18 69.78,153.18 arc(71.01,153.43) 72.05,154.12 73.65,155.72 arc(74.27,156.65) 74.49,157.75 74.49,160.83 arc(74.45,161.02) 74.35,161.18 74.26,161.26 arc(74.15,161.34) 74.01,161.36 73.9,161.36 arc(73.81,161.34) 73.73,161.29 v3(73.5,161.06)
DDRA_100M_REFCLK_N: length 13.7
  TOP w0.095: v4(33.7,127.65) U40.AK24
  BOTTOM w0.095: CB344.2 31.23,136.96 31.23,136.78 31.53,136.47 RB145.1 31.53,135.99 31.13,135.58 31.13,135.25 31.31,135.08 31.31,130.57 arc(31.4,130.35) 31.63,130.25 31.83,130.25 arc(32.17,130.11) 32.31,129.77 32.31,127.59 arc(32.41,127.36) 32.64,127.26 33.12,127.26 33.28,127.1 33.56,127.1 33.7,127.25 v4(33.7,127.65)
DDRA_100M_REFCLK_P: length 13.7
  TOP w0.095: v4(33.7,126.65) U40.AJ24
  BOTTOM w0.095: CB343.2 31,136.88 31,136.72 30.63,136.35 RB145.2 30.63,135.87 30.9,135.59 30.9,135.16 31.08,134.98 31.08,130.57 arc(31.24,130.19) 31.63,130.03 31.83,130.03 arc(32.01,129.95) 32.08,129.77 32.08,127.59 arc(32.25,127.2) 32.64,127.03 33.03,127.03 33.18,126.88 33.47,126.88 v4(33.7,126.65)
DDRA_A0: length 84.5
  TOP w0.127: v4(36.7,134.65) U40.AU21
  S12 w0.127: v4(21.63,169.49) 21.63,169.8 21.75,169.92 21.91,169.92 22.23,169.61 22.44,169.61 22.57,169.73 22.57,170 22.7,170.13 23.2,170.13 23.33,170 23.33,169.73 23.46,169.61 24.08,169.61 24.37,169.9 30.96,169.9 v4(31.37,169.49)
  S14 w0.127: v4(31.37,169.49) 31.76,169.49 31.91,169.34 32.45,169.34 34.3,167.49 34.66,167.49 34.97,167.18 34.97,166.93 35.35,166.55 38.62,166.55 39.28,165.88 39.28,163.44 39.3,163.44 39.3,161.15 39.3,161.15 39.3,157.06 39.75,156.6 41.68,156.6 42.04,156.25 42.04,154.4 41.8,154.16 40.74,154.16 40.54,153.96 40.54,153.65 40.79,153.4 41.8,153.4 42.03,153.18 42.03,152.86 41.8,152.64 40.47,152.64 40.25,152.41 40.25,152.1 40.47,151.87 41.8,151.87 42.03,151.65 42.03,151.34 41.8,151.11 40.32,151.11 40.1,150.89 40.1,150.57 40.32,150.35 42.97,150.35 43.2,150.13 43.2,149.81 42.97,149.59 40.47,149.59 40.25,149.37 40.25,149.05 40.47,148.83 42.64,148.83 42.87,148.6 42.87,148.29 42.64,148.06 40.47,148.06 40.25,147.84 40.25,147.53 40.47,147.3 42.4,147.3 42.74,146.96 42.74,146.64 36.83,140.73 36.83,134.78 v4(36.7,134.65)
  BOTTOM w0.127: v4(21.63,169.49) 22.06,169.93 22.06,171.3 20.92,172.44 RB50.2
  BOTTOM w0.13: UB5.P3 v4(21.63,169.49) ; UB6.P3 v4(31.37,169.49)
DDRA_A1: length 83.7
  TOP w0.127: v4(36.7,127.65) U40.AK21
  S7 w0.127: v4(24.82,169.49) 25.49,169.88 31.75,169.88 v4(34.56,169.49)
  S14 w0.127: v4(36.7,127.65) 36.21,127.16 31.63,127.16 31.21,127.58 31.21,128.01 30.18,129.04 29.65,129.04 29.15,129.54 29.15,129.99 28.99,130.15 28.63,130.15 28.09,130.7 28.09,130.98 27.91,131.16 27.37,131.16 27.19,131.34 27.19,134.71 21.23,140.68 21.23,152.53 27.07,158.38 27.07,158.95 27.7,159.58 27.7,169.87 29.47,171.65 32.41,171.65 34.56,169.5 v4(34.56,169.49)
  BOTTOM w0.127: UB5.P7 24.03,169.48 24.03,170.93 25.75,172.65 26.07,172.65 27.02,173.6 RB56.2
  BOTTOM w0.13: v4(24.82,169.49) UB5.P7 ; UB6.P7 v4(34.56,169.49)
DDRA_A2: length 83.8
  TOP w0.127: v4(21.64,170.3) 22.06,170.73 22.06,172.95 23.28,174.16 23.28,174.17 23.99,174.89 R142.2 ; v4(37.7,133.65) U40.AT20
  S12 w0.127: v4(31.37,170.29) 31.37,170.5 31.17,170.7 23.12,170.7 22.83,170.99 22.32,170.99 22.03,170.7 22.03,170.7 v4(21.64,170.3)
  S14 w0.127: v4(31.37,170.29) 31.48,170.41 32.93,170.41 34.24,169.1 36.25,169.1 36.49,168.86 37.98,168.86 38.2,169.08 38.2,169.93 38.42,170.15 38.74,170.15 38.96,169.93 38.96,168.75 39.19,168.53 39.59,168.53 39.77,168.71 39.77,169.82 39.97,170.03 40.35,170.03 40.55,169.82 40.55,167.84 40.53,167.82 40.53,167.41 41.63,166.3 41.63,160.33 44.77,157.19 44.77,146.89 43.98,146.1 43.98,145.84 44.77,145.05 44.77,144.76 44.48,144.47 44.27,144.47 43.48,145.26 43.22,145.26 42.89,144.93 42.89,144.77 44.09,143.58 44.09,143.37 43.74,143.02 43.56,143.02 42.37,144.22 42.13,144.22 41.82,143.91 41.82,143.69 43.02,142.49 43.02,142.31 42.69,141.98 42.45,141.98 41.54,142.89 41.17,142.89 37.85,139.57 37.85,135.23 38.2,134.88 38.2,133.12 38.09,133.02 37.83,133.02 37.56,133.29 37.56,133.51 v4(37.7,133.65)
  BOTTOM w0.13: UB5.R3 v4(21.64,170.3) ; UB6.R3 v4(31.37,170.29)
DDRA_A3: length 84.3
  TOP w0.127: U40.AR25 v4(32.7,132.65)
  S7 w0.127: v4(34.56,168.69) 31.36,169.1 25.54,169.1 v4(24.82,168.69)
  S16 w0.127: v4(32.7,132.65) 32.69,132.65 32.37,132.32 32.21,132.32 32.1,132.43 32.1,135.02 31.69,135.43 31.69,136.39 25.42,142.67 25.42,143.41 25.24,143.58 22.84,143.58 22.66,143.76 22.66,144.07 22.86,144.27 23.92,144.27 24.04,144.4 24.04,144.83 23.92,144.96 22.8,144.96 22.66,145.09 22.66,145.69 22.88,145.91 25.25,145.91 25.42,146.07 25.42,146.5 25.25,146.67 22.78,146.67 22.66,146.8 22.66,147.28 22.82,147.43 25.15,147.43 25.26,147.55 25.26,148.03 25.1,148.2 22.88,148.2 22.66,148.42 22.66,152.41 26.8,156.55 31.8,156.55 32.96,157.71 32.96,166.1 33.09,166.23 33.09,167.51 33.49,167.92 33.49,168.09 33.09,168.5 33.09,168.7 33.29,168.91 33.64,168.91 34.22,168.32 34.48,168.32 34.56,168.4 v4(34.56,168.69)
  BOTTOM w0.127: UB5.N7 23.71,169 23.71,172.13 26,174.42 RB55.2
  BOTTOM w0.13: UB6.N7 v4(34.56,168.69) ; v4(24.82,168.69) UB5.N7
DDRA_A4: length 84.3
  TOP w0.127: v4(35.7,134.65) U40.AU22
  S12 w0.127: v4(21.64,168.69) 22.34,168 22.84,168 23.13,168.29 30.97,168.29 v4(31.37,168.69)
  S14 w0.127: v4(35.7,134.65) 35.7,142.97 36.05,143.32 37.97,143.32 38.19,143.55 38.19,143.86 37.97,144.08 36,144.08 35.78,144.31 35.78,144.62 36,144.85 39.01,144.85 39.23,145.07 39.23,145.38 39.01,145.61 36.02,145.61 35.8,145.82 35.8,146.2 35.97,146.37 39.01,146.37 39.23,146.59 39.23,146.91 39.01,147.13 36.09,147.13 35.91,147.32 35.91,147.62 36.18,147.89 38.51,147.89 38.62,148 38.62,148.46 38.43,148.66 36.7,148.66 36.54,148.82 36.54,157.96 38.17,159.58 38.17,159.89 38.04,160.02 37.51,160.02 37.33,160.2 37.33,160.4 37.53,160.6 38.01,160.6 38.17,160.75 38.17,161.08 38,161.25 36.45,161.25 36.22,161.48 36.22,161.79 36.45,162.01 38,162.01 38.17,162.18 38.17,162.53 37.96,162.74 36.44,162.74 36.26,162.91 36.26,163.55 35.5,164.31 34.38,164.31 34.08,164.61 34.08,165.97 33.24,166.81 33.24,167.11 31.66,168.69 v4(31.37,168.69)
  BOTTOM w0.127: RB51.2 21.94,172.24 22.29,171.88 22.29,169.35 22.09,169.15 22.09,169.14 v4(21.64,168.69)
  BOTTOM w0.13: UB6.N3 v4(31.37,168.69) ; UB5.N3 21.63,168.69 v4(21.64,168.69)
DDRA_A5: length 83
  TOP w0.127: R144.2 27.04,173.66 24.91,171.52 24.91,170.79 25.23,170.46 25.23,169.88 v4(25.63,169.49) ; v4(34.7,129.65) U40.AM23
  S9 w0.127: v4(35.37,169.49) 34.97,169.09 25.94,169.09 25.63,169.41 v4(25.63,169.49)
  S16 w0.127: v4(34.7,129.65) 34.7,130.36 35.45,131.11 37.86,131.11 38.24,131.49 38.24,134.66 37.75,135.15 37.66,135.15 37.35,135.46 37.35,136.36 36.83,136.88 36.83,140.42 36.64,140.61 35.86,140.61 35.68,140.8 35.68,141.21 35.89,141.42 36.64,141.42 36.83,141.61 36.83,142.02 36.59,142.26 34.59,142.26 34.36,142.49 34.36,142.94 34.58,143.17 36.44,143.17 36.67,143.39 36.67,143.71 36.44,143.93 34.58,143.93 34.36,144.15 34.36,151.62 34.61,151.88 34.61,152 34.16,152.44 34.16,152.79 34.36,152.98 34.7,152.98 35.11,152.58 35.3,152.58 35.65,152.92 35.65,153.11 35.04,153.72 35.04,153.93 35.34,154.23 35.61,154.23 36.2,153.64 36.37,153.64 36.72,153.99 36.72,154.2 36.11,154.81 36.11,154.99 36.43,155.32 36.68,155.32 37.29,154.71 37.44,154.71 37.81,155.08 37.81,155.26 37.4,155.68 37.4,155.9 37.68,156.18 37.97,156.18 38.15,156.01 38.73,156.01 40.69,157.97 40.69,166.24 37.91,169.03 35.83,169.03 v4(35.37,169.49)
  BOTTOM w0.127: UB5.P8 v4(25.63,169.49) ; 35.4,169.46 v4(35.37,169.49)
  BOTTOM w0.13: UB6.P8 35.4,169.46
DDRA_A6: length 84
  TOP w0.127: v4(37.7,132.65) U40.AR20 ; R141.2 22.85,174.88 21.23,173.25 21.23,169.9 20.82,169.5 v4(20.82,169.49)
  S14 w0.127: v4(37.7,132.65) 37.18,133.16 37.18,135.07 37.34,135.23 37.34,140.3 43.96,146.92 43.96,150.7 43.73,150.92 42.78,150.92 42.56,151.15 42.56,151.46 42.78,151.68 44.04,151.68 44.26,151.91 44.26,152.22 44.04,152.45 42.78,152.45 42.56,152.67 42.56,152.98 42.78,153.21 44.04,153.21 44.26,153.43 44.26,153.75 44.04,153.97 43.06,153.97 42.82,154.22 42.82,154.53 43.01,154.73 44.04,154.73 44.26,154.96 44.26,155.27 44.04,155.49 42.78,155.49 42.56,155.72 42.56,156.03 42.78,156.26 44.16,156.26 44.26,156.36 44.26,156.98 43.8,157.44 43.42,157.44 42.77,156.79 42.38,156.79 42.05,157.12 42.05,157.41 42.78,158.13 42.78,158.46 42.38,158.86 42.06,158.86 41.31,158.11 40.99,158.11 40.77,158.33 40.77,158.65 41.52,159.4 41.52,159.72 41.13,160.12 41.13,165.87 38.7,168.3 34.31,168.3 32.71,169.9 31.53,169.9 31.2,169.9 31.2,169.9 30.97,169.9 v4(30.57,169.49)
  S16 w0.127: v4(20.82,169.49) 21.21,169.1 30.17,169.1 v4(30.57,169.49)
  BOTTOM w0.13: UB6.P2 v4(30.57,169.49) ; UB5.P2 v4(20.82,169.49)
DDRA_A7: length 82.4
  TOP w0.127: v4(25.63,170.29) 25.63,170.45 25.19,170.89 25.19,171.27 25.8,171.88 26.28,171.88 28.06,173.66 R145.2 ; v4(35.7,129.65) U40.AM22
  S9 w0.127: v4(25.63,170.29) 25.66,170.29 26.05,169.9 26.29,169.9 29.6,169.9 29.6,169.9 29.93,169.9 30.4,169.9 30.43,169.88 30.73,169.88 30.74,169.87 31.19,169.87 31.2,169.88 31.53,169.88 31.54,169.87 34.38,169.87 34.41,169.9 34.97,169.9 v4(35.36,170.29)
  S16 w0.127: v4(35.36,170.29) 35.59,170.07 37.79,170.07 41.2,166.65 41.2,157.76 35.02,151.57 35.02,149.61 35.24,149.39 36.3,149.39 36.44,149.25 36.44,148.74 36.33,148.63 35.01,148.63 34.86,148.49 34.86,147.98 34.98,147.87 37.24,147.87 37.34,147.76 37.34,147.2 37.24,147.1 35.01,147.1 34.86,146.96 34.86,146.5 35.03,146.34 37.19,146.34 37.34,146.19 37.34,145.73 37.19,145.58 35.01,145.58 34.86,145.44 34.86,144.96 35,144.82 37.06,144.82 37.34,144.54 37.34,137.66 37.86,137.14 37.86,135.36 38.56,134.67 38.56,130.52 38.29,130.25 36.3,130.25 v4(35.7,129.65)
  BOTTOM w0.13: UB5.R8 v4(25.63,170.29) ; UB6.R8 v4(35.36,170.29)
DDRA_A8: length 83
  TOP w0.127: v4(36.7,130.65) U40.AN21 ; R140.2 21.91,174.7 20.41,173.2 20.41,170.71 v4(20.83,170.29)
  S7 w0.127: v4(20.83,170.29) 21.5,170.69 29.86,170.69 v4(30.57,170.29)
  S14 w0.127: v4(30.57,170.29) 30.43,170.29 30.03,169.88 29.14,169.88 28.86,169.61 28.86,158.73 28.09,157.95 28.08,157.95 24.98,154.86 24.98,154.15 24.84,154.01 24.5,154.01 24.25,153.76 24.25,153.44 24.45,153.25 24.8,153.25 24.98,153.06 24.98,152.62 24.84,152.48 23.79,152.48 23.56,152.26 23.56,151.95 23.79,151.72 24.76,151.72 24.98,151.5 24.98,151.18 24.76,150.96 23.86,150.96 23.64,150.74 23.64,150.42 23.86,150.2 24.76,150.2 24.98,149.97 24.98,149.66 24.76,149.44 23.86,149.44 23.64,149.21 23.64,148.9 23.86,148.67 24.85,148.67 25.07,148.45 25.07,148.14 24.85,147.91 23.66,147.91 23.43,147.69 23.43,147.37 23.66,147.15 24.76,147.15 24.98,146.93 24.98,146.56 24.83,146.4 23.73,146.4 23.64,146.31 23.64,145.82 23.79,145.67 24.78,145.67 24.98,145.46 24.98,143.82 24.76,143.6 24.08,143.6 23.86,143.38 23.86,143.06 24.08,142.84 24.76,142.84 24.98,142.62 24.98,138.92 29.15,134.75 29.15,132.48 29.53,132.1 29.89,132.1 30.29,131.7 30.29,131.39 30.57,131.11 36.23,131.11 v4(36.7,130.65)
  BOTTOM w0.13: UB5.R2 v4(20.83,170.29) ; UB6.R2 v4(30.57,170.29)
DDRA_A9: length 82.6
  TOP w0.127: v4(36.7,128.65) U40.AL21
  S9 w0.127: v4(34.54,170.3) 34.16,170.69 25.47,170.69 v4(24.82,170.29)
  S16 w0.127: v4(34.54,170.3) 34.95,170.71 37.86,170.71 41.71,166.86 41.71,157.55 40.62,156.46 40.62,156.45 40.19,156.02 40.19,155.84 40.77,155.26 40.77,155.08 40.41,154.72 40.23,154.72 39.65,155.3 39.47,155.3 39.34,155.17 39.33,155.17 38.57,154.41 38.57,152.63 38.29,152.34 36.51,152.34 36.28,152.12 36.28,151.8 36.51,151.58 38.58,151.58 38.79,151.36 38.79,151.08 38.53,150.82 35.7,150.82 35.53,150.65 35.53,150.18 35.66,150.06 38.4,150.06 38.59,149.87 38.59,149.44 38.44,149.29 37.09,149.29 36.95,149.15 36.95,148.66 37.08,148.53 37.66,148.53 37.85,148.35 37.85,137.88 38.37,137.35 38.37,135.46 38.79,135.04 38.79,129.9 38.09,129.21 37.26,129.21 v4(36.7,128.65)
  BOTTOM w0.127: v4(24.82,170.29) 24.82,171.01 25.96,172.15 26.28,172.15 28.03,173.9 RB57.2
  BOTTOM w0.13: UB6.R7 34.94,169.89 34.56,170.28 34.56,170.28 v4(34.54,170.3) ; UB5.R7 v4(24.82,170.29)
DDRA_A10: length 85.5
  TOP w0.127: v4(33.7,134.65) U40.AU24
  S12 w0.127: v4(31.37,167.89) 30.97,167.49 23.31,167.49 23.18,167.36 22.18,167.36 v4(21.63,167.9)
  S14 w0.127: v4(33.7,134.65) 33.7,135.02 33.76,135.09 34.37,135.09 34.66,135.38 34.66,135.68 34.51,135.84 33.79,135.84 33.57,136.05 33.57,136.38 33.79,136.6 34.48,136.6 34.66,136.78 34.66,137.21 34.51,137.36 33.92,137.36 33.7,137.58 33.7,137.9 33.92,138.12 34.48,138.12 34.66,138.3 34.66,138.71 34.48,138.88 33.92,138.88 33.7,139.11 33.7,139.47 33.87,139.65 34.51,139.65 34.66,139.8 34.66,140.21 34.46,140.41 33.69,140.41 33.47,140.63 33.47,140.95 33.69,141.17 34.51,141.17 34.66,141.32 34.66,141.76 34.48,141.93 33.63,141.93 33.4,142.16 33.4,142.47 33.63,142.69 34.48,142.69 34.66,142.87 34.66,143.25 34.46,143.46 32.81,143.46 32.68,143.58 32.68,144.07 32.83,144.22 34.48,144.22 34.66,144.4 34.66,144.8 34.48,144.98 32.98,144.98 32.76,145.2 32.76,145.52 32.98,145.74 34.56,145.74 34.66,145.84 34.66,146.35 34.51,146.5 33.23,146.5 33.01,146.73 33.01,147.04 33.23,147.27 34.53,147.27 34.66,147.39 34.66,147.9 34.53,148.03 32.9,148.03 32.68,148.25 32.68,148.69 32.9,148.9 35.05,148.9 35.27,149.12 35.27,149.53 35.07,149.73 33.04,149.73 32.81,149.96 32.81,158.32 32.99,158.5 33.94,158.5 34.17,158.72 34.17,159.04 33.94,159.26 32.45,159.26 32.32,159.38 32.32,159.89 32.46,160.02 33.85,160.02 34.01,160.18 34.01,160.6 33.83,160.78 32.73,160.78 32.5,161.01 32.5,161.39 32.73,161.61 33.06,161.61 33.21,161.77 33.21,162.33 32.57,162.98 32.57,164.95 31.77,165.74 31.77,167.49 v4(31.37,167.89)
  BOTTOM w0.127: RB52.2 22.95,174.52 22.62,174.19 22.62,168.89 v4(21.63,167.9)
  BOTTOM w0.13: UB5.M3 v4(21.63,167.9) ; UB6.M3 v4(31.37,167.89)
DDRA_A11: length 82.1
  TOP w0.127: v4(37.7,130.65) U40.AN20
  S7 w0.127: v4(30.57,171.09) 30.13,171.53 21.45,171.53 v4(20.82,171.12)
  S14 w0.127: v4(30.57,171.09) 30.16,170.69 29.23,170.69 28.36,169.82 28.36,158.94 27.88,158.46 27.87,158.46 22.83,153.42 22.83,146.57 22.6,146.35 22.49,146.35 22.24,146.1 22.24,145.78 22.44,145.58 23.06,145.58 23.28,145.36 23.28,145.01 23.1,144.82 22.16,144.82 21.94,144.6 21.94,144.28 22.16,144.06 22.6,144.06 22.83,143.84 22.83,143.52 22.6,143.3 22.16,143.3 21.94,143.07 21.94,142.76 22.16,142.54 22.81,142.54 23.03,142.31 23.03,142 22.81,141.77 21.96,141.77 21.73,141.55 21.73,141.24 21.96,141.01 22.6,141.01 22.83,140.79 22.83,139.79 27.37,135.25 27.65,135.25 28.18,134.72 28.18,131.42 28.46,131.14 28.95,131.14 29.2,130.88 29.2,130.45 29.45,130.2 29.96,130.2 29.96,130.2 30.17,129.99 30.17,129.38 30.44,129.11 30.95,129.11 31.18,129.33 31.18,130.05 31.34,130.2 34.14,130.2 34.2,130.15 36.87,130.15 37.09,130.37 37.09,131.1 37.23,131.24 37.56,131.24 37.7,131.1 v4(37.7,130.65)
  BOTTOM w0.127: RB48.2 18.89,173.05 v4(20.82,171.12) 20.8,171.12 20.43,170.74 UB5.T2
  BOTTOM w0.13: UB6.T2 v4(30.57,171.09)
DDRA_A12: length 85.2
  TOP w0.127: v4(36.7,131.65) U40.AP21
  S7 w0.127: v4(24.82,167.89) 25.5,167.49 31.46,167.49 v4(34.56,167.89)
  S16 w0.127: v4(36.7,131.65) 36.95,131.65 37.2,131.9 37.2,134.84 36.85,135.19 36.85,136.15 36.15,136.84 36.15,139.6 33.65,142.1 33.65,146.89 33.43,147.11 31.41,147.11 31.18,147.34 31.18,147.65 31.41,147.88 33.43,147.88 33.65,148.1 33.65,148.41 33.43,148.64 31.41,148.64 31.18,148.86 31.18,149.18 31.41,149.4 33.43,149.4 33.65,149.62 33.65,149.94 33.43,150.16 31.35,150.16 31.13,150.39 31.13,150.7 31.35,150.92 33.65,150.92 33.8,151.08 33.8,151.53 33.65,151.69 31.43,151.69 31.21,151.91 31.21,152.22 31.43,152.45 33.43,152.45 33.65,152.67 33.65,153.26 37.12,156.72 38.42,156.72 39.3,157.6 39.3,160.89 39.44,161.03 40.05,161.03 40.19,161.17 40.19,161.68 40.07,161.8 39.46,161.8 39.3,161.96 39.3,166.13 37.13,168.3 34.97,168.3 v4(34.56,167.89)
  BOTTOM w0.127: RB54.2 24.98,174.12 23.38,172.52 23.38,168.53 UB5.M7
  BOTTOM w0.13: UB6.M7 34.57,167.89 v4(34.56,167.89) ; UB5.M7 v4(24.82,167.89)
DDRA_A13: length 81.5
  TOP w0.127: v4(35.7,128.65) U40.AL22
  S9 w0.127: v4(25.63,171.09) 26.31,171.49 35.08,171.49 v4(35.42,171.14)
  S16 w0.127: v4(35.42,171.14) 36.24,171.14 36.46,171.36 37.93,171.36 42.22,167.07 42.22,164.41 42.44,164.19 45.58,164.19 45.82,163.95 45.82,163.63 45.61,163.42 42.44,163.42 42.22,163.2 42.22,159.03 42.44,158.81 44.62,158.81 44.84,158.59 44.84,158.27 44.62,158.05 42.44,158.05 42.22,157.82 42.22,157.33 41.63,156.75 41.63,151.76 38.36,148.49 38.36,138.09 38.88,137.56 38.88,135.46 39.02,135.32 39.02,129.19 37.89,128.06 36.28,128.06 v4(35.7,128.65)
  BOTTOM w0.127: v4(35.42,171.14) 35.77,170.8 UB6.T8 ; v4(25.63,171.09) 26.13,171.6 26.48,171.6 29.05,174.17 RB58.2
  BOTTOM w0.13: UB5.T8 v4(25.63,171.09)
DDRA_ACT_N: length 85.6
  TOP w0.127: U40.AT24 34.2,133.2 v4(33.7,133.7) ; v4(21.67,167.09) 21.98,167.69 22.09,168.03 22.23,168.77 22.32,169.22 22.32,169.9 22.6,170.51 23.61,171.52 24.38,172.57 R163.2
  S7 w0.127: v4(31.37,167.09) 30.97,166.7 25.46,166.7 22.06,166.7 v4(21.67,167.09)
  S14 w0.127: v4(33.7,133.7) 33.7,133.98 33.26,134.42 33.26,135.46 32.73,136 31.88,136 31.66,136.22 31.66,136.6 31.79,136.73 33.02,136.73 33.17,136.88 33.17,137.23 33.02,137.38 31.57,137.38 31.39,137.56 31.39,137.94 31.58,138.14 33.01,138.14 33.23,138.36 33.23,138.68 33.01,138.9 31.5,138.9 31.33,139.06 31.33,139.49 31.5,139.66 32.77,139.66 32.94,139.83 32.94,140.28 32.73,140.48 32.05,140.48 31.83,140.7 31.83,141.2 32.03,141.4 32.59,141.4 32.79,141.6 32.79,141.98 32.6,142.17 30.96,142.17 30.75,142.38 30.75,142.82 30.95,143.02 31.88,143.02 32.05,143.18 32.05,143.61 31.88,143.78 30.17,143.78 30.05,143.9 30.05,144.36 30.23,144.54 31.88,144.54 32.06,144.71 32.06,145.08 31.84,145.3 30.15,145.3 30.05,145.4 30.05,145.93 30.19,146.06 31.93,146.06 32.06,146.19 32.06,146.59 31.83,146.83 30.14,146.83 30.04,146.93 30.04,147.31 30.31,147.59 31.83,147.59 32.06,147.81 32.06,148.13 31.83,148.35 29.5,148.35 29.35,148.5 29.35,148.94 29.53,149.12 32,149.12 32.17,149.29 32.17,149.93 32.07,150.04 31.41,150.04 31.26,150.19 31.26,150.45 31.46,150.65 31.97,150.65 32.17,150.85 32.17,158.32 31.77,158.72 31.77,165.04 31.37,165.45 v4(31.37,167.09)
  BOTTOM w0.13: v4(21.67,167.09) 21.65,167.09 21.25,166.69 UB5.L3 ; UB6.L3 v4(31.37,167.09)
DDRA_ALERT0: length 84.5
  TOP w0.127: v4(30.7,133.65) U40.AT27
  S16 w0.127: v4(30.7,133.65) 30.85,133.49 30.85,133.3 30.65,133.09 28.41,133.09 28.2,133.31 28.2,134.7 26.73,136.17 24.97,136.17 20.37,140.76 20.37,145.3 19.98,145.69 19.98,155.57 20.62,156.21 22.86,156.21 23.03,156.38 23.03,156.79 22.9,156.92 21.56,156.92 21.43,157.05 21.43,157.55 21.58,157.71 23.46,157.71 23.59,157.83 23.59,158.28 23.46,158.41 21.4,158.41 21.21,158.61 21.21,158.99 21.4,159.19 23.62,159.19 23.84,159.41 23.84,159.73 23.62,159.95 22.26,159.95 22.04,160.17 22.04,160.54 22.26,160.77 23.67,160.77 23.89,160.99 23.89,161.3 23.67,161.53 22.21,161.53 21.99,161.75 21.99,162.07 22.21,162.29 23.72,162.29 23.94,162.51 23.94,162.83 23.72,163.05 22.88,163.05 22.66,163.27 22.66,163.59 22.88,163.81 23.3,163.81 23.52,164.03 23.52,164.4 23.34,164.58 22.74,164.58 22.63,164.68 22.63,165.53 22.4,165.77 20.02,165.77 19.6,166.19 19.6,170.91 20.23,171.55 22.8,171.55 24.46,169.89 26.03,169.89 v4(26.42,169.49)
  BOTTOM w0.127: TPB43.1 30.45,174.66 29.44,173.66 29.44,171.85 28.64,171.04 27.98,171.04 v4(26.42,169.49) UB5.P9
DDRA_ALERT1: length 72
  TOP w0.127: U40.AM25 v4(32.7,129.65)
  S14 w0.127: v4(36.97,169.49) 36.97,170.58 37.52,171.13 40.19,171.13 41.19,170.13 41.19,167.65 42.27,166.57 42.27,164.47 42.4,164.34 43.68,164.34 43.81,164.21 43.81,163.7 43.68,163.58 42.4,163.58 42.27,163.45 42.27,162.14 44.26,160.14 44.26,158.59 45.66,157.2 45.66,144.05 42.96,141.35 40.53,141.35 38.48,139.31 38.48,135.06 38.55,135 38.55,128.31 38.32,128.09 33.39,128.09 33.24,128.24 33.24,128.72 32.7,129.27 v4(32.7,129.65)
  BOTTOM w0.127: v4(36.97,169.49) UB6.P9 37.48,169.09 37.68,168.88 39.97,168.88 40.22,168.63 42.51,168.63 TPB44.1
DDRA_BA0: length 82.9
  TOP w0.127: v4(36.7,133.65) U40.AT21
  S14 w0.127: v4(30.57,168.69) 30.57,168.88 30.78,169.09 31.74,169.09 32.02,168.81 32.27,168.81 33.75,167.33 33.75,167.02 34.88,165.89 38.29,165.89 38.67,165.51 38.67,164.8 38.45,164.58 37.58,164.58 37.35,164.35 37.35,164.04 37.58,163.81 38.45,163.81 38.67,163.59 38.67,159.37 37.3,158 37.3,157.2 37.3,157.2 37.3,156.07 37.53,155.84 41.19,155.84 41.42,155.62 41.42,155.3 41.19,155.08 37.56,155.08 37.34,154.86 37.34,154.17 37.56,153.95 38.25,153.95 38.45,153.75 38.45,153.43 38.2,153.18 37.27,153.18 37.05,152.96 37.05,152.65 37.27,152.42 38.76,152.42 38.99,152.2 38.99,151.88 38.76,151.66 37.27,151.66 37.05,151.44 37.05,151.08 37.23,150.9 38.85,150.9 39.07,150.68 39.07,150.31 38.9,150.14 37.23,150.14 37.07,149.98 37.07,149.53 37.23,149.37 39.54,149.37 39.74,149.17 39.74,144.36 37.41,142.02 37.39,142.02 36.21,140.84 36.21,140.43 36.23,140.41 36.23,133.77 36.35,133.65 v4(36.7,133.65)
  S16 w0.127: v4(30.57,168.69) 30.17,168.3 21.23,168.3 v4(20.83,168.69)
  BOTTOM w0.127: RB101.2 16.2,168.12 16.48,168.4 18.3,168.4 18.6,168.7 20.02,168.7 UB5.N2 v4(20.83,168.69)
  BOTTOM w0.13: UB6.N2 v4(30.57,168.69)
DDRA_BA1: length 84.3
  TOP w0.127: R146.2 29.18,174.14 26.58,171.55 26.23,171.55 26.03,171.35 26.03,169.09 v4(25.63,168.69) ; v4(31.7,133.65) U40.AT26
  S9 w0.127: v4(25.63,168.69) 26.03,168.29 34.95,168.29 v4(35.36,168.69)
  S16 w0.127: v4(31.7,133.65) 31.7,133.38 31.59,133.27 31.36,133.27 31.23,133.4 31.23,135 31.08,135.15 30.42,135.15 30.24,135.33 30.24,135.5 30.88,136.13 30.88,136.45 30.65,136.67 30.34,136.67 29.7,136.03 29.38,136.03 28.51,136.9 28.51,137.22 29.07,137.78 29.07,138 28.82,138.25 28.47,138.25 27.97,137.76 27.66,137.76 27.46,137.95 27.46,138.27 28.13,138.94 28.13,139.23 27.92,139.44 27.56,139.44 26.9,138.78 26.63,138.78 26.38,139.03 26.38,139.35 27.04,140 27.04,140.32 26.82,140.54 26.5,140.54 25.85,139.89 25.53,139.89 25.31,140.11 25.31,140.43 25.94,141.06 25.94,141.38 25.72,141.6 25.41,141.6 24.8,140.99 24.42,140.99 23.61,141.8 23.61,142.09 24.12,142.59 24.12,142.85 23.92,143.05 23.61,143.05 23.12,142.55 22.86,142.55 22.15,143.26 22.15,152.77 26.44,157.06 31.59,157.06 32.45,157.92 32.45,163.27 32.58,163.4 32.58,169.62 32.79,169.83 33.53,169.83 34.28,169.09 34.97,169.09 v4(35.36,168.69)
  BOTTOM w0.13: UB5.N8 v4(25.63,168.69) ; UB6.N8 v4(35.36,168.69)
DDRA_BG0: length 85.9
  TOP w0.127: v4(20.82,167.89) 20.82,167.9 21.25,168.32 21.25,168.86 21.48,169.09 21.78,169.09 22.04,169.34 22.04,169.9 22.39,170.71 22.85,171.17 R143.2 ; v4(34.7,133.65) U40.AT23
  S7 w0.127: v4(30.57,167.89) 29.88,168.3 21.45,168.3 v4(20.82,167.89)
  S14 w0.127: v4(34.7,133.65) 35.17,134.12 35.17,148.05 36.03,148.92 36.03,150.31 35.96,150.39 33.62,150.39 33.52,150.49 33.52,151.03 33.65,151.15 35.88,151.15 36.03,151.31 36.03,151.84 35.91,151.96 33.45,151.96 33.32,152.09 33.32,152.6 33.44,152.72 35.81,152.72 36.03,152.95 36.03,153.4 35.81,153.62 33.44,153.62 33.32,153.74 33.32,154.28 33.42,154.39 35.81,154.39 36.03,154.61 36.03,154.92 35.81,155.15 33.46,155.15 33.32,155.29 33.32,155.75 33.47,155.91 35.81,155.91 36.03,156.13 36.03,156.45 35.81,156.67 33.54,156.67 33.32,156.9 33.32,157.21 33.54,157.43 35.91,157.43 36.03,157.55 36.03,158.14 36.57,158.67 36.57,160.6 36.08,161.08 34.25,161.08 33.92,161.41 33.92,162.73 33.69,162.95 33.46,162.95 33.26,163.15 33.26,163.46 33.51,163.71 33.69,163.71 33.83,163.85 33.83,164.14 33.57,164.4 33.57,165.76 32.73,166.6 32.73,166.9 31.89,167.75 31.89,167.94 31.53,168.3 31.2,168.3 31.2,168.3 30.97,168.3 v4(30.57,167.89)
  BOTTOM w0.13: UB5.M2 v4(20.82,167.89) ; UB6.M2 v4(30.57,167.89)
DDRA_CAS_N: length 78.8
  TOP w0.127: U40.AU25 v4(32.7,134.65) ; R226.2 24.22,169.72 24.22,169.54 24.67,169.09 25.06,169.09 25.22,168.92 25.22,168.29 v4(25.63,167.89)
  S9 w0.127: v4(35.37,167.89) 34.97,167.49 25.9,167.49 25.63,167.76 v4(25.63,167.89)
  S16 w0.127: v4(32.7,134.65) 32.7,135.21 32.2,135.71 32.2,136.6 29.76,139.04 29.76,139.36 30.11,139.71 30.11,140.13 29.94,140.31 29.63,140.31 29.22,139.89 28.91,139.89 28.68,140.12 28.68,140.43 29.71,141.46 29.71,141.62 29.34,141.98 29.15,141.98 28.14,140.97 27.83,140.97 25.92,142.88 25.92,144.22 25.76,144.38 25.17,144.38 25.04,144.52 25.04,145.01 25.17,145.15 25.7,145.15 25.92,145.37 25.92,148.74 25.78,148.89 23.29,148.89 23.17,149.01 23.17,149.54 23.28,149.65 25.75,149.65 25.97,149.87 25.97,150.19 25.75,150.41 23.54,150.41 23.4,150.56 23.4,151.04 23.53,151.17 25.79,151.17 25.92,151.31 25.92,151.84 25.83,151.94 24.25,151.94 24.03,152.16 24.03,152.42 24.3,152.7 25.7,152.7 25.92,152.92 25.92,153.24 25.7,153.46 25.36,153.46 25.14,153.68 25.14,154 25.36,154.22 25.79,154.22 25.92,154.35 25.92,154.91 27.05,156.04 32.01,156.04 33.47,157.5 33.47,166.14 33.76,166.44 33.76,167.19 34.07,167.5 34.98,167.5 v4(35.37,167.89)
  BOTTOM w0.13: UB6.M8 v4(35.37,167.89) ; UB5.M8 v4(25.63,167.89)
DDRA_CK_N: length 65
  TOP w0.095: U40.AP24 v4(33.7,131.65) ; R305.2 24.27,165.02 24.63,165.02 25.34,165.73 25.34,166.01 v4(25.63,166.29)
  S12 w0.108: v4(35.37,165.49) 35.23,165.49 34.84,165.88 34.36,165.88 34.26,165.78 26.13,165.78 v4(25.63,166.29)
  S16 w0.108: v4(35.37,165.49) 35.09,165.21 35.09,165.07 35.17,164.99 35.55,164.99 35.91,165.35 37.41,165.35 37.86,164.89 37.86,163.83 37.59,163.56 36.42,163.56 36.25,163.39 36.25,163.06 36.5,162.81 37.56,162.81 37.91,162.46 37.91,161.97 37.56,161.61 36.66,161.61 36.39,161.35 36.39,161.14 36.66,160.87 37.51,160.87 37.86,160.52 37.86,158.55 37.42,158.11 36.55,158.11 32.69,154.25 30.29,154.25 29.64,153.59 29.64,144.16 31.91,141.89 31.91,139.36 33.94,137.32 33.94,136.51 35.09,135.35 35.09,132.5 34.72,132.13 34.18,132.13 v4(33.7,131.65)
  BOTTOM w0.095: v4(35.37,165.49) 35.77,165.89 UB6.K8 ; v4(25.63,166.29) UB5.K8
DDRA_CK_P: length 64.5
  TOP w0.095: U40.AP25 v4(32.7,131.65) ; R292.2 24.27,165.25 24.53,165.25 25.11,165.83 25.11,166.01 v4(24.82,166.29)
  S12 w0.108: v4(34.57,165.49) 34.51,165.55 26.04,165.55 25.71,165.88 25.36,165.88 24.96,166.29 v4(24.82,166.29)
  S16 w0.108: v4(34.57,165.49) 34.86,165.21 34.86,164.98 35.07,164.76 35.64,164.76 36,165.12 37.31,165.12 37.63,164.8 37.63,163.92 37.5,163.79 36.32,163.79 36.03,163.49 36.03,162.96 36.4,162.59 37.46,162.59 37.68,162.37 37.68,162.06 37.46,161.84 36.56,161.84 36.16,161.44 36.16,161.04 36.56,160.64 37.42,160.64 37.63,160.42 37.63,158.65 37.33,158.34 36.45,158.34 32.59,154.48 30.2,154.48 29.41,153.69 29.41,144.06 31.68,141.79 31.68,139.26 33.71,137.23 33.71,136.41 34.33,135.79 34.33,134.98 34.13,134.77 34.13,132.43 33.82,132.13 33.57,132.13 32.96,131.52 32.82,131.52 v4(32.7,131.65)
  BOTTOM w0.095: v4(34.57,165.49) UB6.K7 ; v4(24.82,166.29) UB5.K7
DDRA_CKE: length 83.9
  TOP w0.127: v4(33.7,128.65) U40.AL24 ; R274.2 22.75,166.72 22.67,166.72 21.76,165.81 21.17,165.81 20.82,166.16 v4(20.82,166.29)
  S7 w0.127: v4(30.57,166.29) 31.42,166.29 31.88,166.75 32.38,166.75 32.77,166.37 32.77,165.99 32.26,165.48 30.1,165.48 29.68,165.9 21.43,165.9 v4(20.82,166.29)
  S14 w0.127: v4(33.7,128.65) 34.18,129.13 37.76,129.13 38.14,129.51 38.14,131.93 37.94,132.13 36.47,132.13 36.24,132.36 36.24,132.86 35.93,133.17 34.2,133.17 34.11,133.27 33.39,133.27 33.21,133.45 33.21,133.83 32.94,134.1 32.53,134.1 32.09,134.55 32.09,134.81 31.44,135.46 31.06,135.46 30.23,136.29 30.23,136.61 30.65,137.03 30.65,137.67 29.72,138.6 29.72,138.81 30.65,139.74 30.65,140.99 30.14,141.5 30.14,142.21 29.42,142.94 29.42,145.46 28.95,145.92 28.45,145.92 28.07,146.3 28.07,146.56 28.72,147.21 28.72,148.68 28.72,149.5 28.98,149.75 30.25,149.75 30.35,149.86 30.35,150.37 30.23,150.5 28.7,150.5 28.58,150.62 28.58,151.13 28.73,151.28 31.01,151.28 31.19,151.46 31.19,151.94 30.99,152.15 29.72,152.15 29.49,152.37 29.49,152.81 29.72,153.03 31.37,153.03 31.54,153.2 31.54,154.14 31.33,154.35 29.34,154.35 28.93,154.75 28.93,155.09 29.46,155.62 31.28,155.62 31.54,155.87 31.54,157.28 30.96,157.86 30.96,164.53 30.96,165.9 v4(30.57,166.29)
  BOTTOM w0.127: UB6.K2 v4(30.57,166.29) ; UB5.K2 v4(20.82,166.29)
DDRA_CS_N0: length 86
  TOP w0.127: v4(30.7,134.65) U40.AU27
  S16 w0.127: v4(30.7,134.65) 30.24,134.19 29.37,134.19 29.21,134.34 29.21,134.78 28.92,135.07 28.72,135.07 27,136.8 25.23,136.8 21.01,141.02 21.01,153.73 21.17,153.9 21.45,153.9 21.65,154.1 21.65,154.48 21.56,154.58 20.76,154.58 20.64,154.7 20.64,155.19 20.77,155.32 22.87,155.32 24.22,156.67 24.22,158.51 24.22,165.07 24.35,165.2 26.66,165.2 26.97,164.89 26.97,158.47 27.09,158.34 27.68,158.34 27.85,158.52 27.85,160.34 27.98,160.46 29.02,160.46 29.15,160.59 29.15,161.1 29.02,161.23 27.98,161.23 27.85,161.35 27.85,161.86 27.98,161.99 28.79,161.99 28.92,162.11 28.92,162.62 28.79,162.75 27.98,162.75 27.85,162.88 27.85,163.38 27.98,163.51 28.79,163.51 28.92,163.64 28.92,164.15 28.79,164.27 27.98,164.27 27.85,164.4 27.85,164.91 27.98,165.04 28.79,165.04 28.92,165.16 28.92,165.67 28.79,165.8 27.98,165.8 27.85,165.92 27.85,166.55 27.68,166.72 27.35,166.72 27.17,166.55 27.17,165.99 26.99,165.81 23.33,165.81 23.05,166.09 23.05,166.39 23.18,166.52 24.25,166.52 v4(24.83,167.09)
  BOTTOM w0.127: UB5.L7 22.98,168.14 22.98,173.12 23.97,174.11 RB53.2
  BOTTOM w0.13: v4(24.83,167.09) UB5.L7
DDRA_CS_N1: length 74.7
  TOP w0.127: v4(33.7,130.65) U40.AN24
  S16 w0.127: v4(33.7,130.65) 33.7,130.98 33.59,131.09 32.55,131.09 32.25,131.39 32.25,131.77 32.66,132.18 32.81,132.18 33.21,132.59 33.21,135.66 32.83,136.04 32.83,136.87 30.75,138.95 30.75,141.48 29.42,142.8 29.03,142.8 28.05,141.83 27.87,141.83 27.5,142.2 27.5,142.35 28.64,143.5 28.64,143.6 28.31,143.93 28,143.93 26.96,142.9 26.8,142.9 26.56,143.14 26.56,144.24 26.78,144.46 27.2,144.46 27.42,144.68 27.42,145 27.2,145.22 26.78,145.22 26.56,145.45 26.56,145.96 26.78,146.18 27.33,146.18 27.55,146.4 27.55,146.72 27.33,146.94 26.78,146.94 26.56,147.17 26.56,147.69 26.78,147.91 28.37,147.91 28.53,148.07 28.53,148.55 28.4,148.68 26.78,148.68 26.56,148.9 26.56,149.21 26.78,149.44 28.17,149.44 28.35,149.62 28.35,150.07 28.22,150.2 26.78,150.2 26.56,150.42 26.56,154.65 27.21,155.3 27.49,155.3 27.6,155.19 27.6,154.84 27.73,154.71 27.99,154.71 28.18,154.9 28.18,155.25 28.34,155.41 32.27,155.41 32.3,155.43 34.1,157.24 34.1,165.58 34.51,165.99 35.23,165.99 35.35,166.11 35.35,166.57 35.22,166.7 34.66,166.7 34.51,166.85 v4(34.51,167.04)
  BOTTOM w0.127: RB59.2 32.1,172.01 33.26,170.84 33.26,168.29 v4(34.51,167.04) 34.86,166.69 UB6.L7
DDRA_DBI_N0: length 57.5
  TOP w0.127: v4(25.7,130.65) U40.AN32
  S7 w0.127: v4(24.82,161.49) 25.22,161.1 26.7,161.1 26.94,160.86 26.94,157.88 27.07,157.76 27.55,157.76 27.73,157.93 27.73,164.49 27.85,164.61 28.34,164.61 28.49,164.46 28.49,156.58 30.34,154.73 31.55,154.73 32.18,154.1 32.18,148.18 29.3,145.3 29.3,143.68 29.08,143.46 28.66,143.46 28.44,143.23 28.44,142.92 28.66,142.69 29.16,142.69 29.38,142.47 29.38,142.16 29.16,141.93 28.66,141.93 28.44,141.71 28.44,141.39 28.66,141.17 29.08,141.17 29.3,140.95 29.3,140.63 29.08,140.41 28.66,140.41 28.44,140.18 28.44,139.87 28.66,139.65 29.08,139.65 29.3,139.42 29.3,138.38 26.15,135.23 26.15,131.26 25.7,130.81 v4(25.7,130.65)
  BOTTOM w0.127: UB5.E7 v4(24.82,161.49)
DDRA_DBI_N1: length 58.3
  TOP w0.127: v4(27.7,131.65) U40.AP30
  S9 w0.127: v4(20.83,162.29) 20.73,162.29 20.42,162.6 20.42,171.54 20.21,171.75 19.98,171.75 19.63,171.4 19.63,165.48 19.62,165.48 19.62,157.06 21.01,155.68 21.01,151.65 23.02,149.64 23.02,139.25 23.09,139.18 23.09,135.96 22.22,135.09 22.22,132.57 22.68,132.1 27.04,132.1 27.5,131.65 v4(27.7,131.65)
  BOTTOM w0.127: UB5.E2 v4(20.83,162.29)
DDRA_DBI_N2: length 42.8
  TOP w0.127: U40.AJ25 v4(32.7,126.65)
  S5 w0.127: v4(32.7,126.65) 32.86,126.65 33.32,127.1 33.93,127.1 34.26,127.43 34.26,128.78 34.64,129.16 35.78,129.16 36.26,129.64 36.26,130.88 36.49,131.11 36.74,131.11 37.18,131.54 37.18,158.74 37.52,159.09 37.52,160.81 36.84,161.49 36.57,161.49 36.41,161.34 36.41,160.68 36.26,160.53 35.93,160.53 35.83,160.63 35.83,161.34 35.68,161.49 v4(35.37,161.49)
  BOTTOM w0.127: UB6.E7 34.97,161.89 v4(35.37,161.49)
DDRA_DBI_N3: length 60.4
  TOP w0.127: v4(29.7,126.65) U40.AJ28
  S7 w0.127: v4(30.57,161.49) 31.28,161.9 31.95,161.9 34.34,164.29 35.58,164.29 37.38,163.8 43.23,157.95 43.23,156.01 43.12,155.9 43.12,138.72 39.3,134.9 39.3,128.69 37.91,127.3 37.21,127.07 33.57,127.07 33.11,126.62 33.11,126.49 32.71,126.09 32.56,126.09 32.26,125.79 32.26,125.54 31.97,125.24 30.54,125.24 30.14,125.65 30.14,125.78 v4(29.7,126.65)
  BOTTOM w0.381: UB6.E2 v4(30.57,161.49)
DDRA_DQ0: length 57.4
  TOP w0.127: v4(22.7,132.65) U40.AR35
  S7 w0.127: v4(20.83,163.09) 20.83,163.24 20.13,163.93 19.88,163.93 19.65,163.7 19.65,163.46 20.42,162.69 20.42,161.8 20.3,161.67 18.94,161.67 18.81,161.54 18.81,161.21 18.94,161.08 20.26,161.08 20.42,160.92 20.42,158.38 20.13,158.09 19.24,158.09 19.02,157.87 19.02,157.43 19.25,157.2 20.52,157.2 20.74,156.98 20.74,156.67 20.52,156.44 18.86,156.44 18.63,156.66 18.36,156.66 18.1,156.41 18.1,155.99 18.41,155.68 20.52,155.68 20.74,155.46 20.74,155.14 20.52,154.92 18.73,154.92 18.51,154.69 18.51,154.38 18.73,154.16 20.53,154.16 20.74,153.95 20.74,153.56 20.57,153.39 20.22,153.39 19.85,153.03 19.48,153.03 19.12,153.39 18.74,153.39 18.51,153.16 18.51,152.68 18.91,152.27 18.91,151.99 18.51,151.58 18.51,149.88 18.73,149.66 20.64,149.66 20.74,149.56 20.74,149.07 20.57,148.89 19.8,148.89 19.56,148.65 19.56,139.66 20.3,138.91 20.3,133.38 20.54,133.15 20.91,133.15 21.2,132.86 21.2,132.49 21.52,132.17 22.41,132.17 22.7,132.46 v4(22.7,132.65)
  BOTTOM w0.127: UB5.G2 v4(20.83,163.09)
DDRA_DQ1: length 57.3
  TOP w0.127: v4(25.72,132.65) 26.2,132.17 U40.AR32
  S7 w0.127: v4(24.83,162.29) 24.62,162.29 24.43,162.11 24.43,157.91 25.22,157.12 27.23,157.12 29.48,154.87 29.48,154.45 29.7,154.22 31.34,154.22 31.57,154 31.57,153.68 31.34,153.46 29.7,153.46 29.48,153.24 29.48,152.92 29.7,152.7 31.45,152.7 31.67,152.47 31.67,152.16 31.45,151.94 29.7,151.94 29.48,151.71 29.48,151.4 29.7,151.17 31.45,151.17 31.67,150.95 31.67,150.64 31.45,150.41 29.65,150.41 29.4,150.16 29.4,149.78 29.63,149.55 31.31,149.55 31.44,149.43 31.44,148.97 31.26,148.79 28.97,148.79 28.79,148.61 28.79,148.21 29,148 30.6,148 30.72,147.88 30.72,147.44 30.5,147.22 27.88,147.22 27.65,146.99 27.65,146.59 27.18,146.12 27.18,144.04 27.7,143.52 27.7,137.5 25.3,135.1 25.3,132.27 25.38,132.19 25.58,132.19 25.72,132.33 v4(25.72,132.65)
  BOTTOM w0.127: UB5.F7 v4(24.83,162.29)
DDRA_DQ2: length 57.2
  TOP w0.127: v4(22.7,133.65) U40.AT35
  S7 w0.127: v4(21.62,163.89) 21.25,163.52 21.25,151.53 21.12,151.41 19.17,151.41 19.04,151.28 19.04,150.77 19.17,150.64 21.12,150.64 21.25,150.52 21.25,148.42 21.02,148.2 20.25,148.2 20.08,148.03 20.08,147.57 20.22,147.43 21.39,147.43 21.62,147.21 21.62,146.9 21.39,146.67 20.2,146.67 20.07,146.54 20.07,146.01 20.17,145.91 21.59,145.91 21.81,145.69 21.81,145.13 21.59,144.91 20.28,144.91 20.07,144.7 20.07,144.36 20.28,144.15 21.87,144.15 22.09,143.92 22.09,143.61 21.87,143.38 20.31,143.38 20.08,143.16 20.08,142.85 20.31,142.62 21.91,142.62 22.09,142.44 22.09,142.04 21.92,141.86 20.28,141.86 20.07,141.65 20.07,141.23 20.26,141.04 21.91,141.04 22.09,140.87 22.09,140.51 21.81,140.23 20.34,140.23 20.18,140.08 20.18,139.75 20.67,139.27 21.25,139.27 21.45,139.47 21.76,139.47 21.99,139.24 21.99,138.81 21.83,138.66 21.83,136.07 21.09,135.32 21.09,133.63 21.56,133.16 22.56,133.16 22.7,133.3 v4(22.7,133.65)
  BOTTOM w0.13: UB5.H3 v4(21.62,163.89)
DDRA_DQ3: length 57.6
  TOP w0.127: v4(23.7,131.65) U40.AP34
  S7 w0.127: v4(24.82,163.89) 24.5,163.89 24.35,164.04 24.35,165.11 24.2,165.26 22.91,165.26 22.77,165.12 22.77,164.51 22.89,164.39 23.21,164.39 23.33,164.26 23.33,163.02 23.21,162.89 23.21,157.7 25.01,155.89 25.01,155.57 25.16,155.42 27.47,155.42 27.61,155.28 27.61,154.82 27.42,154.63 26.03,154.63 25.81,154.41 25.81,153.99 26.03,153.76 26.34,153.76 26.56,153.54 26.56,153.22 26.34,153 25.95,153 25.73,152.78 25.73,152.46 25.95,152.24 26.36,152.24 26.58,152.02 26.58,151.7 26.36,151.48 26.07,151.48 25.85,151.25 25.85,150.86 26.07,150.64 26.74,150.64 26.96,150.41 26.96,150.1 26.74,149.87 26.02,149.87 25.85,149.71 25.85,149.27 26.05,149.07 27.42,149.07 27.58,148.91 27.58,148.47 27.41,148.31 25.92,148.31 25.75,148.13 25.75,147.75 25.95,147.55 26.4,147.55 26.58,147.37 26.58,146.96 26.41,146.78 25.41,146.78 25.25,146.63 25.25,146.21 25.45,146.02 25.94,146.02 26.16,145.79 26.16,145.48 25.94,145.26 25.21,145.26 25.06,145.11 25.06,144.31 23.57,142.82 23.57,141.48 23.79,141.26 24.4,141.26 24.63,141.04 24.63,140.72 24.4,140.5 23.79,140.5 23.57,140.28 23.57,139.36 23.94,138.98 23.94,135.85 23.57,135.47 23.57,135.07 23.09,134.6 23.09,133.34 23.46,132.97 23.99,132.97 24.3,132.66 24.3,131.88 24.07,131.65 v4(23.7,131.65)
  BOTTOM w0.13: UB5.H7 v4(24.82,163.89)
DDRA_DQ4: length 57.2
  TOP w0.127: v4(24.7,131.65) U40.AP33
  S7 w0.127: v4(24.7,131.65) 25.06,131.65 25.19,131.52 25.19,131.34 25.01,131.16 21.99,131.16 21.91,131.24 21.33,131.24 21.12,131.44 21.12,131.9 20.89,132.13 20.34,132.13 20.21,132.26 20.21,133.02 19.98,133.24 18.9,133.24 18.67,133.47 18.67,133.82 18.86,134.01 19.53,134.01 19.75,134.23 19.75,134.54 19.53,134.77 17.64,134.77 17.41,134.99 17.41,135.31 17.64,135.53 19.53,135.53 19.79,135.79 19.79,138.14 19.05,138.87 19.05,148.61 18,149.67 18,155.37 17.16,156.21 17.16,157.63 17.52,157.99 18.42,157.99 18.95,158.52 18.95,159.07 19.63,159.75 19.63,160.4 19.4,160.63 18.28,160.63 18.08,160.83 18.08,162.6 19.62,164.15 19.62,164.85 19.32,165.15 19.01,165.15 18.89,165.28 18.89,166.29 19.17,166.57 19.73,166.57 19.96,166.34 19.96,165.48 20.43,165 20.43,164.29 20.83,163.89 v4(20.83,163.89)
  BOTTOM w0.127: UB5.H2 v4(20.83,163.89)
DDRA_DQ5: length 57.3
  TOP w0.127: v4(24.7,133.65) U40.AT33
  S7 w0.127: v4(25.63,163.89) 25.23,163.5 24.53,163.5 23.71,162.68 23.71,157.91 25.01,156.61 27.02,156.61 28.12,155.51 28.12,148.3 27.09,147.27 27.09,146.75 26.67,146.33 26.67,143.76 26.52,143.61 25.08,143.61 24.86,143.39 24.86,143.05 25.08,142.83 26.97,142.83 27.19,142.61 27.19,142.29 26.97,142.07 25.08,142.07 24.86,141.84 24.86,141.53 25.08,141.31 26.97,141.31 27.19,141.08 27.19,140.77 26.97,140.54 25.18,140.54 24.96,140.32 24.96,140 25.18,139.78 26.97,139.78 27.19,139.56 27.19,139.24 26.97,139.02 24.68,139.02 24.45,138.8 24.45,138.48 24.68,138.26 26.82,138.26 27.04,138.03 27.04,137.72 26.82,137.5 24.72,137.5 24.5,137.27 24.5,136.83 24.63,136.7 25.47,136.7 25.64,136.52 25.64,136.16 25.36,135.87 24.69,135.87 24.27,135.46 24.27,134.07 v4(24.7,133.65)
  BOTTOM w0.13: UB5.H8 v4(25.63,163.89)
DDRA_DQ6: length 57.3
  TOP w0.127: v4(24.7,130.65) U40.AN33
  S7 w0.127: v4(20.83,164.69) 20.83,165.12 20.43,165.51 20.43,166.56 20.43,169.72 20.25,169.9 19.8,169.9 19.63,169.72 19.63,167.72 17.63,165.72 17.63,162.84 17.01,162.22 17.01,160.34 17.29,160.07 17.95,160.07 18.44,159.58 18.44,159.08 18.07,158.71 17.03,158.71 16.65,158.33 16.65,156 17.49,155.16 17.49,149.46 18.55,148.4 18.55,139.53 18.33,139.32 18.33,138.71 16.91,137.28 16.91,134.52 20.29,131.14 20.97,131.14 21.3,130.81 21.68,130.81 22.37,130.12 24.17,130.12 v4(24.7,130.65)
  BOTTOM w0.13: UB5.J3 v4(20.83,164.69)
DDRA_DQ7: length 57.4
  TOP w0.127: v4(26.7,131.65) U40.AP31
  S7 w0.127: v4(24.83,164.69) 24.73,164.79 24.73,164.97 25.02,165.26 29.8,165.26 30,165.07 30,164.71 29.8,164.52 29.39,164.52 29.13,164.26 29.13,163.78 29.41,163.5 29.6,163.5 29.6,163.5 29.93,163.5 29.93,163.5 30.4,163.5 30.4,163.5 31.53,163.5 31.53,163.5 32.11,163.5 32.28,163.32 32.28,162.92 32.06,162.69 29.16,162.69 29,162.53 29,158.17 29.2,157.96 29.2,157.96 29.69,157.48 32.07,157.48 32.25,157.3 32.25,156.87 32.09,156.72 29.91,156.72 29.71,156.52 29.71,156.07 29.88,155.9 31.64,155.9 31.85,155.69 31.85,155.15 31.99,155.01 32.69,154.31 32.69,147.97 30.31,145.59 30.31,137.19 29.79,136.67 28.8,136.67 27.19,135.06 27.19,132.14 v4(26.7,131.65)
  BOTTOM w0.13: UB5.J7 v4(24.83,164.69)
DDRA_DQ8: length 58.4
  TOP w0.127: v4(23.7,134.65) U40.AU34
  S9 w0.127: v4(20.83,158.29) 20.83,158.54 20.56,158.8 20.11,158.8 19.89,158.58 19.89,158.23 20.54,157.58 21.3,157.58 21.52,157.36 21.52,152.33 21.78,152.07 25.36,152.07 25.56,151.87 25.56,151.47 25.39,151.31 22.75,151.31 22.55,151.1 22.55,150.92 23.07,150.39 25.39,150.39 25.56,150.23 25.56,149.84 25.34,149.63 23.71,149.63 23.53,149.45 23.53,149.05 23.73,148.84 25.24,148.84 25.44,148.64 25.44,148.23 25.19,147.98 23.78,147.98 23.53,147.72 23.53,147.22 23.73,147.01 25.34,147.01 25.56,146.8 25.56,146.42 25.39,146.25 23.71,146.25 23.53,146.06 23.53,143.51 23.73,143.3 26.11,143.3 26.28,143.14 26.28,142.71 26.11,142.54 23.7,142.54 23.53,142.37 23.53,141.66 23.64,141.55 25.19,141.55 25.32,141.42 25.32,140.99 25.12,140.79 23.85,140.79 23.7,140.64 23.7,135.52 23.09,134.91 23.09,133.31 23.36,133.04 23.89,133.04 24.3,133.45 24.3,134.23 23.89,134.65 v4(23.7,134.65)
  BOTTOM w0.127: UB5.A3 v4(20.83,158.29)
DDRA_DQ9: length 58.1
  TOP w0.127: v4(28.7,132.65) U40.AR29
  S9 w0.127: v4(25.63,159.09) 25.66,159.09 26.05,159.49 27.2,159.49 27.52,159.81 27.52,164.11 28.26,164.84 29.81,164.84 30.17,165.2 32.27,165.2 32.88,164.59 34.05,164.59 34.33,164.31 34.81,164.31 34.99,164.49 34.99,164.97 35.12,165.1 35.55,165.1 35.68,164.97 35.68,164.49 35.87,164.3 36.92,164.3 37.15,164.06 37.15,163.78 36.97,163.6 35.93,163.6 35.76,163.43 35.76,163.08 35.93,162.91 36.95,162.91 37.15,162.71 37.15,160.63 36.56,160.04 36.56,158.76 37.15,158.16 37.15,155.32 31.28,149.45 31.28,141.81 28.79,139.32 28.79,135.43 29.21,135.02 29.21,132.59 29.07,132.46 28.88,132.46 v4(28.7,132.65)
  BOTTOM w0.127: UB5.B8 v4(25.63,159.09)
DDRA_DQ10: length 58.4
  TOP w0.127: v4(25.7,133.65) U40.AT32
  S9 w0.127: v4(25.7,133.65) 25.7,133.43 25.61,133.34 25.2,133.34 25.09,133.44 25.09,134.89 24.71,135.27 24.71,135.9 24.84,136.02 25.63,136.02 25.77,136.17 25.77,136.62 25.61,136.79 24.94,136.79 24.71,137.01 24.71,137.32 24.94,137.55 25.6,137.55 25.77,137.72 25.77,138.12 25.58,138.31 24.94,138.31 24.71,138.53 24.71,138.95 27.47,141.71 27.47,143.38 26.57,144.28 26.57,147.88 26.7,148.01 28.13,148.01 28.25,148.14 28.25,148.64 28.13,148.77 26.7,148.77 26.57,148.9 26.57,149.41 26.7,149.53 28.29,149.53 28.41,149.66 28.41,150.17 28.29,150.29 26.7,150.29 26.57,150.42 26.57,152.26 26.56,152.27 26.56,152.73 26.2,153.09 22.89,153.09 22.72,153.25 22.72,153.68 22.89,153.85 26.34,153.85 26.56,154.07 26.56,154.5 26.45,154.61 22.67,154.61 22.53,154.75 22.53,155.23 22.68,155.37 23.74,155.37 23.89,155.52 23.89,155.91 23.67,156.13 22.76,156.13 22.53,156.36 22.53,159.32 23.92,160.7 23.92,161.16 23.61,161.47 23.28,161.47 21.69,159.87 v4(21.64,159.87)
  BOTTOM w0.13: UB5.C3 v4(21.64,159.87)
