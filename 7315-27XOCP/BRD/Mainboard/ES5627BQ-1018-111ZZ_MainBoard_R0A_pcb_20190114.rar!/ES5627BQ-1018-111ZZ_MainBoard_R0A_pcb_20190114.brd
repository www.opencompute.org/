# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDRC_DQ31: length 77.5
  TOP w0.127: v4(49.7,118.65) U40.AA9
  TOP w0.13: v4(83.94,160.82) U16.D7
  S7 w0.127: v4(83.94,160.82) 83.54,161.22 78.11,161.22 77.74,160.85 77.22,160.85 76.72,161.34 76.4,161.34 76.18,161.12 76.18,160.81 76.68,160.31 76.68,159.99 76.45,159.77 76.14,159.77 75.49,160.42 75.17,160.42 74.95,160.2 74.95,159.88 75.6,159.23 75.6,158.91 75.38,158.69 75.06,158.69 74.31,159.44 73.99,159.44 73.77,159.22 73.77,158.9 74.52,158.15 74.52,157.83 74.3,157.61 73.98,157.61 73.28,158.31 72.94,158.31 72.71,158.09 72.71,157.8 73.44,157.07 73.44,156.76 73.22,156.53 72.9,156.53 72.37,157.07 72.05,157.07 71.81,156.84 71.81,156.55 72.36,155.99 72.36,155.68 70.66,153.97 67.01,153.97 61.97,148.93 61.97,147.35 59.27,144.65 59.27,137.26 59.04,137.03 59.04,128.11 58.09,127.15 55.64,127.15 55.18,126.69 55.18,126.57 54.7,126.08 54.37,126.08 54.22,125.93 54.22,125.45 53.97,125.19 53.51,125.19 53.2,124.89 53.2,124.46 52.92,124.18 52.44,124.18 52.11,123.85 52.11,123.34 51.93,123.16 51.5,123.16 51.2,122.86 51.2,119.45 50.89,119.15 50.2,119.15 v4(49.7,118.65)
DDRC_DQS0_N: length 68.9
  TOP w0.095: U40.AC2 v4(56.7,120.65) ; U17.F3 v4(98.48,163.22)
  S9 w0.108: v4(98.48,163.22) 98.33,163.38 98.33,163.63 97.98,163.98 96.65,163.98 95.85,163.18 95.85,156.76 92.96,153.87 91.73,153.87 87.82,149.96 85.73,149.96 84.12,148.35 84.12,142.02 79.75,137.64 76.81,137.64 64.62,125.46 63.17,125.46 59.14,121.43 58.16,121.43 57.99,121.26 57.31,121.26 v4(56.7,120.65)
DDRC_DQS0_P: length 68.9
  TOP w0.095: U40.AC1 v4(57.7,120.65) ; U17.G3 v4(97.69,163.22)
  S9 w0.108: v4(57.7,120.65) 58.26,121.21 59.24,121.21 63.26,125.23 64.72,125.23 76.9,137.41 79.84,137.41 84.35,141.93 84.35,148.26 85.83,149.73 87.91,149.73 91.82,153.64 93.06,153.64 96.08,156.67 96.08,163.09 96.75,163.75 97.88,163.75 98.1,163.54 98.1,162.7 98,162.6 97.79,162.6 97.69,162.71 v4(97.69,163.22)
DDRC_DQS1_N: length 67.7
  TOP w0.095: v4(94.49,158.42) U17.A7 ; U40.AJ1 v4(57.7,126.65)
  S5 w0.108: v4(57.7,126.65) 57.6,126.55 57.6,126.34 57.83,126.11 58.44,126.11 64.05,131.72 64.05,134.29 64.64,134.88 arc(64.73,135.1) 64.64,135.31 64.25,135.7 arc(64.25,136.46) 65.01,136.46 65.4,136.07 arc(65.62,135.98) 65.84,136.07 65.84,136.07 arc(65.93,136.29) 65.84,136.51 65.47,136.87 arc(65.47,137.63) 66.23,137.63 66.6,137.27 arc(66.81,137.18) 67.03,137.27 73.73,143.97 73.73,149.48 75.89,151.64 77.66,151.64 78.87,152.85 86.62,152.85 86.88,153.1 86.88,154.63 87.24,154.99 87.73,154.99 88.08,154.63 88.08,153.66 88.27,153.46 88.58,153.46 88.82,153.71 88.82,154.63 89.17,154.99 89.67,154.99 90.02,154.63 90.02,153.96 90.24,153.74 90.55,153.74 90.77,153.96 90.77,154.63 91.12,154.99 91.86,154.99 93.64,156.77 93.64,156.77 94.78,157.91 94.78,157.91 94.96,158.09 94.96,158.65 94.76,158.85 94.59,158.85 94.49,158.74 v4(94.49,158.42)
DDRC_DQS1_P: length 67.7
  TOP w0.095: v4(94.49,159.22) U17.B7 ; U40.AH1 v4(57.7,125.65)
  S5 w0.108: v4(57.7,125.65) 57.93,125.88 58.53,125.88 64.28,131.63 64.28,134.19 64.8,134.72 arc(64.96,135.1) 64.8,135.48 64.42,135.86 arc(64.42,136.3) 64.85,136.3 65.24,135.91 arc(65.62,135.75) 66,135.91 66,135.91 arc(66.16,136.29) 66,136.67 65.63,137.03 arc(65.63,137.47) 66.07,137.47 66.43,137.11 arc(66.81,136.95) 67.19,137.11 73.9,143.81 73.96,143.88 73.96,149.39 75.99,151.41 77.75,151.41 78.96,152.62 86.72,152.62 87.11,153.01 87.11,154.53 87.33,154.76 87.63,154.76 87.85,154.54 87.85,153.56 88.18,153.24 88.67,153.24 89.05,153.61 89.05,154.54 89.27,154.76 89.58,154.76 89.79,154.54 89.79,153.87 90.15,153.52 90.64,153.52 90.99,153.87 90.99,154.54 91.21,154.76 91.95,154.76 93.87,156.67 93.87,156.68 94.87,157.68 94.87,157.68 95.19,157.99 95.19,158.75 94.86,159.08 94.63,159.08 v4(94.49,159.22)
DDRC_DQS2_N: length 77.3
  TOP w0.095: U40.AJ5 v4(53.7,126.65) ; v4(87.94,162.42) U16.F3
  S9 w0.108: v4(87.94,162.42) 88.34,162.02 89.78,162.02 90,162.25 90.15,162.25 90.26,162.14 90.26,158.59 88.89,157.22 88.58,157.22 87.5,158.3 86.97,158.3 86.63,157.96 86.63,157.47 87.75,156.36 87.75,156.08 87.5,155.83 87.23,155.83 86.06,156.99 85.54,156.99 85.21,156.66 85.21,156.15 86.35,155 86.35,154.68 86.12,154.45 85.85,154.45 84.49,155.81 83.92,155.81 83.58,155.47 83.58,155.02 84.17,154.44 84.17,154.15 83.91,153.9 83.66,153.9 82.64,154.91 82.13,154.91 81.76,154.55 81.76,154.09 82.79,153.06 82.79,152.8 82.55,152.55 82.26,152.55 81.23,153.57 80.79,153.57 80.4,153.19 80.4,152.68 81.42,151.66 81.42,151.34 79.1,149.01 79.1,145.43 77.89,144.23 77.89,142.83 76.73,141.67 74.84,141.67 71.67,138.5 69.19,138.5 59.25,128.57 58.54,128.57 58.24,128.27 57.5,128.27 57.29,128.06 57.29,127.38 57.07,127.15 54.21,127.15 v4(53.7,126.65)
DDRC_DQS2_P: length 77.3
  TOP w0.095: U40.AJ4 v4(54.7,126.65) ; v4(87.94,163.22) U16.G3
  S9 w0.108: v4(54.7,126.65) 55.08,126.26 56.86,126.26 57.22,126.62 57.22,126.98 57.5,127.26 57.86,127.26 58.16,127.56 58.16,127.86 58.64,128.34 59.35,128.34 69.28,138.28 71.77,138.28 74.93,141.44 76.83,141.44 78.12,142.73 78.12,144.13 79.33,145.34 79.33,148.92 81.65,151.24 81.65,151.76 80.63,152.78 80.63,153.09 80.88,153.34 81.14,153.34 82.16,152.32 82.64,152.32 83.02,152.7 83.02,153.16 81.99,154.19 81.99,154.45 82.22,154.68 82.55,154.68 83.56,153.67 84.01,153.67 84.39,154.06 84.39,154.53 83.81,155.12 83.81,155.38 84.02,155.58 84.4,155.58 85.75,154.23 86.22,154.23 86.58,154.59 86.58,155.1 85.44,156.24 85.44,156.56 85.64,156.77 85.96,156.77 87.13,155.6 87.59,155.6 87.98,155.98 87.98,156.45 86.86,157.57 86.86,157.86 87.07,158.07 87.41,158.07 88.48,156.99 88.99,156.99 90.49,158.5 90.49,162.23 90.25,162.47 90.07,162.47 89.73,162.81 88.35,162.81 v4(87.94,163.22)
DDRC_DQS3_N: length 77.5
  TOP w0.095: U40.AD6 v4(52.7,121.65) ; v4(83.94,158.42) U16.A7
  S7 w0.108: v4(52.7,121.65) 53.2,122.15 57.79,122.15 58.2,121.74 58.81,121.74 61.75,124.68 61.75,132.21 68.16,138.62 arc(68.58,138.79) 68.99,138.62 69.28,138.33 arc(69.72,138.33) 69.72,138.76 69.39,139.09 arc(69.24,139.47) 69.39,139.85 69.39,139.85 arc(69.77,140.01) 70.15,139.85 70.5,139.51 arc(70.93,139.51) 70.93,139.94 70.59,140.28 arc(70.43,140.66) 70.59,141.04 73.69,144.14 73.69,149.6 75.39,151.31 77.33,151.31 79.39,153.37 81.06,153.37 81.76,152.67 82.18,152.67 82.35,152.84 82.35,153.13 81.32,154.16 81.32,154.68 81.63,154.99 82.19,154.99 83.41,153.77 83.72,153.77 83.94,153.99 83.94,154.29 82.69,155.54 82.69,156.05 83.03,156.39 83.54,156.39 84.79,155.14 85.09,155.14 85.28,155.34 85.28,155.69 84.05,156.93 84.05,157.4 84.4,157.76 84.92,157.76 86.14,156.54 86.48,156.54 86.68,156.73 86.68,157.05 84.99,158.73 84.26,158.73 v4(83.94,158.42)
DDRC_DQS3_P: length 77.5
  TOP w0.095: v4(83.94,159.22) U16.B7 ; U40.AD5 v4(53.7,121.65)
  S7 w0.108: v4(53.7,121.65) 53.7,121.25 53.83,121.11 57.76,121.11 58.16,121.51 58.91,121.51 61.98,124.59 61.98,132.12 68.32,138.46 arc(68.58,138.56) 68.83,138.46 69.12,138.16 arc(69.88,138.16) 69.88,138.92 69.55,139.25 arc(69.46,139.47) 69.55,139.69 69.56,139.69 arc(69.77,139.78) 69.99,139.69 70.33,139.34 arc(71.09,139.34) 71.09,140.1 70.75,140.45 arc(70.66,140.66) 70.75,140.88 73.91,144.05 73.91,149.5 75.49,151.08 77.42,151.08 79.48,153.14 80.97,153.14 81.67,152.44 82.27,152.44 82.57,152.74 82.57,153.23 81.55,154.25 81.55,154.58 81.73,154.76 82.1,154.76 83.31,153.54 83.81,153.54 84.17,153.9 84.17,154.39 82.92,155.63 82.92,155.95 83.12,156.16 83.45,156.16 84.69,154.91 85.18,154.91 85.51,155.24 85.51,155.79 84.28,157.03 84.28,157.31 84.5,157.53 84.82,157.53 86.04,156.31 86.58,156.31 86.91,156.64 86.91,157.14 85.09,158.96 84.2,158.96 v4(83.94,159.22)
DDRC_ODT: length 125
  TOP w0.127: U40.AP1 v4(57.7,131.65)
  TOP w0.13: v4(98.48,166.42) U17.K3 ; v4(87.94,166.42) U16.K3
  S7 w0.127: v4(98.48,166.42) 97.51,166.42 97.05,165.96 97.05,161.06 96.88,160.88 95.86,160.88 95.76,160.99 95.76,166.32 95.27,166.81 91.49,166.81 91.31,166.63 91.31,166.01 91.19,165.89 90.47,165.89 90.35,166.01 90.35,166.55 90.08,166.81 88.34,166.81 v4(87.94,166.42)
  S16 w0.127: v4(57.7,131.65) 58.19,132.14 58.19,138 58.32,138.13 58.78,138.13 58.93,137.97 58.93,131.98 59.08,131.83 59.51,131.83 59.66,131.98 59.66,138.1 59.99,138.43 61.46,138.43 64.2,141.17 72.31,141.17 73.99,142.85 73.99,150.03 76.19,152.23 76.19,156.82 76.37,156.99 84.73,156.99 85.64,157.91 85.64,163.29 87.34,165 89.5,165 90.9,166.39 90.9,169.03 91.08,169.21 93.06,169.21 93.28,169.44 93.28,169.87 93.42,170.01 95.1,170.01 95.27,169.85 95.27,168.51 97.36,166.42 v4(98.48,166.42)
  BOTTOM w0.127: RB102.2 84.89,158.7 84.99,158.6 85.55,158.6 85.67,158.72 85.67,161.44 86.54,162.31 86.61,162.31 86.74,162.43 86.74,162.86 86.64,162.97 86.16,162.97 86.03,163.09 86.03,163.4 86.18,163.55 86.59,163.55 86.72,163.68 86.72,163.98 86.59,164.11 86,164.11 85.88,164.24 85.88,164.54 86,164.67 86.23,164.67 87.07,165.51 87.07,166.09 87.4,166.42 v4(87.94,166.42)
DDRC_PAR: length 103
  TOP w0.127: v4(56.7,132.65) U40.AR2
  TOP w0.13: v4(98.49,171.22) U17.T3 ; U16.T3 v4(87.94,171.22)
  S7 w0.127: v4(87.94,171.22) 88.4,171.68 90.14,171.68 90.39,171.93 91.28,171.93 91.53,171.68 98.03,171.68 v4(98.49,171.22)
  S16 w0.127: v4(98.49,171.22) 94.4,171.22 93.35,172.27 87.43,172.27 84.5,169.34 84.5,166.19 84.32,166.01 81.8,166.01 81.63,165.83 81.63,164.87 80.97,164.21 74.49,164.21 74.26,163.98 74.26,163.62 74.39,163.5 76.14,163.5 76.27,163.37 76.27,162.91 76.17,162.81 74.41,162.81 74.23,162.63 74.23,162.23 74.36,162.1 76.32,162.1 76.47,161.95 76.47,161.49 76.39,161.41 74.18,161.41 74.1,161.33 74.1,159.85 73.57,159.33 73.57,154.33 72.32,153.07 66.77,153.07 55.54,141.84 55.54,137.34 55.36,137.16 54.83,137.16 54.65,136.98 54.65,136.7 54.83,136.52 55.62,136.52 55.74,136.4 55.74,136.07 55.59,135.91 54.8,135.91 54.63,135.74 54.63,135.38 54.78,135.23 55.03,135.23 55.19,135.07 55.19,132.48 55.49,132.18 56.58,132.18 56.7,132.29 v4(56.7,132.65)
  BOTTOM w0.127: RB73.2 88.48,172.94 87.94,172.4 v4(87.94,171.22)
DDRC_RAS_N: length 104.1
  TOP w0.127: R267.2 79.59,167.36 79.73,167.22 v4(83.14,167.22) ; v4(50.7,124.65) U40.AG8
  TOP w0.13: v4(83.14,167.22) U16.L8 ; v4(93.69,167.22) U17.L8
  S5 w0.127: v4(93.69,167.22) 93.29,167.62 92.68,167.62 92.67,167.62 83.55,167.62 v4(83.14,167.22)
  S16 w0.127: v4(93.69,167.22) 93.91,167.22 94.3,167.61 94.88,167.61 96.48,166.01 98.64,166.01 98.89,166.26 98.89,166.58 99.12,166.81 100.25,166.81 100.68,166.38 100.68,158.27 100.08,157.68 97.35,157.68 96.21,156.54 96.21,156.38 96.93,155.66 96.93,155.48 96.57,155.12 96.39,155.12 95.69,155.82 95.49,155.82 94.1,154.43 89.42,154.43 82.84,147.84 82.84,143.82 73.28,134.26 71.86,134.26 60.77,123.17 52.42,123.17 52.14,123.45 52.14,123.91 51.96,124.09 51.26,124.09 v4(50.7,124.65)
DDRC_RST_N: length 107.6
  TOP w0.127: U40.AN5 v4(53.7,130.65)
  TOP w0.13: v4(100.08,169.62) U17.P1 ; v4(89.54,169.62) U16.P1
  S12 w0.127: v4(100.08,169.62) 99.89,169.42 99.41,169.21 92.93,169.21 v4(89.54,169.62)
  S14 w0.127: v4(100.08,169.62) 99.68,170.02 98.06,170.02 96.89,168.86 96.89,165.33 96.05,164.49 96.05,163.04 95.04,162.02 92.68,162.02 91.08,160.42 85.06,160.42 84.27,161.21 84.11,161.21 83.78,161.21 83.78,161.21 83.31,161.21 82.98,161.21 82.98,161.21 82.51,161.21 82.18,161.21 82.18,161.21 81.73,161.21 81.04,161.9 80.66,161.9 80.36,161.59 80.36,161.11 80.99,160.47 80.99,159.18 77.31,155.5 77.31,152.75 77.56,152.5 79.87,152.5 80.46,151.91 80.46,149.93 79.16,148.64 79.16,145.62 79.75,145.03 79.75,143.46 73.5,137.21 68.32,137.21 63.03,131.93 63.03,131.67 58.49,127.13 56.56,127.13 56.2,127.49 56.2,127.73 55.79,128.15 54.49,128.15 54.21,128.42 54.21,128.91 53.93,129.19 53.49,129.19 53.2,129.48 U40.AN5 v4(53.7,130.65)
  BOTTOM w0.127: v4(89.54,169.62) 90.09,169.62 90.14,169.57 90.75,169.57 91.44,170.26 91.44,172.31 93.69,174.56 RB78.2
DDRC_TEN: length 17.2
  TOP w0.127: v4(82.34,168.82) 79.18,168.82 78.6,169.39 R238.2 R250.1
  TOP w0.13: U16.N9 v4(82.34,168.82) ; U17.N9 v4(92.89,168.82)
  S12 w0.122: 82.85,169.19 83.01,169.22 89.75,169.22 90.15,168.82 v4(92.89,168.82)
  S12 w0.127: 82.85,169.19 v4(82.34,168.82)
DDRC_VREF_1: length 8.9
  TOP w0.381: v4(100.08,168.02) U17.M1
  BOTTOM w0.254: CB120.1 103.34,172.69 v2(103.47,172.82)
  BOTTOM w0.381: v4(100.08,168.02) 100.35,168.02 100.65,168.33 CB159.1 102.17,168.33 RB104.1
  BOTTOM w0.508: CB120.1 RB89.2 RB94.1 101.89,169.51 102.17,169.22 RB104.1
DDRC_VREF_2: length 15
  TOP w0.381: v4(89.54,168.02) U16.M1
  S14 w0.381: v1(95.81,173.72) 93.89,171.8 92.68,171.8 90.14,169.26 90.14,168.59 89.56,168.02 v4(89.54,168.02)
  BOTTOM w0.381: v4(89.54,168.02) 89.59,167.97 CB160.1 ; v2(96.6,172.93) v1(95.81,173.72) 96.28,174.19 CB90.1 RB47.2 RB46.1
DDRC_WE_N: length 105
  TOP w0.127: U40.AJ7 v4(51.7,126.65)
  TOP w0.13: v4(99.29,167.22) U17.L2 ; v4(88.74,167.22) U16.L2
  S5 w0.127: v4(88.74,167.22) 89.14,166.82 92.93,166.82 92.93,166.82 U17.L2 v4(99.29,167.22)
  S14 w0.127: v4(99.29,167.22) 99.69,166.82 99.69,161.41 99.48,161.21 99.45,161.21 99.45,161.21 99.12,161.21 99.12,161.21 98.65,161.21 98.65,161.21 98.32,161.21 98.32,161.21 98.19,161.21 97.78,160.8 97.78,158.7 95.32,156.23 84.55,156.23 83.25,154.94 83.25,154.24 83.38,154.11 85.11,154.11 85.23,153.98 85.23,153.48 85.11,153.35 83.38,153.35 83.25,153.22 83.25,152.71 83.38,152.59 85.11,152.59 85.23,152.46 85.23,151.95 85.11,151.83 83.38,151.83 83.25,151.7 83.25,143.55 74.37,134.67 69.94,134.67 58.42,123.15 56.48,123.15 56.15,123.48 56.15,123.85 55.85,124.14 54.47,124.14 54.14,124.48 54.14,124.83 53.88,125.09 53.51,125.09 53.22,125.38 53.22,125.83 52.85,126.2 52.14,126.2 v4(51.7,126.65)
  BOTTOM w0.127: RB90.2 86.17,170.12 86.17,169.21 87.77,167.62 88.34,167.62 v4(88.74,167.22)
DDRC_ZQ_1: length 4.3
  TOP w0.13: v4(92.89,162.42) U17.F9
  BOTTOM w0.127: v4(92.89,162.42) 93.28,162.02 94.83,162.02 94.94,162.13 v2(95.34,162.13) RB128.2
DDRC_ZQ_2: length 4.1
  TOP w0.13: v4(82.34,162.42) U16.F9
  BOTTOM w0.127: RB121.2 79.52,163.35 v2(79.29,163.12)
  BOTTOM w0.13: v4(82.34,162.42) 82.05,162.71 80.99,162.71 RB121.2
DIAG_A: length 316
  TOP w0.127: P1.G7 v4(100.29,215.46)
  S12 w0.127: v4(100.29,215.46) 99.79,214.96 94.69,214.96 92.42,212.69 89.79,212.69 88.8,211.71 88.14,211.71 87.76,211.33 84.45,211.33 83.09,212.69 81.55,212.69 v1(80.64,211.79)
  S16 w0.127: v1(80.64,211.79) 76.76,211.79 65.41,200.43 30.86,200.43 17.3,186.87 17.3,180.5 16.22,179.42 16.22,175.36 12.41,171.55 12.41,167.8 12.69,167.52 12.69,166.69 11.99,166 11.99,157.24 14.9,154.33 14.9,150.59 15.54,149.96 15.54,142.34 10.51,137.31 10.51,117.85 9.82,117.16 9.82,114.06 8.04,112.28 8.04,106.09 6.74,104.79 6.74,99.1 7.28,98.56 7.28,93.06 5.86,91.64 5.86,82.56 8.69,79.72 11.67,79.72 14.95,76.45 14.95,66.77 14.33,66.16 14.33,63.33 19.76,57.9 19.76,55.08 18.35,53.67 14.77,53.67 13.3,52.2 13.3,45.52 19.32,39.5 19.32,22.1 20.45,20.97 29.89,20.97 36.86,14.01 v1(43.08,14.01)
  BOTTOM w0.127: v2(43.02,15.02) 43.02,14.07 v1(43.08,14.01) 43.27,13.82 RB736.2
DIAG_A_R: length 7.2
  BOTTOM w0.127: RB736.1 CB982.2 44.35,8.87 v2(43.65,8.16) 42.7,7.21 LEDB7.C1
DIAG_G: length 312.7
  TOP w0.127: v4(93.18,215.68) 93.18,216.05 94.59,217.46 96.29,217.46 P1.C9
  S16 w0.127: v4(93.18,215.68) 93.18,214.79 91.11,212.72 90.31,212.72 89.26,211.68 87.72,211.68 87.04,211 77.89,211 74.99,208.09 73.72,208.09 65.8,200.18 31.14,200.18 17.77,186.81 17.77,178.6 16.48,177.3 16.48,175.17 14.19,172.88 14.19,167.79 12.27,165.88 12.27,157.47 15.28,154.46 15.28,150.75 15.79,150.24 15.79,142.14 10.81,137.16 10.81,117.79 10.17,117.15 10.17,113.96 8.79,112.59 8.79,97.77 7.59,96.57 7.59,92.88 6.26,91.56 6.26,82.65 8.81,80.1 11.9,80.1 15.97,76.03 15.97,62.1 20.06,58.01 20.06,54.95 18.33,53.22 14.86,53.22 13.74,52.11 13.74,45.56 19.62,39.68 19.62,22.37 20.71,21.29 29.96,21.29 36.73,14.51 44.86,14.51 v1(45.3,14.07)
  BOTTOM w0.127: v2(45.94,15.21) 45.3,14.58 v1(45.3,14.07) 45.37,14 RB737.2
DIAG_G_R: length 6.8
  BOTTOM w0.127: CB983.2 RB737.1 45.37,8.99 v2(45.94,8.42) 45.94,8.1 44.2,6.36 LEDB7.C2
DISCONNECT: length 18.9
  TOP w0.127: R552.1 14.26,128.37 16.64,128.37 16.8,128.54 R553.2 17.51,128.88 v1(17.54,128.85) ; U40.AJ31 v4(26.7,126.65)
  S12 w0.127: v4(26.7,126.65) 26.17,126.11 24.42,126.11 24.15,126.39 24.15,126.87 23.87,127.15 22.42,127.15 20.95,128.62 19.98,128.62 19.76,128.85 v1(17.54,128.85)
  BOTTOM w0.127: v2(18.69,131.34) 18.08,130.73 18.08,129.39 v1(17.54,128.85)
DSR_L: length 19.4
  S5 w0.254: v1(256.14,34.73) 258.07,32.79 258.07,26.09 RJ1.F7
  BOTTOM w0.254: LB73.2 256.95,34.71 CB926.1 v1(256.14,34.73) 256.31,34.91 256.31,37.18 256.7,37.56 v2(256.7,38.01)
DTR_L: length 18.6
  S5 w0.254: RJ1.F2 261.81,24.64 260.86,25.59 260.86,33.01 v1(260.09,33.78)
  BOTTOM w0.254: v2(262.28,32.87) 262.14,32.72 LB74.2 260.81,34.71 CB927.1 260.36,34.73 260.09,34.46 v1(260.09,33.78)
EE_A0: length 5
  TOP w0.127: U8.1 144.38,244.21 144.26,244.09 R88.2 R73.2 143.67,245.91 v1(143.67,245.91)
  BOTTOM w0.127: v2(144.65,245.9) 144.64,245.91 v1(143.67,245.91)
EE_A1: length 4.1
  TOP w0.127: U8.2 v1(144.49,242.94) 144.36,243.07 R99.2 R111.2
  BOTTOM w0.127: v2(145.06,243.56) 145.06,243.51 v1(144.49,242.94)
EE_A2: length 4.4
  TOP w0.127: U8.3 v1(144.49,241.67) 144.3,241.67 R117.2 R121.2
  BOTTOM w0.127: v2(145.25,241.15) 145.02,241.15 v1(144.49,241.67)
EE_WP: length 86.9
  TOP w0.127: v1(156.18,239.11) 153.43,241.86 R106.1 R96.2 152.77,243.32 152.39,242.94 U8.7 ; P1.H8 v4(101.29,216.46)
  S9 w0.127: v1(156.62,222.54) 155.82,221.74 149.15,221.74 148.3,220.89 136.3,220.89 134.14,218.73 132.79,218.73 132.48,218.42 130.96,218.42 130.27,217.73 126.05,217.73 125.7,217.38 124.37,217.38 123.34,218.41 121.89,218.41 119.83,216.35 116.96,216.35 116.36,216.95 113.01,216.95 112.94,217.02 101.84,217.02 v4(101.29,216.46)
  S12 w0.127: v1(156.62,222.54) 157.79,223.71 157.79,237.5 v1(156.18,239.11)
  BOTTOM w0.127: v1(156.18,239.11) 155.6,239.68 v2(154.91,239.68)
EEPROM_SCL: length 12.8
  TOP w0.127: U8.6 151.24,241.65 150.08,241.65 149.57,241.15 149.57,240.26 150.21,239.62 151.94,239.62 154.86,236.7 v1(154.86,235.75) R278.1
  BOTTOM w0.127: v2(153.57,236.07) 154.54,236.07 v1(154.86,235.75)
EEPROM_SCL_R: length 9
  TOP w0.127: R278.2 154.86,233.03 v1(154.84,233.02) 154.86,233 R279.2 155.12,232.29 155.41,232 155.41,229.59 154.95,229.12 U10.9
  BOTTOM w0.127: v2(154.71,234.29) 154.71,233.14 v1(154.84,233.02)
EEPROM_SDA: length 10.2
  TOP w0.127: U8.5 152.73,240.4 156.13,237 v1(156.13,235.81) R260.1
  BOTTOM w0.127: v1(156.13,235.81) 155.22,236.72 v2(155.22,237.21)
EEPROM_SDA_R: length 9.1
  TOP w0.127: R260.2 v1(156.13,233.02) R261.2 156.39,232.29 156.6,232.09 156.6,229.63 155.6,228.63 U10.8
  BOTTOM w0.127: v2(156.05,231.81) 156.05,232.94 v1(156.13,233.02)
EN3_5: length 3.6
  TOP w0.254: U39.3 94.99,117.68 v1(94.83,117.83)
  BOTTOM w0.127: v2(93.18,117.83) v1(94.83,117.83)
  BOTTOM w0.508: RB192.2 95.29,117.83 v1(94.83,117.83)
EN3_6: length 3.5
  TOP w0.254: v1(94.83,133.63) 95.04,133.43 U30.3
  BOTTOM w0.127: v2(93.77,134.59) 94.73,133.63 v1(94.83,133.63)
  BOTTOM w0.254: v1(94.83,133.63) 95.11,133.63 RB162.2
EN_VDD1P0_ROV: length 7.9
  TOP w0.254: U33.23 116.07,124.33 117.55,122.84 v1(119.09,122.84) 119.28,123.04 C324.1 R600.2 R591.2
  BOTTOM w0.254: v1(119.09,122.84) v2(118.3,122.84)
FAN_A: length 378.5
  TOP w0.127: P1.W17 v4(113.29,226.46)
  S7 w0.127: v1(62.32,12.29) 46.6,28.02 40.62,28.02 37.54,31.1 37.54,37.62 36.95,38.21 v1(36.95,42.69) ; v1(36.08,75.16) 46.9,85.98 46.9,89.15 48.81,91.06 63.22,91.06 66.97,94.8 66.97,129.6 79.55,142.19 86.49,142.19 89.26,139.42 93.87,139.42 100.17,145.72 108.73,145.72 114.58,151.58 126.3,151.58 142.67,167.95 144.59,167.95 146.55,169.9 150.8,169.9 151.57,169.13 154.72,169.13 157.16,171.57 157.95,171.57 161.59,175.21 163.96,175.21 164.67,175.92 164.67,176.9 166.27,178.5 166.27,199.14 167.31,200.18 v1(167.31,200.13)
  S12 w0.127: v1(36.08,75.16) 36.08,74.88 34.53,73.33 34.53,63.98 36.85,61.67 36.85,55.04 37.28,54.61 37.28,52.25 37,51.97 37,48.9 38.42,47.48 38.42,44.16 v1(36.95,42.69)
  S14 w0.127: v4(113.29,226.46) 113.29,226.58 113.68,226.97 115.51,226.97 117.49,228.95 119.73,228.95 122.46,231.68 132.24,231.68 134.29,229.63 134.29,228.19 137.4,225.09 138.57,225.09 141.18,222.48 142.57,222.48 150.31,214.74 150.31,208.49 157.94,200.86 165.53,200.86 166.27,200.13 v1(167.31,200.13)
  BOTTOM w0.127: v2(167.35,198.03) 167.31,198.07 v1(167.31,200.13) ; v1(62.32,12.29) 62.33,12.29 RB738.2
FAN_A_R: length 6.6
  BOTTOM w0.127: LEDB8.C1 63.59,5 v2(63.59,8.54) 63.59,10.13 CB984.2 RB738.1
FAN_G: length 8.4
  TOP w0.127: RB722.2 120.11,208.76 119.07,209.8 119.07,210.81 v1(117.95,211.94) 116.92,212.96 P1.AB4
  BOTTOM w0.127: v2(116.87,212.06) 117.82,212.06 v1(117.95,211.94)
FAN_G_R: length 376.7
  TOP w0.127: CB976.2 122.37,208.7 v1(122.33,208.73) 122.3,208.76 RB722.1
  S5 w0.127: v1(58.92,207.34) 59.44,206.82 67,206.82 68.61,205.2 70.01,205.2 71.58,206.78 74.6,206.78 75.26,206.12 78.97,206.12 79.93,205.16 81.18,205.16 81.77,205.75 85.84,205.75 86.59,205 90.71,205 91.08,205.37 91.09,205.37 91.37,205.64 91.37,206.42 92.25,207.3 97.04,207.3 97.37,207.63 104.73,207.63 106.02,206.33 107.71,206.33 108.05,206.68 108.53,207.16 118.76,207.16 119.66,208.06 121.66,208.06 v1(122.33,208.73)
  S16 w0.127: v1(64.99,7.97) 64.35,7.34 48.05,7.34 43.03,12.35 34.95,12.35 28.35,18.96 19.52,18.96 17.07,21.41 17.07,38.9 8.52,47.45 6.68,47.45 4.21,49.92 4.21,52.37 2.48,54.1 2.48,60.64 3.51,61.68 3.51,67.13 2.8,67.84 2.8,142.4 2.16,143.03 2.16,160.74 2.75,161.32 2.75,169.78 10.64,177.68 10.64,189.68 28.33,207.37 33.6,207.37 35.29,209.05 35.29,214.74 38.61,218.06 48.2,218.06 v1(58.92,207.34)
  BOTTOM w0.127: v2(123.42,207.38) 123.42,207.65 v1(122.33,208.73) ; v1(64.99,7.97) 65.14,7.82 LEDB8.C2
FAN_IDLE: length 148.9
  TOP w0.127: P1.W21 v4(113.29,230.46) ; CONN56.19 235.91,256.88 v1(235.8,256.99)
  S7 w0.127: v1(235.8,256.99) 235.64,256.99 234.85,257.78 208.82,257.78 v1(196.56,245.53)
  S9 w0.127: v1(196.56,245.53) 195.23,244.19 195.23,239.56 194.73,239.06 182.92,239.06 181.45,237.59 178.14,237.59 177.51,236.95 176.81,236.95 175.48,235.62 172.86,235.62 167.84,230.6 165.64,230.6 164.94,229.91 147.85,229.91 142.87,234.88 134.55,234.88 134.2,234.53 120.8,234.53 119.53,235.8 115.08,235.8 114.46,235.18 114.46,231.63 v4(113.29,230.46)
  BOTTOM w0.127: v2(236.25,255.81) 236.25,256.54 v1(235.8,256.99)
FAN_INT_L: length 148
  TOP w0.127: v1(234.53,257.01) 234.64,256.9 CONN56.21 ; P1.U20 v4(111.29,229.46)
  S7 w0.127: v1(234.53,257.01) 233.53,256 207.93,256 v1(197.39,245.46)
  S9 w0.127: v1(197.39,245.46) 195.99,244.07 195.99,239.43 194.74,238.18 191.81,238.18 191.29,237.65 187.43,237.65 186.31,238.77 183.11,238.77 181.65,237.31 178.44,237.31 177.64,236.51 176.75,236.51 175.54,235.3 172.9,235.3 167.94,230.35 166.14,230.35 165.38,229.59 147.79,229.59 144.9,232.47 138.51,232.47 136.93,234.06 118.23,234.06 115.38,231.21 115.38,229.75 114.58,228.95 111.79,228.95 v4(111.29,229.46)
  BOTTOM w0.127: v1(234.53,257.01) 234.09,256.57 v2(234.09,255.88)
FAN_SCL_1: length 4.7
  TOP w0.127: CONN56.22 v1(234.64,247.24)
  BOTTOM w0.127: RB84.1 234.7,247.18 v1(234.64,247.24) 234.34,247.54 v2(234.34,248.19)
FAN_SCL_FPGA: length 133.4
  TOP w0.127: RB133.2 124.58,215.85 v1(125.63,214.79)
  S7 w0.127: v1(142.8,211.77) 142.8,211.77 142.8,213.1 150.9,221.21 165.28,221.21 168.23,224.16 168.23,230.62 173.11,235.49 175.73,235.49 177.96,237.72 177.96,239.18 180.94,242.16 187.22,242.16 188.11,243.05 200.63,243.05 201.7,244.13 v1(234.41,244.13)
  S14 w0.127: v1(125.63,214.79) 126.2,214.79 127.35,213.65 130.08,213.65 131.52,212.22 142.34,212.22 142.8,211.76 142.8,211.77 v1(142.8,211.77)
  BOTTOM w0.127: v1(234.41,244.13) 234.7,244.42 RB84.2 ; v2(125.19,215.81) 125.63,215.36 v1(125.63,214.79)
FAN_SCL_FPGA_R: length 13.1
  TOP w0.127: v1(118.71,216.95) 119.82,215.85 RB130.2 120.72,216.17 120.93,216.38 122.77,216.38 123.06,216.1 RB133.1 ; P1.Y9 v4(114.29,217.46)
  BOTTOM w0.127: v4(114.29,217.46) 114.8,216.95 v1(118.71,216.95) 118.72,216.96 118.72,217.83 117.82,218.73 117.82,218.74 v2(117.8,218.74)
FAN_SDA_1: length 5.3
  TOP w0.127: v1(236.06,247.09) 235.91,247.23 CONN56.20
  BOTTOM w0.127: v2(236.5,248.57) 236.5,247.54 v1(236.06,247.09) RB88.1
FAN_SDA_FPGA: length 138.7
  TOP w0.127: RB132.2 v1(124.76,214.81)
  S7 w0.127: v1(235.99,244) 235.3,243.3 202.02,243.3 201.07,242.35 188.72,242.35 187.69,241.33 182.58,241.33 176.11,234.86 173.19,234.86 168.75,230.42 168.75,222.55 166.7,220.51 151.29,220.51 144.24,213.46 144.24,210.64 v1(142.8,209.2)
  S14 w0.127: v1(142.8,209.2) 142.14,209.86 142.14,210.13 140.56,211.71 131.31,211.71 129.87,213.14 127.09,213.14 126.04,214.19 125.37,214.19 v1(124.76,214.81)
  BOTTOM w0.127: v2(126.66,214.44) 126.4,214.18 125.38,214.18 v1(124.76,214.81) ; RB88.2 236.06,244.06 v1(235.99,244)
FAN_SDA_FPGA_R: length 12.6
  TOP w0.127: P1.Y8 v4(114.29,216.46) ; v1(119.22,215.11) 119.52,214.81 RB129.2 120.72,214.43 120.87,214.28 122.54,214.28 RB132.1
  BOTTOM w0.127: v2(120.87,215.36) 120.61,215.11 v1(119.22,215.11) 118.33,216 114.77,216 114.31,216.46 v4(114.29,216.46)
FAP_A_FC_RX_CLK: length 7.4
  TOP w0.127: v4(20.7,131.65) U40.AP37
  BOTTOM w0.127: RB148.1 23.52,135.6 RB147.2 22.52,135.54 RB156.1
  BOTTOM w0.13: v4(20.7,131.65) 20.3,132.04 20.3,133.81 21.57,135.07 RB156.1
FAP_A_FC_RX_STAT_0: length 8.8
  TOP w0.127: v4(20.32,129.15) U40.AM37
  BOTTOM w0.127: v4(20.32,129.15) 20.37,129.19 RB171.1 20.96,128.5 21.19,128.27 RB175.2 21.19,126.99 20.85,126.65 19.63,126.65 RB177.1 19.55,127.57 18.62,128.5 18.62,129.36 v2(18.69,129.44)
FAP_A_FC_RX_STAT_1: length 19.6
  TOP w0.127: U40.AL37 21.15,128.1 v4(20.56,128.1)
  BOTTOM w0.127: v2(22.62,142.48) 21.19,142.48 20.67,141.96 20.67,140.63 RB153.1 ; RB153.1 19.9,140.62 19.65,140.37 RB158.1 19.83,139.55 20.2,139.19 20.2,137.04 19.59,136.43 19.59,131.8 ; RB153.1 20.67,140.61 RB150.2
  BOTTOM w0.13: v4(20.56,128.1) 20.56,128.35 19.93,128.98 19.93,129.4 19.59,129.74 19.59,131.8
FAP_A_FC_TX_CLK: length 6.8
  TOP w0.127: v4(20.11,130.15) U40.AN37
  BOTTOM w0.127: v4(20.11,130.15) 19.96,130.29 19.96,134.2 20.66,134.9 RB156.2
FAP_A_FC_TX_STAT_0: length 3.8
  TOP w0.127: v4(20.18,126.02) 20.31,126.15 U40.AJ37
  BOTTOM w0.127: v4(20.18,126.02) 19.99,125.82 RB177.2 19.36,125.82 18.59,126.59 v2(18.59,127.38)
FAP_A_FC_TX_STAT_1: length 12.8
  TOP w0.127: v4(20.56,127.15) U40.AK37
  BOTTOM w0.127: 19.65,128.06 19.65,129.32 19.33,129.64 19.33,131.9 19.33,131.91 19.33,137.45 v2(19.46,137.58) 19.65,137.77 RB158.2
  BOTTOM w0.13: 19.65,128.06 v4(20.56,127.15)
FAP_GPIO0: length 188.9
  TOP w0.127: v4(23.7,118.65) U40.AA34 ; R254.1 88.59,222.92 88.04,222.37 86.69,222.37 84.65,224.42 81.32,224.42 v1(81.23,224.51) ; v1(8.02,114.7) 8.02,115.05 7.4,115.66 R683.1
  S7 w0.127: v1(81.23,224.51) 73.94,217.21 72.37,217.21 67.36,212.21 63.24,212.21 v1(61.59,210.57) 61.3,210.57 51.11,200.38 33.82,200.38 17.9,184.46 17.9,178.81 10.44,171.35 10.44,169.26 8.47,167.29 8.47,163.93 4.69,160.15 4.69,153.18 4.32,152.8 4.32,135.86 6.9,133.28 6.9,115.82 v1(8.02,114.7)
  S14 w0.127: v1(8.02,114.7) 7.6,115.12 7.6,116.82 7.97,117.19 10.37,117.19 11.4,118.22 18.8,118.22 20.07,119.48 22.43,119.48 23.27,118.65 v4(23.7,118.65)
  BOTTOM w0.127: v2(60.45,210.57) v1(61.59,210.57)
FAP_GPIO1: length 197
  TOP w0.127: v4(24.7,118.65) U40.AA33 ; R366.1 95.95,238.21 v1(95.94,238.22) ; R639.1 12.16,120.75 v1(12.13,120.72)
  S9 w0.127: v1(65.89,204.05) 65.77,204.05 61.44,199.72 34.46,199.72 18.37,183.63 18.37,178.31 17.72,177.67 17.72,176.3 15.08,173.66 15.08,167.38 13.34,165.65 13.34,159.03 15.08,157.29 15.08,155.82 17.03,153.86 17.03,149.96 17.92,149.08 17.92,140.99 15.24,138.31 13.75,138.31 10.81,135.37 10.81,124.07 10.79,124.04 10.79,123.55 10.81,123.53 10.81,122.2 12.13,120.88 v1(12.13,120.72)
  S14 w0.127: v1(71.02,208.89) 70.73,208.89 v1(65.89,204.05) ; v4(24.7,118.65) 24.29,119.05 23.3,119.05 22.61,119.74 19.69,119.74 19.21,119.26 14.19,119.26 12.74,120.71 12.19,120.71 12.18,120.72 v1(12.13,120.72)
  S16 w0.127: v1(95.94,238.22) 95.94,237.83 95.06,236.95 90.9,236.95 89.37,235.43 86.71,235.43 81.2,229.93 81.2,225.87 81.8,225.27 81.8,222.32 79.06,219.58 79.06,218.75 73.77,213.47 73.77,211.63 v1(71.02,208.89)
  BOTTOM w0.127: v2(66.89,204.12) 65.97,204.12 v1(65.89,204.05) ; v1(71.02,208.89) 71.83,208.89 v2(71.84,208.87)
FAP_NSE_SYNC_IN0: length 199.9
  TOP w0.127: R662.2 9.77,116.69 8.8,115.72 8.8,115.47 v1(8.63,115.29) ; v1(104.26,237.77) 104.13,237.64 R61.1
  S9 w0.127: v1(69.75,209.84) 68.93,209.84 59.44,200.36 33.77,200.36 17.12,183.71 17.12,181.82 16.28,180.99 16.28,179.61 11.89,175.22 11.89,168.64 10.76,167.51 10.76,163.8 11.62,162.94 11.62,158.39 13.34,156.68 13.34,154.77 14.13,153.97 14.13,150.32 15.6,148.85 15.6,148.84 15.65,148.79 15.65,142.26 11.63,138.25 10.81,138.25 7.18,134.62 7.18,116.33 8.22,115.29 v1(8.63,115.29)
  S16 w0.127: v1(69.75,209.84) 70.83,209.84 72.86,211.88 72.86,213.13 78.61,218.87 78.61,219.88 80.71,221.99 80.71,222.61 80.36,222.96 80.36,231.93 84.7,236.27 87.93,236.27 90.67,239.01 100.46,239.01 101.22,238.25 103.77,238.25 v1(104.26,237.77)
  BOTTOM w0.127: v1(69.75,209.84) 69.05,209.84 v2(68.93,209.72)
FAP_NSE_SYNC_IN0_R: length 21.7
  TOP w0.127: v1(14.49,117.67) 14.46,117.7 R663.1 13.75,117.98 13.55,118.18 12.21,118.18 R662.1 ; v4(22.7,118.65) U40.AA35
  S14 w0.127: v4(22.7,118.65) 22.28,118.65 21.82,119.1 20.05,119.1 18.9,117.96 16.13,117.96 15.37,117.2 14.96,117.2 v1(14.49,117.67)
  BOTTOM w0.127: v1(14.49,117.67) 14.49,116.19 15.28,115.4 15.28,112.8 v2(16.41,111.67)
FAP_NSE_SYNC_IN1: length 192.4
  TOP w0.127: v1(88.16,228.4) 88.56,228 R211.1 ; U40.AB35 22.72,119.62 19.32,119.62 17.85,118.16 17.26,118.16 R664.1 17.34,117.7 v1(17.57,117.47)
  S7 w0.127: v1(17.57,117.47) 17.57,117.4 14.88,114.71 14.16,114.71 13.45,115.42 12.57,115.42 11.11,113.97 7.26,113.97 6.62,114.6 6.62,130.12 3.92,132.82 3.92,153.04 3.54,153.42 3.54,157.22 4.22,157.89 4.22,160.26 8.16,164.2 8.16,167.74 9.79,169.38 9.79,171.98 16.48,178.66 16.48,180.85 17.11,181.49 17.11,184.18 34.2,201.27 51.51,201.27 63.06,212.82 67.1,212.82 71.77,217.49 73.64,217.49 79.54,223.38 79.54,223.79 83.89,228.14 87.91,228.14 v1(88.16,228.4)
  BOTTOM w0.127: v2(85.94,230.67) 86.71,229.91 87.32,229.91 88.16,229.06 v1(88.16,228.4)
FAP_NSE_SYNC_OUT: length 176.1
  TOP w0.127: v4(23.7,119.65) U40.AB34 ; R78.1 88.78,212.19 87.36,210.76 v1(87.36,210.58) ; v1(5.81,122.53) 5.73,122.6 R625.1
  S9 w0.127: v1(87.36,210.58) 87.04,210.89 82.49,210.89 82.41,210.81 69.13,210.81 59.16,200.84 33.71,200.84 15.52,182.65 15.52,179.42 11.38,175.28 11.38,168.82 10.32,167.76 10.32,163.58 11.16,162.74 11.16,158.29 12.83,156.63 12.83,154.58 13.74,153.67 13.74,150.34 15.34,148.74 15.34,142.43 11.56,138.64 10.56,138.64 6.72,134.8 6.72,123.44 v1(5.81,122.53)
  S14 w0.127: v4(23.7,119.65) 23.35,119.99 19.18,119.99 18.73,119.54 14.43,119.54 12.71,121.26 11.76,121.26 11.69,121.32 10.51,121.32 9.65,122.17 7.86,122.17 7.51,122.53 v1(5.81,122.53)
FAP_SYNC0_R: length 35.1
  TOP w0.127: U40.AC29 v4(28.7,120.65) ; v1(11.4,116.46) 11.4,115.92 11.14,115.67 R1186.1
  S14 w0.127: v4(28.7,120.65) 28.16,120.11 28.16,118.47 27.78,118.09 25.4,118.09 25.15,117.83 25.15,117.45 24.88,117.19 20.56,117.19 19.25,115.87 17.96,115.87 16.97,114.88 14.25,114.88 13.53,115.6 12.11,115.6 11.93,115.78 11.91,115.78 11.56,116.13 11.56,116.24 11.4,116.41 v1(11.4,116.46)
  BOTTOM w0.127: v1(11.4,116.46) 11.06,116.12 11.06,113.81 6.59,109.34 5.3,109.34 v2(4.53,108.57)
FAP_SYNC1: length 160.4
  TOP w0.127: R624.1 v1(4.08,123.42) ; v1(88.45,211.18) 88.46,211.17 R77.2
  S9 w0.127: v1(88.45,211.18) 82.39,211.18 80.5,213.07 75.64,213.07 73.89,211.32 70.13,211.32 69.39,212.06 v1(69.24,212.06) 61.43,204.25 51.96,204.25 50.15,206.05 38.04,206.05 36.23,204.25 32.73,204.25 12.35,183.86 12.35,180.82 4.85,173.33 4.85,167.68 6.12,166.41 6.12,161.14 4.66,159.67 4.66,154 3.08,152.41 3.08,130.66 4.84,128.89 4.84,126.37 4.08,125.61 v1(4.08,123.42)
  BOTTOM w0.127: v1(69.24,212.06) 68.8,212.51 v2(68.8,213.21)
FAP_SYNC1_FPGA: length 10.3
  TOP w0.127: R77.1 v1(91.09,211.17) ; P1.C6 v4(96.29,214.46)
  S12 w0.127: v1(91.09,211.17) 91.86,211.17 94.65,213.97 95.8,213.97 v4(96.29,214.46)
  BOTTOM w0.127: v2(89.31,210.35) 90.07,211.11 91.02,211.11 v1(91.09,211.17)
FAP_SYNC1_R: length 48.8
  TOP w0.127: U40.AC30 v4(27.7,120.65) ; R624.2 v1(4.08,120.93)
  S9 w0.127: v4(27.7,120.65) 27.19,120.14 27.19,119.5 26.86,119.17 20.56,119.17 19.73,118.34 19.73,113.6 17.64,111.52 17.64,108.35 15.48,106.18 14.21,106.18 12.72,107.67 10.31,107.67 8.84,109.14 8.84,111.55 4.18,116.21 4.18,120.83 v1(4.08,120.93)
  BOTTOM w0.127: v2(3.33,118.72) 3.33,120.18 v1(4.08,120.93)
FAP_TIME_VAL0: length 157.8
  TOP w0.127: v1(9.11,122.78) 9.13,122.81 R630.1
  S5 w0.127: v1(88.12,212.22) 88.11,212.22 87.63,211.74 87.01,211.74 86.63,211.37 82.82,211.37 81.11,213.08 77.83,213.08 77.2,213.71 72.79,213.71 v1(71.87,214.63)
  S7 w0.127: v1(71.87,214.63) 70.56,214.63 67.3,211.37 64.95,211.37 53.57,200 33.95,200 18.21,184.26 18.21,178.74 10.7,171.22 10.7,169.16 8.86,167.32 8.86,163.55 4.95,159.64 4.95,153.06 4.6,152.71 4.6,136.04 7.53,133.11 7.53,122.7 8.08,122.15 8.48,122.15 v1(9.11,122.78)
  BOTTOM w0.127: v1(88.12,212.22) 88.12,212.23 89.1,213.21 R60.2 ; v1(71.87,214.63) v2(71.87,215.52)
FAP_TIME_VAL0_FPGA: length 18
  TOP w0.127: P1.H12 v4(101.29,221.46)
  BOTTOM w0.127: R60.1 90.15,213.9 91.13,214.87 v2(92.05,214.87) 92.07,214.9 93.03,214.9 93.85,215.72 93.85,218.51 95.66,220.32 101.18,220.32 101.44,220.57 101.44,221.31 v4(101.29,221.46)
FAP_TIME_VAL0_R: length 35.5
  TOP w0.127: v4(27.7,122.65) U40.AE30 ; R630.2 11.01,122.81 v1(12.09,121.73)
  S12 w0.127: v4(27.7,122.65) 27.7,122.31 27.49,122.11 26.49,122.11 26.2,121.82 26.2,121.43 25.85,121.08 25.47,121.08 25.16,120.77 25.16,120.37 24.91,120.12 20.31,120.12 18.18,122.24 13.17,122.24 12.66,121.73 v1(12.09,121.73)
  BOTTOM w0.127: v2(5.39,112.17) 6.04,111.52 7.03,111.52 9.68,114.18 9.68,120 11.41,121.73 v1(12.09,121.73)
FAP_TIME_VAL1: length 161.8
  TOP w0.127: R580.1 3.95,127.28 v1(4.08,127.4) ; R59.2 88.66,220.89 v1(87.72,221.83)
  S9 w0.127: v1(78.07,219.94) 76.59,218.46 76.59,214.38 75.68,213.48 69.39,213.48 60.61,204.7 52.16,204.7 50.37,206.49 34.53,206.49 11.71,183.68 11.71,180.63 4.22,173.14 4.22,167.36 3.39,166.53 3.39,153.32 2.44,152.37 2.44,130.58 4.59,128.44 4.59,127.91 v1(4.08,127.4)
  S12 w0.127: v1(87.72,221.83) 85.8,221.83 84.32,220.35 78.48,220.35 v1(78.07,219.94)
  BOTTOM w0.127: v1(78.07,219.94) 79.47,218.54 v2(79.72,218.54)
FAP_TIME_VAL1_FPGA: length 20.4
  TOP w0.127: P1.N13 v4(107.29,222.46) ; R59.1 v1(91.15,220.89)
  S7 w0.127: v4(107.29,222.46) 106.05,222.46 104.45,220.85 95.25,220.85 94.74,221.36 91.63,221.36 v1(91.15,220.89)
  BOTTOM w0.127: v1(91.15,220.89) 90.9,220.89 v2(90.04,220.02)
FAP_TIME_VAL1_R: length 49.7
  TOP w0.127: v1(5.81,124.76) 4.4,124.76 3.95,125.21 R580.2 ; U40.AC31 v4(26.7,120.65)
  S9 w0.127: v1(5.81,124.76) 5.25,124.2 5.25,121.54 5.73,121.05 6.25,121.05 6.47,120.84 6.47,114.44 14.47,106.44 15.37,106.44 17.39,108.45 17.39,111.63 19.43,113.68 19.43,118.42 21.2,120.19 26.24,120.19 v4(26.7,120.65)
  BOTTOM w0.127: v2(4.85,124.81) 4.91,124.76 v1(5.81,124.76)
FAP_TS_BIT_CLK0: length 187
  TOP w0.127: R83.2 103.12,237.56 103.15,237.6 103.15,237.61 v1(103.11,237.61) ; R638.1 9.19,121.79 v1(9.02,121.61)
  S16 w0.127: v1(103.11,237.61) 103.15,237.61 103.15,237.6 103.15,237.61 103.04,237.61 102.32,236.88 101.12,236.88 100.1,235.87 91.52,235.87 88.42,232.76 86.51,232.76 83.59,229.84 83.59,227.73 82.85,226.98 82.85,220.45 75.66,213.26 75.66,211.86 65.38,201.57 65.32,201.55 30.66,201.55 15.33,186.22 15.33,175.57 11.55,171.79 11.55,168.58 10.19,167.22 10.19,162.21 7.8,159.82 7.8,151.31 6.06,149.58 6.06,145.02 7.08,144 7.22,143.79 7.29,143.72 7.29,143.68 9.74,141.23 9.74,122.34 v1(9.02,121.61)
FAP_TS_BIT_CLK0_FPGA: length 14.9
  TOP w0.127: R83.1 103.12,234.93 103.14,234.91 103.14,234.91 v1(103.15,234.91) ; P1.M14 v4(106.29,223.46)
  S9 w0.127: v1(103.15,234.91) 103.24,234.81 103.24,233.3 103.29,233.25 103.29,226.95 104.38,225.85 104.38,224.76 105.15,224 105.68,224 106.22,223.46 v4(106.29,223.46)
FAP_TS_BIT_CLK1: length 191
  TOP w0.127: v1(3.99,128.19) 4.49,128.19 4.97,127.71 R581.1 ; R82.2 105.15,237.88 104.36,238.67 v1(104.36,238.73)
  S9 w0.127: v1(3.99,128.19) 1.9,130.29 1.9,152.52 1.93,152.56 1.93,153.01 2.76,153.83 2.76,172.63 11.1,180.97 11.1,183.78 34.32,207 50.93,207 52.73,205.2 60.23,205.2 v1(63.78,208.76)
  S16 w0.127: v1(63.78,208.76) 64,208.54 64.62,208.54 65.37,209.29 65.37,210.19 70.84,215.66 72.19,215.66 75.48,218.95 75.48,219.89 79.36,223.77 79.36,233.8 86.26,240.7 102.39,240.7 v1(104.36,238.73)
FAP_TS_BIT_CLK1_FPGA: length 10.3
  TOP w0.127: v1(106.1,234.13) 105.15,235.08 R82.1 ; P1.M18 v4(106.29,227.46)
  S14 w0.127: v1(106.1,234.13) 106.53,233.7 106.53,232.6 106.16,232.24 106.16,229.42 105.8,229.06 105.8,227.98 106.29,227.5 v4(106.29,227.46)
FB_VCC5P0: length 7
  TOP w0.508: U34.5 v1(244.96,164.49) 244.72,164.25 v2(243.81,164.25) R667.1 243.81,165.82 243.34,166.3 R688.2
  BOTTOM w0.254: v2(243.81,164.25) 244.72,164.25 v1(244.96,164.49)
FC0_156.25M_REFCLKN_R: length 13.3
  TOP w0.095: R1375.2 141.05,168.23 142.84,168.23 142.97,168.11 142.97,167.81 R1400.1 143.54,168.18 144.3,168.18 145.44,169.33 148.48,169.33 150.03,170.88 150.03,171.98 150.17,172.11 U77.67
FC0_156.25M_REFCLKP_R: length 13.2
  TOP w0.095: R1374.2 140.53,168.53 140.59,168.46 142.84,168.46 142.97,168.59 142.97,168.88 R1399.1 143.64,168.41 144.21,168.41 145.35,169.56 148.39,169.56 149.81,170.97 149.81,171.98 149.67,172.11 U77.66
FC1_156.25M_REFCLKN_R: length 10.5
  TOP w0.095: R1377.2 140.56,171.22 140.74,171.04 143.03,171.04 143.19,171.2 R1402.1 143.61,171.59 143.7,171.49 143.7,171.16 143.8,171.07 147.81,171.07 148.33,171.58 148.33,172.16 148.3,172.18 148.17,172.32 U77.63
FC1_156.25M_REFCLKP_R: length 10.5
  TOP w0.095: R1376.2 141.08,170.81 143.01,170.81 143.19,170.63 R1401.1 143.61,170.32 143.7,170.41 143.7,170.74 143.8,170.84 147.91,170.84 148.56,171.49 148.56,172.18 148.67,172.3 U77.64
FC2_156.25M_REFCLKN_R: length 6.8
  TOP w0.095: R1379.2 141.05,173.56 142.84,173.56 143.17,173.23 R1394.1 143.58,173.07 143.68,173.17 143.68,173.47 143.77,173.56 143.87,173.56 143.88,173.55 145.73,173.55 145.87,173.42 U77.60
FC2_156.25M_REFCLKP_R: length 6.8
  TOP w0.095: U77.59 145.87,173.92 145.73,173.78 143.97,173.78 143.96,173.79 143.77,173.79 143.68,173.89 143.68,174.18 143.58,174.28 R1403.1 143.17,174.12 142.84,173.79 141.05,173.79 R1378.2
FC_SYNC_VDDP_1P8: length 4.7
  TOP w0.381: v4(28.7,122.65) U40.AE29
  BOTTOM w0.381: v2(16.26,141.53) 14.72,140 14.72,139.19 v1(14.93,138.99) ; v4(28.7,122.65) 28.2,122.15 CB480.1
  vias: v1(15.36,139.6)
FCCM10_5: length 4.6
  TOP w0.254: v1(102.33,119.35) 102.33,118.59 101.41,117.68 U39.10
  TOP w0.381: v1(102.33,119.35) R655.2
  BOTTOM w0.381: v1(102.33,119.35) 102.55,119.35 v2(103.21,120.01)
FCCM10_6: length 5
  TOP w0.254: U30.10 101.25,133.43 102.2,134.38 v1(102.2,134.57) 102.23,134.59 R491.2
  BOTTOM w0.381: v2(103.29,136.32) 103.29,135.66 v1(102.2,134.57)
FPGA1588_TOD_OUT_R: length 8.5
  TOP w0.127: R326.1 99.9,235.79 99.9,234.11 v1(100.1,233.91) 101.79,232.22 P1.H22
  BOTTOM w0.127: v2(99.5,236.29) 99.74,236.05 99.74,234.27 v1(100.1,233.91)
FPGA1588_TOD_OUT_TO_GPS MODULE: length 273.9
  TOP w0.127: R326.2 v1(100.04,237.69) ; v1(216.31,98.27) 216.31,94.44 215.09,93.22 204.5,93.22 204.1,93.61 R726.2
  S12 w0.127: v1(216.31,98.27) 215.8,98.78 215.8,102.65 215.99,102.84 215.99,104.87 214.66,106.21 214.66,113.64 216.57,115.55 216.57,137.78 v1(218.98,140.18)
  S14 w0.127: v1(100.04,237.69) 100.04,238.64 104.73,243.33 107.59,243.33 110.66,246.41 132.23,246.41 133.28,245.36 136.05,245.36 136.53,244.88 146.08,244.88 154.18,236.78 154.18,235.33 155.45,234.06 155.45,229.59 156.51,228.52 159.33,228.52 164.82,223.04 164.82,215.36 171.28,208.9 179.04,208.9 179.94,208 208.46,208 213.31,203.15 213.31,154.74 212.56,153.99 212.56,146.21 218.59,140.18 v1(218.98,140.18)
  BOTTOM w0.127: v2(214.72,98.14) 214.85,98.27 v1(216.31,98.27)
FPGA1588_TOD_OUT_TO_RJ: length 221.5
  TOP w0.127: R408.2 v1(124.77,217.88)
  TOP w0.254: U51.9 v1(244.38,90.01)
  S12 w0.127: v1(244.38,90.01) 244.36,90.01 243.5,90.88 243.5,93.01 243.93,93.44 243.93,96.39 241.38,98.95 v1(241.38,99.97)
  S14 w0.127: v1(124.77,217.88) 125.14,217.88 126.18,216.84 129.16,216.84 131.45,214.55 135.94,214.55 136.83,213.66 142.28,213.66 142.28,213.67 143.01,213.67 144.32,212.36 144.32,206.05 154.74,195.64 163.44,195.64 174.4,184.69 174.4,157.01 175,156.42 175,153.69 177.64,151.05 177.64,147.04 180.03,144.65 187.75,144.65 190.97,141.43 190.97,136.58 193.54,134.02 202.28,134.02 203.67,132.62 211.99,132.62 213.39,131.23 213.39,120.4 214.53,119.26 214.53,108.16 218.11,104.58 218.89,104.58 v1(219.1,104.37)
  S16 w0.127: v1(241.38,99.97) 236.22,105.13 221.35,105.13 220.23,104.01 219.46,104.01 v1(219.1,104.37)
  BOTTOM w0.127: v2(125.7,219.49) 125.7,218.81 v1(124.77,217.88)
FPGA1588_TOD_OUT_TO_RJ_R: length 2.9
  TOP w0.127: R408.1 122.36,217.88 v1(122.33,217.9) 122.3,217.88 121.63,217.88 R407.1
  BOTTOM w0.127: v1(122.33,217.9) 122.96,217.9 v2(123.54,217.33)
FPGA1588_UART1_TOD_OUT: length 15
  TOP w0.127: R407.2 119.94,217.88 119.29,218.53 v1(119.29,219.27) ; P1.T11 v4(110.29,219.46)
  S9 w0.127: v4(110.29,219.46) 110.82,218.92 114.33,218.92 114.77,219.36 114.77,219.87 114.85,219.95 116.73,219.95 117.63,219.05 119.07,219.05 v1(119.29,219.27)
  BOTTOM w0.127: v2(119.73,220.57) 119.73,219.7 v1(119.29,219.27)
FPGA_1V2: length 185.6
  TOP w0.254: R161.2 238.51,210.7 238.54,210.67 v1(238.73,210.67)
  TOP w0.381: P1.N5 v4(107.29,213.46) ; P1.L5 v4(104.29,213.46) ; P1.P17 v4(108.29,226.46) ; P1.K6 v4(103.29,214.46) ; P1.M10 v4(106.29,218.46) ; P1.N16 v4(107.29,225.46) ; P1.J5 v4(102.29,213.46) ; P1.N9 v4(107.29,217.46)
  TOP w0.508: P1.J7 v4(102.29,215.46) ; P1.M6 v4(106.29,214.46) ; P1.J9 v4(102.29,217.46) ; P1.M12 v4(106.29,221.46) ; P1.F7 v4(99.29,215.46) ; CB36.2 37.37,227.93 CONN6.9 ; P1.P8 v4(108.29,216.46) ; P1.R7 v4(109.29,215.46) ; P1.P12 v4(108.29,221.46) ; P1.U16 v4(111.29,225.46) ; P1.H6 v4(101.29,214.46) ; P1.P6 v4(108.29,214.46) ; P1.G9 v4(100.29,217.46) ; v4(102.33,219.49) 102.33,219.5 P1.J11 ; P1.L7 v4(104.29,215.46) ; P1.L9 v4(104.29,217.46) ; P1.T10 v4(110.29,218.46) ; P1.G13 v4(100.29,222.46) ; P1.J17 v4(102.29,226.46) ; P1.L11 v4(104.29,219.46) ; P1.T12 v4(110.29,221.46) ; P1.K8 v4(103.29,216.46) ; P1.L17 v4(105.29,226.46) ; P1.K16 v4(103.29,225.46)
  S9 w0.254: v1(134.27,199.49) 136.87,202.09 165.43,202.09 170.1,206.76 170.51,206.76 171.82,208.06 178,208.06 178.25,207.81 196.22,207.81 196.99,208.58 202.42,208.58 207.04,213.21 218.53,213.21 218.85,212.89 225.64,212.89 227.68,214.92 230.85,214.92 232.06,213.71 232.06,213.33 232.57,212.82 234.85,212.82 235.55,212.13 237.9,212.13 238.73,211.3 v1(238.73,210.67)
  S14 w0.254: v1(117.38,209.4) 117.38,207.49 121.76,203.11 121.76,202.85 125.12,199.49 v1(134.27,199.49)
  V18 w0.635: CONN6.9 37.37,229.27 ; CONN6.9 36.04,227.94 ; CONN6.9 37.37,226.6 ; CONN6.9 38.71,227.94
  BOTTOM w0.127: v1(238.73,210.67) 239.17,211.11 v2(239.74,211.11)
  BOTTOM w0.254: v4(108.29,214.46) 107.81,214.93 CB1117.1 ; v4(111.29,225.46) 110.8,224.98 CB1115.1 ; v4(102.29,226.46) 102.73,226.01 CB1135.1 ; CB1118.1 99.78,215.18 99.53,215.43 99.32,215.43 v4(99.29,215.46) ; v4(106.29,218.46) 105.69,219.06 CB1114.2
  BOTTOM w0.305: CB1130.1 106.78,224.95 v4(107.29,225.46) ; CB1131.1 108.77,226.94 v4(108.29,226.46)
  BOTTOM w0.381: CB1116.1 109.8,218.84 110.18,218.46 v4(110.29,218.46) ; v4(101.29,214.46) 101.8,214.97 CB1129.1 ; v4(102.29,213.46) 101.8,213.94 CB1125.1 ; v4(100.29,217.46) CB1128.1 ; v4(108.29,221.46) 107.84,221.01 CB1133.1 ; v4(103.29,225.46) 102.78,225.96 CB1135.1 ; CB1112.2 104.12,219.63 v4(104.29,219.46) ; CB1119.1 100.79,221.96 v4(100.29,222.46) ; v4(106.29,214.46) 105.64,215.1 CB1126.1 ; CB1132.1 110.76,220.98 v4(110.29,221.46) ; v4(106.29,221.46) 105.79,221.96 CB1134.1
  BOTTOM w0.508: CB1113.2 104.59,217.15 v4(104.29,217.46) ; v4(107.29,213.46) 107.72,213.89 CB1127.1
  vias: v1(77.18,234.29) v1(77.18,233.4) v1(77.18,232.51) v1(116.61,209.4) v1(117.31,210.09)
FPGA_1V2_MON: length 14.7
  TOP w0.254: v1(234.31,217.24) U7.52 235.88,217.24 236.14,216.98 236.14,216.47 236.75,215.86 236.75,214.39 236.22,213.86 C104.1 236.22,212.26 236.47,212 237.69,212 238.14,212.46 R161.1
  BOTTOM w0.127: v2(238.34,214.98) 237.9,215.43 236.12,215.43 v1(234.31,217.24)
FPGA_2V5: length 259.1
  TOP w0.508: RB1305.1 124.72,219.94 v1(124.87,220.09) ; RB1307.1 111.41,205.39 v1(111.15,205.65) ; R208.1 v1(238.96,208.7)
  S5 w0.254: 123.79,206.03 123.79,218.98 124.87,220.06 v1(124.87,220.09)
  S5 w0.381: v1(105.31,205.78) 106.6,204.48 109.99,204.48 v1(111.15,205.65) 111.92,204.89 122.65,204.89 123.79,206.03
  S7 w0.381: v1(105.31,205.78) 103.85,204.32 102.07,204.32 100.86,203.1 100.86,202.12 100.04,201.29 80.65,201.29 78.32,203.62 78.32,205.34 v1(78.35,205.36)
  S9 w0.254: v1(238.96,208.7) 238.53,208.7 235.61,211.62 232.76,211.62 232.06,212.32 218.28,212.32 217.52,211.55 206.09,211.55 202.56,208.03 197.21,208.03 196.32,207.13 176.45,207.13 168.5,199.19 141.33,199.19 137.78,195.63 94.44,195.63 88.49,201.58 82.84,201.58 79.06,205.36 v1(78.35,205.36)
  S9 w0.381: CONN6.21 38.71,233.44 ; CONN6.21 37.37,232.1 ; CONN6.21 36.04,233.44 ; CONN6.21 37.37,234.77
  BOTTOM w0.127: v1(238.96,208.7) 238.96,207.41 v2(238.73,207.17) ; LB107.1 77.07,206.63
  BOTTOM w0.254: 75.75,214.51 CB1137.1 ; CB1137.1 76.26,215.14 ; CB1137.1 75.75,215.71 ; CB1138.1 75.78,225.52 ; CB1138.1 75.78,224.51 ; CB1138.1 76.3,224.96
  BOTTOM w0.381: CONN6.21 37.37,234.77 ; CONN6.21 37.37,232.1 ; CONN6.21 36.04,233.44 ; CONN6.21 38.71,233.44
  BOTTOM w0.508: CB12.1 37.43,237.91
  vias: v1(36.41,236.89) v1(36.41,236) v1(37.43,236.89) v1(37.43,236) v1(38.51,236.89) v1(38.51,236) v1(75.85,223.56) v1(75.86,222.67) v1(75.91,221.89) v1(76.74,223.56)
FPGA_2V5_MON: length 13.2
  TOP w0.254: R208.2 R195.1 236.22,210.17 C118.1 235.55,212.03 235.55,214.05 236.15,214.66 236.15,215.85 235.76,216.24 U7.50 v1(234.35,216.24)
  BOTTOM w0.127: v2(236.44,214.09) 235.61,214.09 234.35,215.36 v1(234.35,216.24)
FPGA_25M_REF_CLK_N: length 1
  TOP w0.095: R1393.1 139.65,181.97 C908.1
FPGA_25M_REF_CLK_N_F: length 62.1
  TOP w0.095: R1503.1 110,205.23 110,205.62 v3(110.29,205.91) ; v3(136.43,182.16) 136.72,182.46 137.28,182.46 C908.2 ; P1.J10 v3(103.29,218.46)
  S7 w0.108: v3(136.43,182.16) 136.69,182.43 arc(136.73,182.45) 136.77,182.46 136.95,182.46 arc(137.1,182.4) 137.16,182.25 137.16,181.84 arc(137.11,181.58) 136.96,181.35 arc(136.6,181.11) 136.17,181.03 133.94,181.03 arc(133.7,181.07) 133.5,181.21 129.4,185.31 arc(129.02,185.56) 128.57,185.65 arc(126.79,186) 125.28,187.01 111.84,200.46 arc(110.47,202.51) 109.99,204.93 109.99,205.6 v3(110.29,205.91) 110,206.2 110,206.77 arc(109.92,207.16) 109.7,207.49 109.7,207.49 109.62,207.57 arc(109.36,207.75) 109.05,207.81 108.86,207.81 arc(108.43,207.89) 108.06,208.14 105.43,210.77 arc(105.16,211.17) 105.07,211.64 105.07,218.67 104.86,218.88 103.71,218.88 v3(103.29,218.46)
FPGA_25M_REF_CLK_N_R: length 8.3
  TOP w0.095: U77.46 145.87,180.42 145.73,180.55 145.05,180.55 144.43,181.17 144.43,181.96 143.94,182.45 143.77,182.45 143.68,182.36 143.68,182.06 143.58,181.96 R1383.1 143.17,182.28 143,182.45 141.17,182.45 141.08,182.36 141.08,182.06 140.98,181.96 R1393.2
FPGA_25M_REF_CLK_P: length 1
  TOP w0.095: C909.1 138.69,183.17 R1392.1
FPGA_25M_REF_CLK_P_F: length 62
  TOP w0.095: v3(109.48,205.91) 109.77,205.62 109.77,205.23 R1504.1 ; C909.2 137.28,182.69 136.72,182.69 v3(136.43,182.98) ; P1.K10 v3(104.29,218.46)
  S7 w0.108: v3(104.29,218.46) 104.48,218.66 104.76,218.66 104.84,218.58 104.84,211.64 arc(104.95,211.08) 105.27,210.61 107.89,207.98 arc(108.34,207.68) 108.86,207.58 109.05,207.58 arc(109.27,207.54) 109.45,207.41 109.54,207.33 arc(109.71,207.07) 109.77,206.77 109.77,206.2 v3(109.48,205.91) 109.76,205.63 109.76,204.93 arc(110.26,202.42) 111.68,200.29 125.12,186.85 arc(126.7,185.79) 128.57,185.42 arc(128.93,185.35) 129.24,185.14 133.33,181.05 arc(133.61,180.86) 133.94,180.8 arc(134.04,180.76) 134.08,180.66 arc(134.12,180.56) 134.22,180.52 134.38,180.52 arc(134.47,180.56) 134.51,180.66 arc(134.55,180.76) 134.65,180.8 136.17,180.8 arc(136.68,180.9) 137.12,181.19 arc(137.32,181.49) 137.39,181.84 137.39,182.25 arc(137.26,182.56) 136.95,182.69 136.77,182.69 arc(136.73,182.69) 136.69,182.72 v3(136.43,182.98)
FPGA_25M_REF_CLK_P_R: length 8.3
  TOP w0.095: R1392.2 140.98,183.17 141.08,183.07 141.08,182.78 141.17,182.68 143.03,182.68 143.17,182.82 R1382.1 143.58,183.17 143.68,183.07 143.68,182.78 143.77,182.68 144.03,182.68 144.66,182.06 144.66,181.26 145.14,180.78 145.73,180.78 145.87,180.92 U77.45
FPGA_156.25M_REF_CLK_N: length 1
  TOP w0.095: C988.1 138.68,176.5 R1387.1
FPGA_156.25M_REF_CLK_N_F: length 65.7
  TOP w0.095: P1.AB12 116.11,220.63 117.19,220.63 117.26,220.56 118.1,220.56 v3(118.39,220.85) 118.68,220.56 120.13,220.56 120.22,220.65 120.22,220.86 120.32,220.95 R1502.1 ; C988.2 137.29,176.02 137.16,176.02 137.07,176.02 137.03,176.02 v3(136.63,176.42)
  S7 w0.108: v3(118.39,220.85) 118.68,220.56 121.33,220.56 arc(121.96,220.43) 122.5,220.08 122.43,220.14 123.09,219.48 arc(123.47,218.92) 123.6,218.25 123.6,201.95 arc(123.94,200.23) 124.91,198.78 138.31,185.38 arc(138.78,184.68) 138.95,183.85 138.95,180.81 arc(138.87,180.45) 138.67,180.14 137.61,179.08 arc(137.56,178.96) 137.61,178.84 arc(137.65,178.72) 137.61,178.6 137.46,178.46 arc(137.34,178.41) 137.22,178.46 arc(137.1,178.51) 136.98,178.46 136.84,178.31 arc(136.79,178.19) 136.84,178.08 arc(136.89,177.96) 136.84,177.84 136.7,177.69 arc(136.58,177.64) 136.46,177.69 arc(136.34,177.74) 136.22,177.69 135.56,177.03 arc(135.48,176.91) 135.45,176.77 135.45,176.37 arc(135.47,176.26) 135.51,176.15 arc(135.63,176.03) 135.79,175.97 arc(135.82,175.97) 135.85,175.97 136.18,175.97 arc(136.5,176.1) v3(136.63,176.42)
FPGA_156.25M_REF_CLK_N_R: length 7.3
  TOP w0.095: R1387.2 141.05,176.01 143.05,176.01 143.16,176.12 143.16,176.49 R1396.1 143.58,176.5 143.68,176.41 143.68,176.11 143.77,176.01 144.35,176.01 145.13,175.23 145.57,175.23 145.75,175.42 U77.56
FPGA_156.25M_REF_CLK_P: length 1
  TOP w0.095: R1386.1 138.68,175.3 C987.1
