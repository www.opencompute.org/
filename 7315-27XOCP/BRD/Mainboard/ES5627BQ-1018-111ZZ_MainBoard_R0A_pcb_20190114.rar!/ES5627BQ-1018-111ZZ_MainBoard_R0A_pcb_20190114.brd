# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P03_LED_R_2: length 138.8
  TOP w0.127: R884.2 194.02,77.63 v1(194.03,77.64) ; v4(204.55,187.58) U9.M15
  S7 w0.127: v1(194.03,77.64) 193.53,78.14 192.05,78.14 188.43,81.76 188.43,131.29 189.83,132.69 189.83,138.81 191.18,140.15 191.18,142.02 192.88,143.72 192.88,144.24 193.21,144.57 193.65,144.57 196.51,147.43 201.41,147.43 206.28,152.29 206.28,154.94 213.36,162.02 213.36,184.95 v1(213.99,185.57)
  S9 w0.127: v1(213.99,185.57) 213.11,185.57 212.53,186.15 206.19,186.15 206.01,186.33 206.01,186.94 205.87,187.09 205.04,187.09 v4(204.55,187.58)
  BOTTOM w0.127: v1(213.99,185.57) 214.98,186.56 v2(214.98,187.04)
P03_R_LED_B_1: length 46.6
  TOP w0.127: LED7.C2 219.85,50.65 v1(220.2,50.31) 220.42,50.31 222.78,52.67 222.78,69.41 218.39,73.8 218.39,86.91 217.58,87.73 216.69,87.73 216.56,87.86 R879.1
  BOTTOM w0.127: v2(222.72,50.2) 222.62,50.31 v1(220.2,50.31)
P03_R_LED_B_2: length 35.7
  TOP w0.127: LED8.C2 199.9,50.65 v1(199.51,50.26) ; v1(194.1,74.38) 194.5,74.79 194.5,78.28 R883.1
  S12 w0.127: v1(194.1,74.38) 194.08,74.37 194.08,74.01 197.65,70.44 197.65,62.41 196.59,61.34 196.59,54.71 199.51,51.79 v1(199.51,50.26)
  BOTTOM w0.127: v2(195.48,76.17) 195.48,75.77 v1(194.1,74.38)
P03_R_LED_G_1: length 46.4
  TOP w0.127: R878.1 218.7,87.1 218.7,74.1 223.27,69.53 223.27,51.82 220.64,49.19 v1(220.49,49.19) 219.88,49.81 LED7.C3
  BOTTOM w0.127: v2(221.77,48.44) 221.25,48.44 v1(220.49,49.19)
P03_R_LED_G_2: length 32.7
  TOP w0.127: R882.1 195.04,74.46 v1(194.83,74.26) ; v1(202.84,51.84) 202.74,51.84 LED8.C3
  S12 w0.127: v1(202.84,51.84) 201.9,52.78 201.9,54.07 199.86,56.11 197.83,56.11 196.99,56.94 196.99,61.19 198.06,62.25 198.06,71.03 v1(194.83,74.26)
  BOTTOM w0.127: v2(196.12,74.14) 196,74.26 v1(194.83,74.26)
P03_R_LED_R_1: length 46.4
  TOP w0.127: LED7.C1 217.67,50.93 217.85,51.1 v1(220.45,51.1) 222.33,52.98 222.33,69.23 218.12,73.44 218.12,86.57 217.22,87.48 215.99,87.48 215.55,87.92 R880.1
  BOTTOM w0.127: v2(221.92,52.11) 220.91,51.1 v1(220.45,51.1)
P03_R_LED_R_2: length 33.2
  TOP w0.127: LED8.C1 199.96,49.8 v1(199.56,49.4) ; R884.1 v1(194.02,75.17)
  S12 w0.127: v1(199.56,49.4) 199.36,49.4 198.97,49.78 198.97,51.94 196.13,54.79 196.13,61.67 197.27,62.81 197.27,69.87 193.58,73.57 193.58,74.72 v1(194.02,75.17)
  BOTTOM w0.127: v2(193.58,76.55) 194.02,76.11 v1(194.02,75.17)
P4_LED1_SFP28_B: length 241.2
  TOP w0.127: v4(192.55,196.58) U9.D4 ; R938.1 v1(50.45,75.03)
  S7 w0.127: v1(50.45,75.03) 50.45,75.38 53.73,78.66 53.73,78.66 55.74,80.67 72.02,80.67 74.56,83.21 77.5,83.21 84.21,89.91 115.63,89.91 119.4,93.68 121.97,93.68 125.73,97.44 125.73,135.51 122.5,138.74 122.5,141.38 125.66,144.54 125.66,146.64 138.63,159.61 152.17,159.61 161.77,169.21 161.77,169.5 164.46,172.18 165.22,172.18 168.62,175.59 168.62,177.7 169.46,178.53 169.46,180.18 175.12,185.84 175.12,194.86 178.74,198.47 181.26,198.47 182.91,200.12 184.62,200.12 186.27,198.47 187.44,198.47 188.99,200.02 189.8,200.02 191.07,198.75 191.07,198.42 191.37,198.12 191.7,198.12 192.12,197.71 192.12,197.01 v4(192.55,196.58)
  BOTTOM w0.127: v1(50.45,75.03) 48.74,76.74 48.73,76.74 v2(48.29,77.19)
P4_LED1_SFP28_B_R: length 26.5
  TOP w0.127: v1(50.45,70.21) C667.1 50.13,71.03 49.94,71.22 49.94,72.86 R938.2 ; LED12.C1 51.51,51.24 51.27,51.48 51.27,52.3 51.55,52.58 52.26,52.58 v1(52.37,52.47)
  S12 w0.127: v1(52.37,52.47) 51.83,53.01 51.83,62.8 50.89,63.74 50.89,69.77 v1(50.45,70.21)
  BOTTOM w0.127: v1(50.45,70.21) 50.89,70.65 v2(50.89,71.41)
P4_LED1_SFP28_G: length 238.7
  TOP w0.127: v4(191.55,198.58) U9.B3 ; R939.1 v1(49.42,75.03)
  S7 w0.127: v4(191.55,198.58) 191.55,198.83 189.91,200.48 188.61,200.48 186.93,198.8 186.4,198.8 184.29,200.91 182.21,200.91 180.1,198.8 178.6,198.8 174.79,194.99 174.79,185.93 169.21,180.34 169.21,178.72 168.24,177.76 168.24,177.07 167.67,176.5 167.59,176.5 167.59,176.5 167.37,176.5 161.49,170.62 161.49,169.31 152.05,159.87 138.52,159.87 125.4,146.75 125.4,144.94 122.24,141.78 122.24,138.44 125.48,135.2 125.48,97.67 121.77,93.96 119.33,93.96 115.55,90.19 84.12,90.19 77.44,83.51 74.49,83.51 72.03,81.05 55.45,81.05 v1(49.42,75.03)
  BOTTOM w0.127: v2(47.91,75.22) 48.1,75.03 v1(49.42,75.03)
P4_LED1_SFP28_G_R: length 28.7
  TOP w0.127: LED12.C2 52.21,51.61 v1(51.81,52.02) ; R939.2 48.98,73.38 48.8,73.19 48.8,71.16 48.93,71.03 C668.1 v1(49.42,70.21)
  S12 w0.127: v1(51.81,52.02) 51.4,52.42 51.4,62.2 49.91,63.69 49.91,69.73 v1(49.42,70.21)
  BOTTOM w0.127: v1(49.42,70.21) 49.98,70.77 49.98,73.52 v2(49.75,73.76)
P4_LED2_SFP28_B: length 238.8
  TOP w0.127: v4(189.55,196.58) U9.D1 ; R1244.1 v1(50.39,69.18)
  S7 w0.127: v1(50.39,69.18) 50.41,69.18 50.99,69.77 50.99,71.51 51.59,72.11 52.88,72.11 53.62,72.85 55.21,72.85 62,79.64 72.44,79.64 74.98,82.18 77.93,82.18 84.63,88.89 119.94,88.89 126.79,95.74 126.79,136.5 125.52,137.77 125.52,142.22 133.25,149.96 133.25,152.12 139.73,158.6 153,158.6 160.66,166.25 164.46,166.25 170.59,172.39 170.59,174.79 171.48,175.68 171.48,179 173.02,180.54 174.96,180.54 176.25,181.84 176.25,194.46 178.74,196.95 185.28,196.95 186.07,196.16 188.64,196.16 189.01,196.53 189.51,196.53 v4(189.55,196.58)
  BOTTOM w0.127: v2(186.84,196.59) 186.85,196.58 v4(189.55,196.58)
P4_LED2_SFP28_B_R: length 16.3
  TOP w0.127: v1(50.38,64.23) 50.39,64.24 C803.1 50.01,65.18 49.88,65.31 49.88,67.41 50,67.53 R1244.2 ; v1(52.44,56.64) 51.51,55.71 LED37.C1
  S7 w0.127: v1(50.38,64.23) 52.44,62.18 v1(52.44,56.64)
  BOTTOM w0.127: v1(50.38,64.23) 49.69,64.93 v2(49.69,65.44)
P4_LED2_SFP28_G: length 239
  TOP w0.127: R1245.1 v1(49.36,69.18) ; v4(190.55,196.58) U9.D2
  S7 w0.127: v4(190.55,196.58) 190.15,196.98 189.39,196.98 189.2,196.79 186.05,196.79 185.64,197.2 178.55,197.2 175.89,194.54 175.89,185.53 170.77,180.41 170.77,179 171.22,178.55 171.22,175.8 170.22,174.8 170.22,173.85 168.25,171.88 168.25,170.41 164.51,166.67 160.7,166.67 152.87,158.85 139.6,158.85 132.93,152.18 132.93,150.02 125.26,142.35 125.26,137.56 126.5,136.33 126.5,97.04 122.28,92.83 119.63,92.83 115.94,89.14 84.53,89.14 77.82,82.44 74.87,82.44 72.33,79.9 61.88,79.9 55.41,73.43 50.36,73.43 49.95,73.02 49.95,69.67 49.47,69.18 v1(49.36,69.18)
  BOTTOM w0.127: v1(49.36,69.18) 49.69,68.86 v2(49.69,67.98)
P4_LED2_SFP28_G_R: length 16.7
  TOP w0.127: v1(52.47,55.85) 52.21,55.6 LED37.C2 ; v1(49.37,64.23) 49.36,64.24 C802.1 48.93,65.18 48.8,65.31 48.8,67.41 48.92,67.53 R1245.2
  S7 w0.127: v1(52.47,55.85) 51.91,56.41 51.91,56.81 51.91,56.82 51.91,61.7 v1(49.37,64.23)
  BOTTOM w0.127: v2(49.75,62.77) 49.75,63.85 v1(49.37,64.23)
P5_LED1_SFP+_A: length 233.7
  TOP w0.127: U9.E1 v4(189.58,195.55) ; R940.1 v1(52.42,69.18)
  S7 w0.127: v4(189.58,195.55) 189.5,195.48 185.82,195.48 184.85,196.44 178.95,196.44 176.76,194.25 176.76,181.63 174.49,179.36 172.81,179.36 171.99,178.53 171.99,175.36 171.1,174.47 171.1,172.18 164.34,165.42 160.62,165.42 153.29,158.09 140.05,158.09 133.82,151.86 133.82,149.78 126.05,142.01 126.05,138.3 127.36,136.99 127.36,95.55 120.05,88.24 84.9,88.24 78.2,81.53 75.07,81.53 72.53,78.99 62.23,78.99 v1(52.42,69.18)
  BOTTOM w0.127: v2(188.65,195.99) 189.08,195.55 v4(189.58,195.55)
P5_LED1_SFP+_A_R: length 16.4
  TOP w0.127: LED13.C2 55.66,55.87 v1(55.36,56.17) ; R940.2 52.1,67.53 51.91,67.35 51.91,65.31 52.04,65.18 C669.1 52.42,64.1 v1(52.48,64.04)
  S7 w0.127: v1(52.48,64.04) 52.42,63.99 55.36,61.05 v1(55.36,56.17)
  BOTTOM w0.127: v2(52.23,62.77) 52.23,63.79 v1(52.48,64.04)
P5_LED1_SFP+_G: length 236.9
  TOP w0.127: U9.E2 191.05,195.08 v4(190.58,195.56) ; R941.1 v1(51.41,69.18)
  S7 w0.127: v1(51.41,69.18) 51.41,69.19 51.96,69.75 51.96,70.99 52.29,71.32 54.12,71.32 62.11,79.31 72.47,79.31 75.01,81.85 78.07,81.85 84.77,88.56 120.01,88.56 127.04,95.59 127.04,136.78 125.77,138.05 125.77,142.11 133.57,149.91 133.57,152.05 139.86,158.34 153.13,158.34 160.64,165.85 164.41,165.85 170.84,172.28 170.84,174.58 171.73,175.46 171.73,178.89 173.13,180.29 175.06,180.29 176.51,181.73 176.51,194.36 178.84,196.7 185,196.7 185.92,195.78 188.89,195.78 189.09,195.98 190.15,195.98 v4(190.58,195.56)
  BOTTOM w0.127: v4(190.58,195.56) v2(191.67,195.56)
P5_LED1_SFP+_G_R: length 19.7
  TOP w0.127: v1(51.4,64.17) 51.41,64.18 C670.1 51.08,65.18 50.89,65.38 50.89,67.41 51.02,67.53 R941.2 ; LED13.C1 54.96,55.78 54.61,56.13 v1(54.51,56.13)
  S7 w0.127: v1(54.51,56.13) 54.93,56.55 54.93,60.64 v1(51.4,64.17)
  BOTTOM w0.127: v1(51.4,64.17) 51.95,64.72 51.95,67.94 v2(51.84,68.04)
P5_LED2_SFP+_A: length 237
  TOP w0.127: R1246.1 v1(51.47,75.03) ; v4(191.55,197.58) U9.C3
  S7 w0.127: v4(191.55,197.58) 191.28,197.58 190.82,198.04 190.39,198.04 190.08,198.35 190.08,198.73 189.73,199.08 188.76,199.08 187.85,198.17 185.99,198.17 185.31,198.85 183.23,198.85 183.1,198.98 182.21,198.98 181.45,198.22 178.85,198.22 175.38,194.75 175.38,185.74 169.71,180.07 169.71,178.29 169.13,177.71 169.13,174.98 166.34,172.19 166.34,169.21 164.57,167.44 160.52,167.44 152.43,159.36 138.78,159.36 125.91,146.49 125.91,143.82 124.58,142.49 124.58,137.2 125.99,135.79 125.99,97.33 122.07,93.42 119.5,93.42 115.73,89.65 84.32,89.65 77.61,82.95 74.66,82.95 72.12,80.41 56.01,80.41 51.47,75.86 v1(51.47,75.03)
  BOTTOM w0.127: v1(51.47,75.03) 50.19,76.3 v2(50.19,76.93)
P5_LED2_SFP+_A_R: length 31.8
  TOP w0.127: v1(51.47,70.21) C805.1 51.84,71.03 51.94,71.12 51.94,73.22 51.78,73.38 R1246.2 ; v1(55.34,52.61) 55.66,52.29 LED38.C2
  S12 w0.127: v1(51.47,70.21) 52.22,70.97 52.54,70.97 52.99,70.52 52.99,61.23 56.48,57.74 56.48,55.91 56.46,55.89 56.46,55.79 55.34,54.67 v1(55.34,52.61)
  BOTTOM w0.127: v1(51.47,70.21) 51.97,70.71 51.97,73.57 v2(51.72,73.82)
P5_LED2_SFP+_G: length 232.9
  TOP w0.127: v1(52.04,75.55) 52.49,75.11 R1247.1 ; v4(190.55,197.58) U9.C2
  S7 w0.127: v1(52.04,75.55) 56.65,80.15 72.23,80.15 74.77,82.69 77.72,82.69 84.42,89.4 115.84,89.4 119.53,93.09 122.1,93.09 126.24,97.23 126.24,135.95 124.98,137.21 124.98,142.53 126.17,143.71 126.17,146.17 139.09,159.1 152.62,159.1 160.56,167.04 164.53,167.04 167.95,170.46 167.95,172.02 169.45,173.52 169.45,177.45 169.97,177.98 169.97,179.97 175.63,185.63 175.63,194.65 178.57,197.58 185.99,197.58 186.54,197.04 188.43,197.04 189.38,198 189.79,198 190.21,197.58 v4(190.55,197.58)
  BOTTOM w0.127: v1(52.04,75.55) 52.04,76.69 v2(52.29,76.93)
P5_LED2_SFP+_G_R: length 29.7
  TOP w0.127: v1(52.49,70.21) C804.1 52.91,71.03 53,71.12 53,73.25 52.88,73.38 R1247.2 ; LED38.C1 54.96,51.86 v1(54.91,51.91)
  S12 w0.127: v1(52.49,70.21) 51.91,69.63 51.91,63.63 52.21,63.32 52.21,61.57 56.2,57.58 56.2,55.89 54.83,54.52 54.83,51.99 v1(54.91,51.91)
  BOTTOM w0.127: v1(52.49,70.21) 53.44,71.16 53.44,73.07 v2(53.62,73.25)
P6_LED1_SFP+_A: length 217.8
  TOP w0.127: R923.1 63.03,75.01 v1(62.98,75.05) ; U9.F1 v4(189.57,194.56)
  S7 w0.127: v4(189.57,194.56) 186.61,194.56 186.38,194.79 182.49,194.79 181.5,195.78 179.06,195.78 177.31,194.03 177.31,181.4 175.35,179.45 175.35,177.42 171.64,173.71 171.64,171.95 164.47,164.78 160.84,164.78 153.64,157.58 141.52,157.58 137.06,153.12 137.06,148.44 134.5,145.88 134.5,139.5 128.06,133.06 128.06,95.53 120.1,87.57 85.1,87.57 78.49,80.97 75.39,80.97 72.81,78.4 66.32,78.4 62.98,75.06 v1(62.98,75.05)
  BOTTOM w0.127: v2(188.65,194.08) 189.12,194.56 v4(189.57,194.56)
P6_LED1_SFP+_A_R: length 27.8
  TOP w0.127: v1(63.03,70.21) C647.1 62.72,71.03 62.54,71.2 62.54,73.23 62.69,73.38 R923.2 ; LED14.C2 v1(66.46,51.89)
  S12 w0.127: v1(63.03,70.21) 62.48,69.67 62.48,63.59 63.69,62.38 65,62.38 65.42,61.97 65.42,54.49 66.46,53.45 v1(66.46,51.89)
  BOTTOM w0.127: v1(63.03,70.21) 63.03,70.76 v2(63.87,71.61)
P6_LED1_SFP+_G: length 224.8
  TOP w0.127: R924.1 v1(62,75.03) ; v4(190.55,194.58) U9.F2
  S7 w0.127: v4(190.55,194.58) 190.14,194.99 189.22,194.99 189.07,195.15 182.59,195.15 181.65,196.09 178.95,196.09 177.02,194.15 177.02,181.52 175.09,179.6 175.09,177.64 171.35,173.9 171.35,172.07 164.39,165.11 160.76,165.11 153.48,157.83 140.17,157.83 134.15,151.81 134.15,139.54 127.75,133.14 127.75,95.58 120.03,87.86 84.98,87.86 78.37,81.26 75.27,81.26 72.69,78.69 65.66,78.69 v1(62,75.03)
  BOTTOM w0.127: v4(190.55,194.58) 190.15,194.98 v2(185.51,194.98)
P6_LED1_SFP+_G_R: length 27.5
  TOP w0.127: LED14.C1 v1(65.76,51.96) ; v1(62,70.21) C648.1 61.64,71.03 61.41,71.26 61.41,73.23 61.56,73.38 R924.2
  S12 w0.127: v1(62,70.21) 61.32,69.53 61.32,63.78 63.08,62.02 64.43,62.02 65.16,61.28 65.16,54.23 65.76,53.63 v1(65.76,51.96)
  BOTTOM w0.127: v1(62,70.21) 62,70.22 v2(62,71.22)
P6_LED2_SFP+_A: length 220.4
  TOP w0.127: R1248.1 v1(63.98,69.18) ; v4(189.55,192.58) U9.H1
  S7 w0.127: v1(63.98,69.18) 64.53,69.74 64.53,73.67 68.21,77.34 73.29,77.34 75.83,79.88 78.95,79.88 85.55,86.48 120.45,86.48 129.3,95.34 129.3,132.61 135.99,139.3 135.99,145.46 138.08,147.55 138.08,149.32 141.13,152.37 144.52,152.37 147,154.85 153.57,154.85 154.46,155.74 154.46,156.69 161.16,163.39 164.72,163.39 176.69,175.36 176.69,178.98 178.55,180.85 178.55,192.41 179.15,193.01 180.05,193.01 180.48,193.44 185.94,193.44 186.8,192.58 v4(189.55,192.58)
  BOTTOM w0.127: v2(186.4,192.95) 189.18,192.95 v4(189.55,192.58)
P6_LED2_SFP+_A_R: length 16.3
  TOP w0.127: R1248.2 63.64,67.53 63.5,67.39 63.5,65.3 63.61,65.18 C807.1 v1(63.98,64.3) ; LED39.C2 66.46,55.78 v1(66.93,56.25)
  S9 w0.127: v1(63.98,64.3) 63.98,62.95 66.46,60.47 66.46,56.72 v1(66.93,56.25)
  BOTTOM w0.127: v1(63.98,64.3) 64.16,64.12 v2(64.16,63.15)
P6_LED2_SFP+_G: length 222.5
  TOP w0.127: v4(189.55,193.58) U9.G1 ; R1249.1 v1(61.93,69.18)
  S7 w0.127: v1(61.93,69.18) 62.02,69.18 62.47,69.64 62.47,73.23 63.55,74.3 64.09,74.3 67.64,77.85 73.02,77.85 75.61,80.44 78.71,80.44 85.32,87.04 120.29,87.04 128.64,95.4 128.64,132.85 135.22,139.43 135.22,145.51 137.57,147.86 137.57,152.69 141.88,157.01 153.96,157.01 161.03,164.08 164.6,164.08 172.23,171.71 172.23,173.32 176.11,177.2 176.11,179.33 177.89,181.11 177.89,193.27 179.01,194.38 181.1,194.38 181.54,193.94 184.39,193.94 184.56,194.11 185.99,194.11 186.52,193.58 v4(189.55,193.58)
  BOTTOM w0.127: v1(61.93,69.18) 62.2,68.92 v2(62.2,67.98)
P6_LED2_SFP+_G_R: length 16.7
  TOP w0.127: R1249.2 61.59,67.53 61.45,67.39 61.45,65.36 61.63,65.18 C806.1 v1(61.93,64.29) ; LED39.C1 65.76,55.82 v1(66.13,56.19)
  S9 w0.127: v1(66.13,56.19) 65.76,56.56 65.76,60.46 v1(61.93,64.29)
  BOTTOM w0.127: v1(61.93,64.29) 62.07,64.16 v2(62.07,63.15)
P7_LED1_SFP+_A: length 218.3
  TOP w0.127: U9.J2 v4(190.55,191.58) ; R925.1 v1(64.99,69.18)
  S7 w0.127: v1(64.99,69.18) 64.99,69.22 65.88,70.1 65.88,72.1 67.04,73.27 69.12,73.27 72.51,76.65 73.65,76.65 76.29,79.3 79.19,79.3 85.79,85.9 121.83,85.9 129.89,93.96 129.89,132.41 136.62,139.14 136.62,145.26 139.16,147.8 139.16,149.39 141.38,151.61 147.67,151.61 148.34,152.28 148.34,153.68 148.87,154.21 153.76,154.21 155.03,155.48 155.03,156.5 161.26,162.72 164.81,162.72 177.19,175.11 177.19,178.47 179.14,180.41 179.14,191.51 179.43,191.81 180.75,191.81 181.65,192.71 185.66,192.71 186.72,191.65 188.85,191.65 189.21,191.28 190.26,191.28 v4(190.55,191.58)
  BOTTOM w0.127: v2(64.8,67.98) 64.8,68.99 v1(64.99,69.18)
P7_LED1_SFP+_A_R: length 16.8
  TOP w0.127: R925.2 64.72,67.53 64.51,67.33 64.51,65.3 64.62,65.18 C649.1 v1(64.99,64.42) ; LED15.C2 69.91,56.35 v1(69.33,56.93)
  S9 w0.127: v1(64.99,64.42) 64.99,63.53 69.33,59.19 v1(69.33,56.93)
  BOTTOM w0.127: v1(64.99,64.42) 65.24,64.67 v2(65.24,65.5)
P7_LED1_SFP+_G: length 222.3
  TOP w0.127: R926.1 v1(62.96,69.18) ; v4(190.55,192.58) U9.H2
  S7 w0.127: v1(62.96,69.18) 63.16,69.18 63.54,69.57 63.54,73.24 67.9,77.59 73.19,77.59 75.73,80.13 78.84,80.13 85.44,86.74 120.35,86.74 129,95.39 129,132.74 135.64,139.38 135.64,145.49 137.82,147.67 137.82,149.66 141.04,152.88 143.33,152.88 147.2,156.75 154.14,156.75 161.14,163.75 164.7,163.75 172.75,171.8 172.75,173.2 176.37,176.82 176.37,179.04 178.17,180.85 178.17,193.04 179.24,194.1 181.02,194.1 181.43,193.69 186.05,193.69 186.7,193.04 190.09,193.04 v4(190.55,192.58)
  BOTTOM w0.127: v4(190.55,192.58) 190.08,192.1 188.19,192.1 v2(187.99,191.9)
P7_LED1_SFP+_G_R: length 19.3
  TOP w0.127: LED15.C1 v1(69.21,56.06) ; v1(62.96,64.3) C650.1 62.59,65.18 62.42,65.36 62.42,67.33 62.62,67.53 R926.2
  S9 w0.127: v1(62.96,64.3) 63.72,65.06 64.29,65.06 64.51,64.84 64.51,63.31 68.81,59.02 68.81,56.46 v1(69.21,56.06)
  BOTTOM w0.127: v2(62.96,65.44) 62.96,64.31 v1(62.96,64.3)
P7_LED2_SFP+_A: length 218.3
  TOP w0.127: v4(193.55,192.58) U9.H5 ; v1(65.99,74.25) 65.95,74.28 R1250.1
  S7 w0.127: v4(193.55,192.58) 193.1,192.12 186.66,192.12 185.77,193.01 180.58,193.01 180.17,192.6 179.2,192.6 178.83,192.24 178.83,180.54 176.94,178.65 176.94,175.23 164.72,163.01 161.16,163.01 154.78,156.63 154.78,155.67 153.64,154.53 147.29,154.53 146.61,153.86 146.61,152.25 146.29,151.93 141.25,151.93 138.68,149.36 138.68,147.7 136.36,145.39 136.36,139.27 129.58,132.48 129.58,94.24 121.57,86.23 85.65,86.23 79.05,79.63 75.94,79.63 73.4,77.09 68.83,77.09 v1(65.99,74.25)
  BOTTOM w0.254: v1(65.99,74.25) 65.94,74.29 v2(65.94,76.3)
P7_LED2_SFP+_A_R: length 29.6
  TOP w0.127: LED40.C2 v1(69.91,52.04) ; R1250.2 65.45,73.38 65.58,73.25 65.58,71.12 65.48,71.03 C809.1 v1(65.06,70.21)
  S12 w0.127: v1(69.91,52.04) 69.91,53.58 70.53,54.2 70.53,57.93 65.21,63.26 65.14,63.26 64.5,63.9 64.5,69.65 v1(65.06,70.21)
  BOTTOM w0.127: v2(67.34,71.98) 66.83,71.98 v1(65.06,70.21)
P7_LED2_SFP+_G: length 217.9
  TOP w0.127: v1(64.02,75) 64.04,74.99 R1251.1 ; v4(190.55,193.58) U9.G2
  S7 w0.127: v1(64.02,75) 64.02,75.08 67.07,78.13 72.93,78.13 75.5,80.7 78.61,80.7 85.21,87.3 120.19,87.3 128.36,95.47 128.36,133 134.81,139.45 134.81,145.68 137.32,148.18 137.32,152.88 141.76,157.33 153.8,157.33 160.81,164.34 164.46,164.34 171.95,171.82 171.95,173.52 175.8,177.37 175.8,179.46 177.61,181.28 177.61,193.9 178.4,194.69 182.01,194.69 182.33,194.36 186.1,194.36 186.45,194.01 190.12,194.01 v4(190.55,193.58)
  BOTTOM w0.254: v1(64.02,75) 63.91,75.12 v2(63.91,76.81)
P7_LED2_SFP+_G_R: length 31.3
  TOP w0.127: R1251.2 64.39,73.38 64.53,73.24 64.53,71.17 64.38,71.03 C808.1 v1(64.04,70.21) ; LED40.C1 v1(69.21,52.01)
  S12 w0.127: v1(69.21,52.01) 69.21,53.58 70.09,54.46 70.09,57.94 65.18,62.86 64.55,62.86 63.51,63.9 63.51,69.67 v1(64.04,70.21)
  BOTTOM w0.127: v1(64.04,70.21) 66.16,72.33 v2(66.16,73.48)
P8_LED1_SFP+_A: length 200
  TOP w0.127: R886.1 v1(75.47,75.03) ; v4(193.55,191.58) U9.J5
  S7 w0.127: v1(75.47,75.03) 76.44,75.99 77.98,75.99 87.21,85.22 122.11,85.22 130.48,93.59 130.48,132.11 137.13,138.76 137.13,141.9 145.29,150.07 149.04,150.07 151.35,152.37 154.21,152.37 154.84,153 154.84,154.47 156.05,155.67 156.43,155.67 156.71,155.96 156.71,157.17 161.7,162.15 164.98,162.15 177.71,174.88 177.71,178.21 179.8,180.3 179.8,185.96 181.52,187.69 185.5,187.69 188.5,190.69 192.67,190.69 v4(193.55,191.58)
  BOTTOM w0.127: v2(75.09,75.79) 75.47,75.4 v1(75.47,75.03)
P8_LED1_SFP+_A_R: length 29.8
  TOP w0.127: R886.2 75.13,73.38 74.99,73.23 74.99,71.2 75.16,71.03 C591.1 v1(75.47,70.21) ; LED16.C2 v1(80.71,52.06)
  S12 w0.127: v1(80.71,52.06) 80.71,54.25 79.34,55.62 79.34,56.58 80.98,58.21 80.98,61.37 78.62,63.73 76.2,63.73 75.93,64 75.93,69.76 v1(75.47,70.21)
  BOTTOM w0.127: v1(75.47,70.21) 75.47,71.03 v2(75.85,71.41)
P8_LED1_SFP+_G: length 201.9
  TOP w0.127: U9.J3 v4(191.55,191.58) ; R887.1 v1(74.44,75.03)
  S7 w0.127: v1(74.44,75.03) 74.44,75.08 75.97,76.6 77.96,76.6 86.84,85.48 121.81,85.48 130.18,93.85 130.18,132.32 136.87,139.01 136.87,145.13 139.41,147.67 139.41,149.07 141.51,151.17 148.24,151.17 149.81,152.74 149.81,153.33 150.31,153.83 153.83,153.83 155.35,155.36 155.35,156.44 161.32,162.41 164.87,162.41 177.45,174.99 177.45,178.32 179.42,180.28 179.42,186.22 181.22,188.03 185.48,188.03 188.48,191.03 191,191.03 v4(191.55,191.58)
  BOTTOM w0.127: v2(73.22,76.16) 73.31,76.16 v1(74.44,75.03)
P8_LED1_SFP+_G_R: length 33.1
  TOP w0.127: R887.2 74.1,73.38 73.86,73.14 73.86,71.26 74.1,71.03 C592.1 v1(74.44,70.21) ; LED16.C1 v1(80.01,52.05)
  S12 w0.127: v1(74.44,70.21) 74.88,69.77 74.88,64.08 75.6,63.37 78.6,63.37 80.69,61.27 80.69,58.37 79.04,56.72 79.04,55.27 80.01,54.29 v1(80.01,52.05)
  BOTTOM w0.127: v2(73.5,73.95) 73.94,73.5 73.94,70.72 74.46,70.21 v1(74.44,70.21)
P8_LED2_SFP+_A: length 201.9
  TOP w0.127: v4(191.55,188.58) U9.L3 ; R1252.1 v1(76.42,69.18)
  S7 w0.127: v4(191.55,188.58) 191.11,188.14 189.3,188.14 188.93,187.77 188.93,186.9 187.78,185.75 186.27,185.75 184.39,183.87 184.39,180.99 184.13,180.74 182.84,180.74 181.72,179.62 180.91,179.62 178.98,177.68 178.98,174.57 178.98,174.36 165.5,160.88 162.84,160.88 159.99,158.02 159.99,153.91 157.17,151.09 156,151.09 153.79,148.88 153.79,147.55 151.53,145.3 150.45,145.3 149.95,144.8 145.37,144.8 144.11,143.55 144.11,141.96 143.28,141.14 140.49,141.14 139.47,140.12 139.47,139.04 131.83,131.41 131.83,91.94 123.51,83.62 88.06,83.62 77.77,73.33 77.36,73.33 77.03,73 77.03,72.21 76.01,71.19 76.01,69.55 76.38,69.18 v1(76.42,69.18)
  BOTTOM w0.127: v2(77.5,67.98) 76.42,69.05 v1(76.42,69.18)
P8_LED2_SFP+_A_R: length 18.1
  TOP w0.127: R1252.2 76.08,67.53 75.94,67.39 75.94,65.3 76.05,65.18 C811.1 76.42,64.56 76.41,64.55 v1(76.41,64.47) ; LED41.C2 80.71,55.62 v1(80.97,55.88)
  S9 w0.127: v1(76.41,64.47) 76.41,64.21 77.05,63.58 78.81,63.58 80.22,62.17 80.22,56.63 v1(80.97,55.88)
  BOTTOM w0.127: v1(76.41,64.47) 76.41,65.31 v2(76.85,65.75)
P8_LED2_SFP+_G: length 204.2
  TOP w0.127: v4(190.55,189.58) U9.K2 ; R1253.1 v1(74.38,69.18)
  S7 w0.127: v1(74.38,69.18) 73.65,69.92 73.65,72.79 75.17,74.32 77.79,74.32 87.9,84.43 123.15,84.43 131.31,92.59 131.31,131.67 138.27,138.63 138.27,141.13 142.54,145.41 149.65,145.41 150.12,145.87 151.36,145.87 153.06,147.58 153.06,149.63 155.22,151.78 157.14,151.78 159.48,154.12 159.48,158.47 162.4,161.39 165.29,161.39 178.47,174.57 178.47,177.89 180.72,180.15 181.3,180.15 182.27,181.12 182.27,183.08 183.32,184.13 183.89,184.13 186.1,186.34 187.34,186.34 188.28,187.28 188.28,188.94 189.33,189.99 190.14,189.99 v4(190.55,189.58)
  BOTTOM w0.127: v2(74.2,68.3) 74.14,68.35 74.14,68.95 v1(74.38,69.18)
P8_LED2_SFP+_G_R: length 19.4
  TOP w0.127: R1253.2 74.04,67.53 73.9,67.39 73.9,65.36 74.07,65.18 C810.1 74.38,64.46 v1(74.39,64.46) ; LED41.C1 80.01,55.71 v1(80.18,55.88)
  S9 w0.127: v1(74.39,64.46) 75.65,63.2 78.73,63.2 79.69,62.24 79.69,56.46 80.18,55.98 v1(80.18,55.88)
  BOTTOM w0.127: v2(74.89,63.12) 74.39,63.63 v1(74.39,64.46)
P9_LED1_SFP+_A: length 200.7
  TOP w0.127: v4(190.55,187.58) U9.M2 ; R888.1 v1(77.44,69.18)
  S7 w0.127: v4(190.55,187.58) 190.02,187.05 189.46,187.05 186.64,184.22 185.34,184.22 184.74,183.62 184.74,180.91 184.15,180.32 182.83,180.32 181.76,179.25 181.06,179.25 179.34,177.53 179.34,174.33 165.54,160.53 163,160.53 160.3,157.83 160.3,153.87 157.18,150.74 156.2,150.74 154.2,148.74 154.2,147.6 151.55,144.95 150.62,144.95 150.1,144.43 145.5,144.43 144.43,143.36 144.43,141.58 143.67,140.82 142.14,140.82 140.24,138.91 139.84,138.91 132.15,131.21 132.15,91.62 123.81,83.28 91.58,83.28 80.84,72.54 78.63,72.54 76.96,70.87 76.96,69.55 77.33,69.18 v1(77.44,69.18)
  BOTTOM w0.127: v1(77.44,69.18) 78.07,69.81 78.07,70.58 78.71,71.22 79.6,71.22 v2(80.46,72.08)
P9_LED1_SFP+_A_R: length 18.6
  TOP w0.127: v1(83.52,56.99) 84.16,56.35 LED17.C2 ; v1(77.44,64.45) 77.44,64.45 C593.1 77.07,65.18 76.96,65.3 76.96,67.33 77.16,67.53 R888.2
  S9 w0.127: v1(77.44,64.45) 77.54,64.34 79.18,64.34 83.52,60.01 v1(83.52,56.99)
  BOTTOM w0.127: v2(78.39,63.79) 78.1,63.79 v1(77.44,64.45)
P9_LED1_SFP+_G: length 204.3
  TOP w0.127: R889.1 v1(75.41,69.18) ; v4(190.55,188.58) U9.L2
  S7 w0.127: v1(75.41,69.18) 75.35,69.18 74.93,69.6 74.93,71.07 76.01,72.16 76.01,73.07 76.75,73.81 77.77,73.81 87.92,83.96 123.37,83.96 131.56,92.16 131.56,131.55 138.65,138.63 138.65,141.13 142.65,145.13 149.84,145.13 150.33,145.62 151.47,145.62 151.47,145.62 151.5,145.62 153.43,147.55 153.43,149.21 155.75,151.53 157.24,151.53 159.73,154.02 159.73,158.34 162.53,161.14 165.4,161.14 178.72,174.46 178.72,177.79 180.81,179.88 181.59,179.88 182.63,180.92 182.63,183.08 183.43,183.87 184,183.87 186.17,186.05 187.46,186.05 188.58,187.16 188.58,188.43 189.22,189.08 190.05,189.08 v4(190.55,188.58)
  BOTTOM w0.127: v1(75.41,69.18) 74.9,68.67 74.9,66.01 v2(74.96,65.95)
P9_LED1_SFP+_G_R: length 22.1
  TOP w0.127: v1(83.37,56.22) 83.46,56.12 LED17.C1 ; v1(75.41,64.51) 75.41,64.55 75.41,64.55 C594.1 75.04,65.18 74.86,65.36 74.86,67.33 75.07,67.53 R889.2
  S9 w0.127: v1(75.41,64.51) 75.94,65.04 76.63,65.04 76.92,64.75 76.92,64.28 77.26,63.94 78.98,63.94 83.04,59.87 83.04,56.54 v1(83.37,56.22)
  BOTTOM w0.127: v1(75.41,64.51) 75.41,64.43 76.94,62.9 v2(76.94,62.56)
P9_LED2_SFP+_A: length 198.5
  TOP w0.127: R1254.1 v1(77.5,75.03) ; v4(191.55,189.58) U9.K3
  S7 w0.127: v4(191.55,189.58) 190.91,190.22 189.17,190.22 187.56,188.61 187.56,187 187.18,186.62 185.88,186.62 184.78,185.52 182.08,185.52 181.38,184.82 181.38,180.6 181.19,180.4 180.62,180.4 178.22,178 178.22,174.67 165.19,161.64 162.14,161.64 158.33,157.83 158.33,153.75 157.91,153.33 157.16,153.33 156.01,152.18 154.98,152.18 152.66,149.87 152.66,147.54 151.28,146.15 149.93,146.15 149.45,145.66 142.23,145.66 137.89,141.32 137.89,138.76 131.05,131.93 131.05,92.79 122.97,84.71 87.7,84.71 78.02,75.03 v1(77.5,75.03)
  BOTTOM w0.127: v2(78.56,76.06) 78.54,76.06 v1(77.5,75.03)
P9_LED2_SFP+_A_R: length 30.7
  TOP w0.127: R1254.2 77.9,73.38 78.02,73.25 78.02,71.12 77.93,71.03 C813.1 v1(77.5,70.21) ; LED42.C2 84.16,51.76 v1(83.86,52.06)
  S12 w0.102: 78.03,69.68 79.22,68.49 79.22,66.36
  S12 w0.127: v1(77.5,70.21) 78.03,69.68 ; 79.22,66.36 79.22,63.95 84.91,58.26 84.91,54.33 83.86,53.28 v1(83.86,52.06)
  BOTTOM w0.127: v2(78.87,73.12) 78.83,73.12 78.83,72.62 77.5,71.29 v1(77.5,70.21)
P9_LED2_SFP+_G: length 203.5
  TOP w0.127: R1255.1 v1(76.49,75.03) ; v4(193.55,193.58) U9.G5
  S7 w0.127: v4(193.55,193.58) 194.05,193.08 194.05,191.11 193.39,190.45 188.99,190.45 185.27,186.73 183.41,186.73 183.09,186.41 180.62,186.41 180.17,185.95 180.17,180.31 177.96,178.1 177.96,174.78 165.08,161.9 161.95,161.9 157.95,157.9 157.95,153.86 157.73,153.64 155.84,153.64 154.31,152.12 151.92,152.12 148.98,149.18 145.11,149.18 137.63,141.7 137.63,138.88 130.75,132 130.75,93.2 122.52,84.97 87.53,84.97 78.21,75.65 77.12,75.65 v1(76.49,75.03)
  BOTTOM w0.127: v1(76.49,75.03) 76.49,76.42 v2(76.77,76.7)
P9_LED2_SFP+_G_R: length 30.8
  TOP w0.127: v1(83.11,52.08) 83.46,51.72 LED42.C1 ; R1255.2 76.8,73.38 77.01,73.17 77.01,71.23 76.81,71.03 C812.1 v1(76.49,70.21)
  S12 w0.127: v1(76.49,70.21) 76.94,69.76 76.94,65.83 84.58,58.19 84.58,54.7 83.11,53.23 v1(83.11,52.08)
  BOTTOM w0.127: v1(76.49,70.21) 76.67,70.4 76.67,71.35 76.96,71.63 76.96,73.25 v2(76.97,73.26)
P10_LED1_SFP+_A: length 185.5
  TOP w0.127: v1(87.15,74.84) 86.89,74.58 R890.1 ; v4(190.55,186.58) U9.N2
  S7 w0.127: v1(87.15,74.84) 94.71,82.4 124.33,82.4 132.72,90.79 132.72,130.9 139.84,138.02 140.43,138.02 142.71,140.31 152.3,140.31 153.42,141.42 153.42,144.09 157.59,148.26 158.64,148.26 159.03,148.66 159.03,149.83 159.67,150.47 159.67,152.47 164.84,157.64 165.86,157.64 166.37,158.16 166.37,160.53 181.58,175.74 181.58,178.09 181.93,178.45 183.66,178.45 184.05,178.84 184.05,179.28 185.25,180.48 185.25,183.03 185.89,183.68 187.02,183.68 189.43,186.08 190.06,186.08 v4(190.55,186.58)
  BOTTOM w0.127: v2(86.5,77.46) 87.15,76.8 v1(87.15,74.84)
P10_LED1_SFP+_A_R: length 32.9
  TOP w0.127: v1(86.89,70.08) C597.1 87.15,70.9 87.36,71.11 87.36,72.78 R890.2 ; LED18.C2 v1(94.96,52.06)
  S12 w0.127: v1(86.89,70.08) 86.96,70.01 86.96,68.43 87.6,67.79 88.55,67.79 88.99,67.35 88.99,63.23 89.75,62.47 94.13,62.47 95.29,61.31 95.29,57.93 93.72,56.37 93.72,55.57 94.96,54.33 v1(94.96,52.06)
  BOTTOM w0.127: v1(86.89,70.08) 86.89,70.26 v2(88.23,71.6)
P10_LED1_SFP+_G: length 183.3
  TOP w0.127: v1(86.39,74.9) 85.86,74.37 R891.1 ; v4(189.55,186.58) U9.N1
  S7 w0.127: v1(86.39,74.9) 94.28,82.79 123.83,82.79 132.43,91.39 132.43,130.99 139.97,138.53 140.36,138.53 142.4,140.56 148.07,140.56 148.68,141.18 148.68,142.28 150.88,144.48 153.34,144.48 157,148.14 157,150.21 160.62,153.83 160.62,157.58 163.19,160.15 165.6,160.15 179.62,174.17 179.62,177.42 180.97,178.77 183.35,178.77 183.64,179.06 183.64,179.38 185,180.74 185,183.27 185.7,183.97 186.94,183.97 v4(189.55,186.58)
  BOTTOM w0.127: v2(85.44,75.85) v1(86.39,74.9)
P10_LED1_SFP+_G_R: length 33.6
  TOP w0.127: v1(86.13,69.95) 85.86,70.22 C598.1 86.22,70.9 86.42,71.09 86.42,73.16 86.33,73.25 R891.2 ; LED18.C1 v1(94.26,52.05)
  S12 w0.127: v1(94.26,52.05) 94.26,54.44 93.28,55.42 93.28,56.42 94.98,58.11 94.98,61.23 94.17,62.05 89.32,62.05 87.98,63.4 87.98,67.03 87.85,67.16 87.34,67.16 85.86,68.64 85.86,69.67 v1(86.13,69.95)
  BOTTOM w0.127: v2(86.33,71.68) 86.13,71.49 v1(86.13,69.95)
P10_LED2_SFP+_A: length 191.4
  TOP w0.127: v4(191.55,185.58) U9.P3 ; R1256.1 v1(87.46,69.06)
  S7 w0.127: v1(87.46,69.06) 87.54,69.06 88.42,69.94 88.42,70.25 89.78,71.61 89.78,74.93 95.81,80.97 124.34,80.97 134.12,90.75 134.12,126.73 134.46,127.07 137.1,127.07 137.43,127.4 137.43,132.48 140.87,135.93 142.65,135.93 145.89,139.16 152.94,139.16 153.57,139.8 156.65,139.8 161.89,145.04 161.89,148.44 162.06,148.6 162.06,153.41 165.02,156.37 166.02,156.37 166.95,157.3 169.16,157.3 170.1,158.24 170.1,162.68 182.59,175.17 183.87,175.17 187.75,179.04 187.75,181.35 188.28,181.88 188.28,183.19 189.65,184.56 189.94,184.56 190.45,185.07 191.04,185.07 v4(191.55,185.58)
  BOTTOM w0.127: v1(87.46,69.06) 87.46,68.88 v2(88.67,67.66)
P10_LED2_SFP+_A_R: length 21.1
  TOP w0.127: v1(95.09,55.78) 95.09,55.73 94.96,55.6 LED43.C2 ; v1(87.46,64.03) C815.1 87.08,65.06 86.95,65.19 86.95,66.9 R1256.2
  S9 w0.127: v1(87.46,64.03) 89.08,62.41 93.61,62.41 95.09,60.93 v1(95.09,55.78)
  BOTTOM w0.127: v1(87.46,64.03) 87.46,64.83 v2(88.24,65.61)
P10_LED2_SFP+_G: length 189.1
  TOP w0.127: v4(190.55,185.58) U9.P2 ; R1257.1 v1(86.43,69.06)
  S7 w0.127: v4(190.55,185.58) 189.81,184.84 189.57,184.84 188.03,183.3 188.03,182.26 187.41,181.63 187.41,179.09 183.92,175.61 182.59,175.61 169.75,162.77 169.75,158.35 168.99,157.59 166.88,157.59 165.92,156.63 164.9,156.63 160.48,152.21 160.48,150.08 160.02,149.61 160.02,148.4 156.92,145.3 156.92,142.7 154.3,140.08 153.44,140.08 152.78,139.42 145.63,139.42 142.46,136.24 140.73,136.24 136.9,132.41 136.9,128.06 136.31,127.48 134.19,127.48 133.76,127.05 133.76,90.75 124.34,81.33 95.77,81.33 89.43,74.99 89.43,73.93 88.41,72.9 88.41,71.25 87.43,70.27 87.43,69.96 86.53,69.06 v1(86.43,69.06)
  BOTTOM w0.127: v2(86.77,67.66) 86.77,68.72 v1(86.43,69.06)
P10_LED2_SFP+_G_R: length 20.8
  TOP w0.127: v1(86.44,64.05) 86.43,64.06 C814.1 86.12,65.06 85.95,65.23 85.95,66.92 R1257.2 ; v1(94.33,55.75) 94.26,55.69 LED43.C1
  S9 w0.127: v1(86.44,64.05) 88.65,61.85 93.28,61.85 94.33,60.8 v1(94.33,55.75)
  BOTTOM w0.127: v2(86.34,65.49) 86.44,65.38 v1(86.44,64.05)
P11_LED1_SFP+_A: length 184.8
  TOP w0.127: R892.1 v1(89.49,69.06) ; v4(191.55,184.58) U9.R3
  S7 w0.127: v1(89.49,69.06) 90.54,70.11 90.54,74.71 96.2,80.36 124.81,80.36 134.71,90.27 134.71,114.44 138.46,118.19 138.46,127.14 140.02,128.7 144.94,128.7 148.76,132.52 150.1,132.52 163.22,145.64 163.22,148.94 162.66,149.49 162.66,153.27 165.01,155.61 167.57,155.61 168.66,156.7 170.35,156.7 171.42,157.77 171.42,161.81 188.68,179.08 188.68,181.04 188.9,181.26 188.9,182.48 189.5,183.08 189.86,183.08 190.06,183.28 190.06,183.64 190.54,184.12 191.1,184.12 v4(191.55,184.58)
  BOTTOM w0.127: v2(90.74,68.18) 90.36,68.18 v1(89.49,69.06)
P11_LED1_SFP+_A_R: length 21.9
  TOP w0.127: v1(97.96,56.03) 98.41,55.57 LED19.C2 ; v1(89.48,64.09) 89.49,64.09 C599.1 89.12,65.06 89.01,65.17 89.01,67.3 89.12,67.41 R892.2
  S9 w0.127: v1(89.48,64.09) 89.48,64 90.33,63.15 94.17,63.15 98.42,58.9 98.42,56.49 v1(97.96,56.03)
  BOTTOM w0.127: v2(91.47,64.04) 91.43,64.09 v1(89.48,64.09)
P11_LED1_SFP+_G: length 190.9
  TOP w0.127: v4(190.55,184.58) U9.R2 ; R893.1 v1(88.48,69.06)
  S7 w0.127: v1(88.48,69.06) 88.8,69.06 90.14,70.4 90.14,74.81 95.99,80.66 124.6,80.66 134.39,90.46 134.39,114.84 137.82,118.27 137.82,132.47 140.96,135.61 142.78,135.61 145.73,138.56 146.57,138.56 147.1,138.02 147.86,138.02 148.75,138.91 153.06,138.91 153.57,139.42 156.65,139.42 162.97,145.74 162.97,148.52 162.38,149.11 162.38,153.37 165.07,156.06 166.46,156.06 167.44,157.03 169.53,157.03 170.4,157.9 170.4,161.33 188.11,179.05 188.11,181.1 188.59,181.58 188.59,182.86 189.07,183.34 189.07,183.65 189.69,184.27 190.25,184.27 v4(190.55,184.58)
  BOTTOM w0.127: v2(91.85,66.58) 91.15,66.58 88.75,68.99 88.55,68.99 v1(88.48,69.06)
P11_LED1_SFP+_G_R: length 22.6
  TOP w0.127: v1(88.48,64.04) C600.1 88.11,65.06 87.99,65.17 87.99,67.17 88.23,67.41 R893.2 ; LED19.C1 97.71,55.4 97.45,55.67 97.45,56.39 v1(97.93,56.87)
  S9 w0.127: v1(88.48,64.04) 89.65,62.86 94.08,62.86 98.04,58.9 98.04,56.98 v1(97.93,56.87)
  BOTTOM w0.127: v1(88.48,64.04) 88.74,64.04 v2(90.14,65.44)
P11_LED2_SFP+_A: length 182.4
  TOP w0.127: v4(191.55,186.58) U9.N3 ; R1258.1 v1(88.92,74.9)
  S7 w0.127: v4(191.55,186.58) 191.03,186.06 190.47,186.06 190.04,185.63 190.04,185.51 189.65,185.12 189.49,185.12 187.78,183.4 187.78,182.46 186.43,181.11 186.07,181.11 185.93,180.98 185.93,180.16 185.62,179.84 185.62,177.75 184.81,176.95 183.54,176.95 166.88,160.28 166.88,157.94 165.85,156.92 164.84,156.92 160.23,152.31 160.23,150.27 159.73,149.77 159.73,148.47 158.79,147.53 157.69,147.53 153.92,143.77 153.92,140.98 152.68,139.74 145.51,139.74 142.4,136.62 139.46,136.62 133.45,130.61 133.45,90.8 124.39,81.73 95.75,81.73 v1(88.92,74.9)
  BOTTOM w0.127: v2(89.98,75.94) 89.96,75.94 v1(88.92,74.9)
P11_LED2_SFP+_A_R: length 30
  TOP w0.127: v1(98.25,52.1) 98.41,51.93 LED44.C2 ; v1(88.92,70.08) C817.1 89.34,70.9 89.56,71.12 89.56,72.93 89.25,73.25 R1258.2
  S12 w0.127: v1(88.92,70.08) 89.3,70.08 90.52,68.87 90.52,68.2 96.85,61.87 96.85,60.12 99.16,57.8 99.16,54.33 98.25,53.42 v1(98.25,52.1)
  BOTTOM w0.127: v2(90.52,70.08) 90.51,70.08 v1(88.92,70.08)
P11_LED2_SFP+_G: length 181.2
  TOP w0.127: v4(189.55,185.58) U9.P1 ; R1259.1 v1(87.9,74.9)
  S7 w0.127: v4(189.55,185.58) 187.49,183.52 187.49,182.56 186.3,181.37 185.97,181.37 185.61,181.01 185.61,180.39 185.19,179.97 185.19,177.84 184.56,177.2 183.42,177.2 166.62,160.41 166.62,158.05 165.84,157.26 164.82,157.26 159.98,152.42 159.98,150.39 159.35,149.77 159.35,148.54 158.82,148.01 157.71,148.01 153.67,143.96 153.67,141.29 152.37,139.99 142.9,139.99 140.43,137.51 139.84,137.51 133.05,130.72 133.05,90.76 124.31,82.02 95.03,82.02 v1(87.9,74.9)
  BOTTOM w0.127: v1(87.9,74.9) 87.9,76.29 v2(88.18,76.57)
P11_LED2_SFP+_G_R: length 33.6
  TOP w0.127: R1259.2 88.23,73.25 88.37,73.11 88.37,70.97 88.3,70.9 C816.1 v1(87.9,70.08) ; v1(97.53,52.05) 97.72,51.87 LED44.C1
  S12 w0.127: v1(87.9,70.08) 87.98,70.01 87.98,68.62 88.4,68.19 89.65,68.19 96.54,61.3 96.54,59.99 98.83,57.7 98.83,54.7 97.53,53.4 v1(97.53,52.05)
  BOTTOM w0.127: v2(91.6,71.66) 89.48,71.66 v1(87.9,70.08)
P12_LED1_SFP+_A: length 180.5
  TOP w0.127: v4(192.55,181.58) U9.V4 ; R894.1 v1(118.75,68.6)
  S7 w0.127: v4(192.55,181.58) 192.8,181.33 192.8,177.32 188.68,173.2 185.7,173.2 174.78,162.28 174.78,157.77 173.76,156.75 173.07,156.75 171.29,154.98 171.29,152.37 169.29,150.37 169.29,149.28 166.45,146.44 166.45,138.3 170.72,134.03 174.26,134.03 176.06,132.23 176.06,92.85 167.38,84.16 148.41,84.16 144.07,79.82 132.22,79.82 125.38,72.97 119.77,72.97 119.22,72.43 119.22,69.06 v1(118.75,68.6)
  BOTTOM w0.127: v4(192.55,181.58) 192.55,180.13 v2(192.75,179.93)
P12_LED1_SFP+_A_R: length 26.8
  TOP w0.127: LED20.C2 v1(109.21,52.06) ; R894.2 118.37,66.95 118.27,66.84 118.27,64.78 118.45,64.6 C603.1 v1(118.75,63.82)
  S12 w0.127: v1(109.21,52.06) 108.02,53.26 108.02,56.61 109.05,57.65 109.05,60.29 110.26,61.51 114.33,61.51 115.82,63 117.93,63 v1(118.75,63.82)
  BOTTOM w0.127: v1(118.75,63.82) 118.52,64.05 v2(118.52,64.93)
P12_LED1_SFP+_G: length 164.8
  TOP w0.127: v4(193.55,183.58) U9.T5 ; R895.1 v1(117.74,68.6)
  S7 w0.127: v4(193.55,183.58) 193.13,183.16 193.13,182.27 192.93,182.06 192.47,182.06 192.09,181.68 192.09,177.11 188.43,173.45 185.57,173.45 174.46,162.35 174.46,157.9 173.64,157.07 173,157.07 171.03,155.1 171.03,153.15 169.87,151.99 169.51,151.99 166.84,149.32 166.84,148.77 165.69,147.61 165.69,147.1 166.2,146.59 166.2,143.19 166.18,143.17 166.18,143.14 153.93,130.89 149.45,130.89 145.79,127.23 140.68,127.23 140.36,126.91 140.36,118.42 144.81,113.98 144.81,108.62 136.11,99.92 136.11,88.38 125.89,78.17 125.89,74.14 125.02,73.27 119.11,73.27 118.17,72.33 118.17,69.03 v1(117.74,68.6)
  BOTTOM w0.127: v1(117.74,68.6) 117.69,68.56 v2(117.69,67.35)
P12_LED1_SFP+_G_R: length 26.1
  TOP w0.127: LED20.C1 v1(108.51,52.05) ; R895.2 117.4,66.95 117.21,66.76 117.21,64.75 117.36,64.6 C604.1 v1(117.74,63.77)
  S12 w0.127: v1(117.74,63.77) 117.26,63.29 115.67,63.29 114.2,61.82 110.2,61.82 108.75,60.37 108.75,57.72 107.59,56.55 107.59,55.19 107.66,55.12 107.66,52.9 v1(108.51,52.05)
  BOTTOM w0.127: v1(117.74,63.77) 117.57,63.6 v2(117.57,62.71)
P12_LED2_SFP+_A: length 149.7
  TOP w0.127: R1260.1 v1(118.72,74.11) ; U9.T4 v4(192.55,183.58)
  S7 w0.127: v1(118.72,74.11) 121.54,76.93 122.55,76.93 135.22,89.6 135.22,114.23 139.2,118.21 139.2,122.42 139.28,122.49 139.28,127.18 140.24,128.14 145.41,128.14 149.15,131.89 153.52,131.89 164.53,142.9 164.53,147.93 165.84,149.25 165.84,149.79 167.99,151.94 167.99,153.2 172.72,157.93 173.03,157.93 173.45,158.35 173.45,162.84 190.01,179.4 190.01,181.89 190.14,182.01 190.59,182.01 191.05,182.47 191.05,182.91 191.24,183.11 191.66,183.11 192.13,183.58 v4(192.55,183.58)
  BOTTOM w0.381: v1(118.72,74.11) 118.65,74.18 v2(118.65,75.16)
P12_LED2_SFP+_A_R: length 28.1
  TOP w0.127: LED45.C2 109.21,55.8 v1(109.34,55.93) ; v1(118.72,69.3) C819.1 118.34,70.11 118.23,70.23 118.23,72.34 118.35,72.46 R1260.2
  S9 w0.127: v1(109.34,55.93) 109.34,59.15 109.38,59.15 111.09,60.87 114.01,60.87 115.6,62.46 115.6,65.82 116.51,66.73 116.97,66.73 118.22,67.98 118.22,68.8 v1(118.72,69.3)
  BOTTOM w0.127: v2(119.35,72.62) 119.22,72.49 119.22,69.8 v1(118.72,69.3)
P12_LED2_SFP+_G: length 155.7
  TOP w0.127: v4(193.55,184.58) U9.R5 ; R1261.1 v1(117.7,74.11)
  S7 w0.127: v1(117.7,74.11) 120.95,77.37 122.25,77.37 134.97,90.08 134.97,114.34 138.87,118.24 138.87,127.13 140.13,128.39 145.21,128.39 149.04,132.22 153.38,132.22 163.48,142.32 163.48,149.26 162.92,149.81 162.92,153.15 165.13,155.36 169.7,155.36 172.43,158.09 172.43,162.47 189.28,179.31 189.28,180.79 189.14,180.92 189.14,181.91 189.32,182.09 189.78,182.09 190.03,182.34 190.03,182.93 190.26,183.16 190.77,183.16 190.95,183.33 190.95,183.54 191.51,184.1 193.07,184.1 v4(193.55,184.58)
  BOTTOM w0.381: v1(117.7,74.11) 117.1,74.71 v2(116.61,74.71)
P12_LED2_SFP+_G_R: length 26.2
  TOP w0.127: v1(117.7,69.3) C818.1 117.3,70.11 117.11,70.3 117.11,72.29 117.29,72.46 R1261.2 ; v1(108.52,55.9) 108.51,55.89 LED45.C1
  S9 w0.127: v1(108.52,55.9) 108.55,55.93 108.55,58.77 111.03,61.25 113.95,61.25 115.22,62.52 115.22,68.1 115.82,68.7 117.1,68.7 v1(117.7,69.3)
  BOTTOM w0.127: v2(117.69,70.52) 117.69,69.3 v1(117.7,69.3)
P13_LED1_SFP+_A: length 153.6
  TOP w0.127: v4(192.55,182.58) U9.U4 ; R896.1 v1(120.75,74.11)
  S7 w0.127: v4(192.55,182.58) 192.04,182.06 191.43,182.06 191.15,181.79 191.15,176.55 188.62,174.03 185.65,174.03 174.08,162.46 174.08,158.02 173.42,157.36 172.91,157.36 169.95,154.4 169.95,153.01 166.56,149.62 166.56,148.93 165.43,147.8 165.43,146.99 165.94,146.48 165.94,143.29 153.82,131.17 149.33,131.17 145.72,127.55 140.56,127.55 139.98,126.97 139.98,117.96 144.3,113.64 144.3,108.56 135.86,100.11 135.86,88.7 122.93,75.77 122.4,75.77 v1(120.75,74.11)
  BOTTOM w0.381: v2(121.12,75.54) 121.12,74.49 v1(120.75,74.11)
P13_LED1_SFP+_A_R: length 25.6
  TOP w0.127: v1(114.26,56.03) 114.71,55.57 LED21.C2 ; R896.2 120.33,72.46 120.26,72.39 120.26,70.33 120.48,70.11 C605.1 v1(120.75,69.3)
  S9 w0.127: v1(120.75,69.3) 120.24,68.79 120.24,67.14 120.07,66.96 119.6,66.96 119.28,66.65 119.28,65.95 118.18,64.85 117.73,64.85 117.21,64.32 117.21,63.11 114.72,60.63 114.72,56.49 v1(114.26,56.03)
  BOTTOM w0.127: v2(121.44,72.62) 121.44,69.99 v1(120.75,69.3)
P13_LED1_SFP+_G: length 148.1
  TOP w0.127: v4(190.55,181.58) U9.V2 ; R897.1 v1(119.73,74.11)
  S7 w0.127: v4(190.55,181.58) 190.55,177.16 189.32,175.93 187,175.93 173.76,162.69 173.76,158.15 173.29,157.67 172.84,157.67 168.35,153.18 168.35,151.92 166.17,149.74 166.17,149 164.78,147.61 164.78,142.79 164.77,142.78 164.77,142.67 153.65,131.56 149.25,131.56 145.58,127.89 140.34,127.89 139.53,127.07 139.53,118.18 135.47,114.13 135.47,88.84 123.01,76.37 121.99,76.37 v1(119.73,74.11)
  BOTTOM w0.127: v2(190.47,179.61) 190.55,179.7 v4(190.55,181.58)
P13_LED1_SFP+_G_R: length 23.6
  TOP w0.127: v1(114.23,56.87) 113.75,56.39 113.75,55.67 114.01,55.4 LED21.C1 ; R897.2 119.32,72.46 119.19,72.34 119.19,70.28 119.36,70.11 C606.1 v1(119.73,69.3)
  S9 w0.127: v1(114.23,56.87) 114.23,60.59 116.91,63.27 116.91,66.25 117.74,67.08 118.45,67.08 119.25,67.88 119.25,69.07 119.48,69.3 v1(119.73,69.3)
  BOTTOM w0.127: v1(119.73,69.3) 119.73,69.51 v2(120.81,70.58)
P13_LED2_SFP+_A: length 176.2
  TOP w0.127: R1262.1 v1(120.79,68.6) ; v4(193.55,181.58) U9.V5
  S7 w0.127: v1(120.79,68.6) 121.25,69.06 121.25,71.56 122.12,72.44 126.28,72.44 133.04,79.19 144.45,79.19 148.74,83.49 167.47,83.49 176.57,92.59 176.57,132.47 174.5,134.54 173.93,134.54 169.98,138.49 169.98,140.61 168.81,141.79 168.81,142.43 168.85,142.47 168.85,144.86 169.44,145.45 169.44,147.97 170.21,148.73 170.21,150.13 172.69,152.6 172.69,153.9 174.02,155.23 174.02,156.18 175.42,157.58 175.42,162.18 185.93,172.69 188.89,172.69 193.67,177.47 193.67,181.46 v4(193.55,181.58)
  BOTTOM w0.127: v2(194.89,179.2) 193.55,180.54 v4(193.55,181.58)
P13_LED2_SFP+_A_R: length 21.7
  TOP w0.127: LED46.C2 114.71,51.93 v1(114.55,52.1) ; v1(120.79,63.76) C821.1 120.48,64.6 120.31,64.77 120.31,66.82 120.44,66.95 R1262.2
  S12 w0.127: v1(114.55,52.1) 115.46,53.01 115.46,58.38 116.23,59.15 117.69,59.15 118.01,59.47 118.01,61.19 120.58,63.76 v1(120.79,63.76)
  BOTTOM w0.127: v1(120.79,63.76) 120.87,63.84 v2(120.87,64.81)
P13_LED2_SFP+_G: length 178.1
  TOP w0.127: R1263.1 v1(119.77,68.6) ; v4(193.55,182.58) U9.U5
  S7 w0.127: v1(119.77,68.6) 120.23,69.06 120.23,72.43 120.52,72.72 125.92,72.72 132.7,79.49 144.21,79.49 148.55,83.83 167.43,83.83 176.32,92.72 176.32,132.33 174.36,134.29 173.82,134.29 169.73,138.38 169.73,140.51 168.55,141.68 168.55,143.07 168.35,143.27 167.99,143.27 167.56,143.7 167.56,146.65 169.73,148.83 169.73,150.12 171.54,151.93 171.54,153.58 172.65,154.69 172.65,155.9 173.19,156.44 173.89,156.44 175.07,157.61 175.07,162.19 185.83,172.95 188.78,172.95 193.06,177.22 193.06,181.71 193.55,182.2 v4(193.55,182.58)
  BOTTOM w0.127: v1(119.77,68.6) 119.79,68.58 v2(119.79,67.41)
P13_LED2_SFP+_G_R: length 22.7
  TOP w0.127: LED46.C1 114.02,51.87 v1(113.83,52.05) ; v1(119.77,63.76) C820.1 119.45,64.6 119.29,64.76 119.29,66.82 119.42,66.95 R1263.2
  S12 w0.127: v1(119.77,63.76) 118.75,62.74 116.01,62.74 114.52,61.25 114.52,58.71 115.13,58.1 115.13,53.35 v1(113.83,52.05)
  BOTTOM w0.127: v2(119.73,62.77) 119.73,63.71 v1(119.77,63.76)
P14_LED1_SFP+_A: length 162.7
  TOP w0.127: R928.1 v1(142.19,69.11) ; v4(199.55,185.58) U9.P10
  S7 w0.127: v1(142.19,69.11) 142.32,69.11 143.43,70.21 143.43,75.24 145.02,76.83 145.43,76.83 149.75,81.15 168.66,81.15 178.6,91.09 178.6,134.01 174.4,138.22 174.4,139 172.16,141.24 172.16,144.92 172.95,145.71 172.95,148.44 174.65,150.15 174.65,150.53 177.13,153.01 177.77,153.01 179.42,154.66 179.42,156.12 180.18,156.88 180.18,159.96 183.19,162.97 183.19,164.12 188.9,169.83 190.78,169.83 191.8,170.85 191.8,172.73 198.49,179.42 198.49,184.52 v4(199.55,185.58)
  BOTTOM w0.127: v2(143.09,67.11) 143.09,68.87 142.86,69.11 v1(142.19,69.11)
P14_LED1_SFP+_A_R: length 35.1
  TOP w0.127: R928.2 141.92,67.46 141.71,67.25 141.71,65.22 141.82,65.11 C657.1 v1(142.19,64.29) ; v1(125.54,51.91) 125.51,51.89 LED22.C2
  S12 w0.127: v1(125.54,51.91) 124.35,53.1 124.35,56.51 124.93,57.1 124.93,58.65 128.78,62.49 131.19,62.49 132.43,63.73 133.76,63.73 135.33,65.3 140.14,65.3 140.62,64.82 140.62,64.09 140.99,63.72 141.62,63.72 v1(142.19,64.29)
  BOTTOM w0.127: v2(141.83,63.29) 141.82,63.29 141.82,63.28 142.19,63.65 v1(142.19,64.29)
P14_LED1_SFP+_G: length 165.6
  TOP w0.127: R929.1 v1(141.18,69.11) ; v4(200.55,185.58) U9.P11
  S7 w0.127: v4(200.55,185.58) 200.1,186.03 199.33,186.03 198.24,184.93 198.24,179.53 190.85,172.13 190.85,170.66 190.59,170.41 188.28,170.41 179.92,162.05 179.92,156.99 179.16,156.22 179.16,154.76 177.72,153.32 177,153.32 174.4,150.72 174.4,150.34 172.43,148.37 172.43,145.95 171.85,145.37 171.85,141.1 174.11,138.84 174.11,138.15 178.35,133.9 178.35,91.24 168.52,81.4 149.64,81.4 145.33,77.09 144.9,77.09 143.17,75.36 143.17,70.35 142.43,69.61 141.68,69.61 v1(141.18,69.11)
  BOTTOM w0.127: v2(140.35,71.47) 140.74,71.08 140.74,69.38 141.02,69.11 v1(141.18,69.11)
P14_LED1_SFP+_G_R: length 34.6
  TOP w0.127: v1(141.18,64.3) C658.1 140.87,65.11 140.68,65.3 140.68,67.33 140.8,67.46 R929.2 ; LED22.C1 124.81,51.08 124.81,51.08 124.81,51.88 v1(124.84,51.9)
  S12 w0.127: v1(124.84,51.9) 124.84,52.03 124.02,52.85 124.02,56.56 124.62,57.16 124.62,58.71 128.95,63.05 131.1,63.05 132.35,64.3 133.6,64.3 135.07,65.76 140.7,65.76 141.18,65.28 v1(141.18,64.3)
  BOTTOM w0.127: v1(141.18,64.3) 141.18,65.42 v2(141.37,65.62)
P14_LED2_SFP+_A: length 154.1
  TOP w0.127: U9.V6 v4(194.55,181.58) ; R1264.1 v1(140.22,74.95)
  S7 w0.127: v4(194.55,181.58) 194.55,177.64 189.02,172.11 187.88,172.11 176.05,160.27 176.05,157.07 175.29,156.31 175.29,155.36 173.38,153.45 173.38,152.56 171.03,150.21 171.03,148.67 169.97,147.6 169.97,144.2 169.85,144.08 169.85,142.69 170.49,142.05 170.49,138.7 174.14,135.05 174.72,135.05 177.08,132.69 177.08,92.24 167.67,82.83 149.02,82.83 144.72,78.53 143.81,78.53 v1(140.22,74.95)
  BOTTOM w0.127: v4(194.55,181.58) 194.55,181.18 195.55,180.19 195.55,178.12 v2(194.72,177.3)
P14_LED2_SFP+_A_R: length 31.7
  TOP w0.127: v1(125.59,55.88) 125.51,55.8 LED47.C2 ; v1(140.22,70.13) C823.1 140.61,70.95 140.75,71.09 140.75,72.77 R1264.2
  S9 w0.127: v1(140.22,70.13) 140.22,70.12 139.66,69.55 139.66,68.65 139.43,68.43 134.93,68.43 125.59,59.09 v1(125.59,55.88)
  BOTTOM w0.127: v1(140.22,70.13) 139.75,70.6 139.75,73.35 v2(139.54,73.57)
P14_LED2_SFP+_G: length 154.3
  TOP w0.127: R1265.1 v1(139.21,74.95) ; U9.T6 v4(194.55,183.58)
  S7 w0.127: v4(194.55,183.58) 193.95,182.97 193.95,177.39 188.93,172.37 185.97,172.37 175.67,162.07 175.67,157.2 175.03,156.56 175.03,155.61 173.1,153.67 173.1,152.66 170.65,150.21 170.65,148.73 169.71,147.79 169.71,144.31 169.55,144.14 169.55,142.63 170.23,141.95 170.23,138.59 174.03,134.8 174.62,134.8 176.83,132.59 176.83,92.39 167.57,83.13 148.89,83.13 144.6,78.84 143.1,78.84 v1(139.21,74.95)
  BOTTOM w0.127: v2(137.83,75) 139.15,75 v1(139.21,74.95)
P14_LED2_SFP+_G_R: length 29.2
  TOP w0.127: v1(124.86,55.9) 124.81,55.86 LED47.C1 ; v1(139.21,70.13) C822.1 138.96,70.95 138.66,71.25 138.66,73.09 138.87,73.3 R1265.2
  S9 w0.127: v1(139.21,70.13) 138.1,69.03 134.85,69.03 134.1,68.28 133.3,68.28 129.42,64.4 129.42,63.57 125.25,59.4 125.25,56.3 v1(124.86,55.9)
  BOTTOM w0.127: v2(138.45,71.26) 138.45,70.89 v1(139.21,70.13)
P15_LED1_SFP+_A: length 154.9
  TOP w0.127: v1(142.01,74.95) 142.26,74.71 R930.1 ; U9.P6 v4(194.55,185.58)
  S7 w0.127: v4(194.55,185.58) 195.02,185.11 195.7,185.11 196.15,184.66 196.15,178.52 189.12,171.49 188.01,171.49 177.77,161.25 177.77,157.9 175.88,156.01 175.88,153.85 174.08,152.05 173.89,152.05 171.63,149.79 171.63,146.39 171.09,145.84 171.09,138.82 174.35,135.56 174.93,135.56 177.59,132.9 177.59,91.7 168.16,82.27 149.29,82.27 144.97,77.95 144.59,77.95 142.01,75.37 v1(142.01,74.95)
  BOTTOM w0.127: v2(143.07,75.98) 143.05,75.98 v1(142.01,74.95)
P15_LED1_SFP+_A_R: length 30.7
  TOP w0.127: v1(128.51,56.03) 128.96,55.57 LED23.C2 ; v1(142.26,70.13) C659.1 142.69,70.95 142.84,71.09 142.84,73.17 142.71,73.3 R930.2
  S9 w0.127: v1(142.26,70.13) 142.07,70.13 141.66,69.72 141.66,67.76 141.33,67.44 138.45,67.44 137.93,66.91 134.5,66.91 128.97,61.38 128.97,56.49 v1(128.51,56.03)
  BOTTOM w0.127: v1(142.26,70.13) 142.21,70.18 142.21,71.42 v2(142.26,71.46)
P15_LED1_SFP+_G: length 153
  TOP w0.127: U9.R6 v4(194.55,184.58) ; R931.1 v1(141.24,74.95)
  S7 w0.127: v4(194.55,184.58) 195.11,184.02 195.11,177.84 189.08,171.8 187.96,171.8 176.3,160.14 176.3,156.9 175.57,156.17 175.57,155.26 173.66,153.35 173.66,152.31 171.29,149.94 171.29,148.51 171.01,148.23 171.01,146.13 170.83,145.95 170.83,138.72 174.24,135.3 174.83,135.3 177.33,132.8 177.33,91.84 168.04,82.55 149.17,82.55 144.85,78.23 144.39,78.23 141.24,75.08 v1(141.24,74.95)
  BOTTOM w0.127: v2(141.28,76.62) 141.24,76.58 v1(141.24,74.95)
P15_LED1_SFP+_G_R: length 32.1
  TOP w0.127: LED23.C1 128.26,55.3 128,55.57 128,56.41 v1(128.43,56.85) ; v1(141.24,70.13) C660.1 141.6,70.95 141.71,71.06 141.71,73.15 141.57,73.3 R931.2
  S9 w0.127: v1(141.24,70.13) 140.94,70.13 140.66,69.85 140.66,68.3 140.38,68.03 135.01,68.03 128.43,61.45 v1(128.43,56.85)
  BOTTOM w0.127: v1(141.24,70.13) 141.47,70.36 141.47,72.12 141.71,72.36 141.71,73.36 v2(141.44,73.63)
P15_LED2_SFP+_A: length 159.6
  TOP w0.127: v4(196.55,182.58) U9.U8 ; R1266.1 v1(139.15,69.11)
  S7 w0.127: v1(139.15,69.11) 139.7,69.66 139.7,70.76 140.78,71.84 141.65,71.84 141.78,71.97 141.78,73.03 142.56,73.8 142.56,75.51 144.75,77.7 145.07,77.7 149.39,82.01 168.26,82.01 177.84,91.59 177.84,133.2 172.41,138.64 172.41,139.13 171.34,140.2 171.34,145.74 171.88,146.28 171.88,148.59 173.89,150.59 173.89,151.04 176.88,154.02 177.66,154.02 178.34,154.7 178.34,156.25 179.16,157.07 179.16,159.29 178.53,159.93 178.53,161.54 188.09,171.1 189.1,171.1 197.15,179.15 197.15,182.14 196.71,182.58 v4(196.55,182.58)
  BOTTOM w0.127: v1(139.15,69.11) 138.65,68.61 v2(138.65,67.71)
P15_LED2_SFP+_A_R: length 25.2
  TOP w0.127: R1266.2 138.78,67.46 138.63,67.31 138.63,65.27 138.8,65.11 C825.1 139.15,64.38 v1(139.08,64.31) ; v1(128.83,51.89) 128.96,51.75 LED48.C2
  S12 w0.127: v1(139.08,64.31) 136.13,61.37 132.55,61.37 129.71,58.53 129.71,52.78 v1(128.83,51.89)
  BOTTOM w0.127: v1(139.08,64.31) 139.08,63.42 v2(139.28,63.22)
