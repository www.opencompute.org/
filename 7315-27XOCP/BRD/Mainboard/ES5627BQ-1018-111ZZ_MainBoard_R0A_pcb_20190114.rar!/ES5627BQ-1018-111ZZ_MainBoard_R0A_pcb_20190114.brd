# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Nets (continued)
DDRB_WE_N: RB82.2 U14.L2(\\W\E/A14) U15.L2(\\W\E/A14) U40.AK12(DDRB_WE_N)
DDRB_ZQ_1: RB127.2 U15.F9(ZQ)
DDRB_ZQ_2: RB125.2 U14.F9(ZQ)
DDRC_100M_N: CB455.1 RB22.1
DDRC_100M_P: CB441.1 RB38.1
DDRC_100M_REFCLK_N: CB455.2 RB182.1 U40.AF7(DDRC_REFCLK_N)
DDRC_100M_REFCLK_P: CB441.2 RB182.2 U40.AF8(DDRC_REFCLK_P)
DDRC_A0: RB71.2 U16.P3(A0) U17.P3(A0) U40.AM7(DDRC_A11)
DDRC_A1: R197.2 U16.P7(A1) U17.P7(A1) U40.AU4(DDRC_A1_A1A9)
DDRC_A2: RB74.2 U16.R3(A2) U17.R3(A2) U40.AN6(DDRC_A13)
DDRC_A3: R187.2 U16.N7(A3) U17.N7(A3) U40.AM4(DDRC_BA0_A2BA0)
DDRC_A4: RB70.2 U16.N3(A4) U17.N3(A4) U40.AL7(DDRC_A12)
DDRC_A5: RB92.2 U16.P8(A5) U17.P8(A5) U40.AN3(DDRC_BG0_A4BA2)
DDRC_A6: RB77.2 U16.P2(A6) U17.P2(A6) U40.AH9(DDRC_A9)
DDRC_A7: RB86.2 U16.R8(A7) U17.R8(A7) U40.AT3(DDRC_A5_A14A15)
DDRC_A8: RB76.2 U16.R2(A8) U17.R2(A8) U40.AG9(DDRC_A8)
DDRC_A9: R209.2 U16.R7(A9) U17.R7(A9) U40.AR5(DDRC_A2_A0A10)
DDRC_A10: RB69.2 U16.M3(A10) U17.M3(A10) U40.AT5(DDRC_A0_A7A8)
DDRC_A11: RB75.2 U16.T2(A11) U17.T2(A11) U40.AE9(DDRC_A7)
DDRC_A12: R179.2 U16.M7(A12) U17.M7(A12) U40.AP4(DDRC_A6)
DDRC_A13: R221.2 U16.T8(A13) U17.T8(A13) U40.AU3(DDRC_A3_A6A11)
DDRC_ACT_N: RB68.2 U16.L3(ACT) U17.L3(ACT) U40.AT2(DDRC_ACT_ABI_N)
DDRC_ALERT0: TPB47.1 U17.P9(ALERT) U40.AR1(DDRC_ALERT_N_0)
DDRC_ALERT1: TPB48.1 U16.P9(ALERT) U40.AH6(DDRC_ALERT_N_1)
DDRC_BA0: RB72.2 U16.N2(BA0) U17.N2(BA0) U40.AJ8(DDRC_A10)
DDRC_BA1: RB96.2 U16.N8(BA1) U17.N8(BA1) U40.AR4(DDRC_A4_A13A12)
DDRC_BG0: RB85.2 U16.M2(BG0) U17.M2(BG0) U40.AH7(DDRC_BA1_A5BA1)
DDRC_CAS_N: RB100.2 U16.M8(\\C\A\S/A15) U17.M8(\\C\A\S/A15) U40.AP3(DDRC_CAS_N)
DDRC_CK_N: RB110.2 U16.K8(\\C\K\) U17.K8(\\C\K\) U40.AK6(DDRC_CK_N)
DDRC_CK_P: RB116.2 U16.K7(CK) U17.K7(CK) U40.AK5(DDRC_CK_P)
DDRC_CKE: RB99.2 U16.K2(CKE) U17.K2(CKE) U40.AG6(DDRC_CKE)
DDRC_CS_N0: RB79.2 U17.L7(CS) U40.AN2(DDRC_CS_N_0)
DDRC_CS_N1: RB107.2 U16.L7(CS) U40.AM5(DDRC_CS_N_1)
DDRC_DBI_N0: U17.E7(\N\F\/\L\D\M\/L\D\B\I\) U40.AC4(DDRC_DBI_N_0)
DDRC_DBI_N1: U17.E2(\N\F\/\U\D\M\/U\D\B\I\) U40.AH3(DDRC_DBI_N_1)
DDRC_DBI_N2: U16.E7(\N\F\/\L\D\M\/L\D\B\I\) U40.AE7(DDRC_DBI_N_2)
DDRC_DBI_N3: U16.E2(\N\F\/\U\D\M\/U\D\B\I\) U40.AB6(DDRC_DBI_N_3)
DDRC_DQ0: U17.G2(DQ0) U40.AB1(DDRC_DQ_2)
DDRC_DQ1: U17.F7(DQ1) U40.AD2(DDRC_DQ_5)
DDRC_DQ2: U17.H3(DQ2) U40.AB3(DDRC_DQ_3)
DDRC_DQ3: U17.H7(DQ3) U40.AE1(DDRC_DQ_4)
DDRC_DQ4: U17.H2(DQ4) U40.AA2(DDRC_DQ_1)
DDRC_DQ5: U17.H8(DQ5) U40.AD3(DDRC_DQ_7)
DDRC_DQ6: U17.J3(DQ6) U40.AE3(DDRC_DQ_6)
DDRC_DQ7: U17.J7(DQ7) U40.AA3(DDRC_DQ_0)
DDRC_DQ8: U17.A3(DQ8) U40.AG2(DDRC_DQ_10)
DDRC_DQ9: U17.B8(DQ9) U40.AK2(DDRC_DQ_14)
DDRC_DQ10: U17.C3(DQ10) U40.AF1(DDRC_DQ_8)
DDRC_DQ11: U17.C7(DQ11) U40.AJ2(DDRC_DQ_13)
DDRC_DQ12: U17.C2(DQ12) U40.AF2(DDRC_DQ_9)
DDRC_DQ13: U17.C8(DQ13) U40.AM1(DDRC_DQ_12)
DDRC_DQ14: U17.D3(DQ14) U40.AG3(DDRC_DQ_11)
DDRC_DQ15: U17.D7(DQ15) U40.AM2(DDRC_DQ_15)
DDRC_DQ16: U16.G2(DQ0) U40.AK3(DDRC_DQ_21)
DDRC_DQ17: U16.F7(DQ1) U40.AE6(DDRC_DQ_16)
DDRC_DQ18: U16.H3(DQ2) U40.AL3(DDRC_DQ_22)
DDRC_DQ19: U16.H7(DQ3) U40.AG5(DDRC_DQ_18)
DDRC_DQ20: U16.H2(DQ4) U40.AL4(DDRC_DQ_23)
DDRC_DQ21: U16.H8(DQ5) U40.AD8(DDRC_DQ_20)
DDRC_DQ22: U16.J3(DQ6) U40.AH4(DDRC_DQ_19)
DDRC_DQ23: U16.J7(DQ7) U40.AC8(DDRC_DQ_17)
DDRC_DQ24: U16.A3(DQ8) U40.AB4(DDRC_DQ_24)
DDRC_DQ25: U16.B8(DQ9) U40.AF4(DDRC_DQ_31)
DDRC_DQ26: U16.C3(DQ10) U40.AE4(DDRC_DQ_28)
DDRC_DQ27: U16.C7(DQ11) U40.AF5(DDRC_DQ_30)
DDRC_DQ28: U16.C2(DQ12) U40.AB7(DDRC_DQ_26)
DDRC_DQ29: U16.C8(DQ13) U40.AC7(DDRC_DQ_29)
DDRC_DQ30: U16.D3(DQ14) U40.AA8(DDRC_DQ_27)
DDRC_DQ31: U16.D7(DQ15) U40.AA9(DDRC_DQ_25)
DDRC_DQS0_N: U17.F3(\\L\D\Q\S\) U40.AC2(DDRC_DQS0_WCK01_N)
DDRC_DQS0_P: U17.G3(LDQS) U40.AC1(DDRC_DQS0_WCK01_P)
DDRC_DQS1_N: U17.A7(\\U\D\Q\S\) U40.AJ1(DDRC_DQS1_N)
DDRC_DQS1_P: U17.B7(UDQS) U40.AH1(DDRC_DQS1_P)
DDRC_DQS2_N: U16.F3(\\L\D\Q\S\) U40.AJ5(DDRC_DQS2_WCK23_N)
DDRC_DQS2_P: U16.G3(LDQS) U40.AJ4(DDRC_DQS2_WCK23_P)
DDRC_DQS3_N: U16.A7(\\U\D\Q\S\) U40.AD6(DDRC_DQS3_N)
DDRC_DQS3_P: U16.B7(UDQS) U40.AD5(DDRC_DQS3_P)
DDRC_ODT: RB102.2 U16.K3(ODT) U17.K3(ODT) U40.AP1(DDRC_ODT)
DDRC_PAR: RB73.2 U16.T3(PAR) U17.T3(PAR) U40.AR2(DDRC_PAR)
DDRC_RAS_N: R267.2 U16.L8(\\R\A\S/A16) U17.L8(\\R\A\S/A16) U40.AG8(DDRC_RAS_N)
DDRC_RST_N: RB78.2 U16.P1(RESET) U17.P1(RESET) U40.AN5(DDRC_RESET_N)
DDRC_TEN: R238.2 R250.1 U16.N9(TEN) U17.N9(TEN)
DDRC_VREF_1: CB120.1 CB159.1 RB89.2 RB94.1 RB104.1 U17.M1(VREFCA)
DDRC_VREF_2: CB90.1 CB160.1 RB46.1 RB47.2 U16.M1(VREFCA)
DDRC_WE_N: RB90.2 U16.L2(\\W\E/A14) U17.L2(\\W\E/A14) U40.AJ7(DDRC_WE_N)
DDRC_ZQ_1: RB128.2 U17.F9(ZQ)
DDRC_ZQ_2: RB121.2 U16.F9(ZQ)
DIAG_A: P1.G7(IO_B8_G7/DIFFIO_T3N) RB736.2
DIAG_A_R: CB982.2 LEDB7.C1 RB736.1
DIAG_G: P1.C9(IO_B8_C9/DIFFIO_T5N/DQ3T) RB737.2
DIAG_G_R: CB983.2 LEDB7.C2 RB737.1
DISCONNECT: R552.1 R553.2 U40.AJ31(DISCONNECT)
DSR_L: CB926.1 LB73.2 RJ1.F7
DTR_L: CB927.1 LB74.2 RJ1.F2
EE_A0: R73.2 R88.2 U8.1(A0)
EE_A1: R99.2 R111.2 U8.2(A1)
EE_A2: R117.2 R121.2 U8.3(A2)
EE_WP: P1.H8(IO_B8_H8/DIFFIO_T1P) R96.2 R106.1 U8.7(WP)
EEPROM_SCL: R278.1 U8.6(SCL)
EEPROM_SCL_R: R278.2 R279.2 U10.9(SC2)
EEPROM_SDA: R260.1 U8.5(SDA)
EEPROM_SDA_R: R260.2 R261.2 U10.8(SD2)
EN3_5: RB192.2 U39.3(EN)
EN3_6: RB162.2 U30.3(EN)
EN_VDD1P0_ROV: C324.1 R591.2 R600.2 U33.23(ENABLE)
FAN_A: P1.W17(IO_B4_W17/DIFFIO_B30P/DQ2B) RB738.2
FAN_A_R: CB984.2 LEDB8.C1 RB738.1
FAN_G: P1.AB4(IO_B3_AB4/DIFFIO_B9P/DQ3B) RB722.2
FAN_G_R: CB976.2 LEDB8.C2 RB722.1
FAN_IDLE: CONN56.19 P1.W21(IO_B5_W21/DIFFIO_R45N/DQ3R)
FAN_INT_L: CONN56.21 P1.U20(IO_B5_U20/DIFFIO_R42N/DQ3R)
FAN_SCL_1: CONN56.22 RB84.1
FAN_SCL_FPGA: RB84.2 RB133.2
FAN_SCL_FPGA_R: P1.Y9(IO_B3_Y9/DIFFIO_B13P/DQ5B) RB130.2 RB133.1
FAN_SDA_1: CONN56.20 RB88.1
FAN_SDA_FPGA: RB88.2 RB132.2
FAN_SDA_FPGA_R: P1.Y8(IO_B3_Y8/DIFFIO_B12N/DQS3B/CQ3B) RB129.2 RB132.1
FAP_A_FC_RX_CLK: RB147.2 RB148.1 RB156.1 U40.AP37(FC_RX_CLK)
FAP_A_FC_RX_STAT_0: RB171.1 RB175.2 RB177.1 U40.AM37(FC_RX_STAT_0)
FAP_A_FC_RX_STAT_1: RB150.2 RB153.1 RB158.1 U40.AL37(FC_RX_STAT_1)
FAP_A_FC_TX_CLK: RB156.2 U40.AN37(FC_TX_CLK)
FAP_A_FC_TX_STAT_0: RB177.2 U40.AJ37(FC_TX_STAT_0)
FAP_A_FC_TX_STAT_1: RB158.2 U40.AK37(FC_TX_STAT_1)
FAP_GPIO0: R254.1 R683.1 U40.AA34(GPIO0)
FAP_GPIO1: R366.1 R639.1 U40.AA33(GPIO1)
FAP_NSE_SYNC_IN0: R61.1 R662.2
FAP_NSE_SYNC_IN0_R: R662.1 R663.1 U40.AA35(NSE_SYNC_IN0)
FAP_NSE_SYNC_IN1: R211.1 R664.1 U40.AB35(NSE_SYNC_IN1)
FAP_NSE_SYNC_OUT: R78.1 R625.1 U40.AB34(NSE_SYNC_OUT)
FAP_SYNC0_R: R1186.1 U40.AC29(TS_SYNC0)
FAP_SYNC1: R77.2 R624.1
FAP_SYNC1_FPGA: P1.C6(IO_B8_C6/DIFFIO_T14P/DQ5T) R77.1
FAP_SYNC1_R: R624.2 U40.AC30(TS_SYNC1)
FAP_TIME_VAL0: R60.2 R630.1
FAP_TIME_VAL0_FPGA: P1.H12(IO_B7_H12/DIFFIO_T20P/DM4T) R60.1
FAP_TIME_VAL0_R: R630.2 U40.AE30(TS_TIME_VAL0)
FAP_TIME_VAL1: R59.2 R580.1
FAP_TIME_VAL1_FPGA: P1.N13(IO_B5_N13/DIFFIO_R35P) R59.1
FAP_TIME_VAL1_R: R580.2 U40.AC31(TS_TIME_VAL1)
FAP_TS_BIT_CLK0: R83.2 R638.1
FAP_TS_BIT_CLK0_FPGA: P1.M14(IO_B5_M14/DIFFIO_R35N) R83.1
FAP_TS_BIT_CLK1: R82.2 R581.1
FAP_TS_BIT_CLK1_FPGA: P1.M18(IO_B5_M18/DIFFIO_R26P/DQ1R) R82.1
FB_VCC5P0: C361.2 R667.1 R688.2 U34.5(FB)
FC0_156.25M_REFCLKN_R: R1375.2 R1400.1 U77.67(HPOUT0N)
FC0_156.25M_REFCLKP_R: R1374.2 R1399.1 U77.66(HPOUT0P)
FC1_156.25M_REFCLKN_R: R1377.2 R1402.1 U77.63(HPOUT1N)
FC1_156.25M_REFCLKP_R: R1376.2 R1401.1 U77.64(HPOUT1P)
FC2_156.25M_REFCLKN_R: R1379.2 R1394.1 U77.60(HPOUT2N)
FC2_156.25M_REFCLKP_R: R1378.2 R1403.1 U77.59(HPOUT2P)
FC_SYNC_VDDP_1P8: C272.1 CB480.1 L18.1 U40.AE29(FC_SYNCE_VDDP)
FCCM10_5: R655.2 U39.10(FCCM)
FCCM10_6: R491.2 U30.10(FCCM)
FPGA1588_TOD_OUT_R: P1.H22(IO_B6_H22/DIFFIO_R22N/DQS0R/CQ1) R326.1
FPGA1588_TOD_OUT_TO_GPS MODULE: R326.2 R726.2
FPGA1588_TOD_OUT_TO_RJ: R408.2 U51.9(2D)
FPGA1588_TOD_OUT_TO_RJ_R: R407.1 R408.1
FPGA1588_UART1_TOD_OUT: P1.T11(IO_B3_T11/DIFFIO_B6N/DQ3B) R407.2
FPGA_1V2: CB36.2 CB1112.2 CB1113.2 CB1114.2 CB1115.1 CB1116.1 CB1117.1 CB1118.1 CB1119.1 CB1125.1 CB1126.1 CB1127.1 CB1128.1 CB1129.1 CB1130.1 CB1131.1 CB1132.1 CB1133.1 CB1134.1 CB1135.1 CONN6.9 LB104.1 LB106.1 P1.F7(VCCINT_F7) P1.G9(VCCINT_G9) P1.G13(VCCINT_G13) P1.H6(VCCINT_H6) P1.J5(VCCINT_J5) P1.J7(VCCINT_J7) P1.J9(VCCINT_J9) P1.J11(VCCINT_J11) P1.J17(VCCINT_J17) P1.K6(VCCINT_K6) P1.K8(VCCINT_K8) P1.K16(VCCINT_K16) P1.L5(VCCINT_L5) P1.L7(VCCINT_L7) P1.L9(VCCINT_L9) P1.L11(VCCINT_L11) P1.L17(VCCINT_L17) P1.M6(VCCINT_M6) P1.M10(VCCINT_M10) P1.M12(VCCINT_M12) P1.N5(VCCINT_N5) P1.N9(VCCINT_N9) P1.N16(VCCINT_N16) P1.P6(VCCINT_P6) P1.P8(VCCINT_P8) P1.P12(VCCINT_P12) P1.P17(VCCINT_P17) P1.R7(VCCINT_R7) P1.T10(VCCINT_T10) P1.T12(VCCINT_T12) P1.U16(VCCINT_U16) R161.2
FPGA_1V2_MON: C104.1 R161.1 U7.52(MON15)
FPGA_2V5: CB12.1 CB1136.1 CB1137.1 CB1138.1 CONN6.21 LB105.1 LB107.1 LB109.1 R208.1 RB1305.1 RB1307.1
FPGA_2V5_MON: C118.1 R195.1 R208.2 U7.50(MON14)
FPGA_25M_REF_CLK_N: C908.1 R1393.1
FPGA_25M_REF_CLK_N_F: C908.2 P1.J10(CLKIO10_J10/DIFFCLK_4N,REFCLK3N) R1503.1
FPGA_25M_REF_CLK_N_R: R1383.1 R1393.2 U77.46(HPOUT6N)
FPGA_25M_REF_CLK_P: C909.1 R1392.1
FPGA_25M_REF_CLK_P_F: C909.2 P1.K10(CLKIO11_K10/DIFFCLK_4P,REFCLK3P) R1504.1
FPGA_25M_REF_CLK_P_R: R1382.1 R1392.2 U77.45(HPOUT6P)
FPGA_156.25M_REF_CLK_N: C988.1 R1387.1
FPGA_156.25M_REF_CLK_N_F: C988.2 P1.AB12(CLKIO15_AB12/DIFFCLK_6N) R1502.1
FPGA_156.25M_REF_CLK_N_R: R1387.2 R1396.1 U77.56(HPOUT3N)
FPGA_156.25M_REF_CLK_P: C987.1 R1386.1
FPGA_156.25M_REF_CLK_P_F: C987.2 P1.AA12(CLKIO14_AA12/DIFFCLK_6P) R1501.1
FPGA_156.25M_REF_CLK_P_R: R1386.2 R1395.1 U77.57(HPOUT3P)
FPGA_CLKUSR: P1.G11(IO_B8_G11/ CLKUSR) R1470.2
FPGA_CONF_DONE: CONN57.3 P1.U5(CONF_DONE) R1341.1
FPGA_CPU_PCIE_RX_N: C905.2 J2.B62(PCIE_RX2-)
FPGA_CPU_PCIE_RX_N_F: C905.1 P1.V1(GXB_TX0N)
FPGA_CPU_PCIE_RX_P: C904.2 J2.B61(PCIE_RX2+)
FPGA_CPU_PCIE_RX_P_F: C904.1 P1.V2(GXB_TX0P)
FPGA_CRC_ERROR: P1.AA4(IO_B3_AA4/DIFFIO_B3P/ CRC_ERROR) R1469.2
FPGA_DATA0: P1.K4(IO_B9_K4/ DATA0) R1455.1 RB1291.1
FPGA_DATA1: P1.D1(IO_B9_D1/ DATA1, ASDO) R1454.1 RB1292.1
FPGA_DCLK: CONN57.1 P1.D3(DCLK) U80.16(SCLK)
FPGA_DEV_CLRN: P1.P13(IO_B5_P13/DIFFIO_R44P/ DEV_CLRN) R1464.1 R1467.2
FPGA_DEV_OE: P1.P14(IO_B5_P14/DIFFIO_R44N/ DEV_OE) R1466.1 R1468.2
FPGA_INIT_DONE: P1.W8(IO_B3_W8/ INIT_DONE) R1471.2
FPGA_JTAG_TCK: R355.1 R1343.1 R1347.1
FPGA_JTAG_TCK_R: P1.E4(TCK) R1343.2
FPGA_JTAG_TDI_R: P1.F5(TDI) R1344.2
FPGA_JTAG_TDO: R258.2 R1346.1
FPGA_JTAG_TDO_R: P1.E3(TDO) R1346.2
FPGA_JTAG_TMS: R419.1 R1345.1
FPGA_JTAG_TMS_R: P1.G5(TMS) R1345.2
FPGA_MSEL0: P1.T6(MSEL0) R1456.1 R1457.2
FPGA_MSEL1: P1.P5(MSEL1) R1458.1 R1459.2
FPGA_MSEL2: P1.R5(MSEL2) R1460.1 R1461.2
FPGA_MSEL3: P1.P4(MSEL3) R1462.1 R1463.2
FPGA_NCE: CONN57.6 P1.D2(NCE) R1453.1
FPGA_NCEO: P1.AB3(IO_B3_AB3/DIFFIO_B3N/ NCEO) R1472.2
FPGA_NCONFIG: CONN57.5 P1.H4(NCONFIG) R1339.1
FPGA_NCSO: CONN57.8 P1.J4(IO_B9_J4/ NCSO) U80.7(CS#)
FPGA_NSTATUS: P1.R8(NSTATUS) R1340.1
FPGA_REF_CLK0: P1.M8(REFCLK1P_M8/DIFFCLK_1P,CLKIO22) R1388.1
FPGA_REF_CLK0_R: R1388.2 U77.51(HPOUT4P)
FPGA_REF_CLK1: P1.N8(REFCLK1N_N8/DIFFCLK_1N) R1389.1
FPGA_REF_CLK1_R: R1389.2 U77.52(HPOUT4N)
FPGA_REF_CLK2: P1.M11(CLKIO12_M11/DIFFCLK_7P,REFCLK2P) R1390.1
FPGA_REF_CLK2_R: R1390.2 U77.49(HPOUT5P)
FPGA_REF_CLK3: P1.N11(CLKIO13_N11/DIFFCLK_7N,REFCLK2N) R1391.1
FPGA_REF_CLK3_R: R1391.2 U77.48(HPOUT5N)
FPGA_REF_CLK_OUT0: R1410.2 RB1262.2
FPGA_REF_CLK_OUT1: R1411.2 RB1263.2
FPGA_REF_CLK_OUT2: R1412.2 RB1264.2
FPGA_REF_CLK_OUT3: R1413.2 RB1265.2
FPGA_RES_CLK: P1.B9(CLKIO9_B9/DIFFCLK_5P) R1405.1
FPGA_RES_CLK_R: R1405.2 U77.42(HPOUT7N)
FPGA_SN65C_1DE: P1.J14(IO_B7_J14/DIFFIO_T26P/DQ4T) RB278.2
FPGA_SN65C_2DE: P1.C13(IO_B7_C13/DIFFIO_T29P) R855.2
FPGA_SPI_D0: CONN57.9 R1454.2 U80.15(SI/SIO0)
FPGA_SPI_D1: CONN57.7 R1455.2 U80.8(SO/SIO1)
FPGA_SPI_DQ3: RB1288.1 U80.1(SIO3)
FPGA_SPI_RST_N: RB1289.1 U9.C5(IO_2_C5) U80.3(RESET#)
FPGA_SPI_WP_N_DQ2: RB1290.2 U80.9(SIO2)
FPGA_STACKING_SYNC0_DATA: P1.J19(IO_B6_J19/DIFFIO_R23P/DQ0R) R1487.1
FPGA_STACKING_SYNC0_DIR: P1.J20(IO_B6_J20/DIFFIO_R23N/DQ0R) R1489.1 U88.2(R\E\) U88.3(DE)
FPGA_STACKING_SYNC1_DATA: P1.K13(IO_B6_K13/DIFFIO_R4P) R1484.1
FPGA_STACKING_SYNC1_DIR: P1.K14(IO_B6_K14/DIFFIO_R4N) R1486.1 U87.2(R\E\) U87.3(DE)
FPGA_STACKING_SYNC2_DATA: P1.K19(IO_B6_K19/DIFFIO_R20P/DQ0R) R1481.1
FPGA_STACKING_SYNC2_DIR: P1.K20(IO_B6_K20/DIFFIO_R20N) R1483.1 U86.2(R\E\) U86.3(DE)
FPGA_STACKING_SYNC3_DATA: P1.L19(IO_B6_L19/DIFFIO_R25P/DQ0R) R1478.1
FPGA_STACKING_SYNC3_DIR: P1.L20(IO_B6_L20/DIFFIO_R25N/DM0R) R1480.1 U85.2(R\E\) U85.3(DE)
FPGA_UART1_TX: P1.C2(IO_B8_C2/DIFFIO_T11P) R717.2 RB319.2
FPGA_VCCA_2V5: CB1139.1 CB1140.1 CB1141.1 CB1142.1 CB1143.1 CB1144.1 CB1145.1 LB105.2 P1.F4(VCCA_F4) P1.F19(VCCA_F19) P1.L4(VCCA_L4) P1.T5(VCCA_T5) P1.U19(VCCA_U19) P1.V4(VCCA_V4)
FT2232H_RESET_N: P1.P10(IO_B3_P10/DIFFIO_B4P) R1491.1 U71.14(RESET_N)
GPS_TIME_PLUSE2: CONN44.7 P1.T22(IO_B5_T22/DIFFIO_R38N)
GPS_UART_R: CONN44.5 R714.1 R717.1 R726.1
GPS_UART_RX: R319.2 R729.1
GPS_UART_RX_R: P1.G22(IO_B6_G22/DIFFIO_R16P) R319.1
GPS_UART_T: CONN44.3 R729.2
HDD_LED_N: D10.C1 J3.10(DAS/DSS_N) R1293.1
HEATER_VCC12: C25.2 CONN6.1 CONN56.1 CONN56.2 CONN56.3 CONN56.4 CONN56.5 CONN56.6 CONN56.7 CONN56.8 CONN56.9 CONN56.10 L22.2 R7.1
HEATER_VCC12_MON: C22.1 R7.2 R19.1 U7.1(MON1)
HSDAC_N: TP50.1 U52.M6(HSDAC-)
HSDAC_P: TP49.1 U52.M5(HSDAC+)
HW_RESET: C280.1 D1.A R25.1 R539.2 SW1.1 SW1.2
I2C_0_SCL: J2.B33(I2C_CK) RB1231.2 U10.22(SCL)
I2C_0_SCL_CPLD1: P1.K12(IO_B7_K12/DIFFIO_T25P) R263.1
I2C_0_SCL_CPLD2: R230.1 U9.M13(IO_3_M13/DIFFIO_R24P)
I2C_0_SCL_SWITCH_CPLD1_R: R262.2 R263.2 U10.16(SC5)
I2C_0_SCL_SWITCH_CPLD2_R: R229.2 R230.2 U10.18(SC6)
I2C_0_SDA: J2.B34(I2C_DAT) R180.2 RB1232.2
I2C_0_SDA_CPLD1: R162.2 R281.1
I2C_0_SDA_CPLD1_R: P1.A4(IO_B8_A4/DIFFIO_T17N/DQ5T) R162.1
I2C_0_SDA_CPLD2: R248.1 R363.1
I2C_0_SDA_CPLD2_R: R363.2 U9.N10(IO_4_N10/DEV_CLRN/DIFFIO_B16N)
I2C_0_SDA_R: R180.1 U10.23(SDA)
I2C_0_SDA_SWITCH_CPLD1_R: R280.2 R281.2 U10.15(SD5)
I2C_0_SDA_SWITCH_CPLD2_R: R247.2 R248.2 U10.17(SD6)
I2C_1_SCL: J2.B13(SMB_CK) RB1230.2 UB17.22(SCL)
I2C_1_SDA: J2.B14(SMB_DAT) RB721.2 RB1229.2
I2C_1_SDA_R: RB721.1 UB17.23(SDA)
I2C_CPU0_RESET_N: P1.B7(IO_B8_B7/DIFFIO_T19P/DQ5T) U10.3(R\E\S\E\T\)
I2C_CPU1_RESET_N: P1.AB14(IO_B4_AB14/DIFFIO_B22P/DQ4B) UB17.3(R\E\S\E\T\)
I2C_USBHUB_SDA_R: R391.1 U24.22(SDA/SMBDATA/NON_REM1)
ID_BUTTON: P1.E22(IO_B6_E22/DIFFIO_R15N) SWB2.2
ID_BUTTON_R: RB744.1 SWB2.1
INT_BITS_L: P1.G15(IO_B7_G15/DIFFIO_T27P/DQS2T/CQ3) R1122.1
INT_BITS_L_R: R182.1 R1081.1 R1122.2 U68.59(I\N\T\)
INT_MGMT_PHY_N: P1.B1(IO_B8_B1/DIFFIO_T13P/DQ5T) RB761.2
IO_VDDP_1P8: C269.1 CB489.1 CB529.1 L12.1 R479.2 U40.AB29(IO_VDDP_1P8#1) U40.AE28(IO_VDDP_1P8#2)
IP_LED_CLK0: R679.2 U9.K16(IO_3_K16/DIFFIO_R18N)
IP_LED_DATA0: R661.1 U9.E10(IO_2_E10)
JTAG_BUFFER_OE_N: R337.1 U20.1(1O\\\E) U20.19(2O\\\E)
JTAG_CPLD2_TCK: R289.1 R302.1 U9.R4(TCK)
JTAG_CPLD2_TDI: R258.1 R275.2 U9.M7(TDI)
JTAG_CPLD2_TDO_R: R318.1 RB123.2 U9.N6(TDO)
JTAG_CPLD2_TMS: R311.1 RB109.2 U9.P5(TMS)
JTAG_TCK: R351.1 R633.2 U20.2(1A1) U20.4(1A2) U20.6(1A3) U20.8(1A4)
JTAG_TDI: R370.1 R555.2 R1344.1
JTAG_TDO: R379.1 R609.2 U22.7(2Y)
JTAG_TMS: R383.1 R586.2 U20.11(2A1) U20.13(2A2) U20.15(2A3) U20.17(2A4)
L1_RCVRD_CLK: R486.1 R487.2 U5.2(B)
L1_RCVRD_CLK_BKUP: R482.1 R483.2 UB2.2(B)
L1_RCVRD_CLK_BKUP_G: RB44.2 U77.7(REF3P)
L1_RCVRD_CLK_BKUP_GR: RB44.1 UB2.4(Y)
L1_RCVRD_CLK_BKUP_R: R483.1 U40.AN36(SRD_REFCLK_OUT_2)
L1_RCVRD_CLK_BKUP_VDD: CB27.2 CB29.1 LB5.2 LB6.2 UB2.5(VCC)
L1_RCVRD_CLK_G: R94.2 U77.9(REF4P)
L1_RCVRD_CLK_GR: R94.1 U5.4(Y)
L1_RCVRD_CLK_R: R487.1 U40.AM36(SRD_REFCLK_OUT_0)
L1_RCVRD_CLK_VALID: R510.1 R511.2 U5.1(A)
L1_RCVRD_CLK_VALID_BKUP: R502.1 R503.2 UB2.1(A)
L1_RCVRD_CLK_VALID_BKUP_R: R503.1 U40.AL36(SRD_REFCLK_OUT_3)
L1_RCVRD_CLK_VALID_R: R511.1 U40.AK36(SRD_REFCLK_OUT_1)
L1_RCVRD_CLK_VDD: C55.2 C56.1 L1.2 L2.2 U5.5(VCC)
LED_DUPLEX: R1044.1 R1053.1 U52.E8(LED_DUPLEX)
LED_LINK10: R1054.1 U52.C8(LED_LINK10)
LED_LINK100: R1056.1 U52.B8(LED_LINK100)
LED_LINK1000: R986.2 R1037.1 R1040.1 U52.A9(LED_LINK1000)
LED_RX: R1041.1 R1050.1 U52.C9(LED_RX)
LED_TX: R985.2 R1036.1 R1039.1 R1052.1 U52.D9(LED_TX)
LGND_VCC5P0: C356.2 R642.2 R688.1
LM75_A0_CH2: R457.1 R460.2 U27.7(A0)
LM75_A0_CH3: R495.2 R506.1 U29.7(A0)
LM75_A0_CH4: R405.2 R431.1 U18.7(A0)
LM75_A1_CH2: R464.2 R470.1 U27.6(A1)
LM75_A1_CH3: R514.2 R524.1 U29.6(A1)
LM75_A1_CH4: R404.2 R430.1 U18.6(A1)
LM75_A2_CH2: R472.2 R480.1 U27.5(A2)
LM75_A2_CH3: R541.2 R549.1 U29.5(A2)
LM75_A2_CH4: R403.2 R429.1 U18.5(A2)
LM75BD1_INT: CONN19.1 P1.R14(IO_B4_R14/DIFFIO_B24P) R471.1 R478.2
LM75BD1_INT_R: R471.2 U27.3(OS)
LM75BD1_SCLK: P1.T15(IO_B4_T15/DIFFIO_B32N) R452.1 R458.2
LM75BD1_SCLK_C: C249.1 R462.2
LM75BD1_SCLK_R: R458.1 R462.1 U27.2(SCLK)
LM75BD1_SDA: P1.U15(IO_B4_U15/DIFFIO_B26N/DQ2B) R450.1 R451.2
LM75BD1_SDA_R: R451.1 U27.1(SDA)
LM75BD2_INT: CONN18.1 P1.W12(IO_B3_W12/DIFFIO_B17P/DQ5B) R523.1 R540.2
LM75BD2_INT_R: R523.2 U29.3(OS)
LM75BD2_SCLK: P1.T14(IO_B4_T14/DIFFIO_B24N) R493.1 R494.2
LM75BD2_SCLK_C: C286.1 R505.2
LM75BD2_SCLK_R: R494.1 R505.1 U29.2(SCLK)
LM75BD2_SDA: P1.U14(IO_B4_U14/DIFFIO_B26P) R484.1 R485.2
LM75BD2_SDA_R: R485.1 U29.1(SDA)
LM75BD3_INT: CONN9.1 P1.G17(IO_B6_G17/DIFFIO_R2N/DQ2R) R257.2 R282.1
LM75BD3_INT_R: R282.2 U18.3(OS)
LM75BD3_SCLK: P1.Y18(IO_B4_Y18/DIFFIO_B31P/DQ2B) R283.2 RB106.1
LM75BD3_SCLK_C: C140.1 R284.2
LM75BD3_SCLK_R: R283.1 R284.1 U18.2(SCLK)
LM75BD3_SDA: P1.Y17(IO_B4_Y17/DIFFIO_B30N) R285.2 RB114.1
LM75BD3_SDA_R: R285.1 U18.1(SDA)
LOC_B: P1.W14(IO_B4_W14/DIFFIO_B23P/DQ4B) RB735.2
LOC_B_R: CB981.2 LEDB11.C RB735.1
M_MCT1: R1297.2 U70.24(MCT1)
M_MCT2: R1298.2 U70.21(MCT2)
M_MCT3: R1299.2 U70.18(MCT3)
M_MCT4: R1300.2 U70.15(MCT4)
MAC_1PPS_IN_1: P1.G20(IO_B6_G20/DIFFIO_R18P/DQ0R) R366.2
MAC_1PPS_IN_2: P1.A8(IO_B8_A8/DIFFIO_T19N/DQS5T/CQ5T) R78.2
MAC_1PPS_IN_3: P1.B18(IO_B7_B18) R211.2
MAC_1PPS_IN_4: P1.L15(IO_B5_L15/DIFFIO_R34N/DQ1R) R61.2
MAC_25M_OUT: C227.2 R438.2 U40.AG36(CLOCK25)
MAC_25M_OUT_R: OSC5.3(OUT) R434.1 R438.1
MAC_CPLD_INT_L: P1.N22(IO_B5_N22/DIFFIO_R29N/DQ1R) R526.1 U40.AH36(INT_N)
MAC_CPU_I2C_SCL: R650.2 R651.2 R656.2 U40.AC32(I2C_SCL)
MAC_CPU_I2C_SDA: R654.2 R657.2 R668.2 U40.AB31(I2C_SDA)
MAC_HS1: C224.2 HS1.1
MAC_HS2: HS1.2 L10.1
MAC_HS3: C483.2 HS1.3
MAC_HS4: HS1.4 L54.1
MAC_INT_L: J2.A63(GPI1) P1.B4(IO_B8_B4/DIFFIO_T15P)
MAC_JTAG_TCE: R527.2 U40.AJ33(JTAG_TCE)
MAC_JTAG_TCK: R517.2 U40.AH32(JTAG_TCK)
MAC_JTAG_TDO: R583.2 U40.AG33(JTAG_TDO)
MAC_NIF_156.25M_N: C432.2 U40.M23(NIF_LCPLL_REFCLK_N)
MAC_NIF_156.25M_P: C436.2 U40.M22(NIF_LCPLL_REFCLK_P)
MAC_NIFE0_156.25M_N: C417.2 U40.U26(NIFE_LCPLL0_REFCLK_N)
MAC_NIFE0_156.25M_P: C424.2 U40.U25(NIFE_LCPLL0_REFCLK_P)
MAC_NIFE1_156.25M_N: CB575.2 U40.U12(NIFE_LCPLL1_REFCLK_N)
MAC_NIFE1_156.25M_P: CB564.2 U40.U13(NIFE_LCPLL1_REFCLK_P)
MAC_PCIE_100M_MAC_N: C382.2 R692.1 R693.2 R694.1 U40.V36(PCIE_REFCLK_N)
MAC_PCIE_100M_MAC_P: C377.2 R690.2 R691.1 R692.2 U40.V37(PCIE_REFCLK_P)
MAC_PCIE_100M_N: C382.1 R1426.1
MAC_PCIE_100M_P: C377.1 R1427.1
MAC_RESET_N: P1.G16(IO_B6_G16/DIFFIO_R2P/DQS4R/CQ5R) R594.1 U40.AG31(SYS_RST_N)
MAC_TCE: R527.1 R542.2 R543.1 R550.1
MAC_TCK: R406.1 R517.1
MAC_TCK_R: R406.2 U20.14(1Y3)
MAC_TDO: R395.1 R583.1 U22.1(2A)
MAC_TMS: R387.1 U40.AJ32(JTAG_TMS)
MAC_TMS_R: R387.2 U20.5(2Y3)
MAC_TRST: R543.2 R551.2 U40.AH34(JTAG_TRST_N)
MAC_UART0_RX: R242.1 R685.1 U40.AC33(UART0_RX)
MAC_UART0_RX_R: P1.A16(IO_B7_A16/DIFFIO_T34N/DQ2T) R242.2
MAC_UART0_TX_FPGA: R373.2 R618.1
MAC_UART0_TX_FPGA_R: P1.Y7(IO_B3_Y7/DIFFIO_B8N/DQ3B) R373.1
MAC_UART0_TX_R: R618.2 R629.1 U40.AD32(UART0_TX)
MAC_UART1_RX: R593.1 R1184.1 U40.AD31(UART1_RX)
MAC_UART1_RX_R: P1.A15(IO_B7_A15/DIFFIO_T32N/DQ2T) R1184.2
MAC_UART1_TX: R640.1 R1182.2 U40.AB33(UART1_TX)
MAC_UART1_TX_FPGA: R1182.1 R1183.1
MAC_UART1_TX_R: P1.A14(IO_B7_A14/DIFFIO_T30P) R1183.2
MANG_1P2: CB30.2 CB1000.2 CONN6.10 LB89.1
MANG_1P2_DVDD: CB999.2 CB1001.1 CB1002.1 CB1003.1 CB1004.1 CB1005.1 CB1006.1 CB1007.1 CB1008.1 CB1018.1 CB1033.1 LB89.2 U52.C6(DVDD#1) U52.C7(DVDD#2) U52.D7(DVDD#3) U52.E3(DVDD#4) U52.E7(DVDD#5) U52.F3(DVDD#6) U52.J3(DVDD#7) U52.J7(DVDD#8)
MANG_1P2_PG: CONN5.5 R119.2
MANG_1P2_PG_R: R119.1 U7.31(PWM1/GPI1)
MANG_2P5: C774.2 C777.1 C778.1 C894.1 C895.2 C896.2 CB898.2 CB1012.2 CB1021.2 CB1027.2 CONN52.1 LB57.1 LB90.1 LB91.1 LB92.1 R1064.1 R1068.2 U66.1(OUT) U76.1(TCT1) U76.4(TCT2) U76.7(TCT3) U76.10(TCT4)
MANG_2P5_AVDD: CB892.2 CB994.1 CB995.1 CB996.1 CB997.1 CB998.1 CB1010.1 CB1017.1 CB1034.1 LB57.2 U52.B7(AVDD#1) U52.M3(AVDD#2) U52.M4(AVDD#3) U52.M7(AVDD#4) U52.M8(AVDD#5) U52.N5(AVDD#6)
MANG_2P5_EN: C775.1 R1065.1 R1066.2 R1067.1 U66.5(EN)
MANG_2P5_FB: C774.1 R1068.1 R1069.2 U66.3(NR/FB)
MANG_2P5_IN: C773.2 L94.2 R1067.2 U66.8(IN)
MANG_2P5_MON: C99.1 R1063.1 R1064.2 U7.54(MON16)
MANG_2P5_VDDO: CB1019.2 CB1020.1 CB1022.1 CB1023.1 CB1024.1 CB1032.1 LB91.2 R1038.1 R1055.1 U52.B4(VDDO#1) U52.C2(VDDO#2) U52.K1(VDDO#3)
MANG_2P5_VDDOH: CB1011.2 CB1013.1 CB1014.1 CB1015.1 CB1016.1 CB1031.1 LB90.2 U52.B9(VDDOH#1) U52.F7(VDDOH#2) U52.J8(VDDOH#3)
MANG_2P5_VDDOX: CB1025.2 CB1026.1 CB1028.1 CB1029.1 CB1030.1 LB92.2 U52.K9(VDDOX#1) U52.L2(VDDOX#2)
MANU_RST: J2.B49(SYS_RESET#) P1.C3(IO_B8_C3/DIFFIO_T9N) RB1234.1 RB1235.1
MASTER_I2C_SCL: P1.T20(IO_B5_T20/DIFFIO_R41N/DQ3R) R120.1
MB1_PWR_EN: CONN5.7 P1.D6(IO_B8_D6/DIFFIO_T4N/DQ3T)
MCLKIN_N: C914.2 R1414.1 R1415.2 U77.76(MCLKIN_N)
MCT1: R1331.2 U76.24(MCT1)
MCT2: R1332.2 U76.21(MCT2)
MCT3: R1333.2 U76.18(MCT3)
MCT4: R1334.2 U76.15(MCT4)
MDI-0: C785.1 R1077.1 R1078.1
MDI-1: C783.1 R1075.1 R1076.1
MDI-2: C781.1 R1073.1 R1074.1
MDI-3: C779.1 R1071.1 R1072.1
MGMT_ACT_LED: R1057.2 U9.M16(IO_3_M16)
MGMT_CLK_IN: R1060.1 U37.7(Y2)
MGMT_CLK_IN_R: R1059.2 R1060.2 U52.H9(XTAL1)
MGMT_LINK_LED: R1058.2 U9.D15(IO_3_D15/DIFFIO_R1P)
MGMT_MDI_N0: J2.A12(GBE0_MDI0-) R957.2
MGMT_MDI_N0_GE: RJ1.E2 U70.22(MX1-)
MGMT_MDI_N0_R: C711.2 R957.1 U55.2(IN2) U55.9(OUT2) U62.2(LINE 2 IN) U70.3(TD1-)
MGMT_MDI_N1: J2.A9(GBE0_MDI1-) R960.2
MGMT_MDI_N1_GE: RJ1.E6 U70.19(MX2-)
MGMT_MDI_N1_R: C714.2 R960.1 U55.5(IN4) U55.6(OUT4) U62.7(LINE 7 IN) U70.6(TD2-)
MGMT_MDI_N2: J2.A6(GBE0_MDI2-) R962.2
MGMT_MDI_N2_GE: RJ1.E5 U70.16(MX3-)
MGMT_MDI_N2_R: C716.1 R962.1 U56.2(IN2) U56.9(OUT2) U62.5(LINE 5 IN) U70.9(TD3-)
MGMT_MDI_N3: J2.A2(GBE0_MDI3-) R963.2
MGMT_MDI_N3_GE: RJ1.E8 U70.13(MX4-)
MGMT_MDI_N3_R: C717.1 R963.1 U56.5(IN4) U56.6(OUT4) U62.3(LINE 3 IN) U70.12(TD4-)
MGMT_MDI_P0: J2.A13(GBE0_MDI0+) R958.2
MGMT_MDI_P0_GE: RJ1.E1 U70.23(MX1+)
MGMT_MDI_P0_R: C712.2 R958.1 U55.1(IN1) U55.10(OUT1) U62.1(LINE 1 IN) U70.2(TD1+)
MGMT_MDI_P1: J2.A10(GBE0_MDI1+) R959.2
MGMT_MDI_P1_GE: RJ1.E3 U70.20(MX2+)
MGMT_MDI_P1_R: C713.2 R959.1 U55.4(IN3) U55.7(OUT3) U62.8(LINE 8 IN) U70.5(TD2+)
MGMT_MDI_P2: J2.A7(GBE0_MDI2+) R961.2
MGMT_MDI_P2_GE: RJ1.E4 U70.17(MX3+)
MGMT_MDI_P2_R: C715.1 R961.1 U56.1(IN1) U56.10(OUT1) U62.6(LINE 6 IN) U70.8(TD3+)
MGMT_MDI_P3: J2.A3(GBE0_MDI3+) R964.2
MGMT_MDI_P3_GE: RJ1.E7 U70.14(MX4+)
MGMT_MDI_P3_R: C718.1 R964.1 U56.4(IN3) U56.7(OUT3) U62.4(LINE 4 IN) U70.11(TD4+)
MGMT_PHY_ACT_D_LED: LEDB6.A R1007.2
MGMT_PHY_ACT_LED: LEDB6.C R985.1 R1057.1
MGMT_PHY_LINK_D_LED: LEDB5.A R1005.2
MGMT_PHY_LINK_LED: LEDB5.C R986.1 R1058.1
MGMT_PHY_MDI_N0: R1077.2 R1329.2 U52.N2(MDI[0]-)
MGMT_PHY_MDI_N0_R: C892.2 R1329.1 U73.2(IN2) U73.9(OUT2) U74.2(LINE 2 IN) U76.3(TD1-)
MGMT_PHY_MDI_N1: R1075.2 R1327.2 U52.N4(MDI[1]-)
MGMT_PHY_MDI_N1_R: C890.2 R1327.1 U73.5(IN4) U73.6(OUT4) U74.7(LINE 7 IN) U76.6(TD2-)
MGMT_PHY_MDI_N2: R1073.2 R1326.2 U52.N7(MDI[2]-)
MGMT_PHY_MDI_N2_R: C888.1 R1326.1 U74.5(LINE 5 IN) U75.2(IN2) U75.9(OUT2) U76.9(TD3-)
MGMT_PHY_MDI_N3: R1071.2 R1324.2 U52.N9(MDI[3]-)
MGMT_PHY_MDI_N3_R: C886.1 R1324.1 U74.3(LINE 3 IN) U75.5(IN4) U75.6(OUT4) U76.12(TD4-)
MGMT_PHY_MDI_P0: R1078.2 R1330.2 U52.N1(MDI[0]+)
MGMT_PHY_MDI_P0_R: C893.2 R1330.1 U73.1(IN1) U73.10(OUT1) U74.1(LINE 1 IN) U76.2(TD1+)
MGMT_PHY_MDI_P1: R1076.2 R1328.2 U52.N3(MDI[1]+)
MGMT_PHY_MDI_P1_R: C891.2 R1328.1 U73.4(IN3) U73.7(OUT3) U74.8(LINE 8 IN) U76.5(TD2+)
MGMT_PHY_MDI_P2: R1074.2 R1325.2 U52.N6(MDI[2]+)
MGMT_PHY_MDI_P2_R: C887.1 R1325.1 U74.6(LINE 6 IN) U75.1(IN1) U75.10(OUT1) U76.8(TD3+)
MGMT_PHY_MDI_P3: R1072.2 R1323.2 U52.N8(MDI[3]+)
MGMT_PHY_MDI_P3_R: C885.1 R1323.1 U74.4(LINE 4 IN) U75.4(IN3) U75.7(OUT3) U76.11(TD4+)
MINI_OSC5_OE: OSC2.1(TRI-STATE) R210.2
MOD_ABS01: CONN54_PF.1T6(MOD_ABS#1T6) RB563.1 U9.C6(IO_2_C6/DIFFIO_T4N)
MOD_ABS02: CONN54_PF.1L6(MOD_ABS#1L6) RB562.1 U9.C7(IO_2_C7/DIFFIO_T7N)
MOD_ABS03: CONN54_PF.2T6(MOD_ABS#2T6) RB566.1 U9.F3(IO_1_F3/DIFFIO_L5P)
MOD_ABS04: CONN54_PF.2L6(MOD_ABS#2L6) RB565.1 U9.E5(IO_1_E5/DIFFIO_L6N)
MOD_ABS05: CONN54_PF.3T6(MOD_ABS#3T6) RB542.1 U9.G6(IO_1_G6/DIFFIO_L12P)
MOD_ABS06: CONN54_PF.3L6(MOD_ABS#3L6) RB541.1 U9.J4(IO_1_J4/DIFFIO_L16P)
MOD_ABS07: CONN54_PF.4T6(MOD_ABS#4T6) RB545.1 U9.M1(IO_1_M1/DIFFIO_L20N)
MOD_ABS08: CONN54_PF.4L6(MOD_ABS#4L6) RB544.1 U9.G7(IO_1_G7)
MOD_ABS09: CONN54_PF.5T6(MOD_ABS#5T6) RB548.1 U9.U1(IO_4_U1/DIFFIO_B1P)
MOD_ABS10: CONN54_PF.5L6(MOD_ABS#5L6) RB547.1 U9.E8(IO_2_E8)
MOD_ABS11: CONN54_PF.6T6(MOD_ABS#6T6) RB551.1 U9.U7(IO_4_U7/DIFFIO_B10P)
MOD_ABS12: CONN54_PF.6L6(MOD_ABS#6L6) RB550.1 U9.N5(IO_1_N5/DIFFIO_L25P)
MOD_ABS13: CONN55_PF.1T6(MOD_ABS#1T6) RB569.1 U9.R7(IO_4_R7/DIFFIO_B7P)
MOD_ABS14: CONN55_PF.1L6(MOD_ABS#1L6) RB568.1 U9.T8(IO_4_T8/DIFFIO_B11P)
MOD_ABS15: CONN55_PF.2T6(MOD_ABS#2T6) RB572.1 U9.R14(IO_4_R14)
MOD_ABS16: CONN55_PF.2L6(MOD_ABS#2L6) RB571.1 U9.T12(IO_4_T12/DIFFIO_B25P)
MOD_ABS17: CONN55_PF.3T6(MOD_ABS#3T6) RB575.1 U9.P16(IO_3_P16/DIFFIO_R28P)
MOD_ABS18: CONN55_PF.3L6(MOD_ABS#3L6) RB574.1 U9.N15(IO_3_N15/DIFFIO_R28N)
MOD_ABS19: CONN55_PF.4T6(MOD_ABS#4T6) RB554.1 U9.H14(IO_3_H14/DIFFIO_R12P)
MOD_ABS20: CONN55_PF.4L6(MOD_ABS#4L6) RB553.1 U9.K15(IO_3_K15)
MOD_ABS21: CONN55_PF.5T6(MOD_ABS#5T6) RB557.1 U9.F16(IO_3_F16/DIFFIO_R8N)
MOD_ABS22: CONN55_PF.5L6(MOD_ABS#5L6) RB556.1 U9.H18(IO_3_H18/DIFFIO_R14N)
MOD_ABS23: CONN55_PF.6T6(MOD_ABS#6T6) RB560.1 U9.C14(IO_2_C14/DIFFIO_T21N)
MOD_ABS24: CONN55_PF.6L6(MOD_ABS#6L6) RB559.1 U9.D17(IO_3_D17)
MPHY_CPU_SGMII_RX_0_S_N: J2.C27(DDI1_PAIR4-) U52.A8(S_OUT-)
MPHY_CPU_SGMII_RX_0_S_P: J2.C26(DDI1_PAIR4+) U52.A7(S_OUT+)
MPHY_INT_N: RB759.1 RB760.1 RB761.1 U52.L1(INT#)
NIF_156.25M_N: C432.1 R1379.1
NIF_156.25M_P: C436.1 R1378.1
NIF_LCPLL_AVDD1P8: C475.1 CB641.2 CB642.1 CB661.1 CB662.1 L52.1 U40.N23(NIF_LCPLL_AVDD1P8)
NIF_N_RX00: CONN53_PF.1T24(RX4_N_1T) U40.F12(NIF_RX_00_P)
NIF_N_RX01: CONN53_PF.1T15(RX3_N_1T) U40.K11(NIF_RX_01_N)
NIF_N_RX02: CONN53_PF.1T21(RX2_N_1T) U40.G10(NIF_RX_02_N)
NIF_N_RX03: CONN53_PF.1T18(RX1_N_1T) U40.K9(NIF_RX_03_N)
NIF_N_RX04: CONN53_PF.1B24(RX4_N_1B) U40.F16(NIF_RX_04_P)
NIF_N_RX05: CONN53_PF.1B21(RX2_N_1B) U40.K15(NIF_RX_05_N)
NIF_N_RX06: CONN53_PF.1B15(RX3_N_1B) U40.G14(NIF_RX_06_N)
NIF_N_RX07: CONN53_PF.1B18(RX1_N_1B) U40.K13(NIF_RX_07_N)
NIF_N_TX00: CONN53_PF.1T5(TX4_N_1T) U40.B12(NIF_TX_00_P)
NIF_N_TX01: CONN53_PF.1T34(TX3_N_1T) U40.C11(NIF_TX_01_N)
NIF_N_TX02: CONN53_PF.1T2(TX2_N_1T) U40.A10(NIF_TX_02_N)
NIF_N_TX03: CONN53_PF.1T37(TX1_N_1T) U40.C9(NIF_TX_03_N)
NIF_N_TX04: CONN53_PF.1B5(TX4_N_1B) U40.A16(NIF_TX_04_N)
NIF_N_TX05: CONN53_PF.1B2(TX2_N_1B) U40.C15(NIF_TX_05_N)
NIF_N_TX06: CONN53_PF.1B34(TX3_N_1B) U40.A14(NIF_TX_06_N)
NIF_N_TX07: CONN53_PF.1B37(TX1_N_1B) U40.C13(NIF_TX_07_N)
NIF_P_RX00: CONN53_PF.1T25(RX4_P_1T) U40.G12(NIF_RX_00_N)
NIF_P_RX01: CONN53_PF.1T14(RX3_P_1T) U40.J11(NIF_RX_01_P)
NIF_P_RX02: CONN53_PF.1T22(RX2_P_1T) U40.F10(NIF_RX_02_P)
NIF_P_RX03: CONN53_PF.1T17(RX1_P_1T) U40.J9(NIF_RX_03_P)
NIF_P_RX04: CONN53_PF.1B25(RX4_P_1B) U40.G16(NIF_RX_04_N)
NIF_P_RX05: CONN53_PF.1B22(RX2_P_1B) U40.J15(NIF_RX_05_P)
NIF_P_RX06: CONN53_PF.1B14(RX3_P_1B) U40.F14(NIF_RX_06_P)
NIF_P_RX07: CONN53_PF.1B17(RX1_P_1B) U40.J13(NIF_RX_07_P)
NIF_P_TX00: CONN53_PF.1T6(TX4_P_1T) U40.A12(NIF_TX_00_N)
NIF_P_TX01: CONN53_PF.1T33(TX3_P_1T) U40.D11(NIF_TX_01_P)
NIF_P_TX02: CONN53_PF.1T3(TX2_P_1T) U40.B10(NIF_TX_02_P)
NIF_P_TX03: CONN53_PF.1T36(TX1_P_1T) U40.D9(NIF_TX_03_P)
NIF_P_TX04: CONN53_PF.1B6(TX4_P_1B) U40.B16(NIF_TX_04_P)
NIF_P_TX05: CONN53_PF.1B3(TX2_P_1B) U40.D15(NIF_TX_05_P)
NIF_P_TX06: CONN53_PF.1B33(TX3_P_1B) U40.B14(NIF_TX_06_P)
NIF_P_TX07: CONN53_PF.1B36(TX1_P_1B) U40.D13(NIF_TX_07_P)
NIF_PVDD10: C496.A C502.2 CB646.2 CB655.2 CB656.2 CB657.2 CB658.2 LB24.2 U40.M17(NIF_PVDD1P0_Q00) U40.M18(NIF_PVDD1P0_Q01) U40.M19(NIF_PVDD1P0_Q02) U40.M20(NIF_PVDD1P0_Q03)
NIF_RX[08]_N: CONN54_PF.2T12(RD-#2T12) U40.K17(NIF_RX_08_N)
NIF_RX[08]_P: CONN54_PF.2T13(RD+#2T13) U40.J17(NIF_RX_08_P)
NIF_RX[09]_N: CONN54_PF.2L12(RD-#2L12) U40.F18(NIF_RX_09_P)
NIF_RX[09]_P: CONN54_PF.2L13(RD+#2L13) U40.G18(NIF_RX_09_N)
NIF_RX[10]_N: CONN54_PF.1T12(RD-#1T12) U40.J19(NIF_RX_10_P)
NIF_RX[10]_P: CONN54_PF.1T13(RD+#1T13) U40.K19(NIF_RX_10_N)
NIF_RX[11]_N: CONN54_PF.1L12(RD-#1L12) U40.F20(NIF_RX_11_P)
NIF_RX[11]_P: CONN54_PF.1L13(RD+#1L13) U40.G20(NIF_RX_11_N)
NIF_RX[12]_N: U40.K21(NIF_RX_12_N) U69.18(RX1_N)
NIF_RX[12]_P: U40.J21(NIF_RX_12_P) U69.17(RX1_P)
NIF_RX[13]_N: U40.G22(NIF_RX_13_N) U69.15(RX3_N)
NIF_RX[13]_P: U40.F22(NIF_RX_13_P) U69.14(RX3_P)
NIF_RX[14]_N: U40.K23(NIF_RX_14_N) U69.21(RX2_N)
NIF_RX[14]_P: U40.J23(NIF_RX_14_P) U69.22(RX2_P)
NIF_RX[15]_N: U40.G24(NIF_RX_15_N) U69.24(RX4_N)
NIF_RX[15]_P: U40.F24(NIF_RX_15_P) U69.25(RX4_P)
NIF_TRVDD10: C497.A C503.2 C504.2 CB675.2 CB676.2 CB677.2 CB678.2 CB679.2 CB688.2 CB689.2 CB690.2 CB691.2 CB692.2 CB695.2 CB701.2 CB702.2 CB703.2 CB714.2 CB724.2 CB725.2 CB726.2 CB745.2 CB747.2 CB749.2 CB769.2 CB770.2 CB771.2 CB772.2 LB23.2 U40.A11(NIF_TVDD1P0_Q00_01#1) U40.A15(NIF_TVDD1P0_Q00_01#2) U40.A19(NIF_TVDD1P0_Q02_03#1) U40.A23(NIF_TVDD1P0_Q02_03#2) U40.B11(NIF_TVDD1P0_Q00_01#3) U40.B15(NIF_TVDD1P0_Q00_01#4) U40.B19(NIF_TVDD1P0_Q02_03#3) U40.B23(NIF_TVDD1P0_Q02_03#4) U40.F11(NIF_RVDD1P0_Q00_01#1) U40.F15(NIF_RVDD1P0_Q00_01#2) U40.F19(NIF_RVDD1P0_Q02_03#1) U40.F23(NIF_RVDD1P0_Q02_03#2) U40.G11(NIF_RVDD1P0_Q00_01#3) U40.G15(NIF_RVDD1P0_Q00_01#4) U40.G19(NIF_RVDD1P0_Q02_03#3) U40.G23(NIF_RVDD1P0_Q02_03#4) U40.J10(NIF_RVDD1P0_Q00_01#5) U40.J14(NIF_RVDD1P0_Q00_01#6) U40.J18(NIF_RVDD1P0_Q02_03#5) U40.J22(NIF_RVDD1P0_Q02_03#6) U40.K10(NIF_RVDD1P0_Q00_01#7) U40.K14(NIF_RVDD1P0_Q00_01#8) U40.K18(NIF_RVDD1P0_Q02_03#7) U40.K22(NIF_RVDD1P0_Q02_03#8)
NIF_TVDD1P25: C425.2 C458.A CB722.2 CB723.2 CB727.2 CB728.2 CB729.2 CB744.2 CB746.2 CB748.2 CB752.2 L51.2 U40.C10(NIF_TVDD1P25_Q00#1) U40.C14(NIF_TVDD1P25_Q01#1) U40.C18(NIF_TVDD1P25_Q02#1) U40.C22(NIF_TVDD1P25_Q03#1) U40.D10(NIF_TVDD1P25_Q00#2) U40.D14(NIF_TVDD1P25_Q01#2) U40.D18(NIF_TVDD1P25_Q02#2) U40.D22(NIF_TVDD1P25_Q03#2)
NIF_TX[08]_N: CONN54_PF.2T19(TD-#2T19) U40.C17(NIF_TX_08_N)
NIF_TX[08]_P: CONN54_PF.2T18(TD+#2T18) U40.D17(NIF_TX_08_P)
NIF_TX[09]_N: CONN54_PF.2L19(TD-#2L19) U40.B18(NIF_TX_09_P)
NIF_TX[09]_P: CONN54_PF.2L18(TD+#2L18) U40.A18(NIF_TX_09_N)
NIF_TX[10]_N: CONN54_PF.1T19(TD-#1T19) U40.C19(NIF_TX_10_N)
NIF_TX[10]_P: CONN54_PF.1T18(TD+#1T18) U40.D19(NIF_TX_10_P)
NIF_TX[11]_N: CONN54_PF.1L19(TD-#1L19) U40.B20(NIF_TX_11_P)
NIF_TX[11]_P: CONN54_PF.1L18(TD+#1L18) U40.A20(NIF_TX_11_N)
NIF_TX[12]_N: U40.D21(NIF_TX_12_P) U69.37(TX1_N)
NIF_TX[12]_P: U40.C21(NIF_TX_12_N) U69.36(TX1_P)
NIF_TX[13]_N: U40.A22(NIF_TX_13_N) U69.34(TX3_N)
NIF_TX[13]_P: U40.B22(NIF_TX_13_P) U69.33(TX3_P)
NIF_TX[14]_N: U40.D23(NIF_TX_14_P) U69.2(TX2_N)
NIF_TX[14]_P: U40.C23(NIF_TX_14_N) U69.3(TX2_P)
NIF_TX[15]_N: U40.A24(NIF_TX_15_N) U69.5(TX4_N)
NIF_TX[15]_P: U40.B24(NIF_TX_15_P) U69.6(TX4_P)
NIFE0_156.25M_N: C417.1 R1375.1
NIFE0_156.25M_P: C424.1 R1374.1
NIFE1_156.25M_N: CB575.1 R1377.1
NIFE1_156.25M_P: CB564.1 R1376.1
NIFE_LCPLL_AVDD1P8: C463.1 CB585.2 CB601.1 CB605.2 L48.1 U40.T13(NIFE_LCPLL1_AVDD1P8) U40.V25(NIFE_LCPLL0_AVDD1P8)
NIFE_PVDD10: C375.A C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C416.2 CB551.2 CB552.2 CB659.2 CB660.2 CB664.2 CB665.2 CB666.2 CB667.2 CB680.2 L44.2 U40.L27(NIFE_PVDD1P0_Q06) U40.M11(NIFE_PVDD1P0_Q10) U40.M12(NIFE_PVDD1P0_Q09) U40.M13(NIFE_PVDD1P0_Q08) U40.M25(NIFE_PVDD1P0_Q04) U40.M26(NIFE_PVDD1P0_Q05) U40.Y6(NIFE_PVDD1P0_Q11) U40.Y28(NIFE_PVDD1P0_Q07)
NIFE_RX[16]_N: CONN55_PF.2T12(RD-#2T12) U40.G26(NIFE_RX_16_N)
NIFE_RX[16]_P: CONN55_PF.2T13(RD+#2T13) U40.F26(NIFE_RX_16_P)
NIFE_RX[17]_N: CONN55_PF.2L12(RD-#2L12) U40.H27(NIFE_RX_17_P)
NIFE_RX[17]_P: CONN55_PF.2L13(RD+#2L13) U40.J27(NIFE_RX_17_N)
NIFE_RX[18]_N: CONN55_PF.1T12(RD-#1T12) U40.G28(NIFE_RX_18_N)
NIFE_RX[18]_P: CONN55_PF.1T13(RD+#1T13) U40.F28(NIFE_RX_18_P)
NIFE_RX[19]_N: CONN55_PF.1L12(RD-#1L12) U40.J29(NIFE_RX_19_N)
NIFE_RX[19]_P: CONN55_PF.1L13(RD+#1L13) U40.H29(NIFE_RX_19_P)
NIFE_RX[20]_N: CONN54_PF.6T12(RD-#6T12) U40.F30(NIFE_RX_20_P)
NIFE_RX[20]_P: CONN54_PF.6T13(RD+#6T13) U40.G30(NIFE_RX_20_N)
NIFE_RX[21]_N: CONN54_PF.6L12(RD-#6L12) U40.J31(NIFE_RX_21_N)
NIFE_RX[21]_P: CONN54_PF.6L13(RD+#6L13) U40.H31(NIFE_RX_21_P)
NIFE_RX[22]_N: CONN54_PF.5T12(RD-#5T12) U40.F32(NIFE_RX_22_P)
NIFE_RX[22]_P: CONN54_PF.5T13(RD+#5T13) U40.G32(NIFE_RX_22_N)
NIFE_RX[23]_N: CONN54_PF.5L12(RD-#5L12) U40.J33(NIFE_RX_23_N)
NIFE_RX[23]_P: CONN54_PF.5L13(RD+#5L13) U40.H33(NIFE_RX_23_P)
NIFE_RX[24]_N: CONN54_PF.3L12(RD-#3L12) U40.J37(NIFE_RX_24_P)
NIFE_RX[24]_P: CONN54_PF.3L13(RD+#3L13) U40.H37(NIFE_RX_24_N)
NIFE_RX[25]_N: CONN54_PF.3T12(RD-#3T12) U40.F36(NIFE_RX_25_N)
NIFE_RX[25]_P: CONN54_PF.3T13(RD+#3T13) U40.G36(NIFE_RX_25_P)
NIFE_RX[26]_N: CONN54_PF.4L12(RD-#4L12) U40.J35(NIFE_RX_26_P)
NIFE_RX[26]_P: CONN54_PF.4L13(RD+#4L13) U40.H35(NIFE_RX_26_N)
NIFE_RX[27]_N: CONN54_PF.4T12(RD-#4T12) U40.F34(NIFE_RX_27_N)
NIFE_RX[27]_P: CONN54_PF.4T13(RD+#4T13) U40.G34(NIFE_RX_27_P)
NIFE_RX[32]_N: CONN55_PF.3L12(RD-#3L12) U40.F8(NIFE_RX_32_P)
NIFE_RX[32]_P: CONN55_PF.3L13(RD+#3L13) U40.G8(NIFE_RX_32_N)
NIFE_RX[33]_N: CONN55_PF.3T12(RD-#3T12) U40.J7(NIFE_RX_33_N)
NIFE_RX[33]_P: CONN55_PF.3T13(RD+#3T13) U40.H7(NIFE_RX_33_P)
NIFE_RX[34]_N: CONN55_PF.4L12(RD-#4L12) U40.F6(NIFE_RX_34_P)
NIFE_RX[34]_P: CONN55_PF.4L13(RD+#4L13) U40.G6(NIFE_RX_34_N)
NIFE_RX[35]_N: CONN55_PF.4T12(RD-#4T12) U40.J5(NIFE_RX_35_N)
NIFE_RX[35]_P: CONN55_PF.4T13(RD+#4T13) U40.H5(NIFE_RX_35_P)
NIFE_RX[36]_N: CONN55_PF.5L12(RD-#5L12) U40.F4(NIFE_RX_36_P)
NIFE_RX[36]_P: CONN55_PF.5L13(RD+#5L13) U40.G4(NIFE_RX_36_N)
NIFE_RX[37]_N: CONN55_PF.5T12(RD-#5T12) U40.J3(NIFE_RX_37_N)
NIFE_RX[37]_P: CONN55_PF.5T13(RD+#5T13) U40.H3(NIFE_RX_37_P)
NIFE_RX[38]_N: CONN55_PF.6L12(RD-#6L12) U40.F2(NIFE_RX_38_P)
NIFE_RX[38]_P: CONN55_PF.6L13(RD+#6L13) U40.G2(NIFE_RX_38_N)
NIFE_RX[39]_N: CONN55_PF.6T12(RD-#6T12) U40.J1(NIFE_RX_39_N)
NIFE_RX[39]_P: CONN55_PF.6T13(RD+#6T13) U40.H1(NIFE_RX_39_P)
NIFE_RX[46]_N: CB607.2 U40.V7(NIFE_RX_46_N)
NIFE_RX[46]_P: CB586.2 U40.V6(NIFE_RX_46_P)
NIFE_RX[47]_N: CB511.2 U40.W9(NIFE_RX_47_N)
NIFE_RX[47]_P: CB528.2 U40.W8(NIFE_RX_47_P)
NIFE_TRVDD10_S1: C495.A C498.2 C499.2 C500.2 C501.2 CB636.2 CB637.2 CB638.2 CB639.2 CB650.2 CB651.2 CB653.2 CB663.2 CB673.2 CB674.2 CB682.2 CB683.2 CB693.2 CB694.2 CB697.2 CB698.2 CB699.2 CB700.2 CB715.2 CB717.2 CB718.2 CB719.2 CB721.2 CB734.2 CB740.2 CB741.2 CB742.2 CB743.2 CB756.2 CB765.2 CB767.2 CB768.2 CB775.2 LB25.2 U40.A27(NIFE_TVDD1P0_Q04_05_06#1) U40.A31(NIFE_TVDD1P0_Q04_05_06#2) U40.A35(NIFE_TVDD1P0_Q04_05_06#3) U40.B27(NIFE_TVDD1P0_Q04_05_06#4) U40.B31(NIFE_TVDD1P0_Q04_05_06#5) U40.B35(NIFE_TVDD1P0_Q04_05_06#6) U40.C28(NIFE_TVDD1P0_Q04_05_06#7) U40.C32(NIFE_TVDD1P0_Q04_05_06#8) U40.C36(NIFE_TVDD1P0_Q04_05_06#9) U40.D28(NIFE_TVDD1P0_Q04_05_06#10) U40.D32(NIFE_TVDD1P0_Q04_05_06#11) U40.D36(NIFE_TVDD1P0_Q04_05_06#12) U40.F27(NIFE_RVDD1P0_Q04_05_06#1) U40.F31(NIFE_RVDD1P0_Q04_05_06#2) U40.F35(NIFE_RVDD1P0_Q04_05_06#3) U40.G27(NIFE_RVDD1P0_Q04_05_06#4) U40.G31(NIFE_RVDD1P0_Q04_05_06#5) U40.G35(NIFE_RVDD1P0_Q04_05_06#6) U40.H28(NIFE_RVDD1P0_Q04_05_06#7) U40.H32(NIFE_RVDD1P0_Q04_05_06#8) U40.H36(NIFE_RVDD1P0_Q04_05_06#9) U40.J28(NIFE_RVDD1P0_Q04_05_06#10) U40.J32(NIFE_RVDD1P0_Q04_05_06#11) U40.J36(NIFE_RVDD1P0_Q04_05_06#12) U40.N31(NIFE_RVDD1P0_Q07#1) U40.N32(NIFE_RVDD1P0_Q07#2) U40.N36(NIFE_TVDD1P0_Q07#1) U40.N37(NIFE_TVDD1P0_Q07#2) U40.P29(NIFE_RVDD1P0_Q07#3) U40.P30(NIFE_RVDD1P0_Q07#4) U40.P34(NIFE_TVDD1P0_Q07#3) U40.P35(NIFE_TVDD1P0_Q07#4)
NIFE_TRVDD10_S2: CB576.2 CB577.2 CB593.2 CB602.2 CB606.2 CB608.2 CB614.2 CB617.2 CB632.2 CB633.2 CB634.2 CB635.2 CB647.2 CB648.2 CB649.2 CB652.2 CB684.2 CB685.2 CB696.2 CB704.2 CB705.2 CB706.2 CB713.2 CB716.2 CB720.2 CB732.2 CB735.2 CB738.2 CB750.2 CB751.2 CB758.2 CB766.2 CB773.2 CB774.2 L45.2 U40.A3(NIFE_TVDD1P0_Q08_09_10#1) U40.A7(NIFE_TVDD1P0_Q08_09_10#2) U40.B3(NIFE_TVDD1P0_Q08_09_10#3) U40.B7(NIFE_TVDD1P0_Q08_09_10#4) U40.C2(NIFE_TVDD1P0_Q08_09_10#5) U40.C6(NIFE_TVDD1P0_Q08_09_10#6) U40.D2(NIFE_TVDD1P0_Q08_09_10#7) U40.D6(NIFE_TVDD1P0_Q08_09_10#8) U40.F3(NIFE_RVDD1P0_Q08_09_10#1) U40.F7(NIFE_RVDD1P0_Q08_09_10#2) U40.G3(NIFE_RVDD1P0_Q08_09_10#3) U40.G7(NIFE_RVDD1P0_Q08_09_10#4) U40.H2(NIFE_RVDD1P0_Q08_09_10#5) U40.H6(NIFE_RVDD1P0_Q08_09_10#6) U40.J2(NIFE_RVDD1P0_Q08_09_10#7) U40.J6(NIFE_RVDD1P0_Q08_09_10#8) U40.N1(NIFE_TVDD1P0_Q08_09_10#9) U40.N2(NIFE_TVDD1P0_Q08_09_10#10) U40.N6(NIFE_RVDD1P0_Q08_09_10#9) U40.N7(NIFE_RVDD1P0_Q08_09_10#10) U40.P3(NIFE_TVDD1P0_Q08_09_10#11) U40.P4(NIFE_TVDD1P0_Q08_09_10#12) U40.P8(NIFE_RVDD1P0_Q08_09_10#11) U40.P9(NIFE_RVDD1P0_Q08_09_10#12) U40.U1(NIFE_TVDD1P0_Q11#1) U40.U2(NIFE_TVDD1P0_Q11#2) U40.U6(NIFE_RVDD1P0_Q11#1) U40.U7(NIFE_RVDD1P0_Q11#2) U40.V3(NIFE_TVDD1P0_Q11#3) U40.V4(NIFE_TVDD1P0_Q11#4) U40.V8(NIFE_RVDD1P0_Q11#3) U40.V9(NIFE_RVDD1P0_Q11#4)
NIFE_TX[16]_N: CONN55_PF.2T19(TD-#2T19) U40.A26(NIFE_TX_16_N)
NIFE_TX[16]_P: CONN55_PF.2T18(TD+#2T18) U40.B26(NIFE_TX_16_P)
NIFE_TX[17]_N: CONN55_PF.2L19(TD-#2L19) U40.D27(NIFE_TX_17_P)
NIFE_TX[17]_P: CONN55_PF.2L18(TD+#2L18) U40.C27(NIFE_TX_17_N)
NIFE_TX[18]_N: CONN55_PF.1T19(TD-#1T19) U40.A28(NIFE_TX_18_N)
NIFE_TX[18]_P: CONN55_PF.1T18(TD+#1T18) U40.B28(NIFE_TX_18_P)
NIFE_TX[19]_N: CONN55_PF.1L19(TD-#1L19) U40.D29(NIFE_TX_19_P)
NIFE_TX[19]_P: CONN55_PF.1L18(TD+#1L18) U40.C29(NIFE_TX_19_N)
NIFE_TX[20]_N: CONN54_PF.6T19(TD-#6T19) U40.A30(NIFE_TX_20_N)
NIFE_TX[20]_P: CONN54_PF.6T18(TD+#6T18) U40.B30(NIFE_TX_20_P)
NIFE_TX[21]_N: CONN54_PF.6L19(TD-#6L19) U40.D31(NIFE_TX_21_P)
NIFE_TX[21]_P: CONN54_PF.6L18(TD+#6L18) U40.C31(NIFE_TX_21_N)
NIFE_TX[22]_N: CONN54_PF.5T19(TD-#5T19) U40.A32(NIFE_TX_22_N)
NIFE_TX[22]_P: CONN54_PF.5T18(TD+#5T18) U40.B32(NIFE_TX_22_P)
NIFE_TX[23]_N: CONN54_PF.5L19(TD-#5L19) U40.C33(NIFE_TX_23_N)
NIFE_TX[23]_P: CONN54_PF.5L18(TD+#5L18) U40.D33(NIFE_TX_23_P)
NIFE_TX[24]_N: CONN54_PF.3L19(TD-#3L19) U40.C37(NIFE_TX_24_P)
NIFE_TX[24]_P: CONN54_PF.3L18(TD+#3L18) U40.D37(NIFE_TX_24_N)
NIFE_TX[25]_N: CONN54_PF.3T19(TD-#3T19) U40.B36(NIFE_TX_25_N)
NIFE_TX[25]_P: CONN54_PF.3T18(TD+#3T18) U40.A36(NIFE_TX_25_P)
NIFE_TX[26]_N: CONN54_PF.4L19(TD-#4L19) U40.C35(NIFE_TX_26_P)
NIFE_TX[26]_P: CONN54_PF.4L18(TD+#4L18) U40.D35(NIFE_TX_26_N)
NIFE_TX[27]_N: CONN54_PF.4T19(TD-#4T19) U40.B34(NIFE_TX_27_N)
NIFE_TX[27]_P: CONN54_PF.4T18(TD+#4T18) U40.A34(NIFE_TX_27_P)
NIFE_TX[32]_N: CONN55_PF.3L19(TD-#3L19) U40.A8(NIFE_TX_32_N)
NIFE_TX[32]_P: CONN55_PF.3L18(TD+#3L18) U40.B8(NIFE_TX_32_P)
NIFE_TX[33]_N: CONN55_PF.3T19(TD-#3T19) U40.D7(NIFE_TX_33_P)
NIFE_TX[33]_P: CONN55_PF.3T18(TD+#3T18) U40.C7(NIFE_TX_33_N)
NIFE_TX[34]_N: CONN55_PF.4L19(TD-#4L19) U40.A6(NIFE_TX_34_N)
NIFE_TX[34]_P: CONN55_PF.4L18(TD+#4L18) U40.B6(NIFE_TX_34_P)
NIFE_TX[35]_N: CONN55_PF.4T19(TD-#4T19) U40.C5(NIFE_TX_35_N)
NIFE_TX[35]_P: CONN55_PF.4T18(TD+#4T18) U40.D5(NIFE_TX_35_P)
NIFE_TX[36]_N: CONN55_PF.5L19(TD-#5L19) U40.B4(NIFE_TX_36_P)
NIFE_TX[36]_P: CONN55_PF.5L18(TD+#5L18) U40.A4(NIFE_TX_36_N)
NIFE_TX[37]_N: CONN55_PF.5T19(TD-#5T19) U40.C3(NIFE_TX_37_N)
NIFE_TX[37]_P: CONN55_PF.5T18(TD+#5T18) U40.D3(NIFE_TX_37_P)
NIFE_TX[38]_N: CONN55_PF.6L19(TD-#6L19) U40.B2(NIFE_TX_38_P)
NIFE_TX[38]_P: CONN55_PF.6L18(TD+#6L18) U40.A2(NIFE_TX_38_N)
NIFE_TX[39]_N: CONN55_PF.6T19(TD-#6T19) U40.C1(NIFE_TX_39_N)
NIFE_TX[39]_P: CONN55_PF.6T18(TD+#6T18) U40.D1(NIFE_TX_39_P)
OCXO25MHZ: R687.1 U37.1(CLK_IN)
OCXO25MHZ_R: OCXO1.4(OUT) OCXO2.4(OUTPUT) R687.2
OCXO_VOUT: CONN26.1 R557.1
OSC_CPLD1_25M_OE: OSC1.1(\\S\T/OE) R54.1
OSC_CPLD1_25M_VDD: C37.1 C48.1 C49.1 L3.2 OSC1.4(VDD) R54.2
OSC_CPLD2_25M_OE: OSC3.1(\\S\T/OE) R222.1
OSC_CPLD2_25M_VDD: C100.1 C114.1 C121.1 L4.2 OSC3.4(VDD) R222.2
OSC_MAC_25M_OE: OSC5.1(\\S\T/OE) R415.1
OSC_MAC_25M_VDD: C176.1 C199.1 C206.1 L8.2 OSC5.4(VDD) R415.2
OSC_MAC_25MHZ: C139.1 C144.1 L8.1 R231.1 R232.1
P01_LANE0_3P3: LED1.A R863.1
P01_LANE0_LED_B: R862.2 U9.E14(IO_3_E14/DIFFIO_R3N)
P01_LANE0_LED_G: R861.2 U9.C15(IO_2_C15/DIFFIO_T24P)
P01_LANE0_LED_R: R860.2 U9.G13(IO_3_G13)
P01_LANE0_R_LED_B: C640.1 LED1.C3 R862.1
P01_LANE0_R_LED_G: C639.1 LED1.C2 R861.1
P01_LANE0_R_LED_R: C638.1 LED1.C1 R860.1
P01_LANE1_3P3: LED2.A R864.1
P01_LANE1_LED_B: R919.2 U9.B14(IO_2_B14/DIFFIO_T20N)
P01_LANE1_LED_G: R918.2 U9.U13(IO_4_U13/DIFFIO_B20P)
P01_LANE1_LED_R: R917.2 U9.B15(IO_2_B15/DIFFIO_T23P)
P01_LANE1_R_LED_B: C643.1 LED2.C3 R919.1
P01_LANE1_R_LED_G: C642.1 LED2.C2 R918.1
P01_LANE1_R_LED_R: C641.1 LED2.C1 R917.1
P01_LANE2_3P3: LED3.A R865.1
P01_LANE2_LED_B: R922.2 U9.N9(IO_4_N9/DEV_OE/DIFFIO_B16P)
P01_LANE2_LED_G: R921.2 U9.B13(IO_2_B13/DIFFIO_T18N)
P01_LANE2_LED_R: R920.2 U9.A13(IO_2_A13)
P01_LANE2_R_LED_B: C646.1 LED3.C3 R922.1
P01_LANE2_R_LED_G: C645.1 LED3.C2 R921.1
P01_LANE2_R_LED_R: C644.1 LED3.C1 R920.1
P01_LANE3_3P3: LED4.A R869.1
P01_LANE3_LED_B: R868.2 U9.B12(IO_2_B12/DIFFIO_T17P)
P01_LANE3_LED_G: R867.2 U9.A12(IO_2_A12/DIFFIO_T16N)
P01_LANE3_LED_R: R866.2 U9.N12(IO_4_N12/DIFFIO_B22N)
P01_LANE3_R_LED_B: C576.1 LED4.C3 R868.1
P01_LANE3_R_LED_G: C575.1 LED4.C2 R867.1
P01_LANE3_R_LED_R: C574.1 LED4.C1 R866.1
P1_LED1_SFP28_B: R932.1 U9.A10(IO_2_A10/DIFFIO_T13N)
P1_LED1_SFP28_B_R: C661.1 LED9.C1 R932.2
P1_LED1_SFP28_G: R933.1 U9.A11(IO_2_A11/DIFFIO_T15P)
P1_LED1_SFP28_G_R: C662.1 LED9.C2 R933.2
P1_LED2_SFP28_B: R1238.1 U9.B10(IO_2_B10/DIFFIO_T14P)
P1_LED2_SFP28_B_R: C796.1 LED34.C1 R1238.2
P1_LED2_SFP28_G: R1239.1 U9.B11(IO_2_B11)
P1_LED2_SFP28_G_R: C797.1 LED34.C2 R1239.2
P2_LED1_SFP28_B: R934.1 U9.B5(IO_2_B5/DIFFIO_T6N)
P2_LED1_SFP28_B_R: C663.1 LED10.C1 R934.2
P2_LED1_SFP28_G: R935.1 U9.C4(IO_2_C4/DIFFIO_T3P)
P2_LED1_SFP28_G_R: C664.1 LED10.C2 R935.2
P2_LED2_SFP28_B: R1240.1 U9.C9(IO_2_C9/DIFFIO_T14N)
P2_LED2_SFP28_B_R: C799.1 LED35.C1 R1240.2
P2_LED2_SFP28_G: R1241.1 U9.C10(IO_2_C10/DIFFIO_T15N)
P2_LED2_SFP28_G_R: C798.1 LED35.C2 R1241.2
P02_LED_B_1: R870.2 U9.F17(IO_3_F17/DIFFIO_R9P)
P02_LED_B_2: R875.2 U9.D8(IO_2_D8/DIFFIO_T9N)
P02_LED_G_1: R873.2 U9.F14(IO_3_F14/DIFFIO_R5P)
P02_LED_G_2: R874.2 U9.C13(IO_2_C13/DIFFIO_T19P)
P02_LED_R_1: R871.2 U9.N7(IO_4_N7/DIFFIO_B5P)
P02_LED_R_2: R876.2 U9.C12(IO_2_C12/DIFFIO_T21P)
P02_R_LED_B_1: LED5.C2 R870.1
P02_R_LED_B_2: LED6.C2 R875.1
P02_R_LED_G_1: LED5.C3 R873.1
P02_R_LED_G_2: LED6.C3 R874.1
P02_R_LED_R_1: LED5.C1 R871.1
P02_R_LED_R_2: LED6.C1 R876.1
P3_LED1_SFP28_B: R936.1 U9.A9(IO_2_A9/DIFFIO_T13P)
P3_LED1_SFP28_B_R: C665.1 LED11.C1 R936.2
P3_LED1_SFP28_G: R937.1 U9.B9(IO_2_B9/DIFFIO_T12N)
P3_LED1_SFP28_G_R: C666.1 LED11.C2 R937.2
P3_LED2_SFP28_B: R1242.1 U9.B4(IO_2_B4/DIFFIO_T4P)
P3_LED2_SFP28_B_R: C801.1 LED36.C1 R1242.2
P3_LED2_SFP28_G: R1243.1 U9.A5(IO_2_A5/DIFFIO_T7P)
P3_LED2_SFP28_G_R: C800.1 LED36.C2 R1243.2
P03_LED_B_1: R879.2 U9.D10(IO_2_D10/DIFFIO_T16P)
P03_LED_B_2: R883.2 U9.G18(IO_3_G18/DIFFIO_R12N)
P03_LED_G_1: R878.2 U9.D9(IO_2_D9)
P03_LED_G_2: R882.2 U9.N13(IO_3_N13/DIFFIO_R27P)
P03_LED_R_1: R880.2 U9.D11(IO_2_D11)
P03_LED_R_2: R884.2 U9.M15(IO_3_M15/DIFFIO_R26P)
P03_R_LED_B_1: LED7.C2 R879.1
P03_R_LED_B_2: LED8.C2 R883.1
P03_R_LED_G_1: LED7.C3 R878.1
P03_R_LED_G_2: LED8.C3 R882.1
P03_R_LED_R_1: LED7.C1 R880.1
P03_R_LED_R_2: LED8.C1 R884.1
P4_LED1_SFP28_B: R938.1 U9.D4(IO_1_D4)
P4_LED1_SFP28_B_R: C667.1 LED12.C1 R938.2
P4_LED1_SFP28_G: R939.1 U9.B3(IO_2_B3/DIFFIO_T2N)
P4_LED1_SFP28_G_R: C668.1 LED12.C2 R939.2
P4_LED2_SFP28_B: R1244.1 U9.D1(IO_1_D1/DIFFIO_L2N)
P4_LED2_SFP28_B_R: C803.1 LED37.C1 R1244.2
P4_LED2_SFP28_G: R1245.1 U9.D2(IO_1_D2/DIFFIO_L2P)
P4_LED2_SFP28_G_R: C802.1 LED37.C2 R1245.2
P5_LED1_SFP+_A: R940.1 U9.E1(IO_1_E1/DIFFIO_L4P)
P5_LED1_SFP+_A_R: C669.1 LED13.C2 R940.2
P5_LED1_SFP+_G: R941.1 U9.E2(IO_1_E2/DIFFIO_L3N)
P5_LED1_SFP+_G_R: C670.1 LED13.C1 R941.2
P5_LED2_SFP+_A: R1246.1 U9.C3(IO_1_C3/DIFFIO_L1N)
P5_LED2_SFP+_A_R: C805.1 LED38.C2 R1246.2
P5_LED2_SFP+_G: R1247.1 U9.C2(IO_1_C2/DIFFIO_L1P)
P5_LED2_SFP+_G_R: C804.1 LED38.C1 R1247.2
P6_LED1_SFP+_A: R923.1 U9.F1(IO_1_F1)
P6_LED1_SFP+_A_R: C647.1 LED14.C2 R923.2
P6_LED1_SFP+_G: R924.1 U9.F2(IO_1_F2/DIFFIO_L6P)
P6_LED1_SFP+_G_R: C648.1 LED14.C1 R924.2
P6_LED2_SFP+_A: R1248.1 U9.H1(IO_1_H1/DIFFIO_L12N)
P6_LED2_SFP+_A_R: C807.1 LED39.C2 R1248.2
P6_LED2_SFP+_G: R1249.1 U9.G1(IO_1_G1/DIFFIO_L9N)
P6_LED2_SFP+_G_R: C806.1 LED39.C1 R1249.2
P7_LED1_SFP+_A: R925.1 U9.J2(IO_1_J2/DIFFIO_L14P)
P7_LED1_SFP+_A_R: C649.1 LED15.C2 R925.2
P7_LED1_SFP+_G: R926.1 U9.H2(IO_1_H2/DIFFIO_L11N)
P7_LED1_SFP+_G_R: C650.1 LED15.C1 R926.2
P7_LED2_SFP+_A: R1250.1 U9.H5(IO_1_H5/DIFFIO_L14N)
P7_LED2_SFP+_A_R: C809.1 LED40.C2 R1250.2
P7_LED2_SFP+_G: R1251.1 U9.G2(IO_1_G2/DIFFIO_L8N)
P7_LED2_SFP+_G_R: C808.1 LED40.C1 R1251.2
P8_LED1_SFP+_A: R886.1 U9.J5(IO_1_J5/DIFFIO_L17P)
P8_LED1_SFP+_A_R: C591.1 LED16.C2 R886.2
P8_LED1_SFP+_G: R887.1 U9.J3(IO_1_J3/DIFFIO_L13P)
P8_LED1_SFP+_G_R: C592.1 LED16.C1 R887.2
P8_LED2_SFP+_A: R1252.1 U9.L3(IO_1_L3/DIFFIO_L19N)
P8_LED2_SFP+_A_R: C811.1 LED41.C2 R1252.2
P8_LED2_SFP+_G: R1253.1 U9.K2(IO_1_K2/DIFFIO_L16N)
P8_LED2_SFP+_G_R: C810.1 LED41.C1 R1253.2
P9_LED1_SFP+_A: R888.1 U9.M2(IO_1_M2/DIFFIO_L21N)
P9_LED1_SFP+_A_R: C593.1 LED17.C2 R888.2
P9_LED1_SFP+_G: R889.1 U9.L2(IO_1_L2/DIFFIO_L18N)
P9_LED1_SFP+_G_R: C594.1 LED17.C1 R889.2
P9_LED2_SFP+_A: R1254.1 U9.K3(IO_1_K3/DIFFIO_L17N)
P9_LED2_SFP+_A_R: C813.1 LED42.C2 R1254.2
P9_LED2_SFP+_G: R1255.1 U9.G5(IO_1_G5/DIFFIO_L11P)
P9_LED2_SFP+_G_R: C812.1 LED42.C1 R1255.2
P10_LED1_SFP+_A: R890.1 U9.N2(IO_1_N2/DIFFIO_L24N)
P10_LED1_SFP+_A_R: C597.1 LED18.C2 R890.2
P10_LED1_SFP+_G: R891.1 U9.N1(IO_1_N1/DIFFIO_L23N)
P10_LED1_SFP+_G_R: C598.1 LED18.C1 R891.2
P10_LED2_SFP+_A: R1256.1 U9.P3(IO_1_P3/DIFFIO_L27N)
P10_LED2_SFP+_A_R: C815.1 LED43.C2 R1256.2
P10_LED2_SFP+_G: R1257.1 U9.P2(IO_1_P2/DIFFIO_L27P)
P10_LED2_SFP+_G_R: C814.1 LED43.C1 R1257.2
P11_LED1_SFP+_A: R892.1 U9.R3(IO_1_R3/DIFFIO_L29P)
P11_LED1_SFP+_A_R: C599.1 LED19.C2 R892.2
P11_LED1_SFP+_G: R893.1 U9.R2(IO_1_R2/DIFFIO_L28N)
P11_LED1_SFP+_G_R: C600.1 LED19.C1 R893.2
P11_LED2_SFP+_A: R1258.1 U9.N3(IO_1_N3/DIFFIO_L25N)
P11_LED2_SFP+_A_R: C817.1 LED44.C2 R1258.2
P11_LED2_SFP+_G: R1259.1 U9.P1(IO_1_P1/DIFFIO_L26N)
P11_LED2_SFP+_G_R: C816.1 LED44.C1 R1259.2
P12_LED1_SFP+_A: R894.1 U9.V4(IO_4_V4)
P12_LED1_SFP+_A_R: C603.1 LED20.C2 R894.2
P12_LED1_SFP+_G: R895.1 U9.T5(IO_4_T5/DIFFIO_B5N)
P12_LED1_SFP+_G_R: C604.1 LED20.C1 R895.2
P12_LED2_SFP+_A: R1260.1 U9.T4(IO_4_T4/DIFFIO_B3P)
P12_LED2_SFP+_A_R: C819.1 LED45.C2 R1260.2
P12_LED2_SFP+_G: R1261.1 U9.R5(IO_4_R5)
P12_LED2_SFP+_G_R: C818.1 LED45.C1 R1261.2
P13_LED1_SFP+_A: R896.1 U9.U4(IO_4_U4/DIFFIO_B4P)
P13_LED1_SFP+_A_R: C605.1 LED21.C2 R896.2
P13_LED1_SFP+_G: R897.1 U9.V2(IO_4_V2/DIFFIO_B1N)
P13_LED1_SFP+_G_R: C606.1 LED21.C1 R897.2
P13_LED2_SFP+_A: R1262.1 U9.V5(IO_4_V5/DIFFIO_B7N)
P13_LED2_SFP+_A_R: C821.1 LED46.C2 R1262.2
P13_LED2_SFP+_G: R1263.1 U9.U5(IO_4_U5/DIFFIO_B6N)
P13_LED2_SFP+_G_R: C820.1 LED46.C1 R1263.2
P14_LED1_SFP+_A: R928.1 U9.P10(IO_4_P10/DIFFIO_B15N)
P14_LED1_SFP+_A_R: C657.1 LED22.C2 R928.2
P14_LED1_SFP+_G: R929.1 U9.P11(IO_4_P11)
P14_LED1_SFP+_G_R: C658.1 LED22.C1 R929.2
P14_LED2_SFP+_A: R1264.1 U9.V6(IO_4_V6/DIFFIO_B9P)
P14_LED2_SFP+_A_R: C823.1 LED47.C2 R1264.2
P14_LED2_SFP+_G: R1265.1 U9.T6(IO_4_T6/DIFFIO_B4N)
P14_LED2_SFP+_G_R: C822.1 LED47.C1 R1265.2
P15_LED1_SFP+_A: R930.1 U9.P6(IO_4_P6/DIFFIO_B2N)
P15_LED1_SFP+_A_R: C659.1 LED23.C2 R930.2
P15_LED1_SFP+_G: R931.1 U9.R6(IO_4_R6/DIFFIO_B3N)
P15_LED1_SFP+_G_R: C660.1 LED23.C1 R931.2
P15_LED2_SFP+_A: R1266.1 U9.U8(IO_4_U8/DIFFIO_B11N)
P15_LED2_SFP+_A_R: C825.1 LED48.C2 R1266.2
P15_LED2_SFP+_G: R1267.1 U9.R8(IO_4_R8/DIFFIO_B10N)
P15_LED2_SFP+_G_R: C824.1 LED48.C1 R1267.2
P16_LED1_SFP+_A: R898.1 U9.V12(IO_4_V12/DIFFIO_B19N)
P16_LED1_SFP+_A_R: C611.1 LED24.C2 R898.2
P16_LED1_SFP+_G: R899.1 U9.T11(IO_4_T11/DIFFIO_B21N)
P16_LED1_SFP+_G_R: C612.1 LED24.C1 R899.2
P16_LED2_SFP+_A: R1268.1 U9.R11(IO_4_R11/DIFFIO_B20N)
P16_LED2_SFP+_A_R: C827.1 LED49.C2 R1268.2
P16_LED2_SFP+_G: R1269.1 U9.R10(IO_4_R10/DIFFIO_B17P)
P16_LED2_SFP+_G_R: C826.1 LED49.C1 R1269.2
P17_LED1_SFP+_A: R900.1 U9.V11(IO_4_V11/DIFFIO_B17N)
P17_LED1_SFP+_B_R: C613.1 LED25.C2 R900.2
P17_LED1_SFP+_G: R901.1 U9.P12(IO_4_P12/DIFFIO_B23P)
P17_LED1_SFP+_G_R: C614.1 LED25.C1 R901.2
P17_LED2_SFP+_A: R1270.1 U9.R13(IO_4_R13/DIFFIO_B26N)
P17_LED2_SFP+_A_R: C829.1 LED50.C2 R1270.2
P17_LED2_SFP+_G: R1271.1 U9.R12(IO_4_R12/DIFFIO_B24P)
P17_LED2_SFP+_G_R: C828.1 LED50.C1 R1271.2
P18_LED1_SFP+_A: R902.1 U9.T16(IO_3_T16/DIFFIO_R31N)
P18_LED1_SFP+_B_R: C617.1 LED26.C2 R902.2
P18_LED1_SFP+_G: R903.1 U9.V15(IO_4_V15/DIFFIO_B26P)
P18_LED1_SFP+_G_R: C618.1 LED26.C1 R903.2
P18_LED2_SFP+_A: R1272.1 U9.U14(IO_4_U14)
P18_LED2_SFP+_A_R: C831.1 LED51.C2 R1272.2
P18_LED2_SFP+_G: R1273.1 U9.T13(IO_4_T13/DIFFIO_B27N)
P18_LED2_SFP+_G_R: C830.1 LED51.C1 R1273.2
P19_LED1_SFP+_A: R904.1 U9.U15(IO_4_U15/DIFFIO_B25N)
P19_LED1_SFP+_B_R: C619.1 LED27.C2 R904.2
P19_LED1_SFP+_G: R905.1 U9.V14(IO_4_V14/DIFFIO_B23N)
P19_LED1_SFP+_G_R: C620.1 LED27.C1 R905.2
P19_LED2_SFP+_A: R1274.1 U9.V17(IO_4_V17/DIFFIO_B28P)
P19_LED2_SFP+_A_R: C833.1 LED52.C2 R1274.2
P19_LED2_SFP+_G: R1275.1 U9.U16(IO_4_U16/DIFFIO_B27P)
P19_LED2_SFP+_G_R: C832.1 LED52.C1 R1275.2
P20_LED1_SFP+_A: R906.1 U9.P17(IO_3_P17/DIFFIO_R27N)
P20_LED1_SFP+_B_R: C623.1 LED28.C2 R906.2
P20_LED1_SFP+_G: R907.1 U9.P18(IO_3_P18/DIFFIO_R26N)
P20_LED1_SFP+_G_R: C624.1 LED28.C1 R907.2
P20_LED2_SFP+_A: R1276.1 U9.R16(IO_3_R16/DIFFIO_R31P)
P20_LED2_SFP+_A_R: C835.1 LED53.C2 R1276.2
P20_LED2_SFP+_G: R1277.1 U9.N17(IO_3_N17/DIFFIO_R24N)
P20_LED2_SFP+_G_R: C834.1 LED53.C1 R1277.2
P21_LED1_SFP+_A: R908.1 U9.R15(IO_3_R15/DIFFIO_R32P)
P21_LED1_SFP+_B_R: C627.1 LED29.C2 R908.2
P21_LED1_SFP+_G: R909.1 U9.T17(IO_3_T17/DIFFIO_R32N)
P21_LED1_SFP+_G_R: C628.1 LED29.C1 R909.2
P21_LED2_SFP+_A: R1278.1 U9.R17(IO_3_R17/DIFFIO_R30P)
P21_LED2_SFP+_A_R: C837.1 LED54.C2 R1278.2
P21_LED2_SFP+_G: R1279.1 U9.N18(IO_3_N18/DIFFIO_R23N)
P21_LED2_SFP+_G_R: C836.1 LED54.C1 R1279.2
P22_LED1_SFP+_A: R910.1 U9.M17(IO_3_M17/DIFFIO_R22P)
P22_LED1_SFP+_B_R: C629.1 LED30.C2 R910.2
P22_LED1_SFP+_G: R911.1 U9.M18(IO_3_M18/DIFFIO_R21P)
