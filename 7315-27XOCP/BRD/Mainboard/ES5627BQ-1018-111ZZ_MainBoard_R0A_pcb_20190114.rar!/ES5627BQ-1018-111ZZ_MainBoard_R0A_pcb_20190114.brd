# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDD1P0_MARGIN HIGH: length 11.3
  TOP w0.127: P1.C16 v4(96.29,225.46) ; R299.2 90.62,230.03 v1(90.94,229.72)
  S9 w0.127: v4(96.29,225.46) 96.29,226.48 95.72,227.05 95.07,227.05 94.8,227.32 94.8,228.86 94.62,229.03 93.65,229.03 92.96,229.72 v1(90.94,229.72)
  BOTTOM w0.127: v2(89.93,229.69) 89.96,229.72 v1(90.94,229.72)
VDD1P0_MARGIN HIGH_R: length 9.6
  TOP w0.127: v1(82.83,232.64) 82.96,232.77 Q2.G 84.13,232.76 C157.2 86.08,232.63 R300.1 87.28,231.62 88.87,230.03 R299.1
  BOTTOM w0.127: v1(82.83,232.64) 83.31,233.11 v2(84.08,233.11)
VDD1P0_MARGIN LOW: length 10.4
  TOP w0.127: R334.2 92.42,229.02 v1(92.55,228.89) ; P1.C15 v4(96.29,224.46)
  S9 w0.127: v4(96.29,224.46) 96.29,224.9 94.54,226.64 94.54,227.4 93.05,228.89 v1(92.55,228.89)
  BOTTOM w0.127: v1(92.55,228.89) 91.98,229.46 v2(91.98,229.59)
VDD1P0_MARGIN LOW_R: length 8.2
  TOP w0.127: R334.1 87.29,229.02 R335.1 85.95,229.01 C182.2 84.13,229.02 Q5.G 84.08,228.98 v1(82.79,228.98)
  BOTTOM w0.127: v2(83.29,230.49) 82.79,230 v1(82.79,228.98)
VDD1P0_MON: length 13.1
  TOP w0.254: R118.1 240.12,214.29 240.12,214.41 239.48,215.05 237.99,215.05 237.74,215.3 C83.1 237.74,215.99 237.16,216.57 237.16,217.2 236.52,217.84 236.52,218.02 235.8,218.74 U7.55 v1(234.42,218.74)
  BOTTOM w0.127: v1(234.42,218.74) 234.96,218.74 236.25,217.46 v2(238.47,217.46)
VDD1P0_ROV: length 473.4
  TOP w0.254: R604.2 v1(103.8,124.05)
  TOP w0.381: U40.U20 v4(37.7,113.65) ; U40.W22 v4(35.7,116.65) ; v4(31.7,120.65) U40.AC26 ; U40.U18 v4(40.7,113.65) ; v4(45.7,123.65) U40.AF13 ; U40.W16 v4(42.7,116.65) ; v4(37.7,122.65) U40.AE20 ; U40.AB13 v4(45.7,119.65) ; v4(42.7,124.65) U40.AG16 ; U40.AA12 v4(46.7,118.65) ; v4(46.7,122.65) U40.AE12 ; U40.V11 v4(47.7,114.65) ; v4(43.7,123.65) U40.AF15 ; U40.AB25 v4(32.7,119.65) ; v4(46.7,111.65) U40.R12 ; v4(30.7,119.65) U40.AB27 ; v4(40.7,111.65) U40.R18 ; v4(40.7,122.65) U40.AE18 ; v4(43.7,114.65) U40.V15 ; U40.T11 v4(47.7,112.65) ; U40.AD15 v4(43.7,121.65) ; v4(30.7,114.65) U40.V27 ; v4(36.7,110.65) U40.P21 ; v4(33.7,120.65) U40.AC24 ; v4(46.7,124.65) U40.AG12 ; U40.AG11 v4(47.7,124.65) ; U40.W20 v4(37.7,116.65) ; U40.U22 v4(35.7,113.65) ; v4(35.7,111.65) U40.R22 ; U40.W24 v4(33.7,116.65) ; v4(37.7,120.65) U40.AC20 ; v4(33.7,122.65) U40.AE24 ; v4(36.7,119.65) U40.AB21 ; v4(34.7,117.65) U40.Y23 ; U40.Y11 v4(47.7,117.65) ; v4(39.7,121.65) U40.AD19 ; U40.AC14 v4(44.7,120.65) ; v4(37.7,111.65) U40.R20 ; v4(30.7,110.65) U40.P27 ; U40.T21 v4(36.7,112.65) ; v4(34.7,121.65) U40.AD23 ; v4(45.7,117.65) U40.Y13 ; v4(42.7,111.65) U40.R16 ; v4(35.7,118.65) U40.AA22 ; v4(37.7,118.65) U40.AA20 ; v4(43.7,117.65) U40.Y15 ; v4(33.7,118.65) U40.AA24 ; v4(34.7,119.65) U40.AB23 ; v4(42.7,120.65) U40.AC16 ; U40.T17 v4(41.7,112.65) ; v4(43.7,110.65) U40.P15 ; U40.T19 v4(39.7,112.65) ; v4(31.7,118.65) U40.AA26 ; v4(45.7,110.65) U40.P13 ; v4(35.7,122.65) U40.AE22 ; U40.U16 v4(42.7,113.65) ; v4(36.7,114.65) U40.V21 ; v1(241.96,218.22) 241.96,218.22 R95.2 ; v4(31.7,111.65) U40.R26 ; v4(34.7,123.65) U40.AF23 ; v4(36.7,121.65) U40.AD21 ; U40.W26 v4(31.7,116.65) ; U40.P25 v4(32.7,110.65) ; v4(42.7,118.65) U40.AA16 ; v4(44.7,122.65) U40.AE14 ; v4(35.7,120.65) U40.AC22 ; v4(39.7,110.65) U40.P19 ; U40.T15 v4(43.7,112.65) ; U40.AE16 v4(42.7,122.65) ; v4(44.7,111.65) U40.R14 ; v4(40.7,118.65) U40.AA18 ; v4(41.7,121.65) U40.AD17 ; v4(39.7,119.65) U40.AB19 ; v4(33.7,111.65) U40.R24 ; U40.T27 v4(30.7,112.65) ; U40.W12 v4(46.7,116.65) ; v4(43.7,119.65) U40.AB15 ; v4(29.7,120.65) U40.AC28 ; v4(41.7,114.65) U40.V17 ; v4(44.7,118.65) U40.AA14 ; v4(44.7,124.65) U40.AG14 ; v4(34.7,114.65) U40.V23 ; U40.W14 v4(44.7,116.65) ; v4(36.7,117.65) U40.Y21 ; v4(41.7,110.65) U40.P17 ; U40.P11 v4(47.7,110.65) ; v4(45.7,121.65) U40.AD13 ; v4(41.7,119.65) U40.AB17 ; U40.T23 v4(34.7,112.65)
  S5 w0.381: 95.98,122.98 CONN29.1 ; CONN29.1 95.98,124.86 ; CONN29.1 95.04,123.92
  S7 w0.381: CONN29.1 95.98,124.86 ; CONN29.1 96.92,123.92 ; CONN29.1 95.98,122.98 ; CONN29.1 95.04,123.92
  S9 w0.254: v1(83.47,113.13) 84.23,112.37 85.18,112.37 94.83,122.02 102.02,122.02 103.42,123.42 103.42,123.67 v1(103.8,124.05) ; v1(224.5,205.93) 224.5,206.03 242.73,206.03 243.49,206.79 243.49,213.01 244.38,213.9 244.38,216.32 242.47,218.22 v1(241.96,218.22)
  S9 w0.381: CONN29.1 96.92,123.92 ; CONN29.1 95.98,122.98 ; CONN29.1 95.98,124.86 ; CONN29.1 95.04,123.92
  S12 w0.254: CONN29.1 95.98,121.84 92.84,118.7 92.84,113.09 95.98,109.95 102.23,109.95 105.41,113.13 107.54,113.13 107.8,112.88 116.37,112.88 128.74,125.26 128.74,128.05 136.4,135.71 145,135.71 146.64,134.07 150.7,134.07 153.81,137.18 169.19,137.18 169.74,137.72 175.1,137.72 175.43,138.05 176.65,138.05 177.89,139.29 187.04,139.29 187.07,139.32 187.11,139.32 188.51,140.72 188.51,143.52 194.05,149.06 199.73,149.06 214.6,163.93 214.6,199.62 218.85,203.87 222.41,203.87 224.5,205.97 v1(224.5,205.93)
  S14 w0.381: CONN29.1 96.92,123.92 ; CONN29.1 95.98,122.98 ; CONN29.1 95.04,123.92 ; CONN29.1 95.98,124.86
  S16 w0.381: 95.04,123.92 CONN29.1 ; CONN29.1 95.98,122.98 ; CONN29.1 95.98,124.86 ; CONN29.1 96.92,123.92
  BOTTOM w0.381: CB582.1 41.7,114.65 v4(41.7,114.65) 42.2,114.14 CB592.1 42.7,113.65 v4(42.7,113.65) CB613.1 43.2,113.14 v4(43.7,112.65) CB625.1 v4(44.7,111.65) CB630.1 v4(45.7,110.65) CB645.1 ; v4(43.7,123.65) 43.2,124.14 CB450.1 42.71,124.65 v4(42.7,124.65) 42.2,125.14 CB432.1 ; v4(43.7,123.65) 43.2,123.15 CB474.1 42.7,122.65 v4(42.7,122.65) 42.2,122.15 CB473.1 41.7,121.65 v4(41.7,121.65) 41.2,121.15 CB492.1 ; v4(43.7,123.65) 43.7,123.65 CB451.1 44.2,124.15 v4(44.7,124.65) 45.2,125.15 CB433.1 ; v4(31.7,120.65) 31.7,120.64 CB515.1 32.19,120.15 v4(32.7,119.65) 32.7,119.64 CB516.1 33.19,119.15 v4(33.7,118.65) 34.19,118.15 CB541.1 34.69,117.65 v4(34.7,117.65) 35.19,117.15 CB553.1 35.7,116.65 v4(35.7,116.65) 36.19,116.15 CB567.1 CB581.1 ; 37.67,115.62 38.28,115.01 38.28,114.28 CB590.1 ; 37.67,115.62 CB568.2 38.2,116.15 v4(37.7,116.65) 37.7,116.65 CB554.1 37.2,117.15 v4(36.7,117.65) 36.7,117.65 CB542.1 v4(35.7,118.65) 35.7,118.65 CB518.1 35.19,119.15 v4(34.7,119.65) 34.7,119.65 CB517.1 34.19,120.15 v4(33.7,120.65) ; 37.67,115.62 CB581.1 ; 95.04,123.92 CONN29.1 ; CONN29.1 96.92,123.92 ; CONN29.1 95.98,122.98 ; CONN29.1 95.98,124.86 ; v4(45.7,121.65) CB485.1 v4(46.7,122.65) ; CB512.1 29.24,120.19 v4(29.7,120.65) 30.19,120.15 CB513.1 30.69,119.65 v4(30.7,119.65) 30.7,119.64 CB514.1 31.69,118.65 v4(31.7,118.65) 32.19,118.15 CB540.1 32.2,118.15 33.21,117.13 ; CB644.1 v4(43.7,110.65) 43.7,110.65 CB629.1 43.2,111.14 v4(42.7,111.65) 42.7,111.65 CB624.1 v4(41.7,112.65) 41.7,112.65 CB612.1 v4(40.7,113.65) 40.7,113.65 CB591.1 ; CB571.1 30.23,115.12 v4(30.7,114.65) 30.7,114.65 CB565.1 ; CB569.1 44.2,116.15 v4(44.7,116.65) 44.7,116.65 CB558.1 45.2,117.15 v4(45.7,117.65) 45.7,117.65 CB549.1 46.2,118.15 v4(46.7,118.65) ; CB600.1 30.7,112.65 v4(30.7,112.65) 30.2,113.14 CB599.1 ; 33.21,117.13 32.22,116.15 CB565.1 ; 33.21,117.13 v4(33.7,116.65) 34.19,116.15 CB566.1 CB580.1 34.7,114.65 v4(34.7,114.65) ; v4(36.7,110.65) 36.7,110.65 CB627.1 37.2,111.14 v4(37.7,111.65) 37.7,111.65 CB622.1 CB640.1 39.69,110.65 v4(39.7,110.65) ; CB581.1 36.7,114.65 v4(36.7,114.65) CB589.1 v4(35.7,113.65) 35.2,113.14 CB609.1 v4(34.7,112.65) CB620.1 33.7,111.65 v4(33.7,111.65) v4(32.7,110.65) ; v4(34.7,123.65) 35.19,123.15 CB467.1 35.7,122.65 v4(35.7,122.65) 36.19,122.15 CB482.1 36.7,121.65 v4(36.7,121.65) 37.19,121.15 CB497.1 37.7,120.65 v4(37.7,120.65) 38.19,120.15 CB521.2 CB530.2 ; CB530.2 39.2,119.15 v4(39.7,119.65) ; CB530.2 CB543.1 v4(37.7,118.65) CB520.1 37.19,119.15 v4(36.7,119.65) CB519.2 36.19,120.15 v4(35.7,120.65) CB496.1 v4(34.7,121.65) ; CB643.1 31.19,110.15 v4(30.7,110.65) 30.7,110.65 CB626.1 31.19,111.14 v4(31.7,111.65) 31.7,111.65 CB619.1 ; v4(46.7,124.65) 46.2,124.15 CB452.1 v4(45.7,123.65) CB468.1 v4(44.7,122.65) CB484.1 v4(43.7,121.65) CB504.1 v4(42.7,120.65) CB503.1 v4(41.7,119.65) ; v4(47.7,110.65) 47.7,110.65 CB631.1 47.2,111.14 v4(46.7,111.65) 46.7,111.65 CB615.1 ; v4(42.7,116.65) 42.7,116.65 CB555.1 43.2,117.15 v4(43.7,117.65) 43.7,117.65 CB534.1 44.2,118.15 v4(44.7,118.65) 44.7,118.65 CB535.1 45.2,119.15 v4(45.7,119.65) ; CB590.1 39.19,113.14 CB611.1 39.7,112.65 v4(39.7,112.65) U40.R18 CB623.1 40.69,111.65 v4(40.7,111.65) 41.2,111.14 CB628.1 41.2,111.14 v4(41.7,110.65) ; CB590.1 38.17,114.12 v4(37.7,113.65) CB610.1 v4(36.7,112.65) CB621.1 v4(35.7,111.65) ; v4(43.7,114.65) 43.7,114.65 CB583.1 ; CB565.1 32.19,116.15 v4(31.7,116.65) ; CB532.1 v4(42.7,118.65) CB533.1 43.2,119.15 v4(43.7,119.65) CB505.1 v4(44.7,120.65) ; v4(46.7,116.65) 46.7,116.65 CB556.1 47.2,117.15 v4(47.7,117.65) ; v4(40.7,122.65) 40.2,122.15 CB491.2 39.7,121.65 v4(39.7,121.65) 39.2,121.15 CB502.1 38.2,122.15 CB483.1 37.7,122.65 v4(37.7,122.65) ; CB573.1 47.7,114.65 v4(47.7,114.65) ; CB616.1 47.7,112.65 v4(47.7,112.65) ; CB538.1 40.7,118.57 v4(40.7,118.65)
  vias: v1(74.65,120.31) v1(74.65,119.62) v1(74.65,118.63) v1(74.65,117.95) v1(74.7,117.24) v1(74.7,116.55) v1(77.22,114.7) v1(77.31,131.04) v1(77.31,130.27) v1(78.07,131.04) v1(78.49,119.65) v1(78.49,118.96) v1(78.83,131.04) v1(79.24,132.46) v1(79.26,131.67) v1(79.5,118.89) v1(79.5,118.2) v1(79.5,117.5) v1(79.5,116.8) v1(79.5,115.79) v1(79.5,115.08) v1(79.5,114.39) v1(79.5,113.68) v1(79.59,130.27) v1(79.72,131.04) v1(80,132.46) v1(80.02,131.67) v1(80.27,118.89) v1(80.27,118.2) v1(80.27,117.5) v1(80.27,116.8) v1(80.27,115.79) v1(80.27,115.08) v1(80.27,114.39) v1(80.27,113.68) v1(80.75,132.45) v1(80.74,130.91) v1(80.77,131.66) v1(81.63,130.91) v1(82.54,131.04) v1(82.71,115.48) v1(82.81,130.37) v1(82.78,114.66) v1(82.78,113.9) v1(82.78,113.13) v1(83.28,131.01) v1(83.47,115.48) v1(83.47,114.66) v1(83.47,113.9) v1(83.79,119.99) v1(83.99,131.01) v1(84.45,132.17) v1(85.03,130.97) v1(85.06,119.99) v1(85.21,132.17) v1(85.31,116.69) v1(85.28,114.63) v1(85.82,130.89) v1(85.97,132.15) v1(86.36,126.98) v1(86.36,125.58) v1(86.35,124.51) v1(86.36,120.75) v1(86.36,119.61) v1(86.36,118.34) v1(86.36,117.2) v1(86.36,115.93) v1(86.36,114.79) v1(86.65,133.01) v1(86.75,132.15) v1(87.12,131.02) v1(87.12,129.75) v1(87.12,128.48) v1(87.25,123.68) v1(87.25,122.53) v1(87.85,131.67) v1(87.89,130.53) v1(87.89,129.26) v1(87.89,127.99) v1(87.89,126.85) v1(87.89,125.45) v1(87.89,124.18) v1(87.89,122.91) v1(87.89,121.77) v1(87.89,120.63) v1(87.89,119.48) v1(87.89,118.21) v1(87.89,117.07) v1(88.9,118.21) v1(88.9,117.2) v1(88.99,130.15) v1(88.99,129.13) v1(88.99,128.12) v1(89.73,117.98) v1(89.88,118.77) v1(90.14,129.13) v1(90.14,128.12) v1(91.19,127.99) v1(91.67,126.9) v1(91.67,125.5) v1(91.67,124.23) v1(91.68,123.09) v1(91.74,122.04) v1(91.76,120.93) v2(89.81,123.47)
VDD1P0_ROV_MON: length 10.3
  TOP w0.254: C61.1 237.6,218.21 236.07,219.74 U7.57 v1(234.41,219.74)
  TOP w0.381: R95.1 239.59,218.92 238.02,218.92 237.8,218.69 237.8,218.26 C61.1
  BOTTOM w0.127: v1(234.41,219.74) 235.04,219.74 236.44,218.35 v2(236.76,218.35)
VDD1P2_DDR: length 286
  TOP w0.254: v1(65.26,184.08) 66,184.83 U6.2 ; v1(242.28,222.48) 242.21,222.4 R68.2
  TOP w0.381: C36.1 63.32,183.16 62.6,182.45 62.6,182.09 62.14,181.63 R49.1
  TOP w0.508: 125.7,161.9 C288.1 ; v1(65.26,184.08) 64.95,183.78 C41.1 C36.1 ; v1(128.62,174.47) 127.97,175.12 R634.1
  S9 w0.254: CONN23.1 129.96,160.56 157.1,160.56 157.15,160.6 158.18,160.6 161.78,164.2 166.57,164.2 169.61,167.23 v1(209.06,167.23) ; v1(243.61,214.73) 243.04,214.16 243.04,207.32 242.18,206.46 224.77,206.46 v1(222.34,208.89)
  S12 w0.254: v1(242.28,222.48) 242.28,218.73 243.61,217.4 v1(243.61,214.73) ; v1(209.06,167.23) 209.07,167.23 209.07,168.69 211.99,171.61 211.99,200.06 220.82,208.89 v1(222.34,208.89)
  S12 w0.508: v1(114.65,159.1) 111.84,159.1 105.76,165.19 105.76,176.25 99.98,182.03 99.98,189.33 94.96,194.35 77.8,194.35 75.01,191.55 73.43,191.55 67.66,185.77 66.95,185.77 v1(65.26,184.08)
  S14 w0.254: v1(128.62,174.47) 128.62,172.18 129.13,171.67 129.13,169.01 127.09,166.98 127.09,164.56 v1(123.79,161.26)
  BOTTOM w0.127: v1(243.61,214.73) 243.74,214.6 v2(245.33,214.6) ; v2(241.98,220.57) 242.28,220.88 v1(242.28,222.48) ; v1(222.34,208.89) 222.66,209.2 v2(222.66,209.78) ; v2(210.53,166.91) 210.21,167.23 v1(209.06,167.23)
  BOTTOM w0.381: 128.45,158.11 CONN23.1 ; CONN23.1 128.45,159.99 ; CONN23.1 127.51,159.05 ; CONN23.1 129.39,159.05 ; C287.2 v1(123.79,162.02)
  vias: v1(114.65,158.34) v1(114.65,157.58) v1(115.66,162.79) v1(115.66,162.02) v1(115.66,161.26) v1(116.68,162.79) v1(116.68,162.02) v1(116.68,161.26) v1(117.19,158.98) v1(117.19,158.21) v1(117.19,157.45) v1(119.73,158.98) v1(119.73,158.21) v1(119.73,157.45) v1(119.98,162.79) v1(119.98,162.02) v1(119.98,161.26) v1(119.98,160.5) v1(121,162.79) v1(121,162.02) v1(121,161.26) v1(121,160.5) v1(122.01,162.79) v1(122.01,162.02) v1(122.01,161.26) v1(122.01,160.5) v1(122.39,159.1) v1(122.39,158.34) v1(122.39,157.58) v1(123.79,160.5) v1(125.06,159.1) v1(125.06,158.34) v1(125.06,157.45) v2(118.38,162.37)
VDD1P2_DDR_ABC: length 85.7
  TOP w0.381: v4(42.7,127.65) U40.AK16 ; v4(51.7,133.65) U40.AT7 ; v4(29.7,133.65) U40.AT28 ; v4(45.7,133.65) U40.AT13 ; v4(46.7,129.65) U40.AM12 ; v4(56.7,119.65) U40.AB2 ; v4(35.7,127.65) U40.AK22 ; v4(41.7,131.65) U40.AP17 ; v4(34.7,131.65) U40.AP23 ; v4(56.7,122.65) U40.AE2 ; v4(23.7,133.65) U40.AT34 ; v4(26.7,127.65) U40.AK31 ; v4(28.7,131.65) U40.AP29 ; v4(50.7,119.65) U40.AB8 ; v4(54.7,130.65) U40.AN4 ; U40.AH17 v4(41.7,125.65) ; v4(44.7,131.65) U40.AP14 ; v4(54.7,127.65) U40.AK4 ; U40.AK19 v4(39.7,127.65) ; v4(52.7,129.65) U40.AM6 ; U40.AT16 v4(42.7,133.65) ; v4(33.7,129.65) U40.AM24 ; v4(56.7,128.65) U40.AL2 ; v4(36.7,129.65) U40.AM21 ; v4(53.7,119.65) U40.AB5 ; U40.AT19 v4(39.7,133.65) ; v4(49.7,123.65) U40.AF9 ; v4(25.7,131.65) U40.AP32 ; v4(20.7,133.65) U40.AT37 ; v4(49.7,129.65) U40.AM9 ; U40.AH2 v4(56.7,125.65) ; v4(22.7,131.65) U40.AP35 ; U40.AH8 v4(50.7,125.65) ; v4(54.7,124.65) U40.AG4 ; U40.AP11 v4(47.7,131.65) ; v4(29.7,127.65) U40.AK28 ; v4(48.7,127.65) U40.AK10 ; U40.AH14 v4(44.7,125.65) ; v4(24.7,129.65) U40.AM33 ; v4(54.7,133.65) U40.AT4 ; U40.AK25 v4(32.7,127.65) ; U40.AT25 v4(32.7,133.65) ; v4(50.7,131.65) U40.AP8 ; v4(52.7,123.65) U40.AF6 ; v4(31.7,131.65) U40.AP26 ; U40.AH11 v4(47.7,125.65) ; v4(52.7,131.65) U40.AP6 ; v4(30.7,129.65) U40.AM27 ; v4(56.7,131.65) U40.AP2 ; U40.AH29 v4(28.7,125.65) ; v4(43.7,129.65) U40.AM15 ; v4(27.7,129.65) U40.AM30 ; v4(35.7,133.65) U40.AT22 ; v4(45.7,127.65) U40.AK13 ; v4(48.7,133.65) U40.AT10 ; v4(51.7,127.65) U40.AK7 ; v4(51.7,121.65) U40.AD7 ; v4(54.7,121.65) U40.AD4 ; v4(40.7,129.65) U40.AM18 ; v4(26.7,133.65) U40.AT31 ; v4(37.7,131.65) U40.AP20
  BOTTOM w0.381: CB377.1 47.69,131.65 v4(47.7,131.65) ; CB364.2 21.18,133.16 v4(20.7,133.65) ; v4(50.7,131.65) 50.69,131.65 CB370.1 ; CB434.2 54.7,124.65 v4(54.7,124.65) ; v4(31.7,131.65) 31.7,131.66 CB369.1 ; CB386.1 34.71,131.65 v4(34.7,131.65) ; CB436.1 50.7,125.59 v4(50.7,125.65) ; CB376.2 25.68,131.65 v4(25.7,131.65) ; CB470.1 52.21,123.16 v4(52.7,123.65) ; v4(35.7,127.65) 36.19,127.15 CB415.1 ; v4(54.7,127.65) 54.22,127.17 CB416.2 ; CB356.1 45.69,133.65 v4(45.7,133.65) ; CB379.2 56.7,131.64 v4(56.7,131.65) ; CB411.1 48.21,127.15 v4(48.7,127.65) ; CB493.1 54.7,121.64 v4(54.7,121.65) ; CB392.1 43.21,129.16 v4(43.7,129.65) ; CB397.1 49.67,129.65 v4(49.7,129.65) ; v4(42.7,127.65) 42.69,127.65 CB409.1 ; v4(45.7,127.65) 45.69,127.65 CB410.2 ; CB391.1 40.69,129.65 v4(40.7,129.65) ; CB357.1 48.69,133.65 v4(48.7,133.65) ; v4(56.7,119.65) 56.69,119.65 CB526.1 ; CB367.1 37.7,131.66 v4(37.7,131.65) ; CB418.1 28.2,126.15 v4(28.7,125.65) ; v4(56.7,125.65) 56.21,125.16 CB435.2 ; v4(36.7,129.65) 37.19,129.16 CB395.1 ; CB537.1 53.21,119.16 v4(53.7,119.65) ; v4(54.7,130.65) 54.21,130.16 CB387.2 ; v4(28.7,131.65) 28.7,131.65 CB385.2 ; v4(44.7,125.65) 44.69,125.65 CB426.1 ; v4(41.7,131.65) 41.22,131.17 CB374.2 ; CB420.1 41.2,126.14 v4(41.7,125.65) ; v4(22.7,131.65) CB384.2 ; CB499.1 51.21,121.16 v4(51.7,121.65) ; CB354.2 26.7,133.67 v4(26.7,133.65) ; CB375.1 44.74,131.65 v4(44.7,131.65) ; CB359.2 51.76,133.65 v4(51.7,133.65) ; CB353.2 23.7,133.67 v4(23.7,133.65) ; CB363.1 39.7,133.59 v4(39.7,133.65) ; v4(42.7,133.65) 42.7,133.72 CB352.1 ; v4(52.7,131.65) 52.7,131.65 CB378.1 ; CB427.1 47.7,125.65 v4(47.7,125.65) ; v4(33.7,129.65) 33.7,129.66 CB389.1 ; CB396.1 52.21,129.16 v4(52.7,129.65) ; v4(39.7,127.65) 39.7,127.7 CB412.1 ; CB393.1 46.69,129.65 v4(46.7,129.65) ; v4(29.7,133.65) 29.7,133.69 CB350.2 ; v4(51.7,127.65) 51.73,127.65 CB403.1 ; CB358.1 54.21,133.16 v4(54.7,133.65) ; CB390.2 24.7,129.67 v4(24.7,129.65) ; CB398.2 v4(27.7,129.65) ; v4(56.7,128.65) 56.21,128.16 CB402.2 ; CB536.1 50.21,119.15 v4(50.7,119.65) ; v4(32.7,133.65) 32.7,133.66 CB355.1 ; CB365.1 36.18,133.16 v4(35.7,133.65) ; v4(32.7,127.65) 32.7,127.66 CB401.1 ; CB486.2 56.7,122.64 v4(56.7,122.65) ; v4(29.7,127.65) 29.7,127.65 CB414.1 ; CB399.2 31.19,129.16 v4(30.7,129.65) ; CB419.2 26.7,127.64 v4(26.7,127.65)
  vias: v1(99.51,142.01) v1(100.02,142.67) v1(100.83,142.95) v1(100.83,142.06) v1(101.77,142.97) v1(101.77,142.09) v1(102.56,142.97) v1(102.58,142.11) v1(103.5,143) v1(103.52,142.14) v1(104.36,143.02) v1(104.36,142.14) v1(105.83,143.05) v1(105.83,142.16) v1(107.66,143.05) v1(107.66,142.16) v1(108.42,143.08) v1(108.42,142.19) v1(118.58,148.31) v1(118.58,147.42) v1(119.47,148.31) v1(119.47,147.42) v1(120.36,148.31) v1(120.36,147.42) v1(121.12,148.31) v1(121.12,147.42) v1(122.01,148.31) v1(122.01,147.42) v1(123.03,148.31) v1(123.03,147.42) v1(123.92,148.31) v1(123.92,147.42) v2(105.98,144.47) v2(106.39,140.5)
VDD1P2_DDR_MARGIN_HIGH: length 11.3
  TOP w0.127: P1.D4 v4(97.29,212.46)
  TOP w0.508: R72.2 v1(92.1,205.59)
  BOTTOM w0.127: v4(97.29,212.46) 96.77,211.94 96.77,208.91 94.77,206.92 v2(94.64,206.92) 93.87,206.14 92.66,206.14 v1(92.1,205.59)
VDD1P2_DDR_MARGIN_HIGH_D: length 70.9
  TOP w0.508: QB4.D 85.88,204.22 v1(86.77,203.33) ; R611.1 132.11,173.14 v1(132.17,173.2)
  S14 w0.508: v1(132.17,173.2) 132.58,173.61 132.58,182.17 131.36,183.39 131.36,185.02 125.34,191.04 118.22,191.04 111.37,197.89 95.57,197.89 90.25,203.21 86.88,203.21 v1(86.77,203.33)
  BOTTOM w0.127: v1(86.77,203.33) 86.74,203.3 86,203.3 v2(85.95,203.25)
VDD1P2_DDR_MARGIN_HIGH_R: length 6.4
  TOP w0.127: QB4.G 88.08,203.5 C42.2 90.24,203.93 R67.1 R72.1 v1(92.1,203.11)
  BOTTOM w0.127: v1(92.1,203.11) 91.47,202.47 v2(90.96,202.47)
VDD1P2_DDR_MARGIN_LOW: length 7.4
  TOP w0.127: P1.B10 95.33,219.42 91.42,219.42 v1(91.15,219.68) 90.34,219.68 R112.2
  BOTTOM w0.127: v1(91.15,219.68) 91.34,219.87 v2(92.48,219.87)
VDD1P2_DDR_MARGIN_LOW_D: length 98.8
  TOP w0.508: v1(130.65,172.25) 130.53,172.13 R601.1 ; v1(80.02,222.34) 79.95,222.41 QB5.D
  S14 w0.254: v1(130.65,172.25) 130.99,172.59 130.99,181.86 129.77,183.08 129.77,184.15 127.21,186.71 116.19,186.71 109.02,193.88 91.75,193.88 87.05,198.58 84.19,198.58 76.39,206.38 76.39,219.3 79.43,222.34 v1(80.02,222.34)
  BOTTOM w0.254: v2(131.66,171.62) 131.28,171.62 v1(130.65,172.25)
VDD1P2_DDR_MARGIN_LOW_R: length 12.7
  TOP w0.127: R112.1 87.73,219.87 C97.2 87.51,220.92 R100.1 86.91,221.89 86.68,222.12 84.6,222.12 83.16,223.56 QB5.G 81.3,223.56 v1(80.98,223.24)
  BOTTOM w0.127: v2(82.55,224.54) 81.25,223.24 v1(80.98,223.24)
VDD1P2_DDR_MON: length 10.5
  TOP w0.254: U7.59 237.59,220.74 C45.1 237.74,221.22 237.97,221.45 239.53,221.45 R68.1 v1(240.49,223.18)
  BOTTOM w0.127: v1(240.49,223.18) 239.85,223.81 238.92,223.81 238.28,224.44 v2(238.28,225.4)
VDD1P2_DDR_VDD: length 150.4
  TOP w0.254: U15.L9 61.9,167.21 v4(61.56,167.21)
  TOP w0.381: C198.1 26.46,159.13 v4(26.42,159.09) ; C80.2 v1(30.09,179.22) ; C142.2 v1(75.2,168.27) ; C79.2 v1(29.05,179.19) ; v4(31.37,159.09) 31.69,159.41 C186.1 ; v4(69.1,165.62) U15.J1 ; v4(58.56,165.62) U14.J1 ; v4(69.1,167.22) U15.L1 ; v1(64.48,178.92) C92.2 ; v1(26,179.22) C76.2 C75.1 ; C172.1 33.88,162.41 v4(34.57,163.09) ; v4(94.49,163.22) U17.G7 ; v4(82.34,171.22) U16.T9 ; v4(89.54,167.22) U16.L1 ; v4(58.56,160.82) U14.D1 ; C87.2 55.34,178.58 v1(55.67,178.92) ; v4(89.54,170.42) U16.R1 ; v4(92.89,167.22) U17.L9 ; U15.B9 v4(61.9,159.22) ; v4(92.89,165.62) U17.J9 ; v4(51.36,167.22) U14.L9 ; v4(29.77,170.29) 29.55,170.08 C128.1 ; v1(46.74,165.22) 46.74,165.47 46.32,165.88 R269.2 ; v4(87.94,159.22) U16.B3 ; v4(100.08,165.62) U17.J1 ; v4(92.89,171.22) U17.T9 ; v4(89.54,165.62) U16.J1 ; v1(75.61,172.67) 75.2,173.07 C119.1 C113.2 ; v1(75.2,172.11) C126.2 C130.2 v1(75.2,169.62) ; v4(89.54,160.82) U16.D1 ; C178.1 29.25,161.26 29.77,160.74 v4(29.77,160.69) ; v4(51.36,165.62) U14.J9 ; v4(82.34,165.62) U16.J9 ; C177.1 23.88,162.15 v4(24.82,163.09) ; v4(69.1,170.42) U15.R1 ; v1(31.11,179.22) C81.2 C82.2 ; v4(100.08,170.42) U17.R1 ; v4(82.34,159.22) U16.B9 ; v4(61.86,165.62) 61.9,165.62 U15.J9 ; v4(83.15,166.42) U16.L9 ; v4(30.57,164.69) 30.51,164.74 C154.1 ; v4(100.08,160.82) U17.D1 ; v4(69.1,160.82) U15.D1 ; v1(60.42,178.92) C88.1 ; v4(92.89,159.22) U17.B9 ; v4(51.36,159.22) U14.B9 ; v1(70.58,178.94) C85.1 ; R301.2 27.53,164.89 C161.1 26.61,164.51 v4(26.43,164.69) ; v4(61.9,171.22) U15.T9 ; v4(51.36,171.22) U14.T9 ; R250.2 77.31,168.2 v1(76.8,168.2) ; v4(58.56,167.22) U14.L1 ; v4(56.96,159.22) U14.B3 ; v1(68.55,178.92) C96.2 ; v1(27.02,179.19) C77.2 C78.1 ; v4(83.94,163.22) U16.G7 ; v4(98.48,159.22) U17.B3 ; v4(52.96,163.22) U14.G7 ; U15.B3 v4(67.5,159.22) ; C73.2 v1(22.06,179.22) ; v4(63.5,163.22) U15.G7 ; v4(58.56,170.42) U14.R1 ; C74.1 v1(22.95,179.19) ; v4(100.08,167.22) U17.L1
  BOTTOM w0.127: v2(70.58,180.25) v1(70.58,178.94)
  BOTTOM w0.305: CB236.1 84.58,162.49 83.94,163.12 v4(83.94,163.22)
  BOTTOM w0.381: CB296.1 40.15,159.48 v1(40.1,159.43) ; v4(92.89,159.22) 92.7,159.03 CB297.1 ; v1(64.48,178.92) C92.2 CB84.2 ; v4(69.1,165.62) 69.29,165.42 CB206.1 ; CB285.1 CB274.1 53.61,162.56 v4(52.96,163.22) ; C88.1 v1(60.42,178.92) ; v4(61.86,165.62) 61.59,165.62 61.2,165.24 61.2,164.9 RB119.2 ; CB185.1 89.76,167 v4(89.54,167.22) ; CB279.1 CB292.1 87.65,159.22 v4(87.94,159.22) ; v4(63.5,163.22) 63.52,163.2 CB231.1 64.48,162.79 64.23,162.53 CB262.1 ; v4(30.57,164.69) 30.17,165.09 UB6.J1 ; CB270.1 100.91,161.64 v4(100.08,160.82) 100.28,160.63 C169.1 ; CB287.1 81.52,160.04 v4(82.34,159.22) ; UB6.L9 v4(36.17,167.09) ; CB122.1 81.85,171.42 82.06,171.22 v4(82.34,171.22) ; v4(89.54,170.42) 89.81,170.15 90.34,170.15 CB134.1 ; UB6.J9 v4(36.97,164.69) ; v4(100.08,167.22) 100.43,167.22 100.6,167.38 CB181.1 101.09,167.41 RB104.2 ; v4(69.1,167.22) 69.18,167.3 CB182.1 ; CB221.1 18.38,164.18 18.63,164.44 v4(18.63,164.79) 18.63,164.92 18.92,165.21 19.51,165.21 UB5.J1 ; CB198.1 CB199.1 50.91,166.06 v4(51.36,165.62) ; CB265.1 CB280.1 50.13,160.63 50.64,160.12 50.64,159.94 v4(51.36,159.22) ; CB66.2 v1(84.42,179.04) ; UB6.D1 v4(29.77,160.69) ; v4(20.02,167.09) 19.63,166.7 UB5.L1 ; UB6.L1 v4(29.77,167.09) ; CB172.1 92.82,167.28 v4(92.89,167.22) ; v4(89.54,165.62) 90.07,165.09 CB217.1 ; v4(31.37,159.09) UB6.B3 ; UB6.B9 v4(36.97,159.89) ; CB173.1 50.05,167.96 CB175.1 50.63,167.94 v4(51.36,167.22) ; v1(72.48,162.86) 72.41,162.79 CB244.1 RB120.2 RB117.2 ; UB6.T9 37.11,170.69 37.26,170.84 38.22,170.84 v1(39.34,171.96) 39.69,171.6 CB118.1 CB119.1 ; UB5.G7 v4(24.82,163.09) ; UB5.B3 v4(20.82,159.89) ; CB67.1 v1(85.44,179.04) ; v4(56.96,159.22) 56.76,159.03 CB300.1 ; UB5.L9 v4(26.42,167.09) ; UB5.R1 19.4,169.67 16.75,169.67 v4(16.7,169.72) 16.15,170.28 CB139.1 ; CB197.1 81.68,165.25 82.05,165.62 v4(82.34,165.62) ; UB5.B9 v4(26.42,159.09) ; C85.1 v1(70.58,178.94) ; CB73.2 v1(81.32,179.04) ; UB5.D1 19.3,161.42 v1(16.42,161.42) 15.82,161.42 CB273.1 15.41,160.57 15.18,160.35 13.78,160.35 12.21,161.92 RB124.2 RB122.2 ; v4(92.89,171.22) 92.71,171.04 CB124.1 ; UB5.J9 v4(26.43,164.69) ; CB277.1 CB276.1 58.85,160.53 v4(58.56,160.82) ; CB284.1 67.05,159.66 v4(67.5,159.22) ; CB214.1 40.25,164.69 v1(40,164.95) ; RB108.2 42.76,166.85 v1(43.23,167.32) ; v4(94.49,163.22) 94.61,163.35 CB229.1 ; CB74.1 v1(82.34,179.04) ; CB263.1 69.92,161.64 v4(69.1,160.82) ; CB288.1 97.85,159.22 v4(98.48,159.22) ; v4(51.36,171.22) 50.8,170.66 CB131.1 ; RB46.2 97.78,176.88 v1(97.93,176.73) ; CB258.1 v1(77.49,161.44) ; v4(92.89,165.62) 92.43,165.62 92.19,165.38 CB193.1 ; CB205.1 100.23,165.48 v4(100.08,165.62) ; v4(26.45,171.09) 26.05,170.69 UB5.T9 ; C96.2 v1(68.55,178.92) ; v1(40.02,165.86) 40.17,165.71 CB196.1 ; v4(29.77,170.29) UB6.R1 ; v4(34.57,163.09) UB6.G7 ; CB65.2 v1(83.4,179.04)
  BOTTOM w0.508: RB104.2 102.95,167.41 v1(102.96,167.42) ; RB94.2 100.33,170.66 v4(100.08,170.42)
  vias: v1(43.91,166.72) v1(44.61,165.77) v1(44.67,166.72) v1(45.3,165.77) v1(45.37,166.72) v1(62.6,156.56) v1(62.88,157.25) v1(63.54,157.53) v1(75.38,165.78) v1(79.01,165.61) v1(111.6,173.71) v1(111.6,172.69) v1(111.6,171.68) v1(111.6,170.66) v1(112.36,173.71) v1(112.36,172.69) v1(112.36,171.68) v1(112.36,170.66) v1(113.12,173.71) v1(113.12,172.69) v1(113.12,171.68) v1(113.12,170.66) v1(113.88,173.71) v1(113.88,172.69) v1(113.88,171.68) v1(113.88,170.66) v2(114.65,172.37)
VDD1P2_DDR_VDDQ: length 118.2
  TOP w0.381: v4(26.42,160.69) 26.56,160.55 C179.1 ; v4(61.9,158.42) U15.A9 ; v4(68.3,162.42) U15.F2 ; C204.1 29.91,158.14 v4(29.77,158.29) ; v4(51.36,158.42) U14.A9 ; C184.1 29.59,160.12 29.77,159.94 v4(29.77,159.89) ; v4(92.89,163.22) U17.G9 ; v4(92.86,160.82) 93.26,161.22 U17.D9 ; U16.A9 v4(82.34,158.42) 80.56,158.42 80.16,158.01 C200.1 ; v4(29.77,163.09) 29.76,163.09 C166.1 ; C152.1 31.33,164.72 v4(31.37,164.69) ; v4(26.42,163.09) 26.66,162.86 27.93,162.86 C165.1 ; v1(57.7,157.6) 57.9,157.6 58.39,158.09 58.39,158.59 U14.A1 ; v4(82.34,163.22) U16.G9 ; v4(51.36,160.82) U14.D9 ; v4(89.54,163.22) U16.G1 ; v4(92.89,158.42) U17.A9 ; v4(52.16,165.62) U14.J8 ; v4(68.3,165.62) U15.J2 ; v4(99.29,162.42) U17.F2 ; v4(58.56,160.02) U14.C1 ; v4(25.63,164.69) 25.93,164.99 C151.1 ; v4(69.1,160.02) U15.C1 ; v4(52.16,162.42) U14.F8 ; v4(93.69,162.42) U17.F8 ; U16.J8 v4(83.14,165.62) ; v4(57.76,162.42) U14.F2 ; v4(88.74,162.42) U16.F2 ; v4(62.7,162.42) U15.F8 ; v4(51.36,163.22) U14.G9 ; v4(69.1,163.22) U15.G1 ; U16.A1 v4(89.54,158.42) ; v4(58.56,163.22) U14.G1 ; C203.1 26.15,158.02 v4(26.45,158.32) ; U16.F8 v4(83.14,162.42) ; v4(62.7,165.62) U15.J8 ; v4(99.29,165.62) U17.J2 ; v4(61.9,163.22) U15.G9 ; v4(82.34,160.82) U16.D9 ; v4(100.08,158.42) U17.A1 ; v4(69.1,158.42) U15.A1 ; v4(61.9,160.82) U15.D9 ; v4(89.54,160.02) U16.C1 ; v4(57.76,165.62) U14.J2 ; v4(88.74,165.62) U16.J2 ; v4(93.69,165.62) U17.J8 ; v4(100.08,163.22) U17.G1 ; v4(100.08,160.02) U17.C1
  BOTTOM w0.305: CB218.1 88.23,164.74 CB213.1
  BOTTOM w0.356: CB230.1 65.75,163.22 66.13,163.6 v4(66.13,164.82)
  BOTTOM w0.381: v4(92.86,160.82) 92.79,160.88 CB268.1 ; CB282.1 40.3,160.5 v1(40.07,160.27) 39.25,161.09 UB6.D9 ; v4(61.9,163.22) 61.77,163.34 CB243.1 CB242.1 CB241.1 58.68,163.34 v4(58.56,163.22) ; CB232.1 v1(40.07,163.55) 40.01,163.49 UB6.G9 ; CB253.1 50.2,162.41 50.58,162.02 50.58,161.59 v4(51.36,160.82) ; UB6.A1 v4(29.77,158.29) ; CB312.1 40.56,158.7 v1(40.02,158.7) ; CB278.1 89.95,160.43 v4(89.54,160.02) ; CB260.1 CB261.1 98.08,162.22 98.28,162.42 v4(99.29,162.42) ; v4(100.08,158.42) 100.14,158.36 CB313.1 100.17,157.71 100.23,157.71 100.8,157.13 v2(101.25,157.13) ; v1(107.79,170.66) 107.87,170.66 107.87,171.47 107.73,171.6 CB334.1 107.21,171.6 106.9,171.3 v1(106.9,170.66) ; v4(82.34,160.82) 82.1,161.06 CB267.1 CB266.1 ; CB233.1 92.61,162.94 v4(92.89,163.22) ; v4(68.3,162.42) 68.26,162.45 66.77,162.45 CB257.1 66.31,162.45 65.75,161.9 CB271.1 CB230.1 ; UB5.D9 v4(26.42,160.69) ; CB235.1 69.42,163.55 v4(69.1,163.22) ; v4(83.14,165.62) 83.25,165.51 CB210.1 ; v1(39.89,158.01) 40.45,157.45 CB318.1 ; CB315.1 92.8,158.34 v4(92.89,158.42) ; v4(93.69,165.62) 93.69,165.61 CB211.1 ; UB5.G9 v4(26.42,163.09) ; CB247.1 v1(39.97,162.53) ; v4(62.7,165.62) 62.8,165.51 CB208.1 ; UB5.F2 v4(20.03,162.29) ; CB209.1 67.99,165.31 v4(68.3,165.62) ; UB6.F2 v4(30.57,162.29) ; UB5.J8 v4(25.63,164.69) ; CB228.1 82.22,163.35 v4(82.34,163.22) ; v4(51.36,158.42) 50.93,158.85 CB308.1 CB291.1 ; CB212.1 98.82,165.16 v4(99.29,165.62) ; CB281.1 69.71,160.63 v4(69.1,160.02) ; UB6.A9 v4(37.13,159.26) ; CB254.1 18.58,162.28 v4(18.63,162.33) 18.63,162.76 19.36,163.49 UB5.G1 ; UB6.J2 v4(31.37,164.69) ; UB5.A1 18.29,157.35 v1(17.85,157.35) 16.9,157.35 16.68,157.58 CB316.1 ; v4(57.76,162.42) 57.74,162.41 57.01,162.41 56.3,161.7 CB275.1 CB286.1 ; v4(89.54,158.42) 89.45,158.32 CB314.1 ; v4(100.08,160.02) 100.49,159.61 CB290.1 ; CB317.1 69.94,157.58 v4(69.1,158.42) ; UB5.A9 26.08,158.69 v4(26.45,158.32) ; CB213.1 88.28,165.08 88.74,165.54 v4(88.74,165.62) ; CB234.1 100.71,162.6 v4(100.08,163.22) 100.48,163.61 CB330.1 ; v4(20.03,164.69) UB5.J2 ; v4(51.36,163.22) 51.23,163.35 CB227.1 CB226.1 ; v4(89.54,163.22) 89.55,163.22 CB246.1 ; UB6.G1 v4(29.77,163.09) ; v4(82.34,158.42) 81.95,158.42 CB299.1 ; UB6.F8 v4(35.36,162.29) ; UB6.C1 v4(29.77,159.89) ; v4(20.03,159.89) UB5.C1 ; UB5.F8 v4(25.63,162.29) ; UB6.J8 v4(36.17,164.69)
  vias: v1(43.97,162.72) v1(43.97,161.96) v1(43.97,161.2) v1(44.86,162.72) v1(44.86,161.96) v1(44.86,161.2) v1(45.75,162.72) v1(45.75,161.96) v1(45.75,161.2) v1(57.7,156.92) v1(57.7,156.23) v1(57.7,155.45) v1(106.9,169.64) v1(106.9,168.76) v1(107.41,165.45) v1(107.79,169.64) v1(107.79,168.76) v1(108.3,165.45) v1(108.68,169.64) v1(108.68,168.76) v1(108.8,170.66) v1(109.19,167.49) v1(109.19,166.47) v1(109.19,165.45) v1(109.69,169.64) v1(109.69,168.76) v1(109.82,170.66)
VDD1P8: length 82.8
  TOP w0.254: 65.88,114.15 C374.1 66.41,114.71 ; U23.18 117.92,143.37 v1(117.41,143.88) 117.27,143.73 U23.19 ; R3.2 v1(228.75,230.85) ; C474.1 7.99,95.35 ; C478.1 7.94,94.33 ; v1(116.4,143.75) 116.62,143.52 U23.20 ; U23.1 114.53,141.24 v1(114.48,141.19) ; C471.1 7.92,96.37 ; C461.1 8.02,97.38
  TOP w0.381: v1(117.41,143.88) C211.1 117.98,144.56 118.18,144.76 118.18,145.25 118.4,145.47 R416.1 ; C226.1 21.73,150.27 ; C226.1 22.44,149.63 ; C226.1 23.33,150.27 ; v1(116.4,143.75) C212.1 115.6,144.56 115.54,144.5 v1(115.54,143.8) ; C225.1 20.8,150.27 ; C225.1 19.55,150.27 ; C225.1 20.16,149.6 ; CONN10.1 80.15,151.36 ; CONN10.1 78.27,151.36 ; CONN10.1 79.21,152.3 ; 39.26,144.25 C265.1 38.52,143.36
  TOP w0.508: C918.1 LB110.1 144.8,187.57 v1(144.56,187.81) ; 7.97,135.1 C277.1 7.4,135.68 ; C267.1 57.69,142.85 ; C267.1 58.77,143.8 ; C267.1 59.72,142.85 ; C917.1 146.26,187.88 L109.1
  S5 w0.254: v1(228.75,230.85) 228.75,229.24 228.19,228.68 228.19,225.5 226.1,223.41 226.1,213.59 225.54,213.04 209.11,213.04 205.69,216.46 204.19,216.46 v1(202.58,218.07)
  BOTTOM w0.127: v2(164.24,181.52) 163.1,181.52 163.03,181.46
  BOTTOM w0.508: v1(154.43,168.38) 154,168.81 L108.1 153.38,168.43 v1(154.11,167.7) ; CB1058.1 199.98,218.34 L95.1 ; C236.1 114.86,140.82 v1(114.48,141.19)
  vias: v1(6.96,138.48) v1(6.96,137.72) v1(7.72,138.48) v1(7.72,137.72) v1(8.5,138.58) v1(8.62,96.14) v1(8.64,95.45) v1(8.68,94.75) v1(9.36,96.11) v1(9.36,95.43) v1(9.36,94.74) v1(27.2,152.82) v1(27.2,151.99) v1(27.2,151.1) v1(28.73,152.77) v1(28.73,151.94) v1(115.54,142.97) v1(143.1,187.81) v1(143.81,187.8) v1(162.4,182.26) v1(162.39,181.47) v1(172.69,178.03) v1(172.69,177.2) v1(172.66,176.36) v1(173.3,177.51) v1(201.19,218.07) v1(201.87,218.08)
VDD1P8_FB: length 6.9
  TOP w0.254: U23.16 v1(119.22,143.49) 118.94,143.78 R416.2 R394.2 R385.2 121.68,144.56 121.86,144.38 R347.2
  BOTTOM w0.254: v2(118.27,143.36) 119.08,143.36 v1(119.22,143.49)
VDD1P8_FB_H: length 4.2
  TOP w0.254: R346.2 122.52,145.43 v1(122.52,146.47) 121.53,145.47 R385.1
  BOTTOM w0.254: v1(122.52,146.47) 121.95,145.9 v2(121.63,145.9)
VDD1P8_FB_L: length 3.9
  TOP w0.254: R347.1 123.46,144 123.23,143.77 122.8,143.77 122.55,143.52 R348.2 122.12,143.11 121.7,143.54 v1(121.67,143.54)
  BOTTOM w0.254: v1(121.67,143.54) 121.66,143.54 121.64,143.52 120.77,143.52 v2(120.74,143.55)
VDD1P8_MARGIN_HIGH: length 33.1
  TOP w0.127: R132.2 121.08,203.85 121,203.93 v1(121,205.65) ; P1.F8 v4(99.29,216.46)
  S9 w0.127: v4(99.29,216.46) 99.34,216.46 99.73,216.08 99.73,214.22 100.04,213.9 104.61,213.9 105.06,213.46 105.06,210.92 106.07,209.9 113,209.9 116.61,206.28 117.88,206.28 118.84,205.33 120.68,205.33 v1(121,205.65)
  BOTTOM w0.127: v1(121,205.65) 121,204.54 v2(120.99,204.53)
VDD1P8_MARGIN_HIGH_D: length 75.9
  TOP w0.127: v1(128.09,203.37) 128.24,203.37 128.37,203.51 QB7.D ; v1(129.89,149.01) 126.28,145.4 R346.1
  S12 w0.127: v1(129.89,149.01) 141.13,160.25 141.13,166.68 142.14,167.69 142.14,183.28 136.78,188.64 136.78,193.38 128.09,202.06 v1(128.09,203.37)
  BOTTOM w0.127: v1(128.09,203.37) 128.09,202.29 v2(128.06,202.26)
VDD1P8_MARGIN_HIGH_R: length 6.1
  TOP w0.127: R132.1 R137.1 123.42,204.76 C115.2 124.59,205.12 v1(125,205.52) 125.22,205.75 QB7.G
  BOTTOM w0.127: v1(125,205.52) 125.99,205.52 v2(126,205.53)
VDD1P8_MARGIN_LOW: length 22.4
  TOP w0.127: v1(126.88,218.99) 126.81,218.92 R287.2 ; P1.AA16 115.29,225.46 118.7,225.46 v1(118.73,225.49)
  S5 w0.127: v1(118.73,225.49) 118.73,225.8 119.79,226.86 123.13,226.86 127.81,222.18 127.81,219.91 v1(126.88,218.99)
  BOTTOM w0.127: v2(128.62,219.3) 128.43,219.49 127.38,219.49 v1(126.88,218.99)
VDD1P8_MARGIN_LOW_D: length 91.6
  TOP w0.254: R348.1 125.32,143.11 126.81,144.6 130.62,144.6 v1(134.97,148.94) ; Q1.D v1(134.43,216.41)
  S12 w0.254: v1(134.97,148.94) 138.56,152.53 138.56,155.71 142.76,159.91 142.76,164.61 142.9,164.76 142.9,183.59 137.62,188.88 137.62,195.33 137.21,195.74 137.21,203.3 134.88,205.64 134.88,209.5 135.6,210.22 135.6,215.33 134.53,216.41 v1(134.43,216.41)
  BOTTOM w0.127: v2(135.79,216.57) 134.6,216.57 v1(134.43,216.41)
VDD1P8_MARGIN_LOW_R: length 6.8
  TOP w0.127: v1(131.28,216.44) 130.89,216.83 Q1.G 129.12,217.36 C145.2 127.94,217.31 R288.1 R287.1
  BOTTOM w0.127: v2(132.87,216.44) 131.29,216.44 v1(131.28,216.44)
VDD1P8_MON: length 10.5
  TOP w0.254: v1(232.31,222.98) 232.31,223.3 232.08,223.54 U7.6 232.08,224.42 230.82,225.68 229.04,225.68 228.8,225.93 C17.1 228.9,226.77 229.09,226.77 229.33,227.01 229.33,228.54 228.85,229.02 R3.1
  BOTTOM w0.127: v1(232.31,222.98) 232.95,222.35 v2(232.95,221.9)
VDD1P8_PG: length 13
  TOP w0.127: R421.2 v1(118.68,136.13) 118.57,136.24 U23.9
  S5 w0.127: v1(118.68,136.13) 118.68,136.46 117.63,137.51 114.53,137.51 CONN16.1
  BOTTOM w0.254: v1(118.68,136.13) 118.46,135.9 v2(118.46,134.91)
VDD1P8_SS: length 5.4
  TOP w0.254: U23.15 121.49,141.24 122.22,141.97 C193.1 122.55,141.61 v1(123.11,141.05)
  BOTTOM w0.254: v1(123.11,141.05) 122.44,140.39 v2(121.56,140.39)
VDD1P8_VIN: length 3.6
  TOP w0.508: C213.1 114.11,136.27 ; C231.1 114.3,138.3 ; C223.1 114.24,137.28
  BOTTOM w0.254: v2(116.81,136.12) 117.53,136.12 v1(117.8,136.38)
VDD1P25: length 19.6
  TOP w0.381: CONN45.1 102.25,95.04 ; CONN45.1 100.37,95.04 ; CONN45.1 101.31,94.1 ; CONN45.1 101.31,95.98 ; C459.1 99.66,96.67 v1(99.46,96.47) ; v1(98.01,94.71) C481.1 97.65,94.03 97.32,93.7 97.32,91.94 97.01,91.63 91.9,91.63 91.53,92 R801.2 ; v1(98.78,94.73) 99.03,94.49 C482.1 99.71,94.03
  BOTTOM w0.381: 100.37,95.04 CONN45.1 ; CONN45.1 102.25,95.04 ; CONN45.1 101.31,95.98 ; CONN45.1 101.31,94.1
  vias: v1(87.34,94.46) v1(88.1,94.46) v1(88.87,95.91) v1(88.87,95.22) v1(88.87,94.51) v1(89.63,95.91) v1(89.63,95.22) v1(89.63,94.46) v1(97.07,96.75) v1(97.53,96.16) v1(97.93,96.77) v1(98.36,96.19) v1(98.54,97.43) v1(98.8,96.75) v1(100.22,96.31) v2(86.27,91.13)
VDD1P25_FB: length 7.2
  TOP w0.254: U47.16 93.79,94.72 94.25,94.25 R795.2
  TOP w0.305: 94.25,94.1 R795.2
  TOP w0.381: 94.25,94.1 93.44,94.1 92.7,94.84 v1(91.53,94.84) R801.1
  BOTTOM w0.254: v1(91.53,94.84) 91.66,94.71 v2(92.5,94.71)
VDD1P25_FB_H: length 2.3
  TOP w0.254: R804.1 95.82,92.23 v1(95.9,92.3) 95.98,92.23 R805.2
  BOTTOM w0.254: v1(95.9,92.3) 96.64,92.3 v2(96.71,92.23)
VDD1P25_FB_L: length 2.4
  TOP w0.254: R802.2 v1(93.51,92.23) 94.2,92.23 R803.1
  BOTTOM w0.254: v2(92.55,92.23) v1(93.51,92.23)
VDD1P25_MARGIN_HIGH: length 18.5
  TOP w0.127: R312.2 126.49,219.96 v1(125.82,220.63) 125.82,223.68 122.58,226.93 119.93,226.93 119.59,226.59 116.16,226.59 P1.AB18
  BOTTOM w0.127: v1(125.82,220.63) 125.34,221.12 125.34,221.15 124.84,221.65 v2(123.73,221.65)
VDD1P25_MARGIN_HIGH_D: length 167.4
  TOP w0.127: R805.1 96.61,93.32 v1(96.1,93.83)
  TOP w0.254: Q3.D v1(134.55,219.9)
  S9 w0.127: v1(106.82,98.14) 106.82,97.74 102.2,93.11 96.82,93.11 v1(96.1,93.83)
  S12 w0.254: v1(136.36,148.69) 139.47,151.8 139.47,156.05 143.21,159.79 143.21,164.53 143.28,164.6 143.28,172.47 144.55,173.74 144.55,182.36 143.28,183.63 143.28,183.75 142.25,184.79 142.25,186.27 138.1,190.42 138.1,205.37 137.13,206.35 137.13,209.59 136.3,210.41 136.3,218.15 v1(134.55,219.9)
  S14 w0.127: v1(136.36,148.69) 136.36,139.16 132.05,134.85 132.05,114.54 125.44,107.93 125.44,102.79 122.74,100.09 119.59,100.09 117.58,98.08 115.34,98.08 114.9,98.52 114.9,98.87 114.65,99.12 107.62,99.12 106.82,98.32 v1(106.82,98.14)
  BOTTOM w0.127: v2(95.24,93.83) v1(96.1,93.83)
VDD1P25_MARGIN_HIGH_R: length 13.3
  TOP w0.127: R312.1 R313.1 129.04,220.87 C167.2 130.94,220.85 Q3.G 132.02,220.85 v1(132.11,220.76)
  BOTTOM w0.127: v2(138.27,216.51) 136.24,218.54 134.33,218.54 v1(132.11,220.76)
VDD1P25_MARGIN_LOW: length 22.3
  TOP w0.127: P1.AB16 119.21,224.96 v1(119.7,225.45) ; R323.2 v1(126.84,215.81)
  S5 w0.127: v1(126.84,215.81) 126.2,216.44 126.2,219.62 126.84,220.25 126.84,221.65 123.73,224.76 120.39,224.76 v1(119.7,225.45)
  BOTTOM w0.127: v2(128.62,216.76) 127.79,216.76 v1(126.84,215.81)
VDD1P25_MARGIN_LOW_D: length 162.2
  TOP w0.127: v1(92.8,93.83) R802.1
  TOP w0.254: Q4.D v1(134.5,212.91)
  S9 w0.127: v1(106.7,98.93) 106.11,98.35 106.11,97.71 101.77,93.37 97.55,93.37 96.53,94.38 93.36,94.38 v1(92.8,93.83)
  S12 w0.254: v1(136.14,152.4) 137.75,154.01 137.75,155.73 142.38,160.35 142.38,164.94 142.52,165.09 142.52,183.44 137.21,188.75 137.21,194.45 136.73,194.94 136.73,203.17 134.5,205.41 v1(134.5,212.91)
  S14 w0.127: v1(106.7,98.93) 107.14,99.37 118.52,99.37 119.48,100.34 122.63,100.34 125.19,102.9 125.19,108.04 131.79,114.64 131.79,135.02 136.11,139.34 136.11,146.09 135.59,146.61 135.59,151.85 v1(136.14,152.4)
  BOTTOM w0.127: v1(92.8,93.83) 92.42,93.44 v2(91.08,93.44)
VDD1P25_MARGIN_LOW_R: length 6.4
  TOP w0.127: R323.1 R324.1 129.02,213.96 C174.2 129.13,213.86 Q4.G v1(132.07,213.86)
  BOTTOM w0.127: v2(133.12,214.09) 132.3,214.09 v1(132.07,213.86)
VDD1P25_PG: length 217.9
  TOP w0.127: U47.9 94.44,101.84 93.95,102.33 R732.1 91.48,103.15 CONN43.1
  TOP w0.254: v1(226.28,208.38) 227.74,208.38 228.29,208.93 R196.2
  S12 w0.254: CONN43.1 90.39,105.64 94.07,109.32 106.81,109.32 108.34,110.84 115.41,110.84 130.06,125.49 130.06,127.85 134.43,132.22 136.19,132.22 139.44,128.97 143.79,128.97 148.1,133.28 150.99,133.28 154.12,136.41 169.58,136.41 170.09,136.93 175.44,136.93 175.72,137.22 187.93,137.22 190.54,139.83 190.54,144.09 194.69,148.24 200.11,148.24 215.54,163.67 215.54,196.3 219.5,200.26 221.66,200.26 224.53,203.14 224.53,204.42 226.66,206.55 226.66,208 v1(226.28,208.38)
  BOTTOM w0.127: v1(226.28,208.38) 226.85,207.81 v2(227.17,207.81)
VDD1P25_PG_R: length 9.6
  TOP w0.254: R196.1 228.58,210.23 229.38,211.04 229.38,212.94 230.04,213.6 231.16,213.6 231.58,214.02 U7.42 231.58,215.53 v1(231.3,215.81)
  BOTTOM w0.127: v1(231.3,215.81) 232.18,216.7 v2(232.69,216.7)
VDD1P25_SS: length 3.6
  TOP w0.305: v1(91.35,96.93) 91.78,97.35 U47.15
  TOP w0.381: C467.1 90.95,96.16 91.35,96.57 v1(91.35,96.93)
  BOTTOM w0.381: v2(90.56,96.93) v1(91.35,96.93)
VDD1P25_VIN: length 3.7
  TOP w0.127: L91.2 v1(97.25,104.62)
  TOP w0.381: 96.49,103.1 C435.1 95.92,102.51 ; C428.1 96.49,104.11
  BOTTOM w0.127: v1(97.25,104.62) 97.31,104.68 v2(98.33,104.68)
VDD3P3: length 344.4
  TOP w0.127: R1127.1 v1(186.36,236.71) ; 199.41,237.99 C146.1
  TOP w0.254: U24.10 210.4,124.32 211.96,122.76 C191.2 ; 92.48,195.12 CB50.2 92.93,195.62 v1(93.25,195.93) ; 208.11,131.16 207.13,130.18 207.13,130.18 206.86,129.92 U24.23 ; v1(211.34,127.93) 211.44,128.03 212.07,128.03 C188.2 211.58,127.17 211.24,127.17 210.89,126.82 U24.15 ; U24.29 203.13,127.82 v1(202.83,128.12) ; R1.1 222.78,232.74 221.85,231.81 v1(216.11,231.81) ; U77.80 156.67,172.33 156.85,172.15 157.22,172.15 v1(157.36,172.29) ; U24.36 203.86,121.81 ; U24.5 206.86,122.47 ; U77.14 158.23,179.92 v1(158.3,179.92) ; U77.21 v1(156.67,184.72) ; v1(146.83,171.73) 147.17,172.07 U77.61
  TOP w0.381: v1(28.02,145.06) 27.98,145.03 C262.1 28.7,144.37 v1(28.7,144.38) ; 211.54,107.61 C473.1 211.74,108.47 v1(212.53,108.47) ; v1(12.09,122.74) 12.13,122.78 R619.2 R631.2 ; v1(201.87,120.94) 202,121.07 CB321.2 C230.2 203.86,121.24 203.86,121.81 ; RB1256.2 v1(163.16,185.65) 164.32,185.65 164.81,185.16 164.81,185 R1422.1 R1420.1 ; CB327.2 208.88,132.05 ; 208.88,132.05 208.88,131.93 208.11,131.16 ; 208.88,132.05 209.2,131.73 v1(209.2,131.16) ; R232.2 v1(9.05,170.27) ; v1(213.27,109.16) 213.4,109.29 C477.1 ; v1(159.17,238.8) CB975.1 159.74,239.49 159.82,239.41 161.15,239.41 161.23,239.49 UB16.24 ; 142.79,134.08 CONN32.1 143.73,133.14 ; v1(12.16,124.81) R595.2 R584.2 R575.2 R563.2 R552.2 R544.2 R528.2 R518.2 ; v1(207.61,121.45) 207.21,121.04 CB322.2 206.86,121.09 206.86,122.47 ; R66.2 66.62,193.54 66.26,193.9 65.07,193.9 65,193.83 ; R435.1 v1(205.68,133.62) ; C472.1 213.88,108.45 v1(213.3,108.45) ; RB730.1 v1(157.45,241.53) ; R658.2 R652.2 11.71,119.73 v1(11.65,119.67)
  TOP w0.508: 174.88,241.55 174.84,241.59 RB719.1 ; C191.2 212.25,122.47 211.99,122.21 v1(211.23,122.21) ; R1086.1 v1(192.74,212.94) ; RB705.1 174.97,243.75 ; R356.1 213.14,132.7 R384.1 212.14,133.68 v1(211.86,133.96) ; R1110.1 v1(181.28,236.73) ; RB700.1 174.85,244.83 ; R1088.2 v1(180.27,236.73) ; v1(150.82,187.51) 150.83,187.49 R1418.2 ; RB711.1 174.97,242.67 ; R528.2 12.13,130.91 v1(12.09,130.87) ; RB1274.1 v1(152.24,188.57) ; v1(173.13,231.56) 173.33,231.37 R1120.2 ; v1(199.67,212.13) 199.68,212.13 CB1057.1 ; 139.91,133.53 C308.2 ; R1100.1 186.65,210.16 v1(186.66,210.16) ; R1100.1 R1102.1 ; R1100.1 R1097.1 ; R1108.1 v1(182.3,236.73) ; v1(185.64,210.16) 185.63,210.16 R1097.1 ; CB1217.1 v1(42.55,204.1) ; CB1217.1 LB114.1 ; CB1217.1 v1(43.31,203.35) ; RB725.1 174.97,240.45 ; R1112.1 v1(175.97,232.89) ; RB729.1 174.72,238.29 ; RB17.2 v1(167.57,253.25) ; RB16.2 v1(168.59,253.25) ; v1(5.82,129.7) 6.31,129.7 R542.1 R526.2 ; v1(188.69,210.22) 188.68,210.23 R1082.1 R1102.1 ; CB10.2 91.95,184.53 92.15,184.33 CB6.1 ; R1116.1 v1(182.59,212.91) ; R182.2 v1(173.02,220.19) ; v1(93.88,185.85) 93.87,185.86 LB4.1 CB6.1 ; R1102.1 187.66,210.23 v1(187.67,210.22) ; R658.2 R651.1 R657.1 ; v1(149.86,187.53) 149.82,187.49 R1417.2 ; R1437.2 v1(109.53,182.31) ; R1092.2 173.04,224.25 v1(173.03,224.24) ; RB681.1 174.85,246.99 ; R340.1 v1(213.89,128.86) ; R1097.1 184.64,211 R1098.1 ; R424.1 207.64,133.61 v1(207.61,133.64) ; OSC7.1 145.79,162.71 CB1227.1 143.72,162.72 CB1224.1 142.73,163.47 142.51,163.68 LB116.1 141.71,162.68 v1(141.66,162.62) ; R1124.1 v1(173.04,222.22) ; R496.2 v1(160.91,132.32) ; LB115.1 108.93,176.69 ; RB1275.1 v1(153.76,188.57) ; v1(140.05,132.33) 140.03,132.32 C319.1 ; R1114.1 v1(181.57,210.2) ; CB1200.1 157.32,185.37 v1(156.67,184.72) ; CB6.1 v1(93.97,184.33) ; C153.2 v1(198.53,239.24) ; RB675.1 174.91,248.07 ; v1(138.52,214.67) RB1268.1 RB1266.1 ; CB3.1 v1(89.84,181.62) ; 174.91,239.37 RB740.1 ; RB691.1 174.84,245.91 ; R1084.1 v1(190.71,212.94)
  TOP w0.635: LB1.1 89.78,182.51 CB3.1
  S7 w0.508: v1(159.17,238.8) 159.16,238.81 159.16,240.77 158.4,241.53 v1(157.45,241.53)
  S9 w0.508: v1(12.09,122.74) 12.83,122.01 12.83,120.44 12.06,119.67 v1(11.65,119.67)
  S12 w0.254: v1(216.11,231.81) 216.11,232.63 209.63,239.12 208.46,239.12 207.77,239.81 199.99,239.81 v1(198.53,238.35)
  S12 w0.381: v1(143.13,191.33) 143.09,191.36 140.82,191.36 138.79,193.39 138.79,205.57 138.2,206.16 138.2,214.35 v1(138.52,214.67)
  S12 w0.508: v1(12.16,124.81) 12.77,124.2 12.77,123.42 v1(12.09,122.74)
  S14 w0.254: v1(145.25,132.31) 145.26,132.32 v1(160.91,132.32)
  S14 w0.508: v1(5.82,129.7) 5.96,129.56 9.07,129.56 9.53,130.03 11.56,130.03 12.09,130.56 v1(12.09,130.87) ; v1(174.27,236.95) 174.27,248 173.76,248.51 173.76,251.89 172.4,253.25 v1(168.59,253.25) 167.58,253.25 v1(167.57,253.25)
  S16 w0.508: v1(159.17,238.8) 163.09,238.8 164.11,237.78 170.46,237.78 171.29,236.95 v1(174.27,236.95)
  V18 w0.381: CONN32.1 144.67,134.08 ; CONN32.1 143.73,135.02 ; CONN32.1 142.79,134.08 ; CONN32.1 143.73,133.14
  V18 w0.508: 100.49,27.72 99.72,27.72
  BOTTOM w0.127: v2(170.22,177.43) 170.22,176.71 v1(169.95,176.44)
  BOTTOM w0.381: v1(74.37,25.14) RB632.1 ; v1(74.37,23.99) RB643.1 ; v1(74.37,31.99) RB577.1 ; v1(74.37,27.42) RB611.1 ; RB623.1 v1(45.55,27.4) ; UB12.24 136.9,23.82 137.33,23.39 CB949.1 v1(138.4,21.56) ; UB13.24 63.57,23.82 64,23.39 CB951.1 v1(64.74,21.46) ; v1(147.67,25.14) RB636.1 ; RB270.1 v1(161.6,31.97) ; v1(190.42,27.42) RB293.1 ; RB264.1 v1(161.6,25.11) ; RB597.1 v1(118.85,29.68) ; v1(89.84,181.62) 89.83,181.63 CB2.1 ; RB593.1 v1(45.55,30.83) ; v1(190.42,23.99) R1188.1 ; RB266.1 v1(161.6,27.4) ; RB601.1 v1(45.55,29.68) ; v1(43.01,21.81) 43.13,21.68 RB670.1 ; v1(147.67,29.71) RB598.1 ; RB584.1 v1(45.55,31.97) ; R1497.1 161.05,183.07 R1498.1 161.05,185.25 161.44,185.65 v1(163.16,185.65) ; RB268.1 v1(161.6,29.68) ; v1(74.37,26.28) RB624.1 ; R1128.1 196.89,229.6 v1(196.94,229.65) ; v1(147.67,28.57) RB607.1 ; v1(74.37,30.85) RB586.1 ; v1(190.42,30.85) RB296.1 ; RB664.1 v1(116.31,22.82) ; RB646.1 v1(118.85,23.97) ; v1(190.42,26.28) RB292.1 ; RB263.1 v1(161.6,23.97) ; RB627.1 v1(118.85,26.25) ; RB651.1 v1(45.55,23.97) ; RB610.1 v1(45.55,28.54) ; RB267.1 v1(161.6,28.54) ; v1(190.42,31.99) RB297.1 ; v1(147.67,30.85) RB590.1 ; v1(190.42,25.14) RB291.1 ; RB660.1 v1(43.01,22.82) ; RB606.1 v1(118.85,28.54) ; RB269.1 v1(161.6,30.83) ; v1(74.37,28.57) RB602.1 ; v1(147.67,27.42) RB615.1 ; RB635.1 v1(118.85,25.11) ; v1(190.42,28.57) RB294.1 ; RB614.1 v1(118.85,27.4) ; RB589.1 v1(118.85,30.83) ; v1(147.67,31.99) RB581.1 ; v1(74.37,29.71) RB594.1 ; v1(147.67,26.28) RB628.1 ; RB580.1 v1(118.85,31.97) ; v1(147.67,23.99) RB647.1 ; RB265.1 v1(161.6,26.25) ; UB8.24 179.62,23.82 180.05,23.39 CB883.1 v1(180.79,21.46) ; RB641.1 v1(45.55,25.11) ; RB631.1 v1(45.55,26.25) ; v1(190.42,29.71) RB295.1
  BOTTOM w0.508: v1(149.08,169.28) 148.78,169.57 148.78,170.24 149.2,170.66 L107.1 149.66,169.75 149.67,169.74 149.67,169.66 v1(149.93,169.41) ; v1(155.64,168.54) 155.66,168.57 R1368.1 ; RB658.1 v1(150.35,22.85) ; v1(157.36,172.29) 157.55,172.1 C940.1 ; v1(209.2,131.16) 210.02,131.99 CB323.2 ; v1(152.05,182.66) 152.05,182.82 151.35,183.51 L105.1 v1(151.16,182.54) ; v1(157.32,167.49) 157.56,167.73 R1414.2 ; R1094.1 v1(188.98,221.56) ; R1187.1 192.77,22.85 v1(192.94,23.02) ; C939.1 158.47,180.09 v1(158.3,179.92) 158.3,179.77 v2(157.57,179.04) ; C938.1 156.67,184.44 v1(156.67,184.72) 157.29,184.72 v2(157.64,184.38) ; RB654.1 76.66,22.85 v1(76.67,22.83) ; RB245.1 v1(161.48,22.83) ; RB673.1 v1(118.8,21.68) ; v1(145.63,170.03) CB1211.1 LB113.1 ; C941.1 146.74,171.64 v1(146.83,171.73) ; v1(150.82,187.51) 150.85,187.47 150.85,186.67 150.09,185.91 L106.1 149.86,186.03 v1(149.86,187.53) ; RB274.1 v1(161.53,21.66) ; RB659.2 v1(99.88,28.79)
  vias: v1(17.31,147.37) v1(17.31,146.66) v1(17.31,145.95) v1(28.7,145.14) v1(61.15,194.8) v1(62.08,194.78) v1(63.01,194.76) v1(91.89,196.42) v1(92.58,196.08) v1(109.19,175.74) v1(109.95,175.74) v1(140.81,133.96) v1(140.81,133.07) v1(140.81,132.31) v1(140.94,131.42) v1(140.94,130.53) v1(140.94,129.77) v1(141.06,123.67) v1(141.06,122.53) v1(141.06,121.38) v1(141.06,120.24) v1(141.06,118.97) v1(141.19,125.86) v1(141.19,124.85) v1(141.7,133.96) v1(141.7,133.07) v1(141.7,132.31) v1(141.7,131.42) v1(141.7,130.53) v1(141.7,129.77) v1(142.08,123.67) v1(142.08,122.53) v1(142.08,121.38) v1(142.08,120.24) v1(142.08,118.97) v1(142.21,125.86) v1(142.21,124.85) v1(142.57,133.96) v1(142.59,133.07) v1(142.59,132.31) v1(142.59,131.42) v1(142.59,130.53) v1(142.59,129.77) v1(142.97,125.96) v1(143.48,132.31) v1(143.48,131.42) v1(143.48,130.53) v1(143.48,129.77) v1(143.73,125.96) v1(144.11,170.03) v1(144.36,132.31) v1(144.36,131.42) v1(144.36,130.53) v1(144.87,170.03) v1(145.25,131.42) v1(175.03,237.78) v1(175.03,236.95) v1(197.39,238.35) v1(197.45,239.18) v1(197.89,212.13) v1(198.78,212.13) v1(211.85,109.9) v1(211.85,109.16) v1(212.53,109.9) v1(212.53,109.16) v1(212.56,107.76) v1(213.27,109.9) v1(213.32,107.76) v1(235.74,71.14) v1(235.77,72.56) v1(235.76,71.85)
VDD3P3_2304: length 6.7
  TOP w0.254: v1(243.81,124.69) 243.8,124.69 L25.1
  TOP w0.381: U37.6 242.87,121.34 242.99,121.46 C321.1 242.99,123.02 C320.1 242.78,124.65 L25.1
  BOTTOM w0.254: v1(243.81,124.69) 244.19,125.07 v2(244.19,125.58)
VDD3P3_MON: length 13.1
  TOP w0.254: R1.2 228.91,231.7 229.31,231.3 229.31,229.33 229.52,229.12 R14.1 230.81,228.38 230.81,227.06 230.4,226.66 C18.1 230.07,226.23 230.18,226.12 231.15,226.12 v1(232.06,225.21) 232.58,224.69 U7.5
  BOTTOM w0.127: v1(232.06,225.21) 231.8,225.46 v2(231.8,226.29)
VDD3P3_OCXO: length 42.6
  TOP w0.508: C313.1 v1(242.05,127.59) ; C313.1 242.77,126.23 L25.2 ; C313.1 242.77,128.26 v1(242.41,128.62) ; v1(242.54,133.07) 242.54,133.2 242.41,133.32 L32.1 242.41,134.59 v1(243.04,135.23)
  S12 w0.254: v1(242.05,127.59) 243.09,126.55 243.09,123.7 243.74,123.04 243.74,118.6 243.27,118.14 v1(242.54,118.14)
  S12 w0.508: v1(242.41,128.62) 242.05,128.26 v1(242.05,127.59)
  S12 w0.635: v1(234.35,145.68) v1(234.35,144.75) 234.35,144.74 237.9,141.2 237.9,141.13 v1(238.03,141.01) 240.12,138.91 240.12,131.8 242.41,129.51 v1(242.41,128.62)
  BOTTOM w0.254: v2(242.83,127.61) 242.07,127.61 v1(242.05,127.59)
  BOTTOM w0.381: 235.04,144.31 235.04,144.31 C332.1 ; R557.2 235.05,145.32 235.04,145.32
  BOTTOM w0.508: v1(242.54,118.14) 242.15,117.75 R674.1 ; R676.2 v1(238.03,141.01)
VDD3P3_XO: length 10.8
  TOP w0.508: v1(245.18,133.2) 244.8,132.81 C484.2 244.26,133.38 243.93,133.7 L32.2 ; OCXO1.3 247.33,130.31
  TOP w1.27: v1(259.08,111.76) v1(259.08,113.16) 258.75,113.48 OCXO2.6
  BOTTOM w0.381: v2(260.1,113.16) v1(259.08,113.16)
  vias: v1(245.16,133.96)
VDD5V_TOD_1PPS: length 13
  TOP w0.127: 239.79,94.41 239.69,94.51 L55.2
  TOP w0.254: U51.16 239.83,90.31 ; 239.8,94.41 239.98,94.23 242.9,94.23 243.32,93.81 R853.2
  TOP w0.381: 239.83,90.31 v1(239.8,90.33)
  TOP w0.508: C528.1 C525.1 C522.1 239.8,94.41 239.79,94.41
  BOTTOM w0.254: RB273.2 238.14,88.06 v2(237.9,88.3)
  BOTTOM w0.381: v1(239.8,90.33) 239.46,89.98 RB273.2
