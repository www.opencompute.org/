# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BCM88470_ROV1: length 193.9
  TOP w0.127: P1.R17 v4(109.29,226.46) ; v1(8.26,131.89) 8.22,131.93 R516.2 ; v4(23.7,126.65) U40.AJ34
  S7 w0.127: v4(23.7,126.65) 23.16,126.11 21,126.11 20.67,126.44 19.45,126.44 18.05,127.84 16.63,127.84 16.12,127.33 14,127.33 11.92,129.41 10.64,129.41 8.26,131.79 v1(8.26,131.89) 8.16,131.99 8.16,134.71 5.11,137.76 5.11,152.5 6.21,153.6 6.21,160.19 7.95,161.92 7.99,161.92 9.62,163.55 9.62,166.79 11.65,168.82 11.65,170.79 15.21,174.34 16.22,174.34 18.91,177.03 18.91,183.76 34.39,199.24 56.61,199.24 68.65,211.28 70.29,211.28 v1(70.95,211.94) 71,211.94 73.06,214 73.06,215.2 74.23,216.37 75.96,216.37 82.99,223.4 82.99,225.49 85.03,227.53 88.88,227.53 90.8,225.61 91.11,225.61 92.3,224.42 93.78,224.42 94.34,224.97 97.06,224.97 98.03,225.94 108.77,225.94 v4(109.29,226.46)
  BOTTOM w0.127: v1(70.95,211.94) 71.78,211.94 71.8,211.95 v2(71.9,211.95)
BCM88470_ROV2: length 206.9
  TOP w0.127: v1(8.63,132.61) 8.31,132.93 8.23,132.93 8.22,132.94 R508.2 ; v4(23.71,127.61) 23.74,127.61 U40.AK34 ; P1.V21 v4(112.29,230.46)
  S7 w0.127: v4(112.29,230.46) 112.85,229.89 112.85,229.08 112.98,228.95 114.39,228.95 114.82,228.53 114.82,226.33 114.4,225.91 109.98,225.91 109.77,225.71 109.77,225.15 109.53,224.9 102.36,224.9 101.49,224.03 91.9,224.03 91.4,224.53 90.65,224.53 88.73,226.45 86.43,226.45 85.23,225.25 85.23,224.35 83.76,222.89 82.9,222.89 71.02,211.01 68.93,211.01 56.78,198.86 34.52,198.86 19.27,183.61 19.27,176.82 14.28,171.83 13.4,171.83 12.09,170.53 12.09,168.69 10.44,167.04 10.44,163.13 8.98,161.67 8.5,161.67 7.33,160.5 7.33,151.99 5.56,150.22 5.56,143.07 5.71,142.93 5.71,137.9 8.54,135.06 8.54,132.7 v1(8.63,132.61) 8.68,132.56 9.24,132.56 9.97,131.82 9.97,131.38 11.47,129.88 11.81,129.88 13.35,128.34 16.93,128.34 17.05,128.22 18.23,128.22 19.7,126.74 20.89,126.74 21.25,127.1 23.2,127.1 v4(23.71,127.61)
  BOTTOM w0.127: v4(112.29,230.46) 112.29,230.66 112.8,231.18 112.8,231.56 113.25,232 116.36,232 v2(116.42,232.06)
BCM88470_SCAN: length 33.9
  TOP w0.127: U40.AH31 v4(26.7,125.65) ; R574.2 11.27,126.85 11.31,126.81 v1(11.41,126.81)
  S14 w0.127: v1(11.41,126.81) 11.65,126.81 12.66,125.8 14.26,125.8 14.77,125.29 18.07,125.29 19.22,124.15 25.94,124.15 26.23,124.43 26.23,124.94 26.7,125.41 v4(26.7,125.65)
  BOTTOM w0.127: v2(16.66,139.67) 16.66,139.67 13.55,136.57 13.55,128.96 v1(11.41,126.81)
BCM88470_SPI_CLK: length 3.8
  TOP w0.127: v4(22.7,121.65) U40.AD35
  BOTTOM w0.127: TPB33.1 22.58,123.09 22.88,123.09 23.14,122.82 23.14,122.09 v4(22.7,121.65)
BCM88470_SPI_MISO: length 8.3
  TOP w0.127: v4(22.7,122.65) U40.AE35
  BOTTOM w0.127: 20.04,124.49 18.93,124.49 17.73,123.3 16.59,123.3 TPB32.1
  BOTTOM w0.13: v4(22.7,122.65) 22.29,122.65 21.8,123.13 21.4,123.13 20.04,124.49
BCM88470_SPI_MOSI: length 6.4
  TOP w0.127: v4(23.7,120.65) U40.AC34
  BOTTOM w0.127: TPB40.1 19.2,118.75
  BOTTOM w0.13: 19.2,118.75 20.17,119.71 22.76,119.71 v4(23.7,120.65)
BCM88470_SPI_SSN: length 6.8
  TOP w0.127: v4(23.7,121.65) U40.AD34
  BOTTOM w0.127: TPB35.1 19.63,122.54
  BOTTOM w0.13: v4(23.7,121.65) 23.29,121.65 22.8,121.15 21.02,121.15 19.63,122.54
BCM88470_TEST_0: length 34.9
  TOP w0.127: R501.2 11.17,133.96 v1(11.41,133.72) ; v4(22.7,128.65) U40.AL35
  S7 w0.127: v4(22.7,128.65) 22.21,128.65 21.21,129.64 19.88,129.64 18.14,131.39 14.39,131.39 12.38,133.4 11.55,133.4 11.41,133.54 v1(11.41,133.72)
  BOTTOM w0.127: v1(11.41,133.72) 10.76,134.36 10.76,138.4 16.6,144.24 16.6,147.42 17.81,148.63 v2(19.59,148.63)
BCM88470_TEST_1: length 2.6
  TOP w0.127: v4(22.7,129.65) U40.AM35
  BOTTOM w0.127: v2(22.07,128.27) 21.97,128.37 RB172.2 22.24,129.19 v4(22.7,129.65)
BCM88470_TEST_2: length 24
  TOP w0.127: v1(8.26,127.95) 7.49,127.95 R561.2 ; U40.AH35 v4(22.7,125.65)
  S14 w0.127: v1(8.26,127.95) 8.62,128.32 9.96,128.32 10.96,127.32 11.85,127.32 12.83,126.34 18.04,126.34 19.22,125.16 21.88,125.16 22.36,125.65 v4(22.7,125.65)
  BOTTOM w0.127: v2(4.29,132.33) 4.29,131.54 5.62,130.21 6.16,130.21 8.26,128.12 v1(8.26,127.95)
BCM88470_TEST_3: length 36.8
  TOP w0.127: R509.2 11.27,132.94 ; v4(22.71,127.6) 23.16,127.15 U40.AK35
  TOP w0.13: 11.27,132.94 12.09,132.12 v1(12.09,131.89)
  S7 w0.127: v1(12.09,131.89) 12.22,131.76 12.22,131.53 14.36,129.39 18.08,129.39 19.86,127.6 v4(22.71,127.6)
  BOTTOM w0.127: v2(17.36,149.83) 16.22,148.69 16.22,144.5 10.32,138.59 10.32,133.89 12.09,132.12 v1(12.09,131.89)
BCM88470_TEST_4: length 27.2
  TOP w0.127: v4(22.7,126.65) U40.AJ35 ; v1(11.41,127.82) 11.31,127.82 11.27,127.86 R562.2
  S14 w0.127: v4(22.7,126.65) 22.43,126.65 21.97,127.1 21.29,127.1 20.92,126.74 19.29,126.74 17.66,128.37 12.83,128.37 11.81,129.39 11.18,129.39 10.92,129.14 10.92,128.31 v1(11.41,127.82)
  BOTTOM w0.127: 7.71,129.39 6.38,130.72 5.91,130.72 5.3,131.33 5.3,133.49 v2(4.43,134.36)
  BOTTOM w0.13: v1(11.41,127.82) 11.25,127.82 9.68,129.39 7.71,129.39
BCM88470_THERM_DIODE_VDD3P3: length 6.7
  TOP w0.127: U40.D25 v4(32.7,100.65)
  BOTTOM w0.127: RB236.2 32.26,95 32.26,96.16 v2(32.26,96.16) 32.26,96.17 32.26,100.21 v4(32.7,100.65)
BCM88470_UC_PLL_BYPCLK0: length 12.3
  TOP w0.127: v4(26.7,114.65) U40.V31 ; v1(18.25,116.5) 18.06,116.69 R682.1
  S7 w0.127: v4(26.7,114.65) 25.37,114.65 24.09,115.93 20.58,115.93 20,116.5 v1(18.25,116.5)
  BOTTOM w0.127: v1(18.25,116.5) 19.11,116.5 v2(19.13,116.48)
BCM88470_UC_PLL_BYPCLK1: length 3.5
  TOP w0.127: v4(26.7,117.65) U40.Y31
  BOTTOM w0.127: v4(26.7,117.65) 27.15,117.19 27.91,117.19 28.22,116.88 28.22,116.1 RB193.1
BITS_1P8: length 16.6
  TOP w0.254: U68.23 v3(191.13,230.88) ; v1(184.56,233.21) 184.63,233.13 U68.36 ; v1(195.2,220.16) 195.2,220.22 194.85,220.57 U68.1 ; U68.65 184.63,219.91 v1(184.63,219.91)
  BOTTOM w0.127: v1(196.24,217.26) 196.75,216.75 v2(196.75,216.25) ; v2(184.58,218.42) 184.58,219.86 v1(184.63,219.91)
  BOTTOM w0.381: v3(191.13,230.88) 191.23,230.78 CB1041.1 191.86,230.09 CB1044.1
  BOTTOM w0.508: CB1037.1 184.15,220.39 v1(184.63,219.91) 185.17,220.45 CB1039.1 ; CB1043.1 194.28,219.75 194.69,220.16 v1(195.2,220.16) 195.29,220.06 CB1045.1 ; CB1040.1 184.18,232.83 v1(184.56,233.21) 185.19,232.57 CB1042.1 ; CB1078.1 203.29,227.94
  vias: v1(196.24,218.11) v1(203.29,227.24) v1(204.31,227.87) v1(204.31,227.18)
BITS_3P3: length 20.6
  TOP w0.254: v3(188.42,230.88) 188.63,231.1 U68.28 ; U68.80 192.13,217.36 192.15,217.34 v1(192.15,217.23) ; v1(192.12,230.79) 192.13,230.81 U68.21
  TOP w0.508: CB1046.2 v1(195.43,215.42) ; L96.2 v1(196.95,215.42)
  TOP w0.762: v1(192.15,217.23) 192.15,216.68 193.97,214.87 CB1049.1 CB1046.2 L96.2
  BOTTOM w0.127: v2(205.9,221.65) 205.01,221.65 204.94,221.59
  BOTTOM w0.381: CB1051.1 188.42,230.88 v3(188.42,230.88) 188.3,231.01 CB1053.1 ; CB1050.1 192.67,216.71 v1(192.15,217.23) 191.63,216.71 CB1054.1
  BOTTOM w0.508: CB1066.1 202.78,222.29 v1(203.04,222.03) 202.85,221.84 CB1072.1 ; v1(192.12,230.79) 192.17,230.85 CB1052.1 CB1048.1
  vias: v1(203.93,222.03) v1(204.69,222.03)
BITS_A: length 400.1
  TOP w0.127: P1.G14 v4(100.29,223.46)
  S5 w0.127: v1(217.07,195.93) 217.55,196.41 217.55,197.91 206.25,209.2 171.54,209.2 168.4,212.35 161.42,212.35 152.01,202.94 136.66,202.94 135.79,203.81 v1(135.03,203.81)
  S7 w0.127: v1(217.07,195.93) 216.31,195.17 216.31,189.1 217.41,188.01 217.41,159.76 216.25,158.6 216.25,152.02 214.66,150.43 214.66,144.76 210.43,140.52 210.43,138.88 207.84,136.3 199.89,136.3 192.94,129.34 192.94,85.7 202.15,76.49 205.21,76.49 208.26,73.44 212.44,73.44 213.33,72.55 218.75,72.55 221.78,69.52 221.78,46.14 214.45,38.81 214.45,30.46 213.18,29.18 213.18,14.58 216.44,11.32 220.55,11.32 221.61,10.26 226.88,10.26 228.97,8.16 236.97,8.16 239,10.2 v1(241.33,10.2) ; v4(100.29,223.46) 100.29,223.44 100.74,222.99 103.81,222.99 104.8,223.98 116.22,223.98 117,224.76 123.54,224.76 129.63,218.67 129.63,213.01 132.73,209.92 132.73,209.58 135.03,207.28 v1(135.03,203.81)
  BOTTOM w0.127: v2(218.85,197.14) 217.64,195.93 v1(217.07,195.93) ; RB669.2 v1(241.33,10.2)
BITS_A_R: length 5.2
  BOTTOM w0.127: CB950.2 RB669.1 v2(241.33,7.27) 239.67,5.61 LEDB4.C1
BITS_ACK0: length 6.4
  TOP w0.127: R1108.2 182.3,234.57 v1(182.58,234.3) 182.73,234.14 184.38,234.14 185.13,233.39 U68.35
  BOTTOM w0.127: v2(183.61,233.91) 182.97,233.91 v1(182.58,234.3)
BITS_ACK1: length 4.8
  TOP w0.127: R1110.2 181.28,234.61 182.12,233.78 183.3,233.78 183.63,233.45 183.63,232.03 U68.38
BITS_ADD0: length 5.9
  TOP w0.127: v1(181.85,228.64) 181.77,228.64 181.7,228.57 U68.44 179.74,228.57 179.23,229.08 178.78,229.08 178.02,229.84 R1198.1
  BOTTOM w0.127: v1(181.85,228.64) 181.26,228.64 v2(180.94,228.95)
BITS_ADD1: length 9.7
  TOP w0.127: RB1199.1 175.5,228.75 178.99,228.75 179.67,228.07 U68.45 182.01,228.07 v1(182.15,227.94)
  BOTTOM w0.127: v1(182.15,227.94) 182.85,228.64 v2(182.85,229.59)
BITS_ADD2: length 8.9
  TOP w0.127: RB1200.1 174.98,228.36 178.8,228.36 179.59,227.57 U68.46 181.5,227.57 v1(181.96,227.11)
  BOTTOM w0.127: v1(181.96,227.11) 183.1,227.11 v2(183.23,227.24)
BITS_ADD3: length 4.5
  TOP w0.127: U68.47 179.72,227.07 179.49,227.3 v1(179.16,227.3) 178.63,227.84 RB1201.1
  BOTTOM w0.127: v1(179.16,227.3) 179.1,227.37 v2(179.1,228.38)
BITS_ADD4: length 6.9
  TOP w0.127: R1202.1 178.43,227.27 179.1,226.6 v1(179.48,226.6) 179.96,226.6 180,226.57 U68.48
  BOTTOM w0.127: v1(179.48,226.6) 179.85,226.24 180.14,226.24 180.14,226.22 v2(180.17,226.22)
BITS_ADD5: length 8.2
  TOP w0.127: v1(181.89,226.35) 181.61,226.07 U68.49 179.25,226.07 178.52,226.8 RB1203.1
  BOTTOM w0.127: v2(185.19,226.73) 185.13,226.73 184.75,226.35 v1(181.89,226.35)
BITS_ADD6: length 11.2
  TOP w0.127: v1(182.27,225.65) 182.19,225.57 U68.50 179.12,225.57 178.4,226.28 RB1204.1
  BOTTOM w0.127: v2(185.32,224.64) 184.31,225.65 v1(182.27,225.65)
BITS_ADD7: length 7.3
  TOP w0.127: RB1205.1 178.21,225.78 v1(178.59,225.4) 178.92,225.07 U68.51 182.09,225.07 v1(182.4,224.76)
  BOTTOM w0.127: v1(182.4,224.76) 183.31,224.76 v2(183.34,224.74) ; v2(177.83,226.16) v1(178.59,225.4)
BITS_ADD8: length 112.6
  TOP w0.127: U68.53 179.68,224.07 179.67,224.06 v1(179.52,224.06) ; R1207.1 93.92,237.69 v1(94.14,237.91)
  S9 w0.127: v1(177.83,240.57) 173.37,240.57 172.65,239.85 172.09,239.85 171.02,238.79 168.19,238.79 168.05,238.92 164.94,238.92 164.3,238.29 157.83,238.29 156.24,239.88 149.47,239.88 145.21,244.13 142.97,244.13 142.33,243.49 140.53,243.49 139.77,244.26 121.57,244.26 121.13,243.81 100.99,243.81 97.39,240.21 95.72,240.21 94.11,238.6 94.11,237.93 v1(94.14,237.91)
  S12 w0.127: v1(177.83,240.57) 176.98,239.72 176.98,225.74 178.27,224.44 179.14,224.44 v1(179.52,224.06)
  BOTTOM w0.127: v1(179.52,224.06) 180.41,224.06 v2(180.52,224.18)
BITS_ADD9: length 6.1
  TOP w0.127: RB1206.1 v1(178.34,221.71) 179.16,221.71 179.52,222.07 U68.57
  BOTTOM w0.127: v2(176.88,219.43) 176.88,220.25 v1(178.34,221.71)
BITS_ADD10: length 4.5
  TOP w0.127: RB1208.1 v1(178.4,220.7) 178.78,220.7 179.65,221.57 U68.58
  BOTTOM w0.127: v2(179.29,220.44) 178.65,220.44 v1(178.4,220.7)
BITS_ADD11: length 5.6
  TOP w0.127: RB1209.1 v1(178.27,218.67) 179.19,219.59 179.19,219.9 179.86,220.57 U68.60
  BOTTOM w0.127: v2(178.21,217.21) 178.21,218.6 v1(178.27,218.67)
BITS_ADD_0: length 103.3
  TOP w0.127: v1(94.98,207.93) 94.79,208.12 P1.A1 ; R1198.2 176.5,229.84 v1(175.92,229.27)
  S9 w0.127: v1(175.92,229.27) 175.73,229.08 173.67,229.08 171.99,227.4 171.99,219.55 168.61,216.17 165.54,216.17 164.99,216.72 162.73,216.72 162.52,216.51 141.5,216.51 138.88,213.89 136.36,213.89 134.03,211.55 133.38,211.55 131.09,209.27 131.09,209.06 127.81,205.78 126.65,205.78 125.18,204.32 122.9,204.32 122.52,203.93 107.03,203.93 106.45,204.51 103.04,204.51 101.73,205.81 101.73,207.12 101.32,207.53 95.37,207.53 v1(94.98,207.93)
  BOTTOM w0.127: v2(94.17,208.76) 94.2,208.76 94.98,207.99 v1(94.98,207.93)
BITS_ADD_1: length 100.9
  TOP w0.127: P1.A2 94.76,210.96 v4(94.28,210.47) ; v1(172.57,229.6) 172.84,229.33 RB1199.2
  S9 w0.127: v4(94.28,210.47) 96.31,208.44 104.42,208.44 106.11,206.76 107.88,206.76 108.74,207.62 112.61,207.62 115.54,204.7 121.76,204.7 123.54,206.47 127.65,206.47 130.14,208.97 130.14,209.52 131.54,210.92 131.54,211.09 134.34,213.89 135.23,213.89 137.13,215.8 139.39,215.8 140.64,217.04 162.33,217.04 162.52,217.23 165.28,217.23 165.8,216.71 168.19,216.71 170.93,219.45 170.93,227.96 v1(172.57,229.6)
  BOTTOM w0.127: v2(173.51,230.03) 173.08,229.6 v1(172.57,229.6)
BITS_ADD_2: length 103.3
  TOP w0.127: v4(94.39,211.49) 94.39,211.56 P1.A3 ; v1(172.57,228.71) 173.01,228.27 RB1200.2
  S9 w0.127: v1(172.57,228.71) 171.42,227.55 171.42,219.43 168.43,216.44 165.66,216.44 165.12,216.98 162.63,216.98 162.41,216.76 140.96,216.76 139.49,215.29 137.08,215.29 135.43,213.64 134.45,213.64 131.79,210.98 131.79,210.6 130.65,209.46 130.65,209.11 127.63,206.09 123.66,206.09 121.82,204.25 107.53,204.25 106.55,205.23 103.06,205.23 102.23,206.06 102.23,207.47 101.75,207.96 95.73,207.96 93.75,209.93 93.75,210.86 v4(94.39,211.49)
  BOTTOM w0.127: v2(171.22,229.02) 171.53,228.71 v1(172.57,228.71)
BITS_ADD_3: length 112.2
  TOP w0.127: v1(92.1,209.9) 92.1,212.13 93.94,213.96 P1.A5 ; v1(175.87,227.83) 175.87,227.84 RB1201.2
  S9 w0.127: v1(92.1,209.9) 92.18,209.82 93.28,209.82 93.88,209.23 93.88,208.07 95.15,206.8 99.88,206.8 100.66,206.02 100.66,205.53 101.24,204.96 102.04,204.96 105.14,201.85 125.37,201.85 126.2,202.68 126.2,204.22 126.82,204.84 126.86,204.85 127.35,204.85 131.47,208.98 131.47,209.08 133.38,210.98 133.86,210.98 136.49,213.61 139.08,213.61 141.73,216.26 162.63,216.26 162.84,216.47 164.82,216.47 165.42,215.87 168.68,215.87 172.49,219.68 172.49,227.4 172.93,227.83 v1(175.87,227.83)
  BOTTOM w0.127: v2(92.1,210.86) v1(92.1,209.9)
BITS_ADD_4: length 117.2
  TOP w0.127: v1(173.18,227.29) 173.2,227.27 R1202.2 ; P1.D7 v4(97.29,215.46)
  S7 w0.127: v1(93.33,206.61) 94.53,206.61 96.85,208.93 96.85,215.02 v4(97.29,215.46)
  S9 w0.127: v1(93.33,206.61) 92.8,206.08 92.8,205.2 93.49,204.52 97.99,204.52 98.37,204.15 100.16,204.15 100.74,203.57 100.74,202.41 102.49,200.65 126.35,200.65 128.62,202.92 128.62,204.37 128.76,204.51 128.76,204.59 132.89,208.73 133.78,208.73 135.39,210.33 135.46,210.33 135.57,210.45 135.57,211.26 136.91,212.6 140.73,212.6 142.55,214.41 162.5,214.41 162.84,214.07 169.02,214.07 173.88,218.94 173.88,226.59 v1(173.18,227.29)
  BOTTOM w0.127: v2(171.99,226.92) 172.35,227.29 v1(173.18,227.29)
BITS_ADD_5: length 105.3
  TOP w0.127: P1.B22 95.79,232.51 v1(95.28,233.02) ; RB1203.2 176.63,226.76 v1(175.88,226.76)
  S9 w0.127: v1(95.28,233.02) 94.68,233.61 94.68,235.61 95.32,236.25 95.32,238.36 96.84,239.88 97.51,239.88 100.61,242.99 101.06,243.43 121.48,243.43 121.99,243.94 139.3,243.94 140.12,243.11 143.79,243.11 144.36,243.69 145.13,243.69 149.19,239.62 154.4,239.62 155.98,238.03 164.98,238.03 165.49,238.54 167.61,238.54 168.84,237.31 168.84,237.06 v1(168.94,236.95)
  S12 w0.127: v1(168.94,236.95) 171.86,236.95 174.4,234.41 174.4,228.24 v1(175.88,226.76)
  BOTTOM w0.127: v2(176.94,228.06) 176.94,227.82 v1(175.88,226.76)
BITS_ADD_6: length 99.8
  TOP w0.127: RB1204.2 v1(173.19,226.28) ; P1.D21 v4(97.29,230.46)
  S9 w0.127: v1(166.97,236.83) 166.44,237.36 165.92,237.36 165.51,236.95 155.29,236.95 154.02,238.22 148.91,238.22 146.37,240.76 143.09,240.76 142.14,241.72 139.89,241.72 138.69,242.92 122.65,242.92 122.14,242.41 101.47,242.41 101.03,241.97 101.03,241.97 98.14,239.07 98.14,237.09 96.52,235.47 96.52,233.54 97.76,232.3 97.76,230.93 v4(97.29,230.46)
  S12 w0.127: v1(173.19,226.28) 171.73,227.74 171.73,232.9 168.82,235.81 167.52,235.81 166.97,236.36 v1(166.97,236.83)
  BOTTOM w0.127: v1(173.19,226.28) 173.57,225.91 v2(174.21,225.91)
BITS_ADD_7: length 104.2
  TOP w0.127: RB1205.2 v1(175.97,225.78) ; P1.E20 v4(98.29,229.46)
  S9 w0.127: v1(166.21,236.89) 166.02,236.7 154.97,236.7 153.76,237.91 148.87,237.91 146.27,240.51 141.25,240.51 140.6,241.16 139.76,241.16 138.5,242.42 122.84,242.42 122.51,242.08 102.15,242.08 98.45,238.39 98.45,236.79 97.15,235.49 97.15,233.67 98.29,232.53 v4(98.29,229.46)
  S12 w0.127: v1(166.21,236.89) 166.72,237.4 167.22,237.4 167.61,237.02 167.61,236.52 167.87,236.26 171.35,236.26 173.83,233.78 173.83,227.81 175.86,225.78 v1(175.97,225.78)
  BOTTOM w0.127: v2(174.36,224.01) 174.36,224.16 v1(175.97,225.78)
BITS_ADD_8: length 9.8
  TOP w0.127: R1207.2 v1(93.92,235.18) 95.32,233.78 95.8,233.78 98.29,231.29 98.29,230.48 98.79,229.98 P1.E21
  BOTTOM w0.127: v1(93.92,235.18) 92.87,236.23 v2(92.87,236.32)
BITS_ADD_9: length 103
  TOP w0.127: P1.F20 v4(99.29,229.46) ; RB1206.2 v1(175.97,221.71)
  S9 w0.127: v1(168.24,235.24) 167.99,235.49 166.46,235.49 166.05,235.09 150.19,235.09 146.35,238.93 135.09,238.93 133,241.02 129,241.02 127.03,239.05 122.89,239.05 120.62,241.32 103.84,241.32 100.55,238.03 100.55,236.89 99.56,235.9 99.56,234.92 99.28,234.64 99.28,234.64 99.28,232.06 99.85,231.49 99.85,230.35 99.29,229.79 v4(99.29,229.46)
  S12 w0.127: v1(175.97,221.71) 174.82,221.71 170.35,226.18 170.35,233.13 v1(168.24,235.24)
  BOTTOM w0.127: v2(177,221.84) 176.88,221.71 v1(175.97,221.71)
BITS_ADD_10: length 105.7
  TOP w0.127: RB1208.2 v1(175.97,220.7) ; P1.H15 v4(101.29,224.46)
  S9 w0.127: v1(168.24,234.48) 149.93,234.48 146.11,238.3 122.22,238.3 120.11,240.41 105.18,240.41 103.71,238.94 103.71,237.33 103.19,236.81 102.37,236.81 101.08,235.51 101.08,232.94 100.8,232.67 100.8,224.94 v4(101.29,224.46)
  S12 w0.127: v1(175.97,220.7) 172.68,220.7 169.13,224.25 169.13,233.59 v1(168.24,234.48)
  BOTTOM w0.127: v2(174.65,221.02) 175.66,221.02 v1(175.97,220.7)
BITS_ADD_11: length 106.3
  TOP w0.127: RB1209.2 v1(175.97,218.67) ; P1.H16 v4(101.29,225.46)
  S9 w0.127: v1(167.35,233.59) 166.76,234.18 149.17,234.18 145.3,238.05 121.65,238.05 119.53,240.16 106.44,240.16 105,238.72 105,237.13 104.23,236.35 102.36,236.35 101.41,235.41 101.41,235.24 101.41,235.24 101.41,234.85 101.41,234.85 101.41,230.98 101.78,230.62 101.78,225.95 v4(101.29,225.46)
  S12 w0.127: v1(167.35,233.59) 167.76,233.18 167.76,224.32 168.41,223.66 168.41,221.49 171.49,218.41 173.57,218.41 174.11,218.95 175.7,218.95 v1(175.97,218.67)
  BOTTOM w0.127: v2(176.11,217.4) 176.11,218.53 v1(175.97,218.67)
BITS_ALE: length 8.3
  TOP w0.127: R1125.2 R1124.2 174.93,222.21 177.49,222.21 177.58,222.3 R1123.2 v1(178.27,222.72) 178.98,222.72 179.13,222.57 U68.56
  BOTTOM w0.127: v1(178.27,222.72) 178.86,222.72 v2(179.16,222.42)
BITS_CHOKE_RRING: length 3.1
  BOTTOM w0.381: v2(240.82,53.19) 241.77,52.23 241.77,50.52
  vias: v1(245.04,47.94) v1(245.87,47.95) v1(245.98,39.41) v1(245.96,38.7)
BITS_CHOKE_RTIP:
  vias: v1(242.52,41.13) v1(243.39,41.13) v2(240.06,40.42)
BITS_CHOKE_TRING: length 3.1
  BOTTOM w0.381: v2(236.82,52.74) 236.82,49.64 UB10.9
  vias: v1(239.28,47.75) v1(240.01,47.76) v1(240.74,47.78)
BITS_CHOKE_TTIP: length 4.2
  BOTTOM w0.254: v1(243.4,39.56) 243.69,39.85 244.88,39.85 245.84,40.8 v2(246.15,40.8) ; v2(236.5,40.23) 236.5,40.89 v1(236.32,41.07)
  vias: v1(237.05,41.04) v1(242.67,39.57)
BITS_CS: length 11.3
  TOP w0.127: 183.06,214.68 R1116.2 182.59,215.17 v1(182.85,215.43) ; 183.06,214.68 183.08,214.66 183.08,212.39 RB1212.2 ; 183.06,214.68 R1117.2 183.61,215.62 183.86,215.87 184.29,215.87 186.13,217.71 U68.68
  BOTTOM w0.127: v2(182.85,216.63) v1(182.85,215.43)
BITS_CS_IN: length 152.5
  TOP w0.127: P1.A13 v1(93.71,221.96) ; v1(182.59,210.22) 182.63,210.26 RB1212.1
  S9 w0.127: v1(93.71,221.96) 93.71,225.7 93.16,226.25 93.16,226.93 92.88,227.21 91.16,227.21 89.69,228.68 89.69,236.26 89.15,236.8 89.15,238.17 92.64,241.65 96.49,241.65 100.28,245.45 129.23,245.45 131.16,247.37 138.97,247.37 139.54,246.8 144.43,246.8 145.36,245.86 159.78,245.86 162.47,243.17 174.38,243.17 174.56,242.99 v1(179.1,242.99)
  S12 w0.127: v1(182.59,210.22) 179.99,212.82 179.99,217.33 180.81,218.16 180.81,237.27 180.5,237.59 180.5,241.59 v1(179.1,242.99)
  BOTTOM w0.127: v2(182.53,209.27) 182.53,210.16 v1(182.59,210.22)
BITS_DA0: length 7.5
  TOP w0.127: U68.40 182.63,232.78 182.46,232.95 180.24,232.95 v1(180.18,233.02) 179.92,233.02 178.24,234.71 R1160.2
  BOTTOM w0.127: v2(179.29,233.59) 179.61,233.59 v1(180.18,233.02)
BITS_DA1: length 7.3
  TOP w0.127: R1161.2 178.02,233.91 179.04,232.89 179.04,232.19 v1(179.1,232.13) 179.48,231.75 179.48,230.35 179.76,230.07 U68.41
  BOTTOM w0.127: v2(180.36,231.87) 179.36,231.87 v1(179.1,232.13)
BITS_DA2: length 4.5
  TOP w0.127: R1162.2 177.65,223.81 v1(178.53,223.81) 178.84,223.81 179.09,223.57 U68.54
  BOTTOM w0.127: v2(177.45,224.19) 177.83,223.81 v1(178.53,223.81)
BITS_DA3: length 8.2
  TOP w0.127: R1163.2 179.04,223.24 179.2,223.07 U68.55 182,223.07 v1(182.02,223.05)
  BOTTOM w0.127: v1(182.02,223.05) 182.3,222.77 v2(182.92,222.77)
BITS_DA4: length 7.2
  TOP w0.127: R1164.2 v1(179.48,217.64) 182.53,217.64 182.63,217.74 U68.61
  BOTTOM w0.127: v1(179.48,217.64) 180.31,218.46 v2(180.31,218.54)
BITS_DA5: length 9.1
  TOP w0.127: U68.63 183.63,217.79 183.11,217.27 180.69,217.27 180.04,216.62 v1(179.23,216.62) R1165.2
  BOTTOM w0.127: v2(180.94,216.57) 179.28,216.57 v1(179.23,216.62)
BITS_DA6: length 10
  TOP w0.127: U68.64 184.13,217.72 183.3,216.89 181.07,216.89 179.78,215.61 v1(178.46,215.61) R1166.2
  BOTTOM w0.127: v1(178.46,215.61) 178.1,215.24 v2(176.94,215.24)
BITS_DA7: length 10
  TOP w0.127: R1167.2 v1(180.57,215.44) 181.64,216.51 183.87,216.51 185.13,217.77 U68.66
  BOTTOM w0.127: v2(180.5,212.57) 180.57,212.65 v1(180.57,215.44)
BITS_DATA0: length 79.3
  TOP w0.127: v1(177.51,235.18) 177.51,235.75 177.79,236.02 R1160.1 ; P1.AA7 v4(115.29,215.46)
  S9 w0.127: v1(177.51,235.18) 176.83,234.49 176.83,232.55 176.65,232.38 175.64,232.38 174.25,230.99 172.37,230.99 169.17,227.79 169.17,222.79 167.27,220.89 164.94,220.89 164.37,221.46 162.91,221.46 162.49,221.88 156.72,221.88 156.17,221.33 149.44,221.33 148.62,220.51 136.43,220.51 134.33,218.41 132.89,218.41 132.53,218.05 131.07,218.05 130.39,217.38 126.25,217.38 125.27,216.39 124.39,216.39 123.38,217.4 121.56,217.4 120.22,216.06 115.92,216.06 115.31,215.46 v4(115.29,215.46)
  BOTTOM w0.127: v2(178.46,235.49) 177.83,235.49 v1(177.51,235.18)
BITS_DATA1: length 76.1
  TOP w0.127: R1161.1 v1(175.97,233.91) ; P1.AA9 v4(115.29,217.46)
  S9 w0.127: v4(115.29,217.46) 116.3,217.46 116.87,216.89 117.8,216.89 118.74,217.83 120.54,217.83 122.12,219.41 123.3,219.41 124.33,218.38 127.89,218.38 128.68,219.17 130.65,219.17 130.97,219.49 133.19,219.49 134.9,221.21 147.86,221.21 148.8,222.15 155.34,222.15 156.24,223.05 157.3,223.05 158.18,222.16 162.13,222.16 162.47,222.5 163.77,222.5 165.07,221.21 167.16,221.21 168.62,222.67 168.62,227.62 172.18,231.18 172.18,231.49 172.94,232.26 174.53,232.26 175.97,233.7 v1(175.97,233.91)
  BOTTOM w0.127: v2(176.56,234.48) 175.99,233.91 v1(175.97,233.91)
BITS_DATA2: length 65.5
  TOP w0.127: P1.AB11 v4(116.29,219.46) ; R1162.1 v1(175.97,223.75)
  S9 w0.127: v4(116.29,219.46) 116.84,219.46 117.63,218.67 120.19,218.67 121.77,220.24 122.85,220.24 124.32,221.71 133.7,221.71 136.3,224.32 139.82,224.32 140.9,223.24 153.64,223.24 154.78,224.38 163.99,224.38 v1(165.32,223.05)
  BOTTOM w0.127: v1(175.97,223.75) 175.59,223.37 v2(171.35,223.37) 165.64,223.37 v1(165.32,223.05)
BITS_DATA3: length 65.8
  TOP w0.127: v1(169.73,224.48) 170.98,223.24 R1163.1 ; P1.AB7 v4(116.29,215.46)
  S9 w0.127: v4(116.29,215.46) 116.96,215.46 117.29,215.79 121.29,215.79 121.88,216.38 123.76,216.38 124.12,216.02 125.44,216.02 126.41,216.99 130.52,216.99 131.2,217.67 132.6,217.67 132.92,218 134.3,218 136.36,220.06 148.94,220.06 149.87,221 156.28,221 156.81,221.52 162.48,221.52 162.98,221.03 164.04,221.03 164.43,220.63 167.67,220.63 169.73,222.7 v1(169.73,224.48)
  BOTTOM w0.127: v1(169.73,224.48) 170.21,224.96 v2(170.21,225.33)
BITS_DATA4: length 70.4
  TOP w0.127: v1(169.7,220.95) 173.02,217.64 R1164.1 ; P1.W7 v4(113.29,215.46)
  S9 w0.127: v1(169.7,220.95) 169.13,220.38 164.24,220.38 163.89,220.73 162.87,220.73 162.53,221.08 157.43,221.08 156.97,220.63 150.2,220.63 149.38,219.81 136.49,219.81 134.43,217.75 133.03,217.75 132.7,217.42 131.41,217.42 130.5,216.51 126.81,216.51 126,215.7 123.04,215.7 122.66,215.32 121.36,215.32 120.24,214.2 118.07,214.2 118.07,214.2 117.57,214.2 116.79,214.98 113.76,214.98 113.29,215.45 v4(113.29,215.46)
  BOTTOM w0.127: v2(169.64,221.97) 169.64,221.02 v1(169.7,220.95)
BITS_DATA5: length 72.7
  TOP w0.127: v1(167.92,222.73) 167.92,221.91 172.76,217.08 175.01,217.08 175.47,216.62 R1165.1 ; P1.W9 v4(113.29,217.46)
  S9 w0.127: v4(113.29,217.46) 113.73,217.9 116.3,217.9 116.87,217.33 117.59,217.33 118.36,218.11 120.38,218.11 121.95,219.68 123.66,219.68 123.87,219.48 130.25,219.48 130.71,219.94 133.12,219.94 134.71,221.52 147.41,221.52 148.37,222.48 154.78,222.48 155.79,223.49 157.46,223.49 158.25,222.7 159.09,222.7 159.18,222.79 163.86,222.79 165.13,221.52 166.72,221.52 v1(167.92,222.73)
  BOTTOM w0.127: v1(167.92,222.73) 167.29,222.1 167.16,222.1 167.16,222.11 v2(167.16,222.11)
BITS_DATA6: length 72.1
  TOP w0.127: P1.Y10 v4(114.29,218.46) ; v1(174.23,216.6) 175.23,215.61 R1166.1
  S5 w0.127: v1(165.32,222.16) 169.95,222.16 170.91,221.21 170.91,219.92 v1(174.23,216.6)
  S9 w0.127: v4(114.29,218.46) 114.63,218.46 115.18,219 116.66,219 117.25,218.41 120.3,218.41 121.87,219.99 123.13,219.99 124.6,221.46 134.08,221.46 136.55,223.94 139.69,223.94 140.71,222.92 154.21,222.92 155.29,224 163.48,224 v1(165.32,222.16)
  BOTTOM w0.127: v1(165.32,222.16) 165.07,221.9 v2(165.07,221.14)
BITS_DATA7: length 77.6
  TOP w0.127: R1167.1 175.43,213.77 167.16,222.04 v1(167.16,225.46) ; P1.Y12 v4(114.29,221.46)
  S9 w0.127: v1(167.16,225.46) 166.84,225.78 135.6,225.78 132.93,223.11 123.43,223.11 122.7,223.85 121.99,223.85 121.06,222.92 119.15,222.92 118.87,222.63 117.15,222.63 116.55,222.03 114.99,222.03 114.42,221.46 v4(114.29,221.46)
  BOTTOM w0.127: v2(165.95,225.46) v1(167.16,225.46)
BITS_G: length 406.7
  TOP w0.127: P1.G12 v4(100.29,221.46)
  S5 w0.127: v1(109.19,203.11) 109.88,203.81 122.39,203.81 123.16,204.57 136.36,204.57 137.35,203.58 151.88,203.58 161.5,213.2 168.14,213.2 171.79,209.54 206.49,209.54 217.91,198.12 217.91,195.95 v1(217.14,195.17)
  S7 w0.127: v1(217.14,195.17) 216.62,194.65 216.62,189.39 218.03,187.98 218.03,174.42 218.55,173.9 218.55,171.03 217.77,170.26 217.77,159.61 216.5,158.34 216.5,151.83 214.98,150.3 214.98,144.63 210.76,140.41 210.76,138.66 208.09,135.99 206.34,135.99 206.33,135.98 199.97,135.98 193.25,129.27 193.25,86.02 202.47,76.81 206.71,76.81 209.77,73.75 212.95,73.75 213.71,73 218.72,73 218.74,73.01 222.1,69.65 222.1,46.01 214.77,38.68 214.77,13.49 216.63,11.63 220.68,11.63 221.8,10.51 227.07,10.51 229.16,8.42 236.5,8.42 238.96,10.87 243.76,10.87 v1(244.38,10.26)
  S14 w0.127: v4(100.29,221.46) 101.75,220 102.56,220 102.86,219.69 102.86,208.76 101.82,207.72 101.82,204.95 102.76,204.01 108.28,204.01 v1(109.19,203.11)
  BOTTOM w0.127: v2(108.93,202.09) 108.93,202.85 v1(109.19,203.11) ; v2(218.04,195.17) 218.04,195.17 v1(217.14,195.17) ; RB662.2 v1(244.38,10.26)
BITS_G_R: length 5.5
  BOTTOM w0.127: RB662.1 CB942.2 v2(243.36,7.14) 243.34,7.15 242.14,7.15 241.17,6.18 LEDB4.C2
BITS_GPIO0: length 10.8
  TOP w0.127: R1097.2 185.37,211.91 185.12,212.17 185.12,214.45 185.37,214.71 R1096.2 v1(185.63,215.54) 185.63,215.85 186.19,216.41 187.46,216.41 188.57,217.52 188.63,217.52 U68.73
  BOTTOM w0.127: v1(185.63,215.54) 185.96,215.87 v2(185.96,216.76)
BITS_GPIO1: length 10.8
  TOP w0.127: R1098.2 184.12,212.4 184.12,214.41 184.42,214.71 R1099.2 184.62,215.36 v3(184.64,215.39) 184.64,215.58 185.73,216.67 187.22,216.67 188.13,217.59 U68.72
  BOTTOM w0.127: v2(184.75,214.22) 184.64,214.33 v3(184.64,215.39)
BITS_GPIO2: length 10.1
  TOP w0.127: U68.74 189.13,217.47 187.59,215.93 v1(187.06,215.93) 186.9,215.93 186.65,215.68 R1101.2 186.37,214.71 186.13,214.47 186.13,212.43 R1100.2
  BOTTOM w0.127: v1(187.06,215.93) 186.97,215.84 186.97,214.92 v2(186.72,214.67)
BITS_GPIO3: length 9.6
  TOP w0.127: R1102.2 187.13,212.45 187.13,214.51 187.33,214.71 R1103.2 187.66,215.22 v1(189.32,216.88) 189.63,217.19 U68.75
  BOTTOM w0.127: v1(189.32,216.88) 188.36,217.84 v2(188.31,217.84)
BITS_PCLK: length 6.5
  TOP w0.127: R1089.1 180.25,235.1 R1088.1 180.27,233.94 180.81,233.4 182.81,233.4 183.13,233.07 U68.39
BITS_RCLK_R: length 5.8
  TOP w0.127: U68.24 190.63,232.81 192.29,234.46 193.02,234.46 R332.2 R1237.2
BITS_RD: length 10.3
  TOP w0.127: RB1210.2 174.92,232.77 175.54,233.4 177.46,233.4 177.58,233.27 R1112.2 R1113.2 178.21,231.87 v1(178.46,231.62) 178.53,231.56 178.53,230.91 179.87,229.57 U68.42
  BOTTOM w0.127: v2(177.7,232.38) v1(178.46,231.62)
BITS_RD_IN: length 69.3
  TOP w0.127: v1(173.05,233.21) 173.05,232.76 173.43,232.38 RB1210.1 ; P1.Y16 v4(114.29,225.46)
  S9 w0.127: v1(173.05,233.21) 172.3,233.21 168.05,228.95 167.42,228.95 166.57,228.1 166.3,228.1 165.51,227.3 146.79,227.3 145.34,228.75 138.33,228.75 135.17,231.9 127.88,231.9 123.96,227.98 122.31,227.98 121.2,226.86 119.85,226.86 119.37,226.37 116.47,226.37 116.06,225.97 114.8,225.97 v4(114.29,225.46)
  BOTTOM w0.127: v1(173.05,233.21) 173,233.26 v2(173,234.41)
BITS_RDY_O: length 80.3
  TOP w0.127: R1119.1 170.21,230.35 v1(169.64,229.78) ; P1.J12 v4(102.29,221.46)
  S9 w0.127: v4(102.29,221.46) 102.72,221.46 103.25,220.92 114.58,220.92 115.37,221.71 116.74,221.71 117.31,222.29 118.91,222.29 119.42,221.78 120.88,221.78 121.99,222.88 122.77,222.88 122.86,222.79 133.19,222.79 135.79,225.4 166.27,225.4 166.72,224.95 167.4,224.95 167.72,225.27 167.72,227.86 v1(169.64,229.78)
  BOTTOM w0.127: v1(169.64,229.78) 169.19,230.22 v2(169.19,230.92)
BITS_RDY_R: length 9.1
  TOP w0.127: R1119.2 R1120.1 177.38,231.37 177.58,231.17 R1118.1 177.7,230.86 v1(178.97,229.59) 179.09,229.59 179.61,229.07 U68.43
  BOTTOM w0.127: v2(178.72,230.6) 178.59,230.48 178.59,229.97 v1(178.97,229.59)
BITS_REST: length 66.8
  TOP w0.127: R1091.1 169.68,225.27 168.41,226.54 v1(167.22,226.54) ; P1.W13 v4(113.29,222.46)
  S9 w0.127: v1(167.22,226.54) 166.91,226.22 135.35,226.22 132.55,223.43 125.97,223.43 124.54,224.86 123.08,224.86 122.83,224.61 122.22,224.61 121.48,223.87 120.72,223.87 120.08,223.24 119.03,223.24 118.84,223.05 113.88,223.05 v4(113.29,222.46)
  BOTTOM w0.127: v2(169,227.11) 167.8,227.11 v1(167.22,226.54)
BITS_RJ48_RRING: length 13.2
  S9 w0.508: v1(245.46,31.87) 246.66,30.67 246.66,26.72 249.11,24.28 RJ1.D1
  BOTTOM w0.254: v1(245.46,31.87) 245.88,31.87 v2(246.47,31.28)
  BOTTOM w0.508: v1(245.46,31.87) 245.45,31.88 F4.1
BITS_RJ48_RTIP: length 16.7
  S12 w0.508: v1(244.59,29.49) 247.74,26.34 247.74,21.04 RJ1.D2
  BOTTOM w0.254: v1(244.59,29.49) 244.64,29.49 245.27,28.86 v2(245.27,28.74)
  BOTTOM w0.508: F3.1 242.11,29.69 244.39,29.69 v1(244.59,29.49)
BITS_RJ48_TRING: length 15.5
  TOP w0.508: F2.1 243.2,28.55 v1(243.74,28.55)
  S12 w0.508: RJ1.D4 245.3,27.05 243.81,28.55 v1(243.74,28.55)
  BOTTOM w0.254: v2(244.38,26.9) 244.38,27.91 v1(243.74,28.55)
BITS_RJ48_TTIP: length 12.4
  TOP w0.508: F1.1 244.85,30.48 v1(245.41,30.48)
  S9 w0.508: v1(245.41,30.48) 245.41,24.86 RJ1.D5
  BOTTOM w0.254: v1(245.41,30.48) 245.88,30.48 v2(247.17,29.18)
BITS_RLOS: length 6.4
  TOP w0.127: U68.25 190.13,233.35 v1(190.58,233.79) 191.56,234.77 R333.2 R1079.1
  BOTTOM w0.127: v1(190.58,233.79) 190.4,233.61 190.4,232.7 v2(190.78,232.32)
BITS_RRING: length 212.9
  TOP w0.095: U68.8 194.99,224.07 195.11,224.18 195.89,224.18 v3(196.17,223.91) ; R943.2 243.17,68.34 243.27,68.44 243.49,68.44 243.58,68.53 243.58,68.55 243.58,68.63 243.58,68.76 245.08,70.25 245.08,73.53 244.1,74.51 240.87,74.51 240.78,74.41 240.78,73.65 240.43,73.3 240.43,73.1 v1(241.19,72.34) 241.39,72.53 242.76,72.53 U50.7
  S16 w0.108: v3(196.17,223.91) 196.46,224.2 197.34,224.2 197.89,224.76 199.36,224.76 200.82,223.3 206.33,223.3 220.06,209.58 220.06,178.08 213.33,171.35 213.33,131.54 217.28,127.59 217.28,103.84 218.68,102.44 235.63,102.44 237.84,100.23 237.84,73.63 238.88,72.58 240.02,72.58 240.32,72.89 240.64,72.89 v1(241.19,72.34)
  BOTTOM w0.095: R843.2 241.16,72.37 v1(241.19,72.34) ; v2(195.38,223.91) v3(196.17,223.91)
BITS_RRING_R: length 4.2
  TOP w0.095: U53.3 242.3,65.97 v1(242.31,65.98) 243.17,66.84 R943.1
  BOTTOM w0.095: v2(241.39,66.71) 241.58,66.71 v1(242.31,65.98)
BITS_RST: length 11.2
  TOP w0.127: R1092.1 R1091.2 177.51,225.27 177.58,225.2 R1090.1 177.78,224.57 U68.52 181.51,224.57 v1(182.15,223.94)
  BOTTOM w0.127: v1(182.15,223.94) 181.96,223.94 181.07,223.05 v2(181.07,222.35)
BITS_RT_R: length 5.2
  BOTTOM w0.127: v2(243.61,70.01) 242.28,70.01 241.38,70.91 C518.1 240.39,71.47 R843.1 R842.1
BITS_RTIP: length 213.9
  TOP w0.095: U50.1 237.64,73.75 v1(239.36,73.75) 239.8,73.3 240.11,73.3 240.55,73.74 240.55,74.51 240.78,74.73 244.2,74.73 245.3,73.63 245.3,70.16 243.81,68.67 243.81,68.62 243.81,68.53 243.91,68.43 244.12,68.43 244.22,68.34 R944.2 ; v3(196.17,224.73) 195.88,224.44 195.12,224.44 194.99,224.57 U68.9
  S16 w0.108: v1(239.36,73.75) 239.72,73.75 240.16,73.31 240.16,73.04 239.92,72.81 238.98,72.81 238.06,73.72 238.06,100.33 235.73,102.67 218.78,102.67 217.51,103.94 217.51,127.68 213.55,131.64 213.55,171.26 220.28,177.99 220.28,209.67 206.43,223.53 200.91,223.53 199.45,224.99 197.8,224.99 197.24,224.43 196.46,224.43 v3(196.17,224.73)
  BOTTOM w0.095: v2(196.85,225.12) 196.56,225.12 v3(196.17,224.73) ; R842.2 v1(239.36,73.75)
BITS_RTIP_R: length 4.2
  TOP w0.095: R944.1 244.21,66.62 v1(244.85,65.98) 244.85,64.37 U53.1
  BOTTOM w0.095: v2(244.82,67.22) 244.85,67.19 v1(244.85,65.98)
BITS_RVDD3V3: length 7.1
  TOP w0.254: v1(192.91,224.84) 193.13,225.07 U68.10 195.41,225.07
  TOP w0.508: 197.64,224.64 196.82,225.46 195.8,225.46 195.41,225.07
  BOTTOM w0.381: CB1068.1 CB1067.1 192.88,224.81 v1(192.91,224.84)
  vias: v1(197.32,223.54) v1(198.08,223.92) v2(198.91,224.24)
BITS_RXCAS: length 139.8
  TOP w0.127: v1(185.77,242.83) 193.54,242.83 196.5,239.88 196.5,237.86 197.76,236.6 RB1216.2 ; P1.D14 v4(97.29,223.46)
  S9 w0.127: v1(185.77,242.83) 185.43,242.49 181.21,242.49 180.79,242.06 169.36,242.06 168.11,240.82 165.95,240.82 164.11,238.99 161,238.99 160.24,239.75 157.32,239.75 156.49,240.57 149.51,240.57 145.19,244.89 142.84,244.89 142.4,245.34 140.55,245.34 140.11,244.89 100.74,244.89 96.74,240.89 93.44,240.89 91.15,238.61 91.15,235.56 90.34,234.75 90.34,229.32 90.61,229.05 91.41,229.05 92.36,228.1 93.29,228.1 94.07,227.32 94.07,226.39 95.79,224.67 95.79,224.32 96.1,224 96.75,224 v4(97.29,223.46)
  BOTTOM w0.127: v1(185.77,242.83) 185.93,242.67 v2(187.1,242.67)
BITS_RXCAS_R: length 9.5
  TOP w0.127: U68.19 195.45,229.57 197.14,231.25 v1(197.14,232.32) 197.76,232.94 RB1216.1
  BOTTOM w0.127: v1(197.14,232.32) 196.25,233.21 v2(195.86,233.21)
BITS_RXCRCS: length 132.4
  TOP w0.127: v1(194.53,240.13) 195.72,238.94 RB1217.2 ; P1.D15 v4(97.29,224.46)
  S9 w0.127: v1(194.53,240.13) 192.52,242.13 181.67,242.13 180.93,241.39 173.02,241.39 172.59,240.96 171.71,240.96 170.74,240 165.63,240 164.3,238.67 160.81,238.67 160.18,239.3 157.22,239.3 156.27,240.26 149.44,240.26 145.08,244.62 142.46,244.62 142.12,244.96 140.94,244.96 140.6,244.62 121.43,244.62 121,244.19 100.74,244.19 97.07,240.53 94.15,240.53 92.37,238.74 92.37,237.85 92.29,237.77 92.29,236.57 93.02,235.85 93.02,234.1 94.15,232.97 94.15,231.94 95.77,230.32 95.77,228.01 96.74,227.05 96.74,225.01 v4(97.29,224.46)
  BOTTOM w0.127: v1(194.53,240.13) 194.59,240.19 v2(194.59,241.21)
BITS_RXCRCS_R: length 7.6
  TOP w0.127: RB1217.1 v1(194.79,234.15) 194.63,233.98 192.62,233.98 191.63,232.99 U68.22
  BOTTOM w0.127: v1(194.79,234.15) 195.67,235.03 v2(195.67,235.43)
BITS_RXS: length 104
  TOP w0.127: P1.N21 v4(107.29,230.46) ; RB1220.1 196.74,236.93 196.12,237.55 196.12,239.37 194.58,240.9 185.12,240.9 v1(184.87,240.65)
  S9 w0.127: v4(107.29,230.46) 107.83,231 109,231 109.4,231.4 109.4,232.07 113.84,236.51 120.2,236.51 120.22,236.5 142.64,236.5 144.01,235.12 145.43,235.12 149,231.55 168.01,231.55 172.72,236.26 175.16,236.26 177.07,238.16 181.13,238.16 183.62,240.65 v1(184.87,240.65)
  BOTTOM w0.127: v2(186.21,240.89) 185.11,240.89 v1(184.87,240.65)
BITS_RXS_R: length 8.1
  TOP w0.127: RB1220.2 196.74,234.19 v1(196.79,234.13) 195.39,232.73 195.39,230.23 195.23,230.07 U68.20
  BOTTOM w0.127: v1(196.79,234.13) 197.53,233.4 v2(197.77,233.4)
BITS_RXSCLK: length 4
  TOP w0.127: U68.18 194.98,229.07 195.01,229.11 v1(195.27,229.11)
  BOTTOM w0.127: v1(195.27,229.11) 195.43,228.94 R1128.2 ; R1128.2 R1129.2 ; R1128.2 195.98,229.95 R1131.2
BITS_RXSER: length 104.3
  TOP w0.127: P1.M15 v4(106.29,224.46) ; RB1218.2 v1(190.52,236.71)
  S9 w0.127: v1(181.19,238.92) 180.72,238.45 174.88,238.45 173.02,236.6 172.5,236.6 167.7,231.8 150.28,231.8 150.13,231.96 149.27,231.96 145.7,235.52 144.08,235.52 142.85,236.75 120.57,236.75 120.3,237.02 108.59,237.02 106.75,235.17 106.75,233.82 106.51,233.58 106.51,232.99 105.89,232.37 105.89,224.85 v4(106.29,224.46)
  S14 w0.127: v1(190.52,236.71) 188.31,238.92 v1(181.19,238.92)
  BOTTOM w0.127: v1(190.52,236.71) 190.52,236.2 v2(190.91,235.81)
BITS_RXSER_R: length 4.3
  TOP w0.127: U68.26 189.63,233.65 v3(189.64,233.65) 189.64,233.88 190.52,234.75 RB1218.1
  BOTTOM w0.127: v2(189.39,234.41) 189.64,234.16 v3(189.64,233.65)
BITS_TCLK_2M: length 71
  TOP w0.127: v1(128.87,183.74) 130.23,185.1 135.96,185.1 136.85,184.21 R1404.1 ; P1.D9 v4(97.29,217.46)
  S7 w0.127: v1(128.87,183.74) 125.84,183.74 110.15,199.43 106.96,199.43 104.11,202.27 104.11,203.64 105.82,205.35 105.82,206.6 104.49,207.93 102.77,207.93 101.85,208.86 101.85,217.61 101.49,217.97 97.78,217.97 97.29,217.47 v4(97.29,217.46)
BITS_TCLK_2M_R: length 4.3
  TOP w0.127: R1404.2 145.41,181.92 U77.43
BITS_TCLK_R: length 4.2
  TOP w0.127: R1018.2 R1236.2 188.43,233.42 188.13,233.13 U68.29
BITS_TRING: length 215.1
  TOP w0.095: U68.3 194.87,221.57 195.23,221.93 195.81,221.93 v3(196.07,221.66) ; R947.2 237.22,68.2 237.22,68.66 237.71,69.15 237.9,69.15 239.98,69.15 240.19,69.36 240.19,70.1 239.95,70.33 v1(239.61,70.33) 239.21,69.93 U50.4
  S16 w0.108: v3(196.07,221.66) 195.78,221.96 194.22,221.96 194.12,221.86 194.12,219.6 194.76,218.96 199.04,218.96 200.67,220.59 207.23,220.59 218.53,209.28 218.53,178.84 211.92,172.23 211.92,162.26 208.65,159 208.65,150.58 211.12,148.11 211.12,132.92 212.74,131.3 212.74,122.06 214.81,120 214.81,105.68 216.31,104.17 216.31,102.83 217.86,101.28 235.87,101.28 237.01,100.14 237.01,70.77 238.45,69.33 239.33,69.33 239.61,69.61 v1(239.61,70.33)
  BOTTOM w0.095: v3(196.07,221.66) 196.62,221.66 196.92,221.37 v2(196.92,220.65)
BITS_TRING_R: length 4
  TOP w0.095: R947.1 236.8,66.56 v1(236.34,66.11) 235.95,65.71 U53.8
  BOTTOM w0.095: v2(235.55,66.9) v1(236.34,66.11)
BITS_TRR_R: length 4.3
  TOP w0.508: v1(243.67,65.94) 243.57,65.83 U53.2
  BOTTOM w0.381: v2(242.09,64.68) 242.32,64.91 C573.1
  BOTTOM w0.508: C573.1 v1(243.67,65.94)
BITS_TRT_R: length 4
  TOP w0.508: U53.7 v1(237.22,65.86)
  BOTTOM w0.381: C637.1 238.56,64.91 v2(238.73,64.74)
  BOTTOM w0.508: C637.1 237.25,65.84 v1(237.22,65.86)
BITS_TTIP: length 208.2
  TOP w0.095: v3(196.07,222.48) 195.76,222.16 195.23,222.16 194.82,222.57 U68.5
  S16 w0.108: v3(196.07,222.48) 195.78,222.18 194.13,222.18 193.89,221.95 193.89,219.5 194.67,218.73 199.14,218.73 200.77,220.36 207.13,220.36 218.3,209.19 218.3,178.94 211.69,172.32 211.69,162.36 208.42,159.09 208.42,150.49 210.89,148.02 210.89,132.83 212.51,131.2 212.51,121.97 214.58,119.9 214.58,105.59 216.08,104.08 216.08,102.74 217.77,101.06 235.77,101.06 236.78,100.05 236.78,70.68 238.36,69.1 239.33,69.1 239.55,68.89 v1(239.55,68.11)
  BOTTOM w0.095: v1(239.55,68.11) 239.68,68.23 C538.1 ; v2(196.92,222.6) 196.2,222.6 v3(196.07,222.48)
BITS_TVDD3V3: length 4.1
  TOP w0.254: U68.4 193.12,222.07 v3(192.94,221.89)
  BOTTOM w0.254: CB1074.1 192.9,221.85 v3(192.94,221.89) 193.05,221.79 CB1073.1
  BOTTOM w0.381: v2(200.18,219.8) 199.42,219.8 199.04,220.18
  vias: v1(198.09,220.94) v1(198.09,219.86)
BITS_TXMSYNC: length 7.2
  TOP w0.127: R1130.2 R1126.2 R1127.2 186.36,234.42 v1(186.64,234.15) 187.16,233.63 187.16,232.04 U68.31
  BOTTOM w0.127: v1(186.64,234.15) 186.64,235.38 v2(186.27,235.75)
BITS_TXON: length 5.6
  TOP w0.127: U68.79 191.63,219.83 v3(191.65,219.85)
  BOTTOM w0.127: v2(192.43,218.95) 191.76,219.63 191.76,219.74 v3(191.65,219.85) 190.95,220.55 R1095.2 R1094.2 R1093.2
BITS_TXS: length 88.7
  TOP w0.127: RB1221.1 183.32,236.92 v1(183.35,236.95) ; P1.P15 v4(108.29,224.46)
  S9 w0.127: v1(183.35,236.95) 183.35,236.17 182.88,235.7 176.89,235.7 175.92,234.73 173.07,234.73 167.99,229.65 167.35,229.65 166.34,228.64 165.76,228.64 165,227.87 147.23,227.87 144.92,230.18 137.75,230.18 135.52,232.41 125.79,232.41 125.5,232.13 122.52,232.13 121.25,230.86 121.25,230.1 118.08,226.92 109.01,226.92 108.7,226.62 108.7,224.87 v4(108.29,224.46)
  BOTTOM w0.127: v2(182.59,237.72) v1(183.35,236.95)
BITS_TXS_R: length 7.5
  TOP w0.127: RB1221.2 183.32,234.77 183.68,234.4 v1(185.07,234.4) 185.62,234.4 186.68,233.34 186.68,232.06 U68.32
  BOTTOM w0.127: v1(185.07,234.4) 184.37,235.1 v2(184.37,236)
BITS_TXSER: length 96.5
  TOP w0.127: v1(184.94,239.68) 187.39,237.23 RB1219.2 ; P1.N17 v4(107.29,226.46)
  S9 w0.127: v1(184.94,239.68) 183.1,239.68 181.27,237.86 177.78,237.86 177.19,237.27 176.62,237.27 175.29,235.94 172.81,235.94 167.95,231.07 147.19,231.07 142.84,235.43 134.23,235.43 133.85,235.05 121.14,235.05 119.94,236.26 114.71,236.26 113.88,235.43 113.88,234.1 111.85,232.06 111.85,231.58 110.52,230.25 109.44,230.25 107.89,228.7 107.89,227.06 v4(107.29,226.46)
  BOTTOM w0.127: v1(184.94,239.68) 184.81,239.81 v2(183.67,239.81)
BITS_TXSER_R: length 5.1
  TOP w0.127: RB1219.1 v1(187.39,234.35) 187.39,234.05 187.63,233.81 U68.30
  BOTTOM w0.127: v2(188.24,235.94) 187.48,235.18 187.48,234.44 v1(187.39,234.35)
BITS_TYPE0: length 10.8
  TOP w0.127: U68.78 191.13,216.2 191.73,215.6 R1087.2 R1086.2 192.85,214.71 193.22,214.33 193.22,212.73 v1(192.69,212.19) 192.41,211.91 RB1215.1
  BOTTOM w0.127: v1(192.69,212.19) 192.12,211.62 v2(191.35,211.62)
BITS_TYPE1: length 10.5
  TOP w0.127: RB1213.1 191.24,212.44 191.24,214.49 191.02,214.71 R1084.2 R1085.2 189.7,215.57 v1(189.94,215.81) 190.63,216.51 U68.77
  BOTTOM w0.127: v1(189.94,215.81) 189.94,215.06 v2(190.66,214.35)
BITS_TYPE2: length 10.2
  TOP w0.127: RB1214.1 R1082.2 188.16,212.44 188.16,214.61 188.25,214.71 R1083.2 188.68,215.38 v1(188.86,215.56) 190.13,216.84 U68.76
  BOTTOM w0.127: v1(188.86,215.56) 188.86,214.71 v2(188.61,214.46)
BITS_TYPE-0: length 154.9
  TOP w0.127: P1.C14 v4(96.29,223.46) ; v1(178.46,213.14) 178.02,212.7 178.02,211.17 180.31,208.89 190.59,208.89 191.73,210.02 RB1215.2
  S9 w0.127: v4(96.29,223.46) 95.95,223.46 95.47,223.94 94.96,223.94 94.52,224.38 94.52,225.4 93.69,226.23 93.69,227.11 93.12,227.67 92.24,227.67 91.21,228.7 90.35,228.7 90,229.05 90,236.63 89.56,237.07 89.56,238.22 92.6,241.25 96.59,241.25 100.5,245.16 129.33,245.16 131.22,247.05 138.78,247.05 139.35,246.48 144.17,246.48 145.96,244.69 154.17,244.69 154.39,244.91 159.46,244.91 v1(164.24,240.13)
  S12 w0.127: v1(178.46,213.14) 178.34,213.14 175.98,215.5 173.69,215.5 167.44,221.75 167.44,224.1 166.65,224.89 166.65,229.31 166.78,229.44 166.78,232.9 164.24,235.44 v1(164.24,240.13)
  BOTTOM w0.127: v2(178.78,214.09) 178.78,213.46 v1(178.46,213.14)
BITS_TYPE-1: length 118.5
  TOP w0.127: v1(178.65,211.81) 178.72,211.74 178.72,211.11 180.31,209.52 190.34,209.52 190.71,209.9 RB1213.2 ; v1(91.98,220.89) 92.36,220.51 96.13,220.51 96.68,219.96 P1.C11
  S9 w0.127: v1(91.98,220.89) 91.98,220.69 93.64,219.03 94.53,219.03 95.67,220.18 113.5,220.18 113.93,220.6 114.84,220.6 115.63,221.4 117,221.4 117.63,222.03 118.81,222.03 119.32,221.52 121.36,221.52 121.68,221.84 123.13,221.84 123.77,222.48 133.32,222.48 135.86,225.02 165.7,225.02 v1(166.46,224.25)
  S12 w0.127: v1(178.65,211.81) 175.6,214.87 173.32,214.87 166.42,221.76 166.42,224.22 v1(166.46,224.25)
  BOTTOM w0.127: v2(167.61,224.19) 166.53,224.19 v1(166.46,224.25)
BITS_TYPE-2: length 126.6
  TOP w0.127: RB1214.2 189.7,210.23 v1(189.7,210.22) ; P1.C10 v4(96.29,218.46)
  S7 w0.127: v1(96.13,203.25) 96.1,203.25 97.62,204.76 97.62,206.45 98.87,207.71 98.87,216.71 98.6,216.98 96.84,216.98 96.29,217.53 v4(96.29,218.46)
  S9 w0.127: v1(189.7,210.22) 189.21,210.72 166.98,210.72 166.04,211.66 144.79,211.66 143.95,210.82 141.27,210.82 137.18,206.73 135.47,206.73 135.16,206.41 135.16,205.51 134.19,204.55 131.64,204.55 130.85,203.76 130.85,200.2 129.58,198.93 129.52,198.93 128.56,197.97 100.04,197.97 96.13,201.88 v1(96.13,203.25)
  BOTTOM w0.127: v2(189.77,209.08) 189.77,210.16 v1(189.7,210.22)
BITS_VDD1V8: length 7.3
  TOP w0.254: U68.13 195.02,226.57 v3(195.23,226.78) ; U68.14 v3(192.94,227.07) ; U68.11 v3(192.94,225.57)
  BOTTOM w0.381: v3(192.94,227.07) 192.77,226.9 CB1082.1 191.99,226.77 CB1079.1 ; v3(192.94,225.57) 192.68,225.83 CB1081.1 ; CB1080.1 195.36,226.92 v3(195.23,226.78)
  vias: v1(198.09,227.54) v1(198.09,226.53) v2(199.01,226.49)
BITS_WR: length 12.6
  TOP w0.127: U68.67 185.63,217.75 184.14,216.25 182.59,216.25 v1(182.11,215.78) 181.58,215.24 R1115.2 181.84,214.68 182.07,214.44 182.07,212.16 181.86,211.95 R1114.2 RB1211.2
  BOTTOM w0.127: v1(182.11,215.78) 181.83,215.49 v2(181.83,214.35)
BITS_WR_IN: length 86
  TOP w0.127: RB1211.1 v1(180.55,210.17) ; P1.Y19 v4(114.29,228.46)
  S9 w0.127: v1(166.27,229.65) 166.21,229.65 165.89,229.33 147.59,229.33 144.99,231.93 138.61,231.93 137.37,233.17 125.34,233.17 125.1,232.93 119.52,232.93 116.61,230.03 116.55,230.03 114.98,228.46 v4(114.29,228.46)
  S12 w0.127: v1(166.27,229.65) 166.27,229.65 165.87,229.26 165.87,221.36 172.98,214.26 174.68,214.26 178.76,210.17 v1(180.55,210.17)
  BOTTOM w0.127: v2(166.4,230.6) 166.27,230.48 v1(166.27,229.65)
BITS_XFMR_R_RRING: length 9.7
  TOP w0.508: v2(242.3,55.61) v1(242.3,53.77) ; U60.1 246.36,50.77 v1(245.44,51.69)
  S12 w0.508: v1(245.44,51.69) 244.38,51.69 v1(242.3,53.77)
  BOTTOM w0.254: v2(242.3,55.61) v1(242.3,53.77)
BITS_XFMR_R_RTIP: length 7.9
  TOP w0.508: U60.2 243.82,52.82 244.7,53.69 v1(244.76,53.69) 244.76,53.75 244.84,53.83 v2(244.84,55.61)
  BOTTOM w0.381: v2(244.84,55.61) 244.84,53.78 v1(244.76,53.69)
BITS_XFMR_R_TRING: length 8.9
  TOP w0.508: U59.1 v1(239.42,51.76) ; v1(235.95,54.24) v2(235.95,55.61)
  S12 w0.508: v1(235.95,54.24) 238.44,51.76 v1(239.42,51.76)
  BOTTOM w0.254: v2(235.95,55.61) v1(235.95,54.24)
BITS_XFMR_R_TTIP: length 8.4
  TOP w0.508: v2(238.49,55.61) v1(238.49,53.42) 236.88,51.81 U59.2
  BOTTOM w0.381: v2(238.49,55.61) v1(238.49,53.42)
BITS_XFMR_TTIP: length 12.3
  TOP w0.095: R948.2 237.45,68.19 237.45,68.56 237.81,68.93 240.08,68.93 240.41,69.26 240.41,70.18 v1(240.63,70.39) 240.63,70.7 241.12,71.2 U50.6
  BOTTOM w0.095: v1(240.63,70.39) 241.2,69.82 C538.2 241.2,68.43 241.66,67.98 v2(242.98,67.98)
BITS_XFMR_TTIP_R: length 4
  TOP w0.095: R948.1 237.86,66.43 v1(238.25,66.04) 238.49,65.8 U53.6
  BOTTOM w0.095: v2(239.23,66.71) 238.92,66.71 v1(238.25,66.04)
BOARD_ID0: length 14.6
  TOP w0.127: v4(200.55,195.58) U9.E11 ; RB25.1 v1(200.37,205.65) RB9.1
  BOTTOM w0.127: v4(200.55,195.58) 200.17,195.58 199.71,196.04 199.31,196.04 198.3,197.06 198.3,200.64 198.28,200.66 198.28,201.78 v2(198.53,202.03) 198.53,203.81 v1(200.37,205.65)
BOARD_ID1: length 16.3
  TOP w0.127: RB10.1 v1(201.45,205.59) RB26.1 ; v4(201.55,195.58) U9.E12
  BOTTOM w0.127: v2(201.45,206.66) v1(201.45,205.59) 199.69,203.83 199.69,200.74 198.81,199.85 198.81,197.44 199.19,197.06 199.69,197.06 200.08,196.67 200.08,196.4 200.44,196.04 201.09,196.04 v4(201.55,195.58)
BOARD_ID2: length 13.9
  TOP w0.127: v4(202.55,195.58) U9.E13 ; RB11.1 v1(202.53,205.59) RB27.1
  BOTTOM w0.127: v1(202.53,205.59) 202.53,205.08 200.88,203.43 v2(200.88,202.28) 201.01,202.16 201.01,197.4 201.38,197.03 201.77,197.03 202.55,196.25 v4(202.55,195.58)
BODE PLOT_1V2: length 17.5
  TOP w0.254: R627.1 v1(126.74,174.16) 126.79,174.21 R634.2
  S16 w0.508: v1(126.74,174.16) 127.45,174.16 129.41,172.19 129.41,170.95 127.54,169.08 124.29,169.08 122.31,167.09 v1(122.31,166.86)
  BOTTOM w0.254: v1(126.74,174.16) v2(127.67,174.16)
  BOTTOM w0.508: v1(122.31,166.86) 122.67,167.23 CB408.1
BODE PLOT_2V5: length 4.5
  TOP w0.254: R572.2 41.96,196.07 41.56,195.67 R558.1 v1(41,196.56)
  BOTTOM w0.508: v2(40.73,197.77) 40.73,196.83 v1(41,196.56) 41.08,196.48 CB509.1
BOOT9_5: length 3.6
  TOP w0.254: U39.9 101.68,117.18 v1(102.2,117.7)
  TOP w0.381: C348.1 102.84,118.34 v1(102.2,117.7)
  BOTTOM w0.381: v1(102.2,117.7) 102.2,118.35 v2(102.07,118.48)
BOOT9_6: length 3.7
  TOP w0.254: v1(102.2,133.58) 101.94,133.58 101.29,132.93 U30.9
  TOP w0.381: C283.1 v1(102.2,133.58)
  BOTTOM w0.381: v2(103.14,134.34) 102.38,133.58 v1(102.2,133.58)
BOOT__R8_5: length 3.9
  TOP w0.254: v1(102.19,116.93) 101.94,116.68 U39.8
  TOP w0.381: v1(102.19,116.93) 102.33,117.07 R670.2
  BOTTOM w0.381: v2(103.42,116.93) v1(102.19,116.93)
BOOT__R8_5_R: length 2.9
  TOP w0.381: R670.1 104.74,117.96 v1(104.61,118.08) 104.36,118.34 C348.2
  BOTTOM w0.381: v2(105.32,117.35) 104.61,118.06 v1(104.61,118.08)
BOOT__R8_6: length 3.4
  TOP w0.254: R515.2 102.45,132.23 102.2,132.49 101.64,132.49 v1(101.64,132.48) 101.58,132.43 U30.8
  BOTTOM w0.381: v2(102.4,132.28) 102.2,132.48 v1(101.64,132.48)
BOOT__R8_6_R: length 5.3
  TOP w0.254: R515.1 104.61,131.87 104.18,131.44 104.18,130.6 v1(104.08,130.5)
  TOP w0.381: R515.1 104.61,133.02 104.05,133.58 C283.2
  BOTTOM w0.381: v1(104.08,130.5) 104.28,130.7 v2(104.28,131.94)
BPCAP: length 4.9
  TOP w0.254: U7.47 234.08,213.53 v1(234.15,213.46) 234.15,213.21 233.93,212.98 C109.1 C110.2
  BOTTOM w0.127: v1(234.15,213.46) 234.98,212.63 v2(234.98,212.44)
BS_PLL_AVDD1P8: length 4.5
  TOP w0.381: U40.U31 v4(26.7,113.65)
  BOTTOM w0.381: v1(14.73,100.56) 15.9,100.56 v2(16.03,100.43) ; CB597.1 26.76,113.65 v4(26.7,113.65) 26.7,113.74 CB596.1 CB595.1
  vias: v1(14.05,100.56)
BS_VCC5P0: length 3.7
  TOP w0.508: U34.1 v1(253.26,160.68)
  BOTTOM w0.254: v1(253.26,160.68) 252.95,160.37 v2(252.95,159.48)
  BOTTOM w0.508: CB440.1 253.33,160.75 v1(253.26,160.68)
BU_CPLD2_TDO: length 4.9
  TOP w0.127: U22.2 183.79,176.25 183.91,176.38 v1(183.92,176.38) 184.12,176.38 185.22,177.48 R349.1
  BOTTOM w0.127: v2(184.31,175.04) 184.31,175.99 v1(183.92,176.38)
