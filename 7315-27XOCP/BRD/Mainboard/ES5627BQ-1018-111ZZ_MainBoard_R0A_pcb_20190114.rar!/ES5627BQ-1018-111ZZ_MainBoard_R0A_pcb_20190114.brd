# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDD33_MINI_OSC5: length 7.8
  TOP w0.508: R210.1 200.94,235.38 L7.1 202.21,236.51 C136.2 202.66,235.69 C137.1 C131.2 201.08,233.53 OSC2.4
VDD_3V3_1204: length 4.2
  TOP w0.254: U79.5 106.02,179.67 106.14,179.55
  TOP w0.508: C922.2 107.09,178.72 ; C923.2 107.09,177.71 ; 107.09,179.74 C925.1 ; 106.96,176.69 LB115.2
  BOTTOM w0.254: v2(105.25,178.6) 105.63,178.98 v1(106.26,178.98)
VDD_30773: length 7.7
  TOP w0.508: OSC7.4 145.14,167.19 144.93,166.99 144.93,165.39 v1(144.46,164.91) 143.75,164.91 C927.1 C924.2 142.06,164.94 LB116.2
  BOTTOM w0.127: v2(144.17,165.9) 144.17,165.19 v1(144.46,164.91)
VDD_DRI_1V8: length 9.7
  TOP w0.254: U77.12 158.33,178.92
  TOP w0.381: v1(159.73,179.04) 159.61,178.92 158.33,178.92
  TOP w0.508: v1(159.73,180.19) 159.99,179.93 C928.1 C916.1 159.86,178.92 v1(159.73,179.04)
  BOTTOM w0.127: CB1195.1 160.87,178.03 v2(161.38,177.52)
  BOTTOM w0.508: L103.2 160.11,180.57 v1(159.73,180.19) ; v1(159.73,179.04) 159.79,179.11 CB1195.1
VDD_Q01: length 4.4
  TOP w0.305: v1(11.4,56.62) 11.24,56.45 U69.30
  BOTTOM w0.381: v2(8.89,54.52) 9.32,54.52 10.02,53.83
  BOTTOM w0.508: v1(11.4,56.62) 11.36,56.57 CB1100.1 11.36,55.03
VDD_Q02: length 13.7
  TOP w0.508: 210.85,74.83 CB899.1 210.85,76.89 CB907.1
  S9 w0.508: CONN53_PF.1T30 208.99,68.57 207.86,69.7 207.86,72.64 v1(209.88,74.66)
  BOTTOM w0.127: v2(208.63,73.63) 209.65,74.66 v1(209.88,74.66)
VDD_Q03: length 26.8
  TOP w0.508: 198.78,75.16 199.09,74.85 CB900.1 199.09,73.98 v1(199.3,73.77)
  BOTTOM w0.508: CONN53_PF.1B30 209.02,58.15 209.02,60.31 208.58,60.75 200.09,60.75 198.72,62.13 198.72,71.73 v2(199.29,72.3) 199.3,72.31 v1(199.3,73.77)
VDD_RX_Q01: length 5.4
  TOP w0.356: v1(12.41,51.41) 12.44,51.43 U69.10
  BOTTOM w0.508: v1(12.41,51.41) v2(13.34,50.48) CB1098.1 13.34,49.02 13.67,48.69 CB1099.1
VDD_RX_Q02: length 15
  TOP w0.508: CB908.1 215.23,75.28
  BOTTOM w0.508: v1(214.35,75.13) 214.34,75.12 214.34,73.21 v2(214.32,73.19) 212.12,70.99 212.12,67.9 212.1,67.88 212.1,67.86 209.45,65.22 209.45,63.14 CONN53_PF.1T10
VDD_RX_Q03: length 30.5
  TOP w0.508: 204.89,76.21 CB909.1 204.89,74.64 205,74.53
  S9 w0.508: v1(205.25,73.53) 201.26,69.54 201.26,58.47 203.14,56.59 209.1,56.59 209.7,55.99 209.7,54.9 CONN53_PF.1B10
  BOTTOM w0.127: v2(204.23,74.3) 204.48,74.3 v1(205.25,73.53)
VDD_TX_Q01: length 5.2
  TOP w0.305: v1(12.23,56.69) 12.04,56.5 U69.29
  BOTTOM w0.254: v1(12.23,56.69) 12.35,56.81 12.35,58.09 v2(12.02,58.42)
  BOTTOM w0.508: 14.92,54.33 14.77,54.19 CB1094.1 ; CB1094.1 14.38,54.78 ; CB1094.1 13.82,54.19
VDD_TX_Q02: length 11
  BOTTOM w0.508: CB905.1 210.79,75.47 CB902.1 210.85,73.38 v2(210.66,73.19) 211.21,72.64 211.21,69.8 209.79,68.38 CONN53_PF.1T29
VDD_TX_Q03: length 26.7
  TOP w0.508: 206.97,74.65 206.97,74.65 CB901.1 ; CB901.1 206.41,75.42 ; CB901.1 206.97,76.16
  S12 w0.508: v1(206.45,73.32) 206.33,73.32 201.45,68.44 201.45,62.62 203.29,60.78 208.33,60.78 209.79,59.33 CONN53_PF.1B29
  BOTTOM w0.127: v2(206.09,74.71) 206.09,73.68 v1(206.45,73.32)
VDDH_1&4_3V3: length 22
  TOP w0.254: U77.38 148.17,184.37 v1(148.32,184.53) ; U77.73 153.17,173.53 v1(153.24,173.6)
  S16 w0.508: v1(148.32,184.53) 148.32,183.45 147.52,182.64 147.52,177.62 148.52,176.62 148.52,175.29 149.55,174.25 152.58,174.25 v1(153.24,173.6)
  BOTTOM w0.254: C944.1 147.96,183.75 v2(147.11,182.9)
  BOTTOM w0.381: C944.1 148.36,184.49 v1(148.32,184.53)
  BOTTOM w0.508: L105.2 149.37,183.51 149.13,183.75 C944.1 ; C945.1 153.34,173.49 v1(153.24,173.6)
VDDH_2_3V3: length 5.7
  TOP w0.254: U77.40 147.17,184.12 v1(146.78,184.51)
  BOTTOM w0.127: L106.2 148.46,187.14 v2(148.68,187.36)
  BOTTOM w0.508: v1(146.78,184.51) 146.53,184.76 C943.1 146.56,185.4 147.56,185.4 147.56,185.41 148.07,185.91 L106.2
VDDH_3_3V3: length 4.5
  TOP w0.254: U77.69 151.17,171.95 v1(151.42,171.7)
  BOTTOM w0.254: v2(151.09,169.22) 151.18,169.3 L107.2
  BOTTOM w0.508: L107.2 151.26,170.74 151.26,171.54 v1(151.42,171.7) 151.36,171.76 C942.1
VDDL_1_1V8: length 7.4
  TOP w0.254: v1(147.61,184.52) 147.67,184.46 U77.39
  TOP w0.508: v1(147.61,184.52) 147.61,185.03 147.79,185.21 C934.1 147.19,185.82 146.93,186.07 L109.2
  BOTTOM w0.254: v2(144.49,182.79) 145.88,182.79 v1(147.61,184.52)
VDDL_2&6_1V8: length 11.7
  TOP w0.254: U77.47 145.47,179.92 v1(145.44,179.88) ; v1(145.44,176.96) 145.45,176.96 145.49,176.92 U77.53 ; v1(145.39,175.79) 145.51,175.92 U77.55 ; 145.25,186.16 LB110.2 144.61,186.66 ; v1(145.49,183.48) 145.49,183.26 145.83,182.92 U77.41 ; v1(147.3,176.4) 147.29,176.42 U77.54
  BOTTOM w0.254: v2(144.52,176.93) 144.52,176.93 145.18,176.93 145.21,176.96 v1(145.44,176.96)
  BOTTOM w0.508: v1(145.49,183.48) 145.53,183.51 C931.1 ; v1(145.44,179.88) 145.45,179.9 C929.1 ; C932.1 144.69,175.37 145.11,175.79 v1(145.39,175.79) ; v1(147.3,176.4) 146.95,176.06 C930.1 ; v1(145.44,176.96) 145.61,177.13 C933.1
  vias: v1(144.65,185.65) v1(145.49,185.64)
VDDL_7&9_1V8: length 10.2
  TOP w0.254: U77.72 152.67,171.8 v1(152.78,171.69) ; v1(150.54,171.75) 150.58,171.75 150.67,171.83 U77.68 ; v1(147.62,171.71) 147.67,171.77 U77.62
  BOTTOM w0.254: v2(147.64,168.89) 147.64,171.69 v1(147.62,171.71)
  BOTTOM w0.508: C935.1 147.68,171.78 v1(147.62,171.71) ; C936.1 152.36,172.11 v1(152.78,171.69) 152.84,171.63 152.84,171.37 153.12,171.09 153.12,171.09 153.32,170.88 153.32,170.39 L108.2 ; v1(150.54,171.75) 150.1,172.19 C937.1
VDDO_3P3: length 9.8
  TOP w0.381: v4(20.7,118.65) U40.AA37 ; v4(23.7,129.65) U40.AM34 ; v4(20.7,122.65) U40.AE37 ; v4(26.7,123.65) U40.AF31 ; v4(22.7,124.65) U40.AG35 ; v4(25.7,119.65) U40.AB32
  BOTTOM w0.381: CB472.1 26.2,123.15 v4(26.7,123.65) ; CB523.1 26.19,119.15 v4(25.7,119.65) ; CB478.1 21.17,122.18 v4(20.7,122.65) ; v4(23.7,129.65) 24.2,129.14 CB394.1 ; v4(22.7,124.65) 23.12,124.22 CB454.1 ; v2(23.66,137.98) v1(22.46,137.98) ; CB544.1 20.7,118.58 v4(20.7,118.65)
  vias: v1(22.47,137.21)
VDDO_3V3: length 10.7
  TOP w0.254: U77.58 v1(145.58,174.42) ; v1(145.51,181.39) 145.53,181.42 U77.44 ; U77.50 v1(145.5,178.42) ; U77.65 v1(149.17,171.78)
  BOTTOM w0.254: C946.1 144.69,180.53 v2(144.43,180.27)
  BOTTOM w0.508: v1(145.58,174.42) 145.51,174.34 C947.1 144.69,173.27 CB1212.1 144.62,172.95 LB113.2 ; v1(149.17,171.78) 149.08,171.88 C948.1 ; C946.1 v1(145.51,181.39) ; v1(145.5,178.42) 145.68,178.24 C949.1
VDDO_FC: length 12.2
  TOP w0.381: U40.AJ36 v4(21.7,126.65) ; v4(21.7,131.65) U40.AP36
  BOTTOM w0.254: RB147.1 21.05,136.51 v1(20.98,136.58) ; v2(24.48,139.86) 23.49,139.86 22.28,138.65 CB345.2
  BOTTOM w0.381: CB380.1 21.7,131.65 v4(21.7,131.65) ; CB421.1 22.22,126.12 v4(21.7,126.65) 21.9,126.65 22.1,126.85 RB175.1
  BOTTOM w0.508: v1(20.98,136.58) v1(20.98,137.26) v1(20.98,137.95) 20.67,138.27 RB150.1 CB345.2
1PPS_FPGA_IN: length 111.3
  TOP w0.127: R1373.1 158.36,168.56 v1(158.44,168.48) ; R1353.2 v1(115.26,237.67)
  S12 w0.127: v1(158.44,168.48) 158.22,168.7 158.22,172.19 159.1,173.07 159.1,176.35 157.7,177.75 157.7,184.55 156.89,185.35 155.9,185.35 154.4,186.85 154.4,190.43 144.45,200.37 144.45,211.71 145.26,212.52 145.26,233.83 145.78,234.35 145.78,236.03 v1(144.63,237.19)
  S14 w0.127: v1(144.63,237.19) 144.1,237.72 123.09,237.72 120.87,239.94 117.53,239.94 v1(115.26,237.67)
  BOTTOM w0.127: v2(159.08,167.62) 159.08,167.84 v1(158.44,168.48)
1PPS_FPGA_IN_R: length 14.5
  TOP w0.127: P1.M21 106.22,230.4 106.22,231.45 108.04,233.27 109.75,233.27 110.26,233.78 113.19,233.78 114.58,235.18 v1(115.26,235.18) R1353.1
  BOTTOM w0.127: v1(115.26,235.18) 115.15,235.28 115.15,235.98 v2(114.65,236.49)
1PPS_GPS_IN: length 255.6
  TOP w0.127: CONN44.6 215.17,94.05 215.8,94.68 215.8,100.25 v1(216.31,100.75) ; v1(101.03,237.74) 101.07,237.71 R1351.1
  TOP w0.508: RB1261.1 v1(162.3,173.73)
  S12 w0.127: v1(162.3,173.73) 161.47,174.56 161.47,187.64 161.7,187.87 161.7,188.59 147.92,202.36 v1(147.92,224)
  S14 w0.127: v1(216.31,100.75) 212.49,100.75 211.86,101.38 208.59,101.38 204.75,105.22 199.51,105.22 198.1,106.63 196.25,106.63 191.91,110.98 191.91,120.58 174.46,138.02 156.91,138.02 154.38,140.56 152.75,140.56 151.29,142.02 151.29,142.87 148.48,145.68 148.48,147.33 149.46,148.32 152.89,148.32 153.13,148.55 153.13,156.88 161.97,165.71 161.97,169.49 162.3,169.82 v1(162.3,173.73)
  S16 w0.127: v1(138.2,234.41) 138.2,229.44 143.64,224 v1(147.92,224)
  BOTTOM w0.127: v2(147.03,224.51) 147.54,224 v1(147.92,224) ; v1(101.03,237.74) 101.06,237.77 101.06,239.68 101.97,240.6 119.26,240.6 122.65,237.21 133.95,237.21 v2(135.35,235.81) 136.24,234.92 137.7,234.92 v1(138.2,234.41)
1PPS_GPS_IN_FPGA: length 12.4
  TOP w0.127: R1351.2 101.07,235.43 v1(100.56,234.93) ; P1.G19 v4(100.29,228.46)
  S14 w0.127: v1(100.56,234.93) 100.56,234.87 100.78,234.66 100.78,228.95 v4(100.29,228.46)
  BOTTOM w0.127: v1(100.56,234.93) 100.56,234.93 100.56,237.94 100.56,237.94 100.56,238.46 v2(100.42,238.61)
1PPS_IN_T_MUX: length 252.5
  TOP w0.127: v1(233.01,158.98) 233.39,159.36 RB277.2 ; P1.L22 104.79,231.27 v1(104.44,231.62)
  S14 w0.127: v1(104.44,231.62) 104.63,231.82 104.63,235.66 103.72,236.57 103.72,239.07 104.83,240.18 107.7,240.18 111.77,244.26 128.2,244.26 128.41,244.26 129.44,243.23 134.75,243.23 135.46,242.52 142.29,242.52 143.92,240.89 145.19,240.89 148.98,237.1 148.98,230.26 152.45,226.8 157.8,226.8 161.69,222.91 161.69,216.18 169.8,208.07 179.1,208.07 179.5,207.67 208.15,207.67 212.72,203.1 212.72,165.94 209.68,162.89 209.68,152.83 210.01,152.5 211.62,152.5 212.31,151.82 212.31,145.79 218.39,139.71 232.92,139.71 235.87,142.66 235.87,148.5 234.03,150.34 234.03,157.96 v1(233.01,158.98)
  BOTTOM w0.127: v2(231.99,158.98) v1(233.01,158.98)
1PPS_IN_T_WP: length 90.8
  TOP w0.127: RB276.2 233.39,158.34 v1(233.01,157.96) ; RB1259.2 162.38,175.83 v1(162.38,175.83)
  S9 w0.127: v1(162.38,175.83) 162.43,175.83 164.56,173.71 168.68,173.71 171.99,170.41 208.25,170.41 210.47,172.63 v1(218.02,172.63)
  S14 w0.127: v1(233.01,157.96) 219.55,157.96 218.02,159.48 v1(218.02,172.63)
  BOTTOM w0.127: v1(162.38,175.83) 162.49,175.83 163.16,176.5 v2(163.16,176.69)
1PPS_OUT_BKUP: length 8
  TOP w0.127: P1.B13 95.27,222.48 93.82,222.48 93.37,222.92 91.02,222.92 v1(90.96,222.98) 90.9,222.92 R254.2
  BOTTOM w0.254: v1(90.96,222.98) 89.84,221.86 v2(89.55,221.86)
1PPS_OUT_ISO_OTC_TO_RJ: length 3.1
  TOP w0.127: v1(240.5,89.95) 240.48,89.93 U51.15
  BOTTOM w0.127: R474.2 240.69,90.14 v1(240.5,89.95)
  BOTTOM w0.254: v1(240.5,89.95) 240.57,89.89 241.46,89.89 v2(241.52,89.82)
1PPS_OUT_ISO_OTC_TO_RJ_R: length 2.9
  BOTTOM w0.127: R1172.1 R474.1
  BOTTOM w0.254: v2(238.98,92.24) 239.41,92.67 R1172.1
1PPS_OUT_N: length 29.3
  TOP w0.095: F6.2 255.01,38.25 D7.1 253.15,41.48 253.06,41.57 253.06,47.06 252.51,47.6 251.7,47.6 251.11,48.19 250.76,48.19 v3(250.47,48.48) 250.13,48.14 249.74,48.14 249.6,48.27 249.6,49.2 249.7,49.29 249.85,49.29 249.94,49.39 RB325.2 249.93,49.95 249.93,50.55 249.62,50.87 249.62,51.33 249.72,51.43 250.17,51.43 250.27,51.52 RB317.2
  BOTTOM w0.095: v3(250.47,48.48) 250.14,48.14 249.38,48.14 248.53,49 248.53,51.79 248.62,51.89 249.86,51.89 249.95,51.79 249.95,51.52 249.86,51.43 249.53,51.43 249.43,51.33 U54.4
1PPS_OUT_N_A: length 37.3
  TOP w0.095: v1(244.3,79.03) 244.01,79.32 244.01,79.74 CB896.1 244.01,80.61 244.01,81.06 243.52,81.55 243.52,81.75 243.73,81.96 U51.7 ; v3(249.94,57.43) 249.62,57.12 249.62,54.6 249.72,54.5 250.17,54.5 250.27,54.41 RB317.1
  S7 w0.108: v1(244.3,79.03) 244,78.73 244,77.75 246.78,74.97 246.78,63.42 249.62,60.58 249.62,57.75 v3(249.94,57.43)
  BOTTOM w0.095: R858.1 243.81,80.21 243.81,80.02 244.04,79.79 244.04,79.29 v1(244.3,79.03) 244,78.73 244,78.5 244.09,78.41 244.55,78.41 244.64,78.31 LB61.2
1PPS_OUT_N_A_R: length 8.8
  TOP w0.095: U51.13 241.78,87.89 241.59,87.7 241.59,87.43 243.81,85.22 243.81,84.89 v1(244.12,84.57)
  BOTTOM w0.095: v1(244.12,84.57) 243.81,84.25 243.81,82.12 243.9,82.03 244.1,82.03 244.2,81.93 R858.2
1PPS_OUT_N_R: length 30
  TOP w0.095: F6.1 253,31.91 252.73,31.64 252.73,30.12 251.81,29.19 251.81,28.79 v3(252.17,28.42)
  S14 w0.108: RJ1.C3 243.8,15.38 250.15,15.38 252.49,17.73 252.49,22.38 254.09,23.98 254.09,26.51 253.48,27.12 252.21,27.12 251.78,27.56 251.78,28.03 v3(252.17,28.42)
1PPS_OUT_P: length 30.3
  TOP w0.095: RB316.2 248.74,51.52 248.84,51.43 249.3,51.43 249.39,51.33 249.39,50.83 249.03,50.47 RB325.1 249.03,49.39 249.13,49.29 249.28,49.29 249.37,49.2 249.37,48.18 249.64,47.91 250.17,47.91 v3(250.47,47.61) 250.81,47.96 251.02,47.96 251.61,47.37 252.42,47.37 252.83,46.96 252.83,41.57 252.73,41.48 D6.1 250.78,41.38 F5.2
  BOTTOM w0.095: v3(250.47,47.61) 250.17,47.92 249.28,47.92 248.3,48.9 248.3,51.88 248.53,52.11 249.95,52.11 250.18,51.88 250.18,51.52 250.27,51.43 250.6,51.43 250.7,51.33 U54.3
1PPS_OUT_P_A: length 37.3
  TOP w0.095: U51.6 243.08,81.96 243.29,81.75 243.29,81.46 243.78,80.97 243.78,80.5 CB895.2 243.45,80.1 243.78,79.77 243.78,79.37 v1(243.44,79.03) ; v3(249.07,57.43) 249.39,57.12 249.39,54.6 249.3,54.5 248.84,54.5 248.74,54.41 RB316.1
  S7 w0.108: v1(243.44,79.03) 243.77,78.7 243.77,77.66 246.55,74.88 246.55,63.33 249.39,60.49 249.39,57.75 v3(249.07,57.43)
  BOTTOM w0.095: R857.1 243.58,80.21 243.58,79.93 243.81,79.7 243.81,79.4 v1(243.44,79.03) 243.77,78.7 243.77,78.5 243.67,78.41 243.22,78.41 243.12,78.31 LB60.2
1PPS_OUT_P_A_R: length 8.8
  TOP w0.095: v1(243.26,84.57) 243.58,84.89 243.58,85.12 241.37,87.33 241.37,87.69 241.13,87.93 U51.14
  BOTTOM w0.095: R857.2 243.18,81.93 243.28,82.03 243.48,82.03 243.58,82.12 243.58,84.25 v1(243.26,84.57)
1PPS_OUT_P_R: length 29.4
  TOP w0.095: F5.1 252.23,31.91 252.51,31.63 252.51,30.22 251.58,29.29 251.58,28.84 v3(251.16,28.42)
  S14 w0.108: v3(251.16,28.42) 251.55,28.03 251.55,27.46 252.12,26.9 253.39,26.9 253.86,26.42 253.86,24.08 252.26,22.48 252.26,17.83 250.05,15.61 245.3,15.61 244.99,15.92 244.99,16.54 245.33,16.88 RJ1.C6
1PPS_RESERVE: length 151.1
  TOP w0.127: v1(117.29,237.69) 117.31,237.67 R138.2 ; v1(168.24,143.86) 168.44,143.66 168.44,140.89 167.94,140.39 J2.A49
  S12 w0.127: v1(168.24,143.86) 164.96,143.86 163.11,145.71 163.11,153.97 166.42,157.29 166.42,159.35 174.97,167.89 174.97,186.65 158.5,203.12 157.32,203.12 156.67,203.77 156.67,207.35 157.57,208.25 v1(157.57,210.16)
  S14 w0.127: v1(117.29,237.69) 118.52,238.92 120.17,238.92 122.46,236.64 140.9,236.64 145.19,232.35 145.19,225.4 148.36,222.22 152.05,222.22 155.73,218.54 155.73,215.39 156.68,214.44 156.68,211.74 157.57,210.86 v1(157.57,210.16)
  BOTTOM w0.127: v1(157.57,210.16) 157.57,211.17 v2(157.83,211.43)
1PPS_RESERVE_R: length 17.1
  TOP w0.127: P1.R19 v4(109.29,228.46) ; R138.1 117.31,235.11 v1(117.25,235.05)
  S9 w0.127: v1(117.25,235.05) 117.25,234.46 116.73,233.94 116.73,233.32 114.77,231.37 114.77,230.22 114.52,229.97 111.03,229.97 110.84,229.78 110.84,229.08 110.65,228.89 109.72,228.89 v4(109.29,228.46)
  BOTTOM w0.127: v1(117.25,235.05) 118.9,236.7 v2(119.6,236.7)
2.048MHZ_BITS_RCLK_IN: length 79.4
  TOP w0.127: v1(173.58,193.68) 173.58,193.68 172.75,192.84 172.75,187.04 165.48,179.77 163.19,179.77 163.03,179.61 163.03,178.09 162.65,177.71 162.21,177.71 162.02,177.9 RB1260.2 ; R332.1 v1(193.64,236.69) ; R1236.1 v1(188.43,236.71)
  S9 w0.127: v1(193.64,236.69) 192.93,237.4 189.12,237.4 v1(188.43,236.71)
  S12 w0.127: v1(173.58,193.68) 173.58,193.68 173.57,193.68 173.57,198.79 186.15,211.36 186.15,232.26 188.43,234.54 v1(188.43,236.71)
4KHZ_1588_SYNC0: length 163.2
  TOP w0.127: v1(8.86,114.63) 9.24,115.01 9.24,115.47 9.44,115.67 R1186.2 ; v1(86.71,209.4) 86.71,209 87.6,208.1 R62.2
  S9 w0.127: v1(8.86,114.63) 8.95,114.63 9.72,115.41 9.72,120.56 10.3,121.13 10.3,126.91 10.56,127.17 10.56,135.52 16.47,141.44 16.84,141.8 16.84,149.25 16.81,149.28 16.81,149.28 16.76,149.33 16.76,149.33 15.4,150.69 15.4,154.58 14.5,155.48 14.5,157.16 13.08,158.58 13.08,165.75 14.82,167.49 14.82,175.49 17.85,178.52 17.85,183.81 34.14,200.1 60.78,200.1 67.36,206.69 69.09,206.69 v1(69.31,206.47) 69.51,206.47 73.49,210.46 84.47,210.46 84.61,210.6 85.5,210.6 v1(86.71,209.4)
  BOTTOM w0.127: v1(69.31,206.47) 69.62,206.79 v2(70.7,206.79)
4KHZ_1588_SYNC0_R: length 11
  TOP w0.127: P1.C5 v4(96.29,213.46) ; R62.1 90.36,207.87 v1(91.15,207.87)
  BOTTOM w0.127: v1(91.15,207.87) 92.41,207.87 v2(92.46,207.92) 92.46,208.86 92.99,209.4 92.99,211.49 94.45,212.95 95.77,212.95 v4(96.29,213.46)
10G_KR_RX0_N: length 145.5
  TOP w0.095: J2.C50 168.44,152.55 168.3,152.69 168.3,153.61 167.31,154.6 162.61,154.6 161.71,153.71 143.5,153.71 141.13,151.34 134.45,151.34 133.31,150.2 112.59,150.2 108.2,154.59 arc(107.95,154.75) 107.65,154.81 106.91,154.81 arc(106.81,154.83) 106.73,154.89 v3(106.51,155.11) ; U40.W4 v4(54.7,116.65)
  BOTTOM w0.095: v3(106.51,155.11) 106.52,155.1 106.26,154.85 arc(106.18,154.79) 106.07,154.77 104.95,154.77 arc(104.67,154.72) 104.44,154.56 103.93,154.05 arc(103.6,153.8) 103.22,153.63 arc(103,153.59) 102.77,153.57 78.94,153.57 arc(77.68,153.32) 76.61,152.61 74,150 arc(73.8,149.7) 73.73,149.34 73.73,143.85 73.73,143.85 arc(73.6,143.18) 73.22,142.61 65.35,134.74 arc(64.52,133.5) 64.23,132.04 64.23,125.56 64.23,125.56 arc(64.13,125.05) 63.84,124.61 58.44,119.21 arc(58.25,118.93) 58.18,118.6 58.18,117.71 arc(58.16,117.6) 58.1,117.51 57.93,117.34 arc(57.83,117.27) 57.72,117.25 55.18,117.25 54.95,117.02 54.95,116.79 54.8,116.65 v4(54.7,116.65)
10G_KR_RX0_P: length 145.5
  TOP w0.095: U40.W3 v4(55.7,116.65) ; J2.C49 167.94,152.52 168.07,152.65 168.07,153.52 167.21,154.38 162.71,154.38 161.81,153.48 143.59,153.48 141.22,151.11 134.55,151.11 133.4,149.97 112.49,149.97 108.04,154.42 arc(107.86,154.54) 107.65,154.58 106.91,154.58 arc(106.87,154.58) 106.83,154.57 arc(106.77,154.55) 106.73,154.51 v3(106.51,154.29)
  BOTTOM w0.095: v3(106.51,154.29) 106.4,154.41 arc(106.25,154.51) 106.07,154.54 104.95,154.54 arc(104.76,154.5) 104.6,154.4 104.09,153.89 arc(103.72,153.6) 103.28,153.41 arc(103.03,153.36) 102.77,153.34 78.94,153.34 arc(77.77,153.11) 76.77,152.44 74.16,149.83 arc(74.01,149.61) 73.96,149.34 73.96,143.85 arc(73.81,143.09) 73.38,142.45 65.51,134.58 arc(64.73,133.42) 64.46,132.04 64.46,125.56 arc(64.34,124.96) 64,124.45 61.31,121.76 arc(61.25,121.61) 61.31,121.47 arc(61.37,121.32) 61.31,121.17 61.27,121.13 arc(61.12,121.07) 60.97,121.13 60.97,121.13 arc(60.82,121.19) 60.68,121.13 58.6,119.05 arc(58.46,118.84) 58.41,118.6 58.41,117.71 arc(58.37,117.51) 58.26,117.35 58.09,117.17 arc(57.92,117.06) 57.72,117.02 55.27,117.02 55.17,116.93 55.17,116.75 55.27,116.65 v4(55.7,116.65)
10G_KR_RX1_N: length 143.9
  TOP w0.095: J2.C43 164.94,152.55 164.8,152.69 164.8,153.1 v3(165.1,153.4) ; U40.V2 v4(56.7,114.65)
  BOTTOM w0.095: v4(56.7,114.65) 56.94,114.41 56.94,114.3 57.2,114.04 64.02,114.04 arc(64.98,114.23) 65.79,114.77 66.52,115.51 arc(67.25,116.59) 67.5,117.88 67.5,122.07 arc(69.51,132.17) 75.24,140.74 arc(77.29,142.11) 79.71,142.59 81.18,142.59 arc(82.68,142.89) 83.95,143.74 arc(84.28,144.24) 84.4,144.84 84.4,145.81 arc(84.49,146.25) 84.74,146.62 87.22,149.1 arc(88.28,149.81) 89.53,150.06 106.26,150.06 arc(107.21,149.87) 108.02,149.33 114.99,142.36 arc(115.43,142.07) 115.96,141.96 120.94,141.96 arc(121.35,142.04) 121.69,142.27 arc(121.79,142.34) 121.91,142.36 124.16,142.36 arc(124.68,142.47) 125.13,142.76 126.2,143.84 arc(127.21,144.52) 128.41,144.75 150.25,144.75 arc(151.13,144.93) 151.88,145.43 153.18,146.74 arc(153.68,147.48) 153.86,148.36 153.86,149.1 arc(153.96,149.6) 154.24,150.03 arc(155.92,151.15) 157.9,151.54 163.69,151.54 arc(164.48,151.87) 164.81,152.67 164.81,153.11 v3(165.1,153.4)
10G_KR_RX1_P: length 143.8
  TOP w0.095: J2.C42 164.44,152.52 164.57,152.65 164.57,153.1 v3(164.28,153.4) ; U40.V1 v4(57.7,114.65)
  BOTTOM w0.095: v4(57.7,114.65) 57.3,114.65 57.17,114.51 57.17,114.39 57.29,114.27 60.28,114.27 arc(60.33,114.29) 60.36,114.35 arc(60.38,114.4) 60.43,114.42 60.75,114.42 arc(60.81,114.4) 60.83,114.35 arc(60.85,114.29) 60.91,114.27 61.23,114.27 arc(61.28,114.29) 61.31,114.35 arc(61.33,114.4) 61.39,114.42 61.71,114.42 arc(61.76,114.4) 61.78,114.35 arc(61.81,114.29) 61.86,114.27 64.02,114.27 arc(64.89,114.44) 65.63,114.94 66.36,115.67 arc(67.04,116.68) 67.28,117.88 67.28,122.07 arc(69.3,132.26) 75.08,140.9 arc(77.2,142.32) 79.71,142.82 81.18,142.82 arc(82.59,143.1) 83.79,143.9 arc(84.07,144.33) 84.17,144.84 84.17,145.81 arc(84.28,146.34) 84.58,146.78 87.05,149.26 arc(88.19,150.02) 89.53,150.29 106.26,150.29 arc(107.3,150.08) 108.18,149.5 115.15,142.52 arc(115.52,142.28) 115.96,142.19 120.94,142.19 arc(121.26,142.25) 121.53,142.43 arc(121.7,142.55) 121.91,142.59 124.16,142.59 arc(124.59,142.68) 124.96,142.93 126.04,144 arc(127.13,144.73) 128.41,144.98 150.25,144.98 arc(151.04,145.14) 151.71,145.59 153.02,146.9 arc(153.47,147.57) 153.63,148.36 153.63,149.1 arc(153.75,149.69) 154.08,150.19 arc(155.83,151.36) 157.9,151.77 163.69,151.77 arc(164.32,152.03) 164.58,152.67 164.58,153.1 v3(164.28,153.4)
10G_KR_TX0_N: length 123
  TOP w0.095: CB511.1 65.14,121.94 v3(65.14,122.46) ; J2.D50 168.44,158.04 arc(168.43,158.08) 168.41,158.11 168.33,158.19 arc(168.31,158.22) 168.3,158.26 168.3,158.51 arc(168.38,158.89) v3(168.6,159.21)
  S9 w0.108: v3(168.6,159.21) 168.57,159.24 arc(168.37,159.53) 168.3,159.88 arc(168.16,160.23) 167.81,160.37 163.29,160.37 arc(162.7,160.26) 162.2,159.92 161.01,158.73 arc(160.48,158.38) 159.86,158.25 141.6,158.25 arc(138.6,157.66) 136.05,155.96 131.87,151.77 arc(131.85,151.75) 131.83,151.73 arc(130.01,150.51) 127.87,150.09 115.92,150.09 arc(114.5,149.81) 113.3,149.01 110.57,146.28 arc(110.05,145.93) 109.44,145.81 102.2,145.81 arc(99.77,145.32) 97.71,143.95 93.07,139.31 92.92,139.15 arc(92.34,138.77) 91.66,138.63 89.53,138.63 arc(88.77,138.48) 88.12,138.05 87.91,137.84 85.49,135.42 arc(84.83,134.98) 84.06,134.83 78.94,134.83 arc(78.29,134.7) 77.73,134.33 68,124.6 67.9,124.5 arc(67.65,124.12) 67.56,123.67 arc(67.47,123.26) 67.24,122.9 67.2,122.86 66.3,121.97 arc(66.05,121.8) 65.75,121.74 64.99,121.74 arc(64.89,121.78) 64.85,121.88 64.85,122.02 arc(64.88,122.16) 64.96,122.28 v3(65.14,122.46)
10G_KR_TX0_P: length 123.8
  TOP w0.095: J2.D49 167.94,158.04 arc(167.95,158.08) 167.97,158.11 168.05,158.19 arc(168.07,158.22) 168.07,158.26 168.07,158.51 arc(168,158.89) v3(167.78,159.21) ; v3(64.33,122.46) 64.33,121.81 CB528.1
  S9 w0.108: v3(167.78,159.21) 167.81,159.24 arc(168.01,159.53) 168.07,159.88 arc(168,160.07) 167.81,160.14 163.29,160.14 arc(162.79,160.05) 162.36,159.76 161.98,159.38 161.37,158.76 161.17,158.57 arc(160.57,158.16) 159.86,158.02 141.6,158.02 arc(138.68,157.44) 136.21,155.79 131.99,151.57 arc(130.1,150.3) 127.87,149.86 115.92,149.86 arc(114.59,149.6) 113.47,148.85 110.73,146.11 arc(110.14,145.72) 109.44,145.58 102.2,145.58 arc(99.86,145.11) 97.87,143.78 93.23,139.15 93.08,138.99 arc(92.43,138.55) 91.66,138.4 89.53,138.4 arc(88.85,138.27) 88.28,137.88 85.66,135.26 arc(84.92,134.77) 84.06,134.6 78.94,134.6 arc(78.37,134.49) 77.89,134.17 69.92,126.19 arc(69.88,126.1) 69.92,126 arc(69.96,125.91) 69.92,125.82 69.73,125.62 arc(69.63,125.58) 69.54,125.62 arc(69.44,125.66) 69.35,125.62 69.16,125.43 arc(69.12,125.34) 69.16,125.24 69.16,125.24 arc(69.2,125.15) 69.16,125.05 68.97,124.86 arc(68.87,124.82) 68.78,124.86 arc(68.68,124.9) 68.59,124.86 68.06,124.33 arc(67.86,124.03) 67.79,123.67 arc(67.69,123.17) 67.4,122.74 67.36,122.7 66.39,121.74 66.47,121.81 arc(66.14,121.59) 65.75,121.51 64.99,121.51 arc(64.73,121.62) 64.62,121.88 64.62,122.02 arc(64.59,122.16) 64.51,122.28 v3(64.33,122.46)
10G_KR_TX1_N: length 127.9
  TOP w0.095: v3(165.05,158.6) 164.79,158.33 164.79,158.06 164.94,157.91 J2.D43
  S9 w0.108: v3(165.05,158.6) 164.81,158.36 164.81,158.12 arc(164.75,157.81) 164.57,157.54 164.34,157.31 arc(163.89,157.01) 163.37,156.91 142.6,156.91 arc(139.52,156.29) 136.91,154.55 136.91,154.55 129.59,147.23 arc(127.05,145.54) 124.06,144.94 114.52,144.94 arc(113.18,144.67) 112.05,143.92 111.73,143.6 108.5,140.36 arc(107.41,139.64) 106.13,139.38 96.74,139.38 arc(96.03,139.24) 95.43,138.84 93.77,137.18 arc(93.18,136.79) 92.48,136.65 89.5,136.65 arc(88.75,136.5) 88.12,136.08 87.79,135.75 86.23,134.19 arc(85.33,133.59) 84.28,133.38 79.34,133.38 arc(78.81,133.27) 78.36,132.97 71.86,126.48 arc(71.08,125.31) 70.81,123.93 arc(70.35,121.65) 69.06,119.72 68.27,118.93 65.06,115.73 arc(64.89,115.61) 64.68,115.57 61.33,115.57 arc(61.21,115.54) 61.11,115.48 60.01,114.37 arc(59.96,114.3) 59.95,114.22 59.95,114.2 arc(59.96,114.11) 60.01,114.04 60.13,113.92 arc(60.25,113.75) 60.29,113.54 60.29,113.03 v3(60.24,112.98)
  BOTTOM w0.095: v3(60.24,112.98) 60.24,112.43 CB607.1
10G_KR_TX1_P: length 128.6
  TOP w0.095: v3(164.24,158.6) 164.56,158.28 164.56,158.09 164.44,157.97 J2.D42
  S9 w0.108: v3(164.24,158.6) 164.58,158.25 164.58,158.12 arc(164.54,157.9) 164.41,157.7 164.17,157.47 arc(163.8,157.22) 163.37,157.13 142.6,157.13 arc(139.43,156.5) 136.75,154.71 129.43,147.39 arc(126.97,145.75) 124.06,145.17 114.52,145.17 arc(113.1,144.89) 111.89,144.08 108.33,140.52 arc(107.32,139.85) 106.13,139.61 96.74,139.61 arc(95.94,139.45) 95.26,139 93.61,137.34 arc(93.09,137) 92.48,136.88 89.5,136.88 arc(88.66,136.71) 87.96,136.24 86.07,134.35 arc(85.25,133.8) 84.28,133.61 79.34,133.61 arc(78.72,133.49) 78.19,133.13 71.7,126.64 arc(70.87,125.4) 70.58,123.93 70.58,123.93 arc(70.14,121.74) 68.9,119.88 68.11,119.09 arc(68.04,119.06) 67.97,119.09 arc(67.91,119.12) 67.84,119.09 67.54,118.79 arc(67.51,118.72) 67.54,118.66 arc(67.57,118.59) 67.54,118.52 67.24,118.22 arc(67.17,118.19) 67.1,118.22 arc(67.04,118.25) 66.97,118.22 66.67,117.92 arc(66.64,117.85) 66.67,117.78 arc(66.69,117.72) 66.67,117.65 66.36,117.35 arc(66.3,117.32) 66.23,117.35 66.23,117.35 arc(66.16,117.38) 66.1,117.35 65.8,117.05 arc(65.77,116.98) 65.8,116.91 arc(65.82,116.85) 65.8,116.78 64.9,115.89 arc(64.8,115.82) 64.68,115.8 61.33,115.8 arc(61.13,115.75) 60.95,115.64 59.85,114.53 arc(59.75,114.39) 59.72,114.22 59.72,114.21 arc(59.7,114.11) 59.65,114.03 59.53,113.92 arc(59.42,113.75) 59.38,113.54 59.38,113.03 v3(59.43,112.98)
  BOTTOM w0.095: v3(59.43,112.98) 59.43,112.43 CB586.1
10MHZ_GPS_IN/RESET: length 246.7
  TOP w0.127: v1(215.17,96.11) 215.1,96.05 CONN44.4
  S14 w0.127: v1(215.17,96.11) 207.04,96.11 205.32,97.83 205.32,100.81 202.59,103.54 196.59,103.54 189.68,110.46 189.68,119.97 173.5,136.15 154.3,136.15 154.27,136.18 154.15,136.18 152.08,138.25 150.17,138.25 148.05,140.37 148.05,143.42 147.39,144.07 144.42,144.07 142.11,146.39 142.11,150.06 139.67,152.51 139.67,182.73 135.57,186.82 130.44,186.82 125.38,191.87 118.26,191.87 111.67,198.46 95.88,198.46 92.14,202.2 91.93,202.2 89.06,205.07 89.06,208.02 90.04,209 90.04,212.6 90.3,212.85 90.3,219.92 90.69,220.32 93.1,220.32 95.84,223.06 99.61,223.06 99.76,223.2 99.76,223.82 99.92,223.99 101.99,223.99 102.83,224.83 102.83,233.17 v1(103.89,234.22)
  BOTTOM w0.127: R85.2 105.38,236.84 104.91,236.37 104.91,235.25 v1(103.89,234.22)
10MHZ_GPS_IN_FPGA: length 6.9
  TOP w0.127: v1(106.05,233.16) 106.05,233.16 106.03,233.16 105.31,232.44 105.31,230.44 104.83,229.96 P1.L21
  BOTTOM w0.127: v1(106.05,233.16) 106.05,233.16 106.03,233.16 106.03,233.16 106.75,233.88 106.75,235.8 R85.1
25MHZ_1PPS_FPGA_IN: length 120.2
  TOP w0.127: v1(109.79,238.45) 109.69,238.35 109.69,237.32 R1350.2 ; v1(159.48,168.69) 159.48,168.82 159.38,168.92 R1372.1
  S12 w0.127: v1(159.48,168.69) 160.75,169.96 160.75,177.01 158.96,178.8 158.96,184.01 157.5,185.47 157.5,188.68 145.87,200.31 145.87,233.58 146.56,234.26 146.56,237.11 144.94,238.73 139.86,238.73 v1(138.78,239.81)
  S14 w0.127: v1(109.79,238.45) 113.95,242.61 127.73,242.61 128.85,241.48 133.88,241.48 134.9,240.46 138.13,240.46 v1(138.78,239.81)
  BOTTOM w0.127: v1(159.48,168.69) 160.11,169.32 v2(160.11,169.8)
25MHZ_1PPS_FPGA_IN_R: length 7.9
  TOP w0.127: R1350.1 109.21,235.14 107.91,233.84 v1(107.7,233.84) 107.7,233.63 105.79,231.72 P1.M22
  BOTTOM w0.127: v1(107.7,233.84) 107.7,232.91 v2(108.04,232.57)
25MHZ_1204: length 216.9
  TOP w0.127: v1(110.14,181.01) 110.11,181.04 R1439.2 ; v1(243.93,123.8) 244.01,123.72 R1371.1
  S9 w0.127: v1(110.14,181.01) 110.16,181.04 111.56,181.04 115.66,185.14 129.41,185.14 130.05,184.5 130.05,178.05 135.89,172.21 144.38,172.21 145.73,170.86 151.57,170.86 152.21,170.22 160.25,170.22 162.74,167.74 165.83,167.74 167.41,169.32 233.95,169.32 238.85,174.22 249.39,174.22 251.55,172.06 251.55,158.09 250.16,156.69 250.16,148.91 247.4,146.15 243.97,146.15 239.32,141.5 239.32,131.39 241.07,129.64 241.07,126.47 243.74,123.8 v1(243.93,123.8)
25MHZ_30773: length 160.7
  TOP w0.127: v1(162.58,168.87) 162.34,168.63 RB1271.2
  S9 w0.127: v1(162.58,168.87) 165.89,168.87 166.92,169.9 233.66,169.9 238.86,175.11 250.72,175.11 253.08,172.75 253.08,166.34 252.57,165.83 252.57,149.6 248.51,145.54 244.63,145.54 240.23,141.15 240.23,131.75 243.13,128.85 243.13,126.79 244.53,125.39 244.53,124.05 244.53,124.04 244.53,120.54 v1(242.91,118.92)
  BOTTOM w0.127: R1369.2 243.17,118.66 v1(242.91,118.92)
25MHZ_30773_R: length 2.2
  TOP w0.127: v1(242.79,115.67) 242.87,115.59 U37.3
  BOTTOM w0.127: R1369.1 243.17,116.05 v1(242.79,115.67)
1588_CPU_OUT: length 12.2
  TOP w0.127: P1.V20 v4(112.29,229.46) ; v1(118.52,231.18) 119.92,232.57 R183.1
  BOTTOM w0.127: 118.46,231.24 113.34,231.24 112.77,230.67 112.77,229.94 v4(112.29,229.46) ; 118.46,231.24 118.39,231.3 v2(118.39,232.45) ; 118.46,231.24 v1(118.52,231.18)
1588_TO_CPU: length 10.3
  TOP w0.127: P1.W20 v4(113.29,229.46) ; v1(119.35,231.18) 119.73,231.56 R193.1
  BOTTOM w0.127: v2(120.45,230.91) 120.19,231.18 v1(119.35,231.18) 118.84,230.67 117.82,230.67 117.19,230.03 113.86,230.03 v4(113.29,229.46)
1588_UART_FROM_CPU: length 151.9
  TOP w0.127: R183.2 122.51,232.57 123.79,231.29 v1(123.79,230.48)
  S14 w0.127: v1(123.79,230.48) 125.65,228.61 125.65,226.31 128.35,223.62 136.43,223.62 138.46,221.59 142.7,221.59 149.95,214.34 149.95,208.29 157.84,200.41 165.35,200.41 166.19,199.57 169.27,199.57 179.5,189.33 179.5,161.2 183.33,157.38 184.94,157.38 196.31,146.01 196.31,138.85 v1(194.78,137.32)
  BOTTOM w0.127: R1310.1 193.84,138.26 v1(194.78,137.32) 194.59,137.13 193.39,137.13 v2(193.03,137.49) ; v2(126.08,235.87) 126.08,234.16 123.79,231.87 v1(123.79,230.48)
1588_UART_TO_CPU: length 141.8
  TOP w0.127: v1(195.01,142.1) 194.44,141.53 J2.A102 ; R193.2 122.52,231.56 123.28,230.79 v1(123.28,229.46)
  S14 w0.127: v1(195.01,142.1) 195.01,142.62 194.16,143.47 194.16,144.9 189.91,149.15 189.27,149.15 182.02,156.4 182.02,158.03 178.4,161.64 178.4,185.64 178.4,189.85 169.3,198.95 166.26,198.95 165.23,199.97 157.61,199.97 149.7,207.88 149.7,208.19 149.7,213.85 149.56,214 149.56,214 142.35,221.21 142.34,221.21 137.77,221.21 135.86,223.11 128.45,223.11 125.2,226.36 125.2,227.55 v1(123.28,229.46)
  BOTTOM w0.127: v1(123.28,229.46) 123.28,232.45 v2(124.93,234.1)
2304_OE: length 4.5
  TOP w0.127: U37.2 242.22,115.47 v1(242.03,115.67)
  BOTTOM w0.127: R675.1 R674.2 242.15,115.8 v1(242.03,115.67) 241.52,115.16 v2(240.88,115.16)
30773_GPIO1: length 2.9
  TOP w0.127: RB1282.2 122.32,210.74 v1(122.33,210.73) 122.34,210.74 123.07,210.74 RB1276.1
  BOTTOM w0.127: v1(122.33,210.73) 122.77,211.17 v2(123.54,211.17)
30773_GPIO2: length 2.7
  TOP w0.127: RB1277.1 123.04,209.75 122.36,209.75 v1(122.33,209.78) 122.3,209.75 RB1283.2
  BOTTOM w0.127: v2(123.3,209.28) 122.81,209.78 v1(122.33,209.78)
30773_GPIO5: length 15.2
  TOP w0.127: RB1268.2 RB1269.1 v1(137,211.05) ; v1(127.98,211.68) RB1280.1 RB1284.2
  BOTTOM w0.127: v2(137.06,209.84) 137.06,210.98 v1(137,211.05) 136.05,212 128.3,212 v1(127.98,211.68)
30773_GPIO6: length 27.1
  TOP w0.127: RB1285.2 122.3,216.86 v1(122.33,216.89) 122.36,216.86 RB1281.1 ; v1(140.05,211.05) RB1266.2 RB1267.1
  S14 w0.127: v1(122.33,216.89) 123.87,215.35 123.87,214.44 125,213.3 125.68,213.3 126.72,212.25 129.5,212.25 130,211.76 130,210.72 130.28,210.44 134.42,210.44 134.65,210.21 139.21,210.21 v1(140.05,211.05)
  BOTTOM w0.127: v2(121.31,217.21) 122,217.21 v1(122.33,216.89)
30773_GPIO7: length 53.9
  TOP w0.127: v1(122.46,226.36) 122.41,226.4 RB1286.1 ; RB1278.1 148.81,187.81 v1(148.3,188.32)
  S7 w0.127: v1(148.3,188.32) 147.76,188.86 146.8,188.86 136.68,198.98 136.68,207.36 136.11,207.93 135.47,207.93 135.03,208.38 135.03,209.33 133.24,211.12 133,211.12 130.01,214.11 130.01,218.8 v1(122.46,226.36)
  BOTTOM w0.127: v2(147.09,188.82) 147.12,188.85 147.77,188.85 v1(148.3,188.32)
30773_GPIO8: length 92.2
  TOP w0.127: RB1287.1 v1(122.51,227.51)
  S7 w0.127: v1(122.51,227.51) 122.51,227.19 130.46,219.24 130.46,214.6 133.41,211.65 133.79,211.65 138.65,206.79 138.65,197.71 143.42,192.94 151.55,192.94 157.25,187.24 157.25,183.68 157.06,183.49 157.06,179.04 v1(156.56,178.53)
  BOTTOM w0.127: v1(156.56,178.53) 159.29,175.8 159.29,174.79 161.62,172.45 v2(161.83,172.45) 161.89,172.39 161.89,169.3 158.49,165.89 156.15,165.89 154.96,167.08 154.96,168.58 154.65,168.89 RB1279.1
30773_I2C_SPI_CS: length 58.4
  TOP w0.127: U9.F10 199.51,194.54 v4(199.55,194.54) ; U77.20 157.83,182.92 158.4,183.49 158.4,184.06 159.99,185.65 RB1256.1 RB1295.1 160.17,187.11 160.02,186.95 160.02,187 v1(160,187)
  S9 w0.127: v4(199.55,194.54) 198.72,194.54 197.24,196.01 189.08,196.01 188.12,195.05 188.12,190.54 184.81,187.23 184.16,187.23 183.14,186.22 172.5,186.22 169.68,189.04 162.14,189.04 160.1,187 v1(160,187)
  BOTTOM w0.127: v2(159.22,185.71) 159.22,186.23 v1(160,187)
30773_SCL_FP: length 235.9
  TOP w0.127: v1(253.97,203.19) 254.05,203.27 RB1297.2 ; U77.16 158.43,180.92 v1(159.73,182.22) ; R98.2 107.18,237.59 107.95,238.35 v1(108.14,238.35)
  S9 w0.127: v1(159.73,182.22) 159.81,182.22 162.22,179.81 168.05,179.81 176.56,171.3 189.51,171.3 192.06,173.84 235.98,173.84 247.12,184.98 247.12,191.19 254.51,198.58 254.51,202.66 v1(253.97,203.19)
  S12 w0.127: v1(159.73,182.22) 159.73,182.53 160.36,183.16 160.36,185.34 159.11,186.59 159.11,188.99 147.03,201.06 147.03,232.07 147.69,232.73 147.69,240.18 145.55,242.32 142.16,242.32 140.11,240.27 v1(140.11,240.26)
  S14 w0.127: v1(140.11,240.26) 139.37,241 135.28,241 134.29,241.99 129.07,241.99 127.94,243.11 112.9,243.11 108.14,238.35 v1(108.14,238.35)
  BOTTOM w0.127: v1(159.73,182.22) 159.89,182.06 R1497.2 ; v1(140.11,240.26) v2(140.11,241.53)
30773_SCL_FP_R: length 16.9
  TOP w0.127: R87.1 R98.1 107.18,235.09 v1(107.34,234.92) ; P1.N15 v4(107.29,224.46)
  S14 w0.127: v1(107.34,234.92) 107.06,234.64 107.06,232.42 106.74,232.09 106.74,225.01 v4(107.29,224.46)
  BOTTOM w0.127: v1(107.34,234.92) 107.34,237.65 v2(107.03,237.97)
30773_SDA_FP: length 226.1
  TOP w0.127: R110.2 111.66,237.26 111.66,238.07 v1(111.37,238.36) ; v1(159.67,183.68) 157.91,181.92 U77.18 ; v1(253.85,202.27) 253.87,202.25 RB1299.1
  S9 w0.127: v1(159.67,183.68) 159.76,183.77 162.68,183.77 164.42,182.03 170.73,182.03 180.52,172.24 189.62,172.24 191.75,174.37 233.28,174.37 233.28,174.37 235.49,174.37 246.25,185.14 246.25,191.26 253.85,198.86 v1(253.85,202.27)
  S12 w0.127: v1(137.67,239.81) 137.67,239.78 138.34,240.45 139.03,240.45 140.11,239.37 142.52,239.37 143.69,240.54 146.04,240.54 147.11,239.47 147.11,233.6 146.52,233.02 146.52,200.76 158.5,188.78 158.5,185.79 159.67,184.63 v1(159.67,183.68)
  S14 w0.127: v1(137.67,239.81) 134.74,239.81 133.6,240.94 128.25,240.94 127.16,242.03 115.04,242.03 v1(111.37,238.36)
  BOTTOM w0.127: v1(137.67,239.81) 137.67,240.67 137.64,240.69 v2(137.64,240.72)
  BOTTOM w0.254: R1498.2 160.14,184.15 v1(159.67,183.68)
30773_SDA_FP_R: length 12
  TOP w0.127: v1(109.5,233.97) 109.99,233.97 111.22,235.2 R110.1 R116.1 ; P1.N20 v4(107.29,229.46)
  S9 w0.127: v4(107.29,229.46) 106.73,230.02 106.73,231.42 107.93,232.62 108.59,232.62 109.19,233.22 109.19,233.26 109.5,233.57 v1(109.5,233.97)
  BOTTOM w0.127: v2(108.68,234.48) 108.99,234.48 v1(109.5,233.97)
33931_SCL: length 72.5
  TOP w0.127: P1.F18 v4(99.29,227.46) ; R306.1 152.57,235.45 v1(152.21,235.81)
  S14 w0.127: v4(99.29,227.46) 99.31,227.46 99.72,227.87 99.72,231.94 99.31,232.35 99.31,234.12 99.79,234.61 99.79,235.5 101.7,237.41 101.7,238.69 104.11,241.1 107.35,241.1 111.52,245.26 128.9,245.26 130.04,244.12 135.12,244.12 135.83,243.41 142.66,243.41 143.54,242.52 143.56,242.52 143.79,242.29 145.72,242.29 152.2,235.81 v1(152.21,235.81)
  BOTTOM w0.127: v1(152.21,235.81) 152.02,235.62 v2(151.35,235.62)
33931_SCL_R: length 8.8
  TOP w0.127: R306.2 v1(152.57,233.02) R307.2 152.96,232.29 153.25,232 153.25,228.7 153.65,228.3 U10.11
  BOTTOM w0.127: v2(152.62,234.03) 152.57,233.99 v1(152.57,233.02)
33931_SDA: length 83.5
  TOP w0.127: v1(152.56,236.51) 153.84,235.22 R294.1 ; P1.H7 v4(101.29,215.46)
  S9 w0.127: v4(101.29,215.46) 101.29,215.4 101.73,214.95 101.76,214.98 104.8,214.98 105.44,214.35 105.44,212.63 106.09,211.98 115.28,211.98 116.01,211.25 117.53,211.25 119.53,209.25 120.78,209.25 121.39,209.85 121.39,211.87 122.15,212.63 122.96,212.63 123.63,213.29 127.38,213.29 127.79,212.89 129.82,212.89 131.57,214.64 133.47,214.64 134.45,215.62 135.22,215.62 138.2,218.6 150.81,218.6 v1(151.28,218.14)
  S12 w0.127: v1(152.56,236.51) 152.81,236.26 152.81,234.91 151.91,234.02 151.91,221.52 152.88,220.56 152.88,219.13 152.62,218.88 152.62,218.88 151.88,218.14 v1(151.28,218.14)
  BOTTOM w0.127: v1(152.56,236.51) 152.11,236.95 v2(152.11,237.46)
33931_SDA_R: length 8.9
  TOP w0.127: R294.2 v1(153.84,233.02) R295.2 153.88,232.26 154.21,232.26 154.39,232.07 154.39,230.09 154.3,230 U10.10
  BOTTOM w0.127: v2(153.89,231.75) 153.84,231.79 v1(153.84,233.02)
88470_1588_I2C_SCL: length 215.6
  TOP w0.127: R650.1 6.37,119.61 v1(5.81,119.61) ; v1(118.96,238.29) 119.03,238.29 119.32,238 R120.2
  S16 w0.127: v1(5.81,119.61) 5.48,119.61 5.2,119.89 5.2,124.69 4.94,124.94 4.94,126.16 5.2,126.41 5.2,129.79 4.66,130.32 4.66,142.5 3.56,143.61 3.56,160.16 6.04,162.63 6.04,165.88 7.31,167.15 7.31,171.57 12.14,176.41 12.14,188.66 29.17,205.69 35.38,205.69 36.83,207.14 54.35,207.14 55.31,206.17 59.8,206.17 61.75,208.13 61.75,209.13 64.49,211.87 65.04,211.87 72.58,219.41 72.58,221.42 77.94,226.79 77.94,234.99 85.12,242.16 115.09,242.16 v1(118.96,238.29)
  BOTTOM w0.127: v2(118.58,239.43) 118.96,239.05 v1(118.96,238.29)
88470_1588_I2C_SDA: length 187.5
  TOP w0.127: v1(5.81,116.05) 5.48,116.05 5.05,116.48 R668.1 ; P1.J13 v4(102.29,222.46)
  S12 w0.127: v1(60.09,207.41) 60.59,207.41 72.37,219.19 76.44,219.19 76.9,218.73 81.04,218.73 81.36,219.05 86.71,219.05 87.94,220.28 92.89,220.28 94.58,221.97 101.88,221.97 102.29,222.37 v4(102.29,222.46)
  S16 w0.127: v1(5.81,116.05) 4.69,117.17 4.69,124.37 4.28,124.77 4.28,126.34 4.69,126.74 4.69,129.26 3.9,130.05 3.9,142.55 3.05,143.4 3.05,160.37 3.69,161 3.69,167.59 4.82,168.72 4.82,170.41 11.53,177.12 11.53,189.03 28.91,206.4 34.18,206.4 36.22,208.43 42.05,208.43 42.28,208.2 54,208.2 55.52,206.68 59.35,206.68 v1(60.09,207.41)
  BOTTOM w0.127: v2(60.67,206.73) 60.67,206.83 v1(60.09,207.41)
88470_I2C_SCL: length 258.3
  TOP w0.127: R656.1 6.26,118.72 6.14,118.84 v1(5.81,118.84) ; R74.2 184.07,201.25 v1(183.69,201.63)
  S5 w0.127: v1(166.83,202.39) 164.78,200.34 141.7,200.34 140.77,201.27 132.74,201.27 131.82,200.34 105.77,200.34 102.73,203.37 102.73,203.78 101.64,204.88 91.84,204.88 90.9,203.94 82.33,203.94 81.86,203.47 79.55,203.47 79.21,203.81 76.37,203.81 76.03,203.47 68.64,203.47 67.26,204.85 59.05,204.85 57.86,203.65 v1(57.86,203.22)
  S9 w0.127: v1(5.81,118.84) 5.63,118.84 4.6,119.87 4.6,125.11 5.25,125.75 5.25,129.66 4.03,130.88 4.03,152.11 6.12,154.2 6.1,154.22 6.1,154.71 6.12,154.74 6.12,159.8 6.7,160.37 6.7,160.42 8.15,161.88 8.15,168.95 7.08,170.03 7.08,174.28 13.62,180.82 13.62,183.73 32.6,202.72 57.35,202.72 v1(57.86,203.22)
  BOTTOM w0.127: v1(183.69,201.63) 183.21,201.16 v2(181.5,201.16) 181.29,200.95 167.79,200.95 166.83,201.91 v1(166.83,202.39)
88470_I2C_SCL_R: length 7.7
  TOP w0.127: U9.A2 188.74,201.39 v1(186.12,201.39) 185.56,201.39 R74.1
  BOTTOM w0.127: v1(186.12,201.39) 185.45,200.72 185.45,200.74 v2(185.4,200.74)
88470_I2C_SDA: length 265.8
  TOP w0.127: U9.A4 192.57,199.56 v1(192.57,199.64) ; v1(5.81,120.37) 5.65,120.52 5.4,120.52 5.05,120.17 R654.1
  S5 w0.127: v1(58.77,203.17) 59.38,203.78 64.45,203.78 65.65,202.58 77.33,202.58 77.75,203 78.88,203 79.29,202.58 90.7,202.58 92.16,204.04 100.56,204.04 100.89,203.7 100.89,202.3 103.79,199.41 133.34,199.41 134.08,200.15 137.07,200.15 137.81,199.41 165.1,199.41 167.82,202.13 v1(167.82,202.51)
  S9 w0.127: v1(58.77,203.17) 58.77,202.79 57.71,201.73 33.33,201.73 14.7,183.1 14.7,180.63 10.06,175.99 10.06,168.65 9.4,167.99 9.4,161.87 7.59,160.06 7.59,154.4 4.92,151.74 4.92,141.7 5.25,141.37 5.25,131.14 6.34,130.05 6.34,125.55 6.06,125.27 5.5,125.27 4.92,124.69 4.92,121.26 v1(5.81,120.37)
  BOTTOM w0.127: v1(167.82,202.51) 168.57,201.76 177.44,201.76 v2(177.51,201.84) 178.02,202.35 190.49,202.35 192.57,200.26 v1(192.57,199.64)
ALARM_G: length 325.4
  TOP w0.127: P1.B12 v4(95.29,221.46)
  S14 w0.127: v1(91.41,209.52) 91.59,209.71 91.59,212.24 94.45,215.1 94.45,220.62 v4(95.29,221.46)
  S16 w0.127: v1(91.41,209.52) 90.25,209.52 89.01,208.28 86.79,208.28 84.47,205.96 81.61,205.96 81,205.34 81,204.14 73.91,197.05 56.11,197.05 52.86,193.8 50.16,193.8 48.62,195.35 44.65,195.35 44.12,194.82 30.18,194.82 19.4,184.04 19.4,175.58 15.61,171.8 15.61,165.8 14.53,164.72 14.53,158.62 18.2,154.95 18.2,138.99 16.99,137.77 16.99,132.68 16.28,131.98 16.28,113.57 10,107.29 10,98.08 11.95,96.12 11.95,93.74 16.18,89.51 16.18,81.14 21.45,75.87 21.45,64.4 23.65,62.2 23.65,45.98 26.86,42.77 26.86,25.19 36.96,15.09 45.75,15.09 46.61,14.23 50.73,14.23 52.1,12.86 68.8,12.86 70.2,11.47 72.16,11.47 v1(72.74,12.04)
  BOTTOM w0.127: RB1293.2 72.67,11.97 v1(72.74,12.04) 72.61,12.16 v2(72.61,13.24)
ALARM_G_R: length 6
  BOTTOM w0.127: CB1228.2 RB1293.1 v2(72.67,9.24) 72.14,8.71 LEDB15.C2
ALARM_R: length 336.3
  TOP w0.127: v4(92.74,226.48) 93.48,226.48 94.5,225.46 95.29,225.46 P1.B16
  S14 w0.127: v4(92.74,226.48) 92.74,226.6 92.23,227.11 90.33,227.11 88.55,228.89 84.67,228.89 81.99,226.21 81.99,222.02 78.49,218.52 78.49,214.53 78.57,214.44 78.57,208.65 81.69,205.54 v1(81.69,204.72)
  S16 w0.127: v1(81.69,204.72) 81.69,203.53 73.61,195.45 55.7,195.45 53.7,193.45 49.81,193.45 48.39,194.87 45.34,194.87 44.86,194.39 30.3,194.39 19.89,183.97 19.89,175.48 15.94,171.53 15.94,165.71 14.85,164.62 14.85,158.94 18.46,155.34 18.46,138.81 17.36,137.71 17.36,132.67 16.67,131.98 16.67,113.56 10.38,107.27 10.38,98.14 12.46,96.06 12.46,93.64 16.56,89.54 16.56,81.32 21.81,76.07 21.81,64.42 23.9,62.33 23.9,46.19 27.24,42.85 27.24,25.4 37.3,15.34 46.07,15.34 46.83,14.58 50.89,14.58 52.29,13.18 69.56,13.18 v1(70.64,12.1)
  BOTTOM w0.127: v4(92.74,226.48) 93.19,226.03 v2(93.51,226.03) ; RB1294.2 v1(70.64,12.1)
ALARM_R_R: length 6.5
  BOTTOM w0.127: CB1229.2 RB1294.1 70.64,8.93 v2(70.58,8.86) 70.39,8.67 LEDB15.C1
ALE_SET: length 70.9
  TOP w0.127: v1(167.16,227.37) 167.1,227.37 166.53,226.79 166.53,226.35 166.87,226 167.35,226 170.63,222.72 R1123.1 ; P1.Y15 v4(114.29,224.46)
  S9 w0.127: v4(114.29,224.46) 114.81,223.94 115.79,223.94 116.17,224.32 120.11,224.32 120.65,224.86 122.65,224.86 123.05,225.27 124.86,225.27 126.38,223.75 132.05,223.75 134.84,226.54 166.34,226.54 v1(167.16,227.37)
  BOTTOM w0.127: v2(165.83,227.75) 166.78,227.75 v1(167.16,227.37)
AP7362_ADJ: length 32
  BOTTOM w0.254: v2(236.12,136.81) 236.2,136.89 R689.1 237.78,138.28 238.02,138.52 241.85,138.52 244.31,136.06 260.01,136.06 CONN36.1
AP7362_ADJ_R: length 8.2
  BOTTOM w0.254: R677.2 235.3,138.28 R689.2 ; R677.2 233.71,139.55 v2(233.39,139.23) ; R677.2 R676.1 234.8,141.5 U36.8
AP7362_EN: length 4.7
  TOP w0.127: RB184.2 RB186.2 225.61,142.74 v1(225.58,142.77)
  BOTTOM w0.127: U36.2 v1(225.58,142.77) 225.15,142.34 v2(224.06,142.34)
AP7362_VIN: length 5.2
  TOP w0.254: v1(225.59,144.64) 227.02,144.64 227.31,144.35 RB184.1
  BOTTOM w0.305: v1(225.59,144.64) 225.27,144.31 C322.1 223.65,144.93
  vias: v2(225.69,147.58)
B2B_PROCHOT_N: length 3.8
  TOP w0.127: v1(161.06,146.47) 160.94,146.34 J2.B35
  BOTTOM w0.127: v2(161.86,145.39) 161.06,146.19 v1(161.06,146.47) 161.13,146.53 R1291.1
BCM88470_C_PLL_BYP_CLK0: length 1.4
  TOP w0.127: U40.Y18 v4(40.7,117.65)
  BOTTOM w0.127: U40.Y18 v4(40.7,117.65)
BCM88470_C_PLL_BYP_CLK1: length 17.2
  TOP w0.127: U40.W18 v4(40.7,116.65)
  S7 w0.127: v4(40.7,116.65) 39.91,115.85 36.76,115.85 36.2,115.29 36.2,108.26 36.3,108.16 37.01,108.16 37.21,107.96 37.21,107.39 37.45,107.15 38.05,107.15 v4(38.7,106.5)
  BOTTOM w0.127: v4(38.7,106.5) 39.15,106.95 RB195.1
BCM88470_DDRA_AUX_0: length 17
  TOP w0.127: v4(34.7,127.65) U40.AK23
  BOTTOM w0.127: 37.85,130.14 38.73,131.03 38.73,132.87 38.43,133.17 38.43,134.92 34.85,138.51 TPB28.1
  BOTTOM w0.13: 37.85,130.14 36.41,130.14 36.18,129.91 36.18,129.51 35.83,129.15 35.35,129.15 35.17,128.97 35.17,128.41 34.7,127.94 v4(34.7,127.65)
BCM88470_DDRA_AUX_1: length 18.2
  TOP w0.127: U40.AH24 v4(33.7,125.65)
  BOTTOM w0.127: TPB29.1 36.68,137.52 38.81,135.38 38.81,133.15 38.94,133.02 38.94,132.99 38.96,132.96 38.96,129.11 38.04,128.18
  BOTTOM w0.13: 38.04,128.18 35.57,128.18 35.17,127.78 35.17,127.42 34.89,127.14 34.51,127.14 34.18,126.81 34.18,126.13 34.15,126.1 v4(33.7,125.65)
BCM88470_DDRA_PLL_CLK_MON: length 11.3
  TOP w0.127: v4(28.7,124.65) U40.AG29
  BOTTOM w0.127: TPB34.1 18.42,125.16 20.02,125.16
  BOTTOM w0.13: 20.02,125.16 28.18,125.16 v4(28.7,124.65)
BCM88470_DDRA_VREF_MON: length 13
  TOP w0.127: U40.AH28 v4(29.7,125.65)
  BOTTOM w0.127: TPB26.1 28.2,133.33 28.45,133.07 29.85,133.07 30.23,132.69 30.23,129.39 29.97,129.14 29.47,129.14 29.21,128.88 29.21,126.47 29.7,125.98 v4(29.7,125.65)
BCM88470_DDRB_AUX_0: length 17.2
  TOP w0.127: v4(41.7,126.65) U40.AJ17
  BOTTOM w0.127: TPB27.1 46.14,137.48
  BOTTOM w0.13: 46.14,137.48 46.14,132.4 45.89,132.15 44.49,132.15 44.24,131.89 44.24,128.46 43.91,128.13 43.52,128.13 43.22,127.83 43.22,126.43 42.97,126.18 42.17,126.18 v4(41.7,126.65)
BCM88470_DDRB_AUX_1: length 13.8
  TOP w0.127: U40.AH18 v4(40.7,125.65)
  BOTTOM w0.127: v4(40.7,125.65) 40.18,126.16 39.37,126.16 39.19,126.34 39.19,136.25 TPB31.1
BCM88470_DDRC_AUX_0: length 10.2
  TOP w0.127: v4(50.7,127.65) U40.AK8
  BOTTOM w0.127: TPB30.1 59.27,126.22 52.45,126.22 52.2,126.47 52.2,126.98 52.07,127.1 51.24,127.1 v4(50.7,127.65)
BCM88470_DDRC_AUX_1: length 13.1
  TOP w0.127: v4(49.7,121.65) U40.AD9
  BOTTOM w0.13: TPB36.1 58.82,122.05 57.9,121.12 55.44,121.12 55.18,120.87 55.18,120.36 54.95,120.13 53.96,120.13 53.22,120.88 53.22,122.02 53.09,122.15 50.55,122.15 50.04,121.65 v4(49.7,121.65)
BCM88470_FTEST_0: length 38.1
  TOP w0.127: v1(14.49,123.77) 14.46,123.8 R607.2 ; v4(27.7,123.65) U40.AF30
  S12 w0.127: v4(27.7,123.65) 27.22,123.17 26.54,123.17 26.2,122.83 26.2,122.37 26,122.17 25.52,122.17 25.26,121.92 25.26,121.49 24.91,121.14 19.84,121.14 17.69,123.28 14.92,123.28 14.49,123.71 v1(14.49,123.77)
  BOTTOM w0.127: v2(15.9,105.54) 15.9,108.75 12.16,112.49 12.16,115.42 13.05,116.3 13.05,122.32 13.97,123.24
  BOTTOM w0.13: 13.97,123.24 v1(14.49,123.77)
BCM88470_FTEST_1: length 29.7
  TOP w0.127: v1(8.26,127.21) 7.77,127.21 R573.2 ; U40.AH30 v4(27.7,125.65)
  S14 w0.127: v1(8.26,127.21) 9.28,127.22 11.14,125.36 11.16,125.37 12.74,125.37 12.86,125.26 13.66,125.26 14.63,124.28 18.32,124.28 18.96,123.64 21,123.64 21.45,123.19 26.94,123.19 27.22,123.47 27.22,124.37 27.22,124.37 27.22,125.16 27.7,125.64 v4(27.7,125.65)
  BOTTOM w0.127: v2(4.98,129.83) 4.98,128.94 5.62,128.29 7.18,128.29 v1(8.26,127.21)
BCM88470_FTEST_2: length 16.8
  TOP w0.127: v1(17.54,123.77) 17.51,123.8 R608.2 ; v4(27.7,124.65) U40.AG30
  S12 w0.127: v4(27.7,124.65) 27.17,124.12 26.51,124.12 26.25,123.87 26.25,123.52 25.92,123.19 25.47,123.19 25.21,122.93 25.21,122.51 24.86,122.15 22.55,122.15 22.55,122.15 22.27,121.87 19.75,121.87 17.85,123.77 v1(17.54,123.77)
  BOTTOM w0.127: v2(16.17,126.03) 16.17,125.13 v1(17.54,123.77)
BCM88470_LED_CLK: length 30.8
  TOP w0.127: R679.1 7.61,116.69 v1(8.21,116.09) ; v4(27.7,118.65) U40.AA30
  S7 w0.127: v4(27.7,118.65) 27.7,118.22 27.23,117.75 27.23,117.43 27,117.2 20.35,117.2 19.58,117.97 17.29,117.97 15.5,116.18 14.73,116.18 14.42,115.87 10.5,115.87 10.28,116.09 v1(8.21,116.09)
  BOTTOM w0.127: v2(3.8,111.01) 3.8,111.82 5.93,113.95 6.57,113.95 8.21,115.6 v1(8.21,116.09)
BCM88470_LED_DATA: length 27.2
  TOP w0.127: R661.2 v1(8.26,117.7) ; v4(27.7,119.65) U40.AB30
  S7 w0.127: v1(8.26,117.7) 11.44,117.7 11.89,118.15 15.62,118.15 15.7,118.23 20.12,118.23 20.2,118.15 26.94,118.15 27.24,118.46 27.24,119.19 v4(27.7,119.65)
  BOTTOM w0.127: v2(5.57,114.39) 5.7,114.53 6.57,114.53 7.65,115.61 7.65,117.09 v1(8.26,117.7)
BCM88470_MDC_0: length 3.8
  TOP w0.127: v4(22.7,120.65) U40.AD36
  BOTTOM w0.127: TPB39.1 20.03,120.24 20.79,120.24
  BOTTOM w0.13: 20.79,120.24 22.29,120.24 v4(22.7,120.65)
BCM88470_MDIO_0: length 4.5
  TOP w0.127: v4(21.7,120.65) U40.AD37
  BOTTOM w0.13: v4(21.7,120.65) 20.95,120.65 19.47,122.12 TPB37.1
BCM88470_NIF_LCPLL_BYP_CLK: length 3.3
  TOP w0.127: v4(36.7,109.65) U40.N21
  BOTTOM w0.127: RB209.1 38.28,109.93 38.1,110.11
  BOTTOM w0.13: v4(36.7,109.65) 37.16,110.11 38.1,110.11
BCM88470_NIFE_LCPLL0_BYP_CLK: length 24.3
  TOP w0.127: U40.U24 v4(33.7,113.65) ; R681.1 14.35,116.69 14.83,117.17 17.16,117.17 17.34,116.99 17.83,116.99 v1(18.32,117.48)
  S7 w0.127: v4(33.7,113.65) 33.19,114.15 20.76,114.15 18.99,115.92 18,115.92 17.67,116.25 17.67,116.83 v1(18.32,117.48)
BCM88470_NIFE_LCPLL1_BYP_CLK: length 1.5
  TOP w0.381: v4(46.7,114.65) U40.V12
  BOTTOM w0.381: v4(46.7,114.65) 46.18,115.16 RB196.1
BCM88470_PVTMON_A_AIO: length 17.4
  TOP w0.127: v4(33.7,109.65) U40.N24
  S16 w0.127: v1(35.74,94.73) 35.68,94.73 35.68,96.01 34.22,97.47 34.22,100.95 34.26,100.99 34.26,105.23 34.18,105.31 34.18,109.17 v4(33.7,109.65)
  BOTTOM w0.127: TPB42.1 35.93,94.54 v1(35.74,94.73)
BCM88470_PVTMON_B_AIO: length 16.9
  TOP w0.127: v4(44.7,109.65) U40.N14
  BOTTOM w0.127: TPB41.1 42.17,95.39 42.17,106.78 42.55,107.17 42.9,107.17 43.18,107.44 43.18,108.82 43.44,109.07 44.12,109.07 v4(44.7,109.65)
BCM88470_ROV0: length 212.7
  TOP w0.127: R500.2 8.35,133.96 8.98,134.59 11.39,134.59 v1(11.55,134.44) ; P1.AA15 v4(115.29,224.46) ; v4(23.7,128.65) U40.AL34
  S7 w0.127: v4(23.7,128.65) 23.09,128.04 21.58,128.04 21.07,128.55 20.03,128.55 18.2,130.38 14.34,130.38 12.31,132.41 11.83,132.41 10.91,133.32 10.91,134.21 11.14,134.44 v1(11.55,134.44)
  S9 w0.127: v1(11.55,134.44) 11.52,134.47 11.52,135.32 14.04,137.84 15.14,137.84 18.19,140.89 18.19,149.28 17.37,150.1 17.37,154.22 15.45,156.14 15.45,157.85 14.28,159.03 14.28,162.47 13.62,163.13 13.62,164.22 14.28,164.88 14.28,166.23 15.33,167.28 15.33,173.09 18.92,176.67 18.92,183.25 35.03,199.36 63,199.36 63.06,199.43 63.56,199.43 73.72,209.59 77.84,209.59 78.35,210.09 v1(85.18,210.09)
  S16 w0.127: v1(85.18,210.09) 87.56,210.09 87.9,210.43 88.98,210.43 90.27,211.72 92.02,211.72 94.2,213.9 109.38,213.9 109.69,214.22 109.69,223.49 110.07,223.87 114.7,223.87 v4(115.29,224.46)
  BOTTOM w0.127: v1(11.55,134.44) 11.55,138.55 16.54,143.55 17.05,143.55 v2(19.21,145.7)
