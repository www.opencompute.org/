# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SFP+_P17_SCL_R: length 13.9
  BOTTOM w0.127: UB8.5 171.34,26.42 170.91,26.85 167.5,26.85 165.93,25.27 v2(165.8,25.27) 165.64,25.11 RB264.2 163.19,24.83 162.97,24.6 161.16,24.6 RB247.2
SFP+_P17_SDA: length 46.6
  S7 w0.127: CONN55_PF.3T4 147.06,54.6 147.06,54.12 148.43,52.75 148.43,52.02 147.61,51.2 147.61,50.65 148.54,49.72 148.54,49.06 146.88,47.39 146.88,41.12 147.36,40.64 147.36,37.69 146.3,36.62 146.3,34.77 v1(144.77,33.24) 145.45,32.56 147.95,32.56 149.14,33.75 149.95,33.75 158,25.7 158,24.75 v1(158.79,23.96)
  BOTTOM w0.127: v2(143.98,33.24) v1(144.77,33.24) RB504.1 ; v1(158.79,23.96) 158.8,23.97 RB246.1
SFP+_P17_SDA_R: length 14.4
  BOTTOM w0.127: RB246.2 160.83,23.97 161.34,23.46 162.99,23.46 163.19,23.66 RB263.2 164.05,23.97 v2(164.17,23.85) 165.42,23.85 168.01,26.44 170.75,26.44 171.42,25.77 UB8.4
SFP+_P18_SCL: length 33.4
  S9 w0.127: v1(158.79,27.28) 156.44,27.28 v1(149.47,34.25)
  S14 w0.127: v1(149.47,34.25) 148.26,35.47 148.26,36.27 147.45,37.08 147.45,40.89 146.9,41.44 146.9,47.39 148.66,49.16 CONN55_PF.3L5
  BOTTOM w0.127: RB249.1 158.91,27.4 v1(158.79,27.28) v2(157.8,27.28) ; RB539.1 v1(149.47,34.25)
SFP+_P18_SCL_R: length 13.2
  BOTTOM w0.127: UB8.7 171.3,27.72 171.18,27.84 166.49,27.84 v2(166.13,27.48) 166.05,27.4 RB266.2 163.19,27.17 162.92,26.89 161.16,26.89 RB249.2
SFP+_P18_SDA: length 36.5
  S9 w0.127: v1(149.51,35.27) 150.33,34.44 150.33,34.05 156.44,27.94 159.42,27.94 159.77,27.59 159.77,27.22 v1(158.79,26.24)
  S14 w0.127: v1(149.51,35.27) 148.88,35.89 148.88,41.5 149.59,42.21 149.59,45.92 148.02,47.5 148.02,48.13 149.46,49.58 CONN55_PF.3L4
  BOTTOM w0.127: v2(157.91,25.36) v1(158.79,26.24) 158.8,26.25 RB248.1 ; RB503.1 v1(149.51,35.27)
SFP+_P18_SDA_R: length 13.7
  BOTTOM w0.127: RB248.2 161.16,25.75 163.12,25.75 163.19,25.82 RB265.2 164.09,26.25 v2(164.22,26.39) 164.43,26.59 166.46,26.59 167.22,27.35 171.03,27.35 171.31,27.07 UB8.6
SFP+_P19_SCL: length 36.7
  S7 w0.127: CONN55_PF.4T5 162.11,53.77 162.95,52.93 162.95,51.74 162.31,51.09 162.31,50.61 163.18,49.73 163.18,49.04 162.26,48.12 162.26,47.48 163.84,45.9 163.84,39.14 165.42,37.57 165.42,35.98 v1(166.13,35.27) 165.42,34.56 165.42,32.31 163.39,30.27 159.5,30.27 v1(158.79,29.57)
  BOTTOM w0.127: v1(158.79,29.57) 158.91,29.68 RB251.1 ; RB447.1 v1(166.13,35.27) 166.35,35.05 v2(167.04,35.05)
SFP+_P19_SCL_R: length 13.2
  BOTTOM w0.127: UB8.9 171.29,29.02 171.11,29.21 165.09,29.21 v2(164.81,29.49) 164.08,29.49 163.88,29.68 RB268.2 163.19,29.45 162.92,29.17 161.16,29.17 RB251.2
SFP+_P19_SDA: length 32.8
  S7 w0.127: CONN55_PF.4T4 161.31,54.12 162.68,52.75 162.68,52.02 161.86,51.2 161.86,50.65 162.79,49.72 162.79,49.06 161.13,47.39 161.13,41.12 161.61,40.64 161.61,37.69 160.55,36.62 160.55,34.77 v1(159.02,33.24) 157.88,32.1 157.88,29.28 158.63,28.53 v1(158.79,28.53)
  BOTTOM w0.127: v1(158.79,28.53) 158.8,28.54 RB250.1 ; RB483.1 v1(159.02,33.24) v2(158.23,33.24)
SFP+_P19_SDA_R: length 13.1
  BOTTOM w0.127: RB250.2 161.16,28.03 162.99,28.03 163.19,28.23 RB267.2 168.36,28.54 v2(168.36,28.57) 171.08,28.57 171.28,28.37 UB8.8
SFP+_P20_SCL: length 29.2
  S7 w0.127: v1(158.79,31.85) 160.69,33.75 163.24,33.75 163.72,34.24 v1(163.72,34.25)
  S14 w0.127: CONN55_PF.4L5 162.91,49.16 161.15,47.39 161.15,41.44 161.7,40.89 161.7,37.08 162.51,36.27 162.51,35.47 v1(163.72,34.25)
  BOTTOM w0.127: RB253.1 158.91,31.97 v1(158.79,31.85) 158.79,31.71 157.53,30.44 v2(156.39,30.44) ; RB518.1 v1(163.72,34.25)
SFP+_P20_SCL_R: length 13.7
  BOTTOM w0.127: UB8.11 167.81,30.32 166.54,31.6 v2(164.94,31.6) 164.56,31.97 RB270.2 163.19,31.71 162.94,31.46 161.16,31.46 RB253.2
SFP+_P20_SDA: length 30.5
  S7 w0.127: v1(158.79,30.82) 158.85,30.82 160.57,32.53 163.69,32.53 164.25,33.09 164.25,34.74 v1(163.72,35.27)
  S14 w0.127: CONN55_PF.4L4 163.71,49.58 162.27,48.13 162.27,47.5 163.84,45.92 163.84,42.21 163.13,41.5 163.13,35.86 v1(163.72,35.27)
  BOTTOM w0.127: v2(157.91,29.3) 157.91,29.94 v1(158.79,30.82) 158.8,30.83 RB252.1 ; v1(163.72,35.27) RB482.1
SFP+_P20_SDA_R: length 13.5
  BOTTOM w0.127: RB252.2 161.16,30.32 162.99,30.32 163.19,30.52 RB269.2 164.52,30.83 165.02,30.32 166.59,30.32 v2(166.64,30.27) 166.74,30.27 167.35,29.67 UB8.10
SFP+_P21_SCL: length 42.9
  S7 w0.127: v1(193.09,30.93) 192.6,31.42 181.37,31.42 179.77,33.02 179.77,34.66 v1(180.38,35.27) 179.67,35.98 179.67,37.57 178.09,39.14 178.09,42.26 177.57,42.78 177.57,43.91 178.09,44.43 178.09,45.9 176.51,47.48 176.51,48.12 177.43,49.04 177.43,49.73 176.56,50.61 176.56,51.09 177.2,51.74 177.2,52.93 176.36,53.77 CONN55_PF.5T5
  BOTTOM w0.127: v2(181.29,35.05) 181.06,35.27 v1(180.38,35.27) RB450.1 ; RB306.1 193.02,30.85 v1(193.09,30.93)
SFP+_P21_SCL_R: length 13
  BOTTOM w0.127: UB8.14 186.14,30.32 186.63,30.81 v2(186.63,30.83) 186.65,30.83 186.67,30.85 RB296.2 188.83,30.67 189.15,30.34 190.61,30.34 RB306.2
SFP+_P21_SDA: length 54.5
  S7 w0.127: CONN55_PF.5T4 175.56,54.12 176.93,52.75 176.93,52.02 176.11,51.2 176.11,50.65 177.04,49.72 177.04,49.06 175.38,47.39 175.38,41.12 175.86,40.64 175.86,37.69 174.8,36.62 174.8,34.77 174.15,34.12 v1(173.27,33.24) 173.27,32.74 178.02,27.99 193.36,27.99 193.87,28.5 193.87,31.29 193.37,31.79 v1(193.09,31.79)
  BOTTOM w0.127: v2(172.41,33.24) v1(173.27,33.24) RB486.1 ; v1(193.09,31.79) 192.89,31.99 RB307.1
SFP+_P21_SDA_R: length 13.3
  BOTTOM w0.127: UB8.13 182.4,30.97 v2(182.46,31.04) 185.64,31.04 186.59,31.99 RB297.2 188.83,31.61 188.95,31.49 190.61,31.49 RB307.2
SFP+_P22_SCL: length 40.9
  S7 w0.127: v1(177.97,34.25) 177.38,33.67 177.38,32.59 178.25,31.72 179.31,31.72 181.95,29.08 192.92,29.08 v1(193.09,28.91)
  S14 w0.127: v1(177.97,34.25) 176.74,35.48 176.74,36.23 175.95,37.03 175.95,40.89 175.4,41.44 175.4,47.39 177.16,49.16 CONN55_PF.5L5
  BOTTOM w0.127: RB304.1 192.75,28.57 v1(193.09,28.91) 193.71,28.29 v2(194.28,28.29) ; v1(177.97,34.25) RB521.1
SFP+_P22_SCL_R: length 13
  BOTTOM w0.127: RB304.2 190.61,28.06 189.15,28.06 188.83,28.38 RB294.2 187.14,28.57 v2(186.96,28.75) 186.83,28.88 180.39,28.88 180.25,29.02 UB8.16
SFP+_P22_SDA: length 39.8
  S7 w0.127: v1(177.97,35.27) 178.55,34.69 179.24,34 179.24,32.92 181.85,30.3 192.59,30.3 v1(193.11,29.78)
  S14 w0.127: CONN55_PF.5L4 177.96,49.58 176.52,48.13 176.52,47.5 178.09,45.92 178.09,44.18 177.7,43.79 177.7,43.16 178.09,42.77 178.09,42.21 177.38,41.5 177.38,35.86 v1(177.97,35.27)
  BOTTOM w0.127: v2(194.34,30.33) 193.65,30.33 v1(193.11,29.78) 192.1,29.78 RB305.1 ; v1(177.97,35.27) RB485.1
SFP+_P22_SDA_R: length 13.2
  BOTTOM w0.127: UB8.15 184.91,29.67 v2(184.93,29.69) 184.95,29.66 188.78,29.66 RB295.2 188.83,29.4 189.07,29.16 190.95,29.16 191.11,29.32 RB305.2
SFP+_P23_SCL: length 36.8
  S7 w0.127: v1(193.09,26.37) 194.94,28.21 194.94,31.82 193.89,32.87 193.89,34.49 194.63,35.23 v1(194.63,35.27) 193.92,35.98 193.92,37.57 192.34,39.14 192.34,41.02 191.61,41.75 191.61,43.6 192.34,44.33 192.34,45.9 190.76,47.48 190.76,48.12 191.68,49.04 191.68,49.73 190.81,50.61 190.81,51.27 191.45,51.91 191.45,52.93 190.61,53.77 CONN55_PF.6T5
  BOTTOM w0.127: v1(193.09,26.37) 193,26.28 RB302.1 ; RB453.1 v1(194.63,35.27) 195.31,35.27 v2(195.54,35.05)
SFP+_P23_SCL_R: length 13.6
  BOTTOM w0.127: RB302.2 190.48,25.64 189.15,25.64 188.83,25.97 RB292.2 187.45,26.28 187.41,26.31 v2(187.36,26.31) 185.69,26.31 184.28,27.72 UB8.18
SFP+_P23_SDA: length 37.2
  S7 w0.127: v1(187.52,33.24) 189.05,34.77 189.05,36.62 190.11,37.69 190.11,40.64 189.63,41.12 189.63,47.39 191.29,49.06 191.29,49.72 190.52,50.5 190.52,51.35 191.18,52.02 191.18,52.75 189.81,54.12 189.81,54.6 CONN55_PF.6T4
  S9 w0.127: v1(187.52,33.24) 188.22,32.53 191.07,32.53 191.94,31.67 191.94,28.37 193.09,27.22 v1(193.09,27.21)
  BOTTOM w0.127: v2(186.73,33.24) v1(187.52,33.24) RB489.1 ; v1(193.09,27.21) 192.88,27.42 RB303.1
SFP+_P23_SDA_R: length 13.1
  BOTTOM w0.127: RB303.2 190.61,26.91 189.25,26.91 188.83,27.34 RB293.2 185.59,27.42 v2(185.54,27.48) 184.64,28.37 UB8.17
SFP+_P24_SCL: length 34.1
  S9 w0.127: v1(192.22,34.25) 194.33,32.15 194.33,26.64 193.31,25.63 192.68,25.63 192.32,25.27 192.32,24.86 193.09,24.09 v1(193.09,24.07)
  S14 w0.127: CONN55_PF.6L5 191.41,49.16 189.65,47.39 189.65,41.44 190.2,40.89 190.2,36.97 190.92,36.24 190.92,35.55 v1(192.22,34.25)
  BOTTOM w0.127: R1190.1 193.02,23.99 v1(193.09,24.07) 193.82,23.34 v2(194.08,23.34) ; RB524.1 v1(192.22,34.25)
SFP+_P24_SCL_R: length 14.7
  BOTTOM w0.127: UB8.20 179.56,26.42 183.15,22.83 185.43,22.83 186.3,23.7 v2(187.21,23.7) 187.21,23.75 187.46,23.99 R1188.2 188.83,23.91 189.23,23.51 190.63,23.51 R1190.2
SFP+_P24_SDA: length 33.9
  S9 w0.127: v1(193.09,24.93) 194.88,26.73 194.88,32.18 193.36,33.7 193.36,34.19 192.25,35.3 v1(192.22,35.27)
  S14 w0.127: v1(192.22,35.27) 191.63,35.86 191.63,41.5 192.34,42.21 192.34,42.61 191.99,42.96 191.99,43.41 192.34,43.76 192.34,45.92 190.77,47.5 190.77,48.13 192.21,49.58 192.21,51.6 CONN55_PF.6L4
  BOTTOM w0.127: v2(194.02,25.94) 194.02,25.86 v1(193.09,24.93) 192.89,25.14 R1191.1 ; RB488.1 v1(192.22,35.27)
SFP+_P24_SDA_R: length 13.7
  BOTTOM w0.127: R1191.2 190.61,24.63 189.03,24.63 188.83,24.83 RB291.2 186.25,25.14 184.29,27.1 v2(182.64,27.1) 182.61,27.07 UB8.19
SKIP#_VCC1V0: length 31.3
  TOP w0.254: R534.2 111.6,130.45 110.94,129.79 v1(110.94,129.72) 110.86,129.64 U33.39
  TOP w0.508: R491.1 v1(104.54,134.59) ; R655.1 v1(104.74,119.35)
  S7 w0.203: v1(110.94,129.72) 110.89,129.77 110.89,132.38 108.68,134.59 v1(104.54,134.59)
  S9 w0.203: v1(104.74,119.35) 105.81,119.35 106.75,120.29 109.93,120.29 110.77,121.13 110.77,129.55 v1(110.94,129.72)
  BOTTOM w0.127: v1(104.54,134.59) 105.2,135.25 v2(105.2,136.17)
SN65C_1DE: length 7.3
  TOP w0.127: v1(241.07,85.95) 241.07,84.62 241.78,83.91 U51.4
  BOTTOM w0.127: v2(241.58,87.92) 241.45,88.06 RB273.1 240.37,87.05 RB280.2 RB278.1 241.01,86.02 v1(241.07,85.95)
SN65C_2DE: length 6.1
  TOP w0.254: U51.12 v1(242.43,90.52)
  TOP w0.381: v1(242.43,90.52) 242.43,91.53 R856.2 R855.1 R853.1
  BOTTOM w0.127: v2(243.36,91.29) 242.6,90.52 v1(242.43,90.52)
SP01_P08_A0: length 14.3
  BOTTOM w0.127: RB670.2 45.11,21.17 46.94,21.17 47.14,21.37 RB671.1 v2(48.21,21.68) 48.85,21.68 49.36,21.17 53.36,21.17 56.01,23.82 UB13.1
SP01_P08_A1: length 14.1
  BOTTOM w0.127: RB660.2 45.13,22.3 46.93,22.3 47.14,22.52 RB661.1 49.61,22.82 v2(50,22.43) 50.12,22.32 53.87,22.32 56.02,24.47 UB13.2
SP01_P08_A2: length 15.2
  BOTTOM w0.127: UB13.21 63.65,25.77 67.28,22.15 v2(69.49,22.15) 70.32,22.15 71.03,22.85 RB653.1 72.78,22.35 72.99,22.13 74.83,22.13 75.06,22.36 RB654.2
SP01_P08_R_SDA: length 110.6
  S14 w0.127: v1(61.46,24.15) 63.59,22.02 63.59,20.89 66.22,18.26 86.45,18.26 87.26,17.45 91.83,17.45 92.64,18.26 150.98,18.26 156.95,12.29 157.12,12.29 v1(157.73,11.68)
  BOTTOM w0.127: v2(60.99,21.31) 60.99,23.68 v1(61.46,24.15) 61.78,24.47 UB13.23 ; v2(155.22,11.66) 157.7,11.66 v1(157.73,11.68) RB720.1
SP01_P08_RESET_N: length 332.4
  TOP w0.127: P1.W5 v4(113.29,213.46)
  S5 w0.127: v1(36.51,205.8) 36.9,206.19 66.91,206.19 68.4,204.7 70.37,204.7 71.81,206.13 74.07,206.13 v1(75.83,204.37)
  S7 w0.127: v1(36.51,205.8) 31.55,205.8 11.26,185.5 11.26,180.34 1.9,170.98 1.9,140.5 1.82,140.43 1.82,135.99 1.9,135.92 1.9,135.42 1.82,135.35 1.82,132.74 1.9,132.66 1.9,126.64 2.31,126.22 2.31,103.08 7.25,98.14 8.18,98.14 11.66,94.66 11.66,92.14 16.23,87.57 16.23,77.47 13.99,75.24 13.99,68.46 10.82,65.28 10.82,55 13.61,52.21 13.61,47.03 v1(27.91,32.74)
  S16 w0.127: v1(75.83,204.37) 78.23,206.78 81.51,206.78 81.79,206.5 84.29,206.5 86.58,208.79 88.26,208.79 90.14,210.67 91.85,210.67 94.14,212.95 112.8,212.95 113.29,213.43 v4(113.29,213.46) ; v1(55.53,24.93) 50.84,20.24 33.32,20.24 27.91,25.65 v1(27.91,32.74)
  BOTTOM w0.127: v1(55.53,24.93) 55.72,25.12 UB13.3 ; v2(74.12,205.31) 74.46,204.97 75.2,204.97 75.79,204.37 v1(75.83,204.37)
SP01_P08_SCL: length 112.7
  S14 w0.127: v1(159.02,11.73) 157.95,12.8 157.16,12.8 150.81,19.14 66.06,19.14 64.14,21.06 64.14,21.21 64.14,21.21 64.14,21.71 64.14,21.71 64.14,22.33 v1(61.38,25.09)
  BOTTOM w0.127: v1(159.02,11.73) 159.41,11.34 RB706.1 ; v2(57.31,20.93) 57.31,22.07 60.33,25.09 v1(61.38,25.09) 61.41,25.12 UB13.22
SP01_P08_SCL_R: length 13.5
  BOTTOM w0.127: RB706.2 161.18,10.84 162.99,10.84 163.22,11.06 RB707.2 165.66,11.34 v2(165.82,11.5) 165.95,11.5 166.77,12.33 171.43,12.33 171.76,12.66 UB17.5
SP01_P08_SDA: length 4.4
  BOTTOM w0.127: RB712.1 159.3,10.2 RB720.2 158.41,10.64 158.41,10.21 157.62,9.42 v2(157.62,8.3)
SP01_P08_SDA_R: length 13.9
  BOTTOM w0.127: RB712.2 160.86,10.2 161.37,9.69 163.02,9.69 163.22,9.89 RB713.2 164.08,10.2 v2(164.2,10.08) 165.44,10.08 166.89,11.53 171.24,11.53 171.71,12.01 UB17.4
SP09_P16_A0: length 14.8
  BOTTOM w0.127: RB672.1 117.89,21.18 118.05,21.03 120.13,21.03 120.43,21.33 RB673.2 v2(121.51,21.68) 122.15,21.68 122.66,21.17 126.88,21.17 129.53,23.82 UB12.1
SP09_P16_A1: length 14.1
  BOTTOM w0.127: RB664.2 118.43,22.3 120.23,22.3 120.44,22.52 RB663.1 122.91,22.82 v2(123.3,22.43) 123.42,22.32 127.46,22.32 129.62,24.47 UB12.2
SP09_P16_A2: length 14.7
  BOTTOM w0.127: RB658.2 147.71,22.2 146.59,22.2 146.08,22.71 RB657.1 144.33,22.85 143.62,22.15 v2(142.79,22.15) 140.58,22.15 136.95,25.77 UB12.21
SP09_P16_R_SDA: length 37
  S9 w0.127: v1(134.76,24.15) 138.07,24.15 140.99,21.23 154.74,21.23 157.23,18.74 157.23,14.21 v1(157.27,14.17)
  BOTTOM w0.127: UB12.23 135.08,24.47 v1(134.76,24.15) 134.08,23.47 v2(134.08,21.18) ; RB692.1 157.73,13.71 v1(157.27,14.17) 156.34,14.17 155.92,13.75 v2(155.92,13.76)
SP09_P16_RESET_N: length 371.3
  TOP w0.127: P1.C7 v4(96.29,215.46)
  S12 w0.127: v1(131.58,25.12) 131.64,25.12 134.56,22.2 196.91,22.2 222.28,47.57 222.28,66.61 217.29,71.6 211.95,71.6 207.14,76.41 207.14,98.69 v1(207.61,99.16)
  S14 w0.127: v4(96.29,215.46) 95.75,214.92 95.15,214.92 93.02,212.78 93.02,209.28 92.41,208.67 92.41,207.88 91.51,206.98 91.51,204.61 92.78,203.34 92.78,202.99 96.4,199.36 112.29,199.36 118.77,192.89 126.16,192.89 128.09,190.96 132.96,190.96 140.49,183.44 140.49,152.44 142.65,150.28 142.65,146.81 144.84,144.61 147.6,144.61 148.56,143.66 148.56,140.77 149.92,139.41 151.64,139.41 154.36,136.69 173.77,136.69 190.35,120.1 190.35,110.52 196.83,104.05 203.79,104.05 207.61,100.23 v1(207.61,99.16)
  BOTTOM w0.127: v2(129.82,21.37) 131.58,23.13 v1(131.58,25.12) 131.58,25.12 UB12.3
SP09_P16_SCL: length 39.5
  S9 w0.127: v1(134.68,25.09) 134.69,25.1 138.46,25.1 141.38,22.17 154.66,22.17 157.98,18.86 157.98,14.65 v1(158.74,13.89)
  BOTTOM w0.127: RB693.1 159,13.63 v1(158.74,13.89) ; UB12.22 134.71,25.12 v1(134.68,25.09) 132.36,22.77 v2(132.36,20.29)
SP09_P16_SCL_R: length 13.3
  BOTTOM w0.127: RB693.2 161.18,13.12 162.94,13.12 163.22,13.4 RB694.2 166.07,13.63 v2(166.15,13.71) 166.44,13.43 170.95,13.43 171.48,13.96 UB17.7
SP09_P16_SDA: length 7.1
  BOTTOM w0.127: RB701.1 159.05,12.49 RB692.2 158.46,12.73 158.46,12.49 158.33,12.37 156.38,12.37 156.01,12.74 v2(153.32,12.74)
SP09_P16_SDA_R: length 13.4
  BOTTOM w0.127: UB17.6 171.49,13.31 171.02,12.83 164.46,12.83 v2(164.25,12.62) 164.11,12.49 RB702.2 163.22,12.05 163.14,11.98 161.18,11.98 RB701.2
SP17_P24_A0: length 15.1
  BOTTOM w0.127: UB8.1 172.08,23.82 169.43,21.17 165.41,21.17 164.9,21.68 v2(164.26,21.68) 164.24,21.66 RB274.2 163.16,21.64 163.16,21.05 162.86,20.75 161.1,20.75 160.64,21.21 RB275.1
SP17_P24_A1: length 14.5
  BOTTOM w0.127: UB8.2 171.97,24.47 169.81,22.32 166.17,22.32 v2(166.05,22.43) 165.65,22.83 RB245.2 163.18,22.45 162.93,22.2 160.85,22.2 160.67,22.38 RB262.1
SP17_P24_A2: length 15
  BOTTOM w0.127: R1187.2 191.11,22.39 191,22.27 189.02,22.27 188.83,22.46 R1189.1 187.08,22.85 186.37,22.15 v2(185.54,22.15) 183.33,22.15 179.7,25.77 UB8.21
SP17_P24_R_SDA: length 11.8
  BOTTOM w0.127: RB279.1 187.89,21.71 v2(187.16,20.99) 187.1,20.93 183.71,20.93 180.18,24.46 178.85,24.46 UB8.23
SP17_P24_RESET_N: length 400.3
  TOP w0.127: P1.D19 v4(97.29,228.46)
  S7 w0.127: v1(206.98,99.92) 207.23,100.18 207.23,107.48 210.02,110.27 210.02,129.13 210.38,129.49 212.11,129.49 212.72,130.1 212.72,131.83 219.99,139.1 219.99,139.16 220.18,139.35 v1(220.18,141.07)
  S9 w0.127: v1(206.98,99.92) 206.98,79.09 211.17,74.9 211.17,74.39 212.56,73 214.28,73 221.31,65.96 221.31,47.17 213.38,39.24 213.38,38.5 213.38,35.96 202.67,25.25 200.51,25.25 197.53,22.26 182.81,22.26 179.06,26.01 175.22,26.01 v1(174.33,25.12)
  S14 w0.127: v4(97.29,228.46) 97.29,228.47 97.8,228.98 97.8,229.62 98.26,230.09 98.26,232.83 97.06,234.03 97.06,235.46 98.51,236.91 98.51,239 104.64,245.13 107.58,245.13 109.99,247.55 133.5,247.55 133.78,247.27 146.19,247.27 156.1,237.36 159.36,237.36 161.87,234.85 161.87,229.86 167.12,224.61 167.12,221.3 166.34,220.51 166.34,218.18 167.11,217.4 167.11,216.05 172.43,210.73 179.92,210.73 180.5,211.3 190.6,211.3 190.6,211.3 190.62,211.3 192.6,209.32 208.31,209.32 209.05,209.32 214.88,203.48 214.88,190.09 215.42,189.56 215.42,152.25 214.25,151.08 214.25,146.57 215.98,144.84 215.98,144.44 218.86,141.55 219.7,141.55 v1(220.18,141.07)
  BOTTOM w0.127: UB8.3 174.33,25.12 v1(174.33,25.12) 174.59,24.86 174.59,20.86 v2(174.53,20.8)
SP17_P24_SCL: length 26.5
  S9 w0.127: v1(158.94,15.92) 159.76,16.74 159.76,18.31 162.83,21.38 173.72,21.38 v1(177.43,25.09)
  BOTTOM w0.127: v1(177.43,25.09) 177.46,25.12 UB8.22 ; RB676.1 v1(158.94,15.92) 158.61,15.59 v2(158.08,15.59)
SP17_P24_SCL_R: length 14
  BOTTOM w0.127: UB17.9 171.21,15.26 170.37,14.42 169.08,14.42 167.96,15.54 165.01,15.54 v2(164.83,15.72) 164.1,15.72 163.9,15.92 RB677.2 163.22,15.57 163.05,15.41 161.18,15.41 RB676.2
SP17_P24_SDA: length 38.5
  S9 w0.127: v1(158.81,14.77) 160.29,16.25 160.29,17.78 162.91,20.39 189.42,20.39 v1(190.59,21.56)
  BOTTOM w0.127: RB279.2 190.44,21.71 v1(190.59,21.56) 191.29,20.86 v2(191.42,20.86) ; RB682.1 v1(158.81,14.77)
SP17_P24_SDA_R: length 13.6
  BOTTOM w0.127: RB682.2 161.18,14.27 163.02,14.27 163.22,14.47 RB683.2 167.59,14.77 v2(168.01,14.35) 168.36,14 170.71,14 171.32,14.61 UB17.8
SPI_CLK: length 4.4
  TOP w0.127: RB1297.1 257.5,203.27 258.04,202.72 CONN58.7
SPI_MISO: length 5.6
  TOP w0.127: RB1296.1 v1(256.73,204.28) 257.71,205.26 CONN58.5
  BOTTOM w0.127: v2(257.65,204.32) 257.61,204.28 v1(256.73,204.28)
SPI_MOSI: length 10.6
  TOP w0.127: CONN58.8 262.92,202.72 262.1,201.9 261.89,201.9 261.89,201.9 258.07,201.9 258.07,201.9 257.11,201.9 v1(256.76,202.25) RB1299.2
  BOTTOM w0.127: v2(257.9,202.03) 256.98,202.03 v1(256.76,202.25)
SPI_SS: length 5.7
  TOP w0.127: CONN58.9 257.72,200.18 v1(256.67,201.23) RB1298.1
  BOTTOM w0.127: v1(256.67,201.23) 256,200.57 v2(256,200.51)
SS_VCC5P0: length 4
  TOP w0.508: U34.8 v1(245.24,160.68) 244.88,160.32 C356.1
  BOTTOM w0.254: v1(245.24,160.68) 245.29,160.63 v2(246.09,160.63)
STACKING_CNTL_MDI_N0_GE: length 84.5
  TOP w0.095: U76.22 232.32,77.94 232.92,77.34 232.92,76.97 v3(232.65,76.71)
  S9 w0.108: RJ1.A2 227.12,16.88 226.7,16.46 226.7,15.99 227.75,14.94 227.75,13.71 228.18,13.27 235.6,13.27 237.45,15.13 237.45,21.42 239.88,23.85 239.88,26.95 238.58,28.24 236.8,28.24 232.31,32.74 232.31,72.5 232.94,73.14 232.94,76.42 v3(232.65,76.71)
STACKING_CNTL_MDI_N1_GE: length 79.3
  TOP w0.095: v3(229.6,74.93) 229.9,75.22 229.9,75.79 229.03,76.65 229.03,77.1 228.94,77.2 228.68,77.2 228.51,77.37 U76.19
  S12 w0.108: RJ1.A6 231.95,17.53 231.47,17.53 231.13,17.19 231.13,16.08 231.6,15.61 236.45,15.61 237.48,16.63 237.48,21.47 239.82,23.8 239.82,27 238.58,28.24 236.81,28.24 232.29,32.76 232.29,70.66 229.9,73.06 229.9,74.64 v3(229.6,74.93)
STACKING_CNTL_MDI_N2_GE: length 82.1
  TOP w0.095: U76.16 224.7,77.37 224.87,77.2 225.13,77.2 225.22,77.1 225.22,76.66 225.77,76.11 226.72,76.11 227.23,75.6 227.23,75.35 v3(226.94,75.06)
  S16 w0.108: v3(226.94,75.06) 227.23,74.76 227.23,73.78 232.22,68.79 232.22,32.7 236.75,28.17 238.66,28.17 239.86,26.97 239.86,23.9 234.54,18.58 229.63,18.58 228.68,17.63 228.68,15.92 229.21,15.38 230.29,15.38 RJ1.A5
STACKING_CNTL_MDI_N3_GE: length 80.6
  TOP w0.095: v3(224.27,75.06) 224.56,75.35 224.56,75.72 224.47,75.82 222.25,75.82 221.41,76.66 221.41,77.1 221.32,77.2 220.99,77.2 220.89,77.29 U76.13
  S7 w0.108: v3(224.27,75.06) 224.56,74.76 224.56,74.04 225.42,73.18 227.82,73.18 232.21,68.78 232.21,32.84 236.8,28.25 238.57,28.25 239.79,27.04 239.79,23.84 237.51,21.56 237.51,16.54 236.58,15.62 234.57,15.62 234.38,15.81 234.38,16.68 234.58,16.88 RJ1.A8
STACKING_CNTL_MDI_P0_GE: length 84.5
  TOP w0.095: v3(233.46,76.71) 233.37,76.71 233.15,76.93 233.15,77.44 233.14,77.44 233.59,77.89 U76.23
  S9 w0.108: RJ1.A1 226.25,15.07 226.5,15.32 227.04,15.32 227.52,14.85 227.52,13.61 228.08,13.05 235.69,13.05 237.68,15.03 237.68,21.32 240.11,23.76 240.11,27.04 238.68,28.47 236.9,28.47 232.54,32.84 232.54,72.41 233.17,73.04 233.17,76.42 v3(233.46,76.71)
STACKING_CNTL_MDI_P1_GE: length 79.3
  TOP w0.095: v3(230.42,74.93) 230.12,75.22 230.12,75.88 229.26,76.75 229.26,77.1 229.36,77.2 229.53,77.2 229.78,77.45 U76.20
  S12 w0.108: RJ1.A3 229.96,15.51 231.38,15.51 231.51,15.38 236.55,15.38 237.71,16.54 237.71,21.37 240.05,23.71 240.05,27.1 238.67,28.47 236.9,28.47 232.52,32.86 232.52,70.76 230.12,73.15 230.12,74.64 v3(230.42,74.93)
STACKING_CNTL_MDI_P2_GE: length 82.1
  TOP w0.095: U76.17 225.97,77.39 225.78,77.2 225.55,77.2 225.45,77.1 225.45,76.75 225.87,76.34 226.81,76.34 227.46,75.69 227.46,75.35 v3(227.75,75.06)
  S16 w0.108: RJ1.A4 230.74,16.2 230.74,15.85 230.5,15.61 229.31,15.61 228.91,16.01 228.91,17.53 229.73,18.35 234.63,18.35 240.08,23.8 240.08,27.07 238.76,28.39 236.85,28.39 232.45,32.8 232.45,68.88 227.46,73.87 227.46,74.76 v3(227.75,75.06)
STACKING_CNTL_MDI_P3_GE: length 80.6
  TOP w0.095: v3(225.08,75.06) 224.79,75.35 224.79,75.82 224.56,76.05 222.35,76.05 221.64,76.75 221.64,77.1 221.74,77.2 222.07,77.2 222.16,77.29 U76.14
  S7 w0.108: RJ1.A7 233.87,15.2 234.05,15.39 236.68,15.39 237.73,16.44 237.73,21.46 240.02,23.75 240.02,27.13 238.67,28.48 236.89,28.48 232.44,32.93 232.44,68.88 227.91,73.41 225.52,73.41 224.79,74.13 224.79,74.76 v3(225.08,75.06)
SW1_CPU_TCK: length 2.9
  TOP w0.127: v1(247.17,237.84) 246.32,237.84 R418.2 246.29,237.82 R351.2
  BOTTOM w0.127: v2(247.87,237.08) 247.87,237.14 v1(247.17,237.84)
SW1_CPU_TCK_R: length 4.1
  TOP w0.127: R418.1 245.36,237.84 244.63,237.84 v1(244.44,238.03) 244.24,238.24 U21.11
  BOTTOM w0.127: v1(244.44,238.03) 245.27,238.03 v2(245.46,237.84)
SW1_CPU_TDI: length 2.7
  TOP w0.127: R398.2 232.38,238.53 v1(232.31,238.61) 232.18,238.48 R370.2
  BOTTOM w0.127: v1(232.31,238.61) 232.57,238.35 v2(233.33,238.35)
SW1_CPU_TDI_R: length 4.8
  TOP w0.127: U21.5 v1(235.13,238.89) 234.78,238.53 R398.1
  BOTTOM w0.127: v1(235.13,238.89) 235.78,238.24 v2(236.76,238.24)
SW1_CPU_TDO: length 2.8
  TOP w0.127: R386.2 v1(247.12,239.83) 247.37,240.08 R379.2
  BOTTOM w0.127: v1(247.12,239.83) 247.11,239.81 246.56,240.36 v2(246.42,240.36)
SW1_CPU_TDO_R: length 4.4
  TOP w0.127: U21.14 244.43,240.19 v1(244.44,240.19) 244.45,240.19 244.81,239.83 R386.1
  BOTTOM w0.127: v1(244.44,240.19) 244.44,241.02 v2(244.82,241.4)
SW1_CPU_TMS: length 2.5
  TOP w0.127: R381.2 232.36,240.57 v1(232.31,240.51) R383.2
  BOTTOM w0.127: v2(232.95,241.21) 232.95,241.15 v1(232.31,240.51)
SW1_CPU_TMS_R: length 5.4
  TOP w0.127: R381.1 234.65,240.57 234.92,240.84 U21.2 v1(238.08,240.84)
  BOTTOM w0.127: v1(238.08,240.84) 237.9,241.02 v2(236.88,241.02)
SW1_FAN_TCK: length 30.3
  TOP w0.127: v1(232.12,247.18) 232.1,247.2 CONN56.26 ; R426.2 v1(247.11,235.81)
  S7 w0.127: v1(232.12,247.18) 233.33,245.97 245.2,245.97 248.76,242.42 248.76,237.46 v1(247.11,235.81)
  BOTTOM w0.127: v2(247.17,234.86) 247.11,234.92 v1(247.11,235.81)
SW1_FAN_TCK_R: length 6.9
  TOP w0.127: v1(241.07,237.72) 241.2,237.59 U21.10 242.54,237.59 243.49,237.59 243.89,237.19 243.89,236.36 244.44,235.81 R426.1
  BOTTOM w0.127: v2(241.84,236.7) 241.84,236.95 v1(241.07,237.72)
SW1_FAN_TDI: length 27.1
  TOP w0.127: CONN56.27 230.83,257.08 v1(230.72,257.19) ; R420.2 v1(232.38,237.53)
  BOTTOM w0.127: v1(230.72,257.19) 230.72,249.59 228.31,247.18 228.31,239.88 229.23,238.95 230.02,238.95 230.3,238.68 230.3,238.65 231.17,237.78 v2(231.17,237.53) 232.38,237.53 v1(232.38,237.53)
SW1_FAN_TDI_R: length 4.7
  TOP w0.127: R420.1 234.79,237.53 v1(235.26,238) 235.5,238.24 U21.6
  BOTTOM w0.127: v1(235.26,238) 234.66,237.4 v2(234.66,236.57)
SW1_FAN_TDO: length 27.3
  TOP w0.127: v1(230.91,245.34) 230.83,245.42 CONN56.28 ; R396.2 v1(247.12,238.81)
  S7 w0.127: v1(230.91,245.34) 242.92,245.34 245.96,242.29 245.96,239.97 v1(247.12,238.81)
  BOTTOM w0.127: v1(247.12,238.81) 248.12,239.81 v2(248.44,239.81)
SW1_FAN_TDO_R: length 4.1
  TOP w0.127: U21.13 v1(243.87,239.54) 244.14,239.54 244.87,238.81 R396.1
  BOTTOM w0.127: v2(243.23,238.86) 243.23,238.9 v1(243.87,239.54)
SW1_FAN_TMS: length 28.5
  TOP w0.127: v1(231.99,257.11) 232.1,257 CONN56.25 ; R388.2 v1(232.37,239.55)
  BOTTOM w0.127: v2(234.85,240.64) 234.72,240.64 233.77,239.68 232.5,239.68 v1(232.37,239.55) 232.04,239.88 229.16,239.88 228.82,240.22 228.82,246.73 231.99,249.91 v1(231.99,257.11)
SW1_FAN_TMS_R: length 5.5
  TOP w0.127: v1(238.09,240) 237.91,240.19 U21.3 235.23,240.19 234.59,239.55 R388.1
  BOTTOM w0.127: v2(238.66,239.18) 238.66,239.43 v1(238.09,240)
SW1_OE_N: length 5.4
  TOP w0.127: R1012.2 245.4,240.83 R350.2 244.45,240.82 244.43,240.84 v1(243.93,240.84) U21.15
  BOTTOM w0.127: v1(243.93,240.84) 243.35,241.42 v2(242.69,241.42)
SW1_SELECT: length 139.5
  TOP w0.127: R1014.1 231.63,241.58 R352.2 R1013.2 232.35,242.57 v1(232.5,242.42) ; P1.W11 v4(113.29,219.46)
  S7 w0.127: v1(174.97,233.53) 175.1,233.4 177.07,233.4 179.13,235.46 180.78,235.46 181.77,236.45 181.77,237.14 183.67,239.05 186.85,239.05 189.27,241.46 202.47,241.46 203.2,242.2 209.18,242.2 209.28,242.1 232.18,242.1 v1(232.5,242.42)
  S9 w0.127: v4(113.29,219.46) 113.41,219.46 114.26,220.32 116.04,220.32 116.89,221.17 117.09,221.17 117.64,221.71 118.72,221.71 119.17,221.27 121.52,221.27 121.76,221.51 123.16,221.51 123.87,222.22 133.44,222.22 135.92,224.7 140.38,224.7 141.38,223.7 145.79,223.7 146.79,224.7 164.86,224.7 166.13,223.43 167.09,223.43 168.17,224.51 168.17,227.61 171.54,230.98 171.54,231.24 173,232.7 173.38,232.7 174.21,233.53 v1(174.97,233.53)
  BOTTOM w0.127: v1(232.5,242.42) 231.68,243.24 v2(231.17,243.24)
SW1_SELECT_R: length 5.4
  TOP w0.127: v1(238.09,241.78) 237.8,241.49 U21.1 234.13,241.49 R1014.2
  BOTTOM w0.127: v2(238.09,242.92) v1(238.09,241.78)
SW_VCC5P0: length 5.5
  BOTTOM w0.254: v2(254.85,165.07) 254.85,164.18 v1(255.11,163.93)
  BOTTOM w0.508: CB440.2 254.91,161.82 R598.2 254.91,163.73 v1(255.11,163.93) 255.87,164.69 D2.C
SW_VCC5P0_PLL_C: length 2.2
  BOTTOM w0.508: R598.1 256.12,162.73 C326.1 257.21,162.1 v2(257.27,162.15)
SYNCE_PLL_AVDD1P8: length 6.2
  TOP w0.381: v4(31.7,122.65) U40.AE26 ; U40.AD25 v4(32.7,121.65)
  BOTTOM w0.127: v2(39.12,138.92) 39.14,138.89 v1(40.26,138.89)
  BOTTOM w0.381: v4(32.7,121.65) 32.7,121.74 CB488.1 31.8,122.65 v4(31.7,122.65) 31.2,122.15 CB490.1 ; v4(32.7,121.65) CB495.1 ; v4(32.7,121.65) 33.19,122.14 CB481.1
  vias: v1(40.29,139.58)
SYS_CPLD_INT_CPU: length 180.7
  TOP w0.127: J2.A54 170.44,142.77 v1(170.35,142.85) ; P1.M16 v4(106.29,225.46)
  S12 w0.127: v1(170.35,142.85) 169.79,143.42 169.79,154.81 170.24,155.26 170.24,159.37 176.43,165.56 176.43,187.6 171.42,192.62 171.42,193.9 169.51,195.81 v1(169.51,203.55)
  S14 w0.127: v4(106.29,225.46) 105.76,225.99 104.83,225.99 103.59,227.23 103.59,230.55 104.07,231.03 104.63,231.03 105.18,231.57 105.18,238.4 106.32,239.55 107.9,239.55 112.35,244 128.31,244 129.36,242.95 134.59,242.95 135.56,241.99 141.62,241.99 144.87,238.73 145.95,238.73 148.29,236.4 148.29,229.82 152.27,225.83 157.97,225.83 161.32,222.48 161.32,215.68 169.51,207.49 v1(169.51,203.55)
  BOTTOM w0.127: v2(169.57,204.76) 169.57,203.62 v1(169.51,203.55)
SYS_PWR_READY: length 163.5
  TOP w0.127: R79.2 88.59,210.16 v1(88.41,209.98) ; v1(218.75,221.56) 219.29,222.11 223.02,222.11 223.13,222.22 R52.2 223.29,222.64 224.51,221.43 225.34,221.43 225.53,221.24 U7.21
  S9 w0.127: v1(218.75,221.56) 211.78,221.56 200.83,210.62 196.07,210.62 194.97,209.52 178.96,209.52 178.17,210.31 166.7,210.31 165.76,211.25 145.64,211.25 144.12,209.73 144.12,208.2 142.54,206.63 140.46,206.63 140.05,206.22 137.07,206.22 135.13,204.28 134.83,204.28 134.82,204.27 132.06,204.27 131.28,203.49 131.28,199.81 129.19,197.71 96.67,197.71 89,205.39 89,209.4 v1(88.41,209.98)
  BOTTOM w0.508: v2(218.21,220.13) 218.21,221.03 v1(218.75,221.56)
SYS_PWR_READY_R: length 10.1
  TOP w0.127: R79.1 v1(91.02,210.16) 91.28,210.16 91.66,210.54 91.66,212.44 94.18,214.96 P1.A6
  BOTTOM w0.127: v2(89.44,208.44) 91.02,210.03 v1(91.02,210.16)
SYS_SW_RST_N: length 134.8
  TOP w0.127: v1(168.15,146.27) 168.44,145.99 J2.B50 ; P1.AB8 v4(116.29,216.46)
  S14 w0.127: v4(116.29,216.46) 116.93,215.81 116.93,214.03 117.31,213.65 119.35,213.65 120.68,212.32 120.68,209.42 121.06,209.03 121.06,207 123.68,204.38 125.19,204.38 128.62,200.95 141.01,200.95 141.93,200.03 144.81,200.03 152.29,192.54 162.36,192.54 169.2,185.71 169.2,175.76 169.89,175.06 169.89,170.56 159.66,160.32 159.66,154.04 155.35,149.73 155.35,147.18 157.25,145.27 167.15,145.27 v1(168.15,146.27)
  BOTTOM w0.127: v1(168.15,146.27) 168.15,145.39 v2(168.29,145.26) 168.47,145.08 RB1233.2 170.4,145.08 RB1302.1
TB_CHASSIS: length 32
  TOP w0.508: v1(229.34,33.86) C958.2 228.61,35.17 LB98.1 ; C959.2 224.02,32.71 v1(223.84,32.53) ; C739.2 240.9,75.27 v1(240.83,75.2) ; LB99.1 224.02,34.04 v1(223.99,34.01) ; v1(255.35,46.98) 255.04,47.29 C952.2 ; C738.2 v1(239.37,75.25) ; 255.01,45.41 D7.2
  BOTTOM w0.508: LB98.1 v1(229.47,35.17) ; C889.2 v1(236.12,75.41) ; C889.2 236.87,75.8 v1(236.19,76.49) ; C889.2 CB1107.2 C897.1 ; 224.01,33.99 v1(223.99,34.01) ; 224.01,33.99 224.01,35.16 LB99.1 ; 224.01,33.99 C957.2 224.01,32.7 v1(223.84,32.53) ; LB100.1 213.93,15.83 v1(213.94,15.82) ; v1(213.91,25.71) C954.2 213.13,24.22 LB102.1 ; LB103.1 214.12,19.72 v1(214.12,19.72) 214.4,19.43 v2(214.4,18.26) ; v1(255.35,46.98) 255.04,47.29 C952.2 ; v1(248.89,66.39) 248.57,66.71 C737.2 ; v1(243.11,75.29) 243.12,75.3 LB60.1 ; v1(213.95,11.34) LB101.1 213.14,11.32 C955.2 ; LB59.1 v1(240.83,75.2) ; C863.1 249.89,65.77 v1(249.58,66.08) 249.65,66.14 CB937.2 ; C956.2 256.06,47.3 v1(256.37,46.99) ; v1(244.62,75.29) 244.62,75.3 244.64,75.32 LB61.1 ; v1(239.37,75.25) 239.31,75.32 LB58.1
  vias: v1(248.82,46.58) v1(248.82,45.82) v1(256.72,30.23) v1(256.71,29.37) v1(257.41,30.19) v1(257.41,29.4)
TEST_1PPS_RX: length 84.1
  TOP w0.127: v1(240.5,159.36) 240.48,159.38 UB71.2 ; U51.5 242.43,84.15 v1(242.09,84.49)
  S7 w0.127: v1(240.5,159.36) 240.5,151.61 242.28,149.83 242.28,139.29 244.06,137.51 244.06,130.78 243.3,130.02 243.3,126.46 244.57,125.19 244.57,112.24 242.92,110.59 242.92,99.03 241.77,97.89 241.77,95.1 243.17,93.7 243.17,89.51 242.09,88.43 v1(242.09,84.49)
  BOTTOM w0.127: CB1087.2 v1(240.5,159.36) 240.88,159.74 v2(241.39,159.74)
TEST_1PPS_RX_R: length 5.2
  TOP w0.127: UB71.4 v1(235.68,160.33) 235.03,160.33 CB1088.2 RB277.1 RB276.1
  BOTTOM w0.127: v1(235.68,160.33) 235.8,160.45 v2(235.8,161.52)
TEST_UART_RX: length 18.6
  TOP w0.127: U51.3 241.13,83.8 240.5,84.43 v1(240.5,85.06) ; UB70.2 242.83,96.61 v1(242.97,96.47)
  S12 w0.127: v1(240.5,85.06) 240.5,86.46 241.93,87.88 241.93,93.16 242.22,93.45 242.22,95.72 v1(242.97,96.47)
  BOTTOM w0.127: CB1089.2 242.77,96.67 v1(242.97,96.47)
  BOTTOM w0.254: v2(243.49,97.7) 243.49,96.99 v1(242.97,96.47)
TEST_UART_RX_R: length 4.8
  TOP w0.127: UB70.4 244.07,95.67 RB283.1 ; RB283.1 245.87,95.12 v1(246.13,94.87) ; RB283.1 CB1090.2
  BOTTOM w0.254: v2(246.85,94.14) v1(246.13,94.87)
THERMAL_DIODE_N_R: length 18.9
  TOP w0.127: v1(32.41,89.15) 32.41,88.68 TP1.1 ; U40.J25 v4(32.7,105.65)
  BOTTOM w0.127: v1(32.41,89.15) 33.53,90.27 v2(33.53,93.75) 33.53,96.9 33.15,97.28 33.15,105.19 v4(32.7,105.65)
THERMAL_DIODE_P_R: length 20.4
  TOP w0.127: v1(33.17,89.15) 33.17,88.68 TP2.1 ; U40.K25 v4(32.7,106.65)
  BOTTOM w0.127: v4(32.7,106.65) 33.08,106.26 arc(33.24,106.02) 33.3,105.74 33.3,105.41 33.46,105.25 arc(33.59,105.16) 33.73,105.13 33.96,105.13 arc(34.03,105.12) 34.09,105.08 34.11,105.06 arc(34.15,105) 34.17,104.93 34.17,104.24 arc(34.22,104.06) 34.24,103.86 34.24,102.47 arc(34.23,102.27) 34.18,102.08 arc(34.17,102.02) 34.17,101.96 34.17,99.29 arc(34.18,99.17) 34.21,99.05 arc(34.23,98.92) 34.24,98.78 v2(34.24,96.11) 34.24,90.22 v1(33.17,89.15)
TOD_A: length 411.2
  TOP w0.127: P1.B6 v4(95.29,214.46)
  S5 w0.127: v1(92.61,206.66) 92.61,206.27 92.74,206.14 96.97,206.14 98.09,207.26 101.37,207.26 102.67,205.97 102.67,205.1 104.38,203.39 104.38,203.06 105.91,201.52 129.38,201.52 131.6,203.74 133.76,203.74 135.35,202.16 152.79,202.16 162.38,211.74 168.15,211.74 170.95,208.95 205.98,208.95 217.07,197.86 v1(217.07,196.63)
  S7 w0.127: v1(246.66,10.26) 244.25,7.85 228.85,7.85 226.69,10.01 221.48,10.01 220.48,11 216.12,11 212.85,14.27 212.85,29.38 214.14,30.66 214.14,39.15 221.53,46.54 221.53,69.33 218.81,72.04 213.33,72.04 212.25,73.12 208.13,73.12 205.27,75.98 201.9,75.98 192.62,85.25 192.62,129.45 199.78,136.61 207.75,136.61 210.12,138.99 210.12,140.66 214.34,144.88 214.34,150.53 215.93,152.12 215.93,158.85 217.13,160.05 217.13,187.59 215.97,188.75 215.97,195.53 v1(217.07,196.63) ; v1(92.61,206.66) 94.78,208.84 94.78,213.95 v4(95.29,214.46)
  BOTTOM w0.127: RB688.2 v1(246.66,10.26) ; v2(216.98,197.52) 217.03,197.52 217.03,197.52 217.07,197.47 v1(217.07,196.63)
TOD_A_R: length 5
  BOTTOM w0.127: LEDB3.C1 246.66,6.51 v2(246.12,7.06) 246.66,7.6 RB688.1 CB954.2
TOD_G: length 404.2
  TOP w0.127: v4(95.22,211.43) 95.26,211.43 P1.B3
  S5 w0.127: v1(166.19,217.22) 172.61,210.8 205.94,210.8 218.42,198.32 218.42,195.7 v1(217.14,194.41)
  S7 w0.127: v1(217.14,194.41) 217.14,189.4 218.43,188.1 218.43,174.57 218.86,174.14 218.86,170.75 218.02,169.92 218.02,159.36 217.3,158.64 217.3,152.06 215.38,150.14 215.38,144.46 211.14,140.22 211.14,138.5 208.22,135.58 200.1,135.58 193.66,129.13 193.66,86.63 201.26,79.03 202.53,79.03 204.31,77.25 209.96,77.25 213.83,73.38 218.91,73.38 222.35,69.94 222.35,45.81 215.02,38.49 215.02,13.9 217.02,11.9 220.79,11.9 221.93,10.77 227.2,10.77 229.16,8.8 235.99,8.8 238.66,11.47 248.5,11.47 v1(249.77,10.2)
  S9 w0.127: v1(166.19,217.22) 165.13,218.29 161.89,218.29 161,217.4 140.18,217.4 139.09,216.3 137.16,216.3 135.01,214.15 134.24,214.15 132.09,212 132,212 130.46,212 129.57,211.11 129.57,210.22 126.08,206.73 123.22,206.73 121.57,205.08 115.66,205.08 111.73,209.01 102.01,209.01 101.06,209.97 99.91,209.97 98.96,210.92 95.72,210.92 v4(95.22,211.43)
  BOTTOM w0.127: v1(249.77,10.2) 249.71,10.13 RB678.2 ; v1(217.14,194.41) 217.38,194.17 217.38,193.4 v2(217.32,193.4)
TOD_G_R: length 4.1
  BOTTOM w0.127: LEDB3.C2 248.17,6.55 v2(248.69,7.08) CB953.2 RB678.1
TOD_UART_RJ_RX: length 249.6
  TOP w0.127: RB283.2 246.78,94.76 246.35,94.33 243.81,94.33 v1(243.46,94.68) ; P1.H13 v4(101.29,222.46)
  S14 w0.127: v4(101.29,222.46) 101.76,221.99 101.76,221.4 102.73,220.42 104.23,220.42 104.65,220 116.49,220 116.73,219.76 116.73,219.25 116.73,219.25 116.73,219.17 116.94,218.96 116.94,217.65 117.39,217.2 117.79,217.2 118.14,217.55 120.16,217.55 121.12,216.58 121.12,215.94 121.69,215.36 122.77,215.36 123.16,214.98 123.16,214.49 124.82,212.83 124.82,212.07 124.17,211.43 124.17,209.27 124.4,209.04 125.7,209.04 126.74,208 136.62,208 141.19,203.43 145.19,203.43 153.61,195.01 163.44,195.01 173.96,184.48 173.96,151.82 174.71,151.07 175.91,151.07 177.32,149.66 177.32,146.53 180.43,143.42 188.58,143.42 190.5,141.5 190.5,136.63 193.36,133.77 201.96,133.77 203.55,132.18 211.86,132.18 213.01,131.04 213.01,119.72 213.96,118.77 213.96,107.89 217.93,103.92 v1(218.41,103.92)
  S16 w0.127: v1(218.41,103.92) 218.41,104.48 220.01,106.08 237.79,106.08 242.4,101.48 242.4,97.5 241.98,97.09 241.98,95.53 242.84,94.68 v1(243.46,94.68)
  BOTTOM w0.254: v1(243.46,94.68) 244.28,94.68 v2(244.31,94.71)
TPM_RESET_N: length 174.8
  TOP w0.127: v1(221.83,165.45) 221.8,165.42 U72.16 ; P1.R10 v4(109.29,218.46)
  S9 w0.127: v1(210.09,214.92) 207.48,214.92 206.91,214.35 206.61,214.35 201.97,209.7 196.45,209.7 195.5,208.76 178.65,208.76 178.32,209.09 171.18,209.09 171,208.92 170.98,208.92 170.26,208.2 169.76,208.2 165.06,203.5 165.06,203.5 164.94,203.38 138.44,203.38 v1(137.41,204.41)
  S14 w0.127: v1(221.83,165.45) 219.42,167.87 219.42,174.28 218.28,175.42 218.28,206.73 v1(210.09,214.92) ; v1(137.41,204.41) 137.38,204.41 137.38,204.38 136.87,204.89 124.66,204.89 122.93,206.62 122.93,206.85 122.58,207.2 122.22,207.2 121.57,207.85 121.57,212.15 119.56,214.16 117.44,214.16 117.19,214.41 117.19,216.32 115.6,217.9 109.84,217.9 v4(109.29,218.46)
  BOTTOM w0.127: v2(209.37,215.6) 209.41,215.6 v1(210.09,214.92) ; R1490.1 222.47,166.09 v1(221.83,165.45)
TPS53219_VDD: length 4.3
  TOP w0.254: U31.6 v1(162.68,129.5)
  TOP w0.508: C292.1 161.41,129.5 v1(162.68,129.5)
  BOTTOM w0.508: v1(162.68,129.5) 160.94,129.5 v2(160.75,129.7)
TPS53641_SCL_R: length 9.4
  TOP w0.127: v1(166.53,241.46) 167.15,242.09 UB16.5 169.84,242.09 170.34,241.59 RB718.2 170.83,241.15 170.96,241.03 173.21,241.03 173.31,241.14 RB719.2
  BOTTOM w0.127: v2(165.45,241.72) 166.27,241.72 v1(166.53,241.46)
TPS53641_SDA_R: length 7.9
  TOP w0.127: RB725.2 173.31,240.18 173.07,239.94 170.97,239.94 170.83,240.08 RB724.2 170.21,240.45 v1(170.02,240.64) 169.22,241.44 UB16.4
  BOTTOM w0.127: v2(169,241.65) v1(170.02,240.64)
TPS53647_GND_SENSE: length 107.3
  TOP w0.254: v4(40.7,120.65) U40.AC18 ; R614.1 v1(106.09,123.04) R613.2
  S14 w0.254: v1(106.09,123.04) 105.71,123.41 105.6,123.41 103.01,126 103.01,127.71 105.76,130.46 105.76,132.5 105.5,132.76 105.5,135.81 104.68,136.62 88.02,136.62 86.04,138.61 82.17,138.61 69.65,126.08 69.65,118.22 66.67,115.25 60,115.25 59.8,115.44 41.21,115.44 40.2,116.46 40.2,117.47 39.89,117.78 39.28,117.78 38.73,118.34 38.73,120.55 39.31,121.13 40.21,121.13 v4(40.7,120.65)
  BOTTOM w0.254: v2(105.17,122.48) 105.73,123.04 v1(106.09,123.04)
TPS53647_VDD_SENSE: length 104.8
  TOP w0.127: v4(39.7,120.65) U40.AC19
  TOP w0.254: R604.1 v1(106.09,124.05) R605.1
  S14 w0.254: v4(39.7,120.65) 39.59,120.75 39.47,120.75 39.11,120.39 39.11,118.51 39.46,118.16 40.88,118.16 41.19,117.85 41.19,116.46 41.82,115.82 59.96,115.82 60.16,115.63 66.51,115.63 69.26,118.38 69.26,126.24 82.01,138.99 86.2,138.99 88.18,137.01 104.84,137.01 105.88,135.96 105.88,132.92 106.14,132.66 106.14,130.3 103.39,127.56 103.39,126.16 105.5,124.05 v1(106.09,124.05)
  BOTTOM w0.254: v2(105.17,124.46) 105.58,124.05 v1(106.09,124.05)
TS_25M_REFCLK_MAC_N: length 22.1
  TOP w0.095: C406.2 15.38,105.48 16.35,105.48 v3(16.6,105.23) ; U40.U30 v4(27.7,113.65)
  S5 w0.108: v3(16.6,105.23) 16.89,105.52 17.37,105.52 arc(17.8,105.61) 18.16,105.85 18.33,106.01 arc(18.61,106.44) 18.71,106.94 18.71,111.2 arc(18.8,111.64) 19.05,112.02 19.26,112.23 arc(19.43,112.49) 19.5,112.81 19.5,112.87 arc(19.56,113.18) 19.73,113.44 20.21,113.92 arc(20.33,114) 20.48,114.03 26.81,114.03 arc(27.01,114.07) 27.18,114.18 27.24,114.25 arc(27.3,114.28) 27.37,114.3 27.83,114.3 arc(28.12,114.18) 28.24,113.89 28.24,113.75 28.13,113.65 v4(27.7,113.65)
TS_25M_REFCLK_MAC_P: length 22.3
  TOP w0.095: v3(16.6,106.04) 16.27,105.71 15.46,105.71 C404.2 ; U40.U29 v4(28.7,113.65)
  S5 w0.108: v4(28.7,113.65) 28.55,113.65 28.46,113.73 28.46,113.89 arc(28.28,114.34) 27.83,114.53 27.37,114.53 arc(27.21,114.5) 27.08,114.41 27.02,114.34 arc(26.92,114.28) 26.81,114.26 20.48,114.26 arc(20.25,114.21) 20.05,114.08 19.57,113.6 arc(19.35,113.27) 19.27,112.88 19.27,112.81 arc(19.22,112.58) 19.09,112.39 18.89,112.18 arc(18.59,111.73) 18.48,111.2 18.48,106.94 arc(18.4,106.53) 18.16,106.17 18,106.01 arc(17.71,105.82) 17.37,105.75 16.89,105.75 v3(16.6,106.04)
TS_25M_REFCLK_N: length 174.9
  TOP w0.095: v3(12.94,105.23) 13.2,105.48 13.76,105.48 C406.1 ; v3(84.58,217.36) 84.58,217.37 84.97,216.98 85.39,216.98 85.73,217.32 R1509.2 85.9,217.4 R1406.1
  S12 w0.108: v3(84.58,217.36) 84.16,216.94 72.94,216.94 60.69,204.68 55.08,204.68 49.94,199.55 32.8,199.55 arc(31.76,199.34) 30.88,198.75 21.36,189.23 arc(19.96,187.14) 19.47,184.68 19.47,184.67 arc(19.17,183.15) 18.3,181.86 16.7,180.25 arc(16.17,179.47) 15.99,178.55 arc(15.9,178.11) 15.66,177.74 11.59,173.67 arc(10.42,171.92) 10.01,169.87 10.01,165.84 arc(9.74,164.5) 8.99,163.37 8.48,162.86 arc(7.75,161.77) 7.5,160.49 7.5,155.09 arc(7.37,154.44) 7,153.88 5.97,152.86 arc(5.14,151.61) 4.84,150.13 4.84,116.31 arc(4.95,115.79) 5.24,115.34 6.37,114.22 6.38,114.22 arc(7.44,113.58) 8.66,113.36 10.36,113.36 arc(11.19,113.2) 11.9,112.72 12.3,112.32 arc(12.64,111.82) 12.75,111.23 12.75,110.35 arc(12.62,109.66) 12.23,109.08 arc(11.63,108.19) 11.42,107.13 11.42,106.45 arc(11.69,105.79) 12.35,105.52 12.65,105.52 arc(12.86,105.44) v3(12.94,105.23)
TS_25M_REFCLK_N_R: length 16
  TOP w0.095: R1406.2 88.19,216.94 89.87,216.94 90.15,217.22 R1408.1 90.56,217.4 90.66,217.3 90.66,217.03 90.75,216.94 91.18,216.94 v3(91.58,217.33) ; P1.G10 v4(100.29,218.46)
  S12 w0.108: v3(91.58,217.33) 91.97,216.94 93.68,216.94 94.31,217.57 96.79,217.57 97.14,217.92 100.56,217.92 100.68,218.03 100.68,218.29 100.5,218.46 v4(100.29,218.46)
TS_25M_REFCLK_P: length 174.7
  TOP w0.095: v3(84.58,216.35) 84.97,216.75 85.38,216.75 85.72,216.41 R1509.1 85.97,216.25 R1407.1 ; v3(12.94,106.04) 13.27,105.71 13.68,105.71 C404.1
  S12 w0.108: v3(84.58,216.35) 84.22,216.71 83.48,216.71 arc(83.41,216.68) 83.38,216.61 arc(83.35,216.53) 83.28,216.5 82.94,216.5 arc(82.87,216.53) 82.84,216.61 arc(82.81,216.68) 82.74,216.71 82.4,216.71 arc(82.33,216.68) 82.3,216.61 arc(82.27,216.53) 82.2,216.5 81.86,216.5 arc(81.79,216.53) 81.76,216.61 arc(81.73,216.68) 81.66,216.71 81.43,216.71 73.04,216.71 60.78,204.45 55.17,204.45 50.04,199.32 32.8,199.32 arc(31.85,199.13) 31.04,198.59 30.29,197.84 21.52,189.07 arc(20.17,187.05) 19.7,184.67 arc(19.38,183.06) 18.47,181.7 16.86,180.09 arc(16.38,179.38) 16.22,178.55 arc(16.11,178.02) 15.82,177.58 11.75,173.51 arc(10.63,171.84) 10.24,169.87 10.24,165.84 arc(9.96,164.41) 9.15,163.21 8.64,162.7 arc(7.96,161.68) 7.72,160.49 7.72,155.09 arc(7.58,154.35) 7.16,153.72 6.13,152.7 arc(5.35,151.52) 5.07,150.13 5.07,116.31 arc(5.16,115.88) 5.4,115.51 6.37,114.54 arc(6.45,114.47) 6.53,114.39 arc(7.52,113.8) 8.66,113.59 10.36,113.59 arc(11.28,113.41) 12.06,112.88 12.46,112.48 arc(12.85,111.91) 12.98,111.23 12.98,110.35 arc(12.83,109.57) 12.39,108.92 arc(11.84,108.1) 11.65,107.13 11.65,106.45 arc(11.85,105.95) 12.35,105.75 12.65,105.75 arc(12.86,105.84) v3(12.94,106.04)
TS_25M_REFCLK_P_R: length 16
  TOP w0.095: P1.H9 v4(101.29,217.46) ; R1407.2 88.19,216.71 89.81,216.71 90.15,216.37 R1409.1 90.56,216.25 90.66,216.35 90.66,216.62 90.75,216.71 91.18,216.71 v3(91.58,216.32)
  S12 w0.108: v3(91.58,216.32) 91.97,216.71 93.77,216.71 94.41,217.35 96.78,217.35 97.12,217 100.83,217 v4(101.29,217.46)
TS_BIT_CLK0_R: length 34.7
  TOP w0.127: v1(11.45,120.72) 10.71,121.46 R638.2 ; v4(27.7,121.65) U40.AD30
  S12 w0.127: v4(27.7,121.65) 27.38,121.65 26.89,121.16 26.43,121.16 26.25,120.98 26.25,120.52 25.95,120.22 25.54,120.22 25.21,119.89 25.21,119.41 24.91,119.1 20.06,119.1 18.16,121.01 16.42,121.01 16.18,121.26 11.98,121.26 v1(11.45,120.72)
  BOTTOM w0.127: v1(11.45,120.72) 10.19,119.47 10.19,114.99 10.19,113.66 6.8,110.27 v2(5.55,110.27)
TS_BIT_CLK1_R: length 31.6
  TOP w0.127: v1(5.77,125.79) 5.79,125.79 5.79,125.79 5.68,125.79 5.68,125.83 5.64,125.79 5,125.79 R581.2 ; U40.AD29 v4(28.7,121.65)
  S14 w0.127: v4(28.7,121.65) 28.42,121.65 27.88,121.1 21.57,121.1 21.13,121.54 19.44,121.54 18.76,122.22 11.26,122.22 9.25,124.23 7.38,124.23 5.81,125.8 5.81,125.79 5.79,125.79 5.79,125.79 v1(5.77,125.79)
  BOTTOM w0.127: v1(5.77,125.79) 5.79,125.79 5.79,125.79 5.68,125.79 5.68,125.83 5.64,125.79 4.69,125.79 3.2,127.28 v2(3.2,128.81)
TXDIS_01: length 311.3
  TOP w0.127: U9.B8 v4(196.55,198.58)
  S5 w0.127: v4(196.55,198.58) 196.1,199.03 196.1,199.68 195.79,200 194.34,200 192.8,201.54 187.63,201.54 186.46,200.38 183.1,200.38 181.32,198.6 178.43,198.6 174.98,195.15 174.98,195.06 174.92,195 174.92,176.52 171.61,173.2 171.61,172.37 168.24,169.01 167.09,169.01 164.17,166.09 162.27,166.09 156.46,160.27 140.76,160.27 136.41,155.92 136.41,153.61 135.45,152.65 135.45,150.5 135.53,150.42 135.53,148.71 132.91,146.09 126.93,146.09 124.48,143.63 124.48,134.83 123.26,133.62 123.26,119.37 120.62,116.72 120.62,111.03 124.85,106.8 124.85,101.61 123.19,99.95 123.19,92.39 119.97,89.17 84.54,89.17 76.72,81.36 72.31,81.36 70.75,79.79 50.68,79.79 45.47,74.58 45.47,68.32 42.95,65.81 40.38,65.81 39.89,65.33 37.91,65.33 37.29,64.71 37.29,63.42 33.04,59.17 33.04,58.41 31.37,56.74 31.37,55.83 30.21,54.67 CONN54_PF.1T3
  S14 w0.102: 28.56,52.66 24.78,52.66
  S14 w0.127: 28.56,52.66 29.81,53.9 CONN54_PF.1T3 ; 24.78,52.66 22.74,50.62 22.74,46.1 28.53,40.31 v1(28.53,36.28)
  BOTTOM w0.127: v2(27.68,37.35) 27.68,37.14 v1(28.53,36.28) RB454.1
TXDIS_02: length 304.3
  TOP w0.127: U9.E6 v4(194.55,195.58)
  S5 w0.127: v4(194.55,195.58) 194.38,195.75 194.38,195.98 193.01,197.36 193.01,197.77 192.71,198.07 192.24,198.07 192.03,198.28 192.03,198.71 191.68,199.06 191.35,199.06 190.29,200.12 188.15,200.12 185.49,197.46 179.13,197.46 176.03,194.36 176.03,174.64 168.78,167.39 167.13,167.39 164.17,164.44 162.46,164.44 156.94,158.91 141.23,158.91 137.63,155.32 137.63,148.13 134.42,144.91 127.78,144.91 125.49,142.62 125.49,134.72 126.33,133.88 126.33,93.7 120.52,87.89 85.07,87.89 77.25,80.08 72.66,80.08 71.21,78.62 51.32,78.62 46.75,74.05 46.75,67.76 41.26,62.27 40.58,62.27 38.47,60.16 38.47,55.45 36.77,53.74 36.03,53.74 34.59,52.3 CONN54_PF.1L3
  S9 w0.127: v1(35.62,33.24) 35.08,33.77 35.08,35.18 33.2,37.06 33.2,40.98 33.94,41.72 33.94,41.88 38.45,46.39 38.45,48.04 36.8,49.69 36.8,49.88 34.37,52.3 CONN54_PF.1L3
  BOTTOM w0.127: RB564.1 v1(35.62,33.24) 35.72,33.14 v2(35.72,31.77) ; v4(194.55,195.58) 194.62,195.51 v2(195.66,195.51)
TXDIS_03: length 279.9
  TOP w0.127: v4(193.55,194.58) U9.F5
  S5 w0.127: v4(193.55,194.58) 193.28,194.85 193.03,194.85 192.22,195.65 191.1,195.65 190.64,196.11 189.27,196.11 189,196.38 187.99,196.38 186.66,195.04 181.38,195.04 180.48,195.95 179.78,195.95 177.38,193.56 177.38,192.91 177.37,192.89 177.37,173.63 169.32,165.58 167.64,165.58 164.85,162.79 163.05,162.79 157.7,157.43 142.08,157.43 139.3,154.65 139.3,146.62 134.53,141.86 134.53,138.47 127.6,131.53 127.6,92.63 121.12,86.15 85.91,86.15 78.12,78.37 73.28,78.37 72.18,77.26 61.67,77.26 57.98,73.57 57.98,67.79 55.24,65.05 51.22,65.05 50.92,64.74 50.92,63.9 48.17,61.16 48.17,59.03 45.13,55.98 45.13,55.24 44.46,54.58 CONN54_PF.2T3
  S14 w0.127: v1(42.97,36.29) 42.97,42.34 44.11,43.48 44.11,46.17 41.72,48.56 41.72,51.31 44.32,53.9 CONN54_PF.2T3
  BOTTOM w0.127: RB457.1 v1(42.97,36.29) 42.13,37.12 v2(42.13,37.35)
TXDIS_04: length 273.9
  TOP w0.127: v4(191.55,193.58) U9.G3
  S5 w0.127: v4(191.55,193.58) 191.16,193.19 189.38,193.19 188.34,194.22 179.8,194.22 178.13,192.55 178.13,173.19 169.64,164.69 167.92,164.69 165.26,162.02 163.46,162.02 160.71,159.27 160.71,156.65 157.64,153.58 144.21,153.58 140.17,149.54 140.17,146.25 135.86,141.94 135.86,138.63 128.46,131.24 128.46,92.42 121.36,85.32 86.22,85.32 78.46,77.56 73.71,77.56 72.35,76.2 62.15,76.2 59.05,73.1 59.05,67.63 52.09,60.68 52.09,57.68 48.46,54.06 CONN54_PF.2L3
  S7 w0.127: CONN54_PF.2L3 48.46,50.69 49.34,49.81 50.59,49.81 51.15,49.25 51.15,48.49 48.48,45.82 48.48,42.19 51.12,39.55 51.12,34.28 v1(50.08,33.24)
  BOTTOM w0.127: v2(50.99,33.02) 50.76,33.24 v1(50.08,33.24) RB567.1
TXDIS_05: length 262.1
  TOP w0.127: v4(192.55,193.58) U9.G4
  S5 w0.127: CONN54_PF.3T3 58.71,54.58 59.38,55.24 59.38,55.98 62.42,59.03 62.42,61.16 63.97,62.71 65.83,62.71 70.15,67.03 70.15,72.52 72.1,74.48 73.22,74.48 74.79,76.05 79.59,76.05 87.18,83.64 121.77,83.64 129.81,91.68 129.81,130.6 137.95,138.74 137.95,140.95 143.22,146.22 143.22,147.46 144.45,148.69 148.36,148.69 149.84,150.16 156.4,150.16 157.44,151.2 158.37,151.2 159.73,152.56 159.73,153.5 162.46,156.22 162.46,159.12 164.03,160.69 165.89,160.69 168.18,162.98 169.91,162.98 179.58,172.64 179.58,186.37 181.21,188 185.11,188 188.03,190.92 188.81,190.92 189,190.73 192.7,190.73 193.06,191.08 193.06,193.07 v4(192.55,193.58)
  S9 w0.127: CONN54_PF.3T3 59.2,53.41 60.21,53.41 61.03,52.6 61.03,52.14 60.49,51.61 60.49,50.67 61.38,49.79 61.38,49.02 60.49,48.13 60.49,47.44 62.02,45.92 62.02,44.63 61.37,43.98 61.37,43.09 62.02,42.44 62.02,39.62 63.44,38.2 63.44,34.16 64.33,33.27 v1(64.33,33.24)
  BOTTOM w0.127: v2(65.24,33.02) 65.01,33.24 v1(64.33,33.24) RB433.1
TXDIS_06: length 249.7
  TOP w0.127: v4(192.55,189.58) U9.K4
  S5 w0.127: CONN54_PF.3L3 62.71,54.24 66.34,57.86 66.34,62.08 71.21,66.95 71.21,72.08 72.59,73.45 77.49,73.45 79.24,75.21 80.26,75.21 87.9,82.85 122.21,82.85 130.92,91.57 130.92,130.57 139.85,139.49 140.57,139.49 141.89,140.82 143.16,140.82 144.05,141.7 144.05,142.97 147.49,146.42 147.49,147.45 147.79,147.75 153.46,147.75 153.89,148.18 158.65,148.18 159.29,148.82 159.29,149.71 161.19,151.61 161.19,153.74 164.48,157.03 165.85,157.03 166.65,157.83 166.65,160.31 168.43,162.09 170.67,162.09 181.32,172.73 181.32,177.2 180.94,177.58 180.94,179.3 182.08,180.44 182.08,182.92 182.4,183.23 182.4,184 182.09,184.3 182.09,184.71 182.84,185.46 184.03,185.46 188.15,189.58 188.88,189.58 189.28,189.99 192.14,189.99 v4(192.55,189.58)
  S12 w0.127: CONN54_PF.3L3 62.71,50.81 63.87,49.65 64.53,49.65 65.04,49.15 65.04,48.51 62.32,45.79 62.32,44.07 v1(61.85,43.6) 61.92,43.53 v1(61.92,36.29)
  BOTTOM w0.127: RB543.1 v1(61.92,36.29) ; v1(61.85,43.6) 61.92,43.66 62.7,43.66 v2(63.02,43.34)
TXDIS_07: length 250.8
  TOP w0.127: v4(192.55,188.58) U9.L4
  S5 w0.127: v4(192.55,188.58) 192.08,188.11 189.22,188.11 188.7,187.59 188.7,185.05 187.04,183.39 187.04,182.09 186.59,181.65 186.58,181.65 186.51,181.57 186.01,181.57 184.96,180.52 184.96,177.67 184.3,177.01 183.67,177.01 183.32,176.66 183.32,176.03 183.92,175.42 183.92,174.03 183.16,173.26 183.16,172.12 173.96,162.91 173.96,161.01 171.42,158.47 171.42,157.45 168.88,154.91 167.39,154.91 167.39,154.91 167.18,154.91 166.34,154.06 166.34,152.17 162.78,148.61 162.78,148.5 161.95,147.67 161.95,145.83 160.87,144.75 152.56,144.75 152.21,144.4 150.48,144.4 150.48,141.66 149.22,140.4 144.84,140.4 143.8,139.35 143.61,139.35 143.2,138.94 143.2,138.58 142.84,138.22 141.33,138.22 141.13,138.02 140.4,138.02 132.71,130.32 132.71,90.85 123.03,81.18 88.3,81.18 83.28,76.15 83.28,67.71 83.23,67.71 76.67,61.16 76.67,59.03 73.63,55.98 73.63,55.24 72.96,54.58 72.96,53.9 CONN54_PF.4T3
  S9 w0.127: v1(78.58,33.24) 78.58,33.27 77.51,34.34 77.51,37.84 76.27,39.09 76.27,45.92 74.74,47.44 74.74,48.13 75.63,49.02 75.63,49.79 74.74,50.67 74.74,51.61 75.28,52.14 75.28,52.6 74.46,53.41 73.45,53.41 CONN54_PF.4T3
  BOTTOM w0.127: v2(187.76,189.94) 188.62,189.08 192.05,189.08 v4(192.55,188.58) ; v2(79.49,33.02) 79.26,33.24 v1(78.58,33.24) RB436.1
