# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDRC_A3: length 110
  TOP w0.127: U16.N7 84.59,168.66 85.08,169.76 85.08,171.56 83.32,173.33 78.52,173.33 R187.2 ; v4(54.7,129.65) U40.AM4
  TOP w0.13: v4(83.94,168.82) U16.N7 ; U17.N7 v4(94.49,168.82)
  S12 w0.127: v4(94.49,168.82) 93.82,168.42 86.2,168.42 v4(83.94,168.82)
  S16 w0.127: v4(54.7,129.65) 55.18,129.16 60.5,129.16 69.13,137.79 71.72,137.79 78.07,144.14 78.07,149.25 78.2,149.37 79.29,149.37 79.42,149.5 79.42,150.01 79.29,150.14 78.2,150.14 78.07,150.26 78.07,154.79 78.27,154.99 79.11,154.99 79.24,154.86 79.24,152.6 79.37,152.47 79.87,152.47 80,152.6 80,154.86 80.13,154.99 80.64,154.99 80.76,154.86 80.76,152.55 80.89,152.42 81.4,152.42 81.52,152.55 81.52,154.86 81.65,154.99 82.16,154.99 82.29,154.86 82.29,152.96 82.41,152.83 82.92,152.83 83.05,152.96 83.05,154.86 83.33,155.14 86.27,155.14 88.51,157.38 91.96,157.38 92.12,157.53 92.12,158.15 91.91,158.35 90.69,158.35 90.57,158.48 90.57,159.24 90.74,159.42 91.56,159.42 92.17,160.03 92.17,164.21 93.28,165.33 93.28,167.46 93.44,167.61 93.95,167.61 94.08,167.75 94.08,168.42 v4(94.49,168.82)
DDRC_A4: length 107.6
  TOP w0.127: v4(51.7,128.65) U40.AL7
  TOP w0.13: U17.N3 v4(98.48,168.82) ; U16.N3 v4(87.94,168.82)
  S7 w0.127: v4(98.48,168.82) 98.09,169.21 88.34,169.21 v4(87.94,168.82)
  S14 w0.127: v4(51.7,128.65) 51.96,128.65 52.45,128.16 52.85,128.16 53.18,127.83 53.18,127.4 53.5,127.09 53.88,127.09 54.14,126.83 54.14,126.58 54.59,126.13 55.8,126.13 56.15,125.78 56.15,125.52 56.53,125.14 58.43,125.14 69.23,135.94 74.2,135.94 81.89,143.62 81.89,145.45 81.63,145.72 80.84,145.72 80.46,146.1 80.46,147.7 81.65,148.89 81.65,153.39 81.07,153.97 79.09,153.97 78.88,154.18 78.88,154.79 79.04,154.94 81.32,154.94 81.7,155.32 81.7,157.45 82.03,157.78 85.42,157.78 85.55,157.91 85.55,158.65 85.68,158.77 86.18,158.77 86.31,158.65 86.31,157.91 86.44,157.78 94.78,157.78 95.93,158.93 95.93,160.68 98.09,162.84 U17.N3 v4(98.48,168.82)
  BOTTOM w0.127: RB70.2 86.35,174.12 86.35,172.41 86.73,172.04 86.73,169.79 87.7,168.82 v4(87.94,168.82)
DDRC_A5: length 103.4
  TOP w0.127: v4(55.7,130.65) U40.AN3
  TOP w0.13: v4(93.69,169.62) U17.P8 ; U16.P8 v4(83.14,169.62)
  S5 w0.127: v4(93.69,169.62) 93.29,170.02 83.55,170.02 83.15,169.62 v4(83.14,169.62)
  S16 w0.127: v4(55.7,130.65) 56.12,131.07 58.05,131.07 58.23,130.88 59.81,130.88 60.29,131.37 60.29,133.73 60.97,134.41 60.97,134.59 60.34,135.22 60.34,135.4 60.7,135.76 60.88,135.76 61.51,135.13 61.69,135.13 62.05,135.49 62.05,135.69 60.81,136.93 60.81,137.11 61.16,137.47 61.34,137.47 62.61,136.21 62.77,136.21 63.13,136.56 63.13,136.74 62.04,137.83 62.04,138.01 62.4,138.37 62.58,138.37 63.67,137.28 63.85,137.28 64.2,137.64 64.2,137.87 63.22,138.86 63.22,139.04 63.57,139.4 63.75,139.4 64.79,138.36 64.92,138.36 65.28,138.72 65.28,138.93 64.29,139.91 64.29,140.09 64.65,140.45 64.83,140.45 65.85,139.44 66,139.44 66.36,139.8 71.82,139.8 76.85,144.83 76.85,146.22 76.72,146.35 75.96,146.35 75.84,146.48 75.84,146.98 75.96,147.11 76.72,147.11 76.85,147.24 76.85,147.75 76.72,147.87 75.96,147.87 75.84,148 75.84,148.51 75.96,148.63 76.72,148.63 76.85,148.76 76.85,155.78 77.44,156.36 85.31,156.36 86.33,157.38 86.33,163.01 87.82,164.51 89.93,164.51 91.53,166.11 91.53,167.61 92.33,168.41 93.04,168.41 93.28,168.65 93.28,168.98 93.69,169.38 v4(93.69,169.62)
  BOTTOM w0.127: v4(83.14,169.62) 83.07,169.62 82.67,169.21 79.59,169.21 RB92.2
DDRC_A6: length 107.4
  TOP w0.127: U40.AH9 v4(49.7,125.65)
  TOP w0.13: v4(88.74,169.62) U16.P2 ; v4(99.29,169.62) U17.P2
  S9 w0.127: v4(88.74,169.62) 89.15,169.21 98.88,169.21 v4(99.29,169.62)
  S14 w0.127: v4(49.7,125.65) 50.21,125.14 50.8,125.14 51.22,124.71 51.22,124.51 51.58,124.15 51.83,124.15 52.21,123.77 52.21,123.52 52.59,123.14 52.82,123.14 53.2,122.76 53.2,122.45 53.53,122.12 53.81,122.12 54.22,121.71 54.22,121.54 54.55,121.21 55.77,121.21 56.18,120.8 56.18,120.57 56.51,120.24 58.41,120.24 71.03,132.86 74.72,132.86 84.98,143.12 84.98,143.2 85,143.23 85,149.1 89.91,154 97.88,154 101.95,158.06 101.95,167.71 100.45,169.21 99.69,169.21 v4(99.29,169.62)
  BOTTOM w0.127: v4(88.74,169.62) 88.74,169.85 89.14,170.25 89.14,170.58 89.38,170.82 89.71,170.82 89.96,171.07 89.96,171.54 92.68,174.26 RB77.2
DDRC_A7: length 104.4
  TOP w0.127: v4(55.7,133.65) U40.AT3
  TOP w0.13: v4(93.69,170.42) U17.R8 ; U16.R8 v4(83.14,170.42)
  S5 w0.127: v4(83.14,170.42) 83.16,170.42 83.55,170.81 93.29,170.81 v4(93.69,170.42)
  S16 w0.127: v4(93.69,170.42) 93.45,170.42 93.04,170.01 90.71,170.01 90.26,169.57 90.26,167.08 90.01,166.82 89.71,166.82 88.91,166.82 88.11,166.82 87.49,166.82 87.27,166.6 87.27,165.89 85,163.63 85,158.37 84.29,157.66 75.84,157.66 75.56,157.38 75.56,152.86 73.5,150.8 73.5,143.24 71.91,141.65 62.9,141.65 62.64,141.92 62.64,143.97 62.41,144.2 62,144.2 61.82,144.02 61.82,139.47 61.7,139.34 61.26,139.34 61.13,139.47 61.13,143.31 60.89,143.55 60.53,143.55 60.29,143.3 60.29,139.37 60.09,139.16 59.63,139.16 59.43,139.37 59.43,141.25 59.12,141.55 58.54,141.55 57.6,140.61 57.6,135.05 57.24,134.69 57.24,133.45 56.96,133.16 56.32,133.16 55.84,133.65 v4(55.7,133.65)
  BOTTOM w0.127: RB86.2 82.26,172.69 82.74,172.22 82.74,170.82 v4(83.14,170.42)
DDRC_A8: length 105.2
  TOP w0.127: v4(49.7,124.65) U40.AG9
  TOP w0.13: v4(88.74,170.42) U16.R2 ; v4(99.29,170.42) U17.R2
  S9 w0.127: v4(88.74,170.42) 89.38,170.01 98.88,170.01 v4(99.29,170.42)
  S16 w0.127: v4(99.29,170.42) 99.69,170.01 99.69,169.45 99.93,169.21 100.25,169.21 100.48,168.98 100.48,167.3 101.18,166.59 101.18,158.06 99.15,156.03 98.97,156.03 98.01,156.99 97.83,156.99 97.47,156.63 97.47,156.45 98.43,155.49 98.43,155.31 96.89,153.77 89.81,153.77 83.71,147.67 83.71,143.53 73.45,133.27 72.21,133.27 61.08,122.14 52.58,122.14 52.26,122.46 52.26,122.84 52.01,123.09 50.5,123.09 50.17,123.42 50.17,124.18 v4(49.7,124.65)
  BOTTOM w0.127: RB76.2 91.66,173.96 89.14,171.45 89.14,171.04 88.74,170.64 v4(88.74,170.42)
DDRC_A9: length 106.3
  TOP w0.127: R209.2 80.74,171.42 81.5,172.18 82.52,172.18 83.05,171.65 83.48,171.65 83.94,171.19 v4(83.94,170.42) ; v4(53.7,132.65) U40.AR5
  TOP w0.13: v4(83.94,170.42) U16.R7 ; v4(94.49,170.42) U17.R7
  S12 w0.127: v4(94.49,170.42) 94.28,170.62 93.82,170.82 86.71,170.82 v4(83.94,170.42)
  S14 w0.127: v4(94.49,170.42) 95.72,169.18 95.72,166.01 95.04,165.33 95.04,164.72 94.73,164.41 94.65,164.41 94.65,164.41 94.32,164.41 93.49,164.41 93.28,164.21 93.28,163.78 93.13,163.62 92.57,163.62 90.97,162.02 85.39,162.02 84.6,162.81 84.11,162.81 83.31,162.81 82.98,162.81 82.98,162.81 82.92,162.81 82.74,162.99 82.74,166.75 82.54,166.95 79.98,166.95 79.7,166.67 79.7,164.72 79.26,164.28 79.26,161.11 78.5,160.35 78.5,158.7 75.86,156.06 75.86,152.42 78.13,150.14 78.13,144.07 72.67,138.61 65.78,138.61 65.52,138.35 65.52,136.73 61.28,132.48 61.28,132.13 58.31,129.15 56.56,129.15 56.2,129.52 56.2,129.8 55.88,130.12 55.55,130.12 55.21,130.46 55.21,130.79 54.85,131.15 54.48,131.15 54.26,131.38 54.26,132.09 v4(53.7,132.65)
DDRC_A10: length 107.9
  TOP w0.127: U16.M3 87.32,167.84 86.88,168.84 86.88,172.63 86.58,173.5 85.79,174.29 v1(85.08,174.29) ; v4(53.7,133.65) U40.AT5
  TOP w0.13: v4(98.48,168.02) U17.M3 ; v4(87.94,168.02) U16.M3
  S7 w0.127: v4(98.48,168.02) 98.09,168.42 91.02,168.42 91.02,168.41 88.34,168.41 v4(87.94,168.02)
  S14 w0.127: v4(53.7,133.65) 53.7,133.31 53.19,132.8 53.19,131.45 52.84,131.1 52.44,131.1 52.22,130.88 52.22,130.38 52,130.16 51.64,130.16 51.2,129.72 51.2,128.38 51.46,128.13 51.81,128.13 52.23,127.71 52.23,127.43 52.52,127.14 52.82,127.14 53.26,126.7 53.26,126.46 53.55,126.16 53.9,126.16 54.26,125.81 54.26,125.46 54.51,125.2 55.76,125.2 56.15,124.81 56.15,124.45 56.45,124.14 58.3,124.14 69.56,135.4 74.39,135.4 82.62,143.63 82.62,155.27 84.42,157.07 95.14,157.07 97.2,159.13 97.2,161.11 98.88,162.79 98.88,166.58 98.88,167.62 v4(98.48,168.02)
  BOTTOM w0.127: v1(85.08,174.29) 84.42,174.95 RB69.2
DDRC_A11: length 102.6
  TOP w0.127: v4(49.7,122.65) U40.AE9
  TOP w0.13: v4(99.29,171.22) U17.T2 ; U16.T2 v4(88.74,171.22)
  S12 w0.127: v4(88.74,171.22) 91.05,171.68 98.03,171.68 98.56,171.61 98.89,171.47 v4(99.29,171.22)
  S16 w0.127: v4(99.29,171.22) 99.69,170.81 100.25,170.81 100.48,170.58 100.48,169.7 100.99,169.19 100.99,167.51 101.69,166.81 101.69,157.85 97.07,153.24 91.2,153.24 84.42,146.45 84.42,141.77 83.9,141.25 82.52,141.25 73.63,132.36 72.3,132.36 61.08,121.14 51.47,121.14 51.18,121.42 51.18,121.98 51.01,122.15 50.19,122.15 v4(49.7,122.65)
  BOTTOM w0.127: v4(88.74,171.22) 88.74,171.39 89.32,172.34 90.52,173.54 RB75.2
DDRC_A12: length 110.6
  TOP w0.127: U40.AP4 v4(54.7,131.65) ; R179.2 83.43,173.94 85.41,171.95 85.41,169.26 84.82,168.1 U16.M7
  TOP w0.13: v4(83.94,168.02) U16.M7 ; v4(94.49,168.02) U17.M7
  S12 w0.127: v4(83.94,168.02) 86.45,167.61 93.84,167.61 v4(94.49,168.02)
  S14 w0.127: v4(54.7,131.65) 54.92,131.65 55.38,131.19 55.85,131.19 56.18,130.86 56.18,130.47 56.53,130.13 58.36,130.13 60.62,132.38 60.62,132.89 64.68,136.95 64.68,138.37 65.68,139.37 72.39,139.37 77.63,144.6 77.63,149.93 75.12,152.43 75.12,156.99 77.16,159.03 77.16,159.92 78.73,161.49 78.73,164.03 78.2,164.56 78.2,168.64 78.51,168.95 78.88,168.95 arc(78.99,168.9) 79.03,168.8 79.03,167.95 arc(79.35,167.63) 79.67,167.95 79.67,168.8 arc(79.71,168.9) 79.82,168.95 80.15,168.95 arc(80.26,168.9) 80.3,168.8 80.3,168.57 arc(80.62,168.25) 80.94,168.57 80.94,168.8 arc(80.98,168.9) 81.09,168.95 81.36,168.95 81.63,168.67 81.63,167.83 81.84,167.62 84.15,167.62 84.39,167.38 84.39,165.2 86.77,162.82 90.91,162.82 92.9,164.82 93.44,164.82 94.08,165.45 94.08,165.77 94.32,166.01 94.64,166.01 94.88,166.25 94.88,167.62 v4(94.49,168.02)
DDRC_A13: length 104.5
  TOP w0.127: R221.2 78.93,169.87 80.2,169.87 82.01,171.68 82.46,171.68 82.92,171.22 v4(83.14,171.22) ; v4(55.7,134.65) U40.AU3
  TOP w0.13: v4(93.69,171.22) U17.T8 ; U16.T8 v4(83.14,171.22)
  S5 w0.127: v4(93.69,171.22) 92.86,172.05 84.64,172.05 83.81,171.22 v4(83.14,171.22)
  S16 w0.127: v4(55.7,134.65) 55.7,135.26 56.28,135.84 56.28,141.85 66.99,152.56 73.05,152.56 74.18,153.69 74.18,159.08 74.62,159.51 74.62,160.73 74.77,160.88 75.1,160.88 75.23,160.75 75.23,159.76 75.38,159.61 75.73,159.61 75.89,159.76 75.89,160.83 75.96,160.91 76.42,160.91 76.55,160.78 76.55,159.84 76.67,159.71 77.05,159.71 77.18,159.84 77.18,160.7 77.32,160.85 77.65,160.85 77.77,160.73 77.77,159.87 77.89,159.74 78.78,159.74 78.96,159.92 78.96,160.7 78.83,160.83 78.45,160.83 78.32,160.96 78.32,161.29 78.45,161.41 78.86,161.41 78.96,161.52 78.96,161.86 78.83,161.99 78.2,161.99 78.07,162.11 78.07,162.62 78.2,162.75 78.72,162.75 78.88,162.91 78.88,163.54 78.97,163.62 79.52,163.62 79.65,163.5 79.65,160.75 79.82,160.58 80.23,160.58 80.41,160.75 80.41,163.6 80.48,163.68 80.99,163.68 81.12,163.55 81.12,160.78 81.25,160.65 81.65,160.65 81.83,160.83 81.83,164.34 82.71,165.21 84.38,165.21 85.03,165.86 85.03,169.15 87.64,171.76 93.14,171.76 v4(93.69,171.22)
DDRC_ACT_N: length 107.4
  TOP w0.127: U16.L3 86.83,167.82 86.26,169.48 86.01,171.57 85.67,172.43 84.83,173.51 v1(84.17,174.17) ; v4(56.7,133.65) U40.AT2
  TOP w0.13: v4(87.94,167.22) U16.L3 ; v4(98.49,167.22) U17.L3
  S7 w0.127: v4(87.94,167.22) 88.35,167.62 92.4,167.62 92.41,167.61 98.09,167.61 v4(98.49,167.22)
  S16 w0.127: v4(56.7,133.65) 56.47,133.65 56.25,133.87 56.25,134.87 56.91,135.53 56.91,140.94 60.77,144.8 63.07,144.8 63.63,144.24 63.63,143.28 64.75,142.16 71.26,142.16 72.77,143.67 72.77,151.34 74.87,153.44 74.87,157.83 75.41,158.37 80.3,158.37 81.54,159.61 84.17,159.61 84.39,159.84 84.39,164.28 85.72,165.61 85.72,168.72 85.86,168.86 86.22,168.86 86.4,168.68 86.4,167.56 86.55,167.41 87.09,167.41 87.16,167.49 87.16,169.47 87.72,170.02 89.8,170.02 90.59,170.81 94.62,170.81 94.65,170.81 94.9,170.56 97.71,170.56 97.86,170.41 97.86,170.1 97.73,169.97 96.26,169.97 96.1,169.82 96.1,169.53 96.32,169.31 97.68,169.31 97.86,169.14 97.86,167.85 v4(98.49,167.22)
  BOTTOM w0.127: v1(84.17,174.17) 83.4,174.93 RB68.2
DDRC_ALERT0: length 91.1
  TOP w0.127: v4(57.7,132.65) U40.AR1
  TOP w0.13: v4(92.89,169.62) U17.P9
  S14 w0.127: v4(57.7,132.65) 57.84,132.65 58.54,133.35 58.54,134.11 62.55,138.12 62.55,139.45 64.55,141.44 71.6,141.44 73.36,143.2 73.36,151.49 72.74,152.11 72.74,157.63 74.79,159.69 74.79,167.56 74.29,168.07 72.91,168.07 72.76,168.22 72.76,168.81 72.89,168.94 73.45,168.94 73.57,169.07 73.57,169.57 73.45,169.7 72.89,169.7 72.76,169.83 72.76,170.34 72.96,170.54 73.32,170.54 73.45,170.67 73.45,171.17 73.32,171.3 72.98,171.3 72.74,171.55 72.74,171.93 73.01,172.21 73.55,172.21 74.3,171.46 75.77,171.46 76.19,171.88 77.11,171.88 77.41,172.18 77.41,173 77.79,173.38 80.56,173.38 81.97,171.97 85.82,171.97 86.96,170.83 86.96,166.95 87.24,166.67 87.24,165.45 87.57,165.12 89.96,165.12 90.26,165.43 90.26,166.11 92.29,168.14 92.29,169.03 v4(92.89,169.62)
  BOTTOM w0.127: v4(92.89,169.62) 93.28,170.01 93.93,170.01 94.09,170.17 94.09,170.58 94.2,170.69 94.2,172.06 TPB47.1
DDRC_ALERT1: length 103.1
  TOP w0.127: U40.AH6 v4(52.7,125.65)
  TOP w0.13: v4(82.34,169.62) U16.P9
  S16 w0.127: v4(52.7,125.65) 52.18,126.16 52.18,128.39 53.22,129.43 53.22,135.13 53.33,135.24 53.33,141 66.68,154.34 71.56,154.34 72.15,154.94 72.15,157.02 71.87,157.3 70.83,157.3 69.84,158.29 69.84,169.59 70.02,169.77 70.64,169.77 70.76,169.64 70.76,167.73 70.91,167.59 71.4,167.59 71.52,167.71 71.52,169.59 71.68,169.75 72.18,169.75 72.29,169.64 72.29,167.73 72.43,167.59 72.87,167.59 73.05,167.76 73.05,169.59 73.2,169.75 73.68,169.75 73.88,169.54 73.88,167.79 74.08,167.59 74.46,167.59 74.67,167.79 74.67,168.65 74.87,168.86 75.86,168.86 76.09,168.63 76.09,166.93 76.37,166.65 77.26,166.65 77.49,166.88 77.49,168.27 77.65,168.44 78.01,168.44 78.14,168.31 78.14,167.76 78.21,167.69 78.72,167.69 78.9,167.87 78.9,168.31 79.03,168.44 79.53,168.44 79.66,168.31 79.66,167.76 79.74,167.69 80.25,167.69 80.42,167.87 80.42,168.31 80.55,168.44 80.99,168.44 81.14,168.29 81.14,167.87 81.27,167.74 81.6,167.74 81.78,167.92 81.78,168.72 81.42,169.08 77.74,169.08 77.59,169.23 77.59,169.59 77.71,169.72 82.24,169.72 v4(82.34,169.62)
  BOTTOM w0.127: TPB48.1 78.98,170.89 78.98,170.72 79.85,169.85 82.12,169.85 v4(82.34,169.62)
DDRC_BA0: length 106.2
  TOP w0.127: v4(50.7,126.65) U40.AJ8
  TOP w0.13: U17.N2 v4(99.29,168.82) ; U16.N2 v4(88.74,168.82)
  S9 w0.127: v4(88.74,168.82) 89.15,168.42 92.65,168.42 92.65,168.42 U17.N2 v4(99.29,168.82)
  S14 w0.127: v4(50.7,126.65) 51.18,126.16 51.18,125.46 51.45,125.19 51.81,125.19 52.19,124.81 52.19,124.37 52.47,124.09 52.94,124.09 53.13,123.9 53.13,123.56 53.58,123.11 53.87,123.11 54.14,122.83 54.14,122.55 54.55,122.15 55.79,122.15 56.18,121.77 56.18,121.49 56.5,121.17 58.28,121.17 70.49,133.37 74.51,133.37 84.47,143.33 84.47,149.37 86.78,151.69 86.78,154.43 87.27,154.91 98.01,154.91 101.34,158.24 101.34,167.56 100.49,168.41 99.69,168.41 v4(99.29,168.82)
  BOTTOM w0.127: v4(88.74,168.82) 88.74,168.88 88.34,169.28 88.34,169.79 88.13,170 88.12,170 88.11,170.01 87.75,170.01 87.48,170.28 87.48,175.02 RB72.2
DDRC_BA1: length 104.8
  TOP w0.127: v4(54.7,132.65) U40.AR4
  TOP w0.13: U16.N8 v4(83.14,168.82) ; U17.N8 v4(93.69,168.82)
  S5 w0.127: v4(93.69,168.82) 93.28,169.22 83.55,169.22 v4(83.14,168.82)
  S16 w0.127: v4(54.7,132.65) 54.7,132.34 55.16,131.87 55.16,130.49 55.53,130.12 60.19,130.12 62.3,132.23 62.3,132.41 61.52,133.18 61.52,133.36 61.88,133.72 62.06,133.72 62.84,132.95 63.02,132.95 63.37,133.31 63.37,133.49 62.6,134.26 62.6,134.44 62.96,134.8 63.14,134.8 63.91,134.03 64.09,134.03 64.45,134.39 64.45,134.57 63.68,135.34 63.68,135.52 64.04,135.88 64.22,135.88 64.99,135.1 65.17,135.1 65.53,135.46 65.53,135.64 64.76,136.42 64.76,136.6 65.12,136.95 65.3,136.95 66.07,136.18 66.25,136.18 66.61,136.54 66.61,136.72 65.84,137.49 65.84,137.67 66.19,138.03 66.37,138.03 67.15,137.26 67.33,137.26 67.69,137.62 67.69,137.8 66.91,138.57 66.91,138.75 67.27,139.11 67.45,139.11 68.23,138.34 68.4,138.34 68.93,138.86 71.82,138.86 77.49,144.52 77.49,155.24 78.07,155.83 85.94,155.83 86.99,156.87 86.99,162.25 87.54,162.81 87.78,162.81 88.58,162.81 89.38,162.81 90.29,162.81 90.49,162.61 90.49,161.16 90.69,160.96 91.23,160.96 91.46,161.19 91.46,164.79 92.04,165.38 92.04,167.23 92.42,167.61 93.06,167.61 93.28,167.84 93.28,168.19 93.69,168.6 v4(93.69,168.82)
  BOTTOM w0.127: RB96.2 79.38,168.41 82.68,168.41 83.09,168.82 v4(83.14,168.82)
DDRC_BG0: length 104.4
  TOP w0.127: U40.AH7 v4(51.7,125.65)
  TOP w0.13: v4(99.29,168.02) U17.M2 ; v4(88.74,168.02) U16.M2
  S9 w0.127: v4(88.74,168.02) 89.15,167.62 98.88,167.62 v4(99.29,168.02)
  S14 w0.127: v4(51.7,125.65) 52.02,125.65 52.52,125.14 52.8,125.14 53.13,124.81 53.13,124.53 53.48,124.17 53.82,124.17 54.19,123.8 54.19,123.47 54.5,123.16 55.82,123.16 56.2,122.78 56.2,122.52 56.61,122.11 58.39,122.11 70.32,134.05 74.47,134.05 83.81,143.39 83.81,150.92 83.99,151.1 85.44,151.1 86.02,151.69 86.02,154.63 85.89,154.76 84.55,154.76 84.42,154.89 84.42,155.32 84.67,155.57 97.12,155.57 99.18,157.63 99.99,157.63 100.75,158.39 100.75,167.31 100.45,167.61 99.69,167.61 v4(99.29,168.02)
  BOTTOM w0.127: RB85.2 86.45,170.86 86.45,169.62 87.65,168.42 88.34,168.42 v4(88.74,168.02)
DDRC_CAS_N: length 103.4
  TOP w0.127: v4(55.7,131.65) U40.AP3
  TOP w0.13: U16.M8 v4(83.14,168.02) ; v4(93.69,168.02) U17.M8
  S5 w0.127: v4(83.14,168.02) 83.54,168.42 93.29,168.42 v4(93.69,168.02)
  S14 w0.127: v4(55.7,131.65) 55.71,131.65 56.19,132.12 58.15,132.12 59.15,133.12 59.15,133.63 63.24,137.72 63.24,139.07 64.83,140.66 71.6,140.66 74,143.05 74,143.72 arc(74.09,143.95) 74.31,144.04 74.59,144.04 arc(74.91,144.36) 74.59,144.68 74.31,144.68 arc(74,144.99) 74.31,145.31 74.59,145.31 arc(74.91,145.63) 74.59,145.95 74.31,145.95 arc(74.09,146.04) 74,146.26 74,151.63 73.52,152.1 73.52,157.48 75.61,159.56 75.61,164.39 76.06,164.84 76.06,170.71 76.42,171.07 78.04,171.07 78.17,171.19 78.17,172.51 78.3,172.64 79.8,172.64 79.92,172.51 79.92,172.08 79.85,172.01 79.06,172.01 78.93,171.88 78.93,171.19 79.04,171.09 81.65,171.09 81.93,170.81 85.46,170.81 85.84,170.43 85.84,165.71 87.09,164.46 90.31,164.46 90.9,165.05 90.9,165.79 92.72,167.61 93.28,167.61 v4(93.69,168.02)
  BOTTOM w0.127: RB100.2 79.19,167.59 82.71,167.59 v4(83.14,168.02)
DDRC_CK_N: length 97.2
  TOP w0.095: U40.AK6 v4(52.7,127.65) ; U17.K8 v4(94.49,166.42) ; U16.K8 v4(83.94,166.42)
  S7 w0.108: v4(94.49,166.42) 94.24,166.17 94.07,165.71 94.07,165.39 93.6,164.92 92.26,164.92 91.82,164.48 91.82,163.13 91.71,163.02 90.94,163.02 90.83,163.13 90.83,164.51 90.42,164.92 87.56,164.92 87.33,165.15 87.33,172.13 86.94,172.52 85.64,172.52 85.27,172.15 85.27,166.34 85.17,166.24 84.12,166.24 v4(83.94,166.42)
  S16 w0.108: v4(94.49,166.42) 94.61,166.29 94.86,166.29 95.49,165.66 95.49,158.29 93.41,156.21 88.91,156.21 79.64,146.94 79.64,143.51 72.35,136.22 69.45,136.22 62.51,129.28 60.67,127.44 arc(60.22,127.14) 59.69,127.03 53.23,127.03 52.96,127.3 52.96,127.51 52.83,127.65 v4(52.7,127.65)
  BOTTOM w0.095: v4(83.94,166.42) 83.98,166.45 RB110.2
DDRC_CK_P: length 97.3
  TOP w0.095: U17.K7 v4(94.49,165.62) ; U16.K7 v4(83.94,165.62) ; U40.AK5 v4(53.7,127.65)
  S7 w0.108: v4(94.49,165.62) 94.41,165.62 94.3,165.51 94.3,165.3 93.69,164.69 92.35,164.69 92.05,164.39 92.05,163.03 91.81,162.79 90.84,162.79 90.6,163.03 90.6,164.41 90.32,164.69 87.46,164.69 87.1,165.06 87.1,172.03 86.84,172.29 85.73,172.29 85.5,172.05 85.5,166.24 85.27,166.01 83.92,166.01 83.81,165.9 83.81,165.75 v4(83.94,165.62)
  S16 w0.108: v4(94.49,165.62) 94.49,165.92 94.63,166.06 94.77,166.06 95.27,165.56 95.27,158.38 93.32,156.44 88.81,156.44 79.41,147.04 79.41,143.6 72.26,136.45 69.36,136.45 62.35,129.44 60.51,127.6 arc(60.13,127.35) 59.69,127.26 53.33,127.26 53.19,127.39 53.19,127.84 53.31,127.96 53.57,127.96 53.7,127.84 v4(53.7,127.65)
  BOTTOM w0.095: v4(83.94,165.62) 84.12,165.44 RB116.2
DDRC_CKE: length 113.4
  TOP w0.127: v4(52.7,124.65) U40.AG6
  TOP w0.13: v4(88.74,166.42) U16.K2 ; v4(99.29,166.42) U17.K2
  S5 w0.127: v4(99.29,166.42) 98.88,166.01 97.38,166.01 97.21,165.83 97.21,163.83 97,163.63 95.94,163.63 95.71,163.86 95.71,165.81 95.51,166.01 92.38,166.01 92.05,165.68 92.05,162.1 91.77,161.82 90.53,161.82 90.27,162.08 90.27,165.81 90.07,166.01 89.15,166.01 v4(88.74,166.42)
  S16 w0.127: v4(52.7,124.65) 53.22,124.13 58.87,124.13 59.26,124.52 59.44,124.52 59.97,123.99 60.15,123.99 60.51,124.35 60.51,124.53 59.98,125.06 59.98,125.24 60.34,125.6 60.52,125.6 61.05,125.06 61.23,125.06 61.59,125.42 61.59,125.6 61.05,126.13 61.05,126.31 61.41,126.67 61.59,126.67 62.13,126.14 62.31,126.14 62.66,126.5 62.66,126.68 62.13,127.21 62.13,127.39 62.49,127.75 62.67,127.75 63.2,127.22 63.38,127.22 63.74,127.58 63.74,127.76 63.21,128.29 63.21,128.47 63.57,128.83 63.75,128.83 64.28,128.3 64.46,128.3 64.82,128.66 64.82,128.84 64.29,129.37 64.29,129.55 64.65,129.91 64.83,129.91 65.36,129.38 65.54,129.38 65.9,129.74 65.9,129.92 65.37,130.45 65.37,130.63 65.73,130.99 65.91,130.99 66.44,130.45 66.62,130.45 66.98,130.81 66.98,130.99 66.44,131.52 66.44,131.7 66.8,132.06 66.98,132.06 67.52,131.53 67.7,131.53 68.05,131.89 68.05,132.07 67.52,132.6 67.52,132.78 67.88,133.14 68.06,133.14 68.59,132.61 68.77,132.61 69.13,132.97 69.13,133.15 68.6,133.68 68.6,133.86 69.94,135.2 73.32,135.2 82.08,143.97 82.08,148.06 89.35,155.33 93.78,155.33 97.4,158.95 97.4,161.82 97.07,162.15 97.07,164.59 97.27,164.79 98.47,164.79 98.88,165.21 98.88,165.81 99.29,166.22 v4(99.29,166.42)
  BOTTOM w0.127: v4(88.74,166.42) 88.05,166.82 87.92,166.82 87.74,166.86 86.99,167.61 RB99.2
DDRC_CS_N0: length 94.8
  TOP w0.127: v4(56.71,130.66) U40.AN2
  TOP w0.13: v4(94.49,167.22) U17.L7
  S14 w0.127: v4(94.49,167.22) 93.28,166.01 92.72,166.01 91.81,165.1 91.81,164.72 90.72,163.62 86.96,163.62 85.11,165.48 85.11,169.47 84.55,170.02 81.96,170.02 81.65,169.72 79.29,169.72 arc(79.06,169.81) 78.97,170.04 78.97,170.37 arc(78.65,170.68) 78.34,170.37 78.34,170.04 arc(78.24,169.81) 78.02,169.72 77.77,169.72 77.46,169.42 77.46,166.75 arc(77.37,166.53) 77.14,166.43 77.05,166.43 arc(76.73,166.12) 77.05,165.8 77.14,165.8 arc(77.37,165.71) 77.46,165.48 77.46,165.1 76.37,164.01 76.37,162.39 arc(76.45,162.2) 76.64,162.12 arc(76.83,162.04) 76.91,161.85 76.91,161.75 arc(76.83,161.56) 76.64,161.48 arc(76.45,161.4) 76.37,161.21 76.37,159.31 74.21,157.15 74.21,152.45 76.83,149.83 76.83,148.62 76.7,148.5 75.71,148.5 75.58,148.37 75.58,147.86 75.71,147.73 76.7,147.73 76.83,147.61 76.83,147.1 76.7,146.97 75.71,146.97 75.58,146.85 75.58,146.34 75.71,146.21 76.7,146.21 76.83,146.08 76.83,144.81 72.03,140 65.35,140 64.05,138.7 64.05,137.34 59.96,133.25 59.96,132.74 58.35,131.13 57.18,131.13 v4(56.71,130.66)
  BOTTOM w0.127: v4(94.49,167.22) 95.15,167.88 95.15,173.34 95.01,173.48 95.01,174.6 RB79.2
DDRC_CS_N1: length 103.3
  TOP w0.127: v4(53.7,129.65) U40.AM5
  TOP w0.13: v4(83.94,167.22) U16.L7
  S16 w0.127: v4(83.94,167.22) 83.54,166.81 82.58,166.81 82.16,167.23 81.18,167.23 80.89,166.94 80.89,165.15 80.77,165.03 80.37,165.03 80.28,165.12 80.28,166.82 80.05,167.05 78.38,167.05 78.2,166.88 78.2,166.6 78.38,166.42 79.39,166.42 79.62,166.19 79.62,165.15 79.44,164.97 78.12,164.97 77.94,165.15 77.94,165.81 77.77,165.99 77.46,165.99 77.26,165.79 77.26,165.12 77.06,164.92 76.83,164.92 76.63,165.12 76.63,165.83 76.47,165.99 76.11,165.99 75.97,165.85 75.97,165.19 75.76,164.97 74.26,164.97 74.08,165.15 74.08,165.5 74.21,165.63 74.64,165.63 74.74,165.73 74.74,166.8 74.59,166.95 70.76,166.95 70.6,166.8 70.6,166.37 70.78,166.19 71.92,166.19 72.05,166.06 72.05,165.55 71.92,165.43 70.78,165.43 70.6,165.25 70.6,164.84 70.76,164.69 72.76,164.69 72.89,164.56 72.89,164.06 72.76,163.93 70.78,163.93 70.63,163.78 70.63,163.34 70.83,163.14 71.77,163.14 71.89,163.03 71.89,162.62 71.72,162.46 70.76,162.46 70.6,162.3 70.6,161.41 70.86,161.16 72.03,161.16 72.23,161.36 72.23,161.95 72.43,162.15 72.66,162.15 72.89,161.92 72.89,158.82 72.69,158.62 72.36,158.62 72.2,158.77 72.2,159.94 72,160.14 70.76,160.14 70.6,159.99 70.6,158.44 71.09,157.96 72.28,157.96 72.89,157.35 72.89,154.58 72.01,153.71 66.71,153.71 54.83,141.82 54.83,138.3 53.99,137.46 53.99,135.1 54.17,134.92 54.17,129.84 53.97,129.65 v4(53.7,129.65)
  BOTTOM w0.127: RB107.2 78.8,166.95 82.46,166.95 82.59,166.82 83.56,166.82 83.94,167.21 v4(83.94,167.22)
DDRC_DBI_N0: length 70.2
  TOP w0.127: v4(54.7,120.65) U40.AC4
  TOP w0.13: v4(94.49,161.62) U17.E7
  S9 w0.127: v4(94.49,161.62) 95.22,160.89 95.22,158.59 94.66,158.03 94.66,157.75 95.16,157.24 95.16,156.96 94.92,156.72 94.61,156.72 94.07,157.26 93.8,157.26 93.53,156.98 93.53,156.72 94.07,156.18 94.07,155.87 93.85,155.65 93.52,155.65 92.99,156.18 92.73,156.18 92.45,155.91 92.45,155.64 93.01,155.09 93.01,154.8 92.76,154.56 92.46,154.56 91.91,155.11 91.65,155.11 89.43,152.89 89.43,152.89 87.13,150.59 85.48,150.59 83.5,148.61 83.5,142.28 79.49,138.27 76.55,138.27 64.37,126.08 62.91,126.08 58.96,122.14 57.63,122.14 57.29,121.8 57.29,121.68 56.86,121.25 55.3,121.25 v4(54.7,120.65)
DDRC_DBI_N1: length 70.2
  TOP w0.127: U40.AH3 v4(55.7,125.65)
  TOP w0.13: v4(99.29,161.62) U17.E2
  S5 w0.127: v4(99.29,161.62) 98.89,161.22 98.33,161.22 96.73,159.62 96.73,158.18 90.54,151.99 81.37,151.99 79.66,150.28 79.44,150.28 74.77,145.6 74.77,144.45 76.37,142.85 76.37,142.51 76.07,142.2 75.77,142.2 74.85,143.12 74.42,143.12 74.2,142.9 74.2,142.51 75.21,141.5 75.21,141.18 74.94,140.92 74.69,140.92 73.76,141.85 73.43,141.85 64.9,133.32 64.9,131.37 58.69,125.15 56.19,125.15 v4(55.7,125.65)
DDRC_DBI_N2: length 76.8
  TOP w0.127: v4(51.7,122.65) U40.AE7
  TOP w0.13: v4(83.94,161.62) U16.E7
  S9 w0.127: v4(51.7,122.65) 52.08,122.65 52.3,122.87 52.3,123.91 52.03,124.18 51.31,124.18 51.18,124.31 51.18,124.98 51.01,125.15 50.25,125.15 50.09,125.31 50.09,127.85 50.33,128.09 50.92,128.09 51.19,128.36 51.19,131.76 51.63,132.2 51.88,132.2 52.14,132.46 52.14,132.92 52.31,133.09 52.87,133.09 53.14,133.36 53.14,133.92 53.31,134.09 53.94,134.09 54.14,134.28 54.14,134.71 54.91,135.48 56.91,135.48 57.34,135.05 57.78,135.05 58.11,135.38 58.4,135.38 59.47,134.31 59.79,134.31 60.02,134.53 60.02,134.84 59.31,135.54 59.31,135.84 59.53,136.06 59.87,136.06 60.54,135.39 60.87,135.39 61.09,135.61 61.09,135.92 60.37,136.64 60.37,136.89 60.66,137.18 60.91,137.18 61.62,136.47 61.96,136.47 62.18,136.7 62.18,136.99 61.48,137.68 61.48,137.96 62.65,139.12 62.65,148.16 66.06,151.57 68.34,151.57 68.61,151.84 68.61,152.21 67.8,153.02 67.8,153.24 68.39,153.83 71.96,153.83 73.73,155.6 73.73,155.96 73.09,156.6 73.09,157.74 75.94,160.59 77.85,160.59 78.72,161.47 81.63,161.47 82.19,162.02 83.54,162.02 v4(83.94,161.62)
DDRC_DBI_N3: length 77.4
  TOP w0.127: v4(52.7,119.65) U40.AB6
  TOP w0.13: v4(88.74,161.62) U16.E2
  S7 w0.127: v4(52.7,119.65) 53.01,119.65 53.56,119.1 53.94,119.1 54.19,118.84 54.19,118.46 54.51,118.14 57.92,118.14 63.62,123.85 63.62,128.97 78.16,143.51 78.16,144.68 84.64,151.16 84.96,151.16 85.77,150.34 86.07,150.34 86.29,150.56 86.29,150.9 85.39,151.8 85.39,152.14 85.62,152.36 85.91,152.36 86.87,151.4 87.17,151.4 87.39,151.62 87.39,151.95 86.37,152.98 86.37,153.27 86.59,153.49 86.93,153.49 87.93,152.49 88.27,152.49 88.49,152.72 88.49,153.01 87.47,154.03 87.47,154.35 87.7,154.57 88.01,154.57 89.01,153.57 89.34,153.57 89.57,153.79 89.57,154.09 88.73,154.93 88.73,155.25 90.14,156.65 90.14,160.91 89.82,161.22 88.93,161.22 88.74,161.41 v4(88.74,161.62)
DDRC_DQ0: length 70.2
  TOP w0.127: v4(57.7,119.65) U40.AB1
  TOP w0.13: v4(99.29,163.22) U17.G2
  S9 w0.127: v4(99.29,163.22) 99.11,163.04 99.11,162.95 97.81,161.65 97.81,160.13 97.21,159.54 97.21,157.73 97.4,157.54 98.62,157.54 98.79,157.37 98.79,157 98.58,156.78 97.46,156.78 97.21,156.54 97.21,155.54 93.23,151.56 91.46,151.56 88.03,148.13 86.52,148.13 85.49,147.09 85.49,141.46 80.31,136.28 77.37,136.28 65.19,124.1 63.73,124.1 59.28,119.65 v4(57.7,119.65)
DDRC_DQ1: length 70.2
  TOP w0.127: v4(56.7,121.65) U40.AD2
  TOP w0.13: v4(94.49,162.42) U17.F7
  S9 w0.127: v4(56.7,121.65) 56.7,122.09 57.14,122.53 57.14,122.91 57.48,123.25 57.86,123.25 66.15,131.54 66.44,131.54 67.21,130.78 67.5,130.78 67.76,131.04 67.76,131.31 66.71,132.35 66.71,132.63 66.97,132.89 67.25,132.89 68.27,131.87 68.59,131.87 68.82,132.11 68.82,132.4 67.78,133.44 67.78,133.74 68,133.96 68.34,133.96 69.36,132.94 69.66,132.94 76,139.28 79.07,139.28 82.48,142.7 82.48,149.03 85.24,151.79 86.82,151.79 93.28,158.25 93.28,162.63 93.48,162.82 94.08,162.82 v4(94.49,162.42)
DDRC_DQ2: length 70.1
  TOP w0.127: v4(55.7,119.65) U40.AB3
  TOP w0.13: v4(98.48,164.02) U17.H3
  S9 w0.127: v4(98.48,164.02) 98.71,164.02 98.88,163.85 98.88,163.05 97.11,161.28 97.11,160.15 96.71,159.75 96.71,155.87 92.9,152.07 91.13,152.07 88.17,149.11 86.52,149.11 84.98,147.57 84.98,141.67 80.1,136.79 77.16,136.79 64.98,124.6 63.52,124.6 59.13,120.22 56.27,120.22 v4(55.7,119.65)
DDRC_DQ3: length 70.2
  TOP w0.127: v4(57.7,122.65) U40.AE1
  TOP w0.13: v4(94.49,164.02) U17.H7
  S9 w0.127: v4(94.49,164.02) 94.88,163.62 94.88,162.25 94.65,162.02 94.33,162.02 94.08,161.77 94.08,158.26 90.82,155 90.82,155 86.92,151.1 85.27,151.1 82.99,148.82 82.99,142.49 79.28,138.78 76.21,138.78 67.38,129.94 67.07,129.94 66.37,130.64 66.07,130.64 65.81,130.38 65.81,130.13 66.52,129.42 66.52,129.11 66.29,128.88 65.98,128.88 65.32,129.54 65.01,129.54 64.79,129.31 64.79,128.99 65.49,128.29 65.49,127.98 65.26,127.75 64.95,127.75 64.22,128.48 63.91,128.48 63.67,128.24 63.67,127.95 64.44,127.18 64.44,126.88 64.21,126.65 63.9,126.65 63.24,127.3 63.01,127.3 58.35,122.65 v4(57.7,122.65)
DDRC_DQ4: length 70.3
  TOP w0.127: v4(56.7,118.65) U40.AA2
  TOP w0.13: v4(99.29,164.02) U17.H2
  S9 w0.127: v4(56.7,118.65) 57.09,119.04 59.39,119.04 63.94,123.59 65.67,123.59 77.86,135.77 80.52,135.77 86.46,141.71 86.46,145.83 91.69,151.05 93.74,151.05 97.72,155.03 97.72,156 98,156.27 98.96,156.27 99.69,157 99.69,163.62 99.29,164.02 v4(99.29,164.02)
DDRC_DQ5: length 70.2
  TOP w0.127: v4(55.7,121.65) U40.AD3
  TOP w0.13: v4(93.69,164.02) U17.H8
  S9 w0.127: v4(55.7,121.65) 56.21,122.16 56.21,122.78 56.59,123.17 56.78,123.17 57.24,123.63 57.24,123.77 57.66,124.19 57.79,124.19 58.09,124.48 58.09,124.76 68.07,134.74 68.33,134.74 69.33,133.75 69.61,133.75 69.89,134.03 69.89,134.26 68.88,135.28 68.88,135.55 69.11,135.79 69.45,135.79 70.43,134.8 70.69,134.8 70.97,135.08 70.97,135.34 70.22,136.09 70.22,136.4 70.46,136.63 70.79,136.63 71.44,135.99 71.8,135.99 75.61,139.79 78.55,139.79 81.98,143.22 81.98,149.24 85.03,152.3 86.61,152.3 92.29,157.98 92.29,162.41 92.71,162.82 93.09,162.82 93.28,163.01 93.28,163.62 v4(93.69,164.02)
DDRC_DQ6: length 70.3
  TOP w0.127: v4(55.7,122.65) U40.AE3
  TOP w0.13: v4(98.48,165.62) U17.J3
  S9 w0.127: v4(55.7,122.65) 55.7,122.88 56.14,123.32 56.14,123.71 56.57,124.15 56.76,124.15 57.24,124.63 57.24,124.75 57.75,125.25 57.86,125.25 69.75,137.14 72.24,137.14 75.4,140.3 78.26,140.3 79.99,142.02 79.99,144.4 80.46,144.87 80.46,146.88 80.68,147.1 81.24,147.1 81.44,147.31 81.44,147.62 81.2,147.86 80.8,147.86 80.63,148.04 80.63,148.4 80.85,148.63 81.26,148.63 81.47,148.83 81.47,149.45 84.92,152.91 86.5,152.91 91.66,158.06 91.66,163.35 92.73,164.42 95.02,164.42 96.22,165.62 v4(98.48,165.62)
DDRC_DQ7: length 70.4
  TOP w0.127: v4(55.7,118.65) U40.AA3
  TOP w0.13: U17.J7 v4(94.49,164.82)
  S9 w0.127: v4(55.7,118.65) 55.14,119.2 54.58,119.2 54.24,119.55 54.24,122.8 54.59,123.14 54.75,123.14 55.19,123.58 55.19,123.7 55.68,124.18 55.79,124.18 56.14,124.53 56.14,124.71 56.56,125.14 56.75,125.14 57.22,125.61 57.22,125.72 57.75,126.25 58.14,126.25 69.54,137.65 72.03,137.65 75.19,140.82 77.17,140.82 79.48,143.12 79.48,144.61 79.95,145.08 79.95,148.66 84.76,153.46 86.34,153.46 91.13,158.25 91.13,163.53 92.51,164.92 94.38,164.92 v4(94.49,164.82)
DDRC_DQ8: length 70.2
  TOP w0.127: v4(56.7,124.65) U40.AG2
  TOP w0.13: v4(98.49,158.42) U17.A3
  S5 w0.127: v4(56.7,124.65) 56.7,124.36 56.89,124.18 58.94,124.18 65.55,130.78 65.55,133.09 70.23,137.78 70.55,137.78 71.42,136.91 71.73,136.91 71.95,137.14 71.95,137.45 71.09,138.32 71.09,138.63 71.31,138.86 71.63,138.86 72.49,137.99 72.81,137.99 73.03,138.22 73.03,138.53 72.17,139.4 72.17,139.71 72.39,139.94 72.71,139.94 73.57,139.07 73.89,139.07 74.1,139.28 74.1,139.62 73.48,140.24 73.48,140.53 73.7,140.76 74.04,140.76 74.64,140.16 74.97,140.16 76.9,142.09 76.9,146.8 81.54,151.43 90.82,151.43 97.8,158.42 v4(98.49,158.42)
DDRC_DQ9: length 70
  TOP w0.127: v4(56.7,127.65) U40.AK2
  TOP w0.13: v4(93.69,159.22) U17.B8
  S5 w0.127: v4(56.7,127.65) 57.19,128.14 57.96,128.14 62.27,132.45 62.27,136.3 62.71,136.74 arc(62.8,136.96) 62.71,137.19 62.38,137.51 arc(62.38,137.96) 62.83,137.96 63.16,137.64 arc(63.61,137.64) 63.61,138.09 63.27,138.43 arc(63.27,138.88) 63.72,138.88 64.06,138.53 arc(64.5,138.53) 64.5,138.98 64.18,139.31 arc(64.18,139.76) 64.63,139.76 64.95,139.43 arc(65.18,139.34) 65.4,139.43 67.37,141.4 69.41,141.4 72.54,144.54 72.54,150.39 74.99,152.84 77.26,152.84 78.52,154.1 79.12,154.1 79.35,154.32 79.35,155.9 79.57,156.12 79.88,156.12 80.11,155.9 80.11,154.28 80.33,154.06 80.65,154.06 80.87,154.28 80.87,155.78 81.09,156.01 81.41,156.01 81.63,155.78 81.63,154.44 81.87,154.2 82.18,154.2 82.39,154.41 82.39,155.9 82.62,156.12 91.34,156.12 93.28,158.06 93.28,158.82 v4(93.69,159.22)
DDRC_DQ10: length 70.2
  TOP w0.127: v4(57.7,123.65) U40.AF1
  TOP w0.13: v4(98.48,160.02) U17.C3
  S5 w0.127: v4(57.7,123.65) 59.45,123.65 66.21,130.4 66.21,132.94 67.86,134.6 68.18,134.6 69.29,133.49 69.6,133.49 69.83,133.71 69.83,134.03 68.85,135.01 68.85,135.32 69.07,135.55 69.38,135.55 70.36,134.57 70.68,134.57 70.9,134.79 70.9,135.11 69.92,136.09 69.92,136.38 70.15,136.6 70.49,136.6 71.28,135.81 71.62,135.81 77.47,141.67 77.47,146.65 81.64,150.82 91.54,150.82 98.89,158.17 98.89,159.62 v4(98.48,160.02)
DDRC_DQ11: length 70.2
  TOP w0.127: U40.AJ2 v4(56.7,126.65)
  TOP w0.13: v4(94.49,160.02) U17.C7
  S5 w0.127: v4(56.7,126.65) 57.22,127.17 58.33,127.17 63.08,131.93 63.08,136.25 65.47,138.64 66.38,138.64 66.75,138.27 67.12,138.27 67.3,138.45 arc(67.39,138.67) 67.3,138.89 66.9,139.3 arc(66.9,139.75) 67.34,139.75 67.75,139.34 arc(68.2,139.34) 68.2,139.79 67.77,140.22 arc(67.77,140.67) 68.22,140.67 68.65,140.24 arc(68.87,140.15) 69.1,140.24 73.08,144.23 73.08,149.97 75.37,152.26 77.4,152.26 78.61,153.47 82.93,153.47 83.03,153.57 83.03,155.37 83.2,155.53 83.7,155.53 83.84,155.4 83.84,154.06 83.97,153.93 84.47,153.93 84.68,154.14 84.68,155.28 84.82,155.42 85.3,155.42 85.43,155.29 85.43,154.14 85.56,154.01 86.06,154.01 86.2,154.14 86.2,155.38 86.43,155.61 91.6,155.61 94.08,158.1 94.08,159.4 94.49,159.8 v4(94.49,160.02)
DDRC_DQ12: length 70.2
  TOP w0.127: v4(56.7,123.65) U40.AF2
  TOP w0.13: v4(99.29,160.02) U17.C2
  S5 w0.127: v4(56.7,123.65) 56.95,123.65 57.46,123.14 60.14,123.14 67.49,130.49 67.49,130.81 66.77,131.54 66.77,131.83 66.99,132.05 67.33,132.05 68.03,131.35 68.35,131.35 68.57,131.57 68.57,131.89 67.39,133.07 67.39,133.36 67.61,133.58 67.95,133.58 69.11,132.43 69.43,132.43 78.16,141.16 78.16,146.62 81.85,150.31 91.75,150.31 99.69,158.25 99.69,159.37 99.29,159.78 v4(99.29,160.02)
DDRC_DQ13: length 70.2
  TOP w0.127: v4(57.7,129.65) U40.AM1
  TOP w0.13: v4(93.69,160.02) U17.C8
  S5 w0.127: v4(93.69,160.02) 93.28,160.42 92.6,160.42 91.66,159.48 91.66,158.07 90.73,157.14 76.9,157.14 76.68,156.91 76.68,155.36 76.46,155.14 76.14,155.14 75.92,155.36 75.92,156.91 75.7,157.14 75.38,157.14 75.16,156.91 75.16,155.47 74.93,155.24 74.62,155.24 74.4,155.47 74.4,156.91 74.17,157.14 73.86,157.14 73.63,156.91 73.63,155.47 70.58,152.42 66.23,152.42 62.51,148.7 62.51,143.55 arc(62.42,143.32) 62.2,143.23 61.78,143.23 arc(61.46,142.91) 61.78,142.59 62.2,142.59 arc(62.51,142.28) 62.2,141.96 61.72,141.96 arc(61.41,141.64) 61.72,141.32 62.2,141.32 arc(62.42,141.23) 62.51,141.01 62.51,140.14 60.8,138.42 60.8,132.75 57.7,129.65 v4(57.7,129.65)
DDRC_DQ14: length 70.2
  TOP w0.127: v4(55.7,124.65) U40.AG3
  TOP w0.13: v4(98.48,160.82) U17.D3
  S5 w0.127: v4(98.48,160.82) 98.88,160.42 100.4,160.42 100.93,159.89 100.93,158.71 92.03,149.81 83.12,149.81 79.37,146.05 79.37,141.29 60.21,122.14 57.45,122.14 57.2,122.38 57.2,122.78 56.8,123.18 56.47,123.18 56.23,123.42 56.23,124.22 55.8,124.65 v4(55.7,124.65)
DDRC_DQ15: length 70.1
  TOP w0.127: v4(56.7,129.65) U40.AM2
  TOP w0.13: v4(94.49,160.82) U17.D7
  S5 w0.127: v4(94.49,160.82) 94.08,160.42 94.08,159.85 93.86,159.62 92.69,159.62 92.29,159.23 92.29,157.99 90.94,156.63 79.05,156.63 78.84,156.42 78.84,154.82 78.63,154.61 78.3,154.61 78.08,154.83 78.08,156.4 77.85,156.63 77.54,156.63 77.31,156.4 77.31,154.83 77.09,154.61 75.38,154.61 75.18,154.4 75.18,153.71 74.95,153.49 74.64,153.49 74.41,153.71 74.41,154.73 74.19,154.95 73.87,154.95 73.65,154.73 73.65,153.71 71.58,151.64 66.18,151.64 63.13,148.59 63.13,141.73 arc(63.22,141.51) 63.44,141.41 63.58,141.41 arc(63.9,141.1) 63.58,140.78 63.44,140.78 arc(63.22,140.69) 63.13,140.46 63.13,140 61.53,138.41 61.53,132.77 57.91,129.14 57.21,129.14 v4(56.7,129.65)
DDRC_DQ16: length 76.7
  TOP w0.127: v4(55.7,127.65) U40.AK3
  TOP w0.13: v4(88.74,163.22) U16.G2
  S9 w0.127: v4(55.7,127.65) 56.19,128.14 57.06,128.14 57.41,128.49 57.57,128.49 58.29,129.2 58.99,129.2 68.93,139.13 71.41,139.13 74.71,142.43 76.52,142.43 76.68,142.58 76.68,143.07 76.5,143.25 75.04,143.25 74.87,143.43 74.87,144.14 75.09,144.36 77.14,144.36 77.69,144.91 77.69,145.36 77.47,145.59 76.11,145.59 75.98,145.71 75.98,146.25 76.19,146.46 78.22,146.46 78.47,146.71 78.47,147.03 78.27,147.22 76.3,147.22 76.08,147.44 76.08,147.86 76.23,148 78.28,148 78.47,148.19 78.47,148.64 78.32,148.8 76.74,148.8 76.59,148.95 76.59,149.41 76.8,149.62 78.74,149.62 78.93,149.81 78.93,150.11 78.63,150.41 76.65,150.41 76.12,150.94 76.12,151.21 76.74,151.83 76.89,151.83 77.27,151.45 77.54,151.45 77.97,151.88 77.97,152.08 77.65,152.39 77.65,152.57 78.01,152.93 78.19,152.93 78.52,152.6 78.68,152.6 82.52,156.44 84.1,156.44 87.54,159.88 87.54,163.5 87.67,163.62 88.34,163.62 v4(88.74,163.22)
DDRC_DQ17: length 76.9
  TOP w0.127: v4(52.7,122.65) U40.AE6
  TOP w0.13: v4(83.94,162.42) U16.F7
  S9 w0.127: v4(83.94,162.42) 84.34,162.02 84.34,160.65 84.11,160.42 81.25,160.42 80.76,160.92 78.92,160.92 77.99,159.99 76.27,159.99 74.9,158.63 74.9,158.21 75.51,157.6 75.51,157.3 75.13,156.92 74.96,156.92 74.13,157.75 73.84,157.75 73.61,157.52 73.61,157 74.29,156.32 74.29,155.45 72.17,153.32 70.03,153.32 69.59,152.88 69.59,151.24 72.2,148.62 72.2,144.74 69.56,142.1 63.42,142.1 63.16,141.83 63.16,138.68 62.45,137.97 62.45,137.46 62.8,137.12 62.8,136.59 59.93,133.73 58.87,133.73 58.06,134.54 57.36,134.54 56.86,135.04 55.31,135.04 55.12,134.85 55.12,134.34 54.92,134.14 54.57,134.14 54.14,133.71 54.14,133.46 53.76,133.09 53.51,133.09 53.14,132.72 53.14,132.47 52.88,132.2 52.63,132.2 52.17,131.74 52.17,128.36 51.93,128.13 51.44,128.13 51.21,127.9 51.21,125.46 51.46,125.2 51.9,125.2 52.19,124.91 52.19,124.42 52.43,124.18 52.96,124.18 53.22,123.93 53.22,123.16 v4(52.7,122.65)
DDRC_DQ18: length 77
  TOP w0.127: v4(55.7,128.65) U40.AL3
  TOP w0.13: v4(87.94,164.02) U16.H3
  S9 w0.127: v4(87.94,164.02) 87.53,164.02 87.32,163.8 87.32,160.37 83.89,156.94 81.98,156.94 81.76,156.72 81.5,156.72 81.08,157.14 80.7,157.14 80.54,156.98 80.54,156.72 80.98,156.28 80.98,155.94 80.82,155.79 80.54,155.79 79.29,157.04 79.1,157.04 78.68,156.62 78.68,156.48 80.02,155.14 80.02,154.98 79.6,154.57 79.46,154.57 78.13,155.9 77.91,155.9 77.54,155.52 77.54,155.38 78.84,154.07 78.84,153.86 78.45,153.46 78.25,153.46 77.01,154.7 76.83,154.7 76.47,154.34 76.47,154.14 77.1,153.51 77.1,153.32 76.74,152.96 76.58,152.96 75.92,153.62 75.67,153.62 75.4,153.34 75.4,153.08 76.04,152.44 76.04,152.16 75.74,151.87 75.52,151.87 74.86,152.53 74.61,152.53 73.47,151.39 73.47,151.2 73.73,150.94 73.95,150.94 74.49,151.48 74.67,151.48 74.97,151.18 74.97,151.02 74.49,150.54 74.49,150.4 75.51,149.37 75.51,146.74 74.36,145.59 74.36,143.04 71.21,139.89 66.2,139.89 66.03,139.71 66.03,139.12 66.15,139 67.19,139 67.4,138.79 67.4,138.33 59.23,130.15 57.64,130.15 57.17,129.67 57.17,129.56 56.75,129.14 56.19,129.14 v4(55.7,128.65)
DDRC_DQ19: length 76.8
  TOP w0.127: v4(53.7,124.65) U40.AG5
  TOP w0.13: v4(83.94,164.02) U16.H7
  S9 w0.127: v4(83.94,164.02) 83.94,164.02 84.9,163.06 85.87,163.06 86.07,162.86 86.07,162.51 85.87,162.3 84.98,162.3 84.75,162.07 84.75,161.71 84.96,161.5 85.56,161.5 85.74,161.31 85.74,161.03 84.32,159.61 81.47,159.61 80.62,158.76 78.43,158.76 72.38,152.71 70.64,152.71 70.46,152.53 70.46,152 70.67,151.79 71.21,151.79 71.39,151.61 71.39,150.19 72.72,148.85 72.72,144.51 69.67,141.46 64.27,141.46 63.75,140.94 63.75,139.04 64.71,138.08 64.71,137.79 64.46,137.54 64.17,137.54 63.67,138.04 63.28,138.04 63.09,137.85 63.09,137.54 63.62,137.01 63.62,136.7 59.47,132.55 58.27,132.55 58.09,132.73 58.09,133.87 57.81,134.16 55.5,134.16 55.3,133.96 55.3,133.34 55.12,133.16 54.54,133.16 54.21,132.83 54.21,132.42 53.87,132.09 53.43,132.09 53.18,131.84 53.18,128.51 52.81,128.14 52.55,128.14 52.18,127.77 52.18,125.54 52.56,125.16 52.88,125.16 53.39,124.65 v4(53.7,124.65)
DDRC_DQ20: length 76.8
  TOP w0.127: v4(54.7,128.65) U40.AL4
  TOP w0.13: v4(88.74,164.02) U16.H2
  S9 w0.127: v4(88.74,164.02) 89.12,164.4 89.38,164.4 89.65,164.66 89.65,164.84 89.48,165 87.26,165 87.1,165.16 87.1,168.21 86.31,169.01 85.31,169.01 85.07,168.77 85.07,168.3 85.23,168.14 85.91,168.14 86.03,168.01 86.03,167.41 85.91,167.28 85.28,167.28 85.07,167.08 85.07,166.75 85.26,166.56 85.7,166.56 85.82,166.43 85.82,166.02 85.73,165.93 85.29,165.93 85.07,165.71 85.07,165.34 87.09,163.32 87.09,160.94 83.8,157.65 78.76,157.65 72.71,151.6 72.71,151.15 73.82,150.04 73.82,143.49 70.72,140.39 65.83,140.39 65.39,139.96 65.39,138.99 65.77,138.61 65.77,137.41 59.53,131.17 57.66,131.17 57.15,130.66 57.15,130.25 57.03,130.13 56.51,130.13 56.26,129.87 56.26,129.53 55.93,129.2 55.52,129.2 55.26,128.94 55.26,128.82 55.08,128.65 v4(54.7,128.65)
DDRC_DQ21: length 76.8
  TOP w0.127: v4(50.7,121.65) U40.AD8
  TOP w0.13: U16.H8 v4(83.14,164.02)
  S9 w0.127: v4(83.14,164.02) 82.75,163.62 82.19,163.62 81.96,163.4 81.26,163.4 81.08,163.22 81.08,162.36 80.92,162.19 80.49,162.19 80.32,162.37 80.32,164.34 80.11,164.54 79.7,164.54 79.56,164.4 79.56,162.3 79.41,162.15 78.98,162.15 78.78,162.35 78.78,164.18 78.53,164.43 77.13,164.43 75.92,163.23 75.92,161.29 72.47,157.84 72.47,156.5 72.79,156.18 72.79,155.39 71.74,154.34 68.06,154.34 67.26,153.54 67.26,153.54 62.14,148.42 62.14,139.39 58.74,135.99 54.38,135.99 53.14,134.75 53.14,134.25 52.98,134.09 52.32,134.09 52.14,133.91 52.14,133.25 51.98,133.09 51.29,133.09 51.14,132.93 51.14,132.35 50.99,132.2 50.41,132.2 50.2,131.99 50.2,128.41 49.99,128.2 49.36,128.2 49.2,128.05 49.2,124.32 49.34,124.18 50.01,124.18 50.2,123.99 50.2,122.38 50.7,121.88 v4(50.7,121.65)
DDRC_DQ22: length 77
  TOP w0.127: U40.AH4 v4(54.7,125.65)
  TOP w0.13: v4(87.94,165.62) U16.J3
  S9 w0.127: v4(87.94,165.62) 87.52,166.04 87.52,168.68 86.64,169.56 85.13,169.56 84.47,168.9 84.47,165.22 86.58,163.11 86.58,161.15 85.36,159.93 84.25,158.82 81.4,158.82 80.76,158.19 78.58,158.19 72.15,151.77 72.15,150.96 73.25,149.86 73.25,144.02 70.18,140.95 65.22,140.95 64.73,140.46 64.73,138.88 65.25,138.36 65.25,137.61 59.68,132.04 57.46,132.04 57.12,131.7 57.12,131.44 56.83,131.16 56.58,131.16 56.2,130.77 56.2,130.5 55.9,130.2 55.7,130.2 55.14,129.64 55.14,129.53 54.81,129.2 54.61,129.2 54.14,128.73 54.14,128.53 53.76,128.15 53.58,128.15 53.18,127.76 53.18,125.6 53.53,125.25 54.3,125.25 v4(54.7,125.65)
DDRC_DQ23: length 76.6
  TOP w0.127: v4(50.7,120.65) U40.AC8
  TOP w0.13: v4(83.94,164.82) U16.J7
  S9 w0.127: v4(83.94,164.82) 83.54,164.41 83.18,164.41 82.97,164.61 82.97,165.05 82.79,165.22 82.39,165.22 82.2,165.04 82.2,164.43 81.98,164.21 81.66,164.21 81.44,164.43 81.44,165.68 81.09,166.02 80.3,166.02 79.21,164.94 76.86,164.94 75.3,163.38 75.3,161.39 71.96,158.05 71.96,155.28 71.53,154.85 67.85,154.85 61.63,148.64 61.63,139.6 58.53,136.5 53.83,136.5 52.17,134.83 52.17,134.32 52,134.15 51.36,134.15 51.18,133.97 51.18,133.3 51.01,133.13 50.37,133.13 50.17,132.93 50.17,132.37 50,132.2 49.37,132.2 49.2,132.03 49.2,128.45 49,128.25 48.26,128.25 48.09,128.08 48.09,123.37 48.33,123.14 49.04,123.14 49.19,122.99 49.19,122.27 49.32,122.14 49.93,122.14 50.1,121.97 50.1,120.77 50.23,120.65 v4(50.7,120.65)
DDRC_DQ24: length 77.6
  TOP w0.127: v4(54.7,119.65) U40.AB4
  TOP w0.13: v4(87.94,158.42) U16.A3
  S7 w0.127: v4(54.7,119.65) 55.22,120.17 58.12,120.17 58.7,120.75 59.03,120.75 62.61,124.33 62.61,131.86 67.71,136.95 70.04,136.95 76.71,143.62 76.71,146.71 75.47,147.95 75.47,148.25 75.69,148.47 76.02,148.47 77.68,146.82 78,146.82 78.22,147.04 78.22,147.36 76.6,148.98 76.6,149.25 76.87,149.52 77.13,149.52 78.76,147.9 79.08,147.9 79.3,148.12 79.3,148.43 77.98,149.75 77.98,150.07 78.2,150.29 78.52,150.29 79.96,148.85 80.28,148.85 80.5,149.07 80.5,149.39 79.77,150.12 79.77,150.39 80.03,150.64 80.32,150.64 81.02,149.95 81.33,149.95 81.56,150.17 81.56,150.49 80.15,151.9 80.15,152.16 80.41,152.42 80.7,152.42 81.99,151.13 82.31,151.13 87.94,156.76 v4(87.94,158.42)
DDRC_DQ25: length 77.4
  TOP w0.127: v4(54.7,123.65) U40.AF4
  TOP w0.13: U16.B8 v4(83.14,159.22)
  S7 w0.127: v4(83.14,159.22) 82.74,158.82 82.74,157.7 79.67,154.63 79.05,154.63 76.87,152.45 71.83,152.45 71.57,152.18 71.57,151.48 71.94,151.1 72.3,151.1 72.51,150.9 72.51,145.04 69.67,142.2 61.53,142.2 61.32,141.99 61.32,141.35 61.53,141.14 62.85,141.14 62.97,141.02 62.97,140.34 62.86,140.23 61.54,140.23 61.34,140.04 61.34,139.02 61.45,138.91 63.61,138.91 63.84,138.69 63.84,138.37 63.61,138.15 61.45,138.15 61.23,137.92 61.23,137.61 61.45,137.39 63.61,137.39 63.84,137.16 63.84,136.85 63.61,136.62 60.84,136.62 60.61,136.4 60.61,136.08 60.84,135.86 62.52,135.86 62.75,135.63 62.75,135.32 62.53,135.1 60.75,135.1 60.57,134.92 60.57,134.55 60.79,134.32 61.19,134.32 61.31,134.2 61.31,133.72 61.15,133.56 60.79,133.56 60.57,133.34 60.57,125.55 59.19,124.17 55.67,124.17 55.14,123.65 v4(54.7,123.65)
DDRC_DQ26: length 77.6
  TOP w0.127: v4(54.7,122.65) U40.AE4
  TOP w0.13: v4(87.94,160.02) U16.C3
  S7 w0.127: v4(54.7,122.65) 55.21,123.16 58.89,123.16 61.08,125.34 61.08,132.55 64.63,136.1 arc(64.72,136.33) 64.63,136.55 64.49,136.69 arc(64.49,137.14) 64.94,137.14 65.03,137.05 arc(65.48,137.05) 65.48,137.5 64.96,138.01 arc(64.96,138.46) 65.41,138.46 65.91,137.96 arc(66.36,137.96) 66.36,138.41 65.4,139.38 64.47,139.38 64.33,139.52 64.33,139.85 64.52,140.04 67.19,140.04 67.43,140.28 67.43,140.68 67.25,140.86 64.53,140.86 64.32,141.07 64.32,141.44 64.55,141.68 70.34,141.68 73.06,144.4 73.06,150.39 74.6,151.94 77.08,151.94 79.13,153.99 79.75,153.99 83.54,157.78 83.54,159.4 83.77,159.62 84.29,159.62 84.96,160.29 84.96,162.31 85.21,162.56 85.69,162.56 85.92,162.33 85.92,160.43 86.34,160.02 v4(87.94,160.02)
DDRC_DQ27: length 77.5
  TOP w0.127: v4(53.7,123.65) U40.AF5
  TOP w0.13: v4(83.94,160.02) U16.C7
  S7 w0.127: v4(53.7,123.65) 53.97,123.65 54.47,124.14 54.84,124.14 55.2,124.5 55.2,124.77 55.57,125.14 59.07,125.14 60.06,126.13 60.06,136.56 60.72,137.23 60.72,143.67 63.09,146.05 63.09,148.59 67.46,152.96 74.54,152.96 75.35,153.77 75.72,153.77 76.29,153.21 76.57,153.21 76.8,153.44 76.8,153.77 75.84,154.74 75.84,155.01 76.08,155.26 76.39,155.26 77.51,154.13 77.83,154.13 78.06,154.36 78.06,154.67 76.93,155.79 76.93,156.11 77.16,156.33 77.47,156.33 78.67,155.14 79,155.14 79.22,155.36 79.22,155.66 78.01,156.87 78.01,157.19 78.23,157.41 78.55,157.41 79.97,155.99 80.31,155.99 80.54,156.21 80.54,156.5 79.01,158.03 79.01,158.34 79.23,158.57 79.55,158.57 81.07,157.04 81.37,157.04 81.6,157.28 81.6,157.59 80.04,159.16 80.04,159.42 80.24,159.62 83.34,159.62 83.74,160.02 v4(83.94,160.02)
DDRC_DQ28: length 77.5
  TOP w0.127: v4(51.7,119.65) U40.AB7
  TOP w0.13: v4(88.74,160.02) U16.C2
  S7 w0.127: v4(51.7,119.65) 52.2,120.15 53.9,120.15 54.19,119.86 54.19,119.54 54.58,119.16 58.16,119.16 63.12,124.12 63.12,129.19 63.52,129.58 63.52,129.9 63.17,130.25 63.17,130.56 63.39,130.78 63.71,130.78 64.05,130.44 64.37,130.44 64.59,130.66 64.59,130.98 63.67,131.9 63.67,132.2 63.89,132.42 64.23,132.42 65.13,131.52 65.45,131.52 65.67,131.74 65.67,132.06 64.74,132.99 64.74,133.27 64.96,133.49 65.31,133.49 66.21,132.59 66.53,132.59 66.75,132.82 66.75,133.13 65.83,134.06 65.83,134.35 66.05,134.58 66.38,134.58 67.29,133.67 67.6,133.67 67.83,133.9 67.83,134.21 66.9,135.14 66.9,135.43 67.12,135.65 67.47,135.65 68.37,134.75 68.68,134.75 68.95,135.02 68.95,135.34 68.38,135.91 68.38,136.2 68.6,136.42 68.95,136.42 69.49,135.88 69.81,135.88 77.65,143.72 77.65,145.4 89.14,156.89 89.14,159.62 v4(88.74,160.02)
DDRC_DQ29: length 77.6
  TOP w0.127: v4(51.7,120.65) U40.AC7
  TOP w0.13: U16.C8 v4(83.14,160.02)
  S7 w0.127: v4(83.14,160.02) 82.74,160.42 82.06,160.42 82.02,160.46 78.07,160.46 76.8,159.19 76.8,158.86 77.71,157.94 77.71,157.63 77.49,157.4 77.17,157.4 76.16,158.42 75.83,158.42 75.6,158.2 75.6,157.9 76.63,156.87 76.63,156.55 76.41,156.33 76.1,156.33 75.08,157.34 74.75,157.34 74.52,157.12 74.52,156.82 75.57,155.78 75.57,155.46 75.34,155.24 75.02,155.24 73.99,156.27 73.68,156.27 73.45,156.05 73.45,155.73 74.8,154.39 74.8,154.15 74.55,153.9 74.21,153.9 72.94,155.17 72.63,155.17 72.31,154.84 72.31,154.53 72.84,154 72.84,153.69 72.61,153.46 72.3,153.46 71.77,153.99 71.46,153.99 70.93,153.46 67.25,153.46 62.55,148.77 62.55,146.92 60.11,144.48 60.11,137.34 59.55,136.77 59.55,126.89 58.82,126.16 55.56,126.16 55.14,125.74 55.14,125.37 54.94,125.17 54.52,125.17 54.14,124.78 54.14,124.46 53.88,124.2 53.61,124.2 53.17,123.77 53.14,123.74 53.14,123.4 52.94,123.2 52.61,123.2 52.59,123.19 52.59,123.18 52.2,122.78 52.2,121.14 v4(51.7,120.65)
DDRC_DQ30: length 77.3
  TOP w0.127: v4(50.7,118.65) U40.AA8
  TOP w0.13: v4(87.94,160.82) U16.D3
  S7 w0.127: v4(50.7,118.65) 51.08,118.65 51.53,119.1 52.92,119.1 53.18,118.84 53.18,118.46 53.43,118.21 53.81,118.21 54.19,117.83 54.19,117.45 54.51,117.13 58.08,117.13 58.36,117.41 58.36,117.86 64.25,123.76 64.25,128.88 79.1,143.73 79.1,144.9 84.03,149.83 86.33,149.83 90.36,153.87 90.36,154.25 89.57,155.05 89.57,155.36 89.79,155.59 90.1,155.59 91.35,154.34 91.59,154.34 91.82,154.56 91.82,154.95 90.64,156.13 90.64,161.14 89.75,162.02 88.59,162.02 88.34,161.78 88.34,161.22 v4(87.94,160.82)
