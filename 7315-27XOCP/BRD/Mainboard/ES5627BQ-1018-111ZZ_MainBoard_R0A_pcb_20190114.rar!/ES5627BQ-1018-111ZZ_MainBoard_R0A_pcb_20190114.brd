# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UCD90160_INT_R: length 4.7
  TOP w0.127: R165.2 226.69,212.98 v1(227.04,213.33) 227.41,213.33 228.58,214.5 U7.36
  BOTTOM w0.127: v1(227.04,213.33) 227.49,212.89 v2(227.49,212.19)
UCD90160_RESERVED: length 160
  TOP w0.127: P1.W15 v4(113.29,224.46) ; R194.1 226.16,209.33 225.81,209.67 221.92,209.67 v1(221.39,210.2)
  S7 w0.127: v1(198.34,244) 178.78,244 176.94,242.16 176.94,238.16 175.16,236.38 172.74,236.38 167.16,230.8 167.16,228.13 v1(167.23,228.06)
  S9 w0.127: v1(167.23,228.06) 167.22,228.06 167.22,228.06 167.03,228.06 165.86,226.89 146.56,226.89 145,228.45 138.07,228.45 135.06,231.46 128.22,231.46 122.65,225.89 121.11,225.89 119.85,224.64 116.3,224.64 115.98,224.95 113.88,224.95 113.39,224.46 v4(113.29,224.46)
  S12 w0.127: v1(198.34,244) 202.04,240.3 212.39,240.3 222.37,230.32 222.37,224.55 221.96,224.14 221.96,210.77 v1(221.39,210.2)
  BOTTOM w0.127: v2(221.96,211.55) 221.96,210.77 v1(221.39,210.2)
UCD90160_RESERVED_R: length 8.2
  TOP w0.127: R194.2 227.25,212.41 227.42,212.58 R166.2 227.78,212.99 v1(228.18,213.4) 229.03,214.24 229.29,214.24 229.58,214.52 U7.38
  BOTTOM w0.127: v2(229.71,211.87) v1(228.18,213.4)
UCD90160_RST: length 131.2
  TOP w0.127: v1(175.38,149.88) 174.52,149.88 171.94,147.3 J2.B57 ; U7.9 230.58,225.07 230.3,225.34 228.5,225.34 227.65,226.19 C16.2
  TOP w0.254: 226.51,229.02 226.51,228.63 227.05,228.1 227.05,226.86 227.25,226.66 C16.2 ; 226.51,229.02 R2.2 224.91,229.03 v1(223.98,228.1) ; 226.51,229.02 R25.2
  TOP w0.381: v1(220.18,219.36) 220.19,219.37 R86.1
  S5 w0.127: v1(220.18,219.36) 221.45,219.36 221.96,219.87 221.96,225.21 223.98,227.22 v1(223.98,228.1)
  S12 w0.127: v1(220.18,219.36) 218.6,217.78 218.6,208.38 210.66,200.44 210.66,176.44 200.99,166.77 200.99,165.1 194.5,158.62 194.5,158.16 188.25,151.91 177.41,151.91 v1(175.38,149.88)
  BOTTOM w0.127: v1(220.18,219.36) 219.61,218.79 v2(216.56,218.79) ; v2(225.07,228.57) 224.45,228.57 v1(223.98,228.1)
UCD90160_RST_L: length 157.7
  TOP w0.127: P1.L14 v4(105.29,223.46)
  TOP w0.254: R2.1 224.68,229.94 v1(223.56,228.81)
  S5 w0.127: v1(223.56,228.81) 219.35,233.02 207.46,233.02 206.65,233.83 206.65,236.83 201.43,242.05 181.97,242.05 v1(179.48,239.56)
  S9 w0.127: v4(105.29,223.46) 104.11,224.64 104.11,225.75 103.01,226.84 103.01,231.32 102.73,231.61 102.73,234.49 102.5,234.71 102.5,235.4 102.87,235.77 104.2,235.77 105.5,237.07 105.5,238.58 106.57,239.65 119.32,239.65 121.17,237.79 145.1,237.79 149.11,233.79 162.11,233.79 162.91,232.99 167.45,232.99 172.16,237.7 172.68,237.7 174.55,239.56 v1(179.48,239.56)
  BOTTOM w0.127: v1(223.56,228.81) 224.21,229.46 225.16,229.46 v2(225.96,230.26)
UCD90160_RST_R: length 5.8
  TOP w0.127: U7.24 v1(224.95,219.74) 224.49,219.74 223.78,220.45 R71.2 223.12,219.38 R86.2
  BOTTOM w0.127: v2(225.71,218.86) 224.95,219.62 v1(224.95,219.74)
UCD90160_SCL: length 216.5
  TOP w0.127: RB704.1 v1(172.43,243.75) ; CONN41.9 v1(40.65,248.43)
  TOP w0.254: U7.15 227.58,224.49 226.46,225.6 R40.2 223.59,226.71 v1(221.44,228.85)
  S9 w0.127: 174.62,248.91 175.28,248.25 188.26,248.25 188.65,248.64 199.29,248.64 215.1,232.83 218.15,232.83 221.44,229.53 v1(221.44,228.85) ; 174.62,248.91 v1(174.62,248.92) ; 174.62,248.91 174.02,248.32 170.72,248.32 170.02,249.02 146.9,249.02 146.08,249.84 138.17,249.84 137.29,248.96 136.8,248.96 136.11,249.65 100.61,249.65 94.64,243.68 85.25,243.68 80.04,248.89 41.11,248.89 v1(40.65,248.43)
  S12 w0.127: v1(172.43,243.75) 174.59,245.91 174.59,248.89 174.62,248.91 v1(174.62,248.92)
  BOTTOM w0.127: v1(221.44,228.85) 222.8,230.21 v2(222.8,230.31)
UCD90160_SCL_R: length 7.6
  TOP w0.127: UB16.7 169.47,243.39 v1(169.83,243.75) RB704.2 170.83,243.31 170.91,243.24 172.8,243.24 RB705.2
  BOTTOM w0.127: v2(171.15,243.29) 170.29,243.29 v1(169.83,243.75)
UCD90160_SDA: length 222.5
  TOP w0.127: RB710.1 v1(172.49,242.67) ; v1(221.9,226.54) 223.43,225.01 R39.2 223.44,224.75 226.54,224.75 227.08,224.21 U7.16 ; v1(42.06,249.44) 41.59,249.9 41.59,253.43 40.65,254.36 CONN41.10
  S9 w0.127: v1(221.9,226.54) 221.93,226.54 222.02,226.63 222.02,229.59 218.34,233.27 215.17,233.27 199.52,248.92 v1(175.76,248.92) 175.76,248.91 175.24,249.43 173.41,249.43 172.56,248.57 171.03,248.57 170.27,249.34 147.16,249.34 146.4,250.1 100.42,250.1 94.51,244.19 85.69,244.19 80.42,249.46 42.08,249.46 v1(42.06,249.44)
  S12 w0.127: v1(175.76,248.92) 175.76,245.94 v1(172.49,242.67)
  BOTTOM w0.127: v2(223.67,226.68) 223.66,226.67 222.02,226.67 v1(221.9,226.54)
UCD90160_SDA_R: length 7.7
  TOP w0.127: UB16.6 169.06,242.74 169.13,242.67 v1(169.89,242.67) RB710.2 170.83,242.3 170.97,242.16 172.8,242.16 RB711.2
  BOTTOM w0.127: v1(169.89,242.67) 169.95,242.67 170.92,241.7 v2(170.92,241.4)
UCD90160_SHUTDOWN_WAKE: length 198.1
  TOP w0.127: P1.B15 v4(95.29,224.46)
  TOP w0.254: v1(230.86,214.14) 230.86,214.08 231.08,214.31 U7.41
  S14 w0.127: v4(95.29,224.46) 95.29,225.2 91.86,228.63 91.25,228.63 88.93,230.95 88.93,238.73 104.14,253.95 132.86,253.95 133.52,254.61 138.46,254.61 139.01,254.05 153.05,254.05 157.04,250.06 160.72,250.06 168.75,242.03 170.53,242.03 171.48,241.08 171.48,238.35 173.38,236.45 175.35,236.45 180.43,241.53 191.48,241.53 193.89,239.11 195.42,239.11 197.2,237.34 205.2,237.34 206.09,236.45 208.37,236.45 210.79,234.03 219.29,234.03 222.85,230.48 222.85,227.68 223.36,227.18 223.36,219.94 226.28,217.02 226.28,215.11 227.25,214.14 v1(230.86,214.14)
  BOTTOM w0.127: v1(230.86,214.14) 231.85,214.14 v2(231.87,214.16)
UCD90160_TRST_LR: length 4.7
  TOP w0.127: R167.2 228.8,213.18 v1(229.14,213.52) 229.8,214.18 230.16,214.18 230.58,214.59 U7.40
  BOTTOM w0.127: v1(229.14,213.52) 228.95,213.71 v2(228.95,214.73)
UCD90160_VCC3P3_R: length 4.8
  TOP w0.127: CONN41.5 v1(35.57,248.38)
  BOTTOM w0.127: v2(35.6,249.3) 35.6,248.41 v1(35.57,248.38) 35.6,248.35 R720.2
USB0_N: length 49.9
  TOP w0.127: J2.A45 165.94,140.52 166.05,140.63 166.05,141.78 166.45,142.18 166.85,142.18 v3(167.1,142.43) ; U24.30 203.2,127.32 203.1,127.22 202.9,127.22 202.66,127.47 202.44,127.47 v3(202.17,127.74)
  S9 w0.14: v3(202.17,127.74) 201.94,127.52 201.08,127.52 arc(200.81,127.57) 200.59,127.72 200.28,128.03 arc(199.89,128.29) 199.42,128.38 191.68,128.38 arc(191.06,128.5) 190.54,128.86 180.66,138.74 180.4,138.99 arc(179.59,139.53) 178.63,139.72 170.81,139.72 arc(170.7,139.74) 170.61,139.81 168.5,141.91 arc(168.24,142.09) 167.93,142.15 167.38,142.15 v3(167.1,142.43)
  BOTTOM w0.127: RB135.2 199.9,126.45 199.9,126.95 200.43,127.48 201.9,127.48 v3(202.17,127.74)
USB0_P: length 50
  TOP w0.127: J2.A46 166.44,140.52 166.36,140.6 166.36,141.65 166.58,141.87 166.85,141.87 v3(167.1,141.62) ; v3(202.17,126.93) 202.4,127.16 202.53,127.16 202.77,126.92 203.09,126.92 203.19,126.82 U24.31
  S9 w0.14: v3(202.17,126.93) 201.88,127.21 201.08,127.21 arc(200.69,127.29) 200.37,127.5 200.06,127.81 arc(199.77,128.01) 199.42,128.08 191.68,128.08 arc(190.94,128.22) 190.32,128.64 180.44,138.52 180.19,138.78 arc(179.47,139.25) 178.63,139.42 170.81,139.42 arc(170.59,139.46) 170.39,139.59 170.33,139.65 arc(170.17,139.72) 170,139.65 arc(169.83,139.58) 169.66,139.65 169.54,139.77 arc(169.47,139.94) 169.54,140.11 arc(169.61,140.28) 169.54,140.45 169.42,140.57 arc(169.25,140.64) 169.08,140.57 arc(168.91,140.5) 168.74,140.57 168.62,140.69 arc(168.55,140.86) 168.62,141.03 arc(168.69,141.19) 168.62,141.36 168.29,141.7 arc(168.12,141.81) 167.93,141.85 167.33,141.85 v3(167.1,141.62)
  BOTTOM w0.127: v3(202.17,126.93) 201.92,127.18 200.56,127.18 200.21,126.82 200.21,126.45 RB134.2
USB1_PWRFAULT: length 148.6
  TOP w0.127: P1.N14 v4(107.29,223.46) ; J2.B44 v1(165.44,146.29)
  S12 w0.127: v1(157.65,204.19) 158.7,204.19 175.86,187.02 175.86,165.69 169.54,159.37 169.54,157.56 166.54,154.55 166.54,149.53 165.47,148.47 165.47,146.32 v1(165.44,146.29)
  S14 w0.127: v4(107.29,223.46) 107.84,224.01 107.84,228.83 107.97,228.95 114.65,228.95 115.15,229.46 115.15,231.05 116.36,232.26 119.98,232.26 121.89,234.16 124.17,234.16 125.5,232.83 133.32,232.83 136.55,229.59 136.55,228.19 141.3,223.44 143.71,223.44 151.98,215.18 151.98,208.83 156.62,204.19 v1(157.65,204.19)
  BOTTOM w0.127: v2(157.66,203.29) 157.65,203.3 v1(157.65,204.19)
USB1_VBUS_RESET: length 141.5
  TOP w0.127: J2.A93 189.94,140.39 v1(189.39,140.94) ; P1.AB10 v4(116.29,218.46)
  S14 w0.127: v1(189.39,140.94) 188.06,139.61 180.92,139.61 177.15,143.38 175.72,143.38 175.46,143.13 175.17,143.13 171.35,146.95 171.35,156.14 172.54,157.33 172.54,170.58 171.35,171.76 171.35,178.72 172.43,179.8 172.43,184.54 163.01,193.96 153.13,193.96 144.81,202.28 140.39,202.28 137.27,205.39 131.79,205.39 130.9,206.28 125.01,206.28 123.03,208.27 123.03,211.87 122.93,211.97 122.93,211.98 122.4,212.51 121.93,212.51 121.12,213.31 121.12,214.09 119.41,215.81 118.01,215.81 117.41,216.41 117.41,216.41 116.29,217.54 v4(116.29,218.46)
  BOTTOM w0.127: R1493.2 191.29,142.85 v2(190.15,141.7) v1(189.39,140.94)
USB2_N: length 121.1
  TOP w0.127: v3(173.21,132.56) 173.46,132.81 173.46,134.74 171.06,137.14 165.22,137.14 164.54,137.83 164.54,138.92 164.44,139.02 J2.A42 ; U71.7 231.95,187.8 232.04,187.9 232.04,188.58 v1(231.66,188.97)
  S12 w0.14: v1(231.66,188.97) 232.04,188.58 232.04,188.16 231.49,187.61 224.24,187.61 220.89,184.26 220.89,150.21 219.17,148.48 219.17,148.46 218.81,148.11 218.81,148.06 207.3,136.55 199.47,136.55 194.81,131.89 183.77,131.89 182.09,133.57 173.81,133.57 173.46,133.22 173.46,132.81 v3(173.21,132.56)
USB2_P: length 121.1
  TOP w0.127: v1(232.73,188.97) 232.35,188.58 232.35,187.93 232.45,187.84 U71.8 ; J2.A43 164.94,139.02 164.84,138.92 164.84,137.96 165.35,137.45 171.19,137.45 173.76,134.87 173.76,132.81 v3(174.02,132.56)
  S12 w0.14: v3(174.02,132.56) 173.76,132.81 173.76,133.1 173.93,133.26 181.96,133.26 183.64,131.58 194.94,131.58 199.6,136.24 207.43,136.24 219.12,147.93 219.12,147.98 219.47,148.33 219.47,148.36 221.2,150.09 221.2,184.14 224.37,187.31 231.62,187.31 232.35,188.03 232.35,188.58 v1(232.73,188.97)
USB5V_GPS_ANT: length 5.3
  TOP w0.508: R754.2 203.07,97.41 v1(202.85,97.64) ; 202.15,97.57 202.14,97.56 C441.1 ; 200.12,97.44 200.11,97.44 C433.1 ; C437.1 201.12,97.5 201.13,97.51
  BOTTOM w0.127: v2(201.51,97.57) 202.78,97.57 v1(202.85,97.64)
USB HUB_GND: length 1.9
  BOTTOM w0.508: v2(93.12,24.11) 93.51,23.72 93.51,23.01 v1(93.57,22.94) ; 93.18,21.44 LB82.1
  vias: v1(85.44,24.93) v1(85.5,23.98) v1(92.66,22.98)
USB_CHASSIS: length 1.9
  BOTTOM w0.508: v2(86.64,31.09) 86.64,30.39 86.26,30.01 ; CB938.1 87.8,29.47
USB_DM: length 253.1
  TOP w0.127: v3(204.67,118.92) 204.98,119.23 204.98,119.62 204.98,119.88 R437.1
  S12 w0.14: v1(89.96,23.59) 89.66,23.3 89.66,23.02 90.4,22.28 93.32,22.28 96.43,19.17 197.28,19.17 224.7,46.59 224.7,69.01 217.39,76.33 217.39,79.68 209.92,87.15 209.92,102.26 207.1,105.08 207.1,113.08 205.02,115.16 205.02,116.5 arc(204.92,116.74) 204.68,116.84 arc(204.44,116.94) 204.34,117.18 204.34,117.19 arc(204.44,117.44) 204.68,117.54 arc(204.92,117.64) 205.02,117.88 205.02,118.56 v3(204.67,118.92)
  BOTTOM w0.127: v1(89.96,23.59) 90.29,23.26 LB81.2 89.78,22.74 89.66,22.61 89.66,21.9 90,21.55 90,20.67 RB686.1 CB959.1 90.01,18.97 90.01,18.17 89.39,17.55 89.39,16.87 89.51,16.74 90.11,16.74 90.23,16.61 CONNB2.2 ; RB135.1 199.9,124.83 199.9,123.99 200.34,123.56 203.74,123.56 204.97,122.32 204.97,119.22 v3(204.67,118.92)
USB_DP: length 253.1
  TOP w0.127: R433.1 205.29,119.72 205.29,119.62 205.29,119.11 v3(205.48,118.92)
  S12 w0.14: v3(205.48,118.92) 205.32,118.76 205.32,115.29 207.41,113.21 207.41,105.2 210.22,102.39 210.22,87.27 217.69,79.8 217.69,76.45 225.01,69.14 225.01,46.47 197.41,18.87 96.31,18.87 93.2,21.98 90.27,21.98 89.36,22.9 89.36,23.33 v1(89.1,23.59)
  BOTTOM w0.127: RB134.1 200.21,124.83 200.21,124.12 200.46,123.86 203.86,123.86 205.27,122.45 205.27,119.12 v3(205.48,118.92) ; v1(89.1,23.59) 89.1,23.56 88.77,23.23 LB80.2 89.25,22.74 89.35,22.63 89.35,21.77 89.69,21.43 89.69,20.67 RB685.2 CB958.2 89.71,18.95 89.71,18.3 89.08,17.67 89.08,16.87 88.96,16.74 88.36,16.74 88.23,16.61 CONNB2.3
USB_ILIM: length 7.3
  BOTTOM w0.127: v2(98.52,28.8) 98.52,27.09 99.27,26.34 101.06,26.34 RB668.2 102.02,26.81 102.47,27.26 UB14.2
USB_ILIM_R: length 5.2
  BOTTOM w0.127: RB667.2 99.73,27.72 99.28,28.17 99.28,29.94 99.91,30.58 v2(99.98,30.58)
  BOTTOM w0.508: RB668.1 RB667.2
USB_PWRFLT_N: length 424.3
  TOP w0.127: v1(214.03,124.78) 214.02,124.8 R342.2 ; P1.T13 v4(110.29,222.46)
  S12 w0.127: v1(101.48,29.5) 101.95,29.04 101.95,22.6 104.58,19.96 196.72,19.96 223.87,47.11 223.87,67.22 217.34,73.74 214.68,73.74 213.79,74.64 213.79,80.66 209.2,85.25 209.2,100.3 205.48,104.02 205.48,113.65 202.02,117.1 202.02,119.31 202.58,119.87 204,119.87 207.42,123.29 214.46,123.29 214.72,123.56 214.72,124.09 v1(214.03,124.78)
  S14 w0.127: v1(214.03,124.78) 215.48,126.22 215.48,131.53 211.97,135.04 193.96,135.04 191.99,137.01 191.99,141.89 188.19,145.69 185,145.69 182.77,147.93 182.77,150.23 179.42,153.58 176.94,153.58 176.09,154.43 176.09,157.24 175.61,157.72 175.61,157.73 175.42,157.92 175.42,184.69 175.42,185.11 163.86,196.66 155.18,196.66 146.44,205.39 146.44,205.41 146.26,205.59 146.26,212.46 141,217.71 131.83,217.71 130.57,218.97 128.32,218.97 125.79,221.51 124.47,221.51 123.42,220.45 120.86,220.45 118.84,222.48 117.5,222.48 116.04,221.02 111.73,221.02 110.29,222.45 v4(110.29,222.46)
  BOTTOM w0.127: UB14.3 102.36,27.91 RB659.1 v1(101.48,29.5) 101.48,30.05 v2(102.14,30.71)
USB_PWRON_N: length 416.6
  TOP w0.127: P1.Y13 v4(114.29,222.46) ; R343.1 v1(213.91,123.78)
  S12 w0.127: v1(213.91,123.78) 207.3,123.78 203.77,120.26 202.41,120.26 201.58,119.43 201.58,117.17 205.12,113.63 205.12,103.68 208.94,99.86 208.94,78.39 214.02,73.31 217.38,73.31 223.61,67.08 223.61,47.21 196.61,20.22 104.69,20.22 102.33,22.58 102.33,24.64 106.39,28.7 v1(107.28,28.7)
  S14 w0.127: v1(213.91,123.78) 215.8,125.67 215.8,131.86 212.31,135.35 194.06,135.35 192.28,137.13 192.28,142.53 189.87,144.94 189.87,145.96 188.9,146.93 187.32,146.93 177.43,156.82 176.88,156.82 175.7,158 175.7,185.2 163.98,196.91 155.78,196.91 146.56,206.14 146.56,212.57 141.1,218.03 132.28,218.03 131.09,219.23 128.43,219.23 125.89,221.76 125.89,221.76 125.74,221.9 124.24,221.9 123.9,221.56 121.97,221.56 120.72,222.82 117.34,222.82 116.51,221.99 114.75,221.99 v4(114.29,222.46)
  BOTTOM w0.127: v2(107.22,29.82) 107.28,29.75 v1(107.28,28.7) 106.49,27.91 UB14.4
USB_RESET_N: length 168
  TOP w0.127: P1.R11 v4(109.29,219.46) ; U24.26 205.36,130.11 204.63,130.84 203.89,130.84 203.65,131.09 203.65,131.89 R443.2 v1(202.75,131.89)
  S14 w0.127: v4(109.29,219.46) 109.34,219.46 109.95,218.86 116.49,218.86 116.68,218.67 116.68,218.63 116.68,218.62 116.68,217.47 117.44,216.71 117.83,216.71 118.22,216.32 119.92,216.32 121.63,214.6 121.63,213.52 122.14,213.01 122.65,213.01 123.6,212.06 123.6,208.42 125.23,206.79 131.11,206.79 131.24,206.66 137,206.66 140.81,202.85 145.03,202.85 153.39,194.49 163.23,194.49 172.98,184.74 172.98,179.21 171.86,178.09 171.86,172.44 173.37,170.93 173.37,157.15 172.75,156.52 172.75,148.67 175.54,145.87 177.22,145.87 179.23,143.86 179.23,142.02 181.11,140.14 187.39,140.14 188.89,141.64 189.58,141.64 189.99,141.23 189.99,135.28 192.01,133.26 199.62,133.26 200.98,131.89 v1(202.75,131.89)
  BOTTOM w0.127: v2(202.66,132.81) 202.66,131.99 v1(202.75,131.89)
USB_VBUS: length 241.5
  TOP w0.508: R453.2 200.58,132.33 C240.2 200.13,132.33 v1(199.66,131.86)
  S12 w0.508: v1(102.81,23.42) 106.57,23.42 109.24,20.75 196.45,20.75 222.98,47.28 222.98,66.9 217.58,72.3 212.68,72.3 210.73,74.25 210.73,75.14 208.5,77.38 208.5,99.54 204.56,103.48 204.56,113.38 201.01,116.94 201.01,125.58 198.78,127.8 198.78,130.98 v1(199.66,131.86)
  BOTTOM w0.127: v2(96.36,28.8) 96.36,27.91 99.03,25.25 101.12,25.25
  BOTTOM w0.254: 102.82,26.03 102.82,26.43 103,26.61 UB14.1
  BOTTOM w0.508: 101.48,25.38 101.48,25.39 CB952.1 102.42,25.87
USB_VCC5P0: length 48.5
  TOP w0.127: C511.1 237.75,103.44
  TOP w0.381: v1(91.41,100.81) 91.15,101.06 C444.1 ; v1(120.74,136.05) 120.74,135.98 120.72,135.95 C205.1 ; C439.1 91.41,102.08 ; R5.1 v1(233.11,233.93)
  TOP w0.508: 197.11,97.94 CB708.1 196.45,97.46 ; v1(119.85,136.05) 119.7,135.9 C207.1 ; C512.1 237.27,96.3 237.26,96.3 ; 197.23,98.96 CB707.1
  S9 w0.381: v1(233.11,233.93) 233.11,233.03 233.57,232.57 246.09,232.57 v1(251.36,237.84)
  S12 w0.381: 69.64,233.44 CONN6.13 ; CONN6.13 70.97,232.1 ; CONN6.13 70.97,234.77 ; CONN6.13 72.31,233.44
  S14 w0.381: 70.97,232.1 CONN6.13 ; CONN6.13 69.64,233.44 ; CONN6.13 70.97,234.77
  BOTTOM w0.254: UB14.6 107.31,26.61 v1(107.34,26.64) ; v2(120.63,121.74) 120.91,122.02 v1(121.36,122.02) ; v1(121.4,123.39) 120.65,123.39 v2(120.4,123.63) ; 70.96,237.65 70.96,237.4 v1(70.7,237.14)
  BOTTOM w0.381: CONN6.13 70.97,234.77 ; CONN6.13 69.64,233.44 ; CONN6.13 70.97,232.1
  BOTTOM w0.508: 106.99,24.92 CB957.2 106.36,25.52 106.57,25.73 ; CB38.1 70.96,237.65
  vias: v1(69.43,232.64) v1(69.56,237.14) v1(69.56,235.94) v1(69.56,234.8) v1(70.7,235.94) v1(70.96,231.56) v1(71.85,237.14) v1(71.85,235.94) v1(71.85,234.8) v1(92.29,101.57) v1(92.29,100.81) v1(93.12,101.64) v1(107.34,25.69) v1(108.11,26.64) v1(108.11,25.69) v1(119.92,137.7) v1(119.92,136.88) v1(120.81,137.64) v1(120.81,136.88) v1(199.36,101.83) v1(199.36,101.06) v1(199.36,100.3) v1(200.37,101.83) v1(200.37,101.06) v1(200.37,100.3) v1(236.53,104.05) v1(236.54,103.32) v1(236.54,102.64) v2(109.18,27.69)
USB_VCC5P0_MON: length 12
  TOP w0.254: v1(233.9,223.11) 233.58,223.43 U7.3 233.58,225.49 233.11,225.95 C20.1 233.4,226.66 233.73,226.99 233.73,228.51 R16.1 232.61,229.12 232.33,229.4 232.33,231.46 R5.2
  BOTTOM w0.127: v2(234.79,223.11) v1(233.9,223.11)
USBHUB_CFG_SEL1: length 4.7
  TOP w0.127: R439.1 R435.2 205.68,130.72 v1(205.59,130.64) 205.86,130.37 U24.25
  BOTTOM w0.127: v1(205.59,130.64) 205.59,130.7 v2(204.94,131.35)
USBHUB_CRFILT: length 5.2
  TOP w0.127: C189.2 C190.2 212,125.81 v1(211.46,126.35) 211.44,126.32 U24.14
  BOTTOM w0.127: v1(211.46,126.35) 212.68,126.35 v2(212.94,126.08)
USBHUB_DM: length 2.5
  TOP w0.127: R437.2 205.11,121.46 205.11,121.81 204.96,121.95 204.96,122.5 204.86,122.6 U24.1
USBHUB_DP: length 2.5
  TOP w0.127: R433.2 205.41,121.37 205.41,121.93 205.27,122.08 205.27,122.52 205.36,122.62 U24.2
USBHUB_NON_REM0: length 5
  TOP w0.127: U24.28 203.39,128.32 v1(202.44,129.28) R455.1
  BOTTOM w0.127: v2(200.5,128.5) 201.28,129.28 v1(202.44,129.28)
USBHUB_OCS1_N: length 4.2
  TOP w0.127: R342.1 212.07,124.8 211.05,125.82 v1(211.01,125.82) U24.13
  BOTTOM w0.127: v2(209.77,125.58) 210.76,125.58 v1(211.01,125.82)
USBHUB_OCS2_N: length 4.5
  TOP w0.127: R340.2 v1(211.28,128.86) 210.74,128.33 210.74,127.97 210.59,127.82 U24.17
  BOTTOM w0.127: v1(211.28,128.86) 211.8,129.39 v2(212.5,129.39)
USBHUB_OCS3_N: length 9.7
  TOP w0.127: R356.2 213.13,131.76 213.13,130.85 212.37,130.08 v1(211.86,130.08) 210.85,130.08 210.4,129.64 209.64,129.64 209.39,129.89 208.94,129.89 208.86,129.81 U24.19
  BOTTOM w0.127: v1(211.86,130.08) v2(214.21,132.43)
USBHUB_OCS4_N: length 8.3
  TOP w0.127: U24.21 207.86,129.92 208.16,130.21 209.52,130.21 209.71,130.02 210.21,130.02 210.66,130.46 211.48,130.46 v1(211.93,130.91) 212.14,131.12 R384.2
  BOTTOM w0.127: v2(212.25,132.88) 212.25,131.23 v1(211.93,130.91)
USBHUB_PLLFILT: length 6.2
  TOP w0.127: U24.34 203.33,125.32 202.55,124.53 202.55,124.09 202.24,123.78 C237.2 C238.2 201.89,122.76 202.38,122.27 v1(202.38,122.21)
  BOTTOM w0.127: v1(202.38,122.21) 202.26,122.08 v2(201.2,122.08)
USBHUB_PRIAS: length 7
  TOP w0.127: R456.1 201.86,121.62 202.98,121.62 203.23,121.87 v1(203.23,122.13) 203.28,122.17 203.28,122.79 203.05,123.02 203.05,124.54 203.33,124.82 U24.35
  BOTTOM w0.127: v1(203.23,122.13) 203.23,121.96 203.55,121.65 203.55,120.94 v2(203.36,120.75)
USBHUB_PRTPWR1: length 4.6
  TOP w0.127: U24.12 211.03,125.32 211.56,124.78 v1(211.56,124.38) 211.66,124.38 R343.2
  BOTTOM w0.127: v1(211.56,124.38) 211.67,124.38 v2(212.56,123.48)
USBHUB_SCL: length 156.3
  TOP w0.127: R297.1 154.06,212.91 v1(154.03,212.88) ; v1(207.17,131.04) 207.23,131.04 207.61,131.42 207.61,131.86 R424.2 R428.1 206.36,131.56 U24.24
  S14 w0.127: v1(217.97,138.08) 210.91,145.14 210.91,147.41 207.94,150.38 207.94,151.42 207.42,151.94 207.42,168.9 207.42,169.63 211.2,173.42 211.2,199.97 211.15,200.03 211.15,200.14 206.56,204.73 177.98,204.73 174.86,201.62 166.6,201.62 165.32,202.9 161.34,202.9 154.03,210.2 v1(154.03,212.88)
  BOTTOM w0.127: v1(207.17,131.04) 208.63,132.5 208.63,132.96 210.44,134.77 214.66,134.77 v1(217.97,138.08) ; v2(153.19,211.24) 154.03,212.08 v1(154.03,212.88)
USBHUB_SCL_R: length 8.4
  TOP w0.127: U10.14 153.65,218.87 153.51,218.73 153.51,216.63 153.72,216.43 R296.2 v1(154.06,215.62) R297.2
  BOTTOM w0.127: v1(154.06,215.62) 154.06,216.85 v2(153.76,217.14)
USBHUB_SDA: length 145.5
  TOP w0.127: v1(210.15,147.17) 215.59,141.73 215.59,138.76 211.12,134.3 R390.1 210.13,132.71 R391.2 ; R309.1 v1(152.79,212.94)
  S14 w0.127: v1(152.79,212.94) 152.79,209.19 156.56,205.41 157.35,205.41 160.76,202.01 164.95,202.01 166.23,200.73 175.64,200.73 178.57,203.66 206.37,203.66 210.26,199.77 210.26,173.74 206.45,169.93 206.45,151.65 207.05,151.05 207.05,149.19 209.07,147.17 v1(210.15,147.17)
  BOTTOM w0.127: v1(152.79,212.94) 152.74,212.89 v2(151.73,212.89)
USBHUB_SDA_R: length 8.4
  TOP w0.127: R309.2 v1(152.79,215.62) R308.2 152.32,216.43 152.16,216.58 152.16,218.42 153,219.26 U10.13
  BOTTOM w0.127: v2(151.6,215.43) 151.79,215.62 v1(152.79,215.62)
USBHUB_VBUS_DET: length 6.8
  TOP w0.127: R453.1 201.49,130.34 R449.2 202.42,130.29 v1(202.47,130.34) 202.51,130.38 204.41,130.38 204.86,129.93 U24.27
  BOTTOM w0.127: v2(201.2,131.1) 201.96,130.34 v1(202.47,130.34)
USBHUB_XTALIN: length 7.3
  TOP w0.127: U24.33 203.14,125.82 202.17,124.85 R454.1 201,124.85 200.95,124.8 C245.1 200.46,124.62 199.9,124.05 198.73,124.05 X1.3
USBHUB_XTALOUT: length 3.7
  TOP w0.127: R459.2 201.1,125.81 201.15,125.76 R454.2 202.4,125.76 202.96,126.32 U24.32
USBHUB_XTALOUT_C: length 5.9
  TOP w0.127: X1.1 196.18,127.38 196.38,127.57 199.38,127.57 199.55,127.4 C244.1 R459.1
VEN_CPLD_VDD1P8: length 255.7
  TOP w0.127: U7.14 228.08,224.57 227.32,225.32 v1(227.32,225.8) ; CONN5.6 v1(9.3,230.54)
  S9 w0.254: v1(9.3,230.54) 9.21,230.54 7.36,232.38 7.36,239.97 9.8,242.41 18.76,251.36 83.63,251.36 87.37,255.1 106.71,255.1 109.31,252.51 132.44,252.51 133.07,251.88 135.91,251.88 136.29,251.5 157.7,251.5 158.59,250.61 162.34,250.61 163.61,251.88 201.53,251.88 218.99,234.41 219.7,234.41 227.32,226.79 v1(227.32,225.8)
  BOTTOM w0.127: v1(227.32,225.8) 226.85,226.28 v2(226.85,226.86)
VEN_FPGA_1V2: length 282.3
  TOP w0.127: CONN5.1 v1(14.38,228)
  TOP w0.254: v1(229.6,224.85) 228.82,224.85 228.58,224.61 U7.13
  S9 w0.254: v1(229.6,224.85) 229.44,225.01 229.44,228.34 228.36,229.43 227.53,229.43 226.92,230.05 226.92,231.25 222.58,235.59 222.58,242.56 221.44,243.7 213.42,243.7 203.02,254.1 175.71,254.1 174.57,255.24 162.18,255.24 160.98,254.04 139.22,254.04 138.27,254.99 111.7,254.99 108.16,258.53 85.4,258.53 80.69,253.82 17.46,253.82 4.71,241.07 4.71,230.36 7.84,227.24 13.62,227.24 14.38,228 v1(14.38,228)
  BOTTOM w0.127: v2(229.77,226.48) 229.6,226.3 v1(229.6,224.85)
VEN_FPGA_2V5: length 255.3
  TOP w0.127: CONN5.8 v1(9.3,231.81)
  TOP w0.254: v1(228.08,223.14) 228.79,223.14 229.08,223.43 U7.12
  S9 w0.254: v1(228.08,223.14) 225.68,225.53 225.68,227.62 219.33,233.97 218.86,233.97 201.46,251.37 165.32,251.37 164.05,250.1 158.33,250.1 157.32,251.11 136.11,251.11 135.73,251.5 109.1,251.5 106,254.6 87.67,254.6 83.91,250.84 18.99,250.84 10.03,241.87 7.9,239.75 7.9,233.21 v1(9.3,231.81)
  BOTTOM w0.127: v2(227.04,223.87) 227.35,223.87 v1(228.08,223.14)
VEN_MANG_1P2: length 281.5
  TOP w0.127: CONN5.3 v1(14.38,229.27)
  TOP w0.254: U7.39 230.08,215.78 v1(229.98,215.88)
  S9 w0.254: v1(229.98,215.88) 229.39,215.88 228.09,217.18 228.09,222.13 228.96,222.99 228.96,223.98 228.21,224.73 228.21,226.44 225.66,228.98 225.66,231.11 220.96,235.81 219.5,235.81 202.1,253.21 175.31,253.21 174.29,254.23 162.39,254.23 161.31,253.15 136.81,253.15 135.86,254.1 110.86,254.1 107.69,257.26 86.23,257.26 81.88,252.91 17.94,252.91 9.11,244.08 5.69,240.66 5.69,230.77 7.76,228.7 13.81,228.7 v1(14.38,229.27)
  BOTTOM w0.127: v1(229.98,215.88) 230.47,216.37 v2(230.47,216.82)
VEN_MANG_2P5: length 99.8
  TOP w0.127: R1065.2 225.75,138.3 214.34,149.71 v1(214.34,152.25) ; U7.22 225.38,220.74 225.36,220.76 v1(225.21,220.76)
  S12 w0.127: v1(225.21,220.76) 226.09,220.76 227.74,219.11 227.74,216.57 228.65,215.66 228.65,212.35 229.14,211.87 229.14,210.28 228.31,209.46 228.31,199.63 226.86,198.18 225.24,198.18 218.04,190.98 218.04,175.97 219.01,175.01 219.01,171.2 218.28,170.47 218.28,156.19 v1(214.34,152.25)
  BOTTOM w0.127: v1(225.21,220.76) 225.78,221.33 v2(226.15,221.33)
VEN_USB_VCC5P0: length 269.1
  TOP w0.127: CONN5.2 v1(9.3,228)
  TOP w0.254: U7.11 v1(229.58,223.19)
  S9 w0.254: v1(229.58,223.19) 229.53,223.23 229.53,224.06 228.79,224.8 228.79,226.43 226.21,229.01 226.21,231.25 221.17,236.29 220.1,236.29 202.67,253.72 175.49,253.72 174.47,254.73 162.23,254.73 161.09,253.59 138.78,253.59 137.89,254.48 111.29,254.48 107.81,257.96 85.85,257.96 81.29,253.41 17.65,253.41 8.88,244.64 5.14,240.89 5.14,230.54 7.8,227.87 9.17,227.87 v1(9.3,228)
  BOTTOM w0.127: v1(229.58,223.19) 228.95,223.82 v2(228.95,223.87)
VEN_VCC5P0: length 6.8
  TOP w0.127: U7.20 225.6,221.74 225.51,221.83 224.83,221.83 v1(224.37,222.29) 224.37,222.98 223.6,223.76 RB766.2
  BOTTOM w0.127: v2(222.22,221.71) 223.8,221.71 v1(224.37,222.29)
VEN_VCC5P0_FPGA: length 209
  TOP w0.127: R673.2 241.74,162.82 v1(241.52,163.04)
  TOP w0.254: P1.AB9 v1(117.56,217.96)
  TOP w0.508: RB766.1 v1(221.31,223.76)
  S9 w0.254: v1(221.31,223.76) 219.99,222.45 219.99,222.03 218.91,220.95 218.91,214.35 218.34,213.78 206.85,213.78 202.2,209.13 196.85,209.13 195.91,208.19 178.41,208.19 178.08,208.52 171.41,208.52 170.41,207.52 170.11,207.52 165.32,202.73 v1(136.05,202.73)
  S12 w0.254: v1(117.56,217.96) 120.12,217.96 120.55,217.52 120.55,207.43 121.94,206.04 123.97,206.04 124.27,206.35 131.47,206.35 135.09,202.73 v1(136.05,202.73)
  S14 w0.127: v1(221.31,223.76) 220.69,223.15 220.69,216.13 219.9,215.34 219.9,208.68 220.18,208.4 220.18,177.52 233.26,164.44 240.12,164.44 v1(241.52,163.04)
  BOTTOM w0.127: v2(222.71,224.65) 222.19,224.65 v1(221.31,223.76)
VEN_VCC5P0_R: length 7.7
  TOP w0.508: R671.2 R673.1 241.74,161.34 R672.2 C355.1 243.85,161.41 244.66,161.41 v1(245.2,161.95) U34.7
  BOTTOM w0.254: v1(245.2,161.95) 244.76,161.51 v2(244.05,161.51)
VEN_VDD0P6: length 188.4
  TOP w0.203: R64.2 65.61,193.03 v1(65.5,193.14)
  TOP w0.254: v1(225.04,223.28) 225.28,223.28 225.82,222.74 U7.18
  S9 w0.203: v1(131.55,193.31) 131.55,193.32 131.98,192.89 134.36,192.89 134.66,193.19 139.7,193.19 143.28,196.77 168.72,196.77 174.31,202.36 176.24,202.36 179.24,205.36 191.42,205.36 192.46,204.32 197.38,204.32 197.57,204.13 209.03,204.13 214.42,209.52 223.36,209.52 v1(224.06,208.82)
  S12 w0.254: v1(224.06,208.82) 224.06,209.96 223.21,210.81 223.21,222.05 224.43,223.28 v1(225.04,223.28)
  S16 w0.203: v1(65.5,193.14) 66.2,193.84 131.03,193.84 131.55,193.32 v1(131.55,193.31)
  BOTTOM w0.127: v2(223.8,223.05) 224.81,223.05 v1(225.04,223.28) ; v1(224.06,208.82) 224.37,209.14 v2(225.2,209.14)
VEN_VDD1P0: length 213.8
  TOP w0.254: v1(227.15,217.02) 226.87,216.74 U7.30
  TOP w0.508: v1(110.53,95.98) 110.46,96.06 R779.1
  S12 w0.254: v1(227.15,217.02) 227.19,216.97 226.51,216.29 226.51,209.67 227.42,208.76 227.42,203.59 220.11,196.28 220.11,194.41 217.24,191.53 217.24,156.76 213.02,152.55 213.02,148.99 210.39,146.35 197.72,146.35 195.77,144.41 195.77,140.18 195.37,139.77 194.52,139.77 194.05,139.31 194.05,137.3 193.12,136.37 191.11,136.37 190.16,135.41 171.56,135.41 169.9,133.76 164.46,133.76 163.22,134.99 154.98,134.99 151.34,131.35 148.46,131.35 144.62,127.5 140.58,127.5 140.05,126.97 134.43,126.97 122.22,114.77 122.22,111.18 119.28,108.24 119.28,99.73 116.55,97 110.96,97 110.53,96.57 v1(110.53,95.98)
  BOTTOM w0.127: v1(227.15,217.02) 227.27,217.14 v2(228.06,217.14)
VEN_VDD1P0_ROV: length 174.5
  TOP w0.127: v1(121.39,124.89) 120.96,125.32 R591.1
  TOP w0.203: U7.34 227.58,214.63 227.3,214.35 225.58,214.35 v1(225.44,214.21)
  S12 w0.254: v1(121.39,124.89) 124.51,124.89 135.79,136.18 145.3,136.18 145.62,135.86 146.96,135.86 149.66,138.56 152.23,138.56 153.23,137.56 168.91,137.56 169.46,138.11 174.77,138.11 176.33,139.67 186.88,139.67 188.07,140.86 188.07,143.76 190.87,146.56 190.87,148.38 194.17,151.68 201.73,151.68 213.33,163.28 213.33,199.11 218.47,204.25 221.9,204.25 225.33,207.68 225.33,214.09 v1(225.44,214.21)
  BOTTOM w0.127: v1(225.44,214.21) 225.45,214.22 v2(226.72,214.22)
VEN_VDD1P2_DDR: length 156.7
  TOP w0.127: R592.1 v1(126.84,171.11)
  TOP w0.254: U7.17 226.08,223.24 225.25,224.08 v1(224.32,224.08)
  S9 w0.254: v1(126.84,171.11) 129.32,168.63 134.08,168.63 136.02,166.68 141.37,166.68 144.16,169.47 146.32,169.47 146.98,170.13 150.89,170.13 151.51,169.5 160.14,169.5 162.55,167.1 166.73,167.1 168.13,168.5 209.99,168.5 v1(209.99,168.5)
  S12 w0.254: v1(224.32,224.08) 222.46,222.21 222.46,210.66 222.98,210.14 222.98,208.52 222.71,208.25 220.82,208.25 212.44,199.87 212.44,170.95 v1(209.99,168.5)
  BOTTOM w0.305: v1(126.84,171.11) 127.92,170.03 v2(128.62,170.03)
VEN_VDD1P8: length 169.5
  TOP w0.254: v1(225.33,216.95) 225.62,217.24 U7.29
  TOP w0.381: R344.2 v1(122.68,136.88)
  S12 w0.254: v1(122.68,136.88) 123.23,136.32 133.32,136.32 134.95,137.96 144.25,137.96 145.42,139.13 152.59,139.13 153.78,137.94 167.59,137.94 168.95,139.3 175.36,139.3 176.21,140.15 186.75,140.15 187.66,141.06 187.66,144.29 190.36,147 190.36,148.59 194.02,152.25 201.7,152.25 212.88,163.42 212.88,199.55 217.96,204.63 221.64,204.63 224.88,207.87 224.88,216.51 v1(225.33,216.95)
  BOTTOM w0.127: v2(225.71,216) 225.33,216.38 v1(225.33,216.95)
VEN_VDD1P8_R: length 5.4
  TOP w0.254: v1(121.73,138.64) U23.11
  TOP w0.381: R344.1 123.64,137.83 R338.2 C194.1 121.82,138.72 v1(121.73,138.64)
  BOTTOM w0.254: v1(121.73,138.64) 120.61,138.64 v2(120.54,138.71)
VEN_VDD1P25: length 228.4
  TOP w0.127: v1(88.97,98.6) 89.42,98.14 R772.2
  TOP w0.254: U7.19 225.41,222.24 v1(225.22,222.44)
  S12 w0.254: v1(88.97,98.6) 89.47,98.6 89.88,99.01 89.88,101.7 96.87,108.68 107.53,108.68 109.19,110.34 115.47,110.34 134.15,129.01 136.88,129.01 137.31,128.58 144.01,128.58 148.23,132.8 151.05,132.8 154.28,136.03 169.83,136.03 170.32,136.53 175.77,136.53 175.97,136.73 188.14,136.73 191.03,139.61 191.03,143.69 195.12,147.78 200.29,147.78 209.01,156.5 212.09,156.5 215.96,160.37 215.96,192.45 218.46,194.95 218.46,196.44 225.18,203.15 225.18,204.36 227.04,206.23 227.04,208.38 226.12,209.3 226.12,217.68 224.25,219.56 224.25,220.95 225.22,221.92 v1(225.22,222.44)
  BOTTOM w0.127: v2(89.98,98.91) 89.68,98.6 v1(88.97,98.6)
VEN_VDD1P25_R: length 5.2
  TOP w0.305: v1(91.41,99.95) U47.11
  TOP w0.381: v1(91.41,99.95) 91.31,100.05 C451.1 R764.2 R772.1
  BOTTOM w0.127: v2(90.49,100.86) v1(91.41,99.95)
VEN_VDD3P3: length 142.1
  TOP w0.127: v1(227.49,220.13) 227.49,219.81 226.92,219.24 U7.25
  S12 w0.254: v1(227.49,220.13) 228.06,219.56 228.06,216.7 229.77,214.99 229.77,212.51 229.52,212.25 229.52,210.16 229.79,209.89 229.79,208.27 228.95,207.43 228.95,198.97 227.23,197.25 227.23,196.23 218.47,187.47 218.47,177.01 219.38,176.1 219.38,170.87 218.62,170.11 218.62,153.47 210.54,145.4 198.25,145.4 196.71,143.86 196.71,137.54 194.68,135.51 191.83,135.51 190.92,134.59 172.56,134.59 v1(170.46,132.5)
  BOTTOM w0.127: v1(227.49,220.13) 227.99,220.63 227.99,220.72 v2(228.01,220.72)
  BOTTOM w0.508: RB155.2 167.6,134.91 168.94,134.91 170.46,133.39 v1(170.46,132.5)
VEN_VPP_DDR2P5: length 205
  TOP w0.203: U7.35 228.08,214.5 227.49,213.9 226.85,213.9 226.13,213.18
  TOP w0.254: 226.13,213.18 224.31,211.36 v1(224.31,210.92)
  S9 w0.203: v1(224.31,210.92) 220.69,210.92 220.04,210.26 206.83,210.26 203.23,206.65 198.05,206.65 196.35,204.95 192.65,204.95 191.66,205.94 178.84,205.94 175.92,203.02 174.14,203.02 168.66,197.54 143.05,197.54 v1(139.47,193.95)
  S16 w0.203: v1(139.47,193.95) 138.28,192.76 133.57,192.76 131.91,194.42 64.94,194.42 64.61,194.09 56.48,194.09 53.82,191.43 38.37,191.43 v1(38,191.81)
  BOTTOM w0.127: v2(225.52,211.55) 224.95,211.55 v1(224.31,210.92)
  BOTTOM w0.381: v1(38,191.81) 38.18,191.99 RB168.1
VEN_XFP_3V3: length 192.9
  TOP w0.254: U7.33 227.08,215.59 v1(227.38,215.89)
  TOP w0.381: R767.2 143.2,100.53 arc(143.07,101.18) v1(142.7,101.73)
  S12 w0.254: v1(142.7,101.73) 143.86,102.89 143.86,114.59 140.3,118.15 140.3,126.46 140.58,126.74 144.52,126.74 148.72,130.94 151.64,130.94 155.26,134.55 162.85,134.55 164.11,133.29 170.64,133.29 172.38,135.02 190.63,135.02 191.54,135.94 194.5,135.94 196.15,137.59 196.15,144.12 197.95,145.91 210.48,145.91 213.58,149.01 213.58,152.56 217.92,156.91 217.92,170.84 218.69,171.61 218.69,173.95 217.73,174.92 217.73,191.3 225.08,198.66 226.63,198.66 227.93,199.96 227.93,209.08 227.04,209.97 227.04,212.13 227.61,212.7 227.61,215.66 v1(227.38,215.89)
  BOTTOM w0.127: v2(142.42,102.75) 142.7,102.47 v1(142.7,101.73)
VMONITOR_3V3: length 679.4
  TOP w0.254: U71.50 227.99,195.98 v1(228.37,195.61) ; 186.26,177.07 185.94,176.75 U22.8 ; U71.31 237.21,195.98 v1(237.2,196) ; U71.42 231.95,199.75 v1(231.97,199.77) ; v1(221.45,242.67) 221.42,242.7 U20.20 ; v1(228.25,193.01) 228.22,192.98 U71.56 ; U21.16 243.36,241.49 243.43,241.56 C183.2 ; U72.10 223.75,168.83 v1(223.19,168.28) ; U72.5 227,168.86 v1(227.54,168.32) ; R40.1 224.98,227.62 v1(224.66,227.3) ; U19.5 183.18,180.85 182.93,181.1 C168.1 ; U71.20 237.25,190.48 v1(237.2,190.54)
  TOP w0.305: C984.2 64.36,215.17 U80.2
  TOP w0.381: v1(158.46,230.48) 158.41,230.52 R228.1 ; R87.2 v1(108.2,237.56) ; R429.2 R430.2 R431.2 ; v1(125.5,210.67) R484.2 R493.2 ; v1(183.66,182.22) 183.44,182 C168.1 ; RB130.1 v1(122.37,215.85) ; U72.19 223.75,162.74 v1(223.78,162.71) ; CONN57.4 60.67,216.31 61.88,217.52 C985.2 RB1288.2 v1(62.39,216.51) ; C984.2 64.05,215.5 64.29,215.75 v1(64.8,215.75) ; R116.2 v1(112.23,237.54) ; 86.12,144.88 86.91,145.67 v1(86.91,147.11) 86.1,147.93 R457.2 85.26,148.34 84.95,148.64 84.55,148.64 84.32,148.86 C235.1 83.61,148.58 83.61,148.08 83.33,147.8 U27.8 ; 86.12,144.88 86.59,144.41 86.59,143.34 86.1,142.85 R480.2 85.26,141.9 84.29,140.94 77.69,140.94 77.38,141.25 R478.1 ; 86.12,144.88 R470.2 ; R450.2 R452.2 ; R1469.1 122.14,207.68 v1(122.39,207.93) ; P1.R18 v4(109.29,227.46) ; U18.8 7.86,157.1 7.71,156.96 7.71,156.78 7.59,156.65 C208.1 ; P1.P19 v4(108.29,228.46) ; P1.N18 v4(107.29,227.46) ; U10.24 160.21,221.08 C175.1 C108.1 162.32,219.35 v1(162.27,219.3) ; RB129.1 v1(122.34,214.81) ; R732.2 v1(93.95,104.75) ; R540.1 v1(125.5,207.43) ; P1.G4 v4(100.29,212.46) ; U72.24 v1(227,162.69)
  TOP w0.508: R1293.2 R1292.2 v1(159.47,251.42) ; v1(152.75,218.16) 152.79,218.12 R308.1 ; R1458.2 v1(114.46,203.11) ; CONN56.16 v1(238.45,247.2) ; R168.2 R184.2 v1(159.83,235.72) ; R548.1 253.15,226.13 v1(253.09,226.07) ; CONN56.15 v1(238.45,257.05) ; U8.8 153.3,244.21 C57.1 v1(153.43,245.16) ; P1.E13 v4(98.29,222.46) ; P1.U13 v4(111.29,222.46) ; P1.U8 v4(111.29,216.46) ; P1.E10 v4(98.29,218.46) ; v1(160.62,213.71) 160.44,213.89 R189.2 ; R1471.1 120.49,203.3 v1(120.36,203.17) ; P1.F14 v4(99.29,223.46) P1.E14 v4(98.29,223.46) ; R452.2 77.51,149.63 76.99,150.15 76.33,150.15 75.96,149.78 v1(75.95,149.78) ; v1(138.83,210.82) 139.04,210.82 139.68,210.17 C276.1 139.36,209.83 U29.8 ; P1.H19 v4(101.29,228.46) ; R39.1 v1(221.39,224.76) ; CB1083.2 v1(244.87,98.83) ; CB1083.2 245.87,98.83 CB1085.2 245.39,97.79 245.15,97.56 UB70.5 ; CB1083.2 245.87,99.5 v1(245.58,99.79) ; RB31.2 122.43,225.36 v1(122.44,225.35) ; R279.1 v1(154.86,230.52) ; R261.1 v1(156.13,230.52) ; v1(240.76,163.04) 240.72,163.01 R671.1 ; C208.1 8.18,156.06 v1(8.55,155.7) ; R247.1 157.36,218.07 v1(157.38,218.09) ; v1(253.09,225.08) 253.16,225.14 R597.1 ; R646.2 116.18,119.98 v1(116.55,119.61) ; R1340.2 112.42,203.43 v1(112.23,203.24) ; L4.1 180.92,196.95 C69.1 180.92,199.4 C62.1 ; v1(120.55,132.75) 119.85,132.75 118.68,133.92 R421.1 ; v1(187.14,174.65) C210.1 C209.1 C869.1 186.58,177.39 186.26,177.07 ; v1(235.73,156.76) CB1084.2 236.57,157.45 ; R121.1 v1(141.68,240.02) ; v1(238.42,156.76) CB1086.2 237.58,157.58 ; D9.A1 v1(211.81,248.29) ; R246.1 v1(157.14,230.52) ; R97.1 v1(221.33,218.3) ; CONN28.4 257.9,221.47 257.54,221.11 v1(256.2,221.11) 256.2,221.1 CB494.2 ; C183.2 v1(244.12,242.8) ; RB9.2 RB10.2 RB11.2 202.9,207.31 203.93,206.28 v1(203.99,206.28) ; R1464.2 122.37,223.37 v1(122.38,223.36) ; R1013.1 v1(229.87,242.57) ; RB254.2 v1(219.31,116.99) ; R275.1 v1(183.82,186.01) ; R307.1 v1(152.57,230.4) ; P1.E16 v4(98.29,225.46) ; v1(102.14,203.24) 102.25,203.35 R1339.2 ; R1341.2 121.9,213.01 123.92,213.01 124.3,212.63 ; v1(125.5,207.43) 125.19,207.11 R1472.1 ; v1(156.24,218.86) 156.3,218.79 156.3,218.16 156.34,218.12 R262.1 ; RB32.2 v1(114.24,237.64) ; R1460.2 124.05,212.39 124.3,212.63 ; R506.2 141.44,208.12 v1(141.44,208.13) ; R106.2 v1(155.14,242.31) ; P1.U9 v4(111.29,217.46) ; P1.F10 v4(99.29,218.46) ; v1(180.81,183.74) 180.86,183.69 R316.2 ; R1451.1 v1(122.52,229.52) ; 124.3,212.63 v1(124.35,212.63) ; P1.V10 v4(112.29,218.46) ; v1(62.39,216.51) 61.71,215.83 61.71,214.83 62.07,214.48 RB1289.2 ; R280.1 155.07,218.14 v1(155.1,218.16) ; v1(158.59,218.03) 158.63,217.99 R229.1 ; C991.2 v1(222.23,38.86) 222.94,38.16 223.98,38.16 U87.8 ; RB727.1 82.26,207.43 v1(82.27,207.44) ; RB34.2 110.3,236.9 110.26,236.94 v1(110.26,237.59) ; v1(72.92,205.51) 73,205.59 RB1290.1 ; P1.V17 v4(112.29,226.46) ; v1(102.3,237.71) 102.3,237.71 102.3,237.71 102.07,237.48 R1449.2 ; R99.1 R88.1 141.72,244.09 v1(141.7,244.07) ; CB903.2 v1(238.85,155.93) ; P1.E11 v4(98.29,219.46) ; DB7.C 81.89,203.75 v1(83.09,204.95) ; C776.2 224.68,133.53 ; R107.1 v1(221.36,216.12) ; R524.2 140.59,205.09 R549.2 141.37,205.08 v1(141.38,205.08) ; P1.E9 v4(98.29,217.46) ; P1.U11 v4(111.29,219.46) ; P1.V15 v4(112.29,224.46) ; v1(6.38,151.99) 6.7,152.31 R431.2 ; R257.1 4.74,168.15 4.54,168.35 4.54,170.53 5.25,171.24 RB106.2 RB114.2 7.64,171.24 7.97,170.91 7.97,170.05 v1(8.03,169.99) R231.2 ; v1(154.02,218.16) 154.06,218.12 R296.1 ; R295.1 v1(153.84,230.52) ; R1012.1 v1(247.23,241.83) ; P1.E15 v4(98.29,224.46) ; P1.V12 v4(112.29,221.46) ; RB1292.2 v1(94.14,203.17) ; P1.K18 v4(104.29,227.46) ; P1.E12 v4(98.29,221.46) ; P1.J18 v4(102.29,227.46) ; RB287.1 v1(239.22,114.41) ; v1(253.07,223.07) 253.13,223.14 R621.1 ; L3.1 82.03,210.55 82.37,210.21 C52.1 83.38,209.73 C50.1 84.2,208.9 v1(84.14,208.84) ; P1.V16 v4(112.29,225.46) ; RB744.2 v1(12.74,215.44) ; R30.1 v1(240.41,228.38) ; R1462.2 v1(108.36,203.11)
  V3 w0.381: CONN6.7 47.11,227.94 ; CONN6.7 44.44,227.94 ; CONN6.7 45.77,226.6 ; CONN6.7 45.77,229.27 ; CONN6.19 45.77,234.77 ; CONN6.19 44.44,233.44 ; CONN6.19 45.77,232.1 ; CONN6.19 47.11,233.44
  S9 w0.381: v1(160.68,149.39) 160.68,150.72 159.97,151.44 156.48,151.44 155.73,150.68 v1(152.21,150.68) ; v1(223.55,133.64) 221.26,133.64 220.06,132.43 220.06,120.73 v1(219.37,120.04) 219.37,120.04 220.18,119.23 220.18,117.87 v1(219.31,116.99) 219.62,116.99 220.06,116.56 220.06,115.62 v1(219.4,114.96)
  S9 w0.508: v1(120.55,132.75) 118.05,130.25 118.05,124.28 116.02,122.25 116.02,120.75 116.55,120.22 v1(116.55,119.61) 116.55,113.76 113.25,110.46 99.66,110.46 v1(93.95,104.75) ; v1(152.21,150.68) 145.91,150.68 140.62,145.39 140.62,141.58 141.88,140.32 v1(141.88,137.19) 143.52,135.54 v1(147.79,135.54) ; v1(239.22,114.41) 238.74,113.94 225.55,113.94 224.52,112.91 221.44,112.91 v1(219.4,114.96)
  S14 w0.508: v1(86.91,147.11) 86.91,142.52 90.01,139.42 105.25,139.42 110.52,134.15 117.63,134.15 119.03,132.75 v1(120.55,132.75) ; v1(72.92,205.51) 72.61,205.83 72.61,208.38 69.75,211.24 68.86,211.24 66.7,213.4 66.7,213.87 64.83,215.75 v1(64.8,215.75)
  S16 w0.381: v1(258.28,10.2) v1(260.32,10.2)
  S16 w0.508: v1(120.55,132.75) 121.08,132.75 122.57,134.24 130.77,134.24 141.86,145.32 156.81,145.32 159.92,142.21 v1(160.56,142.21) ; v1(45.75,224.06) 53.31,216.51 v1(62.39,216.51) 64.04,216.51 v1(64.8,215.75)
  S16 w0.762: 215.31,15.64 219.95,15.64 223.88,11.72 228.31,11.72 228.95,11.08 230.91,11.08 v1(231.8,10.2) 232.76,9.24 235.88,9.24 236.25,9.61 v1(236.25,10.13) 237.36,11.25 250.47,11.25 252.31,9.41 257.59,9.41 258.28,10.1 v1(258.28,10.2)
  V18 w0.508: v1(75.95,149.78) 76.1,149.63 76.43,149.63 77.18,148.88 85.14,148.88 v1(86.91,147.11)
  BOTTOM w0.127: R1474.1 v1(258.28,10.2) ; R1473.1 v1(260.32,10.2) ; R1447.2 v1(110.26,237.59) ; v2(158.27,229.59) 158.46,229.78 v1(158.46,230.48)
  BOTTOM w0.254: v4(111.29,219.46) 111.02,219.73 CB1177.1 ; v4(111.29,217.46) 111.04,217.22 CB1159.1 ; CB1171.1 98,222.17 v4(98.29,222.46) ; v4(112.29,221.46) 112.32,221.42 CB1163.1 ; v4(112.29,224.46) 112.05,224.22 CB1161.1 ; CB1175.1 97.8,217.97 v4(98.29,218.46) ; v1(223.19,168.28) 223.47,167.99 C882.1 ; v1(238.85,155.93) 238.92,155.86 UB9.16 ; CB1168.1 101.83,227 v4(102.29,227.46) ; v4(111.29,216.46) 111.01,216.18 CB1158.1 ; CB1174.1 97.95,219.8 v4(98.29,219.46) ; CB1170.1 98.03,223.21 v4(98.29,223.46) ; v4(112.29,225.46) 111.99,225.16 CB1165.1 ; v4(108.29,228.46) 108.32,228.49 CB1162.1 ; v4(98.29,217.46) 98.02,217.19 CB1172.1 ; CB1167.1 101.54,228.21 v4(101.29,228.46) ; v4(112.29,218.46) 112.04,218.7 CB1160.1 ; v2(257.14,221.08) 257.11,221.11 v1(256.2,221.11) ; CB1176.1 97.98,221.15 v4(98.29,221.46) ; v4(98.29,224.46) 98.56,224.74 CB1169.1 ; R1289.2 v1(194.86,138.22) ; CB1166.1 107.01,227.73 v4(107.29,227.46) ; v4(98.29,225.46) 97.82,225.93 CB1157.1 ; v2(238.63,248.31) 238.63,247.38 v1(238.45,247.2)
  BOTTOM w0.305: v4(100.29,212.46) 99.99,212.76 CB1164.1 ; v1(180.81,7.69) 180.78,7.72 CB985.1 180.05,9.44 179.43,10.06 UB17.24 ; CB1173.1 99.04,218.21 v4(99.29,218.46)
  BOTTOM w0.381: R1319.2 v1(224.51,165.78) ; R1492.1 169.61,148.41 170.41,148.41 171.28,147.54 RB1302.2 ; 44.44,227.94 CONN6.7 ; CONN6.7 47.11,227.94 ; CONN6.7 45.77,226.6 ; CONN6.7 45.77,229.27 ; RB708.2 190.26,12.49 190.29,12.52 v1(190.3,12.52) ; RB677.1 v1(161.62,15.92) ; RB702.1 v1(161.62,12.49) ; RB656.1 v1(161.62,18.2) ; R1007.1 v1(236.25,10.13) ; RB713.1 v1(161.62,10.2) ; 45.77,232.1 CONN6.19 ; CONN6.19 45.77,234.77 ; CONN6.19 47.11,233.44 ; CONN6.19 44.44,233.44 ; R1493.1 194.73,143.66 v1(194.86,143.79) R1290.2 ; v1(223.78,162.71) 223.83,162.76 C881.1 ; RB666.1 v1(161.62,17.06) ; v1(227,162.69) 227.08,162.77 C883.1 227.1,163.42 227.87,163.42 228.48,164.03 228.48,166.3 228.21,166.57 R1320.1 ; RB694.1 v1(161.62,13.63) ; RB707.1 v1(161.62,11.34) ; v1(190.32,15.18) RB1245.1 ; v1(190.32,16.64) RB697.1 ; v1(190.32,13.85) RB1244.1 ; v1(190.45,18.23) RB689.1 ; 219.41,120.04 RB760.2 ; RB683.1 v1(161.62,14.77)
  BOTTOM w0.508: RB123.1 184.23,182.22 v1(183.66,182.22) ; C876.1 v1(228.25,193.01) ; C859.1 125.89,242.61 125.95,242.54 ; v1(176.62,147.04) R1287.2 R1288.2 ; v1(213.96,181.46) 213.77,181.46 213.09,182.13 R264.2 ; v1(125.95,240.64) 125.89,240.57 C856.1 ; R720.1 v1(36.33,246.1) ; C867.1 236.95,190.79 v1(237.2,190.54) ; U86.8 208.54,11.52 208.28,11.26 C989.2 209.08,10.14 v1(209.13,10.2) ; RB256.2 v1(219.4,114.96) ; v1(122.38,223.36) 122.37,223.37 R1464.2 ; v1(152.21,150.68) 152.13,150.77 RB1229.1 RB1230.1 ; L101.1 v1(234.56,181.47) ; v1(221.9,168.25) 222.47,167.68 R1490.2 ; C901.1 103.58,228.16 v4(104.29,227.46) ; v1(219.37,120.04) 219.41,120.04 ; R275.1 v1(183.82,186.01) ; v1(131.09,255.69) 131.16,255.76 C857.1 ; RB745.2 v1(161.48,7.95) ; v1(232.06,181.33) 232.54,181.81 L102.1 ; v1(211.81,18.69) C992.2 211.09,19.74 210.71,20.12 U85.8 ; v1(221.41,41.45) 221.41,41.8 222.11,42.49 C990.2 222.73,41.98 U88.8 ; C855.1 125.76,241.59 v1(125.95,241.4) ; R1005.1 231.12,9.38 231.8,10.07 v1(231.8,10.2) ; v1(102.14,203.24) 102.26,203.36 RB1291.2 ; v1(231.97,199.77) 231.99,199.75 C870.1 ; C858.1 126.01,239.56 126.08,239.62 ; C878.1 228.59,168.78 228.12,168.31 227.55,168.31 v1(227.54,168.32) 227.57,168.36 C879.1 ; C59.2 v1(45.75,224.06) ; v1(160.56,142.21) 160.25,141.9 R1286.1 ; RB1300.2 v1(141.88,137.19) ; R1456.2 117.5,203.36 v1(117.64,203.23) ; v1(131.09,256.45) 131.78,256.45 C853.1 ; v1(6.38,151.99) 7.73,153.34 7.73,154.88 v1(8.55,155.7) 8.55,157.07 8.17,157.45 8.17,162.13 8.98,162.94 8.98,169.03 v1(8.03,169.99) ; v1(160.68,149.39) 160.68,149.26 160.11,148.69 RB1232.1 RB1231.1 159.09,148.37 157.25,148.37 156.57,147.68 RB1303.2 ; C868.1 v1(237.2,196) ; v1(168.58,149.34) RB1235.2 168.59,148.44 R1492.1 ; RB1301.2 v1(147.79,135.54) ; CB39.1 45.81,238.03 ; v1(161.51,9.07) 161.53,9.09 RB746.2 ; C854.1 131.61,257.79 v1(131.09,257.27) ; R1491.2 v1(233.89,190.4)
  vias: v1(44.35,236.95) v1(44.35,235.94) v1(44.35,235.05) v1(44.35,231.49) v1(44.35,230.48) v1(44.35,229.59) v1(44.42,225.97) v1(44.42,224.95) v1(44.42,224.06) v1(45.75,225.97) v1(45.75,224.95) v1(46,231.43) v1(46,230.41) v1(46,229.52) v1(46.07,236.95) v1(46.07,235.94) v1(46.07,235.05) v1(47.02,225.97) v1(47.02,224.95) v1(47.02,224.06) v1(47.53,236.95) v1(47.53,235.94) v1(47.53,235.05) v1(47.46,231.37) v1(47.46,230.35) v1(47.46,229.46) v1(126.71,241.4) v1(126.71,240.64) v1(179.73,199.36) v1(180.05,200.19) v1(213.71,99.26) v1(214.47,99.26) v1(221.52,203.3) v1(221.52,202.47) v1(221.52,201.65) v1(223.55,134.34) v1(234.22,100.24) v1(234.66,99.41) v1(235.09,100.19) v1(235.42,98.91) v1(237.71,203.87) v1(238.53,203.87) v2(221.61,200.41)
VMONITOR_3V3_MON: length 9.6
  TOP w0.254: v1(237.81,229.63) R30.2 R41.1 237.81,225.46 C29.1 237.09,225.45 236.32,224.68 236.32,223.26 235.8,222.74 U7.63
  BOTTOM w0.127: v1(237.81,229.63) 237.15,230.29 v2(237.07,230.29)
VPP_DDR2P5: length 396.1
  TOP w0.254: U17.B1 v4(100.08,159.22)
  TOP w0.381: C196.1 C197.1 29.71,159.15 v4(29.77,159.09) ; v4(61.23,171.22) 61.23,170.75 61.69,170.29 62.04,170.29 62.3,170.04 U15.R9 ; v4(58.56,159.22) U14.B1 ; U16.B1 v4(89.54,159.22) ; v4(26.45,170.29) 26.64,170.1 C134.1 C135.1 ; v4(82.34,170.42) U16.R9 ; C202.1 104.23,159.1 v1(103.28,160.06) ; U17.R9 v4(92.89,170.42) 92.89,170.45 92.29,171.04 92.29,173.01 93.04,173.76 v1(93.74,173.76) ; v1(47.31,171.47) 46.9,171.47 46.45,171.02 C132.1 C133.1 51.04,170.73 U14.R9 ; v4(69.1,159.22) U15.B1
  TOP w0.508: R572.1 42.26,197.62 v1(42.32,197.69) ; L9.1 110.94,134.93 v1(110.9,134.97) ; R81.1 v1(243.3,221.13)
  S5 w0.381: v4(82.34,170.42) 81.3,169.37 81.3,157.9 ; v4(69.1,159.22) 70.08,159.22 71.4,157.9 81.3,157.9 ; 81.3,157.9 89.76,157.9 90.14,158.27 90.14,158.84 89.75,159.22 v4(89.54,159.22) ; v1(50.7,172.63) 50.64,172.57 50.64,155.36 50.91,155.09 56.69,155.09 57.24,154.53 58.08,154.53 59.2,155.65 59.2,158.58 v4(58.56,159.22)
  S5 w0.508: v1(110.9,134.97) 108.8,137.07 105.12,137.07
  S9 w0.254: v1(243.3,221.13) 243.29,221.14 241.65,221.14 240.19,219.68 240.19,212.76 241.01,211.94 241.01,208.44 240.44,207.87 235.61,207.87 232.5,210.98 231.11,210.98 230.22,211.87 218.98,211.87 218.28,211.17 206.47,211.17 202.89,207.6 197.46,207.6 195.62,205.75 192.89,205.75 191.97,206.68 176.58,206.68 168.53,198.63 142.04,198.63 138.4,194.98 116.93,194.98 105.08,183.13 100.95,183.13 95.56,177.74 53.37,177.74 52.29,176.65 v1(52.29,176.18)
  S9 w0.381: v4(100.08,159.22) 102.44,159.22 v1(103.28,160.06)
  S12 w0.381: v1(16.32,158.98) 17.67,158.98 19.19,157.45 27.75,157.45 29.39,159.09 v4(29.77,159.09)
  S12 w0.508: v1(51.34,189.52) 52.93,191.11 52.93,195.54 50.78,197.69 v1(42.32,197.69)
  S14 w0.381: v4(26.45,170.29) 28.85,172.69 v1(30.06,172.69)
  S16 w0.508: 45.25,173.14 CONN35.1 ; CONN35.1 47.13,173.14 ; CONN35.1 46.19,174.08 ; CONN35.1 46.19,172.2
  BOTTOM w0.127: v2(244.24,220.34) 244.09,220.34 v1(243.3,221.13)
  BOTTOM w0.254: C370.2 48.03,182.41 ; C370.2 47.47,182.8 47.59,182.92 47.97,182.92 ; C370.2 47.47,182.08 47.65,181.9 48.1,181.9
  BOTTOM w0.381: v4(69.1,159.22) 69.49,159.61 CB295.1 CB311.1 ; UB6.B1 v4(29.77,159.09) ; CB269.1 100.71,158.6 v4(100.08,159.22) ; CB293.1 59,159.66 v4(58.56,159.22) ; UB6.R9 36.7,170.03 37.38,170.03 38.01,169.39 CB154.1 40.99,169.7 40.79,169.9 CB130.1 v1(39.97,170.66) ; v4(82.34,170.42) 82.23,170.53 81.57,170.53 CB136.1 ; v4(61.23,171.22) 60.93,171.52 CB141.1 CB157.1 CB167.1 ; UB5.B1 19.49,159.36 19.42,159.36 18.41,158.34 15.94,158.34 15.69,158.6 CB310.1 CB294.1 15.54,159.61 16.17,158.98 v1(16.32,158.98) ; CB152.1 92.54,170.07 v4(92.89,170.42) ; v4(26.45,170.29) 26.05,169.89 UB5.R9
  BOTTOM w0.508: 49.37,178.34 C360.1 CB438.1
  vias: v1(48.23,176.18) v1(48.23,175.42) v1(49.24,176.18) v1(49.24,175.42) v1(50.26,176.18) v1(50.26,175.42) v1(51.27,176.18) v1(51.27,175.42) v1(52.29,175.42) v1(52.92,189.46) v1(97.37,102.46) v1(98.26,102.46) v1(98.59,101.8) v1(99,102.87) v1(101.97,174.11) v1(102.94,168.78) v1(103.04,173.89) v1(103.22,161.83) v1(103.28,165.52) v1(103.28,164.5) v2(51.97,187.42) v2(52.74,181.08)
VPP_DDR2P5_BST_C: length 4.7
  TOP w0.254: C323.1 46.97,193.13 v1(47.61,192.5) 47.61,192.11 47.1,191.61 R610.1
  BOTTOM w0.508: v1(47.61,192.5) 47.61,191.85 v2(48.42,191.04)
VPP_DDR2P5_MARGIN_HIGH: length 26.2
  TOP w0.127: RB4.2 v1(137.2,232.46) ; v1(118,228.47) 117.95,228.52 115.23,228.52 P1.AA20
  S16 w0.127: v1(137.2,232.46) 137.01,232.64 126.85,232.64 125.38,231.18 121.95,231.18 119.73,228.95 118.48,228.95 v1(118,228.47)
  BOTTOM w0.127: v2(137.19,231.56) 137.19,232.45 v1(137.2,232.46)
VPP_DDR2P5_MARGIN_HIGH_D: length 155.7
  TOP w0.127: v1(144.55,230.92) 144.64,231.01 QB2.D ; RB233.1 36.65,197.29 v1(36.57,197.38)
  S7 w0.127: v1(144.55,230.92) 143.54,231.94 135.73,231.94 134.9,232.76 116.3,232.76 114.96,234.1 112.17,234.1 110.26,236 82.29,236 73.9,227.61 73.9,227.6 73.33,227.02 73.32,227.02 70.67,224.37 70.67,223.85 69.12,222.3 v1(69.12,221.84)
  S14 w0.127: v1(78.41,202.36) 78.41,202.72 74.07,207.06 74.07,211.24 71.34,213.98 71.34,219.62 v1(69.12,221.84)
  S16 w0.127: v1(78.41,202.36) 73.51,197.46 45.93,197.46 44.21,195.73 40.87,195.73 39.95,196.65 37.3,196.65 v1(36.57,197.38)
  BOTTOM w0.127: v2(145.51,230.92) v1(144.55,230.92)
VPP_DDR2P5_MARGIN_HIGH_R: length 7.2
  TOP w0.127: RB4.1 RB1.1 140.37,231.55 CB21.2 140.92,231.49 QB2.G 143.6,233.01 143.6,233.02 v1(143.6,233.08)
  BOTTOM w0.127: v1(143.6,233.08) 143.54,233.02 v2(142.71,233.02)
