# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FPGA_156.25M_REF_CLK_P_F: length 65.7
  TOP w0.095: R1501.1 120.32,219.94 120.22,220.03 120.22,220.23 120.13,220.33 118.68,220.33 v3(118.39,220.04) 118.1,220.33 117.17,220.33 117.09,220.41 116.02,220.41 115.92,220.51 115.24,220.51 P1.AA12 ; v3(136.63,175.4) 137.03,175.79 137.27,175.79 C987.2
  S7 w0.108: v3(118.39,220.04) 118.68,220.33 121.33,220.33 arc(121.87,220.22) 122.33,219.91 122.93,219.32 arc(123.26,218.83) 123.37,218.25 123.37,201.95 arc(123.73,200.15) 124.75,198.62 138.15,185.21 arc(138.57,184.59) 138.72,183.85 138.72,180.81 arc(138.66,180.54) 138.51,180.3 135.39,177.19 arc(135.27,177) 135.22,176.77 135.22,176.37 arc(135.25,176.19) 135.32,176.03 arc(135.51,175.84) 135.76,175.75 136.18,175.75 arc(136.28,175.73) 136.36,175.67 v3(136.63,175.4)
FPGA_156.25M_REF_CLK_P_R: length 7.2
  TOP w0.095: R1386.2 141.05,175.78 142.99,175.78 143.09,175.68 143.09,175.37 R1395.1 143.58,175.3 143.68,175.39 143.68,175.69 143.77,175.78 144.25,175.78 145.03,175 145.57,175 145.66,174.92 U77.57
FPGA_CLKUSR: length 16.2
  TOP w0.127: P1.G11 v4(100.29,219.46) ; R1470.2 90.88,213.21 v1(91.36,213.68)
  BOTTOM w0.127: v4(100.29,219.46) 99.81,218.98 94.87,218.98 94.33,218.43 94.33,214.55 92.94,213.16 v2(92.9,213.16) 92.84,213.1 91.94,213.1 v1(91.36,213.68)
FPGA_CONF_DONE: length 83.1
  TOP w0.127: P1.U5 v4(111.29,213.46) ; v1(118.9,212.95) 119.09,212.76 R1341.1 ; CONN57.3 55.98,216.31 57.13,217.46 60.99,217.46 61.75,218.22 67.66,218.22 70,215.88 v1(70,212.52)
  S5 w0.127: v1(70,212.52) 76.85,212.52 78.78,210.59 86.29,210.59 86.79,210.08 87.63,210.08 88,210.46 88.64,210.46 89.87,211.68 92.61,211.68 93.31,210.98 98.64,210.98 99.72,209.9 112.55,209.9 112.8,210.16 112.8,212.7 112.46,213.05 111.69,213.05 111.29,213.45 v4(111.29,213.46)
  BOTTOM w0.127: v4(111.29,213.46) 111.73,213.9 114.48,213.9 114.84,213.55 114.84,213.27 115.22,212.89 118.84,212.89 v1(118.9,212.95) 120.22,212.95 v2(120.23,212.96)
FPGA_CPU_PCIE_RX_N: length 103.4
  TOP w0.127: C905.2 118.81,203.56 118.81,202.84 v3(118.57,202.6) ; v3(174.99,147.87) 174.73,148.13 174.46,148.13 174.33,148 174.33,146.06 174.44,145.95 J2.B62
  S16 w0.14: v3(118.57,202.6) 118.84,202.32 118.84,201.43 123.2,197.08 155.23,197.08 165.73,186.58 165.73,170.08 174.23,161.58 174.23,157.2 175.36,156.07 175.36,151.14 174.03,149.81 174.03,148.46 174.37,148.12 174.74,148.12 v3(174.99,147.87)
FPGA_CPU_PCIE_RX_N_F: length 11.6
  TOP w0.127: P1.V1 111.99,209.76 111.99,208.73 112.33,208.38 112.64,208.38 arc(112.78,208.32) 112.84,208.18 112.84,208.11 arc(112.94,207.89) 113.16,207.79 arc(113.38,207.89) 113.48,208.11 113.48,208.18 arc(113.54,208.32) 113.68,208.38 113.91,208.38 arc(113.97,208.37) 114.03,208.34 arc(114.09,208.27) 114.11,208.18 arc(114.43,207.86) 114.75,208.18 arc(114.81,208.32) 114.95,208.38 115.24,208.38 117.04,206.58 117.83,206.58 118.64,205.77 118.64,204.97 C905.1
FPGA_CPU_PCIE_RX_P: length 103.4
  TOP w0.127: C904.2 119.12,203.51 119.12,202.86 v3(119.38,202.6) ; J2.B61 173.94,145.95 174.02,146.03 174.02,148.13 174.33,148.43 174.74,148.43 v3(174.99,148.68)
  S16 w0.14: v3(174.99,148.68) 174.74,148.43 174.5,148.43 174.33,148.59 174.33,149.69 175.66,151.02 175.66,156.2 174.54,157.33 174.54,161.71 166.04,170.21 166.04,186.71 155.36,197.39 123.32,197.39 119.15,201.56 119.15,202.36 v3(119.38,202.6)
FPGA_CPU_PCIE_RX_P_F: length 11.5
  TOP w0.127: P1.V2 112.29,210.45 112.29,208.86 112.46,208.69 115.37,208.69 117.17,206.89 117.96,206.89 118.94,205.9 118.94,205.33 119.07,205.21 119.07,205.2 C904.1
FPGA_CRC_ERROR: length 9.6
  TOP w0.127: R1469.2 120.59,207.68 119.7,208.57 v1(119.6,208.57) 118.52,209.65 118.52,210.35 116.36,212.51 115.28,212.51 114.83,212.96 P1.AA4
  BOTTOM w0.127: v2(120.49,208.85) 119.88,208.85 v1(119.6,208.57)
FPGA_DATA0: length 9.8
  TOP w0.127: P1.K4 v4(103.29,212.46)
  BOTTOM w0.127: v4(103.29,212.46) 102.77,211.94 102.77,208.44 102.26,207.93 v2(102.26,207.81) RB1291.1 R1455.1
FPGA_DATA1: length 11.5
  TOP w0.127: P1.D1 97.79,208.79 95.02,206.03 94.64,206.03 v1(94.14,205.52) RB1292.1
  BOTTOM w0.127: v2(95.6,201.71) 95.53,201.71 94.64,202.6 94.64,204.7 94.51,204.83 RB1292.1 v1(94.14,205.52)
FPGA_DCLK: length 64.3
  TOP w0.127: CONN57.1 56.06,218.85 56.99,219.78 67.75,219.78 71.08,216.44 U80.16 78.16,216.44 79.05,215.55 v1(79.05,214.94) ; P1.D3 v4(97.29,211.46)
  S7 w0.127: v1(79.05,214.94) 79.05,205.87 81.12,203.81 95.34,203.81 96.68,205.14 96.68,206.78 97.29,207.4 v4(97.29,211.46)
  BOTTOM w0.127: v1(79.05,214.94) 79.05,216.09 v2(79.12,216.16)
FPGA_DEV_CLRN: length 14.9
  TOP w0.127: P1.P13 v4(108.29,222.46) ; R1464.1 R1467.2 v1(119.73,222.35)
  BOTTOM w0.127: v4(108.29,222.46) 108.69,222.86 111.6,222.86 112.43,222.03 118.63,222.03 v2(118.88,222.28) 119.66,222.28 v1(119.73,222.35)
FPGA_DEV_OE: length 17.3
  TOP w0.381: P1.P14 v4(108.29,223.46)
  S16 w0.127: v1(118.77,223.68) 118.23,224.22 116.27,224.22 115.54,224.95 109.06,224.95 108.74,224.64 108.74,223.91 v4(108.29,223.46)
  BOTTOM w0.127: R1466.1 R1468.2 119.47,224.38 v1(118.77,223.68) 118.2,224.25 v2(118.2,224.64)
FPGA_INIT_DONE: length 20.9
  TOP w0.127: v1(119.85,205.9) 120.49,205.27 R1471.2 ; P1.W8 v4(113.29,216.46)
  S14 w0.127: v4(113.29,216.46) 113.29,216.34 113.63,216 115.41,216 115.85,215.55 115.85,212.38 117.88,210.35 117.88,207.81 119.79,205.9 v1(119.85,205.9)
  BOTTOM w0.127: v2(121.36,202.16) 121.38,202.16 121.38,202.82 119.85,204.34 v1(119.85,205.9)
FPGA_JTAG_TCK: length 166.3
  TOP w0.127: R1347.1 95.16,203.92 R1343.1 ; R355.1 v1(224.64,241.26)
  TOP w0.508: R1347.1 v1(95.15,203.24)
  S7 w0.127: v1(224.64,241.26) 226.15,239.75 226.15,237.14 223.1,234.1 v1(209.39,234.1)
  S9 w0.127: v1(95.15,203.24) 95.64,203.72 99.24,203.72 99.72,203.24 99.72,202.03 101.85,199.9 126.42,199.9 126.59,200.07 126.6,200.07 129.2,202.68 129.2,204.12 129.34,204.26 129.34,204.35 133.13,208.14 134.09,208.14 136.16,210.21 136.16,211.02 137.43,212.29 141.26,212.29 142.7,213.74 151.66,213.74 151.94,214.02 159.36,214.02 160.2,213.18 169.62,213.18 170.76,214.33 201.49,214.33 209.39,222.22 v1(209.39,234.1)
  BOTTOM w0.127: v2(225.33,240.64) 224.71,241.26 v1(224.64,241.26)
FPGA_JTAG_TCK_R: length 10.4
  TOP w0.127: P1.E4 v4(98.29,212.46) ; R1343.2 v1(96.16,205.53)
  S12 w0.127: v4(98.29,212.46) 97.78,211.95 97.78,208.65 96.16,207.03 v1(96.16,205.53)
  BOTTOM w0.127: v1(96.16,205.53) 95.72,205.1 v2(95.72,204.51)
FPGA_JTAG_TDI_R: length 11.9
  TOP w0.127: P1.F5 v4(99.29,213.46) ; v1(98.57,206.12) 98.16,205.71 R1344.2
  S14 w0.127: v4(99.29,213.46) 98.86,213.03 98.86,206.37 98.61,206.12 v1(98.57,206.12)
  BOTTOM w0.127: v2(97.69,204.38) 97.69,205.24 v1(98.57,206.12)
FPGA_JTAG_TDO: length 99.7
  TOP w0.127: v1(97.12,203.11) 97.15,203.13 R1346.1 ; v1(182.78,187.04) 182.8,187.02 R258.2
  S9 w0.127: v1(182.78,187.04) 172.57,187.04 169.98,189.63 161.77,189.63 v1(159.84,187.69)
  S14 w0.127: v1(159.84,187.69) 158.99,186.84 147.68,186.84 145.48,189.03 142.18,189.03 136.09,195.12 119.06,195.12 119.03,195.15 118.99,195.15 112.69,201.45 98.29,201.45 97.18,202.55 97.18,202.68 97.12,202.74 v1(97.12,203.11)
  BOTTOM w0.127: v1(159.84,187.69) 159.78,187.74 v2(158.65,187.74) ; v1(182.78,187.04) 182.08,186.34 v2(182.02,186.34)
FPGA_JTAG_TDO_R: length 9.2
  TOP w0.127: R1346.2 v1(97.15,205.56) ; P1.E3 v4(98.29,211.46)
  S14 w0.127: v1(97.15,205.56) 97.79,206.2 97.79,210.96 v4(98.29,211.46)
  BOTTOM w0.127: v1(97.15,205.56) 97.12,205.59 v2(97.12,206.98)
FPGA_JTAG_TMS: length 145.1
  TOP w0.127: v1(207.99,235.68) 208.25,235.95 R419.1 ; v1(99.15,202.98) 99.18,203.01 R1345.1
  S9 w0.127: v1(207.99,235.68) 208.64,235.68 210.26,234.07 210.26,222.25 201.85,213.84 177.79,213.84 176.7,212.75 159.79,212.75 158.95,213.59 152.3,213.59 151.87,213.16 142.62,213.16 141.45,211.99 138.39,211.99 137.95,211.55 137.95,210.28 137.06,209.4 135.92,209.4 135.33,208.81 135.33,208.26 133.76,206.69 132.19,206.69 129.7,204.2 129.7,201.9 127.06,199.26 101.66,199.26 99.15,201.78 v1(99.15,202.98)
  BOTTOM w0.127: v1(207.99,235.68) 207.48,235.68 v2(206.91,236.26)
FPGA_JTAG_TMS_R: length 13.6
  TOP w0.127: P1.G5 v4(100.29,213.46) ; R1345.2 v1(99.18,205.61)
  S14 w0.127: v4(100.29,213.46) 99.75,212.92 99.75,206.18 v1(99.18,205.61)
  BOTTOM w0.127: v1(99.18,205.61) 98.64,205.08 v2(98.64,202.03)
FPGA_MSEL0: length 17
  TOP w0.127: R1457.2 v1(117.5,205.71) ; P1.T6 v4(110.29,214.46)
  S16 w0.127: v1(117.5,205.71) 117.5,207.37 115.89,208.98 115.89,210.76 113.8,212.85 113.8,213.7 113.47,214.03 110.72,214.03 v4(110.29,214.46)
  BOTTOM w0.127: R1457.2 v1(117.5,205.71) 117.69,205.52 v2(118.58,205.52)
FPGA_MSEL1: length 14.7
  TOP w0.127: R1458.1 R1459.2 113.44,205.31 v1(113.75,205.62) ; P1.P5 v4(108.29,213.46)
  S7 w0.127: v1(113.75,205.62) 113.75,206.11 110.33,209.53 110.33,210.35 109.76,210.92 109.76,212.7 109.44,213.01 108.73,213.01 v4(108.29,213.46)
  BOTTOM w0.127: v1(113.75,205.62) 113.44,205.31 v2(113.44,204.25)
FPGA_MSEL2: length 20
  TOP w0.127: R1460.1 122.73,212.23 120.97,212.23 120.73,211.99 R1461.2 119.92,211.74 v1(119.66,212) ; P1.R5 v4(109.29,213.46)
  S9 w0.127: v4(109.29,213.46) 109.86,212.89 117.95,212.89 118.84,212 v1(119.66,212)
  BOTTOM w0.127: v1(119.66,212) 120.93,212 121.25,212.32 122.62,212.32 v2(123.38,213.07)
FPGA_MSEL3: length 11.2
  TOP w0.127: R1462.1 108.36,205.71 v1(108.3,205.78) ; P1.P4 v4(108.29,212.46)
  S14 w0.127: v4(108.29,212.46) 107.85,212.02 107.85,207.81 108.3,207.36 v1(108.3,205.78)
  BOTTOM w0.127: v2(109.63,204.33) 109.13,204.83 R1462.1 108.36,205.71 v1(108.3,205.78)
FPGA_NCE: length 49.2
  TOP w0.127: P1.D2 97.31,210.48 97.31,208.95 94.96,206.6 94.33,206.6 v1(93.31,205.59) 93.12,205.39 R1453.1 ; CONN57.6 62.5,213.77 65.54,210.73 69.56,210.73 70.86,209.43 77.91,209.43 80.67,206.66 v1(80.67,205.78)
  S7 w0.127: v1(80.67,205.78) 80.8,205.65 83.69,205.65 84,205.97 88.48,205.97 89.48,204.97 92.7,204.97 v1(93.31,205.59)
  BOTTOM w0.127: v2(80.61,204.25) 80.61,205.71 v1(80.67,205.78)
FPGA_NCEO: length 11.5
  TOP w0.127: P1.AB3 116.21,211.96 117.95,210.22 117.95,209.46 119.85,207.55 v1(119.98,207.55) 120.42,207.11 R1472.2
  BOTTOM w0.127: v2(121.5,207.24) 121.19,207.55 v1(119.98,207.55)
FPGA_NCONFIG: length 68.2
  TOP w0.127: CONN57.5 55.99,213.77 57.25,212.51 62.31,212.51 65.42,209.4 69.24,209.4 70.39,208.25 77.87,208.25 79.21,206.91 v1(79.21,204.44) ; R1339.1 102.25,205.53 v1(101.18,206.6) ; P1.H4 v4(101.29,212.46)
  S7 w0.127: v1(101.18,206.6) 100.68,206.09 100.68,205.27 99.72,204.31 99.72,202.41 99.37,202.05 81.6,202.05 v1(79.21,204.44)
  S14 w0.127: v4(101.29,212.46) 101.29,212.4 101.76,211.93 101.76,209.01 101.18,208.44 v1(101.18,206.6)
  BOTTOM w0.127: v2(100.42,208.38) 101.18,207.62 v1(101.18,206.6)
FPGA_NCSO: length 52.2
  TOP w0.127: CONN57.8 62.33,211.23 64.29,209.27 v1(64.42,209.27) 64.86,208.82 U80.7 ; P1.J4 v4(102.29,212.46)
  S5 w0.127: v4(102.29,212.46) 101.8,212.95 89.56,212.95 88.03,211.42 87.11,211.42 86.58,210.89 79.3,210.89 77.17,213.01 68.16,213.01 v1(64.42,209.27)
  BOTTOM w0.127: v1(64.42,209.27) 64.86,208.82 v2(65.31,208.82)
FPGA_NSTATUS: length 15.3
  TOP w0.127: v1(112.42,205.59) R1340.1 ; P1.R8 v4(109.29,216.46)
  S14 w0.127: v4(109.29,216.46) 109.85,215.9 109.85,209.5 112.42,206.92 v1(112.42,205.59)
  BOTTOM w0.127: v1(112.42,205.59) 111.53,204.7 v2(111.53,204.25)
FPGA_REF_CLK0: length 56.8
  TOP w0.127: R1388.1 136.05,178.72 133.72,181.05 133.72,183.24 133.11,183.85 132.54,183.85 v1(132.33,183.65) ; P1.M8 v3(106.29,216.46)
  S7 w0.127: v3(106.29,216.46) 105.83,216 105.83,214.08 106.04,213.87 106.55,213.87 106.72,213.7 106.72,210.43 107.18,209.97 107.92,209.97 108.97,208.91 109.46,208.91 111.83,206.54 111.83,204.78 112.82,203.79 112.82,203.49 112.83,203.48 112.83,202.99 112.82,202.98 112.82,202.58 124.53,190.87 125.11,190.87 v1(132.33,183.65)
FPGA_REF_CLK0_R: length 6.2
  TOP w0.127: U77.51 141.89,177.92 141.09,178.72 R1388.2
FPGA_REF_CLK1: length 56.1
  TOP w0.127: v1(132.93,183.11) 132.93,180.85 135.86,177.93 139.22,177.93 R1389.1 ; P1.N8 v4(107.29,216.46)
  S7 w0.127: v4(107.29,216.46) 107.33,216.46 107.84,215.95 107.84,210.79 108.6,210.03 109.57,210.03 109.82,209.78 109.82,209.27 113.15,205.94 113.15,204.84 113.69,204.3 114.61,204.3 115.32,203.59 115.32,201.62 132.93,184.01 v1(132.93,183.11)
FPGA_REF_CLK1_R: length 6
  TOP w0.127: U77.52 145.96,177.42 145.81,177.57 141.45,177.57 141.4,177.52 R1389.2
FPGA_REF_CLK2: length 58.5
  TOP w0.127: R1390.1 135.92,179.74 134.25,181.41 134.25,183.62 v1(133.69,184.17) ; P1.M11 v4(106.29,219.46)
  S7 w0.127: v1(133.69,184.17) 133.69,185.48 117.03,202.14 117.03,203.56 111.9,208.7 111.9,209.76 111.63,210.02 111.02,210.02 110.77,210.27 110.77,213.72 110.54,213.95 109.04,213.95 108.75,214.24 108.75,216.77 108.52,216.99 107.03,216.99 106.72,217.31 106.72,219 106.29,219.43 v4(106.29,219.46)
FPGA_REF_CLK2_R: length 6.2
  TOP w0.127: U77.49 141.96,178.92 141.14,179.74 R1390.2
FPGA_REF_CLK3: length 57.6
  TOP w0.127: v1(134.69,184.3) 134.96,184.03 134.96,181.42 135.43,180.95 R1391.1
  TOP w0.508: P1.N11 v4(107.29,219.46)
  S7 w0.127: v4(107.29,219.46) 107.8,218.95 107.8,218.09 107.93,217.96 108.57,217.96 109.82,216.71 109.82,215.07 109.94,214.94 111.6,214.94 111.83,214.71 111.83,211.15 113.53,209.46 113.53,209.21 115.95,206.79 117.89,206.79 121.12,203.56 121.12,199.08 134.69,185.51 v1(134.69,184.3)
FPGA_REF_CLK3_R: length 6.6
  TOP w0.127: U77.48 145.79,179.42 145.69,179.32 142.5,179.32 140.88,180.95 R1391.2
FPGA_REF_CLK_OUT0: length 1.4
  TOP w0.127: RB1262.2 R1410.2
FPGA_REF_CLK_OUT1: length 1.4
  TOP w0.127: RB1263.2 R1411.2
FPGA_REF_CLK_OUT2: length 1.4
  TOP w0.127: R1412.2 RB1264.2
FPGA_REF_CLK_OUT3: length 1.4
  TOP w0.127: R1413.2 RB1265.2
FPGA_RES_CLK: length 71.8
  TOP w0.127: v1(128.3,184.44) 129.63,185.77 136.2,185.77 136.76,185.21 R1405.1 ; P1.B9 v4(95.29,218.46)
  S7 w0.127: v4(95.29,218.46) 95.37,218.46 95.89,218.98 101.8,218.98 102.76,218.02 102.76,210.42 106.9,206.29 106.9,204.72 105.61,203.43 105.61,201.95 106.35,201.21 109.37,201.21 126.15,184.43 128.29,184.43 v1(128.3,184.44)
FPGA_RES_CLK_R: length 4.6
  TOP w0.127: U77.42 145.65,182.42 144.42,183.64 144.42,183.91 R1405.2
FPGA_SN65C_1DE: length 248.7
  TOP w0.127: P1.J14 v4(102.29,223.46)
  S14 w0.127: v4(102.29,223.46) 102.71,223.46 103.19,222.98 103.72,222.98 105.92,220.79 116.23,220.79 117.41,221.97 118.63,221.97 120.86,219.73 123.48,219.73 123.72,219.49 125.36,219.49 127.08,217.78 130.77,217.78 131.35,217.21 140.79,217.21 145.75,212.24 145.75,205.38 145.94,205.19 145.94,205.18 154.97,196.15 163.65,196.15 174.91,184.9 174.91,157.7 175.55,157.07 175.55,154.25 178.14,151.66 178.59,151.66 179.11,151.14 179.11,150.71 184.66,145.16 187.96,145.16 191.48,141.64 191.48,136.8 193.75,134.53 210.35,134.53 211.74,133.13 213.03,133.13 v1(214.88,131.28)
  S16 w0.127: v1(238.79,86.01) 241.58,88.81 242.69,88.81 243.15,89.27 243.15,92.99 244.22,94.06 244.22,96.09 242.95,97.36 242.95,102.57 236.64,108.87 222.63,108.87 220.06,111.45 220.06,128.44 219.09,129.41 216.76,129.41 v1(214.88,131.28)
  BOTTOM w0.127: RB278.2 238.79,86.02 v1(238.79,86.01) 238.22,85.44 v2(238.03,85.44)
FPGA_SN65C_2DE: length 297.4
  TOP w0.381: R855.2 244.1,92.57 v1(244.1,92.57)
  TOP w0.508: P1.C13 v4(96.29,222.46)
  S9 w0.127: v4(96.29,222.46) 96.69,222.86 98.42,222.86 98.73,223.18 98.73,234.36 98.51,234.58 98.51,236.16 99.56,237.21 99.56,238.08 103.19,241.71 121.46,241.71 123.1,240.07 127.24,240.07 128.56,241.4 134.76,241.4 136.94,239.21 144.24,239.21 144.5,239.47 146.5,239.47 148.51,237.46 153.57,237.46 154.59,236.45 161.13,236.45 161.33,236.24 169.22,236.24 171.68,238.7 172.69,238.7 174.09,240.1 180.41,240.1 182.13,241.83 188.96,241.83 v1(190.47,240.32)
  S14 w0.127: v1(190.47,240.32) 190.47,239.62 192.37,237.72 195.42,237.72 196.31,236.83 203.42,236.83 210.15,230.1 210.15,216.72 219.68,207.2 219.68,177.39 227.04,170.03 227.04,169.77 233.14,163.68 235.42,163.68 239.87,159.23 239.87,152.25 242.66,149.45 242.66,139.16 244.65,137.17 244.65,110.57 243.93,109.84 243.93,92.74 v1(244.1,92.57)
  BOTTOM w0.127: v2(245.08,92.56) 245.06,92.57 v1(244.1,92.57)
FPGA_SPI_D0: length 60.9
  TOP w0.127: v1(83.06,203.23) 82.69,202.85 68.74,202.85 65.24,206.35 57.88,206.35 v1(56.48,207.74) 56.48,208.27 56.06,208.69 CONN57.9 ; v1(78.11,214.25) 78.11,214.43 77.36,215.17 U80.15
  S14 w0.127: v1(83.06,203.23) 82.14,203.23 78.11,207.26 v1(78.11,214.25)
  BOTTOM w0.127: R1454.2 90.95,203.92 89.56,202.54 83.75,202.54 v1(83.06,203.23) ; v2(56.48,209.01) v1(56.48,207.74)
FPGA_SPI_D1: length 53.3
  TOP w0.127: CONN57.7 55.87,211.23 57.13,209.97 61.56,209.97 63.97,207.55 U80.8 69.69,207.55 72.24,205 74.15,205 v1(74.98,204.18)
  BOTTOM w0.127: R1455.2 100.74,203.48 100.74,202.54 99.15,200.95 77.88,200.95 v2(76.61,202.22) 76.61,202.55 v1(74.98,204.18)
FPGA_SPI_DQ3: length 5.8
  TOP w0.127: RB1288.1 64.67,216.51 64.73,216.44 U80.1 67.91,216.44 v1(68.23,216.13)
  BOTTOM w0.127: v2(66.89,215.81) 67.91,215.81 v1(68.23,216.13)
FPGA_SPI_RST_N: length 157.7
  TOP w0.127: RB1289.1 v1(64.99,214.48) 65.56,213.9 U80.3 ; U9.C5 v4(193.55,197.58)
  S9 w0.127: v1(168.73,202.49) 166.45,200.2 141.54,200.2 137.65,196.32 94.96,196.32 88.89,202.38 82.88,202.38 78.57,206.69 78.54,206.69 78.5,206.73 75.34,206.73 v1(72.99,204.38)
  S14 w0.127: v1(72.99,204.38) 71.59,202.98 66.01,202.98 65.01,203.97 65.01,214.45 v1(64.99,214.48)
  BOTTOM w0.127: v1(168.73,202.49) 169.09,202.84 174.01,202.84 v2(174.08,202.92) 174.34,203.17 192.62,203.17 194.48,201.31 194.48,198.49 193.57,197.58 v4(193.55,197.58)
FPGA_SPI_WP_N_DQ2: length 4.8
  TOP w0.127: U80.9 74.77,207.55 v1(74.58,207.36) 74.52,207.31 RB1290.2
  BOTTOM w0.127: v1(74.58,207.36) 73.63,207.36 v2(73.5,207.24)
FPGA_STACKING_SYNC0_DATA: length 291.4
  TOP w0.127: P1.J19 v4(102.29,228.46)
  S16 w0.127: v1(224.79,45.38) 224.79,45.41 224.78,45.41 224.78,53.04 222.49,55.33 222.49,66.77 216.45,72.81 214.25,72.81 211.69,75.37 211.39,75.37 207.48,79.28 207.48,87.86 203.06,92.28 196.77,92.28 186.91,102.14 186.91,128.55 189.83,131.47 189.83,137.39 190.69,138.24 190.69,146.18 186.91,149.96 186.4,149.96 186.02,150.34 186.02,156.52 184.12,158.43 184.12,169.39 178.4,175.11 178.4,196.06 175.23,199.24 175.23,208.89 173.32,210.79 172.98,210.79 167.7,216.07 165.69,216.07 164.09,217.67 164.09,219.68 163.7,220.07 162.03,220.07 161.22,220.89 157,220.89 147.92,229.97 147.92,235.68 145.12,238.48 133.17,238.48 132.41,237.72 124.07,237.72 122.01,235.66 105.9,235.66 105.48,235.23 105.48,233.91 103.17,231.6 103.17,229.34 v4(102.29,228.46)
  BOTTOM w0.127: v2(223.99,46.45) 223.99,46.21 224.06,46.14 224.06,46.13 224.79,45.41 v1(224.79,45.38) 224.79,45.32 224.78,45.32 R1487.1
FPGA_STACKING_SYNC0_DIR: length 303.9
  TOP w0.127: P1.J20 v4(102.29,229.46)
  S16 w0.127: v4(102.29,229.46) 102.29,231.68 104.98,234.37 104.98,235.21 105.87,236.1 121.71,236.1 123.79,238.17 132.2,238.17 132.87,238.84 145.32,238.84 148.49,235.67 148.49,230 156.97,221.52 161.46,221.52 162.46,220.52 163.69,220.52 172.88,211.34 173.83,211.34 175.99,209.18 175.99,199.62 178.91,196.7 178.91,175.49 184.75,169.64 184.75,158.28 186.4,156.63 186.4,152.88 187.67,151.61 187.67,150.49 191.13,147.02 191.13,137.93 190.21,137.01 190.21,131.22 187.42,128.42 187.42,102.21 196.88,92.75 203.36,92.75 207.93,88.17 207.93,79.67 214.54,73.06 216.61,73.06 222.83,66.84 222.83,55.43 225.27,52.99 225.27,43.81 v1(226.35,42.73)
  BOTTOM w0.127: U88.3 228.23,39.44 228.06,39.61 228.06,40.67 228.02,40.71 ; 228.02,40.71 U88.2 230,40.71 230.28,40.99 230.28,44.81 v2(229.96,45.13) ; 228.02,40.71 226.35,42.38 v1(226.35,42.73) 226.82,43.2 R1489.1
FPGA_STACKING_SYNC1_DATA: length 311.2
  TOP w0.127: v4(103.29,222.46) 103.34,222.46 103.79,222.01 P1.K13 ; R1484.1 227.83,45.57 v1(226.68,46.72)
  S16 w0.127: v4(103.29,222.46) 102.73,223.02 100.04,223.02 99.68,223.38 99.68,223.62 99.45,223.85 99.21,223.85 98.77,224.29 98.77,230.49 98.89,230.62 98.89,230.62 99.12,230.85 99.13,230.85 101.1,232.82 101.1,235.07 101.71,235.69 102.39,235.69 103.53,236.83 121.02,236.83 123.18,238.99 126.24,238.99 129.04,241.78 142.83,241.78 143.89,240.72 144.78,240.72 149.63,235.86 149.63,232.57 158.27,223.94 160.45,223.94 163.11,221.28 164.36,221.28 170.9,214.73 173.07,214.73 177,210.8 177,200 180.56,196.44 180.56,193.52 179.67,192.63 179.67,176.38 185.88,170.17 185.88,161.15 187.93,159.1 187.93,154.15 191.99,150.09 191.99,137.21 191.1,136.32 191.1,130.58 188.43,127.92 188.43,102.33 197.13,93.63 203.87,93.63 208.92,88.59 208.92,79.86 211.83,76.95 213.02,76.95 213.75,76.22 213.75,74.73 214.85,73.63 217.18,73.63 223.45,67.36 223.45,55.63 226.68,52.41 v1(226.68,46.72)
  BOTTOM w0.127: v2(228.76,48.8) 228.76,48.8 v1(226.68,46.72)
FPGA_STACKING_SYNC1_DIR: length 313.8
  TOP w0.127: U87.2 228.25,39.44 228.06,39.62 228.06,40.62 228.15,40.71 ; 228.15,40.71 U87.3 ; 228.15,40.71 228.15,40.72 227.41,41.46 227.41,42.67 226.82,43.26 R1486.1 226.47,43.75 226.32,43.89 226.32,45.75 v1(225.78,46.29) ; P1.K14 v4(103.29,223.46)
  S16 w0.127: v1(225.78,46.29) 225.78,52.87 223.14,55.51 223.14,67.1 216.93,73.31 214.72,73.31 213.35,74.68 213.35,76.14 212.9,76.6 211.77,76.6 208.44,79.93 208.44,88.24 203.44,93.23 196.9,93.23 187.93,102.21 187.93,128.3 190.72,131.09 190.72,136.75 191.61,137.64 191.61,148.15 189.07,150.69 189.07,151.61 187.16,153.52 187.16,157.24 186.13,158.27 186.13,159.02 185.18,159.97 185.18,170.1 179.29,175.99 179.29,197.08 176.62,199.74 176.62,210.23 172.69,214.16 170.84,214.16 164.09,220.91 162.89,220.91 161.19,222.6 157.25,222.6 149.06,230.79 149.06,235.62 145.29,239.4 143.76,239.4 142.67,240.49 142.37,240.49 142.29,240.56 141.3,240.56 140.72,241.15 129.23,241.15 126.65,238.57 123.5,238.57 121.4,236.47 103.79,236.47 102.53,235.21 102.53,232.84 99.85,230.16 99.85,225.02 99.98,224.89 101.86,224.89 v4(103.29,223.46)
  BOTTOM w0.127: v2(226.72,48.23) 225.78,47.29 v1(225.78,46.29)
FPGA_STACKING_SYNC2_DATA: length 323.1
  TOP w0.127: P1.K19 v4(104.29,228.46)
  S16 w0.127: v4(104.29,228.46) 103.6,229.15 103.6,231.46 104.32,232.19 105.97,232.19 107.08,233.3 116.95,233.3 117.25,233.6 117.25,233.61 117.98,234.33 118.17,234.33 121.42,234.33 124.38,237.29 132.92,237.29 133.48,237.85 145.03,237.85 147.22,235.66 147.22,229.99 156.9,220.32 160.59,220.32 165.46,215.44 167.02,215.44 173,209.46 173.76,209.46 174.84,208.38 174.84,198.98 177.89,195.93 177.89,174.98 183.58,169.29 183.58,162.38 182.46,161.26 182.46,158.53 184.75,156.25 184.75,150.47 185.89,149.32 186.91,149.32 190.08,146.15 190.08,139.2 186.4,135.51 186.4,102.08 196.69,91.79 202.76,91.79 206.98,87.57 206.98,78.47 210.4,75.05 210.4,74.09 211.94,72.55 216.31,72.55 222.18,66.68 222.18,55.24 223.9,53.53 223.9,45.44 209.35,30.89 209.35,23.04 v1(207.81,21.5)
  BOTTOM w0.127: v1(207.81,21.5) 205.36,19.05 v2(205.36,18.78) 206.3,17.84 R1481.1
FPGA_STACKING_SYNC2_DIR: length 328.2
  TOP w0.127: P1.K20 v4(104.29,229.46)
  S16 w0.127: v4(104.29,229.46) 104.72,229.89 104.72,230.44 107.35,233.07 120.77,233.07 124.54,236.83 133.46,236.83 133.96,237.34 143.33,237.34 146.67,234 146.67,229.59 157.65,218.6 161.26,218.6 165.26,214.6 167.06,214.6 172.65,209.01 173.57,209.01 174.34,208.25 174.34,198.85 177.38,195.81 177.38,174.72 183.13,168.98 183.13,162.44 182.08,161.39 182.08,158.38 184.5,155.97 184.5,149.58 185.51,148.56 187.04,148.56 189.2,146.4 189.2,141.7 188.72,141.23 188.72,140.07 185.96,137.3 185.96,101.89 196.37,91.48 202.1,91.48 206.66,86.92 206.66,76.67 211.1,72.24 216.19,72.24 221.84,66.59 221.84,55.16 223.57,53.43 223.57,45.5 209,30.92 209,23.93 207.28,22.21 207.28,21.26 v1(207.86,20.68)
  BOTTOM w0.127: U86.2 205.88,12.79 206.02,12.93 206.02,13.93 205.89,14.06 ; 205.89,14.06 U86.3 203.05,14.06 v2(202.85,14.26) ; 205.89,14.06 207.32,15.49 R1483.1 207,16.83 206.82,17.02 206.82,19.64 v1(207.86,20.68)
FPGA_STACKING_SYNC3_DATA: length 308.5
  TOP w0.127: P1.L19 v4(105.29,228.46)
  S16 w0.127: v4(105.29,228.46) 106.21,229.39 106.21,230.98 107.49,232.26 124.24,232.26 126.97,234.99 135.93,234.99 136.35,235.41 142.93,235.41 145.57,232.76 145.57,229.17 154.63,220.11 154.63,217.68 155.67,216.63 160.75,216.63 164.13,213.26 166.66,213.26 171.86,208.06 172.96,208.06 173.19,207.83 173.19,197.2 175.99,194.41 175.99,171.88 180.69,167.18 180.69,158.66 183.1,156.25 183.1,148.24 185.83,145.51 187.2,145.51 187.99,144.73 187.99,140.22 185,137.24 185,101.51 196.12,90.4 202.24,90.4 204.56,88.07 204.56,83.17 205.72,82.01 205.72,77.78 205.72,75.23 209.28,71.66 215.94,71.66 221.22,66.39 221.22,54.97 222.9,53.28 222.9,45.59 206.4,29.09 206.4,27.41 206.71,27.1 v1(206.73,27.1)
  BOTTOM w0.127: R1478.1 206.4,26.8 206.71,27.1 ; 206.71,27.1 206.47,27.34 v2(206.47,28.17) ; 206.71,27.1 v1(206.73,27.1)
FPGA_STACKING_SYNC3_DIR: length 318.6
  TOP w0.127: P1.L20 v4(105.29,229.46)
  S16 w0.127: v4(105.29,229.46) 105.29,230.57 107.35,232.63 123.88,232.63 126.63,235.38 132.66,235.38 132.78,235.49 135.04,235.49 136.17,236.63 143.43,236.63 146.14,233.92 146.14,229.38 155.48,220.04 155.48,218.44 156.78,217.14 161.06,217.14 164.25,213.96 166.79,213.96 172.24,208.51 173.19,208.51 173.83,207.87 173.83,198.22 176.75,195.3 176.75,174.34 181.19,169.9 181.19,158.66 183.99,155.86 183.99,149.2 185.64,147.55 186.27,147.55 188.34,145.48 188.34,140.06 185.51,137.24 185.51,101.57 196.05,91.03 202.01,91.03 206.21,86.83 206.21,75.37 209.66,71.92 216.1,71.92 221.52,66.5 221.52,55.03 223.26,53.29 223.26,45.56 207.92,30.22 207.92,24.87 v1(207.4,24.35)
  BOTTOM w0.127: 205.96,22.66 206.79,22.66 207.4,23.27 v1(207.4,24.35) R1480.1 ; 205.96,22.66 206.09,22.53 206.09,21.5 205.98,21.39 U85.2 ; 205.96,22.66 U85.3 204.94,22.64 203.23,22.64 v2(202.78,23.09)
FPGA_UART1_TX: length 318.9
  TOP w0.127: v1(216.37,99.73) 217.07,99.03 217.07,94.52 215.43,92.87 203.73,92.87 203.23,93.38 203.23,94.97 203.61,95.34 R717.2 ; RB319.2 v1(235.6,152.7) ; P1.C2 v4(96.29,210.46)
  S14 w0.127: v1(235.6,152.7) 235.73,152.7 236.31,152.12 236.31,143.74 244.02,136.03 244.02,131.39 241.5,128.88 241.5,122.66 242.11,122.05 242.11,118.57 241.73,118.19 241.73,117.35 241.17,116.79 241.17,114.15 239.67,112.65 239.67,110.39 235.05,105.76 224.69,105.76 218.66,99.73 v1(216.37,99.73) 212.25,99.73 211.04,100.94 208.07,100.94 204.38,104.62 199.36,104.62 197.83,106.14 196.09,106.14 191.43,110.8 191.43,120.36 174.27,137.51 156.83,137.51 154.3,140.05 152.76,140.05 150.93,141.88 150.93,142.74 147.44,146.23 147.44,148.02 149.51,150.09 149.51,156.12 160.24,166.85 160.24,174.72 159.03,175.93 159.03,184.45 157.25,186.23 147.22,186.23 145,188.45 141.58,188.45 135.59,194.44 118.87,194.44 112.45,200.86 98.04,200.86 96.6,202.31 96.6,203.82 95.66,204.76 95.66,206.79 96.65,207.78 96.65,210.1 v4(96.29,210.46)
  BOTTOM w0.127: v2(217.52,99.79) 216.44,99.79 v1(216.37,99.73)
FPGA_VCCA_2V5: length 11.7
  TOP w0.381: P1.L4 v4(104.29,212.46) ; P1.F4 v4(99.29,212.46) ; P1.U19 v4(111.29,228.46)
  TOP w0.508: P1.F19 v4(99.29,228.46) ; P1.T5 v4(110.29,213.46) ; P1.V4 v4(112.29,212.46)
  BOTTOM w0.254: v4(104.29,212.46) 104,212.18 CB1142.1 ; CB1139.1 85.89,225.35 85.94,225.4 ; CB1139.1 85.36,225.95 85.44,226.03 ; CB1139.1 85.36,225.1 85.69,224.76 ; CB1143.1 99.03,228.2 v4(99.29,228.46) ; v4(111.29,228.46) 111.78,228.95 CB1144.1 ; v2(89.08,225.46) 88.93,225.31 87.68,225.31
  BOTTOM w0.305: v4(112.29,212.46) 112.02,212.72 CB1145.1 ; CB1140.1 99.01,212.73 v4(99.29,212.46) ; v4(110.29,213.46) 110.03,213.2 CB1141.1
  vias: v1(86.66,225.73) v1(86.66,225.04) v1(87.39,225.78) v1(87.42,225.04)
FT2232H_RESET_N: length 170.1
  TOP w0.127: P1.P10 v4(108.29,218.46) ; U71.14 235.45,188.58 v1(235.43,188.6)
  S9 w0.127: v1(235.43,188.6) 235.42,188.6 235.42,187.74 237.2,185.96 237.2,181.14 232.67,176.61 191.29,176.61 189.45,174.76 188.59,174.76 187.99,175.36 184.59,175.36 184.17,175.78 183.68,175.78 183.66,175.79 180.25,175.79 169.51,186.54 165.14,186.54 164.81,186.2 v1(164.81,186.2)
  S14 w0.127: v4(108.29,218.46) 108.8,217.94 108.8,208.95 109.85,207.9 110.49,207.9 111.83,206.56 111.83,205.34 112.83,204.33 112.83,202.89 119.51,196.22 140.15,196.22 144.43,191.93 146.78,191.93 148.81,189.9 159.54,189.9 163.02,186.42 164.59,186.42 v1(164.81,186.2)
  BOTTOM w0.127: v1(235.43,188.6) 234.8,189.23 R1491.1 ; v1(164.81,186.2) 164.81,186.2 165.14,186.54 166.27,186.54 v2(166.34,186.6)
GPS_TIME_PLUSE2: length 229.1
  TOP w0.127: CONN44.7 208.8,92.28 v1(206.25,92.28) 203.91,89.94 v1(203.91,87.96) ; P1.T22 109.79,231.43 v1(110.01,231.65)
  S16 w0.127: v1(203.91,87.96) 201.88,89.99 195.76,89.99 184.3,101.45 184.3,137.79 187.6,141.1 187.6,144.55 187.25,144.91 185.52,144.91 182.52,147.9 182.52,155.6 179.53,158.6 179.53,166.89 175.13,171.28 175.13,194.31 172.09,197.36 172.09,205.61 165.2,212.5 163.98,212.5 161.93,214.55 153.75,214.55 153.42,214.88 153.42,220.6 145.11,228.9 145.11,232.41 142.54,234.98 136.63,234.98 136.3,234.65 127.3,234.65 124.64,231.98 110.34,231.98 v1(110.01,231.65)
  BOTTOM w0.127: v1(206.25,92.28) 206.5,92.28 v2(207.04,91.74)
GPS_UART_R: length 7.2
  TOP w0.254: R714.1 R717.1 205.01,94.35 R726.1 205.6,94.34 v1(205.9,94.05) CONN44.5
  BOTTOM w0.127: v1(205.9,94.05) 206.06,93.89 v2(206.91,93.89)
GPS_UART_RX: length 258.7
  TOP w0.127: v1(210.47,104.37) 210.34,104.24 R729.1 ; R319.2 v1(99,237.69)
  S12 w0.127: v1(210.47,104.37) 210.98,104.37 214.09,107.48 214.09,114.53 215.99,116.43 215.99,138.28 218.6,140.88 v1(219.42,140.88)
  S14 w0.127: v1(99,237.69) 99,238.23 105.01,244.24 107.95,244.24 110.36,246.66 132.67,246.66 133.62,245.72 136.07,245.72 136.65,245.14 140.13,245.14 141.37,246.38 145.82,246.38 155.73,236.47 157.47,236.47 157.76,236.19 157.76,229.67 158.09,229.34 160.15,229.34 165.86,223.63 165.86,221.3 165.45,220.89 165.45,215.24 171.08,209.61 179.51,209.61 180.68,208.43 208.68,208.43 214,203.12 214,189.72 214.53,189.19 214.53,155.33 213.2,154 213.2,146.36 218.68,140.88 v1(219.42,140.88)
  BOTTOM w0.127: v1(210.47,104.37) 209.58,105.26 v2(209.52,105.26)
GPS_UART_RX_R: length 8.9
  TOP w0.127: P1.G22 100.79,232.09 99.09,233.79 v1(99.09,235.11) 99.09,235.84 R319.1
  BOTTOM w0.127: v1(99.09,235.11) 98.07,236.13 v2(98.07,237.84)
GPS_UART_T: length 8.4
  TOP w0.127: CONN44.3 210.4,96.05 211.04,96.68 211.04,99.84 v1(210.92,99.96) 210.34,100.54 R729.2
  BOTTOM w0.127: v2(211.41,100.83) 210.92,100.35 v1(210.92,99.96)
HDD_LED_N: length 38.8
  TOP w0.127: v1(149.88,255.9) 151.6,254.18 D10.C1 157.57,254.17 R1293.1 ; J3.10 v1(129.97,256.68)
  S12 w0.127: v1(129.97,256.68) 129.97,255.73 130.58,255.12 140.61,255.12 140.86,254.86 148.83,254.86 v1(149.88,255.9)
  BOTTOM w0.127: v2(154.46,254.92) 150.85,254.92 v1(149.88,255.9)
HEATER_VCC12: length 33
  TOP w0.381: v1(235.59,234.21) 235.65,234.14 R7.1
  S9 w0.508: v1(242.28,247.05) 242.57,246.76 242.57,236.8 239.99,234.21 v1(235.59,234.21)
  S16 w0.508: 69.64,227.94 CONN6.1 ; CONN6.1 72.31,227.94 ; CONN6.1 70.97,229.27 ; CONN6.1 70.97,226.6
  BOTTOM w0.254: v1(242.28,247.05) 242.26,247.03 v2(242.26,245.76)
  BOTTOM w0.508: v1(244.69,257.66) 245.15,257.2 v2(245.15,256.91) ; 69.64,227.94 CONN6.1 ; CONN6.1 72.31,227.94 ; CONN6.1 70.97,229.27 ; CONN6.1 70.97,226.6 ; C25.2 70.96,224
  vias: v1(69.69,225.97) v1(69.69,225.08) v1(69.69,224.25) v1(72.93,229.72) v1(72.93,228.83) v1(72.93,228) v1(242.66,258.54) v1(242.66,257.66) v1(243.55,247.05) v1(243.68,258.54) v1(243.68,257.66) v1(244.69,258.54) v1(244.82,247.05) v1(245.71,258.54) v1(245.71,257.66) v1(246.09,247.05) v1(246.85,258.54) v1(246.85,257.66) v1(247.36,247.05) v1(247.87,258.54) v1(247.87,257.66) v1(261.2,162.28) v1(261.25,161.5) v1(261.29,160.72) v1(261.32,159.97) v1(262.05,162.3) v1(262.06,161.5) v1(262.12,160.72)
HEATER_VCC12_MON: length 12.1
  TOP w0.254: U7.1 234.58,225.07 v1(234.97,225.47) 235.65,226.15 C22.1 236.12,226.66 236.32,226.86 236.32,228.61 235.92,229.01 235.92,229.07 R19.1 235.27,229.07 235.09,229.26 235.09,231.43 235.65,231.99 R7.2
  BOTTOM w0.127: v1(234.97,225.47) 234.98,225.46 235.3,225.46 v2(236.31,226.48)
HSDAC_N: length 7.3
  TOP w0.095: U52.M6 v3(231.18,117.65)
  BOTTOM w0.095: TP50.1 235.97,115.95 235.97,116.97 235.71,117.22 231.61,117.22 v3(231.18,117.65)
HSDAC_P: length 7.3
  TOP w0.095: U52.M5 v3(230.18,117.65)
  BOTTOM w0.095: v3(230.18,117.65) 229.75,117.22 225.93,117.22 224.66,115.95 TP49.1
HW_RESET: length 63
  TOP w0.254: R25.1 v1(227.61,230.85)
  TOP w0.508: SW1.1 SW1.2 255.04,194.56 D1.A 249.52,196.39 R539.2 C280.1 248.94,198.27 v1(248.95,198.27)
  S12 w0.127: v1(227.61,230.85) 229.25,229.21 229.78,229.21 230.54,228.46 230.54,227.43 235.99,221.97 235.99,212.15 238.69,209.46 239.04,209.46 v1(240,208.51)
  S16 w0.127: v1(248.95,198.27) 248.95,199.56 v1(240,208.51)
  BOTTOM w0.127: v2(228.06,232.26) 228.06,231.3 v1(227.61,230.85) ; v1(240,208.51) 240.57,207.93 v2(241.2,207.93)
I2C_0_SCL: length 98.5
  TOP w0.127: J2.B33 159.94,145.81 159.29,146.47 v1(159.22,146.47) ; v1(152.43,207.3) 155.6,207.3 161.26,212.95 161.26,217.65 v1(159.67,219.24) 158.85,220.06 U10.22
  S12 w0.127: v1(152.43,207.3) 152.43,205.01 169.31,188.13 169.31,187.73 169.32,187.72 169.32,175.68 170.18,174.82 170.18,169.25 159.69,158.77 159.69,150.39 159.1,149.79 159.1,146.59 v1(159.22,146.47)
  BOTTOM w0.127: v1(159.67,219.24) 159.67,219.56 v2(160.62,220.51) ; RB1231.2 159.1,146.59 v1(159.22,146.47) 159.22,146.42 158.71,145.9 v2(158.35,145.9)
I2C_0_SCL_CPLD1: length 64.5
  TOP w0.127: R263.1 156.34,212.87 155.1,211.62 144.27,211.62 v1(142.88,210.22)
  TOP w0.508: P1.K12 v4(103.29,221.46)
  S14 w0.127: v4(103.29,221.46) 103.77,220.97 104.73,220.97 105.37,220.33 116.6,220.33 116.96,219.97 116.96,219.34 118.28,218.03 121.41,218.03 121.99,217.45 123.03,217.45 124.22,216.25 125.5,216.25 127.31,214.45 130.29,214.45 130.58,214.16 131.48,213.27 133.27,213.27 133.55,213.54 135.13,213.54 135.89,212.78 142.65,212.78 143.43,211.99 143.43,210.78 v1(142.88,210.22)
  BOTTOM w0.127: v1(142.88,210.22) 143.89,209.2 v2(143.98,209.2)
I2C_0_SCL_CPLD2: length 68.4
  TOP w0.127: v1(158.65,213.01) 158.63,213.04 R230.1 ; U9.M13 v4(202.55,187.58)
  S7 w0.127: v1(158.65,213.01) 159.92,211.74 173.85,211.74 177.85,207.74 193.39,207.74 v1(194.72,206.41)
  S12 w0.127: v1(194.72,206.41) 194.86,206.41 197.56,203.71 202.86,203.71 203.2,203.36 203.2,202.89 202.99,202.67 202.99,200.68 203.1,200.57 203.1,193.33 202.85,193.08 202.34,193.08 202.09,192.82 202.09,188.04 v4(202.55,187.58)
  BOTTOM w0.127: v1(194.72,206.41) 193.77,207.36 v2(193.64,207.36)
I2C_0_SCL_SWITCH_CPLD1_R: length 8.4
  TOP w0.127: R263.2 v1(156.34,215.62) R262.2 155.88,216.43 155.67,216.63 155.67,218.92 154.95,219.64 U10.16
  BOTTOM w0.127: v2(155.79,216.7) 155.79,216.17 v1(156.34,215.62)
I2C_0_SCL_SWITCH_CPLD2_R: length 8.9
  TOP w0.127: R230.2 158.63,215.6 v1(158.65,215.62) 158.63,215.64 R229.2 158.15,216.43 157.97,216.6 157.97,218.39 156.25,220.12 U10.18
  BOTTOM w0.127: v1(158.65,215.62) 158.78,215.49 v2(158.78,214.28)
I2C_0_SDA: length 92.7
  TOP w0.127: v1(160.11,146.59) 160.44,146.27 J2.B34 ; R180.2 161.82,216.38 161.82,212.09 155.89,206.16 v1(153.51,206.16)
  S12 w0.127: v1(160.11,146.59) 160.11,149.11 160.09,149.14 160.09,149.63 160.81,150.36 160.81,152.37 160.56,152.63 160.56,158.37 171.35,169.17 171.35,178.66 170.4,179.61 170.4,188.25 153.51,205.14 v1(153.51,206.16)
  BOTTOM w0.127: v2(153.76,204.95) 153.76,205.9 v1(153.51,206.16) ; RB1232.2 v1(160.11,146.59) 160.12,146.58 v2(160.12,144.62)
I2C_0_SDA_CPLD1: length 89.2
  TOP w0.127: v1(87.66,209.46) 87.98,209.14 R162.2 ; v1(155.04,212.88) 155.07,212.92 R281.1
  S9 w0.127: v1(154.65,208.25) 152.14,205.74 141.09,205.74 140.68,205.33 137.44,205.33 135.09,202.98 135.09,202.28 129.63,196.82 96.03,196.82 86.68,206.17 86.68,208.48 v1(87.66,209.46)
  S12 w0.127: v1(154.65,208.25) 154.74,208.34 154.74,212.58 v1(155.04,212.88)
  BOTTOM w0.127: v1(154.65,208.25) 155.22,207.68 v2(155.22,207.49)
I2C_0_SDA_CPLD1_R: length 12.3
  TOP w0.127: P1.A4 94.4,212.96 92.99,211.55 92.99,209.91 91.91,208.82 v1(91.15,208.82) 90.83,209.14 R162.1
  BOTTOM w0.127: v1(91.15,208.82) 90.58,208.25 90.58,207.47 91.47,206.58 v2(91.47,204.57)
I2C_0_SDA_CPLD2: length 77.1
  TOP w0.127: R248.1 157.36,212.93 v1(157.32,212.89)
  S7 w0.127: v1(157.32,212.89) 159.1,211.11 173.76,211.11 178.02,206.86 191.04,206.86 v1(195.48,202.41)
  BOTTOM w0.127: R363.1 183.77,187.76 180.61,187.76 180.18,188.19 180.18,193.01 181.07,193.9 181.07,194.79 183.3,197.03 185.43,197.03 185.87,197.47 189.11,197.47 189.56,197.01 194.7,197.01 195.11,197.42 195.11,199.61 195.48,199.98 v1(195.48,202.41) 195.48,202.85 v2(195.99,203.36)
I2C_0_SDA_CPLD2_R: length 16.2
  TOP w0.127: v4(199.55,186.58) U9.N10
  BOTTOM w0.127: R363.2 185.98,187.02 186.47,186.54 v2(187.8,186.54) 188.36,187.09 194.81,187.09 195.11,186.79 195.11,186.31 195.37,186.05 199.03,186.05 v4(199.55,186.58)
I2C_0_SDA_R: length 6
  TOP w0.127: R180.1 161.76,218.03 v1(160.56,219.24) 160.43,219.24 159.5,220.17 U10.23
  BOTTOM w0.127: v2(160.94,218.09) 160.94,218.86 v1(160.56,219.24)
I2C_0_SDA_SWITCH_CPLD1_R: length 8.7
  TOP w0.127: U10.15 154.3,219.4 154.57,219.13 154.57,216.59 154.73,216.43 R280.2 v1(155.07,215.62) R281.2
  BOTTOM w0.127: v1(155.07,215.62) 155.07,215.34 v2(153.89,214.16)
I2C_0_SDA_SWITCH_CPLD2_R: length 8.9
  TOP w0.127: R248.2 157.36,215.6 v1(157.38,215.62) 157.36,215.64 R247.2 157.02,216.43 156.85,216.6 156.85,219.01 155.6,220.26 U10.17
  BOTTOM w0.127: v2(156.62,214.16) 156.62,214.86 v1(157.38,215.62)
I2C_1_SCL: length 217.1
  TOP w0.127: J2.B13 149.94,146.2 150.4,146.66 v1(150.4,146.78)
  S9 w0.127: v1(177.51,11.4) 181.89,11.4 189.68,19.2 195.72,19.2 200.88,24.36 203.04,24.36 214.27,35.59 214.27,38.87 222.2,46.8 222.2,66.4 214.72,73.89 213.52,73.89 208.25,79.16 208.25,101.28 203.67,105.85 v1(203.67,106.27)
  S14 w0.127: v1(203.67,106.27) 202.59,107.35 196.31,107.35 192.44,111.22 192.44,120.91 173.87,139.48 156.24,139.48 153.43,142.29 153.43,143.75 v1(150.4,146.78)
  BOTTOM w0.127: v2(149.89,146.16) 149.89,146.27 v1(150.4,146.78) 150.4,148.71 150,149.1 RB1230.2 ; UB17.22 177.66,11.36 177.61,11.4 v1(177.51,11.4) 176.56,10.45 v2(176.56,7.59)
I2C_1_SDA: length 206.2
  TOP w0.127: v1(151.22,146.97) 151.09,146.84 151.09,146.5 150.44,145.85 J2.B14
  S9 w0.127: v1(203.74,107.1) 203.8,107.1 205.71,105.19 205.71,104.73 209.07,101.36 209.07,80.3 213.34,76.03 213.34,75.02 213.86,74.49 214.83,74.49 222.71,66.61 222.71,46.59 214.9,38.78 214.9,35.15 209.64,29.9 209.64,28.42 206.98,25.75 205.64,25.75 203.28,23.4 200.8,23.4 195.01,17.61 195.01,12.46 193.7,11.15 v1(190.4,11.15)
  S14 w0.127: v1(151.22,146.97) 153.54,144.66 154.99,144.66 155.85,143.79 155.85,140.93 156.66,140.12 174.08,140.12 193.01,121.19 193.01,111.6 196.62,107.99 202.85,107.99 v1(203.74,107.1)
  BOTTOM w0.127: RB1229.2 151.02,148.67 v2(151.63,148.06) 151.22,147.66 v1(151.22,146.97) ; v2(191.1,9.75) 191.1,10.45 v1(190.4,11.15) 190.35,11.1 RB721.2
I2C_1_SDA_R: length 10
  BOTTOM w0.127: RB721.1 186.54,11.1 v2(186.46,11.02) 186.15,10.71 UB17.23
I2C_CPU0_RESET_N: length 100
  TOP w0.127: v1(158.84,223.3) 158.84,224.57 158.85,224.58 U10.3 ; P1.B7 v4(95.29,215.46)
  S7 w0.127: v1(93.25,208.51) 93.25,211.23 93.21,211.26 93.21,211.72 93.25,211.75 93.25,213.42 v4(95.29,215.46)
  S9 w0.127: v1(160.58,215.6) 159.9,214.92 146.05,214.92 145.86,215.11 141.3,215.11 139.29,213.1 136.7,213.1 134.88,211.29 134.88,210.54 133.57,209.23 132.58,209.23 127.68,204.33 127.03,204.33 126.71,204.01 126.71,202.89 126.71,202.47 125.58,201.35 104.93,201.35 101.83,204.45 100.98,204.45 100.74,204.7 98.85,204.7 97.33,206.22 94.58,206.22 93.26,207.54 93.26,208.49 v1(93.25,208.51)
  S14 w0.127: v1(158.84,223.3) 159.2,222.95 159.2,217.43 160.62,216.01 160.62,215.64 v1(160.58,215.6)
  BOTTOM w0.127: v1(158.84,223.3) 159.16,223.62 v2(159.92,223.62)
I2C_CPU1_RESET_N: length 341
  TOP w0.127: P1.AB14 v4(116.29,223.46)
  S9 w0.127: v1(174.36,11.35) 175.55,10.16 194.17,10.16 195.9,11.88 195.9,17.24 201.3,22.64 203.36,22.64 205.9,25.18 207.13,25.18 210.53,28.58 210.53,29.83 215.41,34.71 215.41,38.57 223.22,46.38 223.22,66.82 215.23,74.81 215.23,75.22 213.33,77.12 213.33,81.13 210.09,84.36 210.09,96.62 215.29,101.83 v1(215.29,103.79)
  S14 w0.127: v1(215.29,103.79) 216.15,102.94 219.64,102.94 220.75,104.05 220.75,105.34 217.45,108.64 217.45,112.56 217.14,112.87 217.14,131.8 217.14,131.81 217.14,132.23 212.69,136.68 194.49,136.68 194.11,137.06 194.11,140.54 194.44,140.87 194.44,142.23 192.53,144.14 191.57,145.1 191.57,146.23 189.54,148.26 188.9,148.26 188.8,148.26 188.8,148.26 188.61,148.26 184.26,152.61 184,152.61 180.54,156.07 180.54,158.24 177.51,161.27 177.51,185.77 164.97,198.31 164.23,198.31 157,198.31 148.16,207.16 148.16,213.42 141.77,219.81 135.89,219.81 133.99,221.72 127.87,221.72 124.62,224.97 122.96,224.97 122.46,224.47 121.04,224.47 120.65,224.85 117.68,224.85 v4(116.29,223.46)
  BOTTOM w0.127: UB17.3 174.35,11.36 v1(174.36,11.35) 174.46,11.25 v2(174.46,7.53)
I2C_USBHUB_SDA_R: length 5.7
  TOP w0.127: R391.1 210.09,131.79 210.09,130.85 v1(209.83,130.59) 207.99,130.59 207.36,129.96 U24.22
  BOTTOM w0.127: v2(210.66,130.15) 210.28,130.15 v1(209.83,130.59)
ID_BUTTON: length 111.7
  TOP w0.127: P1.E22 98.79,231.41 96.99,233.21 96.99,234.6 96.49,235.11 96.49,238.03 v1(96.99,238.54) ; v1(10.19,210.67) 10.15,210.62 SWB2.2
  S12 w0.127: v1(96.99,238.54) 95.18,236.73 91.5,236.73 88.29,233.53 84.42,233.53 71.13,220.23 58.99,220.23 46.92,208.17 42.07,208.17 41.64,208.6 36.64,208.6 34.57,210.67 v1(10.19,210.67)
  BOTTOM w0.127: v1(10.19,210.67) 10.95,209.9 11.01,209.9 v2(11.08,209.97)
ID_BUTTON_R: length 4.6
  TOP w0.127: RB744.1 11.79,214.37 v1(10.13,214.37) SWB2.1
  BOTTOM w0.508: v1(10.13,214.37) 10.59,213.9 v2(11.59,213.9)
INT_BITS_L: length 106
  TOP w0.127: P1.G15 v4(100.29,224.46)
  TOP w0.508: R1122.1 v1(173.04,219.17)
  S9 w0.127: v4(100.29,224.46) 99.88,224.87 99.88,229.7 100.23,230.05 100.23,232.06 99.63,232.66 99.63,234.63 99.81,234.81 99.81,234.84 99.82,234.85 99.82,235.57 101.57,237.31 101.57,238.48 103.98,240.89 120.23,240.89 122.56,238.56 146.21,238.56 149.97,234.8 167.35,234.8 v1(167.54,234.99)
  S12 w0.127: v1(173.04,219.17) 168.75,223.47 168.75,232.95 167.61,234.1 167.61,234.92 v1(167.54,234.99)
  BOTTOM w0.127: v2(171.86,219.05) 172.91,219.05 v1(173.04,219.17)
INT_BITS_L_R: length 11.4
  TOP w0.127: R1122.2 R182.1 177.46,220.19 177.58,220.06 R1081.1 178.4,219.68 179.79,221.07 U68.59 181.86,221.07 v1(181.87,221.07)
  BOTTOM w0.127: v1(181.87,221.07) 181.87,219.33 v2(182.34,218.86)
INT_MGMT_PHY_N: length 230
  TOP w0.127: RB761.2 213.51,119.02 v1(212.75,118.27) ; P1.B1 96.22,209.52 v4(96.23,209.52)
  S5 w0.127: v1(212.75,118.27) 211.37,116.89 206.8,116.89 205.64,115.73 205.64,110.97 201.96,107.29 198.97,107.29 v1(197.32,105.64)
  S14 w0.127: v4(96.23,209.52) 96.23,208.25 94.64,206.66 94.64,204.89 95.66,203.87 95.66,202.6 97.93,200.33 112.47,200.33 118.81,193.99 134.6,193.99 141.78,186.81 146.1,186.81 146.93,185.98 156.67,185.98 157.57,185.08 157.57,173.86 156.56,172.84 156.56,164.56 148.17,156.18 148.17,152.67 145.49,149.98 145.49,146.11 146.42,145.17 148.06,145.17 150.53,142.71 150.53,141.41 152.47,139.48 154.15,139.48 156.43,137.19 173.98,137.19 190.99,120.18 190.99,110.69 196.05,105.64 v1(197.32,105.64)
  BOTTOM w0.127: v1(212.75,118.27) 214.21,116.81 v2(214.21,116.75)
IO_VDDP_1P8: length 6.1
  TOP w0.381: v4(29.7,122.65) U40.AE28 ; v4(28.7,119.65) U40.AB29
  BOTTOM w0.381: v4(29.7,122.65) 29.7,122.64 CB489.1 ; v4(28.7,119.65) 28.2,119.15 CB529.1 ; v1(18.44,137.98) 18.44,140.24 v2(19.14,140.94)
  vias: v1(18.44,137.29) v1(18.44,136.6)
IP_LED_CLK0: length 284.7
  TOP w0.127: U9.K16 v4(205.55,189.58) ; v1(5.82,116.78) 6.41,116.78 R679.2
  S5 w0.127: v1(22.95,181.52) 22.76,181.71 v1(16.03,181.71)
  S7 w0.127: v1(5.82,116.78) 6.37,117.32 6.37,129.84 3.51,132.69 3.51,153.09 3.29,153.31 3.29,157.74 3.63,158.08 3.63,164.24 8.58,169.19 8.58,171.65 16.03,179.11 v1(16.03,181.71)
  S9 w0.127: v1(131.85,190.35) 132.47,190.96 139.86,190.96 143.92,195.02 146.07,195.02 146.96,194.13 152.78,194.13 152.94,193.96 168.72,193.96 174.68,199.92 176.22,199.92 179.84,203.54 190.34,203.54 192.81,201.07 202.21,201.07 203.96,199.31 203.96,191.17 v4(205.55,189.58)
  S16 w0.127: v1(131.85,190.35) 130.2,192 85.69,192 76.29,182.6 67.85,182.6 66.96,181.71 23.14,181.71 v1(22.95,181.52)
IP_LED_DATA0: length 270.6
  TOP w0.127: v1(5.78,117.52) 5.96,117.7 R661.1 ; U9.E10 v4(199.55,195.58)
  S5 w0.127: v1(23.84,182.28) 23.49,182.63 v1(16.22,182.63)
  S7 w0.127: v1(5.78,117.52) 5.29,118.02 5.29,125.04 3.3,127.03 3.3,132.55 3.26,132.59 3.26,152.98 3.02,153.22 3.02,164.06 7.51,168.55 7.51,171.21 15.51,179.2 15.51,182.07 16.07,182.63 v1(16.22,182.63)
  S9 w0.127: v4(199.55,195.58) 199.99,196.02 199.99,197.79 199.71,198.07 185.65,198.07 185.12,197.54 175.82,197.54 170.62,192.34 152.27,192.34 152.11,192.5 149.81,192.5 149.38,192.07 144.75,192.07 141.74,189.06 136.61,189.06 v1(136.27,188.72)
  S16 w0.127: v1(23.84,182.28) 23.96,182.17 66.78,182.17 67.47,182.85 76.04,182.85 85.56,192.38 132.62,192.38 v1(136.27,188.72)
  BOTTOM w0.127: v1(136.27,188.72) 137.35,188.72 v2(137.38,188.69)
JTAG_BUFFER_OE_N: length 11.9
  TOP w0.127: R337.1 221.96,242.31 221.67,242.02 219.9,242.02 U20.19 218.58,242.04 217.92,242.7 v1(216.46,242.7) U20.1
  BOTTOM w0.127: v2(216.06,241.84) 216.06,242.3 v1(216.46,242.7)
JTAG_CPLD2_TCK: length 9.9
  TOP w0.127: U9.R4 v4(192.55,184.58) ; R302.1 R289.1 185.51,185.09 v1(186.45,185.09)
  BOTTOM w0.127: v1(186.45,185.09) 187.44,184.1 v2(187.76,184.1) 188.74,184.1 189.68,185.04 192.09,185.04 v4(192.55,184.58)
JTAG_CPLD2_TDI: length 14.1
  TOP w0.127: v4(195.55,187.58) U9.M7 ; R275.2 R258.1 186.53,187.02 v1(186.78,187.27)
  BOTTOM w0.127: v4(195.55,187.58) 195.12,188.01 189,188.01 189,188.01 188.46,188.01 187.97,188.5 v2(186.46,188.5) 186.4,188.44 186.4,187.65 v1(186.78,187.27)
JTAG_CPLD2_TDO_R: length 13.7
  TOP w0.127: v1(186.26,182.17) 186.03,181.94 R318.1 ; U9.N6 v4(194.55,186.58)
  BOTTOM w0.127: R318.1 186.03,181.94 v1(186.26,182.17) v2(187.48,182.17) 189.41,184.1 193.73,184.1 193.98,184.36 193.98,186.01 v4(194.55,186.58)
JTAG_CPLD2_TMS: length 13.6
  TOP w0.127: v1(186.28,182.96) R311.1 ; U9.P5 v4(193.55,185.58)
  BOTTOM w0.127: v4(193.55,185.58) 193.52,185.58 192.96,186.13 189.14,186.13 188.71,185.71 186.05,185.71 185.75,186.01 RB109.2 v2(185.42,184.08) 185.42,183.82 v1(186.28,182.96)
JTAG_TCK: length 72.3
  TOP w0.127: 213.52,242.04 215.96,242.04 216.55,241.46 v1(217.88,241.46) ; 213.52,242.04 U20.2 ; 213.52,242.04 213.71,241.86 213.71,241.06 213.37,240.72 ; R633.2 253.14,219.07 v1(253.1,219.11) ; U20.6 213.39,239.4 ; 213.39,239.4 213.39,239.43 213.64,239.68 213.64,240.45 213.37,240.72 ; 213.39,239.4 213.57,239.22 213.57,238.25 213.4,238.08 U20.8 ; 213.37,240.72 U20.4 ; R351.1 v1(244.69,236.83)
  S7 w0.127: v1(244.69,236.83) 254.6,226.92 254.6,220.61 v1(253.1,219.11)
  S14 w0.127: v1(244.69,236.83) 244.07,236.83 243.27,237.63 243.27,242.03 241.94,243.36 219.79,243.36 v1(217.88,241.46)
  BOTTOM w0.127: v2(244.57,235.62) 244.57,236.7 v1(244.69,236.83)
JTAG_TDI: length 203.1
  TOP w0.127: R1344.1 98.16,203.07 98.14,203.05 98.14,203.09 v1(98.15,203.09) ; v1(230.72,239.24) 230.71,239.23 R370.1 ; v1(253.03,227.16) 253.04,227.15 R555.2
  S9 w0.127: v1(210.08,235.86) 210.09,235.86 210.09,235.08 211.17,234 211.17,222.19 200.28,211.3 180.95,211.3 179.73,212.52 178.1,212.52 177.83,212.24 142.19,212.24 141.53,211.58 138.8,211.58 138.27,211.05 138.27,210.03 136.14,207.9 135.56,207.9 134.57,206.91 134.57,205.76 133.97,205.16 131.3,205.16 130.27,204.12 130.27,200.44 129.34,199.51 129.27,199.51 128.36,198.6 101.31,198.6 98.15,201.76 v1(98.15,203.09)
  S14 w0.127: v1(253.03,227.16) 253.03,228.87 247.74,234.16 244.41,234.16 242.52,236.04 242.52,238.91 241.78,239.66 240.9,239.66 239.91,238.68 237.57,238.68 235.1,241.15 231.98,241.15 230.72,239.89 v1(230.72,239.24) 227.45,235.97 210.19,235.97 v1(210.08,235.86)
  BOTTOM w0.127: v1(210.08,235.86) 210.48,236.26 v2(211.17,236.26)
JTAG_TDO: length 138.5
  TOP w0.127: R609.2 253.64,222.12 253.63,222.13 253.13,222.13 v1(253.06,222.06) ; v1(248.06,242.03) 248.09,242 R379.1 ; v1(187.94,174.54) 187.41,174.02 185.39,174.02 184.57,174.83 184.57,175.98 184.84,176.25 U22.7
  S5 w0.127: v1(253.06,222.06) 252.37,222.75 252.37,231.31 248.06,235.62 v1(248.06,242.03)
  S12 w0.127: v1(216.41,216.76) 216.5,216.76 216.5,208.57 209.39,201.46 209.39,194.73 208.76,194.1 208.76,178.92 204.37,174.54 v1(187.94,174.54)
  S16 w0.127: v1(216.41,216.76) 220.98,212.19 243.19,212.19 v1(253.06,222.06)
  BOTTOM w0.127: v2(188.05,173.07) 187.94,173.19 v1(187.94,174.54)
JTAG_TMS: length 62.6
  TOP w0.127: 218.79,238.08 U20.13 221.21,238.08 221.6,237.7 222.24,237.7 222.35,237.59 226.72,237.59 v1(229.64,240.51) R383.1 ; 218.79,238.08 218.61,238.25 218.61,239.31 218.71,239.4 ; 218.79,238.08 218.61,237.91 218.61,237.13 218.98,236.76 U20.11 ; 218.71,239.4 218.56,239.56 218.56,240.6 218.68,240.72 U20.17 ; 218.71,239.4 U20.15 ; v1(253.1,224.05) 253.16,224.11 253.55,224.11 253.56,224.13 R586.2
  S14 w0.127: v1(229.64,240.51) 230.75,241.62 235.36,241.62 236.38,242.65 240.46,242.65 242.91,240.2 242.91,237.04 245.2,234.75 248.04,234.75 254.99,227.81 254.99,225.94 v1(253.1,224.05)
  BOTTOM w0.127: v2(230.91,241.21) 230.34,241.21 v1(229.64,240.51)
L1_RCVRD_CLK: length 206.5
  TOP w0.127: U5.2 164.81,180.95 164.81,180.95 164.81,180.51 v1(164.83,180.49) ; v1(15.25,135.45) 14.99,135.45 R486.1 R487.2
  S7 w0.127: v1(164.83,180.49) 164.83,180.13 164.51,179.8 162.33,179.8 159.22,176.69 159.21,176.69 159.21,176.23 155.54,172.57 152.67,172.57 152.16,172.06 152.16,171.59 151.66,171.09 146.4,171.09 146.04,171.45 143.75,171.45 141.95,169.64 140.91,169.64 138.23,166.96 136.78,166.96 130,173.74 128.05,173.74 125.96,175.83 114.68,175.83 114.14,176.38 107.09,176.38 104.68,178.79 100.49,178.79 99.76,178.06 54.22,178.06 53.5,178.79 36.99,178.79 33.68,175.49 20.43,175.49 15.24,170.3 15.24,168.05 14.44,167.25 14.44,161.25 14.13,160.94 14.13,156.6 14.76,155.97 14.76,149.68 14.8,149.62 16.04,148.39 16.04,144.06 13.62,141.64 13.62,137.09 v1(15.25,135.45)
L1_RCVRD_CLK_BKUP: length 202.9
  TOP w0.127: R483.2 15.83,136.05 15.46,136.05 14.97,136.54 ; 14.97,136.54 14.97,136.45 R482.1 ; 14.97,136.54 v1(14.97,136.75) ; UB2.2 164.81,177.51 164.68,177.65 v1(164.68,177.77)
  S7 w0.127: v1(164.68,177.77) 163.73,176.82 162.27,176.82 160.18,174.72 158.95,174.72 156.05,171.82 156.05,171.32 154.7,169.97 152.02,169.97 151.58,170.41 146.11,170.41 145.86,170.66 143.81,170.66 142.71,169.57 142.71,169.09 142,168.37 140.94,168.37 138.43,165.86 136.66,165.86 133.1,169.42 123.25,169.42 120.23,172.44 117.46,172.44 114.79,175.11 107.28,175.11 104.93,177.45 53.81,177.45 53.05,178.22 46.38,178.22 44.67,176.5 35.44,176.5 33.98,175.04 33.96,175.04 33.89,174.98 20.64,174.98 16.09,170.43 16.09,166.47 15.4,165.77 15.4,164.68 16.04,164.03 16.04,162.98 15.27,162.21 15.27,160.63 14.72,160.09 14.72,156.96 15.27,156.41 15.27,149.9 16.63,148.53 16.63,143.83 14.29,141.49 14.29,137.43 v1(14.97,136.75)
