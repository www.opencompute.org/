# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Nets (continued)
Pads without a net: CONN28 6 7 8; CONN53_PF G4 G5 G6 G7 G8 G9 G10 G11 G12 G13 G14 G15 G16 G17 G18 G19 G20 G21; CONN54_PF G4 G5 G6 G7 G8 G9 G10 G11 G12 G13 G14 G15 G16 G17 G18 G19 G20 G21 G25 G26 G27 G28 G29 G30 G31 G32 G33 G34 G35 G36 G40 G41 G42 G43 G44 G45 G46 G47 G48 G49 G50 G51 G55 G56 G57 G58 G59 G60 G61 G62 G63 G64 G65 G66 G70 G71 G72 G73 G74 G75 G76 G77 G78 G79 G80 G81 G85 G86 G87 G88 G89 G90 G91 G92 G93 G94 G95 G96; CONN55_PF G4 G5 G6 G7 G8 G9 G10 G11 G12 G13 G14 G15 G16 G17 G18 G19 G20 G21 G25 G26 G27 G28 G29 G30 G31 G32 G33 G34 G35 G36 G40 G41 G42 G43 G44 G45 G46 G47 G48 G49 G50 G51 G55 G56 G57 G58 G59 G60 G61 G62 G63 G64 G65 G66 G70 G71 G72 G73 G74 G75 G76 G77 G78 G79 G80 G81 G85 G86 G87 G88 G89 G90 G91 G92 G93 G94 G95 G96; CONN58 1 2 3 4 6; J1_PF 6 7 8 9 10; J2 A18 A22 A23 A25 A26 A29 A30 A32 A33 A34 A36 A37 A39 A40 A44 A48 A52 A53 A55 A56 A58 A59 A64 A65 A71 A72 A73 A74 A75 A76 A77 A78 A79 A81 A82 A83 A84 A86 A87 A91 A92 A94 A95 A96 A97 B8 B9 B12 B15 B16 B17 B18 B19 B20 B22 B23 B25 B26 B28 B29 B30 B32 B36 B37 B39 B40 B42 B43 B45 B46 B47 B48 B52 B53 B55 B56 B58 B59 B64 B65 B71 B72 B73 B74 B75 B76 B77 B78 B79 B81 B82 B83 B88 B89 B91 B92 B93 B94 B95 B96 B97 B98 B99 B101 B102 C3 C4 C6 C7 C9 C10 C12 C13 C15 C16 C17 C19 C20 C22 C23 C24 C29 C30 C32 C33 C34 C35 C36 C37 C38 C39 C40 C45 C47 C52 C53 C55 C56 C58 C59 C61 C62 C63 C64 C65 C66 C67 C68 C69 C71 C72 C74 C75 C77 C78 C79 C81 C82 C83 C85 C86 C88 C89 C91 C92 C94 C95 C97 C98 C99 C101 C102 D3 D4 D6 D7 D9 D10 D12 D13 D15 D16 D17 D19 D20 D22 D23 D24 D29 D30 D32 D33 D34 D35 D36 D37 D38 D39 D40 D45 D47 D52 D53 D54 D55 D56 D58 D59 D61 D62 D63 D64 D65 D66 D68 D69 D71 D72 D74 D75 D77 D78 D79 D81 D82 D83 D85 D86 D88 D89 D91 D92 D94 D95 D97 D98 D99 D101 D102; J3 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 29 30 31 32 34 35 36 37 38 40 42 44 46 48 50 52 53 54 55 56 58 67 68; OCXO1 1 2 5 6; OCXO2 1 2 5; P1 A7 AA3 AA19 AA22 AB22 C17 C18 D10 D11 D12 D13 D16 F1 F2 F6 F12 G6 G8 G18 G21 H17 J15 J21 J22 K1 K2 K17 K22 M13 M20 P1 P2 P20 R9 T16 U12 U18 V9 V13 W4 W10 W16 Y3 Y4; RB321 2; RB322 2; RJ1 C1 C2 D3 D6 D7 D8 G4 G5; U7 10 37 51 53; U9 A6 A7 B6 B7 C16 D5 D7 D13 D18 E3 E4 E7 E9 F8 F11 F12 G16 J13 J16 K6 K17 L5 N8 N14 P7 R1 U10 U11 U12 V13; U10 4 5 19 20; U14 T7; U15 T7; U16 T7; U17 T7; U22 3 5 6; U23 2 3 4 13 14 17; U24 3 4 6 7 8 9 16 18 20; U31 15; U32 29 31 33 34; U33 7 8 33 34 35 36; U35 29 31 33 34; U37 8; U40 AB9 AB36 AB37 AC5 AC10 AC35 AC36 AC37 AD27 AE27 AE36 AH19 AK14 AL1 AL6 AL19 AL27 AL30 AN23 AP18 AR34 AT30 AU10 L3 L4 L34 L35 M1 M2 M6 M7 M31 M32 M36 M37 N3 N4 N8 N9 N15 N16 N29 N30 N34 N35 P1 P2 P6 P7 P22 P23 P31 P32 P36 P37 R3 R4 R8 R9 R29 R30 R34 R35 T1 T2 T6 T7 T32 U3 U4 U8 U9 U28 U32 U34 U35 V13 V28 V29 V30 W13 W19 W25 W30 W31 W33 Y19 Y25; U44 29 31 33 34; U48 15; U52 A1 A2 A5 A6 B1 B2 B3 B5 C1 C3 C4 C5 D1 D2 D3 E1 E2 F2 G1 H8 J9 K2 K7; U53 4 5 10 12 13 15; U54 5 6 7 8; U66 2 6 7; U68 34 37; U71 21 22 23 24 26 27 28 29 30 32 33 34 36 38 39 40 41 43 44 45 46 48 52 53 54 55 57 58 59 60 61 62 63; U72 1 2 3 8 9 12 13 14 15 28; U77 11 23 24 32 33; U79 3 4 8 13 14 15 16; U80 4 5 6 11 12 13 14; U81 1 2; UB1 8 12 13 19 20 25 26 29; UB5 T7; UB6 T7; UB16 13 14 15 16 17 18 19 20; UB17 17 18 19 20; UB70 1; UB71 1

## Via types
v1: diameter 0.559, hole 0.305, TOP to BOTTOM, 6224 vias
v2: diameter 0.762, hole 0.381, TOP to BOTTOM, 1863 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 675 vias
v4: diameter 0.457, hole 0.203, TOP to BOTTOM, 2539 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
2V5RC01: length 4.2
  BOTTOM w0.508: v2(44.03,188.25) 44.03,190.22 RB181.2 43.54,190.4 42.95,189.81 42.17,189.81 CB417.2
AGND_VCC1V0: length 18
  TOP w0.254: U33.22 114.36,123.83 v3(113.91,124.28) ; v3(113.05,124.28) 113.36,123.96 U33.17 ; U33.20 v1(115.41,122.58)
  TOP w0.381: v1(110.46,119.06) C336.2 C337.2 ; R600.1 C324.2 121.02,122.7 v1(121.38,122.7) ; R534.1 111.93,131.94 ; R533.1 110.94,132.28
  TOP w0.508: R567.1 118.78,127.24 118.4,126.86 R578.1 v1(119.09,126.59) ; C339.2 v1(119.78,120.18) ; R535.1 v1(116.17,132.08) ; C338.2 114.01,119.3 v1(114.27,119.04) ; 108.37,129.74 108.03,129.39 R560.2 ; R554.1 v1(119.08,128.75) ; C352.2 v1(113.38,116.13)
  BOTTOM w0.381: 108.93,128.5 109.36,128.07 RB176.1 ; v2(108.42,129.77) 109.12,129.07 CB404.2
  vias: v1(108.04,132.74) v1(107.99,132.05) v1(108.73,132.74) v1(108.68,132.05) v1(113.88,133.13) v1(117.24,133.07) v2(113.31,132.37) v3(111.32,126.87) v3(111.32,126.01) v3(111.32,125.14) v3(111.32,124.28) v3(112.18,126.87) v3(112.18,126.01) v3(112.18,125.14) v3(112.18,124.28) v3(113.05,126.87) v3(113.05,126.01) v3(113.05,125.14) v3(113.91,126.87) v3(113.91,126.01) v3(113.91,125.14)
AGND_VCC3V3: length 20.4
  TOP w0.254: v1(162.56,128.4) 163.17,129.01 U31.7 ; v1(164.87,134.53) 164.84,134.49 164.84,134.27
  TOP w0.381: R504.1 168.14,132.56 ; R498.1 164.84,134.27
  TOP w0.508: R512.2 159.76,131.55 159.76,134.85 160.58,135.67 165,135.67
  S7 w0.254: v1(164.87,134.53) 164.13,133.78 164.13,129.96 v1(162.56,128.4)
  BOTTOM w0.127: v2(165.45,135.54) 164.87,134.97 v1(164.87,134.53)
GND: length 3624.1
  TOP w0.127: U75.G1 v1(232.38,107.84) ; U73.G3 v1(226.61,107.72) ; 95.94,98 95.74,98 v3(95.66,98.08) ; U56.G3 v1(255.28,99) ; U56.G1 v1(257.18,99.03) ; U55.G1 v1(251.79,99.03) ; U75.G3 v1(234.28,107.86) ; v3(95.66,99.22) 95.74,99.3 95.95,99.3 ; R1126.1 v1(185.35,236.71) ; U55.G3 v1(249.89,99) ; U73.G1 v1(224.71,107.69)
  TOP w0.254: U68.71 v3(187.63,219.76) ; U55.3 v1(250.84,99.03) ; v1(235.49,199.81) 235.45,199.77 U71.35 ; J2.B60 173.44,144.29 v1(173.28,144.13) ; U68.15 193.23,227.57 v3(192.94,227.86) ; v1(210.91,124.75) 210.84,124.82 U24.11 ; v1(157.48,152.82) 157.44,152.77 J2.C28 ; U68.2 v3(192.94,221.07) ; UB1.24 87.97,190.66 v1(88.48,191.17) ; v1(188.53,146.28) 188.53,146.28 188.44,146.18 J2.B90 ; C16.1 v1(227.65,228.33) ; U48.8 151.9,95.79 v1(152.3,95.4) ; U66.4 233.42,136.97 233.58,137.13 v1(233.58,138.02) ; U35.4 120.8,177.05 v1(120.26,177.59) ; J3.57 134.54,244.93 134.33,245.15 134.33,246.33 v1(134.22,246.43) J3.51 ; v1(230.68,223.13) 231.08,223.53 U7.8 ; UB1.G1 v3(84.38,188.33) 83.71,187.66 UB1.7 ; UB1.G1 v3(85.53,189.48) 85.71,189.66 UB1.27 ; UB1.G1 v3(84.38,189.48) 84.21,189.66 UB1.30 ; C209.2 188.87,176.38 188.89,176.4 v1(188.92,176.4) ; v1(134.2,247.94) 134.2,247.88 134.26,247.93 J3.45 ; U68.12 v3(195.23,226.07) ; v1(167.41,156.12) 167.44,156.14 J2.D48 ; 94.53,132.93 v1(94.85,132.93) U30.4 97.26,132.93 ; 94.53,132.93 v1(93.98,133.48) ; 94.53,132.93 94.44,132.93 v1(94.11,132.59) ; v1(120.21,146.16) 119.95,145.91 R394.1 ; U71.47 229.45,197.21 v1(229.45,197.2) ; C210.2 v1(188.84,175.36) ; v1(233.33,107.83) 233.33,107.82 U75.8 ; U68.69 v3(186.63,219.76) ; UB1.1 81.82,190.66 v1(81.56,190.92) ; J2.B31 158.94,144.27 159.04,144.17 v1(159.05,144.17) ; v1(121.35,139.29) U23.12 ; v1(173.38,155.93) 173.44,155.98 J2.D60 ; J2.C18 v1(152.44,153) ; U20.10 v1(213.77,236.76) ; v1(137.06,253.91) 137.04,253.93 J3.21 ; v1(121.79,177.51) 121.8,177.5 U35.2 ; J2.C21 153.94,152.93 154.02,153.01 v1(154.14,153.01) ; v1(163.6,152.82) 163.94,152.47 J2.C41 ; U71.13 234.95,186.19 235.42,185.71 v1(235.61,185.71) 235.95,186.04 U71.15 ; J2.C1 143.87,152.57 v1(144.17,152.88) 144.44,152.61 J2.C2 ; v1(134.39,250.93) 134.4,250.93 J3.33 ; v1(67.39,184.54) 67,184.92 U6.4 ; U47.2 95.94,98 ; C58.1 90.56,215.24 v1(90.87,215.55) ; J2.D18 v1(152.44,156.18) ; U47.4 95.95,99.3 ; U71.11 233.95,187.89 233.59,188.24 v1(233.45,188.24) U71.10 ; v1(94.33,95.1) 94.33,95.22 94.44,95.33 U47.17 ; v1(182.91,174.53) 182.77,174.68 U22.4 181.66,175.25 R395.2 ; J2.D8 v1(147.44,156.18) ; v1(144.07,100.33) 144.1,100.36 R753.1 ; J2.C31 158.94,150.88 v1(159.1,150.72) ; v1(117.19,100.81) 116.93,100.81 116.56,101.18 U44.2 ; v1(165.83,158.28) 165.44,157.89 J2.D44 ; J3.39 v1(137.09,249.43) ; J3.15 134.52,255.43 134.27,255.69 v1(134.27,256.07) ; v1(243.93,115.67) 243.52,115.26 U37.4 ; J3.27 v1(134.34,252.43) ; U51.8 244.38,82.39 244.69,82.08 v1(244.88,82.08) ; UB1.18 v1(88.63,187.66) ; v1(143.54,144.05) 143.87,144.38 J2.B1 ; J2.D11 v1(148.94,156.18) ; C506.2 154.98,89.58 v1(154.13,88.73) ; U7.64 235.67,223.24 235.85,223.42 235.85,223.78 v1(235.74,223.9) ; U7.48 234.58,214.18 v1(234.66,214.09) ; U71.25 v1(237.11,192.98) ; v1(163.41,158.34) 163.54,158.34 163.94,157.94 J2.D41 ; U7.26 227.18,218.74 v1(227.23,218.79) ; J2.D25 v1(155.94,156.18) ; J2.A21 v1(153.94,138.77) ; J2.D2 144.44,155.56 v1(144.43,155.55) ; v1(37.19,190.72) 37.31,190.6 U32.2 ; v1(36.83,186.75) 36.98,186.6 U32.10 39.5,186.6 ; v1(176.43,138.78) 176.44,138.79 J2.A66 ; C534.2 149.41,71.64 148.91,72.13 148.78,72.13 v1(148.62,72.3) ; U7.49 v1(235.33,215.21) ; J2.A100 193.44,138.76 v1(192.98,138.3) ; v1(69.28,191.27) C60.1 v1(68.59,191.95) ; U68.70 v3(187.13,217.48) ; v3(4.81,56.64) 4.81,56.56 4.84,56.53 U69.38 ; v1(230.91,188.38) 230.95,188.35 U71.5 ; U68.7 v1(192.88,223.57) ; U19.2 183.18,178.07 v1(183.54,177.71) ; J3.9 136.48,256.93 v1(136.98,256.43) ; U79.1 103.06,178.51 v1(102.64,178.09) ; J2.D51 v1(168.94,156.18) ; v1(143.67,155.48) 143.87,155.68 J2.D1 ; U68.27 v3(189.13,230.88) ; J2.D28 157.44,156.11 v1(157.38,156.06) ; J2.B100 193.44,143.92 v1(193.41,143.89) ; 163.72,127.65 v1(163.7,127.64) ; U68.62 v3(183.13,219.8) ; J2.D14 v1(150.44,156.18) ; UB1.15 v1(86.21,185.4) ; J2.C25 155.94,152.77 v1(155.98,152.82) ; v1(181.45,150.75) 181.45,150.75 181.7,150.5 183.23,150.5 183.44,150.7 J2.C80 ; v1(228.75,228.28) 228.75,228.21 228.8,228.16 C17.2 ; v1(66.83,189.46) 66.5,189.13 U6.8 ; v1(158.88,155.8) 158.94,155.86 J2.D31 ; v1(84.45,185.05) 84.21,185.29 UB1.11 ; J2.D5 v1(145.94,156.18) ; v1(162.81,127.64) 163.19,128.02 163.19,128.38 163.32,128.5 U31.8 ; v1(225.69,195.49) 225.7,195.48 U71.51 ; U68.16 v3(195.23,228.07) ; v1(165.82,152.88) 165.44,152.5 165.44,152.21 165.44,152.21 J2.C44 ; U71.1 228.95,188.31 v1(228.95,188.31) ; 148.21,99.59 148.21,99.81 C449.2 ; U68.33 v3(186.13,233.16) ; v1(93.6,116.84) v1(94.11,117.35) 94.33,117.13 v1(94.85,117.13) 94.9,117.18 U39.4 97.72,117.18 v3(97.72,117.18) ; U7.43 v1(232.08,215.79) ; U68.6 v3(195.23,223.07) ; U21.8 v1(238.2,236.94) ; J2.D21 v1(153.94,156.18) ; C869.2 v1(188.99,177.39) ; U73.8 v1(225.66,107.72) ; U56.3 v1(256.23,99.03) ; v4(89.54,168.82) U16.N1 ; C18.2 v1(230.07,228.26)
  TOP w0.305: J2.D76 181.44,156 v1(181.45,155.99) ; J2.D73 179.94,155.82 v1(179.92,155.8) ; J2.D96 191.44,158.26 v1(191.43,158.26) ; v1(167.44,152.89) 167.44,152.88 J2.C48 ; v1(198.64,152.91) 198.63,152.91 198.51,152.78 J2.C110 ; J2.C51 168.94,152.99 v1(168.94,152.99) ; v3(7.57,51.39) 7.64,51.45 U69.4 ; v1(149.17,141.02) 148.94,140.79 J2.A11 ; J2.C14 v1(150.44,152.92) ; v1(178.4,138.72) 178.4,138.78 178.44,138.82 J2.A70 ; J2.D103 194.94,158.18 195.02,158.26 v1(195.09,158.26) ; J2.D84 185.44,158.36 v1(185.44,158.37) ; v1(179.1,146.59) 179.1,146.53 178.44,145.87 J2.B70 ; J2.D67 176.94,158.04 v1(177.3,158.4) ; J2.D70 178.44,158.18 178.45,158.19 v1(178.45,158.26) ; v1(198.52,144.14) 198.49,144.17 198.49,144.2 198.51,144.22 J2.B110 ; J2.C11 148.94,152.9 v1(148.91,152.94) ; v1(193.51,152.91) 193.51,152.86 193.44,152.78 J2.C100 ; v3(19.57,51.39) 19.64,51.45 U69.19 ; v1(187.01,158.32) 187.01,158.25 186.94,158.18 J2.D87 ; U69.35 7.24,56.58 v3(7.24,56.58) ; v1(188.59,158.32) 188.57,158.32 188.44,158.18 J2.D90 ; J2.C93 189.94,150.79 v1(189.96,150.77) ; U69.23 16.84,56.58 v3(16.84,56.58) ; J2.B51 168.94,146.29 v1(168.93,146.3) ; v1(173.5,138.73) 173.44,138.79 J2.A60 ; J2.A90 188.44,138.82 188.41,138.79 v1(188.41,138.71) ; v1(179.9,150.77) 179.9,150.78 179.94,150.82 J2.C73 ; v1(162.53,138.66) 162.44,138.74 J2.A38 ; v1(163.97,146.33) 163.97,146.22 163.94,146.18 J2.B41 ; v3(5.29,51.39) 5.24,51.44 U69.1 ; v1(149.06,146.23) 149.06,146.21 148.94,146.09 J2.B11 ; J2.D80 183.44,158.18 183.45,158.2 v1(183.45,158.29) ; J2.A41 163.94,138.67 v1(163.8,138.53) ; v1(162.45,146.28) 162.45,146.19 162.44,146.18 J2.B38 ; v1(188.43,150.75) 188.43,150.81 188.44,150.82 J2.C90 ; J2.C84 185.44,150.82 185.44,150.82 v1(185.44,150.77) ; v3(9.64,56.58) 9.64,56.58 U69.32 ; J2.D93 189.94,158.18 189.96,158.2 v1(189.96,158.29) ; v3(17.17,51.39) 17.24,51.45 U69.16 ; U69.26 14.44,56.58 v3(14.44,56.58) ; v1(171.92,138.73) 171.92,138.8 171.94,138.82 J2.A57 ; v3(9.97,51.39) 10.04,51.45 U69.7 ; v1(198.67,158.32) 198.64,158.32 198.51,158.18 J2.D110 ; v1(181.45,150.75) 181.44,150.76 J2.C76 ; U69.13 14.84,51.44 v3(14.89,51.39) ; J2.C103 194.94,152.78 v1(195.04,152.88) ; J2.B80 183.44,144.22 183.4,144.18 v1(183.4,144.17) ; v1(178.45,150.7) 178.44,150.71 J2.C70 ; v1(154.21,146.28) 153.94,146.01 J2.B21 ; J2.C8 v1(147.44,152.92) ; J2.C87 186.94,150.82 186.93,150.81 v1(186.93,150.75) ; J2.A80 183.44,138.82 183.38,138.76 v1(183.38,138.73) ; J2.C96 191.44,152.82 v1(191.43,152.83) ; v1(173.37,150.75) 173.37,150.75 173.44,150.82 J2.C60 ; v1(158.91,138.59) 158.94,138.63 J2.A31 ; J2.A51 168.94,138.66 v1(169,138.59) ; J2.D100 193.44,158.24 v1(193.44,158.24) ; U69.20 19.24,56.58 v3(19.24,56.58) ; J2.C5 v1(145.94,152.92)
  TOP w0.381: R629.2 6.47,121.79 v1(5.81,121.79) 5.19,121.79 R625.2 ; R629.2 R617.2 ; R629.2 R637.2 ; R1051.1 v1(237.62,127.72) ; v4(51.36,166.42) U14.K9 ; v4(28.7,128.65) U40.AL29 ; v4(44.7,108.65) U40.M14 ; v4(44.7,107.65) U40.L14 ; v4(100.08,161.62) U17.E1 ; v4(57.7,124.65) U40.AG1 ; v1(122.43,71.25) 123.07,71.25 123.39,71.57 C517.2 123.07,71.95 v1(122.43,71.95) ; C820.2 v1(119.77,66.21) ; RB3.2 85.46,183.33 86.01,182.79 v1(86.06,182.79) ; C245.2 198.91,124.8 198.89,124.82 v1(198.87,124.82) ; v4(45.7,130.65) U40.AN13 ; U40.J8 v4(50.7,105.65) ; C640.2 v1(15.48,72.53) ; v4(61.9,160.02) U15.C9 ; U52.G6 v4(231.18,123.65) ; U52.H5 v4(230.18,121.65) ; v4(29.7,107.65) U40.L28 ; v4(21.7,107.65) U40.L36 ; C821.2 v1(120.79,66.21) ; R764.1 89.32,99.16 89.17,99.31 v1(88.97,99.31) ; U16.G8 v4(83.14,163.22) ; C407.1 v1(6.44,110.87) ; v1(5.78,123.24) 5.94,123.24 6.16,123.47 R606.2 R593.2 ; U40.L29 v4(28.7,107.65) ; v4(22.7,101.65) U40.E35 ; v1(15.18,127.83) 15.21,127.86 R564.1 ; v4(50.7,122.65) U40.AE8 ; R317.2 C168.2 ; v4(23.7,117.65) U40.Y34 ; R70.2 66.68,189.61 v1(66.83,189.46) ; U40.H34 v4(23.7,104.65) ; U40.H13 v4(45.7,104.65) ; v4(41.7,102.65) U40.F17 ; C444.2 v1(88.99,101.06) ; v1(98.01,92.12) C481.2 C482.2 ; v4(39.7,118.65) U40.AA19 ; U52.F5 v4(230.18,124.65) ; U40.T25 v4(32.7,112.65) ; v4(58.56,168.82) U14.N1 ; C188.1 v1(213.9,127.84) ; 140.61,142.27 139.35,141.01 v1(139.22,141.01) ; 140.61,142.27 J2.G2 ; 140.61,142.27 140.61,140.37 v1(140.62,140.37) ; CB861.2 47.66,64.41 v1(47.67,64.4) ; U40.H4 v4(54.7,104.65) ; v4(20.83,161.49) 20.85,161.52 22.32,161.52 23.21,160.63 C177.2 ; R640.2 R632.1 15.18,121.77 v1(15.15,121.73) 14.17,120.75 R639.2 ; v4(22.7,130.65) U40.AN35 ; U40.AH25 v4(32.7,125.65) ; R660.1 v1(127.36,177.71) ; v4(46.7,121.65) U40.AD12 ; U40.AH5 v4(53.7,125.65) ; U40.AH37 v4(20.7,125.65) ; U40.R11 v4(47.7,111.65) ; v4(43.7,132.65) U40.AR15 ; C158.2 76.37,163.6 v1(76.93,163.04) ; v1(234.95,210.93) 234.95,210.88 234.92,210.91 C110.1 ; v1(152.81,228.38) 152.81,228.19 153,228 U10.12 ; v4(36.7,101.65) U40.E21 ; U52.H7 v4(232.18,121.65) ; v4(42.7,101.65) U40.E16 ; v4(52.7,126.65) U40.AJ6 ; v4(45.7,122.65) U40.AE13 ; U40.H30 v4(27.7,104.65) ; U40.P28 v4(29.7,110.65) U40.N28 ; C600.2 v1(88.48,66.67) ; v4(52.7,111.65) U40.R6 ; v4(31.7,119.65) U40.AB26 ; v4(40.7,109.65) U40.N18 ; v4(57.8,130.54) 57.4,130.15 U40.AN1 ; U52.F6 v4(231.18,124.65) ; v4(40.7,110.65) U40.P18 ; U52.H3 v4(227.18,121.65) ; v4(37.7,109.65) U40.N20 ; C203.2 25.24,157.91 v4(25.62,158.29) ; v1(55.98,71.19) 55.42,71.19 C541.2 54.66,71.95 54.08,71.95 v1(53.99,72.05) ; U52.E5 v4(230.18,125.65) ; C833.2 v1(159.55,66.79) ; v4(36.7,102.65) U40.F21 ; v4(30.7,106.65) U40.K27 ; v4(199.55,191.58) U9.J10 ; U14.T1 v4(58.56,171.22) ; v4(42.7,110.65) U40.P16 ; C249.2 78.32,142.97 78.63,143.28 v1(78.63,143.99) U27.4 ; C658.2 v1(141.18,66.72) ; U40.H15 v4(43.7,104.65) ; v4(67.5,161.62) U15.E3 ; v4(37.7,110.65) U40.P20 ; C164.2 23.86,163.27 23.56,162.96 22.44,162.96 22.19,163.22 v1(22.19,163.42) ; v4(48.7,117.65) U40.Y10 ; C636.2 195.23,67.09 v1(195.23,67.09) ; v4(27.7,99.65) U40.C30 ; v4(45.7,109.65) U40.N13 ; v4(36.7,120.65) U40.AC21 ; C178.2 27.65,161.26 27.45,161.46 C179.2 26.45,161.46 v4(26.42,161.49) ; v4(87.94,161.62) U16.E3 ; C674.2 85.19,64.48 v1(85.27,64.4) ; v4(55.7,123.65) U40.AF3 ; U40.U10 v4(48.7,113.65) ; v1(67.53,178.92) C95.2 ; U52.F4 v4(228.18,124.65) ; v4(196.55,188.58) U9.L8 ; R509.1 9.3,132.94 v1(9.01,133.23) ; v1(92.99,193.2) 92.93,193.27 CB50.1 ; v4(200.55,192.58) U9.H11 ; U72.25 v1(227.65,165.55) ; v4(33.7,106.65) U40.K24 ; v4(35.7,117.65) U40.Y22 ; v1(121.35,139.29) 121.69,139.63 C194.2 ; C128.2 29.66,170.99 v4(29.77,171.09) ; v1(185.51,68.88) 185.98,68.41 CB821.2 ; v1(95.01,104.8) C428.2 C435.2 95.01,102.51 v1(94.83,102.33) ; v4(55.7,132.65) U40.AR3 ; U52.K5 v4(230.18,119.65) ; R16.2 233.11,231.46 v1(233.12,231.46) ; v4(44.7,123.65) U40.AF14 ; v4(41.7,111.65) U40.R17 ; v4(28.7,108.65) U40.M29 ; v1(68.04,113.51) 66.89,112.37 C400.1 ; v1(66.51,178.92) C94.2 ; U40.AN19 v4(39.7,130.65) ; v4(33.7,119.65) U40.AB24 ; v4(50.7,100.65) U40.D8 ; C606.2 v1(119.73,71.72) ; U40.W1 v4(57.7,116.65) ; v1(17.57,118.75) 17.54,118.72 R659.1 ; U40.W5 v4(53.7,116.65) ; v4(42.7,117.65) 42.65,117.6 42.47,117.42 U40.Y16 ; C396.1 v1(62.83,112.47) ; v1(132.37,71.1) 131.94,71.1 C533.2 131.21,71.83 130.93,71.83 v1(130.45,71.35) ; v4(36.7,122.65) U40.AE21 ; U40.H8 v4(50.7,104.65) ; U52.F1 v3(225.18,124.65) ; v1(76.8,168.98) 77.08,168.98 R238.1 ; C154.2 29.94,166.12 v4(29.77,166.29) ; C132.2 46.45,169.03 47.08,168.4 v1(47.09,168.4) ; C652.2 v1(35.76,66.39) ; v4(41.7,101.65) U40.E17 ; U40.T9 v4(49.7,112.65) ; v4(53.7,107.65) U40.L5 ; U17.N1 v4(100.08,168.82) ; C599.2 v1(89.49,66.67) ; v4(52.16,158.42) U14.A8 ; C340.2 v1(103.92,121.13) ; U40.L25 v4(32.7,107.65) ; v1(160.62,71.73) 160.94,71.41 161.9,71.41 162.06,71.57 C519.2 161.74,71.95 161.41,71.95 v1(161.19,72.17) ; v4(52.7,132.65) U40.AR6 ; C635.2 v1(193.01,77.65) ; v1(155.74,68.63) 155.4,68.29 CB816.2 ; v4(41.7,123.65) U40.AF17 ; C799.2 v1(37.82,66.79) ; v1(98.95,98.09) C459.2 v1(99.66,98.78) ; v4(93.69,160.82) U17.D8 ; v1(15.15,128.85) 15.18,128.88 R553.1 ; R596.1 15.18,124.81 v1(15.15,124.78) ; R608.1 15.21,123.8 v1(15.18,123.77) ; v4(46.7,100.65) U40.D12 ; U40.T5 v4(53.7,112.65) ; 26.51,144.37 C262.2 27.07,144.95 ; C618.2 v1(156.5,66.79) ; v4(26.42,159.89) 27.52,159.89 27.75,160.12 C184.2 ; v1(121.86,100.86) 121.61,100.61 C446.2 ; v4(43.7,108.65) U40.M15 ; U40.W7 v4(51.7,116.65) ; v4(49.7,101.65) U40.E9 ; C984.1 v1(62.45,215.49) ; C193.2 124.05,141.38 124.05,141.34 v1(124.01,141.34) ; v4(33.7,110.65) U40.P24 ; v4(56.7,106.65) U40.K2 ; U40.T22 v4(35.7,112.65) ; v4(43.7,101.65) U40.E15 ; v4(20.7,111.65) U40.R37 ; v1(125.5,208.57) 125.57,208.51 C286.2 ; v4(45.7,97.65) U40.A13 ; C638.2 v1(13.45,72.5) ; RB37.1 90.95,190.83 v1(91.23,191.11) ; v4(62.7,161.62) U15.E8 ; v4(29.7,111.65) U40.R28 ; v4(37.7,107.65) U40.L20 ; C134.2 C135.2 29.27,169.19 v4(29.77,168.69) ; U40.AC25 v4(32.7,120.65) ; v4(92.89,161.62) U17.E9 ; R693.1 14.06,109.75 v1(13.66,109.34) ; v4(24.7,102.65) U40.F33 ; v4(89.54,166.42) U16.K1 ; v4(31.7,100.65) U40.D26 ; U40.E11 v4(47.7,101.65) ; v4(30.7,132.65) U40.AR27 ; U40.T20 v4(37.7,112.65) ; v4(37.7,123.65) U40.AF20 ; v4(45.7,124.65) U40.AG13 ; 65.3,115.62 C374.2 65.88,116.18 ; C797.2 24.02,66.77 v1(23.99,66.8) ; v1(85.97,145.9) R464.1 R460.1 ; U40.T16 v4(42.7,112.65) ; v1(150.01,91.84) C479.2 ; v4(30.7,124.65) U40.AG27 ; v4(57.7,101.65) U40.E1 ; U40.A25 v4(32.7,97.65) ; v4(39.7,109.65) U40.N19 ; v4(37.7,134.65) U40.AU20 ; C605.2 v1(120.75,71.72) ; 97.88,111.61 C392.1 98.44,112.19 ; U40.T26 v4(31.7,112.65) ; UB16.12 166.81,246.64 v1(166.78,246.61) ; C840.2 v1(183.74,66.79) ; v4(82.34,161.62) U16.E9 ; C152.2 32.86,164.41 32.35,163.9 v4(32.17,163.9) ; v4(26.7,130.65) U40.AN31 ; U40.AA11 46.85,117.8 v4(46.7,117.65) U40.Y12 ; U72.11 v1(223.1,171.1) ; C204.2 30.82,158.03 v4(30.57,158.29) ; v1(28.97,157.53) 29.1,157.66 C197.2 C196.2 27.17,158.24 C198.2 ; C662.2 v1(25.04,66.76) ; v4(69.1,162.42) U15.F1 ; v4(23.7,100.65) U40.D34 ; v4(201.55,188.58) U9.L12 ; C824.2 v1(140.16,66.72) ; U40.U19 v4(39.7,113.65) ; U40.M10 v4(48.7,108.65) U40.M9 ; v4(41.7,134.65) U40.AU17 ; R360.1 v1(105.76,185.52) ; v4(56.7,134.65) U40.AU2 ; v1(62.09,112.11) 61.81,111.83 C395.1 ; UB70.3 242.78,95.66 v1(242.81,95.64) ; RB5.2 90.49,183.9 v1(90.77,183.63) ; v4(45.7,107.65) U40.L13 ; v4(93.69,163.22) U17.G8 ; v4(92.89,168.02) U17.M9 ; v1(5.82,127.82) 5.86,127.86 R561.1 ; v4(31.7,105.65) U40.J26 ; U40.AA17 v4(41.7,118.65) ; v4(57.7,103.65) U40.G1 ; C669.2 v1(52.42,66.79) ; v4(28.7,134.65) U40.AU29 ; v4(58.56,164.02) U14.H1 ; U40.N25 v4(32.7,109.65) ; v4(45.7,102.65) U40.F13 ; U52.H4 v4(228.18,121.65) ; U40.AE25 v4(32.7,122.65) ; v4(53.7,134.65) U40.AU5 ; v4(42.7,123.65) U40.AF16 ; U40.T3 v4(55.7,112.65) ; U52.D5 v4(230.18,126.65) ; v4(54.7,118.65) U40.AA4 ; v4(31.7,121.65) U40.AD26 ; v4(20.7,132.65) U40.AR37 ; v1(73.52,166.44) 73.83,166.75 R237.1 ; U40.P33 v4(24.7,110.65) U40.N33 ; C398.1 64.86,111.83 64.51,112.19 v1(64.51,112.47) ; v1(77.87,158.92) C200.2 ; U40.H23 v4(34.7,104.65) ; v4(46.7,99.65) U40.C12 ; R795.1 95.16,95.02 v1(95.09,95.1) ; U40.AN25 v4(32.7,130.65) ; U40.U5 v4(53.7,113.65) ; C841.2 v1(184.76,66.79) ; v4(22.7,117.65) U40.Y35 ; v4(57.7,106.65) U40.K1 ; v1(183.8,195.74) 183.8,195.74 C101.1 ; v4(29.7,101.65) U40.E28 ; v4(197.55,189.58) U9.K9 ; v4(206.55,182.58) U9.U17 ; v4(34.7,107.65) U40.L23 ; C657.2 v1(142.19,66.72) ; v4(34.7,111.65) U40.R23 ; U52.K6 v4(231.18,119.65) ; v4(48.7,111.65) U40.R10 ; C688.2 192.59,64.41 v1(192.6,64.4) ; v4(62.7,160.82) U15.D8 ; U52.J2 v3(226.18,120.65) ; v4(20.7,106.65) U40.K37 ; v4(20.7,117.65) U40.Y37 ; U40.T28 v4(29.7,112.65) ; v4(27.7,132.65) U40.AR30 ; U40.M5 v4(53.7,108.65) ; v4(31.7,99.65) U40.C26 ; R664.2 15.21,117.7 v1(15.18,117.67) ; U40.W21 v4(36.7,116.65) ; v4(42.7,106.65) U40.K16 ; C461.2 v1(5.53,97.38) ; v1(112.92,109.5) C411.2 ; v4(88.74,160.82) U16.D2 ; v4(50.7,117.65) U40.Y8 ; v4(26.42,163.89) 26.71,163.6 C161.2 ; v4(23.7,101.65) U40.E34 ; v1(89.73,152.52) 89.75,152.55 C214.2 ; v4(23.7,106.65) U40.K34 ; v4(200.55,188.58) U9.L11 ; U40.T30 v4(27.7,112.65) ; v4(27.7,117.65) U40.Y30 ; C84.1 69.59,178.64 69.31,178.92 v1(69.31,178.94) ; v4(53.7,128.65) U40.AL5 ; C575.2 22.31,71.82 C576.2 v1(22.32,72.61) ; v4(39.7,111.65) U40.R19 ; R519.1 15.18,131.93 v1(15.15,131.89) ; v1(192.55,67.28) 192.77,67.5 CB822.2 ; v4(27.7,105.65) U40.J30 ; v4(45.7,118.65) U40.AA13 ; v1(63.47,178.92) C91.2 ; C639.2 14.47,72.54 v1(14.46,72.54) ; v4(49.7,126.65) U40.AJ9 ; C399.1 65.88,111.86 v1(65.24,112.49) ; P1.AA14 v4(115.29,223.46) ; C661.2 v1(27.07,66.76) ; v4(69.1,166.42) U15.K1 ; U40.U23 v4(34.7,113.65) ; U40.L11 v4(47.7,107.65) ; v4(35.7,130.65) U40.AN22 ; v4(52.16,163.22) U14.G8 ; v4(68.3,160.82) U15.D2 ; U72.18 223.1,165.38 v1(223.47,165.76) ; v4(51.36,160.02) U14.C9 ; U52.D4 v4(228.18,126.65) ; v4(51.36,168.02) U14.M9 ; v1(20.51,152.7) 21.53,152.7 22.44,151.79 C226.2 ; v4(29.7,130.65) U40.AN28 ; C425.1 63.97,106.02 v1(63.4,105.45) ; v4(36.7,126.65) U40.AJ21 ; v4(27.7,108.65) U40.M30 ; v1(198.95,140.92) 198.89,140.92 198.51,140.54 J2.A110 ; C471.2 v1(5.48,96.37) ; v4(28.7,101.65) U40.E29 ; v4(36.7,118.65) U40.AA21 ; v4(93.69,158.42) U17.A8 ; v4(29.7,108.65) U40.M28 ; P1.Y21 v4(114.29,230.46) ; U52.G2 v3(226.18,123.65) ; U40.T12 v4(46.7,112.65) ; U40.H20 v4(37.7,104.65) ; v1(41.12,143.36) 41.12,143.36 C265.2 ; v1(182.4,200.44) 182.46,200.38 C62.2 v1(183.48,199.43) ; C133.2 v1(47.46,169.14) ; v4(29.7,106.65) U40.K28 ; v4(43.7,120.65) U40.AC15 ; U40.H25 v4(32.7,104.65) ; v4(24.7,111.65) U40.R33 ; v4(45.7,98.65) U40.B13 ; C32.2 62.94,186.36 ; C842.2 193.87,65.95 v1(193.21,66.6) 193,66.39 C634.2 ; v4(41.7,97.65) U40.A17 ; CB978.1 v1(124.84,218.89) ; U40.U21 v4(36.7,113.65) ; v4(21.7,132.65) U40.AR36 ; v4(36.7,132.65) U40.AR21 ; v4(35.7,101.65) U40.E22 ; v4(26.7,111.65) U40.R31 ; C474.2 v1(5.53,95.35) ; v4(40.7,121.65) U40.AD18 ; U40.W11 v4(47.7,116.65) ; C426.1 5.81,104.04 ; C426.1 6.44,103.48 ; C426.1 v1(7.21,104.04) ; 62.94,185.86 C31.1 R45.2 61.34,185.29 ; v4(46.7,110.65) U40.P12 ; v4(55.7,117.65) U40.Y3 ; v4(48.7,109.65) U40.N10 ; v4(46.7,119.65) U40.AB12 ; v4(54.7,101.65) U40.E4 ; U40.T33 v4(24.7,112.65) ; U40.E25 v4(32.7,101.65) ; v4(57.7,107.65) U40.L1 ; v4(20.7,107.65) U40.L37 ; U18.4 4.05,162.8 v1(4.61,162.24) ; v4(44.7,121.65) U40.AD14 ; R545.1 15.18,129.89 v1(15.15,129.86) ; v4(55.7,120.65) U40.AC3 ; v1(115.79,96.37) 116.04,96.62 R773.1 ; v4(51.7,124.65) U40.AG7 ; v4(33.7,123.65) U40.AF24 ; v4(61.9,161.62) U15.E9 ; v4(33.7,108.65) U40.M24 ; v1(186.4,71.4) 186.4,71.32 186.47,71.25 187.01,71.25 187.33,71.57 C536.2 187.09,71.88 186.78,71.88 v1(186.3,72.36) ; v4(30.7,117.65) U40.Y27 ; C34.2 v1(190.31,171.22) ; v4(206.55,198.58) U9.B17 ; v4(23.7,105.65) U40.J34 ; U16.D8 v4(83.14,160.82) ; v4(98.48,161.62) U17.E3 ; v4(51.7,111.65) U40.R7 ; C33.2 v1(192.34,171.29) ; v1(48,165.81) 47.34,166.47 R270.1 ; v4(56.96,161.62) U14.E3 ; C604.2 v1(117.74,66.21) ; v1(88.99,96.87) 89.37,96.87 89.57,97.07 C467.2 ; v4(189.55,181.4) 189.55,181.4 190.05,181.9 U9.V1 ; v4(54.7,106.65) U40.K4 ; v1(53.56,67.6) 53.94,67.98 C547.2 ; v4(28.7,98.65) U40.B29 ; U52.J4 v4(228.18,120.65) ; U15.B2 v4(68.3,159.22) ; v4(99.29,159.22) U17.B2 ; v4(35.7,107.65) U40.L22 ; v4(24.7,117.65) U40.Y33 ; v4(53.7,118.65) U40.AA5 ; C215.2 v1(92.6,152.55) ; v4(29.7,119.65) U40.AB28 ; C112.1 85.07,218.63 v1(84.93,218.49) ; 6.5,114.53 R683.2 ; U40.W6 v4(52.7,116.65) ; v1(12.09,134.97) R486.2 R482.2 ; R14.2 v1(230.07,231.49) ; v4(34.7,128.65) U40.AL23 ; U16.T1 89.21,170.95 89.26,170.97 90.19,171.11 v4(91.05,171.24) ; v4(40.7,126.65) U40.AJ18 ; C165.2 C166.2 29.66,164 v4(29.77,163.89) ; U40.W10 v4(48.7,116.65) ; C19.2 232.02,228.09 v1(231.86,228.25) ; U40.H21 v4(36.7,104.65) ; U40.W23 v4(34.7,116.65) ; CB855.2 v1(48.27,66.39) ; v4(43.7,118.65) U40.AA15 ; CB7.1 81.88,183.37 v1(81.72,183.21) ; v4(57.7,111.65) U40.R1 ; U40.B5 v4(53.7,98.65) U40.A5 ; v1(9.1,125.29) 9.58,124.81 R594.2 ; R508.1 6.04,132.94 v1(5.78,132.69) ; C545.2 29.25,68.02 29.25,67.68 v1(29.22,67.65) ; C191.1 v1(213.91,122.76) ; v4(55.7,106.65) U40.K3 ; v4(46.7,105.65) U40.J12 ; v4(30.7,111.65) U40.R27 ; v4(26.42,166.29) 26.84,165.88 C151.2 27.14,165.45 27.6,165.91 C149.2 C143.2 R256.1 26.48,167.94 v4(26.42,167.89) ; v1(5.78,133.7) 6.04,133.96 R500.1 ; v4(20.7,98.65) U40.B37 ; v4(100.08,166.42) U17.K1 ; v4(41.7,98.65) U40.B17 ; R607.1 12.12,123.8 v1(12.08,123.76) ; v4(45.7,120.65) U40.AC13 ; v1(54.32,178.96) C86.2 ; C212.2 v1(116.4,146.16) ; U40.T8 v4(50.7,112.65) ; v4(57.7,121.65) U40.AD1 ; U40.W2 v4(56.7,116.65) ; v4(21.7,101.65) U40.E36 ; U40.U33 v4(24.7,113.65) ; R551.1 9.06,128.88 v1(9.02,128.84) ; v1(119.83,133.72) 119.83,134.28 C207.2 ; C819.2 v1(118.72,71.72) ; v4(25.7,101.65) U40.E32 ; v4(26.7,101.65) U40.E31 ; v4(69.1,161.62) U15.E1 ; v4(41.7,128.65) U40.AL17 ; R663.2 R681.2 12.21,117.32 v1(12.09,117.32) ; C838.2 v1(181.71,66.79) ; v4(36.7,103.65) U40.G21 ; v4(49.7,103.65) U40.G9 ; v4(55.7,129.65) U40.AM3 ; v1(80.83,71.07) 80.56,71.07 C531.2 79.68,71.95 v1(79.04,71.95) ; v4(24.7,107.65) U40.L33 ; v4(22.7,108.65) U40.M35 ; v4(48.7,119.65) U40.AB10 ; v4(43.7,124.65) U40.AG15 ; v4(190.55,198.58) U9.B2 ; U40.U17 v4(41.7,113.65) ; v4(42.7,108.65) U40.M16 ; v4(31.7,114.65) U40.V26 ; U40.W29 v4(28.7,116.65) ; v4(52.7,106.65) U40.K6 ; v4(23.7,124.65) U40.AG34 ; v4(37.7,119.65) U40.AB20 ; U40.T31 v4(26.7,112.65) ; v4(25.7,107.65) U40.L32 ; C190.1 v1(213.9,125.81) ; R682.2 15.18,116.69 v1(15.15,116.65) 14.86,116.65 14.51,116.3 14.5,116.3 13.87,115.67 R685.2 ; v1(20.54,151.91) 20.16,151.53 C225.2 ; v4(24.7,132.65) U40.AR33 ; U40.W17 v4(41.7,116.65) ; v4(62.7,158.42) U15.A8 ; R854.1 v1(219.41,115.98) ; U40.H18 v4(40.7,104.65) ; v4(46.7,107.65) U40.L12 ; v4(36.7,97.65) U40.A21 ; v4(43.7,122.65) U40.AE15 ; v4(37.7,114.65) U40.V20 ; v4(31.7,107.65) U40.L26 ; v4(37.7,105.65) U40.J20 ; U40.G25 v4(32.7,103.65) ; v4(57.76,158.42) U14.A2 ; U40.AU11 v4(47.7,134.65) ; v4(89.54,161.62) U16.E1 ; v4(207.58,181.55) U9.V18 ; C666.2 v1(38.83,66.79) ; v4(26.7,122.65) U40.AE31 ; U40.U14 v4(44.7,113.65) ; v4(48.7,114.65) U40.V10 ; U72.4 v1(227.65,171.04) ; v4(57.76,159.22) U14.B2 ; 29.65,71.93 29.39,72.2 v1(28.83,72.2) ; 29.65,71.93 v1(28.91,71.19) ; 29.65,71.93 C539.2 ; R357.1 v1(102.26,185.46) ; v1(43.21,71.15) 43.21,71.28 42.86,71.64 C540.2 41.83,71.64 v1(41.45,71.25) ; v4(22.7,106.65) U40.K35 ; R1019.1 v1(70.61,185.85) ; v4(27.7,100.65) U40.D30 ; J2.A1 143.87,138.82 v1(143.75,138.71) ; v1(86.02,149.27) 86,149.3 C235.2 ; v4(39.7,124.65) U40.AG19 ; R501.1 9.07,133.96 v1(9.03,133.92) ; v4(56.7,101.65) U40.E2 ; v4(49.7,120.65) U40.AC9 ; v4(21.7,117.65) U40.Y36 ; v1(15.15,122.75) 15.18,122.78 R620.1 ; C617.2 v1(157.51,66.79) ; v4(196.55,191.58) U9.J8 ; U52.G5 v4(230.18,123.65) ; v4(26.7,107.65) U40.L31 ; v4(69.1,164.02) U15.H1 ; v4(58.56,162.42) U14.F1 ; v4(197.55,192.58) U9.H9 ; C839.2 v1(182.72,66.79) ; U40.C25 v4(32.7,99.65) ; v4(100.08,162.42) U17.F1 ; v4(34.7,134.65) U40.AU23 ; v4(30.7,120.65) U40.AC27 ; v4(28.7,123.65) U40.AF29 ; C397.1 63.85,112.11 v1(63.59,112.37) ; C493.1 155.78,91.59 v1(155.79,91.6) ; C451.2 v1(88.99,100.05) ; C89.2 v1(61.43,178.92) ; v4(31.7,123.65) U40.AF26 ; v4(200.55,189.58) U9.K11 ; v4(92.89,160.02) U17.C9 ; C672.2 72.74,64.41 v1(72.76,64.4) ; U40.AA25 v4(32.7,118.65) ; v4(50.7,106.65) U40.K8 ; P1.U21 v4(111.29,230.46) ; U16.E8 v4(83.14,161.62) ; C802.2 v1(49.36,66.79) ; CB799.2 v1(35.33,67.6) ; C267.2 58.77,140.53 v1(58.8,140.49) ; v4(42.7,100.65) U40.D16 ; v1(4.08,156.75) 4.16,156.68 R403.1 ; P1.V5 v4(112.29,213.46) ; v4(61.9,164.02) U15.H9 ; v1(109.86,71.95) 110.5,71.95 C532.2 110.81,71.57 110.5,71.25 v1(109.86,71.25) ; R358.1 v1(103.53,185.46) ; v4(41.7,103.65) U40.G17 ; U40.W36 v4(21.7,116.65) ; v4(28.7,103.65) U40.G29 ; v4(24.7,101.65) U40.E33 ; U16.A8 v4(83.14,158.42) ; v4(39.7,101.65) U40.E19 ; v4(99.29,158.42) U17.A2 ; C416.1 v1(60.93,106.02) ; U15.M9 v4(61.9,168.02) ; v4(195.55,181.58) U9.V7 ; U40.H12 v4(46.7,104.65) ; v4(55.7,126.65) U40.AJ3 ; v1(5.82,126.86) 5.93,126.86 5.93,126.85 R573.1 R582.2 ; v4(195.55,192.58) U9.H7 ; v1(36.05,188.18) C285.2 36.37,188.87 v1(36.86,188.38) ; v4(207.55,199.58) U9.A18 ; v4(46.7,106.65) U40.K12 ; v4(43.7,107.65) U40.L15 ; C186.2 32.22,160.63 v4(31.37,161.49) 32.28,162.41 C172.2 ; U40.L10 v4(48.7,107.65) ; U40.E12 v4(46.7,101.65) ; v4(41.7,122.65) U40.AE17 ; U40.B25 v4(32.7,98.65) ; v1(12.07,132.9) 12.1,132.94 R510.2 ; v4(36.7,108.65) U40.M21 ; v4(51.36,161.62) U14.E9 ; 148.21,99.59 v1(148.22,99.58) ; U40.H10 v4(48.7,104.65) ; v4(46.7,109.65) U40.N12 ; C803.2 v1(50.39,66.79) ; v4(57.7,133.65) U40.AT1 ; R502.2 12.21,133.96 v1(12.12,133.87) ; v4(49.7,132.65) U40.AR9 ; C570.2 v1(47.84,67.6) ; v4(53.7,109.65) U40.N5 ; v4(35.7,123.65) U40.AF22 ; v4(44.7,117.65) U40.Y14 ; U52.E4 v3(228.18,125.65) ; v4(20.7,103.65) U40.G37 ; v4(34.7,122.65) U40.AE23 ; v4(28.7,102.65) U40.F29 ; v4(34.7,120.65) U40.AC23 ; P1.C21 v4(96.29,230.46) ; v4(25.7,118.65) U40.AA32 ; P1.E7 v4(98.29,215.46) ; U40.H9 v4(49.7,104.65) ; R338.1 v1(123.64,140.45) ; U40.W28 v4(29.7,116.65) ; v4(190.55,182.58) U9.U2 ; v4(49.7,107.65) U40.L9 ; v4(100.08,164.02) U17.H1 ; C159.2 v1(78.15,163.34) ; CB813.2 v1(121.62,68.41) ; v4(82.34,160.02) U16.C9 ; v4(92.89,166.42) U17.K9 ; R529.1 15.18,130.91 v1(15.15,130.88) ; v4(89.54,164.02) U16.H1 ; v4(44.7,101.65) U40.E14 ; v4(88.74,159.22) U16.B2 ; v4(40.7,101.65) U40.E18 ; v4(56.7,117.65) U40.Y2 ; C140.2 5.73,168.49 5.73,168.49 v1(5.73,168.55) ; U40.U15 v4(43.7,113.65) ; v4(21.7,106.65) U40.K36 ; v1(156.18,93.62) C476.1 ; U40.H24 v4(33.7,104.65) ; R690.1 v1(14.75,113.46) ; v4(31.7,117.65) U40.Y26 ; R472.1 v1(86,143.86) ; U40.H17 v4(41.7,104.65) ; v4(26.7,118.65) U40.AA31 ; v1(155.39,92.3) C489.1 ; RB33.2 v1(113.22,237.59) ; C796.2 v1(26.05,66.76) ; v4(54.7,100.65) U40.D4 ; U52.J1 v3(225.18,121.65) ; v4(37.7,100.65) U40.D20 ; v4(41.7,120.65) U40.AC17 ; v4(57.7,98.65) U40.B1 ; v4(53.7,110.65) U40.P5 ; U52.L5 v4(230.18,118.65) ; v4(31.7,106.65) U40.K26 ; v4(36.7,107.65) U40.L21 ; v4(33.7,101.65) U40.E24 ; v4(30.7,118.65) U40.AA27 ; v4(52.7,118.65) U40.AA6 ; U40.AL11 v4(47.7,128.65) ; CB8.1 v1(84.45,185.05) ; U40.T18 v4(40.7,112.65) ; v4(37.7,121.65) U40.AD20 ; v4(34.7,118.65) U40.AA23 ; v4(20.7,102.65) U40.F37 ; U52.K4 v4(228.18,119.65) ; C603.2 v1(118.75,66.21) ; v4(27.7,101.65) U40.E30 ; v4(52.7,101.65) U40.E6 ; v4(31.7,109.65) U40.N26 ; v4(88.74,158.42) U16.A2 ; v4(31.7,128.65) U40.AL26 ; v4(200.55,187.58) U9.M11 ; v4(69.1,168.82) U15.N1 ; v4(35.7,119.65) U40.AB22 ; C47.2 v1(67.64,193) ; C574.2 v1(20.27,72.6) ; C535.2 174.38,71.95 174.21,71.95 174.14,71.98 173.57,72.36 v1(173.57,72.55) ; v4(57.7,118.65) U40.AA1 ; v4(56.7,107.65) U40.L2 ; U40.H11 v4(47.7,104.65) ; U52.G3 v3(227.18,123.65) ; v1(120.72,133.72) C205.2 ; v4(37.7,117.65) U40.Y20 ; v4(29.7,121.65) U40.AD28 ; R18.2 v1(234.51,230.71) ; v4(33.7,107.65) U40.L24 ; v4(33.7,121.65) U40.AD24 ; R576.1 15.18,126.85 v1(15.15,126.81) ; v4(53.7,101.65) U40.E5 ; R359.1 v1(104.55,185.46) ; v4(55.7,108.65) U40.M3 ; v4(33.7,114.65) U40.V24 ; v4(51.7,107.65) U40.L7 ; v4(34.7,101.65) U40.E23 ; v4(50.7,134.65) U40.AU8 ; v4(53.7,114.65) U40.V5 ; v1(9.02,127.82) 9.06,127.86 R562.1 R574.1 ; U40.W15 v4(43.7,116.65) ; C69.2 v1(182.78,198.16) ; R19.2 v1(235.65,230.71) ; v4(42.7,121.65) U40.AD16 ; v4(28.7,118.65) U40.AA29 ; v4(44.7,119.65) U40.AB14 ; R1470.1 v1(88.42,213.21) ; v4(199.55,188.58) U9.L10 ; C268.2 41.12,142.09 v1(41.12,142.09) ; v4(93.69,161.62) U17.E8 ; U52.E6 v4(231.18,125.65) ; v4(49.7,102.65) U40.F9 ; U40.F25 v4(32.7,102.65) ; v4(57.7,127.65) U40.AK1 ; U52.H1 v3(225.18,122.65) ; v4(23.7,99.65) U40.C34 ; U40.T4 v4(54.7,112.65) ; U52.H2 v1(226.18,121.65) ; v4(46.7,132.65) U40.AR12 ; U40.AG25 v4(32.7,124.65) ; v4(62.7,163.22) U15.G8 ; v4(48.7,124.65) U40.AG10 ; U40.T24 v4(33.7,112.65) ; v4(28.7,117.65) U40.Y29 ; v4(36.7,111.65) U40.R21 ; v4(45.7,101.65) U40.E13 ; v4(57.7,117.65) U40.Y1 ; C30.2 v1(191.33,171.17) ; R405.1 v1(6.7,156.78) ; v4(52.16,160.82) U14.D8 ; U40.T14 v4(44.7,112.65) ; C439.2 v1(88.99,102.08) ; U40.AD11 v4(47.7,121.65) ; R653.1 v1(9.05,119.73) ; v4(23.7,130.65) U40.AN34 ; v4(55.7,101.65) U40.E3 ; v4(28.7,97.65) U40.A29 ; v4(53.7,117.65) U40.Y5 ; v4(99.29,160.82) U17.D2 ; v4(37.7,128.65) U40.AL20 ; v4(27.7,107.65) U40.L30 ; v4(82.34,164.02) U16.H9 ; v4(54.7,108.65) U40.M4 ; v4(37.7,99.65) U40.C20 ; v4(53.7,122.65) U40.AE5 ; v4(48.7,130.65) U40.AN10 ; U40.R25 v4(32.7,111.65) ; v4(25.7,128.65) U40.AL32 ; v4(49.7,117.65) U40.Y9 ; v4(24.7,97.65) U40.A33 ; v4(42.7,99.65) U40.C16 ; U40.T35 v4(22.7,112.65) ; v4(31.7,101.65) U40.E26 ; v4(23.7,108.65) U40.M34 ; R516.1 6.04,131.93 v1(5.78,131.67) ; v4(33.7,132.65) U40.AR24 ; 94.81,105.61 C754.1 ; v4(51.7,130.65) U40.AN7 ; v1(58.8,139.8) 57.5,139.8 C271.2 57.75,139.04 v1(58.8,139.04) ; v4(54.7,99.65) U40.C4 ; v4(40.7,132.65) U40.AR18 ; v1(15.15,125.8) 15.18,125.83 R585.1 ; v4(35.7,114.65) U40.V22 ; U40.T34 v4(23.7,112.65) ; v4(43.7,126.65) U40.AJ15 ; v4(35.7,124.65) U40.AG22 ; v4(58.56,166.42) U14.K1 ; v4(30.7,108.65) U40.M27 ; v4(30.7,101.65) U40.E27 ; v4(69.1,171.22) U15.T1 ; v4(52.7,120.65) U40.AC6 ; v4(196.55,193.58) U9.G8 ; v4(34.7,124.65) U40.AG23 ; v4(53.7,102.65) U40.F5 ; C818.2 v1(117.7,71.72) ; U40.H16 v4(42.7,104.65) ; U40.U27 v4(30.7,113.65) ; v4(44.7,110.65) U40.P14 ; v4(43.7,111.65) U40.R15 ; C211.2 v1(117.41,146.16) ; v4(21.7,111.65) U40.R36 ; v4(54.7,105.65) U40.J4 ; v1(35.17,64.4) 35.15,64.41 C690.2 ; U52.G4 v3(228.18,123.65) ; v4(53.7,106.65) U40.K5 ; C832.2 v1(158.53,66.79) ; v4(27.7,126.65) U40.AJ30 ; v4(50.7,107.65) U40.L8 ; v4(82.34,168.02) U16.M9 ; U40.H14 v4(44.7,104.65) ; v4(37.7,106.65) U40.K20 ; C551.2 v1(65.72,68.41) ; v4(68.3,158.42) U15.A2 ; C815.2 v1(87.46,66.67) ; C670.2 v1(51.41,66.79) ; v4(57.76,160.82) U14.D2 ; U40.L6 v4(52.7,107.65) ; v4(50.7,108.65) U40.M8 ; C814.2 v1(86.43,66.67) ; v4(24.7,103.65) U40.G33 ; P1.AA5 v4(115.29,213.46) ; v4(35.7,109.65) U40.N22 ; v4(24.7,114.65) U40.V33 ; R15.2 v1(231.67,231.43) ; v4(31.7,110.65) U40.P26 ; U40.K7 v4(51.7,106.65) ; v4(25.7,111.65) U40.R32 ; U40.T29 v4(28.7,112.65) ; v4(29.77,162.29) 29.65,162.18 R322.1 ; U52.L6 v4(231.18,118.65) ; v4(42.7,130.65) U40.AN16 ; U40.T10 v4(48.7,112.65) ; v4(54.7,117.65) U40.Y4 ; v4(196.55,192.58) U9.H8 ; v4(50.7,101.65) U40.E8 ; v4(199.55,192.58) U9.H10 ; C665.2 v1(39.85,66.79) ; v4(33.7,117.65) U40.Y24 ; v4(40.7,107.65) U40.L18 ; v4(41.7,109.65) U40.N17 ; v4(25.7,134.65) U40.AU32 ; v4(51.36,164.02) U14.H9 ; P1.F21 v4(99.29,230.46) ; v4(24.7,98.65) U40.B33 ; v4(20.7,101.65) U40.E37 ; v4(45.7,103.65) U40.G13 ; U40.AH20 v4(37.7,125.65) ; v4(26.7,106.65) U40.K31 ; v4(100.08,171.22) U17.T1 ; C825.2 v1(139.15,66.72) ; v4(35.7,121.65) U40.AD22 ; U40.H22 v4(35.7,104.65) ; v1(65.5,178.92) C93.2 ; v4(51.7,118.65) U40.AA7 ; v4(25.7,106.65) U40.K32 ; U40.H26 v4(31.7,104.65) ; C102.2 v1(54.32,173.84) ; U52.H6 v4(231.18,121.65) ; C20.2 v1(233.11,228.31) ; v1(62.45,178.92) C90.2 ; v4(33.7,100.65) U40.D24 ; v4(42.7,119.65) U40.AB16 ; v4(56.7,111.65) U40.R2 ; v4(27.7,106.65) U40.K30 ; v4(37.7,101.65) U40.E20 ; v4(40.7,123.65) U40.AF18 ; v4(42.7,114.65) U40.V16 ; v4(36.7,98.65) U40.B21 ; v4(40.7,119.65) U40.AB18 ; C28.2 193.36,171.21 v1(193.36,171.22) ; R550.2 5.86,128.88 v1(5.82,128.84) ; v4(53.7,111.65) U40.R5 ; 118.94,177.89 CB545.2 119.5,178.48 ; U40.W27 v4(30.7,116.65) ; v4(41.7,107.65) U40.L17 ; v4(51.7,101.65) U40.E7 ; v4(28.7,106.65) U40.K29 ; v4(46.7,126.65) U40.AJ12 ; v4(48.7,110.65) U40.P10 ; v4(49.7,97.65) U40.A9 ; v4(21.7,118.65) U40.AA36 ; U40.E10 v4(48.7,101.65) ; v4(48.7,118.65) U40.AA10 ; v4(50.7,128.65) U40.AL8 ; v4(197.55,188.58) U9.L9 ; v4(33.7,99.65) U40.C24 ; CB3.2 v1(91.37,181.49) ; v4(33.7,105.65) U40.J24 ; v4(24.7,108.65) U40.M33 ; v4(44.7,134.65) U40.AU14 ; v4(57.7,102.65) U40.F1 ; C798.2 v1(36.8,66.79) ; v4(22.7,134.65) U40.AU35 ; v4(45.7,111.65) U40.R13 ; R616.1 46.34,194.88 v1(46.95,194.27) ; v4(51.7,117.65) U40.Y7 ; v4(39.7,107.65) U40.L19 ; U40.H19 v4(39.7,104.65) ; v4(44.7,128.65) U40.AL14 ; v4(46.7,123.65) U40.AF12 ; v4(42.7,107.65) U40.L16 ; C843.2 v1(196.29,66.67) ; P1.U17 v4(111.29,226.46) ; v4(30.7,126.65) U40.AJ27 ; P1.V19 v4(112.29,228.46) ; v4(53.7,131.65) U40.AP5 ; v4(42.7,105.65) U40.J16 ; U52.J5 v4(230.18,120.65) ; v4(92.89,164.02) U17.H9 ; v4(53.7,103.65) U40.G5 ; U52.D6 v4(231.18,126.65) ; v4(61.9,166.42) U15.K9 ; v4(39.7,122.65) U40.AE19 ; P1.P21 v4(108.29,230.46) ; U40.U11 v4(47.7,113.65) ; v4(24.7,106.65) U40.K33 ; U40.AH26 v4(31.7,125.65) ; v4(29.7,118.65) U40.AA28 ; U52.J6 v4(231.18,120.65) ; C478.2 v1(5.55,94.33) ; v4(89.54,162.42) U16.F1 ; v4(58.56,161.62) U14.E1 ; v4(82.34,166.42) U16.K9 ; v4(52.16,161.62) U14.E8 ; C985.1 v1(64.99,217.52) ; v4(50.7,99.65) U40.C8 ; v4(189.55,199.58) U9.A1 ; R404.1 v1(5.43,156.75) ; v4(31.7,134.65) U40.AU26 ; v4(49.7,98.65) U40.B9 ; v4(44.7,114.65) U40.V14
  TOP w0.508: 254.1,159.5 C311.2 ; C627.2 v1(169.13,72.64) ; R439.2 v1(204.66,133.64) ; CB922.1 v1(248.38,157.71) ; Q3.S v1(132.14,218.95) ; P1.D18 v4(97.29,227.46) ; C718.2 v1(254.94,100.91) ; v1(148.5,67.66) 148.51,67.67 C560.2 ; P1.F9 v4(99.29,217.46) ; R1066.1 v1(227.1,139.03) ; v1(214.29,140.79) 213.96,140.46 C999.2 ; v1(227.74,210.92) 227.78,210.96 R166.1 ; CONN56.14 239.72,247.26 v1(239.74,247.24) ; CB866.2 78.86,65.12 v1(78.36,65.62) ; C485.2 v1(172.62,206.35) ; CB903.1 v1(241.52,155.93) ; CB908.2 216.7,74.72 v1(216.37,74.39) ; C806.2 v1(61.93,66.79) ; C21.2 234.38,228.29 v1(234.36,228.31) ; C887.2 v1(230.6,109.77) ; P1.U2 v4(111.29,210.46) ; v1(123.16,224.25) 123.06,224.35 RB30.2 ; R1059.1 v1(240.11,119.6) ; C183.1 v1(241.46,242.8) ; v1(68.25,70.94) 68.18,70.94 C530.2 66.81,70.96 v1(66.72,70.96) ; CB31.2 v1(58.83,222.03) ; v1(258.74,36.43) 258.74,36.43 CB931.2 ; CB862.2 60.23,64.41 v1(60.25,64.4) ; RB1306.1 v1(124.87,220.95) ; R1401.2 v1(141.6,170.32) ; C646.2 v1(18.56,66.78) ; v1(69.43,181.39) 69.54,181.49 C63.1 ; CB1083.1 v1(247.56,98.83) ; v1(212.63,75.66) 212.86,75.9 212.86,76.89 212.82,76.93 CB907.2 212.82,78.08 v1(212.79,78.12) ; P1.E2 v4(98.29,210.46) ; C554.2 v1(109.05,68.41) ; C97.1 85.15,220.1 v1(85.1,220.06) 84.93,219.88 R139.2 84.1,220.52 v1(83.76,220.87) 83.83,220.95 84.76,220.95 85.34,221.52 R100.2 ; C522.2 v1(241.4,93.64) ; C344.2 v1(31.24,208.54) ; R1438.1 v1(109.4,183.39) ; v1(152.8,163.7) 152.29,163.19 OSC7.2 151.35,162.14 150.96,161.75 v1(149.88,161.75) ; C549.2 v1(111.52,75.27) ; P1.N6 v4(107.29,214.46) ; v1(238.53,137.7) 238.54,137.7 CB1012.1 ; C837.2 v1(172.18,72.64) ; R856.1 v1(244.12,91.55) ; v1(156.52,188.82) 156.48,188.82 156.48,188.78 157.32,187.94 CB1200.2 ; U81.3 38.95,217.01 v1(38.99,217.04) ; v4(104.31,230.43) 104.25,230.43 P1.K21 ; CB910.2 203.04,77.22 v1(202.33,77.92) 202.34,77.93 CB919.2 ; P1.K7 v4(103.29,215.46) ; CB809.2 v1(85.44,67.28) 84.99,66.83 C596.2 ; OSCB1.2 86.12,180.23 v1(86.39,180.5) ; v1(111.73,137.32) 111.76,137.28 C223.2 ; C680.2 136.78,64.29 v1(136.8,64.27) ; C959.1 v1(223.11,32.49) ; U29.4 v1(133.57,206.02) ; C973.2 v1(208.37,113.38) ; v1(198.28,231.45) 198.36,231.52 OSC2.2 ; C146.2 201.75,237.99 v1(201.77,237.97) ; v1(141.81,161.83) 141.84,161.81 CB1224.2 ; v1(111.79,136.24) 111.81,136.27 C213.2 ; U80.10 v1(74.9,208.82) ; v1(233.33,247.24) 233.37,247.29 CONN56.24 ; C980.2 129.15,235.84 129.12,235.87 v1(129.12,235.97) ; P1.U1 v4(111.29,209.46) ; C563.2 v1(167.49,67.6) ; C423.2 v1(30.13,208.56) ; J2.G1 140.61,154.91 v1(141.89,156.18) ; X1.2 v1(196.18,123.8) ; v4(106.29,217.46) P1.M9 P1.L10 ; CB49.2 91.56,192.92 v1(91.6,192.89) ; C631.2 v1(183.8,72.64) ; v1(205.32,235.87) C136.1 v1(204.37,236.7) ; R1115.1 v1(181.58,212.91) ; R67.2 91.09,205.59 90.9,205.78 v1(90.9,205.84) ; CB36.1 v1(37.37,221.84) ; C924.1 141.98,165.84 v1(141.92,165.78) ; v1(141.32,204.06) 141.25,204.06 141.24,204.08 R541.1 ; RB1269.2 v1(137,214.54) ; R317.2 v1(181.91,183.7) ; C7.2 v1(152.94,259) ; P1.B17 v4(95.29,226.46) ; R65.1 v1(221.32,221.54) ; CB854.2 40.72,66.4 v1(40.72,66.39) ; C175.2 163.23,222.02 v1(163.22,222.03) ; C39.2 v1(263.68,249.27) ; P1.E19 v4(98.29,228.46) ; R1383.2 v1(141.57,181.96) ; CB21.1 v1(141.32,233.02) ; CB828.2 v1(40.64,68.41) ; C121.2 v1(180.66,192.4) ; C182.1 85.63,230.54 v1(85.06,229.97) ; R378.2 v1(139.18,234.31) ; CB807.2 v1(72.92,67.6) ; P1.AA8 v4(115.29,216.46) ; C828.2 v1(145.96,66.79) ; P1.T4 v4(110.29,212.46) ; P1.AA1 v4(115.29,209.46) ; CB708.2 v1(194.66,97.94) ; R1440.2 104.31,175.74 v1(104.33,175.71) ; v1(122.33,206.6) 122.14,206.41 RB1252.1 ; CB1029.2 v1(218.43,122.71) ; C659.2 v1(142.26,72.56) ; v1(228.57,184) 227.64,183.07 OSC6.4 ; v1(243.81,128.52) 243.68,128.39 C313.2 ; C341.2 v1(266.33,90.43) ; C805.2 v1(51.47,72.64) ; R80.2 243.12,219.67 v1(243.16,219.63) ; CONN2.2 v1(167.31,257.48) ; C437.2 201.12,94.74 v1(200.74,94.35) C967.2 ; v1(160.24,65.19) 160.3,65.13 CB876.2 ; R1363.2 101.21,202.94 v1(101.49,202.66) ; C983.2 v1(132.16,235.99) ; 132.23,117.83 132.28,117.78 C977.2 ; R1099.1 v1(184.62,212.94) ; v1(10.99,92.2) 10.38,92.81 L54.2 ; v1(229.26,209.03) 229.56,209.33 C123.1 ; C525.2 v1(241.45,92.62) ; v1(219.35,121.03) R1047.1 220.15,121.03 RB759.2 ; C972.2 v1(208.44,112.37) ; C279.2 33.06,192.37 33.02,192.41 ; CONN56.17 v1(237.18,257) ; C649.2 v1(64.99,66.79) ; P1.W1 112.79,209.34 v4(112.78,209.33) ; v1(239.47,222.26) 239.33,222.12 R57.1 ; P1.E1 v4(98.29,209.46) ; P1.AA17 v4(115.29,226.46) ; RB21.1 v1(91.19,189.67) ; C206.2 v1(9.06,158.68) ; v1(198.83,126.62) 198.74,126.62 198.73,126.63 X1.4 ; v1(144.49,239.94) 144.96,240.4 U8.4 ; C104.2 v1(237.12,213.5) ; C347.2 v1(265.3,90.43) ; C227.1 v1(12.41,153.36) ; C57.2 v1(155.27,244.34) ; C276.2 v1(141.38,210.15) ; C620.2 v1(158.59,72.64) ; R641.2 253.07,220.09 v1(253.01,220.02) ; 133.34,117.89 133.27,117.83 C978.2 ; R352.1 v1(229.9,241.53) ; v1(179.97,64.4) 179.95,64.41 C686.2 ; CB4.2 v1(61.69,222.03) ; C994.2 v1(247.46,148.56) ; v1(233.52,182.4) R1318.1 233.52,183.27 C871.2 ; v1(239.42,218.22) 239.41,218.21 C61.2 ; P1.V14 v4(112.29,223.46) ; v1(130.78,210.98) 130.96,211.17 Q4.S ; R1457.1 R1366.2 ; R1366.2 116.49,203.17 v1(116.42,203.11) ; R1366.2 R1367.2 ; R190.1 v1(159.73,215.62) ; C45.2 v1(239.52,220.89) ; C622.2 167.92,66.4 v1(167.93,66.39) ; v1(87.15,231.07) 87.15,231.05 87.28,230.92 R335.2 ; v1(226.72,109.89) 226.73,109.9 C891.1 ; C231.2 111.69,138.3 v1(111.66,138.28) ; C608.2 v1(129.25,66.39) ; C641.2 v1(16.52,72.49) ; C816.2 v1(87.9,72.51) ; C564.2 v1(172.93,68.41) ; C29.2 239.45,225.45 v1(239.47,225.46) ; v1(241.23,73.75) 241.24,73.74 U50.8 ; v1(154.82,64.4) 154.8,64.41 C682.2 ; v1(8.63,154.73) 8.22,154.73 7.8,155.16 C208.2 ; R1461.1 122.27,211.74 122.33,211.68 v1(122.33,211.73) ; C826.2 v1(143.99,72.64) ; v1(235.56,209.43) 235.56,209.43 235.51,209.43 235.43,209.51 235.36,209.51 234.87,210.01 C122.1 234.87,210.86 v1(234.95,210.93) ; CB759.1 v1(194.3,102.56) ; C555.2 116.25,67.86 115.93,67.54 115.93,67.5 v1(115.97,67.5) ; CB327.1 v1(210.15,133.64) ; R1042.1 240.11,120.61 v1(240.12,120.62) ; CB1057.2 v1(199.68,214.93) ; CB846.2 v1(173.01,66.39) ; R377.2 v1(139.16,227.68) ; v1(112.41,75.26) 112.41,75.49 111.59,76.31 C544.2 ; v1(255.24,49.76) 255.04,49.57 C952.1 ; RB1228.2 90.87,237.74 v1(90.58,238.03) ; C738.1 238.73,77.01 v1(238.6,76.87) ; C644.2 v1(16.55,66.77) ; v1(78.35,188.8) 78.46,188.91 RB29.1 ; C610.2 v1(137.39,66.27) ; v1(214.87,140.23) 214.06,139.42 C998.2 ; P1.AB2 v4(116.29,210.46) ; CB1227.2 144.52,161.8 144.6,161.72 v1(144.7,161.72) ; R1423.2 v1(162.4,184.38) ; C303.2 v1(264.28,90.43) ; L10.2 60.92,85.85 v1(61.68,86.61) ; CB1217.2 45.02,204.1 v1(45.02,204.11) ; R499.1 165.85,134.44 v1(165.83,134.47) ; R455.2 v1(199.84,129.28) ; R41.2 v1(240.43,226.86) ; C477.2 v1(215.66,109.29) ; CB1047.1 v1(198.41,215.42) ; C468.2 v1(202.12,101.79) ; CB796.2 180.13,67.36 v1(180.18,67.31) ; C629.2 v1(182.79,72.64) ; C934.2 147.79,187.83 v1(147.78,187.83) ; v1(162.46,178.22) 162.46,178.53 162.08,178.92 C916.2 C928.2 ; P1.M3 v4(106.29,211.46) ; C809.2 v1(65.06,72.64) ; v1(60.42,67.45) 60.41,67.46 CB801.2 ; C1000.2 v1(209.29,147.7) ; P1.J6 v4(102.29,214.46) ; CB7.1 82.42,182.57 82.87,182.12 OSCB1.4 ; v1(29.18,208.51) 29.12,208.56 C422.2 ; v1(94.14,182.81) CB6.2 v1(92.96,181.81) ; C591.2 v1(75.47,72.64) ; R390.2 v1(211.12,131.06) ; C56.2 168.73,177.05 v1(167.54,175.87) ; R672.1 C355.2 244.41,162.25 v1(244.57,162.41) ; P1.B11 v4(96.29,219.46) ; C676.2 116.07,64.41 v1(116.08,64.4) ; P1.U3 v4(111.29,211.46) ; CB999.1 218.36,130.07 v1(218.35,130.07) 217.3,129.02 CB1021.1 ; v1(142.78,245.91) 142.76,245.89 R73.1 ; v1(240.38,123.29) 240.44,123.23 C320.2 241.26,122.78 v1(240.76,122.27) ; OSC1.2 v1(86.61,212.18) ; C308.1 137.61,133.53 ; C248.2 v1(208.44,225.55) ; C218.2 15.83,257.33 v1(15.84,257.34) ; CB863.2 54.05,64.35 v1(54,64.3) ; C642.2 17.54,72.49 v1(17.54,72.49) ; C35.2 v1(239.45,224.44) ; v1(85.21,211.95) 84.51,211.25 C50.2 ; C678.2 128.64,64.41 v1(128.66,64.4) ; P1.B5 v4(95.29,213.46) ; v1(78.35,187.78) 78.37,187.76 RB13.1 ; v1(82.13,195.17) 82.16,195.14 RB45.2 ; R137.2 v1(122.52,202.98) ; R288.2 127.83,218.75 v1(127.66,218.92) 127.82,219.07 R313.2 ; CB1023.2 v1(221.72,127.16) ; CB899.2 v1(211.75,74.58) ; C145.1 v1(129.07,214.93) ; C716.2 255.93,100.89 v1(255.93,100.89) ; CONN28.2 v1(257.64,218.93) ; v1(230.37,213.05) 230.27,212.95 230.21,212.95 229.99,212.73 C106.1 ; v1(203.13,154.5) J2.G3 ; J2.G3 v1(201.76,156.69) ; J2.G3 201.76,154.08 200.63,152.94 v1(199.99,152.94) ; CB321.1 202.7,119.37 202.72,119.35 v1(202.72,119.29) ; v1(88.44,216.11) 88.42,216.11 88.42,216.13 88.55,216.25 R1409.2 ; R1365.2 v1(106.33,202.98) ; C24.2 v1(5.3,190.47) ; P1.J8 v4(102.29,216.46) ; C874.2 v1(235.52,182.42) ; v1(252.15,102.51) 252.13,102.5 C717.2 ; R1425.1 v1(38.58,207.86) ; R350.1 v1(247.23,240.82) ; CB1000.1 v1(221.78,134.54) ; R1424.1 v1(41.39,207.82) ; v1(185.51,64.72) 185.92,65.12 CB880.2 ; SW1.4 v1(261.05,194.6) ; v1(162.33,188.31) RB1295.2 v1(163.22,187.11) ; v1(203.74,119.29) 203.7,119.33 C230.1 ; CB48.2 v1(88.51,196.29) ; C52.2 v1(82.9,212.08) ; v1(224.91,37.26) CB1106.1 224.04,36.42 v1(224.04,36.41) ; CB844.2 160.37,66.4 160.37,66.39 v1(160.24,66.39) ; 129.35,131.98 128.33,132.99 C1004.2 127.7,132.23 127.34,131.87 v1(124.91,131.87) ; R1467.1 v1(122.46,222.35) ; C107.1 v1(232.02,211.54) ; RB741.2 158.26,243.31 v1(158.21,243.37) ; C668.2 v1(49.42,72.64) ; RB25.2 v1(200.37,203.17) ; CB929.2 v1(260.79,36.52) ; CB1046.1 v1(195.43,212.05) ; R1069.1 234.56,136.4 v1(234.22,136.05) ; C893.1 v1(222.92,109.83) ; CB1025.1 v1(218.37,124.17) ; C865.2 v1(236.54,182.42) ; C888.2 v1(233.42,109.86) ; v1(172.43,238.22) 172.36,238.29 RB728.2 ; P1.W2 v4(113.29,210.46) ; C829.2 v1(146.97,66.79) ; v1(173.26,71.79) 173.64,71.41 174.53,71.41 174.69,71.57 C535.2 ; P1.N2 v4(107.29,210.46) ; P1.J2 v4(102.29,210.46) ; P1.G2 v4(100.29,210.46) ; CB870.2 121.7,65.12 v1(121.67,65.1) ; v1(61.15,190.88) C23.2 61.15,189.37 ; R1090.2 v1(175.97,224.76) ; C129.2 v1(231.75,207.68) ; v1(140.24,94.21) 140.03,94 C963.2 ; v1(241.55,79.39) 241.54,79.4 CB894.1 ; v1(215.65,108.28) 215.64,108.27 C472.2 ; v1(93.37,203.24) 93.12,203.49 R1453.2 ; C725.2 v1(265.33,62.65) ; v1(148.17,71.73) 148.56,71.35 149.26,71.35 C534.2 ; C927.2 143.73,166.58 v1(144.09,166.94) ; R1103.1 v1(187.66,212.94) ; CONN56.13 v1(239.72,257.19) ; v1(239.35,217.32) 238.98,216.95 C68.2 ; v1(221.83,107.86) 221.83,108.75 221.25,109.34 CB898.1 v1(220.85,107.95) ; C827.2 v1(145,72.64) ; CB707.2 v1(194.54,98.96) ; R71.1 v1(221.34,220.45) ; v1(54.19,67.28) 54.19,67.28 CB857.2 ; C22.2 v1(235.65,228.33) ; CB1218.2 42.62,206.14 arc(42.55,205.79) v1(42.35,205.5) ; C38.2 v1(264.7,249.15) ; P1.N10 v4(107.29,218.46) ; C969.2 v1(266.26,191.16) ; UB2.3 163.86,176.07 v1(164.01,175.92) ; CB893.1 238.73,79.41 v1(238.73,79.41) ; v1(241.52,121.38) 241.52,121.39 C321.2 ; C873.2 231.52,183.26 C872.2 v1(231.51,182.37) ; C804.2 v1(52.49,72.64) ; v1(81.52,216.09) 81.73,215.88 C37.2 ; v1(208.68,120.5) 208.31,120.13 CB322.1 ; v1(229.37,32.95) C958.1 v1(228.61,32.13) ; CB494.1 253.07,221.1 v1(253.01,221.04) ; v1(265.27,191.15) C968.2 ; C274.2 103.98,135.43 v1(104.54,135.43) ; C511.2 v1(241.17,103.44) ; CB1019.1 v1(221.86,128.62) ; v1(242.54,69.06) 242.83,69.36 U50.5 ; CB868.2 109.76,65.12 v1(109.22,65.66) ; LED33.C v1(189.7,238.24) ; P1.K5 v4(103.29,213.46) ; C735.2 v1(264.32,62.65) ; Q1.S v1(132.02,215.46) ; C2.2 v1(152.94,260.01) ; C420.2 v1(245.22,219.16) ; CB923.1 v1(242.46,151.66) ; C1002.2 v1(121.94,135.07) ; C886.2 v1(237.23,109.79) ; C919.1 v1(42.58,207.66) ; R1081.2 v1(175.97,219.68) ; C925.2 109.25,179.74 v1(109.31,179.8) ; C922.1 v1(109.25,178.72) ; C614.2 v1(146.02,72.64) ; RB1308.1 112.8,202.54 v1(113.44,203.17) R1459.1 ; v1(147.89,65.94) 148.35,66.4 CB842.2 ; P1.L8 v4(104.29,216.46) ; v1(111.41,177.77) 111.47,177.71 CB1221.2 ; v1(8.53,153.36) 9.08,153.92 OSC5.2 ; R108.2 v1(242.9,216.95) ; C628.2 v1(170.15,72.64) ; R514.1 141.37,207.1 v1(141.38,207.11) ; C884.1 v1(230.48,185.09) ; C593.2 v1(77.44,66.79) ; CB24.1 v1(57.81,222.03) ; CB896.2 v1(245.35,79.3) ; CB32.2 v1(91.19,188.65) ; v1(228.57,210.98) 228.61,210.98 228.8,211.17 R167.1 ; C592.2 v1(74.44,72.64) ; C144.2 11.78,168.31 12.09,167.99 12.09,167.29 v1(12.11,167.28) 11.87,167.04 C139.2 ; U87.5 223.17,41.98 222.88,41.68 v1(222.88,41.3) ; v1(36.83,186.75) 36.73,186.85 C293.2 36.12,187.19 v1(35.77,187.54) ; C811.2 v1(76.42,66.79) ; P1.L6 v4(104.29,214.46) ; v1(72.03,150.31) 72.92,151.21 C224.1 ; CB838.2 122.6,67.16 v1(122.42,67.35) ; v1(85.79,196.31) 85.72,196.24 CB43.2 ; v1(86.9,181.46) 86.88,181.48 CB9.2 ; CB46.2 v1(84.45,196.22) ; v1(245.2,156.56) 244.77,156.13 CB913.2 ; C993.2 v1(246.47,148.56) ; C598.2 v1(85.86,72.51) ; CB1036.1 173.25,172.95 v1(173.26,172.95) ; CB834.2 v1(78.31,66.39) ; v1(183.69,184.86) 183.82,184.99 R289.2 ; v1(201.39,140.05) 201.76,140.43 J2.G4 ; v1(185.34,189.25) 185.25,189.16 OSC3.2 ; P1.F13 v4(99.29,222.46) ; v1(5.81,135.61) 6.32,135.1 C277.2 ; P1.H5 v4(101.29,213.46) ; P1.L18 v4(105.29,227.46) ; R186.2 184.71,192.86 184.71,192.42 v1(185.07,192.06) ; P1.F11 v4(99.29,219.46) ; P1.B14 v4(95.29,223.46) ; v1(235.11,133.51) 235.1,133.52 C778.2 ; C647.2 v1(63.03,72.64) ; R1402.2 v1(141.6,171.59) ; RB26.2 v1(201.45,203.17) ; C309.2 v1(162.17,123.29) ; C464.2 214.59,101.96 v1(214.6,101.95) ; v1(16.35,153.69) 14.65,155.39 R434.2 ; CB980.1 98.01,235.15 v1(97.98,235.13) ; C1003.2 v1(124.94,132.99) ; CONN58.10 267.49,200.18 v1(267.73,200.43) ; v1(137.51,94.46) 137.04,93.99 C960.2 ; R495.1 v1(141.43,209.13) ; C117.1 229.99,210.99 230.27,210.71 230.27,210.68 v1(230.24,210.68) ; v1(100.19,203.24) 100.17,203.24 100.19,203.26 R1362.2 ; v1(109.52,67.44) 110.03,66.94 CB836.2 v1(109.12,66.39) ; CONN56.12 240.99,247.2 v1(241.01,247.18) ; v1(17.57,66.8) 17.56,66.79 C645.2 ; CB901.2 v1(207.88,74.67) ; CB1084.1 v1(235.6,155.85) ; C632.2 v1(184.82,72.64) ; v1(28.65,67.24) 29.11,66.78 CB852.2 ; C114.2 v1(179.98,193.63) ; C465.2 v1(214.58,102.97) ; v1(258.72,100.81) 258.73,100.81 C715.2 ; C342.2 v1(247.25,219.16) ; C345.2 v1(32.25,208.54) ; C836.2 v1(171.1,66.79) ; C850.2 v1(208.45,148.89) ; CB858.2 28.91,64.29 28.92,64.28 28.92,64.21 v1(28.9,64.19) ; C611.2 v1(144.94,66.79) ; C602.2 116.65,67.17 v1(116.65,67.22) ; R1486.2 226.82,45.51 v1(226.83,45.52) ; v1(238.47,155.29) 237.91,155.85 CB1086.1 ; C53.2 v1(239.42,219.55) ; v1(200.07,121.72) 200.79,121.72 R456.2 ; C553.2 v1(78.23,68.41) ; C260.2 v1(208.45,228.6) ; CONN57.10 v1(60.99,208.69) ; R1089.2 v1(179.25,236.71) ; v1(242.15,163.42) 242.34,163.23 C354.2 ; R1400.2 v1(141.47,167.71) ; R1382.2 v1(141.57,183.17) ; v1(9.06,159.43) 9.49,159.86 C176.2 9.5,160.63 C199.2 ; P1.P11 v4(108.29,219.46) ; C597.2 v1(86.89,72.51) ; C831.2 v1(157.58,72.64) ; C823.2 v1(140.22,72.56) ; v1(264.25,191.16) 264.26,191.15 C970.2 ; C801.2 v1(39.91,72.64) ; C201.1 141.18,227.95 141.19,227.94 v1(141.25,227.94) ; OSC6.2 v1(231.1,180.88) ; v1(141.32,233.91) 140.72,234.5 C195.1 ; P1.R1 v4(109.29,209.46) ; v1(208.11,111.29) C974.2 ; CB918.2 214.37,85.29 v1(214.72,84.94) ; C713.1 v1(247.33,100.94) ; R642.1 245.08,166.7 245.12,166.74 ; C83.2 v1(239.36,215.68) ; v1(5.97,214.37) SWB2.3 v1(7.4,216.19) ; R69.2 88.18,213.45 v1(88.42,213.21) ; C898.2 v1(259.93,88.87) ; C263.2 v1(98.59,146.12) ; v1(213.9,125.81) 214.04,125.67 CB1027.1 ; C667.2 v1(50.45,72.64) ; CB915.2 v1(247.49,153.77) ; C892.1 v1(225.73,109.86) ; R1408.2 88.61,217.4 v1(88.42,217.59) ; C512.2 239.43,96.3 v1(239.8,95.92) ; C915.2 v1(156.07,187.65) ; v1(164.12,180.45) 163.86,180.71 U5.3 ; CB1090.1 v1(247.53,96.73) ; v1(173.02,64.77) 173.37,65.12 CB878.2 ; v1(216.25,83.67) 216.19,83.61 CB920.2 ; v1(141.57,174.41) 141.7,174.28 R1403.2 ; SW1.3 v1(261.2,186.3) ; R169.1 v1(160.84,230.51) ; v1(124.74,208.51) 124.55,208.7 CB976.1 ; CONN56.18 237.18,247.2 v1(237.2,247.18) ; C9.2 v1(265.71,249.15) ; C996.2 v1(248.45,148.54) ; v1(205.15,85.27) CB917.2 206.8,85.56 205.96,86.4 v1(205.26,86.4) ; C264.2 245.41,168.1 245.4,168.09 ; C619.2 v1(159.61,72.64) ; C217.2 v1(15.81,258.32) ; CB733.1 v1(194.18,100.53) ; R1096.1 v1(185.63,212.94) ; CB840.2 130.71,66.27 v1(129.97,67.01) ; P1.K11 v4(103.29,219.46) ; CB47.2 v1(86.99,196.35) ; v1(172.94,111.48) 172.87,111.41 C402.1 ; v1(40.69,65.1) 40.72,65.06 CB860.2 ; v1(85.63,74.9) 85.63,75.54 86.07,75.98 C523.2 C524.2 ; v1(138.27,94.14) 138.03,93.91 C961.2 ; C473.2 209.99,108.27 v1(209.71,108.56) ; R1399.2 v1(141.47,168.98) ; C664.2 v1(38.9,72.64) ; C714.1 v1(244.54,100.91) ; C259.2 v1(15.76,255.35) ; P1.L2 v4(104.29,210.46) ; C238.1 200.1,122.76 v1(199.97,122.63) 199.97,123.09 200.66,123.78 C237.1 ; v1(240.25,210.12) 239.8,210.58 R1063.2 ; P1.H18 v4(101.29,227.46) ; P1.AA2 v4(115.29,210.46) ; C624.2 v1(169.07,66.79) ; CB30.1 v1(33.18,221.9) ; C964.2 v1(198.75,94.3) ; CONN56.23 v1(233.37,257) ; P1.F15 v4(99.29,224.46) ; CONN44.8 v1(211.29,92.05) ; C817.2 v1(88.92,72.51) ; P1.V11 v4(112.29,219.46) ; CONN57.2 v1(61.24,218.85) ; v1(83.22,207.43) 83.28,207.37 CB973.1 ; v1(141.72,241.04) R117.1 R111.1 ; v1(147.83,65.1) 147.86,65.13 CB874.2 ; C736.2 v1(267.36,62.65) ; P1.P18 v4(108.29,227.46) ; C808.2 v1(64.04,72.64) ; C167.1 v1(129.06,218.48) ; C966.2 v1(201.74,94.3) 202.14,94.7 C441.2 ; C623.2 v1(170.09,66.79) ; P1.H11 v4(101.29,219.46) ; P1.F3 v4(99.29,211.46) ; P1.V8 v4(112.29,216.46) ; v1(259.92,230.72) CONN28.10 v1(257.44,229.09) ; C466.2 v1(214.58,103.99) ; P1.G1 v4(100.29,209.46) ; CB1002.2 v1(218.35,131.54) ; CB29.2 v1(168.73,171.53) ; 255.12,159.64 C312.2 ; v1(78.35,186.51) 78.46,186.62 RB7.1 ; C189.1 v1(213.88,126.83) ; C997.2 v1(206.59,147.7) ; P1.N4 v4(107.29,212.46) ; v1(160.3,68.41) CB818.2 161.02,67.72 v1(161.08,67.66) ; C981.2 v1(130.16,235.98) ; v1(251.18,102.51) 251.13,102.46 C712.1 ; C626.2 v1(180.56,66.39) ; C220.2 v1(208.4,226.56) ; C157.1 v1(87.21,234.29) 87.28,234.22 R300.2 ; P1.P9 v4(108.29,217.46) ; P1.L1 v4(104.29,209.46) ; C995.2 v1(245.46,148.54) ; CONN56.29 v1(229.56,257.08) ; QB7.S 127.18,203.85 v1(127.35,203.68) ; v1(228.12,184.76) 227.58,184.22 C880.1 ; R1087.1 v1(191.73,212.94) ; P1.P16 v4(108.29,225.46) ; CB909.2 v1(203.1,75.35) ; C991.1 v1(221.21,40.62) ; v1(221.29,222.65) 221.3,222.64 R52.1 ; v1(7.4,209.33) SWB2.4 v1(6.36,210.62) ; R56.1 v1(239.4,223.14) ; v1(162.39,183.17) 162.41,183.17 162.41,183.19 162.31,183.19 162.14,183.36 R1421.2 R1416.2 ; CB1085.1 v1(247.58,97.79) ; C219.2 208.43,227.57 v1(208.41,227.55) ; RB1.2 v1(139.09,233.21) ; v1(201.21,126.61) 200.99,126.83 C244.2 ; C648.2 v1(62,72.64) ; v1(223.42,135.1) 223.44,135.12 C776.1 ; R953.1 v1(239.95,116.17) ; v1(78.35,190.07) 78.37,190.05 RB40.1 ; C812.2 v1(76.49,72.64) ; v1(130.58,67.57) 130.48,67.67 C559.2 ; CB995.2 v1(218.38,113.73) ; C976.2 131.26,117.8 131.29,117.83 ; v1(253.33,165.02) 252.79,164.49 U34.4 251.06,164.49 v1(250.72,164.83) ; C516.2 v1(172.62,205.33) ; C917.2 v1(147.02,189.76) ; C885.2 v1(234.41,109.9) ; R1452.1 v1(122.52,230.54) ; CB856.2 v1(60.84,66.39) ; v1(88.83,186.32) 89.29,185.86 CB25.2 90.56,185.86 v1(90.61,185.81) 90.65,185.86 CB26.2 91.51,185.86 92.13,185.24 v1(92.19,185.24) ; C247.2 v1(15.76,256.34) ; C55.1 v1(167.39,176.97) ; v1(224.55,242.57) 224.55,242.56 224.3,242.31 R337.2 ; J5.3 v1(220.07,259.91) ; C100.2 v1(179.87,195.28) ; R1117.1 v1(183.61,212.91) ; CB895.1 242.54,79.46 v1(242.53,79.44) ; C711.1 v1(248.32,100.91) ; C486.2 v1(172.62,207.36) ; C153.1 v1(201.26,239.24) ; v1(240.63,98.08) 239.93,98.08 239.47,97.62 C509.1 239.47,97.27 v1(240.12,96.62) ; C202.2 105.88,157.01 ; C975.2 v1(208.37,114.4) ; CB864.2 66.63,64.24 v1(66.5,64.12) ; R428.2 v1(206.69,133.62) ; CB1105.1 v1(228.44,36.42) ; C250.2 v1(98.59,148.79) ; v1(18.56,72.51) 18.56,72.51 C643.2 ; R1396.2 v1(141.51,176.5) ; C470.2 v1(202.12,99.76) ; R96.1 v1(155.14,243.32) ; P1.R12 v4(109.29,221.46) ; C3.2 v1(153,257.98) ; C860.2 v1(263.68,88.87) ; C775.2 v1(228.12,139.1) ; C99.2 239.04,214.41 239.04,214.41 v1(239.36,214.41) ; C240.1 v1(201.48,133.29) ; C663.2 v1(36.86,72.64) ; v1(266.79,105.13) R800.2 v1(268.06,106.14) ; C613.2 v1(147.04,72.64) ; CB928.2 v1(256.94,36.47) ; CB10.1 v1(90.77,183.63) ; v3(228.99,142.64) 228.89,142.74 RB186.1 ; CB27.1 167.55,172.06 v1(167.39,171.9) ; C965.2 v1(199.74,94.33) 200.11,94.69 C433.2 ; CB916.2 v1(247.49,149.45) ; C514.2 v1(240.88,99.36) ; v1(130.03,64.28) 130.54,64.79 CB872.2 ; CB1049.2 v1(193.97,212.05) ; CB912.2 v1(243.6,153.31) ; v1(218.37,112.28) 218.38,112.27 CB892.1 ; C42.1 v1(89.8,205.98) ; CB832.2 65.8,66.4 v1(65.8,66.39) ; C594.2 v1(75.41,66.79) ; C8.2 v1(152.99,261.03) ; R1113.1 v1(175.97,231.87) ; C834.2 v1(172.12,66.79) ; C304.2 v1(263.27,90.43) ; C739.1 v1(241.83,77.01) ; C982.2 v1(131.16,235.99) ; C44.1 v1(62.7,222.03) ; CB906.2 v1(209.01,75.42) ; C810.2 v1(74.38,66.79) ; P1.R6 v4(109.29,214.46) ; C508.1 v1(240.98,101.41) ; P1.K9 v4(103.29,217.46) ; P1.B8 v4(95.29,216.46) ; CB1188.2 v1(141.33,186.43) ; v1(139.28,94.21) 139.03,93.95 C962.2 ; R1505.2 103.3,203.92 R1506.2 104.31,203.79 v1(104.85,203.25) ; C280.2 v1(247.17,197.46) ; C109.2 233.93,210.96 v1(233.93,210.96) ; v1(168.98,113.74) 169.04,113.8 C376.2 ; UB71.3 v1(240.42,160.33) ; R1347.2 v1(95.15,205.52) ; C137.2 v1(204.37,234.54) ; CONN56.30 v1(229.56,246.48) ; P1.J1 v4(102.29,209.46) ; C724.2 v1(266.35,62.65) ; C926.2 v1(42.48,208.67) ; C401.1 157.12,111.41 ; P1.M5 v4(106.29,213.46) ; C813.2 v1(77.5,72.64) ; CB904.2 200.75,74.9 v1(201.01,74.65) CB900.2 ; C131.1 v1(204.37,233.53) ; CONN56.11 v1(240.99,257.06) ; R1394.2 v1(141.57,173.07) ; C528.2 v1(241.38,91.6) ; C4.2 v1(266.73,249.15) ; C830.2 v1(156.56,72.64) ; R1101.1 v1(186.65,212.94) ; C822.2 v1(139.21,72.56) ; C660.2 v1(141.24,72.56) ; R195.2 237.81,210.93 v1(237.87,210.99) 237.49,211.37 C118.2 ; CB848.2 v1(185.64,66.39) ; R1085.1 v1(189.7,212.94) ; CB975.2 v1(158.26,238.78) ; CB815.2 v1(136.96,67.48) ; C1001.2 v1(121.96,136.12) ; R1125.1 v1(173.02,221.21) ; CB42.2 v1(83.18,195.14) ; CB1088.1 v1(233.39,160.37) ; P1.L12 v4(104.29,221.46) ; C979.2 134.28,117.73 134.28,117.73 ; C343.2 v1(248.27,219.13) ; v1(172.49,239.24) 172.37,239.37 RB739.2 ; P1.U10 v4(111.29,218.46) ; CB911.2 v1(216.63,78.65) ; C971.2 v1(263.27,191.21) ; C27.2 4.26,190.45 v1(4.28,190.47) ; C777.2 v1(236.12,133.64) ; P1.K15 v4(103.29,224.46) ; R1118.2 v1(175.97,230.86) ; R1419.2 v1(155.03,187.55) ; C590.2 v1(73.35,66.39) ; C630.2 v1(181.77,72.64) ; C923.1 v1(109.25,177.71) ; R449.1 v1(199.88,130.29) ; P1.AA11 v4(115.29,219.46) ; C421.2 v1(246.24,219.16) ; v1(155.42,66.39) C616.2 ; R443.1 v1(203.64,133.67) ; C835.2 v1(171.17,72.64) ; P1.B2 v4(95.29,210.46) ; C807.2 v1(63.98,66.79) ; CONN41.6 v1(35.57,255.49) ; C890.1 v1(229.61,109.85) ; RB1267.2 v1(141.57,214.48) ; v1(167.33,64.4) 167.29,64.44 C684.2 ; R324.2 v1(127.85,215.81) ; R613.1 v1(103.8,123.04) ; C650.2 v1(62.96,66.79) ; C918.2 v1(144.36,189.77) ; C49.2 v1(80.03,216.08) ; R185.1 v1(159.83,230.51) ; P1.R2 v4(109.29,210.46) ; C307.1 98.9,126.59 ; C469.2 v1(202.12,100.78) ; R1364.2 v1(107.34,203.11) ; R1395.2 v1(141.51,175.3) ; C174.1 v1(129.12,211.49) ; P1.N1 v4(107.29,209.46) ; C108.2 v1(163.23,219.29) ; CB812.2 v1(128.82,67.6) ; RB27.2 v1(202.53,203.11) ; C800.2 v1(37.88,72.64) ; C115.1 v1(124.64,203.59) ; C521.2 v1(172.69,204.32) ; C612.2 v1(143.93,66.79) ; R1083.1 v1(188.68,212.94) ; C48.2 v1(80.04,212.36)
  TOP w0.635: CB1000.1 220.81,135.03 221.17,135.39 v1(221.93,135.39) ; v1(241.33,133.45) 241.31,133.43 CB1011.1 ; C773.1 v1(229.56,133.93) ; CB1014.2 v1(240.97,131.99)
  G2 w0.254: v3(19.57,50.12) v3(19.57,51.39) ; v3(17.17,50.12) v3(17.17,51.39)
  G2 w0.508: 28.97,232.1 CONN6.23 ; CONN6.23 27.64,233.44 ; CONN6.23 28.97,234.77 ; CONN6.23 30.31,233.44 ; CONN6.8 42.91,227.94 ; CONN6.8 41.57,226.6 ; CONN6.8 41.57,229.27 ; CONN6.8 40.24,227.94 ; 28.97,226.6 CONN6.11 ; CONN6.11 28.97,229.27 ; CONN6.11 30.31,227.94 ; CONN6.11 27.64,227.94 ; 41.57,232.1 CONN6.20 ; CONN6.20 41.57,234.77 ; CONN6.20 42.91,233.44 ; CONN6.20 40.24,233.44 ; 23.44,227.94 CONN6.12 ; CONN6.12 26.11,227.94 ; CONN6.12 24.77,229.27 ; CONN6.12 24.77,226.6 ; 243.22,16.88 RJ1.C4 ; RJ1.C4 244.84,16.88 ; RJ1.C4 244.03,16.07 ; RJ1.C4 244.03,17.69 ; RJ1.C5 245.3,15.15 ; RJ1.C5 244.49,14.34 ; RJ1.C5 245.3,13.53 ; RJ1.C5 246.11,14.34 ; CONN6.2 66.77,229.27 ; CONN6.2 68.11,227.94 ; CONN6.2 66.77,226.6 ; CONN6.2 65.44,227.94 ; 54.17,232.1 CONN6.17 ; CONN6.17 55.51,233.44 ; CONN6.17 52.84,233.44 ; CONN6.17 54.17,234.77 ; 258,22.67 RJ1.F5 ; RJ1.F5 257.19,23.48 ; RJ1.F5 258,24.29 ; RJ1.F5 258.81,23.48 ; CONN6.14 66.77,234.77 ; CONN6.14 66.77,232.1 ; CONN6.14 68.11,233.44 ; CONN6.14 65.44,233.44 ; 259.27,20.13 RJ1.F4 ; RJ1.F4 259.27,21.75 ; RJ1.F4 260.08,20.94 ; RJ1.F4 258.46,20.94 ; 226.98,252.07 CONN56.G2 ; CONN56.G2 228.01,251.04 ; CONN56.G2 228.01,253.1 ; CONN56.G2 229.04,252.07 ; 24.77,232.1 CONN6.24 ; CONN6.24 23.44,233.44 ; CONN6.24 24.77,234.77 ; CONN6.24 26.11,233.44 ; 248.89,251.04 CONN56.G1 ; CONN56.G1 247.86,252.07 ; CONN56.G1 249.92,252.07 ; CONN56.G1 248.89,253.1 ; CONN6.5 54.17,229.27 ; CONN6.5 54.17,226.6 ; CONN6.5 55.51,227.94 ; CONN6.5 52.84,227.94
  G4 w0.508: CONN6.23 30.31,233.44 ; CONN6.23 28.97,234.77 ; CONN6.23 28.97,232.1 ; CONN6.23 27.64,233.44 ; CONN6.20 42.91,233.44 ; CONN6.20 41.57,234.77 ; CONN6.20 41.57,232.1 ; CONN6.20 40.24,233.44 ; 245.3,13.53 RJ1.C5 ; RJ1.C5 244.49,14.34 ; RJ1.C5 245.3,15.15 ; RJ1.C5 246.11,14.34 ; RJ1.F4 260.08,20.94 ; RJ1.F4 258.46,20.94 ; RJ1.F4 259.27,20.13 ; RJ1.F4 259.27,21.75 ; 28.97,226.6 CONN6.11 ; CONN6.11 27.64,227.94 ; CONN6.11 28.97,229.27 ; CONN6.11 30.31,227.94 ; 23.44,233.44 CONN6.24 ; CONN6.24 26.11,233.44 ; CONN6.24 24.77,234.77 ; CONN6.24 24.77,232.1 ; 52.84,227.94 CONN6.5 ; CONN6.5 55.51,227.94 ; CONN6.5 54.17,229.27 ; CONN6.5 54.17,226.6 ; 40.24,227.94 CONN6.8 ; CONN6.8 41.57,229.27 ; CONN6.8 41.57,226.6 ; CONN6.8 42.91,227.94 ; CONN56.G1 248.89,253.1 ; CONN56.G1 249.92,252.07 ; CONN56.G1 248.89,251.04 ; CONN56.G1 247.86,252.07 ; 243.22,16.88 RJ1.C4 ; RJ1.C4 244.84,16.88 ; RJ1.C4 244.03,17.69 ; RJ1.C4 244.03,16.07 ; CONN6.2 66.77,229.27 ; CONN6.2 65.44,227.94 ; CONN6.2 68.11,227.94 ; CONN6.2 66.77,226.6 ; 54.17,232.1 CONN6.17 ; CONN6.17 52.84,233.44 ; CONN6.17 55.51,233.44 ; CONN6.17 54.17,234.77 ; RJ1.F5 258.81,23.48 ; RJ1.F5 258,24.29 ; RJ1.F5 258,22.67 ; RJ1.F5 257.19,23.48 ; 228.01,251.04 CONN56.G2 ; CONN56.G2 226.98,252.07 ; CONN56.G2 228.01,253.1 ; CONN56.G2 229.04,252.07 ; CONN6.14 68.11,233.44 ; CONN6.14 65.44,233.44 ; CONN6.14 66.77,232.1 ; CONN6.14 66.77,234.77 ; CONN6.12 26.11,227.94 ; CONN6.12 24.77,229.27 ; CONN6.12 23.44,227.94 ; CONN6.12 24.77,226.6
  G6 w0.508: CONN6.24 24.77,234.77 ; CONN6.24 24.77,232.1 ; CONN6.24 26.11,233.44 ; CONN6.24 23.44,233.44 ; CONN6.11 30.31,227.94 ; CONN6.11 28.97,229.27 ; CONN6.11 27.64,227.94 ; CONN6.11 28.97,226.6 ; CONN6.23 28.97,234.77 ; CONN6.23 30.31,233.44 ; CONN6.23 28.97,232.1 ; CONN6.23 27.64,233.44 ; 52.84,233.44 CONN6.17 ; CONN6.17 54.17,234.77 ; CONN6.17 55.51,233.44 ; CONN6.17 54.17,232.1 ; CONN6.12 24.77,229.27 ; CONN6.12 26.11,227.94 ; CONN6.12 23.44,227.94 ; CONN6.12 24.77,226.6 ; CONN56.G2 228.01,253.1 ; CONN56.G2 229.04,252.07 ; CONN56.G2 228.01,251.04 ; CONN56.G2 226.98,252.07 ; 257.19,23.48 RJ1.F5 ; RJ1.F5 258,24.29 ; RJ1.F5 258,22.67 ; RJ1.F5 258.81,23.48 ; RJ1.C4 244.03,17.69 ; RJ1.C4 244.03,16.07 ; RJ1.C4 244.84,16.88 ; RJ1.C4 243.22,16.88 ; 248.89,251.04 CONN56.G1 ; CONN56.G1 248.89,253.1 ; CONN56.G1 247.86,252.07 ; CONN56.G1 249.92,252.07 ; CONN6.2 68.11,227.94 ; CONN6.2 66.77,226.6 ; CONN6.2 65.44,227.94 ; CONN6.2 66.77,229.27 ; 52.84,227.94 CONN6.5 ; CONN6.5 54.17,229.27 ; CONN6.5 55.51,227.94 ; CONN6.5 54.17,226.6 ; CONN6.14 68.11,233.44 ; CONN6.14 66.77,234.77 ; CONN6.14 65.44,233.44 ; CONN6.14 66.77,232.1 ; CONN6.8 42.91,227.94 ; CONN6.8 40.24,227.94 ; CONN6.8 41.57,226.6 ; CONN6.8 41.57,229.27 ; 259.27,20.13 RJ1.F4 ; RJ1.F4 259.27,21.75 ; RJ1.F4 260.08,20.94 ; RJ1.F4 258.46,20.94 ; 41.57,232.1 CONN6.20 ; CONN6.20 41.57,234.77 ; CONN6.20 42.91,233.44 ; CONN6.20 40.24,233.44 ; RJ1.C5 245.3,15.15 ; RJ1.C5 246.11,14.34 ; RJ1.C5 244.49,14.34 ; RJ1.C5 245.3,13.53
  G8 w0.508: CONN6.17 54.17,234.77 ; CONN6.17 54.17,232.1 ; CONN6.17 55.51,233.44 ; CONN6.17 52.84,233.44 ; 65.44,233.44 CONN6.14 ; CONN6.14 66.77,234.77 ; CONN6.14 66.77,232.1 ; CONN6.14 68.11,233.44 ; CONN6.23 30.31,233.44 ; CONN6.23 28.97,232.1 ; CONN6.23 27.64,233.44 ; CONN6.23 28.97,234.77 ; 54.17,226.6 CONN6.5 ; CONN6.5 54.17,229.27 ; CONN6.5 55.51,227.94 ; CONN6.5 52.84,227.94 ; CONN6.2 68.11,227.94 ; CONN6.2 66.77,229.27 ; CONN6.2 65.44,227.94 ; CONN6.2 66.77,226.6 ; 257.19,23.48 RJ1.F5 ; RJ1.F5 258,22.67 ; RJ1.F5 258.81,23.48 ; RJ1.F5 258,24.29 ; 24.77,232.1 CONN6.24 ; CONN6.24 24.77,234.77 ; CONN6.24 23.44,233.44 ; CONN6.24 26.11,233.44 ; 40.24,227.94 CONN6.8 ; CONN6.8 41.57,229.27 ; CONN6.8 41.57,226.6 ; CONN6.8 42.91,227.94 ; RJ1.F4 260.08,20.94 ; RJ1.F4 258.46,20.94 ; RJ1.F4 259.27,21.75 ; RJ1.F4 259.27,20.13 ; 28.97,226.6 CONN6.11 ; CONN6.11 30.31,227.94 ; CONN6.11 28.97,229.27 ; CONN6.11 27.64,227.94 ; 24.77,226.6 CONN6.12 ; CONN6.12 23.44,227.94 ; CONN6.12 26.11,227.94 ; CONN6.12 24.77,229.27 ; 228.01,251.04 CONN56.G2 ; CONN56.G2 229.04,252.07 ; CONN56.G2 226.98,252.07 ; CONN56.G2 228.01,253.1 ; CONN6.20 41.57,234.77 ; CONN6.20 40.24,233.44 ; CONN6.20 41.57,232.1 ; CONN6.20 42.91,233.44 ; RJ1.C4 244.03,17.69 ; RJ1.C4 243.22,16.88 ; RJ1.C4 244.84,16.88 ; RJ1.C4 244.03,16.07 ; 245.3,13.53 RJ1.C5 ; RJ1.C5 245.3,15.15 ; RJ1.C5 244.49,14.34 ; RJ1.C5 246.11,14.34 ; 247.86,252.07 CONN56.G1 ; CONN56.G1 248.89,251.04 ; CONN56.G1 248.89,253.1 ; CONN56.G1 249.92,252.07
  S9 w0.254: v1(84.29,111.48) 84.67,111.86 85.39,111.86 95.04,121.51 102.28,121.51 v1(103.8,123.04)
  G10 w0.508: RJ1.C5 245.3,15.15 ; RJ1.C5 245.3,13.53 ; RJ1.C5 244.49,14.34 ; RJ1.C5 246.11,14.34 ; RJ1.C4 244.84,16.88 ; RJ1.C4 243.22,16.88 ; RJ1.C4 244.03,17.69 ; RJ1.C4 244.03,16.07 ; 54.17,232.1 CONN6.17 ; CONN6.17 54.17,234.77 ; CONN6.17 55.51,233.44 ; CONN6.17 52.84,233.44 ; CONN56.G2 228.01,253.1 ; CONN56.G2 229.04,252.07 ; CONN56.G2 228.01,251.04 ; CONN56.G2 226.98,252.07 ; 40.24,227.94 CONN6.8 ; CONN6.8 41.57,226.6 ; CONN6.8 41.57,229.27 ; CONN6.8 42.91,227.94 ; 258,22.67 RJ1.F5 ; RJ1.F5 257.19,23.48 ; RJ1.F5 258.81,23.48 ; RJ1.F5 258,24.29 ; 65.44,233.44 CONN6.14 ; CONN6.14 68.11,233.44 ; CONN6.14 66.77,232.1 ; CONN6.14 66.77,234.77 ; 65.44,227.94 CONN6.2 ; CONN6.2 66.77,226.6 ; CONN6.2 66.77,229.27 ; CONN6.2 68.11,227.94 ; 28.97,226.6 CONN6.11 ; CONN6.11 28.97,229.27 ; CONN6.11 30.31,227.94 ; CONN6.11 27.64,227.94 ; CONN6.12 24.77,229.27 ; CONN6.12 24.77,226.6 ; CONN6.12 26.11,227.94 ; CONN6.12 23.44,227.94 ; CONN6.24 24.77,234.77 ; CONN6.24 26.11,233.44 ; CONN6.24 23.44,233.44 ; CONN6.24 24.77,232.1 ; CONN6.23 28.97,234.77 ; CONN6.23 28.97,232.1 ; CONN6.23 30.31,233.44 ; CONN6.23 27.64,233.44 ; CONN6.20 41.57,234.77 ; CONN6.20 42.91,233.44 ; CONN6.20 41.57,232.1 ; CONN6.20 40.24,233.44 ; 54.17,226.6 CONN6.5 ; CONN6.5 55.51,227.94 ; CONN6.5 52.84,227.94 ; CONN6.5 54.17,229.27 ; CONN56.G1 249.92,252.07 ; CONN56.G1 248.89,251.04 ; CONN56.G1 248.89,253.1 ; CONN56.G1 247.86,252.07 ; RJ1.F4 259.27,21.75 ; RJ1.F4 259.27,20.13 ; RJ1.F4 260.08,20.94 ; RJ1.F4 258.46,20.94
  G11 w0.508: 259.27,20.13 RJ1.F4 ; RJ1.F4 259.27,21.75 ; RJ1.F4 260.08,20.94 ; RJ1.F4 258.46,20.94 ; CONN6.12 26.11,227.94 ; CONN6.12 23.44,227.94 ; CONN6.12 24.77,229.27 ; CONN6.12 24.77,226.6 ; 54.17,226.6 CONN6.5 ; CONN6.5 54.17,229.27 ; CONN6.5 55.51,227.94 ; CONN6.5 52.84,227.94 ; 258,22.67 RJ1.F5 ; RJ1.F5 258,24.29 ; RJ1.F5 257.19,23.48 ; RJ1.F5 258.81,23.48 ; 28.97,226.6 CONN6.11 ; CONN6.11 27.64,227.94 ; CONN6.11 28.97,229.27 ; CONN6.11 30.31,227.94 ; CONN6.14 66.77,234.77 ; CONN6.14 66.77,232.1 ; CONN6.14 65.44,233.44 ; CONN6.14 68.11,233.44 ; 244.49,14.34 RJ1.C5 ; RJ1.C5 245.3,13.53 ; RJ1.C5 246.11,14.34 ; RJ1.C5 245.3,15.15 ; CONN6.23 28.97,234.77 ; CONN6.23 27.64,233.44 ; CONN6.23 28.97,232.1 ; CONN6.23 30.31,233.44 ; CONN6.17 54.17,234.77 ; CONN6.17 55.51,233.44 ; CONN6.17 52.84,233.44 ; CONN6.17 54.17,232.1 ; CONN6.8 42.91,227.94 ; CONN6.8 40.24,227.94 ; CONN6.8 41.57,226.6 ; CONN6.8 41.57,229.27 ; 228.01,251.04 CONN56.G2 ; CONN56.G2 226.98,252.07 ; CONN56.G2 228.01,253.1 ; CONN56.G2 229.04,252.07 ; CONN6.24 24.77,234.77 ; CONN6.24 26.11,233.44 ; CONN6.24 24.77,232.1 ; CONN6.24 23.44,233.44 ; CONN56.G1 249.92,252.07 ; CONN56.G1 247.86,252.07 ; CONN56.G1 248.89,251.04 ; CONN56.G1 248.89,253.1 ; CONN6.20 41.57,234.77 ; CONN6.20 40.24,233.44 ; CONN6.20 41.57,232.1 ; CONN6.20 42.91,233.44 ; CONN6.2 68.11,227.94 ; CONN6.2 65.44,227.94 ; CONN6.2 66.77,226.6 ; CONN6.2 66.77,229.27 ; 244.03,16.07 RJ1.C4 ; RJ1.C4 244.84,16.88 ; RJ1.C4 244.03,17.69 ; RJ1.C4 243.22,16.88
  G13 w0.508: 41.57,226.6 CONN6.8 ; CONN6.8 40.24,227.94 ; CONN6.8 42.91,227.94 ; CONN6.8 41.57,229.27 ; CONN6.17 55.51,233.44 ; CONN6.17 54.17,234.77 ; CONN6.17 52.84,233.44 ; CONN6.17 54.17,232.1 ; CONN6.23 30.31,233.44 ; CONN6.23 28.97,232.1 ; CONN6.23 28.97,234.77 ; CONN6.23 27.64,233.44 ; RJ1.F5 258,24.29 ; RJ1.F5 258,22.67 ; RJ1.F5 257.19,23.48 ; RJ1.F5 258.81,23.48 ; CONN56.G2 229.04,252.07 ; CONN56.G2 226.98,252.07 ; CONN56.G2 228.01,253.1 ; CONN56.G2 228.01,251.04 ; 244.03,16.07 RJ1.C4 ; RJ1.C4 244.03,17.69 ; RJ1.C4 243.22,16.88 ; RJ1.C4 244.84,16.88 ; CONN6.11 30.31,227.94 ; CONN6.11 27.64,227.94 ; CONN6.11 28.97,226.6 ; CONN6.11 28.97,229.27 ; 244.49,14.34 RJ1.C5 ; RJ1.C5 246.11,14.34 ; RJ1.C5 245.3,13.53 ; RJ1.C5 245.3,15.15 ; CONN56.G1 249.92,252.07 ; CONN56.G1 248.89,251.04 ; CONN56.G1 247.86,252.07 ; CONN56.G1 248.89,253.1 ; CONN6.24 24.77,234.77 ; CONN6.24 26.11,233.44 ; CONN6.24 24.77,232.1 ; CONN6.24 23.44,233.44 ; CONN6.2 66.77,229.27 ; CONN6.2 66.77,226.6 ; CONN6.2 65.44,227.94 ; CONN6.2 68.11,227.94 ; 65.44,233.44 CONN6.14 ; CONN6.14 66.77,234.77 ; CONN6.14 68.11,233.44 ; CONN6.14 66.77,232.1 ; CONN6.5 54.17,229.27 ; CONN6.5 54.17,226.6 ; CONN6.5 55.51,227.94 ; CONN6.5 52.84,227.94 ; CONN6.12 26.11,227.94 ; CONN6.12 23.44,227.94 ; CONN6.12 24.77,229.27 ; CONN6.12 24.77,226.6 ; CONN6.20 42.91,233.44 ; CONN6.20 41.57,232.1 ; CONN6.20 40.24,233.44 ; CONN6.20 41.57,234.77 ; 259.27,20.13 RJ1.F4 ; RJ1.F4 260.08,20.94 ; RJ1.F4 259.27,21.75 ; RJ1.F4 258.46,20.94
  S14 w0.203: v1(97.3,137.78) 89.34,137.78 87.17,139.95 82.38,139.95 74.88,132.45
  S14 w0.254: v1(65.12,117.26) 67.54,119.68 67.54,126.23 73.76,132.45 74.88,132.45
  G15 w0.508: CONN6.2 66.77,229.27 ; CONN6.2 66.77,226.6 ; CONN6.2 65.44,227.94 ; CONN6.2 68.11,227.94 ; 245.3,13.53 RJ1.C5 ; RJ1.C5 245.3,15.15 ; RJ1.C5 246.11,14.34 ; RJ1.C5 244.49,14.34 ; CONN6.12 26.11,227.94 ; CONN6.12 24.77,226.6 ; CONN6.12 23.44,227.94 ; CONN6.12 24.77,229.27 ; RJ1.C4 244.84,16.88 ; RJ1.C4 243.22,16.88 ; RJ1.C4 244.03,16.07 ; RJ1.C4 244.03,17.69 ; 248.89,251.04 CONN56.G1 ; CONN56.G1 247.86,252.07 ; CONN56.G1 249.92,252.07 ; CONN56.G1 248.89,253.1 ; CONN6.17 54.17,234.77 ; CONN6.17 55.51,233.44 ; CONN6.17 54.17,232.1 ; CONN6.17 52.84,233.44 ; 258,22.67 RJ1.F5 ; RJ1.F5 257.19,23.48 ; RJ1.F5 258.81,23.48 ; RJ1.F5 258,24.29 ; 54.17,226.6 CONN6.5 ; CONN6.5 52.84,227.94 ; CONN6.5 55.51,227.94 ; CONN6.5 54.17,229.27 ; CONN56.G2 228.01,253.1 ; CONN56.G2 226.98,252.07 ; CONN56.G2 228.01,251.04 ; CONN56.G2 229.04,252.07 ; 27.64,233.44 CONN6.23 ; CONN6.23 28.97,232.1 ; CONN6.23 28.97,234.77 ; CONN6.23 30.31,233.44 ; CONN6.8 41.57,229.27 ; CONN6.8 42.91,227.94 ; CONN6.8 40.24,227.94 ; CONN6.8 41.57,226.6 ; CONN6.24 24.77,234.77 ; CONN6.24 24.77,232.1 ; CONN6.24 26.11,233.44 ; CONN6.24 23.44,233.44 ; 40.24,233.44 CONN6.20 ; CONN6.20 42.91,233.44 ; CONN6.20 41.57,232.1 ; CONN6.20 41.57,234.77 ; CONN6.14 68.11,233.44 ; CONN6.14 66.77,232.1 ; CONN6.14 66.77,234.77 ; CONN6.14 65.44,233.44 ; RJ1.F4 259.27,21.75 ; RJ1.F4 260.08,20.94 ; RJ1.F4 258.46,20.94 ; RJ1.F4 259.27,20.13 ; 28.97,226.6 CONN6.11 ; CONN6.11 28.97,229.27 ; CONN6.11 30.31,227.94 ; CONN6.11 27.64,227.94
  G17 w0.508: 66.77,232.1 CONN6.14 ; CONN6.14 66.77,234.77 ; CONN6.14 65.44,233.44 ; CONN6.14 68.11,233.44 ; 258.46,20.94 RJ1.F4 ; RJ1.F4 259.27,20.13 ; RJ1.F4 259.27,21.75 ; RJ1.F4 260.08,20.94 ; CONN56.G2 229.04,252.07 ; CONN56.G2 228.01,253.1 ; CONN56.G2 226.98,252.07 ; CONN56.G2 228.01,251.04 ; RJ1.F5 258.81,23.48 ; RJ1.F5 258,22.67 ; RJ1.F5 258,24.29 ; RJ1.F5 257.19,23.48 ; 41.57,232.1 CONN6.20 ; CONN6.20 42.91,233.44 ; CONN6.20 40.24,233.44 ; CONN6.20 41.57,234.77 ; 54.17,232.1 CONN6.17 ; CONN6.17 52.84,233.44 ; CONN6.17 55.51,233.44 ; CONN6.17 54.17,234.77 ; CONN6.11 30.31,227.94 ; CONN6.11 28.97,229.27 ; CONN6.11 27.64,227.94 ; CONN6.11 28.97,226.6 ; CONN6.8 42.91,227.94 ; CONN6.8 41.57,226.6 ; CONN6.8 41.57,229.27 ; CONN6.8 40.24,227.94 ; 245.3,13.53 RJ1.C5 ; RJ1.C5 246.11,14.34 ; RJ1.C5 245.3,15.15 ; RJ1.C5 244.49,14.34 ; 23.44,233.44 CONN6.24 ; CONN6.24 24.77,232.1 ; CONN6.24 24.77,234.77 ; CONN6.24 26.11,233.44 ; 23.44,227.94 CONN6.12 ; CONN6.12 24.77,229.27 ; CONN6.12 24.77,226.6 ; CONN6.12 26.11,227.94 ; 28.97,232.1 CONN6.23 ; CONN6.23 28.97,234.77 ; CONN6.23 30.31,233.44 ; CONN6.23 27.64,233.44 ; CONN6.5 55.51,227.94 ; CONN6.5 52.84,227.94 ; CONN6.5 54.17,226.6 ; CONN6.5 54.17,229.27 ; RJ1.C4 244.84,16.88 ; RJ1.C4 244.03,17.69 ; RJ1.C4 244.03,16.07 ; RJ1.C4 243.22,16.88 ; CONN56.G1 248.89,253.1 ; CONN56.G1 248.89,251.04 ; CONN56.G1 247.86,252.07 ; CONN56.G1 249.92,252.07 ; CONN6.2 66.77,229.27 ; CONN6.2 66.77,226.6 ; CONN6.2 65.44,227.94 ; CONN6.2 68.11,227.94
  G19 w0.508: CONN56.G1 249.92,252.07 ; CONN56.G1 248.89,251.04 ; CONN56.G1 248.89,253.1 ; CONN56.G1 247.86,252.07 ; CONN6.14 68.11,233.44 ; CONN6.14 65.44,233.44 ; CONN6.14 66.77,234.77 ; CONN6.14 66.77,232.1 ; CONN56.G2 229.04,252.07 ; CONN56.G2 226.98,252.07 ; CONN56.G2 228.01,251.04 ; CONN56.G2 228.01,253.1 ; 244.03,16.07 RJ1.C4 ; RJ1.C4 243.22,16.88 ; RJ1.C4 244.84,16.88 ; RJ1.C4 244.03,17.69 ; 41.57,226.6 CONN6.8 ; CONN6.8 41.57,229.27 ; CONN6.8 42.91,227.94 ; CONN6.8 40.24,227.94 ; 259.27,20.13 RJ1.F4 ; RJ1.F4 260.08,20.94 ; RJ1.F4 259.27,21.75 ; RJ1.F4 258.46,20.94 ; CONN6.24 24.77,234.77 ; CONN6.24 26.11,233.44 ; CONN6.24 23.44,233.44 ; CONN6.24 24.77,232.1 ; 65.44,227.94 CONN6.2 ; CONN6.2 66.77,226.6 ; CONN6.2 66.77,229.27 ; CONN6.2 68.11,227.94 ; 54.17,232.1 CONN6.17 ; CONN6.17 54.17,234.77 ; CONN6.17 55.51,233.44 ; CONN6.17 52.84,233.44 ; 52.84,227.94 CONN6.5 ; CONN6.5 54.17,229.27 ; CONN6.5 54.17,226.6 ; CONN6.5 55.51,227.94 ; RJ1.F5 258,24.29 ; RJ1.F5 258.81,23.48 ; RJ1.F5 258,22.67 ; RJ1.F5 257.19,23.48 ; CONN6.20 42.91,233.44 ; CONN6.20 41.57,232.1 ; CONN6.20 41.57,234.77 ; CONN6.20 40.24,233.44 ; CONN6.12 24.77,229.27 ; CONN6.12 24.77,226.6 ; CONN6.12 26.11,227.94 ; CONN6.12 23.44,227.94 ; RJ1.C5 246.11,14.34 ; RJ1.C5 244.49,14.34 ; RJ1.C5 245.3,13.53 ; RJ1.C5 245.3,15.15 ; CONN6.23 28.97,234.77 ; CONN6.23 30.31,233.44 ; CONN6.23 27.64,233.44 ; CONN6.23 28.97,232.1 ; 28.97,226.6 CONN6.11 ; CONN6.11 28.97,229.27 ; CONN6.11 27.64,227.94 ; CONN6.11 30.31,227.94
  BOTTOM w0.127: v2(93.63,202.41) 93.63,202.98 v1(93.37,203.24) ; 86.88,181.51 86.88,181.48 v1(86.9,181.46) ; R1189.2 190.41,22.85 v1(190.41,22.86) ; v1(89.88,27.21) 89.91,27.24 ; v2(128.49,166.47) 128.24,166.72 128.24,167.38 v1(128.25,167.38)
  BOTTOM w0.254: 200.78,216.99 200.33,217.44 CB1058.2 ; CB1172.2 98.78,216.95 v4(99.29,217.46) 99.57,217.74 CB1173.2 ; CB1142.2 103.79,212.96 v4(103.29,213.46) ; CB1115.2 110.8,225.98 v4(111.29,226.46) 111.8,226.97 CB1123.2 ; v4(103.29,224.46) 103.24,224.46 CB1135.2 ; CB1167.2 101,227.75 v4(101.29,227.46) 101.3,227.45 CB1168.2 ; CB1170.2 98.79,222.96 v4(99.29,222.46) 98.79,221.96 CB1171.2 ; 197.03,193.1 196.55,192.63 v4(196.55,192.58) ; 197.03,193.1 v4(197.55,192.58) ; 197.03,193.1 CB92.2 196.58,193.58 v4(196.55,193.58) ; v4(112.29,219.46) 112.58,219.17 CB1160.2 ; v4(112.29,219.46) 111.78,219.97 CB1177.2 ; v4(112.29,219.46) 112.32,219.49 CB1163.2 ; C287.1 123.79,164.18 v1(125.38,165.77) ; UB9.15 240.8,155.21 v1(241.52,155.93) ; v4(107.29,212.46) 107.78,212.95 CB1121.2 ; CB1058.2 199.75,217.44 199.38,217.06 ; CB1058.2 199.99,216.88 v1(200.31,216.56) ; v4(195.55,192.58) 196,192.13 CB108.2 196.03,192.1 v4(196.55,191.58) 196.55,191.81 196.84,192.09 CB113.2 ; v1(105.06,251.11) 105.12,251.05 v2(106.4,251.05) ; CB1143.2 98.57,228.74 v4(98.29,228.46) ; v4(109.29,221.46) 108.78,221.97 CB1179.2 ; v4(201.55,188.58) 201.55,188.51 CB155.2 201.08,188.05 v4(200.55,188.58) 200.08,188.1 CB162.2 ; v4(113.31,225.4) 112.87,224.95 CB1165.2 ; CB162.2 199.55,188.55 v4(199.55,188.58) 198.71,188.58 CB140.2 ; CB162.2 200.53,187.58 v4(200.55,187.58) ; v2(133.17,246.38) 134.17,246.38 v1(134.22,246.43) ; CB1169.2 99.03,224.2 v4(99.29,224.46) ; v1(134.34,252.43) 133.34,252.43 v2(133.32,252.45) ; v4(109.29,214.46) 108.81,214.93 CB1117.2 ; v4(109.29,214.46) 109.8,213.95 CB1141.2 ; v4(109.29,214.46) 108.77,213.94 CB1127.2 ; UB5.H9 v4(26.42,163.89) ; CB1149.2 106.19,211.36 v4(106.29,211.46) ; CB1162.2 108.32,230.42 v4(108.29,230.46) ; v1(35.77,187.54) 36.12,187.19 C293.2 36.73,186.85 v1(36.83,186.75) ; CB1159.2 P1.V8 v4(112.29,216.46) 111.76,215.94 CB1158.2 ; CB765.1 21.19,98.16 v4(20.7,98.65) ; v4(110.29,212.46) 109.8,211.97 CB1151.2 ; v4(101.29,219.46) 101.52,219.7 CB1180.2 ; v2(239.47,246.23) 239.47,246.97 v1(239.74,247.24) ; CB1118.2 98.76,214.98 v4(98.29,215.46) ; CB38.2 v1(70.14,239.38) ; v4(106.29,213.46) 105.71,212.88 CB1122.2 ; CB1176.2 98.78,220.95 v4(99.29,221.46) ; CB1174.2 98.78,219.97 v4(99.29,219.46) ; v1(230.68,223.13) 230.61,223.2 CB33.1 ; v4(112.29,228.46) 112.53,228.7 CB1144.2 ; v4(112.29,223.46) 112.58,223.75 CB1161.2 ; CB1073.2 193.13,220.88 v3(192.94,221.07) 192.81,220.94 CB1074.2 ; UB14.5 UB14.G1 ; v4(197.55,188.58) 197.71,188.42 CB140.2 ; v1(239.72,257.19) 239.7,257.17 v2(239.7,255.91) ; CB170.2 199.05,187.78 198.55,188.28 CB140.2 ; v4(108.29,227.46) 107.81,227.94 CB1166.2 ; CB1175.2 96.8,217.97 v4(95.29,216.46) ; CB1157.2 97.82,226.93 v4(97.29,227.46) ; v4(111.29,218.46) 110.81,218.94 CB1116.2
  BOTTOM w0.305: v4(53.7,101.65) 53.19,101.13 CB735.1 ; CB698.1 25.15,103.2 v4(24.7,103.65) ; CB699.1 27.64,104.65 v4(27.7,104.65) ; v4(25.7,101.65) 25.7,101.73 CB717.1 ; CB1155.2 101.78,210.96 v4(102.29,210.46) ; CB690.1 45.7,104.63 v4(45.7,104.65) ; v4(28.7,101.65) 29.21,102.16 CB719.1 ; v4(31.7,106.65) 31.17,106.12 CB680.1 ; v4(54.7,104.65) 54.7,104.65 CB696.1 ; v4(45.7,97.65) 46.34,97.01 47.09,97.01 CB772.1 ; v4(54.7,108.65) 54.78,108.65 CB652.1 ; CB649.1 53.7,108.65 v4(53.7,108.65) ; v4(41.7,102.65) 41.23,102.18 CB722.1 ; CB576.1 49.22,115.17 v4(48.7,114.65) ; CB769.1 35.44,96.88 35.93,96.88 v4(36.7,97.65) ; v4(53.7,103.65) 53.7,103.63 CB705.1 ; v4(43.7,104.65) 43.7,104.62 CB703.1 ; v1(174.4,17.18) 174.37,17.21 UB17.12 ; v4(39.7,101.65) 39.7,101.61 CB725.1 ; v4(50.7,100.65) 51.13,100.21 CB750.1 ; CB700.1 29.19,103.14 v4(28.7,102.65) ; CB770.1 39.3,97.01 41.06,97.01 v4(41.7,97.65) ; CB706.1 57.21,103.16 v4(57.7,103.65) ; v4(48.7,110.65) 49.17,111.12 CB634.1 ; v4(29.7,106.65) 29.67,106.65 CB683.1 ; UB12.12 v1(131.59,30.97) ; v4(54.7,100.65) 54.7,100.6 55.06,100.23 CB751.1 ; v4(34.7,104.65) 35.17,104.17 CB701.1 ; v4(37.7,99.65) 38.22,100.17 CB745.1 ; CB1131.2 108.23,227.46 v4(108.29,227.46) ; CB767.1 27.32,97.01 28.06,97.01 v4(28.7,97.65) 29.47,96.88 30.91,96.88 CB768.1 ; v4(41.7,98.65) 41.17,99.17 CB746.1 ; CB740.1 v4(24.7,98.65) 24.7,98.72 CB756.1 ; CB718.1 26.74,101.65 v4(26.7,101.65) ; v1(40.69,65.1) 40.72,65.06 CB860.2 ; v4(43.7,101.65) 43.7,101.64 CB726.1 ; CB773.1 50.95,96.88 50.47,96.88 v4(49.7,97.65) ; v4(31.7,105.65) 31.24,105.19 CB694.1 ; CB678.1 45.18,107.17 v4(44.7,107.65) ; CB218.2 87.27,162.29 v4(87.94,161.62) ; v4(49.7,102.65) 49.7,102.63 CB727.1 ; CB1124.2 99.56,211.74 v4(99.29,211.46) 98.79,211.96 CB1140.2 ; CB1150.2 104.28,210.46 v4(104.29,210.46) ; CB1145.2 112.56,213.19 v4(112.29,213.46) ; CB614.1 50.18,113.12 v4(49.7,112.65) ; v4(113.29,210.46) 112.79,210.95 CB1153.2 ; v4(46.7,105.65) 46.7,105.64 CB691.1 ; CB715.1 30.7,101.67 v4(30.7,101.65) ; v4(109.29,210.46) 109.26,210.49 CB1154.2 108.73,210.02 v4(109.29,209.46) ; CB704.1 v4(50.7,104.65) ; v4(23.7,104.65) 23.63,104.65 CB697.1 ; v4(108.29,225.46) 107.78,224.95 CB1130.2 ; v4(56.7,111.65) 56.21,112.13 CB617.1 ; CB720.1 51.25,101.2 v4(51.7,101.65) ; CB747.1 43.18,100.13 v4(42.7,99.65) ; CB749.1 47.12,100.22 v4(46.7,100.65) ; CB479.2 50.1,122.15 50.59,122.65 v4(50.7,122.65) ; CB606.1 48.7,113.6 v4(48.7,113.65) ; 47.7,101.67 CB714.1 ; CB1146.2 110.53,212.7 v4(110.29,212.46) ; CB1164.2 100.79,212.96 v4(101.29,213.46) ; v4(21.7,101.65) 21.67,101.65 CB734.1 ; v4(31.7,99.65) 31.7,99.69 CB743.1 ; v4(111.29,211.46) 111.56,211.73 CB1148.2 ; v4(28.7,98.65) 29.21,99.16 CB742.1 ; UB8.12 v1(171.68,30.97) ; v4(52.7,111.65) 52.21,111.16 CB632.1 ; v4(36.7,102.65) 36.7,102.63 CB728.1 35.72,101.65 v4(35.7,101.65) 35.7,101.64 CB724.1 ; v4(100.29,210.46) 100.41,210.34 CB1156.2 ; CB602.1 54.2,113.14 v4(53.7,113.65) 53.26,114.09 CB593.1 53.26,114.21 v4(53.7,114.65) 53.7,114.75 CB577.1 ; v4(57.7,111.65) 57.21,111.16 CB633.1 ; CB748.1 45.17,99.17 v4(45.7,98.65) ; CB692.1 48.7,104.64 v4(48.7,104.65) 48.22,105.13 CB695.1 ; CB677.1 41.17,107.17 v4(40.7,107.65) ; v4(50.7,108.65) 50.7,108.66 CB648.1 ; CB741.1 27.7,99.76 v4(27.7,99.65) ; CB34.2 80.68,190.04 v1(81.56,190.92) ; v4(52.7,106.65) 52.7,106.6 CB684.1 ; v4(48.7,107.65) 48.7,107.62 CB679.1 ; CB729.1 45.21,102.16 v4(45.7,102.65) ; CB766.1 53.7,98.62 v4(53.7,98.65) ; v4(84.83,164.05) 84.81,164.03 CB236.2 ; v4(22.7,101.65) 22.72,101.65 CB721.1 ; v4(33.7,107.65) 33.77,107.65 CB661.2 34.25,108.1 v4(34.7,107.65) 34.74,107.65 CB662.2 ; v4(36.7,98.65) CB744.1 ; v4(52.7,101.65) 52.2,102.14 CB713.1
  BOTTOM w0.381: 24.7,117.69 CB546.2 23.7,117.72 v4(23.7,117.65) ; 24.7,117.69 v4(24.7,117.65) ; 24.7,117.69 24.7,117.7 CB547.2 25.26,118.21 v4(25.7,118.65) 25.78,118.65 CB548.1 26.26,118.21 v4(26.7,118.65) 26.74,118.65 CB523.2 ; v4(34.7,128.65) 34.68,128.65 CB401.2 ; CB370.2 49.72,132.65 v4(49.7,132.65) ; CB208.2 61.89,164.02 v4(61.9,164.02) ; CB465.2 37.7,123.65 v4(37.7,123.65) 37.2,123.15 CB464.1 36.7,122.65 v4(36.7,122.65) 37.19,122.15 CB483.2 37.7,121.65 v4(37.7,121.65) 37.7,121.65 CB497.2 39.2,120.15 CB502.2 ; CB620.2 33.19,112.14 v4(33.7,112.65) v4(34.7,113.65) v4(35.7,114.65) 35.7,114.65 CB581.2 ; CB620.2 32.7,111.65 v4(32.7,111.65) 32.7,111.65 CB626.2 32.19,111.14 v4(31.7,110.65) 31.7,110.64 CB643.2 ; CB620.2 32.7,112.64 v4(32.7,112.65) 32.2,113.14 CB601.2 32.19,113.14 v4(31.7,112.65) 31.69,112.65 CB619.2 31.19,112.14 v4(30.7,111.65) 30.7,111.58 CB639.1 29.76,110.65 v4(29.7,110.65) ; RB280.1 238.73,87.04 v1(238.73,87.03) ; CB367.2 37.16,132.18 v4(36.7,132.65) 36.21,132.16 CB365.2 ; CB529.2 27.7,117.66 v4(27.7,117.65) ; CB529.2 28.2,118.15 v4(28.7,117.65) ; CB529.2 28.69,118.65 v4(28.7,118.65) 28.7,118.7 CB512.2 29.19,119.16 v4(29.7,118.65) ; CB436.2 51.7,124.7 v4(51.7,124.65) ; v1(208.75,197.06) CB72.2 ; v4(34.7,122.65) 35.19,122.15 CB482.2 35.7,121.65 v4(35.7,121.65) CB496.2 36.7,120.65 v4(36.7,120.65) 37.19,120.15 CB520.2 37.7,119.65 v4(37.7,119.65) 38.19,119.15 CB521.1 ; v4(34.7,122.65) 34.2,122.15 CB481.2 33.7,121.65 v4(33.7,121.65) CB495.2 v4(34.7,120.65) CB518.2 v4(35.7,119.65) CB519.1 v4(36.7,118.65) CB543.2 v4(37.7,117.65) 38.2,117.15 CB554.2 38.26,117.21 39.13,117.21 RB194.2 ; v4(34.7,122.65) 34.7,122.65 CB467.2 34.19,123.15 v4(33.7,123.65) 33.2,123.15 CB462.2 32.7,122.66 v4(32.7,122.65) CB461.2 v4(31.7,123.65) 31.2,123.15 CB460.2 ; v4(232.18,121.65) CB1015.2 ; CB466.2 28.68,123.65 v4(28.7,123.65) 28.2,124.14 CB448.2 ; RB685.1 v1(88.44,21.21) ; CB202.2 16.22,165.33 v1(16.35,165.45) ; v4(27.7,112.65) 27.7,112.75 CB597.2 ; v1(47.21,162.79) 47.01,162.59 RB125.1 ; RB411.2 192.27,37.36 192.6,37.68 v1(193.01,37.68) ; CB416.1 52.76,126.65 v4(52.7,126.65) ; 32.7,107.61 32.7,107.6 CB667.1 33.25,107.1 v4(33.7,106.65) ; 32.7,107.61 v4(32.7,107.65) ; 32.7,107.61 CB666.1 ; CB203.2 RB113.1 60.74,166.34 61.82,166.34 v4(61.9,166.42) ; v4(26.7,112.65) 26.7,112.74 CB596.2 ; v3(14.89,51.39) 15.85,52.35 CB1095.2 16.9,51.39 v3(17.17,51.39) ; v4(57.7,98.65) 57.21,99.13 CB758.1 ; v4(30.7,116.65) 30.7,116.64 CB565.2 ; v4(231.18,126.65) CB1007.2 ; v4(46.7,107.65) 46.2,108.14 CB660.1 ; CB159.2 100.65,169.23 100.23,168.82 v4(100.08,168.82) ; v1(71.59,159.61) CB295.2 ; v3(195.23,226.07) 195.29,226.01 CB1080.2 ; v4(46.7,126.65) 46.71,126.65 CB427.2 ; CB657.1 39.2,108.14 v4(39.7,107.65) 39.7,107.65 CB658.1 40.69,107.65 v4(40.7,107.65) ; CB134.2 90.79,170.99 v4(91.05,171.24) ; CB812.2 v1(128.82,67.6) ; v4(47.7,128.65) 48.19,128.15 CB411.2 ; CB828.2 v1(40.64,68.41) ; CB459.2 30.68,124.65 v4(30.7,124.65) 30.7,124.66 CB430.2 31.68,125.65 v4(31.7,125.65) 31.7,125.66 CB423.2 32.7,125.65 v4(32.7,125.65) ; CB501.2 50.18,120.16 v4(49.7,120.65) 49.7,120.64 CB508.2 49.2,120.15 v4(48.7,119.65) ; CB506.2 46.7,119.65 v4(46.7,119.65) 46.2,119.15 CB524.2 45.7,118.65 v4(45.7,118.65) 45.7,118.64 CB535.2 44.7,117.65 v4(44.7,117.65) 44.2,117.15 CB555.2 43.7,116.65 v4(43.7,116.65) 43.2,116.15 CB569.2 CB583.2 44.2,115.14 v4(44.7,114.65) 45.2,114.14 CB605.1 44.72,113.65 v4(44.7,113.65) ; CB393.2 45.71,130.65 45.7,130.65 ; v1(237.62,125.95) 237.87,125.69 R1045.1 ; CB369.2 32.19,131.15 v4(32.7,130.65) 33.19,130.16 CB389.2 ; CB866.2 78.86,65.12 v1(78.36,65.62) ; CB799.2 v1(35.33,67.6) ; v4(103.29,213.46) 102.8,213.94 CB1125.2 ; v4(45.7,109.65) CB644.2 v4(44.7,110.65) CB630.2 v4(43.7,111.65) CB625.2 v4(42.7,112.65) 42.7,112.65 CB612.2 v4(41.7,113.65) 41.7,113.65 CB591.2 ; v4(34.7,107.65) 35.19,107.16 CB675.1 35.21,107.16 v4(35.7,107.65) 35.7,107.61 CB676.1 36.19,107.14 v4(36.7,107.65) ; RB396.2 v1(92.9,37.36) ; CB1067.2 190.68,224.81 v1(190.38,224.51) ; CB130.2 42.03,170.66 v1(42.48,170.2) ; CB757.2 112.31,100.23 CB731.2 112.49,100.43 113.24,101.18 v3(113.24,101.41) ; v4(43.7,126.65) 44.19,126.15 CB426.2 ; CB862.2 60.23,64.41 v1(60.25,64.4) ; CB727.1 48.72,101.65 v4(48.7,101.65) 48.69,101.65 CB723.1 47.7,101.72 v4(47.7,101.65) ; CB643.2 32.2,110.14 v4(32.7,109.65) ; CB643.2 v4(31.7,109.65) ; v4(92.89,160.02) 92.81,159.94 CB297.2 ; v1(190.83,215.71) CB1054.2 191.67,215.68 CB1050.2 v1(194.43,215.68) ; v4(231.18,125.65) CB1033.2 ; CB1132.2 109.76,220.98 v4(109.29,221.46) 108.84,221.01 CB1133.2 ; v3(41.02,190.37) 41.02,190.51 40.67,190.85 CB400.2 41.89,191.1 CB417.1 ; CB458.1 41.2,123.15 v4(41.7,123.65) 41.7,123.65 CB450.2 ; v1(35.69,37.35) RB416.2 ; v1(121.76,37.68) 121.35,37.68 121.02,37.36 RB423.2 ; C545.2 28.85,68.07 29.25,67.68 v1(29.22,67.65) ; CB314.2 88.54,158.21 v4(88.74,158.42) ; C672.2 72.74,64.41 v1(72.76,64.4) ; v4(89.54,162.42) 89.66,162.31 CB246.2 ; 45.7,130.65 v4(45.7,130.65) ; 45.7,130.65 CB375.2 ; v4(200.55,189.58) 201.08,190.11 CB129.2 201.28,190.19 201.97,190.87 CB121.2 ; v4(53.7,118.65) 53.7,118.64 CB537.2 ; UB5.D8 v4(25.63,160.69) ; v4(21.7,118.65) 22.14,118.2 CB544.2 ; CB56.2 CB57.2 v1(24.1,179.19) ; v4(34.7,111.65) 35.19,111.15 CB642.2 ; v4(34.7,111.65) CB641.1 v4(33.7,110.65) ; v4(34.7,111.65) CB621.2 v4(35.7,112.65) CB609.2 36.2,113.14 v4(36.7,113.65) CB589.2 v4(37.7,114.65) ; CB666.1 31.7,107.58 v4(31.7,107.65) ; CB666.1 31.73,106.65 v4(31.7,106.65) ; v4(230.18,118.65) CB994.2 ; CB213.2 89.19,164.37 v4(89.54,164.02) 89.71,164.19 CB217.2 ; v1(28.03,179.19) CB61.2 CB60.1 ; C551.2 v1(65.72,68.41) ; CB391.2 40.19,130.16 v4(39.7,130.65) 40.14,131.09 CB374.1 ; RB758.1 228.59,121.25 v4(228.18,121.65) ; v1(130.58,67.57) 130.48,67.67 C559.2 ; v4(21.7,111.65) 21.7,111.59 CB636.1 ; v4(37.7,128.65) 38.2,129.14 CB395.2 ; C781.2 233.31,113.17 v1(233.32,113.18) ; v4(57.7,124.65) 57.21,125.13 CB435.1 ; CB449.2 35.19,124.15 v4(35.7,123.65) 35.7,123.65 CB463.2 35.7,124.65 v4(35.7,124.65) 35.2,124.15 CB449.2 ; CB449.2 34.7,124.65 v4(34.7,124.65) 34.7,124.65 CB431.2 ; UB5.K1 18.84,165.89 18.05,165.1 v4(18.05,164.74) ; CB399.1 31.21,128.16 v4(31.7,128.65) ; CB44.2 191.06,199.09 v4(190.55,198.58) 190.05,199.08 CB51.2 190.04,199.09 v4(189.55,199.58) ; U52.L5 v4(230.18,119.65) ; CB270.2 102.52,161.64 ; v4(31.7,114.65) 31.2,114.14 CB600.2 30.7,113.65 v4(30.7,113.65) 30.2,114.14 CB599.2 ; UB13.12 v1(55.4,30.97) ; CB390.1 25.19,129.16 v4(25.7,128.65) ; v4(37.7,106.65) 38.21,107.16 RB195.2 ; C570.2 v1(47.84,67.6) ; v1(91.21,37.68) 90.8,37.68 90.47,37.36 RB395.2 ; CB109.2 200.55,192.52 v4(200.55,192.58) 201.08,193.11 CB101.2 ; v1(72.61,166.47) 72.15,166.47 CB183.2 RB105.1 ; v4(20.7,117.65) 21.15,117.19 CB557.2 ; CB491.1 40.2,121.15 v4(40.7,121.65) 40.7,121.65 CB492.2 41.2,122.15 v4(41.7,122.65) 41.7,122.65 CB473.2 42.2,123.15 v4(42.7,123.65) ; v1(185.51,68.88) 185.98,68.41 CB821.2 ; CB352.2 43.18,133.16 43.55,132.79 v4(43.7,132.65) ; RB126.1 CB282.2 42.21,160.5 v1(42.74,159.97) ; UB5.G8 v4(25.63,163.09) ; RB671.2 v1(45.55,21.68) ; U52.F4 v3(228.18,123.65) ; v1(42.76,157.45) CB318.2 ; UB5.H1 v4(19.23,164.69) ; v4(55.7,101.65) 55.72,101.65 CB716.1 56.7,101.65 v4(56.7,101.65) 57.21,101.13 CB732.1 57.7,101.62 v4(57.7,101.65) ; CB195.2 72.52,165.81 v1(72.61,165.71) ; CB1026.2 v3(226.18,120.65) CB1030.2 ; CB816.2 155.4,68.29 v1(155.74,68.63) ; v4(41.7,128.65) 42.19,128.15 CB409.2 ; v4(46.7,121.65) CB485.2 47.7,121.66 v4(47.7,121.65) ; v4(106.29,217.46) 105.6,218.15 CB1114.1 ; v4(48.7,117.65) 48.2,117.15 CB556.2 47.7,116.65 v4(47.7,116.65) 47.2,116.15 CB573.2 ; v4(33.7,132.65) 33.7,132.65 CB355.2 ; v4(28.7,128.65) 28.68,128.65 CB398.1 ; CB1089.1 242.69,95.76 v1(242.81,95.64) ; CB308.2 48.23,158.85 v1(47.97,159.1) 48.61,159.74 CB291.2 ; CB807.2 v1(72.92,67.6) ; R1322.1 v1(226.55,165.76) ; RB171.2 RB172.1 22.15,130.1 v4(22.7,130.65) ; R1129.1 v1(196.89,227.23) ; v1(33.99,37.68) 33.59,37.68 33.26,37.35 RB415.2 ; v4(23.7,124.65) 24.12,124.22 CB454.2 ; v4(21.7,122.65) 22.17,122.17 CB478.2 ; CB277.2 CB276.2 58.74,161.44 v4(58.56,161.62) ; v4(23.7,112.65) 23.24,113.1 CB598.2 23.21,113.16 v4(22.7,112.65) 22.25,113.09 CB604.2 22.23,113.12 21.24,113.12 CB603.2 ; C676.2 116.07,64.41 v1(116.08,64.4) ; CB402.1 57.7,127.67 v4(57.7,127.65) ; C652.2 v1(35.76,66.39) ; C690.2 35.15,64.41 v1(35.17,64.4) ; v4(98.48,161.62) 98.18,161.32 CB261.2 CB260.2 ; v1(136.01,37.68) 135.6,37.68 135.27,37.36 RB427.2 ; v4(22.7,106.65) 22.7,106.69 CB674.1 21.72,106.65 v4(21.7,106.65) 21.7,106.67 CB673.1 20.7,106.65 v4(20.7,106.65) ; CB568.1 36.7,116.64 v4(36.7,116.65) 36.2,117.15 CB553.2 35.7,117.64 v4(35.7,117.65) 35.2,118.15 CB542.2 34.7,118.64 v4(34.7,118.65) CB517.2 33.7,119.64 v4(33.7,119.65) 33.19,120.15 CB516.2 32.7,120.64 v4(32.7,120.65) 32.22,121.13 CB488.2 31.8,121.65 v4(31.7,121.65) 31.2,121.15 CB490.2 30.7,120.66 v4(30.7,120.65) ; v1(193.21,66.6) 193,66.39 C634.2 ; v4(52.7,120.65) 52.21,121.14 CB499.2 ; RB428.2 v1(137.7,37.36) ; RB385.2 v1(58.69,37.36) ; v4(196.55,188.58) 196.55,188.45 196.17,188.07 CB153.2 ; CB471.2 39.69,122.65 v4(39.7,122.65) U40.AF18 CB457.2 40.2,123.15 v4(40.7,123.65) ; v4(69.1,162.42) 69.32,162.64 CB235.2 70.74,162.64 CB244.2 ; CB1017.2 v4(228.18,119.65) CB997.2 ; CB425.2 37.7,125.65 37.7,125.65 ; v4(20.7,125.65) 21.14,126.09 CB421.2 ; v4(103.29,219.46) 103.21,219.54 CB1112.1 ; 106.36,23.35 CB957.1 105.85,24.01 ; v4(230.18,121.65) U52.J6 ; v1(47.46,169.14) 47.77,169.14 CB131.2 ; v1(11.34,164.23) 11.42,164.31 RB118.1 ; U52.D4 v3(228.18,125.65) ; v4(207.58,181.55) 207.06,182.07 CB240.2 206.55,182.57 v4(206.55,182.58) 206.55,182.59 CB225.2 ; CB110.2 v1(85.64,173.76) ; v4(58.56,162.42) 58.57,162.43 CB241.2 CB242.2 CB243.2 ; v1(31.7,37.35) RB414.2 ; v4(28.7,116.65) 28.9,116.65 29.25,116.29 RB193.2 ; v4(104.29,221.46) 104.79,221.96 CB1134.2 ; v1(95.6,135.74) CB348.2 ; v4(40.7,104.65) 40.7,104.61 CB689.1 ; v1(43.32,169.49) 43.22,169.39 CB154.2 ; v4(230.18,123.65) U52.F6 ; RB418.2 v1(46.17,37.36) ; CB1139.2 84.45,226.05 84.39,226.1 84.39,226.13 v1(84.36,226.13) ; CB357.2 48.18,134.16 v4(47.7,134.65) ; UB6.A2 v4(30.57,158.29) ; CB363.2 40.74,132.65 v4(40.7,132.65) ; CB470.2 53.21,123.14 v4(53.7,122.65) 54.19,122.15 CB493.2 ; C90.2 v1(62.45,178.92) ; UB5.C9 v4(26.42,159.89) ; UB6.E3 v4(31.37,161.49) ; CB364.1 21.21,132.16 v4(21.7,132.65) ; v4(93.69,158.42) 93.71,158.39 CB315.2 ; v4(42.7,117.65) CB533.2 43.2,118.15 v4(43.7,118.65) 44.2,119.15 CB534.2 44.2,119.15 v4(44.7,119.65) 44.85,119.8 45.2,120.15 CB510.2 v4(45.7,120.65) 45.7,120.65 CB498.2 ; v1(79.47,159.99) 79.52,160.04 CB287.2 ; UB5.D2 v4(20.83,161.49) UB5.E3 ; RB207.1 v4(46.7,109.65) ; v1(62.71,37.68) 62.3,37.68 61.97,37.36 RB387.2 ; CB156.1 CB166.1 11.96,167.43 v1(12.11,167.28) ; v1(64.74,164.82) 64.48,164.56 CB231.2 64.51,164.13 CB230.2 ; v1(96.64,160.34) CB288.2 ; v4(45.7,116.65) 46.18,116.16 RB196.2 ; v4(45.7,116.65) 45.7,116.65 CB549.2 46.7,117.64 v4(46.7,117.65) 46.85,117.8 47.15,118.1 CB539.2 ; v4(45.7,116.65) 45.7,116.64 CB558.2 ; C688.2 192.59,64.41 v1(192.6,64.4) ; v1(24.98,179.25) CB58.1 CB59.2 ; v4(231.18,118.65) CB996.2 231.81,119.28 232.56,119.28 CB1034.2 ; 86.88,181.51 86.88,183.09 CB5.2 86.4,183.13 86.07,182.8 86.07,182.79 v1(86.06,182.79) ; v1(71.59,158.72) 71.03,158.72 CB311.2 ; CB959.2 v1(91.25,18.54) ; CB294.2 CB310.2 CB316.2 14.5,155.54 v1(16.35,153.69) ; v1(57.34,95.76) 56.63,95.76 CB774.1 ; CB856.2 v1(60.84,66.39) ; v4(52.7,132.65) 52.26,133.08 CB359.1 ; v4(19.02,167.66) 19.63,168.27 UB5.N1 ; CB453.2 48.71,124.65 v4(48.7,124.65) 49.22,125.17 CB429.2 ; CB645.2 47.2,110.14 v4(46.7,110.65) 46.7,110.65 CB631.2 v4(45.7,111.65) v4(44.7,112.65) 44.7,112.65 CB613.2 v4(43.7,113.65) CB592.2 v4(42.7,114.65) CB582.2 42.2,115.19 CB559.1 41.7,116.59 v4(41.7,116.65) 41.76,116.65 CB560.2 ; v1(79.85,170.53) 79.98,170.41 CB136.2 ; CB536.2 50.21,118.14 v4(50.7,117.65) ; v4(35.7,104.65) 35.7,104.63 CB688.1 ; CB1024.2 v4(228.18,126.65) CB1020.2 ; CB161.2 197.03,188.05 v4(197.55,188.58) ; v1(39.84,172.69) 40.02,172.51 CB118.2 CB119.2 ; UB6.B2 v4(30.57,159.09) ; v1(227.65,165.55) 227.08,164.98 C883.2 ; CB205.2 100.63,164.57 v4(100.08,164.02) 99.73,164.37 CB212.2 ; C169.2 v1(102.71,160.63) ; CB1053.2 189.21,230.95 v3(189.13,230.88) 189.33,230.68 CB1051.2 ; RB417.2 v1(44.44,37.36) ; CB1068.2 v1(190.48,223.8) ; v4(30.7,120.65) 30.7,120.64 CB514.2 31.19,120.15 v4(31.7,119.65) 31.7,119.64 CB515.2 32.69,118.65 v4(32.7,118.65) 33.19,118.15 CB541.2 33.69,117.65 v4(33.7,117.65) v4(34.7,116.65) 34.7,116.64 CB567.2 ; v4(30.7,120.65) 30.19,121.15 CB489.2 29.7,121.64 v4(29.7,121.65) ; v1(21.33,179.27) 21.33,179.07 21.05,178.79 CB54.2 CB55.2 ; v4(30.7,126.65) 31.19,127.14 CB414.2 ; CB258.2 v1(77.51,162.35) ; v1(178.76,37.68) 178.35,37.68 178.02,37.36 RB407.2 ; RB386.2 v1(60.42,37.36) ; CB818.2 v1(160.3,68.41) ; CB152.2 91.79,168.76 CB172.2 92.71,168.19 v4(92.89,168.02) ; v1(42.51,167.45) 42.09,167.87 RB103.1 ; v1(47.97,161.14) 48.23,161.39 48.91,161.39 CB265.2 CB253.2 ; CB437.2 39.79,124.65 v4(39.7,124.65) 39.7,124.65 CB442.2 ; CB418.2 27.7,126.72 v4(27.7,126.65) 27.21,126.15 CB419.1 ; v1(93.41,176.63) 93.69,176.35 RB78.1 ; UB6.D2 v4(30.57,160.69) ; CB268.2 92.71,161.79 v4(92.89,161.62) ; v1(168.93,146.3) 169.24,145.99 RB1233.1 ; v1(234.18,112.37) 234.19,112.38 C779.2 ; RB388.2 v1(64.4,37.36) ; v4(23.7,108.65) 23.25,109.1 CB653.1 ; CB656.1 36.7,108.65 v4(36.7,108.65) ; v1(53.56,67.6) 53.94,67.98 C547.2 ; v4(89.54,168.82) 90.07,168.82 90.13,168.88 CB160.2 ; C608.2 v1(129.25,66.39) ; RB432.2 v1(151.95,37.36) ; C610.2 v1(137.39,66.27) ; CB2.2 90.74,182.12 v1(91.37,181.49) ; RB419.2 47.72,37.36 48.05,37.68 v1(48.46,37.68) ; v4(57.7,111.65) U40.R1 ; C879.2 227.57,170.97 v1(227.65,171.04) ; RB405.2 v1(174.74,37.36) ; CB771.1 43.47,96.88 44.93,96.88 v4(45.7,97.65) ; CB227.2 CB226.2 48.19,164.26 v1(48.01,164.08) ; v1(192.55,67.28) 192.77,67.5 CB822.2 ; RB393.2 v1(87.19,37.36) ; CB224.2 191.05,183.08 v4(190.55,182.58) 190.05,182.08 CB239.2 ; v4(57.7,121.65) 57.21,122.13 CB486.1 ; v4(49.7,98.65) 49.21,99.13 CB752.1 ; CB185.2 89.87,166.09 v4(89.54,166.42) ; v1(85.27,64.4) 85.19,64.48 C674.2 ; CB274.2 CB285.2 54.52,159.67 54.78,159.41 v4(54.78,159.41) ; C563.2 v1(167.49,67.6) ; v4(42.7,110.65) 42.7,110.65 CB629.2 42.2,111.14 v4(41.7,111.65) 41.7,111.65 CB624.2 v4(40.7,112.65) 40.7,112.65 CB611.2 U40.T18 v4(39.7,113.65) 39.18,114.17 CB590.2 ; CB312.2 CB296.2 42.28,159.48 42.46,159.31 43.04,159.31 v1(43.48,159.74) ; v4(58.56,168.82) 58.96,168.82 59.58,169.44 CB167.2 CB157.2 ; v4(26.7,111.65) 27.19,111.16 CB638.1 ; CB472.2 26.68,122.65 v4(26.7,122.65) 27.19,122.15 CB480.2 ; CB233.2 92.72,163.85 v4(92.89,164.02) 92.78,164.12 CB211.2 ; CB574.2 24.72,114.67 v4(24.7,114.65) ; 81.6,102 C367.1 C366.1 CB447.1 ; v4(51.36,166.42) 50.74,167.03 CB175.2 50.05,167.06 CB173.2 ; v4(22.7,130.65) 22.7,130.64 CB384.1 23.21,130.16 v4(23.7,130.65) 24.2,130.14 CB394.2 ; v4(22.7,130.65) 22.3,131.04 CB380.2 ; CB299.2 79.52,159.05 v4(79.21,159.36) ; 37.7,125.65 CB424.2 37.19,126.15 v4(36.7,126.65) 36.7,126.66 CB415.2 ; 37.7,125.65 v4(37.7,125.65) ; C95.2 v1(67.53,178.92) ; UB5.E8 v4(25.63,161.49) ; v4(47.7,107.65) CB664.1 ; v4(48.7,119.65) 48.2,120.14 CB507.2 ; v4(48.7,119.65) 48.71,119.65 CB525.2 48.7,118.65 v4(48.7,118.65) ; RB429.2 v1(146.24,37.36) ; C626.2 v1(180.56,66.39) ; CB835.2 84.99,66.83 v1(85.44,67.28) ; C411.2 112.61,108.81 v1(112.23,109.19) ; CB386.2 35.68,130.65 v4(35.7,130.65) ; RB409.2 v1(188.99,37.36) ; UB5.F1 v4(19.23,162.29) 19.63,161.89 UB5.E1 ; C564.2 v1(172.93,68.41) ; v4(82.34,166.42) 81.63,166.42 CB197.2 ; RB227.1 110.53,100.45 110.53,101.24 109.9,101.88 v1(109.82,101.88) ; 81.25,109.45 CB444.1 ; CB52.2 CB53.2 20.03,178.74 v1(20.54,179.25) ; CB292.2 CB279.2 86.25,161.06 86.81,161.62 v4(87.94,161.62) ; CB801.2 60.41,67.46 v1(60.42,67.45) ; v4(96.52,162.95) 96.52,163.51 95.78,164.26 CB229.2 ; v1(204.99,47.11) 205.02,47.14 RB328.2 ; CB962.1 v1(101.15,23.2) ; v1(69.31,178.94) 69.59,178.66 C84.1 ; CB266.2 CB267.2 81.99,161.97 v4(82.34,161.62) ; v1(87.47,179.04) CB69.2 ; U40.Y27 v4(30.7,117.65) ; v1(111.15,237.59) 111.15,237.02 111.22,236.95 R1448.2 ; v1(78.23,68.41) C553.2 78.95,67.41 79.21,67.16 CB834.2 ; RB400.2 v1(107.15,37.36) ; UB6.A8 35.77,158.67 v4(35.38,158.29) ; CB1041.2 v1(191.23,228.45) 191.76,228.45 CB1044.2 ; RB389.2 v1(72.94,37.36) ; CB271.2 65.7,160.57 CB284.2 CB257.2 67.42,161.54 v4(67.5,161.62) ; UB6.M9 36.57,167.49 v4(36.97,167.09) 37.09,166.97 37.09,166.41 UB6.K9 ; C590.2 v1(73.35,66.39) ; U52.H1 v3(225.18,122.65) ; CB210.2 82.34,164.02 v4(82.34,164.02) 82.05,164.02 81.81,164.26 CB228.2 RB121.1 ; C878.2 228.59,171.08 v1(228.57,171.1) ; CB135.1 CB125.2 74.92,171.42 74.51,171.83 v1(74.51,171.96) ; C680.2 136.78,64.29 v1(136.8,64.27) ; CB659.1 45.2,108.14 v4(45.7,107.65) ; v4(29.7,119.65) 29.7,119.64 CB513.2 30.19,119.15 v4(30.7,118.65) 31.19,118.15 CB540.2 31.69,117.65 v4(31.7,117.65) ; RB391.2 76.22,37.36 76.55,37.68 v1(76.96,37.68) ; CB724.1 34.7,101.63 v4(34.7,101.65) ; CB234.2 102.64,162.6 ; v4(27.7,132.65) 27.7,132.65 CB354.1 ; CB1119.2 100.62,220.96 100.49,220.83 99.92,220.83 v4(99.29,221.46) ; CB330.2 102.64,163.61 ; CB1006.2 v4(228.18,120.65) ; RB329.2 v1(206.9,46.35) ; UB6.F1 v4(29.77,162.29) ; v1(28.9,64.19) 28.92,64.21 28.92,64.28 28.91,64.29 CB858.2 ; CB682.1 25.68,106.65 v4(25.7,106.65) ; CB855.2 v1(48.27,66.39) ; RB422.2 v1(119.47,37.36) ; CB1081.2 v1(190.47,225.83) ; v4(44.7,134.65) 45.18,134.16 CB356.2 ; v4(51.7,117.65) 52.14,117.2 CB551.1 ; v1(121.67,65.1) 121.7,65.12 CB870.2 ; v4(25.62,158.29) UB5.A8 ; UB5.E9 v4(26.42,161.49) ; CB181.2 100.14,166.47 v4(100.08,166.42) ; v1(89.58,178.69) 89.58,178.64 89.88,178.33 CB75.2 CB76.2 92.65,178.33 CB71.1 93.08,178.35 v1(93.39,178.66) ; CB269.2 102.71,158.6 v1(102.77,158.53) ; CB420.2 40.7,126.65 v4(40.7,126.65) 40.63,126.65 CB412.2 ; RB413.2 v1(29.98,37.35) ; v1(75.45,166.55) 75.2,166.8 CB176.2 ; CB141.2 58.86,171.52 v4(58.56,171.22) ; v4(29.7,130.65) 29.68,130.65 CB385.1 ; CB434.1 53.72,125.65 v4(53.7,125.65) ; UB5.K9 v4(26.42,166.29) ; v1(71.59,161.64) CB263.2 ; v4(24.7,110.65) 24.74,110.65 CB637.1 ; CB177.2 60.74,167.23 61.53,168.02 v4(61.9,168.02) ; v3(121.56,174.55) 121.75,174.74 CB487.2 RB187.1 ; CB377.2 48.7,130.66 v4(48.7,130.65) ; CB775.1 24.25,97.2 v4(24.7,97.65) ; CB623.2 39.69,111.65 v4(39.7,111.65) U40.P18 CB628.2 40.69,110.65 v4(40.7,110.65) 41.2,110.14 CB646.1 41.69,109.65 v4(41.7,109.65) ; v1(230.15,113.14) 230.12,113.17 C783.2 ; C686.2 179.95,64.41 v1(179.97,64.4) ; UB5.A2 v4(20.83,159.09) UB5.B2 ; CB378.2 53.7,131.65 v4(53.7,131.65) 54.19,131.16 CB387.1 ; v4(194.54,189.59) 194.54,189.67 194.93,190.06 CB138.2 195.23,190.2 CB128.2 ; CB1032.2 v3(226.17,128.66) ; v4(29.7,108.65) 29.76,108.65 RB208.1 ; CB104.2 199.08,192.11 v4(199.55,192.58) ; UB6.T1 v4(29.77,171.09) ; UB6.K1 v4(29.77,166.29) ; C91.2 v1(63.47,178.92) ; CB813.2 v1(121.62,68.41) ; CB280.2 48.48,160.63 v4(47.97,160.12) ; CB647.1 58.24,109.87 58.39,110.02 58.39,110.06 v1(58.38,110.06) ; CB863.2 54.05,64.35 v1(54,64.3) ; v4(51.36,164.02) 51.36,164.48 50.69,165.15 CB199.2 CB198.2 ; v4(92.89,166.42) 92.76,166.29 CB193.2 ; CB868.2 109.76,65.12 v1(109.22,65.66) ; RB47.1 v1(97.97,175.87) ; v1(115.97,67.5) 115.93,67.5 115.93,67.54 116.25,67.86 C555.2 ; CB702.1 40.17,104.17 v4(39.7,104.65) ; v4(99.29,158.42) 99.23,158.36 CB313.2 ; CB403.2 53.7,128.61 v4(53.7,128.65) ; v1(88.48,179.04) CB70.2 ; v4(54.78,158.47) 55.34,159.03 CB300.2 CB286.2 CB275.2 ; v4(47.7,111.65) 47.7,111.65 CB616.2 47.2,112.14 v4(46.7,112.65) 46.7,112.65 CB615.2 ; CB379.1 57.21,131.13 v4(57.8,130.54) ; v4(29.7,107.65) 29.78,107.65 CB665.1 ; RB397.2 v1(101.44,37.36) ; v4(35.37,163.09) UB6.G8 UB6.H9 ; CB120.2 RB89.1 100.54,171.68 v4(100.08,171.22) ; RB420.2 v1(50.15,37.36) ; RB209.2 37.7,107.65 v4(37.7,107.65) ; RB421.2 v1(117.74,37.36) ; v1(173.02,64.77) 173.37,65.12 CB878.2 ; CB1018.2 v4(231.18,124.65) ; CB433.2 45.7,124.65 v4(45.7,124.65) 45.2,124.15 CB451.2 44.7,123.65 v4(44.7,123.65) CB468.2 43.7,122.65 v4(43.7,122.65) 43.2,122.15 CB474.2 42.7,121.65 v4(42.7,121.65) CB503.2 41.7,120.65 v4(41.7,120.65) ; RB424.2 v1(123.45,37.36) ; v1(235.4,128.15) CB1031.2 234.68,127.81 R1043.1 ; CB651.1 27.25,109.1 v4(27.7,108.65) ; RB402.2 v1(162.22,37.36) ; RB686.2 v1(91.25,21.21) ; RB392.2 v1(78.65,37.36) ; v4(20.7,107.65) 20.43,107.91 20.43,107.92 20.29,108.06 CB663.1 ; CB114.2 200.04,191.09 v4(199.55,191.58) ; CB1129.2 102.8,214.97 v4(102.29,214.46) ; v4(28.7,134.65) 28.79,134.65 CB350.1 ; CB452.2 v4(46.7,123.65) CB469.1 v4(45.7,122.65) CB484.2 v4(44.7,121.65) CB505.2 v4(43.7,120.65) CB504.2 v4(42.7,119.65) CB532.2 v4(41.7,118.65) 41.7,118.65 CB531.2 ; RB398.2 v1(103.17,37.36) ; C678.2 128.64,64.41 v1(128.66,64.4) ; v1(32.12,179.22) CB64.1 CB63.2 CB62.2 ; UB6.E1 v4(29.77,161.49) ; C882.2 v1(223.47,165.76) 223.83,165.4 C881.2 ; CB214.2 43.91,164.69 44.1,164.88 v1(44.1,165.01) 43.53,165.58 42.38,165.58 42.26,165.71 CB196.2 ; CB262.2 64.23,160.75 64.61,160.37 ; UB6.E8 35.77,161.89 v4(36.16,162.29) 36.56,161.89 UB6.E9 ; CB139.2 14.24,170.28 v1(13.63,169.67) 14.16,169.14 RB98.1 ; CB443.1 v1(80.23,109.95) ; CB580.2 33.7,114.65 v4(33.7,114.65) 33.69,114.65 CB585.1 CB566.2 ; CB278.2 90.38,161.32 89.84,161.32 v4(89.54,161.62) ; RB401.2 v1(160.49,37.36) ; RB399.2 104.72,37.36 105.05,37.68 v1(105.46,37.68) ; CB358.2 54.18,134.16 v4(53.7,134.65) ; CB410.1 44.71,128.65 v4(44.7,128.65) ; C682.2 154.8,64.41 v1(154.82,64.4) ; CB182.2 69.12,166.4 v4(69.1,166.42) ; CB206.2 69.61,164.52 69.31,164.82 CB209.2 68.9,164.22 v4(69.1,164.02) ; RB430.2 v1(147.97,37.36) ; v3(192.94,227.86) 192.89,227.81 CB1082.2 191.23,227.81 CB1079.2 ; v4(40.7,119.65) 40.24,119.18 CB538.2 39.78,118.65 v4(39.7,118.65) 39.2,118.15 CB530.1 ; CB396.2 v4(50.7,128.65) 50.21,129.14 CB397.2 ; v4(24.7,108.65) 24.27,109.08 CB650.1 ; v1(164.51,37.68) 164.1,37.68 163.77,37.36 RB403.2 ; CB640.2 39.69,109.65 v4(39.7,109.65) ; CB273.2 CB254.2 v1(13.81,162.28) ; RB412.2 v1(194.7,37.36) ; CB353.1 24.19,133.16 v4(24.7,132.65) ; RB394.2 v1(88.92,37.36) ; RB390.2 v1(74.67,37.36) ; CB290.2 102.52,159.61 ; v1(150.26,37.68) 149.85,37.68 149.52,37.36 RB431.2 ; v1(116.65,67.22) 116.65,67.17 C602.2 ; CB376.1 26.7,130.65 v4(26.7,130.65) ; v1(87.17,204.49) 87.55,204.88 CB1152.2 ; C560.2 148.51,67.67 v1(148.5,67.66) ; UB6.N1 v4(29.77,168.69) ; R1321.2 v1(225.53,165.66) ; v1(97.19,173.84) CB90.2 ; 71.59,157.58 CB317.2 ; v1(71.59,160.63) CB281.2 ; RB406.2 v1(176.47,37.36) ; C89.2 v1(61.43,178.92) ; CB432.2 43.7,124.66 v4(43.7,124.65) ; C621.2 160.24,66.39 v1(160.24,66.39) ; v4(26.42,167.89) UB5.M9 ; RB410.2 v1(190.72,37.36) ; CB526.2 57.24,119.1 v4(57.7,118.65) ; CB1028.2 v1(235.19,119.64) ; C866.2 229.91,189.78 v1(229.96,189.84) ; CB998.2 v3(230.17,128.66) ; CB221.2 14.5,163.88 15.01,163.36 v1(15.33,163.36) ; CB655.1 41.7,107.72 v4(41.7,107.65) ; v1(185.51,64.72) 185.92,65.12 CB880.2 ; 79.57,101.93 C369.1 ; CB68.1 v1(86.45,179.04) ; v1(180.18,67.31) 180.13,67.36 CB796.2 ; v4(29.7,116.65) 30.17,116.17 CB571.2 ; CB685.1 57.19,106.14 v4(57.7,106.65) ; CB627.2 37.7,110.65 v4(37.7,110.65) ; RB404.2 v1(166.2,37.36) ; CB392.2 43.19,130.16 v4(42.7,130.65) ; RB426.2 v1(133.72,37.36) ; CB958.1 v1(88.44,18.54) ; v1(11.34,164.97) 11.7,165.33 CB201.2 CB186.2 ; CB815.2 v1(136.96,67.48) ; UB6.H1 v4(29.77,163.89) ; CB232.2 CB247.2 ; v4(230.18,120.65) U52.K6 ; C899.2 v1(256.18,85.76) ; CB595.2 24.75,112.65 v4(24.7,112.65) ; 83.28,109.37 CB446.1 ; RB661.2 v1(45.55,22.82) ; v4(106.29,213.46) 105.64,214.1 CB1126.2 ; v1(47.67,64.4) 47.66,64.41 CB861.2 ; RB663.2 v1(118.85,22.82) ; C554.2 v1(109.05,68.41) ; RB425.2 v1(131.99,37.36) ; CB293.2 61.54,159.66 v4(61.9,160.02) 61.39,160.53 RB127.1 ; CB1008.2 v4(230.18,126.65) ; 82.26,109.4 CB445.1 ; C368.1 80.58,101.9 ; v4(36.7,111.65) 36.7,111.65 CB622.2 v4(37.7,112.65) CB610.2 ; UB6.D8 v4(35.36,160.69) ; v4(53.7,110.65) 53.74,110.65 CB635.1 ; v1(155.42,66.39) C616.2 ; RB408.2 v1(180.45,37.36) ; v4(20.7,103.65) 20.73,103.65 CB693.1 ; UB5.T1 v4(19.2,170.27) ; U52.E4 v4(228.18,124.65) ; UB6.C9 v4(36.16,159.89) ; CB1128.2 v4(101.29,219.46) ; C900.2 v1(252.44,85.68) ; C94.2 v1(66.51,178.92)
  BOTTOM w0.508: C930.2 149.27,175.61 v3(149.32,175.56) 149.2,175.45 149.2,173.54 C948.2 ; v1(179.9,150.77) 179.92,150.77 180.36,150.34 CB1102.2 180.14,149.36 179.69,149.82 179.11,149.82 179.07,149.86 179.07,149.85 v1(179.06,149.85) ; CB1096.2 10.25,43.15 9.93,42.83 v1(9.43,42.83) ; v1(255.24,49.76) 255.04,49.57 C952.1 ; CB1101.2 12.94,52.21 14.02,51.13 ; v1(226.83,45.52) 226.82,45.5 R1489.2 ; CB857.2 54.19,67.28 v1(54.19,67.28) ; C518.2 244.31,71.47 v1(244.5,71.66) ; v1(34.26,12.1) 34.83,11.53 CB981.1 ; v1(34.12,239.38) CB13.2 v1(32.15,239.38) ; v1(235.49,66.01) 235.72,65.77 C637.2 ; CB848.2 v1(185.64,66.39) ; C901.2 103.34,229.46 v4(104.31,230.43) ; 119.75,178.48 CB545.2 118.94,177.79 ; v1(225.83,154.02) 224.95,154.02 224.35,153.43 C302.2 v1(225.84,152.98) ; CB1147.2 105.11,208.63 v4(104.29,209.46) ; RB667.1 v1(99.81,26.81) ; CB1087.1 v1(237.96,159.36) ; v1(147.78,187.83) 147.78,187.61 146.53,186.35 C943.2 ; v1(168.98,113.74) 169.04,113.8 C376.2 ; CB1211.2 v1(145.63,172.82) ; CB1066.2 v1(202.78,225.02) ; v1(28.65,67.24) 29.11,66.78 CB852.2 ; v1(102.37,6.15) SWB1.4 v1(97.48,6.15) ; v1(248.89,69.76) 248.57,69.44 C737.1 CB937.1 v1(249.65,69.38) ; CB836.2 v1(109.12,66.39) ; v1(211.12,131.06) 211.18,131.11 CB323.1 ; R675.2 v1(241.14,118.21) ; CB232.2 44.22,163.55 v1(45.37,164.69) ; U85.5 210.73,23.93 211.12,24.32 v1(211.12,24.89) ; R1468.1 123.03,224.38 v1(123.16,224.25) ; v4(206.55,198.58) 206.04,199.09 CB45.2 ; C941.2 146.74,169.06 v1(146.54,168.86) ; CB952.2 v1(99.76,25.87) ; RB1234.2 v1(167.57,149.24) ; CB1099.2 15.7,49.6 ; 15.7,49.6 v1(15.72,49.63) ; 15.7,49.6 15.53,49.43 CB1098.2 ; CB928.2 v1(256.94,36.47) ; C59.1 v1(45.75,221.71) ; C935.2 147.89,173.43 148.46,174 v1(148.46,174.04) ; CB1094.2 14.38,51.92 14.02,51.56 14.02,51.13 ; v1(260.7,163.42) 260.06,164.06 D2.A v1(261.2,164.69) ; U86.5 208.74,15.33 v1(208.71,15.35) ; R1309.2 v1(170.93,158.32) ; C939.2 v1(156.56,180.69) ; R1308.2 v1(174.58,153.32) ; v1(89.35,30.44) CB938.2 90.13,29.47 v1(90.43,29.78) ; R1480.2 207.4,27.47 v1(207.39,27.48) ; v1(62.17,21.46) CB951.2 v1(63.09,20.55) ; v1(44.58,168.32) 44.67,168.22 v2(46.32,168.22) ; C992.1 v1(211.85,17.78) ; v1(63.34,12.29) 63.34,12.29 CB984.1 ; C876.2 230.72,193.01 v1(230.79,192.95) ; C990.1 v1(223.11,43.4) ; v1(212.08,19.79) 211.85,20.02 CB1111.1 ; CB842.2 148.35,66.4 v1(147.89,65.94) ; CB1212.2 v1(141.57,173.07) ; C945.2 v1(154.25,173.49) ; CB1108.2 v1(211.86,15.59) ; CB1103.2 v1(224.04,36.41) ; RB714.1 v1(192.68,12.49) ; C573.2 245.2,64.34 v1(245.73,63.81) ; CB907.2 212.82,78.08 v1(212.79,78.12) ; v1(219.91,145.09) 219.84,145.16 219.84,146.01 220.35,146.52 C316.2 220.95,145.14 v1(220.95,145.13) ; v1(226.34,113.13) 226.38,113.17 C785.2 ; C875.2 v1(226.12,197.49) ; v1(83.67,223.82) CB1178.2 ; v1(96.64,160.34) 96.47,160.17 RB128.1 ; CB28.2 211.06,208.04 v1(211.1,208) ; v1(167.33,64.4) 167.29,64.44 C684.2 ; v1(162.46,178.22) 162.4,178.28 CB1195.2 ; C895.1 v1(230.14,95.09) ; R1483.2 v1(207.32,18.47) ; CB1045.2 CB1043.2 v1(193.38,218.34) ; C326.2 256.12,159.58 v1(255.24,158.7) ; v1(258.74,36.43) 258.74,36.43 CB931.2 ; v1(181.67,143.97) C846.2 181.67,146.64 C845.2 181.68,147.67 C844.2 v1(180.89,147.67) ; CB797.2 v1(235.85,68.66) ; v1(91.07,28.2) LB79.2 89.91,27.24 ; C333.2 v1(238.02,142.78) ; RB262.2 v1(158.99,22.83) ; CB929.2 v1(260.79,36.52) ; v1(257.01,49.76) 256.88,49.76 C956.1 ; C332.2 v1(237.64,144.31) ; C877.2 v1(225.78,196.5) ; v3(151.4,175.56) 151.36,175.52 C942.2 ; CB1136.2 v1(73.47,218.62) ; C940.2 157.49,171.19 v1(157.33,171.03) 157.33,170.8 157.55,170.57 C914.1 R1415.1 ; RB275.2 v1(158.99,21.66) ; R1095.1 v1(188.98,220.55) ; v1(109.06,237.59) 109.25,237.4 RB35.2 ; CB1064.1 v1(204.12,225.78) ; v1(147.67,22.83) 147.65,22.85 RB657.2 ; CB1051.2 189.33,229.34 v1(189.32,229.33) ; v1(237.77,139.42) 237.65,139.55 R677.1 ; CB883.2 v1(178.25,21.46) ; CB1107.1 238.6,74.39 v1(238.92,74.71) 238.22,75.41 C889.1 237.78,76.05 v1(238.6,76.87) ; 14.02,51.13 v1(14.44,50.71) ; RB167.1 38.77,190.29 38.7,190.22 ; C859.2 C855.2 123.54,241.59 v1(123.35,241.4) ; C932.2 141.57,175.36 v1(141.51,175.3) ; v1(24.43,142.03) 23.02,140.62 RB153.2 21.68,140.51 CB345.1 ; C931.2 144.62,184.53 v1(144.07,185.08) ; CB854.2 40.72,66.4 v1(40.72,66.39) ; v1(225.83,151.61) 225.07,151.61 224.35,150.89 C317.2 v1(225.75,150.56) ; v3(149.32,179.73) 149.14,179.9 C929.2 ; CB1072.2 v1(202.85,219.36) ; CB1228.1 v1(73.69,12.16) ; v1(160.24,65.19) 160.3,65.12 C683.2 ; CB1138.2 v1(74.05,224.96) ; CB39.2 v1(45.81,240.19) ; CB1091.1 v1(49.94,221.71) ; RB148.2 25.29,136.57 25.94,135.93 25.94,134.89 v4(25.7,134.65) ; CB1137.2 v1(74.14,215.14) ; v3(149.32,178.69) 148.87,178.24 C949.2 ; v1(135.35,21.56) CB949.2 136.42,22.59 v1(136.3,22.71) ; CB1100.2 10.45,57.05 v1(10.32,57.19) ; C64.1 v1(69.67,186.68) ; v1(141.57,174.41) 141.63,174.34 C947.2 ; CB1076.1 v1(202.02,230.22) ; v1(84.39,20.96) LB83.2 85.59,21.72 v1(85.18,22.13) ; v1(96.1,120.88) 96.1,120.62 95.6,120.11 CB527.2 ; CB383.2 165.12,129.35 v3(165.22,129.26) ; CB954.1 v1(247.68,10.2) ; v1(230.93,132.13) 230.96,132.1 R1070.2 ; v1(147.83,65.1) 147.86,65.13 CB874.2 ; CB1052.2 v1(193.89,231.62) ; v3(149.32,177.65) 148.8,177.13 C933.2 ; v1(141.57,181.96) 142.14,181.39 C946.2 ; C955.1 v1(214.86,9.81) ; CB1042.2 v1(185.19,230.54) ; CB1109.1 v1(211.86,11.34) ; C25.1 v1(70.06,222.47) ; SWB1.2 v1(101.06,12.16) ; R1463.1 108.16,203.92 v1(107.34,203.11) ; CB1070.1 v1(204.12,218.03) ; CB864.2 66.63,64.24 v1(66.5,64.12) ; v1(89.69,26.2) RB652.1 v1(88.61,26.45) ; C868.2 v1(234.53,196) ; v1(240.05,124.69) 240.04,124.69 R1195.1 ; RB332.2 v1(206.98,42.9) ; CB982.1 v1(44.35,12.1) ; v1(8.47,44.74) CB1097.2 9.62,43.85 v1(9.36,43.6) ; v3(152.44,175.56) 152.36,175.48 C936.2 ; C894.2 v1(226.33,95.02) ; RB743.1 v1(158.94,9.04) ; CB1113.1 104.5,216.24 v4(104.29,216.46) ; C957.1 223.1,32.51 v1(223.11,32.49) ; CB979.1 v1(61.31,12.23) ; v1(198.95,140.92) 198.89,140.92 198.41,140.44 C849.2 ; C854.2 v1(133.75,257.79) ; v1(94.71,237.53) 94.26,237.08 R1450.2 ; CB846.2 v1(173.01,66.39) ; CB1229.1 v1(71.66,12.1) ; v1(108.17,172.57) 108.12,172.51 CB334.2 v1(106.64,172.51) ; CB1039.2 v1(185.17,222.33) ; v1(65.8,66.39) 65.8,66.4 CB832.2 ; C896.1 222.52,94.77 222.66,94.9 v1(222.66,94.97) ; C867.2 v1(234.66,190.79) ; v1(122.42,67.35) 122.6,67.16 CB838.2 ; CB1040.2 v1(184.18,230.6) ; v1(222.74,143.62) C322.2 v1(221.97,144.31) ; RB742.1 v1(158.99,7.95) ; CB104.2 199.06,192.07 v4(199.55,191.58) ; RB1226.2 9.18,45.94 v1(9.24,45.88) ; CB899.2 v1(211.75,74.58) ; v1(130.03,64.28) 130.54,64.79 CB872.2 ; v1(134.27,256.07) 133.96,255.76 C857.2 ; v1(172.29,104.16) 172.74,103.71 CB712.1 ; C483.1 3.3,147.83 v1(1.3,145.83) ; R1307.2 169.57,153.63 v1(168.94,152.99) ; CB1078.2 v1(203.29,230.22) ; C989.1 206.49,10.14 v1(206.43,10.21) ; CB124.2 92.19,172.43 92.84,173.07 93.99,173.07 94.45,173.54 v1(94.45,173.63) ; CB1048.2 v1(193.89,232.64) ; v3(150.36,175.56) 150.1,175.31 C937.2 ; RB672.2 v1(116.27,21.69) ; CB977.1 v1(48.42,12.04) ; RB323.2 v1(207.97,42.81) ; C954.1 v1(213.87,26.62) ; v3(163.49,116.49) 162.65,117.33 CB584.2 ; v1(46.38,12.1) 46.39,12.1 CB983.1 ; v1(167.93,66.39) 167.92,66.4 C622.2 ; C370.1 45.88,182.41 ; v1(74.39,22.83) 74.37,22.85 RB653.2 ; C853.2 v1(133.75,256.77) ; v1(36.49,239.38) CB12.2 v1(38.31,239.38) ; v3(117.35,140.51) 116.75,139.91 C236.2 ; C944.2 v1(148.36,182.09) ; CB950.1 v1(242.34,10.2) ; U36.1 v1(227.98,141.5) ; CB985.2 v1(178.02,7.72) ; CB834.2 v1(78.31,66.39) ; C858.2 v1(123.35,239.56) ; v1(83.53,237.02) 83.9,236.65 CB1120.2 ; CB942.1 v1(243.36,10.2) ; CB809.2 v1(85.44,67.28) ; CB953.1 v1(248.69,10.2) ; C986.2 v1(105.06,251.11) ; CB35.2 v1(49.94,240.19) ; v1(129.97,67.01) 130.71,66.27 CB840.2 ; v1(156.05,182.09) C938.2 ; CB1037.2 v1(184.15,222.37) ; U88.5 v1(225.39,38.17) ; CB122.2 v1(80.69,172.33) ; SWB1.3 v1(105.29,6.15) ; CB1104.1 v1(227.73,37.18) ; C864.2 v1(234.53,199.74) ; C856.2 v1(123.35,240.57) ; CB1110.1 v1(211.85,24.1) ; C870.2 v1(231.99,197.01)
  vias: v1(1.3,257.59) v1(1.3,252.51) v1(1.3,247.43) v1(1.3,242.35) v1(1.3,237.27) v1(1.3,232.19) v1(1.3,227.11) v1(1.3,222.03) v1(1.3,216.95) v1(1.3,211.87) v1(1.3,206.79) v1(1.3,201.71) v1(1.3,196.63) v1(1.3,191.55) v1(1.3,186.47) v1(1.3,181.39) v1(1.3,176.31) v1(1.3,171.23) v1(1.3,166.15) v1(1.3,161.07) v1(1.3,155.99) v1(1.3,150.91) v1(1.3,140.75) v1(1.3,135.67) v1(1.3,130.59) v1(1.3,125.51) v1(1.3,120.43) v1(1.3,115.35) v1(1.3,110.27) v1(1.3,105.19) v1(1.3,100.11) v1(1.3,95.03) v1(1.3,89.95) v1(1.3,84.87) v1(1.3,79.79) v1(1.57,7.06) v1(1.87,261.85) v1(4.34,114.29) v1(4.35,111.7) v1(5.28,7.82) v1(6.47,113.1) v1(6.47,112.33) v1(6.95,261.85) v1(7.26,103.35) v1(7.26,102.51) v1(9.11,157.72) v1(9.07,120.44) v1(12.03,261.85) v1(14.44,115.35) v1(15.18,133.16) v1(15.67,136.83) v1(16.35,153.01) v1(16.35,152.3) v1(16.35,151.56) v1(16.37,150.87) v1(16.98,176.38) v1(17.03,99.24) v1(16.98,97.18) v1(17.11,261.85) v1(17.34,145.23) v1(17.31,144.55) v1(17.31,141.15) v1(17.26,95.55) v1(17.26,94.79) v1(17.36,139.01) v1(19.93,89.48) v1(21.73,89.46) v1(22.19,261.85) v1(24.26,90.66) v1(24.26,89.89) v1(24.51,145.14) v1(24.51,144.45) v1(25.93,4.72) v1(27.27,261.85) v1(29.54,137.87) v1(29.52,137.19) v1(31.01,4.72) v1(31.22,140.87) v1(31.22,140.19) v1(31.59,189.08) v1(32.35,261.85) v1(32.48,189.08) v1(33.37,189.08) v1(36.4,93.7) v1(36.4,93.02) v1(36.43,91.26) v1(36.43,90.58) v1(36.45,89.89) v1(36.8,187.55) v1(37.18,189.01) v1(37.43,261.85) v1(39.02,189.14) v1(39.02,188.25) v1(39.06,167.1) v1(39.39,153.77) v1(39.41,153.08) v1(39.41,152.4) v1(39.44,151.71) v1(39.44,150.98) v1(39.84,93.65) v1(39.84,92.89) v1(39.88,91.26) v1(39.88,90.58) v1(39.88,89.89) v1(41.17,4.72) v1(42.13,181.14) v1(42.13,180.31) v1(42.19,178.09) v1(42.19,177.26) v1(42.51,261.85) v1(43.21,181.14) v1(43.21,180.31) v1(43.2,170.2) v1(43.27,178.09) v1(43.27,177.26) v1(44.29,181.14) v1(44.29,180.31) v1(44.35,178.09) v1(44.35,177.26) v1(44.48,172.69) v1(44.54,171.49) v1(44.54,170.6) v1(44.54,169.64) v1(47.42,4.75) v1(47.59,261.85) v1(47.75,89.13) v1(48.52,89.13) v1(49.23,192.22) v1(49.24,89.13) v1(50,89.13) v1(50.77,89.13) v1(51.33,4.72) v1(51.65,157.33) v1(51.65,156.61) v1(51.65,155.93) v1(52.42,156.69) v1(52.42,155.98) v1(52.67,261.85) v1(57.03,93.45) v1(57.01,89.19) v1(57.75,261.85) v1(57.79,93.45) v1(57.77,89.19) v1(58.14,95.76) v1(58.55,93.45) v1(58.53,89.19) v1(58.9,95.76) v1(59.31,93.45) v1(59.3,89.19) v1(59.67,95.76) v1(60.2,93.45) v1(61.11,93.37) v1(61.49,4.72) v1(61.65,93.94) v1(62.1,186.75) v1(62.1,185.98) v1(62.83,261.85) v1(63.65,116.59) v1(64.36,116.59) v1(65.17,159.48) v1(67.53,196.38) v1(67.47,102.53) v1(67.79,4.98) v1(67.91,261.85) v1(68.16,180.63) v1(68.16,102.53) v1(68.99,180.57) v1(69.82,156.69) v1(69.82,156) v1(69.82,155.32) v1(70.07,196.5) v1(70.63,186.64) v1(70.58,156.69) v1(70.58,156) v1(70.58,155.32) v1(70.65,187.37) v1(70.87,116.56) v1(71.34,156.69) v1(71.34,156) v1(71.34,155.32) v1(71.52,186.66) v1(71.51,102.33) v1(71.6,196.44) v1(71.63,116.56) v1(71.65,4.72) v1(72.33,102.33) v1(72.36,119.1) v1(72.36,118.21) v1(72.36,117.45) v1(72.39,116.56) v1(72.48,125.96) v1(72.48,125.19) v1(72.48,124.43) v1(72.99,261.85) v1(73.24,220.7) v1(73.56,192.63) v1(73.75,125.96) v1(73.75,125.27) v1(73.75,124.56) v1(74.64,192.63) v1(74.81,126.01) v1(74.78,125.33) v1(74.78,124.61) v1(75.47,196.44) v1(75.78,124.94) v1(76.29,196.44) v1(76.55,124.94) v1(76.73,4.72) v1(77.31,124.94) v1(78.07,261.85) v1(78.07,124.94) v1(78.96,124.94) v1(79.34,111.48) v1(79.34,110.72) v1(79.34,109.95) v1(79.72,124.94) v1(80.1,99.03) v1(80.1,98.27) v1(80.23,111.48) v1(80.23,110.72) v1(80.48,124.94) v1(80.86,99.03) v1(80.86,98.27) v1(81.25,124.94) v1(81.63,99.03) v1(81.63,98.27) v1(81.81,4.72) v1(82.01,124.94) v1(82.39,99.03) v1(82.39,98.27) v1(82.81,137.39) v1(82.81,136.71) v1(82.81,135.99) v1(83.02,126.59) v1(83.02,125.83) v1(83.02,125.07) v1(83.02,124.31) v1(83.15,261.85) v1(83.57,137.39) v1(83.57,136.71) v1(83.57,135.99) v1(83.79,126.59) v1(83.79,125.83) v1(83.79,125.07) v1(83.79,124.31) v1(84.29,110.72) v1(84.29,109.95) v1(84.74,137.14) v1(84.74,136.45) v1(84.99,74.39) v1(85.42,137.14) v1(85.42,136.45) v1(86.89,4.72) v1(88.23,261.85) v1(90.9,179.02) v1(91.28,99.26) v1(91.41,98.57) v1(91.66,179.02) v1(91.97,4.72) v1(93.06,106.02) v1(93.31,261.85) v1(93.75,106.53) v1(94.15,178.74) v1(96.87,112.11) v1(96.87,111.35) v1(97.05,4.72) v1(97.81,135.53) v1(97.76,120.55) v1(97.76,119.86) v1(97.88,127.35) v1(97.95,125.77) v1(98.01,126.57) v1(98.11,137.78) v1(98.07,124.94) v1(98.07,123.48) v1(98.39,261.85) v1(98.57,135.53) v1(98.58,127.42) v1(98.64,123.92) v1(98.64,123.04) v1(98.62,120.6) v1(98.62,119.91) v1(98.71,125.83) v1(98.9,98.78) v1(99.33,135.53) v1(99.38,120.6) v1(99.38,119.91) v1(99.53,123.92) v1(99.53,123.04) v1(99.81,147.29) v1(99.84,137.67) v1(100.55,147.32) v1(100.55,14.83) v1(100.55,14.01) v1(100.61,13.24) v1(100.65,137.67) v1(101.06,97.13) v1(101.57,14.83) v1(101.63,13.94) v1(101.63,13.24) v1(101.79,147.32) v1(101.82,97.13) v1(101.95,137.69) v1(102.53,147.34) v1(102.58,97.13) v1(102.73,137.67) v1(102.77,157.83) v1(103.34,97.13) v1(103.47,261.85) v1(103.52,147.29) v1(103.57,137.67) v1(103.85,148.82) v1(104.11,97.13) v1(104.16,25.52) v1(104.26,147.32) v1(104.36,137.67) v1(104.89,131.26) v1(104.89,130.5) v1(105.15,147.27) v1(105.31,4.7) v1(105.88,147.29) v1(106.39,158.98) v1(106.52,158.09) v1(106.7,157.24) v1(107.15,158.98) v1(107.28,158.09) v1(107.46,157.24) v1(107.89,147.22) v1(108.04,158.98) v1(108.17,158.09) v1(108.35,157.24) v1(108.55,261.85) v1(108.63,147.24) v1(108.93,158.98) v1(109.06,158.09) v1(109.24,157.24) v1(109.95,179.17) v1(110.96,179.93) v1(111.03,179.17) v1(112.11,155.93) v1(112.11,154.91) v1(112.11,154.02) v1(112.17,179.17) v1(113.63,261.85) v1(114.29,4.89) v1(114.65,155.93) v1(114.65,154.02) v1(116.03,178.29) v1(116.96,104.62) v1(116.96,103.86) v1(116.96,103.1) v1(116.96,102.33) v1(117.19,155.93) v1(117.19,154.91) v1(117.19,153.9) v1(117.57,104.19) v1(117.62,103.38) v1(117.57,102.66) v1(117.95,111.92) v1(118.71,261.85) v1(118.71,111.99) v1(118.77,91.16) v1(119.37,4.89) v1(119.47,111.99) v1(119.58,177.59) v1(119.62,91.2) v1(119.65,92.16) v1(120.01,103.1) v1(120.01,102.33) v1(120.49,92.19) v1(120.51,91.2) v1(121.5,183.11) v1(121.5,182.22) v1(121.63,111.99) v1(122.39,183.11) v1(122.39,182.22) v1(122.39,155.67) v1(122.39,154.91) v1(122.39,154.02) v1(122.52,103.1) v1(122.52,102.08) v1(122.85,171.64) v1(123.28,183.11) v1(123.28,182.22) v1(123.35,166.28) v1(123.28,103.1) v1(123.28,102.08) v1(123.79,261.85) v1(123.87,172.33) v1(124.11,166.28) v1(124.45,4.89) v1(125.19,155.42) v1(125.19,154.53) v1(125.95,166.47) v1(128.87,261.85) v1(129.53,4.89) v1(129.7,167.87) v1(131.98,240.45) v1(131.98,239.75) v1(132.87,240.45) v1(132.87,239.75) v1(133.95,261.85) v1(134.59,126.21) v1(134.59,125.45) v1(134.59,124.69) v1(134.59,123.92) v1(134.59,123.16) v1(134.59,122.4) v1(134.59,121.64) v1(134.59,120.88) v1(134.59,120.11) v1(134.59,119.35) v1(134.59,118.59) v1(134.61,4.89) v1(134.79,131.24) v1(134.79,129.72) v1(134.79,128.19) v1(135.55,131.24) v1(135.55,129.72) v1(135.55,128.19) v1(135.6,126.21) v1(135.6,125.45) v1(135.6,124.69) v1(135.6,123.92) v1(135.6,123.16) v1(135.6,122.4) v1(135.6,121.64) v1(135.6,120.88) v1(135.6,120.11) v1(135.6,119.35) v1(135.6,118.59) v1(135.6,117.57) v1(136.68,260.26) v1(137.51,260.26) v1(139.03,261.85) v1(139.69,4.89) v1(141.5,180.96) v1(144.77,4.89) v1(149.19,261.85) v1(149.85,4.89) v1(150.46,86.21) v1(151.48,86.21) v1(152.49,86.21) v1(152.61,88.76) v1(153.37,88.73) v1(153.76,86.21) v1(154.27,261.85) v1(154.4,115.54) v1(154.4,114.53) v1(154.4,113.51) v1(154.4,112.49) v1(154.4,111.48) v1(154.93,4.89) v1(155.16,115.54) v1(155.16,114.53) v1(155.16,113.51) v1(155.16,112.49) v1(155.16,111.48) v1(155.92,115.54) v1(155.92,114.53) v1(155.92,113.51) v1(155.92,112.49) v1(155.92,111.48) v1(156.68,115.54) v1(156.68,114.53) v1(156.68,113.51) v1(156.68,112.49) v1(156.87,106.19) v1(156.87,105.48) v1(156.87,104.8) v1(157.45,115.54) v1(157.45,114.53) v1(157.45,113.51) v1(157.45,112.49) v1(158.21,114.53) v1(158.21,113.51) v1(158.21,112.49) v1(158.36,129.89) v1(158.36,129.13) v1(158.97,114.53) v1(158.97,113.51) v1(158.97,112.49) v1(159.35,261.85) v1(159.99,114.53) v1(159.99,113.51) v1(160.01,4.89) v1(160.3,105.94) v1(160.3,105.18) v1(160.3,104.04) v1(160.75,114.53) v1(160.75,113.51) v1(161.19,105.94) v1(161.19,105.18) v1(161.19,104.04) v1(161.76,114.53) v1(161.76,113.51) v1(162.07,105.94) v1(162.07,105.18) v1(162.07,104.04) v1(162.53,114.53) v1(162.53,113.51) v1(162.97,126.92) v1(163.41,114.77) v1(164.43,261.85) v1(164.43,114.77) v1(165.09,4.89) v1(166.08,114.78) v1(167.16,114.02) v1(167.16,113) v1(167.86,113) v1(168.21,113.74) v1(168.3,105.81) v1(168.3,104.8) v1(168.88,113) v1(169.51,261.85) v1(169.76,113.7) v1(169.89,113) v1(170.17,4.89) v1(170.45,113.74) v1(170.71,96.29) v1(170.71,95.6) v1(170.71,94.56) v1(170.71,93.88) v1(170.91,113) v1(171.24,113.76) v1(171.29,261.66) v1(171.29,132.5) v1(171.47,96.29) v1(171.47,95.6) v1(171.54,94.71) v1(171.6,105.94) v1(171.6,105.05) v1(171.6,104.16) v1(171.92,113) v1(172.05,132.5) v1(172.15,113.79) v1(172.29,105.94) v1(172.29,105.05) v1(172.94,113) v1(172.94,112.24) v1(173.01,113.81) v1(173,105.94) v1(173.96,113.76) v1(173.96,113) v1(173.96,112.24) v1(173.96,111.48) v1(174.59,261.85) v1(174.97,113.76) v1(174.97,113) v1(174.97,112.24) v1(174.97,111.48) v1(175.25,4.89) v1(176.04,255.31) v1(177.28,255.39) v1(177.51,205.33) v1(178.69,255.39) v1(179.67,261.85) v1(180.33,4.89) v1(184.7,195.73) v1(184.75,261.85) v1(185.41,4.89) v1(186.26,178.92) v1(187.8,133.83) v1(187.8,133.07) v1(188.56,133.83) v1(188.56,133.07) v1(189.32,133.83) v1(189.32,133.07) v1(189.83,261.85) v1(190.49,4.89) v1(194.91,261.85) v1(195.57,4.89) v1(196.62,7.47) v1(198.72,141.64) v1(199.55,216.56) v1(199.71,140.87) v1(199.93,138.4) v1(199.99,261.85) v1(200.82,139.23) v1(200.82,138.4) v1(201.32,225.91) v1(201.39,219.62) v1(201.45,224.89) v1(201.45,224.06) v1(201.72,138.43) v1(202.09,225.91) v1(202.15,219.62) v1(203.1,131.1) v1(205.07,261.85) v1(208.93,111.19) v1(208.93,110.43) v1(210.15,261.85) v1(210.4,154.66) v1(210.47,157.33) v1(210.47,153.64) v1(210.53,151.17) v1(210.53,150.02) v1(211.74,153.71) v1(211.74,151.23) v1(211.67,149.96) v1(211.8,157.33) v1(211.8,154.66) v1(215.23,261.85) v1(216.82,111.16) v1(216.82,110.4) v1(219.41,251.72) v1(220.31,261.85) v1(224.17,171.94) v1(224.66,1.51) v1(225.39,261.85) v1(229.74,1.51) v1(230.47,261.85) v1(230.85,133.2) v1(231.11,138.15) v1(231.61,134.47) v1(231.99,138.15) v1(233.01,133.7) v1(234.82,1.51) v1(235.55,261.85) v1(239.14,78.49) v1(239.9,74.37) v1(239.9,1.51) v1(239.97,241.47) v1(240.46,67.84) v1(240.63,261.85) v1(240.68,109.52) v1(241.04,241.34) v1(241.05,78.49) v1(242.57,78.49) v1(242.82,85.22) v1(244.6,85.22) v1(244.98,1.51) v1(245.24,78.49) v1(245.71,261.85) v1(246.08,167.47) v1(246.11,166.45) v1(246.14,165.41) v1(247.28,167.47) v1(247.31,166.45) v1(247.33,165.41) v1(248.37,166.44) v1(248.84,159.59) v1(248.84,158.72) v1(249.52,165.2) v1(249.57,166.44) v1(249.98,159.59) v1(249.98,158.72) v1(250.06,1.51) v1(250.5,217.61) v1(250.5,207.02) v1(250.79,261.85) v1(250.92,166.6) v1(250.87,159.59) v1(250.87,158.72) v1(251.51,216.4) v1(251.64,208.1) v1(252.19,166.6) v1(254.05,158.7) v1(254.05,157.83) v1(255.14,1.51) v1(255.24,157.83) v1(255.87,261.85) v1(257.65,157.83) v1(260.22,1.51) v1(260.95,261.85) v1(265.3,1.51) v1(268.11,15.57) v1(268.11,10.49) v1(268.11,5.41) v1(268.32,260.83) v1(268.32,255.75) v1(268.32,250.67) v1(268.32,245.59) v1(268.32,240.51) v1(268.32,235.43) v1(268.32,230.35) v1(268.32,225.27) v1(268.32,220.19) v1(268.32,215.11) v1(268.32,210.03) v1(268.32,204.95) v1(268.32,199.87) v1(268.32,194.79) v1(268.32,189.71) v1(268.32,184.63) v1(268.32,174.47) v1(268.32,169.39) v1(268.32,164.31) v1(268.32,159.23) v1(268.32,154.15) v1(268.32,149.07) v1(268.32,143.99) v1(268.32,138.91) v1(268.32,133.83) v1(268.32,128.75) v1(268.32,123.67) v1(268.32,118.59) v1(268.32,113.51) v1(268.32,108.43) v1(268.32,103.35) v1(268.32,93.19) v1(268.32,88.11) v1(268.32,83.03) v1(268.32,77.95) v1(268.32,72.87) v1(268.32,67.79) v1(268.32,62.71) v1(268.32,57.63) v1(268.32,47.47) v1(268.32,42.39) v1(268.32,37.31) v1(268.32,32.23) v1(268.32,27.15) v1(268.32,22.07) v2(31.35,191.86) v2(40.35,181.52) v2(68.67,156.31) v2(99.86,130.78) v2(104.11,163.1) v2(107.15,146.59) v2(170.05,95.07) v3(5.28,50.14) v3(7.57,50.12) v3(9.97,50.12) v3(11.6,112.39) v3(11.6,110.31) v3(12.94,106.68) v3(12.94,104.59) v3(12.94,103.88) v3(12.94,101.8) v3(13.16,114.96) v3(13.18,112.73) v3(14.85,108.96) v3(14.85,106.88) v3(14.91,50.14) v3(16.27,103.88) v3(16.27,101.8) v3(16.6,106.68) v3(16.6,104.59) v3(18.35,115.42) v3(18.35,113.33) v3(39.06,204.1) v3(40.23,190.37) v3(40.23,189.53) v3(40.23,188.69) v3(40.23,187.86) v3(40.23,187.02) v3(41.05,204.1) v3(41.02,189.53) v3(41.02,188.69) v3(41.02,187.86) v3(41.02,187.02) v3(41.36,64.34) v3(59.83,113.59) v3(59.83,110.15) v3(64.74,123.08) v3(64.86,119.56) v3(65.58,186.87) v3(66.5,186.87) v3(67.41,186.87) v3(73.47,165.28) v3(73.47,163.19) v3(73.5,162.51) v3(73.5,160.42) v3(74.51,190.47) v3(74.51,188.48) v3(75.96,188.19) v3(75.96,186.2) v3(83.87,217.86) v3(83.87,215.87) v3(85.53,188.33) v3(88.31,23.59) v3(90.8,23.59) v3(92.29,217.57) v3(92.29,216.08) v3(94.08,188.56) v3(94.52,99.22) v3(94.52,98.08) v3(96.07,188.56) v3(97.72,133.92) v3(97.72,132.93) v3(97.72,131.93) v3(97.72,130.95) v3(97.72,129.96) v3(97.72,118.17) v3(97.72,116.18) v3(97.72,115.2) v3(97.72,114.21) v3(98.74,133.92) v3(98.74,132.93) v3(98.74,131.94) v3(98.74,130.95) v3(98.74,129.96) v3(98.74,118.17) v3(98.74,117.18) v3(98.74,116.19) v3(98.74,115.2) v3(98.74,114.21) v3(101.76,187.95) v3(103,206.77) v3(103.81,180.42) v3(104.1,187.95) v3(104.37,189.37) v3(104.58,206.77) v3(105.75,155.49) v3(105.75,153.91) v3(105.94,189.37) v3(109.1,206.67) v3(110.67,206.67) v3(113.24,104.76) v3(113.24,103.93) v3(113.24,103.09) v3(113.24,102.25) v3(114.02,104.76) v3(114.02,103.93) v3(114.02,103.09) v3(114.02,102.25) v3(114.02,101.41) v3(117.35,139.37) v3(117.7,221.18) v3(117.7,219.79) v3(117.81,202.34) v3(118.21,174.55) v3(118.21,173.76) v3(118.49,140.51) v3(118.49,139.37) v3(119.05,174.55) v3(119.05,173.76) v3(119.89,174.55) v3(119.89,173.76) v3(120.14,202.34) v3(120.73,174.55) v3(120.73,173.76) v3(121.56,173.76) v3(135.72,181.93) v3(135.76,183.31) v3(135.92,176.65) v3(135.92,175.17) v3(137.01,245.64) v3(137.21,174.37) v3(137.21,172.89) v3(137.21,171.58) v3(137.21,170.35) v3(137.16,169.09) v3(137.16,167.61) v3(139,245.64) v3(139.14,247.88) v3(141.94,247.88) v3(145.88,143.16) v3(146.53,137.97) v3(146.53,136.39) v3(147.45,143.16) v3(149.32,180.77) v3(149.32,176.6) v3(150.21,136.15) v3(150.21,134.58) v3(150.36,180.77) v3(150.36,179.73) v3(150.36,178.69) v3(150.36,177.65) v3(150.36,176.6) v3(151.15,97.69) v3(151.4,180.77) v3(151.4,179.73) v3(151.4,178.69) v3(151.4,177.65) v3(151.4,176.6) v3(151.73,137.81) v3(151.73,136.23) v3(152.44,180.77) v3(152.44,179.73) v3(152.44,178.69) v3(152.44,177.65) v3(152.44,176.6) v3(152.62,143.75) v3(152.62,141.92) v3(153.48,180.77) v3(153.48,179.73) v3(153.48,178.69) v3(153.48,177.65) v3(153.48,176.6) v3(153.48,175.56) v3(154.52,180.77) v3(154.52,179.73) v3(154.52,178.69) v3(154.52,177.65) v3(154.52,176.6) v3(154.52,175.56) v3(155.28,143.61) v3(155.28,142.04) v3(155.9,154.14) v3(157.48,154.14) v3(157.58,105.25) v3(158.32,105.94) v3(158.32,105.23) v3(158.33,104.49) v3(158.47,150.45) v3(158.47,149.02) v3(159.08,105.94) v3(159.08,105.23) v3(159.08,104.6) v3(159.09,103.96) v3(163.91,159.36) v3(164.02,117.25) v3(164.13,116.5) v3(164.78,118) v3(164.76,117.26) v3(164.76,116.5) v3(165.38,159.36) v3(165.47,117.26) v3(165.47,116.5) v3(167.4,158.45) v3(167.86,142.81) v3(167.86,141.24) v3(168.98,158.45) v3(169.01,105.25) v3(169.75,105.94) v3(169.75,105.23) v3(169.76,104.49) v3(170.51,105.94) v3(170.51,105.23) v3(170.51,104.6) v3(170.52,103.96) v3(172.61,133) v3(172.9,131.87) v3(173.31,142.39) v3(174.3,131.87) v3(174.79,132.64) v3(174.88,142.39) v3(175.75,149.06) v3(175.75,147.49) v3(176.27,142.62) v3(176.27,141.15) v3(179.2,149.18) v3(179.2,147.61) v3(182.15,141.25) v3(182.19,142.79) v3(186.23,142.75) v3(186.23,141.18) v3(196.07,223.11) v3(196.1,220.95) v3(202.17,128.38) v3(202.17,126.3) v3(204.25,118.32) v3(205.68,127.5) v3(205.68,126.71) v3(205.68,125.93) v3(205.68,125.14) v3(205.93,118.32) v3(206.47,127.5) v3(206.47,126.71) v3(206.47,125.93) v3(206.47,125.14) v3(207.26,127.5) v3(207.26,126.71) v3(207.26,125.93) v3(207.26,125.14) v3(208.05,127.5) v3(208.05,126.71) v3(208.05,125.93) v3(208.05,125.14) v3(218.72,96.89) v3(218.72,94.4) v3(218.98,14.56) v3(218.98,12.57) v3(220.34,98.98) v3(221.01,22.04) v3(221.01,20.06) v3(221.92,98.98) v3(222.86,99.21) v3(223.83,104.21) v3(223.9,27.43) v3(224.44,99.21) v3(225.07,97.41) v3(225.66,104.21) v3(225.86,103.11) v3(225.89,27.43) v3(227.05,28.77) v3(227.43,103.11) v3(227.5,132.1) v3(227.56,97.41) v3(228.99,144.16) v3(228.99,143.4) v3(229.04,28.77) v3(229.69,220.64) v3(229.69,219.49) v3(229.69,218.35) v3(229.88,144.16) v3(229.88,143.4) v3(229.88,142.64) v3(229.9,132.1) v3(230.65,130.3) v3(230.83,220.64) v3(230.83,219.49) v3(230.83,218.35) v3(231.63,135.99) v3(231.63,103.26) v3(231.97,220.64) v3(231.97,219.49) v3(231.97,218.35) v3(232.83,130.12) v3(233.2,103.26) v3(233.4,104.35) v3(235.23,104.35) v3(242.32,106.21) v3(242.32,104.64) v3(248.5,104.53) v3(248.57,58.17) v3(248.93,163.99) v3(248.93,163.05) v3(248.93,162.11) v3(248.93,161.18) v3(248.92,94.74) v3(249.84,163.99) v3(249.84,163.05) v3(249.84,162.11) v3(249.84,161.18) v3(249.81,46.99) v3(250.44,58.17) v3(250.67,29.13) v3(250.67,27.71) v3(251.04,104.53) v3(250.96,94.63) v3(251.28,57.3) v3(251.33,48.77) v3(251.87,48.04) v3(252.48,94.63) v3(252.63,105.27) v3(252.59,90.68) v3(252.59,88.19) v3(252.66,29.13) v3(252.66,27.71) v3(253.43,92.78) v3(253.43,91.2) v3(253.39,48.04) v3(253.45,27.71) v3(253.67,88.92) v3(253.67,86.38) v3(253.82,57.3) v3(254.2,105.27) v3(254.36,95.52) v3(255.44,27.71) v3(256.19,95.52) v3(256.38,94.38) v3(256.46,105.34) v3(258.04,105.34) v3(257.96,94.38) v3(259.08,92.8) v3(259.08,91.22)
