# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MGMT_MDI_N1_R: length 29.3
  TOP w0.095: R960.1 245.45,102.66 C714.2 245.82,101.29 245.82,101.09 246.89,100.03 249.46,100.03 249.75,99.74 249.75,99.6 arc(249.74,99.54) 249.7,99.49 249.48,99.27 arc(249.37,98.99) 249.48,98.71 249.52,98.67 arc(249.57,98.59) 249.59,98.5 ; v3(252.67,91.58) 252.96,91.88 254.86,91.88 258.91,87.83 258.91,85.56 258.81,85.47 258.57,85.47 258.39,85.29 U70.6 ; U55.6 249.59,95.54 v3(249.41,95.35) ; 249.5,97.66 249.5,98.04
  S12 w0.108: v3(249.41,95.35) 249.67,95.08 249.67,93.37 251.17,91.88 252.38,91.88 v3(252.67,91.58)
  BOTTOM w0.095: v3(252.67,91.58) 252.35,91.91 252.08,91.91 251.56,91.39 U62.7
MGMT_MDI_N2: length 130.2
  TOP w0.095: R962.2 257.21,103.96 257.21,104.26 v3(256.84,104.63) ; J2.A6 146.44,140.51 146.55,140.62 146.55,142.11 v3(146.26,142.4)
  S9 w0.108: v3(146.26,142.4) 146.5,142.16 arc(146.54,142.09) 146.56,142.01 146.56,141.76 arc(146.62,141.46) 146.79,141.2 147.81,140.19 arc(148.07,140.01) 148.37,139.95 153.62,139.95 arc(154.44,139.79) 155.15,139.32 arc(156.84,138.19) 158.83,137.79 174.71,137.79 arc(177.28,137.28) 179.46,135.83 191.42,123.86 arc(192.26,123.3) 193.26,123.1 202.22,123.1 arc(204.56,122.64) 206.53,121.32 214.85,113 arc(215.27,112.72) 215.77,112.62 215.93,112.62 arc(216.32,112.54) 216.64,112.33 217.06,111.91 arc(217.47,111.64) 217.95,111.54 219.73,111.54 arc(220.08,111.47) 220.38,111.27 220.83,110.83 arc(221.27,110.53) 221.8,110.43 241.17,110.43 arc(241.82,110.3) 242.37,109.93 244.87,107.43 arc(245.22,107.19) 245.64,107.11 254.17,107.11 arc(255.26,106.89) 256.19,106.28 257.19,105.28 arc(257.25,105.18) 257.28,105.06 arc(257.15,104.76) v3(256.84,104.63)
MGMT_MDI_N2_GE: length 71.8
  TOP w0.095: U70.16 254.58,68.51 255.1,67.99 255.1,67.4 v3(254.75,67.06)
  S7 w0.108: v3(254.75,67.06) 255.04,66.76 255.04,64.84 258.87,61 258.87,50.24 265.3,43.81 265.3,22.21 264.49,21.41 264.49,16.49 263.8,15.79 263.8,14.03 262.83,13.06 258.43,13.06 258.07,13.42 258.07,14.74 259,15.67 259.48,15.67 259.84,15.31 259.84,14.91 RJ1.E5
MGMT_MDI_N2_R: length 28.2
  TOP w0.095: v3(252.59,89.03) 252.84,89.28 253.24,89.28 253.3,89.35 253.87,89.35 255.1,88.12 255.1,85.56 255,85.47 254.68,85.47 254.58,85.37 U70.9 ; v3(256.77,95.14) 257.05,95.42 257.05,95.82 256.88,95.99 ; R962.1 256.84,102.67 C716.1 257.21,101.29 257.21,100.72 257.04,100.54 257.04,99.6 arc(257.03,99.54) 256.99,99.49 256.8,99.29 arc(256.67,98.99) 256.8,98.69 256.81,98.67 arc(256.86,98.59) 256.88,98.5
  S14 w0.108: v3(256.77,95.14) 257.03,94.87 257.03,94.16 256.57,93.7 251.97,93.7 250.94,92.68 250.94,89.77 251.38,89.33 252.29,89.33 v3(252.59,89.03)
  BOTTOM w0.095: U62.5 251.59,88.85 252.09,89.35 252.26,89.35 v3(252.59,89.03)
MGMT_MDI_N3: length 127.4
  TOP w0.095: R963.2 253.43,103.96 253.43,104.14 v3(253.01,104.56) ; J2.A2 144.44,139 144.55,138.89 144.55,137.6 145.12,137.03 145.51,137.03 v3(145.77,136.77)
  S9 w0.108: v3(145.77,136.77) 146.03,137.03 146.76,137.03 arc(146.86,136.99) 146.9,136.89 arc(146.94,136.79) 147.04,136.75 147.3,136.75 arc(147.4,136.79) 147.44,136.89 arc(147.48,136.99) 147.58,137.03 147.95,137.03 arc(148.6,137.16) 149.15,137.53 149.65,138.03 arc(150.02,138.28) 150.46,138.37 152.59,138.37 arc(153.41,138.2) 154.12,137.73 arc(155.45,136.84) 157.02,136.53 174.81,136.53 arc(176.49,136.2) 177.92,135.24 190.79,122.37 arc(191.23,122.08) 191.76,121.97 198.1,121.97 arc(198.54,121.88) 198.91,121.64 200.05,120.5 arc(200.5,120.2) 201.03,120.09 205.03,120.09 arc(205.63,119.97) 206.15,119.63 216.76,109.02 arc(217.2,108.72) 217.73,108.62 241.03,108.62 arc(241.82,108.46) 242.48,108.02 244.07,106.43 arc(244.41,106.2) 244.82,106.12 252.41,106.12 arc(252.74,106.06) 253.01,105.87 253.28,105.6 253.35,105.54 arc(253.42,105.43) 253.44,105.31 253.44,105.08 arc(253.42,105) 253.38,104.93 v3(253.01,104.56)
MGMT_MDI_N3_GE: length 63.6
  TOP w0.095: U70.13 250.77,68.46 251.29,67.94 251.29,67.02 v3(250.94,66.67)
  S12 w0.108: v3(250.94,66.67) 251.23,66.38 251.23,65.55 258.89,57.89 258.89,50.22 265.31,43.79 265.31,22.32 264.49,21.5 264.49,16.14 263.9,15.55 262.69,15.55 262.46,15.78 262.46,16.26 RJ1.E8
MGMT_MDI_N3_R: length 26.9
  TOP w0.095: R963.1 253.05,101.67 C717.1 253.42,101.29 253.42,100.28 253.75,99.95 254.94,99.95 255.14,99.75 255.14,99.6 arc(255.13,99.54) 255.09,99.49 254.87,99.27 arc(254.76,98.99) 254.87,98.71 254.91,98.67 arc(254.96,98.59) 254.98,98.5 ; 254.98,95.99 255.15,95.82 255.15,95.42 v3(254.87,95.14) ; U70.12 250.77,85.37 250.86,85.47 251.19,85.47 251.29,85.56 251.29,86.9 252.12,87.74 253.38,87.74 v3(253.67,88.03)
  S5 w0.108: v3(254.87,95.14) 255.16,94.84 255.16,88.3 254.6,87.74 253.97,87.74 v3(253.67,88.03)
  BOTTOM w0.095: v3(253.67,88.03) 253.97,87.74 254.17,87.74 254.29,87.86 254.29,89.36 254.51,89.58 255.07,89.58 255.61,90.12 U62.3
MGMT_MDI_P0: length 118.9
  TOP w0.095: v3(250.15,104.53) 249.86,104.24 249.86,103.95 R958.2 ; v3(150.97,137.42) 150.68,137.13 150.45,137.13 149.76,137.82 149.76,138.91 149.94,139.09 J2.A13
  S9 w0.108: v3(250.15,104.53) 249.9,104.79 arc(249.87,104.83) 249.86,104.88 arc(249.7,105.27) 249.3,105.44 244.4,105.44 arc(244.09,105.5) 243.82,105.67 242.73,106.77 arc(242.35,107.02) 241.89,107.11 210.61,107.11 arc(209.88,107.26) 209.27,107.67 207.98,108.95 arc(207.29,109.99) 207.04,111.22 207.04,113.22 arc(206.94,113.75) 206.64,114.19 203.02,117.82 arc(202.36,118.25) 201.59,118.41 196.84,118.41 arc(193.18,119.13) 190.08,121.21 176.75,134.54 arc(175.61,135.3) 174.28,135.56 155.84,135.56 arc(155,135.73) 154.29,136.2 arc(153.27,136.89) 152.05,137.13 151.26,137.13 arc(151.05,137.22) v3(150.97,137.42)
MGMT_MDI_P0_GE: length 70.2
  TOP w0.095: U70.23 263.47,68.44 262.99,67.96 262.99,67.37 v3(263.31,67.06)
  S16 w0.108: RJ1.E1 255.28,15.43 264,15.43 264.75,16.19 264.75,21.37 265.54,22.16 265.54,43.83 258.3,51.07 258.3,60.57 263.02,65.28 263.02,66.76 v3(263.31,67.06)
MGMT_MDI_P0_R: length 29.5
  TOP w0.095: U70.2 263.47,85.37 263.37,85.47 263.04,85.47 262.94,85.56 262.94,89.07 259.89,92.12 258.66,92.12 v3(258.37,92.42) ; U55.10 252.09,95.43 v3(252.17,95.35) ; R958.1 250.22,102.67 C712.2 249.89,101.33 249.89,101.19 250.13,100.94 250.84,100.94 251.88,99.9 251.88,99.7 arc(251.9,99.6) 251.96,99.5 252.15,99.31 arc(252.29,98.98) 252.15,98.64 arc(252.11,98.58) 252.09,98.51
  S12 w0.108: v3(252.17,95.35) 251.86,95.03 251.86,94.05 252.21,93.69 254.17,93.69 255.73,92.12 258.08,92.12 v3(258.37,92.42)
  BOTTOM w0.095: U62.1 257.65,92.66 257.74,92.56 257.74,92.23 257.84,92.14 258.09,92.14 v3(258.37,92.42)
MGMT_MDI_P1: length 118.3
  TOP w0.095: v3(241.6,105.83) 241.95,105.49 245.64,105.49 246.04,105.08 246.04,104.32 246.14,104.22 246.33,104.22 246.42,104.13 R959.2 ; v3(149.44,135.77) 149.15,135.48 148.88,135.48 148.75,135.61 148.75,138.28 148.3,138.72 148.3,138.98 148.44,139.11 J2.A10
  S9 w0.108: v3(149.44,135.77) 149.76,135.46 151.67,135.46 arc(152.25,135.34) 152.75,135.01 arc(154.51,133.83) 156.59,133.42 168.09,133.42 arc(168.35,133.47) 168.56,133.61 168.79,133.84 arc(169.15,134.08) 169.57,134.16 173.85,134.16 arc(175.11,133.91) 176.18,133.19 189.94,119.43 arc(193,117.39) 196.6,116.67 201.19,116.67 arc(201.97,116.52) 202.64,116.07 204.38,114.33 arc(204.94,113.49) 205.13,112.51 205.13,110.69 arc(205.37,109.49) 206.05,108.47 207.98,106.54 arc(208.78,106) 209.73,105.82 238.38,105.82 arc(238.54,105.78) 238.68,105.69 238.8,105.58 arc(238.84,105.55) 238.89,105.54 241.31,105.54 v3(241.6,105.83)
MGMT_MDI_P1_GE: length 65.6
  TOP w0.095: U70.20 259.66,68.44 259.15,67.93 259.15,67.45 v3(259.41,67.18)
  S9 w0.108: RJ1.E3 257.93,15.54 258.92,15.54 259.17,15.3 263.79,15.3 264.74,16.25 264.74,21.41 265.53,22.21 265.53,43.9 259.12,50.32 259.12,66.89 v3(259.41,67.18)
MGMT_MDI_P1_R: length 28.9
  TOP w0.095: v3(252.67,92.4) 252.96,92.1 254.96,92.1 259.13,87.93 259.13,85.56 259.23,85.47 259.56,85.47 259.66,85.37 U70.5 ; U55.7 250.19,95.38 v3(250.22,95.35) ; R959.1 246.42,102.13 246.43,102.13 C713.2 246.05,101.29 246.05,101.19 246.98,100.25 249.56,100.25 249.98,99.83 249.98,99.7 arc(250,99.6) 250.06,99.5 250.25,99.31 arc(250.39,98.98) 250.25,98.64 arc(250.21,98.58) 250.19,98.51
  S12 w0.108: v3(252.67,92.4) 252.38,92.1 251.27,92.1 249.9,93.47 249.9,95.03 v3(250.22,95.35)
  BOTTOM w0.095: U62.8 251.73,92.66 252.25,92.14 252.41,92.14 v3(252.67,92.4)
MGMT_MDI_P2: length 130.2
  TOP w0.095: J2.A7 146.94,140.46 146.78,140.62 146.78,142.11 v3(147.07,142.4) ; v3(257.86,104.63) 257.44,104.21 257.44,103.96 R961.2
  S9 w0.108: v3(147.07,142.4) 146.83,142.16 arc(146.8,142.12) 146.79,142.07 146.79,141.76 arc(146.83,141.54) 146.95,141.36 147.97,140.35 arc(148.15,140.22) 148.37,140.18 153.62,140.18 arc(154.53,140) 155.31,139.48 arc(156.92,138.4) 158.83,138.02 174.71,138.02 arc(177.37,137.49) 179.62,135.99 191.59,124.02 arc(192.35,123.51) 193.26,123.33 202.22,123.33 arc(204.64,122.85) 206.7,121.48 215.01,113.16 arc(215.36,112.93) 215.77,112.85 215.93,112.85 arc(216.41,112.76) 216.81,112.49 217.22,112.07 arc(217.56,111.85) 217.95,111.77 219.73,111.77 arc(220.17,111.68) 220.54,111.43 220.99,110.99 arc(221.36,110.74) 221.8,110.66 241.17,110.66 arc(241.91,110.51) 242.53,110.1 245.03,107.59 arc(245.31,107.41) 245.64,107.34 254.17,107.34 arc(255.35,107.11) 256.35,106.44 257.35,105.44 arc(257.46,105.27) 257.51,105.06 257.51,104.99 arc(257.61,104.74) v3(257.86,104.63)
MGMT_MDI_P2_GE: length 71.8
  TOP w0.095: U70.17 255.85,68.52 255.32,68 255.32,67.29 v3(255.56,67.06)
  S7 w0.108: v3(255.56,67.06) 255.27,66.76 255.27,64.93 259.1,61.1 259.1,50.34 265.53,43.91 265.53,22.12 264.72,21.31 264.72,16.4 264.02,15.7 264.02,13.93 262.93,12.84 258.34,12.84 257.84,13.33 257.84,14.83 258.74,15.73 258.74,16.14 RJ1.E4
MGMT_MDI_P2_R: length 28.1
  TOP w0.095: v3(252.59,89.84) 252.92,89.51 253.14,89.51 253.21,89.58 253.96,89.58 255.32,88.21 255.32,85.56 255.42,85.47 255.75,85.47 255.85,85.37 U70.8 ; 257.41,95.94 257.28,95.8 257.28,95.44 v3(257.58,95.14) ; R961.1 257.82,101.68 C715.1 257.44,101.29 257.44,100.62 257.27,100.45 257.27,99.7 arc(257.29,99.6) 257.35,99.5 257.54,99.31 arc(257.68,98.98) 257.54,98.64 arc(257.5,98.58) 257.48,98.51
  S14 w0.108: v3(252.59,89.84) 252.31,89.56 251.48,89.56 251.17,89.86 251.17,92.58 252.06,93.47 256.67,93.47 257.26,94.07 257.26,94.82 v3(257.58,95.14)
  BOTTOM w0.095: U62.6 251.56,90.12 252.09,89.58 252.33,89.58 v3(252.59,89.84)
MGMT_MDI_P3: length 127.1
  TOP w0.095: v3(145.77,137.58) 145.45,137.26 145.21,137.26 144.78,137.69 144.78,138.95 144.94,139.11 J2.A3 ; R964.2 253.65,103.96 253.65,104.19 v3(254.02,104.56)
  S9 w0.108: v3(145.77,137.58) 146.09,137.26 147.95,137.26 arc(148.51,137.37) 148.99,137.69 149.49,138.19 arc(149.93,138.49) 150.46,138.6 152.59,138.6 arc(153.5,138.41) 154.28,137.9 arc(155.54,137.05) 157.02,136.76 174.81,136.76 arc(176.58,136.41) 178.08,135.4 190.95,122.53 arc(191.32,122.29) 191.76,122.2 198.1,122.2 arc(198.63,122.09) 199.07,121.8 200.21,120.66 arc(200.59,120.41) 201.03,120.32 205.03,120.32 arc(205.72,120.19) 206.31,119.79 216.92,109.18 arc(217.29,108.93) 217.73,108.85 241.03,108.85 arc(241.91,108.67) 242.65,108.18 244.23,106.59 arc(244.5,106.41) 244.82,106.35 252.41,106.35 arc(252.82,106.27) 253.17,106.03 253.44,105.77 253.51,105.7 arc(253.63,105.52) 253.67,105.31 253.67,105.08 arc(253.7,104.92) 253.79,104.79 v3(254.02,104.56)
MGMT_MDI_P3_GE: length 63.5
  TOP w0.095: v3(251.75,66.67) 251.51,66.91 251.51,67.94 252.04,68.46 U70.14
  S12 w0.108: v3(251.75,66.67) 251.46,66.38 251.46,65.64 259.12,57.98 259.12,50.31 265.54,43.89 265.54,22.23 264.72,21.4 264.72,16.04 264,15.32 262.79,15.32 RJ1.E7
MGMT_MDI_P3_R: length 26.8
  TOP w0.095: v3(253.67,87.22) 253.38,87.51 252.22,87.51 251.51,86.81 251.51,85.56 251.61,85.47 251.94,85.47 252.04,85.37 U70.11 ; 255.51,95.94 255.38,95.8 255.38,95.44 v3(255.68,95.14) ; R964.1 254.03,102.67 C718.1 254.03,101.63 253.65,101.25 253.65,100.37 253.85,100.18 255.03,100.18 255.37,99.84 255.37,99.7 arc(255.39,99.6) 255.45,99.5 255.64,99.31 arc(255.78,98.98) 255.64,98.64 arc(255.6,98.58) 255.58,98.51
  S5 w0.108: v3(255.68,95.14) 255.39,94.85 255.39,88.21 254.69,87.51 253.97,87.51 v3(253.67,87.22)
  BOTTOM w0.095: U62.4 255.63,88.85 255.12,89.35 254.61,89.35 254.52,89.26 254.52,87.76 254.27,87.51 253.97,87.51 v3(253.67,87.22)
MGMT_PHY_ACT_D_LED: length 3.8
  BOTTOM w0.127: R1007.2 v2(236.25,6.89) 235.6,6.24 LEDB6.A
MGMT_PHY_ACT_LED: length 5.1
  BOTTOM w0.127: LEDB6.C 232.8,5.47 v2(234.22,6.89) R1057.1 R985.1
MGMT_PHY_LINK_D_LED: length 4.8
  BOTTOM w0.127: LEDB5.A 228.6,5.56 229.93,6.89 v2(230.66,6.89) 230.6,6.96 R1005.2
MGMT_PHY_LINK_LED: length 6.3
  BOTTOM w0.127: LEDB5.C 225.8,5.63 226.33,6.17 227.39,6.17 v2(228.31,7.08) 228.57,7.34 R1058.1 R986.1
MGMT_PHY_MDI_N0: length 6.9
  TOP w0.095: U52.N2 v4(227.18,116.65) 226.8,116.27 226.8,115.81 224.44,113.45 224.44,113.15 224.54,113.05 224.74,113.05 224.83,112.96 R1329.2
  BOTTOM w0.095: v4(227.18,116.65) 227.16,116.63 R1077.2
MGMT_PHY_MDI_N0_R: length 31.6
  TOP w0.095: U76.3 232.32,94.84 232.42,94.94 232.75,94.94 232.84,95.03 232.84,95.64 230.29,98.19 226.57,98.19 226.4,98.02 226.4,97.73 v3(226.72,97.41) ; R1329.1 224.83,110.64 C892.2 224.5,110.3 224.5,109.01 224.64,108.87 arc(224.76,108.69) 224.8,108.48 224.8,108.39 arc(224.82,108.29) 224.88,108.19 225.07,108 arc(225.21,107.67) 225.07,107.33 arc(225.03,107.27) 225.01,107.2 ; v3(225.15,103.83) 224.81,104.17 224.81,104.47 225.01,104.68
  S12 w0.108: v3(225.15,103.83) 224.83,103.51 224.83,103.15 226.38,101.6 226.38,101.11 arc(226.43,100.99) 226.55,100.94 arc(226.67,100.89) 226.72,100.77 226.72,100.5 arc(226.67,100.38) 226.55,100.33 arc(226.43,100.28) 226.38,100.16 226.38,99.88 arc(226.43,99.76) 226.55,99.71 arc(226.67,99.66) 226.72,99.54 226.72,99.27 arc(226.67,99.15) 226.55,99.1 arc(226.43,99.04) 226.38,98.92 226.38,97.75 v3(226.72,97.41)
  BOTTOM w0.095: U74.2 223.01,97.43 223.1,97.52 223.43,97.52 223.53,97.62 223.53,98.25 223.81,98.53 226.09,98.53 226.4,98.22 226.4,97.73 v3(226.72,97.41)
MGMT_PHY_MDI_N1: length 6.1
  TOP w0.095: R1327.2 228.71,112.96 228.61,113.05 228.41,113.05 228.31,113.15 228.31,113.56 228.82,114.07 228.82,116.29 v3(229.18,116.65) U52.N4
  BOTTOM w0.095: R1075.2 229.17,116.64 v3(229.18,116.65)
MGMT_PHY_MDI_N1_R: length 29.7
  TOP w0.095: 226.91,104.68 226.71,104.47 226.71,104.17 v3(227.05,103.83) ; R1327.1 228.71,110.64 C890.2 228.7,110.07 228.6,109.98 228.38,109.98 228.28,109.88 228.28,109.39 227.98,109.09 227.02,109.09 226.73,108.8 226.73,108.39 arc(226.74,108.32) 226.76,108.26 arc(226.77,108.24) 226.78,108.23 arc(226.8,108.21) 226.81,108.19 227.04,107.97 arc(227.15,107.69) 227.04,107.42 arc(226.95,107.28) 226.91,107.11 ; U76.6 228.51,94.29 229.03,94.81 229.03,95.22 229.04,95.23 229.04,95.6 228.14,96.5 224.85,96.5 223.48,97.86 223.48,99.63 v3(223.19,99.92)
  S9 w0.108: v3(227.05,103.83) 226.76,103.53 226.76,100.17 225.14,98.55 223.94,98.55 223.49,98.99 223.49,99.62 v3(223.19,99.92)
  BOTTOM w0.095: U74.7 223.01,100.96 223.48,100.49 223.48,100.21 v3(223.19,99.92)
MGMT_PHY_MDI_N2: length 5.9
  TOP w0.095: R1326.2 232.2,112.99 232.2,115.14 231.82,115.52 231.82,116.29 v3(232.18,116.65) U52.N7
  BOTTOM w0.095: v3(232.18,116.65) 232.16,116.63 R1073.2
MGMT_PHY_MDI_N2_R: length 34.9
  TOP w0.095: v3(220.67,99.74) 221.03,99.38 221.03,98.52 223.88,95.67 225.01,95.67 225.22,95.45 225.22,94.86 224.7,94.34 U76.9 ; v3(232.82,103.97) 232.48,104.31 232.48,104.62 232.68,104.83 U75.2 ; R1326.1 232.51,111.62 C888.1 232.17,110.29 232.17,109.16 232.31,109.02 arc(232.43,108.84) 232.47,108.62 232.47,108.54 arc(232.49,108.43) 232.55,108.34 232.75,108.15 arc(232.88,107.81) 232.75,107.48 arc(232.7,107.42) 232.68,107.34
  S12 w0.108: v3(220.67,99.74) 220.99,100.06 220.99,102.75 223.54,105.31 232.05,105.31 232.5,104.85 232.5,104.29 v3(232.82,103.97)
  BOTTOM w0.095: U74.5 220.47,100.69 220.56,100.59 220.89,100.59 220.99,100.5 220.99,100.06 v3(220.67,99.74)
MGMT_PHY_MDI_N3: length 7.4
  TOP w0.095: U52.N9 v3(234.18,116.65) 233.8,116.27 233.8,116.17 233.8,116.17 233.8,114.93 234.5,114.22 235.62,114.22 235.93,113.91 235.93,113.21 236.03,113.12 236.23,113.12 236.33,113.02 R1324.2
  BOTTOM w0.095: R1071.2 234.19,116.64 v3(234.18,116.65)
MGMT_PHY_MDI_N3_R: length 37.5
  TOP w0.095: 234.58,104.82 234.37,104.61 234.37,104.32 v3(234.72,103.97) ; R1324.1 236.33,110.64 C886.1 236.32,110.07 236.22,109.98 236.03,109.98 235.93,109.88 235.93,109.35 235.47,108.89 234.58,108.89 234.37,108.68 234.37,108.54 arc(234.39,108.43) 234.45,108.34 234.65,108.15 arc(234.78,107.81) 234.65,107.48 arc(234.6,107.42) 234.58,107.34 ; v3(218.72,95.19) 219.02,95.5 220.97,95.5 221.41,95.05 221.41,94.77 220.89,94.25 U76.12 ; 234.56,107.09 U75.6
  S9 w0.108: v3(218.72,95.19) 219.04,95.51 220.67,95.51 221.27,96.1 227.58,96.1 234.43,102.95 234.43,103.68 v3(234.72,103.97)
  BOTTOM w0.095: U74.3 221.74,95.6 221.18,95.04 221.18,94.68 220.84,94.34 220.65,94.34 219.88,94.34 219.5,94.72 219.5,95.31 219.35,95.46 218.99,95.46 v3(218.72,95.19)
MGMT_PHY_MDI_P0: length 6.9
  TOP w0.095: R1330.2 223.82,112.96 223.91,113.05 224.12,113.05 224.21,113.15 224.21,113.54 226.57,115.9 226.57,116.27 v3(226.18,116.65) U52.N1
  BOTTOM w0.095: R1078.2 226.13,116.6 v3(226.18,116.65)
MGMT_PHY_MDI_P0_R: length 30.8
  TOP w0.095: 224.41,104.67 224.58,104.5 224.58,104.07 v3(224.34,103.83) ; R1330.1 223.82,110.64 C893.2 224.27,110.19 224.27,108.92 224.36,108.83 224.47,108.71 arc(224.55,108.6) 224.57,108.48 224.57,108.29 arc(224.56,108.23) 224.53,108.18 224.3,107.96 arc(224.19,107.68) 224.3,107.4 224.34,107.36 arc(224.39,107.28) 224.41,107.19 ; U76.2 233.59,94.84 233.5,94.94 233.17,94.94 233.07,95.03 233.07,95.73 230.39,98.42 226.48,98.42 226.17,98.11 226.17,97.72 v3(225.86,97.41)
  S12 w0.108: v3(224.34,103.83) 224.61,103.56 224.61,103.06 226.15,101.51 226.15,97.71 v3(225.86,97.41)
  BOTTOM w0.095: v3(225.86,97.41) 226.17,97.72 226.17,98.13 226,98.3 223.91,98.3 223.76,98.15 223.76,97.62 223.85,97.52 224.18,97.52 224.28,97.43 U74.1
MGMT_PHY_MDI_P1: length 6.2
  TOP w0.095: U52.N3 v3(228.18,116.65) 228.59,116.24 228.59,114.16 228.09,113.66 228.09,113.15 227.99,113.05 227.79,113.05 227.69,112.96 R1328.2
  BOTTOM w0.095: v3(228.18,116.65) 228.16,116.63 R1076.2
MGMT_PHY_MDI_P1_R: length 29.9
  TOP w0.095: U73.7 226.31,107.31 arc(226.3,107.37) 226.27,107.41 226.24,107.44 arc(226.19,107.52) 226.17,107.62 226.17,107.81 arc(226.19,107.91) 226.25,108 226.47,108.22 arc(226.49,108.25) 226.5,108.29 226.5,108.37 arc(226.5,108.38) 226.5,108.39 226.5,108.9 226.92,109.32 227.89,109.32 228.05,109.49 228.05,109.88 227.96,109.98 227.73,109.98 227.64,110.07 C891.2 227.69,110.68 R1328.1 ; U76.5 229.78,94.26 229.26,94.78 229.26,95.13 229.26,95.13 229.26,95.7 228.23,96.73 224.94,96.73 223.71,97.96 223.71,99.58 v3(224.05,99.92) ; v3(226.24,103.83) 226.48,104.07 226.48,104.48 226.31,104.65
  S9 w0.108: v3(226.24,103.83) 226.53,103.53 226.53,103 arc(226.5,102.92) 226.42,102.89 arc(226.27,102.83) 226.21,102.68 226.21,102.56 arc(226.27,102.41) 226.42,102.35 arc(226.5,102.32) 226.53,102.24 226.53,101.92 arc(226.5,101.84) 226.42,101.81 arc(226.26,101.74) 226.19,101.58 226.19,101.51 arc(226.26,101.34) 226.42,101.27 arc(226.5,101.24) 226.53,101.16 226.53,100.26 225.04,98.78 224.03,98.78 223.72,99.08 223.72,99.59 v3(224.05,99.92)
  BOTTOM w0.095: v3(224.05,99.92) 223.71,100.27 223.71,100.41 224.28,100.98 U74.8
MGMT_PHY_MDI_P2: length 6
  TOP w0.095: R1325.2 231.97,113.07 231.97,115.04 231.59,115.42 231.59,116.25 v3(231.18,116.65) U52.N6
  BOTTOM w0.095: R1074.2 231.14,116.61 v3(231.18,116.65)
MGMT_PHY_MDI_P2_R: length 35
  TOP w0.095: 232.08,104.81 232.25,104.65 232.25,104.22 v3(232.01,103.97) ; U76.8 225.97,94.2 225.45,94.72 225.45,95.55 225.1,95.9 223.98,95.9 221.26,98.61 221.26,99.47 v3(221.53,99.74) ; R1325.1 231.51,111.69 C887.1 231.94,110.2 231.94,109.06 232.03,108.97 232.05,108.95 232.05,108.95 232.14,108.86 arc(232.22,108.75) 232.24,108.62 232.24,108.44 arc(232.23,108.38) 232.2,108.33 231.97,108.1 arc(231.86,107.83) 231.97,107.55 232.01,107.51 arc(232.07,107.43) 232.08,107.34 ; U75.1 232.08,104.81
  S12 w0.108: v3(232.01,103.97) 232.27,104.24 232.27,104.75 231.95,105.08 230.74,105.08 arc(230.64,105.04) 230.6,104.94 arc(230.56,104.85) 230.47,104.81 230.12,104.81 arc(230.03,104.85) 229.99,104.94 arc(229.95,105.04) 229.85,105.08 229.51,105.08 arc(229.41,105.04) 229.37,104.94 arc(229.33,104.85) 229.24,104.81 228.89,104.81 arc(228.8,104.85) 228.76,104.94 arc(228.72,105.04) 228.62,105.08 228.27,105.08 arc(228.18,105.04) 228.14,104.94 arc(228.1,104.85) 228.01,104.81 227.66,104.81 arc(227.56,104.85) 227.52,104.94 arc(227.48,105.04) 227.39,105.08 223.64,105.08 221.22,102.66 221.22,100.06 v3(221.53,99.74)
  BOTTOM w0.095: U74.6 221.74,100.69 221.64,100.59 221.31,100.59 221.22,100.5 221.22,100.06 v3(221.53,99.74)
MGMT_PHY_MDI_P3: length 7.4
  TOP w0.095: R1323.2 235.31,113.02 235.41,113.12 235.61,113.12 235.71,113.21 235.71,113.81 235.52,113.99 234.41,113.99 233.57,114.83 233.57,116.08 233.57,116.08 233.57,116.27 v3(233.18,116.65) U52.N8
  BOTTOM w0.095: v3(233.18,116.65) 233.18,116.64 R1072.2
MGMT_PHY_MDI_P3_R: length 37.9
  TOP w0.095: v3(218.72,96.06) 219.05,95.72 221.06,95.72 221.64,95.15 221.64,94.77 222.16,94.25 U76.11 ; 233.98,104.81 234.14,104.66 234.14,104.21 v3(233.91,103.97) ; R1323.1 235.31,110.64 C885.1 235.32,110.07 235.42,109.98 235.61,109.98 235.71,109.88 235.71,109.45 235.37,109.12 234.48,109.12 234.14,108.77 234.14,108.44 arc(234.13,108.38) 234.1,108.33 233.87,108.1 arc(233.76,107.83) 233.87,107.55 233.91,107.51 arc(233.97,107.43) 233.98,107.34
  S9 w0.108: v3(233.91,103.97) 234.2,103.68 234.2,103.05 231.54,100.38 arc(231.41,100.33) 231.27,100.38 arc(231.14,100.44) 231.01,100.38 230.89,100.26 arc(230.84,100.13) 230.89,100 arc(230.95,99.87) 230.89,99.74 230.77,99.62 arc(230.64,99.56) 230.51,99.62 arc(230.38,99.67) 230.25,99.62 230.13,99.5 arc(230.07,99.37) 230.13,99.24 230.13,99.24 arc(230.18,99.11) 230.13,98.98 227.49,96.33 221.17,96.33 220.58,95.74 219.04,95.74 v3(218.72,96.06)
  BOTTOM w0.095: U74.4 220.47,95.52 220.95,95.04 220.95,94.78 220.74,94.57 219.98,94.57 219.73,94.81 219.73,95.41 219.45,95.69 219.08,95.69 v3(218.72,96.06)
MINI_OSC5_OE: length 1.7
  TOP w0.127: OSC2.1 199.38,234.44 199.82,234.88 R210.2
MOD_ABS01: length 304.5
  TOP w0.127: U9.C6 v4(194.55,197.58)
  S5 w0.127: v4(194.55,197.58) 194.55,197.94 194.05,198.45 194.05,198.77 193.77,199.04 193.32,199.04 193.13,199.24 193.13,200.13 192.37,200.89 187.89,200.89 185.92,198.92 182.46,198.92 181.51,197.97 178.7,197.97 175.5,194.76 175.5,176.18 172.49,173.18 172.49,172.12 168.42,168.05 167.04,168.05 164.38,165.38 162.44,165.38 156.68,159.63 141.02,159.63 137.06,155.66 137.06,148.63 133.95,145.53 127.38,145.53 124.98,143.13 124.98,134.62 123.91,133.55 123.91,119.1 122.17,117.37 122.17,110.24 125.5,106.91 125.5,93.76 120.26,88.52 84.81,88.52 76.99,80.71 72.46,80.71 70.99,79.24 51.04,79.24 46.11,74.31 46.11,67.99 40.93,62.8 40.19,62.8 37.08,59.7 37.08,57.35 35.56,55.83 33.68,55.83 32.61,54.76 CONN54_PF.1T6
  S9 w0.127: CONN54_PF.1T6 32.61,51.73 32.03,51.15 32.03,50.39 32.48,49.95 32.48,49.12 31.56,48.2 31.56,47.5 30.57,46.52 30.57,43.56 v1(31.1,43.04) 31.93,42.21 31.93,38.76 31.15,37.99 31.15,37.03 31.69,36.49 31.69,35.06 v1(33.2,33.54)
  BOTTOM w0.127: RB563.1 32.9,33.24 v1(33.2,33.54) ; v1(31.1,43.04) 30.41,43.72 v2(30.06,43.72)
MOD_ABS02: length 314.9
  TOP w0.127: v4(195.55,197.58) U9.C7
  S5 w0.127: CONN54_PF.1L6 31.81,54.32 33.57,56.08 35.37,56.08 36.78,57.49 36.78,59.85 40.06,63.13 40.87,63.13 45.79,68.05 45.79,74.45 50.84,79.49 70.86,79.49 72.39,81.03 76.86,81.03 84.67,88.85 120.13,88.85 125.17,93.89 125.17,106.85 120.9,111.12 120.9,112.65 121.67,113.41 121.67,117.32 123.59,119.24 123.59,133.58 124.73,134.73 124.73,143.33 127.23,145.83 133.27,145.83 135.89,148.45 135.89,149.3 136.73,150.14 136.73,155.79 140.89,159.95 156.58,159.95 162.33,165.71 164.25,165.71 167.04,168.5 168.24,168.5 172.09,172.35 172.09,173.23 175.17,176.32 175.17,194.89 178.56,198.28 181.45,198.28 183.29,200.12 186.67,200.12 187.76,201.22 192.61,201.22 194.02,199.81 194.02,199.3 194.28,199.04 194.72,199.04 195.06,198.7 195.06,198.07 v4(195.55,197.58)
  S14 w0.127: CONN54_PF.1L6 31.81,51.64 30.4,50.23 28.9,50.23 28,49.33 24.24,49.33 23.64,48.73 23.64,46.52 30.35,39.82 30.35,38.33 30.71,37.97 30.71,37.02 29.8,36.11 29.8,33.76 29.26,33.22 v1(29.26,32.25)
  BOTTOM w0.127: v2(29.28,31.03) 29.26,31.05 v1(29.26,32.25) 29.29,32.28 RB562.1
MOD_ABS03: length 278.7
  TOP w0.127: v4(191.55,194.58) U9.F3
  S5 w0.127: CONN54_PF.2T6 46.86,54.86 47.94,55.95 49.5,55.95 51.55,58 51.55,60.93 58.52,67.9 58.52,73.29 62.24,77.01 72.28,77.01 73.35,78.08 78.24,78.08 86.03,85.86 121.19,85.86 127.85,92.53 127.85,131.37 134.99,138.51 134.99,141.91 139.61,146.53 139.61,154.6 142.12,157.11 157.74,157.11 163.16,162.53 164.95,162.53 167.73,165.31 169.45,165.31 177.63,173.48 177.63,192.79 177.64,192.8 177.64,192.82 179.61,194.79 179.63,194.79 179.84,194.79 179.84,194.79 188.5,194.79 188.68,194.97 191.16,194.97 v4(191.55,194.58)
  S14 w0.127: CONN54_PF.2T6 48.06,53.9 49.47,52.5 50.1,52.5 50.89,51.71 50.89,50.54 52.55,48.89 52.55,44.31 v1(51.62,43.38) 48.61,40.38 48.61,39.21 49.19,38.63 49.19,36.09 48.68,35.58 48.68,34.25 v1(47.67,33.24)
  BOTTOM w0.127: RB566.1 v1(47.67,33.24) ; v2(50.47,43.31) 51.55,43.31 v1(51.62,43.38)
MOD_ABS04: length 284.3
  TOP w0.127: U9.E5 v4(193.55,195.58)
  S5 w0.127: v4(193.55,195.58) 193.5,195.53 193.03,195.53 192.6,195.96 191.2,195.96 191.02,196.14 191.02,196.72 190.74,197 189.22,197 188.85,196.63 187.73,196.63 187.41,196.31 179.68,196.31 177.13,193.76 177.13,193.01 177.12,193 177.12,173.82 169.19,165.9 167.5,165.9 164.71,163.11 162.92,163.11 157.56,157.75 142.01,157.75 138.97,154.71 138.97,147.02 134.25,142.29 134.25,138.56 127.35,131.66 127.35,92.91 120.94,86.51 85.76,86.51 77.98,78.72 73.13,78.72 71.96,77.56 61.48,77.56 57.62,73.71 57.62,67.87 55.11,65.35 50.76,65.35 49.88,64.47 49.88,63.8 47.69,61.62 47.69,59.03 44.77,56.11 44.77,55.32 43.86,54.4 43.86,53.64 44.26,53.24 45.13,53.24 CONN54_PF.2L6
  S7 w0.127: v1(42.97,33.24) 43.63,33.9 43.63,37.77 45.08,39.21 45.08,46.44 46.02,47.38 46.02,48.34 46.74,49.06 46.74,49.59 45.91,50.42 45.91,52.16 CONN54_PF.2L6
  BOTTOM w0.127: RB565.1 v1(42.97,33.24) v2(42.18,33.24) ; v4(193.55,195.58) 193.55,195.91 v2(193.91,196.27)
MOD_ABS05: length 259.3
  TOP w0.127: U9.G6 v4(194.55,193.58)
  S5 w0.127: v4(194.55,193.58) 194.52,193.58 194.02,193.08 194.02,191.3 193.2,190.47 188.5,190.47 188.18,190.15 187.67,190.15 185.19,187.68 181.38,187.68 179.83,186.13 179.83,172.54 170.02,162.72 168.3,162.72 165.95,160.37 164.07,160.37 162.72,159.02 162.72,156.12 160.03,153.43 160.03,152.37 158.6,150.95 157.55,150.95 156.05,149.45 153.65,149.45 152.5,148.31 144.43,148.31 143.48,147.36 143.48,146.05 138.32,140.89 138.32,138.74 130.15,130.58 130.15,91.54 121.99,83.38 87.69,83.38 80.04,75.73 78.9,75.73 77.18,74.01 72.41,74.01 70.69,72.3 70.69,67.19 65.7,62.2 65.7,58.16 63.61,56.07 62.2,56.07 61.11,54.98 CONN54_PF.3T6
  S12 w0.127: CONN54_PF.3T6 61.11,52.03 59.38,50.29 57.65,50.29 56.53,49.17 56.53,48.41 59.1,45.84 59.1,41.55 58.18,40.64 58.18,36.23 v1(57.22,35.27)
  BOTTOM w0.127: v2(56.41,35.45) 56.58,35.27 v1(57.22,35.27) RB542.1
MOD_ABS06: length 261.4
  TOP w0.127: v4(192.55,191.58) U9.J4
  S5 w0.127: v4(192.55,191.58) 191.93,190.96 189.16,190.96 187.12,192.99 182.38,192.99 179.3,189.91 179.3,172.73 169.87,163.29 168.11,163.29 165.77,160.95 163.93,160.95 162.08,159.1 162.08,156.37 159.32,153.62 159.32,152.63 158.15,151.46 157.17,151.46 156.97,151.26 150.5,151.26 148.17,148.94 144.34,148.94 142.97,147.57 142.97,146.33 137.52,140.88 137.52,138.69 129.56,130.73 129.56,92.07 121.48,84 87.04,84 79.44,76.4 74.77,76.4 73.14,74.78 72.04,74.78 69.79,72.52 69.79,68.19 64.59,62.99 63.89,62.99 61.94,61.04 61.94,59.03 59.02,56.11 59.02,55.32 58.2,54.5 58.2,53.69 59.59,52.3 CONN54_PF.3L6
  S9 w0.127: CONN54_PF.3L6 60.06,52.05 60.06,50.75 61.05,49.76 61.05,49.2 59.33,47.47 59.33,44.31 v1(60.8,42.83) 61.08,42.56 61.08,34.08 v1(61.92,33.24)
  BOTTOM w0.127: RB541.1 v1(61.92,33.24) ; v1(60.8,42.83) 60.61,43.03 v2(59.66,43.03)
MOD_ABS07: length 240.2
  TOP w0.127: v4(189.55,187.58) U9.M1
  S5 w0.127: v4(189.55,187.58) 188.95,186.98 188.95,184.87 187.29,183.21 187.29,181.84 186.66,181.2 186.27,181.2 185.32,180.25 185.32,177.64 184.56,176.88 184.56,173.11 174.51,163.06 174.51,160.17 170.22,155.88 170.22,155.12 169.76,154.66 167.29,154.66 166.59,153.96 166.59,152.06 163.03,148.51 163.03,142.34 161.57,140.88 150.34,140.88 149.57,140.11 145.88,140.11 143.74,137.97 141.52,137.97 141.32,137.77 140.56,137.77 133,130.2 133,90.63 123.18,80.81 88.33,80.81 83.53,76.01 83.53,67.46 83.53,63.06 79.95,59.48 79.95,57.91 78.11,56.07 76.58,56.07 75.36,54.86 75.36,53.9 CONN54_PF.4T6
  S12 w0.127: CONN54_PF.4T6 75.36,53.9 75.36,52.03 73.63,50.29 71.9,50.29 70.78,49.17 70.78,48.41 73.35,45.84 73.35,41.55 72.43,40.64 72.43,36.23 v1(71.47,35.27)
  BOTTOM w0.127: v2(70.66,35.45) 70.83,35.27 v1(71.47,35.27) RB545.1
MOD_ABS08: length 252.8
  TOP w0.127: U9.G7 v4(195.55,193.58)
  S5 w0.127: v1(182.53,177.96) 182.53,175.99 183.42,175.11 183.42,174.22 182.59,173.39 182.59,172.06 170.91,160.37 170.91,159.04 170.33,158.47 170.33,157.51 169.64,156.82 167.35,156.82 166.41,155.87 166.39,155.87 166.34,155.83 164.94,155.83 162.46,153.35 162.46,148.56 161.67,147.77 161.67,146.12 160.68,145.13 152.45,145.13 152.13,144.81 150.3,144.81 148.75,143.26 148.75,141.58 147.86,140.69 144.68,140.69 143.6,139.61 142.33,139.61 141.06,138.34 140.34,138.34 132.4,130.4 132.4,91.05 122.88,81.53 88.3,81.53 82.92,76.16 82.92,67.79 76.42,61.29 76.42,59.25 73.27,56.11 73.27,55.32 72.36,54.4 72.36,53.51 72.63,53.23 73.63,53.23 CONN54_PF.4L6
  S9 w0.127: v1(76.17,33.24) 74.46,34.94 74.46,36.6 73.88,37.18 73.88,40.56 73.58,40.87 73.58,47.47 75.3,49.2 75.3,49.76 74.48,50.58 74.48,52.22 CONN54_PF.4L6 ; v4(195.55,193.58) 194.98,193.01 194.28,193.01 193.95,192.68 193.95,190.85 193.56,190.47 188.97,190.47 185.13,186.63 185.13,180.57 v1(182.53,177.96)
  BOTTOM w0.127: v1(182.53,177.96) 181.51,177.96 v2(181.38,177.84) ; RB544.1 v1(76.17,33.24)
MOD_ABS09: length 221.1
  TOP w0.127: U9.U1 v4(189.55,182.58)
  S5 w0.127: CONN54_PF.5T6 89.61,55.61 90.07,56.07 92.36,56.07 94.2,57.91 94.2,60.83 98.09,64.72 101.42,64.72 105.3,68.6 105.3,74.94 108.72,78.36 124.11,78.36 135.6,89.85 135.6,114.97 137.76,117.13 137.76,126.95 139.53,128.72 144.08,128.72 148.59,133.23 151,133.23 155.16,137.39 164.68,137.39 167.48,140.18 167.92,140.18 168.75,141.01 168.75,142.4 169.27,142.93 169.27,144.09 171.26,146.08 171.26,149.93 173.86,152.53 174.56,152.53 175.16,153.13 175.16,156.25 176.11,157.2 178.4,157.2 179.8,158.6 179.8,164.05 180.82,165.07 180.82,165.91 190.34,175.43 190.34,178.03 188.79,179.58 188.79,181.82 v4(189.55,182.58)
  S12 w0.127: v1(85.72,35.27) 86.68,36.23 86.68,40.64 87.6,41.55 87.6,45.84 85.03,48.41 85.03,49.17 86.15,50.29 87.88,50.29 89.61,52.03 CONN54_PF.5T6
  BOTTOM w0.127: RB548.1 v1(85.72,35.27) 85.08,35.27 v2(84.91,35.45)
MOD_ABS10: length 245.9
  TOP w0.127: v4(196.55,195.58) U9.E8
  S5 w0.127: v1(189.51,178.15) 188.94,178.15 186.34,175.55 186.34,172.71 178.78,165.15 178.78,162.09 172.81,156.12 172.81,154.79 173.45,154.15 173.45,153.01 169.93,149.49 169.93,145.7 168.83,144.6 168.12,144.6 165.32,141.8 165.32,139.1 164.18,137.96 154.59,137.96 150.43,133.8 146.43,133.8 144.87,135.35 140.81,135.35 137.7,132.24 137.7,127.89 137,127.2 137,117.64 134.92,115.55 134.92,90.05 123.88,79.02 108.31,79.02 104.74,75.44 104.74,68.87 101.22,65.35 94.92,65.35 90.44,60.87 90.44,59.03 87.52,56.11 87.52,55.32 86.61,54.4 86.61,53.64 87.94,52.3 CONN54_PF.5L6
  S9 w0.127: v1(90.42,33.24) 89.58,34.08 89.58,39.47 87.83,41.22 87.83,47.47 89.5,49.15 89.5,49.78 88.74,50.54 88.74,52.23 CONN54_PF.5L6 ; v1(189.51,178.15) 192.83,178.15 196.05,181.38 196.05,185.9 195.8,186.15 195.29,186.15 195.04,186.41 195.04,190.35 196.12,191.42 196.12,195.14 v4(196.55,195.58)
  BOTTOM w0.127: v2(191.67,177.65) 191.1,178.22 189.58,178.22 v1(189.51,178.15) ; RB547.1 v1(90.42,33.24)
MOD_ABS11: length 227
  TOP w0.127: v4(195.55,182.58) U9.U7
  S5 w0.127: v4(195.55,182.58) 195.95,182.18 195.95,181.35 194.3,179.7 194.3,175.48 190.94,172.12 190.34,172.12 183.85,165.63 183.85,163.03 182.15,161.33 182.15,155.99 179.04,152.88 179.04,150.53 179.8,149.77 179.8,147.29 179.61,147.1 178.53,147.1 178.08,146.66 178.08,141.39 176.94,140.24 176.94,138.06 177.93,137.07 177.93,92.16 169.31,83.54 146.78,83.54 143.24,80 130.58,80 126.38,75.79 109.66,75.79 107.92,74.05 107.92,63.09 108.45,62.56 108.45,57.91 106.61,56.07 104.92,56.07 103.86,55.01 CONN54_PF.6T6
  S12 w0.127: v1(99.97,35.27) 100.93,36.23 100.93,40.64 101.85,41.55 101.85,45.84 99.28,48.41 99.28,49.17 100.4,50.29 102.13,50.29 103.86,52.03 CONN54_PF.6T6
  BOTTOM w0.127: v2(99.16,35.45) 99.33,35.27 v1(99.97,35.27) RB551.1
MOD_ABS12: length 233.9
  TOP w0.127: v4(193.55,186.58) U9.N5
  S5 w0.127: CONN54_PF.6L6 102.13,53.24 101.26,53.24 100.86,53.64 100.86,54.4 101.77,55.32 101.77,56.11 104.69,59.03 104.69,61.14 107.09,63.54 107.09,74.05 109.52,76.48 126.07,76.48 130.43,80.84 142.86,80.84 146.42,84.4 168.95,84.4 177.42,92.87 177.42,136.69 172.81,141.3 172.81,142.73 173.13,143.05 173.83,143.05 174.6,143.83 174.6,144.52 175.47,145.39 176.75,145.39 177.57,146.21 177.57,152.69 180.43,155.55 180.43,156.63 181.51,157.71 181.51,161.52 182.88,162.88 182.88,165.55 192.13,174.8 192.13,179.41 193.97,181.25 193.97,185.75 193.55,186.17 v4(193.55,186.58)
  S9 w0.127: v1(104.67,33.24) 103.83,34.08 103.83,39.42 102.07,41.17 102.07,47.42 103.8,49.15 103.8,49.65 102.81,50.64 102.81,52.05 CONN54_PF.6L6
  BOTTOM w0.127: v2(104.23,31.85) 103.95,32.13 RB550.1 v1(104.67,33.24)
MOD_ABS13: length 213.8
  TOP w0.127: v4(195.55,184.58) U9.R7
  S5 w0.127: CONN55_PF.1T6 120.16,54.96 121.27,56.07 122.91,56.07 124.75,57.91 124.75,59.93 127,62.18 127,70.63 129.41,73.04 133.4,73.04 137.38,77.02 143.69,77.02 147.87,81.2 170.43,81.2 179.96,90.73 179.96,138.41 180.56,139 180.56,144.24 181.96,145.64 181.96,145.77 183.04,146.85 183.04,153.66 186.13,156.75 186.13,159.97 186.45,160.29 186.45,165.33 189.31,168.18 193.32,168.18 195.51,170.37 195.51,173.81 198.01,176.31 198.01,178.97 198.57,179.52 198.57,183.41 197.88,184.1 196.05,184.1 195.57,184.58 v4(195.55,184.58)
  S12 w0.127: v1(116.27,35.27) 117.23,36.23 117.23,40.64 118.15,41.55 118.15,45.82 115.58,48.39 115.58,49.17 116.72,50.31 118.45,50.31 120.16,52.03 CONN55_PF.1T6
  BOTTOM w0.127: RB569.1 v1(116.27,35.27) 115.63,35.27 v2(115.46,35.45)
MOD_ABS14: length 212.9
  TOP w0.127: v4(196.55,183.58) U9.T8
  S5 w0.127: v4(196.55,183.58) 196.67,183.46 196.97,183.46 197.32,183.11 197.81,183.11 197.96,182.95 197.96,179.8 197.5,179.35 197.5,176.52 194.66,173.68 194.66,170.6 192.99,168.93 189.34,168.93 185.82,165.41 185.82,162.34 184.62,161.14 184.62,156.06 182.53,153.96 182.53,147.1 181.38,145.96 181.38,145.83 179.86,144.31 179.86,139.02 179.45,138.62 179.45,91.01 170.2,81.76 147.59,81.76 143.48,77.65 132.73,77.65 127,71.92 126.63,71.92 124.62,69.91 124.62,64.96 120.99,61.34 120.99,59.03 118.07,56.11 118.07,55.32 117.16,54.4 117.16,53.64 117.56,53.24 118.43,53.24 CONN55_PF.1L6
  S9 w0.127: CONN55_PF.1L6 119.11,52.05 119.11,50.65 120.1,49.66 120.1,49.2 118.58,47.68 118.58,43.72 v1(119.5,42.8) 120.13,42.18 120.13,34.08 v1(120.97,33.24)
  BOTTOM w0.127: v2(120.68,42.9) 119.6,42.9 v1(119.5,42.8) ; RB568.1 v1(120.97,33.24)
MOD_ABS15: length 202.4
  TOP w0.127: v4(203.55,184.58) U9.R14
  S5 w0.127: v4(203.55,184.58) 203.01,184.04 203.01,183.39 202.76,183.13 202.76,180.34 202.15,179.73 202.15,168.68 196.88,163.41 196.88,160.88 194.47,158.47 194.47,157.83 192.31,155.67 190.41,155.67 186.4,151.66 186.4,148.69 185.39,147.67 185.39,145.7 184.75,145.07 184.75,138.28 182.39,135.92 182.39,89.33 171.76,78.7 152.67,78.7 151.54,77.57 151.54,72.87 149.32,70.65 147.86,70.65 147.79,70.58 147.79,69 147.41,68.62 144.17,68.62 142.96,67.4 142.96,66.38 142.44,65.86 141.48,65.86 141.19,65.57 139.93,65.57 139.63,65.28 139.63,61.14 139,60.51 139,57.91 137.16,56.07 135.5,56.07 134.41,54.98 CONN55_PF.2T6
  S12 w0.127: CONN55_PF.2T6 134.41,52.03 132.68,50.29 130.95,50.29 129.83,49.17 129.83,48.39 132.4,45.82 132.4,41.55 131.48,40.64 131.48,36.23 v1(130.52,35.27)
  BOTTOM w0.127: v2(129.71,35.45) 129.88,35.27 v1(130.52,35.27) RB572.1
MOD_ABS16: length 204.4
  TOP w0.127: v4(201.55,183.58) U9.T12
  S5 w0.127: CONN55_PF.2L6 132.74,52.3 131.41,53.64 131.41,54.4 132.32,55.32 132.32,56.11 135.24,59.03 135.24,61.14 137.95,63.85 137.95,72.38 138.89,73.31 145.63,73.31 146.52,74.2 146.52,76.36 148.56,78.39 151.29,78.39 152.29,79.4 171.57,79.4 181.74,89.57 181.74,136.28 184.24,138.78 184.24,145.51 184.88,146.15 184.88,151.02 190.42,156.56 192.05,156.56 192.88,157.39 192.88,158.4 193.2,158.72 193.92,158.72 196.18,160.99 196.18,163.91 200.85,168.58 200.85,179.43 202.23,180.8 202.23,182.87 201.84,183.25 201.84,183.29 v4(201.55,183.58)
  S9 w0.127: v1(135.22,33.24) 134.38,34.08 134.38,42.41 v1(133.82,42.96) 132.63,44.16 132.63,47.47 134.35,49.2 134.35,49.66 133.36,50.65 133.36,52.05 CONN55_PF.2L6
  BOTTOM w0.127: v2(132.74,42.96) v1(133.82,42.96) ; RB571.1 v1(135.22,33.24)
MOD_ABS17: length 199
  TOP w0.127: U9.P16 v4(205.55,185.58)
  S5 w0.127: CONN55_PF.3T6 148.66,55.02 149.51,55.87 151.22,55.87 152.48,57.14 152.48,58.71 154.02,60.25 154.02,74.01 156.3,76.3 172.88,76.3 184.72,88.14 184.72,134.69 187.93,137.89 187.93,139.04 188.24,139.35 189.45,139.35 190.34,140.24 190.34,145.26 194.21,149.13 194.21,153.9 195.16,154.85 197.64,154.85 200.89,158.09 200.89,163.73 209.56,172.41 209.56,184.73 209.16,185.14 206.26,185.14 205.82,185.58 v4(205.55,185.58)
  S14 w0.127: v1(144.77,35.27) 145.73,36.23 145.73,40.64 146.65,41.55 146.65,45.82 144.08,48.39 144.08,49.17 145.2,50.29 146.93,50.29 148.66,52.03 CONN55_PF.3T6
  BOTTOM w0.127: RB575.1 v1(144.77,35.27) 144.13,35.27 v2(143.96,35.45)
MOD_ABS18: length 199.7
  TOP w0.127: U9.N15 v4(204.55,186.58)
  S5 w0.127: v4(204.55,186.58) 205.04,186.09 205.04,185.42 205.38,185.09 205.71,185.09 206.09,184.71 206.09,184.38 206.34,184.12 207.97,184.12 208.95,183.13 208.95,172.66 199.88,163.59 199.88,158.55 196.94,155.61 194.85,155.61 192.5,153.26 192.5,150.91 191.74,150.15 191.74,147.42 188.77,144.45 188.77,140.89 187.06,139.19 187.06,137.97 184.12,135.03 184.12,88.4 172.63,76.91 155.9,76.91 153.51,74.52 153.51,71.47 153,70.97 153,67.47 149.49,63.96 149.49,59.03 147.46,57 147.46,56.21 145.66,54.4 145.66,53.64 146.06,53.24 146.93,53.24 CONN55_PF.3L6
  S16 w0.127: v1(149.47,33.24) 148.63,34.08 148.63,41.56 v1(147.63,42.55) 146.88,43.31 146.88,47.47 148.6,49.2 148.6,49.66 147.61,50.65 147.61,52.05 CONN55_PF.3L6
  BOTTOM w0.127: RB574.1 v1(149.47,33.24) ; v2(148.49,42.96) 148.05,42.96 v1(147.63,42.55)
MOD_ABS19: length 195.8
  TOP w0.127: U9.H14 v4(203.55,192.58)
  S5 w0.127: v4(203.55,192.58) 203.55,192.31 204.08,191.78 204.08,191.34 205.04,190.37 208.12,190.37 209.69,188.8 211.06,188.8 212.19,187.67 212.19,167.5 205.72,161.04 205.72,153.34 198.96,146.58 197.85,146.58 195.57,144.29 195.57,137.4 194.09,135.93 191.8,135.93 191.04,135.17 191.04,132.87 187.6,129.44 187.6,87.28 176.94,76.62 176.94,65.76 174.39,63.21 171.36,63.21 166.97,58.82 166.97,57.38 165.66,56.07 164,56.07 162.91,54.98 CONN55_PF.4T6
  S14 w0.127: v1(159.02,35.27) 159.98,36.23 159.98,40.64 160.9,41.55 160.9,45.82 158.33,48.39 158.33,49.17 159.45,50.29 161.18,50.29 162.91,52.03 CONN55_PF.4T6
  BOTTOM w0.127: RB554.1 v1(159.02,35.27) 158.38,35.27 v2(158.21,35.45)
MOD_ABS20: length 201.9
  TOP w0.127: v4(204.55,189.58) U9.K15
  S5 w0.127: CONN55_PF.4L6 161.18,53.24 160.31,53.24 159.91,53.64 159.91,54.4 160.82,55.32 160.82,56.11 163.74,59.03 163.74,61.14 163.41,61.47 163.41,70.39 166.36,73.34 175.34,73.34 175.9,73.9 175.9,76.62 187.09,87.81 187.09,133.88 191.99,138.78 191.99,143.61 193.89,145.51 195.48,145.51 197.13,147.17 198.28,147.17 204.75,153.64 204.75,164.63 211.56,171.43 211.56,185.92 207.97,189.51 207.25,189.51 206.85,189.1 205.03,189.1 v4(204.55,189.58)
  S16 w0.127: CONN55_PF.4L6 161.86,52.05 161.86,50.65 162.85,49.66 162.85,49.2 161.36,47.7 161.36,40.77 162.88,39.25 162.88,34.08 v1(163.72,33.24)
  BOTTOM w0.127: v4(204.55,189.58) 205.2,190.22 210.4,190.22 v2(210.98,189.65) ; RB553.1 v1(163.72,33.24)
MOD_ABS21: length 197
  TOP w0.127: v4(205.55,194.58) U9.F16
  S5 w0.127: CONN55_PF.5T6 177.16,54.93 178.3,56.07 179.91,56.07 181.75,57.91 181.75,60.28 189.92,68.45 189.92,128.39 198.28,136.75 208.43,136.75 210.15,138.48 210.15,143.61 211.01,144.47 211.01,147.42 209.39,149.04 209.39,160.2 214.98,165.79 214.98,178.87 215.77,179.67 215.77,187.9 212.51,191.16 212.16,191.16 209.24,194.08 206.05,194.08 v4(205.55,194.58)
  S14 w0.127: v1(173.27,35.27) 174.23,36.23 174.23,40.64 175.15,41.55 175.15,45.82 172.58,48.39 172.58,49.17 173.7,50.29 175.43,50.29 177.16,52.03 CONN55_PF.5T6
  BOTTOM w0.127: RB557.1 v1(173.27,35.27) 172.63,35.27 v2(172.46,35.45)
MOD_ABS22: length 196.2
  TOP w0.127: U9.H18 v4(207.55,192.58)
  S5 w0.127: CONN55_PF.5L6 175.43,53.24 174.56,53.24 174.16,53.64 174.16,54.4 175.07,55.32 175.07,56.11 178.5,59.54 178.5,61.65 180.69,63.83 180.69,64.93 181.64,65.89 185.94,65.89 189.35,69.29 189.35,128.58 198.75,137.99 198.75,138.97 201.41,141.63 201.41,143.13 203.01,144.73 206.58,144.73 207.61,145.75 207.61,149.9 208.39,150.67 208.39,160.4 214.28,166.3 214.28,179.3 215.21,180.22 215.21,187.66 212.27,190.6 210.58,190.6 208.6,192.58 v4(207.55,192.58)
  S16 w0.127: v1(177.97,33.24) 177.13,34.08 177.13,39.25 175.38,41 175.38,47.47 177.1,49.2 177.1,49.66 176.26,50.51 176.26,52.2 CONN55_PF.5L6
  BOTTOM w0.127: v4(207.55,192.58) 208.23,192.58 208.5,192.31 212.63,192.31 v2(212.82,192.5) ; RB556.1 v1(177.97,33.24)
MOD_ABS23: length 203.7
  TOP w0.127: v4(203.55,197.58) U9.C14
  S5 w0.127: CONN55_PF.6T6 191.41,54.77 192.72,56.07 194.16,56.07 196,57.91 196,60.83 197.18,62.01 197.18,70.22 195.55,71.85 195.55,81.64 192.54,84.64 192.54,127.4 199.61,134.47 210.91,134.47 213.1,136.65 213.1,141.53 214.21,142.64 214.21,150.76 214.94,151.5 214.94,161.03 217.52,163.6 217.52,176.57 218.09,177.14 218.09,191.46 211.25,198.3 208.12,198.3 207.92,198.09 207.38,198.09 206.85,197.56 206.19,197.56 205.76,197.13 204.36,197.13 203.91,197.58 v4(203.55,197.58)
  S14 w0.127: CONN55_PF.6T6 191.41,52.03 189.68,50.29 187.95,50.29 186.83,49.17 186.83,48.39 189.4,45.82 189.4,41.55 188.36,40.51 188.36,36.11 v1(187.52,35.27)
  BOTTOM w0.127: v2(186.71,35.45) 186.88,35.27 v1(187.52,35.27) RB560.1
MOD_ABS24: length 197.5
  TOP w0.127: U9.D17 v4(206.55,196.58)
  S5 w0.127: CONN55_PF.6L6 189.74,52.3 188.41,53.64 188.41,54.02 189.32,54.94 189.32,56.11 192.45,59.23 192.45,62.34 193.72,63.61 193.72,71.65 191.68,73.68 191.68,127.55 199.18,135.05 210.58,135.05 212.46,136.93 212.46,141.88 213.34,142.76 213.34,161.08 216.75,164.49 216.75,177.2 217.24,177.68 217.45,177.77 217.45,190.89 211.76,196.58 v4(206.55,196.58)
  S16 w0.127: v1(192.22,33.24) 191.38,34.08 191.38,42.05 v1(190.78,42.64) 189.63,43.8 189.63,47.47 191.35,49.2 191.35,49.66 190.52,50.5 190.52,52.21 CONN55_PF.6L6
  BOTTOM w0.127: v2(189.7,42.77) 189.83,42.64 v1(190.78,42.64) ; RB559.1 v1(192.22,33.24)
MPHY_CPU_SGMII_RX_0_S_N: length 87
  TOP w0.095: v3(157.76,150.14) 157.47,149.85 157.12,149.85 156.8,150.16 156.8,150.79 156.94,150.93 J2.C27 ; U52.A8 v3(232.18,129.65)
  S9 w0.108: v3(232.18,129.65) 232.05,129.65 arc(231.88,129.72) 231.81,129.89 231.81,130.27 arc(231.53,130.94) 230.86,131.22 227.89,131.22 arc(227.58,131.28) 227.32,131.46 226.09,132.69 arc(226.05,132.75) 226.04,132.82 226.04,133.32 arc(225.98,133.61) 225.82,133.85 223.86,135.8 arc(223.42,136.1) 222.89,136.2 216.79,136.2 arc(216.15,136.33) 215.61,136.69 207.98,144.32 arc(207.32,144.76) 206.54,144.92 175.43,144.92 arc(174.99,145) 174.63,145.25 171.68,148.19 arc(171.19,148.52) 170.61,148.64 160.69,148.64 arc(160.44,148.69) 160.23,148.83 159.46,149.6 arc(159.19,149.78) 158.86,149.85 158.05,149.85 v3(157.76,150.14)
MPHY_CPU_SGMII_RX_0_S_P: length 87
  TOP w0.095: J2.C26 156.44,150.93 156.57,150.79 156.57,150.07 157.02,149.62 157.47,149.62 v3(157.76,149.33) ; U52.A7 v3(231.18,129.65)
  S9 w0.108: v3(157.76,149.33) 158.05,149.62 158.86,149.62 arc(159.1,149.57) 159.3,149.44 159.35,149.39 160.07,148.67 arc(160.36,148.48) 160.69,148.41 170.61,148.41 arc(171.1,148.31) 171.52,148.03 171.64,147.92 174.46,145.09 arc(174.91,144.79) 175.43,144.69 206.54,144.69 arc(207.23,144.55) 207.82,144.16 215.44,136.53 arc(216.06,136.12) 216.79,135.98 222.89,135.98 arc(223.33,135.89) 223.7,135.64 225.65,133.69 arc(225.77,133.52) 225.81,133.32 225.81,132.82 arc(225.84,132.66) 225.93,132.53 226.18,132.28 227.16,131.3 arc(227.5,131.07) 227.89,130.99 230.86,130.99 arc(231.37,130.78) 231.58,130.27 231.58,130.04 arc(231.47,129.77) 231.19,129.65 v3(231.18,129.65)
MPHY_INT_N: length 8
  TOP w0.127: RB761.1 RB759.1 v1(221.75,120.04) 222.88,118.91 225.44,118.91 U52.L1
  BOTTOM w0.127: v2(222.6,119.35) 221.91,120.04 v1(221.75,120.04) RB759.1
Net_866: length 0.7
  TOP w0.127: v4(52.7,110.65) 52.2,111.15
Net_867: length 0.7
  TOP w0.127: 54.2,110.15 v4(54.7,109.65)
Net_868: length 0.7
  TOP w0.127: 49.2,114.15 v4(49.7,113.65)
Net_869: length 0.7
  TOP w0.127: v4(54.7,111.65) 54.2,112.15
Net_870: length 0.7
  TOP w0.127: 54.2,114.15 v4(54.7,113.65)
Net_871: length 0.7
  TOP w0.127: 52.2,113.15 v4(52.7,112.65)
Net_872: length 0.7
  TOP w0.127: v4(56.7,108.65) 56.2,109.15
Net_873: length 0.7
  TOP w0.127: 56.2,111.15 v4(56.7,110.65)
Net_874: length 0.7
  TOP w0.127: v4(55.7,109.65) 55.2,110.15
Net_875: length 0.7
  TOP w0.127: 51.2,113.15 v4(51.7,112.65)
Net_876: length 0.7
  TOP w0.127: v4(55.7,111.65) 55.2,112.15
Net_877: length 0.7
  TOP w0.127: 56.2,113.15 v4(56.7,112.65)
Net_878: length 0.7
  TOP w0.127: v4(49.7,111.65) 49.2,112.15
Net_879: length 0.7
  TOP w0.127: v4(57.7,108.65) 57.2,109.15
Net_880: length 0.7
  TOP w0.127: 55.2,114.15 v4(55.7,113.65)
Net_881: length 0.7
  TOP w0.127: 57.2,111.15 v4(57.7,110.65)
Net_882: length 0.7
  TOP w0.127: v4(51.7,108.65) 51.2,109.15
Net_883: length 0.7
  TOP w0.127: v4(51.7,110.65) 51.2,111.15
Net_884: length 0.7
  TOP w0.127: 50.2,114.15 v4(50.7,113.65)
Net_885: length 0.7
  TOP w0.127: v4(50.7,111.65) 50.2,112.15
Net_886: length 0.7
  TOP w0.127: 49.2,110.15 v4(49.7,109.65)
Net_887: length 0.7
  TOP w0.127: 57.2,113.15 v4(57.7,112.65)
Net_888: length 0.7
  TOP w0.127: v4(52.7,108.65) 52.2,109.15
Net_889: length 0.7
  TOP w0.127: v4(50.7,109.65) 50.2,110.15
NIF_156.25M_N: length 196.9
  TOP w0.095: C432.1 13.72,102.96 13.24,102.96 v3(12.94,103.25) ; R1379.1 139.66,173.4 139.54,173.52 138.31,173.52 v3(137.92,173.12)
  S12 w0.108: v3(12.94,103.25) 13.24,102.96 13.55,102.96 14.72,104.13 14.72,105.96 15.89,107.13 15.89,114.81 12.53,118.17 10.8,118.17 10.17,118.8 10.17,135.95 16.98,142.76 34.35,142.76 37.95,146.35 58.01,146.35 63.9,152.25 71.34,152.25 74.99,155.9 99.96,155.9 103.64,152.22 127.41,152.22 138.84,163.65 138.84,164.65 arc(138.78,164.79) 138.64,164.85 arc(138.49,164.91) 138.44,165.05 138.44,165.26 arc(138.49,165.4) 138.64,165.46 arc(138.78,165.52) 138.84,165.67 138.84,165.88 arc(138.78,166.02) 138.64,166.08 arc(138.49,166.14) 138.44,166.28 138.44,166.49 arc(138.49,166.64) 138.64,166.7 arc(138.78,166.75) 138.84,166.9 138.84,173.45 138.73,173.56 138.36,173.56 v3(137.92,173.12)
NIF_156.25M_P: length 196.8
  TOP w0.095: v3(137.92,174.14) 138.31,173.75 139.56,173.75 139.66,173.84 R1378.1 ; v3(12.94,102.44) 13.24,102.73 13.72,102.73 C436.1
  S12 w0.108: v3(137.92,174.14) 138.27,173.79 138.82,173.79 139.07,173.54 139.07,163.55 127.51,151.99 103.55,151.99 99.86,155.67 75.09,155.67 71.43,152.02 64,152.02 58.1,146.12 38.04,146.12 34.45,142.53 17.07,142.53 10.4,135.85 10.4,118.9 10.9,118.39 12.63,118.39 16.12,114.9 16.12,107.03 14.95,105.86 14.95,104.04 13.64,102.73 13.24,102.73 v3(12.94,102.44)
NIF_LCPLL_AVDD1P8: length 5.5
  TOP w0.381: v4(34.7,109.65) U40.N23
  BOTTOM w0.381: CB641.2 34.2,110.14 v4(34.7,109.65) ; v4(34.7,109.65) 35.19,110.14 CB642.1 ; v4(34.7,109.65) 35.19,109.15 CB662.1 ; v4(34.7,109.65) 34.22,109.16 CB661.1 ; v2(16.09,93.32) 15.59,93.83 v1(14.47,93.83)
  vias: v1(13.94,94.31)
NIF_N_RX00: length 180.7
  TOP w0.152: v4(46.7,102.65) U40.F12
  S14 w0.102: v4(46.7,102.65) 46.7,102.91 46.83,103.04 47,103.04 47.1,102.95 47.1,101.32 47.37,101.06 57.89,101.06 57.97,100.98
  S14 w0.152: CONN53_PF.1T24 213.5,66.39 213.27,66.39 212.46,65.58 arc(212.35,65.45) 212.22,65.34 arc(211.31,64.89) 210.3,64.74 205.17,64.74 arc(203.48,65.05) 202,65.94 arc(202,65.94) 202,65.94 197.65,70.28 arc(195.86,71.48) 193.74,71.9 188.99,71.9 arc(187.85,72.1) 186.84,72.67 186.86,72.64 186.44,73.06 arc(185.69,73.58) 184.8,73.76 182.29,73.76 arc(180.78,74.06) 179.51,74.93 arc(177.78,76) 175.78,76.38 137.33,76.38 137.2,76.4 125.07,80.93 arc(119.62,82.42) 113.99,82.93 107.16,82.93 106.84,82.92 95.85,85.42 88.97,85.42 arc(83.6,86.49) 79.04,89.53 77.83,90.74 arc(71.97,94.66) 65.05,96.03 64.35,96.03 arc(64.33,96.03) 64.31,96.03 arc(63.01,96.31) 61.9,97.05 57.97,100.98
NIF_N_RX01: length 193
  TOP w0.152: v4(47.7,106.65) U40.K11
  S14 w0.102: v4(47.7,106.65) 47.7,106.44 arc(47.75,106.32) 47.87,106.27 48,106.27 arc(48.21,106.18) 48.3,105.97 48.3,105.6 arc(48.41,105.34) 48.67,105.23 48.68,105.23 arc(49.13,105.05) 49.31,104.61 49.31,104.59 arc(49.41,104.35) 49.66,104.24 58.21,104.24 58.28,104.32
  S14 w0.152: CONN53_PF.1T15 213.79,62.7 arc(213.82,62.85) 213.9,62.98 arc(213.91,62.99) 213.91,62.99 214.21,63.29 arc(214.31,63.42) 214.38,63.57 arc(214.4,63.65) 214.4,63.73 214.49,63.95 214.84,64.3 arc(215.18,64.52) 215.57,64.6 215.8,64.6 arc(217.52,65.31) 218.23,67.02 218.23,68.22 arc(218.03,69.18) 217.48,69.99 216.55,70.91 216.61,70.85 arc(215.82,71.48) 214.82,71.7 207.03,71.7 arc(205.63,71.97) 204.42,72.73 201.83,75.31 arc(200.53,76.21) 198.97,76.53 193.11,76.53 arc(191.66,76.82) 190.45,77.66 190.06,78.05 190.06,78.05 arc(188.17,79.22) 185.99,79.63 137.43,79.63 128.03,83.37 arc(128,83.38) 127.97,83.4 arc(122.34,85.32) 116.42,85.98 107.66,85.98 98.23,88.48 97.93,88.49 88.78,88.49 arc(84.97,89.25) 81.74,91.41 76.82,96.33 arc(72.81,99.01) 68.08,99.95 63.62,99.95 arc(63.19,100.03) 62.83,100.27 59.09,104.01 arc(58.75,104.24) 58.35,104.32 58.28,104.32
