# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
(no net) on BOTTOM: 81.65,68.65 79.87,68.65 79.81,68.59 79.81,67.32 80.31,66.81 80.31,64.97 80.29,64.95 80.29,64.63 80.17,64.5 79.8,64.5 79.62,64.32 79.62,63.38 79.93,63.06 81.52,63.06 81.58,63.13 81.58,63.38 81.65,63.44
(no net) on BOTTOM: 173.4,69.74 173.4,70.33 173.91,70.84 176.83,70.84 177.08,71.09 177.08,72.11 178.23,73.25 180.1,73.25 180.51,72.84 180.51,69.85 180.31,69.64 179.9,69.64 179.75,69.49 179.75,69.39 179.65,69.29 174.49,69.29 174.46,69.31 174.21,69.31 174.02,69.5 174.02,69.63 173.96,69.7 173.45,69.7
(no net) on BOTTOM: 34.7,68.5 34.7,67.53 33.93,66.77 33.93,66.01 34.57,65.37 34.57,64.61 34.82,64.36 34.82,63.22 34.7,63.09 33.04,63.09 32.54,63.6 32.54,68.5 32.69,68.65 34.54,68.65
(no net) on BOTTOM: 112.46,68.65 110.69,68.65 110.62,68.59 110.62,67.32 111.13,66.81 111.13,64.97 110.94,64.78 110.5,64.78 110.43,64.71 110.43,63.38 110.75,63.06 112.34,63.06 112.4,63.13 112.4,63.38 112.46,63.44
(no net) on BOTTOM: 66.19,69.57 66.19,70.33 66.7,70.84 69.62,70.84 69.87,71.09 69.87,72.11 71.02,73.25 72.9,73.25 73.3,72.84 73.3,69.85 73.1,69.64 72.69,69.64 72.54,69.49 72.54,69.39 72.44,69.29 67.28,69.29 67.18,69.39 67.18,69.46 67.08,69.57
(no net) on BOTTOM: 188.98,68.65 187.2,68.65 187.14,68.59 187.14,67.32 187.65,66.81 187.65,64.97 187.61,64.93 187.61,64.74 187.54,64.68 187.08,64.68 186.95,64.55 186.95,63.38 187.27,63.06 188.86,63.06 188.92,63.13 188.92,63.38 188.98,63.44
(no net) on BOTTOM: 115.61,68.5 115.61,67.53 114.85,66.77 114.85,66.01 114.87,65.99 114.8,65.92 114.8,65.18 115.26,64.72 115.38,64.72 115.74,64.36 115.74,63.22 115.61,63.09 113.96,63.09 113.46,63.6 113.46,68.5 113.61,68.65 115.46,68.65
(no net) on S7: 234.98,128.9 234.57,129.31 221.91,129.31 221.22,128.63 221.22,113.46 221.63,113.05 233.98,113.05 234.98,114.06
(no net) on S9: 221.47,125.39 221.47,115.36 222.52,114.31 236.45,114.31 237.26,115.12 237.26,121.3 236.94,121.61 234.77,121.61 232.56,119.4 225.97,119.4 224.91,120.46 224.91,125.54 224.63,125.82 221.9,125.82
(no net) on S12: 217.74,119.96 218.17,119.54 235.8,119.54 236.57,120.3 240.51,120.3 241.34,121.13 241.34,122.78 238.53,125.59 238.53,133.89 235.86,136.57 219.07,136.57 217.74,135.25
(no net) on S14: 239.89,135.37 222.17,135.37 221.2,134.4 221.2,123.4 220.73,122.93 220.73,121.65 223.36,119.02 240.53,119.02 240.94,119.43 240.94,134.33
(no net) on S16: 237.08,118.26 225.57,118.26 224.83,119 224.83,132.59 226.2,133.96 237.49,133.96 238.02,133.42 238.02,119.2
AP7362_VIN on BOTTOM: 227.03,149.28 222.98,149.28 222.7,149 222.7,147.66 222.96,147.4 222.96,145.11 223.45,144.62 223.45,144.21 223.94,144.21 223.95,144.2 223.95,144.16 224.32,143.79 227.59,143.79 227.76,143.96 227.76,148.55
BITS_1P8 on TOP: 197.69,216.53 197.69,218.72 196.07,220.34 194.99,220.34 194.85,220.19 194.85,218.6 195.8,217.65 195.8,217.28 196.65,216.43 197.59,216.43
BITS_1P8 on BOTTOM: 202.47,228.13 200.05,228.13 199.99,228.06 199.99,227.3 200.37,226.92 204.5,226.92 204.63,227.05 204.63,228.06 204.5,228.19 202.53,228.19
BITS_1P8 on BOTTOM: 197.64,217.07 197.64,218.59 197.39,218.84 196.12,218.84 195.86,218.59 195.86,217.07 196.12,216.81 197.39,216.81
BITS_1P8 on S14: 204.31,233.59 183.54,233.59 183.23,233.27 183.23,220.57 187.48,216.32 205.53,216.32 207.67,218.46 207.67,230.23
BITS_3P3 on BOTTOM: 203.41,223.48 203.23,223.3 203.23,222.73 202.34,222.73 202.28,222.79 202.28,223.35 202.15,223.48 200.18,223.48 200.06,223.36 200.06,220.87 200.24,220.69 202.28,220.69 202.28,220.7 202.47,220.89 202.47,221.4 202.53,221.46 203.23,221.46 203.29,221.4 203.29,220.75 203.36,220.69 204.93,220.69 205.2,220.95 205.2,223.24 204.96,223.48
BITS_3P3 on S12: 192.43,232.45 187.48,232.45 186.97,231.94 186.97,215.24 189.51,212.7 205.83,212.7 206.53,213.4 206.53,221.97 205.2,223.3 200.94,223.3 200.24,222.6 200.24,218.22 199.04,217.02 193.77,217.02 191.99,218.79 191.99,228.19 193.07,229.27 193.07,231.81
BITS_CHOKE_RRING on TOP: 245.25,38.14 245.58,37.82 246.69,37.82 247,38.14 247,48.05 246.72,48.33 244.8,48.33 244.73,48.27 244.73,44.39 245.25,43.87
BITS_CHOKE_RRING on BOTTOM: 242.41,39.86 241.96,39.41 241.96,36.35 242.08,36.24 245.72,36.24 245.75,36.26 246.56,36.26 246.98,36.68 246.98,39.22 246.34,39.86
BITS_CHOKE_RRING on BOTTOM: 246.02,50.55 241.7,50.55 241.58,50.44 241.58,47.83 241.87,47.55 245.8,47.55 246.17,47.92 246.17,50.4
BITS_CHOKE_RTIP on TOP: 244.63,43.75 242.43,43.75 242.24,43.56 242.24,40.95 242.48,40.71 244,40.71 244.79,41.5 244.79,43.59
BITS_CHOKE_RTIP on BOTTOM: 246.08,45.09 241.67,45.09 241.59,45 241.59,41.18 241.45,41.04 238.52,41.04 238.26,40.79 238.26,36.44 238.47,36.23 241.13,36.23 241.26,36.36 241.26,39.9 241.46,40.09 244.54,40.09 244.79,40.34 244.79,42.87 245,43.08 245.98,43.08 246.25,43.34 246.25,44.92
BITS_CHOKE_TRING on TOP: 238.34,36.41 238.49,36.27 241.17,36.27 241.34,36.44 241.34,47.72 241.03,48.04 238.69,48.04 238.34,47.69
BITS_CHOKE_TRING on BOTTOM: 240.76,50.63 236.57,50.63 236.32,50.37 236.32,47.78 236.61,47.49 240.69,47.49 240.95,47.74 240.95,50.44
BITS_CHOKE_TTIP on TOP: 244.96,39.86 242.51,39.86 242.02,39.37 242.02,36.32 242.09,36.26 244.74,36.26 245.06,36.58 245.06,39.76
BITS_CHOKE_TTIP on TOP: 237.5,43.71 236.17,43.71 236,43.54 236,40.48 236.23,40.25 237.28,40.25 237.64,40.61 237.64,43.57
BITS_CHOKE_TTIP on BOTTOM: 240.89,45.12 236.22,45.12 235.98,44.88 235.98,40.49 236.22,40.25 237.29,40.25 237.64,40.6 237.64,42.5 238.01,42.88 240.79,42.88 241.2,43.29 241.2,44.8
BITS_CHOKE_TTIP on S9: 243.88,39.9 239.61,39.9 237.9,41.61 236.32,41.61 236.04,41.33 236.04,39.14 237.24,37.94 243.66,37.94 244.04,38.33 244.04,39.73
BITS_RVDD3V3 on TOP: 199.42,222.61 199.42,224.89 199.26,225.04 197.55,225.04 196.94,224.43 196.94,223.03 197.53,222.45 199.26,222.45
BITS_RVDD3V3 on BOTTOM: 199.42,222.59 199.42,224.56 199.16,224.81 197.7,224.81 197.01,224.11 197.01,223.48 197.96,222.53 199.36,222.53
BITS_TVDD3V3 on TOP: 199.42,219.34 199.42,221.66 199.26,221.82 197.84,221.82 197.59,221.56 197.59,219.73 198.09,219.22 199.3,219.22
BITS_TVDD3V3 on BOTTOM: 199.42,219.91 199.42,221.64 199.36,221.7 197.96,221.7 197.7,221.45 197.7,219.67 197.79,219.58 199.09,219.58
BITS_TVDD3V3 on S12: 198.72,222.29 197.39,222.29 196.82,222.86 193.2,222.86 192.37,222.03 192.37,221.08 194.34,219.11 198.47,219.11 198.85,219.49 198.85,222.16
BITS_VDD1V8 on TOP: 199.42,225.76 199.42,228.06 199.29,228.19 197.82,228.19 197.56,227.94 197.56,225.91 197.79,225.68 199.34,225.68
BITS_VDD1V8 on BOTTOM: 199.42,226.34 199.42,228.05 199.29,228.18 197.89,228.18 197.64,227.92 197.64,226.34 197.89,226.08 199.16,226.08
BITS_VDD1V8 on S12: 198.59,227.87 195.8,227.87 195.04,227.11 193.45,227.11 193.2,227.37 192.94,227.37 192.43,226.86 192.43,225.59 192.75,225.27 194.78,225.27 195.55,226.03 198.53,226.03 198.78,226.29 198.78,227.68
BS_PLL_AVDD1P8 on TOP: 13.37,100.91 13.17,100.71 11.93,100.71 11.88,100.66 11.88,99.18 11.9,99.16 15.12,99.16 15.15,99.2 15.15,100.78 15.03,100.91
BS_PLL_AVDD1P8 on S9: 13.21,100.05 13.21,101.32 13.71,101.83 16.45,101.83 16.89,102.27 16.89,109.45 22.74,115.29 26.67,115.29 27.31,114.66 27.31,111.76 25.71,110.16 23.31,110.16 19.7,106.55 19.7,100.7 18.8,99.8 13.46,99.8
CPLD2_3V3 on BOTTOM: 211.17,206.6 205.07,206.6 204.69,206.22 204.69,204.52 204.73,204.52 205.16,204.08 208.48,204.08 211.73,200.84 215.12,200.84 215.23,200.94 215.23,207.61 214.91,207.93 212.27,207.93 212.13,207.79 212.13,207.56
CPLD2_3V3 on S16: 208.37,206.92 193.13,206.92 188.69,202.47 188.69,181.14 190.66,179.17 208.31,179.17 210.21,181.07 210.21,205.08
CPLD_VDD1P8 on BOTTOM: 197.61,190.07 197.79,190.07 197.92,189.94 199.19,189.94 199.31,189.82 199.31,189.44 199.44,189.31 199.64,189.31 199.82,189.49 199.82,189.77 199.64,189.94 199.64,190.76 198.55,191.85 197.54,191.85 197.46,191.77 197.46,190.22
CPLD_VDD1P8 on BOTTOM: 33.94,238.16 32.29,238.16 31.37,237.24 31.37,232.28 31.9,231.75 34.26,231.75 35.14,232.64 35.14,236.95
CPLD_VDD1P8 on S5: 176.69,243.37 200.86,243.37 210.28,233.94 225.86,233.94 232,227.8 232,214.83 224.75,207.57 220.92,207.57 218.69,205.34 218.69,204.23 224.51,198.42 224.51,184.75 225.58,183.68 240.38,183.68 243.68,186.98 243.68,234.67 219.72,258.63 156.22,258.63 150.8,253.21 137.57,253.21 132.13,258.65 32.92,258.65 31.95,257.68 31.95,251.39 32.03,251.31 32.03,247.81 31.37,247.14 31.37,232.29 31.91,231.75 34.26,231.75 43.05,240.54 173.86,240.54
CPLD_VDD1P8 on V18: 191.1,199.36 191.1,184.88 193.58,182.41 225.96,182.41 226.85,183.3 226.85,200.38 226.34,200.89 192.62,200.89
CPLL_AVDD1P8 on TOP: 63.02,114.62 63.02,113.08 62.85,112.92 60.54,112.92 60.42,113.05 60.42,116.69 60.53,116.8 62.63,116.8 62.79,116.64 62.79,114.85
CPLL_AVDD1P8 on S12: 41.06,118.94 41.06,117.5 41.72,116.84 60.56,116.84 61.22,116.18 62.49,116.18 62.61,116.31 62.61,120.01 62.57,120.05 62.57,121.9 61.63,122.84 44.97,122.84
DDR_AB_AVDD1P8 on TOP: 55.83,142.05 55.92,141.96 55.92,140.74 55.79,140.6 55.79,138.56 55.5,138.28 53.13,138.28 52.74,138.66 52.74,141.62 53.18,142.05
DDR_AB_AVDD1P8 on S9: 29.12,124.91 42.97,124.91 43.22,124.65 43.22,120.21 42.97,119.96 29.25,119.96 28.87,120.34 28.87,124.65
DDR_AB_AVDD1P8 on S12: 43.98,127.83 43.98,123.77 43.22,123 36.23,123 36.11,123.13 36.11,129.61 36.74,130.24 36.74,131.08 45.68,140.02 54.23,140.02 54.58,139.67 54.58,137.64 54.32,137.39 49.24,137.39 47.72,135.86 47.72,132.56 44.01,128.85 44.01,128.01 44.01,128.01 44.01,127.86
DDR_ABC_AVDD1P8 on TOP: 59.55,117.46 59.31,117.71 59.31,119.96 59.34,119.99 59.34,120.37 59.88,120.91 62.04,120.91 62.26,120.69 62.26,117.76 61.96,117.46
DDR_ABC_AVDD1P8 on S5: 61.85,118.12 61.48,117.75 46.33,117.75 45.85,118.23 45.85,124.06 46.1,124.31 49.79,124.31 52.77,121.33 59.91,121.33 61.85,119.39
DDR_GEN_VCCA on TOP: 90.54,194.13 86.54,194.13 86.26,193.85 86.26,193.27 86.07,193.08 85.14,193.08 85.08,193.01 85.08,192.03 85.14,191.97 85.33,191.97 85.42,192.06 89.31,192.06 90.36,193.11 90.41,193.11 90.61,193.3 90.61,194.07
DDR_GEN_VDD on TOP: 86.6,185.3 86.48,185.18 86.48,183.59 88.7,183.59 88.76,183.65 88.76,184.41 87.87,185.3
FC_SYNC_VDDP_1P8 on TOP: 14.83,137.09 14.88,137.13 14.88,138.5 14.99,138.62 15.21,138.62 15.81,139.22 15.81,139.6 15.61,139.8 15.05,139.8 12.21,136.95 10.51,136.95 10.28,136.73 10.28,135.25 10.35,135.18 11.73,135.18 11.98,135.43 12.56,135.43 13.05,135.91 13.05,136.5 13.1,136.55 13.99,136.55 14.53,137.09
FC_SYNC_VDDP_1P8 on S12: 30.9,123.29 30.65,123.04 29.21,123.04 28.96,122.79 28.96,122.24 28.7,121.99 27.6,121.99 27.22,122.37 27.22,132.3 26.02,133.49 26.02,135.25 21.9,139.36 18.45,139.36 16.57,137.48 14.93,137.48 14.32,138.09 14.32,139.04 17.19,141.9 23.76,141.9 30.9,134.76
FPGA_1V2 on BOTTOM: 76.8,238.87 76.8,230.85 77.03,230.62 79.84,230.62 80.1,230.89 80.1,238.79 79.8,239.1 77.03,239.1
FPGA_1V2 on BOTTOM: 118.84,206.86 119.03,207.05 119.03,209.4 118.08,210.35 116.96,210.35 115.85,209.24 115.85,207.17 116.17,206.86
FPGA_1V2 on V18: 34.95,219.11 37.43,216.63 51.84,216.63 63.47,205.01 119.34,205.01 122.15,207.82 122.15,230.32 117.04,235.43 77.12,235.43 75.91,234.22 75.91,224.83 74.83,223.75 41.24,223.75 39.78,225.21 39.78,230.1 38.83,231.05 35.97,231.05 34.95,230.03
FPGA_2V5 on BOTTOM: 79.14,228.98 76.04,228.98 75.51,228.45 75.51,225.36 75.53,225.33 76.1,225.33 76.17,225.27 76.17,224.7 76.04,224.57 75.57,224.57 75.51,224.51 75.51,215.62 76.17,215.62 76.23,215.55 76.23,214.79 76.1,214.67 75.57,214.67 75.51,214.6 75.51,211.62 75.52,211.61 75.52,205.47 76.74,204.25 78.2,204.25 79.15,205.2 79.15,206.57 79.14,206.59 79.14,211.54 79.09,211.59 79.09,225.74 79.74,226.4 79.74,228.38
FPGA_2V5 on BOTTOM: 38.64,238.16 36.1,238.16 35.97,238.03 35.97,232.32 36.35,231.94 39.14,231.94 39.4,232.19 39.4,237.4
FPGA_2V5 on S9: 56.35,218.16 56.61,217.9 75.02,217.9 77.5,220.38 77.5,224.95 76.93,225.52 41.49,225.52 39.84,227.18 39.84,237.02 37.81,239.05 36.41,239.05 34.38,237.02 34.38,221.02 37.3,218.09 56.29,218.09
FPGA_VCCA_2V5 on BOTTOM: 84.52,226.67 84.52,226.44 85.08,225.88 85.08,224.91 85.49,224.51 87.48,224.51 87.9,224.93 87.9,225.59 87.53,225.96 87.53,229.02 87.34,229.21 84.23,229.21 83.98,228.95 83.98,227.21
FPGA_VCCA_2V5 on S12: 112.11,229.33 97.25,229.33 97.22,229.3 86.36,229.3 86.01,228.95 86.01,224.44 86.33,224.13 96.49,224.13 96.55,224.06 101.5,224.06 102.71,222.86 102.71,218.48 100.7,216.46 100.7,214.91 100.49,214.7 98.87,214.7 98.71,214.54 98.71,212.44 98.96,212.19 113.31,212.19 113.63,212.51 113.63,215.11 113.19,215.55 109.38,215.55 107.79,217.14 107.79,225.21 108.61,226.03 111.98,226.03 112.49,226.54 112.49,228.95
HEATER_VCC12 on TOP (solid shape): 262.39,162.42 262.39,160.24 261.74,159.58 260.23,159.58 259.78,160.03 259.78,162.48 259.94,162.64 262.17,162.64
HEATER_VCC12 on TOP: 248.12,259.18 242.79,259.18 241.9,258.29 241.9,246.61 242.28,246.23 247.62,246.23 248.25,246.86 248.25,259.05
HEATER_VCC12 on BOTTOM: 73.12,230.03 69.69,230.03 69.31,229.65 69.31,224.13 69.75,223.68 72.42,223.68 73.43,224.7 73.43,229.72
HEATER_VCC12 on V3: 265.31,253.95 258.61,260.65 242.71,260.65 242.01,259.95 242.01,257.66 245.04,254.63 251.67,254.63 257.95,248.35 257.95,187.81 255.1,184.97 255.1,121.74 256.24,120.59 256.22,120.5 256.25,120.5 257.27,119.48 263.74,119.48 265.31,121.05
HEATER_VCC12 on S16: 61.43,223.62 57.37,227.68 57.37,251.43 64.29,258.35 137.38,258.35 141.44,254.29 149.25,254.29 155.48,260.51 249.14,260.51 249.65,260 249.65,247.05 248.57,245.97 160.11,245.97 156.68,242.54 123.35,242.54 122.27,243.62 80.48,243.62 75.94,239.08 75.94,227.21 72.36,223.62 ; 2 cut-outs
IO_VDDP_1P8 on TOP: 18.16,140.65 18.28,140.76 18.51,140.76 19.23,141.48 20.35,141.48 20.42,141.55 20.42,144.56 19.89,145.08 19.89,146.38 20.21,146.7 21.71,146.7 21.94,146.48 21.94,144.63 22.2,144.37 22.2,141.74 19.56,139.1 19.56,136.38 19.43,136.25 18.29,136.25 18.16,136.38
IO_VDDP_1P8 on S16: 17.82,132.53 17.82,138.07 18.14,138.39 18.15,138.38 20.29,138.38 20.69,137.97 20.69,136.6 21.28,136.01 24.75,136.01 29.94,130.82 29.94,116.27 29.47,115.8 19.6,115.8 19.27,116.13 19.27,116.13 18.86,116.53 18.86,117.8 18.15,118.51 18.15,132.2
L1_RCVRD_CLK_BKUP_VDD on TOP: 168.62,175.61 165.7,175.61 165.45,175.36 165.45,173.77 165.51,173.71 166.84,173.71 167.1,173.96 167.99,173.96 168.49,173.45 172.18,173.45 172.24,173.52 172.24,174.34 169.89,174.34
L1_RCVRD_CLK_VDD on TOP: 171.67,180.69 167.1,180.69 166.34,179.93 165.51,179.93 165.45,179.87 165.45,178.47 165.64,178.28 166.02,178.28 166.59,178.85 168.11,178.85 168.43,178.53 172.05,178.53 172.3,178.79 172.3,180.06
MAC_HS1 on TOP (solid shape): outline of 268 points within 63.18,142.22 72.07,151.11
MAC_HS1 on BOTTOM (solid shape): outline of 268 points within 63.18,142.22 72.07,151.11
MAC_HS2 on TOP (solid shape): outline of 268 points within 63.18,81.22 72.07,90.11
MAC_HS2 on BOTTOM (solid shape): outline of 268 points within 63.18,81.22 72.07,90.11
MAC_HS3 on TOP (solid shape): outline of 268 points within 6.28,142.22 15.17,151.11
MAC_HS3 on BOTTOM (solid shape): outline of 268 points within 6.28,142.22 15.17,151.11
MAC_HS4 on TOP (solid shape): outline of 268 points within 6.28,81.22 15.17,90.11
MAC_HS4 on BOTTOM (solid shape): outline of 268 points within 6.28,81.22 15.17,90.11
MANG_1P2 on TOP: 219.52,135.4 217.95,135.4 217.74,135.2 217.74,132.69 218.08,132.36 219.47,132.36 219.68,132.56 219.68,135.25
MANG_1P2 on V18: 34.38,226.67 34.38,244.83 37.81,248.26 145.82,248.26 145.89,248.32 227.68,248.32 231.8,244.19 231.8,152.5 227.36,148.05 216.94,148.05 215.1,146.21 215.1,134.78 217.39,132.5 229.07,132.5 229.26,132.69 241.65,132.69 242.85,131.48 248.76,131.48 252.7,135.42 252.7,256.7 249.52,259.88 152.75,259.88 152.75,259.81 150.4,259.81 150.33,259.74 30.57,259.74 26.06,255.24 26.06,225.27 27.78,223.56 33.75,223.56 34.51,224.32 34.51,226.54
MANG_1P2_DVDD on S14 (solid shape): outline of 4467 points within 220.73,119.02 240.94,135.37
MANG_1P2_DVDD on TOP: 222.37,133.55 220.41,133.55 220.36,133.5 220.36,129.49 220.41,129.44 222.14,129.44 222.44,129.74 222.44,133.47
MANG_2P5 on TOP (solid shape): 237.82,135.69 237.82,134.53 237.76,134.47 236.95,134.47 236.52,134.9 236.52,135.96 237.56,135.96
MANG_2P5 on TOP: 216.06,129.51 214.66,129.51 214.47,129.32 214.47,127.48 215.36,126.59 215.93,126.59 216.18,126.85 216.18,129.39
MANG_2P5 on TOP: 219.57,126.18 216.96,126.18 216.83,126.06 216.83,124.23 216.93,124.13 217.8,124.13 218.41,124.74 219.37,124.74 219.62,124.99 219.62,126.13
MANG_2P5 on TOP: 219.74,111.29 217.9,111.29 217.83,111.22 217.83,108.81 218.02,108.62 219.55,108.62 219.8,108.87 219.8,111.1 219.74,111.16
MANG_2P5 on TOP: 241.27,137.28 239.87,137.28 239.64,137.06 239.64,134.52 239.87,134.29 241.27,134.29 241.52,134.54 241.52,137.03
MANG_2P5 on S7: 212.38,130.47 212.38,118.09 212.25,117.96 212.25,100.24 218.28,94.21 232.76,94.21 234.22,95.67 234.22,96.3 220.75,109.76 220.75,130.97 221.52,131.73 241.84,131.73 242.5,132.4 242.5,138.12 242.15,138.47 220.37,138.47 ; 1 cut-out
MANG_2P5_AVDD on S7 (solid shape): outline of 3773 points within 221.22,113.05 234.98,129.31
MANG_2P5_AVDD on TOP: 222.57,114.17 220.46,114.17 220.41,114.12 220.41,110.39 220.59,110.21 221.33,110.21 221.55,110.44 221.55,113 221.71,113.15 222.62,113.15 222.88,113.41 222.88,113.87
MANG_2P5_IN on TOP: 230.6,135.2 229.58,135.2 229.45,135.33 229.45,135.99 228.92,136.52 225.52,136.52 225.23,136.81 223.74,136.81 223.68,136.75 223.68,135.86 224.03,135.51 226.91,135.51 227.04,135.38 228.29,135.38 229.02,134.64 230.39,134.64 230.6,134.85
MANG_2P5_VDDO on S12 (solid shape): outline of 4902 points within 218.09,119.54 241.27,136.57
MANG_2P5_VDDO on TOP: 219.65,129.03 218.3,129.03 218.1,128.83 218.1,127.78 218.02,127.71 216.96,127.71 216.86,127.61 216.86,126.69 217.01,126.54 219.52,126.54 219.68,126.69 219.68,128.98 219.65,129
MANG_2P5_VDDOH on S16 (solid shape): outline of 3594 points within 224.83,118.26 237.59,133.96
MANG_2P5_VDDOH on TOP: 238.95,135.33 238.17,135.33 238.12,135.28 238.12,133.78 237.96,133.63 236.85,133.63 236.69,133.47 236.69,131.7 236.97,131.42 238.85,131.42 238.98,131.54 238.98,135.3
MANG_2P5_VDDOX on TOP (solid shape): 222.77,125.74 222.77,122.59 222.32,122.14 221.42,122.14 221.07,122.28 220.71,122.15 220.69,122.14 220.54,122.14 220.29,122.39 220.29,123.11 220.28,123.11 220.28,123.76 220.29,123.76 220.29,124.57 220.28,124.57 220.28,125.95 220.54,126.2 222.32,126.2
MANG_2P5_VDDOX on S9 (solid shape): outline of 1399 points within 221.47,114.31 237.26,125.82
NIF_LCPLL_AVDD1P8 on TOP: 14.85,95.96 14.8,96.02 13.71,96.02 13.62,95.93 11.93,95.93 11.85,95.86 11.85,94.1 12.61,93.34 14.72,93.34 14.85,93.47
NIF_LCPLL_AVDD1P8 on S9: 12.96,96.62 13.21,96.88 24.66,96.88 25.82,98.04 25.82,102.84 32.04,109.05 32.08,109.05 32.99,109.96 35.05,109.96 35.31,109.71 35.31,107.51 34.95,107.16 34.95,107.16 34.82,107.03 34.19,107.03 34.13,106.97 34.13,104.3 33.94,104.11 33.52,104.11 33.39,103.99 33.39,100.33 25.49,92.43 13.22,92.43 12.96,92.7
NIF_PVDD10 on TOP: 106.54,96.31 103.95,96.31 103.24,95.6 103.24,92.58 103.98,91.84 106.72,91.84 106.9,92.02 106.9,95.96
NIF_PVDD10 on TOP: 45.82,89.26 42.93,89.26 42.67,89.51 42.67,95.48 43.06,95.86 48.01,95.86 48.14,95.74 48.14,91.8 48.01,91.67 46.74,91.67 46.72,91.65 46.3,91.65 46.07,91.41 46.07,89.51
NIF_PVDD10 on V3: 43.72,93.69 43.72,95.54 44.76,96.57 87.05,96.57 90.72,100.24 104.49,100.24 106.28,98.45 106.28,91.94 105.77,91.43 104.1,91.43 102.42,93.11 98.45,93.11 95.13,89.79 47.63,89.79
NIF_PVDD10 on S7: 46.19,92.85 63.29,92.85 65.82,95.38 65.82,104.14 54.17,115.79 40.21,115.79 37.48,113.06 37.48,108.36 38.87,106.96 39.79,106.96 39.99,107.16 42.61,107.16 43.12,106.65 43.12,97.66 45.58,95.2 45.58,93.46
NIF_TRVDD10 on TOP (solid shape): 82.97,85.27 82.97,82.88 82.64,82.55 74.5,82.55 73.5,83.55 73.5,85.36 73.81,85.67 82.57,85.67
NIF_TRVDD10 on TOP: 55.5,89 52.71,89 52.58,89.13 52.58,91.54 52.45,91.67 48.9,91.67 48.77,91.8 48.77,95.61 49.02,95.86 55.5,95.86 56.01,95.35 56.01,89.51
NIF_TRVDD10 on V18: 32.13,106.81 32.37,107.04 57.51,107.04 57.91,106.63 58.09,106.63 58.51,106.21 74.45,106.21 77.82,102.84 77.82,84.05 76.42,82.65 39.59,82.65 32.13,90.1
NIF_TVDD1P25 on TOP: 68.8,98.27 78.96,98.27 80.61,96.62 80.61,94.33 79.34,93.06 68.29,93.06 66.64,94.71 66.64,96.62 66.26,97 61.94,97 61.69,97.25 61.69,103.68 62.5,104.49 65.37,104.49 65.5,104.37 65.5,103.99 66.77,102.72 66.77,100.3
NIF_TVDD1P25 on S12: 37.69,110.06 41.88,114.25 65.31,114.25 66.39,113.17 66.39,102.44 65.89,101.94 63.87,101.94 61.94,103.87 61.94,104.75 60.41,106.27 50.71,106.27 50.32,105.89 50.32,99.27 50.06,99.01 43.37,99.01 43.23,99.15 43.23,100.69 42.75,101.17 41.46,101.17 41.25,100.96 41.25,100.59 41,100.34 40.42,100.34 40.42,100.84 40.13,101.14 36.36,101.14 36.29,101.07 36.29,99.64 35.94,99.29 35.56,99.29 35.28,99.56 35.28,100.98 35.02,101.24 35.02,105.97 36.21,107.17 37.69,107.17
NIF_TVDD1P25 on S14: 41.21,102.47 35.29,102.47 34.76,101.94 34.76,99.24 35.34,98.66 40.55,98.66 41.46,99.57 41.46,102.22
NIFE_LCPLL_AVDD1P8 on TOP: 11.85,98.24 11.85,96.64 11.9,96.59 13.22,96.59 13.3,96.67 14.95,96.67 15,96.72 15,98.14 14.65,98.5 12.11,98.5
NIFE_LCPLL_AVDD1P8 on S9: 25.01,102.67 25.01,97.91 24.61,97.51 13.63,97.51 13.26,97.88 13.26,98.91 13.37,99.01 18.89,99.01 20.18,100.3 20.18,106.45 23.59,109.85 25.87,109.85 28.06,112.04 28.06,114.63 28.59,115.17 45.47,115.17 46.23,114.4 46.23,112.33 45.61,111.71 34.05,111.71
NIFE_PVDD10 on TOP: 65.62,107 63.08,107 62.67,107.41 61.18,107.41 60.93,107.67 60.93,109.95 61.05,110.08 67.28,110.08 67.4,110.21 67.4,110.42 67.42,110.44 67.42,112.64 68.67,113.89 72.48,113.89 72.99,113.38 72.99,104.11 72.48,103.6 66.77,103.6 66.13,104.24 66.13,106.49
NIFE_PVDD10 on S5: 43.31,101.58 41.13,99.4 30.75,99.4 28.26,101.89 28.26,111.2 29.29,112.23 29.42,112.23 29.42,114.96 28.96,115.42 28.96,119.48 29.09,119.61 45.08,119.61 45.08,118.75 45.67,118.16 52.95,118.16 53.34,117.76 53.34,117.7 54.49,116.56 70.73,116.56 72.24,115.05 72.24,108.55 65.27,101.58
NIFE_TRVDD10_S1 on TOP: 29.72,90.02 26.93,90.02 26.67,90.27 26.67,91.29 26.16,91.8 18.29,91.8 18.16,91.93 18.16,94.34 19.43,95.61 30.1,95.61 30.23,95.48 30.23,90.53
NIFE_TRVDD10_S1 on BOTTOM: 100.09,92.3 100.55,92.76 102.89,92.76 103.6,92.05 103.6,90.35 104.54,89.41 107.08,89.41 108.92,87.56 108.92,83.18 108.58,82.84 105.94,82.84 100.09,88.69
NIFE_TRVDD10_S1 on V3: outline of 121 points within 18.82,75.98 103.13,105.95 ; 32 cut-outs
NIFE_TRVDD10_S1 on S7: 14.65,113.89 11.75,111 11.75,99.26 17.36,93.65 17.36,92.02 18.76,90.62 29.07,90.62 29.76,91.31 29.76,95.27 33.11,98.63 33.11,107.03 33.29,107.21 35.42,107.21 35.5,107.29 35.5,111.5 33.11,113.89
NIFE_TRVDD10_S2 on TOP: 84.67,101.57 84.67,98.52 84.93,98.27 87.6,98.27 87.98,98.65 87.98,101.57 87.72,101.83 84.93,101.83
NIFE_TRVDD10_S2 on BOTTOM: 82.9,102.33 87.6,102.33 87.98,101.95 87.98,98.65 87.6,98.27 84.93,98.27 84.67,98.52 84.67,100.3 84.55,100.43 82.77,100.43 82.64,100.56 82.64,102.08
NIFE_TRVDD10_S2 on S5: 58.94,101.33 44.8,101.33 44.29,100.82 44.29,99.6 43.72,99.03 43.72,93.67 45.56,91.83 82.8,91.83 88.42,97.44 88.42,101.99 87.77,102.64 67.8,102.64 65.96,100.8 59.47,100.8
NIFE_TRVDD10_S2 on S9: 75.33,112.24 83.83,112.24 88.01,108.05 88.01,99.04 87,98.03 82.42,98.03 79,101.45 57.59,101.45 57.25,101.11 57.25,100.58 57.23,100.58 56.75,100.1 56.46,100.1 56.46,101.18 56.19,101.45 53.45,101.45 53.21,101.21 53.21,99.25 53.02,99.06 52.47,99.06 52.15,99.38 52.15,101.31 52.01,101.45 49.61,101.45 49.41,101.65 49.41,114.69 49.6,114.88 72.69,114.88
PCIE_PVDD10 on TOP: 9.46,108.13 9.57,108.02 10.79,108.02 11.18,108.42 11.18,109.29 10.88,109.59 10.88,112.38 10.65,112.61 10.65,113.42 10.49,113.59 9.67,113.59 9.62,113.54 9.62,109.85 9.46,109.7
PCIE_TRDD10 on TOP: 9.72,101.47 9.97,101.22 11.52,101.22 11.65,101.34 12.13,101.34 12.36,101.57 12.36,106.83 11.83,107.36 9.54,107.36 9.49,107.31 9.49,105.64 9.72,105.41
PCIE_TRDD10 on BOTTOM: 20.31,115.46 21.27,115.46 21.78,115.97 24.22,115.97 24.63,115.56 24.63,115.17 23.99,114.53 20.83,114.53 20.7,114.4 20.7,113.9 20.83,113.77 20.83,113.52 19.78,112.46 19.78,93.97 18.95,93.15 17.23,93.15 15.75,94.63 12.82,94.63 10.42,97.03 10.42,102.09 10.46,102.13 10.46,102.85 11.25,103.64 16.88,103.64 17.44,104.2 17.44,112.59
QSFP1_R on BOTTOM: 11.9,42.47 19.44,42.47 19.64,42.67 19.64,46.32 20.52,47.19 20.52,48.03 20.75,48.27 20.75,52.31 19.96,53.11 17.17,53.11 17.12,53.05 17.12,51.85 17.17,51.79 19.78,51.79 19.96,51.61 19.96,48.72 18.94,47.7 18.94,46.91 17.94,45.91 17.94,44.43 17.62,44.1 15.58,44.1 15.53,44.16 12.73,44.16 12.73,47.41 12.67,47.47 10.13,47.47 10,47.34 10,46.07 10.25,45.82 11.01,45.82 11.14,45.69 11.14,43.6 11.78,43.6 11.84,43.53 11.84,42.53
QSFP2_R on TOP: 212.88,83.54 210.59,83.54 210.34,83.28 210.34,82.52 210.09,82.27 209.71,82.27 209.44,82 209.44,81.74 209.81,81.37 209.81,80.11 215.67,80.11 215.87,80.3 215.87,82.2 215.74,82.33 214.85,82.33 214.85,82.9 214.66,83.09 214.66,83.41 214.28,83.79 212.94,83.79 212.94,83.6
QSFP2_R on BOTTOM: 212.56,82.71 209.71,82.71 209.32,82.33 209.32,80.24 209.58,79.98 212.44,79.98 212.82,80.36 212.82,82.46
QSFP3_R on TOP: 207.67,83.54 207.29,83.92 203.74,83.92 202.15,82.33 200.88,82.33 199.99,81.44 199.99,77.82 200.18,77.63 201.32,77.63 201.45,77.76 201.45,80.05 201.9,80.49 202.78,80.49 203.17,80.11 209.17,80.11 209.27,80.21 209.27,81.47 209.15,81.59 209.15,82.29 209.26,82.4 209.77,82.4 209.83,82.46 209.83,83.41 209.71,83.54
SCREW1 on TOP (solid shape): outline of 235 points within 187.86,159.7 194.87,166.7
SCREW1 on BOTTOM (solid shape): outline of 235 points within 187.86,159.7 194.87,166.7
SCREW2 on TOP (solid shape): outline of 235 points within 87.96,141.91 94.96,148.91
SCREW2 on BOTTOM (solid shape): outline of 235 points within 87.96,141.91 94.96,148.91
SCREW3 on TOP (solid shape): outline of 235 points within 141.15,255.2 148.15,262.2
SCREW3 on BOTTOM (solid shape): outline of 235 points within 141.15,255.2 148.15,262.2
SCREW4 on TOP (solid shape): outline of 235 points within 3.7,253.2 10.7,260.2
SCREW4 on BOTTOM (solid shape): outline of 235 points within 3.7,253.2 10.7,260.2
SCREW5 on TOP (solid shape): outline of 235 points within 213.33,224 220.34,231
SCREW5 on BOTTOM (solid shape): outline of 235 points within 213.33,224 220.34,231
SCREW6 on TOP (solid shape): outline of 235 points within 261.15,255.2 268.16,262.2
SCREW6 on BOTTOM (solid shape): outline of 235 points within 261.15,255.2 268.16,262.2
SCREW7 on TOP (solid shape): outline of 235 points within 261.15,95.2 268.15,102.2
SCREW7 on BOTTOM (solid shape): outline of 235 points within 261.15,95.2 268.15,102.2
SCREW8 on TOP (solid shape): outline of 235 points within 243.33,224 250.34,231
SCREW8 on BOTTOM (solid shape): outline of 235 points within 243.33,224 250.34,231
SCREW9 on TOP (solid shape): outline of 235 points within 26.8,213.2 33.8,220.2
SCREW9 on BOTTOM (solid shape): outline of 235 points within 26.8,213.2 33.8,220.2
SCREW10 on TOP (solid shape): outline of 213 points within 202.72,137 209.34,144.01
SCREW10 on BOTTOM (solid shape): outline of 235 points within 202.34,137 209.34,144
SCREW11 on TOP (solid shape): outline of 235 points within 159.85,203.7 166.86,210.7
SCREW11 on BOTTOM (solid shape): outline of 235 points within 159.85,203.7 166.86,210.7
SCREW12 on TOP (solid shape): outline of 235 points within 95.07,68.1 102.08,75.11
SCREW12 on BOTTOM (solid shape): outline of 235 points within 95.07,68.1 102.08,75.11
SCREW14 on TOP (solid shape): outline of 228 points within 261.45,49.11 268.46,56.12
SCREW14 on BOTTOM (solid shape): outline of 228 points within 261.45,49.11 268.46,56.12
SCREW15 on TOP (solid shape): outline of 235 points within 2.37,178.78 9.37,185.78
SCREW15 on BOTTOM (solid shape): outline of 235 points within 2.37,178.78 9.37,185.78
SCREW16 on TOP (solid shape): outline of 235 points within 126.34,137 133.35,144
SCREW16 on BOTTOM (solid shape): outline of 235 points within 126.34,137 133.35,144
SCREW17 on TOP (solid shape): outline of 235 points within 243.34,137 250.35,144
SCREW17 on BOTTOM (solid shape): outline of 235 points within 243.34,137 250.35,144
SCREW18 on TOP (solid shape): outline of 235 points within 136.17,82.57 143.17,89.57
SCREW18 on BOTTOM (solid shape): outline of 235 points within 136.17,82.57 143.17,89.57
SCREW19 on TOP (solid shape): outline of 235 points within 196.62,82.57 203.62,89.57
SCREW19 on BOTTOM (solid shape): outline of 235 points within 196.62,82.57 203.62,89.57
SCREW20 on TOP (solid shape): outline of 235 points within 261.15,175.2 268.15,182.2
SCREW20 on BOTTOM (solid shape): outline of 235 points within 261.15,175.2 268.15,182.2
SCREW21 on TOP (solid shape): outline of 235 points within 196.62,108.61 203.62,115.61
SCREW21 on BOTTOM (solid shape): outline of 235 points within 196.62,108.61 203.62,115.61
SCREW22 on TOP (solid shape): outline of 235 points within 136.17,108.61 143.17,115.61
SCREW22 on BOTTOM (solid shape): outline of 235 points within 136.17,108.61 143.17,115.61
SCREW23 on TOP (solid shape): outline of 235 points within 126.34,224 133.34,231
SCREW23 on BOTTOM (solid shape): outline of 235 points within 126.34,224 133.34,231
SW_VCC5P0 on TOP: 252.76,163.84 251.38,163.84 251.14,163.6 251.14,162.95 251.2,162.9 254.22,162.9 254.26,162.94 254.99,162.94 255.51,163.46 257.09,163.46 258.4,164.78 258.4,167.42 258.25,167.57 253.96,167.57 253.73,167.34 253.73,164.82
SYNCE_PLL_AVDD1P8 on TOP: 41.19,138.57 41.02,138.41 37.72,138.41 37.34,138.79 37.34,140.17 37.4,140.23 39.26,140.23 39.64,140.62 39.64,140.84 39.87,141.07 40.9,141.07 41.19,140.78
SYNCE_PLL_AVDD1P8 on S12: 36.49,131.51 36.49,130.37 35.98,129.86 35.98,121.48 35.6,121.1 31.54,121.1 31.15,121.48 31.15,133.67 37.99,140.51 40.54,140.51 41.25,139.8 41.25,136.27
TB_CHASSIS on TOP: 256.55,47.38 254.14,47.38 253.57,46.8 253.57,44.39 253.7,44.26 256.55,44.26 256.81,44.52 256.81,47.12
TB_CHASSIS on TOP: 261.93,31.67 256.49,31.67 256.43,31.61 256.43,29.16 256.64,28.95 261.92,28.95 262.28,29.3 262.28,31.33
TB_CHASSIS on TOP: 248.47,44.68 248.7,44.45 252.29,44.45 252.36,44.52 252.36,46.57 252.31,46.62 249.6,46.62 249.27,46.96 248.57,46.96 248.47,46.86
TB_CHASSIS on BOTTOM: 254.08,47.38 253.63,46.93 253.63,44.46 253.76,44.33 256.62,44.33 256.81,44.52 256.81,47.12 256.55,47.38
TB_CHASSIS on BOTTOM: 248.52,46.62 248.49,46.59 248.49,44.65 248.69,44.45 252.29,44.45 252.37,44.53 252.37,46.56 252.3,46.62
TB_CHASSIS on BOTTOM: 261.93,31.66 256.52,31.66 256.44,31.58 256.44,30.14 256.43,30.13 256.43,29.16 256.62,28.97 261.93,28.97 262.29,29.33 262.29,31.3
TB_CHASSIS on S9: 223.75,37.38 223.74,37.38 211.31,24.95 211.31,11.25 212.67,9.88 214.39,9.88 216.37,11.86 216.37,26.74 220.97,31.34 228.92,31.34 229.89,32.32 229.89,66.66 218.37,78.18 218.37,91.7 218.81,92.13 236.38,92.13 236.56,91.95 236.58,91.95 236.58,80.49 235.8,79.71 235.8,74.06 236.34,73.52 240.87,73.52 246.38,68.02 246.38,63.07 247.68,61.77 247.68,55.88 248.21,55.34 248.21,44.9 248.23,44.88 248.23,44.13 249.59,42.77 249.59,31.47 251.2,29.87 254.65,29.87 255.69,28.82 257.4,28.82 257.84,29.27 257.84,31.4 255.74,33.51 255.74,40.8 256.92,41.98 256.92,47.07 255.78,48.21 255.78,57.81 250.14,63.44 250.14,65.57 249.93,65.78 249.93,70.88 246.01,74.8 246.01,92.56 244.03,94.53 218.09,94.53 218.08,94.53 215.68,94.53 214.79,93.63 214.79,76.54 223.94,67.38 223.94,37.58
TPS53219_VDD on TOP (solid shape): 163.04,129.97 163.04,129.81 163.23,129.62 164.13,129.62 164.13,129.44 164.08,129.39 163.07,129.39 162.84,129.16 162.43,129.16 162.18,128.91 162.18,128.07 162.06,127.95 162.06,126.5 161.93,126.36 161.04,126.36 160.91,126.49 160.91,130.18 162.83,130.18
UC_PLL_AVDD1P8 on TOP: 7.06,98.37 7.09,98.4 7.09,100.19 7.2,100.3 7.43,100.3 7.65,100.52 7.65,100.59 7.71,100.66 7.71,101.34 7.46,101.6 6.06,101.6 5.61,101.15 5.61,98.56 5.81,98.37
UCD9016_3V3 on TOP: 235.3,209.14 234.47,209.14 234.34,209.01 234.34,207.17 234.22,207.05 230.6,207.05 230.41,207.24 230.41,208.95 230.34,209.01 229.84,209.01 229.77,208.95 229.77,206.41 231.17,205.01 234.98,205.01 235.42,205.46 235.42,209.01
USB5V_GPS_ANT on TOP: 204.3,97.78 203.53,97.78 203.02,98.29 198.84,98.29 198.34,97.79 198.34,96.17 198.53,95.98 199.36,95.98 199.74,96.37 199.74,96.88 199.99,97.14 204.37,97.14 204.38,97.15 204.38,97.7
USB HUB_GND on BOTTOM: 86.9,27.59 85.56,27.59 84.8,26.83 84.8,23.91 86.71,22.01 86.71,20.55 86.77,20.48 87.66,20.48 87.94,20.77 87.94,21.28 87.72,21.49 87.72,23.85 87.28,24.29 87.28,27.21
USB HUB_GND on BOTTOM: 91.43,23.24 94.51,23.24 94.75,23 94.75,21.04 94.42,20.7 92.32,20.7 92.07,20.96 92.07,21.47 91.31,22.23 91.31,23.12
USB HUB_GND on S16: 90.28,23.37 87.59,26.06 85.64,26.06 84.9,25.31 84.9,24.16 88.44,20.61 93.73,20.61 94.27,21.16 94.27,23.14 94.05,23.37
USB_CHASSIS on BOTTOM: 86,30.36 85.52,29.88 85.52,28.86 85.83,28.54 87.21,28.54 87.22,28.53 87.43,28.53 87.57,28.39 87.57,27.94 87.81,27.69 88.61,27.69 88.8,27.88 88.8,28.8 88.77,28.83 88.77,29.66 88.07,30.36
USB_VBUS on BOTTOM: 102.53,26.68 101.92,26.07 101.92,25.49 101.81,25.38 101.18,25.38 101.18,25.38 100.94,25.38 100.79,25.23 100.79,25.14 100.72,25.08 100.72,24.01 100.95,23.78 101.86,23.78 102.05,23.59 102.05,23.14 102.23,22.96 102.99,22.96 103.31,23.28 103.31,25.76 103.47,25.92 103.47,26.01 103.15,26.01 103.15,26.2 102.9,26.45 102.84,26.45 102.84,26.62 102.77,26.68
USB_VCC5P0 on TOP: 196.82,103.35 196.82,97.76 196.81,97.76 196.81,97.63 196.76,97.58 196.3,97.58 196.27,97.56 196.27,96.26 196.55,95.98 197.58,95.98 197.83,96.24 197.83,97.51 197.91,97.59 197.91,98.34 198.62,99.04 200.95,99.04 201.32,99.4 201.32,102.16 201.15,102.33 199.1,102.33 198.09,103.35
USB_VCC5P0 on TOP: 93.82,100.56 91.23,100.56 91.15,100.63 91.15,102.33 91.28,102.46 93.31,102.46 93.95,101.83 93.95,100.68
USB_VCC5P0 on TOP: 236.23,94.99 236.9,94.32 238.4,94.32 238.6,94.52 238.6,95.42 238.34,95.67 237.58,95.67 237.46,95.79 237.46,96.87 237.52,96.94 238.33,96.94 238.33,104.25 238.16,104.42 236.35,104.42 236.23,104.31
USB_VCC5P0 on TOP: 121.19,138.02 119.09,138.02 119.03,137.96 119.03,136.43 119.73,135.74 121.06,135.74 121.25,135.93 121.25,137.96
USB_VCC5P0 on BOTTOM: 69.05,237.4 69.05,232.57 70.45,231.18 71.59,231.18 72.16,231.75 72.16,237.4 71.66,237.91 69.56,237.91
USB_VCC5P0 on BOTTOM: 106.82,24.7 106.82,25.28 106.72,25.38 106.08,25.38 105.98,25.49 106.01,25.52 106.01,26.32 106.01,26.33 106.01,26.76 106.36,27.11 106.36,27.59 106.82,28.05 109.28,28.05 109.59,27.75 109.59,25.26 108.8,24.47 107.05,24.47
USB_VCC5P0 on S5: 118.81,138.12 114.01,133.32 114.01,109.19 104.3,99.48 96.55,99.48 94.07,101.95 91.09,101.95 90.07,100.94 90.07,94.27 92.1,92.24 104.61,92.24 119.6,107.22 119.6,117.83 121.76,119.99 121.76,137.51 121.15,138.12
USB_VCC5P0 on S5: 106.77,23.15 107.47,22.45 217.58,22.45 229.64,34.52 229.64,67.19 218.9,77.93 218.79,78.04 218.79,83.76 218.79,83.77 218.79,91.86 219.04,92.11 221.96,92.11 227.87,98.02 235.68,98.02 237.9,100.24 237.9,106.27 237.71,106.46 218.34,106.46 214.15,102.27 199.29,102.27 198.59,101.57 198.59,98.78 201.64,95.73 204.44,95.73 209.51,90.65 209.51,76.22 216.8,68.93 216.8,45 211.4,39.59 108.8,39.59 106.77,37.57
USB_VCC5P0 on S12: 91.82,102.18 90.71,101.06 90.71,91.16 94.33,87.54 133.38,87.54 136.81,90.97 193.89,90.97 201.7,98.78 201.7,104.18 199.74,106.14 155.79,106.14 151.8,102.15 124.09,102.15 118.49,96.56 106.07,96.56 100.45,102.18 ; 1 cut-out
USB_VCC5P0 on S12: 242.39,106.63 240.23,104.46 240.23,101.68 239.11,100.56 235.25,100.56 234.23,101.57 234.23,115.36 234.98,116.11 239.87,116.11 240.15,116.4 242.88,116.4 245.41,118.92 245.41,130.92 252.18,137.69 252.18,235.95 234.79,253.34 160.49,253.34 158.4,251.24 153.44,251.24 151.65,249.45 139.03,249.45 134.6,245.02 85.56,245.02 80.67,240.13 80.67,234.48 77.37,231.18 70.45,231.18 69.05,232.57 69.05,253.59 70.51,255.05 148.81,255.05 154.17,260.41 248.16,260.41 261.2,247.37 261.2,166.49 263.8,163.9 263.8,157.21 261.2,154.62 261.2,137.62 265.99,132.83 265.99,109.22 263.4,106.63
USB_VCC5P0 on S14: 71.66,237.91 69.56,237.91 69.05,237.4 69.05,232.57 70.45,231.18 71.59,231.18 72.16,231.75 72.16,237.4
VMONITOR_3V3 on TOP: 226.41,134.9 225.36,134.9 225.18,134.71 225.18,133.96 225.04,133.82 224.26,133.82 224.11,133.97 224.11,134.44 223.99,134.57 223.36,134.57 223.1,134.31 223.1,132.86 223.45,132.51 226.16,132.51 226.56,132.91 226.56,134.74
VMONITOR_3V3 on TOP: 236.5,207.68 236.38,207.55 236.38,203.74 236.69,203.43 238.73,203.43 238.98,203.68 238.98,207.49 238.79,207.68
VMONITOR_3V3 on TOP: 237.71,158.85 236.06,158.85 235.93,158.72 235.93,157.45 236.06,157.33 237.84,157.33 237.96,157.45 237.96,158.6
VMONITOR_3V3 on TOP: 127.09,258.93 126.84,258.67 126.84,258.29 127.09,258.04 129.76,258.04 130.52,257.27 130.52,256.48 130.06,256.03 129.29,256.03 128.99,256.32 128.87,256.32 128.81,256.39 127.16,256.39 127.09,256.32 127.09,254.54 127.22,254.42 129,254.42 129.51,253.91 132.05,253.91 132.55,254.42 132.55,258.48 132.11,258.93
VMONITOR_3V3 on TOP: 181.26,200.44 179.61,200.44 179.48,200.31 179.48,196.89 180.24,196.12 181.07,196.12 181.38,196.44 181.38,197.39 181.32,197.46 180.5,197.46 180.11,197.84 180.11,198.54 180.43,198.85 181.32,198.85 181.45,198.98 181.45,200.25
VMONITOR_3V3 on TOP: 128.74,241.78 125.7,241.78 125.31,241.4 125.31,240.26 125.57,240 128.49,240 128.87,240.38 128.87,241.65
VMONITOR_3V3 on BOTTOM: 46.73,238.26 44.76,238.26 43.94,237.43 43.94,224.06 44.35,223.65 47.37,223.65 47.81,224.1 47.81,237.18
VMONITOR_3V3 on BOTTOM: 221.64,203.55 218.09,203.55 217.96,203.43 217.96,199.81 218.41,199.36 221.45,199.36 222.09,200 222.09,203.11
VMONITOR_3V3 on BOTTOM: 126.97,243.05 125.82,243.05 125.57,242.8 125.57,239.62 125.95,239.24 127.09,239.24 127.35,239.49 127.35,242.67
VMONITOR_3V3 on V3: 8.86,177.46 6.12,174.72 6.12,174.66 3.71,172.25 3.71,151.99 4.09,151.61 7.2,151.61 7.59,151.99 12.09,151.99 15.59,155.48 15.59,170.28 26.31,181 26.31,186.81 26.18,186.93 26.18,191.61 35.65,201.08 35.65,211.05 42.89,218.29 46.85,218.29 55.78,227.21 55.78,236.19 57.81,238.22 64.48,238.22 66.89,235.81 66.89,227.3 67.78,226.41 76.48,226.41 80.67,222.22 80.67,206.79 84.55,202.92 119.79,202.92 120.04,203.17 126.01,203.17 126.77,202.41 156.24,202.41 165.76,211.94 165.76,217.14 166.08,217.14 172.75,223.81 211.36,223.81 212.56,222.6 212.56,210.09 211.1,208.63 186.46,208.63 179.35,201.52 179.35,167.87 177.13,165.64 177.18,165.59 177.18,138.02 179.71,135.49 198.34,135.49 201.9,131.93 201.9,116.3 199.86,114.27 199.86,102.33 203.17,99.03 210.02,99.03 212.18,96.87 254.03,96.87 255.68,98.52 255.74,98.52 264.51,107.29 264.51,119.1 256.95,119.1 254.48,121.57 254.48,185.37 257.35,188.24 257.35,244.51 257.32,244.59 257.32,248.26 251.17,254.42 245.08,254.42 245.05,254.44 244.39,254.44 238.03,260.79 17.07,260.79 6.2,249.93 6.2,191.97 8.86,189.31
VMONITOR_3V3 on S16: 160.47,19.1 160.32,18.95 160.32,6.96 160.67,6.6 188.79,6.6 196.07,13.88 202.69,13.88 206.9,9.67 214.95,9.67 216.63,11.34 216.63,24.84 216.64,24.86 216.64,28.02 217.71,29.09 226.78,29.09 229.96,32.26 229.96,66.87 218.66,78.17 218.66,92.15 219.95,93.44 230.84,93.44 235.93,98.53 235.93,100.23 235.5,100.66 213.49,100.66 211.54,98.71 211.54,79.86 213.69,77.71 213.69,76.56 215.1,75.14 216.21,75.14 223.91,67.43 223.91,57.73 223.75,57.56 223.75,56.31 227,53.06 227,45.07 226.84,44.9 225.62,44.9 222.96,42.24 221.63,42.24 214.22,34.83 214.22,34.56 209.66,29.99 209.66,21.69 208.03,20.06 207.07,20.06 203.53,23.61 196.5,23.61 191.99,19.1
VMONITOR_3V3 on V18: 171.98,174.58 160.41,163.01 160.41,141.71 164.67,137.45 205.26,137.45 211.53,143.72 211.53,145.81 215.65,149.93 227.36,149.93 229.69,152.26 229.69,171.88 226.99,174.58
VPP_DDR2P5 on TOP: 50.74,185.2 50.74,189.31 51.21,189.78 53.19,189.78 53.62,189.34 53.62,173.01 53.11,172.5 48.54,172.5 48.03,173.01 48.03,181.46 48.16,181.58 48.16,182.62
VPP_DDR2P5 on TOP: 99.3,104.14 98.39,104.14 98.19,103.93 98.19,102.99 98.06,102.87 97.2,102.87 97.07,102.74 97.07,102.26 97.93,101.39 99.13,101.39 99.32,101.58 99.32,102.22 99.61,102.51 99.61,103.83
VPP_DDR2P5 on BOTTOM: 53.05,189.77 50.57,189.77 47.91,187.11 47.91,181.96 47.97,181.9 47.97,173.01 48.48,172.5 53.05,172.5 53.56,173.01 53.56,189.27
VPP_DDR2P5 on S5: 105.02,135.76 104.38,135.76 104.36,135.74 104.36,134.08 105.72,132.73 106.81,132.73 108.04,131.49 108.04,113.31 108.09,113.26 108.09,104.75 103.49,100.15 98.47,100.15 96.46,102.16 96.46,107.95 99.74,111.22 99.74,117.4 100.42,118.08 100.42,124.05 99.91,124.56 99.91,127.05 99.51,127.45 99.51,134.74 95.22,139.04 95.22,151.51 100.75,157.05 100.75,169.21 100.96,169.21 100.96,173.68 102.17,174.9 104.93,174.9 106.4,173.43 106.4,157.45 108.28,155.57 108.28,154.81 107.44,153.97 107.44,138.18
VPP_DDR2P5 on S16: 39.79,170.05 47.67,170.05 49.57,171.96 59.68,171.96 60.77,170.86 62.37,170.86 63.47,171.96 68.29,171.96 70.04,170.2 84.98,170.2 85.28,170.51 85.28,170.96 87.19,172.87 93.62,172.87 94.68,171.8 100.07,171.8 101.06,170.81 101.06,169.95 101.59,169.42 101.59,167.66 102.28,166.98 102.28,160.09 102.58,159.79 103.99,159.79 103.99,173.77 102.86,174.9 79.91,174.9 78.31,176.5 36.03,176.5 33.59,174.06 18.53,174.06 16.11,171.64 16.11,165.52 14.99,164.4 14.99,159.71 16.02,158.68 16.04,158.7 16.07,158.67 17.06,158.67 18.18,159.79 18.18,162.61 19.02,163.45 19.02,171.93 19.14,172.06 37.79,172.06
VPP_DDR2P5_VIN on TOP (solid shape): 38.61,186.19 38.61,185.51 38.73,185.39 39.97,185.39 39.98,185.38 39.98,184.38 39.84,184.25 39.84,183.66 37.62,181.44 30.45,181.44 29.43,182.46 29.43,185.57 29.62,185.76 35.31,185.76 35.33,185.78 35.56,185.55 36.65,185.55 37.24,186.14 37.55,186.14 37.56,186.15 37.68,186.15 37.75,186.22 38.59,186.22
VPP_DDR2P5_VIN on BOTTOM: 35.21,185.8 29.63,185.8 29.48,185.65 29.48,182.88 29.99,182.37 35.68,182.37 36.74,183.44 36.74,185.19 36.54,185.39 35.59,185.39 35.21,185.77
VSTB_3V3 on S12 (solid shape): 51.84,237.49 51.84,223.94 51.18,223.27 48.96,223.27 48.42,223.81 48.42,237.49 49.11,238.19 51.15,238.19
VSTB_3V3 on BOTTOM: 48.42,237.49 48.42,223.94 48.73,223.62 51.53,223.62 51.84,223.94 51.84,237.53 51.15,238.22 49.15,238.22
VSTB_3V3 on BOTTOM: 221,209.15 218.33,209.15 217.65,208.47 217.65,204.85 218.24,204.26 221.15,204.26 221.99,205.1 221.99,208.16
VSTB_3V3 on V18: 47.59,227.05 47.59,246.16 48.99,247.56 225.07,247.56 231.36,241.27 231.36,204.76 230.28,203.68 220.31,203.68 219.04,204.95 219.04,225.08 220.28,226.32 220.28,228.98 210.72,238.54 205.5,238.54 203.43,240.61 195.27,240.61 195.27,240.55 193.26,238.54 141.38,238.54 138.52,235.68 76.56,235.68 75.17,234.29 75.17,225.88 73.69,224.4 51.36,224.4 50.89,223.94 48.67,223.94 47.53,225.08 47.53,226.98
XFP_3V3 on TOP (solid shape): 44.56,74.94 44.56,71.47 43.65,71.47 43.36,71.77 43.36,72.46 43.1,72.72 40.76,72.72 40.67,72.81 40.67,75.22 40.99,75.54 43.97,75.54
XFP_3V3 on TOP (solid shape): 69.65,74.3 69.65,71.64 69.53,71.52 68.52,71.52 68.44,71.6 68.44,72.46 68.19,72.72 66.92,72.72 66.66,72.97 66.66,74.43 66.85,74.62 69.33,74.62
XFP_3V3 on TOP (solid shape): 112.97,74.3 112.97,73.92 112.57,73.51 112.57,71.47 111.77,71.47 111.77,72.46 111.51,72.72 109.62,72.72 109.44,72.9 109.44,74.52 109.54,74.62 112.66,74.62
XFP_3V3 on TOP (solid shape): 32.05,74.87 32.05,73.92 31.65,73.51 31.65,71.47 30.85,71.47 30.85,72.88 30.69,73.04 29.96,73.04 29.95,73.03 27.76,73.03 27.52,73.28 27.52,74.86 27.77,75.1 31.82,75.1
XFP_3V3 on TOP (solid shape): 134.2,74.9 134.2,72.04 133.63,71.47 132.92,71.47 132.48,71.92 132.48,72.34 132.22,72.59 130.33,72.59 130.15,72.77 130.15,74.78 130.53,75.16 133.95,75.16
XFP_3V3 on TOP (solid shape): 82.16,74.3 82.16,71.6 82.1,71.54 81.09,71.54 81.03,71.57 80.97,71.59 80.95,71.61 80.95,72.46 80.69,72.72 79.42,72.72 79.17,72.97 79.17,74.43 79.36,74.62 81.84,74.62
XFP_3V3 on TOP (solid shape): 57.14,74.75 57.14,71.62 57.06,71.54 56.38,71.54 56.2,71.68 55.98,71.73 55.94,71.74 55.93,71.78 55.93,72.46 55.68,72.72 53.84,72.72 53.32,73.24 53.32,73.38 53.21,73.49 53.21,74.91 53.49,75.18 56.71,75.18
XFP_3V3 on TOP (solid shape): 176.85,74.3 176.85,73.92 176.45,73.51 176.45,71.47 175.65,71.47 175.65,72.46 175.39,72.72 174.08,72.72 174.07,72.75 173.85,73.01 173.52,73.08 173.49,73.08 172.94,73.63 172.94,74.52 173.04,74.62 176.54,74.62
XFP_3V3 on TOP: 207.99,85.32 208.05,85.25 212.31,85.25 212.63,85.57 212.63,88.11 212.06,88.68 208.63,88.68 207.99,88.05
XFP_3V3 on TOP: 150.63,71.32 150.5,71.45 150.5,72.46 150.25,72.72 148.35,72.72 148.17,72.9 148.17,75.34 148.44,75.6 150.65,75.6 151.71,74.54 151.71,71.45 151.58,71.32
XFP_3V3 on TOP: 170.46,92.86 171.6,91.72 171.6,86.66 171.6,86.66 171.6,83.21 171.42,83.03 156.05,83.03 155.41,83.67 155.41,86.15 155.47,86.2 155.47,88.41 155.6,88.54 156.11,88.54 156.23,88.67 156.23,90.19 156.36,90.32 156.87,90.32 157.12,90.57 157.12,92.35 157.63,92.86
XFP_3V3 on TOP: 124.47,71.32 124.34,71.45 124.34,72.46 124.09,72.72 122.19,72.72 122.01,72.9 122.01,74.65 122.65,75.28 125.06,75.28 125.55,74.8 125.55,71.45 125.42,71.32
XFP_3V3 on TOP: 163.14,71.32 163.01,71.45 163.01,72.46 162.76,72.72 160.86,72.72 160.68,72.9 160.68,74.52 160.78,74.62 163.9,74.62 164.22,74.3 164.22,71.45 164.09,71.32
XFP_3V3 on TOP: 188.41,71.32 188.28,71.45 188.28,72.46 188.03,72.72 186.14,72.72 185.96,72.9 185.96,74.52 185.97,74.54 185.97,74.95 186.33,75.31 189,75.31 189.49,74.83 189.49,71.45 189.36,71.32
XFP_3V3 on BOTTOM: 172.08,92.48 173.02,91.54 173.02,83.64 172.77,83.39 156.26,83.39 155.6,84.05 155.6,89.81 156.44,90.65 159.25,90.65 159.43,90.83 159.43,92.15 159.76,92.48
XFP_3V3 on V3: 149.13,78.33 87.47,78.33 84.36,75.22 13.81,75.22 11.9,73.31 11.9,69.41 10.46,67.97 4.05,67.97 3.61,67.54 3.61,60.46 4.67,59.4 18.21,59.4 21.02,56.59 21.02,50.7 19.75,49.43 18.65,49.43 18.61,49.47 18.54,49.47 18.19,49.12 18.19,47.37 18.5,47.06 24.18,47.06 26.64,44.6 26.64,28.29 33.68,21.24 210.79,21.24 219.58,30.04 219.58,77.66 217.01,80.24 217.01,90.4 210.66,96.75 160.68,96.75 156.81,92.87 156.81,86.01
XFP_3V3-R_P01 on TOP (solid shape): 34.52,68.34 34.52,67.36 33.96,66.8 33.93,66.8 33.93,65.98 33.93,65.98 33.93,65.53 33.84,65.53 33.84,64.71 33.93,64.71 33.93,63.34 33.68,63.09 32.28,63.09 32.16,63.22 32.16,68.3 32.28,68.42 34.43,68.42
XFP_3V3-R_P02 on BOTTOM (solid shape): 31.55,63.98 31.5,63.89 30.88,63.82 30.64,63.35 30.64,63.06 29.83,63.06 29.51,63.38 29.51,63.84 29.59,64.02 29.62,64.21 29.62,64.57 29.61,64.58 29.61,64.71 30.21,64.71 30.21,65.53 30.21,66.81 29.79,67.23 29.82,67.27 29.95,67.73 29.74,68.17 29.7,68.21 29.7,68.59 29.77,68.65 31.55,68.65
XFP_3V3-R_P03 on TOP (solid shape): 47.2,68.3 47.2,67.53 46.47,66.8 46.44,66.8 46.44,65.98 46.44,65.53 46.35,65.53 46.35,64.71 46.44,64.71 46.44,63.34 46.19,63.09 44.79,63.09 44.66,63.22 44.66,68.3 44.79,68.42 47.08,68.42
XFP_3V3-R_P04 on BOTTOM (solid shape): 44.06,63.86 43.99,63.77 43.88,63.79 43.27,63.92 42.91,63.42 42.91,63.4 42.63,63.12 42.56,63.1 42.5,63.06 42.34,63.06 42.02,63.38 42.02,64.66 42.79,64.66 42.79,65.47 42.72,65.47 42.72,66.81 42.21,67.32 42.21,68.59 42.28,68.65 44.06,68.65
XFP_3V3-R_P05 on TOP (solid shape): 59.78,68.3 59.78,67.53 59.04,66.8 59.02,66.8 59.02,65.98 59.02,65.53 58.93,65.53 58.93,64.71 59.02,64.71 59.02,63.34 58.76,63.09 57.36,63.09 57.24,63.22 57.24,68.3 57.36,68.42 59.65,68.42
XFP_3V3-R_P06 on BOTTOM (solid shape): 56.63,64.04 56.59,63.96 56.49,63.95 55.92,63.86 55.65,63.35 55.65,63.06 54.91,63.06 54.6,63.38 54.6,63.9 54.75,64.06 54.75,64.72 55.36,64.72 55.36,65.53 55.29,65.53 55.29,66.81 54.95,67.15 54.95,67.2 54.93,67.5 54.79,67.76 54.79,68.59 54.85,68.65 56.63,68.65
XFP_3V3-R_P07 on TOP (solid shape): 72.29,68.3 72.29,67.53 71.55,66.8 71.52,66.8 71.52,65.98 71.53,65.98 71.53,65.53 71.44,65.53 71.44,64.71 71.53,64.71 71.53,63.34 71.27,63.09 69.87,63.09 69.75,63.22 69.75,68.3 69.87,68.42 72.16,68.42
XFP_3V3-R_P08 on BOTTOM (solid shape): 69.14,63.93 69.1,63.85 68.51,63.74 68.29,63.28 68.29,63.06 67.42,63.06 67.11,63.38 67.11,63.64 67.39,63.93 67.39,64.72 67.93,64.72 67.93,65.53 67.8,65.53 67.8,66.81 67.3,67.32 67.3,68.59 67.36,68.65 69.14,68.65
XFP_3V3-R_P09 on TOP (solid shape): 84.49,68.57 84.49,67.23 84.03,66.77 84.03,66.74 83.97,66.74 83.97,65.93 84.03,65.93 84.03,65.53 83.88,65.53 83.88,64.72 84.03,64.72 84.03,63.34 83.78,63.09 82.38,63.09 82.26,63.22 82.26,68.39 82.51,68.64 84.42,68.64
XFP_3V3-R_P10 on BOTTOM (solid shape): 81.65,63.98 81.6,63.89 80.98,63.82 80.74,63.35 80.74,63.06 79.93,63.06 79.62,63.38 79.62,64.32 79.8,64.5 80.17,64.5 80.29,64.63 80.29,64.71 80.31,64.71 80.31,65.53 80.31,66.81 79.91,67.22 79.91,67.45 79.81,67.55 79.81,68.59 79.87,68.65 81.65,68.65
XFP_3V3-R_P11 on TOP (solid shape): 115.61,68.3 115.61,67.94 115.57,67.9 115.46,67.73 115.42,67.54 115.42,67.5 115.43,67.44 115.44,67.36 114.88,66.8 114.85,66.8 114.85,65.98 114.85,65.53 114.76,65.53 114.76,64.71 114.85,64.71 114.85,63.34 114.6,63.09 113.2,63.09 113.07,63.22 113.07,68.3 113.2,68.42 115.49,68.42
XFP_3V3-R_P12 on BOTTOM (solid shape): 112.46,64.12 112.43,64.05 112.35,64.02 112.05,63.98 111.8,63.82 111.04,63.06 110.75,63.06 110.43,63.38 110.43,64.71 111.13,64.71 111.13,65.53 111.13,66.81 110.62,67.32 110.62,68.59 110.69,68.65 112.46,68.65
XFP_3V3-R_P13 on TOP (solid shape): 128.19,68.3 128.19,67.53 127.45,66.8 127.42,66.8 127.42,65.98 127.43,65.98 127.43,65.53 127.34,65.53 127.34,64.71 127.43,64.71 127.43,63.34 127.17,63.09 125.77,63.09 125.65,63.22 125.65,68.3 125.77,68.42 128.06,68.42
XFP_3V3-R_P14 on BOTTOM (solid shape): 125.04,63.95 124.98,63.86 124.16,63.9 123.79,63.28 123.79,63.06 123.32,63.06 123.01,63.38 123.01,64.71 123.7,64.71 123.7,65.53 123.7,66.81 123.36,67.15 123.36,67.48 123.2,67.64 123.2,68.59 123.26,68.65 125.04,68.65
XFP_3V3-R_P15 on TOP (solid shape): 136.33,68.17 136.33,67.41 135.59,66.68 135.56,66.68 135.56,65.86 135.56,65.86 135.56,65.41 135.47,65.41 135.47,64.59 135.56,64.59 135.56,63.22 135.31,62.97 133.91,62.97 133.79,63.09 133.79,68.17 133.91,68.3 136.2,68.3
XFP_3V3-R_P16 on BOTTOM (solid shape): 133.18,63.82 133.13,63.74 133.04,63.72 132.73,63.74 132.46,63.59 131.81,62.94 131.46,62.94 131.14,63.26 131.14,64.32 131.3,64.48 131.3,64.59 131.84,64.59 131.84,65.41 131.84,65.87 131.88,65.87 131.88,66.68 131.84,66.68 131.84,66.69 131.33,67.2 131.33,68.47 131.4,68.53 133.18,68.53
XFP_3V3-R_P17 on TOP (solid shape): 154.35,68.3 154.35,67.83 153.59,67.07 153.59,66.8 153.59,66.8 153.59,65.98 153.59,65.98 153.59,65.53 153.5,65.53 153.5,64.71 153.59,64.71 153.59,63.34 153.33,63.09 151.94,63.09 151.81,63.22 151.81,68.3 151.94,68.42 154.22,68.42
