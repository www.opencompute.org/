# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NIFE_RX[33]_N: length 135.4
  TOP w0.095: U40.J7 v4(51.7,105.65)
  S12 w0.102: v4(51.7,105.65) 51.7,105.34 51.78,105.26 52.08,105.26 52.29,105.05 52.29,100.93 52.31,100.91 52.31,99.19 52.29,99.16 52.29,97.17 52.29,97.17
  S12 w0.108: 52.29,97.17 52.29,95.84 52.66,95.48 52.66,93.07 53.57,92.16 73.39,92.16 arc(74.94,91.85) 76.25,90.98 89.2,78.03 arc(89.82,77.61) 90.56,77.47 126.13,77.47 arc(126.65,77.36) 127.1,77.07 129.91,74.25 arc(130.55,73.82) 131.31,73.67 147.13,73.67 arc(147.3,73.64) 147.44,73.54 147.51,73.47 arc(147.91,73.21) 148.37,73.12 148.78,73.12 arc(149.57,72.79) 149.9,72 149.9,61.55 arc(150.14,60.36) 150.81,59.35 151.25,58.91 arc(151.38,58.72) 151.43,58.48 arc(151.38,58.2) 151.22,57.97 150.91,57.66 arc(150.79,57.36) 150.91,57.05 CONN55_PF.3T12
NIFE_RX[33]_P: length 135.4
  TOP w0.095: U40.H7 v4(51.7,104.65)
  S12 w0.102: 52.06,97.17 52.06,97.18 52.09,97.2 52.09,99.25 52.11,99.27 52.11,100.82 52.09,100.85 52.09,104.96 52.02,105.03 51.79,105.03 51.7,104.94 v4(51.7,104.65)
  S12 w0.108: CONN55_PF.3T13 150.26,58.03 arc(150.44,57.76) 150.75,57.82 151.06,58.13 arc(151.16,58.29) 151.2,58.48 arc(151.17,58.63) 151.09,58.75 150.65,59.19 arc(149.92,60.27) 149.67,61.55 149.67,72 arc(149.41,72.63) 148.78,72.89 148.37,72.89 arc(147.82,73) 147.35,73.31 147.28,73.38 arc(147.21,73.43) 147.13,73.44 131.31,73.44 arc(130.47,73.61) 129.75,74.08 126.93,76.9 arc(126.56,77.15) 126.13,77.24 90.56,77.24 arc(89.73,77.4) 89.03,77.87 76.09,90.81 arc(74.85,91.64) 73.39,91.93 56.44,91.93 arc(56.38,91.9) 56.35,91.84 arc(56.33,91.78) 56.26,91.75 55.83,91.75 arc(55.76,91.78) 55.74,91.84 arc(55.71,91.9) 55.65,91.93 55.21,91.93 arc(55.15,91.9) 55.12,91.84 arc(55.09,91.78) 55.03,91.75 54.6,91.75 arc(54.53,91.78) 54.5,91.84 arc(54.48,91.9) 54.41,91.93 53.47,91.93 52.43,92.97 52.43,95.38 52.06,95.75 52.06,97.17
NIFE_RX[34]_N: length 145.9
  TOP w0.095: U40.F6 v4(52.7,102.65)
  S12 w0.102: v4(52.7,102.65) 52.7,102.99 52.75,103.04 53.02,103.04 53.11,102.95 53.11,101.67 53.08,101.64 53.08,99.02 53.1,98.99 53.1,97.95
  S12 w0.108: 53.1,97.95 53.14,97.91 53.14,97.4 arc(53.27,96.77) 53.62,96.23 55.01,94.84 arc(55.28,94.67) 55.59,94.61 56.33,94.61 arc(56.38,94.58) 56.41,94.53 arc(56.43,94.48) 56.48,94.46 56.87,94.46 arc(56.92,94.48) 56.95,94.53 arc(56.97,94.58) 57.02,94.61 72.67,94.61 arc(73.88,94.37) 74.9,93.68 89.53,79.05 arc(90.02,78.72) 90.59,78.61 128.24,78.61 arc(128.62,78.53) 128.94,78.32 131.16,76.1 arc(131.54,75.85) 131.98,75.76 148.11,75.76 arc(151.32,74.43) 152.64,71.23 152.64,65.25 arc(152.8,64.46) 153.25,63.79 156.9,60.14 arc(157.36,59.44) 157.53,58.62 157.53,57.72 arc(157.57,57.51) 157.68,57.34 157.74,57.28 arc(157.87,57.09) 157.92,56.85 157.92,56.86 157.92,51.71 arc(158.4,50.56) 159.55,50.08 160.01,50.08 arc(160.36,50.01) 160.65,49.81 arc(160.82,49.41) 160.65,49.01 160.41,48.77 arc(160.31,48.7) 160.2,48.68 160.15,48.68 arc(160.05,48.73) 159.96,48.8 159.9,48.86 arc(159.76,49.07) CONN55_PF.4L12
NIFE_RX[34]_P: length 145.8
  TOP w0.095: U40.G6 v4(52.7,103.65)
  S12 w0.102: v4(52.7,103.65) 52.7,103.34 52.79,103.24 53.1,103.24 53.31,103.03 53.31,101.58 53.28,101.55 53.28,99.1 53.3,99.08 53.3,98.07 53.31,98.07
  S12 w0.108: 53.31,98.07 53.37,98.01 53.37,97.4 arc(53.48,96.86) 53.78,96.4 55.17,95.01 arc(55.37,94.88) 55.59,94.83 72.67,94.83 arc(73.96,94.58) 75.06,93.85 89.69,79.21 arc(90.11,78.94) 90.59,78.84 128.24,78.84 arc(128.7,78.75) 129.1,78.48 131.32,76.26 arc(131.62,76.06) 131.98,75.99 148.11,75.99 arc(151.48,74.59) 152.87,71.23 152.87,65.25 arc(153.01,64.55) 153.41,63.95 157.06,60.3 arc(157.57,59.53) 157.75,58.62 157.75,57.72 arc(157.78,57.6) 157.84,57.51 157.9,57.45 arc(158.08,57.17) 158.15,56.85 158.15,51.71 arc(158.56,50.72) 159.55,50.31 160.01,50.31 160.01,50.31 arc(160.44,50.22) 160.81,49.98 arc(161.05,49.41) 160.81,48.84 160.62,48.65 arc(160.54,48.53) 160.51,48.4 CONN55_PF.4L13
NIFE_RX[35]_N: length 146.2
  TOP w0.095: U40.J5 v4(53.7,105.65)
  S12 w0.102: 54.29,97.46 54.29,97.46 54.29,98.78 54.31,98.81 54.31,101.29 54.3,101.31 54.3,102.33 54.29,102.34 54.29,103.93 54.3,103.94 54.3,105 54.03,105.26 53.78,105.26 53.7,105.34 v4(53.7,105.65)
  S12 w0.108: 54.29,97.46 54.67,97.08 arc(54.87,96.95) 55.11,96.9 60.1,96.9 arc(60.49,96.82) 60.83,96.59 61.19,96.23 arc(61.5,96.02) 61.87,95.95 73.3,95.95 arc(74.62,95.69) 75.74,94.94 90.21,80.47 arc(90.72,80.13) 91.33,80.01 129.52,80.01 arc(130.19,79.87) 130.76,79.49 132.2,78.06 arc(133.08,77.47) 134.11,77.27 160.35,77.27 arc(161.65,77.01) 162.75,76.27 arc(163.36,75.35) 163.58,74.27 163.58,63.17 arc(163.67,62.71) 163.92,62.33 arc(164.38,61.67) 164.58,60.9 164.59,60.89 164.59,60.51 arc(164.67,60.07) 164.92,59.7 165.39,59.24 arc(165.63,58.87) 165.72,58.43 arc(165.65,58.11) 165.47,57.84 165.46,57.83 arc(165.42,57.78) 165.39,57.73 arc(165.38,57.71) 165.37,57.7 arc(165.37,57.7) 165.37,57.69 arc(165.33,57.58) 165.31,57.46 CONN55_PF.4T12
NIFE_RX[35]_P: length 146.2
  TOP w0.095: U40.H5 v4(53.7,104.65)
  S12 w0.102: v4(53.7,104.65) 53.7,104.93 53.8,105.03 53.97,105.03 54.09,104.91 54.09,104.02 54.08,104.01 54.08,102.26 54.09,102.25 54.09,101.22 54.11,101.2 54.11,98.89 54.08,98.87 54.08,97.34
  S12 w0.108: 54.08,97.34 54.5,96.92 arc(54.78,96.73) 55.11,96.67 55.5,96.67 arc(55.57,96.64) 55.59,96.58 arc(55.62,96.52) 55.68,96.49 56.12,96.49 arc(56.18,96.52) 56.21,96.58 arc(56.23,96.64) 56.29,96.67 56.74,96.67 arc(56.8,96.64) 56.82,96.58 arc(56.85,96.52) 56.91,96.49 57.35,96.49 arc(57.41,96.52) 57.44,96.58 arc(57.46,96.64) 57.53,96.67 60.1,96.67 arc(60.4,96.61) 60.67,96.43 61.03,96.07 arc(61.41,95.81) 61.87,95.72 73.3,95.72 arc(74.53,95.48) 75.58,94.78 90.04,80.31 arc(90.64,79.92) 91.33,79.78 129.52,79.78 arc(130.11,79.66) 130.6,79.33 132.03,77.9 arc(132.99,77.26) 134.11,77.04 160.35,77.04 arc(161.56,76.8) 162.59,76.11 arc(163.15,75.26) 163.35,74.27 163.35,63.17 arc(163.46,62.63) 163.76,62.17 arc(164.17,61.58) 164.35,60.88 arc(164.36,60.81) 164.36,60.74 164.36,60.51 arc(164.46,59.98) 164.76,59.54 165.22,59.07 arc(165.42,58.78) 165.49,58.43 arc(165.44,58.2) 165.31,58 165.26,57.95 arc(165.15,57.88) 165.03,57.86 164.96,57.86 arc(164.64,57.99) CONN55_PF.4T13
NIFE_RX[36]_N: length 155.7
  TOP w0.095: v4(54.7,102.65) U40.F4
  S12 w0.102: v4(54.7,102.65) 54.7,102.95 54.78,103.03 54.96,103.03 arc(55.05,103) 55.08,102.91 55.08,101.41 55.43,101.06 57.97,101.06 57.97,101.05
  S12 w0.108: 57.97,101.05 59.86,99.17 arc(59.89,99.1) 59.86,99.03 arc(59.83,98.96) 59.86,98.89 60.11,98.65 arc(60.17,98.62) 60.24,98.65 arc(60.31,98.68) 60.38,98.65 61.71,97.32 arc(62.16,97.02) 62.68,96.92 74.02,96.92 arc(75.01,96.72) 75.84,96.16 90.41,81.59 arc(91.18,81.08) 92.09,80.9 130.96,80.9 arc(131.41,80.81) 131.79,80.55 133.54,78.81 arc(134.27,78.32) 135.14,78.14 161.51,78.14 arc(162.33,77.98) 163.02,77.52 164.14,76.39 arc(164.7,75.56) 164.9,74.57 164.9,66.11 arc(165.02,65.52) 165.35,65.03 170.96,59.41 arc(171.24,58.99) 171.34,58.5 171.34,58.2 arc(171.42,57.77) 171.66,57.42 171.99,57.09 arc(172.28,56.66) 172.38,56.14 172.38,51.46 arc(172.79,50.46) 173.79,50.05 174.49,50.05 arc(174.79,49.92) 174.92,49.62 174.92,49.16 arc(174.89,49.02) 174.81,48.9 174.67,48.76 arc(174.6,48.71) 174.52,48.7 174.51,48.7 arc(174.4,48.72) 174.32,48.78 174.09,49 arc(174,49.14) CONN55_PF.5L12
NIFE_RX[36]_P: length 155.7
  TOP w0.095: U40.G4 v4(54.7,103.65)
  S12 w0.102: v4(54.7,103.65) 54.7,103.32 54.79,103.23 54.96,103.23 arc(55.19,103.14) 55.28,102.91 55.28,101.49 55.52,101.26 57.89,101.26 57.89,101.26 58.06,101.26 58.06,101.26 58.09,101.26
  S12 w0.108: 58.09,101.26 61.87,97.48 arc(62.24,97.23) 62.68,97.15 74.02,97.15 arc(75.09,96.93) 76,96.32 90.57,81.75 arc(91.27,81.29) 92.09,81.13 130.96,81.13 arc(131.5,81.02) 131.95,80.71 133.7,78.97 arc(134.36,78.53) 135.14,78.37 161.51,78.37 161.51,78.37 arc(162.41,78.19) 163.18,77.68 164.31,76.56 arc(164.91,75.64) 165.13,74.57 165.13,66.11 arc(165.23,65.61) 165.51,65.19 171.12,59.58 arc(171.45,59.08) 171.57,58.5 171.57,58.19 171.57,58.2 arc(171.63,57.86) 171.82,57.58 172.15,57.25 arc(172.49,56.74) 172.61,56.14 172.61,51.46 arc(172.95,50.62) 173.79,50.28 174.49,50.28 arc(174.95,50.09) 175.15,49.62 175.15,49.16 arc(175.1,48.93) 174.97,48.73 174.83,48.6 arc(174.82,48.58) 174.81,48.56 arc(174.8,48.56) 174.8,48.56 arc(174.8,48.55) 174.79,48.54 arc(174.79,48.54) 174.79,48.54 arc(174.79,48.53) 174.78,48.52 arc(174.78,48.52) 174.78,48.52 arc(174.77,48.48) 174.76,48.43 CONN55_PF.5L13
NIFE_RX[37]_N: length 154.3
  TOP w0.095: U40.J3 v4(55.7,105.65)
  S12 w0.102: v4(55.7,105.65) 55.7,105.37 55.8,105.27 56.04,105.27 56.29,105.02 56.29,102.41 56.47,102.23 57.91,102.23 57.93,102.25
  S12 w0.108: 57.93,102.25 58.72,102.25 arc(58.91,102.22) 59.08,102.11 59.34,101.84 59.34,101.84 62.54,98.64 arc(62.91,98.4) 63.35,98.31 74.58,98.31 arc(75.61,98.11) 76.48,97.52 90.64,83.37 arc(91.3,82.92) 92.08,82.77 131.47,82.77 arc(131.96,82.67) 132.37,82.4 134.7,80.06 arc(135.19,79.74) 135.77,79.62 169.7,79.62 arc(170.78,79.4) 171.7,78.79 175.39,75.1 arc(175.68,74.67) 175.78,74.17 175.78,66.41 arc(175.85,66.02) 176.07,65.7 176.1,65.67 178.07,63.69 arc(178.53,63.01) 178.69,62.2 178.69,60.29 178.69,60.29 arc(178.76,59.97) 178.94,59.69 179.42,59.22 179.76,58.87 arc(179.97,58.37) 179.76,57.86 179.49,57.59 arc(179.37,57.28) 179.49,56.97 CONN55_PF.5T12
NIFE_RX[37]_P: length 154.4
  TOP w0.095: v4(55.7,104.65) U40.H3
  S12 w0.102: v4(55.7,104.65) 55.7,104.98 55.78,105.07 55.96,105.07 56.09,104.94 56.09,102.32 56.38,102.03 57.96,102.03
  S12 w0.108: CONN55_PF.5T13 178.76,57.99 arc(178.97,57.68) 179.33,57.75 179.6,58.02 arc(179.74,58.37) 179.6,58.71 179.02,59.29 178.78,59.53 arc(178.55,59.88) 178.46,60.29 178.46,62.2 arc(178.32,62.92) 177.91,63.53 175.91,65.54 arc(175.64,65.94) 175.55,66.41 175.55,74.17 arc(175.47,74.59) 175.23,74.94 171.54,78.63 arc(170.69,79.19) 169.7,79.39 135.77,79.39 arc(135.1,79.52) 134.54,79.9 132.2,82.24 arc(131.87,82.46) 131.47,82.54 92.08,82.54 arc(91.21,82.71) 90.48,83.2 76.32,97.36 arc(75.52,97.89) 74.58,98.08 63.35,98.08 arc(62.82,98.19) 62.38,98.48 60.01,100.85 arc(59.94,100.88) 59.88,100.85 arc(59.81,100.83) 59.75,100.85 59.44,101.16 arc(59.42,101.22) 59.44,101.29 arc(59.47,101.35) 59.44,101.42 58.92,101.94 arc(58.83,102) 58.72,102.03 57.96,102.03 57.96,102.03
NIFE_RX[38]_N: length 167.2
  TOP w0.095: U40.F2 v4(56.7,102.65)
  S12 w0.108: v4(56.7,102.65) 56.7,102.94 56.79,103.03 58.14,103.03 58.25,103.14 59.17,103.14 arc(59.7,103.04) 60.14,102.74 60.67,102.22 arc(60.7,102.14) 60.67,102.06 arc(60.62,101.95) 60.67,101.83 60.82,101.68 arc(60.94,101.63) 61.05,101.68 arc(61.13,101.71) 61.2,101.68 63.07,99.81 arc(63.71,99.39) 64.45,99.24 74.89,99.24 arc(75.95,99.03) 76.85,98.44 91.02,84.27 arc(91.62,83.87) 92.34,83.73 132.34,83.73 arc(133.12,83.57) 133.79,83.13 135.92,81 arc(136.47,80.63) 137.12,80.5 171.25,80.5 arc(172.4,80.27) 173.38,79.61 176.47,76.53 176.59,76.4 arc(176.95,75.87) 177.08,75.23 177.08,66.7 arc(177.18,66.17) 177.48,65.73 179.35,63.86 arc(179.85,63.53) 180.43,63.41 180.9,63.41 arc(181.91,63.21) 182.77,62.63 185.08,60.33 arc(185.47,59.73) 185.61,59.03 185.61,58.23 arc(185.72,57.69) 186.02,57.24 186.24,57.03 arc(186.47,56.68) 186.55,56.26 186.55,56.26 186.55,51.62 arc(187.01,50.51) 188.13,50.05 188.73,50.05 arc(189.14,49.88) 189.31,49.47 arc(189.31,49.42) 189.31,49.38 arc(189.25,49.22) 189.16,49.08 189.04,48.96 arc(188.51,48.86) CONN55_PF.6L12
NIFE_RX[38]_P: length 167.2
  TOP w0.095: U40.G2 v4(56.7,103.65)
  S12 w0.108: 189.54,49.47 189.54,49.47 189.54,49.47 ; 189.54,49.47 arc(189.31,50.04) 188.73,50.28 188.13,50.28 arc(187.18,50.67) 186.78,51.62 186.78,56.26 arc(186.68,56.76) 186.4,57.19 186.19,57.4 arc(185.93,57.78) 185.84,58.23 185.84,59.03 arc(185.69,59.82) 185.24,60.49 182.93,62.8 arc(182,63.42) 180.9,63.64 180.43,63.64 arc(179.93,63.74) 179.51,64.02 177.64,65.89 arc(177.39,66.26) 177.31,66.7 177.31,75.23 arc(177.16,75.95) 176.75,76.57 176.63,76.69 173.57,79.75 arc(173.56,79.76) 173.55,79.78 arc(172.49,80.48) 171.25,80.73 137.12,80.73 arc(136.56,80.84) 136.08,81.16 133.95,83.29 arc(133.21,83.78) 132.34,83.96 92.34,83.96 arc(91.71,84.08) 91.18,84.43 77.04,98.58 arc(77.02,98.59) 77.01,98.6 arc(76.04,99.24) 74.89,99.47 64.45,99.47 arc(63.79,99.6) 63.23,99.97 60.3,102.9 arc(59.78,103.25) 59.17,103.37 58.16,103.37 58.04,103.26 56.86,103.26 56.7,103.42 v4(56.7,103.65) ; 189.54,49.47 arc(189.54,49.4) 189.53,49.34 arc(189.46,49.11) 189.32,48.92 189.12,48.72 189.12,48.72 arc(189.04,48.61) 189.01,48.47 CONN55_PF.6L13
NIFE_RX[39]_N: length 164.3
  TOP w0.095: U40.J1 v4(57.7,105.65)
  S12 w0.108: v4(57.7,105.65) 58.08,105.26 59.13,105.26 arc(59.68,105.15) 60.15,104.84 64.08,100.91 arc(64.45,100.66) 64.89,100.58 arc(64.9,100.58) 64.91,100.58 75.35,100.58 arc(76.6,100.33) 77.66,99.62 91.76,85.52 arc(92.27,85.18) 92.87,85.06 133.81,85.06 arc(134.59,84.9) 135.25,84.46 137.24,82.47 arc(137.65,82.2) 138.14,82.1 180.49,82.1 arc(182.35,81.73) 183.92,80.68 190.02,74.58 arc(190.71,73.56) 190.95,72.35 190.95,65.26 arc(191.07,64.63) 191.43,64.09 192.08,63.44 arc(192.72,62.49) 192.94,61.37 192.94,60.56 arc(192.99,60.32) 193.13,60.11 193.88,59.36 arc(194.08,59.06) 194.15,58.71 194.15,58.48 arc(194.09,58.18) 193.92,57.93 arc(193.87,57.87) 193.83,57.8 arc(193.82,57.74) 193.81,57.68 CONN55_PF.6T12
NIFE_RX[39]_P: length 164.3
  TOP w0.095: U40.H1 v4(57.7,104.65)
  S12 w0.108: CONN55_PF.6T13 193.33,57.99 arc(193.41,57.93) 193.5,57.91 arc(193.57,57.93) 193.63,57.97 193.76,58.09 arc(193.88,58.27) 193.92,58.48 193.92,58.73 arc(193.86,58.98) 193.72,59.2 193.57,59.35 192.96,59.95 arc(192.78,60.23) 192.71,60.56 192.71,61.37 arc(192.51,62.4) 191.92,63.28 191.92,63.28 191.27,63.93 arc(190.86,64.54) 190.72,65.26 190.72,72.35 arc(190.5,73.47) 189.86,74.42 183.76,80.52 arc(182.26,81.52) 180.49,81.87 138.14,81.87 arc(137.57,81.99) 137.08,82.31 135.09,84.3 135.09,84.3 arc(134.51,84.69) 133.81,84.83 92.87,84.83 arc(92.18,84.97) 91.6,85.36 77.49,99.46 arc(76.51,100.12) 75.35,100.35 64.89,100.35 arc(64.36,100.45) 63.92,100.75 62.75,101.91 62.64,101.8 62.26,102.18 arc(62.23,102.24) 62.26,102.29 arc(62.28,102.35) 62.26,102.41 61.93,102.73 arc(61.88,102.75) 61.82,102.73 arc(61.77,102.71) 61.71,102.73 61.39,103.05 arc(61.36,103.11) 61.39,103.17 arc(61.41,103.22) 61.39,103.28 61.06,103.6 arc(61.01,103.62) 60.95,103.6 60.95,103.6 arc(60.9,103.58) 60.84,103.6 60.52,103.92 arc(60.49,103.98) 60.52,104.04 arc(60.54,104.09) 60.52,104.15 59.99,104.67 arc(59.59,104.94) 59.13,105.03 58.08,105.03 v4(57.7,104.65)
NIFE_RX[46]_N: length 14
  TOP w0.095: v4(51.7,114.65) U40.V7
  S7 w0.108: v3(60.24,110.77) 60.07,110.93 arc(59.98,111.07) 59.95,111.24 59.95,111.26 arc(59.91,111.43) 59.82,111.57 58.68,112.71 arc(58.61,112.81) 58.59,112.93 58.59,114.6 arc(58.55,114.81) 58.43,114.98 57.83,115.59 arc(57.65,115.7) 57.44,115.75 52.87,115.75 arc(52.66,115.7) 52.49,115.59 52.23,115.33 arc(52.12,115.17) 52.08,114.98 52.08,114.82 arc(52.07,114.76) 52.04,114.71 52.02,114.69 arc(51.97,114.66) 51.91,114.65 v4(51.7,114.65)
  BOTTOM w0.095: v3(60.24,110.77) 60.24,111.32 CB607.2
NIFE_RX[46]_P: length 13.3
  TOP w0.095: v4(52.7,114.65) U40.V6
  S7 w0.108: v3(59.43,110.77) 59.62,110.97 arc(59.69,111.07) 59.72,111.19 59.72,111.26 arc(59.7,111.34) 59.66,111.41 58.52,112.55 arc(58.4,112.72) 58.36,112.93 58.36,114.6 arc(58.34,114.72) 58.27,114.82 57.66,115.43 arc(57.56,115.49) 57.44,115.52 52.87,115.52 arc(52.75,115.49) 52.65,115.43 52.39,115.17 arc(52.33,115.08) 52.31,114.98 52.31,114.82 arc(52.32,114.76) 52.36,114.71 52.37,114.69 arc(52.42,114.66) 52.49,114.65 v4(52.7,114.65)
  BOTTOM w0.095: v3(59.43,110.77) 59.43,111.32 CB586.2
NIFE_RX[47]_N: length 20.1
  TOP w0.095: v4(49.7,116.65) U40.W9 ; CB511.2 v3(65.31,120.05)
  S9 w0.108: v3(65.31,120.05) 65.31,119.42 arc(65.28,119.3) 65.21,119.19 64.93,118.91 arc(64.87,118.82) 64.85,118.72 64.85,118.52 arc(64.81,118.31) 64.69,118.14 63.85,117.3 arc(63.68,117.18) 63.47,117.14 61.33,117.14 arc(61.21,117.12) 61.11,117.05 59.99,115.93 arc(59.82,115.81) 59.61,115.77 50.58,115.77 arc(50.4,115.81) 50.24,115.91 50.22,115.93 arc(50.12,116.09) 50.08,116.27 50.08,116.47 arc(50.07,116.53) 50.04,116.58 50.02,116.6 arc(49.97,116.63) 49.91,116.65 v4(49.7,116.65)
NIFE_RX[47]_P: length 19.3
  TOP w0.095: CB528.2 v3(64.29,120.05) ; v4(50.7,116.65) U40.W8
  S9 w0.108: v4(50.7,116.65) 50.49,116.65 arc(50.42,116.63) 50.37,116.6 50.36,116.58 arc(50.32,116.53) 50.31,116.47 50.31,116.27 arc(50.33,116.17) 50.39,116.09 50.4,116.07 arc(50.49,116.02) 50.58,116 59.61,116 arc(59.73,116.02) 59.83,116.09 60.95,117.21 arc(61.14,117.34) 61.36,117.38 63.48,117.38 arc(63.6,117.41) 63.7,117.47 64.53,118.3 arc(64.6,118.4) 64.62,118.52 64.62,118.88 arc(64.61,118.96) 64.6,119.05 64.51,119.13 arc(64.35,119.38) 64.29,119.67 v3(64.29,120.05)
NIFE_TRVDD10_S1: length 48.5
  TOP w0.254: U40.H36 v4(21.7,104.65) ; v4(21.7,100.65) U40.D36 ; v4(22.7,98.65) U40.B35 ; v4(29.7,105.65) U40.J28 ; v4(25.7,100.65) U40.D32 ; v4(25.7,109.65) U40.N32 ; v4(26.7,102.65) U40.F31 ; v4(21.7,109.65) U40.N36 ; v4(22.7,97.65) U40.A35 ; U40.H32 v4(25.7,104.65) ; v4(22.7,102.65) U40.F35 ; v4(28.7,110.65) U40.P29 ; v4(29.7,99.65) U40.C28 ; v4(30.7,102.65) U40.F27 ; v4(23.7,110.65) U40.P34 ; v4(26.7,97.65) U40.A31 ; v4(22.7,110.65) U40.P35 ; v4(22.7,103.65) U40.G35 ; U40.H28 v4(29.7,104.65) ; v4(26.7,103.65) U40.G31 ; v4(29.7,100.65) U40.D28 ; v4(25.7,99.65) U40.C32 ; v4(21.7,99.65) U40.C36 ; v4(30.7,103.65) U40.G27 ; v4(21.7,105.65) U40.J36 ; v4(26.7,109.65) U40.N31 ; v4(20.7,109.65) U40.N37 ; v4(26.7,98.65) U40.B31 ; v4(27.7,110.65) U40.P30 ; v4(30.7,97.65) U40.A27 ; v4(30.7,98.65) U40.B27
  TOP w0.381: U40.J32 v4(25.7,105.65)
  BOTTOM w0.254: v4(27.7,110.65) 27.73,110.65 CB638.2 ; v4(26.7,109.65) 26.25,109.2 CB651.2 ; CB636.2 22.73,110.65 v4(22.7,110.65) ; CB697.2 22.76,103.65 v4(22.7,103.65)
  BOTTOM w0.305: v4(25.7,99.65) 25.7,99.7 CB740.2 ; v4(25.7,104.65) 25.24,104.19 CB698.2 ; CB683.2 29.67,105.65 v4(29.7,105.65) ; v4(29.7,104.65) 29.65,104.65 CB700.2 ; v4(26.7,98.65) 26.76,98.65 CB741.2 ; v4(30.7,97.65) 30.7,97.67 CB768.2 ; CB715.2 30.7,102.67 v4(30.7,102.65) ; v4(25.7,105.65) 25.24,105.19 CB682.2 ; v4(26.7,102.65) 26.74,102.65 CB718.2 ; CB717.2 25.7,100.73 v4(25.7,100.65) ; CB734.2 21.67,100.65 v4(21.7,100.65) ; v4(26.7,97.65) 26.7,97.66 CB767.2 ; CB743.2 30.7,98.65 v4(30.7,98.65) ; CB699.2 26.72,103.65 v4(26.7,103.65) ; v4(22.7,102.65) 22.73,102.65 CB721.2 ; v4(29.7,100.65) 29.7,100.72 CB719.2 ; v4(21.7,105.65) 21.21,105.16 CB693.2 21.22,105.13 v4(21.7,104.65) ; v4(29.7,99.65) 29.7,99.69 CB742.2 ; v4(30.7,103.65) 31.18,104.13 CB694.2 ; v4(22.7,98.65) 23.22,99.16 CB756.2
  BOTTOM w0.381: v4(28.7,110.65) 28.76,110.65 CB639.2 ; v2(23.18,94.56) 23.83,94.56 24.4,95.12 v1(24.54,95.12) ; CB674.2 21.72,105.65 v4(21.7,105.65) 21.21,106.13 CB673.2 ; CB650.2 25.27,109.22 v4(25.7,109.65) ; v4(21.7,109.65) 22.24,109.11 CB653.2 ; v4(21.7,99.65) 21.21,99.16 CB765.2 ; CB663.2 20.38,109.4 20.45,109.4 v4(20.7,109.65) ; CB637.2 23.74,110.65 v4(23.7,110.65) ; CB775.2 23.2,97.15 v4(22.7,97.65)
  vias: v1(24.54,94.36) v1(24.54,93.6) v1(28.55,95.46) v1(28.62,94.77) v1(28.58,94.06) v1(28.58,93.35) v1(29.33,94.19) v1(29.33,93.45) v1(100.42,92.25) v1(101.13,92.25) v1(101.95,92.25) v1(102.71,92.25)
NIFE_TRVDD10_S2: length 49.1
  TOP w0.381: U40.H2 v4(56.7,104.65) ; v4(50.7,114.65) U40.V8 ; v4(55.7,103.65) U40.G3 ; v4(56.7,99.65) U40.C2 ; v4(54.7,114.65) U40.V4 ; U40.U1 v4(57.7,113.65) ; U40.U2 v4(56.7,113.65) ; v4(55.7,98.65) U40.B3 ; U40.U7 v4(51.7,113.65) ; v4(56.7,105.65) U40.J2 ; v4(56.7,109.65) U40.N2 ; v4(57.7,109.65) U40.N1 ; v4(51.7,102.65) U40.F7 v4(51.7,103.65) U40.G7 ; v4(54.7,110.65) U40.P4 ; U40.H6 v4(52.7,104.65) ; v4(52.7,99.65) U40.C6 ; v4(50.7,110.65) U40.P8 ; U40.P3 v4(55.7,110.65) ; v4(55.7,97.65) U40.A3 ; v4(51.7,98.65) U40.B7 ; v4(49.7,114.65) U40.V9 ; v4(55.7,114.65) U40.V3 ; v4(56.7,100.65) U40.D2 ; v4(52.7,100.65) U40.D6 ; v4(51.7,97.65) U40.A7 ; v4(49.7,110.65) U40.P9 ; v4(52.7,109.65) U40.N6 ; v4(55.7,102.65) U40.F3 ; v4(51.7,109.65) U40.N7 ; U40.U6 v4(52.7,113.65) ; v4(52.7,105.65) U40.J6
  BOTTOM w0.305: CB602.2 54.21,114.16 v4(54.7,114.65) ; CB706.2 56.7,104.65 v4(56.7,104.65) 56.21,104.16 CB696.2 55.72,103.65 v4(55.7,103.65) ; v4(51.7,109.65) 52.18,109.17 CB648.2 ; CB704.2 v4(51.7,102.65) 51.26,102.2 CB720.2 ; v4(55.7,98.65) 55.17,99.17 CB751.2 ; CB647.2 57.24,109.19 v4(57.7,109.65) ; v4(51.7,103.65) 52.17,103.17 CB713.2 ; CB649.2 53.18,109.17 v4(52.7,109.65) ; CB576.2 50.7,114.69 v4(50.7,114.65) ; CB774.2 55.7,97.69 v4(55.7,97.65) ; v4(49.7,110.65) 49.73,110.65 CB634.2 ; v4(51.7,97.65) 51.7,97.65 CB773.2 ; CB766.2 52.7,99.64 v4(52.7,99.65) ; v4(54.7,110.65) 54.74,110.65 CB635.2 ; CB614.2 51.19,113.13 v4(51.7,113.65) ; v4(56.7,109.65) 56.26,109.2 CB652.2 ; CB735.2 52.7,100.62 v4(52.7,100.65) ; CB617.2 56.21,113.16 v4(56.7,113.65) ; v4(52.7,105.65) 52.7,105.6 CB684.2 ; v4(57.7,113.65) CB608.2 ; CB685.2 56.7,105.63 v4(56.7,105.65) ; CB705.2 v4(52.7,104.65) ; v4(50.7,110.65) 51.19,111.14 CB632.2 ; v4(55.7,110.65) 55.71,110.65 CB633.2 ; v4(49.7,114.65) 49.19,114.14 CB606.2 ; v4(55.7,114.65) 55.18,115.17 CB577.2 ; v4(51.7,98.65) 51.17,99.17 CB750.2
  BOTTOM w0.381: v4(52.7,113.65) 52.26,114.09 CB593.2 52.15,114.1 v4(51.7,113.65) ; CB732.2 56.21,101.13 v4(56.7,100.65) ; v4(56.7,99.65) 56.7,99.62 CB758.2 56.18,99.13 v4(55.7,98.65) ; v4(55.7,102.65) 55.21,102.16 CB716.2
  vias: v1(85.06,101.32) v1(85.06,100.56) v1(85.06,99.79) v1(85.06,99.03) v1(87.6,101.32) v1(87.6,100.56) v1(87.6,99.79) v1(87.6,99.03) v2(86.12,99.74)
NIFE_TX[16]_N: length 123.1
  TOP w0.095: U40.A26 v4(31.7,97.65)
  S14 w0.102: v4(31.7,97.65) 31.7,97.91 31.82,98.03 31.96,98.03 arc(32.07,97.99) 32.11,97.88 32.11,97.32 32.11,97.32 32.11,97.27 32.09,97.25 32.09,97.23
  S14 w0.108: 32.09,97.23 arc(32.18,96.74) 32.46,96.33 32.97,95.82 arc(33.1,95.62) 33.15,95.39 33.15,92.42 arc(33.25,91.91) 33.53,91.49 38.17,86.85 arc(38.74,86.47) 39.41,86.33 57.25,86.33 arc(57.79,86.22) 58.25,85.92 64.13,80.03 arc(64.8,79.59) 65.59,79.43 77.21,79.43 arc(77.93,79.28) 78.54,78.88 79.14,78.28 arc(79.87,77.79) 80.73,77.62 91.62,77.62 arc(92.5,77.44) 93.25,76.95 94.04,76.15 arc(94.58,75.79) 95.22,75.66 100.82,75.66 arc(102.68,75.29) 104.26,74.24 114.54,63.95 114.75,63.75 arc(115.65,63.15) 116.7,62.94 122.37,62.94 arc(122.72,62.87) 123.02,62.67 123.13,62.56 arc(123.58,62.26) 124.11,62.15 130.69,62.15 arc(131.1,62.07) 131.45,61.84 131.77,61.51 arc(131.98,61.2) 132.06,60.83 132.06,57.94 arc(132.03,57.79) 131.94,57.66 131.94,57.65 arc(131.88,57.61) 131.82,57.58 arc(131.74,57.6) 131.67,57.65 131.36,57.96 arc(131.25,58.12) CONN55_PF.2T19
NIFE_TX[16]_P: length 123.1
  TOP w0.095: U40.B26 v4(31.7,98.65)
  S14 w0.102: v4(31.7,98.65) 31.7,98.35 31.81,98.24 31.96,98.24 arc(32.21,98.13) 32.32,97.88 32.32,97.23
  S14 w0.108: CONN55_PF.2T18 132.01,57.41 132.1,57.5 arc(132.24,57.7) 132.29,57.94 132.29,60.83 arc(132.2,61.29) 131.94,61.68 131.61,62 arc(131.19,62.28) 130.69,62.38 124.11,62.38 arc(123.67,62.47) 123.29,62.72 123.18,62.83 arc(122.81,63.08) 122.37,63.17 116.7,63.17 arc(115.73,63.36) 114.91,63.91 104.42,74.4 arc(102.77,75.51) 100.82,75.89 95.22,75.89 arc(94.67,76) 94.21,76.31 93.41,77.11 arc(92.59,77.66) 91.62,77.85 80.73,77.85 arc(79.96,78) 79.3,78.44 78.7,79.04 arc(78.02,79.5) 77.21,79.66 65.59,79.66 arc(64.89,79.8) 64.29,80.2 58.41,86.08 arc(57.88,86.44) 57.25,86.56 39.42,86.56 arc(38.83,86.68) 38.33,87.01 33.69,91.65 arc(33.46,92) 33.38,92.42 33.38,95.39 arc(33.31,95.71) 33.13,95.98 32.62,96.49 arc(32.4,96.83) 32.32,97.23
NIFE_TX[17]_N: length 143.9
  TOP w0.095: U40.D27 v4(30.7,100.65)
  S14 w0.102: 33.29,97.37 33.29,97.37 33.29,99.82 arc(33.17,100.11) 32.87,100.24 31.11,100.24 arc(30.82,100.36) v4(30.7,100.65)
  S14 w0.108: CONN55_PF.2L19 136.81,48.56 arc(136.81,48.59) 136.82,48.61 arc(136.85,48.74) 136.92,48.84 arc(136.93,48.85) 136.93,48.85 137.99,49.91 arc(138.35,50.44) 138.47,51.07 138.47,55.84 arc(138.58,56.39) 138.9,56.86 139.11,57.07 arc(139.4,57.52) 139.51,58.04 139.51,60.86 arc(139.42,61.31) 139.17,61.69 138.01,62.84 arc(137.59,63.12) 137.1,63.22 136.53,63.22 arc(136.18,63.29) 135.89,63.48 135.05,64.32 arc(133.74,65.2) 132.2,65.5 125.65,65.5 arc(125.4,65.55) 125.2,65.69 arc(124.9,65.89) 124.54,65.96 121.74,65.96 arc(121.32,65.88) 120.96,65.64 120.87,65.55 arc(120.65,65.4) 120.39,65.35 117.49,65.35 arc(116.71,65.51) 116.05,65.95 115.42,66.58 114.11,67.89 113.67,68.33 arc(113.45,68.65) 113.38,69.03 113.38,69.59 arc(113.26,70.18) 112.93,70.68 111.08,72.52 arc(110.58,72.86) 110,72.97 109.06,72.97 arc(107.85,73.2) 106.8,73.87 arc(106.77,73.9) 106.74,73.93 106.74,73.93 104.62,76.04 arc(103.32,76.91) 101.79,77.21 97.2,77.21 arc(95.48,77.55) 94.03,78.53 arc(93.15,79.11) 92.11,79.32 81.6,79.32 arc(80.51,79.54) 79.59,80.15 79.46,80.29 arc(78.76,80.76) 77.93,80.92 65.98,80.92 arc(65.29,81.06) 64.71,81.45 59.33,86.83 59.33,86.83 59.03,87.13 arc(58.29,87.62) 57.43,87.79 40.35,87.79 arc(39.86,87.89) 39.45,88.17 38.61,89 arc(38.42,89.28) 38.36,89.61 38.36,93.36 arc(38.25,93.91) 37.93,94.38 35.85,96.46 arc(35.33,96.81) 34.72,96.93 33.92,96.93 arc(33.74,96.97) 33.59,97.07 33.29,97.37
NIFE_TX[17]_P: length 143.9
  TOP w0.095: U40.C27 v4(30.7,99.65)
  S14 w0.102: v4(30.7,99.65) 30.7,99.88 arc(30.74,99.99) 30.85,100.03 32.87,100.03 arc(33.02,99.97) 33.09,99.82 33.09,97.25 33.13,97.21
  S14 w0.108: CONN55_PF.2L18 136.01,49.01 arc(136.03,48.9) 136.09,48.82 136.18,48.73 arc(136.24,48.69) 136.32,48.67 136.33,48.67 arc(136.42,48.69) 136.49,48.74 136.75,49 136.75,49 137.83,50.07 arc(138.14,50.53) 138.24,51.07 138.24,55.84 arc(138.37,56.48) 138.74,57.02 138.95,57.23 arc(139.19,57.6) 139.28,58.04 139.28,60.86 arc(139.21,61.22) 139,61.52 137.85,62.68 arc(137.51,62.91) 137.1,62.99 136.53,62.99 arc(136.09,63.08) 135.73,63.32 134.89,64.16 arc(133.65,64.99) 132.2,65.28 125.65,65.28 arc(125.32,65.34) 125.03,65.53 arc(124.81,65.68) 124.54,65.73 121.74,65.73 arc(121.4,65.67) 121.12,65.48 121.03,65.39 arc(120.74,65.19) 120.39,65.12 117.49,65.12 arc(116.62,65.3) 115.89,65.79 113.95,67.73 113.51,68.17 arc(113.24,68.57) 113.15,69.03 113.15,69.59 arc(113.05,70.09) 112.77,70.52 112.1,71.18 111.42,71.86 110.92,72.36 arc(110.5,72.64) 110,72.74 109.06,72.74 arc(107.76,72.99) 106.64,73.7 106.64,73.7 104.46,75.88 arc(103.24,76.7) 101.79,76.98 97.2,76.98 arc(95.4,77.34) 93.87,78.36 arc(93.06,78.9) 92.11,79.09 81.6,79.09 arc(80.43,79.33) 79.43,79.99 79.3,80.13 arc(78.67,80.55) 77.93,80.69 65.98,80.69 arc(65.21,80.85) 64.55,81.28 58.87,86.97 arc(58.21,87.41) 57.43,87.56 40.35,87.56 arc(39.77,87.68) 39.29,88 38.45,88.84 arc(38.21,89.19) 38.13,89.61 38.13,93.36 arc(38.04,93.83) 37.77,94.22 35.69,96.3 arc(35.24,96.6) 34.72,96.7 33.92,96.7 arc(33.65,96.76) 33.43,96.91 33.13,97.21
NIFE_TX[18]_N: length 112.7
  TOP w0.095: U40.A28 v4(29.7,97.65)
  S14 w0.102: 30.1,97.52 30.1,97.63 30.11,97.63 30.11,97.9 arc(30.06,98.01) 29.95,98.06 29.82,98.06 arc(29.73,98.02) 29.7,97.94 v4(29.7,97.65)
  S14 w0.108: 30.1,97.52 30.1,97.52 30.1,97.41 arc(30.1,97.35) 30.1,97.3 arc(30.18,97.03) 30.34,96.81 31.28,95.88 arc(31.51,95.53) 31.59,95.12 31.59,92.46 arc(31.74,91.67) 32.19,91 37.46,85.73 arc(38.13,85.28) 38.93,85.13 55.46,85.13 arc(57.07,84.8) 58.45,83.89 63.24,79.09 arc(64.47,78.27) 65.93,77.98 76.89,77.98 arc(77.56,77.85) 78.12,77.47 78.63,76.96 arc(79.36,76.47) 80.23,76.3 89.52,76.3 arc(90.6,76.08) 91.51,75.47 93.03,73.96 arc(93.27,73.59) 93.36,73.15 arc(93.36,73.14) 93.36,73.13 93.36,70.89 arc(93.52,70.11) 93.96,69.45 95.1,68.31 arc(96.41,67.44) 97.95,67.13 105.34,67.13 arc(106.39,66.92) 107.29,66.32 110.97,62.64 arc(111.9,62.02) 113,61.8 116.75,61.8 arc(117.63,61.44) 117.99,60.57 117.99,58.31 arc(117.95,58.13) 117.85,57.98 117.58,57.71 arc(117.52,57.67) 117.46,57.66 117.32,57.66 arc(117.24,57.67) 117.16,57.72 117.03,57.85 arc(116.98,57.93) 116.96,58.02 CONN55_PF.1T19
NIFE_TX[18]_P: length 112.7
  TOP w0.095: U40.B28 v4(29.7,98.65)
  S14 w0.102: 30.31,97.47 30.31,97.9 arc(30.2,98.16) 29.95,98.26 29.82,98.26 arc(29.73,98.3) 29.7,98.39
  S14 w0.108: CONN55_PF.1T18 117.76,57.49 arc(117.76,57.52) 117.77,57.54 arc(117.77,57.55) 117.77,57.55 arc(117.79,57.59) 117.82,57.63 118.01,57.82 arc(118.16,58.04) 118.21,58.31 118.21,60.57 arc(117.79,61.6) 116.75,62.03 113,62.03 arc(111.99,62.23) 111.13,62.8 107.45,66.49 arc(106.48,67.13) 105.34,67.36 97.95,67.36 arc(96.5,67.65) 95.26,68.47 94.12,69.62 arc(93.73,70.2) 93.59,70.89 93.59,73.15 arc(93.49,73.67) 93.19,74.12 91.67,75.63 arc(90.68,76.3) 89.52,76.53 80.23,76.53 arc(79.45,76.68) 78.79,77.12 78.78,77.13 78.28,77.63 arc(77.64,78.06) 76.89,78.21 65.93,78.21 arc(64.56,78.48) 63.4,79.26 58.61,84.05 arc(57.16,85.01) 55.46,85.35 38.93,85.35 arc(38.22,85.49) 37.62,85.89 32.35,91.17 arc(31.96,91.76) 31.82,92.46 31.82,95.12 arc(31.72,95.62) 31.44,96.04 30.5,96.97 arc(30.39,97.14) 30.33,97.33 30.31,97.35 30.31,97.47 ; 29.7,98.39 v4(29.7,98.65)
NIFE_TX[19]_N: length 127.2
  TOP w0.095: U40.D29 v4(28.7,100.65)
  S14 w0.102: v4(28.7,100.65) 28.7,100.4 arc(28.75,100.28) 28.87,100.23 28.96,100.23 arc(29.21,100.13) 29.31,99.88 29.31,99.34 29.28,99.31 29.28,96.9 29.31,96.87 29.31,96.57 arc(29.34,96.39) 29.43,96.23 arc(29.45,96.2) 29.47,96.18
  S14 w0.108: 29.47,96.18 29.98,95.67 arc(30.42,95.02) 30.57,94.24 30.57,91.74 arc(30.87,90.25) 31.72,88.98 36.17,84.53 arc(36.59,84.25) 37.08,84.15 55.32,84.15 arc(56.46,83.92) 57.42,83.28 63.27,77.42 arc(63.64,77.18) 64.08,77.09 75.96,77.09 arc(76.69,76.94) 77.3,76.53 77.6,76.24 78.07,75.77 arc(78.58,75.43) 79.17,75.31 81.88,75.31 arc(82.87,75.11) 83.7,74.55 83.91,74.34 84.22,74.04 arc(84.84,73.62) 85.56,73.48 88.76,73.48 arc(89.73,73.29) 90.55,72.74 90.59,72.7 arc(90.84,72.31) 90.94,71.85 90.94,70.94 arc(91.06,70.29) 91.43,69.74 91.57,69.6 94.39,66.78 arc(95.34,66.15) 96.46,65.92 102.63,65.92 arc(104.63,65.53) 106.33,64.39 109.8,60.92 arc(110.63,60.36) 111.6,60.17 113.83,60.17 114.31,59.69 arc(114.55,59.33) 114.63,58.9 114.63,58.4 arc(114.66,58.26) 114.74,58.14 115.1,57.79 arc(115.38,57.37) 115.47,56.88 115.47,51.11 arc(115.73,50.5) 116.34,50.24 122.16,50.24 arc(122.62,50.05) 122.8,49.6 122.8,48.95 arc(122.76,48.75) 122.65,48.57 122.42,48.35 122.42,48.04 CONN55_PF.1L19
NIFE_TX[19]_P: length 127.2
  TOP w0.095: U40.C29 v4(28.7,99.65)
  S14 w0.102: v4(28.7,99.65) 28.7,99.86 arc(28.75,99.98) 28.87,100.03 28.96,100.03 arc(29.07,99.98) 29.11,99.88 29.11,99.43 29.08,99.4 29.08,96.82 29.11,96.79 29.11,96.57 arc(29.15,96.32) 29.27,96.11 29.27,96.09 29.3,96.06 29.3,96.03 29.31,96.02
  S14 w0.108: 29.31,96.02 29.82,95.51 arc(30.21,94.93) 30.34,94.24 30.34,91.74 arc(30.66,90.16) 31.56,88.81 36.01,84.36 arc(36.5,84.03) 37.08,83.92 55.32,83.92 arc(56.37,83.71) 57.26,83.12 63.11,77.26 arc(63.56,76.96) 64.08,76.86 75.96,76.86 arc(76.6,76.73) 77.14,76.37 77.91,75.6 arc(78.49,75.22) 79.17,75.08 81.88,75.08 arc(82.78,74.9) 83.54,74.39 83.56,74.37 84.06,73.87 arc(84.75,73.41) 85.56,73.25 88.76,73.25 arc(89.64,73.08) 90.39,72.58 90.42,72.54 arc(90.63,72.22) 90.71,71.85 90.71,70.94 arc(90.85,70.2) 91.27,69.57 94.23,66.62 arc(95.25,65.93) 96.46,65.69 102.63,65.69 arc(104.54,65.31) 106.17,64.23 109.64,60.75 arc(110.54,60.15) 111.6,59.94 113.73,59.94 113.94,59.73 114.15,59.53 arc(114.34,59.24) 114.41,58.9 114.41,58.4 arc(114.45,58.17) 114.58,57.98 114.94,57.62 arc(115.16,57.28) 115.24,56.88 115.24,51.11 arc(115.57,50.33) 116.34,50.01 122.16,50.01 arc(122.45,49.89) 122.58,49.6 122.58,48.95 arc(122.55,48.83) 122.48,48.73 122.3,48.54 122.17,48.54 121.76,48.95 CONN55_PF.1L18
NIFE_TX[20]_N: length 102.5
  TOP w0.095: U40.A30 v4(27.7,97.65)
  S14 w0.102: v4(27.7,97.65) 27.7,97.95 27.81,98.06 27.99,98.06 28.11,97.95 28.11,97.38 28.01,97.29 28.01,96.46 27.99,96.44 27.99,96.43
  S14 w0.108: 27.99,96.43 27.99,96.22 27.93,96.15 arc(27.78,95.93) 27.73,95.67 27.73,91.69 arc(28.2,89.3) 29.55,87.28 32.26,84.57 arc(35.19,82.62) 38.63,81.93 55.44,81.93 arc(56.09,81.8) 56.65,81.43 61.8,76.28 arc(62.46,75.84) 63.24,75.68 69.81,75.68 arc(71.02,75.44) 72.04,74.76 72.53,74.27 arc(73.35,73.72) 74.31,73.53 78.04,73.53 arc(78.77,73.39) 79.39,72.97 79.67,72.69 arc(79.92,72.52) 80.22,72.46 80.51,72.46 arc(80.87,72.39) 81.17,72.19 84.01,69.35 arc(85.26,68.51) 86.73,68.22 89.67,68.22 arc(90.19,68.12) 90.63,67.82 94.05,64.4 arc(94.7,63.97) 95.46,63.81 102.16,63.81 arc(102.69,63.6) 102.91,63.07 102.91,62.49 arc(102.79,62.2) 102.49,62.08 102.15,62.08 arc(101.76,61.92) 101.6,61.53 101.6,58.39 101.6,58.39 arc(101.6,58.33) 101.59,58.26 arc(101.52,58.04) 101.38,57.85 101.27,57.74 101.25,57.72 arc(101.18,57.67) 101.08,57.65 101.04,57.65 arc(100.95,57.67) 100.87,57.72 100.79,57.8 arc(100.7,57.94) 100.66,58.11 CONN54_PF.6T19
NIFE_TX[20]_P: length 102.5
  TOP w0.095: U40.B30 v4(27.7,98.65)
  S14 w0.102: 28.22,96.43 28.22,96.46 28.22,96.46 28.22,97.21 28.31,97.3 28.31,98.03 28.08,98.26 27.82,98.26 27.8,98.29
  S14 w0.108: v4(27.7,98.65) 27.7,98.39 27.8,98.29 ; CONN54_PF.6T18 101.46,57.5 arc(101.46,57.53) 101.47,57.56 arc(101.5,57.63) 101.54,57.69 arc(101.72,57.93) 101.82,58.23 101.83,58.24 101.83,61.53 arc(101.93,61.75) 102.15,61.85 102.49,61.85 arc(102.95,62.04) 103.14,62.49 103.14,63.07 arc(102.85,63.76) 102.16,64.04 95.46,64.04 arc(94.78,64.18) 94.21,64.56 90.79,67.98 arc(90.27,68.33) 89.67,68.45 86.73,68.45 arc(85.35,68.72) 84.18,69.51 81.33,72.35 arc(80.95,72.6) 80.51,72.69 80.22,72.69 arc(80.01,72.73) 79.83,72.85 79.55,73.13 arc(78.86,73.6) 78.04,73.76 74.31,73.76 arc(73.44,73.93) 72.69,74.43 72.2,74.92 arc(71.1,75.66) 69.81,75.91 63.24,75.91 arc(62.55,76.05) 61.96,76.45 56.81,81.59 arc(56.18,82.01) 55.44,82.16 38.63,82.16 arc(35.27,82.83) 32.42,84.73 29.71,87.45 arc(28.41,89.39) 27.95,91.69 27.95,95.67 arc(27.99,95.84) 28.09,95.99 28.22,96.13 28.22,96.43
NIFE_TX[21]_N: length 113.9
  TOP w0.095: U40.D31 v4(26.7,100.65)
  S14 w0.102: 27.25,97.24 27.29,97.29 27.29,97.49 27.29,97.49 27.29,99.93 arc(27.18,100.18) 26.94,100.28 26.89,100.28 arc(26.75,100.34) 26.7,100.48 v4(26.7,100.65)
  S14 w0.108: CONN54_PF.6L19 106.26,48.54 arc(106.26,48.57) 106.27,48.59 arc(106.27,48.6) 106.27,48.6 arc(106.27,48.6) 106.27,48.61 arc(106.3,48.69) 106.35,48.76 106.44,48.85 arc(106.59,49.07) 106.65,49.34 arc(106.37,50) 105.71,50.27 100.32,50.27 arc(99.58,50.58) 99.27,51.32 99.27,56.41 arc(99.13,57.14) 98.71,57.75 91.56,64.91 arc(90.97,65.31) 90.26,65.44 85.81,65.44 arc(85.14,65.58) 84.58,65.95 80.61,69.92 80.61,69.92 80.45,70.08 79.94,70.59 arc(79.36,70.98) 78.67,71.12 73.09,71.12 arc(72.24,71.29) 71.52,71.76 70.2,73.09 arc(69.79,73.36) 69.31,73.46 62.16,73.46 arc(61.46,73.6) 60.87,73.99 54.43,80.43 arc(53.77,80.88) 52.98,81.03 38.04,81.03 arc(34.13,81.81) 30.82,84.02 27.21,87.63 arc(26.86,88.15) 26.74,88.76 26.74,96.07 arc(26.77,96.19) 26.84,96.29 26.93,96.39 arc(27.02,96.52) 27.05,96.67 27.05,97.05 27.25,97.24
NIFE_TX[21]_P: length 113.9
  TOP w0.095: U40.C31 v4(26.7,99.65)
  S14 w0.102: v4(26.7,99.65) 26.7,99.97 arc(26.73,100.05) 26.8,100.08 26.94,100.08 arc(27.04,100.03) 27.08,99.93 27.08,97.4
  S14 w0.108: 27.08,97.4 26.82,97.14 26.82,96.68 arc(26.81,96.61) 26.77,96.55 26.67,96.45 arc(26.56,96.28) 26.51,96.07 26.51,88.76 arc(26.65,88.06) 27.05,87.47 30.65,83.86 arc(34.04,81.6) 38.04,80.8 52.98,80.8 arc(53.68,80.66) 54.27,80.27 60.71,73.83 arc(61.37,73.39) 62.16,73.23 69.31,73.23 arc(69.7,73.15) 70.04,72.93 71.36,71.6 arc(72.15,71.07) 73.09,70.89 78.67,70.89 arc(79.27,70.77) 79.78,70.43 80.29,69.92 84.42,65.79 arc(85.06,65.37) 85.81,65.22 90.26,65.22 arc(90.88,65.09) 91.4,64.75 98.55,57.59 arc(98.91,57.05) 99.04,56.41 99.04,51.32 arc(99.41,50.42) 100.32,50.05 105.71,50.05 arc(106.21,49.84) 106.42,49.34 arc(106.38,49.16) 106.28,49.01 105.98,48.71 arc(105.93,48.68) 105.87,48.66 arc(105.8,48.68) 105.74,48.72 105.6,48.86 arc(105.5,49.01) 105.46,49.19 CONN54_PF.6L18
NIFE_TX[22]_N: length 103.5
  TOP w0.095: U40.A32 v4(25.7,97.65)
  S14 w0.102: v4(25.7,97.65) 25.7,97.82 arc(25.75,97.97) 25.88,98.06 25.91,98.06 25.95,98.07 arc(26.06,98.02) 26.11,97.91 26.11,97.45 26.11,97.44
  S14 w0.108: 26.11,97.44 25.73,97.07 arc(25.49,96.7) 25.4,96.28 25.4,86.35 arc(25.51,85.83) 25.8,85.38 27.28,83.91 arc(32.06,80.71) 37.7,79.59 52.21,79.59 arc(53.07,79.42) 53.8,78.93 60.27,72.46 arc(61.31,71.76) 62.55,71.52 68.44,71.52 arc(69.08,71.39) 69.62,71.03 arc(69.77,70.82) 69.82,70.57 69.82,69.24 arc(70.1,68.56) 70.78,68.27 73.98,68.27 arc(74.22,68.22) 74.43,68.09 74.67,67.84 arc(74.98,67.63) 75.35,67.56 80.69,67.56 arc(80.96,67.45) 81.07,67.19 81.07,66.86 arc(80.95,66.57) 80.65,66.44 80.21,66.44 arc(79.19,65.42) 80.21,64.4 81.62,64.4 arc(82.99,64.13) 84.16,63.35 arc(84.65,63.02) 85.23,62.9 91.22,62.9 arc(91.39,62.83) 91.46,62.67 91.46,62.03 arc(91.39,61.86) 91.22,61.8 88.04,61.8 arc(87.6,61.62) 87.42,61.18 87.42,58.5 arc(87.35,58.11) 87.12,57.78 87.11,57.77 arc(87.01,57.7) 86.9,57.68 86.84,57.68 arc(86.73,57.7) 86.64,57.76 86.57,57.84 arc(86.45,58.01) 86.41,58.21 CONN54_PF.5T19
NIFE_TX[22]_P: length 103.5
  TOP w0.095: U40.B32 v4(25.7,98.65)
  S14 w0.102: v4(25.7,98.65) 25.7,98.52 arc(25.77,98.35) 25.94,98.27 arc(26.2,98.17) 26.31,97.91 26.31,97.53 26.31,97.33 26.27,97.28
  S14 w0.108: CONN54_PF.5T18 87.21,57.45 arc(87.22,57.49) 87.23,57.54 arc(87.23,57.54) 87.23,57.54 arc(87.25,57.58) 87.28,57.62 arc(87.56,58.02) 87.65,58.5 87.65,61.18 arc(87.77,61.45) 88.04,61.57 91.22,61.57 arc(91.55,61.7) 91.68,62.03 91.68,62.67 arc(91.55,62.99) 91.22,63.13 85.23,63.13 arc(84.74,63.23) 84.32,63.51 84.32,63.51 arc(83.08,64.34) 81.62,64.63 80.21,64.63 arc(79.42,65.42) 80.21,66.22 80.65,66.22 arc(81.11,66.4) 81.3,66.86 81.3,67.19 arc(81.12,67.61) 80.69,67.79 75.35,67.79 arc(75.07,67.85) 74.83,68.01 74.59,68.25 arc(74.31,68.44) 73.98,68.5 70.78,68.5 arc(70.26,68.72) 70.04,69.24 70.04,70.57 arc(69.98,70.9) 69.79,71.19 arc(69.17,71.6) 68.44,71.75 62.55,71.75 arc(61.4,71.98) 60.43,72.63 53.96,79.1 arc(53.16,79.63) 52.21,79.82 37.7,79.82 arc(32.15,80.92) 27.45,84.07 25.97,85.55 arc(25.72,85.92) 25.63,86.35 25.63,96.28 arc(25.7,96.62) 25.89,96.9 26.27,97.28
NIFE_TX[23]_N: length 105.2
  TOP w0.095: U40.C33 v4(24.7,99.65)
  S14 w0.102: v4(24.7,99.65) 24.7,99.81 arc(24.63,99.97) 24.48,100.04 arc(24.36,99.99) 24.31,99.87 24.31,97.42 24.31,97.41
  S14 w0.108: 24.31,97.41 24.52,97.2 24.52,96.32 arc(24.46,96.02) 24.29,95.76 arc(23.89,95.15) 23.74,94.44 23.74,87.33 arc(24.18,85.12) 25.44,83.25 arc(30.55,79.83) 36.58,78.63 50.68,78.63 arc(51.62,78.45) 52.41,77.91 58.89,71.43 arc(59.09,71.13) 59.16,70.78 59.16,70.53 arc(59.23,70.22) 59.4,69.96 61.22,68.14 arc(61.58,67.9) 62.01,67.81 68.01,67.81 arc(68.4,67.74) 68.73,67.52 72.35,63.9 arc(72.87,63.55) 73.49,63.42 78.29,63.42 arc(79.96,63.09) 81.37,62.15 84.51,59.01 arc(84.87,58.47) 84.99,57.83 84.99,51.06 arc(85.25,50.44) 85.88,50.18 91.65,50.18 arc(92.06,50.01) 92.23,49.6 92.23,49.12 arc(92.2,48.98) 92.13,48.87 92.1,48.84 arc(92.07,48.81) 92.05,48.78 arc(92.05,48.77) 92.05,48.77 arc(92.02,48.7) 92.01,48.63 CONN54_PF.5L19
NIFE_TX[23]_P: length 105.3
  TOP w0.095: U40.D33 v4(24.7,100.65)
  S14 w0.102: v4(24.7,100.65) 24.7,100.59 arc(24.62,100.37) 24.43,100.25 arc(24.2,100.15) 24.11,99.93 24.11,97.42 24.11,97.42 24.11,97.33 24.14,97.29 24.14,97.26 24.15,97.25
  S14 w0.108: CONN54_PF.5L18 91.45,49.07 arc(91.6,48.97) 91.78,48.93 arc(91.86,48.95) 91.94,49 arc(91.99,49.07) 92,49.16 92,49.6 arc(91.9,49.85) 91.65,49.95 85.88,49.95 arc(85.09,50.27) 84.76,51.06 84.76,57.83 arc(84.65,58.38) 84.34,58.85 81.21,61.99 arc(79.87,62.88) 78.29,63.19 73.49,63.19 arc(72.78,63.34) 72.18,63.74 68.57,67.36 arc(68.31,67.52) 68.01,67.58 62.01,67.58 arc(61.5,67.69) 61.06,67.98 59.24,69.8 arc(59.02,70.14) 58.94,70.53 58.94,70.78 arc(58.88,71.05) 58.73,71.27 52.25,77.75 arc(51.53,78.23) 50.68,78.4 36.58,78.4 arc(30.46,79.62) 25.28,83.08 arc(23.97,85.03) 23.52,87.33 23.52,94.44 arc(23.68,95.24) 24.13,95.92 arc(24.25,96.11) 24.29,96.32 24.29,97.11 24.15,97.25
NIFE_TX[24]_N: length 102.7
  TOP w0.095: U40.C37 v4(20.7,99.65)
  S14 w0.108: v4(20.7,99.65) 20.7,99.93 20.6,100.03 16.3,100.03 arc(16.12,100) 15.97,99.9 arc(15.74,99.56) 15.66,99.16 15.66,93.24 arc(15.42,92.66) 14.84,92.42 14.5,92.42 arc(13.91,91.82) 14.5,91.23 14.84,91.23 arc(15.42,90.99) 15.66,90.41 15.66,78.33 16.27,77.72 20.41,77.72 21.53,76.6 21.53,68.18 arc(22.22,66.51) 23.89,65.82 44.24,65.82 arc(45.46,65.58) 46.49,64.89 47.72,63.66 47.87,63.51 arc(48.62,63.01) 49.5,62.84 54.17,62.84 arc(55.14,62.44) 55.54,61.47 55.54,60.3 arc(55.6,60.01) 55.76,59.76 arc(56.13,59.21) 56.26,58.56 56.26,51.3 arc(56.58,50.52) 57.36,50.2 63.47,50.2 63.85,49.82 63.85,49.12 63.51,48.79 CONN54_PF.3L19
NIFE_TX[24]_P: length 102.7
  TOP w0.095: U40.D37 v4(20.7,100.65)
  S14 w0.108: CONN54_PF.3L18 63.06,48.96 63.36,48.96 63.62,49.22 63.62,49.72 63.37,49.97 57.36,49.97 arc(56.42,50.36) 56.03,51.3 56.03,58.56 arc(55.92,59.12) 55.6,59.6 55.6,59.6 arc(55.39,59.92) 55.31,60.3 55.31,61.47 arc(54.98,62.27) 54.17,62.61 49.49,62.61 arc(48.53,62.8) 47.71,63.35 47.56,63.49 46.33,64.73 arc(45.37,65.37) 44.24,65.59 23.89,65.59 arc(22.06,66.35) 21.3,68.18 21.3,76.5 20.31,77.49 16.18,77.49 15.43,78.24 15.43,90.41 arc(15.26,90.83) 14.84,91 14.5,91 arc(13.68,91.82) 14.5,92.64 14.84,92.64 arc(15.26,92.82) 15.43,93.24 15.43,99.16 arc(15.53,99.65) 15.81,100.06 arc(16.03,100.21) 16.3,100.26 20.6,100.26 20.7,100.35 v4(20.7,100.65)
NIFE_TX[25]_N: length 89
  TOP w0.095: U40.B36 v4(21.7,98.65)
  S14 w0.108: v4(21.7,98.65) 21.7,98.37 arc(21.67,98.29) 21.59,98.26 19.37,98.26 arc(18.4,97.86) 18,96.89 18,90.41 arc(17.86,90.07) 17.52,89.93 17.4,89.93 arc(16.58,89.11) 17.4,88.29 17.41,88.29 arc(17.83,88.11) 18,87.69 18,87.58 arc(17.86,87.24) 17.52,87.1 17.4,87.1 arc(16.58,86.28) 17.4,85.45 17.41,85.45 arc(17.86,85.26) 18.05,84.8 arc(17.9,84.42) 17.52,84.27 17.4,84.27 arc(16.58,83.44) 17.4,82.62 19.24,82.62 arc(19.67,82.44) 19.85,82.01 19.85,81.51 arc(19.65,81.02) 19.17,80.82 17.77,80.82 arc(17.18,80.57) 16.93,79.98 16.93,79.55 arc(17.16,79.01) 17.69,78.79 20.78,78.79 arc(21.55,78.64) 22.2,78.2 22.87,77.53 arc(23.19,77.05) 23.31,76.47 23.31,74.15 arc(23.36,73.87) 23.53,73.62 23.86,73.29 24.09,73.06 arc(24.5,72.79) 24.98,72.69 25.46,72.69 arc(25.8,72.63) 26.08,72.44 27.63,70.88 arc(27.78,70.66) 27.83,70.41 27.83,70.41 27.83,70.1 arc(27.91,69.71) 28.13,69.38 28.78,68.72 arc(29.39,68.31) 30.12,68.17 36.4,68.17 arc(36.69,68.11) 36.95,67.94 37.25,67.64 arc(37.53,67.45) 37.86,67.38 45.17,67.38 arc(45.69,67.49) 46.13,67.78 46.38,68.03 arc(46.7,68.25) 47.08,68.32 48.02,68.32 arc(48.33,68.26) 48.6,68.08 48.66,68.02 48.67,68.02 arc(49.04,67.8) 49.46,67.73 51.28,67.73 arc(52.27,67.53) 53.12,66.96 53.48,66.6 arc(53.91,66.32) 54.41,66.22 54.91,66.22 arc(55.33,66.13) 55.7,65.89 58.34,63.25 arc(58.7,62.7) 58.83,62.06 58.83,58.42 arc(58.79,58.22) 58.67,58.04 arc(58.55,57.96) 58.41,57.93 arc(58.29,57.96) 58.19,58.02 57.91,58.3 CONN54_PF.3T19
NIFE_TX[25]_P: length 89
  TOP w0.095: U40.A36 v4(21.7,97.65)
  S14 w0.108: v4(21.7,97.65) 21.7,97.92 arc(21.67,98) 21.59,98.03 19.37,98.03 arc(18.56,97.7) 18.23,96.89 18.23,90.41 arc(18.02,89.91) 17.52,89.7 17.4,89.7 arc(16.81,89.11) 17.4,88.51 17.41,88.51 arc(17.99,88.27) 18.23,87.69 18.23,87.58 arc(18.02,87.08) 17.52,86.87 17.4,86.87 arc(16.81,86.28) 17.4,85.68 17.41,85.68 arc(18.03,85.43) 18.28,84.8 arc(18.06,84.26) 17.52,84.04 17.4,84.04 arc(16.81,83.44) 17.4,82.85 19.24,82.85 arc(19.84,82.6) 20.08,82.01 20.08,81.51 arc(19.81,80.86) 19.17,80.59 17.77,80.59 arc(17.34,80.41) 17.16,79.98 17.16,79.55 arc(17.32,79.17) 17.69,79.02 20.78,79.02 arc(21.64,78.85) 22.36,78.36 23.03,77.7 arc(23.4,77.13) 23.54,76.47 23.54,74.15 arc(23.58,73.95) 23.69,73.78 24.25,73.23 arc(24.59,73) 24.98,72.92 25.46,72.92 arc(25.88,72.84) 26.24,72.6 27.79,71.05 arc(27.99,70.75) 28.06,70.41 28.06,70.1 arc(28.12,69.8) 28.29,69.54 28.94,68.88 arc(29.48,68.53) 30.11,68.4 36.4,68.4 arc(36.78,68.32) 37.11,68.1 37.42,67.8 arc(37.62,67.66) 37.86,67.61 45.17,67.61 arc(45.6,67.7) 45.96,67.94 46.22,68.2 arc(46.61,68.46) 47.08,68.55 48.02,68.55 arc(48.42,68.47) 48.76,68.25 arc(48.79,68.22) 48.82,68.19 arc(49.12,68.02) 49.46,67.96 51.28,67.96 arc(52.36,67.74) 53.28,67.13 53.64,66.77 arc(53.99,66.53) 54.41,66.44 54.91,66.44 arc(55.42,66.34) 55.86,66.05 58.5,63.41 arc(58.91,62.79) 59.06,62.06 59.06,58.42 arc(59,58.13) 58.83,57.88 58.67,57.72 arc(58.67,57.72) 58.66,57.71 arc(58.66,57.71) 58.66,57.71 arc(58.62,57.64) 58.61,57.57 58.61,57.15 arc(58.64,57.02) CONN54_PF.3T18
NIFE_TX[26]_N: length 105.4
  TOP w0.095: U40.C35 v4(22.7,99.65)
  S14 w0.102: 22.27,97.26 22.31,97.31 22.31,97.34 22.31,97.51 22.31,97.51 22.31,99.9 arc(22.36,100.03) 22.49,100.08 arc(22.64,100.02) 22.7,99.87 v4(22.7,99.65)
  S14 w0.108: CONN54_PF.4L19 77.76,48.66 arc(77.77,48.72) 77.78,48.78 arc(77.82,48.86) 77.87,48.92 arc(78.02,49.14) 78.07,49.4 78.07,49.64 arc(77.89,50.08) 77.45,50.26 71.54,50.26 arc(71,50.49) 70.78,51.03 70.78,57.53 arc(70.35,59.69) 69.12,61.52 arc(67.31,62.73) 65.17,63.16 64.65,63.16 arc(63.97,62.88) 63.69,62.2 63.69,62.11 arc(63.56,61.78) 63.23,61.64 63.04,61.64 arc(62.71,61.78) 62.58,62.11 62.58,62.17 arc(62.5,62.58) 62.26,62.92 arc(62,63.1) 61.69,63.16 61.43,63.16 arc(60.87,63.27) 60.39,63.59 55.89,68.09 arc(55.55,68.6) 55.43,69.21 55.43,69.55 arc(55.3,70.2) 54.93,70.76 arc(54.41,71.11) 53.8,71.23 49.5,71.23 arc(49.02,71.43) 48.82,71.91 48.82,71.96 arc(48.77,72.2) 48.64,72.4 arc(48.01,72.66) 47.38,72.4 47.15,72.17 arc(46.97,72.05) 46.76,72.01 43.96,72.01 arc(42.74,72.25) 41.7,72.94 41.5,73.15 arc(41.16,73.37) 40.76,73.45 arc(40.35,73.59) 40.01,73.84 arc(39.65,74.08) 39.23,74.17 35.99,74.17 arc(35.26,74.02) 34.64,73.61 arc(34.52,73.44) 34.48,73.24 34.48,71.5 arc(34.45,71.33) 34.36,71.19 arc(33.63,70.7) 32.76,70.53 32.23,70.53 arc(31,71.04) 30.5,72.27 30.5,74.6 arc(30.38,75.16) 30.06,75.64 29.81,75.89 arc(29.08,76.38) 28.21,76.55 arc(27.04,76.79) 26.04,77.45 22.22,81.28 arc(21.31,82.63) 21,84.22 21,95.21 arc(21.14,95.93) 21.55,96.54 22.27,97.26
NIFE_TX[26]_P: length 105.3
  TOP w0.095: U40.D35 v4(22.7,100.65)
  S14 w0.102: v4(22.7,100.65) 22.7,100.49 arc(22.64,100.34) 22.49,100.28 arc(22.22,100.17) 22.11,99.9 22.11,97.42
  S14 w0.108: CONN54_PF.4L18 76.96,49.3 77.3,48.97 arc(77.36,48.92) 77.44,48.91 77.44,48.91 arc(77.53,48.93) 77.6,48.97 77.71,49.09 arc(77.81,49.23) 77.84,49.4 77.84,49.64 arc(77.73,49.92) 77.45,50.04 71.54,50.04 arc(70.84,50.33) 70.55,51.03 70.55,57.53 arc(70.14,59.6) 68.96,61.36 arc(67.22,62.52) 65.17,62.93 64.65,62.93 arc(64.14,62.72) 63.92,62.2 63.92,62.11 arc(63.72,61.62) 63.23,61.41 63.04,61.41 arc(62.55,61.62) 62.35,62.11 62.35,62.17 arc(62.28,62.49) 62.1,62.76 arc(61.91,62.89) 61.69,62.93 61.43,62.93 arc(60.78,63.06) 60.23,63.43 55.73,67.93 arc(55.34,68.51) 55.2,69.21 55.2,69.55 arc(55.09,70.12) 54.77,70.6 arc(54.32,70.89) 53.8,71 49.5,71 arc(48.86,71.26) 48.59,71.91 48.59,71.96 arc(48.56,72.11) 48.48,72.24 arc(48.01,72.43) 47.54,72.24 47.31,72.01 arc(47.06,71.84) 46.76,71.78 43.96,71.78 arc(42.65,72.04) 41.54,72.78 41.34,72.98 arc(41.07,73.16) 40.76,73.22 arc(40.75,73.22) 40.74,73.22 arc(40.73,73.22) 40.72,73.23 arc(40.25,73.39) 39.84,73.68 arc(39.56,73.87) 39.23,73.94 35.99,73.94 arc(35.34,73.81) 34.8,73.44 arc(34.73,73.35) 34.71,73.24 34.71,71.5 arc(34.66,71.25) 34.52,71.03 arc(33.71,70.49) 32.76,70.3 32.23,70.3 arc(30.84,70.88) 30.27,72.27 30.27,74.6 arc(30.17,75.07) 29.9,75.48 29.65,75.73 arc(28.99,76.17) 28.21,76.32 arc(26.95,76.58) 25.88,77.29 22.05,81.12 arc(21.1,82.54) 20.77,84.22 20.77,95.21 arc(20.93,96.02) 21.39,96.71 22.11,97.42
NIFE_TX[27]_N: length 102.7
  TOP w0.095: U40.B34 v4(23.7,98.65)
  S14 w0.108: v4(23.7,98.65) 23.37,98.32 arc(23.25,98.14) 23.21,97.94 23.21,97.22 arc(23.16,96.98) 23.03,96.78 22.65,96.4 arc(22.35,95.95) 22.25,95.42 22.25,84.16 arc(22.35,83.63) 22.65,83.19 26.96,78.88 arc(27.45,78.55) 28.03,78.43 arc(29.23,78.19) 30.24,77.52 31.16,76.6 arc(31.51,76.07) 31.64,75.44 31.64,72.14 arc(31.82,71.7) 32.25,71.52 32.9,71.52 arc(33.34,71.7) 33.52,72.14 33.52,75.61 arc(33.93,76.6) 34.92,77.01 41.65,77.01 arc(42.46,76.68) 42.8,75.87 42.8,75.15 arc(43.15,74.29) 44.01,73.94 44.75,73.94 arc(45.33,74.18) 45.57,74.76 45.57,76.19 arc(46.17,76.78) 46.76,76.19 46.76,74.76 arc(47,74.18) 47.58,73.94 51.78,73.94 arc(52.06,73.88) 52.29,73.73 52.55,73.46 arc(53.09,73.11) 53.72,72.98 54.7,72.98 arc(55.17,72.88) 55.58,72.62 56.93,71.26 arc(57.18,70.89) 57.27,70.45 57.27,69.05 arc(57.47,68.05) 58.04,67.2 58.97,66.26 arc(60.02,65.56) 61.25,65.32 68.47,65.32 arc(68.91,65.23) 69.28,64.98 71.89,62.37 arc(72.36,62.06) 72.92,61.95 75.97,61.95 arc(76.66,61.66) 76.95,60.96 76.95,59.87 arc(76.79,59.49) 76.41,59.33 74.92,59.33 arc(74.21,59.19) 73.61,58.79 72.85,58.03 arc(72.78,57.99) 72.7,57.97 72.61,57.97 arc(72.51,57.99) 72.42,58.05 CONN54_PF.4T19
NIFE_TX[27]_P: length 102.7
  TOP w0.095: U40.A34 v4(23.7,97.65)
  S14 w0.108: v4(23.7,97.65) 23.56,97.51 arc(23.47,97.38) 23.44,97.22 arc(23.37,96.89) 23.19,96.62 22.82,96.24 arc(22.56,95.86) 22.47,95.42 22.47,94.44 arc(22.5,94.38) 22.56,94.35 arc(22.62,94.33) 22.65,94.27 22.65,93.9 arc(22.62,93.84) 22.56,93.82 arc(22.5,93.79) 22.47,93.73 22.47,93.36 arc(22.5,93.3) 22.56,93.28 arc(22.62,93.25) 22.65,93.19 22.65,92.82 arc(22.62,92.76) 22.56,92.74 arc(22.5,92.71) 22.47,92.65 22.47,92.28 arc(22.5,92.22) 22.56,92.2 arc(22.62,92.17) 22.65,92.11 22.65,91.74 arc(22.62,91.68) 22.56,91.66 arc(22.5,91.63) 22.47,91.57 22.47,91.2 arc(22.5,91.14) 22.56,91.12 arc(22.62,91.09) 22.65,91.03 22.65,90.66 arc(22.62,90.6) 22.56,90.58 arc(22.5,90.55) 22.47,90.49 22.47,84.16 arc(22.56,83.72) 22.81,83.35 27.12,79.04 28.03,78.66 arc(29.32,78.41) 30.41,77.68 31.32,76.77 arc(31.72,76.16) 31.87,75.44 31.87,72.14 arc(31.98,71.87) 32.25,71.75 32.9,71.75 arc(33.18,71.87) 33.29,72.14 33.29,75.61 arc(33.77,76.76) 34.92,77.24 41.65,77.24 arc(42.62,76.84) 43.02,75.87 43.02,75.15 arc(43.31,74.45) 44.01,74.16 44.75,74.16 arc(45.17,74.34) 45.35,74.76 45.35,76.19 arc(46.17,77.01) 46.99,76.19 46.99,74.76 arc(47.16,74.34) 47.58,74.16 51.78,74.16 arc(52.14,74.09) 52.45,73.89 52.71,73.63 arc(53.18,73.32) 53.72,73.21 54.7,73.21 arc(55.26,73.1) 55.74,72.78 57.1,71.42 arc(57.39,70.98) 57.5,70.45 57.5,69.05 arc(57.68,68.14) 58.2,67.36 59.14,66.42 arc(60.11,65.77) 61.25,65.55 68.47,65.55 arc(69,65.44) 69.44,65.14 72.05,62.54 arc(72.45,62.27) 72.92,62.18 75.97,62.18 arc(76.83,61.82) 77.18,60.96 77.18,59.87 arc(76.96,59.33) 76.41,59.1 74.92,59.1 arc(74.3,58.98) 73.77,58.63 73.77,58.63 73.06,57.92 arc(73.02,57.87) 73,57.83 arc(72.99,57.82) 72.99,57.81 arc(72.97,57.75) 72.96,57.68 CONN54_PF.4T18
