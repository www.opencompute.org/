# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P15_LED2_SFP+_G: length 161.6
  TOP w0.127: R1267.1 v1(140.16,69.11) ; v4(196.55,184.58) U9.R8
  S7 w0.127: v1(140.16,69.11) 140.73,69.68 140.73,70.5 141.01,70.78 142.3,70.78 142.88,71.36 142.88,75.45 144.82,77.39 145.2,77.39 149.52,81.71 168.39,81.71 178.1,91.42 178.1,133.4 172.72,138.77 172.72,139.17 171.59,140.3 171.59,145.63 172.14,146.18 172.14,148.46 174.15,150.47 174.15,150.91 176.94,153.71 177.7,153.71 178.91,154.91 178.91,156.44 179.67,157.2 179.67,162.24 188.22,170.79 189.14,170.79 197.76,179.41 197.76,180.7 198.01,180.95 198.01,183.94 197.81,184.15 196.98,184.15 v4(196.55,184.58)
  BOTTOM w0.127: v2(140.56,68.05) 140.17,68.43 140.17,69.09 v1(140.16,69.11)
P15_LED2_SFP+_G_R: length 29
  TOP w0.127: LED48.C1 128.26,51.69 v1(128.11,51.85) ; v1(140.14,64.31) 140.16,64.33 C824.1 139.85,65.11 139.66,65.3 139.66,67.28 139.84,67.46 R1267.2
  S12 w0.127: v1(128.11,51.85) 129.38,53.12 129.38,60.97 129.95,61.54 132.25,61.54 132.88,62.17 136.03,62.17 138.68,64.82 139.63,64.82 v1(140.14,64.31)
  BOTTOM w0.127: v1(140.14,64.31) 139.28,65.17 v2(139.28,65.57)
P16_LED1_SFP+_A: length 160
  TOP w0.127: R898.1 v1(144.94,69.18) ; v4(201.55,181.58) U9.V12
  S7 w0.127: v1(144.94,69.18) 144.94,69.46 145.51,70.03 145.51,72.87 146.33,73.7 146.86,73.7 147.98,74.82 147.98,76.46 150.85,79.32 169.2,79.32 180.13,90.25 180.13,134.64 177.33,137.44 177.33,140.3 178.34,141.31 178.34,147.17 177.89,147.61 177.89,149.44 179.35,150.9 179.35,151.36 182.97,154.98 182.97,159.99 185.01,162.03 185.01,163.78 189.18,167.95 193.34,167.95 195.86,170.47 195.86,174.64 201.55,180.32 v4(201.55,181.58)
  BOTTOM w0.127: v2(203.36,175.8) 203.36,177.33 201.83,178.85 201.83,181.01 201.55,181.29 v4(201.55,181.58)
P16_LED1_SFP+_A_R: length 22.2
  TOP w0.127: v1(144.95,64.28) 144.94,64.29 C611.1 144.58,65.18 144.47,65.3 144.47,67.41 144.59,67.53 R898.2 ; LED24.C2 v1(139.76,51.98)
  S16 w0.127: v1(144.95,64.28) 139.39,58.72 139.39,56.94 138.78,56.33 138.78,53.14 139.76,52.15 v1(139.76,51.98)
  BOTTOM w0.127: v1(144.95,64.28) 144.95,64.92 144.3,65.57 v2(144.3,65.63)
P16_LED1_SFP+_G: length 160.3
  TOP w0.127: v1(143.95,69.16) 143.93,69.14 R899.1 ; v4(200.55,183.58) 200.12,184.01 U9.T11
  S7 w0.127: v1(143.95,69.16) 143.95,69.45 144.49,70 144.49,73.31 145.17,74 146.74,74 147.68,74.94 147.68,76.58 150.72,79.62 169.08,79.62 179.87,90.42 179.87,134.54 176.99,137.42 176.99,140.5 178.08,141.59 178.08,147.04 177.64,147.48 177.64,150.83 182.72,155.91 182.72,160.18 184.75,162.21 184.75,163.88 189.18,168.31 193.26,168.31 195.41,170.46 195.41,174.54 201.03,180.16 201.03,181.79 200.55,182.27 v4(200.55,183.58)
  BOTTOM w0.127: v4(200.55,183.58) 201.04,183.09 201.04,180.14 v2(201.17,180.01)
P16_LED1_SFP+_G_R: length 21.6
  TOP w0.127: R899.2 143.46,67.53 143.36,67.43 143.36,65.38 143.55,65.18 C612.1 143.93,64.36 v1(143.94,64.34) ; LED24.C1 139.06,52.01 v1(139.07,52.02)
  S16 w0.127: v1(143.94,64.34) 139.08,59.48 139.08,57.23 138.32,56.47 138.32,52.78 v1(139.07,52.02)
  BOTTOM w0.127: v1(143.94,64.34) 144.3,63.98 144.3,63.35 v2(144.32,63.35)
P16_LED2_SFP+_A: length 154.1
  TOP w0.127: R1268.1 v1(145,75.03) ; v4(200.55,184.58) U9.R11
  S7 w0.127: v4(200.55,184.58) 200.14,184.58 199.66,184.1 199.46,184.1 199.08,183.72 199.08,179.29 194.28,174.49 194.28,171.17 192.43,169.33 189.11,169.33 183.7,163.91 183.7,162.63 180.69,159.63 180.69,155.19 176.5,151 176.5,147.58 175.91,146.99 175.23,146.99 172.79,144.55 172.79,141.69 175.04,139.44 175.04,138.29 179.11,134.22 179.11,90.87 168.81,80.57 150.33,80.57 145,75.24 v1(145,75.03)
  BOTTOM w0.127: v2(145.57,76.11) 145,75.54 v1(145,75.03)
P16_LED2_SFP+_A_R: length 26.2
  TOP w0.127: v1(140.1,55.95) 139.76,55.62 LED49.C2 ; v1(145,70.21) C827.1 144.66,71.03 144.49,71.19 144.49,73.23 144.64,73.38 R1268.2
  S7 w0.127: v1(145,70.21) 145,69.95 144.43,69.38 144.43,64.04 142.84,62.46 142.84,57.76 141.38,56.3 140.44,56.3 v1(140.1,55.95)
  BOTTOM w0.127: v1(145,70.21) 145,71.73 144.53,72.2 144.53,73.14 v2(143.92,73.76)
P16_LED2_SFP+_G: length 154.8
  TOP w0.127: R1269.1 v1(143.99,75.03) ; v4(199.55,184.58) U9.R10
  S7 w0.127: v4(199.55,184.58) 198.75,183.77 198.75,179.32 192.88,173.45 192.88,170.91 191.54,169.58 189,169.58 183.44,164.02 183.44,162.81 180.44,159.8 180.44,155.3 177.76,152.63 177.26,152.63 174.91,150.28 174.91,149.9 173.55,148.53 173.55,145.87 172.46,144.79 172.46,141.29 174.65,139.11 174.65,138.32 178.86,134.12 178.86,90.98 168.78,80.9 149.86,80.9 v1(143.99,75.03)
  BOTTOM w0.127: v1(143.99,75.03) 143.92,75.1 143.92,77.15 v2(144.25,77.48)
P16_LED2_SFP+_G_R: length 23.3
  TOP w0.127: LED49.C1 139.06,55.63 v1(139.36,55.93) ; R1269.2 143.65,73.38 143.44,73.17 143.44,71.24 143.66,71.03 C826.1 v1(143.99,70.21)
  S7 w0.127: v1(143.99,70.21) 143.35,69.57 143.35,64.68 142.52,63.86 142.52,57.95 141.19,56.61 140.05,56.61 v1(139.36,55.93)
  BOTTOM w0.127: v1(143.99,70.21) 143.99,71.06 v2(144.15,71.21)
P17_LED1_SFP+_A: length 151.2
  TOP w0.127: v4(200.55,181.58) U9.V11 ; R900.1 v1(147.04,75.03)
  S7 w0.127: v4(200.55,181.58) 200.55,180.04 194.97,174.46 194.97,170.51 193.19,168.72 189.23,168.72 184.43,163.92 184.43,162.34 182.46,160.37 182.46,156.03 177.38,150.95 177.38,146.59 175.82,145.03 175.82,142.37 175.77,142.32 175.77,138.28 179.62,134.43 179.62,90.57 168.98,79.93 150.6,79.93 147.04,76.37 v1(147.04,75.03)
  BOTTOM w0.127: v4(200.55,181.58) 200.55,178.73 v2(201.9,177.39)
P17_LED1_SFP+_B_R: length 24.9
  TOP w0.127: R900.2 147.21,73.38 147.7,72.89 147.7,71.29 147.44,71.03 C613.1 v1(147.04,70.21) ; LED25.C2 143.21,55.79 142.99,56.01 v1(142.99,56.39)
  S7 w0.127: v1(142.99,56.39) 143.54,56.93 143.54,61.12 146.46,64.04 146.46,69.43 147.04,70.01 v1(147.04,70.21)
  BOTTOM w0.127: v1(147.04,70.21) 147.04,71.03 147.6,71.6 147.6,72.11 v2(148.62,73.12)
P17_LED1_SFP+_G: length 153.2
  TOP w0.127: R901.1 v1(146.02,75.03) ; v4(201.55,185.58) U9.P12
  S7 w0.127: v4(201.55,185.58) 201.07,185.1 201.07,184.44 200.75,184.12 200.37,184.12 200.02,183.77 200.02,179.87 194.7,174.55 194.7,170.96 192.75,169.01 189.16,169.01 184.06,163.91 184.06,162.55 180.94,159.43 180.94,155.09 177.13,151.27 177.13,146.78 174.74,144.39 174.74,143.52 175.48,142.77 175.48,138.21 179.37,134.33 179.37,90.7 168.9,80.24 150.47,80.24 146.02,75.79 v1(146.02,75.03)
  BOTTOM w0.127: v2(146.33,73.95) 146.02,74.26 v1(146.02,75.03)
P17_LED1_SFP+_G_R: length 22.3
  TOP w0.127: v1(142.23,56.41) 142.51,56.13 LED25.C1 ; v1(146.02,70.21) C614.1 146.23,71.03 146.49,71.29 146.49,73.09 146.2,73.38 R901.2
  S7 w0.127: v1(142.23,56.41) 143.16,57.34 143.16,61.63 145.44,63.92 145.44,69.4 146.02,69.98 v1(146.02,70.21)
  BOTTOM w0.127: v2(146.27,71.41) 146.02,71.16 v1(146.02,70.21)
P17_LED2_SFP+_A: length 155.1
  TOP w0.127: v4(202.55,184.58) U9.R13 ; R1270.1 v1(146.97,69.18)
  S7 w0.127: v4(202.55,184.58) 202.12,184.15 202.12,183.39 202.51,183 202.51,178.51 196.5,172.5 196.5,169.59 194.2,167.29 189.36,167.29 186.03,163.96 186.03,157.27 180.63,151.87 180.63,148.66 180.09,148.11 180.09,146.5 178.91,145.32 178.91,136.58 180.64,134.85 180.64,90.04 175.64,85.05 175.64,85.02 169.41,78.79 159.05,78.79 153.57,73.31 148.24,73.31 147.6,72.68 147.6,69.81 v1(146.97,69.18)
  BOTTOM w0.127: v1(146.97,69.18) 146.84,69.05 v2(146.84,67.79)
P17_LED2_SFP+_A_R: length 21.6
  TOP w0.127: v1(143.01,51.98) 143.21,51.78 LED50.C2 ; R1270.2 146.7,67.53 146.49,67.33 146.49,65.3 146.6,65.18 C829.1 146.97,64.37 v1(147.03,64.31)
  S16 w0.127: v1(143.01,51.98) 143.01,53.13 143.92,54.03 143.92,58.39 143.19,59.12 143.19,60.47 v1(147.03,64.31)
  BOTTOM w0.127: v1(147.03,64.31) 147.03,63.89 v2(146.2,63.06)
P17_LED2_SFP+_G: length 157.2
  TOP w0.127: v4(201.55,184.58) 201.12,185.01 U9.R12 ; R1271.1 v1(145.96,69.18)
  S7 w0.127: v4(201.55,184.58) 201.55,184.39 201.13,183.97 201.13,182.34 201.51,181.97 201.72,181.97 202,181.69 202,178.45 196.24,172.69 196.24,170.15 193.7,167.61 189.32,167.61 185.49,163.78 185.49,159.33 184.45,158.29 184.45,156.07 180.38,152 180.38,148.84 179.83,148.29 179.83,146.61 178.59,145.37 178.59,141.2 177.84,140.45 177.84,137.29 180.38,134.75 180.38,90.14 169.31,79.07 169.1,79.07 151.83,79.07 148.24,75.47 148.24,74.71 146.52,73 146.52,70 145.96,69.43 v1(145.96,69.18)
  BOTTOM w0.127: v1(145.96,69.18) 145.96,69 v2(144.95,67.99)
P17_LED2_SFP+_G_R: length 21.6
  TOP w0.127: R1271.2 145.62,67.53 145.47,67.39 145.47,65.3 145.59,65.18 C828.1 145.96,64.32 v1(145.99,64.28) ; v1(142.24,52.18) 142.24,51.82 142.51,51.54 LED50.C1
  S16 w0.127: v1(145.99,64.28) 142.61,60.9 142.61,58.98 143.54,58.05 143.54,54.35 142.26,53.07 142.26,52.2 v1(142.24,52.18)
  BOTTOM w0.127: v2(146.27,65.69) 145.99,65.42 v1(145.99,64.28)
P18_LED1_SFP+_A: length 147.3
  TOP w0.127: v4(205.55,183.58) U9.T16 ; R902.1 v1(157.51,69.18)
  S7 w0.127: v1(157.51,69.18) 157.51,69.43 158.08,70 158.08,73.44 158.54,73.9 159.65,73.9 162.81,77.06 170.42,77.06 182.11,88.75 182.11,88.79 182.15,88.82 182.15,88.85 182.16,88.86 182.16,135.5 180.49,137.17 180.49,144.62 182.28,146.41 182.28,146.44 182.29,146.44 182.29,146.61 184.24,148.56 184.24,151.11 190.21,157.08 195.49,157.08 199.42,161.01 199.42,171.61 205.96,178.15 205.96,180.34 204.99,181.3 204.99,183.02 v4(205.55,183.58)
  BOTTOM w0.127: v1(157.51,69.18) 157.51,69.18 v2(157.51,67.98)
P18_LED1_SFP+_B_R: length 21.9
  TOP w0.127: v1(157.51,64.43) C617.1 157.03,65.18 156.97,65.24 156.97,67.33 157.17,67.53 R902.2 ; LED26.C2 v1(154.01,51.99)
  S16 w0.127: v1(157.51,64.43) 157.51,63.29 153.64,59.41 153.64,57.76 152.77,56.89 152.77,54.38 154.01,53.14 v1(154.01,51.99)
  BOTTOM w0.127: v2(153.57,53.49) 154.01,53.05 v1(154.01,51.99)
P18_LED1_SFP+_G: length 146.4
  TOP w0.127: v4(204.55,181.58) U9.V15 ; R903.1 v1(156.5,69.18)
  S7 w0.127: v4(204.55,181.58) 204.55,177.95 198.09,171.49 198.09,160.06 195.37,157.34 190.02,157.34 183.87,151.19 183.87,148.55 182.04,146.72 182.04,146.55 182.03,146.54 182.03,146.52 182,146.5 182,146.49 180.18,144.66 180.18,137.12 181.91,135.4 181.91,88.97 181.89,88.96 181.89,88.93 170.31,77.34 162.7,77.34 159.53,74.18 158.43,74.18 157.06,72.82 157.06,69.75 v1(156.5,69.18)
  BOTTOM w0.127: v2(206.61,179.49) 206.61,179.52 v4(204.55,181.58)
P18_LED1_SFP+_G_R: length 20.9
  TOP w0.127: v1(156.43,64.42) 156.5,64.48 C618.1 156.12,65.18 155.95,65.36 155.95,67.3 156.18,67.53 R903.2 ; v1(153.33,52.16) 153.31,52.14 LED26.C1
  S16 w0.127: v1(153.33,52.16) 153.33,53.05 152.52,53.87 152.52,57.08 153.32,57.88 153.32,59.54 156.43,62.65 v1(156.43,64.42)
  BOTTOM w0.127: v1(156.43,64.42) 156.11,64.74 v2(156.11,65.5)
P18_LED2_SFP+_A: length 140
  TOP w0.127: R1272.1 v1(157.58,75.03) ; v4(203.55,182.58) U9.U14
  S7 w0.127: v4(203.55,182.58) 203.09,182.12 203.09,178.2 197.12,172.23 197.12,160.36 195.8,159.04 188.43,159.04 187.81,158.42 187.81,156.31 182.86,151.36 182.86,148.75 181,146.89 181,146.58 179.42,144.99 179.42,136.79 181.14,135.06 181.14,89.83 176.15,84.83 176.15,84.77 169.66,78.28 160.83,78.28 v1(157.58,75.03)
  BOTTOM w0.127: v2(157.83,75.98) 157.58,75.73 v1(157.58,75.03)
P18_LED2_SFP+_A_R: length 21.7
  TOP w0.127: v1(157.58,70.21) C831.1 157.94,71.03 158.05,71.14 158.05,73.3 157.98,73.38 R1272.2 ; LED51.C2 154.01,55.86 v1(153.99,55.88)
  BOTTOM w0.127: v1(153.99,55.88) 153.99,58.05 v2(156.81,60.87) 157.12,61.18 157.12,63.02 158.02,63.92 158.02,67.16 158.4,67.54 158.4,68.23 158.02,68.62 158.02,69.77 v1(157.58,70.21)
P18_LED2_SFP+_G: length 142.2
  TOP w0.127: R1273.1 v1(156.56,75.03) ; v4(202.55,183.58) U9.T13
  S7 w0.127: v1(156.56,75.03) 160.07,78.53 169.56,78.53 175.9,84.88 175.9,84.94 180.89,89.93 180.89,134.96 179.16,136.69 179.16,145.18 180.34,146.35 180.34,147.96 180.89,148.51 180.89,151.75 186.34,157.2 186.34,158.53 187.16,159.36 195.61,159.36 196.87,160.61 196.87,172.43 202.76,178.32 202.76,183.37 v4(202.55,183.58)
  BOTTOM w0.127: v1(156.56,75.03) 156.43,74.89 v2(156.43,74.01)
P18_LED2_SFP+_G_R: length 21.3
  TOP w0.127: LED51.C1 153.31,55.71 153.28,55.75 v1(153.28,55.8) ; R1273.2 156.6,73.38 157.05,72.92 157.05,71.19 156.88,71.03 C830.1 v1(156.56,70.21)
  BOTTOM w0.127: v1(153.28,55.8) 153.28,58.31 155.83,60.86 155.83,62.55 v2(156.05,62.77) 157.02,63.75 157.02,67.07 156.68,67.41 156.68,68.53 157.02,68.87 157.02,69.75 v1(156.56,70.21)
P19_LED1_SFP+_A: length 137.8
  TOP w0.127: v4(204.55,182.58) U9.U15 ; R904.1 159.61,75.02 v1(159.6,75.03)
  S7 w0.127: v1(159.6,75.03) 162.25,77.67 170.25,77.67 181.65,89.08 181.65,135.29 179.92,137.02 179.92,144.77 181.75,146.59 181.75,146.6 181.78,146.63 181.78,146.83 183.53,148.58 183.53,151.2 189.92,157.59 195.24,157.59 197.83,160.18 197.83,171.99 204.08,178.24 204.08,182.11 v4(204.55,182.58)
  BOTTOM w0.127: v1(159.6,75.03) 159.6,75.35 v2(160.05,75.79)
P19_LED1_SFP+_B_R: length 22.2
  TOP w0.127: LED27.C2 157.46,55.6 v1(156.84,56.22) ; R904.2 159.99,73.38 160.11,73.25 160.11,71.22 159.92,71.03 C619.1 v1(159.61,70.21)
  S7 w0.127: v1(156.84,56.22) 157.09,56.47 157.09,62.04 159.03,63.98 159.03,69.38 159.61,69.95 v1(159.61,70.21)
  BOTTOM w0.127: v2(159.54,71.47) 159.54,70.28 v1(159.61,70.21)
P19_LED1_SFP+_G: length 140.1
  TOP w0.127: v4(203.55,181.58) U9.V14 ; R905.1 v1(158.59,75.03)
  S7 w0.127: v4(203.55,181.58) 203.59,181.54 203.59,178.26 197.58,172.25 197.58,160.31 196.05,158.79 189.51,158.79 189.26,158.53 189.26,157.29 183.18,151.22 183.18,150.23 183.19,150.23 183.19,148.63 181.5,146.94 181.5,146.7 179.67,144.87 179.67,136.91 181.4,135.19 181.4,89.72 181.35,89.67 181.35,89.17 170.13,77.95 161.52,77.95 v1(158.59,75.03)
  BOTTOM w0.127: v4(203.55,181.58) 203.8,181.33 203.8,178.84 v2(204.01,178.63)
P19_LED1_SFP+_G_R: length 22.3
  TOP w0.127: v1(158.59,70.21) C620.1 158.88,71.03 159.07,71.22 159.07,73.3 159,73.38 R905.2 ; LED27.C1 156.31,55.16 156.31,56.82 v1(156.49,57.01)
  S7 w0.127: v1(156.49,57.01) 156.77,57.28 156.77,62.86 158.02,64.11 158.02,69.4 158.59,69.98 v1(158.59,70.21)
  BOTTOM w0.127: v2(157.38,71.41) 157.39,71.41 v1(158.59,70.21)
P19_LED2_SFP+_A: length 146.6
  TOP w0.127: R1274.1 v1(159.55,69.18) ; v4(206.55,181.58) U9.V17
  S7 w0.127: v1(159.55,69.18) 159.6,69.18 160.11,69.7 160.11,72.04 160.75,72.68 162.02,72.68 163.6,74.27 163.6,75.87 164.24,76.5 170.65,76.5 182.6,88.45 182.6,88.51 182.63,88.54 182.63,88.59 182.65,88.61 182.65,88.64 182.67,88.65 182.67,135.71 181,137.38 181,144.24 182.93,146.17 182.93,146.53 184.88,148.48 184.88,150.92 190.53,156.58 195.83,156.58 205.9,166.64 205.9,169.09 208.58,171.77 208.58,179.07 206.55,181.1 v4(206.55,181.58)
  BOTTOM w0.127: v2(208.53,180.14) 207.99,180.14 v4(206.55,181.58)
P19_LED2_SFP+_A_R: length 20.9
  TOP w0.127: LED52.C2 157.46,52.27 157.15,52.58 v1(157.12,52.58) ; R1274.2 159.27,67.53 159.06,67.33 159.06,65.31 159.19,65.18 C833.1 v1(159.55,64.47)
  S16 w0.127: v1(159.55,64.47) 159.55,63.6 157.33,61.39 157.33,57.9 158.22,57.01 158.22,54.08 157.12,52.98 v1(157.12,52.58)
  BOTTOM w0.127: v1(159.55,64.47) 159.1,64.92 v2(159.1,65.63)
P19_LED2_SFP+_G: length 147.6
  TOP w0.127: R1275.1 v1(158.53,69.18) ; U9.U16 v4(205.55,182.58)
  S7 w0.127: v4(205.55,182.58) 206.04,182.09 206.04,181.08 208.32,178.79 208.32,171.88 205.64,169.2 205.64,166.87 195.6,156.83 190.34,156.83 184.56,151.05 184.56,148.52 182.65,146.61 182.65,146.32 180.74,144.41 180.74,137.28 182.41,135.61 182.41,88.76 182.4,88.75 182.4,88.72 182.38,88.7 182.38,88.64 170.53,76.8 162.96,76.8 159.8,73.63 159.48,73.63 159.1,73.25 159.1,69.92 158.53,69.36 v1(158.53,69.18)
  BOTTOM w0.127: v2(159.54,67.73) 159.54,68.17 v1(158.53,69.18)
P19_LED2_SFP+_G_R: length 21.4
  TOP w0.127: v1(158.53,64.44) C832.1 158.15,65.18 158.05,65.28 158.05,67.39 158.19,67.53 R1275.2 ; LED52.C1 156.76,51.88 v1(156.68,51.97)
  S16 w0.127: v1(158.53,64.44) 158.52,64.44 158.52,63.35 156.98,61.8 156.98,57.72 157.9,56.8 157.9,54.27 156.56,52.93 156.56,52.09 v1(156.68,51.97)
  BOTTOM w0.127: v2(158.08,62.58) 158.46,62.96 158.46,64.38 v1(158.53,64.44)
P20_LED1_SFP+_A: length 144
  TOP w0.127: U9.P17 v4(206.55,185.58) ; R906.1 v1(170.09,69.18)
  S7 w0.127: v4(206.55,185.58) 207.03,186.05 208.4,186.05 210.26,184.19 210.26,171.16 207.86,168.76 207.86,165.2 197.7,155.04 194.91,155.04 187.42,147.55 187.42,145.31 186.8,144.7 185.28,144.7 184.64,144.05 184.64,143.62 184.43,143.41 184.43,136.72 184.21,136.49 184.21,87.77 184.17,87.73 184.13,87.68 184.13,87.57 184.07,87.51 184.07,87.44 175.66,79.03 175.66,73.61 175.43,73.38 171.92,73.38 171.67,73.12 171.67,71.92 171.29,71.54 171.03,71.54 170.65,71.16 170.65,69.57 170.27,69.18 v1(170.09,69.18)
  BOTTOM w0.127: v2(169.57,68.04) 169.57,68.67 v1(170.09,69.18)
P20_LED1_SFP+_B_R: length 21.2
  TOP w0.127: LED28.C2 v1(168.26,51.84) ; v1(170.09,64.38) C623.1 169.78,65.18 169.61,65.35 169.61,67.41 169.74,67.53 R906.2
  S16 w0.127: v1(168.26,51.84) 167.25,52.85 167.25,55.3 166.89,55.65 166.89,56.03 167.99,57.12 167.99,60.55 170.15,62.71 170.15,64.32 v1(170.09,64.38)
  BOTTOM w0.127: v1(170.09,64.38) 169.19,65.27 v2(169.19,65.69)
P20_LED1_SFP+_G: length 147.9
  TOP w0.127: v4(207.55,185.58) U9.P18 ; R907.1 v1(169.07,69.18)
  S7 w0.127: v1(169.07,69.18) 169.07,69.46 169.64,70.03 169.64,70.71 170.65,71.73 170.65,72.87 171.52,73.74 175.35,73.74 175.35,79.16 183.87,87.68 183.87,87.79 183.92,87.83 183.96,87.87 183.96,136.6 184.18,136.82 184.18,143.53 184.39,143.74 184.39,144.34 185.16,145.12 186.63,145.12 187.16,145.65 187.16,148.97 187.93,149.73 187.93,151.1 192.14,155.31 197.44,155.31 207.17,165.03 207.17,168.56 209.85,171.24 209.85,184.02 208.29,185.58 v4(207.55,185.58)
  BOTTOM w0.127: v4(207.55,185.58) 210.36,185.58 v2(212.29,183.65)
P20_LED1_SFP+_G_R: length 20.6
  TOP w0.127: LED28.C1 v1(167.56,51.86) ; R907.2 168.71,67.53 168.56,67.38 168.56,65.48 168.85,65.18 C624.1 169.07,64.42 v1(169.06,64.41)
  S16 w0.127: v1(167.56,51.86) 166.77,52.65 166.77,55.1 166.51,55.35 166.51,56.22 167.61,57.31 167.61,60.61 169.06,62.07 v1(169.06,64.41)
  BOTTOM w0.127: v1(169.06,64.41) 169.06,63.23 v2(169.26,63.03)
P20_LED2_SFP+_A: length 135.3
  TOP w0.127: v4(205.55,184.58) U9.R16 ; R1276.1 v1(171.17,75.03)
  S7 w0.127: v4(205.55,184.58) 205.86,184.58 206.31,184.12 208.52,184.12 209.34,183.31 209.34,171.46 206.66,168.78 206.66,165.24 197.23,155.81 191.9,155.81 187.42,151.33 187.42,149.94 183.88,146.4 183.88,143.95 183.67,143.74 183.67,140.29 182.85,139.48 182.85,136.89 183.45,136.29 183.45,88.08 171.17,75.8 v1(171.17,75.03)
  BOTTOM w0.127: v2(171.45,76.7) 171.17,76.42 v1(171.17,75.03)
P20_LED2_SFP+_A_R: length 24
  TOP w0.127: R1276.2 171.49,73.38 171.69,73.17 171.69,71.17 171.55,71.03 C835.1 v1(171.17,70.21) ; LED53.C2 168.36,54.81 v1(168.36,55.85)
  S16 w0.127: v1(171.17,70.21) 171.17,70.13 170.59,69.56 170.59,62.58 168.36,60.36 v1(168.36,55.85)
  BOTTOM w0.127: v2(171.65,73.26) 171.64,73.25 171.64,71.63 171.35,71.35 171.35,70.4 v1(171.17,70.21)
P20_LED2_SFP+_G: length 146.1
  TOP w0.127: R1277.1 v1(172.12,69.18) ; v4(206.55,186.58) U9.N17
  S7 w0.127: v4(206.55,186.58) 207.02,187.04 208.55,187.04 210.87,184.72 210.87,164.21 202.47,155.8 202.47,153.39 201.07,151.99 193.84,151.99 189.87,148.02 189.87,145.81 187.33,143.27 185.78,143.27 185.06,142.54 185.06,87.42 176.37,78.74 176.37,73.31 175.23,72.17 175.23,70.65 173.76,69.18 v1(172.12,69.18)
  BOTTOM w0.127: v1(172.12,69.18) 171.99,69.05 v2(171.99,67.79)
P20_LED2_SFP+_G_R: length 15.7
  TOP w0.127: v1(172.1,64.28) 172.12,64.3 C834.1 171.75,65.18 171.64,65.3 171.64,67.4 171.77,67.53 R1277.2 ; LED53.C1 167.66,54.81 167.66,55.71 v1(167.51,55.87)
  BOTTOM w0.127: v1(167.51,55.87) 168.05,56.41 168.05,59.22 v2(170.02,61.19) 172.1,63.27 v1(172.1,64.28)
P21_LED1_SFP+_A: length 135.2
  TOP w0.127: R908.1 v1(169.13,75.03) ; U9.R15 v4(204.55,184.58)
  S7 w0.127: v1(169.13,75.03) 169.13,75.16 170.1,76.13 170.74,76.13 182.72,88.11 182.72,88.21 182.86,88.35 182.86,88.4 182.89,88.43 182.89,88.49 182.91,88.51 182.91,88.54 182.92,88.55 182.92,135.82 181.25,137.49 181.25,142.86 182.65,144.26 182.65,145.48 183.21,146.03 183.21,146.45 185.96,149.2 185.96,151.08 191.19,156.32 195.94,156.32 206.15,166.53 206.15,168.99 208.83,171.67 208.83,179.18 207.07,180.94 207.07,182.68 206.72,183.03 206.42,183.03 206.01,183.44 206.01,183.82 205.68,184.15 204.98,184.15 v4(204.55,184.58)
  BOTTOM w0.127: v1(169.13,75.03) 169.13,75.03 v2(169.13,75.92)
P21_LED1_SFP+_B_R: length 22.5
  TOP w0.127: v1(169.13,70.21) C627.1 169.01,71.16 168.76,71.16 168.59,71.33 168.59,73.17 168.79,73.38 R908.2 ; v1(171.14,56.66) 171.71,56.09 LED29.C2
  S7 w0.127: v1(169.13,70.21) 168.42,69.49 168.42,63.45 171.14,60.73 v1(171.14,56.66)
  BOTTOM w0.127: v1(169.13,70.21) 168.62,70.72 v2(168.62,71.34)
P21_LED1_SFP+_G: length 134.3
  TOP w0.127: v4(206.55,183.58) U9.T17 ; R909.1 v1(170.15,75.03)
  S7 w0.127: v4(206.55,183.58) 207.13,183 207.8,183 207.8,182.99 209.08,181.71 209.08,171.56 206.4,168.88 206.4,165.35 197.12,156.07 191.44,156.07 186.21,150.84 186.21,149.09 183.53,146.41 183.53,145.9 182.92,145.28 182.92,144.14 181.51,142.74 181.51,140.65 182.55,139.61 182.55,136.6 183.18,135.97 183.18,88.44 183.16,88.43 183.16,88.4 183.14,88.38 183.14,88.33 183.11,88.3 183.11,88.24 183.07,88.2 183.07,88.08 170.15,75.16 v1(170.15,75.03)
  BOTTOM w0.127: v4(206.55,183.58) 207.04,184.06 v2(208.33,184.06)
P21_LED1_SFP+_G_R: length 24.3
  TOP w0.127: v1(170.41,56.65) 171.01,56.05 LED29.C1 ; R909.2 169.81,73.38 169.66,73.23 169.66,71.19 169.83,71.03 C628.1 170.15,70.15 v1(170.15,70.14)
  S7 w0.127: v1(170.15,70.14) 170.15,69.97 169.59,69.42 169.59,63.37 171.86,61.1 171.86,56.61 171.29,56.04 171.02,56.04 v1(170.41,56.65)
  BOTTOM w0.127: v1(170.15,70.14) 170.15,70.15 170.15,71.03 v2(170.53,71.41)
P21_LED2_SFP+_A: length 133.9
  TOP w0.127: v4(206.55,184.58) U9.R17 ; R1278.1 v1(172.18,75.03)
  S7 w0.127: v4(206.55,184.58) 207.01,185.04 208.14,185.04 209.59,183.59 209.59,171.35 206.91,168.67 206.91,165.14 197.33,155.56 192.03,155.56 187.67,151.2 187.67,149.83 184.13,146.3 184.13,143.84 183.92,143.63 183.92,136.94 183.7,136.72 183.7,87.98 183.66,87.94 172.18,76.46 v1(172.18,75.03)
  BOTTOM w0.127: v1(172.18,75.03) 173.22,76.06 v2(173.24,76.06)
P21_LED2_SFP+_A_R: length 26.5
  TOP w0.127: v1(171.49,51.84) 171.71,51.62 LED54.C2 ; R1278.2 172.57,73.38 172.7,73.25 172.7,71.12 172.6,71.03 C837.1 v1(172.18,70.21)
  S16 w0.127: v1(171.49,51.84) 171.49,52.3 172.02,52.83 172.02,62.05 173.64,63.66 173.64,68.76 v1(172.18,70.21)
  BOTTOM w0.127: v2(172.56,71.28) 172.43,71.28 172.18,71.03 v1(172.18,70.21)
P21_LED2_SFP+_G: length 147.7
  TOP w0.127: v4(207.55,186.58) U9.N18 ; R1279.1 v1(171.1,69.18)
  S7 w0.127: v4(207.55,186.58) 208.48,186.58 210.59,184.46 210.59,164.31 202.17,155.89 202.17,153.49 200.95,152.27 193.48,152.27 187.86,146.65 187.86,144.18 187.21,143.53 185.65,143.53 184.78,142.66 184.78,87.65 176.01,78.88 176.01,73.46 174.53,71.98 174.53,70.9 174.15,70.52 173.45,70.52 172.62,69.7 171.61,69.7 v1(171.1,69.18)
  BOTTOM w0.127: v4(207.55,186.58) 210.74,186.58 v2(211.61,185.71)
P21_LED2_SFP+_G_R: length 20.2
  TOP w0.127: v1(171.14,64.21) 171.1,64.24 C836.1 170.77,65.18 170.58,65.38 170.58,67.36 170.75,67.53 R1279.2 ; LED54.C1 171.01,51.61 v1(170.78,51.84)
  S16 w0.127: v1(170.78,51.84) 170.17,52.45 170.17,53.46 171.67,54.96 171.67,62.2 171.14,62.74 v1(171.14,64.21)
  BOTTOM w0.127: v1(171.14,64.21) 171.1,64.25 v2(171.1,65.5)
P22_LED1_SFP+_A: length 135
  TOP w0.127: v4(206.55,187.58) U9.M17 ; R910.1 v1(182.79,75.03)
  S7 w0.127: v1(182.79,75.03) 182.79,83.41 185.62,86.24 185.62,138.8 187.93,141.1 187.93,143.15 190.53,145.75 190.53,147.73 194.22,151.42 201.3,151.42 204.05,154.18 204.05,156.37 211.44,163.76 211.44,185.63 209.06,188.01 207.33,188.01 206.9,187.58 v4(206.55,187.58)
  BOTTOM w0.127: v2(182.4,75.79) 182.79,75.4 v1(182.79,75.03)
P22_LED1_SFP+_B_R: length 21.8
  TOP w0.127: R910.2 183.15,73.38 183.28,73.25 183.28,71.27 183.03,71.03 C629.1 v1(182.79,70.21) ; v1(183.14,55.99) 182.51,55.37 LED30.C2
  S9 w0.127: v1(182.79,70.21) 183.23,69.77 183.23,62.12 182.44,61.33 182.44,56.69 v1(183.14,55.99)
  BOTTOM w0.127: v1(182.79,70.21) 182.79,71.03 v2(183.16,71.41)
P22_LED1_SFP+_G: length 133.6
  TOP w0.127: v4(207.55,187.58) U9.M18 ; R911.1 v1(181.77,75.03)
  S7 w0.127: v1(181.77,75.03) 181.77,83.07 185.36,86.66 185.36,138.95 187.61,141.2 187.61,143.19 190.21,145.79 190.21,147.85 194.04,151.69 201.19,151.69 203.76,154.25 203.76,156.51 211.18,163.93 211.18,185 208.67,187.51 207.62,187.51 v4(207.55,187.58)
  BOTTOM w0.127: v1(181.77,75.03) 181.71,75.08 v2(180.63,75.08)
P22_LED1_SFP+_G_R: length 22.7
  TOP w0.127: v1(182.44,56) 181.81,55.38 LED30.C1 ; R911.2 181.43,73.38 181.23,73.17 181.23,71.33 181.53,71.03 C630.1 v1(181.77,70.21)
  S9 w0.127: v1(182.44,56) 182.01,56.43 182.01,61.55 182.94,62.47 182.94,64.47 181.07,66.34 181.07,69.51 v1(181.77,70.21)
  BOTTOM w0.127: v2(181.26,71.34) 181.26,70.72 v1(181.77,70.21)
P22_LED2_SFP+_A: length 149.9
  TOP w0.127: R1280.1 v1(182.72,69.18) ; v4(202.55,188.58) U9.L13
  S7 w0.127: v1(182.72,69.18) 183.29,69.75 183.29,70.9 184.31,71.92 184.31,73.57 184.62,73.89 185.13,73.89 185.77,74.52 185.77,83.14 186.77,84.14 186.77,138.3 188.46,139.99 189.83,139.99 190.34,140.5 190.34,142.53 191.42,143.61 191.42,144.24 191.99,144.82 191.99,145.52 194.91,148.44 199.85,148.44 205.35,153.94 205.35,155.74 212.52,162.91 212.52,186.08 208.54,190.07 202.31,190.07 202.02,189.77 202.02,189.11 v4(202.55,188.58)
  BOTTOM w0.127: v2(182.02,67.98) 182.02,68.48 v1(182.72,69.18)
P22_LED2_SFP+_A_R: length 19.6
  TOP w0.127: LED55.C2 v1(182.51,51.84) ; v1(182.41,64.02) 182.41,64.05 182.72,64.37 C839.1 182.4,65.18 182.18,65.41 182.18,67.33 182.38,67.53 R1280.2
  S9 w0.152: v1(182.41,64.02) 181.55,63.16 181.55,52.8 v1(182.51,51.84)
  BOTTOM w0.127: v2(182.7,63.07) 182.72,63.09 182.72,63.71 v1(182.41,64.02)
P22_LED2_SFP+_G: length 144.7
  TOP w0.127: U9.K18 206.57,189.6 v4(206.57,189.58) ; R1281.1 v1(181.71,69.18)
  S7 w0.127: v1(181.71,69.18) 182.27,69.75 182.27,70.65 183.29,71.66 183.29,73.44 184.18,74.33 185.13,74.33 185.39,74.58 185.39,83.18 186.46,84.26 186.46,138.4 188.37,140.31 189.77,140.31 190.02,140.56 190.02,142.59 191.04,143.61 191.04,144.24 191.66,144.87 191.66,145.76 194.64,148.74 199.72,148.74 205.02,154.03 205.02,155.9 212.22,163.1 212.22,185.95 208.36,189.81 206.8,189.81 v4(206.57,189.58)
  BOTTOM w0.127: v2(208.7,189.58) 206.57,189.58 v4(206.57,189.58)
P22_LED2_SFP+_G_R: length 19.4
  TOP w0.127: R1281.2 181.37,67.53 181.12,67.28 181.12,65.43 181.36,65.18 C838.1 181.71,64.42 v1(181.65,64.36) ; LED55.C1 v1(181.81,51.83)
  S9 w0.152: v1(181.81,51.83) 181.05,52.6 181.05,63.76 v1(181.65,64.36)
  BOTTOM w0.127: v2(181.51,65.38) 181.65,65.24 v1(181.65,64.36)
P23_LED1_SFP+_A: length 140
  TOP w0.127: U9.L14 v4(203.55,188.58) ; R912.1 v1(183.8,75.03)
  S7 w0.127: v4(203.55,188.58) 204.02,188.11 206.72,188.11 207.1,188.49 207.1,188.77 207.46,189.13 208.19,189.13 208.74,188.58 208.88,188.58 211.71,185.74 211.71,163.61 204.42,156.32 204.42,154.16 201.41,151.15 194.38,151.15 190.84,147.62 190.84,145.7 188.24,143.1 188.24,141.05 185.96,138.77 185.96,85.56 183.8,83.41 v1(183.8,75.03)
  BOTTOM w0.127: v1(183.8,75.03) 183.8,76.42 v2(184.08,76.7)
P23_LED1_SFP+_B_R: length 26.4
  TOP w0.127: R912.2 184.13,73.38 184.27,73.23 184.27,71.14 184.16,71.03 C631.1 v1(183.8,70.21) ; LED31.C2 185.96,55.48 v1(185.31,56.13)
  S9 w0.127: v1(183.8,70.21) 184.56,70.97 184.94,70.97 185.7,70.2 185.7,69.63 186.21,69.12 186.21,64.65 184.88,63.32 184.88,56.56 v1(185.31,56.13)
  BOTTOM w0.127: v1(183.8,70.21) 183.99,70.4 183.99,71.35 184.27,71.63 184.27,73.25 v2(184.28,73.26)
P23_LED1_SFP+_G: length 138.3
  TOP w0.127: U9.K14 v4(203.55,189.58) ; R913.1 v1(184.82,75.03)
  S7 w0.127: v1(184.82,75.03) 184.82,83.41 186.21,84.8 186.21,138.53 188.56,140.88 188.56,141.58 190.77,143.79 190.77,144.38 191.33,144.94 191.33,145.81 194.52,148.99 199.61,148.99 204.7,154.08 204.7,156.09 211.97,163.36 211.97,185.85 208.36,189.46 207.2,189.46 206.8,189.05 204.08,189.05 v4(203.55,189.58)
  BOTTOM w0.127: v1(184.82,75.03) 185.86,76.06 v2(185.88,76.06)
P23_LED1_SFP+_G_R: length 23.7
  TOP w0.127: LED31.C1 185.26,55.44 v1(184.59,56.12) ; v1(184.82,70.21) C632.1 185.32,71.03 185.51,71.22 185.51,73.05 185.18,73.38 R913.2
  S9 w0.127: v1(184.59,56.12) 183.75,56.12 183.04,56.83 183.04,60.95 184.24,62.16 184.24,69.63 184.82,70.21 v1(184.82,70.21)
  BOTTOM w0.127: v1(184.82,70.21) 184.82,71.03 v2(185.51,71.73)
P23_LED2_SFP+_A: length 154.4
  TOP w0.127: R1282.1 v1(184.76,69.18) ; U9.J15 v4(204.55,191.58)
  S7 w0.127: v4(204.55,191.58) 205.53,190.6 209.54,190.6 213.08,187.06 213.08,162.34 205.94,155.2 205.94,153.74 199.94,147.74 195.04,147.74 192.69,145.39 192.69,144.63 192.37,144.31 192.37,143.61 190.85,142.09 190.85,140.23 187.33,136.71 187.33,83.07 186.4,82.14 186.4,74.08 185.7,73.38 185.7,70.13 v1(184.76,69.18)
  BOTTOM w0.127: v2(212.5,188.5) 212.5,189.96 211.93,190.54 205.59,190.54 v4(204.55,191.58)
P23_LED2_SFP+_A_R: length 20.3
  TOP w0.127: v1(184.78,64.46) 184.76,64.48 C841.1 184.37,65.18 184.24,65.31 184.24,67.47 184.3,67.53 R1282.2 ; LED56.C2 185.96,52.02 v1(185.56,52.43)
  S7 w0.152: v1(185.56,52.43) 186.43,53.3 186.43,58.56 184.78,60.21 v1(184.78,64.46)
  BOTTOM w0.127: v1(184.78,64.46) 184.78,63.18 v2(184.75,63.15)
P23_LED2_SFP+_G: length 147
  TOP w0.127: U9.J14 v4(203.55,191.58) ; R1283.1 v1(183.74,69.18)
  S7 w0.127: v4(203.55,191.58) 204.78,190.35 208.62,190.35 212.78,186.19 212.78,162.72 205.68,155.63 205.68,153.91 199.82,148.05 194.97,148.05 192.31,145.39 192.31,144.76 191.89,144.34 191.89,143.68 190.59,142.38 190.59,140.37 189.9,139.68 188.59,139.68 187.02,138.11 187.02,83.65 186.08,82.71 186.08,74.33 185.32,73.57 185.32,71.85 184.31,70.84 184.31,69.75 v1(183.74,69.18)
  BOTTOM w0.127: v2(183.99,67.85) 183.74,68.1 v1(183.74,69.18)
P23_LED2_SFP+_G_R: length 20.3
  TOP w0.127: v1(183.76,64.49) 183.74,64.51 C840.1 183.36,65.18 183.23,65.31 183.23,67.41 183.35,67.53 R1283.2 ; v1(184.9,51.92) 185.26,51.56 LED56.C1
  S7 w0.152: v1(184.9,51.92) 184.9,52.52 185.97,53.59 185.97,58.38 183.76,60.59 v1(183.76,64.49)
  BOTTOM w0.127: v1(183.76,64.49) 183.76,65.54 v2(183.73,65.57)
P24_LED1_SFP+_A: length 142.1
  TOP w0.127: v1(193.2,81) 193.01,80.81 R914.1 ; U9.H15 v4(204.55,192.58)
  S7 w0.127: v1(193.2,81) 191.12,83.07 191.12,130.81 193.07,132.75 193.07,137.32 192.99,137.4 196.05,140.47 196.05,141.85 196.75,142.55 196.75,144.5 197.87,145.62 210.08,145.62 212.82,148.35 212.82,153.39 214.21,154.79 214.21,159.36 215.97,161.11 215.97,186.46 v1(209.46,192.96)
  S9 w0.127: v4(204.55,192.58) 205.06,193.09 209.34,193.09 v1(209.46,192.96)
  BOTTOM w0.127: v2(211.1,193.52) 210.02,193.52 v1(209.46,192.96)
P24_LED1_SFP+_B_R: length 31.7
  TOP w0.127: R914.2 193.54,78.28 193.54,76.11 193.44,76.01 C635.1 193.01,75.34 v1(193.13,75.22) ; v1(196.85,51.95) 196.76,51.86 LED32.C2
  BOTTOM w0.127: v1(196.85,51.95) 197.02,52.12 197.02,67.11 v2(196.72,67.41) 197.29,67.98 197.29,71.33 195.47,73.15 194.33,73.15 193.07,74.41 193.07,75.16 v1(193.13,75.22)
P24_LED1_SFP+_G: length 156.5
  TOP w0.127: U9.H16 v4(205.55,192.58) ; R915.1 195.23,69.89 v1(195.8,70.46)
  S7 w0.127: v4(205.55,192.58) 205.55,191.87 206.31,191.11 209.92,191.11 215.43,185.6 215.43,161.72 213.39,159.67 213.39,156.88 212.66,156.15 211.14,156.15 209.36,154.38 209.36,148.6 206.96,146.2 197.56,146.2 195.93,144.56 195.93,143.07 195.49,142.64 195.49,140.73 194.9,140.15 193,140.15 191.04,138.18 191.04,132.05 190.31,131.33 190.31,81.91 192.56,79.66 195.96,79.66 197.83,77.79 197.83,72.49 v1(195.8,70.46)
  BOTTOM w0.127: v2(194.4,69.89) 195.23,69.89 v1(195.8,70.46)
P24_LED1_SFP+_G_R: length 19
  TOP w0.127: LED32.C1 196.06,51.98 v1(196.07,51.98) ; v1(194.91,63.54) 194.97,63.54 195.23,63.8 C636.1 195.53,65.04 195.75,65.25 195.75,67.32 R915.2
  BOTTOM w0.127: v1(196.07,51.98) 196.68,52.6 196.68,61.89 v2(196.05,62.52) 195.04,63.54 v1(194.91,63.54)
P24_LED2_SFP+_A: length 156.5
  TOP w0.127: U9.H17 v4(206.55,192.58) ; R1285.1 v1(196.29,69.93)
  S7 w0.127: v4(206.55,192.58) 207.08,192.05 209.58,192.05 215.7,185.92 215.7,161.41 213.77,159.48 213.77,154.85 212.39,153.46 212.39,148.46 209.87,145.94 197.75,145.94 196.4,144.59 196.4,142.55 195.8,141.96 195.8,140.63 193.94,138.77 192.78,138.77 191.29,137.28 191.29,131.93 190.69,131.33 190.69,81.98 192.62,80.05 196.12,80.05 198.21,77.95 198.21,71.86 v1(196.29,69.93)
  BOTTOM w0.127: v1(196.29,69.93) 194.6,68.24 v2(194.6,67.99)
P24_LED2_SFP+_A_R: length 16.4
  TOP w0.127: R1285.2 196.76,67.34 196.76,65.12 196.66,65.02 C843.1 196.38,64.93 196.38,64.39 v1(195.75,63.75) 196.38,63.12 196.38,56.88 196.76,56.5 LED57.C2
  BOTTOM w0.127: v1(195.75,63.75) 195.75,64.82 v2(196.37,65.44)
P24_LED2_SFP+_G: length 158.3
  TOP w0.127: v1(195.16,70.77) 194.19,69.8 R1284.1 ; U9.G17 v4(206.55,193.58)
  S7 w0.127: v1(195.16,70.77) 197.55,73.16 197.55,77.67 195.84,79.39 192.46,79.39 190.03,81.81 190.03,131.49 190.78,132.24 190.78,138.33 192.04,139.59 192.04,141.17 193.25,142.38 194.29,142.38 195.67,143.77 195.67,144.88 197.27,146.48 206.86,146.48 209.11,148.72 209.11,154.51 211.11,156.5 212.5,156.5 212.94,156.94 212.94,159.8 215.17,162.03 215.17,185.37 209.69,190.85 205.98,190.85 205.04,191.79 205.04,193.06 205.56,193.58 v4(206.55,193.58)
  BOTTOM w0.127: v2(194.72,71.85) 194.72,71.22 v1(195.16,70.77)
P24_LED2_SFP+_G_R: length 16.2
  TOP w0.127: LED57.C1 196.06,61.62 194.21,63.47 194.21,63.85 v1(194.66,64.3) 194.19,64.76 C842.1 194.57,65.04 194.72,65.19 194.72,67.3 R1284.2
  BOTTOM w0.127: v1(194.66,64.3) 194.66,65.25 v2(194.4,65.5)
P_STACKING_SYNC_N0: length 10.1
  BOTTOM w0.095: RB1237.1 226.63,33.72 226.48,33.87 226.48,34.96 226.69,35.17 LB97.2 227.09,35.72 226.82,36 CB1104.2 226.44,36.79 226.44,39.18 225.44,40.19 224.08,40.19 223.99,40.28 U88.7
P_STACKING_SYNC_N1: length 9.5
  TOP w0.095: U87.7 223.99,39.85 224.08,39.94 225.34,39.94 226.2,39.08 226.2,36.94 225.82,36.56 CB1106.2 226.34,35.9 226.34,35.28 226.23,35.17 LB99.2 225.54,35.17 RB1239.1
P_STACKING_SYNC_N2: length 4.7
  BOTTOM w0.095: RB1248.1 214.58,12.86 LB101.2 213,12.99 CB1109.2 211.66,12.79 U86.7
P_STACKING_SYNC_N3: length 4.6
  BOTTOM w0.095: RB1250.1 214.59,21.25 LB103.2 212.92,21.46 CB1111.2 211.78,21.39 U85.7
P_STACKING_SYNC_P0: length 10
  BOTTOM w0.095: RB1236.1 226.15,33.72 226.26,33.83 226.26,35.05 226.13,35.17 LB96.2 225.54,35.68 225.82,35.96 CB1103.1 226.21,36.81 226.21,39.09 225.34,39.96 224.08,39.96 223.99,39.86 U88.6
P_STACKING_SYNC_P1: length 9.5
  TOP w0.095: U87.6 223.99,40.7 223.99,40.26 224.09,40.17 225.44,40.17 226.43,39.17 226.43,36.89 226.82,36.5 CB1105.2 226.57,36.17 226.57,35.28 226.67,35.17 LB98.2 227.09,35.17 RB1238.1
P_STACKING_SYNC_P2: length 4.7
  BOTTOM w0.095: U86.6 211.77,14.06 CB1108.1 212.78,13.96 LB100.2 214.61,14.31 RB1247.1
P_STACKING_SYNC_P3: length 4.7
  BOTTOM w0.095: RB1249.1 214.59,22.69 LB102.2 212.9,22.46 CB1110.2 211.65,22.66 U85.6
PCA9548_A0_CPU0: length 9.1
  TOP w0.127: U10.1 160.15,228.23 160.37,228.45 160.37,232 160.66,232.29 R169.2 v1(160.84,233.14) R168.1
  BOTTOM w0.127: v1(160.84,233.14) 161.67,232.32 v2(162.08,232.32)
PCA9548_A0_CPU1: length 14
  BOTTOM w0.127: RB742.2 160.72,7.9 161.18,7.44 162.98,7.44 163.23,7.69 RB745.1 163.27,7.92 v2(164.29,7.92) 165.92,7.92 168.21,10.21 171.46,10.21 171.62,10.06 UB17.1
PCA9548_A1_CPU0: length 9.1
  TOP w0.127: U10.2 159.5,229.82 159.35,229.97 159.35,232.13 159.52,232.29 R185.2 v1(159.83,233.14) R184.1
  BOTTOM w0.127: v1(159.83,233.14) 160.11,233.43 v2(160.11,234.54)
PCA9548_A1_CPU1: length 13.9
  BOTTOM w0.127: RB743.2 160.69,8.64 160.8,8.53 163.01,8.53 163.21,8.73 RB746.1 165.92,9.09 v2(166.15,9.33) 167.47,10.64 171.61,10.64 171.67,10.71 UB17.2
PCA9548_A2_CPU0: length 9.6
  TOP w0.127: R189.1 159.34,214.8 159.22,214.92 159.22,217.14 159.42,217.34 R190.2 159.73,218.15 v1(158.65,219.23) 158.2,219.68 U10.21
  BOTTOM w0.127: v2(158.81,221.11) 158.65,220.95 v1(158.65,219.23)
PCA9548_A2_CPU1: length 13.2
  BOTTOM w0.127: UB17.21 182.24,12.01 v2(182.78,12.55) 182.83,12.49 RB708.1 188.72,12.11 188.92,11.91 190.67,11.91 191,12.24 RB714.2
PCB_VER_1: length 12.7
  TOP w0.127: RB34.1 110.23,235.26 v1(109.95,234.99) ; P1.M19 v4(106.29,228.46)
  S9 w0.127: v4(106.29,228.46) 106.29,231.62 107.91,233.24 107.95,233.24 108.3,233.59 108.3,233.63 108.61,233.94 108.61,234.34 109.26,234.99 v1(109.95,234.99)
  BOTTOM w0.127: v2(108.11,236.38) 108.62,235.86 RB35.1 109.25,235.68 v1(109.95,234.99)
PCB_VER_2: length 13.6
  TOP w0.127: RB32.1 RB33.1 113.22,235.23 v1(113.17,235.18) ; P1.N19 v4(107.29,228.46)
  S9 w0.127: v4(107.29,228.46) 107.32,228.46 107.76,228.9 107.76,229.21 109.23,230.68 110.31,230.68 110.58,230.95 110.58,232.04 113.17,234.63 v1(113.17,235.18)
  BOTTOM w0.127: v2(112.68,236.26) 113.17,235.76 v1(113.17,235.18)
PCB_VER_3: length 15.5
  TOP w0.127: P1.R16 v4(109.29,225.46) ; RB31.1 RB30.1 120.39,224.35 v1(119.79,223.75)
  BOTTOM w0.127: v1(119.79,223.75) 119.09,223.05 117,223.05 v2(116.93,222.98) 116.91,222.96 112.18,222.96 111.73,223.42 111.73,223.75 111.53,223.94 110.01,223.94 109.69,224.25 109.69,225.05 v4(109.29,225.46)
PCIE_PVDD10: length 25.1
  TOP w0.381: U40.W37 v4(20.7,116.65)
  S14 w0.508: v1(10.06,110.08) 10.54,109.6 11.88,109.6 13.96,111.68 18.02,111.68 19.17,112.82 19.17,115.12 v4(20.7,116.65)
  BOTTOM w0.305: v1(10.06,110.08) 10.06,108.49 v2(5.11,103.54)
  BOTTOM w0.381: CB557.1 21.15,116.19 v4(20.7,116.65)
PCIE_TRDD10: length 7.8
  TOP w0.381: U40.U37 v4(20.7,113.65) ; U40.U36 v4(21.7,113.65) ; v4(22.7,114.65) U40.V35 ; v4(23.7,114.65) U40.V34
  BOTTOM w0.381: v4(20.7,113.65) 20.72,113.65 CB603.1 21.7,113.66 v4(21.7,113.65) 21.76,113.65 CB604.1 22.7,114.59 v4(22.7,114.65) 22.76,114.65 CB598.1 23.24,114.19 v4(23.7,114.65) 23.72,114.67 CB574.1
  vias: v1(11.22,102.16) v1(11.22,101.47) v1(11.93,102.18) v1(11.9,101.5) v2(18,103.67)
PEX_CPU_PCIEA_RX_0_C_N: length 8.5
  TOP w0.127: U40.T36 21.62,112.57 21.02,112.57 20.12,111.66 arc(20,111.48) 19.95,111.26 19.95,110.61 arc(19.84,110.06) 19.53,109.59 18.01,108.07 17.96,108.01 arc(17.73,107.86) 17.47,107.81 17.2,107.81 C415.2
PEX_CPU_PCIEA_RX_0_C_P: length 7.4
  TOP w0.127: U40.T37 21.18,113.15 19.9,111.88 arc(19.71,111.59) 19.65,111.26 19.65,110.61 arc(19.56,110.17) 19.31,109.8 17.79,108.28 17.74,108.23 arc(17.62,108.15) 17.47,108.12 17.12,108.12 C413.2
PEX_CPU_PCIEA_RX_0_N: length 259.2
  TOP w0.127: J2.B69 177.94,145.88 177.85,145.97 177.85,148.09 178.01,148.26 178.22,148.26 v3(178.49,147.99) ; C415.1 15.53,107.77 15.11,107.77 v3(14.85,107.52)
  S9 w0.14: v3(178.49,147.99) 178.24,148.24 177.92,148.24 169.82,156.35 169.82,160.29 168.75,161.36 161.25,161.36 159.12,159.23 135.61,159.23 129.36,152.98 116.36,152.98 104.26,165.08 104.26,169.75 99.05,174.96 54.38,174.96 53.48,174.06 47.87,174.06 46.91,175.02 20.65,175.02 17.82,172.19 17.82,165.84 17.32,165.35 17.32,158.04 17.23,157.95 17.23,157.11 19.99,154.35 19.99,136.06 16.56,132.63 16.56,114.05 15.89,113.38 15.89,108.23 15.44,107.77 15.1,107.77 v3(14.85,107.52)
PEX_CPU_PCIEA_RX_0_P: length 260.4
  TOP w0.127: v3(14.85,108.33) 15.1,108.08 15.54,108.08 C413.1 ; J2.B68 177.44,145.82 177.54,145.92 177.54,148.22 177.89,148.56 178.25,148.56 v3(178.49,148.8)
  S9 w0.14: v3(14.85,108.33) 15.1,108.07 15.31,108.07 15.59,108.35 15.59,110.33 arc(15.54,110.44) 15.43,110.48 arc(15.33,110.53) 15.28,110.64 15.28,111.03 arc(15.33,111.14) 15.43,111.18 arc(15.54,111.23) 15.59,111.34 15.59,111.73 arc(15.54,111.83) 15.43,111.88 arc(15.33,111.92) 15.28,112.03 15.28,112.42 arc(15.33,112.53) 15.43,112.58 arc(15.54,112.62) 15.59,112.73 15.59,113.51 16.26,114.18 16.26,132.76 19.69,136.19 19.69,154.22 16.93,156.98 16.93,158.08 17.02,158.17 17.02,165.47 17.52,165.97 17.52,172.31 20.53,175.32 47.04,175.32 48,174.37 53.36,174.37 54.25,175.26 99.18,175.26 104.57,169.87 104.57,165.21 116.49,153.28 129.23,153.28 135.49,159.54 159,159.54 161.13,161.67 168.88,161.67 170.12,160.42 170.12,156.47 178.05,148.55 178.24,148.55 v3(178.49,148.8)
PHY_COL: length 7.1
  TOP w0.127: U52.B6 v3(231.18,128.65)
  BOTTOM w0.127: v2(233.8,131.09) 233.69,131.19 R1070.1 230.55,131.19 230.17,130.81 230.17,129.67 v3(231.18,128.65)
PHY_RST_N: length 225.5
  TOP w0.127: R1047.2 v1(222.02,121.03) 222.95,121.03 224.32,119.66 227.19,119.66 U52.K3 ; R1048.2 v1(116.25,237.7)
  S14 w0.127: v1(220.18,138.08) 220.12,138.15 219.23,138.15 211.8,145.58 211.8,148.34 210.96,149.18 210.53,149.18 209.35,150.36 209.35,151.27 208.31,152.31 208.31,169.27 212.09,173.05 212.09,202.97 207.95,207.11 177.04,207.11 172.47,202.54 169.65,202.54 168.33,203.86 168.33,207.8 164.25,211.87 158.65,211.87 157.98,212.54 157.98,215.87 156.73,217.12 156.73,218.33 156.87,218.48 156.87,219.49 152.03,224.33 148.95,224.33 146.2,227.08 146.2,234.03 143.08,237.14 122.77,237.14 120.49,239.43 117.99,239.43 v1(116.25,237.7)
  S16 w0.127: v1(220.18,138.08) 220.18,134.78 223.04,131.93 223.04,121.96 222.12,121.03 v1(222.02,121.03)
  BOTTOM w0.127: v1(222.02,121.03) 222.62,121.03 v2(222.91,121.32)
PHY_RST_N_R: length 13.1
  TOP w0.127: P1.R21 109.34,230.51 109.34,231.33 109.4,231.39 109.4,232.33 110.33,233.27 113.5,233.27 114.43,234.19 115.19,234.19 116.04,235.04 v1(116.25,235.04) 116.25,235.23 116.25,235.23 R1048.1
  BOTTOM w0.127: v1(116.25,235.04) 116.22,235.07 116.22,236.24 v2(116.55,236.57)
PHY_TCK: length 152.7
  TOP w0.127: U52.L9 v3(234.18,118.65) ; v1(224.56,236.7) 224.44,236.83 R423.1
  S12 w0.127: v3(234.18,118.65) 234.26,118.73 236.58,118.73 237.89,120.04 240.69,120.04 240.76,120.11 241.39,120.11 242.15,120.88 242.15,122.38 240.76,123.78 240.76,125.96 238.22,128.5 238.22,135.75 236.02,137.94 235.87,138.1 235.87,140.57 235.53,140.9 235.53,140.9 230.25,146.18 230.25,169.2 245.01,183.96 245.01,217.7 243.91,218.81 243.91,222.38 241.2,225.08 241.2,229.91 235.04,236.07 225.2,236.07 v1(224.56,236.7)
  BOTTOM w0.127: v2(225.33,236) 224.63,236.7 v1(224.56,236.7)
PHY_TCK_R: length 4.6
  TOP w0.127: R423.2 222.16,236.83 221.9,237.09 v1(221.9,237.14) 221.19,237.14 220.91,237.42 U20.12
  BOTTOM w0.127: v2(220.63,236.51) 221.26,237.14 v1(221.9,237.14)
PHY_TDI: length 130.6
  TOP w0.127: v1(186.26,179.62) 185.91,179.96 R327.1 ; U52.L7 v3(232.18,118.65)
  S12 w0.127: v1(205.26,178.79) 188.34,178.79 187.25,177.69 185.93,177.69 185.66,177.96 185.66,179.42 185.86,179.62 v1(186.26,179.62) ; v3(232.18,118.65) 232.19,118.65 232.69,118.15 233.4,118.15 233.92,117.63 235.51,117.63 236.28,116.86 242.96,116.86 244.81,118.7 244.81,128.39 v1(241.9,131.29)
  S14 w0.127: v1(205.26,178.79) 205.26,150.35 206.06,149.55 206.06,148.15 205.82,147.9 205.82,147.38 216.61,136.59 222.87,136.59 223.94,135.52 227.05,135.52 228.41,136.88 239.04,136.88 241.94,133.98 241.94,131.33 v1(241.9,131.29)
  BOTTOM w0.127: v1(186.26,179.62) v2(185.13,179.62)
PHY_TDI_R: length 7.7
  TOP w0.127: R327.2 184.76,180.87 184.35,180.47 184.35,180.2 183.58,179.42 v1(182.95,179.42) 182.77,179.42 182.53,179.18 U19.1
  BOTTOM w0.127: v1(182.95,179.42) 180.5,179.42 v2(179.62,178.54)
PHY_TDO: length 339.1
  TOP w0.127: R846.1 v1(239.93,117.56) ; U40.AH33 v4(24.7,125.65)
  S7 w0.127: v4(24.7,125.65) 24.27,126.07 24.27,128.88 23.97,129.18 22.27,129.18 20.79,130.66 19.69,130.66 16.3,134.05 16.3,138.98 17.96,140.64 17.96,148.09 16.98,149.07 16.98,154.77 15.78,155.98 15.78,157.02 15.3,157.5 15.3,159.65 15.78,160.13 15.78,161.89 16.79,162.9 16.79,164.69 16.98,164.88 16.98,166.42 17.11,166.55 17.11,168.32 17.92,169.13 17.92,170.68 21.53,174.29 33.95,174.29 35.59,175.93 46.26,175.93 47.91,177.58 51.9,177.58 54.5,174.98 85.75,174.98 86.13,174.6 100.92,174.6 101.38,175.06 103.93,175.06 104.4,174.6 114.58,174.6 117.38,171.8 120.06,171.8 123.14,168.72 127.8,168.72 131.83,164.69 v1(133.51,164.69)
  S9 w0.127: v1(231.36,167.23) 211.23,167.23 210.58,167.88 169.09,167.88 165.98,164.77 160.51,164.77 156.87,161.13 137.07,161.13 v1(133.51,164.69)
  S12 w0.127: v1(231.36,167.23) 231.27,167.14 231.27,146.75 237.14,140.88 237.14,138.95 237.44,138.64 238.48,138.64 239.36,137.77 239.36,131.48 241.14,129.7 241.14,127.06 242.03,126.17 242.03,123.95 243.17,122.8 243.17,120.45 241.81,119.1 241.39,119.1 241.18,119.1 239.93,117.85 v1(239.93,117.56)
  BOTTOM w0.127: v2(133.7,163.61) 133.7,164.5 v1(133.51,164.69)
PHY_TDO_R: length 7.9
  TOP w0.127: U52.K8 233.11,119.72 233.94,119.72 236.1,117.56 236.9,117.56 v1(236.91,117.57) 236.91,117.56 R846.2
  BOTTOM w0.127: v2(238.07,117.63) 238.02,117.57 v1(236.91,117.57)
PHY_TMS: length 177.6
  TOP w0.127: U52.L8 v3(233.18,118.65) ; R380.1 208.25,241.34 v1(208.44,241.53)
  S12 w0.127: v1(208.44,241.53) 209.39,242.48 213.07,242.48 219.17,236.38 222.34,236.38 223.49,237.53 224.69,237.53 225.64,236.57 235.25,236.57 242.02,229.8 242.02,225.67 244.4,223.3 244.4,222.61 244.41,222.59 244.41,219.02 245.52,217.92 245.52,183.57 230.76,168.82 230.76,146.53 236.53,140.76 236.53,138.15 238.73,135.96 238.73,129.89 240.63,127.99 240.63,126.85 241.52,125.96 241.52,123.74 242.66,122.59 242.66,120.67 241.6,119.61 240.97,119.61 240.47,119.1 237.76,119.1 236.84,118.18 233.92,118.18 233.46,118.65 v3(233.18,118.65)
  BOTTOM w0.127: v2(236.3,118.62) 235.23,118.62 234.7,119.15 233.68,119.15 v3(233.18,118.65)
PHY_TMS_R: length 4.4
  TOP w0.127: U20.3 210.71,241.38 v1(210.44,241.11) 210.07,240.75 R380.2
  BOTTOM w0.127: v2(209.45,240.95) 209.61,241.11 v1(210.44,241.11)
PHY_TRST_N: length 8.2
  TOP w0.127: U52.M9 235.67,116.17 v1(236.63,116.17) R953.2 RB287.2
  BOTTOM w0.305: v1(236.63,116.17) 237.65,116.17 v2(238.15,115.67)
PM_VDDQ_EN_R: length 6.6
  TOP w0.254: R64.1 R66.1 C47.1 67.64,190.83 67.59,190.78 R70.1 67.79,190.1 v1(67.79,189.56) 67.72,189.56 67,188.85 U6.7
  BOTTOM w0.127: v1(67.79,189.56) 67.66,189.7 v2(67.66,190.6)
POWER_RST: length 143.8
  TOP w0.127: v1(212.66,219.9) 218.5,219.9 219.57,220.98 222.96,220.98 223.12,221.14 R65.2 223.63,221.54 224.93,220.24 U7.23 ; R84.2 v1(106.16,237.66)
  S9 w0.127: v1(191.35,239.75) 191.17,239.57 190.01,239.57 188.28,241.29 182.61,241.29 180.28,238.96 174.67,238.96 172.85,237.15 172.33,237.15 167.49,232.31 151.92,232.31 151.37,232.86 149.27,232.86 146.08,236.04 144.28,236.04 143.06,237.26 143.03,237.26 143,237.29 120.85,237.29 119,239.14 107.69,239.14 106.21,237.66 v1(106.16,237.66)
  S12 w0.127: v1(191.35,239.75) 192.78,238.32 195.39,238.32 197.72,235.98 203.93,235.98 209.9,230.02 209.9,222.67 v1(212.66,219.9)
  BOTTOM w0.127: v2(191.96,240.34) 191.95,240.34 v1(191.35,239.75)
POWER_RST_S: length 13.1
  TOP w0.127: v1(106.09,234.99) 106.16,235.06 R84.1 ; P1.L16 v4(105.29,225.46)
  S9 w0.127: v1(106.09,234.99) 105.99,234.99 105.99,234.9 105.22,234.13 105.22,231.29 104.74,230.81 104.74,226.39 105.29,225.84 v4(105.29,225.46)
  BOTTOM w0.127: v1(106.09,234.99) 105.69,235.39 v2(105.69,235.84)
PS1_12V_PG: length 114
  TOP w0.127: P1.C8 v4(96.29,216.46) ; CONN5.11 v1(14.38,234.35)
  S9 w0.127: v4(96.29,216.46) 95.9,216.46 94.42,217.94 93.74,217.94 91.53,220.16 90.54,220.16 89.51,221.18 89.51,222.84 88.2,224.16 88.18,224.16 88.17,224.17 86.31,224.17 85.36,225.11 85.36,226.75 83.75,228.37 82.59,228.37 80.86,230.1 80.86,237.84 74.64,244.07 16.32,244.07 13.53,241.27 13.53,235.2 v1(14.38,234.35)
  BOTTOM w0.127: v1(14.38,234.35) 13.49,234.35 v2(13.36,234.22)
PS1_AC_ALERT: length 118.6
  TOP w0.127: v1(90.26,207.11) 90.33,207.17 94.96,207.17 96.79,209 P1.C1 ; CONN5.15 18.19,236.89 v1(18.19,236.89)
  S9 w0.127: v1(18.19,236.89) 22.7,241.4 72.8,241.4 77.94,236.26 77.94,224.76 78.58,224.13 78.58,219.34 80.75,217.16 80.75,213.43 82.7,211.48 87.91,211.48 88.16,211.73 88.75,211.73 90.26,210.22 v1(90.26,207.11)
  BOTTOM w0.127: v1(18.19,236.89) 18.44,236.64 v2(18.44,235.49)
PS1_ON: length 117.7
  TOP w0.127: P1.D8 v4(97.29,216.46) ; CONN5.9 v1(14.38,233.08)
  S9 w0.127: v1(14.38,233.08) 12.78,234.68 12.78,241.78 15.44,244.45 74.96,244.45 81.44,237.97 81.44,232.83 82.46,231.8 82.46,230.61 85.49,227.58 88.42,227.58 88.7,227.3 88.7,226.64 90.1,225.24 90.1,221.23 90.91,220.41 91.66,220.41 93.78,218.29 94.64,218.29 95.69,217.23 96.07,217.23 96.84,216.46 v4(97.29,216.46)
  BOTTOM w0.127: v1(14.38,233.08) 15.27,233.08 v2(15.27,233.08)
PS1_PRESENT: length 114.9
  TOP w0.127: P1.E8 v4(98.29,216.46) ; CONN5.13 v1(14.38,235.62)
  S9 w0.127: v1(14.38,235.62) 15.16,236.4 15.16,241.8 17.11,243.75 74.26,243.75 80.42,237.59 80.42,227.67 83.47,224.62 84.36,224.62 86.53,222.45 87.22,222.45 87.38,222.61 88.7,222.61 89.09,222.21 89.09,220.32 91.09,218.31 92.84,218.31 93.73,217.42 93.73,216.8 94.66,215.87 97.76,215.87 98.29,216.4 v4(98.29,216.46)
  BOTTOM w0.127: v2(15.78,235.56) 14.44,235.56 v1(14.38,235.62)
PS2_12V_PG: length 120.1
  TOP w0.127: P1.D5 v4(97.29,213.46) ; CONN5.12 v1(9.3,234.35)
  S7 w0.127: v1(18.06,239.3) 18.06,238.61 15.87,236.41 11.37,236.41 v1(9.3,234.35)
  S9 w0.127: v1(18.06,239.3) 21.36,242.61 73.31,242.61 79.21,236.7 79.21,225.21 79.93,224.49 79.93,223.44 80.86,222.51 80.86,221.68 82.58,219.97 84.18,219.97 84.75,220.54 86.6,220.54 89.62,217.53 89.62,215.25 90.57,214.29 91.6,214.29 92.98,212.91 96.65,212.91 97.2,213.46 v4(97.29,213.46)
  BOTTOM w0.127: v1(18.06,239.3) 19.78,239.3 v2(20.03,239.56) ; v2(10.57,234.29) 9.36,234.29 v1(9.3,234.35)
PS2_AC_ALERT: length 116.2
  TOP w0.127: P1.C4 v4(96.29,212.46) ; CONN5.16 v1(9.3,236.89)
  S7 w0.127: v1(16.6,238.67) 15.4,237.46 9.87,237.46 v1(9.3,236.89)
  S9 w0.127: v4(96.29,212.46) 92.36,212.46 91.78,213.03 90.76,213.03 87.68,216.11 87.68,217.6 85.77,219.51 81.9,219.51 79.53,221.88 79.53,224.38 78.83,225.08 78.83,236.51 73.12,242.22 21.68,242.22 18.13,238.67 v1(16.6,238.67)
  BOTTOM w0.127: v1(16.6,238.67) 15.59,237.65 v2(15.59,237.59) ; v1(9.3,236.89) 9.43,237.02 v2(10.63,237.02)
PS2_ON: length 122.3
  TOP w0.127: P1.E5 v4(98.29,213.46) ; CONN5.10 v1(9.3,233.08)
  S7 w0.127: v1(9.3,233.08) 11.14,234.92 15.4,234.92 v1(18.13,237.65)
  S9 w0.127: v4(98.29,213.46) 98.29,213.36 97.88,212.95 97.88,212.32 97.5,211.94 93.18,211.94 91.91,210.67 90.64,210.67 89.77,211.54 89.77,213.37 87.37,215.77 87.37,216.83 85.14,219.06 81.58,219.06 79.02,221.61 79.02,224.25 78.39,224.89 78.39,236.32 72.86,241.84 22.32,241.84 v1(18.13,237.65)
  BOTTOM w0.127: v1(18.13,237.65) 19.02,237.65 v2(19.08,237.72) ; v1(9.3,233.08) 9.25,233.12 v2(7.88,233.12)
PS2_PRESENT: length 118.3
  TOP w0.127: P1.E6 v4(98.29,214.46) ; CONN5.14 v1(9.3,235.62)
  S7 w0.127: v1(17.3,239.3) 17.3,238.54 15.71,236.95 10.63,236.95 v1(9.3,235.62)
  S9 w0.127: v1(17.3,239.3) 20.98,242.99 73.69,242.99 79.66,237.02 79.66,225.32 82.45,222.53 84.1,222.53 85.6,221.03 86.96,221.03 90.02,217.97 90.02,215.72 90.69,215.04 93.6,215.04 94.7,213.94 97.77,213.94 v4(98.29,214.46)
  BOTTOM w0.127: v1(17.3,239.3) 17.3,240.26 v2(17.68,240.64) ; v2(8.28,235.75) 9.17,235.75 v1(9.3,235.62)
