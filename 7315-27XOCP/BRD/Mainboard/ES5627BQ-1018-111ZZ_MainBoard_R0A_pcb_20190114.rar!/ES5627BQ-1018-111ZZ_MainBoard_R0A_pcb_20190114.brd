# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NIFE_TX[32]_N: length 139.6
  TOP w0.095: U40.A8 v4(50.7,97.65)
  S9 w0.102: 50.29,97.3 50.29,97.86 arc(50.35,98.01) 50.49,98.07 50.52,98.07 arc(50.65,98.02) 50.7,97.9 v4(50.7,97.65)
  S9 w0.108: 50.29,97.3 49.49,96.5 arc(49.3,96.21) 49.23,95.87 49.23,94.32 arc(49.68,92.05) 50.96,90.13 60.16,80.94 arc(61.35,80.14) 62.77,79.86 82.16,79.86 arc(83.66,79.56) 84.93,78.71 85.64,78.01 arc(86.01,77.76) 86.45,77.67 123.54,77.67 arc(125.03,77.37) 126.3,76.53 129.95,72.88 arc(130.32,72.63) 130.75,72.54 136.85,72.54 arc(137.32,72.45) 137.71,72.19 138.16,71.74 arc(138.52,71.5) 138.95,71.41 142.21,71.41 arc(142.97,71.1) 143.29,70.33 143.29,58.21 arc(143.36,57.87) 143.55,57.58 143.64,57.48 arc(143.85,57.18) 143.92,56.82 143.92,51.44 arc(144.27,50.61) 145.1,50.26 150.79,50.26 arc(151.22,50.08) 151.4,49.65 151.4,49.21 arc(151.37,49.06) 151.28,48.93 151.23,48.88 arc(151.19,48.83) 151.16,48.78 arc(151.11,48.67) 151.1,48.55 151.1,47.94 CONN55_PF.3L19
NIFE_TX[32]_P: length 139.6
  TOP w0.095: U40.B8 v4(50.7,98.65)
  S9 w0.102: 50.08,97.41 50.08,97.42 50.08,97.86 arc(50.2,98.15) 50.49,98.27 50.59,98.27 arc(50.59,98.27) 50.6,98.27 arc(50.67,98.31) 50.7,98.38 v4(50.7,98.65)
  S9 w0.108: CONN55_PF.3L18 150.29,49.27 arc(150.62,49.05) 151.01,48.98 151.08,49.05 151.12,49.09 arc(151.16,49.15) 151.17,49.21 151.17,49.65 arc(151.06,49.92) 150.79,50.04 145.1,50.04 arc(144.1,50.45) 143.69,51.44 143.69,56.82 arc(143.64,57.09) 143.48,57.32 143.39,57.41 arc(143.14,57.78) 143.06,58.21 143.06,70.33 arc(142.81,70.94) 142.21,71.19 138.95,71.19 arc(138.43,71.29) 138,71.58 137.55,72.03 arc(137.23,72.24) 136.85,72.32 130.75,72.32 arc(130.23,72.42) 129.78,72.72 126.14,76.36 arc(124.94,77.16) 123.54,77.44 86.45,77.44 arc(85.92,77.55) 85.48,77.84 84.77,78.55 arc(83.57,79.35) 82.16,79.63 62.77,79.63 arc(61.27,79.93) 60,80.78 50.8,89.97 arc(49.47,91.97) 49,94.32 49,95.87 arc(49.09,96.3) 49.33,96.66 50.08,97.41
NIFE_TX[33]_N: length 132.3
  TOP w0.095: U40.D7 v4(51.7,100.65)
  S9 w0.102: v4(51.7,100.65) 51.7,100.37 51.62,100.3 51.44,100.3 arc(51.19,100.19) 51.08,99.94 51.08,98.96 51.11,98.93 51.11,97.51 51.11,97.51 51.11,97.46 51.08,97.44 51.08,97.43
  S9 w0.108: 51.08,97.43 51.08,96.99 51,96.9 51,95.63 51.08,95.55 51.08,93.37 arc(51.38,91.89) 52.22,90.63 60.97,81.88 arc(60.98,81.87) 60.99,81.86 arc(62.21,81.06) 63.65,80.77 83.58,80.77 arc(84.57,80.58) 85.41,80.02 86.48,78.95 arc(86.92,78.65) 87.45,78.55 124.34,78.55 arc(125.8,78.26) 127.04,77.43 129.03,75.43 arc(129.48,75.13) 130,75.03 136.68,75.03 arc(137.31,74.9) 137.85,74.55 138.13,74.26 arc(138.55,73.99) 139.03,73.89 146.52,73.89 arc(146.87,73.82) 147.17,73.62 147.54,73.25 147.61,73.18 arc(148.04,72.89) 148.55,72.79 148.81,72.79 arc(149.39,72.55) 149.63,71.97 149.63,65.23 arc(149.53,64.73) 149.25,64.3 147.28,62.33 arc(146.87,61.72) 146.73,60.99 146.73,58.96 146.73,58.96 146.72,58.83 arc(146.61,58.45) 146.38,58.14 146.33,58.08 146.21,57.97 arc(146.07,57.87) 145.89,57.83 arc(145.78,57.86) 145.68,57.92 145.58,58.02 arc(145.49,58.15) CONN55_PF.3T19
NIFE_TX[33]_P: length 132.4
  TOP w0.095: U40.C7 v4(51.7,99.65)
  S9 w0.102: 51.31,97.43 51.31,99.02 51.29,99.04 51.29,99.94 arc(51.33,100.05) 51.44,100.09 51.62,100.09 51.7,100.02 v4(51.7,99.65)
  S9 w0.108: CONN55_PF.3T18 146.26,57.55 arc(146.27,57.62) 146.29,57.68 arc(146.3,57.7) 146.31,57.73 arc(146.32,57.74) 146.32,57.74 arc(146.34,57.77) 146.36,57.79 146.55,57.98 arc(146.82,58.35) 146.95,58.8 146.96,58.81 146.96,60.99 arc(147.08,61.63) 147.44,62.17 149.41,64.14 arc(149.75,64.64) 149.86,65.23 149.86,71.97 arc(149.55,72.71) 148.81,73.02 148.56,73.02 arc(148.13,73.1) 147.77,73.35 147.7,73.41 147.26,73.86 147.33,73.78 arc(146.96,74.03) 146.52,74.12 139.03,74.12 arc(138.63,74.2) 138.3,74.42 138.01,74.71 arc(137.4,75.11) 136.68,75.26 130,75.26 arc(129.57,75.34) 129.2,75.59 127.2,77.59 arc(125.89,78.47) 124.34,78.78 87.45,78.78 arc(87.01,78.86) 86.64,79.11 85.57,80.18 arc(84.66,80.79) 83.58,81 63.65,81 arc(62.3,81.27) 61.15,82.02 52.38,90.8 arc(51.59,91.98) 51.31,93.37 51.31,95.64 51.23,95.73 51.23,96.81 51.31,96.89 51.31,97.43
NIFE_TX[34]_N: length 147.9
  TOP w0.095: U40.A6 v4(52.7,97.65)
  S9 w0.102: 52.29,97.25 52.29,97.26 52.29,97.85 arc(52.35,97.99) 52.49,98.05 52.64,98.05 52.7,97.99 v4(52.7,97.65)
  S9 w0.108: CONN55_PF.4L19 165.31,48.73 arc(165.32,48.78) 165.33,48.82 arc(165.33,48.82) 165.33,48.83 arc(165.36,48.89) 165.4,48.95 arc(165.56,49.19) 165.62,49.47 165.62,49.61 arc(165.44,50.04) 165,50.22 159.06,50.22 arc(158.45,50.48) 158.2,51.08 158.2,57.16 arc(158.1,57.65) 157.82,58.08 157.38,58.52 arc(157.27,58.68) 157.23,58.88 157.23,58.92 arc(157.1,59.58) 156.73,60.13 152.56,64.3 arc(152.37,64.59) 152.3,64.92 152.3,72.34 arc(152.16,73.07) 151.74,73.69 149.93,75.5 arc(148.91,76.18) 147.69,76.43 132.07,76.43 arc(131.63,76.51) 131.26,76.76 130.31,77.71 arc(127.8,79.39) 124.83,79.98 87.89,79.98 arc(87.46,80.07) 87.08,80.32 76.42,90.99 arc(75.85,91.37) 75.18,91.5 55.09,91.5 arc(54.21,91.67) 53.47,92.17 53.02,92.62 arc(52.78,92.99) 52.69,93.42 52.69,96.27 arc(52.62,96.61) 52.43,96.9 arc(52.32,97.06) 52.29,97.24 52.29,97.25
NIFE_TX[34]_P: length 147.9
  TOP w0.095: U40.B6 v4(52.7,98.65)
  S9 w0.102: 52.06,97.45 52.08,97.45 52.08,97.85 arc(52.2,98.14) 52.49,98.26 52.61,98.26 52.7,98.34 v4(52.7,98.65)
  S9 w0.108: 52.06,97.45 52.06,97.24 arc(52.11,96.97) 52.26,96.74 arc(52.41,96.52) 52.46,96.27 52.46,93.42 arc(52.56,92.9) 52.86,92.45 53.31,92.01 arc(54.12,91.46) 55.09,91.27 75.18,91.27 arc(75.76,91.16) 76.25,90.82 86.92,80.16 arc(87.37,79.86) 87.89,79.75 124.83,79.75 arc(127.71,79.18) 130.15,77.55 131.1,76.6 arc(131.54,76.3) 132.07,76.2 147.69,76.2 arc(148.82,75.97) 149.77,75.34 151.58,73.53 arc(151.95,72.98) 152.07,72.34 152.07,64.92 arc(152.16,64.5) 152.4,64.14 152.4,64.14 156.57,59.97 arc(156.89,59.49) 157,58.92 157,58.88 arc(157.06,58.6) 157.22,58.36 157.66,57.91 arc(157.89,57.57) 157.97,57.16 157.97,51.08 arc(158.29,50.31) 159.06,50 165,50 arc(165.27,49.88) 165.39,49.61 165.39,49.47 arc(165.35,49.28) 165.24,49.11 165.11,48.98 arc(165.04,48.94) 164.97,48.92 arc(164.9,48.93) 164.85,48.97 164.81,49.01 CONN55_PF.4L18
NIFE_TX[35]_N: length 136.3
  TOP w0.095: U40.C5 v4(53.7,99.65)
  S9 w0.102: 54.06,98.42 54.08,98.45 54.08,99.98 53.99,100.06 53.8,100.06 53.7,99.96 v4(53.7,99.65)
  S9 w0.108: 54.06,98.42 54.06,97.72 53.84,97.5 53.84,96.37 arc(53.89,96.09) 54.05,95.86 54.76,95.15 arc(54.89,94.95) 54.94,94.72 arc(55.57,93.19) 57.1,92.55 57.97,92.55 arc(58.03,92.53) 58.05,92.47 arc(58.08,92.41) 58.15,92.38 58.58,92.38 arc(58.64,92.41) 58.67,92.47 arc(58.69,92.53) 58.75,92.55 59.21,92.55 arc(59.26,92.53) 59.29,92.47 arc(59.31,92.42) 59.37,92.39 59.82,92.39 arc(59.88,92.42) 59.9,92.47 arc(59.93,92.53) 59.98,92.55 75.65,92.55 arc(76.18,92.45) 76.63,92.15 87.42,81.36 arc(87.86,81.06) 88.39,80.96 125.65,80.96 arc(128.56,80.38) 131.03,78.73 132.04,77.72 arc(132.49,77.42) 133.01,77.32 149.39,77.32 arc(150.2,77.15) 150.89,76.7 153.57,74.01 arc(153.81,73.66) 153.89,73.25 153.89,64.59 arc(153.96,64.26) 154.14,63.98 155.26,62.86 arc(155.71,62.56) 156.24,62.46 158.61,62.46 arc(159.05,62.37) 159.42,62.12 160.27,61.27 arc(160.49,60.94) 160.56,60.56 160.56,58.12 arc(160.54,58.01) 160.48,57.91 160.44,57.88 arc(160.37,57.83) 160.28,57.81 arc(160.21,57.83) 160.15,57.87 CONN55_PF.4T19
NIFE_TX[35]_P: length 136.3
  TOP w0.095: U40.D5 v4(53.7,100.65)
  S9 w0.102: v4(53.7,100.65) 53.7,100.34 53.78,100.26 54.08,100.26 54.28,100.06 54.28,98.57 54.29,98.57 54.29,98.45 54.28,98.45 54.28,98.42
  S9 w0.108: CONN55_PF.4T18 160.51,57.48 arc(160.54,57.61) 160.6,57.72 160.64,57.75 arc(160.75,57.92) 160.79,58.12 160.79,60.56 arc(160.7,61.03) 160.43,61.43 159.58,62.28 arc(159.13,62.58) 158.61,62.68 156.24,62.68 arc(155.8,62.77) 155.42,63.02 154.3,64.14 arc(154.17,64.35) 154.12,64.59 154.12,73.25 arc(154.02,73.75) 153.73,74.18 153.67,74.24 151.05,76.86 arc(150.29,77.37) 149.39,77.54 133.01,77.54 arc(132.58,77.63) 132.21,77.88 131.19,78.89 arc(128.65,80.59) 125.65,81.19 88.39,81.19 arc(87.95,81.28) 87.58,81.52 76.79,92.31 arc(76.27,92.66) 75.65,92.78 57.1,92.78 arc(55.74,93.35) 55.17,94.72 arc(55.11,95.04) 54.92,95.31 54.21,96.02 arc(54.1,96.18) 54.07,96.37 54.07,97.41 54.28,97.62 54.28,98.42
NIFE_TX[36]_N: length 157
  TOP w0.095: U40.B4 v4(54.7,98.65)
  S9 w0.102: v4(54.7,98.65) 54.7,98.36 54.78,98.27 55.11,98.27 55.31,98.07 55.31,97.42
  S9 w0.108: CONN55_PF.5L19 179.56,48.44 arc(179.57,48.5) 179.58,48.56 arc(179.59,48.57) 179.59,48.57 arc(179.62,48.64) 179.67,48.7 arc(179.77,48.85) 179.81,49.03 179.81,49.44 arc(179.58,49.98) 179.04,50.21 173.46,50.21 arc(172.65,50.55) 172.31,51.36 172.31,56.79 arc(172.12,57.74) 171.58,58.55 166.5,63.63 arc(166.17,64.12) 166.06,64.71 166.06,71.43 arc(165.77,72.85) 164.97,74.05 160.74,78.29 arc(160.33,78.55) 159.86,78.65 133.68,78.65 arc(133.24,78.74) 132.87,78.98 131.75,80.1 arc(129.14,81.85) 126.06,82.46 88.88,82.46 arc(88.27,82.58) 87.76,82.92 75.8,94.88 arc(75.49,95.09) 75.12,95.16 57.51,95.16 arc(57.07,95.25) 56.7,95.5 55.53,96.67 arc(55.36,96.91) 55.31,97.2 55.31,97.42
NIFE_TX[36]_P: length 156.9
  TOP w0.095: U40.A4 v4(54.7,97.65)
  S9 w0.102: 55.08,97.48 55.1,97.51 55.1,97.99 55.02,98.07 54.77,98.07 54.7,98 v4(54.7,97.65)
  S9 w0.108: CONN55_PF.5L18 178.76,49.12 178.76,49.12 arc(178.88,48.83) 179.17,48.71 179.24,48.71 arc(179.35,48.73) 179.44,48.79 179.51,48.86 arc(179.56,48.94) 179.58,49.03 179.58,49.44 arc(179.42,49.82) 179.04,49.98 173.46,49.98 arc(172.48,50.39) 172.08,51.36 172.08,56.79 arc(171.91,57.66) 171.42,58.39 166.34,63.46 arc(165.96,64.04) 165.83,64.71 165.83,71.43 arc(165.56,72.76) 164.81,73.89 160.57,78.12 arc(160.25,78.34) 159.86,78.42 133.68,78.42 arc(133.15,78.52) 132.71,78.82 131.59,79.94 arc(129.05,81.63) 126.06,82.23 88.88,82.23 arc(88.19,82.37) 87.6,82.76 75.64,94.72 arc(75.4,94.88) 75.12,94.93 57.51,94.93 arc(56.98,95.04) 56.54,95.33 55.37,96.5 arc(55.15,96.82) 55.08,97.2 55.08,97.48
NIFE_TX[37]_N: length 151.5
  TOP w0.095: U40.C3 v4(55.7,99.65)
  S9 w0.102: v4(55.7,99.65) 55.7,99.96 55.79,100.06 55.97,100.06 56.08,99.95 56.08,97.53 56.08,97.53 56.08,97.33 56.12,97.28
  S9 w0.108: 56.12,97.28 56.42,96.99 arc(56.7,96.8) 57.03,96.74 60.08,96.74 arc(60.14,96.71) 60.16,96.65 60.16,96.65 arc(60.18,96.59) 60.24,96.57 60.69,96.57 arc(60.75,96.59) 60.78,96.65 60.78,96.65 arc(60.8,96.71) 60.86,96.74 75.08,96.74 arc(75.43,96.67) 75.73,96.47 75.73,96.46 88.38,83.81 arc(88.83,83.52) 89.35,83.41 126.86,83.41 arc(129.62,82.86) 131.96,81.3 133.29,79.96 arc(133.74,79.67) 134.26,79.56 170.4,79.56 arc(171.55,79.33) 172.52,78.68 175.42,75.79 arc(175.7,75.37) 175.8,74.87 175.8,65.58 arc(175.75,65.33) 175.61,65.12 175.07,64.58 arc(174.87,64.28) 174.8,63.93 174.8,58.13 arc(174.76,57.95) 174.66,57.8 arc(174.53,57.72) 174.39,57.69 arc(174.25,57.72) 174.14,57.79 174.08,57.85 arc(173.99,57.98) 173.96,58.14 CONN55_PF.5T19
NIFE_TX[37]_P: length 151.5
  TOP w0.095: U40.D3 v4(55.7,100.65)
  S9 w0.102: 56.29,97.45 56.29,100.03 56.06,100.26 55.83,100.26 55.7,100.39 v4(55.7,100.65)
  S9 w0.108: CONN55_PF.5T18 174.73,56.9 174.73,57.38 arc(174.74,57.45) 174.76,57.52 arc(174.76,57.52) 174.76,57.53 arc(174.76,57.54) 174.76,57.54 arc(174.77,57.57) 174.78,57.59 arc(174.81,57.63) 174.84,57.66 174.82,57.64 arc(174.97,57.87) 175.02,58.13 175.02,63.93 arc(175.08,64.2) 175.23,64.42 175.77,64.96 arc(175.96,65.25) 176.03,65.58 176.03,74.87 arc(175.91,75.46) 175.58,75.95 172.69,78.84 arc(171.64,79.55) 170.4,79.79 134.26,79.79 arc(133.83,79.88) 133.45,80.13 132.12,81.46 arc(129.71,83.07) 126.86,83.64 89.35,83.64 arc(88.92,83.73) 88.55,83.97 75.91,96.61 arc(75.53,96.87) 75.08,96.97 57.03,96.97 arc(56.79,97.02) 56.58,97.15 56.29,97.45
NIFE_TX[38]_N: length 173.8
  TOP w0.095: U40.B2 v4(56.7,98.65)
  S9 w0.108: v4(56.7,98.65) 57.08,98.26 75.69,98.26 arc(76.01,98.2) 76.28,98.02 89.11,85.18 arc(89.49,84.93) 89.92,84.85 128.08,84.85 arc(130.64,84.34) 132.81,82.89 134.34,81.36 arc(134.71,81.11) 135.15,81.02 173.13,81.02 arc(174.28,80.79) 175.26,80.14 181.17,74.23 arc(181.62,73.93) 182.15,73.82 185.05,73.82 arc(186.25,73.59) 187.26,72.91 187.26,72.91 arc(187.8,72.1) 187.99,71.14 187.99,64.8 arc(187.85,64.1) 187.45,63.5 186.91,62.96 186.82,62.87 arc(186.54,62.45) 186.44,61.95 186.44,51.39 arc(186.78,50.58) 187.59,50.24 193.35,50.24 arc(193.86,50.03) 194.08,49.51 194.08,49.01 arc(194.03,48.8) 193.91,48.62 193.81,48.52 CONN55_PF.6L19
NIFE_TX[38]_P: length 173.8
  TOP w0.095: U40.A2 v4(56.7,97.65)
  S9 w0.108: v4(56.7,97.65) 57.08,98.03 75.69,98.03 arc(75.92,97.99) 76.12,97.86 88.95,85.02 arc(89.4,84.72) 89.92,84.62 128.08,84.62 arc(130.56,84.13) 132.65,82.72 134.18,81.19 arc(134.63,80.9) 135.15,80.79 173.13,80.79 arc(174.19,80.58) 175.09,79.98 181.01,74.06 arc(181.53,73.72) 182.15,73.59 185.05,73.59 arc(186.16,73.37) 187.1,72.75 arc(187.59,72.01) 187.76,71.14 187.76,64.8 arc(187.64,64.18) 187.29,63.66 186.75,63.12 186.66,63.03 arc(186.33,62.54) 186.21,61.95 186.21,51.39 arc(186.62,50.41) 187.59,50.01 193.35,50.01 arc(193.7,49.86) 193.85,49.51 193.85,49.01 arc(193.82,48.89) 193.75,48.78 193.67,48.7 arc(193.6,48.65) 193.51,48.63 193.39,48.63 arc(193.29,48.65) 193.21,48.7 193.11,48.81 arc(193.04,48.91) 193.01,49.04 CONN55_PF.6L18
NIFE_TX[39]_N: length 161.6
  TOP w0.095: U40.C1 v4(57.7,99.65)
  S9 w0.108: v4(57.7,99.65) 58.08,100.03 75.13,100.03 arc(75.5,99.96) 75.82,99.75 89.38,86.19 arc(89.82,85.89) 90.35,85.79 129.31,85.79 arc(131.59,85.33) 133.53,84.04 135.22,82.35 arc(135.66,82.05) 136.19,81.95 180.31,81.95 arc(181.89,81.64) 183.23,80.74 188.72,75.25 arc(189.12,74.65) 189.26,73.95 189.26,66.64 arc(189.36,66.11) 189.66,65.67 190.5,64.83 arc(190.71,64.52) 190.78,64.14 190.78,63.12 arc(190.71,62.75) 190.49,62.43 189.73,61.67 arc(189.38,61.14) 189.26,60.52 189.26,58.42 arc(189.22,58.21) 189.1,58.04 188.73,57.66 arc(188.66,57.62) 188.58,57.6 188.56,57.6 arc(188.46,57.62) 188.37,57.68 188.28,57.77 arc(188.23,57.85) 188.21,57.94 CONN55_PF.6T19
NIFE_TX[39]_P: length 161.6
  TOP w0.095: U40.D1 v4(57.7,100.65)
  S9 w0.108: v4(57.7,100.65) 58.08,100.26 75.13,100.26 arc(75.59,100.17) 75.98,99.91 89.54,86.35 arc(89.91,86.1) 90.35,86.01 129.31,86.01 arc(131.68,85.54) 133.69,84.2 135.38,82.51 arc(135.75,82.27) 136.19,82.18 180.31,82.18 arc(181.98,81.85) 183.39,80.91 188.88,75.41 arc(189.33,74.74) 189.49,73.95 189.49,66.64 arc(189.57,66.2) 189.82,65.83 190.66,64.99 arc(190.92,64.6) 191.01,64.14 191.01,63.12 arc(190.92,62.66) 190.66,62.27 189.89,61.5 arc(189.59,61.05) 189.49,60.52 189.49,58.42 arc(189.43,58.12) 189.26,57.88 189.1,57.71 arc(189.06,57.66) 189.03,57.61 arc(189.02,57.58) 189.02,57.54 arc(189.01,57.52) 189.01,57.5 CONN55_PF.6T18
OCXO25MHZ: length 2
  TOP w0.127: U37.1 241.57,114.49 R687.1
OCXO25MHZ_R: length 19.2
  TOP w0.127: OCXO2.4 253.71,116.84 253.71,114.39 251.82,112.5 248.89,112.5 247.33,110.93 OCXO1.4 244.24,108.91 R687.2
OCXO_VOUT: length 20.3
  S5 w0.254: v1(239.12,145.31) 255.6,145.31 CONN26.1
  BOTTOM w0.254: R557.1 237.92,145.32 v2(237.92,145.31) v1(239.12,145.31)
OSC_CPLD1_25M_OE: length 1.7
  TOP w0.127: OSC1.1 84.35,213.06 R54.1
OSC_CPLD1_25M_VDD: length 6.9
  TOP w0.508: L3.2 81.56,212.12 C48.1 81.55,213.55 C49.1 81.57,214.97 C37.1 ; R54.2 82.82,214.96 C37.1 ; C37.1 84.32,214.97 OSC1.4
OSC_CPLD2_25M_OE: length 2.1
  TOP w0.127: R222.1 180.87,189.64 181.34,189.16 OSC3.1
OSC_CPLD2_25M_VDD: length 11.5
  TOP w0.254: L4.2 182.95,196.93 v1(184.24,198.22)
  TOP w0.508: L4.2 C100.1 C114.1 182.42,193.12 182.28,192.98 C121.1 182.28,190.95 OSC3.4 181.87,190.55 R222.2
  BOTTOM w0.254: v2(185.07,198.16) 184.31,198.16 v1(184.24,198.22)
OSC_MAC_25M_OE: length 1.7
  TOP w0.127: OSC5.1 9.67,156.05 9.67,156.99 9.8,157.12 R415.1
OSC_MAC_25M_VDD: length 11.4
  TOP w0.508: OSC5.4 11.26,157.12 R415.2 10.71,158.67 C206.1 11.35,158.68 12.28,159.62 12.28,161.45 11.59,162.15 C199.1 9.5,162.15 C176.1 L8.2
OSC_MAC_25MHZ: length 5.6
  TOP w0.381: C139.1 8.03,167.74 R231.1
  TOP w0.508: R231.1 R232.1 9.06,168.31 C144.1 ; C139.1 8.73,166.08 L8.1
P01_LANE0_3P3: length 6
  TOP w0.305: LED1.A 2.8,62.22 2.8,64.11
  TOP w0.381: R863.1 v1(2.8,64.41) 2.8,64.11
  BOTTOM w0.254: v1(2.8,64.41) 3.95,64.41 v2(3.97,64.42)
P01_LANE0_LED_B: length 342.3
  TOP w0.127: R862.2 15.48,75.11 v1(13.47,77.12) ; U9.E14 v4(203.55,195.58)
  S5 w0.127: v1(204.66,201.95) 204.59,202.03 204.59,203.85 203.42,205.01 202.44,205.01 202.06,205.39 202.06,206.44 200.43,208.06 178.61,208.06 168.58,198.03 103.22,198.03 100.01,201.23 52.43,201.23 51.84,201.82 30.16,201.82 12.1,183.76 12.1,178.82 4.82,171.53 4.82,166.65 3.11,164.95 3.11,133.12 5.61,130.63 6.02,130.63 6.91,129.74 6.91,115.59 5.97,114.65 5.97,99.37 4.35,97.75 4.35,82.35 7.24,79.46 11.13,79.46 v1(13.47,77.12)
  S12 w0.127: v1(204.66,201.95) 204.66,200.61 204.12,200.06 204.12,196.14 v4(203.55,195.58)
  BOTTOM w0.127: v2(14.51,78.46) 14.51,78.17 v1(13.47,77.12)
P01_LANE0_LED_G: length 339.9
  TOP w0.127: v4(204.55,197.58) U9.C15 ; R861.2 14.47,75.29 v1(13.43,76.32)
  S5 w0.127: v1(13.43,76.32) 10.58,79.17 7,79.17 4.05,82.12 4.05,97.99 5.72,99.65 5.72,114.76 6.66,115.7 6.66,129.58 5.93,130.3 5.42,130.3 2.84,132.88 2.84,165.17 4.28,166.62 4.28,171.36 11.85,178.92 11.85,183.86 30.06,202.07 52.1,202.07 52.68,201.49 100.12,201.49 103.32,198.28 168.47,198.28 178.51,208.32 200.77,208.32 205.2,203.89 205.2,200.7 205.07,200.57 205.07,198.5 204.55,197.98 v4(204.55,197.58)
  BOTTOM w0.127: v2(14.76,76.49) 13.59,76.49 v1(13.43,76.32)
P01_LANE0_LED_R: length 345.7
  TOP w0.127: R860.2 13.45,75.49 v1(13.42,75.51) ; U9.G13 v4(202.55,193.58)
  S5 w0.127: v1(205.79,201.98) 205.79,203.66 200.82,208.63 178.46,208.63 168.43,198.6 103.41,198.6 100.24,201.77 52.87,201.77 52.23,202.41 29.98,202.41 11.56,183.99 11.56,178.99 3.9,171.34 3.9,166.67 2.48,165.25 2.48,132.64 5.07,130.05 5.07,124.61 6.4,123.29 6.4,118.42 6.4,118.42 6.4,115.8 5.18,114.58 5.18,99.74 3.55,98.1 3.55,82.14 6.85,78.84 10.1,78.84 v1(13.42,75.51)
  BOTTOM w0.127: v1(13.42,75.51) 14.35,74.58 v2(14.63,74.58) ; v1(205.79,201.98) 204.12,200.31 204.12,199.3 203.1,198.28 203.1,194.13 v4(202.55,193.58)
P01_LANE0_R_LED_B: length 22.6
  TOP w0.127: LED1.C3 4.8,61.59 5.4,62.19 5.4,65.42 6.57,66.58 9.68,66.58 11.78,68.68 v1(12.86,68.68) 14,69.82 14.88,69.82 15.48,70.43 C640.1 15.73,70.89 15.99,71.15 15.99,73.15 15.84,73.3 R862.1
  BOTTOM w0.127: v1(12.86,68.68) 14.91,68.68 v2(15.06,68.53)
P01_LANE0_R_LED_G: length 19.4
  TOP w0.127: R861.1 14.77,73.3 14.98,73.1 14.98,71.04 14.82,70.89 C639.1 14.47,70.3 14.27,70.1 13.07,70.1 v1(12.79,69.82) 12.41,69.82 9.55,66.96 6.12,66.96 4.8,65.64 LED1.C2
  BOTTOM w0.127: v1(12.79,69.82) 12.9,69.93 v2(13.77,69.93)
P01_LANE0_R_LED_R: length 20.1
  TOP w0.127: LED1.C1 3.9,65.32 6,67.41 9.36,67.41 v1(12.73,70.77) 12.84,70.89 C638.1 13.68,70.89 13.94,71.14 13.94,72.77 13.45,73.25 R860.1
  BOTTOM w0.127: v2(15.14,71.47) 13.43,71.47 v1(12.73,70.77)
P01_LANE1_3P3: length 9.5
  TOP w0.254: R864.1 v1(6.85,65.91)
  TOP w0.508: R864.1 9.13,65.76 9.13,61.58 9.6,61.11 LED2.A
  BOTTOM w0.254: v1(6.85,65.91) 6.76,65.82 v2(6.76,64.42)
P01_LANE1_LED_B: length 337.5
  TOP w0.127: U9.B14 203.55,198.57 203.55,200.12 v4(203.67,200.25) ; R919.2 18.56,75.36 v1(17.87,76.05)
  S5 w0.127: v1(17.87,76.05) 13.43,80.49 7.86,80.49 5.27,83.08 5.27,91.49 6.74,92.95 6.74,104.43 7.47,105.17 7.47,115.07 7.67,115.28 7.67,133.68 6.61,134.74 5.38,134.74 4.28,135.84 4.28,152.5 6.07,154.29 6.07,164.95 10.44,169.32 10.44,170.47 10.44,170.47 10.44,171.1 10.44,171.3 12.44,173.29 12.44,178.08 12.86,178.5 12.86,183.39 30.42,200.95 51.53,200.95 52.04,200.44 99.63,200.44 102.87,197.2 170.21,197.2 180.31,207.3 198.36,207.3 199.42,206.24 199.42,204.95 200.24,204.12 202.66,204.12 203.55,203.24 203.55,202.74 203.09,202.28 203.09,200.84 v4(203.67,200.25)
  BOTTOM w0.127: v1(17.87,76.05) 17.81,76.11 v2(17.81,76.93)
P01_LANE1_LED_G: length 384.3
  TOP w0.127: R918.2 17.54,74.93 v1(17.9,75.28) ; v4(201.62,182.65) 201.62,182.65 U9.U13
  S5 w0.127: v1(17.9,75.28) 13.1,80.08 7.86,80.08 4.94,83 4.94,91.62 6.48,93.15 6.48,104.54 7.22,105.27 7.22,115.18 7.42,115.38 7.42,133.53 6.66,134.29 5.35,134.29 3.95,135.69 3.95,153.18 4.74,153.97 4.74,157.21 5.58,158.05 5.58,166.08 9.83,170.33 9.83,171.13 12.12,173.42 12.12,178.12 12.61,178.6 12.61,183.5 30.37,201.26 51.66,201.26 52.23,200.7 99.74,200.7 102.98,197.46 168.88,197.46 178.97,207.55 198.46,207.55 199.86,206.16 199.86,204.95 200.31,204.51 202.78,204.51 203.8,203.49 203.8,202.09 v1(203.61,201.9)
  BOTTOM w0.127: v2(18.8,74.66) 18.52,74.66 v1(17.9,75.28) ; v4(201.62,182.65) 202.28,181.99 202.28,179.04 203.76,177.56 211.78,177.56 215.87,181.65 215.87,194.74 212.48,198.13 212.48,199.33 v2(212.13,199.68) 212.12,199.68 212.11,199.68 208.99,202.8 204.57,202.8 203.67,201.9 v1(203.61,201.9)
P01_LANE1_LED_R: length 337.6
  TOP w0.127: v1(16.75,75.03) 16.52,74.8 R917.2 ; v4(204.55,198.58) U9.B15
  S5 w0.127: v1(16.75,75.03) 12.01,79.78 7.59,79.78 4.64,82.73 4.64,97.41 6.23,99 6.23,104.64 6.96,105.38 6.96,115.28 7.17,115.49 7.17,130.08 6.34,130.91 5.81,130.91 3.47,133.25 3.47,164.59 5.07,166.19 5.07,171.43 12.35,178.71 12.35,183.65 30.27,201.56 51.74,201.56 52.32,200.98 99.91,200.98 103.11,197.77 168.68,197.77 178.72,207.81 198.89,207.81 200.94,205.75 200.94,205.33 201.51,204.76 203.1,204.76 204.13,203.73 204.13,199 v4(204.55,198.58)
  BOTTOM w0.127: v2(16.98,74.08) 16.98,74.8 v1(16.75,75.03)
P01_LANE1_R_LED_B: length 18.8
  TOP w0.127: R919.1 18.91,73.33 19.07,73.17 19.07,71.04 18.91,70.89 C643.1 18.56,70.38 18.02,69.85 16.4,69.85 15.56,69.01 14.82,69.01 13.89,68.07 v1(13.89,67.03) 13.89,66.23 11.52,63.86 11.52,61.65 LED2.C3
  BOTTOM w0.127: v2(14.06,65.89) 14.06,66.85 v1(13.89,67.03)
P01_LANE1_R_LED_G: length 16.7
  TOP w0.127: LED2.C2 11,62.74 11,63.77 13.16,65.93 13.16,66.54 v1(13.19,66.56) 13.16,66.58 13.16,67.83 14.62,69.29 15.41,69.29 16.34,70.22 17,70.22 17.54,70.76 C642.1 17.95,70.89 18.08,71.02 18.08,72.79 R918.1
  BOTTOM w0.127: v2(11.61,67.02) 12.8,67.02 13.19,66.63 v1(13.19,66.56)
P01_LANE1_R_LED_R: length 16.3
  TOP w0.127: R917.1 17.01,72.84 17.01,71.02 16.88,70.89 C641.1 16.52,70.84 15.23,69.54 14.42,69.54 12.57,67.7 v1(12.57,66.19) 10.08,63.7 LED2.C1
  BOTTOM w0.127: v1(12.57,66.19) 11.28,64.9 v2(11.28,64.83)
P01_LANE2_3P3: length 9.2
  TOP w0.508: R865.1 15.29,65.87 v1(15.15,65.73) 14.77,65.73 12.51,63.47 12.44,63.47 12.44,61.66 12.99,61.11 LED3.A
  BOTTOM w0.127: v2(16.45,65.7) 15.19,65.7 v1(15.15,65.73)
P01_LANE2_LED_B: length 353.1
  TOP w0.127: v1(18.51,69.31) 18.56,69.26 R922.2 ; U9.N9 v4(197.54,186.56)
  S5 w0.127: v1(18.51,69.31) 18.02,69.8 18.02,73.56 19.42,74.95 19.42,76.61 15.46,80.57 15.46,87.93 12.13,91.26 10.33,91.26 7.68,93.91 7.68,98.11 8.41,98.84 8.41,112.59 9.83,114.01 9.83,117.92 10.25,118.34 10.25,118.37 10.43,118.55 10.43,122.16 10.43,122.16 10.43,135.68 9.72,136.4 7.48,136.4 5.15,138.73 5.15,151.81 6.06,152.73 6.68,152.73 8,154.05 8,162.93 9.17,164.09 9.17,166.91 11.2,168.95 11.2,170.79 13.26,172.84 13.26,177.77 13.33,177.84 13.33,177.87 13.68,178.22 13.68,183.1 30.77,200.19 51.15,200.19 51.65,199.68 99.25,199.68 102.49,196.44 170.53,196.44 179.61,205.52 197.77,205.52 v1(198.09,205.84)
  S7 w0.127: v4(197.54,186.56) 197.54,186.75 198.85,188.06 198.85,194.22 196.94,196.12 196.05,196.12 195.93,196.25 195.93,196.82 196.18,197.08 196.82,197.08 197.07,197.33 197.07,197.84 197.32,198.09 197.77,198.09 198.02,198.35 198.02,205.78 v1(198.09,205.84)
  BOTTOM w0.127: v1(18.51,69.31) 19.08,69.89 v2(19.08,70.39) ; v2(198.59,206.92) 198.59,206.35 v1(198.09,205.84)
P01_LANE2_LED_G: length 344.8
  TOP w0.127: v1(17.59,69.31) 17.56,69.28 R921.2 ; v4(202.55,198.58) U9.B13
  S5 w0.127: v4(202.55,198.58) 202.02,199.11 202.02,200.06 202.47,200.51 202.47,202.47 202.24,202.7 199.83,202.7 198.59,203.93 198.59,206.04 198.22,206.41 197.58,206.41 196.94,205.78 179.5,205.78 170.42,196.7 102.62,196.7 99.38,199.93 51.78,199.93 51.27,200.44 30.63,200.44 13.37,183.18 13.37,178.29 13.03,177.95 13.03,177.91 13,177.88 13,172.99 10.95,170.94 10.95,170.89 10.95,169.11 8.92,167.08 8.92,164.35 7.53,162.96 7.53,154.02 6.62,153.11 6.04,153.11 4.87,151.94 4.87,138.4 7.2,136.07 9.26,136.07 10.1,135.23 10.1,122.28 10.17,122.21 10.17,118.65 9.58,118.06 9.58,114.11 8.12,112.65 8.12,99.34 7.4,98.62 7.4,92.7 5.96,91.26 5.96,83.18 8.02,81.13 14.54,81.13 19.07,76.6 19.07,75.05 17.01,73 17.01,69.9 v1(17.59,69.31)
  BOTTOM w0.127: v2(17.46,68.21) 17.46,69.18 v1(17.59,69.31)
P01_LANE2_LED_R: length 345.7
  TOP w0.127: U9.A13 v4(202.55,199.58) ; v1(16.68,69.29) 16.55,69.16 R920.2
  S5 w0.127: v4(202.55,199.58) 202.76,199.79 202.76,202.41 203.04,202.69 203.04,203.36 202.56,203.84 200.15,203.84 199.04,204.95 199.04,206.16 198.15,207.05 180.43,207.05 179.42,206.03 179.4,206.03 170.32,196.95 102.74,196.95 99.51,200.19 51.91,200.19 51.4,200.7 30.52,200.7 13.12,183.29 13.12,178.39 12.78,178.06 12.78,178.01 12.75,177.98 12.75,173.1 10.7,171.05 10.7,171 10.7,169.22 8.66,167.18 8.66,164.83 7.28,163.45 7.28,154.2 6.59,153.52 5.93,153.52 4.54,152.12 4.54,138.2 7.28,135.46 9.19,135.46 9.84,134.8 9.84,122.18 9.92,122.1 9.92,118.76 9.33,118.17 9.33,114.22 7.86,112.76 7.86,99.59 7.1,98.83 7.1,92.83 5.65,91.39 5.65,83.06 7.84,80.87 14.11,80.87 18.69,76.3 18.69,75.28 17.11,73.71 16.74,73.71 15.97,72.94 15.97,70 v1(16.68,69.29)
  BOTTOM w0.127: v1(16.68,69.29) 16.68,70.22 v2(16.98,70.52)
P01_LANE2_R_LED_B: length 10.4
  TOP w0.127: R922.1 19.07,67.16 19.07,65.45 18.8,65.19 C646.1 18.56,64.46 v1(18.52,64.41) 15.22,61.11 LED3.C3
  BOTTOM w0.127: v1(18.52,64.41) 18.54,64.43 v2(18.54,65.44)
P01_LANE2_R_LED_G: length 9.1
  TOP w0.127: R921.1 18.08,67.15 18.08,65.4 17.85,65.18 C645.1 17.56,64.45 v1(17.53,64.41) 17.53,64.2 16.04,62.71 LED3.C2
  BOTTOM w0.127: v2(17.29,63.27) 17.53,63.51 v1(17.53,64.41)
P01_LANE2_R_LED_R: length 9.5
  TOP w0.127: LED3.C1 13.48,63.32 13.86,63.7 15.83,63.7 v1(16.55,64.42) C644.1 16.91,65.18 17.08,65.35 17.08,67.12 R920.1
  BOTTOM w0.127: v1(16.55,64.42) 15.38,64.42 v2(15.14,64.18)
P01_LANE3_3P3: length 7.2
  TOP w0.508: R869.1 20.43,64.55 v1(20.45,64.53) 20.02,64.53 18.87,63.38 18.87,61.71 19.47,61.11 LED4.A
  BOTTOM w0.127: v2(20.54,66.01) 20.43,65.91 20.43,64.55 v1(20.45,64.53)
P01_LANE3_LED_B: length 326.7
  TOP w0.127: v4(201.55,198.58) U9.B12 ; R868.2 v1(22.31,75.17)
  S5 w0.127: v1(22.31,75.17) 16.65,80.83 16.65,88.09 11.83,92.91 11.83,96.04 9.39,98.47 9.39,111.77 10.75,113.13 10.75,115.63 10.89,115.77 10.89,117.19 13.11,119.41 13.11,137.07 14.24,138.2 15.23,138.2 16.06,139.03 16.06,139.97 16.5,140.41 16.5,141.46 16.79,141.75 16.79,147.93 14.56,150.17 14.56,155.38 10.62,159.32 10.62,165.27 11.38,166.03 11.38,167.64 12.08,168.34 12.08,170.18 14.02,172.13 14.02,177.4 14.69,178.07 14.69,182.98 31.14,199.43 50.64,199.43 51.15,198.92 98.78,198.92 102.21,195.49 152.29,195.49 153.08,194.7 155.12,194.7 155.9,195.49 170.83,195.49 180.1,204.76 196.56,204.76 201.06,200.26 201.06,199.07 v4(201.55,198.58)
  BOTTOM w0.127: v2(22.44,76.11) 22.44,75.31 v1(22.31,75.17)
P01_LANE3_LED_G: length 325.6
  TOP w0.127: v1(20.34,76.1) 21.31,75.13 R867.2 ; U9.A12 v4(201.55,199.58)
  S5 w0.127: v1(20.34,76.1) 20.34,76.53 16.35,80.52 16.35,87.99 11.46,92.87 11.46,95.97 9.11,98.32 9.11,111.85 10.49,113.24 10.49,115.74 10.63,115.88 10.63,117.45 12.85,119.67 12.85,138.17 16.54,141.86 16.54,147.83 14.3,150.06 14.3,155.28 10.37,159.22 10.37,165.38 11.13,166.14 11.13,167.75 11.82,168.44 11.82,170.29 13.77,172.23 13.77,177.54 14.37,178.14 14.37,183.03 31.02,199.68 50.77,199.68 51.27,199.17 98.91,199.17 102.27,195.81 152.49,195.81 153.3,195 154.57,195 155.38,195.81 170.69,195.81 179.9,205.01 196.69,205.01 201.44,200.26 201.44,199.69 v4(201.55,199.58)
  BOTTOM w0.127: v2(20.35,77.12) 20.35,76.11 v1(20.34,76.1)
P01_LANE3_LED_R: length 346.7
  TOP w0.127: v4(201.55,186.58) U9.N12 ; R866.2 v1(20.29,75.2)
  S5 w0.127: v1(20.29,75.2) 20.29,75.23 19.85,75.66 19.85,76.54 16.09,80.3 16.09,87.71 12.21,91.59 10.9,91.59 10.28,92.21 10.28,96.74 8.8,98.21 8.8,112.37 10.1,113.66 10.1,117.55 10.76,118.21 10.76,136.62 16.2,142.06 16.2,147.81 14.05,149.96 14.05,155.17 10.06,159.16 10.06,165.52 10.7,166.15 10.7,167.74 11.52,168.56 11.52,170.53 13.51,172.52 13.51,177.67 14,178.15 14,183.03 30.9,199.93 51.02,199.93 51.53,199.43 99.13,199.43 102.43,196.12 170.59,196.12 179.73,205.27 196.79,205.27 199.97,202.09 201.56,202.09 v1(201.8,201.85)
  S12 w0.127: v4(201.55,186.58) 201.01,187.12 201.01,192.82 201.26,193.08 201.96,193.08 202.09,193.2 202.09,201.57 v1(201.8,201.85)
  BOTTOM w0.127: v4(201.55,186.58) 202.15,185.98 202.15,183.17 202.53,182.79 202.53,181.26 v2(203.04,180.76)
P01_LANE3_R_LED_B: length 14.8
  TOP w0.127: LED4.C3 20.92,61.11 21.17,61.36 21.17,63.03 22.32,64.18 v1(22.32,69.92) 22.32,69.93 C576.1 22.5,70.92 22.9,71.32 22.9,72.77 R868.1
  BOTTOM w0.127: v1(22.32,69.92) 22.83,70.43 v2(23.13,70.43)
P01_LANE3_R_LED_G: length 14.5
  TOP w0.127: LED4.C2 20.55,63.23 21.81,64.48 21.81,68.28 v1(20.53,69.56) 20.53,69.69 21.32,70.49 C575.1 20.85,70.91 20.79,70.96 20.79,72.41 21.31,72.93 R867.1
  BOTTOM w0.127: v2(20.83,71.15) 20.83,69.86 v1(20.53,69.56)
P01_LANE3_R_LED_R: length 14.4
  TOP w0.127: LED4.C1 19.65,62.92 21.33,64.59 21.33,67.88 v1(20.44,68.77) 19.97,69.24 19.97,69.88 20.27,70.19 C574.1 19.9,70.89 19.75,71.04 19.75,73.25 19.88,73.38 R866.1
  BOTTOM w0.127: v1(20.44,68.77) 20.66,68.99 v2(21.77,68.99)
P1_LED1_SFP28_B: length 330.3
  TOP w0.127: U9.A10 v4(199.55,199.58) ; R932.1 27.07,75.86 v1(19.42,83.51)
  S5 w0.127: v4(199.55,199.58) 199.74,199.76 199.74,200.37 196.17,203.93 180.38,203.93 170.98,194.54 156.81,194.54 156.05,193.77 152.24,193.77 151.48,194.54 102.02,194.54 98.44,198.12 50.61,198.12 50.07,198.66 31.48,198.66 15.5,182.69 15.5,177.8 14.78,177.09 14.78,168.53 12.32,166.07 12.32,158.7 15.32,155.7 15.32,150.79 18.33,147.78 18.33,140.86 16.89,139.42 16.89,138.69 15.62,137.41 14.62,137.41 13.87,136.67 13.87,116.38 12.31,114.82 12.31,110.31 11.88,109.88 11.88,108.73 10.15,107.01 10.15,99.08 12.84,96.39 12.84,93.4 17.54,88.7 17.54,85.39 v1(19.42,83.51)
  BOTTOM w0.127: v2(20.59,83.31) 19.62,83.31 v1(19.42,83.51)
P1_LED1_SFP28_B_R: length 18.3
  TOP w0.127: v1(26.18,55.97) 26.46,55.68 LED9.C1 ; R932.2 27.52,67.64 27.64,67.53 27.64,65.37 27.44,65.17 C661.1 27.07,64.6 v1(26.83,64.36)
  S5 w0.127: v1(26.18,55.97) 25.91,56.24 25.91,56.97 26.51,57.57 26.51,61.53 25.05,62.99 25.05,63.98 25.75,64.68 26.51,64.68 v1(26.83,64.36)
  BOTTOM w0.127: v1(26.83,64.36) 26.83,63.22 v2(27.08,62.96)
P1_LED1_SFP28_G: length 333
  TOP w0.127: R933.1 25.04,75.98 18.98,82.04 18.05,82.04 v1(17.9,81.89) ; U9.A11 v4(200.55,199.58)
  S5 w0.127: v1(17.9,81.89) 17,82.78 17,88.22 12.23,92.99 12.23,96.06 9.64,98.65 9.64,107.74 10.61,108.72 10.61,112.64 11.17,113.2 11.17,114.45 13.36,116.64 13.36,136.88 14.41,137.92 15.41,137.92 16.39,138.9 16.39,139.91 16.75,140.28 16.75,141.35 17.82,142.42 17.82,147.57 17.35,148.04 17.04,148.04 14.81,150.27 14.81,155.49 10.87,159.43 10.87,165.17 11.64,165.93 11.64,167.54 12.33,168.23 12.33,170.08 14.27,172.02 14.27,177.3 14.99,178.02 14.99,182.9 31.27,199.17 50.45,199.17 50.94,198.68 51.03,198.68 51.04,198.66 98.66,198.66 102.15,195.17 152,195.17 152.82,194.35 155.53,194.35 156.36,195.17 170.89,195.17 180.16,204.44 196.38,204.44 200.55,200.27 v4(200.55,199.58)
  BOTTOM w0.127: v2(17.77,82.93) 17.77,82.01 v1(17.9,81.89)
P1_LED1_SFP28_G_R: length 17.9
  TOP w0.127: v1(25.56,63.22) 25.04,63.74 C662.1 25.41,65.17 25.55,65.3 25.55,67.4 25.3,67.64 R933.2 ; v1(26.41,56.67) 27.16,55.92 LED9.C2
  S5 w0.127: v1(26.41,56.67) 27.02,57.28 27.02,61.76 v1(25.56,63.22)
  BOTTOM w0.127: v2(23.95,65.49) 23.95,64.83 v1(25.56,63.22)
P1_LED2_SFP28_B: length 330.3
  TOP w0.127: v1(19.4,84.33) 18.81,83.74 18.81,83.3 26.05,76.05 R1238.1 ; v4(199.55,198.58) U9.B10
  S5 w0.127: v1(19.4,84.33) 18.12,85.6 18.12,88.77 13.2,93.7 13.2,96.54 10.4,99.34 10.4,106.78 12.23,108.61 12.23,109.83 12.84,110.44 12.84,111.73 13.95,112.84 13.95,113.84 16,115.9 16,134.57 17.36,135.93 17.36,138.35 17.83,138.82 17.83,139.28 18.84,140.28 18.84,147.99 17.77,149.05 17.47,149.05 15.88,150.64 15.88,155.86 12.83,158.91 12.83,165.85 15.04,168.06 15.04,173.06 20.38,178.41 34.09,178.41 38.82,183.14 53.5,183.14 54.46,184.1 54.46,193.59 58.63,197.76 58.65,197.76 58.75,197.87 98.29,197.87 103.44,192.71 146.52,192.71 147.17,193.36 156.84,193.36 157.76,194.28 171.08,194.28 180.48,203.68 196.01,203.68 199.03,200.67 199.03,200.66 199.13,200.56 199.13,199 v4(199.55,198.58)
  BOTTOM w0.127: v2(19.8,85.16) 19.8,84.73 v1(19.4,84.33)
P1_LED2_SFP28_B_R: length 19.7
  TOP w0.127: v1(26.05,64.08) 26.05,64.08 C796.1 26.45,65.17 26.58,65.3 26.58,67.33 26.27,67.64 R1238.2 ; v1(26.05,51.94) 26.46,51.53 LED34.C1
  S16 w0.127: v1(26.05,51.94) 27.12,53.01 27.12,63.01 v1(26.05,64.08)
  BOTTOM w0.127: v2(26.19,65.06) 26.05,64.92 v1(26.05,64.08)
P1_LED2_SFP28_G: length 331.1
  TOP w0.127: v4(200.55,198.58) U9.B11 ; R1239.1 24.02,76.14 18.69,81.48 v1(18.51,81.48)
  S5 w0.127: v4(200.55,198.58) 199.99,199.14 199.99,200.47 196.27,204.19 180.27,204.19 170.94,194.85 156.49,194.85 155.67,194.03 152.68,194.03 151.86,194.85 102.08,194.85 98.56,198.37 50.86,198.37 50.32,198.92 31.37,198.92 15.25,182.8 15.25,177.91 14.53,177.19 14.53,168.63 12.07,166.17 12.07,158.59 15.07,155.59 15.07,150.38 17.15,148.29 17.45,148.29 18.08,147.67 18.08,140.96 16.64,139.53 16.64,138.79 15.51,137.67 14.51,137.67 13.62,136.77 13.62,116.51 11.7,114.59 11.7,113.36 10.89,112.55 10.89,108.46 9.9,107.46 9.9,98.9 12.56,96.24 12.56,93.16 17.26,88.47 17.26,83.85 18.51,82.6 v1(18.51,81.48)
  BOTTOM w0.127: v1(18.51,81.48) 18.51,80.77 v2(18.69,80.59)
P1_LED2_SFP28_G_R: length 21.1
  TOP w0.127: LED34.C2 27.16,51.52 26.24,52.44 24.51,52.44 23.68,53.27 23.68,62.87 v1(24.02,63.22) C797.1 24.42,65.17 24.53,65.28 24.53,67.13 24.02,67.64 R1239.2
  BOTTOM w0.127: v2(23.14,62.86) 23.5,63.22 v1(24.02,63.22)
P2_LED1_SFP28_B: length 249.1
  TOP w0.127: v4(193.55,198.58) U9.B5 ; R934.1 v1(36.86,75.03)
  S7 w0.127: v4(193.55,198.58) 194.05,199.07 194.05,201.18 191.8,203.43 180.97,203.43 172.05,194.5 172.05,185.57 167.55,181.07 167.55,179.25 165.13,176.82 165.13,175.93 164.05,174.85 162.17,174.85 160.03,172.71 160.03,171.15 159.22,170.34 158.12,170.34 156.02,168.25 156.02,165.64 151.39,161.01 136.59,161.01 126.84,151.25 115.65,151.25 108.82,144.42 100.1,144.42 94.39,138.71 88.9,138.71 86.19,141.42 79.9,141.42 69.23,130.76 69.23,95.89 63.9,90.57 53.16,90.57 50.03,87.43 49.27,87.43 v1(36.86,75.03)
  BOTTOM w0.127: v2(36.34,73.68) 36.86,74.21 v1(36.86,75.03)
P2_LED1_SFP28_B_R: length 26.4
  TOP w0.127: v1(36.86,70.21) C663.1 36.62,71.03 36.32,71.33 36.32,73.17 36.52,73.38 R934.2 ; v1(37.84,52.42) 37.48,52.42 37.13,52.07 37.13,51.41 37.26,51.27 LED10.C1
  S12 w0.127: v1(36.86,70.21) 36.48,69.82 36.47,69.82 36.29,69.64 36.29,65.06 36.03,64.81 36.03,63.92 37.21,62.74 37.21,55.26 37.84,54.63 v1(37.84,52.42)
  BOTTOM w0.127: v1(36.86,70.21) 36.35,70.72 v2(36.35,71.34)
P2_LED1_SFP28_G: length 246.6
  TOP w0.127: U9.C4 v4(192.55,197.58) ; R935.1 v1(38.9,75.03)
  S7 w0.127: v4(192.55,197.58) 192.59,197.58 193.13,198.12 193.13,199.9 190.31,202.72 181.12,202.72 174.05,195.65 174.05,186.58 168.16,180.69 168.16,179.09 166.27,177.2 166.27,176.21 159.71,169.64 158.28,169.64 156.71,168.07 156.71,165.36 151.79,160.45 137.6,160.45 127.14,149.99 115.37,149.99 109.86,144.47 109.86,142.14 108.85,141.14 98.51,141.14 95.44,138.06 88.8,138.06 85.98,140.88 80.27,140.88 69.82,130.43 69.82,95.68 62.78,88.64 52.51,88.64 v1(38.9,75.03)
  BOTTOM w0.127: v2(39.17,76.7) 38.9,76.42 v1(38.9,75.03)
P2_LED1_SFP28_G_R: length 30
  TOP w0.127: v1(37.63,51.76) 37.96,51.43 LED10.C2 ; v1(38.9,70.21) C664.1 38.52,71.03 38.39,71.15 38.39,73.31 38.45,73.38 R935.2
  S12 w0.127: v1(38.9,70.21) 38.42,70.69 37.66,70.69 37.38,70.41 37.38,69.42 37.3,69.34 37.3,63.55 37.75,63.1 37.75,57.35 38.5,56.61 38.5,52.22 38.04,51.76 v1(37.63,51.76)
  BOTTOM w0.127: v1(38.9,70.21) 39.37,70.68 39.37,73.25 v2(39.38,73.26)
P2_LED2_SFP28_B: length 337.4
  TOP w0.127: R1240.1 v1(37.82,69.18) ; v4(197.55,197.58) U9.C9
  S5 w0.127: v4(197.55,197.58) 198.52,198.54 198.52,200.45 195.8,203.17 180.69,203.17 171.54,194.02 171.54,193.27 170.73,192.45 147.16,192.45 146.91,192.2 103.14,192.2 98.01,197.33 59.17,197.33 59.04,197.21 58.9,197.21 55.09,193.4 55.09,183.92 53.8,182.63 39.03,182.63 34.3,177.9 20.59,177.9 15.54,172.85 15.54,167.85 13.34,165.64 13.34,159.38 17.22,155.5 17.22,150.32 19.35,148.2 19.35,140.07 18.34,139.07 18.34,138.61 17.87,138.14 17.87,135.72 16.51,134.36 16.51,114.29 13.6,111.38 13.6,110.41 12.84,109.65 12.84,108.35 13.63,107.57 13.63,102.38 15.28,100.73 15.28,95.7 15.41,95.57 15.41,92.32 19.14,88.59 19.14,86.38 29.27,76.25 32.4,76.25 37.38,71.27 37.38,69.63 v1(37.82,69.18)
  BOTTOM w0.127: v2(37.11,65.63) 37.3,65.82 37.3,68.67 v1(37.82,69.18)
P2_LED2_SFP28_B_R: length 15.3
  TOP w0.127: v1(37.99,56.41) 37.84,56.41 37.26,55.84 LED35.C1 ; R1240.2 37.48,67.53 37.27,67.33 37.27,65.36 37.45,65.18 C799.1 37.82,64.3 v1(37.81,64.3)
  S14 w0.127: v1(37.99,56.41) 37.81,56.59 v1(37.81,64.3)
  BOTTOM w0.127: v1(37.81,64.3) 37.81,63.09 v2(37.79,63.07)
P2_LED2_SFP28_G: length 336.6
  TOP w0.127: v4(199.55,197.58) U9.C10 ; R1241.1 v1(36.8,69.18)
  S5 w0.127: v1(36.8,69.18) 36.29,69.7 36.29,71.47 31.97,75.79 29,75.79 18.66,86.13 18.66,88.64 15.12,92.19 15.12,95.39 10.66,99.85 10.66,102.64 11.22,103.2 11.22,107.16 12.54,108.48 12.54,109.75 13.25,110.46 13.25,111.55 14.26,112.56 14.26,113.67 16.26,115.66 16.26,134.46 17.62,135.82 17.62,138.24 18.09,138.71 18.09,139.17 19.09,140.17 19.09,148.09 16.97,150.22 16.97,155.37 13.08,159.26 13.08,165.75 15.29,167.96 15.29,172.96 20.48,178.15 34.19,178.15 38.93,182.89 53.61,182.89 54.84,184.12 54.84,193.59 58.86,197.61 98.18,197.61 103.34,192.46 146.62,192.46 147.15,192.98 156.97,192.98 157.95,193.96 171.12,193.96 180.59,203.43 195.9,203.43 198.77,200.56 198.77,200.56 198.85,200.48 198.85,198.28 v4(199.55,197.58)
  BOTTOM w0.127: v1(36.8,69.18) 36.55,68.94 v2(36.55,67.78)
P2_LED2_SFP28_G_R: length 15.3
  TOP w0.127: v1(36.73,64.17) 36.8,64.24 C798.1 36.48,65.18 36.29,65.38 36.29,67.35 36.48,67.53 R1241.2 ; v1(37.79,55.6) 37.79,55.59 37.96,55.41 LED35.C2
  S14 w0.127: v1(37.79,55.6) 37.48,55.91 37.48,63.49 36.8,64.17 v1(36.73,64.17)
  BOTTOM w0.127: v1(36.73,64.17) 35.9,63.34 v2(35.9,63.32)
P02_LED_B_1: length 142.6
  TOP w0.127: R870.2 v1(196.05,80.55) ; v4(206.55,194.58) U9.F17
  S7 w0.127: v1(196.05,80.55) 192.13,84.48 192.13,129.38 198.22,135.47 198.22,142.72 199.99,144.5 211.73,144.5 214.08,146.85 214.08,150.7 215.55,152.17 215.55,159.04 216.84,160.33 216.84,187.36 209.13,195.07 207.04,195.07 v4(206.55,194.58)
  BOTTOM w0.127: v1(196.05,80.55) 195.42,79.92 v2(195.42,79.03)
P02_LED_B_2: length 170.8
  TOP w0.127: v1(214.15,87.54) 214.98,86.71 216,86.71 R875.2 ; v4(196.55,196.58) U9.D8
  S7 w0.127: v1(214.15,87.54) 214.15,89 213.06,90.09 207.74,90.09 198.78,99.04 198.78,102.97 196.15,105.6 196.15,114.34 201.39,119.57 201.39,122.53 204.44,125.58 204.44,130.21 205.9,131.67 208.94,131.67 209.83,132.56 211.86,132.56 217.29,137.99 217.29,142.5 219.39,144.59 219.39,146.66 221.23,148.5 221.23,196.29 216.25,201.27 210.15,201.27 207.99,203.43 205.01,203.43 204.12,202.54 200.83,202.54 198.29,200 198.29,197.61 197.78,197.1 197.41,197.1 196.89,196.58 v4(196.55,196.58)
  BOTTOM w0.127: v1(214.15,87.54) 214.28,87.41 v2(216.63,87.41)
P02_LED_G_1: length 145.6
  TOP w0.127: v4(203.55,194.58) U9.F14 ; R873.2 v1(195.04,80.62)
  S7 w0.127: v4(203.55,194.58) 204.08,194.05 209.77,194.05 216.57,187.25 216.57,160.57 215.23,159.23 215.23,152.37 213.67,150.82 213.67,147.34 211.22,144.88 198.15,144.88 197.51,144.24 197.51,142.59 196.56,141.64 196.56,134.72 191.84,129.99 191.84,83.82 v1(195.04,80.62)
  BOTTOM w0.127: v1(195.04,80.62) 193.81,79.39 v2(193.55,79.39)
P02_LED_G_2: length 163.7
  TOP w0.127: U9.C13 v4(202.55,197.58) ; R874.2 217.58,86.33 216.82,87.09 215.67,87.09 v1(214.85,87.92)
  S7 w0.127: v1(214.85,87.92) 214.85,87.48 213.83,86.46 209.1,86.46 202.75,92.81 197.83,92.81 196.94,93.7 196.94,102.33 195.01,104.26 195.01,128.39 200.79,134.16 208.6,134.16 212.44,138 212.44,139.63 217.56,144.75 217.56,146.45 220.08,148.97 220.08,195.21 217.14,198.16 203.13,198.16 v4(202.55,197.58)
  BOTTOM w0.127: v1(214.85,87.92) 214.85,88.36 v2(215.55,89.06)
P02_LED_R_1: length 151.2
  TOP w0.127: v4(195.55,186.58) U9.N7 ; v1(196.06,77.64) 196.05,77.63 R871.2
  S7 w0.127: v1(214.04,184.78) 214.91,183.91 214.91,162.33 211.1,158.53 211.1,156.95 207.89,153.74 207.89,147.88 206.81,146.8 196.83,146.8 194.34,144.31 194.34,143.1 193.97,142.74 192.98,142.74 191.79,141.55 191.79,139.84 190.47,138.52 190.47,132.43 189.07,131.04 189.07,82.2 192.18,79.09 194.61,79.09 v1(196.06,77.64)
  S9 w0.127: v1(214.04,184.78) 212.56,184.78 212.28,185.06 205.45,185.06 205.02,185.49 205.02,185.72 204.74,186 203.83,186 202.8,187.03 196.01,187.03 v4(195.55,186.58)
  BOTTOM w0.127: v2(215.04,184.69) 214.13,184.69 v1(214.04,184.78)
P02_LED_R_2: length 161.1
  TOP w0.127: R876.2 214.71,86.15 v1(214.47,86.4) ; U9.C12 v4(201.55,197.58)
  S7 w0.127: v4(201.55,197.58) 202.05,197.08 208.04,197.08 208.74,197.77 217.07,197.77 219.77,195.08 219.77,149.1 217.07,146.4 217.07,144.63 212.08,139.63 212.08,138.12 208.42,134.47 200.56,134.47 194.68,128.58 194.68,104.15 196.62,102.21 196.62,93.44 197.51,92.56 202.52,92.56 208.99,86.08 214.15,86.08 v1(214.47,86.4)
  BOTTOM w0.127: v2(213.94,85.72) 214.47,86.25 v1(214.47,86.4)
P02_R_LED_B_1: length 22.7
  TOP w0.127: LED5.C2 201.08,61.34 200.28,61.34 199.9,60.96 199.62,60.96 197.64,62.94 197.64,72.24 197.28,72.6 197.28,76.98 v1(196.82,77.44) 196.82,78 R870.1
  BOTTOM w0.127: v2(197.77,77.82) 197.2,77.82 v1(196.82,77.44)
P02_R_LED_B_2: length 30.7
  TOP w0.127: LED6.C2 220.25,60.87 v1(220.6,61.21) 221.33,61.94 221.33,69.21 217.51,73.03 217.51,83.73 216.56,84.68 R875.1
  BOTTOM w0.127: v2(222.15,62.65) 222.03,62.65 v1(220.6,61.21)
P02_R_LED_G_1: length 25.2
  TOP w0.127: R873.1 195.57,78.23 195.57,73.48 197.13,71.92 197.13,62.54 198.72,60.96 v1(198.72,60.81) 198.72,59.98 199.16,59.54 201.08,59.54 LED5.C3
  BOTTOM w0.127: v2(197.96,62.14) 197.96,61.57 v1(198.72,60.81)
P02_R_LED_G_2: length 31.3
  TOP w0.127: LED6.C3 218.53,60 219,60 219.57,60.58 220.47,60.58 v1(220.6,60.45) 220.73,60.45 221.83,61.56 221.83,69.16 217.76,73.24 217.76,84.43 217.58,84.61 R874.1
  BOTTOM w0.127: v1(220.6,60.45) 220.64,60.41 222.26,60.41 v2(222.34,60.49)
P02_R_LED_R_1: length 20
  TOP w0.127: LED5.C1 200.42,60.58 199.64,60.58 197.39,62.84 197.39,72.02 196.05,73.36 R871.1 196.32,75.97 v1(196.75,75.54)
  BOTTOM w0.127: v2(197.83,75.54) v1(196.75,75.54)
P02_R_LED_R_2: length 25.6
  TOP w0.127: v1(217.27,61.61) 217.67,61.2 LED6.C1 ; R876.1 v1(215.55,84.43)
  BOTTOM w0.127: v1(215.55,84.43) 215.48,84.36 v2(215.48,77.7) 217.68,75.5 217.68,62.02 v1(217.27,61.61)
P3_LED1_SFP28_B: length 331.2
  TOP w0.127: R936.1 v1(39.85,69.18) ; U9.A9 v4(197.55,199.58)
  S5 w0.127: v4(197.55,199.58) 197.55,200.53 196.94,201.14 194.78,201.14 193.26,202.66 180.9,202.66 172.43,194.19 172.43,192.38 170.86,190.8 142.63,190.8 141.88,191.55 102.94,191.55 99.06,195.43 84.17,195.43 83.85,195.74 58.45,195.74 55.74,193.03 55.74,183.86 53.99,182.1 39.22,182.1 34.51,177.39 20.8,177.39 16.05,172.64 16.05,167.64 14.58,166.17 14.58,158.97 17.73,155.82 17.73,150.53 19.85,148.41 19.85,139.86 19.17,139.17 19.17,136.29 17.02,134.15 17.02,114.05 14.27,111.3 14.27,102.46 15.99,100.73 15.99,92.61 19.92,88.68 19.92,86.75 29.63,77.04 32.87,77.04 35.41,74.5 36.93,74.5 38.4,73.02 38.4,72.22 39.43,71.2 39.43,69.63 39.85,69.21 v1(39.85,69.18)
  BOTTOM w0.127: v1(39.85,69.18) 39.72,69.05 v2(39.72,67.79)
P3_LED1_SFP28_B_R: length 15.7
  TOP w0.127: v1(40.71,56) 40.71,56 LED11.C1 ; v1(39.84,64.3) 39.85,64.3 C665.1 39.53,65.18 39.34,65.37 39.34,67.35 39.52,67.53 R936.2
  S14 w0.127: v1(39.84,64.3) 40.8,63.34 40.8,57.69 41.11,57.38 41.11,56.41 v1(40.71,56)
  BOTTOM w0.127: v2(40.35,63.03) 40.35,63.79 v1(39.84,64.3)
P3_LED1_SFP28_G: length 336.2
  TOP w0.127: R937.1 v1(38.83,69.18) ; U9.B9 v4(197.55,198.58)
  S5 w0.127: v4(197.55,198.58) 198.26,199.29 198.26,200.26 197.12,201.4 195.03,201.4 193.51,202.92 180.8,202.92 171.99,194.11 171.99,193.14 170.06,191.21 148.96,191.21 148.25,191.93 103.05,191.93 97.91,197.08 59.27,197.08 55.41,193.21 55.41,183.88 53.88,182.35 39.11,182.35 34.4,177.65 20.7,177.65 15.8,172.75 15.8,167.74 14.33,166.27 14.33,158.78 17.48,155.63 17.48,150.43 19.6,148.3 19.6,139.96 18.91,139.28 18.91,136.4 16.77,134.25 16.77,114.18 13.95,111.36 13.95,110.35 13.1,109.5 13.1,108.71 13.99,107.82 13.99,102.38 15.59,100.78 15.59,95.76 15.67,95.68 15.67,92.55 19.54,88.68 19.54,86.59 29.45,76.68 32.66,76.68 35.17,74.17 36.13,74.17 37.37,72.93 37.37,72.24 38.38,71.22 38.38,70.02 38.83,69.56 v1(38.83,69.18)
  BOTTOM w0.127: v1(38.83,69.18) 38.83,67.46 39.3,66.99 39.3,65.73 v2(39.27,65.69)
P3_LED1_SFP28_G_R: length 17.5
  TOP w0.127: LED11.C2 41.41,56.04 v1(40.63,56.82) ; v1(38.83,64.3) 38.83,64.3 C666.1 38.46,65.18 38.35,65.3 38.35,67.39 38.49,67.53 R937.2
  S14 w0.127: v1(38.83,64.3) 40.37,62.75 40.37,57.07 v1(40.63,56.82)
  BOTTOM w0.127: v1(38.83,64.3) 38.83,61.87 v2(39.14,61.55)
P3_LED2_SFP28_B: length 242.7
  TOP w0.127: U9.B4 v4(192.55,198.58) ; R1242.1 v1(39.91,75.03)
  S7 w0.127: v4(192.55,198.58) 192.04,199.09 192.04,199.97 189.65,202.36 181.27,202.36 174.49,195.58 174.49,186.29 168.52,180.31 168.52,178.94 166.6,177.02 166.6,176.11 159.82,169.33 158.4,169.33 157.83,168.75 157.83,167.1 157.31,166.58 157.31,165.58 151.91,160.18 138.03,160.18 127.47,149.63 115.59,149.63 110.18,144.22 110.18,142.01 108.98,140.82 98.64,140.82 95.57,137.74 88.67,137.74 85.85,140.56 80.4,140.56 70.07,130.23 70.07,95.58 62.88,88.39 53.27,88.39 v1(39.91,75.03)
  BOTTOM w0.127: v1(39.91,75.03) 40.95,76.06 v2(40.97,76.06)
P3_LED2_SFP28_B_R: length 26.8
  TOP w0.127: LED36.C1 40.71,51.68 40.43,51.97 v1(40.43,52.37) ; R1242.2 39.53,73.38 39.4,73.25 39.4,71.09 39.47,71.03 C801.1 v1(39.91,70.21)
  S12 w0.127: v1(39.91,70.21) 39.36,69.66 39.36,61.34 38.47,60.45 38.47,57.71 39.39,56.79 39.39,56.18 40.43,55.14 v1(40.43,52.37)
  BOTTOM w0.127: v2(40.61,71.73) 39.91,71.03 v1(39.91,70.21)
P3_LED2_SFP28_G: length 245.8
  TOP w0.127: v4(193.55,199.58) U9.A5 ; R1243.1 v1(37.88,75.03)
  S7 w0.127: v4(193.55,199.58) 193.55,199.88 190.34,203.1 181.11,203.1 172.3,194.29 172.3,185.43 167.88,181.01 167.88,179.19 165.48,176.79 165.48,175.84 164.05,174.41 162.18,174.41 160.75,172.97 160.75,171.36 159.41,170.03 158.22,170.03 156.35,168.16 156.35,165.5 151.61,160.75 137,160.75 127.14,150.9 115.76,150.9 108.96,144.09 100.3,144.09 94.66,138.45 88.8,138.45 86.08,141.17 80.08,141.17 69.49,130.58 69.49,95.79 64.01,90.31 53.53,90.31 50.36,87.15 50,87.15 v1(37.88,75.03)
  BOTTOM w0.127: v4(193.55,199.58) 193.55,199.58 v2(193.55,200.75) ; v2(37.49,75.79) 37.88,75.4 v1(37.88,75.03)
P3_LED2_SFP28_G_R: length 27.3
  TOP w0.127: R1243.2 37.54,73.38 37.4,73.23 37.4,71.2 37.57,71.03 C800.1 v1(37.88,70.21) ; v1(41.16,52.07) 41.41,51.82 LED36.C2
  S12 w0.127: v1(37.88,70.21) 37.88,69.93 38.29,69.52 38.29,63.75 38.17,63.62 38.17,57.5 38.95,56.72 38.95,56.23 40.1,55.09 40.1,53.36 39.94,53.21 39.94,52.04 40.12,51.86 40.96,51.86 v1(41.16,52.07)
  BOTTOM w0.127: v2(38.26,71.41) 37.88,71.03 v1(37.88,70.21)
P03_LED_B_1: length 170.6
  TOP w0.127: v4(199.55,196.58) U9.D10 ; R879.2 216.56,89.76 216.4,89.92 215.01,89.92 v1(213.26,88.17)
  S7 w0.127: v1(213.26,88.17) 212.54,88.9 207.7,88.9 203.02,93.57 198.28,93.57 197.96,93.89 197.96,102.65 195.52,105.09 195.52,114.62 200.69,119.79 200.69,130.95 202.23,132.49 208.11,132.49 210.9,135.28 213.43,135.28 216.14,137.99 216.14,142.45 218.3,144.6 218.3,146.4 220.59,148.69 220.59,195.6 216.04,200.15 204.44,200.15 204.03,199.74 203.36,199.74 202.95,200.15 199.38,200.15 199.13,199.9 199.13,197 v4(199.55,196.58)
  BOTTOM w0.127: v2(211.71,89.66) 211.78,89.66 v1(213.26,88.17)
P03_LED_B_2: length 140
  TOP w0.127: R883.2 v1(194.02,80.62) ; v4(207.55,193.58) U9.G18
  S7 w0.127: v4(207.55,193.58) 209.79,193.58 216.29,187.07 216.29,160.87 214.72,159.29 214.72,154.47 213.12,152.87 213.12,147.42 210.99,145.29 198.05,145.29 197.2,144.43 197.2,142.63 196.31,141.75 196.31,140.37 193.32,137.38 193.32,132.56 191.45,130.69 191.45,83.7 194.02,81.13 v1(194.02,80.62)
  BOTTOM w0.127: v2(208.71,194.4) 208.37,194.4 v4(207.55,193.58)
P03_LED_G_1: length 167
  TOP w0.127: v4(197.55,196.58) U9.D9 ; R878.2 217.58,89.7 216.94,90.33 214.28,90.33 v1(213.07,89.13)
  S7 w0.127: v4(197.55,196.58) 197.86,196.58 198.69,197.42 198.69,199.92 199.84,201.07 202.44,201.07 202.8,201.43 209.63,201.43 210.36,200.7 216,200.7 220.9,195.8 220.9,148.56 218.85,146.52 218.85,144.56 216.56,142.28 216.56,137.77 211.8,133 209.64,133 208.82,132.18 205.45,132.18 203.86,130.59 203.86,125.58 201.01,122.72 201.01,119.73 195.82,114.55 195.82,105.42 198.34,102.91 198.34,98.68 207.44,89.59 212.61,89.59 v1(213.07,89.13)
  BOTTOM w0.127: v2(213.62,89.69) 213.61,89.69 213.61,89.67 v1(213.07,89.13)
P03_LED_G_2: length 144.6
  TOP w0.127: U9.N13 v4(202.55,186.58) ; R882.2 195.04,77.63 v1(195.05,77.64)
  S7 w0.127: v1(195.05,77.64) 193.98,78.71 192.05,78.71 188.71,82.06 188.71,131.12 190.15,132.56 190.15,138.72 191.51,140.08 191.51,141.81 192.82,143.12 193.78,143.12 193.96,143.29 193.96,144.37 196.74,147.16 206.81,147.16 207.17,147.51 207.17,148.78 206.71,149.23 206.71,154.77 214.6,162.66 214.6,183.44 v1(214.01,184.02)
  S9 w0.127: v4(202.55,186.58) 203.04,186.09 203.04,184.48 203.42,184.1 213.93,184.1 v1(214.01,184.02)
  BOTTOM w0.127: v1(214.01,184.02) 214.72,183.31 v2(214.72,182.6)
P03_LED_R_1: length 168.3
  TOP w0.127: v1(213.2,87.28) 215.05,89.14 R880.2 ; U9.D11 v4(200.55,196.58)
  S7 w0.127: v1(213.2,87.28) 212.69,86.78 209.33,86.78 202.98,93.13 197.89,93.13 197.45,93.57 197.45,102.52 195.27,104.71 195.27,128.28 200.05,133.06 200.83,133.06 201.21,132.69 201.79,132.69 202.12,133.02 208.02,133.02 210.71,135.71 213.3,135.71 215.8,138.2 215.8,142.46 217.93,144.59 217.93,146.43 220.34,148.84 220.34,195.4 216.6,199.13 200.27,199.13 200.02,198.88 200.02,197.11 v4(200.55,196.58)
  BOTTOM w0.127: v2(212.09,86.18) 212.1,86.18 v1(213.2,87.28)
