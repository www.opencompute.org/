# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Nets (continued)
P22_LED1_SFP+_G_R: C630.1 LED30.C1 R911.2
P22_LED2_SFP+_A: R1280.1 U9.L13(IO_3_L13/DIFFIO_R19N)
P22_LED2_SFP+_A_R: C839.1 LED55.C2 R1280.2
P22_LED2_SFP+_G: R1281.1 U9.K18(IO_3_K18/DIFFIO_R17N)
P22_LED2_SFP+_G_R: C838.1 LED55.C1 R1281.2
P23_LED1_SFP+_A: R912.1 U9.L14(IO_3_L14/DIFFIO_R20N)
P23_LED1_SFP+_B_R: C631.1 LED31.C2 R912.2
P23_LED1_SFP+_G: R913.1 U9.K14(IO_3_K14/DIFFIO_R17P)
P23_LED1_SFP+_G_R: C632.1 LED31.C1 R913.2
P23_LED2_SFP+_A: R1282.1 U9.J15(IO_3_J15/DIFFIO_R15P)
P23_LED2_SFP+_A_R: C841.1 LED56.C2 R1282.2
P23_LED2_SFP+_G: R1283.1 U9.J14(IO_3_J14/DIFFIO_R16P)
P23_LED2_SFP+_G_R: C840.1 LED56.C1 R1283.2
P24_LED1_SFP+_A: R914.1 U9.H15(IO_3_H15/DIFFIO_R11P)
P24_LED1_SFP+_B_R: C635.1 LED32.C2 R914.2
P24_LED1_SFP+_G: R915.1 U9.H16(IO_3_H16/DIFFIO_R10N)
P24_LED1_SFP+_G_R: C636.1 LED32.C1 R915.2
P24_LED2_SFP+_A: R1285.1 U9.H17(IO_3_H17/DIFFIO_R13N)
P24_LED2_SFP+_A_R: C843.1 LED57.C2 R1285.2
P24_LED2_SFP+_G: R1284.1 U9.G17(IO_3_G17/DIFFIO_R11N)
P24_LED2_SFP+_G_R: C842.1 LED57.C1 R1284.2
P_STACKING_SYNC_N0: CB1104.2 LB97.2 RB1237.1 U88.7(B)
P_STACKING_SYNC_N1: CB1106.2 LB99.2 RB1239.1 U87.7(B)
P_STACKING_SYNC_N2: CB1109.2 LB101.2 RB1248.1 U86.7(B)
P_STACKING_SYNC_N3: CB1111.2 LB103.2 RB1250.1 U85.7(B)
P_STACKING_SYNC_P0: CB1103.1 LB96.2 RB1236.1 U88.6(A)
P_STACKING_SYNC_P1: CB1105.2 LB98.2 RB1238.1 U87.6(A)
P_STACKING_SYNC_P2: CB1108.1 LB100.2 RB1247.1 U86.6(A)
P_STACKING_SYNC_P3: CB1110.2 LB102.2 RB1249.1 U85.6(A)
PCA9548_A0_CPU0: R168.1 R169.2 U10.1(A0)
PCA9548_A0_CPU1: RB742.2 RB745.1 UB17.1(A0)
PCA9548_A1_CPU0: R184.1 R185.2 U10.2(A1)
PCA9548_A1_CPU1: RB743.2 RB746.1 UB17.2(A1)
PCA9548_A2_CPU0: R189.1 R190.2 U10.21(A2)
PCA9548_A2_CPU1: RB708.1 RB714.2 UB17.21(A2)
PCB_VER_1: P1.M19(IO_B5_M19/DIFFIO_R26N/DQ1R) RB34.1 RB35.1
PCB_VER_2: P1.N19(IO_B5_N19/DIFFIO_R30P/DQS1R/CQ1) RB32.1 RB33.1
PCB_VER_3: P1.R16(IO_B5_R16/DIFFIO_R49P/DQS5R/CQ5) RB30.1 RB31.1
PCIE_PVDD10: C383.1 C403.1 CB557.1 L41.1 U40.W37(PCIE_PVDD1P0)
PCIE_TRDD10: C427.1 C438.1 CB574.1 CB598.1 CB603.1 CB604.1 L42.1 U40.U36(PCIE_TVDD1P0#1) U40.U37(PCIE_TVDD1P0#2) U40.V34(PCIE_RVDD1P0#1) U40.V35(PCIE_RVDD1P0#2)
PEX_CPU_PCIEA_RX_0_C_N: C415.2 U40.T36(PCIE_TX0_N)
PEX_CPU_PCIEA_RX_0_C_P: C413.2 U40.T37(PCIE_TX0_P)
PEX_CPU_PCIEA_RX_0_N: C415.1 J2.B69(PCIE_RX0-)
PEX_CPU_PCIEA_RX_0_P: C413.1 J2.B68(PCIE_RX0+)
PHY_COL: R1070.1 U52.B6(COL)
PHY_RST_N: R1047.2 R1048.2 U52.K3(RESET#)
PHY_RST_N_R: P1.R21(IO_B5_R21/DIFFIO_R39N) R1048.1
PHY_TCK: R423.1 U52.L9(TCK)
PHY_TCK_R: R423.2 U20.12(1Y4)
PHY_TDI: R327.1 U52.L7(TDI)
PHY_TDI_R: R327.2 U19.1(B1)
PHY_TDO: R846.1 U40.AH33(JTAG_TDI)
PHY_TDO_R: R846.2 U52.K8(TDO)
PHY_TMS: R380.1 U52.L8(TMS)
PHY_TMS_R: R380.2 U20.3(2Y4)
PHY_TRST_N: R953.2 RB287.2 U52.M9(TRST#)
PM_VDDQ_EN_R: C47.1 R64.1 R66.1 R70.1 U6.7(EN)
POWER_RST: R65.2 R84.2 U7.23(FPWM7/GPIO11)
POWER_RST_S: P1.L16(IO_B5_L16/DIFFIO_R27N) R84.1
PS1_12V_PG: CONN5.11 P1.C8(IO_B8_C8/DIFFIO_T12N)
PS1_AC_ALERT: CONN5.15 P1.C1(IO_B8_C1/DIFFIO_T11N/DM5T/BWS#5)
PS1_ON: CONN5.9 P1.D8(IO_B8_D8/DIFFIO_T12P)
PS1_PRESENT: CONN5.13 P1.E8(IO_B8_E8/DIFFIO_T8N/DQ3T)
PS2_12V_PG: CONN5.12 P1.D5(IO_B8_D5/DIFFIO_T6N/DQ3T)
PS2_AC_ALERT: CONN5.16 P1.C4(IO_B8_C4/DIFFIO_T9P/DQ3T)
PS2_ON: CONN5.10 P1.E5(IO_B8_E5/DIFFIO_T6P/DQS1T/CQ1T#)
PS2_PRESENT: CONN5.14 P1.E6(IO_B8_E6/DIFFIO_T4P/DQ3T)
PSU1_A: P1.M17(IO_B5_M17/DIFFIO_R32N) RB723.2
PSU1_A_R: CB977.2 LEDB9.C1 RB723.1
PSU1_G: P1.Y11(IO_B3_Y11/DIFFIO_B15N/DQ5B) RB732.2
PSU1_G_R: CB978.2 LEDB9.C2 RB732.1
PSU1_SCL: CONN5.17 RB674.1
PSU1_SCL_R: RB674.2 RB675.2 UB16.11(SC3)
PSU1_SDA: CONN5.19 RB680.1
PSU1_SDA_R: RB680.2 RB681.2 UB16.10(SD3)
PSU2_A: P1.L13(IO_B5_L13/DIFFIO_R31N) RB733.2
PSU2_A_R: CB979.2 LEDB10.C1 RB733.1
PSU2_G: P1.F22(IO_B6_F22/DIFFIO_R16N/DQ0R) RB734.2
PSU2_G_R: CB980.2 LEDB10.C2 RB734.1
PSU2_SCL: CONN5.18 RB690.1
PSU2_SCL_R: RB690.2 RB691.2 UB16.9(SC2)
PSU2_SDA: CONN5.20 RB699.1
PSU2_SDA_R: RB699.2 RB700.2 UB16.8(SD2)
PSU_MONITOR_RESET_N: P1.C22(IO_B6_C22/DIFFIO_R12P) UB16.3(R\E\S\E\T\)
PSU_MONITOR_SCL: R245.1 UB16.22(SCL)
PSU_MONITOR_SCL_R: R245.2 R246.2 U10.7(SC1)
PSU_MONITOR_SDA: R227.1 RB731.2
PSU_MONITOR_SDA_R: R227.2 R228.2 U10.6(SD1)
PUC5_I2C_ADD_0: R584.1 R585.2 U40.AF33(PUC_05_I2C_ADD_0)
PUC6_I2C_ADD_1: R658.1 R659.2 U40.AE32(PUC_06_I2C_ADD_1)
PUC_00: R631.1 R632.2 U40.AF37(PUC_00_CORE_PLL_FREQ_0)
PUC_01: R563.1 R564.2 U40.AG37(PUC_01_CORE_PLL_FREQ_1)
PUC_02: R575.1 R576.2 U40.AF32(PUC_02_CORE_PLL_FREQ_2)
PUC_03: R595.1 R596.2 U40.AG32(PUC_03_CORE_PLL_FREQ_3)
PUC_04: R617.1 U40.AE34(PUC_04)
PUC_07: R637.1 U40.AD33(PUC_07_PCIE_DIS)
PUC_08: R606.1 U40.AF34(PUC_08)
PUC_09: R582.1 U40.AF35(PUC_09)
PUC_10: R652.1 R653.2 U40.AE33(PUC_10)
PUC_11: R619.1 R620.2 U40.AF36(PUC_11)
PWR_OK: P1.V7(IO_B3_V7/PLL6_CLKOUTN) R1500.2
QSFP1_R: CB1096.1 CB1097.1 LB93.2 LB94.2 LB95.2 PTCB3.1
QSFP2_R: CB918.1 CB920.1 LB67.2 LB68.2 LB69.2 PTCB2.1
QSFP3_R: CB917.1 CB919.1 LB62.2 LB63.2 LB64.2 PTCB1.1
QSFP_INT_P01: P1.U22(IO_B5_U22/DIFFIO_R40N) RB1222.1
QSFP_INT_P01_R: RB1222.2 RB1223.2 U69.28(INT#)
QSFP_INT_P02: P1.C20(IO_B6_C20/DIFFIO_R8N) RB308.1
QSFP_INT_P02_R: CONN53_PF.1T28(INT#_1T) RB308.2 RB309.2
QSFP_INT_P03: P1.C19(IO_B6_C19/DIFFIO_R8P/DQ2R) RB311.1
QSFP_INT_P03_R: CONN53_PF.1B28(INT#_1B) RB311.2 RB312.2
QSFP_MODE_P01: P1.T19(IO_B5_T19/DIFFIO_R42P) U69.31(LPMODE)
QSFP_MODE_P02: CONN53_PF.1T31(LPMODE_1T) P1.R20(IO_B5_R20/DIFFIO_R39P/DM1R/BWS#)
QSFP_MODE_P03: CONN53_PF.1B31(LPMODE_1B) P1.P22(IO_B5_P22/DIFFIO_R33N/DQ1R)
QSFP_P01_SCL: RB655.1 RB1224.1 U69.11(SCL)
QSFP_P01_SCL_R: RB655.2 RB656.2 UB17.11(SC3)
QSFP_P01_SDA: RB665.1 RB1225.1 U69.12(SDA)
QSFP_P01_SDA_R: RB665.2 RB666.2 UB17.10(SD3)
QSFP_P02_SCL: CONN53_PF.1T11(SCL_1T) RB326.1 RB703.1
QSFP_P02_SCL_R: RB697.2 RB703.2 UB17.14(SC4)
QSFP_P02_SDA: CONN53_PF.1T12(SDA_1T) RB327.1 RB679.1
QSFP_P02_SDA_R: RB679.2 RB689.2 UB17.13(SD4)
QSFP_P03_SCL: CONN53_PF.1B11(SCL_1B) RB330.1 RB1242.1
QSFP_P03_SCL_R: RB1242.2 RB1244.2 UB17.16(SC5)
QSFP_P03_SDA: CONN53_PF.1B12(SDA_1B) RB331.1 RB1243.1
QSFP_P03_SDA_R: RB1243.2 RB1245.2 UB17.15(SD5)
QSFP_PRSNT_P01: P1.A20(IO_B6_A20/DIFFIO_R7N) RB1227.1 U69.27(MODPRSNT#)
QSFP_PRSNT_P02: CONN53_PF.1T27(MODPRSNT#_1T) P1.B19(IO_B6_B19/DIFFIO_R7P/DQ2R) RB310.1
QSFP_PRSNT_P03: CONN53_PF.1B27(MODPRSNT#_1B) P1.V22(IO_B5_V22/DIFFIO_R40P/DQS3R/CQ3) RB313.1
QSFP_RST_P01_N: P1.A22(IO_B6_A22/DIFFIO_R11N) RB1228.1 U69.9(RESET#)
QSFP_RST_P02_N: CONN53_PF.1T9(RESET#_1T) P1.D22(IO_B6_D22/DIFFIO_R14N) RB323.1
QSFP_RST_P03_N: CONN53_PF.1B9(RESET#_1B) P1.R22(IO_B5_R22/DIFFIO_R33P) RB328.1
QSFP_SEL_P01: RB1226.1 U69.8(MODSEL#)
QSFP_SEL_P02: CONN53_PF.1T8(MODSEL#_1T) RB332.1
QSFP_SEL_P03: CONN53_PF.1B8(MODSEL#_1B) RB329.1
QSP01_P02_A0: RB728.1 RB729.2 UB16.1(A0)
QSP01_P02_A1: RB739.1 RB740.2 UB16.2(A1)
QSP01_P02_A2: RB730.2 RB741.1 UB16.21(A2)
QSP01_P02_R_SDA: RB731.1 UB16.23(SDA)
RESCAL0: RB208.2 U40.N27(RES_CAL0)
RESCAL1: RB207.2 U40.N11(RES_CAL1)
RESET_BUTTON_RST: CB973.2 DB7.A P1.AA13(IO_B4_AA13/DIFFIO_B21P) RB727.2 SWB1.1
RESET_MAC88470: J2.B54(GPO1) P1.E17(IO_B7_E17/DIFFIO_T36P) R1492.2
RJ_STACKING_SYNC_N0: RB1237.2 RB1240.1 RJ1.B2
RJ_STACKING_SYNC_N1: RB1239.2 RB1241.2 RJ1.B4
RJ_STACKING_SYNC_N2: RB1246.1 RB1248.2 RJ1.B6
RJ_STACKING_SYNC_N3: RB1250.2 RB1251.2 RJ1.B8
RJ_STACKING_SYNC_P0: RB1236.2 RB1240.2 RJ1.B1
RJ_STACKING_SYNC_P1: RB1238.2 RB1241.1 RJ1.B3
RJ_STACKING_SYNC_P2: RB1246.2 RB1247.2 RJ1.B5
RJ_STACKING_SYNC_P3: RB1249.2 RB1251.1 RJ1.B7
RJ_UART_RX: R205.2 RB318.2
RLOS_FPGA: P1.AB20(IO_B4_AB20/DIFFIO_B34N/DQS0B/CQ) R414.1
RLOS_FPGA_R: R333.1 R414.2
RS0_01: CONN54_PF.1T7(RS0#1T7) RB340.1 RB416.1
RS0_02: CONN54_PF.1L7(RS0#1L7) RB338.1 RB414.1
RS0_03: CONN54_PF.2T7(RS0#2T7) RB344.1 RB420.1
RS0_04: CONN54_PF.2L7(RS0#2L7) RB342.1 RB418.1
RS0_05: CONN54_PF.3T7(RS0#3T7) RB348.1 RB388.1
RS0_06: CONN54_PF.3L7(RS0#3L7) RB346.1 RB386.1
RS0_07: CONN54_PF.4T7(RS0#4T7) RB352.1 RB392.1
RS0_08: CONN54_PF.4L7(RS0#4L7) RB350.1 RB390.1
RS0_09: CONN54_PF.5T7(RS0#5T7) RB356.1 RB396.1
RS0_10: CONN54_PF.5L7(RS0#5L7) RB354.1 RB394.1
RS0_11: CONN54_PF.6T7(RS0#6T7) RB360.1 RB400.1
RS0_12: CONN54_PF.6L7(RS0#6L7) RB358.1 RB398.1
RS0_13: CONN55_PF.1T7(RS0#1T7) RB364.1 RB424.1
RS0_14: CONN55_PF.1L7(RS0#1L7) RB362.1 RB422.1
RS0_15: CONN55_PF.2T7(RS0#2T7) RB368.1 RB428.1
RS0_16: CONN55_PF.2L7(RS0#2L7) RB366.1 RB426.1
RS0_17: CONN55_PF.3T7(RS0#3T7) RB372.1 RB432.1
RS0_18: CONN55_PF.3L7(RS0#3L7) RB370.1 RB430.1
RS0_19: CONN55_PF.4T7(RS0#4T7) RB376.1 RB404.1
RS0_20: CONN55_PF.4L7(RS0#4L7) RB374.1 RB402.1
RS0_21: CONN55_PF.5T7(RS0#5T7) RB380.1 RB408.1
RS0_22: CONN55_PF.5L7(RS0#5L7) RB378.1 RB406.1
RS0_23: CONN55_PF.6T7(RS0#6T7) RB384.1 RB412.1
RS0_24: CONN55_PF.6L7(RS0#6L7) RB382.1 RB410.1
RS1_01: CONN54_PF.1T9(RS1#1T9) RB339.1 RB415.1
RS1_02: CONN54_PF.1L9(RS1#1L9) RB337.1 RB413.1
RS1_03: CONN54_PF.2T9(RS1#2T9) RB343.1 RB419.1
RS1_04: CONN54_PF.2L9(RS1#2L9) RB341.1 RB417.1
RS1_05: CONN54_PF.3T9(RS1#3T9) RB347.1 RB387.1
RS1_06: CONN54_PF.3L9(RS1#3L9) RB345.1 RB385.1
RS1_07: CONN54_PF.4T9(RS1#4T9) RB351.1 RB391.1
RS1_08: CONN54_PF.4L9(RS1#4L9) RB349.1 RB389.1
RS1_09: CONN54_PF.5T9(RS1#5T9) RB355.1 RB395.1
RS1_10: CONN54_PF.5L9(RS1#5L9) RB353.1 RB393.1
RS1_11: CONN54_PF.6T9(RS1#6T9) RB359.1 RB399.1
RS1_12: CONN54_PF.6L9(RS1#6L9) RB357.1 RB397.1
RS1_13: CONN55_PF.1T9(RS1#1T9) RB363.1 RB423.1
RS1_14: CONN55_PF.1L9(RS1#1L9) RB361.1 RB421.1
RS1_15: CONN55_PF.2T9(RS1#2T9) RB367.1 RB427.1
RS1_16: CONN55_PF.2L9(RS1#2L9) RB365.1 RB425.1
RS1_17: CONN55_PF.3T9(RS1#3T9) RB371.1 RB431.1
RS1_18: CONN55_PF.3L9(RS1#3L9) RB369.1 RB429.1
RS1_19: CONN55_PF.4T9(RS1#4T9) RB375.1 RB403.1
RS1_20: CONN55_PF.4L9(RS1#4L9) RB373.1 RB401.1
RS1_21: CONN55_PF.5T9(RS1#5T9) RB379.1 RB407.1
RS1_22: CONN55_PF.5L9(RS1#5L9) RB377.1 RB405.1
RS1_23: CONN55_PF.6T9(RS1#6T9) RB383.1 RB411.1
RS1_24: CONN55_PF.6L9(RS1#6L9) RB381.1 RB409.1
RST_T: R854.2 TP51.1 U52.M2(RSET)
RTC_BAT_R: D9.C J5.1
RXLOS_01: CONN54_PF.1T8(RX_LOS#1T8) RB528.1 U9.D6(IO_2_D6/DIFFIO_T3N)
RXLOS_02: CONN54_PF.1L8(RX_LOS#1L8) RB526.1 U9.A8(IO_2_A8/DIFFIO_T11N)
RXLOS_03: CONN54_PF.2T8(RX_LOS#2T8) RB531.1 U9.F4(IO_1_F4/DIFFIO_L7P)
RXLOS_04: CONN54_PF.2L8(RX_LOS#2L8) RB529.1 U9.B1(IO_2_B1/DIFFIO_T1P)
RXLOS_05: CONN54_PF.3T8(RX_LOS#3T8) RB507.1 U9.H6(IO_1_H6/DIFFIO_L15N)
RXLOS_06: CONN54_PF.3L8(RX_LOS#3L8) RB505.1 U9.J1(IO_1_J1/DIFFIO_L15P)
RXLOS_07: CONN54_PF.4T8(RX_LOS#4T8) RB510.1 U9.L6(IO_1_L6/DIFFIO_L19P)
RXLOS_08: CONN54_PF.4L8(RX_LOS#4L8) RB508.1 U9.K5(IO_1_K5)
RXLOS_09: CONN54_PF.5T8(RX_LOS#5T8) RB513.1 U9.F7(IO_2_F7/DIFFIO_T5N)
RXLOS_10: CONN54_PF.5L8(RX_LOS#5L8) RB511.1 U9.M4(IO_1_M4/DIFFIO_L24P)
RXLOS_11: CONN54_PF.6T8(RX_LOS#6T8) RB516.1 U9.M5(IO_1_M5/DIFFIO_L23P)
RXLOS_12: CONN54_PF.6L8(RX_LOS#6L8) RB514.1 U9.P4(IO_1_P4)
RXLOS_13: CONN55_PF.1T8(RX_LOS#1T8) RB534.1 U9.R9(IO_4_R9/DIFFIO_B13P)
RXLOS_14: CONN55_PF.1L8(RX_LOS#1L8) RB532.1 U9.U9(IO_4_U9/DIFFIO_B13N)
RXLOS_15: CONN55_PF.2T8(RX_LOS#2T8) RB537.1 U9.T14(IO_4_T14/DIFFIO_B22P)
RXLOS_16: CONN55_PF.2L8(RX_LOS#2L8) RB535.1 U9.P9(IO_4_P9/DIFFIO_B12P)
RXLOS_17: CONN55_PF.3T8(RX_LOS#3T8) RB540.1 U9.N16(IO_3_N16/DIFFIO_R25N)
RXLOS_18: CONN55_PF.3L8(RX_LOS#3L8) RB538.1 U9.P15(IO_3_P15/DIFFIO_R30N)
RXLOS_19: CONN55_PF.4T8(RX_LOS#4T8) RB519.1 U9.D14(IO_2_D14/DIFFIO_T26P)
RXLOS_20: CONN55_PF.4L8(RX_LOS#4L8) RB517.1 U9.L18(IO_3_L18/DIFFIO_R19P)
RXLOS_21: CONN55_PF.5T8(RX_LOS#5T8) RB522.1 U9.F18(IO_3_F18/DIFFIO_R10P)
RXLOS_22: CONN55_PF.5L8(RX_LOS#5L8) RB520.1 U9.J18(IO_3_J18/DIFFIO_R16N)
RXLOS_23: CONN55_PF.6T8(RX_LOS#6T8) RB525.1 U9.B18(IO_2_B18/DIFFIO_T26N)
RXLOS_24: CONN55_PF.6L8(RX_LOS#6L8) RB523.1 U9.C11(IO_2_C11/DIFFIO_T18P)
RXSCLK_SET: P1.A12(IO_B7_A12/DIFFIO_T22P) R1131.1
SATA0_RX_N: J2.A20(SATA0_RX-) J3.43(PETP0/SATA_BN)
SATA0_RX_P: J2.A19(SATA0_RX+) J3.41(PETN0/SATA_BP)
SATA0_TX_N: J2.A17(SATA0_TX-) J3.47(PERN0/SATA_AN)
SATA0_TX_P: J2.A16(SATA0_TX+) J3.49(PERP0/SATA_AP)
SCREW1: C28.1 C30.1 C33.1 C34.1 H4.1 H4.2 H4.3 H4.4 H4.5 H4.6 H4.7 H4.8
SCREW2: C214.1 C215.1 C250.1 C263.1 H5.1 H5.2 H5.3 H5.4 H5.5 H5.6 H5.7 H5.8
SCREW3: C2.1 C3.1 C7.1 C8.1 H2.1 H2.2 H2.3 H2.4 H2.5 H2.6 H2.7 H2.8
SCREW4: C217.1 C218.1 C247.1 C259.1 H6.1 H6.2 H6.3 H6.4 H6.5 H6.6 H6.7 H6.8
SCREW5: C219.1 C220.1 C248.1 C260.1 H7.1 H7.2 H7.3 H7.4 H7.5 H7.6 H7.7 H7.8
SCREW6: C4.1 C9.1 C38.1 C39.1 H3.1 H3.2 H3.3 H3.4 H3.5 H3.6 H3.7 H3.8
SCREW7: C303.1 C304.1 C341.1 C347.1 H8.1 H8.2 H8.3 H8.4 H8.5 H8.6 H8.7 H8.8
SCREW8: C342.1 C343.1 C420.1 C421.1 H10.1 H10.2 H10.3 H10.4 H10.5 H10.6 H10.7 H10.8
SCREW9: C344.1 C345.1 C422.1 C423.1 H11.1 H11.2 H11.3 H11.4 H11.5 H11.6 H11.7 H11.8
SCREW10: C997.1 C998.1 C999.1 C1000.1 H25.1 H25.2 H25.3 H25.4 H25.5 H25.6 H25.7 H25.8
SCREW11: C485.1 C486.1 C516.1 C521.1 H12.1 H12.2 H12.3 H12.4 H12.5 H12.6 H12.7 H12.8
SCREW12: C523.1 C524.1 C544.1 C549.1 H15.1 H15.2 H15.3 H15.4 H15.5 H15.6 H15.7 H15.8
SCREW14: C724.1 C725.1 C735.1 C736.1 H17.1 H17.2 H17.3 H17.4 H17.5 H17.6 H17.7 H17.8
SCREW15: C24.1 C27.1 H1.1 H1.2 H1.3 H1.4 H1.5 H1.6 H1.7 H1.8
SCREW16: C1001.1 C1002.1 C1003.1 C1004.1 H26.1 H26.2 H26.3 H26.4 H26.5 H26.6 H26.7 H26.8
SCREW17: C993.1 C994.1 C995.1 C996.1 H24.1 H24.2 H24.3 H24.4 H24.5 H24.6 H24.7 H24.8
SCREW18: C960.1 C961.1 C962.1 C963.1 H18.1 H18.2 H18.3 H18.4 H18.5 H18.6 H18.7 H18.8
SCREW19: C964.1 C965.1 C966.1 C967.1 H19.1 H19.2 H19.3 H19.4 H19.5 H19.6 H19.7 H19.8
SCREW20: C968.1 C969.1 C970.1 C971.1 H20.1 H20.2 H20.3 H20.4 H20.5 H20.6 H20.7 H20.8
SCREW21: C972.1 C973.1 C974.1 C975.1 H21.1 H21.2 H21.3 H21.4 H21.5 H21.6 H21.7 H21.8
SCREW22: C976.1 C977.1 C978.1 C979.1 H22.1 H22.2 H22.3 H22.4 H22.5 H22.6 H22.7 H22.8
SCREW23: C980.1 C981.1 C982.1 C983.1 H23.1 H23.2 H23.3 H23.4 H23.5 H23.6 H23.7 H23.8
SFP+_P01_SCL: CONN54_PF.1T5(SCL#1T5) RB456.1 RB640.1
SFP+_P01_SCL_R: RB640.2 RB641.2 UB13.5(SC0)
SFP+_P01_SDA: CONN54_PF.1T4(SDA#1T4) RB492.1 RB650.1
SFP+_P01_SDA_R: RB650.2 RB651.2 UB13.4(SD0)
SFP+_P02_SCL: CONN54_PF.1L5(SCL#1L5) RB527.1 RB622.1
SFP+_P02_SCL_R: RB622.2 RB623.2 UB13.7(SC1)
SFP+_P02_SDA: CONN54_PF.1L4(SDA#1L4) RB491.1 RB630.1
SFP+_P02_SDA_R: RB630.2 RB631.2 UB13.6(SD1)
SFP+_P03_SCL: CONN54_PF.2T5(SCL#2T5) RB459.1 RB600.1
SFP+_P03_SCL_R: RB600.2 RB601.2 UB13.9(SC2)
SFP+_P03_SDA: CONN54_PF.2T4(SDA#2T4) RB495.1 RB609.1
SFP+_P03_SDA_R: RB609.2 RB610.2 UB13.8(SD2)
SFP+_P04_SCL: CONN54_PF.2L5(SCL#2L5) RB530.1 RB583.1
SFP+_P04_SCL_R: RB583.2 RB584.2 UB13.11(SC3)
SFP+_P04_SDA: CONN54_PF.2L4(SDA#2L4) RB494.1 RB592.1
SFP+_P04_SDA_R: RB592.2 RB593.2 UB13.10(SD3)
SFP+_P05_SCL: CONN54_PF.3T5(SCL#3T5) RB435.1 RB587.1
SFP+_P05_SCL_R: RB586.2 RB587.2 UB13.14(SC4)
SFP+_P05_SDA: CONN54_PF.3T4(SDA#3T4) RB471.1 RB578.1
SFP+_P05_SDA_R: RB577.2 RB578.2 UB13.13(SD4)
SFP+_P06_SCL: CONN54_PF.3L5(SCL#3L5) RB506.1 RB603.1
SFP+_P06_SCL_R: RB602.2 RB603.2 UB13.16(SC5)
SFP+_P06_SDA: CONN54_PF.3L4(SDA#3L4) RB470.1 RB595.1
SFP+_P06_SDA_R: RB594.2 RB595.2 UB13.15(SD5)
SFP+_P07_SCL: CONN54_PF.4T5(SCL#4T5) RB438.1 RB625.1
SFP+_P07_SCL_R: RB624.2 RB625.2 UB13.18(SC6)
SFP+_P07_SDA: CONN54_PF.4T4(SDA#4T4) RB474.1 RB612.1
SFP+_P07_SDA_R: RB611.2 RB612.2 UB13.17(SD6)
SFP+_P08_SCL: CONN54_PF.4L5(SCL#4L5) RB509.1 RB644.1
SFP+_P08_SCL_R: RB643.2 RB644.2 UB13.20(SC7)
SFP+_P08_SDA: CONN54_PF.4L4(SDA#4L4) RB473.1 RB633.1
SFP+_P08_SDA_R: RB632.2 RB633.2 UB13.19(SD7)
SFP+_P09_SCL: CONN54_PF.5T5(SCL#5T5) RB441.1 RB634.1
SFP+_P09_SCL_R: RB634.2 RB635.2 UB12.5(SC0)
SFP+_P09_SDA: CONN54_PF.5T4(SDA#5T4) RB477.1 RB645.1
SFP+_P09_SDA_R: RB645.2 RB646.2 UB12.4(SD0)
SFP+_P10_SCL: CONN54_PF.5L5(SCL#5L5) RB512.1 RB613.1
SFP+_P10_SCL_R: RB613.2 RB614.2 UB12.7(SC1)
SFP+_P10_SDA: CONN54_PF.5L4(SDA#5L4) RB476.1 RB626.1
SFP+_P10_SDA_R: RB626.2 RB627.2 UB12.6(SD1)
SFP+_P11_SCL: CONN54_PF.6T5(SCL#6T5) RB444.1 RB596.1
SFP+_P11_SCL_R: RB596.2 RB597.2 UB12.9(SC2)
SFP+_P11_SDA: CONN54_PF.6T4(SDA#6T4) RB480.1 RB605.1
SFP+_P11_SDA_R: RB605.2 RB606.2 UB12.8(SD2)
SFP+_P12_SCL: CONN54_PF.6L5(SCL#6L5) RB515.1 RB579.1
SFP+_P12_SCL_R: RB579.2 RB580.2 UB12.11(SC3)
SFP+_P12_SDA: CONN54_PF.6L4(SDA#6L4) RB479.1 RB588.1
SFP+_P12_SDA_R: RB588.2 RB589.2 UB12.10(SD3)
SFP+_P13_SCL: CONN55_PF.1T5(SCL#1T5) RB462.1 RB591.1
SFP+_P13_SCL_R: RB590.2 RB591.2 UB12.14(SC4)
SFP+_P13_SDA: CONN55_PF.1T4(SDA#1T4) RB498.1 RB582.1
SFP+_P13_SDA_R: RB581.2 RB582.2 UB12.13(SD4)
SFP+_P14_SCL: CONN55_PF.1L5(SCL#1L5) RB533.1 RB608.1
SFP+_P14_SCL_R: RB607.2 RB608.2 UB12.16(SC5)
SFP+_P14_SDA: CONN55_PF.1L4(SDA#1L4) RB497.1 RB599.1
SFP+_P14_SDA_R: RB598.2 RB599.2 UB12.15(SD5)
SFP+_P15_SCL: CONN55_PF.2T5(SCL#2T5) RB465.1 RB629.1
SFP+_P15_SCL_R: RB628.2 RB629.2 UB12.18(SC6)
SFP+_P15_SDA: CONN55_PF.2T4(SDA#2T4) RB501.1 RB616.1
SFP+_P15_SDA_R: RB615.2 RB616.2 UB12.17(SD6)
SFP+_P16_SCL: CONN55_PF.2L5(SCL#2L5) RB536.1 RB648.1
SFP+_P16_SCL_R: RB647.2 RB648.2 UB12.20(SC7)
SFP+_P16_SDA: CONN55_PF.2L4(SDA#2L4) RB500.1 RB637.1
SFP+_P16_SDA_R: RB636.2 RB637.2 UB12.19(SD7)
SFP+_P17_SCL: CONN55_PF.3T5(SCL#3T5) RB247.1 RB468.1
SFP+_P17_SCL_R: RB247.2 RB264.2 UB8.5(SC0)
SFP+_P17_SDA: CONN55_PF.3T4(SDA#3T4) RB246.1 RB504.1
SFP+_P17_SDA_R: RB246.2 RB263.2 UB8.4(SD0)
SFP+_P18_SCL: CONN55_PF.3L5(SCL#3L5) RB249.1 RB539.1
SFP+_P18_SCL_R: RB249.2 RB266.2 UB8.7(SC1)
SFP+_P18_SDA: CONN55_PF.3L4(SDA#3L4) RB248.1 RB503.1
SFP+_P18_SDA_R: RB248.2 RB265.2 UB8.6(SD1)
SFP+_P19_SCL: CONN55_PF.4T5(SCL#4T5) RB251.1 RB447.1
SFP+_P19_SCL_R: RB251.2 RB268.2 UB8.9(SC2)
SFP+_P19_SDA: CONN55_PF.4T4(SDA#4T4) RB250.1 RB483.1
SFP+_P19_SDA_R: RB250.2 RB267.2 UB8.8(SD2)
SFP+_P20_SCL: CONN55_PF.4L5(SCL#4L5) RB253.1 RB518.1
SFP+_P20_SCL_R: RB253.2 RB270.2 UB8.11(SC3)
SFP+_P20_SDA: CONN55_PF.4L4(SDA#4L4) RB252.1 RB482.1
SFP+_P20_SDA_R: RB252.2 RB269.2 UB8.10(SD3)
SFP+_P21_SCL: CONN55_PF.5T5(SCL#5T5) RB306.1 RB450.1
SFP+_P21_SCL_R: RB296.2 RB306.2 UB8.14(SC4)
SFP+_P21_SDA: CONN55_PF.5T4(SDA#5T4) RB307.1 RB486.1
SFP+_P21_SDA_R: RB297.2 RB307.2 UB8.13(SD4)
SFP+_P22_SCL: CONN55_PF.5L5(SCL#5L5) RB304.1 RB521.1
SFP+_P22_SCL_R: RB294.2 RB304.2 UB8.16(SC5)
SFP+_P22_SDA: CONN55_PF.5L4(SDA#5L4) RB305.1 RB485.1
SFP+_P22_SDA_R: RB295.2 RB305.2 UB8.15(SD5)
SFP+_P23_SCL: CONN55_PF.6T5(SCL#6T5) RB302.1 RB453.1
SFP+_P23_SCL_R: RB292.2 RB302.2 UB8.18(SC6)
SFP+_P23_SDA: CONN55_PF.6T4(SDA#6T4) RB303.1 RB489.1
SFP+_P23_SDA_R: RB293.2 RB303.2 UB8.17(SD6)
SFP+_P24_SCL: CONN55_PF.6L5(SCL#6L5) R1190.1 RB524.1
SFP+_P24_SCL_R: R1188.2 R1190.2 UB8.20(SC7)
SFP+_P24_SDA: CONN55_PF.6L4(SDA#6L4) R1191.1 RB488.1
SFP+_P24_SDA_R: R1191.2 RB291.2 UB8.19(SD7)
SKIP#_VCC1V0: R491.1 R534.2 R655.1 U33.39(S\K\I\P\-NVM)
SN65C_1DE: RB273.1 RB278.1 RB280.2 U51.4(RE#)
SN65C_2DE: R853.1 R855.1 R856.2 U51.12(DE)
SP01_P08_A0: RB670.2 RB671.1 UB13.1(A0)
SP01_P08_A1: RB660.2 RB661.1 UB13.2(A1)
SP01_P08_A2: RB653.1 RB654.2 UB13.21(A2)
SP01_P08_R_SDA: RB720.1 UB13.23(SDA)
SP01_P08_RESET_N: P1.W5(IO_B3_W5/DIFFIO_B5P/DM3B/BWS#3B) UB13.3(R\E\S\E\T\)
SP01_P08_SCL: RB706.1 UB13.22(SCL)
SP01_P08_SCL_R: RB706.2 RB707.2 UB17.5(SC0)
SP01_P08_SDA: RB712.1 RB720.2
SP01_P08_SDA_R: RB712.2 RB713.2 UB17.4(SD0)
SP09_P16_A0: RB672.1 RB673.2 UB12.1(A0)
SP09_P16_A1: RB663.1 RB664.2 UB12.2(A1)
SP09_P16_A2: RB657.1 RB658.2 UB12.21(A2)
SP09_P16_R_SDA: RB692.1 UB12.23(SDA)
SP09_P16_RESET_N: P1.C7(IO_B8_C7/DIFFIO_T10N/DQS3T/CQ3T) UB12.3(R\E\S\E\T\)
SP09_P16_SCL: RB693.1 UB12.22(SCL)
SP09_P16_SCL_R: RB693.2 RB694.2 UB17.7(SC1)
SP09_P16_SDA: RB692.2 RB701.1
SP09_P16_SDA_R: RB701.2 RB702.2 UB17.6(SD1)
SP17_P24_A0: RB274.2 RB275.1 UB8.1(A0)
SP17_P24_A1: RB245.2 RB262.1 UB8.2(A1)
SP17_P24_A2: R1187.2 R1189.1 UB8.21(A2)
SP17_P24_R_SDA: RB279.1 UB8.23(SDA)
SP17_P24_RESET_N: P1.D19(IO_B6_D19/DIFFIO_R10P/DQ2R) UB8.3(R\E\S\E\T\)
SP17_P24_SCL: RB676.1 UB8.22(SCL)
SP17_P24_SCL_R: RB676.2 RB677.2 UB17.9(SC2)
SP17_P24_SDA: RB279.2 RB682.1
SP17_P24_SDA_R: RB682.2 RB683.2 UB17.8(SD2)
SPI_CLK: CONN58.7 RB1297.1
SPI_MISO: CONN58.5 RB1296.1
SPI_MOSI: CONN58.8 RB1299.2
SPI_SS: CONN58.9 RB1298.1
SS_VCC5P0: C356.1 U34.8(SS)
STACKING_CNTL_MDI_N0_GE: RJ1.A2 U76.22(MX1-)
STACKING_CNTL_MDI_N1_GE: RJ1.A6 U76.19(MX2-)
STACKING_CNTL_MDI_N2_GE: RJ1.A5 U76.16(MX3-)
STACKING_CNTL_MDI_N3_GE: RJ1.A8 U76.13(MX4-)
STACKING_CNTL_MDI_P0_GE: RJ1.A1 U76.23(MX1+)
STACKING_CNTL_MDI_P1_GE: RJ1.A3 U76.20(MX2+)
STACKING_CNTL_MDI_P2_GE: RJ1.A4 U76.17(MX3+)
STACKING_CNTL_MDI_P3_GE: RJ1.A7 U76.14(MX4+)
SW1_CPU_TCK: R351.2 R418.2
SW1_CPU_TCK_R: R418.1 U21.11(3B1)
SW1_CPU_TDI: R370.2 R398.2
SW1_CPU_TDI_R: R398.1 U21.5(2B1)
SW1_CPU_TDO: R379.2 R386.2
SW1_CPU_TDO_R: R386.1 U21.14(4B1)
SW1_CPU_TMS: R381.2 R383.2
SW1_CPU_TMS_R: R381.1 U21.2(1B1)
SW1_FAN_TCK: CONN56.26 R426.2
SW1_FAN_TCK_R: R426.1 U21.10(3B2)
SW1_FAN_TDI: CONN56.27 R420.2
SW1_FAN_TDI_R: R420.1 U21.6(2B2)
SW1_FAN_TDO: CONN56.28 R396.2
SW1_FAN_TDO_R: R396.1 U21.13(4B2)
SW1_FAN_TMS: CONN56.25 R388.2
SW1_FAN_TMS_R: R388.1 U21.3(1B2)
SW1_OE_N: R350.2 R1012.2 U21.15(\\O\\E\)
SW1_SELECT: P1.W11(IO_B3_W11/DIFFIO_B15P/DQ5B) R352.2 R1013.2 R1014.1
SW1_SELECT_R: R1014.2 U21.1(S)
SW_VCC5P0: CB440.2 D2.C L21.1 R598.2 U34.3(SW)
SW_VCC5P0_PLL_C: C326.1 R598.1
SYNCE_PLL_AVDD1P8: C268.1 CB481.1 CB488.1 CB490.1 CB495.1 L17.1 U40.AD25(SYNCE_1_PLL_AVDD1P8) U40.AE26(SYNCE_0_PLL_AVDD1P8)
SYS_CPLD_INT_CPU: J2.A54(GPI0) P1.M16(IO_B5_M16/DIFFIO_R27P)
SYS_PWR_READY: R52.2 R79.2 U7.21(FPWM5/GPIO9)
SYS_PWR_READY_R: P1.A6(IO_B8_A6/DIFFIO_T18N) R79.1
SYS_SW_RST_N: J2.B50(CB_RESET#) P1.AB8(IO_B3_AB8/DIFFIO_B14P/DQ5B) RB1233.2 RB1302.1
TB_CHASSIS: C737.2 C738.2 C739.2 C863.1 C889.2 C897.1 C952.2 C953.2 C954.2 C955.2 C956.2 C957.2 C958.2 C959.2 CB937.2 CB1107.2 D6.2 D7.2 DB1.2 DB2.2 LB58.1 LB59.1 LB60.1 LB61.1 LB73.1 LB74.1 LB75.1 LB76.1 LB77.1 LB78.1 LB96.1 LB97.1 LB98.1 LB99.1 LB100.1 LB101.1 LB102.1 LB103.1
TEST_1PPS_RX: CB1087.2 U51.5(2R) UB71.2(A-IN)
TEST_1PPS_RX_R: CB1088.2 RB276.1 RB277.1 UB71.4(Y-OUT)
TEST_UART_RX: CB1089.2 U51.3(1R) UB70.2(A-IN)
TEST_UART_RX_R: CB1090.2 RB283.1 UB70.4(Y-OUT)
THERMAL_DIODE_N_R: TP1.1 U40.J25(THERM_DIODE_N)
THERMAL_DIODE_P_R: TP2.1 U40.K25(THERM_DIODE_P)
TOD_A: P1.B6(IO_B8_B6/DIFFIO_T14N/DQ5T) RB688.2
TOD_A_R: CB954.2 LEDB3.C1 RB688.1
TOD_G: P1.B3(IO_B8_B3/DIFFIO_T15N/DQ5T) RB678.2
TOD_G_R: CB953.2 LEDB3.C2 RB678.1
TOD_UART_RJ_RX: P1.H13(IO_B7_H13/DIFFIO_T23N/DQ4T) RB283.2
TPM_RESET_N: P1.R10(IO_B3_R10/DIFFIO_B4N) R1490.1 U72.16(LRESET#)
TPS53219_VDD: C292.1 R556.2 U31.6(VDD)
TPS53641_SCL_R: RB718.2 RB719.2 UB16.5(SC0)
TPS53641_SDA_R: RB724.2 RB725.2 UB16.4(SD0)
TPS53647_GND_SENSE: R613.2 R614.1 U40.AC18(VSS_SENSE)
TPS53647_VDD_SENSE: R604.1 R605.1 U40.AC19(VDDC_SENSE)
TS_25M_REFCLK_MAC_N: C406.2 U40.U30(TS_PLL_REFCLK_N)
TS_25M_REFCLK_MAC_P: C404.2 U40.U29(TS_PLL_REFCLK_P)
TS_25M_REFCLK_N: C406.1 R1406.1 R1509.2
TS_25M_REFCLK_N_R: P1.G10(IO_B8_G10/PLL2_CLKOUTN) R1406.2 R1408.1
TS_25M_REFCLK_P: C404.1 R1407.1 R1509.1
TS_25M_REFCLK_P_R: P1.H9(IO_B8_H9/PLL2_CLKOUTP) R1407.2 R1409.1
TS_BIT_CLK0_R: R638.2 U40.AD30(TS_BIT_CLK0)
TS_BIT_CLK1_R: R581.2 U40.AD29(TS_BIT_CLK1)
TXDIS_01: CONN54_PF.1T3(TX_DISABLE#1T3) RB454.1 U9.B8(IO_2_B8/DIFFIO_T10N)
TXDIS_02: CONN54_PF.1L3(TX_DISABLE#1L3) RB564.1 U9.E6(IO_2_E6)
TXDIS_03: CONN54_PF.2T3(TX_DISABLE#2T3) RB457.1 U9.F5(IO_1_F5/DIFFIO_L8P)
TXDIS_04: CONN54_PF.2L3(TX_DISABLE#2L3) RB567.1 U9.G3(IO_1_G3/DIFFIO_L7N)
TXDIS_05: CONN54_PF.3T3(TX_DISABLE#3T3) RB433.1 U9.G4(IO_1_G4/DIFFIO_L10P)
TXDIS_06: CONN54_PF.3L3(TX_DISABLE#3L3) RB543.1 U9.K4(IO_1_K4/DIFFIO_L18P)
TXDIS_07: CONN54_PF.4T3(TX_DISABLE#4T3) RB436.1 U9.L4(IO_1_L4/DIFFIO_L21P)
TXDIS_08: CONN54_PF.4L3(TX_DISABLE#4L3) RB546.1 U9.M6(IO_1_M6/DIFFIO_L22P)
TXDIS_09: CONN54_PF.5T3(TX_DISABLE#5T3) RB439.1 U9.P8(IO_4_P8/DIFFIO_B9N)
TXDIS_10: CONN54_PF.5L3(TX_DISABLE#5L3) RB549.1 U9.T3(IO_1_T3)
TXDIS_11: CONN54_PF.6T3(TX_DISABLE#6T3) RB442.1 U9.U6(IO_4_U6/DIFFIO_B8P)
TXDIS_12: CONN54_PF.6L3(TX_DISABLE#6L3) RB552.1 U9.T7(IO_4_T7)
TXDIS_13: CONN55_PF.1T3(TX_DISABLE#1T3) RB460.1 U9.T9(IO_4_T9)
TXDIS_14: CONN55_PF.1L3(TX_DISABLE#1L3) RB570.1 U9.V10(IO_4_V10/DIFFIO_B15P)
TXDIS_15: CONN55_PF.2T3(TX_DISABLE#2T3) RB463.1 U9.P13(IO_4_P13)
TXDIS_16: CONN55_PF.2L3(TX_DISABLE#2L3) RB573.1 U9.P14(IO_3_P14/DIFFIO_R29N)
TXDIS_17: CONN55_PF.3T3(TX_DISABLE#3T3) RB466.1 U9.R18(IO_3_R18/DIFFIO_R29P)
TXDIS_18: CONN55_PF.3L3(TX_DISABLE#3L3) RB576.1 U9.L15(IO_3_L15/DIFFIO_R21N)
TXDIS_19: CONN55_PF.4T3(TX_DISABLE#4T3) RB445.1 U9.G14(IO_3_G14/DIFFIO_R8P)
TXDIS_20: CONN55_PF.4L3(TX_DISABLE#4L3) RB555.1 U9.G15(IO_3_G15/DIFFIO_R7P)
TXDIS_21: CONN55_PF.5T3(TX_DISABLE#5T3) RB448.1 U9.E15(IO_3_E15/DIFFIO_R2P)
TXDIS_22: CONN55_PF.5L3(TX_DISABLE#5L3) RB558.1 U9.E16(IO_3_E16/DIFFIO_R4N)
TXDIS_23: CONN55_PF.6T3(TX_DISABLE#6T3) RB451.1 U9.D16(IO_3_D16/DIFFIO_R3P)
TXDIS_24: CONN55_PF.6L3(TX_DISABLE#6L3) RB561.1 U9.C17(IO_3_C17/DIFFIO_R1N)
TXFLT_01: CONN54_PF.1T2(TX_FAULT#1T2) RB490.1 U9.C8(IO_2_C8/DIFFIO_T10P)
TXFLT_02: CONN54_PF.1L2(TX_FAULT#1L2) RB455.1 U9.F6(IO_1_F6/DIFFIO_L9P)
TXFLT_03: CONN54_PF.2T2(TX_FAULT#2T2) RB493.1 U9.D3(IO_1_D3/DIFFIO_L3P)
TXFLT_04: CONN54_PF.2L2(TX_FAULT#2L2) RB458.1 U9.H3(IO_1_H3/DIFFIO_L10N)
TXFLT_05: CONN54_PF.3T2(TX_FAULT#3T2) RB469.1 U9.H4(IO_1_H4/DIFFIO_L13N)
TXFLT_06: CONN54_PF.3L2(TX_FAULT#3L2) RB434.1 U9.K1(IO_1_K1)
TXFLT_07: CONN54_PF.4T2(TX_FAULT#4T2) RB472.1 U9.L1(IO_1_L1)
TXFLT_08: CONN54_PF.4L2(TX_FAULT#4L2) RB437.1 U9.M3(IO_1_M3/DIFFIO_L22N)
TXFLT_09: CONN54_PF.5T2(TX_FAULT#5T2) RB475.1 U9.T2(IO_1_T2/DIFFIO_L29N)
TXFLT_10: CONN54_PF.5L2(TX_FAULT#5L2) RB440.1 U9.U3(IO_4_U3/DIFFIO_B2P)
TXFLT_11: CONN54_PF.6T2(TX_FAULT#6T2) RB478.1 U9.N4(IO_1_N4/DIFFIO_L26P)
TXFLT_12: CONN54_PF.6L2(TX_FAULT#6L2) RB443.1 U9.V8(IO_4_V8/DIFFIO_B12N)
TXFLT_13: CONN55_PF.1T2(TX_FAULT#1T2) RB496.1 U9.V9(IO_4_V9/DIFFIO_B14P)
TXFLT_14: CONN55_PF.1L2(TX_FAULT#1L2) RB461.1 U9.T10(IO_4_T10/DIFFIO_B18P)
TXFLT_15: CONN55_PF.2T2(TX_FAULT#2T2) RB499.1 U9.N11(IO_4_N11/DIFFIO_B19P)
TXFLT_16: CONN55_PF.2L2(TX_FAULT#2L2) RB464.1 U9.T15(IO_4_T15/DIFFIO_B24N)
TXFLT_17: CONN55_PF.3T2(TX_FAULT#3T2) RB502.1 U9.U18(IO_4_U18/DIFFIO_B28N)
TXFLT_18: CONN55_PF.3L2(TX_FAULT#3L2) RB467.1 U9.L16(IO_3_L16/DIFFIO_R22N)
TXFLT_19: CONN55_PF.4T2(TX_FAULT#4T2) RB481.1 U9.L17(IO_3_L17/DIFFIO_R20P)
TXFLT_20: CONN55_PF.4L2(TX_FAULT#4L2) RB446.1 U9.J17(IO_3_J17/DIFFIO_R15N)
TXFLT_21: CONN55_PF.5T2(TX_FAULT#5T2) RB484.1 U9.F15(IO_3_F15/DIFFIO_R4P)
TXFLT_22: CONN55_PF.5L2(TX_FAULT#5L2) RB449.1 U9.E18(IO_3_E18/DIFFIO_R7N)
TXFLT_23: CONN55_PF.6T2(TX_FAULT#6T2) RB487.1 U9.E17(IO_3_E17/DIFFIO_R6N)
TXFLT_24: CONN55_PF.6L2(TX_FAULT#6L2) RB452.1 U9.B16(IO_2_B16/DIFFIO_T25P)
TXMSYNC_SET: P1.A11(IO_B7_A11/DIFFIO_T22N/DQ4T) R1130.1
TXON_SET: P1.W18(IO_B4_W18/DIFFIO_B36P) R1093.1
U72_PP: R1319.1 R1321.1 U72.7(PP)
UART1_RX: J2.A99(SER0_RX) R310.2 RB1304.2
UART1_TX: J2.A98(SER0_TX) R259.2 R714.2 RB320.2
UART_TX+: DB2.1 FB5.2 RB315.2 RB324.1 U54.2(LINE 2 IN)
UART_TX+_A: CB894.2 LB59.2 R946.1 RB315.1 U51.2(1A)
UART_TX+_A_R: R946.2 U51.10(2Y)
UART_TX+_R: FB5.1 RJ1.C8
UART_TX-: DB1.1 FB4.2 RB314.2 RB324.2 U54.1(LINE 1 IN)
UART_TX-_A: CB893.2 LB58.2 R945.1 RB314.1 U51.1(1B)
UART_TX-_A_R: R945.2 U51.11(2Z)
UART_TX-_R: FB4.1 RJ1.C7
UC_25M_R_CLK_N: CB1062.2 U40.W32(UC_PLL_REFCLK_N)
UC_25M_R_CLK_P: CB1061.2 U40.V32(UC_PLL_REFCLK_P)
UC_25M_REFCLK_N: CB1062.1 R399.1
UC_25M_REFCLK_P: CB1061.1 R400.1
UC_PLL_AVDD1P8: C440.1 CB546.1 CB547.1 CB548.2 L47.1 U40.Y32(UC_PLL_AVDD1P8)
UC_PLL_LOCK: R518.1 R519.2 U40.AL33(UC_PLL_LOCK)
UCD9016_3V3: C129.1 D1.C R206.2 R207.2 R234.1 R539.1
UCD9016_V33: C107.2 C122.2 R207.1 U7.46(V33A)
UCD9016_VDIO: C106.2 C117.2 C123.2 CB33.2 R206.1 U7.7(V33DIO1) U7.44(V33DIO2) U7.45(V33D)
UCD9090_ALERT_L: J2.A67(GPI2) P1.AA10(IO_B3_AA10/DIFFIO_B16N/DQ5B)
UCD90160_A0: R56.2 U7.61(PMBUS_ADDR0)
UCD90160_A1: R57.2 U7.60(PMBUS_ADDR1)
UCD90160_ALERT_L: CONN41.8 R97.2 U7.27(PMBUS_ALERT)
UCD90160_CNTRL: R107.2 R708.2 U7.28(PMBUS_CNTRL)
UCD90160_CNTRL_R: CONN41.7 R708.1
UCD90160_INT: P1.H14(IO_B7_H14/DIFFIO_T26N) R165.1
UCD90160_INT_R: R165.2 U7.36(TCK/GPIO19)
UCD90160_RESERVED: P1.W15(IO_B4_W15/DIFFIO_B25P/DQ4B) R194.1
UCD90160_RESERVED_R: R166.2 R194.2 U7.38(TDI/GPIO21)
UCD90160_RST: C16.2 J2.B57(GPO2) R2.2 R25.2 R86.1 U7.9(RESET_L)
UCD90160_RST_L: P1.L14(IO_B5_L14/DIFFIO_R34P) R2.1
UCD90160_RST_R: R71.2 R86.2 U7.24(FPWM8/GPIO12)
UCD90160_SCL: CONN41.9 R40.2 RB704.1 U7.15(PMBUS_CLK)
UCD90160_SCL_R: RB704.2 RB705.2 UB16.7(SC1)
UCD90160_SDA: CONN41.10 R39.2 RB710.1 U7.16(PMBUS_DATA)
UCD90160_SDA_R: RB710.2 RB711.2 UB16.6(SD1)
UCD90160_SHUTDOWN_WAKE: P1.B15(IO_B7_B15/DIFFIO_T32P/DQ2T) U7.41(PWM4/GPI4)
UCD90160_TRST_LR: R167.2 U7.40(TRST_L)
UCD90160_VCC3P3_R: CONN41.5 R720.2
USB0_N: J2.A45(USB0-) RB135.2 U24.30(USBUP_DM)
USB0_P: J2.A46(USB0+) RB134.2 U24.31(USBUP_DP)
USB1_PWRFAULT: J2.B44(USB_0_1_OC#) P1.N14(IO_B5_N14/DIFFIO_R36P)
USB1_VBUS_RESET: J2.A93(GPO0) P1.AB10(IO_B3_AB10/DIFFIO_B18P/DM4B) R1493.2
USB2_N: J2.A42(USB2-) U71.7(DM)
USB2_P: J2.A43(USB2+) U71.8(DP)
USB5V_GPS_ANT: C433.1 C437.1 C441.1 LB26.2 R754.2
USB HUB_GND: LB80.1 LB81.1 LB82.1 LB84.1 RB642.1 RB652.2
USB_CHASSIS: CB938.1 LB79.1 RB642.2
USB_DM: CB959.1 CONNB2.2(D-) LB81.2 R437.1 RB135.1 RB686.1
USB_DP: CB958.2 CONNB2.3(D+) LB80.2 R433.1 RB134.1 RB685.2
USB_ILIM: RB668.2 UB14.2(ILIM)
USB_ILIM_R: RB667.2 RB668.1
USB_PWRFLT_N: P1.T13(IO_B4_T13/DIFFIO_B19N/DQS4B/CQ5) R342.2 RB659.1 UB14.3(F\A\U\L\T\)
USB_PWRON_N: P1.Y13(IO_B4_Y13/DIFFIO_B20N/DQ4B) R343.1 UB14.4(EN)
USB_RESET_N: P1.R11(IO_B3_R11/DIFFIO_B6P/DQS1B/CQ1B) R443.2 U24.26(R\E\S\E\T\)
USB_VBUS: C240.2 CB952.1 CB956.2 LB85.1 R453.2 UB14.1(OUT)
USB_VCC5P0: C205.1 C207.1 C439.1 C444.1 C508.2 C509.2 C511.1 C512.1 C514.1 CB38.1 CB707.1 CB708.1 CB733.2 CB759.2 CB957.2 CONN6.13 L55.1 LB26.1 R5.1 U23.10(BIAS) U47.10(BIAS) UB14.6(IN)
USB_VCC5P0_MON: C20.1 R5.2 R16.1 U7.3(MON3)
USBHUB_CFG_SEL1: R435.2 R439.1 U24.25(HS_IND/CFG_SEL1)
USBHUB_CRFILT: C189.2 C190.2 U24.14(CRFILT)
USBHUB_DM: R437.2 U24.1(USBDN1_DM)
USBHUB_DP: R433.2 U24.2(USBDN1_DP)
USBHUB_NON_REM0: R455.1 U24.28(SUSP_IND/LOCAL_PWR/NON_REM0)
USBHUB_OCS1_N: R342.1 U24.13(O\C\S\1\)
USBHUB_OCS2_N: R340.2 U24.17(O\C\S\2\)
USBHUB_OCS3_N: R356.2 U24.19(O\C\S\3\)
USBHUB_OCS4_N: R384.2 U24.21(O\C\S\4\)
USBHUB_PLLFILT: C237.2 C238.2 U24.34(PLLFILT)
USBHUB_PRIAS: R456.1 U24.35(RBIAS)
USBHUB_PRTPWR1: R343.2 U24.12(PRTPWR1)
USBHUB_SCL: R297.1 R424.2 R428.1 U24.24(SCL/SMBCLK/CFG_SEL0)
USBHUB_SCL_R: R296.2 R297.2 U10.14(SC4)
USBHUB_SDA: R309.1 R390.1 R391.2
USBHUB_SDA_R: R308.2 R309.2 U10.13(SD4)
USBHUB_VBUS_DET: R449.2 R453.1 U24.27(VBUS_DET)
USBHUB_XTALIN: C245.1 R454.1 U24.33(XTALIN/CLKIN) X1.3
USBHUB_XTALOUT: R454.2 R459.2 U24.32(XTALOUT/CLKIN_EN)
USBHUB_XTALOUT_C: C244.1 R459.1 X1.1
VEN_CPLD_VDD1P8: CONN5.6 U7.14(GPIO4)
VEN_FPGA_1V2: CONN5.1 U7.13(GPIO3)
VEN_FPGA_2V5: CONN5.8 U7.12(GPIO2)
VEN_MANG_1P2: CONN5.3 U7.39(TMS/GPIO22)
VEN_MANG_2P5: R1065.2 U7.22(FPWM6/GPIO10)
VEN_USB_VCC5P0: CONN5.2 U7.11(GPIO1)
VEN_VCC5P0: RB766.2 U7.20(FPWM4/GPIO8)
VEN_VCC5P0_FPGA: P1.AB9(IO_B3_AB9/DIFFIO_B14N) R673.2 RB766.1
VEN_VCC5P0_R: C355.1 R671.2 R672.2 R673.1 U34.7(EN)
VEN_VDD0P6: R64.2 U7.18(FPWM2/GPIO6)
VEN_VDD1P0: R779.1 U7.30(GPIO15)
VEN_VDD1P0_ROV: R591.1 U7.34(GPIO17)
VEN_VDD1P2_DDR: R592.1 U7.17(FPWM1/GPIO5)
VEN_VDD1P8: R344.2 U7.29(GPIO14)
VEN_VDD1P8_R: C194.1 R338.2 R344.1 U23.11(EN)
VEN_VDD1P25: R772.2 U7.19(FPWM3/GPIO7)
VEN_VDD1P25_R: C451.1 R764.2 R772.1 U47.11(EN)
VEN_VDD3P3: RB155.2 U7.25(GPIO13)
VEN_VPP_DDR2P5: RB168.1 U7.35(GPIO18)
VEN_XFP_3V3: R767.2 U7.33(GPIO16)
VMONITOR_3V3: C50.1 C52.1 C57.1 C59.2 C62.1 C69.1 C108.1 C168.1 C175.1 C183.2 C208.1 C209.1 C210.1 C235.1 C276.1 C776.2 C853.1 C854.1 C855.1 C856.1 C857.1 C858.1 C859.1 C867.1 C868.1 C869.1 C870.1 C876.1 C878.1 C879.1 C881.1 C882.1 C883.1 C901.1 C984.2 C985.2 C989.2 C990.2 C991.2 C992.2 CB39.1 CB494.2 CB903.2 CB985.1 CB1083.2 CB1084.2 CB1085.2 CB1086.2 CB1157.1 CB1158.1 CB1159.1 CB1160.1 CB1161.1 CB1162.1 CB1163.1 CB1164.1 CB1165.1 CB1166.1 CB1167.1 CB1168.1 CB1169.1 CB1170.1 CB1171.1 CB1172.1 CB1173.1 CB1174.1 CB1175.1 CB1176.1 CB1177.1 CONN6.7 CONN6.19 CONN28.4 CONN56.15 CONN56.16 CONN57.4 D9.A1 DB7.C FB2.1 J3.2(P3.3V_1) J3.4(P3.3V_2) J3.12(P3.3V_3) J3.14(P3.3V_4) J3.16(P3.3V_5) J3.18(P3.3V_6) J3.70(P3.3V_7) J3.72(P3.3V_8) J3.74(P3.3V_9) L3.1 L4.1 L94.1 L101.1 L102.1 P1.E9(VCCIO8_E9) P1.E10(VCCIO8_E10) P1.E11(VCCIO8_E11) P1.E12(VCCIO8_E12) P1.E13(VCCIO7_E13) P1.E14(VCCIO7_E14) P1.E15(VCCIO7_E15) P1.E16(VCCIO7_E16) P1.F10(VCCIO8_F10) P1.F14(VCCIO7_F14) P1.G4(VCCIO9_G4) P1.H19(VCCIO6_H19) P1.J18(VCCIO6_J18) P1.K18(VCCIO6_K18) P1.N18(VCCIO5_N18) P1.P19(VCCIO5_P19) P1.R18(VCCIO5_R18) P1.U8(VCCIO3_U8) P1.U9(VCCIO3_U9) P1.U11(VCCIO3_U11) P1.U13(VCCIO4_U13) P1.V10(VCCIO3_V10) P1.V12(VCCIO3_V12) P1.V15(VCCIO4_V15) P1.V16(VCCIO4_V16) P1.V17(VCCIO4_V17) R30.1 R39.1 R40.1 R87.2 R88.1 R97.1 R99.1 R106.2 R107.1 R116.2 R121.1 R168.2 R184.2 R189.2 R228.1 R229.1 R231.2 R234.2 R246.1 R247.1 R257.1 R261.1 R262.1 R264.2 R275.1 R279.1 R280.1 R295.1 R296.1 R307.1 R308.1 R316.2 R421.1 R429.2 R430.2 R431.2 R450.2 R452.2 R457.2 R470.2 R478.1 R480.2 R484.2 R493.2 R506.2 R524.2 R540.1 R548.1 R549.2 R597.1 R621.1 R646.2 R671.1 R720.1 R732.2 R1005.1 R1007.1 R1012.1 R1013.1 R1286.1 R1287.2 R1288.2 R1289.2 R1290.2 R1292.2 R1293.2 R1319.2 R1320.1 R1339.2 R1340.2 R1341.2 R1447.2 R1449.2 R1451.1 R1456.2 R1458.2 R1460.2 R1462.2 R1464.2 R1466.2 R1469.1 R1471.1 R1472.1 R1473.1 R1474.1 R1490.2 R1491.2 R1492.1 R1493.1 RB9.2 RB10.2 RB11.2 RB31.2 RB32.2 RB34.2 RB106.2 RB109.1 RB114.2 RB123.1 RB129.1 RB130.1 RB254.2 RB256.2 RB287.1 RB656.1 RB666.1 RB677.1 RB683.1 RB689.1 RB694.1 RB697.1 RB702.1 RB707.1 RB708.2 RB713.1 RB727.1 RB744.2 RB745.2 RB746.2 RB760.2 RB1229.1 RB1230.1 RB1231.1 RB1232.1 RB1235.2 RB1244.1 RB1245.1 RB1288.2 RB1289.2 RB1290.1 RB1291.2 RB1292.2 RB1300.2 RB1301.2 RB1302.2 RB1303.2 U8.8(VCC) U10.24(VDD) U18.8(VCC) U19.5(VCC) U20.20(VCC) U21.16(VCC) U22.8(VCC) U27.8(VCC) U29.8(VCC) U71.20(VCCIO1) U71.31(VCCIO2) U71.42(VCCIO3) U71.50(VREGIN) U71.56(VCCIO4) U72.5(VDD-1) U72.10(VDD-2) U72.19(VDD-3) U72.24(VDD-4) U80.2(VCC) U85.8(VCC) U86.8(VCC) U87.8(VCC) U88.8(VCC) UB9.16(VCC) UB17.24(VDD) UB70.5(VCC) UB71.5(VCC)
VMONITOR_3V3_MON: C29.1 R30.2 R41.1 U7.63(MON13)
VPP_DDR2P5: C132.1 C133.1 C134.1 C135.1 C196.1 C197.1 C202.1 C359.1 C360.1 C370.2 C373.1 CB130.1 CB136.1 CB141.1 CB152.1 CB154.1 CB157.1 CB167.1 CB269.1 CB293.1 CB294.1 CB295.1 CB310.1 CB311.1 CB438.1 CB439.1 CONN35.1 L9.1 L28.1 L91.1 R81.1 R572.1 U14.B1(VPP1) U14.R9(VPP2) U15.B1(VPP1) U15.R9(VPP2) U16.B1(VPP1) U16.R9(VPP2) U17.B1(VPP1) U17.R9(VPP2) UB5.B1(VPP1) UB5.R9(VPP2) UB6.B1(VPP1) UB6.R9(VPP2)
VPP_DDR2P5_BST_C: C323.1 R610.1
VPP_DDR2P5_MARGIN_HIGH: P1.AA20(IO_B4_AA20/DIFFIO_B34P) RB4.2
VPP_DDR2P5_MARGIN_HIGH_D: QB2.D RB233.1
VPP_DDR2P5_MARGIN_HIGH_R: CB21.2 QB2.G RB1.1 RB4.1
VPP_DDR2P5_MARGIN_LOW: P1.AB13(IO_B4_AB13/DIFFIO_B21N) R188.2
VPP_DDR2P5_MARGIN_LOW_D: QB6.D RB232.1
VPP_DDR2P5_MARGIN_LOW_R: C112.2 QB6.G R139.1 R188.1
VPP_DDR2P5_MON: C53.1 R80.1 R81.2 U7.58(MON10)
VPP_DDR2P5_VBST: C323.2 U32.30(VBST)
VPP_DDR2P5_VIN: C281.2 C282.2 C284.1 C293.1 C294.2 C295.2 L20.1 U32.11(VIN#1) U32.12(VIN#2) U32.13(VIN#3) U32.14(VIN#4) U32.15(VIN#5)
VPP_DDR2P5_VREG: C285.1 RB159.1 U32.3(VREG)
VREG5_VCC5P0: C354.1 U34.6(VREG)
VSTB_3V3: CB35.1 CB1091.2 CONN6.6 CONN6.18 FB1.1 R590.2 R599.2 R647.2 RB236.1
VTT_REFIN: C31.2 R45.1 R49.2 U6.1(REFIN)
VTT_REFOUT: C60.2 U6.6(REFOUT)
XFP_3V3: C493.2 C506.1 C513.1 C517.1 C519.1 C530.1 C531.1 C532.1 C533.1 C534.1 C535.1 C536.1 C539.1 C540.1 C541.1 CB786.1 CB787.1 CB788.1 CB789.1 CB793.1 CONN48.1 L53.2 LED5.A LED6.A LED7.A LED8.A LED9.A1 LED9.A2 LED10.A1 LED10.A2 LED11.A1 LED11.A2 LED12.A1 LED12.A2 LED13.A1 LED13.A2 LED14.A1 LED14.A2 LED15.A1 LED15.A2 LED16.A1 LED16.A2 LED17.A1 LED17.A2 LED18.A1 LED18.A2 LED19.A1 LED19.A2 LED20.A1 LED20.A2 LED21.A1 LED21.A2 LED22.A1 LED22.A2 LED23.A1 LED23.A2 LED24.A1 LED24.A2 LED25.A1 LED25.A2 LED26.A1 LED26.A2 LED27.A1 LED27.A2 LED28.A1 LED28.A2 LED29.A1 LED29.A2 LED30.A1 LED30.A2 LED31.A1 LED31.A2 LED32.A1 LED32.A2 LED34.A1 LED34.A2 LED35.A1 LED35.A2 LED36.A1 LED36.A2 LED37.A1 LED37.A2 LED38.A1 LED38.A2 LED39.A1 LED39.A2 LED40.A1 LED40.A2 LED41.A1 LED41.A2 LED42.A1 LED42.A2 LED43.A1 LED43.A2 LED44.A1 LED44.A2 LED45.A1 LED45.A2 LED46.A1 LED46.A2 LED47.A1 LED47.A2 LED48.A1 LED48.A2 LED49.A1 LED49.A2 LED50.A1 LED50.A2 LED51.A1 LED51.A2 LED52.A1 LED52.A2 LED53.A1 LED53.A2 LED54.A1 LED54.A2 LED55.A1 LED55.A2 LED56.A1 LED56.A2 LED57.A1 LED57.A2 LEDB3.A LEDB4.A LEDB7.A LEDB8.A LEDB9.A LEDB10.A LEDB11.A LEDB15.A PTC1.2 PTC2.2 PTC3.2 PTC4.2 PTC5.2 PTC6.2 PTC7.2 PTC8.2 PTC9.2 PTC10.2 PTC11.2 PTC12.2 PTCB1.2 PTCB2.2 PTCB3.2 R109.1 R759.1 R863.2 R864.2 R865.2 R869.2 RB309.1 RB310.2 RB312.1 RB313.2 RB326.2 RB327.2 RB330.2 RB331.2 RB337.2 RB338.2 RB339.2 RB340.2 RB341.2 RB342.2 RB343.2 RB344.2 RB345.2 RB346.2 RB347.2 RB348.2 RB349.2 RB350.2 RB351.2 RB352.2 RB353.2 RB354.2 RB355.2 RB356.2 RB357.2 RB358.2 RB359.2 RB360.2 RB361.2 RB362.2 RB363.2 RB364.2 RB365.2 RB366.2 RB367.2 RB368.2 RB369.2 RB370.2 RB371.2 RB372.2 RB373.2 RB374.2 RB375.2 RB376.2 RB377.2 RB378.2 RB379.2 RB380.2 RB381.2 RB382.2 RB383.2 RB384.2 RB433.2 RB434.2 RB435.2 RB436.2 RB437.2 RB438.2 RB439.2 RB440.2 RB441.2 RB442.2 RB443.2 RB444.2 RB445.2 RB446.2 RB447.2 RB448.2 RB449.2 RB450.2 RB451.2 RB452.2 RB453.2 RB454.2 RB455.2 RB456.2 RB457.2 RB458.2 RB459.2 RB460.2 RB461.2 RB462.2 RB463.2 RB464.2 RB465.2 RB466.2 RB467.2 RB468.2 RB469.2 RB470.2 RB471.2 RB472.2 RB473.2 RB474.2 RB475.2 RB476.2 RB477.2 RB478.2 RB479.2 RB480.2 RB481.2 RB482.2 RB483.2 RB484.2 RB485.2 RB486.2 RB487.2 RB488.2 RB489.2 RB490.2 RB491.2 RB492.2 RB493.2 RB494.2 RB495.2 RB496.2 RB497.2 RB498.2 RB499.2 RB500.2 RB501.2 RB502.2 RB503.2 RB504.2 RB505.2 RB506.2 RB507.2 RB508.2 RB509.2 RB510.2 RB511.2 RB512.2 RB513.2 RB514.2 RB515.2 RB516.2 RB517.2 RB518.2 RB519.2 RB520.2 RB521.2 RB522.2 RB523.2 RB524.2 RB525.2 RB526.2 RB527.2 RB528.2 RB529.2 RB530.2 RB531.2 RB532.2 RB533.2 RB534.2 RB535.2 RB536.2 RB537.2 RB538.2 RB539.2 RB540.2 RB541.2 RB542.2 RB543.2 RB544.2 RB545.2 RB546.2 RB547.2 RB548.2 RB549.2 RB550.2 RB551.2 RB552.2 RB553.2 RB554.2 RB555.2 RB556.2 RB557.2 RB558.2 RB559.2 RB560.2 RB561.2 RB562.2 RB563.2 RB564.2 RB565.2 RB566.2 RB567.2 RB568.2 RB569.2 RB570.2 RB571.2 RB572.2 RB573.2 RB574.2 RB575.2 RB576.2 RB1223.1 RB1224.2 RB1225.2 RB1227.2
XFP_3V3-R_P01: C652.1 C690.1 CONN54_PF.1T15(VCCR#1T15) L75.1
XFP_3V3-R_P02: C651.1 C689.1 CONN54_PF.1L15(VCCR#1L15) L74.1
XFP_3V3-R_P03: CB855.1 CB861.1 CONN54_PF.2T15(VCCR#2T15) LB51.1
XFP_3V3-R_P04: C653.1 C691.1 CONN54_PF.2L15(VCCR#2L15) L76.1
XFP_3V3-R_P05: CB856.1 CB862.1 CONN54_PF.3T15(VCCR#3T15) LB52.1
XFP_3V3-R_P06: C655.1 C693.1 CONN54_PF.3L15(VCCR#3L15) L78.1
XFP_3V3-R_P07: C590.1 C672.1 CONN54_PF.4T15(VCCR#4T15) L57.1
XFP_3V3-R_P08: C589.1 C671.1 CONN54_PF.4L15(VCCR#4L15) L56.1
XFP_3V3-R_P09: C596.1 C674.1 CONN54_PF.5T15(VCCR#5T15) L59.1
XFP_3V3-R_P10: C595.1 C673.1 CONN54_PF.5L15(VCCR#5L15) L58.1
XFP_3V3-R_P11: C602.1 C676.1 CONN54_PF.6T15(VCCR#6T15) L61.1
XFP_3V3-R_P12: C601.1 C675.1 CONN54_PF.6L15(VCCR#6L15) L60.1
XFP_3V3-R_P13: C608.1 C678.1 CONN55_PF.1T15(VCCR#1T15) L63.1
XFP_3V3-R_P14: C607.1 C677.1 CONN55_PF.1L15(VCCR#1L15) L62.1
XFP_3V3-R_P15: C610.1 C680.1 CONN55_PF.2T15(VCCR#2T15) L65.1
XFP_3V3-R_P16: C609.1 C679.1 CONN55_PF.2L15(VCCR#2L15) L64.1
XFP_3V3-R_P17: C616.1 C682.1 CONN55_PF.3T15(VCCR#3T15) L67.1
XFP_3V3-R_P18: C615.1 C681.1 CONN55_PF.3L15(VCCR#3L15) L66.1
XFP_3V3-R_P19: C622.1 C684.1 CONN55_PF.4T15(VCCR#4T15) L69.1
XFP_3V3-R_P20: C621.1 C683.1 CONN55_PF.4L15(VCCR#4L15) L68.1
XFP_3V3-R_P21: C626.1 C686.1 CONN55_PF.5T15(VCCR#5T15) L71.1
XFP_3V3-R_P22: C625.1 C685.1 CONN55_PF.5L15(VCCR#5L15) L70.1
XFP_3V3-R_P23: C634.1 C688.1 CONN55_PF.6T15(VCCR#6T15) L73.1
XFP_3V3-R_P24: C633.1 C687.1 CONN55_PF.6L15(VCCR#6L15) L72.1
XFP_3V3-T_P01: CB852.1 CB858.1 CONN54_PF.1T16(VCCT#1T16) LB48.1
XFP_3V3-T_P02: CB853.1 CB859.1 CONN54_PF.1L16(VCCT#1L16) LB49.1
XFP_3V3-T_P03: CB854.1 CB860.1 CONN54_PF.2T16(VCCT#2T16) LB50.1
XFP_3V3-T_P04: C654.1 C692.1 CONN54_PF.2L16(VCCT#2L16) L77.1
XFP_3V3-T_P05: CB857.1 CB863.1 CONN54_PF.3T16(VCCT#3T16) LB53.1
XFP_3V3-T_P06: C656.1 C694.1 CONN54_PF.3L16(VCCT#3L16) L79.1
XFP_3V3-T_P07: CB832.1 CB864.1 CONN54_PF.4T16(VCCT#4T16) LB30.1
XFP_3V3-T_P08: CB833.1 CB865.1 CONN54_PF.4L16(VCCT#4L16) LB31.1
XFP_3V3-T_P09: CB834.1 CB866.1 CONN54_PF.5T16(VCCT#5T16) LB32.1
XFP_3V3-T_P10: CB835.1 CB867.1 CONN54_PF.5L16(VCCT#5L16) LB33.1
XFP_3V3-T_P11: CB836.1 CB868.1 CONN54_PF.6T16(VCCT#6T16) LB34.1
XFP_3V3-T_P12: CB837.1 CB869.1 CONN54_PF.6L16(VCCT#6L16) LB35.1
XFP_3V3-T_P13: CB838.1 CB870.1 CONN55_PF.1T16(VCCT#1T16) LB36.1
XFP_3V3-T_P14: CB839.1 CB871.1 CONN55_PF.1L16(VCCT#1L16) LB37.1
XFP_3V3-T_P15: CB840.1 CB872.1 CONN55_PF.2T16(VCCT#2T16) LB38.1
XFP_3V3-T_P16: CB841.1 CB873.1 CONN55_PF.2L16(VCCT#2L16) LB39.1
XFP_3V3-T_P17: CB842.1 CB874.1 CONN55_PF.3T16(VCCT#3T16) LB40.1
XFP_3V3-T_P18: CB843.1 CB875.1 CONN55_PF.3L16(VCCT#3L16) LB41.1
XFP_3V3-T_P19: CB844.1 CB876.1 CONN55_PF.4T16(VCCT#4T16) LB42.1
XFP_3V3-T_P20: CB845.1 CB877.1 CONN55_PF.4L16(VCCT#4L16) LB43.1
XFP_3V3-T_P21: CB846.1 CB878.1 CONN55_PF.5T16(VCCT#5T16) LB44.1
XFP_3V3-T_P22: CB847.1 CB879.1 CONN55_PF.5L16(VCCT#5L16) LB45.1
XFP_3V3-T_P23: CB848.1 CB880.1 CONN55_PF.6T16(VCCT#6T16) LB46.1
XFP_3V3-T_P24: CB849.1 CB881.1 CONN55_PF.6L16(VCCT#6L16) LB47.1
XFP_3V3_12V_VIN: C387.2 C388.2 C389.2 C390.2 C391.2 C393.2 C401.2 C402.2 L37.1 L38.1 U41.2(VIN) U42.2(VIN)
XFP_3V3_F: CB712.2 RB215.2
XFP_3V3_GND: QB8.S QB9.S R741.2 R770.1 R793.2 R796.2 R808.2 U48.7(GND)
XFP_3V3_MARGIN_HIGH: P1.AA21(IO_B4_AA21/DIFFIO_B35P) R345.2
XFP_3V3_MARGIN_HIGH_D: QB9.D R787.2
XFP_3V3_MARGIN_HIGH_R: C195.2 QB9.G R345.1 R378.1
XFP_3V3_MARGIN_LOW: P1.AA18(IO_B4_AA18/DIFFIO_B31N/DQ2B) R376.2
XFP_3V3_MARGIN_LOW_D: QB8.D R789.2
XFP_3V3_MARGIN_LOW_R: C201.2 QB8.G R376.1 R377.1
XFP_3V3_MON: C68.1 R108.1 R109.2 U7.56(MON8)
XFP_3V3_P01_02: C545.1 C569.1 CB799.1 CB827.1 L74.2 L75.2 LB48.2 LB49.2 PTC10.1
XFP_3V3_P03_04: C546.1 C570.1 CB800.1 CB828.1 L76.2 L77.2 LB50.2 LB51.2 PTC11.1
XFP_3V3_P05_06: C547.1 C571.1 CB801.1 CB829.1 L78.2 L79.2 LB52.2 LB53.2 PTC12.1
XFP_3V3_P07_08: C550.1 C551.1 CB806.1 CB807.1 L56.2 L57.2 LB30.2 LB31.2 PTC1.1
XFP_3V3_P09_10: C552.1 C553.1 CB808.1 CB809.1 L58.2 L59.2 LB32.2 LB33.2 PTC2.1
XFP_3V3_P11_12: C554.1 C555.1 CB810.1 CB811.1 L60.2 L61.2 LB34.2 LB35.2 PTC3.1
XFP_3V3_P13_14: C556.1 C557.1 CB812.1 CB813.1 L62.2 L63.2 LB36.2 LB37.2 PTC4.1
XFP_3V3_P15_16: C558.1 C559.1 CB814.1 CB815.1 L64.2 L65.2 LB38.2 LB39.2 PTC5.1
XFP_3V3_P17_18: C560.1 C561.1 CB816.1 CB817.1 L66.2 L67.2 LB40.2 LB41.2 PTC6.1
XFP_3V3_P19_20: C562.1 C563.1 CB818.1 CB819.1 L68.2 L69.2 LB42.2 LB43.2 PTC7.1
XFP_3V3_P21_22: C529.1 C564.1 CB796.1 CB820.1 L70.2 L71.2 LB44.2 LB45.2 PTC8.1
XFP_3V3_P23_24: C565.1 C566.1 CB821.1 CB822.1 L72.2 L73.2 LB46.2 LB47.2 PTC9.1
XFP_3V3_PCH_DRVH: D4.C D5.C R713.2 R719.2 U48.13(DRVH)
XFP_3V3_PCH_DRVH_A_R: D4.A R719.1 U42.1(TG)
XFP_3V3_PCH_DRVH_B_R: D5.A R713.1 U41.1(TG)
XFP_3V3_PCH_DRVL: R728.2 R731.2 U48.11(DRVL)
XFP_3V3_PCH_DRVL_A_R: R728.1 U42.4(BG)
XFP_3V3_PCH_DRVL_B_R: R731.1 U41.4(BG)
XFP_3V3_PCH_EN_R: C449.1 R753.2 R767.1 U48.2(EN)
XFP_3V3_PCH_MODE: R793.1 R794.2 U48.5(MODE)
XFP_3V3_PCH_RF: R796.1 U48.4(RF)
XFP_3V3_PCH_TRIP: R741.1 U48.1(TRIP)
XFP_3V3_PCH_VBST: R752.2 U48.14(VBST)
XFP_3V3_PCH_VBST_R: C455.1 R752.1
XFP_3V3_PCH_VFB: C462.2 R768.2 R770.2 R788.2 R790.2 U48.3(VFB)
XFP_3V3_PCH_VFB_H: C771.1 R788.1
XFP_3V3_PCH_VFB_H_R: C771.2 R787.1
XFP_3V3_PCH_VFB_L: C772.1 R790.1
XFP_3V3_PCH_VFB_L_R: C772.2 R789.1
XFP_3V3_PCH_VFB_S: CB790.2 R759.2 R768.1
XFP_3V3_PCH_VREG_VDRV: R774.1 U48.10(VDRV)
XFP_3V3_PCL_SW: C455.2 L53.1 RB215.1 RB235.2 U41.5(VSW) U42.5(VSW) U48.12(SW)
XFP_3V3_PG: CONN47.1 R742.1 R794.1 U48.16(PGOOD)
XFP_3V3_REG: C476.2 R742.2 R774.2 U48.9(VREG)
XFP_3V3_TAP: C462.1 CB790.1 RB235.1
XFP_3V3_VDD: C479.1 R797.2 U48.6(VDD)
XO_30773: RB1272.2 U77.70(OSCI) U77.77(MCLKIN_P)
ZL30773_AD0: R1422.2 R1423.1 RB1298.2 U77.19(CS_B_ASEL0)
ZL30773_AD1: R1420.2 R1421.1 RB1296.2 U77.17(SO_ASEL1)
ZL30773_RST: P1.W6(IO_B3_W6/DIFFIO_B7P/DQ3B) R1368.2 U77.37(SRST_B) U77.75(RST_B)
N38023365: CB686.1 R792.1 R1499.2
N59764650: LED33.A R1079.2
N61042419: J2.A27(BATLOW#) R1286.2
N61194510: J2.B66(WAKE0#) R1287.1
N61194531: J2.B67(WAKE1#) R1288.1
N61194554: J2.A103(LID#) R1289.1
N61194568: J2.B103(SLEEP#) R1290.1
N61195399: J2.A47(VCC_RTC) J5.2
N61195405: J4.A(+) R1295.1
N61195407: D9.A2 R1295.2
N61232717: LEDB12.C R1294.1
N61232745: D10.A R1294.2
N61307888: C863.2 R1297.1 R1298.1 R1299.1 R1300.1
N61309659: C860.1 R1335.1 U70.1(TCT1)
N61309684: C898.1 R1336.1 U70.4(TCT2)
N61309711: C899.1 R1337.1 U70.7(TCT3)
N61309740: C900.1 R1338.1 U70.10(TCT4)
N61354121: J2.C54(TYPE0#) R1301.2 R1304.1
N61354124: J2.C57(TYPE1#) R1302.2 R1305.1
N61354127: J2.D57(TYPE2#) R1303.2 R1306.1
N61392787: J2.A101(SER1_TX) R1310.2
N61788405: C872.1 C873.1 L102.2 U71.4(VPHY)
N61788410: C871.1 C874.1 L101.2 U71.9(VPLL)
N61789248: R1318.2 U71.6(REF)
N61795259: C880.2 OSC6.1 U71.2(OSCI)
N61795286: C884.2 OSC6.3 U71.3(OSCO)
N61867245: R1320.2 R1322.2 U72.6(GPIO)
N61867605: J2.A50(LPC_SERIRQ) R1311.2
N61867630: J2.B3(LPC_FRAME#) R1312.2
N61867639: J2.B4(LPC_AD0) R1313.2
N61867648: J2.B5(LPC_AD1) R1314.2
N61867660: J2.B6(LPC_AD2) R1315.2
N61867672: J2.B7(LPC_AD3) R1316.2
N61867684: J2.B10(LPC_CLK) R1317.2
N61983825: C897.2 R1331.1 R1332.1 R1333.1 R1334.1
N62133379: P1.T2(GXB_RX1P) R1366.1
N62133382: P1.T1(GXB_RX1N) R1367.1
N62133385: P1.M1(GXB_RX2N) R1365.1
N62133388: P1.M2(GXB_RX2P) R1364.1
N62133391: P1.H1(GXB_RX3N) R1363.1
N62133394: P1.H2(GXB_RX3P) R1362.1
N62133772: P1.AB1(RREF0) RB1252.2
N62366162: RB1271.1 U77.1(REF0P)
N62370066: R1371.2 U37.5(Y1)
N62372699: RB1259.1 U77.8(REF3N)
N62372733: RB1260.1 U77.10(REF4N)
N62372774: RB1261.2 U77.6(REF2N)
N62372807: R1372.2 U77.79(GPOUT0)
N62372810: R1373.2 U77.78(GPOUT1)
N62385003: P1.T8(IO_B3_T8/PLL1_CLKOUTN) R1410.1
N62385006: P1.T7(IO_B3_T7/PLL1_CLKOUTP) R1411.1
N62385009: P1.V6(IO_B3_V6/PLL5_CLKOUTN) R1412.1
N62385012: P1.U6(IO_B3_U6/PLL5_CLKOUTP) R1413.1
N62385145: RB1262.1 U77.2(REF0N)
N62385148: RB1263.1 U77.3(REF1P)
N62385151: RB1264.1 U77.4(REF1N)
N62385154: RB1265.1 U77.5(REF2P)
N62388298: R1416.1 U77.15(IC1)
N62390159: R1417.1 U77.35(IC2)
N62390162: R1418.1 U77.34(IC3)
N62390762: R1419.1 U77.26(IC7)
N62408192: C915.1 U77.13(VREG_OUT) U77.22(VDDC)
N62470038: C919.2 C926.1 CB1218.1 LB114.2 U81.6(VDD)
N62472864: R1424.2 R1426.2 U81.5(COMP_OUTPUT)
N62472867: R1425.2 R1427.2 U81.4(OUTPUT)
N62744061: R1437.1 R1438.2 U79.7(INN0)
N62745262: R1439.1 U79.6(INP0)
N62745869: R1440.1 U79.2(IN_SEL)
N62747426: R360.2 R402.2 U79.9(OUTP0)
N62747432: R359.2 R401.2 U79.10(OUTN0)
N62747438: R358.2 R400.2 U79.11(OUTP1)
N62747447: R357.2 R399.2 U79.12(OUTN1)
N62754686: OSC7.3(OUT) RB1272.1
N62757272: RB1274.2 U77.29(MC0)
N62757275: RB1275.2 U77.28(MC1)
N62922114: RB1276.2 U77.25(GPIO1)
N62922117: RB1277.2 U77.27(GPIO2)
N62922800: RB1278.2 U77.36(GPI07)
N62922803: RB1279.2 U77.74(GPI08)
N62922934: RB1280.2 U77.31(GPIO5_AC0)
N62922937: RB1281.2 U77.30(GPIO6_AC1)
N62922967: P1.AB5(IO_B3_AB5/DIFFIO_B9N/DQ3B) RB1282.1
N62923015: P1.Y5(IO_B3_Y5/DIFFIO_B5N/DQ3B) RB1283.1
N62923052: P1.Y6(IO_B3_Y6/DIFFIO_B7N/DQ3B) RB1284.1
N62923103: P1.T9(IO_B3_T9/DIFFIO_B2N) RB1285.1
N62923170: P1.AB17(IO_B4_AB17/DIFFIO_B29P) RB1286.2
N62923212: P1.AB19(IO_B4_AB19/DIFFIO_B33N) RB1287.2
N63099887: P1.T17(IO_B5_T17/RUP3) R1447.1
N63099890: P1.T18(IO_B5_T18/RDN3) R1448.1
N63099969: P1.F16(IO_B7_F16/RUP4) R1449.1
N63099973: P1.F17(IO_B7_F17/RDN4) R1450.1
N63100208: P1.W19(IO_B4_W19/RUP2) R1451.2
N63100211: P1.Y20(IO_B4_Y20/RDN2) R1452.2
N63138975: P1.A17(IO_B7_A17/DIFFIO_T34P) R1445.1
N63138992: P1.A18(IO_B7_A18/DIFFIO_T37N/DQ2T) R1446.1
N63139056: P1.AB21(IO_B4_AB21/DIFFIO_B35N) R1443.1
N63139092: P1.R15(IO_B4_R15/DIFFIO_B32P) R1444.1
N63180384: TP52.1 U77.71(OSCO)
N63293528: C986.1 NUT1.1
N63368767: J2.A88(PCIE_CLK_REF+) R1510.2
N63368769: J2.A89(PCIE_CLK_REF-) R1511.2
N63587082: R1478.2 R1479.1 U85.4(D)
N63589715: R1481.2 R1482.1 U86.4(D)
N63590191: R1484.2 R1485.1 U87.4(D)
N63590681: R1487.2 R1488.1 U88.4(D)
N63973491: J2.B24(PWR_OK) R1500.1 RB1303.1
N63973866: R1501.2 R1502.2 RB1305.2 RB1306.2
N63974703: R1503.2 R1504.2 RB1307.2 RB1308.2
N635794501: R1479.2 U85.1(R)
N635896801: R1482.2 U86.1(R)
N635901561: R1485.2 U87.1(R)
N635906461: R1488.2 U88.1(R)
