# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BGA_1D_20C_1365SP_37D5WL
  round 0.508 smd: (-19.75,-19.75) (19.75,19.75) A2(-17,18) A3(-16,18) A4(-15,18) A5(-14,18) A6(-13,18) A7(-12,18) A8(-11,18) A9(-10,18) A10(-9,18) A11(-8,18) A12(-7,18) A13(-6,18) A14(-5,18) A15(-4,18) A16(-3,18) A17(-2,18) A18(-1,18) A19(0,18) A20(1,18) A21(2,18) A22(3,18) A23(4,18) A24(5,18) A25(6,18) A26(7,18) A27(8,18) A28(9,18) A29(10,18) A30(11,18) A31(12,18) A32(13,18) A33(14,18) A34(15,18) A35(16,18) A36(17,18) AA1(-18,-2) AA2(-17,-2) AA3(-16,-2) AA4(-15,-2) AA5(-14,-2) AA6(-13,-2) AA7(-12,-2) AA8(-11,-2) AA9(-10,-2) AA10(-9,-2) AA11(-8,-2) AA12(-7,-2) AA13(-6,-2) AA14(-5,-2) AA15(-4,-2) AA16(-3,-2) AA17(-2,-2) AA18(-1,-2) AA19(0,-2) AA20(1,-2) AA21(2,-2) AA22(3,-2) AA23(4,-2) AA24(5,-2) AA25(6,-2) AA26(7,-2) AA27(8,-2) AA28(9,-2) AA29(10,-2) AA30(11,-2) AA31(12,-2) AA32(13,-2) AA33(14,-2) AA34(15,-2) AA35(16,-2) AA36(17,-2) AA37(18,-2) AB1(-18,-3) AB2(-17,-3) AB3(-16,-3) AB4(-15,-3) AB5(-14,-3) AB6(-13,-3) AB7(-12,-3) AB8(-11,-3) AB9(-10,-3) AB10(-9,-3) AB11(-8,-3) AB12(-7,-3) AB13(-6,-3) AB14(-5,-3) AB15(-4,-3) AB16(-3,-3) AB17(-2,-3) AB18(-1,-3) AB19(0,-3) AB20(1,-3) AB21(2,-3) AB22(3,-3) AB23(4,-3) AB24(5,-3) AB25(6,-3) AB26(7,-3) AB27(8,-3) AB28(9,-3) AB29(10,-3) AB30(11,-3) AB31(12,-3) AB32(13,-3) AB33(14,-3) AB34(15,-3) AB35(16,-3) AB36(17,-3) AB37(18,-3) AC1(-18,-4) AC2(-17,-4) AC3(-16,-4) AC4(-15,-4) AC5(-14,-4) AC6(-13,-4) AC7(-12,-4) AC8(-11,-4) AC9(-10,-4) AC10(-9,-4) AC11(-8,-4) AC12(-7,-4) AC13(-6,-4) AC14(-5,-4) AC15(-4,-4) AC16(-3,-4) AC17(-2,-4) AC18(-1,-4) AC19(0,-4) AC20(1,-4) AC21(2,-4) AC22(3,-4) AC23(4,-4) AC24(5,-4) AC25(6,-4) AC26(7,-4) AC27(8,-4) AC28(9,-4) AC29(10,-4) AC30(11,-4) AC31(12,-4) AC32(13,-4) AC33(14,-4) AC34(15,-4) AC35(16,-4) AC36(17,-4) AC37(18,-4) AD1(-18,-5) AD2(-17,-5) AD3(-16,-5) AD4(-15,-5) AD5(-14,-5) AD6(-13,-5) AD7(-12,-5) AD8(-11,-5) AD9(-10,-5) AD10(-9,-5) AD11(-8,-5) AD12(-7,-5) AD13(-6,-5) AD14(-5,-5) AD15(-4,-5) AD16(-3,-5) AD17(-2,-5) AD18(-1,-5) AD19(0,-5) AD20(1,-5) AD21(2,-5) AD22(3,-5) AD23(4,-5) AD24(5,-5) AD25(6,-5) AD26(7,-5) AD27(8,-5) AD28(9,-5) AD29(10,-5) AD30(11,-5) AD31(12,-5) AD32(13,-5) AD33(14,-5) AD34(15,-5) AD35(16,-5) AD36(17,-5) AD37(18,-5) AE1(-18,-6) AE2(-17,-6) AE3(-16,-6) AE4(-15,-6) AE5(-14,-6) AE6(-13,-6) AE7(-12,-6) AE8(-11,-6) AE9(-10,-6) AE10(-9,-6) AE11(-8,-6) AE12(-7,-6) AE13(-6,-6) AE14(-5,-6) AE15(-4,-6) AE16(-3,-6) AE17(-2,-6) AE18(-1,-6) AE19(0,-6) AE20(1,-6) AE21(2,-6) AE22(3,-6) AE23(4,-6) AE24(5,-6) AE25(6,-6) AE26(7,-6) AE27(8,-6) AE28(9,-6) AE29(10,-6) AE30(11,-6) AE31(12,-6) AE32(13,-6) AE33(14,-6) AE34(15,-6) AE35(16,-6) AE36(17,-6) AE37(18,-6) AF1(-18,-7) AF2(-17,-7) AF3(-16,-7) AF4(-15,-7) AF5(-14,-7) AF6(-13,-7) AF7(-12,-7) AF8(-11,-7) AF9(-10,-7) AF10(-9,-7) AF11(-8,-7) AF12(-7,-7) AF13(-6,-7) AF14(-5,-7) AF15(-4,-7) AF16(-3,-7) AF17(-2,-7) AF18(-1,-7) AF19(0,-7) AF20(1,-7) AF21(2,-7) AF22(3,-7) AF23(4,-7) AF24(5,-7) AF25(6,-7) AF26(7,-7) AF27(8,-7) AF28(9,-7) AF29(10,-7) AF30(11,-7) AF31(12,-7) AF32(13,-7) AF33(14,-7) AF34(15,-7) AF35(16,-7) AF36(17,-7) AF37(18,-7) AG1(-18,-8) AG2(-17,-8) AG3(-16,-8) AG4(-15,-8) AG5(-14,-8) AG6(-13,-8) AG7(-12,-8) AG8(-11,-8) AG9(-10,-8) AG10(-9,-8) AG11(-8,-8) AG12(-7,-8) AG13(-6,-8) AG14(-5,-8) AG15(-4,-8) AG16(-3,-8) AG17(-2,-8) AG18(-1,-8) AG19(0,-8) AG20(1,-8) AG21(2,-8) AG22(3,-8) AG23(4,-8) AG24(5,-8) AG25(6,-8) AG26(7,-8) AG27(8,-8) AG28(9,-8) AG29(10,-8) AG30(11,-8) AG31(12,-8) AG32(13,-8) AG33(14,-8) AG34(15,-8) AG35(16,-8) AG36(17,-8) AG37(18,-8) AH1(-18,-9) AH2(-17,-9) AH3(-16,-9) AH4(-15,-9) AH5(-14,-9) AH6(-13,-9) AH7(-12,-9) AH8(-11,-9) AH9(-10,-9) AH10(-9,-9) AH11(-8,-9) AH12(-7,-9) AH13(-6,-9) AH14(-5,-9) AH15(-4,-9) AH16(-3,-9) AH17(-2,-9) AH18(-1,-9) AH19(0,-9) AH20(1,-9) AH21(2,-9) AH22(3,-9) AH23(4,-9) AH24(5,-9) AH25(6,-9) AH26(7,-9) AH27(8,-9) AH28(9,-9) AH29(10,-9) AH30(11,-9) AH31(12,-9) AH32(13,-9) AH33(14,-9) AH34(15,-9) AH35(16,-9) AH36(17,-9) AH37(18,-9) AJ1(-18,-10) AJ2(-17,-10) AJ3(-16,-10) AJ4(-15,-10) AJ5(-14,-10) AJ6(-13,-10) AJ7(-12,-10) AJ8(-11,-10) AJ9(-10,-10) AJ10(-9,-10) AJ11(-8,-10) AJ12(-7,-10) AJ13(-6,-10) AJ14(-5,-10) AJ15(-4,-10) AJ16(-3,-10) AJ17(-2,-10) AJ18(-1,-10) AJ19(0,-10) AJ20(1,-10) AJ21(2,-10) AJ22(3,-10) AJ23(4,-10) AJ24(5,-10) AJ25(6,-10) AJ26(7,-10) AJ27(8,-10) AJ28(9,-10) AJ29(10,-10) AJ30(11,-10) AJ31(12,-10) AJ32(13,-10) AJ33(14,-10) AJ34(15,-10) AJ35(16,-10) AJ36(17,-10) AJ37(18,-10) AK1(-18,-11) AK2(-17,-11) AK3(-16,-11) AK4(-15,-11) AK5(-14,-11) AK6(-13,-11) AK7(-12,-11) AK8(-11,-11) AK9(-10,-11) AK10(-9,-11) AK11(-8,-11) AK12(-7,-11) AK13(-6,-11) AK14(-5,-11) AK15(-4,-11) AK16(-3,-11) AK17(-2,-11) AK18(-1,-11) AK19(0,-11) AK20(1,-11) AK21(2,-11) AK22(3,-11) AK23(4,-11) AK24(5,-11) AK25(6,-11) AK26(7,-11) AK27(8,-11) AK28(9,-11) AK29(10,-11) AK30(11,-11) AK31(12,-11) AK32(13,-11) AK33(14,-11) AK34(15,-11) AK35(16,-11) AK36(17,-11) AK37(18,-11) AL1(-18,-12) AL2(-17,-12) AL3(-16,-12) AL4(-15,-12) AL5(-14,-12) AL6(-13,-12) AL7(-12,-12) AL8(-11,-12) AL9(-10,-12) AL10(-9,-12) AL11(-8,-12) AL12(-7,-12) AL13(-6,-12) AL14(-5,-12) AL15(-4,-12) AL16(-3,-12) AL17(-2,-12) AL18(-1,-12) AL19(0,-12) AL20(1,-12) AL21(2,-12) AL22(3,-12) AL23(4,-12) AL24(5,-12) AL25(6,-12) AL26(7,-12) AL27(8,-12) AL28(9,-12) AL29(10,-12) AL30(11,-12) AL31(12,-12) AL32(13,-12) AL33(14,-12) AL34(15,-12) AL35(16,-12) AL36(17,-12) AL37(18,-12) AM1(-18,-13) AM2(-17,-13) AM3(-16,-13) AM4(-15,-13) AM5(-14,-13) AM6(-13,-13) AM7(-12,-13) AM8(-11,-13) AM9(-10,-13) AM10(-9,-13) AM11(-8,-13) AM12(-7,-13) AM13(-6,-13) AM14(-5,-13) AM15(-4,-13) AM16(-3,-13) AM17(-2,-13) AM18(-1,-13) AM19(0,-13) AM20(1,-13) AM21(2,-13) AM22(3,-13) AM23(4,-13) AM24(5,-13) AM25(6,-13) AM26(7,-13) AM27(8,-13) AM28(9,-13) AM29(10,-13) AM30(11,-13) AM31(12,-13) AM32(13,-13) AM33(14,-13) AM34(15,-13) AM35(16,-13) AM36(17,-13) AM37(18,-13) AN1(-18,-14) AN2(-17,-14) AN3(-16,-14) AN4(-15,-14) AN5(-14,-14) AN6(-13,-14) AN7(-12,-14) AN8(-11,-14) AN9(-10,-14) AN10(-9,-14) AN11(-8,-14) AN12(-7,-14) AN13(-6,-14) AN14(-5,-14) AN15(-4,-14) AN16(-3,-14) AN17(-2,-14) AN18(-1,-14) AN19(0,-14) AN20(1,-14) AN21(2,-14) AN22(3,-14) AN23(4,-14) AN24(5,-14) AN25(6,-14) AN26(7,-14) AN27(8,-14) AN28(9,-14) AN29(10,-14) AN30(11,-14) AN31(12,-14) AN32(13,-14) AN33(14,-14) AN34(15,-14) AN35(16,-14) AN36(17,-14) AN37(18,-14) AP1(-18,-15) AP2(-17,-15) AP3(-16,-15) AP4(-15,-15) AP5(-14,-15) AP6(-13,-15) AP7(-12,-15) AP8(-11,-15) AP9(-10,-15) AP10(-9,-15) AP11(-8,-15) AP12(-7,-15) AP13(-6,-15) AP14(-5,-15) AP15(-4,-15) AP16(-3,-15) AP17(-2,-15) AP18(-1,-15) AP19(0,-15) AP20(1,-15) AP21(2,-15) AP22(3,-15) AP23(4,-15) AP24(5,-15) AP25(6,-15) AP26(7,-15) AP27(8,-15) AP28(9,-15) AP29(10,-15) AP30(11,-15) AP31(12,-15) AP32(13,-15) AP33(14,-15) AP34(15,-15) AP35(16,-15) AP36(17,-15) AP37(18,-15) AR1(-18,-16) AR2(-17,-16) AR3(-16,-16) AR4(-15,-16) AR5(-14,-16) AR6(-13,-16) AR7(-12,-16) AR8(-11,-16) AR9(-10,-16) AR10(-9,-16) AR11(-8,-16) AR12(-7,-16) AR13(-6,-16) AR14(-5,-16) AR15(-4,-16) AR16(-3,-16) AR17(-2,-16) AR18(-1,-16) AR19(0,-16) AR20(1,-16) AR21(2,-16) AR22(3,-16) AR23(4,-16) AR24(5,-16) AR25(6,-16) AR26(7,-16) AR27(8,-16) AR28(9,-16) AR29(10,-16) AR30(11,-16) AR31(12,-16) AR32(13,-16) AR33(14,-16) AR34(15,-16) AR35(16,-16) AR36(17,-16) AR37(18,-16) AT1(-18,-17) AT2(-17,-17) AT3(-16,-17) AT4(-15,-17) AT5(-14,-17) AT6(-13,-17) AT7(-12,-17) AT8(-11,-17) AT9(-10,-17) AT10(-9,-17) AT11(-8,-17) AT12(-7,-17) AT13(-6,-17) AT14(-5,-17) AT15(-4,-17) AT16(-3,-17) AT17(-2,-17) AT18(-1,-17) AT19(0,-17) AT20(1,-17) AT21(2,-17) AT22(3,-17) AT23(4,-17) AT24(5,-17) AT25(6,-17) AT26(7,-17) AT27(8,-17) AT28(9,-17) AT29(10,-17) AT30(11,-17) AT31(12,-17) AT32(13,-17) AT33(14,-17) AT34(15,-17) AT35(16,-17) AT36(17,-17) AT37(18,-17) AU2(-17,-18) AU3(-16,-18) AU4(-15,-18) AU5(-14,-18) AU6(-13,-18) AU7(-12,-18) AU8(-11,-18) AU9(-10,-18) AU10(-9,-18) AU11(-8,-18) AU12(-7,-18) AU13(-6,-18) AU14(-5,-18) AU15(-4,-18) AU16(-3,-18) AU17(-2,-18) AU18(-1,-18) AU19(0,-18) AU20(1,-18) AU21(2,-18) AU22(3,-18) AU23(4,-18) AU24(5,-18) AU25(6,-18) AU26(7,-18) AU27(8,-18) AU28(9,-18) AU29(10,-18) AU30(11,-18) AU31(12,-18) AU32(13,-18) AU33(14,-18) AU34(15,-18) AU35(16,-18) AU36(17,-18) B1(-18,17) B2(-17,17) B3(-16,17) B4(-15,17) B5(-14,17) B6(-13,17) B7(-12,17) B8(-11,17) B9(-10,17) B10(-9,17) B11(-8,17) B12(-7,17) B13(-6,17) B14(-5,17) B15(-4,17) B16(-3,17) B17(-2,17) B18(-1,17) B19(0,17) B20(1,17) B21(2,17) B22(3,17) B23(4,17) B24(5,17) B25(6,17) B26(7,17) B27(8,17) B28(9,17) B29(10,17) B30(11,17) B31(12,17) B32(13,17) B33(14,17) B34(15,17) B35(16,17) B36(17,17) B37(18,17) C1(-18,16) C2(-17,16) C3(-16,16) C4(-15,16) C5(-14,16) C6(-13,16) C7(-12,16) C8(-11,16) C9(-10,16) C10(-9,16) C11(-8,16) C12(-7,16) C13(-6,16) C14(-5,16) C15(-4,16) C16(-3,16) C17(-2,16) C18(-1,16) C19(0,16) C20(1,16) C21(2,16) C22(3,16) C23(4,16) C24(5,16) C25(6,16) C26(7,16) C27(8,16) C28(9,16) C29(10,16) C30(11,16) C31(12,16) C32(13,16) C33(14,16) C34(15,16) C35(16,16) C36(17,16) C37(18,16) D1(-18,15) D2(-17,15) D3(-16,15) D4(-15,15) D5(-14,15) D6(-13,15) D7(-12,15) D8(-11,15) D9(-10,15) D10(-9,15) D11(-8,15) D12(-7,15) D13(-6,15) D14(-5,15) D15(-4,15) D16(-3,15) D17(-2,15) D18(-1,15) D19(0,15) D20(1,15) D21(2,15) D22(3,15) D23(4,15) D24(5,15) D25(6,15) D26(7,15) D27(8,15) D28(9,15) D29(10,15) D30(11,15) D31(12,15) D32(13,15) D33(14,15) D34(15,15) D35(16,15) D36(17,15) D37(18,15) E1(-18,14) E2(-17,14) E3(-16,14) E4(-15,14) E5(-14,14) E6(-13,14) E7(-12,14) E8(-11,14) E9(-10,14) E10(-9,14) E11(-8,14) E12(-7,14) E13(-6,14) E14(-5,14) E15(-4,14) E16(-3,14) E17(-2,14) E18(-1,14) E19(0,14) E20(1,14) E21(2,14) E22(3,14) E23(4,14) E24(5,14) E25(6,14) E26(7,14) E27(8,14) E28(9,14) E29(10,14) E30(11,14) E31(12,14) E32(13,14) E33(14,14) E34(15,14) E35(16,14) E36(17,14) E37(18,14) F1(-18,13) F2(-17,13) F3(-16,13) F4(-15,13) F5(-14,13) F6(-13,13) F7(-12,13) F8(-11,13) F9(-10,13) F10(-9,13) F11(-8,13) F12(-7,13) F13(-6,13) F14(-5,13) F15(-4,13) F16(-3,13) F17(-2,13) F18(-1,13) F19(0,13) F20(1,13) F21(2,13) F22(3,13) F23(4,13) F24(5,13) F25(6,13) F26(7,13) F27(8,13) F28(9,13) F29(10,13) F30(11,13) F31(12,13) F32(13,13) F33(14,13) F34(15,13) F35(16,13) F36(17,13) F37(18,13) G1(-18,12) G2(-17,12) G3(-16,12) G4(-15,12) G5(-14,12) G6(-13,12) G7(-12,12) G8(-11,12) G9(-10,12) G10(-9,12) G11(-8,12) G12(-7,12) G13(-6,12) G14(-5,12) G15(-4,12) G16(-3,12) G17(-2,12) G18(-1,12) G19(0,12) G20(1,12) G21(2,12) G22(3,12) G23(4,12) G24(5,12) G25(6,12) G26(7,12) G27(8,12) G28(9,12) G29(10,12) G30(11,12) G31(12,12) G32(13,12) G33(14,12) G34(15,12) G35(16,12) G36(17,12) G37(18,12) H1(-18,11) H2(-17,11) H3(-16,11) H4(-15,11) H5(-14,11) H6(-13,11) H7(-12,11) H8(-11,11) H9(-10,11) H10(-9,11) H11(-8,11) H12(-7,11) H13(-6,11) H14(-5,11) H15(-4,11) H16(-3,11) H17(-2,11) H18(-1,11) H19(0,11) H20(1,11) H21(2,11) H22(3,11) H23(4,11) H24(5,11) H25(6,11) H26(7,11) H27(8,11) H28(9,11) H29(10,11) H30(11,11) H31(12,11) H32(13,11) H33(14,11) H34(15,11) H35(16,11) H36(17,11) H37(18,11) J1(-18,10) J2(-17,10) J3(-16,10) J4(-15,10) J5(-14,10) J6(-13,10) J7(-12,10) J8(-11,10) J9(-10,10) J10(-9,10) J11(-8,10) J12(-7,10) J13(-6,10) J14(-5,10) J15(-4,10) J16(-3,10) J17(-2,10) J18(-1,10) J19(0,10) J20(1,10) J21(2,10) J22(3,10) J23(4,10) J24(5,10) J25(6,10) J26(7,10) J27(8,10) J28(9,10) J29(10,10) J30(11,10) J31(12,10) J32(13,10) J33(14,10) J34(15,10) J35(16,10) J36(17,10) J37(18,10) K1(-18,9) K2(-17,9) K3(-16,9) K4(-15,9) K5(-14,9) K6(-13,9) K7(-12,9) K8(-11,9) K9(-10,9) K10(-9,9) K11(-8,9) K12(-7,9) K13(-6,9) K14(-5,9) K15(-4,9) K16(-3,9) K17(-2,9) K18(-1,9) K19(0,9) K20(1,9) K21(2,9) K22(3,9) K23(4,9) K24(5,9) K25(6,9) K26(7,9) K27(8,9) K28(9,9) K29(10,9) K30(11,9) K31(12,9) K32(13,9) K33(14,9) K34(15,9) K35(16,9) K36(17,9) K37(18,9) L1(-18,8) L2(-17,8) L3(-16,8) L4(-15,8) L5(-14,8) L6(-13,8) L7(-12,8) L8(-11,8) L9(-10,8) L10(-9,8) L11(-8,8) L12(-7,8) L13(-6,8) L14(-5,8) L15(-4,8) L16(-3,8) L17(-2,8) L18(-1,8) L19(0,8) L20(1,8) L21(2,8) L22(3,8) L23(4,8) L24(5,8) L25(6,8) L26(7,8) L27(8,8) L28(9,8) L29(10,8) L30(11,8) L31(12,8) L32(13,8) L33(14,8) L34(15,8) L35(16,8) L36(17,8) L37(18,8) M1(-18,7) M2(-17,7) M3(-16,7) M4(-15,7) M5(-14,7) M6(-13,7) M7(-12,7) M8(-11,7) M9(-10,7) M10(-9,7) M11(-8,7) M12(-7,7) M13(-6,7) M14(-5,7) M15(-4,7) M16(-3,7) M17(-2,7) M18(-1,7) M19(0,7) M20(1,7) M21(2,7) M22(3,7) M23(4,7) M24(5,7) M25(6,7) M26(7,7) M27(8,7) M28(9,7) M29(10,7) M30(11,7) M31(12,7) M32(13,7) M33(14,7) M34(15,7) M35(16,7) M36(17,7) M37(18,7) N1(-18,6) N2(-17,6) N3(-16,6) N4(-15,6) N5(-14,6) N6(-13,6) N7(-12,6) N8(-11,6) N9(-10,6) N10(-9,6) N11(-8,6) N12(-7,6) N13(-6,6) N14(-5,6) N15(-4,6) N16(-3,6) N17(-2,6) N18(-1,6) N19(0,6) N20(1,6) N21(2,6) N22(3,6) N23(4,6) N24(5,6) N25(6,6) N26(7,6) N27(8,6) N28(9,6) N29(10,6) N30(11,6) N31(12,6) N32(13,6) N33(14,6) N34(15,6) N35(16,6) N36(17,6) N37(18,6) P1(-18,5) P2(-17,5) P3(-16,5) P4(-15,5) P5(-14,5) P6(-13,5) P7(-12,5) P8(-11,5) P9(-10,5) P10(-9,5) P11(-8,5) P12(-7,5) P13(-6,5) P14(-5,5) P15(-4,5) P16(-3,5) P17(-2,5) P18(-1,5) P19(0,5) P20(1,5) P21(2,5) P22(3,5) P23(4,5) P24(5,5) P25(6,5) P26(7,5) P27(8,5) P28(9,5) P29(10,5) P30(11,5) P31(12,5) P32(13,5) P33(14,5) P34(15,5) P35(16,5) P36(17,5) P37(18,5) R1(-18,4) R2(-17,4) R3(-16,4) R4(-15,4) R5(-14,4) R6(-13,4) R7(-12,4) R8(-11,4) R9(-10,4) R10(-9,4) R11(-8,4) R12(-7,4) R13(-6,4) R14(-5,4) R15(-4,4) R16(-3,4) R17(-2,4) R18(-1,4) R19(0,4) R20(1,4) R21(2,4) R22(3,4) R23(4,4) R24(5,4) R25(6,4) R26(7,4) R27(8,4) R28(9,4) R29(10,4) R30(11,4) R31(12,4) R32(13,4) R33(14,4) R34(15,4) R35(16,4) R36(17,4) R37(18,4) T1(-18,3) T2(-17,3) T3(-16,3) T4(-15,3) T5(-14,3) T6(-13,3) T7(-12,3) T8(-11,3) T9(-10,3) T10(-9,3) T11(-8,3) T12(-7,3) T13(-6,3) T14(-5,3) T15(-4,3) T16(-3,3) T17(-2,3) T18(-1,3) T19(0,3) T20(1,3) T21(2,3) T22(3,3) T23(4,3) T24(5,3) T25(6,3) T26(7,3) T27(8,3) T28(9,3) T29(10,3) T30(11,3) T31(12,3) T32(13,3) T33(14,3) T34(15,3) T35(16,3) T36(17,3) T37(18,3) U1(-18,2) U2(-17,2) U3(-16,2) U4(-15,2) U5(-14,2) U6(-13,2) U7(-12,2) U8(-11,2) U9(-10,2) U10(-9,2) U11(-8,2) U12(-7,2) U13(-6,2) U14(-5,2) U15(-4,2) U16(-3,2) U17(-2,2) U18(-1,2) U19(0,2) U20(1,2) U21(2,2) U22(3,2) U23(4,2) U24(5,2) U25(6,2) U26(7,2) U27(8,2) U28(9,2) U29(10,2) U30(11,2) U31(12,2) U32(13,2) U33(14,2) U34(15,2) U35(16,2) U36(17,2) U37(18,2) V1(-18,1) V2(-17,1) V3(-16,1) V4(-15,1) V5(-14,1) V6(-13,1) V7(-12,1) V8(-11,1) V9(-10,1) V10(-9,1) V11(-8,1) V12(-7,1) V13(-6,1) V14(-5,1) V15(-4,1) V16(-3,1) V17(-2,1) V18(-1,1) V19(0,1) V20(1,1) V21(2,1) V22(3,1) V23(4,1) V24(5,1) V25(6,1) V26(7,1) V27(8,1) V28(9,1) V29(10,1) V30(11,1) V31(12,1) V32(13,1) V33(14,1) V34(15,1) V35(16,1) V36(17,1) V37(18,1) W1(-18,0) W2(-17,0) W3(-16,0) W4(-15,0) W5(-14,0) W6(-13,0) W7(-12,0) W8(-11,0) W9(-10,0) W10(-9,0) W11(-8,0) W12(-7,0) W13(-6,0) W14(-5,0) W15(-4,0) W16(-3,0) W17(-2,0) W18(-1,0) W19(0,0) W20(1,0) W21(2,0) W22(3,0) W23(4,0) W24(5,0) W25(6,0) W26(7,0) W27(8,0) W28(9,0) W29(10,0) W30(11,0) W31(12,0) W32(13,0) W33(14,0) W34(15,0) W35(16,0) W36(17,0) W37(18,0) Y1(-18,-1) Y2(-17,-1) Y3(-16,-1) Y4(-15,-1) Y5(-14,-1) Y6(-13,-1) Y7(-12,-1) Y8(-11,-1) Y9(-10,-1) Y10(-9,-1) Y11(-8,-1) Y12(-7,-1) Y13(-6,-1) Y14(-5,-1) Y15(-4,-1) Y16(-3,-1) Y17(-2,-1) Y18(-1,-1) Y19(0,-1) Y20(1,-1) Y21(2,-1) Y22(3,-1) Y23(4,-1) Y24(5,-1) Y25(6,-1) Y26(7,-1) Y27(8,-1) Y28(9,-1) Y29(10,-1) Y30(11,-1) Y31(12,-1) Y32(13,-1) Y33(14,-1) Y34(15,-1) Y35(16,-1) Y36(17,-1) Y37(18,-1)
BGA_D8_18C_96SP_7D5W13L1D2H
  round 0.508 smd: (-4.75,-7.5) (4.75,7.5)
  round 0.457 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
BRACKET_56D9X61D_4DPNP_70W65D9L
  round 4.496 hole 4.496 unplated: (-28.45,-30.5) (-28.45,30.5) (28.45,-30.5) (28.45,30.5)
CAP_6D2_2SP_4D3W7D3L2D1H
  rect 2.413x2.794 smd: A(-3.1,0) C(3.1,0)
CAP_6D4_2SP_4D3W7D3L2D1H
  rect 2.413x2.794 smd: A(3.2,0) C(-3.2,0)
CAPALE_6D3PI_5D6_2SP_6D6WL7D6H
  rect 1.6x3.505 smd: A(0,-2.8) C(0,2.8)
CC0201
  rect 0.305x0.305 smd: 1(0,0.267) 2(0,-0.267)
CC0402
  rect 0.559x0.539 smd: 1(0,0.454) 2(0,-0.454)
CC0402_22X22_8OCT
  custom 0.14x0.14 smd: 1(0,0.5) 2(0,-0.5)
CC0603
  rect 0.813x0.813 smd: 1(0,0.762) 2(0,-0.762)
CC0805
  rect 1.27x1.016 smd: 1(0,1.016) 2(0,-1.016)
CC1206
  rect 1.524x1.524 smd: 1(0,1.397) 2(0,-1.397)
CHOKE_6D05_2SP_6D6WL5H
  rect 2.413x3.556 smd: 1(-3.025,0) 2(3.025,0)
CONN_1D27X4D62_2X15SP_22D14W
  rect 0.762x4.115 smd: 1(-8.89,-2.31) 2(-8.89,2.31) 3(-7.62,-2.31) 4(-7.62,2.31) 5(-6.35,-2.31) 6(-6.35,2.31) 7(-5.08,-2.31) 8(-5.08,2.31) 9(-3.81,-2.31) 10(-3.81,2.31) 11(-2.54,-2.31) 12(-2.54,2.31) 13(-1.27,-2.31) 14(-1.27,2.31) 15(0,-2.31) 16(0,2.31) 17(1.27,-2.31) 18(1.27,2.31) 19(2.54,-2.31) 20(2.54,2.31) 21(3.81,-2.31) 22(3.81,2.31) 23(5.08,-2.31) 24(5.08,2.31) 25(6.35,-2.31) 26(6.35,2.31) 27(7.62,-2.31) 28(7.62,2.31) 29(8.89,-2.31) 30(8.89,2.31)
  round 1.702 hole 1.194: G1(-10.44,0) G2(10.44,0)
CONN_1DP_2D54WL8D94H_PIP
  round 1.524 hole 1.016: 1(0,0)
CONN_2D54_3SP_4W7D62L9D3H_1
  rect 1.016x3.302 smd: 1(-2.54,1.25) 2(0,-1.25) 3(2.54,1.25)
CONN_2D54X2D54_3SP_2D5W7D62L
  rect 1.27x3.302 smd: 1(2.54,-1.27) 2(0,1.27) 3(-2.54,-1.27)
CONN_2D54X6D9_2X5SP_20D32W8D8L
  rect 1.016x3.429 smd: 1(-5.08,-3.45) 2(-5.08,3.45) 3(-2.54,-3.45) 4(-2.54,3.45) 5(0,-3.45) 6(0,3.45) 7(2.54,-3.45) 8(2.54,3.45) 9(5.08,-3.45) 10(5.08,3.45)
CONN_4D2X5D5_12X2DP_52W_PIP
  rect 2.311x2.311 hole 1.803: 1(23.1,-2.75)
  round 2.311 hole 1.803: 2(18.9,-2.75) 3(14.7,-2.75) 4(10.5,-2.75) 5(6.3,-2.75) 6(2.1,-2.75) 7(-2.1,-2.75) 8(-6.3,-2.75) 9(-10.5,-2.75) 10(-14.7,-2.75) 11(-18.9,-2.75) 12(-23.1,-2.75) 13(23.1,2.75) 14(18.9,2.75) 15(14.7,2.75) 16(10.5,2.75) 17(6.3,2.75) 18(2.1,2.75) 19(-2.1,2.75) 20(-6.3,2.75) 21(-10.5,2.75) 22(-14.7,2.75) 23(-18.9,2.75) 24(-23.1,2.75)
CONN_D5X5D4X6D6_110X4SP_61D9W
  round 0.914 hole 0.914 unplated: (-28.85,6) (-28.85,-6)
  round 1.6 hole 1.6 unplated: (28.85,6) (28.85,-6)
  rect 0.457x1.219 smd: A1(-27.323,-8.7) A110(27.322,-8.7) B1(-27.323,-3.3) B110(27.322,-3.3) C1(-27.323,3.3) C110(27.322,3.3) D1(-27.323,8.7) D110(27.322,8.7)
  rect 0.305x1.219 smd: A2(-26.75,-8.7) A3(-26.25,-8.7) A4(-25.75,-8.7) A5(-25.25,-8.7) A6(-24.75,-8.7) A7(-24.25,-8.7) A8(-23.75,-8.7) A9(-23.25,-8.7) A10(-22.75,-8.7) A11(-22.25,-8.7) A12(-21.75,-8.7) A13(-21.25,-8.7) A14(-20.75,-8.7) A15(-20.25,-8.7) A16(-19.75,-8.7) A17(-19.25,-8.7) A18(-18.75,-8.7) A19(-18.25,-8.7) A20(-17.75,-8.7) A21(-17.25,-8.7) A22(-16.75,-8.7) A23(-16.25,-8.7) A24(-15.75,-8.7) A25(-15.25,-8.7) A26(-14.75,-8.7) A27(-14.25,-8.7) A28(-13.75,-8.7) A29(-13.25,-8.7) A30(-12.75,-8.7) A31(-12.25,-8.7) A32(-11.75,-8.7) A33(-11.25,-8.7) A34(-10.75,-8.7) A35(-10.25,-8.7) A36(-9.75,-8.7) A37(-9.25,-8.7) A38(-8.75,-8.7) A39(-8.25,-8.7) A40(-7.75,-8.7) A41(-7.25,-8.7) A42(-6.75,-8.7) A43(-6.25,-8.7) A44(-5.75,-8.7) A45(-5.25,-8.7) A46(-4.75,-8.7) A47(-4.25,-8.7) A48(-3.75,-8.7) A49(-3.25,-8.7) A50(-2.75,-8.7) A51(-2.25,-8.7) A52(-1.75,-8.7) A53(-1.25,-8.7) A54(-0.75,-8.7) A55(-0.25,-8.7) A56(0.25,-8.7) A57(0.75,-8.7) A58(1.25,-8.7) A59(1.75,-8.7) A60(2.25,-8.7) A61(2.75,-8.7) A62(3.25,-8.7) A63(3.75,-8.7) A64(4.25,-8.7) A65(4.75,-8.7) A66(5.25,-8.7) A67(5.75,-8.7) A68(6.25,-8.7) A69(6.75,-8.7) A70(7.25,-8.7) A71(7.75,-8.7) A72(8.25,-8.7) A73(8.75,-8.7) A74(9.25,-8.7) A75(9.75,-8.7) A76(10.25,-8.7) A77(10.75,-8.7) A78(11.25,-8.7) A79(11.75,-8.7) A80(12.25,-8.7) A81(12.75,-8.7) A82(13.25,-8.7) A83(13.75,-8.7) A84(14.25,-8.7) A85(14.75,-8.7) A86(15.25,-8.7) A87(15.75,-8.7) A88(16.25,-8.7) A89(16.75,-8.7) A90(17.25,-8.7) A91(17.75,-8.7) A92(18.25,-8.7) A93(18.75,-8.7) A94(19.25,-8.7) A95(19.75,-8.7) A96(20.25,-8.7) A97(20.75,-8.7) A98(21.25,-8.7) A99(21.75,-8.7) A100(22.25,-8.7) A101(22.75,-8.7) A102(23.25,-8.7) A103(23.75,-8.7) A104(24.25,-8.7) A105(24.75,-8.7) A106(25.25,-8.7) A107(25.75,-8.7) A108(26.25,-8.7) A109(26.75,-8.7) B2(-26.75,-3.3) B3(-26.25,-3.3) B4(-25.75,-3.3) B5(-25.25,-3.3) B6(-24.75,-3.3) B7(-24.25,-3.3) B8(-23.75,-3.3) B9(-23.25,-3.3) B10(-22.75,-3.3) B11(-22.25,-3.3) B12(-21.75,-3.3) B13(-21.25,-3.3) B14(-20.75,-3.3) B15(-20.25,-3.3) B16(-19.75,-3.3) B17(-19.25,-3.3) B18(-18.75,-3.3) B19(-18.25,-3.3) B20(-17.75,-3.3) B21(-17.25,-3.3) B22(-16.75,-3.3) B23(-16.25,-3.3) B24(-15.75,-3.3) B25(-15.25,-3.3) B26(-14.75,-3.3) B27(-14.25,-3.3) B28(-13.75,-3.3) B29(-13.25,-3.3) B30(-12.75,-3.3) B31(-12.25,-3.3) B32(-11.75,-3.3) B33(-11.25,-3.3) B34(-10.75,-3.3) B35(-10.25,-3.3) B36(-9.75,-3.3) B37(-9.25,-3.3) B38(-8.75,-3.3) B39(-8.25,-3.3) B40(-7.75,-3.3) B41(-7.25,-3.3) B42(-6.75,-3.3) B43(-6.25,-3.3) B44(-5.75,-3.3) B45(-5.25,-3.3) B46(-4.75,-3.3) B47(-4.25,-3.3) B48(-3.75,-3.3) B49(-3.25,-3.3) B50(-2.75,-3.3) B51(-2.25,-3.3) B52(-1.75,-3.3) B53(-1.25,-3.3) B54(-0.75,-3.3) B55(-0.25,-3.3) B56(0.25,-3.3) B57(0.75,-3.3) B58(1.25,-3.3) B59(1.75,-3.3) B60(2.25,-3.3) B61(2.75,-3.3) B62(3.25,-3.3) B63(3.75,-3.3) B64(4.25,-3.3) B65(4.75,-3.3) B66(5.25,-3.3) B67(5.75,-3.3) B68(6.25,-3.3) B69(6.75,-3.3) B70(7.25,-3.3) B71(7.75,-3.3) B72(8.25,-3.3) B73(8.75,-3.3) B74(9.25,-3.3) B75(9.75,-3.3) B76(10.25,-3.3) B77(10.75,-3.3) B78(11.25,-3.3) B79(11.75,-3.3) B80(12.25,-3.3) B81(12.75,-3.3) B82(13.25,-3.3) B83(13.75,-3.3) B84(14.25,-3.3) B85(14.75,-3.3) B86(15.25,-3.3) B87(15.75,-3.3) B88(16.25,-3.3) B89(16.75,-3.3) B90(17.25,-3.3) B91(17.75,-3.3) B92(18.25,-3.3) B93(18.75,-3.3) B94(19.25,-3.3) B95(19.75,-3.3) B96(20.25,-3.3) B97(20.75,-3.3) B98(21.25,-3.3) B99(21.75,-3.3) B100(22.25,-3.3) B101(22.75,-3.3) B102(23.25,-3.3) B103(23.75,-3.3) B104(24.25,-3.3) B105(24.75,-3.3) B106(25.25,-3.3) B107(25.75,-3.3) B108(26.25,-3.3) B109(26.75,-3.3) C2(-26.75,3.3) C3(-26.25,3.3) C4(-25.75,3.3) C5(-25.25,3.3) C6(-24.75,3.3) C7(-24.25,3.3) C8(-23.75,3.3) C9(-23.25,3.3) C10(-22.75,3.3) C11(-22.25,3.3) C12(-21.75,3.3) C13(-21.25,3.3) C14(-20.75,3.3) C15(-20.25,3.3) C16(-19.75,3.3) C17(-19.25,3.3) C18(-18.75,3.3) C19(-18.25,3.3) C20(-17.75,3.3) C21(-17.25,3.3) C22(-16.75,3.3) C23(-16.25,3.3) C24(-15.75,3.3) C25(-15.25,3.3) C26(-14.75,3.3) C27(-14.25,3.3) C28(-13.75,3.3) C29(-13.25,3.3) C30(-12.75,3.3) C31(-12.25,3.3) C32(-11.75,3.3) C33(-11.25,3.3) C34(-10.75,3.3) C35(-10.25,3.3) C36(-9.75,3.3) C37(-9.25,3.3) C38(-8.75,3.3) C39(-8.25,3.3) C40(-7.75,3.3) C41(-7.25,3.3) C42(-6.75,3.3) C43(-6.25,3.3) C44(-5.75,3.3) C45(-5.25,3.3) C46(-4.75,3.3) C47(-4.25,3.3) C48(-3.75,3.3) C49(-3.25,3.3) C50(-2.75,3.3) C51(-2.25,3.3) C52(-1.75,3.3) C53(-1.25,3.3) C54(-0.75,3.3) C55(-0.25,3.3) C56(0.25,3.3) C57(0.75,3.3) C58(1.25,3.3) C59(1.75,3.3) C60(2.25,3.3) C61(2.75,3.3) C62(3.25,3.3) C63(3.75,3.3) C64(4.25,3.3) C65(4.75,3.3) C66(5.25,3.3) C67(5.75,3.3) C68(6.25,3.3) C69(6.75,3.3) C70(7.25,3.3) C71(7.75,3.3) C72(8.25,3.3) C73(8.75,3.3) C74(9.25,3.3) C75(9.75,3.3) C76(10.25,3.3) C77(10.75,3.3) C78(11.25,3.3) C79(11.75,3.3) C80(12.25,3.3) C81(12.75,3.3) C82(13.25,3.3) C83(13.75,3.3) C84(14.25,3.3) C85(14.75,3.3) C86(15.25,3.3) C87(15.75,3.3) C88(16.25,3.3) C89(16.75,3.3) C90(17.25,3.3) C91(17.75,3.3) C92(18.25,3.3) C93(18.75,3.3) C94(19.25,3.3) C95(19.75,3.3) C96(20.25,3.3) C97(20.75,3.3) C98(21.25,3.3) C99(21.75,3.3) C100(22.25,3.3) C101(22.75,3.3) C102(23.25,3.3) C103(23.75,3.3) C104(24.25,3.3) C105(24.75,3.3) C106(25.25,3.3) C107(25.75,3.3) C108(26.25,3.3) C109(26.75,3.3) D2(-26.75,8.7) D3(-26.25,8.7) D4(-25.75,8.7) D5(-25.25,8.7) D6(-24.75,8.7) D7(-24.25,8.7) D8(-23.75,8.7) D9(-23.25,8.7) D10(-22.75,8.7) D11(-22.25,8.7) D12(-21.75,8.7) D13(-21.25,8.7) D14(-20.75,8.7) D15(-20.25,8.7) D16(-19.75,8.7) D17(-19.25,8.7) D18(-18.75,8.7) D19(-18.25,8.7) D20(-17.75,8.7) D21(-17.25,8.7) D22(-16.75,8.7) D23(-16.25,8.7) D24(-15.75,8.7) D25(-15.25,8.7) D26(-14.75,8.7) D27(-14.25,8.7) D28(-13.75,8.7) D29(-13.25,8.7) D30(-12.75,8.7) D31(-12.25,8.7) D32(-11.75,8.7) D33(-11.25,8.7) D34(-10.75,8.7) D35(-10.25,8.7) D36(-9.75,8.7) D37(-9.25,8.7) D38(-8.75,8.7) D39(-8.25,8.7) D40(-7.75,8.7) D41(-7.25,8.7) D42(-6.75,8.7) D43(-6.25,8.7) D44(-5.75,8.7) D45(-5.25,8.7) D46(-4.75,8.7) D47(-4.25,8.7) D48(-3.75,8.7) D49(-3.25,8.7) D50(-2.75,8.7) D51(-2.25,8.7) D52(-1.75,8.7) D53(-1.25,8.7) D54(-0.75,8.7) D55(-0.25,8.7) D56(0.25,8.7) D57(0.75,8.7) D58(1.25,8.7) D59(1.75,8.7) D60(2.25,8.7) D61(2.75,8.7) D62(3.25,8.7) D63(3.75,8.7) D64(4.25,8.7) D65(4.75,8.7) D66(5.25,8.7) D67(5.75,8.7) D68(6.25,8.7) D69(6.75,8.7) D70(7.25,8.7) D71(7.75,8.7) D72(8.25,8.7) D73(8.75,8.7) D74(9.25,8.7) D75(9.75,8.7) D76(10.25,8.7) D77(10.75,8.7) D78(11.25,8.7) D79(11.75,8.7) D80(12.25,8.7) D81(12.75,8.7) D82(13.25,8.7) D83(13.75,8.7) D84(14.25,8.7) D85(14.75,8.7) D86(15.25,8.7) D87(15.75,8.7) D88(16.25,8.7) D89(16.75,8.7) D90(17.25,8.7) D91(17.75,8.7) D92(18.25,8.7) D93(18.75,8.7) D94(19.25,8.7) D95(19.75,8.7) D96(20.25,8.7) D97(20.75,8.7) D98(21.25,8.7) D99(21.75,8.7) D100(22.25,8.7) D101(22.75,8.7) D102(23.25,8.7) D103(23.75,8.7) D104(24.25,8.7) D105(24.75,8.7) D106(25.25,8.7) D107(25.75,8.7) D108(26.25,8.7) D109(26.75,8.7)
  custom 0.412x0.412 smd: G1(-30.575,6) G2(-30.575,-6) G3(30.575,6) G4(30.575,-6)
CONN_D5X7D55_75SP_7NP_21D9W4D2H
  round 1.118 hole 1.118 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.524 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.27x2.794 smd: G1(-10.35,4.5) G2(10.35,4.5)
CONNM_1D27X4D05_2X10SP_27D2W
  rect 0.762x2.54 smd: 1(-5.715,-2.025) 2(-5.715,2.025) 3(-4.445,-2.025) 4(-4.445,2.025) 5(-3.175,-2.025) 6(-3.175,2.025) 7(-1.905,-2.025) 8(-1.905,2.025) 9(-0.635,-2.025) 10(-0.635,2.025) 11(0.635,-2.025) 12(0.635,2.025) 13(1.905,-2.025) 14(1.905,2.025) 15(3.175,-2.025) 16(3.175,2.025) 17(4.445,-2.025) 18(4.445,2.025) 19(5.715,-2.025) 20(5.715,2.025)
CONNM_2D54X4D65_2X5SP_12D7W5L
  rect 1.016x3.556 smd: 1(5.08,2.325) 2(5.08,-2.325) 3(2.54,2.325) 4(2.54,-2.325) 5(0,2.325) 6(0,-2.325) 7(-2.54,2.325) 8(-2.54,-2.325) 9(-5.08,2.325) 10(-5.08,-2.325)
CONNM_2DX4D27_2X4SP_3D937W
  rect 0.889x2.794 smd: 1(-3,-2.135) 2(-3,2.135) 3(-1,-2.135) 4(-1,2.135) 5(1,-2.135) 6(1,2.135) 7(3,-2.135) 8(3,2.135)
DO214AA_4D_2SP_3D625W5D35L2D65H
  rect 2.032x2.794 smd: 1(2,0) 2(-2,0)
FBGA_1D_20C_324SP_19WL1D55H
  round 0.508 smd: (-10.5,-10.5) (10.5,10.5) A1(-8.5,8.5) A2(-7.5,8.5) A3(-6.5,8.5) A4(-5.5,8.5) A5(-4.5,8.5) A6(-3.5,8.5) A7(-2.5,8.5) A8(-1.5,8.5) A9(-0.5,8.5) A10(0.5,8.5) A11(1.5,8.5) A12(2.5,8.5) A13(3.5,8.5) A14(4.5,8.5) A15(5.5,8.5) A16(6.5,8.5) A17(7.5,8.5) A18(8.5,8.5) B1(-8.5,7.5) B2(-7.5,7.5) B3(-6.5,7.5) B4(-5.5,7.5) B5(-4.5,7.5) B6(-3.5,7.5) B7(-2.5,7.5) B8(-1.5,7.5) B9(-0.5,7.5) B10(0.5,7.5) B11(1.5,7.5) B12(2.5,7.5) B13(3.5,7.5) B14(4.5,7.5) B15(5.5,7.5) B16(6.5,7.5) B17(7.5,7.5) B18(8.5,7.5) C1(-8.5,6.5) C2(-7.5,6.5) C3(-6.5,6.5) C4(-5.5,6.5) C5(-4.5,6.5) C6(-3.5,6.5) C7(-2.5,6.5) C8(-1.5,6.5) C9(-0.5,6.5) C10(0.5,6.5) C11(1.5,6.5) C12(2.5,6.5) C13(3.5,6.5) C14(4.5,6.5) C15(5.5,6.5) C16(6.5,6.5) C17(7.5,6.5) C18(8.5,6.5) D1(-8.5,5.5) D2(-7.5,5.5) D3(-6.5,5.5) D4(-5.5,5.5) D5(-4.5,5.5) D6(-3.5,5.5) D7(-2.5,5.5) D8(-1.5,5.5) D9(-0.5,5.5) D10(0.5,5.5) D11(1.5,5.5) D12(2.5,5.5) D13(3.5,5.5) D14(4.5,5.5) D15(5.5,5.5) D16(6.5,5.5) D17(7.5,5.5) D18(8.5,5.5) E1(-8.5,4.5) E2(-7.5,4.5) E3(-6.5,4.5) E4(-5.5,4.5) E5(-4.5,4.5) E6(-3.5,4.5) E7(-2.5,4.5) E8(-1.5,4.5) E9(-0.5,4.5) E10(0.5,4.5) E11(1.5,4.5) E12(2.5,4.5) E13(3.5,4.5) E14(4.5,4.5) E15(5.5,4.5) E16(6.5,4.5) E17(7.5,4.5) E18(8.5,4.5) F1(-8.5,3.5) F2(-7.5,3.5) F3(-6.5,3.5) F4(-5.5,3.5) F5(-4.5,3.5) F6(-3.5,3.5) F7(-2.5,3.5) F8(-1.5,3.5) F9(-0.5,3.5) F10(0.5,3.5) F11(1.5,3.5) F12(2.5,3.5) F13(3.5,3.5) F14(4.5,3.5) F15(5.5,3.5) F16(6.5,3.5) F17(7.5,3.5) F18(8.5,3.5) G1(-8.5,2.5) G2(-7.5,2.5) G3(-6.5,2.5) G4(-5.5,2.5) G5(-4.5,2.5) G6(-3.5,2.5) G7(-2.5,2.5) G8(-1.5,2.5) G9(-0.5,2.5) G10(0.5,2.5) G11(1.5,2.5) G12(2.5,2.5) G13(3.5,2.5) G14(4.5,2.5) G15(5.5,2.5) G16(6.5,2.5) G17(7.5,2.5) G18(8.5,2.5) H1(-8.5,1.5) H2(-7.5,1.5) H3(-6.5,1.5) H4(-5.5,1.5) H5(-4.5,1.5) H6(-3.5,1.5) H7(-2.5,1.5) H8(-1.5,1.5) H9(-0.5,1.5) H10(0.5,1.5) H11(1.5,1.5) H12(2.5,1.5) H13(3.5,1.5) H14(4.5,1.5) H15(5.5,1.5) H16(6.5,1.5) H17(7.5,1.5) H18(8.5,1.5) J1(-8.5,0.5) J2(-7.5,0.5) J3(-6.5,0.5) J4(-5.5,0.5) J5(-4.5,0.5) J6(-3.5,0.5) J7(-2.5,0.5) J8(-1.5,0.5) J9(-0.5,0.5) J10(0.5,0.5) J11(1.5,0.5) J12(2.5,0.5) J13(3.5,0.5) J14(4.5,0.5) J15(5.5,0.5) J16(6.5,0.5) J17(7.5,0.5) J18(8.5,0.5) K1(-8.5,-0.5) K2(-7.5,-0.5) K3(-6.5,-0.5) K4(-5.5,-0.5) K5(-4.5,-0.5) K6(-3.5,-0.5) K7(-2.5,-0.5) K8(-1.5,-0.5) K9(-0.5,-0.5) K10(0.5,-0.5) K11(1.5,-0.5) K12(2.5,-0.5) K13(3.5,-0.5) K14(4.5,-0.5) K15(5.5,-0.5) K16(6.5,-0.5) K17(7.5,-0.5) K18(8.5,-0.5) L1(-8.5,-1.5) L2(-7.5,-1.5) L3(-6.5,-1.5) L4(-5.5,-1.5) L5(-4.5,-1.5) L6(-3.5,-1.5) L7(-2.5,-1.5) L8(-1.5,-1.5) L9(-0.5,-1.5) L10(0.5,-1.5) L11(1.5,-1.5) L12(2.5,-1.5) L13(3.5,-1.5) L14(4.5,-1.5) L15(5.5,-1.5) L16(6.5,-1.5) L17(7.5,-1.5) L18(8.5,-1.5) M1(-8.5,-2.5) M2(-7.5,-2.5) M3(-6.5,-2.5) M4(-5.5,-2.5) M5(-4.5,-2.5) M6(-3.5,-2.5) M7(-2.5,-2.5) M8(-1.5,-2.5) M9(-0.5,-2.5) M10(0.5,-2.5) M11(1.5,-2.5) M12(2.5,-2.5) M13(3.5,-2.5) M14(4.5,-2.5) M15(5.5,-2.5) M16(6.5,-2.5) M17(7.5,-2.5) M18(8.5,-2.5) N1(-8.5,-3.5) N2(-7.5,-3.5) N3(-6.5,-3.5) N4(-5.5,-3.5) N5(-4.5,-3.5) N6(-3.5,-3.5) N7(-2.5,-3.5) N8(-1.5,-3.5) N9(-0.5,-3.5) N10(0.5,-3.5) N11(1.5,-3.5) N12(2.5,-3.5) N13(3.5,-3.5) N14(4.5,-3.5) N15(5.5,-3.5) N16(6.5,-3.5) N17(7.5,-3.5) N18(8.5,-3.5) P1(-8.5,-4.5) P2(-7.5,-4.5) P3(-6.5,-4.5) P4(-5.5,-4.5) P5(-4.5,-4.5) P6(-3.5,-4.5) P7(-2.5,-4.5) P8(-1.5,-4.5) P9(-0.5,-4.5) P10(0.5,-4.5) P11(1.5,-4.5) P12(2.5,-4.5) P13(3.5,-4.5) P14(4.5,-4.5) P15(5.5,-4.5) P16(6.5,-4.5) P17(7.5,-4.5) P18(8.5,-4.5) R1(-8.5,-5.5) R2(-7.5,-5.5) R3(-6.5,-5.5) R4(-5.5,-5.5) R5(-4.5,-5.5) R6(-3.5,-5.5) R7(-2.5,-5.5) R8(-1.5,-5.5) R9(-0.5,-5.5) R10(0.5,-5.5) R11(1.5,-5.5) R12(2.5,-5.5) R13(3.5,-5.5) R14(4.5,-5.5) R15(5.5,-5.5) R16(6.5,-5.5) R17(7.5,-5.5) R18(8.5,-5.5) T1(-8.5,-6.5) T2(-7.5,-6.5) T3(-6.5,-6.5) T4(-5.5,-6.5) T5(-4.5,-6.5) T6(-3.5,-6.5) T7(-2.5,-6.5) T8(-1.5,-6.5) T9(-0.5,-6.5) T10(0.5,-6.5) T11(1.5,-6.5) T12(2.5,-6.5) T13(3.5,-6.5) T14(4.5,-6.5) T15(5.5,-6.5) T16(6.5,-6.5) T17(7.5,-6.5) T18(8.5,-6.5) U1(-8.5,-7.5) U2(-7.5,-7.5) U3(-6.5,-7.5) U4(-5.5,-7.5) U5(-4.5,-7.5) U6(-3.5,-7.5) U7(-2.5,-7.5) U8(-1.5,-7.5) U9(-0.5,-7.5) U10(0.5,-7.5) U11(1.5,-7.5) U12(2.5,-7.5) U13(3.5,-7.5) U14(4.5,-7.5) U15(5.5,-7.5) U16(6.5,-7.5) U17(7.5,-7.5) U18(8.5,-7.5) V1(-8.5,-8.5) V2(-7.5,-8.5) V3(-6.5,-8.5) V4(-5.5,-8.5) V5(-4.5,-8.5) V6(-3.5,-8.5) V7(-2.5,-8.5) V8(-1.5,-8.5) V9(-0.5,-8.5) V10(0.5,-8.5) V11(1.5,-8.5) V12(2.5,-8.5) V13(3.5,-8.5) V14(4.5,-8.5) V15(5.5,-8.5) V16(6.5,-8.5) V17(7.5,-8.5) V18(8.5,-8.5)
FILTER_2D54X7D5_4SP_6W9D2L5H
  rect 2.032x1.27 smd: 1(-3.75,1.27) 2(-3.75,-1.27) 3(3.75,-1.27) 4(3.75,1.27)
FUSE_5D8_2SP_6D1W2D49L
  rect 2.794x2.794 smd: 1(-2.9,0) 2(2.9,0)
HSINK_61DX56D9_4DP_74D4W_OSP
  round 4.496 hole 4.496 unplated: (-30.5,28.45) (-30.5,-28.45) (30.5,28.45) (30.5,-28.45)
  round 0.559 hole 0.305: 1(-30.489,31.6) 2(30.511,31.6) 3(-30.489,-25.3) 4(30.511,-25.3)
IND_1D6_2SP_1D6W2L1H
  rect 1.778x1.016 smd: 1(0,0.8) 2(0,-0.8)
IND_2D_2SP_2W2D5L1D2H_MAGLAYERS
  rect 1.27x2.54 smd: 1(-1,0) 2(1,0)
IND_5D1_2SP_7D1WL4D2H
  rect 2.794x2.286 smd: 1(-2.55,0) 2(2.55,0)
IND_6D1_2SP_7D3W7D5L6H_1
  rect 2.667x2.032 smd: 1(-3.431,0) 2(3.431,0)
IND_7D7_2SP_7D8W10D2L_1
  rect 2.54x3.81 smd: 1(0,4.231) 2(0,-4.231)
IND_11D1_2SP_12D5WL6H
  rect 3.683x4.953 smd: 1(-5.55,0) 2(5.55,0)
LC0402
  rect 0.559x0.539 smd: 1(0,0.454) 2(0,-0.454)
LC0603
  rect 0.813x0.813 smd: 1(0,0.762) 2(0,-0.762)
LC0805
  rect 1.524x1.27 smd: 1(0,1.016) 2(0,-1.016)
LC3312
  rect 4.064x2.54 smd: 1(0,4.509) 2(0,-4.509)
LC3312_1
  rect 1.524x2.794 smd: 1(0,4.015) 2(0,-4.015)
LED_1D2XD7_4SP_1D6WD8L
  rect 0.508x0.406 smd: A1(-0.6,0.35) A2(-0.6,-0.35) C1(0.6,0.35) C2(0.6,-0.35)
LED_1D2XD7_4SP_1D6WD8L_1
  rect 0.711x0.406 smd: A1(-0.702,0.35) A2(-0.702,-0.35) C1(0.702,0.35) C2(0.702,-0.35)
LED_1D5_2SP_D8W1D6LD6H_AC
  rect 0.813x0.813 smd: A(0,0.75) C(0,-0.75)
LED_1D6XD9_4SP_1D6WL_AC
  rect 0.813x0.559 smd: A(0.8,-0.45) C1(-0.8,-0.45) C2(-0.8,0.45) C3(0.8,0.45)
LED_2D8_2SP_3W2L1H_AC
  rect 1.016x1.016 smd: A(1.4,0) C(-1.4,0)
LED_3D5_3SP_1W3L_A_C1_C2
  rect 1.524x1.524 smd: A(1.75,0) C1(-1.75,0)
  rect 0.914x0.914 smd: C2(0,-0.65)
LED_3D_2SP_1W3L_AC
  rect 1.016x0.61 smd: (0,-0.4)
  rect 0.813x1.422 smd: A(1.5,0) C(-1.5,0)
LED_3D_3SP_3W2L_AC1C2
  rect 1.016x1.524 smd: A(1.5,0) C1(-1.5,0)
  rect 0.914x0.914 smd: C2(0,-0.65)
LED_D85_4SP_1WLD25H
  rect 0.457x0.457 smd: A(0.425,-0.425) C1(-0.425,-0.425) C2(-0.425,0.425) C3(0.425,0.425)
MOS_1D358X1D7545_5SP_5W3D5L
  rect 0.33x0.33 smd: 1(-1.755,-1.048) 4(1.282,-1.048)
  rect 0.508x1.778 smd: 2(-1.754,0.31)
  custom 0.564x0.564 smd: 3(0,0)
  rect 0.508x3.505 smd: 5(2.25,0)
MT_RJ_D8_38SP_18D2W12D5L
  round 1.6 hole 1.6 unplated: (-8.4,-8.635) (8.4,-8.635)
  rect 0.356x1.803 smd: 1(-7,-1.265) 2(-6.2,-1.265) 3(-5.4,-1.265) 4(-4.6,-1.265) 5(-3.8,-1.265) 6(-3,-1.265) 7(-2.2,-1.265) 8(-1.4,-1.265) 9(-0.6,-1.265) 10(0.2,-1.265) 11(1,-1.265) 12(1.8,-1.265) 13(2.6,-1.265) 14(3.4,-1.265) 15(4.2,-1.265) 16(5,-1.265) 17(5.8,-1.265) 18(6.6,-1.265) 19(7.4,-1.265) 20(7,1.245) 21(6.2,1.245) 22(5.4,1.245) 23(4.6,1.245) 24(3.8,1.245) 25(3,1.245) 26(2.2,1.245) 27(1.4,1.245) 28(0.6,1.245) 29(-0.2,1.245) 30(-1,1.245) 31(-1.8,1.245) 32(-2.6,1.245) 33(-3.4,1.245) 34(-4.2,1.245) 35(-5,1.245) 36(-5.8,1.245) 37(-6.6,1.245) 38(-7.4,1.245)
MT_RJS_2X6X20DP_86D35W63D25L_PF
  round 1.6 hole 1.6 unplated: (0,0) (9.8,0) (14.25,0) (24.05,0) (28.5,0) (38.3,0) (42.75,0) (52.55,0) (57,0) (66.8,0) (71.25,0) (81.05,0)
  round 0.635 hole 0.371: 1L1(8.5,4.5) 1L2(7.7,3.8) 1L3(6.9,5.2) 1L4(6.1,4.5) 1L5(5.3,3.8) 1L6(4.5,5.2) 1L7(3.7,4.5) 1L8(2.9,3.8) 1L9(2.1,5.2) 1L10(1.3,4.5) 1L11(1.3,1.5) 1L12(2.1,2.2) 1L13(2.9,0.8) 1L14(3.7,1.5) 1L15(4.5,2.2) 1L16(5.3,0.8) 1L17(6.1,1.5) 1L18(6.9,2.2) 1L19(7.7,0.8) 1L20(8.5,1.5) 1T1(1.3,7.5) 1T2(2.1,8.2) 1T3(2.9,6.8) 1T4(3.7,7.5) 1T5(4.5,8.2) 1T6(5.3,6.8) 1T7(6.1,7.5) 1T8(6.9,8.2) 1T9(7.7,6.8) 1T10(8.5,7.5) 1T11(8.5,10.5) 1T12(7.7,9.8) 1T13(6.9,11.2) 1T14(6.1,10.5) 1T15(5.3,9.8) 1T16(4.5,11.2) 1T17(3.7,10.5) 1T18(2.9,9.8) 1T19(2.1,11.2) 1T20(1.3,10.5) 2L1(22.75,4.5) 2L2(21.95,3.8) 2L3(21.15,5.2) 2L4(20.35,4.5) 2L5(19.55,3.8) 2L6(18.75,5.2) 2L7(17.95,4.5) 2L8(17.15,3.8) 2L9(16.35,5.2) 2L10(15.55,4.5) 2L11(15.55,1.5) 2L12(16.35,2.2) 2L13(17.15,0.8) 2L14(17.95,1.5) 2L15(18.75,2.2) 2L16(19.55,0.8) 2L17(20.35,1.5) 2L18(21.15,2.2) 2L19(21.95,0.8) 2L20(22.75,1.5) 2T1(15.55,7.5) 2T2(16.35,8.2) 2T3(17.15,6.8) 2T4(17.95,7.5) 2T5(18.75,8.2) 2T6(19.55,6.8) 2T7(20.35,7.5) 2T8(21.15,8.2) 2T9(21.95,6.8) 2T10(22.75,7.5) 2T11(22.75,10.5) 2T12(21.95,9.8) 2T13(21.15,11.2) 2T14(20.35,10.5) 2T15(19.55,9.8) 2T16(18.75,11.2) 2T17(17.95,10.5) 2T18(17.15,9.8) 2T19(16.35,11.2) 2T20(15.55,10.5) 3L1(37,4.5) 3L2(36.2,3.8) 3L3(35.4,5.2) 3L4(34.6,4.5) 3L5(33.8,3.8) 3L6(33,5.2) 3L7(32.2,4.5) 3L8(31.4,3.8) 3L9(30.6,5.2) 3L10(29.8,4.5) 3L11(29.8,1.5) 3L12(30.6,2.2) 3L13(31.4,0.8) 3L14(32.2,1.5) 3L15(33,2.2) 3L16(33.8,0.8) 3L17(34.6,1.5) 3L18(35.4,2.2) 3L19(36.2,0.8) 3L20(37,1.5) 3T1(29.8,7.5) 3T2(30.6,8.2) 3T3(31.4,6.8) 3T4(32.2,7.5) 3T5(33,8.2) 3T6(33.8,6.8) 3T7(34.6,7.5) 3T8(35.4,8.2) 3T9(36.2,6.8) 3T10(37,7.5) 3T11(37,10.5) 3T12(36.2,9.8) 3T13(35.4,11.2) 3T14(34.6,10.5) 3T15(33.8,9.8) 3T16(33,11.2) 3T17(32.2,10.5) 3T18(31.4,9.8) 3T19(30.6,11.2) 3T20(29.8,10.5) 4L1(51.25,4.5) 4L2(50.45,3.8) 4L3(49.65,5.2) 4L4(48.85,4.5) 4L5(48.05,3.8) 4L6(47.25,5.2) 4L7(46.45,4.5) 4L8(45.65,3.8) 4L9(44.85,5.2) 4L10(44.05,4.5) 4L11(44.05,1.5) 4L12(44.85,2.2) 4L13(45.65,0.8) 4L14(46.45,1.5) 4L15(47.25,2.2) 4L16(48.05,0.8) 4L17(48.85,1.5) 4L18(49.65,2.2) 4L19(50.45,0.8) 4L20(51.25,1.5) 4T1(44.05,7.5) 4T2(44.85,8.2) 4T3(45.65,6.8) 4T4(46.45,7.5) 4T5(47.25,8.2) 4T6(48.05,6.8) 4T7(48.85,7.5) 4T8(49.65,8.2) 4T9(50.45,6.8) 4T10(51.25,7.5) 4T11(51.25,10.5) 4T12(50.45,9.8) 4T13(49.65,11.2) 4T14(48.85,10.5) 4T15(48.05,9.8) 4T16(47.25,11.2) 4T17(46.45,10.5) 4T18(45.65,9.8) 4T19(44.85,11.2) 4T20(44.05,10.5) 5L1(65.5,4.5) 5L2(64.7,3.8) 5L3(63.9,5.2) 5L4(63.1,4.5) 5L5(62.3,3.8) 5L6(61.5,5.2) 5L7(60.7,4.5) 5L8(59.9,3.8) 5L9(59.1,5.2) 5L10(58.3,4.5) 5L11(58.3,1.5) 5L12(59.1,2.2) 5L13(59.9,0.8) 5L14(60.7,1.5) 5L15(61.5,2.2) 5L16(62.3,0.8) 5L17(63.1,1.5) 5L18(63.9,2.2) 5L19(64.7,0.8) 5L20(65.5,1.5) 5T1(58.3,7.5) 5T2(59.1,8.2) 5T3(59.9,6.8) 5T4(60.7,7.5) 5T5(61.5,8.2) 5T6(62.3,6.8) 5T7(63.1,7.5) 5T8(63.9,8.2) 5T9(64.7,6.8) 5T10(65.5,7.5) 5T11(65.5,10.5) 5T12(64.7,9.8) 5T13(63.9,11.2) 5T14(63.1,10.5) 5T15(62.3,9.8) 5T16(61.5,11.2) 5T17(60.7,10.5) 5T18(59.9,9.8) 5T19(59.1,11.2) 5T20(58.3,10.5) 6L1(79.75,4.5) 6L2(78.95,3.8) 6L3(78.15,5.2) 6L4(77.35,4.5) 6L5(76.55,3.8) 6L6(75.75,5.2) 6L7(74.95,4.5) 6L8(74.15,3.8) 6L9(73.35,5.2) 6L10(72.55,4.5) 6L11(72.55,1.5) 6L12(73.35,2.2) 6L13(74.15,0.8) 6L14(74.95,1.5) 6L15(75.75,2.2) 6L16(76.55,0.8) 6L17(77.35,1.5) 6L18(78.15,2.2) 6L19(78.95,0.8) 6L20(79.75,1.5) 6T1(72.55,7.5) 6T2(73.35,8.2) 6T3(74.15,6.8) 6T4(74.95,7.5) 6T5(75.75,8.2) 6T6(76.55,6.8) 6T7(77.35,7.5) 6T8(78.15,8.2) 6T9(78.95,6.8) 6T10(79.75,7.5) 6T11(79.75,10.5) 6T12(78.95,9.8) 6T13(78.15,11.2) 6T14(77.35,10.5) 6T15(76.55,9.8) 6T16(75.75,11.2) 6T17(74.95,10.5) 6T18(74.15,9.8) 6T19(73.35,11.2) 6T20(72.55,10.5)
  round 0.965 hole 0.559: G1(-2.225,-38.29) G2(-2.225,-30.29) G3(-2.225,-22.29) G4(-2.225,-14.29) G5(-2.225,-6.29) G6(1.4,-1.72) G7(4.9,-1.72) G8(8.4,-1.72) G9(-2.225,0.5) G10(-2.225,4) G11(-2.225,7.5) G12(-2.225,11) G13(1.4,13.28) G14(4.9,13.28) G15(8.4,13.28) G16(12.025,11) G17(12.025,7.5) G18(12.025,4) G19(12.025,0.5) G20(12.025,-6.29) G21(12.025,-14.29) G22(12.025,-22.29) G23(12.025,-30.29) G24(12.025,-38.29) G25(15.65,-1.72) G26(19.15,-1.72) G27(22.65,-1.72) G28(15.65,13.28) G29(19.15,13.28) G30(22.65,13.28) G31(26.275,11) G32(26.275,7.5) G33(26.275,4) G34(26.275,0.5) G35(26.275,-6.29) G36(26.275,-14.29) G37(26.275,-22.29) G38(26.275,-30.29) G39(26.275,-38.29) G40(29.9,-1.72) G41(33.4,-1.72) G42(36.9,-1.72) G43(29.9,13.28) G44(33.4,13.28) G45(36.9,13.28) G46(40.525,11) G47(40.525,7.5) G48(40.525,4) G49(40.525,0.5) G50(40.525,-6.29) G51(40.525,-14.29) G52(40.525,-22.29) G53(40.525,-30.29) G54(40.525,-38.29) G55(44.15,-1.72) G56(47.65,-1.72) G57(51.15,-1.72) G58(44.15,13.28) G59(47.65,13.28) G60(51.15,13.28) G61(54.775,11) G62(54.775,7.5) G63(54.775,4) G64(54.775,0.5) G65(54.775,-6.29) G66(54.775,-14.29) G67(54.775,-22.29) G68(54.775,-30.29) G69(54.775,-38.29) G70(58.4,-1.72) G71(61.9,-1.72) G72(65.4,-1.72) G73(58.4,13.28) G74(61.9,13.28) G75(65.4,13.28) G76(69.025,11) G77(69.025,7.5) G78(69.025,4) G79(69.025,0.5) G80(69.025,-6.29) G81(69.025,-14.29) G82(69.025,-22.29) G83(69.025,-30.29) G84(69.025,-38.29) G85(72.65,-1.72) G86(76.15,-1.72) G87(79.65,-1.72) G88(72.65,13.28) G89(76.15,13.28) G90(79.65,13.28) G91(83.275,11) G92(83.275,7.5) G93(83.275,4) G94(83.275,0.5) G95(83.275,-6.29) G96(83.275,-14.29) G97(83.275,-22.29) G98(83.275,-30.29) G99(83.275,-38.29)
MTH_276C118D_8DP_OSP
  round 2.997 hole 2.997 unplated: (0,0)
  round 0.889 hole 0.305: 1(0,2.629) 2(1.859,1.859) 3(2.629,0) 4(1.859,-1.859) 5(0,-2.629) 6(-1.859,-1.859) 7(-2.629,0) 8(-1.859,1.859)
MTH_276C138D_8DP_OSP
  round 3.505 hole 3.505 unplated: (0,0)
  round 0.889 hole 0.305: 1(0,2.629) 2(1.859,1.859) 3(2.629,0) 4(1.859,-1.859) 5(0,-2.629) 6(-1.859,-1.859) 7(-2.629,0) 8(-1.859,1.859)
MTH_276C138D_8DP_OSP_6OCT
  round 3.505 hole 3.505 unplated: (0,0)
  round 0.889 hole 0.305: 1(0,2.629) 2(1.859,1.859) 3(2.629,0) 4(1.859,-1.859) 5(0,-2.629) 6(-1.859,-1.859) 7(-2.629,0) 8(-1.859,1.859)
NUT_295C166D_PTH
  round 7.493 hole 4.216: 1(0,0)
OCXO_8D9X23D4_7SP_22W25D4L
  rect 2.718x3.404 smd: 1(-8.9,-11.7) 2(0,-11.7) 3(8.9,-11.7) 4(8.9,11.7) 5(3.81,11.7) 6(-3.81,11.7) 7(-8.9,11.7)
OSC_1D6X1D63_4SP_2D05W2D55L
  rect 1.219x1.118 smd: 1(-0.815,-0.8) 2(0.815,-0.8) 3(0.815,0.8) 4(-0.815,0.8)
OSC_1D6X2D12_4SP_2D5W3D2L1DH
  rect 1.422x1.219 smd: 1(-1.06,-0.8) 2(1.06,-0.8) 3(1.06,0.8) 4(-1.06,0.8)
OSC_1D6X2D12_4SP_2D5W3D2LD75H
  rect 1.524x1.194 smd: 1(-1.06,-0.8) 2(1.06,-0.8) 3(1.06,0.8) 4(-1.06,0.8)
OSC_2D1X1D6_4SP_2D5WX3D2L
  rect 1.27x1.143 smd: 1(-1.05,-0.8) 2(1.05,-0.8) 3(1.05,0.8) 4(-1.05,0.8)
OSC_2D54X4D2_6SP_7W5L1D55H
  rect 1.905x2.032 smd: 1(-2.54,-2.1) 2(0,-2.1) 3(2.54,-2.1) 4(2.54,2.1) 5(0,2.1) 6(-2.54,2.1)
OSC_2D54X7D5_6SP_14D6W9D7L6D2H
  rect 1.651x2.286 smd: 1(-2.54,-3.75) 2(0,-3.75) 3(2.54,-3.75) 4(2.54,3.75) 5(0,3.75) 6(-2.54,3.75)
OSC_4DX5D08_4SP_7W5L
  rect 1.778x2.032 smd: 1(-2.54,-2) 2(2.54,-2) 3(2.54,2) 4(-2.54,2)
PTC_2D8_2SP_3D2W1D65L
  rect 1.016x1.778 smd: 1(-1.4,0) 2(1.4,0)
QFN_D5_13SP_5W6L
  rect 1.016x0.254 smd: 1(2.45,-2.5) 2(2.45,-2) 3(2.45,-1.5) 4(2.45,-1) 5(2.45,-0.5) 8(-2.45,-0.5) 9(-2.45,-1) 10(-2.45,-1.5) 11(-2.45,-2) 12(-2.45,-2.5)
  custom 0.25x0.25 smd: 6(2.45,1.25) 7(-2.45,1.25)
  custom 0.85x0.85 smd: 13(0,0)
QFN_D5_16SP_4WL
  rect 0.813x0.254 smd: 1(-1.5,0.75) 2(-1.5,0.25) 3(-1.5,-0.25) 4(-1.5,-0.75) 9(1.5,-0.75) 10(1.5,-0.25) 11(1.5,0.25) 12(1.5,0.75)
  rect 0.254x0.813 smd: 5(-0.75,-1.5) 6(-0.25,-1.5) 7(0.25,-1.5) 8(0.75,-1.5) 13(0.75,1.5) 14(0.25,1.5) 15(-0.25,1.5) 16(-0.75,1.5)
  rect 1.524x1.524 smd: 17(0,0)
QFN_D5_40SP_7W5L1DH_G1
  rect 0.864x0.254 smd: 1(-2.475,2.796) 2(-2.475,2.296) 3(-2.475,1.796) 4(-2.475,1.296) 5(-2.475,0.796) 6(-2.475,0.296) 7(-2.475,-0.204) 8(-2.475,-0.704) 9(-2.475,-1.204) 10(-2.475,-1.704) 11(-2.475,-2.204) 12(-2.475,-2.704) 21(2.475,-2.704) 22(2.475,-2.204) 23(2.475,-1.704) 24(2.475,-1.204) 25(2.475,-0.704) 26(2.475,-0.204) 27(2.475,0.296) 28(2.475,0.796) 29(2.475,1.296) 30(2.475,1.796) 31(2.475,2.296) 32(2.475,2.796)
  rect 0.254x0.864 smd: 13(-1.75,-3.429) 14(-1.25,-3.429) 15(-0.75,-3.429) 16(-0.25,-3.429) 17(0.25,-3.429) 18(0.75,-3.429) 19(1.25,-3.429) 20(1.75,-3.429) 33(1.75,3.521) 34(1.25,3.521) 35(0.75,3.521) 36(0.25,3.521) 37(-0.25,3.521) 38(-0.75,3.521) 39(-1.25,3.521) 40(-1.75,3.521)
  rect 2.108x4.775 smd: G1(0,0.386)
QFN_D5X2D95_11SP_3D15WL
  custom 0.07x0.07 smd: 1(-1,-1.475) 2(-0.5,-1.475) 3(0,-1.475) 4(0.5,-1.475) 5(1,-1.475) 6(1,1.475) 7(0.5,1.475) 8(0,1.475) 9(-0.5,1.475) 10(-1,1.475)
  custom 0.412x0.412 smd: 11(0,0)
QFN_D5X3D_16SP_3WL1H
  rect 0.813x0.254 smd: 1(-1.5,0.75) 2(-1.5,0.25) 3(-1.5,-0.25) 4(-1.5,-0.75) 9(1.5,-0.75) 10(1.5,-0.25) 11(1.5,0.25) 12(1.5,0.75)
  rect 0.254x0.813 smd: 5(-0.75,-1.5) 6(-0.25,-1.5) 7(0.25,-1.5) 8(0.75,-1.5) 13(0.75,1.5) 14(0.25,1.5) 15(-0.25,1.5) 16(-0.75,1.5)
  rect 1.6x1.6 smd: G1(0,0)
QFN_D5X5D_32SP_5WL1H_G1
  rect 0.813x0.254 smd: 1(-2.5,1.75) 2(-2.5,1.25) 3(-2.5,0.75) 4(-2.5,0.25) 5(-2.5,-0.25) 6(-2.5,-0.75) 7(-2.5,-1.25) 8(-2.5,-1.75) 17(2.5,-1.75) 18(2.5,-1.25) 19(2.5,-0.75) 20(2.5,-0.25) 21(2.5,0.25) 22(2.5,0.75) 23(2.5,1.25) 24(2.5,1.75)
  rect 0.254x0.813 smd: 9(-1.75,-2.5) 10(-1.25,-2.5) 11(-0.75,-2.5) 12(-0.25,-2.5) 13(0.25,-2.5) 14(0.75,-2.5) 15(1.25,-2.5) 16(1.75,-2.5) 25(1.75,2.5) 26(1.25,2.5) 27(0.75,2.5) 28(0.25,2.5) 29(-0.25,2.5) 30(-0.75,2.5) 31(-1.25,2.5) 32(-1.75,2.5)
  rect 3.175x3.175 smd: G1(0,0)
QFN_D5X6D_36SP_6WL1H_G1
  rect 1.219x0.254 smd: 1(-3,2) 2(-3,1.5) 3(-3,1) 4(-3,0.5) 5(-3,0) 6(-3,-0.5) 7(-3,-1) 8(-3,-1.5) 9(-3,-2) 19(3,-2) 20(3,-1.5) 21(3,-1) 22(3,-0.5) 23(3,0) 24(3,0.5) 25(3,1) 26(3,1.5) 27(3,2)
  rect 0.254x1.219 smd: 10(-2,-3) 11(-1.5,-3) 12(-1,-3) 13(-0.5,-3) 14(0,-3) 15(0.5,-3) 16(1,-3) 17(1.5,-3) 18(2,-3) 28(2,3) 29(1.5,3) 30(1,3) 31(0.5,3) 32(0,3) 33(-0.5,3) 34(-1,3) 35(-1.5,3) 36(-2,3)
  rect 3.683x3.683 smd: G1(0,0)
QFN_D5X6D_40SP_6WL_G1_4D1SQ
  rect 0.813x0.254 smd: 1(-3,2.25) 2(-3,1.75) 3(-3,1.25) 4(-3,0.75) 5(-3,0.25) 6(-3,-0.25) 7(-3,-0.75) 8(-3,-1.25) 9(-3,-1.75) 10(-3,-2.25) 21(3,-2.25) 22(3,-1.75) 23(3,-1.25) 24(3,-0.75) 25(3,-0.25) 26(3,0.25) 27(3,0.75) 28(3,1.25) 29(3,1.75) 30(3,2.25)
  rect 0.254x0.813 smd: 11(-2.25,-3) 12(-1.75,-3) 13(-1.25,-3) 14(-0.75,-3) 15(-0.25,-3) 16(0.25,-3) 17(0.75,-3) 18(1.25,-3) 19(1.75,-3) 20(2.25,-3) 31(2.25,3) 32(1.75,3) 33(1.25,3) 34(0.75,3) 35(0.25,3) 36(-0.25,3) 37(-0.75,3) 38(-1.25,3) 39(-1.75,3) 40(-2.25,3)
  rect 4.064x4.064 smd: G1(0,0)
QFN_D5X9D_64SP_9WL1H_G1_4D25SQ
  rect 0.762x0.254 smd: 1(-4.5,3.75) 2(-4.5,3.25) 3(-4.5,2.75) 4(-4.5,2.25) 5(-4.5,1.75) 6(-4.5,1.25) 7(-4.5,0.75) 8(-4.5,0.25) 9(-4.5,-0.25) 10(-4.5,-0.75) 11(-4.5,-1.25) 12(-4.5,-1.75) 13(-4.5,-2.25) 14(-4.5,-2.75) 15(-4.5,-3.25) 16(-4.5,-3.75) 33(4.5,-3.75) 34(4.5,-3.25) 35(4.5,-2.75) 36(4.5,-2.25) 37(4.5,-1.75) 38(4.5,-1.25) 39(4.5,-0.75) 40(4.5,-0.25) 41(4.5,0.25) 42(4.5,0.75) 43(4.5,1.25) 44(4.5,1.75) 45(4.5,2.25) 46(4.5,2.75) 47(4.5,3.25) 48(4.5,3.75)
  rect 0.254x0.762 smd: 17(-3.75,-4.5) 18(-3.25,-4.5) 19(-2.75,-4.5) 20(-2.25,-4.5) 21(-1.75,-4.5) 22(-1.25,-4.5) 23(-0.75,-4.5) 24(-0.25,-4.5) 25(0.25,-4.5) 26(0.75,-4.5) 27(1.25,-4.5) 28(1.75,-4.5) 29(2.25,-4.5) 30(2.75,-4.5) 31(3.25,-4.5) 32(3.75,-4.5) 49(3.75,4.5) 50(3.25,4.5) 51(2.75,4.5) 52(2.25,4.5) 53(1.75,4.5) 54(1.25,4.5) 55(0.75,4.5) 56(0.25,4.5) 57(-0.25,4.5) 58(-0.75,4.5) 59(-1.25,4.5) 60(-1.75,4.5) 61(-2.25,4.5) 62(-2.75,4.5) 63(-3.25,4.5) 64(-3.75,4.5)
  rect 4.318x4.318 smd: G1(0,0)
QFN_D5X11D_80SP_11WL_G1_275SQ
  rect 0.813x0.254 smd: 1(-5.5,4.75) 2(-5.5,4.25) 3(-5.5,3.75) 4(-5.5,3.25) 5(-5.5,2.75) 6(-5.5,2.25) 7(-5.5,1.75) 8(-5.5,1.25) 9(-5.5,0.75) 10(-5.5,0.25) 11(-5.5,-0.25) 12(-5.5,-0.75) 13(-5.5,-1.25) 14(-5.5,-1.75) 15(-5.5,-2.25) 16(-5.5,-2.75) 17(-5.5,-3.25) 18(-5.5,-3.75) 19(-5.5,-4.25) 20(-5.5,-4.75) 41(5.5,-4.75) 42(5.5,-4.25) 43(5.5,-3.75) 44(5.5,-3.25) 45(5.5,-2.75) 46(5.5,-2.25) 47(5.5,-1.75) 48(5.5,-1.25) 49(5.5,-0.75) 50(5.5,-0.25) 51(5.5,0.25) 52(5.5,0.75) 53(5.5,1.25) 54(5.5,1.75) 55(5.5,2.25) 56(5.5,2.75) 57(5.5,3.25) 58(5.5,3.75) 59(5.5,4.25) 60(5.5,4.75)
  rect 0.254x0.813 smd: 21(-4.75,-5.5) 22(-4.25,-5.5) 23(-3.75,-5.5) 24(-3.25,-5.5) 25(-2.75,-5.5) 26(-2.25,-5.5) 27(-1.75,-5.5) 28(-1.25,-5.5) 29(-0.75,-5.5) 30(-0.25,-5.5) 31(0.25,-5.5) 32(0.75,-5.5) 33(1.25,-5.5) 34(1.75,-5.5) 35(2.25,-5.5) 36(2.75,-5.5) 37(3.25,-5.5) 38(3.75,-5.5) 39(4.25,-5.5) 40(4.75,-5.5) 61(4.75,5.5) 62(4.25,5.5) 63(3.75,5.5) 64(3.25,5.5) 65(2.75,5.5) 66(2.25,5.5) 67(1.75,5.5) 68(1.25,5.5) 69(0.75,5.5) 70(0.25,5.5) 71(-0.25,5.5) 72(-0.75,5.5) 73(-1.25,5.5) 74(-1.75,5.5) 75(-2.25,5.5) 76(-2.75,5.5) 77(-3.25,5.5) 78(-3.75,5.5) 79(-4.25,5.5) 80(-4.75,5.5)
  rect 6.985x6.985 smd: G1(0,0)
QFN_D6_D65X2D_10SP_2W3LD65H
  rect 0.584x0.254 smd: 1(-1,1.25) 2(-1,0.65) 3(-1,0) 4(-1,-0.65) 5(-1,-1.25) 6(1,-1.25) 7(1,-0.65) 8(1,0) 9(1,0.65) 10(1,1.25)
  rect 0.94x0.356 smd: G1(0,0.95) G2(0,0) G3(0,-0.95)
QFN_D65X2D1_6SP_2WLD8H
  rect 0.254x0.635 smd: 1(-0.65,-1.05) 2(0,-1.05) 3(0.65,-1.05) 4(0.65,1.05) 5(0,1.05) 6(-0.65,1.05)
  rect 1.651x0.889 smd: G1(0,0)
QFN_D65X2D95_8SP_3WL1H_G1
  rect 0.864x0.356 smd: 1(-1.475,0.975) 2(-1.475,0.325) 3(-1.475,-0.325) 4(-1.475,-0.975) 5(1.475,-0.975) 6(1.475,-0.325) 7(1.475,0.325) 8(1.475,0.975)
  rect 1.524x1.778 smd: G1(0,0)
QFN_D65X5D_20SP_5WL_G1
  rect 0.305x1.016 smd: 1(1.3,2.5) 2(0.65,2.5) 3(0,2.5) 4(-0.65,2.5) 5(-1.3,2.5) 11(-1.3,-2.5) 12(-0.65,-2.5) 13(0,-2.5) 14(0.65,-2.5) 15(1.3,-2.5)
  rect 1.016x0.305 smd: 6(-2.5,1.3) 7(-2.5,0.65) 8(-2.5,0) 9(-2.5,-0.65) 10(-2.5,-1.3) 16(2.5,-1.3) 17(2.5,-0.65) 18(2.5,0) 19(2.5,0.65) 20(2.5,1.3)
  rect 3.175x3.175 smd: G1(0,0)
QFP_D5X11D4_64SP_10WL1D6H
  rect 1.524x0.254 smd: 1(-5.7,3.75) 2(-5.7,3.25) 3(-5.7,2.75) 4(-5.7,2.25) 5(-5.7,1.75) 6(-5.7,1.25) 7(-5.7,0.75) 8(-5.7,0.25) 9(-5.7,-0.25) 10(-5.7,-0.75) 11(-5.7,-1.25) 12(-5.7,-1.75) 13(-5.7,-2.25) 14(-5.7,-2.75) 15(-5.7,-3.25) 16(-5.7,-3.75) 33(5.7,-3.75) 34(5.7,-3.25) 35(5.7,-2.75) 36(5.7,-2.25) 37(5.7,-1.75) 38(5.7,-1.25) 39(5.7,-0.75) 40(5.7,-0.25) 41(5.7,0.25) 42(5.7,0.75) 43(5.7,1.25) 44(5.7,1.75) 45(5.7,2.25) 46(5.7,2.75) 47(5.7,3.25) 48(5.7,3.75)
  rect 0.254x1.524 smd: 17(-3.75,-5.7) 18(-3.25,-5.7) 19(-2.75,-5.7) 20(-2.25,-5.7) 21(-1.75,-5.7) 22(-1.25,-5.7) 23(-0.75,-5.7) 24(-0.25,-5.7) 25(0.25,-5.7) 26(0.75,-5.7) 27(1.25,-5.7) 28(1.75,-5.7) 29(2.25,-5.7) 30(2.75,-5.7) 31(3.25,-5.7) 32(3.75,-5.7) 49(3.75,5.7) 50(3.25,5.7) 51(2.75,5.7) 52(2.25,5.7) 53(1.75,5.7) 54(1.25,5.7) 55(0.75,5.7) 56(0.25,5.7) 57(-0.25,5.7) 58(-0.75,5.7) 59(-1.25,5.7) 60(-1.75,5.7) 61(-2.25,5.7) 62(-2.75,5.7) 63(-3.25,5.7) 64(-3.75,5.7)
QSFP28_SINGLE_CAGE
  round 1.55 hole 1.05: 1(-19.6,9.5) 2(-10.6,9.5) 3(-1.6,9.5) 4(7.4,9.5) 5(18.1,9.5) 6(27.79,5) 7(27.79,-2.2) 8(22.6,-9.5) 9(11.9,-9.5) 10(2.9,-9.5) 11(-6.1,-9.5) 12(-15.1,-9.5)
