# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R207  5.1  [RC0603]  234.1 208.72 90 top
R208  4.02K  [RC0603]  237.05 208.7 270 top
R209  40.2  [RC0402]  77.94 171.42 90 top
R210  4.7K  [RC0402]  200.27 235.16 270 top
R211  0  [RC0402]  89.69 228 90 top
R221  40.2  [RC0402]  77.94 170.41 90 top
R222  4.7K  [RC0402]  180.23 190.09 180 top
R226  40.2  [RC0402]  23.46 170.03 90 top
R227  33  [RC0402]  158.41 234.38 0 top
R228  4.7K  [RC0402]  158.41 231.84 180 top
R229  4.7K  [RC0402]  158.63 216.88 0 top
R230  33  [RC0402]  158.63 214.34 180 top
R231  @0  [RC0402]  8.03 168.76 180 top
R232  0  [RC0402]  9.05 168.76 180 top
R233  0  [RC0402]  89.86 236.38 180 top
R234  0ohm(0805)  [RC0805]  235.91 206.95 90 top
R237  4.7K  [RC0402]  73.37 169.39 270 top
R238  1K  [RC0402]  77.94 169.39 90 top
R242  0  [RC0402]  89.69 225.97 90 top
R243  40.2  [RC0402]  23.46 169.01 90 top
R244  0  [RC0402]  121.25 233.59 90 top
R245  33  [RC0402]  157.14 234.38 0 top
R246  4.7K  [RC0402]  157.14 231.84 180 top
R247  4.7K  [RC0402]  157.36 216.88 0 top
R248  33  [RC0402]  157.36 214.34 180 top
R250  @1K  [RC0402]  77.94 168.37 270 top
R254  0  [RC0402]  89.69 222.92 90 top
R255  40.2  [RC0402]  23.46 167.99 270 top
R256  100 1%  [RC0402]  28.54 167.94 90 top
R257  4.7K  [RC0402]  4.28 167.8 270 top
R258  0  [RC0402]  184.96 187.02 270 top
R259  0  [RC0402]  94.94 236.38 180 top
R260  33  [RC0402]  156.13 234.38 0 top
R261  4.7K  [RC0402]  156.13 231.84 180 top
R262  4.7K  [RC0402]  156.34 216.88 0 top
R263  33  [RC0402]  156.34 214.34 180 top
R264  4.7K  [RC0402]  212.64 186.92 270 bottom
R267  40.2  [RC0402]  77.94 167.36 90 top
R269  @1K  [RC0402]  46.32 167.1 0 top
R270  1K  [RC0402]  47.34 167.1 180 top
R274  40.2  [RC0402]  23.46 166.98 270 top
R275  @10K  [RC0402]  184.96 186.01 90 top
R278  33  [RC0402]  154.86 234.38 0 top
R279  4.7K  [RC0402]  154.86 231.84 180 top
R280  4.7K  [RC0402]  155.07 216.88 0 top
R281  33  [RC0402]  155.07 214.34 180 top
R282  0  [RC0402]  4.54 166.28 0 top
R283  33  [RC0402]  5.55 166.28 180 top
R284  @75  [RC0402]  6.44 166.28 180 top
R285  33  [RC0402]  7.46 166.28 180 top
R287  0 ohm  [RC0402]  126.81 217.65 180 top
R288  24.9K  [RC0402]  127.83 217.65 180 top
R289  1K  [RC0402]  184.96 184.99 270 top
R292  40.2  [RC0402]  23.43 165.63 90 top
R294  33  [RC0402]  153.84 234.38 0 top
R295  4.7K  [RC0402]  153.84 231.84 180 top
R296  4.7K  [RC0402]  154.06 216.88 0 top
R297  @33  [RC0402]  154.06 214.34 180 top
R299  0 ohm  [RC0402]  89.69 230.03 90 top
R300  24.9K  [RC0402]  87.28 233.08 180 top
R301  100 1%  [RC0402]  28.54 164.89 270 top
R302  0  [RC0402]  184.96 183.97 270 top
R305  40.2  [RC0402]  23.41 164.61 90 top
R306  33  [RC0402]  152.57 234.38 0 top
R307  4.7K  [RC0402]  152.57 231.84 180 top
R308  4.7K  [RC0402]  152.79 216.88 0 top
R309  @33  [RC0402]  152.79 214.34 180 top
R310  33  [RC0402]  92.9 236.38 180 top
R311  0  [RC0402]  184.96 182.96 270 top
R312  0  [RC0402]  126.75 220.42 0 top
R313  24.9K  [RC0402]  127.82 220.42 0 top
R316  @4.7K  [RC0402]  180.86 182.47 180 top
R317  4.7K  [RC0402]  181.91 182.45 180 top
R318  33  [RC0402]  184.96 181.94 270 top
R319  0  [RC0402]  99 236.38 180 top
R322  240 ohm 1%  [RC0402]  28.57 162.18 270 top
R323  0 ohm  [RC0402]  126.84 214.41 180 top
R324  24.9K  [RC0402]  127.85 214.41 180 top
R326  33  [RC0402]  100.04 236.38 180 top
R327  33  [RC0402]  185.22 180.42 180 top
R332  33  [RC0402]  193.64 235.53 0 top
R333  0  [RC0402]  191.56 235.53 0 top
R334  0  [RC0402]  89.69 229.02 90 top
R335  24.9K  [RC0402]  87.28 229.46 180 top
R337  4.7K  [RC0402]  223.2 242.31 90 top
R338  1K(5%)  [RC0402]  123.64 139.18 0 top
R340  4.7K  [RC0402]  212.71 128.86 270 top
R342  0  [RC0402]  212.71 124.8 90 top
R343  0  [RC0402]  212.71 123.78 270 top
R344  0  [RC0402]  123.13 137.78 270 top
R345  0  [RC0402]  138.14 235.57 0 top
R346  0  [RC0402]  123 145.4 270 top
R347  36K  [RC0402]  123 144.38 270 top
R348  4.3K  [RC0402]  123 143.11 270 top
R349  33  [RC0402]  185.22 178.39 180 top
R350  10K  [RC0402]  245.87 240.82 270 top
R351  0  [RC0402]  245.84 236.83 90 top
R352  4.7K  [RC0402]  231.12 241.53 90 top
R355  33  [RC0402]  223.19 241.26 270 top
R356  4.7K  [RC0402]  213.16 132.23 0 top
R357  150  [RC0402]  102.26 184.25 0 top
R358  150  [RC0402]  103.53 184.25 0 top
R359  150  [RC0402]  104.55 184.25 0 top
R360  150  [RC0402]  105.76 184.25 0 top
R363  0  [RC0402]  184.96 187.02 270 bottom
R366  0  [RC0402]  95.95 236.38 0 top
R370  0  [RC0402]  231.17 238.48 90 top
R373  0  [RC0402]  121.17 213.76 90 top
R376  0 ohm  [RC0402]  138.14 228.95 0 top
R377  24.9K  [RC0402]  139.16 228.95 0 top
R378  24.9K  [RC0402]  139.18 235.54 0 top
R379  0  [RC0402]  248.09 240.53 0 top
R380  @33  [RC0402]  208.71 240.75 90 top
R381  0  [RC0402]  233.59 240.57 270 top
R383  0  [RC0402]  231.12 240.51 90 top
R384  4.7K  [RC0402]  212.14 132.25 0 top
R385  30K  [RC0402]  120.97 145.02 0 top
R386  0  [RC0402]  245.84 239.83 90 top
R387  @33  [RC0402]  208.71 239.73 90 top
R388  0  [RC0402]  233.58 239.55 270 top
R389  33  [RC0402]  223.19 239.23 270 top
R390  100K  [RC0402]  211.12 132.26 0 top
R391  33  [RC0402]  210.11 132.27 180 top
R394  3.09K  [RC0402]  119.95 145.02 0 top
R395  10K  [RC0402]  181.25 176.12 0 top
R396  0  [RC0402]  245.84 238.81 90 top
R397  33  [RC0402]  208.71 238.72 90 top
R398  0  [RC0402]  233.58 238.53 270 top
R399  33  [RC0402]  102.26 186.85 0 top
R400  33  [RC0402]  103.53 186.85 0 top
R401  33  [RC0402]  104.55 186.85 0 top
R402  33  [RC0402]  105.76 186.85 0 top
R403  @4.7K  [RC0402]  4.16 155.61 0 top
R404  4.7K  [RC0402]  5.43 155.61 0 top
R405  4.7K  [RC0402]  6.7 155.61 0 top
R406  @33  [RC0402]  223.19 238.21 270 top
R407  0  [RC0402]  121.18 217.88 270 top
R408  33  [RC0402]  123.51 217.88 90 top
R414  0  [RC0402]  121.21 228.51 90 top
R415  4.7K  [RC0402]  10.25 157.67 90 top
R416  3.83K  [RC0402]  118.94 145.02 0 top
R418  0  [RC0402]  245.84 237.82 90 top
R419  33  [RC0402]  208.71 237.7 90 top
R420  0  [RC0402]  233.58 237.53 270 top
R421  10K  [RC0402]  118.68 134.86 180 top
R423  @33  [RC0402]  223.17 236.83 270 top
R424  @4.7K  [RC0402]  207.64 132.35 0 top
R426  0  [RC0402]  245.84 235.81 90 top
R428  4.7K  [RC0402]  206.69 132.35 180 top
R429  4.7K  [RC0402]  4.16 153.32 0 top
R430  @4.7K  [RC0402]  5.43 153.32 0 top
R431  @4.7K  [RC0402]  6.7 153.32 0 top
R433  0  [RC0402]  205.72 120.61 180 top
R434  @0  [RC0402]  13.55 155.39 90 top
R435  @4.7K  [RC0402]  205.68 132.35 0 top
R437  0  [RC0402]  204.71 120.61 180 top
R438  33  [RC0402]  13.53 154.38 90 top
R439  4.7K  [RC0402]  204.66 132.35 180 top
R443  1K  [RC0402]  203.64 132.35 0 top
R449  100K  [RC0402]  201.08 130.29 90 top
R450  4.7K  [RC0402]  78.96 149.2 270 top
R451  33  [RC0402]  80.86 149.2 270 top
R452  4.7K  [RC0402]  77.05 149.2 90 top
R453  100K  [RC0402]  201.03 131.33 270 top
R454  1M  [RC0402]  201.53 125.3 180 top
R455  100K  [RC0402]  201.09 129.28 270 top
R456  12K  [RC0402]  201.28 121.75 270 top
R457  4.7K  [RC0402]  84.8 147.93 90 top
R458  33  [RC0402]  75.59 148.31 180 top
R459  0  [RC0402]  200.01 125.81 90 top
R460  @4.7K  [RC0402]  84.8 146.91 270 top
R462  @75  [RC0402]  79.34 142.09 0 top
R464  4.7K  [RC0402]  84.8 145.9 270 top
R470  @4.7K  [RC0402]  84.8 144.88 90 top
R471  0  [RC0402]  76.93 142.59 90 top
R472  4.7K  [RC0402]  84.8 143.86 270 top
R474  33  [RC0402]  240.69 91.22 180 bottom
R478  4.7K  [RC0402]  76.93 141.58 270 top
R479  49.9  [RC1210]  19.77 142.87 90 top
R480  @4.7K  [RC0402]  84.8 142.85 90 top
R481  49.9  [RC1210]  28.29 139.8 90 top
R482  @1K  [RC0402]  14.06 135.99 270 top
R483  33  [RC0402]  16.35 135.99 270 top
R484  4.7K  [RC0402]  126.65 210.67 270 top
R485  33  [RC0402]  129 210.67 270 top
R486  @1K  [RC0402]  14.06 134.97 270 top
R487  33  [RC0402]  16.35 134.97 270 top
R488  0  [RC0805]  169.92 134.08 90 top
R489  0  [RC0805]  33.56 190.54 270 top
R490  0  [RC0805]  33.97 194.93 0 top
R491  0  [RC0402]  103.34 134.59 270 top
R492  27K(1%)  [RC0603]  167.12 133.57 180 top
R493  4.7K  [RC0402]  126.65 209.59 270 top
R494  33  [RC0402]  129 209.59 270 top
R495  4.7K  [RC0402]  140.14 209.13 270 top
R496  10ohm  [RC0603]  161.67 133.24 270 top
R497  51K(1%)  [RC0402]  163.69 133.32 0 top
R498  11.5K_1%  [RC0402]  164.84 133.32 0 top
R499  1K(5%)  [RC0402]  165.85 133.32 0 top
R500  1K  [RC0402]  6.95 133.96 90 top
R501  1K  [RC0402]  10.25 133.96 90 top
R502  @1K  [RC0402]  13.3 133.96 270 top
R503  33  [RC0402]  16.35 133.96 270 top
R504  @0  [RC0402]  169.28 132.56 90 top
R505  @75  [RC0402]  129 208.51 270 top
R506  @4.7K  [RC0402]  140.14 208.12 90 top
R507  @187K(1%)  [RC0603]  36.22 194.98 180 top
R508  1K  [RC0402]  6.95 132.94 90 top
R509  1K  [RC0402]  10.25 132.94 90 top
R510  @1K  [RC0402]  13.3 132.94 270 top
R511  33  [RC0402]  16.35 132.94 270 top
R512  187K(1%)  [RC0603]  160.76 131.31 270 top
R513  100K(1%)  [RC0402]  169.28 131.54 270 top
R514  @4.7K  [RC0402]  140.14 207.1 270 top
R515  2.2_1%  [RC0603]  103.85 132.23 270 top
R516  1K  [RC0402]  6.95 131.93 90 top
R517  33  [RC0402]  10.25 131.93 90 top
R518  @1K  [RC0402]  13.3 131.93 270 top
R519  1K  [RC0402]  16.35 131.93 90 top
R520  91K  [RC0402]  111.47 97.13 180 top
R521  0  [RC0402]  111.47 97.13 0 bottom
R522  100K  [RC0402]  169.28 130.53 270 top
R523  0  [RC0402]  129.01 207.39 90 top
R524  4.7K  [RC0402]  140.14 206.09 90 top
R525  9.31K(1%)  [RC0402]  118.2 130.93 0 top
R526  4.7K  [RC0402]  6.95 130.91 270 top
R527  1K  [RC0402]  10.25 130.91 90 top
R528  @1K  [RC0402]  13.3 130.91 270 top
R529  1K  [RC0402]  16.35 130.91 90 top
R530  0  [RC0805]  107.15 130.91 270 top
R531  39K(1%)  [RC0603]  113.38 131.48 180 top
R532  160Kohm  [RC0603]  114.9 131.48 180 top
R533  121K  [RC0402]  110.94 131.16 0 top
R534  20K  [RC0402]  111.93 130.91 0 top
R535  24K(1%)  [RC0402]  116.17 130.93 0 top
R536  86.6Kohm  [RC0402]  117.19 130.93 180 top
R537  4.3K  [RC0402]  112.49 97.13 180 top
R538  169K  [RC0402]  112.49 97.13 0 bottom
R539  4.7K  [RC0402]  248.49 196.39 90 top
R540  4.7K  [RC0402]  126.65 207.43 90 top
R541  4.7K  [RC0402]  140.14 204.08 270 top
R542  @1K  [RC0402]  6.95 129.89 90 top
R543  0  [RC0402]  10.25 129.89 90 top
R544  @1K  [RC0402]  13.3 129.89 270 top
R545  1K  [RC0402]  16.35 129.89 90 top
R546  2.2ohm_1%  [RC0603]  169.79 129 270 top
R547  10.7Kohm  [RC0402]  39.73 194.4 0 top
R548  @10K  [RC0402]  254.82 226.13 90 top
R549  @4.7K  [RC0402]  140.12 205.08 90 top
R550  1K  [RC0402]  6.95 128.88 270 top
R551  1K  [RC0402]  10.25 128.88 90 top
R552  @1K  [RC0402]  13.3 128.88 270 top
R553  1K  [RC0402]  16.35 128.88 90 top
R554  150K(1%)  [RC0402]  117.95 128.75 270 top
R555  0  [RC0402]  254.82 227.15 270 top
R556  0  [RC0805]  160.39 127.48 90 top
R557  @0  [RC0402]  236.13 145.32 90 bottom
R558  34Kohm  [RC0603]  41 194.91 0 top
R559  44.2K(1%)  [RC0402]  104.77 128.04 270 top
R560  39K(1%)  [RC0402]  107.66 128.94 180 top
R561  1K  [RC0402]  6.95 127.86 90 top
R562  1K  [RC0402]  10.25 127.86 90 top
R563  @1K  [RC0402]  13.3 127.86 270 top
R564  1K  [RC0402]  16.35 127.86 90 top
R565  49.9  [RC1210]  81.25 127.73 180 top
R566  0  [RC0603]  123.06 168.57 0 top
R567  39K(1%)  [RC0402]  118.33 127.61 270 top
R568  374Kohm  [RC0402]  120.23 127.61 90 top
R569  39K(1%)  [RC0603]  126.61 169.08 0 top
R570  100K  [RC0402]  125.34 169.08 0 top
R571  0  [RC0805]  128.39 169.33 0 top
R572  10ohm  [RC0402]  42.26 196.53 0 top
R573  1K  [RC0402]  6.95 126.85 90 top
R574  1K  [RC0402]  10.25 126.85 90 top
R575  @1K  [RC0402]  13.3 126.85 270 top
R576  1K  [RC0402]  16.35 126.85 90 top
R577  0  [RC0603]  106.72 126.85 270 top
R578  24K(1%)  [RC0402]  117.95 126.59 270 top
R579  16.5K(1%)  [RC0402]  120.23 126.59 90 top
R580  33  [RC0402]  3.95 126.21 0 top
R581  33  [RC0402]  4.97 126.21 0 top
R582  1K  [RC0402]  6.95 125.83 270 top
R583  33  [RC0402]  10.25 125.83 90 top
R584  @1K  [RC0402]  13.3 125.83 270 top
R585  1K  [RC0402]  16.35 125.83 90 top
R586  33  [RC0402]  254.82 224.13 270 top
R587  0  [RC0603]  163.69 124.94 180 top
R588  24K(1%)  [RC0402]  43.41 194.34 180 top
R589  @4.7K  [RC0603]  106.72 125.32 270 top
R590  10K  [RC0402]  118.33 125.32 90 top
R591  0  [RC0402]  120.23 125.32 270 top
R592  0  [RC0402]  125.6 171.11 270 top
R593  @4.75K  [RC0402]  6.95 124.81 270 top
R594  1K  [RC0402]  10.25 124.81 270 top
R595  @1K  [RC0402]  13.3 124.81 270 top
R596  1K  [RC0402]  16.35 124.81 90 top
R597  10K  [RC0402]  254.82 225.14 90 top
R598  @1.5(1%)  [RC0402]  255.36 163.04 90 bottom
R599  10K  [RC0402]  118.33 124.31 90 top
R600  1K(5%)  [RC0402]  120.23 124.18 270 top
R601  133K  [RC0402]  127.88 172.13 270 top
R602  120K  [RC0402]  125.6 172.13 270 top
R603  200K(1%)  [RC0603]  45.07 195.29 0 top
R604  10  [RC0402]  104.94 124.05 270 top
R605  0  [RC0402]  107.23 124.05 90 top
R606  1K  [RC0402]  6.95 123.8 270 top
R607  1K  [RC0402]  13.3 123.8 90 top
R608  1K  [RC0402]  16.35 123.8 90 top
R609  0  [RC0402]  254.82 222.12 270 top
R610  0ohm  [RC0603]  45.96 191.61 270 top
R611  100K  [RC0402]  127.88 173.14 270 top
R612  91K  [RC0402]  125.6 173.14 270 top
R613  0  [RC0402]  104.94 123.04 90 top
R614  0  [RC0402]  107.23 123.04 90 top
R616  @0  [RC0402]  46.34 195.54 180 top
R617  1K  [RC0402]  6.95 122.78 270 top
R618  0  [RC0402]  10.25 123.82 90 top
R619  1K  [RC0402]  13.3 122.78 270 top
R620  @1K  [RC0402]  16.35 122.78 90 top
R621  10K  [RC0402]  254.82 223.14 90 top
R622  0  [RC0603]  163.57 121.38 180 top
R623  2.2ohm  [RC0603]  165.09 121.38 180 top
R624  33  [RC0402]  4.08 122.15 0 top
R625  4.75K  [RC0402]  5.1 122.15 0 top
R626  49.9  [RC1210]  81.25 122.15 0 top
R627  11K_1%  [RC0402]  125.6 174.16 270 top
R628  10K  [RC0402]  120.23 122.02 90 top
R629  @4.75K  [RC0402]  6.95 121.77 270 top
R630  33  [RC0402]  10.25 122.81 90 top
R631  @1K  [RC0402]  13.3 121.77 270 top
R632  1K  [RC0402]  16.35 121.77 90 top
R633  33  [RC0402]  254.82 219.07 270 top
R634  10ohm  [RC0402]  127.5 174.67 0 top
R635  11.5K  [RC0402]  125.6 175.17 90 top
R636  100  [RC0603]  105.05 129.33 90 top
R637  1K  [RC0402]  6.95 120.75 270 top
R638  33  [RC0402]  10.25 121.79 90 top
R639  4.75K  [RC0402]  13.3 120.75 90 top
R640  @4.75K  [RC0402]  16.35 120.75 270 top
R641  @10K  [RC0402]  254.82 220.09 270 top
R642  0ohm  [RC0402]  244.36 167.16 180 top
R643  6.81K_1%  [RC0402]  107.66 120.56 180 top
R644  2.43K  [RC0402]  109.44 120.19 180 top
R645  10  [RC0402]  112.87 120.19 0 top
R646  10K  [RC0402]  115.73 120.62 90 top
R647  10K  [RC0402]  117.95 121.32 90 top
R649  @187K(1%)  [RC0603]  126.1 176.44 90 top
R650  0  [RC0402]  6.95 119.73 90 top
R651  4.7K  [RC0402]  10.25 118.72 270 top
R652  1K  [RC0402]  13.3 119.73 270 top
R653  @1K  [RC0402]  10.25 119.73 90 top
R654  @33  [RC0402]  5.05 119.35 0 top
R655  0  [RC0402]  103.47 119.35 270 top
R656  @0  [RC0402]  6.95 118.72 90 top
R657  4.7K  [RC0402]  10.25 117.7 270 top
R658  @1K  [RC0402]  13.3 118.72 270 top
R659  1K  [RC0402]  16.35 118.72 270 top
R660  @0  [RC0402]  126.23 177.71 270 top
R661  0  [RC0402]  6.95 117.7 90 top
R662  0  [RC0402]  10.25 116.69 270 top
R663  4.75K  [RC0402]  13.3 117.7 270 top
R664  4.75K  [RC0402]  16.35 117.7 270 top
R665  2.2  [RC0603]  111.73 117.7 0 top
R666  2.2ohm/1%  [RC0603]  115.15 117.7 180 top
R667  124Kohm  [RC0402]  243.36 165.26 270 top
R668  33  [RC0402]  5.05 117.45 180 top
R669  200K(1%)  [RC0603]  126.23 178.98 90 top
R670  2.2_1%  [RC0603]  103.98 117.07 270 top
R671  @4.7K  [RC0402]  240.72 161.79 0 top
R672  1K(5%)  [RC0402]  242.74 161.79 0 top
R673  0  [RC0402]  241.74 161.79 180 top
R674  4.7K  [RC0402]  242.15 116.94 180 bottom
R675  @4.7K  [RC0402]  241.14 116.94 0 bottom
R676  12.1K(1%)  [RC0603]  236.06 141.01 270 bottom
R677  2.7K(1%)  [RC0603]  236.06 139.55 90 bottom
R678  10ohm  [RC0603]  242.12 167.54 180 top
R679  33  [RC0402]  6.95 116.69 270 top
R681  1K  [RC0402]  13.3 116.69 270 top
R682  1K  [RC0402]  16.35 116.69 270 top
R683  4.75K  [RC0402]  6.95 115.67 270 top
R685  @4.75K  [RC0402]  13.3 115.67 90 top
R686  0  [RC0805]  126.26 180.76 270 top
R687  33  [RC0402]  241.57 112.04 0 top
R688  22.1Kohm  [RC0402]  243.34 167.16 0 top
R689  @0  [RC0402]  235.74 138.28 90 bottom
R690  @4.7K  [RC0402]  14.75 112.24 0 top
R691  4.7K  [RC0402]  15.76 112.24 180 top
R692  100  [RC0402]  16.78 111.22 180 top
R693  4.7K  [RC0402]  14.75 110.21 180 top
R694  @4.7K  [RC0402]  15.76 110.21 0 top
R708  0  [RC0402]  222.68 217.21 90 top
R713  1ohm  [RC0603]  154.14 107.47 270 top
R714  @0  [RC0402]  204.56 96.36 270 top
R717  @0  [RC0402]  204.56 95.34 270 top
R719  1ohm  [RC0603]  165.38 105.31 270 top
R720  0  [RC0402]  35.6 246.56 0 bottom
R726  0  [RC0402]  204.56 94.34 270 top
R728  0  [RC0603]  165.38 103.78 270 top
R729  33  [RC0402]  210.34 101.89 0 top
R731  0  [RC0603]  154.84 103.02 0 top
R732  10K  [RC0402]  93.95 103.6 180 top
R741  20K(1%)  [RC0805]  146.28 101.88 270 top
R742  100K  [RC0402]  149.88 101.11 270 top
R746  2.2ohm  [RC0603]  106.26 100.68 0 top
R752  2.2ohm  [RC0603]  155.72 99.72 270 top
R753  1K(5%)  [RC0402]  145.32 100.36 90 top
R754  @0  [RC0402]  204.57 97.41 270 top
R758  100K  [RC0402]  108.55 99.16 270 top
R759  10ohm  [RC0603]  145.26 98.64 90 top
R764  1K(5%)  [RC0402]  90.14 99.16 90 top
R765  0  [RC0805]  119.6 98.6 270 top
R766  0  [RC0402]  204.58 98.41 270 top
R767  0  [RC0402]  143.2 100.02 180 top
R768  51K(1%)  [RC0402]  147.6 97.94 0 top
R770  11.5K(1%)  [RC0402]  145.69 97.43 90 top
R772  0  [RC0402]  90.14 98.14 270 top
R773  @0  [RC0402]  116.04 97.51 180 top
R774  0  [RC0603]  155.72 96.67 270 top
R779  0  [RC0402]  110.46 97.13 180 top
R780  150K  [RC0402]  38.51 194.55 0 top
R781  140K  [RC0402]  37.47 194.5 0 top
R782  11.3Kohm  [RC0402]  113.5 97.13 0 top
R783  200K(1%)  [RC0603]  118.08 96.7 90 top
R784  49.9K(1%)  [RC0402]  109.06 97 180 top
R785  187K(1%)  [RC0603]  114.77 97 0 top
R787  49.9K  [RC0402]  142.64 97.49 180 top
R788  158K  [RC0402]  147.09 95.4 90 top
R789  430  [RC0402]  141.44 94.76 180 top
R790  158K  [RC0402]  147.09 94.38 90 top
R791  6.98Kohm  [RC0603]  113.25 94.71 90 top
R792  0ohm  [RC0402]  110.46 94.59 90 top
R793  @39K  [RC0402]  148.61 93.62 0 top
R794  39K  [RC0402]  149.63 93.62 180 top
R795  5.49Kohm  [RC0402]  94.71 94.14 270 top
R796  187K(1%)  [RC0603]  146.58 92.86 270 top
R797  0  [RC0805]  153.18 92.86 180 top
R800  0  [RC0603]  266.03 106.14 90 top
R801  3.09K(1%)  [RC0603]  91.53 93.19 0 top
R802  33.2K  [RC0402]  92.8 92.68 0 top
R803  33.2K  [RC0402]  94.2 92.68 180 top
R804  91K  [RC0402]  95.22 92.68 180 top
R805  2.2K  [RC0402]  96.61 92.68 0 top
R808  0ohm 0805  [RC0805]  149.67 89.89 270 top
R842  60.4  [RC0402]  239.36 71.92 0 bottom
R843  60.4  [RC0402]  240.38 71.92 0 bottom
R846  33  [RC0402]  238.76 117.56 270 top
R853  @10K  [RC0402]  242.87 93.59 90 top
R854  4.99K(1%)  [RC0402]  220.6 115.98 90 top
R855  0  [RC0402]  242.87 92.57 90 top
R856  1K  [RC0402]  242.87 91.55 270 top
R857  0  [RC0402]  243.18 81.06 0 bottom
R858  0  [RC0402]  244.2 81.06 0 bottom
R860  510  [RC0402]  13.45 73.76 180 top
R861  150  [RC0402]  14.47 73.76 180 top
R862  150  [RC0402]  15.48 73.76 180 top
R863  49.9  [RC0603]  2.8 66.29 180 top
R864  49.9  [RC0603]  10.05 65.91 90 top
R865  49.9  [RC0603]  15.29 67.62 180 top
R866  510  [RC0402]  20.29 73.83 180 top
R867  150  [RC0402]  21.31 73.81 180 top
R868  150  [RC0402]  22.31 73.81 180 top
R869  49.9  [RC0603]  20.43 66.18 180 top
R870  80.6ohm  [RC0402]  196.05 79.22 180 top
R871  270ohm  [RC0402]  196.05 76.43 180 top
R873  60.4ohm  [RC0402]  195.04 79.22 180 top
R874  60.4ohm  [RC0402]  217.58 85.7 180 top
R875  80.6ohm  [RC0402]  216.56 85.7 180 top
R876  270ohm  [RC0402]  215.55 85.7 180 top
R878  60.4ohm  [RC0402]  217.58 88.68 180 top
R879  80.6ohm  [RC0402]  216.56 88.68 180 top
R880  270ohm  [RC0402]  215.55 88.68 180 top
R882  60.4ohm  [RC0402]  195.04 76.43 180 top
R883  80.6ohm  [RC0402]  194.02 79.22 180 top
R884  270ohm  [RC0402]  194.02 76.43 180 top
R886  110  [RC0402]  75.47 73.83 0 top
R887  110  [RC0402]  74.44 73.83 0 top
R888  110  [RC0402]  77.44 67.99 0 top
R889  110  [RC0402]  75.41 67.99 0 top
R890  110  [RC0402]  86.89 73.7 0 top
R891  110  [RC0402]  85.86 73.7 0 top
R892  110  [RC0402]  89.49 67.86 0 top
R893  110  [RC0402]  88.48 67.86 0 top
R894  110  [RC0402]  118.75 67.4 0 top
R895  110  [RC0402]  117.74 67.4 0 top
R896  110  [RC0402]  120.75 72.92 0 top
R897  110  [RC0402]  119.73 72.92 0 top
R898  110  [RC0402]  144.94 67.99 0 top
R899  110  [RC0402]  143.93 67.99 0 top
R900  110  [RC0402]  147.04 73.83 0 top
R901  110  [RC0402]  146.02 73.83 0 top
R902  110  [RC0402]  157.51 67.99 0 top
R903  110  [RC0402]  156.5 67.99 0 top
R904  110  [RC0402]  159.61 73.83 0 top
R905  110  [RC0402]  158.59 73.83 0 top
R906  110  [RC0402]  170.09 67.99 0 top
R907  110  [RC0402]  169.07 67.99 0 top
R908  110  [RC0402]  169.13 73.83 0 top
R909  110  [RC0402]  170.15 73.83 0 top
R910  110  [RC0402]  182.79 73.83 0 top
R911  110  [RC0402]  181.77 73.83 0 top
R912  110  [RC0402]  183.8 73.83 0 top
R913  110  [RC0402]  184.82 73.83 0 top
R914  110  [RC0402]  193.01 79.26 0 top
R915  110  [RC0402]  195.23 68.28 0 top
R917  510  [RC0402]  16.52 73.78 180 top
R918  150  [RC0402]  17.54 73.78 180 top
R919  150  [RC0402]  18.56 73.78 180 top
R920  510  [RC0402]  16.55 68.11 180 top
R921  150  [RC0402]  17.56 68.11 180 top
R922  150  [RC0402]  18.56 68.12 180 top
R923  110  [RC0402]  63.03 73.83 0 top
R924  110  [RC0402]  62 73.83 0 top
R925  110  [RC0402]  64.99 67.99 0 top
R926  110  [RC0402]  62.96 67.99 0 top
R928  110  [RC0402]  142.19 67.91 0 top
R929  110  [RC0402]  141.18 67.91 0 top
R930  110  [RC0402]  142.26 73.75 0 top
R931  110  [RC0402]  141.24 73.75 0 top
R932  110  [RC0402]  27.07 68.1 0 top
R933  110  [RC0402]  25.04 68.1 0 top
R934  110  [RC0402]  36.86 73.83 0 top
R935  110  [RC0402]  38.9 73.83 0 top
R936  110  [RC0402]  39.85 67.99 0 top
R937  110  [RC0402]  38.83 67.99 0 top
R938  110  [RC0402]  50.45 73.83 0 top
R939  110  [RC0402]  49.42 73.83 0 top
R940  110  [RC0402]  52.42 67.99 0 top
R941  110  [RC0402]  51.41 67.99 0 top
R943  0  [RC0402]  243.17 67.47 180 top
R944  0  [RC0402]  244.21 67.46 180 top
R945  0  [RC0402]  239.69 80.93 0 bottom
R946  0  [RC0402]  240.71 80.93 0 bottom
R947  0  [RC0402]  236.8 67.32 180 top
R948  0  [RC0402]  237.86 67.32 180 top
R953  4.7K  [RC0402]  238.76 116.17 270 top
R957  0  [RC0402]  249.23 103.13 180 top
R958  0  [RC0402]  250.22 103.13 180 top
R959  0  [RC0402]  246.42 103.13 180 top
R960  0  [RC0402]  245.43 103.13 180 top
R961  0  [RC0402]  257.82 103.13 180 top
R962  0  [RC0402]  256.83 103.13 180 top
R963  0  [RC0402]  253.05 103.13 180 top
R964  0  [RC0402]  254.04 103.13 180 top
R985  33  [RC0402]  235.23 8.93 0 bottom
R986  33  [RC0402]  229.58 8.93 0 bottom
R1005  270  [RC0402]  230.6 8.93 180 bottom
R1007  270  [RC0402]  236.25 8.93 180 bottom
R1012  @10K  [RC0402]  245.85 241.83 270 top
R1013  @4.7K  [RC0402]  231.12 242.57 90 top
R1014  0  [RC0402]  233.58 241.58 90 top
R1018  33  [RC0402]  189.47 235.56 0 top
R1019  10ohm(1%)  [RC0402]  69.92 185.39 0 top
R1036  0  [RC0402]  238.76 124.68 270 top
R1037  @0  [RC0402]  235.88 126.7 180 bottom
R1038  0  [RC0402]  238.76 121.63 270 top
R1039  @0  [RC0402]  238.76 123.66 270 bottom
R1040  0  [RC0402]  238.76 128.74 90 top
R1041  @0  [RC0402]  238.76 125.69 90 top
R1042  0  [RC0402]  238.76 120.61 270 top
R1043  0  [RC0402]  234.03 126.7 180 bottom
R1044  @0  [RC0402]  238.76 122.64 270 bottom
R1045  0  [RC0402]  238.76 125.69 270 bottom
R1047  4.99K(1%)  [RC0402]  220.6 121.03 90 top
R1048  0  [RC0402]  116.25 236.36 180 top
R1050  @0  [RC0402]  238.76 126.71 90 top
R1051  @0  [RC0402]  238.76 127.72 90 top
R1052  @0  [RC0402]  238.76 123.66 90 top
R1053  @0  [RC0402]  238.76 122.64 90 top
R1054  @0  [RC0402]  238.76 121.63 90 bottom
R1055  0  [RC0402]  238.76 130.75 90 top
R1056  @0  [RC0402]  238.76 129.73 90 top
R1057  @33  [RC0402]  234.22 8.93 0 bottom
R1058  @33  [RC0402]  228.57 8.93 0 bottom
R1059  150  [RC0402]  238.76 119.6 270 top
R1060  33  [RC0402]  238.76 118.58 270 top
R1063  4.02K  [RC0603]  239.8 212.05 0 top
R1064  4.02K  [RC0603]  241.32 212.05 180 top
R1065  0  [RC0402]  226.08 137.84 180 top
R1066  1K  [RC0402]  227.1 137.82 0 top
R1067  @1K  [RC0402]  224.6 137.39 270 top
R1068  39.2K  [RC0402]  236.11 136.86 0 top
R1069  36.5K  [RC0402]  235.1 136.85 180 top
R1070  4.7K  [RC0402]  231.71 131.65 0 bottom
R1071  49.9  [RC0402]  234.19 115.53 0 bottom
R1072  49.9  [RC0402]  233.18 115.53 0 bottom
R1073  49.9  [RC0402]  232.16 115.53 0 bottom
R1074  49.9  [RC0402]  231.14 115.53 0 bottom
R1075  49.9  [RC0402]  229.17 115.53 0 bottom
R1076  49.9  [RC0402]  228.16 115.53 0 bottom
R1077  49.9  [RC0402]  227.16 115.52 0 bottom
R1078  49.9  [RC0402]  226.13 115.53 0 bottom
R1079  220ohm  [RC0402]  192.6 235.53 180 top
R1081  @10K  [RC0402]  177.13 219.68 270 top
R1082  @4.7K  [RC0402]  188.68 211.46 180 top
R1083  4.7K  [RC0402]  188.68 214.25 180 top
R1084  @4.7K  [RC0402]  190.71 214.25 180 top
R1085  4.7K  [RC0402]  189.7 214.25 180 top
R1086  @4.7K  [RC0402]  192.74 214.25 180 top
R1087  4.7K  [RC0402]  191.73 214.25 180 top
R1088  @4.7K  [RC0402]  180.27 235.57 180 top
R1089  4.7K  [RC0402]  179.25 235.56 180 top
R1090  4.7K  [RC0402]  177.13 224.76 270 top
R1091  0  [RC0402]  174.46 225.27 90 top
R1092  @4.7K  [RC0402]  174.46 224.25 270 top
R1093  0  [RC0402]  190.34 222.58 270 bottom
R1094  4.7K  [RC0402]  190.34 221.56 270 bottom
R1095  @4.7K  [RC0402]  190.34 220.55 270 bottom
R1096  4.7K  [RC0402]  185.63 214.25 180 top
R1097  @4.7K  [RC0402]  185.63 211.46 180 top
R1098  @4.7K  [RC0402]  184.62 211.44 180 top
R1099  4.7K  [RC0402]  184.62 214.25 180 top
R1100  @4.7K  [RC0402]  186.65 211.46 180 top
R1101  4.7K  [RC0402]  186.65 214.25 180 top
R1102  @4.7K  [RC0402]  187.66 211.46 180 top
R1103  4.7K  [RC0402]  187.66 214.25 180 top
R1108  4.7K  [RC0402]  182.3 235.57 0 top
R1110  4.7K  [RC0402]  181.28 235.57 0 top
R1112  @4.7K  [RC0402]  177.13 232.89 90 top
R1113  4.7K  [RC0402]  177.13 231.87 90 top
R1114  @4.7K  [RC0402]  181.57 211.49 180 top
R1115  4.7K  [RC0402]  181.58 214.22 180 top
R1116  @10K  [RC0402]  182.59 214.22 180 top
R1117  10K  [RC0402]  183.61 214.22 180 top
R1118  @4.7K  [RC0402]  177.13 230.86 270 top
R1119  0  [RC0402]  174.46 230.35 90 top
R1120  4.7K  [RC0402]  174.46 231.37 270 top
R1122  0  [RC0402]  174.46 219.17 90 top
R1123  0  [RC0402]  177.13 222.72 90 top
R1124  4.7K  [RC0402]  174.46 222.22 90 top
R1125  @4.7K  [RC0402]  174.46 221.21 90 top
R1126  @10K  [RC0402]  185.35 235.56 0 top
R1127  10K  [RC0402]  186.36 235.56 0 top
R1128  10K  [RC0402]  196.43 228.94 90 bottom
R1129  @10K  [RC0402]  196.43 227.92 90 bottom
R1130  0  [RC0402]  184.33 235.56 0 top
R1131  0  [RC0402]  195.99 230.41 180 bottom
R1160  0  [RC0402]  178.24 235.57 0 top
R1161  0  [RC0402]  177.13 233.91 90 top
R1162  0  [RC0402]  177.13 223.75 90 top
R1163  0  [RC0402]  174.46 223.24 90 top
R1164  0  [RC0402]  177.13 217.64 90 top
R1165  0  [RC0402]  177.13 216.62 90 top
R1166  0  [RC0402]  177.13 215.61 90 top
R1167  0  [RC0402]  180.57 214.22 180 top
R1172  0  [RC0402]  240.69 93.13 0 bottom
R1182  0  [RC0402]  16.35 119.75 90 top
R1183  0  [RC0402]  89.69 223.94 90 top
R1184  0  [RC0402]  89.69 224.95 90 top
R1186  0  [RC0402]  10.25 115.67 270 top
R1187  @4.7K  [RC0402]  191.57 22.85 90 bottom
R1188  4.7K  [RC0402]  189.28 23.99 90 bottom
R1189  4.7K  [RC0402]  189.28 22.85 270 bottom
R1190  33  [RC0402]  191.57 23.99 90 bottom
R1191  33  [RC0402]  191.57 25.14 90 bottom
R1195  @0  [RC0402]  238.78 124.69 90 bottom
R1198  0  [RC0402]  177.13 229.84 270 top
R1202  0  [RC0402]  174.47 227.27 270 top
R1207  0  [RC0402]  93.92 236.38 0 top
R1236  @33  [RC0402]  188.43 235.56 0 top
R1237  @33  [RC0402]  194.68 235.53 0 top
R1238  110  [RC0402]  26.05 68.1 0 top
R1239  110  [RC0402]  24.02 68.1 0 top
R1240  110  [RC0402]  37.82 67.99 0 top
R1241  110  [RC0402]  36.8 67.99 0 top
R1242  110  [RC0402]  39.91 73.83 0 top
R1243  110  [RC0402]  37.88 73.83 0 top
R1244  110  [RC0402]  50.39 67.99 0 top
R1245  110  [RC0402]  49.36 67.99 0 top
R1246  110  [RC0402]  51.47 73.83 0 top
R1247  110  [RC0402]  52.49 73.83 0 top
R1248  110  [RC0402]  63.98 67.99 0 top
R1249  110  [RC0402]  61.93 67.99 0 top
R1250  110  [RC0402]  65.06 73.83 0 top
R1251  110  [RC0402]  64.04 73.83 0 top
R1252  110  [RC0402]  76.42 67.99 0 top
R1253  110  [RC0402]  74.38 67.99 0 top
R1254  110  [RC0402]  77.5 73.83 0 top
R1255  110  [RC0402]  76.49 73.83 0 top
R1256  110  [RC0402]  87.46 67.86 0 top
R1257  110  [RC0402]  86.43 67.86 0 top
R1258  110  [RC0402]  88.92 73.7 0 top
R1259  110  [RC0402]  87.9 73.7 0 top
R1260  110  [RC0402]  118.72 72.92 0 top
R1261  110  [RC0402]  117.7 72.92 0 top
R1262  110  [RC0402]  120.79 67.4 0 top
R1263  110  [RC0402]  119.77 67.4 0 top
R1264  110  [RC0402]  140.22 73.75 0 top
R1265  110  [RC0402]  139.21 73.75 0 top
R1266  110  [RC0402]  139.15 67.91 0 top
R1267  110  [RC0402]  140.16 67.91 0 top
R1268  110  [RC0402]  145 73.83 0 top
R1269  110  [RC0402]  143.99 73.83 0 top
R1270  110  [RC0402]  146.97 67.99 0 top
R1271  110  [RC0402]  145.96 67.99 0 top
R1272  110  [RC0402]  157.58 73.83 0 top
R1273  110  [RC0402]  156.56 73.83 0 top
R1274  110  [RC0402]  159.55 67.99 0 top
R1275  110  [RC0402]  158.53 67.99 0 top
R1276  110  [RC0402]  171.17 73.83 0 top
R1277  110  [RC0402]  172.12 67.99 0 top
R1278  110  [RC0402]  172.18 73.83 0 top
R1279  110  [RC0402]  171.1 67.99 0 top
R1280  110  [RC0402]  182.72 67.99 0 top
R1281  110  [RC0402]  181.71 67.99 0 top
R1282  110  [RC0402]  184.76 67.99 0 top
R1283  110  [RC0402]  183.74 67.99 0 top
R1284  110  [RC0402]  194.19 68.28 0 top
R1285  110  [RC0402]  196.29 68.27 0 top
R1286  4.7K  [RC0402]  159.79 141.26 90 bottom
R1287  4.7K  [RC0402]  176.62 145.64 0 bottom
R1288  4.7K  [RC0402]  177.64 145.64 0 bottom
R1289  4.7K  [RC0402]  194.86 139.37 180 bottom
R1290  4.7K  [RC0402]  194.86 145.13 180 bottom
R1291  0  [RC0402]  161.13 147.93 0 bottom
R1292  4.7K  [RC0402]  158.59 251.88 0 top
R1293  4.7K  [RC0402]  157.57 251.88 0 top
R1294  150  [RC0402]  156.05 256.64 0 top
R1295  470ohm  [RC0402]  214.44 246.77 90 top
R1297  75  [RC0402]  264.79 65.91 0 bottom
R1298  75  [RC0402]  260.95 65.89 0 bottom
R1299  75  [RC0402]  257.14 65.89 0 bottom
R1300  75  [RC0402]  253.33 66.27 0 bottom
R1301  4.7Kohm  [RC0402]  171.58 154.58 180 bottom
R1302  4.7Kohm  [RC0402]  172.58 154.58 180 bottom
R1303  4.7Kohm  [RC0402]  172.95 159.65 180 bottom
R1304  0ohm  [RC0402]  170.58 154.59 0 bottom
R1305  0ohm  [RC0402]  173.58 154.58 0 bottom
R1306  0ohm  [RC0402]  171.93 159.65 0 bottom
R1307  9.1Kohm  [RC0402]  169.57 154.59 180 bottom
R1308  9.1Kohm  [RC0402]  174.58 154.57 180 bottom
R1309  9.1Kohm  [RC0402]  170.93 159.64 180 bottom
R1310  33  [RC0402]  193.84 139.37 0 bottom
R1311  0ohm  [RC0402]  166.66 144.03 270 bottom
R1312  0ohm  [RC0402]  143.92 150.31 180 bottom
R1313  0ohm  [RC0402]  144.93 150.31 180 bottom
R1314  0ohm  [RC0402]  145.95 150.31 180 bottom
R1315  0ohm  [RC0402]  146.94 150.31 180 bottom
R1316  0ohm  [RC0402]  147.96 150.31 180 bottom
R1317  0ohm  [RC0402]  148.97 150.31 180 bottom
R1318  12K  [RC0402]  233.52 183.72 180 top
R1319  10K  [RC0402]  224.51 167 180 bottom
R1320  10K  [RC0402]  227.56 167.03 0 bottom
R1321  @10K  [RC0402]  225.53 167 180 bottom
R1322  @10K  [RC0402]  226.55 167.03 0 bottom
R1323  0  [RC0402]  235.31 112.15 180 top
R1324  0  [RC0402]  236.33 112.15 180 top
R1325  0  [RC0402]  231.5 112.15 180 top
R1326  0  [RC0402]  232.58 112.15 180 top
R1327  0  [RC0402]  228.71 112.09 180 top
R1328  0  [RC0402]  227.69 112.09 180 top
R1329  0  [RC0402]  224.83 112.09 180 top
R1330  0  [RC0402]  223.82 112.09 180 top
R1331  75  [RC0402]  234.92 75.85 0 bottom
R1332  75  [RC0402]  230.6 76.17 270 bottom
R1333  75  [RC0402]  226.98 76.17 270 bottom
R1334  75  [RC0402]  223.29 76.24 270 bottom
R1335  @0ohm  [RC0402]  264.7 87.54 180 top
R1336  @0ohm  [RC0402]  260.95 87.54 180 top
R1337  @0ohm  [RC0402]  257.08 83.31 180 bottom
R1338  @0ohm  [RC0402]  253.34 83.31 180 bottom
R1339  10K  [RC0402]  102.25 204.38 0 top
R1340  10K  [RC0402]  112.42 204.38 0 top
R1341  10K  [RC0402]  121.19 212.76 90 top
R1343  0  [RC0402]  96.16 204.38 180 top
R1344  0  [RC0402]  98.16 204.38 180 top
R1345  0  [RC0402]  99.18 204.38 180 top
R1346  33  [RC0402]  97.15 204.38 180 top
R1347  1K  [RC0402]  95.15 204.39 180 top
R1350  0  [RC0402]  109.21 236.38 180 top
R1351  0  [RC0402]  101.07 236.38 0 top
R1353  0  [RC0402]  115.26 236.36 180 top
R1362  10K  [RC0402]  100.19 204.38 0 top
R1363  10K  [RC0402]  101.21 204.38 0 top
R1364  10K  [RC0402]  107.34 204.38 0 top
R1365  10K  [RC0402]  106.33 204.38 0 top
R1366  10K  [RC0402]  116.49 204.38 0 top
R1367  10K  [RC0402]  115.47 204.38 0 top
R1368  4.7K  [RC0402]  155.66 169.71 0 bottom
R1369  33  [RC0402]  243.17 116.94 0 bottom
R1371  33  [RC0402]  244.01 122.41 0 top
R1372  22ohm 5%  [RC0402]  159.38 169.92 180 top
R1373  22ohm 5%  [RC0402]  158.36 169.92 180 top
R1374  33  [RC0402]  140.07 168.98 90 top
R1375  33  [RC0402]  140.07 167.71 90 top
R1376  33  [RC0402]  140.14 170.32 90 top
R1377  33  [RC0402]  140.11 171.61 90 top
R1378  33  [RC0402]  140.11 174.28 90 top
R1379  33  [RC0402]  140.11 173.07 90 top
R1382  150  [RC0402]  142.71 183.17 270 top
R1383  150  [RC0402]  142.71 181.96 270 top
R1386  33  [RC0402]  140.11 175.3 90 top
R1387  33  [RC0402]  140.11 176.5 90 top
R1388  33  [RC0402]  140.08 178.72 90 top
R1389  33  [RC0402]  140.08 177.52 90 top
R1390  33  [RC0402]  140.08 179.74 90 top
R1391  33  [RC0402]  140.08 180.95 90 top
R1392  33  [RC0402]  140.11 183.17 90 top
R1393  33  [RC0402]  140.11 181.96 90 top
R1394  150  [RC0402]  142.71 173.07 270 top
R1395  150  [RC0402]  142.71 175.3 270 top
R1396  150  [RC0402]  142.71 176.5 270 top
R1399  150  [RC0402]  142.61 168.98 270 top
R1400  150  [RC0402]  142.61 167.71 270 top
R1401  150  [RC0402]  142.74 170.32 270 top
R1402  150  [RC0402]  142.74 171.59 270 top
R1403  150  [RC0402]  142.71 174.28 270 top
R1404  33  [RC0402]  142.66 184.21 90 top
R1405  33  [RC0402]  142.67 185.21 90 top
R1406  33  [RC0402]  87.28 217.4 90 top
R1407  33  [RC0402]  87.28 216.25 90 top
R1408  @150  [RC0402]  89.69 217.4 270 top
R1409  @150  [RC0402]  89.69 216.25 270 top
R1410  33  [RC0402]  163.38 169.67 270 top
R1411  33  [RC0402]  163.38 170.69 270 top
R1412  33  [RC0402]  163.38 171.7 270 top
R1413  33  [RC0402]  163.38 172.72 270 top
R1414  10K  [RC0402]  157.1 168.21 270 bottom
R1415  10K  [RC0402]  157.1 169.2 90 bottom
R1416  1K  [RC0402]  161.06 182.34 90 top
R1417  1K  [RC0402]  149.82 186.26 180 top
R1418  1K  [RC0402]  150.83 186.26 180 top
R1419  1K  [RC0402]  155.03 186.03 180 top
R1420  @4.7K  [RC0402]  164.3 183.93 270 top
R1421  4.7K  [RC0402]  161.06 183.36 90 top
R1422  4.7K  [RC0402]  164.3 184.95 270 top
R1423  @4.7K  [RC0402]  161.06 184.38 90 top
R1424  150  [RC0402]  40.94 208.6 270 top
R1425  150  [RC0402]  39.04 208.6 90 top
R1426  33  [RC0402]  40.56 207.07 180 top
R1427  33  [RC0402]  39.54 207.07 180 top
R1437  1K  [RC0402]  108.17 182.31 90 top
R1438  1K  [RC0402]  108.19 183.39 270 top
R1439  0  [RC0603]  108.45 181.04 90 top
R1440  150K  [RC0402]  103.52 176.2 0 top
R1443  0  [RC0402]  89.63 234.1 270 top
R1444  0  [RC0402]  89.69 233.08 270 top
R1445  0  [RC0402]  89.69 231.05 270 top
R1446  0  [RC0402]  89.69 232.06 270 top
R1447  49.9  [RC0402]  110.26 236.38 0 bottom
R1448  49.9  [RC0402]  111.22 236.38 0 bottom
R1449  49.9  [RC0402]  102.07 236.38 180 top
R1450  49.9  [RC0402]  94.26 236.38 0 bottom
R1451  49.9  [RC0402]  121.19 229.52 270 top
R1452  49.9  [RC0402]  121.25 230.54 270 top
R1453  10K  [RC0402]  93.12 204.38 0 top
R1454  0  [RC0402]  94.14 204.38 180 bottom
R1455  0  [RC0402]  101.18 204.38 180 bottom
R1456  10K  [RC0402]  117.5 204.38 180 bottom
R1457  @10K  [RC0402]  117.5 204.38 180 top
R1458  @10K  [RC0402]  114.46 204.38 0 top
R1459  10K  [RC0402]  113.44 204.38 180 top
R1460  @10K  [RC0402]  123.6 211.81 90 top
R1461  10K  [RC0402]  121.19 211.74 270 top
R1462  10K  [RC0402]  108.36 204.38 0 top
R1463  @10K  [RC0402]  108.36 204.38 0 bottom
R1464  10K  [RC0402]  121.25 223.37 90 top
R1466  10K  [RC0402]  121.25 223.37 270 bottom
R1467  @1K  [RC0402]  121.25 222.35 270 top
R1468  @1K  [RC0402]  121.25 224.38 90 bottom
R1469  @10K  [RC0402]  121.19 207.68 270 top
R1470  @10K  [RC0402]  89.69 213.21 90 top
R1471  10K  [RC0402]  120.49 204.32 180 top
R1472  @10K  [RC0402]  123.6 207.11 270 top
R1473  270  [RC0402]  260.32 8.93 180 bottom
R1474  270  [RC0402]  258.28 8.93 180 bottom
R1476  33  [RC0402]  259.3 8.93 0 bottom
R1477  33  [RC0402]  257.27 8.93 0 bottom
R1478  33  [RC0402]  206.4 25.93 180 bottom
R1479  33  [RC0402]  208.42 25.91 180 bottom
R1480  100K(1%)  [RC0402]  207.4 25.93 0 bottom
R1481  33  [RC0402]  206.3 17.28 180 bottom
R1482  33  [RC0402]  208.34 17.27 180 bottom
R1483  100K(1%)  [RC0402]  207.32 17.28 0 bottom
R1484  33  [RC0402]  227.83 44.2 0 top
R1485  33  [RC0402]  228.83 44.18 180 top
R1486  100K(1%)  [RC0402]  226.82 44.2 180 top
R1487  33  [RC0402]  224.78 44.23 180 bottom
R1488  33  [RC0402]  225.79 44.2 0 bottom
R1489  100K(1%)  [RC0402]  226.82 44.21 0 bottom
R1490  10K  [RC0402]  222.47 167.04 0 bottom
R1491  10K  [RC0402]  234.34 189.46 90 bottom
R1492  4.7K  [RC0402]  169.57 147.99 180 bottom
R1493  4.7K  [RC0402]  194.28 142.85 90 bottom
R1494  0ohm  [RC0402]  146.02 140.43 0 bottom
R1495  @0ohm  [RC0402]  147.03 140.43 0 bottom
R1496  @0ohm  [RC0402]  145 140.43 0 bottom
R1497  4.7K  [RC0402]  160.95 182.51 180 bottom
R1498  4.7K  [RC0402]  160.59 184.5 90 bottom
R1499  10ohm  [RC0603]  110.5 94.05 270 bottom
R1500  33  [RC0402]  155.48 147.23 0 bottom
R1501  49.9ohm  [RC0402]  121.19 219.94 90 top
R1502  49.9ohm  [RC0402]  121.19 220.95 90 top
R1503  49.9ohm  [RC0402]  110.39 204.38 0 top
R1504  49.9ohm  [RC0402]  109.38 204.38 0 top
R1505  49.9ohm  [RC0402]  103.29 204.38 0 top
R1506  49.9ohm  [RC0402]  104.31 204.38 0 top
R1507  0  [RC0402]  149.2 143.37 180 bottom
R1508  0  [RC0402]  156.31 142.91 180 bottom
R1509  150  [RC0402]  85.82 216.86 180 top
R1510  0  [RC0402]  184.62 141.53 270 bottom
R1511  0  [RC0402]  184.62 142.54 270 bottom
RB1  24.9K  [RC0402]  139.09 232 180 top
RB2  0  [RC0402]  83.43 183.83 180 top
RB3  4.7K  [RC0402]  85.46 183.83 0 top
RB4  0 ohm  [RC0402]  138.08 232 180 top
RB5  4.7K  [RC0402]  90.04 184.59 90 top
RB6  33  [RC0402]  77.21 186.62 90 top
RB7  150  [RC0402]  79.5 186.62 90 top
RB9  @4.7K  [RC0402]  200.37 206.86 180 top
RB10  4.7K  [RC0402]  201.45 206.86 180 top
RB11  4.7K  [RC0402]  202.53 206.86 180 top
RB12  33  [RC0402]  77.21 187.76 90 top
RB13  150  [RC0402]  79.5 187.76 90 top
RB15  0  [RC0402]  169.61 252.04 0 top
RB16  @10K  [RC0402]  168.59 252.04 180 top
RB17  @10K  [RC0402]  167.57 252.04 180 top
RB18  0  [RC0402]  166.56 252.04 0 top
RB21  150  [RC0402]  90.06 189.67 270 top
RB22  33  [RC0402]  92.45 189.67 270 top
RB25  4.7K  [RC0402]  200.37 204.38 0 top
RB26  @4.7K  [RC0402]  201.45 204.38 0 top
RB27  @4.7K  [RC0402]  202.53 204.38 0 top
RB28  33  [RC0402]  77.18 188.91 90 top
RB29  150  [RC0402]  79.5 188.91 90 top
RB30  @4.7K  [RC0402]  121.23 224.35 90 top
RB31  4.7K  [RC0402]  121.23 225.36 90 top
RB32  @4.7K  [RC0402]  114.24 236.36 180 top
RB33  4.7K  [RC0402]  113.22 236.36 180 top
RB34  @4.7K  [RC0402]  110.23 236.37 180 top
RB35  4.7K  [RC0402]  109.25 236.32 0 bottom
RB37  150  [RC0402]  90.06 190.83 270 top
RB38  33  [RC0402]  92.45 190.81 270 top
RB39  33  [RC0402]  77.18 190.05 90 top
RB40  150  [RC0402]  79.5 190.05 90 top
RB44  33  [RC0402]  161.11 174.77 270 top
RB45  4.7K  [RC0402]  82.16 193.99 180 top
RB46  100 1%  [RC0402]  96.74 176.88 270 bottom
RB47  100 1%  [RC0402]  96.74 175.87 90 bottom
RB48  40.2  [RC0402]  18.89 175.61 180 bottom
RB49  40.2  [RC0402]  19.9 175.61 180 bottom
RB50  40.2  [RC0402]  20.92 175.61 180 bottom
RB51  40.2  [RC0402]  21.94 175.61 180 bottom
RB52  40.2  [RC0402]  22.95 175.61 180 bottom
RB53  40.2  [RC0402]  23.97 175.61 180 bottom
RB54  40.2  [RC0402]  24.98 175.61 180 bottom
RB55  40.2  [RC0402]  26 175.61 180 bottom
RB56  40.2  [RC0402]  27.02 175.61 180 bottom
RB57  40.2  [RC0402]  28.03 175.61 180 bottom
RB58  40.2  [RC0402]  29.05 175.61 180 bottom
RB59  40.2  [RC0402]  32.1 175.61 180 bottom
RB60  40.2  [RC0402]  60.42 175.49 180 bottom
RB61  40.2  [RC0402]  62.7 172.58 180 bottom
RB62  40.2  [RC0402]  62.45 175.49 180 bottom
RB63  40.2  [RC0402]  63.47 175.49 180 bottom
RB64  40.2  [RC0402]  64.48 175.49 180 bottom
RB65  40.2  [RC0402]  65.5 175.49 180 bottom
RB66  40.2  [RC0402]  69.56 175.49 180 bottom
RB67  40.2  [RC0402]  70.58 175.49 180 bottom
RB68  40.2  [RC0402]  83.4 175.49 180 bottom
RB69  40.2  [RC0402]  84.42 175.49 180 bottom
RB70  40.2  [RC0402]  85.44 175.49 180 bottom
RB71  40.2  [RC0402]  86.45 175.49 180 bottom
RB72  40.2  [RC0402]  87.47 175.49 180 bottom
RB73  40.2  [RC0402]  88.48 175.49 180 bottom
RB74  40.2  [RC0402]  89.5 175.49 180 bottom
RB75  40.2  [RC0402]  90.52 175.49 180 bottom
RB76  40.2  [RC0402]  91.66 175.49 180 bottom
RB77  40.2  [RC0402]  92.68 175.49 180 bottom
RB78  4.7K  [RC0402]  93.69 175.49 180 bottom
RB79  40.2  [RC0402]  94.71 175.36 180 bottom
RB80  40.2  [RC0402]  66.51 174.22 180 bottom
RB81  40.2  [RC0402]  67.53 174.22 180 bottom
RB82  40.2  [RC0402]  68.55 174.22 180 bottom
RB83  40.2  [RC0402]  73.37 172.44 90 bottom
RB84  33  [RC0402]  234.7 245.66 180 bottom
RB85  40.2  [RC0402]  85.18 171.68 270 bottom
RB86  40.2  [RC0402]  82.26 175.49 180 bottom
RB88  33  [RC0402]  236.06 245.68 180 bottom
RB89  100 1%  [RC0402]  101.44 171.68 270 bottom
RB90  40.2  [RC0402]  85.18 170.66 270 bottom
RB91  40.2  [RC0402]  73.37 170.41 90 bottom
RB92  40.2  [RC0402]  77.94 170.41 270 bottom
RB94  @100  [RC0402]  101.44 170.66 90 bottom
RB95  40.2  [RC0402]  73.37 169.47 90 bottom
RB96  40.2  [RC0402]  77.94 169.39 270 bottom
RB98  4.7K  [RC0402]  14.95 169.14 270 bottom
RB99  40.2  [RC0402]  86.45 167.61 270 bottom
RB100  40.2  [RC0402]  77.94 168.37 270 bottom
RB101  40.2  [RC0402]  14.95 168.12 270 bottom
RB102  40.2  [RC0402]  84.89 160.68 180 bottom
RB103  1K  [RC0402]  41.11 167.87 90 bottom
RB104  100 1%  [RC0402]  102.17 167.87 180 bottom
RB105  100 1%  [RC0402]  71.34 167.84 90 bottom
RB106  4.7K  [RC0402]  5.81 170.79 180 top
RB107  40.2  [RC0402]  77.94 167.36 270 bottom
RB108  @1K  [RC0402]  41.11 166.85 270 bottom
RB109  @10K  [RC0402]  184.96 186.01 270 bottom
RB110  40.2  [RC0402]  85.05 166.45 90 bottom
RB111  40.2  [RC0402]  64.89 166.57 90 bottom
RB112  40.2  [RC0402]  14.95 166.34 270 bottom
RB113  100 1%  [RC0402]  60.16 166.22 90 bottom
RB114  4.7K  [RC0402]  6.89 170.79 180 top
RB115  40.2  [RC0402]  64.89 165.58 90 bottom
RB116  40.2  [RC0402]  85.05 165.44 90 bottom
RB117  @100  [RC0402]  71.34 164.77 270 bottom
RB118  100 1%  [RC0402]  12.67 164.31 270 bottom
RB119  100 1%  [RC0402]  60.16 164.31 270 bottom
RB120  100 1%  [RC0402]  71.34 163.8 270 bottom
RB121  240 ohm 1%  [RC0402]  80.36 163.8 180 bottom
RB122  @100  [RC0402]  12.67 163.29 90 bottom
RB123  @10K  [RC0402]  184.96 181.94 270 bottom
RB124  100 1%  [RC0402]  12.67 162.28 90 bottom
RB125  240 ohm 1%  [RC0402]  47.46 162.02 270 bottom
RB126  240 ohm 1%  [RC0402]  41.24 161.54 90 bottom
RB127  240 ohm 1%  [RC0402]  61.28 160.98 0 bottom
RB128  240 ohm 1%  [RC0402]  95.34 160.63 0 bottom
RB129  4.7K  [RC0402]  121.17 214.81 270 top
RB130  4.7K  [RC0402]  121.17 215.85 270 top
RB132  0  [RC0402]  123.51 214.81 90 top
RB133  0  [RC0402]  123.51 215.85 90 top
RB134  @0  [RC0402]  200.56 125.64 0 bottom
RB135  @0  [RC0402]  199.55 125.64 0 bottom
RB145  100  [RC0402]  31.08 136.24 90 bottom
RB146  100  [RC0402]  42.13 136.24 90 bottom
RB147  @100  [RC0402]  22.57 136.05 180 bottom
RB148  @100  [RC0402]  23.59 136.12 0 bottom
RB150  @100  [RC0402]  20.67 139.1 0 bottom
RB153  @100  [RC0402]  21.11 140.62 270 bottom
RB154  2.2  [RC0603]  96.87 134.08 0 bottom
RB155  0  [RC0402]  166.59 133.45 0 bottom
RB156  @0  [RC0402]  21.11 135.54 90 bottom
RB158  @0  [RC0402]  19.65 139.1 180 bottom
RB159  100K(1%)  [RC0402]  35.14 189.9 90 bottom
RB162  10K  [RC0402]  95.6 132.69 0 bottom
RB167  1K(5%)  [RC0402]  39.23 190.97 270 bottom
RB168  0  [RC0402]  39.23 191.99 270 bottom
RB171  @100  [RC0402]  20.96 129.64 0 bottom
RB172  1K  [RC0402]  21.97 129.64 180 bottom
RB173  1ohm/0805  [RC0805]  96.87 128.5 270 bottom
RB174  2K(1%)  [RC0402]  121.53 168.57 0 bottom
RB175  @100  [RC0402]  21.64 127.36 90 bottom
RB176  118Kohm  [RC0402]  110.06 128.07 270 bottom
RB177  @0  [RC0402]  19.55 126.28 180 bottom
RB178  60.4  [RC0402_22X22_8OCT]  48.7 126.15 270 bottom
RB179  60.4  [RC0402_22X22_8OCT]  35.69 126.09 90 bottom
RB180  40.2  [RC0402_22X22_8OCT]  35.69 125.07 90 bottom
RB181  @2.7ohm  [RC0805]  44.87 190.4 90 bottom
RB182  100  [RC0402]  59.27 124.31 0 bottom
RB183  @2.7  [RC0805]  118.48 172.63 90 bottom
RB184  1K  [RC0402]  226.86 143.65 270 top
RB185  40.2  [RC0402_22X22_8OCT]  48.7 123.15 270 bottom
RB186  @1K  [RC0402]  226.86 142.74 270 top
RB187  1K(5%)  [RC0402]  123.18 174.28 180 bottom
RB188  4.7K  [RC0402]  160.97 133.59 0 bottom
RB189  10Kohm  [RC0402]  46.31 192.34 180 bottom
RB190  2.2  [RC0603]  96.87 118.72 0 bottom
RB191  1ohm  [RC0805]  161.64 120.11 270 bottom
RB192  10K  [RC0402]  95.6 117.07 0 bottom
RB193  1K  [RC0402]  28.79 115.99 270 bottom
RB194  1K  [RC0402_22X22_8OCT]  39.7 117.15 90 bottom
RB195  1K  [RC0402]  38.7 107.16 90 bottom
RB196  1K  [RC0402]  46.18 115.65 0 bottom
RB202  1ohm/0805  [RC0805]  94.64 111.85 270 bottom
RB207  4.53K  [RC0402_22X22_8OCT]  47.7 109.14 270 bottom
RB208  4.53K  [RC0402_22X22_8OCT]  30.71 109.1 270 bottom
RB209  1K  [RC0402]  38.28 108.69 180 bottom
RB214  @1ohm  [RC0805]  112.11 104.49 0 bottom
RB215  1ohm  [RC0805]  170.08 102.64 270 bottom
RB218  1.5Kohm  [RC0402]  111.09 95.29 270 bottom
RB227  1K(5%)  [RC0402]  110.2 99.67 180 bottom
RB228  0  [RC0805]  119.66 99.46 270 bottom
RB232  2.8K  [RC0402]  38.51 196.86 0 top
RB233  3.9K  [RC0402]  37.5 196.84 0 top
RB235  4.7K  [RC0402]  146.06 101.02 270 bottom
RB236  33  [RC0402]  32.35 94.46 0 bottom
RB242  33  [RC0402]  220.6 118.01 270 top
RB245  4.7K  [RC0402]  162.73 22.83 270 bottom
RB246  33  [RC0402]  160.2 23.97 270 bottom
RB247  33  [RC0402]  160.2 25.11 270 bottom
RB248  33  [RC0402]  160.2 26.25 270 bottom
RB249  33  [RC0402]  160.2 27.4 270 bottom
RB250  33  [RC0402]  160.2 28.54 270 bottom
RB251  33  [RC0402]  160.2 29.68 270 bottom
RB252  33  [RC0402]  160.2 30.83 270 bottom
RB253  33  [RC0402]  160.2 31.97 270 bottom
RB254  4.7K  [RC0402]  220.6 116.99 270 top
RB255  33  [RC0402]  220.61 114.97 270 top
RB256  @4.7K  [RC0402]  220.62 114.96 90 bottom
RB262  @4.7K  [RC0402]  160.21 22.83 90 bottom
RB263  4.7K  [RC0402]  162.74 23.97 270 bottom
RB264  4.7K  [RC0402]  162.74 25.11 270 bottom
RB265  4.7K  [RC0402]  162.74 26.25 270 bottom
RB266  4.7K  [RC0402]  162.74 27.4 270 bottom
RB267  4.7K  [RC0402]  162.74 28.54 270 bottom
RB268  4.7K  [RC0402]  162.74 29.68 270 bottom
RB269  4.7K  [RC0402]  162.74 30.83 270 bottom
RB270  4.7K  [RC0402]  162.74 31.97 270 bottom
RB273  @10K  [RC0402]  239.91 88.06 90 bottom
RB274  4.7K  [RC0402]  162.73 21.66 270 bottom
RB275  @4.7K  [RC0402]  160.19 21.66 90 bottom
RB276  33  [RC0402]  234.53 158.34 270 top
RB277  33  [RC0402]  234.53 159.36 270 top
RB278  0  [RC0402]  239.92 86.02 90 bottom
RB279  0  [RC0402]  189.27 21.71 270 bottom
RB280  1K  [RC0402]  239.92 87.04 270 bottom
RB283  33  [RC0402]  246.33 95.67 90 top
RB287  @4.7K  [RC0402]  238.76 115.15 270 top
RB291  4.7K  [RC0402]  189.28 25.14 90 bottom
RB292  4.7K  [RC0402]  189.28 26.28 90 bottom
RB293  4.7K  [RC0402]  189.28 27.42 90 bottom
RB294  4.7K  [RC0402]  189.28 28.57 90 bottom
RB295  4.7K  [RC0402]  189.28 29.71 90 bottom
RB296  4.7K  [RC0402]  189.28 30.85 90 bottom
RB297  4.7K  [RC0402]  189.28 31.99 90 bottom
RB302  33  [RC0402]  191.57 26.28 90 bottom
RB303  33  [RC0402]  191.57 27.42 90 bottom
RB304  33  [RC0402]  191.57 28.57 90 bottom
RB305  33  [RC0402]  191.57 29.71 90 bottom
RB306  33  [RC0402]  191.57 30.85 90 bottom
RB307  33  [RC0402]  191.57 31.99 90 bottom
RB308  33  [RC0402]  207.92 47.6 0 bottom
RB309  4.7K  [RC0402]  208.93 47.6 0 bottom
RB310  4.7K  [RC0402]  215.03 47.62 180 bottom
RB311  33  [RC0402]  209.95 47.62 0 bottom
RB312  4.7K  [RC0402]  210.96 47.62 0 bottom
RB313  4.7K  [RC0402]  213 47.62 180 bottom
RB314  0ohm  [RC0603]  253.32 52.96 0 top
RB315  0ohm  [RC0603]  251.79 52.96 0 top
RB316  0ohm  [RC0603]  248.74 52.96 0 top
RB317  0ohm  [RC0603]  250.27 52.96 0 top
RB318  33  [RC0402]  237.04 150.7 270 top
RB319  0  [RC0402]  237.04 152.7 270 top
RB320  @0  [RC0402]  237.04 151.71 270 top
RB321  0  [RC0402]  237.04 153.72 270 top
RB322  33  [RC0402]  237.04 154.73 270 top
RB323  @4.7K  [RC0402]  207.97 44.12 180 bottom
RB324  100  [RC0402]  252.62 49.98 90 top
RB325  100  [RC0402]  249.49 49.94 90 top
RB326  4.7K  [RC0402]  204.97 44.14 180 bottom
RB327  4.7K  [RC0402]  205.98 44.14 180 bottom
RB328  @4.7K  [RC0402]  205.88 47.6 180 bottom
RB329  100ohm  [RC0402]  206.9 47.6 180 bottom
RB330  4.7K  [RC0402]  214.01 47.62 180 bottom
RB331  4.7K  [RC0402]  211.98 47.62 180 bottom
RB332  100ohm  [RC0402]  206.98 44.12 180 bottom
RB333  0  [RC0402]  242.92 154.28 270 top
RB334  0  [RC0402]  242.92 155.29 270 top
RB335  0  [RC0402]  245.96 152.12 270 top
RB336  0  [RC0402]  245.96 151.1 270 top
RB337  4.7K  [RC0402]  29.24 40.86 0 bottom
RB338  4.7K  [RC0402]  31.02 40.86 0 bottom
RB339  4.7K  [RC0402]  32.92 40.86 0 bottom
RB340  4.7K  [RC0402]  34.96 40.86 0 bottom
RB341  4.7K  [RC0402]  43.7 40.86 0 bottom
RB342  4.7K  [RC0402]  45.48 40.86 0 bottom
RB343  4.7K  [RC0402]  47.26 40.86 0 bottom
