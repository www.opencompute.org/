# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BU_CPLD2_TDO_R: length 3.9
  TOP w0.127: R349.2 183.97,178.84 U19.3 183.83,178.24 184.05,178.03 v1(184.18,178.03)
  BOTTOM w0.127: v1(184.18,178.03) 184.94,177.26 v2(185.39,177.26)
BU_SEL: length 4.6
  TOP w0.127: v1(180.88,181.07) 180.86,181.09 R316.1 181.89,182.02 R317.1 181.91,181.38 182.53,180.76 U19.6
  BOTTOM w0.127: v2(180.01,180.77) 180.31,181.07 v1(180.88,181.07)
C_PLL_BYPASS: length 20.6
  TOP w0.127: v1(17.54,129.86) 17.51,129.89 R545.2 16.8,129.55 16.64,129.39 14.26,129.39 R544.1 ; v4(25.7,127.65) U40.AK32
  S12 w0.127: v1(17.54,129.86) 19.78,129.86 20.08,129.56 20.72,129.56 22.14,128.14 23.94,128.14 24.22,127.86 24.22,127.43 24.48,127.17 25.22,127.17 v4(25.7,127.65)
  BOTTOM w0.127: v1(17.54,129.86) 16.89,130.51 16.89,134.94 v2(16.6,135.24)
CLK_BITS_MCLK: length 2.1
  TOP w0.127: R192.1 v1(199.8,228.95)
  BOTTOM w0.127: v1(199.8,228.95) 199.95,229.1 TPB7.1
CLK_BITS_OSC_MCLK: length 5
  TOP w0.127: U68.17 196.23,228.57 196.61,228.95 R192.2 R204.2
CLK_BITS_OSC_R: length 3.1
  TOP w0.127: R204.1 199.85,229.97 200.98,231.1 OSC2.3
CLK_BITS_TCLK: length 101.7
  TOP w0.127: R1237.1 v1(194.68,236.69) ; P1.AA6 v4(115.29,214.46) ; R1018.1 v1(189.47,236.71)
  S9 w0.127: v4(115.29,214.46) 116.1,213.65 121.25,213.65 121.73,213.17 122.59,213.17 123.39,213.97 129.68,213.97 131.77,216.05 132.06,216.05 133.01,217 135.84,217 138.14,219.3 149.76,219.3 150.58,220.12 157.18,220.12 157.38,220.32 162.46,220.32 162.65,220.13 163.78,220.13 164.03,219.87 169.56,219.87 170.34,220.65 170.34,228.21 172.33,230.2 176.47,230.2 177.39,231.11 177.39,233.34 179.15,235.1 183.01,235.1 183.98,236.08 v1(183.98,237.76)
  BOTTOM w0.127: v1(194.68,236.69) 193.11,235.11 190.21,235.11 189.47,235.85 v1(189.47,236.71) 189.4,236.71 188.29,237.83 183.98,237.83 v1(183.98,237.76)
COM_CTREF: length 183.9
  TOP w0.305: v1(149.69,141.78) 149.69,141.46 150.44,140.71 J2.A14
  TOP w0.508: R1335.2 v1(264.7,88.94) ; R1336.2 v1(260.95,88.87)
  S5 w0.254: v1(242.77,111.68) 242.95,111.51 242.95,99.42 248.23,94.13 248.23,87.3 251.54,84 257.2,84 260.93,87.73 260.93,88.86 v1(260.95,88.87)
  S9 w0.305: 183.7,140.56 188.16,136.1 212.19,136.1 215.67,132.62 215.67,117.67 221.06,112.29 228.87,112.29 229.47,111.68 v1(242.77,111.68)
  S9 w0.381: 183.7,140.56 173,140.56 172.18,141.39 172.18,143.29 170.68,144.79 150.58,144.79 149.22,143.43 149.22,142.24 v1(149.69,141.78)
  BOTTOM w0.508: R1338.2 255.2,82.86 v2(255.23,82.89) 255.26,82.86 R1337.2 258.62,82.86 259.11,83.35 259.11,87.03 v1(260.95,88.87) 261.84,87.98 263.74,87.98 v1(264.7,88.94)
COM_LPC_AD0: length 99.2
  TOP w0.127: U72.26 228.3,162.77 v1(228.12,162.6)
  BOTTOM w0.127: R1313.1 144.93,154.11 146.7,155.88 146.7,157.03 v2(147.3,157.63) 151.78,157.63 161.19,167.04 175.98,167.04 179.14,170.19 204.68,170.19 212.28,162.59 222.63,162.59 223.46,161.75 225.69,161.75 225.83,161.9 227.42,161.9 v1(228.12,162.6)
COM_LPC_AD1: length 97
  TOP w0.127: U72.23 226.35,162.05 226.34,162.05 v1(226.34,161.33)
  BOTTOM w0.127: v1(226.34,161.33) 226.25,161.42 223.05,161.42 222.64,161.83 212.05,161.83 204.06,169.82 179.78,169.82 176.4,166.44 161.22,166.44 151.67,156.88 151.67,156.46 150.59,155.38 v2(147.57,155.38) 145.36,153.16 145.36,152.42 145.95,151.82 R1314.1
COM_LPC_AD2: length 94.3
  TOP w0.127: v1(224.37,160.91) 224.4,160.93 U72.20
  BOTTOM w0.127: R1315.1 146.94,151.66 v2(146.75,151.85) 146.75,152.97 148.67,154.89 151.88,154.89 152.94,155.94 152.94,157.52 161.41,165.99 176.94,165.99 180.39,169.44 203.72,169.44 211.95,161.2 222.56,161.2 222.85,160.91 v1(224.37,160.91)
COM_LPC_AD3: length 91
  TOP w0.127: U72.17 222.45,161.21 v1(221.87,160.63)
  BOTTOM w0.127: v1(221.87,160.63) 221.71,160.47 211.94,160.47 203.38,169.03 181,169.03 177.4,165.44 161.49,165.44 153.39,157.33 153.39,155.55 152.29,154.45 149.47,154.45 v2(149.3,154.29) 148.78,153.76 148.78,153.74 147.98,152.95 147.98,150.79 R1316.1
COM_LPC_CLK: length 92.5
  TOP w0.127: U72.21 225.05,163.01 224.97,162.93 224.97,160.61 v1(224.59,160.22)
  BOTTOM w0.127: v1(224.59,160.22) 224.24,159.88 211.82,159.88 203.28,168.41 181.43,168.41 177.84,164.83 161.78,164.83 154.71,157.77 154.71,156.06 152.3,153.65 150.27,153.65 149.57,152.95 149.57,152.53 148.97,151.93 R1317.1
COM_LPC_FRAME: length 98.1
  TOP w0.127: v1(225.63,162.81) 225.7,162.88 U72.22
  BOTTOM w0.127: R1312.1 143.92,151.78 143.57,152.13 143.57,153.77 145.22,155.41 145.22,157.02 146.41,158.21 151.72,158.21 161.29,167.77 175.68,167.77 178.49,170.58 204.91,170.58 212.13,163.36 v2(220.44,163.36) 222.34,163.36 223.51,162.18 225.01,162.18 v1(225.63,162.81)
COM_LPC_SERIRQ: length 91
  TOP w0.127: v1(228.12,161.14) 228.95,161.96 U72.27
  BOTTOM w0.127: v2(229.23,160.95) 228.31,160.95 v1(228.12,161.14) 227.3,161.14 225.53,159.37 211.6,159.37 203.07,167.9 181.94,167.9 178.26,164.21 170.81,164.21 166.46,159.87 166.46,150.74 164.77,149.05 164.77,145.04 165.78,144.03 R1311.1
COM_TYPE0: length 78.2
  TOP w0.127: U9.A14 203.05,200.39 v4(203.67,201.01)
  S14 w0.127: v4(203.67,201.01) 189.42,201.01 187.74,199.33 187.74,189.71 185.34,187.31 185.34,187.31 185.23,187.2 185.23,166.51 v1(182.4,163.68)
  BOTTOM w0.127: v1(182.4,163.68) 173.07,163.68 170.39,161 170.39,156.19 170.58,156 R1304.2 169.58,155.04 R1307.1 ; v4(203.67,201.01) 203.29,200.63 v2(202.47,200.63)
COM_TYPE1: length 81
  TOP w0.127: U9.A15 v4(204.55,199.58)
  S5 w0.127: v1(180.11,165.07) 179.54,164.51 179.54,161.26 177.89,159.61 177.89,158.02 177.43,157.57 176.1,157.57 v1(174.53,155.99)
  S14 w0.127: v1(180.11,165.07) 180.11,163.27 181.33,162.05 182.5,162.05 185.6,165.15 185.6,187.21 188.3,189.91 188.3,199.19 189.36,200.25 202.53,200.25 203.2,199.58 v4(204.55,199.58)
  BOTTOM w0.127: v1(174.53,155.99) 174.58,155.93 R1308.1 173.59,155.03 R1305.2 ; v2(208.82,200.19) 207.86,200.19 207.36,200.7 205.67,200.7 v4(204.55,199.58)
COM_TYPE2: length 77.3
  TOP w0.127: U9.A17 206.06,199.08 206.59,199.62 v1(206.59,202.03)
  S14 w0.127: v1(181.85,163.14) 181.85,163.95 184.78,166.88 184.78,187.14 187.27,189.62 187.27,199.92 189.06,201.71 200.18,201.71 201.07,202.6 205.9,202.6 206.47,202.03 v1(206.59,202.03)
  BOTTOM w0.127: R1309.1 171.93,160.09 R1306.2 171.93,160.64 174.43,163.14 v1(181.85,163.14) ; v2(208.37,202.04) 208.44,202.04 208.44,202.03 v1(206.59,202.03)
COMA_INT: length 9.3
  TOP w0.127: v1(229.18,119.65) U52.L4
  BOTTOM w0.127: v2(224.22,123.15) 228.16,123.15 229.56,121.76 229.56,120.61 229.28,120.34 RB758.2 228.92,119.91 v1(229.18,119.65)
COME_GPO3: length 144.5
  TOP w0.127: J2.B63 174.94,146.05 175.37,146.48 v1(175.8,146.48) ; P1.H20 v4(101.29,229.46)
  S12 w0.127: v1(175.8,146.48) 174.92,146.48 173.96,147.44 173.96,151.36 175.8,153.2 175.8,159.14 178.53,161.87 178.53,187.97 173.61,192.89 v1(173.58,192.89)
  S16 w0.127: v4(101.29,229.46) 101.31,229.46 101.76,229.02 101.76,228.25 102.01,228 117,228 118.46,226.54 119.35,226.54 119.66,226.86 123.09,226.86 131.92,218.03 144.46,218.03 152.64,209.84 152.64,208.44 168.55,192.53 173.25,192.53 173.61,192.89 v1(173.58,192.89)
  BOTTOM w0.127: v2(174.55,192.89) v1(173.58,192.89)
COME_MANLAN_ACT: length 279.5
  TOP w0.127: J2.B2 144.44,141.84 142.71,140.12 v1(142.71,138.85)
  S7 w0.127: v1(259.11,10.96) 250.13,10.96 248.99,12.1 238.08,12.1 237.51,11.53 229.49,11.53 228.73,12.29 222.77,12.29 221.9,13.16 221.9,15.02 220.31,16.61 217.33,16.61 216.63,17.31 216.63,37.81 223.88,45.06 223.88,71.71 218.28,77.32 218.28,91.54 219.04,92.3 233.39,92.3 235.99,94.9 235.99,97.07 v1(235.74,97.32)
  S14 w0.127: v1(142.71,138.85) 147.87,133.69 152.23,133.69 153.61,135.07 173.21,135.07 188.71,119.57 188.71,110.37 196.3,102.78 202.09,102.78 204.56,100.3 204.56,97.44 206.85,95.16 215.55,95.16 217.8,97.41 217.8,97.41 223.77,97.41 224.52,98.15 233.77,98.15 234.6,97.32 v1(235.74,97.32)
  BOTTOM w0.127: v2(236.82,96.81) 236.31,97.32 v1(235.74,97.32) ; v1(259.11,10.96) 259.3,10.77 R1476.2
  BOTTOM w0.508: RB1300.1 v1(142.71,138.85)
COME_MANLAN_ACT_D_LED: length 5.6
  BOTTOM w0.127: R1473.2 261.66,8.47 v2(261.71,8.42) 261.71,7.44 263.54,5.61 LEDB13.A
COME_MANLAN_ACT_LED: length 4.1
  BOTTOM w0.127: LEDB13.C 260.74,5.9 260.08,6.56 v2(260.07,6.56) 260.07,6.57 259.3,7.34 R1476.1
COME_MANLAN_LINK: length 4.1
  TOP w0.127: J2.A8 147.44,140.49 147.54,140.59 v1(147.54,141.64)
  BOTTOM w0.127: v2(148.43,142.02) 147.92,142.02 v1(147.54,141.64) 147.21,141.64 147.03,141.46 R1495.2
COME_MANLAN_LINK100: length 6
  TOP w0.127: v1(145.06,142.28) 145.06,141.36 145.44,140.98 J2.A4
  BOTTOM w0.127: v2(143.13,140.72) 143.23,140.82 144.93,140.82 R1496.2 145,142.21 v1(145.06,142.28)
COME_MANLAN_LINK1000: length 5.5
  TOP w0.127: J2.A5 145.94,141.4 v1(145.7,141.64)
  BOTTOM w0.127: R1494.2 146.02,141.32 v1(145.7,141.64) 145.69,141.65 145.69,142.54 145.25,142.97 v2(144.11,142.97)
COME_MANLAN_LINK1000_D_LED: length 4.2
  BOTTOM w0.127: LEDB14.A 256.54,5.59 v2(258.28,7.34) R1474.2
COME_MANLAN_LINK1000_LED: length 5.7
  BOTTOM w0.127: LEDB14.C 253.74,5.27 254.92,6.45 v2(256.06,6.45) 257.27,7.66 R1477.1
COME_MANLAN_LINK_ALL: length 271
  S7 w0.127: v1(234,98.59) 234,98.29 235.61,96.68 235.61,94.96 233.33,92.68 218.98,92.68 218.02,91.73 218.02,77.21 223.62,71.61 223.62,45.16 216.37,37.91 216.37,17.12 217.14,16.36 220.18,16.36 221.58,14.96 221.58,13.12 222.66,12.04 228.63,12.04 229.39,11.28 237.61,11.28 238.18,11.85 248.89,11.85 250.54,10.2 v1(257.27,10.2)
  S14 w0.127: v1(234,98.59) 224.06,98.59 223.39,97.92 217.67,97.92 215.36,95.6 206.98,95.6 204.94,97.64 204.94,100.49 202.21,103.22 196.35,103.22 189.3,110.27 189.3,119.59 173.41,135.48 153.06,135.48 151.65,134.07 149.22,134.07 148.39,134.9 148.39,137.49 v1(147.29,138.59)
  BOTTOM w0.127: v1(234,98.59) 233.55,98.14 v2(232.82,98.14) ; R1496.1 R1494.1 R1495.1 147.03,138.85 v1(147.29,138.59) 147.79,138.08 RB1301.1 ; R1477.2 v1(257.27,10.2)
COME_SUS_S3_N: length 5.8
  TOP w0.127: J2.A15 150.94,140.72 150.22,141.44 150.22,142.26 149.92,142.56 v1(149.92,142.59)
  BOTTOM w0.127: R1507.2 149.57,142.91 149.89,142.59 v1(149.92,142.59) 149.92,142.56 150.9,141.58 v2(151.22,141.58)
COME_SUS_S3_N_F: length 162.2
  TOP w0.127: P1.H21 v4(101.29,230.46)
  S14 w0.127: v1(151.23,143.86) 149.8,145.3 149.8,147.36 150.21,147.76 153.36,147.76 153.85,148.25 153.85,151.78 154.78,152.7 154.78,158.12 168.23,171.56 168.23,185.31 161.85,191.69 151.66,191.69 144.41,198.94 140.78,198.94 v1(139.45,200.27)
  S16 w0.127: v1(139.45,200.27) 139.46,200.27 139.93,199.8 143.02,199.8 144.51,201.29 144.51,215.04 142.11,217.45 131.55,217.45 124.17,224.82 121.82,224.82 121.67,224.98 117.86,224.98 115.85,226.98 101.06,226.98 100.8,227.24 100.8,229.97 v4(101.29,230.46)
  BOTTOM w0.127: v1(139.45,200.27) 139.4,200.22 arc(139.11,199.78) v2(139.01,199.27) ; R1507.1 151.19,143.82 v1(151.23,143.86)
COME_SUS_S5_N: length 4.3
  TOP w0.127: v1(156.49,141.39) 156.03,141.39 155.44,140.8 J2.A24
  BOTTOM w0.127: R1508.2 156.31,141.57 v1(156.49,141.39) 155.65,141.39 v2(155.62,141.36)
COME_SUS_S5_N_F: length 151.5
  TOP w0.127: P1.J16 v4(102.29,225.46)
  S14 w0.127: v1(157.47,143.27) 157.47,143.44 155.23,145.68 153.96,145.68 153.42,146.22 153.42,146.99 154.44,148.02 154.44,151.57 155.31,152.43 155.31,157.28 169.27,171.24 169.27,172.85 168.66,173.45 168.66,185.49 162.11,192.04 151.91,192.04 144.63,199.32 141.57,199.32 v1(140.58,200.31)
  S16 w0.127: v4(102.29,225.46) 102.8,225.97 115.85,225.97 117.25,224.57 121.13,224.57 121.68,224.02 122.54,224.02 122.85,223.71 124.66,223.71 131.41,216.95 140.81,216.95 143.55,214.21 143.55,200.97 142.89,200.31 v1(140.58,200.31)
  BOTTOM w0.127: R1508.1 157.38,143.36 v1(157.47,143.27) ; v1(140.58,200.31) 141.21,199.67 arc(141.28,199.58) v2(141.3,199.47)
COME_WDT: length 122.9
  TOP w0.127: J2.B27 156.94,146.09 v1(157.25,146.4) ; P1.U7 v4(111.29,215.46)
  S14 w0.127: v1(157.25,146.4) 157.38,146.4 159.99,149.01 159.99,151.21 161.53,152.75 161.53,160.33 170.84,169.65 170.84,185.36 162.76,193.44 152.91,193.44 145.02,201.33 v1(142.84,201.33)
  S16 w0.127: v4(111.29,215.46) 111.29,215.5 111.85,216.06 117.62,216.06 118.52,215.17 118.52,214.92 121.19,212.25 122.74,212.25 123.28,211.71 123.28,208.06 124.62,206.73 137.76,206.73 142.84,201.65 v1(142.84,201.33)
  BOTTOM w0.127: v1(142.84,201.33) 143.09,201.58 v2(143.92,201.58)
COML_S_ATA_ACT_N: length 140.1
  TOP w0.127: v1(160.62,251.81) 160.62,253.59 160.04,254.18 D10.C2 158.79,254.18 158.59,253.97 R1292.1 ; v1(157.83,142.37) 158.14,142.06 158.14,141.2 157.44,140.49 J2.A28
  S12 w0.127: v1(160.62,251.81) 159.73,250.92 154.84,250.92 154.17,250.26 154.17,243.65 153.19,242.67 153.19,238.68 153.71,238.17 153.71,234.02 153.19,233.5 153.19,230.1 153.51,229.78 153.51,223.69 153.96,223.24 153.96,218.96 153.51,218.51 153.51,217.77 151.79,216.06 151.79,207.81 151.62,207.64 151.62,204.67 168.49,187.79 168.49,175.11 169.32,174.28 169.32,169.55 158.12,158.35 158.12,152 157.13,151.01 157.13,148.56 158.2,147.49 158.2,142.75 v1(157.83,142.37)
  BOTTOM w0.127: v2(160.62,253.08) v1(160.62,251.81)
CONFIG_SET0: length 8.3
  TOP w0.127: R1036.2 v1(237.62,124.68) 237.3,124.68 235.33,126.64 233.18,126.64 U52.D8
  BOTTOM w0.127: R1195.2 237.63,124.69 v1(237.62,124.68) 237.62,124.74 v2(236.99,125.37)
CONFIG_SET1: length 4.7
  TOP w0.127: v1(234.89,124.68) 234.41,125.15 U52.E9
  BOTTOM w0.127: v2(234.97,125.48) 234.79,125.48 R1043.2 ; v2(234.97,125.48) 234.97,124.75 v1(234.89,124.68) ; v2(234.97,125.48) 235.12,125.48 R1037.2
CONFIG_SET2: length 8.5
  TOP w0.127: U52.F8 233.17,123.66 235.59,123.66 v1(237.62,121.63) R1038.2
  BOTTOM w0.127: v2(238.7,120.61) 238.31,121 R1038.2 v1(237.62,121.63)
CONFIG_SET3: length 22.5
  TOP w0.127: v1(240.1,129.77) 240.06,129.73 R1056.2 R1055.2 ; U52.G7 v1(232.18,123.65)
  BOTTOM w0.127: v1(232.18,123.65) 233.66,122.17 238.99,122.17 239.22,122.4 R1044.2 R1039.2 239.32,123.76 241.23,123.76 241.77,124.31 241.77,126.83 241.38,127.23 241.38,128.3 241.77,128.69 v2(241.77,130.15) 240.48,130.15 v1(240.1,129.77)
CONFIG_SET4: length 10.6
  TOP w0.127: U52.F9 v1(234.36,124.15) ; R1040.2 R1051.2 239.99,127.72 v1(240,127.73)
  S9 w0.127: v1(234.36,124.15) 235.8,124.15 237.07,125.42 237.93,125.42 240,127.48 v1(240,127.73)
  BOTTOM w0.127: v2(240.5,128.43) 240.5,128.24 v1(240,127.73)
CONFIG_SET5: length 10.5
  TOP w0.127: R1041.2 v1(240.06,125.69) ; U52.G9 234.49,123.15 v1(234.51,123.14)
  S5 w0.127: v1(234.51,123.14) 234.53,123.14 236.62,125.22 239.58,125.22 v1(240.06,125.69)
  BOTTOM w0.127: R1041.2 v1(240.06,125.69) 240.3,125.69 v2(241.07,126.46)
CONFIG_SET6: length 17.9
  TOP w0.127: 239.87,122.65 v1(239.89,122.65) ; 239.87,122.65 239.87,123.67 240.63,124.43 240.63,126.29 240.21,126.71 R1050.2 ; 239.87,122.65 239.86,122.64 R1053.2 R1052.2 ; R1042.2 v1(237.62,120.61) 237.16,120.61 235.12,122.64 233.19,122.64 U52.G8
  S5 w0.127: v1(237.62,120.61) 239.66,122.65 v1(239.89,122.65)
  BOTTOM w0.127: v2(236.79,120.61) v1(237.62,120.61)
CONN41_1_FPGA: length 70.2
  TOP w0.127: CONN41.1 30.49,247.97 v1(30.49,247.96) ; v1(88.17,234.92) 88.99,234.1 R1443.2
  S9 w0.127: v1(30.49,247.96) 30.64,247.81 36.95,247.81 37.76,247 75.14,247 84.36,237.78 84.36,236.38 84.93,235.81 87.28,235.81 v1(88.17,234.92)
  BOTTOM w0.127: v2(86.2,235.05) 88.04,235.05 v1(88.17,234.92)
CONN41_2_FPGA: length 78.1
  TOP w0.127: v1(32.14,246.18) 32.14,248.9 31.6,249.44 31.6,253.7 30.49,254.8 CONN41.2 ; R1444.2 89.18,233.08 89.12,233.14 89.06,233.14 v1(88.04,234.16)
  S9 w0.127: v1(32.14,246.18) 33.22,247.27 36.73,247.27 37.43,246.57 74.97,246.57 82.83,238.71 82.83,236.51 84.04,235.3 86.9,235.3 v1(88.04,234.16)
  BOTTOM w0.127: v2(31.06,246.11) 32.06,246.11 v1(32.14,246.18)
CONN41_3_FPGA: length 71.2
  TOP w0.127: R1445.2 88.52,231.05 v1(88.2,231.37) ; CONN41.3 33.03,246.68 v1(33.5,246.21)
  S9 w0.127: v1(88.2,231.37) 87.85,231.37 85.91,233.3 84.64,233.3 81.82,236.13 81.82,238.41 74.77,245.46 34.18,245.46 33.43,246.21 v1(33.5,246.21)
  BOTTOM w0.127: v2(85.94,232.73) 86.86,231.81 87.76,231.81 88.2,231.37 v1(88.2,231.37)
CONN41_4_FPGA: length 75
  TOP w0.127: CONN41.4 33.03,255.1 34.7,253.43 34.7,246.76 v1(34.63,246.69) ; v1(88.1,232.13) 88.17,232.06 R1446.2
  S9 w0.127: v1(88.1,232.13) 87.72,232.13 86.13,233.72 84.8,233.72 82.32,236.19 82.32,238.54 74.87,245.99 37.33,245.99 36.64,246.69 v1(34.63,246.69)
  BOTTOM w0.127: v1(34.63,246.69) 33.96,247.35 v2(33.96,247.55)
CONN_1PPS_OUT_TO_RJ: length 232.7
  TOP w0.127: P1.R13 v4(109.29,222.46)
  S14 w0.127: v4(109.29,222.46) 109.84,223.01 116.65,223.01 116.74,223.1 118.24,223.1 118.36,223.21 120.77,223.21 122.1,221.88 123.53,221.88 123.93,222.28 125.8,222.28 128.53,219.56 132.34,219.56 133.42,218.48 141.09,218.48 146.89,212.67 146.89,206.47 156.19,197.17 164.3,197.17 176.17,185.3 176.17,158.1 177.07,157.2 177.41,157.2 187.23,147.37 189.17,147.37 190.68,145.87 190.68,144.74 193.48,141.94 193.48,136.44 194.23,135.68 212.42,135.68 216.25,131.86 216.25,131.44 216.26,131.43 216.26,124.95 215.48,124.18 215.48,110.14 216.31,109.32 216.31,108.06 v1(219.84,104.53)
  S16 w0.127: v1(219.84,104.53) 220.82,105.51 237.71,105.51 241.91,101.31 241.91,98.11 241.07,97.27 v1(241.07,94.84)
  BOTTOM w0.127: R1172.2 240.69,94.46 v1(241.07,94.84)
  BOTTOM w0.254: v2(242.15,94.59) 241.33,94.59 v1(241.07,94.84)
CONN_JTAG_TCK: length 12.4
  TOP w0.254: CONN28.1 262.67,218.93 261.55,217.81 257.48,217.81 v1(256.22,219.07) R633.1 R641.1
  BOTTOM w0.254: v1(256.22,219.07) 256.25,219.04 v2(256.25,218.03)
CONN_JTAG_TDI: length 11.8
  TOP w0.254: R621.2 v2(255.27,222.12) 256.2,222.12 v1(256.2,222.13) 256.54,222.46 262.17,222.46 263.16,221.47 CONN28.3
  BOTTOM w0.254: v2(255.27,222.12) 255.28,222.13 v1(256.2,222.13)
CONN_JTAG_TDO: length 12.1
  TOP w0.254: CONN28.9 262.63,229.09 261.46,227.92 v1(256.74,227.92) 255.97,227.15 R555.1 R548.2
  BOTTOM w0.254: v2(255.74,227.94) 256.72,227.94 v1(256.74,227.92)
CONN_JTAG_TMS: length 11.7
  TOP w0.254: R586.1 R597.2 v1(256.41,225.14) 262.22,225.14 263.36,224.01 CONN28.5
  BOTTOM w0.254: v2(257.27,225.27) 256.54,225.27 v1(256.41,225.14)
CORE _CPLL_LOCK: length 17
  TOP w0.127: v4(24.7,127.65) U40.AK33 ; R528.1 14.26,130.41 16.64,130.41 16.8,130.57 R529.2 17.51,130.91 v1(17.54,130.88)
  S12 w0.127: v1(17.54,130.88) 20.22,130.88 21.84,129.25 23.8,129.25 24.21,128.84 24.21,128.56 24.7,128.07 v4(24.7,127.65)
  BOTTOM w0.127: v1(17.54,130.88) 17.54,131.15 18.21,131.82 v2(18.21,133.6)
CPLD1_25M_OUT: length 7.4
  TOP w0.127: P1.A9 94.32,217.96 92.75,216.39 92.75,215.87 91.21,214.33 C58.2 89.2,214.33 R76.2
CPLD1_25M_OUT_R: length 2.8
  TOP w0.127: OSC1.3 87.05,215.25 R69.1 89.17,215.25 R76.1
CPLD1_TCK_R: length 4.4
  TOP w0.127: R355.2 221.96,241.26 v1(221.83,241.38) U20.18
  BOTTOM w0.127: v2(220.56,241.91) 221.31,241.91 v1(221.83,241.38)
CPLD1_TMS_R: length 5.1
  TOP w0.127: v1(209.16,236.98) R419.2 210.13,237.7 210.41,237.42 U20.9
  BOTTOM w0.127: v1(209.16,236.98) 209.16,237.69 v2(208.82,238.03)
CPLD2_3V3: length 24.6
  TOP w0.381: v4(199.55,193.58) U9.G10 ; v4(207.55,183.58) U9.T18 ; v4(205.55,199.58) U9.A16 ; U9.K12 201.05,190.07 v4(201.48,189.64) ; v4(201.55,191.58) U9.J12 ; v4(195.55,189.58) U9.K7 ; v4(189.55,183.58) U9.T1 ; v4(189.55,197.58) U9.C1 ; v4(205.55,181.58) U9.V16 ; v4(195.55,191.58) U9.J7 ; v4(191.55,199.58) U9.A3 ; v4(199.55,187.58) U9.M10 ; v4(197.55,193.58) U9.G9 ; v4(197.55,187.58) U9.M9 ; v4(207.55,197.58) U9.C18 ; v4(191.55,181.58) U9.V3
  BOTTOM w0.127: CB44.1 190.3,200.1 189.7,200.7 v2(189.64,200.7)
  BOTTOM w0.381: v4(195.55,189.58) 195.55,189.52 CB138.1 ; v4(197.55,193.58) 197.55,193.6 CB92.1 ; CB51.1 190.04,198.07 v4(189.55,197.58) ; CB72.1 207.07,197.1 v4(207.55,197.58) ; CB240.1 206.04,182.07 v4(205.55,181.58) ; v4(191.55,181.58) 191.06,182.07 CB239.1 ; CB225.1 207.06,183.09 v4(207.55,183.58) ; v4(205.55,199.58) 205.55,199.71 205.93,200.1 CB45.1 ; v4(199.55,187.58) 199.55,187.56 200.08,187.03 CB162.1 ; v4(189.55,183.58) 190.04,183.09 CB224.1 ; CB121.1 201.49,191.58 v4(201.55,191.58) ; v4(201.48,189.64) 201.09,189.26 CB155.1 ; CB108.1 195.53,191.58 v4(195.55,191.58) ; CB44.1 191.55,199.6 v4(191.55,199.58) ; v4(199.55,193.58) 199.53,193.58 CB104.1 ; v4(197.55,187.58) 197.61,187.58 198.05,187.14 CB170.1
  vias: v1(205.2,206.22) v1(205.2,205.33) v1(206.09,206.22) v1(206.09,205.33) v1(206.98,206.22) v1(206.98,205.33) v1(207.86,206.22) v1(207.86,205.33) v2(210.47,203.9)
CPLD2_25M_OUT: length 13.3
  TOP w0.127: U9.J6 194.58,190.6 189.72,190.6 185.46,194.87 C101.2 R178.2
CPLD2_25M_OUT_R: length 3.3
  TOP w0.127: OSC3.3 184.21,191.58 183.8,192 R186.1 R178.1
CPLD2_INT: length 161.1
  TOP w0.127: v1(92.17,218.79) 92.33,218.96 P1.A10 ; v4(202.55,189.58) U9.K13
  S9 w0.127: v4(202.55,189.58) 202.09,190.04 202.09,194.92 201.83,195.17 199.36,195.17 198.85,195.68 198.85,196.34 198.14,197.05 186.72,197.05 186.31,196.65 175.84,196.65 170.26,191.06 144.45,191.06 141.64,188.25 134.73,188.25 134.24,188.75 129.39,188.75 v1(129.06,189.08)
  S14 w0.127: v1(92.17,218.79) 92.76,218.2 92.76,214.3 91.44,212.98 91.06,212.98 90.55,212.47 90.55,208.47 89.31,207.23 89.31,205.18 92.04,202.45 92.54,202.45 96.14,198.85 111.99,198.85 118.47,192.38 125.76,192.38 v1(129.06,189.08)
  BOTTOM w0.127: v4(202.55,189.58) 203.08,189.05 207.7,189.05 209.09,187.66 v2(209.98,187.66) 210.62,187.66 211.36,186.92 R264.1 ; v1(92.17,218.79) 92.36,218.79 v2(93.09,218.06)
CPLD2_TCK: length 109.5
  TOP w0.127: v1(182.91,184.56) 183.49,183.97 R302.2 ; v1(223.61,240) 223.64,239.97 R389.1
  S7 w0.127: v1(223.61,240) 224.37,240 225.26,239.11 225.26,238.1 224.56,237.4 223.36,237.4 221.33,235.37 v1(211.04,235.37)
  S12 w0.127: v1(182.91,184.56) 183.49,183.97 186.21,183.97 190.12,180.06 207.55,180.06 208.28,180.79 208.28,194.54 208.36,194.62 208.36,196.62 208.05,196.92 208.05,200.92 215.8,208.66 215.8,217.97 211.17,222.6 211.17,235.24 v1(211.04,235.37)
  BOTTOM w0.127: v2(223.23,239.11) 223.61,239.49 v1(223.61,240)
CPLD2_TCK_R: length 5.6
  TOP w0.127: R389.2 221.91,239.23 v1(221.48,239.65) 221.07,240.06 U20.16
  BOTTOM w0.127: v2(219.24,240.1) 221.03,240.1 v1(221.48,239.65)
CPLD2_TDO: length 3.1
  TOP w0.127: U19.4 183.83,181.23 v1(183.73,181.33) 184.23,181.33 184.51,181.62 R318.2
  BOTTOM w0.127: v1(183.73,181.33) 183.26,181.33 v2(182.78,180.85)
CPLD2_TMS: length 107.5
  TOP w0.127: v1(183.69,183.21) 183.95,182.96 R311.2 ; v1(207.23,238.16) 207.79,238.72 R397.1
  S12 w0.127: v1(207.23,238.16) 209.34,238.16 212.18,235.32 212.18,223.24 217.07,218.35 217.07,208.63 210.07,201.64 210.07,178.9 204.69,173.52 186.53,173.52 184.91,175.14 184.91,182.06 183.75,183.21 v1(183.69,183.21)
  BOTTOM w0.127: v1(183.69,183.21) 183.01,183.21 v2(182.63,182.83)
CPLD2_TMS_R: length 4.7
  TOP w0.127: R397.2 209.24,238.8 v1(210.91,238.8) 210.97,238.74 U20.7
  BOTTOM w0.127: v2(212.4,238.7) 212.37,238.7 212.37,238.73 212.31,238.8 v1(210.91,238.8)
CPLD23_INT_CPU: length 132.3
  TOP w0.127: v1(118.05,223.57) 117.66,223.96 P1.AB15 ; v1(185.66,140.83) 185.67,140.83 185.94,140.57 J2.A85
  S14 w0.127: v1(177.3,159.29) 176.62,159.97 176.62,159.97 176.62,185.4 164.6,197.42 156.64,197.42 147.27,206.79 147.27,212.67 141.02,218.92 133.94,218.92 132.82,220.04 128.58,220.04 125.76,222.86 121.89,222.86 120.4,224.35 118.31,224.35 118.05,224.08 v1(118.05,223.57)
  S16 w0.127: v1(177.3,159.29) 178.33,159.29 179.1,158.53 179.1,157.52 181.94,154.67 181.94,146.89 185.66,143.17 v1(185.66,140.83)
  BOTTOM w0.127: v2(178.27,159.42) 177.42,159.42 v1(177.3,159.29)
CPLD_FPGA_R_S1: length 121.6
  TOP w0.127: R89.2 v1(118.3,237.61) ; v4(197.55,194.58) U9.F9
  S7 w0.127: v4(197.55,194.58) 196.58,194.58 195.61,195.55 195.61,196.95 196.05,197.39 196.05,197.84 196.31,198.09 196.75,198.09 197.01,198.35 197.01,206.66 195.04,208.63 178.22,208.63 174.15,212.7 160.24,212.7 158.78,214.16 156.68,214.16 156.37,213.84 156.37,210.54 v1(156.68,210.22)
  S14 w0.127: v1(118.3,237.61) 120.21,237.61 122.14,235.68 126.14,235.68 126.46,235.37 140.16,235.37 140.85,234.68 140.85,232.82 142.18,231.49 142.18,226.78 147.8,221.16 151.14,221.16 153.46,218.84 153.46,215.37 155.73,213.1 155.73,211.17 v1(156.68,210.22)
  BOTTOM w0.127: v1(156.68,210.22) 156.11,209.65 v2(155.48,209.65)
CPLD_FPGA_R_S2: length 116.8
  TOP w0.127: R75.2 122.27,234.6 v1(123.28,233.59) ; v4(201.55,193.58) U9.G12
  S7 w0.127: v1(194.59,210.03) 193.83,209.27 178.53,209.27 173.56,214.24 162.03,214.24 161.54,214.73 154.46,214.73 153.43,213.7 153.43,211.67 v1(151.16,209.4)
  S12 w0.127: v4(201.55,193.58) 201.1,194.03 200.24,194.03 200.05,194.22 200.05,199.84 196.6,203.3 196.05,203.3 193.77,205.59 193.77,209.2 v1(194.59,210.03)
  S14 w0.127: v1(123.28,233.59) 124.6,232.27 133.11,232.27 135.81,229.57 135.81,227.99 137.72,226.08 138.3,226.08 141.29,223.09 143.46,223.09 151.54,215.01 151.54,209.78 v1(151.16,209.4)
  BOTTOM w0.127: v1(194.59,210.03) 195.1,210.54 v2(195.55,210.54)
CPLD_FPGA_R_S3: length 115.1
  TOP w0.127: v4(202.55,194.58) U9.F13 ; R244.2 v1(122.39,233.59)
  S7 w0.127: v1(193.58,210.09) 191.54,210.09 190.53,211.11 177.77,211.11 173.3,215.58 166.15,215.58 165.03,216.7 152.78,216.7 150.97,214.89 v1(150.97,210.54)
  S14 w0.127: v1(150.97,210.54) 150.97,214.82 143.03,222.76 141.26,222.76 138.51,225.51 137.64,225.51 135.03,228.12 135.03,229.59 132.62,232 123.98,232 v1(122.39,233.59)
  BOTTOM w0.127: v1(193.58,210.09) 195.55,208.13 v2(195.61,208.13) 195.61,208.06 196.88,206.79 196.88,203.11 197.45,202.54 197.45,200.63 197.01,200.19 197.01,196.5 198.46,195.04 202.15,195.04 202.55,194.64 v4(202.55,194.58)
CPLD_FPGA_R_S4: length 185.1
  TOP w0.127: R233.2 89.86,237.27 v1(90.1,237.51) ; U9.H13 v4(202.55,192.58)
  S12 w0.127: v1(214.66,208.44) 207.1,200.89 207.1,193.52 206.59,193.01 203.36,193.01 202.92,192.58 v4(202.55,192.58)
  S14 w0.127: v1(90.1,237.51) 90.07,237.51 90.07,238.22 90.68,238.83 90.74,238.83 104.78,252.87 133.21,252.87 133.94,253.59 135.37,253.59 136.2,252.76 151.71,252.76 155.58,248.89 159.9,248.89 160.32,248.89 167.88,241.34 170.27,241.34 170.84,240.76 170.84,238.37 173.46,235.76 175.66,235.76 177,234.41 177,221.08 181.19,216.89 182.15,216.89 184.15,214.88 194.95,214.88 195.68,214.15 208.95,214.15 v1(214.66,208.44)
  BOTTOM w0.127: v2(214.76,209.39) 214.66,209.29 v1(214.66,208.44)
CPLD_FPGA_R_SCL: length 166.9
  TOP w0.127: R181.2 88.17,226.98 v1(88.1,226.92) ; v4(201.55,196.58) U9.D12
  S9 w0.127: v4(201.55,196.58) 202.09,197.11 202.09,199.87 201.75,200.2 190.61,200.2 188.08,202.73 180.17,202.73 176.43,198.99 175.14,198.99 169.3,193.15 152.6,193.15 152.44,193.31 149.47,193.31 149.05,192.89 143.43,192.89 140.69,190.14 134.07,190.14 133.53,189.61 130.07,189.61 129.8,189.89 125.94,189.89 v1(125.44,189.39)
  S14 w0.127: v1(125.44,189.39) 125.38,189.39 125.21,189.21 117.48,189.21 110.61,196.08 94.82,196.08 89.5,201.4 86.13,201.4 84.95,202.57 84.95,204.08 85.7,204.83 85.7,206.82 84.44,208.07 82.76,208.07 82.05,208.78 82.05,215.15 82.17,215.26 82.17,216.41 81.79,216.79 81.79,217.79 82.3,218.3 82.3,218.7 83.53,219.93 83.79,219.93 84.38,220.53 84.38,223.09 85.82,224.53 85.82,225.91 86.83,226.92 v1(88.1,226.92)
  BOTTOM w0.127: v1(125.44,189.39) 125.19,189.14 v2(125.19,188.63)
CPLD_FPGA_R_SDA: length 180.1
  TOP w0.127: v4(203.55,187.58) U9.M14 ; R191.2 88.48,221.9 v1(88.46,221.93)
  S9 w0.127: v1(124.87,190.03) 126.61,191.77 139.52,191.77 143.59,195.83 152.22,195.83 153.28,194.78 168.08,194.78 174.32,201.02 176.1,201.02 179.44,204.36 191.22,204.36 192.1,203.47 196.63,203.47 197.59,202.51 203.71,202.51 203.91,202.72 206.88,202.72 210.46,199.14 210.46,189.7 208.83,188.06 204.03,188.06 v4(203.55,187.58)
  S14 w0.127: v1(88.46,221.93) 89.23,221.16 89.23,209.34 88.55,208.66 87.96,208.66 86.57,207.27 86.57,204.74 86.57,204.74 86.57,204.55 85.76,203.74 85.76,202.91 86.46,202.21 89.83,202.21 95.15,196.89 110.95,196.89 117.81,190.03 v1(124.87,190.03)
  BOTTOM w0.127: v2(123.79,190.15) 124.74,190.15 v1(124.87,190.03)
CPLD_FPGA_S1: length 13.5
  TOP w0.127: R89.1 118.3,234.45 117.95,234.1 v1(116.04,234.1) 115.63,233.69 114.74,233.69 113.69,232.64 111.53,232.64 110.56,231.66 110.56,231.36 110.33,231.13 110.33,230.5 P1.T21
  BOTTOM w0.127: v1(116.04,234.1) 115.54,233.59 v2(115.09,233.59)
CPLD_FPGA_S2: length 12.7
  TOP w0.127: R75.1 120.36,234.6 119.85,234.1 119.09,234.1 v1(118.58,233.59) 118.2,233.21 115.09,233.21 112.84,230.96 P1.W22
  BOTTOM w0.127: v2(121.44,232.7) 119.47,232.7 v1(118.58,233.59)
CPLD_FPGA_S3: length 9.4
  TOP w0.127: R244.1 v1(120.11,233.59) 118.96,232.45 115.34,232.45 113.86,230.96 P1.Y22
  BOTTOM w0.127: v1(120.11,233.59) 120.8,234.28 v2(120.8,234.6)
CPLD_FPGA_S4: length 15.1
  TOP w0.127: v1(88.42,240.1) 88.42,236.7 89.19,235.93 R233.1 89.86,235.43 90.31,234.97 90.91,234.97 91.72,234.16 91.72,232.67 94.43,229.96 P1.A21
  BOTTOM w0.127: v2(88.23,241.4) 88.23,240.29 v1(88.42,240.1)
CPLD_FPGA_SCL: length 9.6
  TOP w0.127: R181.1 91.34,226.98 v1(91.98,226.35) ; P1.D17 v4(97.29,226.46)
  S7 w0.127: v1(91.98,226.35) 92.42,225.91 96.74,225.91 v4(97.29,226.46)
  BOTTOM w0.127: v2(91.58,225.45) 91.58,225.95 v1(91.98,226.35)
CPLD_FPGA_SDA: length 7.5
  TOP w0.127: P1.C12 v4(96.29,221.46) ; R191.1 v1(91.21,221.9)
  BOTTOM w0.127: v4(96.29,221.46) 95.78,220.95 92.89,220.95 v2(92.01,221.83) 91.94,221.9 v1(91.21,221.9)
CPLD_RJ_UART_RX_R: length 11.2
  TOP w0.127: P1.B20 v4(95.29,229.46) ; v1(92.42,235.18) 91.89,235.71 R205.1
  S14 w0.127: v4(95.29,229.46) 95.29,230.43 91.79,233.93 91.79,234.54 v1(92.42,235.18)
  BOTTOM w0.127: v2(90.83,236.32) 91.28,236.32 v1(92.42,235.18)
CPLD_RST: length 127
  TOP w0.127: P1.Y14 v4(114.29,223.46) ; v4(201.55,187.58) U9.M12
  S9 w0.127: v4(201.55,187.58) 201.73,187.58 202.21,188.06 202.85,188.06 203.1,188.31 203.1,195.87 202.85,196.12 201.32,196.12 201.07,196.38 201.07,198.78 200.79,199.06 188.8,199.06 187.96,199.9 184.25,199.9 183.03,201.12 179.76,201.12 176.81,198.17 175.56,198.17 170.89,193.5 170.89,193.41 170.78,193.41 v1(170.78,193.37)
  S14 w0.127: v1(170.78,193.37) 170.78,193.41 170.81,193.41 170.81,193.73 165.34,199.2 157.42,199.2 149.63,206.98 149.59,206.98 149.12,207.45 149.12,213.71 149.05,213.78 149.05,213.79 142.14,220.7 136.26,220.7 134.35,222.61 128.24,222.61 123.93,226.91 119.78,226.91 119.03,226.16 117.8,226.16 115.66,224.03 114.9,224.03 114.33,223.46 v4(114.29,223.46)
  BOTTOM w0.127: v2(170.97,194.47) 170.97,193.58 170.89,193.5 170.89,193.41 170.78,193.41 v1(170.78,193.37)
CPLD_UART1_RX_R: length 8.7
  TOP w0.127: R310.1 93.03,235.8 93.03,235.18 93.89,234.31 v1(93.92,234.31) 94.52,233.72 94.52,232.1 95.31,231.31 95.31,230.48 95.79,230 P1.B21
  BOTTOM w0.127: v2(92.73,233.46) 93.58,234.31 v1(93.92,234.31)
CPLD_VDD1P8: length 39.7
  TOP w0.127: 228.43,196.48 U71.49
  TOP w0.254: v1(234.53,197.14) 234.45,197.23 U71.37 ; v1(228.18,189.01) 228.16,188.98 U71.64 ; v1(228.62,196.48) 228.43,196.48 ; C865.1 236.54,184.7 236.14,185.1 235.13,185.1 234.45,185.79 U71.12
  TOP w0.381: v4(200.55,193.58) U9.G11 ; v4(197.55,191.58) U9.J9 ; v4(201.55,192.58) U9.H12 ; v4(199.55,189.58) U9.K10 ; v4(196.55,189.58) U9.K8 ; v4(196.55,187.58) U9.M8 ; v4(200.55,191.58) U9.J11 ; v4(195.55,188.58) U9.L7
  TOP w0.508: C865.1 238.06,184.18 v1(238.11,184.22)
  S5 w0.381: CONN6.22 33.17,234.77 ; CONN6.22 34.51,233.44 ; CONN6.22 33.17,232.1 ; CONN6.22 31.84,233.44
  BOTTOM w0.127: v1(225.9,200.38) 225.96,200.44 v2(225.96,201.58)
  BOTTOM w0.254: CB113.1 197.07,191.09 v4(197.55,191.58) 197.51,191.58 ; v4(199.55,189.58) 200.08,190.11 CB129.1 199.7,190.58 199.44,190.58 ; v4(195.55,188.58) 196.05,189.07 CB153.1 196.09,189.11 v4(196.55,189.58) 197.02,190.05 CB128.1 197.66,190.2
  BOTTOM w0.305: v4(196.55,187.58) 196.55,187.51 CB161.1
  BOTTOM w0.381: CB114.1 200.55,191.62 v4(200.55,191.58) ; CONN6.22 33.17,234.77 ; CONN6.22 33.17,232.1 ; CONN6.22 31.84,233.44 ; CONN6.22 34.51,233.44 ; v4(201.55,192.58) 202,192.13 CB109.1 ; CB101.1 200.54,193.58 v4(200.55,193.58)
  BOTTOM w0.508: v1(228.62,196.48) 228.61,196.5 C877.1 C875.1 ; C864.1 v1(234.53,197.14) ; C866.1 v1(228.18,189.01) ; CB13.1 33.05,237.84
  vias: v1(32.41,237.65) v1(32.41,236.64) v1(32.41,235.68) v1(33.3,235.68) v1(33.37,236.64) v1(34.32,235.75) v1(34.38,236.64) v1(224.95,200.31) v1(225.01,199.36) v1(225.65,193.02) v1(225.9,199.43)
CPLD_VDD1P8_PG: length 275
  TOP w0.127: CONN5.4 v1(9.3,229.27)
  TOP w0.254: R134.2 v1(221.41,214.01)
  S5 w0.254: v1(224.52,231.39) 225.92,229.99 225.92,226.77 223.17,224.02 223.17,215.77 v1(221.41,214.01)
  S9 w0.254: v1(9.3,229.27) 8.6,229.27 6.25,231.62 6.25,240.43 9.34,243.52 18.2,252.38 82.3,252.38 86.48,256.57 107.23,256.57 110.14,253.65 135.54,253.65 136.46,252.73 161.53,252.73 162.65,253.85 174.02,253.85 175.1,252.77 201.97,252.77 219.43,235.3 220.6,235.3 v1(224.52,231.39)
  BOTTOM w0.127: v2(219.1,211.94) 219.33,211.94 v1(221.41,214.01)
CPLD_VDD1P8_PG_R: length 5.1
  TOP w0.127: U7.32 225.78,215.74 v1(224.05,214.01) R134.1
  BOTTOM w0.127: v2(223.23,213.14) 223.23,213.19 v1(224.05,214.01)
CPLL_25M_R_CLK_N: length 1.4
  TOP w0.095: v4(40.7,114.65) U40.V18
  BOTTOM w0.095: U40.V18 v4(40.7,114.65)
CPLL_25M_R_CLK_P: length 1.4
  TOP w0.095: v4(39.7,114.65) U40.V19
  BOTTOM w0.095: U40.V19 v4(39.7,114.65)
CPLL_25M_REFCLK_N: length 124
  TOP w0.095: R401.1 105.04,187.8 105.04,188.32 v3(104.75,188.61)
  S16 w0.108: v3(104.75,188.61) 104.9,188.46 arc(104.99,188.33) 105.02,188.17 105.02,187.61 arc(105.08,187.3) 105.26,187.03 106.49,185.8 arc(106.77,185.39) 106.86,184.91 106.86,176.08 arc(106.68,175.17) 106.16,174.39 105.55,173.78 arc(105.34,173.47) 105.27,173.12 105.27,160.34 arc(105.12,159.58) 104.69,158.93 98.89,153.13 arc(97.52,151.09) 97.04,148.67 97.04,147.95 arc(96.55,145.44) 95.13,143.32 92.89,141.08 arc(90.2,139.29) 87.04,138.66 83.24,138.66 arc(81.39,138.29) 79.83,137.24 67.18,124.6 arc(67.06,124.42) 67.02,124.21 67.02,118.13 67.02,118.13 arc(67,118.01) 66.93,117.91 64.68,115.66 arc(64.58,115.59) 64.46,115.57 39.92,115.57 arc(39.83,115.59) 39.75,115.64 39.4,115.98 arc(39.34,116.08) 39.31,116.2 39.31,116.47 arc(39.32,116.53) 39.36,116.58 39.37,116.6 arc(39.42,116.63) 39.49,116.65 v4(39.7,116.65)
  BOTTOM w0.095: CB1060.1 v4(39.7,116.65)
CPLL_25M_REFCLK_P: length 124.7
  TOP w0.095: R402.1 105.27,187.8 105.27,188.32 v3(105.56,188.61)
  S16 w0.108: v3(105.56,188.61) 105.34,188.4 arc(105.27,188.29) 105.25,188.17 105.25,187.61 arc(105.29,187.39) 105.42,187.19 106.65,185.96 arc(106.98,185.48) 107.09,184.91 107.09,176.08 arc(106.89,175.08) 106.32,174.23 105.71,173.61 arc(105.56,173.39) 105.5,173.12 105.5,160.34 arc(105.33,159.49) 104.85,158.77 99.05,152.97 arc(97.74,151) 97.27,148.67 97.27,147.95 arc(96.76,145.35) 95.29,143.16 93.05,140.92 arc(90.29,139.07) 87.04,138.43 83.24,138.43 arc(81.48,138.08) 79.99,137.08 67.35,124.44 arc(67.27,124.33) 67.25,124.21 67.25,118.13 arc(67.21,117.92) 67.09,117.75 64.84,115.5 arc(64.67,115.38) 64.46,115.34 39.92,115.34 arc(39.74,115.37) 39.58,115.48 39.24,115.82 arc(39.12,116) 39.08,116.2 39.08,116.47 arc(39.07,116.53) 39.04,116.58 39.02,116.6 arc(38.97,116.63) 38.91,116.65 v4(38.7,116.65)
  BOTTOM w0.095: CB1059.1 v4(38.7,116.65)
CPLL_AVDD1P8: length 5.4
  TOP w0.381: v4(41.7,117.65) U40.Y17
  BOTTOM w0.127: v1(62.36,116.49) 62.36,118.45 v2(62,118.81)
  BOTTOM w0.381: v4(41.7,117.65) 41.2,118.14 CB531.1 ; v4(41.7,117.65) 41.25,117.2 CB559.2 ; v4(41.7,117.65) 41.76,117.65 CB560.1
  vias: v1(61.6,116.54)
CPU_CTS_N: length 6.8
  TOP w0.254: v1(241.52,153.64) 242.15,154.28 RB333.2
  BOTTOM w0.254: v1(241.52,153.64) 241.25,153.91 UB9.13 238.83,153.91 238.82,153.92 238.15,153.92 237.87,153.64 v2(236.14,153.64)
CPU_CTS_N_A: length 7.6
  TOP w0.254: RB333.1 243.42,154.22 CB912.1 245.66,154.22 245.84,154.4 v1(248,154.4) 248.38,154.02 LB65.1
  BOTTOM w0.254: v2(249.14,154.79) 248.63,154.28 248.12,154.28 v1(248,154.4)
CPU_CTS_N_L: length 157.6
  TOP w0.254: LB75.2 256.95,34.71 CB928.1 v1(257.72,34.73) ; LB65.2 v1(251.81,154.02)
  S9 w0.254: v1(257.72,34.73) 258.61,33.84 258.61,28.55 254.19,24.13 RJ1.F8
  S16 w0.254: v1(251.81,154.02) 250.45,152.67 250.45,149.08 248.87,147.5 245.38,147.5 238.68,140.81 238.68,138.86 237.97,138.15 237.97,136.91 238.23,136.65 238.23,116.84 237.49,116.1 237.49,113.97 243.54,107.92 243.54,98.03 245.08,96.49 245.08,94.13 246.6,92.61 246.6,65.25 254.35,57.5 254.35,53.08 253.95,52.68 253.95,49.33 254.51,48.77 254.51,46.86 256.82,44.55 257.27,44.55 257.52,44.3 257.52,36.17 257.14,35.79 257.14,35.41 257.72,34.83 v1(257.72,34.73)
  BOTTOM w0.254: v2(252.7,154.4) 252.19,154.4 v1(251.81,154.02)
CPU_FPGA_PCIE_REFCLK_N: length 146.4
  TOP w0.127: v3(104.19,206.01) 103.96,205.77 103.96,205.19 R1506.1 ; P1.N7 v4(107.29,215.46)
  S14 w0.14: v4(107.29,215.46) 106.84,215.01 106.27,215.01 105.45,214.19 105.45,208.89 103.94,207.38 103.94,206.26 v3(104.19,206.01)
  S16 w0.14: v3(104.19,206.01) 103.94,205.75 103.94,202.96 111,195.89 152.07,195.89 153.3,194.67 154.24,194.67 161.58,187.33 161.58,171.95 173.05,160.47 173.05,157.27 172.62,156.84 172.62,155.7 173.19,155.14 173.19,151.93 172.65,151.4 172.65,148.87 171.71,147.93 171.71,141.06 172.26,140.52 178.13,140.52 179.81,142.19 182.64,142.19 v3(182.89,142.44)
  BOTTOM w0.127: v3(182.89,142.44) 183.11,142.22 183.85,142.22 R1511.1
CPU_FPGA_PCIE_REFCLK_P: length 146.8
  TOP w0.127: v3(103.38,206.01) 103.65,205.74 103.65,205.19 R1505.1 ; P1.M7 v4(106.29,215.46)
  S14 w0.14: v3(103.38,206.01) 103.64,206.26 103.64,207.51 105.15,209.02 105.15,214.32 105.98,215.15 105.99,215.16 v4(106.29,215.46)
  S16 w0.14: v3(182.89,141.63) 182.62,141.89 181.41,141.89 arc(181.28,141.84) 181.23,141.71 arc(181.17,141.58) 181.04,141.52 180.71,141.52 arc(180.58,141.58) 180.53,141.71 arc(180.48,141.84) 180.35,141.89 179.93,141.89 178.26,140.21 172.13,140.21 171.41,140.93 171.41,148.06 172.35,149 172.35,151.53 172.88,152.06 172.88,155.01 172.32,155.57 172.32,156.97 172.75,157.4 172.75,160.35 161.28,171.82 161.28,187.21 154.12,194.36 153.17,194.36 151.95,195.59 110.88,195.59 103.64,202.83 103.64,205.75 v3(103.38,206.01)
  BOTTOM w0.127: R1510.1 183.78,141.91 183.17,141.91 v3(182.89,141.63)
CPU_FPGA_PCIE_TX_N: length 122.1
  TOP w0.127: P1.Y1 v4(114.29,209.46) ; v3(174.5,141.63) 174.31,141.43 174.31,140.68 174.44,140.55 J2.A62
  S16 w0.14: v3(174.5,141.63) 174.25,141.88 174.25,144.3 174.93,144.98 175.98,144.98 177.54,146.55 177.54,151.78 arc(177.61,151.94) 177.77,152 arc(177.93,152.07) 178,152.23 178,152.48 arc(177.93,152.64) 177.77,152.7 arc(177.61,152.77) 177.54,152.93 177.54,153.2 178.77,154.42 178.77,155.85 176.2,158.43 176.2,167.06 169.24,174.02 169.24,186.17 156.72,198.69 128.37,198.69 122.44,204.62 115.54,204.62 114.69,205.48 114.69,207.58 113.82,208.44 113.82,209.64 113.96,209.78 114.14,209.78 114.29,209.63 v4(114.29,209.46)
CPU_FPGA_PCIE_TX_P: length 122
  TOP w0.127: J2.A61 173.94,140.53 174,140.59 174,141.31 v3(173.69,141.63) ; P1.Y2 v4(114.29,210.46)
  S16 w0.14: v3(173.69,141.63) 173.94,141.88 173.94,144.42 174.8,145.28 175.85,145.28 177.24,146.67 177.24,153.32 178.47,154.55 178.47,155.73 175.89,158.3 175.89,166.93 168.93,173.89 168.93,186.05 156.6,198.38 128.25,198.38 122.32,204.32 115.42,204.32 114.38,205.35 114.38,207.45 113.52,208.32 113.52,209.77 113.83,210.09 113.91,210.09 v4(114.29,210.46)
CPU_MPHY_MDC: length 82.4
  TOP w0.127: RB255.2 219.67,115.47 219,115.47 v1(218.53,115.93) ; J2.C46 166.44,147.42 v1(166.44,147.42)
  S9 w0.127: v1(166.44,147.42) 170.91,147.42 174.96,143.37 183.39,143.37 183.98,142.78 183.98,141.17 188.54,136.6 212.41,136.6 216.44,132.58 216.44,118.03 v1(218.53,115.93)
  BOTTOM w0.127: v1(218.53,115.93) 217.46,115.93 v2(217.26,115.73)
CPU_MPHY_MDC_R: length 10.1
  TOP w0.127: RB255.1 221.84,114.97 v1(221.86,115) ; U52.L3 v3(227.18,118.65)
  S5 w0.127: v1(221.86,115) 223.16,116.3 224.83,116.3 v3(227.18,118.65)
  BOTTOM w0.127: v2(222.76,114.81) 222.06,114.81 v1(221.86,115) 221.82,114.96 RB256.1
CPU_MPHY_MDIO: length 85.3
  TOP w0.127: v1(183.48,158.98) 182.03,160.43 167.68,160.43 166.44,159.19 J2.D46
  TOP w0.508: RB242.2 v1(219.37,118.01)
  S14 w0.127: v1(183.48,158.98) 183.99,158.98 198.28,144.69 207.57,144.69 216.5,135.76 218.52,135.76 219.02,135.25 219.02,121.84 218.57,121.39 218.57,118.81 v1(219.37,118.01)
  BOTTOM w0.127: v2(218.21,118.15) 219.23,118.15 v1(219.37,118.01)
CPU_MPHY_MDIO_R: length 7.3
  TOP w0.127: U52.M1 221.2,118.15 RB242.1 RB254.1 v1(221.75,116.99)
  BOTTOM w0.127: v1(221.75,116.99) 222.13,116.99 v2(222.5,117.37)
CPU_MPHY_SGMII_TX_0_N: length 1.5
  TOP w0.095: U52.A4 v3(229.18,129.65)
  BOTTOM w0.095: C542.1 229.17,129.66 v3(229.18,129.65)
CPU_MPHY_SGMII_TX_0_P: length 1.5
  TOP w0.095: U52.A3 v3(228.18,129.65)
  BOTTOM w0.095: v3(228.18,129.65) 228.18,129.65 C548.1
CPU_MPHY_SGMII_TX_0_S_N: length 87.7
  TOP w0.095: J2.D27 156.94,156.33 156.8,156.19 156.8,155.14 v3(157.1,154.85)
  S9 w0.108: v3(157.1,154.85) 156.78,154.54 156.78,154.11 arc(156.94,153.74) 157.32,153.58 160.38,153.58 arc(161.25,153.41) 161.99,152.91 162.52,152.39 162.88,152.02 arc(163.23,151.79) 163.63,151.71 168.45,151.71 arc(169.57,151.49) 170.52,150.86 175.26,146.12 arc(175.5,145.95) 175.79,145.9 180.82,145.9 arc(181.24,145.98) 181.59,146.21 181.63,146.26 182.84,147.46 arc(183.28,147.76) 183.81,147.86 195.23,147.86 arc(195.65,147.78) 196.01,147.54 196.34,147.21 arc(196.77,146.92) 197.28,146.82 205.76,146.82 arc(207.22,146.53) 208.46,145.7 216.41,137.75 arc(216.78,137.51) 217.22,137.42 224.63,137.42 arc(225.07,137.33) 225.44,137.09 228.68,133.84 arc(228.82,133.63) 228.87,133.39 228.87,132.86 arc(228.97,132.62) v3(229.21,132.52)
  BOTTOM w0.095: v3(229.21,132.52) 228.79,132.1 228.79,131.72 C542.2
CPU_MPHY_SGMII_TX_0_S_P: length 87.7
  TOP w0.095: v3(156.28,154.85) 156.57,155.14 156.57,156.19 156.44,156.33 J2.D26
  S9 w0.108: v3(156.28,154.85) 156.56,154.57 156.56,154.11 arc(156.78,153.57) 157.32,153.35 160.38,153.35 arc(161.17,153.19) 161.83,152.75 162.72,151.86 arc(163.14,151.58) 163.63,151.48 168.45,151.48 arc(169.48,151.28) 170.35,150.7 175.1,145.95 arc(175.42,145.74) 175.79,145.67 180.82,145.67 arc(181.32,145.77) 181.75,146.05 183,147.3 arc(183.37,147.55) 183.81,147.63 195.23,147.63 arc(195.56,147.57) 195.85,147.38 196.18,147.05 arc(196.68,146.71) 197.28,146.59 205.76,146.59 arc(207.13,146.32) 208.3,145.54 216.25,137.59 arc(216.69,137.29) 217.22,137.19 224.63,137.19 arc(224.98,137.12) 225.27,136.92 228.52,133.68 arc(228.61,133.54) 228.64,133.39 228.64,132.93 arc(228.64,132.91) 228.64,132.88 arc(228.6,132.75) 228.52,132.64 arc(228.38,132.55) 228.22,132.52 v3(228.2,132.52)
  BOTTOM w0.095: v3(228.2,132.52) 228.57,132.15 228.57,131.72 C548.2
CPU_PEX_PCIEA_TX_0_N: length 180.6
  TOP w0.127: v4(23.7,116.65) U40.W34 ; J2.A69 177.93,139.81 177.93,140.56 177.93,140.56 177.93,141.74 177.63,142.04 177.29,142.04 v3(177.03,142.29)
  S12 w0.14: v3(177.03,142.29) 176.81,142.07 175.83,142.07 174.59,140.83 168.25,140.83 167.82,140.4 141.97,140.4 136.67,145.7 123.88,145.7 123.24,145.06 97.37,145.06 92.4,140.09 80.63,140.09 68.37,127.83 68.37,117.49 66.42,115.55 28.78,115.55 28.48,115.25 27.3,115.25 27.09,115.47 26.32,115.47 26.03,115.17 25.4,115.17 25.11,115.47 23.72,115.47 23.32,115.87 23.32,116.27 v4(23.7,116.65)
CPU_PEX_PCIEA_TX_0_P: length 180.6
  TOP w0.127: J2.A68 177.44,140.5 177.62,140.68 177.62,141.61 177.5,141.73 177.29,141.73 v3(177.03,141.48) ; v4(22.7,116.65) U40.W35
  S12 w0.14: v3(177.03,141.48) 176.75,141.77 175.96,141.77 174.72,140.52 168.37,140.52 167.95,140.1 141.85,140.1 136.54,145.4 124.01,145.4 123.37,144.76 97.5,144.76 92.53,139.79 80.76,139.79 68.67,127.7 68.67,117.37 66.55,115.24 28.91,115.24 28.6,114.94 27.18,114.94 26.96,115.16 26.44,115.16 26.15,114.87 25.27,114.87 24.98,115.16 23.6,115.16 23.01,115.75 23.01,116.33 v4(22.7,116.65)
CPU_PROCHOT: length 202
  TOP w0.127: P1.A19 v4(94.29,228.46)
  S12 w0.127: v1(161.45,149.9) 161.45,158.47 171.96,168.99 171.96,187.45 155.73,203.68 155.73,218.48 155.48,218.73 155.48,241.08 156.24,241.84 156.24,249.27 v1(155.29,250.23)
  S14 w0.127: v4(94.29,228.46) 92.84,229.91 92.48,229.91 91.76,230.63 91.76,230.97 91.14,231.58 90.66,231.58 89.44,232.8 89.44,238.35 104.46,253.38 133,253.38 133.73,254.1 135.58,254.1 136.41,253.26 152.25,253.26 v1(155.29,250.23)
  BOTTOM w0.127: R1291.2 161.45,148.7 v1(161.45,149.9) ; v1(155.29,250.23) 155.35,250.16 v2(155.35,249.21)
CPU_RS232_C1+: length 4.3
  TOP w0.127: v1(244.44,156.94) 244.51,157.02 CB914.2
  BOTTOM w0.127: v2(245.33,157.83) v1(244.44,156.94) 244.44,156.18 244.76,155.86 UB9.1
CPU_RS232_C1-: length 7.6
  TOP w0.127: v1(243.55,156.94) 243.55,157.65 CB914.1
  BOTTOM w0.127: v2(244.19,159.61) 244.19,157.58 v1(243.55,156.94) 243.55,155.93 244.92,154.56 UB9.3
CPU_RS232_C2+: length 7
  TOP w0.127: CB921.2 242.61,156.95 v1(242.62,156.94)
  BOTTOM w0.127: UB9.4 245.81,153.9 244.95,153.9 242.62,156.23 v1(242.62,156.94) 242.62,158.04 v2(242.79,158.21)
CPU_RS232_C2-: length 7.8
  TOP w0.127: v1(241.71,156.94) 241.7,156.95 CB921.1
  BOTTOM w0.127: UB9.5 244.95,153.26 241.71,156.5 v1(241.71,156.94) 241.65,156.94 v2(240.88,157.71)
CPU_RS232_CTS_N: length 10
  TOP w0.127: RB322.1 237.89,154.73 238.6,154.02 v1(238.6,153.39)
  BOTTOM w0.127: v1(238.6,153.39) 238.73,153.26 UB9.12 240.05,153.26 241.01,153.26 241.77,152.5 v2(241.77,148.05)
CPU_RS232_RTS_N: length 7.4
  TOP w0.127: RB321.1 237.51,153.72 v1(238.62,152.61)
  BOTTOM w0.127: v2(240.63,149.71) 241.39,150.47 241.39,152.25 241.03,152.61 UB9.11 v1(238.62,152.61)
CPU_RS232_RXD: length 5.3
  TOP w0.127: v1(238.73,150.98) 238.45,150.7 RB318.1 237.49,149.76 RB1304.1
  BOTTOM w0.127: UB9.9 239.06,151.31 v1(238.73,150.98) 238.47,150.72 v2(238.47,149.58)
CPU_RS232_TXD: length 5.1
  TOP w0.127: RB319.1 RB320.1 238.57,151.71 v1(238.73,151.86)
  BOTTOM w0.127: UB9.10 238.82,151.96 v1(238.73,151.86) 237.26,151.86 v2(237.26,151.87)
CPU_RS232_V+: length 4.9
  TOP w0.127: v1(246.6,156.94) 246.53,157.02 CB922.2
  BOTTOM w0.127: v2(247.36,157.83) 246.6,157.07 v1(246.6,156.94) 246.98,156.56 246.98,155.55 246.64,155.21 UB9.2
CPU_RS232_V-: length 6
  TOP w0.127: v1(244.44,152.63) 244.19,152.37 CB923.2
  BOTTOM w0.127: v2(243.42,149.58) 243.42,151.61 v1(244.44,152.63) 244.46,152.61 UB9.6
CPU_RTS_N: length 6.2
  TOP w0.254: v1(241.39,154.66) 242.03,155.29 RB334.2
  BOTTOM w0.254: v2(236.93,155.4) 237.77,154.56 UB9.14 241.29,154.56 v1(241.39,154.66)
CPU_RTS_N_A: length 7.9
  TOP w0.254: LB66.1 v1(248.25,155.55) 247.23,155.55 246.91,155.22 CB913.1 244.37,155.29 RB334.1
  BOTTOM w0.254: v1(248.25,155.55) 249.27,156.56 v2(249.27,156.94)
CPU_RTS_N_L: length 156.2
  TOP w0.254: LB66.2 v1(251.81,155.55) ; v1(261.6,34.78) 261.54,34.73 CB929.1 260.79,32.74 LB76.2
  S7 w0.254: RJ1.F1 260.9,25.66 260.9,32.81 261.5,33.41 261.5,34.69 v1(261.6,34.78)
  S16 w0.254: v1(261.6,34.78) 261.32,34.78 259.87,36.24 259.87,36.79 259.1,37.56 259.1,46.81 256.38,49.53 256.38,57.25 247.87,65.76 247.87,95.19 246.76,96.3 246.76,100.4 244.82,102.34 244.82,108.6 240.59,112.82 240.59,118.7 242.32,120.42 242.32,122.5 241.07,123.75 241.07,130.1 240.21,130.96 240.21,140.37 245.87,146.03 249.39,146.03 252.7,149.34 252.7,154.66 v1(251.81,155.55)
  BOTTOM w0.254: v1(251.81,155.55) 252.44,156.18 v2(252.44,156.31)
CPU_RXD: length 4.7
  TOP w0.254: RB336.2 v1(244.57,151.1)
  BOTTOM w0.254: UB9.8 244.77,151.31 v1(244.57,151.1) 244.57,150.47 245.2,149.83 v2(246.09,149.83)
CPU_RXD_A: length 4.3
  TOP w0.254: LB71.1 248.94,151.05 v1(248.18,151.05) CB916.1 246.47,151.05 RB336.1
  BOTTOM w0.254: v1(248.18,151.05) 249.21,151.05 v2(249.52,151.36)
CPU_RXD_L: length 152.7
  TOP w0.254: LB71.2 v1(251.81,150.85) ; LB78.2 258.74,32.94 CB931.1 259.39,34.73 v1(259.54,34.88)
  S9 w0.254: v1(259.54,34.88) 259.54,26.85 256.73,24.04 RJ1.F6
  S16 w0.254: v1(259.54,34.88) 259.48,34.94 259.48,36.63 258.72,37.4 258.72,46.65 255.87,49.5 255.87,57.22 247.49,65.6 247.49,65.82 247.36,65.95 247.36,95.03 246.35,96.04 246.35,100.23 244.4,102.18 244.4,108.48 239,113.88 239,113.88 238.35,114.52 238.35,115.44 239.06,116.15 239.06,136.59 239.75,137.27 239.75,140.59 245.73,146.57 249.26,146.57 251.81,149.12 v1(251.81,150.85)
  BOTTOM w0.254: v2(252.82,150.47) 252.19,150.47 v1(251.81,150.85)
CPU_TCK: length 56
  TOP w0.127: v1(236.69,188.31) 236.45,188.07 U71.16 ; U21.9 240.71,236.94 v1(240.69,236.95)
  S14 w0.127: v1(236.69,188.31) 237.9,189.52 237.9,190.92 236.4,192.42 236.4,211.6 237.95,213.15 237.95,227.8 238.85,228.7 238.85,233.33 240.69,235.18 v1(240.69,236.95)
  BOTTOM w0.508: v2(236.19,187.3) 236.45,187.56 236.45,188.07 v1(236.69,188.31)
CPU_TDI: length 56.6
  TOP w0.127: v1(239.59,189.12) 239.46,188.98 U71.17 ; U21.12 241.29,238.89 v1(241.27,238.86)
  S14 w0.127: v1(241.27,238.86) 241.84,238.29 241.84,235.56 239.55,233.27 239.55,228.32 238.6,227.37 238.6,212.88 237.05,211.33 237.05,199.95 238.03,198.98 238.03,191.71 239.59,190.15 v1(239.59,189.12)
  BOTTOM w0.127: v2(241.33,239.88) 241.27,239.81 v1(241.27,238.86)
CPU_TDO: length 57.8
  TOP w0.127: U21.7 235.87,237.59 v1(235.49,237.21) ; U71.18 236.22,189.48 v1(235.69,190.02)
  S14 w0.127: v1(235.49,237.21) 236.57,236.12 236.57,223.88 233.58,220.89 233.58,212.32 232.79,211.53 232.79,193.74 235.69,190.84 v1(235.69,190.02)
  BOTTOM w0.127: v2(237.84,188.88) 236.12,188.88 235.69,189.32 v1(235.69,190.02)
CPU_THERMALTRIP: length 128.6
  TOP w0.127: P1.AB6 v4(116.29,214.46) ; J2.A35 160.94,140.69 161.26,141.01 v1(161.26,141.51)
  S9 w0.127: v1(158.97,201.36) 159,201.36 159,201.4 159,201.39 145.38,201.39 144.8,200.81 136.45,200.81 v1(135.09,199.45)
  S12 w0.127: v1(158.97,201.36) 159,201.36 174.08,186.28 174.08,170.27 162.21,158.4 162.21,147.86 161.7,147.36 161.7,141.96 v1(161.26,141.51)
  S14 w0.127: v4(116.29,214.46) 116.29,213.53 116.87,212.95 117.95,212.95 118.77,212.13 118.77,209.84 119.28,209.33 120.04,209.33 120.55,208.82 120.55,206.79 127.09,200.25 134.29,200.25 v1(135.09,199.45)
  BOTTOM w0.127: v1(158.97,201.36) 158.52,200.92 158.52,199.93 v2(158.59,199.87)
CPU_TMS: length 58.6
  TOP w0.127: v1(235.49,239.56) 235.51,239.54 U21.4 ; v1(236.67,190.06) 236.74,189.98 U71.19
  S14 w0.127: v1(236.67,190.06) 236.56,190.17 236.56,191.18 233.43,194.31 233.43,208.25 235.8,210.63 235.8,212.13 236.25,212.57 236.25,222.54 237.21,223.5 237.21,237.84 v1(235.49,239.56)
  BOTTOM w0.127: v2(238.66,191.11) 237.61,190.06 v1(236.67,190.06)
CPU_TXD: length 5.1
  TOP w0.254: v1(244.6,151.96) 244.76,152.12 RB335.2
  BOTTOM w0.254: v2(248.12,153.13) 248.12,152.88 247.2,151.96 UB9.7 v1(244.6,151.96)
