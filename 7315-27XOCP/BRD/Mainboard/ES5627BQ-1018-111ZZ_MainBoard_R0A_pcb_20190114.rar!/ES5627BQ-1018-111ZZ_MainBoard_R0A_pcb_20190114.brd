# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
L1_RCVRD_CLK_BKUP_G: length 3.9
  TOP w0.127: U77.7 159.01,176.42 RB44.2
L1_RCVRD_CLK_BKUP_GR: length 2.5
  TOP w0.127: UB2.4 163.06,174.25 162.54,174.77 RB44.1
L1_RCVRD_CLK_BKUP_R: length 8.9
  TOP w0.127: R483.1 17.35,135.99 20.23,133.11 20.23,131.26 20.84,130.65 21.69,130.65 U40.AN36
L1_RCVRD_CLK_BKUP_VDD: length 2
  TOP w0.508: 167.56,174.3 167.55,174.29 CB27.2
  BOTTOM w0.127: v2(166.37,174.85) 167.16,174.85 v1(167.41,175.11)
L1_RCVRD_CLK_G: length 3.5
  TOP w0.127: R94.2 160.14,177.42 U77.9
L1_RCVRD_CLK_GR: length 3.7
  TOP w0.127: U5.4 163.86,178.16 162.59,176.88 R94.1
L1_RCVRD_CLK_R: length 9.3
  TOP w0.127: R487.1 17.23,134.97 19.47,132.73 19.47,130.17 20.01,129.63 21.71,129.63 U40.AM36
L1_RCVRD_CLK_VALID: length 215.7
  TOP w0.127: v1(14.49,133.16) 14.31,133.35 13.88,133.35 13.75,133.22 R510.1 14.13,132.57 15.52,132.57 R511.2 ; v1(164.81,182.66) 165.26,182.66 165.76,182.15 U5.1
  S7 w0.127: v1(14.49,133.16) 14.49,132.96 14.89,132.56 15.59,132.56 15.9,132.88 15.9,133.68 13.11,136.48 13.11,141.89 15.47,144.26 15.47,148.23 14.55,149.15 14.5,149.16 14.41,149.3 14.4,149.31 14.25,149.53 14.25,154.98 13.21,156.02 13.21,166.74 14.74,168.27 14.74,170.51 20.22,175.99 33.37,175.99 37.05,179.68 58.96,179.68 59.08,179.8 75.81,179.8 80.2,184.19 85.86,184.19 90.24,179.8 104.55,179.8 107.41,176.94 114.29,176.94 114.48,176.76 125.89,176.76 127.16,175.49 130.97,175.49 136.79,169.66 137.4,169.66 137.41,169.65 139.93,169.65 141.22,170.95 142.49,170.95 143.68,172.13 145.9,172.13 146.41,172.64 150.1,172.64 151.86,174.41 156.2,174.41 162.62,180.82 162.97,180.82 v1(164.81,182.66)
L1_RCVRD_CLK_VALID_BKUP: length 230.1
  TOP w0.127: UB2.1 165.76,177.71 v1(164.62,178.85) ; R502.1 13.98,134.18 v1(14.47,134.18) 15.67,134.18 R503.2
  S7 w0.127: v1(14.47,134.18) 14.28,134.18 12.09,136.37 12.09,137.26 6.07,143.29 6.07,150.01 7.84,151.78 7.84,160.29 8.49,160.94 9.93,160.94 12.28,163.29 12.28,166.53 14.23,168.48 14.23,170.89 20.03,176.69 20.03,176.92 20.82,177.71 33.94,177.71 38.76,182.53 77.05,182.53 80.76,186.25 86.61,186.25 88.61,184.25 91.6,184.25 94.2,181.65 110.65,181.65 114.77,177.52 118.2,177.52 119.31,178.63 127.55,178.63 127.73,178.45 129.85,178.45 135.97,172.32 140.53,172.32 140.67,172.45 142.51,172.45 143.71,173.66 146.79,173.66 148.05,174.91 155.6,174.91 157.57,176.88 157.57,183.23 160.75,186.41 163.48,186.41 165.51,184.38 165.51,179.74 v1(164.62,178.85)
L1_RCVRD_CLK_VALID_BKUP_R: length 9.2
  TOP w0.127: U40.AL36 21.73,128.62 20.16,128.62 18.84,129.95 18.84,132.3 17.18,133.96 R503.1
L1_RCVRD_CLK_VALID_R: length 9.3
  TOP w0.127: R511.1 17.36,132.94 18.2,132.11 18.2,129.62 20.19,127.63 21.72,127.63 U40.AK36
L1_RCVRD_CLK_VDD: length 6
  TOP w0.508: C55.2 167.39,179.65 ; 165.79,179.04 U5.5 ; C56.1 168.78,178.95 L1.2 170.19,178.92 L2.2 171.73,179.74 v1(171.35,180.12)
  BOTTOM w0.127: v1(171.35,180.12) 171.03,179.8 v2(170.59,179.8)
LED_DUPLEX: length 9.9
  TOP w0.127: U52.E8 233.16,125.63 234.64,125.63 v1(237.62,122.64) R1053.1
  BOTTOM w0.127: v2(235.68,123.04) 236.07,122.64 v1(237.62,122.64) R1053.1
LED_LINK10: length 18.1
  TOP w0.127: v3(236.86,127.6) 233.13,127.6 U52.C8
  S5 w0.127: v1(240.76,121.38) 241.65,122.27 241.65,125.85 240.27,127.23 237.23,127.23 v3(236.86,127.6)
  BOTTOM w0.127: R1054.1 239.72,121.13 240.5,121.13 v1(240.76,121.38) 241.58,122.21 v2(241.58,122.59)
LED_LINK100: length 7.8
  TOP w0.127: U52.B8 233.18,128.64 233.18,129.38 233.53,129.73 v1(236.5,129.73) R1056.1
  BOTTOM w0.127: v2(236.25,130.72) 236.25,129.99 v1(236.5,129.73)
LED_LINK1000: length 167.9
  TOP w0.127: U52.A9 237.21,129.15 v1(237.62,128.74) R1040.1
  S7 w0.127: v1(237.62,128.74) 238.9,127.46 238.9,115.77 235.93,112.8 235.93,107.21 235.02,106.3 232.53,106.3 230.84,104.6 230.84,100.91 235.13,96.63 235.13,95.31 232.82,93 218.91,93 217.77,91.86 217.77,77.09 223.37,71.49 223.37,45.36 216.12,38.11 216.12,16.86 216.98,16 220.18,16 221.33,14.85 221.33,12.9 222.45,11.78 228.44,11.78 230.09,10.13 v1(230.47,10.13)
  BOTTOM w0.127: v1(230.47,10.13) 229.64,10.13 229.58,10.07 R986.2 ; R1037.1 235.88,127.79 236.85,128.75 237.61,128.75 v1(237.62,128.74) v2(238.41,128.74)
LED_RX: length 8
  TOP w0.127: 238.31,125.7 R1050.1 v1(237.62,126.71) ; 238.31,125.7 R1041.1 ; 238.31,125.7 238.04,125.44 237.11,125.44 235.4,127.15 U52.C9
  BOTTOM w0.127: v2(238.45,126.71) v1(237.62,126.71)
LED_TX: length 171.1
  TOP w0.127: U52.D9 235.13,126.15 v1(237.62,123.66) R1052.1 238.31,124.02 238.45,124.16 239.08,124.16 239.22,124.29 R1036.1
  S7 w0.127: v1(237.62,123.66) 238.21,123.07 238.21,115.81 235.37,112.98 235.37,107.36 234.92,106.91 232,106.91 230.26,105.17 230.26,100.96 234.78,96.44 234.78,95.47 232.63,93.32 218.85,93.32 217.52,91.98 217.52,76.43 223.12,70.83 223.12,45.47 215.87,38.22 215.87,16.67 216.84,15.69 220.12,15.69 221.01,14.81 221.01,12.86 222.34,11.53 228.31,11.53 230.41,9.43 232.76,9.43 234.15,10.83 234.53,10.83 v1(235.23,10.13)
  BOTTOM w0.127: v2(241.01,124.43) 240.71,124.13 238.49,124.13 238.31,123.95 R1052.1 v1(237.62,123.66) ; R985.2 v1(235.23,10.13)
LGND_VCC5P0: length 14.1
  TOP w0.508: v1(242.84,159.51) 242.9,159.56 C356.2 ; v1(243.34,168.48) R688.1 R642.2
  S12 w0.508: v1(243.34,168.48) 241.65,166.78 241.65,165.45 243.17,163.93 243.17,159.84 v1(242.84,159.51)
  BOTTOM w0.254: v1(243.34,168.48) 243.62,168.76 v2(244.19,168.76)
LM75_A0_CH2: length 11.1
  TOP w0.127: v1(86.1,146.83) 86.1,147.01 85.72,147.39 84.78,147.39 84.55,147.62 84.55,147.73 R457.1 R460.2 83.97,146.53 U27.7
  BOTTOM w0.127: v2(83.71,142.01) 85.36,143.66 85.36,145.98 86.1,146.72 v1(86.1,146.83)
LM75_A0_CH3: length 6.1
  TOP w0.127: v1(135.93,208.56) U29.7 138.3,208.56 138.87,209.13 R495.2 R506.1
  BOTTOM w0.127: v1(135.93,208.56) 135.92,208.57 v2(134.84,208.57)
LM75_A0_CH4: length 6
  TOP w0.127: R431.1 v1(6.7,154.47) R405.2 6.39,155.16 6.21,155.33 6.21,157.06 6.59,157.43 U18.7
  BOTTOM w0.127: v1(6.7,154.47) 6.76,154.53 v2(6.76,155.48)
LM75_A1_CH2: length 5.4
  TOP w0.127: v1(81.19,145.11) 81.35,145.26 U27.6 83.43,145.26 84.06,145.9 R464.2 R470.1
  BOTTOM w0.127: v2(80.51,145.72) 81.12,145.11 v1(81.19,145.11)
LM75_A1_CH3: length 5.9
  TOP w0.127: v1(135.86,207.29) U29.6 138.6,207.29 138.79,207.1 R514.2 R524.1
  BOTTOM w0.127: v1(135.86,207.29) 136.86,207.29 v2(136.87,207.3)
LM75_A1_CH4: length 5.8
  TOP w0.127: R430.1 v1(5.43,154.47) R404.2 5.14,155.16 4.94,155.36 4.94,156.96 5.32,157.33 U18.6
  BOTTOM w0.127: v2(5.05,153.77) 5.05,154.09 v1(5.43,154.47)
LM75_A2_CH2: length 5.7
  TOP w0.127: v1(81.14,144.4) 81.52,144.4 81.93,143.99 U27.5 83.73,143.99 83.86,143.86 R472.2 R480.1
  BOTTOM w0.127: v1(81.14,144.4) 81.18,144.43 v2(82.41,144.43)
LM75_A2_CH3: length 6.2
  TOP w0.127: v1(135.86,206.02) U29.5 138.09,206.02 139.03,205.08 R549.1 139.67,204.09 R541.2
  BOTTOM w0.127: v1(135.86,206.02) 135.86,205.09 v2(135.79,205.01)
LM75_A2_CH4: length 6.5
  TOP w0.127: U18.5 4.05,157.51 3.6,157.06 3.6,155.36 3.8,155.16 R403.2 v1(4.16,154.47) R429.1
  BOTTOM w0.127: v2(4.03,155.8) 4.03,154.59 v1(4.16,154.47)
LM75BD1_INT: length 198.7
  TOP w0.127: R478.2 R471.1 75.57,142.59 75.38,142.78 v1(75.38,144.96) ; P1.R14 v4(109.29,223.46)
  S12 w0.127: v1(75.38,144.96) 75.38,145.36 76.67,146.66 78.2,146.66 83.79,152.25 88.99,152.25 89.37,151.86 96.3,151.86 98.21,149.96 129.66,149.96 140.84,161.14 140.84,173.54 140.84,181.22 140.32,181.74 137.49,184.57 137.49,186.22 133.53,190.19 133.53,193.81 124.11,203.22 124.11,203.49 122.46,205.14 118.84,205.14 118.11,205.87 118.11,210.63 116.87,211.87 116.87,213.33 116.17,214.03 115.09,214.03 114.84,214.28 114.84,220 114.14,220.7 110.07,220.7 109.82,220.95 109.82,222.86 109.29,223.39 v4(109.29,223.46)
  S14 w0.127: v4(109.29,223.46) 109.73,223.9 112.39,223.9 112.74,224.25 112.74,225.52 113.17,225.96 116.07,225.96 118.05,227.94 119.09,227.94 122.46,231.3 131.73,231.3 133.7,229.33 133.7,228.07 CONN19.1
  BOTTOM w0.127: v2(75.38,145.77) v1(75.38,144.96)
LM75BD1_INT_R: length 6.5
  TOP w0.127: U27.3 76.42,145.26 v1(76.11,144.96) 76.11,143.66 76.55,143.23 77.05,143.23 77.38,142.9 R471.2
  BOTTOM w0.127: v2(77.28,146.41) 76.11,145.24 v1(76.11,144.96)
LM75BD1_SCLK: length 157.4
  TOP w0.127: P1.T15 v4(110.29,224.46) ; R452.1 76.03,149.2 R458.2 75.52,148.69 74.98,148.69 v1(74.61,148.32)
  S12 w0.127: v4(110.29,224.46) 109.68,223.85 109.12,223.85 108.8,223.53 108.8,220.76 109.38,220.19 113.63,220.19 113.88,219.94 113.88,212.7 115.79,210.79 115.79,208.19 116.87,207.11 116.87,205.14 117.82,204.19 122.16,204.19 123.22,203.13 123.22,202.86 132.64,193.44 132.64,189.82 136.6,185.85 136.6,184.2 139.95,180.85 139.95,162.08 128.91,151.04 98.53,151.04 96.04,153.52 83.41,153.52 78.2,148.32 v1(74.61,148.32)
LM75BD1_SCLK_C: length 1
  TOP w0.127: R462.2 C249.1
LM75BD1_SCLK_R: length 8.3
  TOP w0.127: R458.1 75.59,146.91 75.97,146.53 U27.2 78.45,146.53 79.34,145.64 R462.1
LM75BD1_SDA: length 193.6
  TOP w0.127: P1.U15 v4(111.29,224.46) ; v1(74.7,149.26) 76.17,150.72 77.44,150.72 77.94,150.21 79.78,150.21 80.41,149.59 R451.2 R450.1
  S12 w0.127: v1(74.7,149.26) 73.82,148.37 73.82,145.2 75.34,143.67 76.86,143.67 84.04,150.85 93.95,150.85 96.61,148.18 106.65,148.18 107.47,149.01 124.36,149.01 125.78,147.58 137.16,147.58 140.59,151.02 140.59,155.71 144.16,159.28 144.16,163.35 145.08,164.26 145.08,168.52 146.23,169.67 146.23,172.22 146.57,172.57 146.57,179.12 146.1,179.59 146.1,187.4 145.17,188.33 145.17,190.95 141.3,194.82 141.3,200.69 140.11,201.88 140.11,209.37 140.71,209.98 140.71,215.08 134.27,221.52 126.69,221.52 124.69,223.52 123.07,223.52 122.63,223.95 120.66,223.95 120.21,224.4 117.56,224.4 117.02,224.94 111.77,224.94 v4(111.29,224.46)
  BOTTOM w0.254: v1(74.7,149.26) 75.2,148.76 75.87,148.76 77.15,150.04 v2(77.15,150.1)
LM75BD1_SDA_R: length 9
  TOP w0.127: v1(81.37,146.33) 81.55,146.5 81.55,148.97 R451.1 81.12,149 81.12,148.72 80.2,147.8 U27.1
  BOTTOM w0.127: v1(81.37,146.33) v2(82.57,146.33)
LM75BD2_INT: length 32.9
  TOP w0.127: P1.W12 v4(113.29,221.46) ; R540.2 127.14,207.39 127.75,207.39 v1(127.79,207.43) 127.83,207.39 R523.1
  TOP w0.254: R523.1 128.55,206.73 132.68,202.6 CONN18.1
  S16 w0.127: v1(127.79,207.43) 126,209.22 124.55,209.22 123.73,210.04 123.73,212.19 122.96,212.95 121.82,212.95 120.36,214.41 120.36,217.21 119.73,217.84 119.36,217.84 118.34,218.86 117.57,218.86 116.38,220.05 114.7,220.05 v4(113.29,221.46)
  BOTTOM w0.127: v1(127.79,207.43) 127.79,206.56 v2(127.77,206.54)
LM75BD2_INT_R: length 4.9
  TOP w0.127: v1(133.51,207.29) U29.3 131.84,207.39 R523.2
  BOTTOM w0.127: v2(132.68,207.31) 132.7,207.29 v1(133.51,207.29)
LM75BD2_SCLK: length 29.5
  TOP w0.127: P1.T14 v4(110.29,223.46) ; R494.2 v1(127.79,209.59) R493.1
  S16 w0.127: v4(110.29,223.46) 110.73,223.01 110.73,222.21 110.96,221.99 118.56,221.99 120.99,219.55 122.97,219.55 123.53,218.99 123.53,214.64 124.39,213.78 125.48,213.78 126.2,213.05 126.2,211.17 v1(127.79,209.59)
LM75BD2_SCLK_C: length 1.4
  TOP w0.127: C286.1 R505.2
LM75BD2_SCLK_R: length 3.6
  TOP w0.127: R494.1 R505.1 129.51,208.56 U29.2
LM75BD2_SDA: length 29.7
  TOP w0.127: R484.1 v1(127.79,210.67) R485.2 ; P1.U14 v4(111.29,223.46)
  S16 w0.127: v4(111.29,223.46) 111.31,223.46 111.82,222.95 120.07,222.95 121.24,221.77 122.49,221.77 123.71,220.55 123.71,220.2 124.49,219.42 125.52,219.42 125.89,219.05 125.89,215.5 127.35,214.04 127.35,211.35 127.79,210.91 v1(127.79,210.67)
  BOTTOM w0.127: v2(129.38,210.28) 129,210.67 v1(127.79,210.67)
LM75BD2_SDA_R: length 5.2
  TOP w0.127: R485.1 130.08,210.67 130.91,209.83 U29.1 v1(133.32,209.83)
  BOTTOM w0.127: v2(132.3,209.84) 133.32,209.84 v1(133.32,209.83)
LM75BD3_INT: length 141.4
  TOP w0.127: CONN9.1 3.33,174.75 3.33,169.17 v1(3.4,169.1) 3.33,169.02 3.33,167.99 3.52,167.8 R257.2 3.83,167.44 R282.1 ; P1.G17 100.34,226.41 100.34,227.41 v4(100.35,227.42)
  S7 w0.127: v4(100.35,227.42) 100.35,227.68 99.84,228.19 99.84,228.52 99.34,229.02 93.52,229.02 91.94,230.59 91.17,230.59 91.09,230.52 90.7,230.52 90.63,230.59 86.81,230.59 85.86,231.54 84.44,231.54 84.06,231.16 81.16,231.16 68.41,218.41 62.96,218.41 50.54,205.99 39.6,205.99 37.7,204.09 32.06,204.09 13.06,185.09 13.06,180.1 3.4,170.44 v1(3.4,169.1)
  BOTTOM w0.127: v2(4.16,170.28) 4.16,169.85 v1(3.4,169.1)
LM75BD3_INT_R: length 3.6
  TOP w0.127: U18.3 5.32,164.59 v1(5.1,164.82) 4.54,165.38 R282.2
  BOTTOM w0.127: v1(5.1,164.82) 5.1,165.04 v2(5.65,165.6)
LM75BD3_SCLK: length 145.7
  TOP w0.127: RB106.1 5.81,169.36 v1(5.88,169.29) 5.65,169.29 5.22,168.86 5.22,167.22 5.55,166.89 R283.2 ; P1.Y18 v4(114.29,227.46)
  S7 w0.127: v4(114.29,227.46) 114.17,227.46 113.6,228.03 101.04,228.03 100.86,227.85 100.86,227.21 100.53,226.88 100.09,226.88 99.79,227.19 99.79,227.71 99.46,228.03 94.93,228.03 94.77,227.87 93.06,227.87 93.03,227.9 92.23,227.9 91.19,228.94 90.19,228.94 89.44,229.7 86.44,229.7 85.51,230.63 84.79,230.63 84.43,230.27 81.53,230.27 66.37,215.11 64.78,215.11 64.64,214.97 60.77,214.97 48.54,202.73 32.64,202.73 14.04,184.14 14.04,179.8 5.88,171.64 v1(5.88,169.29)
LM75BD3_SCLK_C: length 3.3
  TOP w0.127: R284.2 6.44,167.09 6.64,167.29 C140.1 6.64,168.36 v1(6.44,168.56)
  BOTTOM w0.127: v1(6.44,168.56) 6.44,168.18 v2(7.08,167.55)
LM75BD3_SCLK_R: length 4.8
  TOP w0.127: R283.1 R284.1 6.44,165.03 v1(6.75,164.73) 6.59,164.57 U18.2
  BOTTOM w0.127: v1(6.75,164.73) 6.75,164.49 v2(5.92,163.66)
LM75BD3_SDA: length 148
  TOP w0.127: R285.2 7.27,166.92 7.27,168.6 v1(6.62,169.25) 6.89,169.52 RB114.1 ; P1.Y17 v4(114.29,226.46)
  S7 w0.127: v4(114.29,226.46) 114.29,226.51 113.82,226.97 101.67,226.97 101.04,226.34 100.07,226.34 99.44,226.97 93.24,226.97 92.82,227.39 90.79,227.39 89.1,229.09 83.61,229.09 83.08,229.62 82.17,229.62 78.56,226.01 78.56,223.66 74.58,219.68 72.71,219.68 66.74,213.71 60.98,213.71 49.48,202.2 33.76,202.2 14.6,183.05 14.6,179.56 6.62,171.58 v1(6.62,169.25)
  BOTTOM w0.127: v4(114.29,226.46) 114.92,225.83 116.54,225.83 v2(116.55,225.84) ; v2(6.7,170.6) 6.62,170.52 v1(6.62,169.25)
LM75BD3_SDA_R: length 3.5
  TOP w0.127: U18.1 7.86,164.33 v1(7.46,164.73) R285.1
  BOTTOM w0.127: v1(7.46,164.73) 7.46,164.18 v2(7.81,163.83)
LOC_B: length 330.8
  TOP w0.127: P1.W14 v4(113.29,223.46)
  S7 w0.127: v4(113.29,223.46) 112.81,222.98 104.38,222.98 103.41,222.02 94.94,222.02 94.06,222.9 91.54,222.9 91.16,222.51 90.43,222.51 87.5,219.58 83.42,219.58 82.43,218.59 82.43,217.6 v1(82.48,217.55)
  S16 w0.127: v1(35.85,14.19) 29.37,20.67 20.26,20.67 18.96,21.97 18.96,39.32 11.52,46.77 11.52,52.27 10.65,53.13 6.09,53.13 4,55.22 4,57.47 10.43,63.9 10.43,64.89 13.78,68.25 13.78,71.08 12.94,71.92 12.94,75.7 9.36,79.28 8.56,79.28 5.5,82.34 5.5,91.77 7.03,93.29 7.03,98.45 6.48,99 6.48,104.89 7.79,106.2 7.79,112.39 9.44,114.04 9.44,117.15 10.25,117.95 10.25,137.46 15.28,142.49 15.28,149.55 14.34,150.49 14.34,154.43 10.7,158.07 10.7,166.91 12.05,168.27 12.05,171.57 15.78,175.3 15.8,175.3 15.97,175.46 15.97,179.58 16.86,180.46 16.86,187.01 30.86,201.02 65.54,201.02 77.85,213.33 79.68,213.33 82.55,216.2 82.55,217.48 v1(82.48,217.55)
  BOTTOM w0.127: RB735.2 v1(35.85,14.19) 35.85,14.83 v2(35.53,15.15) ; v2(82.71,216.32) 82.71,217.32 v1(82.48,217.55)
LOC_B_R: length 6.5
  BOTTOM w0.127: LEDB11.C 35.7,7.16 v2(35.65,7.21) 35.7,7.26 35.7,9.05 35.85,9.19 RB735.1 CB981.2
M_MCT1: length 4.1
  TOP w0.508: U70.24 v1(264.74,67.64)
  BOTTOM w0.381: v2(264.76,68.74) 264.74,68.72 v1(264.74,67.64)
  BOTTOM w0.508: R1297.2 264.79,67.59 v1(264.74,67.64)
M_MCT2: length 4.1
  TOP w0.508: U70.21 v1(260.93,67.64)
  BOTTOM w0.508: R1298.2 260.95,67.61 v1(260.93,67.64) 261.01,67.73 261.01,68.55 v2(261.08,68.62)
M_MCT3: length 4.3
  TOP w0.508: U70.18 v1(257.12,67.54)
  BOTTOM w0.381: v2(256.76,68.68) 257.12,68.32 v1(257.12,67.54)
  BOTTOM w0.508: v1(257.12,67.54) 257.14,67.51 R1299.2
M_MCT4: length 4.6
  TOP w0.508: U70.15 253.31,67.64 v1(253.33,67.61)
  BOTTOM w0.508: v2(254.09,69.12) 254.09,68.11 253.6,67.61 v1(253.33,67.61) R1300.2
MAC_1PPS_IN_1: length 9.4
  TOP w0.127: R366.2 v1(95.95,235.23) ; P1.G20 v4(100.29,229.46)
  BOTTOM w0.127: v1(95.95,235.23) 96.74,234.44 v2(96.74,233.14) 97.88,232 98.67,232 100.29,230.38 v4(100.29,229.46)
MAC_1PPS_IN_2: length 8.2
  TOP w0.127: R78.2 v1(91.09,212.19) 91.09,212.63 94.14,215.68 94.14,216.31 P1.A8
  BOTTOM w0.127: v2(90.14,212.19) v1(91.09,212.19)
MAC_1PPS_IN_3: length 6.1
  TOP w0.127: v1(91.21,228) R211.2 ; P1.B18 v4(95.29,227.46)
  BOTTOM w0.127: v4(95.29,227.46) 92.52,227.46 v2(92.33,227.65) 91.98,228 v1(91.21,228)
MAC_1PPS_IN_4: length 14.7
  TOP w0.127: v1(104.11,235.18) 104.13,235.2 R61.2 ; P1.L15 v4(105.29,224.46)
  S9 w0.127: v1(104.11,235.18) 104.71,234.57 104.71,233.48 103.75,232.52 103.75,226.9 104.84,225.8 104.84,224.86 105.25,224.46 v4(105.29,224.46)
  BOTTOM w0.127: v1(104.11,235.18) 103.84,235.44 v2(103.84,236.29)
MAC_25M_OUT: length 44
  TOP w0.127: R438.2 13.98,153.39 C227.2 14.01,152.93 13.5,152.42 v1(11.73,152.42) ; v4(21.7,124.65) U40.AG36
  S14 w0.127: v1(11.73,152.42) 15.17,148.97 arc(15.45,148.57) 15.54,148.08 15.54,142.37 arc(15.74,141.37) 16.3,140.53 arc(16.69,139.95) 16.83,139.26 16.83,135.99 arc(17.08,134.72) 17.8,133.65 21.3,130.15 23.82,130.15 24.2,129.77 24.2,129.28 24.32,129.16 24.86,129.16 25.24,128.78 25.24,128.45 25.54,128.14 25.9,128.14 26.15,127.89 26.15,125.4 25.92,125.17 22.39,125.17 21.87,124.65 v4(21.7,124.65)
MAC_25M_OUT_R: length 3.7
  TOP w0.127: OSC5.3 11.62,154.28 11.98,154.28 12.18,154.48 12.18,154.91 12.67,155.39 R434.1 13.1,154.4 R438.1
MAC_CPLD_INT_L: length 191.6
  TOP w0.127: v1(8.27,131.11) 8.07,130.91 R526.1 ; P1.N22 106.89,230.96 v4(107.3,231.36) ; U40.AH36 v4(21.7,125.65)
  S7 w0.127: v1(83.72,226.98) 82.43,225.69 82.43,223.51 75.73,216.81 73.86,216.81 72.35,215.3 72.35,214.17 69.71,211.53 68.14,211.53 v1(59.78,203.17) 56.23,199.62 34.2,199.62 18.57,183.99 18.57,178.72 11.01,171.17 11.01,169.01 9.32,167.32 9.32,163.65 5.96,160.29 5.96,153.71 4.86,152.61 4.86,137.47 7.79,134.54 7.79,131.69 8.26,131.22 8.26,131.13 v1(8.27,131.11) 11.05,128.34 11.85,128.34 13.88,126.31 15.46,126.31 16.74,127.59 17.75,127.59 20.17,125.17 21,125.17 21.47,125.65 v4(21.7,125.65)
  S12 w0.127: v4(107.3,231.36) 106.24,232.42 90.73,232.42 88.83,230.52 87.25,230.52 v1(83.72,226.98)
  BOTTOM w0.127: v2(59.78,204.19) v1(59.78,203.17)
MAC_CPU_I2C_SCL: length 27
  TOP w0.127: U40.AC32 v4(25.7,120.65) ; R656.2 R650.2 7.78,119.36 8.4,119.36 v1(8.41,119.35) 8.46,119.35 8.78,119.03 9.48,119.03 R651.2
  S7 w0.127: v1(8.41,119.35) 8.54,119.23 11.43,119.23 11.45,119.2 12.13,119.2 12.64,119.71 16,119.71 16.11,119.82 23.07,119.82 23.41,120.16 25.21,120.16 v4(25.7,120.65)
  BOTTOM w0.127: v2(4.73,117.32) 5.55,118.15 6.52,118.15 7.69,119.32 8.41,119.32 v1(8.41,119.35)
MAC_CPU_I2C_SDA: length 32.6
  TOP w0.127: R668.2 R654.2 5.73,118.21 8.09,118.21 8.32,118.44 v1(8.78,118.44) 9.52,117.7 R657.2 ; U40.AB31 v4(26.7,119.65)
  S7 w0.127: v1(8.78,118.44) 9.13,118.79 12.48,118.79 12.89,119.2 17.35,119.2 17.37,119.22 19.12,119.22 19.13,119.2 22.84,119.2 22.86,119.21 26.26,119.21 v4(26.7,119.65)
  BOTTOM w0.127: v2(3.92,115.36) 3.98,115.42 6.2,115.42 6.76,115.97 6.76,117.46 7.74,118.44 v1(8.78,118.44)
MAC_HS1: length 8.4
  TOP w0.508: 71.42,147.68 71.83,147.68 73.89,149.73 C224.2
  BOTTOM w0.127: 65.29,144.43 65.12,144.43
  BOTTOM w0.254: v2(61.31,143.78) 61.34,143.75 64.61,143.75 v1(65.34,144.48)
  vias: v1(64.44,146.66) v1(65.35,148.95) v1(67.58,149.92) v1(67.6,143.41) v1(69.83,144.37) v1(69.95,149)
MAC_HS2: length 13.6
  TOP w0.127: v1(69.83,83.37) 68.87,82.41 v1(67.6,82.41) ; v1(67.58,88.92) 66.32,88.92 v1(65.35,87.95)
  TOP w0.508: 63.31,84.92 63.29,84.94 L10.1
  BOTTOM w0.127: 70.63,86.97 71.33,87.67 v2(75.94,87.67)
  vias: v1(64.44,85.66) v1(65.34,83.48) v1(69.95,88)
MAC_HS3: length 5.9
  BOTTOM w0.508: C483.2 3.67,150.23 v2(3.71,150.28) 7,150.28 7.72,149.56
  vias: v1(7.54,146.66) v1(8.44,144.48) v1(8.45,148.95) v1(10.68,149.92) v1(10.7,143.41) v1(12.93,144.37) v1(13.05,149)
MAC_HS4: length 8.6
  TOP w0.508: v1(10.68,88.92) 9.47,90.14 L54.1
  BOTTOM w0.254: HS1.4 14.61,86.4 v2(17.68,86.4)
  vias: v1(7.54,85.66) v1(8.44,83.48) v1(8.45,87.95) v1(10.7,82.41) v1(12.93,83.37) v1(13.05,88)
MAC_INT_L: length 144.6
  TOP w0.127: v1(170.32,143.89) 170.97,143.23 174.84,143.23 175.39,142.68 175.39,141.06 174.94,140.61 J2.A63 ; v4(93.75,211.49) 93.75,211.68 94.52,212.44 95.27,212.44 P1.B4
  S14 w0.127: v4(93.75,211.49) 93.75,210.02 93.96,209.82 93.96,206.36 93.69,206.09 92.99,206.09 92.74,205.84 92.74,205.29 94.67,203.36 94.67,202.73 97.5,199.9 112.5,199.9 119,193.39 126.37,193.39 127.06,192.71 133.28,192.71 v1(134.09,193.52)
  S16 w0.127: v1(170.32,143.89) 169.79,144.41 169.79,147.97 171.4,149.57 171.4,159.11 159.7,170.81 159.7,175.32 158.84,176.18 158.84,187.3 155.22,190.92 153.48,190.92 149.9,194.5 135.07,194.5 v1(134.09,193.52)
  BOTTOM w0.127: v2(135.01,193.01) 134.61,193.01 v1(134.09,193.52)
MAC_JTAG_TCE: length 29.3
  TOP w0.127: v1(11.41,130.87) 11.37,130.91 R527.2 ; v4(24.7,126.65) U40.AJ33
  S14 w0.127: v4(24.7,126.65) 24.46,126.65 23.92,127.19 22.48,127.19 22.06,127.61 19.56,127.61 17.82,129.35 14.77,129.35 12.74,131.39 11.92,131.39 v1(11.41,130.87)
  BOTTOM w0.127: v2(5.05,136.47) 6.02,136.47 6.98,135.51 6.98,130.69 7.9,129.77 10.21,129.77 11.31,130.87 v1(11.41,130.87)
MAC_JTAG_TCK: length 32.5
  TOP w0.127: U40.AH32 v4(25.7,125.65) ; R517.2 11.37,131.93 v1(11.41,131.89)
  S14 w0.127: v4(25.7,125.65) 25.7,126.05 25.28,126.47 25.28,126.73 24.94,127.07 24.59,127.07 24.17,127.49 24.17,127.74 23.79,128.12 22.16,128.12 21.77,128.5 19.81,128.5 17.95,130.37 14.77,130.37 12.74,132.4 11.95,132.4 v1(11.41,131.89)
  BOTTOM w0.127: v1(11.41,131.89) 9.81,133.49 9.81,139.16 7.78,141.19 v2(5.29,141.19)
MAC_JTAG_TDO: length 23.9
  TOP w0.127: v4(24.7,124.65) U40.AG33 ; R583.2 11.24,125.83 v1(11.41,125.99)
  S12 w0.127: v1(11.41,125.99) 14.42,125.99 14.7,126.27 15.56,126.27 16.54,125.3 17.7,125.3 17.77,125.37 18.72,125.37 20.45,123.64 21.5,123.64 22.14,124.27 22.14,124.73 22.54,125.14 24.21,125.14 v4(24.7,124.65)
  BOTTOM w0.127: v1(11.41,125.99) 11.4,125.98 6.96,125.98 6.55,126.39 5.44,126.39 v2(4.98,126.85)
MAC_NIF_156.25M_N: length 25.3
  TOP w0.095: v4(34.7,108.65) U40.M23 ; v3(16.27,103.25) 15.93,102.91 15.46,102.91 C432.2
  S12 w0.108: v4(34.7,108.65) 34.82,108.65 arc(34.92,108.67) 35,108.72 35.04,108.76 arc(35.11,108.91) 35.04,109.07 arc(34.71,109.2) 34.38,109.07 34.34,109.03 arc(34.22,108.84) 34.18,108.63 arc(34.15,108.47) 34.06,108.34 arc(33.91,108.25) 33.74,108.2 31.82,108.2 arc(31.62,108.16) 31.46,108.05 31.32,107.9 arc(31.28,107.85) 31.27,107.8 31.27,107.73 arc(31.25,107.61) 31.18,107.51 31.11,107.45 30.98,107.32 arc(30.93,107.27) 30.88,107.23 arc(30.72,107.16) 30.55,107.14 20.84,107.14 arc(20.6,107.09) 20.39,106.96 20.27,106.83 arc(20.2,106.79) 20.12,106.77 19.98,106.77 arc(19.79,106.73) 19.63,106.62 17.69,104.69 arc(17.48,104.36) 17.4,103.99 17.4,103.43 arc(17.38,103.31) 17.31,103.21 17.16,103.05 arc(17.06,102.99) 16.94,102.96 16.56,102.96 v3(16.27,103.25)
MAC_NIF_156.25M_P: length 25.4
  TOP w0.095: v3(16.27,102.44) 16.03,102.68 15.37,102.68 C436.2 ; v4(35.7,108.65) U40.M22
  S12 w0.108: v4(35.7,108.65) 35.37,108.31 arc(35.08,108.12) 34.74,108.05 34.66,108.05 arc(34.51,108.02) 34.38,107.94 34.22,107.79 arc(34.22,107.78) 34.22,107.78 arc(34.18,107.71) 34.17,107.64 34.17,107.43 arc(34.09,107.24) 33.9,107.17 31.53,107.17 arc(31.49,107.16) 31.45,107.15 arc(31.44,107.15) 31.44,107.15 arc(31.43,107.15) 31.43,107.15 arc(31.27,107.03) 31.21,106.84 31.21,106.64 arc(31.17,106.48) 31.08,106.33 arc(30.9,106.22) 30.69,106.17 20.79,106.17 arc(20.57,106.22) 20.38,106.34 20.28,106.44 20.26,106.47 arc(20.18,106.52) 20.08,106.54 19.98,106.54 arc(19.88,106.52) 19.79,106.46 17.85,104.53 arc(17.69,104.28) 17.63,103.99 17.63,103.43 arc(17.59,103.22) 17.47,103.04 17.32,102.89 arc(17.14,102.77) 16.94,102.73 16.57,102.73 v3(16.27,102.44)
MAC_NIFE0_156.25M_N: length 17.9
  TOP w0.095: v3(18.35,114.78) 18.03,114.45 17.23,114.45 C417.2 ; U40.U26 v4(31.7,113.65)
  S12 w0.102: v3(18.35,114.78) 18.66,114.48 19.56,114.48 19.94,114.1 19.94,113.58 20.27,113.25 31.99,113.25 32.1,113.35 32.1,113.54 31.99,113.65 v4(31.7,113.65)
MAC_NIFE0_156.25M_P: length 18.2
  TOP w0.095: C424.2 17.14,114.22 18.1,114.22 v3(18.35,113.97) ; U40.U25 v4(32.7,113.65)
  S12 w0.102: v4(32.7,113.65) 32.4,113.65 32.3,113.54 32.3,113.26 32.08,113.04 20.18,113.04 19.73,113.49 19.73,114.02 19.48,114.27 18.66,114.27 v3(18.35,113.97)
MAC_NIFE1_156.25M_N: length 15.3
  TOP w0.095: U40.U12 v4(46.7,113.65)
  BOTTOM w0.095: v4(46.7,113.65) 46.41,113.65 46.29,113.77 46.29,113.94 arc(46.31,114.01) 46.38,114.04 47.79,114.04 arc(48.16,114.19) 48.31,114.56 arc(48.64,115.35) 49.43,115.67 51.67,115.67 51.8,115.54 52.09,115.54 52.22,115.67 52.51,115.67 52.64,115.54 52.93,115.54 53.06,115.67 55.61,115.67 55.74,115.54 56.03,115.54 56.16,115.67 58.18,115.67 arc(58.39,115.63) 58.57,115.51 CB575.2
MAC_NIFE1_156.25M_P: length 15.3
  TOP w0.095: U40.U13 v4(45.7,113.65)
  BOTTOM w0.095: v4(45.7,113.65) 45.96,113.65 46.06,113.74 46.06,113.94 arc(46.15,114.17) 46.38,114.26 47.79,114.26 arc(48,114.35) 48.08,114.56 arc(48.48,115.51) 49.43,115.9 58.17,115.9 arc(58.38,115.94) 58.55,116.06 CB564.2
MAC_PCIE_100M_MAC_N: length 12.4
  TOP w0.095: U40.V36 21.78,114.73 20.86,114.73 arc(20.63,114.68) 20.45,114.56 19.36,113.48 arc(19.26,113.32) 19.22,113.13 19.22,113.07 arc(19.19,112.9) 19.09,112.76 18.98,112.65 arc(18.92,112.55) 18.89,112.44 18.89,112.43 arc(18.84,112.14) 18.67,111.89 18.66,111.88 arc(18.66,111.88) 18.65,111.87 18.07,111.29 arc(17.89,111.17) 17.67,111.13 17.33,111.13 16.97,110.77 R692.1 16.7,110.77 16.34,111.13 15.9,111.13 15.76,111 R694.1 15.3,111.13 14.88,111.13 14.75,111 R693.2 14.23,111.18 13.86,111.18 13.75,111.07 C382.2
MAC_PCIE_100M_MAC_P: length 11.5
  TOP w0.095: U40.V37 21.01,114.96 20.86,114.96 arc(20.55,114.9) 20.28,114.72 20.14,114.58 arc(20.02,114.53) 19.89,114.58 arc(19.77,114.63) 19.64,114.58 19.62,114.56 arc(19.57,114.44) 19.62,114.31 arc(19.68,114.19) 19.62,114.06 19.2,113.64 arc(19.04,113.4) 18.99,113.13 18.99,113.07 arc(18.97,112.99) 18.93,112.92 18.82,112.81 arc(18.71,112.64) 18.67,112.44 18.67,112.43 arc(18.63,112.22) 18.51,112.05 arc(18.5,112.05) 18.5,112.04 17.91,111.46 arc(17.8,111.38) 17.67,111.36 17.31,111.36 16.99,111.68 R692.2 16.62,111.68 16.3,111.36 15.86,111.36 15.76,111.45 R691.1 15.33,111.36 14.87,111.36 14.75,111.48 R690.2 14.37,111.41 13.85,111.41 13.75,111.51 C377.2
MAC_PCIE_100M_N: length 124.1
  TOP w0.095: R1426.1 40.17,206.23 40.17,205.21 v3(40.56,204.81) ; C382.1 12.31,111.25 11.91,111.25 v3(11.6,110.94)
  S12 w0.108: v3(40.56,204.81) 40.17,205.21 40.17,205.68 arc(40.12,205.91) 39.99,206.1 39.66,206.43 arc(39.32,206.66) 38.93,206.74 36.71,206.74 arc(35.79,206.55) 35,206.02 20.58,191.6 18.22,189.23 arc(15.48,185.14) 14.52,180.31 arc(14.43,179.87) 14.18,179.5 6.02,171.34 arc(4.67,169.31) 4.19,166.92 4.19,165.09 arc(4.15,164.73) 4.03,164.39 arc(3.9,164.18) 3.73,163.98 arc(3.23,163.22) 3.05,162.32 3.05,116.17 arc(3.37,114.52) 4.31,113.12 5.13,112.3 arc(6.29,111.52) 7.67,111.25 11.14,111.25 arc(11.28,111.22) 11.4,111.14 v3(11.6,110.94)
MAC_PCIE_100M_P: length 125
  TOP w0.095: R1427.1 39.94,206.23 39.94,205.21 v3(39.54,204.81) ; C377.1 12.47,111.48 11.87,111.48 v3(11.6,111.76)
  S12 w0.108: v3(39.54,204.81) 39.94,205.21 39.94,205.68 arc(39.91,205.82) 39.83,205.94 39.5,206.27 arc(39.24,206.45) 38.93,206.51 36.71,206.51 arc(35.87,206.34) 35.17,205.86 18.38,189.07 arc(15.69,185.05) 14.75,180.31 arc(14.64,179.78) 14.35,179.34 6.18,171.18 arc(4.88,169.22) 4.42,166.92 4.42,165.09 arc(4.37,164.68) 4.23,164.29 arc(4.08,164.04) 3.9,163.82 arc(3.44,163.13) 3.28,162.32 3.27,162.32 3.27,120.39 arc(3.35,120.2) 3.54,120.12 3.58,120.12 arc(3.85,119.85) 3.58,119.58 3.54,119.58 arc(3.27,119.31) 3.54,119.04 3.58,119.04 arc(3.85,118.77) 3.58,118.5 3.54,118.5 arc(3.27,118.23) 3.54,117.96 3.58,117.96 arc(3.85,117.69) 3.58,117.42 3.54,117.42 arc(3.35,117.34) 3.27,117.15 3.27,116.17 arc(3.59,114.61) 4.47,113.28 5.29,112.46 arc(6.38,111.73) 7.67,111.48 11.14,111.48 arc(11.31,111.51) 11.44,111.6 v3(11.6,111.76)
MAC_RESET_N: length 198.8
  TOP w0.127: v1(11.44,124.75) 11.46,124.75 11.46,124.81 R594.1 ; P1.G16 v4(100.29,225.46) ; v4(26.7,124.65) U40.AG31
  S9 w0.127: v1(80.97,208.63) 80.93,208.63 80.48,208.19 73.11,208.19 63.84,198.92 63.27,198.92 63.21,198.86 35.24,198.86 24.15,187.77 v1(24.15,187.56) 19.43,182.84 19.43,176.32 16.16,173.04 16.16,167.39 14.89,166.12 14.89,164.77 14.74,164.62 14.74,163.11 14.8,163.04 14.8,159.26 15.99,158.08 15.99,156.32 17.94,154.37 17.94,150.38 18.74,149.57 18.74,140.35 18.05,139.66 18.05,138.71 17.39,138.06 17.39,137.42 16.07,136.1 14.29,136.1 12.82,134.63 12.82,126.43 11.46,125.07 11.46,124.75 v1(11.44,124.75)
  S12 w0.127: v1(11.44,124.75) 11.46,124.75 11.46,125 11.78,125.32 15.68,125.32 16.73,124.27 18.2,124.27 20.22,122.25 21.89,122.25 22.16,122.53 22.16,122.91 22.42,123.17 24.89,123.17 25.19,123.46 25.19,123.84 25.49,124.15 25.87,124.15 26.37,124.65 v4(26.7,124.65)
  S14 w0.127: v4(100.29,225.46) 99.78,224.95 99.03,224.95 98.87,224.79 98.87,224.08 98.74,223.96 95,223.96 93.22,225.74 90.5,225.74 88.51,227.73 86.08,227.73 85,226.66 85,225.48 83.94,224.41 83.42,224.41 83.05,224.04 83.05,221.42 81.41,219.78 81.41,218.56 80.64,217.8 80.64,212.6 80.86,212.38 80.89,212.38 81.24,212.03 81.24,208.91 v1(80.97,208.63)
  BOTTOM w0.127: v1(24.15,187.56) 24.15,186.46 v2(24.1,186.41)
MAC_TCE: length 14.3
  TOP w0.127: R550.1 R542.2 7.97,129.89 v1(8.32,130.25) 8.68,129.89 R543.1 R527.1
  BOTTOM w0.127: v1(8.32,130.25) 7.71,130.86 7.71,135.61 4.99,138.33 4.88,138.33 4.88,138.37 v2(4.87,138.37)
MAC_TCK: length 326.3
  TOP w0.127: v1(224.5,238.22) 224.49,238.21 R406.1 ; v1(9.02,131.89) 9.06,131.93 R517.1
  S7 w0.127: v1(224.5,238.22) 222.22,238.22 221.94,237.94 209.22,237.94 206.47,240.7 v1(196.88,240.7)
  S14 w0.127: v1(9.02,131.89) 10.19,133.06 10.19,137.86 7.84,140.21 5.3,140.21 2.89,142.62 2.89,164.49 4,165.61 4,172.88 11.97,180.84 11.97,192.76 42.37,223.16 65.42,223.16 65.81,223.56 70.96,223.56 75.66,228.25 75.66,236.27 81.06,241.67 89.72,241.67 103.15,255.09 127.2,255.09 130.81,258.7 137.16,258.7 140.99,254.86 175.64,254.86 175.79,254.71 176.29,254.71 176.44,254.86 176.96,254.86 177.03,254.79 177.53,254.79 177.6,254.86 178.38,254.86 178.44,254.79 178.94,254.79 179.01,254.86 182.72,254.86 v1(196.88,240.7)
  BOTTOM w0.127: v2(225.9,238.54) 224.82,238.54 v1(224.5,238.22)
MAC_TCK_R: length 4.6
  TOP w0.127: R406.2 221.91,238.21 v1(221.58,238.54) 221.38,238.74 U20.14
  BOTTOM w0.127: v2(220.12,238.41) 220.25,238.54 v1(221.58,238.54)
MAC_TDO: length 242.9
  TOP w0.127: R583.1 9.64,125.83 v1(9.01,126.45) ; U22.1 182,176.75 181.83,176.58 R395.1 180.49,176.58 v1(180.43,176.63)
  S5 w0.127: v1(21.81,180.12) 18.25,180.12 v1(17.17,179.04)
  S9 w0.127: v1(17.17,179.04) 14.24,176.11 14.24,167.73 12.84,166.33 12.5,165.99 12.5,158.34 13.92,156.92 13.92,155.15 14.82,154.25 14.82,150.45 16.18,149.09 16.18,149.09 16.23,149.04 16.23,142.02 11.87,137.67 11.55,137.67 9.97,136.09 9.97,135.28 9.97,127.41 v1(9.01,126.45) ; v1(133.19,187.93) 134.07,187.05 141.4,187.05 143.56,189.2 145.32,189.2 146.4,190.28 156.17,190.28 158.5,187.96 158.5,187.32 159.72,186.11 161.14,186.11 162.72,187.68 169.38,187.68 v1(180.43,176.63)
  S16 w0.127: v1(133.19,187.93) 129.71,191.41 93.88,191.41 92.89,190.42 88.25,190.42 86.75,188.93 83.45,188.93 76.53,182.01 68.09,182.01 67.2,181.12 67.07,181.12 66.99,181.04 46.61,181.04 45.37,179.8 22.13,179.8 v1(21.81,180.12)
  BOTTOM w0.127: v2(180.5,175.61) 180.5,176.57 v1(180.43,176.63)
MAC_TMS: length 320
  TOP w0.127: v4(25.7,126.65) U40.AJ32 ; R387.1 207.79,239.73 v1(207.04,238.99)
  S14 w0.127: v4(25.7,126.65) 25.7,126.94 25.15,127.49 25.15,127.81 24.84,128.12 24.5,128.12 24.12,128.5 24.12,128.8 23.79,129.13 21.2,129.13 20.69,129.64 19.65,129.64 17.92,131.37 14.95,131.37 13.34,132.98 13.34,135.63 8.26,140.71 5.76,140.71 3.39,143.08 3.39,163.34 4.59,164.54 4.59,172.74 12.79,180.95 12.79,192.82 40.8,220.83 66.05,220.83 68.27,223.05 71.34,223.05 76.42,228.13 76.42,235.99 81.47,241.04 90.36,241.04 103.78,254.45 132.66,254.45 133.12,254.92 138.84,254.92 139.41,254.36 175.43,254.36 175.58,254.2 176.5,254.2 176.65,254.36 176.75,254.36 176.82,254.29 177.74,254.29 177.81,254.36 178.16,254.36 178.23,254.29 179.15,254.29 179.22,254.36 181.95,254.36 196.31,240 206.02,240 v1(207.04,238.99)
  BOTTOM w0.127: v1(207.04,238.99) 206.98,238.92 v2(205.58,238.92)
MAC_TMS_R: length 4.3
  TOP w0.127: R387.2 v1(210.34,239.73) 210.64,239.73 210.97,240.06 U20.5
  BOTTOM w0.127: v1(210.34,239.73) 210.78,240.18 v2(211.19,240.18)
MAC_TRST: length 37.6
  TOP w0.127: U40.AH34 v4(23.7,125.65) ; v1(11.41,128.84) 11.37,128.88 R551.2 R543.2
  S14 w0.127: v1(11.41,128.84) 12.89,127.36 16.77,127.36 17.02,127.61 17.91,127.61 19.05,126.47 20.45,126.47 20.7,126.22 23.12,126.22 23.69,125.65 v4(23.7,125.65)
  BOTTOM w0.127: v2(20.9,144.65) 19.84,143.59 18.08,143.59 17.3,142.8 16.38,142.8 12.9,139.31 12.9,130.33 v1(11.41,128.84)
MAC_UART0_RX: length 206.2
  TOP w0.127: v1(12.16,116.38) 12.85,115.69 R685.1 ; v1(88.31,225.97) R242.1 ; v4(24.7,120.65) U40.AC33
  S14 w0.127: v1(12.16,116.38) 12.35,116.18 15.35,116.18 16.04,116.88 17.81,116.88 17.94,117 19.03,117 20.16,118.13 24.81,118.13 25.19,118.51 25.19,119.96 24.7,120.44 v4(24.7,120.65) ; v1(88.31,225.97) 89.16,225.12 89.16,224.39 88.81,224.04 88.31,224.04 88.04,224.32 86.62,224.32 86.36,224.05 86.36,220.22 85.6,219.46 84.45,219.46 83.49,218.49 83.49,218.1 83.42,218.03 83.42,217.41 82.93,216.92 82.93,212.85 83.57,212.22 83.57,209.18 v1(83.28,208.89)
  S16 w0.127: v1(12.16,116.38) 13.16,117.38 13.16,132.92 13.34,133.1 13.34,138.76 16.32,141.75 16.32,148.87 16.84,149.39 16.84,154.52 12.79,158.57 12.79,165.33 14.7,167.23 14.7,172.59 17.75,175.64 17.75,177.58 18.32,178.15 18.32,185.75 31.9,199.34 66.7,199.34 71.3,203.94 71.3,204.85 72.93,206.47 74.53,206.47 78.27,210.21 81.94,210.21 83.26,208.89 v1(83.28,208.89)
  BOTTOM w0.127: v1(12.16,116.38) 11.56,115.78 11.56,113.13 7.26,108.84 6.43,108.84 5.43,107.83 v2(5.43,106.65)
MAC_UART0_RX_R: length 6.5
  TOP w0.127: P1.A16 94.09,224.96 93.35,225.7 91.89,225.7 v1(91.18,226.41) 90.73,225.97 R242.2
  BOTTOM w0.127: v1(91.18,226.41) 91.02,226.41 v2(90.39,227.05)
MAC_UART0_TX_FPGA: length 197.1
  TOP w0.127: R618.1 9.11,123.82 v1(9.03,123.75) ; R373.2 v1(122.34,213.76)
  S5 w0.127: v1(122.34,213.76) 121.34,212.77 121.34,210.35 120.26,209.27 119.03,209.27 117.53,207.77 108.32,207.77 107.47,206.92 106.26,206.92 104.95,208.23 101.33,208.23 101.23,208.33 95.63,208.33 94.86,209.1 92.58,209.1 92.28,208.8 92.28,208.15 90.64,206.51 89.32,206.51 88.85,206.04 86.38,206.04 85.92,206.5 81.98,206.5 81.25,207.23 77.89,207.23 77.04,208.08 71.99,208.08 69.7,205.79 68.98,205.79 v1(68.86,205.9)
  S16 w0.127: v1(9.03,123.75) 9.03,123.8 7.64,125.19 7.64,133.06 8.26,133.68 8.26,136.86 9.16,137.77 9.16,138.88 6.71,141.34 6.71,143.55 5.46,144.79 5.46,149.84 7.27,151.65 7.27,159.95 9.58,162.26 9.58,167.33 11.04,168.79 11.04,172 14.76,175.72 14.76,186.57 30.33,202.13 65.08,202.13 68.85,205.9 v1(68.86,205.9)
  BOTTOM w0.127: v2(123.37,215.25) 123.37,214.79 v1(122.34,213.76)
MAC_UART0_TX_FPGA_R: length 8.7
  TOP w0.127: R373.1 118.85,213.76 v1(117.82,214.79) ; P1.Y7 v4(114.29,215.46)
  BOTTOM w0.127: v4(114.29,215.46) 114.76,214.98 117.63,214.98 v1(117.82,214.79) 117.82,214.03 117.76,213.97 117.76,214.01 v2(117.75,214.01)
MAC_UART0_TX_R: length 29.6
  TOP w0.127: v4(25.7,121.65) U40.AD32 ; v1(11.38,123.8) 11.36,123.82 R618.2 ; R629.1 8.05,121.77 v1(8.21,121.61)
  S7 w0.127: v4(25.7,121.65) 25.65,121.65 25.15,122.15 23.5,122.15 23.24,121.9 23.24,121.39 22.99,121.14 22.59,121.14 22.16,121.56 19.07,121.56 18.41,122.22 8.91,122.22 8.29,121.61 v1(8.21,121.61)
  BOTTOM w0.127: v1(11.38,123.8) 11.32,123.8 9.8,122.28 8.88,122.28 v1(8.21,121.61) 7.79,121.19 5.62,121.19 v2(4.66,122.15)
MAC_UART1_RX: length 173
  TOP w0.127: v1(88.56,224.64) 88.88,224.95 R1184.1 ; v4(26.7,121.65) U40.AD31 ; v1(8.33,125.31) 7.84,124.81 R593.1
  S5 w0.127: v4(26.7,121.65) 26.57,121.65 26.18,122.04 26.18,137.22 23.32,140.08 23.32,169.74 26.87,173.29 33.91,173.29 34.87,172.33 38.24,172.33 40.63,174.72 55.34,174.72 60.29,179.68 v1(60.29,184.88)
  S7 w0.127: v1(60.29,184.88) 60.29,196.43 71.77,207.92 71.77,208.76 83.34,220.33 84.07,220.33 85.99,222.25 85.99,223.54 86.83,224.38 88.31,224.38 v1(88.56,224.64)
  S14 w0.127: v4(26.7,121.65) 26.22,122.12 20.17,122.12 20.17,122.12 19.69,122.12 19,122.81 19,122.81 18.55,123.26 10.98,123.26 9.42,124.82 8.82,124.82 v1(8.33,125.31)
  BOTTOM w0.127: v2(59.27,184.88) v1(60.29,184.88)
MAC_UART1_RX_R: length 6.3
  TOP w0.127: P1.A15 94.32,223.96 93.26,225.02 v1(92.55,225.02) 92.48,224.95 R1184.2
  BOTTOM w0.127: v2(92.55,223.78) v1(92.55,225.02)
MAC_UART1_TX: length 12.1
  TOP w0.127: v4(24.7,119.65) U40.AB33 ; R1182.2 16.81,120.74 R640.1 17.2,120.75 v1(17.53,120.41)
  S14 w0.127: v4(24.7,119.65) 24.1,120.25 21.16,120.25 20.68,120.72 17.84,120.72 17.53,120.41 v1(17.53,120.41)
  BOTTOM w0.127: v2(16.59,119.02) 16.59,119.47 v1(17.53,120.41)
MAC_UART1_TX_FPGA: length 168.6
  TOP w0.127: v1(15.13,120.7) 15.21,120.7 15.33,120.57 15.33,119.96 15.54,119.75 R1182.1 ; v1(87.93,223.57) 88.29,223.94 R1183.1
  S14 w0.127: v1(87.93,223.57) 87.93,222.9 87.1,222.07 87.1,216.56 87.76,215.9 87.76,212.7 87.53,212.47 87.53,211.81 86.13,210.41 86.13,209.71 v1(85.69,209.27)
  S16 w0.127: v1(85.69,209.27) 84.46,208.03 82.02,208.03 81.51,207.52 77.39,207.52 67.92,198.04 43.52,198.04 42.57,197.09 41.62,197.09 41.33,197.38 37.95,197.38 37.26,198.07 32.55,198.07 19.14,184.66 19.14,176.06 15.36,172.27 15.36,165.9 13.3,163.85 13.3,158.95 17.69,154.56 17.69,149.02 16.83,148.16 16.83,140.98 16.22,140.37 16.22,132.93 15.8,132.51 14.24,132.51 13.86,132.13 13.86,122.15 15.13,120.88 v1(15.13,120.7)
  BOTTOM w0.127: v1(85.69,209.27) 85.69,209.35 86.2,209.86 v2(86.2,210.16)
MAC_UART1_TX_R: length 6.1
  TOP w0.127: P1.A14 93.81,223.94 v1(91.15,223.94) R1183.2
  BOTTOM w0.254: v2(90.14,223.87) 90.18,223.92 91.14,223.92 v1(91.15,223.94)
MANG_1P2: length 9.7
  TOP w0.508: CONN6.10 33.18,227.93 CB30.2
  V18 w0.635: 33.17,226.6 CONN6.10 ; CONN6.10 33.17,229.27 ; CONN6.10 31.84,227.94
  BOTTOM w0.508: v2(219.48,134.59) 219.46,134.57 v1(218.15,134.57)
  vias: v1(218.1,133.73) v1(218.1,132.9)
MANG_1P2_DVDD: length 12.8
  TOP w0.381: U52.J3 v3(227.18,120.65) ; U52.E7 v3(232.18,125.65) ; U52.J7 v3(232.18,120.65) ; U52.E3 v3(227.18,125.65) ; U52.C6 v3(231.18,127.65) ; U52.D7 v3(232.18,126.65) ; U52.C7 v3(232.18,127.65) ; U52.F3 v3(227.18,124.65)
  BOTTOM w0.127: v2(221.06,122.54) v1(221.06,121.75)
  BOTTOM w0.381: CB1001.1 v3(227.18,125.65) U52.E3 ; U52.F3 v3(227.18,124.65) ; v3(232.18,127.65) CB1007.1 ; v3(232.18,126.65) CB1033.1 ; U52.C6 v3(231.18,127.65) ; U52.J3 v3(227.18,120.65) ; v3(232.18,125.65) CB1018.1 ; U52.J7 v3(232.18,120.65)
  vias: v1(221.94,130.48) v1(221.94,129.77) v1(221.96,131.19)
MANG_1P2_PG: length 278.2
  TOP w0.127: CONN5.5 v1(14.38,230.54)
  TOP w0.254: R119.2 v1(221.36,215.08)
  S5 w0.254: v1(221.36,215.08) 222.55,216.27 222.55,224.29 225.31,227.04 225.31,229.73 v1(224.49,230.55)
  S9 w0.254: v1(224.49,230.55) 220.18,234.86 219.18,234.86 201.65,252.38 175.38,252.38 175.34,252.35 136.08,252.35 135.22,253.21 109.36,253.21 106.64,255.93 86.93,255.93 82.92,251.92 18.53,251.92 9.57,242.97 6.81,240.2 6.81,231.83 8.79,229.84 13.68,229.84 v1(14.38,230.54)
  BOTTOM w0.127: v1(221.36,215.08) 217.93,215.08 v2(216.82,213.97)
MANG_1P2_PG_R: length 10.3
  TOP w0.127: U7.31 225.03,216.24 v1(223.87,215.08) R119.1
  BOTTOM w0.127: v1(223.87,215.08) 223.39,215.55 219.36,215.55 v2(218.02,216.89)
MANG_2P5: length 110.1
  TOP w0.254: v1(244.31,211.24) 244.26,211.29 R1064.1
  TOP w0.305: C774.2 237.12,136.4 R1068.2 ; 233.9,135.02 U66.1
  TOP w0.508: v1(223.68,95.03) 223.43,94.79 U76.10 ; U76.4 v1(231.05,95.17) ; 233.9,135.02 234.16,135.28 C778.1 235.11,135.3 C777.1 236.56,135.3 ; v1(233.95,96.09) 234.28,96.09 234.86,95.51 U76.1 ; CB898.2 219.31,109.35 LB57.1 ; 236.88,135.93 237.13,136.17 C774.2 ; U76.7 v1(227.24,94.98)
  S7 w0.508: CONN52.1 211.35,119.48 213.58,119.48
  S12 w0.254: v1(237.53,135.53) 235.3,137.77 235.3,140.33 229.64,145.98 229.64,169.57 244.31,184.24 v1(244.31,211.24)
  BOTTOM w0.127: v2(245.14,210.22) 245.14,210.41 v1(244.31,211.24)
  BOTTOM w0.508: v1(223.68,95.03) 223.43,94.79 C896.2 ; C895.2 v1(231.05,95.17) ; C894.1 v1(227.24,94.98)
  vias: v1(214.72,128.94) v1(214.79,127.92) v1(218.13,125.63) v1(218.15,124.94) v1(218.41,110.91) v1(218.41,110.08) v1(237.53,134.74) v1(240.88,137.01) v1(241.01,136.12)
MANG_2P5_AVDD: length 15.4
  TOP w0.381: U52.M8 v3(233.18,117.65) ; U52.B7 v3(232.18,128.65) ; U52.M7 v3(232.18,117.65) ; U52.M3 v3(227.18,117.65) ; U52.N5 v3(230.18,116.65) ; U52.M4 v3(228.18,117.65)
  TOP w0.508: LB57.2 CB892.2 CB995.1 v1(221.75,113.73) 222.43,113.73 v1(222.44,113.74)
  BOTTOM w0.381: U52.B7 v3(232.18,128.65) ; U52.M8 v3(233.18,117.65) ; U52.M7 v3(232.18,117.65) ; v3(228.18,117.65) U52.M4 CB1010.1 ; U52.M3 v3(227.18,117.65) ; v3(230.18,116.65) CB994.1
  BOTTOM w0.508: v2(222.6,112.43) 222.6,113.59 v1(222.44,113.74)
MANG_2P5_EN: length 7.9
  TOP w0.305: 229.32,136.97 U66.5
  TOP w0.508: 229.32,136.97 228.93,137.37 C775.1 R1066.2 227.08,137.39 R1065.1 226.07,137.39 R1067.1 225.06,138.2 v1(225.07,138.21)
  BOTTOM w0.508: v2(223.29,138.21) v1(225.07,138.21)
MANG_2P5_FB: length 7.4
  TOP w0.254: R1069.2 234.52,137.31 233.53,136.32 U66.3 ; R1069.2 235.1,137.95 235,138.05 v1(234.4,138.05) ; R1069.2 235.11,137.31 R1068.1 237.12,137.31 C774.1
  BOTTOM w0.508: v1(234.4,138.05) 234.4,137.7 v2(233.52,136.81)
MANG_2P5_IN: length 2.2
  TOP w0.381: 224.15,136.6 R1067.2
  BOTTOM w0.381: v1(224.56,136.12) v2(225.96,136.12)
MANG_2P5_MON: length 13.4
  TOP w0.254: R1064.2 R1063.1 238.88,213.73 238.07,213.73 237.74,214.06 C99.1 237.15,215 237.15,216.02 236.7,216.47 236.7,217.11 236.14,217.67 236.14,217.84 235.74,218.24 U7.54 234.81,218.24 v1(234.53,217.97)
  BOTTOM w0.127: v2(236.76,216.25) 236.25,216.25 v1(234.53,217.97)
MANG_2P5_VDDO: length 9.3
  TOP w0.127: v3(226.18,127.65) U52.C2
  TOP w0.381: U52.B4 v3(228.18,128.65) ; U52.K1 v3(225.18,120.65)
  TOP w0.508: R1038.1 v1(240.04,121.63) ; R1055.1 v1(237.42,130.75)
  BOTTOM w0.127: v1(237.42,130.75) 239.77,130.75 v2(240,130.97)
  BOTTOM w0.381: CB1032.1 v3(228.18,128.65) U52.B4 ; U52.C2 v3(226.18,127.65) ; v3(225.18,120.65) CB1022.1
  vias: v1(218.38,128.78) v1(218.43,128.04)
MANG_2P5_VDDOH: length 9
  TOP w0.381: U52.F7 v1(232.18,124.65) ; U52.B9 v3(234.18,128.65) ; U52.J8 v3(233.18,120.65)
  BOTTOM w0.381: U52.B9 v3(234.18,128.65) ; CB1013.1 231.79,120.04 232.57,120.04 CB1015.1 v3(233.18,120.65) ; U52.F7 v1(232.18,124.65)
  BOTTOM w0.508: v2(233.9,133.04) 235.09,131.85 v1(237.07,131.85)
  vias: v1(237.05,132.61) v1(237.07,133.32)
MANG_2P5_VDDOX: length 4.8
  TOP w0.381: U52.K9 v3(234.18,120.65) ; U52.L2 v3(226.18,118.65)
  BOTTOM w0.381: U52.K9 v3(234.18,120.65) ; U52.L2 v3(226.18,118.65) CB1026.1
  BOTTOM w0.508: v2(222.98,124.69) 222.32,124.03 v1(221.96,124.03)
  vias: v1(221.96,123.29) v1(221.96,122.55)
MANU_RST: length 146.2
  TOP w0.127: P1.C3 v4(96.29,211.46) ; v1(167.08,146.24) 167.2,146.35 167.36,146.35 167.94,145.77 J2.B49
  S9 w0.127: v1(167.08,146.24) 167.08,146.2 166.55,145.66 153.66,145.66 152.16,147.17 v1(152.16,149.17)
  S14 w0.127: v4(96.29,211.46) 97.06,210.69 97.06,206.28 96.68,205.9 96.68,204.89 97.63,203.93 97.63,202.93 98.46,202.1 112.9,202.1 119.3,195.71 139.89,195.71 144.38,191.22 146.55,191.22 148.37,189.39 159.22,189.39 161.81,186.81 161.81,175.11 161.07,174.38 161.07,165.65 151.6,156.18 151.6,149.72 v1(152.16,149.17)
  BOTTOM w0.127: v2(166.39,145.41) 167.08,146.11 v1(167.08,146.24) 167.57,146.72 RB1234.1 RB1235.1
MASTER_I2C_SCL: length 13.9
  TOP w0.127: P1.T20 v4(110.29,229.46) ; v1(119.28,234.99) 119.32,235.02 R120.1
  BOTTOM w0.127: v4(110.29,229.46) 110.8,229.97 111.47,229.97 111.73,230.22 111.73,231.94 112.55,232.76 116.61,232.76 v2(118.3,234.45) 118.64,234.78 119.08,234.78 v1(119.28,234.99)
MB1_PWR_EN: length 115.6
  TOP w0.127: CONN5.7 v1(14.38,231.81) ; P1.D6 v4(97.29,214.46)
  S9 w0.127: v1(14.38,231.81) 15.9,233.33 15.9,241.08 18.19,243.37 73.94,243.37 80.04,237.27 80.04,226.53 83.51,223.06 84.18,223.06 85.11,222.13 86.62,222.13 90.74,218.01 92.69,218.01 92.69,217.96 93.41,217.23 93.41,216.57 95.07,214.92 96.83,214.92 v4(97.29,214.46)
  BOTTOM w0.127: v1(14.38,231.81) 14.38,231.81 v2(13.49,231.81)
MCLKIN_N: length 5.8
  TOP w0.254: v1(154.85,171.77) 154.8,171.77 154.67,171.9 U77.76
  BOTTOM w0.508: v1(154.85,171.77) 154.87,171.74 155.64,171.74 156.65,170.73 C914.2 R1415.2 156.65,168.21 R1414.1
MCT1: length 4
  TOP w0.381: U76.24 234.86,77.13 v1(234.87,77.13)
  BOTTOM w0.127: v1(234.87,77.13) 234.87,78.06 234.72,78.2 v2(234.72,78.52)
  BOTTOM w0.508: R1331.2 234.92,77.08 v1(234.87,77.13)
MCT2: length 4.3
  TOP w0.381: U76.21 v1(231.05,77.16)
  BOTTOM w0.508: R1332.2 v1(231.05,77.16) 231.17,77.28 v2(231.17,78.71)
MCT3: length 4.1
  TOP w0.381: v1(227.3,77.06) 227.24,77.11 U76.18
  BOTTOM w0.508: R1333.2 227.43,76.92 v1(227.3,77.06) 227.23,77.12 v2(227.23,78.39)
MCT4: length 4
  TOP w0.508: U76.15 223.43,77.31 v1(223.68,77.06)
  BOTTOM w0.508: R1334.2 223.75,76.99 v1(223.68,77.06) 223.68,77.82 v2(223.29,78.2)
MDI-0: length 3
  BOTTOM w0.127: C785.1 R1077.1 226.13,115.07 R1078.1 v2(226.13,114.12)
MDI-1: length 3
  BOTTOM w0.127: C783.1 R1075.1 R1076.1 v2(228.16,114.12)
MDI-2: length 3
  BOTTOM w0.127: C781.1 R1073.1 R1074.1 v2(231.14,114.12)
MDI-3: length 3
  BOTTOM w0.127: v2(233.18,114.12) R1072.1 R1071.1 C779.1
MGMT_ACT_LED: length 243
  TOP w0.127: U9.M16 v4(205.55,187.58)
  S7 w0.127: v1(219.2,183.72) 219.2,174.8 219.48,174.52 219.48,170.35 218.53,169.4 218.53,158.91 218.02,158.4 218.02,148.63 216.47,147.07 216.47,144.78 211.8,140.11 211.8,138.3 208.4,134.9 200.36,134.9 194.34,128.88 194.34,103.99 196.24,102.08 196.24,93.32 197.32,92.24 202.35,92.24 212.16,82.42 212.16,77.85 213.58,76.43 216.63,76.43 222.86,70.2 222.86,45.57 215.61,38.32 215.61,16.38 216.62,15.37 219.9,15.37 220.75,14.51 220.75,12.74 222.22,11.28 228.12,11.28 230.22,9.18 233.26,9.18 v1(234.22,10.13)
  S9 w0.127: v1(219.2,183.72) 215.8,187.12 206.39,187.12 205.93,187.58 v4(205.55,187.58)
  BOTTOM w0.127: v2(219.55,184.76) 219.55,184.07 v1(219.2,183.72) ; R1057.2 v1(234.22,10.13)
MGMT_CLK_IN: length 4.4
  TOP w0.127: U37.7 242.22,119.04 242.08,118.9 240.18,118.9 239.86,118.58 R1060.1
MGMT_CLK_IN_R: length 6.7
  TOP w0.127: R1060.2 R1059.2 236.71,119.6 234.16,122.15 U52.H9
MGMT_LINK_LED: length 249.7
  TOP w0.127: U9.D15 v4(204.55,196.58)
  S7 w0.127: v1(228.57,10.13) 227.68,11.02 222.09,11.02 220.5,12.61 220.5,14.28 219.66,15.11 216.46,15.11 215.29,16.28 215.29,38.38 222.6,45.69 222.6,70.04 216.73,75.92 213.53,75.92 211.87,77.57 211.87,82.17 202.25,91.79 197.13,91.79 195.86,93.06 195.86,101.89 193.97,103.78 193.97,129.02 200.25,135.3 208.42,135.3 211.43,138.31 211.43,140.1 216.1,144.77 216.1,147.72 216.82,148.44 216.82,151.04 217.62,151.84 217.62,158.44 218.28,159.1 218.28,169.73 219.17,170.62 219.17,174.34 218.72,174.79 218.72,195.68 217.2,197.2 211.13,197.2 209.99,196.06 205.07,196.06 v4(204.55,196.58)
  BOTTOM w0.127: v2(227.36,10.45) 228.25,10.45 v1(228.57,10.13) R1058.2
MGMT_MDI_N0: length 118.9
  TOP w0.095: R957.2 249.63,103.99 249.63,104.24 v3(249.34,104.53) ; v3(150.97,136.61) 150.68,136.9 150.35,136.9 149.53,137.72 149.53,138.95 149.44,139.04 J2.A12
  S9 w0.108: v3(249.34,104.53) 249.59,104.79 arc(249.62,104.83) 249.63,104.88 arc(249.53,105.11) 249.3,105.21 244.4,105.21 arc(244,105.29) 243.66,105.51 242.57,106.6 arc(242.26,106.81) 241.89,106.89 210.61,106.89 arc(209.79,107.05) 209.11,107.51 207.82,108.79 arc(207.08,109.91) 206.82,111.22 206.82,113.22 arc(206.73,113.66) 206.48,114.03 202.85,117.66 arc(202.27,118.04) 201.59,118.18 196.84,118.18 arc(193.09,118.92) 189.92,121.04 176.59,134.38 arc(175.53,135.08) 174.28,135.33 155.84,135.33 arc(154.92,135.52) 154.13,136.04 arc(153.18,136.68) 152.06,136.9 151.26,136.9 arc(151.05,136.82) v3(150.97,136.61)
MGMT_MDI_N0_GE: length 70.2
  TOP w0.095: v3(262.5,67.06) 262.76,67.32 262.76,67.87 262.2,68.44 U70.22
  S16 w0.108: RJ1.E2 255.25,16.88 254.86,16.5 254.86,15.88 255.08,15.66 263.9,15.66 264.52,16.28 264.52,21.47 265.31,22.25 265.31,43.74 258.08,50.97 258.08,60.66 262.79,65.37 262.79,66.76 v3(262.5,67.06)
MGMT_MDI_N0_R: length 29.6
  TOP w0.095: U55.9 251.49,95.48 v3(251.36,95.35) ; v3(258.37,91.6) 258.66,91.9 259.8,91.9 262.72,88.98 262.72,85.56 262.62,85.47 262.29,85.47 262.2,85.37 U70.3 ; R957.1 249.23,102.67 C711.2 249.66,101.24 249.66,101.09 250.04,100.71 250.74,100.71 251.65,99.8 251.65,99.6 arc(251.64,99.54) 251.6,99.49 251.42,99.31 arc(251.29,98.99) 251.42,98.67 arc(251.47,98.59) 251.49,98.5
  S12 w0.108: v3(258.37,91.6) 258.08,91.9 255.64,91.9 254.07,93.46 252.12,93.46 251.63,93.95 251.63,95.08 v3(251.36,95.35)
  BOTTOM w0.095: v3(258.37,91.6) 258.37,91.62 258.08,91.91 257.84,91.91 257.74,91.81 257.74,91.48 257.65,91.39 U62.2
MGMT_MDI_N1: length 118.2
  TOP w0.095: v3(241.6,105.02) 241.85,105.26 245.54,105.26 245.81,104.99 245.81,104.32 245.72,104.22 245.53,104.22 245.43,104.13 R960.2 ; J2.A9 147.94,139.02 148.07,138.88 148.07,138.63 148.52,138.19 148.52,135.52 148.78,135.25 149.15,135.25 v3(149.44,134.96)
  S9 w0.108: v3(149.44,134.96) 149.66,135.18 arc(149.72,135.21) 149.78,135.23 151.67,135.23 arc(152.17,135.13) 152.59,134.84 arc(154.43,133.62) 156.59,133.19 168.09,133.19 arc(168.43,133.26) 168.73,133.45 168.95,133.68 arc(169.23,133.87) 169.57,133.93 173.85,133.93 arc(175.02,133.7) 176.02,133.03 189.78,119.27 arc(192.91,117.18) 196.6,116.44 201.19,116.44 arc(201.89,116.3) 202.48,115.91 204.22,114.17 arc(204.73,113.41) 204.91,112.51 204.91,110.69 arc(205.16,109.4) 205.89,108.31 207.82,106.38 arc(208.7,105.79) 209.73,105.59 238.38,105.59 arc(238.46,105.57) 238.52,105.53 238.64,105.41 arc(238.75,105.34) 238.89,105.31 241.31,105.31 v3(241.6,105.02)
MGMT_MDI_N1_GE: length 65.5
  TOP w0.095: v3(258.6,67.18) 258.92,67.5 258.92,67.91 258.39,68.44 U70.19
  S9 w0.108: v3(258.6,67.18) 258.89,66.89 258.89,50.22 265.3,43.81 265.3,22.3 264.51,21.51 264.51,16.34 263.69,15.52 259.27,15.52 259.05,15.74 259.05,17.06 259.38,17.39 260.03,17.39 RJ1.E6
