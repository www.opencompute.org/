# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RB344  4.7K  [RC0402]  49.29 40.86 0 bottom
RB345  4.7K  [RC0402]  57.95 40.86 0 bottom
RB346  4.7K  [RC0402]  59.73 40.86 0 bottom
RB347  4.7K  [RC0402]  61.51 40.86 0 bottom
RB348  4.7K  [RC0402]  63.54 40.86 0 bottom
RB349  4.7K  [RC0402]  72.2 40.86 0 bottom
RB350  4.7K  [RC0402]  73.98 40.86 0 bottom
RB351  4.7K  [RC0402]  75.76 40.86 0 bottom
RB352  4.7K  [RC0402]  77.79 40.86 0 bottom
RB353  4.7K  [RC0402]  86.45 40.86 0 bottom
RB354  4.7K  [RC0402]  88.23 40.86 0 bottom
RB355  4.7K  [RC0402]  90.01 40.86 0 bottom
RB356  4.7K  [RC0402]  92.04 40.86 0 bottom
RB357  4.7K  [RC0402]  100.7 40.86 0 bottom
RB358  4.7K  [RC0402]  102.48 40.86 0 bottom
RB359  4.7K  [RC0402]  104.26 40.86 0 bottom
RB360  4.7K  [RC0402]  106.29 40.86 0 bottom
RB361  4.7K  [RC0402]  117 40.86 0 bottom
RB362  4.7K  [RC0402]  118.78 40.86 0 bottom
RB363  4.7K  [RC0402]  120.56 40.86 0 bottom
RB364  4.7K  [RC0402]  122.59 40.86 0 bottom
RB365  4.7K  [RC0402]  131.25 40.86 0 bottom
RB366  4.7K  [RC0402]  133.03 40.86 0 bottom
RB367  4.7K  [RC0402]  134.81 40.86 0 bottom
RB368  4.7K  [RC0402]  136.84 40.86 0 bottom
RB369  4.7K  [RC0402]  145.5 40.86 0 bottom
RB370  4.7K  [RC0402]  147.28 40.86 0 bottom
RB371  4.7K  [RC0402]  149.06 40.86 0 bottom
RB372  4.7K  [RC0402]  151.09 40.86 0 bottom
RB373  4.7K  [RC0402]  159.75 40.86 0 bottom
RB374  4.7K  [RC0402]  161.53 40.86 0 bottom
RB375  4.7K  [RC0402]  163.31 40.86 0 bottom
RB376  4.7K  [RC0402]  165.34 40.86 0 bottom
RB377  4.7K  [RC0402]  174 40.86 0 bottom
RB378  4.7K  [RC0402]  175.78 40.86 0 bottom
RB379  4.7K  [RC0402]  177.56 40.86 0 bottom
RB380  4.7K  [RC0402]  179.59 40.86 0 bottom
RB381  4.7K  [RC0402]  188.25 40.86 0 bottom
RB382  4.7K  [RC0402]  190.03 40.86 0 bottom
RB383  4.7K  [RC0402]  191.81 40.86 0 bottom
RB384  4.7K  [RC0402]  193.84 40.86 0 bottom
RB385  @4.7K  [RC0402]  57.95 37.81 180 bottom
RB386  @4.7K  [RC0402]  59.73 37.81 180 bottom
RB387  @4.7K  [RC0402]  61.51 37.81 180 bottom
RB388  @4.7K  [RC0402]  63.54 37.81 180 bottom
RB389  @4.7K  [RC0402]  72.2 37.81 180 bottom
RB390  @4.7K  [RC0402]  73.98 37.81 180 bottom
RB391  @4.7K  [RC0402]  75.76 37.81 180 bottom
RB392  @4.7K  [RC0402]  77.79 37.81 180 bottom
RB393  @4.7K  [RC0402]  86.45 37.81 180 bottom
RB394  @4.7K  [RC0402]  88.23 37.81 180 bottom
RB395  @4.7K  [RC0402]  90.01 37.81 180 bottom
RB396  @4.7K  [RC0402]  92.04 37.81 180 bottom
RB397  @4.7K  [RC0402]  100.7 37.81 180 bottom
RB398  @4.7K  [RC0402]  102.48 37.81 180 bottom
RB399  @4.7K  [RC0402]  104.26 37.81 180 bottom
RB400  @4.7K  [RC0402]  106.29 37.81 180 bottom
RB401  @4.7K  [RC0402]  159.75 37.81 180 bottom
RB402  @4.7K  [RC0402]  161.53 37.81 180 bottom
RB403  @4.7K  [RC0402]  163.31 37.81 180 bottom
RB404  @4.7K  [RC0402]  165.34 37.81 180 bottom
RB405  @4.7K  [RC0402]  174 37.81 180 bottom
RB406  @4.7K  [RC0402]  175.78 37.81 180 bottom
RB407  @4.7K  [RC0402]  177.56 37.81 180 bottom
RB408  @4.7K  [RC0402]  179.59 37.81 180 bottom
RB409  @4.7K  [RC0402]  188.25 37.81 180 bottom
RB410  @4.7K  [RC0402]  190.03 37.81 180 bottom
RB411  @4.7K  [RC0402]  191.81 37.81 180 bottom
RB412  @4.7K  [RC0402]  193.84 37.81 180 bottom
RB413  @4.7K  [RC0402]  29.24 37.81 180 bottom
RB414  @4.7K  [RC0402]  30.94 37.81 180 bottom
RB415  @4.7K  [RC0402]  32.92 37.81 180 bottom
RB416  @4.7K  [RC0402]  34.96 37.81 180 bottom
RB417  @4.7K  [RC0402]  43.7 37.81 180 bottom
RB418  @4.7K  [RC0402]  45.48 37.81 180 bottom
RB419  @4.7K  [RC0402]  47.26 37.81 180 bottom
RB420  @4.7K  [RC0402]  49.29 37.81 180 bottom
RB421  @4.7K  [RC0402]  117 37.81 180 bottom
RB422  @4.7K  [RC0402]  118.78 37.81 180 bottom
RB423  @4.7K  [RC0402]  120.56 37.81 180 bottom
RB424  @4.7K  [RC0402]  122.59 37.81 180 bottom
RB425  @4.7K  [RC0402]  131.25 37.81 180 bottom
RB426  @4.7K  [RC0402]  133.03 37.81 180 bottom
RB427  @4.7K  [RC0402]  134.81 37.81 180 bottom
RB428  @4.7K  [RC0402]  136.84 37.81 180 bottom
RB429  @4.7K  [RC0402]  145.5 37.81 180 bottom
RB430  @4.7K  [RC0402]  147.28 37.81 180 bottom
RB431  @4.7K  [RC0402]  149.06 37.81 180 bottom
RB432  @4.7K  [RC0402]  151.09 37.81 180 bottom
RB433  4.7K  [RC0402]  63.16 33.24 90 bottom
RB434  4.7K  [RC0402]  63.16 34.25 90 bottom
RB435  4.7K  [RC0402]  63.16 35.27 90 bottom
RB436  4.7K  [RC0402]  77.41 33.24 90 bottom
RB437  4.7K  [RC0402]  77.41 34.25 90 bottom
RB438  4.7K  [RC0402]  77.41 35.27 90 bottom
RB439  4.7K  [RC0402]  91.66 33.24 90 bottom
RB440  4.7K  [RC0402]  91.66 34.25 90 bottom
RB441  4.7K  [RC0402]  91.66 35.27 90 bottom
RB442  4.7K  [RC0402]  105.91 33.24 90 bottom
RB443  4.7K  [RC0402]  105.91 34.25 90 bottom
RB444  4.7K  [RC0402]  105.91 35.27 90 bottom
RB445  4.7K  [RC0402]  164.96 33.24 90 bottom
RB446  4.7K  [RC0402]  164.96 34.25 90 bottom
RB447  4.7K  [RC0402]  164.96 35.27 90 bottom
RB448  4.7K  [RC0402]  179.21 33.24 90 bottom
RB449  4.7K  [RC0402]  179.21 34.25 90 bottom
RB450  4.7K  [RC0402]  179.21 35.27 90 bottom
RB451  4.7K  [RC0402]  193.46 33.24 90 bottom
RB452  4.7K  [RC0402]  193.46 34.25 90 bottom
RB453  4.7K  [RC0402]  193.46 35.27 90 bottom
RB454  4.7K  [RC0402]  29.75 36.28 270 bottom
RB455  4.7K  [RC0402]  32.03 36.28 90 bottom
RB456  4.7K  [RC0402]  34.45 36.28 90 bottom
RB457  4.7K  [RC0402]  44.21 36.29 270 bottom
RB458  4.7K  [RC0402]  46.5 36.29 90 bottom
RB459  4.7K  [RC0402]  48.91 36.29 90 bottom
RB460  4.7K  [RC0402]  122.21 33.24 90 bottom
RB461  4.7K  [RC0402]  122.21 34.25 90 bottom
RB462  4.7K  [RC0402]  122.21 35.27 90 bottom
RB463  4.7K  [RC0402]  136.46 33.24 90 bottom
RB464  4.7K  [RC0402]  136.46 34.25 90 bottom
RB465  4.7K  [RC0402]  136.46 35.27 90 bottom
RB466  4.7K  [RC0402]  150.71 33.24 90 bottom
RB467  4.7K  [RC0402]  150.71 34.25 90 bottom
RB468  4.7K  [RC0402]  150.71 35.27 90 bottom
RB469  4.7K  [RC0402]  58.46 34.25 270 bottom
RB470  4.7K  [RC0402]  60.75 35.27 90 bottom
RB471  4.7K  [RC0402]  58.46 33.24 270 bottom
RB472  4.7K  [RC0402]  72.71 34.25 270 bottom
RB473  4.7K  [RC0402]  75 35.27 90 bottom
RB474  4.7K  [RC0402]  72.71 33.24 270 bottom
RB475  4.7K  [RC0402]  86.96 34.25 270 bottom
RB476  4.7K  [RC0402]  89.25 35.27 90 bottom
RB477  4.7K  [RC0402]  86.96 33.24 270 bottom
RB478  4.7K  [RC0402]  101.21 34.25 270 bottom
RB479  4.7K  [RC0402]  103.5 35.27 90 bottom
RB480  4.7K  [RC0402]  101.21 33.24 270 bottom
RB481  4.7K  [RC0402]  160.26 34.25 270 bottom
RB482  4.7K  [RC0402]  162.55 35.27 90 bottom
RB483  4.7K  [RC0402]  160.26 33.24 270 bottom
RB484  4.7K  [RC0402]  174.51 34.25 270 bottom
RB485  4.7K  [RC0402]  176.8 35.27 90 bottom
RB486  4.7K  [RC0402]  174.51 33.24 270 bottom
RB487  4.7K  [RC0402]  188.76 34.25 270 bottom
RB488  4.7K  [RC0402]  191.05 35.27 90 bottom
RB489  4.7K  [RC0402]  188.76 33.24 270 bottom
RB490  4.7K  [RC0402]  29.75 35.27 270 bottom
RB491  4.7K  [RC0402]  32.03 35.27 90 bottom
RB492  4.7K  [RC0402]  34.45 35.27 90 bottom
RB493  4.7K  [RC0402]  44.21 35.27 270 bottom
RB494  4.7K  [RC0402]  46.5 35.27 90 bottom
RB495  4.7K  [RC0402]  48.91 35.27 90 bottom
RB496  4.7K  [RC0402]  117.51 34.25 270 bottom
RB497  4.7K  [RC0402]  119.8 35.27 90 bottom
RB498  4.7K  [RC0402]  117.51 33.24 270 bottom
RB499  4.7K  [RC0402]  131.76 34.25 270 bottom
RB500  4.7K  [RC0402]  134.05 35.27 90 bottom
RB501  4.7K  [RC0402]  131.76 33.24 270 bottom
RB502  4.7K  [RC0402]  146.01 34.25 270 bottom
RB503  4.7K  [RC0402]  148.3 35.27 90 bottom
RB504  4.7K  [RC0402]  146.01 33.24 270 bottom
RB505  4.7K  [RC0402]  58.46 36.29 270 bottom
RB506  4.7K  [RC0402]  60.75 34.25 90 bottom
RB507  4.7K  [RC0402]  63.16 36.29 90 bottom
RB508  4.7K  [RC0402]  72.71 36.29 270 bottom
RB509  4.7K  [RC0402]  75 34.25 90 bottom
RB510  4.7K  [RC0402]  77.41 36.29 90 bottom
RB511  4.7K  [RC0402]  86.96 36.29 270 bottom
RB512  4.7K  [RC0402]  89.25 34.25 90 bottom
RB513  4.7K  [RC0402]  91.66 36.29 90 bottom
RB514  4.7K  [RC0402]  101.21 36.29 270 bottom
RB515  4.7K  [RC0402]  103.5 34.25 90 bottom
RB516  4.7K  [RC0402]  105.91 36.29 90 bottom
RB517  4.7K  [RC0402]  160.26 36.29 270 bottom
RB518  4.7K  [RC0402]  162.55 34.25 90 bottom
RB519  4.7K  [RC0402]  164.96 36.29 90 bottom
RB520  4.7K  [RC0402]  174.51 36.29 270 bottom
RB521  4.7K  [RC0402]  176.8 34.25 90 bottom
RB522  4.7K  [RC0402]  179.21 36.29 90 bottom
RB523  4.7K  [RC0402]  188.76 36.29 270 bottom
RB524  4.7K  [RC0402]  191.05 34.25 90 bottom
RB525  4.7K  [RC0402]  193.46 36.29 90 bottom
RB526  4.7K  [RC0402]  29.75 34.25 270 bottom
RB527  4.7K  [RC0402]  32.03 34.25 90 bottom
RB528  4.7K  [RC0402]  34.45 34.25 90 bottom
RB529  4.7K  [RC0402]  44.21 34.25 270 bottom
RB530  4.7K  [RC0402]  46.5 34.25 90 bottom
RB531  4.7K  [RC0402]  48.91 34.25 90 bottom
RB532  4.7K  [RC0402]  117.51 36.29 270 bottom
RB533  4.7K  [RC0402]  119.8 34.25 90 bottom
RB534  4.7K  [RC0402]  122.21 36.29 90 bottom
RB535  4.7K  [RC0402]  131.76 36.29 270 bottom
RB536  4.7K  [RC0402]  134.05 34.25 90 bottom
RB537  4.7K  [RC0402]  136.46 36.29 90 bottom
RB538  4.7K  [RC0402]  146.01 36.29 270 bottom
RB539  4.7K  [RC0402]  148.3 34.25 90 bottom
RB540  4.7K  [RC0402]  150.71 36.29 90 bottom
RB541  4.7K  [RC0402]  60.75 33.24 90 bottom
RB542  4.7K  [RC0402]  58.46 35.27 270 bottom
RB543  4.7K  [RC0402]  60.75 36.29 90 bottom
RB544  4.7K  [RC0402]  75 33.24 90 bottom
RB545  4.7K  [RC0402]  72.71 35.27 270 bottom
RB546  4.7K  [RC0402]  75 36.29 90 bottom
RB547  4.7K  [RC0402]  89.25 33.24 90 bottom
RB548  4.7K  [RC0402]  86.96 35.27 270 bottom
RB549  4.7K  [RC0402]  89.25 36.29 90 bottom
RB550  4.7K  [RC0402]  103.5 33.24 90 bottom
RB551  4.7K  [RC0402]  101.21 35.27 270 bottom
RB552  4.7K  [RC0402]  103.5 36.29 90 bottom
RB553  4.7K  [RC0402]  162.55 33.24 90 bottom
RB554  4.7K  [RC0402]  160.26 35.27 270 bottom
RB555  4.7K  [RC0402]  162.55 36.29 90 bottom
RB556  4.7K  [RC0402]  176.8 33.24 90 bottom
RB557  4.7K  [RC0402]  174.51 35.27 270 bottom
RB558  4.7K  [RC0402]  176.8 36.29 90 bottom
RB559  4.7K  [RC0402]  191.05 33.24 90 bottom
RB560  4.7K  [RC0402]  188.76 35.27 270 bottom
RB561  4.7K  [RC0402]  191.05 36.29 90 bottom
RB562  4.7K  [RC0402]  29.75 33.24 270 bottom
RB563  4.7K  [RC0402]  32.03 33.24 90 bottom
RB564  4.7K  [RC0402]  34.45 33.24 90 bottom
RB565  4.7K  [RC0402]  44.21 33.24 270 bottom
RB566  4.7K  [RC0402]  46.5 33.24 90 bottom
RB567  4.7K  [RC0402]  48.91 33.24 90 bottom
RB568  4.7K  [RC0402]  119.8 33.24 90 bottom
RB569  4.7K  [RC0402]  117.51 35.27 270 bottom
RB570  4.7K  [RC0402]  119.8 36.29 90 bottom
RB571  4.7K  [RC0402]  134.05 33.24 90 bottom
RB572  4.7K  [RC0402]  131.76 35.27 270 bottom
RB573  4.7K  [RC0402]  134.05 36.29 90 bottom
RB574  4.7K  [RC0402]  148.3 33.24 90 bottom
RB575  4.7K  [RC0402]  146.01 35.27 270 bottom
RB576  4.7K  [RC0402]  148.3 36.29 90 bottom
RB577  4.7K  [RC0402]  73.23 31.99 90 bottom
RB578  33  [RC0402]  75.52 31.99 90 bottom
RB579  33  [RC0402]  117.45 31.97 270 bottom
RB580  4.7K  [RC0402]  119.99 31.97 270 bottom
RB581  4.7K  [RC0402]  146.53 31.99 90 bottom
RB582  33  [RC0402]  148.82 31.99 90 bottom
RB583  33  [RC0402]  44.15 31.97 270 bottom
RB584  4.7K  [RC0402]  46.69 31.97 270 bottom
RB586  4.7K  [RC0402]  73.23 30.85 90 bottom
RB587  33  [RC0402]  75.52 30.85 90 bottom
RB588  33  [RC0402]  117.45 30.83 270 bottom
RB589  4.7K  [RC0402]  119.99 30.83 270 bottom
RB590  4.7K  [RC0402]  146.53 30.85 90 bottom
RB591  33  [RC0402]  148.82 30.85 90 bottom
RB592  33  [RC0402]  44.15 30.83 270 bottom
RB593  4.7K  [RC0402]  46.69 30.83 270 bottom
RB594  4.7K  [RC0402]  73.23 29.71 90 bottom
RB595  33  [RC0402]  75.52 29.71 90 bottom
RB596  33  [RC0402]  117.45 29.68 270 bottom
RB597  4.7K  [RC0402]  119.99 29.68 270 bottom
RB598  4.7K  [RC0402]  146.53 29.71 90 bottom
RB599  33  [RC0402]  148.82 29.71 90 bottom
RB600  33  [RC0402]  44.15 29.68 270 bottom
RB601  4.7K  [RC0402]  46.69 29.68 270 bottom
RB602  4.7K  [RC0402]  73.23 28.57 90 bottom
RB603  33  [RC0402]  75.52 28.57 90 bottom
RB605  33  [RC0402]  117.45 28.54 270 bottom
RB606  4.7K  [RC0402]  119.99 28.54 270 bottom
RB607  4.7K  [RC0402]  146.53 28.57 90 bottom
RB608  33  [RC0402]  148.82 28.57 90 bottom
RB609  33  [RC0402]  44.15 28.54 270 bottom
RB610  4.7K  [RC0402]  46.69 28.54 270 bottom
RB611  4.7K  [RC0402]  73.23 27.42 90 bottom
RB612  33  [RC0402]  75.52 27.42 90 bottom
RB613  33  [RC0402]  117.45 27.4 270 bottom
RB614  4.7K  [RC0402]  119.99 27.4 270 bottom
RB615  4.7K  [RC0402]  146.53 27.42 90 bottom
RB616  33  [RC0402]  148.82 27.42 90 bottom
RB622  33  [RC0402]  44.15 27.4 270 bottom
RB623  4.7K  [RC0402]  46.69 27.4 270 bottom
RB624  4.7K  [RC0402]  73.23 26.28 90 bottom
RB625  33  [RC0402]  75.52 26.28 90 bottom
RB626  33  [RC0402]  117.45 26.25 270 bottom
RB627  4.7K  [RC0402]  119.99 26.25 270 bottom
RB628  4.7K  [RC0402]  146.53 26.28 90 bottom
RB629  33  [RC0402]  148.82 26.28 90 bottom
RB630  33  [RC0402]  44.15 26.25 270 bottom
RB631  4.7K  [RC0402]  46.69 26.25 270 bottom
RB632  4.7K  [RC0402]  73.23 25.14 90 bottom
RB633  33  [RC0402]  75.52 25.14 90 bottom
RB634  33  [RC0402]  117.45 25.11 270 bottom
RB635  4.7K  [RC0402]  119.99 25.11 270 bottom
RB636  4.7K  [RC0402]  146.53 25.14 90 bottom
RB637  33  [RC0402]  148.82 25.14 90 bottom
RB640  33  [RC0402]  44.15 25.11 270 bottom
RB641  4.7K  [RC0402]  46.69 25.11 270 bottom
RB642  @0  [RC0805]  86.6 28.04 0 bottom
RB643  4.7K  [RC0402]  73.23 23.99 90 bottom
RB644  33  [RC0402]  75.52 23.99 90 bottom
RB645  33  [RC0402]  117.45 23.97 270 bottom
RB646  4.7K  [RC0402]  119.99 23.97 270 bottom
RB647  4.7K  [RC0402]  146.53 23.99 90 bottom
RB648  33  [RC0402]  148.82 23.99 90 bottom
RB650  33  [RC0402]  44.15 23.97 270 bottom
RB651  4.7K  [RC0402]  46.69 23.97 270 bottom
RB652  0  [RC0805]  87.6 25.12 90 bottom
RB653  4.7K  [RC0402]  73.23 22.85 270 bottom
RB654  @4.7K  [RC0402]  75.52 22.85 90 bottom
RB655  33  [RC0402]  160.22 18.2 270 bottom
RB656  4.7K  [RC0402]  162.76 18.2 270 bottom
RB657  4.7K  [RC0402]  146.53 22.85 270 bottom
RB658  @4.7K  [RC0402]  148.82 22.85 90 bottom
RB659  100K  [RC0402]  101.03 28.79 90 bottom
RB660  @4.7K  [RC0402]  44.15 22.82 270 bottom
RB661  4.7K  [RC0402]  46.69 22.82 90 bottom
RB662  150  [RC0402]  244.38 8.93 0 bottom
RB663  4.7K  [RC0402]  119.99 22.82 90 bottom
RB664  @4.7K  [RC0402]  117.45 22.82 270 bottom
RB665  33  [RC0402]  160.22 17.06 270 bottom
RB666  4.7K  [RC0402]  162.76 17.06 270 bottom
RB667  12.7k  [RC0402]  100.52 27.26 0 bottom
RB668  12.7k  [RC0402]  101.53 27.26 180 bottom
RB669  150  [RC0402]  241.33 8.93 0 bottom
RB670  @4.7K  [RC0402]  44.15 21.68 270 bottom
RB671  4.7K  [RC0402]  46.69 21.68 90 bottom
RB672  @4.7K  [RC0402]  117.44 21.69 90 bottom
RB673  4.7K  [RC0402]  119.98 21.68 270 bottom
RB674  33  [RC0402]  171.29 248.07 270 top
RB675  4.7K  [RC0402]  173.76 248.07 270 top
RB676  33  [RC0402]  160.22 15.92 270 bottom
RB677  4.7K  [RC0402]  162.76 15.92 270 bottom
RB678  150  [RC0402]  249.71 8.93 0 bottom
RB679  33  [RC0402]  191.59 18.23 90 bottom
RB680  33  [RC0402]  171.29 246.99 270 top
RB681  4.7K  [RC0402]  173.76 246.99 270 top
RB682  33  [RC0402]  160.22 14.77 270 bottom
RB683  4.7K  [RC0402]  162.76 14.77 270 bottom
RB685  15K  [RC0402]  88.89 20.32 270 bottom
RB686  15K  [RC0402]  90.8 20.32 270 bottom
RB688  150  [RC0402]  246.66 8.93 0 bottom
RB689  4.7K  [RC0402]  189.3 18.23 90 bottom
RB690  33  [RC0402]  171.29 245.91 270 top
RB691  4.7K  [RC0402]  173.76 245.91 270 top
RB692  0  [RC0402]  158.18 12.9 270 bottom
RB693  33  [RC0402]  160.22 13.63 270 bottom
RB694  4.7K  [RC0402]  162.76 13.63 270 bottom
RB697  4.7K  [RC0402]  189.18 16.64 90 bottom
RB699  33  [RC0402]  171.29 244.83 270 top
RB700  4.7K  [RC0402]  173.76 244.83 270 top
RB701  33  [RC0402]  160.22 12.49 270 bottom
RB702  4.7K  [RC0402]  162.76 12.49 270 bottom
RB703  33  [RC0402]  191.46 16.64 90 bottom
RB704  33  [RC0402]  171.29 243.75 270 top
RB705  4.7K  [RC0402]  173.76 243.75 270 top
RB706  33  [RC0402]  160.22 11.34 270 bottom
RB707  4.7K  [RC0402]  162.76 11.34 270 bottom
RB708  @4.7K  [RC0402]  189.17 12.49 270 bottom
RB710  33  [RC0402]  171.29 242.67 270 top
RB711  4.7K  [RC0402]  173.76 242.67 270 top
RB712  33  [RC0402]  160.22 10.2 270 bottom
RB713  4.7K  [RC0402]  162.76 10.2 270 bottom
RB714  4.7K  [RC0402]  191.46 12.49 90 bottom
RB718  @33  [RC0402]  171.29 241.59 270 top
RB719  4.7K  [RC0402]  173.76 241.59 270 top
RB720  0  [RC0402]  158.18 10.87 270 bottom
RB721  33  [RC0402]  189.2 11.1 270 bottom
RB722  150  [RC0402]  121.19 208.76 270 top
RB723  150  [RC0402]  47.4 10.83 0 bottom
RB724  @33  [RC0402]  171.29 240.45 270 top
RB725  4.7K  [RC0402]  173.76 240.45 270 top
RB727  4.7K  [RC0402]  82.26 206.09 0 top
RB728  4.7K  [RC0402]  171.26 238.29 90 top
RB729  @4.7K  [RC0402]  173.76 238.29 270 top
RB730  4.7K  [RC0402]  158.72 241.53 90 top
RB731  0  [RC0402]  158.72 240.51 270 top
RB732  150  [RC0402]  121.2 218.89 270 top
RB733  150  [RC0402]  60.29 10.83 0 bottom
RB734  150  [RC0402]  96.99 236.38 0 top
RB735  150  [RC0402]  35.85 10.83 0 bottom
RB736  150  [RC0402]  43.27 10.83 0 bottom
RB737  150  [RC0402]  45.37 10.83 0 bottom
RB738  150  [RC0402]  62.33 10.83 0 bottom
RB739  4.7K  [RC0402]  171.29 239.37 90 top
RB740  @4.7K  [RC0402]  173.76 239.37 270 top
RB741  @4.7K  [RC0402]  158.72 242.54 270 top
RB742  4.7K  [RC0402]  160.26 7.95 270 bottom
RB743  @4.7K  [RC0402]  160.24 9.04 270 bottom
RB744  4.7K  [RC0402]  12.28 214.41 90 top
RB745  @4.7K  [RC0402]  162.78 7.95 90 bottom
RB746  4.7K  [RC0402]  162.75 9.09 90 bottom
RB758  4.7K  [RC0402]  228.92 120.79 180 bottom
RB759  4.7K  [RC0402]  220.6 120.04 270 top
RB760  @4.7K  [RC0402]  220.6 120.04 90 bottom
RB761  0  [RC0402]  220.6 119.02 270 top
RB766  @0  [RC0402]  222.7 223.76 90 top
RB1199  0  [RC0402]  174.46 229.33 270 top
RB1200  0  [RC0402]  174.44 228.27 270 top
RB1201  0  [RC0402]  177.12 227.84 270 top
RB1203  0  [RC0402]  177.13 226.8 270 top
RB1204  0  [RC0402]  174.44 226.28 270 top
RB1205  0  [RC0402]  177.13 225.78 270 top
RB1206  0  [RC0402]  177.13 221.71 270 top
RB1208  0  [RC0402]  177.13 220.7 270 top
RB1209  0  [RC0402]  177.13 218.67 270 top
RB1210  0  [RC0402]  174.46 232.38 90 top
RB1211  0  [RC0402]  180.55 211.49 180 top
RB1212  0  [RC0402]  182.63 211.49 180 top
RB1213  0  [RC0402]  190.71 211.46 0 top
RB1214  0  [RC0402]  189.7 211.46 0 top
RB1215  0  [RC0402]  191.73 211.46 0 top
RB1216  0  [RC0402]  197.76 235.58 180 top
RB1217  0  [RC0402]  195.72 235.53 180 top
RB1218  0  [RC0402]  190.52 235.56 180 top
RB1219  0  [RC0402]  187.39 235.56 180 top
RB1220  0  [RC0402]  196.74 235.56 0 top
RB1221  0  [RC0402]  183.32 235.57 0 top
RB1222  33  [RC0402]  21.2 58.87 180 bottom
RB1223  4.7K  [RC0402]  20.2 58.86 180 bottom
RB1224  4.7K  [RC0402]  17.97 48 270 bottom
RB1225  4.7K  [RC0402]  17.98 49.04 270 bottom
RB1226  100ohm  [RC0402]  9.18 47.49 180 bottom
RB1227  4.7K  [RC0402]  19.18 58.83 0 bottom
RB1228  @4.7K  [RC0402]  90.87 236.38 180 top
RB1229  4.7K  [RC0402]  151.02 150.31 180 bottom
RB1230  4.7K  [RC0402]  150 150.31 180 bottom
RB1231  4.7K  [RC0402]  159.1 147.93 180 bottom
RB1232  4.7K  [RC0402]  160.11 147.93 180 bottom
RB1233  @1K  [RC0402]  169.71 145.53 180 bottom
RB1234  @4.7K  [RC0402]  167.57 147.98 0 bottom
RB1235  @4.7K  [RC0402]  168.58 147.98 0 bottom
RB1236  0ohm  [RC0603]  225.55 32.96 180 bottom
RB1237  0ohm  [RC0603]  227.08 32.96 180 bottom
RB1238  0ohm  [RC0603]  227.09 32.95 0 top
RB1239  0ohm  [RC0603]  225.54 32.95 0 top
RB1240  100  [RC0402]  226.3 30.92 90 bottom
RB1241  100  [RC0402]  226.3 30.92 270 top
RB1242  33  [RC0402]  191.46 13.85 90 bottom
RB1243  33  [RC0402]  191.46 15.18 90 bottom
RB1244  4.7K  [RC0402]  189.18 13.85 90 bottom
RB1245  4.7K  [RC0402]  189.18 15.18 90 bottom
RB1246  100  [RC0402]  217.36 13.55 0 bottom
RB1247  0ohm  [RC0603]  215.37 14.31 270 bottom
RB1248  0ohm  [RC0603]  215.36 12.89 270 bottom
RB1249  0ohm  [RC0603]  215.37 22.68 270 bottom
RB1250  0ohm  [RC0603]  215.37 21.23 270 bottom
RB1251  100  [RC0402]  217.42 21.97 180 bottom
RB1252  2K(1%)  [RC0402]  121.19 206.41 270 top
RB1256  1K  [RC0603]  161.57 185.65 90 top
RB1259  0  [RC0402]  161.15 175.83 90 top
RB1260  0  [RC0402]  161.13 177.9 90 top
RB1261  33  [RC0402]  161.09 173.73 270 top
RB1262  0  [RC0402]  161.09 169.67 90 top
RB1263  0  [RC0402]  161.09 170.69 90 top
RB1264  0  [RC0402]  161.09 171.7 90 top
RB1265  0  [RC0402]  161.09 172.72 90 top
RB1266  @1K  [RC0603]  140.05 212.82 0 top
RB1267  1K  [RC0603]  141.57 212.82 180 top
RB1268  @1K  [RC0603]  138.52 212.82 0 top
RB1269  1K  [RC0603]  137 212.82 180 top
RB1271  0  [RC0402]  161.06 168.63 90 top
RB1272  33  [RC0402]  153.58 169.53 180 top
RB1274  1K  [RC0603]  152.24 186.79 0 top
RB1275  1K  [RC0603]  153.76 186.79 0 top
RB1276  33  [RC0402]  123.54 210.73 90 top
RB1277  33  [RC0402]  123.54 209.71 90 top
RB1278  33  [RC0402]  148.81 186.27 0 top
RB1279  33  [RC0402]  154.65 169.71 0 bottom
RB1280  33  [RC0402]  126.65 211.68 270 top
RB1281  33  [RC0402]  123.51 216.86 90 top
RB1282  0  [RC0402]  121.17 210.74 90 top
RB1283  0  [RC0402]  121.17 209.75 90 top
RB1284  @0  [RC0402]  126.65 212.7 90 top
RB1285  @0  [RC0402]  121.17 216.86 90 top
RB1286  0  [RC0402]  121.22 226.4 270 top
RB1287  0  [RC0402]  121.2 227.51 270 top
RB1288  4.7K  [RC0402]  63.59 216.51 270 top
RB1289  4.7K  [RC0402]  63.59 214.48 270 top
RB1290  4.7K  [RC0402]  74.07 205.59 90 top
RB1291  @4.7K  [RC0402]  102.26 204.38 180 bottom
RB1292  @4.7K  [RC0402]  94.14 204.38 0 top
RB1293  150  [RC0402]  72.67 10.83 0 bottom
RB1294  150  [RC0402]  70.64 10.83 0 bottom
RB1295  @1K  [RC0603]  161.57 187.11 90 top
RB1296  0  [RC0402]  255.31 204.28 270 top
RB1297  0  [RC0402]  255.31 203.27 270 top
RB1298  0  [RC0402]  255.31 201.23 270 top
RB1299  0  [RC0402]  255.31 202.25 90 top
RB1300  4.7K  [RC0402]  142.71 137.64 180 bottom
RB1301  4.7K  [RC0402]  147.79 137.07 180 bottom
RB1302  4.7K  [RC0402]  171.28 146.41 0 bottom
RB1303  4.7K  [RC0402]  156.49 147.23 0 bottom
RB1304  @0  [RC0402]  237.02 149.73 270 top
RB1305  1K  [RC0402]  123.54 219.94 270 top
RB1306  1K  [RC0402]  123.54 220.95 270 top
RB1307  1K  [RC0402]  111.41 204.38 0 top
RB1308  1K  [RC0402]  111.92 202.54 270 top
RJ1  TE 5569256-1 RJ45_2X3  [RJ45_2X3X8DP_45D21W28D45L]  224.98 7.99 0 top
SW1  SW_3  [SW_4D5X8D3_4SP_6WL4D3H]  257.33 190.45 90 top
SWB1  SW_34GND  [SW_5DX7D5X4D1_4SP_7W]  103.56 6.15 0 bottom
SWB2  SW_3  [SW_PUSH_3D75X1D5_4SP_3D5W3D6L]  8.15 212.5 270 top
TP1  @NCA  [TP_30C0D0C_OSP]  32.1 88.36 0 top
TP2  @NCA  [TP_30C0D0C_OSP]  33.49 88.36 0 top
TP49  @NCA  [TP_30C0D0C_OSP]  224.66 115.57 180 bottom
TP50  @NCA  [TP_30C0D0C_OSP]  235.59 115.57 180 bottom
TP51  @NCA  [TP_30C0D0C_OSP]  221.05 116.1 180 bottom
TP52  @NCA  [TP_30C0D0C_OSP]  153.37 165.63 180 bottom
TPB7  @NCA  [TP_30C0D0C_OSP]  199.95 230.02 0 bottom
TPB26  @NCA  [TP_30C0D0C_OSP]  28.2 135.36 180 bottom
TPB27  @NCA  [TP_30C0D0C_OSP]  47.09 138.43 180 bottom
TPB28  @NCA  [TP_30C0D0C_OSP]  34.85 139.52 180 bottom
TPB29  @NCA  [TP_30C0D0C_OSP]  36.68 138.35 180 bottom
TPB30  @NCA  [TP_30C0D0C_OSP]  59.27 126.21 180 bottom
TPB31  @NCA  [TP_30C0D0C_OSP]  40.21 137.26 180 bottom
TPB32  @NCA  [TP_30C0D0C_OSP]  16.41 123.11 180 bottom
TPB33  @NCA  [TP_30C0D0C_OSP]  21.84 123.83 180 bottom
TPB34  @NCA  [TP_30C0D0C_OSP]  18.36 125.22 180 bottom
TPB35  @NCA  [TP_30C0D0C_OSP]  19.63 123.8 180 bottom
TPB36  @NCA  [TP_30C0D0C_OSP]  59.28 122.05 180 bottom
TPB37  @NCA  [TP_30C0D0C_OSP]  18.52 122.12 180 bottom
TPB38  @NCA  [TP_30C0D0C_OSP]  115.15 120.75 180 bottom
TPB39  @NCA  [TP_30C0D0C_OSP]  19.84 120.43 180 bottom
TPB40  @NCA  [TP_30C0D0C_OSP]  18.8 118.75 180 bottom
TPB41  @NCA  [TP_30C0D0C_OSP]  42 95.22 180 bottom
TPB42  @NCA  [TP_30C0D0C_OSP]  36.54 94.54 180 bottom
TPB43  @NCA  [TP_30C0D0C_OSP]  30.45 175.36 180 bottom
TPB44  @NCA  [TP_30C0D0C_OSP]  43.02 168.12 180 bottom
TPB45  @NCA  [TP_30C0D0C_OSP]  60.42 168.37 180 bottom
TPB46  @NCA  [TP_30C0D0C_OSP]  49.37 169.26 180 bottom
TPB47  @NCA  [TP_30C0D0C_OSP]  94.45 172.31 180 bottom
TPB48  @NCA  [TP_30C0D0C_OSP]  78.2 171.68 180 bottom
U5  TTL_FAIRCHILD_NC7SZ08  [SOT23_D95X2D6_5SP_2D9W1D6L]  164.81 180.31 180 top
U6  DC_DC_TI_TPS51200  [QFN_D5X2D95_11SP_3D15WL]  66.5 186.87 0 top
U7  UCD90160RGCR  [QFN_D5X9D_64SP_9WL1H_G1_4D25SQ]  230.83 219.49 270 top
U8  256K  [SOIC_1D27X5D16_8SP_5D1L]  148.55 242.31 0 top
U9  5M2210ZF324I5N  [FBGA_1D_20C_324SP_19WL1D55H]  198.55 190.58 0 top
U10  PCA9548APWRG4  [TSSOP_D65X5D775_24SP_4D4W7D8L]  156.57 223.91 270 top
U14  4Gb  [BGA_D8_18C_96SP_7D5W13L1D2H]  54.96 164.82 180 top
U15  4Gb  [BGA_D8_18C_96SP_7D5W13L1D2H]  65.5 164.82 180 top
U16  4Gb  [BGA_D8_18C_96SP_7D5W13L1D2H]  85.94 164.82 180 top
U17  4Gb  [BGA_D8_18C_96SP_7D5W13L1D2H]  96.49 164.82 180 top
U18  LM75BD  [SO8_1D27X5D3_8SP_3D9W4D9L]  5.95 160.87 270 top
U19  NC7SB3157P6X  [SC70_D65X1D9_6SP_1D25W2LD95H_1]  183.18 179.66 0 top
U20  SN74LVC244ADBR  [SSOP20]  216.07 239.73 270 top
U21  SN74CBTLV3257PWR  [TSSOP_D65X5D775_16SP_4D4W5L1D2H]  239.65 239.21 0 top
U22  SN74LVC2G32DCUR  [US8_D5X2D8_8SP_2D1W2D4L]  184.17 176 0 top
U23  TPS74401RGWT  [QFN_D65X5D_20SP_5WL_G1]  117.92 139.94 90 top
U24  USB2514B-I/M2  [QFN_D5X6D_36SP_6WL1H_G1]  206.86 126.32 90 top
U27  LM75BD  [SO8_1D27X5D3_8SP_3D9W4D9L]  79.98 145.9 0 top
U29  LM75BD  [SO8_1D27X5D3_8SP_3D9W4D9L]  134.59 207.93 0 top
U30  CSD95372BVQP  [QFN_D5_13SP_5W6L]  98.26 131.93 180 top
U31  TPS53219ARGTR  [QFN_D5X3D_16SP_3WL1H]  165.22 129.26 270 top
U32  TPS53314RGFR  [QFN_D5_40SP_7W5L1DH_G1]  40.62 188.3 0 top
U33  TPS53647RTAT  [QFN_D5X6D_40SP_6WL_G1_4D1SQ]  112.61 125.58 0 top
U34  TPS54329DDAR  [SOP_1D27X5D165_8SP_3D9W_G95X130]  249.38 162.58 180 top
U35  TPS53314RGFR  [QFN_D5_40SP_7W5L1DH_G1]  119.5 174.16 270 top
U36  AP7362-SP-13  [SOP_1D27X5D28_8SP_3D9W4D9L_G1]  229.43 143.4 0 bottom
U37  2304NZLPGGI8  [TSSOP_D65X5D775_8SP_3L]  242.61 117.38 90 top
U38  CSD87384M  [MOS_1D358X1D7545_5SP_5W3D5L]  164.84 117.06 180 top
U39  CSD95372BVQP  [QFN_D5_13SP_5W6L]  98.26 116.18 180 top
U40  BCM88470CB0IFSBG  [BGA_1D_20C_1365SP_37D5WL]  39.2 116.15 180 top
U41  CSD87384M  [MOS_1D358X1D7545_5SP_5W3D5L]  158.52 105.31 270 top
U42  CSD87384M  [MOS_1D358X1D7545_5SP_5W3D5L]  169.95 105.31 270 top
U44  TPS53315RGFR  [QFN_D5_40SP_7W5L1DH_G1]  113.63 103.48 180 top
U47  TPS74801RGWR  [QFN_D65X5D_20SP_5WL_G1]  95.09 98.65 270 top
U48  TPS53219ARGTR  [QFN_D5X3D_16SP_3WL1H]  151.15 97.69 0 top
U50  TVS_SRDA05-4  [SO8_1D27X5D2_8SP_3D9W4D9L]  240.23 71.83 0 top
U51  SN65C1167EPWR  [TSSOP_D65X5D775_16SP_4D4W5L1D2H]  242.11 85.89 90 top
U52  88E1111-B2-BAB1I000  [BGA_1D_18C_117SP_10W14L1D54H]  229.68 123.15 0 top
U53  1:1/1:2  [XFMR_1D27X8D76_16SP_12D7L]  240.4 59.99 270 top
U54  CDNBS08-SLVU2.8-8  [SOP_1D27X5D24_8SP_5L]  251.34 52.96 90 bottom
U55  AZ3133-08F  [QFN_D6_D65X2D_10SP_2W3LD65H]  250.84 97.23 270 top
U56  AZ3133-08F  [QFN_D6_D65X2D_10SP_2W3LD65H]  256.23 97.23 270 top
U59  47uH  [FILTER_2D54X7D5_4SP_6W9D2L5H]  238.15 46.31 270 top
U60  47uH  [FILTER_2D54X7D5_4SP_6W9D2L5H]  245.09 46.31 270 top
U62  CDNBS08-SLVU2.8-8  [SOP_1D27X5D24_8SP_5L]  253.69 90.75 180 bottom
U66  TPS73701DRBR  [QFN_D65X2D95_8SP_3WL1H_G1]  231.63 135.99 180 top
U68  XRT86VL30IV80-F  [TQFP_D5X13D4_80SP_12WL]  187.38 225.32 180 top
U69  QSFP_FEMALE_1X1P_SMD38  [MT_RJ_D8_38SP_18D2W12D5L]  12.24 54.05 0 top
U70  UTG24C14Q  [XFMR_1D27X14D46_24SP_17D55W]  257.75 76.6 180 top
U71  FT2232HL  [QFP_D5X11D4_64SP_10WL1D6H]  232.7 192.73 90 top
U72  TPM_SLB 9665XT2.0 FW5.63  [TSSOP_D65X5D8_28SP_4D4W9D7L1D2H]  225.37 166.9 270 top
U73  AZ3133-08F  [QFN_D6_D65X2D_10SP_2W3LD65H]  225.66 105.91 90 top
U74  CDNBS08-SLVU2.8-8  [SOP_1D27X5D24_8SP_5L]  222.37 99.06 90 bottom
U75  AZ3133-08F  [QFN_D6_D65X2D_10SP_2W3LD65H]  233.33 106.06 90 top
U76  UTG24C14Q  [XFMR_1D27X14D46_24SP_17D55W]  227.88 86.07 180 top
U77  ZL30773  [QFN_D5X11D_80SP_11WL_G1_275SQ]  151.92 178.17 180 top
U79  CDCLVP1204RGTT  [QFN_D5_16SP_4WL]  103.81 180.42 90 top
U80  128Mb  [SOP_1D27X9D5_16SP_10D31W7D49L]  71.59 212 0 top
U81  OTERDLLTNF-100M  [OSC_2D54X4D2_6SP_7W5L1D55H]  41.49 212.88 180 top
U85  SN65MLVD200A  [SOIC_1D27X5D165_8SP_3D9W4D9L]  207.54 22.02 0 bottom
U86  SN65MLVD200A  [SOIC_1D27X5D165_8SP_3D9W4D9L]  207.48 13.43 0 bottom
U87  SN65MLVD200A  [SOIC_1D27X5D165_8SP_3D9W4D9L]  226.58 40.07 180 top
U88  SN65MLVD200A  [SOIC_1D27X5D165_8SP_3D9W4D9L]  226.57 40.07 180 bottom
UB1  8V43N104NLGI8  [QFN_D5X5D_32SP_5WL1H_G1]  84.96 188.91 0 top
UB2  TTL_FAIRCHILD_NC7SZ08  [SOT23_D95X2D6_5SP_2D9W1D6L]  164.81 175.55 180 top
UB5  4Gb  [BGA_D8_18C_96SP_7D5W13L1D2H]  22.83 164.69 0 bottom
UB6  4Gb  [BGA_D8_18C_96SP_7D5W13L1D2H]  33.37 164.69 0 bottom
UB8  PCA9548APWRG4  [TSSOP_D65X5D775_24SP_4D4W7D8L]  175.95 27.4 0 bottom
UB9  RS3232EIPWR  [TSSOP_D65X5D775_16SP_4D4W5L1D2H]  242.93 153.58 180 bottom
UB10  TVS_SEMTECH_LC04-6  [SOIC_1D27X5D3_16SP_10L]  241.25 46.9 90 bottom
UB12  PCA9548APWRG4  [TSSOP_D65X5D775_24SP_4D4W7D8L]  133.2 27.4 0 bottom
UB13  PCA9548APWRG4  [TSSOP_D65X5D775_24SP_4D4W7D8L]  59.9 27.4 0 bottom
UB14  TPS2553DRVR  [QFN_D65X2D1_6SP_2WLD8H]  104.46 27.26 90 bottom
UB16  PCA9548APWRG4  [TSSOP_D65X5D775_24SP_4D4W7D8L]  165.12 243.06 180 top
UB17  PCA9548APWRG4  [TSSOP_D65X5D775_24SP_4D4W7D8L]  175.97 13.63 0 bottom
UB70  SN74LV1T34DBV  [SOT23_D95X2D35_5SP_1D6W2D9L]  242.88 96.61 270 top
UB71  SN74LV1T34DBV  [SOT23_D95X2D35_5SP_1D6W2D9L]  238.09 159.38 90 top
X1  24MHz  [OSC_1D6X1D63_4SP_2D05W2D55L]  196.98 125.81 270 top

## Library data of the parts
C2-C4 C7-C9 C23 C24 C27 C28 C30 C33 C34 C38 C39 C47 C55 C57 C60 C69 C73 C76 C80 C81 C86 C91 C92 C95 C96 C102 C113 C121 C129 C133 C134 C142 C144 C149 C161 C168 C175 C178 C194 C205 C206 C209 C210 C212 C214 C215 C217-C220 C231 C247 C248 C250 C259 C260 C263 C264 C280 C283 C303-C305 C312 C313 C321 C322 C332 C339 C341-C345 C347 C348 C355 C377 C382 C401 C402 C404 C406 C413 C415 C417 C420-C424 C432 C435 C436 C439 C448 C449 C451 C481 C484-C486 C516 C521 C523 C524 C529 C542 C544-C566 C569-C571 C574-C576 C638-C646 C671-C694 C724 C725 C735-C739 C904 C905 C908 C909 CB2 CB5 CB27 CB32 CB34 CB42 CB43 CB53 CB54 CB56 CB57 CB65 CB66 CB69 CB70 CB76 CB77 CB79 CB82 CB83 CB122 CB125 CB134 CB159 CB160 CB195 CB198 CB201-CB203 CB205 CB218 CB229 CB230 CB233 CB243 CB244 CB247 CB254 CB257 CB260 CB262 CB265 CB267 CB277 CB280 CB282 CB286 CB294 CB295 CB308 CB341-CB345 CB348 CB383 CB400 CB441 CB455 CB487 CB494 CB511 CB522 CB527 CB528 CB564 CB575 CB586 CB607 CB757 CB796 CB799-CB801 CB806-CB822 CB827-CB829 CB858-CB881 CB883 CB898-CB903 CB908 CB909 CB914 CB919-CB923 CB937 CB949 CB951 CB952 CB957 CB962 CB973 CB975 CB1059-CB1062 = C_NP: signal model: C_NP_CC0402_0.1UF/16V_0.1uF/16V
C16-C22 C29 C31 C32 C35-C37 C41 C43 C45 C48-C50 C52-C54 C56 C61-C63 C68 C74 C75 C77-C79 C82-C85 C87-C90 C93 C94 C99 C100 C104 C106-C110 C114 C117-C119 C122 C123 C126 C128 C130 C132 C135 C137 C139 C140 C143 C151 C152 C154 C158 C159 C164-C166 C169 C172 C176 C177 C179 C183 C184 C186 C193 C196-C200 C202-C204 C207 C208 C211 C213 C223-C226 C235 C236 C249 C251-C257 C261 C262 C265-C272 C274 C276 C277 C284-C286 C291 C293 C296-C298 C300-C302 C307 C309 C311 C316 C317 C320 C324 C326-C331 C333 C335-C338 C340 C346 C349 C351 C352 C354 C356-C358 C361 C366-C369 C372 C374 C376 C383 C387-C390 C392 C393 C395-C400 C403 C407 C411 C416 C425-C428 C433 C437 C438 C440 C441 C444 C447 C454 C459 C461 C463-C475 C477 C478 C482 C483 C487-C489 C498-C504 C508 C509 C511 C514 C517 C519 C522 C525 C528 C530-C536 C539-C541 C573 C589-C637 C647-C670 C711-C718 C771 C772 C774-C779 C781 C783 C785 C796-C843 C848-C851 C853-C860 C863-C901 C914-C919 C922-C949 C952-C1004 CB3 CB6-CB9 CB25 CB26 CB28 CB29 CB33 CB44-CB49 CB51 CB52 CB55 CB58-CB64 CB67 CB68 CB71-CB75 CB78 CB80 CB81 CB84-CB87 CB90 CB92 CB101 CB104 CB108-CB110 CB113 CB114 CB118-CB121 CB124 CB128-CB131 CB135 CB136 CB138-CB141 CB152-CB157 CB161 CB162 CB166 CB167 CB170 CB172 CB173 CB175-CB177 CB181-CB183 CB185 CB186 CB193 CB196 CB197 CB199 CB206 CB208-CB214 CB217 CB221 CB224-CB228 CB231 CB232 CB234-CB236 CB239-CB242 CB246 CB253 CB258 CB261 CB263 CB266 CB268-CB271 CB273-CB276 CB278 CB279 CB281 CB284 CB285 CB287 CB288 CB290-CB293 CB296 CB297 CB299 CB300 CB310-CB318 CB324 CB330-CB340 CB350 CB352-CB365 CB367 CB369 CB370 CB374-CB381 CB384-CB399 CB401-CB407 CB409-CB412 CB414-CB421 CB423-CB427 CB429-CB437 CB440 CB442-CB454 CB456-CB486 CB488-CB493 CB495-CB499 CB501-CB508 CB510 CB512-CB521 CB523-CB526 CB529-CB549 CB551-CB560 CB565-CB569 CB571-CB574 CB576-CB585 CB589-CB593 CB595-CB606 CB608-CB617 CB619-CB667 CB673-CB680 CB682-CB685 CB688-CB707 CB712-CB729 CB731-CB735 CB738 CB740-CB752 CB756 CB758 CB759 CB765-CB775 CB790 CB797 CB832-CB849 CB852-CB857 CB892-CB896 CB904-CB907 CB910-CB913 CB915-CB918 CB926-CB931 CB938 CB942 CB950 CB953 CB954 CB956 CB958 CB959 CB974 CB976-CB985 CB994-CB1008 CB1010-CB1054 CB1057 CB1058 CB1063-CB1090 CB1094-CB1180 CB1188 CB1195 CB1200 CB1211 CB1212 CB1217 CB1218 CB1221 CB1224 CB1227-CB1229 = C_NP
C25 C44 C59 CB4 CB12 CB13 CB24 CB30 CB31 CB35 CB36 CB38 CB39 = C_NP: signal model: C_NP_CC0402_0.1UF/16V_0.1uF/16V; room: U89
C42 C97 C112 C115 C145 C157 C167 C174 C182 C195 C201 CB21 = C_NP: room: 28
C58 C101 C227 CB10 CB50 = C_NP: room: 159
C64 C512 = C_NP: signal model: C_NP_CC0402_10NF/50V_10nF/50V
C131 C323 C518 = CAP NP
C136 C153 = CAP NP_4
C146 = CAP-NON-POLAR
C188 C190 C191 C230 C238 C240 CB321-CB323 = C_NP: signal model: C_NP_CC0402_0.1UF/16V_0.1uF/16V; room: USB
C189 C237 CB327 = C_NP: room: USB
C244 C245 = CAPACITOR NON-POL: room: USB
C258 C273 C314 C353 C375 C378 C379 C412 C431 C443 C458 C495-C497 C847 C852 CB319 CB320 CB325 CB326 CB328 CB346 CB347 CB422 CB587 CB588 CB783 CB972 = C_P
C275 C279 C281 C282 C288 C289 C292 C294 C295 C306 C310 C318 C319 C325 C334 C350 C359 C360 C362-C365 C371 C373 C380 C381 C391 C394 C405 C408 C409 C429 C430 C446 C452 C453 C455 C462 C476 C479 C506 C513 C753 C773 CB366 CB371-CB373 CB408 CB413 CB438 CB439 CB500 CB509 CB550 CB561-CB563 CB570 CB594 CB618 CB686 CB776 CB786-CB789 CB793 CB986 CB987 = C_NP: room: 1
C287 C308 C370 C493 C754 = CAP NP: room: 1
C538 = C_NP: signal model: C_NP_CC0603_1UF/16V_1_1uF/16V
C844-C846 CB1091 = C_NP: room: U89
CB708 = CAP_NP
CONN2 J5 = PINSTICK_MALE_3PX1R
CONN3 CONN8-CONN10 CONN13 CONN16 CONN18 CONN19 CONN23 CONN24 CONN26 CONN29 CONN31 CONN32 CONN34-CONN36 CONN40 CONN43 CONN45-CONN48 CONN52 = PINSTICK_MALE_1PX1R
CONN5 = PIN HEADER_MALE_10PX2R
CONN6 = CONN_POWER_MALE_12PX2R
CONN28 CONN57 CONN58 = PINSTICK_MALE_5PX2R
CONN41 = PIN HEADER_MALE_5PX2R
CONN44 = PINSTICK_MALE_4PX2R
CONN53_PF = QSFP_FEMALE_2X1P_FIT99_G23
CONN54_PF CONN55_PF = SFP_FEMALE_2X6P_FIT293_G53_4
CONN56 = PINHEADER_MALE_15PX2R_G2
CONNB2 = CONN_USB_FEMALE_4P_G2
D1 D2 DB7 = DIODE1_1
D3-D5 = SCHOTTKY1_1
D6 D7 DB1 DB2 = SIDACTOR
D9 = SCHOTTKY2_2
D10 = DIODE2_3
F1-F6 FB2 FB4 FB5 = FUSE: signal model: FUSE_FC_8D65_2SP_2D69WX10D1L_1._1.25A/250V
FB1 FB12 FB17 = FUSE
H1-H8 H10-H12 H14 H15 H17-H26 = SCREW_8_1
HS1 = HEATSINK_4PIN
HSB1 = Bracket_0
J1_PF = qsfp28_single_cage_1
J2 = COMTYPE6_8
J3 = M.2_M_FEMALE_75P_G2_1
J4 = HOLDER_AC
L1-L4 L7-L10 L12 L13 L15-L18 L20 L22 L24-L27 L30 L32 L33 L36-L38 L40-L42 L44-L52 L54 L55 L91-L99 L101-L103 L105-L109 LB1 LB4-LB6 LB8 LB20-LB26 LB57 LB62-LB71 LB85 LB89-LB95 LB104-LB107 LB109 LB110 LB113-LB116 = BEAD
L19 L21 L23 L28 L29 L31 L43 L53 L56-L79 LB30-LB53 = POWER CHOKE
LB58-LB61 LB73-LB78 LB80-LB82 LB84 LB96-LB103 = ESD_1
LB79 LB83 = BEAD: room: 8
LED1-LED8 = LED3_7
LED9-LED12 LED34-LED37 = LED2_2
LED13-LED32 LED38-LED57 = LED2_1
LED33 LEDB5 LEDB6 LEDB11-LEDB14 = LED1_1
LEDB3 LEDB4 LEDB7-LEDB10 = LED2_3_1
LEDB15 = LED2_3
NUT1 = NUT_1
OCXO1 = OCXO_RAKON_STP3377LF
OCXO2 = OCXO_RAKON_M6183LF
OSC1 OSC3 OSC5 = OSC_10
OSC2 = OSC_16
OSC6 OSCB1 = XTAL_2
OSC7 = OSC_1
P1 = FPGA_ALTERA_EP4CGX30_FBGA484
PTC1-PTC12 PTCB1-PTCB3 = PTC
Q1-Q5 QB2 QB4-QB9 = NMOS1_1
R1 R4-R7 R14-R16 R18 R19 R30 R39-R41 R45 R48 R49 R52 R54-R57 R65 R66 R70 R71 R76 R80 R81 R87 R88 R97 R99 R107-R109 R116 R121 R166 R167 R195 R207 R208 R222 R228 R229 R231 R234 R237 R238 R246 R247 R250 R256 R257 R261 R262 R264 R269 R270 R275 R279 R280 R284 R289 R295-R297 R301 R307-R309 R316 R317 R322 R326 R337 R338 R347 R348 R350 R352 R357-R360 R380 R381 R385-R388 R394-R396 R398-R406 R415 R416 R418 R420 R423 R424 R426 R428-R431 R435 R439 R443 R450 R452 R457 R460 R462 R464 R470 R472 R478-R482 R484 R486 R488 R492-R495 R497-R502 R504-R510 R512 R514-R516 R518-R520 R522 R524-R530 R532-R542 R544-R554 R558-R568 R570 R573-R579 R582 R584 R585 R587-R590 R593-R604 R606-R608 R610-R612 R616 R617 R619-R623 R625-R629 R631 R632 R634-R637 R639-R647 R649 R651-R654 R657-R660 R663-R667 R669-R672 R678 R681-R683 R685 R688 R690-R694 R713 R719 R728 R731 R732 R741 R742 R746 R752 R753 R764 R768 R770 R773 R774 R780-R785 R787-R796 R800-R805 R808 R842 R843 R853 R854 R856 R860-R871 R873-R876 R878-R880 R882-R884 R886-R915 R917-R926 R928-R941 R953 R1005 R1007 R1012 R1013 R1047 R1057-R1060 R1063 R1064 R1066-R1078 R1186-R1191 R1238-R1294 R1297-R1300 R1310 R1319-R1322 R1331-R1334 R1339-R1341 R1346 R1347 R1362-R1369 R1371-R1373 R1376-R1379 R1382 R1383 R1386-R1391 R1394-R1396 R1399-R1419 R1424-R1427 R1437-R1440 R1447-R1453 R1456-R1464 R1466-R1474 R1476 R1477 R1490-R1493 R1499-R1509 RB3 RB5 RB7 RB9-RB11 RB13 RB15-RB17 RB21 RB25-RB27 RB29-RB35 RB37 RB40 RB45-RB47 RB78 RB89 RB94 RB98 RB103-RB106 RB108 RB109 RB113 RB114 RB117-RB130 RB145-RB148 RB150 RB153 RB154 RB156 RB158 RB159 RB162 RB167 RB171 RB172 RB174-RB196 RB207-RB209 RB214 RB215 RB218 RB227 RB232 RB233 RB235 RB245 RB254 RB256 RB262-RB270 RB273-RB275 RB280 RB287 RB291-RB297 RB309 RB310 RB312-RB317 RB320 RB323-RB332 RB337-RB577 RB580 RB581 RB584 RB586 RB589 RB590 RB593 RB594 RB597 RB598 RB601 RB602 RB606 RB607 RB610 RB611 RB614 RB615 RB623 RB624 RB627 RB628 RB631 RB632 RB635 RB636 RB641 RB643 RB646 RB647 RB651 RB653 RB654 RB656-RB664 RB666-RB673 RB675 RB677 RB678 RB681 RB683 RB685 RB686 RB688 RB689 RB691 RB694 RB697 RB700 RB702 RB705 RB707 RB711 RB713 RB719 RB722 RB723 RB725 RB727-RB730 RB732-RB741 RB744 RB758-RB761 RB1222-RB1252 RB1256 RB1261 RB1266-RB1269 RB1272 RB1274-RB1281 RB1288-RB1295 RB1300-RB1308 = R: tolerance: 1%
R2 R69 R86 R186 R351 R370 R379 R383 R434 R656 R1036-R1045 R1050-R1056 R1065 R1195 R1343-R1345 RB766 = R: tolerance: 1%; room: U120
R3 R25 R53 R68 R74 R95 R118 R119 R134 R161 R165 R194 R196 R258 R302 R311 R555 R591 R609 R650 R673 R708 R720 R767 RB155 = R: tolerance: 1%; signal model: R_RC0402_DISCRETE_0_1%_0; room: U120
R58 R758 R1019 = R: room: 1
R59-R61 R67 R75 R77-R79 R82-R84 R89 R98 R100 R110 R137 R139 R181 R191 R192 R210 R211 R233 R242 R244 R254 R288 R300 R313 R324 R333 R335 R366 R373 R377 R378 R408 R414 R474 R531 R569 R717 R729 R766 R943 R944 R947 R948 R1048 R1079 R1091 R1093 R1119 R1122 R1123 R1130 R1131 R1160-R1167 R1183 R1184 R1198 R1202 R1207 R1295 R1301-R1309 R1311-R1317 R1323-R1330 R1335-R1338 R1443-R1446 R1454 R1455 R1494-R1496 RB1 RB132 RB133 RB276 RB277 RB283 RB642 RB652 RB1199-RB1201 RB1203-RB1206 RB1208-RB1221 = R
R62 R85 R557 R674-R677 R689 R1082-R1090 R1092 R1094-R1103 R1108 R1110 R1112-R1115 R1118 R1120 R1124 R1125 R1350 R1351 R1353 R1420-R1423 R1497 R1498 RB1259 RB1260 RB1262-RB1265 RB1271 RB1282-RB1287 RB1296-RB1299 = R: tolerance: 1%; room: U83
R64 R205 R232 R259 R282 R283 R285 R319 R344 R451 R458 R471 R485 R491 R523 R543 R592 R605 R613 R614 R655 R661 R759 R772 R779 RB2 RB18 RB168 RB319 RB321 RB333-RB336 = R: tolerance: 1%; signal model: R_RC0402_DISCRETE_0_1%_0
R72 R112 R132 R188 R287 R299 R312 R323 R334 R345 R346 R376 R521 RB4 = R_0: room: 82
R73 R96 R106 R111 R117 R168 R169 R182 R184 R185 R189 R190 R407 R618 R662 R855 R857 R858 R945 R946 R1014 R1081 R1116 R1117 R1126-R1129 R1172 R1182 RB278 RB708 RB714 RB742 RB743 RB745 RB746 = RES
R94 R120 R178 R180 R183 R193 R227 R230 R245 R248 R260 R263 R278 R281 R294 R306 R318 R327 R349 R355 R389 R391 R397 R419 R438 R483 R487 R503 R511 R517 R580 R581 R583 R586 R624 R630 R633 R638 R668 R679 R687 R846 R985 R986 R1374 R1375 R1392 R1393 RB6 RB12 RB22 RB28 RB38 RB39 RB44 RB84 RB88 RB236 RB242 RB246-RB253 RB255 RB279 RB302-RB308 RB311 RB578 RB579 RB582 RB583 RB587 RB588 RB591 RB592 RB595 RB596 RB599 RB600 RB603 RB605 RB608 RB609 RB612 RB613 RB616 RB622 RB625 RB626 RB629 RB630 RB633 RB634 RB637 RB640 RB644 RB645 RB648 RB650 RB655 RB665 RB674 RB676 RB679 RB680 RB682 RB690 RB692 RB693 RB699 RB701 RB703 RB704 RB706 RB710 RB712 RB720 RB721 RB731 = R: tolerance: 1%; signal model: R_RC0402_DISCRETE_33_1%_33
R138 = R: signal model: R_RC0402_DISCRETE
R140-R158 R163 R179 R187 R197 R209 R221 R226 R243 R255 R267 R274 R292 R305 RB48-RB77 RB79-RB83 RB85 RB86 RB90-RB92 RB95 RB96 RB99-RB102 RB107 RB110-RB112 RB115 RB116 = R: tolerance: 1%; signal model: R_RC0402_DISCRETE_40.2_1%_40.2
R162 R363 = R: tolerance: 1%; room: U120; signal model: R_RC0402_DISCRETE_33_1%_33
R204 R572 R957-R964 = R: signal model: R_RC0402_0_0
R206 = R_0
R310 RB318 RB322 = R: tolerance: 1%; signal model: R_RC0402_DISCRETE_33_1%_33; room: U95
R332 R1018 R1236 R1237 = RESISTOR
R340 R356 R384 R390 R449 R453 R455 R456 R1318 = R: tolerance: 1%; room: USB
R342 R343 R433 R437 = RES: signal model: RES_RC0402_0_0; room: USB
R421 = R: tolerance: 1%; room: 71
R454 = RESISTOR: room: USB
R459 = R: tolerance: 1%; signal model: R_RC0402_DISCRETE_0_1%_0; room: USB
R489 R490 R556 R571 R686 R765 R797 RB228 = R: tolerance: 1%; room: 1
R496 = R: tolerance: 1%; signal model: R_RC0402_0_0
R513 R1480 R1483 R1486 R1489 RB173 RB202 = R: room: 71
R714 R726 R754 = R: signal model: R_RC0402_DISCRETE_@0_@0
R1478 R1479 R1481 R1482 R1484 R1485 R1487 R1488 = R: tolerance: 1%; room: U95
R1510 R1511 = R: tolerance: 1%; signal model: R_RC0402_DISCRETE_0_1%_0; room: U83
RB134 RB135 = RES: signal model: RES_RC0402; room: USB
RB718 RB724 = R: tolerance: 1%; signal model: R_RC0402_DISCRETE
RJ1 = 5569256-1_1
SW1 SWB2 = SW_3
SWB1 = SW_34GND
TP1 TP2 TP52 TPB26-TPB42 = NCA: room: 28
TP49-TP51 TPB7 TPB43-TPB48 = NCA
U5 UB2 = TTL_FAIRCHILD_NC7SZ08
U6 = DC_DC_TI_TPS51200
U7 = PWR_TI_UCD90160
U8 = EEPROM_MICROCHIP_24LC256
U9 = CPLD_ALTERA_5M2210Z_FBGA324
U10 UB8 UB12 UB13 UB16 UB17 = I2C_TI_PCA9548A
U14-U17 UB5 UB6 = SDRAM_SAMSUNG_K4A4G165WD
U18 U27 U29 = TEMP MINOTOR_NXP_LM75BD
U19 = MUX_FAIRCHILD_NC7SB3157P6X
U20 = LOGIC_TI_SN74LVC244A
U21 = TTL_TI_SN74CBTLV3257
U22 = TTL_TI_SN74LVC2G32
U23 = LDO_TI_TPS74801RGW_0
U24 = ASIC_SMSC_USB2514B_2
U30 U39 = DRIVER_TI_CSD95372BVQP
U31 U48 = DC_DC_TI_TPS53219
U32 = DC_DC_TI_TPS53315
U33 = DC_DC_TI_TPS53647
U34 = DC_DC_MPS_MP1484EN-C166_0
U35 U44 = DC_DC_TI_TPS53314
U36 = LDO_DIODES_AP7362
U37 = CLK_IDT_2304NZL
U38 U41 U42 = CSD87384M
U40 = MAC_BROADCOM_BCM88470
U47 = LDO_TI_TPS74801RGW_6
U50 = TVS_SEMTECH_SRDA05-4
U51 U85-U88 = TTL_TI_SN65C1167EPW
U52 = PHY_MARVELL_88E1111_TFBGA117
U53 = XFMR_HALO_TG74-1505N1RL
U54 U62 U74 = TVS_SEMTECH_RClamp2574N_3
U55 U56 U73 U75 = TVS_AMAZING_AZ3133-08F
U59 U60 = COMMCHOKE_4PIN_1
U66 = LDO_TI_TPS73701
U68 = ASIC_EXAR_XRT86VL30IV80
U69 = QSFP_FEMALE_1X1P_SMD38
U70 U76 = XFMR_FPE_LG24140SN
U71 = FT2232HL
U72 = TPM_SLB 9665XT2.0 FW5_0.63
U77 = ZL30773LFG7
U79 = CLK_BUFFER_TI_CDCLVP1204
U80 = FLASH_WINBOND_W25Q128JV_SOIC16
U81 = OTERDLLTNF-100M
UB1 = CLK_IDT_3
UB9 = RS232_SIPEX_SP3232E
UB10 = TVS_SEMTECH_LC04-6
UB14 = MONITOR_CUR_TI_TPS2553
UB70 UB71 = TTL_TI_SN74LV1T34
X1 = XTAL_2: room: USB

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
BGA_1D_18C_117SP_10W14L1D54H
  round 0.508 smd: (-6,-8) (6,8)
  round 0.457 smd: A1(-4,6) A2(-3,6) A3(-2,6) A4(-1,6) A5(0,6) A6(1,6) A7(2,6) A8(3,6) A9(4,6) B1(-4,5) B2(-3,5) B3(-2,5) B4(-1,5) B5(0,5) B6(1,5) B7(2,5) B8(3,5) B9(4,5) C1(-4,4) C2(-3,4) C3(-2,4) C4(-1,4) C5(0,4) C6(1,4) C7(2,4) C8(3,4) C9(4,4) D1(-4,3) D2(-3,3) D3(-2,3) D4(-1,3) D5(0,3) D6(1,3) D7(2,3) D8(3,3) D9(4,3) E1(-4,2) E2(-3,2) E3(-2,2) E4(-1,2) E5(0,2) E6(1,2) E7(2,2) E8(3,2) E9(4,2) F1(-4,1) F2(-3,1) F3(-2,1) F4(-1,1) F5(0,1) F6(1,1) F7(2,1) F8(3,1) F9(4,1) G1(-4,0) G2(-3,0) G3(-2,0) G4(-1,0) G5(0,0) G6(1,0) G7(2,0) G8(3,0) G9(4,0) H1(-4,-1) H2(-3,-1) H3(-2,-1) H4(-1,-1) H5(0,-1) H6(1,-1) H7(2,-1) H8(3,-1) H9(4,-1) J1(-4,-2) J2(-3,-2) J3(-2,-2) J4(-1,-2) J5(0,-2) J6(1,-2) J7(2,-2) J8(3,-2) J9(4,-2) K1(-4,-3) K2(-3,-3) K3(-2,-3) K4(-1,-3) K5(0,-3) K6(1,-3) K7(2,-3) K8(3,-3) K9(4,-3) L1(-4,-4) L2(-3,-4) L3(-2,-4) L4(-1,-4) L5(0,-4) L6(1,-4) L7(2,-4) L8(3,-4) L9(4,-4) M1(-4,-5) M2(-3,-5) M3(-2,-5) M4(-1,-5) M5(0,-5) M6(1,-5) M7(2,-5) M8(3,-5) M9(4,-5) N1(-4,-6) N2(-3,-6) N3(-2,-6) N4(-1,-6) N5(0,-6) N6(1,-6) N7(2,-6) N8(3,-6) N9(4,-6)
BGA_1D_20C_484SP_23WL2D44H
  round 0.508 smd: (-12.5,-12.5) (12.5,12.5) A1(-10.5,10.5) A2(-9.5,10.5) A3(-8.5,10.5) A4(-7.5,10.5) A5(-6.5,10.5) A6(-5.5,10.5) A7(-4.5,10.5) A8(-3.5,10.5) A9(-2.5,10.5) A10(-1.5,10.5) A11(-0.5,10.5) A12(0.5,10.5) A13(1.5,10.5) A14(2.5,10.5) A15(3.5,10.5) A16(4.5,10.5) A17(5.5,10.5) A18(6.5,10.5) A19(7.5,10.5) A20(8.5,10.5) A21(9.5,10.5) A22(10.5,10.5) AA1(-10.5,-9.5) AA2(-9.5,-9.5) AA3(-8.5,-9.5) AA4(-7.5,-9.5) AA5(-6.5,-9.5) AA6(-5.5,-9.5) AA7(-4.5,-9.5) AA8(-3.5,-9.5) AA9(-2.5,-9.5) AA10(-1.5,-9.5) AA11(-0.5,-9.5) AA12(0.5,-9.5) AA13(1.5,-9.5) AA14(2.5,-9.5) AA15(3.5,-9.5) AA16(4.5,-9.5) AA17(5.5,-9.5) AA18(6.5,-9.5) AA19(7.5,-9.5) AA20(8.5,-9.5) AA21(9.5,-9.5) AA22(10.5,-9.5) AB1(-10.5,-10.5) AB2(-9.5,-10.5) AB3(-8.5,-10.5) AB4(-7.5,-10.5) AB5(-6.5,-10.5) AB6(-5.5,-10.5) AB7(-4.5,-10.5) AB8(-3.5,-10.5) AB9(-2.5,-10.5) AB10(-1.5,-10.5) AB11(-0.5,-10.5) AB12(0.5,-10.5) AB13(1.5,-10.5) AB14(2.5,-10.5) AB15(3.5,-10.5) AB16(4.5,-10.5) AB17(5.5,-10.5) AB18(6.5,-10.5) AB19(7.5,-10.5) AB20(8.5,-10.5) AB21(9.5,-10.5) AB22(10.5,-10.5) B1(-10.5,9.5) B2(-9.5,9.5) B3(-8.5,9.5) B4(-7.5,9.5) B5(-6.5,9.5) B6(-5.5,9.5) B7(-4.5,9.5) B8(-3.5,9.5) B9(-2.5,9.5) B10(-1.5,9.5) B11(-0.5,9.5) B12(0.5,9.5) B13(1.5,9.5) B14(2.5,9.5) B15(3.5,9.5) B16(4.5,9.5) B17(5.5,9.5) B18(6.5,9.5) B19(7.5,9.5) B20(8.5,9.5) B21(9.5,9.5) B22(10.5,9.5) C1(-10.5,8.5) C2(-9.5,8.5) C3(-8.5,8.5) C4(-7.5,8.5) C5(-6.5,8.5) C6(-5.5,8.5) C7(-4.5,8.5) C8(-3.5,8.5) C9(-2.5,8.5) C10(-1.5,8.5) C11(-0.5,8.5) C12(0.5,8.5) C13(1.5,8.5) C14(2.5,8.5) C15(3.5,8.5) C16(4.5,8.5) C17(5.5,8.5) C18(6.5,8.5) C19(7.5,8.5) C20(8.5,8.5) C21(9.5,8.5) C22(10.5,8.5) D1(-10.5,7.5) D2(-9.5,7.5) D3(-8.5,7.5) D4(-7.5,7.5) D5(-6.5,7.5) D6(-5.5,7.5) D7(-4.5,7.5) D8(-3.5,7.5) D9(-2.5,7.5) D10(-1.5,7.5) D11(-0.5,7.5) D12(0.5,7.5) D13(1.5,7.5) D14(2.5,7.5) D15(3.5,7.5) D16(4.5,7.5) D17(5.5,7.5) D18(6.5,7.5) D19(7.5,7.5) D20(8.5,7.5) D21(9.5,7.5) D22(10.5,7.5) E1(-10.5,6.5) E2(-9.5,6.5) E3(-8.5,6.5) E4(-7.5,6.5) E5(-6.5,6.5) E6(-5.5,6.5) E7(-4.5,6.5) E8(-3.5,6.5) E9(-2.5,6.5) E10(-1.5,6.5) E11(-0.5,6.5) E12(0.5,6.5) E13(1.5,6.5) E14(2.5,6.5) E15(3.5,6.5) E16(4.5,6.5) E17(5.5,6.5) E18(6.5,6.5) E19(7.5,6.5) E20(8.5,6.5) E21(9.5,6.5) E22(10.5,6.5) F1(-10.5,5.5) F2(-9.5,5.5) F3(-8.5,5.5) F4(-7.5,5.5) F5(-6.5,5.5) F6(-5.5,5.5) F7(-4.5,5.5) F8(-3.5,5.5) F9(-2.5,5.5) F10(-1.5,5.5) F11(-0.5,5.5) F12(0.5,5.5) F13(1.5,5.5) F14(2.5,5.5) F15(3.5,5.5) F16(4.5,5.5) F17(5.5,5.5) F18(6.5,5.5) F19(7.5,5.5) F20(8.5,5.5) F21(9.5,5.5) F22(10.5,5.5) G1(-10.5,4.5) G2(-9.5,4.5) G3(-8.5,4.5) G4(-7.5,4.5) G5(-6.5,4.5) G6(-5.5,4.5) G7(-4.5,4.5) G8(-3.5,4.5) G9(-2.5,4.5) G10(-1.5,4.5) G11(-0.5,4.5) G12(0.5,4.5) G13(1.5,4.5) G14(2.5,4.5) G15(3.5,4.5) G16(4.5,4.5) G17(5.5,4.5) G18(6.5,4.5) G19(7.5,4.5) G20(8.5,4.5) G21(9.5,4.5) G22(10.5,4.5) H1(-10.5,3.5) H2(-9.5,3.5) H3(-8.5,3.5) H4(-7.5,3.5) H5(-6.5,3.5) H6(-5.5,3.5) H7(-4.5,3.5) H8(-3.5,3.5) H9(-2.5,3.5) H10(-1.5,3.5) H11(-0.5,3.5) H12(0.5,3.5) H13(1.5,3.5) H14(2.5,3.5) H15(3.5,3.5) H16(4.5,3.5) H17(5.5,3.5) H18(6.5,3.5) H19(7.5,3.5) H20(8.5,3.5) H21(9.5,3.5) H22(10.5,3.5) J1(-10.5,2.5) J2(-9.5,2.5) J3(-8.5,2.5) J4(-7.5,2.5) J5(-6.5,2.5) J6(-5.5,2.5) J7(-4.5,2.5) J8(-3.5,2.5) J9(-2.5,2.5) J10(-1.5,2.5) J11(-0.5,2.5) J12(0.5,2.5) J13(1.5,2.5) J14(2.5,2.5) J15(3.5,2.5) J16(4.5,2.5) J17(5.5,2.5) J18(6.5,2.5) J19(7.5,2.5) J20(8.5,2.5) J21(9.5,2.5) J22(10.5,2.5) K1(-10.5,1.5) K2(-9.5,1.5) K3(-8.5,1.5) K4(-7.5,1.5) K5(-6.5,1.5) K6(-5.5,1.5) K7(-4.5,1.5) K8(-3.5,1.5) K9(-2.5,1.5) K10(-1.5,1.5) K11(-0.5,1.5) K12(0.5,1.5) K13(1.5,1.5) K14(2.5,1.5) K15(3.5,1.5) K16(4.5,1.5) K17(5.5,1.5) K18(6.5,1.5) K19(7.5,1.5) K20(8.5,1.5) K21(9.5,1.5) K22(10.5,1.5) L1(-10.5,0.5) L2(-9.5,0.5) L3(-8.5,0.5) L4(-7.5,0.5) L5(-6.5,0.5) L6(-5.5,0.5) L7(-4.5,0.5) L8(-3.5,0.5) L9(-2.5,0.5) L10(-1.5,0.5) L11(-0.5,0.5) L12(0.5,0.5) L13(1.5,0.5) L14(2.5,0.5) L15(3.5,0.5) L16(4.5,0.5) L17(5.5,0.5) L18(6.5,0.5) L19(7.5,0.5) L20(8.5,0.5) L21(9.5,0.5) L22(10.5,0.5) M1(-10.5,-0.5) M2(-9.5,-0.5) M3(-8.5,-0.5) M4(-7.5,-0.5) M5(-6.5,-0.5) M6(-5.5,-0.5) M7(-4.5,-0.5) M8(-3.5,-0.5) M9(-2.5,-0.5) M10(-1.5,-0.5) M11(-0.5,-0.5) M12(0.5,-0.5) M13(1.5,-0.5) M14(2.5,-0.5) M15(3.5,-0.5) M16(4.5,-0.5) M17(5.5,-0.5) M18(6.5,-0.5) M19(7.5,-0.5) M20(8.5,-0.5) M21(9.5,-0.5) M22(10.5,-0.5) N1(-10.5,-1.5) N2(-9.5,-1.5) N3(-8.5,-1.5) N4(-7.5,-1.5) N5(-6.5,-1.5) N6(-5.5,-1.5) N7(-4.5,-1.5) N8(-3.5,-1.5) N9(-2.5,-1.5) N10(-1.5,-1.5) N11(-0.5,-1.5) N12(0.5,-1.5) N13(1.5,-1.5) N14(2.5,-1.5) N15(3.5,-1.5) N16(4.5,-1.5) N17(5.5,-1.5) N18(6.5,-1.5) N19(7.5,-1.5) N20(8.5,-1.5) N21(9.5,-1.5) N22(10.5,-1.5) P1(-10.5,-2.5) P2(-9.5,-2.5) P3(-8.5,-2.5) P4(-7.5,-2.5) P5(-6.5,-2.5) P6(-5.5,-2.5) P7(-4.5,-2.5) P8(-3.5,-2.5) P9(-2.5,-2.5) P10(-1.5,-2.5) P11(-0.5,-2.5) P12(0.5,-2.5) P13(1.5,-2.5) P14(2.5,-2.5) P15(3.5,-2.5) P16(4.5,-2.5) P17(5.5,-2.5) P18(6.5,-2.5) P19(7.5,-2.5) P20(8.5,-2.5) P21(9.5,-2.5) P22(10.5,-2.5) R1(-10.5,-3.5) R2(-9.5,-3.5) R3(-8.5,-3.5) R4(-7.5,-3.5) R5(-6.5,-3.5) R6(-5.5,-3.5) R7(-4.5,-3.5) R8(-3.5,-3.5) R9(-2.5,-3.5) R10(-1.5,-3.5) R11(-0.5,-3.5) R12(0.5,-3.5) R13(1.5,-3.5) R14(2.5,-3.5) R15(3.5,-3.5) R16(4.5,-3.5) R17(5.5,-3.5) R18(6.5,-3.5) R19(7.5,-3.5) R20(8.5,-3.5) R21(9.5,-3.5) R22(10.5,-3.5) T1(-10.5,-4.5) T2(-9.5,-4.5) T3(-8.5,-4.5) T4(-7.5,-4.5) T5(-6.5,-4.5) T6(-5.5,-4.5) T7(-4.5,-4.5) T8(-3.5,-4.5) T9(-2.5,-4.5) T10(-1.5,-4.5) T11(-0.5,-4.5) T12(0.5,-4.5) T13(1.5,-4.5) T14(2.5,-4.5) T15(3.5,-4.5) T16(4.5,-4.5) T17(5.5,-4.5) T18(6.5,-4.5) T19(7.5,-4.5) T20(8.5,-4.5) T21(9.5,-4.5) T22(10.5,-4.5) U1(-10.5,-5.5) U2(-9.5,-5.5) U3(-8.5,-5.5) U4(-7.5,-5.5) U5(-6.5,-5.5) U6(-5.5,-5.5) U7(-4.5,-5.5) U8(-3.5,-5.5) U9(-2.5,-5.5) U10(-1.5,-5.5) U11(-0.5,-5.5) U12(0.5,-5.5) U13(1.5,-5.5) U14(2.5,-5.5) U15(3.5,-5.5) U16(4.5,-5.5) U17(5.5,-5.5) U18(6.5,-5.5) U19(7.5,-5.5) U20(8.5,-5.5) U21(9.5,-5.5) U22(10.5,-5.5) V1(-10.5,-6.5) V2(-9.5,-6.5) V3(-8.5,-6.5) V4(-7.5,-6.5) V5(-6.5,-6.5) V6(-5.5,-6.5) V7(-4.5,-6.5) V8(-3.5,-6.5) V9(-2.5,-6.5) V10(-1.5,-6.5) V11(-0.5,-6.5) V12(0.5,-6.5) V13(1.5,-6.5) V14(2.5,-6.5) V15(3.5,-6.5) V16(4.5,-6.5) V17(5.5,-6.5) V18(6.5,-6.5) V19(7.5,-6.5) V20(8.5,-6.5) V21(9.5,-6.5) V22(10.5,-6.5) W1(-10.5,-7.5) W2(-9.5,-7.5) W3(-8.5,-7.5) W4(-7.5,-7.5) W5(-6.5,-7.5) W6(-5.5,-7.5) W7(-4.5,-7.5) W8(-3.5,-7.5) W9(-2.5,-7.5) W10(-1.5,-7.5) W11(-0.5,-7.5) W12(0.5,-7.5) W13(1.5,-7.5) W14(2.5,-7.5) W15(3.5,-7.5) W16(4.5,-7.5) W17(5.5,-7.5) W18(6.5,-7.5) W19(7.5,-7.5) W20(8.5,-7.5) W21(9.5,-7.5) W22(10.5,-7.5) Y1(-10.5,-8.5) Y2(-9.5,-8.5) Y3(-8.5,-8.5) Y4(-7.5,-8.5) Y5(-6.5,-8.5) Y6(-5.5,-8.5) Y7(-4.5,-8.5) Y8(-3.5,-8.5) Y9(-2.5,-8.5) Y10(-1.5,-8.5) Y11(-0.5,-8.5) Y12(0.5,-8.5) Y13(1.5,-8.5) Y14(2.5,-8.5) Y15(3.5,-8.5) Y16(4.5,-8.5) Y17(5.5,-8.5) Y18(6.5,-8.5) Y19(7.5,-8.5) Y20(8.5,-8.5) Y21(9.5,-8.5) Y22(10.5,-8.5)
