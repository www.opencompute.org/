# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TXDIS_08: length 242.4
  TOP w0.127: U9.M6 v4(194.55,187.58)
  S5 w0.127: CONN54_PF.4L3 76.96,52.3 76.96,54.06 80.59,57.68 80.59,59.33 84.06,62.8 84.06,75.75 88.59,80.29 123.4,80.29 133.52,90.41 133.52,128.09 134.1,128.67 136.11,128.67 136.52,129.08 136.52,132.74 140.34,136.56 143.35,136.56 146.37,139.58 149.79,139.58 150.45,140.24 163.22,140.24 163.92,140.94 163.92,142.97 164.87,143.93 164.87,147.86 166.14,149.13 166.14,149.51 167.22,150.59 169.26,150.59 171.03,152.37 171.03,154.35 170.97,154.41 170.97,155.87 177.04,161.93 177.04,164.85 185.07,172.88 185.07,176.25 186.91,178.09 v1(186.91,179.93)
  S9 w0.127: v4(194.55,187.58) 194.02,187.04 189.2,187.04 188.75,186.6 188.75,181.58 187.1,179.93 v1(186.91,179.93)
  S12 w0.127: CONN54_PF.4L3 76.96,52.3 76.96,50.81 78.12,49.65 78.58,49.65 79.29,48.94 79.29,48.51 76.57,45.79 76.57,41.88 76.17,41.48 v1(76.17,36.29)
  BOTTOM w0.127: v1(186.91,179.93) 187.42,179.42 v2(187.42,178.66) ; RB546.1 v1(76.17,36.29)
TXDIS_09: length 236.2
  TOP w0.127: v4(196.55,185.58) U9.P8
  S5 w0.127: CONN54_PF.5T3 87.21,54.58 87.88,55.24 87.88,55.98 90.92,59.03 90.92,60.87 95.1,65.05 101.36,65.05 104.99,68.68 104.99,75.31 108.34,78.66 124.03,78.66 135.27,89.9 135.27,115.28 137.38,117.38 137.38,127.07 138.09,127.78 138.09,132.18 141.01,135.1 144.62,135.1 146.24,133.48 150.52,133.48 154.68,137.64 164.43,137.64 167.35,140.56 167.94,140.56 168.43,141.05 168.43,142.53 168.88,142.97 168.88,144.14 170.98,146.25 170.98,150.04 173.89,152.94 173.89,156.69 179.1,161.9 179.1,165.11 187.81,173.82 188.3,173.82 189.83,175.35 v1(189.83,177.39)
  S9 w0.127: v1(189.83,177.39) 194.53,177.39 197.13,179.99 197.13,180.88 197.07,180.95 197.07,185.06 v4(196.55,185.58) ; CONN54_PF.5T3 87.64,53.48 87.7,53.41 88.71,53.41 89.4,52.73 89.4,52.02 88.99,51.61 88.99,50.69 89.81,49.88 89.81,48.97 88.99,48.16 88.99,47.44 90.52,45.92 90.52,44.36 90.14,43.98 90.14,43.22 90.52,42.83 90.52,39.06 91.94,37.64 91.94,34.13 v1(92.83,33.24)
  BOTTOM w0.127: RB439.1 v1(92.83,33.24) 93.51,33.24 v2(93.74,33.02) ; v2(190.4,175.99) 190.4,176.82 v1(189.83,177.39)
TXDIS_10: length 222.3
  TOP w0.127: v4(191.55,183.58) U9.T3
  S5 w0.127: CONN54_PF.5L3 91.21,54.06 94.84,57.68 94.84,60.68 98.09,63.93 101.45,63.93 105.81,68.29 105.81,74.6 108.94,77.74 124.49,77.74 136.55,89.8 136.55,102.08 143.83,109.36 143.83,113.85 138.53,119.15 138.53,126.99 139.6,128.06 143.12,128.06 143.17,128.12 144.24,128.12 148.71,132.59 151.38,132.59 155.6,136.81 166.04,136.81 171.03,141.81 171.03,144.88 172.11,145.96 172.11,148.81 174.27,150.98 174.27,151.42 175.67,152.82 175.67,155.67 176.5,156.5 178.53,156.5 180.43,158.4 180.43,163.68 181.6,164.84 181.6,165.87 190.97,175.25 190.97,178.72 189.98,179.72 189.98,181.89 190.26,182.17 191.02,182.17 191.15,182.29 191.15,183.18 v4(191.55,183.58)
  S12 w0.127: v1(90.42,36.29) 90.42,43.25 v1(90.82,43.66) 90.82,45.79 93.54,48.51 93.54,49.15 93.03,49.65 92.37,49.65 91.21,50.81 CONN54_PF.5L3
  BOTTOM w0.127: v1(90.82,43.66) 91.27,43.22 v2(91.72,43.22) ; RB549.1 v1(90.42,36.29)
TXDIS_11: length 227.1
  TOP w0.127: U9.U6 v4(194.55,182.58)
  S5 w0.127: CONN54_PF.6T3 101.46,54.58 102.13,55.24 102.13,55.98 105.17,59.03 105.17,61.16 107.53,63.52 107.53,74.05 109.65,76.16 126.2,76.16 130.48,80.44 143.02,80.44 146.58,84 169.11,84 177.68,92.57 177.68,136.84 175.48,139.04 175.48,142.59 175.86,142.98 175.86,144.27 176.54,144.94 176.81,144.94 177.83,145.96 177.83,152.51 180.78,155.46 180.78,156.52 181.89,157.64 181.89,161.52 183.35,162.98 183.35,165.58 192.38,174.61 192.38,178.8 195.06,181.48 195.06,182.07 v4(194.55,182.58)
  S9 w0.127: v1(107.08,33.24) 106.19,34.13 106.19,37.69 104.77,39.11 104.77,45.92 103.24,47.44 103.24,48.16 104.13,49.05 104.13,49.73 103.24,50.62 103.24,51.54 103.78,52.07 103.78,52.6 102.96,53.41 101.95,53.41 CONN54_PF.6T3
  BOTTOM w0.127: RB442.1 v1(107.08,33.24) 107.76,33.24 v2(107.99,33.02)
TXDIS_12: length 228.4
  TOP w0.127: v4(195.55,183.58) U9.T7
  S5 w0.127: CONN54_PF.6L3 105.46,54.06 109.09,57.68 109.09,63.14 111.81,65.86 111.81,72.23 113.06,73.48 125.95,73.48 131.65,79.18 143.35,79.18 147.09,82.93 169.71,82.93 178.44,91.65 178.44,137.32 177.51,138.25 177.51,139.61 178.65,140.75 178.65,144.63 180.37,146.34 180.37,149.96 180.5,150.09 180.5,153.58 182.65,155.74 182.65,160.97 184.6,162.91 184.6,165.63 189.25,170.28 191.49,170.28 191.86,170.66 191.86,172.32 195.7,176.16 195.7,180.31 196.79,181.4 196.79,182.14 197.02,182.37 197.02,182.85 196.74,183.13 196.31,183.13 195.86,183.58 v4(195.55,183.58)
  S12 w0.127: v1(104.67,36.29) 104.67,41.48 105.07,41.88 105.07,45.79 107.79,48.51 107.79,49.15 107.28,49.65 106.62,49.65 105.46,50.81 CONN54_PF.6L3
  BOTTOM w0.127: v2(196.94,175.8) 196.05,176.69 196.05,183.11 195.58,183.58 v4(195.55,183.58) ; RB552.1 v1(104.67,36.29)
TXDIS_13: length 216.6
  TOP w0.127: v4(197.55,183.58) U9.T9
  S5 w0.127: CONN55_PF.1T3 117.76,54.58 118.43,55.24 118.43,55.98 121.47,59.03 121.47,61.29 125.32,65.13 125.32,69.66 133.01,77.34 143.58,77.34 147.72,81.48 170.32,81.48 179.71,90.87 179.71,138.51 180.24,139.04 180.24,144.31 181.7,145.77 181.7,145.9 182.78,146.97 182.78,153.77 184.88,155.86 184.88,158.8 185.77,159.69 185.77,161.8 186.16,162.19 186.16,165.39 189.26,168.5 193.06,168.5 195.04,170.47 195.04,173.64 195.01,173.67 197.76,176.42 197.76,179.17 198.29,179.7 198.29,183.11 198.03,183.36 197.77,183.36 v4(197.55,183.58)
  S9 w0.127: v1(123.38,33.24) 122.49,34.13 122.49,37.64 121.07,39.07 121.07,45.92 119.54,47.44 119.54,48.13 120.43,49.02 120.43,49.74 119.54,50.62 119.54,51.61 120.08,52.14 120.08,52.6 118.77,53.9 CONN55_PF.1T3
  BOTTOM w0.127: RB460.1 v1(123.38,33.24) 124.06,33.24 v2(124.29,33.02) ; v2(198.48,179.99) 198.48,183.16 198.06,183.58 v4(197.55,183.58)
TXDIS_14: length 206.5
  TOP w0.127: v4(199.49,181.64) U9.V10
  S5 w0.127: CONN55_PF.1L3 121.76,54.06 125.39,57.68 125.39,59.61 129.26,63.48 129.26,64.6 133.94,69.28 133.94,72.19 138,76.25 143.81,76.25 148.08,80.52 170.71,80.52 180.72,90.53 180.72,138.07 181.26,138.6 181.26,142.86 182.15,143.75 182.15,144.94 182.59,145.39 182.59,145.51 183.54,146.47 183.54,151.62 187.67,155.75 187.67,161.58 187.04,162.21 187.04,165.19 189.33,167.49 193.77,167.49 199.15,172.87 199.15,181.22 199.53,181.6 v4(199.49,181.64)
  S12 w0.127: v1(120.97,36.29) 120.97,41.48 121.37,41.88 121.37,45.79 123.97,48.39 123.97,49.04 123.36,49.65 122.92,49.65 121.76,50.81 CONN55_PF.1L3
  BOTTOM w0.127: v4(199.49,181.64) 199.49,176.44 199.48,176.44 199.48,176.35 v2(199.53,176.35) ; RB570.1 v1(120.97,36.29)
TXDIS_15: length 207.4
  TOP w0.127: v4(202.55,185.58) 202.12,186.01 U9.P13
  S5 w0.127: v4(202.55,185.58) 202.55,185.21 202.1,184.76 202.1,183.36 202.48,182.98 202.48,180.69 201.11,179.32 201.11,168.48 196.56,163.93 196.56,161.01 194.15,158.6 194.15,157.96 192.43,156.25 190.46,156.25 186.08,151.87 186.08,148.82 185.13,147.86 185.13,146.02 184.5,145.39 184.5,138.53 182.14,136.17 182.14,89.46 171.71,79.04 152.38,79.04 151.22,77.89 151.22,73 149.19,70.97 138.8,70.97 138.41,70.57 138.41,63.85 135.72,61.16 135.72,59.03 132.68,55.98 132.68,55.24 132.01,54.58 CONN55_PF.2T3
  S9 w0.127: CONN55_PF.2T3 132.5,53.41 133.51,53.41 134.33,52.6 134.33,52.14 133.79,51.61 133.79,50.62 134.68,49.74 134.68,49.02 133.79,48.13 133.79,47.44 135.43,45.81 135.43,44.56 134.84,43.98 134.84,42.68 135.32,42.2 135.32,39.07 136.74,37.64 136.74,34.13 v1(137.63,33.24)
  BOTTOM w0.127: RB463.1 v1(137.63,33.24) 138.31,33.24 v2(138.54,33.02)
TXDIS_16: length 198.3
  TOP w0.127: v4(203.55,185.58) U9.P14
  S5 w0.127: CONN55_PF.2L3 136.01,54.06 139.64,57.68 139.64,60.31 141.25,61.93 141.25,62.21 143.14,64.1 143.14,64.36 144.43,65.65 144.43,67.09 145.06,67.73 147.41,67.73 152.24,72.55 152.24,77.17 153.25,78.18 171.98,78.18 182.9,89.1 182.9,135.67 185.74,138.51 185.74,139.46 187.67,141.39 187.67,146.43 188.43,147.19 188.43,149.58 187.8,150.21 187.8,151.86 190.59,154.66 192.18,154.66 194.72,157.2 196.24,157.2 197.01,157.96 197.01,159.42 196.97,159.45 197.83,160.31 197.83,163.6 203.74,169.5 203.74,180.78 204,181.05 204,185.13 v4(203.55,185.58)
  S12 w0.127: v1(135.22,36.29) 135.22,41.73 136.08,42.59 v1(136.08,43.15) 136.08,43.75 135.6,44.24 135.6,45.77 138.22,48.39 138.22,49.04 137.61,49.65 137.17,49.65 136.01,50.81 CONN55_PF.2L3
  BOTTOM w0.127: v2(137.76,43.09) 136.15,43.09 v1(136.08,43.15) ; RB573.1 v1(135.22,36.29)
TXDIS_17: length 200.9
  TOP w0.127: U9.R18 v4(207.55,184.58)
  S5 w0.127: CONN55_PF.3T3 146.26,54.58 147.91,56.23 147.91,56.97 149.94,58.99 149.94,64.05 153.25,67.37 153.25,70.86 153.76,71.37 153.76,74.42 155.9,76.55 172.77,76.55 184.47,88.25 184.47,134.88 187.42,137.83 187.42,139.1 187.93,139.61 189.2,139.61 190.08,140.5 190.08,141.32 189.23,142.18 189.23,144.47 190.08,145.32 190.08,145.39 192.05,147.36 192.05,149.77 192.94,150.66 192.94,153.13 195.04,155.23 197.13,155.23 200.24,158.34 200.24,163.45 209.31,172.52 209.31,183.29 208.02,184.58 207.55,184.58 v4(207.55,184.58)
  S16 w0.127: v1(151.88,33.24) 150.99,34.13 150.99,37.64 149.57,39.07 149.57,45.92 148.04,47.44 148.04,48.13 148.93,49.02 148.93,49.74 148.04,50.62 148.04,51.45 148.58,51.98 148.58,52.6 147.27,53.9 CONN55_PF.3T3
  BOTTOM w0.127: v2(210.42,183.99) 209.53,184.88 207.93,184.88 207.62,184.58 v4(207.55,184.58) ; v2(152.79,33.02) 152.56,33.24 v1(151.88,33.24) RB466.1
TXDIS_18: length 201.3
  TOP w0.127: v4(204.55,188.58) U9.L15
  S5 w0.127: CONN55_PF.3L3 150.26,54.19 151.13,55.05 151.13,55.05 153.01,56.92 153.01,58.45 157.98,63.43 157.98,69.38 158.05,69.44 158.05,72.81 161.03,75.79 173.17,75.79 185.47,88.09 185.47,134.17 190.91,139.61 190.91,144.82 194.59,148.5 198.08,148.5 202.21,152.63 202.21,155.62 202.59,156 202.59,164.51 210.13,172.05 210.13,185.14 208.17,187.09 206.29,187.09 205.98,187.4 205.98,187.75 205.73,188.01 205.12,188.01 v4(204.55,188.58)
  S14 w0.127: v1(149.47,36.29) 149.47,41.48 149.87,41.88 149.87,45.79 152.47,48.39 152.47,49.04 151.86,49.65 151.42,49.65 150.26,50.81 CONN55_PF.3L3
  BOTTOM w0.127: RB576.1 v1(149.47,36.29) 149.47,36.02 149.7,35.79 153.76,35.79 154.59,36.61 v2(154.59,38.26)
TXDIS_19: length 200.5
  TOP w0.127: U9.G14 v4(203.55,193.58)
  S5 w0.127: v4(203.55,193.58) 203.09,193.12 203.09,191.28 204.36,190.01 208.02,190.01 211.81,186.22 211.81,171.08 205.07,164.34 205.07,153.26 198.66,146.85 197.39,146.85 195.55,145.01 193.83,145.01 192.24,143.42 192.24,137.32 190.68,135.76 190.68,133.23 187.35,129.9 187.35,87.53 176.65,76.84 176.65,65.83 174.29,63.47 171.16,63.47 170.4,62.71 165.47,62.71 164.01,61.25 164.01,58.81 161.18,55.98 161.18,55.24 160.51,54.58 CONN55_PF.4T3
  S16 w0.127: v1(166.13,33.24) 165.24,34.13 165.24,37.64 164.02,38.86 164.02,45.71 162.29,47.44 162.29,48.13 163.18,49.02 163.18,49.74 162.29,50.62 162.29,51.61 162.83,52.14 162.83,52.6 161.52,53.9 CONN55_PF.4T3
  BOTTOM w0.127: v2(167.04,33.02) 166.81,33.24 v1(166.13,33.24) RB445.1
TXDIS_20: length 193.2
  TOP w0.127: U9.G15 v4(204.55,193.58)
  S5 w0.127: CONN55_PF.4L3 164.51,54.06 167.61,57.15 167.61,58.58 171.54,62.52 174.53,62.52 177.7,65.69 177.7,76.54 188.2,87.03 188.2,129.15 196.24,137.19 196.24,144.14 198.08,145.98 200.33,145.98 204.5,150.15 205.39,150.15 206.53,151.3 206.53,160.94 212.78,167.18 212.78,187.92 211.31,189.39 209.94,189.39 208.42,190.9 206.44,190.9 205.1,192.25 205.1,193.03 v4(204.55,193.58)
  S14 w0.127: CONN55_PF.4L3 164.51,50.81 165.67,49.65 166.11,49.65 166.72,49.04 166.72,48.39 164.12,45.79 164.12,41.88 163.72,41.48 v1(163.72,36.29)
  BOTTOM w0.127: v1(163.72,36.29) RB555.1 163,36.58 162.72,36.87 162.72,39.26 v2(162.74,39.28)
TXDIS_21: length 198.1
  TOP w0.127: v4(204.55,195.58) U9.E15
  S5 w0.127: CONN55_PF.5T3 174.76,54.58 175.43,55.24 175.43,55.98 178.8,59.36 178.8,61.49 181,63.69 181,64.81 181.83,65.63 186.12,65.63 189.62,69.13 189.62,128.48 199.23,138.08 199.23,138.91 202,141.68 202,143.18 203.22,144.4 208.04,144.4 208.3,144.65 208.3,147.72 209.07,148.5 209.07,160.49 214.72,166.14 214.72,178.98 215.48,179.74 215.48,187.78 212.36,190.9 210.73,190.9 208.55,193.09 206.29,193.09 205.02,194.36 205.02,195.11 v4(204.55,195.58)
  S16 w0.127: CONN55_PF.5T3 175.25,53.41 176.26,53.41 177.08,52.6 177.08,52.14 176.54,51.61 176.54,50.62 177.43,49.74 177.43,49.02 176.54,48.13 176.54,47.44 178.07,45.92 178.07,44.09 177.77,43.79 177.77,42.9 178.07,42.6 178.07,39.07 179.49,37.64 179.49,34.13 v1(180.38,33.24)
  BOTTOM w0.127: v2(181.29,33.02) 181.06,33.24 v1(180.38,33.24) RB448.1
TXDIS_22: length 193.8
  TOP w0.127: v4(205.55,195.58) U9.E16
  S5 w0.127: CONN55_PF.5L3 178.76,54.06 182.39,57.68 182.39,60.16 190.44,68.21 190.44,128.08 198.5,136.14 209.26,136.14 210.91,137.79 210.91,142.12 211.95,143.16 211.95,148.31 211.1,149.16 211.1,160.89 215.55,165.33 215.55,178.15 216.25,178.85 216.3,178.85 216.3,188.52 209.92,194.89 208.02,194.89 207.79,195.12 206.01,195.12 v4(205.55,195.58)
  S14 w0.127: v1(177.97,36.29) 177.97,41.48 178.37,41.88 v1(178.37,43.47) 178.37,45.79 180.97,48.39 180.97,49.04 180.36,49.65 179.92,49.65 178.76,50.81 CONN55_PF.5L3
  BOTTOM w0.127: v1(178.37,43.47) 178.44,43.53 179.55,43.53 v2(179.77,43.31) ; RB558.1 v1(177.97,36.29)
TXDIS_23: length 201.5
  TOP w0.127: v4(205.55,196.58) U9.D16
  S5 w0.127: CONN55_PF.6T3 190.04,53.9 191.18,55.04 191.18,55.83 190.59,56.41 190.59,57 192.72,59.13 192.72,62.12 193.99,63.38 193.99,71.95 192.04,73.9 192.04,127.4 199.39,134.76 210.82,134.76 212.79,136.73 212.79,141.78 213.73,142.72 213.73,160.63 217.07,163.97 217.07,176.82 217.77,177.52 217.77,191.07 211.18,197.66 208.55,197.66 208.02,197.13 206.44,197.13 205.89,196.58 v4(205.55,196.58)
  S16 w0.127: CONN55_PF.6T3 189.86,53.06 190.87,53.06 191.33,52.6 191.33,52.14 190.79,51.61 190.79,50.62 191.68,49.74 191.68,49.02 190.79,48.13 190.79,47.44 192.32,45.92 192.32,44.11 191.74,43.53 191.74,42.91 192.32,42.33 192.32,39.07 193.74,37.64 193.74,34.13 v1(194.63,33.24)
  BOTTOM w0.127: RB451.1 v1(194.63,33.24) 195.31,33.24 v2(195.54,33.02)
TXDIS_24: length 201.1
  TOP w0.127: v4(205.56,197.57) U9.C17
  S5 w0.127: CONN55_PF.6L3 193.01,54.06 196.64,57.68 196.64,60.68 197.84,61.88 197.84,80.29 193.12,85.01 193.12,126.84 197.52,131.24 200.24,131.24 202.04,133.04 211.95,133.04 212.97,134.06 212.97,135.23 213.81,136.07 213.81,141.12 214.96,142.27 214.96,150.47 215.6,151.11 215.6,160.32 218.15,162.87 218.15,169.01 219.55,170.41 219.55,175.36 218.72,176.18 218.72,191.64 211.05,199.31 207.99,199.31 207.76,199.08 207.28,199.08 207.03,198.83 207.03,198.37 206.54,197.89 205.89,197.89 v4(205.56,197.57)
  S14 w0.127: v1(192.22,36.29) 192.22,41.48 192.62,41.88 v1(192.62,43.15) 192.62,45.79 195.22,48.39 195.22,49.04 194.61,49.65 194.17,49.65 193.01,50.81 CONN55_PF.6L3
  BOTTOM w0.127: v1(192.62,43.15) 194.47,43.15 v2(194.53,43.09) ; RB561.1 v1(192.22,36.29)
TXFLT_01: length 318.9
  TOP w0.127: v4(196.55,197.58) U9.C8
  S5 w0.127: v4(196.55,197.58) 197.09,198.12 197.09,200.19 196.52,200.76 194.59,200.76 193.14,202.21 185.13,202.21 183.86,200.94 183.3,200.94 182.97,201.27 179.98,201.27 179.2,200.49 179.2,200.32 174.31,195.43 174.31,176.85 170.97,173.52 170.97,172.57 168.46,170.06 167.19,170.06 163.86,166.72 161.95,166.72 156.17,160.94 140.32,160.94 135.74,156.36 135.74,153.89 134.65,152.8 134.65,150.01 131.36,146.72 126.65,146.72 122.32,142.39 122.32,139.04 123.56,137.79 123.56,135.06 122.6,134.1 122.6,119.65 120.06,117.11 120.06,109.04 120.67,108.43 120.67,102.73 122.43,100.97 122.43,92.4 119.94,89.92 84.23,89.92 76.42,82.1 72.19,82.1 70.44,80.35 50.18,80.35 44.72,74.89 44.72,69.7 42.87,67.84 38.07,67.84 37.3,67.08 37.3,66.01 37.06,65.76 36.36,65.76 35.91,65.31 35.91,62.96 32.09,59.14 28.56,59.14 27.83,58.4 27.83,56.89 CONN54_PF.1T2
  S14 w0.102: 28.41,52.95 24.69,52.95
  S14 w0.127: 28.41,52.95 29.49,54.02 29.49,55.23 CONN54_PF.1T2 ; 24.69,52.95 22.41,50.67 22.41,45.99 27.72,40.68 27.72,36.15 28.53,35.33 v1(28.53,35.27)
  BOTTOM w0.127: v2(27.39,35.46) 27.58,35.27 v1(28.53,35.27) RB490.1
TXFLT_02: length 295.5
  TOP w0.127: U9.F6 v4(194.55,194.58)
  S5 w0.127: v4(194.55,194.58) 194.07,195.06 194.07,195.73 192.65,197.15 192.22,197.15 192.09,197.28 192.09,197.84 191.76,198.17 191.23,198.17 191.07,198.32 191.07,198.8 190.82,199.06 188.32,199.06 186.46,197.2 179.34,197.2 176.36,194.22 176.36,174.46 168.68,166.79 166.93,166.79 164.2,164.06 162.53,164.06 157.13,158.66 141.49,158.66 137.96,155.13 137.96,147.89 134.58,144.5 127.85,144.5 125.75,142.39 125.75,134.82 126.58,133.98 126.58,93.42 120.68,87.52 85.23,87.52 77.41,79.7 72.93,79.7 71.6,78.37 51.52,78.37 47.12,73.97 47.12,67.73 40.48,61.08 40.48,57.73 38.75,56 38.75,55.29 36.94,53.48 36.36,53.48 35.01,52.13 CONN54_PF.1L2
  S9 w0.127: CONN54_PF.1L2 36.48,49.44 36.48,48.36 35.84,47.72 35.84,47.41 33.94,45.5 33.94,43.6 v1(33.93,43.6) 33.33,43 33.33,41.64 32.76,41.06 32.76,36.84 33.2,36.39 v1(33.2,36.28)
  BOTTOM w0.127: v1(33.93,43.6) 34.59,43.6 v2(34.75,43.44) ; v1(33.2,36.28) RB455.1
TXFLT_03: length 282.9
  TOP w0.127: v4(191.55,196.58) U9.D3
  S5 w0.127: v4(191.55,196.58) 191.1,197.03 191.1,197.61 190.69,198.02 189.37,198.02 188.24,196.89 187.42,196.89 187.1,196.57 179.53,196.57 176.94,193.98 176.94,193.93 176.88,193.87 176.88,193.12 176.86,193.1 176.86,174.14 168.94,166.22 167.41,166.22 164.59,163.4 162.8,163.4 157.44,158.04 141.91,158.04 138.69,154.81 138.69,147.27 133.86,142.45 133.86,138.57 127.09,131.79 127.09,93.06 120.82,86.79 85.64,86.79 77.86,79 72.95,79 71.81,77.86 61.31,77.86 57.34,73.89 57.34,68.07 55.08,65.81 50,65.81 48.66,64.47 48.66,63.55 46.54,61.43 45.57,61.43 42.14,57.99 42.14,56.83 CONN54_PF.2T2
  S14 w0.127: v1(42.97,35.27) 43.04,35.27 43.86,36.09 43.86,37.95 44.24,38.33 44.24,40.1 43.96,40.38 43.96,40.79 45.23,42.06 45.23,47.62 46.83,49.22 46.83,50.11 46.29,50.65 46.29,51.33 46.78,51.81 46.78,52.83 46.17,53.44 45.66,53.44 43.79,55.3 CONN54_PF.2T2
  BOTTOM w0.127: RB493.1 v1(42.97,35.27) 42.33,35.27 v2(42.16,35.45)
TXFLT_04: length 267.3
  TOP w0.127: v4(191.55,192.58) U9.H3
  S5 w0.127: v4(191.55,192.58) 191.43,192.58 191.04,192.19 189.24,192.19 187.48,193.95 181.18,193.95 178.39,191.16 178.39,173.04 169.66,164.31 167.99,164.31 165.45,161.77 163.56,161.77 161.06,159.27 161.06,156.58 157.78,153.29 156.92,153.29 156.61,152.99 156.61,152.61 156.25,152.25 145,152.25 143.98,151.23 143.98,149.83 142.08,147.93 142.08,146.83 136.27,141.03 136.27,138.67 128.72,131.11 128.72,92.31 121.44,85.04 86.3,85.04 78.57,77.3 73.86,77.3 72.43,75.88 62.18,75.88 59.4,73.1 59.4,67.49 52.44,60.53 52.44,57.55 50.94,56.06 50.94,53.79 49.26,52.11 CONN54_PF.2L2
  S14 w0.127: CONN54_PF.2L2 49.87,50.9 51.15,49.63 51.15,48.51 48.5,45.87 48.5,45.06 47.34,43.89 v1(47.34,43.34) 47.34,36.62 v1(47.67,36.29)
  BOTTOM w0.127: RB458.1 v1(47.67,36.29) ; v1(47.34,43.34) 47.4,43.41 v2(48.23,43.41)
TXFLT_05: length 265
  TOP w0.127: v4(192.55,192.58) U9.H4
  S5 w0.127: CONN54_PF.3T2 56.6,56.61 56.6,58.29 61.81,63.5 64.74,63.5 69.51,68.27 69.51,72.6 72.09,75.18 72.99,75.18 74.49,76.68 79.33,76.68 86.92,84.27 121.4,84.27 129.3,92.18 129.3,130.9 137.06,138.67 137.06,140.86 142.71,146.5 142.71,147.67 144.81,149.77 144.81,151.1 145.38,151.67 156.87,151.67 157.03,151.83 158.07,151.83 158.87,152.63 158.87,153.67 161.64,156.44 161.64,159.1 163.74,161.2 165.64,161.2 168.05,163.61 169.7,163.61 179.02,172.93 179.02,190.02 182.32,193.31 187.24,193.31 189.37,191.18 191.71,191.18 192.01,191.48 192.01,191.62 192.55,192.15 v4(192.55,192.58)
  S9 w0.127: v1(57.22,34.25) 58.13,35.17 58.13,40.66 59.07,41.6 59.07,45.54 56.51,48.11 56.51,52.5 57.91,53.91 CONN54_PF.3T2
  BOTTOM w0.127: RB469.1 v1(57.22,34.25) 55.07,34.25 v2(54.65,34.67)
TXFLT_06: length 250
  TOP w0.127: v4(189.55,189.58) U9.K1
  S5 w0.127: CONN54_PF.3L2 63.51,51.66 65.19,53.34 65.19,56.26 66.69,57.76 66.69,62.02 71.57,66.9 71.57,71.93 72.81,73.17 77.64,73.17 79.31,74.85 80.41,74.85 88.05,82.5 122.36,82.5 131.28,91.42 131.28,130.54 139.96,139.21 140.73,139.21 142.01,140.5 143.28,140.5 144.3,141.51 144.3,142.85 147.16,145.7 151.86,145.7 154.08,147.93 158.84,147.93 159.54,148.63 159.54,149.58 161.51,151.55 161.51,153.68 164.5,156.67 165.93,156.67 166.94,157.67 166.94,160.21 168.56,161.83 170.78,161.83 181.58,172.63 181.58,177.33 181.19,177.71 181.19,179.17 182.46,180.44 182.46,182.9 183.44,183.87 184.43,183.87 184.88,184.31 184.88,185.11 186.1,186.33 187.14,186.33 187.6,186.8 187.6,188.12 188.81,189.33 189.3,189.33 v4(189.55,189.58)
  S7 w0.127: CONN54_PF.3L2 65.24,49.17 65.24,48.33 62.6,45.69 62.6,41.83 64.99,39.44 64.99,34.91 v1(64.33,34.25)
  BOTTOM w0.127: v2(67.27,35.66) 67.28,35.66 65.67,34.05 64.53,34.05 v1(64.33,34.25) RB434.1
TXFLT_07: length 243.9
  TOP w0.127: v4(189.55,188.58) U9.L1
  S5 w0.127: v4(189.55,188.58) 189.13,188.58 188.37,187.81 188.37,186.1 185.66,183.39 185.66,181.72 184.88,180.94 184.88,180.88 184.32,180.33 184.32,179.04 183.84,178.57 182.23,178.57 182,178.34 182,177.67 182.08,177.58 182.08,172.11 170.61,160.64 170.61,159.13 170.02,158.53 170.02,157.7 169.51,157.2 167.35,157.2 166.24,156.09 164.84,156.09 162.21,153.45 162.21,148.94 160.68,147.42 154.38,147.42 152.05,145.09 150.17,145.09 148.24,143.16 148.24,141.64 147.54,140.94 144.55,140.94 143.54,139.93 142.27,139.93 140.94,138.59 140.21,138.59 132.1,130.48 132.1,91.14 122.77,81.81 88.18,81.81 82.64,76.27 82.64,67.97 82.62,67.97 77.03,62.38 75.02,62.38 73.6,60.96 73.6,59.84 72.74,58.98 71.62,58.98 70.79,58.14 70.79,56.68 CONN54_PF.4T2
  S9 w0.127: CONN54_PF.4T2 72.16,53.91 70.76,52.5 70.76,48.11 73.32,45.54 73.32,41.6 72.38,40.66 72.38,35.17 v1(71.47,34.25)
  BOTTOM w0.127: RB472.1 v1(71.47,34.25) 69.32,34.25 v2(68.9,34.67)
TXFLT_08: length 243.8
  TOP w0.127: v4(191.55,187.58) U9.M3
  S5 w0.127: CONN54_PF.4L2 77.76,52.3 79.44,53.98 79.44,56.06 80.94,57.55 80.94,59.18 84.41,62.65 84.41,75.7 88.64,79.93 123.5,79.93 133.82,90.25 133.82,126.95 134.38,127.51 135.88,127.51 136.8,128.42 136.8,132.56 140.48,136.24 143.54,136.24 146.59,139.29 149.96,139.29 150.59,139.93 163.48,139.93 164.3,140.75 164.3,142.72 165.95,144.37 165.95,146.85 165.64,147.17 165.64,148.18 166.59,149.13 166.59,149.51 167.41,150.34 169.45,150.34 171.29,152.18 171.29,155.74 177.65,162.1 177.65,165.1 185.32,172.77 185.32,175.93 187.54,178.15 187.54,182.85 190.14,185.44 190.14,186.87 190.41,187.14 190.85,187.14 191.23,187.53 191.5,187.53 v4(191.55,187.58)
  S7 w0.127: v1(78.58,34.25) 79.24,34.91 79.24,39.44 76.85,41.83 76.85,45.69 79.49,48.33 79.49,49.17 CONN54_PF.4L2
  BOTTOM w0.127: RB437.1 v1(78.58,34.25) 79.52,34.25 v2(81.94,36.68)
TXFLT_09: length 227.7
  TOP w0.127: v4(190.55,183.58) U9.T2
  S5 w0.127: CONN54_PF.5T2 84.92,56.8 84.92,58.02 89.1,62.2 90.77,62.2 94.38,65.81 101.17,65.81 104.49,69.12 104.49,75.72 108.06,79.29 123.77,79.29 134.64,90.16 134.64,115.78 136.55,117.7 136.55,127.15 137.38,127.97 137.38,132.31 140.68,135.61 145.32,135.61 145.54,135.38 146.95,135.38 150.92,139.35 163.99,139.35 165.07,140.43 165.07,142.15 168.2,145.28 169.03,145.28 169.6,145.86 169.6,149.52 173.07,152.99 173.07,153.9 172.43,154.53 172.43,156.12 178.53,162.21 178.53,165.26 185.97,172.7 185.97,175.68 188.43,178.14 188.43,182.42 189.14,183.13 190.01,183.13 190.45,183.58 v4(190.55,183.58)
  S9 w0.127: v1(85.72,34.25) 86.63,35.17 86.63,40.66 87.57,41.6 87.57,45.54 85.01,48.11 85.01,52.5 86.41,53.91 CONN54_PF.5T2
  BOTTOM w0.127: RB475.1 v1(85.72,34.25) 83.57,34.25 v2(83.15,34.67)
TXFLT_10: length 225.7
  TOP w0.127: U9.U3 v4(191.55,182.58)
  S5 w0.127: CONN54_PF.5L2 92.01,51.96 93.69,53.64 93.69,56.06 95.19,57.55 95.19,60.53 98.32,63.65 101.55,63.65 106.13,68.23 106.13,74.42 109.15,77.44 124.68,77.44 136.93,89.7 136.93,101.95 144.11,109.13 144.11,113.99 138.83,119.28 138.83,126.87 139.65,127.7 144.48,127.7 148.99,132.21 151.44,132.21 155.79,136.56 166.14,136.56 171.29,141.7 171.29,144.7 172.44,145.85 172.44,148.76 174.59,150.91 174.59,151.23 175.92,152.56 175.92,155.48 176.62,156.18 178.72,156.18 180.75,158.21 180.75,163.55 181.94,164.74 181.94,165.77 181.96,165.79 181.96,165.81 191.29,175.14 191.29,179.3 191.13,179.46 191.13,181.89 191.55,182.31 v4(191.55,182.58)
  S7 w0.127: CONN54_PF.5L2 92.01,50.9 93.74,49.17 93.74,48.33 91.1,45.69 91.1,44.34 91.41,44.04 91.41,41.53 93.49,39.44 93.49,34.91 v1(92.83,34.25)
  BOTTOM w0.127: RB440.1 v1(92.83,34.25) 93.87,34.25 v2(96.36,36.74)
TXFLT_11: length 235.5
  TOP w0.127: v4(192.55,186.58) U9.N4
  S5 w0.127: v4(192.55,186.58) 193.06,186.07 193.06,181.25 191.87,180.07 191.87,174.93 182.5,165.55 182.5,164.53 181.26,163.29 181.26,157.83 178.91,155.48 178.91,154.59 177.26,152.94 177.26,146.47 176.5,145.7 175.35,145.7 174.33,144.68 174.33,143.99 173.8,143.46 173.11,143.46 172.56,142.91 172.56,141.13 177.17,136.52 177.17,93.23 168.77,84.83 146.24,84.83 142.68,81.27 130.46,81.27 125.97,76.78 109.32,76.78 106.67,74.13 106.67,67.94 101.79,63.07 99.56,63.07 98.52,62.02 98.52,58.88 98.95,58.44 98.95,57.02 CONN54_PF.6T2
  S9 w0.127: CONN54_PF.6T2 100.66,53.91 99.26,52.5 99.26,48.11 101.82,45.54 101.82,41.6 100.88,40.66 100.88,35.17 v1(99.97,34.25)
  BOTTOM w0.127: v2(97.4,34.67) 97.82,34.25 v1(99.97,34.25) RB478.1
TXFLT_12: length 227.5
  TOP w0.127: U9.V8 197.05,181.03 v4(196.74,180.72)
  S5 w0.127: CONN54_PF.6L2 106.26,52.22 107.94,53.9 107.94,56.06 109.44,57.55 109.44,62.92 112.16,65.64 112.16,71.82 113.53,73.19 126.09,73.19 131.63,78.73 143.25,78.73 147.2,82.67 169.82,82.67 178.69,91.55 178.69,137.6 177.83,138.47 177.83,139.42 179.04,140.63 179.04,144.63 180.62,146.21 180.62,146.53 181.45,147.36 181.45,147.8 180.93,148.32 180.93,153.57 182.97,155.61 182.97,160.75 184.87,162.65 184.87,165.54 189.28,169.95 192.67,169.95 192.81,170.09 192.81,172.91 196.56,176.66 196.56,180.54 v4(196.74,180.72)
  S7 w0.127: v1(107.08,34.25) 107.74,34.91 107.74,39.44 105.35,41.83 105.35,45.69 107.99,48.33 107.99,49.17 CONN54_PF.6L2
  BOTTOM w0.127: v2(110.65,36.74) 107.96,34.05 107.28,34.05 v1(107.08,34.25) RB443.1 ; v2(196.75,177.77) 196.75,179.78 196.74,179.79 v4(196.74,180.72)
TXFLT_13: length 220.8
  TOP w0.127: v4(197.55,181.58) U9.V9
  S5 w0.127: v4(197.55,181.58) 197.55,179.78 197.25,179.47 197.25,176.63 194.28,173.65 194.28,170.66 192.92,169.3 189.35,169.3 185.48,165.43 185.48,162.44 184.31,161.27 184.31,156.13 182.27,154.1 182.27,147.29 181.13,146.15 181.13,145.96 179.61,144.43 179.61,139.13 179.2,138.72 179.2,91.16 170.08,82.04 147.46,82.04 143.36,77.94 132.29,77.94 126.77,72.43 116.18,72.43 115.25,71.5 115.25,57.02 CONN55_PF.1T2
  S9 w0.127: v1(116.27,34.25) 117.18,35.17 117.18,40.66 118.12,41.6 118.12,45.49 115.56,48.06 115.56,52.5 116.96,53.91 CONN55_PF.1T2
  BOTTOM w0.127: v2(198.64,178.03) 197.55,179.12 v4(197.55,181.58) ; v2(113.7,34.67) 114.12,34.25 v1(116.27,34.25) RB496.1
TXFLT_14: length 211.1
  TOP w0.127: v4(199.55,183.58) U9.T10
  S5 w0.127: CONN55_PF.1L2 122.56,52.25 124.24,53.93 124.24,56.06 125.74,57.55 125.74,59.58 129.67,63.51 130.52,63.51 131.24,64.23 131.24,66.07 134.55,69.38 134.55,72.21 138.24,75.9 143.94,75.9 148.29,80.25 170.82,80.25 170.94,80.37 180.98,90.41 180.98,137.96 181.51,138.5 181.51,142.74 181.68,142.9 181.68,142.92 182.02,143.26 182.04,143.26 182.53,143.75 182.53,144.88 182.85,145.2 182.85,145.32 183.86,146.34 183.86,151.4 187.93,155.46 187.93,161.77 187.35,162.34 187.35,165.15 189.37,167.17 194.15,167.17 199.89,172.91 199.89,182.8 199.56,183.13 199.56,183.57 v4(199.55,183.58)
  S7 w0.127: CONN55_PF.1L2 122.99,50.48 124.25,49.22 124.25,48.29 121.65,45.69 121.65,41.89 124.04,39.5 124.04,34.91 v1(123.38,34.25)
  BOTTOM w0.127: v2(127.03,36.74) 124.34,34.05 123.58,34.05 v1(123.38,34.25) RB461.1
TXFLT_15: length 212.5
  TOP w0.127: v4(200.55,186.58) U9.N11
  S5 w0.127: CONN55_PF.2T2 129.5,57.02 129.5,58.57 128.64,59.43 128.64,60.61 130.19,62.15 134.86,62.15 135.65,62.94 135.65,71.36 137.99,73.7 145.25,73.7 145.51,73.95 145.51,76.3 148.89,79.68 171.45,79.68 181.49,89.71 181.49,137.61 183.99,140.12 183.99,145.64 184.5,146.15 184.5,151 190.36,156.86 191.97,156.86 192.5,157.39 192.5,158.4 193.2,159.1 193.7,159.1 195.88,161.28 195.88,163.97 200.6,168.69 200.6,179.53 201.95,180.88 201.95,181.56 201.95,181.56 201.95,181.74 201.72,181.97 201.53,181.97 201.13,182.37 201.13,186 v4(200.55,186.58)
  S9 w0.127: CONN55_PF.2T2 131.21,53.91 129.81,52.5 129.81,48.06 132.37,45.49 132.37,41.6 131.43,40.66 131.43,35.17 v1(130.52,34.25)
  BOTTOM w0.127: RB499.1 v1(130.52,34.25) 128.37,34.25 v2(127.95,34.67)
TXFLT_16: length 206.8
  TOP w0.127: v4(204.55,183.58) U9.T15
  S5 w0.127: v4(204.55,183.58) 204.55,183.37 205.04,182.88 205.04,181.38 204.5,180.83 204.5,169.55 198.19,163.25 198.19,160.29 197.32,159.42 197.32,157.77 196.4,156.85 194.75,156.85 192.12,154.21 191.23,154.21 189.02,152 189.02,147.61 189.4,147.23 189.4,146.2 187.97,144.78 187.97,141.31 186.11,139.44 186.11,138.52 183.15,135.56 183.15,88.85 172.13,77.82 153.25,77.82 152.56,77.12 152.56,72.43 151.67,71.54 151.67,67.73 146.78,62.84 142.85,62.84 139.99,59.99 139.99,57.55 138.49,56.06 138.49,53.87 136.81,52.19 CONN55_PF.2L2
  S7 w0.127: CONN55_PF.2L2 137.24,50.48 138.5,49.22 138.5,48.29 135.9,45.69 135.9,43.96 135.35,43.41 135.35,42.44 138.29,39.5 138.29,34.91 v1(137.63,34.25)
  BOTTOM w0.127: v4(204.55,183.58) 204.09,183.12 204.09,181.12 v2(204.89,180.32) ; v2(141.51,36.8) 138.76,34.05 137.83,34.05 v1(137.63,34.25) RB464.1
TXFLT_17: length 198.5
  TOP w0.127: v4(207.55,182.58) U9.U18
  S5 w0.127: CONN55_PF.3T2 143.98,56.78 143.98,58.19 143.27,58.9 143.27,61.24 144.16,62.13 146.97,62.13 152.49,67.65 152.49,71.05 153.06,71.62 153.06,74.92 155.33,77.19 172.51,77.19 183.84,88.51 183.84,135.35 186.75,138.27 186.75,139.32 188.51,141.08 188.51,144.56 188.53,144.58 188.53,144.6 191.42,147.48 191.42,150.47 192.24,151.29 192.24,153.45 194.85,156.06 196.82,156.06 198.02,157.26 198.02,159.23 199.16,160.37 199.16,163.27 205.75,169.85 205.75,171.29 208.68,174.22 208.68,182.02 208.25,182.45 207.68,182.45 v4(207.55,182.58)
  S16 w0.127: v1(144.77,34.25) 145.68,35.17 145.68,40.66 146.62,41.6 146.62,45.49 144.06,48.06 144.06,52.5 145.46,53.91 CONN55_PF.3T2
  BOTTOM w0.127: v2(209.2,181.96) 208.17,181.96 v4(207.55,182.58) ; v2(142.2,34.67) 142.62,34.25 v1(144.77,34.25) RB502.1
TXFLT_18: length 201
  TOP w0.127: v4(205.55,188.58) U9.L16
  S5 w0.127: CONN55_PF.3L2 151.06,50.9 151.06,52.77 152.74,54.45 152.74,56.3 153.26,56.82 153.26,58.2 159.08,64.01 159.08,69.95 159.14,70.02 159.14,73.17 161.51,75.54 173.37,75.54 185.79,87.96 185.79,133.98 191.23,139.42 191.23,144.68 193.9,147.36 195.44,147.36 196.27,148.18 198.12,148.18 203.61,153.67 203.61,165.07 210.45,171.91 210.45,185.55 207.94,188.06 206.07,188.06 v4(205.55,188.58)
  S7 w0.127: CONN55_PF.3L2 152.75,49.22 152.75,48.29 150.15,45.69 150.15,41.89 152.54,39.5 152.54,34.91 v1(151.88,34.25)
  BOTTOM w0.127: v2(156.37,36.76) 153.86,34.25 v1(151.88,34.25) RB467.1
TXFLT_19: length 194.7
  TOP w0.127: U9.L17 v4(206.55,188.58)
  S5 w0.127: CONN55_PF.4T2 158,57.02 158,58.6 157.6,59 157.6,61.07 162.91,66.37 162.91,70.39 166.16,73.64 175.24,73.64 175.56,73.97 175.56,76.91 186.64,87.99 186.64,133.94 191.74,139.04 191.74,144.24 193.45,145.96 195.48,145.96 197.07,147.55 198.3,147.55 204.37,153.62 204.37,164.64 211.11,171.37 211.11,185.83 207.74,189.2 207.43,189.2 206.81,188.58 v4(206.55,188.58)
  S16 w0.127: v1(159.02,34.25) 159.93,35.17 159.93,40.66 160.87,41.6 160.87,45.49 158.31,48.06 158.31,52.5 159.71,53.91 CONN55_PF.4T2
  BOTTOM w0.127: v2(156.45,34.67) 156.87,34.25 v1(159.02,34.25) RB481.1
TXFLT_20: length 204.4
  TOP w0.127: U9.J17 v4(206.55,191.58)
  S5 w0.127: v4(206.55,191.58) 206.97,191.16 208.6,191.16 210.07,189.69 211.44,189.69 213.16,187.97 213.16,167.08 207.02,160.94 207.02,151.04 206.34,150.36 206.34,148.69 203.31,145.66 198.41,145.66 196.58,143.83 196.58,137.15 188.5,129.07 188.5,86.91 178.06,76.46 178.06,63.32 177,62.27 171.67,62.27 167.96,58.56 167.96,57.02 166.99,56.06 166.99,53.39 165.31,51.71 CONN55_PF.4L2
  S7 w0.127: CONN55_PF.4L2 165.74,50.48 167,49.22 167,48.29 164.4,45.69 164.4,41.89 166.79,39.5 166.79,34.91 v1(166.13,34.25)
  BOTTOM w0.127: v4(206.55,191.58) 207.09,191.04 212.82,191.04 213.58,190.28 v2(213.58,190.22) ; RB446.1 v1(166.13,34.25) 166.33,34.05 167.01,34.05 v2(169.64,36.68)
TXFLT_21: length 198.6
  TOP w0.127: v4(204.55,194.58) U9.F15
  S5 w0.127: CONN55_PF.5T2 171.92,57.34 171.92,60.95 172.73,61.76 177.7,61.76 178.62,62.67 178.62,76.19 189.09,86.66 189.09,128.78 197.96,137.64 197.96,142.67 200.32,145.03 206.53,145.03 207.29,145.8 207.29,150.21 207.97,150.89 207.97,160.53 213.9,166.46 213.9,179.61 214.95,180.67 214.95,187.56 212.16,190.35 210.38,190.35 208.68,192.05 206.34,192.05 206.04,192.35 206.04,192.76 204.55,194.24 v4(204.55,194.58)
  S16 w0.127: v1(173.27,34.25) 174.18,35.17 174.18,40.66 174.74,41.22 174.74,45.87 172.56,48.06 172.56,52.5 173.96,53.91 CONN55_PF.5T2
  BOTTOM w0.127: v2(170.7,34.67) 171.12,34.25 v1(173.27,34.25) RB484.1
TXFLT_22: length 201.3
  TOP w0.127: U9.E18 207.5,195.53 v4(207.97,195.53)
  S5 w0.127: v4(207.97,195.53) 208.25,195.25 210.86,195.25 216.6,189.51 216.6,178.64 215.87,177.9 215.87,165.18 212.44,161.75 212.44,143.08 211.34,141.98 211.34,137.49 209.69,135.84 198.62,135.84 190.8,128.01 190.8,68.12 182.74,60.07 182.74,57.55 181.24,56.06 181.24,54.16 179.56,52.48 CONN55_PF.5L2
  S7 w0.127: CONN55_PF.5L2 179.99,50.48 181.25,49.22 181.25,48.29 178.65,45.69 178.65,44.11 178.97,43.79 178.97,43.09 178.65,42.77 178.65,41.89 181.04,39.5 181.04,34.91 v1(180.38,34.25)
  BOTTOM w0.127: v2(210.66,195.87) 208.31,195.87 v4(207.97,195.53) ; RB449.1 v1(180.38,34.25) 180.58,34.05 181.75,34.05 v2(184.37,36.68)
TXFLT_23: length 197.5
  TOP w0.127: U9.E17 v4(206.55,195.58)
  S5 w0.127: v4(206.55,195.58) 207.13,195.58 207.58,196.03 208.42,196.03 208.65,195.81 211.63,195.81 216.88,190.56 216.88,178.56 216.18,177.86 216.18,165.01 212.69,161.52 212.69,142.92 211.8,142.03 211.8,137.56 209.82,135.58 198.82,135.58 191.05,127.81 191.05,73.3 192.96,71.39 192.96,69.9 185.99,62.94 185.99,57.52 CONN55_PF.6T2
  S16 w0.127: v1(187.52,34.25) 188.43,35.17 188.43,40.66 189.37,41.6 189.37,45.49 186.81,48.06 186.81,53.26 188.21,54.67 188.21,55.3 CONN55_PF.6T2
  BOTTOM w0.127: RB487.1 v1(187.52,34.25) 185.37,34.25 v2(184.95,34.67)
TXFLT_24: length 205.7
  TOP w0.127: v4(205.55,198.58) U9.B16
  S5 w0.127: CONN55_PF.6L2 193.81,50.9 193.81,51.71 195.49,53.39 195.49,56.06 196.99,57.55 196.99,60.53 198.15,61.68 198.15,73.62 198.4,73.88 198.4,80.11 193.51,85.01 193.51,126.77 197.65,130.91 200.61,130.91 202.33,132.62 212.37,132.62 213.38,133.63 213.38,135.25 215.4,137.28 215.4,150.28 216,150.87 216.01,150.87 216.01,159.91 218.53,162.44 218.53,168.63 219.8,169.9 219.8,190.98 210.71,200.07 207.05,200.07 v4(205.55,198.58)
  S7 w0.127: CONN55_PF.6L2 195.5,49.22 195.5,48.29 193.26,46.05 193.26,41.53 195.29,39.5 195.29,34.91 v1(194.63,34.25)
  BOTTOM w0.127: v2(197.44,36.02) 195.47,34.05 194.83,34.05 v1(194.63,34.25) RB452.1
TXMSYNC_SET: length 136
  TOP w0.127: R1130.1 184.33,236.88 184.59,237.15 184.59,238.77 180.94,242.42 v1(180.94,243.24) ; P1.A11 94.76,219.94 v1(93.44,219.94)
  S9 w0.127: v1(180.94,243.24) 176.5,247.69 170.91,247.69 168.37,245.15 162.88,245.15 160.57,247.45 147.13,247.45 145.43,249.15 138.63,249.15 137.87,248.38 136.24,248.38 135.54,249.08 130.27,249.08 127.65,246.46 99.86,246.46 96.13,242.73 92.19,242.73 87.21,237.75 87.21,236.51 87.48,236.24 88.13,236.24 88.67,235.69 88.67,228.18 89.39,227.46 89.39,226.56 91.82,224.13 91.82,222.1 93.44,220.49 v1(93.44,219.94)
  BOTTOM w0.127: v1(180.94,243.24) 181.32,243.62 v2(181.32,244.51)
TXON_SET: length 101.6
  TOP w0.127: P1.W18 v4(113.29,227.46)
  S9 w0.127: v4(113.29,227.46) 113.29,227.47 113.71,227.89 116.25,227.89 118.63,230.27 120.22,230.27 122.46,232.51 125.25,232.51 125.53,232.79 135.68,232.79 136.86,231.61 144.93,231.61 147.59,228.95 166.27,228.95 167.35,230.03 167.99,230.03 172.94,234.99 175.61,234.99 176.59,235.97 182.23,235.97 182.85,236.58 182.85,237.97 183.35,238.48 186.15,238.48 187.86,236.76 187.86,234.03 187.48,233.65 187.48,224.19 v1(189,222.67)
  BOTTOM w0.127: R1093.1 189.09,222.58 v1(189,222.67) v2(187.73,222.67)
U72_PP: length 5.2
  TOP w0.127: v1(225.5,168.32) 225.7,168.51 U72.7
  BOTTOM w0.127: v2(224.21,169.42) 224.41,169.42 v1(225.5,168.32)
  BOTTOM w0.254: R1319.1 R1321.1 225.53,168.3 v1(225.5,168.32)
UART1_RX: length 281.5
  TOP w0.127: J2.A99 192.94,140.88 v1(192.88,140.94) ; RB1304.2 v1(235.7,149.73) ; R310.2 92.9,237.56 v1(92.93,237.59)
  S9 w0.127: v1(235.7,149.73) 235.7,148.97 233.26,146.53 223.36,146.53 221.74,144.91 221.72,144.91 221.37,144.56 221.37,144.54 220.06,143.23 v1(219.55,143.23)
  S14 w0.127: v1(219.55,143.23) 219.28,143.5 219.28,152.27 217.02,154.53 217.02,190.04 216.37,190.69 216.37,204.66 208.2,212.83 194.84,212.83 194.02,213.65 181.07,213.65 180.69,214.03 175.55,214.03 171.73,217.84 171.73,229.69 169.24,232.18 167.83,232.18 165.51,234.5 165.51,237.85 162.46,240.89 162.46,242.18 157.85,246.8 155.39,246.8 151.6,250.58 139.23,250.58 138.65,251.17 135.93,251.17 135.09,250.33 134.14,250.33 133.67,250.8 107.44,250.8 104.93,248.28 102.48,248.28 92.93,238.73 v1(92.93,237.59)
  BOTTOM w0.127: v1(192.88,140.94) 191.34,139.41 v2(191.34,138.74) 191.34,136.38 192.88,134.85 201.64,134.85 203.24,136.45 212.97,136.45 219.55,143.03 v1(219.55,143.23)
UART1_TX: length 333.5
  TOP w0.127: R714.2 203.29,96.36 v1(202.97,96.05) ; R259.2 95.3,237.21 95.3,237.77 94.73,238.35 v1(94.71,238.35) ; RB320.2 235.58,151.71 v1(235.55,151.74) ; v1(191.89,134.29) 191.87,134.29 191.93,134.35 191.93,138.34 192.44,138.85 J2.A98
  S9 w0.127: v1(220.12,142.28) 222.28,142.28 225.64,145.64 233.26,145.64 236.44,148.82 236.44,150.85 v1(235.55,151.74)
  S14 w0.127: v1(220.12,142.28) 219.4,142.28 216.87,144.81 216.87,145.21 215.47,146.61 215.47,150.6 216.31,151.44 216.31,189.92 215.77,190.46 215.77,204.17 208.58,211.36 191.82,211.36 190.99,212.19 190.97,212.19 190.91,212.25 181.38,212.25 181.13,212.51 171.92,212.51 170.34,214.09 170.34,227.15 164.22,233.26 164.22,235.7 157.14,242.78 157.14,244.54 156.27,245.41 154.06,245.41 150.06,249.41 138.39,249.41 137.8,250.01 136.51,250.01 135.77,249.28 133.55,249.28 133.37,249.45 109.1,249.45 106.71,247.06 103.08,247.06 94.71,238.69 v1(94.71,238.35)
  S16 w0.127: v1(202.97,96.05) 195.72,96.05 189.07,102.7 189.07,127.47 191.89,130.28 v1(191.89,134.29)
  BOTTOM w0.127: v1(191.89,134.29) 191.97,134.21 201.96,134.21 203.59,135.84 213.43,135.84 v2(217.77,140.18) 219.87,142.28 v1(220.12,142.28)
UART_TX+: length 19.1
  TOP w0.095: v3(252.22,48.76) 252.52,49.06 252.52,49.22 252.41,49.33 252.35,49.33 252.16,49.52 RB324.1 252.16,50.47 252.44,50.75 252.44,51.33 252.34,51.43 251.89,51.43 251.79,51.52 RB315.2
  BOTTOM w0.095: FB5.2 250.77,41.37 DB2.1 252.66,41.48 252.81,41.62 252.81,46.98 252.52,47.27 252.52,48.46 v3(252.22,48.76) 251.97,49.01 U54.2
UART_TX+_A: length 45.7
  TOP w0.095: RB315.1 251.79,54.41 251.89,54.5 252.34,54.5 252.44,54.6 252.44,56.99 v3(252.12,57.3) ; v1(240.49,79.12) 240.17,79.43 240.17,79.71 CB894.2 240.27,80.54 240.27,81.75 240.48,81.96 U51.2
  S7 w0.108: v1(240.49,79.12) 240.15,79.45 240.15,80.29 240.34,80.47 245.14,80.47 248.05,77.56 248.05,64.24 249.09,63.21 arc(249.13,63.09) 249.09,62.97 arc(249.04,62.85) 249.09,62.74 249.15,62.67 arc(249.27,62.62) 249.39,62.67 arc(249.51,62.72) 249.63,62.67 249.7,62.6 arc(249.75,62.48) 249.7,62.36 arc(249.65,62.24) 249.7,62.12 249.77,62.06 arc(249.88,62.01) 250,62.06 arc(250.12,62.1) 250.24,62.06 252.44,59.85 252.44,57.62 v3(252.12,57.3)
  BOTTOM w0.095: R946.1 240.3,80.07 240.3,79.31 v1(240.49,79.12) 240.41,79.12 240.17,78.88 240.17,78.27 240.81,77.63 LB59.2
UART_TX+_A_R: length 10.1
  TOP w0.127: U51.10 243.73,87.75 v1(243.9,87.58)
  BOTTOM w0.127: R946.2 240.71,83.87 243.9,87.07 v1(243.9,87.58) 244.19,87.86 v2(244.19,88.75)
UART_TX+_R: length 24.7
  S16 w0.108: v3(253.93,28.42) 254.33,28.03 254.33,24.54 252.28,22.49 252.28,17.86 249.99,15.56 248.61,15.56 248.26,15.91 248.26,16.27 248.87,16.88 RJ1.C8
  BOTTOM w0.095: v3(253.93,28.42) 254.29,28.78 254.29,29.17 253.93,29.52 252.86,29.52 252.5,29.88 252.5,31.65 252.24,31.91 FB5.1
UART_TX-: length 19.4
  TOP w0.095: v3(253.08,48.76) 252.75,49.09 252.75,49.26 252.83,49.33 252.98,49.33 253.07,49.43 RB324.2 253.07,50.42 252.67,50.82 252.67,51.33 252.76,51.43 253.22,51.43 253.32,51.52 RB314.2
  BOTTOM w0.095: FB4.2 255.01,38.26 DB1.1 253.27,41.48 253.04,41.71 253.04,47.07 252.75,47.36 252.75,48.42 v3(253.08,48.76) 253.24,48.91 U54.1
UART_TX-_A: length 45.7
  TOP w0.095: v3(252.99,57.3) 252.67,56.99 252.67,54.6 252.76,54.5 253.22,54.5 253.32,54.41 RB314.1 ; v1(239.63,79.12) 239.95,79.43 239.95,79.86 CB893.2 240.04,80.58 240.04,81.75 239.83,81.96 U51.1
  S7 w0.108: v1(239.63,79.12) 239.92,79.41 239.92,80.38 240.24,80.7 245.23,80.7 248.28,77.65 248.28,64.34 252.67,59.95 252.67,57.62 v3(252.99,57.3)
  BOTTOM w0.095: LB58.2 239.95,78.27 239.95,78.8 v1(239.63,79.12) 240.07,79.56 240.07,80.1 R945.1
UART_TX-_A_R: length 8.8
  TOP w0.127: U51.11 243.08,87.65 243.02,87.59 v1(243.02,87.59)
  BOTTOM w0.127: R945.2 v2(239.69,83.36) 243.02,86.69 v1(243.02,87.59)
UART_TX-_R: length 24.5
  S16 w0.108: v3(254.95,28.42) 254.56,28.03 254.56,24.45 252.51,22.4 252.51,17.76 250.08,15.34 248.61,15.34 247.84,14.57 RJ1.C7
  BOTTOM w0.095: FB4.1 253,31.91 252.73,31.64 252.73,29.98 252.96,29.75 254.03,29.75 254.52,29.26 254.52,28.85 v3(254.95,28.42)
UC_25M_R_CLK_N: length 1.4
  TOP w0.095: v4(25.7,116.65) U40.W32
  BOTTOM w0.095: U40.W32 v4(25.7,116.65)
UC_25M_R_CLK_P: length 1.4
  TOP w0.095: v4(25.7,115.65) U40.V32
  BOTTOM w0.095: U40.V32 v4(25.7,115.65)
UC_25M_REFCLK_N: length 166.3
  TOP w0.095: R399.1 102.82,187.86 102.82,188.32 v3(102.52,188.61)
  S5 w0.108: v3(102.52,188.61) 102.72,188.81 arc(102.77,188.89) 102.79,188.98 102.79,189.16 arc(102.64,189.52) 102.29,189.67 100.16,189.67 arc(98.2,190.06) 96.53,191.17 94.57,193.13 arc(93.9,193.58) 93.11,193.74 81.43,193.74 arc(79.07,193.27) 77.07,191.93 arc(76.71,191.69) 76.28,191.6 73.17,191.6 arc(72,191.37) 71,190.7 70.89,190.59 70.78,190.48 arc(70.65,190.39) 70.49,190.36 65,190.36 arc(62.37,189.84) 60.13,188.34 59.63,187.84 arc(58.86,186.69) 58.59,185.33 arc(58.48,184.78) 58.16,184.3 53.43,179.57 arc(52.98,179.27) 52.46,179.17 43.69,179.17 arc(41.25,178.68) 39.17,177.3 38.36,176.49 arc(36.1,174.98) 33.43,174.44 21.28,174.44 arc(21.15,174.42) 21.05,174.35 18.73,172.03 arc(18.66,171.92) 18.63,171.8 18.63,166.26 arc(18.59,166.05) 18.47,165.87 17.71,165.12 arc(17.64,165.01) 17.62,164.89 17.62,160.99 arc(17.64,160.87) 17.71,160.76 18.55,159.93 arc(18.67,159.75) 18.71,159.53 18.71,156.6 arc(18.74,156.47) 18.81,156.37 19.79,155.38 arc(19.91,155.2) 19.96,154.99 19.96,151.81 arc(20.02,151.48) 20.2,151.21 21.9,149.51 arc(22.02,149.33) 22.06,149.12 22.06,138.78 arc(22.03,138.62) 21.94,138.48 arc(21.84,138.34) 21.81,138.17 21.81,136.68 arc(21.81,136.55) 21.8,136.43 arc(21.57,135.62) 21.09,134.94 21.09,134.94 19.6,133.45 arc(19.53,133.34) 19.5,133.22 19.5,125.68 19.62,125.56 19.62,125.24 19.5,125.12 19.5,124.79 19.62,124.67 19.62,124.35 19.5,124.23 19.5,123.9 19.62,123.78 19.62,123.46 19.5,123.34 19.5,123.01 19.62,122.89 19.62,122.57 19.5,122.45 19.5,122.12 19.62,122 19.62,121.68 19.5,121.56 19.5,121.23 19.62,121.11 19.62,120.79 19.5,120.67 19.5,120.35 19.62,120.23 19.62,119.9 19.5,119.78 19.5,119.4 arc(19.53,119.28) 19.6,119.17 20.11,118.66 arc(20.23,118.48) 20.27,118.27 20.27,115.91 arc(20.29,115.84) 20.33,115.78 20.56,115.54 arc(20.73,115.43) 20.92,115.39 21.45,115.39 21.57,115.52 21.9,115.52 22.02,115.39 22.34,115.39 22.46,115.52 22.79,115.52 22.91,115.39 23.23,115.39 23.35,115.52 23.68,115.52 23.8,115.39 24.12,115.39 24.24,115.52 24.57,115.52 24.69,115.39 24.85,115.39 arc(25,115.37) 25.12,115.29 25.2,115.2 arc(25.25,115.17) 25.32,115.16 25.86,115.16 arc(25.98,115.18) 26.08,115.25 26.94,116.1 arc(27.11,116.22) 27.32,116.26 27.52,116.26 arc(27.58,116.27) 27.64,116.31 27.65,116.32 arc(27.69,116.37) 27.7,116.43 v4(27.7,116.65)
  BOTTOM w0.095: CB1062.1 v4(27.7,116.65)
UC_25M_REFCLK_P: length 166.3
  TOP w0.095: v3(103.34,188.61) 103.04,188.32 103.04,187.8 R400.1
  S5 w0.108: v4(27.7,115.65) 27.7,115.86 arc(27.69,115.92) 27.65,115.97 27.64,115.99 arc(27.58,116.02) 27.52,116.03 27.32,116.03 arc(27.2,116.01) 27.1,115.94 26.24,115.09 arc(26.07,114.97) 25.86,114.93 25.32,114.93 arc(25.17,114.96) 25.04,115.04 24.96,115.12 arc(24.91,115.16) 24.85,115.17 20.92,115.17 arc(20.64,115.22) 20.4,115.38 20.17,115.62 arc(20.08,115.75) 20.04,115.91 20.04,118.27 arc(20.02,118.39) 19.95,118.5 19.44,119.01 arc(19.32,119.19) 19.28,119.4 19.28,133.22 arc(19.32,133.43) 19.44,133.61 20.93,135.1 arc(21.37,135.72) 21.57,136.45 arc(21.58,136.56) 21.58,136.68 21.58,138.17 arc(21.63,138.43) 21.77,138.64 arc(21.82,138.71) 21.83,138.79 21.83,149.12 arc(21.81,149.24) 21.74,149.35 20.04,151.05 arc(19.81,151.4) 19.73,151.81 19.73,154.99 arc(19.7,155.11) 19.63,155.22 18.64,156.2 arc(18.52,156.38) 18.48,156.6 18.48,159.53 arc(18.46,159.66) 18.39,159.76 17.55,160.6 arc(17.43,160.78) 17.39,160.99 17.39,164.89 arc(17.43,165.1) 17.55,165.28 18.31,166.03 arc(18.38,166.14) 18.4,166.26 18.4,171.8 arc(18.44,172.01) 18.56,172.19 20.88,174.51 arc(21.06,174.63) 21.28,174.67 33.43,174.67 arc(36.01,175.19) 38.2,176.65 39.01,177.46 arc(41.16,178.89) 43.69,179.4 52.46,179.4 arc(52.9,179.48) 53.27,179.73 58,184.47 arc(58.27,184.86) 58.36,185.33 arc(58.65,186.78) 59.46,188 59.97,188.5 arc(62.28,190.05) 65,190.59 70.49,190.59 arc(70.56,190.6) 70.62,190.64 70.84,190.87 arc(71.91,191.58) 73.17,191.83 76.28,191.83 arc(76.62,191.9) 76.9,192.09 arc(78.98,193.48) 81.43,193.96 93.11,193.96 arc(93.99,193.79) 94.73,193.29 96.69,191.33 arc(98.28,190.27) 100.16,189.9 102.29,189.9 arc(102.81,189.68) 103.02,189.16 103.02,188.98 arc(103.03,188.93) 103.05,188.9 v3(103.34,188.61)
  BOTTOM w0.095: CB1061.1 v4(27.7,115.65)
UC_PLL_AVDD1P8: length 34.3
  TOP w0.381: v4(25.7,117.65) U40.Y32
  S14 w0.381: 25.02,116.31 25.02,116.82 25.7,117.5 v4(25.7,117.65)
  S14 w0.635: 25.02,116.31 24.26,115.55 21.08,115.55 19.95,114.41 19.95,112.38 18.48,110.92 14.19,110.92 9.2,105.93 9.2,103.17 v1(7.37,101.34) v1(7.37,100.58)
  BOTTOM w0.254: CB547.1 25.15,117.16 24.23,117.16 CB546.1 ; v1(7.37,101.34) 5.45,101.34 v2(5.3,101.19)
  BOTTOM w0.381: CB548.2 25.78,117.65 v4(25.7,117.65) 25.26,117.21 CB547.1
UC_PLL_LOCK: length 18.2
  TOP w0.127: v4(24.7,128.65) U40.AL33 ; v1(17.54,131.89) 17.51,131.93 R519.2 16.8,131.59 16.64,131.42 14.26,131.42 R518.1
  S12 w0.127: v4(24.7,128.65) 24.7,129.04 24.22,129.52 24.22,129.9 23.89,130.22 21.47,130.22 19.8,131.89 v1(17.54,131.89)
  BOTTOM w0.127: 17.54,133.88 17.54,134.69 v2(18.46,135.61)
  BOTTOM w0.13: 17.54,133.88 v1(17.54,131.89)
UCD9016_3V3: length 21.1
  TOP w0.508: D1.C 248.07,196.35 R539.1 v1(247.14,196.39) ; 230.12,207.16 C129.1 R206.2
  S16 w0.508: v1(247.14,196.39) 243.85,196.39 v1(234.92,205.33)
  BOTTOM w0.127: v2(234.09,205.14) 234.72,205.14 v1(234.92,205.33)
UCD9016_V33: length 7.9
  TOP w0.254: 233.3,213.74 233.58,214.03 U7.46
  TOP w0.508: R207.1 C122.2 232.93,210.53 C107.2 v1(232.93,213.38) 233.3,213.74
  BOTTOM w0.127: v2(233.07,212.25) 233.07,213.24 v1(232.93,213.38)
UCD9016_VDIO: length 27.1
  TOP w0.254: U7.44 232.58,214.17 ; 232.58,214.17 232.71,214.17 233.08,214.54 U7.45 ; 232.58,214.17 230.9,212.49 C106.2 ; v1(231.59,223.2) 231.58,223.22 U7.7
  TOP w0.508: v1(232.06,210.16) 231.87,209.97 C123.2 ; C123.2 231.08,208.75 R206.1 ; C123.2 230.9,210.15 C117.2 C106.2
  S12 w0.508: v1(231.59,223.2) 231.59,222.24 233.39,220.44 233.39,214.98 231.3,212.89 231.3,210.92 v1(232.06,210.16)
  BOTTOM w0.254: v1(231.59,223.2) 231.51,223.28 CB33.2 ; v2(232.18,209.01) 232.18,209.85 arc(232.15,210.02) v1(232.06,210.16)
UCD9090_ALERT_L: length 146.4
  TOP w0.127: P1.AA10 v4(115.29,218.46) ; v1(175.35,143.86) 175.71,143.51 175.71,140.87 175.95,140.62 176.73,140.62 176.94,140.42 J2.A67
  S5 w0.127: v4(115.29,218.46) 115.75,218.92 117.69,218.92 117.95,218.67 120.79,218.67 123.8,221.68 125.92,221.68 126.58,221.02 126.58,220.51 125.76,219.68 125.76,215.68 127.21,214.23 129.77,214.23 130.27,214.73 134.44,214.73 136,216.29 162.74,216.29 v1(163.03,216)
  S12 w0.127: v1(175.35,143.86) 172.71,146.51 172.71,160.44 177.51,165.24 177.51,188.02 172.88,192.66 172.88,194.35 171.22,196 171.22,209.2 164.43,216 v1(163.03,216)
  BOTTOM w0.127: v2(163.16,215.17) 163.16,215.87 v1(163.03,216)
UCD90160_A0: length 4.3
  TOP w0.254: R56.2 237.57,223.14 v1(237.1,222.67) 237.1,222.59 236.25,221.74 U7.61
  BOTTOM w0.127: v1(237.1,222.67) 237.1,223.78 v2(237.01,223.87)
UCD90160_A1: length 3.9
  TOP w0.254: U7.60 236.54,221.24 v1(236.99,221.69) 237.42,222.12 R57.2
  BOTTOM w0.127: v2(237.01,220.57) 236.99,220.59 v1(236.99,221.69)
UCD90160_ALERT_L: length 221.5
  TOP w0.127: v1(39.44,250.21) 39.44,253.48 38.11,254.81 CONN41.8 ; R97.2 223.85,218.3 v1(223.87,218.29) 223.91,218.24 U7.27
  S9 w0.127: v1(39.44,250.21) 39.5,250.16 81.25,250.16 86.63,244.78 94.09,244.78 99.72,250.42 146.78,250.42 147.6,249.59 170.84,249.59 171.08,249.83 176.51,249.83 177.15,249.19 199.6,249.19 199.62,249.17 199.63,249.17 215.21,233.59 218.72,233.59 222.75,229.56 222.75,219.4 v1(223.87,218.29)
  BOTTOM w0.127: v1(223.87,218.29) 223.74,218.29 v2(222.6,219.43)
UCD90160_CNTRL: length 6
  TOP w0.127: U7.28 224.66,217.74 224.12,217.21 v1(223.93,217.21) R708.2 R107.2
  BOTTOM w0.127: v1(223.93,217.21) 222.85,217.21 v2(222.53,217.52)
UCD90160_CNTRL_R: length 216
  TOP w0.127: CONN41.7 v1(38.11,248.52) ; R708.1 221.46,217.21 v1(221.39,217.14)
  S9 w0.127: v1(221.39,217.14) 221.39,217.22 222.02,217.85 222.02,224.95 220.95,226.03 220.95,229.14 217.71,232.38 215.1,232.38 199.1,248.38 188.75,248.38 188.31,247.94 170.15,247.94 167.92,245.72 163.57,245.72 161.14,248.15 147.14,248.15 145.76,249.53 138.52,249.53 137.7,248.7 136.68,248.7 136.05,249.34 101.31,249.34 95.18,243.2 83.89,243.2 79.15,247.94 38.7,247.94 v1(38.11,248.52)
  BOTTOM w0.127: v1(221.39,217.14) 221.2,216.95 v2(220.25,216.95)
UCD90160_INT: length 140.6
  TOP w0.127: v1(203.17,212.13) 220.86,212.13 222.67,210.31 225.85,210.31 226.69,211.15 R165.1
  TOP w0.508: P1.H14 v4(101.29,223.46)
  S9 w0.127: v1(203.17,212.13) 201.29,210.25 196.18,210.25 195.2,209.27 178.86,209.27 178.17,209.96 166.52,209.96 165.53,210.95 159.84,210.95 158.04,209.14 151.92,209.14 151.61,208.84 145.9,208.84 v1(145.15,209.59)
  S14 w0.127: v1(145.15,209.59) 145.15,212.12 141.1,216.17 136.13,216.17 135.3,215.34 133.66,215.34 132.88,216.12 132.01,216.12 131.87,215.97 130.68,215.97 129.4,217.25 126.49,217.25 125.39,218.35 121.8,218.35 121.54,218.62 118.94,218.62 118.63,218.92 117.9,218.92 117.27,219.56 117.27,220.31 117.02,220.56 105.83,220.56 104.42,221.97 102.98,221.97 102.79,222.16 102.79,222.71 102.65,222.85 101.89,222.85 v4(101.29,223.46)
  BOTTOM w0.508: v2(203.17,213.08) v1(203.17,212.13)
