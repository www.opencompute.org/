# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDRB_BG0: length 87.2
  TOP w0.127: U40.AR8 v4(50.7,132.65)
  TOP w0.13: v4(68.3,168.02) U15.M2 ; v4(57.76,168.02) U14.M2
  S5 w0.127: v4(68.3,168.02) 67.89,167.61 58.16,167.61 v4(57.76,168.02)
  S14 w0.127: v4(57.76,168.02) 57.94,167.83 58.05,167.83 58.16,167.95 58.16,172.06 58.92,172.82 60.29,172.82 60.68,172.43 60.68,170.99 61,170.67 61.81,170.67 61.97,170.52 61.97,170.15 61.82,170 61.56,170 60.99,169.43 60.99,165.88 62.46,164.41 63.08,164.41 63.1,164.42 64.21,164.42 64.79,163.85 66.87,163.85 67.1,163.62 67.1,162.91 66.87,162.68 64.74,162.68 64.48,162.43 64.48,162.07 64.74,161.82 66.61,161.82 66.72,161.72 66.72,153.67 53.63,140.59 53.63,138.06 51.3,135.73 51.3,134.48 50.97,134.14 50.55,134.14 50.24,133.83 50.24,133.41 50.7,132.96 v4(50.7,132.65)
  BOTTOM w0.127: v4(68.3,168.02) 67.89,168.42 67.23,168.42 67.09,168.56 67.09,171.39 67.38,171.68 67.61,171.68 69.56,173.62 RB66.2
DDRB_CAS_N: length 86.2
  TOP w0.127: v4(52.7,133.65) U40.AT6
  TOP w0.13: v4(52.16,168.02) U14.M8 ; v4(62.7,168.02) U15.M8
  S9 w0.127: v4(52.16,168.02) 52.55,168.41 62.3,168.41 v4(62.7,168.02)
  S14 w0.127: v4(52.16,168.02) 52.56,167.61 53.11,167.61 53.48,167.99 53.48,173.07 53.58,173.17 54.25,173.17 54.5,172.92 54.5,168.58 54.32,168.4 54.32,162.02 55.25,161.1 55.25,157.88 54.46,157.09 54.46,146.27 45.2,137.01 45.2,133.49 45.54,133.15 45.84,133.15 46.21,132.77 46.21,132.45 46.53,132.14 46.84,132.14 47.19,131.78 47.19,131.48 47.58,131.09 47.88,131.09 48.16,130.8 48.16,130.61 48.62,130.15 50.93,130.15 51.16,130.39 51.16,130.86 51.45,131.14 51.84,131.14 52.2,131.5 52.2,133.06 52.3,133.15 53.11,133.15 53.25,133.3 53.25,133.53 53.05,133.73 52.78,133.73 v4(52.7,133.65)
  BOTTOM w0.127: RB63.2 63.47,174.28 64.07,173.67 64.07,168.66 63.84,168.42 63.11,168.42 62.71,168.02 v4(62.7,168.02)
DDRB_CK_N: length 77.7
  TOP w0.095: U40.AM10 v4(48.7,129.65) ; v4(52.16,166.42) U14.K8 ; v4(63.5,166.42) U15.K8
  S5 w0.108: v4(63.5,166.42) 63.34,166.26 63.09,166.26 62.8,166.55 62.5,166.55 62.22,166.82 61.66,166.82 61.4,166.56 60.19,166.56 59.82,166.19 59.82,165.53 59.48,165.2 56.57,165.2 55.17,163.8 55.17,160.23 55.06,160.12 54.44,160.12 54.33,160.23 54.33,165.48 56.11,167.26 56.11,167.74 55.58,168.28 54.99,168.28 53.52,166.81 52.55,166.81 v4(52.16,166.42)
  S14 w0.108: v4(48.7,129.65) 48.14,130.2 46.56,130.2 46.2,130.56 46.2,130.91 45.95,131.17 45.49,131.17 45.21,131.45 45.21,131.9 44.96,132.16 44.39,132.16 44.2,132.36 44.2,134.72 43.79,135.13 43.79,136.84 53.58,146.64 53.58,157.46 54.37,158.24 54.37,158.74 54.37,158.74 54.37,160.33 53.61,161.08 53.61,166.32 53.11,166.81 52.55,166.81 v4(52.16,166.42)
  BOTTOM w0.095: RB111.2 64.03,166.16 63.75,166.16 v4(63.5,166.42)
DDRB_CK_P: length 77.7
  TOP w0.095: v4(63.5,165.62) U15.K7 ; v4(52.96,166.42) U14.K7 ; U40.AM11 v4(47.7,129.65)
  S5 w0.108: v4(63.5,165.62) 63.7,165.62 63.82,165.74 63.82,165.91 63.7,166.03 63,166.03 62.71,166.32 62.45,166.32 62.14,166.01 61.69,166.01 61.36,166.33 60.28,166.33 60.05,166.1 60.05,165.44 59.58,164.97 56.66,164.97 55.4,163.7 55.4,160.13 55.16,159.89 54.34,159.89 54.1,160.13 54.1,165.58 55.88,167.35 55.88,167.65 55.48,168.05 55.09,168.05 53.62,166.58 53.12,166.58 v4(52.96,166.42)
  S14 w0.108: v4(47.7,129.65) 47.92,129.43 47.92,129.27 47.78,129.14 46.51,129.14 46.23,129.42 46.23,129.87 46.03,130.08 45.93,130.18 45.52,130.18 45.21,130.48 45.21,130.86 44.93,131.14 43.61,131.14 43.21,131.55 43.21,134.75 43.56,135.11 43.56,136.94 53.36,146.73 53.36,157.55 54.14,158.34 54.14,158.74 54.14,160.23 53.38,160.99 53.38,166.22 53.19,166.42 v4(52.96,166.42)
  BOTTOM w0.095: RB115.2 64.08,165.94 63.82,165.94 v4(63.5,165.62)
DDRB_CKE: length 98.5
  TOP w0.127: v4(43.7,128.65) U40.AL15
  TOP w0.13: v4(68.3,166.42) U15.K2 ; v4(57.76,166.42) U14.K2
  S9 w0.127: v4(57.76,166.42) 57.76,166.41 58.15,166.02 67.65,166.02 67.89,165.78 67.89,165.21 68.2,164.9 71.7,164.9 71.96,165.15 71.96,168 71.65,168.3 70.69,168.3 70.26,167.87 70.26,167.18 69.88,166.8 69.27,166.8 69.26,166.81 68.93,166.81 68.92,166.8 68.68,166.8 v4(68.3,166.42)
  S16 w0.127: v4(57.76,166.42) 57.36,166.81 56.19,166.81 55.59,166.22 55.59,165.45 55.72,165.33 56.2,165.33 56.33,165.2 56.33,164.64 56.2,164.51 55.72,164.51 55.59,164.39 55.59,162.91 56.35,162.15 56.35,154.87 56.48,154.74 57.55,154.74 57.67,154.62 57.67,154.11 57.55,153.98 55.59,153.98 55.47,153.85 55.47,153.35 55.59,153.22 57.55,153.22 57.67,153.09 57.67,152.58 57.55,152.46 55.44,152.46 55.31,152.33 55.31,151.82 55.44,151.7 57.55,151.7 57.67,151.57 57.67,151.06 57.55,150.93 55.98,150.93 55.72,150.67 55.72,150.15 55.95,149.92 56.52,149.92 56.61,149.83 56.61,149.44 47.09,139.92 47.09,130.53 47.48,130.14 47.89,130.14 48.17,129.86 48.17,128.45 47.84,128.12 47.47,128.12 47.2,127.85 47.2,127.42 46.92,127.14 45.4,127.14 45.18,127.36 45.18,127.83 44.83,128.19 44.42,128.19 43.96,128.65 v4(43.7,128.65)
  BOTTOM w0.127: RB81.2 66.86,172.63 66.39,171.3 66.39,167.62 67.19,166.82 67.9,166.82 v4(68.3,166.42)
DDRB_CS_N0: length 86.5
  TOP w0.127: v4(51.7,134.65) U40.AU7
  TOP w0.13: v4(63.5,167.22) U15.L7
  S14 w0.127: v4(63.5,167.22) 64.32,166.4 65.78,166.4 67.61,164.56 69.36,164.56 69.49,164.44 69.49,164.42 70.49,163.42 70.49,159.04 67.39,155.94 67.39,153.55 59.29,145.45 59.29,144.9 60.57,143.63 60.57,143.33 60.32,143.09 60.03,143.09 58.75,144.37 58.57,144.37 58.21,144.01 58.21,143.83 60.57,141.47 60.57,141.29 60.21,140.93 60.03,140.93 57.68,143.29 57.5,143.29 57.14,142.93 57.14,142.75 58.46,141.43 58.46,141.25 58.1,140.89 57.92,140.89 56.6,142.21 56.42,142.21 56.05,141.84 56.05,141.63 58.35,139.33 58.35,139.15 57.99,138.8 57.81,138.8 55.85,140.76 55.84,140.76 55.59,141.02 55.23,141.02 54.96,140.75 54.96,140.48 58.26,137.18 58.26,136.93 57.83,136.5 57.52,136.5 55.49,138.53 55.06,138.53 54.72,138.19 54.72,138.01 55.61,137.12 55.61,136.95 55.25,136.59 55.07,136.59 54.18,137.47 54,137.47 51.7,135.17 v4(51.7,134.65)
  BOTTOM w0.127: v4(63.5,167.22) 63.5,167.22 63.78,167.22 65.14,168.58 65.14,172.31 65.5,172.67 RB65.2
DDRB_CS_N1: length 75
  TOP w0.127: v4(45.7,128.65) U40.AL13 ; U14.L7 54.58,168.04 54.58,170.91 55.34,171.68 R147.2
  TOP w0.13: v4(52.96,167.22) U14.L7
  S16 w0.127: v4(52.96,167.22) 53.69,166.49 53.69,161.9 54.32,161.26 54.32,160.84 54.19,160.71 53.81,160.71 53.69,160.58 53.69,160.07 53.81,159.95 54.19,159.95 54.32,159.82 54.32,159 53.51,158.19 53.51,157.91 53.69,157.73 54.45,157.73 54.58,157.6 54.58,157.1 54.45,156.97 53.31,156.97 53.18,156.84 53.18,156.33 53.31,156.21 54.45,156.21 54.58,156.08 54.58,155.48 54.39,155.29 53.71,155.29 53.4,154.98 53.22,154.98 52.79,155.41 52.46,155.41 52.25,155.21 52.25,154.88 52.62,154.51 52.62,154.2 52.24,153.82 52.01,153.82 50.54,155.29 50.19,155.29 49.89,154.99 49.89,154.81 51.52,153.18 51.52,153 51.16,152.64 50.98,152.64 49.35,154.27 49.17,154.27 48.81,153.91 48.81,153.73 50.44,152.1 50.44,151.92 50.08,151.56 49.9,151.56 48.27,153.19 48.09,153.19 47.73,152.83 47.73,152.65 48.68,151.7 48.68,144.45 44.2,139.96 44.2,129.52 44.58,129.14 44.96,129.14 45.45,128.65 v4(45.7,128.65)
DDRB_DBI_N0: length 54.7
  TOP w0.127: v4(40.7,133.65) U40.AT18
  TOP w0.13: v4(63.5,161.62) U15.E7
  S5 w0.127: v4(63.5,161.62) 63.6,161.72 64.42,162.54 64.6,162.54 65.02,162.12 65.02,162 64.07,161.04 64.07,160.8 64.2,160.67 64.79,160.67 64.91,160.55 64.91,160.04 64.79,159.91 64.2,159.91 64.07,159.78 64.07,159.06 64.43,158.7 64.71,158.7 64.84,158.58 64.84,158.07 64.71,157.94 64.3,157.94 64.18,157.81 64.18,157.31 64.3,157.18 64.9,157.18 65.02,157.05 65.02,156.54 64.9,156.42 63.6,156.42 63.48,156.29 63.48,155.87 63.62,155.73 63.83,155.73 63.96,155.6 63.96,155.27 63.81,155.12 63.38,155.12 63.26,154.99 63.26,154.17 58.21,149.12 57.78,149.12 57.65,148.99 57.65,148.51 57.52,148.38 57.01,148.38 56.89,148.51 56.89,148.99 56.76,149.12 56.19,149.12 47.48,140.42 47.48,140.24 48.46,139.26 48.46,139.09 48.1,138.73 47.92,138.73 46.95,139.7 46.77,139.7 46.41,139.34 46.41,139.16 46.76,138.81 46.76,138.63 46.4,138.27 46.22,138.27 45.87,138.62 45.69,138.62 42.17,135.1 42.17,133.53 41.84,133.2 41.4,133.2 40.96,133.65 v4(40.7,133.65)
DDRB_DBI_N1: length 56.6
  TOP w0.127: U40.AT11 v4(47.7,133.65)
  TOP w0.13: v4(68.3,161.62) U15.E2
  S9 w0.127: v4(47.7,133.65) 47.7,133.89 47.76,133.96 47.76,133.96 48.5,134.71 48.5,135.07 48.31,135.27 47.83,135.27 47.73,135.37 47.73,135.84 47.86,135.97 48.73,135.97 48.86,136.09 48.86,136.6 48.73,136.73 47.86,136.73 47.73,136.85 47.73,138.74 48.45,139.47 48.45,139.64 48.1,140 48.1,140.18 48.46,140.54 48.63,140.54 48.99,140.18 49.17,140.18 49.53,140.54 49.53,140.72 49.16,141.09 49.16,141.27 49.52,141.63 49.7,141.63 50.07,141.26 50.25,141.26 50.61,141.62 50.61,141.8 50.24,142.17 50.24,142.35 50.6,142.71 50.78,142.71 51.14,142.34 51.32,142.34 51.68,142.7 51.68,142.88 51.32,143.25 51.32,143.42 51.68,143.78 51.86,143.78 52.22,143.42 52.4,143.42 52.76,143.78 52.76,143.96 52.4,144.32 52.4,144.5 52.75,144.86 52.93,144.86 53.3,144.5 53.48,144.5 53.84,144.86 53.84,145.03 53.47,145.4 53.47,145.6 53.81,145.94 54.01,145.94 54.38,145.57 54.56,145.57 54.92,145.93 54.92,146.11 54.56,146.47 54.56,146.69 54.88,147.01 55.1,147.01 55.46,146.65 55.64,146.65 56.06,147.07 56.06,147.25 55.82,147.49 55.82,148.19 58.2,150.57 59.55,150.57 65.98,157 65.98,159.43 65.47,159.94 65.47,160.52 65.63,160.68 66.59,160.68 66.92,161.01 66.92,161.41 66.59,161.74 65.5,161.74 65.34,161.9 65.34,162.48 65.52,162.66 67.66,162.66 67.78,162.53 67.78,162.11 68.27,161.62 v4(68.3,161.62)
DDRB_DBI_N2: length 50.1
  TOP w0.127: U40.AN15 v4(43.7,130.65)
  TOP w0.13: v4(52.96,161.62) U14.E7
  S7 w0.127: v4(43.7,130.65) 44.19,130.15 44.19,128.44 43.9,128.15 41.62,128.15 41.19,128.59 41.19,135.17 44.27,138.24 44.27,139.97 52.89,148.59 52.89,152.17 52.76,152.29 51.83,152.29 51.71,152.42 51.71,152.93 51.83,153.05 52.76,153.05 52.89,153.18 52.89,153.69 52.76,153.82 51.83,153.82 51.71,153.94 51.71,154.45 51.83,154.58 52.76,154.58 52.89,154.71 52.89,157.29 54.27,158.67 54.27,160.3 v4(52.96,161.62)
DDRB_DBI_N3: length 57.3
  TOP w0.127: v4(37.7,129.65) U40.AM20
  TOP w0.13: v4(57.76,161.62) U14.E2
  S9 w0.127: v4(37.7,129.65) 37.96,129.65 38.48,129.12 38.48,128.41 38.71,128.18 39.75,128.18 40.01,128.44 40.01,128.88 40.28,129.15 41.95,129.15 42.18,129.38 42.18,131.86 41.9,132.14 41.47,132.14 41.2,132.41 41.2,135.54 40.96,135.79 40.64,135.79 40.48,135.95 40.48,136.39 40.64,136.55 41.2,136.55 41.34,136.69 41.34,137.17 41.2,137.31 40.4,137.31 40.21,137.5 40.21,137.88 40.4,138.07 41.34,138.07 41.44,138.17 41.44,139.06 41.34,139.16 41.34,141.21 40.5,142.05 40.5,144.92 40.63,145.05 41.72,145.05 41.93,145.26 41.93,145.62 41.73,145.81 40.63,145.81 40.5,145.94 40.5,146.46 48.48,154.44 53.68,154.44 54.73,155.49 54.73,157 55.47,157.74 55.47,159.09 56,159.62 57.12,159.62 57.36,159.87 57.36,161.22 v4(57.76,161.62)
DDRB_DQ0: length 54.7
  TOP w0.127: v4(41.7,132.65) U40.AR17
  TOP w0.13: v4(68.3,163.22) U15.G2
  S5 w0.127: v4(68.3,163.22) 68.3,163.02 67.9,162.62 67.9,155.43 67.02,154.55 66.73,154.55 55.17,142.99 55.17,142.12 56.44,140.85 56.44,140.67 56.08,140.31 55.9,140.31 55.2,141.02 54.91,141.02 53.05,139.17 53.05,138.99 53.99,138.05 53.99,137.87 53.63,137.51 53.45,137.51 52.52,138.45 52.34,138.45 51.98,138.09 51.98,137.91 52.86,137.02 52.86,136.84 52.5,136.48 52.32,136.48 51.4,137.41 50.92,137.41 49.75,136.25 46.61,136.25 45.22,134.85 45.22,134.54 44.81,134.14 44.5,134.14 44.22,133.87 44.22,133.42 43.97,133.16 42.22,133.16 v4(41.7,132.65)
DDRB_DQ1: length 54.8
  TOP w0.127: v4(41.7,133.65) U40.AT17
  TOP w0.13: v4(63.5,162.42) U15.F7
  S5 w0.127: v4(41.7,133.65) 41.21,134.14 41.21,134.86 43.42,137.08 43.42,138.33 43.6,138.5 43.88,138.5 44.29,138.1 44.44,138.1 44.88,138.53 44.88,138.71 43.44,140.15 43.44,140.33 43.8,140.69 43.98,140.69 45.42,139.25 45.6,139.25 45.96,139.61 45.96,139.79 44.52,141.23 44.52,141.41 44.88,141.77 45.06,141.77 46.5,140.33 46.68,140.33 47.04,140.69 47.04,140.87 45.6,142.31 45.6,142.49 45.96,142.85 46.14,142.85 47.58,141.41 47.76,141.41 55.98,149.63 57.88,149.63 62.02,153.77 62.02,154.68 61.99,154.71 61.99,157.4 62.55,157.96 62.93,157.96 63.1,158.13 63.1,162.02 v4(63.5,162.42)
DDRB_DQ2: length 54.5
  TOP w0.127: v4(43.7,133.65) U40.AT15
  TOP w0.13: v4(67.5,164.02) U15.H3
  S5 w0.127: v4(67.5,164.02) 67.9,163.62 67.9,162.95 66.51,161.57 66.51,157.91 66.64,157.78 67.1,157.78 67.22,157.65 67.22,157.14 67.1,157.02 66.64,157.02 66.51,156.89 66.51,156.38 66.64,156.26 67.1,156.26 67.22,156.13 67.22,155.62 67.1,155.49 66.64,155.49 66.51,155.37 66.51,155.05 54.32,142.86 54.32,142.68 54.64,142.36 54.64,142.18 54.28,141.82 54.1,141.82 53.73,142.19 53.55,142.19 53.19,141.83 53.19,141.65 53.92,140.93 53.92,140.75 53.56,140.39 53.38,140.39 52.71,141.06 52.53,141.06 52.17,140.7 52.17,140.52 52.84,139.85 52.84,139.67 52.48,139.31 52.3,139.31 51.63,139.98 51.45,139.98 51.09,139.62 51.09,139.44 51.76,138.77 51.76,138.59 51.4,138.23 51.22,138.23 50.55,138.9 50.37,138.9 50.01,138.54 50.01,138.36 50.49,137.88 50.49,137.7 50.13,137.34 49.95,137.34 49.47,137.83 49.29,137.83 48.22,136.76 46.1,136.76 44.19,134.84 44.19,134.44 43.7,133.95 v4(43.7,133.65)
DDRB_DQ3: length 54.8
  TOP w0.127: v4(40.7,134.65) U40.AU18
  TOP w0.13: v4(63.5,164.02) U15.H7
  S5 w0.127: v4(63.5,164.02) 63.1,163.62 63.1,163.05 62.87,162.82 61.73,162.82 61.48,162.58 61.48,153.95 57.67,150.14 55.76,150.14 51.24,145.62 50.79,145.62 49.74,146.67 49.56,146.67 49.2,146.31 49.2,146.13 50.25,145.07 50.25,144.9 49.89,144.54 49.71,144.54 48.66,145.59 48.48,145.59 48.12,145.23 48.12,145.05 49.23,143.93 49.23,143.75 48.87,143.39 48.69,143.39 47.58,144.51 47.4,144.51 47.04,144.15 47.04,143.97 48.19,142.82 48.19,142.64 47.83,142.28 47.65,142.28 46.38,143.56 45.95,143.56 42.92,140.53 42.92,137.29 40.7,135.07 v4(40.7,134.65)
DDRB_DQ4: length 54.8
  TOP w0.127: v4(42.7,132.65) U40.AR16
  TOP w0.13: v4(68.3,164.02) U15.H2
  S5 w0.127: v4(42.7,132.65) 42.7,132.38 42.88,132.2 43.92,132.2 44.26,132.54 44.26,132.89 44.51,133.15 44.82,133.15 45.23,133.56 45.23,133.81 45.63,134.2 45.95,134.2 46.19,134.44 46.19,134.94 46.99,135.74 52.6,135.74 56.99,140.13 56.99,141.25 55.91,142.32 55.91,142.5 56.27,142.86 56.45,142.86 57.4,141.91 57.58,141.91 57.94,142.27 57.94,142.45 56.99,143.4 56.99,143.56 57.37,143.94 57.53,143.94 58.2,143.27 58.38,143.27 58.74,143.63 58.74,143.81 58.07,144.48 58.07,145.14 61.88,148.95 61.88,148.97 66.92,154.01 67.21,154.01 68.7,155.5 68.7,163.62 v4(68.3,164.02)
DDRB_DQ5: length 54.5
  TOP w0.127: U40.AP19 v4(39.7,131.65)
  TOP w0.13: v4(62.7,164.02) U15.H8
  S5 w0.127: v4(39.7,131.65) 40.13,132.08 40.13,135.23 42.41,137.5 42.41,140.74 49.37,147.7 49.55,147.7 50.75,146.51 50.93,146.51 51.28,146.87 51.28,147.05 50.09,148.24 50.09,148.42 50.45,148.78 50.63,148.78 51.77,147.64 51.95,147.64 52.31,148 52.31,148.18 51.17,149.32 51.17,149.5 51.53,149.86 51.71,149.86 52.93,148.64 53.55,148.64 55.55,150.64 57.46,150.64 60.98,154.16 60.98,162.85 61.75,163.62 62.3,163.62 v4(62.7,164.02)
DDRB_DQ6: length 54.6
  TOP w0.127: U40.AU19 v4(39.7,134.65)
  TOP w0.13: v4(67.5,165.62) U15.J3
  S5 w0.127: v4(67.5,165.62) 64.75,165.62 64.1,164.97 64.1,164.84 63.68,164.42 61.74,164.42 60.47,163.15 60.47,154.37 57.25,151.15 55.34,151.15 54.64,150.45 54.46,150.45 53.15,151.75 52.97,151.75 52.61,151.4 52.61,151.22 53.92,149.91 53.92,149.73 53.56,149.37 53.38,149.37 52.08,150.67 51.56,150.67 41.9,141.01 41.9,137.71 39.63,135.44 39.63,134.72 v4(39.7,134.65)
DDRB_DQ7: length 54.5
  TOP w0.127: U40.AR19 v4(39.7,132.65)
  TOP w0.13: U15.J7 v4(63.5,164.82)
  S5 w0.127: v4(63.5,164.82) 63.37,164.95 61.15,164.95 59.96,163.75 59.96,154.58 57.29,151.91 56.6,151.91 54.41,154.1 54.23,154.1 53.87,153.75 53.87,153.57 55.36,152.07 55.36,151.89 55,151.53 54.82,151.53 53.47,152.88 53.05,152.88 41.39,141.22 41.39,137.92 39.12,135.65 39.12,133.22 v4(39.7,132.65)
DDRB_DQ8: length 56.6
  TOP w0.127: v4(49.7,134.65) U40.AU9
  TOP w0.13: v4(67.5,158.42) U15.A3
  S9 w0.127: v4(49.7,134.65) 49.7,134.92 53.28,138.5 53.28,138.82 51.42,140.68 51.42,140.89 51.77,141.23 52.05,141.23 53.51,139.77 53.74,139.77 54.13,140.17 54.13,140.4 52.71,141.82 52.71,142.15 52.95,142.39 53.23,142.39 55.56,140.05 55.74,140.05 56.1,140.41 56.1,140.59 53.77,142.93 53.77,143.21 54.03,143.47 54.31,143.47 57.13,140.65 57.3,140.65 57.66,141.01 57.66,141.19 54.85,144.01 54.85,144.19 58,147.34 58.22,147.34 58.68,146.88 58.92,146.88 59.28,147.25 59.28,147.43 58.83,147.87 58.83,148.17 67.31,156.65 67.83,156.65 67.96,156.78 67.96,157.22 67.83,157.35 67.2,157.35 67.06,157.49 67.06,158.28 67.2,158.42 v4(67.5,158.42)
DDRB_DQ9: length 56.7
  TOP w0.127: U40.AU13 v4(45.7,134.65)
  TOP w0.13: U15.B8 v4(62.7,159.22)
  S9 w0.127: v4(45.7,134.65) 45.66,134.69 45.66,135.68 45.57,135.77 45.01,135.77 44.69,136.09 44.69,136.42 44.82,136.54 45.53,136.54 45.66,136.67 45.66,137.18 45.53,137.3 44.24,137.3 44.11,137.43 44.11,137.94 44.24,138.07 45.53,138.07 45.66,138.19 45.66,138.7 45.53,138.83 44.24,138.83 44.11,138.96 44.11,139.46 44.24,139.59 45.51,139.59 45.66,139.74 45.66,140.2 45.51,140.35 44.24,140.35 44.11,140.48 44.11,140.99 44.24,141.11 45.63,141.11 45.78,141.27 45.78,141.72 45.63,141.88 44.22,141.88 44.11,141.98 44.11,142.47 44.12,142.47 44.29,142.64 45.78,142.64 45.9,142.76 45.9,142.89 45.39,143.4 45.39,143.96 51.9,150.48 55.15,150.48 57.65,152.97 59,152.97 60.99,154.96 60.99,155.23 60.24,155.98 60.24,156.31 60.43,156.5 60.8,156.5 61.57,155.72 61.75,155.72 62.04,156.01 62.04,156.33 60.16,158.21 60.16,158.52 60.42,158.77 60.72,158.77 62.03,157.46 62.18,157.46 62.6,157.88 62.98,157.88 63.1,158 63.1,159.11 62.99,159.22 v4(62.7,159.22)
DDRB_DQ10: length 56.8
  TOP w0.127: U40.AR11 v4(47.7,132.65)
  TOP w0.13: v4(67.5,160.02) U15.C3
  S9 w0.127: v4(47.7,132.65) 48.02,132.65 48.52,133.14 49.01,133.14 49.19,133.33 49.19,133.87 49.44,134.12 49.83,134.12 50.19,134.48 50.19,134.7 53.29,137.79 54.6,137.79 54.89,138.08 54.89,139.32 55.12,139.55 56.99,139.55 58.72,141.27 58.72,141.55 56.07,144.19 56.07,144.55 56.39,144.87 56.8,144.87 59.73,141.93 60.01,141.93 60.39,142.31 60.39,142.59 57.52,145.47 57.52,145.84 57.8,146.13 58.25,146.13 59.66,144.72 60.06,144.72 60.49,145.15 60.49,149.11 67.41,156.03 68.62,156.03 68.84,156.25 68.84,157.34 69.51,158.01 69.51,159.41 69.3,159.62 67.9,159.62 v4(67.5,160.02)
DDRB_DQ11: length 56.8
  TOP w0.127: v4(44.7,133.65) U40.AT14
  TOP w0.13: v4(63.5,160.02) U15.C7
  S9 w0.127: v4(63.5,160.02) 63.1,159.62 62.46,159.62 62.3,159.46 62.3,159.03 62.09,158.82 61.53,158.82 61.31,159.05 61.31,160.01 60.67,160.65 60.67,164.51 60.44,164.74 59.81,164.74 59.66,164.59 59.66,154.35 58.98,153.67 57.63,153.67 57.1,153.14 56.92,153.14 56.39,153.67 56.21,153.67 55.85,153.31 55.85,153.13 56.38,152.6 56.38,152.42 56.02,152.06 55.84,152.06 55.19,152.71 55.01,152.71 54.65,152.36 54.65,152.18 55.3,151.52 55.3,151.34 54.94,150.98 51.35,150.98 43.6,143.24 43.6,136.46 45.23,134.84 45.23,133.65 45.05,133.47 44.87,133.47 v4(44.7,133.65)
DDRB_DQ12: length 56.8
  TOP w0.127: v4(44.7,129.65) U40.AM14
  TOP w0.13: v4(68.3,160.02) U15.C2
  S9 w0.127: v4(68.3,160.02) 68.3,160.05 68.67,160.42 69.43,160.42 70.02,159.84 70.02,157.8 69.35,157.13 69.35,155.81 69.02,155.49 67.72,155.49 67.71,155.48 67.58,155.48 61,148.9 61,139.86 58.42,137.28 57.83,137.28 57.7,137.41 57.7,138.89 57.55,139.04 57.09,139.04 56.94,138.89 56.94,137.47 56.76,137.28 56.32,137.28 56.18,137.43 56.18,138.81 55.97,139.01 55.62,139.01 55.41,138.81 55.41,137.42 55.28,137.28 53.72,137.28 51.2,134.76 51.2,134.52 50.88,134.2 50.52,134.2 50.26,133.94 50.26,133.51 49.89,133.15 49.51,133.15 49.26,132.9 49.26,132.55 48.85,132.14 47.57,132.14 47.19,131.77 47.19,131.45 46.9,131.15 45.45,131.15 45.21,130.91 45.21,129.81 45.25,129.77 45.25,129.46 45.08,129.28 44.9,129.28 44.7,129.48 v4(44.7,129.65)
DDRB_DQ13: length 56.5
  TOP w0.127: v4(44.7,132.65) U40.AR14
  TOP w0.13: v4(62.7,160.02) U15.C8
  S9 w0.127: v4(44.7,132.65) 44.7,132.18 44.82,132.05 45.05,132.05 45.23,132.23 45.23,132.95 45.42,133.14 46.81,133.14 47.22,133.55 47.22,140.07 55.3,148.15 55.3,148.39 58.4,151.49 59.61,151.49 65.37,157.25 65.37,158.58 65.14,158.81 64.93,158.81 64.46,159.28 64.46,159.99 64.84,160.37 64.84,163.72 65.22,164.11 66.6,164.11 66.75,164.26 66.75,165.2 66.57,165.38 64.41,165.38 64.07,165.05 64.07,160.55 63.95,160.42 63.34,160.42 62.93,160.02 v4(62.7,160.02)
DDRB_DQ14: length 56.7
  TOP w0.127: v4(45.7,132.65) U40.AR13
  TOP w0.13: v4(67.5,160.82) U15.D3
  S9 w0.127: v4(67.5,160.82) 66.53,159.85 66.53,156.72 58.94,149.12 58.76,149.12 58.21,149.68 58.03,149.68 57.67,149.32 57.67,149.14 58.22,148.59 58.22,148.41 57.86,148.05 57.68,148.05 57.13,148.6 56.95,148.6 56.59,148.24 56.59,148.06 57.14,147.51 57.14,147.33 50.4,140.59 50.4,140.41 52.34,138.48 52.34,138.28 51.99,137.94 51.8,137.94 49.87,139.87 49.57,139.87 49.24,139.54 49.24,139.32 51.21,137.35 51.21,137.15 50.86,136.8 50.68,136.8 48.82,138.66 48.54,138.66 48.24,138.35 48.24,138.06 50.03,136.27 50.03,135.99 49.17,135.13 49.17,134.39 48.87,134.09 48.49,134.09 48.19,133.79 48.19,133.43 47.93,133.16 47.55,133.16 47.18,132.79 47.18,132.42 46.92,132.16 46.18,132.16 v4(45.7,132.65)
DDRB_DQ15: length 56.8
  TOP w0.127: v4(44.7,130.65) U40.AN14
  TOP w0.13: v4(63.5,160.82) U15.D7
  S9 w0.127: v4(44.7,130.65) 44.7,130.41 44.49,130.2 44.36,130.2 44.2,130.36 44.2,134.64 44.07,134.77 44.07,135.12 43.09,136.1 43.09,143.5 51.16,151.56 53.14,151.56 55.75,154.18 58.77,154.18 59.12,154.53 59.12,164.95 59.56,165.38 60.99,165.38 61.31,165.07 61.31,160.73 61.61,160.42 62.88,160.42 63.09,160.63 63.09,161.09 63.17,161.17 63.43,161.17 63.5,161.1 v4(63.5,160.82)
DDRB_DQ16: length 50.1
  TOP w0.127: v4(45.7,131.65) U40.AP13
  TOP w0.13: v4(57.76,163.22) U14.G2
  S7 w0.127: v4(57.76,163.22) 57.76,163.07 57.35,162.66 57.35,158.14 56.99,157.78 56.99,149.68 54.47,147.17 54.47,146.77 54.97,146.27 54.97,146.09 54.61,145.73 54.43,145.73 53.72,146.44 53.54,146.44 53.18,146.08 53.18,145.9 53.89,145.19 53.89,145.01 53.53,144.65 53.36,144.65 52.67,145.34 52.44,145.34 52.13,145.03 52.13,144.8 52.8,144.12 52.8,143.95 52.44,143.59 52.26,143.59 51.61,144.24 51.35,144.24 51.07,143.96 51.07,143.71 51.76,143.01 51.76,142.84 51.4,142.48 51.22,142.48 50.53,143.17 50.27,143.17 49.99,142.88 49.99,142.63 50.67,141.94 50.67,141.76 50.31,141.4 50.13,141.4 49.44,142.1 49.21,142.1 48.9,141.79 48.9,141.56 49.54,140.92 49.54,140.62 46.22,137.3 46.22,131.39 46.05,131.21 45.89,131.21 45.7,131.41 v4(45.7,131.65)
DDRB_DQ17: length 49.8
  TOP w0.127: v4(46.7,130.65) U40.AN12
  TOP w0.13: v4(52.96,162.42) U14.F7
  S7 w0.127: v4(46.7,130.65) 46.84,130.5 47.06,130.5 47.19,130.63 47.19,131.9 47.49,132.2 47.88,132.2 48.18,132.5 48.26,132.59 48.26,137.9 58.35,147.99 58.35,150.15 59.78,151.58 59.78,163.4 58.74,164.44 56.38,164.44 55.21,163.27 55.21,163.04 54.52,162.35 54.29,162.35 54.19,162.44 54.19,163.01 54.07,163.14 53.71,163.14 53.58,163.01 53.58,162.35 53.46,162.23 53.15,162.23 v4(52.96,162.42)
DDRB_DQ18: length 50
  TOP w0.127: v4(45.7,129.65) U40.AM13
  TOP w0.13: v4(56.96,164.02) U14.H3
  S7 w0.127: v4(56.96,164.02) 57.36,163.62 57.36,163.03 57.02,162.69 57.02,162.26 56.48,161.72 56.48,157.84 56.26,157.62 55.72,157.62 55.5,157.39 55.5,157.08 55.72,156.86 56.26,156.86 56.48,156.63 56.48,150.16 56.35,150.04 56.23,150.04 55.87,150.39 55.57,150.39 55.25,150.07 55.25,149.82 55.57,149.5 55.57,149.18 48.03,141.65 48.03,141.47 48.76,140.74 48.76,140.56 48.4,140.2 48.22,140.2 47.49,140.93 47.31,140.93 46.95,140.57 46.95,140.39 47.68,139.66 47.68,139.48 47.32,139.12 47.14,139.12 46.47,139.8 46.19,139.8 45.82,139.43 45.82,139.23 46.38,138.67 46.38,138.36 45.72,137.7 45.72,135.22 45.2,134.7 45.2,130.4 45.38,130.22 46.22,130.22 46.31,130.13 46.31,129.73 46.23,129.65 v4(45.7,129.65)
DDRB_DQ19: length 49.9
  TOP w0.127: v4(48.7,132.65) U40.AR10
  TOP w0.13: v4(52.96,164.02) U14.H7
  S7 w0.127: v4(48.7,132.65) 48.7,132.96 49.19,133.46 49.19,138.11 59.37,148.29 59.37,148.47 58.88,148.96 58.88,149.21 59.17,149.5 59.42,149.5 59.91,149.01 60.09,149.01 60.29,149.21 60.29,163.67 59.15,164.82 56.43,164.82 56.27,164.97 55.26,164.97 55.18,164.89 55.18,164.01 54.98,163.8 54.55,163.8 54.42,163.93 54.42,164.84 54.3,164.97 53.89,164.97 53.76,164.84 53.76,163.85 53.58,163.68 53.3,163.68 v4(52.96,164.02)
DDRB_DQ20: length 50
  TOP w0.127: v4(46.7,131.65) U40.AP12
  TOP w0.13: v4(57.76,164.02) U14.H2
  S7 w0.127: v4(46.7,131.65) 46.7,132.02 47.22,132.54 47.22,137.57 55.72,146.08 55.72,146.26 55.13,146.85 55.13,147.11 55.42,147.39 55.67,147.39 56.26,146.8 56.44,146.8 56.8,147.16 56.8,147.34 56.22,147.92 56.22,148.2 56.48,148.45 56.76,148.45 57.34,147.88 57.52,147.88 57.84,148.2 57.84,148.52 57.45,148.92 57.45,149.15 57.75,149.45 57.75,151.61 57.91,151.77 58.92,151.77 59.1,151.94 59.1,152.45 58.94,152.61 57.82,152.61 57.65,152.78 57.65,153.24 57.78,153.37 59.15,153.37 59.27,153.5 59.27,154.01 59.15,154.13 57.93,154.13 57.72,154.34 57.72,154.69 57.93,154.89 59.15,154.89 59.27,155.02 59.27,163.17 58.82,163.62 58.15,163.62 v4(57.76,164.02)
DDRB_DQ21: length 50.2
  TOP w0.127: U40.AN11 v4(47.7,130.65)
  TOP w0.13: v4(52.16,164.02) U14.H8
  S7 w0.127: v4(47.7,130.65) 48.21,131.16 48.21,131.75 48.55,132.09 48.9,132.09 49.26,132.44 49.26,132.76 49.58,133.09 49.7,133.09 50.25,133.64 50.25,138.45 60.8,149 60.8,163.89 59.36,165.33 58.84,165.33 58.72,165.2 56.81,165.2 56.53,165.48 53.62,165.48 v4(52.16,164.02)
DDRB_DQ22: length 50.2
  TOP w0.127: U40.AP10 v4(48.7,131.65)
  TOP w0.13: v4(56.96,165.62) U14.J3
  S7 w0.127: v4(48.7,131.65) 48.97,131.65 49.47,132.15 49.95,132.15 50.14,132.34 50.14,132.82 50.53,133.2 50.88,133.2 51.18,133.51 51.18,138.67 61.31,148.79 61.31,150.5 61.43,150.63 62.73,150.63 62.86,150.75 62.86,151.26 62.73,151.39 61.43,151.39 61.31,151.52 61.31,152.24 61.43,152.37 62.47,152.37 62.6,152.5 62.6,153 62.47,153.13 61.43,153.13 61.31,153.26 61.31,164.46 59.76,166.01 57.35,166.01 v4(56.96,165.62)
DDRB_DQ23: length 50.2
  TOP w0.127: v4(41.7,127.65) U40.AK17
  TOP w0.13: v4(52.96,165.62) U14.J7
  S7 w0.127: v4(41.7,127.65) 41.16,127.1 40.52,127.1 40.13,127.49 40.13,134.83 43.76,138.45 43.76,140.69 50.77,147.7 50.77,149.08 50.89,149.21 51.55,149.21 51.68,149.34 51.68,149.85 51.55,149.97 50.89,149.97 50.77,150.1 50.77,150.61 50.89,150.73 51.55,150.73 51.68,150.86 51.68,151.37 51.55,151.5 50.89,151.5 50.77,151.62 50.77,164.18 51.53,164.95 52.28,164.95 v4(52.96,165.62)
DDRB_DQ24: length 57.5
  TOP w0.127: v4(42.7,131.65) U40.AP16
  TOP w0.13: v4(56.96,158.42) U14.A3
  S9 w0.127: v4(56.96,158.42) 56.83,158.54 56.83,158.78 56.56,159.05 56.15,159.05 55.97,158.88 55.97,157.85 56.04,157.78 56.79,157.78 56.96,157.62 56.96,157.15 56.83,157.02 55.47,157.02 55.24,156.79 55.24,156.46 55.49,156.21 56.89,156.21 57.04,156.06 57.04,155.57 56.89,155.42 55.38,155.42 53.89,153.93 52.96,153.93 52.84,153.8 52.84,152.88 52.71,152.75 52.2,152.75 52.07,152.88 52.07,153.8 51.95,153.93 51.44,153.93 51.31,153.8 51.31,152.83 51.19,152.7 50.68,152.7 50.55,152.83 50.55,153.8 50.42,153.93 48.69,153.93 44.34,149.58 44.34,149.23 45.6,147.97 45.6,147.62 45.41,147.43 45.06,147.43 43.77,148.71 43.47,148.71 43.24,148.47 43.24,148.17 44.52,146.89 44.52,146.54 44.33,146.35 43.98,146.35 42.75,147.58 42.35,147.58 42.09,147.33 42.09,147 43.25,145.84 43.25,145.56 41.95,144.27 41.95,135.02 42.21,134.77 42.21,132.45 42.7,131.96 v4(42.7,131.65)
DDRB_DQ25: length 57.2
  TOP w0.127: U40.AM19 v4(39.7,129.65)
  TOP w0.13: v4(52.16,159.22) U14.B8
  S9 w0.127: v4(39.7,129.65) 38.87,129.65 38.18,130.33 38.18,134.99 37.99,135.18 37.99,135.4 36,137.39 36,140.46 35.87,140.58 35.32,140.58 35.2,140.71 35.2,141.22 35.32,141.35 35.87,141.35 36,141.47 36,141.98 35.87,142.11 35.32,142.11 35.2,142.24 35.2,142.74 35.32,142.87 35.87,142.87 36,143 36,143.51 35.87,143.63 35.32,143.63 35.2,143.76 35.2,144.27 35.32,144.39 35.87,144.39 36,144.52 36,144.88 36.21,145.09 36.21,145.27 35.06,146.42 35.06,146.6 35.42,146.96 35.6,146.96 36.75,145.81 36.93,145.81 37.29,146.17 37.29,146.35 35.65,148 35.65,148.18 36.01,148.53 36.19,148.53 37.83,146.89 38.01,146.89 38.37,147.25 38.37,147.43 37.23,148.57 37.23,148.75 37.59,149.11 37.77,149.11 38.91,147.97 39.09,147.97 41.39,150.27 41.39,151.87 46.63,157.11 48.8,157.11 50.51,158.82 51.76,158.82 v4(52.16,159.22)
DDRB_DQ26: length 57.1
  TOP w0.127: v4(37.7,127.65) U40.AK20
  TOP w0.13: v4(56.96,160.02) U14.C3
  S9 w0.127: v4(37.7,127.65) 37.46,127.65 36.95,128.16 36.39,128.16 36.2,128.35 36.2,134.8 34.03,136.97 34.03,148 36.16,150.12 39.25,150.12 40.1,150.97 40.1,153.19 44.39,157.49 45.57,157.49 46.21,158.13 48.38,158.13 50.68,160.42 53.36,160.42 53.49,160.55 53.49,161.34 53.61,161.47 54.12,161.47 54.25,161.34 54.25,160.35 54.38,160.22 54.88,160.22 55.01,160.35 55.01,161.34 55.14,161.47 55.65,161.47 55.77,161.34 55.77,160.55 55.9,160.42 56.55,160.42 v4(56.96,160.02)
DDRB_DQ27: length 57.2
  TOP w0.127: v4(41.7,129.65) U40.AM17
  TOP w0.13: v4(52.96,160.02) U14.C7
  S9 w0.127: v4(52.96,160.02) 52.56,159.62 52.56,158.25 52.33,158.02 50.43,158.02 50.21,157.8 50.21,157.55 50.88,156.88 50.88,156.53 50.6,156.25 50.34,156.25 49.62,156.97 49.38,156.97 48.69,156.28 48.05,156.28 47.8,156.54 47.62,156.54 47.26,156.18 47.26,156 47.51,155.74 47.51,155.56 47.15,155.2 46.97,155.2 46.36,155.82 46.18,155.82 45.82,155.46 45.82,155.28 46.44,154.67 46.44,154.49 46.08,154.13 45.9,154.13 45.22,154.8 45.04,154.8 44.68,154.44 44.68,154.26 45.36,153.59 45.36,153.41 45,153.05 44.82,153.05 44.15,153.72 43.97,153.72 43.61,153.36 43.61,153.18 44.28,152.51 44.28,152.33 43.92,151.97 43.74,151.97 43.07,152.64 42.89,152.64 42.53,152.28 42.53,152.1 43.2,151.43 43.2,151.25 38.42,146.47 38.42,146.29 38.96,145.75 38.96,145.5 38.68,145.21 38.42,145.21 37.83,145.81 37.65,145.81 36.51,144.67 36.51,137.6 38.58,135.53 38.58,130.47 39.01,130.04 40.91,130.04 41.12,130.25 41.6,130.25 41.7,130.15 v4(41.7,129.65)
DDRB_DQ28: length 57.1
  TOP w0.127: v4(43.7,131.65) U40.AP15
  TOP w0.13: v4(57.76,160.02) U14.C2
  S9 w0.127: v4(57.76,160.02) 57.98,160.02 58.15,159.85 58.15,158.78 58.49,158.44 58.49,155.39 57.91,154.81 55.49,154.81 52.87,152.19 50.89,152.19 50.7,152.01 50.52,152.01 49.11,153.42 48.93,153.42 48.57,153.06 48.57,152.88 49.99,151.47 49.99,151.29 49.63,150.93 49.45,150.93 48.02,152.36 47.84,152.36 47.48,152 47.48,151.82 48.91,150.39 48.91,150.21 48.55,149.85 48.37,149.85 46.94,151.28 46.76,151.28 46.4,150.92 46.4,150.74 47.83,149.31 47.83,149.13 47.47,148.77 47.29,148.77 45.86,150.2 45.68,150.2 45.32,149.84 45.32,149.66 46.75,148.23 46.75,148.05 42.46,143.76 42.46,135.84 43.21,135.09 43.21,131.71 43.37,131.54 43.6,131.54 v4(43.7,131.65)
DDRB_DQ29: length 57.2
  TOP w0.127: U40.AJ19 v4(39.7,126.65)
  TOP w0.13: v4(52.16,160.02) U14.C8
  S9 w0.127: v4(39.7,126.65) 39.57,126.51 38.62,126.51 38.13,127.01 38.13,127.9 37.88,128.15 37.57,128.15 37.21,128.51 37.21,134.69 36.71,135.19 36.52,135.19 34.54,137.18 34.54,137.47 34.66,137.6 35.27,137.6 35.4,137.73 35.4,138.23 35.27,138.36 34.66,138.36 34.54,138.49 34.54,139 34.66,139.12 35.27,139.12 35.4,139.25 35.4,139.76 35.27,139.89 34.66,139.89 34.54,140.01 34.54,147.78 36.37,149.61 39.46,149.61 40.61,150.76 40.61,151.8 40.97,152.16 40.97,152.34 40.61,152.7 40.61,152.88 40.97,153.24 41.15,153.24 41.51,152.88 41.69,152.88 42.05,153.24 42.05,153.42 41.64,153.83 41.64,154.01 42,154.37 42.18,154.37 42.59,153.96 42.77,153.96 43.13,154.32 43.13,154.5 42.71,154.91 42.71,155.09 43.07,155.45 43.25,155.45 43.67,155.04 43.84,155.04 44.2,155.4 44.2,155.58 43.79,155.99 43.79,156.17 44.15,156.53 44.33,156.53 44.74,156.12 44.92,156.12 46.42,157.62 48.59,157.62 50.59,159.62 51.76,159.62 v4(52.16,160.02)
DDRB_DQ30: length 57.1
  TOP w0.127: U40.AH21 v4(36.7,125.65)
  TOP w0.13: v4(56.96,160.82) U14.D3
  S9 w0.127: v4(56.96,160.82) 56.96,161.01 55.95,162.02 50.74,162.02 48.42,159.7 46.35,159.7 45.37,158.72 42.89,158.72 32.93,148.77 32.93,136.62 34.24,135.32 34.24,126.4 34.49,126.15 36.19,126.15 v4(36.7,125.65)
DDRB_DQ31: length 57.4
  TOP w0.127: v4(37.7,126.65) U40.AJ20
  TOP w0.13: v4(52.96,160.82) U14.D7
  S9 w0.127: v4(52.96,160.82) 52.55,161.22 50.76,161.22 48.17,158.63 46,158.63 45.48,158.11 44.3,158.11 41.78,155.6 41.48,155.6 41.06,156.02 40.91,156.02 40.55,155.66 40.55,155.45 40.9,155.1 40.9,154.85 40.61,154.56 40.36,154.56 40.01,154.91 39.8,154.91 38.92,154.03 38.92,151.89 38.65,151.62 38.33,151.62 37.58,152.37 37.29,152.37 36.97,152.06 36.97,151.82 37.62,151.17 37.62,150.88 37.37,150.63 37.09,150.63 36.48,151.24 36.15,151.24 33.44,148.53 33.44,136.83 35.17,135.11 35.17,127.46 35.5,127.14 36.9,127.14 37.09,126.95 37.09,126.3 37.2,126.18 37.57,126.18 37.7,126.31 v4(37.7,126.65)
DDRB_DQS0_N: length 57
  TOP w0.095: U15.F3 v4(67.5,163.22) ; U40.AU15 v4(43.7,134.65)
  S5 w0.108: v4(43.7,134.65) 43.42,134.65 43.31,134.75 43.31,135.04 45.69,137.42 48,137.42 49.75,139.17 49.75,139.51 48.84,140.42 48.84,140.57 49.22,140.94 49.37,140.94 50.28,140.04 50.62,140.04 51.13,140.54 51.13,140.89 50.37,141.64 50.37,141.8 50.74,142.17 50.89,142.17 51.65,141.41 51.99,141.41 52.5,141.92 52.5,142.26 51.74,143.02 51.74,143.17 52.12,143.55 52.27,143.55 53.03,142.79 53.37,142.79 53.88,143.29 53.88,143.64 53.12,144.39 53.12,144.55 53.49,144.92 53.64,144.92 54.4,144.16 54.74,144.16 55.25,144.67 55.25,145.01 54.49,145.77 54.49,145.92 54.87,146.29 55.02,146.29 55.78,145.54 56.12,145.54 56.63,146.04 56.63,146.39 55.87,147.14 55.87,147.3 56.24,147.67 56.39,147.67 57.15,146.91 57.49,146.91 65.88,155.3 65.88,162.14 66.18,162.44 66.94,162.44 67.21,162.71 67.21,162.93 v4(67.5,163.22)
DDRB_DQS0_P: length 57
  TOP w0.095: U15.G3 v4(66.7,163.22) ; U40.AU16 v4(42.7,134.65)
  S5 w0.108: v4(66.7,163.22) 66.98,162.93 66.98,162.81 66.85,162.67 66.08,162.67 65.65,162.24 65.65,155.39 57.4,147.14 57.25,147.14 56.49,147.9 56.15,147.9 55.64,147.39 55.64,147.05 56.4,146.29 56.4,146.14 56.02,145.77 55.87,145.77 55.11,146.52 54.77,146.52 54.26,146.02 54.26,145.67 55.02,144.92 55.02,144.76 54.65,144.39 54.5,144.39 53.74,145.15 53.4,145.15 52.89,144.64 52.89,144.3 53.65,143.54 53.65,143.39 53.27,143.02 53.12,143.02 52.36,143.77 52.02,143.77 51.52,143.27 51.52,142.92 52.27,142.17 52.27,142.01 51.9,141.64 51.75,141.64 50.99,142.4 50.65,142.4 50.14,141.89 50.14,141.55 50.9,140.79 50.9,140.64 50.52,140.27 50.37,140.27 49.46,141.17 49.12,141.17 48.62,140.67 48.62,140.32 49.52,139.42 49.52,139.26 47.9,137.65 45.6,137.65 43.08,135.13 43.08,134.75 42.97,134.65 v4(42.7,134.65)
DDRB_DQS1_N: length 55.9
  TOP w0.095: U40.AT12 v4(46.7,133.65) ; v4(63.5,158.42) U15.A7
  S9 w0.108: v4(63.5,158.42) 63.5,158.42 63.7,158.21 63.8,158.12 64.03,157.88 64.36,157.88 64.43,157.81 64.43,157.52 59.26,152.34 57.91,152.34 54.23,148.66 53.8,148.66 52.7,149.77 52.36,149.77 51.85,149.26 51.85,148.92 53.28,147.49 53.28,147.34 52.91,146.96 52.76,146.96 51.32,148.4 50.98,148.4 50.47,147.89 50.47,147.55 51.87,146.15 51.87,145.92 51.57,145.63 51.34,145.63 49.95,147.02 49.61,147.02 49.1,146.51 49.1,146.17 50.42,144.85 50.42,144.47 50.27,144.33 49.89,144.33 48.57,145.65 48.23,145.65 47.72,145.14 47.72,144.8 49.09,143.43 49.09,143.15 48.85,142.9 48.57,142.9 47.2,144.27 46.86,144.27 46.35,143.76 46.35,143.42 47.67,142.1 47.67,141.82 46.28,140.44 46.28,134.52 46.7,134.1 v4(46.7,133.65)
DDRB_DQS1_P: length 55.7
  TOP w0.095: U40.AU12 v4(46.7,134.65) ; U15.B7 v4(63.5,159.22)
  S9 w0.108: v4(46.7,134.65) 46.51,134.83 46.51,140.34 47.9,141.73 47.9,142.2 46.58,143.52 46.58,143.67 46.95,144.04 47.1,144.04 48.47,142.67 48.94,142.67 49.32,143.05 49.32,143.52 47.95,144.89 47.95,145.04 48.33,145.42 48.48,145.42 49.8,144.1 50.37,144.1 50.65,144.38 50.65,144.95 49.33,146.27 49.33,146.42 49.7,146.79 49.85,146.79 51.25,145.4 51.67,145.4 52.1,145.83 52.1,146.25 50.7,147.64 50.7,147.79 51.08,148.17 51.23,148.17 52.66,146.74 53,146.74 53.51,147.24 53.51,147.58 52.08,149.02 52.08,149.17 52.45,149.54 52.6,149.54 53.71,148.44 54.32,148.44 58,152.11 59.35,152.11 64.66,157.42 64.66,157.91 64.46,158.11 64.13,158.11 64.03,158.21 64.03,158.49 63.67,158.85 63.54,158.85 63.5,158.89 v4(63.5,159.22)
DDRB_DQS2_N: length 48.2
  TOP w0.095: U40.AL16 v4(42.7,128.65) ; U14.F3 v4(56.16,163.22)
  S7 w0.108: v4(56.16,163.22) 56.44,162.93 56.44,162.78 56.17,162.51 55.6,162.51 55.21,162.11 55.21,158.32 54.19,157.3 54.19,156.16 54.44,155.92 55.25,155.92 55.36,155.81 55.36,155.28 55.25,155.17 54.44,155.17 54.19,154.93 54.19,154.21 54.44,153.97 55.25,153.97 55.36,153.87 55.36,153.34 55.25,153.23 54.44,153.23 54.19,152.99 54.19,152.27 54.44,152.03 55.25,152.03 55.36,151.92 55.36,151.39 55.25,151.29 54.44,151.29 54.19,151.05 54.19,149.02 44.89,139.71 44.89,137.98 42.67,135.77 42.67,135.31 42.19,134.83 42.19,129.15 v4(42.7,128.65)
DDRB_DQS2_P: length 48.1
  TOP w0.095: v4(56.96,163.22) U14.G3 ; U40.AM16 v4(42.7,129.65)
  S7 w0.108: v4(56.96,163.22) 56.67,162.93 56.67,162.69 56.26,162.28 55.7,162.28 55.44,162.02 55.44,158.22 54.42,157.2 54.42,156.25 54.53,156.14 55.35,156.14 55.59,155.9 55.59,155.19 55.35,154.94 54.53,154.94 54.42,154.84 54.42,154.31 54.53,154.2 55.35,154.2 55.59,153.96 55.59,153.24 55.35,153 54.53,153 54.42,152.89 54.42,152.37 54.53,152.26 55.35,152.26 55.59,152.02 55.59,151.3 55.35,151.06 54.53,151.06 54.42,150.95 54.42,148.92 45.12,139.62 45.12,137.89 42.9,135.67 42.9,135.08 43.21,134.77 43.21,129.39 43.06,129.24 42.81,129.24 42.7,129.35 v4(42.7,129.65)
DDRB_DQS3_N: length 55
  TOP w0.095: v4(53.76,159.22) U14.A7 ; U40.AN17 v4(41.7,130.65)
  S9 w0.108: v4(53.76,159.22) 53.47,158.93 53.47,158.37 53.97,157.88 53.97,157.48 53.72,157.24 53.44,157.24 53.33,157.13 53.33,155.48 52.92,155.06 50.83,155.06 50.5,155.39 48.55,155.39 39.84,146.69 39.84,144.57 39.56,144.29 37.67,144.29 37.43,144.06 37.43,143.78 37.67,143.55 39.34,143.55 39.58,143.31 39.58,142.59 39.34,142.35 37.84,142.35 37.61,142.11 37.61,141.84 37.84,141.6 39.34,141.6 39.58,141.36 39.58,140.65 39.34,140.4 37.84,140.4 37.68,140.25 37.68,139.82 37.84,139.66 39.34,139.66 39.58,139.42 39.58,138.7 39.34,138.46 37.6,138.46 37.42,138.28 37.42,137.9 37.6,137.72 39.34,137.72 39.58,137.48 39.58,136.55 39.8,136.33 39.8,135.13 40.21,134.72 40.21,132.31 40.39,132.13 41,132.13 41.24,131.9 41.24,131.11 v4(41.7,130.65)
DDRB_DQS3_P: length 55
  TOP w0.095: v4(52.96,159.22) U14.B7 ; U40.AN18 v4(40.7,130.65)
  S9 w0.108: v4(40.7,130.65) 40.17,131.17 39.52,131.17 39.19,131.5 39.19,134.7 39.58,135.08 39.58,136.24 39.35,136.46 39.35,137.38 39.24,137.49 37.5,137.49 37.19,137.81 37.19,138.37 37.5,138.69 39.24,138.69 39.35,138.8 39.35,139.33 39.24,139.43 37.75,139.43 37.46,139.73 37.46,140.34 37.75,140.63 39.24,140.63 39.35,140.74 39.35,141.27 39.24,141.38 37.75,141.38 37.38,141.74 37.38,142.21 37.75,142.58 39.24,142.58 39.35,142.68 39.35,143.21 39.24,143.32 37.57,143.32 37.2,143.69 37.2,144.15 37.57,144.52 39.47,144.52 39.61,144.67 39.61,146.78 48.46,155.62 50.59,155.62 50.92,155.29 52.82,155.29 53.1,155.57 53.1,157.23 53.34,157.47 53.63,157.47 53.74,157.58 53.74,157.78 53.24,158.28 53.24,158.93 v4(52.96,159.22)
DDRB_ODT: length 100
  TOP w0.127: v4(49.7,133.65) U40.AT9
  TOP w0.13: v4(56.96,166.42) U14.K3 ; v4(67.5,166.42) U15.K3
  S7 w0.127: v4(56.96,166.42) 56.96,166.42 57.36,166.81 59.87,166.81 60.67,166.01 63.86,166.01 64.14,165.74 64.14,160.27 64.41,159.99 65.46,159.99 65.94,160.48 65.94,163.53 66.88,164.47 66.88,165.33 66.75,165.46 66.5,165.46 66.37,165.58 66.37,166.29 66.5,166.42 v4(67.5,166.42)
  S14 w0.127: v4(56.96,166.42) 57.36,166.01 58.82,166.01 59.02,166.22 59.02,171.9 59.3,172.18 59.81,172.18 60.05,171.94 60.05,166.08 60.54,165.58 60.54,161.54 60.86,161.22 63.65,161.22 64.14,160.73 64.14,157.28 63.72,156.86 63.69,156.86 63.57,156.73 63.57,156.22 63.69,156.1 65.95,156.1 66.08,155.97 66.08,155.46 65.95,155.33 63.69,155.33 63.57,155.21 63.57,154.7 63.69,154.57 65.95,154.57 66.08,154.45 66.08,153.94 65.88,153.74 63.03,153.74 62.5,153.21 62.5,150.36 53,140.85 53,138.32 50.14,135.46 50.14,134.46 50.13,134.46 50.13,134.32 49.7,133.88 v4(49.7,133.65)
  BOTTOM w0.127: v4(67.5,166.42) 67.13,166.42 67.12,166.43 66.84,166.43 66.08,167.18 66.08,171.55 RB80.2
DDRB_PAR: length 83.2
  TOP w0.127: R157.2 68.61,174.08 68.61,172.12 67.71,171.22 v4(67.5,171.22) ; v4(52.7,134.65) U40.AU6
  TOP w0.13: v4(56.96,171.22) U14.T3 ; v4(67.5,171.22) U15.T3
  S5 w0.127: v4(56.96,171.22) 57.39,171.65 60.65,171.65 60.77,171.78 61.69,171.78 61.81,171.65 67.06,171.65 v4(67.5,171.22)
  S16 w0.127: v4(56.96,171.22) 56.96,171.7 57.44,172.18 58.98,172.18 60.59,170.57 62,170.57 62.25,170.81 65.8,170.81 67.1,169.51 67.1,165.45 67.15,165.41 67.15,164.31 66.3,163.47 66.3,157.89 66.43,157.76 69.46,157.76 69.56,157.66 69.56,157.1 69.46,157 66.18,157 66.06,156.87 66.06,156.37 66.18,156.24 69.22,156.24 69.35,156.11 69.35,155.6 69.22,155.48 66.43,155.48 66.3,155.35 66.3,154.65 52.7,141.04 v4(52.7,134.65)
DDRB_RAS_N: length 86.3
  TOP w0.127: v4(48.7,128.65) U40.AL10 ; U15.L8 63.09,166.82 v4(62.69,167.22)
  TOP w0.13: U14.L8 52.19,167.18 52.19,167.18 52.16,167.22 v4(52.16,167.22)
  S12 w0.127: v4(62.69,167.22) 61.73,167.59 61.57,167.61 52.91,167.61 52.8,167.6 v4(52.16,167.22)
  S14 w0.127: v4(48.7,128.65) 48.7,128.33 48.48,128.12 46.48,128.12 46.23,128.37 46.23,128.88 45.98,129.14 45.51,129.14 45.19,129.46 45.19,129.85 44.9,130.14 43.58,130.14 43.19,130.52 43.19,130.93 42.93,131.19 42.5,131.19 42.22,131.47 42.22,136.84 50.38,145 50.38,146.66 50.62,146.9 52.28,146.9 52.48,147.09 52.48,147.47 52.3,147.65 50.51,147.65 50.38,147.77 50.38,148.28 50.51,148.41 52.22,148.41 52.48,148.66 52.48,149.8 52.35,149.93 51.86,149.93 51.73,150.06 51.73,150.56 51.86,150.69 52.35,150.69 52.48,150.82 52.48,151.33 52.35,151.45 51.86,151.45 51.73,151.58 51.73,152.09 51.86,152.21 52.35,152.21 52.48,152.34 52.48,152.85 52.35,152.98 51.86,152.98 51.73,153.1 51.73,153.61 51.86,153.74 52.35,153.74 52.48,153.87 52.48,154.37 51.18,155.67 51.18,156.78 50.92,157.04 50,157.04 49.88,157.17 49.88,157.68 50,157.8 50.64,157.8 50.77,157.93 50.77,164.3 50.89,164.43 52.82,164.43 52.95,164.56 52.95,165.06 52.82,165.19 50.89,165.19 50.77,165.32 50.77,166.52 51.06,166.81 51.74,166.81 v4(52.16,167.22)
  BOTTOM w0.127: v4(62.69,167.22) 62.7,167.22 63.09,167.62 63.72,167.62 64.48,168.37 RB64.2
DDRB_RST_N: length 81.9
  TOP w0.127: v4(46.7,128.65) U40.AL12 ; v4(69.1,169.62) 69.32,169.39 R237.2
  TOP w0.13: v4(58.56,169.62) U14.P1 ; v4(69.1,169.62) U15.P1
  S7 w0.127: v4(58.56,169.62) 59.05,169.62 59.17,169.49 61.15,169.49 61.43,169.21 68.69,169.21 v4(69.1,169.62)
  S16 w0.127: v4(58.56,169.62) 58.34,169.62 57.94,170.01 56.11,170.01 55.92,170.2 55.92,171.45 55.79,171.57 53.61,171.57 53.38,171.35 53.38,170.91 53.53,170.76 54.98,170.76 55.11,170.63 55.11,168.88 54.45,168.22 54.45,162.15 55.21,161.39 55.21,155.22 54.47,154.48 53.9,154.48 50.79,151.37 50.79,150.77 50.6,150.58 49.47,150.58 49.34,150.46 49.34,149.95 49.47,149.82 50.41,149.82 50.69,149.55 50.69,149.33 50.41,149.06 49.47,149.06 49.34,148.93 49.34,148.42 49.47,148.3 50.41,148.3 50.64,148.07 50.64,147.76 50.41,147.54 49.47,147.54 49.34,147.41 49.34,146.9 49.47,146.77 51.33,146.77 51.65,146.45 51.65,146.1 45.09,139.54 45.09,129.6 45.55,129.14 45.85,129.14 46.34,128.65 v4(46.7,128.65)
DDRB_TEN: length 18.4
  TOP w0.127: R269.1 R270.2 49.11,167.56 50.37,168.82 v4(51.36,168.82)
  TOP w0.13: v4(61.9,168.82) U15.N9 ; U14.N9 v4(51.36,168.82)
  S12 w0.122: v4(51.36,168.82) 51.75,169.21 61.5,169.21 v4(61.9,168.82)
  BOTTOM w0.127: v2(50.7,169.16) 51.05,168.82 v4(51.36,168.82)
DDRB_VREF_1: length 6.7
  TOP w0.381: v4(69.1,168.02) U15.M1
  BOTTOM w0.381: RB120.1 RB117.1 CB195.1 CB183.1 RB105.2 70.38,168.35 v2(69.94,168.35) 69.79,168.35 69.46,168.02 v4(69.1,168.02)
DDRB_VREF_2: length 6.2
  TOP w0.381: v4(58.56,168.02) U14.M1
  BOTTOM w0.381: v2(58.64,164.82) 59.15,164.31 RB119.1 CB203.1 RB113.2 CB177.1 59.34,167.23 v4(58.56,168.02)
DDRB_WE_N: length 87
  TOP w0.127: v4(46.7,127.65) U40.AK12
  TOP w0.13: v4(68.3,167.22) U15.L2 ; v4(57.76,167.22) U14.L2
  S9 w0.127: v4(57.76,167.22) 57.76,167.19 58.13,166.82 67.9,166.82 v4(68.3,167.22)
  S16 w0.127: v4(46.7,127.65) 46.7,128.01 47.18,128.5 47.18,128.84 46.89,129.14 46.46,129.14 46.3,129.29 46.3,140.03 53.85,147.58 53.85,147.74 53.72,147.86 51.34,147.86 51.22,147.98 51.22,148.66 51.35,148.79 54.5,148.79 54.68,148.97 54.68,149.59 54.55,149.72 51.32,149.72 51.2,149.84 51.2,150.35 51.32,150.48 54.55,150.48 54.68,150.61 54.68,151.11 54.55,151.24 52.14,151.24 52.01,151.37 52.01,151.88 52.14,152 54.55,152 54.68,152.13 54.68,152.64 54.55,152.77 53.84,152.77 53.71,152.89 53.71,153.4 53.84,153.53 54.55,153.53 54.68,153.65 54.68,153.96 55.72,155.01 55.72,161.77 54.96,162.53 54.96,166.6 55.97,167.61 57.36,167.61 v4(57.76,167.22)
  BOTTOM w0.127: RB82.2 67.18,172 67.11,171.92 66.72,171.19 66.72,168.17 67.27,167.62 67.9,167.62 v4(68.3,167.22)
DDRB_ZQ_1: length 6
  TOP w0.13: v4(61.9,162.42) U15.F9
  BOTTOM w0.127: v2(61.27,158.82) 62.06,158.82 62.3,159.06 62.3,160.98 62.06,161.21 61.75,161.21 61.52,161.44 RB127.2 61.28,161.65 61.9,162.27 v4(61.9,162.42)
DDRB_ZQ_2: length 6.3
  TOP w0.13: v4(51.36,162.42) U14.F9
  BOTTOM w0.127: v4(51.36,162.42) 50.89,162.89 48.63,162.89 47.92,162.17 RB125.2 47.92,161.84 47.37,161.3 v2(47.37,160.63)
DDRC_100M_N: length 109.8
  TOP w0.095: RB22.1 93.36,190.13 94.82,190.13 arc(94.86,190.12) 94.89,190.1 94.93,190.06 arc(94.95,190.03) 94.96,189.99 94.96,189.7 arc(94.95,189.66) 94.93,189.63 v3(94.56,189.27)
  BOTTOM w0.095: CB455.1 61.73,124.27 61.85,124.27 62.15,124.58 arc(62.35,124.87) 62.42,125.23 62.42,133.11 arc(62.53,133.63) 62.82,134.07 72.05,143.29 arc(72.66,144.2) 72.87,145.28 72.87,149.88 arc(72.94,150.23) 73.14,150.52 77.06,154.44 arc(78.03,155.09) 79.17,155.32 102.89,155.32 arc(103.23,155.38) 103.51,155.57 103.77,155.83 104.94,157.01 105.4,157.46 arc(105.6,157.76) 105.66,158.1 105.66,172.3 arc(105.55,172.87) 105.22,173.36 99.52,179.07 arc(98.89,180) 98.67,181.11 98.67,189.14 arc(98.62,189.39) 98.48,189.61 97.69,190.4 arc(97.4,190.59) 97.06,190.66 95.55,190.66 arc(95.13,190.49) 94.96,190.06 94.96,189.74 arc(94.94,189.66) 94.9,189.6 v3(94.56,189.27)
DDRC_100M_P: length 109.7
  TOP w0.095: v3(95.58,189.27) 95.21,189.63 arc(95.19,189.66) 95.19,189.7 95.19,189.99 arc(95.16,190.11) 95.09,190.22 95.05,190.26 arc(94.95,190.33) 94.82,190.35 93.36,190.35 RB38.1
  BOTTOM w0.095: CB441.1 61.57,124.5 61.75,124.5 61.99,124.74 arc(62.14,124.96) 62.19,125.23 62.2,125.23 62.2,126.93 arc(62.15,127.04) 62.04,127.09 arc(61.93,127.13) 61.88,127.25 61.88,127.41 arc(61.93,127.52) 62.04,127.57 arc(62.15,127.61) 62.2,127.72 62.2,127.89 arc(62.15,128) 62.04,128.04 arc(61.93,128.09) 61.88,128.2 61.88,128.36 arc(61.93,128.47) 62.04,128.52 arc(62.15,128.56) 62.2,128.67 62.2,133.11 arc(62.32,133.71) 62.66,134.23 71.89,143.46 arc(72.45,144.29) 72.64,145.28 72.64,149.88 arc(72.73,150.31) 72.98,150.68 76.89,154.6 arc(77.94,155.3) 79.17,155.55 102.89,155.55 arc(103.14,155.6) 103.35,155.74 103.61,155.99 105.24,157.63 arc(105.38,157.84) 105.44,158.1 105.44,172.3 arc(105.34,172.79) 105.06,173.2 99.36,178.91 arc(98.68,179.92) 98.44,181.11 98.44,189.14 arc(98.41,189.31) 98.32,189.45 97.53,190.24 arc(97.31,190.38) 97.06,190.43 95.55,190.43 arc(95.29,190.32) 95.18,190.06 95.18,189.74 arc(95.2,189.67) 95.24,189.61 v3(95.58,189.27)
DDRC_100M_REFCLK_N: length 11.2
  TOP w0.095: v4(51.7,123.65) U40.AF7
  BOTTOM w0.095: v4(51.7,123.65) 51.25,123.65 51.13,123.77 51.13,123.88 arc(51.18,123.99) 51.28,124.03 57.95,124.03 arc(58.13,124.07) 58.28,124.17 arc(58.31,124.19) 58.35,124.2 58.47,124.2 arc(58.61,124.17) 58.73,124.09 58.86,123.95 arc(58.98,123.88) 59.11,123.85 RB182.1 59.48,123.85 59.83,124.2 59.95,124.2 CB455.2
DDRC_100M_REFCLK_P: length 11.2
  TOP w0.095: v4(50.7,123.65) U40.AF8
  BOTTOM w0.095: v4(50.7,123.65) 50.77,123.65 50.9,123.78 50.9,123.88 arc(51.01,124.15) 51.28,124.26 57.95,124.26 arc(58.04,124.28) 58.12,124.33 arc(58.22,124.4) 58.35,124.42 58.51,124.42 arc(58.69,124.46) 58.85,124.56 59.04,124.76 RB182.2 59.43,124.76 59.76,124.42 59.96,124.42 CB441.2
DDRC_A0: length 106.3
  TOP w0.127: U40.AM7 v4(51.7,129.65)
  TOP w0.13: v4(98.48,169.62) U17.P3 ; U16.P3 v4(87.94,169.62)
  S7 w0.127: v4(87.94,169.62) 88.34,170.01 98.09,170.01 v4(98.48,169.62)
  S14 w0.127: v4(51.7,129.65) 52.22,129.13 52.99,129.13 53.22,128.9 53.22,128.37 53.47,128.12 53.9,128.12 54.25,127.77 54.25,127.31 54.44,127.12 55.83,127.12 56.15,126.79 56.15,126.52 56.51,126.16 58.49,126.16 68.92,136.59 74.14,136.59 80.25,142.71 80.25,145.51 79.77,146 79.77,148.21 81.04,149.48 81.04,152.59 80.38,153.25 78.35,153.25 78.22,153.38 78.22,155.41 78.35,155.54 80.91,155.54 81.04,155.67 81.04,156.18 80.86,156.36 79.87,156.36 79.7,156.54 79.7,156.99 79.85,157.15 80.92,157.15 81.04,157.27 81.04,158.21 81.58,158.75 81.58,159.33 81.86,159.61 94.78,159.61 95.34,160.17 95.34,160.94 97.14,162.74 97.14,164.76 97.5,165.12 97.5,168.63 v4(98.48,169.62)
  BOTTOM w0.127: RB71.2 86.86,174.63 86.86,172.44 87.04,172.26 87.04,170.13 87.55,169.62 v4(87.94,169.62)
DDRC_A1: length 120.5
  TOP w0.127: R197.2 79.85,172.44 80.23,172.82 82.44,172.82 83.28,171.98 83.81,171.98 84.76,171.03 84.76,169.7 84.7,169.57 U16.P7 ; U40.AU4 v4(54.7,134.65)
  TOP w0.13: v4(94.49,169.62) U17.P7 ; v4(83.94,169.62) U16.P7
  S12 w0.127: v4(83.94,169.62) 84.34,170.01 94.83,170.01 95.12,170.31 95.12,171.07 95.22,171.17 97.69,171.17 98.05,170.81 99.57,170.81 99.69,170.69 99.69,170.15 99.57,170.02 98.02,170.02 97.74,169.74 94.61,169.74 v4(94.49,169.62)
  S14 w0.127: v4(94.49,169.62) 94.09,170.01 92.72,170.01 91.86,169.15 91.79,169.15 91.66,169.03 91.66,168.4 90.08,166.82 87.65,166.82 87.47,167 87.47,171.63 86.2,172.9 83.91,172.9 82.74,174.06 75.6,174.06 75.48,173.94 75.48,173.43 75.35,173.3 74.84,173.3 74.72,173.43 74.72,173.94 74.59,174.06 73.98,174.06 73.83,173.91 73.83,173.17 73.7,173.05 72.44,173.05 72.1,172.71 72.1,167.89 72.66,167.33 73.88,167.33 74.16,167.05 74.16,160.07 72.08,157.99 72.08,151.64 72.76,150.96 72.76,143.85 71.01,142.09 64.04,142.09 61.8,139.86 61.8,138.48 58.47,135.15 55.2,135.15 v4(54.7,134.65)
DDRC_A2: length 105.5
  TOP w0.127: v4(52.7,130.65) U40.AN6
  TOP w0.13: v4(87.94,170.42) U16.R3 ; v4(98.48,170.42) U17.R3
  S7 w0.127: v4(98.48,170.42) 98.09,170.82 88.34,170.82 v4(87.94,170.42)
  S14 w0.127: v4(52.7,130.65) 53.05,130.65 53.51,131.11 53.89,131.11 54.19,130.81 54.19,130.41 54.49,130.11 54.94,130.11 55.19,129.85 55.19,129.42 55.53,129.09 55.88,129.09 56.14,128.83 56.14,128.48 56.49,128.13 58.3,128.13 62.07,131.9 62.07,132.23 67.76,137.92 73.42,137.92 79.21,143.71 79.21,144.7 78.65,145.26 78.65,150.34 76.57,152.42 76.57,155.67 80.31,159.41 80.31,160.25 79.82,160.73 79.82,162.51 80,162.68 80.79,162.68 80.97,162.86 80.97,163.27 80.74,163.5 80.13,163.5 79.95,163.68 79.95,164.06 80.1,164.21 81.19,164.21 81.75,163.65 81.75,162.25 81.98,162.02 84.29,162.02 85.11,161.21 87.78,161.21 88.58,161.21 89.38,161.21 90.97,161.21 92.57,162.81 92.72,162.81 93.05,162.81 93.05,162.81 93.52,162.81 93.85,162.81 93.85,162.81 94.32,162.81 94.76,162.81 95.55,163.6 95.55,164.82 96.33,165.61 96.33,169.24 97.51,170.42 v4(98.48,170.42)
  BOTTOM w0.127: RB74.2 89.5,173.24 88.34,172.08 88.34,170.82 v4(87.94,170.42)
