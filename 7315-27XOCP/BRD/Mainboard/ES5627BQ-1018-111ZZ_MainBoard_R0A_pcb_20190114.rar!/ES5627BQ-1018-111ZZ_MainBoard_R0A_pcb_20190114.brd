# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VPP_DDR2P5_MARGIN_LOW: length 29.5
  TOP w0.127: R188.2 91.28,218.86 v1(91.34,218.79) ; P1.AB13 v4(116.29,222.46)
  S7 w0.127: v4(116.29,222.46) 114.1,220.27 94.6,220.27 93.69,219.36 91.91,219.36 v1(91.34,218.79)
  BOTTOM w0.127: v1(91.34,218.79) 90.64,218.09 v2(90.52,218.09)
VPP_DDR2P5_MARGIN_LOW_D: length 53.9
  TOP w0.381: QB6.D 80.08,219.5 v1(80.14,219.44)
  TOP w0.508: RB232.1 38.51,198.02 v1(38.45,198.09)
  S7 w0.381: v1(38.45,198.09) 38.75,198.39 57,198.39 69.12,210.52 71.21,210.52 v1(80.14,219.44)
  BOTTOM w0.381: v2(37.86,198.99) 37.86,198.68 v1(38.45,198.09)
VPP_DDR2P5_MARGIN_LOW_R: length 10.6
  TOP w0.127: R188.1 87.73,218.86 C112.2 86.83,219.3 85.12,219.3 84.79,218.97 R139.1 83.93,218.97 83.03,219.88 QB6.G 82.28,218.96 v1(82.9,218.35)
  BOTTOM w0.127: v2(83.72,218.79) 83.34,218.79 v1(82.9,218.35)
VPP_DDR2P5_MON: length 13.4
  TOP w0.254: R81.2 R80.1 240.18,219.67 239.73,220.12 238.02,220.12 237.76,219.85 C53.1 237,219.55 236.3,220.24 235.92,220.24 U7.58 234.86,220.24 v1(234.47,220.63)
  BOTTOM w0.127: v1(234.47,220.63) 235.23,220.63 236.5,219.36 v2(238.6,219.36)
VPP_DDR2P5_VBST: length 5.4
  TOP w0.254: U32.30 43.56,190.1 43.92,190.46 43.92,191.86 v1(44.05,191.99) 45.19,193.13 C323.2
  BOTTOM w0.381: v1(44.05,191.99) 44.35,192.28 v2(44.9,192.28)
VPP_DDR2P5_VIN: length 1.3
  TOP w0.508: C293.1 36.12,185.47
  BOTTOM w0.508: 36.03,185.14 36.12,185.23 C293.1
  vias: v1(30.64,182.84) v1(31.59,183.6) v1(31.65,182.84) v1(32.6,183.6) v1(32.67,182.84) v1(33.62,183.6) v1(33.68,182.84) v1(34.46,183.63) v1(34.57,182.84) v2(30,183.68)
VPP_DDR2P5_VREG: length 4.5
  TOP w0.254: v1(36.81,189.9) 37.01,190.1 U32.3
  TOP w0.508: C285.1 36.18,189.9 v1(36.81,189.9)
  BOTTOM w0.381: RB159.1 36.81,189.9 v1(36.81,189.9)
  BOTTOM w0.508: v1(36.81,189.9) 37.56,189.9 v2(37.75,190.09)
VREG5_VCC5P0: length 4.1
  TOP w0.508: U34.6 v1(245.08,163.22) 243.85,163.22 C354.1
  BOTTOM w0.254: v1(245.08,163.22) 245.15,163.29 v2(246.22,163.29)
VSTB_3V3: length 352.1
  TOP w0.508: v1(118.01,120.56) 118.4,120.95 R647.2 ; v1(118.78,123.61) R599.2 R590.2
  S9 w0.508: v1(118.78,123.61) 118.01,122.83 v1(118.01,120.56) 118.01,117.19 v1(121.19,114.02) ; v1(221.39,206.03) 221.39,206.03 ; 221.39,206.03 221.39,206.73 v1(221.33,206.79) ; 221.39,206.03 v1(221.39,205.21)
  S12 w0.508: v1(226.78,204.21) 226.78,203.79 219.27,196.28 219.27,194.42 216.52,191.67 216.52,158.45 213.71,155.64 210.31,155.64 205.02,150.35 204.36,150.35 201.08,147.07 196.94,147.07 195.33,145.45 193.62,145.45 191.66,143.48 191.66,139.01 188.58,135.93 171.14,135.93 170.72,135.5 154.64,135.5 151.21,132.07 148.43,132.07 144.39,128.03 139.96,128.03 139.45,127.52 133.62,127.52 121.19,115.09 v1(121.19,114.02)
  V18 w0.635: 48.64,227.94 CONN6.6 ; CONN6.6 51.31,227.94 ; CONN6.6 49.97,226.6 ; CONN6.6 49.97,229.27 ; CONN6.18 51.31,233.44 ; CONN6.18 49.97,234.77 ; CONN6.18 48.64,233.44 ; CONN6.18 49.97,232.1
  BOTTOM w0.381: CONN6.18 49.97,234.77 ; CONN6.18 51.31,233.44 ; CONN6.18 49.97,232.1 ; CONN6.18 48.64,233.44 ; CONN6.6 49.97,229.27 ; CONN6.6 49.97,226.6 ; CONN6.6 51.31,227.94 ; CONN6.6 48.64,227.94
  BOTTOM w0.508: v1(49.88,237.72) 49.94,237.78 CB35.1 ; CB1091.2 49.94,224.44 v1(50,224.51) ; v1(121.19,114.02) 121.89,114.72 125.82,114.72 129.89,110.65 129.89,93.95 116.97,81.04 88.18,81.04 v2(80.25,88.96) 76.31,92.9 66.3,92.9 59.5,86.1 33.09,86.1 31.38,87.81 31.38,90.26 32.35,91.23 RB236.1
  vias: v1(49.88,236.83) v1(49.88,236) v1(50,226.29) v1(50,225.33) v1(221.33,207.55) v2(221.08,208.71)
VTT_REFIN: length 7
  TOP w0.254: 64.8,184.84 65.2,184.84 65.5,185.14 U6.1
  TOP w0.381: R45.1 C31.2 63.5,184.39 63.96,184.84 64.8,184.84 ; R45.1 v1(61.23,184.39) ; R45.1 61.93,183.19 R49.2
  BOTTOM w0.254: v1(61.23,184.39) 61.37,184.25 v2(62.13,184.25)
VTT_REFOUT: length 3.7
  TOP w0.254: U6.6 67.5,188.71 67.67,188.88 v1(68.13,188.88)
  TOP w0.381: v1(68.13,188.88) 68.59,189.34 C60.2
  BOTTOM w0.127: v2(69.12,188.88) 68.13,188.88 v1(68.13,188.88)
XFP_3V3: length 602
  TOP w0.254: v1(220.22,59.82) 219.33,59.82 219.04,59.53 217.96,59.53 217.67,59.82 LED6.A ; v1(199.23,60.17) 199.33,60.07 200.65,60.07 LED5.A ; v1(215.03,46.38) 215.03,48.08 216.75,49.81 LED7.A ; v1(202.35,48.97) 201.56,49.76 LED8.A
  TOP w0.381: LED41.A1 LED41.A2 81.14,53.5 v1(81.49,53.15) ; R109.1 v1(242.98,215.48) ; v1(168.9,49.5) 168.6,49.5 168.59,49.5 LED28.A2 LED28.A1 ; LED36.A2 LED36.A1 v1(39.94,49.4) ; v1(168.27,52.78) 168.26,52.78 LED53.A2 LED53.A1 ; v1(109.21,52.83) 109.21,52.83 LED45.A2 LED45.A1 ; v1(170.37,49.5) 170.83,49.5 170.83,49.5 LED54.A1 LED54.A2 ; LED49.A1 LED49.A2 139.96,53.5 v1(140.58,52.88) ; v1(113.4,49.5) LED46.A1 LED46.A2 ; v1(184.52,53.01) 185.02,53.5 LED31.A1 LED31.A2 ; LED12.A1 LED12.A2 v1(52.95,49.4) ; LED26.A2 LED26.A1 153.31,48.81 v1(153.36,48.77) ; v1(196.76,48.79) LED32.A2 LED32.A1 ; v1(141.49,52.88) 142.12,53.5 LED25.A1 LED25.A2 ; LED17.A2 LED17.A1 82.97,53.5 v1(82.63,53.16) ; LED21.A2 LED21.A1 113.54,53.03 v1(113.43,53.03) ; v1(156.12,49.5) LED52.A1 LED52.A2 ; v1(125.49,52.83) 125.51,52.85 LED47.A2 LED47.A1 ; LED10.A1 LED10.A2 v1(38.7,49.4) ; v1(128.26,52.83) 128.26,52.91 128.26,52.91 LED23.A1 LED23.A2 ; LED27.A2 LED27.A1 156.1,53.5 v1(156.08,53.48) ; v1(68.42,52.94) 68.99,53.5 LED15.A1 LED15.A2 ; LED34.A2 LED34.A1 26.46,48.85 v1(26.23,48.61) ; LED40.A2 LED40.A1 v1(68.47,49.5) ; LED14.A1 LED14.A2 v1(67.39,49.5) ; v1(171.01,52.78) 171.01,52.8 171.01,52.81 LED29.A1 LED29.A2 ; v1(140.4,49.5) 140.1,49.5 140.09,49.5 LED24.A2 LED24.A1 ; LED48.A2 LED48.A1 128.26,48.91 128.26,48.91 v1(128.26,48.83) ; LED11.A2 LED11.A1 LED35.A2 LED35.A1 37.26,53.17 v1(36.72,52.63) ; LED57.A2 LED57.A1 196.06,52.94 v1(195.93,52.8) ; LED22.A1 LED22.A2 125.51,48.85 v1(125.49,48.83) ; v1(81.35,49.5) LED16.A2 LED16.A1 ; LED37.A1 LED37.A2 52.58,53.4 v1(53.08,52.91) ; v1(67.26,52.92) 66.68,53.5 LED39.A2 LED39.A1 ; v1(27.82,53.52) 27.71,53.4 LED9.A2 LED9.A1 ; v1(182.51,52.75) LED30.A2 LED30.A1 ; LED13.A2 LED13.A1 54.64,53.5 54.32,53.19 v1(54.32,52.99) ; v1(109.85,49.5) LED20.A2 LED20.A1 ; v1(182.52,48.79) 182.51,48.79 LED55.A2 LED55.A1 ; v1(154.91,53.06) 154.46,53.5 LED51.A2 LED51.A1 ; v1(82.71,49.5) LED42.A1 LED42.A2 ; v1(144.4,97.5) 144.4,98.54 R759.1 ; v1(54.33,49.5) 54.34,49.5 LED38.A1 LED38.A2 ; v1(141.87,49.5) 142.33,49.5 142.33,49.5 LED50.A1 LED50.A2 ; LED56.A2 LED56.A1 185.26,48.82 v1(185.23,48.79)
  TOP w0.508: R865.2 15.03,68.38 14.44,67.79 v1(14.39,67.79) ; v1(95.82,49.5) 95.82,49.5 LED18.A2 LED18.A1 ; C493.2 157.38,90.83 ; v1(95.75,53.11) 95.35,53.5 LED43.A2 LED43.A1 ; R864.2 v1(10.81,66.85) ; v1(4.01,67.08) 3.99,67.05 R863.2 ; v1(97.02,49.5) LED44.A1 LED44.A2 ; R869.2 v1(20.43,67.99) ; v1(96.87,53.11) 96.87,53.13 97.24,53.5 LED19.A1 LED19.A2
  V3 w0.254: 219.46,59.94 220.09,59.94 v1(220.22,59.82)
  S5 w0.381: v1(144.4,97.5) 144.42,97.52 144.42,98.73 CONN48.1
  S12 w0.381: v1(242.98,215.48) 242.98,213.77 243.36,213.39 243.36,185.09 229.16,170.9 229.16,167.84 229.2,167.8 229.2,149.45 224.44,144.69 224.44,143.42 217.39,136.37 217.39,112.37 217.58,112.18 217.58,108.87 217.39,108.68 217.39,97.25 211.99,91.86 v1(211.99,88.17)
  S12 w0.508: v1(58.89,22.2) 59.66,21.44 v1(59.66,6.7)
  S14 w0.381: v1(242.67,6.12) 242.67,6.11 242.56,6 230.85,6 226,10.86 222.74,10.86 221.91,11.69 217.13,11.69 216.21,12.6 208.43,12.6 202.58,18.45 v1(202.58,21.41)
  S16 w0.381: v1(249.62,6.18) 249.61,6.2 242.75,6.2 242.67,6.11 v1(242.67,6.12)
  S16 w0.508: v1(144.4,97.5) 146,97.5 149.67,93.83 154.91,93.83 158.01,90.72 v1(158.01,90.32) ; 66.65,6.82 v1(66.64,6.83) ; 66.65,6.82 66.54,6.7 v1(59.66,6.7) 59.65,6.7 52.67,6.7 v1(52.67,6.7) 46.19,6.7 v1(45.81,6.32) 45.81,6.32 38.7,6.32 v1(38.7,6.32) ; 66.65,6.82 v1(73.89,6.82)
  BOTTOM w0.381: RB455.2 v1(30.88,36.28) RB454.2 ; v1(209.26,46.35) 208.93,46.68 RB309.1 ; v1(91.21,36.97) RB513.2 RB441.2 RB440.2 RB439.2 v1(91.21,32.55) ; v1(105.46,32.55) RB442.2 RB443.2 RB444.2 RB516.2 v1(105.46,36.97) ; v1(178.76,32.55) RB448.2 RB449.2 RB450.2 RB522.2 v1(178.76,36.97) ; v1(121.76,32.55) RB460.2 RB461.2 RB462.2 RB534.2 v1(121.76,36.97) ; RB337.2 v1(29.24,42) ; v1(32.8,42) 32.92,41.87 RB339.2 ; v1(164.51,36.97) RB519.2 RB447.2 RB446.2 RB445.2 v1(164.51,32.55) ; v1(33.99,36.97) RB456.2 RB492.2 RB528.2 RB564.2 ; v1(48.46,32.55) RB567.2 RB531.2 RB495.2 RB459.2 v1(48.46,36.97) ; v1(144.4,97.5) 143.72,98.19 v2(143.47,98.19) ; RB540.2 v1(150.26,36.97) ; v1(150.26,32.55) RB466.2 RB467.2 RB468.2 ; v1(249.62,6.18) 250.27,6.18 252.06,7.97 v2(252.06,8.1) ; RB338.2 v1(31.02,42) ; RB490.2 v1(30.88,35.27) RB491.2 ; RB526.2 v1(30.88,34.25) RB527.2 ; v1(192.95,32.51) 192.95,32.53 193.01,32.59 RB451.2 RB452.2 RB453.2 RB525.2 v1(193.01,36.97) ; v1(76.96,36.97) RB510.2 RB438.2 RB437.2 RB436.2 v1(76.96,32.55) ; RB340.2 34.96,41.87 v1(34.83,42) ; v1(135.3,32.26) 135.63,32.26 136.01,32.64 RB463.2 RB464.2 RB465.2 RB537.2 v1(136.01,36.97) ; RB564.2 v1(33.99,32.53) ; RB564.2 33.84,33.24 33.2,32.6 31.83,32.6 31.58,32.85 RB563.2 v1(30.88,33.24) RB562.2 ; v1(62.71,36.97) RB507.2 RB435.2 RB434.2 RB433.2 62.71,32.89 v1(62.27,32.46)
  BOTTOM w0.508: RB485.2 175.66,35.27 v1(175.66,35.28) 175.65,35.27 RB557.2 ; RB556.2 v1(175.64,33.24) RB486.2 ; RB457.2 45.35,36.29 v1(45.36,36.29) 45.36,36.29 RB458.2 ; RB545.2 73.85,35.27 v1(73.86,35.28) 73.86,35.27 RB473.2 ; RB482.2 161.41,35.27 v1(161.41,35.28) 161.4,35.27 RB554.2 ; RB469.2 v1(59.6,34.25) RB506.2 ; RB471.2 v1(59.59,33.24) RB541.2 ; RB504.2 v1(147.14,33.24) RB574.2 ; v1(214.01,46.4) RB330.2 RB310.2 v1(215.03,46.38) ; RB569.2 118.65,35.27 v1(118.66,35.28) 118.66,35.27 RB497.2 ; RB538.2 147.15,36.29 v1(147.16,36.29) 147.16,36.29 RB576.2 ; RB509.2 v1(73.86,34.25) RB472.2 ; RB524.2 v1(189.91,34.25) RB487.2 ; v1(72.2,42.11) RB349.2 RB350.2 RB351.2 RB352.2 77.79,42.11 v1(77.82,42.14) ; RB512.2 v1(88.1,34.25) RB475.2 ; RB496.2 v1(118.66,34.25) RB533.2 ; RB532.2 118.65,36.29 v1(118.66,36.29) 118.66,36.29 RB570.2 ; LEDB11.A v1(38.7,6.32) ; RB508.2 73.85,36.29 v1(73.86,36.29) 73.86,36.29 RB546.2 ; v1(57.95,42.11) RB345.2 RB346.2 RB347.2 RB348.2 63.54,42.11 v1(63.57,42.14) ; v1(43.7,42.11) RB341.2 RB342.2 RB343.2 RB344.2 49.29,42.11 v1(49.32,42.14) ; v1(145.5,42.11) RB369.2 RB370.2 RB371.2 RB372.2 151.09,42.11 v1(151.12,42.14) ; RB555.2 161.41,36.29 v1(161.41,36.29) 161.4,36.29 RB517.2 ; v2(111.92,72.93) 111.92,74.08 v1(111.98,74.14) ; RB313.2 v1(213,46.43) ; RB474.2 v1(73.84,33.24) RB544.2 ; RB559.2 v1(189.89,33.24) RB489.2 ; RB505.2 59.6,36.29 v1(59.6,36.29) 59.61,36.29 RB543.2 ; v1(159.75,42.11) RB373.2 RB374.2 RB375.2 RB376.2 165.34,42.11 v1(165.37,42.14) ; v1(106.32,42.14) 106.29,42.11 RB360.2 RB359.2 RB358.2 RB357.2 v1(100.7,42.11) ; PTCB3.2 18.42,47.31 RB1224.2 18.43,48.01 RB1225.2 v1(19.23,49.04) ; RB493.2 45.35,35.27 v1(45.36,35.28) 45.36,35.27 RB494.2 ; RB565.2 v1(45.34,33.24) RB566.2 ; v1(117,42.11) RB361.2 RB362.2 RB363.2 RB364.2 122.59,42.11 v1(122.62,42.14) ; LEDB3.A 249.67,6.14 v1(249.62,6.18) ; RB550.2 v1(102.34,33.24) RB480.2 ; RB521.2 v1(175.66,34.25) RB484.2 ; RB553.2 v1(161.39,33.24) RB483.2 ; RB1223.1 19.21,59.31 RB1227.2 19.18,59.94 v1(18.95,60.17) ; v1(45.81,6.32) 45.7,6.21 LEDB7.A ; RB518.2 v1(161.41,34.25) RB481.2 ; v1(136.87,42.14) 136.84,42.11 RB368.2 RB367.2 RB366.2 RB365.2 v1(131.25,42.11) ; v1(188.25,42.11) RB381.2 RB382.2 RB383.2 RB384.2 193.84,42.11 v1(193.87,42.14) ; LEDB10.A 59.67,6.69 v1(59.66,6.7) ; RB514.2 102.35,36.29 v1(102.35,36.29) 102.36,36.29 RB552.2 ; RB573.2 132.91,36.29 v1(132.91,36.29) 132.9,36.29 RB535.2 ; RB529.2 v1(45.36,34.25) RB530.2 ; RB536.2 v1(132.91,34.25) RB499.2 ; v1(242.67,6.12) 242.67,5.5 242.67,5.5 LEDB4.A ; RB478.2 v1(102.35,34.25) RB515.2 ; RB500.2 132.91,35.27 v1(132.91,35.28) 132.9,35.27 RB572.2 ; RB520.2 175.65,36.29 v1(175.66,36.29) 175.66,36.29 RB558.2 ; RB551.2 102.35,35.27 v1(102.35,35.28) 102.36,35.27 RB479.2 ; RB327.2 v1(205.98,42.9) ; RB477.2 v1(88.09,33.24) RB547.2 ; LEDB8.A v1(66.64,6.83) ; LEDB9.A v1(52.67,6.7) ; RB571.2 v1(132.89,33.24) RB501.2 ; v1(92.07,42.14) 92.04,42.11 RB356.2 RB355.2 RB354.2 RB353.2 v1(86.45,42.11) ; RB539.2 v1(147.16,34.25) RB502.2 ; RB331.2 v1(211.98,46.4) ; LEDB15.A v1(73.89,6.82) ; v1(179.62,42.14) 179.59,42.11 RB380.2 RB379.2 RB378.2 RB377.2 v1(174,42.11) ; RB503.2 147.16,35.27 v1(147.16,35.28) 147.15,35.27 RB575.2 ; RB523.2 189.9,36.29 v1(189.91,36.29) 189.91,36.29 RB561.2 ; RB312.1 v1(210.96,46.4) ; RB548.2 88.1,35.27 v1(88.1,35.28) 88.11,35.27 RB476.2 ; RB560.2 189.9,35.27 v1(189.91,35.28) 189.91,35.27 RB488.2 ; RB511.2 88.1,36.29 v1(88.1,36.29) 88.11,36.29 RB549.2 ; RB542.2 59.6,35.27 v1(59.6,35.28) 59.61,35.27 RB470.2 ; RB326.2 v1(204.97,42.92) ; RB568.2 v1(118.64,33.24) RB498.2
  vias: v1(28.74,74.8) v1(28.74,73.4) v1(28.77,74.09) v1(29.58,74.75) v1(40.94,74.95) v1(40.94,74.25) v1(41.64,74.95) v1(41.66,74.21) v1(53.54,74.3) v1(53.97,74.88) v1(54.3,74.26) v1(67.03,74.26) v1(67.73,74.26) v1(68.49,74.26) v1(69.25,74.26) v1(79.54,74.26) v1(80.23,74.26) v1(81,74.26) v1(81.76,74.26) v1(109.69,74.14) v1(110.46,74.14) v1(111.22,74.14) v1(122.58,74.78) v1(123.31,74.19) v1(124.07,74.19) v1(124.83,74.19) v1(131,74.4) v1(131.77,74.4) v1(132.53,74.4) v1(148.74,74.39) v1(149.12,75.04) v1(149.68,74.48) v1(156.04,86.18) v1(156.81,86.18) v1(157.57,86.18) v1(158.01,89.56) v1(158.01,88.8) v1(158.01,88.03) v1(157.95,87.22) v1(158.33,86.18) v1(159.03,90.32) v1(159.03,89.56) v1(159.03,88.8) v1(159.03,88.03) v1(159.03,87.27) v1(160.04,90.32) v1(160.04,89.56) v1(160.04,88.8) v1(160.04,88.03) v1(160.04,87.27) v1(161.3,74.39) v1(162,74.39) v1(162.73,74.4) v1(163.75,86.07) v1(164.51,86.07) v1(165.27,86.07) v1(166.04,86.07) v1(168.42,90.13) v1(168.42,89.44) v1(168.42,88.73) v1(168.42,87.97) v1(169.31,90.13) v1(169.31,89.44) v1(169.31,88.73) v1(169.31,87.97) v1(169.69,92.1) v1(169.69,91.21) v1(170.2,90.13) v1(170.2,89.44) v1(170.2,88.73) v1(170.2,87.97) v1(170.46,92.1) v1(170.46,91.21) v1(173.19,74.27) v1(173.96,74.27) v1(174.72,74.27) v1(186.95,75) v1(186.96,74.29) v1(187.66,75.03) v1(187.72,74.29) v1(211.04,88.11) v1(211.09,87.36) v1(211.99,87.41)
XFP_3V3-R_P01: length 8.8
  TOP w0.508: 33.56,65.13 33.56,65.12 C690.1
  S14 w0.508: CONN54_PF.1T15 32.61,58.34 33.81,59.54 33.81,62.93 v1(33.37,63.37)
  BOTTOM w0.127: v1(33.37,63.37) 33.11,63.11 v2(33.11,62.52)
XFP_3V3-R_P02: length 21.2
  BOTTOM w0.127: v2(29.87,63.66) 29.81,63.66
  BOTTOM w0.305: C689.1 30.43,65.12 30.47,65.16
  BOTTOM w0.381: 29.84,63.63 29.59,63.63 27.02,61.06 27.02,57.01 27.84,56.19 27.84,55.22 26.83,54.2 26.83,51.66 28.31,50.17 30.85,50.17 31.72,49.3 CONN54_PF.1L15 ; C689.1 29.82,64.67
  BOTTOM w0.508: 29.84,63.63 v2(29.87,63.66)
XFP_3V3-R_P03: length 10.8
  TOP w0.508: 45.94,65.19 46,65.12 CB861.1
  S14 w0.508: CONN54_PF.2T15 46.86,58.17 48.03,59.34 48.03,61.44 46.13,63.35 v1(45.05,63.35)
  BOTTOM w0.127: v2(45.56,62.39) 45.05,62.9 v1(45.05,63.35)
XFP_3V3-R_P04: length 19.7
  BOTTOM w0.305: 42.95,65.06 42.95,65.06 C691.1
  BOTTOM w0.381: CONN54_PF.2L15 45.06,49.3 44.1,50.26 42.64,50.26 41.94,50.96 41.94,57.31 41.11,58.14 41.11,59.66 40.81,59.97 v2(40.81,60.63) 40.81,61.84 42.45,63.47 42.45,63.6
  BOTTOM w0.508: C691.1 42.39,64.53
XFP_3V3-R_P05: length 13.4
  TOP w0.381: CB862.1 58.63,65.12
  S9 w0.381: CONN54_PF.3T15 61.11,58.33 62.32,59.54 62.32,61.12 61.18,62.27 58.45,62.27 v1(57.43,63.28)
  BOTTOM w0.254: v2(58.93,61.69) 57.43,63.18 v1(57.43,63.28)
XFP_3V3-R_P06: length 19.5
  BOTTOM w0.381: v2(54.96,63.54) 53.81,62.39 53.81,60.36 56.19,57.98 56.19,50.93 57.05,50.07 59.54,50.07 CONN54_PF.3L15 ; 55.59,65.12 55.59,65.13 C693.1
XFP_3V3-R_P07: length 13.6
  TOP w0.381: C672.1 71.14,65.12
  S9 w0.381: v1(69.94,63.28) 74.2,63.28 76.23,61.25 76.23,59.34 75.36,58.48 CONN54_PF.4T15
  BOTTOM w0.127: v2(70.64,62.52) 69.94,63.22 v1(69.94,63.28)
XFP_3V3-R_P08: length 19.3
  BOTTOM w0.381: CONN54_PF.4L15 73.73,50.14 71.4,50.14 70.64,50.9 70.64,52.99 70.13,53.5 70.13,58.2 67.08,61.25 67.08,62.96 v2(67.59,63.47)
  BOTTOM w0.508: 68.03,65.13 C671.1
XFP_3V3-R_P09: length 14.3
  TOP w0.508: C674.1 83.79,65.13
  S9 w0.381: v1(82.58,63.35) 83.53,62.39 86.52,62.39 87.53,61.38 87.53,60.17 88.55,59.15 89.23,59.15 89.61,58.77 CONN54_PF.5T15
  BOTTOM w0.127: v1(82.58,63.35) 83.78,62.14 v2(84.37,62.14)
XFP_3V3-R_P10: length 19.7
  BOTTOM w0.381: 79.98,63.28 79.98,62.39 v2(80.55,61.82) 84.48,57.88 84.48,53.5 84.74,53.25 84.74,50.96 85.56,50.14 87.98,50.14 CONN54_PF.5L15
  BOTTOM w0.508: 80.59,65.12 C673.1
XFP_3V3-R_P11: length 16.9
  TOP w0.381: 114.65,65.12 C676.1 115.16,64.56 115.03,64.42 114.77,64.42
  S9 w0.381: v1(113.39,63.26) 112.85,62.71 106.9,62.71 105.57,61.38 105.57,59.66 103.72,57.82 103.72,57.04 CONN54_PF.6T15
  BOTTOM w0.381: v1(113.39,63.26) 113.39,61.99 v2(113.57,61.82)
XFP_3V3-R_P12: length 27.6
  BOTTOM w0.381: 111.06,63.44 110.07,63.44 110.07,63.41 v2(109.12,62.46) 103.23,62.46 101.88,61.1 101.88,59.98 101.12,59.22 99.72,59.22 99.03,58.52 99.03,50.71 99.6,50.14 102.23,50.14 CONN54_PF.6L15 ; C675.1 110.73,64.67
XFP_3V3-R_P13: length 11.8
  TOP w0.381: C678.1 127.04,65.12
  S9 w0.254: CONN55_PF.1T15 120.17,56.91 120.17,57.82 121.63,59.28 121.63,61.44 122.84,62.65 125.19,62.65 v1(125.89,63.35)
  BOTTOM w0.381: v1(125.89,63.35) 125.89,62.71 v2(126.08,62.52)
XFP_3V3-R_P14: length 23.9
  BOTTOM w0.305: C677.1 123.85,65.12
  BOTTOM w0.381: C677.1 123.31,64.67 ; CONN55_PF.1L15 118.53,50.14 116.11,50.14 115.28,50.96 115.28,58.17 116.39,59.28 117.71,59.28 118.01,59.59 118.01,61.12 118.77,61.88 121.12,61.88 v2(122.01,62.77) 122.46,62.77 123.16,63.47
XFP_3V3-R_P15: length 9.7
  TOP w0.381: C680.1 135.18,65
  S9 w0.381: v1(133.98,63.19) 135.88,61.29 135.88,59.37 134.46,57.95 134.46,56.95 CONN55_PF.2T15
  BOTTOM w0.127: v2(134.95,62.3) 134.87,62.3 v1(133.98,63.19)
XFP_3V3-R_P16: length 19.5
  BOTTOM w0.381: 131.22,63.4 130.7,63.4 v2(130.14,62.84) 129.09,61.78 129.09,59.87 129.44,59.52 129.44,50.52 129.82,50.14 132.78,50.14 CONN55_PF.2L15
  BOTTOM w0.508: C679.1 132.05,65
XFP_3V3-R_P17: length 9.8
  TOP w0.381: C682.1 153.26,65.12
  S16 w0.381: v1(152.11,63.41) 152.11,63.35 149.83,61.06 149.83,59.15 148.66,57.99 CONN55_PF.3T15
  BOTTOM w0.381: v1(152.11,63.41) 152.85,62.67 v2(152.85,62.48)
XFP_3V3-R_P18: length 21.6
  BOTTOM w0.381: 149.47,64.53 C681.1 150.14,65.13 ; 149.57,63.41 149.51,63.41 v2(148.62,62.52) 146.46,60.36 146.46,60.23 145.63,59.41 145.13,59.41 143.86,58.14 143.86,50.84 144.55,50.14 147.67,50.14 147.86,49.94 CONN55_PF.3L15
XFP_3V3-R_P19: length 9
  TOP w0.381: C684.1 165.7,65.12
  S16 w0.381: CONN55_PF.4T15 162.91,58.08 163.86,59.03 163.86,62.65 v1(164.56,63.35)
  BOTTOM w0.127: v2(164.87,62.27) 164.56,62.58 v1(164.56,63.35)
XFP_3V3-R_P20: length 21.3
  BOTTOM w0.381: CONN55_PF.4L15 161.28,50.14 158.52,50.14 157.95,50.71 157.95,58.01 160.18,60.23 160.18,63.11 ; 160.18,63.11 160.18,63.28 160.81,63.92 162.27,63.92 ; 160.18,63.11 v2(160.13,63.11)
  BOTTOM w0.508: 162.59,65.12 C683.1
XFP_3V3-R_P21: length 9.4
  TOP w0.381: C686.1 178.35,65.12
  S16 w0.381: v1(177.19,63.28) 178.46,62.01 178.46,59.54 177.13,58.2 177.13,56.94 CONN55_PF.5T15
  BOTTOM w0.127: v2(177.72,62.29) 177.72,62.76 v1(177.19,63.28)
XFP_3V3-R_P22: length 19.6
  BOTTOM w0.381: 174.4,63.79 174.02,63.79 v2(173.07,62.84) 171.8,61.57 171.8,59.41 172.28,58.93 172.28,51.18 173.38,50.07 175.54,50.07 176.31,49.3 CONN55_PF.5L15
  BOTTOM w0.508: C685.1 175.29,65.12
XFP_3V3-R_P23: length 9.6
  TOP w0.381: C688.1 190.85,65.12 190.85,65.12
  S12 w0.381: CONN55_PF.6T15 191.41,58.52 190.88,59.06 190.39,59.06 189.64,59.81 189.64,63.15 v1(189.83,63.35)
  BOTTOM w0.381: v2(190.72,62.58) 190.59,62.58 v1(189.83,63.35)
XFP_3V3-R_P24: length 19.4
  BOTTOM w0.381: CONN55_PF.6L15 189.78,50.14 187.35,50.14 186.46,51.03 186.46,56.87 185.89,57.44 185.89,62.14 187.29,63.54 ; 187.25,64.59 C687.1 187.92,65.12 187.93,65.12
  vias: v2(188.5,64.49)
XFP_3V3-T_P01: length 7.9
  TOP w0.508: 30.44,65.12 CB858.1
  S14 w0.508: v1(31.21,63.35) 30.83,62.96 30.83,59.29 CONN54_PF.1T16
  BOTTOM w0.127: v2(30.7,61.89) 31.21,62.4 v1(31.21,63.35)
XFP_3V3-T_P02: length 20.4
  BOTTOM w0.381: CONN54_PF.1L16 32.61,49.57 36.73,53.69 36.73,58.01 37.81,59.09 v2(37.81,59.6) 37.81,61.44 37.18,62.08 35.65,62.08 34.45,63.28
  BOTTOM w0.508: 33.63,65.12 CB859.1
XFP_3V3-T_P03: length 7.8
  TOP w0.508: CB860.1 42.89,65.06
  S14 w0.508: v1(43.48,63.38) 44.54,62.32 44.54,59.79 46.03,58.3 CONN54_PF.2T16
  BOTTOM w0.127: v2(42.81,62.51) 42.83,62.51 43.48,63.16 v1(43.48,63.38)
XFP_3V3-T_P04: length 21.5
  BOTTOM w0.381: CONN54_PF.2L16 46.86,49.54 50.77,53.44 50.77,56.74 51.65,57.63 51.65,60.81 50.77,61.69 48.71,61.69 47.15,63.26
  BOTTOM w0.508: 46.1,65.12 C692.1 46.75,65.1 arc(46.71,64.88) 46.58,64.69
  vias: v2(46.83,63.92)
XFP_3V3-T_P05: length 9.9
  TOP w0.508: CB863.1 55.62,65.13 55.63,65.12
  S9 w0.381: v1(56.29,63.35) 59.27,60.36 59.27,59.34 CONN54_PF.3T16
  BOTTOM w0.254: v1(56.29,63.35) 56.29,62.46 v2(55.15,61.31)
XFP_3V3-T_P06: length 23.9
  BOTTOM w0.381: 59.32,65.58 C694.1 ; C694.1 58.76,65.12 ; C694.1 59.32,64.56 ; v2(59.59,63.47) 59.59,63.35 60.61,62.33 64.54,62.33 65.69,61.19 65.69,57.38 65.12,56.8 65.12,53.63 61.11,49.63 CONN54_PF.3L16
XFP_3V3-T_P07: length 11.6
  TOP w0.508: 67.97,65.13 CB864.1
  S9 w0.508: CONN54_PF.4T16 73.43,59.43 73.43,61.44 72.67,62.2 69.43,62.2 68.86,62.77 v1(68.86,63.28)
  BOTTOM w0.127: v2(68.48,61.5) 68.86,61.88 v1(68.86,63.28)
XFP_3V3-T_P08: length 25.2
  BOTTOM w0.381: CONN54_PF.4L16 75.36,49.59 79.4,53.63 79.4,57.44 79.73,57.76 79.73,60.99 78.96,61.76 74.39,61.76 v2(72.99,63.15) 72.48,63.15 72.04,63.6 ; CB865.1 71.83,64.56 ; CB865.1 71.27,65.12 ; CB865.1 71.83,65.58
XFP_3V3-T_P09: length 13.5
  TOP w0.508: 80.48,65.12 CB866.1 79.92,64.54
  S9 w0.381: CONN54_PF.5T16 88.6,58.3 87.02,59.88 87.02,60.93 86.2,61.76 83.02,61.76 81.44,63.35 v1(81.31,63.35)
  BOTTOM w0.127: v1(81.31,63.35) 81.31,63.28 82.52,62.08 v2(82.52,61.69)
XFP_3V3-T_P10: length 24.7
  BOTTOM w0.381: 84.61,63.28 85.18,62.71 v2(89.5,62.71) 89.88,62.71 91.34,61.25 91.34,59.47 92.17,58.65 92.99,58.65 93.63,58.01 93.63,53.57 89.61,49.55 CONN54_PF.5L16
  BOTTOM w0.508: 83.63,65.13 CB867.1
XFP_3V3-T_P11: length 14.6
  TOP w0.381: 111.42,65.12 CB868.1
  S9 w0.381: v1(112.29,63.33) 112.21,63.41 106.77,63.41 104.8,61.44 104.8,59.92 103.19,58.3 CONN54_PF.6T16
  BOTTOM w0.381: v1(112.29,63.33) 111.29,62.32 v2(111.02,62.32)
XFP_3V3-T_P12: length 22.9
  BOTTOM w0.381: CB869.1 115.16,64.56 ; 115.28,63.35 115.66,62.97 v2(115.66,62.59) 115.66,62.26 113.08,59.68 110.71,59.68 107.86,56.84 107.86,53.71 103.86,49.7 CONN54_PF.6L16
  BOTTOM w0.508: 114.64,65.12 CB869.1
XFP_3V3-T_P13: length 10.2
  TOP w0.381: 124,65.12 CB870.1
  S9 w0.254: CONN55_PF.1T16 120.02,58.3 121.25,59.54 121.25,61.6 122.93,63.28 v1(124.49,63.28)
  BOTTOM w0.381: v1(124.49,63.28) 124.49,62.77 124.09,62.38 v2(124.02,62.38)
XFP_3V3-T_P14: length 19.9
  BOTTOM w0.381: 127.17,65.12 CB871.1 ; CB871.1 127.73,64.56 ; CB871.1 127.73,65.58 ; 127.47,63.22 127.47,62.47 124.23,59.23 124.23,53.75 120.16,49.68 CONN55_PF.1L16
  vias: v2(128.11,63.54)
XFP_3V3-T_P15: length 7.1
  TOP w0.508: CB872.1 132.18,65
  S9 w0.305: CONN55_PF.2T16 133.54,58.3 132.86,58.99 v1(132.86,63.18)
  BOTTOM w0.127: v1(132.86,63.18) 132.38,62.7 v2(132.38,62.3)
XFP_3V3-T_P16: length 20
  BOTTOM w0.381: v2(136.94,62.74) 139.28,60.4 139.28,57.44 138.46,56.61 138.46,55.41 138.84,55.03 138.84,54.14 134.41,49.71 CONN55_PF.2L16
  BOTTOM w0.508: 135.16,65 135.16,65 CB873.1 ; v2(136.94,62.74) 136.5,63.18 136.02,63.18
XFP_3V3-T_P17: length 10.7
  TOP w0.381: CB874.1 150.01,65.13
  S16 w0.381: CONN55_PF.3T16 146.59,59.58 146.59,61.57 147.54,62.52 150.21,62.52 v1(150.97,63.28)
  BOTTOM w0.381: v2(150.62,62.19) 150.97,62.53 v1(150.97,63.28)
XFP_3V3-T_P18: length 18.5
  BOTTOM w0.381: CONN55_PF.3L16 148.66,49.48 152.62,53.44 152.62,56.09 152.71,56.18 152.71,59.31 154.08,60.68 v2(154.08,60.87) 154.08,63.22 153.89,63.41
  BOTTOM w0.508: CB875.1 153.22,65.12
XFP_3V3-T_P19: length 7.9
  TOP w0.381: 162.65,65.12 162.65,65.13 CB876.1
  S16 w0.381: v1(162.65,63.35) 160.81,61.5 160.81,59.6 162.11,58.3 CONN55_PF.4T16
  BOTTOM w0.127: v1(162.65,63.35) 162.81,63.19 v2(162.81,62.5)
XFP_3V3-T_P20: length 19
  BOTTOM w0.381: CONN55_PF.4L16 162.91,49.25 163.1,49.44 163.1,49.95 166.91,53.76 166.91,55.22 166.4,55.73 166.4,56.42 166.97,57 166.97,62.69 arc(166.92,62.94) v2(166.78,63.15)
  BOTTOM w0.508: CB877.1 165.76,65.12 ; v2(166.78,63.15) 166.21,63.73 166.21,63.85
XFP_3V3-T_P21: length 7.8
  TOP w0.381: 175.3,65.12 CB878.1
  S16 w0.381: CONN55_PF.5T16 175.16,59.51 175.16,62.33 v1(176.11,63.28)
  BOTTOM w0.127: v1(176.11,63.28) 175.48,62.65 v2(175.48,62.33)
XFP_3V3-T_P22: length 19.4
  BOTTOM w0.381: CONN55_PF.5L16 177.16,49.54 181.45,53.82 181.45,57.63 180.05,59.03 179.42,59.03 178.59,59.85 178.59,63.41
  BOTTOM w0.508: 178.5,65.12 CB879.1
  vias: v2(179.29,63.47)
XFP_3V3-T_P23: length 7.6
  TOP w0.381: CB880.1 187.92,65.12 187.93,65.12
  S12 w0.381: CONN55_PF.6T16 190.43,58.3 189.13,59.6 189.13,62.65 v1(188.62,63.15)
  BOTTOM w0.381: v1(188.62,63.15) 188.77,63.01 v2(188.77,62.11)
XFP_3V3-T_P24: length 21.3
  BOTTOM w0.381: 192.05,63.47 192.37,63.47 v2(193.07,62.77) 193.32,62.52 194.59,62.52 196.12,61 196.12,54.33 191.41,49.62 CONN55_PF.6L16
  BOTTOM w0.508: 191.68,64.52 CB881.1 191.07,65.12
XFP_3V3_12V_VIN: length 2.9
  TOP w0.381: v1(157.5,108.71) 157.12,109.09 C401.2 157.65,109.68 ; 172.31,109.68 C402.2 172.87,108.99
  vias: v1(158.77,108.71) v1(158.77,107.97) v1(159.66,108.68) v1(159.66,107.95) v1(160.55,108.68) v1(160.55,107.95) v1(160.55,107.08) v1(161.67,108.43) v1(161.67,107.54) v1(166.27,108.96) v1(166.27,107.97) v1(167.41,108.96) v1(167.41,107.97) v1(169.06,108.96) v1(169.06,107.97) v1(170.27,108.94) v1(170.34,108.05) v1(171.29,108.94) v1(171.29,108.05) v1(171.6,107.08) v2(162.96,107.46)
XFP_3V3_F: length 3.5
  BOTTOM w0.381: v2(172.74,100.23) CB712.2
  BOTTOM w0.508: RB215.2 172.11,101.62 CB712.2
XFP_3V3_GND: length 158.5
  TOP w0.254: QB9.S 142.24,234.73 v1(142.24,233.95) ; U48.7 151.4,95.41 v1(151.53,95.28)
  TOP w0.381: R770.1 145.24,97.05 145.72,96.57 v1(145.95,96.57) ; v1(145.08,93.7) R796.2 ; v1(148.61,92.48) R793.2
  TOP w0.508: QB8.S 142.16,227.28 141.35,227.28 v1(141.19,227.12)
  S12 w0.254: v1(141,149.07) 141.41,149.07 145.25,152.91 145.25,156.37 146.17,157.29 147.41,157.29 153.55,163.44 153.55,167.3 149.95,170.91 149.95,172.01 148.98,172.98 148.26,172.98 147.9,173.34 147.9,181.09 147.77,181.22 147.77,183.19 148.35,183.77 149.4,183.77 149.76,184.13 149.76,186.62 149.07,187.31 149.07,190.97 142.25,197.79 142.25,201.08 142.14,201.19 142.14,220.85 141.17,221.82 141.17,227.12 v1(141.19,227.12) 142.24,228.17 v1(142.24,233.95)
  S14 w0.254: v1(141,149.07) 141.44,148.63 141.44,145.64 138.56,142.76 138.56,120.58 145.13,114.02 145.13,103.22 v1(144.06,102.16)
  BOTTOM w0.508: v1(145.08,93.7) 144.68,94.09 v2(144.68,94.88)
  vias: v1(144.12,101.45) v1(148.56,91.79) v1(148.61,90.98)
XFP_3V3_MARGIN_HIGH: length 27.5
  TOP w0.127: v1(116.79,229.43) 116.79,229.44 115.3,229.44 P1.AA21 ; v1(137.38,234.41) 137.38,234.92 137.57,235.12 R345.2
  S16 w0.127: v1(116.79,229.43) 117.92,230.57 120.56,230.57 121.49,231.49 124.68,231.49 126.38,233.2 136.16,233.2 v1(137.38,234.41)
  BOTTOM w0.127: v2(136.24,234.03) 137,234.03 v1(137.38,234.41)
XFP_3V3_MARGIN_HIGH_D: length 157.9
  TOP w0.127: QB9.D 144.58,234.61 v1(144.73,234.46) ; R787.2 v1(141.94,97.95)
  S12 w0.127: v1(144.73,234.46) 144.08,233.82 144.08,230.73 144.22,230.59 144.22,221.95 143.95,221.67 143.95,200.16 153.29,190.82 153.29,186.25 157.19,182.34 157.19,172.88 156.62,172.31 156.62,163.43 149.95,156.76 149.95,156.05 148.22,154.32 148.22,152.07 146.14,149.98 144.2,149.98 v1(140.81,146.59)
  S14 w0.127: v1(140.81,146.59) 137.89,143.68 137.89,120.46 143.98,114.37 143.98,105.14 141.94,103.1 v1(141.94,97.95)
  BOTTOM w0.127: v1(144.73,234.46) 145.42,234.46 145.43,234.47 v2(145.61,234.47)
XFP_3V3_MARGIN_HIGH_R: length 6.8
  TOP w0.127: v1(137.1,236.02) R345.1 138.17,236 R378.1 139.21,236.03 C195.2 141.14,236.76 QB9.G
  BOTTOM w0.127: v1(137.1,236.02) 137.19,236.11 v2(137.19,237.21)
XFP_3V3_MARGIN_LOW: length 28.7
  TOP w0.127: R376.2 v1(137.31,228.5) ; P1.AA18 115.29,227.46 116.17,227.46 116.67,226.95 118.87,226.95 118.96,227.05 v1(118.96,227.06)
  S16 w0.127: v1(118.96,227.06) 118.96,227.48 119.48,228 123.35,228 127.5,232.15 133.65,232.15 v1(137.31,228.5)
  BOTTOM w0.127: v2(138.01,229.21) v1(137.31,228.5)
XFP_3V3_MARGIN_LOW_D: length 153.6
  TOP w0.127: v1(143.54,227.63) 144.4,227.63 144.58,227.81 QB8.D ; v1(141.44,95.91) R789.2
  S12 w0.127: v1(143.54,227.63) 143.84,227.33 143.84,222.68 143.69,222.53 143.69,199.32 151.57,191.44 151.57,186.19 155.1,182.66 155.1,182.01 155.92,181.19 155.92,178.03 155.67,177.77 155.67,176.06 156.62,175.11 156.62,173.14 155.92,172.44 155.92,169.66 156.21,169.38 156.21,167.73 155.92,167.44 155.92,163.94 146.68,154.69 146.68,152.68 145.04,151.05 144.37,151.05 v1(140.81,147.48)
  S14 w0.127: v1(141.44,95.91) 141.44,103.65 143.58,105.79 143.58,114.22 137.56,120.23 137.56,144.24 v1(140.81,147.48)
  BOTTOM w0.127: v2(144.94,228.45) 144.13,227.63 v1(143.54,227.63)
XFP_3V3_MARGIN_LOW_R: length 6.8
  TOP w0.127: R376.1 R377.1 139.22,229.47 C201.2 142.3,229.47 QB8.G 143.54,229.4 v1(143.54,229.4)
  BOTTOM w0.127: v1(143.54,229.4) 143.22,229.08 v2(142.33,229.08)
XFP_3V3_MON: length 14
  TOP w0.127: R108.1 240.23,216.99 240.88,217.65 v1(244.12,217.65)
  TOP w0.254: U7.56 235.91,219.24 236.94,218.21 236.94,218.08 237.74,217.28 C68.1 237.74,216.59 237.96,216.37 239.23,216.37 239.81,216.95 R108.1 240.23,215.5 R109.2
  BOTTOM w0.127: v1(244.12,217.65) 244.31,217.84 v2(245.52,217.84)
XFP_3V3_P01_02: length 4
  TOP w0.381: v1(35.36,69.92) 35.33,69.9 CB799.1 34.82,69.19 ; 29.37,69.32 C545.1
  TOP w0.508: C545.1 28.85,70.02 v1(28.88,70.05)
  BOTTOM w0.508: CB799.1 35.33,69.9 v1(35.36,69.92) ; v1(28.88,70.05) 28.85,70.02 C545.1
  vias: v1(35.36,71.57) v1(35.36,70.75) v2(33.75,72.62)
XFP_3V3_P03_04: length 4.1
  TOP w0.508: v1(47.87,69.92) 47.84,69.9 C570.1 ; v1(41.39,70.05) 41.36,70.02 CB828.1
  BOTTOM w0.508: CB828.1 41.36,70.02 v1(41.39,70.05) ; v1(47.87,69.92) 47.84,69.9 C570.1 ; v1(47.87,71.57) 47.78,71.66 v2(47.78,72.68)
  vias: v1(47.87,70.75)
XFP_3V3_P05_06: length 2.9
  TOP w0.508: v1(53.96,70.05) 53.94,70.02 C547.1 ; v1(60.44,69.92) 60.41,69.9 CB801.1
  BOTTOM w0.508: v1(60.44,69.92) 60.41,69.9 CB801.1 ; v1(53.96,70.05) 53.94,70.02 C547.1
  vias: v1(59.96,70.81) v1(60.77,70.99) v2(59.15,71.72)
XFP_3V3_P07_08: length 2.9
  TOP w0.508: C551.1 66.45,70.02 v1(66.47,70.05) ; v1(72.95,69.92) 72.92,69.9 CB807.1
  BOTTOM w0.508: C551.1 66.45,70.02 v1(66.47,70.05) ; CB807.1 72.92,69.9 v1(72.95,69.92)
  vias: v1(72.96,72.54) v1(72.99,71.76) v2(71.4,72.55)
XFP_3V3_P09_10: length 3.5
  TOP w0.254: v1(85.37,69.82) 85.44,69.76 CB809.1 85.11,69.13 84.93,69.31
  TOP w0.381: v1(78.98,70.05) 78.95,70.02 C553.1
  BOTTOM w0.381: v1(85.37,69.82) 85.44,69.76 CB809.1
  BOTTOM w0.508: C553.1 78.95,70.02 v1(78.98,70.05)
  vias: v1(85.06,71.22) v1(85.06,70.52) v2(84.1,72.62)
XFP_3V3_P11_12: length 3.6
  TOP w0.381: v1(116.27,69.92) 116.25,69.9 C555.1 115.96,69.19 115.74,69.42
  TOP w0.508: C554.1 109.77,70.02 v1(109.8,70.05)
  BOTTOM w0.381: v1(116.27,69.92) 116.25,69.9 C555.1
  BOTTOM w0.508: C554.1 109.77,70.02 v1(109.8,70.05)
  vias: v1(116.27,71.57) v1(116.27,70.75) v2(115.28,72.62)
XFP_3V3_P13_14: length 4.6
  TOP w0.381: CB813.1 122.65,69.32 122.9,69.57 ; 128.35,69.19 CB812.1
  TOP w0.508: v1(122.37,70.05) 122.35,70.02 CB813.1 ; CB812.1 128.82,70.16
  BOTTOM w0.508: v1(122.37,70.05) 122.35,70.02 CB813.1 ; v1(128.87,70.2) 128.82,70.16 CB812.1
  vias: v1(128.16,70.86) v1(128.87,70.9) v2(127.98,72.74)
XFP_3V3_P15_16: length 2.9
  TOP w0.508: C559.1 130.48,69.9 v1(130.51,69.93) ; v1(136.99,69.8) 136.96,69.77 CB815.1
  BOTTOM w0.508: CB815.1 136.96,69.77 v1(136.99,69.8) ; C559.1 130.48,69.9 v1(130.51,69.93)
  vias: v1(136.26,70.74) v1(137,70.52) v2(136.05,72.62)
XFP_3V3_P17_18: length 2.9
  TOP w0.508: C560.1 148.51,70.02 v1(148.53,70.05) ; CB816.1 154.98,69.9 v1(155.01,69.92)
  BOTTOM w0.508: v1(148.53,70.05) 148.51,70.02 C560.1 ; CB816.1 154.98,69.9 v1(155.01,69.92)
  vias: v1(154.97,72.81) v1(154.97,72.11) v2(153.64,72.68)
XFP_3V3_P19_20: length 4.2
  TOP w0.254: 161.64,69.5 161.45,69.32 CB818.1 161.02,70.02 v1(161.04,70.05) ; 166.97,69.38 167.15,69.19 C563.1 167.49,69.9 v1(167.52,69.92)
  BOTTOM w0.508: C563.1 167.49,69.9 v1(167.52,69.92) ; v1(161.04,70.05) 161.02,70.02 CB818.1
  vias: v1(167.48,72.74) v1(167.48,72.04) v2(166.21,72.87)
XFP_3V3_P21_22: length 4.7
  TOP w0.254: 179.66,69.19 CB796.1 180.13,69.9 v1(180.16,69.92) ; 173.65,70.02 v1(173.68,70.05)
  TOP w0.508: 174.28,69.32 C564.1 173.65,70.02
  BOTTOM w0.254: v1(173.68,70.05) 173.65,70.02 C564.1 174.09,69.32 174.27,69.5
  BOTTOM w0.508: v1(180.16,69.92) 180.13,69.9 CB796.1
  vias: v1(180.16,71.57) v1(180.16,70.75) v2(178.91,72.55)
XFP_3V3_P23_24: length 5.1
  TOP w0.254: 192.3,69.19 CB822.1 ; v1(186.82,70.52) 186.79,70.52 186.3,70.02 186.29,70.02 CB821.1 186.73,69.32 186.91,69.5
  TOP w0.381: CB822.1 192.77,69.76
  BOTTOM w0.254: CB822.1 192.55,69.19 192.18,69.57
  BOTTOM w0.381: CB822.1 192.77,69.81
  BOTTOM w0.508: CB821.1 186.29,69.9
  vias: v1(191.61,70.97) v1(192.37,70.97) v1(192.37,70.27) v2(190.59,72.68)
XFP_3V3_PCH_DRVH: length 26.4
  TOP w0.254: v1(152.3,99.97) 151.9,99.58 U48.13
  TOP w0.508: D4.C 164.15,106.96 164.61,106.49 v1(164.61,106.12) R719.2 ; v1(152.49,104.75) 152.87,105.12 D5.C 152.87,106.96 R713.2
  S7 w0.508: v1(164.61,106.12) 164.59,106.14 162.96,104.52 162.96,103.76 162.3,103.1 156.43,103.1 154.78,104.75 v1(152.49,104.75) 152.37,104.62 152.37,100.04 v1(152.3,99.97)
  BOTTOM w0.127: v2(152.49,100.98) 152.3,100.78 v1(152.3,99.97)
XFP_3V3_PCH_DRVH_A_R: length 5.5
  TOP w0.381: U42.1 v1(167.54,107.06)
  TOP w0.508: R719.1 166.4,105.57 D4.A 166.5,107.06 v1(167.54,107.06)
  BOTTOM w0.127: v1(167.54,107.06) 167.54,106.45 v2(167.15,106.07)
XFP_3V3_PCH_DRVH_B_R: length 5.3
  TOP w0.381: v1(156.49,107.06) U41.1
  TOP w0.508: D5.A 154.9,106.16 R713.1 155.78,107.47 156.19,107.06 v1(156.49,107.06)
  BOTTOM w0.127: v2(155.62,107.06) v1(156.49,107.06)
XFP_3V3_PCH_DRVL: length 19.1
  TOP w0.254: v1(153.56,97.94) U48.11
  TOP w0.508: v1(163.62,104.21) 164.06,103.78 R728.2 ; R731.2 v1(155.72,102.26)
  S7 w0.508: v1(163.62,104.21) 163.62,103.31 162.58,102.26 v1(155.72,102.26) 154.14,100.68 154.14,99.74 153.25,98.85 153.25,98.24 v1(153.56,97.94)
  BOTTOM w0.127: v1(153.56,97.94) 154.32,97.94 v2(154.81,97.44)
XFP_3V3_PCH_DRVL_A_R: length 4.4
  TOP w0.381: v1(167.28,104.54) 167.8,104.02 U42.4
  TOP w0.508: R728.1 166.52,103.78 v1(167.28,104.54)
  BOTTOM w0.127: v2(166.27,104.38) 166.43,104.54 v1(167.28,104.54)
XFP_3V3_PCH_DRVL_B_R: length 4.9
  TOP w0.127: R731.1 v1(153.67,103.78)
  TOP w0.381: U41.4 156.6,104.02 156.36,103.78
  TOP w0.508: R731.1 156.36,103.78
  BOTTOM w0.127: v1(153.67,103.78) v2(153.67,104.8)
XFP_3V3_PCH_EN_R: length 10
  TOP w0.254: U48.2 149.07,97.94 v1(148.59,98.42) 148.08,98.93 147.11,98.93 147.02,99.01 147.02,99.68 146.75,99.96 C449.1 146.75,100.36 R753.2 145.77,99.81 145.68,99.72 143.56,99.72 arc(143.36,99.68) R767.1
  BOTTOM w0.127: v1(148.59,98.42) 149.46,98.42 v2(149.72,98.68)
XFP_3V3_PCH_MODE: length 4.4
  TOP w0.254: R793.1 R794.2 v1(149.63,94.89) 150.4,95.67 U48.5
  BOTTOM w0.127: v2(148.87,94.51) 149.25,94.89 v1(149.63,94.89)
XFP_3V3_PCH_RF: length 6.7
  TOP w0.254: U48.4 148.88,96.94 v1(148.42,96.48) 148.08,96.14 148.08,93.6 R796.1
  BOTTOM w0.254: v1(148.42,96.48) 149.35,96.48 v2(149.57,96.69)
XFP_3V3_PCH_TRIP: length 7.5
  TOP w0.254: U48.1 149.41,98.44 148.99,98.85 v1(148.99,98.98) 148.99,99.6 148.52,100.07 148.52,101.54 148.18,101.88 R741.1
  BOTTOM w0.254: v1(148.99,98.98) 148.99,99.86 148.63,100.23 v2(147.6,100.23)
XFP_3V3_PCH_VBST: length 6
  TOP w0.254: R752.2 153.57,99.72 v1(153.31,99.97) 152.68,100.61 152.04,100.61 151.4,99.97 U48.14
  BOTTOM w0.127: v2(153.03,99.11) 153.31,99.39 v1(153.31,99.97)
XFP_3V3_PCH_VBST_R: length 3.6
  TOP w0.254: C455.1 156.99,98.19 157.38,98.57 v1(157.38,99.21) 156.87,99.72 R752.1
  BOTTOM w0.127: v2(157.38,98.42) v1(157.38,99.21)
XFP_3V3_PCH_VFB: length 7.7
  TOP w0.254: R768.2 146.83,97.48 146.78,97.43 R770.2 ; R768.2 148.56,97.48 v1(148.61,97.44) U48.3 ; R768.2 147.6,97.05 147.54,97 C462.2 R788.2 R790.2
  BOTTOM w0.127: v2(147.72,97.18) 147.98,97.44 v1(148.61,97.44)
XFP_3V3_PCH_VFB_H: length 3.9
  TOP w0.127: R788.1 v1(145.95,95.4) 145.15,95.4 144.76,95.78 C771.1
  BOTTOM w0.127: v1(145.95,95.4) 146.45,95.4 v2(146.96,94.89)
XFP_3V3_PCH_VFB_H_R: length 3.2
  TOP w0.127: C771.2 R787.1 v1(141.94,97.04)
  BOTTOM w0.127: v2(142.59,96.09) 142.59,96.4 v1(141.94,97.04)
XFP_3V3_PCH_VFB_L: length 4.1
  TOP w0.127: R790.1 v1(145.95,94.38) 145.88,94.32 C772.1
  BOTTOM w0.508: v1(145.95,94.38) 146.52,93.81 v2(146.52,93.04)
XFP_3V3_PCH_VFB_L_R: length 3.8
  TOP w0.127: C772.2 141.92,94.32 141.91,94.31 R789.1 141.44,93.22 v1(141.49,93.16)
  BOTTOM w0.127: v1(141.49,93.16) 141.72,93.16 v2(142.53,93.97)
XFP_3V3_PCH_VFB_S: length 4.5
  TOP w0.254: R768.1 147.47,98.27 146.96,98.27 v1(146.91,98.32)
  TOP w0.508: R759.2 146.6,98.64 v1(146.91,98.32)
  BOTTOM w0.381: CB790.2 146.49,98.74 v1(146.91,98.32)
  BOTTOM w0.508: v2(145.89,97.69) 146.28,97.69 v1(146.91,98.32)
XFP_3V3_PCH_VREG_VDRV: length 5.5
  TOP w0.254: R774.1 156.49,97.05 156.16,97.38 v1(155.72,97.38) 153.24,97.38 153.18,97.44 U48.10
  BOTTOM w0.127: v1(155.72,97.38) 155.88,97.38 v2(156.56,96.7)
XFP_3V3_PCL_SW: length 19.6
  TOP w0.254: v1(154.07,98.56) 153.43,98.56 153.3,98.44 U48.12
  TOP w0.508: C455.2 154.44,98.19 v1(154.07,98.56)
  S14 w0.508: v1(154.07,98.56) 154.49,98.14 v1(158.46,98.14)
  BOTTOM w0.254: RB235.2 147.2,101.71 153.83,101.71 v2(154.67,100.86)
  BOTTOM w0.305: v2(154.67,100.86) 154.67,99.16 v1(154.07,98.56)
  BOTTOM w0.508: v1(169.06,101.5) RB215.1
XFP_3V3_PG: length 24.9
  TOP w0.127: U48.16 150.4,99.58 150.34,99.64 R742.1 151.28,101.11 v1(151.53,100.86) ; v1(149.63,92.48) R794.1
  S7 w0.127: v1(151.53,100.86) 151.53,100.11 150.13,98.7 150.13,92.98 v1(149.63,92.48)
  S14 w0.127: CONN47.1 151.53,109.47 v1(151.53,100.86)
  BOTTOM w0.127: v2(150.3,92.89) 149.89,92.48 v1(149.63,92.48)
XFP_3V3_REG: length 11.1
  TOP w0.254: v1(149.5,100.3) 149.43,100.38 R742.2 ; U48.9 153.81,96.94 v1(154.07,96.67) R774.2 C476.2
  BOTTOM w0.254: v1(149.5,100.3) v2(150.71,100.3) 150.71,99.96 154,96.67 v1(154.07,96.67)
XFP_3V3_TAP: length 8.3
  TOP w0.254: v1(145.18,96.16) 145.31,96.03 146.25,96.03 C462.1
  BOTTOM w0.127: v2(145.7,102.4) 145.7,101.11 RB235.1
  BOTTOM w0.381: RB235.1 144.96,100.38 CB790.1 145.14,99.37 145.14,96.2 v1(145.18,96.16)
XFP_3V3_VDD: length 5.5
  TOP w0.254: 150.9,95.32 U48.6
  TOP w0.381: R797.2 C479.1 150.9,94.13 v1(150.9,94.89) 150.9,95.32
  BOTTOM w0.381: v1(150.9,94.89) 150.9,94.69 151.3,94.29 v2(151.63,94.29)
XO_30773: length 8.5
  TOP w0.127: U77.77 155.17,172.23 155.37,172.02 155.37,170.52 154.84,169.98 RB1272.2 152.23,169.98 151.91,170.3 151.91,171.93 151.67,172.18 U77.70
ZL30773_AD0: length 121.8
  TOP w0.127: U77.19 157.83,182.42 158.87,183.46 158.87,183.84 159.41,184.38 R1423.1 160.62,184.39 160.62,184.69 160.94,185.01 161.76,185.01 161.83,184.95 v1(163.1,184.95) R1422.2 ; v1(252.04,201.22) 252.06,201.23 RB1298.2
  S9 w0.127: v1(252.04,201.22) 252.04,199.67 244.58,192.2 244.58,185.95 234.5,175.87 191.31,175.87 189.08,173.63 181.39,173.63 170.08,184.95 v1(163.1,184.95)
  BOTTOM w0.127: v1(163.1,184.95) 163.15,185 164.04,185 v2(164.37,185.33)
ZL30773_AD1: length 124.8
  TOP w0.127: U77.17 158.17,181.42 160.11,183.36 R1421.1 160.61,183.79 160.68,183.87 163.79,183.87 R1420.2 163.98,183.8 163.98,183.52 v1(164.34,183.16) ; v1(254.11,204.27) 254.12,204.28 RB1296.2
  S9 w0.127: v1(164.34,183.16) 165.3,184.12 170.08,184.12 181.08,173.13 189.25,173.13 191.38,175.26 235.12,175.26 245.36,185.5 245.36,191.63 252.73,199 252.73,202.89 v1(254.11,204.27)
  BOTTOM w0.127: v2(166.02,183.68) 164.86,183.68 v1(164.34,183.16)
ZL30773_RST: length 93.5
  TOP w0.127: P1.W6 v4(113.29,214.46) ; v1(149.51,182.66) 149.19,182.66 148.67,183.18 U77.37 ; U77.75 154.17,171.54 v1(154.76,170.95)
  S7 w0.127: v1(150.09,191.81) 151.28,191.81 153.1,190 153.1,187.65 154.97,185.77 154.97,184.44 152.43,181.9 150.27,181.9 v1(149.51,182.66)
  S14 w0.127: v1(149.51,182.66) 150.33,181.84 154.59,181.84 155.16,181.26 155.16,173.92 154.95,173.71 154.95,172.92 154.24,172.2 154.24,171.47 v1(154.76,170.95) ; v4(113.29,214.46) 113.29,214.18 113.69,213.78 113.69,212.05 114.77,210.97 114.77,208.44 116.81,206.41 116.81,203.8 117.02,203.58 117.02,201.81 120.82,198.02 143.8,198.02 150.01,191.81 v1(150.09,191.81)
  BOTTOM w0.127: R1368.2 154.87,170.95 v1(154.76,170.95) ; v2(152.3,190.85) 151.41,191.74 150.16,191.74 v1(150.09,191.81)
N38023365: length 11.4
  TOP w0.254: v1(107.34,95.98) 108.74,94.59 R792.1
  BOTTOM w0.254: v2(106.52,96.63) 106.55,96.63 107.2,95.98 v1(107.34,95.98) 107.34,95.48 108.04,94.78 110.21,94.78 110.31,94.68 110.99,94.68 111.26,94.41 R1499.2 111.93,94.05 112.41,94.53 112.68,94.53 CB686.1
N59764650: length 4
  TOP w0.127: LED33.A 192.6,238.23 v1(192.6,236.69) R1079.2
  BOTTOM w0.127: v2(193.2,238.16) 193.2,237.28 v1(192.6,236.69)
N61042419: length 4.5
  TOP w0.127: J2.A27 156.94,140.75 v1(157.57,141.39)
  BOTTOM w0.127: v2(157.45,140.56) 157.45,141.26 v1(157.57,141.39) 157.7,141.26 R1286.2
N61194510: length 3.8
  TOP w0.127: J2.B66 v1(176.44,144.02)
  BOTTOM w0.127: v1(176.44,144.02) 176.62,144.21 R1287.1 176.57,145.13 v2(175.23,145.13)
N61194531: length 4.6
  TOP w0.127: v1(177.5,144.07) 177.11,144.07 176.94,144.25 J2.B67
  BOTTOM w0.127: R1288.1 177.64,144.21 v1(177.5,144.07) 179.01,144.07 v2(179.23,143.86)
N61194554: length 7
  TOP w0.127: J2.A103 194.94,140.83 v1(194.91,140.86)
  BOTTOM w0.127: R1289.1 195.33,139.82 195.55,139.61 195.55,136.88 v2(194.59,135.93)
  BOTTOM w0.254: v1(194.91,140.86) 194.86,140.81 R1289.1
N61194568: length 3.5
  TOP w0.127: v1(194.86,146.56) 194.94,146.48 J2.B103
  BOTTOM w0.127: v2(193.89,146.97) 194.44,146.97 v1(194.86,146.56) R1290.1
N61195399: length 165.6
  TOP w0.127: v1(167.1,138.66) 166.94,138.81 J2.A47
  TOP w0.508: J5.2 v1(217.53,251.98)
  S9 w0.127: v1(220.37,213.97) 221.01,213.33 225.39,213.33 227.3,215.24 230.28,215.24 230.66,215.62 230.66,216 230.03,216.63 229.33,216.63 228.69,217.27 228.69,221.59 230.15,223.05 230.15,223.62 230.85,224.32 230.85,228.51 229.58,229.78 229.58,230.73 222.96,237.35 222.96,242.85 217.53,248.29 v1(217.53,251.98)
  S12 w0.127: v1(167.1,138.66) 167.86,138.66 168.82,139.62 168.84,139.62 168.85,139.63 175.15,139.63 176.11,140.59 176.13,140.57 179.13,140.57 182.11,143.55 183.82,143.55 185.56,145.29 186.5,145.29 190.78,149.58 190.78,153.01 202.02,164.25 202.02,165.71 211.36,175.04 211.36,200.12 220.88,209.65 220.88,213.46 v1(220.37,213.97)
  BOTTOM w0.127: v2(219.1,214.22) 219.36,213.97 v1(220.37,213.97)
N61195405: length 2.2
  TOP w0.508: v1(212.69,246.77) R1295.1
  BOTTOM w0.254: v2(213.58,246.86) 213.49,246.77 v1(212.69,246.77)
N61195407: length 3.4
  TOP w0.254: v2(214.9,248.29) v1(215.83,248.29)
  TOP w0.508: R1295.2 214.9,246.77 v2(214.9,248.29)
  BOTTOM w0.254: v2(214.9,248.29) v1(215.83,248.29)
N61232717: length 4.7
  TOP w0.127: v1(154.97,259.18) 155.04,259.25 LEDB12.C 156.05,259.24 R1294.1
  BOTTOM w0.127: v2(156.37,259.24) 156.3,259.18 v1(154.97,259.18)
N61232745: length 3.6
  TOP w0.127: R1294.2 156.06,256.18 v1(157.38,256.18) D10.A
  BOTTOM w0.127: v2(158.52,256.19) 158.51,256.18 v1(157.38,256.18)
N61307888: length 7.3
  BOTTOM w0.508: R1298.1 260.95,65.25 v1(260.19,64.49) ; v1(264.06,64.55) 264.79,65.28 R1297.1 ; R1299.1 v1(257.14,64.62) ; v2(254.92,64.04) 254.28,64.04 v1(253.65,64.68) 253.33,65 R1300.1 ; C863.2 250.8,64.99 v1(251.55,64.23)
  vias: v1(254.37,15.57) v1(255.52,14.91) v1(256.88,16.31) v1(259.6,16.18) v1(260.6,14.58) v1(261.83,16.25) v1(263.19,14.53) v3(250.69,67.38) v3(252.01,67.38) v3(254.37,66.34) v3(255.94,66.34) v3(258.22,66.47) v3(259.79,66.47) v3(262.12,66.34) v3(263.69,66.34)
N61309659: length 5.4
  TOP w0.508: C860.1 R1335.1 264.7,85.63 v1(264.68,85.62) 264.74,85.57 U70.1
  BOTTOM w0.508: v1(264.68,85.62) 264.7,85.61 v2(264.7,84.49)
N61309684: length 5.3
  TOP w0.508: U70.4 v1(260.93,85.77) 260.95,85.8 R1336.1 C898.1
  BOTTOM w0.508: v1(260.93,85.77) 260.95,85.75 v2(260.95,84.74)
N61309711: length 5.7
  TOP w0.508: U70.7 257.12,85.52 v1(257.09,85.54)
  BOTTOM w0.254: v1(257.09,85.54) C899.1 257.08,84.8
  BOTTOM w0.508: R1337.1 257.08,85.53 v1(257.09,85.54) 257.46,85.91 v2(257.46,86.84)
N61309740: length 5
  TOP w0.508: U70.10 v1(253.31,85.55)
  BOTTOM w0.254: 253.34,84.8 C900.1
  BOTTOM w0.508: v2(254.73,85.7) 253.45,85.7 v1(253.31,85.55) 253.35,85.51 C900.1 ; R1338.1 253.34,84.8
N61354121: length 5.1
  TOP w0.127: J2.C54 170.44,153.24 170.46,153.26 v1(170.46,153.39)
  BOTTOM w0.127: R1301.2 171.17,154.13 171.16,154.13 R1304.1 170.58,153.51 v1(170.46,153.39) 170.4,153.32 v2(170.4,151.74)
N61354124: length 4.9
  TOP w0.127: v1(172.11,152.88) 171.94,152.71 J2.C57
  BOTTOM w0.127: v2(172.43,151.74) 172.43,152.56 v1(172.11,152.88) 172.58,153.35 R1302.2 R1305.1
N61354127: length 4.4
  TOP w0.127: J2.D57 v1(171.94,158.29)
  BOTTOM w0.127: R1303.2 R1306.1 171.93,158.3 v1(171.94,158.29) 171.61,157.96 v2(171.61,157.07)
N61392787: length 4.8
  TOP w0.127: v1(193.96,141.25) 193.94,141.23 J2.A101
  BOTTOM w0.127: v2(192.36,141.87) 193.34,141.87 v1(193.96,141.25) 193.96,140.59 193.84,140.47 R1310.2
N61788405: length 7.8
  TOP w0.254: U71.4 230.45,186.06 231.5,185.01 231.5,184.19 C872.1
  TOP w0.508: C872.1 231.52,184.17 C873.1 v1(232.5,184.95)
  BOTTOM w0.127: v2(231.23,185.9) 231.55,185.9 v1(232.5,184.95)
  BOTTOM w0.508: v1(232.5,184.95) 232.54,184.91 L102.2
N61788410: length 7.6
  TOP w0.254: U71.9 232.95,186.26 234.27,184.93 v1(234.36,184.93) 234.5,184.79 C871.1 C874.1
  BOTTOM w0.127: L101.2 234.6,183.87 v2(236.5,183.87)
  BOTTOM w0.254: L101.2 234.56,184.73 v1(234.36,184.93)
N61789248: length 5.8
  TOP w0.254: U71.6 231.45,185.9 231.77,185.58 232.82,185.58 v1(233.45,184.95) 233.52,184.88 R1318.2
  BOTTOM w0.127: v1(233.45,184.95) 233.52,185.01 v2(233.52,186.34)
N61795259: length 9.4
  TOP w0.127: U71.2 229.45,185.88 229.02,185.45 227.23,185.45 226.51,184.72 C880.2 226.52,184.21 226.52,181.14 226.78,180.88 OSC6.1
N61795286: length 4.8
  TOP w0.127: OSC6.3 229.57,182.67 C884.2 229.57,185.13 229.95,185.5 U71.3
N61867245: length 5.1
  TOP w0.127: U72.6 226.35,168.49 v1(226.57,168.27)
  BOTTOM w0.127: v1(226.57,168.27) 226.09,168.75 v2(226.09,169.71)
  BOTTOM w0.254: R1320.2 R1322.2 226.55,168.24 v1(226.57,168.27)
N61867605: length 6.8
  TOP w0.127: J2.A50 168.44,140.44 169.28,141.28 v1(169.28,142.23)
  BOTTOM w0.127: v2(170.02,141.39) 170.02,141.49 v1(169.28,142.23) 168.24,143.27 167.88,143.27 R1311.2
N61867630: length 6.2
  TOP w0.127: v1(144.03,146.94) 144.94,146.03 J2.B3
  BOTTOM w0.127: v2(142.85,149.62) 143.09,149.86 R1312.2 144.03,149.74 v1(144.03,146.94)
N61867639: length 4.9
  TOP w0.127: v1(144.95,146.94) 145.44,146.45 J2.B4
  BOTTOM w0.127: v1(144.95,146.94) 144.95,148.08 v2(144.95,148.08) 144.95,148.09 144.95,149.84 R1313.2
N61867648: length 5.5
  TOP w0.127: v1(145.99,146.96) 145.94,146.91 J2.B5
  BOTTOM w0.127: v2(145.81,146.19) 145.99,146.37 v1(145.99,146.96) 145.96,146.99 145.96,149.84 R1314.2
N61867660: length 5
  TOP w0.127: J2.B6 146.44,146.45 v1(146.96,146.96)
  BOTTOM w0.127: R1315.2 146.94,148.85 v2(146.76,148.67) 146.96,148.48 v1(146.96,146.96)
N61867672: length 5.9
  TOP w0.127: J2.B7 146.94,145.88 147.97,146.91 v1(147.97,146.96)
  BOTTOM w0.127: R1316.2 147.97,149.84 v1(147.97,146.96) 147.97,146.36 147.82,146.21 147.82,146.19 v2(147.81,146.19)
N61867684: length 5
  TOP w0.127: J2.B10 148.44,146.34 v1(149.04,146.94)
  BOTTOM w0.127: R1317.2 149.06,149.77 149.06,146.96 v1(149.04,146.94)
N61983825: length 5.3
  BOTTOM w0.508: v1(222.66,76.93) 222.84,76.75 R1334.1 ; R1331.1 234.92,74.45 C897.2 v1(234.09,74.39) 233.14,74.39 v2(233.01,74.53) ; R1333.1 226.52,76.82 v1(226.41,76.93) ; R1332.1 v1(230.14,76.86)
  vias: v1(226.24,15.73) v1(227.94,15.7) v1(230.09,14.58) v1(231.79,16.13) v1(232.56,14.6) v1(233.75,16.11) v1(235.16,14.5) v1(236.34,16.55) v3(223.89,74.35) v3(225.46,74.35) v3(226.56,74.35) v3(228.13,74.35) v3(229.22,74.22) v3(230.8,74.22) v3(232.27,76) v3(233.85,76)
N62133379: length 15.2
  TOP w0.127: P1.T2 110.29,210.46 110.29,208.91 112.61,206.59 115.64,206.59 116.21,206.02 v1(116.21,205.71) 116.49,205.43 R1366.1
  BOTTOM w0.127: v2(116.55,201.58) 115.95,202.18 115.95,203.46 116.21,203.72 v1(116.21,205.71)
N62133382: length 10.7
  TOP w0.127: R1367.1 v1(115.47,206.03) 115.28,206.22 112.55,206.22 109.79,208.98 P1.T1
  BOTTOM w0.127: v2(115.41,204.51) 115.54,204.63 115.54,205.97 v1(115.47,206.03)
N62133385: length 6.4
  TOP w0.127: P1.M1 105.79,206.38 v1(106.33,205.84) v2(106.33,204.83)
  BOTTOM w0.127: v2(106.33,204.83) v1(106.33,205.84)
N62133388: length 11.1
  TOP w0.127: P1.M2 106.29,210.46 106.29,207.08 107.48,205.89 v1(107.48,205.6) 107.34,205.47 R1364.1
  BOTTOM w0.127: v2(107.03,201.78) 106.84,201.97 106.84,203.58 107.48,204.22 v1(107.48,205.6)
N62133391: length 8.2
  TOP w0.127: P1.H1 101.79,209.62 100.61,208.44 100.61,206.35 v1(101.18,205.78) 101.21,205.75 R1363.1
  BOTTOM w0.127: v2(99.22,206.79) 100.17,206.79 v1(101.18,205.78)
N62133394: length 8.4
  TOP w0.127: P1.H2 101.27,210.45 101.27,209.55 100.19,208.47 v1(100.19,205.69) R1362.1
  BOTTOM w0.127: v1(100.19,205.69) 99.72,205.22 v2(99.72,204.25)
N62133772: length 10.1
  TOP w0.127: RB1252.2 120.11,206.41 v1(119.85,206.66) 119.15,207.36 119.15,207.81 118.08,208.89 116.43,208.89 115.79,209.53 P1.AB1
  BOTTOM w0.127: v1(119.85,206.66) 121.5,206.66 v2(122.58,205.59)
N62366162: length 6.4
  TOP w0.127: U77.1 157.93,173.42 158.78,172.57 158.78,172.12 159.67,171.23 159.67,170.91 159.86,170.72 159.86,169.98 160.14,169.7 160.14,169.1 RB1271.1
N62370066: length 1.9
  TOP w0.127: U37.5 243.52,120.97 244.01,121.46 R1371.2
N62372699: length 5.4
  TOP w0.127: RB1259.1 160.4,175.83 v1(159.99,176.25) 159.32,176.92 U77.8
  BOTTOM w0.127: v1(159.99,176.25) 160.68,175.55 v2(160.68,174.85)
