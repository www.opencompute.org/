# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NIF_TRVDD10: length 38.4
  TOP w0.381: U40.A11 v4(47.7,97.65) ; v4(35.7,106.65) U40.K22 ; v4(34.7,103.65) U40.G23 ; U40.F11 v4(47.7,102.65) ; v4(39.7,103.65) U40.G19 ; U40.J10 v4(48.7,105.65) ; U40.B11 v4(47.7,98.65) ; U40.K10 v4(48.7,106.65) ; v4(44.7,105.65) U40.J14 ; v4(39.7,98.65) U40.B19 ; v4(34.7,102.65) U40.F23 ; v4(43.7,97.65) U40.A15 ; v4(44.7,106.65) U40.K14 ; v4(39.7,102.65) U40.F19 ; v4(40.7,106.65) U40.K18 ; v4(43.7,98.65) U40.B15 ; v4(34.7,97.65) U40.A23 ; v4(34.7,98.65) U40.B23 ; v4(40.7,105.65) U40.J18 ; v4(43.7,102.65) U40.F15 ; v4(43.7,103.65) U40.G15 ; U40.G11 v4(47.7,103.65) ; v4(39.7,97.65) U40.A19 ; v4(35.7,105.65) U40.J22
  BOTTOM w0.305: CB688.2 35.7,105.64 v4(35.7,105.65) ; v4(43.7,103.65) 43.7,103.61 CB703.2 ; v4(34.7,98.65) 35.18,98.16 CB769.2 34.7,97.66 v4(34.7,97.65) ; v4(34.7,103.65) 35.17,103.17 CB701.2 ; v4(40.7,106.65) 40.7,106.61 CB677.2 ; v4(35.7,105.65) 35.7,105.67 CB676.2 35.7,106.61 v4(35.7,106.65) 35.7,106.65 CB675.2 35.21,106.14 v4(35.7,105.65) ; CB689.2 40.7,105.61 v4(40.7,105.65) ; CB772.2 47.22,98.12 v4(47.7,97.65) ; CB726.2 43.7,102.64 v4(43.7,102.65) ; CB690.2 44.7,105.64 v4(44.7,105.65) ; v4(44.7,106.65) 44.7,106.62 CB678.2 ; v4(39.7,97.65) 39.2,98.14 CB770.2 ; v4(47.7,102.65) 47.7,102.67 CB714.2 47.23,103.18 v4(47.7,103.65) ; v4(39.7,103.65) 39.7,103.61 CB702.2 ; v4(47.7,103.65) 47.69,103.65 CB691.2 ; v4(47.7,103.65) 47.71,103.65 CB695.2 ; v4(47.7,98.65) 47.17,99.17 CB749.2 ; v4(39.7,98.65) 39.17,99.17 CB745.2 ; CB679.2 48.7,106.62 v4(48.7,106.65) ; v4(43.7,98.65) 43.18,99.16 CB747.2 ; CB692.2 v4(48.7,105.65) ; v4(43.7,97.65) 43.7,97.65 CB771.2 ; v4(39.7,102.65) 39.7,102.61 CB725.2
  BOTTOM w0.381: CB724.2 34.7,102.63 v4(34.7,102.65) ; v1(54.08,93.4) v2(54.87,93.4)
  vias: v1(50.15,94.88) v1(50.17,94.15) v1(50.17,93.38) v1(53.33,94.12) v1(53.32,93.42) v1(53.36,94.83) v1(54.12,94.83) v1(54.07,94.11) v1(73.84,83.92) v1(73.91,84.86)
NIF_TVDD1P25: length 16.9
  TOP w0.381: U40.C14 v4(44.7,99.65) ; v4(35.7,99.65) U40.C22 ; v4(44.7,100.65) U40.D14 ; v4(40.7,100.65) U40.D18 ; v4(40.7,99.65) U40.C18 ; v4(35.7,100.65) U40.D22 ; U40.D10 v4(48.7,100.65) ; v4(48.7,99.65) U40.C10
  S14 w0.381: v4(35.7,100.65) v4(35.7,99.65) ; v4(40.7,100.65) v4(40.7,99.65)
  BOTTOM w0.305: v4(48.7,99.65) 48.7,99.65 CB752.2 48.7,100.62 v4(48.7,100.65) ; v4(35.7,99.65) 35.7,99.7 CB744.2 ; v4(40.7,100.65) 40.7,100.65 CB722.2 ; v4(48.7,100.65) 48.16,101.18 CB723.2 ; v4(48.7,100.65) 49.19,101.13 CB727.2 ; CB729.2 44.73,100.65 v4(44.7,100.65) ; CB748.2 44.7,99.73 v4(44.7,99.65) ; v4(40.7,99.65) 40.7,99.72 CB746.2 ; CB728.2 35.72,100.65 v4(35.7,100.65)
  BOTTOM w0.381: v1(63.72,102.84) 61.62,102.84 v2(61.62,102.84)
  vias: v1(62.73,104.27) v1(62.73,103.56) v1(63.44,104.21) v1(63.44,103.5) v1(64.48,102.84) v1(65.24,102.84) v1(66.01,102.84)
NIF_TX[08]_N: length 46
  TOP w0.095: U40.C17 v4(41.7,99.65)
  S12 w0.102: 42.08,97.44 42.08,97.46 42.08,97.46 42.08,97.61 42.08,97.61 42.08,99.03 42.11,99.06 42.11,99.92 arc(42.07,100.02) 41.97,100.06 41.82,100.06 arc(41.73,100.02) 41.7,99.94 v4(41.7,99.65)
  S12 w0.108: CONN54_PF.2T19 43.66,58.06 arc(43.69,57.94) 43.75,57.84 43.85,57.75 arc(43.93,57.69) 44.03,57.67 44.04,57.67 arc(44.15,57.7) 44.24,57.76 44.54,58.06 arc(44.77,58.4) 44.85,58.82 44.85,61.16 arc(44.8,61.42) 44.65,61.65 44.43,61.86 arc(44.17,62.26) 44.07,62.74 44.07,94.42 arc(43.94,95.07) 43.57,95.63 42.08,97.12 42.08,97.44
NIF_TX[08]_P: length 46
  TOP w0.095: U40.D17 v4(41.7,100.65)
  S12 w0.102: 42.29,97.52 42.29,98.95 42.31,98.97 42.31,99.92 arc(42.21,100.16) 41.97,100.26 41.9,100.26 arc(41.76,100.32) 41.7,100.46 v4(41.7,100.65)
  S12 w0.108: CONN54_PF.2T18 44.46,57.54 arc(44.46,57.57) 44.47,57.6 arc(44.47,57.6) 44.47,57.6 arc(44.47,57.61) 44.47,57.62 arc(44.5,57.69) 44.54,57.74 44.7,57.89 arc(44.98,58.32) 45.08,58.82 45.08,61.16 arc(45.01,61.51) 44.81,61.81 44.6,62.02 arc(44.38,62.35) 44.3,62.74 44.3,94.42 arc(44.15,95.16) 43.73,95.79 42.31,97.21 42.31,97.5 42.29,97.52
NIF_TX[09]_N: length 59.5
  TOP w0.095: U40.B18 v4(40.7,98.65)
  S12 w0.108: CONN54_PF.2L19 49.26,48.5 arc(49.28,48.61) 49.34,48.7 49.52,48.87 arc(49.64,49.06) 49.69,49.28 49.69,49.6 arc(49.51,50.02) 49.08,50.2 43.56,50.2 arc(43.16,50.28) 42.83,50.5 42.18,51.15 arc(42.12,51.24) 42.1,51.34 42.1,55.26 arc(42.02,55.67) 41.79,56.01 arc(41.7,56.15) 41.67,56.31 41.67,62.36 arc(41.76,62.8) 42,63.17 42.07,63.24 arc(42.47,63.83) 42.61,64.54 42.61,94.33 arc(42.48,94.98) 42.12,95.53 41.58,96.07 arc(41.38,96.36) 41.31,96.71 41.31,97.92 arc(41.21,98.16) 40.97,98.26 40.83,98.26 arc(40.74,98.3) 40.7,98.39 v4(40.7,98.65)
NIF_TX[09]_P: length 59.5
  TOP w0.095: U40.A18 v4(40.7,97.65)
  S12 w0.108: v4(40.7,97.65) 40.7,97.92 arc(40.73,98) 40.81,98.03 40.97,98.03 arc(41.05,98) 41.08,97.92 41.08,96.71 arc(41.17,96.27) 41.42,95.91 41.96,95.37 arc(42.27,94.89) 42.38,94.33 42.38,93.46 arc(42.35,93.38) 42.27,93.35 arc(42.19,93.32) 42.16,93.24 42.16,92.92 arc(42.19,92.84) 42.27,92.81 arc(42.35,92.78) 42.38,92.7 42.38,92.38 arc(42.35,92.3) 42.27,92.27 arc(42.19,92.24) 42.16,92.16 42.16,91.84 arc(42.19,91.76) 42.27,91.73 arc(42.35,91.7) 42.38,91.62 42.38,64.54 42.38,64.54 arc(42.26,63.92) 41.91,63.4 41.84,63.33 arc(41.54,62.88) 41.44,62.36 41.44,56.31 arc(41.49,56.06) 41.63,55.85 arc(41.81,55.58) 41.88,55.26 41.88,51.34 arc(41.91,51.15) 42.02,50.99 42.67,50.34 arc(43.08,50.07) 43.56,49.97 49.08,49.97 arc(49.35,49.86) 49.46,49.6 49.46,49.28 arc(49.43,49.15) 49.36,49.03 49.29,48.97 arc(49.18,48.9) 49.05,48.87 49.05,48.87 arc(48.9,48.9) 48.78,48.98 CONN54_PF.2L18
NIF_TX[10]_N: length 49.3
  TOP w0.095: U40.C19 v4(39.7,99.65)
  S12 w0.102: 40.08,97.34 40.08,99.98 arc(40.05,100.07) 39.95,100.11 39.86,100.11 arc(39.75,100.06) 39.7,99.94 v4(39.7,99.65)
  S12 w0.108: 40.08,97.34 40.08,97.11 39.94,96.97 39.94,95.72 arc(40.02,95.31) 40.26,94.95 40.45,94.75 arc(40.68,94.41) 40.76,94.01 40.76,93.14 arc(40.73,93.07) 40.65,93.03 arc(40.58,93) 40.55,92.93 40.55,92.53 arc(40.58,92.45) 40.65,92.42 arc(40.73,92.39) 40.76,92.31 40.76,91.91 arc(40.73,91.83) 40.65,91.8 arc(40.58,91.77) 40.55,91.69 40.55,91.29 arc(40.58,91.22) 40.65,91.19 arc(40.73,91.15) 40.76,91.08 40.76,87.85 40.76,87.85 arc(40.66,87.33) 40.37,86.9 33.19,79.72 arc(32.71,79) 32.54,78.15 32.54,64 arc(32.43,63.45) 32.12,62.99 30.81,61.68 30.73,61.6 arc(30.41,61.12) 30.3,60.56 30.3,58.33 arc(30.28,58.21) 30.21,58.11 30.03,57.93 29.78,57.93 CONN54_PF.1T19
NIF_TX[10]_P: length 49.3
  TOP w0.095: U40.D19 v4(39.7,100.65)
  S12 w0.102: 40.31,97.34 40.31,97.35 40.29,97.38 40.29,97.43 40.29,97.43 40.29,100.06 arc(40.21,100.24) 40.04,100.31 39.89,100.31 arc(39.75,100.37) 39.7,100.51 v4(39.7,100.65)
  S12 w0.108: CONN54_PF.1T18 30.21,57.79 30.37,57.94 arc(30.49,58.12) 30.53,58.33 30.53,60.56 arc(30.62,61.03) 30.89,61.44 30.97,61.52 32.28,62.83 arc(32.64,63.37) 32.77,64 32.77,78.15 arc(32.92,78.91) 33.35,79.56 40.53,86.74 arc(40.87,87.25) 40.99,87.85 40.99,94.01 arc(40.89,94.5) 40.62,94.92 40.42,95.11 arc(40.23,95.39) 40.17,95.72 40.17,96.87 40.31,97.02 40.31,97.34
NIF_TX[11]_N: length 63.6
  TOP w0.095: U40.B20 v4(37.7,98.65)
  S12 w0.108: v4(37.7,98.65) 37.7,98.47 arc(37.73,98.38) 37.82,98.33 37.85,98.32 38.24,98.32 arc(38.72,98.13) 38.91,97.66 38.91,88.61 arc(38.76,87.85) 38.34,87.21 32,80.88 arc(30.92,79.26) 30.54,77.36 30.54,65.12 arc(30.43,64.55) 30.11,64.07 27.67,61.64 arc(27.35,61.15) 27.23,60.58 27.23,51.99 arc(27.32,51.56) 27.56,51.19 27.56,51.19 27.64,51.11 arc(27.91,50.94) 28.22,50.87 28.36,50.87 arc(28.84,50.78) 29.25,50.51 29.31,50.44 arc(29.62,50.24) 29.99,50.16 34.54,50.16 arc(35.06,49.95) 35.28,49.42 35.28,49.09 arc(35.24,48.9) 35.14,48.75 35.08,48.69 arc(35.03,48.62) 35.01,48.53 CONN54_PF.1L19
NIF_TX[11]_P: length 63.5
  TOP w0.095: U40.A20 v4(37.7,97.65)
  S12 w0.108: CONN54_PF.1L18 34.21,49.13 arc(34.24,49.01) 34.3,48.91 34.5,48.72 arc(34.57,48.67) 34.65,48.66 arc(34.72,48.67) 34.77,48.71 34.98,48.91 arc(35.03,48.99) 35.05,49.09 35.05,49.42 arc(34.9,49.78) 34.54,49.93 29.99,49.93 arc(29.54,50.02) 29.15,50.28 29.09,50.34 arc(28.76,50.57) 28.36,50.64 28.22,50.64 arc(27.82,50.72) 27.48,50.95 27.4,51.03 arc(27.11,51.47) 27.01,51.99 27.01,60.58 arc(27.14,61.24) 27.51,61.8 29.95,64.23 arc(30.22,64.64) 30.31,65.12 30.31,77.36 arc(30.71,79.35) 31.84,81.04 38.17,87.38 arc(38.55,87.94) 38.68,88.61 38.68,97.66 arc(38.56,97.97) 38.24,98.1 37.84,98.1 37.83,98.1 37.82,98.09 arc(37.73,98.04) 37.7,97.95 v4(37.7,97.65)
NIF_TX[12]_N: length 70.5
  TOP w0.095: U40.D21 v4(36.7,100.65) ; U69.37 5.64,56.12 5.94,56.43 5.94,56.59 v3(5.53,57)
  S12 w0.102: 36.7,100.34 36.78,100.26 37.08,100.26 37.29,100.05 37.29,97.42 37.29,97.41
  S12 w0.108: 37.29,97.41 37.69,97.02 37.69,90.21 arc(37.47,89.14) 36.87,88.23 29.31,80.67 arc(28.37,79.26) 28.04,77.6 28.04,65.11 arc(27.9,64.43) 27.52,63.85 19.26,55.59 arc(18.81,55.3) 18.29,55.19 7.3,55.19 arc(6.33,55.59) 5.93,56.56 5.93,56.6 arc(5.81,56.88) v3(5.53,57) ; 36.7,100.34 v4(36.7,100.65)
NIF_TX[12]_P: length 70.5
  TOP w0.095: v3(6.55,57) 6.17,56.62 6.17,56.47 6.44,56.2 U69.36 ; U40.C21 v4(36.7,99.65)
  S12 w0.102: 37.08,97.3 37.08,99.97 36.99,100.06 36.78,100.06 36.7,99.97 v4(36.7,99.65)
  S12 w0.108: 37.08,97.3 37.46,96.92 37.46,96.43 arc(37.42,96.35) 37.34,96.31 arc(37.25,96.27) 37.21,96.19 37.21,95.82 arc(37.25,95.73) 37.34,95.69 arc(37.42,95.66) 37.46,95.57 37.46,95.2 arc(37.42,95.11) 37.34,95.08 arc(37.25,95.04) 37.21,94.96 37.21,94.58 arc(37.25,94.5) 37.34,94.46 arc(37.42,94.43) 37.46,94.34 37.46,93.97 arc(37.42,93.88) 37.34,93.85 arc(37.25,93.81) 37.21,93.72 37.21,93.35 arc(37.25,93.27) 37.34,93.23 arc(37.42,93.19) 37.46,93.11 37.46,92.74 arc(37.42,92.65) 37.34,92.61 arc(37.25,92.58) 37.21,92.49 37.21,92.12 arc(37.25,92.03) 37.34,92 arc(37.42,91.96) 37.46,91.88 37.46,90.21 arc(37.26,89.22) 36.7,88.39 29.15,80.83 arc(28.16,79.35) 27.81,77.6 27.81,65.11 27.81,65.11 arc(27.69,64.52) 27.36,64.02 19.09,55.75 arc(18.72,55.51) 18.29,55.42 7.3,55.42 arc(6.49,55.75) 6.16,56.56 6.16,56.6 arc(6.27,56.88) v3(6.55,57)
NIF_TX[13]_N: length 62.4
  TOP w0.095: U69.34 8.04,56.12 8.36,56.44 8.36,56.67 8.04,57 v3(7.93,57) ; U40.A22 v4(35.7,97.65)
  S12 w0.108: v4(35.7,97.65) 35.69,97.65 35.69,97.98 arc(35.72,98.07) 35.81,98.13 arc(35.83,98.13) 35.84,98.13 35.93,98.13 arc(36.04,98.09) 36.08,97.98 36.08,96.61 arc(36.02,96.29) 35.83,96.01 35.15,95.33 arc(34.97,95.06) 34.91,94.73 34.91,89.97 arc(34.83,89.57) 34.6,89.24 23.87,78.51 arc(23.4,77.8) 23.24,76.97 23.24,64.75 arc(23.16,64.36) 22.94,64.04 22.76,63.86 21.93,63.03 arc(21.65,62.61) 21.55,62.12 21.55,61.03 arc(21.48,60.67) 21.28,60.36 20.74,59.83 arc(20.33,59.55) 19.84,59.46 17.37,59.46 arc(17.23,59.48) 17.12,59.56 arc(16.91,59.7) 16.66,59.75 10.67,59.75 arc(9.94,59.6) 9.32,59.19 8.7,58.57 arc(8.43,58.17) 8.34,57.7 8.34,57.25 arc(8.27,57.07) 8.09,57 v3(7.93,57)
NIF_TX[13]_P: length 62.5
  TOP w0.095: U40.B22 v4(35.7,98.65) ; v3(8.95,57) 8.59,56.64 8.59,56.39 8.84,56.14 U69.33
  S12 w0.108: v4(35.7,98.65) 35.7,98.45 arc(35.71,98.39) 35.76,98.35 arc(35.8,98.36) 35.84,98.36 35.93,98.36 arc(36.2,98.25) 36.31,97.98 36.31,96.61 arc(36.23,96.2) 35.99,95.85 35.31,95.17 arc(35.18,94.97) 35.14,94.73 35.14,89.97 arc(35.04,89.49) 34.76,89.08 24.03,78.35 arc(23.61,77.71) 23.46,76.97 23.46,64.75 arc(23.37,64.28) 23.1,63.88 22.14,62.91 22.09,62.87 arc(21.86,62.52) 21.78,62.12 21.78,61.03 arc(21.69,60.58) 21.44,60.2 20.91,59.67 arc(20.42,59.34) 19.84,59.23 17.36,59.23 arc(17.15,59.27) 16.96,59.4 arc(16.82,59.49) 16.66,59.52 10.67,59.52 arc(10.03,59.39) 9.48,59.03 8.86,58.41 arc(8.64,58.08) 8.57,57.7 8.57,57.21 arc(8.63,57.06) 8.78,57 v3(8.95,57)
NIF_TX[14]_N: length 71.5
  TOP w0.095: U40.D23 v4(34.7,100.65) ; U69.2 6.04,51.78 6.32,51.5 6.32,51.15 v3(5.92,50.75)
  S12 w0.102: v4(34.7,100.65) 34.7,100.36 arc(34.67,100.29) 34.59,100.26 34.51,100.26 arc(34.23,100.14) 34.11,99.86 34.11,97.54 34.1,97.53 34.1,97.36 34.14,97.33 34.14,97.3 34.15,97.29
  S12 w0.108: v3(5.92,50.75) 6.19,51.02 arc(6.28,51.15) 6.31,51.3 6.31,51.92 arc(6.25,52.18) 6.11,52.4 4.64,53.87 arc(4.13,54.63) 3.95,55.53 3.95,56.34 arc(4.2,57.59) 4.9,58.64 9.45,63.19 arc(10.04,63.58) 10.73,63.72 18.65,63.72 arc(18.98,63.78) 19.25,63.97 19.39,64.11 arc(19.5,64.28) 19.54,64.48 19.54,64.77 arc(19.61,65.1) 19.79,65.38 20.83,66.41 arc(21.16,66.91) 21.28,67.49 21.28,78.39 arc(21.45,79.28) 21.96,80.04 33.17,91.26 arc(33.32,91.47) 33.37,91.72 33.37,94.63 arc(33.5,95.29) 33.87,95.85 33.97,95.95 arc(34.13,96.19) 34.18,96.47 34.18,97.25 34.15,97.29
NIF_TX[14]_P: length 71.5
  TOP w0.095: v3(6.94,50.75) 6.54,51.15 6.54,51.47 6.84,51.76 U69.3 ; U40.C23 v4(34.7,99.65)
  S12 w0.102: 34.31,97.45 34.31,99.86 arc(34.37,100) 34.51,100.06 34.59,100.06 arc(34.67,100) 34.7,99.9 v4(34.7,99.65)
  S12 w0.108: v3(6.94,50.75) 6.63,51.06 arc(6.56,51.17) 6.53,51.3 6.53,51.92 arc(6.46,52.27) 6.27,52.56 4.8,54.03 arc(4.34,54.72) 4.18,55.53 arc(4.18,55.53) 4.18,55.54 4.18,56.34 arc(4.41,57.5) 5.06,58.48 5.23,58.64 9.61,63.03 arc(10.13,63.37) 10.73,63.49 18.65,63.49 arc(19.06,63.57) 19.41,63.81 19.55,63.94 arc(19.71,64.19) 19.77,64.48 19.77,64.77 arc(19.82,65.01) 19.96,65.22 20.99,66.25 arc(21.37,66.82) 21.5,67.49 21.5,78.39 arc(21.67,79.2) 22.12,79.88 33.34,91.09 arc(33.53,91.38) 33.59,91.72 33.59,92.13 arc(33.62,92.18) 33.67,92.2 arc(33.72,92.22) 33.74,92.27 33.74,92.67 arc(33.72,92.72) 33.67,92.74 arc(33.62,92.76) 33.59,92.81 33.59,93.21 arc(33.62,93.26) 33.67,93.28 arc(33.72,93.3) 33.74,93.35 33.74,93.75 arc(33.72,93.8) 33.67,93.82 arc(33.62,93.84) 33.59,93.89 33.59,94.63 arc(33.71,95.21) 34.03,95.69 34.13,95.79 arc(34.34,96.1) 34.41,96.47 34.41,97.35 34.31,97.45
NIF_TX[15]_N: length 75.9
  TOP w0.095: U69.5 8.44,51.78 8.72,51.5 8.72,51.15 v3(8.32,50.75) ; U40.A24 v4(33.7,97.65)
  S12 w0.108: v3(8.32,50.75) 8.55,50.75 arc(8.71,50.69) 8.78,50.53 8.78,50.1 arc(8.57,49.6) 8.08,49.4 5.96,49.4 arc(3.91,50.25) 3.06,52.3 3.06,57.02 arc(3.32,58.3) 4.04,59.39 8.87,64.21 arc(9.54,64.66) 10.32,64.82 15.24,64.82 arc(15.63,64.89) 15.96,65.11 16.41,65.56 arc(16.63,65.71) 16.9,65.77 18.42,65.77 arc(18.76,65.83) 19.04,66.02 19.2,66.18 arc(19.47,66.59) 19.57,67.07 19.57,79.51 arc(19.74,80.4) 20.24,81.15 27.97,88.88 arc(28.07,88.92) 28.16,88.88 arc(28.26,88.84) 28.35,88.88 28.69,89.21 arc(28.73,89.31) 28.69,89.4 arc(28.65,89.5) 28.69,89.59 29.02,89.93 arc(29.12,89.97) 29.21,89.93 arc(29.31,89.89) 29.4,89.93 29.74,90.26 arc(29.78,90.36) 29.74,90.45 arc(29.7,90.55) 29.74,90.64 30.08,90.98 arc(30.17,91.02) 30.27,90.98 arc(30.39,90.93) 30.52,90.98 30.79,91.25 arc(30.84,91.38) 30.79,91.5 arc(30.75,91.6) 30.79,91.69 31.71,92.61 arc(32,93.05) 32.1,93.56 32.1,95.34 arc(32.22,95.91) 32.54,96.4 33.14,97 arc(33.27,97.19) 33.31,97.41 33.31,97.85 arc(33.37,97.98) 33.5,98.03 arc(33.64,97.97) 33.7,97.83 v4(33.7,97.65)
NIF_TX[15]_P: length 75.9
  TOP w0.095: v3(9.34,50.75) 8.94,51.15 8.94,51.54 9.24,51.83 U69.6 ; U40.B24 v4(33.7,98.65)
  S12 w0.108: v3(9.34,50.75) 9.17,50.75 arc(9.06,50.7) 9.01,50.59 9.01,50.1 arc(8.74,49.44) 8.08,49.17 5.96,49.17 arc(3.75,50.09) 2.84,52.3 2.84,57.02 arc(3.11,58.39) 3.88,59.55 6.23,61.9 8.71,64.38 arc(9.45,64.87) 10.32,65.04 15.24,65.04 arc(15.54,65.1) 15.8,65.28 16.24,65.72 arc(16.55,65.92) 16.9,65.99 18.42,65.99 arc(18.67,66.04) 18.88,66.18 19.04,66.34 arc(19.26,66.67) 19.34,67.07 19.34,79.51 arc(19.53,80.48) 20.08,81.31 30.62,91.85 arc(30.62,91.85) 30.63,91.86 31.55,92.78 arc(31.79,93.14) 31.87,93.56 31.87,95.34 arc(32.01,96) 32.38,96.56 32.98,97.16 arc(33.06,97.27) 33.08,97.41 33.08,97.85 arc(33.21,98.14) 33.5,98.26 arc(33.64,98.32) 33.7,98.46 v4(33.7,98.65)
NIFE0_156.25M_N: length 181.4
  TOP w0.095: v3(13.16,114.24) 13.45,113.95 14.1,113.95 14.63,114.49 15.68,114.49 15.89,114.7 C417.1 ; v3(137.87,167.84) 138.27,168.23 139.1,168.23 R1375.1
  S12 w0.108: v3(137.87,167.84) 137.56,168.15 136.76,168.15 136.34,167.73 136.34,166.86 arc(136.41,166.69) 136.58,166.62 arc(136.75,166.55) 136.82,166.38 136.82,166.32 arc(136.75,166.15) 136.58,166.08 arc(136.41,166.01) 136.34,165.84 136.34,165.78 arc(136.41,165.61) 136.58,165.54 arc(136.75,165.47) 136.82,165.3 136.82,165.24 arc(136.75,165.07) 136.58,165 arc(136.41,164.93) 136.34,164.76 136.34,163.95 125.52,153.13 104.51,153.13 100.76,156.88 74.58,156.88 71.41,153.72 61.33,153.72 56.58,148.97 37.84,148.97 35.78,146.91 25.24,146.91 21.96,143.63 16.3,143.63 6.9,134.24 6.9,117.94 7.75,117.09 9.49,117.09 12.6,113.97 12.89,113.97 v3(13.16,114.24)
NIFE0_156.25M_P: length 181.1
  TOP w0.095: v3(13.16,113.43) 13.45,113.73 14.2,113.73 14.73,114.26 15.68,114.26 15.77,114.16 15.77,113.96 C424.1 ; R1374.1 139.1,168.46 138.27,168.46 v3(137.87,168.86)
  S12 w0.108: v3(137.87,168.86) 137.87,168.8 137.46,168.38 136.66,168.38 136.11,167.83 136.11,164.05 125.43,153.36 104.6,153.36 100.85,157.11 74.48,157.11 71.32,153.94 61.23,153.94 56.48,149.2 37.74,149.2 35.68,147.14 25.14,147.14 21.87,143.86 16.2,143.86 6.67,134.33 6.67,117.84 7.65,116.86 9.39,116.86 12.51,113.75 12.84,113.75 v3(13.16,113.43)
NIFE1_156.25M_N: length 127.3
  TOP w0.095: R1377.1 139.66,171.17 139.56,171.08 138.31,171.08 v3(137.92,171.47)
  BOTTOM w0.095: v3(137.92,171.47) 138.31,171.08 139.32,171.08 139.83,170.57 139.83,161.5 arc(139.63,160.52) 139.08,159.69 138.82,159.43 124.65,145.26 arc(123.95,144.79) 123.12,144.63 116.7,144.63 arc(116.18,144.73) 115.73,145.03 110.89,149.87 arc(109.33,150.91) 107.48,151.28 97.44,151.28 arc(97.06,151.36) 96.73,151.58 arc(96.64,151.64) 96.52,151.66 87.35,151.66 arc(84.83,151.16) 82.69,149.73 73.18,140.22 arc(68.13,132.66) 66.36,123.75 66.36,118.02 arc(66.15,116.97) 65.55,116.08 65.18,115.7 arc(64.91,115.52) 64.6,115.46 61.3,115.46 arc(61.1,115.5) 60.93,115.61 arc(60.84,115.67) 60.73,115.69 60.31,115.69 arc(60.12,115.66) 59.97,115.55 CB575.1
NIFE1_156.25M_P: length 127.3
  TOP w0.095: R1376.1 139.68,170.73 139.56,170.85 138.31,170.85 v3(137.92,170.46)
  BOTTOM w0.095: v3(137.92,170.46) 138.31,170.85 139.23,170.85 139.6,170.48 139.6,169.75 arc(139.55,169.63) 139.43,169.58 arc(139.31,169.53) 139.26,169.41 139.26,169.15 arc(139.31,169.03) 139.43,168.98 arc(139.55,168.93) 139.6,168.81 139.6,168.54 arc(139.55,168.42) 139.43,168.38 arc(139.31,168.33) 139.26,168.21 139.26,167.94 arc(139.31,167.82) 139.43,167.77 arc(139.55,167.72) 139.6,167.6 139.6,161.5 arc(139.42,160.61) 138.92,159.85 138.66,159.59 124.49,145.42 arc(123.86,145) 123.12,144.85 116.7,144.85 arc(116.26,144.94) 115.89,145.19 111.05,150.03 arc(109.41,151.12) 107.48,151.51 97.44,151.51 96.89,151.74 arc(96.72,151.85) 96.52,151.89 87.35,151.89 arc(84.74,151.37) 82.53,149.89 73.02,140.38 arc(67.92,132.75) 66.13,123.75 66.13,118.02 arc(65.94,117.06) 65.39,116.24 65.02,115.86 arc(64.83,115.73) 64.6,115.69 61.3,115.69 arc(61.19,115.71) 61.09,115.77 arc(60.93,115.88) 60.73,115.92 60.28,115.92 arc(60.1,115.96) 59.94,116.06 CB564.1
NIFE_LCPLL_AVDD1P8: length 5.2
  TOP w0.381: U40.T13 v4(45.7,112.65) ; U40.V25 v4(32.7,114.65)
  BOTTOM w0.381: CB601.1 32.2,114.14 v4(32.7,114.65) 32.7,114.64 CB585.2 ; v2(16.09,97.95) 15.9,98.15 v1(14.48,98.15) ; v4(45.7,112.65) 45.21,113.13 CB605.2
  vias: v1(13.72,98.15)
NIFE_PVDD10: length 20.7
  TOP w0.381: v4(29.7,117.65) U40.Y28 ; U40.M25 v4(32.7,108.65) ; C399.2 65.88,109.57 ; v4(46.7,108.65) U40.M12 ; C397.2 v1(63.85,109.7) ; v4(52.7,117.65) U40.Y6 ; U40.M11 v4(47.7,108.65) ; C395.2 v1(61.81,109.7) ; C400.2 66.89,109.57 ; v4(30.7,107.65) U40.L27 ; C396.2 v1(62.83,109.73) ; v4(45.7,108.65) U40.M13 ; C398.2 64.86,109.83 ; v4(31.7,108.65) U40.M26
  S5 w0.381: 52.26,117.68 52.29,117.65 v4(52.7,117.65)
  BOTTOM w0.381: CB659.2 v4(45.7,108.65) 45.71,108.65 CB660.2 v4(46.7,108.65) ; v4(47.7,108.65) CB664.2 ; CB667.2 33.2,108.14 v4(32.7,108.65) 32.7,108.61 CB666.2 31.7,108.58 v4(31.7,108.65) 31.21,108.16 CB665.2 30.78,107.65 v4(30.7,107.65) 31.17,107.18 CB680.2 ; CB551.2 52.76,117.65 v4(52.7,117.65) ; v2(60.96,109.58) 61.69,109.58 v1(61.81,109.7) ; U40.Y28 v4(29.7,117.65)
  vias: v1(61.53,108.96) v1(62.25,108.96) v1(62.98,108.96) v1(63.69,108.96)
NIFE_RX[16]_N: length 135.5
  TOP w0.095: U40.G26 v4(31.7,103.65)
  S16 w0.102: v4(31.7,103.65) 31.7,103.44 arc(31.75,103.33) 31.86,103.28 31.94,103.28 arc(32.18,103.18) 32.29,102.93 32.29,99.07 32.31,99.05 32.31,97.59 arc(32.41,97.33) 32.65,97.2 arc(32.68,97.19) 32.71,97.19
  S16 w0.108: 32.71,97.19 33.01,97.19 arc(33.14,97.17) 33.25,97.1 33.85,96.5 arc(34.3,95.82) 34.45,95.03 34.45,93.68 arc(34.5,93.47) 34.62,93.29 35.34,92.57 arc(35.72,92.31) 36.17,92.22 37.16,92.22 arc(38.19,91.8) 38.61,90.77 38.61,90.08 arc(38.73,89.49) 39.07,88.98 40.53,87.52 arc(41.46,86.89) 42.56,86.68 54.64,86.68 arc(58.5,85.91) 61.78,83.72 62.1,83.4 arc(64.81,81.59) 68.02,80.95 74.81,80.95 arc(75.45,80.82) 75.99,80.46 76.27,80.17 arc(78.49,78.7) 81.1,78.18 123.76,78.18 arc(124.28,78.07) 124.73,77.77 129.19,73.32 arc(130.03,72.75) 131.03,72.55 131.45,72.55 arc(132.16,72.41) 132.75,72.01 134.32,70.45 arc(134.73,69.83) 134.88,69.09 134.88,65.25 arc(134.95,64.89) 135.16,64.58 136,63.74 arc(136.27,63.33) 136.37,62.84 136.37,60.08 arc(136.43,59.78) 136.6,59.53 136.6,59.53 arc(136.89,59.09) 137,58.57 137,58 arc(136.96,57.82) 136.85,57.66 arc(136.83,57.63) 136.82,57.6 arc(136.82,57.6) 136.82,57.59 arc(136.81,57.58) 136.81,57.56 CONN55_PF.2T12
NIFE_RX[16]_P: length 135.6
  TOP w0.095: U40.F26 v4(31.7,102.65)
  S16 w0.102: v4(31.7,102.65) 31.7,102.97 arc(31.73,103.04) 31.81,103.08 31.94,103.08 arc(32.04,103.03) 32.08,102.93 32.08,98.99 32.11,98.96 32.11,97.59 arc(32.25,97.2) 32.62,97 32.63,96.99 32.68,96.99 32.7,96.97 32.71,96.97
  S16 w0.108: 32.71,96.97 33.01,96.97 arc(33.05,96.96) 33.09,96.93 33.69,96.33 arc(34.09,95.74) 34.23,95.03 34.23,93.68 arc(34.29,93.38) 34.46,93.13 35.17,92.41 arc(35.63,92.1) 36.17,91.99 37.16,91.99 arc(38.02,91.64) 38.38,90.77 38.38,90.08 arc(38.52,89.4) 38.9,88.82 40.37,87.36 arc(41.38,86.68) 42.56,86.45 54.64,86.45 arc(58.42,85.7) 61.62,83.56 61.93,83.24 arc(64.73,81.37) 68.02,80.72 74.81,80.72 arc(75.36,80.61) 75.83,80.3 76.11,80.01 arc(78.4,78.48) 81.1,77.95 123.76,77.95 arc(124.2,77.86) 124.57,77.61 129.02,73.16 arc(129.95,72.54) 131.03,72.32 131.45,72.32 arc(132.07,72.2) 132.59,71.85 134.15,70.29 arc(134.52,69.74) 134.65,69.09 134.65,65.25 arc(134.74,64.8) 135,64.42 135.88,63.54 135.84,63.58 arc(136.06,63.24) 136.14,62.84 136.14,60.08 arc(136.22,59.69) 136.44,59.37 136.44,59.36 arc(136.68,59) 136.77,58.57 136.77,58 arc(136.75,57.9) 136.69,57.82 136.65,57.78 arc(136.57,57.72) 136.48,57.71 136.44,57.71 arc(136.33,57.73) 136.24,57.79 136.17,57.86 arc(136.05,58.03) 136.01,58.24 CONN55_PF.2T13
NIFE_RX[17]_N: length 141.4
  TOP w0.095: U40.H27 v4(30.7,104.65)
  S16 w0.102: 31.1,97.22 31.08,97.24 31.08,99.32 31.11,99.35 31.11,101.32 31.08,101.35 31.08,104.99 30.97,105.11 30.77,105.11 30.64,104.98 30.64,104.7 v4(30.7,104.65)
  S16 w0.108: CONN55_PF.2L12 arc(131.26,49.06) 131.4,48.85 arc(131.66,48.74) 131.91,48.85 132.24,49.17 arc(132.32,49.3) 132.35,49.45 arc(132.18,49.87) 131.75,50.05 130.98,50.05 arc(129.91,50.49) 129.47,51.56 129.47,57.37 arc(129.41,57.64) 129.26,57.87 128.7,58.43 arc(128.46,58.77) 128.33,59.18 128.32,59.19 128.32,62.68 arc(128.14,63.62) 127.6,64.42 127.42,64.6 arc(127.08,65.11) 126.97,65.71 126.97,68.58 arc(126.85,69.17) 126.51,69.68 119.96,76.23 arc(119.4,76.6) 118.73,76.74 80.2,76.74 arc(77.7,77.23) 75.57,78.65 75.57,78.65 arc(75.54,78.68) 75.51,78.71 arc(74.79,79.16) 73.96,79.32 67,79.32 arc(64.07,79.9) 61.58,81.57 60.87,82.27 arc(57.52,84.52) 53.56,85.31 41.7,85.31 arc(40.03,85.64) 38.62,86.58 33.25,91.95 arc(33.04,92.27) 32.96,92.66 32.96,94.21 arc(32.79,95.06) 32.31,95.77 31.41,96.68 arc(31.22,96.93) 31.1,97.22
NIFE_RX[17]_P: length 141.5
  TOP w0.095: U40.J27 v4(30.7,105.65)
  S16 w0.102: 31.29,97.45 31.29,97.45 31.29,99.24 31.32,99.27 31.32,101.4 31.29,101.44 31.29,105.07 31.05,105.31 30.77,105.31 30.7,105.38 v4(30.7,105.65)
  S16 w0.108: CONN55_PF.2L13 132.01,48.32 arc(132.07,48.6) 132.23,48.84 132.36,48.97 132.36,48.97 132.4,49.01 arc(132.53,49.21) 132.58,49.45 arc(132.34,50.03) 131.75,50.28 130.98,50.28 arc(130.07,50.65) 129.7,51.56 129.7,57.37 arc(129.62,57.73) 129.42,58.03 128.86,58.59 arc(128.66,58.87) 128.56,59.21 arc(128.56,59.27) 128.55,59.34 128.55,59.34 128.55,62.68 arc(128.35,63.71) 127.76,64.58 127.59,64.76 arc(127.3,65.2) 127.19,65.71 127.19,68.58 arc(127.06,69.26) 126.67,69.84 120.12,76.39 arc(119.48,76.82) 118.73,76.97 80.2,76.97 arc(77.78,77.45) 75.73,78.82 75.67,78.88 75.66,78.88 arc(74.88,79.38) 73.96,79.55 67,79.55 arc(64.16,80.12) 61.75,81.73 61.04,82.44 arc(57.6,84.73) 53.56,85.53 41.7,85.53 arc(40.12,85.85) 38.79,86.74 33.42,92.11 arc(33.25,92.36) 33.19,92.66 33.19,94.21 arc(33,95.14) 32.48,95.93 31.57,96.84 arc(31.38,97.12) 31.29,97.45
NIFE_RX[18]_N: length 118.9
  TOP w0.095: v4(29.7,103.65) U40.G28
  S16 w0.102: 30.32,97.5 30.31,97.52 30.31,99.05 30.29,99.07 30.29,102.93 arc(30.18,103.18) 29.94,103.28 29.86,103.28 arc(29.75,103.33) 29.7,103.44 v4(29.7,103.65)
  S16 w0.108: CONN55_PF.1T12 122.56,57.38 arc(122.57,57.46) 122.6,57.53 arc(122.6,57.53) 122.6,57.53 arc(122.63,57.57) 122.66,57.61 122.78,57.73 arc(122.91,57.92) 122.95,58.16 122.95,58.5 arc(122.9,58.76) 122.75,58.99 122.22,59.52 arc(121.97,59.89) 121.89,60.32 121.89,61.18 arc(121.78,61.7) 121.49,62.13 arc(121.07,62.41) 120.58,62.51 111.28,62.51 arc(110.91,62.58) 110.59,62.8 109.27,64.11 arc(106.68,65.85) 103.62,66.46 98.94,66.46 arc(98.26,66.59) 97.68,66.98 91.91,72.75 arc(90.9,73.43) 89.7,73.66 85.08,73.66 arc(84.75,73.73) 84.47,73.91 83.74,74.64 arc(82.41,75.53) 80.83,75.85 77.25,75.85 arc(75.63,76.17) 74.26,77.09 arc(72.99,77.93) 71.5,78.23 64.33,78.23 arc(62.96,78.5) 61.8,79.28 61.79,79.29 60.04,81.03 arc(56.35,83.5) 52,84.37 41.14,84.37 arc(39.76,84.63) 38.57,85.39 arc(38.54,85.42) 38.51,85.46 32.14,91.83 arc(31.89,92.2) 31.8,92.64 31.8,94.43 arc(31.69,94.99) 31.37,95.47 30.74,96.1 arc(30.45,96.54) 30.35,97.05 30.35,97.48 30.32,97.5
NIFE_RX[18]_P: length 118.9
  TOP w0.095: v4(29.7,102.65) U40.F28
  S16 w0.102: 30.12,97.42 30.11,97.43 30.11,98.97 30.08,98.99 30.08,102.93 arc(30.04,103.03) 29.94,103.08 29.81,103.08 arc(29.73,103.04) 29.7,102.97 v4(29.7,102.65)
  S16 w0.108: 30.12,97.42 30.12,97.05 arc(30.24,96.45) 30.58,95.94 31.21,95.31 arc(31.48,94.91) 31.57,94.43 31.57,92.64 arc(31.68,92.11) 31.98,91.67 38.35,85.29 38.41,85.23 38.42,85.23 arc(39.67,84.42) 41.14,84.14 52,84.14 arc(56.26,83.29) 59.88,80.87 61.64,79.11 arc(62.87,78.29) 64.33,78 71.5,78 arc(72.91,77.72) 74.1,76.93 arc(75.54,75.96) 77.25,75.62 80.83,75.62 arc(82.32,75.32) 83.58,74.48 84.31,73.75 arc(84.66,73.52) 85.08,73.43 89.7,73.43 arc(90.81,73.21) 91.74,72.59 97.52,66.82 arc(98.17,66.38) 98.94,66.23 103.62,66.23 arc(106.59,65.64) 109.11,63.95 110.43,62.64 arc(110.82,62.37) 111.28,62.28 120.58,62.28 arc(120.99,62.2) 121.33,61.97 arc(121.57,61.61) 121.66,61.18 121.66,60.32 arc(121.76,59.8) 122.05,59.36 122.59,58.83 arc(122.69,58.68) 122.73,58.5 122.73,58.16 arc(122.7,58.01) 122.62,57.89 122.48,57.76 arc(122.4,57.7) 122.31,57.69 arc(122.17,57.71) 122.05,57.79 121.92,57.93 arc(121.8,58.1) CONN55_PF.1T13
NIFE_RX[19]_N: length 125.4
  TOP w0.095: v4(28.7,105.65) U40.J29
  S16 w0.102: v4(28.7,105.65) 28.7,105.35 28.6,105.25 28.34,105.25 28.08,105 28.08,103.93 28.11,103.9 28.11,101.13 28.08,101.1 28.08,99.13 28.11,99.1 28.11,97.49 28.11,97.49 28.11,97.32 28.15,97.28 28.14,97.27 28.14,97.25 28.15,97.24
  S16 w0.108: CONN55_PF.1L12 117.23,49.04 arc(117.34,48.97) 117.46,48.94 arc(117.56,48.96) 117.65,49.02 117.82,49.19 arc(117.87,49.26) 117.88,49.35 117.88,49.45 arc(117.84,49.65) 117.73,49.81 arc(117.56,49.93) 117.35,49.97 116.39,49.97 arc(115.58,50.31) 115.24,51.12 115.24,53.09 115.24,53.09 115.03,53.6 arc(114.91,53.79) 114.86,54.01 114.86,58.28 arc(114.75,58.84) 114.43,59.32 114.1,59.65 113.66,60.1 arc(112.47,60.89) 111.08,61.16 110.03,61.16 arc(109.43,61.28) 108.92,61.62 arc(105.94,63.61) 102.43,64.31 99.18,64.31 arc(97.39,64.67) 95.87,65.68 91.03,70.52 arc(90.32,70.99) 89.48,71.16 86.62,71.16 arc(86.31,71.22) 86.06,71.39 arc(85.49,71.77) 84.82,71.91 81.44,71.91 arc(80.56,72.08) 79.81,72.58 arc(78.52,73.44) 77,73.75 74.47,73.75 arc(74.19,73.8) 73.96,73.96 72.54,75.38 arc(70.9,76.47) 68.98,76.86 63.17,76.86 arc(61.92,77.11) 60.87,77.81 58.84,79.83 arc(55.35,82.17) 51.22,82.99 39.47,82.99 arc(37.5,83.38) 35.84,84.5 30.48,89.85 arc(30.32,90.09) 30.27,90.37 30.27,94.07 arc(30.17,94.56) 29.89,94.98 29.18,95.69 arc(28.98,95.98) 28.91,96.32 28.91,96.48 28.15,97.24
NIFE_RX[19]_P: length 125.4
  TOP w0.095: v4(28.7,104.65) U40.H29
  S16 w0.102: 28.32,97.41 28.32,99.18 28.28,99.21 28.28,101.01 28.32,101.04 28.32,103.99 28.29,104.02 28.29,104.91 28.42,105.05 28.56,105.05 28.7,104.91 v4(28.7,104.65)
  S16 w0.108: 28.32,97.41 29.14,96.58 29.14,96.32 arc(29.19,96.07) 29.34,95.86 30.05,95.14 arc(30.38,94.65) 30.5,94.07 30.5,90.37 arc(30.53,90.18) 30.65,90.01 36,84.66 arc(37.59,83.59) 39.47,83.22 51.22,83.22 arc(55.43,82.38) 59.01,80 61.03,77.97 arc(62.01,77.32) 63.17,77.09 68.98,77.09 arc(70.99,76.69) 72.7,75.54 74.12,74.12 arc(74.28,74.01) 74.47,73.98 77,73.98 arc(78.61,73.66) 79.97,72.74 arc(80.65,72.29) 81.44,72.14 84.82,72.14 arc(85.58,71.99) 86.22,71.56 arc(86.4,71.43) 86.62,71.39 89.48,71.39 arc(90.41,71.21) 91.19,70.68 96.03,65.84 arc(97.47,64.88) 99.18,64.54 102.43,64.54 arc(106.03,63.82) 109.08,61.79 arc(109.52,61.49) 110.03,61.39 111.08,61.39 arc(112.56,61.1) 113.82,60.26 114.59,59.48 arc(114.96,58.93) 115.09,58.28 115.09,54.01 arc(115.12,53.87) 115.19,53.76 arc(115.4,53.45) 115.47,53.09 115.47,51.12 arc(115.74,50.47) 116.39,50.2 117.35,50.2 arc(117.65,50.14) 117.89,49.98 arc(118.05,49.74) 118.11,49.45 118.11,49.35 arc(118.08,49.17) 117.98,49.03 117.85,48.9 117.84,48.88 arc(117.78,48.8) 117.76,48.71 CONN55_PF.1L13
NIFE_RX[20]_N: length 107.6
  TOP w0.095: U40.F30 v4(27.7,102.65)
  S16 w0.102: v4(27.7,102.65) 27.7,103.01 27.63,103.08 27.48,103.08 27.29,102.89 27.29,101.2 27.32,101.18 27.32,99.06 27.28,99.02 27.28,97.47
  S16 w0.108: CONN54_PF.6T12 106.26,57.61 arc(106.27,57.69) 106.3,57.78 arc(106.3,57.78) 106.3,57.78 arc(106.34,57.84) 106.38,57.89 arc(106.48,58.04) 106.52,58.22 106.52,58.33 arc(106.4,58.91) 106.07,59.4 arc(105.84,59.75) 105.76,60.16 105.76,60.74 arc(105.66,61.22) 105.39,61.63 arc(104.95,61.92) 104.43,62.03 99.7,62.03 arc(98.08,62.35) 96.71,63.26 93.6,66.38 arc(92.43,67.16) 91.05,67.43 87.84,67.43 arc(87.62,67.47) 87.44,67.6 arc(86.79,68.03) 86.04,68.18 85.15,68.18 arc(82.61,68.68) 80.46,70.12 80.26,70.32 arc(79.46,70.86) 78.52,71.04 73.07,71.04 arc(72.54,71.26) 72.32,71.79 72.32,72.79 arc(72.21,73.35) 71.89,73.82 70.53,75.19 arc(69.74,75.71) 68.82,75.89 62.1,75.89 arc(61.1,76.09) 60.26,76.65 57.7,79.21 arc(54.48,81.37) 50.68,82.12 37.92,82.12 arc(37.02,82.3) 36.25,82.81 28.24,90.83 arc(28.03,91.14) 27.96,91.5 27.96,95.71 arc(27.85,96.23) 27.56,96.67 27.49,96.74 arc(27.34,96.97) 27.28,97.25 27.28,97.47
NIFE_RX[20]_P: length 107.7
  TOP w0.095: U40.G30 v4(27.7,103.65)
  S16 w0.102: 27.05,97.47 27.05,97.48 27.08,97.5 27.08,97.55 27.08,97.55 27.08,99.11 27.11,99.14 27.11,101.09 27.08,101.12 27.08,103.01 27.36,103.28 27.63,103.28 27.7,103.35 v4(27.7,103.65)
  S16 w0.108: CONN54_PF.6T13 105.71,58.06 arc(105.84,57.97) 106,57.94 106.02,57.94 arc(106.1,57.95) 106.16,58 106.22,58.05 arc(106.27,58.13) 106.29,58.22 106.29,58.33 arc(106.19,58.82) 105.91,59.24 arc(105.63,59.66) 105.53,60.16 105.53,60.74 arc(105.45,61.13) 105.23,61.46 arc(104.86,61.71) 104.43,61.8 99.7,61.8 arc(97.99,62.14) 96.55,63.1 93.44,66.21 arc(92.34,66.95) 91.05,67.2 87.84,67.2 arc(87.53,67.26) 87.27,67.44 arc(86.71,67.81) 86.04,67.95 85.15,67.95 arc(82.53,68.47) 80.3,69.96 80.1,70.16 arc(79.37,70.64) 78.52,70.81 73.07,70.81 arc(72.38,71.1) 72.09,71.79 72.09,72.79 arc(72,73.26) 71.73,73.66 70.36,75.02 arc(69.66,75.5) 68.82,75.66 62.1,75.66 arc(61.01,75.88) 60.1,76.49 57.54,79.05 arc(54.39,81.16) 50.68,81.89 37.92,81.89 arc(36.93,82.09) 36.09,82.65 28.07,90.67 arc(27.82,91.05) 27.73,91.5 27.73,95.71 arc(27.64,96.14) 27.39,96.51 27.33,96.58 arc(27.13,96.88) 27.05,97.24 27.05,97.47
NIFE_RX[21]_N: length 114.4
  TOP w0.095: U40.J31 v4(26.7,105.65)
  S16 w0.102: v4(26.7,105.65) 26.7,105.35 26.6,105.25 26.34,105.25 26.08,105 26.08,103.93 26.11,103.9 26.11,101.13 26.08,101.1 26.08,99.13 26.11,99.1 26.11,97.49 26.11,97.49 26.11,97.4 26.11,97.05 26.09,97.05
  S16 w0.108: CONN54_PF.6L12 100.97,48.99 arc(101.05,48.94) 101.14,48.92 arc(101.18,48.93) 101.21,48.93 arc(101.27,48.96) 101.32,49 arc(101.49,49.41) 101.33,49.82 101.32,49.83 arc(101.18,49.92) 101.02,49.96 99.88,49.96 arc(99.15,50.26) 98.85,50.99 98.85,58.36 arc(98.31,59.68) 96.99,60.23 96.7,60.23 arc(96.45,60.27) 96.24,60.42 93.32,63.33 arc(91.77,64.37) 89.95,64.73 86.87,64.73 arc(86.28,64.85) 85.78,65.18 arc(85.55,65.33) 85.29,65.38 81.7,65.38 arc(81.31,65.46) 80.98,65.68 arc(79.09,66.94) 76.86,67.39 74.87,67.39 arc(74.59,67.44) 74.35,67.6 arc(73.66,68.06) 72.84,68.23 72.1,68.23 arc(71.86,68.27) 71.66,68.41 arc(71.12,69.21) 70.93,70.16 70.93,71.03 arc(70.29,72.58) 68.74,73.23 62.49,73.23 arc(61.21,73.48) 60.13,74.2 56.21,78.12 arc(53.3,80.06) 49.87,80.74 37.24,80.74 arc(36.95,80.76) 36.65,80.83 arc(36.16,81.04) 35.74,81.37 27.29,89.81 arc(26.82,90.5) 26.6,91.31 arc(26.6,91.4) 26.6,91.5 26.6,94.63 26.6,94.63 26.6,95.85 arc(26.56,96.05) 26.44,96.22 26.42,96.25 arc(26.17,96.62) 26.09,97.05
NIFE_RX[21]_P: length 114.4
  TOP w0.095: U40.H31 v4(26.7,104.65)
  S16 w0.102: 26.32,97.41 26.32,99.18 26.28,99.21 26.28,101.01 26.32,101.04 26.32,103.99 26.29,104.02 26.29,104.91 26.42,105.05 26.57,105.05 26.7,104.93 26.7,104.83
  S16 w0.108: 26.7,104.83 v4(26.7,104.65) ; 26.32,97.41 26.32,97.05 arc(26.38,96.7) 26.58,96.41 26.61,96.38 arc(26.77,96.14) 26.83,95.85 26.83,94.68 26.83,94.67 26.83,91.33 arc(27.02,90.6) 27.46,89.97 35.9,81.53 arc(36.28,81.24) 36.72,81.05 arc(36.98,80.99) 37.24,80.97 49.87,80.97 arc(53.39,80.27) 56.37,78.28 60.13,74.53 60.29,74.36 arc(61.3,73.69) 62.49,73.45 68.74,73.45 arc(70.45,72.74) 71.16,71.03 71.16,70.92 71.16,70.92 71.16,70.16 arc(71.33,69.3) 71.82,68.57 arc(71.95,68.48) 72.1,68.45 72.84,68.45 arc(73.75,68.27) 74.51,67.76 arc(74.68,67.65) 74.87,67.62 76.86,67.62 arc(79.18,67.15) 81.14,65.84 arc(81.4,65.67) 81.7,65.61 85.29,65.61 arc(85.64,65.54) 85.94,65.34 arc(86.36,65.06) 86.87,64.96 89.95,64.96 arc(91.86,64.58) 93.49,63.49 96.4,60.58 arc(96.54,60.49) 96.7,60.45 96.99,60.45 arc(98.47,59.84) 99.08,58.36 99.08,50.99 arc(99.32,50.42) 99.88,50.19 101,50.19 arc(101.26,50.14) 101.48,49.99 arc(101.49,49.98) 101.5,49.98 arc(101.72,49.4) 101.48,48.84 arc(101.45,48.8) 101.42,48.76 arc(101.42,48.76) 101.42,48.76 arc(101.38,48.66) 101.37,48.56 101.37,48.13 arc(101.39,48.01) CONN54_PF.6L13
NIFE_RX[22]_N: length 96.7
  TOP w0.095: U40.F32 v4(25.7,102.65)
  S16 w0.102: 25.29,97.43 25.29,97.45 25.29,97.45 25.29,97.53 25.28,97.53 25.28,99.02 25.32,99.06 25.32,101.05 25.29,101.08 25.29,102.89 25.42,103.02 25.59,103.02 25.7,102.91 v4(25.7,102.65)
  S16 w0.108: CONN54_PF.5T12 92.01,57.75 arc(92.02,57.82) 92.03,57.88 arc(92.03,57.88) 92.04,57.89 arc(92.08,57.97) 92.13,58.04 arc(92.3,58.3) 92.37,58.6 92.37,58.79 92.35,58.81 arc(92.26,59.07) 92.1,59.29 91.36,60.03 arc(91.21,60.24) 91.16,60.5 arc(90.69,61.63) 89.56,62.1 86.53,62.1 arc(85.62,62.28) 84.84,62.8 84.38,63.27 84.38,63.27 83.62,64.03 arc(83.17,64.33) 82.65,64.43 79.25,64.43 arc(78.81,64.52) 78.44,64.77 78.22,64.99 arc(77.67,65.35) 77.02,65.48 73.37,65.48 arc(72.9,65.58) 72.51,65.84 72.2,66.14 70.19,68.15 arc(69.95,68.53) 69.86,68.96 69.86,69.85 arc(69.3,71.21) 67.95,71.77 61.41,71.77 arc(60.54,71.94) 59.81,72.43 54.91,77.33 arc(52.21,79.13) 49.03,79.77 36.85,79.77 arc(36.15,79.9) 35.57,80.3 25.72,90.14 arc(25.57,90.37) 25.52,90.64 25.52,95.35 arc(25.51,95.45) 25.48,95.53 arc(25.44,95.61) 25.38,95.68 arc(25.32,95.78) 25.29,95.9 25.29,97.43
NIFE_RX[22]_P: length 96.6
  TOP w0.095: U40.G32 v4(25.7,103.65)
  S16 w0.102: v4(25.7,103.65) 25.7,103.35 25.57,103.23 25.3,103.23 25.08,103.01 25.08,101 25.11,100.97 25.11,99.14 25.08,99.11 25.08,97.44
  S16 w0.108: CONN54_PF.5T13 91.42,58.09 arc(91.53,58.03) 91.65,58 arc(91.76,58.02) 91.85,58.08 91.97,58.2 arc(92.09,58.39) 92.14,58.6 92.14,58.64 arc(92.13,58.7) 92.12,58.77 arc(92.06,58.96) 91.93,59.13 91.19,59.87 arc(91,60.16) 90.93,60.49 90.93,60.5 arc(90.53,61.47) 89.56,61.87 86.53,61.87 arc(85.53,62.07) 84.68,62.64 83.45,63.87 arc(83.08,64.11) 82.65,64.2 79.25,64.2 arc(78.72,64.31) 78.28,64.61 78.06,64.82 arc(77.58,65.14) 77.02,65.26 73.37,65.26 arc(72.82,65.37) 72.34,65.68 70.03,67.99 arc(69.73,68.44) 69.63,68.96 69.63,69.85 arc(69.14,71.04) 67.95,71.54 61.41,71.54 arc(60.46,71.73) 59.65,72.27 54.75,77.17 arc(52.12,78.92) 49.03,79.54 36.85,79.54 arc(36.07,79.69) 35.4,80.13 25.56,89.98 arc(25.36,90.28) 25.29,90.64 25.29,95.35 arc(25.27,95.44) 25.22,95.52 arc(25.1,95.69) 25.06,95.9 25.06,97.43 25.08,97.44
NIFE_RX[23]_N: length 102.9
  TOP w0.095: v4(24.7,105.65) U40.J33
  S16 w0.102: 24.09,97.37 24.11,97.39 24.11,97.44 24.11,97.44 24.11,99.05 24.08,99.08 24.08,101.11 24.11,101.14 24.11,103.9 24.08,103.93 24.08,105.03 24.3,105.25 24.6,105.25 24.7,105.35 v4(24.7,105.65)
  S16 w0.108: 24.09,97.37 24.09,97.15 arc(24.03,96.88) 23.88,96.66 23.65,96.43 arc(23.55,96.27) 23.51,96.08 23.51,90 arc(23.58,89.66) 23.77,89.38 33.48,79.67 arc(34.89,78.72) 36.55,78.39 46.51,78.39 arc(51.02,77.5) 54.85,74.94 56.77,73.02 arc(57.12,72.5) 57.24,71.88 57.24,71.46 arc(57.38,70.77) 57.76,70.19 58.56,69.4 arc(59.75,68.6) 61.16,68.32 63.4,68.32 arc(63.8,68.24) 64.13,68.02 64.16,67.99 arc(64.61,67.69) 65.13,67.59 66.87,67.59 arc(67.31,67.5) 67.68,67.25 71.57,63.36 arc(72.05,63.04) 72.62,62.93 78.67,62.93 arc(79.38,62.78) 79.99,62.38 83.86,58.51 arc(84.43,57.66) 84.63,56.66 84.63,51.14 arc(84.94,50.39) 85.69,50.08 86.71,50.08 arc(86.87,50.05) 87.01,49.95 87.18,49.79 arc(87.25,49.67) 87.28,49.54 87.28,49.36 arc(87.26,49.26) 87.2,49.17 87.04,49.01 arc(86.97,48.96) 86.89,48.95 arc(86.78,48.97) 86.69,49.03 CONN54_PF.5L12
NIFE_RX[23]_P: length 102.8
  TOP w0.095: U40.H33 v4(24.7,104.65)
  S16 w0.102: v4(24.7,104.65) 24.7,104.91 24.56,105.05 24.39,105.05 24.29,104.95 24.29,104.02 24.32,103.99 24.32,101.06 24.28,101.02 24.28,99.17 24.32,99.13 24.32,97.35
  S16 w0.108: CONN54_PF.5L13 87.21,48.76 arc(87.22,48.8) 87.22,48.83 arc(87.22,48.83) 87.22,48.83 arc(87.25,48.89) 87.28,48.93 87.36,49.01 arc(87.47,49.17) 87.51,49.36 87.51,49.54 arc(87.46,49.76) 87.34,49.95 87.17,50.11 arc(86.96,50.26) 86.71,50.31 85.69,50.31 arc(85.1,50.55) 84.86,51.14 84.86,56.66 arc(84.64,57.75) 84.02,58.67 80.15,62.54 arc(79.47,62.99) 78.67,63.15 72.62,63.15 arc(72.14,63.25) 71.73,63.52 67.84,67.41 arc(67.4,67.71) 66.87,67.82 65.13,67.82 arc(64.7,67.9) 64.32,68.15 64.29,68.18 arc(63.88,68.46) 63.4,68.55 61.16,68.55 arc(59.84,68.81) 58.72,69.56 57.93,70.36 arc(57.59,70.86) 57.47,71.46 57.47,71.88 arc(57.33,72.58) 56.94,73.18 56.76,73.35 55.01,75.1 arc(51.11,77.71) 46.51,78.62 36.55,78.62 arc(34.97,78.94) 33.64,79.83 23.93,89.54 arc(23.79,89.75) 23.74,90 23.74,96.08 arc(23.76,96.18) 23.82,96.27 24.05,96.5 arc(24.25,96.8) 24.32,97.15 24.32,97.35
NIFE_RX[24]_N: length 111.1
  TOP w0.095: U40.J37 v4(20.7,105.65)
  S16 w0.108: v4(20.7,105.65) 20.47,105.42 arc(20.29,105.3) 20.09,105.26 19.73,105.26 arc(19.27,105.17) 18.89,104.91 arc(18.16,103.83) 17.91,102.54 17.91,84.68 arc(18.15,83.48) 18.83,82.46 22.5,78.79 arc(23.25,77.67) 23.51,76.35 23.51,75.61 arc(23.75,75.03) 24.33,74.78 26.52,74.78 arc(27.11,74.19) 26.52,73.6 24.33,73.6 arc(23.51,72.77) 24.33,71.95 26.52,71.95 arc(27.11,71.36) 26.52,70.76 24.66,70.76 arc(23.88,70.44) 23.56,69.67 23.56,69.65 arc(23.88,68.87) 24.66,68.55 30.06,68.55 arc(31.19,68.08) 31.66,66.94 arc(31.77,66.42) 32.07,65.97 34.75,63.29 arc(35.76,62.62) 36.95,62.38 37.69,62.38 arc(38.11,62.21) 38.28,61.79 38.28,60.41 arc(39.11,59.59) 39.93,60.41 39.93,61.79 arc(40.1,62.21) 40.52,62.38 50.99,62.38 arc(51.41,62.21) 51.59,61.79 51.59,61.47 arc(52.41,60.65) 53.23,61.47 53.23,61.79 arc(53.41,62.21) 53.83,62.38 55.16,62.38 arc(55.8,62.12) 56.06,61.48 56.06,51.66 arc(56.5,50.59) 57.57,50.15 58.25,50.15 arc(58.33,50.13) 58.41,50.08 58.84,49.65 arc(58.98,49.33) 58.84,49.01 58.58,48.75 arc(58.49,48.69) 58.38,48.67 arc(58.28,48.69) 58.19,48.75 58.11,48.83 arc(57.96,49.05) CONN54_PF.3L12
NIFE_RX[24]_P: length 111.1
  TOP w0.095: U40.H37 v4(20.7,104.65)
  S16 w0.108: CONN54_PF.3L13 58.71,48.38 arc(58.75,48.55) 58.84,48.68 59.01,48.85 arc(59.2,49.33) 59.01,49.81 58.57,50.24 arc(58.42,50.34) 58.25,50.38 57.57,50.38 arc(56.66,50.75) 56.29,51.66 56.29,61.48 arc(55.96,62.28) 55.16,62.61 53.83,62.61 arc(53.25,62.37) 53,61.79 53,61.47 arc(52.41,60.88) 51.82,61.47 51.82,61.79 arc(51.58,62.37) 50.99,62.61 40.52,62.61 arc(39.94,62.37) 39.7,61.79 39.7,60.41 arc(39.11,59.81) 38.51,60.41 38.51,61.79 arc(38.27,62.37) 37.69,62.61 36.95,62.61 arc(35.84,62.83) 34.91,63.45 32.23,66.13 arc(31.98,66.51) 31.89,66.94 arc(31.35,68.24) 30.06,68.78 24.66,68.78 arc(24.05,69.04) 23.79,69.65 23.79,69.67 arc(24.05,70.28) 24.66,70.54 26.52,70.54 arc(27.34,71.36) 26.52,72.18 24.33,72.18 arc(23.74,72.77) 24.33,73.37 26.52,73.37 arc(27.34,74.19) 26.52,75.01 24.33,75.01 arc(23.91,75.19) 23.74,75.61 23.74,76.35 arc(23.46,77.76) 22.66,78.95 20.84,80.78 arc(20.8,80.86) 20.84,80.95 arc(20.87,81.04) 20.84,81.13 20.63,81.33 arc(20.54,81.37) 20.46,81.33 arc(20.37,81.3) 20.28,81.33 20.07,81.54 arc(20.04,81.63) 20.07,81.72 arc(20.11,81.8) 20.07,81.89 19.87,82.1 arc(19.78,82.13) 19.69,82.1 arc(19.6,82.06) 19.52,82.1 18.99,82.62 arc(18.36,83.57) 18.14,84.68 18.14,102.64 arc(18.36,103.74) 18.98,104.68 19.05,104.75 arc(19.36,104.96) 19.73,105.03 20.09,105.03 arc(20.29,104.99) 20.47,104.87 v4(20.7,104.65)
NIFE_RX[25]_N: length 102.7
  TOP w0.095: U40.F36 v4(21.7,102.65)
  S16 w0.108: CONN54_PF.3T12 63.51,57.8 arc(63.52,57.83) 63.52,57.86 arc(63.54,57.89) 63.56,57.92 arc(63.78,58.44) 63.56,58.97 62.83,59.7 arc(62.64,59.98) 62.58,60.31 62.58,60.93 arc(62.52,61.21) 62.37,61.44 62.07,61.73 arc(61.72,61.97) 61.31,62.07 arc(60.82,62.09) 60.33,62.1 60.3,62.1 arc(59.86,62.18) 59.49,62.43 58.38,63.54 arc(56.38,64.88) 54.02,65.35 42.34,65.35 arc(41.69,66) 42.34,66.65 44.94,66.65 arc(45.53,66.89) 45.77,67.47 arc(45.53,68.06) 44.94,68.3 42.69,68.3 arc(41.98,69.01) 42.69,69.72 43.53,69.72 arc(44.08,69.95) 44.31,70.51 44.31,72.2 arc(43.91,73.17) 42.94,73.57 40.39,73.57 arc(39.94,73.66) 39.56,73.92 arc(38.98,74.3) 38.31,74.43 34.31,74.43 arc(33.73,74.19) 33.49,73.62 33.49,70.74 arc(33.28,70.22) 32.75,70 31.39,70 arc(30.87,70.22) 30.65,70.74 30.65,74.62 arc(30.55,75.13) 30.26,75.56 29.69,76.13 29.56,76.26 arc(28.54,76.95) 27.32,77.19 arc(26.88,77.28) 26.5,77.53 24.78,79.24 arc(24.62,79.64) 24.78,80.04 arc(25.02,80.62) 24.78,81.2 arc(24.2,81.44) 23.62,81.2 23.55,81.13 arc(23.22,81) 22.89,81.13 22.28,81.75 arc(21.99,82.18) 21.89,82.69 arc(21.66,83.84) 21.01,84.82 20.72,85.1 arc(19.65,86.71) 19.27,88.61 19.27,102.21 arc(19.51,102.79) 20.09,103.03 21.31,103.03 v4(21.7,102.65)
NIFE_RX[25]_P: length 102.7
  TOP w0.095: U40.G36 v4(21.7,103.65)
  S16 w0.108: CONN54_PF.3T13 62.94,58.08 62.94,58.07 arc(63.04,58.01) 63.16,57.98 arc(63.27,58) 63.36,58.05 63.4,58.08 arc(63.55,58.44) 63.4,58.81 62.66,59.54 arc(62.43,59.9) 62.35,60.31 62.35,60.93 arc(62.31,61.12) 62.2,61.28 61.91,61.57 arc(61.63,61.76) 61.3,61.84 arc(60.81,61.86) 60.33,61.87 60.3,61.87 arc(59.78,61.97) 59.33,62.27 58.22,63.38 arc(56.29,64.67) 54.02,65.12 42.34,65.12 arc(41.46,66) 42.34,66.88 44.94,66.88 arc(45.36,67.05) 45.54,67.47 arc(45.36,67.89) 44.94,68.07 42.69,68.07 arc(41.75,69.01) 42.69,69.95 43.53,69.95 arc(43.92,70.11) 44.09,70.51 44.09,72.2 arc(43.75,73.01) 42.94,73.34 40.39,73.34 arc(39.86,73.45) 39.41,73.75 arc(38.9,74.09) 38.31,74.2 34.31,74.2 arc(33.89,74.03) 33.72,73.62 33.72,70.74 arc(33.44,70.06) 32.75,69.77 31.39,69.77 arc(30.7,70.06) 30.42,70.74 30.42,74.62 arc(30.34,75.05) 30.1,75.4 29.4,76.1 arc(28.45,76.74) 27.32,76.96 arc(26.79,77.07) 26.34,77.37 24.62,79.08 arc(24.39,79.64) 24.62,80.2 arc(24.79,80.62) 24.62,81.04 arc(24.2,81.21) 23.78,81.04 23.71,80.97 arc(23.22,80.77) 22.73,80.97 22.11,81.59 arc(21.78,82.1) 21.66,82.69 arc(21.45,83.76) 20.84,84.66 20.56,84.94 arc(19.43,86.62) 19.04,88.61 19.04,102.21 arc(19.35,102.95) 20.09,103.26 21.31,103.26 v4(21.7,103.65)
NIFE_RX[26]_N: length 102.3
  TOP w0.095: U40.J35 v4(22.7,105.65)
  S16 w0.102: 20.53,102.25 20.55,102.25 20.56,102.24 20.62,102.24 20.62,102.23 21.91,102.23 22.11,102.43 22.11,105 22.35,105.24 22.59,105.24 22.7,105.35 v4(22.7,105.65)
  S16 w0.108: 20.53,102.25 20.48,102.25 arc(20.09,102.09) 19.93,101.71 19.93,97.74 arc(20,97.38) 20.21,97.08 20.27,97.01 arc(20.46,96.73) 20.53,96.39 20.53,89.38 arc(20.74,88.33) 21.33,87.44 27.04,81.73 arc(27.21,81.32) 27.04,80.91 26.89,80.77 arc(26.89,79.6) 28.06,79.6 28.19,79.74 arc(28.61,79.91) 29.03,79.74 31.73,77.04 31.73,77.04 arc(32.81,76.35) 34.08,76.11 43.96,76.11 arc(45.47,75.48) 46.09,73.97 46.09,70.79 arc(46.28,69.83) 46.82,69.02 arc(47.71,68.43) 48.75,68.22 54.53,68.22 arc(54.95,68.14) 55.31,67.9 55.35,67.86 59.43,63.78 arc(59.97,63.42) 60.6,63.29 65.06,63.29 arc(65.49,63.21) 65.86,62.96 66.98,61.85 arc(67.09,61.57) 66.98,61.29 66.43,60.74 arc(66.43,59.58) 67.59,59.58 68.12,60.1 arc(68.42,60.23) 68.72,60.1 69.88,58.95 arc(70.42,58.14) 70.61,57.18 70.61,51.44 arc(71.01,50.47) 71.98,50.07 72.63,50.07 arc(73.04,49.9) 73.21,49.5 73.21,49.35 arc(73.19,49.29) 73.16,49.25 72.71,48.79 arc(72.54,48.72) 72.38,48.79 arc(72.22,49.03) CONN54_PF.4L12
NIFE_RX[26]_P: length 102.3
  TOP w0.095: U40.H35 v4(22.7,104.65)
  S16 w0.102: v4(22.7,104.65) 22.7,104.91 22.57,105.04 22.43,105.04 22.31,104.92 22.31,102.35 22,102.03 20.54,102.03
  S16 w0.108: 20.54,102.03 20.53,102.03 20.48,102.03 arc(20.25,101.93) 20.16,101.71 20.16,97.74 arc(20.21,97.47) 20.37,97.24 20.43,97.18 arc(20.67,96.81) 20.76,96.39 20.76,96.02 arc(20.81,95.91) 20.92,95.86 arc(21.04,95.81) 21.09,95.69 21.09,95.41 arc(21.04,95.29) 20.92,95.24 arc(20.81,95.2) 20.76,95.08 20.76,89.38 arc(20.95,88.41) 21.5,87.6 27.2,81.89 arc(27.44,81.32) 27.2,80.75 27.06,80.6 arc(27.06,79.76) 27.9,79.76 28.03,79.9 arc(28.61,80.14) 29.19,79.9 31.82,77.27 31.82,77.27 arc(31.85,77.24) 31.89,77.21 arc(32.9,76.56) 34.08,76.34 43.96,76.34 arc(45.63,75.65) 46.32,73.97 46.32,70.79 arc(46.49,69.92) 46.99,69.18 46.99,69.18 arc(47.8,68.64) 48.75,68.45 54.53,68.45 arc(55.04,68.35) 55.47,68.06 55.51,68.03 59.59,63.94 arc(60.06,63.63) 60.6,63.52 65.06,63.52 arc(65.58,63.42) 66.03,63.12 67.14,62.01 arc(67.32,61.57) 67.14,61.13 66.59,60.58 arc(66.59,59.74) 67.43,59.74 67.96,60.27 arc(68.42,60.46) 68.88,60.27 70.04,59.11 arc(70.63,58.22) 70.84,57.18 70.84,51.44 arc(71.17,50.63) 71.98,50.3 72.63,50.3 arc(73.2,50.06) 73.43,49.5 73.43,49.35 arc(73.41,49.21) 73.33,49.09 72.96,48.72 arc(72.79,48.31) CONN54_PF.4L13
NIFE_RX[27]_N: length 87.5
  TOP w0.095: U40.F34 v4(23.7,102.65)
  S16 w0.102: v4(23.7,102.65) 23.7,102.88 23.62,102.96 23.44,102.96 23.29,102.81 23.29,101.18 23.32,101.16 23.32,99.13 23.29,99.11 23.29,97.33
  S16 w0.108: 23.29,97.33 23.09,97.13 arc(22.71,96.55) 22.57,95.87 22.57,89.74 arc(22.81,88.56) 23.48,87.55 32.48,78.55 arc(33.66,77.76) 35.06,77.48 44.57,77.48 arc(45.87,77.22) 46.98,76.48 arc(47.79,75.27) 48.07,73.84 48.07,73.45 arc(48.18,72.89) 48.5,72.42 48.97,71.95 arc(49.5,71.6) 50.11,71.47 53.39,71.47 arc(53.83,71.39) 54.2,71.14 55.63,69.71 arc(55.87,69.55) 56.15,69.49 56.18,69.49 arc(56.5,69.43) 56.77,69.25 60.07,65.95 arc(60.78,65.47) 61.63,65.3 66.45,65.3 arc(67.67,64.79) 68.18,63.57 68.18,63.57 arc(68.28,63.04) 68.59,62.59 68.87,62.3 arc(69.46,61.91) 70.16,61.77 75.46,61.77 arc(76.09,61.64) 76.62,61.29 76.84,61.07 76.91,61 77.04,60.87 arc(77.18,60.66) 77.23,60.41 77.23,60 arc(77.27,59.82) 77.37,59.66 77.63,59.4 77.64,59.4 78.04,59 arc(78.23,58.52) 78.04,58.05 77.73,57.74 77.7,57.72 arc(77.62,57.59) 77.59,57.44 77.59,57.32 arc(77.63,57.1) CONN54_PF.4T12
NIFE_RX[27]_P: length 87.5
  TOP w0.095: U40.G34 v4(23.7,103.65)
  S16 w0.102: 22.93,97.29 23.09,97.45 23.09,99.19 23.11,99.22 23.11,101.07 23.09,101.1 23.09,102.93 23.32,103.16 23.51,103.16 23.7,103.35 v4(23.7,103.65)
  S16 w0.108: CONN54_PF.4T13 77.15,58.12 arc(77.28,58.03) 77.43,58 77.53,58 arc(77.65,58.02) 77.76,58.09 77.87,58.21 arc(78,58.52) 77.87,58.84 77.21,59.5 arc(77.06,59.73) 77,60 77,60.41 arc(76.97,60.57) 76.88,60.71 76.75,60.84 76.46,61.12 arc(76,61.43) 75.46,61.54 70.16,61.54 arc(69.38,61.7) 68.71,62.14 68.42,62.43 arc(68.07,62.95) 67.95,63.57 67.95,63.57 arc(67.51,64.63) 66.45,65.07 61.63,65.07 arc(60.7,65.26) 59.91,65.79 56.6,69.09 arc(56.41,69.22) 56.18,69.26 56.15,69.26 arc(55.78,69.34) 55.47,69.54 54.04,70.97 arc(53.74,71.17) 53.39,71.24 50.11,71.24 arc(49.41,71.38) 48.81,71.78 48.34,72.26 arc(47.97,72.8) 47.84,73.45 47.84,73.84 arc(47.58,75.18) 46.81,76.32 arc(45.78,77.01) 44.57,77.25 35.06,77.25 arc(33.58,77.55) 32.32,78.38 23.31,87.39 arc(22.59,88.47) 22.34,89.74 22.34,95.87 arc(22.5,96.64) 22.93,97.29
NIFE_RX[32]_N: length 138.1
  TOP w0.095: v4(50.7,102.65) U40.F8
  S12 w0.102: 51.09,97.51 51.11,97.53 51.11,98.97 51.09,98.99 51.09,103.01 50.96,103.14 50.8,103.14 50.7,103.03 v4(50.7,102.65)
  S12 w0.108: 51.09,97.51 51.09,97.49 51.08,97.48 51.08,97.42 50.85,97.18 50.85,92.33 arc(50.92,91.94) 51.14,91.61 51.71,91.05 arc(52.17,90.74) 52.72,90.63 73.37,90.63 arc(74.61,90.38) 75.66,89.68 88.67,76.67 arc(89.47,76.13) 90.42,75.94 122.94,75.94 arc(124.83,75.57) 126.42,74.5 127.92,73.01 arc(128.74,72.45) 129.72,72.26 137.2,72.26 arc(137.69,72.16) 138.1,71.89 138.18,71.81 arc(138.69,71.47) 139.29,71.35 142.02,71.35 arc(142.68,71.08) 142.95,70.42 142.95,57.86 143.64,57.17 143.64,51.15 arc(143.71,50.8) 143.91,50.5 144.05,50.36 arc(144.38,50.14) 144.77,50.06 145.64,50.06 arc(145.88,50.01) 146.08,49.88 146.35,49.61 arc(146.45,49.47) 146.48,49.3 146.48,49.29 arc(146.45,49.14) 146.36,49.01 146.13,48.78 arc(146.08,48.75) 146.03,48.74 arc(145.92,48.76) 145.83,48.82 145.55,49.1 arc(145.48,49.2) CONN55_PF.3L12
NIFE_RX[32]_P: length 138.2
  TOP w0.095: U40.G8 v4(50.7,103.65)
  S12 w0.102: 51.31,97.46 51.31,99.05 51.29,99.07 51.29,103.1 51.05,103.34 50.83,103.34 50.7,103.47
  S12 w0.108: CONN55_PF.3L13 146.26,48.38 arc(146.28,48.49) 146.31,48.6 arc(146.36,48.67) 146.41,48.73 146.52,48.85 arc(146.66,49.05) 146.71,49.29 146.71,49.3 arc(146.66,49.55) 146.51,49.77 146.24,50.04 arc(145.97,50.23) 145.64,50.29 144.77,50.29 arc(144.46,50.35) 144.21,50.52 144.07,50.66 arc(143.92,50.88) 143.87,51.15 143.87,57.26 143.18,57.95 143.18,70.42 arc(142.84,71.24) 142.02,71.58 139.29,71.58 arc(138.77,71.68) 138.34,71.98 138.26,72.05 arc(137.78,72.38) 137.2,72.49 129.72,72.49 arc(128.83,72.67) 128.08,73.17 126.58,74.66 arc(124.91,75.78) 122.94,76.17 90.45,76.17 arc(89.58,76.34) 88.83,76.83 75.82,89.84 arc(74.7,90.59) 73.37,90.86 52.72,90.86 arc(52.26,90.95) 51.87,91.21 51.3,91.77 arc(51.13,92.03) 51.07,92.33 51.07,97.09 51.31,97.32 51.31,97.46 ; 50.7,103.47 v4(50.7,103.65)
