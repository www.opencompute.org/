# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NIF_N_RX02: length 181.9
  TOP w0.152: v4(48.7,103.65) U40.G10
  S14 w0.102: v4(48.7,103.65) 48.7,103.37 arc(48.74,103.27) 48.83,103.24 48.97,103.24 arc(49.19,103.14) 49.29,102.92 49.29,102.53 arc(49.37,102.33) 49.57,102.24 58.01,102.24 58.13,102.37
  S14 w0.152: CONN53_PF.1T21 216.19,66.6 arc(216.27,67.01) 216.5,67.36 216.51,67.37 arc(216.67,67.61) 216.73,67.89 216.73,68.12 arc(216.46,68.77) 215.81,69.03 204.66,69.03 arc(202.28,69.54) 200.31,70.98 200.02,71.27 arc(200,71.28) 199.98,71.3 arc(197.86,73) 195.22,73.61 193.26,73.61 arc(191.17,74.02) 189.38,75.19 189.17,75.4 arc(186.15,77.47) 182.57,78.2 137.07,78.2 127.11,82.14 arc(127.11,82.13) 127.11,82.13 126.97,82.2 arc(121.58,84.03) 115.92,84.66 107.15,84.66 97.09,87.14 88.57,87.14 arc(84.4,87.97) 80.86,90.34 75.95,95.25 arc(72.72,97.41) 68.9,98.17 64.46,98.17 arc(63.21,98.42) 62.14,99.13 59.25,102.02 arc(58.86,102.28) 58.41,102.37 58.13,102.37
NIF_N_RX03: length 192.6
  TOP w0.152: v4(49.7,106.65) U40.K9
  S14 w0.102: 58.08,106.32 58.02,106.26 49.89,106.26 arc(49.75,106.31) 49.7,106.45 v4(49.7,106.65)
  S14 w0.152: 58.08,106.32 59.09,106.32 63.59,101.82 arc(64.26,101.37) 65.06,101.22 68.37,101.22 arc(73.53,100.19) 77.91,97.27 82.72,92.46 arc(85.64,90.5) 89.1,89.81 98.92,89.81 107.91,87.3 116.27,87.3 arc(122.28,86.67) 128.02,84.81 128.01,84.81 137.63,80.92 188.81,80.92 arc(190.18,80.65) 191.33,79.88 arc(192.09,79.37) 192.98,79.2 201.94,79.2 arc(207.9,78.01) 212.95,74.63 arc(213.95,73.97) 215.13,73.73 215.67,73.73 arc(216.76,73.52) 217.69,72.9 219.7,70.89 arc(219.79,70.81) 219.86,70.72 arc(220.33,69.88) 220.49,68.93 220.49,66.56 arc(220.37,65.94) 220.02,65.42 218.82,64.22 arc(218.02,63.69) 217.07,63.5 217.07,63.5 arc(216.83,63.45) 216.62,63.31 216.4,63.09 arc(216.24,62.85) 216.19,62.58 CONN53_PF.1T18
NIF_N_RX04: length 191.7
  TOP w0.152: v4(42.7,102.65) U40.F16
  S14 w0.102: v4(42.7,102.65) 42.7,102.97 42.78,103.04 42.98,103.04 43.08,102.94 43.08,98.97 43.11,98.94 43.11,97.31
  S14 w0.108: 43.11,97.31 43.1,97.31 43.1,97.26
  S14 w0.152: 43.1,97.26 43.1,96.9 arc(43.19,96.45) 43.45,96.07 44.58,94.94 arc(44.74,94.7) 44.8,94.41 arc(44.94,93.68) 45.35,93.07 45.72,92.69 arc(46.16,92.4) 46.67,92.3 65.43,92.3 arc(71.63,91.07) 76.88,87.56 arc(82.26,83.96) 88.61,82.7 93.28,82.7 105.44,80.02 105.62,80.03 105.62,80.03 105.76,80.03 111.5,80.03 arc(114.49,79.66) 117.31,78.56 130.55,73.04 130.55,73.04 arc(131.75,72.72) 132.99,72.62 134.22,72.62 arc(135.86,72.4) 137.4,71.81 arc(137.46,71.77) 137.53,71.74 arc(139.54,71.08) 141.65,70.86 148.4,70.86 arc(149.89,70.57) 151.14,69.73 151.73,69.14 arc(153.56,67.92) 155.73,67.49 158.92,67.49 arc(159.65,67.38) 160.32,67.08 160.98,66.41 arc(162.15,65.66) 163.52,65.4 193.08,65.4 arc(195.06,65.03) 196.77,63.96 200.55,60.18 arc(200.96,59.58) 201.11,58.87 arc(201.22,58.21) 201.56,57.62 arc(201.65,57.51) 201.76,57.42 202.11,57.06 arc(202.13,57.04) 202.15,57.03 arc(203.02,56.53) 204,56.36 210.28,56.36 arc(211.16,56.54) 211.91,57.04 212.88,58 arc(212.98,58.07) 213.09,58.11 arc(213.12,58.11) 213.14,58.11 CONN53_PF.1B24
NIF_N_RX05: length 195.6
  TOP w0.152: v4(43.7,106.65) U40.K15
  S14 w0.102: v4(43.7,106.65) 43.7,106.53 arc(43.78,106.34) 43.97,106.27 arc(44.21,106.16) 44.32,105.92 44.32,105.63 arc(44.43,105.35) 44.71,105.23 45.75,105.23 arc(46.14,105.07) 46.31,104.67 46.31,104.17 46.28,104.14 46.28,101.98 46.32,101.95 46.32,98.96 46.28,98.93 46.28,97.16 46.32,97.13
  S14 w0.152: CONN53_PF.1B21 216.19,58.44 arc(216.21,58.66) 216.29,58.88 arc(216.37,59.01) 216.47,59.13 arc(216.66,59.42) 216.73,59.75 216.73,60 arc(216.41,60.77) 215.64,61.08 203.83,61.08 arc(203.11,61.18) 202.44,61.45 202.01,61.88 arc(201.76,62.21) 201.67,62.61 arc(201.67,62.66) 201.66,62.71 arc(201.51,63.18) 201.22,63.58 198.32,66.48 arc(198.27,66.52) 198.23,66.57 arc(196.82,67.75) 195.04,68.17 180.91,68.17 arc(179.14,68.56) 177.7,69.66 177.46,69.9 177.56,69.79 arc(175.85,70.87) 173.85,71.24 155.39,71.24 arc(154.25,71.44) 153.24,71.99 153.09,72.15 arc(153.06,72.17) 153.04,72.2 arc(151.56,73.26) 149.77,73.63 142.15,73.63 arc(140.82,73.76) 139.52,74.12 139.53,74.12 129.11,77.89 122.04,80.45 arc(121.96,80.49) 121.88,80.51 arc(117.67,81.51) 113.35,81.84 106.44,81.84 94.39,84.4 89.17,84.4 arc(83.16,85.6) 78.07,89 77.28,89.79 arc(71.54,93.62) 64.77,94.97 58.03,94.97 arc(56.83,95.2) 55.81,95.86 55.69,95.98 arc(55.01,96.43) 54.21,96.59 46.62,96.59 46.32,96.89 46.32,97.13
NIF_N_RX06: length 204.1
  TOP w0.152: v4(44.7,103.65) U40.G14
  S14 w0.102: 42.06,97.43 42.08,97.45 42.08,99.09 42.11,99.12 42.11,101.98 42.08,102.01 42.08,104 42.32,104.24 43.93,104.24 44.28,103.89 44.28,103.33 44.37,103.24 44.56,103.24 44.7,103.37 v4(44.7,103.65)
  S14 w0.108: 42.06,97.43 41.9,97.27 41.9,97.25
  S14 w0.152: 41.9,97.25 41.65,97 41.65,95.41 arc(41.76,94.84) 42.08,94.36 45.45,90.99 arc(45.94,90.66) 46.51,90.55 65.47,90.55 arc(70.81,89.58) 75.46,86.79 75.92,86.34 arc(81.6,82.54) 88.31,81.2 93.21,81.2 105.5,78.64 105.86,78.64 108.7,78.64 arc(110,78.54) 111.27,78.26 118.73,76.05 arc(120.09,75.46) 121.27,74.56 123.63,72.2 124.11,71.72 arc(128.12,69.04) 132.86,68.09 145.25,68.09 arc(146.58,67.82) 147.69,67.05 148.8,65.95 arc(149.95,65.12) 151.3,64.69 arc(151.37,64.69) 151.45,64.69 151.53,64.69 arc(152.86,64.36) 153.89,63.46 arc(153.89,63.45) 153.9,63.43 153.91,63.43 arc(155.46,62.28) 157.34,61.87 189.83,61.87 arc(191.38,61.53) 192.63,60.55 195.51,57.67 195.49,57.7 arc(196.04,56.94) 196.23,56.03 196.23,55.6 arc(196.42,54.65) 196.95,53.83 199.39,51.4 arc(200.63,50.63) 202.07,50.37 210.86,50.37 arc(212.39,51) 213.02,52.53 213.02,54.2 213.22,54.4 213.5,54.4 CONN53_PF.1B15
NIF_N_RX07: length 208.5
  TOP w0.152: v4(45.7,106.65) U40.K13
  S14 w0.102: v4(45.7,106.65) 45.7,106.44 45.89,106.25 45.98,106.25 46.11,106.37 46.11,106.99 46.38,107.26 57.75,107.26 57.75,107.26 57.98,107.26 57.98,107.26 58.28,107.26 58.41,107.39
  S14 w0.152: 58.41,107.39 64.8,107.39 arc(69.36,106.48) 73.23,103.9 83.77,93.36 arc(86.23,91.71) 89.13,91.13 99.73,91.13 109.21,88.64 118.28,88.64 arc(123.15,88.15) 127.83,86.67 arc(128.38,86.43) 128.93,86.16 arc(129.04,86.12) 129.14,86.07 129.14,86.07 138.13,82.22 194.3,82.22 arc(200.84,81.69) 207.22,80.13 207.31,80.09 210.28,78.83 212.8,77.51 arc(213.53,77.18) 214.3,76.93 arc(217.09,75.76) 219.5,73.91 220.85,72.56 arc(221.82,71.1) 222.16,69.38 222.16,60.9 arc(221.28,58.32) 219.04,56.78 arc(217.82,56.25) 216.77,55.44 216.77,55.44 216.19,54.86 CONN53_PF.1B18
NIF_N_TX00: length 180
  TOP w0.152: U40.B12 v4(46.7,98.65)
  S16 w0.102: 47.44,97.32 47.32,97.45 47.32,97.78 arc(47.2,98.06) 46.92,98.18 arc(46.76,98.24) 46.7,98.4
  S16 w0.108: 46.7,98.4 v4(46.7,98.65)
  S16 w0.152: CONN53_PF.1T5 205.79,62.87 arc(205.77,62.77) 205.73,62.67 arc(205.69,62.61) 205.64,62.55 204.56,61.47 204.46,61.38 arc(204.34,61.31) 204.2,61.29 203.51,61.29 arc(203.04,61.38) 202.64,61.65 201.65,62.64 arc(201.53,62.81) 201.49,63.01 201.49,63.27 arc(201.4,63.72) 201.15,64.11 199.59,65.66 arc(199.29,66.11) 199.19,66.64 199.19,67.98 arc(199.05,68.66) 198.67,69.24 194.86,73.05 arc(194.45,73.32) 193.98,73.41 arc(193.69,73.47) 193.46,73.63 187.97,79.11 arc(186.72,79.95) 185.24,80.24 138.72,80.24 arc(137.79,80.43) 136.99,80.96 133.2,84.75 arc(132.19,85.43) 131,85.66 85.59,85.66 arc(84.48,85.88) 83.55,86.51 73.95,96.1 arc(73.47,96.43) 72.89,96.54 63.9,96.54 arc(62.97,96.35) 62.18,95.83 62.17,95.82 60.87,94.51 58.74,94.51 arc(58.66,94.55) 58.63,94.63 arc(58.6,94.71) 58.52,94.74 57.98,94.74 arc(57.9,94.71) 57.87,94.63 arc(57.84,94.55) 57.76,94.51 57.18,94.51 arc(56.87,94.58) 56.6,94.75 55.95,95.41 arc(55.44,95.75) 54.84,95.87 49.13,95.87 arc(48.77,95.94) 48.46,96.14 48.21,96.4 47.44,97.17 47.44,97.32
NIF_N_TX01: length 181.7
  TOP w0.152: U40.C11 v4(47.7,99.65)
  S16 w0.102: 58.23,101.05 48.73,101.05 arc(48.43,100.93) 48.31,100.64 48.31,100.49 arc(48.18,100.16) 47.85,100.03 arc(47.74,99.99) 47.7,99.88
  S16 w0.108: 47.7,99.88 v4(47.7,99.65)
  S16 w0.152: CONN53_PF.1T34 206.12,67.17 206.35,67.17 206.68,67.5 206.68,68.78 arc(206.48,69.76) 205.93,70.59 203.74,72.78 203.74,77.34 arc(203.6,78.01) 203.22,78.58 202.01,79.79 201.74,80.06 arc(201.27,80.38) 200.73,80.48 198.17,80.48 arc(197.17,80.68) 196.32,81.25 195.46,82.11 arc(192.17,84.31) 188.29,85.08 150.38,85.08 arc(149.53,85.25) 148.81,85.73 143.28,91.27 arc(142.72,91.64) 142.07,91.77 133.51,91.77 arc(133.01,91.67) 132.58,91.38 132.43,91.22 131.7,90.5 arc(131.05,90.06) 130.29,89.91 88.36,89.91 arc(86.93,90.2) 85.72,91.01 76.65,100.08 arc(75.35,100.94) 73.83,101.24 66.61,101.24 arc(66.52,101.21) 66.48,101.11 arc(66.44,101.02) 66.35,100.98 65.85,100.98 arc(65.76,101.02) 65.72,101.11 arc(65.68,101.21) 65.59,101.24 65.09,101.24 arc(64.99,101.21) 64.95,101.11 arc(64.92,101.02) 64.82,100.98 64.32,100.98 arc(64.23,101.02) 64.19,101.11 arc(64.15,101.21) 64.06,101.24 63.56,101.24 arc(63.47,101.21) 63.43,101.11 arc(63.39,101.02) 63.3,100.98 62.8,100.98 arc(62.71,101.02) 62.67,101.11 arc(62.63,101.21) 62.54,101.24 62.04,101.24 arc(61.95,101.21) 61.91,101.11 arc(61.87,101.02) 61.78,100.98 61.28,100.98 arc(61.18,101.02) 61.14,101.11 arc(61.11,101.21) 61.01,101.24 60.1,101.24 59.87,101.02 58.27,101.02 58.23,101.05
NIF_N_TX02: length 175.1
  TOP w0.152: U40.A10 v4(48.7,97.65)
  S16 w0.102: 48.7,97.81 arc(48.76,97.96) 48.91,98.02
  S16 w0.108: v4(48.7,97.65) 48.7,97.81 ; 49.1,97.1 49.1,97.1 49.1,97.83 arc(49.04,97.96) 48.91,98.02
  S16 w0.152: 49.1,97.1 49.41,96.79 58.66,96.79 arc(59.16,96.89) 59.58,97.17 60.19,97.78 arc(60.49,97.98) 60.84,98.05 61.37,98.05 arc(61.49,98) 61.54,97.88 arc(61.58,97.77) 61.7,97.72 62.13,97.72 arc(62.25,97.77) 62.3,97.88 arc(62.35,98) 62.46,98.05 62.9,98.05 arc(63.01,98) 63.06,97.88 arc(63.11,97.77) 63.22,97.72 63.66,97.72 arc(63.77,97.77) 63.82,97.88 arc(63.87,98) 63.99,98.05 72.33,98.05 arc(73.86,97.74) 75.15,96.88 84.17,87.86 arc(84.93,87.35) 85.82,87.18 131.27,87.18 arc(132.34,86.96) 133.24,86.36 137.12,82.49 arc(138.25,81.73) 139.59,81.46 185.4,81.46 arc(187.52,81.04) 189.33,79.83 191.95,77.21 arc(192.6,76.78) 193.37,76.62 arc(193.72,76.55) 194.03,76.35 200.85,69.53 arc(201.17,69.05) 201.28,68.5 201.28,66.99 arc(201.39,66.45) 201.69,65.98 202.03,65.65 202.48,65.2 arc(202.93,64.9) 203.45,64.8 arc(203.72,64.74) 203.95,64.59 204.06,64.48 arc(204.2,64.27) 204.24,64.03 204.24,63.67 arc(204.2,63.44) 204.07,63.25 204.05,63.23 arc(203.63,63.15) CONN53_PF.1T2
NIF_N_TX03: length 175.8
  TOP w0.152: U40.C9 v4(49.7,99.65)
  S16 w0.102: 58.56,98.99 58.53,98.99 58.46,99.06 58.23,99.06 58.21,99.05 50.33,99.05 50.1,99.27 50.1,99.88 arc(50.06,100) 49.94,100.04 49.84,100.04 arc(49.74,100) 49.7,99.9 v4(49.7,99.65)
  S16 w0.152: 58.56,98.99 59.37,98.99 60.1,99.71 61.01,99.71 arc(61.1,99.68) 61.13,99.59 arc(61.17,99.5) 61.26,99.46 61.77,99.46 arc(61.86,99.5) 61.9,99.59 arc(61.93,99.68) 62.02,99.71 62.53,99.71 arc(62.62,99.68) 62.66,99.59 arc(62.7,99.5) 62.78,99.46 63.3,99.46 arc(63.38,99.5) 63.42,99.59 arc(63.46,99.68) 63.55,99.71 64.06,99.71 arc(64.15,99.68) 64.18,99.59 arc(64.22,99.5) 64.31,99.46 64.82,99.46 arc(64.91,99.5) 64.94,99.59 arc(64.98,99.68) 65.07,99.71 72.88,99.71 arc(74.29,99.43) 75.48,98.64 84.72,89.39 arc(85.64,88.78) 86.73,88.56 132.13,88.56 arc(132.81,88.7) 133.39,89.08 134.01,89.71 arc(134.58,90.08) 135.24,90.21 141.1,90.21 arc(141.73,90.09) 142.26,89.73 147.87,84.12 arc(149.05,83.33) 150.44,83.06 187.37,83.06 arc(189.13,82.71) 190.63,81.71 192.79,79.55 arc(193.76,78.9) 194.91,78.67 198.82,78.67 arc(199.26,78.58) 199.63,78.33 201.41,76.55 arc(201.66,76.18) 201.75,75.74 201.75,72.42 arc(202.04,70.95) 202.87,69.7 203.91,68.67 arc(204.15,68.3) 204.24,67.86 204.24,67.86 204.24,67.43 203.94,67.13 203.77,67.13 CONN53_PF.1T37
NIF_N_TX04: length 198.8
  TOP w0.152: U40.A16 v4(42.7,97.65)
  S16 w0.102: 42.32,97.12 42.32,97.55 42.3,97.57 42.3,97.85 arc(42.36,97.98) 42.49,98.03 arc(42.5,98.03) 42.51,98.03 42.51,98.03 arc(42.64,97.96) 42.7,97.81 v4(42.7,97.65)
  S16 w0.152: CONN53_PF.1B5 205.77,55.5 205.77,54.74 205.46,54.43 205.46,51.74 arc(205.26,51.25) 204.78,51.05 201.02,51.05 arc(200.27,51.2) 199.64,51.62 195.84,55.43 arc(195.66,55.68) 195.6,55.99 195.6,57.71 arc(195.47,58.36) 195.1,58.92 arc(194.77,59.14) 194.38,59.22 arc(194.32,59.23) 194.26,59.27 192.07,61.46 191.98,61.55 arc(191.2,62.07) 190.29,62.25 181.58,62.25 arc(181,62.37) 180.51,62.69 180.38,62.82 178.33,64.87 arc(178.08,65.24) 178,65.68 178,66.24 arc(177.71,67.68) 176.9,68.9 175.41,70.38 arc(174.68,70.87) 173.81,71.05 173.54,71.05 arc(173.26,71.1) 173.02,71.26 arc(172.64,71.52) 172.18,71.61 168.34,71.61 arc(168.08,71.56) 167.86,71.41 arc(167.68,71.29) 167.46,71.24 138.83,71.24 arc(137.73,71.46) 136.8,72.08 129.64,79.25 arc(128.72,79.86) 127.64,80.07 81,80.07 arc(80.45,80.18) 79.98,80.5 70.57,89.91 arc(69.59,90.57) 68.43,90.8 66.55,90.8 arc(65.81,90.65) 65.19,90.23 63.62,88.67 arc(63.41,88.52) 63.15,88.47 43.95,88.47 arc(43.53,88.56) 43.18,88.79 41.59,90.38 arc(41.47,90.56) 41.43,90.78 41.43,92.26 arc(41.5,92.43) 41.67,92.5 arc(41.85,92.58) 41.92,92.75 41.92,93.02 arc(41.85,93.19) 41.67,93.27 arc(41.5,93.34) 41.43,93.51 41.43,93.78 arc(41.5,93.96) 41.67,94.03 arc(41.85,94.1) 41.92,94.27 41.92,94.55 arc(41.85,94.72) 41.67,94.79 arc(41.5,94.86) 41.43,95.03 41.43,95.95 arc(41.48,96.2) 41.62,96.42 42.32,97.12
NIF_N_TX05: length 188.7
  TOP w0.152: U40.C15 v4(43.7,99.65)
  S16 w0.102: 43.4,97.3 43.4,97.31 43.31,97.4 43.31,99.91 arc(43.35,100.02) 43.45,100.06 43.54,100.06 arc(43.55,100.06) 43.56,100.06 43.57,100.06 arc(43.66,100) 43.7,99.9 v4(43.7,99.65)
  S16 w0.152: 43.4,97.3 43.4,96.7 43.19,96.49 43.19,95.57 arc(43.22,95.48) 43.32,95.45 arc(43.41,95.41) 43.44,95.32 43.44,94.81 arc(43.41,94.72) 43.32,94.68 arc(43.22,94.65) 43.19,94.56 43.19,94.05 arc(43.22,93.96) 43.32,93.92 arc(43.41,93.88) 43.44,93.79 43.44,93.29 arc(43.41,93.2) 43.32,93.16 arc(43.22,93.12) 43.19,93.03 43.19,92.27 arc(43.24,92.01) 43.39,91.78 44.85,90.32 arc(45.15,90.12) 45.51,90.04 62.68,90.04 arc(63.06,90.12) 63.39,90.34 64.55,91.5 arc(65.45,92.1) 66.51,92.32 68.98,92.32 arc(70.17,92.08) 71.18,91.4 80.65,81.93 arc(81.18,81.58) 81.8,81.45 128.65,81.45 arc(129.73,81.24) 130.65,80.63 136.83,74.45 arc(137.57,73.95) 138.45,73.78 172.13,73.78 arc(172.49,73.71) 172.8,73.5 174.29,73.5 arc(175.42,73.28) 176.37,72.64 180.33,68.68 arc(180.77,68.39) 181.29,68.28 184.22,68.28 arc(185.05,68.12) 185.75,67.65 186.62,66.78 186.72,66.68 arc(187.2,66.36) 187.75,66.25 188.5,66.25 arc(189.47,66.06) 190.29,65.51 192.08,63.72 arc(192.53,63.42) 193.06,63.31 arc(193.28,63.27) 193.46,63.15 195.43,61.17 196.44,60.16 arc(196.44,60.16) 196.44,60.16 arc(196.8,59.63) 196.92,59.01 196.92,58.69 arc(197.09,57.82) 197.58,57.09 198.76,55.91 arc(199.1,55.69) 199.49,55.61 200.5,55.61 arc(200.84,55.54) 201.13,55.35 202.1,54.38 202.24,54.24 arc(202.38,54.14) 202.55,54.11 202.74,54.11 arc(202.93,54.15) 203.1,54.26 203.23,54.39 arc(203.34,54.56) 203.39,54.77 CONN53_PF.1B2
NIF_N_TX06: length 188.1
  TOP w0.152: U40.A14 v4(44.7,97.65)
  S16 w0.102: v4(44.7,97.65) 44.7,97.96 44.61,98.04 44.42,98.04 44.28,97.91 44.28,97.24 44.38,97.14
  S16 w0.152: 44.38,97.14 44.53,96.99 arc(44.67,96.78) 44.72,96.52 44.72,92.69 arc(44.78,92.42) 44.93,92.19 45.46,91.66 arc(45.78,91.45) 46.17,91.37 62.21,91.37 arc(62.58,91.44) 62.89,91.65 63.9,92.67 arc(63.95,92.78) 63.9,92.9 arc(63.86,93.01) 63.9,93.13 64.21,93.44 arc(64.33,93.48) 64.44,93.44 64.44,93.44 arc(64.56,93.39) 64.67,93.44 64.84,93.6 arc(65.1,93.78) 65.41,93.84 69.16,93.84 arc(71.01,93.47) 72.57,92.43 81.45,83.55 arc(82.23,83.02) 83.16,82.84 129.52,82.84 arc(130.36,82.67) 131.07,82.2 136.2,77.07 arc(136.97,76.56) 137.87,76.38 175.64,76.38 arc(176.82,76.15) 177.82,75.48 178.85,74.45 181.14,72.16 arc(181.65,71.83) 182.24,71.71 184.18,71.71 arc(184.66,71.61) 185.08,71.33 186.97,69.43 arc(187.35,69.19) 187.78,69.1 191.07,69.1 arc(191.88,68.94) 192.56,68.48 195.6,65.45 196.86,64.19 arc(197.42,63.35) 197.62,62.37 197.62,62.03 arc(197.82,60.99) 198.42,60.1 198.84,59.68 arc(199.16,59.19) 199.28,58.62 199.28,58.27 arc(199.32,58.03) 199.45,57.83 199.49,57.8 199.97,57.32 arc(200.44,57) 201,56.89 203.84,56.89 arc(204.2,56.96) 204.5,57.16 206.08,58.74 206.08,59.22 CONN53_PF.1B34
NIF_N_TX07: length 186.1
  TOP w0.152: U40.C13 v4(45.7,99.65)
  S16 w0.102: 45.36,97.37 45.31,97.41 45.31,99.76 arc(45.39,99.96) 45.6,100.04 arc(45.67,100.02) 45.7,99.94 v4(45.7,99.65)
  S16 w0.152: 45.36,97.37 45.76,96.96 arc(45.98,96.64) 46.05,96.26 46.05,93.31 arc(46.24,92.86) 46.69,92.67 48.2,92.67 arc(48.34,92.73) 48.4,92.87 48.4,92.87 arc(48.45,93.01) 48.59,93.06 48.96,93.06 arc(49.1,93.01) 49.16,92.87 49.16,92.87 arc(49.22,92.73) 49.35,92.67 50.75,92.67 arc(50.93,92.75) 51,92.93 arc(51.08,93.11) 51.26,93.19 51.51,93.19 arc(51.69,93.11) 51.77,92.93 arc(51.84,92.75) 52.02,92.67 60.99,92.67 arc(61.19,92.71) 61.36,92.82 63.29,94.76 arc(63.75,95.06) 64.29,95.17 71.34,95.17 arc(72.45,94.95) 73.39,94.32 82.92,84.79 arc(83.65,84.3) 84.51,84.13 130.64,84.13 arc(131.47,83.96) 132.18,83.49 136.66,79.01 arc(137.57,78.4) 138.65,78.19 185.29,78.19 arc(186.53,77.94) 187.58,77.24 197.15,67.68 arc(197.44,67.23) 197.55,66.71 197.55,66.13 arc(197.63,65.7) 197.87,65.34 198.73,64.48 arc(199.02,64.06) 199.12,63.56 199.12,62.34 arc(199.19,61.99) 199.39,61.69 201.27,59.81 arc(201.56,59.36) 201.67,58.84 201.67,58.81 arc(201.7,58.67) 201.78,58.55 201.99,58.34 arc(202.16,58.23) 202.35,58.19 202.72,58.19 arc(202.83,58.21) 202.93,58.28 203.39,58.74 CONN53_PF.1B37
NIF_P_RX00: length 180.6
  TOP w0.152: v4(46.7,103.65) U40.G12
  S14 w0.102: 58.17,101.28 58.15,101.26 47.45,101.26 47.3,101.41 47.3,103.03 47.09,103.25 46.8,103.25 46.7,103.35 v4(46.7,103.65)
  S14 w0.152: 58.17,101.28 62.15,97.3 arc(63.14,96.63) 64.31,96.39 65.05,96.39 arc(72.1,94.99) 78.08,90.99 79.3,89.78 arc(83.73,86.81) 88.97,85.77 95.62,85.77 95.93,85.76 106.88,83.28 107.15,83.28 113.99,83.28 arc(119.69,82.77) 125.2,81.26 137.3,76.74 137.36,76.73 175.78,76.73 arc(177.91,76.33) 179.75,75.19 arc(179.76,75.19) 179.77,75.18 arc(180.92,74.39) 182.29,74.11 184.8,74.11 arc(185.83,73.9) 186.7,73.31 187.06,72.94 arc(187.97,72.44) 188.99,72.26 193.74,72.26 arc(195.99,71.81) 197.9,70.54 202.24,66.2 arc(203.6,65.38) 205.17,65.1 210.3,65.1 arc(211.2,65.23) 212.02,65.63 arc(212.11,65.71) 212.18,65.81 213.12,66.74 213.12,67.37 CONN53_PF.1T25
NIF_P_RX01: length 193
  TOP w0.152: v4(47.7,105.65) U40.J11
  S14 w0.102: v4(47.7,105.65) 47.7,105.95 arc(47.73,106.03) 47.82,106.07 48,106.07 arc(48.07,106.04) 48.1,105.97 48.1,105.6 arc(48.27,105.2) 48.67,105.03 48.68,105.03 arc(48.98,104.91) 49.11,104.61 49.11,104.59 arc(49.27,104.2) 49.66,104.04 58.2,104.04 58.28,103.96
  S14 w0.152: 58.28,103.96 58.35,103.96 arc(58.62,103.9) 58.85,103.75 58.85,103.75 62.58,100.02 arc(63.05,99.7) 63.62,99.59 63.87,99.59 arc(64.02,99.53) 64.08,99.37 arc(64.16,99.19) 64.35,99.11 64.73,99.11 arc(64.92,99.19) 65,99.37 arc(65.06,99.53) 65.21,99.59 65.7,99.59 arc(65.85,99.53) 65.91,99.37 arc(66,99.17) 66.21,99.08 66.54,99.08 arc(66.74,99.17) 66.83,99.37 arc(66.89,99.53) 67.04,99.59 68.08,99.59 arc(72.67,98.68) 76.57,96.08 81.49,91.16 arc(84.83,88.92) 88.78,88.14 98.14,88.14 107.61,85.62 116.42,85.62 arc(122.26,84.98) 127.82,83.07 137.3,79.3 137.43,79.27 185.99,79.27 arc(188.05,78.89) 189.82,77.78 190.19,77.41 arc(191.52,76.49) 193.11,76.17 198.97,76.17 arc(200.39,75.88) 201.58,75.07 204.11,72.54 arc(204.14,72.5) 204.18,72.47 arc(205.5,71.64) 207.03,71.35 214.82,71.35 arc(215.66,71.16) 216.34,70.62 217.23,69.74 arc(217.71,69.04) 217.87,68.22 217.87,67.02 arc(217.27,65.56) 215.8,64.95 215.57,64.95 arc(215.04,64.85) 214.59,64.55 214.19,64.15 214.05,63.8 214.05,63.76 arc(214.05,63.72) 214.04,63.67 arc(214,63.6) 213.96,63.54 213.78,63.36 arc(213.68,63.3) 213.57,63.27 213.38,63.27 arc(213.17,63.37) CONN53_PF.1T14
NIF_P_RX02: length 181.9
  TOP w0.152: v4(48.7,102.65) U40.F10
  S14 w0.102: v4(48.7,102.65) 48.7,102.9 arc(48.74,102.99) 48.83,103.03 48.97,103.03 arc(49.05,103) 49.08,102.92 49.08,102.53 arc(49.22,102.18) 49.57,102.04 58.04,102.04 58.05,102.04 58.1,102.04 58.12,102.02 58.13,102.02
  S14 w0.152: 58.13,102.02 58.41,102.02 arc(58.73,101.95) 59,101.77 61.89,98.88 arc(63.07,98.09) 64.46,97.81 65.38,97.81 arc(65.5,97.76) 65.56,97.64 arc(65.65,97.4) 65.89,97.3 66.14,97.3 arc(66.37,97.4) 66.47,97.64 arc(66.52,97.76) 66.65,97.81 67.21,97.81 arc(67.33,97.76) 67.39,97.64 arc(67.47,97.42) 67.69,97.33 68,97.33 arc(68.21,97.42) 68.3,97.64 arc(68.35,97.76) 68.48,97.81 68.9,97.81 arc(72.58,97.08) 75.7,95 80.61,90.09 arc(84.26,87.65) 88.57,86.79 97.04,86.79 107.1,84.3 115.92,84.3 arc(121.5,83.69) 126.82,81.87 136.94,77.87 137.07,77.85 182.57,77.85 arc(186.01,77.15) 188.92,75.16 189.13,74.94 arc(191.03,73.69) 193.26,73.25 195.22,73.25 arc(197.71,72.68) 199.7,71.08 200.12,70.66 200.04,70.74 arc(202.13,69.22) 204.66,68.68 215.81,68.68 arc(216.21,68.52) 216.37,68.12 216.37,67.89 arc(216.34,67.75) 216.26,67.62 216.15,67.51 CONN53_PF.1T22
NIF_P_RX03: length 192.5
  TOP w0.152: v4(49.7,105.65) U40.J9
  S14 w0.102: v4(49.7,105.65) 49.7,105.65 49.7,105.92 arc(49.74,106.02) 49.83,106.05 57.99,106.05 58.08,105.97
  S14 w0.152: 58.08,105.97 58.94,105.97 59.59,105.32 arc(59.61,105.26) 59.59,105.2 arc(59.52,105.04) 59.59,104.89 59.93,104.55 arc(60.08,104.49) 60.23,104.55 60.23,104.55 arc(60.3,104.58) 60.36,104.55 60.88,104.03 arc(60.91,103.97) 60.88,103.9 arc(60.8,103.71) 60.88,103.52 61.15,103.26 arc(61.34,103.18) 61.53,103.26 arc(61.59,103.28) 61.65,103.26 62.17,102.74 arc(62.2,102.67) 62.17,102.61 62.17,102.61 arc(62.09,102.42) 62.17,102.23 62.44,101.96 arc(62.63,101.88) 62.82,101.96 arc(62.88,101.99) 62.95,101.96 63.34,101.57 arc(64.13,101.05) 65.06,100.86 68.37,100.86 arc(73.39,99.86) 77.65,97.01 82.46,92.2 arc(85.51,90.17) 89.1,89.46 98.87,89.46 107.86,86.94 116.27,86.94 arc(122.2,86.32) 127.88,84.48 137.5,80.59 137.63,80.57 188.81,80.57 arc(190.04,80.32) 191.08,79.63 arc(191.95,79.05) 192.98,78.84 201.94,78.84 arc(207.76,77.68) 212.7,74.38 arc(213.81,73.64) 215.13,73.38 215.67,73.38 arc(216.62,73.19) 217.44,72.65 219.59,70.5 arc(219.99,69.76) 220.13,68.93 220.13,66.56 arc(220.04,66.08) 219.76,65.67 218.57,64.47 arc(217.88,64.01) 217.07,63.85 217.07,63.85 arc(216.69,63.78) 216.37,63.56 arc(216.27,63.52) 216.18,63.51 CONN53_PF.1T17
NIF_P_RX04: length 191.7
  TOP w0.152: v4(42.7,103.65) U40.G16
  S14 w0.102: 43.4,97.31 43.31,97.4 43.31,99.03 43.29,99.05 43.29,103.02 43.06,103.25 42.8,103.25 42.7,103.35 v4(42.7,103.65)
  S14 w0.152: 43.4,97.31 43.46,97.25 43.46,96.9 arc(43.52,96.58) 43.7,96.32 44.83,95.19 arc(45.07,94.83) 45.15,94.41 arc(45.27,93.82) 45.6,93.32 45.97,92.95 arc(46.3,92.73) 46.67,92.66 65.43,92.66 arc(71.76,91.4) 77.13,87.81 77.13,87.81 arc(82.4,84.29) 88.61,83.06 93.36,83.06 93.36,83.05 105.48,80.38 105.61,80.38 105.61,80.38 105.76,80.39 111.5,80.39 arc(114.58,80) 117.48,78.87 arc(117.54,78.84) 117.61,78.82 130.67,73.38 arc(131.81,73.07) 132.99,72.97 134.23,72.97 arc(135.95,72.74) 137.57,72.12 arc(137.63,72.09) 137.68,72.06 arc(139.62,71.43) 141.65,71.22 148.4,71.22 arc(150.02,70.9) 151.4,69.98 151.98,69.39 arc(153.7,68.24) 155.73,67.84 158.92,67.84 arc(159.75,67.72) 160.51,67.38 arc(160.56,67.34) 160.6,67.29 161.23,66.67 arc(162.28,65.99) 163.52,65.76 193.08,65.76 arc(195.19,65.36) 197.01,64.22 arc(197.08,64.14) 197.16,64.07 200.79,60.44 arc(201.29,59.73) 201.46,58.87 arc(201.56,58.33) 201.83,57.85 202.38,57.3 arc(203.14,56.87) 204,56.72 210.28,56.72 arc(211.03,56.86) 211.66,57.29 212.8,58.43 arc(212.94,58.63) 212.99,58.87 CONN53_PF.1B25
NIF_P_RX05: length 195.6
  TOP w0.152: v4(43.7,105.65) U40.J15
  S14 w0.102: 45.96,97.13 46.08,97.24 46.08,99.01 46.11,99.05 46.11,101.87 46.08,101.9 46.08,104.23 46.1,104.25 46.1,104.67 arc(46,104.93) 45.75,105.03 44.71,105.03 arc(44.29,105.21) 44.11,105.63 44.11,105.92 arc(44.07,106.02) 43.97,106.06 43.89,106.06 arc(43.75,106.01) 43.7,105.87 v4(43.7,105.65)
  S14 w0.152: 45.96,97.13 45.96,96.75 46.47,96.24 49.17,96.24 arc(49.25,96.2) 49.29,96.12 arc(49.36,95.94) 49.55,95.86 49.93,95.86 arc(50.12,95.94) 50.2,96.12 arc(50.23,96.2) 50.31,96.24 51,96.24 arc(51.08,96.2) 51.11,96.12 arc(51.17,95.99) 51.3,95.93 51.84,95.93 arc(51.97,95.99) 52.03,96.12 arc(52.06,96.2) 52.14,96.24 54.21,96.24 arc(54.88,96.11) 55.44,95.73 55.57,95.6 arc(56.7,94.87) 58.03,94.61 64.77,94.61 arc(71.41,93.29) 77.03,89.53 77.82,88.75 arc(83.03,85.27) 89.17,84.05 94.35,84.05 106.4,81.48 113.35,81.48 arc(117.61,81.15) 121.77,80.17 129.23,77.47 129.23,77.47 129.47,77.39 139.39,73.8 139.4,73.79 arc(140.75,73.41) 142.15,73.28 149.77,73.28 arc(151.41,72.93) 152.77,71.96 153.04,71.69 153.02,71.72 arc(154.13,71.1) 155.39,70.89 173.85,70.89 arc(175.72,70.54) 177.32,69.53 177.42,69.43 arc(177.43,69.43) 177.43,69.43 arc(179,68.24) 180.91,67.82 195.04,67.82 arc(196.66,67.43) 197.95,66.35 200.97,63.33 arc(201.19,63.02) 201.31,62.66 201.31,62.61 arc(201.43,62.06) 201.78,61.61 arc(201.79,61.6) 201.79,61.59 202.17,61.21 arc(202.22,61.17) 202.26,61.14 arc(203.02,60.83) 203.83,60.73 215.64,60.73 arc(216.16,60.51) 216.37,60 216.37,59.75 arc(216.33,59.55) 216.22,59.38 216.04,59.21 arc(215.99,59.17) 215.92,59.15 215.74,59.15 215.39,59.51 CONN53_PF.1B22
NIF_P_RX06: length 204.1
  TOP w0.152: v4(44.7,102.65) U40.F14
  S14 w0.102: v4(44.7,102.65) 44.7,102.81 44.48,103.03 44.29,103.03 44.08,103.24 44.08,103.8 43.85,104.04 42.4,104.04 42.29,103.92 42.29,102.09 42.31,102.07 42.31,99.03 42.29,99.01 42.29,97.37 42.28,97.37 42.28,97.33 42.26,97.3
  S14 w0.108: 42.15,97 42.15,97.19 42.26,97.3
  S14 w0.152: 42.15,97 42,96.85 42,95.41 arc(42.09,94.98) 42.33,94.62 45.71,91.24 arc(46.08,90.99) 46.51,90.9 47.24,90.9 arc(47.34,90.94) 47.38,91.04 arc(47.47,91.24) 47.67,91.33 48.01,91.33 arc(48.22,91.24) 48.3,91.04 arc(48.34,90.94) 48.44,90.9 49.07,90.9 arc(49.17,90.94) 49.21,91.04 arc(49.28,91.2) 49.43,91.26 49.91,91.26 arc(50.06,91.2) 50.13,91.04 arc(50.17,90.94) 50.27,90.9 65.47,90.9 arc(70.94,89.91) 75.7,87.06 76.17,86.59 arc(81.74,82.86) 88.31,81.56 93.25,81.56 105.57,78.98 105.86,78.99 108.7,78.99 arc(110.05,78.89) 111.37,78.6 118.83,76.39 arc(120.27,75.76) 121.52,74.82 123.7,72.63 124.36,71.97 arc(128.26,69.37) 132.86,68.45 145.25,68.45 arc(146.72,68.15) 147.95,67.3 149.05,66.2 arc(150.11,65.44) 151.35,65.05 151.53,65.05 arc(153.02,64.68) 154.18,63.66 arc(155.61,62.6) 157.34,62.23 189.83,62.23 arc(191.53,61.85) 192.9,60.78 arc(192.99,60.68) 193.09,60.59 195.72,57.96 arc(196.36,57.09) 196.59,56.03 196.59,55.6 arc(196.75,54.78) 197.21,54.08 199.63,51.66 arc(200.77,50.96) 202.07,50.72 210.86,50.72 arc(212.14,51.25) 212.66,52.53 212.66,54.35 213.31,54.99 213.31,55.18 CONN53_PF.1B14
NIF_P_RX07: length 208.6
  TOP w0.152: v4(45.7,105.65) U40.J13
  S14 w0.102: v4(45.7,105.65) 45.7,105.83 45.92,106.04 46.07,106.04 46.31,106.29 46.31,106.91 46.46,107.06 58.39,107.06 58.41,107.03
  S14 w0.152: 58.41,107.03 61.34,107.03 arc(61.5,106.97) 61.57,106.8 arc(61.63,106.64) 61.8,106.58 62.25,106.58 arc(62.42,106.64) 62.48,106.8 arc(62.55,106.97) 62.71,107.03 63.17,107.03 arc(63.33,106.97) 63.4,106.8 arc(63.46,106.64) 63.63,106.58 64.08,106.58 arc(64.24,106.64) 64.31,106.8 arc(64.38,106.97) 64.54,107.03 64.8,107.03 arc(69.23,106.15) 72.98,103.65 83.52,93.11 arc(86.09,91.38) 89.13,90.78 99.69,90.78 109.16,88.29 118.28,88.29 arc(123.08,87.8) 127.69,86.35 arc(128.23,86.1) 128.77,85.85 138.06,81.86 194.3,81.86 arc(200.79,81.34) 207.1,79.79 207.19,79.76 210.13,78.51 212.63,77.19 212.64,77.19 arc(213.4,76.85) 214.2,76.59 arc(216.92,75.45) 219.25,73.66 220.6,72.31 arc(221.49,70.97) 221.81,69.38 221.81,60.91 arc(221,58.54) 218.94,57.12 arc(217.64,56.56) 216.51,55.69 arc(216.51,55.69) 216.51,55.69 216.03,55.2 215.7,55.2 215.39,55.51 CONN53_PF.1B17
NIF_P_TX00: length 180.1
  TOP w0.152: U40.A12 v4(46.7,97.65)
  S16 w0.102: 47.08,97.37 47.11,97.4 47.11,97.41 47.11,97.42 47.11,97.48 47.11,97.48 47.11,97.78 arc(47.06,97.92) 46.92,97.97 46.89,97.97 arc(46.75,97.92) 46.7,97.78
  S16 w0.108: 46.7,97.78 v4(46.7,97.65)
  S16 w0.152: 47.08,97.37 47.08,97.02 48.21,95.89 arc(48.64,95.61) 49.13,95.51 54.84,95.51 arc(55.31,95.42) 55.7,95.16 56.35,94.5 arc(56.73,94.25) 57.18,94.16 61.02,94.16 62.43,95.57 arc(63.11,96.03) 63.9,96.18 72.89,96.18 arc(73.33,96.1) 73.7,95.85 83.29,86.26 arc(84.35,85.55) 85.59,85.31 131,85.31 arc(132.05,85.1) 132.95,84.5 136.74,80.71 arc(137.65,80.1) 138.72,79.89 185.24,79.89 arc(186.58,79.62) 187.72,78.86 193.21,73.38 arc(193.56,73.14) 193.98,73.06 arc(194.32,72.99) 194.61,72.79 198.42,68.98 arc(198.73,68.53) 198.83,67.98 198.83,66.64 arc(198.97,65.97) 199.34,65.41 200.89,63.86 arc(201.08,63.59) 201.14,63.27 201.14,63.01 arc(201.21,62.67) 201.4,62.39 202.38,61.4 arc(202.9,61.05) 203.51,60.93 204.2,60.93 arc(204.46,60.98) 204.68,61.11 204.8,61.2 205.89,62.29 arc(205.91,62.32) 205.93,62.34 arc(206.08,62.42) 206.24,62.45 206.25,62.45 arc(206.49,62.35) CONN53_PF.1T6
NIF_P_TX01: length 181.7
  TOP w0.152: U40.D11 v4(47.7,100.65)
  S16 w0.102: 57.96,101.33 57.88,101.26 48.73,101.26 arc(48.29,101.08) 48.11,100.64 48.11,100.49 arc(48.03,100.31) 47.85,100.23 47.83,100.24 arc(47.74,100.29) 47.7,100.39 v4(47.7,100.65)
  S16 w0.152: 57.96,101.33 58,101.37 59.72,101.37 59.95,101.6 73.83,101.6 arc(75.49,101.27) 76.9,100.33 85.97,91.26 arc(87.07,90.52) 88.36,90.27 130.29,90.27 arc(130.92,90.39) 131.45,90.75 132.18,91.47 132.33,91.63 arc(132.87,91.99) 133.51,92.12 142.07,92.12 arc(142.86,91.96) 143.53,91.52 149.06,85.98 arc(149.67,85.58) 150.38,85.44 188.29,85.44 arc(192.3,84.64) 195.71,82.36 196.57,81.5 arc(197.3,81.01) 198.17,80.84 200.73,80.84 arc(201.41,80.7) 201.99,80.32 202.26,80.05 203.47,78.83 arc(203.93,78.15) 204.09,77.34 204.09,72.93 206.18,70.85 arc(206.81,69.9) 207.03,68.78 207.03,67.35 206.36,66.68 206.36,66.33 CONN53_PF.1T33
NIF_P_TX02: length 175.1
  TOP w0.152: U40.B10 v4(48.7,98.65)
  S16 w0.102: 48.91,98.23 48.8,98.23 arc(48.73,98.26) 48.7,98.34 48.7,98.45
  S16 w0.108: 49.36,97.35 49.31,97.4 49.31,97.83 arc(49.19,98.11) 48.91,98.23 ; 48.7,98.45 v4(48.7,98.65)
  S16 w0.152: CONN53_PF.1T3 204.19,62.71 arc(204.21,62.85) 204.29,62.97 204.29,62.97 arc(204.3,62.98) 204.31,62.98 204.32,63 arc(204.53,63.31) 204.6,63.67 204.6,64.03 arc(204.52,64.41) 204.31,64.73 204.2,64.84 arc(203.86,65.07) 203.45,65.15 arc(203.06,65.23) 202.73,65.45 201.95,66.24 arc(201.71,66.58) 201.63,66.99 201.63,68.5 arc(201.5,69.19) 201.1,69.78 194.28,76.6 arc(193.86,76.88) 193.37,76.98 arc(192.74,77.11) 192.2,77.46 189.58,80.08 arc(187.66,81.36) 185.4,81.82 139.59,81.82 arc(138.39,82.06) 137.37,82.74 133.5,86.61 arc(132.47,87.29) 131.27,87.53 85.82,87.53 arc(85.06,87.68) 84.42,88.11 75.4,97.13 arc(73.99,98.07) 72.33,98.4 60.84,98.4 arc(60.35,98.3) 59.93,98.03 59.33,97.42 arc(59.02,97.22) 58.66,97.14 49.56,97.14 49.36,97.35
NIF_P_TX03: length 175.9
  TOP w0.152: U40.D9 v4(49.7,100.65)
  S16 w0.102: 58.56,99.34 58.53,99.34 58.46,99.26 58.23,99.26 58.22,99.28 58.05,99.28 58.03,99.25 50.41,99.25 50.31,99.35 50.31,99.88 arc(50.2,100.14) 49.94,100.25 49.86,100.25 arc(49.74,100.29) 49.7,100.41 v4(49.7,100.65)
  S16 w0.152: 58.56,99.34 59.22,99.34 59.95,100.07 72.88,100.07 arc(74.42,99.76) 75.73,98.89 84.97,89.65 arc(85.78,89.11) 86.73,88.92 132.13,88.92 arc(132.68,89.02) 133.14,89.33 133.76,89.96 arc(134.44,90.41) 135.24,90.57 141.1,90.57 arc(141.86,90.42) 142.51,89.99 148.13,84.37 arc(149.19,83.66) 150.44,83.41 187.37,83.41 arc(189.27,83.04) 190.88,81.96 193.04,79.8 arc(193.9,79.23) 194.91,79.03 198.82,79.03 arc(199.4,78.91) 199.88,78.59 201.67,76.8 arc(201.99,76.31) 202.1,75.74 202.1,72.42 202.11,72.42 arc(202.37,71.08) 203.13,69.95 204.16,68.92 arc(204.48,68.43) 204.6,67.86 204.6,67.28 204.19,66.87 CONN53_PF.1T36
NIF_P_TX04: length 198.9
  TOP w0.152: U40.B16 v4(42.7,98.65)
  S16 w0.102: 42.06,97.35 42.1,97.39 42.1,97.85 arc(42.22,98.13) 42.5,98.23 arc(42.64,98.3) 42.7,98.45 v4(42.7,98.65)
  S16 w0.152: CONN53_PF.1B6 206.21,54.49 206.02,54.49 205.82,54.28 205.82,51.74 arc(205.51,51) 204.78,50.7 201.02,50.7 arc(200.14,50.87) 199.39,51.37 195.58,55.18 arc(195.34,55.55) 195.25,55.99 195.25,57.71 arc(195.15,58.23) 194.85,58.67 194.85,58.67 arc(194.64,58.81) 194.38,58.86 arc(194.18,58.9) 194.01,59.02 193.83,59.19 193.29,59.73 191.81,61.21 191.73,61.3 arc(191.06,61.74) 190.28,61.9 181.58,61.9 arc(180.87,62.04) 180.26,62.44 178.08,64.62 arc(177.75,65.11) 177.64,65.68 177.64,66.24 arc(177.38,67.55) 176.64,68.65 175.16,70.13 arc(174.54,70.55) 173.81,70.69 173.54,70.69 arc(173.12,70.77) 172.77,71.01 arc(172.5,71.19) 172.18,71.25 168.34,71.25 arc(168.22,71.23) 168.11,71.16 arc(167.81,70.96) 167.46,70.89 138.83,70.89 arc(137.6,71.13) 136.55,71.83 129.39,78.99 arc(128.59,79.53) 127.64,79.72 81,79.72 arc(80.31,79.86) 79.73,80.25 70.31,89.66 arc(69.45,90.24) 68.43,90.44 66.55,90.44 arc(65.95,90.32) 65.44,89.98 63.88,88.42 arc(63.54,88.19) 63.15,88.12 43.95,88.12 arc(43.4,88.23) 42.93,88.54 41.34,90.13 arc(41.14,90.42) 41.07,90.78 41.07,95.95 arc(41.15,96.34) 41.37,96.67 42.06,97.35
NIF_P_TX05: length 188.7
  TOP w0.152: U40.D15 v4(43.7,100.65)
  S16 w0.102: 43.04,97.3 43.1,97.36 43.1,99.91 arc(43.21,100.16) 43.45,100.26 arc(43.63,100.33) 43.7,100.51 v4(43.7,100.65)
  S16 w0.152: CONN53_PF.1B3 203.6,54.11 arc(203.46,54.08) 203.35,54 arc(203.07,53.82) 202.74,53.75 202.55,53.75 arc(202.25,53.81) 201.99,53.99 200.88,55.1 arc(200.71,55.21) 200.5,55.25 199.49,55.25 arc(198.96,55.36) 198.51,55.66 197.33,56.83 arc(196.76,57.69) 196.56,58.69 196.56,59.01 arc(196.47,59.5) 196.19,59.91 195.41,60.69 193.21,62.89 arc(193.14,62.94) 193.06,62.96 arc(192.39,63.09) 191.83,63.47 190.04,65.25 arc(189.33,65.73) 188.5,65.89 187.75,65.89 arc(187.06,66.03) 186.47,66.42 186.37,66.53 185.5,67.4 arc(184.91,67.79) 184.22,67.93 181.29,67.93 arc(180.63,68.06) 180.08,68.43 176.12,72.39 arc(175.28,72.95) 174.29,73.15 172.65,73.15 172.54,73.25 arc(172.35,73.38) 172.13,73.42 138.45,73.42 arc(137.43,73.62) 136.58,74.2 130.4,80.37 arc(129.6,80.91) 128.65,81.1 81.8,81.1 arc(81.04,81.25) 80.4,81.68 70.93,91.15 arc(70.03,91.75) 68.98,91.96 66.51,91.96 arc(65.59,91.78) 64.8,91.25 63.64,90.09 arc(63.2,89.79) 62.68,89.69 45.51,89.69 arc(45.02,89.79) 44.6,90.07 43.14,91.53 arc(42.91,91.87) 42.83,92.27 42.83,96.64 43.04,96.85 43.04,97.3
NIF_P_TX06: length 188
  TOP w0.152: U40.B14 v4(44.7,98.65)
  S16 w0.102: 44.11,96.9 44.08,96.94 44.08,97.99 44.33,98.25 44.6,98.25 44.7,98.34 v4(44.7,98.65)
  S16 w0.152: CONN53_PF.1B33 205.95,58.11 204.75,56.91 arc(204.33,56.64) 203.84,56.54 201,56.54 arc(200.3,56.68) 199.72,57.07 199.24,57.55 199.2,57.58 arc(198.99,57.9) 198.92,58.27 198.92,58.62 arc(198.83,59.06) 198.58,59.43 198.16,59.85 arc(197.49,60.85) 197.26,62.03 197.26,62.37 arc(197.09,63.21) 196.61,63.93 195.35,65.2 192.31,68.23 arc(191.74,68.61) 191.07,68.75 187.78,68.75 arc(187.21,68.86) 186.72,69.18 184.82,71.08 arc(184.53,71.28) 184.18,71.35 182.24,71.35 arc(181.51,71.5) 180.89,71.91 177.57,75.23 arc(176.69,75.82) 175.64,76.03 137.87,76.03 arc(136.84,76.23) 135.95,76.81 130.82,81.95 arc(130.23,82.34) 129.52,82.48 83.16,82.48 arc(82.1,82.7) 81.2,83.3 72.32,92.18 arc(70.87,93.14) 69.16,93.48 65.41,93.48 arc(65.24,93.45) 65.09,93.35 63.14,91.4 arc(62.71,91.12) 62.21,91.01 46.17,91.01 arc(45.65,91.12) 45.21,91.41 44.68,91.94 arc(44.45,92.29) 44.37,92.69 44.37,96.52 arc(44.34,96.64) 44.28,96.74 44.11,96.9
NIF_P_TX07: length 186
  TOP w0.152: U40.D13 v4(45.7,100.65)
  S16 w0.102: v4(45.7,100.65) 45.7,100.35 arc(45.67,100.28) 45.6,100.25 arc(45.25,100.1) 45.11,99.76 45.11,97.11
  S16 w0.152: CONN53_PF.1B36 203.87,58.43 203.58,58.43 203.18,58.03 arc(202.97,57.88) 202.72,57.83 202.35,57.83 arc(202.02,57.9) 201.74,58.08 201.52,58.3 arc(201.37,58.54) 201.31,58.81 201.31,58.84 arc(201.24,59.23) 201.02,59.56 200.6,59.98 199.14,61.44 arc(198.86,61.85) 198.76,62.34 198.76,63.56 arc(198.69,63.92) 198.48,64.23 197.62,65.09 arc(197.3,65.57) 197.19,66.13 197.19,66.71 arc(197.11,67.1) 196.89,67.42 187.33,76.99 arc(186.4,77.61) 185.29,77.83 138.65,77.83 arc(137.44,78.07) 136.41,78.76 131.93,83.24 arc(131.34,83.64) 130.64,83.78 84.51,83.78 arc(83.51,83.97) 82.67,84.54 73.13,94.07 arc(72.31,94.62) 71.34,94.81 64.29,94.81 arc(63.88,94.73) 63.54,94.5 61.61,92.57 arc(61.32,92.38) 60.99,92.32 46.69,92.32 arc(45.99,92.61) 45.7,93.31 45.7,96.26 arc(45.65,96.5) 45.51,96.71 45.11,97.11
NIF_PVDD10: length 10.2
  TOP w0.127: 104.34,93.69 LB24.2
  TOP w0.381: v4(39.7,108.65) U40.M19 ; v4(40.7,108.65) U40.M18 ; v4(41.7,108.65) U40.M17 ; v4(37.7,108.65) U40.M20
  BOTTOM w0.381: CB656.2 37.7,108.64 v4(37.7,108.65) ; CB657.2 39.69,108.65 v4(39.7,108.65) 39.7,108.65 CB658.2 40.69,108.65 v4(40.7,108.65) 40.7,108.65 CB646.2 41.2,109.14 v4(41.7,108.65) 41.7,108.72 CB655.2 ; v2(48.78,93.32) v1(47.65,93.32)
  vias: v1(46.7,95.57) v1(46.71,94.84) v1(46.71,94.07) v1(46.71,93.31) v1(47.65,94.85) v1(47.65,94.08) v1(47.66,95.57) v1(103.95,92.12) v1(104.77,92.15) v1(105.2,92.83) v1(105.63,92.07) v1(105.93,93.49)
NIF_RX[08]_N: length 64.1
  TOP w0.095: v4(41.7,106.65) U40.K17
  S7 w0.102: v4(41.7,106.65) 41.7,106.38 41.79,106.29 42.09,106.29 42.29,106.09 42.29,101.46 42.31,101.43 42.31,99.15 42.29,99.13 42.29,97.52 42.29,97.52 42.29,97.47 42.31,97.45 42.31,97.43
  S7 w0.108: CONN54_PF.2T12 49.26,57.59 arc(49.26,57.6) 49.26,57.61 arc(49.29,57.7) 49.34,57.77 arc(49.53,58.11) 49.6,58.49 49.6,58.58 arc(49.49,59.11) 49.19,59.56 48.87,59.88 arc(48.56,60.34) 48.45,60.89 48.45,61.16 arc(48.31,61.86) 47.91,62.46 46.48,63.89 arc(46.35,63.98) 46.2,64.01 arc(45.76,64.1) 45.38,64.35 43.29,66.44 arc(41.85,67.4) 40.16,67.74 37.69,67.74 arc(36.64,68.17) 36.21,69.22 36.21,71.89 arc(36.14,72.27) 35.93,72.58 35.9,72.6 arc(35.32,73.47) 35.12,74.5 35.12,75.65 arc(35.19,76.02) 35.39,76.32 44.07,85 arc(44.41,85.5) 44.52,86.08 44.52,94.38 arc(44.41,94.93) 44.1,95.4 42.31,97.19 42.31,97.43
NIF_RX[08]_P: length 64.1
  TOP w0.095: v4(41.7,105.65) U40.J17
  S7 w0.102: 42.08,97.43 42.08,99.21 42.11,99.24 42.11,101.35 42.08,101.37 42.08,106.01 42.01,106.08 41.78,106.08 41.7,106 v4(41.7,105.65)
  S7 w0.108: CONN54_PF.2T13 48.46,58.17 arc(48.51,57.93) 48.65,57.73 arc(48.72,57.68) 48.81,57.66 arc(48.9,57.68) 48.98,57.73 48.99,57.74 49.1,57.85 arc(49.3,58.14) 49.37,58.49 49.37,58.58 arc(49.28,59.02) 49.03,59.4 48.71,59.72 arc(48.35,60.26) 48.23,60.89 48.23,61.16 arc(48.1,61.78) 47.75,62.3 47,63.06 46.32,63.73 arc(46.27,63.77) 46.2,63.78 arc(45.67,63.89) 45.22,64.19 43.13,66.28 arc(41.77,67.19) 40.16,67.51 37.69,67.51 arc(36.48,68.01) 35.98,69.22 35.98,71.89 arc(35.93,72.18) 35.76,72.42 35.74,72.44 arc(35.11,73.39) 34.89,74.5 34.89,75.65 arc(34.98,76.1) 35.23,76.48 43.91,85.16 arc(44.19,85.58) 44.29,86.08 44.29,94.38 arc(44.2,94.85) 43.94,95.24 42.15,97.03 42.08,97.1 42.08,97.43
NIF_RX[09]_N: length 67.2
  TOP w0.095: U40.F18 v4(40.7,102.65)
  S7 w0.102: v4(40.7,102.65) 40.7,102.96 40.79,103.04 41.01,103.04 41.1,102.95 41.1,101.22 41.08,101.19 41.08,99 41.1,98.98 41.1,97.41 41.11,97.4 41.11,97.37
  S7 w0.108: 41.11,97.37 41.11,96.29 arc(41.2,95.84) 41.46,95.46 42.1,94.82 arc(42.37,94.41) 42.47,93.92 42.47,86.97 arc(42.35,86.38) 42.01,85.88 34.03,77.9 arc(33.78,77.53) 33.7,77.09 33.7,65.26 arc(33.83,64.58) 34.22,64 36.82,61.39 arc(37.45,60.98) 38.18,60.83 38.84,60.83 arc(40.64,60.08) 41.39,58.27 41.39,54.55 arc(41.45,54.24) 41.62,53.99 arc(41.73,53.83) 41.77,53.63 41.77,51.2 arc(42.06,50.49) 42.77,50.2 43.48,50.2 arc(43.87,50.12) 44.21,49.9 44.28,49.82 arc(44.41,49.63) 44.45,49.41 44.45,48.86 arc(44.44,48.79) 44.4,48.73 arc(44.3,48.66) 44.18,48.64 44.05,48.64 arc(43.96,48.66) 43.88,48.71 43.8,48.79 arc(43.7,48.95) 43.66,49.13 CONN54_PF.2L12
NIF_RX[09]_P: length 67.2
  TOP w0.095: v4(40.7,103.65) U40.G18
  S7 w0.102: 41.34,97.46 41.31,97.49 41.31,99.06 41.28,99.09 41.28,101.11 41.31,101.13 41.31,103.03 41.09,103.25 40.81,103.25 40.7,103.36 v4(40.7,103.65)
  S7 w0.108: 41.34,97.46 41.34,96.29 arc(41.41,95.93) 41.62,95.62 42.26,94.98 arc(42.58,94.5) 42.7,93.92 42.7,86.97 arc(42.56,86.29) 42.18,85.72 34.19,77.73 arc(33.99,77.44) 33.93,77.09 33.93,65.26 arc(34.04,64.66) 34.38,64.16 36.98,61.56 arc(37.53,61.19) 38.18,61.06 38.84,61.06 arc(40.81,60.24) 41.62,58.27 41.62,54.55 arc(41.66,54.33) 41.79,54.15 arc(41.94,53.91) 42,53.63 42,51.2 arc(42.23,50.65) 42.77,50.43 43.48,50.43 arc(43.96,50.33) 44.37,50.06 44.45,49.98 arc(44.62,49.72) 44.68,49.41 44.68,48.86 arc(44.65,48.7) 44.56,48.57 arc(44.52,48.53) 44.5,48.48 arc(44.49,48.47) 44.49,48.47 arc(44.47,48.4) 44.46,48.34 CONN54_PF.2L13
NIF_RX[10]_N: length 55.9
  TOP w0.095: U40.J19 v4(39.7,105.65)
  S7 w0.108: v4(39.7,105.65) 39.7,105.92 39.63,105.99 39.32,105.99 39.25,105.92 39.25,97.46 39.97,96.73 39.97,95.51 arc(40.03,95.2) 40.21,94.94 40.64,94.5 arc(40.79,94.28) 40.84,94.02 40.84,93.15 arc(40.89,93.05) 40.99,93 arc(41.09,92.96) 41.14,92.86 41.14,92.61 arc(41.09,92.51) 40.99,92.46 arc(40.89,92.42) 40.84,92.32 40.84,87.29 arc(40.74,86.76) 40.44,86.32 32.74,78.62 arc(32.51,78.28) 32.43,77.88 32.43,63.76 arc(32.56,63.11) 32.93,62.55 33.35,62.14 arc(33.62,61.73) 33.72,61.25 33.72,61.09 arc(33.79,60.71) 34.01,60.39 35.1,59.29 arc(35.41,58.54) 35.1,57.79 35.08,57.77 arc(35.03,57.7) 35.01,57.62 CONN54_PF.1T12
NIF_RX[10]_P: length 55.9
  TOP w0.095: U40.K19 v4(39.7,106.65)
  S7 w0.108: CONN54_PF.1T13 34.59,57.93 arc(34.75,57.86) 34.91,57.93 34.94,57.95 arc(35.18,58.54) 34.94,59.13 33.84,60.23 arc(33.58,60.62) 33.49,61.09 33.49,61.25 arc(33.41,61.64) 33.19,61.97 32.77,62.39 arc(32.35,63.02) 32.2,63.76 32.2,77.88 arc(32.3,78.37) 32.58,78.78 40.28,86.48 arc(40.53,86.85) 40.61,87.29 40.61,94.02 arc(40.58,94.19) 40.48,94.34 40.05,94.77 arc(39.82,95.11) 39.74,95.51 39.74,96.64 39.02,97.36 39.02,106.01 39.22,106.22 39.62,106.22 39.7,106.3 v4(39.7,106.65)
NIF_RX[11]_N: length 63.6
  TOP w0.095: v4(37.7,102.65) U40.F20
  S7 w0.102: v4(37.7,102.65) 37.7,103 37.77,103.07 38.2,103.07 38.29,102.98 38.29,97.56 38.29,97.56 38.29,97.51 38.27,97.49 38.27,97.48
  S7 w0.108: 38.27,97.48 38.27,97 38.33,96.94 38.41,96.86 arc(38.45,96.8) 38.46,96.74 38.46,87.79 arc(38.37,87.35) 38.12,86.97 31.12,79.97 arc(30.6,79.2) 30.42,78.28 30.42,64.98 arc(30.33,64.54) 30.08,64.17 27.53,61.62 arc(27.14,61.04) 27,60.35 27,52.18 arc(27.11,51.66) 27.41,51.21 27.83,50.79 arc(28.62,50.26) 29.55,50.08 arc(29.81,50.03) 30.03,49.88 30.21,49.7 arc(30.38,49.29) 30.21,48.87 30.08,48.74 arc(29.98,48.68) 29.86,48.65 arc(29.77,48.67) 29.7,48.72 29.65,48.77 29.62,48.8 arc(29.47,49.03) CONN54_PF.1L12
NIF_RX[11]_P: length 63.7
  TOP w0.095: v4(37.7,103.65) U40.G20
  S7 w0.102: 38.5,97.48 38.5,103.06 38.28,103.27 37.76,103.27 37.7,103.34 v4(37.7,103.65)
  S7 w0.108: 38.5,97.48 38.5,97.1 38.57,97.02 arc(38.66,96.89) 38.69,96.74 38.69,87.79 arc(38.58,87.26) 38.28,86.81 31.28,79.81 arc(30.81,79.11) 30.65,78.28 30.65,64.98 arc(30.54,64.46) 30.25,64.01 27.69,61.46 arc(27.35,60.95) 27.23,60.35 27.23,52.18 arc(27.32,51.75) 27.57,51.38 27.99,50.95 arc(28.71,50.48) 29.55,50.31 arc(29.9,50.24) 30.19,50.04 30.37,49.87 arc(30.61,49.29) 30.37,48.71 arc(30.32,48.66) 30.29,48.6 arc(30.26,48.56) 30.25,48.51 arc(30.22,48.43) 30.21,48.33 CONN54_PF.1L13
NIF_RX[12]_N: length 67.5
  TOP w0.095: v3(18.94,50.75) 18.54,51.15 18.54,51.47 18.84,51.76 U69.18 ; v4(36.7,106.65) U40.K21
  S7 w0.102: v4(36.7,106.65) 36.7,106.34 36.79,106.25 37.05,106.25 37.29,106.01 37.29,101.36 37.31,101.34 37.31,99.25 37.29,99.23 37.29,97.21
  S7 w0.108: 37.29,97.21 37.48,97.02 37.48,95.55 37.31,95.37 37.31,88.94 arc(37.21,88.44) 36.92,88.01 27.93,79.02 arc(27.67,78.63) 27.58,78.17 27.58,67.66 27.93,67.31 27.93,64.12 22.55,58.75 arc(22.29,58.35) 22.2,57.88 22.2,57.88 22.2,56.96 arc(22.08,56.41) 21.77,55.94 18.91,53.08 18.85,53.02 arc(18.63,52.68) 18.55,52.28 18.55,51.14 arc(18.66,50.87) v3(18.94,50.75)
NIF_RX[12]_P: length 67.5
  TOP w0.095: U69.17 18.04,51.78 18.32,51.5 18.32,51.15 v3(17.92,50.75) ; v4(36.7,105.65) U40.J21
  S7 w0.102: 37.13,97.05 37.12,97.06 37.12,97.08 37.12,97.09 37.08,97.13 37.08,97.3 37.09,97.3 37.09,99.31 37.11,99.33 37.11,101.26 37.09,101.28 37.09,105.93 36.97,106.04 36.77,106.04 36.7,105.97 v4(36.7,105.65)
  S7 w0.108: 37.13,97.05 37.26,96.92 37.26,95.65 37.08,95.47 37.08,92.78 arc(37.04,92.68) 36.94,92.64 arc(36.84,92.6) 36.8,92.5 36.8,92.16 arc(36.84,92.06) 36.94,92.02 arc(37.04,91.98) 37.08,91.88 37.08,88.94 arc(36.99,88.53) 36.76,88.18 27.77,79.18 arc(27.46,78.72) 27.35,78.17 27.35,67.57 27.7,67.21 27.7,64.22 22.39,58.91 arc(22.08,58.44) 21.97,57.88 21.97,56.96 arc(21.87,56.5) 21.61,56.1 18.75,53.24 18.69,53.18 arc(18.42,52.77) 18.32,52.28 18.32,51.15 arc(18.2,50.87) v3(17.92,50.75)
NIF_RX[13]_N: length 64.1
  TOP w0.095: v4(35.7,103.65) U40.G22 ; v3(16.54,50.75) 16.14,51.15 16.14,51.51 16.44,51.8 U69.15
  S7 w0.102: v4(35.7,103.65) 35.7,103.31 35.81,103.2 36.04,103.2 36.3,102.94 36.3,101.22 36.29,101.21 36.29,99.16 36.31,99.13 36.31,97.42 36.33,97.41
  S7 w0.108: 36.33,97.41 36.33,96.72 arc(36.24,96.3) 36.01,95.94 arc(36,95.93) 35.99,95.92 35.38,95.31 arc(35.13,94.94) 35.04,94.5 35.04,88.98 arc(34.92,88.34) 34.56,87.8 34.43,87.68 25.77,79.02 arc(25.49,78.59) 25.39,78.1 25.39,73.12 arc(25.27,72.51) 24.93,72 24.49,71.56 24.07,71.15 arc(23.49,70.27) 23.28,69.24 23.28,63.94 arc(23.19,63.45) 22.91,63.04 22.55,62.68 22.5,62.63 arc(22.18,62.16) 22.07,61.6 22.07,60.99 arc(21.95,60.4) 21.62,59.9 21.1,59.38 21.06,59.34 arc(20.68,58.78) 20.55,58.11 20.55,57.19 arc(20.44,56.65) 20.14,56.2 16.35,52.41 arc(16.2,52.19) 16.15,51.94 16.15,51.14 arc(16.27,50.87) v3(16.54,50.75)
NIF_RX[13]_P: length 64.1
  TOP w0.095: v3(15.52,50.75) 15.92,51.15 15.92,51.5 15.64,51.78 U69.14 ; v4(35.7,102.65) U40.F22
  S7 w0.102: 36.09,97.37 36.11,97.39 36.11,99.05 36.08,99.07 36.08,101.3 36.09,101.31 36.09,102.86 35.96,102.99 35.77,102.99 35.7,102.92 v4(35.7,102.65)
  S7 w0.108: 36.09,97.37 36.1,97.36 36.1,96.72 arc(36.03,96.39) 35.84,96.1 35.22,95.47 arc(34.92,95.02) 34.82,94.5 34.82,92.5 arc(34.79,92.44) 34.73,92.42 arc(34.61,92.37) 34.56,92.25 34.56,91.97 arc(34.61,91.85) 34.73,91.8 arc(34.79,91.78) 34.82,91.71 34.82,88.98 arc(34.71,88.43) 34.4,87.96 34.27,87.84 25.61,79.18 arc(25.28,78.68) 25.16,78.1 25.16,73.12 arc(25.06,72.6) 24.77,72.16 24.33,71.72 23.91,71.31 arc(23.28,70.36) 23.05,69.24 23.05,63.94 arc(22.97,63.54) 22.75,63.2 22.33,62.79 arc(21.97,62.24) 21.84,61.6 21.84,60.99 arc(21.74,60.49) 21.46,60.06 21.5,60.1 20.94,59.54 20.9,59.51 arc(20.47,58.87) 20.32,58.11 20.32,57.19 arc(20.23,56.74) 19.98,56.36 16.18,52.57 arc(15.99,52.28) 15.93,51.94 15.93,51.16 arc(15.81,50.87) v3(15.52,50.75)
NIF_RX[14]_N: length 59.7
  TOP w0.095: v4(34.7,106.65) U40.K23 ; U69.21 18.44,56.08 18.19,56.33 18.19,56.64 v3(18.55,57)
  S7 w0.102: 35.29,97.4 35.29,99.14 35.32,99.17 35.32,101.11 35.28,101.14 35.28,104.1 35.3,104.11 35.3,106.05 35.11,106.23 34.79,106.23 34.7,106.33 v4(34.7,106.65)
  S7 w0.108: 35.29,97.4 35.3,97.39 35.3,97.21 arc(35.25,96.96) 35.11,96.75 35.1,96.73 32.06,93.7 arc(31.88,93.43) 31.82,93.11 31.82,88.69 arc(31.71,88.16) 31.41,87.71 31.33,87.63 23.89,80.19 arc(23.59,79.74) 23.49,79.22 23.49,72.92 arc(23.38,72.41) 23.09,71.98 21.68,70.57 arc(21.54,70.35) 21.49,70.09 21.49,67.18 arc(21.39,66.68) 21.1,66.26 19.76,64.91 arc(19.75,64.9) 19.74,64.89 arc(19.61,64.66) 19.57,64.4 arc(19.52,64.14) 19.37,63.92 18.33,62.88 arc(18.19,62.68) 18.14,62.44 18.14,57.4 arc(18.26,57.11) v3(18.55,57)
NIF_RX[14]_P: length 59.7
  TOP w0.095: v4(34.7,105.65) U40.J23 ; U69.22 17.64,56.07 17.96,56.4 17.96,56.57 v3(17.53,57)
  S7 w0.102: 35.07,97.46 35.08,97.47 35.08,99.23 35.11,99.26 35.11,101.02 35.08,101.06 35.08,104.18 35.1,104.2 35.1,105.96 35.03,106.03 34.82,106.03 34.7,105.9 v4(34.7,105.65)
  S7 w0.108: 35.07,97.46 35.07,97.23 arc(35.04,97.05) 34.93,96.89 33.47,95.43 33.42,95.48 arc(33.37,95.5) 33.32,95.48 32.98,95.15 arc(32.96,95.1) 32.98,95.05 arc(33.01,95) 32.98,94.95 32.65,94.61 arc(32.6,94.59) 32.55,94.61 arc(32.5,94.63) 32.45,94.61 32.11,94.28 arc(32.09,94.23) 32.11,94.17 arc(32.13,94.12) 32.11,94.07 31.9,93.86 arc(31.67,93.51) 31.59,93.11 31.59,88.69 arc(31.5,88.25) 31.25,87.87 31.17,87.79 23.73,80.35 arc(23.38,79.83) 23.26,79.22 23.26,72.92 arc(23.17,72.5) 22.93,72.14 21.52,70.73 arc(21.33,70.44) 21.26,70.09 21.26,67.18 arc(21.18,66.77) 20.94,66.42 19.6,65.07 arc(19.59,65.07) 19.59,65.07 19.56,65.04 19.56,65.03 arc(19.4,64.73) 19.34,64.4 arc(19.3,64.23) 19.21,64.08 18.17,63.04 arc(17.98,62.77) 17.92,62.44 17.92,57.38 arc(17.8,57.11) v3(17.53,57)
NIF_RX[15]_N: length 58.9
  TOP w0.095: U69.24 16.04,56.2 15.79,56.45 15.79,56.63 v3(16.15,57) ; v4(33.7,103.65) U40.G24
  S7 w0.102: v4(33.7,103.65) 33.7,103.35 33.8,103.25 34.07,103.25 34.31,103.01 34.31,101.19 34.29,101.17 34.29,99.41 34.31,99.39 34.31,97.36 33.92,96.97
  S7 w0.108: 33.92,96.97 33.86,96.91 33.74,96.91 33.57,96.91 33.57,96.91 arc(33.45,96.88) 33.34,96.81 30.72,94.19 arc(30.52,93.89) 30.45,93.54 30.45,90.16 arc(30.38,89.83) 30.19,89.54 21.99,81.33 arc(21.75,80.98) 21.67,80.56 21.67,73.49 arc(21.44,72.34) 20.79,71.36 20.15,70.73 arc(19.78,70.17) 19.65,69.52 19.65,66.72 arc(19.59,66.42) 19.42,66.17 19.11,65.86 arc(18.83,65.67) 18.5,65.61 17.53,65.61 arc(16.88,65.48) 16.32,65.11 16.17,64.96 arc(15.96,64.64) 15.89,64.27 15.89,63.6 arc(15.93,63.39) 16.05,63.2 arc(16.35,62.76) 16.46,62.23 16.46,58.96 arc(16.36,58.47) 16.08,58.05 15.96,57.93 arc(15.82,57.72) 15.77,57.48 15.77,57.37 arc(15.88,57.11) v3(16.15,57)
NIF_RX[15]_P: length 58.9
  TOP w0.095: U69.25 15.24,56.12 15.56,56.44 15.56,56.57 v3(15.13,57) ; v4(33.7,102.65) U40.F24
  S7 w0.102: v4(33.7,102.65) 33.7,102.89 33.85,103.04 33.99,103.04 34.11,102.92 34.11,101.28 34.08,101.25 34.08,99.33 34.11,99.31 34.11,97.45 33.84,97.18 33.83,97.18
  S7 w0.108: 33.83,97.18 arc(33.79,97.15) 33.74,97.14 33.57,97.14 arc(33.36,97.09) 33.18,96.97 32.59,96.39 arc(32.5,96.35) 32.41,96.39 arc(32.32,96.43) 32.22,96.39 32.03,96.19 arc(31.99,96.1) 32.03,96.01 arc(32.07,95.91) 32.03,95.82 30.56,94.35 arc(30.31,93.98) 30.22,93.54 30.22,90.16 arc(30.17,89.91) 30.03,89.7 21.82,81.5 arc(21.54,81.07) 21.44,80.56 21.44,73.49 arc(21.23,72.43) 20.62,71.53 19.99,70.89 arc(19.57,70.26) 19.42,69.52 19.42,66.72 arc(19.38,66.51) 19.26,66.33 18.95,66.02 arc(18.74,65.88) 18.5,65.83 17.53,65.83 arc(16.79,65.69) 16.16,65.27 16.01,65.12 arc(15.75,64.73) 15.66,64.27 15.66,63.6 arc(15.72,63.3) 15.89,63.04 arc(16.14,62.67) 16.23,62.23 16.23,58.96 arc(16.15,58.56) 15.92,58.21 15.8,58.09 arc(15.61,57.81) 15.54,57.48 15.54,57.4 arc(15.42,57.12) v3(15.13,57)
