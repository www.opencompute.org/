# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RS1_21: length 22.8
  S7 w0.127: v1(179.48,39.37) 178.37,40.48 178.37,42.42 177.89,42.9 177.89,43.85 178.37,44.33 178.37,45.79 180.96,48.38 180.96,49.07 180.13,49.91 179.43,49.91 178.83,50.5 178.83,51.49 179.56,52.22 CONN55_PF.5T9
  BOTTOM w0.127: RB379.1 178.42,40.4 v2(178.55,40.28) 178.57,40.28 v1(179.48,39.37) 178.38,38.27 RB407.1
RS1_22: length 17.9
  S7 w0.127: v1(173.04,40.33) 174.84,42.14 174.84,45.77 172.28,48.33 172.28,49.78 173.96,51.47 CONN55_PF.5L9
  BOTTOM w0.127: RB377.1 173.11,40.4 v1(173.04,40.33) 173.04,39.23 v2(173.16,39.11) 174,38.27 RB405.1
RS1_23: length 22.9
  S7 w0.127: v1(193.73,39.37) 192.62,40.48 192.62,41.88 191.99,42.52 191.99,43.47 192.62,44.1 192.62,45.79 195.21,48.38 195.21,49.07 194.38,49.91 193.66,49.91 193.08,50.49 193.08,51.49 193.81,52.22 CONN55_PF.6T9
  BOTTOM w0.127: RB411.1 192.63,38.27 v1(193.73,39.37) 193.31,39.79 v2(192.81,39.79) 192.2,40.4 RB383.1
RS1_24: length 17.9
  S7 w0.127: CONN55_PF.6L9 188.21,51.47 186.53,49.78 186.53,48.33 189.09,45.77 189.09,42.14 v1(187.29,40.33)
  BOTTOM w0.127: RB381.1 187.36,40.4 v1(187.29,40.33) 187.29,39.23 v2(187.41,39.11) 188.25,38.27 RB409.1
RST_T: length 8.3
  TOP w0.127: v1(221.73,115.7) 221.61,115.7 221.61,115.76 221.27,115.76 R854.2 221.48,116.4 222.29,116.4 223.52,117.63 226.16,117.63 U52.M2
  BOTTOM w0.127: v1(221.73,115.7) 221.61,115.7 221.61,115.76 221.39,115.76 TP51.1
RTC_BAT_R: length 7.9
  TOP w0.508: J5.1 v1(214.99,252.02) 213.89,250.92 D9.C
  BOTTOM w0.254: v1(214.99,252.02) 215.1,252.14 v2(215.1,252.96)
RXLOS_01: length 305.4
  TOP w0.127: U9.D6 v4(194.55,196.58)
  S5 w0.127: CONN54_PF.1T8 35.49,55.3 37.34,57.16 37.34,59.49 40.39,62.54 41.15,62.54 46.37,67.77 46.37,74.21 51.05,78.88 71.11,78.88 72.68,80.45 77.1,80.45 84.92,88.26 120.37,88.26 126.08,93.97 126.08,117.09 124.17,119 124.17,133.45 125.24,134.52 125.24,142.97 127.52,145.26 134.26,145.26 137.32,148.32 137.32,155.54 141.14,159.37 156.95,159.37 162.46,164.88 164.24,164.88 167.11,167.74 168.77,167.74 175.76,174.73 175.76,194.59 178.88,197.71 181.67,197.71 182.59,198.63 182.98,198.63 183.25,198.35 183.25,198.13 183.67,197.71 185.08,197.71 188,200.63 191.48,200.63 192.05,200.06 192.05,199.36 192.24,199.17 192.69,199.17 193.13,198.73 193.13,198.3 193.34,198.09 193.89,198.09 194.06,197.93 194.06,197.37 194.55,196.88 v4(194.55,196.58)
  S14 w0.127: CONN54_PF.1T8 34.21,53.92 33.69,53.39 33.69,52.09 34.22,51.55 34.22,50.59 34.72,50.09 35.4,50.09 36.48,49.02 36.48,48.11 33.43,45.06 33.43,41.69 32.9,41.15 32.9,36.92 32.72,36.74 32.72,36.03 33,35.74 34.13,35.74 v1(35.62,34.25)
  BOTTOM w0.127: RB528.1 v1(35.62,34.25) 36.04,34.25 v2(36.93,33.36)
RXLOS_02: length 315.6
  TOP w0.127: v4(196.55,199.58) U9.A8
  S5 w0.127: CONN54_PF.1L8 30.21,52.67 29.46,53.42 29.46,54.42 31.08,56.04 31.08,56.83 32.62,58.37 32.62,59.2 36.19,62.77 36.19,65.17 36.34,65.33 37.2,65.33 37.66,65.78 38.67,65.78 39.34,66.44 39.34,67.18 39.54,67.38 43.86,67.38 45.11,68.63 45.11,74.73 50.47,80.09 70.54,80.09 72.17,81.71 76.58,81.71 84.39,89.53 119.97,89.53 122.81,92.37 122.81,101.03 121.05,102.79 121.05,108.56 120.36,109.24 120.36,116.98 122.9,119.52 122.9,133.89 123.84,134.83 123.84,138.1 122.62,139.32 122.62,142.29 126.73,146.4 131.57,146.4 135.1,149.93 135.1,152.81 136.04,153.76 136.04,156.07 140.61,160.64 156.38,160.64 162.09,166.35 163.92,166.35 166.96,169.39 168.24,169.39 171.31,172.46 171.31,173.43 174.61,176.73 174.61,195.3 179.45,200.14 179.45,200.38 180.08,201.01 182.78,201.01 183.16,200.63 186.2,200.63 187.47,201.9 193.01,201.9 194.53,200.38 196.31,200.38 196.6,200.09 196.6,199.63 v4(196.55,199.58)
  S14 w0.127: CONN54_PF.1L8 29.12,50.9 27.82,49.6 24.15,49.6 23.35,48.8 23.35,46.35 29.75,39.96 29.75,39.18 29.37,38.8 29.37,34.9 28.72,34.25 v1(28.53,34.25)
  BOTTOM w0.127: RB526.1 v1(28.53,34.25) 27.95,34.25 v2(27.26,33.56)
RXLOS_03: length 276.8
  TOP w0.127: U9.F4 v4(192.55,194.58)
  S5 w0.127: v4(192.55,194.58) 192.13,194.16 189.34,194.16 188.97,194.54 179.73,194.54 177.88,192.68 177.88,173.38 169.51,165.01 167.85,165.01 165.12,162.28 163.35,162.28 157.92,156.84 155.57,156.84 153.51,154.79 144.68,154.79 139.92,150.02 139.92,146.38 135.5,141.96 135.5,138.64 128.17,131.31 128.17,92.48 121.28,85.6 86.14,85.6 78.35,77.81 73.44,77.81 72.27,76.64 62.23,76.64 58.79,73.2 58.79,67.79 51.81,60.8 51.81,57.76 49.35,55.3 CONN54_PF.2T8
  S7 w0.127: v1(50.08,34.25) 50.74,34.91 50.74,39.44 48.2,41.98 48.2,45.92 50.79,48.51 50.79,49.07 50.39,49.47 49.31,49.47 48.21,50.58 48.21,51.79 47.93,52.07 47.93,53.27 48.46,53.8 CONN54_PF.2T8
  BOTTOM w0.127: RB531.1 v1(50.08,34.25) 51.33,34.25 53.62,36.55 v2(53.62,36.8)
RXLOS_04: length 287.6
  TOP w0.127: v4(189.55,198.58) U9.B1
  S5 w0.127: v4(189.55,198.58) 188.22,198.58 186.53,196.89 179.48,196.89 176.62,194.02 176.62,193.22 176.61,193.21 176.61,174.27 168.85,166.51 167.25,166.51 164.46,163.72 162.67,163.72 157.31,158.36 141.66,158.36 138.36,155.06 138.36,147.55 133.54,142.72 133.54,138.6 126.84,131.9 126.84,93.32 120.63,87.11 85.51,87.11 77.73,79.33 72.91,79.33 71.7,78.12 61.11,78.12 57.02,74.03 57.02,68.2 54.95,66.13 49.89,66.13 48.33,64.57 48.33,63.7 46.48,61.84 45.53,61.84 41.83,58.14 41.83,54.73 43.5,53.06 43.86,53.06 44.46,52.45 CONN54_PF.2L8
  S16 w0.127: CONN54_PF.2L8 43.23,50.9 41.88,49.55 41.88,48.38 44.57,45.69 44.57,43.91 42.21,41.55 42.21,35.02 v1(42.97,34.25)
  BOTTOM w0.127: v2(186.72,199.36) 188.77,199.36 v4(189.55,198.58) ; v2(40.4,34.67) 40.82,34.25 v1(42.97,34.25) RB529.1
RXLOS_05: length 255.6
  TOP w0.127: U9.H6 v4(194.55,192.58)
  S5 w0.127: v4(194.55,192.58) 194.53,192.56 194.53,191.34 193.41,190.22 189.07,190.22 188.69,189.84 187.77,189.84 184.6,186.66 183.33,186.66 181.38,184.71 181.38,180.12 180.69,179.42 180.69,177.33 181.07,176.95 181.07,173.14 170.34,162.41 168.37,162.41 166.4,160.44 166.4,157.96 165.86,157.42 164.38,157.42 160.94,153.98 160.94,151.74 158.97,149.77 158.97,148.88 158.52,148.44 153.64,148.44 153.23,148.03 146.15,148.03 145.45,147.33 145.45,144.89 143.73,143.16 143.73,141.77 143.09,141.13 140.68,141.13 139.54,139.99 139.54,139.58 130.56,130.61 130.56,91.57 122.1,83.11 87.8,83.11 80.15,75.46 79.09,75.46 77.33,73.71 72.48,73.71 70.96,72.18 70.96,67.08 66.06,62.18 66.06,58.06 63.3,55.3 CONN54_PF.3T8
  S9 w0.127: CONN54_PF.3T8 62.71,53.61 63.54,52.78 64.07,52.78 65.01,51.84 65.01,48.49 62.58,46.05 62.58,41.81 65.04,39.34 65.04,37 v1(64.33,36.29)
  BOTTOM w0.127: RB507.1 v1(64.33,36.29) 64.57,36.29 v2(65.24,36.95)
RXLOS_06: length 260.5
  TOP w0.127: U9.J1 189.55,191.58 v4(189.55,191.68)
  S5 w0.127: v4(189.55,191.68) 189.54,191.69 189.24,191.69 187.24,193.69 181.28,193.69 178.7,191.11 178.7,172.99 169.74,164.03 168.09,164.03 165.57,161.52 163.67,161.52 161.38,159.23 161.38,156.54 158.44,153.6 158.44,152.64 158.02,152.22 157.06,152.22 156.83,151.99 145.1,151.99 144.24,151.12 144.24,149.7 142.46,147.93 142.46,146.73 136.67,140.94 136.67,138.63 129.05,131.01 129.05,92.28 121.36,84.6 86.79,84.6 79.19,77 74.11,77 72.67,75.57 72.12,75.57 69.19,72.64 69.19,69.12 65.5,65.43 62.41,65.43 61.33,64.35 61.33,63.4 56.35,58.41 56.35,54.58 58.71,52.22 CONN54_PF.3L8
  S12 w0.127: v1(57.22,36.29) 57.78,36.84 57.78,40.71 58.74,41.68 58.74,45.79 56.2,48.33 56.2,49.43 57.68,50.9 CONN54_PF.3L8
  BOTTOM w0.127: v2(56.38,37.35) 56.38,37.12 v1(57.22,36.29) RB505.1
RXLOS_07: length 245.5
  TOP w0.127: U9.L6 v4(194.55,188.58)
  S5 w0.127: v1(186.53,180.57) 186.21,180.57 185.64,180 185.64,177.26 184.81,176.44 184.81,172.98 175.91,164.07 175.91,161.18 170.7,155.97 170.7,154.58 169.95,153.83 169.95,152.5 168.3,150.85 166.91,150.85 165.83,149.77 165.83,149.32 164.56,148.05 164.56,144.12 163.54,143.1 163.54,141.32 162.78,140.56 150.41,140.56 149.68,139.84 146.12,139.84 143.95,137.67 141.66,137.67 141.51,137.51 140.86,137.51 136.11,132.76 136.11,129.34 135.83,129.05 134.08,129.05 133.26,128.24 133.26,90.51 123.29,80.54 88.47,80.54 83.8,75.87 83.8,62.95 80.31,59.46 80.31,57.78 77.83,55.3 CONN54_PF.4T8
  S9 w0.127: v4(194.55,188.58) 193.97,188 189.13,188 187.73,186.6 187.73,181.77 v1(186.53,180.57) ; CONN54_PF.4T8 76.96,55.3 76.96,53.8 77.66,53.1 78.01,53.1 79.26,51.84 79.26,48.49 76.83,46.05 76.83,39.29 78.15,37.97 78.15,36.72 v1(78.58,36.29)
  BOTTOM w0.127: RB510.1 v1(78.58,36.29) 79.25,36.95 v2(79.49,36.95) ; v2(188.52,180.22) 188.17,180.57 v1(186.53,180.57)
RXLOS_08: length 254.9
  TOP w0.127: v4(193.55,189.58) U9.K5
  S5 w0.127: v4(193.55,189.58) 193.51,189.53 193.51,189.47 193.08,189.05 189.22,189.05 188.06,187.89 188.06,186.75 187.16,185.85 186.22,185.85 185.51,185.14 185.51,184 185.09,183.58 185.09,181.76 183.51,180.19 182.66,180.19 181.51,179.04 181.51,177.77 181.83,177.45 181.83,172.37 169.88,160.42 169.88,158.82 169.54,158.48 169.54,157.86 169.22,157.54 167.25,157.54 166.09,156.38 164.62,156.38 161.83,153.58 161.83,151.48 159.92,149.58 159.92,148.5 159.1,147.67 154.27,147.67 151.97,145.37 147.27,145.37 144.55,142.66 144.55,141.39 143.35,140.18 142.08,140.18 140.74,138.85 140.03,138.85 131.65,130.46 131.65,91.27 122.51,82.13 88.05,82.13 82.32,76.41 82.32,68.13 76.95,62.76 74.95,62.76 73.3,61.11 73.3,59.94 72.61,59.26 71.44,59.26 70.49,58.3 70.49,53.97 70.97,53.49 71.93,53.49 72.96,52.45 72.96,50.9 CONN54_PF.4L8
  S12 w0.127: v1(71.47,36.29) 72.03,36.84 72.03,40.71 72.99,41.68 72.99,45.79 70.45,48.33 70.45,49.43 71.93,50.9 CONN54_PF.4L8
  BOTTOM w0.127: v2(70.63,37.35) 71.47,36.52 v1(71.47,36.29) RB508.1 ; v4(193.55,189.58) 192.22,190.91 186.01,190.91 v2(185.76,190.67)
RXLOS_09: length 237.1
  TOP w0.127: v4(195.55,194.58) U9.F7
  S5 w0.127: v4(195.55,194.58) 195.52,194.58 195.09,194.14 195.09,191.16 194,190.07 194,189.25 193.13,188.39 193.13,187.47 192.73,187.07 192.4,187.07 192.4,187.04 191.99,186.64 191.99,185.37 191.68,185.06 191.41,185.06 191.02,184.68 191.02,183.44 190.72,183.13 190.41,183.13 190.01,182.73 190.01,182.42 189.07,181.48 189.07,180.06 190.66,178.47 190.66,175.29 181.29,165.93 181.29,165.17 180.18,164.06 180.18,158.51 178.55,156.88 176.37,156.88 175.42,155.93 175.42,152.94 173.96,151.48 173.38,151.48 171.6,149.7 171.6,145.97 169.76,144.13 169.76,142.53 170.02,142.28 170.02,141.32 168.3,139.61 167.29,139.61 164.81,137.13 155.41,137.13 151.22,132.94 149.06,132.94 148.97,132.85 148.61,132.85 144.13,128.37 139.55,128.37 138.28,127.1 138.28,119.05 143.58,113.75 143.58,109.48 136.24,102.14 136.24,90 124.23,77.99 108.75,77.99 105.55,74.8 105.55,68.48 101.45,64.37 98.12,64.37 94.56,60.8 94.56,57.78 92.08,55.3 CONN54_PF.5T8
  S9 w0.127: v1(92.83,36.29) 92.42,36.7 92.42,37.92 91.08,39.26 91.08,42.64 91.41,42.97 91.41,44.3 91.08,44.62 91.08,46.05 93.51,48.49 93.51,51.84 92.57,52.78 92.24,52.78 91.21,53.81 CONN54_PF.5T8
  BOTTOM w0.127: v2(93.74,36.95) 93.07,36.29 v1(92.83,36.29) RB513.1
RXLOS_10: length 232
  TOP w0.127: v4(192.55,187.58) U9.M4
  S5 w0.127: CONN54_PF.5L8 87.21,52.45 86.61,53.06 86.25,53.06 84.59,54.72 84.59,58.16 88.89,62.46 90.45,62.46 94.13,66.13 101.11,66.13 104.17,69.19 104.17,75.89 107.9,79.62 123.63,79.62 134.08,90.06 134.08,126.62 134.66,127.2 136.06,127.2 137.06,128.2 137.06,132.39 140.66,135.99 145.44,135.99 145.67,135.76 146.87,135.76 150.78,139.67 163.8,139.67 164.75,140.62 164.75,142.34 166.46,144.05 166.46,146.46 167.03,147.02 167.03,149.44 167.67,150.09 169.7,150.09 171.54,151.93 171.54,153.71 172.18,154.34 172.18,156.25 178.15,162.21 178.15,165.24 185.7,172.79 185.7,175.89 187.93,178.11 187.93,182.75 190.31,185.14 190.8,185.14 191.02,185.37 191.02,186.71 191.41,187.09 191.79,187.09 192.27,187.58 v4(192.55,187.58)
  S12 w0.127: CONN54_PF.5L8 86.18,50.9 84.7,49.43 84.7,48.33 87.24,45.79 87.24,41.68 86.28,40.71 86.28,36.84 v1(85.72,36.29)
  BOTTOM w0.127: RB511.1 v1(85.72,36.29) 84.88,37.12 v2(84.88,37.35)
RXLOS_11: length 226.7
  TOP w0.127: v4(193.55,187.58) U9.M5
  S5 w0.127: CONN54_PF.6T8 106.33,55.3 108.81,57.78 108.81,63.36 111.38,65.94 111.38,72.41 114.51,75.54 126.78,75.54 130.89,79.64 143.45,79.64 146.99,83.18 169.61,83.18 178.18,91.76 178.18,137.2 177.19,138.19 177.19,139.93 178.4,141.13 178.4,144.77 180.05,146.42 180.05,149.88 179.35,150.58 179.35,152.82 182.4,155.86 182.4,161.18 184.15,162.93 184.15,165.53 189.27,170.65 190.59,170.65 190.85,170.91 190.85,171.66 194.78,175.6 194.78,179.75 196.31,181.28 196.31,182.14 196.15,182.29 196.15,182.85 195.82,183.18 195.24,183.18 195.11,183.31 195.11,185.72 194.83,186 194.53,186 194.12,186.41 194.12,187.01 v4(193.55,187.58)
  S9 w0.127: v1(107.08,36.29) 106.57,36.8 106.57,37.77 105.33,39.01 105.33,46.05 107.76,48.49 107.76,51.84 106.82,52.78 106.29,52.78 105.46,53.61 CONN54_PF.6T8
  BOTTOM w0.127: RB516.1 v1(107.08,36.29) 107.32,36.29 v2(107.99,36.95)
RXLOS_12: length 232
  TOP w0.127: U9.P4 v4(192.55,185.58)
  S5 w0.127: v4(192.55,185.58) 192.55,185.45 192.04,184.93 192.04,181.07 191.58,180.62 191.58,175.05 182.19,165.66 182.19,164.61 181,163.42 181,158.02 178.53,155.55 178.53,154.79 177,153.26 177,148.62 176.2,147.82 176.2,147.24 175.94,146.99 175.18,146.99 172.18,143.98 172.18,141.01 176.91,136.27 176.91,93.43 168.64,85.16 146.11,85.16 142.54,81.59 130.3,81.59 125.87,77.16 109.32,77.16 106.39,74.24 106.39,68.11 101.65,63.37 99.3,63.37 98.2,62.26 98.2,58.69 98.56,58.33 98.56,55 100.5,53.06 100.86,53.06 101.46,52.45 CONN54_PF.6L8
  S12 w0.127: CONN54_PF.6L8 100.43,50.9 98.95,49.43 98.95,48.33 101.54,45.74 101.54,41.73 100.53,40.71 100.53,36.84 v1(99.97,36.29)
  BOTTOM w0.127: RB514.1 v1(99.97,36.29) 99.97,36.52 v2(99.13,37.35)
RXLOS_13: length 209
  TOP w0.127: v4(197.55,184.58) U9.R9
  S5 w0.127: v4(197.55,184.58) 198.24,184.58 198.85,183.97 198.85,173.07 193.66,167.88 189.37,167.88 186.71,165.22 186.71,160.16 186.5,159.95 186.5,156.69 183.29,153.48 183.29,146.72 182.21,145.64 182.21,145.51 181,144.31 181,138.97 180.22,138.19 180.22,90.38 170.61,80.77 147.87,80.77 143.75,76.65 137.73,76.65 133.77,72.69 130.14,72.69 129.6,72.15 129.6,69.95 129.04,69.39 128.42,69.39 127.38,68.35 127.38,62.04 125.11,59.77 125.11,57.78 122.63,55.3 CONN55_PF.1T8
  S9 w0.127: CONN55_PF.1T8 121.76,53.61 122.59,52.78 123.13,52.78 123.97,51.94 123.97,48.39 121.63,46.05 121.63,39.22 122.95,37.89 122.95,36.72 v1(123.38,36.29)
  BOTTOM w0.127: RB534.1 v1(123.38,36.29) 123.62,36.29 v2(124.29,36.95)
RXLOS_14: length 216.4
  TOP w0.127: v4(197.55,182.58) U9.U9
  S5 w0.127: v4(197.55,182.58) 197.02,182.05 197.02,181.18 197.22,180.97 197.22,180.31 196.99,180.08 196.99,176.73 193.96,173.7 193.96,170.79 192.78,169.61 189.3,169.61 185.15,165.46 185.15,162.48 184.05,161.38 184.05,156.26 181.96,154.16 181.96,147.48 180.88,146.4 180.88,146.09 179.29,144.5 179.29,139.17 178.95,138.83 178.95,91.44 169.93,82.42 147.31,82.42 143.24,78.35 132.2,78.35 126.58,72.74 115.85,72.74 114.86,71.75 114.86,55 116.8,53.06 117.16,53.06 117.76,52.45 CONN55_PF.1L8
  S12 w0.127: v1(116.27,36.29) 116.83,36.84 116.83,40.71 117.84,41.73 117.84,45.77 115.25,48.36 115.25,49.43 116.73,50.9 CONN55_PF.1L8
  BOTTOM w0.127: v2(115.43,37.35) 115.43,37.12 v1(116.27,36.29) RB532.1
RXLOS_15: length 198.1
  TOP w0.127: v4(203.55,183.58) U9.T14
  S5 w0.127: CONN55_PF.2T8 136.88,55.3 139.36,57.78 139.36,60.44 140.93,62.01 140.92,62.02 140.92,62.97 141.7,63.75 141.7,64.88 142.32,65.5 143.17,65.5 143.41,65.75 143.41,67.09 144.62,68.3 147.54,68.3 151.98,72.74 151.98,77.61 152.81,78.43 171.87,78.43 182.64,89.2 182.64,135.77 185,138.13 185,144.82 185.39,145.2 187.05,145.2 187.29,145.44 187.29,146.53 188.05,147.29 188.05,149.45 187.48,150.02 187.48,152.18 190.53,155.23 192.39,155.23 194.76,157.6 195.57,157.6 196.12,158.15 196.12,159.17 197.2,160.25 197.2,163.32 203.06,169.19 203.06,182.8 203.55,183.29 v4(203.55,183.58)
  S9 w0.127: CONN55_PF.2T8 136.01,53.8 136.69,53.12 137.03,53.12 138.22,51.94 138.22,48.39 135.75,45.92 135.75,44.25 135.28,43.79 135.28,42.92 135.88,42.33 135.88,39.22 137.2,37.89 137.2,36.72 v1(137.63,36.29)
  BOTTOM w0.127: v2(138.54,36.95) 138.3,36.95 v1(137.63,36.29) RB537.1
RXLOS_16: length 212
  TOP w0.127: v4(197.55,185.58) U9.P9
  S5 w0.127: v4(197.55,185.58) 198.28,185.58 198.8,185.06 199.74,185.06 200.04,184.76 200.04,183.21 200.7,182.55 200.7,182.09 201.11,181.68 201.11,180.4 200.35,179.64 200.35,168.79 195.54,163.99 195.54,161.39 193.58,159.42 192.81,159.42 192.24,158.85 192.24,157.64 191.8,157.2 190.21,157.2 184.18,151.17 184.18,146.28 183.47,145.56 183.47,145.31 182.91,144.75 182.91,143.69 183.57,143.03 183.57,140.15 181.23,137.81 181.23,89.92 171.32,80 148.43,80 144.49,76.06 144.49,74.71 144.06,74.28 137.78,74.28 135.3,71.8 135.3,63.1 134.72,62.52 130.12,62.52 128.11,60.51 128.11,59.46 129.11,58.46 129.11,54.7 130.46,53.35 131.19,53.35 132.01,52.52 CONN55_PF.2L8
  S12 w0.127: CONN55_PF.2L8 130.98,50.9 129.5,49.43 129.5,48.36 132.09,45.77 132.09,41.73 131.08,40.71 131.08,36.84 v1(130.52,36.29)
  BOTTOM w0.127: v2(129.68,37.35) 130.52,36.52 v1(130.52,36.29) RB535.1
RXLOS_17: length 195.2
  TOP w0.127: U9.N16 v4(205.55,186.58)
  S5 w0.127: CONN55_PF.3T8 151.03,55.3 152.75,57.02 152.75,58.6 154.27,60.12 154.27,73.7 156.62,76.05 172.98,76.05 185.16,88.22 185.16,134.49 190.6,139.94 190.6,145.01 194.53,148.93 194.53,153.64 195.42,154.53 197.83,154.53 201.83,158.53 201.83,164.19 209.82,172.18 209.82,184.96 208.74,186.04 206.43,186.04 206.11,186.36 205.77,186.36 v4(205.55,186.58)
  S16 w0.127: v1(151.88,36.29) 151.45,36.72 151.45,37.89 150.13,39.22 150.13,46.05 152.47,48.39 152.47,51.94 151.32,53.09 150.93,53.09 150.26,53.75 CONN55_PF.3T8
  BOTTOM w0.127: v2(152.79,36.95) 152.55,36.95 v1(151.88,36.29) RB540.1
RXLOS_18: length 200.4
  TOP w0.127: v4(204.55,185.58) U9.P15
  S5 w0.127: CONN55_PF.3L8 146.26,52.45 145.66,53.06 144.99,53.06 143.55,54.5 143.55,58.16 142.92,58.8 142.92,61.36 143.96,62.41 146.85,62.41 152.24,67.79 152.24,71.16 152.81,71.73 152.81,75.03 155.29,77.51 172.38,77.51 183.51,88.65 183.51,135.47 186.46,138.41 186.46,139.41 188.22,141.18 188.22,144.67 190.72,147.17 190.72,153.2 191.47,153.95 192.38,153.95 194.83,156.39 196.71,156.39 197.7,157.39 197.7,159.27 198.85,160.41 198.85,163.41 205.33,169.89 205.33,171.32 208.35,174.34 208.35,181.45 207.76,182.04 206.31,182.04 206.04,182.32 206.04,182.7 205.6,183.13 205.35,183.13 205.1,183.39 205.1,184.66 204.55,185.2 v4(204.55,185.58)
  S14 w0.127: CONN55_PF.3L8 145.23,50.9 143.75,49.43 143.75,48.36 146.34,45.77 146.34,41.73 145.33,40.71 145.33,39.98 144.77,39.42 v1(144.77,36.29)
  BOTTOM w0.127: v2(143.93,37.35) 144.77,36.52 v1(144.77,36.29) RB538.1
RXLOS_19: length 195.5
  TOP w0.127: U9.D14 v4(203.55,196.58)
  S5 w0.127: CONN55_PF.4T8 165.38,55.3 167.32,57.25 167.32,58.8 171.42,62.9 174.52,62.9 177.32,65.69 177.32,76.57 187.91,87.15 187.91,129.3 195.89,137.28 195.89,144.23 197.93,146.27 199.93,146.27 204.19,150.53 204.75,150.53 206.1,151.88 206.1,161 212.49,167.39 212.49,187.8 211.19,189.1 209.82,189.1 208.27,190.65 206.09,190.65 204.66,192.07 204.28,192.07 204,192.35 204,195.88 203.55,196.33 v4(203.55,196.58)
  S16 w0.127: CONN55_PF.4T8 164.51,53.61 165.34,52.78 165.88,52.78 166.72,51.94 166.72,48.39 164.38,46.05 164.38,39.22 165.7,37.89 165.7,36.72 v1(166.13,36.29)
  BOTTOM w0.127: RB519.1 v1(166.13,36.29) 166.8,36.95 v2(167.04,36.95)
RXLOS_20: length 189.4
  TOP w0.127: U9.L18 v4(207.55,188.58)
  S5 w0.127: CONN55_PF.4L8 160.51,52.45 159.91,53.06 159.55,53.06 157.61,55 157.61,58.56 157.3,58.87 157.3,61.2 162.53,66.42 162.53,70.46 166.34,74.27 172.51,74.27 186.35,88.11 186.35,134.03 191.48,139.16 191.48,144.44 194.14,147.1 195.67,147.1 196.43,147.86 198.26,147.86 204.05,153.66 204.05,164.73 210.82,171.49 210.82,185.61 207.85,188.58 v4(207.55,188.58)
  S14 w0.127: CONN55_PF.4L8 159.48,50.9 158,49.43 158,48.36 160.59,45.77 160.59,41.73 159.58,40.71 159.58,39.98 159.02,39.42 v1(159.02,36.29)
  BOTTOM w0.127: RB517.1 v1(159.02,36.29) 158.18,37.12 v2(158.18,37.35)
RXLOS_21: length 197.4
  TOP w0.127: U9.F18 v4(207.55,194.58)
  S5 w0.127: CONN55_PF.5T8 179.63,55.3 182.11,57.78 182.11,60.26 190.19,68.34 190.19,128.28 198.39,136.48 208.72,136.48 210.53,138.3 210.53,143.43 211.45,144.35 211.45,147.57 209.71,149.31 209.71,160.03 215.23,165.55 215.23,178.34 216.04,179.16 216.04,188.14 209.72,194.46 208.14,194.46 208.02,194.58 v4(207.55,194.58)
  S16 w0.127: CONN55_PF.5T8 178.76,53.8 179.45,53.11 179.79,53.11 180.97,51.94 180.97,48.39 178.63,46.05 178.63,44.07 178.91,43.79 178.91,42.99 178.63,42.71 178.63,39.22 179.95,37.89 179.95,36.72 v1(180.38,36.29)
  BOTTOM w0.127: v4(207.55,194.58) 207.78,194.58 208.25,195.04 212.44,195.04 v2(212.63,195.23) ; v2(181.29,36.95) 181.05,36.95 v1(180.38,36.29) RB522.1
RXLOS_22: length 194.6
  TOP w0.127: v4(207.55,191.58) U9.J18
  S5 w0.127: v4(207.55,191.58) 208.69,191.58 210.21,190.06 212.04,190.06 214.66,187.44 214.66,180.95 213.52,179.8 213.52,166.63 207.46,160.57 207.46,150.88 206.91,150.34 206.91,148.78 203.44,145.31 198.59,145.31 196.84,143.56 196.84,136.9 188.81,128.87 188.81,86.78 178.32,76.29 178.32,62.88 177.45,62.01 172.55,62.01 171.67,61.13 171.67,55.19 173.8,53.06 174.16,53.06 174.76,52.45 CONN55_PF.5L8
  S14 w0.127: v1(173.27,36.29) 173.83,36.84 173.83,40.71 174.84,41.73 174.84,45.77 172.25,48.36 172.25,49.43 173.73,50.9 CONN55_PF.5L8
  BOTTOM w0.127: RB520.1 v1(173.27,36.29) 173.27,36.52 v2(172.43,37.35) ; v2(210.91,191.62) 207.59,191.62 v4(207.55,191.58)
RXLOS_23: length 201.5
  TOP w0.127: v4(207.55,198.58) U9.B18
  S5 w0.127: v4(207.55,198.58) 211.33,198.58 218.47,191.44 218.47,175.87 219.23,175.11 219.23,170.85 217.9,169.52 217.9,163.27 215.25,160.62 215.25,151.34 214.56,150.66 214.56,142.38 213.45,141.27 213.45,136.52 211.12,134.19 199.9,134.19 192.79,127.08 192.79,84.89 197.46,80.23 197.46,61.91 196.36,60.8 196.36,57.78 193.88,55.3 CONN55_PF.6T8
  S16 w0.127: v1(194.63,36.29) 194.2,36.72 194.2,37.89 192.88,39.22 192.88,42.2 193.26,42.58 193.26,43.66 192.88,44.04 192.88,46.05 195.22,48.39 195.22,49.19 194.4,50.01 193.87,50.01 192.89,50.99 192.89,51.67 192.47,52.09 192.47,53.91 193.01,54.46 CONN55_PF.6T8
  BOTTOM w0.127: v4(207.55,198.58) 208.9,198.58 209.8,197.68 v2(211.26,197.68) ; RB525.1 v1(194.63,36.29) 195.3,36.95 v2(195.54,36.95)
RXLOS_24: length 203.5
  TOP w0.127: v4(200.55,197.58) U9.C11
  S5 w0.127: CONN55_PF.6L8 189.01,52.45 188.1,53.36 188.1,54.12 188.89,54.91 188.89,55.42 187.6,56.72 187.29,56.72 186.27,57.73 186.27,62.81 193.28,69.82 193.28,71.51 191.33,73.47 191.33,127.7 198.93,135.3 210.23,135.3 212.08,137.16 212.08,141.93 213.01,142.86 213.01,161.28 216.44,164.71 216.44,177.39 217.14,178.09 217.14,190.7 211.52,196.31 207,196.31 206.82,196.14 204.26,196.14 204.08,196.31 204.08,196.75 203.72,197.1 201.03,197.1 v4(200.55,197.58)
  S14 w0.127: CONN55_PF.6L8 187.98,50.9 186.5,49.43 186.5,48.36 189.09,45.77 189.09,41.73 187.85,40.49 187.85,36.62 v1(187.52,36.29)
  BOTTOM w0.127: RB523.1 v1(187.52,36.29) 187.52,36.52 v2(186.68,37.35)
RXSCLK_SET: length 143.7
  TOP w0.127: P1.A12 94.67,220.96 94.61,221.02 93.64,221.02 92.8,221.85 v1(92.8,222.03)
  S9 w0.127: v1(179.92,243.05) 179.23,243.75 173.57,243.75 173.09,244.23 162.6,244.23 159.9,246.94 146.92,246.94 146.55,247.3 144.43,247.3 143.09,248.64 138.84,248.64 138.08,247.88 135.86,247.88 135.16,248.57 131.24,248.57 128.61,245.95 100.07,245.95 96.27,242.16 92.33,242.16 88.64,238.47 88.64,236.59 89.18,236.05 89.18,228.47 89.93,227.72 89.93,226.81 91.03,225.71 91.34,225.71 91.77,225.28 91.77,224.92 92.79,223.9 92.79,222.04 v1(92.8,222.03)
  S12 w0.127: v1(196.03,231.98) 196.03,236.53 194.97,237.59 185.39,237.59 v1(179.92,243.05)
  BOTTOM w0.127: v1(196.03,231.98) 195.99,231.94 R1131.1
SATA0_RX_N: length 138
  TOP w0.127: J2.A20 153.44,140.59 153.34,140.69 153.34,141.1 153.72,141.48 153.72,142.54 153.85,142.67 154.26,142.67 v3(154.52,142.42) ; J3.43 136.51,248.43 136.61,248.54 140.32,248.54 140.43,248.42 140.43,248.26 140.05,247.88 v3(140.03,247.88)
  S12 w0.14: v3(154.52,142.42) 154.77,142.67 155.77,142.67 156.49,143.39 156.49,147.49 155.13,148.85 155.13,157.19 166.65,168.71 166.65,188.11 150.35,204.41 150.35,244.18 145.31,249.22 140.94,249.22 140.41,248.7 140.41,248.25 v3(140.03,247.88)
SATA0_RX_P: length 138
  TOP w0.127: J2.A19 152.94,140.59 153.04,140.69 153.04,141.23 153.42,141.6 153.42,142.67 153.72,142.98 154.26,142.98 v3(154.52,143.23) ; J3.41 136.51,248.93 136.61,248.84 140.44,248.84 140.73,248.55 140.73,248.19 v3(141.05,247.88)
  S12 w0.14: v3(154.52,143.23) 154.77,142.98 155.64,142.98 156.18,143.52 156.18,144.84 arc(156.11,145.01) 155.94,145.08 arc(155.77,145.15) 155.7,145.32 155.7,145.54 arc(155.77,145.71) 155.94,145.78 arc(156.11,145.85) 156.18,146.02 156.18,147.36 154.82,148.72 154.82,157.32 166.35,168.84 166.35,187.98 150.05,204.28 150.05,244.05 145.18,248.92 141.06,248.92 140.72,248.57 140.72,248.21 v3(141.05,247.88)
SATA0_TX_N: length 134
  TOP w0.127: J2.A17 151.94,140.59 151.84,140.69 151.84,141.6 151.44,142 151.44,142.55 151.57,142.67 151.74,142.67 v3(151.98,142.43) ; v3(138.51,246.35) 138.4,246.35 138.18,246.57 138.18,246.88 137.73,247.34 136.63,247.34 136.54,247.43 J3.47
  S12 w0.14: v3(151.98,142.43) 152.24,142.68 153.05,142.68 153.51,143.14 153.51,146.85 151.36,149 151.36,156.24 163.62,168.5 163.62,174.68 163.38,174.91 163.38,183.22 164.17,184.01 164.17,188.27 149.14,203.3 149.14,242.01 146.12,245.03 138.54,245.03 138.16,245.42 138.16,246 v3(138.51,246.35)
SATA0_TX_P: length 134
  TOP w0.127: J2.A16 151.44,140.59 151.54,140.69 151.54,141.48 151.14,141.88 151.14,142.67 151.44,142.98 151.72,142.98 v3(151.98,143.24) ; J3.49 136.53,246.93 136.63,247.03 137.6,247.03 137.88,246.76 137.88,246.57 137.66,246.35 v3(137.5,246.35)
  S12 w0.14: v3(151.98,143.24) 152.24,142.99 152.92,142.99 153.2,143.27 153.2,145.22 arc(153.14,145.36) 153,145.42 arc(152.85,145.48) 152.79,145.63 152.79,145.92 arc(152.85,146.06) 153,146.12 arc(153.14,146.18) 153.2,146.33 153.2,146.72 151.05,148.87 151.05,156.36 163.31,168.62 163.31,174.55 163.08,174.79 163.08,183.35 163.87,184.14 163.87,188.14 148.84,203.17 148.84,241.88 145.99,244.73 138.41,244.73 137.85,245.29 137.85,246 v3(137.5,246.35)
SCREW1: length 20.3
  TOP w0.508: C34.1 190.31,166.34 190.47,166.19 ; H4.1 191.33,165.86 C30.1 ; C28.1 193.36,165.17 ; 192.34,166.27 C33.1
  BOTTOM w0.127: v2(198.09,167.1) 195.27,167.1 H4.2
SCREW2: length 16.2
  TOP w0.381: 94.03,147.76 95.91,147.76 96.05,147.9 C250.1 C263.1 ; C214.1 C215.1 91.81,149.81 91.4,149.39 91.4,147.74
  BOTTOM w0.127: 89.54,143.26 v2(89.54,137.13)
SCREW3: length 23.9
  TOP w0.508: H2.3 147.58,259 C7.1 ; C3.1 147.8,257.98 147.51,257.7 ; C8.1 146.98,261.03 H2.2 ; C2.1 147.49,260.01 147.48,260 ; 144.68,256.05 144.75,255.98 145.4,255.98 145.75,255.63 ; 142.74,256.74 142.82,256.82
  BOTTOM w0.508: 147.6,257.85 151.1,257.85 152.24,256.7 v2(153.64,256.7)
SCREW4: length 22.6
  TOP w0.508: C247.1 10.4,256.34 10.19,256.13 ; 9.87,255.5 10.02,255.35 C259.1 ; 9.93,257.72 10.54,258.32 C217.1 ; C218.1 10.69,257.33 10.25,256.89
  BOTTOM w0.508: H6.4 10.5,253.4 v2(15.01,253.4)
SCREW5: length 21.8
  TOP w0.381: 214.36,225.51 214.32,225.55 C248.1 ; H7.7 214.14,227.57 C219.1 ; C220.1 214.07,226.56 H7.6 ; C260.1 213.98,228.6 214.17,228.41
  TOP w0.508: 218.76,225.07 218.68,225.14 ; 217.76,224.52 217.57,224.71
  BOTTOM w0.508: 214.47,229.65 211.67,232.45 v2(211.42,232.45)
SCREW6: length 27.5
  TOP w0.508: C38.1 264.7,255.43 264.76,255.5 ; 265.9,255.88 265.71,255.69 C9.1 ; 266.67,256.58 266.73,256.51 C4.1 ; C39.1 263.68,255.24 264.44,256
  BOTTOM w0.254: v2(261.39,250.35) 261.39,252.81 H3.5
SCREW7: length 18
  TOP w0.508: 263.49,95.73 263.27,95.51 C304.1 ; 264.38,95.35 264.28,95.25 C303.1 ; 266.16,95.98 266.33,95.82 C341.1 ; 265.4,95.48 265.3,95.38 C347.1
  BOTTOM w0.254: v2(261.97,104.62) 261.97,104.01 H8.1
SCREW8: length 23.6
  TOP w0.508: 248.27,224.47 C343.1 ; 246.19,225.1 245.22,224.14 C420.1 ; 249.27,228.01 249.7,228.45 249.8,228.34 ; C421.1 246.24,224.01 246.8,224.57 ; 247.25,224.62 C342.1 ; H10.3 249.64,227.33
  BOTTOM w0.127: v2(253.71,233.91) 253.25,233.91 H10.2
SCREW9: length 21.5
  TOP w0.381: 31.21,214.35 31.24,214.32 C344.1 ; 29.68,213.59 29.12,213.02 C422.1 ; 32.25,214.06 C345.1 ; C423.1 30.13,213.08 30.51,213.46
  BOTTOM w0.508: H11.6 27.84,214.24 v2(27.84,208.44)
SCREW10: length 23.8
  TOP w0.508: H25.3 208.51,140.46 C999.1 ; H25.1 207.46,144.75 C997.1 ; H25.2 208.5,143.16 C1000.1 ; H25.4 208.48,139.42 C998.1
  BOTTOM w0.508: H25.4 213.59,138.64 213.76,138.48 v2(213.76,138.43)
SCREW11: length 25.6
  TOP w0.508: 166.17,207.38 166.15,207.36 ; 166.15,207.36 H12.3 ; 166.15,207.36 C486.1 ; C516.1 166.59,205.33 166.21,205.71 ; C521.1 166.24,204.32 H12.4 ; C485.1 166.21,206.35
  BOTTOM w0.508: H12.2 167.73,211.57 v2(167.73,212.7)
SCREW12: length 45.7
  TOP w0.508: C549.1 104.98,75.27 101.33,71.63 ; C524.1 95.96,77 98.71,74.26 ; 96.85,73.49 94.35,75.98 C523.1 ; C544.1 103.38,76.31 100.56,73.49
  BOTTOM w0.508: H15.2 100.47,73.47 v2(103.58,76.58)
SCREW14: length 31.8
  TOP w0.381: 266.65,54.64 H17.2
  TOP w0.508: C736.1 267.36,56.23 266.16,55.03 ; C724.1 266.35,55.98 265.84,55.47 ; C735.1 264.32,55.88 H17.1 265.33,55.62 C725.1
  BOTTOM w0.254: v2(262.54,61.95) 262.54,55.03 H17.8
SCREW15: length 14.6
  TOP w0.508: C27.1 4.26,185.16 4.41,185.01 ; C24.1 5.3,185.48 5.9,184.89
  BOTTOM w0.508: H1.2 7.73,189.55 v2(6.91,190.37)
SCREW16: length 26.2
  TOP w0.508: C1002.1 125.16,135.07 128.21,138.12 ; 127.37,139.16 124.32,136.12 C1001.1 ; C1004.1 127.7,135.07 129.84,137.21 H26.5 ; 128.62,137.56 126.66,135.61 C1003.1
  BOTTOM w0.127: 132.77,140.5 H26.3
  BOTTOM w0.254: v2(137.84,142.55) 132.58,142.55 132.32,142.3
SCREW17: length 24.9
  TOP w0.508: C994.1 247.46,143.75 H24.1 ; C993.1 246.47,144.04 245.81,143.38 ; C995.1 245.46,143.33 245.74,143.05 ; H24.2 248.45,142.61 C996.1
  BOTTOM w0.254: v2(249.39,148.82) 249.39,142.65 249.4,142.65 249.4,142.07 249.39,142.06 249.39,140.58 H24.3
SCREW18: length 25.1
  TOP w0.508: C960.1 137.04,88.71 137.81,87.93 ; C963.1 140.03,90.83 140.86,89.99 140.86,88.6 141.53,87.93 ; C962.1 139.03,90.62 139.67,89.98 139.67,88.7 138.81,88.7 138.03,89.48 C961.1
  BOTTOM w0.254: H18.8 135.86,89.88 v2(135.86,93.38)
SCREW19: length 23
  TOP w0.508: C964.1 198.75,90.08 200.15,88.68 200.35,88.88 200.35,90.04 199.74,90.64 C965.1 ; C967.1 200.74,91.53 201.16,91.11 201.16,88.84 ; 202.01,87.91 201.74,88.18 C966.1
  BOTTOM w0.254: H19.8 194.21,91.98 v2(194.21,92.1)
SCREW20: length 41.4
  TOP w0.508: C970.1 264.26,181.74 264.68,181.31 ; C968.1 265.27,181.82 266.26,180.82 ; C969.1 266.26,180.82 ; 266.26,180.82 266.54,180.54 ; 263.27,181.8 C971.1
  BOTTOM w0.254: H20.8 262.79,186.28 v2(260.95,188.12)
SCREW21: length 22.2
  TOP w0.508: 199.24,114.7 199.26,114.69 ; 202.75,112.11 203.01,112.37 C972.1 ; C975.1 202.41,114.4 201.98,113.97 ; C974.1 203.23,111.29 202.91,111.61 ; 198.25,113.98 198.26,113.97 ; 203.42,113.07 203.74,113.38 C973.1 ; 200.24,114.86 200.12,114.74
  BOTTOM w0.254: H21.8 193.12,113.97 v2(192.24,114.84)
SCREW22: length 33.5
  TOP w0.508: 137.81,113.97 136.26,113.97 C979.1 ; C976.1 131.26,114.7 135.53,110.44 137.63,110.44 137.81,110.25 ; 136.71,111.43 135.71,111.43 132.28,114.86 C977.1 ; C978.1 133.27,115.36 136.52,112.11 137.04,112.11
  BOTTOM w0.254: v2(147.98,114.91) 142.47,114.91 H22.2
SCREW23: length 24.8
  TOP w0.127: 131.72,229.2 131.72,229.64 131.96,229.88
  TOP w0.508: H23.1 130.16,230.45 C981.1 ; 128.87,230.67 129.15,230.95 C980.1 ; H23.2 132.16,229.82 C983.1 ; 130.84,230.22 131.16,230.55 C982.1
  BOTTOM w0.508: v2(133.25,235.49) 133.25,230.91 H23.2
SFP+_P01_SCL: length 40.7
  S7 w0.127: v1(35.62,36.28) 36.94,34.96 36.94,30.79 v1(42.74,24.99)
  S16 w0.127: CONN54_PF.1T5 31.92,55.2 31.92,53.28 32.47,52.73 32.47,52.01 31.64,51.17 31.64,50.31 32.42,49.53 32.42,49.14 31.82,48.54 31.82,46.4 30.81,45.39 30.81,43.99 31.79,43.02 31.79,40.73 34.89,37.62 34.89,37.05 35.62,36.33 v1(35.62,36.28)
  BOTTOM w0.127: v2(37.38,37.13) 36.53,36.28 v1(35.62,36.28) RB456.1 ; v1(42.74,24.99) 42.86,25.11 RB640.1
SFP+_P01_SCL_R: length 13.9
  BOTTOM w0.127: RB640.2 45.11,24.6 46.92,24.6 47.14,24.83 RB641.2 49.59,25.11 v2(49.75,25.27) 49.88,25.27 51.45,26.85 54.86,26.85 55.29,26.42 UB13.5
SFP+_P01_SDA: length 41.7
  S7 w0.127: v1(42.74,23.96) 36.46,30.24 36.46,34.43 v1(35.62,35.27)
  S16 w0.127: CONN54_PF.1T4 31.01,52.85 28.01,49.84 28.01,48.15 30.09,46.06 30.09,39.39 31.03,38.45 31.8,38.45 34.98,35.27 v1(35.62,35.27)
  BOTTOM w0.127: v2(36.81,35.27) 36.81,35.27 v1(35.62,35.27) RB492.1 ; v1(42.74,23.96) 42.75,23.97 RB650.1
SFP+_P01_SDA_R: length 14.4
  BOTTOM w0.127: UB13.4 55.37,25.77 54.7,26.44 51.96,26.44 49.37,23.85 v2(48.12,23.85) 48,23.97 RB651.2 47.14,23.66 46.94,23.46 45.29,23.46 44.78,23.97 RB650.2
SFP+_P02_SCL: length 33.1
  S9 w0.127: v1(33.2,34.25) 40.18,27.28 v1(42.74,27.28)
  S14 w0.127: v1(33.2,34.25) 32.45,35.01 32.45,41.57 31.87,42.15 31.87,43.37 31.37,43.88 31.37,47.51 32.61,48.76 CONN54_PF.1L5
  BOTTOM w0.127: RB622.1 42.86,27.4 v1(42.74,27.28) v2(41.75,27.28) ; v1(33.2,34.25) RB527.1
SFP+_P02_SCL_R: length 13.2
  BOTTOM w0.127: UB13.7 55.25,27.72 55.13,27.84 50.44,27.84 v2(50.08,27.48) 50,27.4 RB623.2 47.14,27.17 46.87,26.89 45.11,26.89 RB622.2
SFP+_P02_SDA: length 37.2
  S9 w0.127: CONN54_PF.1L4 33.41,49.55 32.06,48.2 32.06,47.31 30.83,46.07 30.83,44.49 32.24,43.07 32.24,35.95 32.92,35.27 v1(33.2,35.27) 34.26,34.22 34.26,33.69 40,27.94 43.37,27.94 43.72,27.59 43.72,27.22 v1(42.74,26.24)
  BOTTOM w0.127: v1(33.2,35.27) RB491.1 ; RB630.1 42.75,26.25 v1(42.74,26.24) v2(41.86,25.36)
SFP+_P02_SDA_R: length 13.7
  BOTTOM w0.127: UB13.6 55.26,27.07 54.98,27.35 51.17,27.35 50.41,26.59 48.38,26.59 v2(48.17,26.39) 48.04,26.25 RB631.2 47.14,25.82 47.07,25.75 45.11,25.75 RB630.2
SFP+_P03_SCL: length 37.9
  S7 w0.127: v1(42.74,29.57) 44.59,31.42 48.45,31.42 49.04,32 49.04,35.24 v1(50.08,36.29)
  S9 w0.127: CONN54_PF.2T5 46.06,53.8 47.08,52.79 47.08,51.89 46.35,51.16 46.35,50.52 47.11,49.76 47.11,49.02 46.06,47.97 46.06,47.38 45.06,46.38 45.06,42.33 49.52,37.87 49.52,36.85 v1(50.08,36.29)
  BOTTOM w0.127: v1(42.74,29.57) 42.86,29.68 RB600.1 ; v2(50.99,36.95) 50.75,36.95 v1(50.08,36.29) RB459.1
SFP+_P03_SCL_R: length 13.2
  BOTTOM w0.127: UB13.9 55.24,29.02 55.06,29.21 49.04,29.21 v2(48.76,29.49) 48.56,29.68 RB601.2 47.14,29.45 46.87,29.17 45.11,29.17 RB600.2
SFP+_P03_SDA: length 38.2
  S7 w0.127: v1(42.74,28.53) 42.77,28.53 44.57,30.33 48.3,30.33 49.55,31.57 49.55,34.74 v1(50.08,35.27)
  S9 w0.127: v1(50.08,35.27) 49.22,36.14 49.22,37.72 44.78,42.15 44.78,46.48 45.65,47.35 45.65,47.95 46.73,49.02 46.73,49.68 45.99,50.42 45.99,51.23 46.73,51.97 46.73,52.75 45.26,54.22 CONN54_PF.2T4
  BOTTOM w0.127: v1(42.74,28.53) 42.75,28.54 RB609.1 ; RB495.1 v1(50.08,35.27) 50.76,35.27 v2(50.99,35.05)
SFP+_P03_SDA_R: length 13.1
  BOTTOM w0.127: RB609.2 45.11,28.03 46.94,28.03 47.14,28.23 RB610.2 52.31,28.54 v2(52.31,28.57) 55.03,28.57 55.23,28.37 UB13.8
SFP+_P04_SCL: length 29.1
  S7 w0.127: v1(42.74,31.85) 44.64,33.75 47.17,33.75 v1(47.67,34.25)
  S14 w0.127: v1(47.67,34.25) 46.46,35.47 46.46,36.27 45.65,37.08 45.65,47.58 47.31,49.25 47.31,50.31 46.86,50.76 CONN54_PF.2L5
  BOTTOM w0.127: RB583.1 42.86,31.97 v1(42.74,31.85) 42.74,31.71 41.48,30.44 v2(40.34,30.44) ; RB530.1 v1(47.67,34.25)
SFP+_P04_SCL_R: length 13.7
  BOTTOM w0.127: UB13.11 51.76,30.32 50.43,31.66 v2(49.05,31.66) 48.73,31.98 47.16,31.98 RB584.2 47.14,31.71 46.89,31.46 45.11,31.46 RB583.2
SFP+_P04_SDA: length 32.4
  S7 w0.127: v1(42.74,30.82) 42.8,30.82 44.52,32.53 47.64,32.53 48.2,33.09 48.2,34.74 v1(47.67,35.27)
  S14 w0.127: CONN54_PF.2L4 49.18,50.09 49.96,50.09 50.75,49.29 50.75,48.49 48.23,45.96 48.23,45.44 46.83,44.04 46.83,36.14 47.67,35.3 v1(47.67,35.27)
  BOTTOM w0.127: RB592.1 42.75,30.83 v1(42.74,30.82) 41.86,29.94 v2(41.86,29.3) ; RB494.1 v1(47.67,35.27)
SFP+_P04_SDA_R: length 13.5
  BOTTOM w0.127: UB13.10 51.19,29.67 v2(50.59,30.27) 50.04,30.83 RB593.2 47.14,30.52 46.94,30.32 45.11,30.32 RB592.2
SFP+_P05_SCL: length 43.1
  S7 w0.127: CONN54_PF.3T5 60.31,53.77 61.15,52.93 61.15,51.74 60.51,51.09 60.51,50.61 61.38,49.73 61.38,49.04 60.46,48.12 60.46,47.48 62.04,45.9 62.04,44.65 61.37,43.98 61.37,40.55 63.62,38.3 63.62,35.98 v1(64.33,35.27) 63.72,34.66 63.72,33.02 65.32,31.42 76.55,31.42 v1(77.04,30.93)
  BOTTOM w0.127: RB435.1 v1(64.33,35.27) 65.01,35.27 v2(65.24,35.05) ; v1(77.04,30.93) 76.97,30.85 RB587.1
SFP+_P05_SCL_R: length 13
  BOTTOM w0.127: UB13.14 67.05,30.32 67.18,30.45 70.19,30.45 v2(70.58,30.83) 70.6,30.83 70.62,30.85 RB586.2 72.78,30.67 73.1,30.34 74.56,30.34 RB587.2
SFP+_P05_SDA: length 53.8
  S7 w0.127: CONN54_PF.3T4 59.51,54.04 60.82,52.73 60.82,51.99 60.11,51.28 60.11,50.47 60.99,49.59 60.99,49.06 59.33,47.39 59.33,41.4 59.71,41.02 59.71,39.49 57.88,37.67 57.88,33.9 v1(57.22,33.24) 57.82,32.64 61.08,32.64 65.73,27.99 77.31,27.99 77.82,28.5 77.82,31.02 v1(77.04,31.79)
  BOTTOM w0.127: v1(77.04,31.79) 76.84,31.99 RB578.1 ; RB471.1 v1(57.22,33.24) v2(56.43,33.24)
SFP+_P05_SDA_R: length 13.3
  BOTTOM w0.127: RB578.2 74.56,31.49 72.9,31.49 72.78,31.61 RB577.2 70.02,31.99 69.06,31.04 v2(66.41,31.04) 66.35,30.97 UB13.13
SFP+_P06_SCL: length 39.9
  S7 w0.127: v1(61.92,34.25) 62.78,33.39 62.78,32.2 65.9,29.08 76.87,29.08 v1(77.04,28.91)
  S12 w0.127: CONN54_PF.3L5 61.11,49.16 59.35,47.39 59.35,41.44 59.9,40.89 59.9,37.08 60.71,36.27 60.71,35.47 v1(61.92,34.25)
  BOTTOM w0.127: RB603.1 76.7,28.57 v1(77.04,28.91) 77.47,28.48 v2(78.32,28.48) ; RB506.1 v1(61.92,34.25)
SFP+_P06_SCL_R: length 13
  BOTTOM w0.127: RB603.2 74.56,28.06 73.1,28.06 72.78,28.38 RB602.2 71.09,28.57 v2(70.91,28.75) 70.78,28.88 64.34,28.88 64.2,29.02 UB13.16
SFP+_P06_SDA: length 39.3
  S7 w0.127: v1(61.92,35.27) 63.19,34 63.19,32.92 65.8,30.3 76.54,30.3 v1(77.06,29.78)
  S12 w0.127: v1(61.92,35.27) 61.33,35.86 61.33,41.5 61.37,41.54 61.37,43.98 62.04,44.65 62.04,45.92 60.47,47.5 60.47,48.13 61.91,49.58 CONN54_PF.3L4
  BOTTOM w0.127: RB595.1 76.98,29.71 v1(77.06,29.78) 77.66,30.39 v2(78.13,30.39) ; RB470.1 v1(61.92,35.27)
SFP+_P06_SDA_R: length 13.2
  BOTTOM w0.127: RB595.2 75.06,29.32 74.9,29.16 73.02,29.16 72.78,29.4 RB594.2 72.73,29.66 68.9,29.66 68.89,29.67 v2(68.86,29.67) 68.86,29.67 UB13.15
SFP+_P07_SCL: length 36
  S7 w0.127: v1(78.58,35.27) 77.87,35.98 77.87,38.3 76.29,39.88 76.29,45.9 74.71,47.48 74.71,48.12 75.63,49.04 75.63,49.73 74.76,50.61 74.76,51.09 75.4,51.74 75.4,52.93 74.56,53.77 CONN54_PF.4T5
  S9 w0.127: v1(77.04,26.37) 77.16,26.37 79.21,28.42 79.21,34.64 v1(78.58,35.27)
  BOTTOM w0.127: v2(79.49,35.05) 79.26,35.27 v1(78.58,35.27) RB438.1 ; RB625.1 76.95,26.28 v1(77.04,26.37)
SFP+_P07_SCL_R: length 13.6
  BOTTOM w0.127: RB625.2 74.43,25.64 73.1,25.64 72.78,25.97 RB624.2 71.4,26.28 71.36,26.31 v2(71.31,26.31) 69.51,26.31 68.1,27.72 UB13.18
SFP+_P07_SDA: length 37
  S7 w0.127: CONN54_PF.4T4 73.76,54.09 75.1,52.75 75.1,51.88 74.49,51.27 74.49,50.34 75.24,49.59 75.24,49.06 73.58,47.39 73.58,40.89 73.88,40.59 73.88,37.36 73.24,36.73 73.24,35.01 v1(71.47,33.24)
  S9 w0.127: v1(77.04,27.21) 75.21,29.03 75.21,32.29 74.83,32.67 72.03,32.67 v1(71.47,33.24)
  BOTTOM w0.127: RB474.1 v1(71.47,33.24) v2(70.68,33.24) ; RB612.1 76.83,27.42 v1(77.04,27.21)
SFP+_P07_SDA_R: length 13.1
  BOTTOM w0.127: UB13.17 68.59,28.37 v2(69.49,27.48) 69.54,27.42 RB611.2 72.78,27.34 73.2,26.91 74.56,26.91 RB612.2
SFP+_P08_SCL: length 32.5
  S12 w0.127: CONN54_PF.4L5 75.36,50.9 75.36,49.16 73.6,47.39 73.6,41.44 74.15,40.89 74.15,37.08 74.96,36.27 74.96,35.47 v1(76.17,34.25) 75.61,33.69 75.61,32.79 76.43,31.97 76.43,24.68 v1(77.04,24.07)
  BOTTOM w0.127: v2(78.13,23.66) 77.45,23.66 v1(77.04,24.07) 76.97,23.99 RB644.1 ; RB509.1 v1(76.17,34.25)
SFP+_P08_SCL_R: length 14.7
  BOTTOM w0.127: UB13.20 63.51,26.42 67.1,22.83 70.3,22.83 v2(71.16,23.7) 71.46,23.99 RB643.2 72.78,23.91 73.18,23.51 74.58,23.51 RB644.2
SFP+_P08_SDA: length 32.8
  S12 w0.127: CONN54_PF.4L4 76.16,49.58 74.72,48.13 74.72,47.5 76.29,45.92 76.29,42.21 75.58,41.5 75.58,35.86 v1(76.17,35.27) 76.36,35.27 77.75,33.88 77.75,25.64 v1(77.04,24.93)
  BOTTOM w0.127: RB633.1 76.84,25.14 v1(77.04,24.93) 77.86,25.75 v2(78.07,25.75) ; RB473.1 v1(76.17,35.27)
SFP+_P08_SDA_R: length 13.7
  BOTTOM w0.127: RB633.2 74.56,24.63 72.98,24.63 72.78,24.83 RB632.2 69.8,25.14 67.83,27.1 v2(66.59,27.1) 66.56,27.07 UB13.19
SFP+_P09_SCL: length 56
  S7 w0.127: v1(116.09,25.12) 110.05,31.16 93.56,31.16 92.22,32.51 92.22,34.66 v1(92.83,35.27) 92.12,35.98 92.12,38.3 89.94,40.47 89.94,44.1 90.54,44.7 90.54,45.9 88.96,47.48 88.96,48.12 89.81,48.97 89.81,49.88 89.01,50.68 89.01,51.24 89.68,51.91 89.68,52.91 88.81,53.77 CONN54_PF.5T5
  BOTTOM w0.127: RB634.1 116.1,25.11 v1(116.09,25.12) ; v2(93.74,35.05) 93.51,35.27 v1(92.83,35.27) RB441.1
SFP+_P09_SCL_R: length 13.9
  BOTTOM w0.127: RB634.2 118.41,24.6 120.22,24.6 120.44,24.83 RB635.2 122.89,25.11 v2(123.05,25.27) 123.18,25.27 124.75,26.85 128.16,26.85 128.59,26.42 UB12.5
SFP+_P09_SDA: length 61.1
  S7 w0.127: v1(116.04,23.96) 109.5,30.5 91.93,30.5 90.01,32.42 86.54,32.42 v1(85.72,33.24) 86.53,34.05 86.53,35.79 88.15,37.41 88.15,40.49 87.83,40.81 87.83,47.47 89.49,49.14 89.49,49.79 88.74,50.54 88.74,51.38 89.4,52.04 89.4,52.7 88.01,54.09 CONN54_PF.5T4
  BOTTOM w0.127: RB645.1 116.05,23.97 v1(116.04,23.96) ; RB477.1 v1(85.72,33.24) v2(84.93,33.24)
SFP+_P09_SDA_R: length 14.4
  BOTTOM w0.127: UB12.4 128.67,25.77 128,26.44 125.26,26.44 122.67,23.85 v2(121.42,23.85) 121.3,23.97 RB646.2 120.44,23.66 120.24,23.46 118.59,23.46 118.08,23.97 RB645.2
SFP+_P10_SCL: length 49.7
  S9 w0.127: v1(90.41,34.26) 94.15,30.53 108.91,30.53 112.15,27.28 v1(116.04,27.28)
  S12 w0.127: CONN54_PF.5L5 89.61,49.26 87.85,47.5 87.85,41.44 88.4,40.89 88.4,36.91 89.21,36.11 89.21,35.44 90.39,34.26 v1(90.41,34.26)
  BOTTOM w0.127: RB613.1 116.16,27.4 v1(116.04,27.28) v2(115.05,27.28) ; v1(90.41,34.26) 90.41,34.25 RB512.1
SFP+_P10_SCL_R: length 13.2
  BOTTOM w0.127: RB613.2 118.41,26.89 120.17,26.89 120.44,27.17 RB614.2 123.3,27.4 v2(123.38,27.48) 123.74,27.84 128.43,27.84 128.55,27.72 UB12.7
SFP+_P10_SDA: length 53.3
  S9 w0.127: v1(116.04,26.24) 116.69,26.24 117.11,26.67 117.11,27.58 116.7,27.99 112.13,27.99 109.34,30.78 94.38,30.78 90.97,34.19 90.97,34.71 v1(90.42,35.27)
  S12 w0.127: v1(90.42,35.27) 89.88,35.81 89.88,44.04 90.54,44.7 90.54,45.92 88.97,47.5 88.97,48.13 90.41,49.58 CONN54_PF.5L4
  BOTTOM w0.127: v2(115.16,25.36) v1(116.04,26.24) 116.05,26.25 RB626.1 ; RB476.1 v1(90.42,35.27)
SFP+_P10_SDA_R: length 13.7
  BOTTOM w0.127: UB12.6 128.56,27.07 128.28,27.35 124.47,27.35 123.71,26.59 121.68,26.59 v2(121.47,26.39) 121.34,26.25 RB627.2 120.44,25.82 120.37,25.75 118.41,25.75 RB626.2
SFP+_P11_SCL: length 40.1
  S7 w0.127: v1(116.04,29.57) 112.92,29.57 110.48,32 106.75,32 106.11,32.64 106.11,34.29 107.08,35.26 v1(107.08,35.27) 106.37,35.98 106.37,37.79 104.79,39.37 104.79,45.9 103.21,47.48 103.21,48.12 104.13,49.04 104.13,49.73 103.26,50.61 103.26,51.09 104.08,51.91 104.08,52.76 103.06,53.77 CONN54_PF.6T5
  BOTTOM w0.127: v2(107.99,35.05) 107.76,35.27 v1(107.08,35.27) RB444.1 ; v1(116.04,29.57) 116.16,29.68 RB596.1
SFP+_P11_SCL_R: length 13.2
  BOTTOM w0.127: RB596.2 118.41,29.17 120.17,29.17 120.44,29.45 RB597.2 121.13,29.68 121.33,29.49 v2(122.06,29.49) 122.34,29.21 128.36,29.21 128.54,29.02 UB12.9
SFP+_P11_SDA: length 45.2
  S7 w0.127: v1(99.97,33.24) 100.68,33.95 100.68,37.61 102.38,39.31 102.38,40.59 102.08,40.89 102.08,47.42 103.83,49.17 103.83,49.63 102.81,50.64 102.81,51.13 103.78,52.09 103.78,52.55 102.26,54.06 CONN54_PF.6T4
  S9 w0.127: v1(116.04,28.53) 112.28,28.53 109.41,31.39 101.81,31.39 v1(99.97,33.24)
  BOTTOM w0.127: RB480.1 v1(99.97,33.24) v2(99.18,33.24) ; v1(116.04,28.53) 116.05,28.54 RB605.1
SFP+_P11_SDA_R: length 13.1
  BOTTOM w0.127: RB605.2 118.41,28.03 120.24,28.03 120.44,28.23 RB606.2 125.61,28.54 v2(125.61,28.57) 128.33,28.57 128.53,28.37 UB12.8
SFP+_P12_SCL: length 39
  S9 w0.127: v1(104.67,34.25) 107.25,31.67 109.79,31.67 111.37,30.1 116.35,30.1 116.91,30.66 116.91,31.04 116.09,31.85 v1(116.04,31.85)
  S12 w0.127: v1(104.67,34.25) 103.46,35.47 103.46,36.27 102.65,37.08 102.65,40.89 102.1,41.44 102.1,47.45 103.86,49.21 CONN54_PF.6L5
  BOTTOM w0.127: RB515.1 v1(104.67,34.25) ; RB579.1 116.16,31.97 v1(116.04,31.85) 116.04,31.71 114.78,30.44 v2(113.64,30.44)
SFP+_P12_SCL_R: length 13.7
  BOTTOM w0.127: RB579.2 118.41,31.46 120.19,31.46 120.44,31.71 RB580.2 121.69,31.97 v2(122.27,31.4) 123.99,31.4 125.06,30.32 UB12.11
SFP+_P12_SDA: length 35.1
  S9 w0.127: v1(104.67,35.27) 105.31,34.63 105.31,34.21 107.28,32.23 109.85,32.23 111.26,30.82 v1(116.04,30.82)
  S12 w0.127: v1(104.67,35.27) 104.08,35.86 104.08,41.5 104.79,42.21 104.79,45.92 103.22,47.5 103.22,48.13 104.66,49.58 CONN54_PF.6L4
  BOTTOM w0.127: v2(115.16,29.3) 115.16,29.94 v1(116.04,30.82) 116.05,30.83 RB588.1 ; RB479.1 v1(104.67,35.27)
SFP+_P12_SDA_R: length 13.5
  BOTTOM w0.127: UB12.10 124.6,29.67 123.99,30.27 v2(123.89,30.27) 123.84,30.32 122.27,30.32 121.77,30.83 RB589.2 120.44,30.52 120.24,30.32 118.41,30.32 RB588.2
SFP+_P13_SCL: length 57.1
  S7 w0.127: v1(150.34,30.93) 149.85,31.42 138.62,31.42 138.57,31.47 123.69,31.47 122.72,32.43 122.72,34.69 123.3,35.27 v1(123.38,35.27) 122.67,35.98 122.67,37.57 121.09,39.14 121.09,45.9 119.51,47.48 119.51,48.21 120.32,49.03 120.32,49.84 119.54,50.62 119.54,51.25 120.2,51.92 120.2,52.93 119.36,53.77 CONN55_PF.1T5
  BOTTOM w0.127: RB462.1 v1(123.38,35.27) 124.06,35.27 v2(124.29,35.05) ; v1(150.34,30.93) 150.27,30.85 RB591.1
SFP+_P13_SCL_R: length 13
  BOTTOM w0.127: UB12.14 143.39,30.32 143.88,30.81 v2(143.88,30.83) 143.9,30.83 143.92,30.85 RB590.2 146.08,30.67 146.4,30.34 147.86,30.34 RB591.2
SFP+_P13_SDA: length 68.2
  S7 w0.127: CONN55_PF.1T4 118.56,54.12 119.93,52.75 119.93,52.02 119.29,51.37 119.29,50.48 120.04,49.72 120.04,49.14 118.38,47.48 118.38,41.12 118.86,40.64 118.86,37.69 117.8,36.62 117.8,34.77 v1(116.27,33.24) 118.06,31.44 120.16,31.44 123.61,27.99 150.61,27.99 151.12,28.5 151.12,31.29 150.62,31.79 v1(150.34,31.79)
  BOTTOM w0.127: v2(115.48,33.24) v1(116.27,33.24) RB498.1 ; v1(150.34,31.79) 150.14,31.99 RB582.1
SFP+_P13_SDA_R: length 13.3
  BOTTOM w0.127: UB12.13 139.65,30.97 v2(139.71,31.04) 142.89,31.04 143.84,31.99 RB581.2 146.08,31.61 146.2,31.49 147.86,31.49 RB582.2
SFP+_P14_SCL: length 55.1
  S7 w0.127: v1(120.97,34.25) 120.36,33.65 120.36,33.07 124.35,29.08 150.17,29.08 v1(150.34,28.91)
  S12 w0.127: CONN55_PF.1L5 120.16,49.16 118.4,47.39 118.4,41.44 118.95,40.89 118.95,37.08 119.76,36.27 119.76,35.47 v1(120.97,34.25)
  BOTTOM w0.127: RB608.1 150,28.57 v1(150.34,28.91) 151.56,28.91 v2(151.86,28.61) ; RB533.1 v1(120.97,34.25)
SFP+_P14_SCL_R: length 13
  BOTTOM w0.127: RB608.2 147.86,28.06 146.4,28.06 146.08,28.38 RB607.2 144.39,28.57 v2(144.21,28.75) 144.08,28.88 137.64,28.88 137.5,29.02 UB12.16
SFP+_P14_SDA: length 54.6
  S7 w0.127: v1(120.97,35.27) 122.29,33.95 122.29,31.9 123.89,30.3 149.84,30.3 v1(150.36,29.78)
  S12 w0.127: CONN55_PF.1L4 120.96,49.58 119.52,48.13 119.52,47.5 121.09,45.92 121.09,42.21 120.38,41.5 120.38,35.86 v1(120.97,35.27)
  BOTTOM w0.127: RB497.1 v1(120.97,35.27) ; v2(151.86,30.58) 151.06,29.78 v1(150.36,29.78) 149.35,29.78 RB599.1
SFP+_P14_SDA_R: length 13.2
  BOTTOM w0.127: RB599.2 148.36,29.32 148.2,29.16 146.32,29.16 146.08,29.4 RB598.2 146.03,29.66 142.2,29.66 v2(142.18,29.69) 142.16,29.67 UB12.15
SFP+_P15_SCL: length 42.8
  S7 w0.127: CONN55_PF.2T5 133.61,53.77 134.45,52.93 134.45,51.74 133.81,51.09 133.81,50.61 134.68,49.73 134.68,49.04 133.76,48.12 133.76,47.48 135.34,45.9 135.34,44.42 134.78,43.85 134.78,42.01 135.34,41.44 135.34,39.14 136.92,37.57 136.92,35.98 v1(137.63,35.27)
  S9 w0.127: v1(150.34,26.37) 149.81,26.9 147.06,26.9 143.81,30.15 142.61,30.15 137.63,35.13 v1(137.63,35.27)
  BOTTOM w0.127: v2(138.54,35.05) 138.31,35.27 v1(137.63,35.27) RB465.1 ; RB629.1 150.25,26.28 v1(150.34,26.37)
SFP+_P15_SCL_R: length 13.6
  BOTTOM w0.127: RB629.2 147.73,25.64 146.4,25.64 146.08,25.97 RB628.2 144.7,26.28 144.66,26.31 v2(144.61,26.31) 142.42,26.31 141.01,27.72 UB12.18
SFP+_P15_SDA: length 56.4
  S7 w0.127: v1(130.52,33.24) 132.05,34.77 132.05,36.62 133.11,37.69 133.11,40.64 132.63,41.12 132.63,47.39 134.29,49.06 134.29,49.72 133.36,50.65 133.36,51.2 134.18,52.02 134.18,52.75 132.81,54.12 CONN55_PF.2T4
  S9 w0.127: v1(130.52,33.24) 130.55,33.24 136.87,26.92 143.68,26.92 147.17,23.43 151.11,23.43 151.35,23.67 151.35,26.2 v1(150.34,27.21)
  BOTTOM w0.127: RB501.1 v1(130.52,33.24) v2(129.66,33.24) ; v1(150.34,27.21) 150.13,27.42 RB616.1
SFP+_P15_SDA_R: length 13.1
  BOTTOM w0.127: RB616.2 147.86,26.91 146.5,26.91 146.08,27.34 RB615.2 142.85,27.42 v2(142.84,27.41) 142.65,27.41 141.69,28.37 UB12.17
SFP+_P16_SCL: length 41.7
  S9 w0.127: v1(150.34,24.07) 149.88,24.53 147.13,24.53 143.56,28.1 140.34,28.1 135.78,32.66 135.78,33.7 135.23,34.25 v1(135.22,34.25)
  S12 w0.127: CONN55_PF.2L5 134.41,49.16 132.65,47.39 132.65,41.44 133.2,40.89 133.2,37.08 134.01,36.27 134.01,35.47 v1(135.22,34.25)
  BOTTOM w0.127: v2(151.41,23.02) 151.39,23.02 v1(150.34,24.07) 150.27,23.99 RB648.1 ; RB536.1 v1(135.22,34.25)
SFP+_P16_SCL_R: length 14.7
  BOTTOM w0.127: RB648.2 147.88,23.51 146.48,23.51 146.08,23.91 RB647.2 144.71,23.99 144.46,23.75 v2(144.46,23.7) 143.55,23.7 142.68,22.83 140.4,22.83 136.81,26.42 UB12.20
SFP+_P16_SDA: length 41.2
  S9 w0.127: v1(135.22,35.27) 135.28,35.27 136.49,34.06 136.49,32.89 140.55,28.83 143.96,28.83 147.08,25.7 149.52,25.7 150.29,24.93 v1(150.34,24.93)
  S12 w0.127: v1(135.22,35.27) 134.63,35.86 134.63,41.5 135.34,42.21 135.34,45.92 133.77,47.5 133.77,48.13 135.21,49.58 CONN55_PF.2L4
  BOTTOM w0.127: v2(151.29,25.31) 150.72,25.31 v1(150.34,24.93) 150.14,25.14 RB637.1 ; RB500.1 v1(135.22,35.27)
SFP+_P16_SDA_R: length 13.7
  BOTTOM w0.127: RB637.2 147.86,24.63 146.28,24.63 146.08,24.83 RB636.2 142.48,25.14 140.52,27.1 v2(139.89,27.1) 139.86,27.07 UB12.19
SFP+_P17_SCL: length 39.5
  S7 w0.127: v1(158.79,24.99) 158.79,25.42 154.24,29.97 154.24,30.15 151.07,33.32 151.07,34.46 v1(151.88,35.27) 151.17,35.98 151.17,37.57 149.59,39.14 149.59,45.9 148.01,47.48 148.01,48.12 148.93,49.04 148.93,49.73 148.06,50.61 148.06,51.09 148.7,51.74 148.7,52.93 147.86,53.77 CONN55_PF.3T5
  BOTTOM w0.127: RB468.1 v1(151.88,35.27) 152.56,35.27 v2(152.79,35.05) ; v1(158.79,24.99) 158.91,25.11 RB247.1
