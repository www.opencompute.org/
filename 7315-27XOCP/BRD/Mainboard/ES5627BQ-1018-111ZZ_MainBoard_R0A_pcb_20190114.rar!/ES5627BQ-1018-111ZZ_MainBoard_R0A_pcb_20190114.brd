# Allegro board ES5627BQ-1018-111ZZ_MainBoard_R0A_pcb_20190114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDRA_DQ11: length 58.2
  TOP w0.127: v4(28.7,133.65) U40.AT29
  S9 w0.127: v4(28.7,133.65) 28.7,133.88 28.29,134.29 28.29,139.53 30.78,142.02 30.78,149.66 35.98,154.87 35.98,158.54 35.84,158.69 33.96,158.69 33.75,158.9 33.75,159.87 33.52,160.1 32.83,160.1 32.6,160.32 32.6,160.64 32.83,160.86 33.75,160.86 33.98,161.08 33.98,161.52 33.72,161.77 32.41,161.77 32.25,161.94 32.25,162.54 32.39,162.68 33.54,162.68 33.75,162.89 33.75,163.27 33.57,163.45 31.92,163.45 31.77,163.6 31.77,164.14 31.61,164.3 28.43,164.3 28.03,163.9 28.03,159.6 27.37,158.94 27.37,157.98 27.01,157.62 26.31,157.62 26.06,157.88 26.06,158.49 25.85,158.7 25.39,158.7 25.23,158.86 25.23,159.49 v4(24.82,159.89)
  BOTTOM w0.13: UB5.C7 v4(24.82,159.89)
DDRA_DQ12: length 58.3
  TOP w0.127: v4(24.7,134.65) U40.AU33
  S9 w0.127: v4(24.7,134.65) 24.32,134.65 24.21,134.76 24.21,139.16 26.96,141.92 26.96,143.17 26.06,144.07 26.06,152.08 25.57,152.58 22.68,152.58 22.03,153.23 22.03,158.53 21.22,159.34 21.22,160.08 20.99,160.3 20.59,160.3 20.43,160.46 20.43,161.69 20.64,161.9 20.99,161.9 21.22,162.13 21.22,170.58 21.25,170.61 21.25,171.5 21.47,171.72 22.5,171.72 22.88,171.35 22.88,162.61 20.96,160.69 v4(20.83,160.69)
  BOTTOM w0.13: UB5.C2 v4(20.83,160.69)
DDRA_DQ13: length 58.1
  TOP w0.127: v4(29.7,132.65) U40.AR28
  S9 w0.127: v4(29.7,132.65) 29.7,132.95 30.09,133.35 30.09,134.85 30.4,135.15 30.93,135.15 31.79,136.02 31.79,138.37 31.57,138.6 30.16,138.6 29.94,138.82 29.94,139.13 30.16,139.36 31.57,139.36 31.79,139.58 31.79,149.24 37.66,155.11 37.66,164.96 36.71,165.91 34.41,165.91 33.8,165.3 32.6,165.3 32.38,165.53 29.84,165.53 29.68,165.38 27.55,165.38 27.02,164.84 27.02,160.42 26.89,160.3 25.92,160.3 25.63,160 v4(25.63,159.89)
  BOTTOM w0.13: UB5.C8 v4(25.63,159.89)
DDRA_DQ14: length 58.3
  TOP w0.127: v4(26.7,132.65) U40.AR31
  S9 w0.127: v4(26.7,132.65) 26.7,132.8 26.28,133.22 26.28,139.62 27.98,141.32 27.98,142.86 28.1,142.99 28.79,142.99 28.92,143.12 28.92,143.63 28.79,143.75 28.1,143.75 27.42,144.44 27.42,146.58 28.92,148.09 28.92,150.56 27.91,151.58 27.91,154.56 26.33,156.14 24.38,156.14 23.11,157.4 23.11,158.51 24.43,159.83 24.43,170.45 24.15,170.74 23.69,170.74 23.38,170.43 23.38,162.38 v4(21.66,160.66)
  BOTTOM w0.13: UB5.D3 v4(21.66,160.66)
DDRA_DQ15: length 58.3
  TOP w0.127: v4(29.7,131.65) U40.AP28
  S9 w0.127: v4(29.7,131.65) 30.16,132.11 30.16,132.8 30.5,133.14 30.95,133.14 31.19,133.38 31.19,134.69 32.3,135.8 32.3,149.03 38.98,155.71 38.98,164.36 36.69,166.65 35.6,166.65 35.24,166.29 34,166.29 33.57,165.86 29.61,165.86 29.45,166.01 26.98,166.01 26.55,165.57 25.49,165.57 25.23,165.31 25.23,160.98 24.94,160.69 v4(24.82,160.69)
  BOTTOM w0.13: UB5.D7 v4(24.82,160.69)
DDRA_DQ16: length 42.8
  TOP w0.127: v4(28.7,129.65) U40.AM29
  S5 w0.127: v4(28.7,129.65) 28.19,130.15 28.19,138.01 29.08,138.9 29.08,142.29 29.42,142.63 29.42,147.86 29.19,148.08 28.18,148.08 27.96,148.31 27.96,148.62 28.18,148.84 29.19,148.84 29.42,149.07 29.42,149.38 29.19,149.61 28.05,149.61 27.83,149.83 27.83,150.14 28.05,150.37 29.19,150.37 29.42,150.59 29.42,155.85 29.19,156.07 28.7,156.07 28.48,156.29 28.48,156.61 28.7,156.83 29.95,156.83 30.17,157.05 30.17,162.7 v4(30.57,163.09)
  BOTTOM w0.127: UB6.G2 v4(30.57,163.09)
DDRA_DQ17: length 42.8
  TOP w0.127: v4(29.7,128.65) U40.AL28
  S5 w0.127: v4(34.56,162.28) 34.95,161.89 34.95,159.76 35.22,159.48 35.91,159.48 36.67,158.72 36.67,135.74 36.19,135.26 36.19,131.42 35.92,131.15 35.48,131.15 35.1,130.77 35.1,130.43 34.82,130.15 34.51,130.15 34.19,129.83 34.19,129.43 33.92,129.15 33.53,129.15 33.16,128.79 33.16,128.45 32.88,128.17 29.63,128.17 29.53,128.27 29.53,128.48 v4(29.7,128.65)
  BOTTOM w0.127: v4(34.56,162.28) UB6.F7
DDRA_DQ18: length 43
  TOP w0.127: v4(28.7,130.65) U40.AN29
  S5 w0.127: v4(28.7,130.65) 29.19,131.14 29.19,136.63 28.95,136.88 28.95,138.05 29.59,138.69 29.59,142.08 30.97,143.47 30.97,148.75 30.75,148.97 30.15,148.97 29.92,149.19 29.92,149.51 30.15,149.73 30.75,149.73 30.97,149.95 30.97,150.27 30.75,150.49 30.24,150.49 30.01,150.72 30.01,151.03 30.24,151.26 30.75,151.26 30.97,151.48 30.97,151.79 30.75,152.02 30.24,152.02 30.01,152.24 30.01,152.56 30.24,152.78 30.75,152.78 30.97,153 30.97,153.32 30.75,153.54 30.24,153.54 30.01,153.76 30.01,154.08 30.24,154.3 30.75,154.3 30.97,154.53 30.97,154.84 30.75,155.07 30.24,155.07 30.01,155.29 30.01,155.6 30.24,155.83 30.75,155.83 30.97,156.05 30.97,162.92 30.97,162.92 30.97,163.25 30.97,163.25 30.97,163.5 v4(31.37,163.89)
  BOTTOM w0.13: UB6.H3 v4(31.37,163.89)
DDRA_DQ19: length 42.8
  TOP w0.127: U40.AL25 v4(32.7,128.65)
  S5 w0.127: v4(32.7,128.65) 32.7,128.94 33.21,129.45 33.21,129.85 33.57,130.2 33.95,130.2 34.23,130.48 34.23,130.87 34.48,131.12 34.84,131.12 35.09,131.37 35.09,134.89 36.16,135.95 36.16,152.98 35.94,153.21 35.32,153.21 35.09,153.43 35.09,153.74 35.32,153.97 36.03,153.97 36.16,154.1 36.16,154.58 36.01,154.73 35.32,154.73 35.09,154.95 35.09,155.32 35.27,155.49 35.94,155.49 36.16,155.71 36.16,156.13 34.13,158.16 34.13,163.45 v4(34.57,163.89)
  BOTTOM w0.13: UB6.H7 34.97,164.29 v4(34.57,163.89)
DDRA_DQ20: length 42.8
  TOP w0.127: v4(27.7,130.65) U40.AN30
  S5 w0.127: v4(30.57,163.89) 30.17,163.5 29.46,163.5 29.37,163.41 29.37,159.33 27.97,157.93 27.97,151.01 27.21,150.25 27.21,143.29 27.44,143.06 28.29,143.06 28.51,142.84 28.51,142.52 28.29,142.3 27.44,142.3 27.21,142.08 27.21,141.76 27.44,141.54 28.29,141.54 28.51,141.32 28.51,141 28.29,140.78 27.44,140.78 27.21,140.55 27.21,140.24 27.44,140.02 28.29,140.02 28.51,139.79 28.51,139.48 28.29,139.25 27.44,139.25 27.21,139.03 27.21,131.13 v4(27.7,130.65)
  BOTTOM w0.13: UB6.H2 v4(30.57,163.89)
DDRA_DQ21: length 42.9
  TOP w0.127: v4(29.7,129.65) U40.AM28
  S5 w0.127: v4(35.36,163.89) 34.96,164.29 34.25,164.29 33.62,163.66 33.62,157.95 34.59,156.99 34.59,152.78 35.65,151.71 35.65,136.67 34.21,135.23 34.21,131.5 33.85,131.14 33.63,131.14 33.2,130.71 33.2,130.59 32.78,130.17 32.53,130.17 32.2,129.84 32.2,129.59 31.79,129.18 30.16,129.18 v4(29.7,129.65)
  BOTTOM w0.127: UB6.H8 v4(35.36,163.89)
DDRA_DQ22: length 42.9
  TOP w0.127: v4(31.7,130.65) U40.AN26
  S5 w0.127: v4(32.16,164.69) 32.61,164.24 32.61,157.53 33.57,156.57 33.57,148.62 34.38,147.8 34.38,146.98 34.16,146.76 33.79,146.76 33.57,146.54 33.57,146.22 33.79,146 34.16,146 34.38,145.78 34.38,145.46 34.16,145.24 33.79,145.24 33.57,145.01 33.57,144.7 33.79,144.48 34.16,144.48 34.38,144.25 34.38,143.94 34.16,143.71 33.79,143.71 33.57,143.49 33.57,143.17 33.79,142.95 34.16,142.95 34.38,142.73 34.38,142.41 34.16,142.19 33.79,142.19 33.57,141.97 33.57,141.65 33.79,141.43 34.16,141.43 34.38,141.2 34.38,140.89 34.16,140.67 33.79,140.67 33.57,140.44 33.57,140.13 33.79,139.9 34.16,139.9 34.48,139.58 34.48,138.4 32.26,136.17 32.26,131.49 31.7,130.93 v4(31.7,130.65)
  BOTTOM w0.13: v4(32.16,164.69) 31.77,165.08 UB6.J3
DDRA_DQ23: length 42.8
  TOP w0.127: v4(31.7,129.65) U40.AM26
  S5 w0.127: v4(31.7,129.65) 31.7,129.95 32.14,130.39 32.14,130.76 32.53,131.16 32.95,131.16 33.22,131.42 33.22,136.07 34.99,137.84 34.99,148.38 34.77,148.6 34.3,148.6 34.08,148.83 34.08,149.14 34.3,149.37 34.77,149.37 34.99,149.59 34.99,149.91 34.77,150.13 34.3,150.13 34.08,150.35 34.08,150.67 34.3,150.89 34.91,150.89 35.09,151.08 35.09,151.43 34.87,151.65 34.29,151.65 34.08,151.86 34.08,156.78 33.11,157.74 33.11,163.87 33.89,164.65 34.11,164.74 34.51,164.74 v4(34.53,164.72)
  BOTTOM w0.13: v4(34.53,164.72) 34.91,165.09 UB6.J7
DDRA_DQ24: length 60.3
  TOP w0.127: v4(31.7,127.65) U40.AK26
  S7 w0.127: v4(31.7,127.65) 31.63,127.58 31.33,127.58 31.26,127.66 31.26,127.94 31.39,128.07 31.79,128.07 32.13,128.41 32.13,128.88 32.39,129.14 33.02,129.14 33.24,129.36 33.24,129.86 33.42,130.04 34.05,130.04 34.15,130.15 34.15,130.6 34.28,130.73 34.76,130.73 34.89,130.6 34.89,130.2 35.05,130.04 37.68,130.04 38.09,130.45 38.09,135.84 40.88,138.63 40.88,139.39 41.09,139.6 41.47,139.6 41.6,139.72 41.6,140.18 41.42,140.36 40.63,140.36 40.48,140.51 40.48,140.9 40.7,141.12 41.44,141.12 41.6,141.28 41.6,143.61 41.2,144.01 41.2,150.85 40.96,151.09 40.96,154.66 38.03,157.59 38.03,160.11 37.36,160.78 37.36,161.09 37.49,161.22 37.49,161.54 37.27,161.76 36.95,161.76 36.82,161.63 36.51,161.63 36.25,161.89 34.16,161.89 33.54,161.27 33.54,160.14 33.33,159.93 31.89,159.93 31.53,160.28 31.2,160.28 30.97,160.05 30.97,158.8 31.08,158.7 31.72,158.7 31.79,158.77 31.97,158.77 32.1,158.65 32.1,158.24 31.92,158.06 31.6,158.06 v4(31.37,158.29)
  BOTTOM w0.127: v4(31.37,158.29) UB6.A3
DDRA_DQ25: length 60.3
  TOP w0.127: v4(25.7,129.65) U40.AM32
  S7 w0.127: v4(35.36,159.09) 34.97,158.69 34.97,157.88 35.26,157.59 35.26,155.87 35.11,155.71 34.4,155.71 34.18,155.5 34.18,155.11 34.39,154.9 35.94,154.9 36.16,154.67 36.16,154.36 35.94,154.13 34.39,154.13 34.17,153.91 34.17,153.59 34.39,153.37 35.84,153.37 36.06,153.15 36.06,152.83 35.84,152.61 34.39,152.61 34.17,152.39 34.17,152.07 34.39,151.85 35.91,151.85 36.13,151.62 36.13,151.31 35.91,151.09 34.39,151.09 34.17,150.86 34.17,150.55 34.39,150.32 35.91,150.32 36.13,150.1 36.13,149.78 35.91,149.56 34.39,149.56 34.17,149.34 34.17,146.29 34.65,145.8 34.65,139.16 33.27,137.77 32.95,137.77 32.68,138.04 32.37,138.04 32.14,137.81 32.14,137.5 32.41,137.23 32.41,136.92 30.23,134.73 30.23,131.52 29.9,131.19 29.49,131.19 29.15,130.86 29.15,130.41 28.9,130.15 28.45,130.15 28.2,129.9 28.2,129.39 27.94,129.14 27.56,129.14 27.18,128.76 27.18,125.45 26.93,125.2 26.42,125.2 26.19,125.43 26.19,128.86 25.7,129.35 v4(25.7,129.65)
  BOTTOM w0.381: UB6.B8 v4(35.36,159.09)
DDRA_DQ26: length 60.5
  TOP w0.127: U40.AH27 v4(30.7,125.65)
  S7 w0.127: v4(30.7,125.65) 30.7,125.88 30.19,126.39 30.19,127.86 30.45,128.12 30.88,128.12 31.24,128.48 31.24,128.88 31.5,129.14 31.75,129.14 32.13,129.52 32.13,129.77 32.51,130.15 32.9,130.15 33.15,130.41 33.15,130.81 33.49,131.14 35.75,131.14 36.3,131.7 36.3,135.12 36.55,135.36 36.55,135.68 35.63,136.6 35.63,136.92 35.85,137.14 36.17,137.14 37.14,136.17 37.46,136.17 37.68,136.39 37.68,136.71 36.68,137.7 36.68,138.02 36.9,138.24 37.22,138.24 38.3,137.16 38.57,137.16 38.82,137.4 38.82,137.72 37.89,138.65 37.89,138.97 38.11,139.19 38.43,139.19 39.17,138.44 39.35,138.44 39.66,138.76 39.66,139.8 39.66,140.81 40.65,141.8 40.65,144.45 40.69,144.49 40.69,150.64 40.45,150.88 40.45,154.45 38.34,156.57 37.52,157.38 37.52,159.9 36.34,161.08 34.4,161.08 34.05,160.73 34.05,159.68 33.78,159.42 31.84,159.42 v4(31.37,159.89)
  BOTTOM w0.13: UB6.C3 v4(31.37,159.89)
DDRA_DQ27: length 60.3
  TOP w0.127: v4(27.7,127.65) U40.AK30
  S7 w0.127: v4(34.52,159.85) 34.89,159.48 35.53,159.48 35.78,159.23 35.78,156.34 36.67,155.45 36.67,149.2 36.44,148.98 34.87,148.98 34.68,148.78 34.68,148.37 34.83,148.21 36.61,148.21 36.8,148.03 36.8,147.62 36.63,147.45 34.85,147.45 34.68,147.28 34.68,146.84 34.83,146.69 36.61,146.69 36.8,146.5 36.8,146.12 36.6,145.93 35.38,145.93 35.16,145.71 35.16,145.39 35.38,145.17 36.63,145.17 36.82,144.99 36.82,144.59 36.63,144.4 35.44,144.4 35.22,144.18 35.22,143.87 35.44,143.64 36.56,143.64 36.82,143.39 36.82,143 36.65,142.83 35.36,142.83 35.16,142.63 35.16,142.3 35.4,142.06 36.61,142.06 36.82,141.86 36.82,141.48 36.56,141.22 35.32,141.22 35.16,141.06 35.16,140.57 35.32,140.41 35.96,140.41 36.16,140.21 36.16,139.77 33.08,136.69 33.08,136.38 33.6,135.86 33.6,135.49 33.38,135.27 33.11,135.27 32.54,135.84 32.23,135.84 31.19,134.81 31.19,131.33 31.01,131.14 30.46,131.14 30.15,130.84 30.15,130.41 29.9,130.15 29.59,130.15 29.21,129.77 29.21,129.39 28.96,129.14 28.58,129.14 28.2,128.76 28.2,127.29 27.98,127.07 27.78,127.07 27.63,127.23 27.63,127.57 v4(27.7,127.65)
  BOTTOM w0.13: v4(34.52,159.85) UB6.C7
DDRA_DQ28: length 60.5
  TOP w0.127: v4(31.7,126.65) U40.AJ26
  S7 w0.127: v4(30.57,159.89) 30.57,160.09 30.97,160.49 30.97,160.9 31.17,161.1 31.87,161.1 34.26,163.49 35.52,163.49 36.98,163.49 39.3,161.17 39.3,157.76 39.84,157.22 40.38,157.22 40.49,157.34 40.49,158.04 40.62,158.16 40.62,158.84 40.81,159.03 41.44,159.03 42.29,158.17 42.29,157.26 42.61,156.94 42.61,138.93 38.95,135.27 38.95,129.23 37.84,128.12 33.53,128.12 33.28,127.87 33.28,127.49 33.02,127.23 32.67,127.23 32.08,126.65 v4(31.7,126.65)
  BOTTOM w0.13: UB6.C2 v4(30.57,159.89)
DDRA_DQ29: length 60.5
  TOP w0.127: v4(28.7,127.65) U40.AK29
  S7 w0.127: v4(28.7,127.65) 28.7,127.92 29.21,128.43 29.21,128.88 29.47,129.14 29.97,129.14 30.23,129.39 30.23,129.9 30.48,130.15 30.86,130.15 31.27,130.57 31.27,130.89 31.53,131.14 31.75,131.14 32.21,131.6 32.21,132.72 32.66,133.17 34,133.17 34.3,133.47 34.3,137.08 37.32,140.1 37.32,146.43 37.53,146.64 39.54,146.64 39.67,146.77 39.67,147.26 39.53,147.4 37.45,147.4 37.3,147.55 37.3,148 37.46,148.16 39.54,148.16 39.67,148.29 39.67,148.78 39.53,148.92 37.48,148.92 37.3,149.1 37.3,149.46 37.53,149.68 39.54,149.68 39.67,149.82 39.67,150.22 39.45,150.45 37.53,150.45 37.3,150.67 37.3,150.98 37.53,151.21 38.74,151.21 38.97,151.43 38.97,151.75 38.74,151.97 37.53,151.97 37.3,152.19 37.3,152.51 37.53,152.73 38.72,152.73 38.94,152.95 38.94,153.27 38.72,153.49 37.4,153.49 37.18,153.72 37.18,154.03 37.4,154.26 38.45,154.26 38.67,154.48 38.67,154.79 38.45,155.02 37.53,155.02 37.2,155.34 37.2,155.63 36.29,156.55 36.29,158.06 36.16,158.19 36.16,159.25 35.51,159.89 v4(35.37,159.89)
  BOTTOM w0.13: UB6.C8 v4(35.37,159.89)
DDRA_DQ30: length 60.4
  TOP w0.127: v4(30.7,127.65) U40.AK27
  S7 w0.127: v4(31.37,160.69) 32.25,160.69 34.24,162.68 37.07,162.68 38.79,160.96 38.79,157.55 40.39,155.95 40.88,155.95 41,156.07 41,157.77 41.21,157.98 41.6,157.98 41.79,157.79 41.79,155.19 41.47,154.87 41.47,154.43 41.58,154.32 41.98,154.32 42.11,154.2 42.11,153.67 42,153.56 41.69,153.56 41.47,153.34 41.47,153.02 41.69,152.8 41.96,152.8 42.11,152.65 42.11,152.15 42,152.04 41.69,152.04 41.47,151.81 41.47,151.3 41.71,151.07 41.71,144.54 42.11,144.14 42.11,139.14 38.64,135.67 38.64,130.03 37.74,129.14 33.53,129.14 33.28,128.88 33.28,128.53 32.86,128.12 32.39,128.12 32.13,127.87 32.13,127.36 32,127.23 31.21,127.23 30.79,127.65 v4(30.7,127.65)
  BOTTOM w0.13: UB6.D3 v4(31.37,160.69)
DDRA_DQ31: length 60.4
  TOP w0.127: v4(28.7,126.65) U40.AJ29
  S7 w0.127: v4(28.7,126.65) 28.7,126.31 28.9,126.11 29.2,126.11 29.3,126.21 29.3,127.94 29.48,128.12 29.85,128.12 30.18,128.45 30.18,128.7 30.61,129.14 30.99,129.14 31.24,129.39 31.24,129.77 31.63,130.15 31.85,130.15 32.27,130.58 32.27,130.88 32.51,131.12 32.9,131.12 33.23,131.45 33.23,131.76 33.59,132.13 34.74,132.13 35.12,132.51 35.12,137.18 37.64,139.7 39.03,139.7 39.16,139.82 39.16,140.28 38.98,140.46 38.01,140.46 37.83,140.64 37.83,141.06 38.07,141.3 39.44,141.3 39.61,141.48 39.61,141.93 39.41,142.14 38.09,142.14 37.83,142.39 37.83,142.67 38.06,142.9 39.67,142.9 39.87,143.1 39.87,143.58 39.72,143.74 37.98,143.74 37.83,143.89 37.83,144.29 38.03,144.5 39.92,144.5 40.1,144.68 40.1,145.13 39.95,145.28 37.99,145.28 37.83,145.44 37.83,145.9 38.06,146.13 39.97,146.13 40.18,146.34 40.18,150.43 39.94,150.67 39.94,154.24 38.68,155.5 37.02,157.17 37.02,158.37 36.58,158.81 36.58,160.08 36.37,160.29 34.89,160.29 v4(34.53,160.66)
  BOTTOM w0.13: UB6.D7 v4(34.53,160.66)
DDRA_DQS0_N: length 59.7
  TOP w0.095: U40.AU36 v4(21.7,134.65)
  S7 w0.108: v4(21.65,162.27) 21.67,162.27 22.03,162.63 22.18,162.63 22.32,162.48 22.32,156.06 22.59,155.79 23.91,155.79 24.12,155.57 24.12,155.26 23.91,155.05 22.16,155.05 21.87,154.76 21.87,154.1 22.13,153.85 24.81,153.85 24.99,153.67 24.99,153.24 24.86,153.1 22.15,153.1 21.87,152.83 21.87,152.12 22.09,151.9 24.85,151.9 24.99,151.76 24.99,151.33 24.82,151.16 22.22,151.16 21.87,150.81 21.87,150.31 22.22,149.96 24.84,149.96 24.99,149.8 24.99,149.35 24.86,149.22 22.22,149.22 21.87,148.86 21.87,148.37 22.22,148.02 24.67,148.02 24.83,147.86 24.83,147.41 24.69,147.27 22.59,147.27 22.24,146.92 22.24,146.42 22.59,146.07 23.31,146.07 23.56,145.83 23.56,145.46 23.44,145.33 22.77,145.33 22.42,144.98 22.42,144.48 22.72,144.18 22.72,138.79 23.09,138.42 23.09,136.34 22.08,135.34 22.08,134.36 21.81,134.08 21.63,134.08 21.5,134.21 21.5,134.45 v4(21.7,134.65)
  BOTTOM w0.095: v4(21.65,162.27) UB5.F3
DDRA_DQS0_P: length 59.7
  TOP w0.095: U40.AT36 v4(21.7,133.65)
  S7 w0.108: v4(21.67,163.05) 21.86,162.86 22.27,162.86 22.55,162.58 22.55,156.15 22.69,156.02 24,156.02 24.35,155.67 24.35,155.17 24,154.82 22.25,154.82 22.1,154.67 22.1,154.19 22.22,154.07 24.91,154.07 25.22,153.76 25.22,153.14 24.95,152.87 22.24,152.87 22.1,152.73 22.1,152.21 22.18,152.13 24.95,152.13 25.22,151.85 25.22,151.24 24.91,150.93 22.32,150.93 22.1,150.71 22.1,150.41 22.32,150.19 24.93,150.19 25.22,149.9 25.22,149.26 24.95,148.99 22.32,148.99 22.1,148.77 22.1,148.46 22.32,148.24 24.77,148.24 25.06,147.95 25.06,147.32 24.79,147.04 22.69,147.04 22.47,146.83 22.47,146.52 22.69,146.3 23.41,146.3 23.79,145.92 23.79,145.36 23.53,145.1 22.87,145.1 22.65,144.88 22.65,144.58 22.95,144.28 22.95,138.88 23.32,138.51 23.32,136.25 22.31,135.24 22.31,134.26 v4(21.7,133.65)
  BOTTOM w0.095: v4(21.67,163.05) UB5.G3
DDRA_DQS1_N: length 59.9
  TOP w0.095: U40.AU30 v4(27.7,134.65)
  S9 w0.108: v4(24.83,158.29) 24.54,158.58 24.39,158.58 23.97,158.16 23.97,157.76 24.73,156.99 27.27,156.99 28.49,158.22 29.29,158.22 29.83,157.68 34.97,157.68 35.3,157.35 35.3,156.72 34.89,156.31 28.38,156.31 28.06,155.99 28.06,155.62 28.2,155.47 34.33,155.47 34.71,155.09 34.71,154.48 34.23,154 30.2,154 30.01,153.81 30.01,153.36 30.28,153.09 31.94,153.09 32.12,152.91 32.12,152.47 30.15,150.5 30.15,142.28 27.13,139.26 27.13,134.78 27.27,134.65 v4(27.7,134.65)
  BOTTOM w0.095: v4(24.83,158.29) UB5.A7
DDRA_DQS1_P: length 59.9
  TOP w0.095: U40.AU31 v4(26.7,134.65)
  S9 w0.108: v4(24.82,159.09) 24.54,158.81 24.29,158.81 23.74,158.25 23.74,157.66 24.64,156.77 27.36,156.77 28.59,157.99 29.2,157.99 29.73,157.45 34.87,157.45 35.07,157.26 35.07,156.81 34.79,156.54 28.28,156.54 27.83,156.08 27.83,155.52 28.11,155.24 34.24,155.24 34.48,155 34.48,154.58 34.13,154.23 30.1,154.23 29.78,153.91 29.78,153.26 30.18,152.86 31.84,152.86 31.89,152.81 31.89,152.57 29.92,150.6 29.92,142.37 26.91,139.36 26.91,134.85 v4(26.7,134.65)
  BOTTOM w0.095: v4(24.82,159.09) UB5.B7
DDRA_DQS2_N: length 45.3
  TOP w0.095: U40.AN27 v4(30.7,130.65)
  S5 w0.108: v4(31.37,162.29) 31.37,162.49 31.45,162.58 31.62,162.58 31.75,162.45 31.75,156.2 31.98,155.97 32.59,155.97 32.72,155.85 32.72,155.37 32.57,155.23 31.96,155.23 31.66,154.94 31.66,154.3 31.94,154.03 32.55,154.03 32.72,153.87 32.72,153.49 32.51,153.29 31.94,153.29 31.66,153.01 31.66,152.37 31.95,152.09 32.54,152.09 32.72,151.91 32.72,151.46 32.6,151.34 31.96,151.34 31.66,151.05 31.66,150.42 31.94,150.14 32.53,150.14 32.72,149.96 32.72,149.55 32.56,149.4 31.97,149.4 31.66,149.1 31.66,148.36 31.95,148.07 32.57,148.07 32.72,147.92 32.72,147.47 32.57,147.33 31.96,147.33 31.66,147.04 31.66,146.4 31.94,146.13 32.5,146.13 32.72,145.91 32.72,145.6 32.5,145.39 32.02,145.39 31.75,145.12 31.75,144.34 32.1,143.99 32.39,143.99 32.6,143.77 32.6,143.46 32.39,143.25 32.04,143.25 31.75,142.96 31.75,142.6 30.22,141.06 30.22,139.96 30.58,139.59 30.58,135.21 30.2,134.83 30.2,131.14 30.52,130.83 v4(30.7,130.65)
  BOTTOM w0.095: v4(31.37,162.29) UB6.F3
DDRA_DQS2_P: length 45.4
  TOP w0.095: U40.AP27 v4(30.7,131.65)
  S5 w0.108: v4(30.7,131.65) 30.7,131.55 30.88,131.37 31.08,131.37 31.19,131.48 31.19,134.83 30.81,135.21 30.81,139.69 30.45,140.05 30.45,140.97 31.98,142.5 31.98,142.86 32.13,143.02 32.48,143.02 32.83,143.37 32.83,143.87 32.48,144.22 32.2,144.22 31.98,144.44 31.98,145.02 32.11,145.16 32.59,145.16 32.94,145.51 32.94,146.01 32.59,146.36 32.03,146.36 31.89,146.5 31.89,146.94 32.05,147.1 32.67,147.1 32.94,147.38 32.94,148.02 32.66,148.3 32.04,148.3 31.89,148.45 31.89,149 32.06,149.17 32.66,149.17 32.94,149.46 32.94,150.05 32.62,150.37 32.03,150.37 31.89,150.51 31.89,150.96 32.05,151.11 32.69,151.11 32.94,151.37 32.94,152.01 32.64,152.31 32.05,152.31 31.89,152.47 31.89,152.91 32.04,153.06 32.6,153.06 32.94,153.4 32.94,153.96 32.65,154.26 32.03,154.26 31.89,154.4 31.89,154.84 32.05,155 32.67,155 32.94,155.28 32.94,155.94 32.69,156.2 32.07,156.2 31.98,156.29 31.98,162.54 31.72,162.8 31.44,162.8 31.36,162.88 v4(31.36,163.09)
  BOTTOM w0.095: v4(31.36,163.09) UB6.G3
DDRA_DQS3_N: length 57.9
  TOP w0.095: U40.AM31 v4(26.7,129.65)
  S7 w0.108: v4(34.56,158.29) 34.28,158.57 33.05,158.57 32.96,158.47 32.96,158.03 33.18,157.81 34.15,157.81 34.64,157.33 34.64,156.66 34.39,156.42 33.01,156.42 32.71,156.12 32.71,155.63 33.54,154.79 33.54,146.94 33.3,146.69 32.61,146.69 32.4,146.47 32.4,146.07 32.52,145.95 33.62,145.95 33.98,145.59 33.98,145.01 33.72,144.75 31.27,144.75 31.17,144.64 31.17,144.13 31.29,144 33.76,144 34.03,143.74 34.03,143.08 33.75,142.8 31.28,142.8 31.17,142.68 31.17,142.17 31.28,142.06 33.72,142.06 34.03,141.76 34.03,141.09 33.79,140.86 32.12,140.86 31.9,140.64 31.9,140.33 32.12,140.12 33.48,140.12 33.8,139.8 33.8,139.19 33.41,138.8 31.29,138.8 31.17,138.67 31.17,136.73 30.24,135.81 29.15,135.81 28.78,135.44 28.78,135.16 29.19,134.75 29.19,131.47 28.88,131.17 28.45,131.17 28.2,130.91 28.2,130.46 27.89,130.15 27.2,130.15 27.04,129.99 27.04,129.89 27.24,129.69 27.24,129.54 27.03,129.32 26.8,129.32 26.7,129.42 v4(26.7,129.65)
  BOTTOM w0.095: v4(34.56,158.29) UB6.A7
DDRA_DQS3_P: length 57.9
  TOP w0.095: U40.AL31 v4(26.7,128.65)
  S7 w0.108: v4(26.7,128.65) 26.7,128.9 26.28,129.32 26.28,129.77 26.63,130.12 26.84,130.12 27.17,130.45 27.17,130.69 27.63,131.14 27.84,131.14 28.2,131.5 28.2,134.78 28.55,135.13 28.55,135.54 29.06,136.04 30.15,136.04 30.94,136.83 30.94,138.77 31.2,139.03 33.32,139.03 33.57,139.28 33.57,139.7 33.39,139.89 32.03,139.89 31.68,140.24 31.68,140.74 32.03,141.09 33.7,141.09 33.8,141.19 33.8,141.66 33.63,141.83 31.18,141.83 30.94,142.08 30.94,142.78 31.19,143.03 33.66,143.03 33.8,143.17 33.8,143.64 33.66,143.77 31.19,143.77 30.94,144.03 30.94,144.74 31.18,144.97 33.62,144.97 33.75,145.1 33.75,145.5 33.53,145.72 32.43,145.72 32.17,145.98 32.17,146.57 32.52,146.92 33.2,146.92 33.32,147.03 33.32,154.7 32.48,155.53 32.48,156.21 32.92,156.65 34.3,156.65 34.41,156.76 34.41,157.23 34.06,157.58 33.08,157.58 32.73,157.93 32.73,158.57 32.96,158.79 34.27,158.79 v4(34.56,159.08)
  BOTTOM w0.095: v4(34.56,159.08) UB6.B7
DDRA_ODT: length 87.7
  TOP w0.127: v4(29.7,134.65) U40.AU28 ; v4(21.64,166.31) 22.44,167.11 22.44,167.43 R255.2
  S12 w0.127: v4(32.19,166.27) 31.75,166.7 24.43,166.7 24.05,166.32 24.05,162.99 23.77,162.71 23.34,162.71 23.06,162.99 23.06,166.4 22.76,166.7 22.03,166.7 v4(21.64,166.31)
  S16 w0.127: v4(29.7,134.65) 29.7,134.82 26.77,137.75 26.45,137.75 26.01,137.31 25.69,137.31 25.47,137.53 25.47,137.85 25.92,138.29 25.92,138.6 25.66,138.86 25.4,138.86 24.74,138.2 24.58,138.2 24.22,138.55 24.22,138.76 24.84,139.37 24.84,139.68 24.61,139.91 24.29,139.91 23.68,139.29 23.49,139.29 23.16,139.62 23.16,139.85 23.79,140.48 23.79,140.73 23.53,140.99 23.22,140.99 22.61,140.38 22.39,140.38 22.09,140.69 22.09,140.94 22.5,141.34 22.5,141.73 22.29,141.93 22.01,141.93 21.76,141.68 21.61,141.68 21.52,141.77 21.52,153.25 25.96,157.69 28.27,157.69 28.44,157.86 28.44,158.64 28.52,158.72 28.94,158.72 29.07,158.59 29.07,158.09 29.47,157.69 31.33,157.69 31.77,158.14 31.77,165.05 31.65,165.16 29.6,165.16 29.51,165.25 29.51,165.73 29.62,165.85 30.7,165.85 30.96,166.11 30.96,169.74 31.11,169.88 31.81,169.88 31.94,169.75 31.94,166.63 31.76,166.45 31.76,165.67 31.82,165.62 32.06,165.62 32.19,165.74 v4(32.19,166.27)
  BOTTOM w0.127: v4(21.64,166.31) UB5.K3 ; UB6.K3 31.81,165.89 v4(32.19,166.27)
DDRA_PAR: length 81.9
  TOP w0.127: v4(31.7,132.65) U40.AR26
  S12 w0.127: v4(21.67,171.13) 21.58,171.22 21.58,171.4 21.78,171.6 30.85,171.6 v4(31.36,171.09)
  S16 w0.127: v4(31.7,132.65) 31.7,132.64 31.23,132.18 28.36,132.18 28.16,132.38 28.16,132.81 27.22,133.75 27.22,134.68 26.37,135.53 24.7,135.53 23.63,136.61 22.13,136.61 21.63,137.11 21.63,138.61 19.74,140.5 19.74,144.49 19.35,144.88 19.35,155.84 20.42,156.91 20.42,160.73 20.32,160.83 19.5,160.83 19.35,160.98 19.35,161.31 19.5,161.47 20.29,161.47 20.42,161.6 20.42,162.12 20.42,162.13 20.42,164.85 20.19,165.09 20.15,165.09 18.51,166.72 18.51,171.02 19.7,172.21 26.58,172.21 27.27,171.52 30.93,171.52 v4(31.36,171.09)
  BOTTOM w0.127: v4(31.36,171.09) 31.37,171.09 UB6.T3 ; RB49.2 19.9,172.9 v4(21.67,171.13) UB5.T3
DDRA_RAS_N: length 79.1
  TOP w0.127: v4(35.7,132.65) U40.AR22 ; R243.2 24.43,168.5 24.43,167.66 24.6,167.49 25.23,167.49 v4(25.63,167.09)
  S9 w0.127: v4(35.36,167.09) 34.66,166.65 34.38,166.65 34.34,166.68 26.23,166.68 v4(25.63,167.09)
  S16 w0.127: v4(35.7,132.65) 36.04,132.65 36.19,132.79 36.19,135.56 34.82,136.92 34.82,137.68 34.64,137.86 34.64,138.17 35.64,139.18 35.64,139.39 35.37,139.67 35.05,139.67 34.11,138.72 33.79,138.72 33.57,138.94 33.57,139.26 34.52,140.21 34.52,140.52 34.29,140.75 33.98,140.75 33.16,139.93 32.99,139.93 32.79,140.12 32.79,140.63 33.44,141.28 33.44,141.6 33.15,141.89 33.15,143.1 32.97,143.28 31.76,143.28 31.58,143.46 31.58,143.79 31.78,143.99 32.94,143.99 33.15,144.19 33.15,144.63 33,144.77 30.72,144.77 30.52,144.97 30.52,145.45 30.74,145.68 32.72,145.68 32.89,145.85 32.89,146.29 32.75,146.44 30.74,146.44 30.52,146.66 30.52,153.14 30.71,153.34 33.02,153.34 36.91,157.23 38.23,157.23 38.79,157.79 38.79,165.84 38.57,166.06 38.04,166.06 37.89,166.21 37.89,166.74 37.74,166.9 37.35,166.9 37.23,166.77 37.23,165.83 37.07,165.68 36.67,165.68 36.57,165.78 36.57,167.59 36.29,167.87 35.98,167.87 35.77,167.66 35.77,167.07 35.63,166.93 35.44,166.93 35.36,167 v4(35.36,167.09)
  BOTTOM w0.127: UB6.L8 v4(35.36,167.09)
  BOTTOM w0.13: UB5.L8 v4(25.63,167.09)
DDRA_RST_N: length 82
  TOP w0.127: v4(34.7,132.65) U40.AR23
  S12 w0.127: v4(29.77,169.49) 29.08,168.8 28.86,168.8 28.74,168.93 28.74,169.19 28.53,169.39 28.11,169.39 27.97,169.26 27.97,168.93 27.85,168.8 27.52,168.8 27.23,169.09 20.44,169.09 v4(20.03,169.49)
  S14 w0.127: v4(29.77,169.49) UB6.P1 30.17,167.64 30.32,167.49 30.78,167.49 30.96,167.3 30.96,166.88 30.76,166.68 30.4,166.68 30.17,166.45 30.17,166.45 30.16,166.44 30.16,157.26 27.85,154.96 27.85,147.37 27.31,146.82 27.31,144.89 26.84,144.42 26.84,144.04 27.15,143.73 28.52,143.73 28.77,143.48 28.77,143.17 28.57,142.97 26.15,142.97 26.03,142.85 26.03,142.31 26.13,142.21 29.25,142.21 29.47,141.98 29.47,141.57 29.35,141.45 26.1,141.45 26,141.35 26,140.79 26.11,140.68 29.81,140.68 29.95,140.55 29.95,140.09 29.78,139.92 26.31,139.92 26.08,139.7 26.08,139.25 26.25,139.09 28.46,139.09 29.05,138.5 29.05,136.57 30.47,135.15 31.03,135.15 31.21,134.97 31.21,133.42 31.59,133.04 33.95,133.04 34.13,132.86 34.13,132.59 34.26,132.46 34.51,132.46 v4(34.7,132.65)
  BOTTOM w0.127: v4(20.03,169.49) UB5.P1 15.45,169.09 RB98.2
  BOTTOM w0.13: UB6.P1 v4(29.77,169.49)
DDRA_TEN: length 17.1
  S5 w0.127: v4(37.12,167.71) 36.56,168.28 34.73,168.28 34.72,168.28 29.93,168.28 29.93,168.29 26.83,168.29 v4(26.42,168.69)
  BOTTOM w0.127: UB5.N9 v4(26.42,168.69) ; RB108.1 RB103.2 38.45,167.87 38.25,167.67 37.17,167.67 v4(37.12,167.71) 37.1,167.74 37.1,167.76 UB6.N9
DDRA_VREF_1: length 11.3
  BOTTOM w0.381: RB124.1 RB122.1 RB118.2 CB201.1 CB186.1 14.14,167.36 v2(16.73,167.36) 17.62,167.36 17.93,167.05 19.18,167.05 UB5.M1
DDRA_VREF_2: length 6
  TOP w0.381: v4(29.76,167.89) 29.4,167.89 29.35,167.94 R256.2 C143.1 C149.1 R301.1
  BOTTOM w0.381: UB6.M1 30.16,167.49 v4(29.76,167.89) v2(28.16,167.89)
DDRA_WE_N: length 82.4
  TOP w0.127: v4(35.7,131.65) U40.AP22
  S14 w0.127: v4(30.57,167.09) 30.48,167.18 30.29,167.18 30.16,167.05 30.16,166.9 29.96,166.7 29.53,166.7 29.37,166.54 29.37,158.09 29.65,157.81 29.65,157.47 29.1,156.92 28.85,156.92 28.46,157.3 28.15,157.3 27.8,156.95 27.8,156.64 28.16,156.28 28.16,156.03 27.85,155.72 27.63,155.72 27.23,156.13 26.98,156.13 26.69,155.84 26.69,155.6 27.16,155.12 27.16,154.8 26.94,154.58 26.62,154.58 26.18,155.02 25.87,155.02 25.57,154.72 25.57,153.23 25.71,153.09 26.13,153.09 26.33,152.89 26.33,152.57 26.09,152.33 25.55,152.33 25.4,152.18 25.4,151.79 25.62,151.56 26.35,151.56 26.57,151.34 26.57,151.02 26.35,150.8 25.57,150.8 25.4,150.63 25.4,150.26 25.62,150.04 27.22,150.04 27.35,149.91 27.35,149.4 27.22,149.28 25.62,149.28 25.49,149.15 25.49,148.74 25.71,148.52 27.22,148.52 27.35,148.38 27.35,147.9 27.2,147.75 25.65,147.75 25.49,147.6 25.49,147.12 25.61,146.99 26.68,146.99 26.8,146.87 26.8,146.42 26.61,146.23 25.62,146.23 25.49,146.1 25.49,145.54 25.62,145.41 26.05,145.41 26.18,145.29 26.18,145.09 25.49,144.4 25.49,139.13 26.43,138.19 26.75,138.19 26.99,138.43 27.25,138.43 27.47,138.2 27.47,137.84 27.29,137.65 27.29,137.33 27.51,137.11 27.82,137.11 28.02,137.31 28.34,137.31 28.54,137.11 28.54,136.75 28.36,136.57 28.36,136.26 29.36,135.26 29.85,135.26 30.27,134.85 30.27,132.43 30.55,132.15 35.86,132.15 36.01,132 36.01,131.77 35.88,131.65 v4(35.7,131.65)
  S16 w0.127: v4(20.83,167.09) 21.22,167.49 30.17,167.49 v4(30.57,167.09)
  BOTTOM w0.127: RB112.2 17.43,166.34 17.49,166.28 20.02,166.28 UB5.L2
  BOTTOM w0.13: UB5.L2 v4(20.83,167.09) ; UB6.L2 v4(30.57,167.09)
DDRA_ZQ_1: length 4
  TOP w0.381: R322.2 26.54,162.18 v4(26.42,162.29)
  BOTTOM w0.127: v4(26.42,162.29) v2(28.16,162.29)
  BOTTOM w0.381: UB5.F9 v4(26.42,162.29)
DDRA_ZQ_2: length 4.7
  BOTTOM w0.127: UB6.F9 37.23,162.02 v2(39.08,162.02) 39.59,162.02 40.07,161.54 RB126.2
DDRB_100M_N: length 79.7
  TOP w0.095: v3(75.25,186.68) arc(75.36,186.96) 75.64,187.08 76.3,187.08 arc(76.62,186.94) RB6.1
  S5 w0.108: v3(73.47,164.64) 73.18,164.35 72.5,164.35 arc(71.95,164.58) 71.72,165.13 71.72,172.02 arc(71.87,172.79) 72.31,173.44 73.64,174.77 arc(74.19,175.6) 74.39,176.57 74.39,183.82 arc(74.43,183.93) 74.55,183.98 arc(74.66,184.02) 74.7,184.13 74.7,184.43 arc(74.66,184.55) 74.55,184.59 arc(74.43,184.64) 74.39,184.75 74.39,185.05 arc(74.43,185.16) 74.55,185.21 arc(74.66,185.25) 74.7,185.37 74.7,185.66 arc(74.66,185.78) 74.55,185.82 arc(74.43,185.87) 74.39,185.98 74.39,186.68 arc(74.5,186.96) 74.78,187.07 74.86,187.07 arc(75.13,186.96) v3(75.25,186.68)
  BOTTOM w0.095: v3(73.47,164.64) 73.64,164.48 arc(73.79,164.37) 73.97,164.34 74.27,164.34 arc(74.47,164.3) 74.63,164.18 75.43,163.39 arc(75.75,162.91) 75.86,162.35 75.86,156.42 arc(75.75,155.85) 75.43,155.38 73.45,153.4 arc(71.74,152.26) 69.73,151.85 68.17,151.85 arc(65.85,151.39) 63.88,150.08 62.03,148.22 arc(56.25,144.36) 49.43,143 45.23,143 arc(44.83,142.93) 44.5,142.7 43.9,142.1 42.71,140.92 arc(42.49,140.58) 42.41,140.18 42.41,138.9 arc(42.44,138.72) 42.55,138.57 CB342.1
DDRB_100M_P: length 79.7
  TOP w0.095: v3(75.25,187.7) arc(75.36,187.42) 75.64,187.31 76.3,187.31 arc(76.62,187.44) RB12.1
  S5 w0.108: v3(73.47,163.83) 73.18,164.12 72.5,164.12 arc(71.79,164.41) 71.49,165.13 71.49,172.02 arc(71.66,172.88) 72.15,173.6 73.48,174.93 arc(73.98,175.69) 74.16,176.57 74.16,186.68 arc(74.34,187.12) 74.78,187.3 74.85,187.3 arc(75.13,187.42) v3(75.25,187.7)
  BOTTOM w0.095: CB341.1 42.04,138.64 arc(42.14,138.79) 42.18,138.98 42.18,139.26 42.05,139.4 42.05,139.68 42.18,139.81 42.18,140.18 arc(42.28,140.67) 42.55,141.08 42.75,141.28 42.75,141.47 42.95,141.67 43.14,141.67 43.35,141.87 43.35,142.06 43.55,142.26 43.74,142.26 44.33,142.86 arc(44.75,143.14) 45.23,143.23 49.43,143.23 arc(56.16,144.57) 61.87,148.39 63.72,150.24 arc(65.76,151.6) 68.17,152.08 69.73,152.08 arc(71.65,152.47) 73.29,153.56 75.27,155.54 arc(75.54,155.94) 75.63,156.42 75.63,162.35 arc(75.54,162.82) 75.27,163.23 74.47,164.02 arc(74.38,164.09) 74.27,164.11 73.94,164.11 arc(73.77,164.07) 73.62,163.97 v3(73.47,163.83)
DDRB_100M_REFCLK_N: length 11.8
  TOP w0.095: v4(40.7,127.65) U40.AK18
  BOTTOM w0.095: CB342.2 42.33,137.01 42.33,136.8 42.58,136.55 RB146.1 42.58,135.78 42.32,135.52 42.32,129.57 arc(42.16,129.19) 41.79,129.03 41.63,129.03 arc(41.41,128.94) 41.32,128.72 41.32,128.25 arc(41.22,128.02) 40.99,127.93 40.98,127.93 v4(40.7,127.65)
DDRB_100M_REFCLK_P: length 11.8
  TOP w0.095: v4(40.7,128.65) U40.AL18
  BOTTOM w0.095: CB341.2 42.1,137.09 42.1,136.85 41.67,136.42 RB146.2 41.67,135.86 42.09,135.44 42.09,129.57 arc(42,129.35) 41.79,129.26 41.63,129.26 arc(41.25,129.1) 41.09,128.72 41.09,128.25 arc(41.06,128.19) 40.99,128.16 40.89,128.16 40.7,128.35 v4(40.7,128.65)
DDRB_A0: length 84.1
  TOP w0.127: U15.P3 66.96,169.36 arc(66.77,169.64) 66.7,169.98 66.7,170.99 68.04,172.33 68.04,174.52 R156.2 ; v4(49.7,130.65) U40.AN9
  TOP w0.13: U15.P3 v4(67.5,169.62) ; v4(56.96,169.62) U14.P3
  S7 w0.127: v4(67.5,169.62) 67.1,170.01 60.05,170.01 59.91,170.15 58.87,170.15 58.73,170.01 57.35,170.01 v4(56.96,169.62)
  S14 w0.127: v4(56.96,169.62) 56.25,169.62 55.79,170.08 55.79,173.12 56.12,173.45 59.99,173.45 60.14,173.61 60.14,174.01 59.96,174.19 55.16,174.19 55.01,174.04 55.01,168.3 54.83,168.12 54.83,162.4 55.76,161.48 55.76,157.25 54.97,156.46 54.97,146.06 46.21,137.3 46.21,133.51 46.51,133.2 46.81,133.2 47.26,132.76 47.26,132.46 47.55,132.17 47.87,132.17 48.26,131.79 48.26,131.46 48.55,131.17 49.17,131.17 v4(49.7,130.65)
DDRB_A1: length 85.3
  TOP w0.127: v4(46.7,125.65) U40.AH12 ; U15.P7 64.39,169.71 64.39,170.98 62.45,172.92 R150.2
  TOP w0.13: v4(52.96,169.62) U14.P7 ; U15.P7 v4(63.5,169.62)
  S12 w0.127: v4(63.5,169.62) 62.83,170.02 55.46,170.02 v4(52.96,169.62)
  S14 w0.127: v4(52.96,169.62) 52.56,170.01 51.19,170.01 49.24,168.06 49.24,159.26 48.35,158.37 48.35,156.8 46.8,155.25 46.8,149.37 46.93,149.24 48.28,149.24 48.4,149.11 48.4,148.6 48.28,148.48 46.93,148.48 46.8,148.35 46.8,147.84 46.93,147.72 48.33,147.72 48.45,147.59 48.45,147.08 48.33,146.95 46.93,146.95 46.8,146.83 46.8,146.32 46.93,146.19 48.5,146.19 48.63,146.06 48.63,145.56 48.5,145.43 46.93,145.43 46.8,145.3 46.8,143.58 39.77,136.54 39.77,135.33 39.3,134.87 39.3,130.35 39.47,130.18 39.79,130.18 40.26,129.7 40.26,129.39 40.52,129.14 40.9,129.14 41.19,128.84 41.19,128.34 41.39,128.14 41.9,128.14 42.19,127.84 42.19,127.48 42.56,127.12 44.78,127.12 45.18,126.72 45.18,126.52 45.55,126.16 46.19,126.16 v4(46.7,125.65)
DDRB_A2: length 83.7
  TOP w0.127: U40.AJ11 v4(47.7,126.65)
  TOP w0.13: v4(67.5,170.42) U15.R3 ; v4(56.96,170.42) U14.R3
  S7 w0.127: v4(56.96,170.42) 57,170.42 57.39,170.81 60.7,170.81 60.85,170.66 62.14,170.66 62.3,170.81 67.1,170.81 v4(67.5,170.42)
  S16 w0.127: v4(47.7,126.65) 48.2,127.15 49.97,127.15 50.17,127.34 50.17,127.82 50.47,128.12 50.95,128.12 51.2,128.36 51.2,129.89 51.48,130.17 51.92,130.17 52.22,130.47 52.22,134.97 52.19,135.01 52.19,141.25 65.45,154.51 65.45,157.17 65.68,157.4 65.68,163.56 66.68,164.56 66.68,165.16 66.6,165.24 66.6,169.3 65.88,170.01 65.57,170.01 65.37,169.81 65.37,169.42 65.22,169.26 64.84,169.26 64.71,169.39 64.71,169.72 64.42,170.01 60.43,170.01 58.77,171.68 57.65,171.68 57.36,171.38 57.36,170.82 v4(56.96,170.42)
  BOTTOM w0.127: RB67.2 70.58,173.33 68.7,171.45 68.7,171.04 68.48,170.82 68.07,170.82 67.67,170.42 v4(67.5,170.42)
DDRB_A3: length 85.5
  TOP w0.127: v4(49.7,128.65) U40.AL9 ; R151.2 63.47,172.64 64.77,171.34 64.77,169.28 63.9,168.42 U15.N7
  TOP w0.13: v4(52.96,168.82) U14.N7 ; U15.N7 v4(63.5,168.82)
  S12 w0.127: v4(52.96,168.82) 55.43,168.42 62.81,168.42 v4(63.5,168.82)
  S14 w0.127: v4(49.7,128.65) 49.23,128.18 49.23,127.56 48.9,127.23 46.36,127.23 46.1,127.49 46.1,127.92 45.85,128.18 45.44,128.18 45.22,128.39 45.22,128.82 44.89,129.15 43.51,129.15 43.19,129.48 43.19,129.92 42.95,130.15 42.47,130.15 42.19,130.43 42.19,130.91 41.99,131.12 41.53,131.12 41.23,131.42 41.23,136.56 49.88,145.21 49.88,148.85 50,148.97 51.1,148.97 51.22,149.1 51.22,149.61 51.1,149.74 50,149.74 49.88,149.86 49.88,150.37 50,150.5 51.1,150.5 51.22,150.63 51.22,151.13 51.1,151.26 50,151.26 49.88,151.39 49.88,151.9 50,152.02 51.1,152.02 51.22,152.15 51.22,152.66 51.1,152.78 50,152.78 49.88,152.91 49.88,153.42 50,153.55 51.1,153.55 51.22,153.67 51.22,154.18 51.1,154.31 50,154.31 49.37,154.94 49.37,157.89 50.26,158.78 50.26,167.48 51.19,168.41 52.86,168.41 53.03,168.58 53.03,168.75 v4(52.96,168.82)
DDRB_A4: length 85
  TOP w0.127: U15.N3 66.3,169.22 66.3,171.31 67.53,172.54 R155.2 ; v4(51.7,131.65) U40.AP7
  TOP w0.13: v4(56.96,168.82) U14.N3 ; U15.N3 v4(67.5,168.82)
  S7 w0.127: v4(67.5,168.82) 66.8,168.12 64.58,168.12 64.29,168.41 61.27,168.41 60.7,168.98 58.97,168.98 58.74,169.21 57.35,169.21 v4(56.96,168.82)
  S14 w0.127: v4(51.7,131.65) 51.63,131.65 51.11,131.13 50.53,131.13 50.21,131.44 50.21,131.81 49.92,132.1 49.5,132.1 49.14,132.46 49.14,132.83 48.88,133.09 48.55,133.09 48.18,133.46 48.18,137.83 57.17,146.82 57.17,147 55.99,148.19 55.99,148.6 56.2,148.82 56.44,148.82 57.71,147.54 57.89,147.54 58.25,147.9 58.25,148.08 57.24,149.09 57.24,149.4 57.47,149.63 57.78,149.63 58.79,148.62 58.97,148.62 60.24,149.89 60.24,150.26 60.04,150.47 59.27,150.47 59.1,150.64 59.1,151.08 59.29,151.27 61.1,151.27 61.23,151.4 61.23,151.91 61.1,152.03 59.26,152.03 59.05,152.25 59.05,152.55 59.29,152.8 61.1,152.8 61.23,152.92 61.23,153.43 61.1,153.56 59.4,153.56 59.27,153.68 59.27,164.06 58.89,164.44 56.6,164.44 55.85,165.19 55.85,167.54 56.96,168.65 v4(56.96,168.82)
DDRB_A5: length 84.9
  TOP w0.127: v4(42.7,126.65) U40.AJ16
  TOP w0.13: v4(62.7,169.62) U15.P8 ; v4(52.16,169.62) U14.P8
  S9 w0.127: v4(52.16,169.62) 52.55,170.01 62.3,170.01 62.3,170.01 v4(62.7,169.62)
  S16 w0.127: v4(52.16,169.62) 51.75,170.03 50.89,170.03 49.52,168.65 49.52,157.32 44.98,152.77 44.98,152.59 46.11,151.46 46.11,151.28 45.75,150.92 45.57,150.92 44.62,151.87 44.44,151.87 44.09,151.51 44.09,151.33 46.78,148.64 46.78,148.46 46.42,148.1 46.24,148.1 43.57,150.76 43.39,150.76 43.03,150.41 43.03,150.23 43.96,149.3 43.96,149.27 45.11,148.12 45.11,147.94 44.26,147.09 41.75,147.09 40.13,145.48 40.13,140.57 40.88,139.82 40.88,136.35 41.09,136.14 41.09,127.56 41.53,127.12 43.01,127.12 43.21,126.92 43.21,126.76 43.09,126.65 v4(42.7,126.65)
  BOTTOM w0.127: RB60.2 60.42,173.44 62.3,171.56 62.3,170.02 v4(62.7,169.62)
DDRB_A6: length 82.7
  TOP w0.127: v4(49.7,127.65) U40.AK9
  TOP w0.13: v4(57.76,169.62) U14.P2 ; v4(68.3,169.62) U15.P2
  S5 w0.127: v4(57.76,169.62) 58.16,169.21 67.89,169.21 v4(68.3,169.62)
  S16 w0.127: v4(49.7,127.65) 49.7,128.02 50.21,128.53 50.21,129.96 50.01,130.16 49.51,130.16 49.2,130.47 49.2,134.7 50.67,136.17 50.67,141.88 58.95,150.17 58.95,151.06 59.08,151.19 59.97,151.19 60.1,151.32 60.1,151.82 59.97,151.95 59.08,151.95 58.95,152.08 58.95,152.59 59.08,152.71 60.87,152.71 61,152.84 61,153.35 60.87,153.48 59.08,153.48 58.95,153.6 58.95,154.11 59.08,154.24 60.87,154.24 61,154.36 61,154.87 60.87,155 59.08,155 58.95,155.13 58.95,155.63 59.08,155.76 60.87,155.76 61,155.89 61,156.4 60.87,156.52 59.08,156.52 58.95,156.65 58.95,157.16 59.08,157.29 60.87,157.29 61,157.41 61,157.92 60.87,158.05 59.08,158.05 58.95,158.17 58.95,169.08 58.82,169.21 58.16,169.21 v4(57.76,169.62)
  BOTTOM w0.127: RB91.2 72.1,170.41 71.71,170.01 68.69,170.01 v4(68.3,169.62)
DDRB_A7: length 80.4
  TOP w0.127: v4(43.7,125.65) U40.AH15
  TOP w0.13: v4(62.7,170.42) U15.R8 ; v4(52.16,170.42) U14.R8
  S5 w0.127: v4(62.7,170.42) 62.3,170.02 52.55,170.02 v4(52.16,170.42)
  S16 w0.127: v4(52.16,170.42) 51.78,170.79 50.89,170.79 48.99,168.88 48.99,163.8 48.59,163.4 48.09,163.4 47.77,163.07 47.77,162.52 48.01,162.28 48.78,162.28 48.99,162.07 48.99,157.47 47.58,156.06 47.27,156.06 45.87,157.46 45.69,157.46 45.07,156.84 45.07,156.66 45.54,156.19 45.55,156.19 46.32,155.42 46.32,154.84 42.01,150.53 42.01,150.35 43.28,149.08 43.29,149.08 44.05,148.32 44.05,147.96 43.68,147.59 42.86,147.59 41.23,149.22 41.05,149.22 39.63,147.8 39.63,138.52 40.12,138.02 40.12,127.53 40.54,127.11 40.91,127.11 41.21,126.8 41.21,126.43 41.51,126.13 43.21,126.13 v4(43.7,125.65)
  BOTTOM w0.127: v4(62.7,170.42) 62.7,170.59 63.22,171.11 63.22,171.29 62.7,171.8 RB61.2
DDRB_A8: length 83.8
  TOP w0.127: v4(50.7,130.65) U40.AN8
  TOP w0.13: v4(57.76,170.42) U14.R2 ; v4(68.3,170.42) U15.R2
  S5 w0.127: v4(68.3,170.42) 67.9,170.82 63.76,170.82 61.72,170.82 61.56,170.66 60.83,170.66 60.67,170.82 58.16,170.82 v4(57.76,170.42)
  S16 w0.127: v4(57.76,170.42) 57.99,170.42 58.4,170.01 58.78,170.01 59.52,169.28 59.52,168.36 59.79,168.08 60.81,168.08 61.18,167.71 61.18,167.52 60.85,167.19 59.68,167.19 59.46,166.97 59.46,166.65 59.68,166.43 61.05,166.43 61.18,166.3 61.18,165.79 61.05,165.67 59.68,165.67 59.46,165.44 59.46,165.13 59.68,164.91 61.05,164.91 61.18,164.78 61.18,164.27 61.05,164.14 59.68,164.14 59.46,163.92 59.46,163.6 59.68,163.38 61.05,163.38 61.18,163.25 61.18,162.75 61.05,162.62 59.68,162.62 59.46,162.4 59.46,162.08 59.68,161.86 61.05,161.86 61.18,161.73 61.18,161.22 61.05,161.1 59.68,161.1 59.48,160.89 59.48,160.54 59.68,160.33 61.05,160.33 61.18,160.21 61.18,159.7 61.05,159.57 59.68,159.57 59.48,159.37 59.48,159.01 59.68,158.81 61.05,158.81 61.51,158.35 61.51,152.01 51.17,141.67 51.17,135.69 50.17,134.68 50.17,130.8 50.33,130.65 v4(50.7,130.65)
  BOTTOM w0.127: RB83.2 72.36,172.44 70.73,170.81 68.93,170.81 68.53,170.42 v4(68.3,170.42)
DDRB_A9: length 83.7
  TOP w0.127: v4(63.5,170.42) 63.5,171.15 61.43,173.22 R149.2 ; v4(45.7,125.65) U40.AH13
  TOP w0.13: v4(52.96,170.42) U14.R7 ; v4(63.5,170.42) U15.R7
  S9 w0.127: v4(63.5,170.42) 62.83,170.81 61.69,170.81 61.53,170.66 60.93,170.66 60.77,170.81 53.35,170.81 v4(52.96,170.42)
  S14 w0.127: v4(52.96,170.42) 52.96,173.63 52.77,173.81 52.28,173.81 51.76,173.3 51.76,170.82 51.55,170.61 51.07,170.61 48.73,168.27 48.73,160.29 48.11,159.66 47.87,159.66 47.5,159.3 47.5,158.71 46.29,157.5 46.29,143.79 42.4,139.89 42.22,139.89 41.39,140.71 41.21,140.71 40.85,140.35 40.85,140.17 41.68,139.35 41.68,139.17 39.17,136.67 39.17,135.33 38.86,135.02 38.86,129.92 40.57,128.22 40.68,128.22 41.22,127.68 41.22,127.56 41.65,127.14 41.76,127.14 42.19,126.71 42.19,126.59 42.63,126.16 44.74,126.16 45.12,125.78 45.12,125.53 45.2,125.45 45.5,125.45 v4(45.7,125.65)
DDRB_A10: length 86
  TOP w0.127: U15.M3 65.92,168.8 65.92,171.64 66.51,172.24 R154.2 ; U40.AK11 v4(47.7,127.65)
  TOP w0.13: v4(56.96,168.02) U14.M3 ; U15.M3 v4(67.5,168.02)
  S7 w0.127: v4(67.5,168.02) 67.09,167.61 60.87,167.61 60.06,168.42 57.36,168.42 v4(56.96,168.02)
  S16 w0.127: v4(47.7,127.65) 48.07,127.65 48.55,128.13 49.06,128.13 49.2,128.27 49.2,129.83 48.91,130.13 48.47,130.13 48.13,130.47 48.13,134.83 48.38,135.07 49.17,135.07 49.37,135.28 49.37,135.68 49.19,135.86 47.92,135.86 47.73,136.06 47.73,136.51 47.92,136.7 50,136.7 50.16,136.85 50.16,137.29 50.03,137.42 47.85,137.42 47.73,137.54 47.73,138.05 47.85,138.18 50.03,138.18 50.16,138.3 50.16,138.81 50.03,138.94 47.85,138.94 47.73,139.07 47.73,139.57 47.85,139.7 50.03,139.7 50.16,139.83 50.16,140.34 50.03,140.46 49.37,140.46 49.24,140.59 49.24,141.1 49.37,141.23 50.03,141.23 50.16,141.35 50.16,142.09 58.31,150.24 58.31,158.52 58.16,158.67 58.16,164.32 58.03,164.45 57.01,164.45 56.89,164.57 56.89,165.08 57.01,165.21 58.03,165.21 58.16,165.34 58.16,168.25 57.99,168.41 57.35,168.41 v4(56.96,168.02)
DDRB_A11: length 82.1
  TOP w0.127: v4(50.7,129.65) U40.AM8 ; v4(68.3,171.22) 69.31,172.23 69.31,173.76 R158.2
  TOP w0.13: v4(57.76,171.22) U14.T2 ; v4(68.3,171.22) U15.T2
  S9 w0.127: v4(68.3,171.22) 67.84,171.68 61.81,171.68 61.71,171.78 60.9,171.78 60.8,171.68 58.21,171.68 v4(57.76,171.22)
  S16 w0.127: v4(57.76,171.22) 58.16,170.81 58.74,170.81 60.34,169.21 63.87,169.21 64.02,169.06 64.02,168.78 64.24,168.56 65.96,168.56 66.09,168.44 66.09,167.93 65.96,167.8 64.28,167.8 64.15,167.67 64.15,167.17 64.28,167.04 65.96,167.04 66.09,166.91 66.09,166.4 65.96,166.28 64.41,166.28 64.28,166.15 64.28,164.08 64.41,163.96 65.04,163.96 65.17,163.83 65.17,163.32 65.04,163.19 64.41,163.19 64.28,163.07 64.28,162.56 64.41,162.43 65.04,162.43 65.17,162.3 65.17,161.8 65.04,161.67 64.01,161.67 63.88,161.54 63.88,161.03 64.01,160.91 65.04,160.91 65.17,160.78 65.17,160.27 65.04,160.15 64.41,160.15 64.28,160.02 64.28,154.06 51.68,141.46 51.68,135.19 51.25,134.76 51.25,130.5 50.7,129.94 v4(50.7,129.65)
DDRB_A12: length 86.2
  TOP w0.127: U15.M7 65.15,168.87 65.15,171.7 64.48,172.36 R152.2 ; v4(44.7,126.65) U40.AJ14
  TOP w0.13: U15.M7 v4(63.5,168.02) ; v4(52.96,168.02) U14.M7
  S9 w0.127: v4(63.5,168.02) 63.09,167.61 53.36,167.61 v4(52.96,168.02)
  S16 w0.127: v4(44.7,126.65) 44.53,126.48 44.36,126.48 44.17,126.67 44.17,127.85 43.87,128.15 43.52,128.15 43.3,128.37 43.3,134.81 43.56,135.07 43.56,140.37 44.72,141.53 44.72,141.68 44.59,141.81 43.7,141.81 43.58,141.93 43.56,141.93 43.56,142.54 43.69,142.67 46,142.67 46.13,142.79 46.13,143.3 46,143.43 43.69,143.43 43.56,143.56 43.56,144.06 43.69,144.19 47.53,144.19 47.65,144.32 47.65,144.83 47.53,144.95 43.69,144.95 43.56,145.08 43.56,145.59 43.69,145.71 47.33,145.71 48.05,146.43 48.05,151.44 47.1,152.39 47.1,153.1 50.79,156.79 50.79,168.04 51.16,168.41 52.56,168.41 v4(52.96,168.02)
DDRB_A13: length 82
  TOP w0.127: v4(42.7,125.65) U40.AH16 ; R148.2 60.42,173.51 v4(62.7,171.23)
  TOP w0.13: U15.T8 62.7,171.22 v4(62.7,171.23) ; v4(52.16,171.22) U14.T8
  S12 w0.122: v4(52.16,171.22) 56.79,170.81 58.72,170.81 58.74,170.79 61.89,170.79 62.22,170.89 v4(62.7,171.23)
  S16 w0.127: v4(42.7,125.65) 42.22,125.17 41.62,125.17 41.17,125.62 41.17,125.73 40.73,126.17 40.62,126.17 40.14,126.64 40.14,126.76 39.8,127.1 39.68,127.1 39.25,127.54 39.25,134.96 39.51,135.23 39.51,137.87 38.99,138.39 38.99,148.23 43.48,152.71 43.48,153.23 42.27,154.44 42.27,154.62 42.62,154.98 42.8,154.98 44.18,153.6 44.36,153.6 44.72,153.96 44.72,154.14 43.34,155.51 43.34,155.69 43.7,156.05 43.88,156.05 45.26,154.68 45.44,154.68 45.8,155.03 45.8,155.21 44.42,156.59 44.42,156.91 46.49,158.99 46.49,164.08 47.22,164.8 47.22,166.27 48.48,167.53 48.48,169.14 50.95,171.61 51.76,171.61 v4(52.16,171.22)
DDRB_ACT_N: length 87.2
  TOP w0.127: v4(51.7,132.65) U40.AR7 ; R153.2 65.51,175.01 65.51,168.4 U15.L3
  TOP w0.13: v4(56.96,167.22) U14.L3 ; U15.L3 v4(67.5,167.22)
  S7 w0.127: v4(56.96,167.22) 57.36,167.62 59.96,167.62 60.76,166.82 67.1,166.82 v4(67.5,167.22)
  S14 w0.127: v4(56.96,167.22) 56.48,166.74 56.48,165.54 56.94,165.07 59.27,165.07 59.91,164.44 59.91,160.85 60.23,160.53 61.2,160.53 61.43,160.3 61.43,159.87 61.2,159.64 60.14,159.64 59.91,159.41 59.91,159 60.14,158.77 61.18,158.77 61.31,158.65 61.31,158.19 61.13,158.01 60.16,158.01 59.99,157.83 59.99,157.5 60.19,157.3 61.74,157.3 61.87,157.17 61.87,156.67 61.74,156.54 60.14,156.54 60.01,156.42 60.01,155.91 60.14,155.78 62.42,155.78 62.55,155.65 62.55,155.15 62.42,155.02 60.14,155.02 60.01,154.89 60.01,154.38 60.14,154.26 61.74,154.26 61.87,154.13 61.87,150.62 52.34,141.09 52.34,138.56 52.03,138.25 51.85,138.25 51.02,139.08 50.84,139.08 50.48,138.72 50.48,138.54 51.31,137.71 51.31,137.53 50.95,137.17 50.77,137.17 49.94,138.01 49.76,138.01 49.4,137.65 49.4,137.47 50.23,136.63 50.23,136.45 49.2,135.42 49.2,133.35 49.41,133.14 49.89,133.14 50.17,132.85 50.17,132.52 50.52,132.18 51.23,132.18 v4(51.7,132.65)
DDRB_ALERT0: length 80.7
  TOP w0.127: v4(50.7,133.65) U40.AT8
  TOP w0.13: v4(61.9,169.62) U15.P9
  S14 w0.127: v4(61.9,169.62) 62.29,169.22 63.83,169.22 64.32,168.74 64.59,168.74 66.37,170.52 66.55,170.52 66.91,170.16 66.91,169.98 65.14,168.22 65.14,167.93 65.49,167.58 65.67,167.58 66.46,168.37 66.74,168.37 67.03,168.09 67.03,167.86 66.21,167.04 66.21,166.86 67.05,166.02 67.65,166.02 67.9,165.77 67.9,165.45 68.31,165.05 69.08,165.05 69.69,165.65 69.69,171.75 69.82,171.88 70.93,171.88 71.12,171.69 71.12,158.76 71.11,158.76 68.01,155.66 68.01,153.48 62.23,147.7 62.23,142.01 59.69,139.48 59.69,139.2 60.14,138.76 60.14,138.4 59.86,138.12 59.53,138.12 59.2,138.45 58.82,138.45 58.59,138.22 58.59,137.77 59.16,137.2 59.16,136.74 58.27,135.85 55,135.85 54.21,135.06 52.55,135.06 52.19,134.7 52.19,134.3 52.02,134.12 51.52,134.12 51.04,133.65 v4(50.7,133.65)
  BOTTOM w0.127: v4(61.9,169.62) 60.65,168.37 TPB45.1
DDRB_ALERT1: length 68.3
  TOP w0.127: v4(43.7,127.65) U40.AK15
  TOP w0.13: v4(51.36,169.62) U14.P9
  S16 w0.127: v4(51.36,169.62) 51.36,169.59 50.16,168.39 50.16,157.05 46.46,153.36 46.46,152.13 47.41,151.17 47.41,146.69 47.07,146.35 42.2,146.35 41.91,146.06 41.91,145.51 42.03,145.39 42.8,145.39 42.93,145.26 42.93,144.75 42.8,144.63 42.05,144.63 41.91,144.49 41.91,143.98 42.04,143.86 42.75,143.86 42.93,143.68 42.93,143.25 42.77,143.09 41.79,143.09 41.6,142.91 41.6,142.52 41.84,142.28 42.69,142.28 42.93,142.04 42.93,141.59 42.69,141.35 41.04,141.35 40.91,141.22 40.91,140.69 41.04,140.57 42.76,140.57 42.93,140.4 42.93,139.88 42.71,139.66 41.66,139.66 41.52,139.52 41.52,138.95 41.66,138.81 42.79,138.81 42.93,138.67 42.93,138.19 42.76,138.02 41.95,138.02 41.62,137.69 41.62,137.41 41.88,137.16 42.82,137.16 42.93,137.04 42.93,136.51 42.8,136.38 41.89,136.38 41.73,136.22 41.73,135.22 42.29,134.66 42.29,128.35 42.49,128.15 42.93,128.15 43.44,127.65 v4(43.7,127.65)
  BOTTOM w0.127: TPB46.1 49.97,169.86 51.11,169.86 v4(51.36,169.62)
DDRB_BA0: length 83.8
  TOP w0.127: v4(49.7,131.65) U40.AP9
  TOP w0.13: v4(57.76,168.82) U14.N2 ; v4(68.3,168.82) U15.N2
  S5 w0.127: v4(57.76,168.82) 58.16,168.42 U15.N2 v4(68.3,168.82)
  S14 w0.127: v4(49.7,131.65) 49.38,131.65 48.83,132.2 48.51,132.2 48.14,132.58 48.14,132.83 47.76,133.2 47.51,133.2 47.18,133.53 47.18,137.55 55.48,145.85 55.48,150.03 55.61,150.16 58.46,150.16 58.59,150.29 58.59,150.8 58.46,150.92 55.61,150.92 55.48,151.05 55.48,151.56 55.61,151.68 58.41,151.68 58.54,151.81 58.54,152.32 58.41,152.45 55.61,152.45 55.48,152.57 55.48,153.08 55.61,153.21 58.44,153.21 58.56,153.34 58.56,153.84 58.44,153.97 55.61,153.97 55.48,154.1 55.48,154.61 55.61,154.73 56.71,154.73 56.84,154.86 56.84,155.37 56.71,155.49 55.61,155.49 55.48,155.62 55.48,156.02 55.67,156.21 56.71,156.21 56.94,156.44 56.94,157.44 56.26,158.11 56.26,161.99 55.34,162.91 55.34,167.76 56.79,169.22 57.35,169.22 v4(57.76,168.82)
  BOTTOM w0.127: v4(68.3,168.82) 68.7,169.22 72.67,169.22 RB95.2
DDRB_BA1: length 84.7
  TOP w0.127: v4(45.7,126.65) U40.AJ13
  TOP w0.13: v4(62.7,168.82) U15.N8 ; v4(52.16,168.82) U14.N8
  S9 w0.127: v4(52.16,168.82) 52.56,169.22 59.32,169.22 62.29,169.22 v4(62.7,168.82)
  S14 w0.127: v4(45.7,126.65) 45.7,127 45.21,127.48 45.21,127.83 44.89,128.15 42.49,128.15 42.2,128.44 42.2,128.84 41.91,129.14 41.53,129.14 41.28,129.39 41.28,129.87 41.02,130.13 40.62,130.13 40.3,130.44 40.3,135.43 40.28,135.46 40.28,136.33 49.14,145.19 49.14,149.87 49.01,150 47.59,150 47.46,150.12 47.46,150.63 47.59,150.76 49.24,150.76 49.37,150.89 49.37,151.39 49.24,151.52 47.59,151.52 47.46,151.65 47.46,152.16 47.59,152.28 49.24,152.28 49.37,152.41 49.37,152.92 49.24,153.04 47.59,153.04 47.46,153.17 47.46,153.68 47.59,153.81 49.01,153.81 49.14,153.93 49.14,154.38 48.94,154.58 47.72,154.58 47.54,154.76 47.54,155.27 47.77,155.5 48.76,155.5 48.86,155.6 48.86,158.16 49.75,159.05 49.75,167.77 51.19,169.21 51.76,169.21 v4(52.16,168.82)
  BOTTOM w0.127: v4(62.7,168.82) 62.71,168.82 63.09,169.2 63.09,170.66 63.47,171.03 63.47,173.38 62.45,174.39 RB62.2
