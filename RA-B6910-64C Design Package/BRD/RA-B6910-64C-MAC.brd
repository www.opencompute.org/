# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC13_TDN1: length 149.6
  TOP w0.147: v4(167.55,147.39) 167.55,147.34 U1.BA63
  SIG6 w0.112: v4(167.55,147.39) 167.55,147.62 arc(167.51,147.71) 167.42,147.74 167.25,147.74 arc(167.02,147.84) 166.92,148.07 166.92,148.56 arc(166.91,148.61) 166.89,148.65 166.83,148.7 arc(166.79,148.73) 166.74,148.74 163.23,148.74 163.14,148.65 163.12,148.65
  SIG6 w0.16: 163.12,148.65 162.82,148.65 arc(162.7,148.62) 162.59,148.55 159.28,145.24 arc(158.9,144.99) 158.47,144.9 152.09,144.9 arc(151.95,144.88) 151.82,144.79 129.84,122.81 arc(129.76,122.69) 129.73,122.54 129.73,108.62 arc(129.67,108.33) 129.51,108.08 123.76,102.33 114.87,93.44 arc(114.62,93.27) 114.33,93.22 111.23,93.22 arc(110.93,93.16) 110.69,92.99 95.66,77.97 arc(95.5,77.72) 95.44,77.43 95.44,73.06 arc(95.38,72.77) 95.22,72.52 91.5,68.8 arc(91.25,68.64) 90.96,68.58 88.05,68.58 87.8,68.33 87.37,68.33 87.13,68.58 86.65,68.58 86.4,68.33 85.97,68.33 85.73,68.58 85.25,68.58 85.02,68.36 84.54,68.36 84.32,68.58 83.84,68.58 arc(83.55,68.52) 83.3,68.35 82.94,67.99 82.94,67.67 82.6,67.33 82.28,67.33 81.94,66.99 arc(81.78,66.75) 81.72,66.46 81.72,64.53 arc(81.75,64.39) 81.83,64.26 82.59,63.51 arc(82.71,63.42) 82.86,63.39 91.59,63.39 arc(91.88,63.34) 92.13,63.17 92.22,63.08 arc(92.46,62.92) 92.76,62.86 93.66,62.86 arc(93.9,62.76) 94,62.52 94,62.34 arc(93.96,62.14) 93.85,61.97 YJ24.A5
FC13_TDN2: length 127.4
  TOP w0.147: U1.BB61 170,147.84 arc(169.68,147.97) v4(169.55,148.29)
  SIG6 w0.112: v4(169.55,148.29) 169.55,148.07 arc(169.51,147.98) 169.42,147.94 169.25,147.94 arc(169.02,147.85) 168.92,147.62 168.92,147.13 arc(168.91,147.08) 168.89,147.04 168.83,146.99 arc(168.79,146.96) 168.74,146.95 163.36,146.95 163.27,147.04 163.24,147.04
  SIG6 w0.16: 163.24,147.04 162.89,147.04 arc(162.59,146.98) 162.35,146.82 161.96,146.43 arc(161.79,146.18) 161.73,145.89 161.73,144.64 arc(161.68,144.35) 161.51,144.1 160.63,143.22 arc(160.53,143.13) 160.4,143.07 arc(160.25,143.02) 160.09,143 152.91,143 arc(152.47,142.91) 152.1,142.66 131.84,122.4 arc(131.6,122.03) 131.51,121.6 131.51,107.86 arc(131.48,107.71) 131.4,107.59 109.62,85.81 arc(109.37,85.44) 109.28,85 109.28,77.5 arc(109.25,77.36) 109.17,77.23 104.42,72.48 arc(104.17,72.32) 103.88,72.26 98.9,72.26 arc(98.61,72.2) 98.36,72.04 94.85,68.52 arc(94.6,68.15) 94.51,67.71 94.51,66.16 arc(94.57,65.85) 94.75,65.58 95.14,65.19 arc(95.26,65.02) 95.3,64.81 YJ24.A36
FC13_TDN3: length 124.5
  TOP w0.147: U1.AW66 164.55,145.34 v4(164.55,145.39)
  SIG7 w0.112: 163.15,144.68 163.18,144.68 163.27,144.78 163.71,144.78 arc(163.75,144.78) 163.79,144.79 arc(163.87,144.82) 163.94,144.87 164,144.93 arc(164.08,145.06) 164.11,145.21 164.11,145.62 arc(164.15,145.71) 164.24,145.74 164.38,145.74 arc(164.5,145.7) 164.55,145.58 v4(164.55,145.39)
  SIG7 w0.16: YJ24.A34 93.85,65.97 arc(93.96,66.14) 94,66.34 94,66.52 arc(93.9,66.76) 93.66,66.86 92.76,66.86 arc(92.46,66.92) 92.22,67.08 91.99,67.31 arc(91.7,67.74) 91.6,68.24 91.6,68.37 arc(91.66,68.68) 91.84,68.94 92.58,69.68 arc(92.91,69.9) 93.29,69.97 94.23,69.97 94.39,69.82 94.9,69.82 95.05,69.97 95.52,69.97 95.67,69.82 96.19,69.82 96.34,69.97 96.8,69.97 96.98,69.8 97.45,69.8 97.62,69.97 98.09,69.97 98.22,69.85 98.78,69.85 98.91,69.97 99.37,69.97 99.53,69.82 100.04,69.82 100.19,69.97 100.66,69.97 100.81,69.82 101.33,69.82 101.48,69.97 102.11,69.97 arc(102.4,70.03) 102.65,70.2 109.44,76.99 arc(109.61,77.24) 109.66,77.53 109.66,85.18 arc(109.69,85.33) 109.78,85.45 131.67,107.34 arc(131.83,107.59) 131.89,107.88 131.89,121.73 arc(131.92,121.88) 132,122 152.5,142.51 arc(152.63,142.59) 152.77,142.62 160.15,142.62 arc(160.44,142.68) 160.69,142.84 162.42,144.57 arc(162.54,144.66) 162.69,144.68 163.15,144.68
FC13_TDP0: length 147.7
  TOP w0.147: U1.BA65 165.55,147.34 v4(165.55,147.39)
  SIG7 w0.112: 163.15,146.71 163.18,146.71 163.27,146.8 164.71,146.8 arc(164.86,146.83) 164.98,146.92 165,146.94 arc(165.09,147.06) 165.12,147.21 165.12,147.62 arc(165.16,147.71) 165.25,147.74 165.38,147.74 arc(165.5,147.7) 165.55,147.58 v4(165.55,147.39)
  SIG7 w0.16: 163.15,146.71 161.54,146.71 arc(161.39,146.68) 161.27,146.6 159.8,145.13 arc(159.55,144.96) 159.26,144.9 152.11,144.9 arc(151.97,144.88) 151.84,144.79 129.84,122.79 arc(129.76,122.67) 129.73,122.52 129.73,108.64 arc(129.67,108.35) 129.51,108.11 114.94,93.54 arc(114.69,93.37) 114.4,93.31 111.19,93.31 arc(111.04,93.28) 110.92,93.2 95.55,77.83 arc(95.47,77.71) 95.44,77.56 95.44,75.59 arc(95.38,75.3) 95.22,75.05 94.67,74.51 94.67,74.28 94.31,73.93 94.09,73.93 93.76,73.6 93.76,73.4 93.38,73.02 93.19,73.02 92.52,72.36 arc(92.27,72.19) 91.98,72.13 91.06,72.13 arc(90.74,72.07) 90.48,71.89 89.21,70.63 89.21,70.4 88.89,70.07 88.66,70.07 88.33,69.75 88.33,69.57 87.95,69.19 87.77,69.19 87.46,68.87 arc(87.13,68.65) 86.74,68.58 86.18,68.58 86.03,68.43 85.52,68.43 85.36,68.58 84.9,68.58 84.72,68.4 84.26,68.4 84.08,68.58 83.66,68.58 arc(83.51,68.55) 83.39,68.47 81.83,66.91 arc(81.75,66.78) 81.72,66.64 81.72,64.36 arc(81.75,64.21) 81.83,64.09 82.42,63.51 arc(82.54,63.42) 82.69,63.39 93.99,63.39 arc(94.28,63.34) 94.53,63.17 94.62,63.08 arc(94.86,62.92) 95.16,62.86 96.06,62.86 arc(96.3,62.76) 96.4,62.52 96.4,62.34 arc(96.36,62.14) 96.25,61.97 YJ24.A2
FC13_TDP1: length 149.6
  TOP w0.147: U1.BB63 168,147.84 arc(167.68,147.97) v4(167.55,148.29)
  SIG6 w0.112: v4(167.55,148.29) 167.55,148.07 arc(167.51,147.98) 167.42,147.94 167.25,147.94 arc(167.16,147.98) 167.12,148.07 167.12,148.56 arc(167.09,148.69) 167.02,148.79 166.97,148.84 arc(166.87,148.91) 166.74,148.94 163.23,148.94 163.14,149.03 163.12,149.03
  SIG6 w0.16: YJ24.A6 92.9,60.83 arc(92.86,61.02) 92.75,61.18 92.53,61.4 92.35,61.58 arc(92.17,61.85) 92.11,62.16 92.11,62.48 arc(92.11,62.53) 92.1,62.58 arc(92.06,62.68) 91.99,62.77 91.95,62.82 91.86,62.9 arc(91.74,62.98) 91.59,63.01 82.86,63.01 arc(82.57,63.07) 82.32,63.24 81.56,63.99 arc(81.4,64.24) 81.34,64.53 81.34,66.46 arc(81.43,66.89) 81.68,67.26 83.04,68.62 arc(83.41,68.87) 83.84,68.96 90.96,68.96 arc(91.11,68.99) 91.23,69.07 94.95,72.79 arc(95.03,72.91) 95.06,73.06 95.06,77.43 arc(95.15,77.87) 95.39,78.24 110.42,93.26 arc(110.79,93.51) 111.23,93.6 114.33,93.6 arc(114.47,93.63) 114.6,93.71 129.24,108.35 arc(129.32,108.47) 129.35,108.62 129.35,122.54 arc(129.41,122.84) 129.57,123.08 151.55,145.06 arc(151.8,145.23) 152.09,145.29 158.47,145.29 arc(158.76,145.34) 159.01,145.51 162.32,148.82 arc(162.55,148.98) 162.82,149.03 163.12,149.03
FC13_TDP2: length 127.5
  TOP w0.147: v4(169.55,147.39) 169.55,147.34 U1.BA61
  SIG6 w0.112: v4(169.55,147.39) 169.55,147.58 arc(169.54,147.63) 169.51,147.67 169.48,147.71 arc(169.44,147.73) 169.39,147.74 169.25,147.74 arc(169.16,147.71) 169.12,147.62 169.12,147.13 arc(169.09,147) 169.02,146.9 168.97,146.85 arc(168.87,146.78) 168.74,146.75 163.36,146.75 163.27,146.66 163.24,146.66
  SIG6 w0.16: 163.24,146.66 162.89,146.66 arc(162.74,146.63) 162.62,146.55 162.23,146.16 arc(162.14,146.04) 162.12,145.89 162.12,144.64 arc(162.03,144.2) 161.78,143.83 160.9,142.95 arc(160.74,142.82) 160.56,142.72 arc(160.33,142.64) 160.09,142.62 152.91,142.62 arc(152.62,142.56) 152.37,142.4 132.11,122.14 arc(131.95,121.89) 131.89,121.6 131.89,107.86 arc(131.83,107.57) 131.67,107.32 109.89,85.54 arc(109.72,85.29) 109.66,85 109.66,77.5 arc(109.61,77.21) 109.44,76.96 104.69,72.21 arc(104.32,71.97) 103.88,71.88 101.87,71.88 101.67,71.68 101.15,71.68 100.95,71.88 100.3,71.88 100.12,71.7 99.56,71.7 99.38,71.88 98.9,71.88 arc(98.75,71.85) 98.63,71.77 98.09,71.23 98.09,70.89 97.78,70.57 97.44,70.57 97.1,70.23 97.1,69.9 96.78,69.58 96.45,69.58 96.11,69.24 96.11,68.91 95.79,68.59 95.45,68.59 95.11,68.25 arc(94.95,68) 94.89,67.71 94.89,67.07 arc(94.95,66.92) 95.1,66.86 96.06,66.86 arc(96.3,66.76) 96.4,66.52 96.4,66.34 arc(96.36,66.14) 96.25,65.97 YJ24.A37
FC13_TDP3: length 124.5
  TOP w0.147: U1.AY66 165,145.84 arc(164.68,145.97) v4(164.55,146.29)
  SIG7 w0.112: 163.15,145.07 163.18,145.07 163.23,145.01 arc(163.27,144.98) 163.33,144.97 163.71,144.97 arc(163.73,144.97) 163.74,144.98 arc(163.77,144.99) 163.8,145.01 163.86,145.07 arc(163.9,145.13) 163.92,145.21 163.92,145.62 arc(164.01,145.85) 164.24,145.94 164.38,145.94 arc(164.5,145.99) 164.55,146.1 v4(164.55,146.29)
  SIG7 w0.16: YJ24.A33 92.9,64.77 arc(92.85,65.01) 92.72,65.22 92.35,65.58 arc(92.17,65.85) 92.11,66.16 92.11,66.48 arc(92.11,66.53) 92.1,66.58 arc(92.06,66.69) 91.99,66.77 91.95,66.82 91.72,67.04 arc(91.35,67.59) 91.22,68.24 91.22,68.37 arc(91.31,68.83) 91.57,69.21 92.31,69.95 arc(92.76,70.25) 93.29,70.36 102.11,70.36 arc(102.26,70.38) 102.38,70.47 109.17,77.26 arc(109.25,77.38) 109.28,77.53 109.28,85.18 arc(109.34,85.48) 109.51,85.72 131.4,107.61 arc(131.48,107.74) 131.51,107.88 131.51,121.73 arc(131.57,122.03) 131.73,122.27 152.23,142.78 arc(152.48,142.94) 152.77,143 160.15,143 arc(160.29,143.03) 160.42,143.11 162.15,144.84 arc(162.4,145.01) 162.69,145.07 163.15,145.07
FC14_15_PVDD0P8: length 5.1
  TOP w0.229: U1.AU49 182.05,142.84 v1(181.55,143.34) ; v1(181.55,141.34) 182.05,140.84 U1.AR49
  TOP w0.381: 155.61,146.53 C2958.1 154.88,147.32
  BOTTOM w0.13: v1(155.38,147.7) v2(155.38,148.46)
  BOTTOM w0.381: v1(181.55,143.34) 181.06,143.83 C2911.1 ; v1(181.55,141.34) 181.06,141.83 C3331.1
  vias: v1(154.37,147.7)
FC14_RDN0: length 135.2
  TOP w0.147: v4(176.55,145.29) 176.66,145.29 arc(176.76,145.27) 176.84,145.22 176.97,145.08 arc(177.03,145) 177.05,144.9 U1.AW54
  SIG2 w0.112: 163.28,143.02 163.31,143.02 163.4,142.92 175.7,142.92 arc(175.75,142.93) 175.79,142.96 175.89,143.06 arc(175.91,143.1) 175.92,143.15 175.92,144.62 arc(176.02,144.85) 176.25,144.94 176.42,144.94 arc(176.51,144.98) 176.55,145.07 v4(176.55,145.29)
  SIG2 w0.16: YJ23.C14 92.75,61.97 arc(92.64,62.13) 92.61,62.32 92.61,62.57 arc(92.69,62.78) 92.9,62.86 93.78,62.86 arc(94.07,62.92) 94.32,63.08 94.36,63.13 94.41,63.18 arc(94.5,63.26) 94.6,63.32 arc(94.77,63.38) 94.95,63.41 97.45,63.41 arc(97.74,63.46) 97.99,63.63 99.66,65.31 arc(99.83,65.55) 99.89,65.85 99.89,67.53 arc(99.94,67.82) 100.11,68.07 111.42,79.38 arc(111.59,79.63) 111.65,79.92 111.65,89.83 arc(111.7,90.12) 111.87,90.37 131.29,109.79 arc(131.45,110.03) 131.51,110.33 131.51,121.6 arc(131.6,122.04) 131.84,122.41 152.04,142.61 arc(152.42,142.86) 152.85,142.95 161.4,142.95 arc(161.52,143) 161.66,143.02 163.28,143.02
FC14_RDN1: length 128.5
  TOP w0.147: v4(172.55,144.39) 172.55,144.34 U1.AV58
  SIG3 w0.112: v4(172.55,144.39) 172.55,144.62 arc(172.51,144.71) 172.42,144.74 172.25,144.74 arc(172.16,144.71) 172.12,144.62 172.12,143.14 arc(172.09,143.02) 172.02,142.91 171.94,142.82 arc(171.83,142.75) 171.71,142.73 163.29,142.73 163.21,142.66
  SIG3 w0.16: 163.21,142.66 161.79,142.66 arc(161.72,142.65) 161.66,142.64 161.5,142.58 arc(161.4,142.56) 161.3,142.55 152.84,142.55 arc(152.55,142.5) 152.3,142.33 132.11,122.14 arc(131.95,121.89) 131.89,121.6 131.89,110.17 arc(131.83,109.88) 131.67,109.63 112.25,90.21 arc(112.08,89.97) 112.03,89.67 112.03,79.76 arc(111.97,79.47) 111.8,79.23 102.01,69.44 arc(101.85,69.19) 101.79,68.9 101.79,68.09 arc(101.7,67.65) 101.46,67.28 99.18,65.01 99.18,64.67 98.79,64.29 98.46,64.29 98.1,63.93 98.1,63.59 97.72,63.21 97.38,63.21 97.02,62.85 arc(96.94,62.72) 96.91,62.57 96.91,62.08 arc(96.86,61.86) 96.74,61.67 96.27,61.21 arc(96.15,61.02) 96.1,60.79 YJ23.C18
FC14_RDN2: length 129
  TOP w0.147: v4(174.55,145.29) 174.64,145.29 arc(174.73,145.27) 174.8,145.23 174.97,145.05 arc(175.03,144.97) 175.05,144.87 U1.AW56
  SIG2 w0.112: v4(174.55,145.29) 174.55,145.07 arc(174.51,144.98) 174.42,144.94 174.25,144.94 arc(174.02,144.85) 173.92,144.62 173.92,144.2 arc(173.91,144.15) 173.89,144.11 173.79,144.01 arc(173.75,143.99) 173.7,143.98 169.35,143.98 arc(169.3,143.99) 169.26,144.01 169.19,144.09 arc(169.16,144.13) 169.15,144.18 169.15,144.18 169.15,144.62 arc(169.06,144.85) 168.83,144.95 163.38,144.95 163.28,145.04 163.26,145.04
  SIG2 w0.16: YJ23.C22 95.15,65.97 arc(95.04,66.13) 95.01,66.32 95.01,66.54 arc(95.1,66.77) 95.33,66.86 96.18,66.86 arc(96.47,66.92) 96.72,67.08 96.76,67.13 96.81,67.18 97.33,67.7 arc(97.53,68) 97.6,68.35 97.6,79.85 arc(97.66,80.14) 97.82,80.39 129.13,111.69 arc(129.29,111.94) 129.35,112.23 129.35,122.41 arc(129.44,122.85) 129.68,123.22 151.54,145.08 arc(151.92,145.33) 152.35,145.41 159.95,145.41 arc(160.19,145.36) 160.4,145.22 arc(160.61,145.09) 160.85,145.04 163.26,145.04
FC14_RDN3: length 124.5
  TOP w0.147: v4(170.55,144.39) 170.55,144.34 U1.AV60
  SIG3 w0.112: 163.26,144.65 163.28,144.65 163.38,144.74 168.84,144.74 arc(169,144.77) 169.13,144.86 arc(169.13,144.87) 169.14,144.87 169.53,144.87 arc(170.03,144.77) 170.46,144.48 v4(170.55,144.39)
  SIG3 w0.16: 163.26,144.65 162.49,144.65 arc(162.09,144.73) 161.76,144.95 arc(161.67,145.01) 161.57,145.03 152.35,145.03 arc(152.06,144.97) 151.81,144.81 129.95,122.95 arc(129.79,122.7) 129.73,122.41 129.73,112.07 arc(129.67,111.78) 129.51,111.53 95.54,77.56 arc(95.37,77.32) 95.31,77.02 95.31,70.91 95.54,70.68 95.54,70.12 95.31,69.89 95.31,69.38 95.54,69.16 95.54,68.6 95.31,68.37 95.31,67.86 arc(95.26,67.57) 95.09,67.32 94.73,66.96 94.71,66.94 arc(94.56,66.72) 94.51,66.45 94.51,66.08 arc(94.46,65.86) 94.34,65.67 94.09,65.43 93.88,65.22 arc(93.75,65.02) 93.7,64.78 YJ23.C24
FC14_RDP0: length 135.2
  TOP w0.147: v4(176.55,144.39) 176.55,144.34 U1.AV54
  SIG2 w0.112: v4(176.55,144.39) 176.55,144.62 arc(176.51,144.71) 176.42,144.74 176.25,144.74 arc(176.16,144.71) 176.12,144.62 176.12,143.15 arc(176.09,143.02) 176.02,142.92 175.93,142.82 arc(175.82,142.75) 175.7,142.73 163.4,142.73 163.31,142.64 163.28,142.64
  SIG2 w0.16: 163.28,142.64 161.66,142.64 arc(161.63,142.63) 161.6,142.62 arc(161.58,142.61) 161.57,142.6 arc(161.53,142.57) 161.49,142.57 152.85,142.57 arc(152.56,142.51) 152.31,142.34 132.11,122.14 arc(131.95,121.89) 131.89,121.6 131.89,110.33 arc(131.8,109.89) 131.55,109.52 112.14,90.1 arc(112.06,89.98) 112.03,89.83 112.03,79.92 arc(111.94,79.48) 111.69,79.11 102.53,69.96 102.53,69.62 102.15,69.24 101.82,69.24 101.46,68.88 101.46,68.54 101.07,68.16 100.74,68.16 100.38,67.8 arc(100.3,67.68) 100.27,67.53 100.27,65.85 arc(100.18,65.41) 99.93,65.04 98.26,63.36 arc(97.88,63.11) 97.45,63.03 94.95,63.03 arc(94.86,63.01) 94.78,62.98 arc(94.73,62.95) 94.68,62.91 94.63,62.86 arc(94.54,62.72) 94.51,62.57 94.51,62.08 arc(94.46,61.86) 94.34,61.67 93.87,61.21 arc(93.75,61.02) 93.7,60.79 YJ23.C15
FC14_RDP1: length 128.5
  TOP w0.147: v4(172.55,145.29) 172.55,145.22 arc(172.56,145.15) 172.6,145.09 172.71,144.98 arc(172.86,144.88) U1.AW58
  SIG3 w0.112: 163.26,143.04 163.37,142.92 171.71,142.92 arc(171.76,142.93) 171.8,142.96 171.89,143.05 arc(171.91,143.09) 171.92,143.14 171.92,144.62 arc(172.02,144.85) 172.25,144.94 172.42,144.94 arc(172.51,144.98) 172.55,145.07 v4(172.55,145.29)
  SIG3 w0.16: 163.26,143.04 161.79,143.04 arc(161.67,143.03) 161.55,143 161.39,142.95 arc(161.34,142.94) 161.3,142.93 152.84,142.93 arc(152.4,142.85) 152.03,142.6 131.84,122.41 arc(131.6,122.04) 131.51,121.6 131.51,110.17 arc(131.48,110.02) 131.4,109.9 111.98,90.48 arc(111.73,90.11) 111.65,89.67 111.65,79.76 arc(111.62,79.62) 111.53,79.49 101.74,69.71 arc(101.5,69.33) 101.41,68.9 101.41,68.09 arc(101.35,67.8) 101.19,67.55 96.72,63.09 arc(96.47,62.92) 96.18,62.86 95.34,62.86 arc(95.1,62.76) 95.01,62.53 95.01,62.32 arc(95.04,62.13) 95.15,61.97 YJ23.C17
FC14_RDP2: length 129.1
  TOP w0.147: v4(174.55,144.39) 174.55,144.34 U1.AV56
  SIG2 w0.112: v4(174.55,144.39) 174.55,144.62 arc(174.51,144.71) 174.42,144.74 174.25,144.74 arc(174.16,144.71) 174.12,144.62 174.12,144.2 arc(174.09,144.07) 174.02,143.97 173.93,143.87 arc(173.82,143.8) 173.7,143.78 169.35,143.78 arc(169.23,143.8) 169.12,143.87 169.05,143.95 arc(168.98,144.05) 168.95,144.18 168.95,144.62 arc(168.92,144.71) 168.83,144.75 163.38,144.75 163.28,144.66 163.26,144.66
  SIG2 w0.16: YJ23.C21 96.1,64.77 arc(96.15,65.02) 96.29,65.22 96.74,65.67 arc(96.86,65.86) 96.91,66.08 96.91,66.57 arc(96.94,66.72) 97.03,66.86 97.08,66.91 97.6,67.43 arc(97.88,67.85) 97.98,68.35 97.98,69.09 98.21,69.31 98.21,69.85 97.98,70.08 97.98,70.61 98.21,70.84 98.21,71.4 97.98,71.63 97.98,79.85 arc(98.01,80) 98.09,80.12 129.4,111.42 arc(129.64,111.79) 129.73,112.23 129.73,122.41 arc(129.79,122.7) 129.95,122.95 151.81,144.81 arc(152.06,144.97) 152.35,145.03 159.95,145.03 arc(160.04,145.01) 160.13,144.96 arc(160.46,144.73) 160.85,144.66 163.26,144.66
FC14_RDP3: length 124.5
  TOP w0.147: v4(170.55,145.29) 170.55,145.22 arc(170.56,145.15) 170.6,145.09 170.71,144.98 arc(170.86,144.88) U1.AW60
  SIG3 w0.112: 163.26,145.03 163.28,145.03 163.38,144.94 168.84,144.94 arc(168.92,144.96) 168.99,145 arc(169.06,145.05) 169.14,145.06 169.53,145.06 arc(169.8,145.04) 170.06,144.97 arc(170.17,144.96) 170.27,145.02 v4(170.55,145.29)
  SIG3 w0.16: YJ23.C25 92.75,65.97 arc(92.64,66.13) 92.61,66.32 92.61,66.51 arc(92.71,66.76) 92.95,66.86 93.78,66.86 arc(93.99,66.89) 94.18,66.98 arc(94.19,66.99) 94.21,67 arc(94.26,67.04) 94.32,67.08 94.68,67.45 94.82,67.59 arc(94.9,67.71) 94.93,67.86 94.93,77.02 arc(95.02,77.46) 95.27,77.83 129.24,111.8 arc(129.32,111.93) 129.35,112.07 129.35,122.41 arc(129.44,122.85) 129.68,123.22 151.54,145.08 arc(151.92,145.33) 152.35,145.41 161.57,145.41 arc(161.82,145.36) 162.03,145.22 arc(162.24,145.08) 162.49,145.03 163.26,145.03
FC14_TDN0: length 131.9
  TOP w0.147: U1.AU63 167.55,143.34 v4(167.55,143.39)
  SIG4 w0.112: v4(167.55,143.39) 167.55,143.61 arc(167.51,143.7) 167.42,143.73 167.25,143.73 arc(167.16,143.7) 167.12,143.61 167.12,143.14 arc(167.09,143.02) 167.02,142.91 166.94,142.83 arc(166.84,142.76) 166.71,142.74 163.38,142.74 163.29,142.65 163.27,142.65
  SIG4 w0.16: YJ23.C6 86.5,60.82 arc(86.54,61.02) 86.65,61.19 86.91,61.45 87.14,61.67 arc(87.26,61.86) 87.31,62.08 87.31,62.57 arc(87.34,62.72) 87.43,62.86 87.46,62.89 87.48,62.91 arc(87.61,63) 87.75,63.03 96.56,63.03 arc(97,63.11) 97.37,63.36 97.73,63.72 98.06,63.72 98.44,64.1 98.44,64.44 98.8,64.8 99.14,64.8 99.52,65.18 99.52,65.52 101.46,67.45 arc(101.7,67.82) 101.79,68.26 101.79,68.87 101.79,68.87 arc(101.85,69.16) 102.01,69.41 104.36,71.75 111.8,79.2 arc(111.97,79.45) 112.03,79.74 112.03,90.82 arc(112.06,90.96) 112.14,91.09 131.55,110.5 arc(131.8,110.87) 131.89,111.31 131.89,121.63 arc(131.95,121.92) 132.11,122.17 152.28,142.33 arc(152.52,142.5) 152.82,142.55 162.12,142.55 arc(162.27,142.56) 162.41,142.6 162.57,142.65 163.27,142.65
FC14_TDN1: length 133.1
  TOP w0.147: U1.AV65 166,143.84 arc(165.68,143.97) v4(165.55,144.29)
  SIG5 w0.112: v4(165.55,144.29) 165.55,144.07 arc(165.51,143.98) 165.42,143.94 165.25,143.94 arc(165.02,143.85) 164.92,143.62 164.92,143.13 arc(164.92,143.08) 164.89,143.04 164.82,142.97 arc(164.78,142.94) 164.73,142.93 163.38,142.93 163.28,143.02 163.26,143.02
  SIG5 w0.16: 163.26,143.02 152.93,143.02 arc(152.49,142.94) 152.12,142.69 131.84,122.41 arc(131.6,122.04) 131.51,121.6 131.51,111.69 arc(131.45,111.4) 131.29,111.15 111.92,91.79 arc(111.75,91.54) 111.7,91.25 111.7,80.04 arc(111.64,79.75) 111.47,79.5 104.66,72.69 103.37,71.4 99.6,67.63 arc(99.44,67.39) 99.38,67.09 99.38,64.99 arc(99.32,64.7) 99.15,64.45 98.22,63.52 arc(98.1,63.44) 97.96,63.41 85.35,63.41 arc(85.06,63.35) 84.81,63.18 84.76,63.13 84.72,63.08 arc(84.47,62.92) 84.18,62.86 83.31,62.86 arc(83.1,62.77) 83.01,62.55 83.01,62.32 arc(83.04,62.13) 83.15,61.97 YJ23.C2
FC14_TDN2: length 127.5
  TOP w0.147: U1.AW62 168.55,145.34 v4(168.55,145.39)
  SIG4 w0.112: v4(168.55,145.39) 168.55,145.62 arc(168.51,145.71) 168.42,145.74 168.25,145.74 arc(168.16,145.71) 168.12,145.62 168.12,145.15 arc(168.09,145.02) 168.02,144.92 167.94,144.84 arc(167.84,144.77) 167.71,144.74 163.38,144.74 163.28,144.65 163.26,144.65
  SIG4 w0.16: YJ23.C33 86.5,64.78 arc(86.55,65.01) 86.68,65.22 87.14,65.67 arc(87.26,65.86) 87.31,66.08 87.31,66.57 arc(87.34,66.72) 87.43,66.86 87.46,66.89 87.48,66.91 arc(87.61,67) 87.75,67.03 89.57,67.03 arc(89.86,67.08) 90.1,67.25 90.46,67.61 90.77,67.61 91.18,68.02 91.18,68.33 91.54,68.69 91.87,68.69 92.26,69.07 92.26,69.4 93.7,70.84 94.33,71.47 arc(95.06,72.56) 95.31,73.86 95.31,77.02 arc(95.37,77.32) 95.54,77.56 129.51,111.53 arc(129.67,111.78) 129.73,112.07 129.73,122.41 arc(129.79,122.71) 129.95,122.95 151.81,144.81 arc(152.06,144.97) 152.35,145.03 161.47,145.03 arc(161.47,145.03) 161.48,145.03 arc(161.72,144.98) 161.93,144.84 arc(162.14,144.7) 162.39,144.65 163.26,144.65
FC14_TDN3: length 130.4
  TOP w0.147: U1.AY64 167,145.84 arc(166.68,145.97) v4(166.55,146.29)
  SIG5 w0.112: v4(166.55,146.29) 166.55,146.07 arc(166.51,145.98) 166.42,145.94 166.25,145.94 arc(166.02,145.85) 165.92,145.62 165.92,145.14 arc(165.92,145.09) 165.89,145.05 165.82,144.99 arc(165.78,144.96) 165.73,144.95 163.38,144.95 163.28,145.04 163.26,145.04
  SIG5 w0.16: YJ23.C37 83.15,65.97 arc(83.04,66.13) 83.01,66.32 83.01,66.55 arc(83.1,66.77) 83.31,66.86 84.32,66.86 arc(84.46,66.92) 84.53,67.07 84.53,69.67 arc(84.61,70.1) 84.86,70.47 85.68,71.29 arc(86.05,71.54) 86.49,71.63 87.89,71.63 arc(88.18,71.68) 88.43,71.85 92.55,75.97 arc(92.72,76.22) 92.77,76.51 92.77,81.63 arc(92.83,81.92) 93,82.17 100.03,89.2 arc(100.4,89.45) 100.84,89.53 106.3,89.53 arc(106.59,89.59) 106.84,89.76 129.13,112.04 arc(129.29,112.29) 129.35,112.58 129.35,122.39 arc(129.44,122.83) 129.68,123.2 152.07,145.59 arc(152.44,145.83) 152.88,145.92 160.91,145.92 arc(161.2,145.86) 161.45,145.7 161.88,145.26 arc(162.13,145.1) 162.42,145.04 163.26,145.04
FC14_TDP0: length 131.9
  TOP w0.147: v4(167.55,144.29) 167.66,144.29 arc(167.77,144.27) 167.86,144.21 167.92,144.15 arc(168.02,144.01) U1.AV63
  SIG4 w0.112: 163.27,143.03 163.29,143.03 163.38,142.94 166.71,142.94 arc(166.76,142.95) 166.8,142.97 166.89,143.05 arc(166.91,143.09) 166.92,143.14 166.92,143.61 arc(167.02,143.84) 167.25,143.93 167.4,143.93 167.4,143.93 arc(167.45,143.95) 167.5,143.98 arc(167.54,144.04) 167.55,144.1 v4(167.55,144.29)
  SIG4 w0.16: 163.27,143.03 162.57,143.03 arc(162.51,143.02) 162.46,143.01 162.3,142.96 arc(162.21,142.94) 162.12,142.93 152.82,142.93 arc(152.38,142.85) 152.01,142.6 131.84,122.44 arc(131.6,122.06) 131.51,121.63 131.51,111.31 arc(131.45,111.02) 131.29,110.77 111.87,91.36 arc(111.7,91.11) 111.65,90.82 111.65,79.74 arc(111.62,79.59) 111.53,79.47 103.82,71.75 101.74,69.68 arc(101.5,69.31) 101.41,68.87 101.41,68.26 arc(101.35,67.97) 101.19,67.72 97.1,63.63 arc(96.85,63.46) 96.56,63.41 87.75,63.41 arc(87.46,63.35) 87.21,63.18 87.2,63.17 arc(87.2,63.17) 87.2,63.17 87.16,63.13 87.12,63.08 arc(86.87,62.92) 86.58,62.86 85.68,62.86 arc(85.49,62.78) 85.41,62.58 85.41,62.32 arc(85.44,62.13) 85.55,61.97 YJ23.C5
FC14_TDP1: length 133.1
  TOP w0.147: U1.AU65 165.55,143.34 v4(165.55,143.39)
  SIG5 w0.112: v4(165.55,143.39) 165.55,143.62 arc(165.51,143.71) 165.42,143.74 165.25,143.74 arc(165.16,143.71) 165.12,143.62 165.12,143.13 arc(165.1,143) 165.03,142.9 164.96,142.83 arc(164.85,142.76) 164.73,142.74 163.38,142.74 163.28,142.64 163.26,142.64
  SIG5 w0.16: 163.26,142.64 162.5,142.64 162.34,142.49 161.58,142.49 161.43,142.64 152.93,142.64 arc(152.64,142.59) 152.39,142.42 132.11,122.14 arc(131.95,121.89) 131.89,121.6 131.89,111.69 arc(131.8,111.25) 131.55,110.88 112.19,91.52 arc(112.11,91.39) 112.08,91.25 112.08,80.04 arc(111.99,79.61) 111.74,79.24 105.04,72.54 103.75,71.24 102.46,69.95 102.46,69.73 101.92,69.19 101.7,69.19 101.16,68.66 101.16,68.44 100.62,67.9 100.41,67.9 99.87,67.36 arc(99.79,67.24) 99.76,67.09 99.76,64.99 arc(99.67,64.55) 99.42,64.18 98.49,63.25 arc(98.25,63.08) 97.96,63.03 85.35,63.03 arc(85.21,63) 85.08,62.91 85.03,62.86 arc(84.94,62.72) 84.91,62.57 84.91,62.08 arc(84.86,61.86) 84.74,61.67 84.28,61.21 arc(84.15,61.02) 84.1,60.78 YJ23.C3
FC14_TDP2: length 127.6
  TOP w0.147: v4(168.55,146.29) 168.66,146.29 arc(168.77,146.27) 168.86,146.21 168.92,146.15 arc(169.02,146.01) U1.AY62
  SIG4 w0.112: v4(168.55,146.29) 168.55,146.07 arc(168.51,145.98) 168.42,145.94 168.25,145.94 arc(168.02,145.85) 167.92,145.62 167.92,145.15 arc(167.91,145.1) 167.89,145.06 167.8,144.98 arc(167.76,144.95) 167.71,144.94 163.38,144.94 163.28,145.03 163.26,145.03
  SIG4 w0.16: YJ23.C34 85.55,65.97 arc(85.44,66.13) 85.41,66.32 85.41,66.53 arc(85.5,66.77) 85.73,66.86 86.58,66.86 arc(86.87,66.92) 87.12,67.08 87.16,67.13 87.2,67.17 arc(87.2,67.17) 87.2,67.17 87.21,67.18 arc(87.46,67.35) 87.75,67.41 89.57,67.41 arc(89.71,67.44) 89.83,67.52 94.06,71.74 arc(94.71,72.71) 94.93,73.86 94.93,77.02 arc(95.02,77.46) 95.27,77.83 129.24,111.8 arc(129.32,111.93) 129.35,112.07 129.35,122.41 arc(129.44,122.85) 129.68,123.22 151.54,145.08 arc(151.91,145.33) 152.35,145.41 161.49,145.41 arc(161.87,145.33) 162.19,145.11 arc(162.28,145.05) 162.39,145.03 163.26,145.03
FC14_TDP3: length 130.4
  TOP w0.147: U1.AW64 166.55,145.34 v4(166.55,145.39)
  SIG5 w0.112: 163.26,144.66 163.28,144.66 163.38,144.75 165.73,144.75 arc(165.85,144.78) 165.96,144.85 166.03,144.91 arc(166.1,145.02) 166.12,145.14 166.12,145.62 arc(166.16,145.71) 166.25,145.74 166.42,145.74 arc(166.51,145.71) 166.55,145.62 v4(166.55,145.39)
  SIG5 w0.16: YJ23.C36 84.1,64.76 arc(84.15,65.01) 84.29,65.23 84.74,65.67 arc(84.86,65.86) 84.91,66.08 84.91,67.79 85.1,67.99 85.1,68.66 84.91,68.86 84.91,69.67 arc(84.96,69.96) 85.13,70.2 85.95,71.02 arc(86.19,71.19) 86.49,71.24 87.89,71.24 arc(88.32,71.33) 88.69,71.58 89.23,72.12 92.82,75.7 arc(93.07,76.08) 93.15,76.51 93.15,81.63 arc(93.18,81.77) 93.27,81.9 100.3,88.93 arc(100.54,89.09) 100.84,89.15 106.3,89.15 arc(106.74,89.24) 107.11,89.49 129.4,111.77 arc(129.64,112.14) 129.73,112.58 129.73,122.39 arc(129.79,122.68) 129.95,122.93 152.34,145.32 arc(152.59,145.48) 152.88,145.54 159.08,145.54 159.26,145.36 159.97,145.36 160.15,145.54 160.91,145.54 arc(161.06,145.51) 161.18,145.43 161.61,144.99 arc(161.99,144.75) 162.42,144.66 163.26,144.66
FC15_RDN0: length 138.1
  TOP w0.147: v4(176.55,141.39) 176.55,141.34 U1.AR54
  SIG2 w0.112: v4(176.55,141.39) 176.55,141.62 arc(176.51,141.71) 176.42,141.74 176.25,141.74 arc(176.16,141.71) 176.12,141.62 176.12,140.32 arc(176.05,139.96) 175.84,139.65 175.25,139.06 arc(174.94,138.85) 174.57,138.78 163.34,138.78 163.26,138.69
  SIG2 w0.16: YJ23.D15 93.7,52.73 arc(93.76,53.01) 93.91,53.25 94.34,53.67 arc(94.46,53.86) 94.51,54.08 94.51,54.57 arc(94.54,54.72) 94.63,54.86 94.68,54.91 arc(94.73,54.95) 94.78,54.98 arc(94.86,55.01) 94.95,55.03 96.81,55.03 arc(97.25,55.11) 97.62,55.36 98.12,55.86 98.45,55.86 98.84,56.24 98.84,56.58 99.2,56.94 99.53,56.94 99.92,57.32 99.92,57.65 106.44,64.18 arc(106.61,64.43) 106.67,64.72 106.67,67.39 arc(106.73,67.68) 106.89,67.93 116.19,77.23 arc(116.44,77.6) 116.52,78.04 116.52,86.05 arc(116.55,86.19) 116.63,86.32 135.87,105.56 arc(136.12,105.93) 136.21,106.36 136.21,120.03 arc(136.27,120.32) 136.43,120.57 154.04,138.18 arc(154.29,138.34) 154.58,138.4 160.73,138.4 arc(160.92,138.44) 161.08,138.55 arc(161.24,138.66) 161.43,138.69 163.26,138.69
FC15_RDN1: length 131.8
  TOP w0.147: v4(172.55,142.29) 172.55,142.22 arc(172.56,142.15) 172.6,142.09 172.71,141.98 arc(172.86,141.88) U1.AT58
  SIG3 w0.112: 164.03,139.08 164.13,138.98 170.74,138.98 arc(171.03,139.03) 171.27,139.2 171.7,139.62 arc(171.86,139.87) 171.92,140.16 171.92,141.62 arc(172.02,141.85) 172.25,141.94 172.42,141.94 arc(172.51,141.98) 172.55,142.07 v4(172.55,142.29)
  SIG3 w0.16: YJ23.D17 95.15,53.97 arc(95.04,54.13) 95.01,54.32 95.01,54.53 arc(95.1,54.77) 95.34,54.86 96.18,54.86 arc(96.47,54.92) 96.72,55.08 96.76,55.13 105.76,64.13 arc(105.92,64.38) 105.98,64.67 105.98,67.09 arc(106.07,67.53) 106.32,67.9 116.03,77.62 arc(116.11,77.74) 116.14,77.88 116.14,85.89 arc(116.23,86.33) 116.48,86.7 135.71,105.94 arc(135.8,106.06) 135.83,106.21 135.83,120.03 arc(135.91,120.46) 136.16,120.84 153.73,138.4 arc(154.1,138.65) 154.54,138.74 160.33,138.74 arc(160.41,138.75) 160.47,138.79 arc(160.78,139) 161.15,139.08 164.03,139.08
FC15_RDN2: length 133.6
  TOP w0.147: U1.AR56 174.55,141.34 v4(174.55,141.39)
  SIG2 w0.112: 163.23,140.69 163.32,140.78 173.78,140.78 arc(173.83,140.79) 173.87,140.82 174.02,140.97 arc(174.09,141.07) 174.12,141.2 174.12,141.62 arc(174.16,141.71) 174.25,141.74 174.42,141.74 arc(174.51,141.71) 174.55,141.62 v4(174.55,141.39)
  SIG2 w0.16: 163.23,140.69 162.64,140.69 arc(162.51,140.67) 162.39,140.59 arc(162.28,140.51) 162.14,140.48 153.72,140.48 arc(153.43,140.43) 153.18,140.26 134.27,121.35 arc(134.11,121.11) 134.05,120.81 134.05,120.81 134.05,109.56 arc(133.96,109.13) 133.71,108.76 114.22,89.26 arc(114.14,89.14) 114.11,88.99 114.11,79.05 arc(114.02,78.62) 113.77,78.24 104.73,69.2 arc(104.57,68.95) 104.51,68.66 104.51,65.99 arc(104.45,65.7) 104.29,65.45 100.45,61.62 100.45,61.29 100.05,60.9 99.73,60.9 99.37,60.54 99.37,60.23 98.96,59.82 98.65,59.82 98.19,59.36 arc(97.82,59.11) 97.38,59.03 94.95,59.03 arc(94.86,59.01) 94.78,58.98 arc(94.73,58.95) 94.68,58.91 94.63,58.86 arc(94.54,58.72) 94.51,58.57 94.51,58.18 arc(94.44,57.87) 94.26,57.6 93.88,57.21 arc(93.75,57.02) 93.7,56.78 YJ23.D24
FC15_RDN3: length 126.9
  TOP w0.147: v4(170.55,142.29) 170.55,142.22 arc(170.56,142.15) 170.6,142.09 170.71,141.98 arc(170.86,141.88) U1.AT60
  SIG3 w0.112: 163.26,141.04 163.28,141.04 163.38,140.94 169.69,140.94 arc(169.74,140.95) 169.78,140.98 169.89,141.09 arc(169.91,141.13) 169.92,141.17 169.92,141.62 arc(170.02,141.85) 170.25,141.94 170.42,141.94 arc(170.51,141.98) 170.55,142.07 v4(170.55,142.29)
  SIG3 w0.16: 163.26,141.04 161.61,141.04 arc(161.48,141.02) 161.35,140.98 161.09,140.87 arc(160.94,140.83) 160.79,140.82 153.67,140.82 arc(153.23,140.73) 152.86,140.48 134,121.62 arc(133.75,121.25) 133.67,120.81 133.67,109.41 arc(133.64,109.26) 133.56,109.14 114.06,89.64 arc(113.82,89.27) 113.73,88.84 113.73,78.93 arc(113.7,78.78) 113.62,78.66 104.03,69.07 arc(103.78,68.7) 103.7,68.26 103.7,66.38 arc(103.64,66.09) 103.47,65.84 96.72,59.08 arc(96.47,58.92) 96.18,58.86 95.29,58.86 arc(95.09,58.78) 95.01,58.57 95.01,58.32 arc(95.04,58.13) 95.15,57.97 YJ23.D22
FC15_RDP0: length 138.1
  TOP w0.147: v4(176.55,142.29) 176.65,142.29 arc(176.74,142.27) 176.81,142.22 176.97,142.06 arc(177.03,141.98) 177.05,141.88 U1.AT54
  SIG2 w0.112: v4(176.55,142.29) 176.55,142.07 arc(176.51,141.98) 176.42,141.94 176.25,141.94 arc(176.02,141.85) 175.92,141.62 175.92,140.32 arc(175.86,140.03) 175.7,139.79 175.11,139.2 arc(174.86,139.03) 174.57,138.98 163.36,138.98 163.26,139.08
  SIG2 w0.16: 163.26,139.08 161.43,139.08 arc(161.1,139.01) 160.81,138.82 arc(160.77,138.79) 160.73,138.78 154.58,138.78 arc(154.15,138.7) 153.77,138.45 136.16,120.84 arc(135.91,120.46) 135.83,120.03 135.83,106.36 arc(135.77,106.07) 135.6,105.82 116.37,86.59 arc(116.2,86.34) 116.14,86.05 116.14,78.04 arc(116.08,77.75) 115.92,77.5 106.62,68.2 arc(106.37,67.83) 106.29,67.39 106.29,64.72 arc(106.26,64.58) 106.17,64.45 97.35,55.63 arc(97.1,55.46) 96.81,55.41 94.95,55.41 arc(94.77,55.38) 94.6,55.32 arc(94.5,55.26) 94.41,55.18 94.36,55.13 94.32,55.08 arc(94.07,54.92) 93.78,54.86 92.94,54.86 arc(92.7,54.77) 92.61,54.53 92.61,54.32 arc(92.64,54.13) 92.75,53.97 YJ23.D14
FC15_RDP1: length 131.8
  TOP w0.147: U1.AR58 172.55,141.34 v4(172.55,141.39)
  SIG3 w0.112: 164.03,138.69 164.12,138.78 170.74,138.78 arc(171.1,138.85) 171.41,139.06 171.84,139.48 arc(172.05,139.8) 172.12,140.16 172.12,141.62 arc(172.16,141.71) 172.25,141.74 172.42,141.74 arc(172.51,141.71) 172.55,141.62 v4(172.55,141.39)
  SIG3 w0.16: YJ23.D18 96.1,52.77 arc(96.15,53.01) 96.29,53.22 96.74,53.67 arc(96.86,53.86) 96.91,54.08 96.91,54.57 arc(96.94,54.72) 97.03,54.86 97.39,55.22 97.72,55.22 98.1,55.6 98.1,55.93 98.46,56.29 98.77,56.29 99.18,56.7 99.18,57.01 106.03,63.86 arc(106.28,64.23) 106.36,64.67 106.36,67.09 106.36,67.09 arc(106.42,67.39) 106.59,67.63 116.3,77.35 arc(116.46,77.59) 116.52,77.88 116.52,85.89 arc(116.58,86.18) 116.75,86.43 135.98,105.67 arc(136.15,105.91) 136.21,106.21 136.21,120.03 arc(136.27,120.32) 136.43,120.57 154,138.13 arc(154.25,138.3) 154.54,138.36 160.33,138.36 arc(160.55,138.4) 160.74,138.52 arc(160.93,138.65) 161.15,138.69 164.03,138.69
FC15_RDP2: length 133.6
  TOP w0.147: U1.AT56 175.05,141.87 arc(175.03,141.97) 174.97,142.05 174.8,142.22 arc(174.73,142.27) 174.64,142.29 v4(174.55,142.29)
  SIG2 w0.112: v4(174.55,142.29) 174.55,142.07 arc(174.51,141.98) 174.42,141.94 174.25,141.94 arc(174.02,141.85) 173.92,141.62 173.92,141.2 arc(173.91,141.15) 173.89,141.11 173.79,141.01 arc(173.75,140.99) 173.7,140.98 163.33,140.98 163.23,141.07
  SIG2 w0.16: 163.23,141.07 162.64,141.07 arc(162.37,141.02) 162.13,140.87 153.72,140.87 arc(153.28,140.78) 152.91,140.53 134,121.62 arc(133.75,121.25) 133.67,120.81 133.67,109.56 arc(133.61,109.27) 133.44,109.03 113.95,89.53 arc(113.79,89.29) 113.73,88.99 113.73,79.05 arc(113.67,78.76) 113.51,78.51 104.46,69.47 arc(104.21,69.1) 104.13,68.66 104.13,65.99 arc(104.1,65.85) 104.02,65.72 97.92,59.63 arc(97.68,59.46) 97.38,59.41 94.95,59.41 arc(94.77,59.38) 94.6,59.32 arc(94.5,59.26) 94.41,59.18 94.36,59.13 94.32,59.08 arc(94.15,58.96) 93.95,58.88 arc(93.87,58.87) 93.78,58.86 92.97,58.86 arc(92.71,58.75) 92.61,58.5 92.61,58.32 arc(92.64,58.13) 92.75,57.97 YJ23.D25
FC15_RDP3: length 126.9
  TOP w0.147: U1.AR60 170.55,141.34 v4(170.55,141.39)
  SIG3 w0.112: v4(170.55,141.39) 170.55,141.62 arc(170.51,141.71) 170.42,141.74 170.25,141.74 arc(170.16,141.71) 170.12,141.62 170.12,141.17 arc(170.09,141.05) 170.02,140.95 169.92,140.84 arc(169.82,140.77) 169.69,140.75 163.38,140.75 163.28,140.66 163.26,140.66
  SIG3 w0.16: YJ23.D21 96.1,56.76 arc(96.15,57.01) 96.29,57.23 96.74,57.67 arc(96.86,57.86) 96.91,58.08 96.91,58.57 arc(96.94,58.72) 97.03,58.86 97.39,59.22 97.72,59.22 98.1,59.6 98.1,59.93 98.7,60.53 99.04,60.53 99.42,60.92 99.42,61.25 103.74,65.57 arc(103.99,65.94) 104.08,66.38 104.08,68.26 104.08,68.26 arc(104.13,68.55) 104.3,68.8 113.89,78.39 arc(114.05,78.63) 114.11,78.93 114.11,88.84 arc(114.17,89.13) 114.33,89.37 133.83,108.87 arc(133.99,109.11) 134.05,109.41 134.05,120.81 arc(134.11,121.11) 134.27,121.35 153.13,140.21 arc(153.38,140.38) 153.67,140.44 160.79,140.44 arc(161.02,140.46) 161.23,140.52 161.49,140.63 arc(161.55,140.65) 161.61,140.66 163.26,140.66
FC15_TDN0: length 130.6
  TOP w0.147: U1.AT66 165,141.84 arc(164.68,141.97) v4(164.55,142.29)
  SIG5 w0.112: 163.18,141.04 163.21,141.04 163.3,140.95 163.75,140.95 arc(163.8,140.96) 163.84,140.99 163.89,141.03 arc(163.92,141.07) 163.92,141.12 163.92,141.62 arc(164.02,141.85) 164.25,141.94 164.42,141.94 arc(164.51,141.98) 164.55,142.07 v4(164.55,142.29)
  SIG5 w0.16: 163.18,141.04 161.49,141.04 arc(161.29,141) 161.11,140.88 161.09,140.87 153.72,140.87 arc(153.28,140.78) 152.91,140.53 134,121.62 arc(133.75,121.25) 133.67,120.81 133.67,110.8 arc(133.61,110.51) 133.44,110.26 113.95,90.77 arc(113.79,90.52) 113.73,90.23 113.73,78.9 arc(113.7,78.75) 113.62,78.63 104.81,69.82 arc(104.64,69.58) 104.58,69.28 104.58,67.12 arc(104.53,66.82) 104.36,66.58 97.42,59.63 arc(97.17,59.46) 96.88,59.41 87.75,59.41 arc(87.46,59.35) 87.21,59.18 87.16,59.13 87.12,59.08 arc(86.87,58.92) 86.58,58.86 85.69,58.86 arc(85.49,58.78) 85.41,58.58 85.41,58.32 arc(85.44,58.13) 85.55,57.97 YJ23.D34
FC15_TDN1: length 134.8
  TOP w0.147: U1.AR64 166.55,141.34 v4(166.55,141.39)
  SIG4 w0.112: v4(166.55,141.39) 166.55,141.61 arc(166.51,141.7) 166.42,141.74 166.25,141.74 arc(166.16,141.7) 166.12,141.61 166.12,141.15 arc(166.09,141.03) 166.02,140.92 165.94,140.84 arc(165.84,140.77) 165.71,140.75 163.35,140.75 163.26,140.66 163.23,140.66
  SIG4 w0.16: 163.23,140.66 162.55,140.66 arc(162.5,140.65) 162.46,140.64 162.21,140.54 arc(162.01,140.48) 161.79,140.46 153.67,140.46 arc(153.38,140.4) 153.13,140.24 134.27,121.38 arc(134.11,121.13) 134.05,120.84 134.05,120.84 134.05,110.17 arc(133.99,109.88) 133.83,109.63 114.33,90.14 arc(114.17,89.89) 114.11,89.6 114.11,78.9 arc(114.05,78.61) 113.89,78.36 107.35,71.82 arc(107.18,71.58) 107.12,71.28 107.12,69.27 arc(107.07,68.98) 106.9,68.73 100.65,62.48 99.94,61.76 99.94,61.76 99.58,61.4 99.58,61.1 99.17,60.69 98.86,60.69 98.5,60.33 98.5,59.99 98.11,59.61 97.78,59.61 97.42,59.25 arc(97.17,59.08) 96.88,59.03 85.35,59.03 arc(85.21,59) 85.08,58.91 85.03,58.86 arc(84.96,58.76) 84.92,58.66 arc(84.91,58.61) 84.91,58.57 84.91,58.08 arc(84.86,57.86) 84.74,57.67 84.3,57.24 arc(84.15,57.01) 84.1,56.75 YJ23.D36
FC15_TDN2: length 141.3
  TOP w0.147: v4(168.57,142.29) 168.66,142.29 arc(168.77,142.27) 168.86,142.21 168.92,142.15 arc(169.02,142.01) U1.AT62
  SIG4 w0.112: v4(168.57,142.29) 168.57,142.06 arc(168.54,141.97) 168.45,141.94 168.29,141.94 arc(168.06,141.84) 167.96,141.61 167.96,139.18 167.96,139.18 arc(167.95,139.13) 167.93,139.09 167.84,139.01 arc(167.8,138.99) 167.76,138.98 163.36,138.98 163.26,139.07
  SIG4 w0.16: YJ23.D2 83.15,53.97 arc(83.04,54.13) 83.01,54.32 83.01,54.56 arc(83.1,54.77) 83.31,54.86 84.18,54.86 arc(84.47,54.92) 84.72,55.08 84.76,55.13 84.81,55.18 arc(85.06,55.35) 85.35,55.41 97.42,55.41 arc(97.57,55.44) 97.69,55.52 108.16,65.98 arc(108.24,66.11) 108.27,66.25 108.27,66.86 arc(108.35,67.3) 108.6,67.67 110.57,69.64 arc(110.94,69.89) 111.38,69.97 111.99,69.97 arc(112.14,70) 112.26,70.09 116.03,73.86 arc(116.11,73.98) 116.14,74.13 116.14,89.09 arc(116.23,89.53) 116.48,89.9 135.71,109.14 arc(135.8,109.26) 135.83,109.41 135.83,120.05 arc(135.91,120.49) 136.16,120.86 153.39,138.09 arc(153.76,138.34) 154.2,138.43 161.73,138.43 arc(161.88,138.46) 162,138.54 162.22,138.76 arc(162.57,138.99) 162.97,139.07 163.26,139.07
FC15_TDN3: length 132.9
  TOP w0.147: v4(165.55,139.39) 165.55,139.34 U1.AN65
  SIG5 w0.112: 163.89,139.29 163.92,139.29 164.01,139.39 164.39,139.39 arc(164.58,139.42) 164.75,139.54 164.81,139.59 arc(164.97,139.7) 165.17,139.74 165.42,139.74 arc(165.51,139.71) 165.55,139.62 v4(165.55,139.39)
  SIG5 w0.16: YJ23.D6 86.5,52.81 arc(86.54,53.02) 86.66,53.19 87.14,53.67 arc(87.26,53.86) 87.31,54.08 87.31,54.57 arc(87.34,54.72) 87.43,54.86 87.46,54.89 87.48,54.91 arc(87.61,55) 87.75,55.03 97.29,55.03 arc(97.73,55.11) 98.1,55.36 100.21,57.47 100.42,57.47 100.96,58.01 100.96,58.22 101.5,58.76 101.72,58.76 102.25,59.3 102.25,59.52 102.79,60.06 103.01,60.06 103.55,60.59 103.55,60.81 116.19,73.45 arc(116.44,73.82) 116.52,74.26 116.52,89.22 arc(116.55,89.36) 116.63,89.49 135.87,108.72 arc(136.12,109.1) 136.21,109.53 136.21,120.03 arc(136.27,120.32) 136.43,120.57 153.64,137.77 arc(153.88,137.94) 154.18,138 160.61,138 arc(161.04,138.08) 161.41,138.33 162.27,139.18 arc(162.39,139.27) 162.54,139.29 163.89,139.29
FC15_TDP0: length 130.6
  TOP w0.147: v4(164.55,141.39) 164.55,141.34 U1.AR66
  SIG5 w0.112: v4(164.55,141.39) 164.55,141.62 arc(164.51,141.71) 164.42,141.74 164.25,141.74 arc(164.16,141.71) 164.12,141.62 164.12,141.12 arc(164.1,141) 164.03,140.89 163.98,140.85 arc(163.87,140.78) 163.75,140.75 163.3,140.75 163.21,140.66 163.18,140.66
  SIG5 w0.16: YJ23.D33 86.5,56.88 arc(86.53,57.02) 86.61,57.14 87.14,57.67 arc(87.26,57.86) 87.31,58.08 87.31,58.57 arc(87.34,58.72) 87.43,58.86 87.46,58.89 87.48,58.91 arc(87.61,59) 87.75,59.03 96.88,59.03 arc(97.31,59.11) 97.68,59.36 99.97,61.64 100.18,61.64 100.72,62.18 100.72,62.4 101.26,62.94 101.48,62.94 102.02,63.48 102.02,63.69 102.56,64.23 102.77,64.23 103.31,64.77 103.31,64.99 104.63,66.31 arc(104.88,66.68) 104.97,67.12 104.97,69.28 arc(104.99,69.43) 105.08,69.55 107.28,71.75 113.89,78.36 arc(114.05,78.61) 114.11,78.9 114.11,90.23 arc(114.14,90.38) 114.22,90.5 133.71,109.99 arc(133.96,110.37) 134.05,110.8 134.05,120.81 134.05,120.81 arc(134.11,121.11) 134.27,121.35 153.18,140.26 arc(153.43,140.43) 153.72,140.48 161.13,140.48 arc(161.24,140.51) 161.34,140.57 161.38,140.61 arc(161.43,140.65) 161.49,140.66 163.18,140.66
FC15_TDP1: length 134.9
  TOP w0.147: v4(166.55,142.29) 166.66,142.29 arc(166.77,142.27) 166.86,142.21 166.92,142.15 arc(167.02,142.01) U1.AT64
  SIG4 w0.112: v4(166.55,142.29) 166.55,142.06 arc(166.51,141.97) 166.42,141.94 166.25,141.94 arc(166.02,141.84) 165.92,141.61 165.92,141.15 arc(165.91,141.1) 165.89,141.06 165.8,140.98 arc(165.76,140.95) 165.71,140.95 163.35,140.95 163.26,141.04 163.23,141.04
  SIG4 w0.16: YJ23.D37 83.15,57.97 arc(83.04,58.13) 83.01,58.32 83.01,58.55 arc(83.1,58.77) 83.32,58.86 84.12,58.86 arc(84.46,58.93) 84.76,59.13 84.81,59.18 arc(85.06,59.35) 85.35,59.41 96.88,59.41 arc(97.03,59.44) 97.15,59.52 106.63,69 arc(106.71,69.12) 106.74,69.27 106.74,71.28 arc(106.83,71.72) 107.08,72.09 113.62,78.63 arc(113.7,78.75) 113.73,78.9 113.73,89.6 arc(113.82,90.04) 114.06,90.41 133.56,109.9 arc(133.64,110.02) 133.67,110.17 133.67,120.84 arc(133.75,121.28) 134,121.65 152.86,140.51 arc(153.23,140.75) 153.67,140.84 161.79,140.84 arc(161.93,140.85) 162.07,140.89 162.32,140.99 arc(162.43,141.03) 162.55,141.04 163.23,141.04
FC15_TDP2: length 141.3
  TOP w0.147: v4(168.57,141.39) 168.57,141.32 U1.AR62
  SIG4 w0.112: v4(168.57,141.39) 168.57,141.61 arc(168.54,141.7) 168.45,141.74 168.29,141.74 arc(168.2,141.7) 168.16,141.61 168.16,139.18 arc(168.14,139.06) 168.07,138.95 167.98,138.87 arc(167.88,138.8) 167.76,138.78 163.35,138.78 163.26,138.69
  SIG4 w0.16: YJ23.D3 84.1,52.81 arc(84.14,53.02) 84.26,53.19 84.74,53.67 arc(84.86,53.86) 84.91,54.08 84.91,54.57 arc(84.94,54.72) 85.03,54.86 85.06,54.89 85.08,54.91 arc(85.21,55) 85.35,55.03 97.42,55.03 arc(97.71,55.08) 97.96,55.25 98.88,56.17 99.21,56.17 99.6,56.55 99.6,56.88 99.96,57.24 100.29,57.24 100.68,57.63 100.68,57.96 108.43,65.71 arc(108.59,65.96) 108.65,66.25 108.65,66.86 arc(108.71,67.16) 108.87,67.4 110.84,69.37 arc(111.09,69.54) 111.38,69.59 111.99,69.59 arc(112.28,69.65) 112.53,69.82 116.3,73.59 arc(116.46,73.83) 116.52,74.13 116.52,89.09 arc(116.58,89.38) 116.75,89.63 135.98,108.87 arc(136.15,109.11) 136.21,109.41 136.21,120.05 arc(136.27,120.34) 136.43,120.59 153.66,137.82 arc(153.91,137.99) 154.2,138.05 161.73,138.05 arc(162.02,138.1) 162.27,138.27 162.49,138.49 arc(162.71,138.64) 162.97,138.69 163.26,138.69
FC15_TDP3: length 132.9
  TOP w0.147: U1.AP65 166,139.84 arc(165.68,139.97) v4(165.55,140.29)
  SIG5 w0.112: v4(165.55,140.29) 165.55,140.07 arc(165.51,139.98) 165.42,139.94 165.17,139.94 arc(164.9,139.89) 164.67,139.73 164.61,139.67 arc(164.51,139.61) 164.39,139.58 164.01,139.58 163.92,139.68 163.89,139.68
  SIG5 w0.16: 163.89,139.68 162.54,139.68 arc(162.24,139.62) 162,139.45 161.15,138.6 arc(160.9,138.43) 160.61,138.38 154.18,138.38 arc(153.74,138.29) 153.37,138.04 136.16,120.84 arc(135.91,120.46) 135.83,120.03 135.83,109.53 arc(135.77,109.24) 135.6,108.99 116.37,89.76 arc(116.2,89.51) 116.14,89.22 116.14,74.26 arc(116.08,73.97) 115.92,73.72 97.83,55.63 arc(97.58,55.46) 97.29,55.41 87.75,55.41 arc(87.46,55.35) 87.21,55.18 87.16,55.13 87.12,55.08 arc(86.87,54.92) 86.58,54.86 85.71,54.86 arc(85.5,54.77) 85.41,54.55 85.41,54.32 arc(85.44,54.13) 85.55,53.97 YJ23.D5
FC16_17_PVDD0P8: length 5.1
  TOP w0.229: v1(181.55,140.34) 182.05,139.84 U1.AP49 ; U1.AL49 v1(181.55,136.34)
  TOP w0.508: 155.61,133.83 C2801.1 154.88,134.62
  BOTTOM w0.13: v1(155.51,135) v2(155.51,135.76)
  BOTTOM w0.381: v1(181.55,136.34) 182.03,136.82 C3334.1 ; v1(181.55,140.34) 181.06,140.83 C2753.1
  vias: v1(154.62,135)
FC16_31_PVDD1P8: length 15.5
  TOP w0.229: U1.AF49 v1(181.55,131.34) ; U1.Y40 v1(190.55,125.34) ; U1.AC49 v1(181.55,128.34) ; U1.Y46 v1(184.55,125.34) ; U1.W36 v1(194.55,124.34) ; U1.Y43 v1(187.55,125.34) ; U1.AJ49 v1(181.55,134.34) ; U1.AM49 v1(181.55,137.34)
  TOP w0.381: 159.45,134.62 C2735.1 160.19,133.83 ; 159.7,136.04 L432.1 ; L432.1 160.3,136.67 ; L432.1 159.11,136.67
  BOTTOM w0.13: v1(159.96,135) v2(159.96,135.76)
  BOTTOM w0.381: v1(190.55,125.34) 191.03,125.83 C3111.1 ; C3156.1 181.55,134.39 v1(181.55,134.34) ; C2993.1 181.06,128.83 v1(181.55,128.34) ; C3069.1 181.55,131.36 v1(181.55,131.34) ; v1(194.55,124.34) 195.03,124.83 C3024.1 ; v1(187.55,125.34) 187.07,125.82 C2685.1 ; C2705.1 181.06,137.83 v1(181.55,137.34) ; v1(184.55,125.34) 185.03,125.83 C2769.1
  vias: v1(159.07,135)
FC16_RDN0: length 130.3
  TOP w0.147: U1.AN54 176.55,138.34 v4(176.55,138.29)
  SIG8 w0.112: 163.28,136.02 163.31,136.02 163.4,135.92 175.71,135.92 arc(175.76,135.93) 175.8,135.96 175.89,136.05 arc(175.91,136.09) 175.92,136.14 175.92,137.64 arc(176.01,137.85) 176.22,137.94 176.45,137.94 arc(176.52,137.97) 176.55,138.04 v4(176.55,138.29)
  SIG8 w0.16: YJ26.D21 111.3,56.61 arc(111.22,57) 111,57.34 110.74,57.59 arc(110.57,57.85) 110.51,58.15 110.51,58.42 arc(110.5,58.53) 110.47,58.63 arc(110.42,58.73) 110.35,58.82 110.26,58.9 arc(110.14,58.98) 109.99,59.01 108.32,59.01 arc(107.88,59.1) 107.51,59.35 106.7,60.16 arc(106.45,60.53) 106.36,60.97 106.36,71.09 arc(106.42,71.38) 106.59,71.63 111.47,76.51 arc(111.64,76.76) 111.7,77.05 111.7,80.83 arc(111.78,81.27) 112.03,81.64 113.51,83.12 arc(113.88,83.37) 114.32,83.46 115.34,83.46 arc(115.63,83.52) 115.88,83.68 115.92,83.72 arc(116.08,83.97) 116.14,84.26 116.14,86.04 arc(116.2,86.33) 116.37,86.58 135.6,105.82 arc(135.77,106.07) 135.83,106.36 135.83,119.99 arc(135.91,120.43) 136.16,120.8 151.29,135.93 arc(151.66,136.18) 152.1,136.27 160.44,136.27 arc(160.75,136.21) 161.01,136.03 arc(161.03,136.02) 161.05,136.02 163.28,136.02
FC16_RDN1: length 134.9
  TOP w0.147: U1.AM58 172.95,137.84 arc(172.86,137.82) 172.78,137.77 172.65,137.64 arc(172.58,137.53) v4(172.55,137.39)
  SIG9 w0.112: 164,138.67 164.05,138.67 arc(164.09,138.68) 164.13,138.71 164.14,138.72 arc(164.19,138.75) 164.25,138.77 164.98,138.77 165.09,138.66 165.95,138.66 166.06,138.77 166.96,138.77 167.09,138.63 168.08,138.63 168.25,138.79 171.49,138.79 arc(171.8,138.66) 171.93,138.35 171.93,138.04 arc(172.01,137.83) 172.22,137.74 172.42,137.74 arc(172.46,137.73) 172.51,137.71 172.51,137.7 arc(172.54,137.66) 172.55,137.61 v4(172.55,137.39)
  SIG9 w0.16: 164,138.67 160.94,138.67 arc(160.86,138.67) 160.79,138.64 160.22,138.4 arc(160.19,138.4) 160.15,138.39 151.68,138.39 arc(151.39,138.33) 151.14,138.17 134.27,121.3 arc(134.11,121.06) 134.05,120.76 134.05,120.76 134.05,107.07 arc(133.99,106.78) 133.83,106.53 123.76,96.47 116.7,89.41 arc(116.45,89.24) 116.16,89.18 114.07,89.18 arc(113.78,89.12) 113.54,88.96 112.25,87.67 arc(112.09,87.43) 112.03,87.13 112.03,76.84 arc(111.97,76.55) 111.8,76.3 105.62,70.12 arc(105.46,69.87) 105.4,69.58 105.4,60.84 arc(105.46,60.55) 105.62,60.3 105.85,60.07 106.17,60.07 106.5,59.74 106.5,59.42 106.82,59.1 107.15,59.1 107.51,58.74 107.51,58.41 107.87,58.05 108.21,58.05 108.57,57.69 108.57,57.36 108.9,57.02 109.23,57.02 109.59,56.66 109.59,56.33 110.31,55.62 arc(110.55,55.45) 110.84,55.39 112.39,55.39 arc(112.68,55.34) 112.93,55.17 113.02,55.08 arc(113.26,54.92) 113.56,54.86 114.46,54.86 arc(114.7,54.76) 114.8,54.52 114.8,54.34 arc(114.76,54.14) 114.65,53.97 YJ26.D14
FC16_RDN2: length 136.9
  TOP w0.147: v4(174.55,138.29) 174.55,138.34 U1.AN56
  SIG8 w0.112: 163.26,138.04 163.28,138.04 163.38,137.95 168.68,137.95 arc(168.72,137.95) 168.76,137.98 168.92,138.13 arc(168.94,138.17) 168.95,138.22 168.95,138.47 arc(168.98,138.6) 169.05,138.7 169.17,138.83 arc(169.28,138.9) 169.4,138.92 173.7,138.92 arc(173.83,138.9) 173.93,138.83 174.02,138.74 arc(174.09,138.63) 174.12,138.51 174.12,138.04 arc(174.15,137.97) 174.22,137.94 174.45,137.94 arc(174.52,137.97) 174.55,138.04 v4(174.55,138.29)
  SIG8 w0.16: YJ26.D18 111.3,52.68 arc(111.23,53.01) 111.05,53.29 110.71,53.63 arc(110.56,53.84) 110.51,54.1 110.51,54.48 arc(110.51,54.54) 110.49,54.61 arc(110.45,54.7) 110.39,54.77 110.35,54.81 110.35,54.82 110.26,54.9 arc(110.14,54.98) 109.99,55.01 108.74,55.01 arc(108.3,55.1) 107.93,55.35 104.59,58.69 arc(104.34,59.06) 104.25,59.5 104.25,71.74 arc(104.34,72.18) 104.59,72.55 109.17,77.13 arc(109.25,77.26) 109.28,77.4 109.28,84.74 arc(109.37,85.18) 109.62,85.55 113.3,89.23 arc(113.67,89.48) 114.11,89.56 115.98,89.56 arc(116.28,89.62) 116.52,89.79 133.44,106.71 arc(133.61,106.96) 133.67,107.25 133.67,120.81 arc(133.75,121.24) 134,121.61 150.83,138.44 arc(151.2,138.69) 151.64,138.77 160.97,138.77 arc(161.26,138.72) 161.51,138.55 161.8,138.26 arc(162.05,138.1) 162.34,138.04 163.26,138.04
FC16_RDN3: length 122.9
  TOP w0.147: U1.AM60 170.95,137.84 arc(170.86,137.82) 170.78,137.77 170.65,137.64 arc(170.58,137.53) v4(170.55,137.39)
  SIG9 w0.112: v4(170.55,137.39) 170.35,137.59 arc(170.15,137.71) 169.92,137.72 arc(169.78,137.7) 169.63,137.69 169.03,137.69 168.97,137.75 163.22,137.75 163.16,137.68
  SIG9 w0.16: YJ26.D25 114.65,57.97 arc(114.76,58.14) 114.8,58.34 114.8,58.52 arc(114.7,58.76) 114.46,58.86 113.42,58.86 arc(113.25,58.89) 113.11,58.99 112.93,59.17 arc(112.68,59.34) 112.39,59.39 110.91,59.39 arc(110.62,59.45) 110.37,59.62 109.64,60.34 109.64,60.68 109.26,61.06 108.92,61.06 108.59,61.4 108.59,61.72 108.2,62.1 107.89,62.1 107.7,62.28 arc(107.54,62.53) 107.48,62.82 107.48,63.33 107.71,63.56 107.71,64.12 107.48,64.35 107.48,68.24 arc(107.54,68.53) 107.7,68.78 108.42,69.49 108.75,69.49 109.14,69.87 109.14,70.21 113.89,74.96 arc(114.05,75.21) 114.11,75.5 114.11,82.23 arc(114.17,82.52) 114.33,82.77 114.42,82.86 arc(114.66,83.02) 114.96,83.08 115.59,83.08 arc(115.89,83.14) 116.13,83.3 116.3,83.47 arc(116.46,83.71) 116.52,84.01 116.52,85.86 arc(116.58,86.16) 116.75,86.4 135.98,105.64 arc(136.15,105.89) 136.21,106.18 136.21,119.98 arc(136.27,120.27) 136.43,120.52 151.58,135.66 arc(151.83,135.83) 152.12,135.89 159.23,135.89 arc(159.51,135.9) 159.79,135.95 arc(160.42,136.2) 160.96,136.6 161.81,137.46 arc(162.06,137.62) 162.35,137.68 163.16,137.68
FC16_RDP0: length 130.3
  TOP w0.147: v4(176.55,137.39) 176.55,137.48 arc(176.57,137.56) 176.61,137.63 176.68,137.71 arc(176.84,137.81) 177.01,137.84 U1.AM54
  SIG8 w0.112: v4(176.55,137.39) 176.55,137.64 arc(176.52,137.71) 176.45,137.74 176.22,137.74 arc(176.15,137.71) 176.12,137.64 176.12,136.14 arc(176.09,136.01) 176.02,135.91 175.94,135.82 arc(175.83,135.75) 175.71,135.73 163.4,135.73 163.31,135.64 163.28,135.64
  SIG8 w0.16: YJ26.D22 112.25,57.97 arc(112.38,58.17) 112.43,58.39 112.43,58.43 arc(112.4,58.57) 112.32,58.69 arc(112.13,58.82) 111.9,58.86 111.02,58.86 arc(110.99,58.86) 110.95,58.87 arc(110.82,58.91) 110.71,58.99 110.53,59.17 arc(110.28,59.34) 109.99,59.39 108.32,59.39 arc(108.03,59.45) 107.78,59.62 106.97,60.43 arc(106.8,60.68) 106.74,60.97 106.74,71.09 arc(106.77,71.23) 106.86,71.36 107.22,71.72 107.53,71.72 107.94,72.13 107.94,72.44 108.31,72.82 108.65,72.82 109.03,73.2 109.03,73.53 109.39,73.89 109.73,73.89 110.11,74.28 110.11,74.61 111.74,76.24 arc(111.99,76.61) 112.08,77.05 112.08,77.7 112.31,77.92 112.31,78.48 112.08,78.71 112.08,80.83 arc(112.14,81.13) 112.3,81.37 113.78,82.86 arc(114.03,83.02) 114.32,83.08 115.34,83.08 arc(115.78,83.17) 116.15,83.41 116.19,83.45 arc(116.44,83.82) 116.52,84.26 116.52,86.04 arc(116.55,86.19) 116.63,86.31 135.87,105.55 arc(136.12,105.92) 136.21,106.36 136.21,119.99 arc(136.27,120.29) 136.43,120.53 151.56,135.66 arc(151.81,135.83) 152.1,135.89 160.44,135.89 arc(160.6,135.85) 160.74,135.76 160.74,135.76 arc(160.88,135.67) 161.05,135.64 163.28,135.64
