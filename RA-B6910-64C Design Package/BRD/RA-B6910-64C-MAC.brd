# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ZQSFP+2_3.3V_EN: length 20.7
  TOP w0.229: v1(35.24,125.09) 35.66,125.51 U131.2
  TOP w0.254: R3538.2 v2(35.5,137.44) v1(34.73,137.44) 34.51,137.44 33.97,136.9 Q48.3
  SIG9 w0.305: v1(34.73,137.44) 32.45,135.15 32.45,127.89 v1(35.24,125.09)
  BOTTOM w0.13: v1(34.73,137.44) v2(35.5,137.44)
ZQSFP+2_3.3V_PG: length 22.1
  TOP w0.229: v1(35.24,124.2) 36.16,125.12 U131.3
  TOP w0.381: R3570.2 v1(34.73,136.01) 34.35,135.63 31.94,135.63 31.59,135.28 R3572.1
  SIG9 w0.305: v1(35.24,124.2) 36,124.97 36,125.22 33.21,128.01 33.21,134.49 v1(34.73,136.01)
  BOTTOM w0.13: v1(34.73,136.01) v2(33.87,136.01)
ZQSFP+3_3.3V: length 600.9
  TOP w0.381: 254.19,90.04 C2473.2 ; C2473.2 254.85,89.3 ; C2473.2 254.85,90.7 ; 277.94,91.06 277.28,91.72 C2506.1 C2502.1 ; C3732.1 397.83,149.86 ; C3732.1 C3730.1 ; C3732.1 397.19,150.49 ; R2814.1 v1(273.75,79.5) ; 252.54,90.04 C2510.2 ; C2510.2 251.88,90.78 ; C2510.2 251.88,89.38 ; v1(261.07,88.14) 261.07,88.49 260.82,88.75 R2815.2 ; C2505.2 268.06,89.3 ; C2505.2 267.4,90.04 ; C2505.2 268.06,90.7 ; C3730.1 397.93,148.74 ; C3730.1 C3731.1 ; R2813.1 v1(260.41,79.5) ; R175.1 v1(424.24,122.35) ; 280.61,90.04 C2467.2 ; C2467.2 281.39,90.78 ; C2467.2 281.39,89.3 ; C2446.2 220.89,90.78 ; C2446.2 220.89,89.25 ; C2446.2 v3(222.31,90.04) C2435.2 ; C2403.2 235.04,91.72 ; C2403.2 235.04,93.11 ; C2403.2 234.38,92.45 ; R163.1 v1(410.2,125.7) ; R178.1 v1(424.24,125.7) ; R172.1 v1(424.24,119) ; C2478.2 265.09,90.78 ; C2478.2 265.75,90.04 ; C2478.2 265.09,89.38 ; R177.1 v1(424.24,124.58) ; C2469.2 254.98,95.27 ; C2469.2 254.32,94.61 ; C2469.2 254.98,93.88 ; R167.1 v1(410.2,121.23) ; C2410.2 234.1,90.78 ; C2410.2 234.76,90.04 ; C2410.2 234.1,89.38 ; C2436.1 254.95,95.63 ; 208.6,90.04 C2406.2 ; C2406.2 207.68,89.3 ; C2406.2 207.68,90.78 ; 279.08,90.04 C2499.2 ; C2499.2 278.3,90.78 ; C2499.2 278.3,89.3 ; C2439.2 210.66,90.78 ; C2439.2 209.87,90.04 ; C2439.2 210.66,89.3 ; R2773.1 v1(229.55,79.5) ; C2435.2 223.86,89.18 ; C2435.2 223.86,90.78 ; R166.1 v1(410.2,122.35) ; v1(216.22,79.5) R2777.1 R2750.1 ; C2468.1 281.14,91.08 ; R168.1 v1(410.2,120.11) ; C3731.1 397.78,147.5 ; C3731.1 397.19,146.81 ; R176.1 v1(424.24,123.47) ; v3(279.72,90.55) 279.95,90.78 C2470.1 ; C2404.1 251.9,95.63 ; R174.1 v1(424.24,121.23) ; R169.1 v1(410.2,119) ; C2440.1 253.94,95.63 ; C2411.1 252.92,95.63 ; R165.1 v1(410.2,123.47) ; R164.1 v1(410.2,124.58) ; C2511.1 220.66,91.95 ; R171.1 v1(424.24,117.88) ; R170.1 v1(410.2,117.88) ; R173.1 v1(424.24,120.11)
  TOP w0.508: R3604.2 v1(393.51,130.93)
  SIG4 w0.508: v1(37.4,156.59) 39.69,156.59 40.96,157.86 40.96,162.18 40.45,162.68 40.45,167.76 39.1,169.11 35.04,169.11 34.1,170.05 33.21,170.05 32.45,170.81 32.45,175.38 36,178.94 42.48,178.94 48.51,184.97 50.17,184.97 51.5,186.31 51.5,187.96 54.42,190.88 55.05,190.88 56.63,192.45 56.63,193.12 58.38,194.87 59.33,194.87 62.15,197.69 63.55,197.69 66.55,200.68 71.46,200.68 73.6,202.82 93.92,202.82 95.39,201.34 124.7,201.34 128.61,205.25 148.32,205.25 153.35,210.28 153.35,211.2 163.72,221.56 376.67,221.56 381.44,216.79 381.44,208.28 386.79,202.93 386.79,189.72 388.81,187.7 388.81,178.53 391.88,175.46 391.88,164.38 401,155.26 v3(401,153.79)
  SIG5 w0.381: v1(398.34,146.94) 399.22,146.05 404.3,146.05 404.94,145.41 404.94,132.97 402.91,130.93 v1(393.51,130.93)
  BOTTOM w0.381: v1(271.21,80.64) 271.84,80.01 271.84,79.09 R2795.1 ; R168.1 v1(410.2,120.11) ; C2479.1 264.86,89.53 ; R175.1 v1(424.24,122.35) ; R2758.1 227.42,78.84 226.63,78.05 v1(226.63,77.85) ; R170.1 v1(410.2,117.88) ; 268.06,89.3 C2505.2 ; C2505.2 267.27,90.04 ; C2505.2 268.06,90.78 ; R166.1 v1(410.2,122.35) ; R2778.2 R2749.2 v1(215.2,85.34) ; C3724.2 397.19,133.12 v1(397.68,133.6) ; R171.1 v1(424.24,117.88) ; 223.86,89.3 C2435.2 ; C2435.2 223.86,90.78 ; C2435.2 223.08,90.04 ; R163.1 v1(410.2,125.7) ; R2793.2 v1(272.73,85.34) ; R164.1 v1(410.2,124.58) ; C2447.1 220.66,90.55 ; v1(229.55,85.34) R2774.2 R2757.2 ; R178.1 v1(424.24,125.7) ; C2439.2 209.87,90.04 ; C2439.2 210.66,89.3 ; C2439.2 210.66,90.78 ; R173.1 v1(424.24,120.11) ; R2816.2 274.76,84.83 v1(275.27,85.34) ; R2796.1 257.72,78.84 v1(257.62,78.74) ; R174.1 v1(424.24,121.23) ; C2511.1 220.66,91.95 ; R169.1 v1(410.2,119) ; R165.1 v1(410.2,123.47) ; R177.1 v1(424.24,124.58) ; v1(37.4,156.59) R3288.1 ; R176.1 v1(424.24,123.47) ; R167.1 v1(410.2,121.23) ; R172.1 v1(424.24,119) ; C2474.1 264.86,90.55 ; R2794.2 v1(259.4,85.34) ; C2443.1 220.66,89.53
  BOTTOM w0.508: 202.25,90.8 C2415.1 ; 202.37,89.79 C2407.1
  vias: v1(253.17,94.87) v1(253.17,93.98) v1(253.17,89.41) v1(253.12,88.52) v1(288.48,88.39) v1(288.48,87.5) v1(398.46,150.24) v2(207.71,90.68) v2(251.9,89.41) v2(404.94,145.92) v3(209.11,82.67) v3(209.11,81.4) v3(209.23,90.68) v3(209.23,89.41) v3(222.31,88.77) v3(222.31,82.67) v3(222.31,81.4) v3(235.65,90.55) v3(235.65,89.28) v3(235.65,82.62) v3(235.65,81.38) v3(253.3,82.62) v3(253.3,81.38) v3(266.51,90.04) v3(266.51,88.77) v3(266.51,82.67) v3(266.51,81.4) v3(279.72,89.28) v3(279.72,82.67) v3(279.72,81.4) v3(399.73,153.79) v3(399.73,152.27) v3(399.73,151) v3(399.73,149.73) v3(399.73,148.46) v3(399.73,147.19) v3(401,152.27) v3(401,151) v3(401,149.73) v3(401,148.46) v3(401,147.19) v3(402.27,152.27) v3(402.27,151) v3(402.4,153.79) v3(402.4,149.73) v3(402.4,148.46) v3(402.4,147.19) v3(403.67,153.79) v3(403.67,152.4) v3(403.67,151.13) v3(403.67,149.73) v3(403.67,148.46) v3(403.67,147.19) v3(404.94,153.79) v3(404.94,152.27) v3(404.94,151) v3(404.94,149.73) v3(404.94,148.46) v3(404.94,147.19)
ZQSFP+3_3.3V_EN: length 20
  TOP w0.229: v1(388.94,133.6) 388.52,134.01 U133.2
  TOP w0.254: Q55.3 377.13,132.33 376.59,132.86 R3562.1 R3556.2 v1(377.25,135.13)
  SIG9 w0.381: v1(388.94,133.6) 388.05,132.71 381.7,132.71 379.29,135.13 v1(377.25,135.13)
  BOTTOM w0.13: v1(377.25,135.13) v2(376.49,135.13)
ZQSFP+3_3.3V_PG: length 22.3
  TOP w0.229: U133.3 388.91,134.51 v1(389.83,133.6)
  TOP w0.381: R3593.1 378.75,129.94 378.14,130.55 v1(378.14,133.09) R3592.2
  SIG9 w0.381: v1(389.83,133.6) 389.83,132.97 388.18,131.32 379.01,131.32 378.14,132.18 v1(378.14,133.09)
  BOTTOM w0.13: v1(378.14,133.09) v2(377.38,133.09)
ZQSFP+4_3.3V: length 636.6
  TOP w0.381: C2567.2 318.71,90.04 ; C2567.2 319.49,90.78 ; C2567.2 319.49,89.3 ; 308.83,90.9 C2537.2 ; C2537.2 308.83,89.43 ; C2537.2 308.04,90.17 ; R419.1 v1(410.2,112.01) ; C2628.1 357.06,88.01 357.57,88.52 ; R2875.2 358.84,80.77 v1(358.69,80.62) 358.69,80.13 358.84,79.98 R2895.2 ; R427.1 v1(424.24,112.01) ; C2563.2 317.31,90.04 ; C2563.2 316.52,89.3 ; C2563.2 316.52,90.78 ; 365.98,85.44 C2633.2 ; C2633.2 365.19,84.71 ; C2633.2 365.98,83.97 ; C2638.2 385.74,98.02 ; C2638.2 386.78,97.28 v1(386.91,97.41) ; C2638.2 385.74,96.37 ; C2599.2 385.74,89.76 ; C2599.2 385.74,88.41 ; C2599.2 386.4,89.15 ; R422.1 v1(410.2,107.54) ; 378.02,82.17 C2603.2 ; C2603.2 378.8,82.9 ; C2603.2 378.8,81.43 ; 292.04,88.9 C2568.2 ; C2568.2 292.82,88.16 ; C2568.2 292.82,89.63 ; R420.1 v1(410.2,110.89) ; R421.1 v1(410.2,108.66) ; C2630.1 356.93,86.99 357.06,86.87 ; 329.73,90.78 C2541.2 ; C2541.2 329.73,89.3 ; C2541.2 330.52,90.04 ; R418.1 v1(410.2,113.13) ; C2573.1 289.12,89.15 ; C2572.2 332.83,89.3 ; C2572.2 332.83,90.78 ; C2572.2 332.04,90.04 ; R435.1 v1(410.2,109.78) ; R424.1 v1(410.2,105.31) ; R437.1 v1(424.24,108.66) ; 397.52,123.49 C3720.1 396.94,122.93 ; R428.1 v1(424.24,113.13) ; R2853.1 v1(311.34,82.93) ; C3719.1 397.68,124.74 ; R3283.1 36.59,158.98 v1(37.4,158.98) ; R436.1 v1(424.24,107.54) ; C2595.2 387.92,89.15 ; C2595.2 388.84,89.76 ; C2595.2 388.84,88.41 ; R439.1 v1(424.24,110.89) ; R438.1 v1(424.24,109.78) ; R426.1 v1(424.24,106.42) ; C2536.1 287.72,89.15 ; R423.1 v1(410.2,106.42) ; R2891.1 v1(369.56,79.4) ; R2854.1 v1(325.18,79.5) ; 397.57,125.85 C3721.1 396.94,126.49 ; R2831.2 R2855.2 v1(309.05,79.5) ; R425.1 v1(424.24,105.31) ; R2830.1 v1(312.36,86.61)
  TOP w0.508: v1(393.13,106.93) R3601.2
  SIG4 w0.508: v3(403.67,125.45) 404.86,126.64 404.86,143.3 406.34,144.78 406.34,154.18 404.94,155.57 401.73,155.57 392.62,164.69 392.62,176.27 390.46,178.43 390.46,189.61 388.3,191.77 388.3,202.69 382.97,208.02 382.97,216.91 377.58,222.3 162.8,222.3 152.34,211.83 152.34,210.31 148.02,205.99 128.31,205.99 124.4,202.08 95.8,202.08 94.17,203.71 87.06,203.71 86.55,204.21 73.6,204.21 72.2,202.82 67.5,202.82 63.11,198.43 61.84,198.43 59.02,195.6 57.34,195.6 41.57,179.83 34.48,179.83 29.78,175.13 29.78,170.94 32.19,168.53 32.19,165.1 33.34,163.95 35.12,163.95 35.75,163.32 35.75,160.63 v1(37.4,158.98)
  SIG5 w0.381: v1(393.13,106.93) 403.03,106.93 404.81,108.71 404.81,124.31 v3(403.67,125.45)
  BOTTOM w0.381: C2542.1 332.8,89.66 ; C2627.2 351.47,92.33 ; C2627.2 352.26,93.06 ; C2627.2 352.26,91.59 ; R418.1 v1(410.2,113.13) ; C2538.1 329.63,89.66 ; R2876.1 R2896.2 375.6,79.35 v1(375.76,79.5) ; R2895.2 358.84,80.13 358.69,80.29 v1(358.69,80.62) 358.84,80.77 R2875.2 ; v1(322.52,80.52) 323.28,79.75 323.28,79.22 R2839.1 ; C2604.1 385.64,89.79 ; C2532.1 329.63,90.68 ; C2564.1 316.29,89.53 ; R437.1 v1(424.24,108.66) ; v3(302.7,81.4) v2(301.31,81.4) ; C2629.2 351.47,90.04 ; C2629.2 352.26,89.3 ; C2629.2 352.26,90.78 ; C2607.2 349.29,91.59 ; C2607.2 350.08,92.33 ; C2607.2 349.29,93.06 ; R2856.2 R2829.2 v1(324.17,85.34) ; C2531.2 332.83,93.19 ; C2531.2 332.83,91.72 ; C2531.2 332.04,92.45 ; C2569.1 316.29,90.55 ; R421.1 v1(410.2,108.66) ; C2567.2 318.71,90.04 ; C2567.2 319.49,90.78 ; C2567.2 319.49,89.3 ; R439.1 v1(424.24,110.89) ; R428.1 v1(424.24,113.13) ; R435.1 v1(410.2,109.78) ; R427.1 v1(424.24,112.01) ; C2639.1 349.03,93.42 349.12,93.34 349.19,93.34 ; 397.57,115.44 396.94,114.81 C3713.2 ; R420.1 v1(410.2,110.89) ; C2596.1 388.81,89.79 ; R419.1 v1(410.2,112.01) ; R436.1 v1(424.24,107.54) ; C2600.1 388.81,88.77 ; C2634.1 385.64,88.77 ; R426.1 v1(424.24,106.42) ; C2608.1 349.69,95.12 350.08,94.74 350.08,93.34 ; R422.1 v1(410.2,107.54) ; R425.1 v1(424.24,105.31) ; R424.1 v1(410.2,105.31) ; R423.1 v1(410.2,106.42) ; R2891.1 v1(369.56,79.4) ; R438.1 v1(424.24,109.78) ; C2574.1 332.8,90.68
  vias: v1(290.39,87.37) v1(290.39,86.48) v1(302.32,88.52) v1(302.32,87.63) v1(349.03,90.42) v1(349.39,80.74) v1(349.69,89.66) v1(350.38,82.8) v1(350.46,92.3) v1(350.99,91.59) v1(351.02,82.17) v1(351.7,91.06) v1(352.29,80.9) v1(358.08,87.75) v1(360.34,88.49) v1(363.69,82.19) v1(364.3,81.53) v1(365.19,83.69) v1(365.82,83.06) v1(375.86,86.48) v1(375.86,85.47) v1(376.87,86.48) v1(376.87,85.47) v1(386.65,89.53) v1(386.65,88.52) v1(386.91,81.53) v1(386.91,80.52) v1(387.52,96.72) v1(387.67,82.04) v1(387.67,81.02) v1(387.79,89.53) v1(387.79,88.52) v2(331.15,91.82) v2(401.13,125.47) v3(302.7,82.67) v3(307.28,90.42) v3(307.28,89.15) v3(318.02,90.04) v3(318.02,88.77) v3(318.02,82.67) v3(318.02,81.4) v3(331.15,90.55) v3(331.15,89.28) v3(331.15,82.67) v3(331.15,81.4) v3(398.59,122.83) v3(398.59,121.59) v3(399.86,124.08) v3(399.86,122.83) v3(399.86,121.59) v3(399.86,120.34) v3(399.86,119.1) v3(399.99,125.45) v3(401.13,124.08) v3(401.13,122.83) v3(401.13,121.59) v3(401.13,120.34) v3(401.13,119.1) v3(402.4,125.45) v3(402.4,124.08) v3(402.4,122.83) v3(402.4,121.59) v3(402.4,120.34) v3(402.4,119.1) v3(403.67,124.08) v3(403.67,122.83) v3(403.67,121.59) v3(403.67,120.34) v3(403.67,119.1)
ZQSFP+4_3.3V_EN: length 20.2
  TOP w0.229: U132.2 388.27,110.01 v1(388.68,109.6)
  TOP w0.254: Q57.3 376.87,108.33 376.34,108.86 R3569.1 R3567.2 v1(377,111.12)
  SIG9 w0.381: v1(377,111.12) 379.03,111.12 381.7,108.46 387.54,108.46 v1(388.68,109.6)
  BOTTOM w0.13: v1(377,111.12) v2(376.24,111.12)
ZQSFP+4_3.3V_PG: length 21.6
  TOP w0.229: U132.3 388.66,110.51 v1(389.57,109.6)
  TOP w0.381: R3588.2 v1(377.89,109.09) 378.14,108.84 378.14,106.3 378.5,105.94 R3589.1
  SIG9 w0.381: v1(389.57,109.6) 389.57,108.96 388.05,107.44 379.54,107.44 v1(377.89,109.09)
  BOTTOM w0.13: v1(377.89,109.09) v2(377.13,109.09)
ZQSFP+_SCL_0: length 57.5
  TOP w0.13: U12.5 12.05,95.89 11.55,96.39 R247.2 11.14,96.77 10.99,96.92 8.83,96.92 8.32,96.42 v1(8.32,96.39)
  SIG1 w0.16: v1(7.81,69.59) 8.19,69.21 8.7,69.21 15.05,62.86 23.46,62.86 YJ21.A11
  SIG9 w0.155: v1(7.81,69.59) 7.81,70.02 6.92,70.91 6.92,75.92 7.63,76.64 7.63,82.37 9.34,84.07 9.34,87.06 10.87,88.59 10.87,94.59 9.64,95.82 8.89,95.82 v1(8.32,96.39)
  BOTTOM w0.13: v1(7.81,69.59) v2(6.92,69.59)
ZQSFP+_SCL_1: length 63.8
  TOP w0.13: v1(8.32,94.16) 8.32,94.18 8.83,94.69 10.99,94.69 11.14,94.54 R249.2 11.75,94.16 11.95,94.36 12.76,94.36 13,94.59 U12.7
  SIG1 w0.16: YJ21.B11 23.96,53.82 23.19,54.6 15.95,54.6 14.56,55.99 14.56,58.53 6.29,66.8 6.29,72.13 4.25,74.17 4.25,75.69 v1(4.76,76.2)
  SIG9 w0.155: v1(4.76,76.2) 5.91,77.34 5.91,81.95 8.41,84.46 8.41,87.44 9.94,88.97 9.94,93.13 9.48,93.6 8.88,93.6 v1(8.32,94.16)
  BOTTOM w0.13: v1(4.76,76.2) v2(5.52,76.2)
ZQSFP+_SCL_2: length 66.6
  TOP w0.13: v1(6.03,84.07) 6.67,84.71 6.67,85.47 6.16,85.98 6.16,89.28 7.05,90.17 7.56,90.17 7.81,90.42 7.81,91.06 8.32,91.56 8.32,91.95 8.83,92.45 10.99,92.45 11.14,92.3 R251.2 11.6,91.92 12.97,93.29 U12.9
  SIG1 w0.16: YJ21.C11 43.14,62.18 42.66,62.18 41.76,63.08 35.66,63.08 34.3,64.44 34.3,68.88 28.51,74.67 25.59,74.67 20.64,79.63 20.64,79.64 17.61,82.67 12.89,82.67 11.62,83.94 6.16,83.94 v1(6.03,84.07)
  BOTTOM w0.13: v1(6.03,84.07) 5.65,84.07 v2(5.14,83.56)
ZQSFP+_SCL_3: length 77.5
  TOP w0.13: U12.11 12.94,91.99 12.76,91.82 12.76,90.55 11.9,89.68 R1957.2 11.14,90.07 10.99,90.22 8.83,90.22 8.32,89.71 v1(8.32,89.68)
  SIG1 w0.16: v1(4.89,77.34) 10.84,77.34 10.85,77.34 11.38,77.34 11.38,77.34 12,77.34 12.38,77.72 20.76,77.72 25.21,73.28 28.26,73.28 33.13,68.4 33.13,57.41 35.55,54.99 42.04,54.99 43.2,53.82 YJ21.D11
  SIG9 w0.155: v1(8.32,89.68) 8.32,88.01 7.95,87.64 7.95,84.65 5.4,82.1 5.4,77.85 v1(4.89,77.34)
  BOTTOM w0.13: v1(4.89,77.34) v2(4.13,77.34)
ZQSFP+_SCL_4: length 82.2
  TOP w0.13: R2098.2 21.65,90.8 20.46,91.99 U12.14 18.53,91.99 v1(18.35,91.82)
  SIG1 w0.16: YJ23.A11 71,61.82 69.7,63.11 63.65,63.11 59.31,67.45 59.31,79.94 56.83,82.42 56.83,83.94 56.2,84.58 52.49,84.58 52.11,84.96 51.88,84.96 49.85,86.99 44.77,86.99 44.01,86.23 41.21,86.23 39.18,88.26 19.62,88.26 18.73,89.15 18.73,91.44 v1(18.35,91.82)
  BOTTOM w0.13: v1(18.35,91.82) 17.66,91.12 v2(17.21,90.04)
ZQSFP+_SCL_5: length 104.1
  TOP w0.13: v1(17.32,93.7) 17.72,93.29 U12.16 20.76,93.29 21.02,93.04 R2100.2
  SIG1 w0.16: YJ23.B11 70.83,53.82 69.76,54.89 63.16,54.89 56.71,61.34 56.71,79.5 56.07,80.13 55.56,80.13 52.51,83.18 49.85,83.18 48.22,84.81 46.14,84.81 44.13,82.8 41.85,82.8 36.77,77.72 24.32,77.72 22.16,79.88 22.16,82.93 18.92,86.17 16.33,86.17 15.68,86.81 13.96,86.81 12.64,88.14 12.64,89.41 16.45,93.22 16.83,93.22 v1(17.32,93.7)
ZQSFP+_SCL_6: length 99.1
  TOP w0.13: U12.18 20.36,94.59 21.04,95.27 R2102.2 22.06,95.53 22.42,95.88 23.56,95.88 23.94,96.26 v1(23.94,96.64)
  SIG1 w0.16: v1(23.94,96.64) 23.94,94.49 25.59,92.83 40.96,92.83 42.35,91.44 50.23,91.44 51.24,90.42 53.4,90.42 54.04,89.79 57.85,89.79 59.53,88.11 75.15,88.11 77.41,85.85 77.41,78.74 81.48,74.66 81.48,64.04 82.44,63.08 88.74,63.08 90,61.82 YJ23.C11
  BOTTOM w0.13: v1(23.94,96.64) 24.32,96.64 v2(24.7,96.26)
ZQSFP+_SCL_7: length 107.5
  TOP w0.13: v1(21.4,97.51) R2104.2 22.06,97.18 21.91,97.03 21.27,97.03 21.02,96.77 21.02,96.64 20.27,95.89 U12.20
  SIG1 w0.16: v1(21.4,97.51) 20.76,96.87 20.76,95.02 25.62,90.17 44.77,90.17 46.95,87.98 50.51,87.98 51.12,87.37 57.72,87.37 58.29,86.8 67.06,86.8 69.15,84.71 72.71,84.71 73.6,85.6 74.49,85.6 76.01,84.07 76.01,77.98 80.45,73.53 80.45,57.15 82.81,54.79 89.53,54.79 YJ23.D11
ZQSFP+_SCL_8: length 122.6
  TOP w0.13: U11.5 47.04,100.97 46.55,101.47 R186.2 45.81,101.83 45.66,101.98 44.52,101.98 44.34,101.8 41.77,101.8 v1(40.7,102.87)
  SIG1 w0.16: v1(40.7,102.87) 40.84,102.74 40.84,99.09 41.43,98.5 41.43,96.04 43.03,94.44 45.73,94.44 46.53,93.64 55.77,93.64 56.25,93.16 58.94,93.16 59.42,93.64 74.49,93.64 74.81,93.96 85.44,93.96 86.68,95.2 93.66,95.2 102.76,86.1 108.12,86.1 108.98,85.24 108.98,81.54 109.95,80.58 109.95,67.76 109.18,67 109.18,64.12 110.23,63.08 116.56,63.08 117.82,61.82 YJ25.A11
  BOTTOM w0.13: v1(40.7,102.87) v2(39.94,102.87)
ZQSFP+_SCL_9: length 132.1
  TOP w0.13: U11.7 47.16,99.67 46.72,99.24 R188.2 45.81,99.59 45.63,99.77 40.25,99.77 v1(38.93,101.09)
  SIG1 w0.16: v1(38.93,101.09) 39.88,100.14 39.88,98.69 40.47,98.1 40.47,95.52 43.3,92.68 51.5,92.68 52.3,91.88 55.75,91.88 56.45,91.18 62.04,91.18 62.47,91.62 77.64,91.62 78.07,92.04 86.24,92.04 87.48,93.28 92.83,93.28 94.66,91.45 94.66,88.02 99.38,83.31 99.38,81.15 98.16,79.93 98.16,76.4 101.54,73.02 101.54,69.42 103.47,67.49 103.47,55.47 104.71,54.23 106.49,54.23 107,54.73 117.16,54.73 117.67,54.23 118.09,54.23 YJ25.B11
  BOTTOM w0.13: v1(38.93,101.09) 38.24,101.09 v2(38.16,101.01)
ZQSFP+_SCL_10: length 131.9
  TOP w0.13: U11.9 47.51,98.37 46.14,97 R190.2 45.81,96.54 45.68,96.42 43.9,96.42 43.43,95.94 43.43,94.48 44.85,93.07 48.63,93.07 51.32,95.76 v1(53.15,95.76)
  SIG1 w0.16: v1(53.15,95.76) 54.29,95.76 54.93,96.39 59.88,96.39 60.26,96.01 81.82,96.01 84.9,99.09 95.25,99.09 103.63,90.71 116.1,90.71 119.44,87.37 123,87.37 125.1,85.28 125.1,84.64 126.61,83.13 126.61,77.29 128.05,75.84 128.05,64.67 129.87,62.86 136.46,62.86 YJ25.C11
  BOTTOM w0.13: v1(53.15,95.76) v2(53.15,94.87)
ZQSFP+_SCL_11: length 129.5
  TOP w0.13: v1(49.37,95.07) 49.06,94.76 R180.2 45.81,94.97 46.42,95.58 46.42,95.76 47.74,97.07 U11.11
  SIG1 w0.16: YJ25.D11 137.09,54.23 136.59,54.23 135.95,54.86 129.35,54.86 127.09,57.12 127.09,75.16 125.41,76.83 125.41,81.79 123.63,83.56 118.05,83.56 117.67,83.18 113.76,83.18 108.91,88.03 103.59,88.03 94.47,97.15 85.92,97.15 83.69,94.92 56.2,94.92 55.88,94.6 49.83,94.6 v1(49.37,95.07)
  BOTTOM w0.13: v2(50.1,94.74) 49.77,95.07 v1(49.37,95.07)
ZQSFP+_SCL_12: length 141.4
  TOP w0.13: U11.14 55.34,97.07 56.53,95.88 R182.2 56.73,95.68 57.24,95.17 59.94,95.17 61.75,96.98 74.57,96.98 80.04,102.45 81.64,102.45 v1(82.23,101.85)
  SIG1 w0.16: v1(82.23,101.85) 83.31,102.93 96.85,102.93 105.22,94.55 126.61,94.55 129.98,91.18 130.87,91.18 132.14,89.91 136.21,89.91 138.75,87.37 143.57,87.37 146.88,84.07 146.88,81.4 148.02,80.26 148.02,78.74 148.91,77.85 148.91,68.7 154.46,63.15 163.13,63.15 163.84,62.44 164.88,62.44 YJ27.A11
  BOTTOM w0.13: v1(82.23,101.85) v2(82.23,102.61)
ZQSFP+_SCL_13: length 146.7
  TOP w0.13: v1(76.64,101.8) 72.89,98.04 60.13,98.04 59.63,97.53 56.86,97.53 56.73,97.66 R192.2 55.99,98.12 55.74,98.37 U11.16
  SIG1 w0.16: v1(76.64,101.8) 76.64,101.72 78.64,99.73 82.82,99.73 84.1,101.01 96.05,101.01 104.42,92.63 122.47,92.63 127.73,87.37 128.84,87.37 130.31,85.9 130.31,72.31 134.94,67.68 144.73,67.68 150.43,61.98 150.43,56.13 151.61,54.95 163.93,54.95 165.06,53.82 YJ27.B11
  BOTTOM w0.13: v1(76.64,101.8) v2(76.64,102.61)
ZQSFP+_SCL_14: length 162.6
  TOP w0.13: v1(77.15,107.74) 69.82,100.42 61.52,100.42 60.9,99.79 56.86,99.79 56.73,99.92 R194.2 55.94,100.35 55.26,99.67 U11.18
  SIG1 w0.16: YJ27.C11 184.5,61.94 183.96,62.48 182.78,62.48 182.18,63.08 176.37,63.08 175.41,64.04 175.41,68.96 171.89,72.48 171.89,77.85 171.64,78.1 171.64,82.42 169.23,84.83 164.15,84.83 163.39,85.6 160.46,85.6 159.45,86.61 156.78,86.61 156.02,87.37 150.05,87.37 143.95,93.47 137.86,93.47 136.59,94.74 129.47,94.74 127.44,96.76 106.03,96.76 95.99,106.8 78.1,106.8 v1(77.15,107.74)
  BOTTOM w0.13: v1(77.15,107.74) v2(77.15,108.51)
ZQSFP+_SCL_15: length 169.8
  TOP w0.13: U11.20 55.12,100.97 55.97,101.83 55.97,102.38 56.17,102.59 R196.2 56.73,102.18 56.89,102.03 58.03,102.03 58.08,102.09 61.29,102.09 61.38,102.18 62.83,102.18 v1(68.39,107.74)
  SIG1 w0.16: v1(68.39,107.74) 71.29,104.85 96.37,104.85 105.51,95.71 127.11,95.71 130.5,92.33 140.14,92.33 141.03,91.44 142.3,91.44 148.53,85.21 155,85.21 156.65,83.56 159.96,83.56 160.34,83.18 164.4,83.18 164.94,83.72 168.69,83.72 170.24,82.17 170.24,77.85 170.75,77.34 170.75,71.63 174.31,68.07 174.31,57.27 176.85,54.73 183.08,54.73 183.46,54.35 183.97,54.35 YJ27.D11
  BOTTOM w0.13: v1(68.39,107.74) v2(68.39,108.51)
ZQSFP+_SCL_16: length 302.9
  TOP w0.13: v1(415.73,124.46) 415.6,124.46 415.23,124.09 U10.5 412.93,124.09 412.43,124.58 R164.2
  SIG3 w0.155: v1(214.57,50.54) 214.06,51.05 214.06,52.44 213.57,52.93 213.57,53.3 213.93,53.66 213.93,54 213.93,54.01 213.93,56.58 213.57,56.94 213.57,57.3 213.93,57.66 213.93,59.16 213.93,59.16 213.93,60.57 213.42,61.08 212.92,61.08 212.5,61.5 YJ29.A11
  SIG6 w0.155: v1(386.27,33.78) 386.27,36.45 390.08,40.26 390.08,60.06 395.54,65.52 395.54,73.12 402.73,80.31 403.59,80.31 v1(404.18,80.9) 405.04,81.76 405.04,94.85 411.7,101.52 411.7,120.42 v1(415.73,124.46)
  SIG10 w0.155: v1(386.27,33.78) 385.13,33.78 383.03,31.68 231.27,31.68 213.94,49.01 213.94,49.92 v1(214.57,50.54)
ZQSFP+_SCL_17: length 290.1
  TOP w0.13: U10.7 413.12,122.79 412.69,122.35 R166.2 411.82,121.94 411.7,121.82 409.82,121.82 v1(409.31,122.32)
  SIG1 w0.155: YJ29.B11 212.5,53.5 212.92,53.08 213.39,53.08 213.93,52.54 213.93,50.29 v1(214.57,49.65)
  SIG9 w0.155: v1(214.57,49.65) 214.57,48.32 226.08,36.8 387.12,36.8 392.8,42.48 392.8,62.21 396.83,66.24 396.83,74.39 408.49,86.06 408.49,90.99 410.46,92.96 410.46,102.42 413.25,105.21 413.25,120.72 412.18,121.79 409.84,121.79 v1(409.31,122.32)
  BOTTOM w0.13: v1(409.31,122.32) v2(408.37,122.32)
ZQSFP+_SCL_18: length 282.6
  TOP w0.13: v1(415.86,120.9) 415.86,121.03 415.4,121.49 U10.9 413.65,121.49 412.28,120.11 R168.2
  SIG3 w0.155: YJ29.C11 232.13,61.19 232.32,61.19 232.88,60.63 232.88,57.61 232.56,57.29 232.56,57.06 232.6,57.02 232.6,56.91 232.85,56.66 232.85,53.58 232.6,53.33 232.6,52.91 232.94,52.57 v1(232.94,48.51) ; v1(409.26,86.36) 409.77,86.36 410.02,86.61 410.02,97.32 413.41,100.71 413.41,118.45 v1(415.86,120.9)
  SIG10 w0.155: v1(232.94,48.51) 232.94,45.23 241.68,36.49 389.9,36.49 394.5,41.09 394.5,57.89 395.43,58.82 395.43,63.6 396.21,64.38 396.21,76.62 401.94,82.35 403.49,82.35 405.35,84.21 405.35,86.13 405.57,86.36 v1(409.26,86.36)
  BOTTOM w0.13: v1(409.26,86.36) v2(410.02,86.36)
ZQSFP+_SCL_19: length 266.2
  TOP w0.13: U10.11 413.62,120.19 413.32,119.89 413.32,118.36 412.84,117.88 R170.2 411.82,117.47 411.7,117.35 409.82,117.35 v1(409.31,117.85)
  SIG1 w0.155: v1(233.49,49.27) 232.98,49.78 232.98,52.53 232.43,53.08 231.97,53.08 231.5,53.55 YJ29.D11
  SIG9 w0.155: v1(409.31,117.85) 408.76,117.3 408.76,115.97 410,114.73 410.46,114.73 410.77,114.42 410.77,107.3 410.46,106.99 409.84,106.99 409.3,106.45 409.3,104.35 407.78,102.82 407.78,99.23 405.04,96.49 405.04,94.59 404.26,93.82 404.26,85.17 402.68,83.59 401.49,83.59 394.73,76.83 394.73,67.38 391.88,64.53 390.63,64.53 389.54,63.45 389.54,61.74 388.93,61.13 388.93,42.07 385.67,38.81 238.85,38.81 233.49,44.17 v1(233.49,49.27)
  BOTTOM w0.13: v1(409.31,117.85) v2(408.37,117.85)
ZQSFP+_SCL_20: length 261.3
  TOP w0.13: v1(426.15,118.97) 425.64,118.46 422.75,118.46 422.62,118.59 R172.2 422.08,119 420.9,120.19 U10.14
  SIG3 w0.155: YJ31.A11 260.13,61.19 260.31,61.19 260.81,60.68 260.81,58.54 260.85,58.51 260.85,57.59 260.56,57.29 260.56,56.95 260.92,56.59 260.92,53.65 260.56,53.29 260.56,52.94 260.94,52.56 260.94,51.07 v1(260.41,50.54)
  SIG10 w0.155: v1(260.41,50.54) 260.41,49.11 271.17,38.35 388.77,38.35 392.64,42.22 392.64,66.24 393.73,67.32 393.73,78.01 404.57,88.86 411.55,88.86 411.86,88.55 412.84,88.55 419.45,95.16 419.45,102.96 420.53,104.04 420.53,118.76 422.42,120.65 425.39,120.65 425.64,120.39 425.64,119.86 426.15,119.35 v1(426.15,118.97)
  BOTTOM w0.13: v1(426.15,118.97) v2(426.91,118.97)
ZQSFP+_SCL_21: length 251.7
  TOP w0.13: v1(426.15,121.21) 425.64,120.7 422.75,120.7 422.62,120.83 R174.2 421.83,121.23 421.58,121.49 U10.16
  SIG1 w0.155: v1(262.57,50.42) 261.07,51.92 261.07,52.36 260.37,53.06 260.26,53.06 YJ31.B11
  SIG8 w0.155: v1(426.15,121.21) 425.56,121.79 422.85,121.79 414.49,113.43 414.49,104.87 404.57,94.95 404.57,83.96 396.81,76.2 396.81,64.51 396.52,64.22 396.52,63.07 396.05,62.61 396.05,50.93 394.91,49.78 394.91,39.84 390.84,35.77 384.77,35.77 382,33 314.21,33 309.48,37.73 280.25,37.73 268.72,49.26 266.76,49.26 265.93,50.09 262.9,50.09 v1(262.57,50.42)
  BOTTOM w0.13: v1(426.15,121.21) v2(426.91,121.21)
ZQSFP+_SCL_22: length 236.6
  TOP w0.13: U10.18 421.4,122.79 422.08,123.47 R176.2 422.62,123.06 422.75,122.93 425.64,122.93 v1(426.15,123.44)
  SIG2 w0.152: YJ31.C11 279.1,61.22 279.29,61.22 279.93,60.58 279.93,59.16 279.93,59.16 279.93,57.66 279.57,57.3 279.57,56.94 279.93,56.58 279.93,54.01 279.93,54 279.93,53.66 279.57,53.3 279.57,52.93 280.06,52.44 280.06,51.81 280.58,51.29 280.58,50.01 v1(281.09,49.5)
  SIG3 w0.155: v1(426.15,123.44) 425.64,122.93 425.64,122.17 426.02,121.79 426.78,121.79 427.09,121.48 427.09,104.4 419.93,97.24 419.93,79.76 414.65,74.47 414.65,68.41 411.08,64.84 400.08,64.84 395.74,60.51 395.74,51.21 392.28,47.75 387.32,47.75 385.91,46.33 385.91,45.29 382.93,42.3 375.38,42.3 374.84,42.84 294.02,42.84 289.37,47.5 283.1,47.5 v1(281.09,49.5)
  BOTTOM w0.13: v1(426.15,123.44) v2(426.91,123.44)
ZQSFP+_SCL_23: length 238.5
  TOP w0.13: U10.20 421.14,124.09 421.77,124.72 421.77,125.24 422.24,125.7 R178.2 422.62,125.3 422.75,125.17 425.64,125.17 v1(426.15,125.68)
  SIG3 w0.155: v1(279.97,50.73) 279.97,52.53 279.42,53.08 279.08,53.08 278.5,53.67 YJ31.D11
  SIG8 w0.155: v1(279.97,50.73) 279.97,49.77 286.19,43.55 307.03,43.55 312.95,37.63 388.67,37.63 392.14,41.1 392.14,50.59 393.11,51.56 393.11,65.93 394.44,67.26 394.44,77.49 400.86,83.9 400.86,95.21 404.19,98.55 404.97,98.55 412.01,105.59 412.01,123.27 415.25,126.51 421.19,126.51 421.46,126.24 425.59,126.24 v1(426.15,125.68)
  BOTTOM w0.13: v1(426.15,125.68) v2(426.91,125.68)
ZQSFP+_SCL_24: length 187.8
  SIG3 w0.155: YJ33.A11 307.24,61.08 307.4,61.08 307.91,60.58 307.91,57.64 307.58,57.31 307.58,56.92 307.89,56.62 307.89,53.62 307.58,53.31 307.58,52.93 307.86,52.65 307.86,50.98 v1(304.86,47.98)
  SIG4 w0.155: v1(425.13,111.99) 424.52,111.38 423.84,111.38 421.31,108.85 421.31,102.49 407.83,89.01 403.15,89.01 v1(402.02,87.88)
  SIG9 w0.155: v1(304.86,47.98) 305.3,47.54 383.24,47.54 384.12,48.42 384.12,72.48 387.36,75.71 388.15,75.71 400.31,87.88 v1(402.02,87.88)
  BOTTOM w0.13: U13.5 421.71,111.51 422.21,112.01 R270.2 422.62,111.61 422.75,111.48 424.62,111.48 v1(425.13,111.99) ; v1(402.02,87.88) v2(401.26,87.88)
ZQSFP+_SCL_25: length 188.8
  SIG2 w0.155: YJ33.B11 306.5,53.21 305.88,52.59 305.88,52.19 306.67,51.4 v1(306.67,50.92)
  SIG5 w0.155: v1(425.13,109.75) 424.6,109.22 422.08,109.22 420.47,107.61 417.96,107.61 399.62,89.26 399.62,88.91 v1(398.59,87.88)
  SIG8 w0.155: v1(398.59,87.88) 398.59,84.89 388,74.3 388,66.7 389.54,65.15 389.54,62.52 391.2,60.87 391.2,52.7 390.94,52.45 390.46,52.45 389.35,51.34 389.35,41.14 387.24,39.02 316.82,39.02 306.67,49.18 v1(306.67,50.92)
  BOTTOM w0.13: U13.7 421.34,110.21 421.78,109.78 R272.2 422.62,109.37 422.75,109.24 424.62,109.24 v1(425.13,109.75) ; v1(398.59,87.88) v2(397.83,87.88)
ZQSFP+_SCL_26: length 169.7
  SIG2 w0.152: v1(327.6,44.57) 326.83,45.34 326.83,52.66 326.57,52.93 326.57,53.3 326.93,53.66 326.93,56.56 326.57,56.93 326.57,57.3 326.93,57.66 326.93,59.16 326.93,59.16 326.93,60.5 326.35,61.08 325.92,61.08 325.5,61.5 YJ33.C11
  SIG4 w0.155: v1(403.42,85.21) 406.04,85.21 422.55,101.72 422.55,105.59 423.89,106.93 424.55,106.93 v1(425.13,107.52)
  SIG9 w0.155: v1(327.6,44.57) 329.87,42.3 384.51,42.3 387.07,44.86 387.07,62.67 390.32,65.93 392.51,65.93 394.11,67.53 394.11,77.14 401.49,84.52 402.72,84.52 v1(403.42,85.21)
  BOTTOM w0.13: v1(425.13,107.52) 424.62,107.01 422.75,107.01 422.62,107.13 R274.2 422.24,107.54 420.86,108.91 U13.9 ; v1(403.42,85.21) v2(403.42,84.45)
ZQSFP+_SCL_27: length 164.7
  SIG5 w0.155: v1(425.13,105.28) 424.87,105.28 410.31,90.72 408.6,90.72 407.21,89.32 405.35,89.32 398.01,81.99 398.01,64.28 398.22,64.07 398.22,63.62 395.28,60.68 395.28,59.12 394.35,58.19 394.35,43.9 388.79,38.35 376.84,38.35 373.62,41.57 350.79,41.57 349.82,42.55 332.29,42.55 324.93,49.91 324.93,52.64 325.5,53.21 YJ33.D11
  BOTTOM w0.13: U13.11 420.94,107.61 421.32,107.23 421.32,105.59 v2(421.37,105.53) 421.6,105.31 R276.2 422.62,104.9 422.75,104.77 424.62,104.77 v1(425.13,105.28)
ZQSFP+_SCL_28: length 136.4
  SIG3 w0.155: YJ35.A11 353.5,61.5 353.92,61.08 354.35,61.08 354.93,60.5 354.93,59.16 354.93,59.16 354.93,57.66 354.57,57.3 354.57,56.94 354.93,56.58 354.93,54.01 354.93,54 354.93,53.66 354.57,53.3 354.57,52.94 355.06,52.45 355.06,51.66 356.81,49.91 370.86,49.91 373.74,47.03 383.35,47.03 385.36,49.04 385.36,50.65 387.03,52.32 391.81,52.32 392.49,53 392.49,61.74 393.88,63.14 393.88,64.84 396.36,67.32 409.84,67.32 411.55,69.03 411.55,75.3 418.07,81.82 418.07,107.36 v1(418.91,108.2)
  BOTTOM w0.13: R278.2 412.25,106.42 412.94,107.11 v2(412.94,107.31) 413.24,107.61 U13.14 418.32,107.61 v1(418.91,108.2)
ZQSFP+_SCL_29: length 125.1
  SIG2 w0.152: v1(355.54,50.42) 354.65,50.42 352.87,52.19 352.87,52.58 353.5,53.21 YJ35.B11
  SIG5 w0.155: v1(355.54,50.42) 355.54,49.4 356.06,48.87 360.38,48.87 361.12,48.13 363.18,48.13 363.68,48.64 372.59,48.64 378.08,43.15 382.73,43.15 385.04,45.46 391.81,45.46 392.33,45.99 392.33,61.32 395.69,64.67 395.69,87.26 410.78,102.36 410.78,107.69 410.3,108.18 409.77,108.18 v1(409.31,108.63)
  BOTTOM w0.13: U13.16 413.53,108.91 413.27,108.66 R280.2 411.82,108.25 411.7,108.13 409.82,108.13 v1(409.31,108.63) 409.31,109.17 v2(409.51,109.37)
ZQSFP+_SCL_30: length 101.1
  SIG2 w0.152: v1(375.76,51.05) 374.97,51.05 374.06,51.96 374.06,52.44 373.57,52.93 373.57,53.3 373.93,53.66 373.93,56.56 373.57,56.93 373.57,57.3 373.93,57.66 373.93,59.16 373.93,59.16 373.93,60.5 373.35,61.08 372.92,61.08 372.5,61.5 YJ35.C11
  SIG3 w0.155: v1(415.86,110.23) 415.35,109.73 415.35,108.96 416.1,108.22 416.1,87.36 401.8,73.06 398.84,73.06 389.54,63.76 389.54,62.83 387.03,60.32 387.03,56.89 382.88,52.74 382.88,51.05 381.86,50.04 376.77,50.04 v1(375.76,51.05)
  BOTTOM w0.13: v1(415.86,110.23) 415.84,110.21 U13.18 413.21,110.21 412.94,110.49 v2(412.94,110.74) 412.79,110.89 R282.2
ZQSFP+_SCL_31: length 96.8
  SIG5 w0.155: YJ35.D11 373.13,53.19 373.29,53.19 373.95,52.53 373.95,52.19 376.13,50.02 383.7,50.02 386.14,52.45 386.14,60.35 387.38,61.59 387.38,73.68 388.46,74.76 392.02,74.76 392.33,75.07 392.33,89.37 399.1,96.14 399.1,96.9 405.81,103.61 405.81,110.35 407.99,112.52 408.72,112.52 v1(409.31,113.1)
  BOTTOM w0.13: U13.20 413.69,111.51 412.08,113.13 R284.2 411.82,112.72 411.7,112.6 409.82,112.6 v1(409.31,113.1) 409.31,113.26 v2(408.57,113.99)
ZQSFP+_SCL_32: length 72.8
  SIG8 w0.155: YJ22.D11 22.54,53.46 22.54,53.24 22.39,53.08 21.98,53.08 21.53,52.63 21.53,51.71 20.36,50.54 16.07,50.54 15.43,49.91 12.76,49.91 12.07,50.61 12.07,54.01 9.94,56.13 v1(9.94,56.77)
  SIG9 w0.155: v1(17.32,95.63) 17.21,95.63 16.7,96.14 15.68,96.14 12.13,92.58 12.13,88.01 11.8,87.68 11.8,85.22 8.7,82.12 8.7,76.15 7.94,75.39 7.94,72.9 8.52,72.31 8.52,69.42 7.68,68.58 7.68,59.02 v1(9.94,56.77)
  BOTTOM w0.13: v1(17.32,95.63) 17.58,95.89 U16.5 21.91,95.89 22.06,96.04 R321.2 ; v1(9.94,56.77) v2(8.76,56.77)
ZQSFP+_SCL_33: length 84.1
  SIG2 w0.152: v1(17.32,94.66) 16.57,93.92 16.57,93.37 10.1,86.89 10.1,66.55 4.51,60.96 4.51,58.29 9.08,53.72 9.46,53.72 10.6,52.58 10.6,49.91 11.57,48.94 21.7,48.94 v1(23.81,51.05)
  SIG8 w0.155: v1(23.81,51.05) 23.94,51.18 23.94,52.58 24.32,52.96 24.32,53.22 23.94,53.6 23.94,56.64 24.25,56.96 24.25,57.28 24.19,57.34 24.19,57.34 23.94,57.6 23.94,59.34 23.67,59.61 23.67,60.44 22.9,61.21 YJ22.C11
  BOTTOM w0.13: R323.2 21.48,94.16 21.04,94.59 U16.7 17.39,94.59 v1(17.32,94.66)
ZQSFP+_SCL_34: length 94.8
  SIG9 w0.155: v1(15.97,93.7) 15.53,93.7 14.41,92.58 14.41,88.77 12.73,87.09 12.73,84.78 11.96,84 11.96,80.96 11.65,80.65 10.54,80.65 9.63,79.74 9.63,75.53 9.45,75.35 9.45,66.94 8.18,65.67 8.18,59.32 10.86,56.64 10.86,48.89 12.89,46.86 33.46,46.86 34.61,48 34.61,49.15 35.62,50.16 41.3,50.16 42.48,51.35 42.48,52.62 41.9,53.2 YJ22.B11
  BOTTOM w0.13: R325.2 22.06,92.3 21.91,92.45 21.53,92.45 20.69,93.29 U16.9 17.79,93.29 17.72,93.22 16.45,93.22 v1(15.97,93.7)
ZQSFP+_SCL_35: length 105.8
  SIG8 w0.155: v1(13.78,89.15) 13.78,88.39 12.38,86.99 12.38,85.32 10.35,83.28 10.35,80.64 6.79,77.09 6.79,68.58 7.78,67.59 7.78,66.32 8.45,65.66 8.45,53.56 10.29,51.72 10.29,48.57 11.49,47.37 15.3,47.37 16.38,48.45 17.91,48.45 18.1,48.64 32.07,48.64 32.58,49.15 34.23,49.15 35.24,50.16 41.5,50.16 42.99,51.65 42.99,52.62 43.24,52.87 43.24,53.29 42.86,53.68 42.86,56.57 43.24,56.95 43.24,57.29 42.86,57.68 42.86,58.54 42.48,58.93 42.48,60.62 41.9,61.2 YJ22.A11
  BOTTOM w0.13: v2(13.02,89.63) 13.5,89.15 v1(13.78,89.15) 14.8,90.17 15.94,90.17 16.7,89.41 18.07,89.41 18.83,88.64 20.44,88.64 20.81,89.01 21.79,89.01 22.06,89.28 R327.2 22.06,90.07 21.87,90.25 21.56,90.25 20.76,91.05 20.76,91.41 20.18,91.99 U16.11
ZQSFP+_SCL_36: length 123.2
  SIG4 w0.155: v1(7.3,90.8) 7.81,90.29 7.81,86.87 8.19,86.48 8.19,76.07 4.76,72.64 v1(4.76,71.5)
  SIG9 w0.155: v1(4.76,71.5) 6.16,70.1 6.16,56.13 7.29,55 7.29,48.23 7.77,47.75 9.36,47.75 13.35,43.76 37.22,43.76 43.5,50.04 67.11,50.04 68.51,51.43 68.51,52.56 69.01,53.06 69.14,53.06 YJ24.D11
  BOTTOM w0.13: v1(7.3,90.8) 7.84,91.34 10.86,91.34 11.14,91.06 R329.2 11.87,90.8 13.06,91.99 U16.14 ; v1(4.76,71.5) v2(4.76,70.61)
ZQSFP+_SCL_37: length 139.9
  SIG9 w0.155: YJ24.C11 69.9,61.21 70.91,60.2 70.91,57.63 71.29,57.25 71.29,57 70.91,56.62 70.91,53.62 71.31,53.22 71.31,52.97 70.95,52.61 70.95,51.6 66.34,46.99 42.61,46.99 37.96,42.34 11.82,42.34 9.72,44.45 7.56,44.45 5.78,46.23 5.78,53.72 1.71,57.78 1.71,81.79 4.55,84.62 4.55,87.69 6.31,89.45 6.31,91.13 6.79,91.62 6.79,92.53 v1(7.3,93.04)
  BOTTOM w0.13: U16.16 12.27,93.29 12.01,93.04 R331.2 11.14,93.29 10.86,93.57 8.09,93.57 v2(7.96,93.44) 7.56,93.04 v1(7.3,93.04)
ZQSFP+_SCL_38: length 149.1
  SIG1 w0.16: v1(4.13,88.14) 4.13,88.64 5.65,90.17 7.43,90.17 7.81,90.55 7.81,94.76 v1(7.3,95.27)
  SIG10 w0.155: v1(4.13,88.14) 4.13,70.02 11.39,62.75 11.39,45.12 12.8,43.71 82.11,43.71 89.58,51.18 89.58,52.53 88.9,53.21 YJ24.B11
  BOTTOM w0.13: v2(6.64,96.01) 6.64,95.91 7.28,95.27 v1(7.3,95.27) 7.84,95.81 10.86,95.81 11.14,95.53 R333.2 11.6,95.27 12.28,94.59 U16.18
ZQSFP+_SCL_39: length 184.1
  SIG3 w0.155: v1(7.3,97.51) 7.81,97 7.81,90.55 7.56,90.29 7.05,90.29 5.91,89.15 5.91,88.97 v1(3.16,86.23)
  SIG10 w0.155: YJ24.A11 88.9,61.21 91.1,59.01 97.37,59.01 101.9,54.48 101.9,47.75 101.01,46.86 86.66,46.86 82.41,42.61 12.44,42.61 10.43,44.63 10.43,58.84 6.44,62.83 6.44,65.15 3.16,68.43 v1(3.16,86.23)
  BOTTOM w0.13: U16.20 12.41,95.89 11.65,96.66 11.65,97 R335.2 11.14,97.76 10.86,98.04 8.32,98.04 8.19,98.17 v2(7.68,98.17) 7.3,97.79 v1(7.3,97.51)
ZQSFP+_SCL_40: length 111.6
  SIG1 w0.16: v1(85,89.64) 85,90.13 87.68,92.8 92.63,92.8 94.18,91.25 94.18,87.75 97.68,84.26 97.68,83.11 98.74,82.04 98.74,81.4 97.68,80.34 97.68,75.56 98.17,75.07 98.17,71.56 102.94,66.79 102.94,55.24 v1(104.97,53.21)
  SIG9 w0.155: v1(104.97,53.21) 105.74,52.43 105.74,49.42 106.25,48.92 114.81,48.92 115.51,49.61 115.51,52.56 116.01,53.06 116.14,53.06 YJ26.D11
  BOTTOM w0.13: U15.5 55.7,100.97 56.2,101.47 R337.2 56.73,101.19 56.99,100.94 59.25,100.94 59.53,101.22 v2(59.88,101.22) 60.64,101.22 61.28,100.58 62.04,100.58 63.06,101.6 69.91,101.6 77.91,93.6 81.98,93.6 85,90.57 v1(85,89.64)
ZQSFP+_SCL_41: length 132.9
  SIG1 w0.16: v1(105.09,56.39) 108.39,59.69 108.39,66.93 109.41,67.94 109.41,80.43 108.5,81.34 108.5,83.08 108.14,83.44 107.12,83.44 105.6,84.96 101.28,84.96 97.6,88.64 97.6,90.55 93.42,94.72 86.88,94.72 85.64,93.48 77.48,93.48 v1(77.15,93.16)
  SIG9 w0.155: v1(105.09,56.39) 103.81,55.11 103.81,49.15 106.02,46.94 115.7,46.94 117.95,49.18 117.95,52.61 118.31,52.97 118.31,53.22 117.91,53.62 117.91,56.62 118.29,57 118.29,57.25 117.91,57.63 117.91,58.42 117.53,58.79 117.53,60.57 116.9,61.21 YJ26.C11
  BOTTOM w0.13: U15.7 55.84,99.67 56.27,99.24 R339.2 56.73,98.91 56.96,98.68 v2(61.28,98.68) 61.4,98.68 63.18,100.45 68.59,100.45 74.44,94.6 74.44,93.17 75.24,92.36 76.36,92.36 v1(77.15,93.16)
ZQSFP+_SCL_42: length 270.6
  SIG1 w0.16: v1(63.18,99.69) 63.18,101.09 62.04,102.23 56.83,102.23 56.32,101.72 46.5,101.72 42.87,105.36 39.79,105.36 39.48,105.66 35.75,105.66 32.96,102.87 31.43,102.87 30.67,102.11 29.65,102.11 28.77,102.99 24.54,102.99 19.21,97.66 16.36,97.66 11.52,92.82 11.52,89.6 8.66,86.74 6.29,86.74 3.11,83.56 3.11,66.42 v1(4.51,65.02)
  SIG10 w0.155: v1(4.51,65.02) 5.47,64.06 5.47,62.41 8.45,59.43 8.45,52.45 8.57,52.32 8.57,41.27 8.95,40.89 9.72,40.89 12,38.61 126.42,38.61 136.58,48.77 136.58,52.53 135.9,53.21 YJ26.B11
  BOTTOM w0.13: U15.9 55.36,98.37 56.2,97.54 56.55,97.54 56.73,97.35 R341.2 56.73,96.61 56.92,96.42 60.54,96.42 v2(61.15,97.03) 63.18,99.06 v1(63.18,99.69)
ZQSFP+_SCL_43: length 316.6
  SIG1 w0.16: v1(66.99,99.69) 63.31,103.38 46.42,103.38 42.61,107.19 40.42,107.19 39.92,106.68 25.97,106.68 17.97,98.68 15.86,98.68 10.1,92.92 10.1,89.79 8.57,88.26 5.91,88.26 1.97,84.33 1.97,65.78 v1(4.51,63.24)
  SIG10 w0.155: YJ26.A11 135.9,61.21 137.93,59.18 144.2,59.18 148.9,54.48 148.9,47.75 148.01,46.86 136.07,46.86 126.72,37.51 10.81,37.51 9.59,38.73 7.56,38.73 6.78,39.5 6.78,52.31 7.43,52.96 7.43,58.93 4.51,61.85 v1(4.51,63.24)
  BOTTOM w0.13: v1(66.99,99.69) 66.99,98.68 v2(63.44,95.12) 62.55,94.23 59.75,94.23 58.74,93.22 56.58,93.22 56.45,93.34 56.45,94.1 56.73,94.38 R343.2 56.73,95.1 56.58,95.25 56.12,95.25 55.82,95.55 55.82,96.52 55.26,97.07 U15.11
ZQSFP+_SCL_44: length 172.7
  SIG1 w0.16: v1(151.99,51.75) 149.67,54.07 149.67,61.78 144.25,67.2 134.74,67.2 129.83,72.11 129.83,85.49 128.59,86.74 127.69,86.74 122.27,92.15 104.22,92.15 95.85,100.53 84.3,100.53 81.24,97.47 61.98,97.47 60.77,98.68 52.01,98.68 50.74,97.41 42.88,97.41 v1(42.37,97.91)
  SIG9 w0.155: YJ28.D11 163.14,53.06 163.01,53.06 162.51,52.56 162.51,49.61 161.81,48.92 153.25,48.92 152.74,49.42 152.74,50.99 v1(151.99,51.75)
  BOTTOM w0.13: U15.14 47.74,97.07 46.55,95.88 R345.2 45.81,95.53 45.56,95.27 44.41,95.27 44.29,95.15 42.58,95.15 v2(42.1,95.63) 41.72,96.01 41.72,97.26 v1(42.37,97.91)
ZQSFP+_SCL_45: length 187.9
  SIG1 w0.16: v1(43.12,99.18) 43.48,99.18 43.91,98.75 50.05,98.75 51.63,100.33 59.75,100.33 60.26,100.84 60.9,100.84 61.15,100.58 61.15,99.69 62.29,98.55 70.8,98.55 75.12,102.87 78.68,102.87 80.38,101.17 82.23,101.17 83.51,102.45 96.65,102.45 105.02,94.07 126.08,94.07 130.87,89.28 133.92,89.28 134.56,88.64 136.72,88.64 140.65,84.71 140.65,78.86 142.68,76.83 142.68,72.19 152.34,62.54 v1(152.34,57.05)
  SIG9 w0.155: YJ28.C11 163.9,61.21 164.91,60.2 164.91,57.63 165.29,57.25 165.29,57 164.91,56.62 164.91,53.62 165.31,53.22 165.31,52.97 164.95,52.61 164.95,49.18 162.75,46.99 152.97,46.99 150.81,49.15 150.81,55.52 v1(152.34,57.05)
  BOTTOM w0.13: U15.16 47.18,98.37 46.93,98.12 R347.2 45.81,97.69 45.66,97.53 44.39,97.53 44.26,97.66 44.26,97.97 v2(43.62,98.61) 43.12,99.11 v1(43.12,99.18)
ZQSFP+_SCL_46: length 290
  SIG2 w0.152: v1(5.14,60.45) 5.14,60.81 11.87,67.54 11.87,87.91 15.28,91.31 16.45,91.31 17.21,92.07 17.72,92.07 18.16,92.52 18.16,95.06 23.56,100.45 25.34,100.45 28.51,103.63 30.04,103.63 30.8,104.39 v1(31.81,104.39)
  SIG10 w0.155: v1(5.14,60.45) 5.65,59.94 5.65,38.73 6.99,37.4 6.99,36.64 7.3,36.32 168.97,36.32 183.58,50.92 183.58,52.53 182.9,53.21 YJ28.B11
  BOTTOM w0.13: U15.18 47.06,99.67 46.38,100.35 R349.2 45.81,100.68 45.61,100.89 43.17,100.89 v2(42.74,100.45) 40.45,100.45 39.54,99.54 37.09,99.54 36.32,100.31 36.32,102.17 34.48,104.01 32.19,104.01 v1(31.81,104.39)
ZQSFP+_SCL_47: length 331.6
  SIG2 w0.152: v1(5.14,59.43) 5.65,59.94 5.65,60.59 12.38,67.33 12.38,86.87 15.68,90.17 16.83,90.17 17.79,91.13 18.53,91.13 18.99,91.58 18.99,93.61 19.62,94.25 19.62,95.63 20.96,96.96 22.1,96.96 23.25,98.11 25.65,98.11 25.97,98.44 25.97,99.33 27.22,100.58 27.75,100.58 29.21,102.04 30.35,102.04 32.32,104.01 32.32,105.13 v1(32.83,105.64)
  SIG10 w0.155: YJ28.A11 182.9,61.21 184.93,59.18 191.2,59.18 195.9,54.48 195.9,47.75 195.01,46.86 183.45,46.86 169.02,32.43 8.27,32.43 5.72,34.99 5.72,36.89 5.02,37.59 3.11,37.59 2.86,37.84 2.86,57.15 v1(5.14,59.43)
  BOTTOM w0.13: U15.20 46.86,100.97 46.33,101.5 46.33,102.07 R351.2 45.81,102.84 45.53,103.12 42.99,103.12 v2(42.23,102.36) 40.96,102.36 38.95,100.35 37.63,100.35 37.19,100.79 37.19,102.57 34.73,105.03 33.44,105.03 v1(32.83,105.64)
ZQSFP+_SCL_48: length 303.4
  SIG4 w0.155: v1(414.21,99.31) 414.41,99.31 418.36,103.27 418.36,119.97 422.47,124.08 424.65,124.08 v1(425.13,124.56)
  SIG9 w0.155: v1(414.21,99.31) 414.21,88.49 398.39,72.67 398.39,65.16 397.14,63.91 397.14,63.14 395.2,61.2 395.2,58.99 394.19,57.98 394.19,41.9 387.59,35.3 385.84,35.3 382.84,32.31 228.21,32.31 209.36,51.16 209.36,52.45 209.99,53.08 210.16,53.08 YJ30.D11
  BOTTOM w0.13: v1(425.13,124.56) 424.62,124.05 422.75,124.05 422.62,124.18 R403.2 422.21,124.58 421.71,124.09 U17.5 ; v1(414.21,99.31) v2(413.45,99.31)
ZQSFP+_SCL_49: length 319.5
  SIG10 w0.155: YJ30.C11 210.27,61.19 210.1,61.19 209.5,60.58 209.5,57.63 209.85,57.28 209.85,56.94 209.5,56.58 209.5,53.63 209.88,53.25 209.88,52.97 ; 209.5,52.56 209.5,52.59 209.88,52.97 ; 209.5,52.56 209.88,52.94 209.88,52.97 ; 209.5,52.56 209.5,50.14 231.99,27.65 382.2,27.65 387.48,32.93 391.02,32.93 396.83,38.74 396.83,56.36 402.4,61.93 402.4,65.46 403.8,66.86 403.8,69.98 413.11,79.29 413.11,82.72 422.7,92.31 422.7,95.06 423.32,95.68 423.32,100.02 427.35,104.04 427.35,122.37 426.78,122.93 425.74,122.93 v1(425.13,122.32)
  BOTTOM w0.13: v1(425.13,122.32) 424.62,121.82 422.75,121.82 422.62,121.94 R405.2 421.78,122.35 421.34,122.79 U17.7
ZQSFP+_SCL_50: length 278.6
  SIG4 w0.155: v1(425.13,120.09) 425.08,120.09 424.62,119.63 423.86,119.63 420.07,115.84 420.07,103.11 410.3,93.34 v1(409.38,93.34)
  SIG9 w0.155: YJ30.B11 229.9,53.56 229.43,53.08 228.97,53.08 228.41,52.52 228.41,45.16 236.31,37.26 386.92,37.26 392.33,42.67 392.33,62.67 396.33,66.67 396.33,75.72 401.73,81.11 402.89,81.11 408.03,86.25 408.03,91.99 v1(409.38,93.34)
  BOTTOM w0.13: v1(425.13,120.09) 424.62,119.58 422.75,119.58 422.62,119.71 R407.2 422.49,120.11 421.12,121.49 U17.9 ; v1(409.38,93.34) v2(410.15,93.34)
ZQSFP+_SCL_51: length 298.1
  SIG10 w0.155: 228.5,57.63 228.5,60.56 ; 228.5,57.63 228.51,57.62 ; 228.5,57.63 228.51,57.62 ; 228.5,60.56 228.5,60.58 229.1,61.19 229.13,61.19 ; 228.5,60.56 229.13,61.19 ; YJ30.A11 229.27,61.19 229.13,61.19 ; 228.51,57.62 228.88,57.25 228.88,56.98 228.5,56.6 228.5,53.63 228.88,53.25 228.88,52.97 228.5,52.59 228.5,43.45 239.8,32.15 382.5,32.15 385.4,35.05 391.82,35.05 395.9,39.12 395.9,56.74 397.91,58.76 397.91,61.64 398.69,62.42 398.69,68.41 398.07,69.03 398.07,75.42 399.48,76.83 399.86,76.83 402.78,79.75 407.86,79.75 421.31,93.2 421.31,95.79 421.97,96.45 421.97,101.92 423.63,103.58 423.63,116.99 423.86,117.22 424.5,117.22 v1(425.13,117.85)
  BOTTOM w0.13: v1(425.13,117.85) 424.62,117.35 422.75,117.35 422.62,117.47 R409.2 421.63,117.88 v2(421.4,118.11) 421.32,118.18 421.32,120.01 421.15,120.19 U17.11
ZQSFP+_SCL_52: length 249.8
  SIG3 w0.155: v1(415.86,119.89) 414.04,118.06 414.04,101.9 v1(414.21,101.72)
  SIG8 w0.155: YJ32.D11 257.24,53.16 257.06,53.16 256.35,52.45 256.35,51.56 260.88,47.03 268.98,47.03 279.67,36.33 308.67,36.33 313.4,31.6 383.4,31.6 386.08,34.29 393.23,34.29 396.81,37.87 396.81,49.02 397.91,50.12 397.91,61.59 398.69,62.36 398.69,65.63 402.78,69.72 402.78,76.71 409.89,83.82 409.89,89.91 413.32,93.34 413.32,100.84 v1(414.21,101.72)
  BOTTOM w0.13: v1(414.21,101.72) v2(413.45,101.72) ; v1(415.86,119.89) 415.56,120.19 U17.14 413.5,120.19 412.31,119 R411.2
ZQSFP+_SCL_53: length 258.2
  SIG9 w0.155: v1(409.31,121.21) 409.87,120.65 410.78,120.65 412.17,119.26 412.17,116.28 412.63,115.82 412.63,105.35 409.51,102.23 409.51,98.29 407.1,95.88 v1(407.1,87.5)
  SIG10 w0.155: 256.88,52.97 256.88,53.25 256.5,53.63 256.5,56.54 ; 256.88,52.97 256.5,52.59 256.5,52.56 ; 256.88,52.97 256.88,52.94 256.5,52.56 ; 256.88,56.97 256.5,56.58 256.5,56.54 ; 256.88,56.97 256.88,57.25 256.5,57.63 256.5,60.56 ; 256.88,56.97 256.88,56.92 256.5,56.54 ; 256.5,52.56 256.5,50.52 270.07,36.95 389.7,36.95 394.04,41.29 394.04,58.31 394.81,59.09 394.81,63.91 395.59,64.69 395.59,76.93 401.79,83.13 403.18,83.13 404.73,84.68 404.73,86.53 405.19,86.99 406.59,86.99 v1(407.1,87.5) ; 257.13,61.19 257.1,61.19 256.5,60.58 256.5,60.56 ; 257.13,61.19 257.27,61.19 YJ32.C11 ; 257.13,61.19 256.5,60.56
  BOTTOM w0.13: U17.16 413.4,121.49 413.14,121.23 R413.2 411.82,120.83 411.7,120.7 409.82,120.7 v1(409.31,121.21) v2(407.73,121.21)
ZQSFP+_SCL_54: length 229.3
  SIG8 w0.155: v1(415.79,123.57) 416.5,122.86 416.5,116.59 413.87,113.96 413.87,104.92 403.95,95.01 403.95,87.62 402.87,86.54 402.87,83.14 396.15,76.43 396.15,65.41 395.43,64.69 395.43,51.2 394.27,50.04 394.27,40.13 390.37,36.23 312.02,36.23 309.78,38.48 286.32,38.48 275.51,49.29 275.51,52.56 ; 275.51,52.56 276.01,53.06 ; 275.51,52.56 275.51,52.6 275.97,53.06 276.01,53.06 ; 276.01,53.06 276.14,53.06 YJ32.B11
  BOTTOM w0.13: v1(415.79,123.57) 415.79,123.49 415.08,122.79 U17.18 413.34,122.79 v2(412.94,123.19) 412.66,123.47 R415.2
ZQSFP+_SCL_55: length 253.1
  SIG9 w0.155: v1(412.43,89.02) 413.1,89.69 413.1,102.9 415.11,104.91 415.11,122.67 412.56,125.22 409.77,125.22 v1(409.31,125.68)
  SIG10 w0.155: 275.5,52.56 275.88,52.94 275.88,52.97 ; 275.5,52.56 275.5,47.04 283.72,38.81 388.48,38.81 392.18,42.51 392.18,63.86 388.46,67.58 388.46,73.06 389.7,74.3 392.18,74.3 393.11,75.22 393.11,78.3 404.29,89.48 411.98,89.48 v1(412.43,89.02) ; 275.5,52.56 275.5,52.59 275.88,52.97 ; 276.13,61.19 276.27,61.19 YJ32.A11 ; 276.13,61.19 275.5,60.56 ; 276.13,61.19 276.1,61.19 275.5,60.58 275.5,60.56 ; 275.88,52.97 275.88,53.25 275.5,53.63 275.5,56.61 275.51,56.62 275.51,56.62 275.8,56.91 275.8,56.91 275.88,56.99 275.88,57.25 275.5,57.63 275.5,60.56
  BOTTOM w0.13: U17.20 413.57,124.09 412.36,125.3 412.36,125.55 412.2,125.7 R417.2 411.82,125.37 411.62,125.17 409.82,125.17 v1(409.31,125.68) ; v1(412.43,89.02) v2(413.19,89.02)
ZQSFP+_SCL_56: length 188.3
  TOP w0.13: U18.5 412.93,111.51 412.43,112.01 R419.2 411.82,111.61 411.7,111.48 408.93,111.48 v1(408.42,111.99)
  SIG8 w0.155: v1(408.42,111.99) 408.9,111.5 410.27,111.5 410.77,111.01 410.77,106.21 410.46,105.9 410,105.9 399.46,95.37 399.46,84.68 392.64,77.86 392.64,76.93 392.02,76.31 391.25,76.31 388.62,73.68 388.62,67.17 390.16,65.62 390.16,63.26 392.14,61.29 392.14,52.6 391.86,52.32 391.48,52.32 391.2,52.04 391.2,51.64 390.87,51.31 390.46,51.31 389.82,50.66 389.82,40.95 387.43,38.56 316.36,38.56 305.5,49.42 305.5,52.62 305.49,52.62 304.9,53.21 YJ34.D11
  BOTTOM w0.13: v1(408.42,111.99) v2(406.97,111.99)
ZQSFP+_SCL_57: length 175.7
  TOP w0.13: U18.7 413.12,110.21 412.69,109.78 R435.2 411.82,109.37 411.7,109.24 408.93,109.24 v1(408.42,109.75)
  SIG9 w0.155: v1(302.83,49.4) 303.5,48.73 314.09,48.73 314.82,48 316.29,48 316.77,48.48 360.24,48.48 360.58,48.13 363.16,48.13 363.54,48.51 383.02,48.51 383.5,48.99 383.5,72.56 387.14,76.2 387.92,76.2 397.91,86.19 397.91,93.09 406.08,101.26 406.08,103.18 407.31,104.41 407.31,108.64 v1(408.42,109.75)
  SIG10 w0.155: YJ34.C11 304.27,61.19 304.1,61.19 303.5,60.58 303.5,57.63 303.88,57.25 303.88,56.97 303.5,56.58 303.5,53.63 303.88,53.25 303.88,52.97 303.5,52.59 303.5,50.83 302.83,50.16 v1(302.83,49.4)
  BOTTOM w0.13: v1(408.42,109.75) v2(406.97,109.75)
ZQSFP+_SCL_58: length 152.2
  TOP w0.13: U18.9 413.65,108.91 412.28,107.54 R422.2 411.82,107.13 411.7,107.01 408.75,107.01 v1(408.24,107.52)
  SIG8 w0.155: YJ34.B11 323.9,53.21 324.67,52.44 324.67,49.93 331.36,43.23 383.48,43.23 385.86,45.62 385.86,52.29 387.03,53.46 388.54,53.46 388.93,53.85 388.93,60.04 386.14,62.83 386.14,75.53 396.36,85.76 396.36,95.04 408.24,106.92 v1(408.24,107.52)
  BOTTOM w0.13: v1(408.24,107.52) v2(406.97,107.52)
ZQSFP+_SCL_59: length 164.8
  TOP w0.13: U18.11 413.62,107.61 413.32,107.31 413.32,105.79 412.84,105.31 R424.2 411.82,104.9 411.7,104.77 408.93,104.77 v1(408.42,105.28)
  SIG9 w0.155: v1(325.31,44.57) 326.37,45.63 328.65,45.63 331.05,43.23 382.96,43.23 385.83,46.1 385.83,71.82 388.28,74.27 391.71,74.27 392.33,74.89 392.33,77.18 401.07,85.92 402.4,85.92 403.67,87.18 403.67,97.15 407.23,100.71 407.23,102.98 408.42,104.17 v1(408.42,105.28)
  SIG10 w0.155: YJ34.A11 323.27,61.19 323.1,61.19 322.5,60.58 322.5,57.63 322.88,57.25 322.88,56.97 322.5,56.58 322.5,53.63 322.5,53.62 322.51,53.62 322.88,53.25 322.88,52.97 322.5,52.59 322.5,45.82 324.25,44.07 324.8,44.07 v1(325.31,44.57)
  BOTTOM w0.13: v1(408.42,105.28) v2(408.42,104.52)
ZQSFP+_SCL_60: length 138.5
  TOP w0.13: v1(426.15,106.4) 425.64,105.89 422.75,105.89 422.62,106.02 R426.2 422.08,106.42 420.9,107.61 U18.14
  SIG5 w0.155: v1(353.63,50.54) 356.93,47.24 373.06,47.24 377.62,42.69 383.5,42.69 385.14,44.32 391.95,44.32 392.95,45.32 392.95,61.28 396.31,64.63 396.31,84.31 400.24,88.24 400.24,89.01 405.19,93.97 410,93.97 417.59,101.56 417.59,101.87 423.79,108.07 426.4,108.07 426.66,107.82 426.66,106.91 v1(426.15,106.4)
  SIG9 w0.155: v1(353.63,50.54) 352.49,51.69 352.49,52.61 351.9,53.2 YJ36.D11
  BOTTOM w0.13: v1(426.15,106.4) v2(426.91,106.4)
ZQSFP+_SCL_61: length 150.1
  TOP w0.13: v1(426.15,108.63) 425.64,108.13 422.75,108.13 422.62,108.25 R437.2 421.83,108.66 421.58,108.91 U18.16
  SIG3 w0.155: v1(350.33,50.8) 351.35,49.78 352.65,49.78 359.12,43.31 375.03,43.31 375.57,42.77 382.73,42.77 385.44,45.48 385.44,46.53 386.91,47.99 386.91,48.57 387.23,48.89 392.49,48.89 395.12,51.52 395.12,60.82 397.14,62.83 397.14,64.07 398.53,65.46 410.77,65.46 414.03,68.72 414.03,74.74 419.46,80.18 419.46,97.86 426.63,105.02 426.63,108.16 v1(426.15,108.63)
  SIG10 w0.155: YJ36.C11 351.27,61.19 351.1,61.19 350.5,60.58 350.5,57.63 350.88,57.25 350.88,56.97 350.5,56.58 350.5,53.63 350.88,53.25 350.88,52.97 350.33,52.42 v1(350.33,50.8)
  BOTTOM w0.13: v1(426.15,108.63) v2(426.91,108.63)
ZQSFP+_SCL_62: length 120.4
  TOP w0.13: U18.18 421.43,110.21 422.12,110.89 R439.2 422.62,110.49 422.75,110.36 425.64,110.36 v1(426.15,110.87)
  SIG5 w0.155: v1(426.15,110.87) 426.91,111.63 426.91,112.27 426.66,112.52 424.1,112.52 423.22,111.64 415.26,111.64 413.99,110.36 407.98,110.36 407.05,109.43 407.05,102.29 394.14,89.38 394.14,65.49 389.08,60.43 389.08,49.35 388.75,49.02 384.88,49.02 383.35,47.49 376.55,47.49 373.82,50.21 v1(373.82,50.67)
  SIG9 w0.155: v1(373.82,50.67) 373.19,51.31 372.76,51.31 371.42,52.65 371.4,52.69 371.36,52.75 371.23,52.88 371.17,52.92 371.13,52.94 370.9,53.17 YJ36.B11
  BOTTOM w0.13: v1(426.15,110.87) v2(426.91,110.87)
