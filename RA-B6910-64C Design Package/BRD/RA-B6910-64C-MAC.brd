# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC11_RDN3: length 157.7
  TOP w0.147: v4(170.55,154.29) 170.55,154.22 arc(170.56,154.15) 170.6,154.09 170.71,153.98 arc(170.86,153.88) U1.BH60
  SIG3 w0.112: 163.19,153.01 163.21,153.01 163.31,152.92 168.75,152.92 arc(168.8,152.93) 168.84,152.96 168.94,153.06 arc(168.97,153.1) 168.98,153.15 168.98,153.62 arc(169.07,153.85) 169.3,153.94 170.42,153.94 arc(170.51,153.98) 170.55,154.07 v4(170.55,154.29)
  SIG3 w0.16: 163.19,153.01 162.14,153.01 arc(162.01,153.02) 161.88,153.06 161.62,153.17 arc(161.48,153.21) 161.33,153.22 154.13,153.22 arc(153.69,153.14) 153.32,152.89 125.37,124.93 arc(125.12,124.56) 125.03,124.12 125.03,113.98 arc(125,113.83) 124.92,113.71 99.46,88.25 arc(99.33,88.16) 99.19,88.14 83.44,88.14 arc(83,88.05) 82.63,87.8 79.9,85.07 arc(79.65,84.7) 79.57,84.26 79.57,72.96 arc(79.65,72.52) 79.9,72.15 81.12,70.93 arc(81.2,70.81) 81.23,70.66 81.23,67.65 arc(81.2,67.5) 81.12,67.38 80.33,66.6 arc(80.08,66.22) 80,65.79 80,62.04 arc(79.87,61.41) 79.52,60.89 77.86,59.23 arc(77.84,59.21) 77.81,59.18 77.76,59.13 77.72,59.08 arc(77.47,58.92) 77.18,58.86 76.3,58.86 arc(76.09,58.78) 76.01,58.57 76.01,58.32 arc(76.04,58.13) 76.15,57.97 YJ23.B22
FC11_RDP0: length 167.8
  TOP w0.147: v4(176.55,154.29) 176.65,154.29 arc(176.75,154.27) 176.83,154.22 176.97,154.07 arc(177.03,153.99) 177.05,153.89 U1.BH54
  SIG2 w0.112: v4(176.55,154.29) 176.55,154.07 arc(176.51,153.98) 176.42,153.94 176.25,153.94 arc(176.02,153.85) 175.92,153.62 175.92,152.2 arc(175.91,152.15) 175.89,152.11 175.72,151.94 arc(175.68,151.91) 175.63,151.9 169.4,151.9 arc(169.28,151.88) 169.17,151.81 169.04,151.68 arc(168.97,151.58) 168.95,151.45 168.95,151.05 arc(168.91,150.96) 168.82,150.92 163.38,150.92 163.28,151.02 163.26,151.02
  SIG2 w0.16: 163.26,151.02 154.93,151.02 arc(154.5,150.93) 154.13,150.68 127.53,124.08 arc(127.28,123.71) 127.19,123.27 127.19,113.34 arc(127.13,113.05) 126.97,112.8 100.36,86.2 arc(100.12,86.03) 99.82,85.98 94.36,85.98 arc(93.92,85.89) 93.55,85.64 92.47,84.56 arc(92.35,84.48) 92.2,84.45 83.09,84.45 arc(82.65,84.37) 82.28,84.12 81.98,83.82 arc(81.74,83.45) 81.65,83.01 81.65,67.45 arc(81.64,67.39) 81.61,67.35 arc(81.41,67.05) 81.34,66.71 81.34,58.48 arc(81.28,58.18) 81.12,57.94 78.81,55.63 arc(78.56,55.46) 78.27,55.41 75.95,55.41 arc(75.77,55.38) 75.6,55.32 arc(75.5,55.26) 75.41,55.18 75.36,55.13 75.32,55.08 arc(75.07,54.92) 74.78,54.86 73.93,54.86 arc(73.7,54.77) 73.61,54.54 73.61,54.32 arc(73.64,54.13) 73.75,53.97 YJ23.B14
FC11_RDP1: length 163.1
  TOP w0.147: v4(172.55,153.39) 172.55,153.34 U1.BG58
  SIG3 w0.112: v4(172.55,153.39) 172.55,153.62 arc(172.51,153.71) 172.42,153.74 172.25,153.74 arc(172.16,153.71) 172.12,153.62 172.12,153.15 arc(172.09,153.03) 172.02,152.92 171.92,152.82 arc(171.82,152.75) 171.69,152.72 170.34,152.72 arc(170.29,152.71) 170.25,152.68 170.18,152.61 arc(170.15,152.57) 170.14,152.52 170.14,152.09 arc(170.12,151.96) 170.05,151.86 169.98,151.79 arc(169.88,151.72) 169.75,151.7 169.34,151.7 arc(169.29,151.69) 169.25,151.66 169.19,151.6 arc(169.16,151.56) 169.15,151.51 169.15,151.2 arc(169.13,151.08) 169.06,150.98 168.94,150.86 arc(168.83,150.79) 168.71,150.76 163.38,150.76 163.28,150.67 163.26,150.67
  SIG3 w0.16: YJ23.B18 77.1,52.71 arc(77.16,53.01) 77.33,53.26 77.74,53.67 arc(77.86,53.86) 77.91,54.08 77.91,54.57 arc(77.94,54.72) 78.03,54.86 78.08,54.91 arc(78.21,55) 78.35,55.03 79.04,55.03 arc(79.48,55.11) 79.85,55.36 81.37,56.88 arc(81.62,57.25) 81.71,57.69 81.71,65.39 arc(81.74,65.54) 81.82,65.66 83.79,67.63 arc(83.95,67.87) 84.01,68.17 84.01,68.55 84.26,68.8 84.26,69.31 84.01,69.56 84.01,70.1 84.21,70.3 84.21,70.79 84.01,70.99 84.01,71.18 arc(83.95,71.47) 83.79,71.72 82.25,73.26 arc(82.09,73.5) 82.03,73.8 82.03,83.04 arc(82.09,83.34) 82.25,83.58 82.52,83.85 arc(82.76,84.01) 83.06,84.07 93.6,84.07 arc(93.89,84.13) 94.14,84.29 95.22,85.37 arc(95.46,85.54) 95.76,85.6 99.95,85.6 arc(100.24,85.65) 100.49,85.82 127.35,112.68 arc(127.51,112.92) 127.57,113.22 127.57,123.27 arc(127.63,123.56) 127.8,123.81 154.43,150.45 arc(154.68,150.61) 154.97,150.67 163.26,150.67
FC11_RDP2: length 163.5
  TOP w0.147: v4(174.55,154.29) 174.64,154.29 arc(174.72,154.27) 174.79,154.23 174.97,154.04 arc(175.03,153.96) 175.05,153.86 U1.BH56
  SIG2 w0.112: v4(174.55,154.29) 174.55,154.07 arc(174.51,153.98) 174.42,153.94 174.25,153.94 arc(174.02,153.85) 173.92,153.62 173.92,153.16 arc(173.91,153.11) 173.89,153.07 173.79,152.97 arc(173.75,152.95) 173.7,152.94 163.38,152.94 163.28,153.03 163.26,153.03
  SIG2 w0.16: 163.26,153.03 161.69,153.03 arc(161.57,153.05) 161.46,153.12 161.39,153.18 arc(161.34,153.21) 161.28,153.22 154.12,153.22 arc(153.69,153.14) 153.32,152.89 125.37,124.94 arc(125.12,124.57) 125.03,124.13 125.03,114.11 arc(124.97,113.81) 124.81,113.57 99.6,88.36 arc(99.35,88.19) 99.06,88.14 83.44,88.14 arc(83,88.05) 82.63,87.8 79.9,85.07 arc(79.65,84.7) 79.57,84.26 79.57,69.39 arc(79.65,68.96) 79.89,68.6 arc(79.97,68.49) 80,68.35 80,60.94 arc(79.94,60.65) 79.77,60.4 79,59.63 arc(78.75,59.46) 78.46,59.41 75.95,59.41 arc(75.77,59.38) 75.6,59.32 arc(75.5,59.26) 75.41,59.18 75.35,59.12 arc(75.06,58.93) 74.72,58.86 73.91,58.86 arc(73.7,58.77) 73.61,58.56 73.61,58.32 arc(73.64,58.13) 73.75,57.97 YJ23.B25
FC11_RDP3: length 157.7
  TOP w0.147: U1.BG60 170.55,153.34 v4(170.55,153.39)
  SIG3 w0.112: 163.19,152.63 163.21,152.63 163.3,152.72 168.75,152.72 arc(168.87,152.75) 168.98,152.82 169.08,152.92 arc(169.15,153.03) 169.18,153.15 169.18,153.62 arc(169.21,153.71) 169.3,153.74 170.42,153.74 arc(170.51,153.71) 170.55,153.62 v4(170.55,153.39)
  SIG3 w0.16: 163.19,152.63 162.14,152.63 arc(161.93,152.65) 161.74,152.71 161.48,152.81 arc(161.4,152.84) 161.33,152.84 154.13,152.84 arc(153.84,152.79) 153.59,152.62 125.64,124.66 arc(125.47,124.42) 125.41,124.12 125.41,113.98 arc(125.35,113.69) 125.19,113.44 99.73,87.98 arc(99.48,87.81) 99.19,87.75 83.44,87.75 arc(83.15,87.7) 82.9,87.53 80.17,84.8 arc(80,84.56) 79.95,84.26 79.95,72.96 arc(80,72.67) 80.17,72.42 81.38,71.2 arc(81.55,70.96) 81.61,70.66 81.61,70.22 81.83,70 81.83,69.57 81.61,69.35 81.61,68.92 81.86,68.66 81.86,68.16 81.61,67.9 81.61,67.65 arc(81.55,67.36) 81.38,67.11 80.6,66.33 arc(80.44,66.08) 80.38,65.79 80.38,62.04 arc(80.23,61.27) 79.79,60.62 78.11,58.94 78.11,58.94 arc(78.1,58.93) 78.08,58.91 78.03,58.86 arc(77.94,58.72) 77.91,58.57 77.91,58.08 arc(77.86,57.86) 77.74,57.67 77.29,57.22 arc(77.15,57.01) 77.1,56.77 YJ23.B21
FC11_TDN0: length 162
  TOP w0.147: U1.BH66 165.01,153.84 arc(164.68,153.98) v4(164.55,154.3)
  SIG5 w0.112: v4(164.55,154.3) 164.55,154.14 arc(164.53,154.07) 164.49,154 164.48,154 arc(164.42,153.95) 164.35,153.94 164.25,153.94 arc(164.02,153.85) 163.92,153.62 163.92,153.12 arc(163.92,153.07) 163.89,153.03 163.84,152.99 arc(163.8,152.96) 163.75,152.95 163.3,152.95 163.21,153.04 163.18,153.04
  SIG5 w0.16: 163.18,153.04 159.3,153.04 arc(159.23,153.05) 159.16,153.07 158.93,153.16 arc(158.76,153.21) 158.57,153.22 153.96,153.22 arc(153.67,153.17) 153.42,153 126.94,126.51 125.37,124.94 arc(125.12,124.57) 125.03,124.14 125.03,113.98 arc(125,113.83) 124.92,113.71 105.94,94.72 arc(105.81,94.64) 105.67,94.61 99.57,94.61 arc(99.13,94.53) 98.76,94.28 92.73,88.25 arc(92.6,88.16) 92.46,88.14 83.18,88.14 arc(82.75,88.05) 82.37,87.8 79.88,85.3 arc(79.63,84.93) 79.54,84.5 79.54,78.65 arc(79.49,78.36) 79.32,78.11 79.03,77.82 arc(78.86,77.57) 78.8,77.28 78.8,69.91 arc(78.89,69.47) 79.14,69.1 79.89,68.35 arc(79.98,68.22) 80.01,68.08 80.01,59.79 arc(79.89,59.52) 79.62,59.41 68.75,59.41 arc(68.46,59.35) 68.21,59.18 68.16,59.13 68.12,59.08 arc(67.87,58.92) 67.58,58.86 66.69,58.86 arc(66.49,58.78) 66.41,58.58 66.41,58.32 arc(66.44,58.13) 66.55,57.97 YJ23.B34
FC11_TDN1: length 165.3
  TOP w0.147: U1.BG64 166.55,153.34 v4(166.55,153.4)
  SIG4 w0.112: v4(166.55,153.4) 166.55,153.62 arc(166.51,153.71) 166.42,153.74 166.25,153.74 arc(166.02,153.84) 165.92,154.07 165.92,154.54 arc(165.92,154.57) 165.91,154.6 arc(165.9,154.62) 165.89,154.63 165.8,154.71 arc(165.76,154.74) 165.71,154.75 163.38,154.75 163.29,154.66 163.27,154.66
  SIG4 w0.16: 163.27,154.66 163.06,154.66 arc(162.87,154.62) 162.7,154.51 161.26,153.07 arc(161.01,152.9) 160.72,152.84 154.09,152.84 arc(153.8,152.79) 153.56,152.62 125.64,124.7 arc(125.47,124.45) 125.41,124.16 125.41,113.98 arc(125.35,113.69) 125.19,113.44 99.73,87.98 arc(99.48,87.81) 99.19,87.75 83.46,87.75 arc(83.17,87.7) 82.92,87.53 80.17,84.78 arc(80,84.53) 79.95,84.24 79.95,71.45 80.2,71.19 80.2,70.69 79.95,70.43 79.95,69.92 arc(80,69.64) 80.16,69.4 arc(80.32,69.16) 80.38,68.88 80.38,61.7 arc(80.32,61.41) 80.16,61.17 79.32,60.33 79.32,59.99 78.93,59.61 78.6,59.61 78.24,59.25 arc(77.99,59.08) 77.7,59.03 66.35,59.03 arc(66.21,59) 66.08,58.91 66.03,58.86 arc(65.94,58.72) 65.91,58.57 65.91,58.08 arc(65.86,57.86) 65.74,57.67 65.23,57.16 arc(65.13,57.02) 65.1,56.85 YJ23.B36
FC11_TDN2: length 168.7
  TOP w0.147: v4(168.55,154.29) 168.66,154.29 arc(168.76,154.27) 168.85,154.21 168.93,154.13 arc(169.02,154) U1.BH62
  SIG4 w0.112: 162.88,152.12 162.9,152.12 163,152.03 163.23,152.03 arc(163.31,152.04) 163.39,152.07 arc(163.43,152.1) 163.47,152.13 164.07,152.73 arc(164.3,152.88) 164.57,152.94 167.71,152.94 arc(167.76,152.95) 167.8,152.97 167.89,153.05 arc(167.91,153.09) 167.92,153.14 167.92,153.62 arc(168.02,153.85) 168.25,153.94 168.42,153.94 arc(168.51,153.98) 168.55,154.07 v4(168.55,154.29)
  SIG4 w0.16: YJ23.B2 64.15,53.97 arc(64.04,54.13) 64.01,54.32 64.01,54.56 arc(64.1,54.77) 64.31,54.86 65.18,54.86 arc(65.47,54.92) 65.72,55.08 65.76,55.13 65.81,55.18 arc(66.06,55.35) 66.35,55.41 78.02,55.41 arc(78.16,55.44) 78.29,55.52 81.2,58.44 arc(81.29,58.56) 81.32,58.7 81.32,66.33 arc(81.4,66.77) 81.65,67.14 81.99,67.48 arc(82.08,67.6) 82.11,67.75 82.11,74.74 arc(82.08,74.88) 81.99,75.01 81.98,75.02 arc(81.74,75.39) 81.65,75.83 81.65,83.27 arc(81.74,83.71) 81.98,84.08 82.02,84.12 arc(82.39,84.37) 82.83,84.45 93.6,84.45 arc(93.75,84.48) 93.87,84.56 94.95,85.64 arc(95.32,85.89) 95.76,85.98 99.95,85.98 arc(100.1,86.01) 100.22,86.09 127.08,112.95 arc(127.16,113.07) 127.19,113.22 127.19,123.3 arc(127.28,123.74) 127.53,124.11 154.11,150.69 arc(154.48,150.94) 154.92,151.02 160.93,151.02 arc(161.08,151.05) 161.2,151.14 161.89,151.83 arc(161.96,151.88) 162.02,151.93 arc(162.3,152.08) 162.61,152.12 162.88,152.12
FC11_TDN3: length 163.8
  TOP w0.147: U1.BE65 165.55,151.34 v4(165.55,151.39)
  SIG5 w0.112: 163.15,150.66 163.24,150.75 164.65,150.75 arc(164.85,150.79) 165.01,150.9 165.03,150.91 arc(165.1,151.02) 165.12,151.14 165.12,151.62 arc(165.16,151.71) 165.25,151.74 165.42,151.74 arc(165.51,151.71) 165.55,151.62 v4(165.55,151.39)
  SIG5 w0.16: 163.15,150.66 162.5,150.66 arc(162.43,150.65) 162.36,150.64 arc(162.27,150.59) 162.18,150.53 160.86,149.21 arc(160.32,148.84) 159.67,148.71 153.01,148.71 arc(152.72,148.66) 152.47,148.49 127.8,123.82 arc(127.63,123.57) 127.57,123.28 127.57,113.22 arc(127.51,112.92) 127.35,112.68 106.44,91.77 arc(106.07,91.52) 105.64,91.44 99.92,91.44 arc(99.77,91.41) 99.65,91.33 92.62,84.29 arc(92.37,84.13) 92.08,84.07 82.93,84.07 arc(82.64,84.01) 82.39,83.85 82.25,83.71 arc(82.09,83.46) 82.03,83.17 82.03,74.73 82.18,74.57 82.18,73.81 82.03,73.66 82.03,72.9 82.18,72.74 82.18,71.98 82.03,71.83 82.03,71.07 82.18,70.92 82.18,70.15 82.03,70 82.03,69.24 arc(81.99,69.03) 81.87,68.85 arc(81.75,68.67) 81.7,68.45 81.7,55.79 arc(81.48,55.25) 80.94,55.03 68.75,55.03 arc(68.61,55) 68.48,54.91 68.43,54.86 arc(68.34,54.72) 68.31,54.57 68.31,54.08 arc(68.26,53.86) 68.14,53.67 67.64,53.18 arc(67.54,53.02) 67.5,52.84 YJ23.B6
FC11_TDP0: length 162
  TOP w0.147: v4(164.55,153.4) 164.55,153.34 U1.BG66
  SIG5 w0.112: 163.18,152.66 163.21,152.66 163.3,152.75 163.75,152.75 arc(163.87,152.78) 163.98,152.85 164.03,152.89 arc(164.1,153) 164.12,153.12 164.12,153.62 arc(164.16,153.71) 164.25,153.74 164.36,153.74 arc(164.43,153.73) 164.49,153.69 arc(164.53,153.63) 164.55,153.56 v4(164.55,153.4)
  SIG5 w0.16: 163.18,152.66 161.13,152.66 160.98,152.51 160.22,152.51 160.06,152.66 159.3,152.66 arc(159.16,152.67) 159.02,152.71 158.79,152.8 arc(158.68,152.83) 158.57,152.84 153.96,152.84 arc(153.82,152.81) 153.69,152.73 153.15,152.19 153.15,151.98 152.61,151.44 152.4,151.44 125.64,124.68 arc(125.47,124.43) 125.41,124.14 125.41,124.14 125.41,113.98 arc(125.35,113.69) 125.19,113.44 106.21,94.45 arc(105.96,94.29) 105.67,94.23 99.57,94.23 arc(99.27,94.17) 99.03,94.01 93,87.98 arc(92.75,87.81) 92.46,87.75 83.18,87.75 arc(82.89,87.7) 82.64,87.53 80.15,85.04 arc(79.98,84.79) 79.93,84.5 79.93,78.65 arc(79.84,78.21) 79.59,77.84 79.3,77.55 arc(79.21,77.42) 79.18,77.28 79.18,73.57 79.26,73.49 79.26,72.58 79.18,72.5 79.18,71.74 79.29,71.64 79.29,70.77 79.18,70.67 79.18,69.91 79.19,69.91 arc(79.24,69.62) 79.41,69.37 80.16,68.62 arc(80.33,68.37) 80.39,68.08 80.39,59.79 arc(80.16,59.25) 79.62,59.03 68.75,59.03 arc(68.61,59) 68.48,58.91 68.43,58.86 arc(68.34,58.72) 68.31,58.57 68.31,58.08 arc(68.26,57.86) 68.14,57.67 67.63,57.16 arc(67.53,57.02) 67.5,56.86 YJ23.B33
FC11_TDP1: length 165.3
  TOP w0.147: v4(166.55,154.3) 166.66,154.3 arc(166.76,154.28) 166.85,154.22 166.92,154.15 arc(167.02,154.01) U1.BH64
  SIG4 w0.112: 163.27,155.04 163.29,155.04 163.38,154.95 165.71,154.95 arc(165.84,154.92) 165.94,154.85 166.02,154.77 arc(166.06,154.73) 166.08,154.69 arc(166.11,154.62) 166.12,154.54 166.12,154.07 arc(166.16,153.98) 166.25,153.94 166.42,153.94 arc(166.51,153.98) 166.55,154.07 v4(166.55,154.3)
  SIG4 w0.16: YJ23.B37 64.15,57.97 arc(64.04,58.13) 64.01,58.32 64.01,58.57 arc(64.09,58.78) 64.3,58.86 65.18,58.86 arc(65.47,58.92) 65.72,59.08 65.76,59.13 65.81,59.18 arc(66.06,59.35) 66.35,59.41 77.7,59.41 arc(77.84,59.44) 77.97,59.52 79.89,61.44 arc(79.97,61.56) 80,61.7 80,68.88 arc(79.97,69.02) 79.89,69.13 arc(79.65,69.5) 79.57,69.92 79.57,84.24 arc(79.65,84.68) 79.9,85.05 82.65,87.8 arc(83.03,88.05) 83.46,88.14 99.19,88.14 arc(99.33,88.16) 99.46,88.25 124.92,113.71 arc(125,113.83) 125.03,113.98 125.03,124.16 arc(125.12,124.6) 125.37,124.97 153.29,152.89 arc(153.66,153.14) 154.09,153.22 160.72,153.22 arc(160.87,153.25) 160.99,153.34 162.43,154.78 arc(162.72,154.97) 163.06,155.04 163.27,155.04
FC11_TDP2: length 168.7
  TOP w0.147: U1.BG62 168.55,153.34 v4(168.55,153.39)
  SIG4 w0.112: 162.88,151.74 162.9,151.74 163,151.84 163.23,151.84 arc(163.31,151.84) 163.39,151.86 arc(163.5,151.91) 163.61,151.99 163.7,152.08 164.21,152.59 arc(164.37,152.7) 164.57,152.74 167.71,152.74 arc(167.84,152.76) 167.94,152.83 168.02,152.91 arc(168.09,153.02) 168.12,153.14 168.12,153.62 arc(168.16,153.71) 168.25,153.74 168.42,153.74 arc(168.51,153.71) 168.55,153.62 v4(168.55,153.39)
  SIG4 w0.16: YJ23.B3 65.1,52.84 arc(65.14,53.02) 65.24,53.17 65.74,53.67 arc(65.86,53.86) 65.91,54.08 65.91,54.57 arc(65.94,54.72) 66.03,54.86 66.08,54.91 arc(66.21,55) 66.35,55.03 78.02,55.03 arc(78.31,55.08) 78.56,55.25 78.92,55.61 79.25,55.61 79.63,55.99 79.63,56.33 79.99,56.69 80.33,56.69 80.71,57.07 80.71,57.4 81.47,58.17 arc(81.64,58.41) 81.7,58.7 81.7,66.33 arc(81.75,66.62) 81.92,66.87 82.26,67.21 arc(82.43,67.46) 82.49,67.75 82.49,74.74 arc(82.43,75.03) 82.26,75.28 82.25,75.29 arc(82.09,75.54) 82.03,75.83 82.03,83.27 arc(82.09,83.56) 82.25,83.81 82.29,83.85 arc(82.54,84.01) 82.83,84.07 93.6,84.07 arc(93.89,84.13) 94.14,84.29 95.22,85.37 arc(95.46,85.54) 95.76,85.6 99.95,85.6 arc(100.24,85.65) 100.49,85.82 127.35,112.68 arc(127.51,112.92) 127.57,113.22 127.57,123.3 arc(127.63,123.59) 127.8,123.84 154.38,150.42 arc(154.63,150.59) 154.92,150.64 160.93,150.64 arc(161.23,150.7) 161.47,150.87 162.16,151.56 arc(162.2,151.59) 162.24,151.62 arc(162.42,151.71) 162.61,151.74 162.88,151.74
FC11_TDP3: length 163.8
  TOP w0.147: U1.BF65 166,151.84 arc(165.68,151.97) v4(165.55,152.29)
  SIG5 w0.112: v4(165.55,152.29) 165.55,152.07 arc(165.51,151.98) 165.42,151.94 165.25,151.94 arc(165.02,151.85) 164.92,151.62 164.92,151.14 arc(164.92,151.09) 164.89,151.05 arc(164.77,150.98) 164.63,150.95 163.24,150.95 163.15,151.04
  SIG5 w0.16: 163.15,151.04 162.5,151.04 arc(162.37,151.03) 162.24,151 arc(162.07,150.92) 161.91,150.8 160.59,149.48 arc(160.17,149.19) 159.67,149.1 153.01,149.1 arc(152.57,149.01) 152.2,148.76 127.53,124.09 arc(127.28,123.72) 127.19,123.28 127.19,113.22 arc(127.16,113.07) 127.08,112.95 106.17,92.04 arc(105.93,91.88) 105.64,91.82 99.92,91.82 arc(99.62,91.76) 99.38,91.6 92.35,84.56 arc(92.22,84.48) 92.08,84.45 82.93,84.45 arc(82.49,84.37) 82.12,84.12 81.98,83.98 arc(81.74,83.61) 81.65,83.17 81.65,69.24 arc(81.64,69.17) 81.6,69.12 arc(81.39,68.81) 81.32,68.45 81.32,55.79 arc(81.21,55.52) 80.94,55.41 68.75,55.41 arc(68.46,55.35) 68.21,55.18 68.16,55.13 68.12,55.08 arc(67.87,54.92) 67.58,54.86 66.72,54.86 arc(66.5,54.77) 66.41,54.55 66.41,54.32 arc(66.44,54.13) 66.55,53.97 YJ23.B5
FC12_13_PVDD0P8: length 5.7
  TOP w0.229: v1(181.55,146.34) 182.05,145.84 U1.AY49 ; v1(181.55,144.34) 182.05,143.84 U1.AV49
  TOP w0.381: C283.1 157.16,147.32 ; C283.1 156.55,146.53 ; C283.1 157.9,146.53
  BOTTOM w0.13: v1(157.67,147.7) v2(157.67,148.46)
  BOTTOM w0.381: v1(181.55,146.34) 182.01,146.8 C284.1 ; v1(181.55,144.34) 181.53,144.34 C3327.1
  vias: v1(156.65,147.7)
FC12_RDN0: length 160.9
  TOP w0.147: U1.BE54 176.94,150.84 arc(176.83,150.86) 176.74,150.92 176.67,150.99 arc(176.58,151.13) v4(176.55,151.29)
  SIG8 w0.112: 163.28,149.02 163.37,148.93 175.71,148.93 arc(175.76,148.94) 175.8,148.97 175.89,149.05 arc(175.91,149.1) 175.92,149.14 175.92,150.64 arc(176.01,150.85) 176.22,150.94 176.45,150.94 arc(176.52,150.97) 176.55,151.04 v4(176.55,151.29)
  SIG8 w0.16: 163.28,149.02 152.93,149.02 arc(152.49,148.93) 152.12,148.68 127.53,124.09 arc(127.28,123.72) 127.19,123.28 127.19,109.53 arc(127.13,109.24) 126.97,108.99 113.95,95.98 arc(113.71,95.82) 113.42,95.76 103.86,95.76 arc(103.56,95.7) 103.32,95.53 92.46,84.68 arc(92.21,84.51) 91.92,84.45 86.49,84.45 arc(86.05,84.37) 85.68,84.12 80.29,78.73 arc(80.04,78.36) 79.95,77.92 79.95,60.37 arc(80.35,59.41) 81.3,59.01 81.99,59.01 arc(82.14,58.98) 82.26,58.9 82.35,58.82 arc(82.42,58.73) 82.47,58.63 arc(82.5,58.53) 82.51,58.42 82.51,58.15 arc(82.57,57.85) 82.74,57.59 83.17,57.16 arc(83.27,57.02) 83.3,56.85 YJ24.B21
FC12_RDN1: length 165.7
  TOP w0.147: v4(172.55,150.39) 172.55,150.34 U1.BD58
  SIG9 w0.112: 163.26,152.64 163.36,152.73 171.65,152.73 arc(171.76,152.71) 171.85,152.65 arc(171.91,152.57) 171.93,152.46 171.93,151.04 arc(172.01,150.83) 172.22,150.74 172.42,150.74 arc(172.46,150.73) 172.51,150.71 172.51,150.7 arc(172.54,150.66) 172.55,150.61 v4(172.55,150.39)
  SIG9 w0.16: 163.26,152.64 162.63,152.64 arc(162.43,152.61) 162.24,152.53 arc(162.16,152.48) 162.09,152.41 160.72,151.03 arc(160.47,150.87) 160.18,150.81 152.11,150.81 arc(151.82,150.75) 151.57,150.59 125.64,124.65 arc(125.47,124.4) 125.41,124.11 125.41,124.11 125.41,110.14 arc(125.35,109.85) 125.19,109.6 123.76,108.18 113.25,97.67 arc(113,97.5) 112.71,97.44 106.1,97.44 arc(105.81,97.38) 105.56,97.22 92.64,84.29 arc(92.39,84.13) 92.1,84.07 86.39,84.07 arc(86.1,84.01) 85.85,83.85 78.27,76.26 arc(78.1,76.02) 78.04,75.72 78.04,72.77 78.27,72.54 78.27,71.98 78.04,71.75 78.04,66.95 arc(78.1,66.66) 78.27,66.41 78.85,65.83 arc(79.01,65.58) 79.07,65.29 79.07,60.81 79.3,60.58 79.3,60.02 79.07,59.79 79.07,59.29 arc(79.1,59.14) 79.18,59.02 79.69,58.5 80.03,58.5 80.41,58.12 80.41,57.78 80.77,57.42 81.11,57.42 81.49,57.04 81.49,56.7 82.69,55.51 arc(82.81,55.42) 82.96,55.39 84.39,55.39 arc(84.68,55.34) 84.93,55.17 85.02,55.08 arc(85.26,54.92) 85.56,54.86 86.46,54.86 arc(86.7,54.76) 86.8,54.52 86.8,54.34 arc(86.76,54.14) 86.65,53.97 YJ24.B14
FC12_RDN2: length 172
  TOP w0.147: U1.BE56 174.94,150.84 arc(174.83,150.86) 174.74,150.92 174.67,150.99 arc(174.58,151.13) v4(174.55,151.29)
  SIG8 w0.112: 163.26,151.04 163.28,151.04 163.38,150.95 168.68,150.95 arc(168.72,150.95) 168.76,150.98 168.92,151.13 arc(168.94,151.17) 168.95,151.22 168.95,151.46 arc(168.98,151.58) 169.05,151.69 169.17,151.81 arc(169.28,151.88) 169.4,151.9 173.7,151.9 arc(173.83,151.88) 173.93,151.81 174.02,151.72 arc(174.09,151.61) 174.12,151.49 174.12,151.04 arc(174.15,150.97) 174.22,150.94 174.45,150.94 arc(174.52,150.97) 174.55,151.04 v4(174.55,151.29)
  SIG8 w0.16: 163.26,151.04 162.39,151.04 arc(162.19,151.16) 161.95,151.2 152.12,151.2 arc(151.68,151.11) 151.31,150.87 125.37,124.92 arc(125.12,124.55) 125.03,124.12 125.03,110.3 arc(124.97,110) 124.81,109.76 113.1,98.05 arc(112.85,97.88) 112.56,97.82 102.62,97.82 arc(102.33,97.76) 102.08,97.6 92.84,88.36 arc(92.59,88.19) 92.3,88.14 79.75,88.14 arc(79.32,88.05) 78.95,87.8 77.49,86.34 arc(77.24,85.97) 77.15,85.53 77.15,68.43 arc(77.21,68.14) 77.38,67.89 78.42,66.84 arc(78.59,66.59) 78.65,66.3 78.65,57.61 arc(79.41,55.77) 81.24,55.01 81.99,55.01 arc(82.14,54.98) 82.26,54.9 82.35,54.82 82.35,54.81 82.39,54.77 arc(82.45,54.7) 82.49,54.61 arc(82.51,54.54) 82.51,54.48 82.51,54.1 arc(82.56,53.84) 82.71,53.63 83.05,53.29 arc(83.24,53.01) 83.3,52.68 YJ24.B18
FC12_RDN3: length 154.7
  TOP w0.147: v4(170.55,150.39) 170.55,150.34 U1.BD60
  SIG9 w0.112: 163.21,150.66 163.26,150.66 arc(163.31,150.67) 163.35,150.69 163.36,150.71 arc(163.41,150.74) 163.47,150.75 169.03,150.75 169.11,150.67 169.61,150.67 arc(169.78,150.68) 169.96,150.71 arc(170.16,150.71) 170.33,150.61 v4(170.55,150.39)
  SIG9 w0.16: 163.21,150.66 162.69,150.66 arc(162.58,150.64) 162.47,150.58 162.45,150.57 arc(162.43,150.55) 162.4,150.53 160.75,148.87 arc(160.6,148.76) 160.43,148.68 arc(160.32,148.66) 160.21,148.65 152.94,148.65 arc(152.65,148.59) 152.4,148.43 127.8,123.82 arc(127.63,123.57) 127.57,123.28 127.57,109.38 arc(127.51,109.09) 127.35,108.84 123.76,105.26 114.11,95.6 arc(113.86,95.44) 113.57,95.38 107.08,95.38 arc(106.79,95.32) 106.54,95.15 93.38,81.99 arc(93.21,81.74) 93.16,81.45 93.15,76.48 arc(93.1,76.19) 92.93,75.94 90.49,73.5 arc(90.24,73.33) 89.95,73.28 85.85,73.28 85.62,73.05 85.06,73.05 84.83,73.28 84.33,73.28 84.1,73.05 83.54,73.05 83.31,73.28 82.8,73.28 arc(82.51,73.22) 82.26,73.05 79.95,70.74 arc(79.79,70.49) 79.73,70.2 79.73,66.94 arc(79.79,66.65) 79.95,66.4 80.17,66.18 arc(80.33,65.94) 80.39,65.64 80.39,63.33 80.62,63.1 80.62,62.54 80.39,62.31 80.39,61.81 arc(80.45,61.51) 80.61,61.27 80.97,60.91 81.33,60.91 81.69,60.55 81.69,60.19 82.26,59.62 arc(82.51,59.45) 82.8,59.39 84.39,59.39 arc(84.68,59.34) 84.93,59.17 arc(85.27,58.94) 85.68,58.86 86.46,58.86 arc(86.7,58.76) 86.8,58.52 86.8,58.34 arc(86.76,58.14) 86.65,57.97 YJ24.B25
FC12_RDP0: length 160.9
  TOP w0.147: U1.BD54 176.55,150.34 v4(176.55,150.39)
  SIG8 w0.112: v4(176.55,150.39) 176.55,150.64 arc(176.52,150.71) 176.45,150.74 176.22,150.74 arc(176.15,150.71) 176.12,150.64 176.12,149.14 arc(176.09,149.02) 176.02,148.91 175.94,148.83 arc(175.83,148.76) 175.71,148.73 163.38,148.73 163.28,148.64
  SIG8 w0.16: YJ24.B22 84.25,57.97 arc(84.38,58.17) 84.43,58.39 84.43,58.43 arc(84.4,58.57) 84.32,58.69 arc(84.13,58.82) 83.9,58.86 83.02,58.86 arc(82.99,58.86) 82.95,58.87 arc(82.82,58.91) 82.71,58.99 82.53,59.17 arc(82.28,59.34) 81.99,59.39 81.3,59.39 arc(80.62,59.68) 80.33,60.37 80.33,70.41 80.59,70.66 80.59,71.17 80.33,71.42 80.33,71.93 80.56,72.16 80.56,72.72 80.33,72.95 80.33,73.45 80.56,73.68 80.56,74.24 80.33,74.47 80.33,74.98 80.56,75.21 80.56,75.77 80.33,75.99 80.33,77.92 arc(80.39,78.21) 80.56,78.46 85.95,83.85 arc(86.19,84.01) 86.49,84.07 91.92,84.07 arc(92.36,84.16) 92.73,84.41 103.59,95.27 arc(103.71,95.35) 103.86,95.38 113.42,95.38 arc(113.85,95.46) 114.22,95.71 127.24,108.72 arc(127.48,109.1) 127.57,109.53 127.57,123.28 arc(127.63,123.57) 127.8,123.82 152.39,148.41 arc(152.64,148.58) 152.93,148.64 163.28,148.64
FC12_RDP1: length 165.7
  TOP w0.147: v4(172.55,151.29) 172.55,151.22 arc(172.56,151.15) 172.6,151.09 172.71,150.98 arc(172.86,150.88) U1.BE58
  SIG9 w0.112: 163.26,153.02 163.35,152.93 171.65,152.93 arc(171.83,152.89) 171.99,152.79 arc(172.09,152.64) 172.12,152.46 172.12,151.04 arc(172.15,150.97) 172.22,150.94 172.42,150.94 arc(172.46,150.95) 172.49,150.97 172.52,150.99 arc(172.54,151.03) 172.55,151.07 v4(172.55,151.29)
  SIG9 w0.16: 163.26,153.02 162.63,153.02 arc(162.33,152.98) 162.05,152.86 arc(161.93,152.78) 161.82,152.68 160.45,151.3 arc(160.32,151.22) 160.18,151.19 152.11,151.19 arc(151.68,151.11) 151.3,150.86 125.37,124.92 arc(125.12,124.55) 125.03,124.11 125.03,110.14 arc(125,110) 124.92,109.87 118.95,103.9 112.98,97.93 arc(112.86,97.85) 112.71,97.82 106.1,97.82 arc(105.66,97.74) 105.29,97.49 98.83,91.03 92.37,84.56 arc(92.24,84.48) 92.1,84.45 86.39,84.45 arc(85.95,84.37) 85.58,84.12 78,76.53 arc(77.75,76.16) 77.66,75.72 77.66,66.95 arc(77.75,66.51) 78,66.14 78.58,65.56 arc(78.66,65.44) 78.69,65.29 78.69,59.29 arc(78.75,58.99) 78.91,58.75 82.42,55.24 arc(82.67,55.07) 82.96,55.01 84.39,55.01 arc(84.54,54.98) 84.66,54.9 84.75,54.82 84.79,54.77 arc(84.85,54.69) 84.9,54.59 arc(84.91,54.54) 84.91,54.48 84.91,54.16 arc(84.97,53.85) 85.15,53.58 85.54,53.19 arc(85.66,53.02) 85.7,52.81 YJ24.B15
FC12_RDP2: length 172
  TOP w0.147: v4(174.55,150.39) 174.55,150.34 U1.BD56
  SIG8 w0.112: 163.26,150.66 163.28,150.66 163.38,150.75 168.68,150.75 arc(168.8,150.77) 168.9,150.84 169.06,150.99 arc(169.13,151.1) 169.15,151.22 169.15,151.46 arc(169.16,151.51) 169.19,151.55 169.31,151.67 arc(169.35,151.7) 169.4,151.71 173.7,151.71 arc(173.75,151.7) 173.79,151.67 173.89,151.58 arc(173.91,151.54) 173.92,151.49 173.92,151.04 arc(174.01,150.83) 174.22,150.74 174.45,150.74 arc(174.52,150.71) 174.55,150.64 v4(174.55,150.39)
  SIG8 w0.16: YJ24.B17 84.25,53.97 arc(84.36,54.14) 84.4,54.34 84.4,54.45 arc(84.37,54.61) 84.28,54.75 arc(84.15,54.83) 84,54.86 83.02,54.86 arc(82.85,54.89) 82.71,54.99 82.53,55.17 arc(82.28,55.34) 81.99,55.39 81.24,55.39 arc(79.68,56.04) 79.03,57.61 79.03,66.3 arc(78.94,66.74) 78.69,67.11 77.65,68.16 arc(77.56,68.28) 77.53,68.43 77.53,69.31 77.78,69.56 77.78,70.09 77.53,70.33 77.53,70.84 77.76,71.07 77.76,71.63 77.53,71.85 77.53,72.36 77.76,72.59 77.76,73.15 77.53,73.38 77.53,73.89 77.76,74.11 77.76,74.67 77.53,74.9 77.53,85.53 arc(77.59,85.83) 77.76,86.07 79.22,87.53 arc(79.46,87.7) 79.75,87.75 92.3,87.75 arc(92.74,87.84) 93.11,88.09 102.35,97.33 arc(102.47,97.41) 102.62,97.44 112.56,97.44 arc(113,97.53) 113.37,97.78 125.08,109.49 arc(125.33,109.86) 125.41,110.3 125.41,124.12 125.41,124.12 arc(125.47,124.41) 125.64,124.66 151.58,150.6 arc(151.82,150.76) 152.12,150.82 161.95,150.82 arc(162.06,150.8) 162.15,150.74 arc(162.19,150.7) 162.24,150.68 arc(162.29,150.66) 162.35,150.66 163.26,150.66
FC12_RDP3: length 154.7
  TOP w0.147: v4(170.55,151.29) 170.55,151.22 arc(170.56,151.15) 170.6,151.09 170.71,150.98 arc(170.86,150.88) U1.BE60
  SIG9 w0.112: 163.21,151.04 163.26,151.04 arc(163.31,151.03) 163.35,151 163.36,150.99 arc(163.41,150.96) 163.47,150.95 169.11,150.95 169.19,150.87 169.61,150.87 arc(170.09,150.96) 170.49,151.23 v4(170.55,151.29)
  SIG9 w0.16: 163.21,151.04 162.69,151.04 arc(162.45,151) 162.23,150.88 162.2,150.85 arc(162.17,150.83) 162.14,150.8 160.48,149.14 arc(160.41,149.08) 160.32,149.05 arc(160.27,149.03) 160.21,149.03 152.94,149.03 arc(152.51,148.94) 152.13,148.7 127.53,124.09 arc(127.28,123.72) 127.19,123.28 127.19,109.38 arc(127.16,109.23) 127.08,109.11 120.46,102.49 113.84,95.87 arc(113.71,95.79) 113.57,95.76 107.08,95.76 arc(106.64,95.67) 106.27,95.42 93.11,82.26 arc(92.86,81.89) 92.77,81.45 92.77,76.48 arc(92.74,76.34) 92.66,76.21 91.44,74.99 90.22,73.77 arc(90.1,73.69) 89.95,73.66 82.8,73.66 arc(82.36,73.57) 81.99,73.32 79.68,71.01 arc(79.43,70.64) 79.35,70.2 79.35,66.94 arc(79.43,66.5) 79.68,66.13 79.9,65.91 arc(79.98,65.79) 80.01,65.64 80.01,61.81 arc(80.1,61.37) 80.34,61 81.99,59.35 arc(82.36,59.1) 82.8,59.01 84.39,59.01 arc(84.54,58.98) 84.66,58.9 84.75,58.82 84.79,58.77 arc(84.85,58.7) 84.89,58.61 arc(84.89,58.6) 84.89,58.6 arc(84.9,58.59) 84.9,58.57 arc(84.91,58.53) 84.91,58.48 84.91,58.16 arc(84.97,57.85) 85.15,57.58 85.53,57.2 arc(85.66,57.02) 85.7,56.79 YJ24.B24
FC12_TDN0: length 157.2
  TOP w0.147: v4(168.55,149.39) 168.55,149.34 U1.BC62
  SIG6 w0.112: v4(168.55,149.39) 168.55,149.62 arc(168.51,149.71) 168.42,149.74 168.25,149.74 arc(168.02,149.84) 167.92,150.07 167.92,150.56 arc(167.91,150.61) 167.89,150.65 167.83,150.71 arc(167.79,150.73) 167.75,150.74 163.36,150.74 163.27,150.65 163.24,150.65
  SIG6 w0.16: 163.24,150.65 162.55,150.65 arc(162.47,150.64) 162.39,150.62 arc(162.33,150.58) 162.28,150.53 160.72,148.98 arc(160.35,148.73) 159.91,148.65 152.81,148.65 arc(152.66,148.62) 152.54,148.53 127.8,123.79 arc(127.63,123.54) 127.57,123.25 127.57,109.38 arc(127.51,109.09) 127.35,108.84 114.11,95.6 arc(113.86,95.44) 113.57,95.38 110.08,95.38 arc(109.93,95.35) 109.81,95.27 93.27,78.72 arc(93.18,78.6) 93.15,78.45 93.15,76.46 arc(93.1,76.16) 92.93,75.92 91.46,74.44 90.46,73.45 90.46,73.11 90.15,72.8 89.81,72.8 89.47,72.46 89.47,72.1 89.18,71.81 88.82,71.81 88.48,71.47 arc(88.23,71.3) 87.94,71.24 86.25,71.24 86.03,71.02 85.55,71.02 85.33,71.24 84.71,71.24 84.49,71.02 84.01,71.02 83.78,71.24 83.3,71.24 arc(83.16,71.22) 83.04,71.13 80.51,68.61 arc(80.43,68.49) 80.4,68.34 80.4,61.44 arc(80.46,61.14) 80.63,60.9 81.91,59.62 arc(82.15,59.45) 82.44,59.39 91.59,59.39 arc(91.88,59.34) 92.13,59.17 arc(92.47,58.94) 92.88,58.86 93.66,58.86 arc(93.9,58.76) 94,58.52 94,58.34 arc(93.96,58.14) 93.85,57.97 YJ24.B34
FC12_TDN1: length 169.2
  TOP w0.147: U1.BD64 167,149.84 arc(166.68,149.97) v4(166.55,150.29)
  SIG7 w0.112: v4(166.55,150.29) 166.55,150.09 arc(166.54,150.04) 166.51,150 166.49,149.98 arc(166.45,149.95) 166.4,149.94 166.26,149.94 arc(166.16,149.98) 166.12,150.08 166.12,150.52 arc(166.09,150.67) 166,150.8 165.98,150.82 arc(165.86,150.9) 165.71,150.93 164.39,150.93 arc(164.35,150.94) 164.31,150.97 164.27,151.01 arc(164.16,151.08) 164.04,151.1 163.73,151.1 163.64,151.19 163.61,151.19
  SIG7 w0.16: YJ24.B3 95.3,52.73 arc(95.24,53.01) 95.08,53.25 94.75,53.58 arc(94.57,53.85) 94.51,54.16 94.51,54.48 arc(94.51,54.53) 94.5,54.58 arc(94.5,54.59) 94.49,54.6 arc(94.45,54.7) 94.39,54.77 94.35,54.82 94.26,54.9 arc(94.14,54.98) 93.99,55.01 82.43,55.01 arc(82.14,55.07) 81.89,55.24 78.93,58.2 arc(78.76,58.45) 78.7,58.74 78.7,70.12 arc(78.76,70.42) 78.93,70.66 79.45,71.19 arc(79.54,71.31) 79.57,71.46 79.57,81.25 arc(79.62,81.54) 79.79,81.79 82.23,84.23 arc(82.48,84.39) 82.77,84.45 92.08,84.45 arc(92.22,84.48) 92.35,84.56 105.38,97.6 arc(105.63,97.76) 105.92,97.82 112.69,97.82 arc(112.83,97.85) 112.96,97.93 124.92,109.9 arc(125,110.02) 125.03,110.17 125.03,124.22 arc(125.09,124.52) 125.26,124.76 151.46,150.97 arc(151.71,151.13) 152,151.19 163.61,151.19
FC12_TDN2: length 154.5
  TOP w0.147: U1.BC66 164.55,149.34 v4(164.55,149.39)
  SIG7 w0.112: 163.17,148.71 163.2,148.71 163.29,148.8 163.67,148.8 arc(163.76,148.81) 163.85,148.85 arc(163.88,148.87) 163.9,148.9 163.98,148.98 arc(164.08,149.12) 164.11,149.29 164.11,149.62 arc(164.15,149.71) 164.24,149.74 164.38,149.74 arc(164.5,149.7) 164.55,149.58 v4(164.55,149.39)
  SIG7 w0.16: YJ24.B37 96.25,57.97 arc(96.36,58.14) 96.4,58.34 96.4,58.52 arc(96.3,58.76) 96.06,58.86 95.16,58.86 arc(94.86,58.92) 94.62,59.08 94.53,59.17 arc(94.28,59.34) 93.99,59.39 82.62,59.39 arc(82.48,59.42) 82.35,59.51 80.51,61.35 arc(80.43,61.47) 80.4,61.61 80.4,68.37 arc(80.43,68.51) 80.51,68.64 82.55,70.67 82.77,70.67 83.1,71 83.1,71.23 83.43,71.55 83.66,71.55 83.99,71.88 83.99,72.11 84.46,72.58 arc(84.61,72.68) 84.79,72.72 85.07,72.72 85.25,72.54 85.71,72.54 85.89,72.72 86.36,72.72 86.53,72.54 87,72.54 87.18,72.72 87.67,72.72 arc(88.11,72.81) 88.49,73.06 88.78,73.35 88.89,73.35 88.98,73.35 89.34,73.7 89.34,73.9 89.61,74.18 arc(89.74,74.26) 89.88,74.29 90.96,74.29 arc(91.26,74.35) 91.5,74.52 91.92,74.93 92.07,74.93 92.5,75.36 92.5,75.51 92.93,75.94 arc(93.1,76.19) 93.15,76.48 93.15,78.45 arc(93.18,78.6) 93.27,78.72 109.81,95.27 arc(109.93,95.35) 110.08,95.38 113.54,95.38 arc(113.83,95.43) 114.08,95.6 127.35,108.87 arc(127.51,109.11) 127.57,109.41 127.57,123.39 arc(127.6,123.53) 127.68,123.65 152.63,148.6 arc(152.75,148.68) 152.9,148.71 163.17,148.71
FC12_TDN3: length 168.4
  TOP w0.147: U1.BF63 168,151.84 arc(167.68,151.97) v4(167.55,152.29)
  SIG6 w0.112: v4(167.55,152.29) 167.55,152.07 arc(167.51,151.98) 167.42,151.94 167.25,151.94 arc(167.16,151.98) 167.12,152.07 167.12,152.56 arc(167.09,152.69) 167.02,152.79 166.97,152.84 arc(166.87,152.91) 166.74,152.94 163.4,152.94 163.31,153.03 163.28,153.03
  SIG6 w0.16: YJ24.B6 92.9,52.78 arc(92.85,53.02) 92.72,53.21 92.35,53.58 arc(92.17,53.85) 92.11,54.16 92.11,54.48 arc(92.11,54.53) 92.1,54.58 arc(92.06,54.69) 91.99,54.77 91.95,54.82 91.86,54.9 arc(91.74,54.98) 91.59,55.01 82.51,55.01 arc(82.07,55.1) 81.7,55.35 79.04,58.01 arc(78.79,58.38) 78.7,58.82 78.7,71.15 arc(78.79,71.59) 79.04,71.96 79.45,72.38 arc(79.54,72.5) 79.57,72.65 79.57,80.94 arc(79.65,81.37) 79.9,81.74 82.27,84.12 arc(82.64,84.37) 83.08,84.45 92.1,84.45 arc(92.25,84.48) 92.37,84.56 105.3,97.49 arc(105.67,97.74) 106.1,97.82 112.71,97.82 arc(112.86,97.85) 112.98,97.93 124.92,109.87 arc(125,110) 125.03,110.14 125.03,124.27 arc(125.09,124.56) 125.26,124.81 126.94,126.49 151.36,150.91 arc(151.61,151.08) 151.9,151.14 158.64,151.14 arc(158.78,151.17) 158.91,151.25 160.35,152.7 arc(160.72,152.94) 161.16,153.03 163.28,153.03
FC12_TDP0: length 157.2
  TOP w0.147: v4(168.55,150.29) 168.6,150.29 arc(168.92,150.16) U1.BD62
  SIG6 w0.112: 163.24,151.03 163.27,151.03 163.36,150.94 167.75,150.94 arc(167.87,150.91) 167.97,150.85 168.02,150.79 arc(168.09,150.68) 168.12,150.56 168.12,150.07 arc(168.16,149.98) 168.25,149.94 168.42,149.94 arc(168.51,149.98) 168.55,150.07 v4(168.55,150.29)
  SIG6 w0.16: YJ24.B33 92.9,56.79 arc(92.85,57.02) 92.72,57.21 92.51,57.43 92.35,57.58 arc(92.17,57.85) 92.11,58.16 92.11,58.48 arc(92.11,58.53) 92.1,58.57 arc(92.1,58.59) 92.09,58.6 arc(92.05,58.69) 91.99,58.77 91.95,58.82 91.86,58.9 arc(91.74,58.98) 91.59,59.01 82.44,59.01 arc(82.01,59.1) 81.64,59.35 80.36,60.63 arc(80.11,61) 80.02,61.44 80.02,68.34 arc(80.08,68.63) 80.25,68.88 82.77,71.4 arc(83.01,71.57) 83.3,71.63 87.94,71.63 arc(88.09,71.65) 88.21,71.74 92.66,76.19 arc(92.74,76.31) 92.77,76.46 92.77,78.45 arc(92.83,78.74) 93,78.99 109.54,95.53 arc(109.79,95.7) 110.08,95.76 113.57,95.76 arc(113.71,95.79) 113.84,95.87 127.08,109.11 arc(127.16,109.23) 127.19,109.38 127.19,123.25 arc(127.28,123.69) 127.53,124.06 152.27,148.8 arc(152.52,148.97) 152.81,149.03 159.91,149.03 arc(160.2,149.08) 160.45,149.25 162.01,150.8 arc(162.12,150.9) 162.24,150.97 arc(162.39,151.01) 162.54,151.03 163.24,151.03
FC12_TDP1: length 169.2
  TOP w0.147: U1.BC64 166.55,149.34 v4(166.55,149.39)
  SIG7 w0.112: 163.61,150.81 163.64,150.81 163.73,150.9 164.04,150.9 arc(164.09,150.89) 164.13,150.87 164.17,150.83 arc(164.27,150.76) 164.39,150.74 165.71,150.74 arc(165.78,150.72) 165.85,150.68 165.86,150.66 arc(165.91,150.6) 165.92,150.52 165.92,150.08 arc(166.02,149.84) 166.26,149.74 166.38,149.74 arc(166.5,149.7) 166.55,149.58 v4(166.55,149.39)
  SIG7 w0.16: 163.61,150.81 152,150.81 arc(151.85,150.78) 151.73,150.7 125.52,124.49 arc(125.44,124.37) 125.41,124.22 125.41,110.17 arc(125.35,109.88) 125.19,109.63 113.23,97.67 arc(112.98,97.5) 112.69,97.44 105.92,97.44 arc(105.78,97.41) 105.65,97.33 92.62,84.29 arc(92.37,84.13) 92.08,84.07 82.77,84.07 arc(82.63,84.04) 82.5,83.96 80.06,81.52 arc(79.98,81.39) 79.95,81.25 79.95,79.84 80.07,79.72 80.07,79.15 79.95,79.02 79.95,78.56 80.1,78.41 80.1,77.9 79.95,77.74 79.95,77.28 80.1,77.13 80.1,76.61 79.95,76.46 79.95,75.99 80.1,75.84 80.1,75.33 79.95,75.17 79.95,74.71 80.12,74.53 80.12,74.07 79.95,73.89 79.95,73.42 80.12,73.25 80.12,72.78 79.95,72.6 79.95,71.46 arc(79.89,71.17) 79.72,70.92 79.2,70.39 arc(79.11,70.27) 79.08,70.12 79.08,58.74 arc(79.11,58.6) 79.2,58.47 82.16,55.51 arc(82.29,55.42) 82.43,55.39 93.99,55.39 arc(94.28,55.34) 94.53,55.17 arc(94.87,54.94) 95.28,54.86 96.06,54.86 arc(96.3,54.76) 96.4,54.52 96.4,54.34 arc(96.36,54.14) 96.25,53.97 YJ24.B2
FC12_TDP2: length 154.5
  TOP w0.147: U1.BD66 165,149.84 arc(164.68,149.97) v4(164.55,150.29)
  SIG7 w0.112: v4(164.55,150.29) 164.55,150.1 arc(164.5,149.99) 164.38,149.94 164.24,149.94 arc(164.01,149.85) 163.92,149.62 163.92,149.29 arc(163.9,149.2) 163.84,149.12 163.76,149.04 arc(163.75,149.03) 163.74,149.02 arc(163.71,149) 163.67,149 163.29,149 163.2,149.09 163.17,149.09
  SIG7 w0.16: 163.17,149.09 152.9,149.09 arc(152.6,149.03) 152.36,148.87 127.41,123.92 arc(127.25,123.68) 127.19,123.39 127.19,109.41 arc(127.16,109.26) 127.08,109.14 113.81,95.87 arc(113.69,95.79) 113.54,95.76 110.08,95.76 arc(109.79,95.7) 109.54,95.53 93,78.99 arc(92.83,78.74) 92.77,78.45 92.77,76.48 arc(92.74,76.34) 92.66,76.21 91.23,74.79 arc(91.11,74.7) 90.96,74.67 89.88,74.67 arc(89.59,74.62) 89.34,74.45 88.66,73.76 88.22,73.33 arc(87.97,73.16) 87.67,73.1 84.79,73.1 arc(84.46,73.03) 84.19,72.85 80.25,68.91 arc(80.08,68.66) 80.02,68.37 80.02,61.61 arc(80.08,61.32) 80.25,61.08 82.08,59.24 arc(82.33,59.07) 82.62,59.01 93.99,59.01 arc(94.14,58.98) 94.26,58.9 94.35,58.82 94.39,58.77 arc(94.46,58.69) 94.5,58.58 arc(94.51,58.53) 94.51,58.48 94.51,58.16 arc(94.57,57.85) 94.75,57.58 95.09,57.25 arc(95.25,57.01) 95.3,56.74 YJ24.B36
FC12_TDP3: length 168.4
  TOP w0.147: U1.BE63 167.55,151.34 v4(167.55,151.39)
  SIG6 w0.112: 163.28,152.65 163.31,152.65 163.4,152.74 166.74,152.74 arc(166.79,152.73) 166.83,152.7 166.89,152.65 arc(166.91,152.61) 166.92,152.56 166.92,152.07 arc(167.02,151.84) 167.25,151.74 167.42,151.74 arc(167.51,151.71) 167.55,151.62 v4(167.55,151.39)
  SIG6 w0.16: 163.28,152.65 161.16,152.65 arc(160.87,152.59) 160.62,152.43 160.28,152.09 159.63,151.43 159.63,151.43 159.17,150.98 arc(158.93,150.82) 158.64,150.76 151.9,150.76 arc(151.75,150.73) 151.63,150.65 125.52,124.54 arc(125.44,124.42) 125.41,124.27 125.41,110.14 arc(125.35,109.85) 125.19,109.6 123.76,108.18 113.25,97.67 arc(113,97.5) 112.71,97.44 106.1,97.44 arc(105.81,97.38) 105.57,97.22 92.64,84.29 arc(92.39,84.13) 92.1,84.07 83.08,84.07 arc(82.79,84.01) 82.54,83.85 80.17,81.48 arc(80,81.23) 79.95,80.94 79.95,75.45 80.19,75.2 80.19,74.78 79.95,74.53 79.95,74.05 80.19,73.8 80.19,73.37 79.95,73.13 79.95,72.65 arc(79.89,72.36) 79.72,72.11 79.31,71.69 arc(79.14,71.45) 79.08,71.15 79.08,58.82 arc(79.14,58.53) 79.31,58.28 79.76,57.82 80.08,57.82 80.42,57.48 80.42,57.17 80.76,56.83 81.07,56.83 81.41,56.49 81.41,56.18 81.97,55.62 arc(82.22,55.45) 82.51,55.39 91.59,55.39 arc(91.88,55.34) 92.13,55.17 92.22,55.08 arc(92.46,54.92) 92.76,54.86 93.66,54.86 arc(93.9,54.76) 94,54.52 94,54.34 arc(93.96,54.14) 93.85,53.97 YJ24.B5
FC13_RDN0: length 142.8
  TOP w0.147: U1.BA53 177.55,147.34 v4(177.55,147.39)
  SIG8 w0.112: v4(177.55,147.39) 177.55,147.64 arc(177.52,147.71) 177.45,147.74 177.22,147.74 arc(177.15,147.71) 177.12,147.64 177.12,146.18 arc(177.09,146.01) 176.99,145.87 arc(176.85,145.77) 176.68,145.74 170.32,145.74 arc(170.11,145.7) 169.92,145.58 169.51,145.17 169.17,144.82 arc(169.08,144.76) 168.98,144.74 163.38,144.74 163.28,144.65 163.26,144.65
  SIG8 w0.16: 163.26,144.65 162.79,144.65 arc(162.5,144.59) 162.25,144.43 160.67,142.84 arc(160.42,142.68) 160.13,142.62 152.91,142.62 arc(152.61,142.56) 152.37,142.4 132.11,122.14 arc(131.95,121.89) 131.89,121.6 131.89,108.01 arc(131.8,107.57) 131.55,107.2 115.94,91.58 arc(115.57,91.33) 115.13,91.25 109.28,91.25 arc(108.99,91.19) 108.74,91.02 98.08,80.36 arc(97.91,80.11) 97.85,79.82 97.85,75.53 arc(97.77,75.09) 97.52,74.72 95.27,72.47 arc(94.9,72.22) 94.46,72.13 92.82,72.13 92.6,71.9 92.04,71.9 91.81,72.13 91.3,72.13 91.07,71.9 90.51,71.9 90.28,72.13 89.43,72.13 arc(89.28,72.1) 89.16,72.02 88.64,71.5 88.64,71.17 88.25,70.78 87.92,70.78 87.56,70.42 87.56,70.09 87.17,69.71 86.84,69.71 86.48,69.35 86.48,69.01 86.1,68.63 85.76,68.63 85.4,68.27 arc(85.32,68.14) 85.29,68 85.29,67.1 arc(85.36,66.93) 85.53,66.86 86.3,66.86 arc(86.5,66.82) 86.66,66.71 86.72,66.65 arc(86.78,66.56) 86.8,66.45 86.8,66.34 arc(86.76,66.14) 86.65,65.97 YJ24.A25
FC13_RDN1: length 148.4
  TOP w0.147: v4(173.55,148.29) 173.55,148.22 arc(173.56,148.15) 173.6,148.09 173.71,147.98 arc(173.86,147.88) U1.BB57
  SIG9 w0.112: v4(173.55,148.29) 173.55,148.07 arc(173.54,148.03) 173.52,147.99 173.49,147.97 arc(173.46,147.95) 173.42,147.94 173.22,147.94 arc(173.15,147.97) 173.12,148.04 173.12,148.5 arc(173.09,148.66) 173,148.81 arc(172.86,148.9) 172.69,148.93 163.59,148.93 arc(163.53,148.94) 163.48,148.98 163.47,148.99 arc(163.43,149.02) 163.39,149.02 163.33,149.02
  SIG9 w0.16: 163.33,149.02 163,149.02 arc(162.56,148.94) 162.19,148.69 160.54,147.04 158.89,145.4 arc(158.77,145.31) 158.63,145.29 152.25,145.29 arc(151.81,145.2) 151.44,144.95 129.68,123.2 arc(129.44,122.83) 129.35,122.39 129.35,108.62 arc(129.32,108.47) 129.24,108.35 123.76,102.87 114.69,93.8 arc(114.57,93.72) 114.42,93.69 108.19,93.69 arc(107.75,93.61) 107.38,93.36 95.39,81.37 arc(95.15,81) 95.06,80.56 95.06,76.01 arc(95,75.71) 94.84,75.47 91.17,71.8 arc(90.92,71.63) 90.63,71.57 88.27,71.57 arc(88.13,71.56) 88,71.52 87.7,71.4 arc(87.56,71.36) 87.42,71.35 83.41,71.35 arc(82.97,71.26) 82.6,71.01 81,69.41 arc(80.76,69.04) 80.67,68.6 80.67,67.29 arc(80.76,66.86) 81,66.48 81.12,66.37 arc(81.2,66.25) 81.23,66.1 81.23,64.41 arc(81.31,63.97) 81.56,63.6 82.35,62.82 82.39,62.77 arc(82.45,62.69) 82.5,62.59 arc(82.51,62.54) 82.51,62.48 82.51,62.23 82.51,62.16 arc(82.57,61.85) 82.75,61.58 83.1,61.23 arc(83.25,61.01) 83.3,60.76 YJ24.A18
FC13_RDN2: length 150.6
  TOP w0.147: U1.BA55 175.55,147.34 v4(175.55,147.39)
  SIG8 w0.112: v4(175.55,147.39) 175.55,147.64 arc(175.52,147.71) 175.45,147.74 175.22,147.74 arc(175.15,147.71) 175.12,147.64 175.12,147.05 arc(175.03,146.84) 174.82,146.75 163.35,146.75 163.26,146.66
  SIG8 w0.16: YJ24.A14 86.65,61.97 arc(86.76,62.14) 86.8,62.35 86.8,62.54 arc(86.78,62.65) 86.72,62.74 arc(86.59,62.83) 86.44,62.86 85.54,62.86 arc(85.26,62.92) 85.03,63.08 84.93,63.17 arc(84.68,63.34) 84.39,63.39 82.82,63.39 arc(82.52,63.45) 82.28,63.62 81.86,64.04 arc(81.69,64.28) 81.64,64.57 81.64,68.12 arc(81.66,68.27) 81.75,68.39 82.11,68.75 82.44,68.75 82.82,69.13 82.82,69.47 83.18,69.83 83.52,69.83 83.9,70.21 83.9,70.55 84.26,70.91 84.59,70.91 84.98,71.29 84.98,71.62 85.34,71.98 85.66,71.98 86.06,72.38 86.06,72.7 87.54,74.18 arc(87.66,74.26) 87.81,74.29 93.32,74.29 arc(93.75,74.38) 94.12,74.63 95.11,75.61 arc(95.35,75.98) 95.44,76.42 95.44,80.58 95.44,80.58 arc(95.5,80.87) 95.66,81.12 107.63,93.09 arc(107.88,93.25) 108.17,93.31 114.27,93.31 arc(114.71,93.4) 115.08,93.65 129.4,107.96 arc(129.64,108.33) 129.73,108.77 129.73,122.41 arc(129.79,122.71) 129.95,122.95 151.68,144.68 arc(151.93,144.85) 152.22,144.9 159.44,144.9 arc(159.73,144.96) 159.98,145.13 161.28,146.44 arc(161.53,146.6) 161.82,146.66 163.26,146.66
FC13_RDN3: length 140.5
  TOP w0.147: v4(171.55,148.29) 171.55,148.22 arc(171.56,148.15) 171.6,148.09 171.71,147.98 arc(171.86,147.88) U1.BB59
  SIG9 w0.112: 163.23,147.05 163.34,146.94 170.75,146.94 arc(170.82,146.95) 170.87,146.99 arc(170.91,147.05) 170.93,147.12 170.93,147.64 arc(171.01,147.85) 171.22,147.94 171.42,147.94 arc(171.46,147.95) 171.51,147.98 171.51,147.98 arc(171.54,148.02) 171.55,148.07 v4(171.55,148.29)
  SIG9 w0.16: YJ24.A21 83.3,64.77 arc(83.25,65.01) 83.12,65.22 82.75,65.58 arc(82.57,65.85) 82.51,66.16 82.51,66.29 82.51,66.48 arc(82.51,66.53) 82.5,66.59 arc(82.46,66.69) 82.39,66.77 82.35,66.82 82.17,66.99 arc(82.04,67.19) 81.99,67.43 81.99,67.5 arc(82.08,67.94) 82.32,68.31 82.83,68.81 arc(83.07,68.98) 83.37,69.03 91.61,69.03 arc(91.91,69.09) 92.15,69.26 94.65,71.75 97.36,74.47 arc(97.44,74.59) 97.47,74.74 97.47,79.82 arc(97.56,80.26) 97.81,80.63 108.47,91.29 arc(108.84,91.54) 109.28,91.63 115.29,91.63 arc(115.43,91.66) 115.56,91.74 123.76,99.95 131.4,107.58 arc(131.48,107.71) 131.51,107.85 131.51,121.6 arc(131.6,122.04) 131.84,122.41 152.1,142.66 arc(152.47,142.91) 152.91,143 160.12,143 arc(160.24,143.01) 160.35,143.04 160.65,143.23 arc(160.68,143.25) 160.71,143.28 161.2,143.77 arc(161.23,143.8) 161.25,143.83 161.44,144.13 arc(161.47,144.24) 161.48,144.36 161.48,145.35 arc(161.57,145.79) 161.82,146.16 162.37,146.71 arc(162.74,146.96) 163.18,147.05 163.23,147.05
FC13_RDP0: length 142.8
  TOP w0.147: U1.BB53 177.94,147.84 arc(177.83,147.86) 177.74,147.92 177.67,147.99 arc(177.58,148.13) v4(177.55,148.29)
  SIG8 w0.112: 163.26,145.03 163.28,145.03 163.38,144.94 168.87,144.94 arc(169,144.96) 169.1,145.03 169.51,145.45 169.79,145.72 arc(170.03,145.88) 170.32,145.94 176.68,145.94 arc(176.77,145.96) 176.85,146.01 arc(176.9,146.09) 176.92,146.18 176.92,147.64 arc(177.01,147.85) 177.22,147.94 177.45,147.94 arc(177.52,147.97) 177.55,148.04 v4(177.55,148.29)
  SIG8 w0.16: YJ24.A24 85.7,64.87 arc(85.67,65.02) 85.58,65.15 85.05,65.68 arc(84.95,65.84) 84.91,66.02 84.91,66.29 84.91,66.42 84.91,68 arc(84.97,68.29) 85.13,68.54 88.89,72.29 arc(89.13,72.46) 89.43,72.51 94.46,72.51 arc(94.75,72.57) 95,72.74 97.25,74.99 arc(97.41,75.24) 97.47,75.53 97.47,79.82 arc(97.56,80.26) 97.81,80.63 108.47,91.29 arc(108.84,91.54) 109.28,91.63 115.13,91.63 arc(115.42,91.69) 115.67,91.85 131.29,107.47 arc(131.45,107.72) 131.51,108.01 131.51,121.6 arc(131.6,122.04) 131.84,122.41 152.1,142.66 arc(152.47,142.91) 152.91,143 160.13,143 arc(160.28,143.03) 160.4,143.11 161.98,144.7 arc(162.35,144.94) 162.79,145.03 163.26,145.03
FC13_RDP1: length 148.4
  TOP w0.147: v4(173.55,147.39) 173.55,147.34 U1.BA57
  SIG9 w0.112: v4(173.55,147.39) 173.55,147.61 arc(173.54,147.66) 173.51,147.7 173.51,147.71 arc(173.46,147.73) 173.42,147.74 173.22,147.74 arc(173.01,147.83) 172.93,148.04 172.93,148.5 arc(172.91,148.59) 172.86,148.67 arc(172.78,148.72) 172.69,148.74 163.59,148.74 arc(163.53,148.72) 163.48,148.69 163.47,148.68 arc(163.43,148.65) 163.39,148.64 163.33,148.64
  SIG9 w0.16: 163.33,148.64 163,148.64 arc(162.7,148.59) 162.46,148.42 159.16,145.13 arc(158.92,144.96) 158.63,144.9 152.25,144.9 arc(151.95,144.85) 151.71,144.68 129.95,122.93 arc(129.79,122.68) 129.73,122.39 129.73,108.62 arc(129.67,108.33) 129.51,108.08 123.76,102.33 114.96,93.54 arc(114.72,93.37) 114.42,93.31 108.19,93.31 arc(107.9,93.25) 107.65,93.09 95.66,81.1 arc(95.5,80.85) 95.44,80.56 95.44,80.56 95.44,76.01 arc(95.35,75.57) 95.11,75.2 92.52,72.61 92.52,72.25 92.16,71.89 91.8,71.89 91.44,71.53 arc(91.07,71.28) 90.63,71.19 89.8,71.19 89.57,70.97 89.01,70.97 88.78,71.19 88.27,71.19 arc(88.2,71.19) 88.14,71.17 87.85,71.05 arc(87.64,70.99) 87.42,70.97 86.42,70.97 86.2,70.74 85.64,70.74 85.41,70.97 84.9,70.97 84.67,70.74 84.11,70.74 83.88,70.97 83.41,70.97 arc(83.12,70.91) 82.87,70.74 81.27,69.14 arc(81.11,68.89) 81.05,68.6 81.05,67.29 arc(81.11,67) 81.27,66.75 81.38,66.64 arc(81.55,66.39) 81.61,66.1 81.61,64.41 arc(81.67,64.12) 81.83,63.87 82.52,63.19 arc(82.88,62.95) 83.3,62.86 84.06,62.86 arc(84.3,62.76) 84.4,62.52 84.4,62.34 arc(84.36,62.14) 84.25,61.97 YJ24.A17
FC13_RDP2: length 150.6
  TOP w0.147: U1.BB55 175.94,147.84 arc(175.83,147.86) 175.74,147.92 175.67,147.99 arc(175.58,148.13) v4(175.55,148.29)
  SIG8 w0.112: 163.26,147.04 163.35,146.95 174.82,146.95 arc(174.89,146.98) 174.92,147.05 174.92,147.64 arc(175.01,147.85) 175.22,147.94 175.45,147.94 arc(175.52,147.97) 175.55,148.04 v4(175.55,148.29)
  SIG8 w0.16: 163.26,147.04 161.82,147.04 arc(161.39,146.95) 161.02,146.71 159.71,145.4 arc(159.58,145.31) 159.44,145.29 152.22,145.29 arc(151.78,145.2) 151.41,144.95 129.68,123.22 arc(129.44,122.85) 129.35,122.41 129.35,108.77 arc(129.29,108.48) 129.13,108.23 114.81,93.92 arc(114.56,93.75) 114.27,93.69 108.17,93.69 arc(107.73,93.61) 107.36,93.36 95.39,81.39 arc(95.15,81.02) 95.06,80.58 95.06,76.42 arc(95,76.13) 94.84,75.88 93.86,74.9 arc(93.61,74.73) 93.32,74.67 87.81,74.67 arc(87.51,74.62) 87.27,74.45 81.48,68.66 arc(81.31,68.41) 81.25,68.12 81.25,64.57 arc(81.34,64.14) 81.59,63.77 82.01,63.35 arc(82.38,63.1) 82.82,63.01 84.39,63.01 arc(84.54,62.98) 84.66,62.9 84.75,62.82 84.76,62.81 84.79,62.77 arc(84.84,62.71) 84.88,62.64 arc(84.88,62.63) 84.88,62.63 arc(84.89,62.62) 84.89,62.61 arc(84.89,62.61) 84.89,62.61 arc(84.89,62.61) 84.89,62.6 arc(84.91,62.54) 84.91,62.48 84.91,62.07 arc(84.96,61.84) 85.09,61.65 85.33,61.41 85.45,61.29 arc(85.47,61.27) 85.49,61.24 arc(85.49,61.24) 85.49,61.24 arc(85.5,61.22) 85.51,61.21 arc(85.65,60.96) 85.7,60.68 YJ24.A15
FC13_RDP3: length 140.5
  TOP w0.147: U1.BA59 171.55,147.34 v4(171.55,147.39)
  SIG9 w0.112: 163.23,146.67 163.31,146.74 170.75,146.74 arc(170.89,146.77) 171.01,146.85 arc(171.09,146.97) 171.12,147.12 171.12,147.64 arc(171.15,147.71) 171.22,147.74 171.42,147.74 arc(171.46,147.74) 171.49,147.71 171.52,147.69 arc(171.54,147.66) 171.55,147.62 v4(171.55,147.39)
  SIG9 w0.16: 163.23,146.67 163.18,146.67 arc(162.89,146.61) 162.64,146.44 162.09,145.89 arc(161.92,145.64) 161.86,145.35 161.86,144.36 arc(161.84,144.16) 161.79,143.96 161.57,143.62 arc(161.52,143.56) 161.47,143.5 160.98,143.01 arc(160.92,142.96) 160.86,142.91 160.52,142.69 arc(160.32,142.64) 160.12,142.62 152.91,142.62 arc(152.61,142.56) 152.37,142.4 132.11,122.14 arc(131.95,121.89) 131.89,121.6 131.89,107.85 arc(131.83,107.56) 131.67,107.31 123.76,99.41 115.82,91.47 arc(115.58,91.3) 115.29,91.25 109.28,91.25 arc(108.99,91.19) 108.74,91.02 98.08,80.36 arc(97.91,80.11) 97.85,79.82 97.85,74.73 arc(97.8,74.44) 97.63,74.2 95.19,71.75 92.42,68.99 arc(92.05,68.74) 91.61,68.65 90.6,68.65 90.38,68.43 89.82,68.43 89.59,68.65 89.08,68.65 88.85,68.43 88.29,68.43 88.06,68.65 87.56,68.65 87.33,68.43 86.77,68.43 86.54,68.65 86.03,68.65 85.78,68.4 85.27,68.4 85.02,68.65 83.37,68.65 arc(83.22,68.62) 83.1,68.54 82.59,68.04 arc(82.43,67.79) 82.37,67.5 82.37,67.43 arc(82.39,67.34) 82.44,67.26 82.62,67.08 arc(82.86,66.92) 83.16,66.86 84.06,66.86 arc(84.3,66.76) 84.4,66.52 84.4,66.34 arc(84.36,66.14) 84.25,65.97 YJ24.A22
FC13_TDN0: length 147.7
  TOP w0.147: U1.BB65 166,147.84 arc(165.68,147.97) v4(165.55,148.29)
  SIG7 w0.112: 163.15,147.09 163.18,147.09 163.27,147 164.71,147 arc(164.78,147.01) 164.85,147.06 164.86,147.08 arc(164.91,147.14) 164.92,147.21 164.92,147.62 arc(165.02,147.85) 165.25,147.94 165.38,147.94 arc(165.5,147.99) 165.55,148.1 v4(165.55,148.29)
  SIG7 w0.16: YJ24.A3 95.3,60.74 arc(95.25,61.01) 95.09,61.25 94.75,61.58 arc(94.57,61.85) 94.51,62.16 94.51,62.48 arc(94.51,62.53) 94.5,62.58 arc(94.46,62.69) 94.39,62.77 94.35,62.82 94.26,62.9 arc(94.14,62.98) 93.99,63.01 82.69,63.01 arc(82.4,63.07) 82.15,63.24 81.56,63.82 arc(81.4,64.07) 81.34,64.36 81.34,66.64 arc(81.4,66.93) 81.56,67.18 83.12,68.74 arc(83.37,68.9) 83.66,68.96 86.74,68.96 arc(86.98,69.01) 87.19,69.14 89.8,71.75 90.21,72.16 arc(90.6,72.42) 91.06,72.51 91.98,72.51 arc(92.13,72.54) 92.25,72.63 94.95,75.32 arc(95.03,75.45) 95.06,75.59 95.06,77.56 arc(95.12,77.86) 95.28,78.1 110.65,93.47 arc(110.9,93.63) 111.19,93.69 114.4,93.69 arc(114.54,93.72) 114.67,93.8 129.24,108.37 arc(129.32,108.5) 129.35,108.64 129.35,122.52 arc(129.41,122.81) 129.57,123.06 151.57,145.06 arc(151.82,145.23) 152.11,145.29 159.26,145.29 arc(159.41,145.31) 159.53,145.4 161,146.87 arc(161.25,147.03) 161.54,147.09 163.15,147.09
