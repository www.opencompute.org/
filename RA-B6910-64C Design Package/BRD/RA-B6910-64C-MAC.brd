# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC45_RDN2: length 105.6
  TOP w0.147: v4(220.55,129.29) 220.55,129.34 U1.AD11
  SIG8 w0.112: v4(220.55,129.29) 220.55,129.04 arc(220.58,128.97) 220.65,128.94 220.87,128.94 arc(220.99,128.92) 221.09,128.85 arc(221.16,128.75) 221.18,128.63 221.18,128.25 arc(221.2,128.16) 221.25,128.08 221.29,128.05 arc(221.4,127.97) 221.54,127.94 231.93,127.94 232.01,128.03
  SIG8 w0.16: YJ32.A17 272.32,62.04 arc(272.38,62.13) 272.4,62.24 272.4,62.45 arc(272.38,62.56) 272.32,62.65 272.22,62.76 arc(272.1,62.83) 271.96,62.86 270.96,62.86 arc(270.85,62.88) 270.75,62.95 270.53,63.17 arc(270.28,63.34) 269.99,63.4 arc(269.94,63.4) 269.9,63.43 269.84,63.49 arc(269.8,63.55) 269.79,63.61 269.79,68.26 arc(269.73,68.55) 269.57,68.8 268.13,70.23 arc(267.96,70.48) 267.91,70.77 267.91,104.58 arc(267.82,105.02) 267.57,105.39 243.96,129 arc(243.59,129.25) 243.16,129.33 234.14,129.33 arc(233.73,129.26) 233.38,129.05 arc(233.35,129.02) 233.33,129 232.42,128.1 arc(232.35,128.05) 232.26,128.03 232.01,128.03
FC45_RDN3: length 101.2
  TOP w0.147: v4(224.55,128.39) 224.55,128.48 arc(224.53,128.56) 224.49,128.62 224.41,128.7 arc(224.25,128.81) 224.07,128.84 U1.AC7
  SIG9 w0.112: 232.04,129.65 232.03,129.67 arc(231.94,129.73) 231.84,129.75 225.54,129.75 arc(225.4,129.72) 225.29,129.64 225.25,129.61 arc(225.2,129.53) 225.18,129.44 225.18,129.06 arc(225.16,128.94) 225.09,128.84 arc(224.99,128.77) 224.87,128.74 224.65,128.74 arc(224.58,128.71) 224.55,128.64 v4(224.55,128.39)
  SIG9 w0.16: 232.04,129.65 232.53,129.65 arc(232.82,129.71) 233.07,129.88 234.09,130.9 arc(234.34,131.07) 234.63,131.12 244.19,131.12 arc(244.34,131.09) 244.46,131.01 253.81,121.66 269.5,105.98 arc(269.58,105.85) 269.61,105.71 269.61,72.78 arc(269.67,72.49) 269.83,72.24 270.07,72.01 270.07,71.62 270.44,71.24 270.83,71.24 271.13,70.94 271.13,70.63 271.54,70.23 271.84,70.23 272.03,70.05 arc(272.19,69.8) 272.25,69.51 272.25,67.79 arc(272.34,67.35) 272.58,66.98 272.75,66.82 272.79,66.77 arc(272.85,66.7) 272.89,66.61 arc(272.89,66.6) 272.9,66.59 arc(272.91,66.54) 272.91,66.48 272.91,66.07 arc(272.96,65.84) 273.09,65.65 273.58,65.16 arc(273.67,65.02) 273.7,64.86 YJ32.A24
FC45_RDP0: length 106
  TOP w0.147: v4(218.55,128.39) 218.55,128.48 arc(218.53,128.56) 218.49,128.63 218.41,128.71 arc(218.26,128.81) 218.09,128.84 U1.AC13
  SIG8 w0.112: 233.18,131.13 233.1,131.21 232.51,131.21 arc(232.32,131.18) 232.15,131.07 230.98,129.89 arc(230.81,129.78) 230.62,129.74 219.54,129.74 arc(219.4,129.71) 219.29,129.64 219.25,129.6 arc(219.2,129.52) 219.18,129.43 219.18,129.06 arc(219.16,128.94) 219.09,128.84 arc(218.99,128.77) 218.87,128.74 218.65,128.74 arc(218.58,128.71) 218.55,128.64 v4(218.55,128.39)
  SIG8 w0.16: 233.18,131.13 244.03,131.13 arc(244.32,131.07) 244.57,130.9 269.39,106.09 arc(269.55,105.84) 269.61,105.55 269.61,73.13 269.35,72.88 269.35,72.37 269.61,72.12 269.61,71.61 arc(269.7,71.17) 269.94,70.8 270.22,70.53 arc(270.43,70.2) 270.51,69.82 270.51,66.09 arc(270.56,65.84) 270.7,65.64 270.74,65.59 271.06,65.28 arc(271.24,65.01) 271.3,64.69 YJ32.A21
FC45_RDP1: length 106.1
  TOP w0.147: v4(222.55,129.29) 222.55,129.34 U1.AD9
  SIG9 w0.112: v4(222.55,129.29) 222.55,129.04 arc(222.58,128.97) 222.65,128.94 222.87,128.94 arc(222.99,128.92) 223.09,128.85 arc(223.16,128.75) 223.18,128.63 223.18,128.25 arc(223.2,128.15) 223.25,128.07 223.29,128.04 arc(223.4,127.96) 223.54,127.94 227.88,127.94 227.88,127.93 231.84,127.93 arc(231.94,127.95) 232.03,128.01 232.04,128.03 232.07,128.03
  SIG9 w0.16: YJ32.A14 274.65,61.97 arc(274.76,62.14) 274.8,62.34 274.8,62.52 arc(274.7,62.76) 274.46,62.86 273.43,62.86 arc(273.26,62.9) 273.11,63 272.93,63.17 arc(272.68,63.34) 272.39,63.39 270.97,63.39 arc(270.68,63.45) 270.43,63.62 269.89,64.16 arc(269.72,64.41) 269.66,64.7 269.66,65.57 269.66,65.57 arc(269.72,65.87) 269.89,66.11 270.06,66.29 arc(270.28,66.61) 270.35,66.98 270.35,68 arc(270.26,68.43) 270.02,68.81 268.13,70.69 arc(267.96,70.94) 267.91,71.23 267.91,104.74 arc(267.85,105.03) 267.68,105.28 256.13,116.84 243.85,129.11 arc(243.61,129.28) 243.31,129.33 234.62,129.33 arc(234.18,129.25) 233.81,129 232.95,128.14 arc(232.82,128.05) 232.68,128.03 232.07,128.03
FC45_RDP2: length 105.6
  TOP w0.147: v4(220.55,128.39) 220.55,128.48 arc(220.53,128.56) 220.49,128.63 220.41,128.71 arc(220.26,128.81) 220.09,128.84 U1.AC11
  SIG8 w0.112: 232.01,127.65 231.92,127.75 221.54,127.75 arc(221.33,127.79) 221.15,127.91 221.12,127.94 arc(221.02,128.08) 220.99,128.25 220.99,128.63 arc(220.98,128.67) 220.95,128.71 arc(220.91,128.73) 220.87,128.74 220.65,128.74 arc(220.58,128.71) 220.55,128.64 v4(220.55,128.39)
  SIG8 w0.16: YJ32.A18 271.3,60.66 arc(271.23,61.01) 271.03,61.3 270.69,61.65 arc(270.56,61.84) 270.51,62.07 270.51,62.48 arc(270.5,62.56) 270.48,62.63 arc(270.44,62.71) 270.39,62.77 270.35,62.82 270.26,62.9 arc(270.14,62.98) 269.99,63.01 arc(269.8,63.05) 269.63,63.16 269.57,63.23 arc(269.45,63.4) 269.41,63.61 269.41,68.26 arc(269.38,68.4) 269.3,68.53 267.86,69.96 arc(267.61,70.34) 267.53,70.77 267.53,71.4 267.27,71.65 267.27,72.16 267.53,72.41 267.53,72.92 267.27,73.17 267.27,73.68 267.53,73.94 267.53,104.58 arc(267.47,104.88) 267.3,105.12 243.7,128.73 arc(243.45,128.9) 243.16,128.95 234.14,128.95 arc(233.87,128.9) 233.63,128.76 arc(233.61,128.75) 233.6,128.73 232.69,127.83 arc(232.5,127.69) 232.26,127.65 232.01,127.65
FC45_RDP3: length 101.2
  TOP w0.147: U1.AD7 224.55,129.34 v4(224.55,129.29)
  SIG9 w0.112: v4(224.55,129.29) 224.55,129.04 arc(224.58,128.97) 224.65,128.94 224.87,128.94 arc(224.91,128.95) 224.95,128.97 arc(224.98,129.01) 224.99,129.06 224.99,129.44 arc(225.02,129.6) 225.12,129.75 225.15,129.78 arc(225.33,129.9) 225.54,129.94 231.84,129.94 arc(231.94,129.96) 232.03,130.02 232.04,130.04
  SIG9 w0.16: 232.04,130.04 232.53,130.04 arc(232.67,130.06) 232.8,130.15 233.82,131.17 arc(234.19,131.42) 234.63,131.5 244.19,131.5 arc(244.48,131.45) 244.73,131.28 259.17,116.84 269.77,106.25 arc(269.93,106) 269.99,105.71 269.99,72.78 arc(270.02,72.63) 270.1,72.51 272.3,70.31 arc(272.54,69.94) 272.63,69.51 272.63,67.79 arc(272.69,67.5) 272.85,67.25 272.93,67.17 arc(273.27,66.94) 273.68,66.86 274.46,66.86 arc(274.7,66.76) 274.8,66.52 274.8,66.34 arc(274.76,66.14) 274.65,65.97 YJ32.A25
FC45_TDN0: length 98.3
  TOP w0.147: U1.AC1 230.1,128.84 arc(230.42,128.71) v4(230.55,128.39)
  SIG7 w0.112: v4(230.55,128.39) 230.55,128.5 arc(230.6,128.62) 230.71,128.67 230.83,128.67 arc(230.96,128.69) 231.07,128.76 231.08,128.77 arc(231.15,128.89) 231.18,129.03 231.18,129.34 arc(231.22,129.52) 231.32,129.67 231.42,129.78 231.55,129.78 231.57,129.8
  SIG7 w0.16: YJ32.A33 280.9,64.84 arc(280.87,65.02) 280.77,65.17 280.33,65.6 arc(280.26,65.68) 280.2,65.76 arc(280.13,65.91) 280.11,66.07 280.11,66.48 arc(280.11,66.53) 280.1,66.58 arc(280.06,66.69) 279.99,66.77 279.95,66.82 279.72,67.04 arc(279.35,67.59) 279.22,68.24 279.22,68.7 279.02,68.9 279.02,69.36 279.22,69.56 279.22,70.02 279.08,70.16 279.08,70.75 279.22,70.89 279.22,71.27 279.02,71.47 279.02,71.95 279.22,72.16 279.22,72.59 arc(279.19,72.74) 279.11,72.86 278.79,73.18 278.54,73.18 278.18,73.55 278.18,73.8 277.85,74.12 277.63,74.12 277.24,74.51 277.24,74.73 276.62,75.35 arc(276.38,75.72) 276.29,76.16 276.29,93.68 arc(276.17,94.28) 275.83,94.79 272.31,98.31 arc(271.97,98.82) 271.84,99.43 271.84,103.47 arc(271.81,103.62) 271.73,103.74 244.45,131.03 arc(244.32,131.11) 244.18,131.14 233.34,131.14 arc(232.95,131.06) 232.62,130.84 231.57,129.8
FC45_TDN1: length 108
  TOP w0.147: U1.AD3 228.55,129.34 v4(228.55,129.29)
  SIG6 w0.112: 232.14,128.03 232.11,128.03 232.02,127.94 229.39,127.94 arc(229.31,127.95) 229.24,128 arc(229.2,128.06) 229.18,128.14 229.18,128.58 arc(229.15,128.72) 229.08,128.83 229.07,128.85 arc(228.96,128.92) 228.84,128.94 228.68,128.94 arc(228.59,128.98) 228.55,129.07 v4(228.55,129.29)
  SIG6 w0.16: 232.14,128.03 233.01,128.03 arc(233.16,128.06) 233.28,128.14 234.16,129.02 arc(234.53,129.27) 234.97,129.35 243.14,129.35 arc(243.58,129.27) 243.95,129.02 269.65,103.31 arc(269.9,102.94) 269.99,102.5 269.99,76.84 arc(270.02,76.7) 270.1,76.57 270.87,75.8 arc(271.12,75.43) 271.21,74.99 271.21,68.11 arc(271.15,67.81) 270.99,67.57 269.94,66.53 arc(269.78,66.28) 269.72,65.99 269.72,64.69 arc(269.73,64.59) 269.75,64.5 arc(269.82,64.31) 269.94,64.15 270.48,63.62 arc(270.73,63.45) 271.02,63.39 279.59,63.39 arc(279.88,63.34) 280.13,63.17 280.22,63.08 arc(280.46,62.92) 280.76,62.86 281.66,62.86 arc(281.9,62.76) 282,62.52 282,62.34 arc(281.96,62.14) 281.85,61.97 YJ32.A5
FC45_TDN2: length 103.1
  TOP w0.147: U1.AC5 226.1,128.84 arc(226.42,128.71) v4(226.55,128.39)
  SIG6 w0.112: 231.84,129.65 231.81,129.65 231.72,129.75 227.39,129.75 arc(227.31,129.73) 227.24,129.69 arc(227.2,129.62) 227.18,129.54 227.18,129.11 arc(227.15,128.97) 227.08,128.85 227.07,128.84 arc(226.96,128.77) 226.84,128.74 226.68,128.74 arc(226.59,128.71) 226.55,128.62 v4(226.55,128.39)
  SIG6 w0.16: YJ32.A36 283.3,64.88 arc(283.27,65.02) 283.19,65.14 282.68,65.65 arc(282.56,65.84) 282.51,66.07 282.51,68.29 282.33,68.46 282.33,69.02 282.51,69.2 282.51,69.66 282.33,69.84 282.33,70.39 282.51,70.57 282.51,71.03 arc(282.48,71.17) 282.4,71.3 277.77,75.93 arc(277.52,76.3) 277.43,76.74 277.43,93 arc(277.4,93.15) 277.32,93.27 272.18,98.41 arc(271.93,98.78) 271.84,99.22 271.84,103.47 arc(271.81,103.61) 271.73,103.74 244.43,131.04 arc(244.3,131.13) 244.16,131.15 234.38,131.15 arc(234.09,131.1) 233.84,130.93 232.79,129.88 arc(232.54,129.71) 232.25,129.65 231.84,129.65
FC45_TDN3: length 109.7
  TOP w0.147: v4(229.55,127.29) 229.55,127.34 U1.AB2
  SIG7 w0.112: 232.22,128.4 232.2,128.38 232.2,128.25 232.03,128.08 232,128.05 arc(231.88,127.97) 231.74,127.94 230.44,127.94 arc(230.12,127.8) 229.99,127.48 229.99,127.03 arc(229.97,126.97) 229.94,126.91 229.93,126.9 arc(229.88,126.87) 229.83,126.86 229.69,126.86 arc(229.59,126.91) 229.55,127.01 v4(229.55,127.29)
  SIG7 w0.16: 232.22,128.4 232.84,129.02 arc(233.05,129.19) 233.29,129.31 arc(233.54,129.39) 233.79,129.41 243.31,129.41 arc(243.61,129.35) 243.85,129.19 269.55,103.49 arc(269.84,103.06) 269.94,102.55 269.94,80.04 arc(270,79.75) 270.16,79.5 270.99,78.67 arc(271.15,78.43) 271.21,78.15 271.21,68.91 arc(271.12,68.46) 270.87,68.08 269.94,67.16 arc(269.78,66.91) 269.72,66.62 269.72,64.54 arc(269.78,64.25) 269.94,64 270.33,63.62 arc(270.58,63.45) 270.87,63.39 281.99,63.39 arc(282.28,63.34) 282.53,63.17 282.62,63.08 arc(282.86,62.92) 283.16,62.86 284.06,62.86 arc(284.3,62.76) 284.4,62.52 284.4,62.34 arc(284.36,62.14) 284.25,61.97 YJ32.A2
FC45_TDP0: length 98.3
  TOP w0.147: v4(230.55,129.29) 230.55,129.34 U1.AD1
  SIG7 w0.112: 231.3,130.07 231.28,130.05 231.28,129.92 231.18,129.81 arc(231.04,129.6) 230.99,129.34 230.99,129.03 arc(230.97,128.97) 230.94,128.91 230.93,128.9 arc(230.88,128.87) 230.83,128.86 230.69,128.86 arc(230.59,128.91) 230.55,129.01 v4(230.55,129.29)
  SIG7 w0.16: YJ32.A34 281.85,65.97 arc(281.96,66.14) 282,66.34 282,66.52 arc(281.9,66.76) 281.66,66.86 280.76,66.86 arc(280.46,66.92) 280.22,67.08 279.99,67.31 arc(279.7,67.74) 279.6,68.24 279.6,72.59 arc(279.55,72.88) 279.38,73.13 276.89,75.62 arc(276.73,75.87) 276.67,76.16 276.67,93.68 arc(276.52,94.42) 276.1,95.06 272.58,98.57 arc(272.32,98.97) 272.22,99.43 272.22,103.47 arc(272.17,103.76) 272,104.01 244.72,131.3 arc(244.47,131.46) 244.18,131.52 233.34,131.52 arc(232.8,131.41) 232.35,131.11 231.3,130.07
FC45_TDP1: length 108
  TOP w0.147: U1.AC3 228.1,128.84 arc(228.42,128.71) v4(228.55,128.39)
  SIG6 w0.112: v4(228.55,128.39) 228.55,128.62 arc(228.59,128.71) 228.68,128.74 228.84,128.74 arc(228.88,128.73) 228.93,128.71 228.94,128.69 arc(228.97,128.64) 228.99,128.58 228.99,128.14 arc(229.02,127.99) 229.1,127.86 arc(229.23,127.77) 229.39,127.74 232.02,127.74 232.11,127.65 232.14,127.65
  SIG6 w0.16: 232.14,127.65 233.01,127.65 arc(233.3,127.71) 233.55,127.87 234.43,128.75 arc(234.68,128.91) 234.97,128.97 243.14,128.97 arc(243.43,128.91) 243.68,128.75 269.39,103.04 arc(269.55,102.79) 269.61,102.5 269.61,76.84 arc(269.67,76.55) 269.83,76.3 270.6,75.53 arc(270.77,75.28) 270.83,74.99 270.83,74.34 270.68,74.19 270.68,73.58 270.83,73.43 270.83,72.97 270.7,72.85 270.7,72.18 270.83,72.05 270.83,71.57 270.7,71.44 270.7,70.78 270.83,70.65 270.83,70.17 270.73,70.07 270.73,69.35 270.83,69.25 270.83,68.11 arc(270.8,67.96) 270.72,67.84 269.68,66.8 arc(269.43,66.42) 269.34,65.99 269.34,64.5 arc(269.35,64.45) 269.38,64.4 arc(269.49,64.12) 269.68,63.88 270.21,63.35 arc(270.58,63.1) 271.02,63.01 279.59,63.01 arc(279.74,62.98) 279.86,62.9 279.95,62.82 279.99,62.77 arc(280.06,62.69) 280.1,62.58 arc(280.11,62.53) 280.11,62.48 280.11,62.07 arc(280.13,61.93) 280.18,61.8 arc(280.24,61.71) 280.31,61.62 280.71,61.22 arc(280.85,61.02) 280.9,60.77 YJ32.A6
FC45_TDP2: length 103.1
  TOP w0.147: v4(226.55,129.29) 226.55,129.34 U1.AD5
  SIG6 w0.112: 231.84,130.04 231.81,130.04 231.72,129.94 227.39,129.94 arc(227.23,129.91) 227.1,129.83 arc(227.02,129.7) 226.99,129.54 226.99,129.11 arc(226.97,129.04) 226.94,128.99 226.93,128.98 arc(226.88,128.95) 226.84,128.94 226.68,128.94 arc(226.59,128.98) 226.55,129.07 v4(226.55,129.29)
  SIG6 w0.16: YJ32.A37 284.25,65.97 arc(284.36,66.14) 284.4,66.34 284.4,66.52 arc(284.3,66.76) 284.06,66.86 283.1,66.86 arc(282.95,66.92) 282.89,67.07 282.89,71.03 arc(282.83,71.32) 282.67,71.57 278.04,76.2 arc(277.87,76.45) 277.81,76.74 277.81,93 arc(277.75,93.29) 277.59,93.54 272.45,98.68 arc(272.28,98.93) 272.22,99.22 272.22,103.47 arc(272.17,103.76) 272,104.01 244.7,131.31 arc(244.45,131.48) 244.16,131.54 234.38,131.54 arc(233.94,131.45) 233.57,131.2 232.52,130.15 arc(232.4,130.06) 232.25,130.04 231.84,130.04
FC45_TDP3: length 109.7
  TOP w0.147: U1.AA2 229.1,126.84 arc(229.42,126.71) v4(229.55,126.39)
  SIG7 w0.112: v4(229.55,126.39) 229.55,126.5 arc(229.6,126.62) 229.71,126.67 229.83,126.67 arc(229.96,126.69) 230.07,126.76 230.08,126.77 arc(230.15,126.89) 230.18,127.03 230.18,127.48 arc(230.26,127.67) 230.44,127.74 231.74,127.74 arc(231.95,127.78) 232.14,127.91 232.17,127.94 232.34,128.11 232.47,128.11 232.49,128.13
  SIG7 w0.16: 232.49,128.13 233.11,128.75 arc(233.26,128.87) 233.43,128.96 arc(233.61,129.01) 233.79,129.03 243.31,129.03 arc(243.46,129) 243.58,128.92 269.28,103.22 arc(269.49,102.91) 269.56,102.55 269.56,80.04 arc(269.64,79.61) 269.89,79.24 270.72,78.4 arc(270.8,78.29) 270.83,78.15 270.83,75.46 270.65,75.29 270.65,74.75 270.83,74.57 270.83,74.19 270.68,74.04 270.68,73.48 270.83,73.33 270.83,72.87 270.68,72.72 270.68,72.16 270.83,72.01 270.83,71.55 270.62,71.35 270.62,70.89 270.83,70.69 270.83,70.23 270.62,70.03 270.62,69.57 270.83,69.37 270.83,68.91 arc(270.77,68.61) 270.6,68.35 269.68,67.43 arc(269.43,67.06) 269.34,66.62 269.34,64.54 arc(269.43,64.11) 269.68,63.74 270.06,63.35 arc(270.43,63.1) 270.87,63.01 281.99,63.01 arc(282.14,62.98) 282.26,62.9 282.35,62.82 282.39,62.77 arc(282.46,62.68) 282.5,62.58 arc(282.51,62.53) 282.51,62.48 282.51,62.07 arc(282.56,61.84) 282.68,61.65 283.11,61.22 arc(283.25,61.02) 283.3,60.77 YJ32.A3
FC46_47_PVDD0P8: length 4.1
  TOP w0.229: U1.AL18 v1(213.55,136.34) ; U1.AP18 v1(213.55,140.34)
  TOP w0.381: 240.22,139.16 C3008.1 239.62,138.53
  BOTTOM w0.381: C3343.1 213.55,140.3 v1(213.55,140.34) ; v1(213.55,136.34) 213.07,135.86 C2944.1
  vias: v1(239.33,139.7) v1(240.22,139.7)
FC46_RDN0: length 112
  TOP w0.147: U1.AF13 218.13,131.84 arc(218.22,131.82) 218.31,131.77 218.5,131.57 arc(218.54,131.52) 218.55,131.46 v4(218.55,131.39)
  SIG2 w0.112: v4(218.55,131.39) 218.55,131.62 arc(218.59,131.71) 218.68,131.74 218.88,131.74 arc(218.92,131.73) 218.95,131.71 arc(218.98,131.68) 218.99,131.63 218.99,131.33 arc(219.03,131.11) 219.16,130.92 arc(219.35,130.79) 219.57,130.75 224.67,130.75 arc(224.78,130.72) 224.87,130.66 arc(224.93,130.57) 224.95,130.47 224.95,130.21 arc(224.99,130.03) 225.09,129.88 225.12,129.85 arc(225.24,129.77) 225.37,129.74 231.72,129.74 231.81,129.65 231.84,129.65
  SIG2 w0.16: 231.84,129.65 232.27,129.65 arc(232.56,129.71) 232.81,129.87 233.85,130.91 arc(234.1,131.08) 234.39,131.14 240.97,131.14 arc(241.26,131.08) 241.51,130.91 257.14,115.28 arc(257.31,115.04) 257.37,114.74 257.37,110.8 arc(257.45,110.37) 257.7,109.99 276.13,91.57 arc(276.21,91.45) 276.24,91.3 276.24,80.62 276.03,80.41 276.03,79.8 276.24,79.6 276.24,75.09 arc(276.32,74.65) 276.57,74.28 277.38,73.48 277.38,73.14 277.76,72.76 278.1,72.76 278.46,72.4 278.46,72.07 278.84,71.68 279.17,71.68 279.53,71.32 279.53,71.01 279.94,70.6 280.25,70.6 280.61,70.24 280.61,69.91 281,69.53 281.33,69.53 281.69,69.17 arc(282.06,68.92) 282.5,68.83 283.57,68.83 arc(283.72,68.8) 283.84,68.72 284.41,68.15 arc(284.5,68.03) 284.53,67.88 284.53,67.19 arc(284.5,67.07) 284.43,66.96 arc(284.32,66.89) 284.19,66.86 283.31,66.86 arc(283.1,66.77) 283.01,66.56 283.01,66.32 arc(283.04,66.13) 283.15,65.97 YJ31.C22
FC46_RDN1: length 115.2
  TOP w0.147: v4(222.55,132.29) 222.55,132.34 U1.AG9
  SIG3 w0.112: v4(222.55,132.29) 222.55,132.07 arc(222.59,131.98) 222.68,131.94 222.88,131.94 arc(222.92,131.95) 222.95,131.97 arc(222.98,132.01) 222.99,132.05 222.99,132.35 arc(223.03,132.58) 223.16,132.77 arc(223.35,132.89) 223.57,132.94 225.59,132.94 arc(225.79,132.9) 225.96,132.79 arc(226.07,132.62) 226.11,132.42 226.11,132.21 arc(226.13,132.1) 226.19,132.02 arc(226.28,131.96) 226.38,131.94 231.97,131.94 232.06,132.03 232.09,132.03
  SIG3 w0.16: 232.09,132.03 232.65,132.03 arc(232.79,132.06) 232.92,132.14 234.04,133.27 arc(234.41,133.51) 234.85,133.6 242.07,133.6 arc(242.36,133.54) 242.61,133.38 260.06,115.92 arc(260.23,115.68) 260.29,115.38 260.29,111.18 arc(260.34,110.89) 260.51,110.65 278.49,92.67 arc(278.65,92.42) 278.71,92.13 278.71,78.03 arc(278.77,77.74) 278.93,77.49 286.46,69.96 arc(286.62,69.72) 286.68,69.42 286.68,64.83 arc(286.62,64.54) 286.46,64.29 285.03,62.86 arc(284.94,62.72) 284.91,62.57 284.91,61.97 arc(284.88,61.85) 284.81,61.75 284.56,61.49 284.27,61.2 arc(284.14,61.02) 284.1,60.8 YJ31.C18
FC46_RDN2: length 122
  TOP w0.147: U1.AF11 220.13,131.84 arc(220.23,131.82) 220.31,131.77 220.5,131.58 arc(220.54,131.53) 220.55,131.46 v4(220.55,131.39)
  SIG2 w0.112: 232.01,131.65 231.98,131.65 231.89,131.74 226.4,131.74 arc(226.23,131.78) 226.08,131.88 arc(225.98,132.03) 225.94,132.21 225.94,132.42 arc(225.92,132.54) 225.85,132.65 arc(225.74,132.72) 225.62,132.74 221.57,132.74 arc(221.42,132.71) 221.3,132.63 arc(221.21,132.5) 221.18,132.35 221.18,132.05 arc(221.16,131.93) 221.09,131.83 arc(220.99,131.77) 220.88,131.74 220.68,131.74 arc(220.59,131.71) 220.55,131.62 v4(220.55,131.39)
  SIG2 w0.16: YJ31.C14 280.75,61.97 arc(280.64,62.13) 280.61,62.32 280.61,62.55 arc(280.7,62.77) 280.92,62.86 281.78,62.86 arc(282.07,62.92) 282.31,63.08 282.36,63.13 282.41,63.18 arc(282.5,63.26) 282.6,63.32 arc(282.77,63.38) 282.95,63.41 285.86,63.41 arc(286.16,63.46) 286.4,63.63 286.84,64.06 arc(287,64.31) 287.06,64.6 287.06,65.11 286.8,65.36 286.8,65.87 287.06,66.12 287.06,66.63 286.8,66.89 286.8,67.39 287.06,67.65 287.06,68.76 arc(287,69.06) 286.84,69.3 286.48,69.66 286.14,69.66 285.76,70.05 285.76,70.38 285.4,70.74 285.04,70.74 284.68,71.1 284.68,71.46 284.28,71.86 arc(284.03,72.02) 283.74,72.08 282.06,72.08 arc(281.77,72.14) 281.52,72.31 278.66,75.16 arc(278.42,75.53) 278.33,75.97 278.33,92.13 arc(278.3,92.28) 278.22,92.4 260.24,110.38 arc(259.99,110.75) 259.91,111.18 259.91,115.25 arc(259.85,115.54) 259.68,115.79 242.48,133 arc(242.23,133.16) 241.94,133.22 234.57,133.22 arc(234.28,133.16) 234.03,133 232.91,131.87 arc(232.66,131.71) 232.37,131.65 232.01,131.65
FC46_RDN3: length 104.7
  TOP w0.147: v4(224.55,132.29) 224.55,132.34 U1.AG7
  SIG3 w0.112: v4(224.55,132.29) 224.55,132.07 arc(224.59,131.98) 224.68,131.94 224.88,131.94 arc(224.99,131.92) 225.09,131.85 arc(225.16,131.75) 225.18,131.63 225.18,130.15 arc(225.2,130.07) 225.24,130 arc(225.31,129.96) 225.39,129.94 231.72,129.94 231.81,130.04 231.84,130.04
  SIG3 w0.16: 231.84,130.04 233.16,130.04 arc(233.31,130.07) 233.43,130.15 234.47,131.18 arc(234.84,131.43) 235.28,131.52 241.13,131.52 arc(241.42,131.46) 241.67,131.3 257.52,115.44 arc(257.69,115.19) 257.75,114.9 257.75,110.8 arc(257.8,110.51) 257.97,110.26 276.41,91.83 arc(276.57,91.58) 276.63,91.29 276.63,76.93 arc(276.69,76.64) 276.85,76.4 282.61,70.64 arc(282.77,70.39) 282.83,70.1 282.83,67.38 arc(282.77,67.08) 282.61,66.83 arc(282.55,66.75) 282.51,66.65 arc(282.51,66.61) 282.51,66.57 282.51,65.97 arc(282.48,65.85) 282.41,65.75 281.91,65.25 arc(281.9,65.24) 281.89,65.23 arc(281.75,65) 281.7,64.74 YJ31.C24
FC46_RDP0: length 112
  TOP w0.147: v4(218.55,132.29) 218.55,132.34 U1.AG13
  SIG2 w0.112: v4(218.55,132.29) 218.55,132.07 arc(218.59,131.98) 218.68,131.94 218.88,131.94 arc(218.99,131.92) 219.09,131.85 arc(219.16,131.75) 219.18,131.63 219.18,131.33 arc(219.21,131.18) 219.3,131.06 arc(219.42,130.97) 219.57,130.94 224.67,130.94 arc(224.85,130.91) 225.01,130.8 arc(225.11,130.65) 225.15,130.47 225.15,130.21 arc(225.17,130.1) 225.23,130.02 225.26,129.99 arc(225.31,129.95) 225.37,129.94 231.72,129.94 231.81,130.03 231.84,130.03
  SIG2 w0.16: 231.84,130.03 232.27,130.03 arc(232.42,130.06) 232.54,130.14 233.58,131.18 arc(233.95,131.43) 234.39,131.52 240.97,131.52 arc(241.41,131.43) 241.78,131.18 257.41,115.55 arc(257.66,115.18) 257.75,114.74 257.75,110.8 arc(257.8,110.51) 257.97,110.26 276.39,91.84 arc(276.56,91.59) 276.62,91.3 276.62,75.09 arc(276.68,74.8) 276.84,74.55 281.96,69.44 arc(282.21,69.27) 282.5,69.21 283.57,69.21 arc(283.86,69.15) 284.11,68.99 284.68,68.42 arc(284.85,68.17) 284.91,67.88 284.91,67.19 arc(284.91,67.19) 284.91,67.18 284.91,65.97 arc(284.88,65.85) 284.81,65.75 284.3,65.23 arc(284.15,65.01) 284.1,64.76 YJ31.C21
FC46_RDP1: length 115.2
  TOP w0.147: v4(222.55,131.39) 222.44,131.39 arc(222.34,131.41) 222.26,131.47 222.17,131.56 arc(222.08,131.69) U1.AF9
  SIG3 w0.112: 232.09,131.65 232.06,131.65 231.97,131.74 226.38,131.74 arc(226.2,131.78) 226.05,131.88 arc(225.95,132.03) 225.91,132.21 225.91,132.42 arc(225.89,132.54) 225.82,132.65 arc(225.72,132.72) 225.59,132.74 223.57,132.74 arc(223.42,132.71) 223.3,132.63 arc(223.21,132.5) 223.18,132.35 223.18,132.05 arc(223.16,131.93) 223.09,131.83 arc(222.99,131.77) 222.88,131.74 222.68,131.74 arc(222.59,131.71) 222.55,131.62 v4(222.55,131.39)
  SIG3 w0.16: 232.09,131.65 232.65,131.65 arc(232.94,131.71) 233.18,131.87 234.31,133 arc(234.56,133.16) 234.85,133.22 242.07,133.22 arc(242.22,133.19) 242.34,133.11 259.79,115.65 arc(259.88,115.53) 259.91,115.38 259.91,111.18 arc(259.99,110.75) 260.24,110.38 278.22,92.4 arc(278.3,92.28) 278.33,92.13 278.33,78.03 arc(278.42,77.59) 278.66,77.22 285.11,70.77 285.11,70.44 285.5,70.05 285.83,70.05 286.19,69.69 arc(286.27,69.57) 286.3,69.42 286.3,67.99 286.05,67.74 286.05,67.23 286.3,66.98 286.3,66.35 286.05,66.1 286.05,65.59 286.3,65.34 286.3,64.83 arc(286.27,64.68) 286.19,64.56 285.79,64.16 285.43,64.16 285.07,63.8 285.07,63.44 284.71,63.08 arc(284.47,62.92) 284.18,62.86 283.29,62.86 arc(283.09,62.78) 283.01,62.58 283.01,62.32 arc(283.04,62.13) 283.15,61.97 YJ31.C17
FC46_RDP2: length 122.1
  TOP w0.147: U1.AG11 220.55,132.34 v4(220.55,132.29)
  SIG2 w0.112: v4(220.55,132.29) 220.55,132.07 arc(220.59,131.98) 220.68,131.94 220.88,131.94 arc(220.92,131.95) 220.95,131.97 arc(220.98,132.01) 220.99,132.05 220.99,132.35 arc(221.03,132.58) 221.16,132.77 arc(221.35,132.89) 221.57,132.94 225.62,132.94 arc(225.82,132.9) 225.99,132.79 arc(226.1,132.62) 226.14,132.42 226.14,132.21 arc(226.16,132.1) 226.22,132.02 arc(226.3,131.96) 226.4,131.94 231.89,131.94 231.98,132.03 232.01,132.03
  SIG2 w0.16: 232.01,132.03 232.37,132.03 arc(232.51,132.06) 232.64,132.14 233.76,133.27 arc(234.13,133.51) 234.57,133.6 241.94,133.6 arc(242.37,133.51) 242.75,133.27 259.95,116.06 arc(260.2,115.69) 260.29,115.25 260.29,111.18 arc(260.34,110.89) 260.51,110.65 278.49,92.67 arc(278.65,92.42) 278.71,92.13 278.71,75.97 278.71,75.97 arc(278.77,75.68) 278.93,75.43 281.79,72.58 arc(281.91,72.49) 282.06,72.46 283.74,72.46 arc(284.18,72.38) 284.55,72.13 287.1,69.57 arc(287.35,69.2) 287.44,68.76 287.44,64.6 arc(287.35,64.16) 287.1,63.79 286.67,63.36 arc(286.3,63.11) 285.86,63.03 282.95,63.03 arc(282.86,63.01) 282.78,62.98 arc(282.73,62.95) 282.68,62.91 282.63,62.86 arc(282.54,62.72) 282.51,62.57 282.51,61.97 arc(282.48,61.85) 282.41,61.75 281.87,61.2 arc(281.74,61.02) 281.7,60.79 YJ31.C15
FC46_RDP3: length 104.7
  TOP w0.147: v4(224.55,131.39) 224.44,131.39 arc(224.34,131.41) 224.26,131.47 224.17,131.56 arc(224.08,131.69) U1.AF7
  SIG3 w0.112: 231.84,129.66 231.81,129.66 231.72,129.75 225.39,129.75 arc(225.23,129.78) 225.1,129.86 arc(225.02,130) 224.99,130.15 224.99,131.63 arc(224.98,131.68) 224.95,131.71 arc(224.92,131.73) 224.88,131.74 224.68,131.74 arc(224.59,131.71) 224.55,131.62 v4(224.55,131.39)
  SIG3 w0.16: 231.84,129.66 233.16,129.66 arc(233.46,129.71) 233.7,129.88 234.74,130.91 arc(234.99,131.08) 235.28,131.14 241.13,131.14 arc(241.28,131.11) 241.4,131.03 257.25,115.17 arc(257.34,115.05) 257.37,114.9 257.37,110.8 arc(257.45,110.37) 257.7,109.99 276.14,91.56 arc(276.22,91.43) 276.25,91.29 276.25,76.93 arc(276.34,76.5) 276.58,76.13 278.72,73.99 278.72,73.65 279.11,73.27 279.44,73.27 279.88,72.83 279.88,72.47 280.24,72.11 280.6,72.11 281.18,71.52 281.18,71.17 281.54,70.81 281.9,70.81 282.34,70.37 arc(282.42,70.25) 282.45,70.1 282.45,68.93 282.19,68.68 282.19,68.17 282.45,67.92 282.45,67.41 282.45,67.41 arc(282.41,67.23) 282.31,67.08 arc(282.07,66.92) 281.78,66.86 280.93,66.86 arc(280.7,66.77) 280.61,66.54 280.61,66.32 arc(280.64,66.13) 280.75,65.97 YJ31.C25
FC46_TDN0: length 96.4
  TOP w0.147: U1.AF4 227.55,131.34 v4(227.55,131.29)
  SIG4 w0.112: v4(227.55,131.29) 227.55,131.07 arc(227.59,130.98) 227.68,130.94 227.83,130.94 arc(227.97,130.91) 228.08,130.84 228.08,130.84 arc(228.16,130.72) 228.18,130.59 228.18,130.21 arc(228.2,130.11) 228.26,130.02 arc(228.35,129.96) 228.46,129.94 231.72,129.94 231.81,130.03 231.84,130.03
  SIG4 w0.16: 231.84,130.03 232.88,130.03 arc(233.17,130.09) 233.42,130.25 234.46,131.3 arc(234.71,131.46) 235,131.52 241.13,131.52 arc(241.42,131.46) 241.67,131.3 262.72,110.25 arc(263.17,109.56) 263.33,108.75 263.33,100.17 arc(263.39,99.87) 263.56,99.63 269.77,93.42 arc(269.93,93.17) 269.99,92.88 269.99,80.17 arc(270.05,79.88) 270.21,79.63 270.33,79.52 arc(270.49,79.27) 270.55,78.98 270.55,72.86 arc(270.61,72.56) 270.77,72.32 272.68,70.41 arc(272.85,70.16) 272.91,69.87 272.91,65.97 arc(272.88,65.85) 272.81,65.75 272.27,65.2 arc(272.14,65.02) 272.1,64.8 YJ31.C36
FC46_TDN1: length 94.3
  TOP w0.147: U1.AE2 229.1,130.84 arc(229.42,130.71) v4(229.55,130.39)
  SIG5 w0.112: 231.84,129.65 231.81,129.65 231.72,129.74 230.39,129.74 arc(230.23,129.77) 230.1,129.86 arc(230.02,129.99) 229.99,130.14 229.99,130.58 arc(229.97,130.64) 229.94,130.69 229.93,130.71 arc(229.88,130.73) 229.84,130.74 229.68,130.74 arc(229.59,130.71) 229.55,130.62 v4(229.55,130.39)
  SIG5 w0.16: YJ31.C34 273.55,65.97 arc(273.44,66.13) 273.41,66.32 273.41,66.59 arc(273.49,66.78) 273.68,66.86 274.69,66.86 arc(274.86,66.93) 274.93,67.1 274.93,68.08 arc(274.9,68.22) 274.81,68.35 274.27,68.88 274.08,68.88 273.52,69.45 273.52,69.64 272.98,70.18 272.79,70.18 272.23,70.74 272.23,70.93 271.69,71.47 271.5,71.47 270.93,72.04 270.93,72.23 270.39,72.76 270.2,72.76 269.64,73.33 269.64,73.52 267.86,75.3 arc(267.61,75.67) 267.53,76.11 267.53,104.58 arc(267.47,104.88) 267.3,105.12 243.7,128.73 arc(243.45,128.9) 243.16,128.95 241.32,128.95 241.22,128.85 240.36,128.85 240.26,128.95 239.5,128.95 239.37,128.83 238.56,128.83 238.43,128.95 237.67,128.95 237.51,128.8 236.75,128.8 236.6,128.95 235.84,128.95 235.69,128.8 234.92,128.8 234.77,128.95 234.01,128.95 arc(233.57,129.04) 233.2,129.29 232.95,129.54 arc(232.83,129.62) 232.68,129.65 231.84,129.65
FC46_TDN2: length 122
  TOP w0.147: U1.AH5 226.55,133.34 v4(226.55,133.29)
  SIG4 w0.112: 232.13,132.03 232.11,132.03 232.01,131.94 227.46,131.94 arc(227.35,131.96) 227.26,132.02 arc(227.2,132.11) 227.18,132.21 227.18,132.59 arc(227.16,132.72) 227.08,132.84 227.08,132.84 arc(226.97,132.91) 226.83,132.94 226.68,132.94 arc(226.59,132.98) 226.55,133.07 v4(226.55,133.29)
  SIG4 w0.16: 232.13,132.03 232.72,132.03 arc(233.01,132.09) 233.26,132.25 234.38,133.38 arc(234.63,133.54) 234.92,133.6 242.1,133.6 arc(242.39,133.54) 242.63,133.38 265.4,110.61 arc(265.56,110.37) 265.62,110.08 265.62,102.96 arc(265.68,102.67) 265.84,102.42 276.45,91.82 arc(276.61,91.57) 276.67,91.28 276.67,78.14 arc(276.73,77.85) 276.89,77.6 285.96,68.53 arc(286.13,68.28) 286.19,67.99 286.19,64.57 arc(286.13,64.28) 285.96,64.03 285.18,63.25 arc(284.94,63.08) 284.65,63.03 273.35,63.03 arc(273.21,63) 273.08,62.91 273.03,62.86 arc(272.94,62.72) 272.91,62.57 272.91,61.97 arc(272.88,61.85) 272.81,61.75 272.28,61.21 arc(272.15,61.01) 272.1,60.78 YJ31.C3
FC46_TDN3: length 116.4
  TOP w0.147: U1.AG3 228.1,132.84 arc(228.42,132.71) v4(228.55,132.39)
  SIG5 w0.112: 232.09,131.65 232.06,131.65 231.97,131.74 229.39,131.74 arc(229.23,131.77) 229.1,131.86 arc(229.02,131.99) 228.99,132.14 228.99,132.58 arc(228.97,132.64) 228.94,132.69 228.93,132.71 arc(228.88,132.73) 228.84,132.74 228.68,132.74 arc(228.59,132.71) 228.55,132.62 v4(228.55,132.39)
  SIG5 w0.16: YJ31.C5 273.55,61.97 arc(273.44,62.13) 273.41,62.32 273.41,62.59 arc(273.49,62.78) 273.68,62.86 274.44,62.86 arc(274.86,62.95) 275.21,63.18 arc(275.46,63.35) 275.75,63.41 284.9,63.41 arc(285.04,63.44) 285.17,63.52 285.7,64.05 arc(285.78,64.17) 285.81,64.32 285.81,67.63 arc(285.78,67.77) 285.7,67.9 285.38,68.22 285.03,68.22 284.73,68.52 284.73,68.87 284.41,69.19 284.06,69.19 283.76,69.49 283.76,69.84 283.44,70.16 283.09,70.16 282.79,70.46 282.79,70.81 282.47,71.13 282.12,71.13 281.82,71.43 281.82,71.78 276.62,76.97 arc(276.38,77.35) 276.29,77.78 276.29,91.12 arc(276.23,91.41) 276.07,91.66 270.15,97.58 arc(269.9,97.95) 269.81,98.39 269.81,105.5 arc(269.78,105.65) 269.7,105.77 244.56,130.91 arc(244.31,131.08) 244.02,131.14 233.83,131.14 arc(233.39,131.22) 233.02,131.47 232.96,131.54 arc(232.83,131.62) 232.69,131.65 232.09,131.65
FC46_TDP0: length 96.4
  TOP w0.147: v4(227.55,130.39) 227.55,130.48 arc(227.53,130.56) 227.49,130.62 227.41,130.7 arc(227.25,130.81) 227.07,130.84 U1.AE4
  SIG4 w0.112: v4(227.55,130.39) 227.55,130.62 arc(227.59,130.71) 227.68,130.74 227.83,130.74 arc(227.89,130.73) 227.94,130.7 arc(227.97,130.65) 227.99,130.59 227.99,130.21 arc(228.02,130.03) 228.12,129.88 arc(228.28,129.78) 228.46,129.74 231.72,129.74 231.81,129.65 231.84,129.65
  SIG4 w0.16: 231.84,129.65 232.88,129.65 arc(233.32,129.74) 233.69,129.98 234.73,131.03 arc(234.85,131.11) 235,131.14 241.13,131.14 arc(241.28,131.11) 241.4,131.03 262.45,109.98 arc(262.82,109.42) 262.95,108.75 262.95,100.17 arc(263.04,99.73) 263.29,99.36 269.5,93.15 arc(269.58,93.03) 269.61,92.88 269.61,80.17 arc(269.7,79.73) 269.94,79.36 270.06,79.25 arc(270.14,79.13) 270.17,78.98 270.17,75.53 269.89,75.25 269.89,74.79 270.17,74.52 270.17,74.01 269.89,73.73 269.89,73.27 270.17,72.99 270.17,72.86 arc(270.25,72.42) 270.5,72.05 271.21,71.33 271.21,70.97 271.57,70.62 271.93,70.62 272.41,70.14 arc(272.5,70.01) 272.53,69.87 272.53,68.78 272.3,68.55 272.3,67.98 272.53,67.76 272.53,67.03 arc(272.47,66.91) 272.35,66.86 271.28,66.86 arc(271.09,66.78) 271.01,66.59 271.01,66.32 arc(271.04,66.13) 271.15,65.97 YJ31.C37
FC46_TDP1: length 94.3
  TOP w0.147: U1.AF2 229.55,131.34 v4(229.55,131.29)
  SIG5 w0.112: 231.84,130.03 231.81,130.03 231.72,129.94 230.39,129.94 arc(230.31,129.95) 230.24,130 arc(230.2,130.06) 230.18,130.14 230.18,130.58 arc(230.15,130.72) 230.08,130.83 230.07,130.85 arc(229.96,130.92) 229.84,130.94 229.68,130.94 arc(229.59,130.98) 229.55,131.07 v4(229.55,131.29)
  SIG5 w0.155: 275.31,65.97 275.31,65.97 arc(275.29,65.88) 275.25,65.8
  SIG5 w0.16: 231.84,130.03 232.68,130.03 arc(232.97,129.97) 233.22,129.81 233.47,129.56 arc(233.72,129.39) 234.01,129.33 243.16,129.33 arc(243.59,129.25) 243.96,129 267.57,105.39 arc(267.82,105.02) 267.91,104.58 267.91,76.11 arc(267.96,75.82) 268.13,75.57 275.08,68.61 arc(275.25,68.37) 275.31,68.08 275.31,65.97 ; YJ31.C33 274.5,64.78 arc(274.55,65.01) 274.68,65.21 275.14,65.67 arc(275.2,65.74) 275.25,65.8
FC46_TDP2: length 122
  TOP w0.147: v4(226.55,132.39) 226.55,132.48 arc(226.53,132.56) 226.49,132.62 226.41,132.7 arc(226.25,132.81) 226.07,132.84 U1.AG5
  SIG4 w0.112: 232.13,131.65 232.11,131.65 232.01,131.74 227.46,131.74 arc(227.28,131.78) 227.12,131.88 arc(227.02,132.03) 226.99,132.21 226.99,132.59 arc(226.97,132.65) 226.94,132.7 arc(226.89,132.73) 226.83,132.74 226.68,132.74 arc(226.59,132.71) 226.55,132.62 v4(226.55,132.39)
  SIG4 w0.16: YJ31.C2 271.15,61.97 arc(271.04,62.13) 271.01,62.32 271.01,62.56 arc(271.1,62.77) 271.31,62.86 272.18,62.86 arc(272.47,62.92) 272.71,63.08 272.76,63.13 272.81,63.18 arc(273.06,63.35) 273.35,63.41 284.65,63.41 arc(284.79,63.44) 284.91,63.52 285.69,64.3 arc(285.78,64.42) 285.81,64.57 285.81,66.42 285.58,66.65 285.58,67.21 285.81,67.43 285.81,67.99 arc(285.78,68.14) 285.69,68.26 285.33,68.62 284.98,68.62 284.62,68.98 284.62,69.34 284.26,69.7 283.9,69.7 283.54,70.06 283.54,70.42 283.18,70.77 282.82,70.77 282.46,71.13 282.46,71.49 276.62,77.33 arc(276.38,77.7) 276.29,78.14 276.29,91.28 arc(276.26,91.43) 276.18,91.55 265.57,102.15 arc(265.33,102.52) 265.24,102.96 265.24,110.08 arc(265.21,110.22) 265.13,110.35 242.36,133.11 arc(242.24,133.19) 242.1,133.22 234.92,133.22 arc(234.78,133.19) 234.65,133.11 233.53,131.98 arc(233.16,131.74) 232.72,131.65 232.13,131.65
FC46_TDP3: length 116.4
  TOP w0.147: v4(228.55,133.29) 228.55,133.34 U1.AH3
  SIG5 w0.112: 232.09,132.03 232.06,132.03 231.97,131.94 229.39,131.94 arc(229.31,131.95) 229.24,132 arc(229.2,132.06) 229.18,132.14 229.18,132.58 arc(229.15,132.72) 229.08,132.83 229.07,132.85 arc(228.96,132.92) 228.84,132.94 228.68,132.94 arc(228.59,132.98) 228.55,133.07 v4(228.55,133.29)
  SIG5 w0.155: 275.31,61.97 arc(275.3,61.91) 275.28,61.84
  SIG5 w0.16: 275.31,61.97 275.31,62.57 arc(275.31,62.6) 275.31,62.64 arc(275.31,62.64) 275.31,62.65 arc(275.35,62.76) 275.43,62.86 275.48,62.91 arc(275.61,63) 275.75,63.03 284.9,63.03 arc(285.19,63.08) 285.44,63.25 285.97,63.78 arc(286.14,64.03) 286.19,64.32 286.19,67.63 arc(286.14,67.92) 285.97,68.17 276.89,77.24 arc(276.73,77.49) 276.67,77.78 276.67,91.12 arc(276.58,91.56) 276.33,91.93 270.42,97.85 arc(270.25,98.1) 270.19,98.39 270.19,105.5 arc(270.13,105.8) 269.97,106.04 244.83,131.18 arc(244.46,131.43) 244.02,131.52 233.83,131.52 arc(233.54,131.58) 233.29,131.74 233.23,131.81 arc(232.98,131.97) 232.69,132.03 232.09,132.03 ; YJ31.C6 274.5,60.81 arc(274.54,61.02) 274.66,61.19 275.19,61.72 arc(275.24,61.78) 275.28,61.84
FC47_RDN0: length 132.4
  TOP w0.147: v4(217.55,135.29) 217.55,135.34 U1.AK14
  SIG2 w0.112: v4(217.55,135.29) 217.55,135.07 arc(217.59,134.98) 217.68,134.94 217.88,134.94 arc(217.99,134.92) 218.09,134.85 arc(218.16,134.75) 218.18,134.63 218.18,134.33 arc(218.21,134.18) 218.3,134.06 arc(218.42,133.97) 218.57,133.94 231.75,133.94 231.84,134.03
  SIG2 w0.16: 231.84,134.03 232.46,134.03 arc(232.6,134.06) 232.73,134.14 233.32,134.73 arc(233.69,134.98) 234.12,135.06 243.52,135.06 arc(243.96,134.98) 244.33,134.73 262.11,116.95 arc(262.36,116.58) 262.45,116.14 262.45,112.71 arc(262.5,112.42) 262.67,112.17 280.89,93.95 arc(281.06,93.7) 281.11,93.41 281.11,76.49 arc(281.17,76.2) 281.34,75.95 282.52,74.77 arc(282.76,74.6) 283.06,74.55 285.12,74.55 arc(285.41,74.49) 285.66,74.32 289.53,70.45 arc(289.69,70.2) 289.75,69.91 289.75,63.43 arc(289.69,63.14) 289.53,62.89 285.88,59.25 arc(285.64,59.08) 285.34,59.03 282.95,59.03 arc(282.86,59.01) 282.78,58.98 arc(282.73,58.95) 282.68,58.91 282.63,58.86 arc(282.54,58.72) 282.51,58.57 282.51,57.97 arc(282.48,57.85) 282.41,57.75 281.87,57.2 arc(281.74,57.02) 281.7,56.8 YJ31.D24
FC47_RDN1: length 123.4
  TOP w0.147: v4(221.55,134.39) 221.44,134.39 arc(221.34,134.41) 221.26,134.47 221.17,134.56 arc(221.08,134.69) U1.AJ10
  SIG3 w0.112: v4(221.55,134.39) 221.55,134.62 arc(221.59,134.71) 221.68,134.74 221.88,134.74 arc(221.92,134.73) 221.95,134.71 arc(221.98,134.68) 221.99,134.63 221.99,134.33 arc(222.03,134.11) 222.16,133.92 arc(222.35,133.79) 222.57,133.75 231.81,133.75 231.91,133.65
  SIG3 w0.16: 231.91,133.65 232.26,133.65 arc(232.55,133.71) 232.79,133.87 233.35,134.43 arc(233.6,134.59) 233.89,134.65 243.71,134.65 arc(243.86,134.62) 243.98,134.54 261.95,116.57 arc(262.04,116.44) 262.06,116.3 262.06,112.71 arc(262.15,112.27) 262.4,111.9 280.62,93.68 arc(280.7,93.55) 280.73,93.41 280.73,82.05 arc(280.82,81.61) 281.07,81.24 284.25,78.06 arc(284.34,77.93) 284.37,77.79 284.37,75.42 arc(284.45,74.98) 284.7,74.61 285.76,73.56 285.76,73.22 286.14,72.84 286.48,72.84 287.05,72.26 287.05,71.9 287.41,71.54 287.77,71.54 288.35,70.96 arc(288.43,70.84) 288.46,70.69 288.46,62.99 arc(288.43,62.84) 288.35,62.72 287,61.37 286.64,61.37 286.28,61.01 286.28,60.65 285.93,60.29 285.57,60.29 285.21,59.93 285.21,59.58 284.85,59.22 arc(284.83,59.2) 284.81,59.18 284.76,59.13 284.71,59.08 arc(284.47,58.92) 284.18,58.86 283.36,58.86 arc(283.11,58.76) 283.01,58.51 283.01,58.32 arc(283.04,58.13) 283.15,57.97 YJ31.D22
FC47_RDN2: length 140.3
  TOP w0.147: U1.AK12 219.55,135.34 v4(219.55,135.29)
  SIG2 w0.112: 232.09,136.04 232.06,136.04 231.97,135.94 220.57,135.94 arc(220.35,135.9) 220.16,135.77 arc(220.03,135.58) 219.99,135.36 219.99,135.05 arc(219.98,135.01) 219.95,134.97 arc(219.92,134.95) 219.88,134.94 219.68,134.94 arc(219.59,134.98) 219.55,135.07 v4(219.55,135.29)
  SIG2 w0.16: 232.09,136.04 232.56,136.04 arc(232.71,136.06) 232.83,136.15 233.5,136.82 arc(233.88,137.07) 234.31,137.16 244.48,137.16 arc(244.91,137.07) 245.29,136.82 264.27,117.84 arc(264.52,117.47) 264.6,117.03 264.6,113.47 264.61,113.47 arc(264.66,113.18) 264.83,112.93 274.53,103.23 arc(274.65,103.15) 274.8,103.12 279.66,103.12 arc(280.09,103.03) 280.46,102.79 281.16,102.09 arc(281.41,101.72) 281.5,101.28 281.5,96.58 arc(281.55,96.29) 281.72,96.04 285.08,92.68 arc(285.25,92.43) 285.31,92.14 285.31,78.14 arc(285.36,77.85) 285.53,77.6 291.69,71.44 arc(291.85,71.2) 291.91,70.9 291.91,61.78 arc(291.85,61.49) 291.69,61.24 285.69,55.25 arc(285.45,55.08) 285.15,55.03 282.95,55.03 arc(282.86,55.01) 282.78,54.98 arc(282.73,54.95) 282.68,54.91 282.63,54.86 arc(282.56,54.76) 282.52,54.65 arc(282.51,54.61) 282.51,54.57 282.51,53.97 arc(282.48,53.85) 282.41,53.75 281.85,53.18 arc(281.74,53.02) 281.7,52.82 YJ31.D15
FC47_RDN3: length 133.7
  TOP w0.147: v4(223.55,134.39) 223.44,134.39 arc(223.34,134.41) 223.26,134.47 223.17,134.56 arc(223.08,134.69) U1.AJ8
  SIG3 w0.112: v4(223.55,134.39) 223.55,134.62 arc(223.59,134.71) 223.68,134.74 223.88,134.74 arc(223.99,134.77) 224.09,134.83 arc(224.16,134.93) 224.18,135.05 224.18,135.36 arc(224.21,135.51) 224.3,135.63 arc(224.42,135.72) 224.57,135.75 231.77,135.75 231.86,135.65 231.89,135.65
  SIG3 w0.16: YJ31.D17 283.15,53.97 arc(283.04,54.13) 283.01,54.32 283.01,54.55 arc(283.1,54.77) 283.32,54.86 284.18,54.86 arc(284.47,54.92) 284.71,55.08 284.76,55.13 284.81,55.18 arc(285.06,55.35) 285.35,55.41 286.02,55.41 arc(286.31,55.46) 286.56,55.63 286.92,55.99 286.92,56.35 287.28,56.71 287.63,56.71 287.99,57.07 287.99,57.43 288.35,57.79 288.71,57.79 289.07,58.14 289.07,58.5 289.43,58.86 289.79,58.86 290.4,59.47 arc(290.56,59.72) 290.62,60.01 290.62,60.52 290.39,60.75 290.39,61.3 290.62,61.53 290.62,71.46 arc(290.59,71.6) 290.51,71.73 286.78,75.45 arc(286.54,75.82) 286.45,76.26 286.45,90.61 arc(286.42,90.76) 286.34,90.88 281.45,95.77 arc(281.2,96.14) 281.11,96.58 281.11,101.25 281.11,101.25 arc(281.06,101.54) 280.89,101.79 280.16,102.52 arc(279.92,102.68) 279.63,102.74 274.8,102.74 arc(274.5,102.8) 274.26,102.96 264.56,112.66 arc(264.31,113.03) 264.22,113.47 264.22,117.19 arc(264.19,117.33) 264.11,117.46 244.9,136.66 arc(244.78,136.75) 244.64,136.78 233.78,136.78 arc(233.49,136.72) 233.24,136.55 232.57,135.88 arc(232.32,135.71) 232.03,135.65 231.89,135.65
FC47_RDP0: length 132.3
  TOP w0.147: v4(217.55,134.39) 217.55,134.46 arc(217.54,134.53) 217.5,134.58 217.31,134.77 arc(217.23,134.82) 217.13,134.84 U1.AJ14
  SIG2 w0.112: 231.84,133.65 231.74,133.75 218.57,133.75 arc(218.35,133.79) 218.16,133.92 arc(218.03,134.11) 217.99,134.33 217.99,134.63 arc(217.98,134.68) 217.95,134.71 arc(217.92,134.73) 217.88,134.74 217.68,134.74 arc(217.59,134.71) 217.55,134.62 v4(217.55,134.39)
  SIG2 w0.16: YJ31.D25 280.75,57.97 arc(280.64,58.13) 280.61,58.32 280.61,58.55 arc(280.7,58.77) 280.92,58.86 281.78,58.86 arc(282.07,58.92) 282.31,59.08 282.36,59.13 282.41,59.18 arc(282.5,59.26) 282.6,59.32 arc(282.77,59.38) 282.95,59.41 285.34,59.41 arc(285.49,59.44) 285.61,59.52 285.97,59.88 285.97,60.24 286.33,60.6 286.69,60.6 287.05,60.96 287.05,61.31 287.41,61.67 287.77,61.67 288.13,62.03 288.13,62.39 288.49,62.75 288.85,62.75 289.26,63.16 arc(289.34,63.29) 289.37,63.43 289.37,63.94 289.14,64.17 289.14,64.73 289.37,64.96 289.37,69.91 arc(289.34,70.06) 289.26,70.18 285.39,74.05 arc(285.26,74.14) 285.12,74.17 283.06,74.17 arc(282.62,74.25) 282.25,74.5 281.07,75.68 arc(280.82,76.05) 280.73,76.49 280.73,93.41 arc(280.7,93.55) 280.62,93.68 262.4,111.9 arc(262.15,112.27) 262.06,112.71 262.06,116.14 arc(262.01,116.43) 261.84,116.68 244.06,134.46 arc(243.81,134.62) 243.52,134.68 234.12,134.68 arc(233.83,134.62) 233.59,134.46 233,133.87 arc(232.75,133.71) 232.46,133.65 231.84,133.65
FC47_RDP1: length 123.4
  TOP w0.147: v4(221.55,135.29) 221.55,135.34 U1.AK10
  SIG3 w0.112: v4(221.55,135.29) 221.55,135.07 arc(221.59,134.98) 221.68,134.94 221.88,134.94 arc(221.99,134.92) 222.09,134.85 arc(222.16,134.75) 222.18,134.63 222.18,134.33 arc(222.21,134.18) 222.3,134.06 arc(222.42,133.97) 222.57,133.94 231.83,133.94 231.91,134.03
  SIG3 w0.16: YJ31.D21 284.1,56.79 arc(284.15,57.02) 284.28,57.21 284.81,57.75 arc(284.88,57.85) 284.91,57.97 284.91,58.57 arc(284.94,58.72) 285.03,58.86 285.08,58.91 arc(285.1,58.93) 285.11,58.94 288.62,62.45 arc(288.78,62.69) 288.84,62.99 288.84,70.69 arc(288.78,70.99) 288.62,71.23 284.97,74.88 arc(284.8,75.13) 284.75,75.42 284.75,77.79 arc(284.69,78.08) 284.52,78.33 281.34,81.51 arc(281.17,81.76) 281.11,82.05 281.11,93.41 arc(281.06,93.7) 280.89,93.95 262.67,112.17 arc(262.5,112.42) 262.45,112.71 262.45,116.3 arc(262.39,116.59) 262.22,116.84 244.25,134.81 arc(244.01,134.97) 243.71,135.03 233.89,135.03 arc(233.45,134.94) 233.08,134.69 232.53,134.14 arc(232.4,134.06) 232.26,134.03 231.91,134.03
FC47_RDP2: length 140.3
  TOP w0.147: U1.AJ12 219.14,134.84 arc(219.24,134.82) 219.32,134.77 219.5,134.59 arc(219.54,134.53) 219.55,134.47 v4(219.55,134.39)
  SIG2 w0.112: v4(219.55,134.39) 219.55,134.62 arc(219.59,134.71) 219.68,134.74 219.88,134.74 arc(219.99,134.77) 220.09,134.83 arc(220.16,134.93) 220.18,135.05 220.18,135.36 arc(220.21,135.51) 220.3,135.63 arc(220.42,135.72) 220.57,135.75 231.97,135.75 232.06,135.65 232.09,135.65
  SIG2 w0.16: 232.09,135.65 232.56,135.65 arc(232.85,135.71) 233.1,135.88 233.77,136.55 arc(234.02,136.72) 234.31,136.78 244.48,136.78 arc(244.77,136.72) 245.02,136.55 264,117.57 arc(264.17,117.32) 264.22,117.03 264.22,113.47 arc(264.31,113.03) 264.56,112.66 274.26,102.96 arc(274.5,102.8) 274.8,102.74 279.66,102.74 arc(279.95,102.68) 280.2,102.52 280.89,101.82 arc(281.06,101.57) 281.11,101.28 281.11,96.58 arc(281.2,96.14) 281.45,95.77 284.81,92.41 arc(284.9,92.28) 284.92,92.14 284.92,78.14 arc(285.01,77.7) 285.26,77.33 291.42,71.17 arc(291.5,71.05) 291.53,70.9 291.53,61.78 arc(291.5,61.64) 291.42,61.51 290.98,61.07 290.64,61.07 290.26,60.69 290.26,60.35 289.9,59.99 289.56,59.99 289.18,59.61 289.18,59.27 288.82,58.92 288.46,58.92 288.1,58.56 288.1,58.2 287.74,57.84 287.38,57.84 287.02,57.48 287.02,57.12 285.42,55.52 arc(285.3,55.44) 285.15,55.41 282.95,55.41 arc(282.77,55.38) 282.6,55.32 arc(282.5,55.26) 282.41,55.18 arc(282.06,54.95) 281.64,54.86 280.85,54.86 arc(280.68,54.79) 280.61,54.62 280.61,54.32 arc(280.64,54.13) 280.75,53.97 YJ31.D14
FC47_RDP3: length 133.7
  TOP w0.147: U1.AK8 223.55,135.34 v4(223.55,135.29)
  SIG3 w0.112: v4(223.55,135.29) 223.55,135.07 arc(223.59,134.98) 223.68,134.94 223.88,134.94 arc(223.92,134.95) 223.95,134.97 arc(223.98,135.01) 223.99,135.05 223.99,135.36 arc(224.03,135.58) 224.16,135.77 arc(224.35,135.9) 224.57,135.94 231.77,135.94 231.86,136.04 231.89,136.04
  SIG3 w0.16: 231.89,136.04 232.03,136.04 arc(232.17,136.06) 232.3,136.15 232.97,136.82 arc(233.34,137.07) 233.78,137.16 244.64,137.16 arc(244.93,137.1) 245.17,136.93 264.38,117.73 arc(264.55,117.48) 264.6,117.19 264.6,113.47 264.61,113.47 arc(264.66,113.18) 264.83,112.93 274.53,103.23 arc(274.65,103.15) 274.8,103.12 279.63,103.12 arc(280.06,103.03) 280.43,102.79 281.16,102.06 arc(281.41,101.69) 281.5,101.25 281.5,96.58 arc(281.55,96.29) 281.72,96.04 286.61,91.15 arc(286.77,90.91) 286.83,90.61 286.83,76.26 arc(286.89,75.97) 287.05,75.72 290.78,72 arc(290.94,71.75) 291,71.46 291,60.01 arc(290.91,59.57) 290.67,59.2 286.83,55.36 arc(286.46,55.11) 286.02,55.03 285.35,55.03 arc(285.21,55) 285.08,54.91 285.03,54.86 arc(284.94,54.72) 284.91,54.57 284.91,53.97 arc(284.88,53.85) 284.81,53.75 284.28,53.21 arc(284.27,53.21) 284.27,53.2 arc(284.14,53.01) 284.1,52.79 YJ31.D18
FC47_TDN0: length 135.3
  TOP w0.147: U1.AJ2 229.1,134.84 arc(229.42,134.71) v4(229.55,134.39)
  SIG5 w0.112: v4(229.55,134.39) 229.55,134.62 arc(229.59,134.71) 229.68,134.74 229.84,134.74 arc(229.96,134.77) 230.07,134.84 230.08,134.85 arc(230.15,134.97) 230.18,135.11 230.18,135.54 arc(230.2,135.62) 230.24,135.69 arc(230.31,135.73) 230.39,135.75 231.97,135.75 232.06,135.65 232.09,135.65
  SIG5 w0.16: YJ31.D2 271.15,53.97 arc(271.04,54.13) 271.01,54.32 271.01,54.54 arc(271.1,54.77) 271.33,54.86 272.18,54.86 arc(272.47,54.92) 272.71,55.08 272.76,55.13 272.81,55.18 arc(273.06,55.35) 273.35,55.41 285.28,55.41 arc(285.43,55.44) 285.55,55.52 286.63,56.6 286.63,56.81 287.17,57.35 287.38,57.35 287.92,57.89 287.92,58.1 288.46,58.64 288.68,58.64 289.21,59.18 289.21,59.4 289.75,59.94 289.97,59.94 290.54,60.51 arc(290.71,60.76) 290.77,61.05 290.77,61.81 290.61,61.96 290.61,62.73 290.77,62.88 290.77,63.64 290.61,63.79 290.61,64.56 290.77,64.71 290.77,65.47 290.64,65.6 290.64,66.41 290.77,66.54 290.77,67.3 290.67,67.4 290.67,68.26 290.77,68.37 290.77,69.66 arc(290.71,69.95) 290.54,70.2 285.15,75.59 arc(284.98,75.84) 284.92,76.13 284.92,86.55 arc(284.87,86.84) 284.7,87.09 280.96,90.83 arc(280.79,91.08) 280.73,91.37 280.73,93.41 arc(280.7,93.55) 280.62,93.68 274.46,99.83 arc(274.22,100.21) 274.13,100.64 274.13,107.28 arc(274.1,107.43) 274.02,107.55 247.12,134.44 arc(246.88,134.61) 246.59,134.67 236.55,134.67 arc(236.11,134.76) 235.74,135 235.2,135.54 arc(235.18,135.56) 235.16,135.58 arc(235.05,135.64) 234.93,135.65 232.09,135.65
FC47_TDN1: length 127.7
  TOP w0.147: v4(227.55,135.29) 227.55,135.34 U1.AK4
  SIG4 w0.112: v4(227.55,135.29) 227.55,135.07 arc(227.59,134.98) 227.68,134.94 227.83,134.94 arc(227.97,134.91) 228.08,134.84 228.08,134.84 arc(228.16,134.72) 228.18,134.59 228.18,134.21 arc(228.2,134.11) 228.26,134.02 arc(228.35,133.96) 228.46,133.94 232.1,133.94 232.19,134.03 232.22,134.03
  SIG4 w0.16: 232.22,134.03 232.56,134.03 arc(232.85,134.09) 233.1,134.25 233.66,134.81 arc(233.91,134.98) 234.2,135.04 243.71,135.04 arc(244,134.98) 244.25,134.81 267.53,111.53 arc(267.81,111.11) 267.91,110.61 267.91,103.63 arc(267.97,103.31) 268.15,103.03 278.23,92.96 arc(278.58,92.43) 278.7,91.82 278.7,88.89 arc(278.96,88.27) 279.58,88.01 279.74,88.01 arc(280.22,87.91) 280.62,87.64 arc(280.99,87.1) 281.11,86.45 281.11,76.74 arc(281.17,76.45) 281.34,76.2 288.64,68.9 arc(288.8,68.66) 288.86,68.36 288.86,62.54 arc(288.8,62.25) 288.64,62 285.88,59.25 arc(285.64,59.08) 285.34,59.03 275.75,59.03 arc(275.61,59) 275.48,58.91 275.43,58.86 arc(275.34,58.72) 275.31,58.57 275.31,57.97 arc(275.28,57.85) 275.21,57.75 274.91,57.45 274.71,57.24 arc(274.55,57.01) 274.5,56.74 YJ31.D33
FC47_TDN2: length 137.7
  TOP w0.147: v4(225.55,134.39) 225.55,134.48 arc(225.53,134.56) 225.49,134.62 225.41,134.7 arc(225.25,134.81) 225.07,134.84 U1.AJ6
  SIG4 w0.112: v4(225.55,134.39) 225.55,134.62 arc(225.59,134.71) 225.68,134.74 225.83,134.74 arc(225.97,134.77) 226.08,134.85 arc(226.16,134.96) 226.18,135.09 226.18,135.47 arc(226.2,135.58) 226.26,135.66 arc(226.35,135.73) 226.46,135.75 231.97,135.75 232.06,135.65 232.09,135.65
  SIG4 w0.16: 232.09,135.65 232.28,135.65 arc(232.6,135.72) 232.87,135.9 233.64,136.66 arc(233.76,136.75) 233.91,136.78 244.64,136.78 arc(244.78,136.75) 244.9,136.66 274.02,107.55 arc(274.1,107.43) 274.13,107.28 274.13,100.67 arc(274.22,100.24) 274.46,99.87 280.62,93.71 arc(280.7,93.58) 280.73,93.44 280.73,91.53 arc(280.82,91.09) 281.07,90.72 284.81,86.98 arc(284.9,86.85) 284.92,86.71 284.92,75.65 arc(285.01,75.21) 285.26,74.84 290.65,69.45 arc(290.74,69.32) 290.77,69.18 290.77,61.15 arc(290.74,61) 290.65,60.88 289.9,60.13 289.54,60.13 289.19,59.77 289.19,59.41 288.82,59.04 288.46,59.04 288.1,58.68 288.1,58.32 287.74,57.97 287.41,57.97 287.02,57.58 287.02,57.25 286.67,56.89 286.33,56.89 285.95,56.5 285.95,56.17 285.3,55.52 arc(285.17,55.44) 285.03,55.41 275.75,55.41 arc(275.46,55.35) 275.21,55.18 275.16,55.13 275.12,55.08 arc(274.87,54.92) 274.58,54.86 273.68,54.86 arc(273.49,54.78) 273.41,54.59 273.41,54.32 arc(273.44,54.13) 273.55,53.97 YJ31.D5
FC47_TDN3: length 125.7
  TOP w0.147: U1.AH1 230.05,133.79 v4(230.55,133.29)
  SIG5 w0.112: 231.98,134.04 231.95,134.04 231.86,133.94 231.39,133.94 arc(231.23,133.91) 231.1,133.83 arc(231.02,133.7) 230.99,133.54 230.99,133.11 arc(230.97,133.04) 230.94,132.99 230.93,132.98 arc(230.88,132.95) 230.84,132.94 230.68,132.94 arc(230.59,132.98) 230.55,133.07 v4(230.55,133.29)
  SIG5 w0.16: 231.98,134.04 233.78,134.04 arc(234.07,133.98) 234.32,133.81 234.33,133.8 arc(234.58,133.63) 234.87,133.58 244.99,133.58 arc(245.42,133.49) 245.79,133.24 271.89,107.14 arc(272.14,106.77) 272.22,106.34 272.22,99.12 arc(272.25,98.97) 272.34,98.85 278.37,92.82 arc(278.61,92.45) 278.7,92.01 278.7,88.83 arc(278.76,88.54) 278.93,88.29 278.99,88.23 arc(279.23,88.07) 279.53,88.01 279.81,88.01 arc(280.22,87.93) 280.57,87.69 280.78,87.49 arc(281.03,87.11) 281.11,86.68 281.11,76.46 arc(281.14,76.32) 281.23,76.19 288.05,69.37 arc(288.3,69) 288.38,68.56 288.38,62.45 arc(288.33,62.15) 288.16,61.91 287.84,61.58 285.5,59.25 arc(285.25,59.08) 284.96,59.03 273.35,59.03 arc(273.21,59) 273.08,58.91 arc(272.98,58.78) 272.92,58.63 arc(272.91,58.56) 272.91,58.49 272.91,57.97 arc(272.88,57.85) 272.81,57.75 272.24,57.18 arc(272.14,57.02) 272.1,56.83 YJ31.D36
