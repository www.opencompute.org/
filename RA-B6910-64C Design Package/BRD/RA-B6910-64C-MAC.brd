# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC53_RDN2: length 160.5
  TOP w0.147: v4(220.55,154.29) 220.55,154.21 arc(220.53,154.13) 220.49,154.06 220.41,153.98 arc(220.25,153.88) 220.07,153.84 U1.BH11
  SIG8 w0.112: 232.01,153.03 231.92,152.94 221.54,152.94 arc(221.4,152.97) 221.29,153.05 221.25,153.08 arc(221.2,153.16) 221.18,153.25 221.18,153.63 arc(221.16,153.75) 221.09,153.85 arc(220.99,153.92) 220.87,153.94 220.65,153.94 arc(220.58,153.97) 220.55,154.04 v4(220.55,154.29)
  SIG8 w0.16: YJ34.A17 319.32,62.04 arc(319.38,62.13) 319.4,62.24 319.4,62.45 arc(319.38,62.56) 319.32,62.65 319.22,62.76 arc(319.1,62.83) 318.96,62.86 318.1,62.86 arc(317.86,62.91) 317.66,63.04 arc(317.66,63.04) 317.66,63.04 317.62,63.09 317.53,63.17 arc(317.28,63.34) 316.99,63.4 arc(316.94,63.4) 316.9,63.43 316.84,63.49 arc(316.8,63.55) 316.79,63.61 316.79,69.65 arc(316.85,69.94) 317.02,70.19 319.19,72.37 arc(319.36,72.61) 319.42,72.91 319.42,93.46 arc(319.33,93.9) 319.08,94.27 294.94,118.41 arc(294.57,118.66) 294.13,118.74 280.03,118.74 arc(279.89,118.77) 279.76,118.85 245.54,153.08 arc(245.17,153.33) 244.73,153.41 235.13,153.41 arc(234.74,153.33) 234.4,153.11 arc(234.38,153.09) 234.36,153.08 arc(234.29,153.04) 234.21,153.03 232.01,153.03
FC53_RDN3: length 155.2
  TOP w0.147: U1.BG7 224.55,153.34 v4(224.55,153.39)
  SIG9 w0.112: v4(224.55,153.39) 224.55,153.64 arc(224.58,153.71) 224.65,153.74 224.87,153.74 arc(224.99,153.77) 225.09,153.84 arc(225.16,153.94) 225.18,154.06 225.18,154.44 arc(225.2,154.53) 225.25,154.61 225.29,154.64 arc(225.4,154.72) 225.54,154.75 231.72,154.75 arc(231.84,154.72) 231.94,154.65
  SIG9 w0.16: YJ34.A24 320.7,64.71 arc(320.64,65.01) 320.47,65.27 320.09,65.65 arc(319.96,65.84) 319.91,66.07 319.91,66.48 arc(319.91,66.53) 319.9,66.57 arc(319.89,66.6) 319.89,66.62 arc(319.89,66.62) 319.89,66.62 arc(319.85,66.7) 319.79,66.77 319.75,66.82 319.67,66.9 arc(319.35,67.66) 319.67,68.41 319.98,68.73 319.98,69.03 320.37,69.42 320.67,69.42 320.9,69.65 arc(321.06,69.89) 321.12,70.18 321.12,70.69 320.81,71 320.81,71.43 321.12,71.73 321.12,94.58 arc(321.09,94.72) 321.01,94.85 295.44,120.41 arc(295.32,120.49) 295.18,120.52 287.05,120.52 arc(286.61,120.61) 286.24,120.86 252.09,155 arc(251.97,155.09) 251.82,155.12 233.48,155.12 arc(233.18,155.06) 232.94,154.89 232.92,154.88 arc(232.67,154.71) 232.38,154.65 231.94,154.65
FC53_RDP0: length 161.6
  TOP w0.147: U1.BG13 218.55,153.34 v4(218.55,153.39)
  SIG8 w0.112: v4(218.55,153.39) 218.55,153.64 arc(218.58,153.71) 218.65,153.74 218.87,153.74 arc(218.99,153.77) 219.09,153.84 arc(219.16,153.94) 219.18,154.06 219.18,154.43 arc(219.2,154.53) 219.25,154.61 219.29,154.64 arc(219.4,154.72) 219.54,154.74 231.85,154.74 231.94,154.65
  SIG8 w0.16: YJ34.A21 318.3,64.62 arc(318.22,65) 318.01,65.32 317.75,65.58 arc(317.57,65.85) 317.51,66.17 317.51,67.42 arc(317.6,67.86) 317.85,68.23 318.36,68.74 318.36,69.13 318.69,69.46 319.08,69.46 321.01,71.39 arc(321.09,71.52) 321.12,71.66 321.12,94.45 arc(321.06,94.74) 320.9,94.99 295.59,120.3 arc(295.34,120.46) 295.05,120.52 280.92,120.52 arc(280.63,120.58) 280.38,120.74 246.24,154.89 arc(245.99,155.06) 245.7,155.12 233.83,155.12 arc(233.54,155.06) 233.29,154.89 233.28,154.88 arc(233.03,154.71) 232.74,154.65 231.94,154.65
FC53_RDP1: length 160.5
  TOP w0.147: U1.BH9 222.16,153.84 arc(222.27,153.86) 222.35,153.92 222.43,153.99 arc(222.52,154.13) v4(222.55,154.29)
  SIG9 w0.112: v4(222.55,154.29) 222.55,154.04 arc(222.58,153.97) 222.65,153.94 222.87,153.94 arc(222.99,153.92) 223.09,153.85 arc(223.16,153.75) 223.18,153.63 223.18,153.25 arc(223.2,153.15) 223.25,153.07 223.29,153.04 arc(223.4,152.96) 223.54,152.94 231.72,152.94 arc(231.84,152.96) 231.94,153.03
  SIG9 w0.16: 231.94,153.03 233.98,153.03 arc(234.08,153.05) 234.17,153.11 arc(234.27,153.2) 234.37,153.27 arc(234.63,153.38) 234.9,153.41 250.88,153.41 arc(251.18,153.36) 251.42,153.19 285.65,118.97 arc(285.89,118.8) 286.19,118.74 294.27,118.74 arc(294.56,118.68) 294.81,118.52 296.49,116.84 319.19,94.13 arc(319.36,93.88) 319.42,93.59 319.42,73.03 arc(319.36,72.74) 319.19,72.49 317.91,71.21 arc(317.75,70.97) 317.69,70.67 317.69,67.5 arc(317.63,67.2) 317.47,66.96 316.89,66.38 arc(316.72,66.13) 316.66,65.84 316.66,64.7 arc(316.72,64.41) 316.89,64.16 317.43,63.62 arc(317.68,63.45) 317.97,63.39 319.39,63.39 arc(319.68,63.34) 319.93,63.17 320.02,63.08 arc(320.26,62.92) 320.56,62.86 321.46,62.86 arc(321.7,62.76) 321.8,62.52 321.8,62.34 arc(321.76,62.14) 321.65,61.97 YJ34.A14
FC53_RDP2: length 160.5
  TOP w0.147: v4(220.55,153.39) 220.55,153.34 U1.BG11
  SIG8 w0.112: v4(220.55,153.39) 220.55,153.64 arc(220.58,153.71) 220.65,153.74 220.87,153.74 arc(220.91,153.73) 220.95,153.71 arc(220.98,153.67) 220.99,153.63 220.99,153.25 arc(221.02,153.08) 221.12,152.94 221.15,152.91 arc(221.33,152.79) 221.54,152.74 231.92,152.74 232.01,152.65
  SIG8 w0.16: 232.01,152.65 234.21,152.65 arc(234.4,152.68) 234.57,152.76 arc(234.62,152.8) 234.67,152.84 arc(234.88,152.98) 235.13,153.03 244.73,153.03 arc(245.02,152.97) 245.27,152.81 279.49,118.58 arc(279.74,118.42) 280.03,118.36 294.13,118.36 arc(294.43,118.3) 294.67,118.14 318.81,94 arc(318.98,93.75) 319.04,93.46 319.04,93.46 319.04,77.48 318.88,77.33 318.88,76.61 319.04,76.46 319.04,75.95 318.88,75.8 318.88,75.09 319.04,74.94 319.04,74.43 318.86,74.25 318.86,73.59 319.04,73.41 319.04,72.91 arc(319.01,72.76) 318.93,72.64 316.75,70.46 arc(316.5,70.09) 316.41,69.65 316.41,63.61 arc(316.45,63.4) 316.57,63.23 316.63,63.16 arc(316.8,63.05) 316.99,63.01 arc(317.14,62.98) 317.26,62.9 317.35,62.82 317.39,62.77 arc(317.48,62.64) 317.51,62.48 317.51,62.07 arc(317.56,61.84) 317.69,61.65 318.03,61.3 arc(318.23,61.01) 318.3,60.66 YJ34.A18
FC53_RDP3: length 155.3
  TOP w0.147: U1.BH7 224.16,153.84 arc(224.27,153.86) 224.35,153.92 224.43,153.99 arc(224.52,154.13) v4(224.55,154.29)
  SIG9 w0.112: v4(224.55,154.29) 224.55,154.04 arc(224.58,153.97) 224.65,153.94 224.87,153.94 arc(224.91,153.95) 224.95,153.97 arc(224.98,154.01) 224.99,154.06 224.99,154.44 arc(225.02,154.6) 225.12,154.75 225.15,154.78 arc(225.33,154.9) 225.54,154.94 231.72,154.94 arc(231.84,154.97) 231.94,155.03
  SIG9 w0.16: 231.94,155.03 232.38,155.03 arc(232.53,155.06) 232.65,155.15 232.67,155.16 arc(233.04,155.41) 233.48,155.5 251.82,155.5 arc(252.12,155.44) 252.36,155.27 286.51,121.12 arc(286.76,120.96) 287.05,120.9 295.18,120.9 arc(295.47,120.84) 295.71,120.68 299.56,116.84 321.28,95.12 arc(321.44,94.87) 321.5,94.58 321.5,70.18 arc(321.41,69.75) 321.17,69.38 319.94,68.15 arc(319.73,67.66) 319.94,67.17 320.06,67.05 arc(320.26,66.91) 320.5,66.86 321.46,66.86 arc(321.7,66.76) 321.8,66.52 321.8,66.34 arc(321.76,66.14) 321.65,65.97 YJ34.A25
FC53_TDN0: length 157.5
  TOP w0.147: U1.BG1 230.55,153.34 v4(230.55,153.39)
  SIG7 w0.112: 231.57,154.8 231.55,154.78 231.42,154.78 231.32,154.67 arc(231.22,154.52) 231.18,154.34 231.18,154.03 arc(231.15,153.89) 231.08,153.77 231.07,153.76 arc(230.96,153.69) 230.83,153.67 230.7,153.67 230.7,153.67 arc(230.59,153.62) 230.55,153.5 v4(230.55,153.39)
  SIG7 w0.155: 327.2,65.76 arc(327.13,65.91) 327.11,66.07
  SIG7 w0.16: 327.11,66.07 327.11,66.48 arc(327.11,66.53) 327.1,66.59 arc(327.06,66.69) 326.99,66.77 326.95,66.82 326.72,67.04 arc(326.35,67.59) 326.22,68.24 326.22,68.4 arc(326.28,68.68) 326.44,68.93 326.71,69.2 326.71,69.56 326.98,69.83 327.34,69.83 327.61,70.09 327.61,70.45 327.88,70.72 328.24,70.72 328.51,70.99 328.51,71.35 328.78,71.62 329.14,71.62 329.64,72.13 arc(329.73,72.25) 329.76,72.4 329.76,73.35 329.63,73.48 329.63,74.09 329.76,74.22 329.76,91.81 arc(329.66,92.28) 329.4,92.68 297.84,124.24 arc(297.17,124.68) 296.38,124.84 276.6,124.84 arc(276.31,124.9) 276.07,125.06 246.17,154.95 arc(246.05,155.04) 245.9,155.06 232.02,155.06 arc(231.86,155.03) 231.71,154.94 231.57,154.8 ; YJ34.A33 327.9,64.73 arc(327.84,65.01) 327.68,65.25 327.33,65.6 arc(327.26,65.68) 327.2,65.76
FC53_TDN1: length 167.1
  TOP w0.147: U1.BH3 228.1,153.84 arc(228.42,153.97) v4(228.55,154.29)
  SIG6 w0.112: v4(228.55,154.29) 228.55,154.07 arc(228.59,153.98) 228.68,153.94 228.84,153.94 arc(228.96,153.92) 229.07,153.85 229.08,153.83 arc(229.15,153.72) 229.18,153.58 229.18,153.14 arc(229.2,153.06) 229.24,153 arc(229.31,152.95) 229.39,152.94 231.84,152.94 231.94,153.03 231.96,153.03
  SIG6 w0.16: 231.96,153.03 232.32,153.03 arc(232.34,153.03) 232.36,153.05 arc(232.62,153.22) 232.94,153.29 244.86,153.29 arc(245.3,153.2) 245.67,152.95 275.45,123.17 arc(275.57,123.09) 275.72,123.06 296.27,123.06 arc(296.56,123) 296.81,122.84 321.28,98.37 arc(321.44,98.12) 321.5,97.83 321.5,71.92 arc(321.44,71.62) 321.28,71.38 316.94,67.04 arc(316.78,66.8) 316.72,66.51 316.72,64.69 arc(316.78,64.4) 316.94,64.15 317.48,63.62 arc(317.73,63.45) 318.02,63.39 326.59,63.39 arc(326.88,63.34) 327.13,63.17 327.29,63.01 arc(327.46,62.9) 327.65,62.86 328.66,62.86 arc(328.9,62.76) 329,62.52 329,62.34 arc(328.96,62.14) 328.85,61.97 YJ34.A5
FC53_TDN2: length 159.3
  TOP w0.147: v4(226.55,153.39) 226.55,153.34 U1.BG5
  SIG6 w0.112: 232.03,154.65 232,154.65 231.91,154.75 227.39,154.75 arc(227.31,154.73) 227.24,154.69 arc(227.2,154.62) 227.18,154.54 227.18,154.11 arc(227.15,153.97) 227.08,153.85 227.07,153.84 arc(226.96,153.77) 226.84,153.74 226.68,153.74 arc(226.59,153.71) 226.55,153.62 v4(226.55,153.39)
  SIG6 w0.16: 232.03,154.65 233.58,154.65 arc(233.99,154.74) 234.34,154.97 arc(234.43,155.03) 234.54,155.06 arc(234.55,155.06) 234.57,155.06 245.91,155.06 arc(246.05,155.04) 246.17,154.95 275.95,125.17 arc(276.32,124.93) 276.76,124.84 296.92,124.84 arc(297.21,124.78) 297.46,124.62 327.45,94.62 arc(327.61,94.38) 327.67,94.08 327.67,71.84 327.5,71.66 327.5,71.1 327.67,70.93 327.67,70.47 arc(327.76,70.03) 328.01,69.66 328.33,69.34 328.33,69.09 328.73,68.69 328.98,68.69 329.4,68.27 arc(329.48,68.14) 329.51,68 329.51,66.07 arc(329.56,65.84) 329.69,65.65 329.98,65.35 330.18,65.16 arc(330.27,65.02) 330.3,64.86 YJ34.A36
FC53_TDN3: length 176
  TOP w0.147: U1.BF2 229.1,151.84 arc(229.42,151.97) v4(229.55,152.29)
  SIG7 w0.112: 232.09,153.03 232,152.94 230.39,152.94 arc(230.23,152.91) 230.1,152.83 arc(230.02,152.7) 229.99,152.54 229.99,152.11 arc(229.97,152.04) 229.94,151.99 229.93,151.98 arc(229.88,151.95) 229.83,151.94 229.69,151.94 arc(229.59,151.98) 229.55,152.09 v4(229.55,152.29)
  SIG7 w0.16: 232.09,153.03 233.22,153.03 arc(233.25,153.04) 233.28,153.05 233.72,153.23 arc(233.86,153.27) 234.01,153.29 244.99,153.29 arc(245.28,153.23) 245.52,153.06 275.41,123.17 arc(275.54,123.09) 275.68,123.06 295.71,123.06 arc(296.52,122.9) 297.21,122.44 327.62,92.02 arc(327.94,91.55) 328.05,90.99 328.05,76.83 arc(328,76.55) 327.84,76.31 327.33,75.8 arc(327.11,75.48) 327.04,75.11 327.04,73.15 arc(326.94,72.66) 326.66,72.24 322.71,68.29 arc(322.47,68.13) 322.18,68.07 318.92,68.07 arc(318.63,68.01) 318.38,67.85 316.94,66.41 arc(316.78,66.17) 316.72,65.87 316.72,64.54 arc(316.78,64.25) 316.94,64 317.33,63.62 arc(317.58,63.45) 317.87,63.39 328.99,63.39 arc(329.28,63.34) 329.53,63.17 329.62,63.08 arc(329.86,62.92) 330.16,62.86 331.06,62.86 arc(331.3,62.76) 331.4,62.52 331.4,62.34 arc(331.36,62.14) 331.25,61.97 YJ34.A2
FC53_TDP0: length 157.5
  TOP w0.147: U1.BH1 230.1,153.84 arc(230.42,153.97) v4(230.55,154.29)
  SIG7 w0.112: v4(230.55,154.29) 230.55,154.01 arc(230.59,153.91) 230.69,153.86 230.83,153.86 arc(230.88,153.87) 230.93,153.9 230.94,153.91 arc(230.97,153.97) 230.99,154.03 230.99,154.34 arc(231.04,154.6) 231.18,154.81 231.28,154.92 231.28,155.05 231.3,155.07
  SIG7 w0.16: 231.3,155.07 231.44,155.21 arc(231.71,155.38) 232.02,155.45 245.9,155.45 arc(246.2,155.39) 246.44,155.22 276.33,125.33 arc(276.46,125.25) 276.6,125.22 296.38,125.22 arc(297.32,125.03) 298.11,124.51 329.66,92.95 arc(330.01,92.42) 330.14,91.81 330.14,72.4 arc(330.08,72.11) 329.91,71.86 326.71,68.66 arc(326.63,68.54) 326.6,68.4 326.6,68.24 arc(326.7,67.74) 326.99,67.31 327.22,67.08 arc(327.46,66.92) 327.76,66.86 328.66,66.86 arc(328.9,66.76) 329,66.52 329,66.34 arc(328.96,66.14) 328.85,65.97 YJ34.A34
FC53_TDP1: length 167.1
  TOP w0.147: U1.BG3 228.55,153.34 v4(228.55,153.39)
  SIG6 w0.112: 231.96,152.65 231.94,152.65 231.84,152.74 229.39,152.74 arc(229.23,152.77) 229.1,152.86 arc(229.02,152.99) 228.99,153.14 228.99,153.58 arc(228.97,153.64) 228.94,153.69 228.93,153.71 arc(228.88,153.73) 228.84,153.74 228.68,153.74 arc(228.59,153.71) 228.55,153.62 v4(228.55,153.39)
  SIG6 w0.155: 327.18,61.8 arc(327.13,61.93) 327.11,62.07
  SIG6 w0.16: 327.11,62.07 327.11,62.48 arc(327.11,62.53) 327.1,62.58 arc(327.1,62.59) 327.09,62.6 arc(327.05,62.69) 326.99,62.77 326.95,62.82 326.86,62.9 arc(326.74,62.98) 326.59,63.01 318.02,63.01 arc(317.58,63.1) 317.21,63.35 316.68,63.88 arc(316.43,64.25) 316.34,64.69 316.34,66.51 arc(316.43,66.94) 316.68,67.31 317.17,67.81 317.17,68.07 317.56,68.46 317.82,68.46 318.16,68.8 318.16,69.06 318.55,69.45 318.82,69.45 319.15,69.79 319.15,70.03 319.57,70.45 319.81,70.45 321.01,71.65 arc(321.09,71.77) 321.12,71.92 321.12,97.83 arc(321.09,97.98) 321.01,98.1 296.54,122.57 arc(296.42,122.65) 296.27,122.68 275.72,122.68 arc(275.42,122.74) 275.18,122.9 245.4,152.68 arc(245.15,152.85) 244.86,152.91 232.94,152.91 arc(232.77,152.87) 232.63,152.78 arc(232.49,152.68) 232.32,152.65 231.96,152.65 ; YJ34.A6 327.9,60.75 arc(327.85,61.01) 327.7,61.24 327.32,61.62 arc(327.24,61.7) 327.18,61.8
FC53_TDP2: length 159.3
  TOP w0.147: U1.BH5 226.1,153.84 arc(226.42,153.97) v4(226.55,154.29)
  SIG6 w0.112: v4(226.55,154.29) 226.55,154.07 arc(226.59,153.98) 226.68,153.94 226.84,153.94 arc(226.88,153.95) 226.93,153.98 226.94,153.99 arc(226.97,154.04) 226.99,154.11 226.99,154.54 arc(227.02,154.7) 227.1,154.83 arc(227.23,154.91) 227.39,154.94 231.91,154.94 232,155.03 232.03,155.03
  SIG6 w0.16: 232.03,155.03 233.58,155.03 arc(233.84,155.09) 234.07,155.24 arc(234.27,155.38) 234.51,155.44 arc(234.54,155.44) 234.57,155.45 245.91,155.45 arc(246.2,155.39) 246.44,155.22 276.22,125.44 arc(276.47,125.28) 276.76,125.22 296.92,125.22 arc(297.36,125.13) 297.73,124.88 327.72,94.89 arc(327.97,94.52) 328.05,94.08 328.05,70.47 arc(328.11,70.18) 328.28,69.93 329.67,68.54 arc(329.83,68.29) 329.89,68 329.89,67.08 arc(329.96,66.93) 330.11,66.86 331.06,66.86 arc(331.3,66.76) 331.4,66.52 331.4,66.34 arc(331.36,66.14) 331.25,65.97 YJ34.A37
FC53_TDP3: length 176
  TOP w0.147: U1.BE2 229.55,151.34 v4(229.55,151.39)
  SIG7 w0.112: 232.09,152.65 232,152.75 230.39,152.75 arc(230.31,152.73) 230.24,152.69 arc(230.2,152.62) 230.18,152.54 230.18,152.11 arc(230.15,151.97) 230.08,151.85 230.07,151.84 arc(229.96,151.77) 229.83,151.74 229.71,151.74 arc(229.6,151.7) 229.55,151.58 v4(229.55,151.39)
  SIG7 w0.16: YJ34.A3 330.3,60.75 arc(330.25,61.01) 330.1,61.24 329.69,61.65 arc(329.56,61.84) 329.51,62.07 329.51,62.48 arc(329.51,62.53) 329.5,62.57 arc(329.46,62.68) 329.39,62.77 329.35,62.82 329.26,62.9 arc(329.14,62.98) 328.99,63.01 317.87,63.01 arc(317.43,63.1) 317.06,63.35 316.68,63.74 arc(316.43,64.11) 316.34,64.54 316.34,65.87 arc(316.43,66.31) 316.68,66.68 318.11,68.12 arc(318.48,68.36) 318.92,68.45 319.37,68.45 319.58,68.65 320.03,68.65 320.24,68.45 320.74,68.45 320.92,68.63 321.4,68.63 321.58,68.45 322.18,68.45 arc(322.32,68.48) 322.45,68.56 322.77,68.89 322.77,69.08 323.18,69.5 323.38,69.5 323.7,69.82 323.7,69.82 326.39,72.51 arc(326.59,72.8) 326.66,73.15 326.66,75.11 arc(326.76,75.63) 327.06,76.07 327.57,76.58 arc(327.65,76.7) 327.67,76.83 327.67,90.99 arc(327.59,91.4) 327.36,91.75 296.94,122.17 arc(296.38,122.55) 295.71,122.68 275.68,122.68 arc(275.39,122.74) 275.15,122.9 245.25,152.79 arc(245.13,152.88) 244.98,152.91 234.01,152.91 arc(233.94,152.9) 233.86,152.88 233.42,152.69 arc(233.32,152.66) 233.22,152.65 232.09,152.65
FC54_55_PVDD0P8: length 4.7
  TOP w0.229: U1.BD18 v1(213.55,150.34) ; U1.BF18 v1(213.55,152.34)
  TOP w0.381: 237.34,163.04 C3097.1 ; C3097.1 238.53,163.04 ; C3097.1 237.93,163.68
  BOTTOM w0.381: C3052.1 214.03,149.86 v1(213.55,150.34) ; C3339.1 214.03,151.86 v1(213.55,152.34)
  vias: v1(237.43,164.21) v1(238.44,164.21)
FC54_RDN0: length 167.4
  TOP w0.147: v4(218.55,156.39) 218.55,156.34 U1.BK13
  SIG2 w0.112: v4(218.55,156.39) 218.55,156.62 arc(218.59,156.71) 218.68,156.74 218.88,156.74 arc(218.92,156.73) 218.95,156.71 arc(218.98,156.68) 218.99,156.63 218.99,156.33 arc(219.03,156.11) 219.16,155.92 arc(219.35,155.79) 219.57,155.75 224.67,155.75 arc(224.78,155.72) 224.87,155.66 arc(224.93,155.57) 224.95,155.47 224.95,155.21 arc(224.99,155.03) 225.09,154.88 225.12,154.85 arc(225.24,154.77) 225.37,154.74 231.97,154.74 232.06,154.65 232.09,154.65
  SIG2 w0.16: YJ33.C22 330.15,65.97 arc(330.04,66.13) 330.01,66.32 330.01,66.57 arc(330.09,66.78) 330.3,66.86 331.19,66.86 arc(331.32,66.89) 331.43,66.96 arc(331.5,67.07) 331.53,67.19 331.53,68.04 arc(331.47,68.33) 331.3,68.58 330.94,68.94 330.61,68.94 330.22,69.32 330.22,69.66 329.87,70.02 329.53,70.02 329.15,70.4 329.15,70.74 327.91,71.98 arc(327.74,72.22) 327.68,72.52 327.68,72.95 327.45,73.18 327.45,73.74 327.68,73.96 327.68,74.47 327.45,74.7 327.45,75.26 327.68,75.49 327.68,76 327.48,76.2 327.48,76.81 327.68,77.01 327.68,91.13 arc(327.62,91.42) 327.46,91.67 296.67,122.46 arc(296.43,122.62) 296.14,122.68 275.72,122.68 arc(275.42,122.74) 275.18,122.9 243.22,154.86 arc(242.97,155.03) 242.68,155.08 233.56,155.08 arc(233.28,155.03) 233.04,154.87 233.04,154.87 arc(232.8,154.71) 232.52,154.65 232.09,154.65
FC54_RDN1: length 171.4
  TOP w0.147: v4(222.55,157.29) 222.44,157.29 arc(222.34,157.27) 222.26,157.21 222.17,157.12 arc(222.08,156.99) U1.BL9
  SIG3 w0.112: v4(222.55,157.29) 222.55,157.07 arc(222.59,156.98) 222.68,156.94 222.88,156.94 arc(222.92,156.95) 222.95,156.97 arc(222.98,157.01) 222.99,157.05 222.99,157.35 arc(223.03,157.58) 223.16,157.77 arc(223.35,157.89) 223.57,157.94 225.59,157.94 arc(225.79,157.9) 225.96,157.79 arc(226.07,157.62) 226.11,157.42 226.11,157.21 arc(226.13,157.1) 226.19,157.02 arc(226.28,156.96) 226.38,156.94 231.87,156.94 231.96,157.03 231.99,157.03
  SIG3 w0.16: 231.99,157.03 233.74,157.03 arc(233.89,157.06) 234.01,157.14 234.08,157.21 arc(234.45,157.46) 234.89,157.54 243.81,157.54 arc(244.1,157.49) 244.34,157.32 276.22,125.44 arc(276.47,125.28) 276.76,125.22 297.08,125.22 arc(297.37,125.16) 297.62,125 329.91,92.7 arc(330.08,92.45) 330.14,92.16 330.14,71.05 arc(330.19,70.76) 330.36,70.51 333.46,67.41 arc(333.62,67.17) 333.68,66.87 333.68,64.83 arc(333.62,64.54) 333.46,64.29 332.03,62.86 arc(331.94,62.72) 331.91,62.57 331.91,61.97 arc(331.88,61.85) 331.81,61.75 331.5,61.44 331.24,61.18 arc(331.14,61.02) 331.1,60.83 YJ33.C18
FC54_RDN2: length 176.8
  TOP w0.147: U1.BK11 220.55,156.34 v4(220.55,156.39)
  SIG2 w0.112: 232.22,156.65 232.19,156.65 232.1,156.74 226.4,156.74 arc(226.23,156.78) 226.08,156.88 arc(225.98,157.03) 225.94,157.21 225.94,157.42 arc(225.92,157.54) 225.85,157.65 arc(225.74,157.72) 225.62,157.74 221.57,157.74 arc(221.42,157.71) 221.3,157.63 arc(221.21,157.5) 221.18,157.35 221.18,157.05 arc(221.16,156.93) 221.09,156.83 arc(220.99,156.77) 220.88,156.74 220.68,156.74 arc(220.59,156.71) 220.55,156.62 v4(220.55,156.39)
  SIG2 w0.16: 232.22,156.65 233.74,156.65 arc(234.04,156.71) 234.28,156.87 234.35,156.94 arc(234.6,157.11) 234.89,157.16 243.65,157.16 arc(243.94,157.11) 244.19,156.94 276.07,125.06 arc(276.31,124.9) 276.6,124.84 296.92,124.84 arc(297.21,124.78) 297.46,124.62 329.55,92.53 arc(329.71,92.28) 329.77,91.99 329.77,73.65 arc(329.83,73.36) 329.99,73.12 333.03,70.07 333.03,69.77 333.44,69.36 333.75,69.36 334.11,69 arc(334.17,68.91) 334.19,68.81 334.19,68.38 333.94,68.12 333.94,67.61 334.19,67.36 334.19,66.85 333.94,66.6 333.94,66.04 334.19,65.78 334.19,65.33 arc(334.16,65.18) 334.08,65.06 333.71,64.69 333.35,64.69 332.99,64.33 332.99,63.97 332.54,63.52 arc(332.42,63.44) 332.27,63.41 329.95,63.41 arc(329.77,63.38) 329.6,63.32 arc(329.5,63.26) 329.41,63.18 329.36,63.13 329.32,63.08 arc(329.07,62.92) 328.78,62.86 327.89,62.86 arc(327.69,62.78) 327.61,62.58 327.61,62.32 arc(327.64,62.13) 327.75,61.97 YJ33.C14
FC54_RDN3: length 160.5
  TOP w0.147: v4(224.55,157.29) 224.44,157.29 arc(224.34,157.27) 224.26,157.21 224.17,157.12 arc(224.08,156.99) U1.BL7
  SIG3 w0.112: v4(224.55,157.29) 224.55,157.07 arc(224.59,156.98) 224.68,156.94 224.88,156.94 arc(224.99,156.92) 225.09,156.85 arc(225.16,156.75) 225.18,156.63 225.18,155.15 arc(225.2,155.07) 225.24,155 arc(225.31,154.96) 225.39,154.94 232.1,154.94 232.19,155.04 232.22,155.04
  SIG3 w0.16: YJ33.C24 328.7,64.83 arc(328.74,65.02) 328.85,65.18 329.35,65.69 arc(329.45,65.83) 329.48,66 329.48,67.54 arc(329.43,67.83) 329.26,68.08 328.28,69.07 arc(328.11,69.31) 328.05,69.6 328.05,91.3 arc(328,91.59) 327.83,91.84 296.83,122.84 arc(296.58,123) 296.29,123.06 275.87,123.06 arc(275.58,123.12) 275.33,123.28 243.81,154.81 arc(243.56,154.98) 243.27,155.04 232.22,155.04
FC54_RDP0: length 167.4
  TOP w0.147: U1.BL13 218.14,156.84 arc(218.24,156.86) 218.32,156.92 218.5,157.09 arc(218.53,157.15) 218.55,157.22 v4(218.55,157.29)
  SIG2 w0.112: 232.09,155.03 232.06,155.03 231.97,154.94 225.37,154.94 arc(225.31,154.95) 225.26,154.99 225.23,155.02 arc(225.17,155.1) 225.15,155.21 225.15,155.47 arc(225.11,155.65) 225.01,155.8 arc(224.85,155.91) 224.67,155.94 219.57,155.94 arc(219.42,155.97) 219.3,156.06 arc(219.21,156.18) 219.18,156.33 219.18,156.63 arc(219.16,156.75) 219.09,156.85 arc(218.99,156.92) 218.88,156.94 218.68,156.94 arc(218.59,156.98) 218.55,157.07 v4(218.55,157.29)
  SIG2 w0.16: YJ33.C21 331.1,64.78 arc(331.15,65.02) 331.28,65.21 331.81,65.75 arc(331.88,65.85) 331.91,65.97 331.91,68.04 arc(331.82,68.48) 331.57,68.85 328.18,72.25 arc(328.09,72.37) 328.06,72.52 328.06,91.13 arc(327.98,91.57) 327.73,91.94 296.94,122.73 arc(296.57,122.97) 296.14,123.06 275.72,123.06 arc(275.57,123.09) 275.45,123.17 243.49,155.13 arc(243.12,155.38) 242.68,155.46 233.56,155.46 arc(233.13,155.38) 232.77,155.14 arc(232.65,155.06) 232.52,155.03 232.09,155.03
FC54_RDP1: length 171.5
  TOP w0.147: v4(222.55,156.39) 222.55,156.34 U1.BK9
  SIG3 w0.112: 231.99,156.65 231.96,156.65 231.87,156.74 226.38,156.74 arc(226.2,156.78) 226.05,156.88 arc(225.95,157.03) 225.91,157.21 225.91,157.42 arc(225.89,157.54) 225.82,157.65 arc(225.72,157.72) 225.59,157.74 223.57,157.74 arc(223.42,157.71) 223.3,157.63 arc(223.21,157.5) 223.18,157.35 223.18,157.05 arc(223.16,156.93) 223.09,156.83 arc(222.99,156.77) 222.88,156.74 222.68,156.74 arc(222.59,156.71) 222.55,156.62 v4(222.55,156.39)
  SIG3 w0.16: 231.99,156.65 233.74,156.65 arc(234.04,156.71) 234.28,156.87 234.35,156.94 arc(234.6,157.11) 234.89,157.16 243.81,157.16 arc(243.95,157.13) 244.08,157.05 275.95,125.17 arc(276.32,124.93) 276.76,124.84 297.08,124.84 arc(297.23,124.81) 297.35,124.73 329.64,92.43 arc(329.73,92.31) 329.76,92.16 329.76,71.05 arc(329.84,70.61) 330.09,70.24 331.81,68.53 331.81,67.99 332.16,67.63 332.7,67.63 333.19,67.14 arc(333.27,67.02) 333.3,66.87 333.3,66.35 333,66.05 333,65.59 333.3,65.29 333.3,64.83 arc(333.27,64.68) 333.19,64.56 332.82,64.19 332.39,64.19 332.06,63.86 332.06,63.43 331.72,63.08 arc(331.47,62.92) 331.18,62.86 330.28,62.86 arc(330.09,62.78) 330.01,62.59 330.01,62.32 arc(330.04,62.13) 330.15,61.97 YJ33.C17
FC54_RDP2: length 176.8
  TOP w0.147: U1.BL11 220.15,156.84 arc(220.25,156.86) 220.33,156.92 220.49,157.08 arc(220.53,157.14) 220.55,157.21 v4(220.55,157.29)
  SIG2 w0.112: 232.22,157.03 232.19,157.03 232.1,156.94 226.4,156.94 arc(226.3,156.96) 226.22,157.02 arc(226.16,157.1) 226.14,157.21 226.14,157.42 arc(226.1,157.62) 225.99,157.79 arc(225.82,157.9) 225.62,157.94 221.57,157.94 arc(221.35,157.89) 221.16,157.77 arc(221.03,157.58) 220.99,157.35 220.99,157.05 arc(220.98,157.01) 220.95,156.97 arc(220.92,156.95) 220.88,156.94 220.68,156.94 arc(220.59,156.98) 220.55,157.07 v4(220.55,157.29)
  SIG2 w0.16: YJ33.C15 328.7,60.78 arc(328.75,61.02) 328.88,61.21 329.41,61.75 arc(329.48,61.85) 329.51,61.97 329.51,62.57 arc(329.54,62.72) 329.63,62.86 329.68,62.91 arc(329.73,62.95) 329.78,62.98 arc(329.86,63.01) 329.95,63.03 332.27,63.03 arc(332.56,63.08) 332.81,63.25 334.35,64.79 arc(334.51,65.04) 334.57,65.33 334.57,68.81 arc(334.52,69.06) 334.38,69.27 330.26,73.38 arc(330.18,73.51) 330.15,73.65 330.15,91.99 arc(330.06,92.42) 329.82,92.8 297.73,124.88 arc(297.36,125.13) 296.92,125.22 276.6,125.22 arc(276.46,125.25) 276.33,125.33 244.46,157.21 arc(244.09,157.46) 243.65,157.54 234.89,157.54 arc(234.45,157.46) 234.08,157.21 234.01,157.14 arc(233.89,157.06) 233.74,157.03 232.22,157.03
FC54_RDP3: length 160.5
  TOP w0.147: v4(224.55,156.39) 224.55,156.34 U1.BK7
  SIG3 w0.112: v4(224.55,156.39) 224.55,156.62 arc(224.59,156.71) 224.68,156.74 224.88,156.74 arc(224.92,156.73) 224.95,156.71 arc(224.98,156.68) 224.99,156.63 224.99,155.15 arc(225.02,155) 225.1,154.86 arc(225.23,154.78) 225.39,154.75 232.1,154.75 232.19,154.66 232.22,154.66
  SIG3 w0.16: 232.22,154.66 232.73,154.66 233,154.38 233.46,154.38 233.74,154.66 234.25,154.66 234.53,154.38 234.99,154.38 235.27,154.66 235.77,154.66 236.03,154.4 236.54,154.4 236.79,154.66 237.3,154.66 237.55,154.4 238.06,154.4 238.31,154.66 243.27,154.66 arc(243.41,154.63) 243.54,154.54 275.06,123.01 arc(275.44,122.77) 275.87,122.68 296.29,122.68 arc(296.44,122.65) 296.56,122.57 327.56,91.57 arc(327.64,91.45) 327.67,91.3 327.67,69.6 arc(327.76,69.17) 328.01,68.8 328.99,67.81 arc(329.07,67.69) 329.1,67.54 329.1,67.07 arc(329.08,66.98) 329.03,66.91 arc(328.97,66.87) 328.89,66.86 327.88,66.86 arc(327.69,66.78) 327.61,66.59 327.61,66.32 arc(327.64,66.13) 327.75,65.97 YJ33.C25
FC54_TDN0: length 149.2
  TOP w0.147: v4(227.55,156.29) 227.55,156.21 arc(227.53,156.13) 227.49,156.06 227.41,155.98 arc(227.26,155.88) 227.07,155.84 U1.BK4
  SIG4 w0.112: 231.96,155.03 231.94,155.03 231.84,154.94 228.46,154.94 arc(228.35,154.96) 228.26,155.02 arc(228.2,155.11) 228.18,155.21 228.18,155.59 arc(228.16,155.72) 228.08,155.84 228.08,155.84 arc(227.97,155.91) 227.83,155.94 227.68,155.94 arc(227.59,155.98) 227.55,156.07 v4(227.55,156.29)
  SIG4 w0.16: YJ33.C36 319.1,64.8 arc(319.14,65.02) 319.27,65.2 319.81,65.75 arc(319.88,65.85) 319.91,65.97 319.91,67.05 arc(319.96,67.34) 320.13,67.59 321.66,69.12 arc(321.82,69.36) 321.88,69.66 321.88,77.71 arc(321.83,77.96) 321.7,78.16 arc(321.56,78.36) 321.51,78.61 321.51,91.5 arc(321.45,91.79) 321.29,92.04 294.81,118.52 arc(294.56,118.68) 294.27,118.74 291.4,118.74 arc(280.78,120.86) 271.77,126.87 269.59,129.06 243.84,154.8 arc(243.59,154.97) 243.3,155.03 231.96,155.03
FC54_TDN1: length 147.8
  TOP w0.147: U1.BJ2 229.55,155.34 v4(229.55,155.39)
  SIG5 w0.112: v4(229.55,155.39) 229.55,155.62 arc(229.59,155.71) 229.68,155.74 229.84,155.74 arc(229.88,155.73) 229.93,155.71 229.94,155.69 arc(229.97,155.64) 229.99,155.58 229.99,155.14 arc(230.02,154.99) 230.1,154.86 arc(230.23,154.77) 230.39,154.74 232.22,154.74 232.32,154.65 232.34,154.65
  SIG5 w0.16: YJ33.C34 320.55,65.97 arc(320.44,66.13) 320.41,66.32 320.41,66.59 arc(320.49,66.78) 320.68,66.86 321.75,66.86 arc(321.88,66.91) 321.93,67.03 321.93,68.04 321.8,68.17 321.8,68.86 321.93,68.98 321.93,69.62 arc(321.9,69.76) 321.81,69.88 321.47,70.23 321.25,70.23 320.88,70.6 320.88,70.82 319.37,72.33 arc(319.12,72.7) 319.03,73.14 319.03,93.41 arc(318.98,93.7) 318.81,93.95 294.62,118.14 arc(294.37,118.3) 294.08,118.36 280.03,118.36 arc(279.74,118.42) 279.49,118.58 243.65,154.43 arc(243.41,154.59) 243.12,154.65 241.49,154.65 241.34,154.5 240.57,154.5 240.42,154.65 239.66,154.65 239.51,154.5 238.75,154.5 238.59,154.65 237.83,154.65 237.68,154.5 236.92,154.5 236.76,154.65 236,154.65 235.85,154.5 235.09,154.5 234.94,154.65 234.17,154.65 234.02,154.5 233.26,154.5 233.11,154.65 232.34,154.65
FC54_TDN2: length 175.8
  TOP w0.147: v4(226.55,158.29) 226.55,158.21 arc(226.53,158.13) 226.49,158.06 226.41,157.98 arc(226.26,157.88) 226.07,157.84 U1.BM5
  SIG4 w0.112: v4(226.55,158.29) 226.55,158.07 arc(226.59,157.98) 226.68,157.94 226.83,157.94 arc(226.97,157.91) 227.08,157.84 227.08,157.84 arc(227.16,157.72) 227.18,157.59 227.18,157.21 arc(227.2,157.11) 227.26,157.02 arc(227.35,156.96) 227.46,156.94 231.87,156.94 231.96,157.03 231.99,157.03
  SIG4 w0.16: YJ33.C3 319.1,60.64 arc(319.17,61) 319.38,61.31 319.81,61.75 arc(319.88,61.85) 319.91,61.97 319.91,62.57 arc(319.94,62.72) 320.03,62.86 320.08,62.91 arc(320.21,63) 320.35,63.03 331.76,63.03 arc(332.05,63.08) 332.3,63.25 333.09,64.04 arc(333.25,64.28) 333.31,64.58 333.31,69.79 arc(333.25,70.08) 333.09,70.32 330.11,73.31 arc(329.94,73.55) 329.88,73.85 329.88,90.33 arc(329.82,90.63) 329.66,90.87 324.67,95.87 arc(324.42,96.03) 324.13,96.09 320.6,96.09 arc(320.31,96.15) 320.06,96.31 295.69,120.68 arc(295.45,120.84) 295.16,120.9 293.81,120.9 arc(281.78,123.3) 271.58,130.11 244.38,157.32 arc(244.13,157.48) 243.84,157.54 234.88,157.54 arc(234.45,157.45) 234.08,157.2 234.01,157.14 arc(233.89,157.06) 233.74,157.03 231.99,157.03
FC54_TDN3: length 171.7
  TOP w0.147: U1.BL3 228.55,157.34 v4(228.55,157.39)
  SIG5 w0.112: v4(228.55,157.39) 228.55,157.62 arc(228.59,157.71) 228.68,157.74 228.84,157.74 arc(228.88,157.73) 228.93,157.71 228.94,157.69 arc(228.97,157.64) 228.99,157.58 228.99,157.14 arc(229.02,156.99) 229.1,156.86 arc(229.23,156.77) 229.39,156.74 231.97,156.74 232.06,156.65 232.09,156.65
  SIG5 w0.16: YJ33.C5 320.55,61.97 arc(320.44,62.13) 320.41,62.32 320.41,62.56 arc(320.49,62.77) 320.71,62.86 321.58,62.86 arc(321.87,62.92) 322.12,63.08 322.16,63.13 322.21,63.18 arc(322.46,63.35) 322.75,63.41 331.64,63.41 arc(331.78,63.44) 331.9,63.52 332.7,64.32 arc(332.78,64.44) 332.81,64.58 332.81,65.92 arc(332.78,66.07) 332.7,66.19 331.29,67.61 330.94,67.61 330.64,67.91 330.64,68.26 330.32,68.58 329.97,68.58 329.67,68.88 329.67,69.23 329.35,69.55 329,69.55 328.7,69.85 328.7,70.2 328.38,70.52 328.03,70.52 327.73,70.82 327.73,71.17 327.13,71.77 arc(327,71.85) 326.86,71.88 324.74,71.88 arc(324.3,71.97) 323.93,72.21 321.45,74.7 arc(321.2,75.07) 321.11,75.5 321.11,94.38 arc(321.06,94.67) 320.89,94.92 295.51,120.3 arc(295.26,120.46) 294.97,120.52 280.92,120.52 arc(280.63,120.58) 280.38,120.74 244.19,156.94 arc(243.94,157.1) 243.65,157.16 234.88,157.16 arc(234.59,157.1) 234.34,156.94 234.28,156.87 arc(234.03,156.71) 233.74,156.65 232.09,156.65
FC54_TDP0: length 149.2
  TOP w0.147: U1.BJ4 227.55,155.34 v4(227.55,155.39)
  SIG4 w0.112: 231.96,154.65 231.95,154.65 231.86,154.74 228.46,154.74 arc(228.28,154.78) 228.12,154.88 arc(228.02,155.03) 227.99,155.21 227.99,155.59 arc(227.97,155.65) 227.94,155.7 arc(227.89,155.73) 227.83,155.74 227.68,155.74 arc(227.59,155.71) 227.55,155.62 v4(227.55,155.39)
  SIG4 w0.16: YJ33.C37 318.15,65.97 arc(318.04,66.13) 318.01,66.32 318.01,66.52 arc(318.11,66.76) 318.35,66.86 319.19,66.86 arc(319.44,66.96) 319.54,67.2 319.54,67.23 arc(319.65,67.57) 319.86,67.86 320.22,68.22 320.22,68.55 320.6,68.93 320.94,68.93 321.39,69.39 arc(321.47,69.51) 321.5,69.66 321.5,70.29 321.32,70.47 321.32,71.13 321.5,71.31 321.5,71.81 321.32,71.99 321.32,72.65 321.5,72.83 321.5,73.34 321.35,73.49 321.35,74.2 321.5,74.35 321.5,74.86 321.32,75.04 321.32,75.7 321.5,75.88 321.5,77.71 arc(321.48,77.81) 321.43,77.89 arc(321.21,78.22) 321.13,78.61 321.13,91.5 arc(321.1,91.64) 321.02,91.77 294.54,118.25 arc(294.41,118.33) 294.27,118.36 291.4,118.36 arc(280.63,120.5) 271.5,126.61 269.32,128.79 243.57,154.53 arc(243.44,154.62) 243.3,154.65 233.33,154.65 233.11,154.42 232.65,154.42 232.42,154.65 231.96,154.65
FC54_TDP1: length 147.8
  TOP w0.147: U1.BK2 229.1,155.84 arc(229.42,155.97) v4(229.55,156.29)
  SIG5 w0.112: v4(229.55,156.29) 229.55,156.07 arc(229.59,155.98) 229.68,155.94 229.84,155.94 arc(229.96,155.92) 230.07,155.85 230.08,155.83 arc(230.15,155.72) 230.18,155.58 230.18,155.14 arc(230.2,155.06) 230.24,155 arc(230.31,154.95) 230.39,154.94 232.22,154.94 232.32,155.03 232.34,155.03
  SIG5 w0.155: 322.31,65.97 arc(322.29,65.88) 322.25,65.8
  SIG5 w0.16: 322.31,65.97 322.31,69.62 arc(322.25,69.91) 322.08,70.15 319.64,72.6 arc(319.47,72.85) 319.41,73.14 319.41,93.41 arc(319.33,93.85) 319.08,94.22 294.89,118.41 arc(294.52,118.66) 294.08,118.74 280.03,118.74 arc(279.89,118.77) 279.76,118.85 243.92,154.69 arc(243.55,154.94) 243.12,155.03 232.34,155.03 ; YJ33.C33 321.5,64.75 arc(321.55,65.01) 321.7,65.24 321.87,65.4 322.14,65.67 arc(322.2,65.74) 322.25,65.8
FC54_TDP2: length 175.8
  TOP w0.147: v4(226.55,157.39) 226.55,157.34 U1.BL5
  SIG4 w0.112: 231.99,156.65 231.96,156.65 231.87,156.74 227.46,156.74 arc(227.28,156.78) 227.12,156.88 arc(227.02,157.03) 226.99,157.21 226.99,157.59 arc(226.97,157.65) 226.94,157.7 arc(226.89,157.73) 226.83,157.74 226.68,157.74 arc(226.59,157.71) 226.55,157.62 v4(226.55,157.39)
  SIG4 w0.16: YJ33.C2 318.15,61.97 arc(318.04,62.13) 318.01,62.32 318.01,62.54 arc(318.1,62.77) 318.33,62.86 319.18,62.86 arc(319.47,62.92) 319.72,63.08 319.76,63.13 319.81,63.18 arc(320.06,63.35) 320.35,63.41 331.76,63.41 arc(331.91,63.44) 332.03,63.52 332.82,64.31 arc(332.9,64.43) 332.93,64.58 332.93,66.29 332.68,66.55 332.68,67.05 332.93,67.31 332.93,67.82 332.68,68.07 332.68,68.58 332.93,68.83 332.93,69.79 arc(332.9,69.93) 332.82,70.06 332.46,70.41 332.13,70.41 331.74,70.8 331.74,71.13 331.38,71.49 331.05,71.49 330.66,71.88 330.66,72.21 329.84,73.04 arc(329.59,73.41) 329.5,73.85 329.5,90.33 arc(329.47,90.48) 329.39,90.6 324.4,95.6 arc(324.27,95.68) 324.13,95.71 320.6,95.71 arc(320.16,95.79) 319.79,96.04 295.43,120.41 arc(295.3,120.49) 295.16,120.52 293.81,120.52 arc(281.64,122.94) 271.31,129.84 244.11,157.05 arc(243.98,157.13) 243.84,157.16 234.88,157.16 arc(234.59,157.1) 234.34,156.94 234.28,156.87 arc(234.03,156.71) 233.74,156.65 231.99,156.65
FC54_TDP3: length 171.7
  TOP w0.147: U1.BM3 228.1,157.84 arc(228.42,157.97) v4(228.55,158.29)
  SIG5 w0.112: v4(228.55,158.29) 228.55,158.07 arc(228.59,157.98) 228.68,157.94 228.84,157.94 arc(228.96,157.92) 229.07,157.84 229.08,157.83 arc(229.15,157.72) 229.18,157.58 229.18,157.14 arc(229.2,157.06) 229.24,157 arc(229.31,156.95) 229.39,156.94 231.97,156.94 232.06,157.03 232.09,157.03
  SIG5 w0.155: 322.31,61.97 arc(322.3,61.91) 322.28,61.84
  SIG5 w0.16: YJ33.C6 321.5,60.75 arc(321.55,61.01) 321.7,61.23 322.19,61.72 arc(322.24,61.78) 322.28,61.84 ; 322.31,61.97 322.31,62.57 arc(322.31,62.6) 322.31,62.63 arc(322.35,62.75) 322.43,62.86 322.48,62.91 arc(322.61,63) 322.75,63.03 331.64,63.03 arc(331.93,63.08) 332.17,63.25 332.97,64.05 arc(333.14,64.29) 333.19,64.58 333.19,65.92 arc(333.14,66.22) 332.97,66.46 327.4,72.04 arc(327.15,72.2) 326.86,72.26 324.74,72.26 arc(324.45,72.32) 324.2,72.48 321.72,74.96 arc(321.55,75.21) 321.49,75.5 321.49,75.5 321.49,94.38 arc(321.41,94.82) 321.16,95.19 295.78,120.57 arc(295.41,120.81) 294.97,120.9 280.92,120.9 arc(280.78,120.93) 280.65,121.01 244.46,157.2 arc(244.09,157.45) 243.65,157.54 234.88,157.54 arc(234.45,157.45) 234.08,157.2 234.01,157.14 arc(233.89,157.06) 233.74,157.03 232.09,157.03
FC55_RDN0: length 186.4
  TOP w0.147: U1.BP13 218.15,159.84 arc(218.24,159.86) 218.33,159.92 218.49,160.08 arc(218.53,160.14) 218.55,160.21 v4(218.55,160.29)
  SIG2 w0.112: 232.09,159.03 232,158.94 219.57,158.94 arc(219.42,158.97) 219.3,159.06 arc(219.21,159.18) 219.18,159.33 219.18,159.63 arc(219.16,159.75) 219.09,159.85 arc(218.99,159.92) 218.88,159.94 218.68,159.94 arc(218.59,159.98) 218.55,160.07 v4(218.55,160.29)
  SIG2 w0.16: YJ33.D24 328.7,56.78 arc(328.75,57.02) 328.88,57.22 329.41,57.75 arc(329.48,57.85) 329.51,57.97 329.51,58.57 arc(329.54,58.72) 329.63,58.86 329.68,58.91 arc(329.73,58.95) 329.78,58.98 arc(329.86,59.01) 329.95,59.03 331.95,59.03 arc(332.39,59.11) 332.76,59.36 336.41,63 arc(336.65,63.38) 336.74,63.81 336.74,69.35 arc(336.65,69.79) 336.41,70.16 332.66,73.91 arc(332.58,74.03) 332.55,74.18 332.55,92.59 arc(332.46,93.03) 332.21,93.4 298.57,127.04 arc(298.2,127.29) 297.77,127.38 277.39,127.38 arc(277.25,127.41) 277.12,127.49 245.37,159.24 arc(245,159.49) 244.56,159.57 233.62,159.57 arc(233.18,159.49) 232.81,159.24 232.71,159.14 arc(232.59,159.06) 232.44,159.03 232.09,159.03
FC55_RDN1: length 179.2
  TOP w0.147: v4(222.55,159.39) 222.55,159.34 U1.BN9
  SIG3 w0.112: v4(222.55,159.39) 222.55,159.62 arc(222.59,159.71) 222.68,159.74 222.88,159.74 arc(222.92,159.73) 222.95,159.71 arc(222.98,159.68) 222.99,159.63 222.99,159.33 arc(223.03,159.11) 223.16,158.92 arc(223.35,158.79) 223.57,158.75 231.99,158.75 232.09,158.65
  SIG3 w0.16: 232.09,158.65 233.33,158.65 arc(233.62,158.71) 233.87,158.87 233.97,158.97 arc(234.21,159.14) 234.51,159.19 244.72,159.19 arc(244.87,159.16) 244.99,159.08 276.74,127.33 arc(277.11,127.08) 277.55,127 297.92,127 arc(298.07,126.97) 298.19,126.89 332.06,93.02 arc(332.14,92.9) 332.17,92.75 332.17,72.6 arc(332.26,72.16) 332.5,71.79 335.35,68.95 arc(335.43,68.82) 335.46,68.68 335.46,64.36 335.26,64.15 335.26,63.57 335.46,63.37 335.46,62.99 arc(335.43,62.84) 335.35,62.72 334.76,62.13 334.4,62.13 334.06,61.78 334.06,61.43 333.79,61.16 333.41,61.16 333.09,60.84 333.09,60.46 332.82,60.19 332.44,60.19 332.12,59.87 332.12,59.49 331.85,59.22 arc(331.83,59.2) 331.81,59.18 331.76,59.13 331.72,59.08 arc(331.62,59.01) 331.52,58.94 arc(331.51,58.94) 331.51,58.94 arc(331.5,58.93) 331.5,58.93 arc(331.49,58.93) 331.48,58.93 arc(331.33,58.88) 331.18,58.86 330.33,58.86 arc(330.1,58.77) 330.01,58.54 330.01,58.32 arc(330.04,58.13) 330.15,57.97 YJ33.D22
FC55_RDN2: length 192.9
  TOP w0.147: v4(220.55,160.29) 220.55,160.21 arc(220.53,160.14) 220.49,160.08 220.33,159.92 arc(220.25,159.86) 220.15,159.84 U1.BP11
  SIG2 w0.112: v4(220.55,160.29) 220.55,160.07 arc(220.59,159.98) 220.68,159.94 220.88,159.94 arc(220.92,159.95) 220.95,159.97 arc(220.98,160.01) 220.99,160.05 220.99,160.35 arc(221.03,160.58) 221.16,160.77 arc(221.35,160.89) 221.57,160.94 231.74,160.94 231.84,161.03
  SIG2 w0.16: YJ33.D15 328.7,52.83 arc(328.74,53.02) 328.85,53.18 329.41,53.75 arc(329.48,53.85) 329.51,53.97 329.51,54.57 arc(329.54,54.72) 329.63,54.86 329.68,54.91 arc(329.73,54.95) 329.78,54.98 arc(329.86,55.01) 329.95,55.03 332.14,55.03 arc(332.44,55.08) 332.68,55.25 338.68,61.24 arc(338.84,61.49) 338.9,61.78 338.9,70.12 arc(338.81,70.55) 338.56,70.92 334.74,74.75 arc(334.66,74.87) 334.63,75.01 334.63,93.61 arc(334.55,94.05) 334.3,94.42 299.51,129.2 arc(299.14,129.45) 298.71,129.54 278.26,129.54 arc(278.11,129.57) 277.99,129.65 246.3,161.33 arc(245.93,161.58) 245.49,161.67 233.42,161.67 arc(232.99,161.58) 232.62,161.33 232.43,161.15 arc(232.31,161.06) 232.16,161.03 231.84,161.03
FC55_RDN3: length 186.4
  TOP w0.147: v4(224.55,159.39) 224.55,159.34 U1.BN7
  SIG3 w0.112: v4(224.55,159.39) 224.55,159.62 arc(224.59,159.71) 224.68,159.74 224.88,159.74 arc(224.99,159.77) 225.09,159.83 arc(225.16,159.93) 225.18,160.05 225.18,160.36 arc(225.21,160.51) 225.3,160.63 arc(225.42,160.72) 225.57,160.75 231.72,160.75 231.81,160.65 231.84,160.65
  SIG3 w0.16: YJ33.D17 330.15,53.97 arc(330.04,54.13) 330.01,54.32 330.01,54.53 arc(330.1,54.76) 330.34,54.86 331.18,54.86 arc(331.47,54.92) 331.72,55.08 331.76,55.13 331.81,55.18 arc(332.06,55.35) 332.35,55.41 333.2,55.41 arc(333.35,55.44) 333.47,55.52 333.74,55.79 333.74,56.15 334.01,56.42 334.37,56.42 334.64,56.69 334.64,57.05 334.91,57.31 335.27,57.31 335.63,57.68 335.63,58.04 335.9,58.31 336.26,58.31 336.53,58.58 336.53,58.91 336.82,59.21 337.16,59.21 337.51,59.56 arc(337.59,59.68) 337.62,59.83 337.62,69.44 arc(337.59,69.59) 337.51,69.71 334.59,72.63 arc(334.34,73) 334.25,73.44 334.25,93.76 arc(334.22,93.91) 334.14,94.03 299.13,129.04 arc(299,129.13) 298.86,129.16 278.41,129.16 arc(277.98,129.24) 277.6,129.49 245.92,161.18 arc(245.8,161.26) 245.65,161.29 233.4,161.29 arc(233.11,161.23) 232.86,161.06 232.67,160.88 arc(232.43,160.71) 232.13,160.65 231.84,160.65
FC55_RDP0: length 186.3
  TOP w0.147: U1.BN13 218.55,159.34 v4(218.55,159.39)
  SIG2 w0.112: 232.09,158.65 231.99,158.75 219.57,158.75 arc(219.35,158.79) 219.16,158.92 arc(219.03,159.11) 218.99,159.33 218.99,159.63 arc(218.98,159.68) 218.95,159.71 arc(218.92,159.73) 218.88,159.74 218.68,159.74 arc(218.59,159.71) 218.55,159.62 v4(218.55,159.39)
  SIG2 w0.16: 232.09,158.65 232.44,158.65 arc(232.73,158.71) 232.98,158.87 233.08,158.97 arc(233.32,159.14) 233.62,159.19 244.56,159.19 arc(244.86,159.14) 245.1,158.97 276.85,127.22 arc(277.1,127.06) 277.39,127 297.77,127 arc(298.06,126.94) 298.31,126.77 331.95,93.13 arc(332.11,92.89) 332.17,92.59 332.17,74.18 arc(332.23,73.88) 332.39,73.64 336.14,69.89 arc(336.3,69.65) 336.36,69.35 336.36,65.34 336.13,65.11 336.13,64.55 336.36,64.32 336.36,63.81 arc(336.3,63.52) 336.14,63.27 335.73,62.86 335.37,62.86 335.01,62.5 335.01,62.14 334.65,61.79 334.29,61.79 333.93,61.43 333.93,61.07 333.57,60.71 333.21,60.71 332.85,60.35 332.85,59.99 332.49,59.63 arc(332.24,59.46) 331.95,59.41 329.95,59.41 arc(329.77,59.38) 329.6,59.32 arc(329.5,59.26) 329.41,59.18 329.36,59.13 329.32,59.08 arc(329.07,58.92) 328.78,58.86 327.93,58.86 arc(327.7,58.77) 327.61,58.54 327.61,58.32 arc(327.64,58.13) 327.75,57.97 YJ33.D25
FC55_RDP1: length 179.2
  TOP w0.147: v4(222.55,160.29) 222.44,160.29 arc(222.34,160.27) 222.26,160.21 222.17,160.12 arc(222.08,159.99) U1.BP9
  SIG3 w0.112: 232.09,159.03 232,158.94 223.57,158.94 arc(223.42,158.97) 223.3,159.06 arc(223.21,159.18) 223.18,159.33 223.18,159.63 arc(223.16,159.75) 223.09,159.85 arc(222.99,159.92) 222.88,159.94 222.68,159.94 arc(222.59,159.98) 222.55,160.07 v4(222.55,160.29)
  SIG3 w0.16: 232.09,159.03 233.33,159.03 arc(233.47,159.06) 233.6,159.14 233.7,159.24 arc(234.07,159.49) 234.51,159.57 244.72,159.57 arc(245.01,159.52) 245.26,159.35 277.01,127.6 arc(277.26,127.44) 277.55,127.38 297.92,127.38 arc(298.22,127.32) 298.46,127.16 332.33,93.29 arc(332.49,93.04) 332.55,92.75 332.55,72.6 arc(332.61,72.31) 332.77,72.06 335.62,69.22 arc(335.78,68.97) 335.84,68.68 335.84,62.99 arc(335.78,62.69) 335.62,62.45 332.11,58.94 arc(332.1,58.93) 332.08,58.91 332.03,58.86 arc(331.95,58.76) 331.91,58.64 arc(331.91,58.6) 331.91,58.57 331.91,57.97 arc(331.88,57.85) 331.81,57.75 331.32,57.25 arc(331.16,57.01) 331.1,56.73 YJ33.D21
FC55_RDP2: length 192.9
  TOP w0.147: v4(220.55,159.39) 220.55,159.34 U1.BN11
  SIG2 w0.112: v4(220.55,159.39) 220.55,159.62 arc(220.59,159.71) 220.68,159.74 220.88,159.74 arc(220.99,159.77) 221.09,159.83 arc(221.16,159.93) 221.18,160.05 221.18,160.35 arc(221.21,160.5) 221.3,160.63 arc(221.42,160.71) 221.57,160.74 231.75,160.74 231.84,160.65
  SIG2 w0.16: YJ33.D14 327.75,53.97 arc(327.64,54.13) 327.61,54.32 327.61,54.59 arc(327.69,54.78) 327.88,54.86 328.78,54.86 arc(329.07,54.92) 329.32,55.08 329.36,55.13 329.41,55.18 arc(329.5,55.26) 329.6,55.32 arc(329.77,55.38) 329.95,55.41 332.14,55.41 arc(332.29,55.44) 332.41,55.52 332.77,55.88 332.77,56.24 333.13,56.6 333.49,56.6 333.85,56.96 333.85,57.31 334.21,57.67 334.57,57.67 334.93,58.03 334.93,58.39 335.29,58.75 335.65,58.75 336.01,59.11 336.01,59.43 336.4,59.83 336.72,59.83 337.08,60.19 338.41,61.51 arc(338.49,61.64) 338.52,61.78 338.52,70.12 arc(338.46,70.41) 338.3,70.65 334.47,74.48 arc(334.31,74.72) 334.25,75.01 334.25,93.61 arc(334.19,93.9) 334.03,94.15 299.25,128.93 arc(299,129.1) 298.71,129.16 278.26,129.16 arc(277.96,129.21) 277.72,129.38 246.03,161.06 arc(245.78,161.23) 245.49,161.29 233.42,161.29 arc(233.13,161.23) 232.89,161.06 232.7,160.88 arc(232.45,160.71) 232.16,160.65 231.84,160.65
FC55_RDP3: length 186.4
  TOP w0.147: v4(224.55,160.29) 224.44,160.29 arc(224.34,160.27) 224.26,160.21 224.17,160.12 arc(224.08,159.99) U1.BP7
  SIG3 w0.112: v4(224.55,160.29) 224.55,160.07 arc(224.59,159.98) 224.68,159.94 224.88,159.94 arc(224.92,159.95) 224.95,159.97 arc(224.98,160.01) 224.99,160.05 224.99,160.36 arc(225.03,160.58) 225.16,160.77 arc(225.35,160.9) 225.57,160.94 231.72,160.94 231.81,161.03 231.84,161.03
  SIG3 w0.16: 231.84,161.03 232.13,161.03 arc(232.28,161.06) 232.4,161.15 232.59,161.33 arc(232.96,161.58) 233.4,161.67 245.65,161.67 arc(245.94,161.61) 246.19,161.45 277.87,129.76 arc(278.12,129.6) 278.41,129.54 298.86,129.54 arc(299.15,129.48) 299.4,129.31 334.41,94.3 arc(334.57,94.06) 334.63,93.76 334.63,73.44 arc(334.69,73.15) 334.86,72.9 337.78,69.98 arc(337.94,69.73) 338,69.44 338,59.83 arc(337.94,59.53) 337.78,59.29 333.74,55.25 arc(333.49,55.08) 333.2,55.03 332.35,55.03 arc(332.21,55) 332.08,54.91 332.03,54.86 arc(331.94,54.72) 331.91,54.57 331.91,53.97 arc(331.88,53.85) 331.81,53.75 331.28,53.21 arc(331.27,53.21) 331.27,53.2 arc(331.14,53.01) 331.1,52.79 YJ33.D18
FC55_TDN0: length 192.2
  TOP w0.147: v4(226.55,161.39) 226.55,161.34 U1.BR5
  SIG4 w0.112: v4(226.55,161.39) 226.55,161.62 arc(226.59,161.71) 226.68,161.74 226.83,161.74 arc(226.89,161.73) 226.94,161.7 arc(226.97,161.65) 226.99,161.59 226.99,161.21 arc(227.02,161.03) 227.12,160.88 arc(227.28,160.78) 227.46,160.74 231.72,160.74 231.81,160.65 231.84,160.65
  SIG4 w0.16: YJ33.D5 320.55,53.97 arc(320.44,54.13) 320.41,54.32 320.41,54.57 arc(320.49,54.78) 320.7,54.86 321.58,54.86 arc(321.87,54.92) 322.12,55.08 322.16,55.13 322.21,55.18 arc(322.46,55.35) 322.75,55.41 332.78,55.41 arc(332.92,55.44) 333.05,55.52 333.41,55.88 333.41,56.14 333.87,56.6 334.13,56.6 334.49,56.96 334.49,57.21 334.95,57.67 335.2,57.67 335.56,58.03 335.56,58.29 336.02,58.75 336.28,58.75 336.64,59.11 336.64,59.39 337.08,59.83 337.36,59.83 337.9,60.37 arc(337.98,60.49) 338.01,60.64 338.01,70.8 arc(337.98,70.95) 337.9,71.07 336.69,72.28 arc(336.45,72.65) 336.36,73.08 336.36,91.69 arc(336.33,91.83) 336.25,91.96 309.38,118.82 305.89,122.31 arc(300.7,125.78) 294.58,127 293.16,127 arc(281.12,129.39) 270.9,136.22 245.95,161.18 arc(245.82,161.26) 245.68,161.29 234.75,161.29 234.52,161.06 234.06,161.06 233.83,161.29 233.37,161.29 arc(233.08,161.23) 232.83,161.06 232.64,160.87 arc(232.39,160.71) 232.1,160.65 231.84,160.65
FC55_TDN1: length 192.6
  TOP w0.147: U1.BP2 229.1,159.84 arc(229.42,159.97) v4(229.55,160.29)
  SIG5 w0.112: 231.84,161.03 231.81,161.03 231.72,160.94 230.39,160.94 arc(230.23,160.91) 230.1,160.83 arc(230.02,160.7) 229.99,160.54 229.99,160.11 arc(229.97,160.04) 229.94,159.99 229.93,159.98 arc(229.88,159.95) 229.84,159.94 229.68,159.94 arc(229.59,159.98) 229.55,160.07 v4(229.55,160.29)
  SIG5 w0.16: 231.84,161.03 232.16,161.03 arc(232.45,161.09) 232.7,161.26 233.15,161.71 arc(233.53,161.96) 233.96,162.05 245.11,162.05 arc(245.55,161.96) 245.92,161.71 282.3,125.33 arc(282.43,125.25) 282.57,125.22 303.02,125.22 arc(303.46,125.13) 303.83,124.88 334.3,94.42 arc(334.55,94.05) 334.63,93.61 334.63,71.01 334.63,71.01 arc(334.69,70.72) 334.86,70.47 336.8,68.53 336.82,68.53 337.32,68.03 arc(337.48,67.79) 337.54,67.49 337.54,60.68 arc(337.48,60.39) 337.32,60.14 332.43,55.25 arc(332.18,55.08) 331.89,55.03 320.35,55.03 arc(320.21,55) 320.08,54.91 320.03,54.86 arc(319.94,54.72) 319.91,54.57 319.91,53.97 arc(319.88,53.85) 319.81,53.75 319.31,53.24 arc(319.15,53.01) 319.1,52.74 YJ33.D3
FC55_TDN2: length 182
  TOP w0.147: v4(227.55,159.39) 227.55,159.34 U1.BN4
  SIG4 w0.112: v4(227.55,159.39) 227.55,159.62 arc(227.59,159.71) 227.68,159.74 227.83,159.74 arc(227.89,159.73) 227.94,159.7 arc(227.97,159.65) 227.99,159.59 227.99,159.21 arc(228.02,159.03) 228.12,158.88 arc(228.28,158.78) 228.46,158.74 232.1,158.74 232.19,158.65 232.22,158.65
  SIG4 w0.16: YJ33.D34 320.55,57.97 arc(320.44,58.13) 320.41,58.32 320.41,58.64 arc(320.47,58.8) 320.63,58.86 321.45,58.86 arc(321.86,58.94) 322.21,59.18 322.21,59.18 arc(322.46,59.35) 322.75,59.41 332.26,59.41 arc(332.41,59.44) 332.53,59.52 332.89,59.88 332.89,60.24 333.25,60.6 333.61,60.6 333.95,60.93 333.95,61.24 334.33,61.62 334.63,61.62 335.36,62.34 arc(335.44,62.47) 335.47,62.61 335.47,63.12 335.22,63.38 335.22,63.88 335.47,64.14 335.47,64.65 335.22,64.9 335.22,65.41 335.47,65.66 335.47,70.42 arc(335.44,70.57) 335.36,70.69 334.59,71.46 arc(334.34,71.83) 334.25,72.27 334.25,90.64 arc(334.22,90.79) 334.14,90.91 307.49,117.56 304.91,120.14 arc(299.7,123.62) 293.56,124.84 292.77,124.84 arc(280.29,127.32) 269.71,134.39 245.02,159.08 arc(244.89,159.16) 244.75,159.19 234.28,159.19 arc(234.13,159.16) 234.01,159.08 233.91,158.98 arc(233.54,158.74) 233.1,158.65 232.22,158.65
FC55_TDN3: length 182.8
  TOP w0.147: U1.BM1 230.1,157.84 arc(230.42,157.97) v4(230.55,158.29)
  SIG5 w0.112: v4(230.55,158.29) 230.55,158.07 arc(230.59,157.98) 230.68,157.94 230.84,157.94 arc(230.88,157.95) 230.93,157.98 230.94,157.99 arc(230.97,158.04) 230.99,158.11 230.99,158.54 arc(231.02,158.7) 231.1,158.83 arc(231.23,158.91) 231.39,158.94 232.35,158.94 232.44,159.04 232.47,159.04
  SIG5 w0.16: YJ33.D36 319.1,56.8 arc(319.14,57.02) 319.26,57.2 319.81,57.75 arc(319.88,57.85) 319.91,57.97 319.91,58.57 arc(319.91,58.61) 319.91,58.64 arc(319.95,58.76) 320.03,58.86 320.08,58.91 arc(320.21,59) 320.35,59.03 331.83,59.03 arc(332.12,59.08) 332.37,59.25 335.16,62.04 arc(335.33,62.29) 335.38,62.58 335.38,66.71 arc(335.33,67) 335.16,67.25 334.01,68.39 333.99,68.39 332.77,69.61 arc(332.61,69.86) 332.55,70.15 332.55,92.57 arc(332.46,93.01) 332.21,93.38 302.87,122.73 arc(302.5,122.97) 302.06,123.06 281.71,123.06 arc(281.56,123.09) 281.44,123.17 245.37,159.24 arc(245,159.49) 244.56,159.57 234.02,159.57 arc(233.59,159.49) 233.21,159.24 233.12,159.15 arc(233,159.06) 232.85,159.04 232.47,159.04
FC55_TDP0: length 192.2
  TOP w0.147: U1.BT5 226.07,161.84 arc(226.26,161.88) 226.41,161.98 226.49,162.06 arc(226.53,162.13) 226.55,162.21 v4(226.55,162.29)
  SIG4 w0.112: v4(226.55,162.29) 226.55,162.07 arc(226.59,161.98) 226.68,161.94 226.83,161.94 arc(226.97,161.91) 227.08,161.84 227.08,161.84 arc(227.16,161.72) 227.18,161.59 227.18,161.21 arc(227.2,161.11) 227.26,161.02 arc(227.35,160.96) 227.46,160.94 231.72,160.94 231.81,161.03 231.84,161.03
  SIG4 w0.16: 231.84,161.03 232.1,161.03 arc(232.25,161.06) 232.37,161.14 232.57,161.33 arc(232.94,161.58) 233.37,161.67 245.68,161.67 arc(245.97,161.61) 246.22,161.45 271.17,136.49 arc(281.26,129.75) 293.16,127.38 294.58,127.38 arc(300.85,126.13) 306.16,122.58 309.65,119.09 336.52,92.23 arc(336.68,91.98) 336.74,91.69 336.74,73.08 arc(336.8,72.79) 336.96,72.55 338.17,71.34 arc(338.33,71.09) 338.39,70.8 338.39,60.64 arc(338.33,60.35) 338.17,60.1 333.32,55.25 arc(333.07,55.08) 332.78,55.03 322.75,55.03 arc(322.61,55) 322.48,54.91 322.43,54.86 arc(322.34,54.72) 322.31,54.57 322.31,53.97 arc(322.28,53.85) 322.21,53.75 321.72,53.25 arc(321.56,53.01) 321.5,52.73 YJ33.D6
