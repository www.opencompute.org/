# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_EARTH: length 447
  TOP w0.381: 420.64,46.89 X68.5 ; X68.5 419.93,47.6 ; X68.5 420.64,48.31 ; 421.63,50.68 X68.4 420.92,49.97 ; 427.08,49.97 X68.2 426.37,50.68 ; 427.08,45.23 X68.8 426.37,44.52 ; 421.63,44.52 X68.6 420.92,45.23 ; 423.29,50.96 X68.3 ; X68.3 424.71,50.96 ; X68.3 424,51.67 ; SW1.7 v1(427.16,1.2) ; 423.29,44.24 X68.7 ; X68.7 424.71,44.24 ; X68.7 424,43.53 ; X68.9 427.36,48.31 ; X68.9 428.07,47.6 ; X68.9 427.36,46.89 ; SW1.6 v1(420.88,1.2)
  TOP w0.508: SW1.2 424.02,3.08 v1(423.61,2.66)
  GND1 w0.381: 427.36,46.89 X68.9 ; X68.9 427.36,48.31 ; X68.9 428.07,47.6 ; 426.37,50.68 X68.2 427.08,49.97 ; X68.3 424,51.67 ; X68.3 423.29,50.96 ; X68.3 424.71,50.96 ; 421.63,50.68 X68.4 420.92,49.97 ; 424,43.53 X68.7 ; X68.7 423.29,44.24 ; X68.7 424.71,44.24 ; 426.37,44.52 X68.8 427.08,45.23 ; 421.63,44.52 X68.6 420.92,45.23 ; 6.8,18.4 6.8,16.63 ; 420.64,46.89 X68.5 ; X68.5 420.64,48.31 ; X68.5 419.93,47.6
  GND1 w0.406: RJ1.3 416.38,17.7 ; RJ1.3 418.13,19.54 ; RJ1.3 418.13,16 ; RJ1.1 401.87,16.02 ; RJ1.1 401.87,19.54 ; RJ1.1 403.62,17.7
  POWER1 w0.381: X68.9 428.07,47.6 ; X68.9 427.36,46.89 ; X68.9 427.36,48.31 ; X68.3 424.71,50.96 ; X68.3 423.29,50.96 ; X68.3 424,51.67 ; 420.92,45.23 X68.6 421.63,44.52 ; 420.92,49.97 X68.4 421.63,50.68 ; X68.7 424.71,44.24 ; X68.7 423.29,44.24 ; X68.7 424,43.53 ; 419.93,47.6 X68.5 ; X68.5 420.64,46.89 ; X68.5 420.64,48.31 ; 427.08,45.23 X68.8 426.37,44.52 ; 426.37,50.68 X68.2 427.08,49.97
  POWER1 w0.406: RJ1.1 401.87,19.41 ; RJ1.1 403.62,17.7 ; RJ1.1 401.87,16.02 ; RJ1.3 418.13,16.02 ; RJ1.3 418.13,19.41 ; RJ1.3 416.38,17.7
  SIG1 w0.381: 420.92,49.97 X68.4 421.63,50.68 ; 421.63,44.52 X68.6 420.92,45.23 ; 419.93,47.6 X68.5 ; X68.5 420.64,46.89 ; X68.5 420.64,48.31 ; X68.7 424.71,44.24 ; X68.7 423.29,44.24 ; X68.7 424,43.53 ; X68.3 424,51.67 ; X68.3 423.29,50.96 ; X68.3 424.71,50.96 ; X68.9 427.36,48.31 ; X68.9 427.36,46.89 ; X68.9 428.07,47.6 ; 426.37,44.52 X68.8 427.08,45.23 ; 427.08,49.97 X68.2 426.37,50.68
  GND2 w0.381: X68.3 424,51.67 ; X68.3 423.29,50.96 ; X68.3 424.71,50.96 ; 421.63,44.52 X68.6 420.92,45.23 ; 424,43.53 X68.7 ; X68.7 423.29,44.24 ; X68.7 424.71,44.24 ; 427.08,49.97 X68.2 426.37,50.68 ; X68.5 420.64,48.31 ; X68.5 419.93,47.6 ; X68.5 420.64,46.89 ; 427.36,46.89 X68.9 ; X68.9 428.07,47.6 ; X68.9 427.36,48.31 ; 426.37,44.52 X68.8 427.08,45.23 ; 421.63,50.68 X68.4 420.92,49.97 ; 6.8,18.39 6.8,16.49
  GND3 w0.381: X68.9 428.07,47.6 ; X68.9 427.36,48.31 ; X68.9 427.36,46.89 ; 420.92,45.23 X68.6 421.63,44.52 ; X68.3 424.71,50.96 ; X68.3 424,51.67 ; X68.3 423.29,50.96 ; 423.29,44.24 X68.7 ; X68.7 424,43.53 ; X68.7 424.71,44.24 ; 427.08,49.97 X68.2 426.37,50.68 ; 421.63,50.68 X68.4 420.92,49.97 ; 419.93,47.6 X68.5 ; X68.5 420.64,48.31 ; X68.5 420.64,46.89 ; 6.8,18.52 6.8,16.63 ; 426.37,44.52 X68.8 427.08,45.23
  SIG3 w0.381: 424,43.53 X68.7 ; X68.7 424.71,44.24 ; X68.7 423.29,44.24 ; 423.29,50.96 X68.3 ; X68.3 424.71,50.96 ; X68.3 424,51.67 ; 420.92,45.23 X68.6 421.63,44.52 ; 421.63,50.68 X68.4 420.92,49.97 ; 426.37,44.52 X68.8 427.08,45.23 ; X68.9 427.36,48.31 ; X68.9 427.36,46.89 ; X68.9 428.07,47.6 ; 419.93,47.6 X68.5 ; X68.5 420.64,46.89 ; X68.5 420.64,48.31 ; 426.37,50.68 X68.2 427.08,49.97
  GND4 w0.381: 426.37,50.68 X68.2 427.08,49.97 ; 420.64,46.89 X68.5 ; X68.5 420.64,48.31 ; X68.5 419.93,47.6 ; X68.7 424.71,44.24 ; X68.7 424,43.53 ; X68.7 423.29,44.24 ; X68.3 424.71,50.96 ; X68.3 423.29,50.96 ; X68.3 424,51.67 ; X68.9 428.07,47.6 ; X68.9 427.36,46.89 ; X68.9 427.36,48.31 ; 421.63,50.68 X68.4 420.92,49.97 ; 426.37,44.52 X68.8 427.08,45.23 ; 421.63,44.52 X68.6 420.92,45.23
  GND5 w0.381: 424,43.53 X68.7 ; X68.7 424.71,44.24 ; X68.7 423.29,44.24 ; 427.08,49.97 X68.2 426.37,50.68 ; 426.37,44.52 X68.8 427.08,45.23 ; 419.93,47.6 X68.5 ; X68.5 420.64,48.31 ; X68.5 420.64,46.89 ; 420.92,49.97 X68.4 421.63,50.68 ; X68.9 427.36,48.31 ; X68.9 427.36,46.89 ; X68.9 428.07,47.6 ; 420.92,45.23 X68.6 421.63,44.52 ; X68.3 424.71,50.96 ; X68.3 424,51.67 ; X68.3 423.29,50.96
  SIG5 w0.381: X68.9 428.07,47.6 ; X68.9 427.36,48.31 ; X68.9 427.36,46.89 ; 421.63,50.68 X68.4 420.92,49.97 ; X68.3 424.71,50.96 ; X68.3 423.29,50.96 ; X68.3 424,51.67 ; 420.64,46.89 X68.5 ; X68.5 420.64,48.31 ; X68.5 419.93,47.6 ; 427.08,49.97 X68.2 426.37,50.68 ; 427.08,45.23 X68.8 426.37,44.52 ; 424,43.53 X68.7 ; X68.7 423.29,44.24 ; X68.7 424.71,44.24 ; 420.92,45.23 X68.6 421.63,44.52
  GND6 w0.381: 427.36,46.89 X68.9 ; X68.9 427.36,48.31 ; X68.9 428.07,47.6 ; X68.7 424.71,44.24 ; X68.7 424,43.53 ; X68.7 423.29,44.24 ; X68.3 424.71,50.96 ; X68.3 423.29,50.96 ; X68.3 424,51.67 ; 420.64,46.89 X68.5 ; X68.5 419.93,47.6 ; X68.5 420.64,48.31 ; 426.37,44.52 X68.8 427.08,45.23 ; 421.63,44.52 X68.6 420.92,45.23 ; 426.37,50.68 X68.2 427.08,49.97 ; 421.63,50.68 X68.4 420.92,49.97
  GND6 w0.406: RJ1.2 401.87,7.51 ; RJ1.2 403.62,9.32 ; RJ1.2 400.17,9.32 ; RJ1.2 401.87,11.03 ; RJ1.4 418.13,11.05 ; RJ1.4 416.42,9.32 ; RJ1.4 419.87,9.32 ; RJ1.4 418.13,7.51 ; J29.5 397.86,11 ; J29.5 396.25,12.76 ; J29.5 396.25,9.31 ; J29.8 389.14,18 ; J29.8 390.75,16.31 ; J29.8 390.75,19.76 ; J29.7 390.75,12.76 ; J29.7 390.75,9.31 ; J29.7 389.14,11 ; J29.6 396.25,16.31 ; J29.6 397.86,18 ; J29.6 396.25,19.76
  SIG6 w0.381: 421.63,50.68 X68.4 420.92,49.97 ; 426.37,44.52 X68.8 427.08,45.23 ; 420.92,45.23 X68.6 421.63,44.52 ; X68.9 427.36,48.31 ; X68.9 427.36,46.89 ; X68.9 428.07,47.6 ; 420.64,46.89 X68.5 ; X68.5 419.93,47.6 ; X68.5 420.64,48.31 ; X68.3 424.71,50.96 ; X68.3 423.29,50.96 ; X68.3 424,51.67 ; X68.7 424.71,44.24 ; X68.7 423.29,44.24 ; X68.7 424,43.53 ; 427.08,49.97 X68.2 426.37,50.68
  GND7 w0.381: 421.63,50.68 X68.4 420.92,49.97 ; X68.3 424,51.67 ; X68.3 424.71,50.96 ; X68.3 423.29,50.96 ; 427.08,45.23 X68.8 426.37,44.52 ; 427.36,46.89 X68.9 ; X68.9 428.07,47.6 ; X68.9 427.36,48.31 ; 424,43.53 X68.7 ; X68.7 423.29,44.24 ; X68.7 424.71,44.24 ; 426.37,50.68 X68.2 427.08,49.97 ; X68.5 420.64,48.31 ; X68.5 419.93,47.6 ; X68.5 420.64,46.89 ; 420.92,45.23 X68.6 421.63,44.52
  SIG7 w0.381: 423.29,50.96 X68.3 ; X68.3 424,51.67 ; X68.3 424.71,50.96 ; 426.37,50.68 X68.2 427.08,49.97 ; 421.63,44.52 X68.6 420.92,45.23 ; X68.5 420.64,48.31 ; X68.5 420.64,46.89 ; X68.5 419.93,47.6 ; 427.08,45.23 X68.8 426.37,44.52 ; 421.63,50.68 X68.4 420.92,49.97 ; X68.7 424.71,44.24 ; X68.7 424,43.53 ; X68.7 423.29,44.24 ; X68.9 427.36,48.31 ; X68.9 427.36,46.89 ; X68.9 428.07,47.6
  GND8 w0.381: X68.3 424.71,50.96 ; X68.3 424,51.67 ; X68.3 423.29,50.96 ; X68.9 428.07,47.6 ; X68.9 427.36,46.89 ; X68.9 427.36,48.31 ; 421.63,44.52 X68.6 420.92,45.23 ; 426.37,50.68 X68.2 427.08,49.97 ; 424,43.53 X68.7 ; X68.7 424.71,44.24 ; X68.7 423.29,44.24 ; X68.5 420.64,48.31 ; X68.5 420.64,46.89 ; X68.5 419.93,47.6 ; 421.63,50.68 X68.4 420.92,49.97 ; 426.37,44.52 X68.8 427.08,45.23
  SIG8 w0.381: 421.63,50.68 X68.4 420.92,49.97 ; X68.9 428.07,47.6 ; X68.9 427.36,48.31 ; X68.9 427.36,46.89 ; 421.63,44.52 X68.6 420.92,45.23 ; 423.29,44.24 X68.7 ; X68.7 424,43.53 ; X68.7 424.71,44.24 ; X68.5 420.64,48.31 ; X68.5 419.93,47.6 ; X68.5 420.64,46.89 ; 427.08,45.23 X68.8 426.37,44.52 ; 426.37,50.68 X68.2 427.08,49.97 ; 423.29,50.96 X68.3 ; X68.3 424,51.67 ; X68.3 424.71,50.96
  GND9 w0.381: 423.29,44.24 X68.7 ; X68.7 424.71,44.24 ; X68.7 424,43.53 ; 420.92,45.23 X68.6 421.63,44.52 ; 426.37,50.68 X68.2 427.08,49.97 ; 427.08,45.23 X68.8 426.37,44.52 ; X68.9 428.07,47.6 ; X68.9 427.36,46.89 ; X68.9 427.36,48.31 ; 419.93,47.6 X68.5 ; X68.5 420.64,48.31 ; X68.5 420.64,46.89 ; 420.92,49.97 X68.4 421.63,50.68 ; 423.29,50.96 X68.3 ; X68.3 424.71,50.96 ; X68.3 424,51.67
  GND9 w0.508: SW1.5 427.13,2.15 ; SW1.5 425.32,2.15 ; SW1.5 426.22,3.05 ; SW1.5 426.22,1.24 ; SW1.4 422.73,2.15 ; SW1.4 421.82,3.05 ; SW1.4 421.82,1.24 ; SW1.4 420.92,2.15
  SIG9 w0.381: X68.5 420.64,48.31 ; X68.5 419.93,47.6 ; X68.5 420.64,46.89 ; X68.9 428.07,47.6 ; X68.9 427.36,46.89 ; X68.9 427.36,48.31 ; X68.3 424,51.67 ; X68.3 423.29,50.96 ; X68.3 424.71,50.96 ; 426.37,44.52 X68.8 427.08,45.23 ; 420.92,49.97 X68.4 421.63,50.68 ; X68.7 424.71,44.24 ; X68.7 423.29,44.24 ; X68.7 424,43.53 ; 420.92,45.23 X68.6 421.63,44.52 ; 427.08,49.97 X68.2 426.37,50.68
  SIG9 w0.508: SW1.4 422.73,2.15 ; SW1.4 421.82,1.24 ; SW1.4 420.92,2.15 ; SW1.4 421.82,3.05 ; 425.32,2.15 SW1.5 ; SW1.5 427.13,2.15 ; SW1.5 426.22,3.05 ; SW1.5 426.22,1.24
  GND10 w0.381: X68.3 424,51.67 ; X68.3 424.71,50.96 ; X68.3 423.29,50.96 ; 427.08,45.23 X68.8 426.37,44.52 ; 420.92,45.23 X68.6 421.63,44.52 ; X68.7 424.71,44.24 ; X68.7 424,43.53 ; X68.7 423.29,44.24 ; 421.63,50.68 X68.4 420.92,49.97 ; 419.93,47.6 X68.5 ; X68.5 420.64,48.31 ; X68.5 420.64,46.89 ; 427.36,46.89 X68.9 ; X68.9 428.07,47.6 ; X68.9 427.36,48.31 ; 427.08,49.97 X68.2 426.37,50.68
  GND10 w0.508: 421.82,1.24 SW1.4 ; SW1.4 421.82,3.05 ; SW1.4 420.92,2.15 ; SW1.4 422.73,2.15 ; SW1.5 426.22,3.05 ; SW1.5 426.22,1.24 ; SW1.5 427.13,2.15 ; SW1.5 425.32,2.15
  SIG10 w0.381: 427.08,45.23 X68.8 426.37,44.52 ; 419.93,47.6 X68.5 ; X68.5 420.64,48.31 ; X68.5 420.64,46.89 ; X68.9 428.07,47.6 ; X68.9 427.36,48.31 ; X68.9 427.36,46.89 ; 423.29,50.96 X68.3 ; X68.3 424,51.67 ; X68.3 424.71,50.96 ; X68.7 424.71,44.24 ; X68.7 423.29,44.24 ; X68.7 424,43.53 ; 427.08,49.97 X68.2 426.37,50.68 ; 421.63,50.68 X68.4 420.92,49.97 ; 421.63,44.52 X68.6 420.92,45.23
  GND11 w0.381: 420.64,46.89 X68.5 ; X68.5 420.64,48.31 ; X68.5 419.93,47.6 ; X68.3 424,51.67 ; X68.3 424.71,50.96 ; X68.3 423.29,50.96 ; 420.92,49.97 X68.4 421.63,50.68 ; X68.9 427.36,48.31 ; X68.9 428.07,47.6 ; X68.9 427.36,46.89 ; 420.92,45.23 X68.6 421.63,44.52 ; 424,43.53 X68.7 ; X68.7 423.29,44.24 ; X68.7 424.71,44.24 ; 426.37,50.68 X68.2 427.08,49.97 ; 426.37,44.52 X68.8 427.08,45.23
  POWER2 w0.381: X68.7 424.71,44.24 ; X68.7 423.29,44.24 ; X68.7 424,43.53 ; 426.37,44.52 X68.8 427.08,45.23 ; X68.9 428.07,47.6 ; X68.9 427.36,48.31 ; X68.9 427.36,46.89 ; 423.29,50.96 X68.3 ; X68.3 424.71,50.96 ; X68.3 424,51.67 ; 420.92,49.97 X68.4 421.63,50.68 ; 426.37,50.68 X68.2 427.08,49.97 ; 420.64,46.89 X68.5 ; X68.5 419.93,47.6 ; X68.5 420.64,48.31 ; 420.92,45.23 X68.6 421.63,44.52
  GND12 w0.381: 420.64,46.89 X68.5 ; X68.5 420.64,48.31 ; X68.5 419.93,47.6 ; 420.92,49.97 X68.4 421.63,50.68 ; 426.37,50.68 X68.2 427.08,49.97 ; 423.29,44.24 X68.7 ; X68.7 424,43.53 ; X68.7 424.71,44.24 ; 427.08,45.23 X68.8 426.37,44.52 ; X68.9 428.07,47.6 ; X68.9 427.36,48.31 ; X68.9 427.36,46.89 ; 420.92,45.23 X68.6 421.63,44.52 ; 423.29,50.96 X68.3 ; X68.3 424.71,50.96 ; X68.3 424,51.67
  BOTTOM w0.13: v1(429.25,31.37) v2(428.31,31.37) ; v1(429.25,28.83) v2(428.18,28.83) ; v2(428.31,32.76) 428.43,32.64 v1(429.25,32.64)
  BOTTOM w0.381: X68.7 424.71,44.24 ; X68.7 423.29,44.24 ; X68.7 424,43.53 ; 420.64,46.89 X68.5 ; X68.5 419.93,47.6 ; X68.5 420.64,48.31 ; X68.3 424,51.67 ; X68.3 424.71,50.96 ; X68.3 423.29,50.96 ; 427.36,46.89 X68.9 ; X68.9 427.36,48.31 ; X68.9 428.07,47.6 ; 427.08,49.97 X68.2 426.37,50.68 ; 426.37,44.52 X68.8 427.08,45.23 ; 420.92,45.23 X68.6 421.63,44.52 ; 421.63,50.68 X68.4 420.92,49.97
  BOTTOM w1.016: C2067.2 417.95,36.35 RV4.2 RV3.2 RV2.2 RV1.2
  vias: v1(0.75,24.86) v1(0.75,23.59) v1(0.75,22.32) v1(0.75,21.05) v1(0.75,19.78) v1(0.75,18.51) v1(0.75,17.24) v1(0.75,15.97) v1(0.75,14.7) v1(0.75,13.43) v1(0.75,12.16) v1(0.75,10.89) v1(0.75,9.62) v1(0.75,8.35) v1(0.75,7.08) v1(0.75,5.81) v1(0.9,4.44) v1(2.22,4.9) v1(3.49,4.9) v1(4.76,4.9) v1(6.03,4.9) v1(7.3,4.9) v1(8.57,4.9) v1(9.84,4.9) v1(10.99,4.32) v1(24.7,21.33) v1(24.7,14.6) v1(24.7,8.89) v1(42.48,21.33) v1(42.48,14.6) v1(42.48,8.89) v1(67.88,21.33) v1(67.88,14.6) v1(67.88,8.89) v1(88.2,21.33) v1(88.2,14.6) v1(88.2,8.89) v1(113.6,21.33) v1(113.6,14.6) v1(113.6,8.89) v1(139,21.33) v1(139,13.08) v1(139,7.36) v1(164.4,21.33) v1(164.4,13.08) v1(164.4,7.36) v1(184.72,21.33) v1(184.72,13.08) v1(184.72,7.36) v1(210.12,21.33) v1(210.12,13.08) v1(210.12,7.36) v1(230.44,21.33) v1(230.44,13.08) v1(230.44,7.36) v1(255.84,21.33) v1(255.84,13.08) v1(255.84,7.36) v1(276.16,21.33) v1(276.16,13.08) v1(276.16,7.36) v1(301.56,21.33) v1(301.56,13.08) v1(301.56,7.36) v1(326.96,21.33) v1(326.96,13.08) v1(326.96,7.36) v1(352.36,21.33) v1(352.36,13.08) v1(352.36,7.36) v1(372.68,21.33) v1(372.68,13.08) v1(372.68,7.36) v1(418.02,26.41) v1(419.54,26.41) v1(420.94,26.41) v1(422.97,26.29) v1(424.62,26.29) v1(426.15,26.29) v1(429.25,50.42) v1(429.25,49.15) v1(429.25,47.88) v1(429.25,46.61) v1(429.25,45.34) v1(429.25,44.07) v1(429.25,42.8) v1(429.25,41.53) v1(429.25,40.26) v1(429.25,38.99) v1(429.25,37.72) v1(429.25,36.45) v1(429.25,35.18) v1(429.25,33.91) v1(429.25,30.1) v1(429.25,27.56) v1(429.25,26.29) v2(2.6,24.89) v2(2.6,22.35) v2(2.6,19.81) v2(2.6,17.27) v2(2.6,14.73) v2(2.6,12.19) v2(2.6,10.28) v2(4.89,24.89) v2(4.89,22.35) v2(4.89,19.81) v2(4.89,17.27) v2(4.89,14.73) v2(4.89,12.19) v2(4.89,10.28) v2(7.18,24.89) v2(7.18,22.35) v2(7.18,19.81) v2(7.18,17.27) v2(7.18,14.73) v2(7.18,12.19) v2(7.18,10.28) v2(419.29,38.86) v2(421.45,38.86) v2(423.74,38.73) v2(423.74,36.83) v2(423.74,34.8) v2(425.64,38.73) v2(425.64,36.83) v2(425.64,34.8) v2(427.55,38.73) v2(427.55,36.83) v2(427.55,34.8)
VCC1_0: length 47.9
  SIG1 w0.508: YJ21.A30 23.38,63.94 23.75,63.94 24.59,63.1 30.89,63.1 31.69,63.89 31.69,66.93 26.89,71.72 v1(24.83,71.72)
  BOTTOM w0.508: L236.1 27.17,93.55 27.39,93.32 C2174.2 27.39,91.31 27.65,91.06 C2175.1 27.65,88.03 22.16,82.55 v2(22.16,78.61) 22.16,75.82 24.83,73.14 v1(24.83,71.72)
VCC1_1: length 65.9
  SIG1 w0.508: YJ21.B30 24.22,55.1 30.77,55.1 32.45,56.78 32.45,67.82 27.75,72.51 24.43,72.51 23.87,71.96 v1(23.87,71.72)
  BOTTOM w0.508: v1(23.87,71.72) 23.87,72.71 21.27,75.31 21.27,83.06 v2(25.34,87.12) 26.1,87.88 26.1,95.63 26.73,96.26 C2177.1 27.65,96.9 27.39,97.15 C2176.2 27.39,98.96 27.17,99.18 L237.1
VCC1_2: length 53.2
  TOP w0.508: L248.1 27.17,93.32 27.39,93.09 C2203.2 27.39,91.54 27.65,91.29 C2205.1 27.65,88.03 24.96,85.34 24.96,80.9 28.77,77.09 v1(29.4,77.09)
  POWER2 w0.508: YJ22.D30 24.5,55.7 25.1,55.1 30.77,55.1 32.42,56.75 32.42,74.7 30.04,77.09 v1(29.4,77.09)
  BOTTOM w0.13: v1(29.4,77.09) v2(28.64,77.09)
VCC1_3: length 51.5
  TOP w0.508: v1(29.78,75.94) 28.77,75.94 24.19,80.52 24.19,85.98 26.1,87.88 26.1,95.63 26.73,96.26 C2207.1 27.65,97.03 27.39,97.28 C2206.2 27.39,98.68 27.17,98.91 L249.1
  POWER2 w0.508: v1(29.78,75.94) 31.66,74.07 31.66,63.86 30.89,63.1 25.14,63.1 24.5,63.74 YJ22.C30
  BOTTOM w0.13: v1(29.78,75.94) v2(30.54,75.94)
VCC1_4: length 28.4
  SIG1 w0.508: v1(49.8,75.44) 50.66,74.58 50.66,63.86 50.04,63.24 43.08,63.24 YJ21.C30
  BOTTOM w0.508: L238.1 50.94,80.74 50.71,80.52 C2171.2 50.71,78.61 50.46,78.36 C2172.1 v2(50.46,76.1) v1(49.8,75.44)
VCC1_5: length 48.1
  TOP w0.508: L239.1 50.94,85.49 50.71,85.27 C2173.2 50.71,83.84 50.97,83.59 C2178.1 52.77,83.06 v1(52.13,82.42)
  SIG1 w0.508: v1(52.13,82.42) 52.13,78.99 54.67,76.45 54.67,55.5 53.91,54.73 52.77,54.73 52.15,55.35 43.39,55.35 42.32,56.42 YJ21.D30
VCC1_6: length 44.4
  SIG10 w0.508: YJ22.B30 43.5,55.62 44.01,55.12 49.79,55.12 51.5,56.83 51.5,83.82 v1(52.01,84.33)
  BOTTOM w0.508: v2(52.79,84.5) 52.18,84.5 v1(52.01,84.33) 51.37,83.69 C2208.1 50.46,84.58 50.71,84.83 C2204.2 50.71,86.36 50.94,86.59 L250.1
VCC1_7: length 29.2
  TOP w0.508: L251.1 50.94,79.86 C2209.2 50.71,78.1 C2210.1 50.46,77.62 v1(49.8,76.96)
  SIG10 w0.508: YJ22.A30 43.5,63.62 44.01,63.12 49.47,63.12 50.61,64.26 50.61,76.15 v1(49.8,76.96)
  BOTTOM w0.13: v1(49.8,76.96) 49.8,76.53 v2(48.58,75.31)
VCC1_8: length 32.3
  SIG1 w0.508: YJ23.A30 71.08,63.24 78.04,63.24 78.66,63.86 78.66,72.92 v1(74.23,77.34)
  BOTTOM w0.13: v1(74.23,77.34) 74.99,76.58 v2(75.25,76.58)
  BOTTOM w0.508: L263.1 75.43,80.72 75.65,80.49 C2238.2 75.65,78.86 75.91,78.61 C2239.1 74.74,77.85 v1(74.23,77.34)
VCC1_9: length 47.6
  SIG1 w0.508: YJ23.B30 71.22,55.1 77.77,55.1 79.42,56.75 79.42,73.3 75.17,77.54 75.17,82.24 v1(74.23,83.18)
  BOTTOM w0.13: v2(73.6,88.52) 74.36,87.75 L261.1
  BOTTOM w0.508: L261.1 75.43,86.33 75.65,86.1 C2240.2 75.65,84.43 75.91,84.17 C2242.1 74.74,83.69 v1(74.23,83.18)
VCC1_10: length 45.4
  TOP w0.508: L272.1 75.43,86.46 75.65,86.23 C2271.2 75.65,84.83 75.91,84.58 C2272.1 74.74,83.69 v1(74.23,84.2)
  SIG10 w0.508: YJ24.D30 71.5,55.6 72.01,55.1 77.77,55.1 79.42,56.75 79.42,74.27 75.5,78.19 75.5,82.93 v1(74.23,84.2)
VCC1_11: length 31
  TOP w0.508: v1(74.23,78.36) 74.74,77.85 C2274.1 75.91,78.74 75.65,78.99 C2273.2 75.65,80.64 75.43,80.87 L274.1
  SIG10 w0.508: v1(74.23,78.36) 78.66,73.93 78.66,63.86 77.89,63.1 72.01,63.1 71.5,63.6 YJ24.C30
VCC1_12: length 38.4
  TOP w0.508: L260.1 95.14,86.81 94.91,86.59 C2235.2 94.91,84.81 94.65,84.55 C2236.1 v1(96.53,83.69)
  SIG1 w0.508: v1(96.53,83.69) 96.2,83.36 96.2,82.55 94.68,81.02 94.68,71.63 97.66,68.65 97.66,63.86 97.04,63.24 90.08,63.24 YJ23.C30
  BOTTOM w0.13: v2(96.46,84.58) 96.46,83.77 v1(96.53,83.69)
VCC1_13: length 38.8
  TOP w0.508: v1(96.33,77.09) 95.92,77.09 95.67,77.34 C2241.1 95.67,78.25 94.91,79.02 C2237.2 94.91,80.64 95.14,80.87 L262.1
  SIG1 w0.508: v1(96.33,77.09) 95.69,76.45 95.69,71.75 98.42,69.03 98.42,56.75 97.02,55.35 90.38,55.35 89.31,56.42 YJ23.D30
  BOTTOM w0.13: v1(96.33,77.09) v2(96.33,77.85)
VCC1_14: length 43.9
  POWER2 w0.508: YJ24.B30 90.5,55.74 91,55.24 96.91,55.24 99.5,57.83 99.5,68.58 97.85,70.23 v1(97.85,81.91)
  BOTTOM w0.508: v2(97.78,89.74) L275.1 97.78,86.33 98.01,86.1 C2267.2 98.01,84.71 98.26,84.45 C2268.1 97.85,83.28 v1(97.85,81.91)
VCC1_15: length 35.3
  POWER2 w0.508: v1(95.57,82.93) 95.57,69.72 97.85,67.43 97.85,64.06 97.17,63.37 90.87,63.37 90.5,63.74 YJ24.A30
  BOTTOM w0.13: v1(95.57,82.93) 95.06,82.42 v2(94.55,82.42)
  BOTTOM w0.508: v1(95.57,82.93) 95.57,83.34 95.22,83.69 C2270.1 94.65,84.43 94.91,84.68 C2269.2 94.91,86.23 95.14,86.46 L273.1
VCC1_16: length 29.7
  SIG1 w0.508: YJ25.A30 118.22,63.1 124.89,63.1 125.66,63.86 125.66,74.18 v1(124.02,75.82)
  BOTTOM w0.508: L286.1 125.21,80.97 125.44,80.74 C2299.2 125.44,78.48 125.69,78.23 C2304.1 125.69,76.73 v2(125.16,76.2) 124.78,75.82 v1(124.02,75.82)
VCC1_17: length 46
  SIG1 w0.508: v1(123.89,82.04) 124.02,82.04 124.65,81.4 124.65,76.58 126.42,74.81 126.42,56.75 124.77,55.1 120.23,55.1 119.95,55.37 117.95,55.37 YJ25.B30
  BOTTOM w0.508: v2(123.38,87.75) L287.1 125.21,86.59 125.44,86.36 C2305.2 125.44,84.71 125.69,84.45 C2306.1 125.16,83.69 123.89,82.42 v1(123.89,82.04)
VCC1_18: length 41.1
  TOP w0.508: v1(126.1,82.95) 125.69,83.36 C2333.1 125.69,84.17 125.44,84.43 C2332.2 125.44,86.33 125.21,86.56 L296.1
  SIG10 w0.508: v1(126.1,82.95) 126.1,77.79 126.42,77.47 126.42,56.75 124.77,55.1 119.15,55.1 118.5,55.74 YJ26.D30
VCC1_19: length 29.3
  TOP w0.508: L299.1 125.21,80.62 125.44,80.39 C2334.2 125.44,78.59 125.69,78.33 C2335.1 125.16,77.85 v1(124.02,76.71)
  SIG10 w0.508: v1(124.02,76.71) 124.65,76.71 125.66,75.7 125.66,63.86 124.89,63.1 119.57,63.1 118.5,64.17 YJ26.C30
  BOTTOM w0.13: v2(124.52,77.34) 124.02,76.83 v1(124.02,76.71)
VCC1_20: length 37.4
  SIG1 w0.508: v1(147.89,60.58) 145.1,63.37 137.1,63.37 136.53,63.94 136.38,63.94 YJ25.C30
  BOTTOM w0.508: L284.1 144.92,80.74 144.69,80.52 C2300.2 144.69,78.97 144.44,78.71 C2301.1 v2(144.44,76.32) 143.45,75.33 143.45,72.79 147.89,68.35 v1(147.89,60.58)
VCC1_21: length 59.3
  SIG1 w0.508: v1(148.02,57.02) 145.69,57.02 144.02,55.35 136.97,55.35 YJ25.D30
  BOTTOM w0.508: L285.1 137.78,92.5 138.01,92.73 C2302.2 139.74,92.73 139.99,92.48 C2303.1 140.65,91.95 140.91,91.69 142.43,91.69 v2(142.94,91.18) 142.94,86.74 146.29,83.39 146.29,81.07 145.61,80.39 145.61,78.86 145.22,78.48 145.22,75.94 144.34,75.05 144.34,73.15 148.91,68.58 148.91,57.91 v1(148.02,57.02)
VCC1_22: length 44
  TOP w0.508: L297.1 144.92,86.46 144.69,86.23 C2331.2 144.69,84.81 144.44,84.55 C2336.1 144.97,83.69 145.35,83.31 v1(145.35,83.06)
  SIG1 w0.508: v1(147.03,76.58) 145.35,78.25 v1(145.35,83.06)
  POWER2 w0.508: v1(147.03,76.58) 146.93,76.58 146.39,76.05 146.39,57.72 144.02,55.35 137.89,55.35 137.5,55.74 YJ26.B30
  BOTTOM w0.13: v2(144.34,83.94) 145.22,83.06 v1(145.35,83.06)
VCC1_23: length 28.6
  TOP w0.508: v1(145.63,75.44) 144.44,76.63 C2338.1 144.44,78.59 144.69,78.84 C2337.2 144.69,80.52 144.92,80.74 L298.1
  POWER2 w0.508: v1(145.63,75.44) 144.66,74.46 144.66,63.86 143.9,63.1 138.01,63.1 137.5,63.6 YJ26.A30
  BOTTOM w0.13: v2(145.22,74.67) 145.63,75.08 v1(145.63,75.44)
VCC1_24: length 32.4
  SIG1 w0.508: YJ27.A30 164.87,63.45 167.6,63.45 167.96,63.1 171.89,63.1 172.66,63.86 172.66,67.18 168.97,70.86 168.97,76.58 v1(168.21,77.34)
  BOTTOM w0.508: C2367.1 169.89,78.61 169.63,78.86 C2366.2 169.41,79.86 L311.1 ; C2367.1 169.89,77.19 v2(170.37,76.71) ; C2367.1 168.72,77.85 v1(168.21,77.34)
VCC1_25: length 45.5
  SIG1 w0.508: YJ27.B30 164.82,55.5 166.31,55.5 166.71,55.1 171.77,55.1 173.42,56.75 173.42,67.56 169.85,71.13 169.85,76.82 169.23,77.45 169.23,82.04 v1(168.21,83.06)
  BOTTOM w0.508: L309.1 169.41,87.2 169.63,86.97 C2368.2 169.63,84.55 169.89,84.3 C2370.1 v2(168.72,83.69) 168.21,83.18 v1(168.21,83.06)
VCC1_26: length 47.4
  TOP w0.508: v1(168.21,85.34) 168.59,84.96 168.59,84.07 168.97,83.69 C2396.1 169.89,84.43 169.63,84.68 C2395.2 169.63,86.33 169.41,86.56 L320.1
  SIG10 w0.508: v1(168.21,85.34) 170.5,83.06 170.5,74.93 173.42,72.01 173.42,56.75 171.77,55.1 166.15,55.1 165.5,55.74 YJ28.D30
VCC1_27: length 31
  TOP w0.508: v1(168.21,78.36) 168.72,77.85 C2401.1 169.89,78.61 169.63,78.86 C2400.2 169.63,80.26 169.41,80.49 L322.1
  SIG10 w0.508: v1(168.21,78.36) 168.97,77.59 168.97,75.18 172.66,71.5 172.66,63.86 171.89,63.1 166.07,63.1 165.5,63.67 YJ28.C30
VCC1_28: length 35.7
  SIG1 w0.508: YJ27.C30 183.95,63.37 191.15,63.37 191.66,63.88 191.66,71.22 v1(189.55,73.33)
  BOTTOM w0.508: v1(189.55,73.33) v2(189.55,80.39) 189.55,82.29 190.94,83.69 C2364.1 191.73,84.45 191.99,84.71 C2363.2 191.99,86.48 191.76,86.71 L308.1
VCC1_29: length 46.3
  SIG1 w0.508: YJ27.D30 183.38,55.94 183.64,55.94 184.23,55.35 191.02,55.35 192.42,56.75 192.42,72.56 188.91,76.07 188.91,83.06 v1(189.55,83.69)
  BOTTOM w0.13: v2(188.53,82.17) 189.55,83.18 v1(189.55,83.69)
  BOTTOM w0.508: L310.1 189.12,87.2 188.89,86.97 C2365.2 188.89,84.68 188.63,84.43 C2369.1 v1(189.55,83.69)
VCC1_30: length 78.8
  TOP w0.508: v1(190.94,81.28) 190.94,82.17 190.06,83.06 188.91,83.06 188.63,83.33 C2398.1 188.63,84.43 188.89,84.68 C2397.2 188.89,86.59 189.12,86.81 L323.1
  SIG8 w0.508: YJ28.B30 184.5,55.74 185.01,55.23 190.43,55.23 193.48,58.29 193.48,69.47 191.71,71.24 191.71,80.52 v1(190.94,81.28)
  POWER2 w0.508: YJ28.B30 184.5,55.74 184.89,55.35 191.02,55.35 192.42,56.75 192.42,75.74 190.94,77.21 v1(190.94,81.28)
  BOTTOM w0.13: v1(190.94,81.28) v2(191.52,81.85)
VCC1_31: length 29
  TOP w0.508: v1(190.82,76.2) 189.17,77.85 C2402.1 188.63,78.59 188.89,78.84 C2399.2 188.89,80.52 189.12,80.74 L321.1
  SIG10 w0.508: v1(190.82,76.2) 191.66,75.36 191.66,63.86 190.92,63.12 185.12,63.12 184.5,63.74 YJ28.A30
  BOTTOM w0.13: v1(190.82,76.2) v2(190.82,76.96)
VCC1_32: length 31.5
  SIG1 w0.508: YJ29.A30 212.22,63.1 218.89,63.1 219.66,63.86 219.66,75.68 v1(218,77.34)
  BOTTOM w0.13: v2(220.03,76.45) 219.67,76.81 C2428.1
  BOTTOM w0.508: L334.1 219.19,79.86 C2427.2 219.42,78.86 219.67,78.61 C2428.1 218.5,77.85 v1(218,77.34)
VCC1_33: length 46.2
  SIG1 w0.508: YJ29.B30 212.22,55.1 218.77,55.1 220.42,56.75 220.42,80.76 v1(218,83.18)
  BOTTOM w0.13: L335.1 v2(217.36,87.75)
  BOTTOM w0.508: v1(218,83.18) 218.5,83.69 C2430.1 219.67,84.43 219.42,84.68 C2429.2 219.19,85.7 L335.1
VCC1_34: length 44.1
  TOP w0.508: v1(218,84.2) 218.5,83.69 C2460.1 219.67,84.43 219.42,84.68 C2459.2 219.19,85.7 L344.1
  POWER2 w0.508: v1(218,84.2) 220.41,81.79 220.41,56.51 219.27,55.37 212.87,55.37 212.5,55.74 YJ30.D30
VCC1_35: length 29.8
  TOP w0.508: v1(218,78.36) 218.5,77.85 C2462.1 219.67,78.46 219.42,78.71 C2461.2 219.19,79.86 L345.1
  POWER2 w0.508: YJ30.C30 212.5,63.53 212.92,63.12 218.88,63.12 219.65,63.88 219.65,76.71 v1(218,78.36)
VCC1_36: length 29
  SIG1 w0.508: v1(237.88,75.69) 237.88,67.51 238.82,66.57 238.82,63.88 237.81,62.86 231.46,62.86 YJ29.C30
  BOTTOM w0.508: L332.1 238.9,79.86 C2431.2 238.67,78.86 238.42,78.61 C2432.1 238.42,77.34 238.57,77.19 v2(238.57,76.38) v1(237.88,75.69)
VCC1_37: length 44.8
  TOP w0.508: v1(240.09,81.28) 240.09,82.55 238.95,83.69 C2434.1 238.42,84.43 238.67,84.68 C2433.2 238.9,85.7 L333.1
  SIG1 w0.508: YJ29.D30 231.21,55.12 238.98,55.12 239.71,55.85 239.71,68.2 238.65,69.26 238.65,79.84 v1(240.09,81.28)
VCC1_38: length 60
  TOP w0.508: v1(248.86,92.33) C2463.2 250.41,92.96 250.18,93.19 L346.1
  POWER2 w0.508: v1(240.6,83.06) 239.46,81.91 239.46,79.88 239.97,79.37 239.97,55.88 239.33,55.24 232,55.24 231.5,55.74 YJ30.B30
  BOTTOM w0.508: v1(240.6,83.06) 239.97,83.69 C2464.1 238.42,84.68 v2(239.2,85.47) 242.25,88.52 246.06,88.52 248.09,90.55 248.98,90.55 249.36,90.93 249.36,91.82 v1(248.86,92.33)
VCC1_39: length 28.2
  TOP w0.508: v1(237.88,76.83) 238.42,77.37 C2466.1 238.42,78.59 238.67,78.84 C2465.2 238.9,79.86 L347.1
  POWER2 w0.508: YJ30.A30 231.5,63.74 232,63.24 238.06,63.24 238.86,64.04 238.86,75.85 v1(237.88,76.83)
  BOTTOM w0.13: v2(237.05,76.58) 237.3,76.83 v1(237.88,76.83)
VCC1_40: length 32.8
  SIG1 w0.508: YJ31.A30 259.2,63.12 266.38,63.12 266.76,63.5 266.76,70.1 262.19,74.67 v1(262.19,77.34)
  BOTTOM w0.508: L357.1 263.39,79.86 C2494.2 263.61,78.71 263.87,78.46 C2495.1 263.87,76.6 v2(263.84,76.58) 262.95,76.58 v1(262.19,77.34)
VCC1_41: length 43.5
  SIG1 w0.508: YJ31.B30 259.2,55.12 265.75,55.12 267.53,56.89 267.53,71.37 264.27,74.62 v1(264.27,82.93)
  BOTTOM w0.508: L358.1 263.39,85.7 C2496.2 263.61,84.58 263.87,84.33 C2498.1 263.87,83.3 264.24,82.93 v1(264.27,82.93)
VCC1_42: length 44.1
  TOP w0.508: L368.1 263.39,86.71 263.61,86.48 C2526.2 263.61,84.83 263.87,84.58 C2527.1 263.08,83.69 v1(262.19,82.8)
  POWER2 w0.508: v1(262.19,82.8) 262.83,82.8 263.97,81.66 263.97,78.86 267.4,75.44 267.4,57.02 265.62,55.24 260,55.24 259.5,55.74 YJ32.D30
VCC1_43: length 31.1
  TOP w0.508: L371.1 263.39,79.86 C2528.2 263.61,78.71 263.87,78.46 C2529.1 263.21,77.85 262.83,78.23 v1(262.19,78.23)
  POWER2 w0.508: YJ32.C30 259.5,63.65 260.16,62.99 265.49,62.99 266.64,64.13 266.64,74.42 262.83,78.23 v1(262.19,78.23)
VCC1_44: length 37
  TOP w0.508: L356.1 283.1,85.7 C2491.2 282.61,85.21 C2492.1 283.15,83.69 v1(283.53,83.31)
  SIG1 w0.508: YJ31.C30 278.22,63.1 284.9,63.1 285.66,63.86 285.66,72.29 282.38,75.56 282.38,82.17 v1(283.53,83.31)
  BOTTOM w0.13: v2(283.53,82.55) v1(283.53,83.31)
VCC1_45: length 40.7
  TOP w0.508: v1(283.4,76.83) 282.61,77.62 C2497.1 282.61,78.59 282.87,78.84 C2493.2 283.1,79.86 L359.1
  SIG1 w0.508: v1(283.4,76.83) 288.12,72.11 288.12,57.26 285.98,55.12 277.94,55.12 276.9,56.16 YJ31.D30
  BOTTOM w0.13: v2(282.64,76.83) v1(283.4,76.83)
VCC1_46: length 44
  POWER2 w0.508: YJ32.B30 278.5,55.74 278.87,55.37 285.81,55.37 287.08,56.64 287.08,71.88 v1(283.27,75.69)
  BOTTOM w0.508: L369.1 285.48,85.7 C2523.2 285.71,84.55 285.97,84.3 C2524.1 285.97,83.08 284.16,81.28 v2(284.16,78.61) 284.16,76.58 v1(283.27,75.69)
VCC1_47: length 37.4
  POWER2 w0.508: v1(283.53,84.33) 282.13,82.93 282.13,74.8 285.81,71.12 285.81,63.88 285.05,63.12 279.13,63.12 278.5,63.74 YJ32.A30
  BOTTOM w0.13: v2(284.42,84.33) v1(283.53,84.33)
  BOTTOM w0.508: v1(283.53,84.33) 282.89,83.69 C2530.1 282.61,84.55 282.87,84.81 C2525.2 283.1,85.7 L370.1
VCC1_48: length 30.5
  SIG1 w0.508: YJ33.A30 306.22,63.1 312.89,63.1 313.66,63.86 313.66,77.31 v1(313.63,77.34)
  BOTTOM w0.508: v1(313.63,77.34) 314.13,77.85 C2556.1 ; C2556.1 315.3,78.74 315.05,78.99 C2555.2 314.82,79.86 L383.1 ; C2556.1 315.3,76.6 v2(315.28,76.58)
VCC1_49: length 45.3
  SIG1 w0.508: v1(313.63,82.67) 314.42,81.88 314.42,56.75 312.77,55.1 306.22,55.1 YJ33.B30
  BOTTOM w0.13: L381.1 v2(312.86,87.75)
  BOTTOM w0.508: v1(313.63,82.67) 314.64,83.69 C2558.1 315.3,84.33 315.05,84.58 C2557.2 314.82,85.7 L381.1
VCC1_50: length 45.3
  TOP w0.508: v1(313.25,83.69) C2592.1 315.3,84.33 315.05,84.58 C2591.2 314.82,85.7 L393.1
  POWER2 w0.508: YJ34.D30 306.5,55.76 307.17,55.1 312.76,55.1 314.41,56.75 314.41,75.33 315.02,75.94 315.02,82.93 314.26,83.69 v1(313.25,83.69)
  BOTTOM w0.13: v2(314.01,84.2) 313.5,83.69 v1(313.25,83.69)
VCC1_51: length 30.5
  TOP w0.508: L394.1 314.82,79.86 C2593.2 315.05,78.84 315.3,78.59 C2594.1 314.13,77.85 v1(313.63,78.36)
  POWER2 w0.508: v1(313.63,78.36) 314.26,77.72 314.26,76.32 313.65,75.71 313.65,63.88 312.86,63.1 306.9,63.1 306.5,63.49 YJ34.C30
  BOTTOM w0.13: v2(313.73,79.12) 313.73,78.46 v1(313.63,78.36)
VCC1_52: length 30.2
  SIG1 w0.508: YJ33.C30 325.08,63.24 331.45,63.24 332.68,64.47 332.68,73.35 v1(330.97,75.05)
  BOTTOM w0.508: L380.1 334.53,79.86 C2559.2 334.3,79.17 333.69,78.56 332.38,78.56 332.02,78.2 C2560.1 v2(332.02,76.1) v1(330.97,75.05)
VCC1_53: length 45.1
  TOP w0.508: v1(335.47,83.69) C2562.1 334.05,84.43 334.3,84.68 C2561.2 334.53,85.7 L382.1
  SIG1 w0.508: YJ33.D30 325.08,55.24 332.04,55.24 334.45,57.66 334.45,82.67 v1(335.47,83.69)
  BOTTOM w0.13: v2(335.85,84.45) 335.85,84.07 v1(335.47,83.69)
VCC1_54: length 43.4
  POWER2 w0.508: v1(333.41,82.93) 333.86,82.48 333.86,57.2 332.01,55.35 325.98,55.35 325.5,55.83 YJ34.B30
  BOTTOM w0.13: L395.1 v2(336.61,87.75)
  BOTTOM w0.508: v1(333.41,82.93) 333.69,82.93 334.05,83.28 C2588.1 334.3,83.94 C2587.2 334.53,85.7 L395.1
VCC1_55: length 30.8
  TOP w0.508: v1(331.03,76.2) 331.15,76.2 332.02,77.06 C2590.1 332.02,78.2 332.35,78.53 333.87,78.53 334.3,78.97 C2589.2 334.53,79.86 L392.1
  POWER2 w0.508: v1(331.03,76.2) 332.93,74.29 332.93,63.88 332.17,63.12 326.13,63.12 325.5,63.74 YJ34.A30
  BOTTOM w0.13: v1(331.03,76.2) v2(330.14,76.2)
VCC1_56: length 28.7
  SIG1 w0.508: YJ35.A30 353.2,63.12 360.36,63.12 360.62,63.37 360.62,70.61 360.24,70.99 360.24,74.29 v1(361.12,75.18)
  BOTTOM w0.508: L406.1 360.79,81.04 361.02,80.82 C2620.2 361.02,78.59 361.28,78.33 C2624.1 v2(361.28,76.45) 361.28,75.33 v1(361.12,75.18)
VCC1_57: length 39.8
  TOP w0.508: v1(365.7,76.96) 366.33,76.96 366.69,77.32 C2626.1 366.69,78.61 366.94,78.86 C2625.2 367.17,79.86 L407.1
  SIG1 w0.508: YJ35.B30 353.22,55.1 359.77,55.1 361.42,56.75 361.42,72.94 365.44,76.96 v1(365.7,76.96)
  BOTTOM w0.13: v1(365.7,76.96) 365.44,76.71 v2(364.81,76.71)
VCC1_58: length 46.5
  TOP w0.508: L416.1 359.96,86.38 C2654.2 362.52,84.2 363.18,84.86 C2655.1 364.02,84.86 v1(364.43,84.45)
  POWER2 w0.508: YJ36.D30 353.5,55.86 354.26,55.1 359.76,55.1 361.41,56.75 361.41,73.05 362.39,74.04 362.39,82.42 v1(364.43,84.45)
  BOTTOM w0.13: v2(365.06,84.96) 364.93,84.96 v1(364.43,84.45)
VCC1_59: length 29
  TOP w0.508: L419.1 360.79,79.86 C2656.2 361.02,78.74 361.28,78.48 C2657.1 361.28,76.3 361.89,75.69 361.89,74.93 v1(361.12,74.17)
  POWER2 w0.508: v1(361.12,74.17) 360.65,73.69 360.65,63.88 359.86,63.1 354.15,63.1 353.5,63.75 YJ36.C30
  BOTTOM w0.13: v1(361.12,74.17) 362.14,75.18 v2(362.14,75.31)
VCC1_60: length 30.5
  TOP w0.508: L404.1 384.04,78.97 C2619.2 384.26,77.95 384.52,77.7 C2621.1 383.35,76.96 v1(382.84,76.45)
  SIG1 w0.508: v1(382.84,76.45) 382.84,66.93 379.16,63.24 372.08,63.24 YJ35.C30
  BOTTOM w0.13: v1(382.84,76.45) 383.35,75.94 v2(383.35,75.82)
VCC1_61: length 42.2
  TOP w0.508: v1(391.48,76.96) C2623.1 390.06,77.57 390.31,77.82 C2622.2 390.54,78.97 L405.1
  SIG1 w0.508: YJ35.D30 370.9,56.39 372.05,55.24 379.03,55.24 385,61.21 385,70.48 v1(391.48,76.96)
  BOTTOM w0.13: v2(391.86,77.85) 391.86,77.34 v1(391.48,76.96)
VCC1_62: length 41.3
  POWER2 w0.508: v1(391.48,75.69) 389.19,75.69 386.52,73.02 386.52,62.85 379.02,55.35 372.89,55.35 372.5,55.74 YJ36.B30
  BOTTOM w0.508: L417.1 390.54,78.97 C2651.2 390.31,77.95 390.06,77.7 C2652.1 390.06,75.59 v2(390.08,75.56) 391.35,75.56 v1(391.48,75.69)
VCC1_63: length 31.1
  POWER2 w0.508: v1(382.84,77.47) 383.48,76.83 383.48,67.68 378.9,63.1 373.15,63.1 372.5,63.74 YJ36.A30
  BOTTOM w0.13: v1(382.84,77.47) 382.71,77.59 v2(381.83,77.59)
  BOTTOM w0.508: v1(382.84,77.47) 383.35,76.96 C2658.1 384.52,77.44 384.26,77.7 C2653.2 384.26,79.49 384.04,79.72 L418.1
VCC_RX_0: length 26.3
  TOP w0.508: L230.1 14.36,77.32 14.14,77.09 C2149.2 14.14,75.69 13.88,75.44 C2150.1 14.8,74.55 v1(15.18,74.17)
  POWER2 w0.508: v1(15.18,74.17) 15.98,73.36 15.98,71.97 15.67,71.66 15.67,63.71 16.29,63.1 22.77,63.1 23.7,62.16 YJ21.A10
VCC_RX_1: length 44.8
  TOP w0.508: v1(8.32,68.45) 7.68,68.45 6.92,69.21 6.92,79.63 7.68,80.39 C2154.1 8.47,81.91 C2153.2 7.99,82.4 L231.1
  POWER2 w0.508: v1(8.32,68.45) 8.81,68.45 13.2,64.07 13.2,62.83 14.26,61.77 14.26,57.25 16.42,55.1 22.94,55.1 23.7,54.34 YJ21.B10
  BOTTOM w0.13: v1(8.32,68.45) v2(7.56,68.45)
VCC_RX_2: length 45.4
  SIG10 w0.508: v1(7.18,81.02) 7.18,73.53 12.13,68.58 12.13,66.9 14.26,64.77 14.26,57.25 16.39,55.12 22.87,55.12 23.7,54.29 YJ22.D10
  BOTTOM w0.508: v2(6.16,81.02) v1(7.18,81.02) 7.81,80.39 C2182.1 8.47,81.13 8.22,81.38 C2181.2 8.22,82.8 7.99,83.03 L240.1
VCC_RX_3: length 25.6
  SIG10 w0.508: v1(15.05,73.15) 15.05,70.1 15.78,69.37 15.78,63.61 16.29,63.1 22.77,63.1 23.7,62.16 YJ22.C10
  BOTTOM w0.508: L241.1 14.36,77.57 14.14,77.34 C2185.2 14.14,75.56 13.88,75.31 C2194.1 13.88,74.32 v1(15.05,73.15)
VCC_RX_4: length 34
  TOP w0.508: v1(43.37,76.68) 44.62,76.68 44.92,76.98 C2158.1 44.92,78.59 44.67,78.84 C2157.2 44.67,80.29 44.44,80.52 L228.1
  SIG10 w0.508: v1(43.37,76.68) 43.37,74.8 34.78,66.21 34.78,63.61 35.29,63.1 41.77,63.1 42.7,62.16 YJ21.C10
  BOTTOM w0.13: v2(44.13,76.07) 43.98,76.07 v1(43.37,76.68)
VCC_RX_5: length 61.3
  TOP w0.508: v1(37.66,74.04) 37.66,80.13 38.42,80.9 38.42,85.6 35.6,88.41 C2162.1 35.6,92.17 35.75,92.33 35.75,94.74 33.44,97.05 C2161.2 33.44,98.83 33.67,99.06 L229.1
  SIG10 w0.508: YJ21.D10 42.7,54.21 41.82,55.1 35.42,55.1 33.26,57.25 33.26,70.78 36.51,74.04 v1(37.66,74.04)
  BOTTOM w0.13: v1(37.66,74.04) 37.66,75.05 v2(37.4,75.31)
VCC_RX_6: length 61.6
  POWER2 w0.508: v1(40.32,74.42) 39.31,74.42 37.24,72.35 37.24,71.59 33.26,67.61 33.26,57.25 35.42,55.1 41.82,55.1 42.7,54.21 YJ22.B10
  BOTTOM w0.508: v1(40.32,74.42) 39.81,74.93 v2(39.81,81.02) 39.81,81.4 39.94,81.53 39.94,85.6 35.6,89.94 C2189.1 35.6,92.56 35.75,92.71 35.75,95.12 33.44,97.43 C2188.2 33.44,98.91 33.67,99.13 L242.1
VCC_RX_7: length 35.5
  POWER2 w0.508: YJ22.A10 42.7,62.16 41.77,63.1 35.29,63.1 34.78,63.6 34.78,66.16 44.18,75.57 44.18,77.08 43.7,77.57 v1(43.37,77.57)
  BOTTOM w0.13: C2192.2 43.57,79.63 v2(43.19,80.01)
  BOTTOM w0.508: v1(43.37,77.57) 43.65,77.85 C2193.1 44.92,78.59 44.67,78.84 C2192.2 44.67,80.41 44.44,80.64 L243.1
VCC_RX_8: length 31.3
  POWER2 w0.508: YJ23.A10 70.7,62.16 69.77,63.1 63.29,63.1 62.78,63.6 62.78,69.57 66.23,73.02 66.23,74.72 v1(67.58,76.07)
  BOTTOM w0.13: v2(66.74,75.56) 67.07,75.56 v1(67.58,76.07)
  BOTTOM w0.508: L254.1 68.59,79.86 C2219.2 68.36,78.97 68.11,78.71 C2220.1 68.11,76.6 v1(67.58,76.07)
VCC_RX_9: length 37.4
  POWER2 w0.508: v1(61.53,72.13) 61.26,71.86 61.26,57.25 63.42,55.1 69.89,55.1 70.7,54.29 YJ23.B10
  BOTTOM w0.508: v1(61.53,72.13) 61.66,72.13 62.7,73.17 v2(62.7,75.94) C2225.1 62.7,78.61 62.45,78.86 C2224.2 62.22,79.86 L255.1
VCC_RX_10: length 37.9
  TOP w0.508: L264.1 62.22,80.49 62.45,80.26 C2250.2 62.45,78.86 62.7,78.61 C2251.1 62.7,74.19 v1(61.66,73.15)
  SIG10 w0.508: YJ24.D10 70.7,54.29 69.87,55.12 63.39,55.12 60.75,57.76 60.75,72.62 61.28,73.15 v1(61.66,73.15)
VCC_RX_11: length 32.7
  TOP w0.508: L265.1 68.59,79.86 C2255.2 68.36,78.99 68.11,78.74 C2258.1 68.11,77.57 67.63,77.09 v1(65.47,77.09)
  SIG10 w0.508: YJ24.C10 70.7,62.16 69.77,63.1 63.29,63.1 62.27,64.12 62.27,69.06 65.47,72.26 v1(65.47,77.09)
  BOTTOM w0.13: v2(65.47,76.32) v1(65.47,77.09)
VCC_RX_12: length 34.4
  TOP w0.508: v1(89.47,76.96) 88.71,76.96 88.23,77.44 C2214.1 88.23,78.46 88.86,79.09 C2213.2 88.86,80.74 88.63,80.97 L252.1
  SIG10 w0.508: v1(89.47,76.96) 89.22,76.96 88.46,76.2 88.46,75.05 97.73,65.78 97.73,64.13 96.46,62.86 90.23,62.86 89.7,62.33 YJ23.C10
  BOTTOM w0.13: v1(89.47,76.96) 89.22,76.96 v2(88.77,76.51)
VCC_RX_13: length 39.3
  TOP w0.508: v1(82.87,77.85) C2226.1 81.32,78.46 81.57,78.71 C2223.2 81.57,80.52 81.8,80.74 L253.1
  SIG10 w0.508: YJ23.D10 89.7,54.21 88.82,55.1 82.42,55.1 80.26,57.25 80.26,75.24 v1(82.87,77.85)
VCC_RX_14: length 40
  POWER2 w0.508: v1(82.87,76.83) 82.2,76.83 80.26,74.89 80.26,57.25 82.42,55.1 88.82,55.1 89.7,54.21 YJ24.B10
  BOTTOM w0.508: v1(82.87,76.83) 82.61,76.58 v2(81.34,76.58) 81.32,76.6 C2246.1 81.32,78.46 81.57,78.71 C2245.2 81.57,80.39 81.8,80.62 L266.1
VCC_RX_15: length 30.9
  POWER2 w0.508: v1(87.57,76.81) 86.79,76.03 86.79,74.3 81.78,69.29 81.78,63.6 82.29,63.1 88.77,63.1 89.7,62.16 YJ24.A10
  BOTTOM w0.508: L267.1 88.63,80.62 88.86,80.39 C2256.2 88.86,79.12 88.23,78.48 C2257.1 88.23,77.47 v1(87.57,76.81)
VCC_RX_16: length 32.2
  POWER2 w0.508: v1(115.3,75.18) 114.49,75.18 113.73,74.42 113.73,70.74 109.78,66.79 109.78,63.6 110.29,63.1 116.77,63.1 117.7,62.16 YJ25.A10
  BOTTOM w0.508: L278.1 118.38,80.85 118.15,80.62 C2285.2 118.15,78.71 117.89,78.46 C2286.1 117.89,77.32 117.54,76.96 117.03,76.96 v2(116.14,76.07) 115.3,75.23 v1(115.3,75.18)
VCC_RX_17: length 44.9
  POWER2 w0.508: v1(111.44,71.24) 108.26,68.06 108.26,57.25 110.42,55.1 116.89,55.1 117.7,54.29 YJ25.B10
  BOTTOM w0.508: L279.1 109.49,86.46 109.26,86.23 C2289.2 109.26,84.55 109,84.3 C2290.1 109,82.42 111.44,79.98 v1(111.44,71.24)
VCC_RX_18: length 40.2
  TOP w0.508: v1(108.01,74.24) 111.62,77.85 C2312.1 112.48,78.46 112.23,78.71 C2311.2 112.23,80.39 112,80.62 L288.1
  SIG10 w0.508: v1(108.01,74.24) 108.26,74 108.26,57.25 110.39,55.12 116.87,55.12 117.7,54.29 YJ26.D10
  BOTTOM w0.13: v2(108.78,73.66) 108.6,73.66 v1(108.01,74.24)
VCC_RX_19: length 34.5
  TOP w0.508: v1(112.84,76.07) 113.47,76.71 117.41,76.71 117.89,77.19 C2322.1 117.89,78.46 118.15,78.71 C2315.2 118.15,80.52 118.38,80.74 L289.1
  SIG10 w0.508: YJ26.C10 117.7,62.16 116.77,63.1 110.29,63.1 109.78,63.61 109.78,73.01 v1(112.84,76.07)
  BOTTOM w0.13: v2(113.6,76.07) v1(112.84,76.07)
VCC_RX_20: length 40.8
  SIG10 w0.508: YJ25.C10 136.7,62.16 135.77,63.1 129.29,63.1 128.78,63.61 128.78,66.72 131.53,69.47 133.54,69.47 136.21,72.13 136.21,74.29 137.22,75.31 137.22,78.15 139,79.93 v1(139,82.95)
  BOTTOM w0.254: v2(137.27,85.75) 137.55,85.47 C2277.2
  BOTTOM w0.508: v1(139,82.95) 138.9,83.06 C2278.1 138.9,84.58 138.65,84.83 C2277.2 138.65,86.46 138.8,86.61 L276.1
VCC_RX_21: length 50.5
  TOP w0.508: v1(132.65,84.33) 132.02,83.69 C2282.1 131.1,84.3 131.36,84.55 C2281.2 131.36,86.59 131.58,86.81 L277.1
  SIG1 w0.508: v1(133.29,74.29) 131.96,75.62 131.96,83.63 v1(132.65,84.33)
  SIG10 w0.508: v1(133.29,74.29) 127.26,68.26 127.26,57.25 129.42,55.1 135.82,55.1 136.7,54.21 YJ25.D10
  BOTTOM w0.13: v2(131.76,75.56) 131.76,75.31 132.78,74.29 v1(133.29,74.29)
VCC_RX_22: length 47.6
  POWER2 w0.508: YJ26.B10 136.7,54.21 135.82,55.1 129.42,55.1 127.26,57.25 127.26,69.79 131.57,74.1 131.57,82.29 v1(132.59,83.31)
  BOTTOM w0.254: v2(132.78,85.72) 132.52,85.47 C2316.2
  BOTTOM w0.508: L290.1 131.58,86.81 131.36,86.59 C2316.2 131.36,84.68 131.1,84.43 C2317.1 132.34,83.69 132.59,83.44 v1(132.59,83.31)
VCC_RX_23: length 42.8
  TOP w0.508: L291.1 138.42,86.46 138.65,86.23 C2320.2 138.65,84.43 138.9,84.17 C2321.1 138.01,83.69 v1(137.35,83.03)
  POWER2 w0.508: YJ26.A10 136.7,62.16 135.77,63.1 129.29,63.1 128.78,63.6 128.78,66.74 132.93,70.89 135.13,70.89 137.48,73.23 137.48,74.8 137.1,75.18 137.1,78.4 138.58,79.88 138.58,82.15 137.7,83.03 v1(137.35,83.03)
  BOTTOM w0.13: v2(137.76,84.2) 137.73,84.17 137.73,83.84 137.35,83.46 v1(137.35,83.03)
VCC_RX_24: length 30.3
  POWER2 w0.508: v1(161.58,75.69) 161.58,74.39 156.78,69.59 156.78,63.6 157.29,63.1 163.77,63.1 164.7,62.16 YJ27.A10
  BOTTOM w0.508: L302.1 162.57,80.62 162.34,80.39 C2348.2 162.34,78.84 162.09,78.59 C2349.1 162.12,77.82 v2(162.12,76.58) 162.12,76.22 v1(161.58,75.69)
VCC_RX_25: length 37.3
  POWER2 w0.508: v1(155.64,72.01) 155.26,71.63 155.26,57.25 157.42,55.1 163.89,55.1 164.7,54.29 YJ27.B10
  BOTTOM w0.508: L303.1 156.2,80.62 156.43,80.39 C2352.2 156.43,78.71 156.68,78.46 C2353.1 156.68,76.48 v2(156.65,76.45) 156.68,76.43 156.68,73.05 v1(155.64,72.01)
VCC_RX_26: length 37.6
  TOP w0.508: L312.1 156.2,80.62 156.43,80.39 C2379.2 156.43,78.74 156.68,78.48 C2380.1 156.68,74.19 v1(155.64,73.15)
  SIG10 w0.508: v1(155.64,73.15) 154.88,72.39 154.88,57.64 157.39,55.12 163.87,55.12 164.7,54.29 YJ28.D10
VCC_RX_27: length 32.4
  TOP w0.508: v1(159.19,76.71) 161.61,76.71 162.09,77.19 C2386.1 162.09,78.46 162.34,78.71 C2383.2 162.34,80.52 162.57,80.74 L313.1
  SIG10 w0.508: v1(159.19,76.71) 158.43,75.94 158.43,71.24 156.78,69.59 156.78,63.61 157.29,63.1 163.77,63.1 164.7,62.16 YJ28.C10
  BOTTOM w0.13: v2(159.19,75.94) v1(159.19,76.71)
VCC_RX_28: length 32.6
  TOP w0.508: L300.1 182.61,80.85 182.84,80.62 C2343.2 182.84,78.97 183.1,78.71 C2344.1 182.76,77.85 182.44,77.52 v1(182.44,77.21)
  SIG10 w0.508: YJ27.C10 183.7,62.16 182.77,63.1 176.29,63.1 175.78,63.61 175.78,68.14 182.44,74.8 v1(182.44,77.21)
  BOTTOM w0.13: v1(182.44,77.21) 183.07,76.58 v2(183.45,76.58)
VCC_RX_29: length 41.6
  TOP w0.508: v1(172.4,77.47) 172.91,76.96 174.97,76.96 175.3,77.28 C2354.1 175.3,78.71 175.55,78.97 C2347.2 175.55,80.62 175.78,80.85 L301.1
  SIG10 w0.508: v1(172.4,77.47) 172.4,74.29 174.26,72.44 174.26,57.25 176.42,55.1 182.82,55.1 183.7,54.21 YJ27.D10
  BOTTOM w0.13: v2(172.4,76.71) v1(172.4,77.47)
VCC_RX_30: length 37.1
  POWER2 w0.508: YJ28.B10 183.7,54.21 182.82,55.1 176.42,55.1 174.26,57.25 174.26,72.36 v1(174.79,72.9)
  BOTTOM w0.508: v1(174.79,72.9) 175.32,73.43 v2(175.32,76.45) 175.3,76.48 C2374.1 175.3,78.59 175.55,78.84 C2373.2 175.55,81.68 L314.1
VCC_RX_31: length 32.1
  POWER2 w0.508: v1(181.42,77.21) 181.17,77.21 180.69,76.73 180.69,74.17 175.78,69.27 175.78,63.6 176.29,63.1 182.77,63.1 183.7,62.16 YJ28.A10
  BOTTOM w0.508: v1(181.42,77.21) 181.67,77.47 181.67,77.72 v2(181.93,77.98) 182.44,77.98 182.56,77.85 C2385.1 183.1,78.61 182.84,78.86 C2384.2 182.84,80.52 182.61,80.74 L315.1
VCC_RX_32: length 32.8
  TOP w0.508: L326.1 212.36,80.87 212.13,80.64 C2408.2 212.13,78.97 211.87,78.71 C2409.1 211.87,76.81 v1(208.98,73.91)
  SIG10 w0.508: v1(208.98,73.91) 203.64,68.58 203.64,64.01 204.53,63.12 210.76,63.12 211.7,62.17 YJ29.A10
  BOTTOM w0.13: v2(208.98,75.31) v1(208.98,73.91)
VCC_RX_33: length 45.7
  TOP w0.508: v1(204.66,82.55) 205.8,83.69 C2417.1 206.46,84.43 206.21,84.68 C2412.2 206.21,86.46 205.98,86.69 L327.1
  POWER2 w0.508: v1(204.66,82.55) 204.03,81.91 204.03,71.86 202.13,69.96 202.13,57.38 204.42,55.1 210.89,55.1 211.7,54.29 YJ29.B10
  BOTTOM w0.13: v1(204.66,82.55) v2(204.66,83.44)
VCC_RX_34: length 44.9
  SIG1 w0.508: v1(204.79,81.53) 204.03,80.77 204.03,73.28 202.26,71.51 202.26,57.25 204.39,55.12 210.87,55.12 211.7,54.29 YJ30.D10
  BOTTOM w0.508: v1(204.79,81.53) 205.8,81.53 v2(206.44,82.17) 206.46,82.19 C2445.1 206.46,84.45 206.21,84.71 C2444.2 206.21,86.36 205.98,86.59 L336.1
VCC_RX_35: length 31.4
  SIG1 w0.508: v1(211.9,74.93) 203.78,66.81 203.78,63.61 204.6,62.79 211.08,62.79 211.7,62.16 YJ30.C10
  BOTTOM w0.508: L337.1 212.36,80.87 212.13,80.64 C2448.2 212.13,78.86 211.87,78.61 C2449.1 v2(211.87,76.32) 211.87,74.95 v1(211.9,74.93)
VCC_RX_36: length 33.8
  TOP w0.508: L324.1 232.4,79.86 C2405.2 232.63,78.84 232.88,78.59 C2413.1 231.84,77.85 v1(231.33,77.34)
  SIG1 w0.508: YJ29.C10 230.7,62.16 229.77,63.1 223.29,63.1 222.78,63.61 222.78,66.25 230.57,74.04 230.57,76.58 v1(231.33,77.34)
  BOTTOM w0.13: v2(231.97,76.71) v1(231.33,77.34)
VCC_RX_37: length 47
  TOP w0.508: v1(226.63,84.2) 226.12,83.69 C2418.1 225.08,84.05 225.34,84.3 C2416.2 225.56,85.7 L325.1
  SIG1 w0.508: YJ29.D10 230.7,54.21 229.82,55.1 223.42,55.1 221.26,57.25 221.26,74.74 226,79.48 226,83.56 v1(226.63,84.2)
VCC_RX_38: length 46
  POWER2 w0.508: v1(226.63,83.18) 225.87,82.42 225.87,77.72 221.26,73.11 221.26,57.25 223.42,55.1 229.82,55.1 230.7,54.21 YJ30.B10
  BOTTOM w0.508: v1(226.63,83.18) 226.12,83.69 C2438.1 225.08,84.55 225.34,84.81 C2437.2 225.56,85.7 L338.1
VCC_RX_39: length 35.3
  POWER2 w0.508: YJ30.A10 230.7,62.16 229.77,63.1 223.29,63.1 222.78,63.6 222.78,66.74 230.42,74.38 230.42,77.45 v1(231.33,78.36)
  BOTTOM w0.13: C2450.1 232.88,77.06 v2(233.36,76.58)
  BOTTOM w0.508: L339.1 232.4,79.86 C2441.2 232.63,78.99 232.88,78.74 C2450.1 231.84,77.85 v1(231.33,78.36)
VCC_RX_40: length 30.9
  POWER2 w0.508: v1(253.3,75.05) 253.3,72.13 250.78,69.61 250.78,63.6 251.29,63.1 257.77,63.1 258.7,62.16 YJ31.A10
  BOTTOM w0.508: L350.1 256.55,79.86 C2476.2 256.32,78.74 256.07,78.48 C2477.1 256.07,76.81 v2(255.46,76.2) 254.32,75.05 v1(253.3,75.05)
VCC_RX_41: length 37.5
  POWER2 w0.508: v1(248.98,71.77) 248.98,57.53 251.42,55.1 257.89,55.1 258.7,54.29 YJ31.B10
  BOTTOM w0.508: v1(248.98,71.77) 250.66,73.45 v2(250.66,76.32) C2481.1 250.66,78.74 250.41,78.99 C2480.2 250.18,79.86 L351.1
VCC_RX_42: length 40.4
  TOP w0.508: L360.1 250.18,79.86 C2503.2 250.41,78.74 250.66,78.48 C2504.1 250.66,74.6 v1(248.96,72.9)
  SIG1 w0.508: YJ32.D10 258.7,54.29 257.87,55.12 251.39,55.12 249.26,57.25 249.26,70.74 249.75,71.22 249.75,72.11 v1(248.96,72.9)
  BOTTOM w0.13: v1(248.96,72.9) v2(248.6,75.31)
VCC_RX_43: length 32.3
  TOP w0.508: v1(253.3,76.32) 255.21,76.32 256.07,77.19 C2514.1 256.07,78.2 256.32,78.46 C2507.2 256.55,79.86 L361.1
  SIG1 w0.508: v1(253.3,76.32) 252.41,75.44 252.41,71.2 250.78,69.57 250.78,63.61 251.29,63.1 257.77,63.1 258.7,62.16 YJ32.C10
  BOTTOM w0.13: v2(253.3,77.21) v1(253.3,76.32)
VCC_RX_44: length 34.8
  TOP w0.508: v1(275.4,77.34) 275.91,77.85 C2472.1 277.08,78.61 276.82,78.86 C2471.2 276.59,79.86 L348.1
  SIG1 w0.508: YJ31.C10 277.7,62.16 276.77,63.1 270.29,63.1 269.78,63.61 269.78,70.96 271.46,72.64 271.46,76.96 272.99,78.48 274.26,78.48 v1(275.4,77.34)
VCC_RX_45: length 38.9
  TOP w0.508: v1(268.77,77.09) 269.28,77.59 C2482.1 269.53,78.1 C2475.2 269.76,79.86 L349.1
  SIG1 w0.508: YJ31.D10 277.7,54.21 276.82,55.1 270.42,55.1 268.29,57.22 268.29,73.53 267.91,73.91 267.91,76.83 268.16,77.09 v1(268.77,77.09)
  BOTTOM w0.13: v1(268.77,77.09) 268.29,77.09 v2(267.78,76.58)
VCC_RX_46: length 37.7
  POWER2 w0.508: v1(268.77,76.2) 268.77,75.28 268.26,74.77 268.26,57.56 270.72,55.1 276.82,55.1 277.7,54.21 YJ32.B10
  BOTTOM w0.508: v1(268.77,76.2) 269.43,76.2 v2(269.81,76.58) 269.81,77.32 C2509.1 269.28,78.59 269.53,78.84 C2508.2 269.76,79.86 L362.1
VCC_RX_47: length 35.3
  POWER2 w0.508: YJ32.A10 277.7,62.16 276.77,63.1 270.29,63.1 269.78,63.6 269.78,69.27 274.51,74 274.51,77.79 275.08,78.36 v1(275.4,78.36)
  BOTTOM w0.508: v1(275.4,78.36) 276.03,77.72 276.03,76.96 276.54,76.45 v2(276.92,76.45) 277.08,76.6 C2513.1 277.08,78.74 276.82,78.99 C2512.2 276.59,79.86 L363.1
VCC_RX_48: length 32.1
  SIG1 w0.508: v1(304.33,76.22) 304.33,75.92 297.78,69.36 297.78,63.61 298.29,63.1 304.77,63.1 305.7,62.16 YJ33.A10
  BOTTOM w0.13: v2(304.23,75.44) 304.23,76.12 v1(304.33,76.22)
  BOTTOM w0.508: v1(304.33,76.22) C2540.1 304.33,77.95 305.73,79.35 C2539.2 305.73,80.39 305.96,80.62 L374.1
VCC_RX_49: length 49.7
  TOP w0.508: L375.1 285.48,85.7 C2544.2 285.71,84.71 285.97,84.45 C2545.1 285.97,83.16 286.33,82.8 287.71,82.8 v1(287.72,82.8)
  SIG1 w0.508: v1(287.72,82.8) 286.58,81.66 286.58,74.8 293.56,67.82 293.56,59.95 298.39,55.12 304.87,55.12 305.7,54.29 YJ33.B10
  BOTTOM w0.13: v2(286.7,82.42) 287.34,82.42 v1(287.72,82.8)
VCC_RX_50: length 45.6
  TOP w0.508: v1(298.89,83.82) C2571.1 299.94,84.45 299.56,84.83 C2570.2 299.33,85.82 L384.1
  POWER2 w0.508: YJ34.D10 305.7,54.29 304.89,55.1 298.42,55.1 296.26,57.25 296.26,74.58 298.03,76.34 298.03,82.95 v1(298.89,83.82)
  BOTTOM w0.13: v2(298.89,84.58) v1(298.89,83.82)
VCC_RX_51: length 32.2
  TOP w0.508: v1(303.34,76.2) 303.37,76.2 304.33,77.16 C2578.1 305.73,79.25 C2575.2 305.73,80.26 305.96,80.49 L385.1
  POWER2 w0.508: YJ34.C10 305.7,62.16 304.77,63.1 298.29,63.1 297.78,63.6 297.78,70.39 303.34,75.94 v1(303.34,76.2)
  BOTTOM w0.13: v2(302.96,75.44) 302.96,75.82 v1(303.34,76.2)
VCC_RX_52: length 38
  POWER2 w0.508: YJ33.C10 324.7,62.16 323.77,63.1 317.29,63.1 316.78,63.6 316.78,66.78 322.64,72.64 325.18,72.64 326.2,73.66 326.2,77.72 v1(326.83,78.36)
  BOTTOM w0.508: v1(326.83,78.36) 327.6,77.59 327.6,76.96 v2(327.98,76.58) 328.51,77.11 C2534.1 328.51,78.86 328.26,79.12 C2533.2 328.03,79.86 L372.1
VCC_RX_53: length 48.3
  POWER2 w0.508: YJ33.D10 324.7,54.21 323.82,55.1 317.42,55.1 315.26,57.25 315.26,74.73 321.53,81 321.53,82.37 v1(322.34,83.18)
  BOTTOM w0.13: v2(322.39,85.77) 322.08,85.47 C2543.2
  BOTTOM w0.508: v1(322.34,83.18) 321.83,83.69 C2546.1 320.71,84.17 320.97,84.43 C2543.2 320.97,86.23 321.2,86.46 L373.1
VCC_RX_54: length 47.8
  TOP w0.508: L386.1 321.2,85.7 C2565.2 320.97,84.83 320.71,84.58 C2566.1 321.83,83.69 v1(322.34,84.2)
  SIG1 w0.508: YJ34.B10 324.7,54.21 323.82,55.1 317.42,55.1 315.26,57.25 315.26,74.65 321.63,81.02 321.63,83.49 v1(322.34,84.2)
VCC_RX_55: length 38.8
  TOP w0.508: v1(326.83,77.34) 327.34,77.85 C2577.1 328.51,78.48 328.26,78.74 C2576.2 328.03,79.86 L387.1
  SIG1 w0.508: YJ34.A10 324.7,62.16 323.77,63.1 317.29,63.1 316.78,63.61 316.78,70.84 324.04,78.1 326.07,78.1 v1(326.83,77.34)
  BOTTOM w0.13: v1(326.83,77.34) 326.83,76.32 v2(327.85,75.31)
VCC_RX_56: length 34.1
  POWER2 w0.508: YJ35.A10 352.7,62.16 351.77,63.1 345.29,63.1 344.78,63.6 344.78,68.36 348.42,72.01 348.42,73.91 350.58,76.07 v1(352.62,76.07)
  BOTTOM w0.13: C2598.1 354.52,77.85 v2(354.65,77.72)
  BOTTOM w0.508: L398.1 353.96,79.86 C2597.2 353.73,78.59 353.48,78.33 C2598.1 353.48,76.96 352.59,76.07 v1(352.62,76.07)
VCC_RX_57: length 40
  POWER2 w0.508: v1(346.63,75.84) 346.63,74.65 342.96,70.99 342.96,57.55 345.42,55.1 351.89,55.1 352.7,54.29 YJ35.B10
  BOTTOM w0.508: L399.1 347.59,79.86 C2601.2 347.82,79.52 346.93,78.64 C2602.1 346.93,77.44 347.66,76.71 v2(347.66,75.82) 346.65,75.82 v1(346.63,75.84)
VCC_RX_58: length 39
  TOP w0.508: v1(346.6,76.83) 346.93,77.16 C2632.1 346.93,78.64 347.82,79.52 C2631.2 347.82,80.26 347.59,80.49 L408.1
  SIG1 w0.508: YJ36.D10 352.7,54.29 351.87,55.12 345.39,55.12 343.26,57.25 343.26,70.78 347.28,74.8 347.28,76.15 v1(346.6,76.83)
VCC_RX_59: length 32.3
  TOP w0.508: v1(352.62,77.09) 353.12,77.09 353.48,77.44 C2642.1 353.73,78.1 C2635.2 353.96,79.86 L409.1
  SIG1 w0.508: v1(352.62,77.09) 352.11,77.09 348.81,73.78 348.81,70.48 344.78,66.45 344.78,63.61 345.29,63.1 351.77,63.1 352.7,62.16 YJ36.C10
