# Allegro board RA-B6910-64C-MAC.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
CPLD3.3V on BOTTOM (solid shape): 375.22,219.83 375.22,218.41 375.21,218.38 375.17,218.36 374.17,218.36 374.17,217.35 374.15,217.31 374.12,217.29 372.77,217.29 372.74,217.31 372.72,217.35 372.72,218.36 371.63,218.36 371.63,217.35 371.61,217.31 371.58,217.29 371.28,217.29 371.16,217.42 371.16,219.83 371.28,219.96 375.09,219.96
CPLD3.3V on SIG7: outline of 137 points within 193.1,167.76 414.08,216.02
CPLD3.3V on POWER2: 394.99,49.15 393,51.13 393,84.28 391.56,85.72 346.94,85.72 345,83.77 345,81.74 344.28,81.02 337.59,81.02 336.99,81.61 336.99,84.15 335.55,85.6 250.93,85.6 247.5,82.17 241.96,82.17 238.53,85.6 154.41,85.6 153.23,84.71 153.23,82.76 152.76,82.29 147.34,82.29 147,82.63 147,84.66 145.94,85.72 60.18,85.72 58.74,84.28 58.74,82.63 58.27,82.17 54.38,82.17 51.58,84.96 40.28,84.96 37.49,87.75 2.18,87.75 1.16,88.77 1.02,88.77 1.02,169.16 1.37,169.51 5.37,169.51 6.54,170.68 6.54,173.99 6.16,174.37 1.77,174.37 1.02,175.13 1.02,221.99 1.78,222.76 10.99,222.76 12,223.77 58.74,223.77 59.37,223 59.4,170.24 59.4,169.92 59.42,109.85 66.02,103.25 352.57,103.25 356.04,106.72 356.04,222.93 357.1,223.98 428,223.98 428.7,223.7 428.98,223 428.98,208.41 428.89,208.41 427.77,207.29 424.2,207.29 423.85,206.93 423.85,203.09 424.38,202.55 428.46,202.55 428.98,202.02 428.98,54.1 428.61,54.1 427.46,52.96 418.83,52.96 416.02,50.15 415.88,50.03 415.88,50.01 415.06,49.19 414.96,49.15
FC0_1_PVDD0P8 on TOP: 173.67,184.91 177.47,184.91 177.5,184.87 177.5,183.11 177.4,183 173.55,183 173.42,183.13 173.42,184.66
FC0_1_PVDD0P8 on SIG5: 192.91,152.65 195.9,152.65 196.28,153.03 196.28,178.94 190.18,185.04 176.09,185.04 175.58,184.53 175.58,182.5 176.09,181.99 188.02,181.99 191.96,178.05 191.96,160.78 191.83,160.65 191.83,158.82 189.32,156.31 189.32,154.25 190.46,153.1 190.63,153.1 191.33,153.8 191.76,153.8
FC0_15_PVDD1P8 on TOP: 184.03,192.78 186.34,192.78 186.54,192.98 186.54,194.87 186.36,195.05 184.04,195.05 183.92,194.93 183.92,192.89 183.92,192.89
FC0_15_PVDD1P8 on SIG5: 182.41,141.78 177.33,141.78 176.92,142.19 176.92,154.07 177.33,154.48 188.61,154.48 188.91,154.18 188.91,153.5 189.38,153.03 190.92,153.03 191.46,153.57 191.68,153.57 192.19,153.05 192.19,153.03 193.08,152.14 196.13,152.14 196.94,152.96 196.94,178.97 190.27,185.64 186.73,185.64 185.86,186.5 185.86,194.05 186.12,194.31 192.68,194.31 199.89,187.1 199.89,169.52 200.5,168.91 200.5,149.4 200.19,149.1 183.12,149.1 182.51,148.49 182.51,141.88
FC2_3_PVDD0P8 on TOP: 207.58,192.78 209.36,192.78 209.49,192.91 209.49,196.34 209.36,196.47 207.58,196.47 207.45,196.34 207.45,192.91
FC2_3_PVDD0P8 on SIG9: 187.77,152.65 200.98,152.65 202.37,154.05 202.37,179.32 201.74,179.96 201.74,184.27 209.49,192.02 209.49,194.18 209.36,194.31 206.06,194.31 199.33,187.58 199.33,176.12 198.43,175.22 198.43,166.86 196.91,165.35 196.91,157.22 195.77,156.08 187.01,156.08 186.88,155.95 186.88,153.54
FC4_5_PVDD0P8 on TOP: 168.47,191.26 172.02,191.26 172.15,191.13 172.15,189.61 172.02,189.48 168.47,189.48 168.34,189.61 168.34,191.13
FC4_5_PVDD0P8 on SIG6: 196.79,160.65 196.79,164.34 196.15,164.97 196.15,168.65 196.79,169.29 196.79,170.43 197.93,171.57 197.93,178.81 190.49,186.25 172.58,186.25 170.24,188.59 170.24,192.53 170.5,192.78 188.66,192.78 200.34,181.1 200.34,167.26 199.71,166.62 199.71,154.56 195.77,150.62 183.96,150.62 183.83,150.75 183.83,154.48 184.08,154.73 190.87,154.73
FC6_7_PVDD0P8 on TOP: 158.05,171.19 158.05,168.53 157.92,168.4 156.02,168.4 152.72,171.7 152.72,172.59 152.84,172.72 156.53,172.72
FC6_7_PVDD0P8 on SIG7: 183.07,160.65 174.82,168.91 156.53,168.91 154.5,166.88 154.5,165.61 155,165.1 162.62,165.1 163.13,164.59 170.62,164.59 173.8,161.41 173.8,155.83 176.85,152.78 182.82,152.78 183.07,153.03
FC8_9_PVDD0P8 on TOP: 156.27,158.62 156.27,161.92 156.4,162.05 157.92,162.05 158.05,161.92 158.05,158.62 157.92,158.49 156.4,158.49
FC8_9_PVDD0P8 on SIG2: 178.75,156.33 177.48,157.6 169.61,157.6 168.59,158.62 157.16,158.62 156.27,159.51 156.27,163.7 156.65,164.08 164.78,164.08 166.81,162.05 179.13,162.05 184.21,156.97 184.21,149.86 183.83,149.48 181.93,149.48 178.75,152.65
FC10_11_PVDD0P8 on TOP: 153.99,158.62 153.99,161.92 154.11,162.05 155.64,162.05 155.77,161.92 155.77,158.62 155.64,158.49 154.11,158.49
FC10_11_PVDD0P8 on SIG3: 173.67,157.6 171.01,157.6 169.99,158.62 163.89,158.62 163.51,159 154.24,159 153.99,159.26 153.99,162.05 154.75,162.81 161.61,162.81 161.86,163.07 169.86,163.07 169.99,163.19 169.99,163.95 170.12,164.08 180.02,164.08 180.28,163.83 180.28,153.67 184.21,149.73 184.21,146.94 183.96,146.68 180.28,146.68 179.9,147.06 179.9,148.08 176.47,151.51 174.18,151.51 173.93,151.76 173.93,157.35
FC12_13_PVDD0P8 on TOP: 156.27,146.4 156.27,149.22 156.4,149.35 157.92,149.35 158.05,149.22 158.05,146.39 157.98,146.32 156.35,146.32
FC12_13_PVDD0P8 on SIG2: 178.88,143.63 178.63,143.89 178.63,145.41 177.48,146.56 163.89,146.56 163.39,147.06 156.53,147.06 156.27,147.32 156.27,148.84 156.4,148.97 168.53,148.97 169.61,150.05 180.85,150.05 184.21,146.68 184.21,143.89 183.96,143.63
FC14_15_PVDD0P8 on TOP: 153.99,149.22 154.11,149.35 155.81,149.35 155.95,149.21 155.95,146.41 155.86,146.32 154.44,146.32 154.44,147.02 153.99,147.47
FC14_15_PVDD0P8 on SIG4: 173.16,140.71 171.77,142.11 171.77,145.16 170.24,146.68 163.89,146.68 163.51,147.06 153.99,147.06 153.86,147.19 153.86,147.95 155,149.1 162.12,149.1 164.02,151 169.99,151 170.12,150.87 170.12,150.24 170.37,149.98 176.97,149.98 182.12,144.84 182.12,143.82 182.18,143.76 182.18,141.35 181.8,140.97 181.17,140.97 180.91,140.71
FC16_17_PVDD0P8 on TOP: 154.62,137.03 155.89,137.03 155.89,133.67 155.7,133.47 154.37,133.47 154.24,133.6 154.24,136.65
FC16_17_PVDD0P8 on SIG4: 171.26,132.71 170.5,133.47 169.35,133.47 168.72,134.11 168.72,135.25 168.34,135.63 164.4,135.63 163.51,134.74 154.11,134.74 153.99,134.87 153.99,136.4 154.37,136.78 161.73,136.78 163,138.05 168.72,138.05 168.97,138.3 168.97,138.81 169.1,138.94 179.64,138.94 181.29,140.59 181.93,140.59 183.2,139.32 183.2,132.97 182.94,132.71
FC16_31_PVDD1P8 on TOP: 160.34,133.35 158.8,133.35 158.68,133.47 158.68,137.03 158.77,137.12 160.52,137.12 160.58,137.06 160.58,133.59
FC16_31_PVDD1P8 on SIG3: 158.69,136.78 161.73,136.78 163,138.05 169.48,138.05 170.5,137.03 177.48,137.03 178.5,138.05 181.8,138.05 183.2,136.65 183.2,133.98 182.82,133.6 182.82,132.43 182.81,132.42 182.81,126.93 183.16,126.58 187.71,126.58 187.83,126.45 187.83,124.78 186.12,123.06 178.81,123.06 176.93,124.95 176.93,132.92 176.24,133.6 164.02,133.6 162.88,134.74 158.56,134.74 158.31,135 158.31,136.4
FC16_31_PVDD1P8 on SIG8: 184.49,126.09 191.86,126.09 192.83,125.12 194.67,125.12 194.82,124.97 194.82,123.8 194.62,123.59 183.94,123.59 183.77,123.76 183.77,125.38
FC18_19_PVDD0P8 on TOP: 158.31,137.03 158.43,136.9 158.43,133.6 158.31,133.47 156.29,133.47 156.12,133.64 156.12,136.93 156.22,137.03
FC18_19_PVDD0P8 on SIG2: 181.42,140.97 182.94,140.97 183.32,140.59 183.32,133.98 182.42,133.08 181.4,133.08 180.88,133.6 163.51,133.6 161.73,135.38 158.69,135.38 158.05,134.74 156.4,134.74 156.27,134.87 156.27,136.4 156.65,136.78 161.73,136.78 163,138.05 169.35,138.05 170.37,137.03 177.48,137.03
FC20_21_PVDD0P8 on TOP: 153.99,119.63 153.99,122.93 154.11,123.06 155.64,123.06 155.77,122.93 155.77,119.63 155.64,119.5 154.11,119.5
FC20_21_PVDD0P8 on SIG2: 178.75,132.71 179.01,132.97 183.2,132.97 183.32,132.84 183.32,126.24 178.63,121.54 160.34,121.54 158.43,119.63 154.62,119.63 154.11,120.14 154.11,123.19 154.5,123.57 158.81,123.57 159.45,124.2 168.59,124.2 169.48,125.09 175.96,125.09 178.75,127.89
FC22_23_PVDD0P8 on TOP: 156.27,119.63 156.27,122.93 156.4,123.06 157.92,123.06 158.05,122.93 158.05,119.63 157.92,119.5 156.4,119.5
FC22_23_PVDD0P8 on SIG4: 169.86,127.76 169.86,130.93 169.99,131.06 184.09,131.06 184.34,130.81 184.34,127 184.09,126.74 178.75,126.74 173.67,121.66 160.46,121.66 158.43,119.63 156.15,119.63 155.77,120.01 155.77,122.3 157.04,123.57 158.81,123.57 160.21,124.97 163.39,124.97 164.53,126.11 168.21,126.11
FC24_25_PVDD0P8 on TOP: 169.99,99.82 173.29,99.82 173.42,99.69 173.42,98.17 173.29,98.04 169.99,98.04 169.86,98.17 169.86,99.69
FC24_25_PVDD0P8 on SIG4: 173.93,121.28 178.63,125.98 184.09,125.98 184.21,125.85 184.21,121.79 181.17,118.74 181.17,114.93 177.86,111.63 177.36,111.63 177.23,111.5 177.23,98.04 176.85,97.66 171.13,97.66 170.88,97.91 170.88,118.74 171.26,119.12 173.67,119.12 173.93,119.38
FC26_27_PVDD0P8 on TOP: 169.99,102.11 173.29,102.11 173.42,101.98 173.42,100.45 173.29,100.33 169.99,100.33 169.86,100.45 169.86,101.98
FC26_27_PVDD0P8 on SIG9: 179.51,126.24 187.26,126.24 187.77,125.73 187.77,120.52 183.2,115.95 183.2,110.87 182.18,109.85 182.18,106.93 181.93,106.68 181.55,106.68 179.51,104.65 177.1,104.65 172.66,100.2 171.13,100.2 170.88,100.45 170.88,103.25 173.99,106.36 173.99,109.03 175.83,110.87 175.83,122.55
FC28_29_PVDD0P8 on TOP: 184.98,99.82 188.28,99.82 188.4,99.69 188.4,98.17 188.28,98.04 184.98,98.04 184.85,98.17 184.85,99.69
FC28_29_PVDD0P8 on SIG2: 189.04,125.98 194.88,125.98 195.14,125.73 195.14,122.04 194.75,121.66 190.44,121.66 190.18,121.41 190.18,121.28 189.29,120.39 189.29,111.5 188.28,110.49 188.28,106.04 187.77,105.53 187.77,96.01 187.39,95.63 185.23,95.63 184.85,96.01 184.85,104.01 183.83,105.03 183.83,120.77
FC28_29_PVDD0P8 on SIG4: 184.98,125.98 189.8,125.98 190.18,125.6 190.18,112.77 188.28,110.87 188.28,106.42 187.77,105.92 187.77,98.17 187.26,97.66 185.36,97.66 184.85,98.17 184.85,104.39 183.83,105.41 183.83,120.52 184.85,121.54 184.85,125.85
FC30_31_PVDD0P8 on TOP: 184.98,102.11 188.28,102.11 188.4,101.98 188.4,100.45 188.28,100.33 184.98,100.33 184.85,100.45 184.85,101.98
FC30_31_PVDD0P8 on SIG3: 189.42,125.98 194.88,125.98 195.14,125.73 195.14,122.17 194.63,121.66 193.48,121.66 189.29,117.47 189.29,111.63 188.28,110.61 188.28,105.53 187.77,105.03 187.77,100.33 187.39,99.95 185.61,99.95 185.48,100.07 185.48,103.63 183.83,105.28 183.83,120.39
FC32_33_PVDD0P8 on TOP: 197.8,99.82 201.1,99.82 201.23,99.69 201.23,98.17 201.1,98.04 197.8,98.04 197.68,98.17 197.68,99.69
FC32_33_PVDD0P8 on SIG3: 197.93,126.11 202.76,126.11 203.01,125.85 203.01,121.41 202.25,120.65 202.25,111.5 201.23,110.49 201.23,102.87 202.37,101.72 202.37,97.91 202.12,97.66 198.69,97.66 198.31,98.04 198.31,104.77 196.79,106.3 196.79,113.79 195.9,114.68 195.9,124.08
FC32_47_PVDD1P8 on TOP: 197.8,97.53 199.96,97.53 200.09,97.41 200.09,95.88 199.96,95.76 197.8,95.76 197.68,95.88 197.68,97.41
FC32_47_PVDD1P8 on SIG2: 196.28,126.24 204.53,126.24 204.54,126.23 208.18,126.23 208.33,126.08 208.33,122.07 207.87,121.61 203.46,121.61 202.25,120.39 202.25,111.5 201.23,110.49 201.23,102.87 202.37,101.72 202.37,96.26 201.74,95.63 198.69,95.63 198.31,96.01 198.31,104.77 196.91,106.17 196.91,119.5 195.9,120.52 195.9,125.85
FC32_47_PVDD1P8 on SIG3: 204.28,126.07 210.41,126.07 212.81,128.48 212.81,137.86 213.1,138.15 216.99,138.15 217.26,137.88 217.26,122.15 216.75,121.64 203.92,121.64 203.64,121.91 203.64,125.94 203.83,126.13 204.23,126.13
FC34_35_PVDD0P8 on TOP: 197.8,102.11 201.1,102.11 201.23,101.98 201.23,100.45 201.1,100.33 197.8,100.33 197.68,100.45 197.68,101.98
FC34_35_PVDD0P8 on SIG4: 197.42,126.11 205.55,126.11 205.8,125.85 205.8,120.9 202.25,117.35 202.25,110.87 202.12,110.74 201.36,110.74 201.23,110.61 201.23,100.58 200.85,100.2 198.56,100.2 198.31,100.45 198.31,103.63 196.91,105.03 196.91,109.34 195.9,110.36 195.9,124.58
FC36_37_PVDD0P8 on TOP: 216.85,102.11 220.15,102.11 220.28,101.98 220.28,100.45 220.15,100.33 216.85,100.33 216.73,100.45 216.73,101.98
FC36_37_PVDD0P8 on SIG4: 212.03,125.98 221.17,116.84 221.17,100.58 220.54,99.95 216.85,99.95 212.79,104.01 212.79,110.49 212.53,110.74 209.36,110.74 208.72,111.38 208.72,116.71 206.18,119.25 206.18,125.73 206.44,125.98
FC38_39_PVDD0P8 on TOP: 216.85,97.53 220.15,97.53 220.28,97.41 220.28,95.67 220.19,95.57 216.86,95.57 216.73,95.71 216.73,97.41
FC38_39_PVDD0P8 on SIG2: 209.23,126.11 212.92,126.11 216.22,122.81 216.22,105.92 219.39,102.74 219.39,96.52 218.63,95.76 215.33,95.76 215.01,96.07 215.01,102.04 210.88,106.17 210.88,118.87 208.85,120.9 208.85,125.73
FC40_41_PVDD0P8 on TOP: 239.33,124.58 239.33,127.89 239.46,128.01 240.86,128.01 240.98,127.89 240.98,124.58 240.86,124.46 239.46,124.46
FC40_41_PVDD0P8 on SIG4: 213.17,130.05 226.76,130.05 227.27,129.54 227.27,128.14 227.39,128.01 240.98,128.01 241.87,127.12 241.87,125.85 241.49,125.47 239.71,125.47 238.82,126.36 231.97,126.36 231.33,125.73 226.63,125.73 224.6,123.7 216.09,123.7 212.92,126.87 212.92,129.79
FC42_43_PVDD0P8 on TOP: 237.05,124.58 237.05,127.89 237.17,128.01 238.7,128.01 238.82,127.89 238.82,124.58 238.7,124.46 237.17,124.46
FC42_43_PVDD0P8 on SIG2: 218.12,129.54 218.12,128.27 218.38,128.01 231.46,128.01 232.47,129.03 238.7,129.03 238.95,128.78 238.95,125.98 238.7,125.73 237.17,125.73 236.54,126.36 234.89,126.36 234.25,125.73 226.89,125.73 225.87,124.71 215.33,124.71 212.79,127.25 212.79,132.97 212.92,133.09 214.57,133.09
FC44_45_PVDD0P8 on TOP: 242.25,141.73 242.38,141.6 242.38,140.21 243.14,139.44 243.14,138.3 243.01,138.17 241.24,138.17 241.11,138.3 241.11,139.57 240.47,140.21 240.47,141.6 240.6,141.73
FC44_45_PVDD0P8 on SIG4: 213.04,132.59 219.52,132.59 223.71,136.78 226,136.78 226.12,136.9 226.12,137.41 226.38,137.67 231.84,137.67 232.98,138.81 243.14,138.81 243.4,139.06 243.4,140.08 242.51,140.97 216.73,140.97 212.79,137.03 212.79,132.84
FC46_47_PVDD0P8 on TOP: 240.09,141.73 240.22,141.6 240.22,140.08 240.86,139.44 240.86,138.3 240.73,138.17 238.95,138.17 238.82,138.3 238.82,140.08 238.19,140.71 238.19,141.6 238.32,141.73
FC46_47_PVDD0P8 on SIG2: 213.04,135.63 215.71,135.63 216.98,136.9 231.58,136.9 233.49,138.81 240.73,138.81 240.98,139.06 240.98,140.71 240.6,141.09 213.42,141.09 212.79,140.46 212.79,135.89
FC48_49_PVDD0P8 on TOP: 238.95,152.52 238.7,152.78 238.7,153.92 238.82,154.05 240.22,154.05 240.35,153.92 240.35,152.52 240.98,151.89 240.98,150.62 240.86,150.49 239.08,150.49 238.95,150.62
FC48_49_PVDD0P8 on SIG4: 212.15,140.59 214.82,140.59 223.84,149.6 225.49,149.6 226.5,150.62 231.71,150.62 232.22,151.13 240.98,151.13 241.24,151.38 241.24,153.16 240.98,153.41 231.84,153.41 231.58,153.16 231.58,153.03 215.07,153.03 214.82,152.78 214.82,147.32 211.96,144.46 211.96,140.78
FC48_63_PVDD1P8 on TOP: 234.76,150.62 234.76,152.78 234.89,152.91 235.52,152.91 236.41,152.02 236.41,150.62 236.28,150.49 234.89,150.49
FC48_63_PVDD1P8 on SIG3: 220.54,149.73 226,149.73 226.12,149.86 226.12,150.49 226.25,150.62 231.71,150.62 232.22,151.13 236.41,151.13 236.92,151.64 236.92,152.65 236.54,153.03 221.53,153.03 221.32,153.24 221.32,157.63 220.92,158.04 203.14,158.04 202.83,157.73 202.83,152.85 203.14,152.55 204.86,152.55 210.66,146.76 212.92,146.76 212.92,141.98 213.17,141.73 216.09,141.73 216.98,142.62 220.03,142.62 220.28,142.87 220.28,149.48
FC50_51_PVDD0P8 on TOP: 238.06,154.05 238.32,153.79 238.32,152.65 238.7,152.27 238.7,150.62 238.57,150.49 236.79,150.49 236.66,150.62 236.66,152.14 235.9,152.91 235.9,153.92 236.03,154.05
FC50_51_PVDD0P8 on SIG2: 211.77,143.76 215.07,143.76 215.33,144.02 215.33,147.44 217.49,149.6 226,149.6 226.25,149.86 226.25,150.49 226.38,150.62 231.71,150.62 232.22,151.13 238.82,151.13 239.2,151.51 239.2,153.16 238.95,153.41 232.09,153.41 231.71,153.03 217.23,153.03 211.65,147.44 211.65,143.89
FC52_53_PVDD0P8 on TOP: 239.33,162.81 239.33,166.11 239.46,166.24 240.98,166.24 241.11,166.11 241.11,162.81 240.98,162.68 239.46,162.68
FC52_53_PVDD0P8 on SIG4: 213.68,146.68 214.19,147.19 214.19,153.03 215.84,154.68 217.74,154.68 220.54,157.48 224.98,157.48 225.3,157.79 225.3,162.24 225.74,162.68 230.95,162.68 231.58,163.32 241.11,163.32 241.36,163.57 241.36,165.48 240.86,165.99 232.85,165.99 231.71,167.13 225.11,167.13 224.92,166.94 224.92,165.67 223.33,164.08 219.14,164.08 213.17,158.11 209.87,158.11 209.74,157.99 209.74,146.94 209.99,146.68
FC54_55_PVDD0P8 on TOP: 237.05,162.81 237.05,166.11 237.17,166.24 238.7,166.24 238.82,166.11 238.82,162.81 238.7,162.68 237.17,162.68
FC54_55_PVDD0P8 on SIG2: 212.03,149.98 213.68,149.98 216.22,152.52 216.22,161.41 216.47,161.67 229.93,161.67 231.58,163.32 238.7,163.32 239.08,163.7 239.08,165.35 238.82,165.61 234.25,165.61 233.62,164.97 213.04,164.97 211.77,163.7 211.77,150.24
FC56_57_PVDD0P8 on TOP: 212.15,182.02 207.21,177.08 207.21,176.56 207.5,176.27 209.23,176.27 213.8,180.85 213.8,192.53 214.06,192.78 215.46,192.78 215.58,192.91 215.58,196.34 215.46,196.47 212.41,196.47 212.15,196.21
FC56_57_PVDD0P8 on SIG10: 204.53,152.52 214.57,152.52 215.07,153.03 215.07,157.86 207.45,165.48 207.45,174.5 209.11,176.15 209.11,177.92 208.98,178.05 206.18,178.05 200.72,172.59 200.72,156.33
FC58_59_PVDD0P8 on TOP: 228.16,192.78 229.93,192.78 230.06,192.91 230.06,196.34 229.93,196.47 228.16,196.47 228.03,196.34 228.03,192.91
FC58_59_PVDD0P8 on SIG6: 213.17,154.94 213.17,163.7 207.22,169.65 207.22,171.46 207.45,171.7 207.96,171.7 208.34,172.08 208.34,174.26 207.22,175.38 207.22,177.67 213.44,183.89 227.27,183.89 229.81,186.43 229.81,194.56 229.43,194.94 227.27,194.94 226.89,194.56 226.89,189.61 224.98,187.7 212.41,187.7 203.77,179.07 203.77,173.48 204.79,172.46 204.79,160.65 207.84,157.6 207.84,153.29 208.09,153.03 211.26,153.03
FC60_61_PVDD0P8 on TOP: 220.92,192.78 222.69,192.78 222.82,192.91 222.82,196.34 222.69,196.47 220.92,196.47 220.79,196.34 220.79,192.91
FC60_61_PVDD0P8 on SIG9: 207.96,152.91 208.22,153.16 208.22,155.45 207.58,156.08 207.58,166.49 206.31,167.76 206.31,174.5 207.2,175.38 207.2,179.7 215.96,188.47 222.19,188.47 222.82,189.1 222.82,194.05 222.57,194.31 219.14,194.31 216.85,192.02 215.84,192.02 204.53,180.72 204.53,174.75 202.88,173.1 202.88,156.21 205.04,154.05 205.04,153.03 205.17,152.91
FC62_63_PVDD0P8 on TOP: 216.09,192.78 217.87,192.78 218,192.91 218,196.34 217.87,196.47 216.09,196.47 215.96,196.34 215.96,192.91
FC62_63_PVDD0P8 on SIG6: 204.53,152.65 204.79,152.91 204.79,153.92 203.26,155.45 203.26,173.23 202.95,173.54 203.01,173.61 203.01,179.7 215.71,192.4 216.98,192.4 217.11,192.53 217.11,194.43 216.98,194.56 211.01,194.56 210.5,194.05 210.5,192.4 200.98,182.88 200.98,167.76 199.83,166.62 199.83,153.16 200.34,152.65
FC_TRVDD0P8_0 on BOTTOM: 154.87,163.34 155.38,162.83 155.38,158.9 154.72,158.25 154.72,145.88 154.4,145.56 148.47,145.56 148.06,145.97 148.06,162.67 148.73,163.34
FC_TRVDD0P8_0 on SIG4: 171.25,172.75 180.21,172.75 180.84,172.13 180.84,167.38 181.16,167.05 184.17,167.05 184.19,167.08 189.45,167.08 189.69,166.83 189.69,152.45 189.35,152.1 170.38,152.1 170.23,152.25 170.23,161.5 170.83,162.1 170.83,172.33
FC_TRVDD0P8_0 on SIG6: 190.06,165.73 192.85,165.73 193.61,164.97 195.64,164.97 196.15,164.46 196.15,161.03 195.9,160.78 178.89,160.78 177.85,159.73 177.85,140.23 177.58,139.95 170.43,139.95 170.18,140.2 170.18,146.25 170.91,146.97 170.91,149.04 169.81,150.13 169.81,153.72 168.74,154.79 168.29,154.79 168.02,155.06 168.02,156.68 169.93,158.58 169.93,162.24 166.18,165.99 165.04,165.99 164.91,166.11 164.91,167.64 165.16,167.89 183.58,167.89 184.72,166.75 189.04,166.75
FC_TRVDD0P8_0 on SIG7: 195.77,168.78 196.15,168.4 196.15,159.38 195.82,159.05 183.63,159.05 183.32,159.36 183.32,162.81 182.31,163.83 182.31,168.65 182.44,168.78
FC_TRVDD0P8_0 on SIG10: 148.15,163.32 157.17,172.34 164.41,172.34 166.7,174.62 189.83,174.62 191.1,173.35 191.1,155.81 190.77,155.48 177.5,155.48 177.23,155.21 177.23,140.23 176.87,139.87 174.27,139.87 173.3,140.84 160.69,140.84 159.97,140.12 148.42,140.12 147.69,140.85 147.69,149.45 148.17,149.93 148.17,152.17 148.15,152.19
FC_TRVDD0P8_1 on TOP: 147.73,129.66 147.4,130 147.4,132.5 147.86,132.97 151.13,132.97 151.36,132.73 151.36,129.93 151.1,129.66
FC_TRVDD0P8_1 on TOP: 153.27,118.48 149.42,118.48 149.42,118.49 146.39,118.49 146.15,118.73 146.15,123.09 146.37,123.32 153.51,123.32 153.68,123.15 153.68,118.9
FC_TRVDD0P8_1 on BOTTOM: 148.14,135.32 156.97,135.32 158.18,134.11 158.18,130.05 161.22,127 161.22,118.13 160.08,116.98 146.39,116.98 146.03,117.35 146.03,122.91 146.56,123.44 149.69,123.44 150.02,123.77 150.02,129.56 149.4,130.19 147.55,130.19 147.26,130.48 147.26,134.43
FC_TRVDD0P8_1 on SIG1: 169.86,121.66 195.64,121.66 197.04,120.27 197.04,106.42 195.77,105.15 171.01,105.15 169.74,106.42 169.74,121.54
FC_TRVDD0P8_1 on SIG10: 150.05,115.95 145.99,120.01 145.99,138.88 146.68,139.57 169.23,139.57 170.24,140.59 173.04,140.59 173.36,140.27 173.36,139 174.31,138.05 176.59,138.05 176.97,137.67 176.97,132.59 176.98,127.78 179.67,125.09 193.36,125.09 193.99,124.46 193.99,123.76 196.41,121.34 196.41,116.41 195.96,115.95 193.29,115.95 192.96,115.62 192.96,111.08 193.29,110.75 195.87,110.75 195.92,110.69 195.92,108.35 192.85,105.28 169.23,105.28 166.94,107.57 165.04,107.57 163.89,108.71 163.89,109.98 159.58,114.3 158.31,114.3 157.54,115.06 152.84,115.06 151.96,115.95
FC_TRVDD0P8_2 on TOP: 241.34,103.88 241.14,103.68 236.97,103.68 236.77,103.88 236.77,107.95 236.97,108.15 241.24,108.15 241.34,108.05
FC_TRVDD0P8_2 on BOTTOM: 239.38,120.85 242.35,120.85 242.76,120.44 242.76,104.29 242.35,103.88 237.07,103.88 236.77,104.19 236.77,110.26 235.9,111.12 234.76,111.12 232.09,113.79 232.09,127.12 232.35,127.38 235.14,127.38 238.44,124.08 238.44,121.79
FC_TRVDD0P8_2 on SIG7: 198.5,119.07 208.73,119.07 209.04,118.76 209.04,110.24 208.57,109.78 199.12,109.78 198.97,109.62 198.97,107.3 198.66,106.99 196.33,106.99 196.02,107.3 196.02,109.78 194.94,110.86 194.94,115.82 195.25,116.13 196.02,116.13 197.11,117.21 197.11,117.99 198.04,118.92 198.35,118.92
FC_TRVDD0P8_2 on SIG7: 226.76,111.76 229.68,111.76 230.57,110.87 235.9,110.87 240.22,106.55 240.22,101.72 239.46,100.96 234.63,100.96 229.68,105.92 226.76,105.92 226.38,106.3 226.38,111.38
FC_TRVDD0P8_2 on SIG10: 197.17,98.8 195.77,100.2 195.77,104.51 197.11,105.85 197.11,114.58 197.97,115.44 198.85,115.44 199.26,115.85 199.26,125.64 200.1,126.49 217.51,126.49 218,126.97 218,133.35 218.63,133.98 219.77,133.98 222.44,136.65 226.63,136.65 229.3,133.98 233.87,133.98 238.69,133.98 247.72,133.98 248.08,133.63 248.08,129.15 248.98,128.24 248.98,105.84 247.03,103.88 240.83,103.88 240.22,103.27 240.22,103.12 238.95,101.85 234,101.85 230.95,98.8
FC_TRVDD0P8_3 on BOTTOM: 240.55,167.89 241.36,168.71 246.28,168.71 246.77,168.21 246.77,163.15 246.03,162.41 244.08,162.41 244.08,162.41 243.19,162.41 242.01,161.22 242.01,159.92 241.66,159.57 237.02,159.57 236.7,159.25 236.7,156.05 237.18,155.57 243.68,155.57 243.68,150.36 243.74,150.29 244.7,150.29 244.86,150.13 244.86,148.69 238.62,148.69 237.98,148.05 237.98,143.89 238.46,143.41 241.18,143.41 241.5,143.73 241.5,145.01 241.82,145.33 244.86,145.33 245.1,145.09 245.1,138.12 244.89,137.92 232.5,137.92 231.99,138.43 231.99,167.41 232.47,167.89
FC_TRVDD0P8_3 on SIG4: 209.23,165.99 210.25,167 215.96,167 216.22,166.75 216.22,162.43 213.55,159.76 201.99,159.76 201.87,159.89 201.87,165.86 201.99,165.99
FC_TRVDD0P8_3 on SIG5: 219.14,163.95 218.88,163.7 204.15,163.7 202.88,164.97 202.88,168.78 203.14,169.03 213.42,169.03 214.31,169.92 219.01,169.92 219.14,169.8
FC_TRVDD0P8_3 on SIG10: 216.98,135.63 216.73,135.89 216.73,146.3 218.14,147.72 218.14,160.02 213.55,160.02 208.12,165.45 208.12,166.09 208.09,166.11 208.09,174.37 210.88,177.16 237.04,177.16 244.03,170.18 244.03,160.4 243.76,160.13 234.62,160.13 234.19,159.7 234.19,155.7 234.76,155.13 234.76,155.06 242.73,155.06 243.39,154.41 243.39,144.66 242.49,143.76 236.54,143.76 236.41,143.89 236.41,144.52 236.16,144.78 234.57,144.78 234.19,144.4 234.19,143.57 234.2,143.56 234.2,142.77 234.55,142.42 245.56,142.42 246.06,141.92 246.06,136.65 245.81,136.4 235.14,136.4 234.38,135.63 228.41,135.63 226.38,137.67 222.57,137.67 220.54,135.63
FC_TVDD1P2_0 on TOP: 163.51,178.69 167.32,178.69 167.45,178.56 167.45,176.78 167.32,176.65 163.51,176.65 163.39,176.78 163.39,178.56
FC_TVDD1P2_0 on BOTTOM: 194.88,173.61 194.88,168.53 194.12,167.76 176.47,167.76 175.45,166.75 175.45,162.18 174.94,161.67 170.37,161.67 169.99,161.29 169.99,144.27 169.74,144.02 163.64,144.02 162.37,145.29 162.37,175.38 164.4,177.42 171.26,177.42 172.28,176.4 192.09,176.4
FC_TVDD1P2_0 on SIG5: 168.21,150.87 174.94,150.87 175.32,151.25 175.32,162.05 177.36,164.08 188.79,164.08 188.91,164.21 188.91,169.03 187.26,170.69 183.71,170.69 181.67,172.72 165.42,172.72 165.04,172.34 165.04,169.42 165.54,168.91 167.32,168.91 167.58,168.65 167.58,164.84 168.08,164.34 168.08,151
FC_TVDD1P2_0 on SIG7: 172.28,153.03 172.15,153.16 168.47,153.16 168.21,152.91 168.21,139.7 168.34,139.57 172.15,139.57 172.28,139.7
FC_TVDD1P2_1 on BOTTOM: 172.66,135 194.88,112.77 194.88,107.06 191.07,103.25 163,103.25 161.93,104.33 161.93,127.31 159.58,129.66 159.58,133.98 160.34,134.74 160.34,135.51 160.97,136.14 163.51,136.14 163.77,135.89 163.77,135.51 164.27,135
FC_TVDD1P2_1 on SIG1: 161.48,121.79 168.21,121.79 169.1,120.9 169.1,108.58 168.47,107.95 161.35,107.95 160.97,108.33 160.97,121.28
FC_TVDD1P2_1 on SIG5: 164.15,107.82 179.13,107.82 179.26,107.95 179.26,108.58 179.51,108.84 181.55,108.84 181.8,108.58 181.8,108.07 182.05,107.82 190.44,107.82 191.07,108.46 191.07,116.96 174.94,133.09 168.08,133.09 167.45,132.46 167.45,115.06 164.02,111.63 164.02,107.95
FC_TVDD1P2_1 on SIG7: 168.21,126.11 168.59,125.73 172.02,125.73 172.28,125.98 172.28,138.94 172.15,139.06 168.34,139.06 168.21,138.94
FC_TVDD1P2_2 on TOP: 236.92,112.06 236.92,108.71 237.07,108.56 240.32,108.56 240.73,108.96 240.73,112.11 240.53,112.32 237.17,112.32
FC_TVDD1P2_2 on SIG5: 229.68,107.95 225.36,107.95 225.11,108.2 225.11,110.23 224.85,110.49 216.47,110.49 215.58,109.6 197.55,109.6 197.17,109.98 197.17,117.47 197.42,117.73 212.79,117.73 214.19,119.12 214.19,136.4 214.95,137.16 217.61,137.16 218.5,138.05 226.89,138.05 227.27,137.67 227.27,119.38 228.92,117.73 229.43,117.73 230.95,116.2 233.11,116.2 239.59,109.73 239.59,108.07 239.46,107.95 235.9,107.95 232.22,111.63 228.92,111.63 228.79,111.5 228.79,110.11 229.17,109.73 229.55,109.73 229.81,109.47 229.81,108.07
FC_TVDD1P2_2 on SIG6: 219.52,138.94 226.5,138.94 226.89,138.55 226.89,138.17 226.5,137.79 225.49,137.79 225.23,137.54 225.23,135 225.49,134.74 229.68,134.74 229.93,134.49 229.93,131.32 229.43,130.81 225.23,130.81 225.11,130.68 225.11,128.27 225.62,127.76 226.5,127.76 226.76,127.51 226.76,126.24 226.5,125.98 226,125.98 225.87,125.85 225.87,123.19 226.38,122.68 229.81,122.68 230.31,122.17 230.31,119.25 229.93,118.87 224.22,118.87 223.58,119.5 223.58,122.68 221.3,124.97 219.27,124.97 219.01,125.22 219.01,138.43
FC_TVDD1P2_2 on SIG6: 199.07,114.93 209.61,114.93 213.04,111.5 213.04,110.36 212.79,110.11 211.39,110.11 211.01,110.49 211.01,110.87 210.76,111.12 208.34,111.12 207.96,110.74 207.96,107.19 207.84,107.06 204.28,107.06 204.03,107.31 204.03,110.36 203.39,111 201.23,111 200.98,110.74 200.98,110.23 200.72,109.98 199.45,109.98 198.95,110.49 198.95,114.81
FC_TVDD1P2_2 on SIG6: 232.6,110.11 239.08,110.11 239.84,109.34 239.84,106.93 239.2,106.3 229.55,106.3 227.77,108.07 227.77,110.49 228.28,111 231.71,111
FC_TVDD1P2_2 on SIG7: 227.27,138.05 227.27,134.36 227.52,134.11 230.06,134.11 230.31,133.86 230.31,131.7 230.19,131.57 227.39,131.57 227.27,131.44 227.27,125.98 227.01,125.73 221.17,125.73 220.92,125.98 220.92,138.68 221.17,138.94 226.38,138.94
FC_TVDD1P2_3 on BOTTOM: 227.39,177.16 231.97,177.16 232.22,176.91 232.22,173.99 231.97,173.73 229.43,173.73 228.66,174.5 226,174.5 224.73,173.23 217.49,173.23 217.11,172.84 208.47,172.84 208.09,172.46 208.09,171.32 207.71,170.94 204.79,170.94 204.28,171.45 204.28,173.61 207.45,176.78 227.01,176.78
FC_TVDD1P2_3 on SIG4: 216.85,175.51 223.33,175.51 223.96,174.88 223.96,168.78 222.82,167.64 211.39,167.64 210.63,168.4 210.63,171.57 212.41,173.35 215.07,173.35 216.09,174.37 216.09,174.75
FC_TVDD1P2_3 on SIG5: 225.11,171.07 225.36,170.81 229.68,170.81 229.93,170.56 229.93,169.16 229.68,168.91 229.17,168.91 229.04,168.78 229.04,163.57 228.66,163.19 220.15,163.19 219.52,163.83 219.52,169.8 219.01,170.3 217.87,170.3 216.85,171.32 216.85,175 217.36,175.51 224.35,175.51 225.11,174.75
FC_TVDD1P2_3 on SIG7: 228.28,143.25 229.93,144.9 229.93,146.56 229.43,147.06 227.39,147.06 227.14,147.32 227.14,152.27 228.16,153.29 228.16,154.43 228.41,154.68 228.92,154.68 229.17,154.94 229.17,156.59 229.3,156.59 229.43,156.72 230.06,156.72 230.19,156.84 230.19,160.65 229.81,161.03 228.41,161.03 228.28,161.16 228.28,164.84 228.03,165.1 223.08,165.1 222.82,164.84 222.82,141.22 224.09,139.95 227.27,139.95 228.28,140.97
IP_PLL_AVDD1P8 on TOP: 177.36,191.26 177.48,191.13 177.48,189.48 177.36,189.35 174.43,189.35 174.31,189.48 174.31,191.01 174.56,191.26
IP_PLL_AVDD1P8 on SIG3: 196.15,174.11 196.15,178.69 184.34,190.5 175.58,190.5 175.2,190.12 175.2,188.59 175.7,188.08 177.23,188.08 179.39,185.93 185.61,185.93 192.85,178.69 192.85,174.37 193.87,173.35 193.87,168.02 194.88,167 194.88,157.86 196.02,156.72 200.03,156.72 200.24,156.93 200.24,170.03
MC_PVDD0P8 on TOP: 171.13,184.91 171.13,184.91 171.43,184.91 172.06,184.27 172.78,184.27 172.91,184.15 172.91,183.36 172.61,183.06 171.55,183.06 171.39,183.23 171.39,183.35 171.03,183.71 167.63,183.71 167.45,183.89 167.45,184.78 167.58,184.91
MC_PVDD0P8 on SIG4: 195.14,151.64 195.26,151.76 195.26,166.62 194.25,167.64 194.25,176.91 186.12,185.04 169.86,185.04 169.35,184.53 169.35,182.37 169.74,181.99 185.1,181.99 189.93,177.16 189.93,152.78 191.07,151.64
MC_TRVDD0P8 on TOP: 187.9,192.78 188.3,192.38 188.77,192.38 188.99,192.6 188.99,195.81 188.76,196.05 187.01,196.05 186.88,195.91 186.88,192.9 186.99,192.78
MC_TRVDD0P8 on SIG2: 198.31,160.65 200.98,160.65 201.23,160.91 201.23,186.49 193.79,193.93 188.44,193.93 187.9,193.39 187.9,191.83 197.75,181.97 197.75,178.23 199.33,176.65 199.33,174.62 197.29,172.59 197.29,161.67
MISC_PLL_AVDD1P8 on TOP: 151.57,133.47 151.45,133.6 151.45,135.76 151.57,135.89 153.86,135.89 153.99,135.76 153.99,133.6 153.86,133.47
MISC_PLL_AVDD1P8 on SIG5: 162.62,133.6 161.86,132.84 152.84,132.84 152.59,133.09 152.59,135.13 153.42,135.95 161.67,135.95 163.77,138.05 168.72,138.05 168.85,138.17 168.85,138.94 169.1,139.19 178.88,139.19 179.13,138.94 179.13,133.98 178.75,133.6
Net_5 on BOTTOM (solid shape): outline of 184 points within 19.75,84.83 23.3,88.39
Net_6 on TOP (solid shape): outline of 184 points within 19.32,74.07 22.87,77.62
Net_7 on TOP (solid shape): outline of 184 points within 11.62,201.16 15.18,204.72
Net_8 on BOTTOM (solid shape): outline of 184 points within 11.62,201.16 15.18,204.72
Net_9 on SIG2: 402.56,37.2 402.56,35.68 404.09,35.68 404.09,37.2
Net_10 on GND2: 402.56,37.2 402.56,35.68 404.09,35.68 404.09,37.2
Net_11 on POWER1: 402.56,37.2 402.56,35.68 404.09,35.68 404.09,37.2
Net_12 on GND2: 399.51,37.2 399.51,35.68 401.04,35.68 401.04,37.2
Net_13 on SIG2: 399.51,37.2 399.51,35.68 401.04,35.68 401.04,37.2
Net_14 on GND3: 399.51,37.2 399.51,35.68 401.04,35.68 401.04,37.2
Net_15 on GND4: 399.51,37.2 399.51,35.68 401.04,35.68 401.04,37.2
Net_16 on GND5: 399.51,37.2 399.51,35.68 401.04,35.68 401.04,37.2
Net_17 on POWER1: 399.51,37.2 399.51,35.68 401.04,35.68 401.04,37.2
Net_18 on SIG10: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_19 on GND11: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_20 on POWER2: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_21 on GND12: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_22 on GND12: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_23 on POWER2: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_24 on GND11: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_25 on SIG10: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_26 on GND10: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_27 on SIG9: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_28 on GND9: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_29 on SIG8: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_30 on GND8: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_31 on SIG7: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_32 on GND7: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_33 on SIG6: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_34 on GND6: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_35 on SIG5: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_36 on GND5: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_37 on SIG4: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_38 on GND4: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_39 on SIG3: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_40 on GND3: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_41 on SIG2: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_42 on GND2: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_43 on POWER1: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_44 on POWER1: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_45 on GND2: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_46 on SIG2: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_47 on GND3: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_48 on SIG3: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_49 on GND4: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_50 on SIG4: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_51 on GND5: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_52 on SIG5: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_53 on GND6: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_54 on SIG6: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_55 on GND7: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_56 on SIG7: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_57 on GND8: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_58 on SIG8: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_59 on GND9: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_60 on SIG9: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_61 on GND10: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_62 on SIG10: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_63 on GND11: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_64 on POWER2: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_65 on GND12: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_66 on GND12: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_67 on POWER2: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_68 on GND11: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_69 on SIG10: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_70 on GND10: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_71 on SIG9: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_72 on GND9: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_73 on SIG8: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_74 on GND8: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_75 on SIG7: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_76 on GND7: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_77 on SIG6: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_78 on GND6: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_79 on SIG5: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_80 on GND5: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_81 on SIG4: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_82 on GND4: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_83 on SIG3: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_84 on GND3: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_85 on SIG2: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_86 on GND2: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_87 on POWER1: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_88 on SIG1: 399.51,40.25 399.51,38.72 401.04,38.72 401.04,40.25
Net_89 on SIG1: 402.56,40.25 402.56,38.72 404.09,38.72 404.09,40.25
Net_90 on SIG1: 399.51,43.3 399.51,41.77 401.04,41.77 401.04,43.3
Net_91 on SIG1: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_92 on POWER1: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_93 on GND2: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_94 on SIG2: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_95 on GND3: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_96 on SIG3: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_97 on GND4: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_98 on SIG4: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_99 on GND5: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_100 on SIG5: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_101 on GND5: 402.56,37.2 402.56,35.68 404.09,35.68 404.09,37.2
Net_102 on GND4: 402.56,37.2 402.56,35.68 404.09,35.68 404.09,37.2
Net_103 on GND3: 402.56,37.2 402.56,35.68 404.09,35.68 404.09,37.2
Net_104 on SIG7: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_105 on GND8: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_106 on SIG8: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_107 on GND9: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_108 on SIG9: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_109 on GND10: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_110 on SIG10: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_111 on GND11: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_112 on POWER2: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_113 on GND12: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_114 on GND12: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_115 on POWER2: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_116 on GND11: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_117 on SIG10: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_118 on GND10: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_119 on SIG9: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_120 on GND9: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_121 on SIG8: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_122 on GND8: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_123 on SIG7: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_124 on GND7: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_125 on SIG6: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_126 on GND6: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_127 on SIG5: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_128 on GND5: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_129 on SIG4: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_130 on GND4: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_131 on SIG3: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_132 on GND3: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_133 on SIG2: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_134 on GND2: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_135 on POWER1: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_136 on SIG1: 402.56,46.34 402.56,44.82 404.09,44.82 404.09,46.34
Net_137 on SIG1: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_138 on POWER1: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_139 on GND2: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_140 on SIG2: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_141 on GND3: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_142 on SIG3: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_143 on GND4: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_144 on SIG4: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_145 on GND5: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_146 on SIG5: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_147 on GND6: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_148 on SIG6: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_149 on GND7: 399.51,46.34 399.51,44.82 401.04,44.82 401.04,46.34
Net_150 on GND6: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_151 on SIG6: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_152 on GND7: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_153 on SIG7: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_154 on GND8: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_155 on SIG8: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_156 on GND9: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_157 on SIG9: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_158 on GND10: 402.56,43.3 402.56,41.77 404.09,41.77 404.09,43.3
Net_159 on SIG3: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_160 on GND4: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_161 on SIG4: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_162 on GND5: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_163 on SIG5: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_164 on GND6: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_165 on SIG6: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_166 on GND7: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_167 on SIG7: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_168 on GND8: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_169 on SIG8: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_170 on GND9: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_171 on SIG9: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_172 on GND10: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_173 on SIG10: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_174 on GND11: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_175 on POWER2: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_176 on GND12: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_177 on POWER1: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_178 on GND2: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_179 on SIG2: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_180 on GND3: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_181 on SIG3: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_182 on GND4: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_183 on SIG4: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_184 on GND5: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_185 on SIG5: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_186 on GND6: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_187 on SIG6: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_188 on GND7: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_189 on SIG7: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_190 on GND8: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_191 on SIG8: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_192 on GND9: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_193 on SIG9: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_194 on GND10: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_195 on SIG10: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_196 on GND11: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_197 on POWER2: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_198 on GND12: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_199 on POWER1: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_200 on GND2: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_201 on SIG2: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_202 on GND3: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_203 on SIG3: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_204 on GND4: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_205 on SIG4: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_206 on GND5: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_207 on SIG5: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_208 on GND6: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_209 on SIG6: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_210 on GND7: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_211 on SIG7: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_212 on GND8: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_213 on SIG8: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_214 on GND9: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_215 on SIG9: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_216 on GND10: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_217 on SIG10: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_218 on GND11: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_219 on POWER2: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_220 on GND12: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_221 on SIG1: 405.61,40.25 405.61,38.72 407.13,38.72 407.13,40.25
Net_222 on SIG1: 408.66,40.25 408.66,38.72 410.18,38.72 410.18,40.25
Net_223 on SIG1: 405.61,43.3 405.61,41.77 407.13,41.77 407.13,43.3
Net_224 on SIG1: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_225 on POWER1: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_226 on GND2: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_227 on SIG2: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_228 on SIG2: 405.61,37.2 405.61,35.68 407.13,35.68 407.13,37.2
Net_229 on GND2: 405.61,37.2 405.61,35.68 407.13,35.68 407.13,37.2
Net_230 on GND5: 408.66,37.2 408.66,35.68 410.18,35.68 410.18,37.2
Net_231 on GND4: 408.66,37.2 408.66,35.68 410.18,35.68 410.18,37.2
Net_232 on GND3: 408.66,37.2 408.66,35.68 410.18,35.68 410.18,37.2
Net_233 on SIG2: 408.66,37.2 408.66,35.68 410.18,35.68 410.18,37.2
Net_234 on GND2: 408.66,37.2 408.66,35.68 410.18,35.68 410.18,37.2
Net_235 on POWER1: 408.66,37.2 408.66,35.68 410.18,35.68 410.18,37.2
Net_236 on POWER1: 405.61,37.2 405.61,35.68 407.13,35.68 407.13,37.2
Net_237 on GND5: 405.61,37.2 405.61,35.68 407.13,35.68 407.13,37.2
Net_238 on GND4: 405.61,37.2 405.61,35.68 407.13,35.68 407.13,37.2
Net_239 on GND3: 405.61,37.2 405.61,35.68 407.13,35.68 407.13,37.2
Net_240 on GND12: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_241 on POWER2: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_242 on GND11: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_243 on SIG10: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_244 on GND10: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_245 on SIG9: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_246 on GND9: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_247 on SIG8: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_248 on GND8: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_249 on SIG7: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_250 on GND7: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_251 on SIG6: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_252 on GND6: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_253 on SIG5: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_254 on GND5: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_255 on SIG4: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_256 on GND4: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_257 on SIG3: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_258 on GND3: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_259 on SIG2: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_260 on GND2: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_261 on POWER1: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_262 on GND12: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_263 on POWER2: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_264 on GND11: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_265 on SIG10: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_266 on GND10: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_267 on SIG9: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_268 on GND9: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_269 on SIG8: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_270 on GND8: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_271 on SIG7: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_272 on GND7: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_273 on SIG6: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_274 on GND6: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_275 on SIG5: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_276 on GND5: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_277 on SIG4: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_278 on GND4: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_279 on SIG3: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_280 on GND3: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_281 on SIG2: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_282 on GND2: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_283 on POWER1: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_284 on SIG1: 408.66,46.34 408.66,44.82 410.18,44.82 410.18,46.34
Net_285 on SIG1: 405.61,46.34 405.61,44.82 407.13,44.82 407.13,46.34
Net_286 on GND3: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_287 on SIG3: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_288 on GND4: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_289 on SIG4: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_290 on GND5: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_291 on SIG5: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_292 on GND6: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_293 on SIG6: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_294 on GND7: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_295 on SIG7: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
Net_296 on GND8: 408.66,43.3 408.66,41.77 410.18,41.77 410.18,43.3
