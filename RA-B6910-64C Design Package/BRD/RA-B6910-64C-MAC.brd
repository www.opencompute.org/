# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAC_PCIE_RST#: length 305.5
  TOP w0.13: R2042.1 165.95,98.65 165.16,99.44 165.16,101.47 v1(166.56,102.87) ; v1(15.94,171.45) R28.2 R3280.2 ; U1.Y33 v1(198.55,125.34)
  SIG7 w0.155: v1(198.55,125.34) 198.04,125.85 194.12,125.85 192.09,123.82 192.09,123.19 190.79,121.89 173.36,121.89 173.04,121.56 173.04,105.97 170.45,103.38 167.07,103.38 v1(166.56,102.87)
  SIG10 w0.155: v1(166.56,102.87) 166.56,103.1 166.39,103.27 166.15,103.27 164.01,105.41 163,105.41 160.29,108.13 159.65,108.13 157.92,109.85 153.96,109.85 152.84,110.97 152.84,111.5 151.65,112.7 150.89,112.7 150.31,113.28 148.75,113.28 146.56,115.47 146.56,115.88 145.54,116.9 144.27,116.9 143.19,117.98 143.19,121.41 122.05,142.55 122.05,192.49 109.31,205.23 71.76,205.23 71.25,205.74 66.99,205.74 65.26,207.47 55.55,207.47 35.65,187.58 29.91,187.58 28.12,185.78 22.78,185.78 17.08,180.08 17.08,174.5 16.45,173.86 16.45,171.96 v1(15.94,171.45)
  BOTTOM w0.13: v1(15.94,171.45) v2(15.18,171.45)
MAC_PCIE_RXN0: length 138.1
  TOP w0.107: U1.BY32 X1.1
  SIG7 w0.102: X1.1 199.55,165.94 arc(199.49,165.8) 199.35,165.75 199.25,165.75 arc(199.21,165.76) 199.18,165.78 arc(199.16,165.81) 199.15,165.85 199.15,169.66 arc(199.19,169.85) 199.3,170.02 199.5,170.22 arc(199.65,170.45) 199.71,170.72 199.71,171.71 199.77,171.78 199.77,171.8
  SIG7 w0.14: 199.77,171.8 199.77,172.92 arc(199.8,173.06) 199.88,173.18 201.76,175.06 arc(201.92,175.29) 201.97,175.56 201.97,180.03 arc(201.92,180.3) 201.76,180.53 195.27,187.02 arc(195.19,187.14) 195.16,187.28 195.16,190.41 arc(195.1,190.67) 194.95,190.9 188.97,196.88 arc(188.74,197.04) 188.48,197.09 184.68,197.09 arc(184.54,197.12) 184.42,197.2 183.62,198 arc(183.4,198.15) 183.13,198.2 162.4,198.2 arc(162.26,198.23) 162.14,198.31 159.54,200.91 arc(159.31,201.06) 159.04,201.11 116.85,201.11 arc(116.71,201.14) 116.59,201.22 108.5,209.31 arc(108.42,209.43) 108.39,209.57 108.39,214.68 arc(108.34,214.95) 108.19,215.17 107.33,216.04 arc(107.1,216.19) 106.83,216.24 105.01,216.24 104.56,216.1 103.92,216.1 arc(103.79,216.13) 103.68,216.2 103.6,216.29 arc(103.57,216.33) 103.54,216.37 arc(103.52,216.42) 103.52,216.48 103.52,216.6 arc(103.56,216.78) 103.66,216.93 103.67,216.93 103.73,216.99 103.89,217.14 103.9,217.15 104,217.24 arc(104.06,217.31) 104.12,217.39 104.16,217.45 arc(104.32,217.6) 104.53,217.65 arc(104.74,217.56) 104.83,217.35 YJ3.B4_1
MAC_PCIE_RXN1: length 144.6
  TOP w0.107: U1.BV31 X2.1
  SIG7 w0.102: 202.89,172.94 202.89,172.91 202.96,172.85 202.96,164.15 arc(202.9,164.01) 202.75,163.95 201.17,163.95 arc(200.92,164) 200.7,164.14 200.58,164.26 arc(200.56,164.3) X2.1
  SIG7 w0.14: YJ3.A5_1 103.97,221.92 arc(103.96,221.88) 103.95,221.84 103.94,221.69 arc(103.91,221.53) 103.84,221.37 arc(103.81,221.32) 103.76,221.28 103.67,221.18 103.51,221.05 103.49,221.03 103.44,220.97 arc(103.25,220.71) 103.19,220.4 103.19,220.28 arc(103.2,220.16) 103.24,220.04 103.24,220.04 arc(103.29,219.94) 103.37,219.85 103.45,219.77 arc(103.67,219.62) 103.92,219.57 104.3,219.57 arc(104.37,219.58) 104.44,219.59 104.72,219.64 arc(104.75,219.65) 104.79,219.65 106.39,219.65 arc(106.54,219.62) 106.65,219.54 111.77,214.43 arc(111.85,214.31) 111.87,214.17 111.87,208.01 arc(111.93,207.74) 112.08,207.51 116.7,202.89 arc(116.93,202.74) 117.19,202.69 159.55,202.69 arc(159.69,202.66) 159.81,202.58 161.59,200.81 arc(161.81,200.65) 162.08,200.6 186.82,200.6 arc(186.97,200.57) 187.08,200.49 196.4,191.18 arc(196.48,191.06) 196.51,190.92 196.51,187.64 arc(196.56,187.37) 196.71,187.14 202.78,181.07 arc(202.86,180.95) 202.89,180.81 202.89,172.94
MAC_PCIE_RXN2: length 150.9
  TOP w0.107: U1.BY30 X72.1
  SIG7 w0.102: 197.83,175.89 197.83,175.87 197.76,175.8 197.76,175.56 arc(197.81,175.33) 197.93,175.14 198.02,175.06 arc(198.2,174.78) 198.27,174.45 198.27,171.25 arc(198.27,171.13) 198.25,171.02 198.16,170.52 arc(198.15,170.44) 198.15,170.37 198.15,165.13 arc(198.2,165) 198.34,164.94 200.81,164.94 arc(200.91,164.98) 200.95,165.08 200.95,165.68 arc(201.06,165.95) 201.33,166.06 arc(201.36,166.06) 201.4,166.07 arc(201.51,166.15) 201.55,166.28 X72.1
  SIG7 w0.14: 197.83,175.89 197.83,179.9 arc(197.77,180.16) 197.62,180.39 191.29,186.72 arc(191.21,186.84) 191.19,186.98 191.19,189.66 arc(191.13,189.92) 190.98,190.15 189.48,191.65 arc(189.25,191.8) 188.99,191.86 184.82,191.86 arc(184.68,191.88) 184.56,191.96 181.45,195.08 arc(181.22,195.23) 180.95,195.28 158.77,195.28 arc(158.62,195.31) 158.5,195.39 156.41,197.48 arc(156.19,197.63) 155.92,197.69 114.82,197.69 arc(114.68,197.71) 114.56,197.79 107.08,205.28 arc(106.85,205.43) 106.58,205.48 100.04,205.48 arc(99.9,205.51) 99.78,205.59 96.47,208.9 arc(96.39,209.02) 96.36,209.16 96.36,218.91 arc(96.31,219.17) 96.15,219.4 95.89,219.67 arc(95.66,219.82) 95.39,219.87 94.54,219.87 arc(94.27,219.82) 94.05,219.67 93.18,218.8 93.01,218.66 92.91,218.56 arc(92.89,218.53) 92.87,218.51 arc(92.85,218.49) 92.83,218.47 arc(92.78,218.43) 92.72,218.4 arc(92.71,218.39) 92.7,218.39 arc(92.69,218.38) 92.68,218.38 arc(92.34,218.37) YJ3.B5_2
MAC_PCIE_RXN3: length 164.6
  TOP w0.107: U1.BT30 X73.1
  SIG7 w0.102: 196.33,175.87 196.4,175.8 196.4,175.04 arc(196.44,174.81) 196.57,174.62 196.64,174.55 arc(196.73,174.42) 196.76,174.27 196.76,170.94 196.84,169.83 196.84,165.78 197,165.63 197,163.23 arc(197.05,162.96) 197.2,162.73 197.98,161.95 arc(198.21,161.8) 198.47,161.75 200.63,161.75 arc(200.7,161.72) 200.73,161.65 arc(200.71,161.53) 200.65,161.44 X73.1
  SIG7 w0.14: 196.33,175.87 196.33,178.73 arc(196.3,178.87) 196.22,178.99 188.84,186.38 arc(188.72,186.46) 188.58,186.48 161.2,186.48 arc(160.93,186.54) 160.71,186.69 153.86,193.54 arc(153.74,193.62) 153.59,193.65 112.94,193.65 arc(112.67,193.7) 112.45,193.85 104.74,201.56 arc(104.62,201.64) 104.47,201.67 97.97,201.67 arc(97.55,201.75) 97.2,201.99 93.78,205.41 arc(93.64,205.5) 93.47,205.53 86.19,205.53 arc(85.77,205.62) 85.42,205.85 84.27,207.01 arc(84.11,207.23) 84.06,207.5 84.06,211.05 arc(84.11,211.31) 84.27,211.54 86.24,213.51 arc(86.32,213.63) 86.35,213.77 86.35,217.33 arc(86.43,217.72) 86.65,218.06 88.38,219.79 arc(88.72,220.02) 89.11,220.09 90.3,220.09 arc(90.54,220.14) 90.75,220.28 91.44,220.97 91.49,221.03 91.51,221.05 91.67,221.18 91.76,221.28 arc(91.81,221.32) 91.84,221.37 arc(91.91,221.53) 91.94,221.69 91.96,221.88 YJ3.A5_2
MAC_PCIE_RXP0: length 138.1
  TOP w0.107: U1.BW32 X3.1
  SIG7 w0.102: 199.44,171.8 199.44,171.78 199.51,171.71 199.51,170.72 arc(199.47,170.53) 199.36,170.36 199.16,170.16 arc(199,169.93) 198.95,169.66 198.95,165.85 arc(198.97,165.74) 199.04,165.64 arc(199.14,165.57) 199.25,165.55 arc(199.33,165.53) 199.4,165.49 X3.1
  SIG7 w0.14: YJ3.B5_1 103.96,218.08 103.94,217.89 arc(103.91,217.73) 103.84,217.57 arc(103.81,217.52) 103.76,217.48 103.67,217.38 103.51,217.25 103.49,217.23 103.44,217.17 arc(103.25,216.91) 103.19,216.6 103.19,216.48 arc(103.2,216.36) 103.24,216.24 103.24,216.24 arc(103.29,216.14) 103.37,216.05 103.45,215.97 arc(103.67,215.82) 103.92,215.77 104.61,215.77 105.06,215.91 106.83,215.91 arc(106.97,215.88) 107.09,215.8 107.96,214.94 arc(108.04,214.82) 108.06,214.68 108.06,209.57 arc(108.12,209.31) 108.27,209.08 116.36,200.99 arc(116.59,200.84) 116.85,200.78 159.04,200.78 arc(159.18,200.76) 159.3,200.68 161.9,198.08 arc(162.13,197.92) 162.4,197.87 183.13,197.87 arc(183.27,197.84) 183.39,197.76 184.19,196.96 arc(184.42,196.81) 184.68,196.76 188.48,196.76 arc(188.62,196.73) 188.74,196.65 194.72,190.67 arc(194.8,190.55) 194.83,190.41 194.83,187.28 arc(194.88,187.02) 195.03,186.79 201.53,180.29 arc(201.61,180.17) 201.64,180.03 201.64,175.56 arc(201.61,175.42) 201.53,175.3 199.65,173.42 arc(199.5,173.19) 199.44,172.92 199.44,171.8
MAC_PCIE_RXP1: length 144.6
  TOP w0.107: U1.BU31 X4.1
  SIG7 w0.102: 203.22,172.94 203.22,172.91 203.16,172.85 203.16,164.15 arc(203.04,163.87) 202.75,163.75 201.53,163.75 arc(201.25,163.72) 200.97,163.63 arc(200.96,163.63) 200.96,163.62 arc(200.95,163.62) 200.94,163.62 arc(200.73,163.5) X4.1
  SIG7 w0.14: 203.22,172.94 203.22,180.81 arc(203.17,181.08) 203.02,181.31 196.95,187.38 arc(196.87,187.5) 196.84,187.64 196.84,190.92 arc(196.79,191.19) 196.63,191.41 187.32,200.73 arc(187.09,200.88) 186.82,200.93 162.08,200.93 arc(161.94,200.96) 161.82,201.04 160.04,202.81 arc(159.82,202.97) 159.55,203.02 117.19,203.02 arc(117.05,203.05) 116.93,203.13 112.31,207.75 arc(112.23,207.87) 112.2,208.01 112.2,214.17 arc(112.15,214.44) 112,214.66 106.89,219.78 arc(106.66,219.93) 106.39,219.98 104.79,219.98 arc(104.72,219.98) 104.65,219.97 104.37,219.91 arc(104.34,219.91) 104.3,219.9 103.92,219.9 arc(103.79,219.93) 103.68,220 103.6,220.09 arc(103.57,220.13) 103.54,220.17 arc(103.52,220.22) 103.52,220.28 103.52,220.4 arc(103.56,220.58) 103.66,220.73 103.67,220.73 103.73,220.79 103.89,220.94 104,221.04 104.27,221.31 arc(104.34,221.36) 104.43,221.38 104.45,221.38 arc(104.72,221.27) YJ3.A4_1
MAC_PCIE_RXP2: length 150.9
  TOP w0.107: U1.BW30 X74.1
  SIG7 w0.102: 197.5,175.89 197.5,175.87 197.56,175.8 197.56,175.56 arc(197.62,175.26) 197.79,175.01 197.88,174.92 arc(198.02,174.7) 198.07,174.45 198.07,171.25 arc(198.07,171.15) 198.06,171.06 197.97,170.55 arc(197.95,170.46) 197.95,170.37 197.95,165.13 arc(198.06,164.86) 198.34,164.74 200.81,164.74 arc(201.05,164.84) 201.15,165.08 201.15,165.68 arc(201.2,165.81) 201.33,165.86 201.43,165.86 arc(201.51,165.83) 201.55,165.74 X74.1
  SIG7 w0.14: YJ3.B4_2 92.94,217.68 arc(92.95,217.72) 92.95,217.76 92.97,217.91 arc(93,218.07) 93.07,218.23 arc(93.1,218.28) 93.14,218.32 93.24,218.42 93.4,218.55 93.41,218.56 94.28,219.43 arc(94.4,219.51) 94.54,219.54 95.39,219.54 arc(95.53,219.51) 95.65,219.43 95.92,219.17 arc(96,219.05) 96.03,218.91 96.03,209.16 arc(96.08,208.9) 96.23,208.67 99.55,205.36 arc(99.77,205.2) 100.04,205.15 106.58,205.15 arc(106.72,205.12) 106.84,205.04 114.33,197.56 arc(114.55,197.41) 114.82,197.36 155.92,197.36 arc(156.06,197.33) 156.18,197.25 158.27,195.16 arc(158.5,195) 158.77,194.95 180.95,194.95 arc(181.1,194.92) 181.22,194.84 184.33,191.73 arc(184.55,191.58) 184.82,191.53 188.99,191.53 arc(189.13,191.5) 189.25,191.42 190.75,189.92 arc(190.83,189.8) 190.86,189.66 190.86,186.98 arc(190.91,186.71) 191.06,186.49 197.39,180.16 arc(197.47,180.04) 197.5,179.9 197.5,175.89
MAC_PCIE_RXP3: length 164.6
  TOP w0.107: U1.BR30 X75.1
  SIG7 w0.102: 196.66,175.87 196.66,175.87 196.59,175.8 196.59,175.04 arc(196.62,174.89) 196.71,174.76 196.78,174.69 arc(196.91,174.5) 196.95,174.27 196.95,170.95 197.04,169.84 197.04,165.86 197.19,165.71 197.19,163.23 arc(197.23,163.03) 197.34,162.87 198.12,162.09 arc(198.28,161.98) 198.47,161.95 200.63,161.95 arc(200.84,161.86) 200.93,161.65 arc(200.93,161.63) 200.93,161.61 arc(200.99,161.42) 201.17,161.34 X75.1
  SIG7 w0.14: 196.66,175.87 196.66,178.73 arc(196.61,179) 196.46,179.23 189.07,186.61 arc(188.84,186.76) 188.58,186.81 161.2,186.81 arc(161.06,186.84) 160.94,186.92 154.09,193.77 arc(153.86,193.92) 153.59,193.98 112.94,193.98 arc(112.8,194.01) 112.68,194.09 104.97,201.8 arc(104.74,201.95) 104.47,202 97.97,202 arc(97.68,202.06) 97.43,202.23 94.01,205.64 arc(93.77,205.81) 93.47,205.86 86.19,205.86 arc(85.9,205.92) 85.65,206.09 84.5,207.24 arc(84.42,207.36) 84.39,207.5 84.39,211.05 arc(84.42,211.19) 84.5,211.31 86.47,213.28 arc(86.62,213.51) 86.68,213.77 86.68,217.33 arc(86.73,217.6) 86.88,217.82 88.62,219.56 arc(88.84,219.71) 89.11,219.76 90.29,219.76 arc(90.67,219.84) 90.98,220.05 91.67,220.74 91.73,220.8 91.89,220.94 92,221.04 arc(92.02,221.07) 92.04,221.09 arc(92.06,221.11) 92.08,221.13 arc(92.13,221.17) 92.19,221.2 arc(92.2,221.21) 92.2,221.21 arc(92.21,221.22) 92.23,221.22 arc(92.57,221.23) YJ3.A4_2
MAC_PCIE_TXN0: length 137.3
  TOP w0.107: v1(127.21,207.01) 127.3,206.92 arc(127.36,206.84) 127.38,206.74 127.38,205.94 arc(127.42,205.74) 127.53,205.56 129.87,203.23 arc(130.04,203.11) 130.25,203.07 156.89,203.07 arc(157.22,203.14) 157.5,203.32 159.68,205.5 arc(159.86,205.62) 160.06,205.66 190.3,205.66 arc(191,205.52) 191.6,205.12 193.66,203.06 arc(194.56,201.71) 194.88,200.12 194.88,187.85 arc(194.95,187.52) 195.13,187.24 204.56,177.81 arc(204.75,177.54) v1(204.81,177.21)
  SIG10 w0.124: YJ3.D5_1 104.08,210.98 arc(104.19,210.7) 104.47,210.59 arc(104.55,210.6) 104.61,210.65 104.99,211.02 arc(105.01,211.04) 105.03,211.06 105.16,211.17 arc(105.17,211.18) 105.18,211.19 105.27,211.28 arc(105.37,211.41) 105.42,211.56 arc(105.48,211.85) 105.65,212.09 arc(105.88,212.25) 106.16,212.3 107.51,212.3 arc(107.62,212.32) 107.72,212.39 108.2,212.87 arc(108.4,213.01) 108.64,213.05 111.62,213.05 arc(111.85,213.01) 112.06,212.87 118.72,206.2 arc(118.82,206.14) 118.93,206.12 127.43,206.12 arc(127.52,206.15) 127.55,206.24 127.55,206.87 arc(127.51,206.97) 127.42,207.01 v1(127.21,207.01)
  BOTTOM w0.107: v1(204.81,177.21) 205.02,177.42 arc(205.08,177.56) 205.02,177.69 204.94,177.77 arc(204.91,177.8) 204.87,177.83 arc(204.73,177.9) 204.57,177.92 204.47,177.92 arc(204.18,177.87) 203.94,177.71 203.93,177.7 arc(203.72,177.39) 203.64,177.01 203.64,176.42 arc(203.64,176.28) 203.62,176.15 arc(203.61,176.1) 203.6,176.06 arc(203.46,175.75) 203.26,175.48 202.64,174.86 202.41,174.63 202.25,174.47 arc(202.13,174.29) 202.09,174.08 202.09,173.24 arc(202.14,173.12) 202.25,173.07 C2075.2
MAC_PCIE_TXN1: length 133.2
  TOP w0.107: C2077.2 208.06,180.47 arc(207.83,180.77) 207.69,181.13 arc(207.68,181.19) 207.67,181.25 arc(207.66,181.35) 207.65,181.46 207.65,181.77 arc(207.48,182.22) 207.04,182.43 206.88,182.44 arc(206.85,182.45) 206.83,182.45 203.41,182.45 arc(203.2,182.49) 203.03,182.6 197.45,188.18 arc(197.34,188.36) 197.29,188.56 197.29,200.03 arc(196.64,203.31) 194.79,206.09 192.19,208.68 arc(191.15,209.38) 189.91,209.62 160.39,209.62 arc(160.06,209.56) 159.78,209.37 156,205.59 arc(155.83,205.47) 155.62,205.43 132.02,205.43 arc(131.95,205.45) 131.88,205.49 131.64,205.73 arc(131.6,205.79) 131.58,205.87 131.58,206.57 arc(131.62,206.75) 131.72,206.89 v1(131.87,207.04)
  SIG10 w0.124: YJ3.C5_1 104.66,214.8 arc(104.72,214.8) 104.77,214.81 arc(104.78,214.81) 104.79,214.81 arc(104.8,214.81) 104.81,214.81 arc(104.82,214.82) 104.84,214.82 arc(105.02,214.89) 105.18,215.01 105.3,215.13 arc(105.37,215.24) 105.42,215.36 arc(105.48,215.65) 105.65,215.89 arc(105.88,216.05) 106.16,216.1 107.51,216.1 arc(107.75,216.05) 107.95,215.92 109.16,214.71 arc(109.25,214.65) 109.37,214.63 113.12,214.63 arc(113.36,214.58) 113.56,214.44 119.69,208.31 arc(119.78,208.25) 119.9,208.23 131.24,208.23 arc(131.56,208.09) 131.69,207.77 131.69,207.46 arc(131.74,207.23) v1(131.87,207.04)
MAC_PCIE_TXN2: length 136.4
  TOP w0.107: C2079.2 198.05,180.69 arc(198.17,180.86) 198.21,181.07 198.21,181.13 arc(198.17,181.34) 198.05,181.51 193.15,186.41 arc(192.97,186.69) 192.9,187.02 192.9,198.72 arc(192.55,200.46) 191.56,201.94 190.28,203.23 arc(189.89,203.49) 189.43,203.58 162.21,203.58 arc(162.01,203.54) 161.83,203.42 159.7,201.29 arc(159.42,201.1) 159.09,201.04 127.6,201.04 arc(127.4,201.08) 127.22,201.19 124.05,204.37 arc(123.93,204.55) 123.89,204.75 123.89,206.54 arc(123.85,206.71) 123.76,206.86 v1(123.61,207.01)
  SIG4 w0.14: YJ3.D5_2 92.08,210.76 arc(92.15,210.58) 92.33,210.51 arc(92.45,210.53) 92.55,210.59 93.1,211.15 93.17,211.19 93.27,211.29 arc(93.28,211.31) 93.3,211.32 93.32,211.35 93.37,211.41 arc(93.39,211.44) 93.42,211.46 93.86,211.91 arc(94.27,212.18) 94.75,212.28 95.23,212.28 arc(95.5,212.23) 95.73,212.07 96.06,211.74 arc(96.22,211.51) 96.27,211.24 96.27,209.31 arc(96.3,209.17) 96.38,209.05 98.95,206.48 arc(99.07,206.4) 99.21,206.37 114.71,206.37 arc(114.98,206.32) 115.2,206.17 116.67,204.7 arc(116.79,204.62) 116.93,204.59 122.34,204.59 arc(122.48,204.62) 122.6,204.7 123.87,205.98 arc(123.95,206.1) 123.98,206.24 123.98,206.39 arc(123.93,206.62) 123.8,206.81 v1(123.61,207.01)
MAC_PCIE_TXN3: length 135.1
  TOP w0.107: v1(119.85,207.01) 120,206.86 arc(120.1,206.71) 120.13,206.54 120.13,204.31 arc(120.17,204.1) 120.29,203.93 126.45,197.77 arc(126.62,197.65) 126.83,197.61 160.49,197.61 arc(160.82,197.68) 161.1,197.86 164.55,201.31 arc(164.72,201.43) 164.93,201.47 187.22,201.47 arc(188.07,201.3) 188.79,200.82 189.82,199.79 arc(190.6,198.62) 190.87,197.25 190.87,186.27 arc(190.94,185.94) 191.13,185.66 195.18,181.61 195.48,181.3 arc(195.53,181.24) 195.54,181.16 195.54,181.03 arc(195.51,180.86) 195.41,180.71 C2081.2
  SIG4 w0.14: v1(119.85,207.01) 119.91,206.94 arc(120.07,206.7) 120.13,206.42 arc(120.04,206.21) 119.82,206.12 117.53,206.12 arc(117.39,206.14) 117.27,206.22 115.8,207.69 arc(115.57,207.84) 115.3,207.9 101.53,207.9 arc(101.39,207.92) 101.27,208 100.58,208.7 arc(100.5,208.82) 100.47,208.96 100.47,211.78 arc(100.42,212.05) 100.27,212.28 96.67,215.87 arc(96.44,216.03) 96.17,216.08 94.75,216.08 arc(94.27,215.98) 93.86,215.71 93.86,215.71 93.42,215.26 arc(93.39,215.24) 93.37,215.21 93.3,215.12 arc(93.28,215.11) 93.27,215.09 93.17,214.99 93.1,214.95 92.58,214.43 arc(92.42,214.32) 92.22,214.28 arc(92.12,214.32) 92.08,214.42 YJ3.C5_2
MAC_PCIE_TXP0: length 137.3
  TOP w0.107: v1(128.11,207.01) 127.96,207.01 arc(127.78,206.93) 127.71,206.76 127.71,205.94 arc(127.72,205.86) 127.77,205.8 130.1,203.46 arc(130.17,203.42) 130.25,203.4 156.89,203.4 arc(157.1,203.44) 157.27,203.56 159.45,205.74 arc(159.73,205.93) 160.06,205.99 190.3,205.99 arc(191.13,205.83) 191.84,205.35 193.9,203.29 arc(194.87,201.84) 195.21,200.12 195.21,187.85 arc(195.25,187.64) 195.37,187.47 198.44,184.4 204.65,178.19 arc(205.02,177.94) 205.45,177.86 v1(205.46,177.86)
  SIG10 w0.124: YJ3.D4_1 104.99,210.43 arc(105,210.47) 105.01,210.51 105.03,210.54 arc(105.04,210.57) 105.06,210.6 105.09,210.65 105.11,210.67 105.22,210.79 arc(105.23,210.8) 105.24,210.81 105.36,210.91 105.37,210.92 arc(105.39,210.94) 105.41,210.95 105.51,211.05 arc(105.66,211.26) 105.74,211.5 arc(105.75,211.51) 105.75,211.53 105.75,211.54 arc(105.78,211.71) 105.88,211.86 arc(106.01,211.94) 106.16,211.97 107.51,211.97 arc(107.75,212.02) 107.95,212.15 108.44,212.64 arc(108.53,212.7) 108.64,212.72 111.62,212.72 arc(111.73,212.7) 111.82,212.64 118.49,205.97 arc(118.69,205.84) 118.93,205.79 127.43,205.79 arc(127.75,205.92) 127.88,206.24 127.88,206.47 arc(127.94,206.76) v1(128.11,207.01)
  BOTTOM w0.107: C2076.2 arc(201.5,173.09) 201.51,173.1 arc(201.69,173.39) 201.76,173.73 201.76,174.08 arc(201.83,174.42) 202.02,174.71 202.33,175.02 202.41,175.1 203.02,175.71 arc(203.18,175.91) 203.28,176.15 arc(203.29,176.18) 203.29,176.21 arc(203.31,176.31) 203.31,176.42 203.31,177.01 arc(203.41,177.51) 203.7,177.93 arc(204.05,178.17) 204.47,178.25 204.57,178.25 arc(204.83,178.22) 205.06,178.1 arc(205.12,178.05) 205.18,178 205.23,177.95 arc(205.33,177.88) v1(205.46,177.86)
MAC_PCIE_TXP1: length 133.2
  TOP w0.107: v1(130.97,207.04) 131.12,206.89 arc(131.22,206.75) 131.25,206.57 131.25,205.87 arc(131.3,205.67) 131.41,205.49 131.65,205.26 arc(131.82,205.14) 132.02,205.1 155.62,205.1 arc(155.95,205.17) 156.23,205.36 160.01,209.14 arc(160.19,209.25) 160.39,209.29 189.91,209.29 arc(191.02,209.07) 191.96,208.45 194.55,205.85 arc(196.34,203.18) 196.96,200.03 196.96,188.56 arc(197.03,188.23) 197.22,187.95 202.8,182.37 arc(203.08,182.18) 203.41,182.12 206.83,182.12 arc(206.84,182.12) 206.85,182.11 207.01,182.1 arc(207.23,182) 207.32,181.77 207.32,181.2 arc(207.25,180.84) 207.05,180.54 C2078.2
  SIG10 w0.124: v1(130.97,207.04) 131.24,207.04 arc(131.33,207.08) 131.36,207.17 131.36,207.77 arc(131.33,207.86) 131.24,207.9 119.9,207.9 arc(119.66,207.94) 119.45,208.08 113.32,214.21 arc(113.23,214.27) 113.12,214.3 109.37,214.3 arc(109.13,214.34) 108.92,214.48 107.72,215.68 arc(107.62,215.75) 107.51,215.77 106.16,215.77 arc(106.01,215.74) 105.88,215.66 arc(105.78,215.51) 105.75,215.34 105.75,215.33 arc(105.74,215.31) 105.74,215.3 arc(105.67,215.08) 105.53,214.9 105.37,214.73 105.26,214.63 105.26,214.63 105.11,214.48 105.08,214.43 arc(105.07,214.42) 105.06,214.41 105.04,214.36 105.02,214.32 arc(105.01,214.31) 105.01,214.29 104.99,214.23 arc(104.98,214.2) 104.97,214.18 104.96,214.16 arc(104.95,214.13) 104.94,214.11 104.89,214.04 104.76,213.86 arc(104.71,213.62) 104.82,213.41 YJ3.C4_1
MAC_PCIE_TXP2: length 136.4
  TOP w0.107: C2080.2 198.7,180.69 arc(198.58,180.86) 198.54,181.07 198.54,181.13 arc(198.47,181.46) 198.29,181.74 193.39,186.64 arc(193.27,186.82) 193.23,187.02 193.23,198.72 arc(192.86,200.59) 191.8,202.18 190.51,203.46 arc(190.02,203.79) 189.43,203.91 162.21,203.91 arc(161.88,203.84) 161.6,203.66 159.47,201.52 arc(159.3,201.41) 159.09,201.37 127.6,201.37 arc(127.52,201.38) 127.46,201.43 124.28,204.61 arc(124.23,204.67) 124.22,204.75 124.22,206.54 arc(124.25,206.71) 124.35,206.86 v1(124.5,207.01)
  SIG4 w0.14: v1(124.5,207.01) 124.4,206.9 arc(124.33,206.81) 124.31,206.7 124.31,206.24 arc(124.26,205.97) 124.11,205.74 122.83,204.47 arc(122.61,204.32) 122.34,204.26 116.93,204.26 arc(116.66,204.32) 116.44,204.47 114.97,205.93 arc(114.85,206.01) 114.71,206.04 99.21,206.04 arc(98.94,206.1) 98.72,206.25 96.14,208.82 arc(95.99,209.05) 95.94,209.31 95.94,211.24 arc(95.91,211.38) 95.83,211.5 95.49,211.84 arc(95.37,211.92) 95.23,211.95 94.75,211.95 arc(94.4,211.88) 94.1,211.68 93.65,211.23 arc(93.64,211.22) 93.62,211.2 93.55,211.11 arc(93.53,211.09) 93.5,211.06 93.38,210.93 93.31,210.89 93.2,210.79 93.14,210.72 93.09,210.67 93.02,210.55 93,210.51 arc(93,210.49) 92.99,210.48 92.9,210.22 arc(92.87,210.13) 92.86,210.04 YJ3.D4_2
MAC_PCIE_TXP3: length 135.1
  TOP w0.107: C2082.2 196.03,180.69 arc(195.91,180.86) 195.87,181.07 195.87,181.16 arc(195.83,181.36) 195.72,181.54 191.36,185.89 arc(191.24,186.06) 191.2,186.27 191.2,197.25 arc(190.91,198.75) 190.06,200.02 189.03,201.05 arc(188.2,201.61) 187.22,201.8 164.93,201.8 arc(164.6,201.73) 164.32,201.55 160.87,198.1 arc(160.69,197.98) 160.49,197.94 126.83,197.94 arc(126.75,197.96) 126.68,198 120.52,204.16 arc(120.48,204.23) 120.46,204.31 120.46,206.54 arc(120.49,206.71) 120.59,206.86 v1(120.74,207.01)
  SIG4 w0.14: v1(120.74,207.01) 120.59,206.86 arc(120.49,206.71) 120.46,206.54 120.46,206.42 arc(120.27,205.97) 119.82,205.79 117.53,205.79 arc(117.26,205.84) 117.03,205.99 115.56,207.46 arc(115.44,207.54) 115.3,207.57 101.53,207.57 arc(101.26,207.62) 101.04,207.77 100.34,208.46 arc(100.19,208.69) 100.14,208.96 100.14,211.78 arc(100.11,211.92) 100.03,212.04 96.44,215.64 arc(96.32,215.72) 96.17,215.75 94.75,215.75 arc(94.4,215.68) 94.1,215.48 93.65,215.03 arc(93.64,215.02) 93.62,215 93.55,214.91 arc(93.53,214.89) 93.5,214.86 93.38,214.73 93.31,214.69 93.2,214.58 93.09,214.47 93.04,214.38 93,214.31 arc(93,214.29) 92.99,214.28 92.9,214.02 arc(92.87,213.93) 92.86,213.84 YJ3.C4_2
MAC_VDD_SENSE: length 247.2
  TOP w0.254: R2195.1 378.36,177.2 378.36,177.45 376.62,179.19 368,179.19 v1(367.73,178.93)
  TOP w0.279: U1.AR34 v1(196.55,141.34)
  SIG4 w0.254: v1(367.73,178.93) 368,179.19 368.52,179.19 369,179.67 369,181.61 366.08,184.53 366.08,189.13 360.52,194.69 327.09,194.69 322.14,189.74 265.75,189.74 262.7,192.78 237.88,192.78 232.4,187.31 211.25,187.31 210.88,186.94 202.09,186.94 198.84,183.69 198.84,176.18 v1(198.69,176.03)
  BOTTOM w0.254: v1(196.55,141.34) 197.57,142.37 197.57,161.84 197.07,162.35 197.07,165.33 196.66,165.73 196.66,169.42 196.15,169.92 196.15,174.15 196.58,174.58 v2(196.58,175.23) 197.24,175.23 197.77,175.77 198.43,175.77 v1(198.69,176.03)
MAIN_PWR_EN: length 482.9
  TOP w0.13: U123.P15 30.45,154.2 31.03,154.2 31.43,153.79 34.48,153.79 34.99,154.3 v1(37.4,154.3)
  SIG4 w0.155: v1(37.4,154.3) 38.04,154.94 39.69,154.94 42.61,157.86 42.61,166.62 39.56,169.67 35.37,169.67 33.97,171.07 33.97,172.97 37.78,176.78 42.48,176.78 48.37,182.67 50.75,182.67 52.72,184.63 52.72,187.02 55.25,189.54 56.1,189.54 58.21,191.65 58.21,192.42 62.54,196.75 63.94,196.75 66.23,199.03 71.34,199.03 72.96,200.66 93.79,200.66 94.75,199.69 124.39,199.69 129,204.31 149.13,204.31 153.23,208.4 155.64,208.4 156.27,209.04 156.27,211.2 165.11,220.04 261.73,220.04 263.33,218.44 263.84,218.44 265.44,220.04 345.5,220.04 377.76,187.77 377.76,183.64 381.7,179.7 381.7,152.78 373.57,144.65 373.57,134.36 v1(370.4,131.19)
  BOTTOM w0.13: v1(370.4,131.19) 370.55,131.04 R3563.1 v2(369.25,130.17)
MASTER_CPLD_CLK_N: length 302.8
  TOP w0.107: v1(24.05,164.6) U123.A8
  SIG8 w0.14: v1(285.81,212.39) 285.52,212.1 283.41,212.1 278.57,207.26 219.65,207.26 213.17,213.74 162.92,213.74 152.89,203.71 71.06,203.71 70.42,203.07 54.42,203.07 31.05,179.7 31.05,175.6 29.96,174.51 29.96,172.22 26.53,168.79 26.53,166.35 26.73,166.14 26.73,165.35 26.23,164.84 24.96,164.84 24.48,164.37 24.29,164.37 v1(24.05,164.6)
  BOTTOM w0.107: C3450.2 287.06,212.21 286.95,212.1 286.11,212.1 v1(285.81,212.39) ; R3319.2 23.08,169.69 23.28,169.49 23.28,168.96 24.04,168.2 24.04,166.05 24.5,165.6 24.5,164.34 24.35,164.18 24.19,164.18 24.05,164.32 v1(24.05,164.6)
MASTER_CPLD_CLK_P: length 302.8
  TOP w0.107: U123.C8 v1(24.05,163.8)
  SIG8 w0.14: v1(24.05,163.8) 24.29,164.04 24.62,164.04 25.09,164.51 26.36,164.51 27.06,165.21 27.06,166.28 26.86,166.48 26.86,168.65 30.29,172.08 30.29,174.37 31.38,175.46 31.38,179.57 54.56,202.74 70.56,202.74 71.19,203.38 153.02,203.38 163.06,213.41 213.03,213.41 219.51,206.93 278.71,206.93 283.55,211.77 285.52,211.77 v1(285.81,211.48)
  BOTTOM w0.107: C3455.2 287.06,211.66 286.95,211.77 286.11,211.77 v1(285.81,211.48) ; v1(24.05,163.8) 24.11,163.85 24.48,163.85 24.83,164.2 24.83,165.73 24.37,166.19 24.37,168.34 23.61,169.1 23.61,169.36 R3318.1
MASTER_CPLD_JTAG_TCK: length 34.5
  TOP w0.13: v1(25.08,172.72) 24.07,172.72 23.43,172.08 23.43,169.92 23.2,169.69 R3310.2 22.67,169.16 23.56,168.27 23.56,165.1 U123.A7
  SIG6 w0.155: v1(25.08,172.72) 24.7,173.1 24.7,176.53 28.53,180.36 28.53,185.23 28,185.76 28,188.72 27.37,189.35 v1(27.37,193.29)
  BOTTOM w0.13: R3210.2 v1(27.37,193.29) v2(27.93,193.85)
MASTER_CPLD_JTAG_TDI: length 57.4
  TOP w0.13: U123.A6 22.8,165.06 22.8,165.48 21.5,166.78 21.5,168.38 21.15,168.73 21.15,173.99 19.24,175.89 19.11,175.89 17.08,177.92 17.08,178.56 v1(16.57,179.07)
  SIG3 w0.155: v1(14.92,193.16) 16.83,191.26 27.5,191.26 30.29,188.47 30.29,186.05 v1(29.65,185.42)
  SIG6 w0.155: v1(16.57,179.07) 15.43,180.21 15.43,185.54 14.8,186.18 14.8,193.04 v1(14.92,193.16)
  BOTTOM w0.13: R3224.1 R3226.2 ; R3226.2 v1(29.65,185.42) ; R3226.2 v2(30.57,184.15) ; R3200.2 v1(16.57,179.07) ; v1(14.92,193.16) 15.3,192.78 R3194.2
MASTER_CPLD_JTAG_TDO: length 420.9
  TOP w0.13: R3384.2 v1(399.61,189.61) 398.97,188.97 398.97,188.32 399.99,187.3 399.99,186.88 U124.A6
  SIG8 w0.155: v1(399.61,189.61) 397.95,189.61 397.07,190.5 381.49,190.5 379.76,192.23 369.12,192.23 361.2,200.14 334.72,200.14 316.99,217.87 273.81,217.87 272.28,219.39 122.44,219.39 118.3,215.25 118.3,212.98 110.81,205.48 68.48,205.48 67.53,204.53 54.23,204.53 38.54,188.85 37.39,188.85 25.45,176.91 23.56,176.91 v1(20.51,173.86)
  BOTTOM w0.13: v1(20.51,173.86) 20.51,173.84 v2(19.98,173.3) 19.98,170.81 20.13,170.66 R3289.1
MASTER_CPLD_JTAG_TMS: length 36.5
  TOP w0.13: U123.B8 24.85,164.6 24.85,165.71 24.19,166.37 24.19,168.15 24.45,168.4 R3314.2 24.73,169.69 24.96,169.92 24.96,171.07 24.83,171.19 24.83,171.83 25.08,172.08 25.59,172.08 v1(26.23,172.72)
  SIG6 w0.155: v1(26.23,172.72) 25.72,172.21 24.32,172.21 23.94,172.59 23.94,176.4 23.18,177.16 23.18,179.45 23.94,180.21 23.94,186.05 24.57,186.69 24.57,191.98 25.08,192.49 v1(25.08,193.29)
  BOTTOM w0.13: R3212.2 v1(25.08,193.29) v2(25.08,194.05)
MC_PVDD0P8: length 5.8
  TOP w0.279: U1.BF36 v1(194.55,152.34)
  TOP w0.381: 169.9,184.55 C3055.1 ; C3055.1 170.5,183.92 ; C3055.1 171.1,184.55 ; 168.21,183.92 L439.1 ; L439.1 168.81,184.55 ; L439.1 167.61,184.55
  BOTTOM w0.381: C2899.1 195.02,152.82 v1(194.55,152.34) ; v1(172.53,183.31) v2(173.29,183.31)
  vias: v1(171.64,183.31)
MC_RDN0: length 129
  TOP w0.107: C3421.1 192.87,180.71 arc(192.92,180.79) 192.94,180.89 192.94,180.93 arc(192.92,181) 192.88,181.07 192.31,181.64 190.53,183.42 188.87,185.08 arc(188.36,185.85) 188.18,186.75 188.18,188.08 arc(188.15,188.24) 188.05,188.38 v1(187.93,188.5)
  SIG7 w0.14: YJ3.B8_2 89.72,218.12 arc(89.71,218.08) 89.7,218.04 89.69,217.89 arc(89.66,217.73) 89.59,217.57 arc(89.56,217.52) 89.51,217.48 89.42,217.38 88.91,216.95 88.41,216.45 88.16,216.2 arc(88.01,215.97) 87.96,215.7 87.96,209.49 arc(88.01,209.22) 88.16,208.99 89.14,208.01 arc(89.5,207.78) 89.91,207.69 94.24,207.69 arc(94.4,207.66) 94.54,207.57 98.41,203.7 arc(98.64,203.54) 98.91,203.49 105.45,203.49 arc(105.59,203.46) 105.71,203.38 113.39,195.71 arc(113.61,195.55) 113.88,195.5 155.03,195.5 arc(155.18,195.47) 155.29,195.39 159.22,191.46 arc(159.45,191.31) 159.72,191.26 181.79,191.26 arc(182.24,191.17) 182.62,190.92 183.47,190.07 arc(183.9,189.78) 184.41,189.68 187.44,189.68 arc(187.65,189.63) 187.84,189.51 arc(188,189.27) 188.05,188.99 188.05,188.74 arc(188.05,188.72) 188.05,188.7 arc(188.05,188.7) 188.04,188.69 arc(188,188.59) v1(187.93,188.5)
MC_RDN2: length 131.6
  SIG7 w0.14: v1(200.81,177.8) 200.81,177.47 arc(200.77,177.37) 200.67,177.33 199.91,177.33 arc(199.82,177.37) 199.77,177.47 199.77,180.18 arc(199.71,180.5) 199.53,180.77 199.43,180.87 193.67,186.63 arc(193.59,186.75) 193.56,186.89 193.56,190.24 arc(193.51,190.51) 193.36,190.73 188.74,195.36 arc(188.51,195.51) 188.24,195.56 183.99,195.56 arc(183.84,195.59) 183.72,195.67 182.79,196.6 arc(182.57,196.75) 182.3,196.8 161.32,196.8 arc(161.18,196.83) 161.06,196.91 158.72,199.26 arc(158.49,199.41) 158.22,199.46 115.2,199.46 arc(115.06,199.49) 114.94,199.57 111.37,203.14 107.71,206.8 arc(107.48,206.95) 107.22,207.01 102.32,207.01 arc(102.18,207.04) 102.06,207.12 100.27,208.91 arc(100.19,209.03) 100.16,209.17 100.16,215.05 arc(100.29,215.68) 100.64,216.21 101.13,216.7 101.64,217.14 102.17,217.66 arc(102.27,217.73) 102.39,217.76 102.43,217.76 arc(102.49,217.74) 102.55,217.71 102.58,217.68 arc(102.68,217.44) YJ3.B7_1
  BOTTOM w0.107: C3423.1 199.71,176.94 arc(199.75,177.15) 199.86,177.32 199.9,177.36 arc(200.06,177.47) 200.25,177.5 200.31,177.5 arc(200.5,177.54) 200.65,177.64 v1(200.81,177.8)
MC_RDP0: length 129
  TOP w0.107: v1(188.84,188.5) 188.83,188.49 arc(188.59,188.13) 188.51,187.72 188.51,186.75 arc(188.66,185.97) 189.1,185.31 189.29,185.12 190.76,183.65 192.54,181.88 193.11,181.3 arc(193.23,181.13) 193.27,180.93 193.27,180.92 arc(193.29,180.79) 193.36,180.69 C3422.1
  SIG7 w0.14: v1(188.84,188.5) 188.78,188.44 arc(188.53,188.39) 188.38,188.6 188.38,188.99 arc(188.3,189.4) 188.07,189.74 arc(187.78,189.94) 187.44,190.01 184.41,190.01 arc(184.03,190.08) 183.7,190.3 182.86,191.15 arc(182.37,191.48) 181.79,191.59 159.72,191.59 arc(159.58,191.62) 159.46,191.7 155.53,195.63 arc(155.3,195.78) 155.03,195.83 113.88,195.83 arc(113.74,195.86) 113.62,195.94 105.94,203.62 arc(105.72,203.77) 105.45,203.82 98.91,203.82 arc(98.77,203.85) 98.65,203.93 94.78,207.8 arc(94.53,207.97) 94.24,208.02 89.91,208.02 arc(89.62,208.08) 89.38,208.25 88.4,209.23 arc(88.32,209.35) 88.29,209.49 88.29,215.7 arc(88.32,215.84) 88.4,215.96 89.13,216.7 89.64,217.14 89.74,217.24 arc(90.14,217.4) 90.54,217.24 YJ3.B7_2
MC_RDP2: length 131.6
  SIG7 w0.14: YJ3.B8_1 101.71,218.08 101.69,217.89 arc(101.66,217.73) 101.59,217.57 arc(101.56,217.52) 101.51,217.48 101.42,217.38 100.91,216.95 100.41,216.44 arc(99.98,215.8) 99.83,215.05 99.83,209.17 arc(99.89,208.9) 100.04,208.68 101.83,206.88 arc(102.06,206.73) 102.32,206.68 107.22,206.68 arc(107.36,206.65) 107.48,206.57 114.71,199.34 arc(114.93,199.19) 115.2,199.13 158.22,199.13 arc(158.36,199.11) 158.48,199.03 160.83,196.68 arc(161.06,196.53) 161.32,196.47 182.3,196.47 arc(182.44,196.45) 182.56,196.37 183.49,195.43 arc(183.72,195.28) 183.99,195.23 188.24,195.23 arc(188.38,195.2) 188.5,195.12 193.13,190.5 arc(193.21,190.38) 193.23,190.24 193.23,186.89 arc(193.29,186.62) 193.44,186.39 199.2,180.63 199.2,180.63 199.3,180.54 arc(199.41,180.37) 199.44,180.18 199.44,177.47 arc(199.58,177.14) 199.91,177 200.53,177 arc(200.68,176.97) v1(200.81,176.88)
  BOTTOM w0.107: v1(200.81,176.88) 200.81,176.94 arc(200.74,177.11) 200.58,177.17 200.25,177.17 arc(200.19,177.16) 200.14,177.13 200.1,177.09 arc(200.05,177.02) 200.04,176.94 200.04,176.04 arc(200.08,175.83) 200.19,175.66 200.55,175.31 arc(200.63,175.25) 200.73,175.23 C3424.1
MC_TDN0: length 145.6
  TOP w0.107: U1.CF33 198.05,171.84 v1(197.55,172.34)
  SIG9 w0.14: v1(197.55,172.34) 197.55,172.18 arc(197.54,172.12) 197.5,172.07 197.48,172.05 arc(197.43,172.02) 197.38,172.01 197.13,172.01 arc(196.99,172.06) 196.94,172.2 196.94,173.44 arc(196.97,173.62) 197.08,173.77 arc(197.18,173.92) 197.21,174.1 197.21,186.6 arc(197.14,186.99) 196.91,187.32 188.96,195.28 arc(188.63,195.5) 188.23,195.58 158.86,195.58 arc(158.47,195.5) 158.13,195.28 156.1,193.24 arc(155.87,193.09) 155.6,193.04 125.74,193.04 arc(125.48,192.98) 125.25,192.83 120.74,188.32 arc(120.62,188.24) 120.47,188.21 114.63,188.21 arc(114.45,188.25) 114.29,188.35 v1(114.14,188.51)
  BOTTOM w0.107: v1(114.14,188.51) 114.14,188.27 arc(114.06,188.1) 113.89,188.02 113.49,188.02 arc(113.41,188.04) 113.35,188.08 112.85,188.58 arc(112.8,188.65) 112.79,188.73 112.79,192.74 arc(112.75,192.94) 112.63,193.12 97.76,207.99 arc(97.58,208.11) 97.38,208.15 89.47,208.15 arc(89.39,208.17) 89.32,208.21 89.09,208.44 arc(89.04,208.51) 89.03,208.59 89.03,208.86 arc(89.04,208.94) 89.09,209.01 90.08,210 arc(90.22,210.1) 90.38,210.14 arc(90.69,209.95) YJ3.D7_2
MC_TDN2: length 140.5
  TOP w0.107: U1.CB33 v1(197.55,167.34)
  SIG9 w0.102: v1(197.55,167.34) 197.55,167.45 arc(197.44,167.72) 197.18,167.82 196.58,167.82 arc(196.14,168.01) 195.95,168.45 195.95,173.01 195.89,173.07 195.89,173.1
  SIG9 w0.14: v1(114.14,183.98) 114.29,184.13 arc(114.45,184.24) 114.63,184.27 120.3,184.27 arc(120.56,184.33) 120.79,184.48 125.94,189.63 arc(126.06,189.71) 126.2,189.74 138.08,189.74 arc(138.34,189.79) 138.57,189.94 139.78,191.15 arc(139.9,191.23) 140.04,191.26 188.17,191.26 arc(188.31,191.23) 188.43,191.15 195.36,184.22 arc(195.51,183.99) 195.57,183.72 195.57,174.27 arc(195.61,174.06) 195.73,173.88 195.82,173.79 arc(195.87,173.72) 195.89,173.63 195.89,173.1
  BOTTOM w0.107: v1(114.14,183.98) 114.26,184.1 arc(114.39,184.19) 114.54,184.22 114.94,184.22 arc(115.14,184.26) 115.31,184.37 116.06,185.12 arc(116.18,185.3) 116.22,185.5 116.22,192.87 arc(116.18,193.07) 116.06,193.24 101.09,208.22 arc(101.04,208.28) 101.03,208.36 101.03,208.86 arc(101.04,208.94) 101.09,209.01 101.91,209.83 arc(102.13,209.92) 102.35,209.83 YJ3.D7_1
MC_TDP0: length 145.6
  TOP w0.107: U1.CF34 197.05,171.84 v1(197.55,171.34)
  SIG9 w0.14: v1(197.55,171.34) 197.55,171.5 arc(197.5,171.62) 197.37,171.68 197.13,171.68 arc(196.76,171.83) 196.61,172.2 196.61,173.44 arc(196.67,173.74) 196.84,174 arc(196.87,174.05) 196.88,174.1 196.88,186.6 arc(196.83,186.86) 196.68,187.09 188.73,195.04 arc(188.5,195.19) 188.23,195.25 158.86,195.25 arc(158.59,195.19) 158.36,195.04 156.33,193.01 arc(156,192.79) 155.6,192.71 125.74,192.71 arc(125.6,192.68) 125.48,192.6 120.97,188.09 arc(120.74,187.93) 120.47,187.88 114.63,187.88 arc(114.45,187.84) 114.29,187.74 v1(114.14,187.58)
  BOTTOM w0.107: YJ3.D8_2 89.67,210.18 arc(89.65,210.11) 89.62,210.05 89.6,210 arc(89.58,209.97) 89.56,209.95 arc(89.53,209.91) 89.5,209.88 88.86,209.24 arc(88.74,209.07) 88.7,208.86 88.7,208.59 arc(88.74,208.38) 88.86,208.21 89.09,207.98 arc(89.26,207.86) 89.47,207.82 97.38,207.82 arc(97.46,207.8) 97.52,207.76 112.4,192.88 arc(112.44,192.82) 112.46,192.74 112.46,188.73 arc(112.5,188.52) 112.62,188.35 113.11,187.85 arc(113.29,187.73) 113.49,187.69 113.95,187.69 arc(114.02,187.68) 114.07,187.65 v1(114.14,187.58)
MC_TDP2: length 140.5
  TOP w0.107: U1.CB34 v1(197.55,168.34)
  SIG9 w0.102: v1(197.55,168.34) 197.38,168.17 arc(197.21,168.06) 197.01,168.02 196.58,168.02 arc(196.28,168.15) 196.15,168.45 196.15,173.01 196.22,173.07 196.22,173.1
  SIG9 w0.14: v1(114.14,184.9) 114.29,184.74 arc(114.45,184.64) 114.63,184.6 120.3,184.6 arc(120.44,184.63) 120.56,184.71 125.71,189.86 arc(125.93,190.01) 126.2,190.07 138.08,190.07 arc(138.22,190.09) 138.34,190.17 139.55,191.38 arc(139.78,191.54) 140.04,191.59 188.17,191.59 arc(188.43,191.54) 188.66,191.39 190.01,190.04 195.6,184.45 arc(195.82,184.12) 195.9,183.72 195.9,174.27 arc(195.91,174.19) 195.96,174.12 196.06,174.02 arc(196.18,173.84) 196.22,173.63 196.22,173.1
  BOTTOM w0.107: YJ3.D8_1 101.67,210.18 arc(101.65,210.11) 101.62,210.05 101.6,210 arc(101.58,209.97) 101.56,209.95 arc(101.53,209.91) 101.5,209.88 100.86,209.24 arc(100.74,209.07) 100.7,208.86 100.7,208.36 arc(100.74,208.16) 100.86,207.98 115.83,193.01 arc(115.87,192.94) 115.89,192.87 115.89,185.5 arc(115.87,185.42) 115.83,185.36 115.08,184.61 arc(115.01,184.56) 114.94,184.55 114.42,184.55 arc(114.22,184.63) 114.14,184.83 v1(114.14,184.9)
MC_TRVDD0P8: length 7.6
  TOP w0.229: v1(197.55,170.34) U1.CE34 ; U1.BR33 v1(198.55,161.34) ; U1.BT33 v1(198.55,162.34) ; v1(198.55,170.34) U1.CE33
  TOP w0.381: 188.11,193.14 C2763.1 187.52,193.77
  BOTTOM w0.381: C2762.1 198.02,170.81 v1(197.55,170.34) ; v1(188.53,193.67) v2(189.29,193.67) ; C2728.1 199.02,161.87 v1(198.55,162.34) ; v1(198.55,170.34) 199.02,170.81 C247.1 ; C3185.1 199.04,160.85 v1(198.55,161.34)
  vias: v1(188.53,192.66)
MDC0: length 1.4
  TOP w0.13: U1.BK20 v1(211.55,156.34)
  BOTTOM w0.13: R2059.1 212.02,156.82 v1(211.55,156.34)
MDC1: length 1.4
  TOP w0.13: U1.BM23 v1(208.55,158.34)
  BOTTOM w0.13: v1(208.55,158.34) 208.52,158.34 R2060.1
MDC2: length 1.4
  TOP w0.13: U1.BM43 v1(187.55,158.34)
  BOTTOM w0.13: R2061.1 187.05,157.85 v1(187.55,158.34)
MDC3: length 1.4
  TOP w0.13: U1.BL44 v1(186.55,157.34)
  BOTTOM w0.13: R2062.1 187.05,156.84 v1(186.55,157.34)
MDC4: length 1.4
  TOP w0.13: U1.BK17 v1(214.55,156.34)
  BOTTOM w0.13: v1(214.55,156.34) 214.07,156.82 R2063.1
MDC5: length 1.4
  TOP w0.13: U1.BK21 v1(210.55,156.34)
  BOTTOM w0.13: R2064.1 211.02,156.82 v1(210.55,156.34)
MDC6: length 1.4
  TOP w0.13: U1.BM44 v1(186.55,158.34)
  BOTTOM w0.13: v1(186.55,158.34) 186.05,157.85 R2065.1
MDC7: length 1.4
  TOP w0.13: U1.BM49 v1(181.55,158.34)
  BOTTOM w0.13: v1(181.55,158.34) 182.02,158.81 R2066.1
MDC8: length 1.4
  TOP w0.13: U1.BM20 v1(211.55,158.34)
  BOTTOM w0.13: R2067.1 212.03,157.86 v1(211.55,158.34)
MDC9: length 1.4
  TOP w0.13: U1.BK22 v1(209.55,156.34)
  BOTTOM w0.13: v1(209.55,156.34) 210.02,156.82 R2068.1
MDC10: length 1.4
  TOP w0.13: U1.BL23 v1(208.55,157.34)
  BOTTOM w0.13: R2069.1 209.05,156.84 v1(208.55,157.34)
MDC11: length 1.4
  TOP w0.13: U1.BK23 v1(208.55,156.34)
  BOTTOM w0.13: R2070.1 208.07,156.82 v1(208.55,156.34)
MDI_A+: length 19.3
  TOP w0.254: v1(412.64,32.26) 412.43,32.46 412.43,32.91 412.81,33.29 T1.23
  SIG4 w0.305: v1(412.64,32.26) 412.43,32.05 412.43,28.18 412.74,27.88 413.63,27.88 413.93,27.57 413.93,26.96 413.63,26.66 412.74,26.66 412.13,26.05 412.13,22.12 413.68,20.56 413.68,19.99 RJ1.B1
MDI_A-: length 19.2
  TOP w0.254: T1.22 411.54,33.29 411.92,32.91 411.92,32.46 v1(411.72,32.26)
  SIG4 w0.305: RJ1.B2 413.17,20.35 411.62,21.91 411.62,26.26 411.92,26.56 411.92,32.05 v1(411.72,32.26)
MDI_B+: length 20
  TOP w0.254: v1(408.83,32.26) 408.62,32.46 408.62,32.91 409,33.29 T1.20
  SIG2 w0.305: RJ1.B3 412.38,19.23 412.63,19.48 412.63,20.28 412.38,20.53 410.17,20.53 409.82,20.89 409.82,22.52 410.5,23.21 410.5,29.1 408.62,30.99 408.62,32.05 v1(408.83,32.26)
MDI_B-: length 20
  TOP w0.254: v1(407.91,32.26) 408.11,32.46 408.11,32.91 407.73,33.29 T1.19
  SIG2 w0.305: v1(407.91,32.26) 408.11,32.05 408.11,30.77 410,28.89 410,23.42 409.31,22.73 409.31,20.88 408.09,19.66 RJ1.B6
MDI_C+: length 20.8
  TOP w0.254: v1(405.02,32.26) 404.81,32.46 404.81,32.91 405.19,33.29 T1.17
  SIG4 w0.305: v1(405.02,32.26) 404.81,32.05 404.81,30.96 409.22,26.55 409.22,24.09 410.63,22.68 RJ1.B4
MDI_C-: length 20.8
  TOP w0.254: v1(404.1,32.26) 404.3,32.46 404.3,32.91 403.92,33.29 T1.16
  SIG4 w0.305: v1(404.1,32.26) 404.3,32.05 404.3,30.75 408.71,26.34 408.71,23.88 410.13,22.47 410.13,21.56 409.87,21.31 409.13,21.31 408.87,21.05 408.87,20.63 409.13,20.38 409.87,20.38 410.13,20.12 410.13,19.46 409.9,19.23 RJ1.B5
MDI_D+: length 23.3
  TOP w0.254: T1.14 401.38,33.29 401,32.91 401,32.46 v1(401.21,32.26)
  SIG2 w0.305: v1(401.21,32.26) 401,32.05 401,31.69 408.36,24.34 408.36,22.05 406.77,20.46 406,20.46 405.57,20.04 405.57,18.59 405.88,18.28 406.39,18.28 406.82,18.72 RJ1.B7
MDI_D-: length 23.3
  TOP w0.254: v1(400.29,32.26) 400.49,32.46 400.49,32.91 400.11,33.29 T1.13
  SIG2 w0.305: v1(400.29,32.26) 400.49,32.05 400.49,31.48 407.85,24.13 407.85,22.26 406.56,20.97 405.79,20.97 405.07,20.25 405.07,18.38 405.55,17.89 RJ1.B8
MDIO0: length 1.4
  TOP w0.13: U1.BK47 v1(183.55,156.34)
  BOTTOM w0.13: R2047.1 183.08,156.81 v1(183.55,156.34)
MDIO1: length 1.4
  TOP w0.13: U1.BL42 v1(188.55,157.34)
  BOTTOM w0.13: v1(188.55,157.34) 189.05,157.84 R2048.1
MDIO2: length 1.4
  TOP w0.13: U1.BK43 v1(187.55,156.34)
  BOTTOM w0.13: v1(187.55,156.34) 188.02,156.81 R2049.1
MDIO3: length 1.4
  TOP w0.13: U1.BL50 v1(180.55,157.34)
  BOTTOM w0.13: R2050.1 181.05,156.84 v1(180.55,157.34)
MDIO4: length 1.4
  TOP w0.13: U1.BL48 v1(182.55,157.34)
  BOTTOM w0.13: R2051.1 182.05,156.84 v1(182.55,157.34)
MDIO5: length 1.4
  TOP w0.13: U1.BM50 v1(180.55,158.34)
  BOTTOM w0.13: R2052.1 180.06,157.85 v1(180.55,158.34)
MDIO6: length 1.4
  TOP w0.13: U1.BL46 v1(184.55,157.34)
  BOTTOM w0.13: R2053.1 184.05,156.84 v1(184.55,157.34)
MDIO7: length 1.4
  TOP w0.13: U1.BK44 v1(186.55,156.34)
  BOTTOM w0.13: v1(186.55,156.34) 186.05,155.85 R2054.1
MDIO8: length 1.4
  TOP w0.13: U1.BM21 v1(210.55,158.34)
  BOTTOM w0.13: R2055.1 211.03,157.86 v1(210.55,158.34)
MDIO9: length 1.4
  TOP w0.13: U1.BM48 v1(182.55,158.34)
  BOTTOM w0.13: R2056.1 v1(182.55,158.34)
MDIO10: length 1.4
  TOP w0.13: U1.BM42 v1(188.55,158.34)
  BOTTOM w0.13: R2057.1 188.05,157.85 v1(188.55,158.34)
MDIO11: length 1.4
  TOP w0.13: U1.BL19 v1(212.55,157.34)
  BOTTOM w0.13: v1(212.55,157.34) 213.07,156.82 R2058.1
MGMT_LED_GREEN: length 257.9
  TOP w0.13: J35.24 v1(385.3,220.22)
  SIG1 w0.155: v1(400.52,62.23) 400.49,62.2 400.49,59.56 396.64,55.7 396.64,26.97 399.35,24.25 404.59,24.25 RJ1.10
  SIG7 w0.155: v1(400.52,62.23) 400.49,62.23 403.7,59.02 410.31,59.02 411.39,60.11 411.39,61.59 413.07,63.27 413.07,72.48 419.55,78.96 419.55,97.25 420.69,98.39 420.69,129.16 426.02,134.49 426.02,144.9 420.44,150.48 420.44,205.18 408.15,217.47 388.05,217.47 v1(385.3,220.22)
  BOTTOM w0.13: v1(385.3,220.22) v2(384.49,220.22)
MGMT_LED_LINKACT: length 293.2
  TOP w0.13: J35.26 v1(383.3,220.21)
  SIG3 w0.155: RJ1.12 418.73,23.16 420.81,21.08 420.81,15.91 419.51,14.6 400.15,14.6 398.84,15.91 398.84,24.76 396.67,26.93 396.67,33.04 395.09,34.63 395.09,47.39 400.11,52.41 400.11,59.56 401.64,61.08 v1(401.64,62.1)
  SIG7 w0.155: v1(401.64,62.1) 404.33,59.41 410,59.41 410.77,60.18 410.77,61.74 412.56,63.53 412.56,72.51 419.16,79.12 419.16,97.41 420.3,98.55 420.3,129.41 425.51,134.62 425.51,144.53 420.05,149.99 420.05,205.02 408.11,216.96 386.55,216.96 v1(383.3,220.21)
  BOTTOM w0.13: v1(383.3,220.21) v2(383.3,221.05)
MHOST0_BOOT_DEV: length 45.7
  TOP w0.13: v1(226.25,100.2) R19.2 R21.2 ; U1.T31 v1(200.55,121.34)
  SIG7 w0.155: v1(200.55,121.34) 200.99,120.9 210.88,120.9 212.03,119.76 212.03,114.09 212.28,113.84 214.77,113.84 215.07,113.54 215.07,113.15 215.33,112.9 216.85,112.9 217.06,112.7 217.06,112.06 217.23,111.88 217.74,111.88 218.12,111.5 218.12,110.11 218.38,109.85 219.9,109.85 220.05,109.7 220.05,106.02 220.79,105.28 221.86,105.28 224.23,102.91 224.23,100.82 224.85,100.2 v1(226.25,100.2)
  BOTTOM w0.13: v1(226.25,100.2) v2(225.49,100.2)
MHOST1_BOOT_DEV: length 47
  TOP w0.13: v1(226.25,98.17) R20.2 R18.2 ; U1.R32 v1(199.55,120.34)
  SIG7 w0.155: v1(199.55,120.34) 200.01,119.89 210.76,119.89 211.01,119.63 211.01,113.28 211.42,112.88 214.59,112.88 214.95,112.52 214.95,112.19 215.33,111.81 215.79,111.81 216.09,111.5 216.09,111.12 216.34,110.87 216.73,110.87 216.98,110.61 216.98,109.22 217.36,108.84 218.76,108.84 219.01,108.58 219.01,106.04 220.16,104.9 221.7,104.9 223.85,102.75 223.85,100.19 225.11,98.93 225.49,98.93 v1(226.25,98.17)
  BOTTOM w0.13: v1(226.25,98.17) v2(225.49,98.17)
MISC_PLL_AVDD1P8: length 5.4
  TOP w0.229: U1.AN52 v1(178.55,138.34)
  TOP w0.381: C75.1 151.98,133.83 ; C75.1 152.59,134.62 ; C75.1 153.33,133.83
  TOP w0.762: L441.1 151.83,135.63
  BOTTOM w0.381: v1(178.55,138.34) 178.55,138.12 C76.1 ; v1(153.73,135) v2(153.73,135.76)
  vias: v1(152.84,135)
MODPRSL0: length 100.7
  TOP w0.13: v1(16.09,161.16) 16.45,161.16 16.89,160.71 17.58,160.71 18.1,160.2 U123.G1 ; v1(16.07,89.15) 16.47,88.75 R2589.2
  SIG4 w0.155: v1(16.07,89.15) 15.56,89.66 15.56,90.17 14.67,91.05 14.67,98.81 17.34,101.47 19.62,101.47 20.64,102.48 20.64,121.89 13.88,128.64 11.35,128.64 9.15,130.84 9.15,131.17 6.83,133.49 6.83,161.48 9.06,163.7 12.89,163.7 14.78,161.81 15.44,161.81 v1(16.09,161.16)
  BOTTOM w0.13: v1(16.07,89.15) 15.68,89.15 v2(15.3,89.53)
MODPRSL1: length 109.6
  TOP w0.13: R2591.1 v1(16.19,79.5) ; v1(17.11,163.07) 17.52,163.07 18.39,162.2 19.25,162.2 U123.E2
  SIG4 w0.155: v1(17.11,163.07) 17.11,163.17 16.7,163.57 15.68,163.57 13.91,165.35 7.41,165.35 5.52,163.46 5.52,125.5 4.07,124.05 4.07,102.93 6.67,100.33 10.25,100.33 12.58,98 12.58,88.24 13.04,87.77 13.04,85.16 13.91,84.29 13.91,80.52 15.05,79.37 16.07,79.37 v1(16.19,79.5)
MODPRSL2: length 117.3
  TOP w0.13: v1(40.7,89.28) 43.24,89.28 46.42,86.1 R2585.2 ; v1(15.05,157.22) 15.54,157.71 17.88,157.71 18.19,157.4 19.25,157.4 U123.K2
  SIG10 w0.155: v1(15.05,157.22) 13.27,159 8.95,159 5.86,155.91 5.86,134.12 10,129.97 11.19,129.97 11.6,130.38 19.33,130.38 21.45,128.27 21.45,126.55 21.02,126.12 21.02,102.26 22.21,101.08 22.21,99.37 28.82,92.75 32.95,92.75 33.47,92.75 33.69,92.96 35.27,92.96 35.28,92.96 35.7,92.96 36.86,91.8 38.18,91.8 v1(40.7,89.28)
  BOTTOM w0.13: v1(40.7,89.28) v2(40.7,90.04)
MODPRSL3: length 98.9
  TOP w0.13: U123.M1 17.57,156.2 17.34,156.44 15.56,156.44 v1(15.08,155.95) ; R2587.1 v1(54.42,91.18)
  SIG10 w0.155: v1(15.08,155.95) 15.08,155.76 14.21,154.89 14.21,147.17 20.24,141.13 20.24,135.79 25.91,130.12 25.91,105.11 31.08,99.94 36.22,99.94 36.93,99.24 39.42,99.24 42.27,96.39 42.73,96.39 43.12,96.79 44.87,96.79 47.84,93.82 49.61,93.82 51.73,91.69 53.91,91.69 v1(54.42,91.18)
  BOTTOM w0.13: v2(55.18,91.18) v1(54.42,91.18)
MODPRSL4: length 114.1
  TOP w0.13: v1(21.3,150.11) 21.81,150.62 21.81,151.37 22.85,152.42 U123.T6 ; R2625.2 73.47,79.63 v1(74.23,80.39)
  SIG10 w0.155: v1(74.23,80.39) 73.77,80.85 73.77,86.34 75.63,88.2 75.63,91.12 73.38,93.38 64.78,93.38 61.71,96.45 59.83,96.45 59.37,96.92 58.31,96.92 56.17,99.06 50.48,99.06 45.42,104.12 43.03,104.12 42.22,104.92 39.59,104.92 39.28,105.23 35.74,105.23 v1(32.29,108.68) 30.02,110.95 30.02,131.7 24.35,137.37 24.35,143.46 23.23,144.59 23.23,146.54 20.76,149 20.76,149.58 v1(21.3,150.11)
MODPRSL5: length 103.2
  TOP w0.13: v1(19.65,150.11) 20.16,150.62 20.16,151.56 21.25,152.66 U123.T4
  SIG10 w0.155: v1(19.65,150.11) 19.08,149.55 19.08,149.13 22.34,145.88 22.34,144.33 23.56,143.1 23.56,137.07 29.26,131.38 29.26,110.12 31.81,107.57 32.32,107.57 36.36,103.53 40.83,103.53 41.39,102.96 45.05,102.96 49.97,98.04 51.43,98.04 52.38,97.09 56.85,97.09 58.9,95.04 62.03,95.04 64.65,92.42 71.21,92.42 v2(73.34,90.29) v1(73.34,89.41)
  BOTTOM w0.13: v2(73.34,90.29) v1(73.34,89.41) 72.68,88.75 R2627.1
MODPRSL6: length 113.5
  TOP w0.13: v1(24.57,149.98) 25.06,150.47 25.06,151.3 25.43,151.67 25.43,152.07 25.65,152.3 25.65,153.4 U123.R9 ; R2636.2 87.29,78.84 87.69,79.25 v1(87.69,79.5)
  SIG10 w0.155: v1(24.57,149.98) 24.35,149.76 24.35,148.69 26.06,146.98 26.06,144.57 28,142.63 28,142.22 28.69,141.54 29.4,141.54 31.37,139.57 31.94,139.57 33.18,138.33 33.18,137.36 34.07,136.47 35.61,136.47 50.53,121.55 50.53,112.98 53.91,109.6 53.91,108.33 58.74,103.5 62.95,103.5 66.25,100.2 67.37,100.2 69.58,97.99 76.74,97.99 84.01,90.72 84.01,88.14 84.77,87.37 86.47,87.37 88.84,85.01 88.84,80.64 v1(87.69,79.5)
MODPRSL7: length 114.7
  TOP w0.13: v1(26.86,149.1) 28.05,150.29 28.05,153.4 U123.R12 ; R2638.1 91.35,77.42 v1(91.58,77.19)
  SIG10 w0.155: v1(91.58,77.19) 93.41,79.02 93.41,82.55 91.57,84.39 91.57,84.8 88.2,88.17 88.2,90.71 86.02,92.9 85.09,92.9 78.17,99.82 71.06,99.82 68.52,102.36 67.12,102.36 62.89,106.59 61.74,106.59 53.02,115.31 53.02,119.07 52.38,119.71 52.38,122.23 37.37,137.24 37.37,138.59 32.7,143.25 31.05,143.25 29.82,144.49 29.82,145.64 29.53,145.93 29.1,145.93 28.69,146.34 28.69,146.86 26.86,148.69 v1(26.86,149.1)
  BOTTOM w0.13: v1(91.58,77.19) 91.3,77.19 v2(90.82,76.71)
MODPRSL8: length 148.2
  TOP w0.13: U123.P11 v1(27.25,154.2) ; v1(124.02,78.48) 123.66,78.84 R2665.2
  SIG10 w0.155: v1(27.25,154.2) 28.68,152.78 29.78,152.78 30.92,151.64 33.31,151.64 33.65,151.3 33.65,150.53 40.92,143.25 v1(41.72,143.25) 41.72,142.45 48.62,135.56 57.37,135.56 59.75,133.17 59.75,127.63 57.98,125.86 57.98,124.33 58.37,123.94 58.37,121.52 60.59,119.3 61.08,119.3 67.9,112.48 77.37,112.48 95.1,94.75 120.07,94.75 124.65,90.17 124.65,88.14 125.16,87.62 125.16,78.99 124.65,78.48 v1(124.02,78.48)
MODPRSL9: length 128.6
  TOP w0.13: U123.P10 v1(26.45,154.2)
  SIG10 w0.155: v1(26.45,154.2) 26.45,153.57 28.13,151.89 29.4,151.89 29.91,151.38 29.91,149.86 30.92,148.84 33.21,148.84 48.83,133.22 48.83,130.09 56.91,122.01 56.91,120.92 60.06,117.78 60.75,117.78 67.64,110.89 77.1,110.89 95.06,92.94 115.91,92.94 118.66,90.19 v1(121.73,90.19)
  BOTTOM w0.13: v1(121.73,90.19) 122.24,89.68 v2(122.24,89.15) R2672.1
MODPRSL10: length 152.4
  TOP w0.13: R2669.2 137.07,78.84 137.83,79.6 v1(137.83,80.39) ; U123.N14 v1(29.65,155)
  SIG10 w0.155: v1(29.65,155) 30.88,155 32.08,153.79 34.24,153.79 35.97,152.06 35.97,150.4 40.58,145.79 v1(40.96,145.79) 41.85,145.79 45.02,142.62 47.56,142.62 48.39,141.79 49.82,141.79 50.99,140.62 50.99,139.19 52.74,137.44 55.16,137.44 55.68,136.92 57.95,136.92 61.09,133.77 61.09,125.71 69.02,117.79 78.12,117.79 96.82,99.09 123.67,99.09 130.8,91.96 130.8,88.86 132.65,87 132.65,85.3 133.58,84.37 135.66,84.37 136.85,83.17 136.85,81.98 137.83,81 v1(137.83,80.39)
MODPRSL11: length 144.4
  TOP w0.13: U123.K15 30.45,157.4 32.15,157.4 32.41,157.14 34.04,157.14 34.51,157.6 v1(34.61,157.6)
  SIG10 w0.155: v1(34.61,157.6) 34.94,157.6 36.44,156.1 40.46,156.1 46.96,149.6 48.2,149.6 48.96,148.84 48.96,147.83 50.23,146.56 52.51,146.56 55.82,143.25 57.21,143.25 59.88,140.59 60.9,140.59 62,139.48 62,137.05 63.46,135.59 63.46,130.63 63.94,130.15 63.94,126.74 70.52,120.16 79.5,120.16 98.26,101.41 125.37,101.41 135.29,91.49 135.29,90.71 v1(135.57,90.42)
  BOTTOM w0.13: v2(136.46,90.29) 135.7,90.29 v1(135.57,90.42) 135.06,89.91 135.06,88.9 135.22,88.75 R2671.1
