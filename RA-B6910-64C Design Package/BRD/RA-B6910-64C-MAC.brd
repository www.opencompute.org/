# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC27_RDP1: length 66.2
  TOP w0.147: v4(181.6,114.34) 181.7,114.34 arc(181.79,114.36) 181.86,114.41 181.92,114.47 arc(182.02,114.61) 182.05,114.78 U1.J49
  SIG3 w0.112: 179.86,105.94 179.86,105.97 179.95,106.06 179.95,113.58 arc(179.96,113.63) 179.99,113.67 180.13,113.82 arc(180.24,113.89) 180.36,113.91 181.82,113.91 arc(181.91,113.95) 181.95,114.04 181.95,114.21 arc(181.91,114.3) 181.82,114.34 v4(181.6,114.34)
  SIG3 w0.16: 179.86,105.94 179.86,103.75 arc(179.83,103.61) 179.75,103.48 179.6,103.33 arc(179.35,102.96) 179.26,102.52 179.26,92 arc(179.23,91.86) 179.15,91.73 173.88,86.46 arc(173.63,86.09) 173.55,85.66 173.55,72.83 arc(173.63,72.39) 173.88,72.02 175.89,70.02 arc(175.97,69.89) 176,69.75 176,68.42 arc(175.97,68.27) 175.89,68.15 174.33,66.6 arc(174.08,66.22) 174,65.79 174,62.04 arc(173.87,61.41) 173.52,60.89 172.98,60.34 172.62,60.34 172.26,59.98 172.26,59.62 171.86,59.23 arc(171.84,59.21) 171.81,59.18 171.76,59.13 171.71,59.08 arc(171.65,59.03) 171.58,58.98 arc(171.39,58.89) 171.18,58.86 170.35,58.86 arc(170.11,58.76) 170.01,58.52 170.01,58.32 arc(170.04,58.13) 170.15,57.97 YJ27.B22
FC27_RDP2: length 74.1
  TOP w0.147: v4(182.5,116.34) 182.55,116.34 U1.L48
  SIG2 w0.112: v4(182.5,116.34) 182.27,116.34 arc(182.18,116.3) 182.15,116.21 182.15,116.04 arc(182.05,115.81) 181.82,115.72 180.37,115.72 arc(180.32,115.71) 180.28,115.68 180.19,115.58 arc(180.16,115.54) 180.15,115.49 180.15,106.08 180.24,105.99 180.24,105.97
  SIG2 w0.16: 180.24,105.97 180.24,105.12 arc(180.3,104.83) 180.47,104.58 181.52,103.53 arc(181.68,103.29) 181.74,102.99 181.74,94.1 arc(181.68,93.81) 181.52,93.56 176.23,88.28 arc(176.07,88.04) 176.01,87.74 176.01,67.43 arc(175.97,67.25) 175.87,67.09 arc(175.76,66.93) 175.72,66.74 175.72,66.74 175.72,58.5 arc(175.63,58.06) 175.39,57.69 173.06,55.36 arc(172.69,55.11) 172.25,55.03 169.95,55.03 arc(169.86,55.01) 169.78,54.98 arc(169.73,54.95) 169.68,54.91 169.63,54.86 arc(169.54,54.72) 169.51,54.57 169.51,54.08 arc(169.46,53.86) 169.34,53.67 168.87,53.2 arc(168.74,53.02) 168.7,52.8 YJ27.B15
FC27_RDP3: length 72.1
  TOP w0.147: U1.N49 182.05,118.74 arc(182.03,118.64) 181.97,118.56 181.81,118.4 arc(181.75,118.36) 181.68,118.34 v4(181.6,118.34)
  SIG2 w0.112: 178.86,105.97 178.86,105.99 178.95,106.08 178.95,117.52 arc(178.98,117.65) 179.05,117.75 179.11,117.82 arc(179.22,117.89) 179.34,117.91 181.82,117.91 arc(181.91,117.95) 181.95,118.04 181.95,118.21 arc(181.91,118.3) 181.82,118.34 v4(181.6,118.34)
  SIG2 w0.16: 178.86,105.97 178.86,105.45 arc(178.85,105.37) 178.83,105.3 arc(178.8,105.24) 178.75,105.18 177.06,103.49 arc(176.81,103.12) 176.72,102.68 176.72,94.67 arc(176.69,94.53) 176.61,94.4 173.88,91.68 arc(173.63,91.31) 173.55,90.87 173.55,71.43 173.29,71.18 173.29,70.67 173.55,70.42 173.55,69.91 arc(173.63,69.47) 173.88,69.1 173.89,69.1 arc(173.97,68.97) 174,68.83 174,60.71 arc(173.94,60.42) 173.77,60.17 173.23,59.63 arc(172.99,59.46) 172.7,59.41 169.95,59.41 arc(169.77,59.38) 169.6,59.32 arc(169.5,59.26) 169.41,59.18 169.36,59.13 169.31,59.08 arc(169.07,58.92) 168.78,58.86 167.88,58.86 arc(167.69,58.78) 167.61,58.58 167.61,58.32 arc(167.64,58.13) 167.75,57.97 YJ27.B25
FC27_TDN0: length 73.2
  TOP w0.147: v4(183.5,109.34) 183.55,109.34 U1.D47
  SIG4 w0.112: v4(183.5,109.34) 183.27,109.34 arc(183.18,109.3) 183.15,109.21 183.15,109.04 arc(183.05,108.81) 182.82,108.72 182.35,108.72 arc(182.3,108.71) 182.26,108.68 182.18,108.6 arc(182.15,108.56) 182.14,108.51 182.14,106.08 182.24,105.99 182.24,105.97
  SIG4 w0.16: 182.24,105.97 182.24,104.1 arc(182.18,103.81) 182.01,103.56 181.9,103.45 arc(181.73,103.2) 181.67,102.91 181.67,91.04 arc(181.62,90.75) 181.45,90.5 176.23,85.29 arc(176.07,85.04) 176.01,84.75 176.01,68.21 arc(175.97,68.01) 175.85,67.84 arc(175.74,67.66) 175.7,67.46 175.7,57.96 arc(175.64,57.67) 175.47,57.42 173.3,55.25 arc(173.06,55.08) 172.76,55.03 162.75,55.03 arc(162.61,55) 162.48,54.91 162.43,54.86 arc(162.34,54.72) 162.31,54.57 162.31,54.08 arc(162.26,53.86) 162.14,53.67 161.68,53.21 arc(161.55,53.02) 161.5,52.78 YJ27.B6
FC27_TDN1: length 74
  TOP w0.147: U1.B48 183.05,107.79 arc(182.92,107.47) v4(182.6,107.34)
  SIG5 w0.112: 181.87,105.97 181.87,105.99 181.96,106.08 181.96,106.52 arc(181.98,106.65) 182.05,106.75 182.12,106.82 arc(182.23,106.89) 182.35,106.91 182.82,106.91 arc(182.91,106.95) 182.95,107.04 182.95,107.21 arc(182.91,107.3) 182.82,107.34 v4(182.6,107.34)
  SIG5 w0.16: YJ27.B2 158.15,53.97 arc(158.04,54.13) 158.01,54.32 158.01,54.54 arc(158.1,54.77) 158.33,54.86 159.18,54.86 arc(159.47,54.92) 159.71,55.08 159.76,55.13 159.81,55.18 arc(160.06,55.35) 160.35,55.41 172.63,55.41 arc(172.92,55.46) 173.17,55.63 175.09,57.55 arc(175.26,57.8) 175.32,58.09 175.32,65.97 arc(175.37,66.26) 175.54,66.51 175.99,66.96 arc(176.15,67.2) 176.21,67.5 176.21,68.43 176.06,68.58 176.06,69.34 176.21,69.49 176.21,72.96 arc(176.15,73.25) 175.99,73.5 175.85,73.64 arc(175.69,73.88) 175.63,74.18 175.63,84.88 arc(175.69,85.17) 175.85,85.42 181.12,90.69 arc(181.29,90.93) 181.34,91.23 181.34,101.97 arc(181.4,102.26) 181.57,102.51 181.64,102.58 arc(181.81,102.83) 181.87,103.12 181.87,103.48 181.74,103.6 181.74,104.26 181.87,104.39 181.87,105.97
FC27_TDN2: length 69.4
  TOP w0.147: v4(181.5,110.34) 181.55,110.34 U1.E49
  SIG4 w0.112: v4(181.5,110.34) 181.27,110.34 arc(181.18,110.3) 181.15,110.21 181.15,110.04 arc(181.05,109.81) 180.82,109.72 180.35,109.72 arc(180.3,109.71) 180.26,109.68 180.18,109.6 arc(180.15,109.56) 180.14,109.51 180.14,106.08 180.24,105.99 180.24,105.97
  SIG4 w0.16: 180.24,105.97 180.24,105.56 arc(180.21,105.35) 180.12,105.15 arc(180.07,105.08) 180.01,105.02 179.81,104.82 arc(179.65,104.57) 179.59,104.28 179.59,92.01 arc(179.53,91.72) 179.37,91.47 174.15,86.25 arc(173.98,86) 173.93,85.71 173.93,69.53 arc(173.98,69.24) 174.15,68.99 174.15,68.99 arc(174.32,68.74) 174.38,68.45 174.38,61.22 arc(174.29,60.78) 174.04,60.41 173,59.36 arc(172.62,59.11) 172.19,59.03 162.75,59.03 arc(162.61,59) 162.48,58.91 162.46,58.89 162.43,58.86 arc(162.34,58.72) 162.31,58.57 162.31,58.08 arc(162.26,57.86) 162.14,57.67 161.63,57.16 arc(161.53,57.02) 161.5,56.86 YJ27.B33
FC27_TDN3: length 69.6
  TOP w0.147: U1.C50 181.05,108.79 arc(180.92,108.47) v4(180.6,108.34)
  SIG5 w0.112: 179.86,105.95 179.86,105.98 179.95,106.07 179.95,107.52 arc(179.98,107.65) 180.05,107.75 180.12,107.82 arc(180.22,107.89) 180.34,107.91 180.82,107.91 arc(180.91,107.95) 180.95,108.04 180.95,108.21 arc(180.91,108.3) 180.82,108.34 v4(180.6,108.34)
  SIG5 w0.16: YJ27.B37 158.15,57.97 arc(158.04,58.13) 158.01,58.32 158.01,58.59 arc(158.09,58.78) 158.28,58.86 159.18,58.86 arc(159.47,58.92) 159.71,59.08 159.76,59.13 159.81,59.18 arc(160.06,59.35) 160.35,59.41 171.7,59.41 arc(171.99,59.46) 172.24,59.63 173.77,61.17 arc(173.94,61.41) 174,61.71 174,68.32 arc(173.94,68.61) 173.77,68.86 173.77,68.86 arc(173.6,69.11) 173.55,69.4 173.55,70.16 173.44,70.26 173.44,71.13 173.55,71.23 173.55,85.82 arc(173.6,86.11) 173.77,86.36 179.04,91.63 arc(179.2,91.87) 179.26,92.17 179.26,102.5 179.11,102.65 179.11,103.42 179.26,103.57 179.26,104.33 arc(179.32,104.62) 179.48,104.87 179.64,105.02 arc(179.69,105.09) 179.74,105.15 arc(179.83,105.35) 179.86,105.56 179.86,105.95
FC27_TDP0: length 73.2
  TOP w0.147: U1.D48 182.88,109.77 arc(182.78,109.72) 182.68,109.64 182.68,109.63 arc(182.62,109.55) 182.6,109.45 v4(182.6,109.34)
  SIG4 w0.112: v4(182.6,109.34) 182.82,109.34 arc(182.91,109.3) 182.95,109.21 182.95,109.04 arc(182.91,108.95) 182.82,108.91 182.35,108.91 arc(182.23,108.89) 182.12,108.82 182.04,108.74 arc(181.97,108.63) 181.95,108.51 181.95,106.08 181.86,105.99 181.86,105.97
  SIG4 w0.16: YJ27.B5 160.55,53.97 arc(160.44,54.13) 160.41,54.32 160.41,54.55 arc(160.5,54.77) 160.71,54.86 161.58,54.86 arc(161.87,54.92) 162.11,55.08 162.16,55.13 162.21,55.18 arc(162.46,55.35) 162.75,55.41 172.76,55.41 arc(172.91,55.44) 173.03,55.52 173.39,55.88 173.39,56.24 173.75,56.6 174.11,56.6 175.2,57.69 arc(175.29,57.81) 175.32,57.96 175.32,67.46 arc(175.39,67.81) 175.58,68.11 arc(175.62,68.16) 175.63,68.21 175.63,84.75 arc(175.72,85.18) 175.96,85.55 181.18,90.77 arc(181.26,90.9) 181.29,91.04 181.29,102.91 arc(181.38,103.34) 181.63,103.72 181.74,103.83 arc(181.83,103.96) 181.86,104.1 181.86,105.97
FC27_TDP1: length 74
  TOP w0.147: v4(183.5,107.34) 183.55,107.34 U1.B47
  SIG5 w0.112: v4(183.5,107.34) 183.27,107.34 arc(183.18,107.3) 183.15,107.21 183.15,107.04 arc(183.05,106.81) 182.82,106.72 182.35,106.72 arc(182.3,106.71) 182.26,106.68 182.19,106.61 arc(182.16,106.57) 182.16,106.52 182.16,106.08 182.25,105.99 182.25,105.97
  SIG5 w0.16: 182.25,105.97 182.25,103.12 arc(182.16,102.68) 181.91,102.31 181.84,102.24 arc(181.75,102.11) 181.72,101.97 181.72,91.23 arc(181.64,90.79) 181.39,90.42 176.12,85.15 arc(176.04,85.02) 176.01,84.88 176.01,74.18 arc(176.04,74.03) 176.12,73.91 176.26,73.77 arc(176.51,73.4) 176.59,72.96 176.59,67.5 arc(176.51,67.06) 176.26,66.69 175.81,66.24 arc(175.73,66.11) 175.7,65.97 175.7,58.09 arc(175.61,57.65) 175.36,57.28 173.44,55.36 arc(173.07,55.11) 172.63,55.03 160.35,55.03 arc(160.21,55) 160.08,54.91 160.06,54.89 160.03,54.86 arc(159.94,54.72) 159.91,54.57 159.91,54.08 arc(159.86,53.86) 159.74,53.67 159.26,53.19 arc(159.25,53.19) 159.24,53.18 arc(159.14,53.01) 159.1,52.81 YJ27.B3
FC27_TDP2: length 69.4
  TOP w0.147: v4(180.6,110.34) 180.6,110.45 arc(180.62,110.55) 180.68,110.63 180.68,110.64 arc(180.78,110.72) 180.88,110.77 U1.E50
  SIG4 w0.112: 179.86,105.97 179.86,105.99 179.95,106.08 179.95,109.51 arc(179.97,109.63) 180.04,109.74 180.12,109.82 arc(180.23,109.89) 180.35,109.91 180.82,109.91 arc(180.91,109.95) 180.95,110.04 180.95,110.21 arc(180.91,110.3) 180.82,110.34 v4(180.6,110.34)
  SIG4 w0.16: YJ27.B34 160.55,57.97 arc(160.44,58.13) 160.41,58.32 160.41,58.57 arc(160.49,58.78) 160.7,58.86 161.58,58.86 arc(161.87,58.92) 162.11,59.08 162.16,59.13 162.21,59.18 arc(162.46,59.35) 162.75,59.41 172.19,59.41 arc(172.48,59.46) 172.73,59.63 172.94,59.84 172.94,60.2 173.28,60.54 173.63,60.54 173.77,60.68 arc(173.94,60.92) 174,61.22 174,68.45 arc(173.97,68.6) 173.89,68.72 173.88,68.73 arc(173.63,69.1) 173.55,69.53 173.55,85.71 arc(173.63,86.15) 173.88,86.52 179.1,91.74 arc(179.18,91.86) 179.21,92.01 179.21,104.28 arc(179.3,104.72) 179.54,105.09 179.74,105.29 arc(179.77,105.32) 179.8,105.35 arc(179.84,105.45) 179.86,105.56 179.86,105.97
FC27_TDP3: length 69.6
  TOP w0.147: U1.C49 181.55,108.34 v4(181.5,108.34)
  SIG5 w0.112: v4(181.5,108.34) 181.27,108.34 arc(181.18,108.3) 181.15,108.21 181.15,108.04 arc(181.05,107.81) 180.82,107.72 180.34,107.72 arc(180.3,107.71) 180.26,107.68 180.19,107.61 arc(180.16,107.57) 180.15,107.52 180.15,106.07 180.24,105.98 180.24,105.95
  SIG5 w0.16: 180.24,105.95 180.24,105.56 arc(180.2,105.24) 180.06,104.95 arc(179.99,104.85) 179.91,104.75 179.75,104.6 arc(179.67,104.48) 179.64,104.33 179.64,92.17 arc(179.55,91.73) 179.31,91.36 174.04,86.09 arc(173.96,85.96) 173.93,85.82 173.93,69.4 arc(173.96,69.26) 174.04,69.13 174.04,69.13 arc(174.29,68.76) 174.38,68.32 174.38,61.71 arc(174.29,61.27) 174.04,60.9 172.51,59.36 arc(172.14,59.11) 171.7,59.03 160.35,59.03 arc(160.21,59) 160.08,58.91 160.03,58.86 arc(159.95,58.76) 159.91,58.64 arc(159.91,58.6) 159.91,58.57 159.91,58.08 arc(159.86,57.86) 159.74,57.67 159.22,57.16 arc(159.13,57.02) 159.1,56.86 YJ27.B36
FC28_29_PVDD0P8: length 5.9
  TOP w0.229: U1.Y41 v1(189.55,125.34) ; U1.Y42 v1(188.55,125.34)
  TOP w0.381: C2969.1 185.2,98.19 ; C2969.1 185.99,98.93 ; C2969.1 185.2,99.67
  BOTTOM w0.13: v1(186.37,99.44) v2(187.13,99.44)
  BOTTOM w0.381: C3328.1 189.07,124.86 v1(189.55,125.34) ; C2925.1 188.58,125.34 v1(188.55,125.34)
  vias: v1(186.37,98.42)
FC28_RDN0: length 69.8
  TOP w0.147: v4(184.6,112.34) 184.68,112.34 arc(184.76,112.36) 184.83,112.4 184.91,112.48 arc(185.01,112.64) 185.05,112.82 U1.G46
  SIG9 w0.112: 185.84,104.95 185.94,105.05 185.94,111.48 arc(185.93,111.52) 185.9,111.57 185.79,111.68 arc(185.75,111.71) 185.7,111.72 185.25,111.72 arc(185.04,111.81) 184.95,112.02 184.95,112.21 arc(184.94,112.26) 184.91,112.3 184.91,112.3 arc(184.87,112.33) 184.82,112.34 v4(184.6,112.34)
  SIG9 w0.16: 185.84,104.95 185.84,103.87 arc(185.8,103.63) 185.69,103.42 arc(185.66,103.37) 185.62,103.33 184.06,101.77 arc(183.89,101.52) 183.83,101.23 183.83,95.56 arc(183.77,95.27) 183.61,95.02 182.02,93.44 arc(181.78,93.27) 181.49,93.22 175.74,93.22 arc(175.44,93.16) 175.2,92.99 171.61,89.4 171.37,89.17 arc(171.2,88.92) 171.15,88.63 171.15,71.83 arc(171.23,71.39) 171.48,71.02 173.89,68.62 arc(173.97,68.5) 174,68.35 174,61.64 arc(174.08,61.2) 174.33,60.83 176.35,58.82 176.39,58.77 arc(176.45,58.7) 176.49,58.62 arc(176.49,58.62) 176.49,58.62 arc(176.49,58.61) 176.49,58.59 arc(176.51,58.54) 176.51,58.48 176.51,58.04 arc(176.55,57.84) 176.66,57.67 177.2,57.13 arc(177.27,57.02) 177.3,56.9 YJ28.B21
FC28_RDN1: length 75.8
  TOP w0.147: U1.J45 185.55,114.34 v4(185.5,114.34)
  SIG9 w0.112: v4(185.5,114.34) 185.31,114.15 arc(185.27,114.09) 185.25,114.02 arc(185.24,113.95) 185.22,113.89 arc(185.11,113.77) 184.95,113.72 184.41,113.72 arc(184.36,113.71) 184.32,113.68 184.2,113.57 arc(184.17,113.52) 184.16,113.48 184.16,113.48 184.16,105.8 arc(184.13,105.63) 184.03,105.47 arc(183.88,105.37) 183.7,105.34 183.42,105.34 arc(183.33,105.32) 183.25,105.27 arc(183.23,105.25) 183.2,105.25
  SIG9 w0.16: YJ28.B17 178.25,53.97 arc(178.36,54.14) 178.4,54.34 178.4,54.52 arc(178.3,54.76) 178.06,54.86 177.16,54.86 arc(176.86,54.92) 176.62,55.08 175.43,56.28 175.43,56.64 175.07,57 174.71,57 174.34,57.36 174.34,57.72 173.98,58.09 173.61,58.09 173.29,58.42 arc(173.12,58.66) 173.06,58.95 173.06,59.46 173.27,59.67 173.27,60.28 173.06,60.48 173.06,65.73 arc(173.01,66.02) 172.84,66.27 172.08,67.03 172.08,67.36 171.69,67.75 171.36,67.75 171,68.11 171,68.11 170.28,68.82 169.67,69.44 arc(169.51,69.68) 169.45,69.97 169.45,89.59 arc(169.48,89.74) 169.56,89.86 171.32,91.63 173.08,93.39 arc(173.33,93.76) 173.42,94.2 173.42,94.96 arc(173.45,95.11) 173.53,95.23 174.45,96.15 arc(174.57,96.23) 174.72,96.26 175.36,96.26 arc(175.8,96.35) 176.17,96.6 177.15,97.58 arc(177.4,97.95) 177.48,98.39 177.48,101.79 arc(177.54,102.08) 177.71,102.33 177.77,102.39 arc(178.01,102.56) 178.31,102.61 179.2,102.61 arc(179.64,102.7) 180.01,102.95 182.19,105.13 arc(182.32,105.22) 182.46,105.25 183.2,105.25
FC28_RDN2: length 78.1
  TOP w0.147: U1.L46 185.05,116.73 arc(185.03,116.62) 184.97,116.53 184.9,116.47 arc(184.76,116.37) v4(184.6,116.34)
  SIG8 w0.112: v4(184.6,116.34) 184.85,116.34 arc(184.92,116.31) 184.95,116.24 184.95,116.01 arc(185.04,115.8) 185.25,115.72 185.84,115.72 arc(185.91,115.69) 185.94,115.61 185.94,105.17 185.85,105.08 185.85,105.05
  SIG8 w0.16: YJ28.B24 179.7,56.61 arc(179.62,57) 179.4,57.34 179.14,57.59 arc(178.97,57.85) 178.91,58.15 178.91,58.42 arc(178.9,58.51) 178.88,58.59 arc(178.88,58.6) 178.88,58.61 arc(178.87,58.62) 178.87,58.63 arc(178.82,58.73) 178.75,58.82 178.66,58.9 arc(178.54,58.98) 178.39,59.01 176.62,59.01 arc(176.18,59.1) 175.81,59.35 174.24,60.92 arc(173.99,61.29) 173.9,61.73 173.9,68.06 arc(173.88,68.2) 173.79,68.32 171.47,70.65 arc(171.22,71.02) 171.13,71.46 171.13,90.64 arc(171.22,91.08) 171.47,91.45 173.05,93.03 arc(173.14,93.16) 173.16,93.3 173.16,100.65 arc(173.25,101.08) 173.5,101.46 174.7,102.66 arc(175.07,102.91) 175.51,102.99 184.63,102.99 arc(184.78,103.02) 184.9,103.11 185.74,103.94 arc(185.82,104.06) 185.85,104.21 185.85,105.05
FC28_RDN3: length 86
  TOP w0.147: U1.N45 185.55,118.34 v4(185.5,118.34)
  SIG8 w0.112: 183.07,104.81 183.1,104.81 183.19,104.9 183.75,104.9 arc(183.88,104.92) 183.98,104.99 184.06,105.07 arc(184.13,105.17) 184.15,105.3 184.15,117.55 arc(184.16,117.6) 184.19,117.64 184.22,117.68 arc(184.26,117.71) 184.31,117.72 185,117.72 arc(185.21,117.8) 185.3,118.01 185.3,118.14 arc(185.36,118.28) v4(185.5,118.34)
  SIG8 w0.16: 183.07,104.81 173.52,104.81 arc(173.22,104.75) 172.98,104.58 170.21,101.82 arc(170.05,101.57) 169.99,101.28 169.99,93.02 arc(169.93,92.73) 169.77,92.48 169.65,92.37 arc(169.49,92.12) 169.43,91.83 169.43,76.48 169.66,76.25 169.66,75.69 169.43,75.46 169.43,74.95 169.66,74.72 169.66,74.17 169.43,73.94 169.43,73.43 169.66,73.2 169.66,72.64 169.43,72.41 169.43,71.9 169.66,71.68 169.66,71.12 169.43,70.89 169.43,70.32 arc(169.46,70.17) 169.54,70.05 172.65,66.94 arc(172.9,66.57) 172.98,66.13 172.98,59.07 arc(173.04,58.78) 173.21,58.53 176.12,55.62 arc(176.36,55.45) 176.66,55.39 178.39,55.39 arc(178.68,55.34) 178.93,55.17 179.11,54.99 arc(179.25,54.89) 179.42,54.86 180.4,54.86 arc(180.55,54.83) 180.68,54.75 arc(180.77,54.61) 180.8,54.45 180.8,54.34 arc(180.76,54.14) 180.65,53.97 YJ28.B14
FC28_RDP0: length 69.8
  TOP w0.147: U1.G45 185.55,112.34 v4(185.5,112.34)
  SIG9 w0.112: 186.22,104.95 186.14,105.04 186.14,111.48 arc(186.11,111.6) 186.04,111.71 185.93,111.82 arc(185.82,111.89) 185.7,111.92 185.25,111.92 arc(185.18,111.95) 185.15,112.02 185.15,112.22 arc(185.15,112.25) 185.18,112.29 185.2,112.31 arc(185.23,112.33) 185.27,112.34 v4(185.5,112.34)
  SIG9 w0.16: 186.22,104.95 186.22,103.87 arc(186.17,103.51) 186,103.19 arc(185.95,103.12) 185.89,103.06 184.33,101.5 arc(184.24,101.37) 184.21,101.23 184.21,95.56 arc(184.13,95.13) 183.88,94.75 182.29,93.17 arc(181.92,92.92) 181.49,92.83 175.74,92.83 arc(175.59,92.81) 175.47,92.72 172.6,89.85 172.12,89.37 171.64,88.9 arc(171.56,88.77) 171.53,88.63 171.53,71.83 arc(171.59,71.54) 171.75,71.29 174.15,68.89 arc(174.32,68.64) 174.38,68.35 174.38,61.64 arc(174.44,61.35) 174.6,61.1 174.96,60.74 175.24,60.74 175.68,60.31 175.68,60.02 176.76,58.94 arc(176.85,58.88) 176.95,58.86 178.06,58.86 arc(178.3,58.76) 178.4,58.52 178.4,58.34 arc(178.36,58.14) 178.25,57.97 YJ28.B22
FC28_RDP1: length 75.8
  TOP w0.147: U1.J46 185.05,114.82 arc(185.01,114.64) 184.91,114.48 184.83,114.4 arc(184.76,114.36) 184.68,114.34 v4(184.6,114.34)
  SIG9 w0.112: v4(184.6,114.34) 184.91,114.34 arc(184.98,114.33) 185.03,114.29 arc(185.05,114.27) 185.05,114.24 185.05,114.02 arc(185.05,114) 185.05,113.98 arc(185.01,113.93) 184.95,113.92 184.41,113.92 arc(184.28,113.89) 184.18,113.82 184.06,113.71 arc(183.99,113.6) 183.97,113.48 183.97,105.8 arc(183.95,105.7) 183.89,105.61 arc(183.8,105.56) 183.7,105.53 183.42,105.53 arc(183.33,105.55) 183.25,105.61 arc(183.23,105.62) 183.2,105.63
  SIG9 w0.16: YJ28.B18 177.3,52.82 arc(177.26,53.02) 177.15,53.19 176.64,53.69 arc(176.55,53.84) 176.51,54.01 176.51,54.48 arc(176.51,54.54) 176.49,54.6 arc(176.45,54.69) 176.39,54.77 176.35,54.82 173.02,58.15 arc(172.77,58.52) 172.68,58.95 172.68,65.73 arc(172.65,65.87) 172.57,66 169.4,69.17 arc(169.15,69.54) 169.07,69.97 169.07,89.59 arc(169.12,89.89) 169.29,90.13 170.17,91.01 172.81,93.66 arc(172.98,93.91) 173.04,94.2 173.04,94.96 arc(173.1,95.25) 173.26,95.5 174.18,96.42 arc(174.43,96.59) 174.72,96.64 175.36,96.64 arc(175.65,96.7) 175.9,96.87 176.88,97.85 arc(177.04,98.1) 177.1,98.39 177.1,101.79 arc(177.19,102.23) 177.44,102.6 177.5,102.66 arc(177.87,102.91) 178.31,102.99 179.2,102.99 arc(179.49,103.05) 179.74,103.22 181.92,105.4 arc(182.17,105.57) 182.46,105.63 183.2,105.63
FC28_RDP2: length 78.1
  TOP w0.147: U1.L45 185.55,116.34 v4(185.5,116.34)
  SIG8 w0.112: v4(185.5,116.34) 185.25,116.34 arc(185.18,116.31) 185.15,116.24 185.15,116.01 arc(185.18,115.94) 185.25,115.91 185.84,115.91 arc(186.05,115.82) 186.14,115.61 186.14,105.17 186.23,105.08 186.23,105.05
  SIG8 w0.16: YJ28.B25 180.65,57.97 arc(180.78,58.17) 180.83,58.39 180.83,58.43 arc(180.8,58.57) 180.72,58.69 arc(180.53,58.82) 180.3,58.86 179.68,58.86 arc(179.27,58.94) 178.93,59.17 arc(178.68,59.34) 178.39,59.39 176.62,59.39 arc(176.33,59.45) 176.08,59.62 174.51,61.19 arc(174.34,61.44) 174.29,61.73 174.29,68.06 arc(174.23,68.35) 174.06,68.59 171.74,70.92 arc(171.57,71.17) 171.51,71.46 171.51,72.03 171.74,72.26 171.74,72.82 171.51,73.05 171.51,90.64 arc(171.57,90.93) 171.74,91.18 173.32,92.76 arc(173.49,93.01) 173.55,93.3 173.55,100.65 arc(173.6,100.94) 173.77,101.19 174.97,102.39 arc(175.22,102.56) 175.51,102.61 184.63,102.61 arc(184.93,102.67) 185.17,102.84 186.01,103.67 arc(186.17,103.92) 186.23,104.21 186.23,105.05
FC28_RDP3: length 86
  TOP w0.147: U1.N46 185.05,118.73 arc(185.03,118.62) 184.97,118.53 184.9,118.47 arc(184.76,118.37) v4(184.6,118.34)
  SIG8 w0.112: 183.07,105.19 183.1,105.19 183.19,105.1 183.75,105.1 arc(183.8,105.11) 183.84,105.13 183.92,105.21 arc(183.94,105.25) 183.95,105.3 183.95,117.55 arc(183.98,117.68) 184.05,117.78 184.08,117.82 arc(184.19,117.89) 184.31,117.91 185,117.91 arc(185.07,117.94) 185.1,118.01 185.1,118.16 arc(185.09,118.21) 185.07,118.25 185.01,118.3 arc(184.97,118.33) 184.92,118.34 v4(184.6,118.34)
  SIG8 w0.16: YJ28.B15 179.7,52.68 arc(179.63,53.01) 179.45,53.29 179.11,53.63 arc(178.96,53.84) 178.91,54.1 178.91,54.48 arc(178.91,54.54) 178.89,54.61 arc(178.85,54.7) 178.79,54.77 178.75,54.81 178.66,54.9 arc(178.54,54.98) 178.39,55.01 176.66,55.01 arc(176.22,55.1) 175.85,55.35 172.94,58.26 arc(172.69,58.63) 172.6,59.07 172.6,66.13 arc(172.54,66.42) 172.38,66.67 169.27,69.78 arc(169.11,70.02) 169.05,70.32 169.05,91.83 arc(169.14,92.27) 169.38,92.64 169.5,92.75 arc(169.58,92.88) 169.61,93.02 169.61,101.28 arc(169.7,101.72) 169.94,102.09 172.71,104.85 arc(173.08,105.1) 173.52,105.19 183.07,105.19
FC28_TDN0: length 72.7
  TOP w0.147: v4(187.5,107.34) 187.55,107.34 U1.B43
  SIG7 w0.112: 186.3,104.95 186.3,104.97 186.24,105.03 arc(186.22,105.07) 186.21,105.12 186.21,106.5 arc(186.22,106.58) 186.26,106.64 186.28,106.66 arc(186.35,106.7) 186.42,106.72 186.76,106.72 arc(187.03,106.83) 187.15,107.1 187.15,107.18 arc(187.2,107.29) 187.31,107.34 v4(187.5,107.34)
  SIG7 w0.16: 186.3,104.95 186.3,103.66 arc(186.33,103.52) 186.41,103.39 187.5,102.31 arc(187.66,102.06) 187.72,101.77 187.72,95.13 arc(187.66,94.84) 187.5,94.59 183.87,90.96 arc(183.78,90.84) 183.75,90.69 183.75,75.93 arc(183.7,75.63) 183.53,75.39 181.1,72.96 181.1,72.81 180.64,72.35 180.49,72.35 180.17,72.03 180.17,71.87 179.71,71.41 179.56,71.41 179.23,71.09 arc(178.98,70.92) 178.69,70.86 177.39,70.86 arc(177.24,70.83) 177.12,70.75 174.51,68.15 arc(174.43,68.03) 174.4,67.88 174.4,61.61 arc(174.43,61.47) 174.51,61.35 176.35,59.51 arc(176.48,59.42) 176.62,59.39 187.99,59.39 arc(188.28,59.34) 188.53,59.17 arc(188.87,58.94) 189.28,58.86 190.06,58.86 arc(190.3,58.76) 190.4,58.52 190.4,58.34 arc(190.36,58.14) 190.25,57.97 YJ28.B37
FC28_TDN1: length 81
  TOP w0.147: U1.E46 185.05,110.79 arc(184.92,110.47) v4(184.6,110.34)
  SIG6 w0.112: v4(184.6,110.34) 184.79,110.34 arc(184.84,110.33) 184.88,110.3 184.91,110.27 arc(184.94,110.23) 184.95,110.18 184.95,110.04 arc(184.91,109.95) 184.82,109.91 184.33,109.91 arc(184.21,109.89) 184.1,109.82 184.05,109.76 arc(183.98,109.66) 183.96,109.54 183.96,105.17 183.86,105.08 183.86,105.05
  SIG6 w0.16: 183.86,105.05 183.86,94.83 arc(183.81,94.54) 183.64,94.29 180.75,91.41 arc(180.51,91.24) 180.22,91.18 178.91,91.18 arc(178.62,91.13) 178.37,90.96 177.68,90.26 arc(177.43,90.1) 177.14,90.04 172.54,90.04 arc(172.24,89.98) 172,89.82 171.36,89.18 arc(171.19,88.93) 171.13,88.64 171.13,69.3 arc(171.22,68.86) 171.47,68.49 172.59,67.37 arc(172.67,67.24) 172.7,67.1 172.7,58.66 arc(172.76,58.37) 172.93,58.12 175.81,55.24 arc(176.06,55.07) 176.35,55.01 185.59,55.01 arc(185.74,54.98) 185.86,54.9 185.95,54.82 185.99,54.77 arc(186.05,54.7) 186.09,54.6 arc(186.09,54.59) 186.1,54.58 arc(186.11,54.53) 186.11,54.48 186.11,54.16 arc(186.17,53.85) 186.35,53.58 186.72,53.21 arc(186.85,53.01) 186.9,52.78 YJ28.B6
FC28_TDN2: length 72.7
  TOP w0.147: U1.C45 185.55,108.34 v4(185.5,108.34)
  SIG6 w0.112: 186.24,105.05 186.24,105.08 186.14,105.17 186.14,107.54 arc(186.12,107.66) 186.05,107.76 186,107.82 arc(185.89,107.89) 185.77,107.91 185.27,107.91 arc(185.18,107.95) 185.15,108.04 185.15,108.21 arc(185.18,108.3) 185.27,108.34 v4(185.5,108.34)
  SIG6 w0.16: 186.24,105.05 186.24,103.86 arc(186.3,103.57) 186.46,103.32 187.39,102.39 187.42,102.39 187.54,102.23 arc(187.62,102.05) 187.64,101.85 187.64,93.82 arc(187.56,93.38) 187.31,93.01 181.75,87.45 arc(181.38,87.21) 180.95,87.12 178.43,87.12 arc(178.29,87.09) 178.16,87.01 174.04,82.88 arc(173.96,82.76) 173.93,82.61 173.93,69.52 arc(173.98,69.23) 174.15,68.98 174.18,68.95 arc(174.34,68.71) 174.4,68.41 174.4,61.28 arc(174.43,61.13) 174.51,61.01 174.87,60.65 175.19,60.65 175.53,60.31 175.53,60 176.02,59.51 arc(176.14,59.42) 176.29,59.39 185.59,59.39 arc(185.88,59.34) 186.13,59.17 arc(186.47,58.94) 186.88,58.86 187.66,58.86 arc(187.9,58.76) 188,58.52 188,58.34 arc(187.96,58.14) 187.85,57.97 YJ28.B34
FC28_TDN3: length 75.1
  TOP w0.147: U1.A46 185.05,106.79 arc(184.92,106.47) v4(184.6,106.34)
  SIG7 w0.112: 183.89,104.95 183.89,104.97 183.98,105.06 183.98,105.5 arc(184.01,105.65) 184.1,105.77 184.12,105.79 arc(184.25,105.88) 184.4,105.91 184.76,105.91 arc(184.89,105.96) 184.95,106.1 184.95,106.18 arc(184.9,106.29) 184.79,106.34 v4(184.6,106.34)
  SIG7 w0.16: YJ28.B3 189.3,52.79 arc(189.26,53.02) 189.13,53.2 188.75,53.58 arc(188.57,53.85) 188.51,54.16 188.51,54.48 arc(188.51,54.53) 188.5,54.58 arc(188.46,54.68) 188.39,54.77 188.35,54.82 188.26,54.9 arc(188.14,54.98) 187.99,55.01 176.43,55.01 arc(176.14,55.07) 175.89,55.24 172.93,58.2 arc(172.76,58.45) 172.7,58.74 172.7,74.56 arc(172.76,74.85) 172.93,75.1 173.43,75.61 arc(173.52,75.73) 173.55,75.88 173.55,85.79 arc(173.6,86.08) 173.77,86.33 178.4,90.96 arc(178.65,91.13) 178.94,91.18 180.37,91.18 arc(180.52,91.21) 180.64,91.3 183.78,94.43 arc(183.86,94.56) 183.89,94.7 183.89,104.95
FC28_TDP0: length 72.7
  TOP w0.147: U1.B44 187.05,107.79 arc(186.92,107.47) v4(186.6,107.34)
  SIG7 w0.112: 185.92,104.95 185.92,104.97 186.01,105.06 186.01,106.5 arc(186.04,106.65) 186.12,106.78 186.14,106.8 arc(186.27,106.88) 186.42,106.91 186.76,106.91 arc(186.9,106.97) 186.95,107.1 186.95,107.18 arc(186.9,107.29) 186.79,107.34 v4(186.6,107.34)
  SIG7 w0.16: YJ28.B36 189.3,56.7 arc(189.24,57.01) 189.07,57.27 188.75,57.58 arc(188.57,57.85) 188.51,58.16 188.51,58.48 arc(188.51,58.53) 188.5,58.58 arc(188.49,58.59) 188.49,58.6 arc(188.45,58.7) 188.39,58.77 188.35,58.82 188.26,58.9 arc(188.14,58.98) 187.99,59.01 176.62,59.01 arc(176.33,59.07) 176.08,59.24 174.25,61.08 arc(174.08,61.32) 174.02,61.61 174.02,67.88 arc(174.08,68.17) 174.25,68.42 176.85,71.02 arc(177.09,71.19) 177.39,71.24 178.69,71.24 arc(178.84,71.27) 178.96,71.36 183.26,75.66 arc(183.34,75.78) 183.37,75.93 183.37,90.69 arc(183.43,90.98) 183.6,91.23 187.23,94.86 arc(187.31,94.99) 187.34,95.13 187.34,101.77 arc(187.31,101.92) 187.23,102.04 186.14,103.13 arc(185.98,103.37) 185.92,103.66 185.92,104.95
FC28_TDP1: length 81
  TOP w0.147: v4(185.5,110.34) 185.55,110.34 U1.E45
  SIG6 w0.112: 184.24,105.05 184.24,105.08 184.15,105.17 184.15,109.54 arc(184.16,109.58) 184.19,109.63 184.24,109.68 arc(184.28,109.71) 184.33,109.72 184.82,109.72 arc(185.05,109.81) 185.15,110.04 185.15,110.19 arc(185.16,110.24) 185.18,110.28 185.21,110.3 arc(185.25,110.33) 185.3,110.34 v4(185.5,110.34)
  SIG6 w0.16: YJ28.B5 187.85,53.97 arc(187.96,54.14) 188,54.34 188,54.52 arc(187.9,54.76) 187.66,54.86 186.88,54.86 arc(186.47,54.94) 186.13,55.17 arc(185.88,55.34) 185.59,55.39 176.35,55.39 arc(176.2,55.42) 176.08,55.51 174.83,56.76 174.83,57.07 174.49,57.41 174.17,57.41 173.2,58.39 arc(173.11,58.51) 173.08,58.66 173.08,67.1 arc(173.03,67.39) 172.86,67.64 171.74,68.76 arc(171.57,69.01) 171.51,69.3 171.51,69.3 171.51,88.64 arc(171.54,88.78) 171.63,88.91 172.27,89.55 arc(172.39,89.63) 172.54,89.66 177.14,89.66 arc(177.57,89.75) 177.94,89.99 178.64,90.69 arc(178.76,90.77) 178.91,90.8 180.22,90.8 arc(180.65,90.89) 181.02,91.14 183.91,94.02 arc(184.16,94.39) 184.24,94.83 184.24,105.05
FC28_TDP2: length 72.8
  TOP w0.147: U1.C46 185.05,108.79 arc(184.92,108.47) v4(184.6,108.34)
  SIG6 w0.112: 185.86,105.05 185.86,105.08 185.95,105.17 185.95,107.54 arc(185.94,107.58) 185.91,107.63 185.86,107.68 arc(185.82,107.71) 185.77,107.72 185.27,107.72 arc(185.05,107.81) 184.95,108.04 184.95,108.21 arc(184.91,108.3) 184.82,108.34 v4(184.6,108.34)
  SIG6 w0.16: YJ28.B33 186.9,56.96 arc(186.89,57.03) 186.84,57.09 186.6,57.33 186.53,57.4 186.35,57.58 arc(186.17,57.85) 186.11,58.16 186.11,58.48 arc(186.11,58.53) 186.1,58.57 arc(186.1,58.59) 186.09,58.6 arc(186.05,58.7) 185.99,58.77 185.95,58.82 185.86,58.9 arc(185.74,58.98) 185.59,59.01 176.29,59.01 arc(175.99,59.07) 175.75,59.24 174.25,60.74 arc(174.08,60.99) 174.02,61.28 174.02,68.41 arc(173.99,68.56) 173.91,68.68 173.88,68.71 arc(173.63,69.08) 173.55,69.52 173.55,82.61 arc(173.6,82.9) 173.77,83.15 177.89,87.28 arc(178.14,87.44) 178.43,87.5 180.95,87.5 arc(181.24,87.56) 181.49,87.72 187.04,93.28 arc(187.2,93.52) 187.26,93.82 187.26,101.85 arc(187.25,101.94) 187.22,102.02 186.19,103.05 arc(185.94,103.42) 185.86,103.86 185.86,105.05
FC28_TDP3: length 75.1
  TOP w0.147: U1.A45 185.55,106.34 v4(185.5,106.34)
  SIG7 w0.112: 184.27,104.95 184.27,104.97 184.22,105.03 arc(184.19,105.07) 184.18,105.12 184.18,105.5 arc(184.2,105.57) 184.24,105.63 184.26,105.65 arc(184.32,105.7) 184.4,105.71 184.76,105.71 arc(185.03,105.82) 185.15,106.1 185.15,106.18 arc(185.2,106.29) 185.31,106.34 v4(185.5,106.34)
  SIG7 w0.16: 184.27,104.95 184.27,94.7 arc(184.21,94.41) 184.05,94.16 180.91,91.03 arc(180.66,90.86) 180.37,90.8 178.94,90.8 arc(178.8,90.77) 178.67,90.69 174.04,86.06 arc(173.96,85.93) 173.93,85.79 173.93,75.88 arc(173.87,75.59) 173.7,75.34 173.2,74.83 arc(173.11,74.71) 173.08,74.56 173.08,72.05 173.19,71.94 173.19,71.33 173.08,71.22 173.08,70.76 173.19,70.65 173.19,70.04 173.08,69.93 173.08,58.74 arc(173.11,58.6) 173.2,58.47 176.16,55.51 arc(176.29,55.42) 176.43,55.39 187.99,55.39 arc(188.28,55.34) 188.53,55.17 188.62,55.08 arc(188.86,54.92) 189.16,54.86 190.06,54.86 arc(190.3,54.76) 190.4,54.52 190.4,54.34 arc(190.36,54.14) 190.25,53.97 YJ28.B2
FC29_RDN0: length 66.2
  TOP w0.147: v4(187.6,112.34) 187.68,112.34 arc(187.76,112.36) 187.83,112.4 187.91,112.48 arc(188.01,112.64) 188.05,112.82 U1.G43
  SIG9 w0.112: v4(187.6,112.34) 187.8,112.14 arc(187.91,111.98) 187.95,111.78 187.95,105.15 arc(187.93,105.07) 187.89,105.01 arc(187.86,104.97) 187.86,104.92
  SIG9 w0.16: YJ28.A15 179.7,60.95 arc(179.68,61.03) 179.64,61.09 179.15,61.58 arc(178.97,61.85) 178.91,62.16 178.91,62.48 arc(178.91,62.54) 178.89,62.6 arc(178.89,62.6) 178.89,62.6 arc(178.89,62.61) 178.89,62.62 arc(178.85,62.7) 178.79,62.77 178.75,62.82 178.66,62.9 arc(178.54,62.98) 178.39,63.01 177.01,63.01 arc(176.57,63.1) 176.2,63.35 175.68,63.88 arc(175.43,64.25) 175.34,64.69 175.34,70.4 arc(175.31,70.55) 175.23,70.67 173.88,72.02 arc(173.63,72.39) 173.55,72.83 173.55,87.82 arc(173.63,88.26) 173.88,88.63 175.08,89.83 arc(175.46,90.08) 175.89,90.17 177.42,90.17 arc(177.57,90.2) 177.69,90.28 178.21,90.8 arc(178.58,91.05) 179.02,91.14 183.34,91.14 arc(183.49,91.16) 183.61,91.25 187.74,95.38 arc(187.83,95.5) 187.86,95.65 187.86,104.92
FC29_RDN1: length 68.1
  TOP w0.147: U1.J42 188.55,114.34 v4(188.5,114.34)
  SIG9 w0.112: v4(188.5,114.34) 188.27,114.34 arc(188.23,114.33) 188.2,114.31 188.18,114.29 arc(188.15,114.25) 188.15,114.22 188.15,114.02 arc(188.18,113.95) 188.25,113.92 189.68,113.92 arc(189.86,113.88) 190.01,113.78 arc(190.12,113.63) 190.15,113.45 190.15,105.12 arc(190.17,105.05) 190.21,104.99 arc(190.23,104.95) 190.24,104.9
  SIG9 w0.16: YJ28.A25 180.65,65.97 arc(180.76,66.14) 180.8,66.34 180.8,66.52 arc(180.7,66.76) 180.46,66.86 179.56,66.86 arc(179.26,66.92) 179.02,67.08 178.89,67.22 arc(178.79,67.36) 178.75,67.54 178.75,68.04 178.98,68.27 178.98,68.88 178.75,69.11 178.75,70.29 arc(178.69,70.59) 178.53,70.83 176.23,73.13 arc(176.07,73.38) 176.01,73.67 176.01,85.96 arc(176.07,86.25) 176.23,86.5 177.18,87.45 arc(177.43,87.62) 177.72,87.68 183.9,87.68 arc(184.04,87.65) 184.17,87.57 184.26,87.48 arc(184.35,87.4) 184.46,87.34 184.86,87.18 arc(185,87.13) 185.15,87.12 186.98,87.12 arc(187.27,87.18) 187.52,87.34 188.05,87.88 arc(188.22,88.13) 188.28,88.42 188.28,91.88 arc(188.34,92.18) 188.5,92.42 191.99,95.91 arc(192.16,96.16) 192.21,96.45 192.21,101.69 arc(192.16,101.99) 191.99,102.23 190.47,103.76 arc(190.3,104) 190.24,104.3 190.24,104.9
FC29_RDN2: length 65.7
  TOP w0.147: U1.L43 188.05,116.73 arc(188.03,116.62) 187.97,116.53 187.9,116.47 arc(187.76,116.37) v4(187.6,116.34)
  SIG8 w0.112: v4(187.6,116.34) 187.85,116.34 arc(187.92,116.31) 187.95,116.24 187.95,116.01 arc(188.04,115.8) 188.25,115.72 189.7,115.72 arc(189.79,115.7) 189.87,115.64 arc(189.92,115.56) 189.94,115.47 189.94,105.17 189.85,105.08 189.85,105.05
  SIG8 w0.16: YJ28.A21 177.3,64.87 arc(177.27,65.02) 177.19,65.15 177.13,65.21 176.61,65.72 arc(176.54,65.83) 176.51,65.97 176.51,72.38 arc(176.45,72.68) 176.29,72.92 175.84,73.37 arc(175.67,73.62) 175.61,73.91 175.61,84.55 arc(175.7,84.99) 175.95,85.36 177.75,87.17 arc(178.12,87.41) 178.56,87.5 185.78,87.5 arc(186.07,87.56) 186.32,87.72 187.17,88.57 arc(187.33,88.82) 187.39,89.11 187.39,92.14 arc(187.45,92.43) 187.61,92.68 189.2,94.26 arc(189.36,94.51) 189.42,94.8 189.42,101.83 arc(189.51,102.25) 189.75,102.62 arc(189.82,102.73) 189.85,102.86 189.85,105.05
FC29_RDN3: length 70.2
  TOP w0.147: U1.N42 188.55,118.34 v4(188.5,118.34)
  SIG8 w0.112: v4(188.5,118.34) 188.25,118.34 arc(188.18,118.31) 188.15,118.24 188.15,118.01 arc(188.06,117.8) 187.85,117.72 187.3,117.72 arc(187.25,117.71) 187.21,117.68 187.19,117.66 arc(187.16,117.62) 187.15,117.57 187.15,112.15 arc(187.16,112.1) 187.19,112.06 187.28,111.97 arc(187.32,111.94) 187.37,111.93 187.76,111.93 arc(187.89,111.91) 187.99,111.84 188.05,111.77 arc(188.12,111.67) 188.15,111.54 188.15,105.22 188.24,105.13 188.24,105.1
  SIG8 w0.16: YJ28.A17 178.32,62.04 arc(178.38,62.13) 178.4,62.24 178.4,62.45 arc(178.38,62.56) 178.32,62.65 178.22,62.76 arc(178.1,62.83) 177.96,62.86 176.99,62.86 arc(176.85,62.89) 176.73,62.97 176.66,63.04 arc(176.66,63.04) 176.66,63.04 176.62,63.09 176.53,63.17 arc(176.28,63.34) 175.99,63.39 175.96,63.39 arc(175.7,63.5) 175.59,63.77 175.59,70.31 arc(175.5,70.75) 175.25,71.12 174.02,72.35 arc(173.94,72.47) 173.91,72.62 173.91,73.58 174.12,73.79 174.12,74.39 173.91,74.6 173.91,85.65 arc(173.97,85.94) 174.14,86.19 178.53,90.58 arc(178.78,90.74) 179.07,90.8 182.3,90.8 arc(182.74,90.89) 183.11,91.14 187.31,95.34 arc(187.56,95.71) 187.64,96.15 187.64,102.4 187.64,102.4 arc(187.7,102.69) 187.87,102.94 188.02,103.09 arc(188.18,103.34) 188.24,103.63 188.24,105.1
FC29_RDP0: length 66.2
  TOP w0.147: v4(188.5,112.34) 188.55,112.34 U1.G42
  SIG9 w0.112: v4(188.5,112.34) 188.29,112.14 arc(188.18,111.97) 188.14,111.78 188.14,105.15 arc(188.16,105.07) 188.2,105.01 arc(188.23,104.97) 188.24,104.92
  SIG9 w0.16: 188.24,104.92 188.24,95.65 arc(188.18,95.36) 188.01,95.11 183.88,90.98 arc(183.63,90.81) 183.34,90.75 179.02,90.75 arc(178.73,90.7) 178.48,90.53 177.96,90.01 arc(177.71,89.84) 177.42,89.79 175.89,89.79 arc(175.6,89.73) 175.35,89.56 174.15,88.36 arc(173.98,88.11) 173.93,87.82 173.93,72.83 arc(173.98,72.54) 174.15,72.29 175.5,70.94 arc(175.66,70.7) 175.72,70.4 175.72,68.2 175.95,67.97 175.95,67.41 175.72,67.18 175.72,64.69 175.72,64.69 arc(175.78,64.39) 175.94,64.15 176.47,63.62 arc(176.72,63.45) 177.01,63.39 178.39,63.39 arc(178.68,63.34) 178.93,63.17 arc(179.27,62.94) 179.68,62.86 180.46,62.86 arc(180.7,62.76) 180.8,62.52 180.8,62.34 arc(180.76,62.14) 180.65,61.97 YJ28.A14
FC29_RDP1: length 68
  TOP w0.147: U1.J43 188.05,114.82 arc(188.01,114.64) 187.91,114.48 187.83,114.4 arc(187.76,114.36) 187.68,114.34 v4(187.6,114.34)
  SIG9 w0.112: v4(187.6,114.34) 187.82,114.34 arc(187.87,114.33) 187.91,114.3 187.91,114.3 arc(187.94,114.26) 187.95,114.21 187.95,114.02 arc(188.04,113.81) 188.25,113.72 189.68,113.72 arc(189.79,113.7) 189.88,113.64 arc(189.93,113.55) 189.96,113.45 189.96,105.12 arc(189.94,105.05) 189.9,104.99 arc(189.87,104.95) 189.86,104.9
  SIG9 w0.16: 189.86,104.9 189.86,104.3 arc(189.95,103.86) 190.2,103.49 191.72,101.96 arc(191.8,101.84) 191.83,101.69 191.83,96.45 arc(191.8,96.31) 191.72,96.18 188.23,92.69 arc(187.98,92.32) 187.9,91.88 187.9,88.42 arc(187.87,88.27) 187.78,88.15 187.25,87.61 arc(187.12,87.53) 186.98,87.5 185.15,87.5 arc(185.08,87.51) 185.01,87.53 184.6,87.7 arc(184.56,87.72) 184.52,87.75 184.44,87.84 arc(184.19,88) 183.9,88.06 177.72,88.06 arc(177.28,87.97) 176.91,87.72 175.96,86.77 arc(175.71,86.4) 175.63,85.96 175.63,73.67 arc(175.71,73.23) 175.96,72.86 178.26,70.56 arc(178.34,70.44) 178.37,70.29 178.37,67.54 arc(178.44,67.22) 178.62,66.95 178.75,66.82 178.79,66.77 arc(178.85,66.69) 178.89,66.59 arc(178.91,66.54) 178.91,66.48 178.91,66.16 arc(178.97,65.85) 179.15,65.58 179.63,65.11 arc(179.68,65.03) 179.7,64.93 YJ28.A24
FC29_RDP2: length 65.7
  TOP w0.147: v4(188.5,116.34) 188.55,116.34 U1.L42
  SIG8 w0.112: 190.23,105.05 190.23,105.08 190.14,105.17 190.14,115.47 arc(190.11,115.64) 190.01,115.78 arc(189.87,115.88) 189.7,115.91 188.25,115.91 arc(188.18,115.94) 188.15,116.01 188.15,116.24 arc(188.18,116.31) 188.25,116.34 v4(188.5,116.34)
  SIG8 w0.16: 190.23,105.05 190.23,102.86 arc(190.18,102.58) 190.02,102.35 arc(189.86,102.11) 189.8,101.83 189.8,94.8 arc(189.71,94.36) 189.47,93.99 187.88,92.41 arc(187.8,92.28) 187.77,92.14 187.77,89.11 arc(187.68,88.67) 187.43,88.3 186.59,87.45 arc(186.22,87.21) 185.78,87.12 178.56,87.12 arc(178.27,87.06) 178.02,86.9 176.22,85.09 arc(176.05,84.84) 175.99,84.55 175.99,73.91 arc(176.02,73.77) 176.1,73.64 176.56,73.19 arc(176.8,72.82) 176.89,72.38 176.89,71.61 177.09,71.4 177.09,70.9 176.89,70.69 176.89,70.18 177.12,69.96 177.12,69.44 176.89,69.21 176.89,68.66 177.12,68.43 177.12,67.96 176.89,67.73 176.89,67.28 arc(177.01,66.98) 177.31,66.86 177.97,66.86 arc(178.09,66.84) 178.19,66.77 arc(178.3,66.6) 178.34,66.41 178.34,66.4 arc(178.28,66.09) YJ28.A22
FC29_RDP3: length 70.2
  TOP w0.147: U1.N43 188.05,118.73 arc(188.03,118.62) 187.97,118.53 187.9,118.47 arc(187.76,118.37) v4(187.6,118.34)
  SIG8 w0.112: 187.86,105.1 187.86,105.13 187.95,105.22 187.95,111.55 arc(187.94,111.59) 187.91,111.63 187.85,111.7 arc(187.81,111.72) 187.76,111.73 187.37,111.73 arc(187.24,111.76) 187.14,111.83 187.05,111.92 arc(186.98,112.02) 186.95,112.15 186.95,117.57 arc(186.98,117.69) 187.05,117.8 187.07,117.82 arc(187.17,117.89) 187.3,117.91 187.85,117.91 arc(187.92,117.94) 187.95,118.01 187.95,118.24 arc(187.92,118.31) 187.85,118.34 v4(187.6,118.34)
  SIG8 w0.16: 187.86,105.1 187.86,103.63 arc(187.83,103.48) 187.75,103.36 187.6,103.21 arc(187.35,102.84) 187.26,102.4 187.26,96.15 arc(187.2,95.86) 187.04,95.61 182.84,91.41 arc(182.59,91.24) 182.3,91.18 179.07,91.18 arc(178.63,91.1) 178.26,90.85 173.87,86.46 arc(173.62,86.08) 173.53,85.65 173.53,72.62 arc(173.59,72.32) 173.76,72.08 174.98,70.85 arc(175.15,70.6) 175.21,70.31 175.21,63.77 arc(175.43,63.24) 175.96,63.01 175.99,63.01 arc(176.14,62.98) 176.26,62.9 176.35,62.82 176.39,62.77 arc(176.48,62.64) 176.51,62.48 176.51,62.07 arc(176.56,61.84) 176.69,61.65 177.03,61.3 arc(177.23,61.01) 177.3,60.66 YJ28.A18
FC29_TDN0: length 50.1
  TOP w0.147: U1.E41 189.55,110.34 v4(189.5,110.34)
  SIG6 w0.112: v4(189.5,110.34) 189.3,110.34 arc(189.25,110.33) 189.21,110.3 189.18,110.28 arc(189.16,110.24) 189.15,110.19 189.15,110.04 arc(189.18,109.95) 189.27,109.91 189.77,109.91 arc(189.89,109.89) 189.99,109.82 190.05,109.76 arc(190.12,109.66) 190.14,109.54 190.14,105.14 190.23,105.05 190.23,105.03
  SIG6 w0.16: 190.23,105.03 190.23,104.75 arc(190.29,104.49) 190.43,104.27 191.99,102.71 arc(192.16,102.46) 192.21,102.17 192.21,73.34 arc(192.13,72.91) 191.88,72.54 189.99,70.65 189.99,70.45 189.55,70 189.34,70 189,69.66 arc(188.92,69.53) 188.89,69.39 188.89,68.68 189.11,68.46 189.11,67.98 188.89,67.76 188.89,67.06 arc(188.95,66.92) 189.09,66.86 190.06,66.86 arc(190.3,66.76) 190.4,66.52 190.4,66.34 arc(190.36,66.14) 190.25,65.97 YJ28.A37
FC29_TDN1: length 49.7
  TOP w0.147: U1.C42 189.05,108.79 arc(188.92,108.47) v4(188.6,108.34)
  SIG7 w0.112: v4(188.6,108.34) 188.82,108.34 arc(188.91,108.3) 188.95,108.21 188.95,108.04 arc(189.05,107.81) 189.27,107.72 189.75,107.72 arc(189.8,107.71) 189.84,107.68 189.9,107.62 arc(189.93,107.58) 189.93,107.53 189.93,106.32 arc(189.98,106.11) 190.1,105.92 arc(190.14,105.87) 190.15,105.8 190.15,105.53 190.06,105.43 190.06,105.41
  SIG7 w0.16: 190.06,105.41 190.06,105.23 arc(190.14,104.83) 190.36,104.49 191.6,103.25 arc(191.77,102.99) 191.83,102.69 191.83,80.96 arc(191.8,80.81) 191.72,80.69 189.77,78.74 arc(189.61,78.49) 189.55,78.2 189.55,75.37 arc(189.52,75.22) 189.44,75.1 185.45,71.11 arc(185.28,70.86) 185.22,70.57 185.22,68.24 arc(185.35,67.59) 185.72,67.04 185.95,66.82 185.99,66.77 arc(186.06,66.68) 186.1,66.58 arc(186.11,66.53) 186.11,66.48 186.11,66.16 arc(186.17,65.85) 186.35,65.58 186.69,65.24 arc(186.85,65.01) 186.9,64.74 YJ28.A33
FC29_TDN2: length 67.8
  TOP w0.147: U1.A41 189.55,106.34 v4(189.5,106.34)
  SIG7 w0.112: v4(189.5,106.34) 189.31,106.34 arc(189.2,106.29) 189.15,106.18 189.15,106.1 arc(189.03,105.82) 188.76,105.71 188.42,105.71 arc(188.35,105.7) 188.28,105.65 188.26,105.63 arc(188.22,105.57) 188.21,105.5 188.21,105.14 arc(188.22,105.09) 188.24,105.04 188.3,104.99 188.3,104.96
  SIG7 w0.16: YJ28.A2 190.25,61.97 arc(190.36,62.14) 190.4,62.34 190.4,62.52 arc(190.3,62.76) 190.06,62.86 189.16,62.86 arc(188.86,62.92) 188.62,63.08 188.53,63.17 arc(188.28,63.34) 187.99,63.39 176.69,63.39 arc(176.54,63.42) 176.42,63.51 175.83,64.09 arc(175.75,64.21) 175.72,64.36 175.72,66.13 arc(175.75,66.28) 175.83,66.4 177.77,68.34 arc(177.9,68.42) 178.04,68.45 179.83,68.45 arc(180.13,68.51) 180.37,68.67 181.93,70.23 182.06,70.23 182.54,70.72 182.54,70.84 182.87,71.17 183.02,71.17 183.48,71.63 183.48,71.78 187.55,75.85 arc(187.71,76.09) 187.77,76.39 187.77,90.01 arc(187.8,90.16) 187.88,90.28 189.58,91.98 arc(189.74,92.22) 189.8,92.52 189.8,102.33 arc(189.74,102.62) 189.58,102.87 188.41,104.04 arc(188.33,104.16) 188.3,104.31 188.3,104.96
FC29_TDN3: length 70.4
  TOP w0.147: U1.D44 187.05,109.79 arc(186.92,109.47) v4(186.6,109.34)
  SIG6 w0.112: v4(186.6,109.34) 186.82,109.34 arc(186.91,109.3) 186.95,109.21 186.95,109.04 arc(187.05,108.81) 187.27,108.72 187.77,108.72 arc(187.82,108.71) 187.86,108.68 187.91,108.63 arc(187.94,108.58) 187.95,108.54 187.95,105.19 187.86,105.1 187.86,105.08
  SIG6 w0.16: YJ28.A6 186.9,60.79 arc(186.86,61.02) 186.73,61.21 186.35,61.58 arc(186.17,61.85) 186.11,62.16 186.11,62.48 arc(186.11,62.53) 186.1,62.58 arc(186.1,62.59) 186.09,62.6 arc(186.05,62.7) 185.99,62.77 185.95,62.82 185.86,62.9 arc(185.74,62.98) 185.59,63.01 176.86,63.01 arc(176.57,63.07) 176.32,63.24 175.56,63.99 arc(175.4,64.24) 175.34,64.53 175.34,67.32 arc(175.38,67.51) 175.48,67.67 175.53,67.72 arc(175.6,67.83) 175.63,67.95 175.63,75.58 arc(175.69,75.87) 175.85,76.12 178.12,78.39 arc(178.36,78.55) 178.66,78.61 182.53,78.61 arc(182.82,78.67) 183.07,78.83 183.86,79.63 arc(184.03,79.88) 184.09,80.17 184.09,86.23 arc(184.14,86.52) 184.31,86.76 184.82,87.28 arc(185.07,87.44) 185.36,87.5 186.37,87.5 arc(186.51,87.53) 186.64,87.61 187.28,88.25 arc(187.36,88.38) 187.39,88.52 187.39,89.95 arc(187.48,90.39) 187.72,90.76 189.31,92.35 arc(189.39,92.47) 189.42,92.62 189.42,101.95 arc(189.39,102.09) 189.31,102.22 188.19,103.34 arc(187.94,103.71) 187.86,104.14 187.86,105.08
FC29_TDP0: length 50.1
  TOP w0.147: U1.E42 189.05,110.79 arc(188.92,110.47) v4(188.6,110.34)
  SIG6 w0.112: v4(188.6,110.34) 188.8,110.34 arc(188.85,110.33) 188.89,110.3 188.91,110.28 arc(188.94,110.24) 188.95,110.19 188.95,110.04 arc(189.05,109.81) 189.27,109.72 189.77,109.72 arc(189.81,109.71) 189.86,109.68 189.91,109.63 arc(189.94,109.58) 189.95,109.54 189.95,105.14 189.85,105.05 189.85,105.03
  SIG6 w0.16: YJ28.A36 189.3,64.92 arc(189.28,65.03) 189.22,65.12 189.15,65.19 188.75,65.58 arc(188.57,65.85) 188.51,66.16 188.51,69.39 arc(188.57,69.68) 188.73,69.93 191.61,72.8 arc(191.78,73.05) 191.83,73.34 191.83,102.17 arc(191.8,102.32) 191.72,102.44 190.16,104 arc(189.93,104.34) 189.85,104.75 189.85,105.03
FC29_TDP1: length 49.7
  TOP w0.147: v4(189.5,108.34) 189.55,108.34 U1.C41
  SIG7 w0.112: 190.44,105.41 190.44,105.43 190.35,105.52 190.35,105.8 arc(190.32,105.94) 190.24,106.06 arc(190.16,106.18) 190.13,106.32 190.13,107.53 arc(190.11,107.65) 190.04,107.76 189.98,107.82 arc(189.87,107.89) 189.75,107.91 189.27,107.91 arc(189.18,107.95) 189.15,108.04 189.15,108.21 arc(189.18,108.3) 189.27,108.34 v4(189.5,108.34)
  SIG7 w0.16: 190.44,105.41 190.44,105.23 arc(190.49,104.98) 190.63,104.76 191.87,103.52 arc(192.12,103.14) 192.21,102.69 192.21,80.96 arc(192.16,80.67) 191.99,80.42 190.04,78.47 arc(189.96,78.34) 189.93,78.2 189.93,75.37 arc(189.87,75.08) 189.71,74.83 186.78,71.91 186.78,71.75 186.32,71.29 186.17,71.29 185.72,70.84 arc(185.63,70.72) 185.6,70.57 185.6,69.77 185.69,69.69 185.69,68.99 185.6,68.91 185.6,68.24 arc(185.7,67.74) 185.99,67.31 186.22,67.08 arc(186.46,66.92) 186.76,66.86 187.66,66.86 arc(187.9,66.76) 188,66.52 188,66.34 arc(187.96,66.14) 187.85,65.97 YJ28.A34
FC29_TDP2: length 67.8
  TOP w0.147: U1.A42 189.05,106.79 arc(188.92,106.47) v4(188.6,106.34)
  SIG7 w0.112: 187.92,104.96 187.92,104.99 188.01,105.08 188.01,105.5 arc(188.04,105.65) 188.12,105.77 188.14,105.79 arc(188.27,105.88) 188.42,105.91 188.76,105.91 arc(188.89,105.96) 188.95,106.1 188.95,106.18 arc(188.9,106.29) 188.79,106.34 v4(188.6,106.34)
  SIG7 w0.16: 187.92,104.96 187.92,104.31 arc(187.98,104.01) 188.14,103.77 189.31,102.6 arc(189.39,102.47) 189.42,102.33 189.42,92.52 arc(189.39,92.37) 189.31,92.25 187.61,90.55 arc(187.45,90.3) 187.39,90.01 187.39,76.39 arc(187.36,76.24) 187.28,76.12 180.1,68.94 arc(179.98,68.86) 179.83,68.83 178.04,68.83 arc(177.75,68.77) 177.5,68.61 175.56,66.67 arc(175.4,66.42) 175.34,66.13 175.34,64.36 arc(175.4,64.07) 175.56,63.82 176.15,63.24 arc(176.4,63.07) 176.69,63.01 187.99,63.01 arc(188.14,62.98) 188.26,62.9 188.35,62.82 188.39,62.77 arc(188.46,62.69) 188.5,62.58 arc(188.51,62.53) 188.51,62.48 188.51,62.16 arc(188.57,61.85) 188.75,61.58 189.14,61.2 arc(189.26,61.02) 189.3,60.8 YJ28.A3
FC29_TDP3: length 70.4
  TOP w0.147: U1.D43 187.55,109.34 v4(187.5,109.34)
  SIG6 w0.112: 188.24,105.08 188.24,105.1 188.14,105.19 188.14,108.54 arc(188.12,108.66) 188.05,108.76 188,108.82 arc(187.89,108.89) 187.77,108.91 187.27,108.91 arc(187.18,108.95) 187.15,109.04 187.15,109.21 arc(187.18,109.3) 187.27,109.34 v4(187.5,109.34)
  SIG6 w0.16: 188.24,105.08 188.24,104.14 arc(188.3,103.85) 188.46,103.6 189.58,102.49 arc(189.74,102.24) 189.8,101.95 189.8,92.62 arc(189.74,92.33) 189.58,92.08 187.99,90.49 arc(187.83,90.25) 187.77,89.95 187.77,88.52 arc(187.71,88.23) 187.55,87.98 186.91,87.34 arc(186.66,87.18) 186.37,87.12 185.36,87.12 arc(185.22,87.09) 185.09,87.01 184.58,86.49 arc(184.5,86.37) 184.47,86.23 184.47,80.17 arc(184.38,79.73) 184.13,79.36 183.33,78.56 arc(182.96,78.32) 182.53,78.23 178.66,78.23 arc(178.51,78.2) 178.39,78.12 176.12,75.85 arc(176.04,75.73) 176.01,75.58 176.01,69.35 176.23,69.13 176.23,68.65 176.01,68.43 176.01,67.95 arc(175.96,67.68) 175.8,67.45 175.75,67.4 arc(175.73,67.37) 175.72,67.32 175.72,64.53 arc(175.75,64.39) 175.83,64.26 176.59,63.51 arc(176.71,63.42) 176.86,63.39 185.59,63.39 arc(185.88,63.34) 186.13,63.17 arc(186.47,62.94) 186.88,62.86 187.66,62.86 arc(187.9,62.76) 188,62.52 188,62.34 arc(187.96,62.14) 187.85,61.97 YJ28.A5
FC30_31_PVDD0P8: length 5.7
  TOP w0.229: U1.Y39 v1(191.55,125.34) ; U1.Y36 v1(194.55,125.34)
  TOP w0.381: C2727.1 185.2,101.83 ; C2727.1 185.2,100.48 ; C2727.1 185.99,101.22
  BOTTOM w0.13: v1(186.37,100.71) v2(187.13,100.71)
  BOTTOM w0.381: v1(194.55,125.34) 195.03,125.83 C3332.1 ; v1(191.55,125.34) 191.07,124.86 C2682.1
  vias: v1(186.37,101.72)
FC30_RDN0: length 52.4
  TOP w0.147: v4(190.6,113.34) 190.67,113.34 arc(190.74,113.36) 190.8,113.39 190.91,113.51 arc(191.01,113.66) U1.H40
  SIG3 w0.112: 189.86,105.04 189.86,105.06 189.95,105.15 189.95,112.48 arc(189.98,112.61) 190.05,112.71 190.15,112.82 arc(190.26,112.89) 190.38,112.91 190.82,112.91 arc(190.91,112.95) 190.95,113.04 190.95,113.21 arc(190.91,113.3) 190.82,113.34 v4(190.6,113.34)
  SIG3 w0.16: 189.86,105.04 189.86,103.97 189.47,103.58 189.47,97 189.47,97 189.47,92.41 arc(189.44,92.26) 189.36,92.14 188.28,91.06 arc(188.03,90.68) 187.94,90.25 187.94,73.3 arc(188.03,72.87) 188.28,72.49 188.82,71.95 arc(188.9,71.83) 188.93,71.68 188.93,69.47 188.65,69.19 188.65,68.73 188.93,68.45 188.93,67.86 arc(188.9,67.71) 188.82,67.59 188.68,67.45 188.31,67.08 arc(188.07,66.92) 187.78,66.86 186.95,66.86 arc(186.71,66.76) 186.61,66.52 186.61,66.32 arc(186.64,66.13) 186.75,65.97 YJ27.C25
FC30_RDN1: length 57.5
  TOP w0.147: v4(191.5,115.34) 191.55,115.34 U1.K39
  SIG3 w0.112: 192.24,105.04 192.14,105.13 192.14,114.5 arc(192.12,114.62) 192.05,114.73 191.95,114.83 arc(191.84,114.9) 191.72,114.93 191.27,114.93 arc(191.18,114.96) 191.15,115.05 191.15,115.21 arc(191.18,115.3) 191.27,115.34 v4(191.5,115.34)
  SIG3 w0.16: YJ27.C18 190.1,60.75 arc(190.15,61.01) 190.3,61.24 190.74,61.67 arc(190.86,61.86) 190.91,62.08 190.91,62.57 arc(190.94,62.72) 191.02,62.85 191.91,63.73 arc(192.16,64.11) 192.24,64.54 192.24,105.04
FC30_RDN2: length 59.9
  TOP w0.147: v4(190.6,117.34) 190.67,117.34 arc(190.73,117.35) 190.79,117.39 190.97,117.58 arc(191.03,117.66) 191.05,117.76 U1.M40
  SIG2 w0.112: v4(190.6,117.34) 190.82,117.34 arc(190.91,117.3) 190.95,117.21 190.95,117.04 arc(190.91,116.95) 190.82,116.91 190.37,116.91 arc(190.24,116.89) 190.14,116.82 190.04,116.72 arc(189.97,116.62) 189.95,116.49 189.95,105.17 189.86,105.08 189.86,105.05
  SIG2 w0.16: YJ27.C22 189.15,65.97 arc(189.04,66.13) 189.01,66.32 189.01,66.54 arc(189.1,66.77) 189.33,66.86 190.2,66.86 arc(190.32,66.88) 190.42,66.95 arc(190.42,66.95) 190.43,66.96 arc(190.5,67.06) 190.53,67.19 arc(190.47,67.45) 190.32,67.67 189.58,68.42 189.29,68.42 188.86,68.86 188.86,69.14 188.5,69.5 188.19,69.5 187.78,69.91 187.78,70.22 185.42,72.58 184.4,73.6 arc(184.13,74) 184.04,74.48 184.04,89.8 arc(184.12,90.24) 184.37,90.61 189.36,95.6 arc(189.44,95.72) 189.47,95.87 189.47,103.03 arc(189.48,103.16) 189.5,103.29 arc(189.61,103.54) 189.78,103.76 arc(189.83,103.85) 189.86,103.95 189.86,105.05
FC30_RDN3: length 68.4
  TOP w0.147: U1.P39 191.55,119.34 v4(191.5,119.34)
  SIG2 w0.112: v4(191.5,119.34) 191.27,119.34 arc(191.18,119.3) 191.15,119.21 191.15,119.05 arc(191.18,118.96) 191.27,118.92 191.73,118.92 arc(191.85,118.9) 191.95,118.83 192.05,118.73 arc(192.12,118.63) 192.14,118.51 192.14,105.17 192.24,105.08 192.24,105.05
  SIG2 w0.16: YJ27.C15 187.7,60.79 arc(187.74,61.02) 187.87,61.21 188.34,61.67 arc(188.46,61.86) 188.51,62.08 188.51,62.57 arc(188.54,62.72) 188.63,62.86 188.68,62.91 arc(188.73,62.95) 188.78,62.98 arc(188.86,63.01) 188.95,63.03 191.17,63.03 arc(191.61,63.11) 191.98,63.36 192.75,64.13 arc(193,64.5) 193.08,64.94 193.08,68.03 arc(193,68.47) 192.75,68.84 187.88,73.7 arc(187.8,73.83) 187.77,73.97 187.77,90.11 arc(187.83,90.4) 187.99,90.64 192.01,94.67 arc(192.18,94.91) 192.24,95.2 192.24,105.05
