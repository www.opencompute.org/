# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC55_TDP1: length 192.6
  TOP w0.147: U1.BN2 229.55,159.34 v4(229.55,159.39)
  SIG5 w0.112: 231.84,160.65 231.81,160.65 231.72,160.75 230.39,160.75 arc(230.31,160.73) 230.24,160.69 arc(230.2,160.62) 230.18,160.54 230.18,160.11 arc(230.15,159.97) 230.08,159.85 230.07,159.84 arc(229.96,159.77) 229.84,159.74 229.68,159.74 arc(229.59,159.71) 229.55,159.62 v4(229.55,159.39)
  SIG5 w0.16: YJ33.D2 318.15,53.97 arc(318.04,54.13) 318.01,54.32 318.01,54.56 arc(318.1,54.77) 318.31,54.86 319.18,54.86 arc(319.47,54.92) 319.72,55.08 319.76,55.13 319.81,55.18 arc(320.06,55.35) 320.35,55.41 331.89,55.41 arc(332.04,55.44) 332.16,55.52 334.19,57.55 334.19,57.76 334.73,58.3 334.94,58.3 335.48,58.84 335.48,59.06 336.02,59.6 336.24,59.6 337.05,60.41 arc(337.13,60.53) 337.16,60.68 337.16,67.49 arc(337.13,67.64) 337.05,67.76 336.66,68.15 336.64,68.15 334.59,70.2 arc(334.34,70.57) 334.25,71.01 334.25,93.61 arc(334.19,93.9) 334.03,94.15 303.56,124.62 arc(303.32,124.78) 303.02,124.84 282.57,124.84 arc(282.28,124.9) 282.03,125.06 245.65,161.45 arc(245.4,161.61) 245.11,161.67 243.11,161.67 242.96,161.52 242.19,161.52 242.04,161.67 241.28,161.67 241.13,161.52 240.36,161.52 240.21,161.67 239.45,161.67 239.32,161.54 238.51,161.54 238.38,161.67 237.62,161.67 237.49,161.54 236.68,161.54 236.55,161.67 235.79,161.67 235.67,161.54 234.85,161.54 234.73,161.67 233.96,161.67 arc(233.67,161.61) 233.42,161.45 232.97,160.99 arc(232.6,160.74) 232.16,160.65 231.84,160.65
FC55_TDP2: length 182
  TOP w0.147: U1.BP4 227.07,159.84 arc(227.26,159.88) 227.41,159.98 227.49,160.06 arc(227.53,160.13) 227.55,160.21 v4(227.55,160.29)
  SIG4 w0.112: 232.22,159.03 232.19,159.03 232.1,158.94 228.46,158.94 arc(228.35,158.96) 228.26,159.02 arc(228.2,159.11) 228.18,159.21 228.18,159.59 arc(228.16,159.72) 228.08,159.84 228.08,159.84 arc(227.97,159.91) 227.83,159.94 227.68,159.94 arc(227.59,159.98) 227.55,160.07 v4(227.55,160.29)
  SIG4 w0.16: YJ33.D33 321.5,56.8 arc(321.54,57.02) 321.66,57.2 322.21,57.75 arc(322.28,57.85) 322.31,57.97 322.31,58.57 arc(322.31,58.6) 322.31,58.64 arc(322.31,58.64) 322.32,58.65 arc(322.36,58.76) 322.43,58.86 322.46,58.89 322.48,58.91 arc(322.61,59) 322.75,59.03 332.26,59.03 arc(332.56,59.08) 332.8,59.25 335.63,62.07 arc(335.79,62.32) 335.85,62.61 335.85,70.42 arc(335.79,70.71) 335.63,70.96 334.86,71.73 arc(334.69,71.98) 334.63,72.27 334.63,90.64 arc(334.57,90.93) 334.41,91.18 307.76,117.83 305.18,120.41 arc(299.85,123.97) 293.56,125.22 292.77,125.22 arc(280.43,127.67) 269.98,134.66 245.29,159.35 arc(245.04,159.52) 244.75,159.57 234.28,159.57 arc(233.98,159.52) 233.74,159.35 233.64,159.25 arc(233.39,159.09) 233.1,159.03 232.22,159.03
FC55_TDP3: length 182.7
  TOP w0.147: v4(230.55,157.39) 230.55,157.34 U1.BL1
  SIG5 w0.112: v4(230.55,157.39) 230.55,157.62 arc(230.59,157.71) 230.68,157.74 230.84,157.74 arc(230.96,157.77) 231.07,157.84 231.08,157.85 arc(231.15,157.97) 231.18,158.11 231.18,158.54 arc(231.2,158.62) 231.24,158.69 arc(231.31,158.73) 231.39,158.75 232.35,158.75 232.44,158.65 232.47,158.65
  SIG5 w0.16: 232.47,158.65 232.85,158.65 arc(233.14,158.71) 233.39,158.88 233.48,158.97 arc(233.73,159.14) 234.02,159.19 244.56,159.19 arc(244.86,159.14) 245.1,158.97 281.17,122.9 arc(281.42,122.74) 281.71,122.68 302.06,122.68 arc(302.35,122.62) 302.6,122.46 331.95,93.11 arc(332.11,92.86) 332.17,92.57 332.17,72.89 331.94,72.66 331.94,72.2 332.17,71.98 332.17,71.52 331.94,71.29 331.94,70.83 332.17,70.6 332.17,70.15 arc(332.26,69.71) 332.5,69.34 333.83,68.01 333.86,68.01 334.89,66.98 arc(334.97,66.85) 335,66.71 335,62.58 arc(334.97,62.44) 334.89,62.31 334.04,61.46 333.66,61.46 333.39,61.19 333.39,60.81 333.07,60.49 332.72,60.49 332.42,60.19 332.42,59.84 332.1,59.52 arc(331.97,59.44) 331.83,59.41 320.35,59.41 arc(320.06,59.35) 319.81,59.18 319.76,59.13 319.72,59.08 arc(319.47,58.92) 319.18,58.86 318.28,58.86 arc(318.09,58.78) 318.01,58.59 318.01,58.32 arc(318.04,58.13) 318.15,57.97 YJ33.D37
FC56_57_PVDD0P8: length 5.5
  TOP w0.229: U1.BG19 v1(212.55,153.34) ; U1.BG18 213.05,152.91 213.48,153.34 v1(213.55,153.34)
  TOP w0.381: C349.1 215.42,193.39 ; C349.1 214.22,193.39 ; C349.1 214.82,194.03
  BOTTOM w0.13: v1(208.22,177.67) v2(208.98,177.67)
  BOTTOM w0.381: v1(212.55,153.34) 213.05,152.85 C3346.1 ; v1(213.55,153.34) 213.1,153.79 C350.1
  vias: v1(207.53,177.04)
FC56_RDN0: length 195.8
  TOP w0.147: U1.BT14 217.55,162.34 v4(217.55,162.39)
  SIG8 w0.112: 231.96,164.65 231.94,164.65 231.84,164.74 224.41,164.74 arc(224.31,164.72) 224.22,164.67 arc(224.17,164.58) 224.15,164.48 224.15,164.23 arc(224.11,164.04) 224.01,163.88 arc(223.85,163.78) 223.67,163.74 218.54,163.74 arc(218.4,163.72) 218.29,163.64 218.25,163.61 arc(218.2,163.53) 218.18,163.43 218.18,163.06 arc(218.16,162.94) 218.09,162.84 arc(217.99,162.77) 217.87,162.74 217.65,162.74 arc(217.58,162.71) 217.55,162.64 v4(217.55,162.39)
  SIG8 w0.16: YJ36.D24 348.7,56.61 arc(348.62,57) 348.4,57.34 348.14,57.59 arc(347.97,57.85) 347.91,58.15 347.91,58.42 arc(347.9,58.53) 347.87,58.63 arc(347.82,58.73) 347.75,58.82 347.66,58.9 arc(347.54,58.98) 347.39,59.01 345.5,59.01 arc(345.06,59.1) 344.69,59.35 342.35,61.69 arc(342.1,62.06) 342.02,62.5 342.02,63.52 341.84,63.7 341.84,64.36 342.02,64.54 342.02,65.05 341.84,65.22 341.84,65.89 342.02,66.06 342.02,66.57 341.84,66.75 341.84,67.41 342.02,67.59 342.02,87.29 arc(341.92,87.77) 341.65,88.18 341.41,88.42 arc(341.13,88.84) 341.03,89.32 341.03,89.98 arc(340.98,90.27) 340.81,90.52 306.71,124.62 arc(306.47,124.78) 306.17,124.84 287.27,124.84 arc(286.98,124.9) 286.73,125.06 246.67,165.13 arc(246.42,165.29) 246.13,165.35 233.73,165.35 arc(233.44,165.29) 233.19,165.13 232.94,164.87 arc(232.9,164.84) 232.85,164.8 arc(232.64,164.69) 232.4,164.65 231.96,164.65
FC56_RDN1: length 185.6
  TOP w0.147: U1.BU10 221.16,162.84 arc(221.27,162.86) 221.35,162.92 221.43,162.99 arc(221.52,163.13) v4(221.55,163.29)
  SIG9 w0.112: v4(221.55,163.29) 221.55,163.04 arc(221.58,162.97) 221.65,162.94 221.87,162.94 arc(221.91,162.95) 221.95,162.97 arc(221.98,163.01) 221.99,163.06 221.99,163.44 arc(222.02,163.6) 222.12,163.75 222.15,163.78 arc(222.33,163.9) 222.54,163.94 223.62,163.94 arc(223.75,163.97) 223.85,164.04 arc(223.92,164.15) 223.95,164.27 223.95,164.53 arc(223.98,164.69) 224.07,164.82 arc(224.2,164.91) 224.36,164.94 231.71,164.94 arc(231.83,164.96) 231.94,165.03
  SIG9 w0.16: 231.94,165.03 232.35,165.03 arc(232.48,165.06) 232.6,165.13 arc(232.61,165.14) 232.62,165.14 arc(232.99,165.39) 233.42,165.48 250.86,165.48 arc(251.15,165.42) 251.4,165.26 291.21,125.44 arc(291.46,125.28) 291.75,125.22 299.93,125.22 arc(300.36,125.13) 300.73,124.88 334.3,91.32 arc(334.55,90.95) 334.63,90.51 334.63,70.39 arc(334.69,70.09) 334.86,69.85 343.37,61.34 345.62,59.08 arc(345.86,58.92) 346.16,58.86 347.06,58.86 arc(347.3,58.76) 347.4,58.52 347.4,58.34 arc(347.36,58.14) 347.25,57.97 YJ36.D22
FC56_RDN2: length 194.4
  TOP w0.147: v4(219.55,162.39) 219.55,162.34 U1.BT12
  SIG8 w0.112: v4(219.55,162.39) 219.55,162.64 arc(219.58,162.71) 219.65,162.74 219.87,162.74 arc(219.91,162.73) 219.95,162.71 arc(219.98,162.67) 219.99,162.63 219.99,162.25 arc(220.02,162.08) 220.12,161.94 220.15,161.91 arc(220.33,161.79) 220.54,161.74 224.65,161.74 arc(224.84,161.78) 225,161.89 arc(225.11,162.05) 225.15,162.24 225.15,162.44 arc(225.17,162.55) 225.23,162.64 225.24,162.65 arc(225.34,162.72) 225.46,162.74 231.97,162.74 232.06,162.65 232.09,162.65
  SIG8 w0.16: YJ36.D15 348.7,52.68 arc(348.63,53.01) 348.45,53.29 348.11,53.63 arc(347.96,53.84) 347.91,54.1 347.91,54.48 arc(347.91,54.54) 347.89,54.61 arc(347.85,54.7) 347.79,54.77 347.75,54.81 347.75,54.82 347.66,54.9 arc(347.54,54.98) 347.39,55.01 345.72,55.01 arc(345.28,55.1) 344.91,55.35 340.19,60.06 arc(339.95,60.44) 339.86,60.87 339.86,76.27 339.6,76.53 339.6,77.04 339.86,77.29 339.86,77.8 339.6,78.05 339.6,78.56 339.86,78.81 339.86,83.97 arc(339.83,84.11) 339.75,84.23 336.69,87.29 arc(336.45,87.66) 336.36,88.1 336.36,91.5 arc(336.3,91.79) 336.14,92.04 305.72,122.46 arc(305.47,122.62) 305.18,122.68 284.73,122.68 arc(284.44,122.74) 284.19,122.9 246.03,161.06 arc(245.78,161.23) 245.49,161.29 234.47,161.29 arc(234.03,161.37) 233.66,161.62 232.74,162.54 arc(232.7,162.57) 232.66,162.6 arc(232.57,162.64) 232.47,162.65 232.09,162.65
FC56_RDN3: length 181.4
  TOP w0.147: U1.BU8 223.16,162.84 arc(223.27,162.86) 223.35,162.92 223.43,162.99 arc(223.52,163.13) v4(223.55,163.29)
  SIG9 w0.112: v4(223.55,163.29) 223.68,163.16 arc(223.92,163) 224.22,162.94 231.71,162.94 arc(231.83,162.96) 231.94,163.03
  SIG9 w0.16: YJ36.D17 347.25,53.97 arc(347.36,54.14) 347.4,54.34 347.4,54.52 arc(347.3,54.76) 347.06,54.86 346.05,54.86 arc(345.86,54.9) 345.69,55.01 345.2,55.51 329.98,70.72 arc(329.81,70.97) 329.76,71.26 329.76,89.45 arc(329.67,89.88) 329.42,90.25 296.95,122.73 arc(296.58,122.97) 296.14,123.06 289.43,123.06 arc(289.29,123.09) 289.16,123.17 253.81,158.52 251,161.33 arc(250.63,161.58) 250.19,161.67 234.31,161.67 arc(234.17,161.7) 234.04,161.78 233.13,162.7 arc(233.13,162.7) 233.12,162.7 arc(232.75,162.95) 232.32,163.03 231.94,163.03
FC56_RDP0: length 195.8
  TOP w0.147: U1.BU14 217.07,162.84 arc(217.25,162.88) 217.41,162.98 217.49,163.06 arc(217.53,163.13) 217.55,163.21 v4(217.55,163.29)
  SIG8 w0.112: v4(217.55,163.29) 217.55,163.04 arc(217.58,162.97) 217.65,162.94 217.87,162.94 arc(217.91,162.95) 217.95,162.97 arc(217.98,163.01) 217.99,163.06 217.99,163.43 arc(218.02,163.6) 218.12,163.75 218.15,163.78 arc(218.33,163.9) 218.54,163.94 223.67,163.94 arc(223.77,163.96) 223.87,164.02 arc(223.93,164.12) 223.95,164.23 223.95,164.48 arc(223.99,164.66) 224.09,164.81 arc(224.23,164.91) 224.41,164.94 231.84,164.94 231.94,165.03 231.96,165.03
  SIG8 w0.16: 231.96,165.03 232.4,165.03 arc(232.52,165.05) 232.63,165.11 arc(232.65,165.13) 232.67,165.14 232.73,165.2 232.79,165.27 232.92,165.4 arc(233.29,165.65) 233.73,165.73 246.13,165.73 arc(246.57,165.65) 246.94,165.4 287,125.33 arc(287.13,125.25) 287.27,125.22 306.17,125.22 arc(306.61,125.13) 306.98,124.88 341.08,90.79 arc(341.33,90.42) 341.41,89.98 341.41,89.32 arc(341.48,88.98) 341.67,88.69 341.92,88.45 arc(342.27,87.92) 342.4,87.29 342.4,62.5 arc(342.46,62.21) 342.62,61.96 344.96,59.62 arc(345.21,59.45) 345.5,59.39 347.39,59.39 arc(347.68,59.34) 347.93,59.17 348.11,58.99 arc(348.22,58.91) 348.35,58.87 arc(348.39,58.86) 348.42,58.86 349.3,58.86 arc(349.53,58.82) 349.72,58.69 arc(349.8,58.57) 349.83,58.43 349.83,58.39 arc(349.78,58.17) 349.65,57.97 YJ36.D25
FC56_RDP1: length 185.6
  TOP w0.147: U1.BT10 221.55,162.34 v4(221.55,162.39)
  SIG9 w0.112: v4(221.55,162.39) 221.55,162.64 arc(221.58,162.71) 221.65,162.74 221.87,162.74 arc(221.99,162.77) 222.09,162.84 arc(222.16,162.94) 222.18,163.06 222.18,163.44 arc(222.2,163.53) 222.25,163.61 222.29,163.64 arc(222.4,163.72) 222.54,163.75 223.62,163.75 arc(223.82,163.79) 223.99,163.9 arc(224.11,164.07) 224.15,164.27 224.15,164.53 arc(224.16,164.61) 224.21,164.68 arc(224.28,164.73) 224.36,164.74 231.71,164.74 arc(231.83,164.72) 231.94,164.65
  SIG9 w0.16: 231.94,164.65 232.35,164.65 arc(232.62,164.7) 232.85,164.85 arc(232.87,164.86) 232.89,164.87 arc(233.13,165.04) 233.42,165.1 250.86,165.1 arc(251,165.07) 251.13,164.99 290.94,125.17 arc(291.31,124.93) 291.75,124.84 299.93,124.84 arc(300.22,124.78) 300.46,124.62 334.03,91.05 arc(334.19,90.8) 334.25,90.51 334.25,70.39 arc(334.34,69.95) 334.59,69.58 342.92,61.25 342.92,60.89 343.28,60.53 343.64,60.53 344,60.17 344,59.81 344.35,59.45 344.71,59.45 345.35,58.82 345.39,58.77 arc(345.45,58.69) 345.49,58.59 arc(345.51,58.54) 345.51,58.48 345.51,58.07 arc(345.56,57.84) 345.69,57.65 346.15,57.18 arc(346.26,57.02) 346.3,56.83 YJ36.D21
FC56_RDP2: length 194.4
  TOP w0.147: v4(219.55,163.29) 219.55,163.21 arc(219.53,163.13) 219.49,163.06 219.41,162.98 arc(219.25,162.88) 219.07,162.84 U1.BU12
  SIG8 w0.112: 232.09,163.03 232.06,163.03 231.97,162.94 225.46,162.94 arc(225.27,162.9) 225.1,162.79 225.09,162.78 arc(224.99,162.62) 224.95,162.44 224.95,162.24 arc(224.93,162.13) 224.86,162.03 arc(224.76,161.96) 224.65,161.94 220.54,161.94 arc(220.4,161.97) 220.29,162.05 220.25,162.08 arc(220.2,162.16) 220.18,162.25 220.18,162.63 arc(220.16,162.75) 220.09,162.85 arc(219.99,162.92) 219.87,162.94 219.65,162.94 arc(219.58,162.97) 219.55,163.04 v4(219.55,163.29)
  SIG8 w0.16: YJ36.D14 349.65,53.97 arc(349.76,54.14) 349.8,54.34 349.8,54.45 arc(349.77,54.61) 349.68,54.75 349.68,54.75 arc(349.55,54.83) 349.4,54.86 348.42,54.86 arc(348.25,54.89) 348.11,54.99 347.93,55.17 arc(347.68,55.34) 347.39,55.39 345.72,55.39 arc(345.43,55.45) 345.18,55.62 340.46,60.33 arc(340.3,60.58) 340.24,60.87 340.24,83.97 arc(340.18,84.26) 340.02,84.5 336.96,87.56 arc(336.8,87.8) 336.74,88.1 336.74,88.1 336.74,91.5 arc(336.65,91.94) 336.41,92.31 305.99,122.73 arc(305.62,122.97) 305.18,123.06 284.73,123.06 arc(284.59,123.09) 284.46,123.17 246.3,161.33 arc(245.93,161.58) 245.49,161.67 234.47,161.67 arc(234.17,161.73) 233.93,161.89 233.01,162.81 arc(232.94,162.87) 232.85,162.93 arc(232.67,163.01) 232.47,163.03 232.09,163.03
FC56_RDP3: length 181.4
  TOP w0.147: v4(223.55,162.39) 223.55,162.34 U1.BT8
  SIG9 w0.112: v4(223.55,162.39) 223.68,162.52 arc(223.92,162.69) 224.22,162.74 231.71,162.74 arc(231.83,162.72) 231.94,162.65
  SIG9 w0.16: 231.94,162.65 232.32,162.65 arc(232.61,162.59) 232.85,162.43 arc(232.86,162.43) 232.86,162.43 233.77,161.51 arc(234.02,161.35) 234.31,161.29 250.19,161.29 arc(250.48,161.23) 250.73,161.06 253.81,157.99 269.81,141.98 288.89,122.9 arc(289.14,122.74) 289.43,122.68 296.14,122.68 arc(296.43,122.62) 296.68,122.46 329.15,89.98 arc(329.32,89.74) 329.37,89.45 329.37,89.45 329.37,71.26 arc(329.46,70.82) 329.71,70.45 342.51,57.66 342.51,57.3 342.86,56.94 343.22,56.94 343.58,56.58 343.58,56.22 343.94,55.86 344.3,55.86 345.35,54.82 345.39,54.77 arc(345.45,54.7) 345.49,54.61 arc(345.49,54.6) 345.49,54.6 arc(345.51,54.54) 345.51,54.48 345.51,54.07 arc(345.56,53.84) 345.69,53.65 346.18,53.16 arc(346.27,53.02) 346.3,52.86 YJ36.D18
FC56_TDN0: length 189.7
  TOP w0.147: U1.BV2 229.1,163.84 arc(229.42,163.97) v4(229.55,164.29)
  SIG7 w0.112: v4(229.55,164.29) 229.55,164.1 arc(229.6,163.99) 229.71,163.94 229.83,163.94 arc(229.96,163.92) 230.07,163.84 230.08,163.83 arc(230.15,163.72) 230.18,163.58 230.18,163.14 arc(230.2,163.06) 230.24,163 arc(230.31,162.95) 230.39,162.94 232.04,162.94 232.13,163.03 232.16,163.03
  SIG7 w0.16: YJ36.D37 359.25,57.97 arc(359.36,58.14) 359.4,58.34 359.4,58.52 arc(359.3,58.76) 359.06,58.86 358.16,58.86 arc(357.86,58.92) 357.62,59.08 357.53,59.17 arc(357.28,59.34) 356.99,59.39 345.2,59.39 arc(344.91,59.45) 344.66,59.62 334.86,69.42 arc(334.69,69.67) 334.63,69.96 334.63,93.05 arc(334.45,93.98) 333.92,94.76 299.86,128.83 arc(299.07,129.35) 298.14,129.54 282.95,129.54 arc(282.81,129.57) 282.68,129.65 250.89,161.45 arc(250.64,161.61) 250.35,161.67 235.84,161.67 arc(235.69,161.7) 235.57,161.78 234.54,162.81 arc(234.29,162.97) 234,163.03 232.16,163.03
FC56_TDN1: length 189
  TOP w0.147: v4(227.55,163.39) 227.55,163.34 U1.BU4
  SIG6 w0.112: 232.22,162.65 232.19,162.65 232.1,162.74 228.39,162.74 arc(228.23,162.77) 228.1,162.86 arc(228.02,162.99) 227.99,163.14 227.99,163.58 arc(227.97,163.64) 227.94,163.69 227.93,163.71 arc(227.88,163.73) 227.84,163.74 227.68,163.74 arc(227.59,163.71) 227.55,163.62 v4(227.55,163.39)
  SIG6 w0.155: 355.13,57.94 arc(355.11,58) 355.11,58.07
  SIG6 w0.16: YJ36.D33 355.9,56.74 arc(355.85,57.01) 355.69,57.24 355.29,57.64 arc(355.19,57.78) 355.13,57.94 ; 232.22,162.65 233.46,162.65 arc(233.61,162.62) 233.73,162.54 234.65,161.62 arc(235.02,161.37) 235.46,161.29 250.35,161.29 arc(250.5,161.26) 250.62,161.18 282.3,129.49 arc(282.67,129.24) 283.11,129.16 298.94,129.16 arc(299.09,129.13) 299.21,129.04 336.25,92.01 arc(336.33,91.88) 336.36,91.74 336.36,68.68 arc(336.45,68.25) 336.69,67.88 342.24,62.33 342.24,62.08 342.64,61.68 342.89,61.68 343.24,61.33 343.24,61.1 343.65,60.68 343.89,60.68 344.23,60.34 344.23,60.08 344.62,59.69 344.88,59.69 345.22,59.35 arc(345.59,59.1) 346.03,59.01 354.59,59.01 arc(354.74,58.98) 354.86,58.9 354.95,58.82 354.99,58.77 arc(355.05,58.69) 355.1,58.59 arc(355.11,58.54) 355.11,58.48 355.11,58.07
FC56_TDN2: length 190.1
  TOP w0.147: U1.BT1 230.1,161.84 arc(230.42,161.97) v4(230.55,162.29)
  SIG7 w0.112: 231.53,160.78 231.4,160.78 231.28,160.9 arc(231.21,161.01) 231.18,161.14 231.18,161.65 arc(231.15,161.79) 231.08,161.91 231.07,161.92 arc(230.96,161.99) 230.83,162.02 230.71,162.02 arc(230.6,162.06) 230.55,162.18 v4(230.55,162.29)
  SIG7 w0.16: YJ36.D2 359.25,53.97 arc(359.36,54.14) 359.4,54.34 359.4,54.52 arc(359.3,54.76) 359.06,54.86 358.16,54.86 arc(357.86,54.92) 357.62,55.08 357.53,55.17 arc(357.28,55.34) 356.99,55.39 345.26,55.39 arc(344.97,55.45) 344.72,55.62 332.77,67.57 arc(332.61,67.81) 332.55,68.11 332.55,92.33 arc(332.41,93.03) 332.01,93.63 331.8,93.84 298.95,126.69 arc(298.19,127.2) 297.29,127.38 280.41,127.38 arc(280.27,127.41) 280.14,127.49 248.28,159.35 arc(248.04,159.52) 247.74,159.57 233.05,159.57 arc(232.76,159.63) 232.52,159.8 231.53,160.78
FC56_TDN3: length 189.4
  TOP w0.147: U1.BR3 228.55,161.34 v4(228.55,161.39)
  SIG6 w0.112: 231.84,160.65 231.81,160.65 231.72,160.74 229.39,160.74 arc(229.23,160.77) 229.1,160.86 arc(229.02,160.99) 228.99,161.14 228.99,161.58 arc(228.97,161.64) 228.94,161.69 228.93,161.71 arc(228.88,161.73) 228.84,161.74 228.68,161.74 arc(228.59,161.71) 228.55,161.62 v4(228.55,161.39)
  SIG6 w0.16: 231.84,160.65 232.29,160.65 arc(232.43,160.62) 232.56,160.54 233.56,159.53 arc(233.93,159.28) 234.37,159.2 247.58,159.2 arc(247.88,159.14) 248.12,158.97 279.76,127.33 arc(280.13,127.08) 280.57,127 297.98,127 arc(298.12,126.97) 298.24,126.89 334.14,90.99 arc(334.22,90.87) 334.25,90.72 334.25,66.73 arc(334.34,66.29) 334.59,65.92 341.57,58.93 341.57,58.66 341.95,58.29 342.22,58.29 342.54,57.96 342.54,57.73 342.96,57.31 343.19,57.31 343.53,56.97 343.53,56.74 343.95,56.32 344.19,56.32 345.16,55.35 arc(345.53,55.1) 345.97,55.01 354.59,55.01 arc(354.74,54.98) 354.86,54.9 354.95,54.82 354.99,54.77 arc(355.05,54.7) 355.09,54.62 arc(355.09,54.59) 355.1,54.57 arc(355.11,54.52) 355.11,54.48 355.11,54.07 arc(355.16,53.84) 355.29,53.65 355.79,53.14 arc(355.87,53.02) 355.9,52.88 YJ36.D6
FC56_TDP0: length 189.7
  TOP w0.147: v4(229.55,163.39) 229.55,163.34 U1.BU2
  SIG7 w0.112: 232.16,162.65 232.13,162.65 232.08,162.7 arc(232.04,162.73) 231.99,162.74 230.39,162.74 arc(230.23,162.77) 230.1,162.86 arc(230.02,162.99) 229.99,163.14 229.99,163.58 arc(229.97,163.64) 229.94,163.69 229.93,163.7 arc(229.88,163.73) 229.83,163.74 229.69,163.74 arc(229.59,163.7) 229.55,163.6 v4(229.55,163.39)
  SIG7 w0.16: YJ36.D36 358.3,56.73 arc(358.24,57.01) 358.08,57.25 357.69,57.65 arc(357.56,57.84) 357.51,58.07 357.51,58.48 arc(357.51,58.53) 357.5,58.58 arc(357.46,58.69) 357.39,58.77 357.35,58.82 357.26,58.9 arc(357.14,58.98) 356.99,59.01 345.2,59.01 arc(344.76,59.1) 344.39,59.35 343.97,59.77 343.68,59.77 343.35,60.1 343.35,60.38 343.03,60.71 342.81,60.71 342.42,61.1 342.42,61.32 342.1,61.64 341.87,61.64 341.49,62.03 341.49,62.25 334.59,69.15 arc(334.34,69.52) 334.25,69.96 334.25,93.05 arc(334.1,93.83) 333.65,94.5 299.59,128.56 arc(298.93,129) 298.14,129.16 282.95,129.16 arc(282.66,129.21) 282.42,129.38 250.62,161.18 arc(250.5,161.26) 250.35,161.29 235.84,161.29 arc(235.55,161.35) 235.3,161.51 234.27,162.54 arc(234.15,162.62) 234,162.65 232.16,162.65
FC56_TDP1: length 189
  TOP w0.147: U1.BV4 227.1,163.84 arc(227.42,163.97) v4(227.55,164.29)
  SIG6 w0.112: v4(227.55,164.29) 227.55,164.07 arc(227.59,163.98) 227.68,163.94 227.84,163.94 arc(227.96,163.92) 228.07,163.84 228.08,163.83 arc(228.15,163.72) 228.18,163.58 228.18,163.14 arc(228.2,163.06) 228.24,163 arc(228.31,162.95) 228.39,162.94 232.1,162.94 232.19,163.03 232.22,163.03
  SIG6 w0.16: 232.22,163.03 233.46,163.03 arc(233.76,162.97) 234,162.81 234.92,161.89 arc(235.16,161.73) 235.46,161.67 250.35,161.67 arc(250.64,161.61) 250.89,161.45 282.57,129.76 arc(282.82,129.6) 283.11,129.54 298.94,129.54 arc(299.23,129.48) 299.48,129.31 336.52,92.28 arc(336.68,92.03) 336.74,91.74 336.74,68.68 arc(336.8,68.39) 336.96,68.14 345.49,59.62 arc(345.74,59.45) 346.03,59.39 354.59,59.39 arc(354.88,59.34) 355.13,59.17 355.22,59.08 arc(355.46,58.92) 355.76,58.86 356.66,58.86 arc(356.9,58.76) 357,58.52 357,58.34 arc(356.96,58.14) 356.85,57.97 YJ36.D34
FC56_TDP2: length 190.1
  TOP w0.147: v4(230.55,161.39) 230.55,161.34 U1.BR1
  SIG7 w0.112: v4(230.55,161.39) 230.55,161.67 arc(230.59,161.78) 230.69,161.82 230.83,161.82 arc(230.88,161.81) 230.93,161.78 230.94,161.77 arc(230.97,161.72) 230.99,161.65 230.99,161.14 arc(231.03,160.94) 231.14,160.76 231.26,160.64 231.26,160.51
  SIG7 w0.16: 231.26,160.51 232.25,159.53 arc(232.62,159.28) 233.05,159.19 247.74,159.19 arc(247.89,159.16) 248.01,159.08 279.88,127.22 arc(280.12,127.06) 280.41,127 297.29,127 arc(298.04,126.85) 298.68,126.42 331.53,93.57 331.74,93.36 arc(332.06,92.88) 332.17,92.33 332.17,68.11 arc(332.26,67.67) 332.5,67.3 343,56.8 343,56.58 343.39,56.19 343.61,56.19 344.45,55.35 arc(344.82,55.1) 345.26,55.01 356.99,55.01 arc(357.14,54.98) 357.26,54.9 357.35,54.82 357.39,54.77 arc(357.46,54.68) 357.5,54.58 arc(357.51,54.53) 357.51,54.48 357.51,54.07 arc(357.56,53.84) 357.69,53.65 358.06,53.27 arc(358.24,53.01) 358.3,52.7 YJ36.D3
FC56_TDP3: length 189.4
  TOP w0.147: U1.BT3 228.1,161.84 arc(228.42,161.97) v4(228.55,162.29)
  SIG6 w0.112: 231.84,161.03 231.81,161.03 231.72,160.94 229.39,160.94 arc(229.31,160.95) 229.24,161 arc(229.2,161.06) 229.18,161.14 229.18,161.58 arc(229.15,161.72) 229.08,161.83 229.07,161.84 arc(228.96,161.92) 228.84,161.94 228.68,161.94 arc(228.59,161.98) 228.55,162.07 v4(228.55,162.29)
  SIG6 w0.16: YJ36.D5 356.85,53.97 arc(356.96,54.14) 357,54.34 357,54.52 arc(356.9,54.76) 356.66,54.86 355.61,54.86 arc(355.44,54.89) 355.3,54.99 355.05,55.24 arc(354.83,55.36) 354.59,55.39 345.97,55.39 arc(345.67,55.45) 345.43,55.62 334.86,66.19 arc(334.69,66.44) 334.63,66.73 334.63,90.72 arc(334.57,91.01) 334.41,91.26 298.51,127.16 arc(298.27,127.32) 297.98,127.38 280.57,127.38 arc(280.28,127.44) 280.03,127.6 248.39,159.24 arc(248.02,159.49) 247.58,159.58 234.37,159.58 arc(234.08,159.64) 233.83,159.8 232.83,160.81 arc(232.58,160.97) 232.29,161.03 231.84,161.03
FC57_RDN0: length 201.6
  TOP w0.147: v4(217.5,167.34) 217.41,167.34 arc(217.33,167.33) 217.26,167.28 217.19,167.2 arc(217.08,167.05) 217.05,166.87 U1.CA14
  SIG8 w0.112: 218.24,173.09 218.24,173.07 218.15,172.97 218.15,168.33 arc(218.11,168.12) 217.99,167.94 217.96,167.91 arc(217.81,167.81) 217.64,167.78 217.26,167.78 arc(217.22,167.77) 217.18,167.74 arc(217.16,167.71) 217.15,167.66 217.15,167.44 arc(217.18,167.37) 217.25,167.34 v4(217.5,167.34)
  SIG8 w0.16: 218.24,173.09 218.24,174.88 arc(218.27,175.03) 218.35,175.15 219.26,176.06 arc(219.38,176.14) 219.53,176.17 229.36,176.17 arc(229.65,176.11) 229.9,175.95 234.18,171.67 arc(234.42,171.51) 234.72,171.45 250.45,171.45 arc(250.74,171.39) 250.99,171.22 292.83,129.38 arc(293.08,129.21) 293.37,129.16 308.07,129.16 arc(308.36,129.1) 308.61,128.93 347.69,89.86 arc(347.85,89.61) 347.91,89.32 347.91,72.62 347.66,72.36 347.66,71.85 347.91,71.6 347.91,71.09 347.66,70.84 347.66,70.33 347.91,70.08 347.91,69.57 347.66,69.31 347.66,68.81 347.91,68.55 347.91,68.04 347.66,67.79 347.66,67.28 347.91,67.03 347.91,66.07 arc(347.96,65.84) 348.09,65.65 348.33,65.41 348.45,65.29 arc(348.63,65.01) 348.7,64.68 YJ36.C24
FC57_RDN1: length 204.1
  TOP w0.147: v4(216.6,165.34) 216.55,165.34 U1.BW15
  SIG8 w0.112: 218.86,172.74 218.86,172.71 218.95,172.62 218.95,166.2 arc(218.93,166.11) 218.89,166.04 arc(218.81,165.99) 218.73,165.98 217.26,165.98 arc(217.14,165.95) 217.04,165.88 217.04,165.88 arc(216.97,165.78) 216.95,165.66 216.95,165.44 arc(216.92,165.37) 216.85,165.34 v4(216.6,165.34)
  SIG8 w0.16: 218.86,172.74 218.86,172.97 arc(218.86,173.03) 218.87,173.1 arc(218.93,173.24) 219.02,173.36 219.34,173.68 arc(219.82,174) 220.39,174.11 224.35,174.11 arc(224.43,174.13) 224.51,174.18 arc(224.83,174.39) 225.21,174.47 228.5,174.47 arc(228.94,174.38) 229.31,174.14 233.59,169.86 arc(233.71,169.77) 233.86,169.75 249.48,169.75 arc(249.92,169.66) 250.29,169.41 292.21,127.49 arc(292.33,127.41) 292.48,127.38 307.04,127.38 arc(307.47,127.29) 307.85,127.04 344.22,90.67 arc(344.47,90.3) 344.56,89.86 344.56,64.86 arc(344.62,64.57) 344.78,64.32 345.48,63.62 arc(345.73,63.45) 346.02,63.39 347.39,63.39 arc(347.68,63.34) 347.93,63.17 348.16,62.94 arc(348.25,62.88) 348.35,62.86 349.44,62.86 arc(349.59,62.83) 349.72,62.74 arc(349.78,62.65) 349.8,62.54 349.8,62.35 arc(349.76,62.14) 349.65,61.97 YJ36.C14
FC57_RDN2: length 195.1
  TOP w0.147: v4(220.5,167.34) 220.42,167.34 arc(220.35,167.33) 220.29,167.29 220.12,167.12 arc(220.07,167.04) 220.05,166.94 U1.CA11
  SIG9 w0.112: 219.24,172.84 219.15,172.75 219.15,168.33 arc(219.18,168.2) 219.25,168.08 219.29,168.05 arc(219.37,167.99) 219.46,167.98 219.83,167.98 arc(219.95,167.95) 220.06,167.88 arc(220.12,167.78) 220.15,167.66 220.15,167.44 arc(220.18,167.37) 220.25,167.34 v4(220.5,167.34)
  SIG9 w0.16: 219.24,172.84 219.24,173.08 219.24,173.08 arc(219.25,173.16) 219.29,173.22 arc(219.29,173.22) 219.3,173.22 222.13,176.06 arc(222.26,176.14) 222.4,176.17 229.55,176.17 arc(229.69,176.14) 229.82,176.06 234.09,171.78 arc(234.47,171.53) 234.9,171.45 250.6,171.45 arc(250.75,171.42) 250.87,171.34 292.72,129.49 arc(293.09,129.24) 293.53,129.16 302.04,129.16 arc(302.18,129.13) 302.31,129.04 314.52,116.84 341.84,89.52 arc(341.92,89.39) 341.95,89.25 341.95,78.1 341.72,77.87 341.72,77.32 341.95,77.09 341.95,73.74 341.69,73.48 341.69,72.98 341.95,72.72 341.95,72.21 341.69,71.96 341.69,71.45 341.95,71.2 341.95,70.69 arc(342.03,70.25) 342.28,69.88 342.64,69.52 342.64,69.16 343,68.8 343.36,68.8 343.72,68.44 343.72,68.08 344.08,67.73 344.44,67.73 345.35,66.82 345.39,66.77 arc(345.45,66.7) 345.49,66.62 arc(345.49,66.6) 345.5,66.58 arc(345.51,66.53) 345.51,66.48 345.51,66.07 arc(345.56,65.84) 345.69,65.65 346.19,65.15 arc(346.27,65.02) 346.3,64.88 YJ36.C21
FC57_RDN3: length 194.9
  TOP w0.147: U1.BW12 219.55,165.34 v4(219.6,165.34)
  SIG9 w0.112: v4(219.6,165.34) 219.77,165.34 arc(219.84,165.37) 219.87,165.44 219.87,165.66 arc(219.9,165.78) 219.97,165.88 arc(220.07,165.95) 220.19,165.98 220.64,165.98 arc(220.73,165.99) 220.81,166.05 220.84,166.08 arc(220.92,166.2) 220.95,166.33 220.95,172.46 arc(220.98,172.64) 221.08,172.78 221.25,172.95 221.25,173.08 221.26,173.1
  SIG9 w0.16: YJ36.C17 347.25,61.97 arc(347.36,62.14) 347.4,62.34 347.4,62.52 arc(347.3,62.76) 347.06,62.86 346.04,62.86 arc(345.85,62.9) 345.69,63.01 336.96,71.73 arc(336.8,71.98) 336.74,72.27 336.74,91.5 arc(336.65,91.94) 336.41,92.31 301.67,127.04 arc(301.3,127.29) 300.87,127.38 292.48,127.38 arc(292.33,127.41) 292.21,127.49 253.81,165.89 250.29,169.41 arc(249.92,169.66) 249.48,169.75 234.04,169.75 arc(233.9,169.76) 233.76,169.8 233.5,169.97 arc(233.48,169.99) 233.45,170.02 231.39,172.08 229.33,174.14 arc(228.96,174.38) 228.53,174.47 225.21,174.47 arc(224.83,174.39) 224.51,174.18 arc(224.43,174.13) 224.35,174.11 223.05,174.11 arc(222.34,173.97) 221.74,173.57 221.26,173.1
FC57_RDP0: length 201.6
  TOP w0.147: U1.CA15 216.55,167.34 v4(216.6,167.34)
  SIG8 w0.112: v4(216.6,167.34) 216.85,167.34 arc(216.92,167.37) 216.95,167.44 216.95,167.66 arc(216.97,167.78) 217.04,167.88 arc(217.14,167.95) 217.26,167.98 217.64,167.98 arc(217.74,167.99) 217.82,168.05 217.85,168.08 arc(217.93,168.2) 217.95,168.33 217.95,172.97 217.86,173.07 217.86,173.09
  SIG8 w0.16: YJ36.C25 349.65,65.97 arc(349.76,66.14) 349.8,66.34 349.8,66.45 arc(349.78,66.56) 349.72,66.65 349.66,66.71 arc(349.5,66.82) 349.3,66.86 348.53,66.86 arc(348.36,66.93) 348.29,67.1 348.29,89.32 arc(348.2,89.76) 347.96,90.13 308.88,129.2 arc(308.51,129.45) 308.07,129.54 293.37,129.54 arc(293.22,129.57) 293.1,129.65 251.25,171.49 arc(250.88,171.74) 250.45,171.83 234.72,171.83 arc(234.57,171.86) 234.45,171.94 230.17,176.22 arc(229.8,176.47) 229.36,176.55 219.53,176.55 arc(219.24,176.49) 218.99,176.33 218.08,175.42 arc(217.92,175.18) 217.86,174.88 217.86,173.09
FC57_RDP1: length 204.1
  TOP w0.147: U1.BW14 217.05,164.87 arc(217.08,165.05) 217.19,165.2 217.26,165.28 arc(217.33,165.33) 217.41,165.34 v4(217.5,165.34)
  SIG8 w0.112: v4(217.5,165.34) 217.25,165.34 arc(217.18,165.37) 217.15,165.44 217.15,165.66 arc(217.16,165.71) 217.18,165.74 arc(217.22,165.77) 217.26,165.78 218.73,165.78 arc(218.89,165.81) 219.02,165.9 arc(219.12,166.04) 219.15,166.2 219.15,172.62 219.24,172.71 219.24,172.74
  SIG8 w0.16: YJ36.C15 348.7,60.68 arc(348.65,60.96) 348.51,61.21 arc(348.5,61.22) 348.49,61.24 arc(348.49,61.24) 348.49,61.24 arc(348.47,61.27) 348.45,61.29 348.33,61.41 348.09,61.65 arc(347.96,61.84) 347.91,62.07 347.91,62.48 arc(347.91,62.54) 347.89,62.6 arc(347.89,62.61) 347.89,62.61 arc(347.89,62.62) 347.88,62.64 arc(347.84,62.71) 347.79,62.77 347.75,62.82 347.66,62.9 arc(347.54,62.98) 347.39,63.01 346.02,63.01 arc(345.59,63.1) 345.22,63.35 344.51,64.05 arc(344.26,64.42) 344.18,64.86 344.18,65.94 343.92,66.19 343.92,66.7 344.18,66.95 344.18,67.46 343.92,67.71 343.92,68.22 344.18,68.48 344.18,68.98 343.92,69.24 343.92,69.75 344.18,70 344.18,70.51 343.92,70.76 343.92,71.27 344.18,71.52 344.18,73.38 343.92,73.63 343.92,74.14 344.18,74.39 344.18,89.86 arc(344.12,90.15) 343.95,90.4 307.58,126.77 arc(307.33,126.94) 307.04,127 292.48,127 arc(292.19,127.06) 291.94,127.22 250.02,169.14 arc(249.77,169.31) 249.48,169.36 233.86,169.36 arc(233.56,169.42) 233.32,169.59 229.04,173.87 arc(228.79,174.03) 228.5,174.09 225.21,174.09 arc(224.97,174.04) 224.78,173.91 arc(224.58,173.78) 224.35,173.73 220.39,173.73 arc(219.97,173.65) 219.61,173.41 219.29,173.09 arc(219.26,173.05) 219.24,173.01 arc(219.24,172.99) 219.24,172.97 219.24,172.74
FC57_RDP2: length 195.1
  TOP w0.147: U1.CA12 219.55,167.34 v4(219.6,167.34)
  SIG9 w0.112: v4(219.6,167.34) 219.85,167.34 arc(219.92,167.37) 219.95,167.44 219.95,167.66 arc(219.94,167.71) 219.92,167.74 arc(219.88,167.77) 219.83,167.78 219.46,167.78 arc(219.29,167.81) 219.15,167.91 219.12,167.94 arc(219,168.12) 218.95,168.33 218.95,172.74 218.86,172.84
  SIG9 w0.16: YJ36.C22 347.25,65.97 arc(347.36,66.14) 347.4,66.34 347.4,66.52 arc(347.3,66.76) 347.06,66.86 346.06,66.86 arc(345.86,66.9) 345.68,67.02 345.45,67.25 342.55,70.15 arc(342.39,70.4) 342.33,70.69 342.33,89.25 arc(342.27,89.54) 342.11,89.79 315.05,116.84 302.58,129.31 arc(302.33,129.48) 302.04,129.54 293.53,129.54 arc(293.23,129.6) 292.99,129.76 251.14,171.61 arc(250.9,171.77) 250.6,171.83 234.9,171.83 arc(234.61,171.89) 234.36,172.05 230.09,176.33 arc(229.84,176.49) 229.55,176.55 222.4,176.55 arc(222.11,176.49) 221.86,176.33 219.03,173.49 arc(219.02,173.49) 219.01,173.48 arc(218.9,173.3) 218.86,173.08 218.86,172.84
FC57_RDP3: length 194.9
  TOP w0.147: v4(220.5,165.34) 220.42,165.34 arc(220.35,165.33) 220.29,165.29 220.12,165.12 arc(220.07,165.04) 220.05,164.94 U1.BW11
  SIG9 w0.112: 221.53,172.83 221.51,172.81 221.38,172.81 221.29,172.72 221.22,172.64 arc(221.16,172.56) 221.14,172.46 221.14,166.33 arc(221.1,166.12) 220.98,165.94 220.95,165.91 arc(220.81,165.81) 220.64,165.78 220.19,165.78 arc(220.14,165.77) 220.11,165.74 arc(220.08,165.71) 220.07,165.66 220.07,165.44 arc(220.1,165.37) 220.17,165.34 v4(220.5,165.34)
  SIG9 w0.16: 221.53,172.83 222.01,173.3 arc(222.48,173.62) 223.05,173.73 224.35,173.73 arc(224.58,173.78) 224.78,173.91 arc(224.97,174.04) 225.21,174.09 228.53,174.09 arc(228.82,174.03) 229.06,173.87 233.18,169.75 arc(233.23,169.7) 233.29,169.66 233.57,169.46 arc(233.8,169.39) 234.04,169.36 249.48,169.36 arc(249.77,169.31) 250.02,169.14 253.81,165.35 291.94,127.22 arc(292.19,127.06) 292.48,127 300.87,127 arc(301.16,126.94) 301.4,126.77 336.14,92.04 arc(336.3,91.79) 336.36,91.5 336.36,72.27 arc(336.45,71.84) 336.69,71.46 340.86,67.3 340.86,67 341.27,66.59 341.57,66.59 341.93,66.23 341.93,65.92 342.34,65.51 342.65,65.51 343.01,65.15 343.01,64.81 343.4,64.43 343.73,64.43 344.09,64.07 344.09,63.76 344.5,63.35 344.81,63.35 345.2,62.96 arc(345.21,62.95) 345.21,62.95 345.26,62.9 345.26,62.9 345.35,62.82 345.39,62.77 arc(345.45,62.7) 345.49,62.61 arc(345.5,62.59) 345.5,62.57 arc(345.51,62.52) 345.51,62.48 345.51,62.07 arc(345.56,61.84) 345.69,61.65 346.15,61.19 arc(346.26,61.02) 346.3,60.82 YJ36.C18
FC57_TDN0: length 182.3
  TOP w0.147: U1.BY5 226.1,165.84 arc(226.42,165.97) v4(226.55,166.29)
  SIG6 w0.112: v4(226.55,166.29) 226.55,166.07 arc(226.59,165.98) 226.68,165.94 226.84,165.94 arc(226.88,165.95) 226.93,165.98 226.94,165.99 arc(226.97,166.04) 226.99,166.11 226.99,166.54 arc(227.02,166.7) 227.1,166.83 arc(227.23,166.91) 227.39,166.94 231.84,166.94 231.94,167.03 231.96,167.03
  SIG6 w0.16: 231.96,167.03 232.83,167.03 arc(233.12,167.09) 233.36,167.26 233.52,167.41 arc(233.77,167.58) 234.06,167.64 251.75,167.64 arc(252.04,167.58) 252.29,167.41 285.62,134.08 arc(285.87,133.91) 286.16,133.86 300.74,133.86 arc(301.04,133.8) 301.28,133.63 353.41,81.51 arc(353.57,81.26) 353.63,80.97 353.63,78.52 arc(353.69,78.23) 353.86,77.98 355.27,76.57 arc(355.43,76.32) 355.49,76.03 355.49,67.08 arc(355.56,66.93) 355.71,66.86 356.66,66.86 arc(356.9,66.76) 357,66.52 357,66.34 arc(356.96,66.14) 356.85,65.97 YJ36.C34
FC57_TDN1: length 181.4
  TOP w0.147: v4(228.55,165.39) 228.55,165.34 U1.BW3
  SIG7 w0.112: 231.84,166.65 231.81,166.65 231.72,166.75 229.39,166.75 arc(229.31,166.73) 229.24,166.69 arc(229.2,166.62) 229.18,166.54 229.18,166.11 arc(229.15,165.97) 229.08,165.85 229.07,165.84 arc(228.96,165.77) 228.83,165.74 228.7,165.74 228.7,165.74 arc(228.59,165.69) 228.55,165.58 v4(228.55,165.39)
  SIG7 w0.16: YJ36.C36 358.3,64.79 arc(358.26,65.02) 358.13,65.21 357.69,65.65 arc(357.56,65.84) 357.51,66.07 357.51,66.48 arc(357.51,66.53) 357.5,66.58 arc(357.46,66.68) 357.39,66.77 357.35,66.82 357.12,67.04 arc(356.75,67.59) 356.62,68.24 356.62,69.06 356.42,69.26 356.42,69.72 356.62,69.92 356.62,70.38 356.45,70.55 356.45,71.07 356.62,71.24 356.62,71.7 356.48,71.85 356.48,72.42 356.62,72.57 356.62,77.59 arc(356.59,77.74) 356.51,77.86 301.01,133.36 arc(300.89,133.45) 300.74,133.47 286,133.47 arc(285.71,133.53) 285.46,133.7 252.02,167.14 arc(251.89,167.23) 251.75,167.26 233.4,167.26 arc(233.11,167.2) 232.86,167.03 232.7,166.88 arc(232.46,166.71) 232.17,166.65 231.84,166.65
FC57_TDN2: length 187.1
  TOP w0.147: U1.BY1 230.1,165.84 arc(230.42,165.97) v4(230.55,166.29)
  SIG7 w0.112: 231.94,166.03 231.91,166.03 231.82,165.94 231.14,165.94 arc(230.92,165.98) 230.73,166.11 v4(230.55,166.29)
  SIG7 w0.16: 231.94,166.03 233.92,166.03 arc(234.21,165.97) 234.46,165.81 234.68,165.59 arc(234.8,165.51) 234.95,165.48 250.86,165.48 arc(251.15,165.42) 251.4,165.26 284.84,131.81 arc(284.97,131.73) 285.11,131.7 299.32,131.7 arc(300.1,131.54) 300.76,131.1 347.54,84.32 arc(347.91,83.76) 348.04,83.11 348.04,71.28 arc(347.99,70.99) 347.82,70.74 344.82,67.74 arc(344.65,67.49) 344.59,67.2 344.59,64.44 arc(344.65,64.15) 344.82,63.9 345.1,63.62 arc(345.35,63.45) 345.64,63.39 354.59,63.39 arc(354.88,63.34) 355.13,63.17 355.22,63.08 arc(355.46,62.92) 355.76,62.86 356.66,62.86 arc(356.9,62.76) 357,62.52 357,62.34 arc(356.96,62.14) 356.85,61.97 YJ36.C5
FC57_TDN3: length 193.5
  TOP w0.147: U1.BU6 225.55,163.34 v4(225.55,163.39)
  SIG6 w0.112: 231.99,164.65 231.96,164.65 231.87,164.75 226.39,164.75 arc(226.31,164.73) 226.24,164.69 arc(226.2,164.62) 226.18,164.54 226.18,164.11 arc(226.15,163.97) 226.08,163.85 226.07,163.84 arc(225.96,163.77) 225.84,163.74 225.68,163.74 arc(225.59,163.71) 225.55,163.62 v4(225.55,163.39)
  SIG6 w0.16: YJ36.C3 358.3,60.8 arc(358.26,61.02) 358.14,61.2 357.69,61.65 arc(357.56,61.84) 357.51,62.07 357.51,62.48 arc(357.51,62.53) 357.5,62.57 arc(357.49,62.6) 357.49,62.62 arc(357.45,62.7) 357.39,62.77 357.35,62.82 357.26,62.9 arc(357.14,62.98) 356.99,63.01 345.71,63.01 arc(345.28,63.1) 344.9,63.35 344.56,63.69 344.33,63.69 343.91,64.1 343.91,64.34 343.57,64.68 343.31,64.68 342.92,65.07 342.92,65.33 342.58,65.67 342.32,65.67 341.93,66.06 341.93,66.32 340.12,68.13 arc(339.88,68.5) 339.79,68.94 339.79,87.36 arc(339.91,87.99) 340.27,88.52 340.67,88.92 arc(340.86,89.21) 340.93,89.55 340.93,90.34 arc(340.9,90.49) 340.82,90.61 300.23,131.2 arc(300.1,131.29) 299.96,131.32 285.27,131.32 arc(284.83,131.4) 284.46,131.65 251.13,164.99 arc(251,165.07) 250.86,165.1 234.69,165.1 arc(234.55,165.07) 234.43,164.99 arc(234.06,164.74) 233.62,164.65 231.99,164.65
FC57_TDP0: length 182.3
  TOP w0.147: U1.BW5 226.55,165.34 v4(226.55,165.39)
  SIG6 w0.112: v4(226.55,165.39) 226.55,165.62 arc(226.59,165.71) 226.68,165.74 226.84,165.74 arc(226.96,165.77) 227.07,165.84 227.08,165.85 arc(227.15,165.97) 227.18,166.11 227.18,166.54 arc(227.2,166.62) 227.24,166.69 arc(227.31,166.73) 227.39,166.75 231.84,166.75 231.94,166.65 231.96,166.65
  SIG6 w0.155: 355.2,65.76 arc(355.13,65.91) 355.11,66.07
  SIG6 w0.16: YJ36.C33 355.9,64.78 arc(355.85,65.02) 355.72,65.21 355.53,65.4 355.34,65.6 arc(355.27,65.68) 355.2,65.76 ; 355.11,66.07 355.11,67.84 354.93,68.02 354.93,68.58 355.11,68.76 355.11,69.21 354.93,69.39 354.93,69.95 355.11,70.13 355.11,76.03 arc(355.08,76.17) 355,76.3 353.59,77.71 arc(353.34,78.08) 353.25,78.52 353.25,80.97 arc(353.22,81.11) 353.14,81.24 301.01,133.36 arc(300.89,133.45) 300.74,133.47 286.16,133.47 arc(285.72,133.56) 285.35,133.81 252.02,167.14 arc(251.89,167.23) 251.75,167.26 234.06,167.26 arc(233.91,167.23) 233.79,167.14 233.63,166.99 arc(233.26,166.74) 232.83,166.65 231.96,166.65
FC57_TDP1: length 181.4
  TOP w0.147: U1.BY3 228.1,165.84 arc(228.42,165.97) v4(228.55,166.29)
  SIG7 w0.112: v4(228.55,166.29) 228.55,166.09 arc(228.59,165.98) 228.69,165.94 228.83,165.94 arc(228.88,165.95) 228.93,165.98 228.94,165.99 arc(228.97,166.04) 228.99,166.11 228.99,166.54 arc(229.02,166.7) 229.1,166.83 arc(229.23,166.91) 229.39,166.94 231.72,166.94 231.81,167.03 231.84,167.03
  SIG7 w0.16: YJ36.C37 359.25,65.97 arc(359.36,66.14) 359.4,66.34 359.4,66.52 arc(359.3,66.76) 359.06,66.86 358.16,66.86 arc(357.86,66.92) 357.62,67.08 357.39,67.31 arc(357.1,67.74) 357,68.24 357,77.59 arc(356.95,77.89) 356.78,78.13 301.28,133.63 arc(301.04,133.8) 300.74,133.86 286,133.86 arc(285.86,133.88) 285.73,133.97 252.29,167.41 arc(252.04,167.58) 251.75,167.64 233.4,167.64 arc(232.96,167.55) 232.59,167.3 232.43,167.15 arc(232.31,167.06) 232.17,167.03 231.84,167.03
FC57_TDP2: length 187.1
  TOP w0.147: v4(230.55,165.39) 230.55,165.34 U1.BW1
  SIG7 w0.112: 231.94,165.65 231.91,165.65 231.82,165.74 231.14,165.74 arc(230.92,165.7) 230.73,165.58 v4(230.55,165.39)
  SIG7 w0.155: 355.18,61.8 arc(355.13,61.93) 355.11,62.07
  SIG7 w0.16: 355.11,62.07 355.11,62.48 arc(355.11,62.54) 355.1,62.59 arc(355.05,62.69) 354.99,62.77 354.95,62.82 354.86,62.9 arc(354.74,62.98) 354.59,63.01 345.64,63.01 arc(345.21,63.1) 344.83,63.35 344.55,63.63 arc(344.3,64.01) 344.21,64.44 344.21,65.17 344.03,65.36 344.03,65.85 344.21,66.04 344.21,67.2 arc(344.3,67.64) 344.55,68.01 344.87,68.33 344.87,68.55 345.26,68.94 345.48,68.94 345.81,69.27 345.81,69.51 346.17,69.88 346.42,69.88 347.55,71.01 arc(347.63,71.13) 347.66,71.28 347.66,83.11 arc(347.56,83.62) 347.27,84.05 300.49,130.83 arc(299.95,131.19) 299.32,131.32 285.11,131.32 arc(284.82,131.37) 284.57,131.54 251.13,164.99 arc(251,165.07) 250.86,165.1 234.95,165.1 arc(234.66,165.16) 234.41,165.32 234.19,165.54 arc(234.07,165.62) 233.92,165.65 231.94,165.65 ; YJ36.C6 355.9,60.7 arc(355.84,61.01) 355.67,61.27 355.32,61.62 arc(355.24,61.71) 355.18,61.8
FC57_TDP3: length 193.5
  TOP w0.147: U1.BV6 225.1,163.84 arc(225.42,163.97) v4(225.55,164.29)
  SIG6 w0.112: 231.99,165.03 231.96,165.03 231.87,164.94 226.39,164.94 arc(226.23,164.91) 226.1,164.83 arc(226.02,164.7) 225.99,164.54 225.99,164.11 arc(225.97,164.04) 225.94,163.99 225.93,163.98 arc(225.88,163.95) 225.84,163.94 225.68,163.94 arc(225.59,163.98) 225.55,164.07 v4(225.55,164.29)
  SIG6 w0.16: 231.99,165.03 233.62,165.03 arc(233.91,165.09) 234.16,165.26 arc(234.4,165.42) 234.69,165.48 250.86,165.48 arc(251.15,165.42) 251.4,165.26 284.73,131.92 arc(284.98,131.75) 285.27,131.7 299.96,131.7 arc(300.25,131.64) 300.5,131.47 341.09,90.88 arc(341.25,90.63) 341.31,90.34 341.31,89.55 arc(341.22,89.06) 340.94,88.65 340.54,88.25 arc(340.27,87.84) 340.17,87.36 340.17,68.94 arc(340.23,68.65) 340.39,68.4 345.17,63.62 arc(345.42,63.45) 345.71,63.39 356.99,63.39 arc(357.28,63.34) 357.53,63.17 357.69,63.01 arc(357.86,62.9) 358.05,62.86 359.06,62.86 arc(359.3,62.76) 359.4,62.52 359.4,62.34 arc(359.36,62.14) 359.25,61.97 YJ36.C2
FC58_59_PVDD0P8: length 5.5
  TOP w0.229: U1.BG23 v1(208.55,153.34) ; U1.BG21 v1(210.55,153.34)
  TOP w0.381: 228.7,193.39 C352.1 ; C352.1 229.3,194.03 ; C352.1 229.9,193.39
  BOTTOM w0.13: v1(228.28,194.18) v2(227.52,194.18)
  BOTTOM w0.381: C3322.1 209.05,153.85 v1(208.55,153.34) ; C2805.1 211.05,153.85 v1(210.55,153.34)
  vias: v1(228.28,193.16)
FC58_RDN0: length 199.9
  TOP w0.147: U1.CE8 223.05,170.91 arc(223.08,171.08) 223.17,171.22 223.23,171.27 arc(223.31,171.32) 223.4,171.34 v4(223.5,171.34)
  SIG3 w0.112: v4(223.5,171.34) 223.37,171.47 arc(223.21,171.72) 223.15,172.01 223.15,172.72 223.24,172.81 223.24,172.84
  SIG3 w0.16: 223.24,172.84 223.24,172.97 arc(223.24,173.04) 223.25,173.1 arc(223.58,173.73) 224.26,173.99 230.23,173.99 arc(230.37,173.96) 230.5,173.88 230.86,173.52 230.86,173.16 231.22,172.8 231.57,172.8 231.93,172.44 231.93,172.08 232.29,171.72 232.65,171.72 233.11,171.26 233.11,170.9 233.47,170.54 233.83,170.54 234.67,169.7 arc(235.04,169.45) 235.48,169.36 246.59,169.36 arc(246.74,169.34) 246.86,169.25 282.3,133.81 arc(282.67,133.56) 283.11,133.47 300.74,133.47 arc(300.88,133.45) 301.01,133.36 357.53,76.84 arc(357.62,76.71) 357.64,76.57 357.64,74.51 arc(357.73,74.07) 357.98,73.7 358.31,73.37 358.31,73.01 358.58,72.74 358.93,72.74 359.28,72.4 359.28,72.04 359.64,71.68 360,71.68 360.36,71.32 360.36,70.99 360.74,70.6 361.07,70.6 361.46,70.21 arc(361.55,70.09) 361.58,69.94 361.58,69.15 361.37,68.95 361.37,68.46 361.58,68.26 361.58,67.62 arc(361.55,67.48) 361.46,67.35 361.01,66.9 arc(360.77,66.53) 360.68,66.09 360.68,64.69 arc(360.62,64.4) 360.46,64.16 359.93,63.63 arc(359.68,63.46) 359.39,63.41 357.95,63.41 arc(357.66,63.35) 357.41,63.18 357.36,63.13 357.32,63.08 arc(357.07,62.92) 356.78,62.86 355.93,62.86 arc(355.7,62.77) 355.61,62.54 355.61,62.32 arc(355.64,62.13) 355.75,61.97 YJ35.A14
FC58_RDN1: length 186.9
  TOP w0.147: U1.CC9 222.55,169.34 v4(222.6,169.34)
  SIG3 w0.112: 231.84,169.03 231.81,169.03 231.72,168.94 225.42,168.94 arc(225.31,168.96) 225.23,169.02 arc(225.17,169.11) 225.14,169.21 225.14,169.48 arc(225.11,169.67) 225,169.83 arc(224.84,169.94) 224.65,169.98 223.23,169.98 arc(223.01,169.91) 222.87,169.74 222.83,169.68 arc(222.82,169.64) 222.8,169.61 arc(222.71,169.47) v4(222.6,169.34)
  SIG3 w0.16: 231.84,169.03 232.11,169.03 arc(232.36,168.98) 232.57,168.84 233.52,167.89 arc(233.77,167.72) 234.06,167.66 244.36,167.66 arc(244.65,167.6) 244.89,167.44 280.41,131.92 arc(280.66,131.75) 280.95,131.7 299.85,131.7 arc(300.14,131.64) 300.39,131.47 355.72,76.14 arc(355.89,75.89) 355.94,75.6 355.94,72.09 arc(356,71.8) 356.17,71.55 359.66,68.06 arc(359.83,67.81) 359.88,67.52 359.88,65.99 arc(359.85,65.83) 359.77,65.7 359.3,65.23 arc(359.15,65.01) 359.1,64.75 YJ35.A21
FC58_RDN2: length 194.1
  TOP w0.147: v4(223.5,167.34) 223.42,167.34 arc(223.34,167.33) 223.28,167.29 223.12,167.13 arc(223.07,167.04) 223.05,166.95 U1.CA8
  SIG2 w0.112: 232.09,168.65 232.06,168.65 231.97,168.74 224.52,168.74 arc(224.37,168.71) 224.25,168.63 arc(224.17,168.51) 224.14,168.37 224.14,168.13 arc(224.12,167.99) 224.04,167.88 arc(223.93,167.81) 223.8,167.78 arc(223.79,167.78) 223.79,167.78 223.3,167.78 arc(223.24,167.77) 223.19,167.73 arc(223.16,167.68) 223.15,167.62 223.15,167.47 arc(223.18,167.38) 223.27,167.34 v4(223.5,167.34)
  SIG2 w0.16: YJ35.A17 358.15,61.97 arc(358.04,62.13) 358.01,62.32 358.01,62.57 arc(358.09,62.77) 358.3,62.86 359.18,62.86 arc(359.47,62.92) 359.72,63.08 359.76,63.13 359.81,63.18 360.28,63.65 arc(360.58,64.09) 360.68,64.61 360.68,65.79 arc(360.65,65.93) 360.57,66.06 360.08,66.55 arc(359.91,66.79) 359.85,67.08 359.85,67.59 359.6,67.85 359.6,68.35 359.85,68.61 359.85,69.12 359.6,69.37 359.6,69.88 359.85,70.13 359.85,70.64 359.6,70.89 359.6,71.4 359.85,71.66 359.85,72.43 arc(359.83,72.57) 359.74,72.7 359.68,72.76 arc(359.43,73.13) 359.35,73.57 359.35,74.71 359.35,74.71 arc(359.34,74.81) 359.32,74.9 arc(359.25,75.09) 359.12,75.25 358.76,75.61 358.48,75.61 358.05,76.04 358.05,76.32 357.69,76.68 357.4,76.68 356.97,77.12 356.97,77.4 356.61,77.76 356.33,77.76 355.89,78.2 355.89,78.48 301.12,133.25 arc(300.87,133.42) 300.58,133.47 282.95,133.47 arc(282.66,133.53) 282.42,133.7 246.97,169.14 arc(246.72,169.31) 246.43,169.36 233.75,169.36 arc(233.46,169.31) 233.22,169.14 232.95,168.87 arc(232.7,168.71) 232.41,168.65 232.09,168.65
FC58_RDN3: length 185.8
  TOP w0.147: U1.BW9 222.55,165.34 v4(222.6,165.34)
  SIG2 w0.112: 232.09,167.03 232.06,167.03 231.97,166.94 224.52,166.94 arc(224.3,166.89) 224.11,166.77 arc(223.99,166.59) 223.95,166.37 223.95,166.13 arc(223.94,166.07) 223.9,166.02 arc(223.85,165.99) 223.79,165.98 223.3,165.98 arc(223.17,165.95) 223.05,165.87 arc(222.98,165.76) 222.95,165.62 222.95,165.47 arc(222.91,165.38) 222.82,165.34 v4(222.6,165.34)
  SIG2 w0.16: 232.09,167.03 232.44,167.03 arc(232.59,167.06) 232.71,167.14 232.88,167.32 arc(233.25,167.56) 233.69,167.65 244.21,167.65 arc(244.65,167.56) 245.02,167.32 280.53,131.81 arc(280.65,131.73) 280.8,131.7 299.69,131.7 arc(300.13,131.61) 300.5,131.36 357.4,74.46 arc(357.57,74.21) 357.63,73.92 357.63,67.04 arc(357.62,66.96) 357.6,66.89 357.54,66.67 arc(357.51,66.57) 357.51,66.46 357.51,66.08 arc(357.46,65.86) 357.34,65.67 356.87,65.21 arc(356.74,65.02) 356.7,64.79 YJ35.A24
FC58_RDP0: length 199.9
  TOP w0.147: U1.CE9 222.55,171.34 v4(222.6,171.34)
  SIG3 w0.112: v4(222.6,171.34) 222.73,171.47 arc(222.89,171.72) 222.95,172.01 222.95,172.72 222.86,172.81 222.86,172.84
  SIG3 w0.16: YJ35.A15 356.7,60.76 arc(356.75,61.02) 356.89,61.23 357.11,61.44 357.34,61.67 arc(357.46,61.86) 357.51,62.08 357.51,62.57 arc(357.54,62.72) 357.63,62.86 357.68,62.91 arc(357.81,63) 357.95,63.03 359.39,63.03 arc(359.83,63.11) 360.2,63.36 360.72,63.89 arc(360.97,64.26) 361.06,64.69 361.06,66.09 arc(361.12,66.39) 361.28,66.63 361.73,67.08 arc(361.9,67.33) 361.96,67.62 361.96,69.94 arc(361.9,70.24) 361.73,70.48 358.25,73.97 arc(358.08,74.21) 358.03,74.51 358.03,76.57 arc(357.97,76.86) 357.8,77.11 301.28,133.63 arc(301.03,133.8) 300.74,133.86 283.11,133.86 arc(282.82,133.91) 282.57,134.08 247.13,169.52 arc(246.88,169.69) 246.59,169.75 235.48,169.75 arc(235.19,169.8) 234.94,169.97 230.77,174.15 arc(230.52,174.31) 230.23,174.37 224.26,174.37 arc(223.33,174.02) 222.87,173.15 arc(222.86,173.06) 222.86,172.97 222.86,172.84
FC58_RDP1: length 186.9
  TOP w0.147: v4(223.5,169.34) 223.43,169.34 arc(223.36,169.33) 223.31,169.29 223.18,169.17 arc(223.08,169.02) U1.CC8
  SIG3 w0.112: v4(223.5,169.34) 223.25,169.34 arc(223.16,169.36) 223.08,169.42 arc(223.04,169.47) 223.03,169.53 223.03,169.6 arc(223.03,169.63) 223.04,169.66 arc(223.12,169.75) 223.23,169.78 224.65,169.78 arc(224.76,169.76) 224.86,169.69 arc(224.92,169.59) 224.95,169.48 224.95,169.21 arc(225.09,168.88) 225.42,168.74 231.72,168.74 231.81,168.65 231.84,168.65
  SIG3 w0.16: 231.84,168.65 232.11,168.65 arc(232.21,168.63) 232.3,168.57 233.25,167.62 arc(233.62,167.37) 234.06,167.28 234.57,167.28 234.82,167.03 235.33,167.03 235.58,167.28 236.09,167.28 236.35,167.03 236.85,167.03 237.11,167.28 237.62,167.28 237.89,167 238.35,167 238.63,167.28 239.14,167.28 239.42,167 239.88,167 240.16,167.28 244.36,167.28 arc(244.5,167.25) 244.63,167.17 280.14,131.65 arc(280.52,131.4) 280.95,131.32 299.85,131.32 arc(299.99,131.29) 300.12,131.2 355.45,75.87 arc(355.53,75.75) 355.56,75.6 355.56,72.09 arc(355.65,71.66) 355.9,71.29 359.39,67.79 arc(359.47,67.67) 359.5,67.52 359.5,67.07 arc(359.49,66.99) 359.44,66.92 arc(359.37,66.88) 359.3,66.86 358.25,66.86 arc(358.08,66.79) 358.01,66.62 358.01,66.32 arc(358.04,66.13) 358.15,65.97 YJ35.A22
FC58_RDP2: length 194.1
  TOP w0.147: v4(222.6,167.34) 222.55,167.34 U1.CA9
  SIG2 w0.112: 232.09,169.03 232.06,169.03 231.97,168.94 224.52,168.94 arc(224.3,168.89) 224.11,168.77 arc(223.99,168.59) 223.95,168.37 223.95,168.13 arc(223.94,168.07) 223.9,168.02 arc(223.85,167.99) 223.79,167.98 223.3,167.98 arc(223.17,167.95) 223.05,167.87 arc(222.98,167.76) 222.95,167.62 222.95,167.47 arc(222.91,167.38) 222.82,167.34 v4(222.6,167.34)
  SIG2 w0.16: YJ35.A18 359.1,60.76 arc(359.15,61.01) 359.29,61.23 359.74,61.67 arc(359.86,61.86) 359.91,62.08 359.91,62.57 arc(359.94,62.72) 360.03,62.86 360.08,62.91 360.55,63.38 arc(360.93,63.95) 361.06,64.61 361.06,65.79 arc(361,66.08) 360.84,66.33 360.35,66.81 arc(360.26,66.94) 360.24,67.08 360.24,72.43 arc(360.18,72.72) 360.01,72.97 359.95,73.03 arc(359.79,73.28) 359.73,73.57 359.73,74.9 arc(359.72,74.95) 359.69,75 arc(359.58,75.28) 359.39,75.52 301.39,133.52 arc(301.02,133.77) 300.58,133.86 282.95,133.86 arc(282.81,133.88) 282.68,133.97 247.24,169.41 arc(246.87,169.66) 246.43,169.75 233.75,169.75 arc(233.32,169.66) 232.95,169.41 232.68,169.14 arc(232.55,169.06) 232.41,169.03 232.09,169.03
FC58_RDP3: length 185.8
  TOP w0.147: U1.BW8 223.05,164.89 arc(223.18,165.21) v4(223.5,165.34)
  SIG2 w0.112: v4(223.5,165.34) 223.27,165.34 arc(223.18,165.38) 223.15,165.47 223.15,165.62 arc(223.16,165.68) 223.19,165.73 arc(223.24,165.77) 223.3,165.78 223.79,165.78 arc(223.79,165.78) 223.8,165.78 arc(223.93,165.81) 224.04,165.88 arc(224.12,165.99) 224.14,166.13 224.14,166.37 arc(224.17,166.51) 224.25,166.63 arc(224.37,166.71) 224.52,166.74 231.97,166.74 232.06,166.65 232.09,166.65
  SIG2 w0.16: YJ35.A25 355.75,65.97 arc(355.64,66.13) 355.61,66.32 355.61,66.57 arc(355.69,66.77) 355.9,66.86 356.9,66.86 arc(356.93,66.86) 356.97,66.87 357.04,66.89 arc(357.13,66.94) 357.19,67.02 357.22,67.11 arc(357.24,67.16) 357.24,67.23 357.24,67.74 357.02,67.96 357.02,68.52 357.24,68.75 357.24,69.26 357.02,69.49 357.02,70.05 357.24,70.28 357.24,70.78 357.02,71.01 357.02,71.57 357.24,71.8 357.24,72.31 357.02,72.54 357.02,73.09 357.24,73.32 357.24,73.92 arc(357.22,74.07) 357.13,74.19 356.78,74.55 356.44,74.55 356.06,74.93 356.06,75.27 355.7,75.62 355.36,75.62 354.98,76.01 354.98,76.34 300.23,131.09 arc(299.98,131.26) 299.69,131.32 280.8,131.32 arc(280.5,131.37) 280.26,131.54 244.75,167.05 arc(244.5,167.21) 244.21,167.27 233.69,167.27 arc(233.4,167.21) 233.15,167.05 232.98,166.87 arc(232.73,166.71) 232.44,166.65 232.09,166.65
