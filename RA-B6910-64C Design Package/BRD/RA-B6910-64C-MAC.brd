# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC_TVDD1P2_0: length 27.7
  TOP w0.229: v1(186.57,168.34) 186.55,168.34 U1.CB44 ; v1(168.55,151.39) 168.55,151.34 U1.BE62 ; U1.CE49 181.55,171.34 v1(181.5,171.34) ; U1.CB43 187.55,168.34 v1(187.52,168.34) ; U1.BL65 165.58,157.31 arc(165.56,157.35) 165.55,157.39 v1(165.5,157.39) ; U1.CE37 194.03,170.84 v1(193.5,171.37) ; v1(165.55,169.37) 165.55,169.34 U1.CC65 ; v1(180.57,171.39) 180.57,171.32 U1.CE50 ; v1(168.57,140.34) 168.55,140.34 U1.AP62 ; v1(165.55,146.29) 166,145.84 U1.AY65 ; v1(192.6,171.34) 192.55,171.34 U1.CE38 ; U1.BV62 168.6,164.29 v1(168.52,164.29) ; v1(165.5,170.29) 165.6,170.29 U1.CD65 ; U1.BU62 168.55,163.34 v1(168.55,163.37) ; v1(168.55,152.29) 168.55,152.34 U1.BF62 ; v1(165.5,145.39) 165.55,145.39 arc(165.56,145.35) 165.58,145.31 U1.AW65 ; U1.BM65 165.55,158.34 v1(165.55,158.29)
  TOP w0.381: 166.43,177.7 C3068.1 ; C3068.1 165.84,178.33 ; C3068.1 167.03,178.33
  BOTTOM w0.229: 168.08,150.92 C2976.1
  BOTTOM w0.254: C3086.1 164.41,156.83
  BOTTOM w0.33: C3117.1 181.04,170.88 v1(181.5,171.34)
  BOTTOM w0.381: v1(165.55,169.37) 165.06,168.88 C3059.1 ; v1(168.57,140.34) 168.07,140.85 C2690.1 ; v1(187.52,168.34) 188.02,167.84 C3188.1 ; v1(165.5,145.39) 165.08,144.97 C3186.1 ; v1(165.5,157.39) 165.5,157.25 C3086.1 ; C2906.1 194,170.86 v1(193.5,171.37) ; v1(192.6,171.34) 192.07,170.81 C2679.1 ; v1(168.55,163.37) 168.1,162.92 C3172.1 ; v1(180.57,171.39) 180.03,170.85 C3141.1 ; v1(165.5,170.29) 165.08,170.71 C2703.1 ; v1(168.52,164.29) 168.08,164.74 C3101.1 ; v1(168.55,151.39) 168.08,150.92 ; v1(168.55,152.29) 168.08,152.76 C2812.1 ; C2738.1 165.08,158.76 v1(165.55,158.29) ; C3124.1 165.06,146.78 v1(165.55,146.29) ; v1(186.57,168.34) 187.04,167.87 C3158.1
  vias: v1(164.43,177.06) v1(165.32,177.06) v1(166.21,177.06) v1(167.09,177.06) v2(167.7,175.89)
FC_TVDD1P2_1: length 26.2
  TOP w0.229: U1.B38 192.55,107.34 v1(192.57,107.34) ; v1(180.57,107.32) 180.57,107.37 U1.B50 ; v1(168.55,126.39) 168.55,126.34 U1.AA62 ; v1(168.55,127.29) 168.55,127.34 U1.AB62 ; U1.E43 187.55,110.34 v1(187.5,110.34) ; v1(168.57,115.29) 168.57,115.37 U1.K62 ; v1(165.55,109.27) 165.55,109.34 U1.D65 ; U1.B37 v1(193.52,107.32) ; v1(181.52,107.34) 181.55,107.34 U1.B49 ; U1.C65 165.55,108.34 v1(165.52,108.34) ; v1(165.55,133.29) 165.55,133.34 U1.AH65 ; U1.T65 165.55,121.34 v1(165.55,121.29) ; v1(165.52,132.39) 165.55,132.39 165.96,132.81 arc(166,132.83) U1.AG65 ; v1(186.6,110.34) 186.55,110.34 U1.E44 ; v1(168.56,114.39) 169.01,114.84 U1.J62 ; v1(168.55,138.37) 168.55,138.39 169,138.84 U1.AN62 ; v1(165.52,120.4) 165.55,120.4 165.55,120.34 U1.R65
  BOTTOM w0.229: 187.05,110.79 C2668.1
  BOTTOM w0.381: C2850.1 168.56,114.33 v1(168.56,114.39) ; 168.08,127.83 168.08,127.76 v1(168.55,127.29) ; v1(168.57,115.29) 168.08,115.78 168.08,115.85 ; v1(180.57,107.32) 180.07,107.82 C3089.1 ; C3096.1 159.93,132.69 ; v1(165.52,132.39) 166.02,131.9 C3062.1 ; v1(168.55,138.37) 168.05,137.87 C2955.1 ; C2729.1 165.52,108.28 v1(165.52,108.34) ; C3133.1 193.05,106.84 v1(193.52,107.32) ; v1(165.55,133.29) 165.05,133.79 C2939.1 ; C2767.1 165.55,109.37 v1(165.55,109.27) ; v1(181.52,107.34) 181.98,106.88 C3031.1 ; v1(192.57,107.34) 193.05,107.82 C3026.1 ; v1(187.5,110.34) 187.05,110.79 ; 168.08,125.85 168.08,125.93 v1(168.55,126.39) ; v1(186.6,110.34) 186.1,110.84 C3065.1 ; C2975.1 165.08,119.95 v1(165.52,120.4) ; C3178.1 165.05,121.79 v1(165.55,121.29)
  vias: v2(162.62,118.87)
FC_TVDD1P2_2: length 26.8
  TOP w0.229: v1(200.5,110.34) 200.05,110.79 U1.E31 ; U1.R2 229.52,120.37 v1(229.6,120.37) ; U1.AA5 226.1,126.84 v1(226.55,126.39) ; U1.E20 211.55,110.34 v1(211.6,110.34) ; U1.J5 226.1,114.84 v1(226.55,114.39) ; v1(229.55,109.32) 229.55,109.34 U1.D2 ; v1(205.57,107.34) 205.55,107.34 U1.B26 ; U1.E32 199.55,110.34 v1(199.6,110.34) ; v1(226.57,127.29) 226.05,127.82 U1.AB5 ; v1(229.56,121.32) 229.56,121.33 U1.T2 ; U1.C2 229.55,108.34 v1(229.61,108.34) ; v1(229.6,132.37) 229.52,132.37 U1.AG2 ; v1(226.55,115.29) 226.55,115.34 U1.K5 ; U1.E19 212.05,110.79 v1(212.5,110.34) ; v1(206.53,107.31) 206.53,107.36 U1.B25 ; v1(229.56,133.32) 229.56,133.33 U1.AH2 ; U1.AN5 226.1,138.84 v1(226.55,138.39)
  TOP w0.381: C203.1 238.04,111 ; C203.1 237.4,111.59 ; C203.1 237.4,110.4
  BOTTOM w0.229: C213.1 199.08,110.86
  BOTTOM w0.381: C2664.1 229.55,121.35 229.55,121.35 229.56,121.34 v1(229.56,121.32) ; C2816.1 227.05,127.76 v1(226.57,127.29) ; v1(229.6,132.37) 229.55,132.32 229.55,132.3 C2706.1 ; C205.1 205.55,107.34 v1(205.57,107.34) ; v1(229.6,120.37) 229.55,120.32 229.55,120.29 C207.1 ; v1(212.5,110.34) 213,110.84 C3002.1 ; C206.1 206.06,106.84 v1(206.53,107.31) ; v1(226.55,126.39) 227.06,125.89 C212.1 ; v1(226.55,114.39) 226.55,114.29 C3179.1 ; v1(226.55,115.29) 226.55,115.34 C216.1 ; C2743.1 226.02,137.86 v1(226.55,138.39) ; v1(211.6,110.34) 212.05,110.79 C204.1 ; v1(229.61,108.34) 229.56,108.34 229.55,108.33 229.55,108.29 C2856.1 ; C215.1 200.05,109.89 v1(200.5,110.34) ; 199.08,110.86 v1(199.6,110.34) ; v1(229.56,133.32) 229.56,133.34 C219.1 ; v1(229.55,109.32) 230.08,109.84 C209.1
  vias: v1(237.17,109.85) v1(237.17,108.86) v1(238.06,109.85)
FC_TVDD1P2_3: length 25.6
  TOP w0.229: v1(229.58,170.34) 229.55,170.34 U1.CD2 ; U1.AW2 229.57,145.37 v1(229.6,145.37) ; U1.BU5 226.05,162.89 v1(226.55,163.39) ; U1.BL2 229.56,157.35 v1(229.59,157.35) ; v1(205.57,171.35) 205.56,171.35 U1.CE26 ; v1(226.55,152.29) 226.55,152.34 U1.BF5 ; U1.CB19 212.05,167.89 v1(212.5,168.34) ; v1(229.56,158.32) 229.56,158.33 229.55,158.34 U1.BM2 ; v1(229.57,146.31) 229.56,146.31 229.1,145.84 U1.AY2 ; v1(226.55,140.29) 226.55,140.34 U1.AP5 ; v1(206.52,171.39) 206.52,171.32 U1.CE25 ; v1(226.61,164.29) 226.55,164.29 226.1,163.84 U1.BV5 ; v1(211.6,168.34) 211.55,168.34 U1.CB20 ; U1.BE5 226.55,151.34 v1(226.55,151.39) ; U1.CC2 229.56,169.35 v1(229.56,169.37)
  BOTTOM w0.381: C2992.1 229.07,158.82 229.56,158.34 v1(229.56,158.32) ; C2766.1 226.55,140.29 v1(226.55,140.29) 227.04,140.78 C3109.1 ; C2806.1 231.46,174.72 ; C2806.1 230.86,174.09 ; C2806.1 232.06,174.09 ; v1(206.52,171.39) 206.52,171.37 207.02,170.87 C226.1 ; v1(226.61,164.29) 226.08,164.81 C3033.1 ; v1(229.59,157.35) 229.56,157.35 229.1,156.89 C2798.1 ; v1(226.55,151.39) 226.02,150.87 C2849.1 ; v1(205.57,171.35) 205.07,170.84 C2770.1 ; C2661.1 226.07,152.77 v1(226.55,152.29) ; v1(229.6,145.37) 229.57,145.34 229.57,145.3 C3171.1 ; v1(226.55,163.39) 226.07,162.91 C2694.1 ; C2731.1 229.54,170.34 v1(229.58,170.34) 230.06,170.82 C2921.1 ; v1(229.57,146.31) C2846.1 ; C227.1 211.07,167.82 v1(211.6,168.34) ; v1(212.5,168.34) 212.05,167.9 C2734.1 ; v1(229.56,169.37) 229.56,169.34 229.12,168.91 C2889.1
  vias: v1(219.42,175.05) v1(222.62,175.08) v1(223.51,175.08) v2(210.76,175.26)
IMN1: length 428.6
  TOP w0.229: D435.31 67.22,131.69
  TOP w0.254: R3608.1 60.29,138.02 v1(60.39,137.92) 61.15,137.92 62.62,136.45 62.62,132.64 63.94,131.32 66.48,131.32 66.86,131.69 67.22,131.69 ; v1(382.59,177.42) 380.94,175.77 R3655.1
  SIG9 w0.254: v1(60.39,137.92) 60.64,138.17 61.53,138.17 62.93,139.57 62.93,145.66 53.28,155.31 53.28,186.42 64.31,197.44 153.46,197.44 163.4,207.39 211.58,207.39 216.53,202.44 280.28,202.44 291.46,191.26 321.32,191.26 326.14,196.09 365.77,196.09 376.87,184.99 376.87,184.15 382.59,178.43 v1(382.59,177.42)
  BOTTOM w0.13: v1(60.39,137.92) v2(59.63,137.92)
IMN2: length 424.1
  TOP w0.229: 67.35,141.85 D436.31
  TOP w0.254: 67.35,141.85 66.61,141.85 66.1,141.35 63.06,141.35 61.91,142.49 60.77,142.49 60.36,142.09 v1(60.26,142.09) R3613.1 ; v1(379.29,184.53) 379.29,183.89 383.22,179.96 383.22,176.91 381.7,175.38 381.7,174.49 381.95,174.23 R3657.1
  SIG9 w0.254: v1(379.29,184.53) 379.29,185.04 366.46,197.86 325.41,197.86 320.84,193.29 291.94,193.29 281.02,204.21 217.26,204.21 212.31,209.16 162.67,209.16 152.6,199.1 74.49,199.1 74.36,198.97 68.8,198.97 68.68,199.1 63.32,199.1 51.5,187.28 51.5,154.05 60.77,144.78 60.77,142.59 v1(60.26,142.09)
  BOTTOM w0.13: v1(60.26,142.09) v2(59.37,142.09)
IMN3: length 400.7
  TOP w0.229: D437.31 67.22,152.01
  TOP w0.254: R3615.1 v1(60.26,158.34) 61.35,158.34 62.46,157.24 62.46,153.33 64.2,151.58 66.05,151.58 66.48,152.01 67.22,152.01 ; v1(383.98,175) 384.65,174.34 R3661.1
  SIG9 w0.254: v1(60.26,158.34) 58.99,159.61 58.99,160.5 58.64,160.86 58.64,189.89 64.96,196.21 154.03,196.21 163.93,206.12 211.05,206.12 216,201.17 279.75,201.17 291.18,189.74 321.59,189.74 326.67,194.82 360.62,194.82 366.2,189.23 366.2,186.69 369.25,183.64 375.56,183.64 381.23,177.97 381.23,176.99 382.08,176.15 382.97,176.15 383.98,175.13 v1(383.98,175)
  BOTTOM w0.13: v1(60.26,158.34) v2(59.5,158.34)
IMN4: length 405.3
  TOP w0.229: D438.31 66.74,162.17
  TOP w0.254: v1(382.71,175) 383.35,174.37 383.35,173.76 383.5,173.61 R3662.1 ; 66.74,162.17 66.28,161.72 64.02,161.72 62.8,162.94 60.69,162.94 v1(60.29,162.53) 60.16,162.41 R3620.1
  SIG8 w0.254: v1(382.71,175) 382.59,175.13 382.59,175.71 380.96,177.33 380.96,178.28 378.84,180.4 375.87,180.4 371.86,184.42 371.86,187.42 370.95,188.33 368.47,188.33 367.86,188.95 367.86,191.9 361.38,198.37 325.2,198.37 320.62,193.79 292.16,193.79 281.23,204.72 217.47,204.72 212.52,209.67 162.46,209.67 152.36,199.58 75.77,199.58 75.64,199.45 69.35,199.45 69.15,199.66 63.16,199.66 50.99,187.49 50.99,177.45 58.86,169.58 58.86,163.95 v1(60.29,162.53)
  BOTTOM w0.13: v1(60.29,162.53) v2(59.53,162.53)
IMN5: length 387.3
  TOP w0.229: D439.31 67.22,172.33
  TOP w0.254: R3622.1 v1(60.29,178.66) 60.57,178.94 61.07,178.94 62.46,177.56 62.46,173.65 64.27,171.83 66.36,171.83 66.86,172.33 67.22,172.33 ; v1(385.25,170.81) 385.23,170.79 R3666.1
  SIG8 w0.254: v1(385.25,170.81) 384.62,171.45 383.34,171.45 380.99,173.8 380.99,175.08 377.24,178.83 375.22,178.83 369.45,184.6 367.15,184.6 365.57,186.18 365.57,191.41 360.38,196.59 325.93,196.59 321.24,191.89 291.54,191.89 280.49,202.94 216.74,202.94 211.79,207.89 163.19,207.89 153.25,197.95 63.91,197.95 58.65,192.69 58.65,185.46 57.98,184.78 57.98,182.5 58.53,181.94 58.53,180.41 v1(60.29,178.66)
  BOTTOM w0.13: v1(60.29,178.66) 59.73,178.66 v2(59.5,178.43)
IMN6: length 375.1
  TOP w0.229: 67.35,182.49 D440.31
  TOP w0.254: R3667.1 385.94,168.91 v1(386.02,168.83) ; R3627.1 v1(60.29,182.73) 60.82,183.26 61.79,183.26 63.06,181.99 66.23,181.99 66.74,182.49 67.35,182.49
  SIG8 w0.254: v1(60.29,182.73) 59.73,183.28 59.73,184 60.34,184.6 60.34,191.55 64.83,196.05 153.86,196.05 163.93,206.12 211.05,206.12 216,201.17 279.75,201.17 291.18,189.74 321.59,189.74 326.67,194.82 359.01,194.82 362.99,190.83 362.99,185.71 366.46,182.24 369.58,182.24 382.99,168.83 v1(386.02,168.83)
  BOTTOM w0.13: v1(60.29,182.73) 60.36,182.73 v2(60.9,183.26)
IMN7: length 61.9
  TOP w0.229: D442.31 348.87,144.29
  TOP w0.254: 348.87,144.29 349.48,144.29 349.99,144.8 351.82,144.8 353.63,142.99 353.63,141.14 v1(354.29,140.48) R3629.1 ; R3668.1 v1(386.14,166.62)
  SIG7 w0.254: v1(386.14,166.62) 386.91,165.86 386.91,165.22 386.27,164.59 386.27,155.51 382.88,152.12 376.53,152.12 370.18,145.77 365.8,145.77 361.25,141.22 355.92,141.22 355.41,140.71 354.52,140.71 v1(354.29,140.48)
  BOTTOM w0.13: v1(386.14,166.62) v2(385.38,166.62)
IMN8: length 69.8
  TOP w0.229: D441.31 349.59,134.13
  TOP w0.254: R3669.1 v1(386.91,167.76) ; R3634.1 354.57,136.42 v1(354.32,136.17) 354.26,136.17 353.63,135.54 353.63,135.25 353.02,134.64 350.1,134.64 349.59,134.13
  SIG7 w0.254: v1(386.91,167.76) 387.79,167.76 388.68,166.88 388.68,163.95 388.05,163.32 388.05,154.81 383.6,150.37 377.25,150.37 370.9,144.02 366.31,144.02 362.39,140.1 362.39,136.4 361.12,135.13 356.55,135.13 355.51,136.17 v1(354.32,136.17)
  BOTTOM w0.13: v1(386.91,167.76) v2(386.14,167.76)
IMN9: length 44.3
  TOP w0.229: D443.31 348.87,164.61
  TOP w0.254: R3636.1 v1(354.23,160.8) 353.63,161.4 353.63,163.31 351.9,165.05 349.79,165.05 349.36,164.61 348.87,164.61 ; v1(384.48,165.54) 385,165.02 R3671.1
  SIG7 w0.254: v1(384.48,165.54) 384.45,165.57 384.35,165.57 383.1,164.31 374.43,164.31 373.7,163.57 358.58,163.57 356.17,161.16 354.59,161.16 v1(354.23,160.8)
  BOTTOM w0.13: v1(354.23,160.8) v2(355,160.8)
IMN10: length 47.9
  TOP w0.229: D444.31 348.98,154.45
  TOP w0.254: 348.98,154.45 349.46,154.94 353.27,154.94 353.76,155.43 353.76,156.21 v1(354.27,156.72) 354.29,156.74 R3641.1 ; v1(384.54,164.08) 385,163.62 R3672.1
  SIG7 w0.254: v1(354.27,156.72) 354.52,156.72 355.36,155.88 360.39,155.88 361.53,157.02 361.53,161.27 362.24,161.97 373.55,161.97 374.08,161.44 377.08,161.44 377.81,162.18 383.76,162.18 384.52,162.94 384.52,164.06 v1(384.54,164.08)
  BOTTOM w0.13: v1(354.27,156.72) v2(355.03,156.72)
IMN11: length 71.5
  TOP w0.229: D445.31 349.21,184.93
  TOP w0.254: 349.21,184.93 349.59,185.31 351.95,185.31 353.78,183.49 353.78,181.68 v1(354.33,181.12) R3643.1 ; R3673.1 387.52,161.14 388.56,162.18 389.7,162.18 v1(389.95,162.43)
  SIG7 w0.254: v1(354.33,181.12) 355.16,180.3 355.16,178.61 357.24,176.53 369.48,176.53 370.28,177.33 374.52,177.33 375.6,178.41 379.39,178.41 379.67,178.69 384.47,178.69 384.75,178.41 384.77,178.41 385.25,177.92 385.25,175.51 387.16,173.61 388.49,173.61 391.48,170.62 391.48,163.07 390.84,162.43 v1(389.95,162.43)
  BOTTOM w0.13: v1(354.33,181.12) v2(355.1,181.12)
IMN12: length 57.8
  TOP w0.229: D446.31 348.83,174.77
  TOP w0.254: R3648.1 354.54,177.06 v1(354.29,176.81) 353.76,176.27 353.76,175.64 353.4,175.28 350.1,175.28 349.59,174.77 348.83,174.77 ; R3674.1 385.74,162.15 389.7,166.11 389.7,167.46 v1(389.06,168.09)
  SIG7 w0.254: v1(354.29,176.81) 354.62,176.81 356.62,174.81 370.19,174.81 371.06,175.68 374.93,175.68 375.29,175.32 375.29,174.69 376.62,173.35 377.76,173.35 379.16,171.96 385.89,171.96 389.06,168.78 v1(389.06,168.09)
  BOTTOM w0.13: v1(354.29,176.81) v2(355.06,176.81)
INTL0: length 52.9
  TOP w0.13: v1(18.25,151.13) 18.25,151.6 U123.T2
  SIG10 w0.155: v1(18.25,151.13) 18.25,150.62 17.71,150.09 17.71,148.18 18.05,147.84 18.51,147.84 21.41,144.95 21.41,143.55 22.59,142.37 22.59,136.73 28.3,131.02 28.3,109.05 v1(29.65,107.69)
  BOTTOM w0.13: R2590.2 v1(29.65,107.69) v2(29.65,108.46)
INTL1: length 119.4
  TOP w0.13: v1(17.11,164.08) 17.42,164.08 18.5,163 19.25,163 U123.D2
  SIG4 w0.155: v1(17.21,80.39) 17.72,79.88 17.72,79.12 16.77,78.17 14.74,78.17 12.89,80.02 12.89,83.74 11.96,84.68 11.96,87.31 11.34,87.93 11.34,97.31 9.33,99.31 6.16,99.31 3.12,102.35 3.12,131.31 4.67,132.86 4.67,164.02 8.67,168.02 12.89,168.02 15.3,165.61 16.32,165.61 16.57,165.35 16.57,164.61 v1(17.11,164.08)
  BOTTOM w0.13: R2588.1 16.98,78.84 16.7,79.12 16.7,79.88 v1(17.21,80.39)
INTL2: length 130.6
  TOP w0.13: v1(16.07,159.76) 16.55,159.28 17.54,159.28 17.66,159.15 18.48,159.15 18.63,159 20.85,159 U123.H4
  SIG10 w0.155: v1(43.37,82.17) 42.51,82.17 41.7,82.97 41.7,84.57 36.8,89.48 34.52,89.48 33.49,90.51 23.35,90.51 17.74,96.11 16.35,96.11 13.02,99.44 5.14,99.44 3.53,101.05 3.53,123.2 4.36,124.02 4.36,127.76 3.53,128.58 3.53,158.02 8.95,163.45 12.2,163.45 15.89,159.76 v1(16.07,159.76)
  BOTTOM w0.13: v2(41.34,82.93) 42,82.27 R2586.2 43.27,82.27 v1(43.37,82.17)
INTL3: length 132.3
  TOP w0.13: U123.L1 18.04,157 17.82,157.22 v1(17.11,157.22)
  SIG10 w0.155: v1(17.11,157.22) 17.08,157.22 16.45,157.86 15.78,157.86 13.62,160.02 8.12,160.02 4.98,156.88 4.98,133.4 5.76,132.63 5.76,123.16 4.93,122.33 4.93,116.55 6.54,114.93 6.54,114.17 5.02,112.65 5.02,103.86 7.15,101.72 17.98,101.72 22.54,97.15 22.54,96.05 26.69,91.9 33.3,91.9 34.32,91.9 34.44,92.02 34.82,92.02 35.97,90.87 37.48,90.87 42.12,86.23 43.56,86.23 45.78,84 45.78,82.78 46.8,81.76 46.8,77.72 47.18,77.34 47.18,76.71 v1(47.69,76.2)
  BOTTOM w0.13: v1(47.69,76.2) 48.2,76.2 v2(48.58,76.58) 48.58,77.32 R2592.1
INTL4: length 113.5
  TOP w0.13: U123.T3 20.45,152.77 19.19,151.51 19.19,150.16 v1(18.25,149.22)
  SIG10 w0.155: v1(18.25,149.22) 21.87,145.6 21.87,143.86 23.07,142.66 23.07,136.9 28.77,131.21 28.77,109.54 30.16,108.15 30.16,107.44 30.61,106.99 32.24,106.99 36.17,103.06 39.59,103.06 40.83,101.82 45.43,101.82 49.85,97.41 51.13,97.41 52.24,96.3 56.98,96.3 58.7,94.58 61.84,94.58 64.61,91.8 67.27,91.8 69.16,89.91 71.69,89.91 71.95,89.66 71.95,88.9 72.92,87.92 72.92,80.86 v1(72.45,80.39)
  BOTTOM w0.13: R2626.2 72.1,78.84 71.95,78.99 71.95,79.88 v1(72.45,80.39) v2(73.34,80.39)
INTL5: length 112.2
  TOP w0.13: U123.P1 18.14,154.6 17.54,154 16.55,154 v1(16.09,153.54) ; R2629.1 v1(72.45,85.34)
  SIG10 w0.155: v1(16.09,153.54) 16.6,153.03 16.6,151.46 16.76,151.3 16.76,146.59 21.64,141.71 21.64,136.37 27.35,130.66 27.35,108.17 30.42,105.11 30.42,104.77 30.54,104.65 30.9,104.65 32.06,103.48 33.06,103.48 34.41,102.13 36.95,102.13 38.45,100.63 40.78,100.63 41.59,99.82 45.91,99.82 49.47,96.26 50.36,96.26 52.18,94.44 57.35,94.44 58.28,93.51 61.07,93.51 64.12,90.46 64.12,89.27 64.87,88.52 71.18,88.52 71.95,87.75 71.95,85.85 v1(72.45,85.34)
  BOTTOM w0.13: v2(14.9,152.4) 14.9,152.5 15.94,153.54 v1(16.09,153.54)
INTL6: length 114.2
  TOP w0.13: v1(24.57,151.13) 24.57,151.31 25.1,151.83 25.1,152.45 25.25,152.6 U123.T9
  SIG10 w0.155: v1(24.57,151.13) 25.03,150.67 25.03,148.66 26.52,147.17 26.52,144.79 28.76,142.55 29.48,142.55 31.62,140.41 32.14,140.41 33.69,138.86 33.69,137.62 34.37,136.94 35.33,136.94 35.34,136.94 35.81,136.94 51.02,121.73 51.02,113.15 54.75,109.42 54.75,108.25 57.84,105.17 59,105.17 59.47,104.7 v1(61.91,104.7) 62.73,104.7 66.76,100.67 67.67,100.67 69.86,98.47 77.18,98.47 84.52,91.13 84.52,89.02 85.66,87.88 86.63,87.88 89.43,85.08 89.43,80.34 88.07,78.99 87.21,78.99 v1(86.7,79.5)
  BOTTOM w0.13: R2637.2 86.14,78.84 86.3,78.99 86.3,79.25 86.55,79.5 v1(86.7,79.5)
INTL7: length 115.4
  TOP w0.13: U123.P7 v1(23.25,154.2) ; R2628.1 85.43,84.68 85.28,84.83 85.28,85.72 v1(85.79,86.23)
  SIG10 w0.155: v1(23.25,154.2) 23.25,152.86 22.8,152.4 22.8,149.04 25.21,146.63 25.21,144.19 26.99,142.42 26.99,141.8 33.65,135.14 33.65,133.95 34,133.59 34,115.71 33.49,115.2 33.49,114.27 33.96,113.8 33.96,111.64 36.98,108.61 47.05,108.61 53.09,102.57 61.72,102.57 67.27,97.03 76.14,97.03 81.06,92.1 81.06,89.6 84.43,86.23 v1(85.79,86.23)
  BOTTOM w0.13: v2(85.53,87.12) 85.53,86.48 v1(85.79,86.23)
INTL8: length 138.3
  TOP w0.13: v1(30.42,150.11) 30.95,150.64 30.95,152.11 U123.T15
  SIG10 w0.155: v1(30.42,150.11) 31.18,149.35 33.46,149.35 49.45,133.36 49.45,130.13 57.4,122.18 57.4,121.27 60.29,118.39 60.8,118.39 67.7,111.48 77.17,111.48 94.83,93.82 119.22,93.82 123.05,89.99 123.05,88.11 123.67,87.49 123.67,85.61 122.74,84.68 122.74,80.9 v1(123.25,80.39)
  BOTTOM w0.13: v1(123.25,80.39) 122.69,79.83 122.69,79.3 R2666.2 ; v2(32.32,148.71) 31.45,149.07 v1(30.42,150.11)
INTL9: length 131
  TOP w0.13: v1(26.86,151.13) 27.25,151.52 27.25,153.4 U123.R11 ; R2667.1 122.59,84.68 122.75,84.83 122.75,85.72 v1(122.24,86.23)
  SIG10 w0.155: v1(122.24,86.23) 121.77,86.7 120.25,86.7 114.9,92.05 94.75,92.05 79.51,107.29 78.72,107.29 78.28,107.73 78.28,108.51 76.76,110.03 67.29,110.03 60.48,116.85 59.77,116.85 54.58,122.04 54.58,123.14 46.04,131.68 46.04,134.61 33.85,146.81 31.43,146.81 29.53,148.71 29.15,148.71 28.77,149.1 28.77,150.29 27.93,151.13 v1(26.86,151.13)
INTL10: length 153.3
  TOP w0.13: R2670.2 135.93,78.84 136.08,78.99 136.08,79.22 136.4,79.54 136.4,79.94 v1(136.84,80.39) ; U123.P13 v1(28.85,154.2)
  SIG10 w0.155: v1(136.84,80.39) 136.39,80.85 136.39,82.88 135.45,83.82 132.43,83.82 132.03,84.21 132.03,86.54 129.98,88.59 129.98,91.84 123.2,98.62 96.51,98.62 77.83,117.3 68.84,117.3 60.63,125.51 60.63,133.51 57.69,136.45 49.89,136.45 47.13,139.21 47.13,141.38 46.4,142.11 44.64,142.11 42.12,144.63 v1(41.7,144.63) 40.94,144.63 35.2,150.37 35.2,151.76 34.89,152.07 34.58,152.07 34.11,152.54 34.11,153.16 33.99,153.29 31.51,153.29 30.74,154.05 30.16,154.05 29.84,153.72 29.33,153.72 v1(28.85,154.2)
INTL11: length 146.9
  TOP w0.13: U123.M15 30.45,155.8 31.33,155.8 31.56,155.57 33.16,155.57 v1(33.62,156.03) ; R2673.1 135.83,84.68 136.08,84.94 136.08,85.6 v1(135.45,86.23)
  SIG10 w0.155: v1(33.62,156.03) 34.18,156.59 34.87,156.59 36.59,154.86 40.78,154.86 46.55,149.1 47.31,149.1 47.82,148.59 47.82,147.7 49.59,145.92 52.13,145.92 55.44,142.62 56.96,142.62 58.99,140.59 58.99,140.57 59.99,139.57 61.14,139.57 61.54,139.17 61.54,136.81 62.98,135.37 62.98,126.93 70.23,119.68 79.33,119.68 98.06,100.94 125.06,100.94 134.36,91.65 134.36,90.65 135.06,89.94 135.06,88.05 134.94,87.92 134.94,86.74 v1(135.45,86.23)
INTL12: length 188.6
  TOP w0.13: U123.H16 31.74,159.4 32.02,159.69 33.19,159.69 v1(33.62,160.12)
  SIG10 w0.155: v1(168.21,80.39) 167.57,81.03 167.57,83.48 166.21,84.84 161,84.84 159.59,86.25 158.58,86.25 157.15,84.82 145.99,84.82 142.8,88.01 141.18,88.01 140.41,88.79 140.41,93.87 139.63,94.65 139.63,95.59 136.21,99.01 111.03,124.19 81.52,124.19 78.82,121.48 71.44,121.48 65.82,127.1 65.82,131.24 65.26,131.8 65.26,135.96 64.02,137.2 64.02,139.21 63.4,139.83 63.4,141.54 55.31,149.63 52.24,149.63 51.5,150.37 50.86,150.37 50.23,151 50.23,151.64 48.45,153.41 46.43,153.41 40.39,159.46 35.93,159.46 35.75,159.64 34.1,159.64 v1(33.62,160.12)
  BOTTOM w0.13: v1(168.21,80.39) 167.96,80.13 v2(167.45,80.13) R2707.2
INTL13: length 190.5
  TOP w0.13: v1(168.21,87.25) 168.08,87.25 167.58,86.74 166.18,86.74 165.93,86.48 165.93,84.83 166.08,84.68 R2711.1 ; v1(33.62,161.16) 33.03,161.75 32.53,161.75 31.93,161.15 31.56,161.15 31.41,161 U123.F16
  SIG10 w0.155: v1(33.62,161.16) 33.79,161.16 34.39,161.76 35.74,161.76 36.15,162.17 40.28,162.17 43.25,159.2 45.2,159.2 v1(47.31,157.1) 48.33,157.1 50.87,154.56 53.4,154.56 56.83,151.13 57.59,151.13 65.57,143.16 65.57,140.14 65.72,139.99 65.72,138.13 66.65,137.2 66.65,132.4 67.21,131.83 67.21,127.96 72.3,122.88 76.47,122.88 79.48,125.89 111.3,125.89 139.19,98 142.26,98 144.12,96.14 144.12,89.79 146.6,87.31 155.59,87.31 157.29,89.01 158.37,89.01 158.77,89.41 159.57,89.41 161.22,87.75 165.04,87.75 165.53,87.26 166.73,87.26 167.26,86.74 167.7,86.74 v1(168.21,87.25)
INTL14: length 279.8
  TOP w0.13: U123.E3 v1(20.05,162.2)
  SIG10 w0.155: v1(179.77,80.39) 180.69,81.31 180.69,84.86 181.42,85.6 182.05,85.6 182.25,85.79 182.25,86.55 179.77,89.02 179.77,90.32 176.74,93.35 175.16,93.35 173.47,95.05 171.71,95.05 169.99,96.76 163.97,96.76 163.55,97.19 162.81,97.19 156.88,103.11 153.26,103.11 151.09,105.28 149.39,105.28 146.44,108.23 145.1,108.23 144.29,109.04 140.98,109.04 117.59,132.43 117.59,191.26 111.82,197.02 111.82,197.61 108.72,200.71 100.49,200.71 100.39,200.61 80.12,200.61 79.48,201.25 77.47,201.25 76,199.78 73.36,199.78 72.88,199.3 69.27,199.3 68.74,199.83 65.51,199.83 62.8,202.54 61,202.54 46.55,188.08 46.55,185.93 34.36,173.74 31.44,173.74 28.52,170.82 23.44,170.82 20.38,167.76 20.38,164.97 19.49,164.08 19.49,162.76 v1(20.05,162.2)
  BOTTOM w0.13: v1(179.77,80.39) 180.02,80.13 v2(180.53,80.13) 180.53,79.63 180.28,79.37 180.28,78.99 180.12,78.84 R2706.2
INTL15: length 266.9
  TOP w0.13: R2710.1 180.12,84.68 180.28,84.83 180.28,85.72 v1(180.78,86.23) ; U123.G6 v1(22.45,160.6)
  SIG10 w0.102: v1(22.45,160.6) 22.85,161 22.85,164.11
  SIG10 w0.155: v1(180.78,86.23) 179.39,87.63 178.33,87.63 172.74,93.22 171.22,93.22 169.12,95.31 161.85,95.31 160.61,96.56 159.04,96.56 156.82,98.78 156.82,99.71 155.59,100.94 153.11,100.94 150.16,103.89 147.76,103.89 146.24,105.41 145.08,105.41 143.77,106.72 138.15,106.72 116.19,128.68 116.19,190.22 107.95,198.47 96.7,198.47 96.08,199.09 95.05,199.09 94.42,198.47 86.1,198.47 85.46,197.82 81.05,197.82 79.78,199.09 77.53,199.09 76.91,198.47 73.91,198.47 73.43,197.99 63.19,197.99 60.31,195.1 58.37,195.1 57.07,193.8 57.07,193.11 55.79,191.84 54.5,191.84 37.38,174.71 37.38,171.04 35.76,169.43 26.25,169.43 22.85,166.03 22.85,164.11
INTL16: length 312.5
  TOP w0.13: U124.D1 395.61,184.45 394.59,185.47 393.74,185.47 v1(393.26,185.95)
  SIG10 w0.155: v1(393.26,185.95) 393.26,186.23 392.29,187.2 391.99,187.2 391.6,187.58 391.6,188.08 391.09,188.59 391.09,189.88 388.77,192.2 383.28,192.2 382.51,192.98 375.76,192.98 375.29,193.44 368.78,193.44 359.18,203.05 331.6,203.05 318.58,216.07 304.65,216.07 303.87,215.29 285.12,215.29 282.79,212.97 282.79,210.38 280.62,208.21 280.62,184.69 268.44,172.51 268.44,169.97 268.67,169.74 268.67,114.03 254.44,99.8 254.44,88.55 253.66,87.77 252.58,87.77 250.41,85.61 250.41,84.31 248.39,82.29 240.55,82.29 236,86.85 230.11,86.85 229.96,86.69 226.58,86.69 223.7,83.82 220.54,83.82 v1(218,81.28)
  BOTTOM w0.13: R2746.2 216.57,78.84 216.73,78.99 216.73,79.63 v2(217.23,80.13) 217.23,80.52 v1(218,81.28)
INTL17: length 309.3
  TOP w0.13: v1(393.89,188.59) 393.89,188.01 394.73,187.17 394.73,186.76 395.85,185.65 396.42,185.65 U124.C2 ; R2748.1 v1(216.22,85.34)
  SIG10 w0.155: v1(393.89,188.59) 393.42,189.06 393.42,190.04 389.39,194.06 383.81,194.06 383.5,194.37 376.99,194.37 376.53,194.84 369.71,194.84 360.11,204.44 332.53,204.44 319.2,217.77 285.27,217.77 281.4,213.9 281.4,211.48 277.3,207.39 277.3,194.56 275.83,193.09 v1(275.83,183.51) 275.83,181.87 266.27,172.32 266.27,170.48 265.59,169.8 265.59,113.2 252.58,100.18 252.58,96.14 251.03,94.59 251.03,88.7 248.7,86.38 248.7,85.92 248.26,85.47 240.47,85.47 237.39,88.55 234.29,88.55 234.07,88.77 230.1,88.77 229.72,88.39 226.55,88.39 225.46,87.31 218.57,87.31 216.6,85.34 v1(216.22,85.34)
INTL18: length 246.5
  TOP w0.13: v1(395.41,173.44) U124.T2
  SIG10 w0.155: v1(228.54,79.5) 227.9,78.86 227.9,73.91 228.75,73.07 248.21,73.07 248.55,73.4 250.25,73.4 251.14,72.51 278.99,72.51 281.06,74.59 281.06,80.12 287,86.06 287,87.56 288.34,88.9 291.78,88.9 314.14,111.25 351.45,111.25 363.41,123.21 363.41,134.37 364.92,135.89 364.99,135.89 365.31,136.2 365.31,143.58 366.45,144.72 366.45,153.37 370.14,157.06 370.14,163.7 371.22,164.78 379.32,164.78 379.78,165.24 379.78,168.19 383.04,171.45 386.39,171.45 388.08,173.15 392.42,173.15 392.49,173.23 395.2,173.23 v1(395.41,173.44)
  BOTTOM w0.13: v2(396.15,172.39) 395.41,173.12 v1(395.41,173.44) ; R2754.2 229.2,78.84 229.04,78.99 229.04,79.37 228.92,79.5 v1(228.54,79.5)
INTL19: length 297.7
  TOP w0.13: v1(394.27,184.91) 394.69,184.91 395.55,184.05 396.42,184.05 U124.E2 ; R2747.1 229.91,84.68 230.06,84.83 230.06,85.34 230.95,86.23 v1(231.33,86.23)
  SIG10 w0.155: v1(394.27,184.91) 393.71,185.47 393.06,185.47 392.79,185.74 392.79,186.03 392.13,186.69 391.73,186.69 391.1,187.32 391.1,187.91 390.63,188.38 390.63,189.57 388.46,191.74 382.42,191.74 381.64,192.51 375.45,192.51 374.98,192.98 368.32,192.98 358.71,202.59 331.29,202.59 318.89,214.98 305.26,214.98 305.1,214.83 285.43,214.83 283.26,212.66 283.26,210.07 281.09,207.9 281.09,184.5 268.92,172.34 268.92,170.59 269.18,170.34 269.18,113.88 256.45,101.15 256.45,95.52 255.21,94.28 255.21,88.39 253.97,87.16 252.73,87.16 251.03,85.45 251.03,84.21 248.39,81.58 240.49,81.58 238.17,83.9 235.38,83.9 233.05,86.23 v1(231.33,86.23)
  BOTTOM w0.13: v2(231.84,86.87) 231.33,86.36 v1(231.33,86.23)
INTL20: length 219.4
  TOP w0.13: U124.K1 395.24,179.65 395,179.88 394.09,179.88 393.64,180.34 v1(393.26,180.34)
  SIG10 w0.155: v1(393.26,180.34) 392.75,179.83 391.58,179.83 387.9,183.51 364.75,183.51 363.92,182.67 363.92,179.75 359.95,175.78 357.26,175.78 352.2,170.72 352.2,162.46 351.12,161.37 351.12,155.48 350.34,154.71 350.34,153.16 351.12,152.38 351.12,146.81 349.73,145.41 349.73,141.23 349.26,140.76 349.26,131.24 342.71,124.69 290.61,124.69 265.75,99.82 265.75,82.77 263.86,80.88 263.86,79.77 262.83,78.74 261.68,78.74 261.05,79.37 261.05,79.75 v1(260.41,80.39)
  BOTTOM w0.13: v2(261.3,80.36) 261.28,80.39 v1(260.41,80.39) 259.91,79.88 259.91,78.97 260.03,78.84 R2788.2
INTL21: length 233.1
  TOP w0.13: R2792.1 260.9,84.68 261.05,84.83 261.05,85.47 v1(261.81,86.23) ; U124.J2 396.42,180.05 395.46,180.05 395.24,180.26 394.35,180.26 v1(394.27,180.34)
  SIG10 w0.155: v1(394.27,180.34) 393.79,180.82 391.91,180.82 386.13,186.6 365.09,186.6 363.05,188.64 355.64,188.64 348.36,195.92 331.6,195.92 326.68,191.01 309.79,191.01 308.14,189.35 292.12,189.35 274.64,171.88 274.64,112.3 263.27,100.93 263.27,87.69 v1(261.81,86.23)
  BOTTOM w0.13: v1(261.81,86.23) 261.51,85.93 v2(261.11,85.93)
INTL22: length 195.7
  TOP w0.13: U124.P1 395.17,176.45 394.61,175.89 393.76,175.89 v1(393.26,175.38)
  SIG10 w0.155: v1(275.12,81.02) 276.54,82.44 276.54,89.15 277.81,90.42 277.81,93.47 281.4,97.05 281.4,101.12 296.87,116.59 351.6,116.59 359.13,124.12 359.13,135.26 361.19,137.32 361.19,144.79 362.43,146.03 362.43,154.74 363.94,156.26 363.94,157.88 364.3,158.24 364.57,158.24 365.77,159.44 365.77,169.15 367.7,171.09 367.7,171.6 371.7,175.6 380.38,175.6 380.71,175.93 384.28,175.93 385.47,177.12 389.71,177.12 391.45,175.38 v1(393.26,175.38)
  BOTTOM w0.13: v1(275.12,81.02) 275.12,80.62 v2(274.64,80.13) 274.27,79.77 274.27,79.36 R2787.2
INTL23: length 193.4
  TOP w0.13: R2791.1 274.76,85.72 v1(275.27,86.23) ; U124.M2 396.42,177.65 394.42,177.65 v1(394.27,177.8)
  SIG10 w0.155: v1(275.27,86.23) 274.64,86.87 274.64,90.77 275.91,92.04 275.91,99.57 279.21,102.87 281.24,102.87 296.52,118.14 v1(339.79,118.14) 351.58,118.14 358.2,124.75 358.2,139.7 360.24,141.74 360.24,146.01 361.5,147.27 361.5,155.33 362.74,156.57 362.74,159.82 364.36,161.44 364.36,164.92 364.83,165.39 364.83,170.41 370.98,176.56 379.63,176.56 381.15,178.08 390.09,178.08 391.46,176.71 392.64,176.71 393.11,177.18 393.65,177.18 v1(394.27,177.8)
INTL24: length 155.8
  TOP w0.13: R2826.2 310.55,82.27 310.83,82.55 310.83,83.82 v1(311.34,84.33) ; v1(398.41,171.07) 399.29,171.95 399.29,173.08 400.42,174.21 400.42,175.25 U124.R7
  SIG10 w0.155: v1(398.41,171.07) 396.52,169.18 396.52,168.49 395.29,167.26 394.38,167.26 394.23,167.1 393.95,167.1 391.16,164.32 389.23,164.32 387.53,162.61 387.53,161.68 384.21,158.37 380.68,158.37 380.17,157.86 380.17,156.97 379.54,156.33 378.75,156.33 373.12,150.7 373.12,146.81 372.35,146.03 372.35,143.53 370.92,142.1 370.92,137.48 370.19,136.75 370.19,133.7 369.09,132.6 369.09,117.06 366.46,114.42 364.3,114.42 361.51,111.63 359.6,111.63 351.86,103.89 322.69,103.89 311.21,92.41 311.21,84.45 v1(311.34,84.33)
  BOTTOM w0.13: v1(311.34,84.33) v2(310.58,84.33)
INTL25: length 162.7
  TOP w0.13: v1(398.46,172.97) 398.46,173.17 399.62,174.32 399.62,175.25 U124.R6 ; R2828.1 v1(312.36,82.93)
  SIG10 w0.155: v1(312.36,82.93) 312.61,83.18 313.5,83.18 314.33,84.01 314.33,93.72 322.86,102.26 369.63,102.26 370.59,103.22 370.59,130.48 371.47,131.36 371.47,136.22 372.19,136.95 372.19,141.57 374.56,143.93 374.56,150.32 378.92,154.68 381.68,154.68 382.79,155.79 384.94,155.79 393.26,164.11 393.26,164.61 394.21,165.55 394.81,165.55 394.97,165.71 395.77,165.71 397.29,167.23 397.29,169.12 398.9,170.72 398.9,172.54 v1(398.46,172.97)
  BOTTOM w0.13: v1(312.36,82.93) 312.36,82.42 v2(312.74,82.04)
INTL26: length 161.7
  TOP w0.13: v1(404.15,172.97) 404.15,173.85 404.42,174.11 404.42,175.25 U124.R11
  SIG10 w0.155: v1(404.15,172.97) 404.61,172.51 404.61,170.08 404.31,169.79 404.31,164.11 386.24,146.03 384.43,146.03 383.81,145.41 383.81,142.37 380.4,138.96 380.4,134.33 380.87,133.87 380.87,131 380.56,130.69 380.56,126.82 378.39,124.65 378.39,116.75 379.29,115.85 379.29,109.12 379.21,109.05 379.21,92.36 373.54,86.69 369.39,86.69 368.85,86.15 362.03,86.15 358.55,89.63 356.27,89.63 355.66,89.02 335.6,89.02 334.33,87.75 329.88,87.75 328.69,86.56 328.69,83.13 v1(326.83,81.28)
  BOTTOM w0.13: R2836.2 325.61,78.84 325.69,78.92 325.69,79.63 v2(326.07,80.01) 326.07,80.26 326.83,81.02 v1(326.83,81.28)
INTL27: length 162.7
  TOP w0.13: R2827.1 v1(325.18,85.34) ; U124.P9 v1(402.82,176.05)
  SIG10 w0.155: v1(325.18,85.34) 325.82,85.98 325.82,90.67 330.25,95.11 356.87,95.11 364.09,87.89 368.13,87.89 368.67,88.43 372.79,88.43 377.47,93.11 377.47,106.55 376.68,107.34 376.68,110.4 376.53,110.55 376.53,111.33 377.3,112.1 377.3,114.58 376.37,115.51 376.37,126.35 378.26,128.24 378.26,131.88 378.62,132.24 378.62,139.64 381.8,142.82 381.8,146.83 384.41,149.44 387.17,149.44 v1(391.57,153.83) 402.56,164.83 402.56,168.65 403.07,169.17 403.07,171.18 403.54,171.65 403.54,173.48 402.82,174.2 v1(402.82,176.05)
INTL28: length 133.3
  TOP w0.13: U124.P13 v1(406.02,176.05)
  SIG10 w0.155: v1(406.02,176.05) 406.02,175.27 407.1,174.19 407.1,171.7 407.03,171.62 407.03,145.69 404.57,143.24 404.57,109.62 400.37,105.42 390.77,105.42 383.5,98.15 383.5,92.89 382.11,91.49 382.11,88.63 376.02,82.54 370.2,82.54 369.85,82.18 366.92,82.18 366.75,82.01 365.57,82.01 364.51,83.06 359.39,83.06 v1(359.04,83.41)
  BOTTOM w0.13: v1(359.04,83.41) 358.89,83.56 v2(357.95,83.56) 357.82,83.44 R2866.2
INTL29: length 143.8
  TOP w0.13: R2867.1 354.85,78.84 v1(354.55,78.53) ; U124.N14 v1(406.82,176.85)
  SIG10 w0.155: v1(354.55,78.53) 360.54,78.53 362.03,80.03 364.04,80.03 364.63,79.44 368.94,79.44 369.36,79.86 371.51,79.86 372.02,80.36 373.41,80.36 374.05,79.72 375.29,79.72 375.76,80.18 375.76,80.3 380.01,84.55 380.01,84.55 381.68,86.23 382.57,86.23 385.05,88.7 385.05,96.2 392.81,103.96 401.39,103.96 406.12,108.69 406.12,142.47 408.44,144.79 408.44,170.66 409.38,171.6 409.38,174.28 v1(406.82,176.85)
  BOTTOM w0.13: v1(354.55,78.53) 355.16,79.14 v2(355.16,80.01)
INTL30: length 117.4
  TOP w0.13: U124.N7 v1(400.42,176.85)
  SIG8 w0.102: v1(400.42,176.85) 400.02,176.45 400.02,175.76
  SIG8 w0.155: 400.02,175.76 400.02,175.38 397.83,173.19 397.83,164.23 382.31,148.71 378.9,148.71 374.33,144.15 374.33,137.28 373.19,136.14 373.19,104.26 379.94,97.52 379.94,82.82 v1(377.63,80.52)
  BOTTOM w0.13: v2(378.4,81.4) 377.63,80.64 v1(377.63,80.52) 377.13,80.01 377.13,78.99 376.97,78.84 R2870.2
INTL31: length 127.3
  TOP w0.13: R2871.1 370.14,80.52 v1(370.78,81.15) ; U124.G4 v1(398.02,182.45)
  SIG8 w0.102: v1(398.02,182.45) 397.63,182.05 397,182.05
  SIG8 w0.155: v1(370.78,81.15) 371.41,81.79 371.41,85.91 376.07,90.56 376.07,95.99 370.14,101.91 370.14,129.41 369.38,130.17 369.38,143.69 378.39,152.69 382,152.69 390.84,161.54 390.84,165.61 389.95,166.49 389.95,167.89 390.84,168.78 390.84,178.31 392.24,179.7 394.65,179.7 397,182.05
  BOTTOM w0.13: v1(370.78,81.15) 369.89,81.15 v2(369.51,80.77)
INTL32: length 108.7
  TOP w0.13: U123.E1 18.33,161.8 17.57,162.56 16.83,162.56 16.32,163.07 v1(16.09,163.07)
  SIG4 w0.155: v1(16.09,163.07) 15.43,163.07 13.65,164.84 7.56,164.84 5.98,163.27 5.98,125.17 5.14,124.33 5.14,114.72 5.4,114.46 5.4,113.88 4.67,113.15 4.67,103.46 6.55,101.59 9.85,101.59 13.27,98.17 13.27,90.55 14.29,89.53 14.29,88.77 13.53,88.01 13.53,87.07 14.54,86.06 14.54,80.77 14.8,80.52 16.07,80.52 v1(16.19,80.39)
  BOTTOM w0.13: v1(16.19,80.39) 16.19,80.13 15.68,79.63 15.68,78.99 15.84,78.84 R2609.1
INTL33: length 122.9
  TOP w0.13: v1(17.11,165.1) 17.36,165.1 18.66,163.8 19.25,163.8 U123.C2
  SIG4 w0.155: v1(18.22,80.39) 18.73,79.88 18.73,78.99 17.44,77.7 14.13,77.7 12.11,79.72 12.11,83.45 10.1,85.47 10.1,97.41 9.46,98.04 6.05,98.04 2.66,101.43 2.66,131.51 4.21,133.05 4.21,164.27 8.59,168.65 13.02,168.65 15.56,166.11 16.57,166.11 17.11,165.58 v1(17.11,165.1)
  BOTTOM w0.13: R2613.2 18.99,79.6 v2(18.99,80.13) 18.73,80.39 v1(18.22,80.39)
INTL34: length 134.9
  TOP w0.13: v1(17.11,158.49) 17.12,158.51 18.16,158.51 18.46,158.2 19.25,158.2 U123.J2 ; R2610.1 v1(42.61,79.5)
  SIG10 w0.155: v1(17.11,158.49) 17.59,158.98 17.59,160.02 16.64,160.97 16.64,161.34 14.02,163.95 8.45,163.95 3.07,158.58 3.07,100.75 5.78,98.04 11.75,98.04 15.61,94.18 17.51,94.18 21.65,90.04 33.3,90.04 34.33,89.01 36.59,89.01 41.24,84.37 41.24,82.77 42.39,81.62 43.66,81.62 43.88,81.4 43.88,80.77 v1(42.61,79.5)
  BOTTOM w0.13: v2(43.37,78.74) v1(42.61,79.5)
INTL35: length 122.3
  TOP w0.13: R2605.2 43.52,85.44 v1(43.37,85.6) ; U123.J1 18.78,158.68 18.45,158.68 18.29,158.83 17.52,158.83 17.4,158.95 16.55,158.95 v1(16.09,158.49)
  SIG10 w0.155: v1(43.37,85.6) 42.02,85.6 37.21,90.41 34.91,90.41 33.88,91.44 33.49,91.44 33.49,91.44 26.11,91.44 23.37,94.18 21.91,94.18 18.05,98.04 16.19,98.04 13.84,100.39 6,100.39 4.46,101.93 4.46,112.98 5.4,113.92 5.4,114.42 4.46,115.36 4.46,122.58 5.29,123.41 5.29,132.44 4.52,133.21 4.52,157.34 8.21,161.03 13.27,161.03 15.81,158.49 v1(16.09,158.49)
  BOTTOM w0.13: v2(42.35,86.87) 43.37,85.85 v1(43.37,85.6)
INTL36: length 113.1
  TOP w0.13: v1(69.66,86.36) 70.29,86.36 70.93,85.72 70.93,84.83 71.08,84.68 R2647.1 ; v1(15.05,153.54) 15.56,153.03 18.09,153.03 U123.R1
  SIG10 w0.155: v1(69.66,86.36) 67.39,86.36 66.37,87.38 64.21,87.38 62.67,88.91 62.67,90.47 62.09,91.06 57.85,91.06 55.71,93.2 51,93.2 49.85,94.35 47.97,94.35 44.91,97.41 42.23,97.41 39.93,99.7 37.28,99.7 36.49,100.49 31.19,100.49 26.39,105.29 26.39,130.29 20.71,135.98 20.71,141.32 15.83,146.2 15.83,150.14 15.05,150.92 v1(15.05,153.54)
  BOTTOM w0.13: v1(15.05,153.54) v2(14.29,153.54)
INTL37: length 119
  TOP w0.13: v1(16.09,155.95) 16.64,155.4 U123.N1
  SIG10 w0.155: v1(70.29,82.55) 70.29,84.33 70.68,84.71 70.68,87.37 70.04,88.01 64.4,88.01 63.4,89.01 63.4,90.41 61.3,92.5 57.43,92.5 56.11,93.82 51.31,93.82 49.45,95.68 49.29,95.68 46.42,98.55 41.78,98.55 40.16,100.17 37.73,100.17 36.3,101.6 33.46,101.6 32.95,102.11 31.61,102.11 29.6,104.12 29.42,104.12 29.02,104.52 29.02,105.57 26.88,107.71 26.88,130.47 21.17,136.17 21.17,141.52 16.29,146.39 16.29,150.53 15.56,151.26 15.56,155.42 v1(16.09,155.95)
  BOTTOM w0.13: R2651.2 70.93,79.35 70.93,80.77 v2(70.55,81.15) 70.29,81.4 v1(70.29,82.55)
INTL38: length 115
  TOP w0.13: R2648.1 v1(84.77,85.34) ; v1(21.3,149.22) 22.41,150.33 22.41,151.52 23.25,152.36 23.25,153.4 U123.R7
  SIG10 w0.155: v1(21.3,149.22) 21.96,149.22 24.64,146.54 24.64,144.09 26.35,142.38 26.35,141.48 32.87,134.96 32.87,133.64 33.36,133.15 33.36,131.18 32.72,130.54 32.72,121.78 33.21,121.28 33.21,120 32.72,119.5 32.72,111.95 36.54,108.12 46.64,108.12 53.02,101.74 57.98,101.74 58.62,101.1 62.54,101.1 67.09,96.55 75.95,96.55 80.28,92.22 80.28,89.63 84.58,85.34 v1(84.77,85.34)
  BOTTOM w0.13: v2(84.52,86.1) 84.52,85.6 v1(84.77,85.34)
INTL39: length 117
  TOP w0.13: U123.T11 26.85,151.83 26.4,151.38 26.4,150.01 25.49,149.1 v1(25.51,149.07)
  SIG10 w0.155: v1(84.77,79.5) 85.03,79.5 85.92,78.61 86.42,78.61 87.06,77.98 87.82,77.98 89.89,80.05 89.89,85.28 86.78,88.39 86.42,88.39 85.53,89.28 85.53,90.89 77.49,98.94 70.16,98.94 67.94,101.15 66.93,101.15 62.68,105.41 60.52,105.41 57.72,108.2 57.21,108.2 55.31,110.11 55.31,110.61 52.01,113.92 52.01,118.45 51.53,118.93 51.53,121.88 36.28,137.12 36.28,137.64 32.83,141.09 31.64,141.09 29.71,143.02 28.99,143.02 28.13,143.89 28.13,144.89 27.94,145.08 27.32,145.08 26.99,145.41 26.99,147.36 25.51,148.84 v1(25.51,149.07)
  BOTTOM w0.13: v2(83.76,80.39) 83.88,80.39 v1(84.77,79.5) R2652.2
INTL40: length 130
  TOP w0.13: U123.T10 26.05,152.05 25.75,151.74 25.75,151.36 v1(25.51,151.13) ; R2693.1 v1(121.22,85.34)
  SIG10 w0.155: v1(121.22,85.34) 120.33,86.23 119.95,86.23 114.62,91.56 94.57,91.56 79.31,106.82 78.53,106.82 77.66,107.69 77.66,108.47 76.57,109.57 66.37,109.57 64,111.94 63.77,111.94 62.42,113.28 62.42,113.92 61.91,114.42 61.51,114.42 54.11,121.82 54.11,122.95 45.58,131.49 45.58,133.97 38.45,141.09 37.53,141.09 34.6,144.02 34.6,145.04 v1(33.72,145.92) 33.34,146.3 31.05,146.3 29.15,148.21 28.77,148.21 28,148.97 28,150.24 27.66,150.58 26.06,150.58 v1(25.51,151.13)
INTL41: length 139.4
  TOP w0.13: v1(26.86,150.11) 27.65,150.9 U123.T12
  SIG10 w0.155: v1(119.95,76.96) 119.44,76.45 114.74,76.45 113.35,77.85 113.35,82.6 109.02,86.93 94.55,86.93 93.64,87.84 91.03,87.84 89.73,89.15 89.73,91.42 85.35,95.8 84.69,95.8 79.24,101.25 76.05,101.25 v1(75.5,101.8) 71.11,101.8 69.27,103.63 67.73,103.63 63.31,108.05 62.32,108.05 54.32,116.05 54.32,120.37 53.65,121.04 53.65,122.76 45.11,131.29 45.11,133.77 38.87,140.02 37.98,140.02 37.37,140.63 37.34,140.63 34.14,143.83 34.14,143.87 32.23,145.77 30.81,145.77 29.01,147.57 28.64,147.57 27.5,148.71 27.5,149.48 v1(26.86,150.11)
  BOTTOM w0.13: R2688.2 120.82,78.84 120.71,78.74 120.71,77.47 120.21,76.96 v1(119.95,76.96)
INTL42: length 144.9
  TOP w0.13: v1(134.43,86.26) 134.94,85.75 134.94,85.21 135.04,85.11 135.04,84.83 134.89,84.68 R2687.1 ; v1(32.6,156.03) 32.51,156.13 31.41,156.13 31.33,156.2 U123.M16
  SIG10 w0.155: v1(134.43,86.26) 134.43,88.77 133.79,89.41 132.88,89.41 132.03,90.25 132.03,92.27 124.29,100.02 97.44,100.02 78.74,118.72 69.64,118.72 62.02,126.33 62.02,134.98 60.51,136.5 60.1,136.5 58.17,138.43 53.53,138.43 52.9,139.06 52.9,140.97 49.34,144.52 47.29,144.52 39.74,152.07 37.37,152.07 35.07,154.37 35.07,155 34.62,155.45 33.34,155.45 32.75,156.03 v1(32.6,156.03)
  BOTTOM w0.13: v1(134.43,86.26) 133.95,86.74 v2(133.67,86.74)
INTL43: length 157.4
  TOP w0.13: U123.M14 v1(29.65,155.8)
  SIG10 w0.155: v1(29.65,155.8) 30.85,155.8 32.35,154.3 34.39,154.3 45.44,143.25 49.72,143.25 51.5,141.48 51.5,139.57 53.15,137.92 57.87,137.92 58.28,137.51 58.28,137.29 61.56,134.02 61.56,126.02 69.33,118.25 78.43,118.25 97.13,99.55 123.98,99.55 131.41,92.11 131.41,90.13 133.86,87.68 133.86,85.02 134.05,84.83 136.21,84.83 138.36,82.68 138.36,80.2 137.15,78.99 135.39,78.99 v1(134.89,79.5)
  BOTTOM w0.13: R2690.2 133.54,79.8 v2(133.67,79.93) 134.46,79.93 v1(134.89,79.5)
INTL44: length 181.4
  TOP w0.13: v1(164.4,86.23) 165.42,85.21 R2728.1 ; v1(32.6,160.14) 32.02,160.14 31.68,159.8 30.45,159.8 U123.H15
  SIG10 w0.155: v1(32.6,160.14) 33.11,160.65 39.94,160.65 45.98,154.62 48.13,154.62 51.9,150.85 54.86,150.85 63.86,141.85 63.86,140.14 64.48,139.52 64.48,137.51 65.72,136.27 65.72,131.99 66.28,131.43 66.28,127.39 71.73,121.95 77.31,121.95 80.01,124.65 111.22,124.65 140.12,95.76 140.14,95.76 140.91,94.99 140.91,91.69 141.29,91.31 142.18,91.31 142.81,90.68 142.81,89.55 146.91,85.45 156.38,85.45 157.65,86.72 160.21,86.72 160.7,86.23 v1(164.4,86.23)
  BOTTOM w0.13: v2(163.72,85.87) 164.07,86.23 v1(164.4,86.23)
INTL45: length 187.7
  TOP w0.13: U123.J15 30.45,158.2 32,158.2 32.37,158.57 v1(32.6,158.57)
  SIG10 w0.155: v1(32.6,158.57) 33.16,159.13 35.37,159.13 36.38,158.12 40.16,158.12 45.42,152.85 47.9,152.85 49.06,151.69 49.06,150.76 50.7,149.12 55.05,149.12 62.93,141.24 62.93,137.51 64.78,135.66 64.78,131.61 65.35,131.04 65.35,126.8 71.14,121.02 82.99,121.02 83.69,120.31 110.39,120.31 136.06,94.64 136.06,92.6 136.84,91.82 136.84,90.8 136.72,90.68 136.72,89.03 137.17,88.57 137.17,86.48 140.25,83.41 140.25,79.05 141.32,77.98 160.34,77.98 162.7,80.34 163.33,80.34 v1(163.64,80.64)
  BOTTOM w0.13: v1(163.64,80.64) 163.13,80.13 163.13,79.63 163.46,79.3 164.27,79.3 164.4,79.17 R2731.2 164.27,78.84 163.54,78.1 v2(163.26,78.1)
INTL46: length 261.1
  TOP w0.13: U123.E7 v1(23.25,162.2) ; R2725.1 v1(178.75,85.34)
  SIG10 w0.102: 24.82,162.61 24.81,162.6 23.65,162.6 v1(23.25,162.2)
  SIG10 w0.155: 24.82,162.61 25.13,162.92 25.13,165.55 27.76,168.19 27.76,168.27 35.27,168.27 37.84,170.85 37.84,174.52 49.12,185.8 50.41,185.8 57.53,192.92 57.53,193.61 58.56,194.64 60.5,194.64 63.39,197.52 73.62,197.52 74.1,198 80.21,198 80.85,197.36 85.65,197.36 86.29,198 107.75,198 115.72,190.03 115.72,128.49 137.96,106.25 143.11,106.25 144.47,104.9 145.99,104.9 147.62,103.27 149.79,103.27 153.2,99.86 155.73,99.86 156.04,99.54 156.04,98.63 158.58,96.09 160.41,96.09 161.76,94.75 168.91,94.75 171.07,92.59 172.71,92.59 176.97,88.33 176.97,87.13 v1(178.75,85.34)
  BOTTOM w0.13: v1(178.75,85.34) 178.45,85.34 v2(177.99,85.8)
INTL47: length 257.8
  TOP w0.13: v1(33.62,162.68) 33.01,162.07 32.4,162.07 31.8,161.48 31.18,161.48 31.11,161.41 30.46,161.41 U123.F15
  SIG10 w0.155: v1(33.62,162.68) 34.32,163.39 35.35,163.39 35.64,163.1 39.43,163.1 44.46,168.13 44.46,173.88 46.97,176.39 50.15,176.39 51.44,177.68 51.44,179.86 56.45,184.88 64.07,184.88 66.93,187.74 66.93,188.66 67.7,189.43 70.38,189.43 73.99,193.04 106.52,193.04 110.54,189.01 110.54,127.96 137.51,101 141.68,101 145.98,96.7 145.98,92.11 148.92,89.17 155.4,89.17 158.19,91.96 158.84,91.96 161.8,89 168.49,89 171.16,86.33 173.06,86.33 173.54,85.85 173.54,85.35 174.69,84.2 174.69,81.66 175.68,80.67 176.59,80.67 v1(176.85,80.92)
  BOTTOM w0.13: v1(176.85,80.92) v2(177.62,80.15) 178.24,79.52 178.24,78.99 178.4,78.84 R2732.2
INTL48: length 329.6
  TOP w0.13: U124.F10 v1(403.62,183.25) ; v1(214.06,86.23) 214.75,85.54 214.75,84.86 214.92,84.68 R2767.1
  SIG10 w0.102: v1(403.62,183.25) 403.22,183.65 402.52,183.65 402.27,183.89
  SIG10 w0.155: 402.27,183.89 402.09,184.07 402.09,187.25 401.66,187.69 400.52,187.69 400.28,187.45 399.48,187.45 399,187.93 399,190.35 396.43,192.91 396.43,197.6 387.47,206.56 376.11,206.56 375.25,205.69 366.31,205.69 364.99,207.01 361.89,207.01 360.88,205.99 333.15,205.99 319.98,219.16 283.57,219.16 277.37,212.97 277.37,211.22 274.27,208.13 274.27,183.65 v1(274.13,183.51) 274.13,182.03 264.2,172.1 264.2,113.66 249.48,98.94 249.48,90.54 247.54,88.59 241.4,88.59 240.26,89.74 239.31,89.74 236.77,92.27 220.35,92.27 218.5,90.42 216.22,90.42 214.06,88.26 v1(214.06,86.23)
INTL49: length 314.9
  TOP w0.13: v1(394.27,185.93) 394.59,185.93 395.67,184.85 396.42,184.85 U124.D2
  SIG10 w0.155: v1(394.27,185.93) 394.27,186.18 393.76,186.69 393.76,187.21 393.57,187.4 393.43,187.4 392.54,188.29 392.06,188.29 391.56,188.8 391.56,190.19 389.08,192.67 383.66,192.67 382.89,193.44 376.07,193.44 375.6,193.91 369.09,193.91 359.49,203.51 331.91,203.51 318.89,216.53 304.35,216.53 303.58,215.76 284.81,215.76 282.33,213.28 282.33,210.69 280.16,208.52 280.16,185.54 v1(279.97,185.36) 279.97,184.7 267.98,172.7 267.98,170.84 266.55,169.42 266.55,112.84 253.82,100.1 253.82,91.49 251.96,89.63 251.96,87.93 249.87,85.84 249.87,85.22 248.86,84.21 239.72,84.21 236.62,87.31 233.68,87.31 233.53,87.46 230.27,87.46 229.8,87.93 226.86,87.93 225.62,86.69 218.8,86.69 215.71,83.6 215.71,79.82 215.39,79.5 v1(215.2,79.5)
  BOTTOM w0.13: R2771.2 v1(215.2,79.5)
INTL50: length 303.4
  TOP w0.13: U124.E1 395.49,183.65 394.74,184.4 393.84,184.4 v1(393.26,184.99) ; R2768.1 228.54,85.19 227.52,86.21 v1(227.52,86.23)
  SIG10 w0.155: v1(227.52,86.23) 227.52,86.21 229.02,84.71 230.06,84.71 230.95,85.6 232.76,85.6 235.07,83.28 236.62,83.28 239.26,80.64 248.98,80.64 250.87,82.53 250.87,83.28 251.9,84.31 251.9,85.51 253.08,86.69 254.44,86.69 255.71,87.97 255.71,94.01 257.07,95.37 257.07,101.12 269.76,113.81 269.76,170.36 269.98,170.57 269.98,172.74 285.43,188.18 285.43,197.47 282.95,199.95 282.95,208.97 283.72,209.74 283.72,212.35 285.74,214.36 306.65,214.36 307.27,213.74 319.36,213.74 330.98,202.12 358.4,202.12 368.01,192.51 374.21,192.51 375.48,191.24 388.03,191.24 390.16,189.11 390.16,188.18 390.61,187.73 390.61,187.04 391.55,186.1 392.04,186.1 392.29,185.85 392.29,185.57 392.88,184.99 v1(393.26,184.99)
  BOTTOM w0.13: v2(226.76,85.77) 227.22,86.23 v1(227.52,86.23)
INTL51: length 248.6
  TOP w0.13: v1(396.81,172.97) 396.81,173.35 398.02,174.56 398.02,175.25 U124.R4
  SIG10 w0.155: v1(396.81,172.97) 396.43,172.59 393,172.59 392.62,172.21 390.59,172.21 387.81,169.43 383.19,169.43 381.33,167.57 381.33,164.93 379.85,163.45 377.22,163.45 376.07,162.3 375.01,162.3 373.57,160.87 373.57,160.02 371.41,157.86 371.41,156.53 367.73,152.84 367.73,144.19 366.58,143.05 366.58,135.31 364.68,133.41 364.68,122.68 351.97,109.97 315.27,109.97 289.69,84.39 287.77,84.39 282.38,79.01 282.38,73.86 279.39,70.86 228.92,70.86 226,73.78 226,79.12 v1(226.63,79.75)
  BOTTOM w0.13: R2772.2 228.03,79.35 228.03,79.88 v2(227.65,80.26) 227.14,80.26 v1(226.63,79.75)
INTL52: length 237.5
  TOP w0.13: v1(258.13,86.23) 258.89,85.47 258.89,84.96 259.17,84.68 R2805.1 ; U124.G2 396.42,182.45 395.32,182.45 394.76,183 v1(394.27,183)
  SIG10 w0.155: v1(258.13,86.23) 258.25,86.36 258.25,88.03 259.09,88.86 259.09,92.42 260.32,93.66 260.32,101.36 272.62,113.65 272.62,172.37 290.54,190.29 290.54,191.03 291.66,192.15 306.13,192.15 307.89,193.91 325.25,193.91 330.87,199.54 354.32,199.54 355.46,198.4 358.56,198.4 366.92,190.04 372.97,190.04 373.9,189.11 386.31,189.11 391.8,183.61 392.77,183.61 392.91,183.47 393.8,183.47 v1(394.27,183)
INTL53: length 240.8
  TOP w0.13: v1(393.38,183) 393.83,182.56 394.72,182.56 395.23,182.05 U124.G1
  SIG10 w0.155: v1(259.4,79.5) 258.89,80.01 258.89,87.46 259.72,88.29 259.72,89.47 260.94,90.7 260.94,101.3 273.08,113.44 v1(273.08,169.03) 273.08,172.18 291,190.1 291,190.79 291.85,191.64 307.69,191.64 309.18,193.13 325.4,193.13 330.81,198.55 354.38,198.55 355.07,197.86 357.55,197.86 366.92,188.49 386.19,188.49 392.03,182.65 393.03,182.65 v1(393.38,183)
  BOTTOM w0.13: R2807.2 v1(259.4,79.5)
INTL54: length 200.6
  TOP w0.13: U124.L1 394.94,178.85 394.72,179.07 v1(394.27,179.07) ; R2806.1 271.49,84.68 v1(270.83,85.34)
  SIG10 w0.155: v1(394.27,179.07) 393.64,178.43 391.62,178.43 388.07,181.99 386.46,181.99 385.6,181.12 378.3,181.12 377.81,180.64 370.57,180.64 369.82,179.89 369.44,179.89 362.7,173.15 357.99,173.15 356.08,171.23 356.08,153.65 354.99,152.57 354.99,146.03 353.75,144.79 353.75,131.93 343.53,121.71 292.21,121.71 269.95,99.45 269.95,86.22 v1(270.83,85.34)
  BOTTOM w0.13: v2(271.62,86.23) 270.83,85.44 v1(270.83,85.34)
INTL55: length 198.2
  TOP w0.13: v1(394.27,175.38) 394.88,175.38 395.54,176.05 396.42,176.05 U124.P2
  SIG10 w0.155: v1(272.73,79.5) 273.39,78.84 275.98,78.84 277.04,79.9 277.04,88.89 279.46,91.31 282,91.31 283.91,93.22 290.64,93.22 299.02,101.6 299.02,102.61 312.38,115.97 351.66,115.97 360.13,124.44 360.13,135.61 361.66,137.13 361.66,144.43 363.05,145.83 363.05,154.48 365.06,156.49 365.06,157.87 366.25,159.06 366.25,168.76 368.16,170.67 368.63,170.67 368.78,170.82 368.78,171.6 372.19,175.01 374.05,175.01 374.39,174.67 377.3,174.67 377.43,174.54 380.9,174.54 381.82,175.47 384.74,175.47 385.85,176.58 389.51,176.58 391.34,174.75 393.64,174.75 v1(394.27,175.38)
  BOTTOM w0.13: v1(394.27,175.38) 393.76,175.89 v2(392.37,175.89) ; R2808.2 v1(272.73,79.5)
INTL56: length 166.5
  TOP w0.13: v1(400.78,172.97) 400.78,173.63 401.22,174.08 401.22,175.25 U124.R8 ; R2847.1 311.7,78.84 311.85,78.99 311.85,79.25 v1(312.36,79.75)
  SIG10 w0.155: v1(400.78,172.97) 400.32,172.51 400.32,171.68 400.08,171.44 400.08,170.2 398.51,168.63 398.51,166.61 385.67,153.78 383.24,153.78 381.49,152.03 378.81,152.03 376.29,149.52 376.29,143.21 373.95,140.86 373.95,136.03 373.3,135.38 373.3,130.1 372.35,129.14 372.35,102.03 370.83,100.52 323.92,100.52 316.34,92.94 316.34,82.47 313.63,79.75 v1(312.36,79.75)
  BOTTOM w0.13: v2(313.02,80.19) 312.59,79.75 v1(312.36,79.75)
INTL57: length 154
  TOP w0.13: v1(310.2,82.93) 309.92,82.93 309.26,82.27 R2849.2 ; U124.T6 400.02,174.27 398.97,173.22 398.97,172.51 v1(398.41,171.96)
  SIG10 w0.155: v1(310.2,82.93) 310.63,83.36 310.63,93.51 321.47,104.35 351.31,104.35 359.6,112.65 361.25,112.65 368.53,119.93 368.53,132.81 369.73,134.01 369.73,141.56 371.76,143.6 371.76,147.12 372.66,148.01 372.66,150.91 378.32,156.57 378.32,158.19 378.93,158.8 380.35,158.8 380.56,159 382.99,159 388.9,164.91 390.76,164.91 393.46,167.61 394.04,167.61 394.46,168.03 395.28,168.03 396.05,168.81 396.05,169.6 v1(398.41,171.96)
  BOTTOM w0.13: v1(310.2,82.93) 310.07,82.8 v2(309.44,82.8)
