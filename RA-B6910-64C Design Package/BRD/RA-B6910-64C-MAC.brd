# Allegro board RA-B6910-64C-MAC.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#124  -  []  240 51.89 0 top
NOREF#125  -  []  206.1 52.42 90 top
NOREF#126  -  []  269.46 173.11 90 top
NOREF#127  -  []  69.43 343.02 90 top
NOREF#128  -  []  194.89 307.48 90 top
NOREF#129  -  []  242.5 184.31 0 top
NOREF#130  -  []  192.16 151.82 0 top
NOREF#131  -  []  80.2 51.89 0 top
NOREF#132  -  []  422.32 3.45 0 top
NOREF#133  -  []  265.9 53.12 0 top
NOREF#134  -  []  68.35 182 90 top
NOREF#135  -  []  70.5 161.28 0 top
NOREF#136  -  []  75.78 310.38 0 top
NOREF#137  -  []  27.45 118.45 90 top
NOREF#138  -  []  334.4 45.29 90 top
NOREF#139  -  []  347.74 144.29 90 top
NOREF#140  -  []  60.75 68.94 0 top
NOREF#141  -  []  35.16 131.02 0 top
NOREF#142  -  []  2147.55 2147.61 90 top
NOREF#143  -  []  99.4 45.29 90 top
NOREF#144  -  []  142.3 64.42 0 top
NOREF#145  -  []  268.2 51.89 0 top
NOREF#146  -  []  172.16 169.82 270 top
NOREF#147  -  []  419.9 -3.25 90 top
NOREF#148  -  []  14 25.59 90 top
NOREF#149  -  []  202 7.59 0 top
NOREF#150  -  []  97.5 343.02 90 top
NOREF#151  -  []  403.94 116 0 top
NOREF#152  -  []  187.86 310.13 0 top
NOREF#153  -  []  249 45.29 90 top
NOREF#154  -  []  96.1 65.82 0 top
NOREF#155  -  []  155.4 12.09 90 top
NOREF#156  -  []  157.5 65.12 0 top
NOREF#157  -  []  48.3 56.42 90 top
NOREF#158  -  []  333.96 152.14 0 top
NOREF#159  -  []  167.56 305.33 90 top
NOREF#160  -  []  107.8 2.95 90 top
NOREF#161  -  []  239.57 108.96 0 top
NOREF#162  -  []  330.31 305.04 90 top
NOREF#163  -  []  411.75 53.98 90 top
NOREF#164  -  []  99.4 34.59 90 top
NOREF#165  -  []  157.73 307.48 90 top
NOREF#166  -  []  13.8 2.95 90 top
NOREF#167  -  []  345.5 65.12 0 top
NOREF#168  -  []  150.2 310.23 0 top
NOREF#169  -  []  174.2 51.89 0 top
NOREF#170  -  []  14 7.59 90 top
NOREF#171  -  []  338.59 305.04 90 top
NOREF#172  -  []  14 34.59 90 top
NOREF#173  -  []  237.9 53.12 0 top
NOREF#174  -  []  105.22 358.17 90 top
NOREF#175  -  []  14.4 51.89 0 top
NOREF#176  -  []  47.5 65.12 0 top
NOREF#177  -  []  211.21 308.86 0 top
NOREF#178  -  []  300.1 52.42 90 top
NOREF#179  -  []  388.19 23.85 90 top
NOREF#180  -  []  100.62 305.28 90 top
NOREF#181  -  []  380.8 2.95 90 top
NOREF#182  -  []  187.46 307.48 90 top
NOREF#183  -  []  19.28 351.6 0 top
NOREF#184  -  []  338.77 121.98 0 top
NOREF#185  -  []  122.5 189.3 0 top
NOREF#186  -  []  14 7.59 0 top
NOREF#187  -  []  200.78 -4.22 90 top
NOREF#188  -  []  111.53 353.52 0 top
NOREF#189  -  []  351.85 216.28 0 top
NOREF#190  -  []  52.4 25.59 90 top
NOREF#191  -  []  239.78 111.78 0 top
NOREF#192  -  []  152.5 94.3 0 top
NOREF#193  -  []  73.15 153.52 90 top
NOREF#194  -  []  182.43 305.33 90 top
NOREF#195  -  []  333.96 131.82 0 top
NOREF#196  -  []  382.62 -4.22 90 top
NOREF#197  -  []  322.97 308.83 90 top
NOREF#198  -  []  383.01 133.51 90 top
NOREF#199  -  []  112.1 56.42 90 top
NOREF#200  -  []  193.4 45.29 90 top
NOREF#201  -  []  253.1 52.42 90 top
NOREF#202  -  []  56.72 362.77 0 top
NOREF#203  -  []  157.73 309.48 0 top
NOREF#204  -  []  97.5 353.52 0 top
NOREF#205  -  []  96.9 53.12 0 top
NOREF#206  -  []  179.93 310.23 0 top
NOREF#207  -  []  341.78 -4.22 0 top
NOREF#208  -  []  383.01 133.51 90 top
NOREF#209  -  []  200.78 -4.22 0 top
NOREF#210  -  []  189.3 64.42 0 top
NOREF#211  -  []  157.63 305.23 90 top
NOREF#212  -  []  240.4 45.29 90 top
NOREF#213  -  []  -8.09 68.84 90 top
NOREF#214  -  []  202.4 51.89 0 top
NOREF#215  -  []  194.89 309.48 0 top
NOREF#216  -  []  335.62 -4.22 0 top
NOREF#217  -  []  187.26 210.82 0 top
NOREF#218  -  []  253.1 56.42 90 top
NOREF#219  -  []  61 34.59 90 top
NOREF#220  -  []  315.2 7.59 0 top
NOREF#221  -  []  364.53 117.36 0 top
NOREF#222  -  []  180.03 309.48 0 top
NOREF#223  -  []  171.61 169.68 0 top
NOREF#224  -  []  239.8 2.95 90 top
NOREF#225  -  []  108 34.59 90 top
NOREF#226  -  []  343 34.59 90 top
NOREF#227  -  []  73.15 163.68 90 top
NOREF#228  -  []  359.84 169.95 0 top
NOREF#229  -  []  95.3 52.42 90 top
NOREF#230  -  []  145.8 2.95 90 top
NOREF#231  -  []  112.65 348.27 0 top
NOREF#232  -  []  117.85 358.17 90 top
NOREF#233  -  []  7.39 360.47 0 top
NOREF#234  -  []  98.8 2.95 90 top
NOREF#235  -  []  410.77 121.98 90 top
NOREF#236  -  []  324.35 342.89 90 top
NOREF#237  -  []  48.3 52.42 90 top
NOREF#238  -  []  202.4 51.89 90 top
NOREF#239  -  []  296 34.59 90 top
NOREF#240  -  []  129.09 205.73 90 top
NOREF#241  -  []  128.4 310.13 0 top
NOREF#242  -  []  218.9 53.12 0 top
NOREF#243  -  []  126.69 348.27 0 top
NOREF#244  -  []  1.99 33.21 0 top
NOREF#245  -  []  94.62 362.77 0 top
NOREF#246  -  []  296.4 51.89 0 top
NOREF#247  -  []  333.96 158.98 90 top
NOREF#248  -  []  324.8 2.95 90 top
NOREF#249  -  []  -1.36 63.38 90 top
NOREF#250  -  []  334.4 16.59 90 top
NOREF#251  -  []  158.13 310.13 0 top
NOREF#252  -  []  296 7.59 90 top
NOREF#253  -  []  107.75 68.94 0 top
NOREF#254  -  []  65.1 52.42 90 top
NOREF#255  -  []  4.25 35.91 90 top
NOREF#256  -  []  197.55 153.03 90 top
NOREF#257  -  []  298.5 53.12 90 top
NOREF#258  -  []  127.2 51.89 0 top
NOREF#259  -  []  194.23 -4.22 90 top
NOREF#260  -  []  315.2 7.59 0 top
NOREF#261  -  []  325.23 180.57 90 top
NOREF#262  -  []  143.9 53.12 0 top
NOREF#263  -  []  185.16 119.82 0 top
NOREF#264  -  []  84.61 310.21 0 top
NOREF#265  -  []  242.5 184.31 90 top
NOREF#266  -  []  345.09 185.83 0 top
NOREF#267  -  []  401.7 53.87 90 top
NOREF#268  -  []  -8.09 68.84 90 top
NOREF#269  -  []  30.9 53.12 0 top
NOREF#270  -  []  367.22 226.21 90 top
NOREF#271  -  []  49.9 53.12 0 top
NOREF#272  -  []  295.75 68.94 0 top
NOREF#273  -  []  240 12.09 90 top
NOREF#274  -  []  378.9 53.12 0 top
NOREF#275  -  []  347.63 155.24 90 top
NOREF#276  -  []  13.75 68.94 0 top
NOREF#277  -  []  244.66 2 270 top
NOREF#278  -  []  362.2 51.89 0 top
NOREF#279  -  []  296 7.59 90 top
NOREF#280  -  []  252.38 136.23 90 top
NOREF#281  -  []  92.38 159.93 90 top
NOREF#282  -  []  315.2 51.89 0 top
NOREF#283  -  []  100.62 -4.22 90 top
NOREF#284  -  []  287.4 45.29 90 top
NOREF#285  -  []  382.75 109.51 90 top
NOREF#286  -  []  328.08 307.54 0 top
NOREF#287  -  []  324.16 132.63 0 top
NOREF#288  -  []  404.13 53.98 90 top
NOREF#289  -  []  418.8 2.95 90 top
NOREF#290  -  []  294.78 -4.22 90 top
NOREF#291  -  []  146.4 25.59 90 top
NOREF#292  -  []  343.61 342.89 90 top
NOREF#293  -  []  110.5 65.12 0 top
NOREF#294  -  []  165.56 310.13 0 top
NOREF#295  -  []  268.2 51.89 0 top
NOREF#296  -  []  68.35 171.84 90 top
NOREF#297  -  []  54.69 358.17 90 top
NOREF#298  -  []  344.46 169.4 90 top
NOREF#299  -  []  353.4 308.14 0 top
NOREF#300  -  []  49.02 170.69 0 top
NOREF#301  -  []  291.65 2 270 top
NOREF#302  -  []  56.53 348.27 0 top
NOREF#303  -  []  204.5 65.12 0 top
NOREF#304  -  []  343 16.59 90 top
NOREF#305  -  []  362.96 225.21 0 top
NOREF#306  -  []  174.2 51.89 0 top
NOREF#307  -  []  157.5 65.12 0 top
NOREF#308  -  []  68.35 133.2 0 top
NOREF#309  -  []  334.4 7.59 90 top
NOREF#310  -  []  287.4 34.59 90 top
NOREF#311  -  []  8.25 347.34 0 top
NOREF#312  -  []  268.2 51.89 0 top
NOREF#313  -  []  202.4 51.89 0 top
NOREF#314  -  []  130.48 358.17 90 top
NOREF#315  -  []  247.78 -4.22 0 top
NOREF#316  -  []  145.8 2.95 90 top
NOREF#317  -  []  89.08 217.9 90 top
NOREF#318  -  []  174.2 7.59 0 top
NOREF#319  -  []  221.2 7.59 0 top
NOREF#320  -  []  324.16 152.95 0 top
NOREF#321  -  []  355.15 305.04 90 top
NOREF#322  -  []  352.93 307.54 0 top
NOREF#323  -  []  35.16 131.02 0 top
NOREF#324  -  []  106.78 -4.22 90 top
NOREF#325  -  []  369.21 182.99 90 top
NOREF#326  -  []  19.9 131.32 0 top
NOREF#327  -  []  343.4 51.89 0 top
NOREF#328  -  []  331.1 65.82 0 top
NOREF#329  -  []  343.4 51.89 90 top
NOREF#330  -  []  47.9 144.55 90 top
NOREF#331  -  []  249.4 51.89 0 top
NOREF#332  -  []  376.07 -4.22 90 top
NOREF#333  -  []  165.56 310.13 0 top
NOREF#334  -  []  175 305.33 90 top
NOREF#335  -  []  77.9 53.12 0 top
NOREF#336  -  []  -8.78 35.24 90 top
NOREF#337  -  []  73.25 171.33 90 top
NOREF#338  -  []  284.9 53.12 90 top
NOREF#339  -  []  364.18 226 90 top
NOREF#340  -  []  106.78 -4.22 0 top
NOREF#341  -  []  346.47 143.74 0 top
NOREF#342  -  []  296 16.59 90 top
NOREF#343  -  []  357.96 159.77 0 top
NOREF#344  -  []  344.46 128.88 90 top
NOREF#345  -  []  342.8 2.95 90 top
NOREF#346  -  []  14 16.59 90 top
NOREF#347  -  []  -4.97 39.81 0 top
NOREF#348  -  []  70.56 348.27 0 top
NOREF#349  -  []  61.4 51.89 0 top
NOREF#350  -  []  155.4 51.89 0 top
NOREF#351  -  []  98.8 2.95 90 top
NOREF#352  -  []  343.4 12.09 90 top
NOREF#353  -  []  61 45.29 90 top
NOREF#354  -  []  315.2 51.89 0 top
NOREF#355  -  []  102.88 149.77 90 top
NOREF#356  -  []  236.3 52.42 90 top
NOREF#357  -  []  218.9 53.12 0 top
NOREF#358  -  []  150.3 309.48 0 top
NOREF#359  -  []  323.47 307.53 90 top
NOREF#360  -  []  298.5 65.12 0 top
NOREF#361  -  []  2.36 33.81 0 top
NOREF#362  -  []  347.5 130.48 0 top
NOREF#363  -  []  359.9 53.12 0 top
NOREF#364  -  []  16.8 358.17 90 top
NOREF#365  -  []  265.9 53.12 0 top
NOREF#366  -  []  230.8 2.95 90 top
NOREF#367  -  []  345.12 308.14 0 top
NOREF#368  -  []  79.96 358.17 90 top
NOREF#369  -  []  -0.76 63.01 0 top
NOREF#370  -  []  347.5 140.64 0 top
NOREF#371  -  []  268.2 7.59 0 top
NOREF#372  -  []  153.06 152.61 0 top
NOREF#373  -  []  153.78 -4.22 90 top
NOREF#374  -  []  358.71 165.7 0 top
NOREF#375  -  []  217.24 307.53 0 top
NOREF#376  -  []  165.16 309.48 0 top
NOREF#377  -  []  235.1 202.35 0 top
NOREF#378  -  []  347.74 184.93 90 top
NOREF#379  -  []  57.92 360.47 0 top
NOREF#380  -  []  384.38 200.3 0 top
NOREF#381  -  []  70.55 360.47 0 top
NOREF#382  -  []  347.74 171.27 90 top
NOREF#383  -  []  345.09 145.19 0 top
NOREF#384  -  []  142.86 307.48 90 top
NOREF#385  -  []  300.1 52.42 90 top
NOREF#386  -  []  150.7 310.13 0 top
NOREF#387  -  []  -16.7 -3.25 0 top
NOREF#388  -  []  254.7 173.77 0 top
NOREF#389  -  []  -0.76 63.01 90 top
NOREF#390  -  []  51.8 2.95 90 top
NOREF#391  -  []  410.78 37.35 0 top
NOREF#392  -  []  63.5 65.12 0 top
NOREF#393  -  []  362.04 106.8 0 top
NOREF#394  -  []  173 310.13 0 top
NOREF#395  -  []  14 7.59 0 top
NOREF#396  -  []  76.33 305.46 90 top
NOREF#397  -  []  108 7.59 0 top
NOREF#398  -  []  -1.16 35.11 90 top
NOREF#399  -  []  70.5 181.6 0 top
NOREF#400  -  []  151.75 308.86 0 top
NOREF#401  -  []  148.07 211.64 0 top
NOREF#402  -  []  197.29 305.33 90 top
NOREF#403  -  []  296 45.29 90 top
NOREF#404  -  []  347.74 130.63 90 top
NOREF#405  -  []  240.26 113.41 0 top
NOREF#406  -  []  143.12 358.17 90 top
NOREF#407  -  []  14 16.59 90 top
NOREF#408  -  []  347.74 150.95 90 top
NOREF#409  -  []  298.5 65.12 0 top
NOREF#410  -  []  52.4 7.59 90 top
NOREF#411  -  []  157.5 65.12 0 top
NOREF#412  -  []  209.76 309.48 0 top
NOREF#413  -  []  73.15 133.2 90 top
NOREF#414  -  []  200.78 -4.22 90 top
NOREF#415  -  []  158.13 310.13 0 top
NOREF#416  -  []  247.78 -4.22 90 top
NOREF#417  -  []  3.1 -3.25 90 top
NOREF#418  -  []  16.5 65.12 0 top
NOREF#419  -  []  344.48 142.79 0 top
NOREF#420  -  []  61.4 51.89 0 top
NOREF#421  -  []  142.3 56.42 90 top
NOREF#422  -  []  794.32 123.12 0 top
NOREF#423  -  []  68.04 161.39 0 top
NOREF#424  -  []  182.44 212.6 0 top
NOREF#425  -  []  392.96 343.14 90 top
NOREF#426  -  []  376.5 65.12 0 top
NOREF#427  -  []  294.78 -4.22 0 top
NOREF#428  -  []  389.94 115.9 90 top
NOREF#429  -  []  -128.08 322.83 90 top
NOREF#430  -  []  345.5 53.12 90 top
NOREF#431  -  []  426.12 1.2 90 top
NOREF#432  -  []  52 12.09 90 top
NOREF#433  -  []  343.4 12.09 0 top
NOREF#434  -  []  344.48 173.27 0 top
NOREF#435  -  []  72.95 197.87 0 top
NOREF#436  -  []  254.7 169.77 90 top
NOREF#437  -  []  53.68 159.87 0 top
NOREF#438  -  []  403.16 37.35 0 top
NOREF#439  -  []  194.79 305.23 90 top
NOREF#440  -  []  381 12.09 90 top
NOREF#441  -  []  159.1 56.42 90 top
NOREF#442  -  []  99 51.89 0 top
NOREF#443  -  []  23.9 216.3 0 top
NOREF#444  -  []  61 25.59 90 top
NOREF#445  -  []  55.4 353.52 0 top
NOREF#446  -  []  -124.33 334.98 90 top
NOREF#447  -  []  243.7 202.35 0 top
NOREF#448  -  []  13.91 104.1 90 top
NOREF#449  -  []  124.9 53.12 0 top
NOREF#450  -  []  143.67 150.31 0 top
NOREF#451  -  []  76.39 197.92 90 top
NOREF#452  -  []  403.16 34.15 90 top
NOREF#453  -  []  125.42 226 90 top
NOREF#454  -  []  145.8 2.95 90 top
NOREF#455  -  []  154.75 68.94 0 top
NOREF#456  -  []  316.75 349.99 0 top
NOREF#457  -  []  294.78 -4.22 90 top
NOREF#458  -  []  390.19 139.9 90 top
NOREF#459  -  []  -75.27 350.43 90 top
NOREF#460  -  []  318.9 308.93 0 top
NOREF#461  -  []  18.1 52.42 90 top
NOREF#462  -  []  155 25.59 90 top
NOREF#463  -  []  108 25.59 90 top
NOREF#464  -  []  288.62 -4.22 90 top
NOREF#465  -  []  248.53 111.78 90 top
NOREF#466  -  []  106.78 -4.22 0 top
NOREF#467  -  []  14.4 51.89 90 top
NOREF#468  -  []  380.8 2.95 90 top
NOREF#469  -  []  56.7 2 270 top
NOREF#470  -  []  143.26 153.82 90 top
NOREF#471  -  []  190.9 53.12 0 top
NOREF#472  -  []  304.49 226 90 top
NOREF#473  -  []  336.01 349.99 0 top
NOREF#474  -  []  409.32 53.87 90 top
NOREF#475  -  []  152.5 94.3 90 top
NOREF#476  -  []  343.4 51.89 0 top
NOREF#477  -  []  155.4 51.89 0 top
NOREF#478  -  []  68.35 141.36 90 top
NOREF#479  -  []  21.45 310.48 0 top
NOREF#480  -  []  7.47 119.29 90 top
NOREF#481  -  []  202 16.59 90 top
NOREF#482  -  []  69 181.6 0 top
NOREF#483  -  []  165.06 310.23 0 top
NOREF#484  -  []  12.78 -4.22 90 top
NOREF#485  -  []  382.75 109.51 90 top
NOREF#486  -  []  33.2 51.89 0 top
NOREF#487  -  []  315.2 51.89 0 top
NOREF#488  -  []  61.4 12.09 0 top
NOREF#489  -  []  251.5 53.12 90 top
NOREF#490  -  []  204.5 65.12 0 top
NOREF#491  -  []  153.78 -4.22 0 top
NOREF#492  -  []  14.4 51.89 0 top
NOREF#493  -  []  242.97 143.13 0 top
NOREF#494  -  []  -3.37 35.91 90 top
NOREF#495  -  []  143.74 155.45 0 top
NOREF#496  -  []  193.4 34.59 90 top
NOREF#497  -  []  -11.25 10.46 90 top
NOREF#498  -  []  202.4 12.09 90 top
NOREF#499  -  []  202 7.59 0 top
NOREF#500  -  []  47.3 216.3 0 top
NOREF#501  -  []  135.83 310.13 0 top
NOREF#502  -  []  -62.67 350.43 0 top
NOREF#503  -  []  155 45.29 90 top
NOREF#504  -  []  60.75 68.94 0 top
NOREF#505  -  []  92.38 139.61 90 top
NOREF#506  -  []  337.41 346.49 0 top
NOREF#507  -  []  287.4 7.59 90 top
NOREF#508  -  []  221.2 7.59 0 top
NOREF#509  -  []  61 7.59 0 top
NOREF#510  -  []  422.6 226 90 top
NOREF#511  -  []  335.23 -4.22 90 top
NOREF#512  -  []  68.04 151.23 0 top
NOREF#513  -  []  155 45.29 90 top
NOREF#514  -  []  143.61 126.49 0 top
NOREF#515  -  []  202 34.59 90 top
NOREF#516  -  []  359.9 53.12 0 top
NOREF#517  -  []  193 51.89 90 top
NOREF#518  -  []  201.75 68.94 0 top
NOREF#519  -  []  366.28 117.36 90 top
NOREF#520  -  []  202.23 305.23 90 top
NOREF#521  -  []  347.1 52.42 90 top
NOREF#522  -  []  242.5 94.3 90 top
NOREF#523  -  []  53.62 -4.22 0 top
NOREF#524  -  []  143.26 310.13 0 top
NOREF#525  -  []  202 7.59 90 top
NOREF#526  -  []  42.53 196.83 90 top
NOREF#527  -  []  218.38 214.28 0 top
NOREF#528  -  []  381 51.89 90 top
NOREF#529  -  []  343 7.59 0 top
NOREF#530  -  []  249.08 111.21 90 top
NOREF#531  -  []  331.9 53.12 0 top
NOREF#532  -  []  347.1 56.42 90 top
NOREF#533  -  []  187.36 305.23 90 top
NOREF#534  -  []  127.2 7.59 0 top
NOREF#535  -  []  333.8 2.95 90 top
NOREF#536  -  []  172.6 307.48 90 top
NOREF#537  -  []  231.3 240.59 0 top
NOREF#538  -  []  195.29 310.13 0 top
NOREF#539  -  []  174.2 51.89 0 top
NOREF#540  -  []  414.08 33.25 90 top
NOREF#541  -  []  6.2 362.77 0 top
NOREF#542  -  []  63.5 53.12 90 top
NOREF#543  -  []  378.9 53.12 0 top
NOREF#544  -  []  387.81 24.45 90 top
NOREF#545  -  []  68.04 141.07 0 top
NOREF#546  -  []  187.36 310.23 0 top
NOREF#547  -  []  157.5 65.12 0 top
NOREF#548  -  []  159.1 52.42 90 top
NOREF#549  -  []  187.86 310.13 0 top
NOREF#550  -  []  35.16 126.27 90 top
NOREF#551  -  []  333.96 139.04 90 top
NOREF#552  -  []  108 7.59 90 top
NOREF#553  -  []  343 25.59 90 top
NOREF#554  -  []  359.84 188.24 0 top
NOREF#555  -  []  170.91 105.57 0 top
NOREF#556  -  []  68.35 161.68 90 top
NOREF#557  -  []  80.2 7.59 0 top
NOREF#558  -  []  197.05 106.84 0 top
NOREF#559  -  []  375.35 116.1 90 top
NOREF#560  -  []  34.61 131.2 0 top
NOREF#561  -  []  296 45.29 90 top
NOREF#562  -  []  193 12.09 90 top
NOREF#563  -  []  296.4 51.89 0 top
NOREF#564  -  []  268.2 51.89 0 top
NOREF#565  -  []  363.68 349.54 0 top
NOREF#566  -  []  379.87 139.05 90 top
NOREF#567  -  []  193 51.89 90 top
NOREF#568  -  []  326.23 184.91 0 top
NOREF#569  -  []  61 25.59 90 top
NOREF#570  -  []  6.92 119.11 90 top
NOREF#571  -  []  152.35 121.32 0 top
NOREF#572  -  []  242.52 154.68 0 top
NOREF#573  -  []  300.1 56.42 90 top
NOREF#574  -  []  81.89 187.75 0 top
NOREF#575  -  []  127.2 51.89 0 top
NOREF#576  -  []  20.28 347.34 0 top
NOREF#577  -  []  343.4 51.89 0 top
NOREF#578  -  []  319.07 307.53 0 top
NOREF#579  -  []  111.91 207.43 90 top
NOREF#580  -  []  146 51.89 0 top
NOREF#581  -  []  155 16.59 90 top
NOREF#582  -  []  146.4 45.29 90 top
NOREF#583  -  []  378.1 65.82 0 top
NOREF#584  -  []  31.31 343 90 top
NOREF#585  -  []  344.48 132.63 0 top
NOREF#586  -  []  387.81 24.45 0 top
NOREF#587  -  []  95.81 360.47 0 top
NOREF#588  -  []  323.46 146.54 0 top
NOREF#589  -  []  108 7.59 90 top
NOREF#590  -  []  248.75 68.94 0 top
NOREF#591  -  []  172.6 309.48 0 top
NOREF#592  -  []  124.9 53.12 0 top
NOREF#593  -  []  1.99 32.26 90 top
NOREF#594  -  []  347.74 130.63 90 top
NOREF#595  -  []  150.3 307.48 90 top
NOREF#596  -  []  77.9 53.12 0 top
NOREF#597  -  []  61 16.59 90 top
NOREF#598  -  []  325.23 189.17 0 top
NOREF#599  -  []  -72.51 378.11 90 top
NOREF#600  -  []  81.89 147.11 0 top
NOREF#601  -  []  69.65 68.94 0 top
NOREF#602  -  []  347.1 56.42 90 top
NOREF#603  -  []  217.16 151.82 270 top
NOREF#604  -  []  347.5 171.12 0 top
NOREF#605  -  []  153.06 163.59 0 top
NOREF#606  -  []  221.2 51.89 0 top
NOREF#607  -  []  102.88 129.45 90 top
NOREF#608  -  []  333.8 2.95 90 top
NOREF#609  -  []  108 7.59 0 top
NOREF#610  -  []  12.78 -4.22 0 top
NOREF#611  -  []  210.65 68.94 0 top
NOREF#612  -  []  163.66 148.01 90 top
NOREF#613  -  []  49.1 65.82 0 top
NOREF#614  -  []  312.9 53.12 0 top
NOREF#615  -  []  343 7.59 0 top
NOREF#616  -  []  346.47 184.38 0 top
NOREF#617  -  []  324.16 183.43 0 top
NOREF#618  -  []  61 7.59 0 top
NOREF#619  -  []  127.9 310.23 0 top
NOREF#620  -  []  -126.81 338.02 0 top
NOREF#621  -  []  135.33 310.23 0 top
NOREF#622  -  []  12.15 225.7 90 top
NOREF#623  -  []  333.8 2.95 90 top
NOREF#624  -  []  347.63 134.92 90 top
NOREF#625  -  []  108 34.59 90 top
NOREF#626  -  []  155 7.59 0 top
NOREF#627  -  []  107.75 68.94 0 top
NOREF#628  -  []  319.57 308.83 0 top
NOREF#629  -  []  14.4 12.09 90 top
NOREF#630  -  []  197.67 2 270 top
NOREF#631  -  []  7.47 124.04 0 top
NOREF#632  -  []  68.35 182 90 top
NOREF#633  -  []  82.59 184 0 top
NOREF#634  -  []  328.56 308.14 0 top
NOREF#635  -  []  83.47 353.52 0 top
NOREF#636  -  []  237.9 53.12 0 top
NOREF#637  -  []  146 12.09 90 top
NOREF#638  -  [unnamed#2]  350.77 124.98 90 top
NOREF#639  -  []  80.2 51.89 0 top
NOREF#640  -  []  343.4 51.89 0 top
NOREF#641  -  []  347.74 140.79 90 top
NOREF#642  -  []  16.5 65.12 0 top
NOREF#643  -  []  343.4 51.89 0 top
NOREF#644  -  []  329.07 -4.22 90 top
NOREF#645  -  []  -1.16 39.81 0 top
NOREF#646  -  []  268.2 51.89 0 top
NOREF#647  -  []  77.33 179.53 90 top
NOREF#648  -  []  73.15 143.36 90 top
NOREF#649  -  []  277.8 2.95 90 top
NOREF#650  -  []  249 45.29 90 top
NOREF#651  -  []  334 51.89 90 top
NOREF#652  -  []  341.77 190.98 0 top
NOREF#653  -  []  249 16.59 90 top
NOREF#654  -  []  202 45.29 90 top
NOREF#655  -  []  107.25 362.77 0 top
NOREF#656  -  []  345.09 135.03 0 top
NOREF#657  -  []  155 34.59 90 top
NOREF#658  -  []  155.4 51.89 0 top
NOREF#659  -  []  68.35 151.52 90 top
NOREF#660  -  []  346.47 133.58 0 top
NOREF#661  -  []  146 12.09 90 top
NOREF#662  -  []  339.06 306.59 90 top
NOREF#663  -  []  14.4 51.89 0 top
NOREF#664  -  []  334.4 25.59 90 top
NOREF#665  -  []  345.5 65.12 0 top
NOREF#666  -  []  231.3 240.59 0 top
NOREF#667  -  []  63.5 65.12 0 top
NOREF#668  -  []  287 12.09 90 top
NOREF#669  -  []  100.23 -4.22 90 top
NOREF#670  -  []  142.76 310.23 0 top
NOREF#671  -  []  132.52 362.77 0 top
NOREF#672  -  []  357.96 139.45 0 top
NOREF#673  -  []  99.4 7.59 90 top
NOREF#674  -  []  59.78 -4.22 90 top
NOREF#675  -  []  347.63 175.56 90 top
NOREF#676  -  []  399.35 37.35 0 top
NOREF#677  -  []  -128.08 322.83 0 top
NOREF#678  -  []  362.2 7.59 0 top
NOREF#679  -  []  379.61 115.05 90 top
NOREF#680  -  []  377.3 56.42 90 top
NOREF#681  -  []  346.87 305.04 90 top
NOREF#682  -  []  248.7 283.91 90 top
NOREF#683  -  []  129.45 308.86 0 top
NOREF#684  -  []  101.17 310.21 0 top
NOREF#685  -  []  343 7.59 90 top
NOREF#686  -  []  155.4 51.89 0 top
NOREF#687  -  []  288.23 -4.22 90 top
NOREF#688  -  []  69 130.8 0 top
NOREF#689  -  []  251.5 65.12 0 top
NOREF#690  -  []  18.1 56.42 90 top
NOREF#691  -  []  265.01 177.74 0 top
NOREF#692  -  []  369.34 144.76 90 top
NOREF#693  -  []  242.04 153.06 0 top
NOREF#694  -  []  47.9 175.94 0 top
NOREF#695  -  []  68.35 171.84 90 top
NOREF#696  -  []  155.4 12.09 0 top
NOREF#697  -  []  150.68 2 270 top
NOREF#698  -  []  298.5 53.12 90 top
NOREF#699  -  []  141.5 65.12 0 top
NOREF#700  -  []  324.16 142.79 0 top
NOREF#701  -  []  382.83 132.96 0 top
NOREF#702  -  []  179.93 305.23 90 top
NOREF#703  -  []  249 7.59 0 top
NOREF#704  -  []  14 7.59 0 top
NOREF#705  -  []  -77.97 352.28 0 top
NOREF#706  -  []  240.4 7.59 90 top
NOREF#707  -  []  171.9 53.12 0 top
NOREF#708  -  []  192.8 2.95 90 top
NOREF#709  -  []  387.78 133.11 90 top
NOREF#710  -  []  190.9 53.12 90 top
NOREF#711  -  []  174.2 7.59 0 top
NOREF#712  -  []  312.9 53.12 0 top
NOREF#713  -  []  381 51.89 0 top
NOREF#714  -  []  346.47 164.06 0 top
NOREF#715  -  []  162.95 116.72 90 top
NOREF#716  -  []  43.35 343 90 top
NOREF#717  -  []  347.5 160.96 0 top
NOREF#718  -  []  7.47 124.04 0 top
NOREF#719  -  []  204.5 53.12 90 top
NOREF#720  -  []  364.8 193.67 90 top
NOREF#721  -  []  33.2 7.59 0 top
NOREF#722  -  []  347.15 349.54 0 top
NOREF#723  -  []  319.07 307.53 90 top
NOREF#724  -  []  185.11 226 90 top
NOREF#725  -  []  249 25.59 90 top
NOREF#726  -  []  138.11 208.56 90 top
NOREF#727  -  []  16.5 65.12 0 top
NOREF#728  -  []  298.5 65.12 0 top
NOREF#729  -  []  378.96 355.94 0 top
NOREF#730  -  []  345.09 155.35 0 top
NOREF#731  -  []  128 307.48 90 top
NOREF#732  -  []  402.65 33.25 90 top
NOREF#733  -  []  110.5 65.12 0 top
NOREF#734  -  []  61 16.59 90 top
NOREF#735  -  []  249.4 12.09 90 top
NOREF#736  -  []  92.34 305.28 90 top
NOREF#737  -  []  218.38 218.28 270 top
NOREF#738  -  []  422.32 3.45 0 top
NOREF#739  -  []  295.8 2.95 90 top
NOREF#740  -  []  111.91 207.43 90 top
NOREF#741  -  []  95.3 56.42 90 top
NOREF#742  -  []  239.67 118.11 0 top
NOREF#743  -  []  202 7.59 0 top
NOREF#744  -  []  155.4 51.89 0 top
NOREF#745  -  []  190.1 65.82 0 top
NOREF#746  -  []  347.74 181.43 90 top
NOREF#747  -  []  69 140.96 0 top
NOREF#748  -  []  785.62 67.75 90 top
NOREF#749  -  []  377.3 64.42 0 top
NOREF#750  -  []  381.4 16.59 90 top
NOREF#751  -  []  287 12.09 90 top
NOREF#752  -  []  82.59 133.2 0 top
NOREF#753  -  []  49.02 149.8 0 top
NOREF#754  -  []  68.04 171.55 0 top
NOREF#755  -  []  263.09 215.34 90 top
NOREF#756  -  []  378.65 115.05 0 top
NOREF#757  -  []  52 12.09 90 top
NOREF#758  -  []  -77.97 342.68 90 top
NOREF#759  -  []  70.5 171.44 0 top
NOREF#760  -  []  287 51.89 90 top
NOREF#761  -  []  202.4 12.09 0 top
NOREF#762  -  []  221.2 7.59 0 top
NOREF#763  -  []  248.98 102.06 90 top
NOREF#764  -  []  84.06 310.38 0 top
NOREF#765  -  []  63.5 65.12 0 top
NOREF#766  -  []  160.13 305.33 90 top
NOREF#767  -  []  190.9 53.12 0 top
NOREF#768  -  []  268.2 51.89 0 top
NOREF#769  -  []  20.02 360.47 0 top
NOREF#770  -  []  151.89 128.11 0 top
NOREF#771  -  []  12.15 240.7 0 top
NOREF#772  -  []  248.8 2.95 90 top
NOREF#773  -  []  217.19 304.73 90 top
NOREF#774  -  []  33.2 7.59 0 top
NOREF#775  -  []  378.44 214.56 0 top
NOREF#776  -  []  180.03 307.48 90 top
NOREF#777  -  []  108.4 51.89 0 top
NOREF#778  -  []  362.2 51.89 0 top
NOREF#779  -  []  222.82 304.73 90 top
NOREF#780  -  []  50.63 159.37 90 top
NOREF#781  -  []  383.3 218.15 0 top
NOREF#782  -  []  298.5 65.12 0 top
NOREF#783  -  []  357.91 136.65 90 top
NOREF#784  -  []  295.8 2.95 90 top
NOREF#785  -  []  -7.18 36.04 90 top
NOREF#786  -  []  344.48 152.95 0 top
NOREF#787  -  []  52 51.89 90 top
NOREF#788  -  []  29.43 358.17 90 top
NOREF#789  -  []  255.33 173.14 90 top
NOREF#790  -  []  190.9 53.12 0 top
NOREF#791  -  []  374.35 169.46 0 top
NOREF#792  -  []  236.3 56.42 90 top
NOREF#793  -  []  362.2 51.89 0 top
NOREF#794  -  []  381.4 34.59 90 top
NOREF#795  -  []  315.2 51.89 0 top
NOREF#796  -  []  110.5 53.12 90 top
NOREF#797  -  []  362.2 51.89 0 top
NOREF#798  -  []  249 34.59 90 top
NOREF#799  -  []  253.1 56.42 90 top
NOREF#800  -  []  249 16.59 90 top
NOREF#801  -  []  347.63 185.72 90 top
NOREF#802  -  []  193.4 16.59 90 top
NOREF#803  -  []  221.2 51.89 0 top
NOREF#804  -  []  336.36 307.54 0 top
NOREF#805  -  []  251.5 65.12 0 top
NOREF#806  -  []  146 51.89 90 top
NOREF#807  -  []  166.61 308.86 0 top
NOREF#808  -  []  194.79 310.23 0 top
NOREF#809  -  []  209.76 307.48 90 top
NOREF#810  -  []  268.2 7.59 0 top
NOREF#811  -  []  155 7.59 90 top
NOREF#812  -  []  235.07 -4.22 90 top
NOREF#813  -  []  228.46 304.73 90 top
NOREF#814  -  []  257.65 68.94 0 top
NOREF#815  -  []  307.7 167.62 90 top
NOREF#816  -  []  159.18 308.86 0 top
NOREF#817  -  []  112.1 56.42 90 top
NOREF#818  -  []  152.5 184.3 0 top
NOREF#819  -  []  249 25.59 90 top
NOREF#820  -  []  68.04 130.91 0 top
NOREF#821  -  []  77.33 179.53 90 top
NOREF#822  -  []  324.16 162.73 0 top
NOREF#823  -  []  127.2 7.59 0 top
NOREF#824  -  []  96.9 53.12 0 top
NOREF#825  -  []  253.1 52.42 90 top
NOREF#826  -  []  50.63 139.05 90 top
NOREF#827  -  []  -1.36 63.38 90 top
NOREF#828  -  []  334.67 171.19 90 top
NOREF#829  -  []  421.92 1.2 90 top
NOREF#830  -  []  362.2 7.59 0 top
NOREF#831  -  []  108 45.29 90 top
NOREF#832  -  []  143.1 65.82 0 top
NOREF#833  -  []  286.8 2.95 90 top
NOREF#834  -  []  102.58 221 90 top
NOREF#835  -  []  400.1 -3.25 0 top
NOREF#836  -  []  192.8 2.95 90 top
NOREF#837  -  []  61.4 51.89 0 top
NOREF#838  -  []  124.9 53.12 0 top
NOREF#839  -  []  347.5 150.8 0 top
NOREF#840  -  []  399.5 56.15 0 top
NOREF#841  -  []  99 12.09 90 top
NOREF#842  -  []  142.76 305.23 90 top
NOREF#843  -  []  143.67 161.29 0 top
NOREF#844  -  []  81.89 167.43 0 top
NOREF#845  -  []  375.6 140.11 90 top
NOREF#846  -  []  108.45 360.47 0 top
NOREF#847  -  []  33.2 51.89 0 top
NOREF#848  -  []  -15.15 -3.25 0 top
NOREF#849  -  []  241.23 -4.22 90 top
NOREF#850  -  []  426.22 2.15 90 top
NOREF#851  -  []  108.4 51.89 90 top
NOREF#852  -  []  338.77 106.98 90 top
NOREF#853  -  []  135.43 307.48 90 top
NOREF#854  -  []  382.75 109.51 0 top
NOREF#855  -  []  -69.81 380.36 90 top
NOREF#856  -  []  -121.33 335.68 0 top
NOREF#857  -  []  -24.35 68.94 0 top
NOREF#858  -  []  112.1 52.42 90 top
NOREF#859  -  []  174.05 308.86 0 top
NOREF#860  -  []  53.23 -4.22 90 top
NOREF#861  -  []  163.66 158.99 90 top
NOREF#862  -  []  108 16.59 90 top
NOREF#863  -  []  350.77 124.98 90 top
NOREF#864  -  []  194.23 -4.22 90 top
NOREF#865  -  []  108.4 51.89 0 top
NOREF#866  -  []  108.4 51.89 0 top
NOREF#867  -  []  99 51.89 90 top
NOREF#868  -  []  0.44 35.91 90 top
NOREF#869  -  []  381 51.89 90 top
NOREF#870  -  []  44.67 309.43 0 top
NOREF#871  -  []  344.65 307.54 0 top
NOREF#872  -  []  53.23 -4.22 90 top
NOREF#873  -  []  247.97 203.35 90 top
NOREF#874  -  []  52.4 34.59 90 top
NOREF#875  -  []  235.5 65.12 0 top
NOREF#876  -  []  139.64 217.68 0 top
NOREF#877  -  []  106.78 -4.22 90 top
NOREF#878  -  []  45.29 360.47 0 top
NOREF#879  -  []  135.83 310.13 0 top
NOREF#880  -  []  68.35 151.52 90 top
NOREF#881  -  []  -116.08 322.83 0 top
NOREF#882  -  []  238.48 115.81 0 top
NOREF#883  -  []  330.3 52.42 90 top
NOREF#884  -  []  75.78 305.28 90 top
NOREF#885  -  []  69 171.44 0 top
NOREF#886  -  []  378.92 215.16 0 top
NOREF#887  -  []  48.3 64.42 0 top
NOREF#888  -  []  359.96 150.01 0 top
NOREF#889  -  []  347.74 140.79 90 top
NOREF#890  -  []  77.9 53.12 0 top
NOREF#891  -  []  296 7.59 0 top
NOREF#892  -  []  193 51.89 0 top
NOREF#893  -  []  268.2 7.59 0 top
NOREF#894  -  []  296.4 51.89 90 top
NOREF#895  -  []  92.38 132.38 0 top
NOREF#896  -  []  421.92 1.2 0 top
NOREF#897  -  []  -124.33 334.98 90 top
NOREF#898  -  []  319.97 306.63 90 top
NOREF#899  -  []  152.01 157.07 0 top
NOREF#900  -  []  282.07 -4.22 90 top
NOREF#901  -  []  70.5 140.96 0 top
NOREF#902  -  []  407.12 56.15 0 top
NOREF#903  -  []  135.43 309.48 0 top
NOREF#904  -  []  315.2 51.89 0 top
NOREF#905  -  []  13.8 2.95 90 top
NOREF#906  -  []  150.77 210.69 90 top
NOREF#907  -  []  31.46 362.77 0 top
NOREF#908  -  []  254.7 173.77 0 top
NOREF#909  -  []  284.9 53.12 0 top
NOREF#910  -  []  152.35 135.65 0 top
NOREF#911  -  []  718.12 67.75 0 top
NOREF#912  -  []  119.88 362.77 0 top
NOREF#913  -  []  153.78 -4.22 90 top
NOREF#914  -  []  6.04 226 90 top
NOREF#915  -  []  82.59 153.52 0 top
NOREF#916  -  []  125.56 353.52 0 top
NOREF#917  -  []  244.07 288.54 0 top
NOREF#918  -  []  344.48 183.43 0 top
NOREF#919  -  []  63.5 65.12 0 top
NOREF#920  -  []  410.78 34.15 90 top
NOREF#921  -  []  16.5 65.12 0 top
NOREF#922  -  []  357.91 177.29 90 top
NOREF#923  -  []  193.4 7.59 90 top
NOREF#924  -  []  108.4 51.89 0 top
NOREF#925  -  []  69 161.28 0 top
NOREF#926  -  []  44.34 347.34 0 top
NOREF#927  -  []  347.63 165.4 90 top
NOREF#928  -  []  359.9 53.12 0 top
NOREF#929  -  []  406.59 34.15 90 top
NOREF#930  -  []  204.5 53.12 90 top
NOREF#931  -  []  14.4 12.09 0 top
NOREF#932  -  []  157.5 65.12 0 top
NOREF#933  -  []  68.35 131.2 90 top
NOREF#934  -  []  48.15 240.7 0 top
NOREF#935  -  []  157.5 65.12 0 top
NOREF#936  -  []  381.4 45.29 90 top
NOREF#937  -  []  92.38 152.7 0 top
NOREF#938  -  []  84.61 310.21 0 top
NOREF#939  -  []  52.42 113.06 90 top
NOREF#940  -  []  148.54 212.24 0 top
NOREF#941  -  []  288.62 -4.22 0 top
NOREF#942  -  []  31.31 351.6 0 top
NOREF#943  -  [unnamed#3]  409.5 70.5 0 top
NOREF#944  -  []  319.17 306.58 90 top
NOREF#945  -  []  33.2 51.89 0 top
NOREF#946  -  []  80.2 51.89 0 top
NOREF#947  -  []  84.06 305.28 90 top
NOREF#948  -  []  69.36 362.77 0 top
NOREF#949  -  []  100.62 310.38 0 top
NOREF#950  -  []  7.25 343 90 top
NOREF#951  -  []  63.5 65.12 0 top
NOREF#952  -  []  255.33 173.14 90 top
NOREF#953  -  []  108 16.59 90 top
NOREF#954  -  []  241.62 -4.22 90 top
NOREF#955  -  []  14.4 51.89 0 top
NOREF#956  -  []  150.7 310.13 0 top
NOREF#957  -  []  59.78 -4.22 90 top
NOREF#958  -  []  342.75 68.94 0 top
NOREF#959  -  []  73.25 151.01 90 top
NOREF#960  -  []  378.9 53.12 90 top
NOREF#961  -  []  380.21 349.54 0 top
NOREF#962  -  []  383.9 199.7 0 top
NOREF#963  -  []  -8.72 358.37 90 top
NOREF#964  -  []  347.5 181.28 0 top
NOREF#965  -  []  421.82 2.15 0 top
NOREF#966  -  []  92.89 305.46 90 top
NOREF#967  -  []  187.15 216.68 0 top
NOREF#968  -  []  249.4 51.89 0 top
NOREF#969  -  []  347.74 171.27 90 top
NOREF#970  -  []  101.83 222.4 0 top
NOREF#971  -  []  63.5 53.12 90 top
NOREF#972  -  []  335.62 -4.22 90 top
NOREF#973  -  []  423.07 -0.15 90 top
NOREF#974  -  []  61.4 12.09 90 top
NOREF#975  -  []  251.5 65.12 0 top
NOREF#976  -  []  296 34.59 90 top
NOREF#977  -  []  99 51.89 90 top
NOREF#978  -  []  341.78 -4.22 90 top
NOREF#979  -  []  76.33 310.21 0 top
NOREF#980  -  []  147.62 -4.22 90 top
NOREF#981  -  []  202 25.59 90 top
NOREF#982  -  []  136.8 2.95 90 top
NOREF#983  -  []  73.25 140.85 90 top
NOREF#984  -  []  406.46 33.25 90 top
NOREF#985  -  []  146 51.89 90 top
NOREF#986  -  []  155.4 51.89 0 top
NOREF#987  -  []  201.75 68.94 0 top
NOREF#988  -  []  284.1 65.82 0 top
NOREF#989  -  []  -129.92 320.18 0 top
NOREF#990  -  []  52 51.89 90 top
NOREF#991  -  []  -4.97 35.11 90 top
NOREF#992  -  []  202.73 310.13 0 top
NOREF#993  -  []  343 34.59 90 top
NOREF#994  -  []  202.4 51.89 0 top
NOREF#995  -  []  202.73 310.13 0 top
NOREF#996  -  []  334 51.89 90 top
NOREF#997  -  []  24.73 106.08 90 top
NOREF#998  -  []  330.78 306.59 90 top
NOREF#999  -  []  405.55 10.46 90 top
NOREF#1000  -  []  345.5 65.12 0 top
NOREF#1001  -  []  241.62 -4.22 0 top
NOREF#1002  -  []  343 16.59 90 top
NOREF#1003  -  []  -75.27 350.43 0 top
NOREF#1004  -  []  70.5 130.8 0 top
NOREF#1005  -  []  376.43 343.14 90 top
NOREF#1006  -  []  180.43 310.13 0 top
NOREF#1007  -  []  68.04 181.71 0 top
NOREF#1008  -  []  2.65 39.81 0 top
NOREF#1009  -  []  193.4 25.59 90 top
NOREF#1010  -  []  714.12 135.25 0 top
NOREF#1011  -  []  221.2 51.89 0 top
NOREF#1012  -  []  64.1 216.3 90 top
NOREF#1013  -  []  155 34.59 90 top
NOREF#1014  -  []  298.8 173.09 90 top
NOREF#1015  -  []  251.5 53.12 90 top
NOREF#1016  -  []  247.78 -4.22 0 top
NOREF#1017  -  []  68.35 161.68 90 top
NOREF#1018  -  []  202 16.59 90 top
NOREF#1019  -  []  244.8 226 90 top
NOREF#1020  -  []  143.26 310.13 0 top
NOREF#1021  -  []  13.75 68.94 0 top
NOREF#1022  -  []  112.1 52.42 90 top
NOREF#1023  -  []  358.84 145.76 0 top
NOREF#1024  -  []  237.9 53.12 90 top
NOREF#1025  -  []  16.5 65.12 0 top
NOREF#1026  -  []  194.62 -4.22 90 top
NOREF#1027  -  []  146.4 34.59 90 top
NOREF#1028  -  []  30.9 53.12 0 top
NOREF#1029  -  []  122.5 189.3 0 top
NOREF#1030  -  []  -119.83 334.98 0 top
NOREF#1031  -  []  343 7.59 90 top
NOREF#1032  -  []  296.4 51.89 0 top
NOREF#1033  -  []  188.91 308.86 0 top
NOREF#1034  -  []  245.4 307.53 0 top
NOREF#1035  -  []  69.43 353.52 0 top
NOREF#1036  -  []  183.8 2.95 90 top
NOREF#1037  -  []  56.09 201.67 0 top
NOREF#1038  -  []  373.82 196.49 90 top
NOREF#1039  -  []  338.77 106.98 0 top
NOREF#1040  -  []  174.2 7.59 0 top
NOREF#1041  -  []  202 7.59 90 top
NOREF#1042  -  []  61.4 51.89 90 top
NOREF#1043  -  []  73.25 130.69 90 top
NOREF#1044  -  []  202 7.59 0 top
NOREF#1045  -  []  296 7.59 0 top
NOREF#1046  -  []  283.3 56.42 90 top
NOREF#1047  -  []  357.91 156.97 90 top
NOREF#1048  -  []  22.65 68.94 0 top
NOREF#1049  -  []  312.91 283.52 90 top
NOREF#1050  -  []  287 51.89 90 top
NOREF#1051  -  []  144.31 308.86 0 top
NOREF#1052  -  []  298.5 65.12 0 top
NOREF#1053  -  []  100.23 -4.22 90 top
NOREF#1054  -  []  378.9 53.12 0 top
NOREF#1055  -  []  18.85 128.02 0 top
NOREF#1056  -  []  718.12 135.25 0 top
NOREF#1057  -  []  95.3 64.42 0 top
NOREF#1058  -  []  204.5 65.12 0 top
NOREF#1059  -  []  99.4 16.59 90 top
NOREF#1060  -  []  239.77 307.53 0 top
NOREF#1061  -  []  368.36 211.35 90 top
NOREF#1062  -  []  391.19 115.95 0 top
NOREF#1063  -  []  324.16 173.15 0 top
NOREF#1064  -  []  172.5 310.23 0 top
NOREF#1065  -  []  51.8 2.95 90 top
NOREF#1066  -  []  345.5 53.12 90 top
NOREF#1067  -  []  401.7 53.87 0 top
NOREF#1068  -  []  73.25 181.49 90 top
NOREF#1069  -  []  249.4 51.89 0 top
NOREF#1070  -  []  378.9 139.05 0 top
NOREF#1071  -  []  154.8 2.95 90 top
NOREF#1072  -  []  14.4 51.89 0 top
NOREF#1073  -  []  41.59 111.09 90 top
NOREF#1074  -  []  425.72 3.45 90 top
NOREF#1075  -  []  99 12.09 90 top
NOREF#1076  -  []  74.33 125.53 90 top
NOREF#1077  -  []  251.5 65.12 0 top
NOREF#1078  -  []  -61.81 387.71 0 top
NOREF#1079  -  []  323.46 187.18 0 top
NOREF#1080  -  []  212.16 305.33 90 top
NOREF#1081  -  []  33.2 51.89 0 top
NOREF#1082  -  []  128.4 310.13 0 top
NOREF#1083  -  []  83.18 360.47 0 top
NOREF#1084  -  []  34.61 126.1 90 top
NOREF#1085  -  []  347.74 150.95 90 top
NOREF#1086  -  []  382.58 108.96 0 top
NOREF#1087  -  []  357.96 180.09 0 top
NOREF#1088  -  []  94.07 -4.22 90 top
NOREF#1089  -  []  341.78 -4.22 0 top
NOREF#1090  -  []  110.5 65.12 0 top
NOREF#1091  -  []  16.5 65.12 0 top
NOREF#1092  -  []  92.38 180.25 90 top
NOREF#1093  -  []  286.8 2.95 90 top
NOREF#1094  -  []  42.06 358.17 90 top
NOREF#1095  -  []  249 34.59 90 top
NOREF#1096  -  []  10.73 106.08 0 top
NOREF#1097  -  []  319.17 306.58 0 top
NOREF#1098  -  []  794.32 190.62 0 top
NOREF#1099  -  []  204.5 65.12 0 top
NOREF#1100  -  []  411.03 -0.99 270 top
NOREF#1101  -  []  241.78 140.83 0 top
NOREF#1102  -  []  142.96 119.02 0 top
NOREF#1103  -  []  221.2 51.89 0 top
NOREF#1104  -  []  65.33 191.53 0 top
NOREF#1105  -  []  334 12.09 90 top
NOREF#1106  -  []  345.9 355.94 0 top
NOREF#1107  -  []  381.14 213.61 90 top
NOREF#1108  -  []  47.9 165.44 90 top
NOREF#1109  -  []  188.07 -4.22 90 top
NOREF#1110  -  []  341.77 190.98 0 top
NOREF#1111  -  []  108 45.29 90 top
NOREF#1112  -  []  147.23 -4.22 90 top
NOREF#1113  -  []  298.8 173.09 90 top
NOREF#1114  -  []  343 45.29 90 top
NOREF#1115  -  []  11.3 216.3 0 top
NOREF#1116  -  []  52.4 45.29 90 top
NOREF#1117  -  []  -21.47 364.77 0 top
NOREF#1118  -  []  174.2 51.89 0 top
NOREF#1119  -  []  159.1 52.42 90 top
NOREF#1120  -  []  -77.97 352.28 0 top
NOREF#1121  -  []  42.57 182.71 90 top
NOREF#1122  -  []  423.07 -4.22 90 top
NOREF#1123  -  []  60.8 2.95 90 top
NOREF#1124  -  []  407.3 218.15 0 top
NOREF#1125  -  []  48.38 125.56 90 top
NOREF#1126  -  []  330.3 56.42 90 top
NOREF#1127  -  []  383.01 133.51 0 top
NOREF#1128  -  []  68.35 153.52 0 top
NOREF#1129  -  []  421.65 3.55 0 top
NOREF#1130  -  []  221.2 51.89 0 top
NOREF#1131  -  []  147.23 -4.22 90 top
NOREF#1132  -  []  412.2 223 90 top
NOREF#1133  -  []  68.35 131.2 90 top
NOREF#1134  -  []  331.9 53.12 0 top
NOREF#1135  -  []  284.9 53.12 0 top
NOREF#1136  -  []  308.7 171.96 0 top
NOREF#1137  -  []  312.9 53.12 0 top
NOREF#1138  -  []  236.3 64.42 0 top
NOREF#1139  -  []  101.17 310.21 0 top
NOREF#1140  -  []  380.67 212.06 90 top
NOREF#1141  -  []  32.66 360.47 0 top
NOREF#1142  -  []  361.44 110.55 0 top
NOREF#1143  -  []  127.9 305.23 90 top
NOREF#1144  -  []  174.2 51.89 0 top
NOREF#1145  -  []  419.9 -3.25 90 top
NOREF#1146  -  []  193 12.09 90 top
NOREF#1147  -  []  92.59 358.17 90 top
NOREF#1148  -  [unnamed#2]  65.33 191.53 270 top
NOREF#1149  -  []  247.21 294.48 0 top
NOREF#1150  -  []  80.2 7.59 0 top
NOREF#1151  -  []  125.56 343.02 90 top
NOREF#1152  -  []  12.78 -4.22 90 top
NOREF#1153  -  []  155 16.59 90 top
NOREF#1154  -  []  43.52 201.17 0 top
NOREF#1155  -  []  241.23 -4.22 90 top
NOREF#1156  -  []  343 7.59 0 top
NOREF#1157  -  []  95.08 209.6 0 top
NOREF#1158  -  []  249 7.59 0 top
NOREF#1159  -  []  73.25 161.17 90 top
NOREF#1160  -  []  130.4 305.33 90 top
NOREF#1161  -  []  362.2 51.89 0 top
NOREF#1162  -  []  404.19 140 0 top
NOREF#1163  -  []  33.2 7.59 0 top
NOREF#1164  -  []  347.74 134.13 90 top
NOREF#1165  -  []  174.2 51.89 0 top
NOREF#1166  -  []  61 7.59 0 top
NOREF#1167  -  []  74.33 125.53 0 top
NOREF#1168  -  []  249.4 51.89 0 top
NOREF#1169  -  []  347.1 52.42 90 top
NOREF#1170  -  []  347.74 174.77 90 top
NOREF#1171  -  []  209.66 305.23 90 top
NOREF#1172  -  []  387.53 109.11 90 top
NOREF#1173  -  []  48.15 225.7 90 top
NOREF#1174  -  []  315.2 7.59 0 top
NOREF#1175  -  []  -7.49 68.47 0 top
NOREF#1176  -  []  74.33 125.53 90 top
NOREF#1177  -  []  202 25.59 90 top
NOREF#1178  -  []  163.65 68.94 0 top
NOREF#1179  -  []  51.8 2.95 90 top
NOREF#1180  -  []  331.9 53.12 0 top
NOREF#1181  -  []  83.47 343.02 90 top
NOREF#1182  -  []  157.63 310.23 0 top
NOREF#1183  -  []  155 7.59 90 top
NOREF#1184  -  []  142.96 133.35 0 top
NOREF#1185  -  []  53.62 -4.22 90 top
NOREF#1186  -  []  287 51.89 0 top
NOREF#1187  -  []  790.32 190.62 0 top
NOREF#1188  -  []  65.89 200.86 0 top
NOREF#1189  -  []  101.17 305.46 90 top
NOREF#1190  -  []  255.1 212.6 90 top
NOREF#1191  -  []  206.1 56.42 90 top
NOREF#1192  -  []  173.16 170.82 270 top
NOREF#1193  -  []  329.5 65.12 0 top
NOREF#1194  -  []  296.4 12.09 90 top
NOREF#1195  -  []  358.71 183.99 0 top
NOREF#1196  -  []  102.88 170.09 90 top
NOREF#1197  -  []  294.78 -4.22 0 top
NOREF#1198  -  []  155 7.59 0 top
NOREF#1199  -  []  61.4 51.89 0 top
NOREF#1200  -  []  -72.51 387.71 0 top
NOREF#1201  -  []  342.8 2.95 90 top
NOREF#1202  -  []  240.4 25.59 90 top
NOREF#1203  -  []  28.1 216.3 90 top
NOREF#1204  -  []  155 7.59 0 top
NOREF#1205  -  []  300.1 56.42 90 top
NOREF#1206  -  []  347.74 164.61 90 top
NOREF#1207  -  []  210.16 310.13 0 top
NOREF#1208  -  []  210.16 310.13 0 top
NOREF#1209  -  []  107.08 209.6 90 top
NOREF#1210  -  []  4.16 358.17 90 top
NOREF#1211  -  []  6.02 2 270 top
NOREF#1212  -  []  345.5 65.12 0 top
NOREF#1213  -  []  39.78 135.13 0 top
NOREF#1214  -  []  296.4 51.89 0 top
NOREF#1215  -  []  2.65 35.11 90 top
NOREF#1216  -  []  -70.67 353.78 0 top
NOREF#1217  -  []  -6.44 362.77 0 top
NOREF#1218  -  []  345.09 175.67 0 top
NOREF#1219  -  []  345.09 165.51 0 top
NOREF#1220  -  []  320.32 305.23 0 top
NOREF#1221  -  []  73.15 184 90 top
NOREF#1222  -  []  265.9 53.12 0 top
NOREF#1223  -  []  92.34 310.38 0 top
NOREF#1224  -  []  338.76 2 270 top
NOREF#1225  -  []  61.4 51.89 0 top
NOREF#1226  -  []  137.83 305.33 90 top
NOREF#1227  -  []  155.4 51.89 90 top
NOREF#1228  -  []  203.78 308.86 0 top
NOREF#1229  -  []  -129.92 320.18 90 top
NOREF#1230  -  []  239.8 2.95 90 top
NOREF#1231  -  []  218.9 53.12 0 top
NOREF#1232  -  []  381 12.09 90 top
NOREF#1233  -  []  330.3 64.42 0 top
NOREF#1234  -  []  401.65 -3.25 0 top
NOREF#1235  -  []  341.78 -4.22 90 top
NOREF#1236  -  []  14 34.59 90 top
NOREF#1237  -  []  421.82 2.15 90 top
NOREF#1238  -  []  136.88 308.86 0 top
NOREF#1239  -  []  249.4 12.09 0 top
NOREF#1240  -  []  202 45.29 90 top
NOREF#1241  -  []  80.2 51.89 0 top
NOREF#1242  -  []  30.9 53.12 0 top
NOREF#1243  -  []  303.11 287.27 0 top
NOREF#1244  -  []  362.2 7.59 0 top
NOREF#1245  -  []  -22.72 371.17 0 top
NOREF#1246  -  []  14 7.59 90 top
NOREF#1247  -  []  65.73 226 90 top
NOREF#1248  -  []  -120.58 336.38 0 top
NOREF#1249  -  []  133.71 360.47 0 top
NOREF#1250  -  []  194.62 -4.22 0 top
NOREF#1251  -  []  240 12.09 90 top
NOREF#1252  -  []  -69.81 385.86 0 top
NOREF#1253  -  []  61 45.29 90 top
NOREF#1254  -  []  334.4 34.59 90 top
NOREF#1255  -  []  -7.49 68.47 90 top
NOREF#1256  -  []  343 45.29 90 top
NOREF#1257  -  []  40.83 138.43 0 top
NOREF#1258  -  []  359.9 343.14 90 top
NOREF#1259  -  []  224.16 158.82 270 top
NOREF#1260  -  []  70.5 151.12 0 top
NOREF#1261  -  []  94.5 65.12 0 top
NOREF#1262  -  []  127.2 51.89 0 top
NOREF#1263  -  []  181.48 308.86 0 top
NOREF#1264  -  []  155 7.59 0 top
NOREF#1265  -  []  3.1 -3.25 90 top
NOREF#1266  -  []  296.4 12.09 0 top
NOREF#1267  -  []  339.79 205.23 0 top
NOREF#1268  -  []  222.87 307.53 0 top
NOREF#1269  -  []  330.04 169.33 0 top
NOREF#1270  -  []  296 25.59 90 top
NOREF#1271  -  []  165.05 135.84 90 top
NOREF#1272  -  []  287.4 16.59 90 top
NOREF#1273  -  []  172.5 305.23 90 top
NOREF#1274  -  []  307.7 176.22 0 top
NOREF#1275  -  []  250.79 153.06 90 top
NOREF#1276  -  []  -77.97 352.28 0 top
NOREF#1277  -  []  159.1 56.42 90 top
NOREF#1278  -  []  52.4 16.59 90 top
NOREF#1279  -  []  202.4 51.89 0 top
NOREF#1280  -  []  154.8 2.95 90 top
NOREF#1281  -  []  361.44 103.05 90 top
NOREF#1282  -  []  -5.24 360.47 0 top
NOREF#1283  -  []  224.16 158.82 270 top
NOREF#1284  -  []  43.69 187.96 0 top
NOREF#1285  -  []  110.5 65.12 0 top
NOREF#1286  -  []  39.77 311.18 0 top
NOREF#1287  -  []  89.08 210.3 90 top
NOREF#1288  -  []  188.5 65.12 0 top
NOREF#1289  -  []  128 309.48 0 top
NOREF#1290  -  []  16.5 53.12 90 top
NOREF#1291  -  []  108.4 51.89 0 top
NOREF#1292  -  []  320.32 305.23 90 top
NOREF#1293  -  []  108 7.59 0 top
NOREF#1294  -  []  369.89 220.48 0 top
NOREF#1295  -  []  251.5 65.12 0 top
NOREF#1296  -  []  344.48 163.11 0 top
NOREF#1297  -  []  77.33 194.53 0 top
NOREF#1298  -  []  202.33 307.48 90 top
NOREF#1299  -  []  14.4 51.89 0 top
NOREF#1300  -  []  -72.51 387.71 0 top
NOREF#1301  -  []  84.59 348.27 0 top
NOREF#1302  -  []  240 51.89 90 top
NOREF#1303  -  []  110.5 53.12 90 top
NOREF#1304  -  []  259.96 214.97 0 top
NOREF#1305  -  []  342.75 68.94 0 top
NOREF#1306  -  []  165.06 305.23 90 top
NOREF#1307  -  []  247.78 -4.22 90 top
NOREF#1308  -  []  347.74 161.11 90 top
NOREF#1309  -  []  409.89 33.25 90 top
NOREF#1310  -  []  -125.08 324.98 0 top
NOREF#1311  -  []  165.05 135.84 90 top
NOREF#1312  -  []  14 7.59 0 top
NOREF#1313  -  []  248.8 2.95 90 top
NOREF#1314  -  []  296 7.59 0 top
NOREF#1315  -  []  202 34.59 90 top
NOREF#1316  -  []  157.5 53.12 90 top
NOREF#1317  -  []  147.62 -4.22 0 top
NOREF#1318  -  []  157.5 53.12 90 top
NOREF#1319  -  []  53.68 180.19 0 top
NOREF#1320  -  []  33.2 51.89 0 top
NOREF#1321  -  []  65.33 191.53 0 top
NOREF#1322  -  []  308.52 346.49 0 top
NOREF#1323  -  []  326.38 349.99 0 top
NOREF#1324  -  []  108.4 12.09 0 top
NOREF#1325  -  []  80.2 7.59 0 top
NOREF#1326  -  []  282.5 65.12 0 top
NOREF#1327  -  []  287.4 25.59 90 top
NOREF#1328  -  []  345.5 65.12 0 top
NOREF#1329  -  []  335.23 -4.22 90 top
NOREF#1330  -  []  82.59 143.36 0 top
NOREF#1331  -  []  369.21 164.7 90 top
NOREF#1332  -  []  343 25.59 90 top
NOREF#1333  -  []  -67.27 352.28 90 top
NOREF#1334  -  []  96.9 53.12 0 top
NOREF#1335  -  []  14 45.29 90 top
NOREF#1336  -  []  347.74 154.45 90 top
NOREF#1337  -  [unnamed#3]  400.5 70.5 0 top
NOREF#1338  -  []  202.4 51.89 0 top
NOREF#1339  -  []  187.46 309.48 0 top
NOREF#1340  -  []  249 7.59 90 top
NOREF#1341  -  []  323.46 166.48 0 top
NOREF#1342  -  []  80.2 51.89 0 top
NOREF#1343  -  []  74 201.17 0 top
NOREF#1344  -  []  53.68 139.55 0 top
NOREF#1345  -  []  173 310.13 0 top
NOREF#1346  -  []  67.32 358.17 90 top
NOREF#1347  -  []  195.29 310.13 0 top
NOREF#1348  -  []  -72.51 387.71 0 top
NOREF#1349  -  []  365.13 119.58 0 top
NOREF#1350  -  []  237.9 53.12 0 top
NOREF#1351  -  []  307.12 349.99 0 top
NOREF#1352  -  []  204.5 65.12 0 top
NOREF#1353  -  []  347.74 181.43 90 top
NOREF#1354  -  []  101.08 221.7 90 top
NOREF#1355  -  []  142.3 52.42 90 top
NOREF#1356  -  []  92.89 310.21 0 top
NOREF#1357  -  []  380.8 2.95 90 top
NOREF#1358  -  []  47.9 155.05 0 top
NOREF#1359  -  []  347.63 145.08 90 top
NOREF#1360  -  []  14 25.59 90 top
NOREF#1361  -  []  236.16 107.82 270 top
NOREF#1362  -  []  347.35 306.59 90 top
NOREF#1363  -  []  96.9 53.12 90 top
NOREF#1364  -  []  7.25 351.6 0 top
NOREF#1365  -  []  49.9 53.12 0 top
NOREF#1366  -  []  189.3 52.42 90 top
NOREF#1367  -  []  82.59 173.84 0 top
NOREF#1368  -  []  84.61 305.46 90 top
NOREF#1369  -  []  245.35 304.73 90 top
NOREF#1370  -  []  371.8 2.95 90 top
NOREF#1371  -  []  197.05 106.84 0 top
NOREF#1372  -  []  330.04 169.33 90 top
NOREF#1373  -  []  171.9 53.12 0 top
NOREF#1374  -  []  49.9 53.12 90 top
NOREF#1375  -  []  346.47 174.22 0 top
NOREF#1376  -  []  296.4 51.89 0 top
NOREF#1377  -  []  202.33 309.48 0 top
NOREF#1378  -  []  343 7.59 0 top
NOREF#1379  -  []  399.35 34.15 90 top
NOREF#1380  -  []  238.38 106.66 0 top
NOREF#1381  -  []  391.44 139.95 0 top
NOREF#1382  -  []  298.5 65.12 0 top
NOREF#1383  -  []  345.5 65.12 0 top
NOREF#1384  -  []  382.23 -4.22 90 top
NOREF#1385  -  []  379.45 164.36 90 top
NOREF#1386  -  []  68.35 184 0 top
NOREF#1387  -  []  259.96 210.97 90 top
NOREF#1388  -  []  240 51.89 90 top
NOREF#1389  -  []  283.3 52.42 90 top
NOREF#1390  -  []  108.4 51.89 0 top
NOREF#1391  -  []  63.5 65.12 0 top
NOREF#1392  -  []  422.72 1.25 90 top
NOREF#1393  -  []  185.16 119.82 0 top
NOREF#1394  -  []  98.62 348.27 0 top
NOREF#1395  -  []  103.69 2 270 top
NOREF#1396  -  []  296 25.59 90 top
NOREF#1397  -  []  52 51.89 0 top
NOREF#1398  -  []  69 151.12 0 top
NOREF#1399  -  []  100.62 -4.22 0 top
NOREF#1400  -  []  409.32 53.87 0 top
NOREF#1401  -  []  80.2 51.89 0 top
NOREF#1402  -  []  257.84 217.88 0 top
NOREF#1403  -  []  249.4 51.89 0 top
NOREF#1404  -  []  180.43 310.13 0 top
NOREF#1405  -  []  346.47 153.9 0 top
NOREF#1406  -  []  206.1 56.42 90 top
NOREF#1407  -  []  202.23 310.23 0 top
NOREF#1408  -  []  302.41 291.02 0 top
NOREF#1409  -  []  143.14 124.86 90 top
NOREF#1410  -  []  251.72 159.77 90 top
NOREF#1411  -  []  189.86 305.33 90 top
NOREF#1412  -  []  -61.81 387.71 90 top
NOREF#1413  -  []  347.74 161.11 90 top
NOREF#1414  -  []  142.86 309.48 0 top
NOREF#1415  -  []  192.8 2.95 90 top
NOREF#1416  -  []  200.78 -4.22 0 top
NOREF#1417  -  []  12.78 -4.22 0 top
NOREF#1418  -  []  412.2 228.5 0 top
NOREF#1419  -  []  68.35 173.84 0 top
NOREF#1420  -  []  219.01 218.9 270 top
NOREF#1421  -  []  388.19 24.15 0 top
NOREF#1422  -  []  89.8 2.95 90 top
NOREF#1423  -  []  343.4 51.89 0 top
NOREF#1424  -  []  242.31 166.67 0 top
NOREF#1425  -  []  296 7.59 0 top
NOREF#1426  -  []  204.73 305.33 90 top
NOREF#1427  -  []  237.1 65.82 0 top
NOREF#1428  -  []  84.25 207.43 0 top
NOREF#1429  -  []  -67.27 352.28 0 top
NOREF#1430  -  []  6.92 124.21 0 top
NOREF#1431  -  []  196.34 308.86 0 top
NOREF#1432  -  []  73.15 173.84 90 top
NOREF#1433  -  []  127.2 7.59 0 top
NOREF#1434  -  []  283.3 64.42 0 top
NOREF#1435  -  []  334 12.09 90 top
NOREF#1436  -  []  141.07 -4.22 90 top
NOREF#1437  -  []  314.72 342.89 90 top
NOREF#1438  -  []  82.59 163.68 0 top
NOREF#1439  -  []  365.13 116.88 90 top
NOREF#1440  -  []  206.1 52.42 90 top
NOREF#1441  -  []  334 51.89 0 top
NOREF#1442  -  []  49.9 53.12 0 top
NOREF#1443  -  []  116.65 68.94 0 top
NOREF#1444  -  []  127.2 51.89 0 top
NOREF#1445  -  []  315.2 51.89 0 top
NOREF#1446  -  []  146.4 7.59 90 top
NOREF#1447  -  []  92.38 173.02 0 top
NOREF#1448  -  []  108.4 12.09 90 top
NOREF#1449  -  []  2.44 30.6 90 top
NOREF#1450  -  []  42.53 205.43 0 top
NOREF#1451  -  []  153.78 -4.22 0 top
NOREF#1452  -  []  234.14 307.53 0 top
NOREF#1453  -  []  239.72 304.73 90 top
NOREF#1454  -  []  249.4 51.89 90 top
NOREF#1455  -  []  329.42 173.73 0 top
NOREF#1456  -  []  165.16 307.48 90 top
NOREF#1457  -  []  249 7.59 0 top
NOREF#1458  -  []  189.3 56.42 90 top
NOREF#1459  -  []  44.09 362.77 0 top
NOREF#1460  -  []  68.35 141.36 90 top
NOREF#1461  -  []  42.57 193.21 0 top
OSC1  25.0007M  [CRYSTAL]  313.04 197.71 180 top
OSC2  25.000625MHz  [OSC_SMD7MX5MX1M4_4]  315.99 208.56 180 top
Q2  MMBT3904LT1G  [SOT_23]  275.27 216.66 90 bottom
