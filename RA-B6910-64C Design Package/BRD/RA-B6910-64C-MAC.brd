# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RESETL44: length 214.5
  SIG4 w0.155: v1(84.14,123.44) 82.87,124.71 80.08,124.71 78.04,122.68 65.59,122.68 61.01,127.26 61.01,133.5 58.02,136.5 47.12,136.5 38.71,144.9 34.99,144.9 34.61,144.52 v1(29.27,144.52)
  SIG8 w0.155: YJ28.D9 165.26,52.66 165.26,53.27 164.92,53.61 164.92,56.63 165.26,56.97 165.26,57.27 164.88,57.65 164.88,60.59 165.26,60.97 165.26,61.28 164.92,61.62 164.92,64.63 165.2,64.91 165.2,65.33 164.92,65.61 164.92,66.05 166.31,67.45 166.31,71.25 166.79,71.73 166.79,72.92 166.31,73.4 166.31,78.1 165.93,78.48 165.93,80.77 v1(166.43,81.28)
  SIG10 w0.155: v1(84.14,123.44) 84.94,122.64 110.78,122.64 138.21,95.21 138.21,94.26 139.13,93.34 139.13,88.26 140.65,86.74 142.18,86.74 143.57,85.34 143.57,82.93 144.96,81.55 156.03,81.55 158.05,83.56 160.35,83.56 160.86,83.06 164.53,83.06 165.04,83.56 165.57,83.56 165.93,83.21 165.93,81.79 v1(166.43,81.28)
  BOTTOM w0.13: v1(166.43,81.28) 166.94,81.79 166.94,83.56 166.79,83.72 R2735.1 ; v1(29.27,144.52) v2(28.45,145.35) 28.26,145.54 R3339.1
RESETL45: length 210.7
  TOP w0.13: v1(166.31,72.13) 165.7,72.74 165.7,72.92 166.31,73.53 166.31,77.47 166.43,77.59 R2733.2 ; R3343.1 v1(29.27,146.43)
  SIG4 w0.155: v1(85.41,123.44) 83.5,125.35 78.94,125.35 76.9,123.31 65.85,123.31 61.65,127.52 61.65,133.76 59.25,136.17 59.25,137.16 58.36,138.05 53.66,138.05 51.22,140.49 45,140.49 43.62,141.86 43.62,142.36 42.1,143.89 40.63,143.89 38.6,145.92 34.99,145.92 34.48,145.41 33.34,145.41 32.32,146.43 v1(29.27,146.43)
  SIG9 w0.155: v1(166.31,72.13) 165.42,71.24 165.42,67.7 164.53,66.81 164.53,65.68 164.12,65.27 164.12,64.99 164.5,64.61 164.5,62.64 164.92,62.23 164.92,61.62 165.5,61.04 YJ28.C9
  SIG10 w0.155: v1(166.31,72.13) 166.12,72.32 166.12,78.32 166.92,79.12 166.92,83.23 165.95,84.2 164.77,84.2 164.27,83.7 161.21,83.7 159.97,84.94 158.41,84.94 155.66,82.18 145.33,82.18 144.34,83.18 144.34,85.48 142.44,87.38 140.92,87.38 139.77,88.52 139.77,93.6 138.85,94.52 138.85,95.46 110.87,123.44 v1(85.41,123.44)
  BOTTOM w0.13: v1(85.41,123.44) v2(85.41,124.2)
RESETL46: length 280.1
  TOP w0.13: R3253.2 v1(37.4,168.15)
  SIG9 w0.155: YJ28.B9 184.5,53.03 183.92,53.61 183.92,56.61 184.26,56.95 184.26,57.27 183.91,57.62 183.9,57.62 183.88,57.65 183.88,60.57 184.26,60.95 184.26,61.27 183.92,61.61 183.92,64.61 184.26,64.95 184.26,65.27 183.92,65.61 183.92,66.05 184.21,66.35 184.21,72.76 182.37,74.6 182.37,76.27 181.93,76.71 181.93,82.42 181.29,83.06 v1(179.77,83.06)
  SIG10 w0.155: v1(179.77,83.06) 180.02,83.31 180.02,84.07 179.26,84.83 178.24,84.83 176.27,86.81 176.27,88.12 173.1,91.3 171.43,91.3 168.62,94.1 161.5,94.1 160.15,95.46 158.29,95.46 154.53,99.21 151.42,99.21 148.02,102.61 145.62,102.61 142.62,105.62 137.69,105.62 115.09,128.23 115.09,189.75 107.47,197.36 86.56,197.36 85.92,196.72 80.59,196.72 79.95,197.36 74.37,197.36 73.89,196.88 65.85,196.88 65.19,196.22 62.99,196.22 59.68,192.91 58.43,192.91 50.68,185.16 49.39,185.16 41.06,176.83 41.06,171.8 v1(37.4,168.15)
  BOTTOM w0.13: v2(36.64,168.27) 36.77,168.15 v1(37.4,168.15) ; R2736.1 v1(179.77,83.06)
RESETL47: length 269.4
  TOP w0.13: R2734.2 v1(179.77,77.21) ; R3261.2 v1(37.4,165.86)
  SIG8 w0.155: v1(179.77,77.21) 180.28,76.71 180.28,74.93 183.53,71.68 183.53,65.67 183.14,65.28 183.14,64.96 183.5,64.6 183.5,62.64 183.92,62.23 183.92,61.62 184.26,61.28 184.26,60.66 YJ28.A9
  SIG10 w0.155: v1(179.77,77.21) 178.12,78.86 178.12,82.93 177.61,83.44 177.25,83.44 174.82,85.87 174.82,87.78 172.81,89.79 171.01,89.79 168.08,92.71 161.09,92.71 159.62,94.18 157.59,94.18 153.93,97.85 150.98,97.85 147.49,101.34 145.09,101.34 142.09,104.34 137.17,104.34 112.67,128.84 112.67,190.34 106.92,196.09 102.54,196.09 101.91,195.45 92.66,195.45 92.02,196.09 90.1,196.09 89.33,195.33 79.32,195.33 78.56,196.09 77.02,196.09 76.54,195.61 66.38,195.61 65.72,194.95 63.52,194.95 52.38,183.81 49.84,183.81 42.33,176.31 v1(42.33,172.08) 42.33,169.5 39.36,166.52 38.06,166.52 v1(37.4,165.86)
RESETL48: length 336.6
  TOP w0.13: v1(414.46,171.83) R3433.1
  SIG8 w0.155: 212.2,53.33 211.92,53.61 211.92,56.62 212.26,56.96 212.26,57.27 211.88,57.66 211.88,60.58 212.26,60.96 212.26,61.28 211.92,61.62 211.92,64.62 212.26,64.96 212.26,65.27 211.92,65.61 211.92,66.05 212.5,66.64 212.5,67.34 215.71,70.55 215.71,80.77 v1(216.22,81.28) ; 212.2,53.33 212.5,53.03 212.5,53.03 ; 212.2,53.33 212.2,53.32 212.5,53.03 ; 212.5,53.03 YJ30.D9
  SIG10 w0.155: v1(414.46,171.83) 416.42,171.83 423.47,164.78 423.47,136.06 418.96,131.55 416.03,131.55 414.2,129.71 414.2,103.77 410.77,100.34 406.6,100.34 388.81,82.55 388.81,80.64 388.18,80.01 386.74,80.01 386.02,79.29 386.02,76.03 379.83,69.85 370.52,69.85 369.9,69.22 228.13,69.22 219.5,77.85 217.61,77.85 216.98,78.48 216.98,80.52 v1(216.22,81.28)
  BOTTOM w0.13: v1(216.22,81.28) 216.7,81.76 216.7,83.23 R2778.1 ; v1(414.46,171.83) v2(415.23,171.83)
RESETL49: length 321.5
  TOP w0.13: v1(414.59,174.88) R3394.2 ; R2777.2 v1(216.22,77.21)
  SIG9 w0.155: YJ30.C9 212.5,61.03 212.2,61.33 212.2,61.33 211.92,61.61 211.92,62.23 211.5,62.64 211.5,64.61 211.12,64.99 211.12,65.27 211.53,65.68 211.53,66.81 215.68,70.97 215.68,76.68 v1(216.22,77.21)
  SIG10 w0.155: v1(414.59,174.88) 414.59,174.57 424.11,165.05 424.11,135.79 419.22,130.9 416.3,130.9 414.85,129.45 414.85,103.5 411.04,99.69 408.24,99.69 401.64,93.09 400.28,93.09 389.54,82.35 389.54,78.63 379.5,68.59 224.85,68.59 v1(216.22,77.21)
  BOTTOM w0.13: v1(414.59,174.88) v2(414.59,174.11)
RESETL50: length 323.6
  SIG9 w0.155: YJ30.B9 231.5,53.03 230.92,53.61 230.92,56.63 231.26,56.97 231.26,57.27 230.91,57.62 230.9,57.62 230.88,57.65 230.88,60.57 231.26,60.95 231.26,61.27 230.92,61.61 230.92,64.61 231.26,64.95 231.26,65.27 230.92,65.61 230.92,66.05 231.5,66.64 231.5,71.46 230.19,72.77 230.19,79.75 v1(229.55,80.39)
  SIG10 w0.155: v1(229.55,80.39) 230.06,80.9 232.47,80.9 235.22,78.15 239,78.15 239.73,78.88 248.36,78.88 251.65,82.16 251.65,83.13 252.57,84.05 253.91,84.05 255.33,85.47 255.33,86.5 256.47,87.64 256.47,93.84 257.85,95.21 257.85,100.99 270.45,113.59 270.45,168.15 271.08,168.78 271.08,172.94 286.35,188.21 286.35,198.87 284.44,200.78 284.44,212.14 285.99,213.69 287.34,213.69 287.62,213.41 305.9,213.41 306.65,212.66 309.29,212.66 309.6,212.97 318.74,212.97 330.36,201.35 358.09,201.35 367.7,191.74 373.9,191.74 375.03,190.6 387.18,190.6 v1(389.57,188.21)
  BOTTOM w0.13: R2774.1 230.01,83.26 230.01,80.85 v1(229.55,80.39) ; R3430.2 390.36,187.89 390.04,188.21 v1(389.57,188.21) v2(389.57,189.1)
RESETL51: length 256.2
  TOP w0.13: v1(389.08,176.09) 389.08,176.54 390.36,177.82 R3419.2 ; R2773.2 v1(229.55,77.21)
  SIG8 w0.155: v1(229.55,77.21) 229,76.66 229,74.34 230.28,73.06 230.28,66.26 230.53,66.01 230.53,65.66 230.12,65.25 230.12,64.99 230.5,64.61 230.5,62.64 230.92,62.23 230.92,61.61 231.26,61.27 231.26,60.66 YJ30.A9
  SIG10 w0.155: v1(229.55,77.21) 230.06,76.71 231.71,76.71 233.73,74.69 250.79,74.69 251.52,73.96 276.1,73.96 278.96,76.81 278.96,86.23 279.59,86.86 284.1,86.86 287.66,90.42 291.27,90.42 313.58,112.73 351.12,112.73 362.13,123.74 362.13,134.9 363.63,136.4 363.63,143.7 365.18,145.25 365.18,153.9 368.86,157.59 368.86,167.38 370.01,168.53 370.01,168.8 372.35,171.13 372.35,171.6 372.74,171.99 373.66,171.99 374.83,170.82 377.92,170.82 378.7,171.6 381.33,171.6 382.46,172.72 384.32,172.72 385.15,173.56 386.69,173.56 389.08,175.95 v1(389.08,176.09)
  BOTTOM w0.13: v1(389.08,176.09) 389.06,176.11 v2(389.06,177.04)
RESETL52: length 262
  TOP w0.13: R2815.1 v1(260.41,87.12)
  SIG8 w0.155: v1(260.41,87.12) 260.9,86.64 260.9,74.52 260.16,73.78 260.16,67.3 258.92,66.05 258.92,65.61 259.26,65.27 259.26,64.97 258.92,64.63 258.92,61.61 259.26,61.27 259.26,60.97 258.88,60.59 258.88,57.65 259.26,57.27 259.26,56.97 258.92,56.63 258.92,53.61 259.5,53.03 YJ32.D9
  SIG10 w0.155: v1(260.41,87.12) 260.92,86.61 260.92,86.22 261.42,85.72 262.32,85.72 263.94,87.34 263.94,100.68 275.28,112.02 275.28,171.61 291.47,187.81 307.63,187.81 309.69,189.87 321.89,189.87 322.39,190.37 327.03,190.37 331.63,194.97 348.41,194.97 357.99,185.39 361.66,185.39 362.12,185.85 385.96,185.85 v1(387.29,184.53)
  BOTTOM w0.13: v1(387.29,184.53) 387.29,185.04 v2(388.56,186.31) R3436.2
RESETL53: length 232.3
  TOP w0.13: R2813.2 260.41,77.59 259.78,76.96 v1(259.4,76.96)
  SIG9 w0.155: YJ32.C9 259.5,61.03 258.92,61.61 258.92,62.23 258.5,62.64 258.5,64.61 258.12,64.99 258.12,65.27 258.53,65.68 258.53,66.81 258.92,67.2 258.92,76.48 v1(259.4,76.96)
  SIG10 w0.155: v1(385.37,182.24) 384.74,182.87 367.34,182.87 365.32,180.85 365.32,178.56 364.81,178.05 364.17,178.05 361.27,175.14 357.53,175.14 354.06,171.68 354.06,164.93 353.12,164 353.12,156.56 352.98,156.41 352.98,147.12 350.5,144.64 350.5,143.24 351.12,142.62 351.12,141.6 350.34,140.83 350.34,133.33 350.96,132.71 350.96,132.04 342.95,124.03 290.86,124.03 267.4,100.57 267.4,78.12 265.74,76.45 259.91,76.45 v1(259.4,76.96)
  BOTTOM w0.13: R3435.1 388.68,183.77 388.05,183.13 v2(386.91,183.13) 386.26,183.13 v1(385.37,182.24)
RESETL54: length 227.8
  SIG9 w0.155: v1(273.75,80.39) 274.23,79.91 274.23,73.82 278.5,69.55 278.5,66.64 277.92,66.05 277.92,65.61 278.26,65.27 278.26,64.95 277.92,64.61 277.92,61.61 278.26,61.27 278.26,60.95 277.88,60.57 277.88,57.65 278.26,57.27 278.26,56.95 277.92,56.61 277.92,53.62 278.5,53.04 YJ32.B9
  SIG10 w0.155: v1(273.75,80.39) 273.24,80.9 273.24,99.02 279.61,105.39 281.5,105.39 295.49,119.38 349.99,119.38 357.08,126.48 357.08,137.59 356.39,138.29 356.39,140.17 357.82,141.6 357.82,145.76 359.28,147.22 359.28,151.61 360.11,152.44 360.11,155.79 361.53,157.21 361.53,164.1 363.72,166.3 363.72,170.99 371.43,178.7 378.68,178.7 379.17,179.2 386.4,179.2 v1(387.16,179.96)
  BOTTOM w0.13: R2816.1 274.38,83.33 274.38,81.02 v1(273.75,80.39) ; v1(387.16,179.96) 387.79,180.59 388.56,180.59 v2(388.94,180.97) 389.19,181.23 R3413.2
RESETL55: length 211.9
  TOP w0.13: v1(387.22,176.09) 389.57,178.44 389.57,180.59 390.36,181.38 R3416.2 ; R2814.2 v1(273.75,77.21)
  SIG8 w0.155: YJ32.A9 278.5,61.03 277.92,61.61 277.92,62.23 277.5,62.64 277.5,64.61 277.12,64.99 277.12,65.25 277.53,65.66 277.53,69.1 273.24,73.39 273.24,76.71 v1(273.75,77.21)
  SIG10 w0.155: v1(387.22,176.09) 387.22,175.89 386.16,174.83 384.57,174.83 384.28,174.54 381.8,174.54 381.02,173.77 376.07,173.77 375.83,174 375.26,174 374.88,173.61 374.36,173.61 373.74,174.23 372.35,174.23 370.18,172.06 370.18,170.98 369.12,169.92 368.5,169.92 367.6,169.02 367.6,168.65 366.89,167.94 366.89,158.8 366.46,158.37 366.46,156.99 363.82,154.35 363.82,145.7 362.35,144.23 362.35,136.92 360.77,135.34 360.77,124.18 351.02,114.42 312.1,114.42 300.55,102.87 300.55,101.98 291.02,92.45 284.16,92.45 279.84,88.14 279.06,88.14 277.68,86.76 277.68,79.37 276.16,77.85 274.38,77.85 v1(273.75,77.21)
  BOTTOM w0.13: v2(387.29,177.04) 387.29,176.16 v1(387.22,176.09)
RESETL56: length 181.2
  TOP w0.13: v1(394.53,168.91) 395.29,168.15 396.81,168.15 397.32,168.65 R3415.2 ; R2855.1 v1(309.05,77.21)
  SIG8 w0.155: v1(309.05,77.21) 308.55,76.71 308.55,75.18 306.21,72.84 306.21,66.34 305.92,66.05 305.92,65.61 306.26,65.27 306.26,64.97 305.92,64.63 305.92,61.61 306.26,61.27 306.26,60.97 305.88,60.59 305.88,57.65 306.26,57.27 306.26,56.97 305.92,56.63 305.92,53.61 306.2,53.33 306.2,53.32 306.5,53.03 YJ34.D9
  SIG10 w0.155: v1(309.05,77.21) 309.74,77.9 309.74,93.52 321.32,105.1 350.91,105.1 364.42,118.62 366.09,118.62 367.35,119.88 367.35,132.53 369.09,134.27 369.09,141.83 371.12,143.86 371.12,147.44 371.87,148.19 371.87,151.47 372.92,152.52 373.37,152.52 377.68,156.84 377.68,158.54 378.58,159.44 380.02,159.44 381.36,160.78 383.87,160.78 388.64,165.55 390.31,165.55 393.01,168.25 393.63,168.25 394.29,168.91 v1(394.53,168.91)
RESETL57: length 183.5
  TOP w0.13: R3428.2 399.76,169.19 396.43,165.86 395.29,165.86 v1(394.4,164.97) ; R2853.2 v1(311.34,80.64)
  SIG9 w0.155: v1(311.34,80.64) 310.83,80.13 310.83,79.12 310.45,78.74 309.44,78.74 308.55,77.85 308.55,75.05 305.53,72.04 305.53,65.68 305.12,65.27 305.12,64.99 305.5,64.61 305.5,62.64 305.92,62.23 305.92,61.61 306.5,61.03 YJ34.C9
  SIG10 w0.155: v1(311.34,80.64) 312.61,81.91 313.88,81.91 315.02,83.06 315.02,93.52 323.12,101.62 370.08,101.62 371.23,102.77 371.23,129.76 372.11,130.64 372.11,135.95 372.84,136.68 372.84,141.31 375.19,143.67 375.19,150.06 379.06,153.92 381.82,153.92 382.97,155.07 385.12,155.07 394.4,164.35 v1(394.4,164.97)
  BOTTOM w0.13: v1(311.34,80.64) 310.58,81.4 v2(310.58,82.17)
RESETL58: length 192.7
  SIG9 w0.155: v1(325.18,81.28) 324.68,80.77 324.68,73.4 325.5,72.58 325.5,66.64 324.92,66.05 324.92,65.61 325.26,65.27 325.26,64.95 324.92,64.61 324.92,61.62 325.26,61.28 325.26,60.95 324.88,60.57 324.88,57.65 324.9,57.62 324.91,57.62 325.26,57.27 325.26,56.95 324.92,56.61 324.92,53.62 325.5,53.04 YJ34.B9
  SIG10 w0.155: v1(325.18,81.28) 325.18,81.4 326.01,82.23 326.01,85.02 327.34,86.36 327.34,89.93 331.08,93.66 343.67,93.66 343.86,93.47 345.76,93.47 346.76,94.47 356.61,94.47 363.82,87.25 368.4,87.25 368.94,87.79 373.05,87.79 378.11,92.85 378.11,106.82 377.32,107.61 377.32,110.56 377.94,111.19 377.94,115.03 377.15,115.82 377.15,125.68 378.9,127.44 378.9,130.9 379.63,131.62 379.63,133.48 379.27,133.85 379.27,139.38 382.57,142.69 382.57,146.71 384.53,148.67 387.32,148.67 403.21,164.56 403.21,166.95 v1(403.03,167.13)
  BOTTOM w0.13: v1(403.03,167.13) 402.78,167.13 v2(402.15,167.76) 401.76,168.15 401.76,168.91 401.49,169.19 R3426.2 ; R2856.1 325.54,83.72 325.69,83.56 325.69,81.79 v1(325.18,81.28)
RESETL59: length 177
  TOP w0.13: v1(405.29,167.64) 404.3,167.64 402.76,169.19 R3421.1 ; R2854.2 v1(325.18,77.21)
  SIG8 w0.155: YJ34.A9 325.5,61.03 324.92,61.61 324.92,62.23 324.5,62.64 324.5,64.61 324.12,64.99 324.12,65.27 324.42,65.57 324.42,66.55 325.67,67.79 325.67,76.73 v1(325.18,77.21)
  SIG10 w0.155: v1(325.18,77.21) 325.82,77.85 327.47,77.85 330.06,80.44 330.06,82.65 330.97,83.56 332.42,83.56 334.07,85.21 343.45,85.21 345.22,86.99 359.63,86.99 361.57,85.05 368.64,85.05 369.18,84.51 370.32,84.51 370.64,84.83 373.74,84.83 374.36,85.45 374.36,85.95 380.54,92.13 380.54,99.03 380.89,99.37 380.89,109.04 380.39,109.53 380.39,119.21 381.06,119.88 381.06,125.16 382.55,126.64 382.55,139.55 384.54,141.54 386.08,141.54 386.6,142.06 386.6,144.65 392.17,150.22 394.04,150.22 396.56,152.74 396.56,153.67 402.19,159.3 402.55,159.3 405.42,162.18 405.42,167.51 v1(405.29,167.64)
  BOTTOM w0.13: v2(406.08,167.26) 405.68,167.26 v1(405.29,167.64)
RESETL60: length 177
  TOP w0.13: R2895.1 358.84,75.05 354.9,71.12 v1(354.14,71.12) ; R3427.1 v1(409.82,169.19)
  SIG8 w0.155: v1(354.14,71.12) 353.5,70.48 353.5,69.97 353.38,69.85 353.38,66.52 352.92,66.05 352.92,65.61 353.26,65.27 353.26,64.97 352.92,64.63 352.92,61.61 353.26,61.27 353.26,60.97 352.88,60.59 352.88,57.65 353.26,57.27 353.26,56.97 352.92,56.63 352.92,53.61 353.2,53.33 353.2,53.32 353.5,53.03 YJ36.D9
  SIG10 w0.155: v1(354.14,71.12) 356.29,71.12 356.43,71.25 364.72,71.25 367.77,74.29 373.72,74.29 374.33,73.68 381.02,73.68 384.36,77.01 384.36,81.57 385.84,83.05 385.84,84.67 387.15,85.98 389.78,85.98 406.55,102.74 409.38,102.74 412.32,105.68 412.32,115.22 411.42,116.13 411.42,131.98 410.1,133.29 410.1,141.49 410.86,142.25 410.87,142.25 412.32,143.7 412.32,168.04 410.93,169.43 410.07,169.43 v1(409.82,169.19)
  BOTTOM w0.13: v2(409,169.16) 409.8,169.16 v1(409.82,169.19)
RESETL61: length 176.9
  TOP w0.13: v1(409.85,167.38) 407.23,167.38 405.42,169.19 R3425.1
  SIG9 w0.155: v1(350.76,71.42) 350.76,67.89 352.53,66.12 352.53,65.68 352.12,65.27 352.12,64.99 352.5,64.61 352.5,62.64 352.92,62.23 352.92,61.61 353.5,61.03 YJ36.C9
  SIG10 w0.155: v1(409.85,167.38) 410.97,166.26 410.97,144.16 408.8,141.99 408.8,131.19 409.13,130.86 409.13,129.87 408.8,129.54 408.8,115.78 409.84,114.73 410.46,114.73 410.77,114.42 410.77,106.21 410.46,105.9 407.26,105.9 399.65,98.3 397.7,98.3 389.83,90.42 389.83,88.9 388.21,87.28 386.65,87.28 383.66,84.29 383.66,83.44 383.01,82.79 382.57,82.79 382.38,82.6 382.38,81.92 382.73,81.58 382.73,79.25 380.48,77.01 379.4,77.01 378.7,76.31 377.77,76.31 377.2,76.88 376.43,76.88 375.99,76.44 375.99,76.08 375.76,75.84 375.14,75.84 374.53,76.45 368.12,76.45 366.47,74.8 362.9,74.8 361.76,75.94 354.87,75.94 352.84,73.91 351.6,73.91 351.35,73.66 351.35,72.01 v1(350.76,71.42)
  BOTTOM w0.13: v1(350.76,71.42) 351.08,71.74 351.25,71.74 351.35,71.83 351.35,72.26 351.54,72.45 355.35,72.45 358.84,75.94 v2(358.84,76.58) R2894.2
RESETL62: length 167.6
  SIG8 w0.155: v1(376.47,76.2) 376.47,76.43 376.54,76.5 379.86,76.5 381.33,77.97 383.37,77.97 385.41,80.01 387.41,80.01 390.59,83.18 390.59,90.17 406.84,106.43 406.84,107.06 407.73,107.94 407.73,142.01 416.12,150.4 416.12,185.16 v1(415.61,185.67)
  SIG9 w0.155: YJ36.B9 372.5,53.04 371.92,53.62 371.92,54.48 372.81,55.37 379.16,55.37 380.17,56.39 380.17,72.97 376.95,76.2 v1(376.47,76.2)
  BOTTOM w0.13: v1(376.47,76.2) 375.6,77.06 R2896.1 ; R3362.1 414.46,185.04 415.1,185.67 v1(415.61,185.67)
RESETL63: length 158.2
  TOP w0.13: v1(414.34,185.54) 413.83,185.04 R3356.1 ; v1(368.36,76.96) 369,77.59 R2891.2
  SIG8 w0.155: v1(368.36,76.96) 368.88,76.96 370.78,78.86 378.02,78.86 379.16,80.01 382.21,80.01 384.87,82.67 384.87,84.83 388.43,88.39 388.43,90.93 398.37,100.87 398.37,102.01 405.81,109.46 405.81,142.8 408.91,145.9 408.91,169.43 411.08,171.6 411.08,171.88 412.17,172.97 412.17,183.38 v1(414.34,185.54)
  SIG9 w0.155: YJ36.A9 372.5,61.03 371.92,61.61 371.92,64.61 372.26,64.95 372.26,65.27 371.92,65.61 371.92,66.05 373.32,67.45 373.32,74.17 370.52,76.96 v1(368.36,76.96)
  BOTTOM w0.13: v1(368.36,76.96) 367.86,76.45 v2(367.86,75.94)
RS232_UART0_SIN: length 82.6
  TOP w0.508: R2032.2 v1(399.68,75.31)
  SIG1 w0.508: v1(399.68,75.31) 396.81,72.44 396.81,66.29 394.78,64.26 394.78,59.05 393.89,58.16 393.89,39.75 392.49,38.35 392.49,27.81 398.53,21.77 398.53,15.8 401.89,12.44 404.05,12.44 404.81,11.68 409.89,11.68 411.21,13 RJ1.A6
  BOTTOM w0.13: v1(399.68,75.31) v2(399.68,76.07)
RS232_UART0_SOUT: length 117.6
  TOP w0.508: R2029.2 v1(419.6,75.31)
  SIG1 w0.508: v1(419.6,75.31) 401.89,75.31 400.75,76.45 398.72,76.45 395.41,73.15 395.41,66.8 392.62,64.01 392.62,40.13 391.73,39.24 391.73,37.34 391.76,37.31 391.76,28.01 388.93,25.18 388.93,20.22 387.92,19.22 387.92,9.27 390.21,6.98 404.62,6.98 RJ1.A3
  BOTTOM w0.13: v1(419.6,75.31) v2(419.6,76.07)
RST#_9548_0: length 513.3
  TOP w0.13: v1(8.32,98.68) 8.8,99.16 10.88,99.16 11.14,98.91 R252.2 11.33,98.63 12.76,97.19 U12.3 ; R3353.1 v1(395.8,193.42)
  SIG3 w0.155: v1(8.32,98.68) 7.87,98.68 2.98,103.56 2.98,165.41 9.79,172.22 9.79,174.54 12.03,176.78 24.96,176.78 26.23,178.05 29.02,178.05 29.91,178.94 46.45,178.94 v1(46.97,178.41)
  SIG6 w0.155: v1(395.8,193.42) 395.28,193.94 395.28,195.46 394.92,195.82 392.1,195.82 384.23,187.94 374.17,187.94 373.16,188.95 368.16,188.95 367.85,189.26 367.85,190.25 356.3,201.8 325.85,201.8 324.78,200.73 324.78,197.16 321.53,193.91 294.21,193.91 293.05,195.07 291.02,195.07 285.52,200.57 251.03,200.57 250.48,201.12 196.1,201.12 194.5,202.71 152.24,202.71 151.06,201.54 115.35,201.54 114.73,200.93 106.1,200.93 105.48,201.54 94.3,201.54 93.97,201.21 85.27,201.21 84.94,201.54 73.16,201.54 71.01,199.39 68.91,199.39 68.53,199.77 63.06,199.77 62.04,198.75 61.37,198.75 56.58,193.97 56.58,193.18 55.17,191.77 54.14,191.77 47.28,184.91 47.28,178.72 v1(46.97,178.41)
  BOTTOM w0.13: v1(46.97,178.41) v2(46.97,179.19)
RST#_9548_1: length 473.4
  TOP w0.13: v1(40.83,106.68) 41.34,106.68 43.73,104.29 45.63,104.29 45.81,104.11 R205.2 46.22,103.71 46.42,103.5 46.42,103.12 47.27,102.27 U11.3
  SIG3 w0.155: v1(47.31,161.54) 46.04,160.27 46.04,139.44 48.06,137.42 48.06,129.97 50.74,127.29 50.74,111.38 47.18,107.82 41.97,107.82 v1(40.83,106.68)
  SIG6 w0.155: v1(47.31,161.54) 47.56,161.8 47.56,172.21 48.07,172.72 48.07,177.29 48.21,177.43 48.21,184.94 53.96,190.69 54.99,190.69 57.34,193.04 57.34,193.83 60.75,197.23 61.51,197.23 63.41,199.13 68.26,199.13 68.64,198.75 71.27,198.75 73.43,200.91 84.65,200.91 84.98,200.58 94.35,200.58 94.68,200.91 105.22,200.91 105.83,200.29 115,200.29 115.61,200.91 154.48,200.91 154.86,201.29 156.27,201.29 157.04,202.05 193.23,202.05 194.8,200.48 250.18,200.48 251.27,199.39 284.13,199.39 290.38,193.13 322.05,193.13 329.16,200.25 329.6,200.25 330.49,201.14 355.57,201.14 366.3,190.41 366.3,189.26 367.36,188.2 371.84,188.2 372.76,187.28 384.47,187.28 392.36,195.17 394.55,195.17 v1(394.58,195.2)
  BOTTOM w0.13: R3360.1 394.17,192.5 393.87,192.81 v2(393.87,193.85) 393.87,194.49 v1(394.58,195.2)
RST#_9548_2: length 105.1
  TOP w0.13: v1(409.31,126.79) 409.82,126.29 411.7,126.29 411.82,126.41 R183.2 412.21,126.82 413.64,125.39 U10.3 ; R3366.1 v1(397.07,193.42)
  SIG8 w0.155: v1(397.07,193.42) 398.21,192.27 403.16,192.27 403.92,193.04 403.92,193.42 404.43,193.93 411.04,193.93 417.86,187.11 417.86,149.12 410.78,142.05 410.78,136.15 416.75,130.18 416.75,128.75 415.89,127.88 411.14,127.88 410.63,127.38 409.89,127.38 v1(409.31,126.79)
  BOTTOM w0.13: v2(397.7,193.93) 397.19,193.42 v1(397.07,193.42)
RST#_9548_3: length 114.8
  TOP w0.13: R3354.1 397.83,193.01 397.83,193.93 v1(398.34,194.43)
  SIG8 w0.155: v1(425.13,114.22) 427.55,116.63 427.55,142.47 419.77,150.24 419.77,188.53 411.46,196.85 402.15,196.85 400.24,194.94 398.84,194.94 v1(398.34,194.43)
  BOTTOM w0.13: v1(425.13,114.22) 424.62,113.71 422.75,113.71 422.62,113.84 R285.2 422.16,114.25 421.96,114.04 421.96,113.66 421.11,112.81 U13.3 ; v1(398.34,194.43) 399,195.09 v2(399,195.83)
RST#_9548_4: length 468.9
  TOP w0.13: v1(392.87,193.16) 393.26,192.78 R3367.1
  SIG6 w0.155: v1(392.87,193.16) 385.72,186.01 366.3,186.01 363.82,188.49 363.82,190.35 361.2,192.98 355.61,192.98 348.95,199.64 331.15,199.64 330.49,198.98 329.69,198.98 322.15,191.43 290.23,191.43 285.32,196.34 279.84,196.34 279.09,197.1 251.27,197.1 249.95,198.42 207.45,198.42 206.95,198.93 193.31,198.93 191.71,200.53 158.43,200.53 156.92,199.02 95.44,199.02 95.17,198.75 84.02,198.75 83.76,199.02 73.34,199.02 71.68,197.36 63.68,197.36 55.04,188.72 54.9,188.72 50.07,183.89 50.07,176.87 49.85,176.64 49.85,169.15 49.06,168.36 49.06,161.52 v1(47.31,159.76)
  SIG9 w0.155: v1(25.34,99.95) 26.61,101.22 26.61,105.66 30.54,109.6 30.54,134.74 32.58,136.78 32.58,139.32 46.16,152.91 46.16,158.62 v1(47.31,159.76)
  BOTTOM w0.13: v1(25.34,99.95) 24.96,99.57 v2(24.57,99.57) 24.32,99.57 23.94,99.18 22.19,99.18 22.06,99.06 R353.2 21.73,98.63 20.3,97.19 U16.3
RST#_9548_5: length 466.3
  TOP w0.13: R3368.1 v1(394.53,193.42)
  SIG3 w0.155: v1(55.18,122.17) 54.29,123.06 54.29,125.09 48.7,130.68 48.7,146.56 47.69,147.57 47.69,152.02 48.96,153.29 48.96,157.1 47.82,158.24 47.82,163.32 v1(48.32,163.83)
  SIG6 w0.155: v1(394.53,193.42) 393.42,194.53 392.67,194.53 384.79,186.65 372.5,186.65 371.59,187.56 366.3,187.56 365.22,188.64 365.22,189.86 362.08,192.99 362.08,193.73 355.41,200.4 330.9,200.4 330.11,199.61 329.43,199.61 322.02,192.2 290.36,192.2 284.7,197.86 251.67,197.86 249.97,199.56 194.5,199.56 192.77,201.29 157.29,201.29 155.65,199.66 94.95,199.66 94.81,199.51 84.28,199.51 84.14,199.66 73.08,199.66 71.41,197.99 63.17,197.99 61.77,196.59 61.01,196.59 58.1,193.69 58.1,192.9 54.56,189.36 54.56,189.28 48.99,183.7 48.99,176.68 48.83,176.53 48.83,169.03 48.32,168.53 v1(48.32,163.83)
  BOTTOM w0.13: U15.3 55.22,102.27 56.2,103.25 56.2,103.5 56.4,103.71 R352.2 56.73,103.25 56.86,103.12 58.05,103.12 58.07,103.15 59.52,103.15 60.52,104.14 60.52,115.82 v2(58.1,118.23) 55.18,121.16 v1(55.18,122.17)
RST#_9548_6: length 100.8
  SIG8 w0.155: v1(395.8,194.43) 396.3,193.93 400.13,193.93 401.91,195.71 411.69,195.71 419.13,188.27 419.13,149.98 423.42,145.69 423.42,127.82 423.86,127.38 424.55,127.38 v1(425.13,126.79)
  BOTTOM w0.13: v1(425.13,126.79) 424.62,126.29 422.75,126.29 422.62,126.41 R429.2 422.16,126.82 421.96,126.62 421.96,126.24 421.11,125.39 U17.3 ; v1(395.8,194.43) 395.72,194.43 v2(395.16,193.88) 395.16,192.78 395.44,192.5 R3372.1
RST#_9548_7: length 114.4
  TOP w0.13: v1(409.31,114.22) 409.82,113.71 411.7,113.71 411.82,113.84 R440.2 412.21,114.25 413.64,112.81 U18.3
  SIG8 w0.155: v1(409.31,114.22) 409.89,114.81 410.4,114.81 411.08,115.49 411.08,123.57 414.75,127.23 416.14,127.23 422.72,133.82 422.72,145.49 418.49,149.72 418.49,187.49 411.41,194.56 406.59,194.56 406.08,195.07 403.03,195.07 401.51,193.55 401.51,193.16 401.26,192.91 398.84,192.91 v1(398.34,193.42)
  BOTTOM w0.13: v1(409.31,114.22) v2(409.31,115.06) ; R3375.1 v1(398.34,193.42)
SECOND_CPLD_CLK_N: length 143.7
  TOP w0.107: U124.A8 v1(401.22,186.45)
  SIG9 w0.14: v1(401.22,186.45) 400.48,186.45 398.21,188.72 398.21,189.86 395.92,192.15 395.03,192.15 393.97,193.22 393.97,195.56 382.9,206.63 366.75,206.63 361.8,201.67 289.33,201.67 287.92,203.08 287.92,208.41 287,209.33 285.98,209.33 285.81,209.5 v1(285.81,209.73)
  BOTTOM w0.107: R3400.2 401.26,191.54 401.35,191.45 401.35,189.94 401.69,189.6 401.69,186.15 401.59,186.05 401.31,186.05 401.22,186.14 v1(401.22,186.45) ; v1(285.81,209.73) 286.18,209.36 286.92,209.36 287.06,209.5 C3446.2
SECOND_CPLD_CLK_P: length 143.7
  TOP w0.107: U124.C8 v1(401.22,185.65)
  SIG9 w0.14: v1(285.81,208.81) 286,209 286.87,209 287.59,208.28 287.59,202.94 289.19,201.34 361.94,201.34 366.89,206.3 382.77,206.3 393.64,195.43 393.64,193.08 394.9,191.82 395.79,191.82 397.88,189.73 397.88,188.58 400.35,186.12 400.75,186.12 v1(401.22,185.65)
  BOTTOM w0.107: v1(401.22,185.65) 401.3,185.72 401.72,185.72 402.02,186.02 402.02,189.74 401.68,190.08 401.68,190.66 402.15,191.13 R3399.1 ; C3447.2 287.06,208.84 286.87,209.03 286.03,209.03 v1(285.81,208.81)
SECOND_CPLD_INT#: length 435.2
  TOP w0.13: U123.C13 v1(28.85,163.8)
  SIG6 w0.155: v1(46.16,173.48) 45.4,173.48 44.83,174.05 44.83,185.72 45.73,186.62 45.73,188.28 60.9,203.46 69.79,203.46 70.28,203.95 117.42,203.95 117.92,203.46 149.9,203.46 152.44,205.99 198.31,205.99 201.27,203.03 213.31,203.03 214.31,204.04 241.01,204.04 245.76,208.79 259.52,208.79 260.03,208.28 280.27,208.28 282.38,210.39 282.38,211.53 285.85,214.99 308.98,214.99 309.31,215.32 317.82,215.32 329.39,203.74 357.89,203.74 370.11,191.52 374.14,191.52 375.57,190.09 383,190.09 388.56,195.65 388.56,196.24 390.61,198.29 402.1,198.29 v1(405.96,194.43)
  BOTTOM w0.13: v1(28.85,163.8) 29.15,164.1 29.15,164.6 29.91,165.35 29.91,167.7 30.99,168.78 32.83,168.78 33.08,169.03 R3325.2 33.49,169.69 33.85,170.05 33.85,172.21 35.12,173.48 v2(36.26,173.48) v1(46.16,173.48) ; v1(405.96,194.43) 405.19,193.67 405.19,192.66 405.04,192.5 R3363.2
SECOND_CPLD_JTAG_TCK: length 408
  TOP w0.13: U124.A7 400.82,187.07 400.7,187.19 400.7,187.88 400.55,188.03 400.55,189.05 v1(400.98,189.48) 400.98,190.78 400.88,190.88 R3391.2
  SIG8 w0.155: v1(400.98,189.48) 400.98,189.97 399.31,191.64 397.83,191.64 397.57,191.89 383.04,191.89 381.67,193.27 369.52,193.27 361.63,201.16 335.14,201.16 315.74,220.56 122.16,220.56 117.28,215.68 117.28,213.4 110.51,206.63 54.28,206.63 43.83,196.18 34.52,196.18 31.05,192.71 26.81,192.71 v1(26.23,193.29)
  BOTTOM w0.13: v1(400.98,189.48) 400.98,189.63 v2(400.37,190.24) ; R3211.2 v1(26.23,193.29)
SECOND_CPLD_JTAG_TDO: length 442
  TOP w0.13: J34.3 27.88,194.31 v1(27.5,194.69)
  SIG4 w0.155: v1(16.45,193.16) 17.34,192.28 20.76,192.28 23.69,195.2 26.99,195.2 v1(27.5,194.69)
  SIG8 w0.155: v1(16.7,186.94) 16.7,189.1 19.88,192.28 21.02,192.28 27.16,198.41 45.17,198.41 54.02,207.26 110.24,207.26 116.64,213.66 116.64,215.94 121.9,221.2 316,221.2 335.22,201.98 361.8,201.98 369.87,193.91 382.26,193.91 383.35,192.82 390.94,192.82 394.04,195.92 396.59,195.92 v1(397.07,195.45)
  BOTTOM w0.13: R3382.1 396.71,192.5 396.48,192.73 v2(396.48,194.94) 396.99,195.45 v1(397.07,195.45) ; U119.4 18.56,184.32 17.26,185.62 17.26,186.38 v1(16.7,186.94) 17.26,187.51 U119.15 17.26,189.55 16.45,190.37 R3199.2 16.17,191.41 15.94,191.64 15.94,192.91 16.19,193.16 v1(16.45,193.16)
SECOND_CPLD_JTAG_TMS: length 413.1
  TOP w0.13: R3395.2 402.15,191.17 401.64,190.66 401.64,189.07 v1(401,188.44) 402.02,187.42 402.02,186.45 U124.B8
  SIG8 w0.155: v1(23.94,193.29) 26.43,190.8 39.36,190.8 53.47,204.91 67.37,204.91 68.32,205.86 110.65,205.86 117.92,213.14 117.92,215.41 122.28,219.78 272.61,219.78 274.13,218.25 317.15,218.25 334.88,200.52 361.36,200.52 369.27,192.61 381.39,192.61 382.87,191.13 397.32,191.13 398.21,190.24 399.8,190.24 400.11,189.93 400.11,189.33 v1(401,188.44)
  BOTTOM w0.13: R3213.2 v1(23.94,193.29) ; v1(401,188.44) 400.9,188.44 v2(400.37,188.97)
SECOND_CPLD_OE_N: length 439.5
  TOP w0.13: R3293.1 37.27,157.73 v1(37.4,157.6) ; U124.E11 v1(404.42,184.05)
  SIG6 w0.102: 404.02,185.99 404.02,184.45 v1(404.42,184.05)
  SIG6 w0.155: v1(37.4,157.6) 37.97,157.03 40.26,157.03 44.98,161.75 44.98,171.62 46.67,173.31 46.67,173.76 45.58,174.85 45.58,185.07 46.36,185.85 46.36,187.9 61.28,202.82 70.05,202.82 70.55,203.31 117.16,203.31 117.66,202.82 150.3,202.82 152.21,204.72 156.65,204.72 157.16,204.21 199.1,204.21 200.92,202.39 213.81,202.39 214.44,203.03 240.9,203.03 246,208.13 252.13,208.13 252.99,207.26 281.03,207.26 283.36,209.58 283.36,211.6 286.11,214.35 304.88,214.35 305.47,213.76 309.73,213.76 v1(310.33,214.37) 310.64,214.68 317.55,214.68 329.13,203.1 357.42,203.1 369.66,190.86 373.69,190.86 375.1,189.45 383.45,189.45 389.22,195.22 389.22,195.86 389.45,196.09 390.54,196.09 392.08,197.63 399.21,197.63 402.65,194.18 402.65,191.01 404.02,189.64 404.02,185.99
  BOTTOM w0.13: v1(37.4,157.6) 37.86,157.29 38.23,157.15 38.69,157.15 v2(39.18,157.48)
SECOND_CPLD_RST#: length 435.2
  TOP w0.13: U124.E9 v1(402.82,184.05) ; R3410.2 403.42,191.2 402.71,190.5 v1(402.15,190.5) ; v1(39.18,155.45) 38.67,155.95 38.67,156.46 38.04,157.1 36.64,157.1 36.49,156.94 R3305.1
  SIG6 w0.155: v1(402.82,184.05) 402.25,184.61 402.25,185.85 402.56,186.16 402.56,190.08 v1(402.15,190.5) 401.64,191.01 401.64,194.29 399.39,196.54 391.91,196.54 383.97,188.61 374.86,188.61 373.43,190.04 369.08,190.04 356.66,202.46 325.58,202.46 323.66,200.54 323.66,197.13 321.22,194.68 305.88,194.68 305.24,195.32 294.32,195.32 293.69,195.96 291.27,195.96 287.72,199.51 287.72,200.53 285.97,202.28 214.93,202.28 214.41,201.76 197.78,201.76 196.09,203.45 151.96,203.45 150.69,202.18 115.08,202.18 114.47,201.57 106.36,201.57 105.75,202.18 72.6,202.18 71.2,200.78 62.22,200.78 46.51,185.08 46.51,175.15 47.33,174.34 47.33,173.04 46.29,172 46.29,161.93 40.31,155.95 39.68,155.95 v1(39.18,155.45)
  BOTTOM w0.13: v1(39.18,155.45) 39.18,155.95 v2(39.43,156.21)
SPS_FAULT0: length 506.3
  TOP w0.229: v1(67.75,136.27) 66.1,136.27 65.85,136.01 65.85,134.11 66.1,133.86 66.91,133.86 67.25,134.2 D435.26 ; v1(350.35,132.2) 350.35,132.15 350.32,132.13 349.24,132.13 348.74,131.63 D441.26 ; D436.26 67.21,144.36 66.71,143.86 v1(66.48,143.86) ; v1(350.35,152.45) 349.38,152.45 348.89,151.95 D444.26 ; D443.26 348.76,162.11 349.25,162.61 v1(350.35,162.61) ; v1(66.61,174.34) 66.84,174.34 67.33,174.84 D439.26 ; D442.26 348.87,141.79 349.36,142.29 v1(350.35,142.29) ; v1(66.48,184.43) 66.76,184.43 67.33,185 D440.26 ; D437.26 67.33,154.52 66.84,154.02 v1(66.61,154.02) ; v1(66.69,164.18) 67.18,164.68 D438.26
  TOP w0.381: R3652.2 370.27,158.62 369.63,157.99 v1(367.09,157.99)
  SIG4 w0.381: v1(67.75,136.27) 67.75,137.28 68.52,138.05 68.52,140.97 66.48,143 v1(66.48,143.86) 66.48,144.27 67.77,145.55 67.77,147.84 68.64,148.71 68.64,151 66.61,153.03 v1(66.61,154.02) 66.61,156.08 68.64,158.11 68.64,161.29 66.69,163.24 v1(66.69,164.18) 66.69,164.56 67.88,165.76 67.88,172.21 66.61,173.48 v1(66.61,174.34) 66.61,174.62 68.39,176.4 68.39,181.73 66.48,183.64 v1(66.48,184.43) 66.48,187.58 68.14,189.23 70.93,189.23 75.01,193.3 106.86,193.3 107.76,192.4 109.91,192.4 110.81,193.3 128.47,193.3 132.91,197.74 155.89,197.74 160.59,202.44 192.85,202.44 194.5,200.78 210.63,200.78 211.26,200.15 211.26,198.5 213.3,196.47 228.78,196.47 233.55,201.23 274.15,201.23 283.36,210.44 285.81,210.44 287.34,211.96 289.12,211.96 290.39,213.23 301.94,213.23 302.26,213.55 306.32,213.55 307.4,212.47 310.71,212.47 311.59,213.36 321.88,213.36 335.6,199.64 358.08,199.64 367.84,189.88 367.84,189.24 368.74,188.34 368.74,184.66 370.52,182.88 370.52,178.05 367.6,175.13 367.6,166.49 367.09,165.99 v1(367.09,157.99)
  SIG6 w0.381: v1(350.35,142.29) 350.35,144.19 349.61,144.93 349.61,147.46 350.35,148.2 v1(350.35,152.45) v1(350.35,162.61)
  SIG7 w0.381: v1(350.35,142.29) v1(350.35,132.2) ; v1(350.35,152.45) 350.8,152.91 363.03,152.91 367.09,156.97 v1(367.09,157.99)
  BOTTOM w0.13: v1(66.48,143.86) v2(66.48,143.08)
SPS_FAULT1: length 46.2
  TOP w0.229: v1(350.35,182.93) 349.36,182.93 348.81,182.37 348.24,182.37 348.17,182.43 D445.26 ; v1(350.35,172.77) 349.24,172.77 348.74,172.27 D446.26
  TOP w0.381: R3653.2 v1(372.81,157.96)
  SIG6 w0.381: v1(350.35,172.77) 350.81,173.23 350.81,182.46 v1(350.35,182.93)
  SIG9 w0.381: v1(372.81,157.96) 363.89,166.88 356.24,166.88 v1(350.35,172.77)
  BOTTOM w0.13: v1(350.35,182.93) v2(350.35,183.69)
SW_BOARD_INT#: length 130.8
  SIG4 w0.155: v1(10.35,174.11) 10.35,180.08 15.88,185.61 15.88,194.24 23.18,201.55 31.56,201.55 34.48,204.47 34.48,211.96 35.86,213.34 64.99,213.34 68.94,217.29 v1(69.66,217.29) 70.23,217.86 70.23,218.5 72.3,220.57 87.16,220.57 88.33,221.74 88.33,222.88 88.96,223.52 93.21,223.52 YJ3.A2_2
  BOTTOM w0.13: C3491.1 v1(69.66,217.29) ; v1(10.35,174.11) v2(10.35,170.56) 10.35,166.37 11.62,165.1 R3302.1
SW_BOARD_PWR_EN: length 119.1
  TOP w0.13: R3315.2 v1(41.59,150.87)
  SIG6 w0.155: v1(41.59,150.87) 40.45,152.02 37.4,152.02 36.26,153.16 36.26,173.73 38.1,175.57 38.1,181.29 37.37,182.02 37.37,188.72 57.14,208.49 65.7,208.49 66.87,209.66 66.87,210.82 67.5,211.45 68.01,211.45 69.66,213.1 v1(69.66,213.23) 70.17,212.72 70.17,209.42 71.09,208.49 93.5,208.49 94.33,209.32 YJ3.D2_2
  BOTTOM w0.13: v2(68.9,212.98) 69.15,213.23 v1(69.66,213.23) C3497.1
SW_BOARD_RST#: length 98
  TOP w0.13: R3300.1 v1(26.23,176.65)
  SIG6 w0.155: v1(26.23,176.65) 27.75,176.65 36.28,185.19 36.28,189.57 56.13,209.42 65.72,209.42 66.23,209.93 66.23,211.31 66.87,211.95 66.87,213.09 68.02,214.25 v1(69.66,214.25) 70.17,214.75 72.2,214.75 76.77,219.33 82.36,219.33 89.47,212.21 94.3,212.21 95.08,211.43 YJ3.D1_2
  BOTTOM w0.13: C3496.1 v1(69.66,214.25) v2(68.9,214.25)
SW_RESERVE1: length 356.9
  TOP w0.13: v1(389.7,196.72) 386.78,193.8 386.78,188.72 389.19,186.31 R3675.2
  SIG4 w0.155: v1(115.13,221.74) 116.68,223.29 378.33,223.29 384.24,217.38 384.24,208.65 389.7,203.18 v1(389.7,196.72)
  SIG9 w0.155: YJ3.A8_2 91.07,223.64 106.24,223.64 109.41,220.47 113.86,220.47 v1(115.13,221.74)
  BOTTOM w0.13: YJ3.A8_2 89.83,221.46 88.14,219.78 73.16,219.78 72.71,219.33 R26.2
SW_RESERVE2: length 353.2
  TOP w0.13: v1(389.7,195.45) 387.29,193.04 387.29,188.97 388.53,187.73 389.8,187.73 389.95,187.58 R3676.2
  SIG4 w0.155: v1(116.21,221.68) 117.41,222.88 378.02,222.88 383.73,217.17 383.73,208.43 389.06,203.1 389.06,196.09 v1(389.7,195.45)
  SIG9 w0.155: YJ3.A7_2 91.25,220.33 91.25,219.99 91.4,219.83 114.36,219.83 v1(116.21,221.68)
  BOTTOM w0.13: YJ3.A7_2 89.83,221 88.28,219.45 73.34,219.45 72.2,218.31 R27.2
SWITCH: length 229.5
  TOP w0.13: R3401.1 412.18,183.77 411.29,182.88 v1(410.78,182.88) 410.32,183.34 409.16,183.34 408.67,182.85 U124.F16 ; R3237.1 423.61,13.33 C3513.2 422.77,13.33 v1(422.72,13.38)
  SIG3 w0.155: v1(402.91,62.23) 402.4,62.74 401.38,62.74 401.13,62.48 401.13,61.85 399.61,60.32 399.61,52.45 394.5,47.35 394.5,27.81 394.97,27.35 395.5,27.35 398.34,24.51 398.34,15.87 399.99,14.22 421.88,14.22 v1(422.72,13.38)
  SIG7 w0.155: v1(402.91,62.23) 404.94,62.23 405.96,63.24 405.96,70.07 401.77,74.26 401.77,82.86 400.88,83.75 400.88,91.13 417.38,107.63 417.38,128.27 424.24,135.13 424.24,142.22 417.13,149.33 417.13,179.83 416.37,180.59 413.07,180.59 v1(410.78,182.88)
  BOTTOM w0.13: v2(402.91,61.47) v1(402.91,62.23)
TCK: length 4.1
  TOP w0.13: J33.1 v1(10.3,190.42)
  BOTTOM w0.13: v1(10.3,190.42) 9.87,189.99 TP2.1 8.85,189.89 R3203.2
TDI: length 8.9
  TOP w0.13: R3206.2 18.63,183.03 18.99,183.39 TP5.1 18.99,184.53 19.37,184.91 J33.9
TEST1.24V: length 16.4
  TOP w0.381: R3307.2 32.17,170.66 32.45,170.94 32.45,172.59 32.19,172.84 C3517.1 C3518.1 35.09,173.12 35.24,172.97 Q41.2 Q41.1 37.84,173.99 37.66,174.17 R3240.2 R3239.2 34.84,175.03 33.21,176.65 X248.1
TMS: length 4.2
  TOP w0.13: J33.5 v1(13.07,190.42)
  BOTTOM w0.13: v1(13.07,190.42) 12.18,190.42 TP4.1 11.52,189.76 R3204.2
TPS3823_MR_N: length 4.5
  TOP w0.13: R3254.1 R3183.2 37.68,161.92 37.91,161.69 37.91,161.11 39,160.02 U118.3
TPS3823_RESET#: length 12.4
  TOP w0.13: R3185.1 C3479.1 40.22,164.06 40.01,164.26 35.81,164.26 35.52,163.98 R3259.2 34.73,163.45 34.35,163.83 32.52,163.83 31.3,162.6 U123.D16
TPS3823_WDI: length 20.1
  TOP w0.13: R3184.2 R3186.2 39.21,154.33 v1(39.18,154.3) ; U123.D14 v1(29.65,163)
  SIG2 w0.152: v1(29.65,163) 31.43,163 31.88,163.45 34.86,163.45 36.13,162.18 36.13,155.57 36.77,154.94 38.54,154.94 v1(39.18,154.3)
TS_PLL_AVDD1P8: length 4.2
  TOP w0.229: U1.BH32 v1(199.55,154.34)
  TOP w0.381: 224.47,194.03 C2940.1 223.88,193.39
  TOP w0.762: L433.1 224.47,194.69
  BOTTOM w0.381: v1(223.46,194.18) v2(222.69,194.18) ; C2739.1 200.03,153.86 v1(199.55,154.34)
  vias: v1(223.46,193.16)
UART0_SIN: length 164.7
  TOP w0.13: v1(421.32,97.28) R2025.2 413.68,96.64 413.75,96.57 R2031.1 ; v1(390.21,220.22) 390.08,220.22 389.3,221 J35.19
  SIG7 w0.155: v1(390.21,220.22) 390.21,219.83 391.05,218.99 410.5,218.99 421.7,207.78 421.7,150.1 426.66,145.15 426.66,133.98 423.1,130.43 423.1,99.06 v1(421.32,97.28)
  BOTTOM w0.13: v1(390.21,220.22) v2(390.21,220.98)
UART0_SOUT: length 172
  TOP w0.13: v1(391.99,220.22) 391.86,220.22 391.3,220.77 J35.17 ; R2027.1 419.6,81.86 419.54,81.91 R2024.2 v1(420.69,82.7)
  SIG7 w0.155: v1(391.99,220.22) 391.99,219.71 392.32,219.37 410.65,219.37 422.34,207.69 422.34,150.58 427.16,145.75 427.16,133.6 423.61,130.05 423.61,98.42 421.58,96.39 421.58,83.59 v1(420.69,82.7)
  BOTTOM w0.13: v1(391.99,220.22) 392.37,220.6 v2(392.37,220.88)
USB0_DM: length 241
  TOP w0.13: J35.15 393.3,221.01 arc(393.3,220.93) 393.32,220.85 arc(393.39,220.63) 393.53,220.45 v1(393.76,220.22)
  SIG9 w0.178: v1(393.76,220.22) arc(393.92,219.99) 393.97,219.72 393.97,209.33 arc(394.1,208.69) 394.46,208.14 399.12,203.48 arc(399.67,203.12) 400.31,202.99 401.42,202.99 arc(401.75,202.92) 402.03,202.74 416.39,188.37 arc(416.58,188.09) 416.65,187.76 416.65,168.82 arc(416.55,168.33) 416.27,167.92 411.51,163.16 arc(411.23,162.74) 411.13,162.26 411.13,135.91 arc(411.26,135.26) 411.63,134.72 416.27,130.08 arc(416.45,129.8) 416.52,129.47 416.52,103.29 arc(416.42,102.8) 416.15,102.39 415.57,101.81 arc(415.3,101.4) 415.2,100.92 415.2,87.39 arc(415.13,87.06) 414.95,86.78 403.5,75.33 arc(403.13,74.79) 403.01,74.15 403.01,67.68 arc(402.91,67.19) 402.63,66.78 397.41,61.56 arc(397.13,61.14) 397.04,60.66 397.04,58.53 arc(396.94,58.05) 396.67,57.64 396.02,56.99 arc(395.66,56.45) 395.53,55.81 395.53,42.38 arc(395.43,41.9) 395.16,41.48 389.24,35.57 arc(388.97,35.15) 388.87,34.67 388.87,34.28 arc(388.8,33.94) v1(388.61,33.65)
  BOTTOM w0.13: J29.2 393.12,13.88 arc(392.71,14.15) 392.23,14.25 389.84,14.25 arc(389.22,14.37) 388.7,14.72 387.92,15.5 arc(387.56,16.03) 387.44,16.65 387.44,20.05 arc(387.56,20.67) 387.92,21.19 388.57,21.85 arc(388.77,22.14) 388.84,22.49 388.84,26.09 arc(388.82,26.19) 388.76,26.27 arc(388.68,26.33) 388.58,26.35 D94.3 387.81,26.42 arc(387.91,26.9) 388.19,27.31 388.52,27.64 arc(388.79,28.05) 388.89,28.54 388.89,32.98 arc(388.81,33.34) v1(388.61,33.65)
USB0_DP: length 241
  TOP w0.13: v1(394.65,220.22) 394.72,220.22 arc(394.77,220.2) 394.82,220.17 395.04,219.96 arc(395.23,219.67) 395.3,219.33 J35.14
  SIG9 w0.178: v1(389.52,33.65) arc(389.33,33.94) 389.26,34.28 389.26,34.67 arc(389.33,35) 389.52,35.29 395.44,41.21 arc(395.8,41.75) 395.92,42.38 395.92,55.81 arc(396.02,56.3) 396.29,56.71 396.94,57.36 arc(397.3,57.9) 397.43,58.53 397.43,60.66 397.45,60.66 arc(397.51,60.99) 397.7,61.27 402.92,66.49 arc(403.29,67.04) 403.42,67.68 403.42,74.15 arc(403.51,74.63) 403.79,75.05 415.24,86.49 arc(415.51,86.91) 415.61,87.39 415.61,100.92 arc(415.67,101.25) 415.86,101.53 416.44,102.1 arc(416.8,102.65) 416.93,103.29 416.93,129.47 arc(416.83,129.96) 416.56,130.37 411.92,135.01 arc(411.64,135.42) 411.54,135.91 411.54,162.26 arc(411.61,162.59) 411.8,162.87 416.56,167.63 arc(416.93,168.18) 417.05,168.82 417.05,187.76 arc(416.96,188.25) 416.68,188.66 402.32,203.03 arc(401.9,203.3) 401.42,203.4 400.31,203.4 arc(399.82,203.5) 399.41,203.77 394.75,208.43 arc(394.48,208.85) 394.38,209.33 394.38,219.55 arc(394.45,219.91) v1(394.65,220.22)
  BOTTOM w0.13: J29.3 393.5,15.24 arc(393.45,14.99) 393.31,14.79 arc(393.11,14.65) 392.87,14.6 389.84,14.6 arc(389.36,14.7) 388.95,14.97 388.17,15.75 arc(387.89,16.17) 387.79,16.65 387.79,20.05 arc(387.89,20.53) 388.17,20.94 388.82,21.6 arc(389.1,22.01) 389.19,22.49 389.19,26.13 arc(389.21,26.21) 389.26,26.28 arc(389.33,26.33) 389.41,26.35 D94.4 390.31,26.54 arc(390.22,27.03) 389.94,27.44 389.61,27.77 arc(389.34,28.18) 389.24,28.67 389.24,32.98 arc(389.32,33.34) v1(389.52,33.65)
USB5V: length 2.8
  TOP w0.381: C108.1 387.92,214.8 ; 390.95,214.1 R3238.2 390.26,214.88 ; C109.1 389.14,214.75
  vias: v1(385.89,215.82) v1(386.4,221.66) v1(386.4,220.26) v1(387.29,215.82) v1(388.18,221.79) v1(388.18,220.39) v1(388.18,218.48) v1(388.94,215.82) v1(390.08,215.82) v1(391.22,215.82) v1(395.01,29.46) v1(395.01,28.57) v1(395.89,29.46) v1(395.89,28.57) v2(389.57,217.42)
VMON_PWM_OUT: length 15.1
  TOP w0.178: U123.A10 v1(26.05,165.61) ; U123.D11 v1(27.25,163) ; U123.J13 v1(28.85,158.2) ; v1(28.05,164.6) U123.B12 v1(27.25,163.8) U123.C11 ; U123.D9 v1(25.65,163) ; U123.A14 v1(29.25,165.61) ; U123.J14 v1(29.65,158.2) ; U123.E11 v1(27.25,162.2) ; U123.A12 28,165.35 v1(28,165.61) ; U123.A15 v1(30.45,165.4) ; U123.E10 v1(26.45,162.2)
  TOP w0.381: v1(14.8,172.46) 13.3,170.96 R3278.1
  BOTTOM w0.305: v1(28.05,164.6) 27.91,164.74 C3521.1 27.24,163.81 v1(27.25,163.8)
XIN: length 6.8
  BOTTOM w0.13: U117.12 301.8,205.63 304.38,203.05 306.54,203.05 306.74,202.84 R3180.1
XOUT: length 6.9
  BOTTOM w0.13: R3182.1 306.74,203.58 306.54,203.38 304.81,203.38 302.06,206.13 U117.11
ZQSFP+1_3.3V: length 251.3
  TOP w0.381: C2155.2 12.66,87.48 ; C2155.2 11.37,86.74 v3(11.11,86.99) 10.86,86.74 C2159.2 ; C2155.2 12.66,85.75 ; C2159.2 9.69,85.87 ; C2159.2 9.69,87.48 ; C2151.2 31.84,103.35 ; C2151.2 31.84,101.88 ; C2151.2 31.05,102.61 ; v1(56.07,89.15) 56.45,88.77 R2615.1 ; 80.1,89.18 C2243.2 79.18,90.04 ; R2593.2 v1(55.44,86.1) R2617.2 ; R1956.1 v1(9.33,90.8) ; v1(27.62,172.46) 28.64,171.45 R3290.2 ; 24.45,109.85 C3681.1 23.81,109.22 ; 21.45,109.27 C3680.1 20.76,109.85 ; R246.1 v1(9.33,97.51) ; v1(18.22,83.69) 17.56,83.03 R2616.2 ; 91,90.04 C2248.2 90.34,89.43 ; R250.1 v1(9.33,93.04) ; v1(43.37,87.75) 41.97,86.36 41.97,83.18 42.61,82.55 R2595.1 ; R248.1 v1(9.33,95.27) ; C2247.2 93.43,89.25 ; C2247.2 93.43,90.78 ; C2247.2 92.52,90.04 ; R2103.1 R2104.1 24.85,97.51 v1(25.21,97.15) 25.21,96.77 23.71,95.27 R2102.1 R2101.1 ; R251.1 v1(9.33,91.92) ; C2147.2 28.87,103.48 ; C2147.2 29.65,102.61 ; C2147.2 28.87,101.75 ; 77.13,89.18 C2215.2 78.04,90.04 ; R1957.1 v1(9.33,89.68) ; R2653.1 v1(72.45,79.5) ; R2097.1 R2098.1 R2099.1 R2100.1 23.61,93.04 v1(23.81,92.83) ; C3679.1 22.7,109.12 ; R249.1 v1(9.33,94.16) ; v1(9.33,96.39) R247.1 ; R2654.1 v1(85.79,79.5)
  TOP w0.508: v1(4.89,114.17) R3585.2
  SIG3 w0.381: v1(4.89,114.17) 4.89,116.33 7.3,118.74 19.62,118.74 22.03,116.33 22.03,110.23 v1(24.04,108.23) ; v1(24.04,109.16) 23.69,109.51 23.69,118.87 12.13,130.43 9.84,130.43 4.76,135.51 4.76,165.1 14.54,174.88 25.97,174.88 26.86,173.99 26.86,173.23 v1(27.62,172.46)
  BOTTOM w0.381: R249.1 v1(9.33,94.16) ; C2222.1 76.9,90.55 ; v1(83.5,79.63) 83.76,79.37 R2639.1 ; 38.54,96.64 C2191.1 37.88,96.03 ; C2211.2 64.83,90.04 v3(65.34,90.55) ; C2211.2 63.92,89.3 ; C2211.2 63.92,90.78 ; R251.1 v1(9.33,91.92) ; R250.1 v1(9.33,93.04) ; R1956.1 v1(9.33,90.8) ; R2632.1 70.42,79.12 v1(70.04,79.5) ; 32.19,103.38 32.22,103.35 C2186.2 31.31,102.49 ; C2252.2 66.1,90.04 ; C2252.2 66.89,90.65 ; C2252.2 66.89,89.43 ; R2596.1 19.24,79.12 19.75,79.63 19.75,81.79 18.5,83.03 R2614.1 v1(18.22,83.69) 18.48,83.69 18.99,84.2 18.99,84.96 18.33,85.62 R2594.2 ; C2156.1 48.83,91.56 ; C2156.1 49.49,90.95 ; C2156.1 49.49,92.17 ; C2249.1 63.69,91.95 ; R246.1 v1(9.33,97.51) ; C2244.1 90.23,90.68 ; C2184.1 28.74,102 ; C2184.1 28.74,103.22 ; C2184.1 29.4,102.61 ; R2656.2 95.31,80.52 94.17,81.66 93.79,81.66 ; 38.54,97.79 C2187.1 37.88,98.4 ; v1(23.81,92.83) 23.61,93.04 R2100.1 ; 80.1,90.65 C2243.2 ; C2243.2 79.08,90.04 v3(78.75,90.37) ; C2243.2 80.1,89.43 ; R2102.1 R2101.1 R2100.1 ; R2100.1 R325.1 R2098.1 R2097.1 ; C2221.2 66.89,91.72 ; C2221.2 66.89,92.94 ; C2221.2 66.1,92.33 ; R2630.2 85.79,84.68 v1(85.79,85.34) ; v1(25.21,97.15) 25.08,97.28 23.81,97.28 23.58,97.51 R2104.1 R2103.1 ; 48.58,90.04 C2179.2 49.37,89.3 ; C3671.2 6.77,109.4 7.05,109.12 v1(7.56,109.12) ; C2216.1 93.41,90.68 ; C2253.1 93.41,89.66 ; C2160.1 46.67,91.69 ; C2160.1 46.01,92.3 ; C2160.1 46.01,91.08 ; v1(71.44,85.34) R2631.2 R2655.2 ; C2190.2 47.18,90.04 ; C2190.2 46.39,90.78 ; C2190.2 46.39,89.18 ; C2218.1 90.23,89.66 ; 29.27,103.88 C2180.1 28.74,103.27 ; C2254.1 63.56,92.96 ; R1957.1 v1(9.33,89.68) ; R247.1 v1(9.33,96.39) ; 12.66,85.62 C2155.2 11.37,86.74 v3(11.11,86.99) ; R248.1 v1(9.33,95.27) ; C2212.1 76.9,89.53
  BOTTOM w0.508: C2148.1 9.72,87.25 ; C2152.1 9.72,86.23
  vias: v1(24.04,107.3) v1(30.92,93.34) v1(33.29,95.76) v2(12.38,105.03) v2(40.07,97.15) v2(91.76,92.07) v3(11.11,85.72) v3(11.11,79.25) v3(11.11,77.98) v3(15.94,109.22) v3(15.94,107.95) v3(15.94,106.68) v3(17.21,109.22) v3(17.21,107.95) v3(17.21,106.68) v3(17.21,105.41) v3(17.21,104.14) v3(17.21,102.87) v3(18.48,109.22) v3(18.48,107.95) v3(18.48,106.68) v3(18.48,105.41) v3(18.48,104.14) v3(18.48,102.87) v3(19.75,109.22) v3(19.75,107.95) v3(19.75,106.68) v3(19.75,105.41) v3(19.75,104.14) v3(19.75,102.87) v3(29.96,102.82) v3(30.99,103.63) v3(38.8,97.03) v3(38.8,95.76) v3(47.56,82.67) v3(47.56,81.4) v3(47.82,89.91) v3(47.82,88.64) v3(65.34,89.28) v3(65.34,82.67) v3(65.34,81.4) v3(78.55,88.85) v3(78.55,82.67) v3(78.55,81.4) v3(91.76,90.55) v3(91.76,89.28) v3(91.76,83.06) v3(91.76,81.79)
ZQSFP+1_3.3V_EN: length 20.6
  TOP w0.229: v1(7.56,118.11) 7.97,118.52 U130.2
  TOP w0.254: R3527.2 R3531.1 v1(7.05,130.45) 6.82,130.45 v2(6.29,129.92) Q45.3
  SIG9 w0.305: v1(7.05,130.45) 8.19,129.31 8.19,127 6.26,125.07 6.26,119.4 v1(7.56,118.11)
  BOTTOM w0.13: v1(7.05,130.45) 6.82,130.45 v2(6.29,129.92)
ZQSFP+1_3.3V_PG: length 21.6
  TOP w0.229: v1(7.56,117.22) 8.47,118.13 U130.3
  TOP w0.381: R3571.2 v1(7.05,129.03) 6.67,128.65 4.25,128.65 3.9,128.29 R3573.1
  SIG9 w0.305: v1(7.05,129.03) 6.79,129.03 5.65,127.89 5.65,119.12 v1(7.56,117.22)
  BOTTOM w0.13: v1(7.05,129.03) 6.79,129.03 v2(6.29,128.52)
ZQSFP+2_3.3V: length 213.2
  TOP w0.381: R179.1 44.21,95.88 v1(43.95,95.63) ; v1(61.18,103.96) 60.02,102.8 57.91,102.8 R196.1 ; v1(44.01,101.34) 44.72,101.34 R186.1 ; C2345.2 171.11,89.3 ; C2345.2 171.11,90.78 ; C2345.2 172.02,90.04 ; 143.22,89.44 C2318.2 ; C2318.2 143.22,90.64 ; C2318.2 142.58,90.04 ; v1(45.3,93.9) 44.84,94.36 R180.1 ; R182.1 v1(59.25,95.88) ; R185.1 44.31,102.59 v1(44.03,102.3) ; R2734.1 v1(179.77,79.5) ; C2309.2 113.7,89.3 ; C2309.2 114.62,90.04 ; C2309.2 113.7,90.78 ; 160.24,92.33 C2381.2 ; C2381.2 160.87,91.73 ; C2381.2 160.87,92.92 ; v1(44.13,99.24) R188.1 R189.1 ; 48.45,116.84 C3688.1 49.14,116.25 ; 186.5,90.04 C2371.2 ; C2371.2 187.41,90.78 ; C2371.2 187.41,89.3 ; R187.1 v1(44.01,100.35) ; C2375.2 184.32,90.78 ; C2375.2 185.23,90.04 ; C2375.2 184.32,89.3 ; 129.88,89.44 C2287.2 ; C2287.2 129.88,90.64 ; C2287.2 129.25,90.04 ; C2350.2 160.87,90.64 ; C2350.2 160.24,90.04 ; C2350.2 160.87,89.44 ; C2307.2 127.55,90.04 ; C2307.2 126.91,90.64 ; C2307.2 126.91,89.44 ; v1(57.09,93.72) 57.7,94.33 R181.1 ; v1(166.43,79.5) R2733.1 R2714.1 ; v1(120.21,79.5) 120.08,79.37 R2695.1 ; R194.1 v1(60.52,100.35) ; R195.1 58.69,101.47 v1(58.84,101.62) ; C2339.2 174.08,90.78 ; C2339.2 173.16,90.04 ; C2339.2 174.08,89.3 ; C2377.2 160.87,97.5 ; C2377.2 160.24,96.9 ; C2377.2 160.87,96.3 ; 52.13,116.84 C3689.1 51.5,116.2 ; R193.1 v1(59.37,99.24) ; C2279.2 140.75,90.04 ; C2279.2 140.12,89.44 ; C2279.2 140.12,90.64 ; C2275.2 116.68,90.78 ; C2275.2 116.68,89.3 ; C2275.2 115.76,90.04 ; C3687.1 50.38,116.1 ; v1(43.26,97.93) 44.19,97 R190.1 ; R191.1 v1(60.16,97) ; v1(58.39,98.12) R192.1
  TOP w0.508: v1(32.58,121.16) R3584.2
  SIG3 w0.381: v1(48.58,115.31) 48.58,124.2 47.05,125.73 34.61,125.73 32.58,123.7 v1(32.58,121.16) ; v1(31.69,171.45) 33.08,170.05 34.35,170.05 35.75,168.65 35.75,145.92 33.53,143.7 33.53,137.73 32.45,136.65 32.45,131.57 31.31,130.43 31.31,114.68 33.21,112.77 v1(35.12,112.77)
  BOTTOM w0.381: C2288.1 140.02,89.66 ; C2351.1 187.39,90.68 ; v1(135.45,85.34) 135.57,85.21 R2674.2 R2692.2 ; C2284.1 140.02,90.68 ; v1(135.83,79.6) 135.57,79.34 R2691.1 R2676.1 ; v1(45.3,93.9) 44.84,94.36 R180.1 ; R179.1 44.21,95.88 v1(43.95,95.63) ; C2382.1 170.88,89.53 ; C2287.2 129.1,90.04 ; C2287.2 129.88,89.43 ; C2287.2 129.88,90.65 ; v1(35.24,116.1) 34.73,116.1 34.46,116.38 C3673.2 ; C2346.1 187.39,89.66 ; R191.1 v1(60.16,97) ; v1(57.09,93.72) 57.7,94.33 R181.1 ; v1(176.85,75.18) 176.85,78.25 177.43,78.84 R2719.1 ; C2339.2 173.29,90.04 ; C2339.2 174.08,90.65 ; C2339.2 174.08,89.43 ; R195.1 58.69,101.47 v1(58.84,101.62) ; C2308.1 126.68,90.55 ; v1(61.79,101.67) 61.79,101.85 61.05,102.59 R196.1 ; v1(44.03,102.3) 44.31,102.59 R185.1 ; R194.1 v1(60.52,100.35) ; v1(134.81,93.6) C2319.1 ; 133.67,93.47 C2314.1 ; v1(59.37,99.24) R193.1 ; 134.81,98.17 C2378.1 ; v1(166.43,85.34) R2735.2 R2713.2 ; 133.67,98.17 C2372.1 ; v1(31.69,171.45) 31.69,170.91 R3311.2 ; R187.1 v1(44.01,100.35) ; v1(44.13,99.24) R188.1 R189.1 ; C2376.1 170.88,90.55 ; v1(120.21,79.5) R2677.1 ; R186.1 44.62,101.47 44.49,101.34 v1(44.01,101.34) ; R190.1 44.19,97 v1(43.26,97.93) ; C2275.2 116.68,89.43 ; C2275.2 116.68,90.65 ; C2275.2 115.89,90.04 ; R192.1 v1(58.39,98.12) ; v1(122.24,85.34) R2696.2 R2675.2 ; v1(179.77,85.34) R2736.2 R2712.2 ; C2342.1 184.21,90.68 ; C2340.1 184.21,89.66 ; C2310.1 126.68,89.53 ; R182.1 v1(59.25,95.88) ; C2280.1 113.6,89.53 ; C2276.1 113.6,90.55
  vias: v1(48.58,114.17) v1(48.58,112.65) v1(49.97,114.17) v1(51.5,115.31) v1(51.5,114.17) v1(52.26,110.23) v1(53.53,111.61) v1(135.45,94.23) v1(157.54,90.07) v1(158.18,90.7) v1(158.81,91.34) v1(193.23,89.66) v1(193.23,88.77) v2(40.2,113.41) v2(114.87,91.18) v2(172.02,89.91) v3(43.62,116.58) v3(43.62,115.31) v3(43.62,114.04) v3(44.89,116.58) v3(44.89,115.31) v3(44.89,114.04) v3(44.89,112.77) v3(44.89,111.5) v3(44.89,110.23) v3(46.16,116.58) v3(46.16,115.31) v3(46.16,114.04) v3(46.16,112.77) v3(46.16,111.5) v3(46.16,110.23) v3(47.43,116.58) v3(47.43,115.31) v3(47.43,114.04) v3(47.43,112.77) v3(47.43,111.5) v3(47.43,110.23) v3(48.7,111.5) v3(115.13,88.19) v3(115.13,86.94) v3(115.13,82.08) v3(115.13,80.84) v3(128.33,90.68) v3(128.33,89.41) v3(128.33,82.67) v3(128.33,81.4) v3(141.67,90.42) v3(141.67,89.15) v3(141.67,82.93) v3(141.67,81.4) v3(159.32,88.69) v3(159.32,87.37) v3(159.32,82.8) v3(159.32,81.4) v3(172.53,88.26) v3(172.53,86.99) v3(172.53,82.67) v3(172.53,81.4) v3(185.74,82.67) v3(185.74,81.4) v3(185.99,90.17) v3(185.99,88.9)
