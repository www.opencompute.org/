# Allegro board RA-B6910-64C-MAC.brd (continued)
## Nets (continued)
FC17_TDP2: U1.AJ61(FC17_TD2P) YJ26.C34(TX3N_3)
FC17_TDP3: U1.AH66(FC17_TD3P) YJ26.C36(TX1P_3)
FC18_19_PVDD0P8: C2780.1 C2832.1 C3338.1 L42.1 U1.AH49(FC19_PVDD0P8) U1.AK49(FC18_PVDD0P8)
FC18_RDN0: U1.AG54(FC18_RD0N) YJ25.A17(RX1P_1)
FC18_RDN1: U1.AF58(FC18_RD1N) YJ25.A15(RX3N_1)
FC18_RDN2: U1.AG56(FC18_RD2N) YJ25.A25(RX4P_1)
FC18_RDN3: U1.AF60(FC18_RD3N) YJ25.A21(RX2N_1)
FC18_RDP0: U1.AF54(FC18_RD0P) YJ25.A18(RX1N_1)
FC18_RDP1: U1.AG58(FC18_RD1P) YJ25.A14(RX3P_1)
FC18_RDP2: U1.AF56(FC18_RD2P) YJ25.A24(RX4N_1)
FC18_RDP3: U1.AG60(FC18_RD3P) YJ25.A22(RX2P_1)
FC18_TDN0: U1.AE63(FC18_TD0N) YJ25.A3(TX2P_1)
FC18_TDN1: U1.AF65(FC18_TD1N) YJ25.A5(TX4N_1)
FC18_TDN2: U1.AG62(FC18_TD2N) YJ25.A36(TX1P_1)
FC18_TDN3: U1.AH64(FC18_TD3N) YJ25.A34(TX3N_1)
FC18_TDP0: U1.AF63(FC18_TD0P) YJ25.A2(TX2N_1)
FC18_TDP1: U1.AE65(FC18_TD1P) YJ25.A6(TX4P_1)
FC18_TDP2: U1.AH62(FC18_TD2P) YJ25.A37(TX1N_1)
FC18_TDP3: U1.AG64(FC18_TD3P) YJ25.A33(TX3P_1)
FC19_RDN0: U1.AC54(FC19_RD0N) YJ25.B15(RX3N_2)
FC19_RDN1: U1.AD58(FC19_RD1N) YJ25.B17(RX1P_2)
FC19_RDN2: U1.AC56(FC19_RD2N) YJ25.B24(RX4N_2)
FC19_RDN3: U1.AD60(FC19_RD3N) YJ25.B22(RX2P_2)
FC19_RDP0: U1.AD54(FC19_RD0P) YJ25.B14(RX3P_2)
FC19_RDP1: U1.AC58(FC19_RD1P) YJ25.B18(RX1N_2)
FC19_RDP2: U1.AD56(FC19_RD2P) YJ25.B25(RX4P_2)
FC19_RDP3: U1.AC60(FC19_RD3P) YJ25.B21(RX2N_2)
FC19_TDN0: U1.AD66(FC19_TD0N) YJ25.B34(TX3N_2)
FC19_TDN1: U1.AC64(FC19_TD1N) YJ25.B36(TX1P_2)
FC19_TDN2: U1.AD62(FC19_TD2N) YJ25.B2(TX2N_2)
FC19_TDN3: U1.AA65(FC19_TD3N) YJ25.B6(TX4P_2)
FC19_TDP0: U1.AC66(FC19_TD0P) YJ25.B33(TX3P_2)
FC19_TDP1: U1.AD64(FC19_TD1P) YJ25.B37(TX1N_2)
FC19_TDP2: U1.AC62(FC19_TD2P) YJ25.B3(TX2P_2)
FC19_TDP3: U1.AB65(FC19_TD3P) YJ25.B5(TX4N_2)
FC20_21_PVDD0P8: C3092.1 C3137.1 C3341.1 L43.1 U1.AE49(FC21_PVDD0P8) U1.AG49(FC20_PVDD0P8)
FC20_RDN0: U1.AA54(FC20_RD0N) YJ26.B21(RX2N_2)
FC20_RDN1: U1.Y58(FC20_RD1N) YJ26.B14(RX3P_2)
FC20_RDN2: U1.AA56(FC20_RD2N) YJ26.B18(RX1N_2)
FC20_RDN3: U1.Y60(FC20_RD3N) YJ26.B25(RX4P_2)
FC20_RDP0: U1.Y54(FC20_RD0P) YJ26.B22(RX2P_2)
FC20_RDP1: U1.AA58(FC20_RD1P) YJ26.B15(RX3N_2)
FC20_RDP2: U1.Y56(FC20_RD2P) YJ26.B17(RX1P_2)
FC20_RDP3: U1.AA60(FC20_RD3P) YJ26.B24(RX4N_2)
FC20_TDN0: U1.W62(FC20_TD0N) YJ26.B34(TX3N_2)
FC20_TDN1: U1.Y64(FC20_TD1N) YJ26.B3(TX2P_2)
FC20_TDN2: U1.W66(FC20_TD2N) YJ26.B37(TX1N_2)
FC20_TDN3: U1.AB63(FC20_TD3N) YJ26.B6(TX4P_2)
FC20_TDP0: U1.Y62(FC20_TD0P) YJ26.B33(TX3P_2)
FC20_TDP1: U1.W64(FC20_TD1P) YJ26.B2(TX2N_2)
FC20_TDP2: U1.Y66(FC20_TD2P) YJ26.B36(TX1P_2)
FC20_TDP3: U1.AA63(FC20_TD3P) YJ26.B5(TX4N_2)
FC21_RDN0: U1.U53(FC21_RD0N) YJ26.A25(RX4P_1)
FC21_RDN1: U1.V57(FC21_RD1N) YJ26.A18(RX1N_1)
FC21_RDN2: U1.U55(FC21_RD2N) YJ26.A14(RX3P_1)
FC21_RDN3: U1.V59(FC21_RD3N) YJ26.A21(RX2N_1)
FC21_RDP0: U1.V53(FC21_RD0P) YJ26.A24(RX4N_1)
FC21_RDP1: U1.U57(FC21_RD1P) YJ26.A17(RX1P_1)
FC21_RDP2: U1.V55(FC21_RD2P) YJ26.A15(RX3N_1)
FC21_RDP3: U1.U59(FC21_RD3P) YJ26.A22(RX2P_1)
FC21_TDN0: U1.V65(FC21_TD0N) YJ26.A3(TX2P_1)
FC21_TDN1: U1.U63(FC21_TD1N) YJ26.A5(TX4N_1)
FC21_TDN2: U1.V61(FC21_TD2N) YJ26.A36(TX1P_1)
FC21_TDN3: U1.R66(FC21_TD3N) YJ26.A34(TX3N_1)
FC21_TDP0: U1.U65(FC21_TD0P) YJ26.A2(TX2N_1)
FC21_TDP1: U1.V63(FC21_TD1P) YJ26.A6(TX4P_1)
FC21_TDP2: U1.U61(FC21_TD2P) YJ26.A37(TX1N_1)
FC21_TDP3: U1.T66(FC21_TD3P) YJ26.A33(TX3P_1)
FC22_23_PVDD0P8: C2852.1 C2898.1 C3345.1 L44.1 U1.AB49(FC23_PVDD0P8) U1.AD49(FC22_PVDD0P8)
FC22_RDN0: U1.R54(FC22_RD0N) YJ25.C14(RX3P_3)
FC22_RDN1: U1.P58(FC22_RD1N) YJ25.C18(RX1N_3)
FC22_RDN2: U1.R56(FC22_RD2N) YJ25.C22(RX2P_3)
FC22_RDN3: U1.P60(FC22_RD3N) YJ25.C24(RX4N_3)
FC22_RDP0: U1.P54(FC22_RD0P) YJ25.C15(RX3N_3)
FC22_RDP1: U1.R58(FC22_RD1P) YJ25.C17(RX1P_3)
FC22_RDP2: U1.P56(FC22_RD2P) YJ25.C21(RX2N_3)
FC22_RDP3: U1.R60(FC22_RD3P) YJ25.C25(RX4P_3)
FC22_TDN0: U1.N63(FC22_TD0N) YJ25.C6(TX4P_3)
FC22_TDN1: U1.P65(FC22_TD1N) YJ25.C2(TX2N_3)
FC22_TDN2: U1.R62(FC22_TD2N) YJ25.C33(TX3P_3)
FC22_TDN3: U1.T64(FC22_TD3N) YJ25.C37(TX1N_3)
FC22_TDP0: U1.P63(FC22_TD0P) YJ25.C5(TX4N_3)
FC22_TDP1: U1.N65(FC22_TD1P) YJ25.C3(TX2P_3)
FC22_TDP2: U1.T62(FC22_TD2P) YJ25.C34(TX3N_3)
FC22_TDP3: U1.R64(FC22_TD3P) YJ25.C36(TX1P_3)
FC23_RDN0: U1.L54(FC23_RD0N) YJ25.D15(RX3N_4)
FC23_RDN1: U1.M58(FC23_RD1N) YJ25.D17(RX1P_4)
FC23_RDN2: U1.L56(FC23_RD2N) YJ25.D24(RX4N_4)
FC23_RDN3: U1.M60(FC23_RD3N) YJ25.D22(RX2P_4)
FC23_RDP0: U1.M54(FC23_RD0P) YJ25.D14(RX3P_4)
FC23_RDP1: U1.L58(FC23_RD1P) YJ25.D18(RX1N_4)
FC23_RDP2: U1.M56(FC23_RD2P) YJ25.D25(RX4P_4)
FC23_RDP3: U1.L60(FC23_RD3P) YJ25.D21(RX2N_4)
FC23_TDN0: U1.M66(FC23_TD0N) YJ25.D34(TX3N_4)
FC23_TDN1: U1.L64(FC23_TD1N) YJ25.D36(TX1P_4)
FC23_TDN2: U1.M62(FC23_TD2N) YJ25.D2(TX2N_4)
FC23_TDN3: U1.J65(FC23_TD3N) YJ25.D6(TX4P_4)
FC23_TDP0: U1.L66(FC23_TD0P) YJ25.D33(TX3P_4)
FC23_TDP1: U1.M64(FC23_TD1P) YJ25.D37(TX1N_4)
FC23_TDP2: U1.L62(FC23_TD2P) YJ25.D3(TX2P_4)
FC23_TDP3: U1.K65(FC23_TD3P) YJ25.D5(TX4N_4)
FC24_25_PVDD0P8: C2996.1 C3041.1 C3319.1 L45.1 U1.Y47(FC25_PVDD0P8) U1.Y48(FC24_PVDD0P8)
FC24_RDN0: U1.J54(FC24_RD0N) YJ28.D24(RX4N_4)
FC24_RDN1: U1.H58(FC24_RD1N) YJ28.D17(RX1P_4)
FC24_RDN2: U1.J56(FC24_RD2N) YJ28.D15(RX3N_4)
FC24_RDN3: U1.H60(FC24_RD3N) YJ28.D22(RX2P_4)
FC24_RDP0: U1.H54(FC24_RD0P) YJ28.D25(RX4P_4)
FC24_RDP1: U1.J58(FC24_RD1P) YJ28.D18(RX1N_4)
FC24_RDP2: U1.H56(FC24_RD2P) YJ28.D14(RX3P_4)
FC24_RDP3: U1.J60(FC24_RD3P) YJ28.D21(RX2N_4)
FC24_TDN0: U1.G62(FC24_TD0N) YJ28.D34(TX3N_4)
FC24_TDN1: U1.H64(FC24_TD1N) YJ28.D3(TX2P_4)
FC24_TDN2: U1.G66(FC24_TD2N) YJ28.D37(TX1N_4)
FC24_TDN3: U1.K63(FC24_TD3N) YJ28.D6(TX4P_4)
FC24_TDP0: U1.H62(FC24_TD0P) YJ28.D33(TX3P_4)
FC24_TDP1: U1.G64(FC24_TD1P) YJ28.D2(TX2N_4)
FC24_TDP2: U1.H66(FC24_TD2P) YJ28.D36(TX1P_4)
FC24_TDP3: U1.J63(FC24_TD3P) YJ28.D5(TX4N_4)
FC25_RDN0: U1.F53(FC25_RD0N) YJ28.C24(RX4N_3)
FC25_RDN1: U1.E55(FC25_RD1N) YJ28.C14(RX3P_3)
FC25_RDN2: U1.F57(FC25_RD2N) YJ28.C18(RX1N_3)
FC25_RDN3: U1.E59(FC25_RD3N) YJ28.C22(RX2P_3)
FC25_RDP0: U1.E53(FC25_RD0P) YJ28.C25(RX4P_3)
FC25_RDP1: U1.F55(FC25_RD1P) YJ28.C15(RX3N_3)
FC25_RDP2: U1.E57(FC25_RD2P) YJ28.C17(RX1P_3)
FC25_RDP3: U1.F59(FC25_RD3P) YJ28.C21(RX2N_3)
FC25_TDN0: U1.C66(FC25_TD0N) YJ28.C37(TX1N_3)
FC25_TDN1: U1.F61(FC25_TD1N) YJ28.C34(TX3N_3)
FC25_TDN2: U1.E63(FC25_TD2N) YJ28.C2(TX2N_3)
FC25_TDN3: U1.F65(FC25_TD3N) YJ28.C6(TX4P_3)
FC25_TDP0: U1.D66(FC25_TD0P) YJ28.C36(TX1P_3)
FC25_TDP1: U1.E61(FC25_TD1P) YJ28.C33(TX3P_3)
FC25_TDP2: U1.F63(FC25_TD2P) YJ28.C3(TX2P_3)
FC25_TDP3: U1.E65(FC25_TD3P) YJ28.C5(TX4N_3)
FC26_27_PVDD0P8: C2667.1 C3151.1 C3323.1 L46.1 U1.Y44(FC27_PVDD0P8) U1.Y45(FC26_PVDD0P8)
FC26_RDN0: U1.C53(FC26_RD0N) YJ27.A15(RX3N_1)
FC26_RDN1: U1.B55(FC26_RD1N) YJ27.A22(RX2P_1)
FC26_RDN2: U1.C57(FC26_RD2N) YJ27.A17(RX1P_1)
FC26_RDN3: U1.B59(FC26_RD3N) YJ27.A25(RX4P_1)
FC26_RDP0: U1.B53(FC26_RD0P) YJ27.A14(RX3P_1)
FC26_RDP1: U1.C55(FC26_RD1P) YJ27.A21(RX2N_1)
FC26_RDP2: U1.B57(FC26_RD2P) YJ27.A18(RX1N_1)
FC26_RDP3: U1.C59(FC26_RD3P) YJ27.A24(RX4N_1)
FC26_TDN0: U1.A63(FC26_TD0N) YJ27.A36(TX1P_1)
FC26_TDN1: U1.B61(FC26_TD1N) YJ27.A2(TX2N_1)
FC26_TDN2: U1.C64(FC26_TD2N) YJ27.A33(TX3P_1)
FC26_TDN3: U1.D62(FC26_TD3N) YJ27.A5(TX4N_1)
FC26_TDP0: U1.B63(FC26_TD0P) YJ27.A37(TX1N_1)
FC26_TDP1: U1.A61(FC26_TD1P) YJ27.A3(TX2P_1)
FC26_TDP2: U1.D64(FC26_TD2P) YJ27.A34(TX3N_1)
FC26_TDP3: U1.C62(FC26_TD3P) YJ27.A6(TX4P_1)
FC27_RDN0: U1.G49(FC27_RD0N) YJ27.B17(RX1P_2)
FC27_RDN1: U1.J48(FC27_RD1N) YJ27.B21(RX2N_2)
FC27_RDN2: U1.L49(FC27_RD2N) YJ27.B14(RX3P_2)
FC27_RDN3: U1.N48(FC27_RD3N) YJ27.B24(RX4N_2)
FC27_RDP0: U1.G48(FC27_RD0P) YJ27.B18(RX1N_2)
FC27_RDP1: U1.J49(FC27_RD1P) YJ27.B22(RX2P_2)
FC27_RDP2: U1.L48(FC27_RD2P) YJ27.B15(RX3N_2)
FC27_RDP3: U1.N49(FC27_RD3P) YJ27.B25(RX4P_2)
FC27_TDN0: U1.D47(FC27_TD0N) YJ27.B6(TX4P_2)
FC27_TDN1: U1.B48(FC27_TD1N) YJ27.B2(TX2N_2)
FC27_TDN2: U1.E49(FC27_TD2N) YJ27.B33(TX3P_2)
FC27_TDN3: U1.C50(FC27_TD3N) YJ27.B37(TX1N_2)
FC27_TDP0: U1.D48(FC27_TD0P) YJ27.B5(TX4N_2)
FC27_TDP1: U1.B47(FC27_TD1P) YJ27.B3(TX2P_2)
FC27_TDP2: U1.E50(FC27_TD2P) YJ27.B34(TX3N_2)
FC27_TDP3: U1.C49(FC27_TD3P) YJ27.B36(TX1P_2)
FC28_29_PVDD0P8: C2925.1 C2969.1 C3328.1 L47.1 U1.Y41(FC29_PVDD0P8) U1.Y42(FC28_PVDD0P8)
FC28_RDN0: U1.G46(FC28_RD0N) YJ28.B21(RX2N_2)
FC28_RDN1: U1.J45(FC28_RD1N) YJ28.B17(RX1P_2)
FC28_RDN2: U1.L46(FC28_RD2N) YJ28.B24(RX4N_2)
FC28_RDN3: U1.N45(FC28_RD3N) YJ28.B14(RX3P_2)
FC28_RDP0: U1.G45(FC28_RD0P) YJ28.B22(RX2P_2)
FC28_RDP1: U1.J46(FC28_RD1P) YJ28.B18(RX1N_2)
FC28_RDP2: U1.L45(FC28_RD2P) YJ28.B25(RX4P_2)
FC28_RDP3: U1.N46(FC28_RD3P) YJ28.B15(RX3N_2)
FC28_TDN0: U1.B43(FC28_TD0N) YJ28.B37(TX1N_2)
FC28_TDN1: U1.E46(FC28_TD1N) YJ28.B6(TX4P_2)
FC28_TDN2: U1.C45(FC28_TD2N) YJ28.B34(TX3N_2)
FC28_TDN3: U1.A46(FC28_TD3N) YJ28.B3(TX2P_2)
FC28_TDP0: U1.B44(FC28_TD0P) YJ28.B36(TX1P_2)
FC28_TDP1: U1.E45(FC28_TD1P) YJ28.B5(TX4N_2)
FC28_TDP2: U1.C46(FC28_TD2P) YJ28.B33(TX3P_2)
FC28_TDP3: U1.A45(FC28_TD3P) YJ28.B2(TX2N_2)
FC29_RDN0: U1.G43(FC29_RD0N) YJ28.A15(RX3N_1)
FC29_RDN1: U1.J42(FC29_RD1N) YJ28.A25(RX4P_1)
FC29_RDN2: U1.L43(FC29_RD2N) YJ28.A21(RX2N_1)
FC29_RDN3: U1.N42(FC29_RD3N) YJ28.A17(RX1P_1)
FC29_RDP0: U1.G42(FC29_RD0P) YJ28.A14(RX3P_1)
FC29_RDP1: U1.J43(FC29_RD1P) YJ28.A24(RX4N_1)
FC29_RDP2: U1.L42(FC29_RD2P) YJ28.A22(RX2P_1)
FC29_RDP3: U1.N43(FC29_RD3P) YJ28.A18(RX1N_1)
FC29_TDN0: U1.E41(FC29_TD0N) YJ28.A37(TX1N_1)
FC29_TDN1: U1.C42(FC29_TD1N) YJ28.A33(TX3P_1)
FC29_TDN2: U1.A41(FC29_TD2N) YJ28.A2(TX2N_1)
FC29_TDN3: U1.D44(FC29_TD3N) YJ28.A6(TX4P_1)
FC29_TDP0: U1.E42(FC29_TD0P) YJ28.A36(TX1P_1)
FC29_TDP1: U1.C41(FC29_TD1P) YJ28.A34(TX3N_1)
FC29_TDP2: U1.A42(FC29_TD2P) YJ28.A3(TX2P_1)
FC29_TDP3: U1.D43(FC29_TD3P) YJ28.A5(TX4N_1)
FC30_31_PVDD0P8: C2682.1 C2727.1 C3332.1 L48.1 U1.Y36(FC31_PVDD0P8) U1.Y39(FC30_PVDD0P8)
FC30_RDN0: U1.H40(FC30_RD0N) YJ27.C25(RX4P_3)
FC30_RDN1: U1.K39(FC30_RD1N) YJ27.C18(RX1N_3)
FC30_RDN2: U1.M40(FC30_RD2N) YJ27.C22(RX2P_3)
FC30_RDN3: U1.P39(FC30_RD3N) YJ27.C15(RX3N_3)
FC30_RDP0: U1.H39(FC30_RD0P) YJ27.C24(RX4N_3)
FC30_RDP1: U1.K40(FC30_RD1P) YJ27.C17(RX1P_3)
FC30_RDP2: U1.M39(FC30_RD2P) YJ27.C21(RX2N_3)
FC30_RDP3: U1.P40(FC30_RD3P) YJ27.C14(RX3P_3)
FC30_TDN0: U1.A37(FC30_TD0N) YJ27.C6(TX4P_3)
FC30_TDN1: U1.F40(FC30_TD1N) YJ27.C37(TX1N_3)
FC30_TDN2: U1.D39(FC30_TD2N) YJ27.C3(TX2P_3)
FC30_TDN3: U1.B40(FC30_TD3N) YJ27.C34(TX3N_3)
FC30_TDP0: U1.A38(FC30_TD0P) YJ27.C5(TX4N_3)
FC30_TDP1: U1.F39(FC30_TD1P) YJ27.C36(TX1P_3)
FC30_TDP2: U1.D40(FC30_TD2P) YJ27.C2(TX2N_3)
FC30_TDP3: U1.B39(FC30_TD3P) YJ27.C33(TX3P_3)
FC31_RDN0: U1.G37(FC31_RD0N) YJ27.D17(RX1P_4)
FC31_RDN1: U1.J36(FC31_RD1N) YJ27.D21(RX2N_4)
FC31_RDN2: U1.L37(FC31_RD2N) YJ27.D25(RX4P_4)
FC31_RDN3: U1.N36(FC31_RD3N) YJ27.D15(RX3N_4)
FC31_RDP0: U1.G36(FC31_RD0P) YJ27.D18(RX1N_4)
FC31_RDP1: U1.J37(FC31_RD1P) YJ27.D22(RX2P_4)
FC31_RDP2: U1.L36(FC31_RD2P) YJ27.D24(RX4N_4)
FC31_RDP3: U1.N37(FC31_RD3P) YJ27.D14(RX3P_4)
FC31_TDN0: U1.D35(FC31_TD0N) YJ27.D6(TX4P_4)
FC31_TDN1: U1.B36(FC31_TD1N) YJ27.D2(TX2N_4)
FC31_TDN2: U1.E37(FC31_TD2N) YJ27.D33(TX3P_4)
FC31_TDN3: U1.C38(FC31_TD3N) YJ27.D37(TX1N_4)
FC31_TDP0: U1.D36(FC31_TD0P) YJ27.D5(TX4N_4)
FC31_TDP1: U1.B35(FC31_TD1P) YJ27.D3(TX2P_4)
FC31_TDP2: U1.E38(FC31_TD2P) YJ27.D34(TX3N_4)
FC31_TDP3: U1.C37(FC31_TD3P) YJ27.D36(TX1P_4)
FC32_33_PVDD0P8: C3029.1 C3077.1 C3336.1 L49.1 U1.Y29(FC33_PVDD0P8) U1.Y31(FC32_PVDD0P8)
FC32_47_PVDD1P8: C2665.1 C2717.1 C2777.1 C2795.1 C2853.1 C2887.1 C2953.1 C2977.1 C3114.1 L438.1 U1.AC18(FC40-41_PVDD1P8) U1.AF18(FC42-43_PVDD1P8) U1.AJ18(FC44-45_PVDD1P8) U1.AM18(FC46-47_PVDD1P8) U1.Y21(FC38-39_PVDD1P8) U1.Y24(FC36-37_PVDD1P8) U1.Y27(FC34-35_PVDD1P8) U1.Y30(FC32-33_PVDD1P8)
FC32_RDN0: U1.G33(FC32_RD0N) YJ30.D22(RX2P_4)
FC32_RDN1: U1.J34(FC32_RD1N) YJ30.D18(RX1N_4)
FC32_RDN2: U1.L33(FC32_RD2N) YJ30.D25(RX4P_4)
FC32_RDN3: U1.N34(FC32_RD3N) YJ30.D15(RX3N_4)
FC32_RDP0: U1.G34(FC32_RD0P) YJ30.D21(RX2N_4)
FC32_RDP1: U1.J33(FC32_RD1P) YJ30.D17(RX1P_4)
FC32_RDP2: U1.L34(FC32_RD2P) YJ30.D24(RX4N_4)
FC32_RDP3: U1.N33(FC32_RD3P) YJ30.D14(RX3P_4)
FC32_TDN0: U1.A34(FC32_TD0N) YJ30.D3(TX2P_4)
FC32_TDN1: U1.C33(FC32_TD1N) YJ30.D34(TX3N_4)
FC32_TDN2: U1.E34(FC32_TD2N) YJ30.D6(TX4P_4)
FC32_TDN3: U1.B31(FC32_TD3N) YJ30.D37(TX1N_4)
FC32_TDP0: U1.A33(FC32_TD0P) YJ30.D2(TX2N_4)
FC32_TDP1: U1.C34(FC32_TD1P) YJ30.D33(TX3P_4)
FC32_TDP2: U1.E33(FC32_TD2P) YJ30.D5(TX4N_4)
FC32_TDP3: U1.B32(FC32_TD3P) YJ30.D36(TX1P_4)
FC33_RDN0: U1.G30(FC33_RD0N) YJ30.C17(RX1P_3)
FC33_RDN1: U1.J31(FC33_RD1N) YJ30.C21(RX2N_3)
FC33_RDN2: U1.L30(FC33_RD2N) YJ30.C25(RX4P_3)
FC33_RDN3: U1.N31(FC33_RD3N) YJ30.C15(RX3N_3)
FC33_RDP0: U1.G31(FC33_RD0P) YJ30.C18(RX1N_3)
FC33_RDP1: U1.J30(FC33_RD1P) YJ30.C22(RX2P_3)
FC33_RDP2: U1.L31(FC33_RD2P) YJ30.C24(RX4N_3)
FC33_RDP3: U1.N30(FC33_RD3P) YJ30.C14(RX3P_3)
FC33_TDN0: U1.D32(FC33_TD0N) YJ30.C3(TX2P_3)
FC33_TDN1: U1.A29(FC33_TD1N) YJ30.C5(TX4N_3)
FC33_TDN2: U1.C30(FC33_TD2N) YJ30.C36(TX1P_3)
FC33_TDN3: U1.E29(FC33_TD3N) YJ30.C34(TX3N_3)
FC33_TDP0: U1.D31(FC33_TD0P) YJ30.C2(TX2N_3)
FC33_TDP1: U1.A30(FC33_TD1P) YJ30.C6(TX4P_3)
FC33_TDP2: U1.C29(FC33_TD2P) YJ30.C37(TX1N_3)
FC33_TDP3: U1.E30(FC33_TD3P) YJ30.C33(TX3P_3)
FC34_35_PVDD0P8: C3054.1 C3099.1 C3340.1 L50.1 U1.Y26(FC35_PVDD0P8) U1.Y28(FC34_PVDD0P8)
FC34_RDN0: U1.H27(FC34_RD0N) YJ29.A21(RX2N_1)
FC34_RDN1: U1.K28(FC34_RD1N) YJ29.A14(RX3P_1)
FC34_RDN2: U1.M27(FC34_RD2N) YJ29.A24(RX4N_1)
FC34_RDN3: U1.P28(FC34_RD3N) YJ29.A17(RX1P_1)
FC34_RDP0: U1.H28(FC34_RD0P) YJ29.A22(RX2P_1)
FC34_RDP1: U1.K27(FC34_RD1P) YJ29.A15(RX3N_1)
FC34_RDP2: U1.M28(FC34_RD2P) YJ29.A25(RX4P_1)
FC34_RDP3: U1.P27(FC34_RD3P) YJ29.A18(RX1N_1)
FC34_TDN0: U1.B28(FC34_TD0N) YJ29.A37(TX1N_1)
FC34_TDN1: U1.D27(FC34_TD1N) YJ29.A6(TX4P_1)
FC34_TDN2: U1.F28(FC34_TD2N) YJ29.A34(TX3N_1)
FC34_TDN3: U1.A25(FC34_TD3N) YJ29.A3(TX2P_1)
FC34_TDP0: U1.B27(FC34_TD0P) YJ29.A36(TX1P_1)
FC34_TDP1: U1.D28(FC34_TD1P) YJ29.A5(TX4N_1)
FC34_TDP2: U1.F27(FC34_TD2P) YJ29.A33(TX3P_1)
FC34_TDP3: U1.A26(FC34_TD3P) YJ29.A2(TX2N_1)
FC35_RDN0: U1.G24(FC35_RD0N) YJ29.B18(RX1N_2)
FC35_RDN1: U1.J25(FC35_RD1N) YJ29.B22(RX2P_2)
FC35_RDN2: U1.L24(FC35_RD2N) YJ29.B24(RX4N_2)
FC35_RDN3: U1.N25(FC35_RD3N) YJ29.B14(RX3P_2)
FC35_RDP0: U1.G25(FC35_RD0P) YJ29.B17(RX1P_2)
FC35_RDP1: U1.J24(FC35_RD1P) YJ29.B21(RX2N_2)
FC35_RDP2: U1.L25(FC35_RD2P) YJ29.B25(RX4P_2)
FC35_RDP3: U1.N24(FC35_RD3P) YJ29.B15(RX3N_2)
FC35_TDN0: U1.C26(FC35_TD0N) YJ29.B37(TX1N_2)
FC35_TDN1: U1.E25(FC35_TD1N) YJ29.B33(TX3P_2)
FC35_TDN2: U1.B24(FC35_TD2N) YJ29.B2(TX2N_2)
FC35_TDN3: U1.D23(FC35_TD3N) YJ29.B6(TX4P_2)
FC35_TDP0: U1.C25(FC35_TD0P) YJ29.B36(TX1P_2)
FC35_TDP1: U1.E26(FC35_TD1P) YJ29.B34(TX3N_2)
FC35_TDP2: U1.B23(FC35_TD2P) YJ29.B3(TX2P_2)
FC35_TDP3: U1.D24(FC35_TD3P) YJ29.B5(TX4N_2)
FC36_37_PVDD0P8: C2815.1 C2858.1 C3344.1 L51.1 U1.Y23(FC37_PVDD0P8) U1.Y25(FC36_PVDD0P8)
FC36_RDN0: U1.G21(FC36_RD0N) YJ30.B22(RX2P_2)
FC36_RDN1: U1.J22(FC36_RD1N) YJ30.B18(RX1N_2)
FC36_RDN2: U1.L21(FC36_RD2N) YJ30.B25(RX4P_2)
FC36_RDN3: U1.N22(FC36_RD3N) YJ30.B15(RX3N_2)
FC36_RDP0: U1.G22(FC36_RD0P) YJ30.B21(RX2N_2)
FC36_RDP1: U1.J21(FC36_RD1P) YJ30.B17(RX1P_2)
FC36_RDP2: U1.L22(FC36_RD2P) YJ30.B24(RX4N_2)
FC36_RDP3: U1.N21(FC36_RD3P) YJ30.B14(RX3P_2)
FC36_TDN0: U1.A22(FC36_TD0N) YJ30.B3(TX2P_2)
FC36_TDN1: U1.C21(FC36_TD1N) YJ30.B34(TX3N_2)
FC36_TDN2: U1.E22(FC36_TD2N) YJ30.B6(TX4P_2)
FC36_TDN3: U1.B19(FC36_TD3N) YJ30.B37(TX1N_2)
FC36_TDP0: U1.A21(FC36_TD0P) YJ30.B2(TX2N_2)
FC36_TDP1: U1.C22(FC36_TD1P) YJ30.B33(TX3P_2)
FC36_TDP2: U1.E21(FC36_TD2P) YJ30.B5(TX4N_2)
FC36_TDP3: U1.B20(FC36_TD3P) YJ30.B36(TX1P_2)
FC37_RDN0: U1.G18(FC37_RD0N) YJ30.A14(RX3P_1)
FC37_RDN1: U1.J19(FC37_RD1N) YJ30.A24(RX4N_1)
FC37_RDN2: U1.L18(FC37_RD2N) YJ30.A22(RX2P_1)
FC37_RDN3: U1.N19(FC37_RD3N) YJ30.A18(RX1N_1)
FC37_RDP0: U1.G19(FC37_RD0P) YJ30.A15(RX3N_1)
FC37_RDP1: U1.J18(FC37_RD1P) YJ30.A25(RX4P_1)
FC37_RDP2: U1.L19(FC37_RD2P) YJ30.A21(RX2N_1)
FC37_RDP3: U1.N18(FC37_RD3P) YJ30.A17(RX1P_1)
FC37_TDN0: U1.D20(FC37_TD0N) YJ30.A6(TX4P_1)
FC37_TDN1: U1.A17(FC37_TD1N) YJ30.A2(TX2N_1)
FC37_TDN2: U1.C18(FC37_TD2N) YJ30.A33(TX3P_1)
FC37_TDN3: U1.E17(FC37_TD3N) YJ30.A37(TX1N_1)
FC37_TDP0: U1.D19(FC37_TD0P) YJ30.A5(TX4N_1)
FC37_TDP1: U1.A18(FC37_TD1P) YJ30.A3(TX2P_1)
FC37_TDP2: U1.C17(FC37_TD2P) YJ30.A34(TX3N_1)
FC37_TDP3: U1.E18(FC37_TD3P) YJ30.A36(TX1P_1)
FC38_39_PVDD0P8: C3123.1 C3164.1 C3318.1 L52.1 U1.Y20(FC39_PVDD0P8) U1.Y22(FC38_PVDD0P8)
FC38_RDN0: U1.C14(FC38_RD0N) YJ29.C21(RX2N_3)
FC38_RDN1: U1.B12(FC38_RD1N) YJ29.C14(RX3P_3)
FC38_RDN2: U1.C10(FC38_RD2N) YJ29.C24(RX4N_3)
FC38_RDN3: U1.B8(FC38_RD3N) YJ29.C17(RX1P_3)
FC38_RDP0: U1.B14(FC38_RD0P) YJ29.C22(RX2P_3)
FC38_RDP1: U1.C12(FC38_RD1P) YJ29.C15(RX3N_3)
FC38_RDP2: U1.B10(FC38_RD2P) YJ29.C25(RX4P_3)
FC38_RDP3: U1.C8(FC38_RD3P) YJ29.C18(RX1N_3)
FC38_TDN0: U1.A4(FC38_TD0N) YJ29.C6(TX4P_3)
FC38_TDN1: U1.B6(FC38_TD1N) YJ29.C34(TX3N_3)
FC38_TDN2: U1.C3(FC38_TD2N) YJ29.C2(TX2N_3)
FC38_TDN3: U1.D5(FC38_TD3N) YJ29.C36(TX1P_3)
FC38_TDP0: U1.B4(FC38_TD0P) YJ29.C5(TX4N_3)
FC38_TDP1: U1.A6(FC38_TD1P) YJ29.C33(TX3P_3)
FC38_TDP2: U1.D3(FC38_TD2P) YJ29.C3(TX2P_3)
FC38_TDP3: U1.C5(FC38_TD3P) YJ29.C37(TX1N_3)
FC39_RDN0: U1.F14(FC39_RD0N) YJ29.D24(RX4N_4)
FC39_RDN1: U1.E10(FC39_RD1N) YJ29.D22(RX2P_4)
FC39_RDN2: U1.F12(FC39_RD2N) YJ29.D15(RX3N_4)
FC39_RDN3: U1.E8(FC39_RD3N) YJ29.D17(RX1P_4)
FC39_RDP0: U1.E14(FC39_RD0P) YJ29.D25(RX4P_4)
FC39_RDP1: U1.F10(FC39_RD1P) YJ29.D21(RX2N_4)
FC39_RDP2: U1.E12(FC39_RD2P) YJ29.D14(RX3P_4)
FC39_RDP3: U1.F8(FC39_RD3P) YJ29.D18(RX1N_4)
FC39_TDN0: U1.E2(FC39_TD0N) YJ29.D2(TX2N_4)
FC39_TDN1: U1.F4(FC39_TD1N) YJ29.D33(TX3P_4)
FC39_TDN2: U1.E6(FC39_TD2N) YJ29.D5(TX4N_4)
FC39_TDN3: U1.D1(FC39_TD3N) YJ29.D36(TX1P_4)
FC39_TDP0: U1.F2(FC39_TD0P) YJ29.D3(TX2P_4)
FC39_TDP1: U1.E4(FC39_TD1P) YJ29.D34(TX3N_4)
FC39_TDP2: U1.F6(FC39_TD2P) YJ29.D6(TX4P_4)
FC39_TDP3: U1.C1(FC39_TD3P) YJ29.D37(TX1N_4)
FC40_41_PVDD0P8: C2716.1 C2757.1 C3325.1 L53.1 U1.AB18(FC40_PVDD0P8) U1.AD18(FC41_PVDD0P8)
FC40_RDN0: U1.H13(FC40_RD0N) YJ32.D24(RX4N_4)
FC40_RDN1: U1.J9(FC40_RD1N) YJ32.D17(RX1P_4)
FC40_RDN2: U1.H11(FC40_RD2N) YJ32.D15(RX3N_4)
FC40_RDN3: U1.J7(FC40_RD3N) YJ32.D22(RX2P_4)
FC40_RDP0: U1.J13(FC40_RD0P) YJ32.D25(RX4P_4)
FC40_RDP1: U1.H9(FC40_RD1P) YJ32.D18(RX1N_4)
FC40_RDP2: U1.J11(FC40_RD2P) YJ32.D14(RX3P_4)
FC40_RDP3: U1.H7(FC40_RD3P) YJ32.D21(RX2N_4)
FC40_TDN0: U1.K4(FC40_TD0N) YJ32.D34(TX3N_4)
FC40_TDN1: U1.G1(FC40_TD1N) YJ32.D3(TX2P_4)
FC40_TDN2: U1.H3(FC40_TD2N) YJ32.D37(TX1N_4)
FC40_TDN3: U1.G5(FC40_TD3N) YJ32.D6(TX4P_4)
FC40_TDP0: U1.J4(FC40_TD0P) YJ32.D33(TX3P_4)
FC40_TDP1: U1.H1(FC40_TD1P) YJ32.D2(TX2N_4)
FC40_TDP2: U1.G3(FC40_TD2P) YJ32.D36(TX1P_4)
FC40_TDP3: U1.H5(FC40_TD3P) YJ32.D5(TX4N_4)
FC41_RDN0: U1.M13(FC41_RD0N) YJ32.C25(RX4P_3)
FC41_RDN1: U1.L9(FC41_RD1N) YJ32.C18(RX1N_3)
FC41_RDN2: U1.M11(FC41_RD2N) YJ32.C14(RX3P_3)
FC41_RDN3: U1.L7(FC41_RD3N) YJ32.C21(RX2N_3)
FC41_RDP0: U1.L13(FC41_RD0P) YJ32.C24(RX4N_3)
FC41_RDP1: U1.M9(FC41_RD1P) YJ32.C17(RX1P_3)
FC41_RDP2: U1.L11(FC41_RD2P) YJ32.C15(RX3N_3)
FC41_RDP3: U1.M7(FC41_RD3P) YJ32.C22(RX2P_3)
FC41_TDN0: U1.L1(FC41_TD0N) YJ32.C36(TX1P_3)
FC41_TDN1: U1.M3(FC41_TD1N) YJ32.C2(TX2N_3)
FC41_TDN2: U1.L5(FC41_TD2N) YJ32.C33(TX3P_3)
FC41_TDN3: U1.K2(FC41_TD3N) YJ32.C5(TX4N_3)
FC41_TDP0: U1.M1(FC41_TD0P) YJ32.C37(TX1N_3)
FC41_TDP1: U1.L3(FC41_TD1P) YJ32.C3(TX2P_3)
FC41_TDP2: U1.M5(FC41_TD2P) YJ32.C34(TX3N_3)
FC41_TDP3: U1.J2(FC41_TD3P) YJ32.C6(TX4P_3)
FC42_43_PVDD0P8: C2877.1 C2932.1 C3330.1 L54.1 U1.AE18(FC42_PVDD0P8) U1.AG18(FC43_PVDD0P8)
FC42_RDN0: U1.P13(FC42_RD0N) YJ31.A25(RX4P_1)
FC42_RDN1: U1.R9(FC42_RD1N) YJ31.A15(RX3N_1)
FC42_RDN2: U1.P11(FC42_RD2N) YJ31.A17(RX1P_1)
FC42_RDN3: U1.R7(FC42_RD3N) YJ31.A21(RX2N_1)
FC42_RDP0: U1.R13(FC42_RD0P) YJ31.A24(RX4N_1)
FC42_RDP1: U1.P9(FC42_RD1P) YJ31.A14(RX3P_1)
FC42_RDP2: U1.R11(FC42_RD2P) YJ31.A18(RX1N_1)
FC42_RDP3: U1.P7(FC42_RD3P) YJ31.A22(RX2P_1)
FC42_TDN0: U1.P4(FC42_TD0N) YJ31.A33(TX3P_1)
FC42_TDN1: U1.N2(FC42_TD1N) YJ31.A37(TX1N_1)
FC42_TDN2: U1.T5(FC42_TD2N) YJ31.A6(TX4P_1)
FC42_TDN3: U1.R3(FC42_TD3N) YJ31.A2(TX2N_1)
FC42_TDP0: U1.N4(FC42_TD0P) YJ31.A34(TX3N_1)
FC42_TDP1: U1.P2(FC42_TD1P) YJ31.A36(TX1P_1)
FC42_TDP2: U1.R5(FC42_TD2P) YJ31.A5(TX4N_1)
FC42_TDP3: U1.T3(FC42_TD3P) YJ31.A3(TX2P_1)
FC43_RDN0: U1.V14(FC43_RD0N) YJ31.B24(RX4N_2)
FC43_RDN1: U1.U10(FC43_RD1N) YJ31.B22(RX2P_2)
FC43_RDN2: U1.V12(FC43_RD2N) YJ31.B15(RX3N_2)
FC43_RDN3: U1.U8(FC43_RD3N) YJ31.B17(RX1P_2)
FC43_RDP0: U1.U14(FC43_RD0P) YJ31.B25(RX4P_2)
FC43_RDP1: U1.V10(FC43_RD1P) YJ31.B21(RX2N_2)
FC43_RDP2: U1.U12(FC43_RD2P) YJ31.B14(RX3P_2)
FC43_RDP3: U1.V8(FC43_RD3P) YJ31.B18(RX1N_2)
FC43_TDN0: U1.R1(FC43_TD0N) YJ31.B37(TX1N_2)
FC43_TDN1: U1.V6(FC43_TD1N) YJ31.B6(TX4P_2)
FC43_TDN2: U1.U4(FC43_TD2N) YJ31.B34(TX3N_2)
FC43_TDN3: U1.V2(FC43_TD3N) YJ31.B3(TX2P_2)
FC43_TDP0: U1.T1(FC43_TD0P) YJ31.B36(TX1P_2)
FC43_TDP1: U1.U6(FC43_TD1P) YJ31.B5(TX4N_2)
FC43_TDP2: U1.V4(FC43_TD2P) YJ31.B33(TX3P_2)
FC43_TDP3: U1.U2(FC43_TD3P) YJ31.B2(TX2N_2)
FC44_45_PVDD0P8: C2699.1 C3195.1 C3337.1 L55.1 U1.AH18(FC44_PVDD0P8) U1.AK18(FC45_PVDD0P8)
FC44_RDN0: U1.Y13(FC44_RD0N) YJ32.B24(RX4N_2)
FC44_RDN1: U1.AA9(FC44_RD1N) YJ32.B17(RX1P_2)
FC44_RDN2: U1.Y11(FC44_RD2N) YJ32.B15(RX3N_2)
FC44_RDN3: U1.AA7(FC44_RD3N) YJ32.B22(RX2P_2)
FC44_RDP0: U1.AA13(FC44_RD0P) YJ32.B25(RX4P_2)
FC44_RDP1: U1.Y9(FC44_RD1P) YJ32.B18(RX1N_2)
FC44_RDP2: U1.AA11(FC44_RD2P) YJ32.B14(RX3P_2)
FC44_RDP3: U1.Y7(FC44_RD3P) YJ32.B21(RX2N_2)
FC44_TDN0: U1.AB4(FC44_TD0N) YJ32.B34(TX3N_2)
FC44_TDN1: U1.W1(FC44_TD1N) YJ32.B3(TX2P_2)
FC44_TDN2: U1.Y3(FC44_TD2N) YJ32.B37(TX1N_2)
FC44_TDN3: U1.W5(FC44_TD3N) YJ32.B6(TX4P_2)
FC44_TDP0: U1.AA4(FC44_TD0P) YJ32.B33(TX3P_2)
FC44_TDP1: U1.Y1(FC44_TD1P) YJ32.B2(TX2N_2)
FC44_TDP2: U1.W3(FC44_TD2P) YJ32.B36(TX1P_2)
FC44_TDP3: U1.Y5(FC44_TD3P) YJ32.B5(TX4N_2)
FC45_RDN0: U1.AD13(FC45_RD0N) YJ32.A22(RX2P_1)
FC45_RDN1: U1.AC9(FC45_RD1N) YJ32.A15(RX3N_1)
FC45_RDN2: U1.AD11(FC45_RD2N) YJ32.A17(RX1P_1)
FC45_RDN3: U1.AC7(FC45_RD3N) YJ32.A24(RX4N_1)
FC45_RDP0: U1.AC13(FC45_RD0P) YJ32.A21(RX2N_1)
FC45_RDP1: U1.AD9(FC45_RD1P) YJ32.A14(RX3P_1)
FC45_RDP2: U1.AC11(FC45_RD2P) YJ32.A18(RX1N_1)
FC45_RDP3: U1.AD7(FC45_RD3P) YJ32.A25(RX4P_1)
FC45_TDN0: U1.AC1(FC45_TD0N) YJ32.A33(TX3P_1)
FC45_TDN1: U1.AD3(FC45_TD1N) YJ32.A5(TX4N_1)
FC45_TDN2: U1.AC5(FC45_TD2N) YJ32.A36(TX1P_1)
FC45_TDN3: U1.AB2(FC45_TD3N) YJ32.A2(TX2N_1)
FC45_TDP0: U1.AD1(FC45_TD0P) YJ32.A34(TX3N_1)
FC45_TDP1: U1.AC3(FC45_TD1P) YJ32.A6(TX4P_1)
FC45_TDP2: U1.AD5(FC45_TD2P) YJ32.A37(TX1N_1)
FC45_TDP3: U1.AA2(FC45_TD3P) YJ32.A3(TX2P_1)
FC46_47_PVDD0P8: C2944.1 C3008.1 C3343.1 L56.1 U1.AL18(FC46_PVDD0P8) U1.AP18(FC47_PVDD0P8)
FC46_RDN0: U1.AF13(FC46_RD0N) YJ31.C22(RX2P_3)
FC46_RDN1: U1.AG9(FC46_RD1N) YJ31.C18(RX1N_3)
FC46_RDN2: U1.AF11(FC46_RD2N) YJ31.C14(RX3P_3)
FC46_RDN3: U1.AG7(FC46_RD3N) YJ31.C24(RX4N_3)
FC46_RDP0: U1.AG13(FC46_RD0P) YJ31.C21(RX2N_3)
FC46_RDP1: U1.AF9(FC46_RD1P) YJ31.C17(RX1P_3)
FC46_RDP2: U1.AG11(FC46_RD2P) YJ31.C15(RX3N_3)
FC46_RDP3: U1.AF7(FC46_RD3P) YJ31.C25(RX4P_3)
FC46_TDN0: U1.AF4(FC46_TD0N) YJ31.C36(TX1P_3)
FC46_TDN1: U1.AE2(FC46_TD1N) YJ31.C34(TX3N_3)
FC46_TDN2: U1.AH5(FC46_TD2N) YJ31.C3(TX2P_3)
FC46_TDN3: U1.AG3(FC46_TD3N) YJ31.C5(TX4N_3)
FC46_TDP0: U1.AE4(FC46_TD0P) YJ31.C37(TX1N_3)
FC46_TDP1: U1.AF2(FC46_TD1P) YJ31.C33(TX3P_3)
FC46_TDP2: U1.AG5(FC46_TD2P) YJ31.C2(TX2N_3)
FC46_TDP3: U1.AH3(FC46_TD3P) YJ31.C6(TX4P_3)
FC47_RDN0: U1.AK14(FC47_RD0N) YJ31.D24(RX4N_4)
FC47_RDN1: U1.AJ10(FC47_RD1N) YJ31.D22(RX2P_4)
FC47_RDN2: U1.AK12(FC47_RD2N) YJ31.D15(RX3N_4)
FC47_RDN3: U1.AJ8(FC47_RD3N) YJ31.D17(RX1P_4)
FC47_RDP0: U1.AJ14(FC47_RD0P) YJ31.D25(RX4P_4)
FC47_RDP1: U1.AK10(FC47_RD1P) YJ31.D21(RX2N_4)
FC47_RDP2: U1.AJ12(FC47_RD2P) YJ31.D14(RX3P_4)
FC47_RDP3: U1.AK8(FC47_RD3P) YJ31.D18(RX1N_4)
FC47_TDN0: U1.AJ2(FC47_TD0N) YJ31.D2(TX2N_4)
FC47_TDN1: U1.AK4(FC47_TD1N) YJ31.D33(TX3P_4)
FC47_TDN2: U1.AJ6(FC47_TD2N) YJ31.D5(TX4N_4)
FC47_TDN3: U1.AH1(FC47_TD3N) YJ31.D36(TX1P_4)
FC47_TDP0: U1.AK2(FC47_TD0P) YJ31.D3(TX2P_4)
FC47_TDP1: U1.AJ4(FC47_TD1P) YJ31.D34(TX3N_4)
FC47_TDP2: U1.AK6(FC47_TD2P) YJ31.D6(TX4P_4)
FC47_TDP3: U1.AG1(FC47_TD3P) YJ31.D37(TX1N_4)
FC48_49_PVDD0P8: C2722.1 C3155.1 C3317.1 L57.1 U1.AR18(FC48_PVDD0P8) U1.AU18(FC49_PVDD0P8)
FC48_63_PVDD1P8: C2678.1 C2687.1 C2764.1 C2841.1 C2959.1 C3014.1 C3104.1 C3134.1 C3197.1 L436.1 U1.AT18(FC48-49_PVDD1P8) U1.AW18(FC50-51_PVDD1P8) U1.BB18(FC52-53_PVDD1P8) U1.BE18(FC54-55_PVDD1P8) U1.BG20(FC56-57_PVDD1P8) U1.BG22(FC58-59_PVDD1P8) U1.BG25(FC60-61_PVDD1P8) U1.BG28(FC62-63_PVDD1P8)
FC48_RDN0: U1.AM13(FC48_RD0N) YJ34.D24(RX4N_4)
FC48_RDN1: U1.AN9(FC48_RD1N) YJ34.D17(RX1P_4)
FC48_RDN2: U1.AM11(FC48_RD2N) YJ34.D15(RX3N_4)
FC48_RDN3: U1.AN7(FC48_RD3N) YJ34.D22(RX2P_4)
FC48_RDP0: U1.AN13(FC48_RD0P) YJ34.D25(RX4P_4)
FC48_RDP1: U1.AM9(FC48_RD1P) YJ34.D18(RX1N_4)
FC48_RDP2: U1.AN11(FC48_RD2P) YJ34.D14(RX3P_4)
FC48_RDP3: U1.AM7(FC48_RD3P) YJ34.D21(RX2N_4)
FC48_TDN0: U1.AP4(FC48_TD0N) YJ34.D34(TX3N_4)
FC48_TDN1: U1.AL1(FC48_TD1N) YJ34.D3(TX2P_4)
FC48_TDN2: U1.AM3(FC48_TD2N) YJ34.D37(TX1N_4)
FC48_TDN3: U1.AL5(FC48_TD3N) YJ34.D6(TX4P_4)
FC48_TDP0: U1.AN4(FC48_TD0P) YJ34.D33(TX3P_4)
FC48_TDP1: U1.AM1(FC48_TD1P) YJ34.D2(TX2N_4)
FC48_TDP2: U1.AL3(FC48_TD2P) YJ34.D36(TX1P_4)
FC48_TDP3: U1.AM5(FC48_TD3P) YJ34.D5(TX4N_4)
FC49_RDN0: U1.AT13(FC49_RD0N) YJ34.C25(RX4P_3)
FC49_RDN1: U1.AR9(FC49_RD1N) YJ34.C18(RX1N_3)
FC49_RDN2: U1.AT11(FC49_RD2N) YJ34.C14(RX3P_3)
FC49_RDN3: U1.AR7(FC49_RD3N) YJ34.C21(RX2N_3)
FC49_RDP0: U1.AR13(FC49_RD0P) YJ34.C24(RX4N_3)
FC49_RDP1: U1.AT9(FC49_RD1P) YJ34.C17(RX1P_3)
FC49_RDP2: U1.AR11(FC49_RD2P) YJ34.C15(RX3N_3)
FC49_RDP3: U1.AT7(FC49_RD3P) YJ34.C22(RX2P_3)
FC49_TDN0: U1.AR1(FC49_TD0N) YJ34.C36(TX1P_3)
FC49_TDN1: U1.AT3(FC49_TD1N) YJ34.C2(TX2N_3)
FC49_TDN2: U1.AR5(FC49_TD2N) YJ34.C33(TX3P_3)
FC49_TDN3: U1.AP2(FC49_TD3N) YJ34.C5(TX4N_3)
FC49_TDP0: U1.AT1(FC49_TD0P) YJ34.C37(TX1N_3)
FC49_TDP1: U1.AR3(FC49_TD1P) YJ34.C3(TX2P_3)
FC49_TDP2: U1.AT5(FC49_TD2P) YJ34.C34(TX3N_3)
FC49_TDP3: U1.AN2(FC49_TD3P) YJ34.C6(TX4P_3)
FC50_51_PVDD0P8: C2981.1 C3028.1 C3326.1 L58.1 U1.AV18(FC50_PVDD0P8) U1.AY18(FC51_PVDD0P8)
FC50_RDN0: U1.AV13(FC50_RD0N) YJ33.A25(RX4P_1)
FC50_RDN1: U1.AW9(FC50_RD1N) YJ33.A15(RX3N_1)
FC50_RDN2: U1.AV11(FC50_RD2N) YJ33.A17(RX1P_1)
FC50_RDN3: U1.AW7(FC50_RD3N) YJ33.A21(RX2N_1)
FC50_RDP0: U1.AW13(FC50_RD0P) YJ33.A24(RX4N_1)
FC50_RDP1: U1.AV9(FC50_RD1P) YJ33.A14(RX3P_1)
FC50_RDP2: U1.AW11(FC50_RD2P) YJ33.A18(RX1N_1)
FC50_RDP3: U1.AV7(FC50_RD3P) YJ33.A22(RX2P_1)
FC50_TDN0: U1.AV4(FC50_TD0N) YJ33.A33(TX3P_1)
FC50_TDN1: U1.AU2(FC50_TD1N) YJ33.A37(TX1N_1)
FC50_TDN2: U1.AY5(FC50_TD2N) YJ33.A6(TX4P_1)
FC50_TDN3: U1.AW3(FC50_TD3N) YJ33.A2(TX2N_1)
FC50_TDP0: U1.AU4(FC50_TD0P) YJ33.A34(TX3N_1)
FC50_TDP1: U1.AV2(FC50_TD1P) YJ33.A36(TX1P_1)
FC50_TDP2: U1.AW5(FC50_TD2P) YJ33.A5(TX4N_1)
FC50_TDP3: U1.AY3(FC50_TD3P) YJ33.A3(TX2P_1)
FC51_RDN0: U1.BB14(FC51_RD0N) YJ33.B24(RX4N_2)
FC51_RDN1: U1.BA10(FC51_RD1N) YJ33.B22(RX2P_2)
FC51_RDN2: U1.BB12(FC51_RD2N) YJ33.B15(RX3N_2)
FC51_RDN3: U1.BA8(FC51_RD3N) YJ33.B17(RX1P_2)
FC51_RDP0: U1.BA14(FC51_RD0P) YJ33.B25(RX4P_2)
FC51_RDP1: U1.BB10(FC51_RD1P) YJ33.B21(RX2N_2)
FC51_RDP2: U1.BA12(FC51_RD2P) YJ33.B14(RX3P_2)
FC51_RDP3: U1.BB8(FC51_RD3P) YJ33.B18(RX1N_2)
FC51_TDN0: U1.BA2(FC51_TD0N) YJ33.B2(TX2N_2)
FC51_TDN1: U1.BB4(FC51_TD1N) YJ33.B33(TX3P_2)
FC51_TDN2: U1.BA6(FC51_TD2N) YJ33.B5(TX4N_2)
FC51_TDN3: U1.AY1(FC51_TD3N) YJ33.B36(TX1P_2)
FC51_TDP0: U1.BB2(FC51_TD0P) YJ33.B3(TX2P_2)
FC51_TDP1: U1.BA4(FC51_TD1P) YJ33.B34(TX3N_2)
FC51_TDP2: U1.BB6(FC51_TD2P) YJ33.B6(TX4P_2)
FC51_TDP3: U1.AW1(FC51_TD3P) YJ33.B37(TX1N_2)
FC52_53_PVDD0P8: C2742.1 C2785.1 C3333.1 L59.1 U1.BA18(FC52_PVDD0P8) U1.BC18(FC53_PVDD0P8)
FC52_RDN0: U1.BD13(FC52_RD0N) YJ34.B24(RX4N_2)
FC52_RDN1: U1.BE9(FC52_RD1N) YJ34.B17(RX1P_2)
FC52_RDN2: U1.BD11(FC52_RD2N) YJ34.B15(RX3N_2)
FC52_RDN3: U1.BE7(FC52_RD3N) YJ34.B22(RX2P_2)
FC52_RDP0: U1.BE13(FC52_RD0P) YJ34.B25(RX4P_2)
FC52_RDP1: U1.BD9(FC52_RD1P) YJ34.B18(RX1N_2)
FC52_RDP2: U1.BE11(FC52_RD2P) YJ34.B14(RX3P_2)
FC52_RDP3: U1.BD7(FC52_RD3P) YJ34.B21(RX2N_2)
FC52_TDN0: U1.BF4(FC52_TD0N) YJ34.B34(TX3N_2)
FC52_TDN1: U1.BC1(FC52_TD1N) YJ34.B3(TX2P_2)
FC52_TDN2: U1.BD3(FC52_TD2N) YJ34.B37(TX1N_2)
FC52_TDN3: U1.BC5(FC52_TD3N) YJ34.B6(TX4P_2)
FC52_TDP0: U1.BE4(FC52_TD0P) YJ34.B33(TX3P_2)
FC52_TDP1: U1.BD1(FC52_TD1P) YJ34.B2(TX2N_2)
FC52_TDP2: U1.BC3(FC52_TD2P) YJ34.B36(TX1P_2)
FC52_TDP3: U1.BD5(FC52_TD3P) YJ34.B5(TX4N_2)
FC53_RDN0: U1.BH13(FC53_RD0N) YJ34.A22(RX2P_1)
FC53_RDN1: U1.BG9(FC53_RD1N) YJ34.A15(RX3N_1)
FC53_RDN2: U1.BH11(FC53_RD2N) YJ34.A17(RX1P_1)
FC53_RDN3: U1.BG7(FC53_RD3N) YJ34.A24(RX4N_1)
FC53_RDP0: U1.BG13(FC53_RD0P) YJ34.A21(RX2N_1)
FC53_RDP1: U1.BH9(FC53_RD1P) YJ34.A14(RX3P_1)
FC53_RDP2: U1.BG11(FC53_RD2P) YJ34.A18(RX1N_1)
FC53_RDP3: U1.BH7(FC53_RD3P) YJ34.A25(RX4P_1)
FC53_TDN0: U1.BG1(FC53_TD0N) YJ34.A33(TX3P_1)
FC53_TDN1: U1.BH3(FC53_TD1N) YJ34.A5(TX4N_1)
FC53_TDN2: U1.BG5(FC53_TD2N) YJ34.A36(TX1P_1)
FC53_TDN3: U1.BF2(FC53_TD3N) YJ34.A2(TX2N_1)
FC53_TDP0: U1.BH1(FC53_TD0P) YJ34.A34(TX3N_1)
FC53_TDP1: U1.BG3(FC53_TD1P) YJ34.A6(TX4P_1)
FC53_TDP2: U1.BH5(FC53_TD2P) YJ34.A37(TX1N_1)
FC53_TDP3: U1.BE2(FC53_TD3P) YJ34.A3(TX2P_1)
FC54_55_PVDD0P8: C3052.1 C3097.1 C3339.1 L60.1 U1.BD18(FC54_PVDD0P8) U1.BF18(FC55_PVDD0P8)
FC54_RDN0: U1.BK13(FC54_RD0N) YJ33.C22(RX2P_3)
FC54_RDN1: U1.BL9(FC54_RD1N) YJ33.C18(RX1N_3)
FC54_RDN2: U1.BK11(FC54_RD2N) YJ33.C14(RX3P_3)
FC54_RDN3: U1.BL7(FC54_RD3N) YJ33.C24(RX4N_3)
FC54_RDP0: U1.BL13(FC54_RD0P) YJ33.C21(RX2N_3)
FC54_RDP1: U1.BK9(FC54_RD1P) YJ33.C17(RX1P_3)
FC54_RDP2: U1.BL11(FC54_RD2P) YJ33.C15(RX3N_3)
FC54_RDP3: U1.BK7(FC54_RD3P) YJ33.C25(RX4P_3)
FC54_TDN0: U1.BK4(FC54_TD0N) YJ33.C36(TX1P_3)
FC54_TDN1: U1.BJ2(FC54_TD1N) YJ33.C34(TX3N_3)
FC54_TDN2: U1.BM5(FC54_TD2N) YJ33.C3(TX2P_3)
FC54_TDN3: U1.BL3(FC54_TD3N) YJ33.C5(TX4N_3)
FC54_TDP0: U1.BJ4(FC54_TD0P) YJ33.C37(TX1N_3)
FC54_TDP1: U1.BK2(FC54_TD1P) YJ33.C33(TX3P_3)
FC54_TDP2: U1.BL5(FC54_TD2P) YJ33.C2(TX2N_3)
FC54_TDP3: U1.BM3(FC54_TD3P) YJ33.C6(TX4P_3)
FC55_RDN0: U1.BP13(FC55_RD0N) YJ33.D24(RX4N_4)
FC55_RDN1: U1.BN9(FC55_RD1N) YJ33.D22(RX2P_4)
FC55_RDN2: U1.BP11(FC55_RD2N) YJ33.D15(RX3N_4)
FC55_RDN3: U1.BN7(FC55_RD3N) YJ33.D17(RX1P_4)
FC55_RDP0: U1.BN13(FC55_RD0P) YJ33.D25(RX4P_4)
FC55_RDP1: U1.BP9(FC55_RD1P) YJ33.D21(RX2N_4)
FC55_RDP2: U1.BN11(FC55_RD2P) YJ33.D14(RX3P_4)
FC55_RDP3: U1.BP7(FC55_RD3P) YJ33.D18(RX1N_4)
FC55_TDN0: U1.BR5(FC55_TD0N) YJ33.D5(TX4N_4)
FC55_TDN1: U1.BP2(FC55_TD1N) YJ33.D3(TX2P_4)
FC55_TDN2: U1.BN4(FC55_TD2N) YJ33.D34(TX3N_4)
FC55_TDN3: U1.BM1(FC55_TD3N) YJ33.D36(TX1P_4)
FC55_TDP0: U1.BT5(FC55_TD0P) YJ33.D6(TX4P_4)
FC55_TDP1: U1.BN2(FC55_TD1P) YJ33.D2(TX2N_4)
FC55_TDP2: U1.BP4(FC55_TD2P) YJ33.D33(TX3P_4)
FC55_TDP3: U1.BL1(FC55_TD3P) YJ33.D37(TX1N_4)
FC56_57_PVDD0P8: C349.1 C350.1 C3346.1 L61.1 U1.BG18(FC56_PVDD0P8) U1.BG19(FC57_PVDD0P8)
FC56_RDN0: U1.BT14(FC56_RD0N) YJ36.D24(RX4N_4)
FC56_RDN1: U1.BU10(FC56_RD1N) YJ36.D22(RX2P_4)
FC56_RDN2: U1.BT12(FC56_RD2N) YJ36.D15(RX3N_4)
FC56_RDN3: U1.BU8(FC56_RD3N) YJ36.D17(RX1P_4)
FC56_RDP0: U1.BU14(FC56_RD0P) YJ36.D25(RX4P_4)
FC56_RDP1: U1.BT10(FC56_RD1P) YJ36.D21(RX2N_4)
FC56_RDP2: U1.BU12(FC56_RD2P) YJ36.D14(RX3P_4)
FC56_RDP3: U1.BT8(FC56_RD3P) YJ36.D18(RX1N_4)
FC56_TDN0: U1.BV2(FC56_TD0N) YJ36.D37(TX1N_4)
FC56_TDN1: U1.BU4(FC56_TD1N) YJ36.D33(TX3P_4)
FC56_TDN2: U1.BT1(FC56_TD2N) YJ36.D2(TX2N_4)
FC56_TDN3: U1.BR3(FC56_TD3N) YJ36.D6(TX4P_4)
FC56_TDP0: U1.BU2(FC56_TD0P) YJ36.D36(TX1P_4)
FC56_TDP1: U1.BV4(FC56_TD1P) YJ36.D34(TX3N_4)
FC56_TDP2: U1.BR1(FC56_TD2P) YJ36.D3(TX2P_4)
FC56_TDP3: U1.BT3(FC56_TD3P) YJ36.D5(TX4N_4)
FC57_RDN0: U1.CA14(FC57_RD0N) YJ36.C24(RX4N_3)
FC57_RDN1: U1.BW15(FC57_RD1N) YJ36.C14(RX3P_3)
FC57_RDN2: U1.CA11(FC57_RD2N) YJ36.C21(RX2N_3)
FC57_RDN3: U1.BW12(FC57_RD3N) YJ36.C17(RX1P_3)
FC57_RDP0: U1.CA15(FC57_RD0P) YJ36.C25(RX4P_3)
FC57_RDP1: U1.BW14(FC57_RD1P) YJ36.C15(RX3N_3)
FC57_RDP2: U1.CA12(FC57_RD2P) YJ36.C22(RX2P_3)
FC57_RDP3: U1.BW11(FC57_RD3P) YJ36.C18(RX1N_3)
FC57_TDN0: U1.BY5(FC57_TD0N) YJ36.C34(TX3N_3)
FC57_TDN1: U1.BW3(FC57_TD1N) YJ36.C36(TX1P_3)
FC57_TDN2: U1.BY1(FC57_TD2N) YJ36.C5(TX4N_3)
FC57_TDN3: U1.BU6(FC57_TD3N) YJ36.C3(TX2P_3)
FC57_TDP0: U1.BW5(FC57_TD0P) YJ36.C33(TX3P_3)
FC57_TDP1: U1.BY3(FC57_TD1P) YJ36.C37(TX1N_3)
FC57_TDP2: U1.BW1(FC57_TD2P) YJ36.C6(TX4P_3)
FC57_TDP3: U1.BV6(FC57_TD3P) YJ36.C2(TX2N_3)
FC58_59_PVDD0P8: C352.1 C2805.1 C3322.1 L62.1 U1.BG21(FC58_PVDD0P8) U1.BG23(FC59_PVDD0P8)
FC58_RDN0: U1.CE8(FC58_RD0N) YJ35.A14(RX3P_1)
FC58_RDN1: U1.CC9(FC58_RD1N) YJ35.A21(RX2N_1)
FC58_RDN2: U1.CA8(FC58_RD2N) YJ35.A17(RX1P_1)
FC58_RDN3: U1.BW9(FC58_RD3N) YJ35.A24(RX4N_1)
FC58_RDP0: U1.CE9(FC58_RD0P) YJ35.A15(RX3N_1)
FC58_RDP1: U1.CC8(FC58_RD1P) YJ35.A22(RX2P_1)
FC58_RDP2: U1.CA9(FC58_RD2P) YJ35.A18(RX1N_1)
FC58_RDP3: U1.BW8(FC58_RD3P) YJ35.A25(RX4P_1)
FC58_TDN0: U1.CD1(FC58_TD0N) YJ35.A3(TX2P_1)
FC58_TDN1: U1.CA6(FC58_TD1N) YJ35.A5(TX4N_1)
FC58_TDN2: U1.CB4(FC58_TD2N) YJ35.A33(TX3P_1)
FC58_TDN3: U1.CA2(FC58_TD3N) YJ35.A37(TX1N_1)
FC58_TDP0: U1.CC1(FC58_TD0P) YJ35.A2(TX2N_1)
FC58_TDP1: U1.CB6(FC58_TD1P) YJ35.A6(TX4P_1)
FC58_TDP2: U1.CA4(FC58_TD2P) YJ35.A34(TX3N_1)
FC58_TDP3: U1.CB2(FC58_TD3P) YJ35.A36(TX1P_1)
FC59_RDN0: U1.CE14(FC59_RD0N) YJ35.B17(RX1P_2)
FC59_RDN1: U1.CE12(FC59_RD1N) YJ35.B21(RX2N_2)
FC59_RDN2: U1.CC14(FC59_RD2N) YJ35.B14(RX3P_2)
FC59_RDN3: U1.CC12(FC59_RD3N) YJ35.B24(RX4N_2)
FC59_RDP0: U1.CE15(FC59_RD0P) YJ35.B18(RX1N_2)
FC59_RDP1: U1.CE11(FC59_RD1P) YJ35.B22(RX2P_2)
FC59_RDP2: U1.CC15(FC59_RD2P) YJ35.B15(RX3N_2)
FC59_RDP3: U1.CC11(FC59_RD3P) YJ35.B25(RX4P_2)
FC59_TDN0: U1.CF4(FC59_TD0N) YJ35.B36(TX1P_2)
FC59_TDN1: U1.CE6(FC59_TD1N) YJ35.B2(TX2N_2)
FC59_TDN2: U1.CD3(FC59_TD2N) YJ35.B33(TX3P_2)
FC59_TDN3: U1.CC5(FC59_TD3N) YJ35.B5(TX4N_2)
FC59_TDP0: U1.CE4(FC59_TD0P) YJ35.B37(TX1N_2)
FC59_TDP1: U1.CF6(FC59_TD1P) YJ35.B3(TX2P_2)
FC59_TDP2: U1.CC3(FC59_TD2P) YJ35.B34(TX3N_2)
FC59_TDP3: U1.CD5(FC59_TD3P) YJ35.B6(TX4P_2)
FC60_61_PVDD0P8: C3121.1 C3162.1 C3329.1 L63.1 U1.BG24(FC60_PVDD0P8) U1.BG26(FC61_PVDD0P8)
FC60_RDN0: U1.BY18(FC60_RD0N) YJ36.B21(RX2N_2)
FC60_RDN1: U1.BV19(FC60_RD1N) YJ36.B17(RX1P_2)
FC60_RDN2: U1.BT18(FC60_RD2N) YJ36.B24(RX4N_2)
FC60_RDN3: U1.BP19(FC60_RD3N) YJ36.B14(RX3P_2)
FC60_RDP0: U1.BY19(FC60_RD0P) YJ36.B22(RX2P_2)
FC60_RDP1: U1.BV18(FC60_RD1P) YJ36.B18(RX1N_2)
FC60_RDP2: U1.BT19(FC60_RD2P) YJ36.B25(RX4P_2)
FC60_RDP3: U1.BP18(FC60_RD3P) YJ36.B15(RX3N_2)
FC60_TDN0: U1.CC20(FC60_TD0N) YJ36.B34(TX3N_2)
FC60_TDN1: U1.CF17(FC60_TD1N) YJ36.B36(TX1P_2)
FC60_TDN2: U1.CD18(FC60_TD2N) YJ36.B2(TX2N_2)
FC60_TDN3: U1.CB17(FC60_TD3N) YJ36.B6(TX4P_2)
FC60_TDP0: U1.CC19(FC60_TD0P) YJ36.B33(TX3P_2)
FC60_TDP1: U1.CF18(FC60_TD1P) YJ36.B37(TX1N_2)
FC60_TDP2: U1.CD17(FC60_TD2P) YJ36.B3(TX2P_2)
FC60_TDP3: U1.CB18(FC60_TD3P) YJ36.B5(TX4N_2)
FC61_RDN0: U1.BY21(FC61_RD0N) YJ36.A24(RX4N_1)
FC61_RDN1: U1.BV22(FC61_RD1N) YJ36.A14(RX3P_1)
FC61_RDN2: U1.BT21(FC61_RD2N) YJ36.A21(RX2N_1)
FC61_RDN3: U1.BP22(FC61_RD3N) YJ36.A17(RX1P_1)
FC61_RDP0: U1.BY22(FC61_RD0P) YJ36.A25(RX4P_1)
FC61_RDP1: U1.BV21(FC61_RD1P) YJ36.A15(RX3N_1)
FC61_RDP2: U1.BT22(FC61_RD2P) YJ36.A22(RX2P_1)
FC61_RDP3: U1.BP21(FC61_RD3P) YJ36.A18(RX1N_1)
FC61_TDN0: U1.CF22(FC61_TD0N) YJ36.A34(TX3N_1)
FC61_TDN1: U1.CD21(FC61_TD1N) YJ36.A36(TX1P_1)
FC61_TDN2: U1.CB22(FC61_TD2N) YJ36.A5(TX4N_1)
FC61_TDN3: U1.CE19(FC61_TD3N) YJ36.A3(TX2P_1)
FC61_TDP0: U1.CF21(FC61_TD0P) YJ36.A33(TX3P_1)
FC61_TDP1: U1.CD22(FC61_TD1P) YJ36.A37(TX1N_1)
FC61_TDP2: U1.CB21(FC61_TD2P) YJ36.A6(TX4P_1)
FC61_TDP3: U1.CE20(FC61_TD3P) YJ36.A2(TX2N_1)
FC62_63_PVDD0P8: C1143.1 C2872.1 C2929.1 L64.1 U1.BG27(FC62_PVDD0P8) U1.BG29(FC63_PVDD0P8)
FC62_RDN0: U1.BY24(FC62_RD0N) YJ35.C17(RX1P_3)
FC62_RDN1: U1.BV25(FC62_RD1N) YJ35.C24(RX4N_3)
FC62_RDN2: U1.BT24(FC62_RD2N) YJ35.C22(RX2P_3)
FC62_RDN3: U1.BP25(FC62_RD3N) YJ35.C15(RX3N_3)
FC62_RDP0: U1.BY25(FC62_RD0P) YJ35.C18(RX1N_3)
FC62_RDP1: U1.BV24(FC62_RD1P) YJ35.C25(RX4P_3)
FC62_RDP2: U1.BT25(FC62_RD2P) YJ35.C21(RX2N_3)
FC62_RDP3: U1.BP24(FC62_RD3P) YJ35.C14(RX3P_3)
FC62_TDN0: U1.CD26(FC62_TD0N) YJ35.C6(TX4P_3)
FC62_TDN1: U1.CB25(FC62_TD1N) YJ35.C2(TX2N_3)
FC62_TDN2: U1.CE24(FC62_TD2N) YJ35.C33(TX3P_3)
FC62_TDN3: U1.CC23(FC62_TD3N) YJ35.C37(TX1N_3)
FC62_TDP0: U1.CD25(FC62_TD0P) YJ35.C5(TX4N_3)
FC62_TDP1: U1.CB26(FC62_TD1P) YJ35.C3(TX2P_3)
FC62_TDP2: U1.CE23(FC62_TD2P) YJ35.C34(TX3N_3)
FC62_TDP3: U1.CC24(FC62_TD3P) YJ35.C36(TX1P_3)
FC63_RDN0: U1.BW27(FC63_RD0N) YJ35.D22(RX2P_4)
FC63_RDN1: U1.BU28(FC63_RD1N) YJ35.D18(RX1N_4)
FC63_RDN2: U1.BR27(FC63_RD2N) YJ35.D25(RX4P_4)
FC63_RDN3: U1.BN28(FC63_RD3N) YJ35.D15(RX3N_4)
FC63_RDP0: U1.BW28(FC63_RD0P) YJ35.D21(RX2N_4)
FC63_RDP1: U1.BU27(FC63_RD1P) YJ35.D17(RX1P_4)
FC63_RDP2: U1.BR28(FC63_RD2P) YJ35.D24(RX4N_4)
FC63_RDP3: U1.BN27(FC63_RD3P) YJ35.D14(RX3P_4)
FC63_TDN0: U1.CE28(FC63_TD0N) YJ35.D3(TX2P_4)
FC63_TDN1: U1.CC27(FC63_TD1N) YJ35.D34(TX3N_4)
FC63_TDN2: U1.CA28(FC63_TD2N) YJ35.D6(TX4P_4)
FC63_TDN3: U1.CF25(FC63_TD3N) YJ35.D37(TX1N_4)
FC63_TDP0: U1.CE27(FC63_TD0P) YJ35.D2(TX2N_4)
FC63_TDP1: U1.CC28(FC63_TD1P) YJ35.D33(TX3P_4)
FC63_TDP2: U1.CA27(FC63_TD2P) YJ35.D5(TX4N_4)
FC63_TDP3: U1.CF26(FC63_TD3P) YJ35.D36(TX1P_4)
FC_LOS0: U1.R19(FC_LOS0)
FC_LOS1: U1.R20(FC_LOS1)
FC_LOS2: U1.U31(FC_LOS2)
FC_LOS3: U1.T19(FC_LOS3)
FC_LOS4: U1.R16(FC_LOS4)
FC_LOS5: U1.V31(FC_LOS5)
FC_LOS6: U1.U49(FC_LOS6)
FC_LOS7: U1.R52(FC_LOS7)
FC_LOS8: U1.V48(FC_LOS8)
FC_LOS9: U1.N51(FC_LOS9)
FC_LOS10: U1.H52(FC_LOS10)
FC_LOS11: U1.N16(FC_LOS11)
FC_LOS12: U1.L16(FC_LOS12)
FC_LOS13: U1.R17(FC_LOS13)
FC_LOS14: U1.K15(FC_LOS14)
FC_LOS15: U1.T18(FC_LOS15)
FC_LOS16: U1.U16(FC_LOS16)
FC_LOS17: U1.T16(FC_LOS17)
FC_LOS18: U1.R15(FC_LOS18)
FC_LOS19: U1.U20(FC_LOS19)
FC_LOS20: U1.U17(FC_LOS20)
FC_LOS21: U1.V51(FC_LOS21)
FC_LOS22: U1.Y52(FC_LOS22)
FC_LOS23: U1.V49(FC_LOS23)
FC_LOS24: U1.W51(FC_LOS24)
FC_LOS25: U1.U50(FC_LOS25)
FC_LOS26: U1.Y51(FC_LOS26)
FC_LOS27: U1.R48(FC_LOS27)
FC_LOS28: U1.P51(FC_LOS28)
FC_LOS29: U1.J15(FC_LOS29)
FC_LOS30: U1.R45(FC_LOS30)
FC_LOS31: U1.H51(FC_LOS31)
FC_LOS32: U1.R24(FC_LOS32)
FC_LOS33: U1.L15(FC_LOS33)
FC_LOS34: U1.W16(FC_LOS34)
FC_LOS35: U1.N15(FC_LOS35)
FC_LOS36: U1.Y15(FC_LOS36)
FC_LOS37: U1.Y16(FC_LOS37)
FC_LOS38: U1.U18(FC_LOS38)
FC_LOS39: U1.U19(FC_LOS39)
FC_LOS40: U1.V18(FC_LOS40)
FC_LOS41: U1.U41(FC_LOS41)
FC_LOS42: U1.U38(FC_LOS42)
FC_LOS43: U1.U46(FC_LOS43)
FC_LOS44: U1.U42(FC_LOS44)
FC_LOS45: U1.W50(FC_LOS45)
FC_LOS46: U1.T42(FC_LOS46)
FC_LOS47: U1.M52(FC_LOS47)
FC_LOS48: U1.R46(FC_LOS48)
FC_LOS49: U1.R23(FC_LOS49)
FC_LOS50: U1.T21(FC_LOS50)
FC_LOS51: U1.T28(FC_LOS51)
FC_LOS52: U1.T30(FC_LOS52)
FC_LOS53: U1.V16(FC_LOS53)
FC_LOS54: U1.Y18(FC_LOS54)
FC_LOS55: U1.V21(FC_LOS55)
FC_LOS56: U1.U22(FC_LOS56)
FC_LOS57: U1.V19(FC_LOS57)
FC_LOS58: U1.W17(FC_LOS58)
FC_LOS59: U1.W18(FC_LOS59)
FC_LOS60: U1.U28(FC_LOS60)
FC_LOS61: U1.U37(FC_LOS61)
FC_LOS62: U1.V42(FC_LOS62)
FC_LOS63: U1.V46(FC_LOS63)
FC_PLL0_REFCLK_N: C2721.1 R3142.2
FC_PLL0_REFCLK_P: C2928.1 R3138.2
FC_PLL1_REFCLK_N: C17.1 R3144.2
FC_PLL1_REFCLK_P: C18.1 R3145.2
FC_PLL2_REFCLK_N: C19.1 R3146.2
FC_PLL2_REFCLK_P: C20.1 R3147.2
FC_PLL3_REFCLK_N: C3108.1 R3153.2
FC_PLL3_REFCLK_P: C3142.1 R3154.2
FC_TRVDD0P8_0: C389.1 C391.1 C393.1 C395.1 C396.1 C397.1 C398.1 C399.1 C400.1 C401.1 C402.1 C403.1 C404.1 C405.1 C406.1 C407.1 C408.1 C409.1 C410.1 C411.1 C412.1 C413.1 C415.1 C416.1 C417.1 C418.1 C419.1 C420.1 C421.1 C422.1 C423.1 C424.1 C425.1 C426.1 C427.1 C428.1 C429.1 C430.1 C431.1 C432.1 C433.1 C434.1 C435.1 C436.1 C437.1 C438.1 C439.1 C440.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.1 C449.1 C450.1 C451.1 C452.1 C453.1 C454.1 C455.1 C456.1 C457.1 C458.1 C459.1 C460.1 C461.1 C462.1 C463.1 C464.1 C465.1 C466.1 C467.1 C2693.1 C2827.1 C2884.1 C2968.1 C2972.1 C2973.1 C2979.1 C2980.1 C3007.1 C3013.1 C3015.1 C3016.1 C3023.1 C3027.1 C3046.1 C3048.1 C3073.1 C3081.1 C3085.1 C3090.1 C3100.1 C3103.1 C3113.1 C3120.1 C3125.1 C3140.1 C3145.1 C3154.1 C3187.1 C3192.1 L65.1 L66.1 L67.1 U1.AP54(FC_TRVDD0P8_0_1) U1.AP56(FC_TRVDD0P8_0_2) U1.AR65(FC_TRVDD0P8_0_3) U1.AT65(FC_TRVDD0P8_0_4) U1.AU54(FC_TRVDD0P8_0_5) U1.AU56(FC_TRVDD0P8_0_6) U1.AU58(FC_TRVDD0P8_0_7) U1.AU60(FC_TRVDD0P8_0_8) U1.AU62(FC_TRVDD0P8_0_9) U1.AV62(FC_TRVDD0P8_0_10) U1.AY54(FC_TRVDD0P8_0_11) U1.AY56(FC_TRVDD0P8_0_12) U1.AY58(FC_TRVDD0P8_0_13) U1.AY59(FC_TRVDD0P8_0_14) U1.BA62(FC_TRVDD0P8_0_15) U1.BB62(FC_TRVDD0P8_0_16) U1.BC54(FC_TRVDD0P8_0_17) U1.BC56(FC_TRVDD0P8_0_18) U1.BC58(FC_TRVDD0P8_0_19) U1.BC59(FC_TRVDD0P8_0_20) U1.BC65(FC_TRVDD0P8_0_21) U1.BD65(FC_TRVDD0P8_0_22) U1.BF54(FC_TRVDD0P8_0_23) U1.BF56(FC_TRVDD0P8_0_24) U1.BF58(FC_TRVDD0P8_0_25) U1.BF60(FC_TRVDD0P8_0_26) U1.BG65(FC_TRVDD0P8_0_27) U1.BH65(FC_TRVDD0P8_0_28) U1.BJ54(FC_TRVDD0P8_0_29) U1.BJ56(FC_TRVDD0P8_0_30) U1.BJ58(FC_TRVDD0P8_0_31) U1.BJ60(FC_TRVDD0P8_0_32) U1.BJ62(FC_TRVDD0P8_0_33) U1.BK62(FC_TRVDD0P8_0_34) U1.BM54(FC_TRVDD0P8_0_35) U1.BM56(FC_TRVDD0P8_0_36) U1.BM58(FC_TRVDD0P8_0_37) U1.BM60(FC_TRVDD0P8_0_38) U1.BN62(FC_TRVDD0P8_0_39) U1.BP38(FC_TRVDD0P8_0_40) U1.BP41(FC_TRVDD0P8_0_41) U1.BP44(FC_TRVDD0P8_0_42) U1.BP47(FC_TRVDD0P8_0_43) U1.BP62(FC_TRVDD0P8_0_44) U1.BR54(FC_TRVDD0P8_0_45) U1.BR56(FC_TRVDD0P8_0_46) U1.BR58(FC_TRVDD0P8_0_47) U1.BR60(FC_TRVDD0P8_0_48) U1.BR65(FC_TRVDD0P8_0_49) U1.BT38(FC_TRVDD0P8_0_50) U1.BT41(FC_TRVDD0P8_0_51) U1.BT44(FC_TRVDD0P8_0_52) U1.BT47(FC_TRVDD0P8_0_53) U1.BT50(FC_TRVDD0P8_0_54) U1.BT51(FC_TRVDD0P8_0_55) U1.BT65(FC_TRVDD0P8_0_56) U1.BV35(FC_TRVDD0P8_0_57) U1.BV38(FC_TRVDD0P8_0_58) U1.BV41(FC_TRVDD0P8_0_59) U1.BV44(FC_TRVDD0P8_0_60) U1.BV47(FC_TRVDD0P8_0_61) U1.BV50(FC_TRVDD0P8_0_62) U1.BV51(FC_TRVDD0P8_0_63) U1.BV54(FC_TRVDD0P8_0_64) U1.BW38(FC_TRVDD0P8_0_65) U1.BW41(FC_TRVDD0P8_0_66) U1.BW54(FC_TRVDD0P8_0_67) U1.BW57(FC_TRVDD0P8_0_68) U1.BW65(FC_TRVDD0P8_0_69) U1.BY44(FC_TRVDD0P8_0_70) U1.BY47(FC_TRVDD0P8_0_71) U1.BY50(FC_TRVDD0P8_0_72) U1.BY51(FC_TRVDD0P8_0_73) U1.BY65(FC_TRVDD0P8_0_74) U1.CA54(FC_TRVDD0P8_0_75) U1.CA57(FC_TRVDD0P8_0_76) U1.CA62(FC_TRVDD0P8_0_77) U1.CB35(FC_TRVDD0P8_0_78) U1.CB36(FC_TRVDD0P8_0_79) U1.CB39(FC_TRVDD0P8_0_80) U1.CB40(FC_TRVDD0P8_0_81) U1.CB47(FC_TRVDD0P8_0_82) U1.CB48(FC_TRVDD0P8_0_83) U1.CB62(FC_TRVDD0P8_0_84) U1.CC54(FC_TRVDD0P8_0_85) U1.CC57(FC_TRVDD0P8_0_86) U1.CE41(FC_TRVDD0P8_0_87) U1.CE42(FC_TRVDD0P8_0_88) U1.CE45(FC_TRVDD0P8_0_89) U1.CE46(FC_TRVDD0P8_0_90) U1.CE62(FC_TRVDD0P8_0_91) U1.CF52(FC_TRVDD0P8_0_92) U1.CF53(FC_TRVDD0P8_0_93) U1.CF55(FC_TRVDD0P8_0_94) U1.CF56(FC_TRVDD0P8_0_95) U1.CF58(FC_TRVDD0P8_0_96) U1.CF59(FC_TRVDD0P8_0_97) U1.CF62(FC_TRVDD0P8_0_98)
FC_TRVDD0P8_1: C469.1 C470.1 C471.1 C472.1 C473.1 C474.1 C475.1 C476.1 C477.1 C478.1 C479.1 C480.1 C481.1 C482.1 C483.1 C484.1 C485.1 C486.1 C487.1 C488.1 C489.1 C490.1 C491.1 C492.1 C493.1 C494.1 C496.1 C497.1 C498.1 C499.1 C500.1 C501.1 C502.1 C503.1 C504.1 C505.1 C506.1 C507.1 C508.1 C509.1 C510.1 C511.1 C512.1 C513.1 C514.1 C515.1 C516.1 C517.1 C518.1 C519.1 C520.1 C521.1 C523.1 C524.1 C525.1 C526.1 C527.1 C528.1 C529.1 C530.1 C531.1 C532.1 C533.1 C534.1 C535.1 C536.1 C537.1 C538.1 C539.1 C540.1 C541.1 C542.1 C543.1 C544.1 C545.1 C546.1 C547.1 C548.1 C551.1 C552.1 C553.1 C554.1 C555.1 C556.1 C557.1 C558.1 C559.1 C560.1 C561.1 C562.1 C563.1 C564.1 C565.1 C566.1 C567.1 C568.1 C569.1 C570.1 C571.1 C572.1 C573.1 C574.1 C575.1 L69.1 L70.1 L71.1 U1.A52(FC_TRVDD0P8_1_1) U1.A54(FC_TRVDD0P8_1_2) U1.A56(FC_TRVDD0P8_1_3) U1.A59(FC_TRVDD0P8_1_4) U1.A62(FC_TRVDD0P8_1_5) U1.AB54(FC_TRVDD0P8_1_71) U1.AB56(FC_TRVDD0P8_1_72) U1.AB58(FC_TRVDD0P8_1_73) U1.AB60(FC_TRVDD0P8_1_74) U1.AC65(FC_TRVDD0P8_1_75) U1.AD65(FC_TRVDD0P8_1_76) U1.AE54(FC_TRVDD0P8_1_77) U1.AE56(FC_TRVDD0P8_1_78) U1.AE58(FC_TRVDD0P8_1_79) U1.AE60(FC_TRVDD0P8_1_80) U1.AE62(FC_TRVDD0P8_1_81) U1.AF62(FC_TRVDD0P8_1_82) U1.AH54(FC_TRVDD0P8_1_83) U1.AH56(FC_TRVDD0P8_1_84) U1.AH58(FC_TRVDD0P8_1_85) U1.AH59(FC_TRVDD0P8_1_86) U1.AJ62(FC_TRVDD0P8_1_87) U1.AK62(FC_TRVDD0P8_1_88) U1.AL54(FC_TRVDD0P8_1_89) U1.AL56(FC_TRVDD0P8_1_90) U1.AL58(FC_TRVDD0P8_1_91) U1.AL59(FC_TRVDD0P8_1_92) U1.AL65(FC_TRVDD0P8_1_93) U1.AM65(FC_TRVDD0P8_1_94) U1.AP58(FC_TRVDD0P8_1_95) U1.AP60(FC_TRVDD0P8_1_96) U1.B41(FC_TRVDD0P8_1_6) U1.B42(FC_TRVDD0P8_1_7) U1.B45(FC_TRVDD0P8_1_8) U1.B46(FC_TRVDD0P8_1_9) U1.B62(FC_TRVDD0P8_1_10) U1.D52(FC_TRVDD0P8_1_11) U1.D54(FC_TRVDD0P8_1_12) U1.D56(FC_TRVDD0P8_1_13) U1.D59(FC_TRVDD0P8_1_14) U1.E35(FC_TRVDD0P8_1_15) U1.E36(FC_TRVDD0P8_1_16) U1.E39(FC_TRVDD0P8_1_17) U1.E40(FC_TRVDD0P8_1_18) U1.E47(FC_TRVDD0P8_1_19) U1.E48(FC_TRVDD0P8_1_20) U1.E62(FC_TRVDD0P8_1_21) U1.F62(FC_TRVDD0P8_1_22) U1.G44(FC_TRVDD0P8_1_23) U1.G47(FC_TRVDD0P8_1_24) U1.G54(FC_TRVDD0P8_1_25) U1.G56(FC_TRVDD0P8_1_26) U1.G58(FC_TRVDD0P8_1_27) U1.G59(FC_TRVDD0P8_1_28) U1.G65(FC_TRVDD0P8_1_29) U1.H38(FC_TRVDD0P8_1_30) U1.H41(FC_TRVDD0P8_1_31) U1.H65(FC_TRVDD0P8_1_32) U1.J38(FC_TRVDD0P8_1_33) U1.J41(FC_TRVDD0P8_1_34) U1.J44(FC_TRVDD0P8_1_35) U1.J47(FC_TRVDD0P8_1_36) U1.K54(FC_TRVDD0P8_1_37) U1.K56(FC_TRVDD0P8_1_38) U1.K58(FC_TRVDD0P8_1_39) U1.K60(FC_TRVDD0P8_1_40) U1.L35(FC_TRVDD0P8_1_41) U1.L38(FC_TRVDD0P8_1_42) U1.L41(FC_TRVDD0P8_1_43) U1.L44(FC_TRVDD0P8_1_44) U1.L47(FC_TRVDD0P8_1_45) U1.L65(FC_TRVDD0P8_1_46) U1.M65(FC_TRVDD0P8_1_47) U1.N35(FC_TRVDD0P8_1_48) U1.N38(FC_TRVDD0P8_1_49) U1.N41(FC_TRVDD0P8_1_50) U1.N44(FC_TRVDD0P8_1_51) U1.N47(FC_TRVDD0P8_1_52) U1.N54(FC_TRVDD0P8_1_53) U1.N56(FC_TRVDD0P8_1_54) U1.N58(FC_TRVDD0P8_1_55) U1.N60(FC_TRVDD0P8_1_56) U1.N62(FC_TRVDD0P8_1_57) U1.P62(FC_TRVDD0P8_1_58) U1.T54(FC_TRVDD0P8_1_59) U1.T56(FC_TRVDD0P8_1_60) U1.T58(FC_TRVDD0P8_1_61) U1.T59(FC_TRVDD0P8_1_62) U1.U62(FC_TRVDD0P8_1_63) U1.V62(FC_TRVDD0P8_1_64) U1.W54(FC_TRVDD0P8_1_65) U1.W56(FC_TRVDD0P8_1_66) U1.W58(FC_TRVDD0P8_1_67) U1.W59(FC_TRVDD0P8_1_68) U1.W65(FC_TRVDD0P8_1_69) U1.Y65(FC_TRVDD0P8_1_70)
FC_TRVDD0P8_2: C577.1 C578.1 C579.1 C580.1 C581.1 C582.1 C583.1 C584.1 C585.1 C586.1 C587.1 C588.1 C589.1 C590.1 C591.1 C592.1 C593.1 C594.1 C595.1 C596.1 C597.1 C598.1 C599.1 C600.1 C601.1 C602.1 C604.1 C605.1 C606.1 C607.1 C608.1 C609.1 C610.1 C611.1 C612.1 C613.1 C614.1 C615.1 C616.1 C617.1 C618.1 C619.1 C620.1 C621.1 C622.1 C623.1 C624.1 C625.1 C626.1 C627.1 C628.1 C629.1 C631.1 C632.1 C633.1 C634.1 C635.1 C636.1 C637.1 C638.1 C639.1 C640.1 C641.1 C642.1 C643.1 C644.1 C645.1 C646.1 C647.1 C648.1 C649.1 C650.1 C651.1 C652.1 C653.1 C654.1 C655.1 C656.1 C659.1 C660.1 C661.1 C662.1 C663.1 C664.1 C665.1 C666.1 C667.1 C668.1 C669.1 C670.1 C671.1 C672.1 C673.1 C674.1 C675.1 C676.1 C677.1 C678.1 C679.1 C680.1 C681.1 C682.1 C683.1 L73.1 L74.1 L75.1 U1.A5(FC_TRVDD0P8_2_1) U1.A8(FC_TRVDD0P8_2_2) U1.A11(FC_TRVDD0P8_2_3) U1.A13(FC_TRVDD0P8_2_4) U1.A15(FC_TRVDD0P8_2_5) U1.AB7(FC_TRVDD0P8_2_77) U1.AB9(FC_TRVDD0P8_2_78) U1.AB11(FC_TRVDD0P8_2_79) U1.AB13(FC_TRVDD0P8_2_80) U1.AC2(FC_TRVDD0P8_2_81) U1.AD2(FC_TRVDD0P8_2_82) U1.AE5(FC_TRVDD0P8_2_83) U1.AE7(FC_TRVDD0P8_2_84) U1.AE9(FC_TRVDD0P8_2_85) U1.AE11(FC_TRVDD0P8_2_86) U1.AE13(FC_TRVDD0P8_2_87) U1.AF5(FC_TRVDD0P8_2_88) U1.AH8(FC_TRVDD0P8_2_89) U1.AH9(FC_TRVDD0P8_2_90) U1.AH11(FC_TRVDD0P8_2_91) U1.AH13(FC_TRVDD0P8_2_92) U1.AJ5(FC_TRVDD0P8_2_93) U1.AK5(FC_TRVDD0P8_2_94) U1.AL8(FC_TRVDD0P8_2_95) U1.AL9(FC_TRVDD0P8_2_96) U1.B5(FC_TRVDD0P8_2_6) U1.B17(FC_TRVDD0P8_2_7) U1.B18(FC_TRVDD0P8_2_8) U1.B21(FC_TRVDD0P8_2_9) U1.B22(FC_TRVDD0P8_2_10) U1.B29(FC_TRVDD0P8_2_11) U1.B30(FC_TRVDD0P8_2_12) U1.B33(FC_TRVDD0P8_2_13) U1.B34(FC_TRVDD0P8_2_14) U1.D8(FC_TRVDD0P8_2_15) U1.D11(FC_TRVDD0P8_2_16) U1.D13(FC_TRVDD0P8_2_17) U1.D15(FC_TRVDD0P8_2_18) U1.E5(FC_TRVDD0P8_2_19) U1.E23(FC_TRVDD0P8_2_20) U1.E24(FC_TRVDD0P8_2_21) U1.E27(FC_TRVDD0P8_2_22) U1.E28(FC_TRVDD0P8_2_23) U1.F5(FC_TRVDD0P8_2_24) U1.G2(FC_TRVDD0P8_2_25) U1.G8(FC_TRVDD0P8_2_26) U1.G9(FC_TRVDD0P8_2_27) U1.G11(FC_TRVDD0P8_2_28) U1.G13(FC_TRVDD0P8_2_29) U1.G20(FC_TRVDD0P8_2_30) U1.G23(FC_TRVDD0P8_2_31) U1.G32(FC_TRVDD0P8_2_32) U1.G35(FC_TRVDD0P8_2_33) U1.H2(FC_TRVDD0P8_2_34) U1.H26(FC_TRVDD0P8_2_35) U1.H29(FC_TRVDD0P8_2_36) U1.J20(FC_TRVDD0P8_2_37) U1.J23(FC_TRVDD0P8_2_38) U1.J26(FC_TRVDD0P8_2_39) U1.J29(FC_TRVDD0P8_2_40) U1.J32(FC_TRVDD0P8_2_41) U1.J35(FC_TRVDD0P8_2_42) U1.K7(FC_TRVDD0P8_2_43) U1.K9(FC_TRVDD0P8_2_44) U1.K11(FC_TRVDD0P8_2_45) U1.K13(FC_TRVDD0P8_2_46) U1.L2(FC_TRVDD0P8_2_47) U1.L20(FC_TRVDD0P8_2_48) U1.L23(FC_TRVDD0P8_2_49) U1.L26(FC_TRVDD0P8_2_50) U1.L29(FC_TRVDD0P8_2_51) U1.L32(FC_TRVDD0P8_2_52) U1.M2(FC_TRVDD0P8_2_53) U1.N5(FC_TRVDD0P8_2_54) U1.N8(FC_TRVDD0P8_2_55) U1.N9(FC_TRVDD0P8_2_56) U1.N11(FC_TRVDD0P8_2_57) U1.N13(FC_TRVDD0P8_2_58) U1.N20(FC_TRVDD0P8_2_59) U1.N23(FC_TRVDD0P8_2_60) U1.N26(FC_TRVDD0P8_2_61) U1.N29(FC_TRVDD0P8_2_62) U1.N32(FC_TRVDD0P8_2_63) U1.P5(FC_TRVDD0P8_2_64) U1.T8(FC_TRVDD0P8_2_65) U1.T9(FC_TRVDD0P8_2_66) U1.T11(FC_TRVDD0P8_2_67) U1.T13(FC_TRVDD0P8_2_68) U1.U5(FC_TRVDD0P8_2_69) U1.V5(FC_TRVDD0P8_2_70) U1.W2(FC_TRVDD0P8_2_71) U1.W8(FC_TRVDD0P8_2_72) U1.W9(FC_TRVDD0P8_2_73) U1.W11(FC_TRVDD0P8_2_74) U1.W13(FC_TRVDD0P8_2_75) U1.Y2(FC_TRVDD0P8_2_76)
