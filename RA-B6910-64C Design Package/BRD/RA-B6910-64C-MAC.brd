# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N31076949: length 29.4
  TOP w0.13: R2725.2 179.11,83.72 179.26,83.56 179.26,80.01 v1(178.75,79.5)
  SIG9 w0.155: YJ28.B28 183.52,58.44 183.52,60.59 183.14,60.97 183.14,61.29 183.52,61.67 183.52,64.59 183.14,64.97 183.14,65.29 183.53,65.68 183.53,72.49 180.28,75.75 180.28,77.98 v1(178.75,79.5)
N31076952: length 36.6
  SIG8 w0.155: v1(179.64,86.23) 179.26,85.85 179.26,74.29 181.52,72.04 181.52,65.61 181.86,65.27 181.86,64.95 181.47,64.56 181.47,61.67 181.86,61.28 181.86,60.96 181.51,60.61 181.51,60.17 183.53,58.15 183.53,57.67 183.13,57.27 182.96,57.27 182.95,57.27 YJ28.B27
  BOTTOM w0.13: v2(177.61,88.31) 178.14,87.78 R2727.2 179.13,87.78 179.26,87.65 179.26,86.61 v1(179.64,86.23)
N31077039: length 14.4
  SIG9 w0.155: v1(178.75,75.44) 179.26,74.93 179.26,74.17 182.9,70.53 YJ28.A28
  BOTTOM w0.13: v1(178.75,75.44) 178.24,75.94 178.24,77.75 178.37,77.87 R2732.1
N31077042: length 14.8
  TOP w0.13: R2730.1 v1(178.75,77.21)
  SIG6 w0.155: YJ28.A27 182.1,65.03 181.41,65.72 181.41,71.89 179.24,74.06 179.24,76.73 v1(178.75,77.21)
N31101246: length 14.5
  SIG8 w0.155: v1(165.16,75.44) 164.64,74.91 164.64,73.3 165.04,72.9 165.04,67.94 163.9,66.8 YJ28.C28
  BOTTOM w0.13: v1(165.16,75.44) 165.04,75.31 v2(164.4,75.31) 163.64,76.07 163.64,77.11 R2731.1
N31101249: length 15.4
  SIG6 w0.155: YJ28.C27 163.1,65.03 162.41,65.72 162.41,68.49 165.67,71.75 165.67,76.71 v1(165.16,77.21)
  BOTTOM w0.13: R2729.1 165.42,77.47 v1(165.16,77.21)
N31101252: length 29.3
  TOP w0.13: v1(165.42,81.28) 165.93,81.79 165.93,83.56 165.77,83.72 R2728.2
  SIG8 w0.155: v1(165.42,81.28) 164.91,80.77 164.91,78.36 165.67,77.59 165.67,67.94 164.53,66.8 164.53,65.68 164.14,65.29 164.14,64.97 164.52,64.59 164.52,61.65 164.14,61.27 164.14,60.97 164.52,60.59 164.52,59.43 163.9,58.81 YJ28.D28
  BOTTOM w0.13: v2(164.53,81.35) 164.6,81.28 v1(165.42,81.28)
N31101255: length 35.4
  SIG9 w0.155: v1(165.42,86.23) 165.42,83.94 164.78,83.31 164.78,77.48 164.71,77.4 164.71,68.34 162.52,66.15 162.52,65.61 162.86,65.27 162.86,64.95 162.47,64.56 162.47,61.66 162.86,61.27 162.86,60.95 162.3,60.39 162.3,57.83 162.8,57.33 ; 163.1,57.03 YJ28.D27 ; 163.1,57.03 163.1,57.03 162.8,57.33 ; 163.1,57.03 162.8,57.33 162.8,57.33
  BOTTOM w0.13: v2(164.27,88.39) 164.88,87.78 R2726.2 v1(165.42,86.23)
N31126523: length 16.5
  TOP w0.13: R2745.1 217.23,77.09 v1(218,76.32)
  SIG1 w0.16: v1(218,76.32) 218,71.88 213.91,67.8 213.91,65.65 213.3,65.03 YJ29.A27
  BOTTOM w0.13: v2(218.76,76.32) v1(218,76.32)
N31126526: length 14
  SIG3 w0.155: v1(216.22,75.44) 215.71,74.93 215.71,70.23 213.04,67.56 213.04,66.36 YJ29.A28
  BOTTOM w0.13: v1(216.22,75.44) 216.73,75.94 216.73,77.37 R2746.1
N31126552: length 29
  TOP w0.13: v1(216.22,83.06) R2748.2
  SIG2 w0.152: v1(216.22,83.06) 216.73,82.55 216.73,74.17 212.17,69.61 212.17,66.3 211.92,66.05 211.92,65.64 212.26,65.29 212.26,64.97 211.88,64.59 211.88,61.67 212.28,61.27 212.28,60.96 212.22,60.9 212.15,60.85 212.07,60.77 212.02,60.7 211.9,60.58 211.9,58.98 212.5,58.38 YJ29.B28
N31126555: length 36.2
  SIG2 w0.152: YJ29.B27 212.57,57.15 212.41,57.15 211.5,58.06 211.5,60.6 211.12,60.98 211.12,61.25 211.49,61.62 211.5,61.62 211.5,64.6 211.16,64.93 211.16,65.29 211.49,65.62 211.53,65.62 211.53,70.37 214.69,73.53 214.69,77.72 215.71,78.74 215.71,85.72 v1(216.22,86.23)
  BOTTOM w0.13: v1(216.22,86.23) v2(217.11,86.23) 217.11,86.48 216.73,86.87 216.73,87.63 216.57,87.78 R2756.2
N31182601: length 34.6
  SIG3 w0.155: v1(229.55,86.23) 229.04,85.72 229.04,67.65 230.53,66.16 230.53,65.66 230.49,65.62 230.49,65.62 230.16,65.29 230.16,64.95 230.5,64.61 230.5,61.62 230.49,61.62 230.12,61.25 230.12,60.99 230.5,60.61 230.5,58.06 231.41,57.15 231.57,57.15 YJ29.D27
  BOTTOM w0.13: R2755.2 v1(229.55,86.23) 230.31,86.23 v2(230.44,86.1)
N31182604: length 27.8
  TOP w0.13: v1(229.55,83.06) R2747.2
  SIG3 w0.155: v1(229.55,83.06) 230.19,82.42 230.19,73.91 229.68,73.4 229.68,67.82 230.92,66.58 230.92,65.61 231.26,65.27 231.26,64.97 230.88,64.59 230.88,61.65 231.28,61.25 231.28,61 231.2,60.92 231.2,60.91 230.91,60.62 230.9,60.62 230.9,58.98 231.5,58.38 YJ29.D28
N31182693: length 13.5
  SIG4 w0.155: YJ29.C28 231.5,67.39 229.55,69.34 v1(229.55,74.55)
  BOTTOM w0.13: v1(229.55,74.55) 229.04,75.05 229.04,77.72 229.2,77.87 R2754.1
N31182696: length 16.6
  TOP w0.13: v1(231.33,76.2) 230.57,76.96 R2753.1
  SIG4 w0.155: YJ29.C27 232.3,65.04 232.92,65.66 232.92,66.86 231.28,68.5 231.28,73.83 230.82,74.29 230.82,75.69 v1(231.33,76.2)
  BOTTOM w0.13: v2(232.47,75.44) 232.09,75.44 v1(231.33,76.2)
N31333317: length 13.5
  SIG8 w0.155: v1(228.54,76.32) 228.05,75.84 228.05,74.37 229.3,73.12 229.3,66.42 YJ30.A28
  BOTTOM w0.13: R2772.1 228.44,77.87 228.08,77.52 228.08,77.04 228.54,76.58 v1(228.54,76.32)
N31333320: length 15
  TOP w0.13: R2770.1 v1(228.54,77.21)
  SIG6 w0.155: v1(228.54,77.21) 229.04,76.71 229.04,73.66 229.74,72.96 229.74,67.12 230.57,66.29 230.57,65.71 229.94,65.07 229.75,65.07 YJ30.A27
N31333457: length 28.2
  TOP w0.13: v1(228.54,82.17) 229.04,82.67 229.04,83.56 228.89,83.72 R2768.2
  SIG9 w0.155: v1(228.54,82.17) 229.04,81.66 229.04,72.64 230.53,71.16 230.53,65.68 230.14,65.29 230.14,64.97 230.52,64.59 230.52,61.67 230.14,61.29 230.14,60.97 230.52,60.59 230.52,59.43 229.9,58.81 YJ30.B28
N31333460: length 34.2
  SIG8 w0.155: v1(228.54,86.21) 228.03,85.7 228.03,76.58 227.65,76.2 227.65,74.19 228.52,73.32 228.52,65.61 228.86,65.27 228.86,64.95 228.47,64.56 228.47,61.66 228.51,61.62 228.86,61.27 228.86,60.97 228.51,60.62 228.51,60.17 230.53,58.15 230.53,57.66 230.14,57.27 229.95,57.27 YJ30.B27
  BOTTOM w0.13: v1(228.54,86.21) R2766.2
N31357668: length 15.2
  SIG9 w0.155: YJ30.C28 210.9,66.4 210.76,66.55 210.76,67 214.69,70.94 214.69,74.93 v1(215.2,75.44)
  BOTTOM w0.13: v2(214.44,75.31) 215.07,75.31 v1(215.2,75.44) 215.71,75.94 215.71,76.71 215.2,77.21 R2771.1
N31357671: length 27.7
  POWER2 w0.508: v1(213.32,77.87) 211.14,75.69 211.14,73.55 203.64,66.05 203.64,63.88 204.41,63.12 209.48,63.12 210.1,63.74 YJ30.C27
  BOTTOM w0.13: R2769.1 v1(213.32,77.87) 213.17,77.72 v2(213.17,76.83)
N31357703: length 35.8
  SIG9 w0.155: v1(215.2,86.23) 214.69,85.72 214.69,77.85 214.06,77.21 214.06,71.24 209.52,66.7 209.52,65.61 209.86,65.27 209.86,64.95 209.47,64.56 209.47,61.66 209.86,61.27 209.86,60.95 209.49,60.58 209.49,57.66 209.66,57.48 209.67,57.47 209.75,57.39 209.76,57.38 210.1,57.04 YJ30.D27
  BOTTOM w0.13: v1(215.2,86.23) 214.94,86.23 v2(214.19,86.98) 214.19,87.11 214.85,87.78 R2765.2
N31357706: length 30.1
  TOP w0.13: v1(215.2,82.17) 215.71,82.67 215.71,83.56 215.56,83.72 R2767.2
  SIG8 w0.155: v1(215.2,82.17) 214.64,81.61 214.64,70.43 211.53,67.32 211.53,65.66 211.14,65.27 211.14,64.97 211.52,64.59 211.52,61.65 211.14,61.27 211.14,60.97 211.52,60.59 211.52,59.43 210.9,58.81 YJ30.D28
  BOTTOM w0.13: v1(215.2,82.17) 214.44,81.4 v2(214.44,81.28)
N31392849: length 27.8
  TOP w0.13: R2792.2 v1(260.41,83.06)
  SIG2 w0.152: YJ31.B28 259.5,58.38 258.9,58.98 258.9,60.62 258.91,60.62 259.28,60.99 259.28,61.27 258.88,61.67 258.88,64.62 258.91,64.62 259.26,64.97 259.26,65.27 258.92,65.61 258.92,66.05 259.17,66.3 259.17,73.88 259.96,74.67 259.96,78.28 260.92,79.25 260.92,82.55 v1(260.41,83.06)
N31392860: length 34.9
  SIG2 w0.152: v1(260.41,86.23) 259.91,85.72 259.91,79.25 258.83,78.17 258.83,74.84 258.53,74.55 258.53,65.66 258.16,65.29 258.16,64.95 258.5,64.61 258.5,61.63 258.12,61.25 258.12,60.94 258.5,60.56 258.5,58.06 259.41,57.15 259.57,57.15 YJ31.B27
  BOTTOM w0.13: R2790.2 260.64,87.78 261.05,87.37 v2(261.53,87.37) 261.53,87.35 v1(260.41,86.23)
N31393396: length 14
  SIG4 w0.155: YJ31.A28 259.5,74.01 v1(260.41,74.93)
  BOTTOM w0.13: v2(261.43,75.31) 261.05,74.93 v1(260.41,74.93) 259.91,75.44 259.91,77.09 260.41,77.59 R2788.1
N31393399: length 14.7
  TOP w0.13: R2786.1 261.43,77.28 261.11,76.96 v1(260.41,76.96)
  SIG4 w0.155: YJ31.A27 260.3,65.03 260.92,65.65 260.92,76.45 v1(260.41,76.96)
N31485105: length 19.3
  SIG1 w0.16: v1(273.75,75.44) 273.24,74.93 273.24,73.53 275.4,71.37 275.4,65.78 276.03,65.15 276.89,65.15 277.46,64.58 277.87,64.58 278.06,64.76 278.07,64.77 278.15,64.85 278.16,64.86 278.5,65.2 YJ31.C28
  BOTTOM w0.13: v1(273.75,75.44) 273.88,75.31 v2(274.64,75.31) 274.64,75.82 274.26,76.2 274.26,77.72 274.1,77.87 R2787.1
N31485108: length 16.6
  TOP w0.13: R2785.1 274.76,75.08 v1(275.4,74.44)
  SIG4 w0.155: v1(275.4,74.44) 275.4,72.26 277.69,69.97 277.69,65.85 278.52,65.02 278.7,65.02 YJ31.C27
  BOTTOM w0.13: v1(275.4,74.44) 275.4,74.55 v2(276.16,75.31)
N31485124: length 29.5
  TOP w0.13: v1(273.75,83.06) 274.38,83.06 274.76,83.44 R2791.2
  SIG3 w0.155: v1(273.75,83.06) 274.26,82.55 274.26,74.29 278.17,70.38 278.17,66.3 277.92,66.05 277.92,65.62 278.26,65.28 278.26,64.97 277.88,64.59 277.88,61.65 278.28,61.25 278.28,60.99 277.91,60.62 277.9,60.62 277.9,58.98 278.5,58.38 YJ31.D28
N31485127: length 36
  SIG3 w0.155: v1(273.75,86.23) 273.24,85.72 273.24,74.27 277.53,69.98 277.53,65.66 277.49,65.62 277.49,65.62 277.2,65.33 277.2,65.33 277.16,65.29 277.16,64.95 277.5,64.61 277.5,61.63 277.12,61.25 277.12,60.99 277.49,60.62 277.5,60.62 277.5,58.03 278.38,57.15 278.57,57.15 YJ31.D27
  BOTTOM w0.13: R2789.2 274.1,87.78 274.51,87.37 v2(274.51,86.48) 274.26,86.23 v1(273.75,86.23)
N31509514: length 14
  SIG7 w0.155: v1(273.75,74.42) 273.75,69.47 276.9,66.32 YJ32.A28
  BOTTOM w0.13: v1(273.75,74.42) 273.24,74.93 273.24,77.72 273.09,77.87 R2808.1
N31509517: length 15.9
  TOP w0.13: R2812.1 v1(272.73,77.21)
  SIG6 w0.155: v1(272.73,77.21) 273.24,76.71 273.24,74.17 275.41,72 275.41,65.72 276.1,65.03 YJ32.A27
  BOTTOM w0.13: v1(272.73,77.21) 272.61,77.21 v2(271.97,76.58)
N31509804: length 36.5
  SIG8 w0.155: v1(272.73,86.23) 272.22,85.72 272.22,73.51 275.52,70.21 275.52,65.61 275.86,65.27 275.86,64.95 275.47,64.56 275.47,61.66 275.51,61.62 275.51,61.62 275.86,61.27 275.86,60.97 275.51,60.62 275.51,60.17 277.53,58.15 277.53,57.66 277.14,57.27 276.95,57.27 YJ32.B27
  BOTTOM w0.13: v1(272.73,86.23) 271.62,87.35 v2(271.62,87.5) 271.89,87.78 R2810.2
N31509807: length 29.2
  TOP w0.13: v1(272.73,82.17) 271.72,83.18 R2806.2
  SIG9 w0.155: YJ32.B28 276.9,58.81 277.52,59.43 277.52,60.59 277.14,60.97 277.14,61.29 277.52,61.67 277.52,64.59 277.14,64.97 277.14,65.29 277.53,65.68 277.53,69.5 273.24,73.78 273.24,81.66 v1(272.73,82.17)
N31535647: length 28.2
  TOP w0.13: R2805.2 259.75,83.72 259.91,83.56 259.91,82.67 v1(259.4,82.17)
  SIG8 w0.155: v1(259.4,82.17) 259.93,81.63 259.93,74.57 259.47,74.11 259.47,67.63 258.53,66.69 258.53,65.68 258.14,65.29 258.14,64.97 258.52,64.59 258.52,61.65 258.14,61.27 258.14,60.97 258.52,60.59 258.52,59.43 257.9,58.81 YJ32.D28
N31535650: length 34.6
  SIG9 w0.155: 256.8,57.33 256.8,57.33 257.1,57.03 ; 256.8,57.33 256.3,57.83 256.3,60.39 256.86,60.95 256.86,61.27 256.47,61.66 256.47,64.56 256.86,64.95 256.86,65.27 256.52,65.61 256.52,66.29 258.25,68.03 258.25,76.96 258.83,77.53 258.83,85.66 v1(259.4,86.23) ; 256.8,57.33 257.1,57.03 257.1,57.03 ; 257.1,57.03 YJ32.D27
  BOTTOM w0.13: R2809.2 259.75,87.78 259.91,87.63 259.91,86.74 v1(259.4,86.23)
N31535718: length 19.2
  SIG8 w0.155: v1(257.62,80.52) 258.89,79.25 258.89,67.79 257.9,66.8 YJ32.C28
  BOTTOM w0.13: v1(257.62,80.52) 257.87,80.52 v2(258.38,80.01) 258.89,79.5 258.89,78.38 R2807.1
N31535721: length 17.4
  TOP w0.13: R2811.1 259.4,77.59 259.02,77.21 v1(257.62,77.21)
  SIG6 w0.155: v1(257.62,77.21) 258.13,76.71 258.13,75.82 257.49,75.18 257.49,67.05 258.51,66.04 258.51,65.65 258.01,65.15 257.83,65.15 YJ32.C27
  BOTTOM w0.13: v2(256.98,76.71) 257.49,77.21 v1(257.62,77.21)
N31668297: length 17.9
  TOP w0.13: R2826.1 v1(310.2,80.64)
  SIG4 w0.155: YJ33.A28 306.5,71.86 309.56,74.93 309.56,80.01 v1(310.2,80.64)
  BOTTOM w0.13: v2(309.59,80.06) 310.17,80.64 v1(310.2,80.64)
N31668300: length 15.6
  TOP w0.13: R2825.1 v1(312.48,77.21)
  SIG4 w0.155: YJ33.A27 307.3,65.03 307.92,65.65 307.92,72.14 311.98,76.2 311.98,76.71 v1(312.48,77.21)
N31668331: length 25.8
  SIG2 w0.152: v1(309.05,75.44) 305.53,71.91 305.53,65.66 305.16,65.29 305.16,64.95 305.5,64.61 305.5,61.64 305.12,61.26 305.12,60.99 305.49,60.62 305.5,60.62 305.5,58.06 306.41,57.15 306.57,57.15 YJ33.B27
  BOTTOM w0.13: R2838.2 309.41,77.87 309.56,77.72 309.56,76.2 309.94,75.82 v2(309.94,75.56) 309.18,75.56 v1(309.05,75.44)
N31668334: length 28.1
  TOP w0.13: R2828.2 v1(312.36,80.64)
  SIG2 w0.152: YJ33.B28 306.5,58.38 305.9,58.98 305.9,60.62 305.91,60.62 306.28,60.99 306.28,61.25 305.88,61.65 305.88,64.59 306.26,64.97 306.26,65.29 305.92,65.64 305.92,66.05 306.17,66.3 306.17,71.79 309.69,75.31 309.69,77.39 311.85,79.55 311.85,80.13 v1(312.36,80.64)
  BOTTOM w0.13: v1(312.36,80.64) v2(311.59,81.4)
N31678786: length 34.9
  SIG3 w0.155: v1(325.18,86.23) 324.68,85.72 324.68,73.4 324.35,73.07 324.35,66.35 324.53,66.16 324.53,65.67 324.16,65.3 324.16,64.95 324.49,64.62 324.5,64.62 324.5,61.63 324.12,61.25 324.12,60.98 324.5,60.6 324.5,60.07 324.85,59.72 324.85,57.7 325.41,57.15 325.57,57.15 YJ33.D27
  BOTTOM w0.13: R2837.2 325.54,87.78 325.69,87.63 325.69,87.12 326.07,86.74 v2(326.07,86.1) 325.31,86.1 v1(325.18,86.23)
N31678789: length 27.3
  TOP w0.13: R2827.2 v1(325.18,83.06)
  SIG3 w0.152: v1(325.18,83.06) 325.64,82.6 325.64,73.45 324.92,72.73 324.92,65.63 325.29,65.26 325.29,64.99 324.91,64.61 324.91,61.63 325.29,61.25 325.29,60.99 324.91,60.61 324.91,60.18 325.5,59.59 YJ33.D28
N31678800: length 14.9
  TOP w0.13: R2835.1 326.2,76.45 v1(325.18,75.44)
  SIG4 w0.155: YJ33.C27 326.3,65.03 326.92,65.65 326.92,73.7 v1(325.18,75.44)
N31678803: length 15.1
  SIG4 w0.155: YJ33.C28 325.5,72.64 325.18,72.96 v1(325.18,73.66)
  BOTTOM w0.13: R2836.1 324.83,77.87 324.68,77.72 324.68,74.17 v1(325.18,73.66) 325.31,73.66 326.58,74.93 v2(326.58,75.31)
N31687868: length 29.3
  TOP w0.13: R2848.2 324.52,83.72 324.68,83.56 324.68,82.67 v1(324.17,82.17)
  SIG9 w0.155: YJ34.B28 323.9,58.81 324.52,59.43 324.52,60.59 324.14,60.97 324.14,61.29 324.52,61.67 324.52,64.59 324.14,64.97 324.14,65.29 324.53,65.68 324.53,72.53 323.66,73.4 323.66,81.66 v1(324.17,82.17)
  BOTTOM w0.13: v2(323.41,81.15) 323.41,81.4 v1(324.17,82.17)
N31687871: length 36.4
  SIG8 w0.155: v1(324.17,86.23) 324.68,85.72 324.68,68.45 322.52,66.29 322.52,65.61 322.86,65.27 322.86,64.95 322.47,64.56 322.47,61.66 322.86,61.27 322.86,60.97 322.51,60.62 322.51,60.17 324.53,58.15 324.53,57.66 324.14,57.27 323.95,57.27 YJ34.B27
  BOTTOM w0.13: v2(323.05,88.39) 323.66,87.78 R2846.2 324.68,87.27 324.68,86.74 v1(324.17,86.23)
N31687984: length 13.5
  SIG6 w0.155: v1(324.17,75.44) 324.68,74.93 324.68,67.43 323.9,66.66 YJ34.A28
  BOTTOM w0.13: R2850.1 323.81,77.87 323.53,77.59 323.53,76.83 v2(323.28,76.58) 323.28,76.32 v1(324.17,75.44)
N31687987: length 14.5
  TOP w0.13: R2852.1 v1(324.17,77.21)
  SIG6 w0.155: YJ34.A27 323.1,65.03 322.41,65.72 322.41,66.31 323.66,67.56 323.66,76.71 v1(324.17,77.21)
N31699202: length 26.9
  TOP w0.13: R2847.2 v1(311.34,77.21)
  SIG8 w0.155: YJ34.D28 304.9,58.81 305.52,59.43 305.52,60.59 305.14,60.97 305.14,61.27 305.52,61.65 305.52,64.59 305.14,64.97 305.14,65.29 305.53,65.68 305.53,73.18 307.28,74.93 307.28,77.24 308.27,78.23 310.78,78.23 311.34,77.67 v1(311.34,77.21)
N31699205: length 25.8
  SIG9 w0.155: v1(307.91,75.44) 304.74,72.26 304.74,67.82 303.52,66.59 303.52,65.61 303.86,65.27 303.86,64.95 303.47,64.56 303.47,61.66 303.86,61.27 303.86,60.95 303.3,60.39 303.3,57.83 303.8,57.33 303.8,57.33 304.1,57.03 YJ34.D27
  BOTTOM w0.13: v2(307.02,75.44) v1(307.91,75.44) 308.42,75.94 308.42,77.72 308.27,77.87 R2845.2
N31699224: length 18.3
  TOP w0.13: R2849.1 v1(309.05,80.64)
  SIG8 w0.155: v1(309.05,80.64) 308.55,80.13 308.55,79.22 306.65,77.32 306.65,74.93 304.9,73.18 YJ34.C28
  BOTTOM w0.13: v1(309.05,80.64) 309.44,81.02 v2(309.44,81.53)
N31699227: length 16.2
  TOP w0.13: R2851.1 306.49,75.92 v1(305.75,75.18)
  SIG6 w0.155: YJ34.C27 304.1,65.03 303.41,65.72 303.41,66.74 304.99,68.32 304.99,74.42 v1(305.75,75.18)
  BOTTOM w0.13: v1(305.75,75.18) 305.75,75.69 v2(305.24,76.2)
N31999676: length 21.7
  SIG4 w0.155: v1(351.85,73.4) 351.35,72.9 351.35,70.48 353.5,68.33 YJ35.A28
  BOTTOM w0.13: v1(351.85,73.4) 352.17,73.08 355.09,73.08 357.57,75.56 v2(357.57,75.94) 358.2,76.58 358.2,80.52 357.82,80.9 R2866.1
N31999679: length 21.5
  SIG4 w0.155: YJ35.A27 354.3,65.04 354.92,65.66 354.92,67.54 352.62,69.85 352.62,73.02 v1(354.01,74.42)
  BOTTOM w0.13: R2865.1 356.81,80.77 357.88,79.7 357.88,77.27 356.3,75.69 v2(356.3,75.31) 355.41,74.42 v1(354.01,74.42)
N31999724: length 24.3
  TOP w0.13: R2867.2 355.79,77.59 353.38,75.18 352.49,75.18 v1(351.85,74.55)
  SIG2 w0.152: v1(351.85,74.55) 351.22,73.91 351.22,69.21 353.17,67.26 353.17,66.33 352.92,66.08 352.92,65.61 353.26,65.27 353.26,64.97 352.88,64.59 352.88,61.67 353.28,61.27 353.28,60.99 352.9,60.61 352.9,58.98 353.5,58.38 YJ35.B28
N31999727: length 25.1
  SIG2 w0.152: YJ35.B27 353.57,57.15 353.41,57.15 352.5,58.06 352.5,60.62 352.49,60.62 352.15,60.96 352.15,61.28 352.5,61.63 352.5,64.62 352.49,64.62 352.16,64.95 352.16,65.3 352.53,65.67 352.53,67.31 350.2,69.63 350.2,76.2 v1(349.44,76.96)
  BOTTOM w0.13: v2(348.68,76.58) 349.06,76.58 v1(349.44,76.96) 349.59,77.11 R2872.2
N32008720: length 14.4
  SIG1 w0.16: v1(375.86,73.02) 375.86,69.18 YJ35.C28
  BOTTOM w0.13: v1(375.86,73.02) 377.38,74.55 377.38,75.73 377.25,75.85 v2(377.25,76.45) 376.62,77.09 R2870.1
N32008723: length 17.6
  TOP w0.13: v1(378.54,76.97) 378,76.97 377.63,77.34 R2869.1
  SIG1 w0.16: YJ35.C27 373.3,65.03 373.86,65.59 373.86,66.32 376.62,69.09 376.62,72.39 378.54,74.31 v1(378.54,76.97)
  BOTTOM w0.13: v2(379.79,76.83) 378.68,76.83 v1(378.54,76.97)
N32009355: length 22.1
  TOP w0.13: R2871.2 370.14,72.39 v1(369.63,71.88)
  SIG3 w0.155: YJ35.D28 372.5,58.38 371.9,58.98 371.9,60.61 372.28,60.99 372.28,61.25 371.88,61.65 371.88,64.59 372.26,64.97 372.26,65.27 371.92,65.61 371.92,66.55 370.14,68.33 370.14,71.37 v1(369.63,71.88)
N32009358: length 26.8
  SIG3 w0.155: v1(369.63,69.7) 369.63,68.07 371.53,66.18 371.53,65.66 371.49,65.62 371.49,65.62 371.2,65.33 371.2,65.33 371.16,65.29 371.16,64.95 371.5,64.61 371.5,61.62 371.49,61.62 371.12,61.25 371.12,60.99 371.5,60.61 371.5,58.06 372.41,57.15 372.57,57.15 YJ35.D27
  BOTTOM w0.13: R2873.2 v2(373.57,76.58) 374.07,76.08 374.07,72.25 371.92,70.1 370.04,70.1 v1(369.63,69.7)
N32021119: length 28.5
  TOP w0.13: R2885.2 373.57,75.44 v1(371.92,73.78)
  SIG8 w0.155: YJ36.B27 370.74,57.06 370.93,57.06 371.53,57.66 371.53,58.15 369.51,60.17 369.51,60.62 369.86,60.97 369.86,61.27 369.51,61.62 369.51,61.62 369.47,61.66 369.47,64.56 369.86,64.95 369.86,65.27 369.52,65.61 369.52,66.94 372.43,69.85 372.43,73.28 v1(371.92,73.78)
  BOTTOM w0.13: v1(371.92,73.78) 373.06,73.78 373.44,74.17 v2(373.44,75.31)
N32021122: length 23.6
  SIG9 w0.155: YJ36.B28 370.9,58.81 371.52,59.43 371.52,60.59 371.14,60.97 371.14,61.29 371.52,61.67 371.52,64.59 371.14,64.97 371.14,65.29 371.53,65.68 371.53,66.66 372.62,67.75 372.62,70.55 370.4,72.77 v1(369.63,72.77)
  BOTTOM w0.13: v1(369.63,72.77) 370.18,73.32 370.18,74.89 v2(369.76,75.31) 369.76,77 370.14,77.38 R2887.2
N32021813: length 13.6
  TOP w0.13: R2890.1 374.59,77.47 374.33,77.21 374.33,75.18 371.79,72.64 v1(371.79,70.61)
  SIG9 w0.155: v1(371.79,70.61) 371.79,67.56 370.9,66.67 YJ36.A28
N32021816: length 15
  SIG6 w0.155: v1(370.78,70.61) 370.78,70 369.51,68.73 369.51,65.63 370.1,65.04 YJ36.A27
  BOTTOM w0.13: v1(370.78,70.61) 371.28,71.12 371.28,73.78 v2(372.17,74.67) 372.43,74.93 372.43,77.21 372.3,77.34 R2893.1
N32032934: length 26.5
  TOP w0.13: v1(350.71,74.17) 350.96,73.91 352.87,73.91 355.22,76.26 355.6,76.26 356.81,77.47 R2886.2
  SIG8 w0.155: YJ36.D28 351.9,58.81 352.52,59.43 352.52,60.59 352.14,60.97 352.14,61.27 352.52,61.65 352.52,64.59 352.14,64.97 352.14,65.29 352.53,65.68 352.53,68.54 350.2,70.86 350.2,73.66 v1(350.71,74.17)
N32032937: length 24.4
  TOP w0.13: R2892.2 348.93,77.19 348.93,76.58 v1(349.44,76.07)
  SIG9 w0.155: YJ36.D27 351.1,57.04 350.3,57.84 350.3,60.39 350.86,60.95 350.86,61.27 350.47,61.66 350.47,64.56 350.86,64.95 350.86,65.27 350.52,65.61 350.52,66.99 349.95,67.56 349.95,75.56 v1(349.44,76.07)
  BOTTOM w0.13: v2(348.93,75.31) 349.44,75.82 v1(349.44,76.07)
N32033441: length 15.3
  SIG6 w0.155: v1(345.63,76.32) 345.63,75.44 347.92,73.15 347.92,71.24 351.9,67.26 YJ36.C28
  BOTTOM w0.13: v1(345.63,76.32) 346.14,76.83 346.14,77.72 345.99,77.87 R2889.1
N32033444: length 16.2
  SIG6 w0.155: YJ36.C27 351.1,65.03 350.41,65.72 350.41,66.97 347.15,70.22 347.15,71.88 v1(346.65,72.39)
  BOTTOM w0.13: R2888.1 345,77.49 345,76.2 345.76,75.44 v2(345.88,75.44) 346.65,74.67 v1(346.65,72.39)
N32118226: length 11.1
  TOP w0.13: U123.G11 v1(27.25,160.6)
  SIG2 w0.102: 28.68,159.13 28,159.13 27.65,159.48 27.65,160.2 v1(27.25,160.6)
  SIG2 w0.152: 28.68,159.13 29.91,159.13 30.42,159.64 33.54,159.64 v1(34.61,158.57)
  BOTTOM w0.13: R3274.1 35.52,158.09 35.37,158.24 34.94,158.24 v1(34.61,158.57)
N32118228: length 8.6
  TOP w0.13: U123.G12 v1(28.05,160.6)
  SIG2 w0.102: 30.13,161 28.45,161 v1(28.05,160.6)
  SIG2 w0.152: 30.13,161 30.32,161 30.67,160.65 34.07,160.65 v1(34.61,160.12)
  BOTTOM w0.13: v1(34.61,160.12) 34.71,160.02 R3266.1
N32118230: length 9.1
  TOP w0.13: U123.F12 v1(28.05,161.4)
  SIG2 w0.102: v1(28.05,161.4) 28.45,161.8 30.32,161.8
  SIG2 w0.152: 30.32,161.8 33.47,161.8 34.35,162.68 v1(34.63,162.68)
  BOTTOM w0.13: R3269.1 35.27,163.57 34.63,162.94 v1(34.63,162.68)
N32118232: length 11.3
  TOP w0.13: U123.F13 v1(28.85,161.4)
  BOTTOM w0.102: 30.04,161.8 29.25,161.8 v1(28.85,161.4)
  BOTTOM w0.13: v2(36,167.1) 35.52,166.62 R3264.1 34.99,165.86 34.35,165.22 34.35,164.23 33.97,163.85 33.11,163.85 32.07,162.81 32.07,162.46 31.41,161.8 30.04,161.8
N32118234: length 8
  TOP w0.13: U123.G13 v1(28.85,160.6)
  BOTTOM w0.102: 30.04,161 29.25,161 v1(28.85,160.6)
  BOTTOM w0.13: 30.04,161 31.58,161 32.37,161.8 34.1,161.8 v2(34.23,161.92) 34.61,161.92 35.12,162.43 R3273.1
N32118236: length 8.7
  TOP w0.13: U123.H13 28.85,159 31.79,159 32.16,159.36 33.73,159.36 34.1,159.74 34.1,160.39 34.35,160.64 35.36,160.64 35.52,160.8 R3279.1
N32118238: length 8.7
  TOP w0.13: U123.H12 v1(28.05,159.8)
  BOTTOM w0.102: v1(28.05,159.8) 28.45,160.2 29.98,160.2
  BOTTOM w0.13: R3276.1 34.99,158.87 34.48,159.38 v2(32.58,159.38) 32.19,159.38 31.37,160.2 29.98,160.2
N32118254: length 5.8
  BOTTOM w0.13: v2(21.53,173.35) 22.39,172.49 R3320.2 R3321.1 23.94,172.08 23.81,171.96 23.81,171.19 23.94,171.07 R3318.2 R3319.1
N32118290: length 5.7
  TOP w0.13: R3272.1 25.46,168.15 25.59,168.02 25.59,165.35 25.65,165.29 25.65,164.6 U123.B9
N32118294: length 6.1
  TOP w0.13: R3290.1 R3292.1 27.5,169.03 26.96,168.5 26.96,165.33 26.85,165.22 U123.A11
N32118315: length 3
  TOP w0.13: Q5.1 40.7,152.4 41.06,152.75 R3315.1 42.13,152.75 v1(42.61,152.27)
N32118330: length 12.5
  TOP w0.13: U123.F9 v1(25.65,161.4)
  SIG2 w0.152: v1(25.65,161.4) 25.08,161.97 25.08,165.48 27.37,167.76 v1(28.51,167.76)
  BOTTOM w0.13: v2(27.75,167.56) 27.95,167.76 v1(28.51,167.76) 28.51,168.01 29.65,169.15 R3275.1
N32118356: length 7.9
  TOP w0.13: U123.D10 v1(26.45,163)
  BOTTOM w0.102: v1(26.45,163) 26.05,163.4 26.05,163.98
  BOTTOM w0.13: 26.05,163.98 26.05,164.89 25.59,165.35 25.59,165.99 25.97,166.37 v2(25.97,166.75) 26.23,167 R3281.1
N32118384: length 8.7
  TOP w0.13: U123.C12 v1(28.05,163.8)
  BOTTOM w0.13: R3311.1 R3313.1 30.8,169.52 29.15,167.88 29.15,167.14 v2(28.89,166.88) 28.51,166.49 28.51,164.26 v1(28.05,163.8)
N32118454: length 5.9
  TOP w0.13: U121.5 R3244.1 203.87,202.66 204.03,202.82 204.03,204.85 203.87,205 R34.1
N32118456: length 5.9
  TOP w0.13: U121.6 R33.1 202.6,202.66 202.76,202.82 202.76,204.85 202.6,205 R3247.1
N32118493: length 5.9
  TOP w0.13: U121.7 R3242.1 201.33,202.66 201.49,202.82 201.49,204.85 201.33,205 R35.1
N32118597: length 7.6
  TOP w0.13: R3307.1 31.94,168.91 31.43,168.4 30.8,168.4 30.29,167.89 30.29,167 29.4,166.11 29.02,166.11 28.79,165.88 28.79,165.23 28.85,165.16 28.85,164.6 U123.B13
N32118603: length 12.4
  TOP w0.13: U123.F8 v1(24.05,161.4)
  BOTTOM w0.102: 19.63,160.2 22.73,160.2 22.85,160.33 22.85,160.83 23.03,161 23.65,161 v1(24.05,161.4)
  BOTTOM w0.13: R3263.1 R3255.1 v2(16.57,160.53) 17.59,160.53 17.88,160.23 19.6,160.23 19.63,160.2
N32118631: length 8.7
  TOP w0.13: R3316.1 R3317.1 33.08,167.89 31.31,166.11 30.42,166.11 29.65,165.35 29.65,164.6 U123.B14
N32118832: length 17
  TOP w0.13: U123.F10 v1(26.45,161.4)
  SIG2 w0.102: 26.85,164.43 26.85,161.79 26.47,161.4 v1(26.45,161.4)
  SIG2 w0.152: v1(34.23,168.91) 30.8,168.91 28.13,166.24 27.5,166.24 26.85,165.6 26.85,164.43
  BOTTOM w0.13: v2(37,169.69) R3296.1 R3299.1 34.61,169.29 v1(34.23,168.91)
N32118872: length 10.8
  TOP w0.13: Q5.3 39.05,149.98 38.29,149.22 v1(38.04,149.22) 36.13,149.22 35.52,149.83 R3312.1 34.73,150.11 32.96,151.89 32.58,151.89 31.81,152.65 31.81,152.84 U123.R16
N32119094: length 7.1
  TOP w0.13: U123.B5 v1(21.65,164.6)
  BOTTOM w0.13: v1(21.65,164.6) 21.65,165.76 20.78,166.64 20.78,168.64 20.38,169.03 19.49,169.03 19.37,169.16 R3257.2
N32119389: length 6.5
  TOP w0.13: U123.B6 22.45,164.6 22.45,165.36 21.17,166.65 21.17,168.25 20.51,168.91 R3258.2
N32119403: length 8.5
  TOP w0.13: U123.C5 v1(21.65,163.8)
  BOTTOM w0.13: v1(21.65,163.8) 21.2,164.25 21.2,165.75 20.45,166.5 20.45,168.02 v2(20.1,168.37) 19.95,168.53 18.86,168.53 18.22,169.16 R3271.2
N32119405: length 6.8
  TOP w0.13: R3268.2 18.22,168.91 18.6,168.53 19.97,168.53 20.48,168.03 20.48,166.3 21.25,165.52 U123.A4
N32119419: length 8.3
  TOP w0.13: R3280.1 17.08,169.16 18.03,168.21 19.84,168.21 20.16,167.89 20.16,166.16 20.85,165.47 20.85,164.6 U123.B4
N32119421: length 13.2
  TOP w0.13: v1(34.61,151.13) 34.61,151.64 34.86,151.89 R3297.1 ; U123.L12 v1(28.05,156.6)
  SIG2 w0.102: 29.97,156.2 28.45,156.2 v1(28.05,156.6)
  SIG2 w0.152: 29.97,156.2 30.3,156.2 30.67,155.83 30.67,155.06 31.94,153.79 31.94,152.27 32.45,151.76 34.35,151.76 34.61,151.51 v1(34.61,151.13)
  BOTTOM w0.13: v1(34.61,151.13) v2(35.37,151.13)
N32119441: length 11.6
  TOP w0.13: U123.D6 v1(22.45,163)
  BOTTOM w0.102: v1(22.45,163) 22.05,162.6 19.79,162.6
  BOTTOM w0.13: 19.79,162.6 16.78,162.6 16.57,162.81 16.57,163.32 16.32,163.57 15.94,163.57 15.18,164.34 15.18,165.86 14.8,166.24 R3282.2
N32119628: length 11
  TOP w0.13: U123.E6 v1(22.45,162.2)
  BOTTOM w0.102: v1(22.45,162.2) 22.05,161.8 19.7,161.8
  BOTTOM w0.13: R3302.2 14.67,165.1 14.8,164.97 14.8,163.7 16.24,162.26 17.76,162.26 18.22,161.8 19.7,161.8
N32119983: length 264.5
  TOP w0.13: v1(34.61,154.81) 34.1,154.3 31.43,154.3 31.13,154.6 U123.P16 ; R3308.2 215.33,189.48 216.19,190.35 225.53,190.35 226.31,191.13 226.31,203.51 218.25,211.58 v1(211.52,211.58)
  SIG9 w0.155: v1(211.52,211.58) 210.88,210.94 161.74,210.94 151.48,200.68 73.05,200.68 71.18,202.55 61.04,202.55 46.8,188.3 46.8,183 43.12,179.32 43.12,160.02 39.05,155.95 36.13,155.95 35.5,155.32 35.12,155.32 v1(34.61,154.81)
  BOTTOM w0.13: v2(211.9,212.34) 211.52,211.96 v1(211.52,211.58)
N32119995: length 166.1
  TOP w0.13: v1(142.18,184.78) 142.18,184.42 151.6,175 151.6,169.46 153.42,167.64 R3306.2 ; v1(32.73,154.79) 32.59,154.93 31.15,154.93 31.08,155 30.45,155 U123.N15
  SIG7 w0.155: v1(142.18,184.78) 119.82,184.78 114.49,190.12 110.15,190.12 105.83,194.43 63.31,194.43 52.14,183.26 52.14,178.18 43.24,169.29 43.24,158.49 39.56,154.81 36.77,154.81 36.13,154.18 33.34,154.18 v1(32.73,154.79)
  BOTTOM w0.13: v2(32.96,154.05) 32.73,154.28 v1(32.73,154.79)
N32120180: length 2.5
  TOP w0.13: R3241.1 v1(199.61,192.91) U121.1
N32120201: length 9.5
  TOP w0.13: U123.D3 v1(20.05,163)
  BOTTOM w0.13: v1(20.05,163) 18.24,163 17.59,163.65 17.59,164.34 17.34,164.59 15.94,164.59 15.56,164.97 15.56,166.62 14.8,167.38 R3344.1
N32120203: length 5.9
  TOP w0.13: R3326.1 15.3,160.53 15.46,160.37 17.36,160.37 17.93,159.8 19.25,159.8 U123.H2
N32120253: length 9.4
  TOP w0.13: U123.A2 19.57,165 18.28,166.29 15.35,166.29 14.67,165.61 12,165.61 X249.1
N32120329: length 5.7
  TOP w0.13: U123.A13 28.45,166.31 29.65,167.51 29.65,168.02 30.8,169.16 R3323.2
N32120333: length 12.5
  TOP w0.13: U123.J11 v1(27.25,158.2)
  BOTTOM w0.102: 28.45,153.75 28.45,156.88 28.33,157.01 27.78,157.01 27.65,157.14 27.65,157.81 v1(27.25,158.2)
  BOTTOM w0.13: R3294.1 29.76,148.31 29.88,148.44 29.88,149.07 v2(30.16,149.35) 30.16,149.6 29.88,149.88 29.88,151.41 28.45,152.84 28.45,153.75
N32120418: length 14.8
  TOP w0.13: U123.B7 23.25,164.6 23.25,165.17 23.13,165.3 23.13,165.61 22.8,165.94 22.8,168.15 21.65,169.29 R3295.2 22.16,170.2 22.16,172.03 21.47,172.72 21.47,175.71 21.78,176.02 Q6.3
N32120471: length 16.5
  TOP w0.13: v1(39.18,167) 39.18,167.38 39.46,167.66 R3262.1 ; U123.E14 v1(29.65,162.2)
  SIG2 w0.102: 29.25,164.09 29.25,162.6 v1(29.65,162.2)
  SIG2 w0.152: 29.25,164.09 29.25,164.32 29.78,164.84 29.78,165.61 30.29,166.11 33.85,166.11 34.23,166.49 38.67,166.49 v1(39.18,167)
  BOTTOM w0.13: v1(39.18,167) 39.81,167 v2(39.94,166.88)
N32120475: length 6.8
  TOP w0.13: U123.J3 v1(20.05,158.2)
  BOTTOM w0.13: v1(20.05,158.2) 19.11,159.14 v2(16.57,159.14) 15.8,159.14 15.56,159.38 R3333.1
N32120477: length 9.7
  TOP w0.13: U123.K6 v1(22.45,157.4)
  BOTTOM w0.102: 19.75,157 22.05,157 v1(22.45,157.4)
  BOTTOM w0.13: 19.75,157 18.07,157 17.38,157.69 14.5,157.69 14.26,157.45 R3329.2
N32120495: length 6.8
  TOP w0.13: U123.E15 30.45,162.2 31.48,162.2 32.42,163.14 33.85,163.14 34.1,162.89 34.1,162.43 34.35,162.18 34.99,162.18 35.24,162.43 R3254.2
N32120573: length 3.9
  TOP w0.13: D427.1 40.32,170.43 40.07,170.18 R3262.2 v1(41.06,169.14)
N32120616: length 6.7
  TOP w0.13: R3334.1 17.46,149.32 18.73,150.59 18.73,151.51 20.05,152.83 20.05,153.4 U123.R3
N32120618: length 6.7
  TOP w0.13: U123.P4 v1(20.85,154.2)
  BOTTOM w0.13: v1(20.85,154.2) 20.85,151.6 20.51,151.25 v2(20.51,149.98) 20.26,149.73 R3331.1
N32120622: length 5.4
  TOP w0.13: U123.T5 22.05,152.54 20.8,151.29 20.8,149.64 20.26,149.1 R3338.1
N32120624: length 10.7
  TOP w0.13: U123.L7 v1(23.25,156.6)
  BOTTOM w0.102: v1(23.25,156.6) 23.65,156.2 23.65,153.77
  BOTTOM w0.13: 23.65,153.77 23.65,152.51 24.07,152.09 24.07,150.11 23.69,149.73 R3340.1 23.15,148.31 v2(22.54,147.7)
N32120626: length 9.6
  TOP w0.13: U123.M7 v1(23.25,155.8)
  BOTTOM w0.102: v1(23.25,155.8) 22.85,155.4 22.85,153.6
  BOTTOM w0.13: 22.85,153.6 22.85,151.69 22.03,150.87 22.03,149.73 v2(22.42,149.35) 22.42,148.59 22.14,148.31 R3342.1
N32120656: length 6
  TOP w0.13: U123.T7 23.65,152.31 22.8,151.45 22.8,149.1 22.01,148.31 R3346.1
N32120658: length 4.8
  TOP w0.13: R3327.2 15.1,158.24 15.3,158.04 18.02,158.04 18.25,157.8 U123.K1
N32120660: length 7.7
  TOP w0.13: U123.N8 24.85,155 24.85,152.78 24.78,152.7 24.78,151.99 24.13,151.34 24.13,150.37 23.94,150.18 23.94,149.35 23.69,149.1 R3350.1
N32120925: length 7.1
  TOP w0.13: R3303.1 29.65,169.03 28.89,168.27 28.13,168.27 27.29,167.43 27.29,165.15 27.25,165.12 27.25,164.6 U123.B11
N32121093: length 8.8
  TOP w0.13: U123.C10 v1(26.45,163.8)
  BOTTOM w0.13: R3284.2 28.11,170.66 28,170.56 28,169.92 27.78,169.69 R3287.1 27.37,168.98 v2(26.84,168.45) 26.61,168.22 26.61,163.95 v1(26.45,163.8)
N32121131: length 5.8
  TOP w0.13: U123.B10 26.45,164.6 26.45,165.33 26.61,165.48 26.61,165.99 26.48,166.11 R3286.2
N32121153: length 8.4
  TOP w0.13: R3265.2 14.67,166.24 15.81,167.38 17.92,167.38 20.05,165.25 20.05,164.6 U123.B3
N32121284: length 8.1
  TOP w0.13: U123.C6 v1(22.45,163.8)
  BOTTOM w0.13: R3289.2 20.51,169.42 21.27,168.65 22.03,168.65 22.66,168.03 22.66,167.27 22.95,166.98 v2(22.95,166.62) 22.45,166.13 v1(22.45,163.8)
N32121533: length 5.7
  TOP w0.13: U123.C16 31.08,163.4 32.85,165.17 34.3,165.17 34.99,165.86 R3261.1
N32121535: length 6.4
  TOP w0.13: R3256.1 32.98,164.84 31.14,163 30.45,163 U123.D15
N32121537: length 6.8
  TOP w0.13: U123.B16 31.84,165.19 31.84,165.99 34,168.15 R3253.1
N32121547: length 7.2
  TOP w0.13: R3252.1 35.52,166.62 35.27,166.37 33.59,166.37 31.03,163.8 30.45,163.8 U123.C15
N32121612: length 7.4
  TOP w0.13: U123.C7 v1(23.25,163.8)
  BOTTOM w0.13: R3298.1 21.65,169.64 v2(23.28,168.02) 23.28,167.38 23.56,167.1 23.56,166.37 23.28,166.09 23.28,163.83 v1(23.25,163.8)
N32121756: length 6.7
  TOP w0.13: U123.C9 v1(25.65,163.8)
  BOTTOM w0.13: v1(25.65,163.8) 25.65,164.78 25.31,165.12 v2(25.31,168.4) 25.31,168.81 25.08,169.03 R3267.1
N32121837: length 6.5
  TOP w0.13: R3249.1 U122.6 v1(395.92,99.41)
  BOTTOM w0.13: R30.1 394.88,100.35 v2(395.03,100.2) 395.82,99.41 v1(395.92,99.41)
N32121839: length 3.6
  TOP w0.13: U122.5 398.46,98.14 398.72,98.4 R3250.1 R31.1
N32121881: length 7.1
  TOP w0.13: R3245.1 U122.7 v1(395.95,100.68)
  BOTTOM w0.13: v1(395.95,100.68) 396.18,100.91 v2(396.18,102.61) R32.1
N32121920: length 7.7
  TOP w0.13: R3278.2 15.05,167.38 15.43,167.76 18,167.76 20.45,165.31 U123.A3
N32166567: length 9.7
  TOP w0.13: U124.H11 v1(404.42,181.65)
  BOTTOM w0.102: 407.48,182.24 407.28,182.05 404.82,182.05 v1(404.42,181.65)
  BOTTOM w0.13: 407.48,182.24 407.82,182.58 408.33,182.58 409.13,183.39 v2(411.42,183.39) 411.8,183.39 412.18,183.77 R3383.1
N32166569: length 10.9
  TOP w0.13: U124.J11 v1(404.42,180.05)
  BOTTOM w0.102: v1(404.42,180.05) 404.82,179.65 407.16,179.65 407.57,179.23
  BOTTOM w0.13: R3386.1 412.31,178.69 411.8,178.18 411.8,177.67 v2(411.42,177.29) 409.51,177.29 407.57,179.23
N32166575: length 7.4
  TOP w0.13: R3370.1 411.16,181.23 411.12,181.18 409.3,181.18 408.96,180.85 406.02,180.85 U124.H13
N32166577: length 9.2
  TOP w0.13: U124.J12 v1(405.22,180.05)
  BOTTOM w0.13: R3373.1 412.2,181.99 v2(411.54,181.99) 411.04,181.48 410.63,181.48 410.5,181.61 410.05,181.61 409.92,181.48 408.88,181.48 408.22,180.82 406.18,180.82 405.41,180.05 v1(405.22,180.05)
N32166579: length 5.2
  TOP w0.13: U124.J16 409.12,180.45 409.54,180.86 411.02,180.86 411.92,179.96 R3378.1
N32166581: length 6.9
  TOP w0.13: U124.J14 v1(406.82,180.05)
  BOTTOM w0.13: v1(406.82,180.05) 408.86,180.05 409,179.91 410.98,179.91 411.42,180.34 v2(411.54,180.34) 411.92,179.96 R3381.1
N32167148: length 7.5
  TOP w0.13: U124.C6 v1(399.62,185.65)
  BOTTOM w0.13: v1(399.62,185.65) 399.62,187.26 398.7,188.17 398.7,189.49 v2(398.34,189.86) 397.07,191.13 R3382.2
N32167346: length 7.7
  TOP w0.13: U124.J13 v1(406.02,180.05)
  BOTTOM w0.13: v1(406.02,180.05) 406.47,180.5 409.16,180.5 409.64,180.97 v2(410.27,180.97) 411.8,180.97 412.05,181.23 R3385.1
N32167587: length 9.7
  TOP w0.13: U124.F9 v1(402.82,183.25)
  BOTTOM w0.102: v1(402.82,183.25) 403.22,183.65 403.22,185.98 403.58,186.34
  BOTTOM w0.13: 403.58,186.34 404.43,187.2 404.43,189.99 v2(404.81,190.37) 404.69,190.5 R3363.1
N32167649: length 6.4
  BOTTOM w0.13: R3403.2 R3404.1 400.47,195.3 400.24,195.07 400.24,192.66 400.39,192.5 R3400.1 R3399.2
N32168026: length 10.2
  TOP w0.13: U124.C10 v1(403.62,185.65)
  BOTTOM w0.13: v1(403.62,185.65) 405.05,187.08 405.05,187.94 405.45,188.34 405.45,191.41 405.57,191.54 R3380.1 R3376.2 407.23,190.45 v2(407.35,190.32)
N32168064: length 6.6
  TOP w0.13: U124.B10 403.62,186.45 403.62,187.81 404.08,188.28 404.08,189.51 405.96,191.39 R3377.2
N32168163: length 254.9
  TOP w0.13: R3392.1 204.51,190.73 204.79,191.01 204.79,191.51 205.5,192.23 205.5,201.55 207.56,203.61 v1(207.56,204.29) ; U124.C12 v1(405.22,185.65)
  SIG6 w0.155: v1(207.56,204.29) 207.56,205.44 208.36,206.25 211.65,206.25 212.62,207.22 234.72,207.22 240.79,213.29 259.84,213.29 260.54,212.6 264.45,212.6 265.21,213.36 270.05,213.36 272,215.31 281.23,215.31 284.4,218.48 318.56,218.48 330.75,206.29 358.95,206.29 371.17,194.07 382.27,194.07 384.59,196.39 384.59,197.4 388.18,200.99 403.53,200.99 410.15,194.38 410.15,188.59 409.38,187.83 406.59,187.83 405.22,186.46 v1(405.22,185.65)
  BOTTOM w0.13: v1(207.56,204.29) v2(207.56,205.05)
N32168175: length 248.6
  TOP w0.13: v1(205.75,204.29) 205.75,202.67 204.89,201.81 204.89,192.51 203.64,191.26 203.14,191.26 203.01,191.13 R3393.1 ; U124.B12 405.22,186.45 405.22,187.53 405.74,188.05 405.74,188.37 v1(405.93,188.57)
  SIG6 w0.155: v1(205.75,204.29) 206.37,203.67 213.04,203.67 214.05,204.67 240.43,204.67 245.3,209.55 259.02,209.55 259.27,209.8 280.89,209.8 281.75,210.65 281.75,211.79 285.59,215.63 305.05,215.63 305.75,216.33 317.7,216.33 329.66,204.38 358.16,204.38 370.38,192.16 374.4,192.16 375.84,190.73 382.73,190.73 387.9,195.89 387.9,196.49 390.33,198.92 402.5,198.92 406.46,194.96 406.46,192.15 405.45,191.13 405.45,189.05 v1(405.93,188.57)
  BOTTOM w0.13: v1(205.75,204.29) v2(205.75,205.05)
N32168363: length 11.5
  TOP w0.13: U124.B3 397.22,186.45 397.22,187.09 395.8,188.52 395.8,188.85 394.53,190.12 393,190.12 391.99,191.13 R3357.2 390.84,191.54 390.61,191.77 Q42.3
N32168450: length 9.4
  TOP w0.13: U124.C5 v1(398.82,185.65)
  BOTTOM w0.13: R3360.2 394.53,190.62 v2(394.84,190.31) 394.91,190.24 396.94,190.24 397.32,189.86 397.32,188.34 398.06,187.6 398.06,186.41 v1(398.82,185.65)
N32168466: length 5.6
  TOP w0.13: U124.A5 399.22,187.15 397.97,188.4 397.97,190.1 397.07,191.01 R3366.2
N32168480: length 6.2
  TOP w0.13: R3354.2 398.34,188.49 399.62,187.21 399.62,186.45 U124.B6
N32168512: length 7.9
  TOP w0.13: R3368.2 394.53,191.13 394.78,190.88 396.18,190.88 397.32,189.74 397.32,188.01 398.02,187.31 398.02,186.45 U124.B4
N32168516: length 7.2
  TOP w0.13: U124.A3 397.62,187.15 396.12,188.65 396.12,189.16 394.78,190.5 393.64,190.5 393.26,190.88 R3367.2
N32168542: length 9.3
  TOP w0.13: U124.D6 v1(399.62,184.85)
  BOTTOM w0.102: 399.22,186.82 399.22,185.25 v1(399.62,184.85)
  BOTTOM w0.13: 399.22,186.82 399.22,186.95 397.95,188.21 v2(397.95,188.59) 397.65,188.9 397.65,189.99 397.02,190.62 396.18,190.62 395.8,191.01 R3372.2
N32168566: length 10.2
  TOP w0.13: U124.E7 v1(400.42,184.05)
  BOTTOM w0.102: 400.02,186.49 400.02,184.45 v1(400.42,184.05)
  BOTTOM w0.13: v2(399.61,191.54) R3375.2 398.34,190.75 399.03,190.06 399.03,188.33 400.02,187.34 400.02,186.49
N32168847: length 3.7
  TOP w0.13: v1(411.16,191.51) 410.65,192.02 D428.1 409.87,192.68 409.28,193.27 R3361.2
N32168849: length 11.6
  TOP w0.13: R3361.1 408.62,190.75 v1(408.88,190.5) ; U124.B9 402.82,186.45 402.82,188.12 v1(403.26,188.57)
  SIG9 w0.155: v1(408.88,190.5) 408.5,190.12 404.56,190.12 403.26,188.82 v1(403.26,188.57)
  BOTTOM w0.13: v1(403.26,188.57) 403.19,188.57 v2(402.68,189.08)
N32168979: length 2.5
  TOP w0.13: X252.1 395.16,188.41 396.73,186.85 U124.A2
N32168993: length 7.3
  TOP w0.13: U124.C9 v1(402.82,185.65)
  BOTTOM w0.13: v1(402.82,185.65) 402.82,186.27 403.92,187.37 403.92,189.68 v2(403.21,190.4) 403.42,190.6 R3358.1
N32240710: length 3.5
  TOP w0.381: C303.1 265.24,218.11 265.01,217.88 U44.4
N32247716: length 6.1
  TOP w0.13: U124.A4 398.42,187.37 397.64,188.14 397.64,189.87 396.56,190.96 396.56,191.39 396.41,191.54 R3353.2
N32265631: length 3.3
  TOP w0.13: v1(270.42,180.82) R361.1 269.61,179.73 269.46,179.58 U14.5
N32287581: length 7.7
  TOP w0.13: U123.L4 v1(20.85,156.6)
  BOTTOM w0.102: v1(20.85,156.6) 20.45,156.2 19.75,156.2
  BOTTOM w0.13: 19.75,156.2 18.95,156.2 18.56,156.59 v2(16.57,156.59) 14.9,156.59 R3332.1
N32287609: length 7.5
  TOP w0.13: U123.K4 v1(20.85,157.4)
  BOTTOM w0.102: 19.93,157.8 20.45,157.8 v1(20.85,157.4)
  BOTTOM w0.13: 19.93,157.8 18.66,157.8 18.45,158.01 15.63,158.01 v2(15.35,158.29) 14.85,158.29 14.8,158.24 R3328.1
N32287740: length 6.8
  TOP w0.13: R3335.2 14.26,155.34 15.21,154.4 17.3,154.4 17.91,155 19.25,155 U123.N2
N32287789: length 8.7
  TOP w0.13: U123.N3 v1(20.05,155)
  BOTTOM w0.13: v1(20.05,155) 19.65,155.4 15.51,155.4 14.92,154.81 R3330.2 14.26,154.53 13.27,153.54 v2(13.02,153.54)
N32287821: length 7.7
  TOP w0.13: U123.F3 v1(20.05,161.4)
  BOTTOM w0.13: v1(20.05,161.4) 17.98,161.4 17.45,161.93 16.1,161.93 14.65,163.39 14.42,163.39 14.26,163.54 R3345.2
N32287843: length 7.3
  TOP w0.13: U123.G3 v1(20.05,160.6)
  BOTTOM w0.13: R3347.2 14.77,162.81 15.97,161.61 17.32,161.61 18.33,160.6 v1(20.05,160.6)
N32288243: length 6.1
  TOP w0.13: R3351.1 15.18,162.81 15.89,162.1 17.57,162.1 18.27,161.4 19.25,161.4 U123.F2
N32288267: length 5.3
  TOP w0.13: U123.C1 18.6,163.4 17.41,164.59 15.56,164.59 14.92,163.95 R3349.1
N32288959: length 4.8
  TOP w0.13: R3348.2 28.13,149.48 28.45,149.8 U123.T13
N32288979: length 5.5
  TOP w0.13: R3343.2 29.76,148.31 29.93,148.49 29.93,151.53 29.25,152.21 U123.T14
N32289037: length 8.6
  TOP w0.13: U123.M10 v1(26.45,155.8)
  BOTTOM w0.102: 26.85,153.75 26.85,155.4 v1(26.45,155.8)
  BOTTOM w0.13: R3341.2 27.11,148.71 27.47,149.07 v2(27.47,149.6) 27.47,152.17 26.85,152.79 26.85,153.75
N32289075: length 8.5
  TOP w0.13: U123.M11 v1(27.25,155.8)
  BOTTOM w0.102: 27.65,153.75 27.65,155.4 v1(27.25,155.8)
  BOTTOM w0.13: R3339.2 28.26,149.35 28.13,149.48 28.13,152.27 27.65,152.75 27.65,153.75
N32289109: length 8.4
  TOP w0.13: U123.M9 v1(25.65,155.8)
  BOTTOM w0.102: 26.05,153.75 26.05,155.4 v1(25.65,155.8)
  BOTTOM w0.13: R3337.2 25.97,148.97 26.2,149.2 v2(26.2,149.6) 26.2,151.56 26.05,151.71 26.05,153.75
N32289129: length 7.6
  TOP w0.13: U123.N9 v1(25.65,155)
  BOTTOM w0.13: v1(25.65,155) 25.06,154.41 25.06,149.45 24.83,149.22 R3336.2
N32289169: length 4.8
  TOP w0.13: R3324.2 34.04,155.45 33.85,155.25 31.36,155.25 31.2,155.4 U123.N16
N32289201: length 9.8
  TOP w0.13: U123.K12 v1(28.05,157.4)
  BOTTOM w0.102: v1(28.05,157.4) 28.45,157.8 30.09,157.8
  BOTTOM w0.13: R3309.2 34.48,154.3 34.1,154.68 34.1,154.94 33.59,155.45 v2(33.11,155.45) 32.45,155.45 30.09,157.8
N32289255: length 4.8
  TOP w0.13: U123.L16 32.09,157 32.28,156.82 34.63,156.82 34.86,156.59 R3305.2
N32289273: length 4.9
  TOP w0.13: U123.K16 32.14,157.8 32.41,158.07 34.77,158.07 35.12,157.73 R3293.2
N32289333: length 7
  TOP w0.13: U123.G14 v1(29.65,160.6)
  BOTTOM w0.13: v1(29.65,160.6) 29.66,160.59 35.31,160.59 35.52,160.8 R3277.2
N32289353: length 8.4
  TOP w0.13: U123.F14 v1(29.65,161.4)
  BOTTOM w0.13: v1(29.65,161.4) 31.5,161.4 32.27,162.18 32.83,162.18 33.08,162.43 33.08,163.07 33.29,163.27 v2(34.13,163.27) 34.94,164.08 35.27,164.08 35.52,164.34 R3270.2
N32292935: length 166
  TOP w0.13: v1(144.08,184.78) 144.08,183.39 152.21,175.26 152.21,170.81 153.61,169.42 R3304.2 ; U123.L13 v1(28.85,156.6)
  SIG7 w0.102: 30.16,156.2 29.25,156.2 v1(28.85,156.6)
  SIG7 w0.155: 30.16,156.2 31.55,156.2 32.19,156.84 35.24,156.84 36.89,158.49 38.8,158.49 41.47,161.16 41.47,167.51 42.23,168.27 42.23,170.56 47.31,175.64 48.45,175.64 51.5,178.69 51.5,183.53 53.33,185.36 53.33,186.62 62.14,195.43 105.74,195.43 110.41,190.75 114.75,190.75 120.09,185.42 143.44,185.42 v1(144.08,184.78)
  BOTTOM w0.13: v1(144.08,184.78) v2(144.08,185.54)
N32292939: length 265.4
  TOP w0.13: R3301.2 214.19,189.23 215.92,190.96 225.27,190.96 225.7,191.39 225.7,203.26 218,210.97 211.24,210.97 v1(210.63,211.58) ; U123.K11 v1(27.25,157.4)
  SIG9 w0.102: v1(27.25,157.4) 27.65,157 30.09,157
  SIG9 w0.155: v1(210.63,211.58) 209.99,212.21 161.99,212.21 153.23,203.45 95.54,203.45 94.68,202.59 72.04,202.59 71.45,203.18 60.63,203.18 46.11,188.67 46.11,185.11 41.85,180.85 41.85,168.78 40.96,167.89 40.96,161.54 38.87,159.46 32.02,159.46 31.43,158.87 31.43,157.92 30.52,157 30.09,157
  BOTTOM w0.13: v1(210.63,211.58) v2(210.63,212.34)
N32295057: length 8.1
  TOP w0.13: U124.K4 v1(398.02,179.25)
  BOTTOM w0.102: v1(398.02,179.25) 397.62,179.65 396.56,179.65
  BOTTOM w0.13: R3413.1 391.86,181.23 392.24,180.85 395.1,180.85 396.3,179.65 396.56,179.65
N32295185: length 6.4
  TOP w0.13: U124.L2 396.42,178.45 394.79,178.45 394.62,178.61 394.09,178.61 393.76,178.94 393.76,179.2 393.44,179.52 392.16,179.52 391.73,179.96 R3419.1
N32295247: length 5.4
  TOP w0.13: R3414.2 392.11,175.77 393,174.88 395.16,174.88 395.93,175.65 U124.R1
N32295323: length 8.5
  TOP w0.13: U124.M3 v1(397.22,177.65)
  BOTTOM w0.13: v1(397.22,177.65) 396.56,178.31 392.75,178.31 392.37,178.69 R3412.2 391.33,177.47 v2(391.63,177.16)
N32295386: length 9.4
  TOP w0.13: U124.F5 v1(398.82,183.25)
  BOTTOM w0.102: v1(398.82,183.25) 398.42,182.85 396.86,182.85 396.81,182.8 396.56,182.8
  BOTTOM w0.13: 396.56,182.8 395.21,182.8 394.91,182.5 394.02,182.5 v2(393.64,182.12) 393.26,182.5 392.21,182.5 391.33,183.39 R3435.2
N32295430: length 7.6
  TOP w0.13: U124.F3 v1(397.22,183.25)
  BOTTOM w0.13: v1(397.22,183.25) 394.79,183.25 394.55,183.49 393.03,183.49 392.49,184.02 v2(392.49,184.78) 392.24,185.04 R3431.2
N32295474: length 8.8
  TOP w0.13: U124.F4 v1(398.02,183.25)
  BOTTOM w0.102: 396.89,183.65 397.62,183.65 v1(398.02,183.25)
  BOTTOM w0.13: R3436.1 392.24,186.31 v2(392.49,186.05) 393.08,185.47 393.46,185.47 393.76,185.16 393.76,184.78 394.14,184.4 394.78,184.4 395.54,183.65 396.89,183.65
N32295554: length 7.4
  TOP w0.13: R3434.1 392.11,183.77 392.62,184.27 392.62,186.05 393.06,186.49 394.52,186.49 395.76,185.25 U124.C1
N32295598: length 9.9
  TOP w0.13: U124.D3 v1(397.22,184.85)
  BOTTOM w0.13: v1(397.22,184.85) 395.1,184.85 394.78,185.16 394.78,186.18 394.53,186.43 393.13,186.43 392.75,186.81 391.48,186.81 391.33,186.97 R3430.1 391.33,188.74 v2(391.22,188.85)
N32295638: length 7.6
  TOP w0.13: U124.N8 402.02,176.85 402.02,173.91 401.55,173.44 401.55,171.61 401.13,171.19 R3432.1
N32295682: length 5.1
  TOP w0.13: R3428.1 399.86,170.86 400.32,171.32 400.32,173.65 400.82,174.15 U124.T7
N32295760: length 8.6
  TOP w0.13: U124.M7 v1(400.42,177.65)
  BOTTOM w0.102: 400.82,175.64 400.82,177.25 v1(400.42,177.65)
  BOTTOM w0.13: 400.82,175.64 400.82,175.06 401.38,174.5 v2(401.38,171.32) 401.13,171.07 R3426.1
N32295825: length 8.1
  TOP w0.13: U124.P6 v1(399.62,176.05)
  BOTTOM w0.13: v2(398.74,170.15) R3424.1 399.86,171.07 400.32,171.52 400.32,174.31 399.62,175 v1(399.62,176.05)
N32295869: length 5.7
  TOP w0.13: R3422.1 398.23,170.15 397.91,170.47 397.91,172.32 397.97,172.37 397.97,173.13 399.22,174.38 U124.T5
N32295913: length 6.3
  TOP w0.13: U124.R5 398.82,175.25 398.82,174.44 397.64,173.27 397.64,172.57 397.32,172.25 R3415.1
N32295951: length 6.7
  TOP w0.13: U124.P4 v1(398.02,176.05)
  BOTTOM w0.13: v1(398.02,176.05) 398.02,173.1 397.61,172.69 v2(397.61,171.96) 397.61,171.48 397.32,171.19 R3418.1
N32296009: length 5.8
  TOP w0.13: R3421.2 402.4,171.07 402.45,171.12 402.45,173.35 402.67,173.57 402.67,174.5 402.82,174.65 402.82,175.25 U124.R9
N32296083: length 8.4
  TOP w0.13: U124.N10 v1(403.62,176.85)
  BOTTOM w0.102: v1(403.62,176.85) 404.02,176.45 404.02,175.41
  BOTTOM w0.13: R3423.2 402.4,170.69 403.03,171.32 v2(403.54,171.32) 403.54,173.97 404.02,174.45 404.02,175.41
N32296127: length 4.8
  TOP w0.13: R3425.2 403.67,171.07 403.7,171.09 403.7,173.94 404.02,174.26 U124.T11
N32296171: length 6.1
  TOP w0.13: U124.R13 406.02,175.25 406.02,171.23 R3427.2
N32296216: length 8.3
  TOP w0.13: U124.P12 v1(405.22,176.05)
  BOTTOM w0.13: v2(404.81,169.92) 404.58,170.15 R3429.2 403.67,170.56 404.63,171.52 404.63,173.78 405.22,174.37 v1(405.22,176.05)
N32296275: length 6.7
  TOP w0.13: U124.T15 408.2,173.86 409,173.86 411.04,171.83 R3433.2
N32296319: length 6.8
  TOP w0.13: U124.K3 v1(397.22,179.25)
  BOTTOM w0.13: R3420.2 391.58,179.7 v2(392.75,179.7) 395.41,179.7 395.87,179.25 v1(397.22,179.25)
N32296357: length 9.2
  TOP w0.13: U124.H5 v1(398.82,181.65)
  BOTTOM w0.102: v1(398.82,181.65) 398.42,182.05 396.86,182.05
  BOTTOM w0.13: 396.86,182.05 395.26,182.05 394.7,181.48 393.38,181.48 393,181.86 391.45,181.86 391.33,181.99 R3417.2
N32296409: length 7.9
  TOP w0.13: R3416.1 392.24,182.5 393.54,181.2 394.59,181.2 394.79,181 395.64,181 395.8,180.85 398.02,180.85 U124.H4
N32296479: length 6.1
  TOP w0.13: U124.P15 407.62,176.05 408.75,176.05 408.95,175.84 411.21,175.84 412.18,174.88 R3394.1
N32296532: length 5.1
  TOP w0.13: U124.N16 408.37,177.25 408.52,177.09 411.36,177.09 412.31,176.15 R3407.2
N32296624: length 6.1
  TOP w0.13: R3396.2 411.92,177.42 411,178.34 409,178.34 408.9,178.45 407.62,178.45 U124.L15
N32296668: length 4.8
  TOP w0.13: R3388.2 412.69,178.66 409.44,178.66 409.26,178.85 U124.L16
N32296748: length 4.9
  TOP w0.13: U124.G16 408.78,182.05 409.16,182.42 411.54,182.42 411.62,182.5 R3371.2
N32296803: length 7.2
  TOP w0.13: U124.F14 v1(406.82,183.25)
  BOTTOM w0.13: R3362.2 v2(411.42,185.04) 409.89,185.04 408.1,183.25 v1(406.82,183.25)
N32296857: length 4.9
  TOP w0.13: R3356.2 409,185.04 408.41,184.45 U124.D16
N32296896: length 10.7
  TOP w0.13: v1(403.92,190.75) 404.3,190.75 404.69,191.13 R3364.2 ; U124.F8 v1(401.22,183.25)
  SIG8 w0.155: v1(403.92,190.75) 403.54,190.75 401.89,189.1 401.89,183.92 v1(401.22,183.25)
N32296968: length 246.9
  TOP w0.13: R3398.1 206.44,191.26 206.69,191.51 206.69,201.42 208.64,203.36 v1(208.64,204.21) ; U124.A15 407.35,186.85 408.5,188 408.5,189.23 v1(408.85,189.58)
  SIG6 w0.155: v1(208.64,204.21) 208.64,205.28 208.96,205.61 211.91,205.61 212.88,206.58 234.98,206.58 241,212.6 258.89,212.6 259.65,211.83 264.73,211.83 265.24,212.34 271.16,212.34 273.49,214.67 282.66,214.67 285.83,217.84 318.3,217.84 330.48,205.65 358.69,205.65 370.9,193.44 383.63,193.44 386.4,196.2 386.4,196.85 389.75,200.2 403.37,200.2 409.38,194.18 409.38,190.12 v1(408.85,189.58)
  BOTTOM w0.13: v1(208.64,204.21) v2(208.64,203.45)
N32296972: length 245.8
  TOP w0.13: v1(210.45,204.21) 210.25,204.21 209.74,204.72 208.34,204.72 208.02,204.4 208.02,203.62 205.93,201.52 205.93,191.89 205.3,191.26 R3397.1 ; U124.B14 406.82,186.45 406.82,187.04 407.96,188.19 v1(407.96,188.57)
  SIG6 w0.155: v1(407.96,188.57) 408.37,188.97 408.37,192.91 407.1,194.18 407.1,195.32 402.86,199.56 390.05,199.56 387.16,196.67 387.16,196.06 383.9,192.8 370.64,192.8 358.42,205.02 330.2,205.02 318.24,216.97 301.69,216.97 301.53,216.81 293.59,216.81 293.04,216.27 285.15,216.27 282.92,214.04 274.13,214.04 271.67,211.58 265.62,211.58 264.73,210.69 259.27,210.69 258.94,210.36 239.76,210.36 235.22,205.82 213.02,205.82 211.65,204.44 210.68,204.44 v1(210.45,204.21)
  BOTTOM w0.13: v1(210.45,204.21) v2(210.45,203.45)
N32338882: length 8.9
  BOTTOM w0.13: U117.9 302.71,207.13 v2(304.23,205.61) 304.51,205.33 C3436.2 305.85,205.71 306.13,205.99 308.27,205.99 308.52,205.74 R3140.1
N32338926: length 15.8
  TOP w0.13: v1(312.1,203.07) 312.41,202.77 312.41,198.19 312.89,197.71 OSC1.1
  BOTTOM w0.13: R3177.1 308.27,202.54 308.42,202.69 R3176.2 309.31,202.69 309.97,202.03 C3466.1 311.59,203.07 v1(312.1,203.07)
