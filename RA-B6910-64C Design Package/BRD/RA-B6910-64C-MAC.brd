# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MODSELL50: length 28.1
  SIG8 w0.155: YJ34.D8 307.3,54.86 307.92,55.48 307.92,56.59 307.54,56.97 307.54,57.27 307.93,57.66 307.93,60.58 307.54,60.97 307.54,61.27 307.93,61.66 307.93,64.58 307.58,64.93 307.58,65.32 307.98,65.72 307.98,72.84 310.2,75.05 v1(310.2,76.32)
  BOTTOM w0.13: R2861.2 310.55,77.87 310.71,77.72 310.71,76.83 v1(310.2,76.32) 310.96,75.56 v2(311.21,75.56)
MODSELL51: length 25.2
  SIG9 w0.155: v1(312.48,76.32) 311.98,76.83 311.98,77.47 311.59,77.85 310.07,77.85 309.69,77.47 309.69,76.71 309.56,76.58 309.56,74.91 306.33,71.68 306.33,66.49 305.92,66.07 305.92,65.61 306.26,65.27 306.26,64.95 305.88,64.57 305.88,63.9 307.3,62.48 YJ34.C8
  BOTTOM w0.13: R2864.2 312.84,77.87 312.99,77.72 312.99,77.21 313.5,76.71 v2(313.5,76.32) v1(312.48,76.32)
MODSELL52: length 24.6
  TOP w0.13: v1(324.17,83.06) 323.41,83.06 323.15,83.31 R2841.2
  SIG2 w0.152: v1(324.17,83.06) 324.68,82.55 324.68,78.86 323.71,77.9 323.71,67 324.53,66.18 324.53,65.67 324.17,65.31 324.17,64.94 324.5,64.61 324.5,63.99 323.1,62.59 YJ33.C8
MODSELL53: length 37.8
  TOP w0.13: R2843.2 v1(324.17,87.12)
  SIG2 w0.152: YJ33.D8 323.1,54.33 324.5,55.73 324.5,56.61 324.17,56.94 324.17,57.31 324.53,57.67 324.53,58.97 324.88,59.32 324.88,60.59 325.26,60.97 325.26,61.29 324.92,61.64 324.92,62.5 325.92,63.5 326.42,63.5 326.9,63.97 326.9,64.61 326.57,64.94 326.57,65.3 326.93,65.66 326.93,66.55 325.69,67.78 325.69,83.82 324.68,84.83 324.68,86.61 v1(324.17,87.12)
MODSELL54: length 35.9
  TOP w0.13: R2863.2 v1(325.18,87.12)
  SIG9 w0.155: v1(325.18,87.12) 325.95,86.36 325.95,74.8 326.98,73.77 326.98,65.71 326.58,65.31 326.58,64.93 326.93,64.58 326.93,61.68 326.54,61.29 326.54,60.97 326.93,60.57 326.93,57.68 326.54,57.29 326.54,56.97 326.92,56.59 326.92,55.48 326.3,54.86 YJ34.B8
MODSELL55: length 24.3
  TOP w0.13: v1(325.18,82.17) 326.2,83.18 R2862.2
  SIG8 w0.155: YJ34.A8 326.3,62.48 324.88,63.9 324.88,64.59 325.26,64.97 325.26,65.27 324.92,65.61 324.92,66.05 326.33,67.46 326.33,81.02 v1(325.18,82.17)
MODSELL56: length 22.9
  SIG3 w0.155: YJ35.A8 351.1,62.59 352.5,63.99 352.5,64.6 352.17,64.93 352.17,65.31 352.53,65.67 352.53,66.25 348.68,70.1 348.68,72.51 v1(349.44,73.28)
  BOTTOM w0.13: v1(349.44,73.28) 350.08,73.91 350.08,74.55 350.96,75.44 v2(351.6,75.44) 352.87,75.44 354.39,76.96 354.88,76.96 R2868.2
MODSELL57: length 35.4
  TOP w0.13: v1(351.98,72.01) 352.49,72.51 354.39,72.51 357.82,75.94 357.82,80.01 356.81,81.02 R2883.2
  SIG3 w0.155: YJ35.B8 351.1,54.33 352.5,55.73 352.5,56.61 352.17,56.94 352.17,57.3 352.53,57.66 352.53,58.97 352.88,59.32 352.88,60.59 353.26,60.97 353.26,61.29 352.92,61.64 352.92,62.5 353.92,63.5 354.42,63.5 354.9,63.97 354.9,64.59 354.57,64.92 354.57,65.31 354.93,65.67 354.93,66.16 351.98,69.11 v1(351.98,72.01)
MODSELL58: length 38.1
  TOP w0.13: R2903.2 355.79,81.15 357.44,79.5 357.44,76.2 354.2,72.96 351.08,72.96 v1(350.76,73.28)
  SIG8 w0.155: YJ36.D8 354.3,54.86 354.92,55.48 354.92,56.59 354.54,56.97 354.54,57.27 354.93,57.66 354.93,58.15 354.93,58.15 354.93,59.43 354.92,59.45 354.92,60.59 354.54,60.97 354.54,61.27 354.93,61.66 354.93,64.58 354.53,64.98 354.53,65.27 355.03,65.77 355.03,66.29 354.77,66.55 354.77,72.13 354.27,72.64 351.4,72.64 v1(350.76,73.28)
MODSELL59: length 20.5
  SIG9 w0.155: YJ36.C8 354.3,62.48 352.88,63.9 352.88,64.57 353.26,64.95 353.26,65.27 352.92,65.61 352.92,66.88 351.42,68.37 351.42,72.21 352.74,73.53 v1(352.74,74.55)
  BOTTOM w0.13: v1(352.74,74.55) 352.74,74.67 354.52,76.45 v2(355.28,76.45) 355.79,76.45 356.81,77.47 R2901.2
MODSELL60: length 19.3
  TOP w0.13: v1(370.78,71.65) 371.28,72.16 R2882.2
  SIG2 w0.152: v1(370.78,71.65) 370.17,71.65 369.84,71.33 369.59,71.33 369.13,70.86 369.13,68.45 371.54,66.04 371.54,65.67 371.2,65.33 371.2,64.91 371.54,64.57 371.54,63.88 370.1,62.44 YJ35.C8
MODSELL61: length 29.7
  SIG2 w0.152: YJ35.D8 370.1,54.33 371.5,55.73 371.5,56.6 371.17,56.93 371.17,57.3 371.53,57.66 371.53,58.97 371.88,59.32 371.88,60.58 372.26,60.96 372.26,61.29 371.92,61.64 371.92,62.5 372.92,63.5 373.42,63.5 373.9,63.97 373.9,64.61 373.57,64.94 373.57,65.3 373.93,65.66 373.93,66.19 371.54,68.58 371.54,69.24 370.8,69.97 370.27,69.97 v1(369.63,70.61)
  BOTTOM w0.13: R2884.2 371.28,77.21 v2(370.52,76.45) 370.52,75.85 370.65,75.73 370.65,72.26 370.27,71.88 370.27,71.24 v1(369.63,70.61)
MODSELL62: length 31.9
  TOP w0.13: R2900.2 379.67,77.21 380.56,76.32 v1(380.56,75.18)
  SIG9 w0.155: YJ36.B8 374.09,54.61 379.54,54.61 380.88,55.95 380.88,74.86 v1(380.56,75.18)
  BOTTOM w0.13: v1(380.56,75.18) v2(381.57,75.18)
MODSELL63: length 23.5
  TOP w0.13: v1(379.41,75.94) 379.41,76.73 378.65,77.49 R2904.2
  SIG8 w0.155: YJ36.A8 373.3,62.48 371.88,63.9 371.88,64.59 372.26,64.97 372.26,65.27 371.92,65.61 371.92,66.92 375.22,70.23 375.22,74.29 376.67,75.74 379.21,75.74 v1(379.41,75.94)
  BOTTOM w0.13: v1(379.41,75.94) 379.41,75.27 379.16,75.02 v2(379.16,74.42)
ONLINE_CPLD_UPDATE: length 84.7
  SIG6 w0.155: v1(33.85,183.77) 35.2,185.12 35.2,189.55 53.54,207.89 53.54,210.19 54.93,211.58 65.6,211.58 66.23,212.21 66.23,213.36 68.71,215.83 69.22,215.83 v1(69.66,216.28) 70.17,216.28 73.98,220.09 82.87,220.09 87.06,215.9 93.25,215.9 93.41,215.74 93.41,215.72 YJ3.C2_2
  BOTTOM w0.13: C3493.1 v1(69.66,216.28) ; R3197.1 v1(33.85,183.77) 33.21,183.77 v2(33.08,183.64)
ONLINE_TCK: length 108.4
  SIG4 w0.155: v1(20,177.29) 21.53,177.29 23.18,178.94 23.18,181.35 25.34,183.51 29.91,183.51 30.8,184.4 30.8,185.04 33.08,187.32 34.61,187.32 42.74,195.45 44.64,195.45 56.73,207.54 65.28,207.54 67.17,209.42 69.15,209.42 v1(69.66,209.93)
  SIG8 w0.155: v1(69.66,209.93) 71.46,209.93 72.46,210.94 72.46,215.02 76.64,219.2 83.63,219.2 86.95,215.88 87.17,215.88 87.19,215.9 94.42,215.9 95.08,215.24 YJ3.C1_2
  BOTTOM w0.13: v1(69.66,209.93) 69.91,210.18 C3495.1 ; U119.2 19.86,182.3 20.62,181.54 20.96,181.54 21.15,181.35 R3191.2 20.87,180.82 20.64,180.59 20.64,178.81 20.89,178.56 v2(20.89,178.18) v1(20,177.29)
ONLINE_TDI: length 95
  SIG4 w0.155: YJ3.A1_2 94.14,220.06 92.4,220.06 92.27,219.93 91.66,219.93 91.53,220.07 89.99,220.07 89.85,219.93 72.68,219.93 70.87,218.12 70.87,216.47 v1(69.66,215.26) 68.77,215.26 66.68,213.17 66.68,212.66 65.34,211.33 64.58,211.33 64.07,210.82 64.07,210.06 62.96,208.94 54.96,208.94 53.38,207.36 44.61,207.36 38.04,200.78 24.57,200.78 18.73,194.94 v1(18.73,193.16)
  BOTTOM w0.13: C3498.1 v1(69.66,215.26) 69.15,215.26 v2(68.9,215.52) ; v1(18.73,193.16) R3193.2 18.33,192.38 18.1,192.15 18.1,191.51 18,191.41 R3190.1
ONLINE_TDO: length 112
  SIG4 w0.155: v1(17.72,178.05) 18.22,178.56 18.22,180.08 24.32,186.18 29.27,186.18 31.81,188.72 34.1,188.72 37.53,192.15 37.53,198.75 45.02,206.25 54.17,206.25 56.09,208.17 65.02,208.17 66.61,209.77 66.61,210.53 67.28,211.2 v1(69.66,211.2)
  SIG8 w0.155: v1(69.66,211.2) 71.15,212.69 71.15,217.26 73.73,219.84 94.55,219.84 95.08,219.31 YJ3.B1_2
  BOTTOM w0.13: C3494.1 v1(69.66,211.2) ; v1(17.72,178.05) 18.35,178.05 v2(18.48,178.18) 18.48,178.56 18.22,178.81 18.22,180.59 18,180.82 R3187.1 17.72,181.35 17.26,181.81 U119.6
ONLINE_TMS: length 111.4
  SIG4 w0.155: YJ3.B2_2 93.25,219.68 92.56,219.68 92.42,219.55 91.5,219.55 91.37,219.68 90.15,219.68 90.01,219.55 72.85,219.55 71.25,217.95 71.25,213.8 v1(69.66,212.21) 69.03,211.58 67.12,211.58 66.23,210.69 66.23,209.93 64.86,208.56 55.46,208.56 53.75,206.85 44.87,206.85 36.64,198.63 36.64,193.04 34.61,191.01 33.34,191.01 31.94,189.61 30.04,189.61 27.62,187.2 22.92,187.2 16.07,180.34 16.07,178.69 v1(15.43,178.05)
  BOTTOM w0.13: v2(15.43,177.29) v1(15.43,178.05) 16.07,178.69 16.07,180.59 15.84,180.82 R3188.1 15.43,181.35 15.96,181.89 U119.8 ; C3492.1 v1(69.66,212.21)
PCIE_PVDD0P8: length 5.8
  TOP w0.229: U1.BL37 v1(193.55,157.34)
  TOP w0.381: 161.77,184.55 L31.1 ; L31.1 162.37,183.92 ; L31.1 162.97,184.55 ; 164.06,184.55 C2984.1 ; C2984.1 165.25,184.55 ; C2984.1 164.66,183.92
  BOTTOM w0.381: v1(161.99,183.31) v2(161.99,184.07) ; C2903.1 193.55,157.33 v1(193.55,157.34)
  vias: v1(162.88,183.31) v1(164.66,183.31) v1(165.54,183.31)
PCIE_TRVDD0P8: length 7.6
  TOP w0.229: v1(202.55,170.34) U1.CE29 ; U1.BY31 v1(200.55,166.34) ; v1(200.55,171.34) 200.55,171.34 U1.CE30 ; U1.BW31 v1(200.55,165.34)
  TOP w0.381: 211.14,194.03 C3106.1 210.54,193.39
  BOTTOM w0.381: v1(200.55,171.34) 201.03,170.86 C2712.1 ; v1(210.12,193.93) v2(210.88,193.93) ; v1(202.55,170.34) 202.55,170.34 C2660.1 ; v1(200.55,165.34) 200.55,165.32 C2974.1 ; v1(200.55,166.34) 201.05,166.84 C3074.1
  vias: v1(210.12,193.04)
PCIE_WAKE_L: length 48.7
  TOP w0.13: U1.U32 v1(199.55,122.34) ; R22.1 v1(229.43,98.17)
  SIG7 w0.155: v1(229.43,98.17) 228.92,98.68 228.16,98.68 226.89,99.95 226.89,101.34 222.06,106.17 222.06,112.52 221.68,112.9 220.28,112.9 220.03,113.15 220.03,114.55 219.77,114.81 217.36,114.81 215.07,117.09 215.07,120.01 212.28,122.81 200.01,122.81 v1(199.55,122.34)
PH1:
  vias: v1(77.03,133.22)
PH2:
  vias: v1(77.03,143.13)
PH3:
  vias: v1(77.03,153.54)
PH4:
  vias: v1(77.03,163.57)
PH5:
  vias: v1(77.03,173.99)
PH6:
  vias: v1(77.79,183.89)
PH7:
  vias: v1(336.61,142.87)
PH8:
  vias: v1(336.61,132.71)
PH9:
  vias: v1(336.61,162.81)
PH10:
  vias: v1(336.61,153.03)
PH11:
  vias: v1(336.61,183.51)
PH12:
  vias: v1(336.61,173.23)
PVTMON_AVDD1P8: length 16.8
  TOP w0.229: U1.AE15 v1(216.55,130.34) ; U1.AC52 v1(178.55,128.34) ; U1.BG52 v1(178.56,153.33) ; U1.BG15 v1(216.55,153.34)
  TOP w0.279: U1.BA36 v1(194.55,147.34) ; U1.AD33 v1(198.55,129.34) ; U1.AB33 v1(198.55,127.34) ; U1.BF34 v1(196.55,152.34)
  TOP w0.381: L426.1 183.2,177.54 ; L426.1 183.93,178.33 ; L426.1 182.46,178.33 ; C91.1 186.22,178.33 ; C91.1 185.48,177.54 ; C91.1 184.75,178.33
  BOTTOM w0.381: v1(198.55,127.34) 198.07,127.83 C98.1 ; v1(178.55,128.34) 178.55,128.35 C96.1 ; v1(216.55,153.34) 216.58,153.34 C95.1 ; v1(186.5,174.88) v2(187.26,174.88) ; v1(216.55,130.34) 216.03,129.82 C97.1 ; v1(198.55,129.34) 198.03,128.83 C99.1 ; v1(194.55,147.34) 194.03,146.82 C94.1 ; C92.1 179.06,153.82 178.57,153.33 v1(178.56,153.33) ; C93.1 196.03,151.82 v1(196.55,152.34)
  vias: v1(185.86,175.51)
PWM1: length 424.2
  TOP w0.203: U140.2 373.98,169.06 373.72,169.31 373.72,169.77
  TOP w0.254: v1(57.67,139.9) 57.52,140.05 U134.3
  TOP w0.381: v1(373.72,170.66) 373.72,169.77
  SIG4 w0.254: v1(373.72,170.66) 373.72,175.03 375.22,176.53 375.22,188.8 345.28,218.74 285.99,218.74 282.89,215.64 278.32,215.64 276.54,213.87 276.54,210.82 273.62,207.9 259.65,207.9 259.02,207.26 214.82,207.26 212.92,209.17 162.75,209.17 160.34,206.75 154.24,206.75 150.38,202.89 129.59,202.89 124.7,197.99 114.87,197.99 114.69,198.17 110.44,198.17 110.26,197.99 102.3,197.99 102.17,198.12 97.81,198.12 97.66,197.97 73.7,197.97 72.43,196.7 66.81,196.7 65.44,195.32 63.13,195.32 60.25,192.44 60.25,191.55 59.12,190.42 59.12,188.21 56.71,185.8 56.71,184.78 55.88,183.96 54.61,183.96 51.37,180.72 51.37,146.2 v1(57.67,139.9)
  BOTTOM w0.13: v1(57.67,139.9) v2(57.67,140.66)
PWM2: length 400.5
  TOP w0.203: v1(372.43,170.43) 373.19,169.67 373.19,169.16 373.69,168.66 U140.3
  TOP w0.254: U135.3 57.52,160.37 v1(57.67,160.22)
  SIG4 w0.254: v1(372.43,170.43) 372.43,174.85 374.21,176.63 374.21,188.77 355.72,207.26 333.95,207.26 323.2,218.01 286.3,218.01 283.08,214.79 278.61,214.79 277.3,213.48 277.3,210.54 273.27,206.5 214.19,206.5 213.3,207.39 162.75,207.39 161.35,205.99 154.62,205.99 150.78,202.15 129.9,202.15 124.95,197.21 114.29,197.21 114.06,197.43 111.98,197.43 111.78,197.23 100.42,197.23 100.27,197.38 99.38,197.38 99.22,197.23 88.84,197.23 87.95,196.34 73.22,196.34 72.83,195.96 67.12,195.96 65.7,194.54 63.39,194.54 60.99,192.14 60.99,191.25 60.01,190.27 60.01,187.45 58.86,186.31 58.86,185.8 56.07,183 54.8,183 53.28,181.48 53.28,167.26 57.67,162.86 v1(57.67,160.22)
  BOTTOM w0.13: v1(57.67,160.22) v2(57.67,161.03)
PWM3: length 372.2
  TOP w0.203: U140.4 373.33,168.26 v1(371.79,169.8)
  TOP w0.254: U136.3 57.26,180.69 v1(57.42,180.54)
  SIG4 w0.254: v1(371.79,169.8) 371.79,170.05 371.69,170.15 371.69,175.18 373.42,176.91 373.42,188.52 355.44,206.5 333.57,206.5 323.28,216.79 304.48,216.79 303.39,215.69 285.1,215.69 274.13,204.72 213.3,204.72 212.03,205.99 162.73,205.99 161.99,205.25 155.16,205.25 151.32,201.41 131.5,201.41 126.3,196.21 88.96,196.21 88.35,195.6 73.62,195.6 73.11,195.09 68.16,195.09 66.87,193.8 63.69,193.8 61.72,191.83 61.72,190.94 60.9,190.12 60.9,185.16 57.42,181.68 v1(57.42,180.54)
  BOTTOM w0.13: v1(57.42,180.54) v2(58.18,180.54)
PWM4: length 41.3
  TOP w0.203: U140.5 373.78,167.86 372.97,167.86 372.81,168.02 v1(372.81,168.02)
  TOP w0.254: U137.3 357.05,138.45 v1(356.9,138.6)
  SIG6 w0.254: v1(372.81,168.02) 372.3,167.51 369.38,167.51 363.54,161.67 363.54,147.06 360.24,143.76 360.24,141.94 v1(356.9,138.6)
  BOTTOM w0.13: v1(372.81,168.02) 372.81,168.53 v2(373.06,168.78)
PWM5: length 24.4
  TOP w0.203: v1(371.92,168.02) 372.48,167.46 U140.6
  TOP w0.254: v1(356.87,158.92) 357.03,158.77 U138.3
  SIG6 w0.254: v1(356.87,158.92) 356.93,158.98 356.93,160.65 363.16,166.88 367.86,166.88 369,168.02 v1(371.92,168.02)
  BOTTOM w0.13: v1(356.87,158.92) v2(356.09,158.92)
PWM6: length 28.1
  TOP w0.203: U140.7 372.61,167.06 v1(372.43,166.88)
  TOP w0.254: v1(356.87,179.24) 357.03,179.09 U139.3
  SIG6 w0.254: v1(356.87,179.24) 359.21,176.91 365.95,176.91 370.14,172.72 370.14,170.43 371.76,168.81 372.91,168.81 373.32,168.4 373.32,167.76 v1(372.43,166.88)
  BOTTOM w0.13: v1(356.87,179.24) v2(356.87,180.02)
PWR_STATUS_LED: length 149.1
  TOP w0.13: v1(402.91,63.37) 403.42,62.86 403.42,61.34 403.72,61.03 R3390.1 405.25,61.03 405.5,61.28 405.5,63.45 405.35,63.6 D431.4 ; v1(409.77,181.96) 409.16,181.96 408.84,181.65 407.62,181.65 U124.H15
  SIG7 w0.155: v1(402.91,63.37) 403.54,64.01 403.54,71.94 401.39,74.1 401.39,82.71 400.5,83.59 400.5,91.29 415.1,105.89 415.1,107.42 415.44,107.76 415.95,107.76 417,108.8 417,128.77 423.48,135.25 423.48,141.56 416.24,148.8 416.24,179.19 415.99,179.45 412.94,179.45 411.29,181.1 410.63,181.1 v1(409.77,181.96)
  BOTTOM w0.13: v2(402.91,64.13) v1(402.91,63.37)
REF_25M: length 4.8
  BOTTOM w0.13: U117.8 303.73,207.63 v2(304.23,207.13) 304.76,206.6 R3181.2
RESCAL_AVDD0P8: length 11.1
  TOP w0.229: U1.BH15 v1(216.55,154.34) ; U1.BH52 v1(178.56,154.33) ; U1.AB52 v1(178.55,127.34) ; U1.AD15 v1(216.55,129.34)
  TOP w0.381: L30.1 177.1,177.54 ; L30.1 176.37,178.33 ; L30.1 177.84,178.33 ; C3083.1 180.12,178.33 ; C3083.1 178.65,178.33 ; C3083.1 179.39,177.42
  BOTTOM w0.381: v1(193.1,175.26) v2(193.1,176.02) ; C3042.1 179.07,154.84 v1(178.56,154.33) ; C3177.1 216.03,128.82 v1(216.55,129.34) ; C2689.1 217.05,153.84 v1(216.55,154.34) ; v1(178.55,127.34) 178.55,127.3 C2951.1
  vias: v1(191.07,174.75) v1(193.1,174.37)
RESETL0: length 144.2
  SIG3 w0.152: 23.2,61.33 23.56,61.69 23.56,62.23
  SIG3 w0.155: YJ21.A9 22.9,61.03 23.2,61.33 ; v1(18.22,77.21) 17.72,76.71 17.72,74.04 15.3,71.63 15.3,64.77 16.57,63.5 22.67,63.5 23.56,62.61 23.56,62.23
  SIG4 w0.155: v1(18.22,77.21) 18.1,77.21 17.72,76.83 17.72,75.18 17.34,74.8 14.67,74.8 12.26,77.21 10.22,77.21 9.08,78.36 9.08,87.63 8.83,87.88 8.83,95.5 8.45,95.88 6.67,95.88 1.88,100.67 1.88,131.63 3.57,133.32 3.57,164.6 9.01,170.05 11.24,170.05 v1(11.75,169.54)
  BOTTOM w0.13: R2596.2 19.24,77.34 19.11,77.21 v1(18.22,77.21) ; R3344.2 12.76,167.38 11.75,168.4 v2(11.75,168.65) v1(11.75,169.54)
RESETL1: length 137.5
  SIG3 w0.152: v1(17.21,84.83) 16.7,85.34 15.94,85.34 13.72,83.12 13.72,78.42 12.13,76.83 12.13,58.93 16.29,54.76 23.03,54.76 23.56,54.23 23.56,53.69 22.9,53.03 YJ21.B9
  SIG4 w0.155: v1(11.49,162.81) 10.73,162.05 9.21,162.05 8.11,160.95 8.11,151.21 18.93,140.39 18.93,137.2 21.96,134.17 21.96,100.89 17.97,96.9 17.97,92.33 17.46,91.82 17.46,85.09 v1(17.21,84.83)
  BOTTOM w0.13: R3345.1 12.64,163.95 v2(12.07,163.38) v1(11.49,162.81) ; R2594.1 16.93,86.59 16.83,86.48 16.83,85.21 v1(17.21,84.83)
RESETL2: length 148.8
  TOP w0.13: R2595.2 v1(42.61,80.52)
  SIG2 w0.152: YJ21.C9 42.17,60.69 42.17,61.3 42.53,61.66 42.53,63.25 42.88,63.6 42.88,64.62 42.91,64.62 43.26,64.97 43.26,65.29 42.92,65.64 42.92,66.18 43.28,66.55 43.28,75.85 43.88,76.45 43.88,79.25 v1(42.61,80.52)
  SIG10 w0.155: v1(11.75,167.51) 11.11,166.88 8.57,166.88 1.79,160.09 1.79,99.74 5.65,95.88 11.75,95.88 13.91,93.72 13.91,91.69 15.56,90.04 16.45,90.04 18.35,88.14 33.4,88.14 33.8,87.74 36.01,87.74 39.07,84.68 39.07,83.59 41.55,81.11 41.88,81.11 42.48,80.52 v1(42.61,80.52)
  BOTTOM w0.13: v1(11.75,167.51) 12.51,166.75 13.17,166.75 13.3,166.62 R3282.1
RESETL3: length 164
  TOP w0.13: R3327.1 13.3,157.76 12.64,157.1 v1(12.38,157.1) ; R2593.1 v1(55.44,88.52)
  SIG1 w0.16: v1(55.59,58.29) 55.59,52.09 53.53,50.04 50.23,50.04 49.72,50.54 43.78,50.54 YJ21.D9
  SIG7 w0.155: v1(55.59,58.29) 55.59,76.98 56.83,78.23 56.83,84.2 55.94,85.09 55.94,86.36 55.44,86.87 v1(55.44,88.52)
  SIG10 w0.155: v1(55.44,88.52) 52.54,88.52 52.31,88.29 50.5,88.29 47.98,90.8 45.95,90.8 43.04,93.71 37.65,93.71 35.06,96.31 34.37,96.31 33.29,97.39 29.63,97.39 25.51,101.51 24.78,101.51 24.32,101.98 24.32,102.7 22.93,104.09 22.93,124.47 23.36,124.9 23.36,129.06 20.13,132.3 11.91,132.3 11.31,132.89 10.51,132.89 7.77,135.63 7.77,154.77 9.59,156.59 11.87,156.59 v1(12.38,157.1)
  BOTTOM w0.13: v2(54.67,88.52) v1(55.44,88.52)
RESETL4: length 157.1
  SIG3 w0.155: YJ23.A9 70.17,60.69 70.17,61.31 70.53,61.67 70.53,63.25 70.88,63.6 70.88,64.59 71.26,64.97 71.26,65.29 70.92,65.64 70.92,66.18 71.18,66.45 71.18,73.2 v1(71.44,73.45)
  SIG10 w0.155: v1(12.38,158.24) 11.72,157.58 9.56,157.58 7.13,155.15 7.13,134.65 9.52,132.26 10.96,132.26 11.56,131.66 19.86,131.66 22.73,128.8 22.73,125.84 22.3,125.41 22.3,103.31 23.48,102.12 23.48,100.77 23.8,100.45 25.67,100.45 26.99,99.13 26.99,97.79 29.98,94.79 35.67,94.79 37.39,93.08 40.59,93.08 43.11,90.55 45.01,90.55 47.93,87.63 52.57,87.63 52.79,87.86 55.79,87.86 55.94,88.01 56.96,88.01 57.34,87.63 59.63,87.63 62.55,84.71 62.55,80.39 64.96,77.98 66.92,77.98 v1(71.44,73.45)
  BOTTOM w0.13: v1(71.44,73.45) 71.39,73.45 70.55,74.29 v2(70.55,75.31) 69.84,76.02 69.84,77.72 69.99,77.87 R2632.2 ; v1(12.38,158.24) R3328.2
RESETL5: length 152.4
  SIG2 w0.152: v1(71.44,80.39) 70.93,79.88 70.93,78.99 69.28,77.34 69.28,67.37 68.47,66.56 68.47,65.69 68.85,65.31 68.85,64.96 68.47,64.58 68.47,61.68 68.85,61.3 68.85,60.96 68.51,60.62 68.5,60.62 68.5,57.66 68.88,57.27 68.88,56.99 68.51,56.62 68.5,56.62 68.5,53.66 68.94,53.21 69.11,53.21 YJ23.B9
  SIG10 w0.155: v1(10.48,154.81) 10.48,149.09 18.97,140.6 18.97,135.26 24.64,129.59 24.64,104.39 27.24,101.8 27.24,101.59 30.16,98.67 34.5,98.67 38.18,94.99 43.56,94.99 46.47,92.08 49.51,92.08 51.27,90.32 53.4,90.32 53.68,90.04 55.05,90.04 55.31,90.3 56.71,90.3 57.28,89.72 57.91,89.72 58.48,89.15 60.14,89.15 64.2,85.1 64.2,83.82 64.58,83.44 65.98,83.44 68.39,81.02 70.42,81.02 71.06,80.39 v1(71.44,80.39)
  BOTTOM w0.13: v1(10.48,154.81) 10.48,154.87 v2(10.99,155.38) 11.05,155.45 13.14,155.45 13.3,155.6 R3332.2 ; R2631.1 71.79,83.72 71.95,83.56 71.95,80.9 v1(71.44,80.39)
RESETL6: length 136.5
  SIG2 w0.152: YJ23.C9 88.9,61.03 89.53,61.66 89.53,63.25 89.88,63.6 89.88,64.59 90.26,64.97 90.26,65.29 89.92,65.64 89.92,66.93 88.71,68.13 88.71,70.74 v1(84.9,74.55)
  SIG10 w0.155: v1(84.9,74.55) 84.01,75.44 84.01,78.34 82.74,79.61 80.98,79.61 79.57,81.02 79.57,85.6 76.77,88.39 76.77,90.97 73.72,94.01 65.05,94.01 61.22,97.85 59.37,97.85 58.34,98.87 57.4,98.87 56.58,99.69 50.75,99.69 45.62,104.82 43.56,104.82 42.8,105.58 40.01,105.58 39.38,106.21 35.66,106.21 30.68,111.2 30.68,131.95 v1(24.96,137.67)
  BOTTOM w0.13: R3331.2 v2(20.26,145.92) 20.26,142.36 v1(24.96,137.67) ; v1(84.9,74.55) 84.39,75.05 84.39,75.56 83.76,76.2 R2639.2
RESETL7: length 144.5
  SIG3 w0.155: YJ23.D9 88.11,53.21 87.92,53.21 87.5,53.63 87.5,56.61 87.88,56.99 87.88,57.25 87.5,57.63 87.5,60.61 87.85,60.96 87.85,61.28 87.47,61.66 87.47,64.58 87.85,64.96 87.85,65.31 87.47,65.69 87.47,66.16 87.15,66.49 87.15,71.54 84.39,74.29 84.39,77.59 85.28,78.48 85.28,81.45 85.53,81.71 v1(85.53,82.17)
  SIG10 w0.155: v1(24.96,142.87) 25.59,142.24 25.59,141.18 32.1,134.68 32.1,133.48 32.72,132.86 32.72,131.47 31.95,130.7 31.95,111.78 36.25,107.49 44.76,107.49 51.14,101.11 57.71,101.11 58.36,100.45 59.73,100.45 60.48,99.71 61.19,99.71 64.98,95.91 75.6,95.91 79.57,91.95 79.57,87.91 81.17,86.31 81.17,83.23 82.23,82.17 v1(85.53,82.17)
  BOTTOM w0.13: v1(85.53,82.17) 84.77,82.93 R2630.1 ; v1(24.96,142.87) 24.83,143 24.83,144.52 v2(25.08,144.78) 25.21,144.9 25.21,146.43 24.83,146.81 R3336.1
RESETL8: length 184
  TOP w0.13: R3351.2 12.76,162.81 v1(11.49,161.54)
  SIG3 w0.155: YJ25.A9 117.17,60.69 117.17,61.3 117.49,61.62 117.5,61.62 117.53,61.65 117.53,63.25 117.88,63.6 117.88,64.59 118.26,64.97 118.26,65.29 117.92,65.64 117.92,66.18 119.19,67.45 119.19,74.42 v1(119.95,75.18)
  SIG4 w0.155: v1(11.49,161.54) 11.37,161.54 10.86,161.03 10.22,161.03 9.38,160.19 9.38,151.74 20.48,140.64 20.48,137.82 25.08,133.22 38.93,133.22 51.87,120.27 51.87,119.38 54.74,116.51 54.87,116.51 v1(55.05,116.33)
  SIG10 w0.155: v1(119.95,75.18) 120.46,75.69 120.46,77.34 120.08,77.72 116.4,77.72 116.14,77.47 114.63,77.47 113.99,78.11 113.99,82.89 109.31,87.57 94.92,87.57 93.97,88.52 91.38,88.52 90.38,89.51 90.38,91.67 85.53,96.52 84.87,96.52 77.12,104.27 73.5,104.27 73.5,104.27 67.99,104.27 63.55,108.71 62.67,108.71 v1(55.05,116.33)
  BOTTOM w0.13: R2677.2 119.82,77.87 119.34,77.39 119.34,76.68 119.7,76.32 v2(119.7,76.2) 119.7,75.44 v1(119.95,75.18)
RESETL9: length 169.7
  TOP w0.13: R3334.2 17.46,146.81 17.84,146.43 v1(18.22,146.43)
  SIG2 w0.152: v1(121.22,81.28) 120.71,80.77 120.71,78.48 120.46,78.23 120.46,72.95 116.78,69.26 116.78,67.31 115.47,66 115.47,65.66 115.85,65.28 115.85,64.96 115.47,64.58 115.47,61.66 115.85,61.28 115.85,60.95 115.5,60.6 115.5,57.66 115.88,57.27 115.88,56.98 115.5,56.6 115.5,53.66 115.94,53.21 116.11,53.21 YJ25.B9
  SIG4 w0.155: v1(55.18,119.82) 55.18,120.01 38.54,136.65 27.85,136.65 26.21,138.29 24.51,138.29 23.73,139.06 23.73,140.4 18.22,145.91 v1(18.22,146.43)
  SIG10 w0.155: v1(121.22,81.28) 118.81,81.28 116.52,83.56 115.12,83.56 109.84,88.84 96.13,88.84 94.93,90.04 94.29,90.04 83.12,101.22 82.22,101.22 81.6,101.84 81.6,102.73 78.79,105.55 74.03,105.55 74.03,105.55 68.57,105.55 68.55,105.57 68.49,105.57 63.97,110.1 63.22,110.1 56.89,116.43 56.89,117.21 55.18,118.92 v1(55.18,119.82)
  BOTTOM w0.13: v1(121.22,81.28) 121.09,81.4 v2(121.09,82.17) 121.09,82.67 121.35,82.93 121.35,83.59 R2675.1
RESETL10: length 173.1
  TOP w0.13: v1(25.84,139.06) 25.84,139.82 25.21,140.46 24.7,140.46 20.26,144.9 R3338.2
  SIG2 w0.152: YJ25.C9 136.17,60.69 136.17,61.3 136.53,61.66 136.53,63.25 136.88,63.6 136.88,64.59 137.26,64.97 137.26,65.29 136.92,65.64 136.92,66.98 136.57,67.32 136.57,72.53 136.33,72.77 136.33,74.55 135.95,74.93 135.32,74.93 135.12,75.13 135.12,75.86 v1(134.66,76.32)
  SIG4 w0.155: v1(58.86,123.06) 53.1,123.06 38.75,137.41 35.62,137.41 35.12,137.92 34.1,137.92 33.47,137.29 28.29,137.29 26.52,139.06 v1(25.84,139.06)
  SIG10 w0.155: v1(58.86,123.06) 59.12,122.81 59.12,121.67 60.83,119.96 61.32,119.96 68.17,113.12 77.64,113.12 95.3,95.45 120.44,95.45 125.29,90.6 125.29,88.4 126.18,87.51 126.18,84.57 127,83.75 127,81.06 127.67,80.39 127.67,78.5 129.85,76.32 v1(134.66,76.32)
  BOTTOM w0.13: v1(134.66,76.32) 134.18,76.32 133.92,76.58 v2(133.92,76.63) 133.92,76.96 134.05,77.09 134.05,77.72 134.2,77.87 R2676.2
RESETL11: length 182.6
  SIG3 w0.155: v1(135.85,80.49) 135.37,80.01 135.37,78.92 134.18,77.72 134.18,69.85 134.43,69.59 134.43,65.7 134.85,65.28 134.85,64.96 134.47,64.58 134.47,61.67 134.85,61.29 134.85,60.96 134.5,60.61 134.5,57.63 134.88,57.25 134.88,56.99 134.5,56.61 134.5,53.63 134.92,53.21 135.11,53.21 YJ25.D9
  SIG4 w0.155: v1(23.69,144.78) 24.21,144.78 25.61,143.38 25.61,142.02 27.84,139.8 32.22,139.8 32.56,140.14 39.86,140.14 49.21,130.8 49.21,128.76 53.13,124.84 59.25,124.84 59.88,124.2 59.88,122.55 v1(61.15,121.28)
  SIG10 w0.155: v1(135.85,80.49) 135.35,79.98 133.17,79.98 129.87,83.29 129.87,85.63 126.56,88.93 126.56,91.13 120.97,96.73 95.83,96.73 77.46,115.1 67.99,115.1 61.81,121.28 v1(61.15,121.28)
  BOTTOM w0.13: v1(23.69,144.78) 22.92,145.54 v2(22.92,145.92) 22.92,146.94 23.33,147.34 R3340.2 ; v1(135.85,80.49) 135.27,81.08 135.27,83 135.57,83.31 R2674.1
RESETL12: length 201.9
  TOP w0.13: v1(165.16,74.32) 165.67,74.83 165.67,77.34 165.42,77.59 R2714.2
  SIG3 w0.155: YJ27.A9 163.9,61.03 164.53,61.66 164.53,63.25 164.88,63.6 164.88,64.59 165.26,64.97 165.26,65.27 164.92,65.61 164.92,66.18 165.11,66.38 165.11,72.59 165.67,73.15 165.67,73.81 v1(165.16,74.32)
  SIG4 w0.155: v1(29.27,142.09) 29.3,142.11 39.7,142.11 50.48,131.33 50.48,129.28 53.53,126.24 60.23,126.24 65.06,121.4 79.81,121.4 v1(81.85,123.44)
  SIG10 w0.155: v1(81.85,123.44) 84.1,121.19 110.42,121.19 136.84,94.77 136.84,93.81 137.83,92.81 137.83,86.74 140.91,83.67 140.91,82.42 141.16,82.17 142.18,82.17 144.16,80.18 157.75,80.18 158.22,80.65 161.16,80.65 161.79,81.28 163.77,81.28 164.26,80.78 164.26,75.22 v1(165.16,74.32)
  BOTTOM w0.13: v1(29.27,142.09) 29.25,142.11 28.64,142.11 v2(26.67,144.08) 25.97,144.78 R3337.1
RESETL13: length 214.4
  TOP w0.13: R3348.1 28.13,146.94 v1(27.62,146.43)
  SIG2 w0.152: YJ27.B9 163.11,53.21 162.94,53.21 162.5,53.66 162.5,56.61 162.88,56.99 162.88,57.25 162.5,57.63 162.5,60.61 162.85,60.96 162.85,61.3 162.47,61.68 162.47,64.58 162.85,64.96 162.85,65.31 162.47,65.69 162.47,66.56 163.77,67.86 163.77,77.72 164.4,78.36 164.4,79.37 v1(165.42,80.39)
  SIG4 w0.155: v1(82.99,123.44) 82.36,124.08 81.09,124.08 79.05,122.04 65.33,122.04 60.37,126.99 60.37,133.23 57.75,135.86 46.85,135.86 39.33,143.38 31.81,143.38 31.43,143 29.02,143 28.38,143.63 28.38,145.67 v1(27.62,146.43)
  SIG10 w0.155: v1(82.99,123.44) 84.6,121.83 110.68,121.83 137.56,94.95 137.56,94.01 138.49,93.08 138.49,86.98 141.53,83.94 142.43,83.94 142.68,83.69 142.68,82.8 144.58,80.91 156.79,80.91 157.95,82.06 163.93,82.06 165.42,80.58 v1(165.42,80.39)
  BOTTOM w0.13: v1(165.42,80.39) 165.93,80.9 165.93,83.56 165.77,83.72 R2713.1 ; v1(82.99,123.44) v2(82.99,124.2)
RESETL14: length 277.2
  SIG2 w0.152: YJ27.C9 183.17,60.69 183.17,61.31 183.53,61.67 183.53,63.25 183.88,63.6 183.88,64.59 184.26,64.97 184.26,65.29 183.92,65.64 183.92,68.49 179.77,72.64 179.77,73.53 v1(178.75,74.55)
  SIG10 w0.155: v1(178.75,74.55) 177.33,75.97 177.33,81.18 177.08,81.43 176.44,81.43 175.45,82.42 175.45,84.34 174.18,85.61 174.18,87.51 172.67,89.02 170.87,89.02 167.95,91.95 160.95,91.95 159.36,93.54 157.44,93.54 154.77,90.87 150.11,90.87 147.76,93.22 147.76,97.61 142.89,102.48 138.12,102.48 112.03,128.58 112.03,189.64 106.22,195.45 102.81,195.45 102.17,194.82 92.39,194.82 91.76,195.45 90.36,195.45 89.6,194.69 79.06,194.69 78.3,195.45 77.28,195.45 76.8,194.97 68.28,194.97 67.62,194.31 63.78,194.31 52.65,183.18 50.11,183.18 42.97,176.04 42.97,169.23 39.6,165.86 v1(39.18,165.86)
  BOTTOM w0.13: v1(39.18,165.86) 38.54,166.49 36.77,166.49 36.49,166.22 R3264.2 ; R2719.2 177.74,77.21 177.61,77.09 v2(177.61,76.45) 177.61,75.69 v1(178.75,74.55)
RESETL15: length 283.3
  TOP w0.13: R3252.2 v1(37.4,167)
  SIG3 w0.155: YJ27.D9 182.11,53.21 181.93,53.21 181.5,53.64 181.5,56.61 181.88,56.99 181.88,57.25 181.5,57.63 181.5,60.61 181.8,60.91 181.8,60.92 181.85,60.96 181.85,61.28 181.47,61.66 181.47,64.58 181.8,64.91 181.8,64.92 181.85,64.96 181.85,65.31 181.15,66.01 181.15,71.5 178.22,74.42 178.22,80.75 v1(178.75,81.28)
  SIG10 w0.155: v1(37.4,167) 37.91,167.51 38.67,167.51 41.7,170.54 41.7,176.57 49.58,184.45 50.87,184.45 58.69,192.27 59.94,192.27 63.25,195.59 65.45,195.59 66.11,196.25 76.27,196.25 76.75,196.73 78.82,196.73 79.59,195.96 89.07,195.96 89.83,196.73 92.29,196.73 92.92,196.09 101.64,196.09 102.28,196.73 107.2,196.73 113.3,190.62 113.3,129.11 137.43,104.98 142.35,104.98 145.35,101.98 147.75,101.98 151.16,98.57 154.24,98.57 157.99,94.82 159.89,94.82 161.36,93.34 168.35,93.34 171.03,90.66 172.83,90.66 175.57,87.92 175.57,86.49 178.12,83.94 179.01,83.94 179.26,83.69 179.26,81.79 v1(178.75,81.28)
  BOTTOM w0.13: v2(39.18,167.89) 38.8,167.51 37.91,167.51 v1(37.4,167) ; R2712.1 179.11,83.72 179.26,83.56 179.26,81.79 v1(178.75,81.28)
RESETL16: length 328.1
  TOP w0.13: v1(215.2,73.66) 215.71,74.17 215.71,76.71 215.2,77.21 R2750.2 ; v1(414.59,177.42) R3396.1
  SIG3 w0.155: v1(215.2,73.66) 214.88,73.33 214.88,70.41 212.28,67.82 212.28,66.55 211.92,66.18 211.92,65.64 212.26,65.29 212.26,64.97 211.88,64.59 211.88,63.6 211.53,63.25 211.53,61.66 211.17,61.3 211.17,60.69 YJ29.A9
  SIG10 w0.155: v1(414.59,177.42) 415.86,177.42 416.37,176.9 416.37,175.34 425.64,166.08 425.64,135.13 417.9,127.38 417.9,99.06 411.16,92.33 403.24,92.33 399.43,88.52 399.43,87.9 390.96,79.43 390.96,78.19 380.08,67.31 221.55,67.31 v1(215.2,73.66)
  BOTTOM w0.13: v1(414.59,177.42) v2(413.83,177.42)
RESETL17: length 347.6
  TOP w0.13: v1(414.59,176.15) R3407.1
  SIG2 w0.152: v1(215.2,80.39) 214.06,79.25 214.06,74.42 210.07,70.43 210.07,67.16 209.47,66.56 209.47,65.69 209.85,65.31 209.85,64.96 209.47,64.58 209.47,61.66 209.85,61.28 209.85,60.96 209.5,60.61 209.5,57.63 209.8,57.33 209.8,56.91 209.5,56.61 209.5,53.66 209.94,53.21 210.11,53.21 YJ29.B9
  SIG10 w0.155: v1(215.2,80.39) 214.69,79.88 214.69,77.72 215.71,76.71 215.71,74.29 222.05,67.95 379.79,67.95 390.32,78.48 390.32,79.72 397.91,87.31 397.91,89.48 400.63,92.2 402.15,92.2 404.3,94.36 411.92,94.36 417.13,99.57 417.13,127.9 424.75,135.52 424.75,165.32 415.74,174.33 415.74,175.76 415.35,176.15 v1(414.59,176.15)
  BOTTOM w0.13: R2749.1 215.71,83.21 215.71,80.9 v1(215.2,80.39) ; v1(414.59,176.15) v2(413.83,176.15)
RESETL18: length 254.2
  SIG2 w0.152: YJ29.C9 230.17,60.69 230.17,61.3 230.53,61.66 230.53,63.25 230.88,63.6 230.88,64.58 231.26,64.96 231.26,65.27 230.92,65.61 230.92,66.18 231.28,66.55 231.28,70.79 228.86,73.21 228.86,74.22 v1(228.54,74.55)
  SIG10 w0.155: v1(228.54,74.55) 229.38,73.71 247.94,73.71 248.28,74.05 250.52,74.05 251.26,73.31 278.88,73.31 280.42,74.85 280.42,82.28 287.8,89.66 291.53,89.66 313.84,111.97 351.27,111.97 362.77,123.47 362.77,134.64 364.26,136.13 364.26,143.43 365.81,144.98 365.81,153.64 369.5,157.33 369.5,166.98 371.6,169.08 372.87,169.08 373.97,170.18 380.84,170.18 382.75,172.09 386.12,172.09 387.96,173.92 389.2,173.92 v1(390.36,175.08)
  BOTTOM w0.13: v1(390.36,175.08) v2(390.36,177.16) R3412.1 ; v1(228.54,74.55) 227.92,75.16 227.92,76.32 227.47,76.78 227.47,77.82 R2758.2
RESETL19: length 273.9
  TOP w0.13: R3414.1 389.83,175.77 389.52,175.46 389.12,175.46 388.18,174.52 v1(388.18,172.34)
  SIG3 w0.155: v1(228.54,80.39) 228.05,79.9 228.05,73.76 228.28,73.53 228.28,66.48 228.47,66.29 228.47,65.69 228.85,65.31 228.85,64.95 228.47,64.57 228.47,61.66 228.85,61.28 228.85,60.96 228.5,60.61 228.5,57.63 228.88,57.25 228.88,56.99 228.5,56.61 228.5,53.63 228.51,53.62 228.8,53.33 228.8,53.33 228.92,53.21 229.11,53.21 YJ29.D9
  SIG10 w0.155: v1(388.18,172.34) 386.04,170.2 383.04,170.2 380.56,167.72 380.56,165.09 379.56,164.09 373.2,164.09 370.78,161.67 370.78,156.8 367.09,153.11 367.09,144.45 365.95,143.31 365.95,135.6 364.04,133.7 364.04,122.94 351.71,110.61 314.51,110.61 291.91,88.01 289.86,88.01 281.72,79.87 281.72,74.31 279.16,71.75 250.63,71.75 250.13,72.26 228.65,72.26 227.26,73.65 227.26,79.62 228.03,80.39 v1(228.54,80.39)
  BOTTOM w0.13: v1(228.54,80.39) 228.05,80.87 228.05,81.79 227.9,81.94 227.9,83.08 228.54,83.71 R2757.1 ; v1(388.18,172.34) v2(388.94,172.34)
RESETL20: length 231.4
  SIG3 w0.155: v1(259.4,74.93) 259.26,74.78 259.26,66.52 258.92,66.18 258.92,65.64 259.26,65.29 259.26,64.97 258.88,64.59 258.88,63.6 258.53,63.25 258.53,61.66 258.17,61.3 258.17,60.69 YJ31.A9
  SIG10 w0.155: v1(383.48,182.23) 367.95,182.23 366.08,180.36 366.08,178.32 362.27,174.51 357.79,174.51 354.9,171.62 354.9,154.56 353.63,153.29 353.63,146.84 352.18,145.39 352.18,140.91 351.09,139.82 351.09,135.45 352.18,134.36 352.18,132.35 343.21,123.39 292.23,123.39 268.16,99.31 268.16,77.98 265.62,75.44 259.91,75.44 v1(259.4,74.93)
  BOTTOM w0.13: R2796.2 258.38,75.94 v1(259.4,74.93) ; R3431.1 388.94,185.04 v2(388.56,184.66) 387.79,183.89 385.14,183.89 v1(383.48,182.23)
RESETL21: length 262.3
  TOP w0.13: R3434.2 386.27,183.77 v1(385.51,184.53)
  SIG2 w0.152: v1(259.4,81.28) 258.13,80.01 258.13,75.44 257.07,74.38 257.07,67.16 256.47,66.56 256.47,65.69 256.85,65.31 256.85,64.96 256.47,64.58 256.47,61.68 256.85,61.3 256.85,60.96 256.51,60.62 256.5,60.62 256.5,57.64 256.88,57.25 256.88,56.99 256.51,56.62 256.5,56.62 256.5,53.66 256.94,53.21 257.11,53.21 YJ31.B9
  SIG10 w0.155: v1(259.4,81.28) 259.91,81.79 259.91,83.21 260.26,83.56 262.22,83.56 264.61,85.96 264.61,100.44 275.98,111.81 275.98,171.41 291.74,187.17 308.14,187.17 310.08,189.11 322.27,189.11 322.89,189.73 327.29,189.73 331.78,194.22 348.26,194.22 357.87,184.61 361.97,184.61 362.43,185.08 384.96,185.08 v1(385.51,184.53)
  BOTTOM w0.13: R2794.1 259.75,83.72 259.85,83.61 259.85,81.73 v1(259.4,81.28) ; v1(385.51,184.53) v2(385.51,185.42)
RESETL22: length 213.3
  SIG2 w0.152: v1(272.73,74.53) 278.28,68.99 278.28,66.55 277.92,66.18 277.92,65.64 278.26,65.29 278.26,64.96 277.88,64.58 277.88,63.6 277.53,63.25 277.53,61.66 277.17,61.3 277.17,60.69 YJ31.C9
  SIG10 w0.155: v1(388.15,176.1) 388.15,175.92 386.43,174.19 384.86,174.19 384.03,173.36 382.11,173.36 381.74,172.99 375.29,172.99 374.98,172.68 374.05,172.68 373.43,173.3 372.33,173.3 371.26,172.24 371.26,171.13 369.4,169.27 369.09,169.27 368.74,168.93 368.74,168.53 367.6,167.38 367.6,157.23 364.54,154.17 364.54,145.51 362.99,143.96 362.99,136.66 361.49,135.16 361.49,124 351.24,113.75 313.46,113.75 290.89,91.18 286.6,91.18 282.92,87.5 279.32,87.5 278.32,86.49 278.32,77.36 275.89,74.93 273.13,74.93 v1(272.73,74.53)
  BOTTOM w0.13: v1(388.15,176.1) 388.15,178.15 v2(388.56,178.56) 389.95,179.96 R3420.1 ; v1(272.73,74.53) 271.73,74.53 271.08,75.18 271.08,76.96 271.59,77.47 R2795.2
RESETL23: length 230.8
  SIG3 w0.155: v1(272.73,80.39) 272.22,79.88 272.22,74.37 275.4,71.19 275.4,65.73 275.85,65.28 275.85,64.96 275.47,64.58 275.47,61.66 275.85,61.28 275.85,60.96 275.5,60.61 275.5,57.63 275.88,57.25 275.88,56.99 275.5,56.61 275.5,53.63 275.98,53.15 276.17,53.15 YJ31.D9
  SIG10 w0.155: v1(272.73,80.39) 272.22,80.9 272.22,87.37 271.72,87.88 271.72,99.57 293.08,120.93 343.99,120.93 344.85,121.79 350.59,121.79 355.77,126.97 355.77,136.89 354.84,137.82 354.84,144.79 355.77,145.72 355.77,152.26 357.01,153.49 357.01,156.87 357.47,157.33 357.47,162.22 362.43,167.18 362.43,171.97 369.53,179.07 369.91,179.07 370.84,179.99 378.07,179.99 378.55,180.47 385.85,180.47 386.6,181.23 v1(387.16,181.23)
  BOTTOM w0.13: R3417.1 v2(388.56,182.5) 388.18,182.5 387.16,181.48 v1(387.16,181.23) ; v1(272.73,80.39) 272.25,80.87 272.25,83.23 R2793.1
RESETL24: length 183.9
  TOP w0.13: v1(394.53,166.49) 395.29,167.26 396.94,167.26 398.59,168.91 R3422.2 ; R2830.2 v1(312.36,84.33)
  SIG3 w0.155: YJ33.A9 305.17,60.69 305.17,61.29 305.2,61.32 305.2,61.33 305.49,61.62 305.5,61.62 305.53,61.65 305.53,63.25 305.88,63.6 305.88,64.59 306.26,64.97 306.26,65.29 305.92,65.64 305.92,66.18 306.28,66.55 306.28,70.08 303.72,72.64 303.72,74.42 308.42,79.12 308.42,82.29 309.82,83.69 311.72,83.69 v1(312.36,84.33)
  SIG10 w0.155: v1(394.53,166.49) 394.26,166.23 393.98,166.23 390.67,162.92 389.67,162.92 383.21,156.46 381.69,156.46 380.8,155.57 378.9,155.57 373.89,150.56 373.89,144.17 371.56,141.83 371.56,137.21 370.83,136.49 370.83,133.44 369.87,132.48 369.87,126.7 369.94,126.63 369.94,103.81 369.03,102.89 322.6,102.89 311.85,92.15 311.85,84.83 v1(312.36,84.33)
  BOTTOM w0.13: v1(312.36,84.33) v2(312.36,85.09)
RESETL25: length 183.4
  TOP w0.13: R2831.1 v1(307.91,77.21)
  SIG2 w0.152: YJ33.B9 304.11,53.21 303.94,53.21 303.5,53.66 303.5,56.62 303.51,56.62 303.88,56.99 303.88,57.25 303.51,57.62 303.5,57.62 303.5,60.62 303.51,60.62 303.85,60.96 303.85,61.28 303.47,61.66 303.47,64.58 303.85,64.96 303.85,65.28 303.47,65.66 303.47,66.56 304.07,67.16 304.07,71.97 307.28,75.18 307.28,76.58 v1(307.91,77.21)
  SIG10 w0.155: v1(393.64,168.91) 392.74,168.91 390.08,166.24 388.43,166.24 383.73,161.54 381.19,161.54 379.72,160.07 378.2,160.07 376.62,158.49 376.62,156.72 376.36,156.46 375.22,156.46 374.08,155.32 374.08,154.58 371.24,151.74 371.24,148.48 370.49,147.74 370.49,144.13 368.45,142.09 368.45,134.54 366.72,132.8 366.72,120.14 365.82,119.25 364.16,119.25 350.65,105.75 321.06,105.75 308.55,93.23 308.55,77.85 v1(307.91,77.21)
  BOTTOM w0.13: v1(393.64,168.91) 393.64,168.78 394.14,168.27 395.92,168.27 v2(396.05,168.4) 396.84,169.19 R3418.2
RESETL26: length 177
  SIG2 w0.152: YJ33.C9 324.17,60.69 324.17,61.3 324.53,61.66 324.53,63.25 324.88,63.6 324.88,64.59 325.26,64.97 325.26,65.29 324.92,65.64 324.92,67.17 324.49,67.59 324.49,73.33 v1(324.17,73.66)
  SIG10 w0.155: v1(399.29,167) 399.15,166.86 399.15,166.35 385.8,153 383.37,153 380.94,150.58 378.92,150.58 376.93,148.59 376.93,142.95 374.83,140.84 374.83,135.6 373.94,134.72 373.94,129.79 372.99,128.83 372.99,101.74 371.12,99.88 329.26,99.88 320,90.62 320,77.82 v1(324.17,73.66)
  BOTTOM w0.13: R3424.2 399.86,168.4 400.08,168.17 v2(400.08,167.79) v1(399.29,167) ; v1(324.17,73.66) 322.52,75.31 322.52,77.49 R2839.2
RESETL27: length 194.9
  TOP w0.13: v1(400.95,167.51) 401.64,168.2 401.64,169.06 401.51,169.19 R3432.2
  SIG3 w0.155: v1(324.17,80.39) 323.69,79.91 323.69,67.33 322.47,66.11 322.47,65.66 322.85,65.28 322.85,64.96 322.47,64.58 322.47,61.66 322.85,61.28 322.85,60.96 322.5,60.61 322.5,57.63 322.5,57.62 322.51,57.62 322.88,57.25 322.88,56.99 322.5,56.61 322.5,53.63 322.51,53.62 322.8,53.33 322.8,53.33 322.92,53.21 323.11,53.21 YJ33.D9
  SIG10 w0.155: v1(324.17,80.39) 323.71,80.85 323.71,87.45 323.28,87.88 323.28,90.35 329.75,96.82 357.26,96.82 364.7,89.37 367.52,89.37 368.06,89.92 371.8,89.92 374.74,92.86 374.74,126.82 376.53,128.61 376.53,130.94 376.22,131.25 376.22,134.17 376.62,134.57 376.62,140.17 378.67,142.22 378.67,147.87 379.65,148.84 381.66,148.84 383.84,151.01 386.47,151.01 400.91,165.45 400.91,167.46 v1(400.95,167.51)
  BOTTOM w0.13: R2829.1 324.52,83.72 324.68,83.56 324.68,80.9 v1(324.17,80.39) ; v1(400.95,167.51) 401,167.46 v2(401,166.75)
RESETL28: length 179.5
  SIG3 w0.155: YJ35.A9 351.9,61.03 352.2,61.32 352.2,61.33 352.53,61.66 352.53,63.25 352.88,63.6 352.88,64.59 353.26,64.97 353.26,65.29 352.92,65.64 352.92,67.01 349.44,70.48 v1(349.44,71.42)
  SIG10 w0.155: v1(409.85,165.61) 410.33,165.13 410.33,144.42 407.96,142.05 407.96,108.05 399.22,99.31 397.32,99.31 389.06,91.06 388.56,91.06 387.22,89.72 387.22,88.24 386.91,87.93 386.39,87.93 381.49,83.03 381.49,79.1 380.25,77.86 374.67,77.86 374.28,77.46 368.11,77.46 366.2,75.56 363.79,75.56 362.78,76.58 354.14,76.58 352.87,75.31 351.09,75.31 350.08,74.29 350.08,72.06 v1(349.44,71.42)
  BOTTOM w0.13: v1(409.85,165.61) v2(407.34,165.61) 406.34,165.61 402.76,169.19 R3423.1 ; R2877.2 359.28,82.27 359.6,81.94 359.6,75.82 354.39,70.61 350.25,70.61 v1(349.44,71.42)
RESETL29: length 202.7
  TOP w0.13: R2875.1 359.37,82.27 359.6,82.04 359.6,74.93 355.16,70.48 347.54,70.48 v1(346.65,71.37)
  SIG2 w0.152: YJ35.B9 351.11,53.21 350.94,53.21 350.5,53.66 350.5,56.61 350.85,56.96 350.85,57.28 350.5,57.63 350.5,60.61 350.85,60.96 350.85,61.28 350.47,61.66 350.47,64.58 350.85,64.96 350.85,65.28 350.47,65.66 350.47,66.15 347.15,69.47 347.15,70.86 v1(346.65,71.37)
  SIG10 w0.155: v1(346.65,71.37) 347.08,70.94 351.68,70.94 352.62,71.88 352.62,72.13 353.31,72.83 355.98,72.83 356.81,73.66 366.23,73.66 368.26,75.69 371.67,75.69 372.05,75.31 373.97,75.31 374.96,74.31 380.7,74.31 381.8,75.41 381.8,77.07 383.72,78.99 383.72,81.83 385.2,83.32 385.2,84.94 386.9,86.64 388.58,86.64 390.59,88.64 390.59,89.91 398.21,97.53 399.79,97.53 405.63,103.38 409.12,103.38 411.55,105.8 411.55,115.05 410.78,115.82 410.78,131.7 409.46,133.02 409.46,141.75 410.6,142.89 410.6,142.89 411.67,143.96 411.67,167.73 411.12,168.27 v1(409.85,168.27)
  BOTTOM w0.13: v1(409.85,168.27) v2(407.35,168.27) 406.34,168.27 405.42,169.19 R3429.1
RESETL30: length 145.1
  TOP w0.13: R3388.1 414.34,178.69 v1(414.59,178.43)
  SIG2 w0.152: YJ35.C9 371.17,60.69 371.17,61.3 371.53,61.66 371.53,63.25 371.88,63.6 371.88,64.58 372.26,64.96 372.26,65.29 371.92,65.64 371.92,66.68 370.78,67.82 v1(370.78,69.34)
  SIG8 w0.155: v1(374.97,77.09) 375.47,77.59 380.04,77.59 381.06,78.61 383.11,78.61 389.95,85.45 389.95,90.43 406.08,106.57 406.08,107.58 407.09,108.58 407.09,142.27 415.23,150.41 415.23,171.96 413.96,173.23 413.96,177.8 v1(414.59,178.43)
  BOTTOM w0.13: R2876.2 374.59,77.47 v1(374.97,77.09) 374.71,76.83 v2(374.71,75.94) 374.71,71.88 372.17,69.34 v1(370.78,69.34)
RESETL31: length 166.1
  TOP w0.13: v1(414.59,182.5) R3371.1
  SIG3 w0.155: YJ35.D9 370.16,53.16 369.97,53.16 369.5,53.63 369.5,56.6 369.88,56.98 369.88,57.25 369.8,57.32 369.8,57.33 369.51,57.62 369.5,57.62 369.5,57.63 369.5,60.6 369.85,60.95 369.85,61.28 369.47,61.66 369.47,64.58 369.85,64.96 369.85,65.29 369.47,65.67 369.47,66.56 368.17,67.86 368.17,70.28 v1(368.49,70.61)
  SIG8 w0.155: v1(414.59,182.5) 413.19,181.1 413.19,149.28 406.45,142.54 406.45,108.96 405.3,107.81 405.3,106.7 389.19,90.6 389.19,88.25 385.57,84.62 385.57,82.35 382.59,79.37 379.42,79.37 378.28,78.23 371.05,78.23 369.13,76.31 369.13,71.25 v1(368.49,70.61)
  BOTTOM w0.13: R2874.1 369,77.38 369.13,77.25 v2(369.13,76.45) 369.13,75.82 369,75.69 369,71.12 v1(368.49,70.61)
RESETL32: length 148.2
  TOP w0.13: v1(16.19,81.28) 16.57,81.28 16.83,81.53 16.83,81.91 16.98,82.06 R2616.1 ; v1(9.59,162.81) 10.73,163.95 R3349.2
  SIG4 w0.155: v1(16.19,81.28) 16.7,81.79 16.7,90.42 16.57,90.55 16.57,97.28 21.27,101.98 21.27,122.15 14.14,129.28 11.61,129.28 9.79,131.11 9.79,131.49 7.47,133.81 7.47,161.21 9.07,162.81 v1(9.59,162.81)
  SIG7 w0.155: v1(16.19,81.28) 15.68,80.77 15.68,79.5 12.38,76.2 12.38,74.55 9.33,71.5 9.33,68.7 8.45,67.82 8.45,59.56 8.95,59.05 8.95,54.35 13.25,50.06 23.48,50.06 24.5,51.08 YJ22.D9
  BOTTOM w0.13: v1(9.59,162.81) v2(9.59,163.57)
RESETL33: length 128.4
  SIG4 w0.155: v1(9.72,161.54) 8.74,160.57 8.74,151.48 19.7,140.52 19.7,137.51 23.3,133.91 23.3,101.22 18.86,96.77 18.86,91.59 18.71,91.44 18.71,81.89 v1(18.22,81.4)
  SIG10 w0.155: v1(18.22,81.4) 18.86,81.4 31.56,68.7 31.56,60.13 30.86,59.43 25.49,59.43 YJ22.C9
  BOTTOM w0.13: R2614.2 v1(18.22,81.4) ; R3347.1 12.64,162.81 12,162.18 v2(11.06,162.18) 10.35,162.18 v1(9.72,161.54)
RESETL34: length 168.3
  TOP w0.13: R2617.1 v1(55.44,83.69)
  SIG7 w0.155: YJ22.B9 45.88,50.04 50.1,50.04 50.36,49.78 53.53,49.78 54.55,50.8 54.55,71.5 54.93,71.88 54.93,77.59 55.44,78.1 v1(55.44,83.69)
  SIG10 w0.155: v1(10.6,158.24) 9.21,158.24 6.5,155.53 6.5,134.38 10.25,130.63 10.94,130.63 11.33,131.02 19.6,131.02 22.09,128.53 22.09,126.11 21.66,125.68 21.66,102.86 22.84,101.68 22.84,99.63 24.13,98.34 25.08,98.34 29.45,93.98 33.59,93.98 33.97,93.6 35.54,93.6 35.54,93.6 35.96,93.6 37.12,92.44 39.74,92.44 42.27,89.91 44.74,89.91 47.69,86.97 52.82,86.97 53.06,87.21 56.06,87.21 56.2,87.35 56.63,87.35 56.96,87.02 56.96,85.21 v1(55.44,83.69)
  BOTTOM w0.13: R3333.2 12.38,159.38 v2(12,159) 11.37,159 v1(10.6,158.24) ; v1(55.44,83.69) 55.51,83.77 v2(55.51,84.45)
RESETL35: length 215.5
  TOP w0.13: v1(56.45,86.87) R2615.2 56.86,87.53 56.96,87.63 56.96,89.53 54.67,91.82 52.51,91.82 52.01,91.31 41.59,91.31 40.07,89.79 40.07,88.52 40.7,87.88 40.7,84.33 v1(40.58,84.2)
  SIG8 w0.155: YJ22.A9 43.5,59.81 44.13,59.18 50.1,59.18 51.68,60.75 51.68,73.66 52.44,74.42 52.44,76.88 53.78,78.23 54.55,78.23 55.31,78.99 55.31,80.39 56.96,82.04 56.96,86.36 v1(56.45,86.87)
  SIG9 w0.155: v1(38.29,164.84) 37.53,164.08 33.85,164.08 31.81,166.11 29.15,166.11 28,167.26 24.07,167.26 22.92,166.11 16.45,166.11 14.92,164.59 8.06,164.59 v1(7.68,164.21)
  SIG10 w0.155: v1(7.68,164.21) 6.92,164.21 2.43,159.72 2.43,100.12 5.52,97.03 11.62,97.03 17.46,91.18 18.22,91.18 19.87,89.54 19.94,89.61 20.32,89.61 20.52,89.41 33.03,89.41 34.06,88.38 36.3,88.38 40.48,84.2 v1(40.58,84.2)
  BOTTOM w0.13: R3270.1 36.49,165.07 36.77,165.35 37.78,165.35 v1(38.29,164.84) ; v1(7.68,164.21) v2(7.68,164.97) ; v2(55.82,87.5) v1(56.45,86.87)
RESETL36: length 153.6
  SIG8 w0.155: v1(72.45,81.28) 73.03,80.71 73.03,78.42 73.57,77.87 73.57,68.71 70.92,66.05 70.92,65.61 71.26,65.27 71.26,64.97 70.92,64.63 70.92,61.61 71.26,61.27 71.26,60.97 70.88,60.59 70.88,57.65 71.26,57.27 71.26,56.97 70.92,56.63 70.92,53.61 71.5,53.03 YJ24.D9
  SIG10 w0.155: v1(72.45,81.28) 71.95,81.79 71.95,83.44 71.69,83.69 71.31,83.69 70.96,83.33 70.96,82.32 70.32,81.68 68.87,81.68 67.75,82.8 67.75,84.83 65.85,86.74 63.94,86.74 61.79,88.9 61.79,89.41 61.15,90.04 60.39,90.04 60.01,90.42 57.48,90.42 56.97,90.93 55.05,90.93 54.79,90.68 53.95,90.68 53.67,90.96 51.54,90.96 49.45,93.04 47.71,93.04 44.61,96.14 43.41,96.14 42.89,95.63 41.98,95.63 39.31,98.3 35.78,98.3 34.77,99.31 30.82,99.31 25.28,104.85 25.28,129.85 19.61,135.52 19.61,140.87 12.38,148.09 v1(12.38,154.81)
  BOTTOM w0.13: R2655.1 72.56,83.72 72.91,83.36 72.91,82.6 73.34,82.17 v2(73.34,81.66) 72.96,81.28 v1(72.45,81.28) ; R3330.1 v1(12.38,154.81)
RESETL37: length 143.8
  TOP w0.13: R2653.2 v1(72.45,77.21)
  SIG9 w0.155: v1(72.45,77.21) 71.97,76.73 71.16,76.73 70.92,76.48 70.92,67.2 70.53,66.81 70.53,65.68 70.12,65.27 70.12,64.99 70.5,64.61 70.5,62.64 70.73,62.41 70.73,61.8 71.5,61.03 YJ24.C9
  SIG10 w0.155: v1(10.48,155.95) 9.84,155.32 9.84,148.83 18.31,140.36 18.31,135.02 24,129.32 24,123.99 23.58,123.57 23.58,104.54 26.35,101.76 26.35,101.57 29.89,98.03 33.55,98.03 34.64,96.95 35.32,96.95 37.92,94.35 43.3,94.35 46.21,91.44 48.24,91.44 50,89.68 52.36,89.68 52.77,89.28 55.21,89.28 55.59,89.66 56.43,89.66 57.57,88.52 59.88,88.52 63.31,85.09 63.31,82.29 64.86,80.74 66.13,80.74 68.9,77.98 71.69,77.98 v1(72.45,77.21)
  BOTTOM w0.13: v1(10.48,155.95) 10.6,156.08 v2(10.6,156.84) 10.6,157.1 11.11,157.6 12.79,157.6 R3329.1
RESETL38: length 154.3
  TOP w0.13: v1(31.05,145.03) 30.04,144.02 28.89,144.02 28.77,143.89 23.18,143.89 21.4,145.67 R3346.2
  SIG8 w0.155: v1(99.76,73.08) 98.87,72.19 98.87,56.13 97.85,55.12 90.49,55.12 89.73,54.35 89.73,53.8 90.2,53.33 90.2,53.32 90.5,53.02 YJ24.B9
  SIG10 w0.155: v1(31.05,145.03) 31.88,144.21 32.77,144.21 37.65,139.32 38.55,139.32 39.23,138.64 39.23,136.28 53.01,122.49 53.01,120.4 53.66,119.75 53.66,115.69 61.96,107.39 63.06,107.39 67.45,103 68.9,103 71.31,100.58 78.88,100.58 84.49,94.97 85.28,94.97 88.96,91.29 88.96,88.8 90.64,87.12 93.03,87.12 93.54,86.61 93.54,85.72 96.96,82.29 v1(96.96,81.02)
  BOTTOM w0.13: v1(99.76,73.08) 99.16,73.68 97.7,73.68 96.96,74.42 v2(96.96,76.07) 96.96,78.1 96.58,78.48 95.57,78.48 95.31,78.74 R2656.1 95.72,79.02 96.96,80.26 v1(96.96,81.02)
RESETL39: length 149.7
  TOP w0.13: R2654.2 86.14,77.87 86.27,77.75 86.27,77.44 v1(86.04,77.21)
  SIG10 w0.155: v1(24.96,139.95) 25.84,139.95 29.65,136.14 29.65,135.02 32.04,132.63 32.04,131.88 31.31,131.15 31.31,111.49 35.96,106.85 39.67,106.85 40.3,106.22 43.25,106.22 43.87,105.59 45.75,105.59 50.87,100.47 57.36,100.47 58.1,99.73 59.55,99.73 60.35,98.93 61.05,98.93 65.18,94.8 75.44,94.8 76.64,93.6 76.64,92.33 77.41,91.56 77.41,88.65 80.2,85.86 80.2,81.78 81.6,80.39 83.88,80.39 84.26,80.01 84.26,78.99 v1(86.04,77.21) 86.12,77.29 88.28,77.29 88.84,77.85 89.85,77.85 90.31,77.39 90.31,74.6 98.62,66.29 98.62,61.72 96.54,59.65 91.27,59.65 YJ24.A9
  BOTTOM w0.13: R3342.2 v2(21.4,144.9) 21.4,143.51 v1(24.96,139.95)
RESETL40: length 184.3
  TOP w0.13: R3335.1 v1(12.38,155.95)
  SIG4 w0.155: v1(56.58,118.36) 55.82,118.36 38.67,135.51 25.27,135.51 22.65,138.13 22.65,140.58 17.22,146.01 17.22,147.06 13.04,151.25 13.04,155.3 v1(12.38,155.95)
  SIG8 w0.155: v1(122.24,80.39) 122.72,79.91 122.72,71.09 118.5,66.87 118.5,66.64 117.92,66.05 117.92,65.61 118.26,65.27 118.26,64.97 117.92,64.63 117.92,61.61 118.26,61.27 118.26,60.97 117.88,60.59 117.88,57.65 118.26,57.27 118.26,56.97 117.92,56.63 117.92,53.61 118.5,53.03 YJ26.D9
  SIG10 w0.155: v1(122.24,80.39) 121.73,80.9 121.73,83.17 119.64,85.26 119.64,85.64 114.4,90.88 94.35,90.88 79.05,106.18 78.26,106.18 78.24,106.21 68.81,106.21 64.28,110.74 63.48,110.74 57.59,116.62 57.59,117.41 56.65,118.36 v1(56.58,118.36)
  BOTTOM w0.13: R2696.1 122.11,83.59 122.11,82.8 121.78,82.47 121.78,80.85 v1(122.24,80.39) ; v1(56.58,118.36) v2(56.58,117.6)
RESETL41: length 183.4
  TOP w0.13: R2695.2 119.6,77.87 119.32,77.59 119.32,76.58 120.46,75.44 120.46,74.93 120.71,74.67 121.2,74.67 121.32,74.55 v1(122.24,74.55) ; R3326.2 13.3,160.04 13.14,159.89 12.13,159.89 v1(11.49,160.53)
  SIG4 w0.155: v1(54.93,118.23) 39.18,133.98 35.25,133.98 34.48,134.74 24.64,134.74 21.25,138.13 21.25,140.77 10.02,152 10.02,159.05 v1(11.49,160.53)
  SIG9 w0.155: v1(122.24,74.55) 122.62,74.17 122.62,69.75 119.95,67.08 119.95,65.7 119.52,65.27 119.52,64.99 119.93,64.58 119.93,61.68 119.33,61.08 118.94,61.08 118.5,60.65 YJ26.C9
  SIG10 w0.155: v1(122.24,74.55) 121.6,75.18 121.6,77.98 121.22,78.36 120.59,78.36 116.14,82.8 114.98,82.8 109.57,88.2 95.23,88.2 83.18,100.25 82.28,100.25 80.96,101.57 80.96,102.1 80.7,102.36 80.09,102.36 77.54,104.91 73.77,104.91 73.76,104.91 68.25,104.91 63.7,109.46 62.95,109.46 55.93,116.48 55.93,117.27 54.97,118.23 v1(54.93,118.23)
  BOTTOM w0.13: v2(11.01,159.87) 11.49,160.35 v1(11.49,160.53)
RESETL42: length 178.6
  SIG4 w0.155: v1(27.62,144.6) 27.62,141.68 28.84,140.45 31.79,140.45 32.25,140.92 39.99,140.92 49.85,131.06 49.85,129.02 53.39,125.47 59.88,125.47 62.17,123.19 v1(62.17,122.04)
  SIG9 w0.155: v1(134.78,82.29) 134.88,82.19 136.64,82.19 137.35,81.48 137.35,80.01 137.6,79.75 137.6,75.69 138.11,75.18 138.11,72.39 137.6,71.88 137.6,66.74 136.92,66.05 136.92,65.61 137.26,65.27 137.26,64.95 136.92,64.61 136.92,61.61 137.26,61.27 137.26,60.95 136.88,60.57 136.88,57.65 136.9,57.62 136.91,57.62 137.26,57.27 137.26,56.95 136.92,56.61 136.92,53.61 137.5,53.03 YJ26.B9
  SIG10 w0.155: v1(134.78,82.29) 134.27,81.79 132.27,81.79 130.64,83.42 130.64,85.75 127.2,89.19 127.2,91.4 121.22,97.38 96.08,97.38 77.33,116.13 68.08,116.13 v1(62.17,122.04)
  BOTTOM w0.13: R3341.1 27.11,146.17 v2(26.86,145.92) 26.86,145.41 27.62,144.65 v1(27.62,144.6) ; R2692.1 134.56,82.52 v1(134.78,82.29)
RESETL43: length 172.5
  TOP w0.13: R3350.2 v1(23.69,146.56)
  SIG4 w0.155: v1(58.86,124.07) 52.99,124.07 48.57,128.49 48.57,130.54 39.74,139.37 32.87,139.37 32.64,139.14 27.59,139.14 26.14,140.59 24.45,140.59 23.69,141.35 23.69,143.25 22.8,144.14 22.8,145.67 v1(23.69,146.56)
  SIG8 w0.155: v1(135.57,76.32) 137.35,74.55 137.35,68.2 136.53,67.37 136.53,65.66 136.12,65.25 136.12,64.99 136.5,64.61 136.5,62.64 136.92,62.23 136.92,61.62 137.5,61.04 YJ26.A9
  SIG10 w0.155: v1(135.57,76.32) 135.11,76.78 135.11,77.8 134.81,78.1 134.05,78.1 129.09,83.06 129.09,83.31 128.84,83.56 128.09,83.56 126.82,84.84 126.82,87.77 125.93,88.66 125.93,90.87 120.7,96.09 95.56,96.09 77.69,113.96 68.23,113.96 61.56,120.62 61.07,120.62 59.88,121.81 59.88,123.44 59.25,124.07 v1(58.86,124.07)
  BOTTOM w0.13: v1(135.57,76.32) 136.08,76.83 136.08,77.72 135.93,77.87 R2691.2 ; v1(23.69,146.56) 23.94,146.56 v2(24.45,146.05)
