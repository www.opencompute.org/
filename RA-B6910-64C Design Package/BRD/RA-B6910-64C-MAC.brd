# Allegro board RA-B6910-64C-MAC.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP, BOTTOM: 67.37,78.48 67.25,78.36 63.56,78.36 63.44,78.48 63.44,80.39 63.69,80.64 67.12,80.64 67.37,80.39
GND on TOP, BOTTOM: 268.54,78.48 268.41,78.36 264.73,78.36 264.6,78.48 264.6,80.39 264.86,80.64 268.29,80.64 268.54,80.39
GND on TOP, BOTTOM: 187.77,84.33 187.64,84.2 183.96,84.2 183.83,84.33 183.83,86.23 184.09,86.48 187.52,86.48 187.77,86.23
GND on BOTTOM: 269.43,91.56 271.46,91.56 271.72,91.31 271.72,89.28 271.46,89.02 269.43,89.02 269.18,89.28 269.18,91.31
GND on BOTTOM: 31.18,205.61 35.88,205.61 36,205.48 36,203.58 35.62,203.2 31.43,203.2 30.92,203.71 30.92,205.36
GND on BOTTOM: 320.87,91.56 322.9,91.56 323.15,91.31 323.15,89.28 322.9,89.02 320.87,89.02 320.61,89.28 320.61,91.31
GND on BOTTOM: 334.07,93.47 337.88,93.47 338.14,93.22 338.14,91.31 338.01,91.18 334.07,91.18 333.82,91.44 333.82,93.22
GND on BOTTOM: 348.17,89.28 345.25,89.28 345.12,89.41 345.12,95.63 345.25,95.76 347.41,95.76 347.54,95.63 347.54,93.72 348.3,92.96 348.3,89.41
GND on BOTTOM: 70.55,89.28 70.29,89.02 68.26,89.02 68.01,89.28 68.01,93.34 68.14,93.47 70.29,93.47 70.55,93.22
GND on BOTTOM: 9.27,76.71 9.53,76.96 12.95,76.96 13.21,76.71 13.21,73.97 13.02,73.78 9.72,73.78 9.27,74.23
GND on BOTTOM: 142.48,213.53 145.62,213.53 146.76,214.67 150.52,214.67 150.79,214.41 150.79,212.53 150.33,212.07 147.37,212.07 146.99,211.69 145.95,211.69 145.75,211.49 145.75,210.2 145.47,209.92 142.67,209.92 142.31,210.28 142.31,213.35
GND on BOTTOM: 214.31,89.28 214.06,89.02 212.03,89.02 211.77,89.28 211.77,91.82 212.03,92.07 214.06,92.07 214.31,91.82
GND on BOTTOM: 92.52,78.36 89.98,78.36 89.85,78.48 89.85,80.9 89.98,81.02 92.65,81.02 92.77,80.9 92.77,78.61
GND on BOTTOM: outline of 102 points within 0,28.32 384.23,224.49 ; 4 cut-outs
GND on BOTTOM: 148.31,143.02 156.27,143.02 156.4,143.14 156.4,144.71 156.15,144.96 148.43,144.96 148.12,144.65 148.12,143.2
GND on BOTTOM: 93.79,84.33 93.66,84.2 89.98,84.2 89.85,84.33 89.85,86.48 89.98,86.61 93.54,86.61 93.79,86.36
GND on BOTTOM: 244.14,137.53 244.32,137.36 244.32,135.58 244.15,135.42 236.52,135.42 236.26,135.68 236.26,137.21 236.58,137.53
GND on BOTTOM: 304.74,78.99 304.1,78.36 302.32,78.36 302.07,78.61 302.07,80.39 302.32,80.64 304.48,80.64 304.74,80.39
GND on BOTTOM: 374.84,169.67 379.67,169.67 379.92,169.42 379.92,164.72 379.67,164.46 374.84,164.46 374.59,164.72 374.59,169.42
GND on BOTTOM: 286.83,86.48 288.61,86.48 288.86,86.23 288.86,84.58 288.73,84.45 286.83,84.45 286.7,84.58 286.7,86.36
GND on BOTTOM: 331.53,78.36 329.37,78.36 329.25,78.48 329.25,80.39 329.5,80.64 333.18,80.64 333.31,80.52 333.31,79.12 333.18,78.99 331.91,78.99 331.79,78.86 331.79,78.61
GND on BOTTOM: 13.14,81.15 13.02,81.02 9.33,81.02 9.21,81.15 9.21,83.06 9.46,83.31 12.89,83.31 13.14,83.06
GND on BOTTOM: 120.33,89.28 120.08,89.02 118.05,89.02 117.79,89.28 117.79,91.44 118.17,91.82 120.21,91.82 120.33,91.69
GND on BOTTOM: outline of 193 points within 249.48,37.11 430,224.49 ; 5 cut-outs
GND on BOTTOM: 164.63,91.99 163.26,91.99 156.7,98.55 155.32,98.55 148.94,104.92 122.42,104.92 107.94,119.41 64.66,119.41 59.05,125.01 56.93,125.01 55.49,123.57 55.49,121.45 60.92,116.01 60.92,105.39 64.83,101.48 71.46,101.48 77.83,95.11 118.09,95.11 119.79,93.41 123.35,93.41 130.83,100.89 140.38,100.89 141.34,99.93 142.23,99.93 144.86,97.3 144.86,87.36 146.73,85.49 155.25,85.49 156.95,83.8 160.75,83.8 160.79,83.84 161.03,83.84 164.74,87.55 164.74,89.49 165,89.74 165,91.63
GND on BOTTOM: 56.58,159.26 56.58,161.54 56.32,161.8 53.66,161.8 53.4,161.54 53.4,159.13 53.53,159 56.32,159
GND on BOTTOM: 230.7,93.09 231.97,93.09 232.35,92.71 232.35,90.29 232.09,90.04 231.2,90.04 230.44,90.8 230.44,92.83
GND on BOTTOM: 320.48,200.66 321.5,199.64 321.5,195.96 320.61,195.07 305.63,195.07 305.18,195.51 305.18,200.47 305.37,200.66
GND on BOTTOM: 53.53,89.41 52.64,88.52 52.01,88.52 51.63,88.9 50.61,88.9 50.48,89.02 50.48,90.29 50.1,90.68 50.1,92.58 50.36,92.83 52.77,92.83 53.53,92.07
GND on BOTTOM: 139.76,84.2 139.64,84.33 139.64,86.23 139.89,86.48 142.05,86.48 142.18,86.36 142.18,84.33 142.05,84.2
GND on BOTTOM: 60.77,90.93 62.93,90.93 63.06,90.8 63.06,89.15 62.93,89.02 61.02,89.02 60.64,89.41 60.64,90.8
GND on BOTTOM: 193.36,86.36 194.5,86.36 195.14,85.72 196.15,85.72 197.93,83.94 197.93,83.44 197.68,83.18 194.63,83.18 193.1,84.71 193.1,86.1
GND on BOTTOM: 174.56,84.33 174.43,84.2 173.8,84.2 173.42,83.82 171.77,83.82 171.39,84.2 170.75,84.2 170.62,84.33 170.62,85.98 170.75,86.1 174.43,86.1 174.56,85.98
GND on BOTTOM: 117.16,78.48 117.03,78.36 116.52,78.36 115.89,77.72 113.6,77.72 113.22,78.1 113.22,80.13 113.35,80.26 114.49,80.26 114.62,80.13 115.76,80.13 115.89,80.26 117.03,80.26 117.16,80.13
GND on BOTTOM: 255.33,87.25 253.3,87.25 252.29,86.23 252.29,83.69 252.54,83.44 254.19,83.44 254.44,83.69 254.44,84.2 255.59,85.34 255.59,86.99
GND on BOTTOM: 131.25,89.02 131,89.28 131,91.18 131.13,91.31 133.54,91.31 133.67,91.18 133.67,89.15 133.54,89.02
GND on BOTTOM: 211.14,78.48 211.01,78.36 210.38,78.36 210.25,78.23 208.72,78.23 208.6,78.36 208.6,80.39 208.85,80.64 210.88,80.64 211.14,80.39
GND on BOTTOM: 227.52,90.93 227.52,89.28 227.27,89.02 225.23,89.02 224.98,89.28 224.98,90.93 225.23,91.18 227.27,91.18
GND on BOTTOM: 234.23,110.18 235.95,110.18 236.26,109.88 236.26,107.44 236.28,107.41 236.28,106.3 236,106.02 234.12,106.02 233.52,106.63 233.52,109.47
GND on BOTTOM: 67.88,205.61 68.14,205.36 68.14,203.45 67.5,202.82 57.34,202.82 56.52,203.64 56.52,205.8 56.83,206.12 58.36,206.12 58.86,205.61
GND on BOTTOM: 138.24,98.55 140.14,98.55 140.27,98.68 140.27,99.82 139.64,100.45 138.24,100.45 138.11,100.33 138.11,98.68
GND on BOTTOM: 28.32,92.9 28.64,93.22 30.04,93.22 30.54,92.71 32.58,92.71 32.58,89.02 32.07,88.52 28.89,88.52 28.32,89.09
GND on BOTTOM: 99.25,84.71 103.44,84.71 103.57,84.83 103.57,86.99 103.44,87.12 101.54,87.12 101.03,86.61 99.38,86.61 99.12,86.36 99.12,84.83
GND on BOTTOM: 175.2,89.41 175.2,91.82 175.32,91.95 177.86,91.95 177.99,91.82 177.99,90.42 176.72,89.15 175.45,89.15
GND on BOTTOM: 257.75,90.68 256.1,90.68 255.84,90.42 255.84,88.14 255.97,88.01 257.62,88.01 257.87,88.26 257.87,90.55
GND on BOTTOM: 45.02,89.02 44.13,89.02 43.24,88.14 42.48,88.14 42.23,88.39 42.23,90.17 44.26,92.2 44.89,92.2 45.28,91.82 45.28,89.28
GND on BOTTOM: 351.47,130.17 353.5,130.17 353.76,130.43 353.76,187.96 353.38,188.34 351.6,188.34 351.35,188.08 351.35,130.3
GND on BOTTOM: 106.36,86.36 107.89,86.36 108.14,86.1 108.14,84.58 108.01,84.45 106.11,84.45 105.98,84.58 105.98,85.98
GND on BOTTOM: 378.9,129.66 378.78,129.79 378.78,133.98 379.03,134.24 380.87,134.24 381.31,133.79 382.57,133.79 382.97,134.19 382.97,152.65 386.14,155.83 395.92,155.83 396.3,155.45 396.3,153.03 396.24,152.97 396.24,150.56 395.92,150.24 395.92,147.57 395.67,147.32 387.79,147.32 387.03,146.56 387.03,131.82 387.67,131.19 397.7,131.19 397.83,131.32 397.83,132.46 398.59,133.22 404.56,133.22 405.57,132.2 405.57,126.87 405.32,126.62 404.43,126.62 404.05,127 404.05,129.16 403.54,129.66
GND on BOTTOM: 185.86,78.36 183.96,78.36 183.83,78.48 183.83,80.39 184.09,80.64 185.99,80.64 186.25,80.39 186.25,78.74
GND on BOTTOM: 27.11,104.9 24.96,104.9 24.7,104.65 24.7,100.84 24.83,100.71 25.84,100.71 27.24,102.11 27.24,104.77
GND on BOTTOM: 138.34,93.85 139.76,93.85 140.02,94.1 141.41,94.1 141.67,94.36 141.67,96.39 141.54,96.52 138.58,96.52 138.34,96.28
GND on BOTTOM: 218,92.33 216.85,92.33 216.6,92.07 216.6,89.79 216.85,89.53 218,89.53 218.25,89.79 218.25,92.07
GND on BOTTOM: 243.14,161.94 245.76,161.94 245.95,161.75 245.95,159.69 245.75,159.48 243.12,159.48 242.94,159.66 242.94,161.74
GND on BOTTOM: 368.24,82.67 372.68,82.67 373.44,83.44 373.44,86.1 373.19,86.36 368.36,86.36 367.98,85.98 367.98,82.93
GND on BOTTOM: 348.57,121.19 347.85,121.91 347.85,122.68 348.66,123.48 352.06,123.48 355.58,127.01 355.58,130.41 354.09,131.89 354.09,135.22 354.64,135.22 354.64,137.03 354.09,137.03 354.09,139.44 354.65,139.44 354.65,141.55 354.09,141.55 354.09,155.74 354.58,155.74 354.58,157.86 354.09,157.86 354.09,159.84 354.56,159.84 354.56,161.6 354.09,161.6 354.09,189.01 352.27,190.84 348.91,190.84 347.72,192.03 347.72,195.17 348.28,195.73 358.04,195.73 365.01,188.76 365.01,168.52 367.39,166.14 367.39,165.15 366.88,164.64 366.88,161.07 365.2,159.39 365.2,155.53 366.03,154.7 372.99,154.7 374.82,156.53 374.82,161.69 376.14,163 377.84,163 379.69,161.15 379.7,161.15 379.92,160.94 379.92,157.97 379.7,157.76 378.6,157.76 377.54,156.7 377.54,153.38 366.88,142.72 366.88,136.01 352.06,121.19 ; 1 cut-out
GND on BOTTOM: 312.36,213.87 322.01,213.87 322.77,213.1 322.77,204.47 322.39,204.09 313.75,204.09 311.72,206.12 311.72,213.23
GND on BOTTOM: 117.16,84.33 117.03,84.2 116.52,84.2 116.14,83.82 114.36,83.82 113.98,84.2 113.35,84.2 113.22,84.33 113.22,85.98 113.35,86.1 117.03,86.1 117.16,85.98
GND on BOTTOM: 49.59,84.33 49.47,84.2 49.09,84.2 48.96,84.07 48.96,83.56 48.83,83.44 47.18,83.44 47.05,83.56 47.05,83.94 46.8,84.2 45.78,84.2 45.66,84.33 45.66,86.48 45.78,86.61 49.47,86.61 49.59,86.48
GND on BOTTOM: 32.32,97.15 31.86,96.69 31.1,96.69 30.4,95.99 29.55,95.99 29.53,96.01 28.38,96.01 28.38,99.06 28.64,99.31 32.07,99.31 32.32,99.06
GND on BOTTOM: 355.92,89.28 355.66,89.02 353.63,89.02 353.38,89.28 353.38,93.34 353.5,93.47 355.79,93.47 355.92,93.34
GND on BOTTOM: 81.47,91.56 83.5,91.56 83.76,91.31 83.76,89.28 83.5,89.02 81.47,89.02 81.22,89.28 81.22,91.31
GND on BOTTOM: 378.52,105.79 378.52,109.98 378.78,110.23 382.46,110.23 382.71,110.49 382.71,128.65 382.97,128.9 395.54,128.9 395.67,128.78 395.67,116.2 395.29,115.82 386.91,115.82 386.78,115.69 386.78,107.95 387.79,106.93 397.32,106.93 397.57,107.19 397.57,108.84 398.08,109.34 400.11,109.34 400.49,108.96 400.49,105.28 399.61,104.39 379.92,104.39
GND on BOTTOM: 383.98,212.47 393.26,212.47 393.76,211.96 393.76,208.79 393.38,208.4 383.86,208.4 383.48,208.79 383.48,211.96
GND on GND1: 388,0.51 386.25,1.23 385.51,2.96 385.51,25.73 383.81,27.43 0.7,27.43 0.7,27.64 0.51,27.83 0.51,168.85 0.92,169.83 1.9,170.24 5.91,170.24 5.91,173.76 1.9,173.76 0.92,174.17 0.51,175.15 0.51,223 0.95,224.05 2,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.97 428.48,52.96 418.83,52.96 414,48.13 397.07,48.13 397.07,27.22 399.65,24.64 405.87,24.64 406.46,24.04 406.46,22.56 406.25,22.35 400.03,22.35 399.1,21.42 399.1,16.04 400.41,14.73 419.37,14.73 420.56,15.92 420.56,20.91 418.99,22.48 413.91,22.48 413.58,22.81 413.58,23.66 414.17,24.25 428.48,24.25 429.49,23.24 429.49,2 429.05,0.95 428,0.51
GND on POWER1: 201.76,180.97 208.41,180.97 208.75,180.63 208.75,179.4 208.42,179.07 201.36,179.07 201.1,178.81 201.1,178.56 200.98,178.43 200.6,178.43 200.47,178.56 200.47,178.81 200.22,179.07 186.58,179.07 186.37,179.28 186.37,180.64 186.71,180.97
GND on POWER1: 400.45,73.4 427.84,73.4 427.84,73.4 428,73.4 429.46,71.95 429.46,53.98 428.43,52.96 418.83,52.96 414,48.13 397.07,48.13 397.07,27.22 399.65,24.64 405.87,24.64 406.46,24.04 406.46,22.56 406.25,22.35 400.03,22.35 399.1,21.42 399.1,16.04 400.41,14.73 419.37,14.73 420.56,15.92 420.56,20.91 418.99,22.48 413.91,22.48 413.58,22.81 413.58,23.66 414.17,24.26 417.96,24.26 417.96,24.25 428.48,24.25 428.98,23.75 428.98,2 428.7,1.3 428,1.02 388,1.02 386.6,1.6 386.02,3 386.02,3.42 385.51,3.93 385.51,25.74 383.81,27.43 1.93,27.43 0.55,28.8 0.55,51.69 2.33,53.46 10.6,53.46 13.53,50.54 191.83,50.54 196.15,54.86 196.15,65.25 197.29,66.39 393.44,66.39 ; 1 cut-out
GND on POWER1: 331.74,110.74 331.03,111.46 331.03,211.58 331.98,212.53 331.98,215.71 331.03,216.67 331.03,224.01 331.44,224.42 359.04,224.42 359.48,223.98 368.88,223.98 369.36,224.47 417.38,224.47 417.87,223.98 427.31,223.98 427.71,224.38 428.2,224.38 429.47,223.1 429.47,208 428.98,207.51 428.98,206.98 428.57,206.74 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 428.57,203.26 428.98,203.02 428.98,202.8 429.36,202.43 429.36,201.79 429.48,201.67 429.48,155.35 428.82,154.68 388.98,154.68 345.04,110.74
GND on POWER1: 1.02,169.59 1.02,169.92 1.43,170.16 1.9,170.24 5.91,170.24 5.91,173.76 1.9,173.76 1.43,173.84 1.02,174.08 1.02,174.21 0.64,174.58 0.64,174.97 0.53,175.09 0.53,223.13 1.17,223.77 1.38,223.77 1.67,223.93 2,223.98 10.75,223.98 11.25,224.48 60.54,224.48 61.04,223.98 70.4,223.98 70.9,224.48 110.86,224.48 111.44,223.9 111.44,209.67 110.3,208.53 109.41,208.53 102.3,201.42 79.47,201.42 78.93,201.8 77.43,200.3 77.43,199.62 63.69,185.88 63.69,118.7 62.72,117.73 48.94,117.73 48.39,118.28 43.29,118.28 39.19,114.17 1.24,114.17 0.57,114.85 0.57,169.14
GND on SIG1: 5.51,170.22 5.56,170.27 5.56,173.73 5.5,173.78 2.09,173.78 2.01,173.86 1.49,173.86 0.69,174.66 0.69,175.64 0.54,175.79 0.54,223.2 1.68,224.34 38.63,224.34 38.8,224.17 38.8,205.43 34.29,200.92 34.29,183.62 32.39,181.72 32.39,174.88 31.69,174.18 31.69,165.09 31.29,164.69 31.29,154.23 32.16,153.36 34.86,153.36 36.66,151.56 38.33,151.56 38.39,151.63 41.48,151.63 43.4,149.7 43.4,145.66 43.06,145.33 43.06,138.25 48.62,132.69 48.62,128.71 53.08,124.25 61.2,124.25 67.2,118.25 67.2,110.37 65.97,109.14 58.3,109.14 54.71,105.55 47.93,105.55 45.02,108.46 25.97,108.46 19.24,101.72 15.05,101.72 15.07,101.7 6.86,101.7 6.2,101.05 6.2,96.9 5.8,96.51 2.44,96.51 1.61,95.67 0.67,95.67 0.53,95.81 0.53,168.86 0.59,168.92 0.59,169.17 1.64,170.22 1.66,170.22
GND on SIG1: 400.68,52.29 400.27,52.69 400.27,58.78 401.06,59.56 401.06,69.01 406.34,74.29 420.56,74.29 420.94,74.67 420.94,76.07 419.16,77.85 401.76,77.85 392.75,86.87 379.95,86.87 377.53,89.28 377.53,97.56 374.53,100.56 365.02,100.56 363.58,102 363.58,112.57 361.41,114.74 331.82,114.74 330.88,115.68 330.88,189.93 330.89,189.94 330.82,190.01 330.82,193.3 328.96,195.16 321.14,195.16 321.11,195.2 305.5,195.2 305.12,195.58 305.12,200.66 308.67,204.21 310.96,204.21 311.85,205.1 311.85,212.09 312.36,212.6 321.25,212.6 322.52,211.33 322.52,207.44 341.03,188.93 341.44,188.93 341.94,188.43 341.94,186.75 342.84,185.85 346.63,185.85 346.94,185.55 346.94,134.2 347.97,133.17 350.99,133.17 351.33,132.82 351.85,132.82 351.93,132.9 365.29,132.9 365.29,132.9 368.56,132.9 370.18,134.53 370.18,187.37 382.1,199.29 382.1,223.27 382.23,223.4 407.75,223.4 408.17,223.82 428.81,223.82 429.4,223.23 429.4,207.8 428.38,206.78 424.5,206.78 424.34,206.62 424.34,203.37 424.5,203.22 428.58,203.22 429.43,202.36 429.45,202.28 429.47,202.2 429.47,54.09 428.72,53.35 415.41,53.35 414.35,52.29
GND on SIG1: 71.75,192.8 86.39,192.8 86.96,192.23 86.96,128.54 86.08,127.67 71.8,127.67 70.88,128.59 70.88,191.92
GND on SIG1: 11.24,27.43 383.6,27.43 384.24,28.06 384.24,46.1 383.22,47.11 142.43,47.11 132.78,37.46 79.95,37.46 73.85,31.37 10.99,31.37 10.48,30.86 10.48,28.19
GND on GND2: 388,0.51 386.25,1.23 385.51,2.96 385.51,25.73 383.81,27.43 0.7,27.43 0.7,27.64 0.51,27.83 0.51,168.85 0.92,169.83 1.9,170.24 5.91,170.24 5.91,173.76 1.9,173.76 0.92,174.17 0.51,175.15 0.51,223 0.95,224.05 2,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.97 428.48,52.96 418.83,52.96 414,48.13 397.07,48.13 397.07,27.22 399.65,24.64 405.87,24.64 406.46,24.04 406.46,22.56 406.25,22.35 400.03,22.35 399.1,21.42 399.1,16.04 400.41,14.73 419.37,14.73 420.56,15.92 420.56,20.91 419.93,21.54 414.85,21.54 413.58,22.81 413.58,23.66 414.17,24.25 428.48,24.25 429.49,23.24 429.49,2 429.05,0.95 428,0.51
GND on SIG2: 118.68,224.41 119.7,223.39 119.7,219.2 109.28,208.79 85.28,208.79 84.65,209.42 84.65,223.77 85.28,224.41
GND on SIG2: 370.55,85.23 370.45,85.38 370.31,85.47 369.7,86.08 369.6,86.24 369.43,86.34 342.55,113.23 342.55,120.05 345.1,122.59 383.71,122.59 385.08,123.97 385.08,141.75 385.22,141.89 385.22,148.36 385.08,148.49 385.08,197.37 386.04,198.33 390.65,198.33 393.08,195.9 393.08,187.28 392.87,186.94 393.08,186.6 393.08,176.74 392.87,176.4 393.08,176.06 393.08,174.16 392.9,173.84 393.08,173.51 393.08,172.28 392.89,171.96 393.08,171.63 393.08,76.73 392.37,76.03 382.77,76.03 377.24,81.55 374.23,81.55
GND on SIG2: 5.51,170.24 5.51,173.76 1.9,173.76 0.92,174.17 0.51,175.15 0.51,223 0.94,224.05 2,224.49 42.17,224.49 42.41,224.25 42.41,204.02 41.98,203.59 41.98,186.28 42.41,185.85 42.41,109.58 38.59,105.77 34.35,105.77 33.06,107.06 26.99,107.06 18.86,98.93 16.7,98.93 15.81,98.04 15.81,97.79 13.91,95.88 13.91,92.58 10.1,88.77 10.1,83.69 10.48,83.69 10.6,83.82 11.49,83.82 12.07,83.24 12.07,48.01 12.96,47.11 301.31,47.11 305.12,43.3 383.35,43.3 384.24,42.42 384.24,28.06 383.6,27.43 1.51,27.43 0.51,28.43 0.51,168.85 0.92,169.83 1.9,170.24 ; 3 cut-outs
GND on SIG2: 405.86,50.12 403.86,52.13 403.86,53.44 412.17,61.75 412.17,194.71 412.23,194.92 412.17,195.13 412.17,214.59 408.91,217.85 399.58,217.85 397.31,220.12 397.31,224 397.8,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.97 428.48,52.96 418.83,52.96 415.99,50.12
GND on SIG2, SIG3, SIG4, SIG7: 312.36,212.6 321.25,212.6 322.52,211.33 322.52,196.47 321.25,195.2 305.5,195.2 305.12,195.58 305.12,200.66 308.67,204.21 310.96,204.21 311.85,205.1 311.85,212.09
GND on GND3: 388,0.51 386.25,1.23 385.51,2.96 385.51,25.73 383.81,27.43 0.7,27.43 0.7,27.64 0.51,27.83 0.51,168.85 0.92,169.83 1.9,170.24 5.91,170.24 5.91,173.76 1.9,173.76 0.92,174.17 0.51,175.15 0.51,223 0.95,224.05 2,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.97 428.48,52.96 418.83,52.96 414,48.13 397.07,48.13 397.07,27.22 399.65,24.64 405.87,24.64 406.46,24.04 406.46,22.56 406.25,22.35 400.03,22.35 399.1,21.42 399.1,16.04 400.41,14.73 419.37,14.73 420.56,15.92 420.56,20.91 419.83,21.64 414.75,21.64 413.58,22.81 413.58,23.66 414.17,24.25 428.48,24.25 429.49,23.24 429.49,2 429.05,0.95 428,0.51
GND on SIG3: 2.04,176.83 0.51,178.37 0.51,223 0.94,224.05 2,224.49 42.22,224.49 42.77,223.94 42.77,183.26 38.7,179.19 29.64,179.19 28.86,178.41 26.17,178.41 24.59,176.83 ; 1 cut-out
GND on SIG3: 118.68,224.41 119.7,223.39 119.7,219.2 109.28,208.79 85.03,208.79 84.52,209.29 84.52,223.77 85.15,224.41
GND on SIG3: 10.48,28.19 10.48,46.73 10.86,47.11 209.99,47.11 214.69,42.42 264.6,42.42 270.95,36.07 352.74,36.07 354.01,37.34 382.59,37.34 384.24,35.68 384.24,28.06 383.6,27.43 11.24,27.43 ; 11 cut-outs
GND on SIG3: 404.69,85.67 395.04,76.03 382.77,76.03 377.24,81.55 374.23,81.55 370.55,85.22 370.46,85.38 370.3,85.47 369.69,86.09 369.59,86.24 369.44,86.34 327.32,128.45 327.32,159.69 328.17,160.54 340.41,160.54 340.83,160.11 340.83,159.92 341.22,159.53 341.41,159.53 341.98,158.96 341.98,158.6 342.42,158.15 342.79,158.15 344.33,156.61 344.33,123.68 345.42,122.59 383.71,122.59 385.08,123.97 385.08,141.75 385.22,141.89 385.22,148.36 385.08,148.49 385.08,223.13 386.44,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,127.55 428.45,126.51 415.33,126.51 411.43,122.61 411.43,102.72 404.69,95.99
GND on GND4: 388,0.51 386.25,1.23 385.51,2.96 385.51,25.73 383.81,27.43 0.7,27.43 0.7,27.64 0.51,27.83 0.51,168.85 0.92,169.83 1.9,170.24 5.91,170.24 5.91,173.76 1.9,173.76 0.92,174.17 0.51,175.15 0.51,223 0.95,224.05 2,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.97 428.48,52.96 418.83,52.96 414,48.13 397.07,48.13 397.07,27.22 399.65,24.64 405.87,24.64 406.46,24.04 406.46,22.56 406.25,22.35 400.03,22.35 399.1,21.42 399.1,16.04 400.41,14.73 419.37,14.73 420.56,15.92 420.56,20.91 418.99,22.48 413.91,22.48 413.58,22.81 413.58,23.66 414.17,24.25 428.48,24.25 429.49,23.24 429.49,2 429.05,0.95 428,0.51 ; 1 cut-out
GND on SIG4: 115.13,187.99 115.13,163.04 116.58,161.6 129.19,161.6 144.93,177.34 144.93,185.12 143.1,186.95 131.75,186.95 127.05,191.65 118.79,191.65
GND on SIG4: 382.77,76.03 377.24,81.55 374.23,81.55 370.62,85.16 370.49,85.41 370.23,85.54 369.81,85.96 369.66,86.31 369.32,86.46 327.32,128.45 327.32,159.69 327.32,187.43 329.88,189.99 356.39,189.99 365.05,181.33 365.05,156.16 366.96,154.25 366.96,132.19 368.64,130.51 371.8,130.51 382.58,141.29 382.58,150.48 385.08,152.98 385.08,176.19 385.51,176.62 390,176.62 391.13,175.48 391.13,163.42 397.56,156.99 397.56,145.21 403.29,139.49 403.29,102.33 392.5,91.54 392.5,80.57 387.96,76.03 ; 1 cut-out
GND on SIG4: 419.13,127.93 411.61,135.45 411.61,166.09 411.97,166.46 411.97,182.5 410.65,183.81 391.98,183.81 391.09,184.7 391.09,202.78 385.08,208.79 385.08,223.13 386.44,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.97 428.48,52.96 418.83,52.96 414,48.13 403.91,48.13 400.15,51.89 400.15,64.12 403.37,67.34 403.37,72.88 401.36,74.89 401.36,79.99 426.5,105.13 426.5,126.99 425.57,127.93
GND on SIG4: 306.13,213.48 306.13,202.94 305.37,202.18 289.12,202.18 288.35,202.94 288.35,211.07 290.77,213.48
GND on SIG4: 64.35,125.35 62.26,127.45 62.26,135.11 59.5,137.87 59.5,139.42 51.84,147.08 51.84,163.24 53.57,164.97 55.34,164.97 55.46,165.1 55.46,165.65 54.36,166.75 54.36,178.52 54.07,178.81 54.07,181.37 54.52,181.82 58.48,181.82 60.32,183.66 64.74,183.66 65.42,182.98 65.42,132.16 66.8,130.77 68.31,130.77 68.87,131.34 68.87,183.58 70.39,185.09 70.39,188.07 75.62,193.3 85.21,193.3 86.23,192.28 86.23,128.92 84.7,127.39 73.86,127.39 71.82,125.35
GND on SIG4: 11.24,27.43 383.6,27.43 384.24,28.06 384.24,35.94 383.73,36.45 383.73,36.57 265.87,36.57 260.79,41.65 227.9,41.65 222.44,47.11 10.86,47.11 10.48,46.73 10.48,28.19
GND on SIG4: 0.51,191.08 0.51,223 0.94,224.05 2,224.49 61.15,224.49 61.15,217.04 58.71,214.6 30.96,214.6 29.13,212.78 29.13,205.71 26.78,203.36 19.14,203.36 9.57,193.79 9.57,192.18 7.93,190.55 1.04,190.55
GND on GND5: 388,0.51 386.25,1.23 385.51,2.96 385.51,25.73 383.81,27.43 0.7,27.43 0.7,27.64 0.51,27.83 0.51,168.85 0.92,169.83 1.9,170.24 5.91,170.24 5.91,173.76 1.9,173.76 0.92,174.17 0.51,175.15 0.51,223 0.95,224.05 2,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.97 428.48,52.96 418.83,52.96 414,48.13 397.07,48.13 397.07,27.22 399.65,24.64 405.87,24.64 406.46,24.04 406.46,22.56 406.25,22.35 400.03,22.35 399.1,21.42 399.1,16.04 400.41,14.73 419.37,14.73 420.56,15.92 420.56,20.91 418.99,22.48 413.91,22.48 413.58,22.81 413.58,23.66 414.17,24.25 428.48,24.25 429.49,23.24 429.49,2 429.05,0.95 428,0.51 ; 1 cut-out
GND on SIG5: 119.06,224.41 119.19,224.53 119.57,224.53 119.82,224.28 119.82,219.33 109.28,208.79 85.28,208.79 84.52,209.55 84.52,223.77 85.15,224.41
GND on SIG5: 321.25,212.6 322.52,211.33 322.52,196.47 321.25,195.2 305.5,195.2 305.44,195.26 295.53,195.26 292.29,198.5 292.29,213.1 293.05,213.87 301.69,213.87 302.96,212.6
GND on SIG5: 11.24,27.43 383.6,27.43 384.24,28.06 384.24,37.08 383.35,37.97 376.75,37.97 373.44,41.27 350.58,41.27 349.82,42.03 331.91,42.03 326.83,47.11 260.16,47.11 251.9,38.86 248.48,38.86 243.14,44.19 243.14,46.1 242.13,47.11 168.21,47.11 159.83,38.73 154.24,38.73 149.42,43.56 149.42,45.84 148.15,47.11 69.02,47.11 64.45,42.54 59.25,42.54 56.96,44.83 56.96,46.23 56.07,47.11 10.86,47.11 10.48,46.73 10.48,28.19
GND on SIG5: 115.13,187.99 115.13,163.04 116.58,161.6 128.15,161.6 144.93,178.38 144.93,187.77 139.15,193.55 120.69,193.55
GND on SIG5: 64.35,125.35 62.26,127.45 62.26,133.43 68.87,140.05 68.87,183.58 70.39,185.09 70.39,188.07 75.62,193.3 85.21,193.3 86.23,192.28 86.23,128.92 84.7,127.39 73.86,127.39 71.82,125.35
GND on SIG5: 370.56,85.22 370.46,85.38 370.3,85.48 369.68,86.1 369.59,86.24 369.45,86.33 327.32,128.45 327.32,146.07 330.41,149.16 351.51,149.16 354.7,145.98 354.7,109.44 357.12,107.02 387.57,107.02 391.49,110.95 391.49,195.02 399.36,202.89 399.36,223.85 400,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.97 428.48,52.96 418.83,52.96 414,48.13 403.91,48.13 399.15,52.89 399.15,64.33 398.62,64.86 398.62,81.28 406.2,88.86 409.32,88.86 425.14,104.69 426.25,104.69 427.42,105.85 427.42,115.83 424.53,118.71 408.19,118.71 403.29,113.81 403.29,102.33 391.75,90.79 391.75,79.82 387.96,76.03 382.77,76.03 377.24,81.55 374.23,81.55
GND on GND6, GND7, GND8, GND9, GND10: 1.93,27.43 0.84,28.52 0.75,28.65 0.7,28.66 0.66,28.7 0.51,28.7 0.51,168.85 0.92,169.83 1.9,170.24 5.91,170.24 5.91,173.76 1.9,173.76 0.92,174.17 0.51,175.15 0.51,223 0.95,224.05 2,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.71 428.73,52.96 418.83,52.96 414,48.13 397.07,48.13 397.07,32.72 396.47,32.13 387.2,32.13 386.27,31.2 386.27,27.89 385.81,27.43
GND on SIG6: 306.51,195.32 303.97,197.86 290.51,197.86 290,198.37 290,199.49 286.75,202.74 242.97,202.74 242.51,203.21 242.51,203.82 245.61,206.92 282.02,206.92 284.34,209.25 284.34,212.04 286.2,213.9 302.8,213.9 303.85,212.85 318.33,212.85 322.64,208.53 322.64,197.36 320.61,195.32
GND on SIG6: 101.66,224.41 114.87,224.41 115.89,223.39 115.89,217.29 113.92,215.33 113.92,212.15 110.55,208.79 100.39,208.79 99.76,209.42 99.76,222.5
GND on SIG6: 327.88,220.09 375.76,220.09 379.47,216.37 379.47,210.18 378.39,209.09 331.91,209.09 326.79,214.21 326.79,219.01
GND on SIG6: outline of 91 points within 0.51,27.43 384.24,224.49 ; 1 cut-out
GND on SIG6: 122.87,218.7 237.39,218.7 238.48,217.61 238.48,213.12 233.68,208.32 207.65,208.32 203.46,204.13 201.6,204.13 199.28,206.46 152.18,206.46 150.32,204.6 119.44,204.6 118.55,205.48 118.55,214.38
GND on SIG6: 362.43,207.85 369.25,207.85 371.88,205.22 381.8,205.22 384.74,202.28 384.74,199.8 380.4,195.46 371.57,195.46 362.12,204.91 362.12,207.54
GND on SIG7: 418.71,107.26 419.65,107.26 419.95,106.96 419.95,99.49 418.33,97.86 418.33,79.55 413.17,74.39 406.08,74.39 405.73,74.75 405.73,80.54 402.91,83.36 402.91,91.46
GND on SIG7: 401.16,48.99 400.47,49.68 400.47,57.91 401.08,58.52 410.76,58.52 411.85,59.61 411.85,61.47 413.78,63.4 413.78,72.06 416.03,74.31 419.28,74.31 422.44,77.47 422.44,96.31 424.04,97.91 424.04,129.33 428.31,133.6 428.31,146.43 422.77,151.97 422.77,208.4 411.34,219.83 397.65,219.83 396.79,220.7 382.84,220.7 382.61,220.47 382.61,218.59 384.87,216.33 407.68,216.33 419.19,204.82 419.19,186.76 418.63,186.2 414.87,186.2 414.49,186.59 414.49,200.58 409.66,205.41 391,205.41 379.82,216.58 350.59,216.58 337.71,203.71 331.41,203.71 321.75,213.36 312.1,213.36 310.96,212.21 310.96,205.61 310.32,204.98 308.55,204.98 307.28,203.71 304.86,203.71 303.62,202.46 210.27,202.46 206.39,206.35 193.15,206.35 190.94,204.14 164.6,204.14 162.32,206.42 134.68,206.42 133.46,207.64 118.68,207.64 117.16,209.17 117.16,219.54 122.11,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.82 419.19,53.82 414.36,48.99
GND on SIG7: 395.74,184.86 395.74,165.58 403.92,157.4 403.92,110.44 393.91,100.42 393.91,99.37 391.69,97.14 391.69,81.49 380.3,70.1 377.15,70.1 371.36,75.89 371.36,78.86 327.04,123.19 327.04,167.66 344.87,185.49 395.11,185.49
GND on SIG7: 0.51,27.43 0.51,168.85 0.92,169.83 1.9,170.24 5.51,170.24 5.51,173.76 1.9,173.76 0.92,174.17 0.51,175.15 0.51,223 0.94,224.05 2,224.49 82.77,224.49 83.81,223.46 83.81,213.48 82.61,212.29 82.61,205.61 88.84,199.39 105.47,199.39 112.48,192.38 153.3,192.38 155.43,190.25 155.43,183.05 153.48,181.1 138.01,181.1 134.8,177.89 134.8,177.41 92.06,134.67 92.06,128.98 85.79,122.7 61.25,122.7 61.15,122.6 60.85,122.48 60.72,122.17 49.31,110.77 35.55,110.77 33.01,113.31 33.01,135.94 27.27,141.68 27.27,152.6 25.72,154.15 25.72,157.63 22,161.35 21.88,161.67 21.54,161.73 14.68,161.73 11.95,159 11.95,146.76 18.76,139.95 18.76,132.92 25.03,126.64 25.03,111.45 24.17,110.59 16.07,110.59 14.59,109.12 14.59,99.64 10.3,95.35 10.3,92.81 9.86,92.36 7.26,92.36 0.98,86.08 0.98,47.65 2.86,45.77 6.62,45.77 7.28,45.11 7.28,39.27 7.68,38.86 10.35,38.86 12.26,36.95 87.82,36.95 97.98,47.11 213.55,47.11 224.6,36.07 383.86,36.07 384.24,35.68 384.24,28.06 383.6,27.43 ; 1 cut-out
GND on SIG8: outline of 104 points within 27.52,87.27 411.59,218.72 ; 2 cut-outs
GND on SIG8: outline of 109 points within 0.51,27.43 429.49,224.49
GND on SIG9: outline of 175 points within 0.51,27.43 429.49,224.49 ; 32 cut-outs
GND on SIG10: 330.77,193.16 346.27,193.16 347.15,192.28 347.15,130.68 341.69,125.22 330.26,125.22 328.1,127.38 328.1,190.5
GND on SIG10: 9.66,129.26 7.2,131.72 6.18,131.72 5.92,131.47 5.92,122.95 5.14,122.17 5.14,104.69 7.84,101.99 17.73,101.99 19.24,103.5 19.24,109.45 19.66,109.87 20.36,109.87 20.36,123.02 14.12,129.26
GND on SIG10: 35.91,135.63 35.27,135.63 34.85,135.21 34.85,115.58 34.12,114.86 34.12,114.56 34.51,114.18 34.51,111.93 36.84,109.6 43.68,109.6 44.83,110.74 49.58,110.74 50.18,111.34 50.18,121.32 35.91,135.59
GND on SIG10: 214.15,79.72 213.38,80.49 214.31,81.42 214.31,91.49 213.07,92.73 204.39,92.73 203.46,93.66 188.59,93.66 187.97,93.04 187.97,90.56 191.07,87.46 196.02,87.46 196.49,87 196.49,85.61 199.59,82.51 201.76,82.51 208.42,75.84 212.45,75.84 214.15,77.55
GND on SIG10: outline of 113 points within 0.51,27.97 429.49,224.49 ; 8 cut-outs
GND on SIG10: 397.97,176.27 397.5,176.74 397.5,184.22 395.76,185.96 395.76,188.93 389.34,195.34 383.44,195.34 383.1,195 377.58,195 377.11,195.47 370.23,195.47 362.55,203.16 362.55,204.01 363.14,204.6 374.69,204.6 374.69,204.6 386.94,204.6 394.76,196.79 394.76,193.07 398.18,189.65 398.18,186.68 398.62,186.24 399.11,186.24 399.34,186.01 399.34,184.86 399.68,184.52 400.62,184.52 401.02,184.12 401.02,184.09 401.06,184.09 401.08,184.07 401.3,184.07 401.82,183.55 401.82,183.04 402.57,182.28 407.25,182.28 408.54,183.58 408.54,186.4 409.03,186.89 415.8,186.89 417.42,185.28 417.42,178.8 417.03,178.42 415.19,178.42 415,178.61 414.07,178.61 413.64,178.18 411.33,178.18 411.32,178.19 409.52,178.19 408.41,177.08 406.71,177.08 405.91,176.27
GND on SIG10: outline of 102 points within 175.11,27.5 382.11,73.37 ; 3 cut-outs
GND on SIG10: 70.52,127.99 69.59,128.92 69.59,130.87 68.82,131.64 68.82,136.31 67.38,137.75 67.38,138.69 67.97,139.28 67.97,140.98 66.87,142.09 66.87,144.04 52.43,158.48 47.93,158.48 44.95,161.45 42.41,161.45 41.05,162.81 41.05,164.25 44.53,167.74 44.53,173.51 47.59,176.57 50.81,176.57 52.26,178.02 52.26,180.65 56.34,184.73 64.24,184.73 66.44,186.93 70.52,186.93 70.84,187.26 70.84,189.07 74.49,192.71 85.43,192.71 86.45,191.69 86.45,128.41 86.06,128.02 71.75,128.02 71.71,127.99
GND on SIG10: 322.52,208.4 322.52,196.47 321.25,195.2 305.5,195.2 305.12,195.58 305.12,200.66 308.67,204.21 310.96,204.21 311.85,205.1 311.85,211.33 312.36,211.83 319.09,211.83
GND on SIG10: 391.25,106.52 400.7,106.52 404.57,110.4 404.57,141.54 398.69,147.43 392.02,147.43 389.7,145.1 389.7,142.16 387.69,140.14 385.05,140.14 383.81,138.9 383.81,125.12 383.04,124.34 383.04,108.07 384.74,106.37 391.09,106.37
GND on GND11: 1.93,27.43 0.84,28.52 0.75,28.65 0.7,28.66 0.66,28.7 0.51,28.7 0.51,168.85 0.92,169.83 1.9,170.24 5.91,170.24 5.91,173.76 1.9,173.76 0.92,174.17 0.51,175.15 0.51,223 0.95,224.05 2,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.71 428.73,52.96 418.83,52.96 414,48.13 397.07,48.13 397.07,27.26 399.77,24.56 405.97,24.56 406.43,24.09 406.43,22.7 406.12,22.39 400.08,22.39 399.15,21.46 399.15,16.04 400.39,14.8 419.45,14.8 420.53,15.88 420.53,20.84 418.98,22.39 413.87,22.39 413.56,22.7 413.56,23.78 414.03,24.25 428.12,24.25 429.47,22.9 429.47,2.04 427.97,0.54 395.44,0.54 395.37,0.61 387.46,0.61 385.62,2.45 385.62,3.43 385.52,3.54 385.52,25.73 383.81,27.43 ; 1 cut-out
GND on POWER2: 66.1,224.41 110.93,224.41 111.44,223.9 111.44,209.8 108.27,206.63 66.74,206.63 64.96,208.4 64.96,223.26
GND on POWER2: 13.82,86.74 14.54,86.02 14.54,76.28 10.9,72.64 7.73,72.64 7.18,72.09 7.18,68.75 12.38,63.54 12.38,62.4 13.65,61.13 13.65,56.94 16.19,54.4 16.19,52.49 17,51.69 378.1,51.69 379.29,52.87 379.29,54.78 388.89,64.39 391.39,64.39 391.99,63.8 391.99,50.71 394.57,48.13 397.07,48.13 397.07,27.26 399.77,24.56 405.97,24.56 406.43,24.09 406.43,22.55 406.28,22.39 400.08,22.39 399.15,21.46 399.15,16.04 400.39,14.8 419.45,14.8 420.53,15.88 420.53,20.84 418.98,22.39 414.34,22.39 413.72,23.01 413.72,23.78 414.18,24.25 428.28,24.25 429.44,23.08 429.44,2.02 427.97,0.54 387.72,0.54 387.65,0.61 387.39,0.61 385.59,2.41 385.59,3.44 385.52,3.51 385.52,25.73 383.81,27.43 1.67,27.43 0.51,28.59 0.51,85.95 1.29,86.74 ; 1 cut-out
GND on POWER2: 198.27,175.64 200.34,175.64 200.47,175.77 200.47,176.02 200.72,176.27 201.53,176.27 203.9,173.9 203.9,172.29 203.43,171.83 197.89,171.83 197.29,172.42 197.29,174.67
GND on GND12: 388,0.51 386.25,1.23 385.51,2.96 385.51,25.73 383.81,27.43 0.7,27.43 0.7,27.64 0.51,27.83 0.51,168.85 0.92,169.83 1.9,170.24 5.91,170.24 5.91,173.76 1.9,173.76 0.92,174.17 0.51,175.15 0.51,223 0.95,224.05 2,224.49 428,224.49 429.05,224.05 429.49,223 429.49,208.05 429.08,207.07 428.1,206.66 424.49,206.66 424.49,203.34 428.1,203.34 429.08,202.93 429.49,201.95 429.49,53.97 428.48,52.96 418.83,52.96 414,48.13 397.07,48.13 397.07,27.22 399.65,24.64 405.87,24.64 406.46,24.04 406.46,22.56 406.25,22.35 400.03,22.35 399.1,21.42 399.1,16.04 400.41,14.73 419.37,14.73 420.56,15.92 420.56,20.91 418.99,22.48 413.91,22.48 413.58,22.81 413.58,23.66 414.17,24.25 428.48,24.25 429.49,23.24 429.49,2 429.05,0.95 428,0.51 ; 1 cut-out
GND_EARTH on TOP: 2,4.02 1.77,4.04 1.55,4.12 1.15,4.12 0.57,4.7 0.57,26.16 0.83,26.41 12.81,26.41 14,24.14 15.19,26.41 59.81,26.41 61,24.14 62.19,26.41 106.81,26.41 108,24.14 109.19,26.41 153.81,26.41 155,24.14 156.19,26.41 200.81,26.41 202,24.14 203.19,26.41 247.81,26.41 249,24.14 250.19,26.41 294.81,26.41 296,24.14 297.19,26.41 341.81,26.41 343,24.14 344.19,26.41 383.39,26.41 384.49,25.32 384.49,4.02 ; 40 cut-outs
GND_EARTH on TOP: 419.67,55.12 424.88,55.12 429.45,50.54 429.45,42.54 422.21,42.54 419.04,45.72 419.04,54.48
GND_EARTH on BOTTOM: 428.56,33.91 416.62,33.91 416.37,34.16 416.37,36.5 417.77,37.9 417.77,50.8 418.78,51.81 428.31,51.81 429.45,50.67 429.45,33.78 429.32,33.65 428.82,33.65
GND_EARTH on BOTTOM: 2,4.02 1.77,4.04 1.55,4.12 1.15,4.12 0.57,4.7 0.57,26.16 0.83,26.41 51.21,26.41 52.4,24.14 53.59,26.41 98.21,26.41 99.4,24.14 100.59,26.41 145.21,26.41 146.4,24.14 147.59,26.41 192.21,26.41 193.4,24.14 194.59,26.41 239.21,26.41 240.4,24.14 241.59,26.41 286.21,26.41 287.4,24.14 288.59,26.41 333.21,26.41 334.4,24.14 335.59,26.41 380.21,26.41 381.4,24.14 382.59,26.41 383.39,26.41 384.49,25.32 384.49,6.63 383.98,6.12 14.39,6.12 12.28,4.02 ; 40 cut-outs
GND_EARTH on GND1: 400.83,15.75 400.11,16.46 400.11,21 400.45,21.33 406.67,21.33 407.48,22.14 407.48,24.46 406.29,25.65 400.07,25.65 398.08,27.64 398.08,31.87 414.21,31.87 417.77,35.43 417.77,50.29 417.68,50.37 419.25,51.94 428.48,51.94 429.49,50.93 429.49,26.28 428.48,25.27 413.75,25.27 412.56,24.08 412.56,22.39 413.49,21.46 418.57,21.46 419.54,20.49 419.54,16.34 418.95,15.75
GND_EARTH on GND1, GND2, GND3, GND4, GND5: 2,3.51 0.95,3.95 0.51,5 0.51,25.02 0.53,25.02 1.93,26.41 383.39,26.41 384.49,25.31 384.49,3.51
GND_EARTH on POWER1: 400.83,15.75 400.11,16.46 400.11,21 400.45,21.33 406.67,21.33 407.48,22.14 407.48,24.46 406.29,25.65 400.07,25.65 398.08,27.64 398.08,31.87 414.21,31.87 417.77,35.43 417.77,50.46 419.25,51.94 428.22,51.94 429.46,50.7 429.46,26.17 428.56,25.27 413.75,25.27 412.56,24.08 412.56,22.39 413.49,21.46 418.57,21.46 419.54,20.49 419.54,16.34 418.95,15.75
GND_EARTH on POWER1: 2,4.02 1.71,4.06 1.44,4.19 0.85,4.19 0.66,4.37 0.66,4.56 0.58,4.64 0.58,25.07 1.93,26.41 383.39,26.41 384.49,25.32 384.49,4.02
GND_EARTH on SIG1: 2,4.02 1.77,4.04 1.55,4.12 1.15,4.12 0.57,4.7 0.57,26.16 0.83,26.41 383.39,26.41 384.49,25.32 384.49,4.02
GND_EARTH on SIG1: 400.07,25.65 398.08,27.64 398.08,34.54 399.48,35.94 417,35.94 417.77,36.7 417.77,50.8 418.78,51.81 429.32,51.81 429.45,51.69 429.45,25.91 429.2,25.65
GND_EARTH on GND2, GND3, GND4, GND5, SIG5, SIG10, GND11, POWER2, GND12: 417.77,50.46 419.25,51.94 428.48,51.94 429.49,50.93 429.49,26.28 428.48,25.27 418.4,25.27 417.77,25.91
GND_EARTH on SIG2: 2,4.02 1.71,4.06 1.44,4.19 1.08,4.19 0.57,4.7 0.57,25.06 1.93,26.41 383.39,26.41 384.49,25.32 384.49,4.02
GND_EARTH on SIG3: 400.07,25.65 398.08,27.64 398.08,34.54 399.48,35.94 417,35.94 417.77,36.7 417.77,50.8 418.78,51.81 428.31,51.81 428.48,51.65 428.48,26.29 427.84,25.65
GND_EARTH on SIG3: 2,4.02 1.77,4.04 1.55,4.12 1.15,4.12 0.57,4.7 0.57,25.78 1.21,26.41 383.39,26.41 384.49,25.32 384.49,4.02
GND_EARTH on SIG4: 2,4.02 1.85,4.03 1.7,4.06 1.08,4.06 0.57,4.57 0.57,26.03 0.95,26.41 383.39,26.41 384.49,25.32 384.49,4.02
GND_EARTH on SIG5, SIG10, GND11, POWER2, GND12: 2,4.02 1.77,4.04 1.55,4.12 1.15,4.12 0.57,4.7 0.57,26.16 0.83,26.41 51.21,26.41 52.4,24.14 53.59,26.41 98.21,26.41 99.4,24.14 100.59,26.41 145.21,26.41 146.4,24.14 147.59,26.41 192.21,26.41 193.4,24.14 194.59,26.41 239.21,26.41 240.4,24.14 241.59,26.41 286.21,26.41 287.4,24.14 288.59,26.41 333.21,26.41 334.4,24.14 335.59,26.41 380.21,26.41 381.4,24.14 382.59,26.41 383.39,26.41 384.49,25.32 384.49,4.02 ; 40 cut-outs
GND_EARTH on GND6, SIG6, GND7, SIG7, GND8, SIG8, GND9, SIG9, GND10: 388,0.51 386.24,1.24 385.51,3 385.51,3.51 2,3.51 0.95,3.95 0.51,5 0.51,25.02 0.53,25.02 1.93,26.41 386.23,26.41 387.29,27.47 387.29,30.78 387.62,31.11 396.9,31.11 398.08,32.3 398.08,35.3 398.72,35.94 415.73,35.94 417.77,37.97 417.77,50.46 419.25,51.94 428.48,51.94 429.49,50.93 429.49,2 429.05,0.95 428,0.51
VDD1.2V on TOP: 232.39,112.72 231.78,113.33 231.78,178.49 231.58,178.69 228.79,178.69 228.54,178.94 228.54,180.46 228.79,180.72 231.97,180.72 232.35,181.1 232.35,219.2 233.62,220.47 248.6,220.47 248.98,220.09 248.98,208.28 248.73,208.02 244.54,208.02 243.78,208.79 238.82,208.79 238.19,208.15 238.19,186.81 237.34,185.97 237.34,176.36 234.59,173.61 234.59,121.71 238,118.3 238,116.58 238.51,116.08 240.22,116.08 240.42,115.87 240.42,112.82 240.32,112.72
VDD1.2V on TOP: 165.54,179.58 165.42,179.45 161.99,179.45 161.61,179.07 161.61,178.81 161.48,178.69 160.34,178.69 160.21,178.81 160.21,181.86 160.34,181.99 165.42,181.99 165.54,181.86
VDD1.2V on BOTTOM: 235.78,177.92 235.9,178.05 235.9,181.73 234.76,182.88 211.14,182.88 210.12,183.89 198.82,183.89 197.55,182.62 161.35,182.62 157.04,178.31 157.04,163.83 156.65,163.45 156.65,143.51 157.67,142.49 157.67,137.28 158.18,136.78 163.39,136.78 164.27,137.67 164.27,142.87 161.86,145.29 161.86,175.38 164.4,177.92 171.77,177.92 172.91,176.78 196.76,176.78 199.43,179.45 206.31,179.45 207.84,177.92
VDD1.8V on TOP: 185.64,195.73 185.58,195.66 183.95,195.66 183.59,195.31 183.59,191.3 183.25,190.97 182.49,190.97 182.28,191.17 182.28,193.13 181.78,193.64 181.78,197.89 181.93,198.05 185.64,198.05
VDD1.8V on TOP: 223.2,199.13 225.11,199.13 225.23,199.01 225.23,197.74 225.11,197.61 223.2,197.61 223.08,197.74 223.08,199.01
VDD1.8V on TOP: 234.76,155.95 234.76,156.72 234.89,156.84 236.16,156.84 236.28,156.72 236.28,155.95 236.16,155.83 234.89,155.83
VDD1.8V on TOP: 235.78,144.52 235.9,144.4 235.9,143.63 235.78,143.51 234.51,143.51 234.38,143.63 234.38,144.4 234.51,144.52
VDD1.8V on TOP: 172.53,191.89 172.4,192.02 172.4,193.91 171.95,194.35 166.15,194.35 166.07,194.43 164.47,194.43 164.02,193.98 164.02,193.16 163.89,193.04 161.48,193.04 161.23,192.78 158.81,192.78 158.69,192.91 158.69,193.99 158.68,194 158.68,195.57 158.94,195.83 173.75,195.83 174.05,195.53 174.05,192.02 173.93,191.89
VDD1.8V on TOP: 159.08,137.65 159.08,137.66 158.75,137.66 158.6,137.81 158.6,139.79 158.76,139.95 160.59,139.95 160.78,140.14 160.78,174.3 161.86,175.38 165.42,175.38 165.67,175.13 165.67,173.86 163,171.19 163,137.95 162.71,137.65
VDD1.8V on TOP: 180.66,181.48 183.83,181.48 183.96,181.35 183.96,180.72 184.21,180.46 184.21,179.58 184.09,179.45 180.78,179.45 180.66,179.58 180.66,180.97 180.53,181.1 180.53,181.35
VDD1.8V on TOP: 220.28,199.13 218.5,199.13 218.38,199.01 218.38,197.36 218.5,197.23 220.28,197.23 220.41,197.36 220.41,199.01
VDD1.8V on TOP: 204.59,97.53 204.83,97.29 204.83,95.87 204.83,95.87 204.83,95.44 205.02,95.25 225.49,95.25 226.5,96.26 232.35,96.26 238.95,102.87 246.19,102.87 247.71,104.39 247.71,111.25 248.35,111.88 252.54,111.88 253.17,111.25 253.17,100.2 252.03,99.06 240.73,99.06 235.84,94.17 234.44,94.17 233.11,92.83 202.62,92.83 201.92,93.53 201.92,97.35 202.11,97.53
VDD1.8V on TOP, BOTTOM: 134.62,218.5 144.99,218.5 145.27,218.22 145.27,213.79 142.27,213.79 141.55,213.07 134.78,213.07 134.29,213.56 134.29,218.16
VDD1.8V on SIG9: 218.1,199.55 226.04,199.55 228.03,197.57 228.36,197.57 230.27,199.47 235.28,199.47 235.58,199.17 235.58,195.45 234.85,194.72 218.41,194.72 217.76,195.38 217.76,199.21
VDD1.8V on SIG10: 249.36,113.66 250,114.3 250,129.16 248.35,130.81 248.35,140.84 246.44,142.75 234.76,142.75 234.51,143 234.51,144.14 234.76,144.4 235.9,144.4 236.03,144.27 236.03,143.63 236.16,143.51 242.72,143.51 243.59,144.38 243.59,155.2 243.21,155.57 235.01,155.57 234.51,156.08 234.51,159.64 234.63,159.76 244.16,159.76 244.54,160.14 244.54,170.69 237.3,177.92 209.74,177.92 209.36,178.31 205.68,178.31 200.22,172.84 200.22,153.16 200.09,153.03 197.8,153.03 197.55,153.29 197.55,174.15 195.54,176.16 185.67,176.16 184.54,175.02 166.45,175.02 164.02,172.59 162.67,172.59 161.89,173.36 161.89,177.06 165.33,180.49 179.76,180.49 180.75,181.48 228.57,181.48 229.29,182.2 229.29,201.96 228.65,202.6 139.6,202.6 131.95,210.25 131.95,214.69 134.05,216.79 199.05,216.79 205,222.74 235.7,222.74 238.51,219.92 238.51,184.59 241.74,181.35 243.15,181.35 253.81,170.69 253.81,110.49 252.08,108.76 249.97,108.76 249.36,109.37
VDD3.3_CLK_MCU on TOP (solid shape): outline of 543 points within 272.86,195.04 301.82,211.55
VDD3.3_CLK_MCU on TOP: 316.55,204.34 316.67,204.21 316.67,202.94 316.29,202.56 316.29,201.55 316.17,201.42 314.77,201.42 314.26,201.93 314.26,203.96 314.64,204.34
VDD3.3V on TOP (solid shape): 362.06,113.66 362.1,113.65 362.11,113.61 362.11,112.85 362.72,112.85 362.76,112.83 362.78,112.8 362.78,112.24 362.76,112.2 362.72,112.19 362.11,112.19 362.11,111.33 362.72,111.33 362.76,111.31 362.78,111.27 362.78,110.87 364.81,108.84 364.81,100.07 364.55,99.82 359.85,99.82 359.6,100.07 359.6,113.54 359.73,113.66
VDD3.3V on BOTTOM (solid shape): 361.28,113.66 361.31,113.65 361.33,113.61 361.33,112.61 362.34,112.61 362.38,112.59 362.39,112.56 362.39,111.21 362.38,111.18 362.34,111.16 361.33,111.16 361.33,110.07 362.34,110.07 362.38,110.05 362.39,110.02 362.39,109.73 362.27,109.6 359.85,109.6 359.73,109.73 359.73,113.54 359.85,113.66
VDD3.3V on SIG1: 361.71,106.99 361.71,113.32 361,114.03 345.49,114.03 330.52,99.06 291.27,99.06 290.39,98.17 269.68,98.17 260.29,88.77 238.32,88.77 235.52,91.56 203.26,91.56 200.47,88.77 197.04,88.77 192.47,93.34 177.48,93.34 174.82,96.01 165.54,96.01 164.15,94.61 164.15,89.24 165.69,87.7 172.26,87.7 174.31,85.64 174.31,84.1 175.61,82.8 206.69,82.8 208.72,84.83 231.71,84.83 233.36,83.18 267.4,83.18 270.19,85.98 340.69,85.98
VDD3.3V on SIG6: 179.15,159.77 189.71,159.77 189.87,159.61 189.87,155.48 189.54,155.14 178.89,155.14 178.7,155.33 178.7,159.32
VDD3.3V on SIG6: 195.39,120.65 185.23,120.65 184.21,121.66 181.29,121.66 180.78,121.16 180.28,121.16 179.77,121.66 179.39,121.66 179.13,121.41 179.13,118.36 179.9,117.6 179.9,112.14 179.77,112.01 179.39,112.01 179.01,111.63 177.48,111.63 177.36,111.5 177.36,106.3 179.26,104.39 179.26,98.68 180.78,97.15 180.78,96.26 180.53,96.01 177.1,96.01 174.82,93.72 174.18,93.72 173.42,94.49 173.42,104.14 171.89,105.66 171.89,127.76 172.15,128.01 203.01,128.01 203.26,127.76 203.26,123.44 202.88,123.06 199.96,123.06 199.33,123.7 198.44,123.7
VDD3.3V on SIG7: 206.18,159.89 215.58,159.89 215.84,159.64 215.84,155.06 215.46,154.68 204.03,154.68 203.9,154.81 203.9,157.6
VDD3.3V on SIG9: 214.57,127.89 221.04,127.89 221.3,127.63 221.3,112.52 223.84,109.98 231.71,109.98 232.73,108.96 232.73,103.12 239.71,96.14 239.71,93.09 241.36,91.44 244.41,91.44 248.35,87.5 248.35,83.31 247.97,82.93 234.38,82.93 227.01,90.29 227.01,95.37 223.84,98.55 223.84,100.33 217.49,106.68 216.22,106.68 215.84,107.06 215.84,114.55 214.69,115.69 189.04,115.69 188.79,115.95 188.79,127.25 182.82,133.22 182.82,148.97 178.88,152.91 178.88,155.83 179.13,156.08 182.69,156.08 182.82,156.21 182.82,159.76 183.2,160.14 189.67,160.14 190.18,159.64 190.18,157.48 189.8,157.1 185.86,157.1 185.36,156.59 185.36,156.08 186.12,155.32 186.12,153.67 187.77,152.02 208.6,152.02 208.85,152.27 208.85,155.95 208.34,156.46 208.34,159.89 208.47,160.02 215.96,160.02 216.22,159.76 216.22,146.94 214.31,145.03 214.31,128.14
VDD3.3V on SIG9: 261.68,184.15 276.29,169.54 307.02,169.54 364.93,111.63 364.93,101.47 364.81,101.34 349.69,101.34 306.26,144.78 291.78,144.78 254.95,181.61 247.08,181.61 246.82,181.86 246.82,183.89 247.08,184.15
VDD5.0V on TOP (solid shape): 70.12,131.04 70.12,128.85 69.91,128.65 68.77,128.65 68.76,128.66 67.5,128.66 67.25,128.92 67.25,130.53 67.5,130.78 68.72,130.78 69.1,131.16 69.99,131.16
VDD5.0V on TOP (solid shape): 350.55,137.83 350.55,135.38 350.3,135.13 347.45,135.13 346.99,134.67 346.1,134.67 345.98,134.79 345.98,136.34 346.05,136.42 347.81,136.42 349.31,137.92 350.46,137.92
VDD5.0V on TOP (solid shape): 350.55,187.88 350.55,186.05 350.42,185.93 347.45,185.93 346.99,185.47 346.1,185.47 345.98,185.59 345.98,187.76 345.98,187.78 345.99,187.79 346.15,187.95 350.48,187.95
VDD5.0V on TOP (solid shape): 70.12,171.68 70.12,170 70.04,169.92 68.14,169.92 67.93,169.72 67.63,169.72 67.25,169.34 65.6,169.34 65.54,169.39 65.54,171.42 65.58,171.46 66.51,171.46 66.6,171.55 66.81,171.55 66.94,171.42 68.72,171.42 69.1,171.8 69.99,171.8
VDD5.0V on TOP (solid shape): 70.12,161.52 70.12,159.97 70.04,159.89 68.49,159.89 66.81,158.21 65.44,158.21 65.32,158.34 65.32,159.76 65.54,159.99 65.54,161.26 65.63,161.35 66.44,161.35 66.47,161.39 66.81,161.39 66.94,161.26 68.72,161.26 69.1,161.64 69.99,161.64
VDD5.0V on TOP (solid shape): 70.12,151.36 70.12,150.34 69.86,150.09 67.7,150.09 67.32,149.71 67.32,149.2 67.07,148.94 65.67,148.94 65.54,149.07 65.54,151.1 65.66,151.22 66.21,151.22 66.22,151.23 66.81,151.23 66.94,151.1 68.64,151.1 69.02,151.48 69.99,151.48
VDD5.0V on TOP (solid shape): 350.55,167.56 350.55,165.53 350.44,165.41 349.63,165.41 349.62,165.4 349.28,165.4 349.15,165.53 347.45,165.53 347.07,165.15 346.1,165.15 345.98,165.27 345.98,166.29 346.23,166.54 348.39,166.54 348.77,166.92 348.77,167.43 349.03,167.69 350.42,167.69
VDD5.0V on TOP (solid shape): 350.78,158.29 350.78,156.87 350.55,156.64 350.55,155.37 350.49,155.31 349.31,155.31 349.3,155.3 349.26,155.28 349.22,155.3 349.15,155.37 347.37,155.37 346.99,154.99 346.1,154.99 345.98,155.11 345.98,156.66 346.05,156.74 347.6,156.74 349.28,158.42 350.65,158.42
VDD5.0V on TOP (solid shape): 350.55,147.24 350.55,145.21 350.51,145.17 349.84,145.17 349.75,145.08 349.28,145.08 349.15,145.21 347.37,145.21 346.99,144.83 346.1,144.83 345.98,144.95 345.98,146.63 346.05,146.71 347.96,146.71 348.03,146.78 348.39,146.78 348.9,147.29 348.92,147.3 349.01,147.32 349.09,147.37 350.42,147.37
VDD5.0V on TOP (solid shape): 70.12,181.84 70.12,180.29 70.04,180.21 68.49,180.21 68.16,179.88 68.14,179.88 67.65,179.39 67.64,179.39 67.43,179.18 67.46,178.89 67.47,178.87 67.47,178.84 67.16,178.53 65.44,178.53 65.11,178.87 65.11,181.06 65.63,181.58 68.72,181.58 69.1,181.96 69.99,181.96
VDD5.0V on TOP (solid shape): 350.55,178.47 350.55,176.15 350.09,175.69 347.37,175.69 346.99,175.31 346.1,175.31 345.98,175.43 345.98,176.98 346.05,177.06 347.6,177.06 347.68,177.14 347.88,177.14 348.52,177.77 348.64,178.15 348.39,178.47 348.38,178.47 348.37,178.5 348.37,178.61 348.49,178.74 350.28,178.74
VDD5.0V on TOP (solid shape): 70.12,141.2 70.12,139.65 70.04,139.57 68.49,139.57 68.42,139.49 68.36,139.49 68.36,139.44 68.29,139.37 68.26,139.37 67.78,138.88 67.77,138.88 67.54,138.59 67.7,138.26 67.72,138.24 67.73,138.22 67.73,138.02 67.6,137.89 66.1,137.89 65.85,138.15 65.85,140.46 66.33,140.94 68.62,140.94 69,141.32 69.99,141.32
VDD5.0V on TOP (solid shape): 381.44,205.86 381.44,202.41 380.83,201.8 380.78,201.8 380.75,201.82 380.73,201.85 380.73,202.72 379.87,202.72 379.87,201.85 379.85,201.82 379.82,201.8 379.26,201.8 379.22,201.82 379.21,201.85 379.21,202.72 378.35,202.72 378.35,201.85 378.33,201.82 378.29,201.8 377.91,201.8 377.63,201.52 377.63,200.02 376.62,199.01 367.86,199.01 367.6,199.26 367.6,205.48 368.11,205.99 376.11,205.99 376.87,206.75 380.56,206.75
VDD5.0V on BOTTOM (solid shape): 350.5,178.33 350.5,175.54 350.37,175.41 348.98,175.41 348.21,176.18 348.21,177.32 349.35,178.46 350.37,178.46
VDD5.0V on BOTTOM (solid shape): 350.63,167.41 350.63,165.38 350.5,165.25 349.26,165.25 348.72,165.79 348.72,167.28 348.97,167.53 350.5,167.53
VDD5.0V on BOTTOM (solid shape): 380.81,206.12 380.81,203.2 380.68,203.07 376.87,203.07 376.75,203.2 376.75,206.12 377,206.37 380.56,206.37
VDD5.0V on BOTTOM (solid shape): 66.87,161.67 66.87,161.66 66.87,158.62 66.61,158.37 65.85,158.37 65.47,158.75 65.47,161.67 65.6,161.8 66.74,161.8
VDD5.0V on BOTTOM (solid shape): 350.63,146.96 350.63,144.93 350.5,144.8 348.84,144.8 348.82,144.83 348.81,144.85 348.75,145.01 348.62,145.13 348.6,145.15 348.59,145.17 348.59,147.09 348.72,147.21 350.37,147.21
VDD5.0V on BOTTOM (solid shape): 67.4,130.93 67.67,130.82 67.94,130.93 68.9,130.93 69.41,130.43 69.41,128.65 69.28,128.52 65.72,128.52 65.47,128.78 65.47,130.81 65.6,130.93
VDD5.0V on BOTTOM (solid shape): 66.73,151.38 66.76,151.37 66.77,151.35 66.97,151.16 67.24,151.15 67.33,151.14 67.37,151.06 67.37,149.35 67.12,149.1 65.6,149.1 65.47,149.22 65.47,151.25 65.6,151.38
