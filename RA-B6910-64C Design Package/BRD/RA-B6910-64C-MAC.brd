# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPLD_RESERVE3: length 416.4
  TOP w0.13: R3606.2 v1(37.15,153.03) ; U124.B7 400.42,186.45 400.42,187.4 399.61,188.21 v1(399.61,188.59)
  SIG6 w0.155: v1(399.61,188.59) 397.95,190.24 393.51,190.24 393.26,189.99 393.26,188.85 392.75,188.34 391.86,188.34 391.73,188.21 391.73,187.88 387.38,183.53 365.99,183.53 361.97,187.56 361.97,189.41 359.8,191.57 353.19,191.57 347.99,196.77 329.5,196.77 321.84,189.11 290.27,189.11 288.24,191.13 281.75,191.13 278.83,194.05 250.76,194.05 248.34,196.47 207.07,196.47 206.02,197.52 188.21,197.52 187.67,196.98 139.13,196.98 138.49,196.34 73.78,196.34 73.27,195.83 66.36,195.83 65.21,194.69 64.15,194.69 51.58,182.12 51.58,168.53 50.77,167.72 50.77,158.27 50.35,157.86 49.08,157.86 44.38,153.16 37.27,153.16 v1(37.15,153.03)
  BOTTOM w0.13: v1(37.15,153.03) v2(36.39,153.03)
CPLD_RESERVE4: length 426.4
  TOP w0.13: U124.E6 v1(399.62,184.05)
  SIG6 w0.102: v1(399.62,184.05) 399.22,184.45 399.22,186.94
  SIG6 w0.155: v1(29.27,145.46) 30.62,146.81 35.24,146.81 36.77,148.33 42.48,148.33 48.96,154.81 50.23,154.81 51.62,156.2 51.62,166.79 52.4,167.57 52.4,173.61 53.02,174.24 53.02,175.44 52.35,176.11 52.35,181.8 64.33,193.78 68.24,193.78 69.41,194.94 73.47,194.94 73.98,195.45 139.76,195.45 140.53,196.21 187.99,196.21 188.49,196.72 204.92,196.72 205.93,195.7 246.7,195.7 249.7,192.7 257.42,192.7 262.41,187.72 322.43,187.72 329.7,194.99 348.27,194.99 358.15,185.11 362.71,185.11 365.06,182.77 388.06,182.77 391.73,186.43 395.54,186.43 396.3,187.2 398.96,187.2 399.22,186.94
  BOTTOM w0.13: v1(29.27,145.46) 29.71,145.46 v2(30.04,145.79) 30.04,146.3 29.4,146.94 R3294.2
CPLD_RESERVE5: length 425.2
  TOP w0.13: v1(38.29,155.45) 37.78,155.95 36.64,155.95 36.49,155.8 R3324.1 ; U124.F7 v1(400.42,183.25)
  SIG6 w0.102: 401.72,183.85 401.51,183.64 400.81,183.64 v1(400.42,183.25)
  SIG6 w0.155: 401.72,183.85 401.89,184.02 401.89,189.61 399.51,191.99 392.72,191.99 390.59,189.86 390.59,188.34 390,187.75 389.24,187.75 386.86,185.37 366.01,185.37 363.05,188.33 363.05,189.72 360.42,192.34 355.35,192.34 349.35,198.34 329.96,198.34 321.5,189.88 290.77,189.88 284.94,195.7 251.52,195.7 249.87,197.36 207.57,197.36 206.63,198.29 188.36,198.29 188.28,198.37 185.74,198.37 184.59,199.51 161.35,199.51 159.71,197.87 73.1,197.87 71.82,196.6 65.57,196.6 64.55,195.58 62.8,195.58 55.18,187.96 55.05,187.96 53.17,186.08 53.17,184.79 50.81,182.43 50.81,169.1 50,168.29 50,159.92 49.59,159.51 48.45,159.51 48.07,159.13 45.47,159.13 41.28,154.94 38.8,154.94 v1(38.29,155.45)
  BOTTOM w0.13: v1(38.29,155.45) 38.29,156.08 v2(38.16,156.21)
CPU_I2C_RST#: length 314.2
  TOP w0.13: v1(390.84,206.4) 393,204.24 393,196.85 390.56,194.41 R3359.1
  SIG6 w0.155: v1(116.27,219.71) 119.88,223.32 379.19,223.32 384.97,217.54 384.97,209.79 388.37,206.4 v1(390.84,206.4)
  BOTTOM w0.13: YJ3.A2_1 106.72,222.4 110.07,219.05 v2(114.24,219.05) C3480.1 v1(116.27,219.71)
CPU_I2C_SCL: length 720.6
  TOP w0.13: v1(415.61,129.16) 415.61,128.9 419.12,125.39 U10.22 ; U124.D9 v1(402.82,184.85) ; U12.22 18.82,97.19 v1(16.83,99.18) ; U11.22 51.74,102.27 v1(51.14,102.87) ; v1(415.61,112.81) U18.22 ; U123.E9 v1(25.65,162.2)
  SIG2 w0.152: v1(38.04,104.01) 35.24,104.01 33.08,106.17 26.96,106.17 19.98,99.18 v1(16.83,99.18)
  SIG3 w0.155: v1(6.92,100.96) 7.87,100.02 15.52,100.02 16.29,100.79 19.25,100.79 25.13,106.66 25.13,134.83 14.03,145.92 14.03,157.73 15.3,159 24.19,159 24.83,159.64 24.83,161.38 v1(25.65,162.2)
  SIG4 w0.155: v1(25.65,162.2) 25.13,162.73 25.13,165.71 25.44,166.02 25.44,166.64 24.97,167.1 23.84,167.1 21.27,169.67 16.19,169.67 15.56,170.3 14.67,170.3 14.16,170.81 14.16,174.11 15.81,175.77 23.69,175.77 25.59,177.67 25.59,179.7 26.99,181.1 30.29,181.1 41.47,192.28 43.83,192.28 57.99,206.43 70.1,206.43 v1(73.09,209.42)
  SIG8 w0.155: v1(402.82,184.85) 402.27,185.39 402.27,186.05 404.05,187.83 414.99,187.83 416.75,186.07 416.75,149.64 409.38,142.26 409.38,135.39 v1(415.61,129.16) ; v1(398.34,195.45) 397.19,196.59 393.78,196.59 390.47,193.29 383.81,193.29 382.73,194.37 370.33,194.37 362.11,202.6 335.46,202.6 316.26,221.8 121.34,221.8 115.57,216.02 102.44,216.02 101.83,215.41 YJ3.C8_1
  SIG9 w0.155: v1(398.34,195.45) 398.84,194.94 398.84,192.53 402.02,189.35 402.02,185.65 v1(402.82,184.85)
  SIG10 w0.155: v1(73.09,209.42) 73.65,208.86 81.42,208.86 88.46,215.9 100.73,215.9 YJ3.C8_1 ; v1(415.61,112.81) 415.61,115.69 416.37,116.46 416.37,128.39 v1(415.61,129.16)
  BOTTOM w0.13: v1(51.14,102.87) 50.55,102.27 U15.22 47.78,102.27 46.66,103.39 46.66,103.89 46.29,104.26 43.12,104.26 42.35,105.03 40.7,105.03 39.69,104.01 v1(38.04,104.01) ; U13.22 v1(415.61,112.81) ; v1(16.83,99.18) 16.83,98.69 15.33,97.19 U16.22 12.98,97.19 11.65,98.52 11.65,99.03 11.49,99.18 8.7,99.18 v2(7.87,100.01) v1(6.92,100.96) ; U17.22 415.01,125.39 415.61,125.98 v1(415.61,129.16)
CPU_I2C_SDA: length 744.5
  TOP w0.13: v1(425.13,127.89) 424.62,127.38 423.74,127.38 423.58,127.53 R201.1 ; R3364.1 v1(404.69,193.42) ; R446.1 423.58,114.96 423.74,114.81 424.62,114.81 v1(425.13,115.31) ; R206.1 58.15,104.82 58.86,105.53 58.86,107.03 58.45,107.44 52.82,107.44 v1(51.63,106.25) ; v1(24.96,100.96) 24.32,100.33 23.18,100.33 23.03,100.18 R254.1
  SIG1 w0.16: v1(24.96,100.96) 34.23,100.96 35.62,102.36 37.78,102.36 39.05,103.63 v1(39.05,104.65)
  SIG3 w0.155: v1(12.89,171.57) 12.89,166.02 11.49,164.63 10.1,164.63 8.95,163.48 8.95,150.2 24.66,134.5 24.66,106.86 19.21,101.41 15.66,101.41 14.73,100.48 8.67,100.48 v1(8.19,100.96)
  SIG4 w0.155: v1(72.2,209.42) 69.68,206.9 57.8,206.9 44.08,193.18 41.48,193.18 33.46,185.16 32.83,185.16 29.72,182.05 26.29,182.05 24.32,180.08 24.32,177.8 22.92,176.4 15.43,176.4 12.89,173.86 v1(12.89,171.57)
  SIG5 w0.155: v1(409.26,116.58) 409.77,116.08 424.37,116.08 v1(425.13,115.31)
  SIG8 w0.155: v1(404.69,193.42) 405.83,192.28 411.42,192.28 417.22,186.47 417.22,149.39 410.14,142.31 410.14,135.89 416.11,129.92 416.11,129.01 415.62,128.52 409.89,128.52 v1(409.26,129.16) 408.8,128.7 408.8,117.04 v1(409.26,116.58) ; v1(399.73,195.45) 398.08,197.1 393.6,197.1 390.25,193.75 384.12,193.75 383.04,194.84 370.64,194.84 362.26,203.22 335.92,203.22 316.88,222.26 117.68,222.26 115.13,219.71 101.28,219.71 100.27,218.69 100.27,213.87 100.73,213.4 YJ3.C7_1 ; v1(425.13,127.89) 426.91,126.11 426.91,117.09 v1(425.13,115.31)
  SIG9 w0.155: v1(404.69,193.42) 402.65,195.45 v1(399.73,195.45) ; v1(24.96,100.96) 23.81,99.82 9.33,99.82 v1(8.19,100.96)
  SIG10 w0.155: v1(72.2,209.42) 73.22,208.4 98.99,208.4 100.14,209.55 100.14,212.6 100.94,213.4 YJ3.C7_1
  BOTTOM w0.13: v1(8.19,100.96) 9.41,99.74 R367.1 ; R432.1 407.43,127.33 v1(409.26,129.16) ; v1(51.63,106.25) 50.3,107.57 44.26,107.57 43.75,107.06 43.75,105.79 44.01,105.53 44.64,105.53 44.84,105.33 R359.1 43.32,104.82 42.48,105.66 v2(40.07,105.66) v1(39.05,104.65) ; v1(12.89,171.57) 13.3,171.17 R3322.2 ; R288.1 410.86,115.82 410.73,115.95 409.89,115.95 v1(409.26,116.58)
CPU_STATUS_LED: length 135.2
  TOP w0.13: D430.4 398.35,63.42 398.07,63.14 397.14,63.14 396.83,62.83 396.83,61.13 396.58,60.88 R3379.1 395.37,60.88 395.16,61.08 395.16,62.99 395.54,63.37 v1(395.92,63.37) ; U124.N11 v1(404.42,176.85)
  SIG7 w0.102: 404.82,175.48 404.82,176.45 v1(404.42,176.85)
  SIG7 w0.155: 404.82,175.48 404.82,175.25 405.96,174.11 405.96,170.59 407.14,169.4 407.14,162.9 409.41,160.62 409.41,143.59 408.25,142.42 408.25,131.82 410.91,129.16 410.91,108.44 410.55,108.07 408.11,108.07 406.16,106.12 406.16,104.47 395.92,94.24 v1(395.92,63.37)
  BOTTOM w0.13: v1(395.92,63.37) v2(395.92,64.13)
E2_WP: length 329.6
  TOP w0.13: R3323.1 30.8,171.07 31.23,171.5 31.23,171.88 v1(31.69,172.34) ; v1(260.73,208.98) 264.8,208.98 274.38,199.39 284.16,199.39 287.97,195.58 287.97,188.85 283.78,184.66 271.08,184.66 269.05,182.62 269.05,181.23 268.9,181.07 R314.1 267.53,181.07 267.37,180.92 R316.1 266.76,179.96 266.92,179.8 U14.7
  SIG9 w0.155: v1(31.69,172.34) 32.58,173.23 32.58,176.08 38.1,181.61 39.81,181.61 44.26,186.05 44.26,191.01 57.72,204.47 71.06,204.47 72.3,203.23 93.92,203.23 94.9,204.21 153.09,204.21 168.31,219.44 251.79,219.44 260.73,210.5 v1(260.73,208.98)
  BOTTOM w0.13: v1(31.69,172.34) v2(31.69,173.1)
FAN_STATUS_LED: length 157.6
  TOP w0.13: v1(409.69,60.2) 409.74,60.25 R3409.1 410.37,61.03 410.62,61.28 410.62,64.35 411.29,65.02 412.18,65.02 412.35,64.85 D432.4 ; v1(410.78,184.15) 410.22,184.71 409.14,184.71 408.47,184.05 407.62,184.05 U124.E15
  SIG7 w0.155: v1(409.69,60.2) 409.89,60.4 409.89,62.35 410.4,62.86 410.4,66.17 402.89,73.68 402.89,82.28 401.26,83.91 401.26,90.97 417.76,107.47 417.76,127.96 424.62,134.81 424.62,143.21 418.91,148.93 418.91,178.94 416.03,181.82 413.11,181.82 v1(410.78,184.15)
  BOTTOM w0.13: v2(409.64,60.96) 409.69,60.91 v1(409.69,60.2)
FB: length 6.8
  TOP w0.305: v1(283.43,208.38) R3510.1 R3507.2 C3606.2 279.46,209.67 279.2,209.93 U126.3
FC0_1_PVDD0P8: length 5.5
  TOP w0.229: U1.BG38 v1(192.55,153.34) ; U1.BG40 v1(190.55,153.34)
  TOP w0.381: 176,184.55 C3010.1 ; C3010.1 176.59,183.92 ; C3010.1 177.19,184.55
  BOTTOM w0.13: v1(176.09,183.28) v2(175.32,183.28)
  BOTTOM w0.381: v1(192.55,153.34) 192.03,152.82 C2927.1 ; C3335.1 v1(190.55,153.34)
  vias: v1(176.97,183.28)
FC0_15_PVDD1P8: length 15.7
  TOP w0.229: v1(181.55,142.34) 182.05,141.84 U1.AT49 ; U1.BB49 v1(181.55,148.34) ; U1.BE49 v1(181.55,151.34) ; U1.AW49 182.05,144.84 v1(181.55,145.34) ; U1.BG45 v1(185.55,153.34) ; U1.BG47 v1(183.55,153.34) ; U1.BG42 v1(188.55,153.34) ; U1.BG39 v1(191.55,153.34)
  TOP w0.381: 184.51,193.14 C101.1 ; C101.1 185.7,193.14 ; C101.1 185.1,193.77 ; 185.1,194.21 L428.1 ; L428.1 184.51,194.84 ; L428.1 185.7,194.84
  BOTTOM w0.13: v1(186.25,194.05) v2(185.48,194.05)
  BOTTOM w0.381: v1(183.55,153.34) 183.06,152.85 C2696.1 ; C103.1 189.05,153.84 v1(188.55,153.34) ; v1(181.55,142.34) 181.06,142.83 C2907.1 ; v1(181.55,151.34) 181.07,151.83 C2713.1 ; v1(181.55,148.34) 181.07,148.83 C3166.1 ; C102.1 192.02,153.82 v1(191.55,153.34) ; C2819.1 181.06,145.83 v1(181.55,145.34) ; C2778.1 v1(185.55,153.34)
  vias: v1(186.25,193.04)
FC0_RDN0: length 271.8
  TOP w0.147: U1.BP37 194.05,159.88 arc(194.01,160.06) 193.91,160.21 193.84,160.28 arc(193.77,160.33) 193.69,160.34 v4(193.6,160.34)
  SIG8 w0.112: v4(193.6,160.34) 193.85,160.34 arc(193.92,160.37) 193.95,160.44 193.95,160.67 arc(193.92,160.74) 193.85,160.77 192.39,160.77 arc(192.22,160.8) 192.08,160.9 arc(191.98,161.04) 191.95,161.21 191.95,173.52 191.86,173.61 191.86,173.64
  SIG8 w0.16: 191.86,173.64 191.86,175.47 arc(191.73,176.79) 191.34,178.07 arc(190.71,179.24) 189.87,180.27 184.21,185.93 arc(183.79,186.21) 183.3,186.31 161.02,186.31 arc(160.72,186.25) 160.46,186.07 155.07,180.68 arc(154.69,180.43) 154.23,180.34 148.58,180.34 arc(148.27,180.28) 148.01,180.1 101.9,133.99 arc(101.72,133.73) 101.66,133.42 101.66,131.09 arc(101.52,130.36) 101.11,129.74 96.65,125.28 arc(90.25,121.01) 82.7,119.5 77.66,119.5 arc(64.4,116.87) 53.16,109.36 50.96,107.15 arc(49.17,105.96) 47.05,105.53 39.65,105.53 arc(38.37,105.28) 37.29,104.56 29.05,96.32 29.05,96.04 28.69,95.68 28.41,95.68 28.05,95.32 28.05,95.03 27.69,94.67 27.4,94.67 27.04,94.31 27.04,94.02 26.68,93.66 26.4,93.66 26.04,93.31 26.04,93.02 25.68,92.66 25.39,92.66 25.03,92.3 25.03,92.01 24.67,91.65 24.38,91.65 24.02,91.29 24.02,91.01 23.67,90.65 23.38,90.65 23.02,90.29 23.02,90 22.66,89.64 22.37,89.64 22.01,89.28 22.01,88.98 21.6,88.56 21.29,88.56 20.85,88.12 arc(20.6,87.74) 20.51,87.29 20.51,86.46 19.81,84.77 arc(19.76,84.62) 19.75,84.46 19.75,76.48 arc(19.66,76.03) 19.4,75.64 14.54,70.78 arc(14.37,70.52) 14.31,70.21 14.31,60.39 arc(14.6,59.69) 15.3,59.39 15.99,59.39 arc(16.28,59.34) 16.53,59.17 16.71,58.99 arc(16.82,58.91) 16.95,58.87 arc(16.99,58.86) 17.02,58.86 17.9,58.86 arc(18.13,58.82) 18.32,58.69 arc(18.4,58.57) 18.43,58.43 18.43,58.39 arc(18.38,58.17) 18.25,57.97 YJ22.D22
FC0_RDN1: length 279.9
  TOP w0.147: v4(194.5,162.34) 194.55,162.34 U1.BT36
  SIG8 w0.112: v4(194.5,162.34) 194.27,162.34 arc(194.18,162.38) 194.15,162.47 194.15,162.67 arc(194.18,162.74) 194.25,162.77 194.53,162.77 arc(194.75,162.82) 194.94,162.94 arc(195.06,163.13) 195.11,163.35 195.11,166.47 arc(195.07,166.66) 194.96,166.83 arc(194.79,166.94) 194.6,166.98 194.36,166.98 arc(194.28,166.99) 194.21,167.04 194.18,167.07 arc(194.16,167.1) 194.15,167.14 194.15,173.5 194.24,173.59 194.24,173.61
  SIG8 w0.16: 194.24,173.61 194.24,176.33 arc(194.01,178.17) 193.32,179.89 arc(192.76,180.74) 192.1,181.5 186.48,187.12 185.91,187.69 arc(184.66,188.53) 183.17,188.82 153.47,188.82 arc(151.2,188.37) 149.27,187.08 145.18,182.99 126.94,164.03 123.76,160.73 100,136.03 arc(99.89,135.91) 99.81,135.77 95.71,128.18 94.97,127.45 arc(89.13,123.54) 82.23,122.17 76.64,122.17 arc(63.47,119.55) 52.31,112.09 50.24,110.02 arc(48.08,108.58) 45.54,108.07 41.94,108.07 arc(37.67,107.23) 34.06,104.81 17.12,87.87 16.82,87.57 15.9,86.55 15.49,86.08 15.44,86.02 14.37,84.82 14.25,84.56 13.93,83.9 arc(13.88,83.77) 13.85,83.64 13.66,81.9 12.63,72.86 arc(12.62,72.79) 12.62,72.72 12.62,57.67 arc(13.4,55.79) 15.27,55.01 15.99,55.01 arc(16.14,54.98) 16.26,54.9 16.35,54.82 16.39,54.77 arc(16.45,54.7) 16.49,54.61 arc(16.51,54.54) 16.51,54.48 16.51,54.1 arc(16.56,53.84) 16.71,53.63 17.15,53.18 arc(17.26,53.02) 17.3,52.83 YJ22.D18
FC0_RDN2: length 269.2
  TOP w0.147: U1.BV37 194.05,163.89 arc(193.92,164.21) v4(193.6,164.34)
  SIG9 w0.112: 191.86,173.59 191.91,173.54 arc(191.94,173.49) 191.95,173.43 191.95,165.36 arc(192,165.13) 192.13,164.94 arc(192.32,164.81) 192.54,164.77 193.85,164.77 arc(193.92,164.74) 193.95,164.67 193.95,164.47 arc(193.94,164.43) 193.92,164.4 193.9,164.37 arc(193.86,164.35) 193.82,164.34 v4(193.6,164.34)
  SIG9 w0.16: 191.86,173.59 191.86,177.84 arc(191.8,178.12) 191.64,178.37 arc(191.64,178.37) 191.64,178.37 187.78,182.23 183.94,186.07 arc(183.68,186.25) 183.37,186.31 161.02,186.31 arc(160.72,186.25) 160.46,186.07 155.89,181.51 154.51,180.12 arc(154.13,179.87) 153.68,179.78 148.05,179.78 arc(147.74,179.72) 147.48,179.54 101.9,133.96 arc(101.72,133.7) 101.66,133.4 101.66,130.79 arc(101.57,130.34) 101.32,129.95 91.45,120.09 arc(88.41,118.06) 84.83,117.35 65.91,117.35 arc(61.51,116.47) 57.79,113.98 49.69,105.88 arc(49.3,105.62) 48.85,105.53 42.03,105.53 arc(41.73,105.47) 41.47,105.3 26.84,90.67 26.84,90.43 26.43,90.02 26.19,90.02 25.83,89.67 25.83,89.43 25.42,89.02 25.18,89.02 24.82,88.66 24.82,88.4 24.44,88.01 24.18,88.01 23.8,87.63 arc(23.71,87.51) 23.69,87.36 23.69,86.05 arc(23.6,85.6) 23.34,85.22 22.27,84.15 arc(22.1,83.89) 22.03,83.58 22.03,80.97 22.24,80.77 22.24,80.26 22.03,80.06 22.03,79.52 22.24,79.31 22.24,78.8 22.03,78.6 22.03,78.09 22.24,77.89 22.24,77.38 22.03,77.18 22.03,76.27 arc(21.94,75.82) 21.69,75.44 14.62,68.37 arc(14.45,68.12) 14.39,67.81 14.39,63.23 14.67,62.95 14.67,62.47 14.39,62.19 14.39,61.81 arc(14.45,61.51) 14.61,61.27 14.95,60.93 15.33,60.93 15.69,60.57 15.69,60.19 16.25,59.63 arc(16.51,59.46) 16.82,59.39 18.39,59.39 arc(18.68,59.34) 18.93,59.17 arc(19.27,58.94) 19.68,58.86 20.44,58.86 arc(20.7,58.76) 20.8,58.5 20.8,58.34 arc(20.76,58.14) 20.65,57.97 YJ22.D25
FC0_RDN3: length 277.3
  TOP w0.147: v4(194.5,166.34) 194.55,166.34 U1.BY36
  SIG9 w0.112: v4(194.5,166.34) 194.39,166.45 arc(194.22,166.7) 194.16,166.99 194.16,173.46 arc(194.17,173.52) 194.21,173.57 194.25,173.61 194.25,173.64
  SIG9 w0.16: 194.25,173.64 194.25,178.01 arc(194.03,179.13) 193.4,180.07 185.51,187.97 arc(185.03,188.35) 184.48,188.63 arc(183.97,188.77) 183.44,188.82 153.27,188.82 arc(151.18,188.41) 149.41,187.22 144.24,182.05 arc(143.84,181.45) 143.7,180.75 143.7,180.14 arc(143.54,179.32) 143.07,178.62 99.47,135.02 arc(99.21,134.64) 99.12,134.18 99.12,131.53 arc(98.85,131.03) 98.49,130.58 90.02,122.12 arc(87.55,120.47) 84.63,119.89 63.57,119.89 arc(60.25,119.22) 57.43,117.34 49.69,109.6 arc(48,108.47) 46.01,108.07 40.78,108.07 arc(40.33,107.98) 39.95,107.73 28.2,95.98 21.49,89.28 arc(20.54,87.85) 20.21,86.17 arc(20.14,85.83) 19.95,85.55 19.95,85.55 arc(19.52,84.9) 19.37,84.14 19.37,76.77 arc(19.26,76.22) 18.94,75.75 12.91,69.72 arc(12.75,69.47) 12.69,69.18 12.69,59.29 arc(12.75,58.99) 12.91,58.75 16.3,55.36 arc(16.68,55.1) 17.13,55.01 18.39,55.01 arc(18.54,54.98) 18.66,54.9 18.74,54.83 18.75,54.81 18.79,54.77 arc(18.86,54.68) 18.9,54.57 arc(18.91,54.53) 18.91,54.48 18.91,54.16 arc(18.97,53.85) 19.15,53.58 19.53,53.2 arc(19.66,53.02) 19.7,52.8 YJ22.D15
FC0_RDP0: length 271.8
  TOP w0.147: U1.BP36 194.55,160.34 v4(194.5,160.34)
  SIG8 w0.112: v4(194.5,160.34) 194.25,160.34 arc(194.18,160.37) 194.15,160.44 194.15,160.67 arc(194.06,160.88) 193.85,160.97 192.39,160.97 arc(192.29,160.99) 192.22,161.04 arc(192.16,161.12) 192.14,161.21 192.14,173.52 192.24,173.61 192.24,173.64
  SIG8 w0.16: 192.24,173.64 192.24,175.47 arc(192.1,176.87) 191.69,178.21 arc(191.03,179.45) 190.13,180.54 184.48,186.2 arc(183.94,186.56) 183.3,186.69 161.02,186.69 arc(160.57,186.6) 160.19,186.34 154.8,180.95 arc(154.54,180.78) 154.23,180.72 148.58,180.72 arc(148.13,180.63) 147.74,180.37 101.63,134.26 arc(101.37,133.87) 101.28,133.42 101.28,131.09 arc(101.17,130.51) 100.84,130.01 96.38,125.55 arc(90.1,121.36) 82.7,119.89 77.66,119.89 arc(64.26,117.22) 52.89,109.63 50.69,107.42 arc(49.02,106.31) 47.05,105.92 39.65,105.92 arc(38.22,105.63) 37.02,104.83 20.58,88.39 arc(20.25,87.89) 20.13,87.3 20.13,86.54 19.46,84.92 arc(19.39,84.69) 19.37,84.46 19.37,76.48 arc(19.31,76.17) 19.13,75.91 14.27,71.05 arc(14.01,70.67) 13.92,70.21 13.92,60.39 arc(14.33,59.42) 15.3,59.01 15.99,59.01 arc(16.14,58.98) 16.26,58.9 16.35,58.82 arc(16.42,58.73) 16.47,58.63 arc(16.5,58.53) 16.51,58.42 16.51,58.15 arc(16.57,57.85) 16.74,57.59 17.09,57.25 arc(17.24,57.01) 17.3,56.73 YJ22.D21
FC0_RDP1: length 279.9
  TOP w0.147: U1.BT37 194.05,161.88 arc(194.01,162.06) 193.91,162.21 193.84,162.28 arc(193.77,162.33) 193.69,162.34 v4(193.6,162.34)
  SIG8 w0.112: v4(193.6,162.34) 193.8,162.34 arc(193.85,162.35) 193.89,162.38 193.91,162.4 arc(193.94,162.44) 193.95,162.48 193.95,162.67 arc(194.04,162.88) 194.25,162.97 194.53,162.97 arc(194.68,163) 194.8,163.08 arc(194.88,163.2) 194.91,163.35 194.91,166.47 arc(194.89,166.59) 194.82,166.69 arc(194.72,166.75) 194.6,166.78 194.36,166.78 arc(194.2,166.81) 194.07,166.9 194.04,166.93 arc(193.98,167.02) 193.96,167.14 193.96,173.5 193.86,173.59 193.86,173.61
  SIG8 w0.16: 193.86,173.61 193.86,176.33 arc(193.64,178.07) 192.98,179.71 arc(192.46,180.51) 191.83,181.23 186.21,186.85 185.64,187.42 arc(184.51,188.17) 183.17,188.44 153.47,188.44 arc(151.34,188.02) 149.54,186.81 148.53,185.8 146.3,183.58 145.46,182.73 126.94,163.48 123.76,160.18 100.27,135.76 arc(100.2,135.68) 100.14,135.59 96.04,128 95.97,127.91 95.24,127.18 arc(89.27,123.19) 82.23,121.79 76.64,121.79 arc(63.62,119.2) 52.58,111.82 50.51,109.75 arc(48.23,108.23) 45.54,107.69 41.94,107.69 arc(37.82,106.87) 34.33,104.54 17.09,87.31 16.28,86.4 16.29,86.2 15.84,85.65 15.75,85.64 15.6,85.64 14.69,84.61 14.59,84.4 14.3,83.79 arc(14.25,83.67) 14.23,83.54 14.04,81.85 14.26,81.57 14.2,81.07 13.92,80.84 13.86,80.34 14.09,80.06 14.03,79.55 13.75,79.33 13.69,78.83 13.92,78.54 13.86,78.04 13.58,77.82 13.52,77.31 13.74,77.03 13.69,76.53 13.4,76.3 13.35,75.8 13.57,75.52 13.51,75.01 13.23,74.79 13.17,74.28 13.4,74 13.34,73.5 13.06,73.27 13.01,72.81 arc(13,72.77) 13,72.72 13,57.67 arc(13.67,56.06) 15.27,55.39 15.99,55.39 arc(16.28,55.34) 16.53,55.17 16.71,54.99 arc(16.85,54.89) 17.02,54.86 18,54.86 arc(18.15,54.83) 18.28,54.75 arc(18.37,54.61) 18.4,54.45 18.4,54.34 arc(18.36,54.14) 18.25,53.97 YJ22.D17
FC0_RDP2: length 269.2
  TOP w0.147: U1.BV36 194.55,164.34 v4(194.5,164.34)
  SIG9 w0.112: 192.24,173.59 192.2,173.54 arc(192.16,173.49) 192.15,173.43 192.15,165.36 arc(192.18,165.21) 192.27,165.08 arc(192.39,164.99) 192.54,164.96 193.85,164.96 arc(194.06,164.88) 194.15,164.67 194.15,164.47 arc(194.16,164.43) 194.18,164.38 194.19,164.38 arc(194.23,164.35) 194.28,164.34 v4(194.5,164.34)
  SIG9 w0.16: 192.24,173.59 192.24,177.84 arc(192.16,178.27) 191.92,178.64 191.91,178.65 184.21,186.34 arc(183.83,186.6) 183.37,186.69 161.02,186.69 arc(160.57,186.6) 160.19,186.34 155.89,182.04 154.24,180.39 arc(153.98,180.22) 153.68,180.16 148.05,180.16 arc(147.59,180.07) 147.21,179.81 123.76,156.37 101.63,134.23 arc(101.37,133.85) 101.28,133.4 101.28,130.79 arc(101.22,130.48) 101.05,130.22 91.18,120.36 arc(88.27,118.41) 84.83,117.73 65.91,117.73 arc(61.37,116.82) 57.52,114.25 49.42,106.15 arc(49.16,105.98) 48.85,105.92 42.03,105.92 arc(41.58,105.83) 41.2,105.57 23.53,87.9 arc(23.36,87.65) 23.3,87.36 23.3,86.05 arc(23.24,85.75) 23.07,85.49 22,84.42 arc(21.74,84.03) 21.65,83.58 21.65,76.27 arc(21.59,75.97) 21.42,75.71 14.35,68.64 arc(14.1,68.26) 14.01,67.81 14.01,61.81 arc(14.1,61.37) 14.34,61 15.98,59.36 arc(16.36,59.1) 16.82,59.01 18.39,59.01 arc(18.54,58.98) 18.66,58.9 18.74,58.83 18.75,58.81 18.79,58.77 arc(18.85,58.7) 18.89,58.6 arc(18.9,58.59) 18.9,58.58 arc(18.91,58.53) 18.91,58.48 18.91,58.16 arc(18.97,57.85) 19.15,57.58 19.52,57.22 arc(19.65,57.01) 19.7,56.78 YJ22.D24
FC0_RDP3: length 277.3
  TOP w0.147: U1.BY37 194.05,165.89 arc(193.92,166.21) v4(193.6,166.34)
  SIG9 w0.112: 193.87,173.64 193.92,173.6 arc(193.95,173.54) 193.97,173.48 193.97,167.02 arc(193.91,166.73) 193.74,166.48 v4(193.6,166.34)
  SIG9 w0.16: YJ22.D14 20.65,53.97 arc(20.76,54.14) 20.8,54.34 20.8,54.52 arc(20.7,54.76) 20.46,54.86 19.57,54.86 arc(19.27,54.92) 19.01,55.1 18.93,55.17 arc(18.68,55.34) 18.39,55.39 17.13,55.39 arc(16.83,55.46) 16.57,55.63 15.34,56.86 15.34,57.25 15,57.58 14.62,57.58 14.26,57.94 14.26,58.32 13.92,58.66 13.54,58.66 13.18,59.02 arc(13.1,59.14) 13.07,59.29 13.07,59.79 13.35,60.07 13.35,60.53 13.07,60.81 13.07,69.18 arc(13.1,69.33) 13.18,69.45 13.54,69.81 13.92,69.81 14.26,70.14 14.26,70.53 14.62,70.89 15,70.89 15.34,71.22 15.34,71.61 15.74,72.01 16.09,72.01 16.45,72.36 16.45,72.72 19.21,75.48 arc(19.61,76.08) 19.75,76.77 19.75,84.14 arc(19.87,84.76) 20.22,85.28 20.22,85.28 arc(20.49,85.69) 20.59,86.17 20.59,86.17 arc(20.89,87.7) 21.76,89.01 28.47,95.72 40.22,107.46 arc(40.47,107.63) 40.78,107.69 46.01,107.69 arc(48.15,108.12) 49.96,109.33 57.7,117.07 arc(60.4,118.87) 63.57,119.5 84.63,119.5 arc(87.7,120.11) 90.29,121.85 98.76,130.31 arc(99.17,130.82) 99.48,131.39 arc(99.49,131.43) 99.5,131.46 99.5,134.18 arc(99.57,134.49) 99.74,134.75 143.34,178.35 arc(143.89,179.17) 144.08,180.14 144.08,180.75 arc(144.19,181.31) 144.51,181.78 149.68,186.95 arc(151.33,188.05) 153.27,188.44 183.44,188.44 arc(183.9,188.4) 184.35,188.27 arc(184.82,188.03) 185.24,187.7 193.13,179.8 arc(193.68,178.98) 193.87,178.01 193.87,173.64
FC0_TDN0: length 278
  TOP w0.147: U1.CC35 195.55,169.34 v4(195.5,169.34)
  SIG6 w0.112: 196.24,172.72 196.24,172.69 196.14,172.6 196.14,170.15 arc(196.12,170.02) 196.05,169.92 196,169.87 arc(195.89,169.8) 195.77,169.77 195.27,169.77 arc(195.18,169.73) 195.15,169.64 195.15,169.47 arc(195.18,169.38) 195.27,169.34 v4(195.5,169.34)
  SIG6 w0.16: 196.24,172.72 196.24,177.65 arc(196.15,178.09) 195.9,178.46 190.17,184.19 arc(189.8,184.44) 189.36,184.53 158.85,184.53 arc(158.41,184.44) 158.04,184.19 154.15,180.3 arc(153.96,180.18) 153.75,180.13 144.97,180.13 arc(144.61,180.06) 144.31,179.86 123.75,159.3 99.35,134.9 arc(99.18,134.65) 99.12,134.36 99.12,133.35 arc(98.87,131.89) 98.06,130.66 93.37,125.97 arc(83.82,119.59) 72.55,117.35 65.62,117.35 arc(58.06,115.84) 51.65,111.56 49.46,109.36 arc(48.03,108.41) 46.34,108.07 45.05,108.07 arc(43.82,107.83) 42.78,107.13 29.88,94.23 arc(29.43,93.93) 28.89,93.83 28.79,93.83 arc(27.66,93.6) 26.7,92.96 20.15,86.41 arc(20,86.23) 19.9,86.03 19.45,84.96 arc(19.39,84.75) 19.37,84.52 19.37,76.27 arc(19.33,76.06) 19.2,75.88 11.39,68.06 arc(11.14,67.69) 11.05,67.25 11.05,61.99 arc(11.14,61.56) 11.39,61.19 11.91,60.66 12.57,60.01 12.68,59.89 12.91,59.67 arc(12.99,59.54) 13.02,59.4 13.02,58.96 arc(13.1,58.52) 13.35,58.15 16.16,55.35 arc(16.53,55.1) 16.97,55.01 25.59,55.01 arc(25.74,54.98) 25.86,54.9 25.95,54.81 arc(26.07,54.64) 26.11,54.42 26.11,54.16 arc(26.17,53.85) 26.35,53.58 26.69,53.25 26.71,53.22 arc(26.85,53.01) 26.9,52.76 YJ22.D6
FC0_TDN1: length 278.1
  TOP w0.147: U1.CE36 195.05,170.89 arc(194.92,171.21) v4(194.6,171.34)
  SIG7 w0.112: 195.86,172.84 195.86,172.81 195.95,172.72 195.95,172.19 arc(195.94,172.15) 195.92,172.11 arc(195.76,172.01) 195.57,171.97 195.27,171.97 arc(195.05,171.87) 194.95,171.64 194.95,171.51 arc(194.9,171.39) 194.79,171.34 v4(194.6,171.34)
  SIG7 w0.16: YJ22.D2 30.25,53.97 arc(30.36,54.14) 30.4,54.34 30.4,54.52 arc(30.3,54.76) 30.06,54.86 29.16,54.86 arc(28.86,54.92) 28.62,55.08 28.53,55.17 arc(28.28,55.34) 27.99,55.39 16.2,55.39 arc(15.99,55.44) 15.81,55.56 13.15,58.21 arc(13.03,58.39) 12.99,58.61 12.99,68.98 arc(13.03,69.19) 13.15,69.37 19.29,75.51 arc(19.63,76.02) 19.75,76.62 19.75,83.82 arc(19.92,84.67) 20.4,85.4 21.9,86.89 28.47,93.43 arc(28.71,93.59) 28.99,93.65 29.25,93.65 arc(29.76,93.75) 30.2,94.04 30.84,94.68 31.04,94.68 31.39,95.03 31.39,95.24 31.72,95.56 31.95,95.56 32.28,95.89 32.28,96.12 32.61,96.45 32.84,96.45 33.17,96.78 33.17,97.01 33.5,97.34 33.65,97.34 34.05,97.74 34.05,97.89 34.38,98.22 34.61,98.22 34.94,98.55 34.94,98.78 37.22,101.07 37.36,101.07 37.5,101.06 37.83,101.39 37.83,101.53 37.83,101.53 37.83,101.67 38.16,102 38.3,102 38.3,102 38.44,102 38.77,102.33 38.77,102.47 38.77,102.47 38.77,102.61 39.1,102.94 39.24,102.94 39.24,102.94 39.38,102.94 39.71,103.27 39.71,103.41 39.7,103.41 39.7,103.54 40.03,103.87 40.26,103.87 40.64,104.25 40.64,104.48 42.22,106.06 42.42,106.06 42.8,106.44 42.8,106.64 43.69,107.53 arc(43.87,107.65) 44.09,107.69 47.93,107.69 arc(48.29,107.77) 48.6,107.97 54.93,114.3 arc(60.7,118.15) 67.5,119.5 80.46,119.5 arc(83.28,119.84) 85.96,120.81 arc(90.83,123.98) 94.85,128.16 arc(96.67,130.63) 98.4,133.15 arc(99.02,134.46) 99.25,135.88 arc(99.25,135.88) 99.25,135.88 99.25,136.52 arc(99.39,137.15) 99.75,137.68 141.65,179.58 arc(141.83,179.7) 142.04,179.74 153.74,179.74 arc(154.1,179.81) 154.41,180.02 158.37,183.98 arc(158.55,184.1) 158.77,184.15 188.3,184.15 arc(188.75,184.06) 189.13,183.8 194.71,178.22 arc(194.8,178.13) 194.88,178.03 arc(195.19,177.46) 195.3,176.81 195.3,174.36 arc(195.31,174.19) 195.34,174.02 arc(195.47,173.69) 195.69,173.4 195.8,173.29 arc(195.84,173.23) 195.86,173.16 195.86,172.84
FC0_TDN2: length 268.5
  TOP w0.147: v4(193.5,168.34) 193.55,168.34 U1.CB37
  SIG6 w0.112: 194.23,173.62 194.23,173.6 194.14,173.5 194.14,169.15 arc(194.12,169.02) 194.05,168.92 193.99,168.87 arc(193.89,168.8) 193.77,168.77 193.27,168.77 arc(193.18,168.73) 193.15,168.64 193.15,168.47 arc(193.18,168.38) 193.27,168.34 v4(193.5,168.34)
  SIG6 w0.16: 194.23,173.62 194.23,176.35 arc(194.15,176.79) 193.9,177.16 188.95,182.11 arc(188.58,182.36) 188.14,182.44 159.63,182.44 arc(159.27,182.37) 158.97,182.17 155.84,179.04 arc(155.59,178.87) 155.3,178.81 146.68,178.81 arc(146.25,178.73) 145.87,178.48 101.62,134.22 arc(101.37,133.85) 101.28,133.41 101.28,131.25 101.28,131.25 arc(101.22,130.96) 101.06,130.71 86.79,116.44 arc(81.74,113.07) 75.79,111.88 55.54,111.88 arc(55.18,111.81) 54.88,111.61 46.93,103.67 arc(46.75,103.55) 46.54,103.5 42.97,103.5 arc(42.61,103.43) 42.3,103.23 30.93,91.86 arc(30.75,91.73) 30.54,91.69 29.59,91.69 arc(29.15,91.6) 28.78,91.36 21.99,84.56 arc(21.74,84.19) 21.65,83.76 21.65,75.89 arc(21.56,75.42) 21.3,75.03 13.89,67.63 arc(13.33,66.78) 13.13,65.79 13.13,63.34 arc(13.22,62.9) 13.47,62.53 14.61,61.39 arc(14.65,61.34) 14.66,61.29 arc(14.72,60.94) 14.92,60.65 16.22,59.35 arc(16.59,59.1) 17.03,59.01 25.59,59.01 arc(25.74,58.98) 25.86,58.9 25.95,58.81 25.99,58.77 arc(26.05,58.69) 26.09,58.6 arc(26.1,58.59) 26.1,58.58 arc(26.11,58.53) 26.11,58.48 26.11,58.16 26.11,58.04 arc(26.15,57.84) 26.26,57.67 26.48,57.46 26.76,57.18 arc(26.86,57.02) 26.9,56.83 YJ22.D33
FC0_TDN3: length 269.4
  TOP w0.147: U1.CD38 193.05,169.9 arc(192.92,170.21) 192.6,170.34 v4(192.6,170.34)
  SIG7 w0.112: 193.87,173.61 193.87,173.58 193.96,173.49 193.96,171.21 arc(193.95,171.18) 193.94,171.14 arc(193.93,171.13) 193.92,171.12 193.84,171.04 arc(193.76,170.99) 193.66,170.97 193.34,170.97 arc(193.06,170.86) 192.95,170.58 192.95,170.51 arc(192.9,170.39) 192.79,170.34 v4(192.6,170.34)
  SIG7 w0.16: YJ22.D37 30.25,57.97 arc(30.36,58.14) 30.4,58.34 30.4,58.52 arc(30.3,58.76) 30.06,58.86 29.28,58.86 arc(28.87,58.94) 28.53,59.17 arc(28.28,59.34) 27.99,59.39 16.14,59.39 arc(15.92,59.44) 15.74,59.56 14.46,60.85 arc(14.33,61.03) 14.29,61.24 14.29,67.33 arc(14.33,67.55) 14.46,67.73 21.59,74.86 arc(21.92,75.36) 22.03,75.94 22.03,83.31 arc(22.17,84.01) 22.57,84.61 22.73,84.77 28.08,90.12 arc(28.5,90.4) 29,90.5 29.54,90.5 arc(30.1,90.61) 30.57,90.92 32.38,92.73 32.65,92.73 32.98,93.06 32.98,93.34 33.31,93.66 33.58,93.66 33.91,93.99 33.91,94.27 34.24,94.6 34.51,94.6 34.84,94.92 34.84,95.2 35.17,95.53 35.45,95.53 35.77,95.86 35.77,96.13 37.43,97.78 37.7,97.78 38.03,98.11 38.03,98.39 38.36,98.72 38.63,98.72 38.96,99.04 38.96,99.32 39.29,99.65 39.57,99.65 39.89,99.98 39.89,100.25 40.22,100.58 40.42,100.58 40.83,100.98 40.83,101.18 41.15,101.51 41.38,101.51 41.76,101.89 41.76,102.11 43.87,104.23 arc(44.05,104.35) 44.27,104.39 47.81,104.39 arc(48.17,104.46) 48.47,104.67 55.99,112.18 arc(61.57,115.91) 68.14,117.22 81.16,117.22 arc(88.02,118.58) 93.83,122.46 99.48,128.12 arc(101.1,130.53) 101.66,133.38 101.66,135.53 arc(101.87,136.59) 102.48,137.49 143.25,178.26 arc(143.43,178.38) 143.65,178.42 155.37,178.42 arc(155.73,178.5) 156.03,178.7 159.23,181.9 arc(159.42,182.02) 159.63,182.06 187.84,182.06 arc(188.06,182.02) 188.24,181.9 193.7,176.44 arc(193.82,176.26) 193.87,176.04 193.87,173.61
FC0_TDP0: length 278
  TOP w0.147: U1.CC36 195.05,168.89 arc(194.92,169.21) v4(194.6,169.34)
  SIG6 w0.112: v4(194.6,169.34) 194.82,169.34 arc(194.91,169.38) 194.95,169.47 194.95,169.64 arc(195.05,169.87) 195.27,169.97 195.77,169.97 arc(195.82,169.98) 195.86,170.01 195.91,170.06 arc(195.94,170.1) 195.95,170.15 195.95,172.6 195.86,172.69 195.86,172.72
  SIG6 w0.16: 195.86,172.72 195.86,177.65 arc(195.8,177.94) 195.63,178.19 195.29,178.53 194.96,178.53 194.64,178.84 194.64,179.18 194.3,179.52 193.96,179.52 193.65,179.83 193.65,180.17 193.31,180.51 192.97,180.51 192.66,180.83 192.66,181.16 192.32,181.5 191.98,181.5 191.67,181.82 191.67,182.16 191.33,182.5 190.99,182.5 190.67,182.81 190.67,183.15 189.9,183.92 arc(189.65,184.09) 189.36,184.14 158.85,184.14 arc(158.56,184.09) 158.31,183.92 154.42,180.03 arc(154.11,179.82) 153.75,179.75 144.97,179.75 arc(144.76,179.71) 144.58,179.59 99.62,134.63 arc(99.53,134.5) 99.5,134.36 99.5,133.36 arc(99.23,131.75) 98.33,130.39 93.64,125.7 arc(83.97,119.24) 72.55,116.96 65.62,116.96 arc(58.21,115.49) 51.92,111.29 49.72,109.09 arc(48.17,108.06) 46.34,107.69 45.05,107.69 arc(43.97,107.48) 43.05,106.86 30.15,93.97 arc(29.57,93.58) 28.89,93.44 28.79,93.44 arc(27.8,93.25) 26.97,92.69 20.42,86.14 arc(20.32,86.02) 20.25,85.89 19.81,84.82 arc(19.76,84.67) 19.75,84.52 19.75,76.27 arc(19.68,75.91) 19.47,75.61 11.66,67.79 arc(11.49,67.55) 11.43,67.25 11.43,61.99 arc(11.49,61.7) 11.66,61.45 12.18,60.93 13.18,59.94 arc(13.34,59.69) 13.4,59.4 13.4,58.96 arc(13.46,58.67) 13.62,58.42 13.85,58.2 14.16,58.2 14.5,57.86 14.5,57.55 14.84,57.21 15.15,57.21 15.49,56.87 15.49,56.55 16.43,55.62 arc(16.67,55.45) 16.97,55.39 25.59,55.39 arc(25.88,55.34) 26.13,55.17 26.22,55.08 arc(26.31,55) 26.42,54.94 arc(26.43,54.93) 26.45,54.93 arc(26.6,54.88) 26.76,54.86 27.66,54.86 arc(27.9,54.76) 28,54.52 28,54.34 arc(27.96,54.14) 27.85,53.97 YJ22.D5
FC0_TDP1: length 278.1
  TOP w0.147: U1.CE35 195.55,171.34 v4(195.5,171.34)
  SIG7 w0.112: 196.24,172.84 196.24,172.81 196.15,172.72 196.15,172.19 arc(196.12,172.07) 196.05,171.97 arc(195.83,171.82) 195.57,171.77 195.27,171.77 arc(195.18,171.73) 195.15,171.64 195.15,171.51 arc(195.2,171.39) 195.31,171.34 v4(195.5,171.34)
  SIG7 w0.16: 196.24,172.84 196.24,173.16 arc(196.19,173.38) 196.07,173.56 195.96,173.67 arc(195.8,173.87) 195.71,174.11 arc(195.68,174.24) 195.68,174.36 195.68,176.81 arc(195.64,177.25) 195.52,177.67 arc(195.29,178.11) 194.98,178.49 193.37,180.1 189.4,184.07 arc(188.89,184.41) 188.3,184.53 158.77,184.53 arc(158.41,184.46) 158.1,184.25 154.14,180.29 arc(153.95,180.17) 153.74,180.12 142.04,180.12 arc(141.68,180.05) 141.38,179.85 99.48,137.95 arc(99.04,137.3) 98.87,136.53 98.87,135.89 arc(98.66,134.57) 98.09,133.36 arc(96.36,130.85) 94.55,128.39 arc(90.58,124.28) 85.79,121.16 arc(83.2,120.21) 80.45,119.89 67.5,119.89 arc(60.55,118.5) 54.66,114.57 48.33,108.24 arc(48.15,108.12) 47.93,108.07 44.09,108.07 arc(43.73,108) 43.42,107.8 29.93,94.31 arc(29.62,94.1) 29.25,94.03 28.99,94.03 arc(28.56,93.94) 28.2,93.7 21.63,87.16 20.13,85.67 arc(19.57,84.82) 19.37,83.82 19.37,76.62 arc(19.28,76.16) 19.02,75.78 12.88,69.64 arc(12.68,69.34) 12.61,68.98 12.61,58.61 arc(12.68,58.25) 12.88,57.94 15.54,55.29 arc(15.84,55.09) 16.2,55.01 27.99,55.01 arc(28.14,54.98) 28.26,54.9 28.35,54.81 28.39,54.77 arc(28.45,54.69) 28.5,54.59 arc(28.51,54.53) 28.51,54.48 28.51,54.16 arc(28.57,53.85) 28.75,53.58 28.92,53.42 29.08,53.26 arc(29.24,53.01) 29.3,52.72 YJ22.D3
FC0_TDP2: length 268.5
  TOP w0.147: U1.CB38 193.05,167.89 arc(192.92,168.21) v4(192.6,168.34)
  SIG6 w0.112: 193.85,173.62 193.85,173.6 193.95,173.51 193.95,169.15 arc(193.94,169.1) 193.91,169.06 193.86,169.01 arc(193.81,168.98) 193.77,168.97 193.27,168.97 arc(193.05,168.87) 192.95,168.64 192.95,168.47 arc(192.91,168.38) 192.82,168.34 v4(192.6,168.34)
  SIG6 w0.16: YJ22.D34 27.85,57.97 arc(27.96,58.14) 28,58.34 28,58.52 arc(27.9,58.76) 27.66,58.86 26.88,58.86 arc(26.47,58.94) 26.13,59.17 arc(25.88,59.34) 25.59,59.39 17.03,59.39 arc(16.74,59.45) 16.49,59.62 15.19,60.92 arc(15.08,61.09) 15.04,61.29 arc(15,61.49) 14.88,61.66 13.74,62.8 arc(13.57,63.05) 13.51,63.34 13.51,65.79 arc(13.68,66.64) 14.16,67.36 15.84,69.04 16.13,69.04 16.5,69.4 16.5,69.69 16.83,70.03 17.12,70.03 17.49,70.39 17.49,70.68 17.83,71.02 18.11,71.02 18.48,71.39 18.48,71.67 18.82,72.01 19.08,72.01 19.47,72.4 19.47,72.66 21.38,74.57 21.57,74.76 arc(21.91,75.28) 22.03,75.89 22.03,83.76 arc(22.09,84.05) 22.26,84.29 29.05,91.09 arc(29.3,91.25) 29.59,91.31 30.54,91.31 arc(30.9,91.38) 31.2,91.59 42.57,102.96 arc(42.75,103.08) 42.97,103.12 46.54,103.12 arc(46.9,103.19) 47.2,103.4 55.14,111.34 arc(55.33,111.46) 55.54,111.5 75.79,111.5 arc(81.89,112.72) 87.06,116.17 101.33,130.44 arc(101.58,130.81) 101.66,131.25 101.66,133.41 arc(101.72,133.7) 101.89,133.95 146.14,178.21 arc(146.39,178.37) 146.68,178.43 155.3,178.43 arc(155.74,178.52) 156.11,178.77 159.24,181.9 arc(159.42,182.02) 159.63,182.06 188.14,182.06 arc(188.43,182) 188.68,181.84 189.66,180.86 189.66,180.54 190,180.2 190.32,180.2 190.66,179.86 190.66,179.55 191,179.21 191.31,179.21 191.65,178.87 191.65,178.56 191.99,178.22 192.3,178.22 192.64,177.88 192.64,177.57 192.98,177.23 193.29,177.23 193.63,176.89 arc(193.8,176.64) 193.85,176.35 193.85,173.62
FC0_TDP3: length 269.4
  TOP w0.147: U1.CD37 193.55,170.34 v4(193.5,170.34)
  SIG7 w0.112: 194.25,173.61 194.25,173.58 194.16,173.49 194.16,171.21 arc(194.14,171.12) 194.1,171.04 arc(194.08,171.01) 194.06,170.98 193.98,170.9 arc(193.83,170.81) 193.66,170.77 193.34,170.77 arc(193.2,170.72) 193.15,170.58 193.15,170.51 arc(193.2,170.39) 193.31,170.34 v4(193.5,170.34)
  SIG7 w0.16: YJ22.D36 29.3,56.81 arc(29.26,57.02) 29.14,57.19 28.93,57.41 28.75,57.58 arc(28.57,57.85) 28.51,58.16 28.51,58.48 arc(28.51,58.53) 28.5,58.58 arc(28.5,58.59) 28.49,58.6 arc(28.45,58.69) 28.39,58.77 28.35,58.81 28.26,58.9 arc(28.14,58.98) 27.99,59.01 16.14,59.01 arc(15.78,59.09) 15.47,59.29 14.19,60.58 arc(13.98,60.88) 13.91,61.24 13.91,67.33 arc(13.98,67.69) 14.19,68 21.32,75.13 arc(21.57,75.5) 21.65,75.94 21.65,83.31 arc(21.82,84.16) 22.3,84.88 22.46,85.04 27.81,90.39 arc(28.36,90.75) 29,90.88 29.54,90.88 arc(29.95,90.96) 30.3,91.19 43.6,104.5 arc(43.91,104.7) 44.27,104.77 47.81,104.77 arc(48.02,104.82) 48.2,104.94 55.72,112.45 arc(61.42,116.26) 68.14,117.6 81.16,117.6 arc(87.87,118.93) 93.56,122.73 99.21,128.39 arc(100.74,130.68) 101.28,133.38 101.28,135.53 arc(101.52,136.73) 102.21,137.76 142.98,178.53 arc(143.29,178.73) 143.65,178.81 155.37,178.81 arc(155.58,178.85) 155.76,178.97 158.96,182.17 arc(159.27,182.37) 159.63,182.45 187.84,182.45 arc(188.2,182.37) 188.51,182.17 193.97,176.71 arc(194.18,176.4) 194.25,176.04 194.25,173.61
FC1_RDN0: length 257.6
  TOP w0.147: U1.BW40 191.05,164.89 arc(190.92,165.21) v4(190.6,165.34)
  SIG9 w0.112: v4(190.6,165.34) 190.82,165.34 arc(190.86,165.35) 190.9,165.37 190.92,165.4 arc(190.94,165.43) 190.95,165.47 190.95,165.67 arc(190.92,165.74) 190.85,165.77 190.4,165.77 arc(190.23,165.8) 190.09,165.9 190.06,165.93 arc(189.99,166.04) 189.96,166.16 189.96,173.54 189.87,173.63
  SIG9 w0.16: 189.87,173.63 189.87,176.89 arc(189.81,177.19) 189.64,177.45 183.18,183.92 arc(182.92,184.09) 182.61,184.15 161.81,184.15 arc(161.51,184.09) 161.25,183.92 156.11,178.77 arc(155.72,178.52) 155.27,178.43 149.64,178.43 arc(149.33,178.37) 149.07,178.19 104.06,133.18 arc(103.88,132.92) 103.82,132.61 103.82,130.03 arc(103.73,129.58) 103.48,129.19 86.64,112.36 arc(86.26,112.1) 85.81,112.01 59.45,112.01 arc(59.14,111.95) 58.88,111.78 39.91,92.8 arc(39.52,92.54) 39.07,92.45 32.35,92.45 arc(32.05,92.39) 31.79,92.22 28.85,89.28 28.85,88.99 28.49,88.63 28.2,88.63 27.84,88.27 27.84,87.99 27.48,87.63 27.2,87.63 26.84,87.27 arc(26.48,86.73) 26.35,86.1 26.35,80.65 26.56,80.45 26.56,79.94 26.35,79.74 26.35,79.23 26.56,79.03 26.56,78.52 26.35,78.32 26.35,77.81 26.56,77.61 26.56,77.1 26.35,76.89 26.35,76.4 arc(26.26,75.95) 26.01,75.57 25.66,75.22 25.66,74.93 25.3,74.57 25.01,74.57 24.65,74.21 24.65,73.93 24.29,73.57 24.01,73.57 23.65,73.21 23.65,72.92 23.29,72.56 23,72.56 21.78,71.34 arc(21.39,71.08) 20.94,70.99 20.08,70.99 arc(19.77,70.93) 19.51,70.76 15.94,67.19 arc(15.77,66.93) 15.71,66.62 15.71,64.57 arc(15.77,64.26) 15.94,64 16.31,63.63 arc(16.57,63.46) 16.88,63.39 18.39,63.39 arc(18.68,63.34) 18.93,63.17 19.09,63.02 arc(19.26,62.9) 19.46,62.86 20.46,62.86 arc(20.7,62.76) 20.8,62.52 20.8,62.34 arc(20.76,62.14) 20.65,61.97 YJ22.C14
FC1_RDN1: length 245.1
  TOP w0.147: U1.BU39 191.55,163.34 v4(191.5,163.34)
  SIG9 w0.112: 188.23,173.61 188.14,173.51 188.14,168.06 arc(188.15,168.02) 188.17,167.99 188.25,167.91 arc(188.28,167.89) 188.32,167.88 188.77,167.88 arc(188.88,167.86) 188.98,167.79 189.04,167.73 arc(189.11,167.63) 189.13,167.52 189.13,164.15 arc(189.14,164.11) 189.16,164.08 189.24,163.99 arc(189.28,163.97) 189.32,163.96 190.85,163.96 arc(191.06,163.88) 191.15,163.67 191.15,163.47 arc(191.18,163.38) 191.27,163.34 v4(191.5,163.34)
  SIG9 w0.16: YJ22.C24 19.7,64.7 arc(19.65,64.98) 19.51,65.23 arc(19.48,65.25) 19.46,65.27 19.15,65.58 arc(18.97,65.85) 18.91,66.16 18.91,68.01 arc(18.98,68.38) 19.19,68.68 arc(19.49,68.89) 19.86,68.96 24.47,68.96 arc(24.77,69.02) 25.03,69.19 38.84,83 arc(39.09,83.38) 39.18,83.82 39.18,89.2 arc(39.27,89.65) 39.53,90.04 40.29,90.8 59.63,110.14 arc(60.01,110.4) 60.47,110.49 86.82,110.49 arc(87.13,110.55) 87.39,110.72 105.37,128.7 arc(105.54,128.96) 105.6,129.27 105.6,131.82 arc(105.69,132.27) 105.95,132.65 126.94,153.64 150.44,177.14 arc(150.82,177.4) 151.27,177.49 156.9,177.49 arc(157.21,177.55) 157.47,177.72 159.6,179.86 161.84,182.1 arc(162.22,182.35) 162.67,182.44 181.73,182.44 arc(182.18,182.35) 182.56,182.1 188.05,176.61 arc(188.12,176.52) 188.18,176.42 arc(188.21,176.33) 188.22,176.24 arc(188.23,176.17) 188.23,176.11 188.23,173.61
FC1_RDN2: length 260.3
  TOP w0.147: v4(190.6,161.34) 190.69,161.34 arc(190.77,161.33) 190.84,161.28 190.91,161.21 arc(191.01,161.06) 191.05,160.88 U1.BR40
  SIG8 w0.112: v4(190.6,161.34) 190.85,161.34 arc(190.92,161.37) 190.95,161.44 190.95,161.67 arc(190.92,161.74) 190.85,161.77 190.26,161.77 arc(190.05,161.86) 189.96,162.07 189.96,173.47 189.87,173.56 189.87,173.59
  SIG8 w0.16: 189.87,173.59 189.87,174.39 arc(189.8,175.37) 189.6,176.32 arc(188.89,178) 187.77,179.45 183.43,183.79 arc(183.03,184.05) 182.56,184.15 161.81,184.15 arc(161.51,184.09) 161.25,183.91 155.6,178.27 arc(155.22,178.01) 154.77,177.92 149.12,177.92 arc(148.82,177.86) 148.56,177.69 104.06,133.19 arc(103.88,132.93) 103.82,132.63 103.82,130.17 arc(103.71,129.59) 103.37,129.09 86.64,112.36 arc(86.26,112.1) 85.81,112.01 59.45,112.01 arc(59.14,111.95) 58.88,111.78 50.96,103.85 arc(50.57,103.59) 50.12,103.5 43.45,103.5 arc(43.14,103.44) 42.88,103.27 34.51,94.89 arc(34.13,94.64) 33.67,94.55 31.07,94.55 arc(30.76,94.49) 30.5,94.31 23.87,87.68 arc(23.7,87.42) 23.63,87.12 23.63,86.03 arc(23.55,85.58) 23.29,85.2 22.27,84.18 arc(22.1,83.92) 22.03,83.61 22.03,79.96 22.24,79.75 22.24,79.25 22.03,79.04 22.03,78.53 22.24,78.33 22.24,77.82 22.03,77.62 22.03,77.11 22.24,76.91 22.24,76.4 22.03,76.2 22.03,75.69 arc(21.97,75.36) 21.78,75.08 21.74,75.03 21.74,74.68 21.37,74.32 21.02,74.32 20.66,73.96 20.66,73.6 20.3,73.24 19.94,73.24 19.58,72.88 19.58,72.52 19.22,72.16 18.86,72.16 18.5,71.8 18.5,71.44 18.14,71.08 17.78,71.08 15.84,69.14 arc(15.67,68.88) 15.61,68.58 15.61,64.59 arc(15.7,64.13) 15.96,63.74 16.53,63.17 16.76,62.94 arc(16.85,62.88) 16.95,62.86 18.04,62.86 arc(18.19,62.83) 18.32,62.74 arc(18.38,62.65) 18.4,62.54 18.4,62.35 arc(18.36,62.14) 18.25,61.97 YJ22.C17
FC1_RDN3: length 252.9
  TOP w0.147: U1.BN39 191.55,159.34 v4(191.5,159.34)
  SIG8 w0.112: 188.23,173.66 188.23,173.64 188.14,173.55 188.14,168.23 arc(188.2,167.92) 188.38,167.66 189,167.04 arc(189.11,166.88) 189.15,166.68 189.15,160.21 arc(189.17,160.12) 189.22,160.04 arc(189.3,159.99) 189.39,159.97 190.85,159.97 arc(191.06,159.88) 191.15,159.67 191.15,159.44 arc(191.18,159.37) 191.25,159.34 v4(191.5,159.34)
  SIG8 w0.16: YJ22.C21 17.3,64.74 arc(17.25,65.01) 17.09,65.24 16.67,65.67 arc(16.55,65.84) 16.51,66.05 16.51,67.43 arc(16.61,67.92) 16.88,68.32 16.98,68.43 17.36,68.81 arc(17.75,69.06) 18.2,69.15 18.55,69.15 arc(18.85,69.21) 19.11,69.39 25.57,75.84 arc(25.87,76.29) 25.97,76.82 25.97,86.41 arc(26.06,86.86) 26.32,87.24 29.47,90.39 arc(29.85,90.65) 30.3,90.74 36.98,90.74 arc(37.28,90.8) 37.54,90.97 47.69,101.12 arc(48.08,101.38) 48.53,101.47 53.71,101.47 arc(54.01,101.53) 54.27,101.7 62.71,110.14 arc(63.09,110.4) 63.55,110.49 86.82,110.49 arc(87.13,110.55) 87.39,110.72 104.72,128.05 105.23,128.56 arc(105.5,128.97) 105.6,129.46 105.6,131.81 arc(105.69,132.26) 105.95,132.65 149.17,175.87 arc(149.55,176.12) 150,176.21 155.62,176.21 arc(155.93,176.27) 156.19,176.45 161.84,182.1 arc(162.22,182.36) 162.68,182.45 181.55,182.45 arc(182.21,182.31) 182.77,181.94 183.98,180.73 185.18,179.53 186.57,178.14 arc(187.23,177.34) 187.74,176.43 arc(188.11,175.3) 188.23,174.11 188.23,173.66
FC1_RDP0: length 257.6
  TOP w0.147: U1.BW39 191.55,165.34 v4(191.5,165.34)
  SIG9 w0.112: v4(191.5,165.34) 191.28,165.34 arc(191.23,165.35) 191.19,165.38 191.18,165.38 arc(191.16,165.43) 191.15,165.47 191.15,165.67 arc(191.06,165.88) 190.85,165.96 190.4,165.96 arc(190.31,165.98) 190.23,166.04 190.2,166.07 arc(190.17,166.11) 190.16,166.16 190.16,173.53 190.25,173.63
  SIG9 w0.16: 190.25,173.63 190.25,176.89 arc(190.16,177.34) 189.91,177.72 183.45,184.18 arc(183.06,184.44) 182.61,184.53 161.81,184.53 arc(161.36,184.44) 160.98,184.18 158.35,181.56 155.84,179.04 arc(155.58,178.87) 155.27,178.81 149.64,178.81 arc(149.19,178.72) 148.81,178.46 123.76,153.42 103.79,133.45 arc(103.53,133.06) 103.44,132.61 103.44,130.03 arc(103.38,129.72) 103.21,129.46 86.37,112.63 arc(86.11,112.45) 85.81,112.39 59.45,112.39 arc(59,112.3) 58.61,112.05 39.64,93.07 arc(39.38,92.9) 39.07,92.83 32.35,92.83 arc(31.9,92.74) 31.52,92.49 26.57,87.54 arc(26.13,86.88) 25.97,86.1 25.97,76.4 arc(25.91,76.1) 25.74,75.84 21.51,71.61 arc(21.25,71.43) 20.94,71.37 20.08,71.37 arc(19.63,71.28) 19.24,71.03 15.68,67.46 arc(15.42,67.07) 15.33,66.62 15.33,64.57 arc(15.42,64.11) 15.68,63.73 16.05,63.36 arc(16.43,63.1) 16.88,63.01 18.39,63.01 arc(18.54,62.98) 18.66,62.9 18.74,62.83 18.75,62.81 18.79,62.77 arc(18.85,62.69) 18.89,62.6 arc(18.9,62.59) 18.9,62.59 arc(18.91,62.53) 18.91,62.48 18.91,62.16 arc(18.97,61.85) 19.15,61.58 19.48,61.25 arc(19.64,61.01) 19.7,60.73 YJ22.C15
FC1_RDP1: length 245.1
  TOP w0.147: U1.BU40 191.05,162.89 arc(190.92,163.21) v4(190.6,163.34)
  SIG9 w0.112: 187.85,173.61 187.94,173.51 187.94,168.06 arc(187.97,167.95) 188.03,167.85 188.11,167.77 arc(188.21,167.71) 188.32,167.68 188.77,167.68 arc(188.81,167.68) 188.84,167.65 188.91,167.59 arc(188.93,167.56) 188.93,167.52 188.93,164.15 arc(188.96,164.03) 189.02,163.94 189.11,163.85 arc(189.2,163.79) 189.32,163.77 190.85,163.77 arc(190.92,163.74) 190.95,163.67 190.95,163.47 arc(190.91,163.38) 190.82,163.34 v4(190.6,163.34)
  SIG9 w0.16: 187.85,173.61 187.85,176.11 arc(187.85,176.15) 187.84,176.19 arc(187.84,176.23) 187.82,176.27 arc(187.81,176.31) 187.78,176.34 182.29,181.83 arc(182.03,182) 181.73,182.06 162.67,182.06 arc(162.37,182) 162.11,181.83 157.74,177.46 arc(157.35,177.2) 156.9,177.11 151.27,177.11 arc(150.97,177.05) 150.71,176.87 106.22,132.38 arc(106.04,132.12) 105.98,131.82 105.98,129.27 arc(105.89,128.81) 105.64,128.43 87.66,110.45 arc(87.28,110.2) 86.82,110.11 60.47,110.11 arc(60.16,110.05) 59.9,109.87 39.8,89.77 arc(39.62,89.51) 39.56,89.2 39.56,83.82 arc(39.44,83.23) 39.11,82.73 29.59,73.21 29.59,72.91 29.13,72.45 28.83,72.45 28.41,72.03 28.41,71.65 28.08,71.32 27.69,71.32 27.33,70.96 27.33,70.57 27,70.24 26.62,70.24 26.26,69.88 26.26,69.49 25.92,69.16 25.54,69.16 25.3,68.92 arc(24.92,68.67) 24.47,68.58 24.13,68.58 23.85,68.3 23.4,68.3 23.12,68.58 22.61,68.58 22.33,68.3 21.87,68.3 21.59,68.58 21.12,68.58 20.84,68.3 20.41,68.3 20.13,68.58 19.86,68.58 arc(19.46,68.41) 19.29,68.01 19.29,67.2 arc(19.39,66.96) 19.63,66.86 20.44,66.86 arc(20.7,66.76) 20.8,66.5 20.8,66.34 arc(20.76,66.14) 20.65,65.97 YJ22.C25
FC1_RDP2: length 260.3
  TOP w0.147: v4(191.5,161.34) 191.55,161.34 U1.BR39
  SIG8 w0.112: v4(191.5,161.34) 191.25,161.34 arc(191.18,161.37) 191.15,161.44 191.15,161.67 arc(191.06,161.88) 190.85,161.97 190.26,161.97 arc(190.18,162) 190.16,162.07 190.16,173.47 190.25,173.56 190.25,173.59
  SIG8 w0.16: 190.25,173.59 190.25,174.39 arc(190.18,175.42) 189.97,176.43 arc(189.21,178.2) 188.04,179.72 183.7,184.06 arc(183.18,184.41) 182.56,184.53 161.81,184.53 arc(161.36,184.44) 160.98,184.18 155.33,178.54 arc(155.07,178.37) 154.77,178.31 149.12,178.31 arc(148.67,178.22) 148.29,177.96 103.79,133.46 arc(103.53,133.08) 103.44,132.63 103.44,130.17 arc(103.35,129.73) 103.1,129.36 86.37,112.63 arc(86.11,112.45) 85.81,112.39 59.45,112.39 arc(59,112.3) 58.61,112.05 50.69,104.12 arc(50.43,103.94) 50.12,103.88 43.45,103.88 arc(43,103.79) 42.61,103.54 34.24,95.16 arc(33.98,94.99) 33.67,94.93 31.07,94.93 arc(30.61,94.84) 30.23,94.58 23.6,87.95 arc(23.34,87.57) 23.25,87.12 23.25,86.03 arc(23.19,85.73) 23.02,85.47 22,84.45 arc(21.74,84.07) 21.65,83.61 21.65,75.69 arc(21.62,75.51) 21.51,75.35 15.57,69.41 arc(15.32,69.03) 15.23,68.58 15.23,64.59 arc(15.35,63.99) 15.69,63.47 16.35,62.82 16.39,62.77 arc(16.44,62.71) 16.48,62.64 arc(16.49,62.62) 16.49,62.61 arc(16.49,62.61) 16.49,62.6 arc(16.51,62.54) 16.51,62.48 16.51,62.07 arc(16.56,61.84) 16.69,61.65 16.93,61.41 17.05,61.29 arc(17.07,61.27) 17.09,61.24 arc(17.09,61.24) 17.09,61.24 arc(17.1,61.22) 17.11,61.21 arc(17.25,60.96) 17.3,60.68 YJ22.C18
FC1_RDP3: length 252.9
  TOP w0.147: v4(190.6,159.34) 190.69,159.34 arc(190.77,159.33) 190.84,159.28 190.91,159.21 arc(191.01,159.06) 191.05,158.88 U1.BN40
  SIG8 w0.112: 187.85,173.66 187.85,173.64 187.95,173.55 187.95,168.23 arc(188.02,167.85) 188.24,167.52 188.86,166.9 arc(188.93,166.8) 188.95,166.68 188.95,160.21 arc(188.98,160.04) 189.08,159.9 arc(189.22,159.8) 189.39,159.77 190.85,159.77 arc(190.92,159.74) 190.95,159.67 190.95,159.44 arc(190.92,159.37) 190.85,159.34 v4(190.6,159.34)
  SIG8 w0.16: 187.85,173.66 187.85,174.11 arc(187.74,175.22) 187.4,176.27 arc(186.92,177.12) 186.3,177.87 184.91,179.26 182.5,181.67 arc(182.06,181.96) 181.55,182.06 162.68,182.06 arc(162.37,182) 162.11,181.83 156.46,176.18 arc(156.07,175.92) 155.62,175.83 150,175.83 arc(149.69,175.77) 149.43,175.6 106.22,132.38 arc(106.04,132.12) 105.98,131.81 105.98,129.46 arc(105.86,128.83) 105.5,128.29 104.99,127.78 87.66,110.45 arc(87.28,110.2) 86.82,110.11 63.55,110.11 arc(63.24,110.05) 62.98,109.87 54.54,101.44 arc(54.16,101.18) 53.71,101.09 48.53,101.09 arc(48.22,101.03) 47.96,100.86 37.81,90.7 arc(37.43,90.45) 36.98,90.36 30.3,90.36 arc(30,90.3) 29.74,90.12 26.59,86.97 arc(26.41,86.71) 26.35,86.41 26.35,81.48 26.56,81.28 26.56,80.64 26.35,80.44 26.35,79.83 26.56,79.63 26.56,79.12 26.35,78.92 26.35,78.31 26.56,78.1 26.56,77.59 26.35,77.39 26.35,76.82 arc(26.22,76.15) 25.83,75.57 24.92,74.65 24.92,74.3 24.56,73.94 24.2,73.94 23.84,73.58 23.84,73.22 23.48,72.86 23.12,72.86 22.76,72.5 22.76,72.14 22.4,71.78 22.04,71.78 21.68,71.42 21.68,71.06 21.32,70.7 20.97,70.7 20.61,70.34 20.61,69.98 20.25,69.62 19.89,69.62 19.38,69.12 arc(19,68.86) 18.55,68.77 18.2,68.77 arc(17.89,68.71) 17.63,68.54 17.25,68.16 17.15,68.05 arc(16.96,67.77) 16.89,67.43 16.89,67.12 arc(16.97,66.94) 17.15,66.86 17.9,66.86 arc(18.12,66.82) 18.3,66.69 18.31,66.69 arc(18.38,66.58) 18.4,66.45 18.4,66.34 arc(18.36,66.14) 18.25,65.97 YJ22.C22
FC1_TDN0: length 255.5
  TOP w0.147: v4(193.5,172.34) 193.55,172.34 U1.CF37
  SIG7 w0.112: v4(193.5,172.34) 193.31,172.34 arc(193.2,172.39) 193.15,172.51 193.15,172.59 arc(193.03,172.86) 192.76,172.97 192.4,172.97 arc(192.34,172.99) 192.28,173.02 192.18,173.13 arc(192.17,173.14) 192.16,173.15 arc(192.14,173.18) 192.14,173.22 192.14,173.53 192.23,173.62 192.23,173.65
  SIG7 w0.16: YJ22.C6 26.9,60.75 arc(26.85,61.01) 26.7,61.24 26.35,61.58 arc(26.17,61.85) 26.11,62.16 26.11,62.48 arc(26.11,62.53) 26.1,62.57 arc(26.09,62.59) 26.09,62.61 arc(26.05,62.7) 25.99,62.77 25.95,62.81 25.86,62.9 arc(25.74,62.98) 25.59,63.01 16.58,63.01 arc(16.22,63.09) 15.92,63.29 15.49,63.72 arc(15.28,64.02) 15.21,64.38 15.21,65.68 arc(15.28,66.04) 15.49,66.35 25.53,76.39 arc(25.86,76.88) 25.97,77.46 25.97,85.15 arc(26.06,85.59) 26.31,85.96 28.08,87.73 arc(28.38,87.94) 28.74,88.01 34.35,88.01 arc(34.56,88.05) 34.74,88.17 58.69,112.12 arc(58.99,112.32) 59.35,112.39 85.91,112.39 arc(86.12,112.44) 86.3,112.56 103.28,129.53 arc(103.4,129.71) 103.44,129.93 103.44,135.66 arc(103.51,136.02) 103.72,136.32 144.61,177.21 arc(144.91,177.42) 145.27,177.49 157,177.49 arc(157.21,177.53) 157.39,177.65 159.83,180.09 arc(160.13,180.29) 160.49,180.36 186.88,180.36 arc(187.24,180.29) 187.54,180.09 191.96,175.67 arc(192.16,175.37) 192.23,175.01 192.23,173.65
