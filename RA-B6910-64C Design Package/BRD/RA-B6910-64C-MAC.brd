# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INTL58: length 154.6
  TOP w0.13: R2848.1 323.66,85.19 323.66,85.72 v1(323.15,86.23) ; U124.P8 v1(401.22,176.05)
  SIG10 w0.155: v1(323.15,86.23) 321.88,87.5 321.88,90.94 329.71,98.78 372.5,98.78 374.1,100.38 374.1,127.18 375.14,128.21 375.14,134.03 375.98,134.88 375.98,140.44 378.03,142.49 378.03,148.13 379.38,149.48 381.4,149.48 383.69,151.76 386.14,151.76 400.26,165.89 400.26,169.06 401.51,170.3 401.51,175.75 v1(401.22,176.05)
  BOTTOM w0.13: v1(323.15,86.23) 323.08,86.31 v2(323.08,87.12)
INTL59: length 168.1
  TOP w0.13: v1(404.15,171.96) 404.61,172.41 404.61,173.78 404.82,173.99 U124.T12
  SIG10 w0.155: v1(404.15,171.96) 404.11,171.91 404.11,171.29 403.85,171.03 403.85,164.3 386.67,147.12 384.12,147.12 383.35,146.34 383.35,142.56 379.94,139.15 379.94,134.13 380.4,133.66 380.4,131.31 379.55,130.46 379.55,127.13 377.79,125.37 377.79,116.26 378.59,115.46 378.59,110.54 378.23,110.18 378.23,109.49 378.74,108.98 378.74,92.55 373.34,87.16 369.2,87.16 368.66,86.61 363.56,86.61 356.34,93.83 347.88,93.83 346.5,92.45 343.65,92.45 343.22,92.89 331.38,92.89 328.1,89.61 328.1,83.31 v1(325.18,80.39)
  BOTTOM w0.13: R2850.2 324.52,78.84 324.68,78.99 324.68,79.88 v1(325.18,80.39) v2(326.07,81.28)
INTL60: length 140.1
  TOP w0.13: R2886.1 356.45,78.84 356.3,78.99 356.3,79.22 355.79,79.73 v1(355.79,80.52) ; v1(407.61,172.97) 407.61,173.83 406.82,174.62 406.82,175.25 U124.R14
  SIG10 w0.155: v1(355.79,80.52) 356.35,81.08 362.89,81.08 363.48,80.49 364.23,80.49 364.69,80.03 366.75,80.03 367.97,81.25 370.23,81.25 370.59,81.61 376.41,81.61 382.11,87.31 382.88,87.31 384.43,88.86 384.43,97.22 391.64,104.42 400.92,104.42 405.66,109.16 405.66,142.78 407.98,145.09 407.98,170.97 408.11,171.11 408.11,172.46 v1(407.61,172.97)
  BOTTOM w0.13: v1(407.61,172.97) 408.11,172.46 v2(408.11,171.07)
INTL61: length 145.4
  TOP w0.13: U124.P11 v1(404.42,176.05)
  SIG10 w0.155: v1(404.42,176.05) 404.42,175.77 406.12,174.07 406.12,170.05 406.55,169.63 406.55,160.4 v1(403.08,156.93) 401.6,156.93 398.5,153.84 398.5,152.36 393.88,147.74 391.25,147.74 388.77,145.26 388.77,141.69 387.22,140.14 384.9,140.14 383.66,138.9 383.66,125.58 382.85,124.78 382.85,93.79 381.64,92.58 381.64,88.82 375.83,83 369.93,83 369.59,82.66 366.61,82.66 366.42,82.47 365.76,82.47 364.7,83.53 361.53,83.53 360.43,84.63 357.05,84.63 356.7,84.99 354.06,84.99 352.56,83.48 349.89,83.48 347.28,80.87 347.28,80.13 v1(346.65,79.5)
  BOTTOM w0.13: R2889.2 345.99,78.84 v1(346.65,79.5)
INTL62: length 125.6
  TOP w0.13: U124.G5 v1(398.82,182.45)
  SIG8 w0.102: v1(398.82,182.45) 398.42,182.05 398.42,181.18 398.21,180.97 397.57,180.97
  SIG8 w0.155: v1(371.41,80.52) 372.05,81.15 372.05,85.66 376.68,90.3 376.68,96.2 370.65,102.23 370.65,129.79 369.89,130.55 369.89,143.42 378.7,152.23 382.26,152.23 391.6,161.57 391.6,172.72 392.11,173.23 392.11,176.91 392.75,177.54 392.75,178.18 393,178.43 394.4,178.43 396.94,180.97 397.57,180.97
  BOTTOM w0.13: R2887.1 370.14,79.63 v2(370.65,80.13) 371.03,80.52 v1(371.41,80.52)
INTL63: length 117.5
  TOP w0.13: R2890.2 374.59,78.99 376.11,80.52 v1(376.62,80.52) ; U124.N6 v1(399.62,176.85)
  SIG8 w0.102: 399.22,175.76 399.22,176.45 v1(399.62,176.85)
  SIG8 w0.155: 399.22,175.76 399.22,175.75 399.22,175.39 397.32,173.48 397.32,164.5 382.04,149.22 378.64,149.22 373.82,144.41 373.82,137.67 372.68,136.52 372.68,103.88 379.16,97.4 379.16,83.06 v1(376.62,80.52)
  BOTTOM w0.13: v2(375.86,80.26) 376.11,80.52 v1(376.62,80.52)
IP_BSC_SCL0: length 76.2
  TOP w0.13: R7.2 R15.2 256.6,167.89 v1(256.35,167.64) ; v1(246.32,181.1) 246.32,179.96 241.24,174.88 238.32,174.88 237.81,174.37 237.81,173.07 238.13,172.74 R2074.1 238.82,172.08 238.44,171.7 237.93,171.7 v1(236.82,170.58) ; U1.BK18 v1(213.55,156.34)
  SIG7 w0.155: v1(236.82,170.58) 236.51,170.89 226.2,170.89 226.12,170.81 219.27,170.81 219.01,170.56 219.01,164.08 218.76,163.83 216.34,163.83 216.09,163.57 216.09,158.88 v1(213.55,156.34)
  SIG10 w0.155: v1(256.35,167.64) 255.46,167.64 255.21,167.89 255.21,172.84 246.95,181.1 v1(246.32,181.1)
IP_BSC_SCL1: length 1.4
  TOP w0.13: U1.BL25 v1(206.55,157.34)
  BOTTOM w0.13: R2075.1 206.06,157.83 v1(206.55,157.34)
IP_BSC_SCL2: length 1.4
  TOP w0.13: U1.BM24 v1(207.55,158.34)
  BOTTOM w0.13: R2076.1 207.53,158.34 v1(207.55,158.34)
IP_BSC_SDA0: length 91
  TOP w0.13: v1(240.98,170.58) 240.35,171.22 R2071.1 241.39,172.74 247.71,179.07 v1(247.71,183.26) ; R9.2 R16.2 255.21,168.4 255.33,168.27 v1(255.71,168.27) ; U1.BM25 v1(206.55,158.34)
  SIG6 w0.155: v1(240.98,170.58) 240.07,169.67 233.11,169.67 232.22,168.78 224.37,168.78 224.09,168.5 224.09,167.13 223.76,166.8 222.24,166.8 222,166.56 222,166.18 221.68,165.86 221.3,165.86 221.04,165.61 221.04,165.22 220.66,164.84 220.28,164.84 220.03,164.59 220.03,164.21 219.65,163.83 219.27,163.83 219.01,163.57 219.01,163.04 218.78,162.81 218.25,162.81 218,162.56 218,162.18 217.74,161.92 217.23,161.92 216.98,161.67 216.98,161.16 216.6,160.78 216.22,160.78 215.07,159.64 215.07,158.37 214.06,157.35 214.06,153.16 213.68,152.78 207.33,152.78 207.13,152.98 207.13,157.76 v1(206.55,158.34)
  SIG10 w0.155: v1(247.71,183.26) 247.71,181.11 255.71,173.11 v1(255.71,168.27)
IP_BSC_SDA1: length 1.4
  TOP w0.13: U1.BK25 v1(206.55,156.34)
  BOTTOM w0.13: R2072.1 207.02,156.82 v1(206.55,156.34)
IP_BSC_SDA2: length 1.4
  TOP w0.13: U1.BM19 v1(212.55,158.34)
  BOTTOM w0.13: R2073.1 213.03,158.82 v1(212.55,158.34)
IP_PLL_AVDD1P8: length 5.5
  TOP w0.229: U1.BL32 v1(198.55,157.34)
  TOP w0.381: 176.72,190.27 C79.1 ; C79.1 176.12,190.9 ; C79.1 177.32,190.9
  TOP w0.508: 174.69,190.24 L422.1 175.55,190.9
  BOTTOM w0.229: C80.1 199.03,157.83 v1(198.55,157.34)
  BOTTOM w0.381: v1(175.83,189.74) v2(175.83,190.5)
  vias: v1(176.72,189.74)
IREF1: length 2851.1
  TOP w0.178: U140.31 381.7,167.46 381.9,167.66 C3941.2 ; 380.45,164.68 380.45,164.89 380.29,165.06 U140.25 ; 381.57,170.56 381.57,170.05 380.58,169.06 U140.35 ; 381.29,168.37 381.17,168.26 380.86,168.26 U140.33 ; 381.76,166.43 381.54,166.66 U140.29 ; 381.44,165.1 381.44,165.35 380.94,165.86 U140.27
  TOP w0.229: D441.30 348.79,133.63 349.15,133.27 C3885.1 ; C3862.1 66.94,183.36 67.31,183 D440.30 ; D436.30 67.31,142.36 66.94,142.72 C3816.1 ; D435.30 67.31,132.2 66.94,132.56 C3815.1 66.28,132.15 66.03,131.9 64,131.9 63.06,132.84 63.06,136.65 60.67,139.04 v1(60.39,139.04) C3800.1 ; D442.30 348.97,143.79 349.33,143.43 C3884.1 349.81,143.84 350.17,144.19 351.76,144.19 353.2,142.76 353.2,140.39 354.12,139.47 v1(354.29,139.47) C3869.1 ; D438.30 67.31,162.68 66.94,163.04 C3839.1 ; C3930.1 349.15,173.91 348.79,174.27 D446.30 ; 63.3,153.15 64.33,152.12 65.93,152.12 66.28,152.47 C3838.1 66.94,152.88 67.31,152.52 D437.30 ; C3907.1 349.1,163.75 348.74,164.11 D443.30 ; D445.30 348.84,184.43 349.2,184.07 C3931.1 349.81,184.48 350.07,184.73 351.86,184.73 352.79,183.8 ; C3908.1 349.33,153.59 348.97,153.95 D444.30 ; D439.30 67.31,172.84 66.94,173.2 C3861.1 66.28,172.79 65.93,172.44 64.33,172.44 63.3,173.47
  TOP w0.254: v1(386.35,165.48) 385.76,166.06 384.06,166.06 v1(383.58,165.58) C3944.2 382.61,165.58 381.76,166.43 ; 63.3,153.15 62.9,153.55 62.9,157.43 60.97,159.36 v1(60.24,159.36) C3823.1 ; R3642.1 354.32,182.14 v1(354.29,182.12) ; C3916.1 354.44,176.04 v1(354.29,175.89) 354.29,175.54 353.58,174.83 350.3,174.83 349.81,174.34 C3930.1 ; v1(354.27,157.76) R3640.1 ; R3612.1 60.24,141.07 v1(60.26,141.09) ; 352.79,183.8 353.27,183.33 353.27,181.34 354.27,180.34 v1(354.27,180.11) C3915.1 ; C3893.1 v1(354.29,155.72) 354.29,155.22 353.5,154.43 350.22,154.43 349.81,154.02 C3908.1 ; v1(383.88,170.79) 383.6,170.51 383.6,170.13 383.3,169.82 C3939.2 382.74,169.82 381.93,169.01 381.29,168.37 ; C3941.2 v1(383.58,167.66) 383.58,168.12 383.78,168.32 387.11,168.32 387.41,168.02 387.41,167.38 v1(388.05,166.75) ; C3824.1 v1(60.29,163.42) 63.21,163.42 64.3,162.33 66,162.33 66.28,162.61 C3839.1 ; v1(380.17,184.53) 380.17,183.77 383.98,179.96 v1(383.98,177.04) 382.21,175.26 382.21,174.62 382.71,174.11 v1(382.71,173.99) 382.71,172.08 382.33,171.7 C3938.2 381.88,170.86 381.57,170.56 ; C3892.1 354.37,159.79 v1(354.24,159.91) 353.12,161.03 353.12,163.07 351.68,164.51 350.13,164.51 349.81,164.2 C3907.1 ; C3846.1 v1(60.29,179.68) 60.97,179.68 62.9,177.75 62.9,173.87 63.3,173.47 ; R3635.1 354.36,161.82 v1(354.23,161.69) ; v1(60.26,161.64) 60.24,161.64 59.98,161.39 R3619.1 ; C3801.1 v1(60.26,143.1) 62.07,143.1 63.18,141.98 65.98,141.98 66.28,142.29 C3816.1 ; R3633.1 354.56,137.44 v1(354.28,137.16) ; R3614.1 v1(60.24,157.33) ; C3885.1 349.81,133.72 350.28,134.19 353.23,134.19 v1(354.29,135.25) 354.44,135.4 C3870.1 ; v1(354.29,177.74) 354.62,178.08 R3647.1 ; R3628.1 v1(354.29,141.5) ; R3626.1 v1(60.24,181.71) ; v1(389.82,168.78) 389.82,168.78 388.94,168.78 388.56,168.4 388.56,167.79 389.19,167.15 389.19,166.37 385.64,162.81 v1(383.48,162.81) 383.12,162.81 382.87,163.07 C3946.2 382.59,163.32 381.44,164.46 381.44,165.1 ; C3847.1 v1(60.24,183.74) 61.94,183.74 63.03,182.65 66,182.65 66.28,182.93 C3862.1 ; R3621.1 v1(60.29,177.65) ; 380.45,164.68 380.45,164.03 382.23,162.25 382.23,161.8 C3947.2 383.63,160.4 v1(385.13,160.4) 387.67,160.4 388.81,161.54 v1(389.95,161.54) ; R3607.1 v1(60.36,137.01)
  SIG7 w0.254: v1(354.29,175.89) 354.29,176.07 353.76,176.6 353.76,177.21 v1(354.29,177.74) 354.45,177.74 356.85,175.35 369.97,175.35 370.84,176.21 375.16,176.21 375.77,175.6 375.77,174.89 376.82,173.84 378.04,173.84 379.34,172.54 386.06,172.54 v1(389.82,168.78) ; v1(386.35,165.48) 385.76,164.89 385.76,155.68 382.68,152.6 376.33,152.6 369.98,146.25 365.39,146.25 360.87,141.73 355.66,141.73 355.16,141.22 354.57,141.22 v1(354.29,141.5) 353.76,140.97 353.76,140 v1(354.29,139.47) ; v1(354.29,135.25) 353.81,135.74 353.81,136.68 v1(354.28,137.16) 354.55,136.89 355.77,136.89 356.9,135.76 360.87,135.76 361.89,136.78 361.89,140.28 366.28,144.67 370.63,144.67 376.98,151.02 383.33,151.02 387.57,155.26 387.57,163.85 388.18,164.46 388.18,166.49 388.05,166.62 v1(388.05,166.75) ; v1(354.24,159.91) 353.63,160.53 353.63,161.29 354.04,161.69 v1(354.23,161.69) 355.94,161.69 358.33,164.08 373.44,164.08 374.15,164.79 382.79,164.79 v1(383.58,165.58) ; v1(383.48,162.81) 383.35,162.68 377.51,162.68 376.75,161.92 374.33,161.92 373.8,162.46 361.79,162.46 361,161.67 361,157.73 359.73,156.46 355.66,156.46 354.37,157.76 v1(354.27,157.76) 354.16,157.76 353.63,157.22 353.63,156.38 v1(354.29,155.72) ; v1(354.27,180.11) 353.76,180.62 353.76,181.58 v1(354.29,182.12) 355.66,180.74 355.66,178.79 357.42,177.04 369.27,177.04 370.05,177.81 374.22,177.81 375.32,178.92 379.16,178.92 379.44,179.19 384.75,179.19 385.76,178.18 385.76,175.77 387.44,174.09 388.69,174.09 391.99,170.79 391.99,162.68 390.97,161.67 390.08,161.67 v1(389.95,161.54)
  SIG8 w0.254: v1(60.24,181.71) 60.9,182.37 60.9,183.08 v1(60.24,183.74) 60.85,184.35 60.85,191.34 65.04,195.54 154.07,195.54 164.14,205.61 210.84,205.61 215.79,200.66 279.54,200.66 291.08,189.13 321.7,189.13 326.88,194.31 358.65,194.31 362.51,190.45 362.51,185.3 366.19,181.62 369.52,181.62 382.73,168.41 382.73,168.41 383.47,167.66 v1(383.58,167.66) ; v1(383.88,170.79) 382.88,170.79 378.88,174.79 378.88,176.3 376.83,178.34 375.02,178.34 369.46,183.9 366.96,183.9 364.93,185.93 364.93,191.26 360.11,196.09 326.14,196.09 321.32,191.26 291.46,191.26 280.28,202.44 216.53,202.44 211.58,207.39 163.4,207.39 153.46,197.44 64.16,197.44 59.13,192.42 59.13,185.18 58.48,184.53 58.48,182.75 59.04,182.19 59.04,180.67 60.03,179.68 v1(60.29,179.68) 60.9,179.07 60.9,178.25 v1(60.29,177.65) ; v1(60.29,163.42) 60.24,163.42 ; 60.24,163.42 60.82,162.84 60.82,162.23 60.24,161.64 v1(60.26,161.64) ; 60.24,163.42 59.5,164.16 59.5,169.66 51.5,177.66 51.5,187.28 63.39,199.17 68.95,199.17 69.15,198.97 75.84,198.97 75.97,199.1 152.6,199.1 162.67,209.16 212.31,209.16 217.26,204.21 281.02,204.21 291.94,193.29 320.84,193.29 325.41,197.86 361,197.86 367.37,191.5 367.37,188.66 368.32,187.71 370.8,187.71 371.31,187.2 371.31,184.29 375.67,179.92 378.59,179.92 380.48,178.03 380.48,177.13 382.08,175.53 382.08,174.62 v1(382.71,173.99)
  SIG9 w0.254: v1(380.17,184.53) 380.17,184.91 366.71,198.37 325.2,198.37 320.75,193.93 292.02,193.93 281.23,204.72 217.47,204.72 212.52,209.67 162.46,209.67 152.39,199.6 74.31,199.6 74.16,199.46 69,199.46 68.86,199.6 63.11,199.6 50.99,187.49 50.99,153.83 60.26,144.57 v1(60.26,143.1) 59.75,142.59 59.75,141.6 v1(60.26,141.09) ; v1(382.71,173.99) 383.22,174.5 383.22,175.21 382.8,175.64 381.83,175.64 380.7,176.76 380.7,177.82 375.51,183 369.13,183 365.7,186.43 365.7,188.97 360.36,194.31 326.88,194.31 321.8,189.23 290.97,189.23 279.54,200.66 215.79,200.66 210.84,205.61 164.14,205.61 154.24,195.7 65.21,195.7 59.12,189.61 59.12,161.06 59.5,160.68 59.5,160.09 v1(60.24,159.36) 60.77,158.82 60.77,157.86 v1(60.24,157.33) ; v1(60.36,137.01) 59.88,137.49 59.88,138.53 v1(60.39,139.04) 60.74,138.68 61.28,138.68 62.42,139.82 62.42,145.45 52.77,155.1 52.77,186.63 64.1,197.95 153.25,197.95 163.19,207.89 211.79,207.89 216.74,202.94 280.49,202.94 291.54,191.89 321.24,191.89 325.93,196.59 365.95,196.59 377.38,185.16 377.38,184.4 383.1,178.69 383.1,177.92 v1(383.98,177.04)
  BOTTOM w0.254: v1(382.71,173.99) 383.88,172.82 v2(383.88,171.96) v1(383.88,170.79) 383.58,170.48 v1(383.58,167.66) v1(383.58,165.58) 383.58,162.91 v1(383.48,162.81) 383.48,162.05 v1(385.13,160.4)
  BOTTOM w0.381: C3945.1 378.42,172.82 378.4,172.84 R3670.1 377.74,173.25 376.49,174.5 376.49,175.51 378.14,177.16 381.44,177.16 383.35,175.26 383.35,174.62 v1(382.71,173.99)
ISL68127_PG0: length 61.7
  TOP w0.13: v1(410.78,180.36) 410.34,179.92 409.6,179.92 409.33,179.65 U124.K16 ; U140.16 376.25,163.89 375.63,163.27 375.63,160.09 R3654.1 374.66,159.59 374.57,159.49 374.57,158.13 374.74,157.96 v1(375.09,157.96)
  SIG9 w0.155: v1(410.78,180.36) 410.24,179.82 410.24,172.68 406.72,169.16 405.07,169.16 404.18,168.27 404.18,166.62 396.3,158.74 375.88,158.74 v1(375.09,157.96)
  BOTTOM w0.13: v2(375.09,158.75) v1(375.09,157.96)
ISL68127_PG1: length 66.4
  TOP w0.13: v1(376.14,163.07) 376.26,162.94 R3656.1 ; U124.J15 407.62,180.05 409.27,180.05 409.59,180.36 v1(409.77,180.36) ; R3649.2 v1(371.92,160.75)
  TOP w0.14: U140.17 376.65,163.58 v1(376.14,163.07)
  SIG9 w0.155: v1(371.92,160.75) 373.55,159.13 395.99,159.13 403.64,166.78 403.64,168.5 404.69,169.54 406.09,169.54 408.11,171.57 408.11,173.35 408.98,174.21 408.98,179.57 v1(409.77,180.36)
  BOTTOM w0.254: v1(371.92,160.75) R3505.2 372.53,163.47 373.06,162.94 v2(373.06,162.56) 373.57,162.05 375.12,162.05 v1(376.14,163.07)
ISL68127_SALRT: length 73.5
  TOP w0.13: U124.H14 v1(406.82,181.65) ; U140.20 377.85,163.23 377.61,162.99 R3660.1 377.92,162.41 378.14,162.19 378.14,161.01 378.4,160.75 v1(378.65,160.75)
  SIG9 w0.155: v1(378.65,160.75) 379.95,162.05 384.24,162.05 385.25,163.07 397.95,163.07 401.61,166.72 401.61,168.65 403.8,170.85 404.97,170.85 405.67,171.55 405.67,174.09 407.48,175.89 407.48,180.98 v1(406.82,181.65)
  BOTTOM w0.13: v1(406.82,181.65) 408.03,181.65 408.8,182.42 410.96,182.42 411.16,182.62 411.8,182.62 412.31,183.13 414.72,183.13 415.43,183.84 415.94,183.84 416.29,184.2 416.29,187.91 v2(410.78,193.42) 409.87,194.33 R3503.1
ISL68127_TWARN: length 59
  TOP w0.13: R3651.1 v1(375.12,163.09) 375.12,163.22 375.85,163.95 U140.15 ; U124.H16 408.9,181.25 409.16,181.51 410.32,181.51 v1(410.78,181.96)
  SIG9 w0.155: v1(410.78,181.96) 410.17,181.35 409.51,181.35 408.37,180.21 408.37,175.13 407.1,173.86 407.1,171.57 405.45,169.93 404.18,169.93 402.53,168.27 402.53,166.32 396.61,160.4 388.05,160.4 387.54,160.91 381.67,160.91 380.56,159.79 377.36,159.79 375.12,162.02 v1(375.12,163.09)
  BOTTOM w0.13: v1(375.12,163.09) 374.61,163.09 v2(374.33,162.81)
JTAG_EN: length 26.9
  BOTTOM w0.13: U119.19 19.86,187.59 20.38,187.07 27.24,187.07 27.74,187.57 U120.19 27.74,189.98 28.51,190.75 R3227.2 28.89,191.41 29.15,191.67 29.15,193.29 29.53,193.67 31.69,193.67 v2(32.32,193.04) 32.83,192.53 32.83,188.97 33.72,188.08 Q40.3
LED_CLK0: length 42.6
  TOP w0.13: U1.BJ48 v1(182.55,155.34) ; R3306.1 155.89,167.64 v1(157.04,166.49)
  SIG9 w0.155: v1(182.55,155.34) 182.55,155.71 182.05,156.21 182.05,159.51 181.78,159.79 181.27,159.79 181.04,160.02 181.04,163.57 180.78,163.83 179.39,163.83 179.01,164.21 179.01,167.76 178.88,167.89 173.16,167.89 173.04,168.02 173.04,168.78 172.96,168.86 164.35,168.86 162.62,167.13 157.67,167.13 v1(157.04,166.49)
  BOTTOM w0.13: v1(157.04,166.49) v2(157.04,167.26)
LED_CLK1: length 41
  TOP w0.13: U1.BM15 v1(216.55,158.34) ; R3301.1 214.19,186.26 v1(214.64,185.8)
  SIG9 w0.155: v1(216.55,158.34) 216.98,158.77 216.98,162.66 216.77,162.86 209.31,162.86 209.11,163.07 209.11,179.96 214.64,185.49 v1(214.64,185.8)
  BOTTOM w0.13: v1(214.64,185.8) v2(213.88,185.8)
LED_CLK2: length 45.2
  TOP w0.13: R3393.2 v1(203.01,189.1) ; U1.BL21 v1(210.55,157.34)
  SIG5 w0.155: v1(203.01,189.1) 200.12,186.21 200.12,169.64 201.1,168.65 201.1,163.07 201.36,162.81 201.74,162.81 201.99,162.56 201.99,157.1 202.25,156.84 U1.BL21 v1(210.55,157.34)
  BOTTOM w0.13: v1(203.01,189.1) v2(203.77,189.1)
LED_CLK3: length 63.1
  TOP w0.13: U1.BK46 v1(184.55,156.34) ; R3398.2 v1(206.44,188.47)
  SIG3 w0.152: v1(206.44,188.47) 206.44,184.15 203.8,181.51 201.76,181.51 199.81,179.56 199.81,170.24 201.1,168.94 201.1,168.15 201.43,167.82 201.82,167.82 202.1,167.54 202.1,153.16 201.84,152.91 188.28,152.91 188.02,153.16 188.02,153.54 187.77,153.79 187.26,153.79 187.01,154.05 187.01,154.56 186.75,154.81 186.25,154.81 185.99,155.06 185.99,155.57 185.74,155.83 185.06,155.83 v1(184.55,156.34)
  BOTTOM w0.13: v1(206.44,188.47) v2(205.88,189.02)
LED_DATA0: length 41.3
  TOP w0.13: v1(216.47,185.8) 215.33,186.94 R3308.1 ; U1.BJ23 v1(208.55,155.34)
  SIG9 w0.155: v1(216.47,185.8) 215.96,186.31 214.31,186.31 207.71,179.7 207.71,177.52 208.09,177.14 208.09,175 207.07,173.99 207.07,168.02 207.33,167.76 207.84,167.76 208.09,167.51 208.09,155.83 208.55,155.37 v1(208.55,155.34)
  BOTTOM w0.13: v1(216.47,185.8) v2(216.47,186.56)
LED_DATA1: length 39.3
  TOP w0.13: v1(155.64,168.65) 155.23,169.06 R3304.1 ; U1.BK49 v1(181.55,156.34)
  SIG9 w0.155: v1(155.64,168.65) 155.64,166.88 156.65,165.86 160.36,165.86 161.18,166.67 163.31,166.67 163.51,166.88 169.99,166.88 170.12,166.75 170.12,166.11 170.35,165.88 175.78,165.88 176.03,165.63 176.03,165.02 176.21,164.84 177.74,164.84 177.99,164.59 177.99,164.08 178.24,163.83 178.88,163.83 179.01,163.7 179.01,161.29 180.53,159.76 180.78,159.76 181.04,159.51 181.04,156.85 v1(181.55,156.34)
  BOTTOM w0.13: v1(155.64,168.65) v2(155.64,169.42)
LED_DATA2: length 53.6
  TOP w0.13: U1.BK45 v1(185.55,156.34) ; v1(200.6,190.62) 201.36,189.86 201.36,189.1 201.87,188.59 203.64,188.59 204.15,189.1 R3392.2
  SIG9 w0.155: v1(185.55,156.34) 186.05,156.84 195.77,156.84 196.02,157.1 196.02,164.56 197.07,165.61 197.42,165.61 198.06,166.24 198.06,173.35 198.18,173.48 198.18,188.21 v1(200.6,190.62)
  BOTTOM w0.13: v1(200.6,190.62) v2(199.83,190.62)
LED_DATA3: length 49.2
  TOP w0.13: v1(200.6,189.61) 200.6,189.35 201.74,188.21 204.41,188.21 205.3,189.1 R3397.2 ; U1.BK41 v1(189.55,156.34)
  SIG8 w0.155: v1(189.55,156.34) 190,156.79 195.62,156.79 196.08,157.25 196.08,185.09 v1(200.6,189.61)
  BOTTOM w0.13: v2(199.83,189.35) 200.09,189.61 v1(200.6,189.61)
LINKACT0: length 141.3
  TOP w0.13: U123.J4 v1(20.85,158.2) ; D363.4 15.35,48.34 15.05,48.64 12.64,48.64 v1(11.87,49.4) ; R2967.1 v1(4.64,51.81)
  SIG1 w0.152: v1(11.87,49.4) 10.59,50.68 10.59,51.24 9.26,52.58 5.4,52.58 v1(4.64,51.81)
  SIG7 w0.102: 19.33,157.57 19.56,157.8 20.45,157.8 v1(20.85,158.2)
  SIG7 w0.155: v1(4.64,51.81) 3.8,52.65 3.8,78.99 9.91,85.1 9.91,86.8 14.99,91.88 14.99,93.53 15.63,94.18 18.43,94.18 21.27,97.03 21.91,97.03 22.8,97.91 22.8,99.44 23.81,100.45 25.21,100.45 28.77,104.01 28.77,128.2 21.78,135.18 21.78,143.13 19.17,145.74 19.17,151.07 17.97,152.27 17.97,153.71 18.22,153.96 18.22,156.46 19.33,157.57
LINKACT1: length 160.4
  TOP w0.13: v1(29.91,48) 30.44,47.48 32.17,47.48 32.35,47.65 D367.4 ; R2975.1 v1(4.64,50.67) ; U123.K3 v1(20.05,157.4)
  SIG1 w0.152: v1(29.91,48) 29.02,47.11 12.38,47.11 9.46,50.04 5.91,50.04 5.27,50.67 v1(4.64,50.67)
  SIG7 w0.155: v1(20.05,157.4) 18.73,156.08 18.73,153.03 19.11,152.65 19.86,152.65 20.63,151.88 20.63,148.34 20.89,148.08 20.89,144.78 22.53,143.14 22.53,135.51 29.15,128.89 29.15,103.85 27.13,101.83 27.13,99.74 25.43,98.04 24.13,98.04 19.3,93.22 16.45,93.22 15.47,92.23 15.47,91.82 12.26,88.61 12.26,85.47 11.62,84.83 10.92,84.83 8.28,82.2 8.28,81.12 5.52,78.36 5.52,63.24 4.23,61.95 4.23,53.74 5.52,52.45 5.52,51.56 v1(4.64,50.67)
  BOTTOM w0.13: v2(2.6,50.54) 2.98,50.16 3.87,50.16 4.38,50.67 v1(4.64,50.67)
LINKACT2: length 169.5
  TOP w0.13: R2983.1 v1(4.64,49.53) ; U123.L3 v1(20.05,156.6) ; D371.4 35,47.99 35.52,47.48 36.87,47.48 v1(37.4,48)
  SIG1 w0.152: v1(37.4,48) 37.4,46.23 34.35,43.18 12.95,43.18 10.6,45.53 10.6,46.86 9.59,47.88 6.67,47.88 5.02,49.53 v1(4.64,49.53)
  SIG7 w0.155: v1(20.05,156.6) 19.49,156.04 19.49,154.05 22.16,151.38 22.16,144.78 22.92,144.02 22.92,135.66 29.86,128.72 29.86,108.76 30.29,108.33 30.29,104.14 29.02,102.87 29.02,101.09 25.59,97.66 24.29,97.66 21.06,94.44 21.06,93.26 18.88,91.07 17.7,91.07 16.79,90.17 15.56,90.17 13,87.61 13,85.49 11.79,84.28 10.9,84.28 9.19,82.56 9.19,81.39 5.91,78.1 5.91,50.8 v1(4.64,49.53)
LINKACT3: length 196.2
  TOP w0.13: D375.4 51.35,48.41 51.12,48.64 49.72,48.64 v1(48.96,49.4) ; U123.H5 v1(21.65,159.8)
  SIG1 w0.152: v1(3.37,48.38) 3.87,48.89 5.11,48.89 7.4,46.61 9.59,46.61 10.03,46.16 10.03,45.56 12.79,42.8 36.71,42.8 41.28,47.37 46.93,47.37 v1(48.96,49.4)
  SIG7 w0.102: v1(21.65,159.8) 21.25,160.2 19.69,160.2 19.62,160.27 19.25,160.27
  SIG7 w0.155: 19.25,160.27 15.68,160.27 14.29,158.87 14.29,147.06 19.99,141.36 19.99,134.19 26.98,127.19 26.98,107.69 17.72,98.42 15.37,98.42 12.32,95.37 12.32,91.75 7.3,86.74 6.29,86.74 2.09,82.54 2.09,49.66 v1(3.37,48.38)
  BOTTOM w0.13: v2(2.1,49.02) 2.73,49.02 v1(3.37,48.38) 3.87,48.38 4.38,48.89 5.22,48.89 R2991.1
LINKACT4: length 206.8
  TOP w0.13: U123.G5 v1(21.65,160.6) ; v1(60.02,49.4) 60.91,48.51 62.18,48.51 62.35,48.34 D379.4
  SIG6 w0.155: v1(3.37,47.24) 4,47.88 4.89,47.88 7.18,50.16 9.59,50.16 11.11,48.64 32.07,48.64 32.7,49.27 33.72,49.27 34.35,48.64 58.99,48.64 59.75,49.4 v1(60.02,49.4)
  SIG7 w0.102: v1(21.65,160.6) 21.25,161 19.28,161
  SIG7 w0.155: v1(3.37,47.24) 1.71,48.9 1.71,83.4 7.81,89.5 7.81,90.04 8.06,90.29 9.62,90.29 11.83,92.5 11.83,95.42 17.1,100.69 19.22,100.69 26.6,108.06 26.6,127.04 19.6,134.03 19.6,140.6 13.65,146.56 13.65,158.87 15.46,160.68 18.5,160.68 18.83,161 19.28,161
  BOTTOM w0.13: v2(1.71,47.11) 3.24,47.11 v1(3.37,47.24) 3.75,47.24 4.38,47.88 5.09,47.88 R2999.1
LINKACT5: length 215.1
  TOP w0.13: v1(4.64,46.1) R3007.1 ; D383.4 79.35,47.66 79.16,47.48 77.44,47.48 v1(76.91,48) ; U123.J6 v1(22.45,158.2)
  SIG6 w0.155: v1(4.64,46.1) 6.16,46.1 6.79,46.73 9.46,46.73 12.74,43.46 72.36,43.46 v1(76.91,48)
  SIG7 w0.102: v1(22.45,158.2) 22.85,157.8 24.38,157.8 24.7,157.48 24.7,157.03
  SIG7 w0.155: v1(4.64,46.1) 7.06,48.52 7.06,51.95 7.84,52.73 7.84,58.52 7.06,59.3 7.06,73.66 9.43,76.03 9.43,78.84 10.86,80.26 13.02,80.26 13.78,81.02 13.78,83.44 17.97,87.63 17.97,88.07 34.1,104.2 34.1,110.76 31.94,112.92 31.94,123.31 32.45,123.82 32.45,135.38 26.86,140.97 26.86,147.7 26.23,148.33 26.23,152.14 24.7,153.67 24.7,157.03
  BOTTOM w0.13: v1(4.64,46.1) 4.38,46.1 3.82,45.54 v2(2.73,45.54)
LINKACT6: length 214.8
  TOP w0.13: R3015.1 v1(4.64,44.96) ; U123.L10 v1(26.45,156.6) ; D387.4 82,47.99 82.52,47.48 83.87,47.48 v1(84.4,48)
  SIG6 w0.155: v1(4.64,44.96) 5.4,44.96 5.91,44.45 9.59,44.45 11.35,42.69 80.85,42.69 84.4,46.24 v1(84.4,48)
  SIG8 w0.102: v1(26.45,156.6) 26.05,156.2 26.05,153.33 26.23,153.16
  SIG8 w0.155: v1(4.64,44.96) 5.78,46.1 5.78,51.81 3.49,54.1 3.49,79.63 7.18,83.31 7.18,84.71 8.47,86 8.47,87.02 14.35,92.9 14.35,93.91 15.58,95.15 18,95.15 18.86,96.01 18.86,96.64 22.8,100.59 22.8,101.88 27.5,106.57 27.5,126.62 26.99,127.12 26.99,146.81 27.5,147.32 27.5,151.89 26.23,153.16
LINKACT7: length 231.7
  TOP w0.13: D391.4 98.35,48.41 98.12,48.64 96.72,48.64 v1(95.96,49.4) ; U123.L9 v1(25.65,156.6)
  SIG6 w0.155: v1(95.96,49.4) 94.17,47.61 94.17,46.86 89.62,42.3 10.59,42.3 9.59,43.3 6.41,43.3 5.4,44.32 3.87,44.32 v1(3.37,43.81)
  SIG8 w0.155: v1(25.65,156.6) 25.08,156.03 25.08,152.91 25.99,151.99 25.99,148.61 25.08,147.7 25.08,144.27 23.94,143.12 23.94,126.75 25.59,125.09 25.59,105.75 21.89,102.06 21.89,100.85 20.61,99.57 19.88,99.57 18.1,97.79 15.68,97.79 13.17,95.27 13.17,92.86 7.67,87.36 7.67,86.37 7.02,85.72 6.03,85.72 2.47,82.16 2.47,44.7 v1(3.37,43.81)
  BOTTOM w0.13: v2(2.73,44.24) 3.16,43.81 v1(3.37,43.81) 3.87,44.32 5.22,44.32 R3023.1
LINKACT8: length 246
  TOP w0.13: U123.L8 v1(24.05,156.6) ; v1(107.02,49.4) 107.91,48.51 109.18,48.51 109.35,48.34 D364.4
  SIG1 w0.16: v1(3.37,42.67) 3.87,43.18 5.14,43.18 6.29,44.32 9.59,44.32 11.21,42.7 11.21,41.75 14.36,38.61 36.19,38.61 41.29,43.71 53.68,43.71 58.61,48.64 78.55,48.64 79.18,49.27 80.33,49.27 80.96,48.64 106.26,48.64 v1(107.02,49.4)
  SIG8 w0.155: v1(24.05,156.6) 24.7,155.96 24.7,152.78 23.94,152.02 23.94,147.7 24.19,147.44 24.19,144.27 23.55,143.63 23.55,125.48 24.83,124.2 24.83,105.75 17.5,98.42 15.37,98.42 12.32,95.37 12.32,93.02 9.59,90.29 9.21,90.29 8.83,89.91 8.83,89.41 7.18,87.75 7.18,86.99 6.92,86.74 6.29,86.74 2.09,82.54 2.09,43.94 v1(3.37,42.67)
  BOTTOM w0.13: v1(3.37,42.67) 3.75,42.67 4.38,43.3 5.09,43.3 R2968.1
LINKACT9: length 262.6
  TOP w0.13: U123.L14 v1(29.65,156.6) ; D368.4 126.35,47.75 126.08,47.48 124.44,47.48 v1(123.91,48) ; R2976.1 v1(4.64,41.53)
  SIG1 w0.16: v1(4.64,41.53) 6.67,41.53 7.3,40.89 10.1,40.89 13.78,37.21 36.77,37.21 42.1,42.54 82.43,42.54 83.3,43.42 119.32,43.42 v1(123.91,48)
  SIG8 w0.155: v1(29.65,156.6) 29.65,156.59 30.29,155.95 30.29,154.05 29.91,153.67 29.91,147.7 30.54,147.06 30.54,130.3 30.29,130.05 30.29,108.33 30.29,108.33 30.29,107.06 28.51,105.28 28.51,103.76 26.23,101.47 26.23,100.96 25.72,100.45 24.83,100.45 23.05,98.68 23.05,97.15 18.61,92.71 18.22,92.71 17.46,91.95 16.83,91.95 16.45,92.33 15.53,92.33 9.89,86.69 9.89,85.14 8.83,84.07 8.83,81.02 5.91,78.1 5.91,66.42 7.56,64.77 7.56,53.46 6.93,52.84 6.93,43.82 v1(4.64,41.53)
  BOTTOM w0.13: v1(4.64,41.53) 4.38,41.53 3.85,40.99 v2(2.81,40.99)
LINKACT10: length 279.9
  TOP w0.13: R2984.1 v1(4.64,40.38) ; U123.K13 v1(28.85,157.4) ; D372.4 129,47.99 129.52,47.48 130.87,47.48 v1(131.4,48)
  SIG1 w0.155: v1(4.64,40.38) 5.65,40.38 7.43,38.61 10.7,38.61 12.01,37.29 12.01,33.5 12.88,32.63 37.43,32.63 43.69,38.89 117.83,38.89 126.31,47.37 130.77,47.37 v1(131.4,48)
  SIG8 w0.102: v1(28.85,157.4) 29.25,157 30,157 30.37,156.64
  SIG8 w0.155: v1(4.64,40.38) 7.31,43.06 7.31,52.33 7.96,52.98 7.96,65.38 6.29,67.05 6.29,77.59 9.33,80.64 9.33,82.93 11.87,85.47 11.87,88.01 15.18,91.31 18.61,91.31 19.37,92.07 19.37,92.93 24.59,98.15 25.95,98.15 26.48,98.68 26.48,99.44 28.77,101.72 28.77,102.74 30.16,104.14 30.16,105.15 31.69,106.68 31.69,108.2 30.94,108.94 30.94,125.49 32.19,126.74 32.19,136.9 33.08,137.79 33.08,147.44 30.98,149.55 30.98,151.58 30.67,151.89 30.67,152.78 31.05,153.16 31.05,155.95 30.37,156.64
LINKACT11: length 290.5
  TOP w0.13: D378.4 145.35,48.41 145.12,48.64 143.72,48.64 v1(142.96,49.4) ; U123.R6 22.45,153.4 22.45,152.48 21.3,151.32 v1(21.3,151.13)
  SIG1 w0.155: 11.45,35.6 11.45,33.35 12.67,32.13 37.47,32.13 43.85,38.51 132.07,38.51 v1(142.96,49.4)
  SIG1 w0.16: v1(3.37,39.24) 3.87,39.75 5.14,39.75 7.3,37.59 10.1,37.59 11.45,36.24 11.45,35.6
  SIG3 w0.155: v1(21.3,151.13) 20.66,150.49 20.66,143 23.06,140.61 26.83,140.61 27.75,139.69 27.75,106.46 22.8,101.51 22.8,100.14 18.86,96.21 18.86,96.01 18,95.15 15.58,95.15 14.35,93.91 14.35,92.51 7.18,85.34 7.18,83.64 3.29,79.75 3.29,59.31 4,58.6 4,39.88 v1(3.37,39.24)
  BOTTOM w0.13: R2992.1 5.22,39.75 4,39.75 3.49,39.24 v1(3.37,39.24)
LINKACT12: length 298.3
  TOP w0.13: v1(154.02,49.65) 155.16,48.51 156.18,48.51 156.35,48.34 D380.4 ; U123.P5 v1(21.65,154.2)
  SIG3 w0.155: v1(3.37,38.1) 2.91,38.56 2.91,79.93 6.79,83.82 6.79,85.49 13.91,92.61 13.91,95 16.19,97.28 19.39,97.28 22.41,100.3 22.41,101.67 26.98,106.23 26.98,138.13 26.52,138.6 24.53,138.6 20.26,142.87 20.26,152.8 v1(21.65,154.2)
  SIG6 w0.155: v1(3.37,38.1) 3.87,38.61 9.46,38.61 10.22,37.84 145.57,37.84 152.21,44.48 152.21,47.88 153.99,49.65 v1(154.02,49.65)
  BOTTOM w0.13: R3000.1 5.09,38.73 4.25,38.73 3.62,38.1 v1(3.37,38.1) v2(2.73,37.46)
LINKACT13: length 308.5
  TOP w0.13: R3008.1 v1(4.64,36.95) ; v1(170.91,48) 171.44,47.48 173.2,47.48 173.35,47.62 D385.4 ; v1(23.36,150.11) 23.81,150.56 23.81,151.48 24.45,152.12 U123.T8
  SIG3 w0.155: v1(4.64,36.95) 6.29,38.61 6.29,79.13 8.28,81.12 8.28,82.2 10.92,84.83 11.62,84.83 12.26,85.47 12.26,88.61 14.96,91.31 16.83,91.31 18.22,92.71 18.61,92.71 23.05,97.15 23.05,98.68 24.83,100.45 25.34,100.45 26.73,101.85 26.73,102.87 28.26,104.39 28.26,105.34 29.02,106.1 29.02,108.58 29.28,108.84 29.28,140.2 27.81,141.67 27.81,143.06 26.23,144.65 26.23,146.68 23.36,149.55 v1(23.36,150.11)
  SIG6 w0.155: v1(170.91,48) 159.35,36.45 10.86,36.45 9.72,35.3 7.05,35.3 5.4,36.95 v1(4.64,36.95)
  BOTTOM w0.13: v2(22.77,150.62) 23.28,150.11 v1(23.36,150.11)
LINKACT14: length 329.8
  TOP w0.13: D388.4 176,47.99 176.52,47.48 177.87,47.48 v1(178.4,48) ; R3016.1 v1(4.64,35.81) ; U123.N6 v1(22.45,155)
  SIG3 w0.102: 22.85,153.62 22.85,154.6 v1(22.45,155)
  SIG3 w0.155: v1(4.64,35.81) 6.68,37.85 6.68,56.77 7.43,57.53 7.43,58.29 6.68,59.04 6.68,78.87 9.19,81.39 9.19,82.56 10.9,84.28 11.79,84.28 13,85.49 13,87.36 14.73,89.09 14.73,89.72 15.18,90.17 16.57,90.17 17.46,91.06 19.75,91.06 22.92,94.23 22.92,96.39 24.45,97.91 25.46,97.91 26.35,98.8 26.35,100.07 27.31,101.03 27.31,102.3 27.94,102.93 27.94,103.53 28.64,104.23 28.64,105.18 29.41,105.94 29.41,106.3 30.29,107.19 30.29,108.64 29.98,108.95 29.98,146.61 27.62,148.97 27.62,151.25 26.61,152.27 23.94,152.27 22.85,153.36 22.85,153.62
  SIG6 w0.155: v1(178.4,48) 178.4,44.45 166.59,32.63 10.86,32.63 9.71,33.78 6.95,33.78 4.92,35.81 v1(4.64,35.81)
  BOTTOM w0.13: v2(2.6,35.94) 3.24,35.3 3.87,35.3 4.38,35.81 v1(4.64,35.81)
LINKACT15: length 342.9
  TOP w0.13: D392.4 192.35,48.41 192.12,48.64 190.72,48.64 v1(189.96,49.4) ; v1(17.11,155.95) 17.26,155.8 19.25,155.8 U123.M2
  SIG3 w0.155: v1(17.11,155.95) 16.57,155.42 16.57,144.51 25.6,135.49 25.6,106.68 25.59,106.68 25.59,106.47 19.14,100.02 16.42,100.02 11.83,95.42 11.83,93.68 9.59,91.44 9.21,91.44 8.83,91.06 8.83,90.55 8.45,90.17 8.12,90.17 7.81,89.86 7.81,89.02 7.3,88.52 6.75,88.52 1.76,83.53 1.76,36.28 v1(3.37,34.67)
  SIG6 w0.155: v1(189.96,49.4) 188.95,48.39 182.88,48.39 166.74,32.25 10.48,32.25 9.33,33.4 6.79,33.4 4.89,35.3 4,35.3 v1(3.37,34.67)
  BOTTOM w0.13: R3024.1 5.22,35.18 4.25,35.18 3.75,34.67 v1(3.37,34.67) v2(2.6,34.67)
LINKACT16: length 362.4
  TOP w0.13: D365.4 203.35,48.34 203.18,48.51 201.91,48.51 v1(201.02,49.4) ; U124.M16 408.5,178.05 408.57,177.97 409.67,177.97 v1(409.77,177.87)
  SIG7 w0.152: 412.6,159.93 412.6,142.41 410.92,140.72 410.92,135.3 414.85,131.37 414.85,108.24 414.19,107.59 414.19,106.28 410.48,102.57 409.37,102.57 399.65,92.86 399.65,83.36 400.62,82.39 400.62,73.78 402.78,71.63 402.78,67.59 399.63,64.44 399.63,51.76 v1(391.68,43.81)
  SIG7 w0.155: v1(201.02,49.4) 201.57,48.85 213.86,48.85 226,36.7 385.45,36.7 390.26,41.51 390.26,42.97 390.59,43.3 391.17,43.3 v1(391.68,43.81) ; v1(409.77,177.87) 410.45,178.56 411.54,178.56 412.94,177.16 412.94,174.24 415.1,172.08 415.1,162.43 412.6,159.93
  BOTTOM w0.13: R2969.1 390.06,44.17 390.21,44.32 391.17,44.32 v1(391.68,43.81) 392.06,43.43 v2(392.49,43.43)
LINKACT17: length 344.2
  TOP w0.13: R2977.1 v1(390.72,43.81) ; D369.4 220.35,47.69 220.13,47.48 218.44,47.48 v1(217.91,48) ; U124.G11 v1(404.42,182.45)
  SIG4 w0.102: v1(404.42,182.45) 404.82,182.05 404.82,181.23 405,181.04
  SIG4 w0.155: v1(217.91,48) 218.37,47.54 223.31,47.54 228.17,42.69 261.45,42.69 266.72,37.41 385.76,37.41 390.21,41.86 390.21,43.3 v1(390.72,43.81) 391.22,44.32 391.89,44.32 398.35,50.78 398.35,54.37 v1(398.72,54.73) 399.51,55.53 399.51,65.78 402.4,68.67 402.4,71.88 400.35,73.93 400.35,89.68 416.5,105.82 416.5,129.11 410.84,134.76 410.84,140.18 412.43,141.76 412.43,161.93 408.75,165.61 408.75,170.05 409.64,170.94 409.64,173.38 408.88,174.15 408.88,175.51 408.5,175.89 408.5,178.96 406.87,180.59 405.45,180.59 405,181.04
LINKACT18: length 329.1
  TOP w0.13: v1(225.4,48) 224.87,47.48 223.52,47.48 223,47.99 D374.4 ; U124.K13 v1(406.02,179.25) ; R2985.1 v1(390.72,46.1)
  SIG4 w0.099: 407.07,178.84 406.43,178.84 v1(406.02,179.25)
  SIG4 w0.155: 407.07,178.84 407.48,178.43 407.48,175.89 406.99,175.41 406.99,174.47 408.11,173.35 408.11,171.07 407.98,170.93 407.98,165.03 v1(409.86,163.16) 411.66,161.35 411.66,142.08 410.08,140.49 410.08,134.45 414.49,130.03 414.49,104.9 399.24,89.65 399.24,89.18 397.76,87.7 397.76,65.85 398.75,64.86 398.75,63.61 396.98,61.84 396.98,51.2 392.38,46.61 391.22,46.61 v1(390.72,46.1) 389.44,44.82 389.44,42.18 385.52,38.25 268.14,38.25 259.33,47.06 226.34,47.06 v1(225.4,48)
LINKACT19: length 326.6
  TOP w0.13: v1(236.96,49.4) 237.72,48.64 239.12,48.64 239.35,48.41 D376.4 ; U124.E16 408.53,183.65 409.03,184.15 v1(409.77,184.15)
  SIG7 w0.152: 411.92,161.79 411.79,161.65 411.79,142.77 410.16,141.13 410.16,134.98 413.95,131.19 413.95,108.42 412.95,107.43 412.95,106.18 410.39,103.62 409.14,103.62 398.08,92.56 398.08,65.56 398.87,64.77 398.87,63.02 397.23,61.38 397.23,51.65 v1(391.68,46.1)
  SIG7 w0.155: v1(236.96,49.4) 237.42,48.94 242.24,48.94 247.91,43.27 263.41,43.27 269.09,37.58 385.25,37.58 389.49,41.82 389.49,44.75 390.33,45.59 391.17,45.59 v1(391.68,46.1) ; 411.92,161.79 412.56,162.42 412.56,171.83 410.27,174.11 410.27,175.26 408.5,177.04 408.5,182.88 v1(409.77,184.15)
  BOTTOM w0.13: v2(392.49,45.97) 391.81,45.97 v1(391.68,46.1) 391.17,46.61 390.21,46.61 390.06,46.45 R2993.1
LINKACT20: length 306.1
  TOP w0.13: D382.4 250.35,48.34 250.18,48.51 248.91,48.51 v1(248.02,49.4) ; U124.K11 v1(404.42,179.25) ; R3001.1 v1(390.72,48.38)
  SIG4 w0.102: v1(404.42,179.25) 404.82,178.85 404.82,175.38
  SIG4 w0.155: 404.82,175.38 404.82,174.36 405.98,173.2 405.98,171.68 407.22,170.44 407.22,164.59 410.9,160.91 410.9,142.61 409.31,141.02 409.31,134.13 413.6,129.84 413.6,105.1 403.75,95.25 402.31,95.25 401.38,94.32 v1(401.38,93.72) 396.99,89.33 396.99,62.98 396.21,62.2 396.21,51.52 393.58,48.89 391.22,48.89 v1(390.72,48.38) 388.94,46.61 387.31,46.61 386.76,46.05 386.76,40.58 385.2,39.02 268.46,39.02 258.64,48.85 248.57,48.85 v1(248.02,49.4)
LINKACT21: length 290.2
  TOP w0.13: v1(264.91,48) 265.44,47.48 267.12,47.48 267.35,47.7 D384.4 ; U124.M14 v1(406.82,177.65)
  SIG7 w0.152: 408.6,165.61 410.58,163.62 410.58,143.14 410.35,142.9 410.35,142.9 409.39,141.94 409.39,134.67 413.19,130.88 413.19,108.74 411.59,107.14 411.59,105.99 410.31,104.71 409.16,104.71 397.32,92.87 397.32,65.02 398.11,64.23 398.11,63.33 396.47,61.7 396.47,53.17 v1(391.68,48.38)
  SIG7 w0.155: v1(264.91,48) 264.91,44.27 270.83,38.35 382.27,38.35 386.8,42.88 386.8,47.52 387.16,47.88 391.17,47.88 v1(391.68,48.38) ; 408.6,165.61 408.6,170.51 409.22,171.13 409.22,173.73 408.9,174.06 408.9,175.11 407.35,176.65 407.35,177.11 v1(406.82,177.65)
  BOTTOM w0.13: v2(392.49,48.51) 391.81,48.51 v1(391.68,48.38) 391.17,48.89 390.21,48.89 390.06,48.74 R3009.1
LINKACT22: length 279.1
  TOP w0.13: U124.L12 v1(405.22,178.45) ; v1(272.4,48) 271.87,47.48 270.52,47.48 270,47.99 D389.4
  SIG7 w0.102: 405.62,175.44 405.62,178.05 v1(405.22,178.45)
  SIG7 w0.152: 409.8,161 409.8,143.43 408.63,142.26 408.63,134.36 411.42,131.57 411.42,108.05 410.3,106.93 408.11,106.93 406.54,105.36 406.54,104.31 396.56,94.33 396.56,63.14 395.71,62.29 395.71,54.7 v1(391.68,50.67)
  SIG7 w0.155: v1(272.4,48) 272.78,47.62 275.94,47.62 284.45,39.12 381.96,39.12 386.04,43.2 386.04,48.79 387.41,50.16 391.17,50.16 v1(391.68,50.67) ; 405.62,175.44 405.62,175.21 407.05,173.78 407.05,170.05 407.53,169.58 407.53,163.27 409.8,161
  BOTTOM w0.13: v2(392.49,51.05) 392.06,51.05 v1(391.68,50.67) 391.17,51.18 390.21,51.18 390.06,51.03 R3017.1
LINKACT23: length 262.6
  TOP w0.13: v1(283.96,49.4) 284.72,48.64 286.12,48.64 286.35,48.41 D393.4 ; R3025.1 v1(390.72,50.67) ; U124.M11 v1(404.42,177.65)
  SIG4 w0.102: 404.02,175.4 404.02,177.25 v1(404.42,177.65)
  SIG4 w0.155: 404.02,175.4 404.02,174.53 404.61,173.94 404.61,171.52 406.45,169.68 406.45,164.27 410.13,160.59 410.13,142.92 408.54,141.34 408.54,133.81 409.89,132.46 409.89,131.7 v1(410.27,131.32) 411.95,129.64 411.95,104.53 405.12,97.7 403.68,97.7 396.22,90.25 396.22,65.03 395.44,64.25 395.44,54.16 392.46,51.18 391.22,51.18 v1(390.72,50.67)
  SIG10 w0.155: v1(390.72,50.67) 389.19,50.67 388.68,50.16 386.42,50.16 385.91,49.65 385.91,45.25 383.67,43.01 332.27,43.01 331.18,41.92 303.98,41.92 298.4,47.5 293.94,47.5 292.59,48.85 284.51,48.85 v1(283.96,49.4)
LINKACT24: length 246.9
  TOP w0.13: v1(295.02,49.4) 295.91,48.51 297.18,48.51 297.35,48.34 D366.4 ; U124.N9 v1(402.82,176.85)
  SIG7 w0.102: v1(402.82,176.85) 403.22,176.45 403.22,175.58
  SIG7 w0.152: v1(391.68,52.96) 394.95,56.22 394.95,68.21 395.03,68.29 395.03,94.61 405.32,104.9 405.32,106.9 407.48,109.06 407.48,142.74 408.63,143.88 408.63,160.14 406.37,162.39 406.37,164.74
  SIG7 w0.155: v1(391.68,52.96) 391.17,52.45 387.16,52.45 385.27,50.56 385.27,45.54 382.49,42.75 311.8,42.75 305.61,48.94 295.48,48.94 v1(295.02,49.4) ; 403.22,175.58 403.22,174.82 404.62,173.42 404.62,170.84 406.37,169.08 406.37,164.74
  BOTTOM w0.13: R2970.1 390.06,53.31 390.21,53.46 391.17,53.46 v1(391.68,52.96) 391.86,52.96 v2(392.49,53.59)
LINKACT25: length 231.1
  TOP w0.13: U124.T10 403.22,174.47 402.99,174.24 402.99,173.05 v1(402.91,172.97) ; D370.4 314.35,47.71 314.11,47.48 312.44,47.48 v1(311.91,48) ; R2978.1 v1(390.72,52.96)
  SIG4 w0.155: v1(402.91,172.97) 402.4,172.46 402.4,171.69 404.84,169.25 404.84,164.8 409.36,160.28 409.36,143.26 407.78,141.68 407.78,132.29 411.09,128.98 411.09,104.75 404.8,98.47 403.36,98.47 395.46,90.57 395.46,65.43 394.68,64.65 394.68,55.1 393.04,53.46 391.22,53.46 v1(390.72,52.96)
  SIG10 w0.155: v1(390.72,52.96) 390.21,52.45 385.78,52.45 385.14,51.81 385.14,45.57 383.35,43.78 331.22,43.78 330.14,42.69 320.97,42.69 316.29,47.37 312.54,47.37 v1(311.91,48)
  BOTTOM w0.13: v2(402.27,172.26) 402.91,172.9 v1(402.91,172.97)
LINKACT26: length 228
  TOP w0.13: D373.4 317,47.99 317.52,47.48 318.87,47.48 v1(319.4,48) ; R2986.1 v1(390.72,55.24) ; U124.G6 v1(399.62,182.45)
  SIG4 w0.102: v1(399.62,182.45) U124.G6 400.02,181.19 400.24,180.97
  SIG4 w0.155: 400.24,180.97 401,180.97 401.76,180.21 401.76,175.77 399.4,173.4 399.4,171.65 399.86,171.19 401.81,171.19 404.07,168.93 404.07,164.48 405.98,162.57 v1(405.98,161.16) 408.52,158.62 408.52,143.53 407.01,142.02 407.01,103.2 394.69,90.88 394.69,66.44 392.91,64.66 392.91,56.8 391.86,55.75 391.22,55.75 v1(390.72,55.24)
  SIG10 w0.155: v1(390.72,55.24) 390.21,54.73 385.39,54.73 384.38,53.72 384.38,49.14 382.78,47.54 380.12,47.54 379.35,46.77 375,46.77 374.53,47.24 332.64,47.24 328.96,43.56 323.85,43.56 v1(319.4,48)
LINKACT27: length 217.8
  TOP w0.13: U124.L8 v1(401.22,178.45) ; D377.4 333.35,48.41 333.12,48.64 331.72,48.64 v1(330.96,49.4)
  SIG7 w0.152: v1(391.68,55.24) 394.19,57.75 394.19,61.29 392.49,62.98 392.49,64.64 390.91,66.23 389,66.23 388.18,67.05 388.18,74.55 394.27,80.64 394.27,94.93 404.56,105.22 404.56,107.22 406.69,109.35 406.69,143.06 407.83,144.2 407.83,158.4
  SIG7 w0.155: 407.83,158.4 405.45,160.78 405.45,163.44 401.89,167 401.89,169.03 401.52,169.41 401.52,174.87 401.76,175.12 401.76,177.9 v1(401.22,178.45) ; v1(330.96,49.4) 331.42,48.94 351.08,48.94 356.5,43.52 382.17,43.52 384.5,45.86 384.5,51.95 387.29,54.73 391.17,54.73 v1(391.68,55.24)
  BOTTOM w0.13: v2(392.49,56.13) 392.49,56.06 v1(391.68,55.24) 391.17,55.75 390.21,55.75 390.06,55.6 R2994.1
LINKACT28: length 198.2
  TOP w0.13: U124.J6 v1(399.62,180.05) ; D381.4 344.35,48.34 344.18,48.51 343.03,48.51 342.02,49.53 v1(342.02,49.56) ; R3002.1 v1(390.72,57.53)
  SIG4 w0.102: v1(399.62,180.05) 399.22,179.65 399.22,175.64
  SIG4 w0.155: v1(390.72,57.53) 391.22,58.04 391.81,58.04 392.14,58.37 392.14,64.98 393.92,66.76 393.92,91.2 398.21,95.49 398.21,96.64 406.24,104.68 406.24,142.56 407.73,144.05 407.73,156.84 404.69,159.89 v1(404.69,162.56) 402.58,164.67 402.58,169.34 401.49,170.43 398.34,170.43 397.95,170.81 397.95,173.11 399.22,174.38 399.22,175.64
  SIG10 w0.155: v1(342.02,49.56) 342.02,49.53 342.6,48.94 360.87,48.94 361.46,49.53 363.54,49.53 364.12,48.94 375.3,48.94 376.7,47.54 379.04,47.54 380.43,48.94 382.78,48.94 383.61,49.77 383.61,55.09 385.54,57.02 390.21,57.02 v1(390.72,57.53)
LINKACT29: length 184.3
  TOP w0.13: U124.L7 v1(400.42,178.45) ; v1(358.91,48) 359.44,47.48 361.2,47.48 361.35,47.62 D386.4
  SIG7 w0.102: v1(400.42,178.45) 400.02,178.05 400.02,175.64
  SIG7 w0.152: v1(391.68,57.53) 392.62,58.47 392.62,61.53 391.22,62.93 391.22,64.13 390.43,64.93 389.22,64.93 387.41,66.74 387.41,74.86 393.51,80.96 393.51,95.24 399.1,100.83 399.1,102.83 405.93,109.66 405.93,143.38 407.07,144.52 407.07,156.62 405.93,157.76
  SIG7 w0.155: v1(358.91,48) 359.42,47.5 382.84,47.5 383.74,48.39 383.74,53.6 387.16,57.02 391.17,57.02 v1(391.68,57.53) ; 400.02,175.64 400.02,175.28 399.02,174.28 399.02,169.21 398.46,168.65 398.46,166.24 404.05,160.65 404.05,159.64 405.93,157.76
  BOTTOM w0.13: R3010.1 390.06,57.88 390.21,58.04 391.17,58.04 v1(391.68,57.53) 392.49,58.34 v2(392.49,58.67)
LINKACT30: length 174.3
  TOP w0.13: U124.M6 v1(399.62,177.65) ; v1(366.4,48) 365.87,47.48 364.52,47.48 364,47.99 D390.4
  SIG7 w0.102: 399.22,175.76 399.22,177.25 v1(399.62,177.65)
  SIG7 w0.152: 405.55,157.56 406.69,156.42 406.69,144.68 405.55,143.54 405.55,109.82 398.72,102.99 398.72,100.99 393.13,95.4 393.13,81.12 387.03,75.02 387.03,66.58 392.24,61.37 392.24,59.23 v1(391.68,58.67)
  SIG7 w0.155: v1(391.68,58.67) 391.05,58.04 386.91,58.04 383.35,54.48 383.35,49.53 382.71,48.89 377,48.89 376.11,48 v1(366.4,48) ; 399.22,175.76 399.22,175.35 397.95,174.08 397.95,166.11 403.61,160.46 403.61,159.5 405.55,157.56
  BOTTOM w0.13: v2(392.49,59.94) 391.86,59.31 391.86,58.85 v1(391.68,58.67) 391.17,59.18 390.21,59.18 390.06,59.03 R3018.1
LINKACT31: length 165
  TOP w0.13: v1(377.96,49.4) 378.72,48.64 380.12,48.64 380.35,48.41 D394.4 ; R3026.1 v1(390.72,59.81) ; U124.H6 v1(399.62,181.65)
  SIG4 w0.155: v1(399.62,181.65) 398.95,180.97 397.32,180.97 396.68,180.34 396.68,175.89 396.88,175.7 396.88,174.05 396.35,173.53 396.35,171.33 398.02,169.66 401.17,169.66 401.81,169.02 401.81,161.5 v1(402.91,160.4) 406.96,156.34 406.96,144.37 405.47,142.88 405.47,105.31 397.04,96.87 397.04,95.4 393,91.37 393,80 387.92,74.92 387.92,62.61 v1(390.72,59.81) 389.57,58.67 389.57,52.07 388.68,51.18 383.6,51.18 382.46,50.04 378.59,50.04 v1(377.96,49.4)
LINKACT32: length 145.1
  TOP w0.13: U123.J5 v1(21.65,158.2)
  SIG1 w0.152: v1(12.86,49.4) 11.07,51.19 11.07,51.88 10,52.96 4.51,52.96 v1(3.37,51.81)
  SIG7 w0.155: v1(21.65,158.2) 21.11,158.75 19.11,158.75 17.59,157.22 17.59,151 18.78,149.81 18.78,145.11 21.26,142.63 21.26,134.72 28.26,127.72 28.26,106.04 19.94,97.72 19.94,97.09 18,95.15 15.58,95.15 14.35,93.91 14.35,91.88 9.21,86.74 9.21,85.09 3.37,79.25 v1(3.37,51.81)
  BOTTOM w0.13: v1(3.37,51.81) 3.37,52.35 v2(3.72,52.7) 4.84,52.7 R3031.1 ; D395.4 14.81,47.99 14.16,48.64 13.62,48.64 v1(12.86,49.4)
LINKACT33: length 166.2
  TOP w0.13: U123.H6 v1(22.45,159.8)
  SIG1 w0.152: v1(3.37,50.67) 3.87,51.18 9.59,51.18 9.79,50.98 9.79,50.47 11.49,48.77 28.26,48.77 v1(29.02,48)
  SIG7 w0.155: v1(22.45,159.8) 21.91,159.26 18.86,159.26 17.59,157.99 17.08,157.99 16.57,157.48 16.57,150.37 17.34,149.6 17.34,145.92 20.75,142.5 20.75,134.51 27.75,127.51 27.75,106.16 18.87,97.28 16.19,97.28 13.91,95 13.91,92.07 8.64,86.8 8.64,85.28 2.86,79.5 2.86,51.05 3.24,50.67 v1(3.37,50.67)
  BOTTOM w0.13: v2(2.6,51.81) 3.37,51.05 v1(3.37,50.67) 3.75,50.67 4.25,51.18 5.22,51.18 R3039.1 ; v1(29.02,48) 29.55,47.48 30.9,47.48 31.42,47.99 D399.4
LINKACT34: length 178.7
  TOP w0.13: U123.H3 v1(20.05,159.8)
  SIG1 w0.152: v1(36.51,48) 36.51,45.88 34.2,43.56 13.27,43.56 11.37,45.46 11.37,46.99 9.46,48.89 6.29,48.89 5.14,50.04 3.87,50.04 v1(3.37,49.53)
  SIG7 w0.155: v1(3.37,49.53) 2.47,50.42 2.47,82.16 6.03,85.72 7.02,85.72 13.17,91.87 13.17,95.27 15.68,97.79 18.83,97.79 27.36,106.32 27.36,127.35 20.37,134.35 20.37,142.25 16.19,146.43 16.19,149.73 15.56,150.37 15.56,158.75 16.07,159.26 18.22,159.26 18.77,159.8 v1(20.05,159.8)
  BOTTOM w0.13: R3047.1 5.09,50.16 4.38,50.16 3.75,49.53 v1(3.37,49.53) ; v1(36.51,48) 36,47.5 34.23,47.5 34.05,47.67 D403.4
LINKACT35: length 182
  TOP w0.13: U123.L5 v1(21.65,156.6) ; v1(4.64,48.38) R3055.1
  SIG1 w0.152: v1(4.64,48.38) 7.43,45.59 9.46,45.59 12.64,42.42 36.87,42.42 41.44,46.99 47.94,46.99 v1(48.96,48)
  SIG7 w0.102: 21.25,153.75 21.25,156.2 v1(21.65,156.6)
  SIG7 w0.155: v1(4.64,48.38) 6.29,50.04 6.29,77.59 9.91,81.21 9.91,82.74 10.99,83.82 11.87,83.82 13.53,85.47 13.53,86.36 14.8,87.63 14.8,88.64 15.81,89.66 18.48,89.66 32.32,103.5 32.32,107.57 30.42,109.47 30.42,135.43 25.46,140.39 25.46,146.05 22.67,148.84 22.67,151.76 21.25,153.18 21.25,153.75
  BOTTOM w0.13: v2(2.73,47.88) 3.87,47.88 4.38,48.38 v1(4.64,48.38) ; D407.4 50.6,47.99 50.1,47.5 49.47,47.5 v1(48.96,48)
LINKACT36: length 190.3
  TOP w0.13: R3063.1 v1(4.64,47.24) ; U123.K5 v1(21.65,157.4)
  SIG6 w0.155: v1(4.64,47.24) 5.14,47.24 6.92,49.02 9.59,49.02 11.14,47.47 59.48,47.47 v1(60.02,48)
  SIG7 w0.102: 22.05,153.75 22.05,157 v1(21.65,157.4)
  SIG7 w0.155: v1(4.64,47.24) 6.67,49.28 6.67,52.58 7.43,53.34 7.43,58.3 6.67,59.05 6.67,76.96 10.35,80.64 12.64,80.64 13.27,81.28 13.27,83.47 17.4,87.6 17.4,88.04 33.72,104.35 33.72,109.61 30.8,112.52 30.8,135.59 26.35,140.04 26.35,147.32 24.07,149.6 24.07,151.25 22.05,153.27 22.05,153.75
  BOTTOM w0.13: D411.4 61.66,47.99 61.16,47.5 60.53,47.5 v1(60.02,48)
LINKACT37: length 221.8
  TOP w0.13: U123.F1 18.21,161 17.57,161.64 15.66,161.64 v1(15.18,161.16)
  SIG6 w0.155: v1(76.02,48) 75.08,47.06 10.27,47.06 9.59,47.75 6.54,47.75 5.52,46.73 4,46.73 v1(3.37,46.1)
  SIG7 w0.155: v1(15.18,161.16) 13.02,159 13.02,146.43 19.22,140.23 19.22,133.87 26.21,126.88 26.21,108.32 19.49,101.6 17.46,101.6 11.05,95.18 11.05,92.9 9.59,91.44 7.05,91.44 6.41,90.8 6.41,88.77 1.32,83.68 1.32,48.14 v1(3.37,46.1)
  BOTTOM w0.13: v2(1.46,45.72) 1.9,46.16 3.31,46.16 v1(3.37,46.1) 3.87,46.1 4.38,46.61 5.22,46.61 R3071.1 ; v1(76.02,48) 76.55,47.48 77.91,47.48 78.42,47.99 D415.4
LINKACT38: length 215.2
  TOP w0.13: U123.P9 v1(25.65,154.2)
  SIG6 w0.155: v1(83.51,48) 83.51,45.89 80.7,43.07 12.11,43.07 9.72,45.46 3.87,45.46 v1(3.37,44.96)
  SIG8 w0.155: v1(25.65,154.2) 25.65,152.9 26.38,152.18 26.38,147.98 25.72,147.32 25.72,144.02 26.43,143.3 26.43,126.54 26.73,126.24 26.73,106.35 22.42,102.04 22.42,100.83 18.87,97.28 16.19,97.28 13.91,95 13.91,93.04 8.06,87.19 8.06,86.22 6.79,84.95 6.79,83.69 2.86,79.75 2.86,45.46 v1(3.37,44.96)
  BOTTOM w0.13: D419.4 81.05,47.67 81.23,47.5 83,47.5 v1(83.51,48) ; R3079.1 5.09,45.59 4.38,45.59 3.75,44.96 v1(3.37,44.96) 3.34,44.93 1.94,44.93 v2(1.46,44.45)
LINKACT39: length 230.3
  TOP w0.13: R3087.1 v1(4.64,43.81) ; U123.N10 v1(26.45,155)
  SIG6 w0.155: v1(4.64,43.81) 5.14,43.3 5.52,43.3 6.67,42.16 9.59,42.16 13.53,38.23 82.23,38.23 85.61,41.6 89.56,41.6 v1(95.96,48)
  SIG8 w0.102: 26.85,153.84 26.85,154.6 v1(26.45,155)
  SIG8 w0.155: 26.85,153.84 26.85,153.55 28,152.4 28,147.7 28.38,147.32 28.38,139.19 29.02,138.55 29.02,131.19 28.26,130.43 28.26,106.68 23.19,101.61 23.19,100.43 19.81,97.05 19.81,95.56 18.43,94.18 15.63,94.18 14.99,93.53 14.99,92.9 9.02,86.93 9.02,85.91 7.75,84.64 7.75,83.12 4,79.37 4,54.86 6.16,52.7 6.16,45.34 v1(4.64,43.81)
  BOTTOM w0.13: D423.4 97.6,47.99 97.1,47.5 96.47,47.5 v1(95.96,48) ; v1(4.64,43.81) 3.68,43.42 3.45,43.37 v2(2.17,43.1)
LINKACT40: length 240.2
  TOP w0.13: R3032.1 v1(4.64,42.67) ; U123.N11 v1(27.25,155)
  SIG1 w0.16: v1(4.64,42.67) 5.65,42.67 6.29,43.3 9.46,43.3 10.35,42.42 10.35,41.74 14.1,37.99 36.44,37.99 41.78,43.32 54.48,43.32 58.54,47.38 106.45,47.38 v1(107.03,47.97)
  SIG8 w0.102: 27.65,153.84 27.65,154.6 v1(27.25,155)
  SIG8 w0.155: 27.65,153.84 27.65,153.64 28.77,152.52 28.77,148.08 29.91,146.94 29.91,130.43 29.15,129.67 29.15,106.68 24.45,101.98 24.45,100.71 22.29,98.55 22.29,97.53 21.78,97.03 21.15,97.03 20.26,96.14 20.26,94.99 18.48,93.22 15.86,93.22 9.46,86.81 9.46,85.6 8.28,84.42 8.28,81.12 5.52,78.36 5.52,65.61 6.16,64.97 6.16,54.48 6.55,54.09 6.55,44.58 v1(4.64,42.67)
  BOTTOM w0.13: v1(107.03,47.97) 107.53,47.47 108.14,47.47 108.66,47.99 D396.4
LINKACT41: length 260.2
  TOP w0.13: U123.P8 v1(24.05,154.2)
  SIG1 w0.16: v1(3.37,41.53) 4,42.16 9.38,42.16 13.94,37.6 36.61,37.6 41.94,42.93 54.64,42.93 58.71,47 122.01,47 v1(123.02,48)
  SIG8 w0.155: v1(3.37,41.53) 1.71,43.19 1.71,83.02 7.81,89.12 7.81,91.06 8.19,91.44 9.59,91.44 11.83,93.68 11.83,95.42 17.1,100.69 19.22,100.69 23.43,104.9 23.43,123.57 22.8,124.2 22.8,152.03 24.05,153.29 v1(24.05,154.2)
  BOTTOM w0.13: R3040.1 5.22,42.03 4.38,42.03 3.87,41.53 v1(3.37,41.53) 3.24,41.65 1.94,41.65 v2(1.56,41.27) ; v1(123.02,48) 123.55,47.48 124.91,47.48 125.42,47.99 D400.4
LINKACT42: length 275.3
  TOP w0.13: U123.M8 v1(24.05,155.8)
  SIG1 w0.155: v1(3.37,40.38) 4,41.02 6.16,41.02 7.43,39.75 10.1,39.75 12.39,37.45 12.39,33.66 13.04,33.02 37.27,33.02 43.53,39.28 79.71,39.28 83.23,42.8 120.33,42.8 125.54,48 127.95,48 128.4,48.46 130.05,48.46 v1(130.51,48)
  SIG8 w0.102: v1(24.05,155.8) 23.65,155.4 23.65,153.89 23.26,153.5
  SIG8 w0.155: v1(3.37,40.38) 1.32,42.43 1.32,83.3 6.79,88.77 6.79,91.18 7.05,91.44 7.56,91.44 8.57,92.45 9.59,92.45 11.05,93.91 11.05,95.18 17.46,101.6 19.49,101.6 21.65,103.76 21.65,118.49 22.16,119 22.16,152.4 23.26,153.5
  BOTTOM w0.13: D404.4 128.05,47.67 128.23,47.5 130,47.5 v1(130.51,48) ; v2(2.1,39.88) 2.6,40.38 v1(3.37,40.38) 3.75,40.38 4.38,41.02 5.09,41.02 R3048.1
LINKACT43: length 287.7
  TOP w0.13: R3056.1 v1(4.64,39.24) ; U123.M6 v1(22.45,155.8)
  SIG1 w0.155: v1(4.64,39.24) 7.43,36.45 9.72,36.45 10.35,35.81 10.35,33.14 11.75,31.75 37.63,31.75 44.01,38.13 132.55,38.13 142.43,48 v1(142.96,48)
  SIG3 w0.102: 22.03,153.5 22.03,153.69 22.05,153.71 22.05,155.4 v1(22.45,155.8)
  SIG3 w0.155: 22.03,153.5 22.03,149.1 24.57,146.56 24.57,144.52 25.97,143.13 25.97,142.08 28.26,139.8 28.26,106.42 23.43,101.6 23.43,100.24 19.81,96.62 19.81,95.56 18.43,94.18 15.63,94.18 14.99,93.53 14.99,92.52 7.68,85.21 7.68,83.56 5.52,81.4 5.52,61.72 4.51,60.7 4.51,57.91 5.52,56.89 5.52,40.13 v1(4.64,39.24)
  BOTTOM w0.13: v1(142.96,48) 143.47,47.5 144.1,47.5 144.6,47.99 D410.4 ; v1(4.64,39.24) 4.13,39.24 3.62,38.73 v2(2.73,38.73)
