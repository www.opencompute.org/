# Allegro board RA-B6910-64C-MAC.brd (continued)
## Nets (continued)
GND_EARTH: C2067.2 C3370.2 C3371.2 J29.5(PGND_1) J29.6(PGND_2) J29.7(PGND_3) J29.8(PGND_4) RJ1.1(PGND1) RJ1.2(PGND2) RJ1.3(PGND4) RJ1.4(PGND3) RV1.2 RV2.2 RV3.2 RV4.2 SW1.2(GND_1) SW1.4(GND_2) SW1.5(GND_3) SW1.6(GND_4) SW1.7(GND_5) X68.2 X68.3 X68.4 X68.5 X68.6 X68.7 X68.8 X68.9 X68.10 X68.11 X68.12 X68.13 YJ21.1(PGND_1) YJ21.2(PGND_2) YJ21.3(PGND_3) YJ21.4(PGND_4) YJ21.5(PGND_5) YJ21.6(PGND_6) YJ21.7(PGND_7) YJ21.8(PGND_8) YJ21.9(PGND_9) YJ21.10(PGND_10) YJ21.11(PGND_11) YJ21.12(PGND_12) YJ21.13(PGND_13) YJ21.14(PGND_14) YJ22.1(PGND_1) YJ22.2(PGND_2) YJ22.3(PGND_3) YJ22.4(PGND_4) YJ22.5(PGND_5) YJ22.6(PGND_6) YJ22.7(PGND_7) YJ22.8(PGND_8) YJ22.9(PGND_9) YJ22.10(PGND_10) YJ22.11(PGND_11) YJ22.12(PGND_12) YJ22.13(PGND_13) YJ22.14(PGND_14) YJ23.1(PGND_1) YJ23.2(PGND_2) YJ23.3(PGND_3) YJ23.4(PGND_4) YJ23.5(PGND_5) YJ23.6(PGND_6) YJ23.7(PGND_7) YJ23.8(PGND_8) YJ23.9(PGND_9) YJ23.10(PGND_10) YJ23.11(PGND_11) YJ23.12(PGND_12) YJ23.13(PGND_13) YJ23.14(PGND_14) YJ24.1(PGND_1) YJ24.2(PGND_2) YJ24.3(PGND_3) YJ24.4(PGND_4) YJ24.5(PGND_5) YJ24.6(PGND_6) YJ24.7(PGND_7) YJ24.8(PGND_8) YJ24.9(PGND_9) YJ24.10(PGND_10) YJ24.11(PGND_11) YJ24.12(PGND_12) YJ24.13(PGND_13) YJ24.14(PGND_14) YJ25.1(PGND_1) YJ25.2(PGND_2) YJ25.3(PGND_3) YJ25.4(PGND_4) YJ25.5(PGND_5) YJ25.6(PGND_6) YJ25.7(PGND_7) YJ25.8(PGND_8) YJ25.9(PGND_9) YJ25.10(PGND_10) YJ25.11(PGND_11) YJ25.12(PGND_12) YJ25.13(PGND_13) YJ25.14(PGND_14) YJ26.1(PGND_1) YJ26.2(PGND_2) YJ26.3(PGND_3) YJ26.4(PGND_4) YJ26.5(PGND_5) YJ26.6(PGND_6) YJ26.7(PGND_7) YJ26.8(PGND_8) YJ26.9(PGND_9) YJ26.10(PGND_10) YJ26.11(PGND_11) YJ26.12(PGND_12) YJ26.13(PGND_13) YJ26.14(PGND_14) YJ27.1(PGND_1) YJ27.2(PGND_2) YJ27.3(PGND_3) YJ27.4(PGND_4) YJ27.5(PGND_5) YJ27.6(PGND_6) YJ27.7(PGND_7) YJ27.8(PGND_8) YJ27.9(PGND_9) YJ27.10(PGND_10) YJ27.11(PGND_11) YJ27.12(PGND_12) YJ27.13(PGND_13) YJ27.14(PGND_14) YJ28.1(PGND_1) YJ28.2(PGND_2) YJ28.3(PGND_3) YJ28.4(PGND_4) YJ28.5(PGND_5) YJ28.6(PGND_6) YJ28.7(PGND_7) YJ28.8(PGND_8) YJ28.9(PGND_9) YJ28.10(PGND_10) YJ28.11(PGND_11) YJ28.12(PGND_12) YJ28.13(PGND_13) YJ28.14(PGND_14) YJ29.1(PGND_1) YJ29.2(PGND_2) YJ29.3(PGND_3) YJ29.4(PGND_4) YJ29.5(PGND_5) YJ29.6(PGND_6) YJ29.7(PGND_7) YJ29.8(PGND_8) YJ29.9(PGND_9) YJ29.10(PGND_10) YJ29.11(PGND_11) YJ29.12(PGND_12) YJ29.13(PGND_13) YJ29.14(PGND_14) YJ30.1(PGND_1) YJ30.2(PGND_2) YJ30.3(PGND_3) YJ30.4(PGND_4) YJ30.5(PGND_5) YJ30.6(PGND_6) YJ30.7(PGND_7) YJ30.8(PGND_8) YJ30.9(PGND_9) YJ30.10(PGND_10) YJ30.11(PGND_11) YJ30.12(PGND_12) YJ30.13(PGND_13) YJ30.14(PGND_14) YJ31.1(PGND_1) YJ31.2(PGND_2) YJ31.3(PGND_3) YJ31.4(PGND_4) YJ31.5(PGND_5) YJ31.6(PGND_6) YJ31.7(PGND_7) YJ31.8(PGND_8) YJ31.9(PGND_9) YJ31.10(PGND_10) YJ31.11(PGND_11) YJ31.12(PGND_12) YJ31.13(PGND_13) YJ31.14(PGND_14) YJ32.1(PGND_1) YJ32.2(PGND_2) YJ32.3(PGND_3) YJ32.4(PGND_4) YJ32.5(PGND_5) YJ32.6(PGND_6) YJ32.7(PGND_7) YJ32.8(PGND_8) YJ32.9(PGND_9) YJ32.10(PGND_10) YJ32.11(PGND_11) YJ32.12(PGND_12) YJ32.13(PGND_13) YJ32.14(PGND_14) YJ33.1(PGND_1) YJ33.2(PGND_2) YJ33.3(PGND_3) YJ33.4(PGND_4) YJ33.5(PGND_5) YJ33.6(PGND_6) YJ33.7(PGND_7) YJ33.8(PGND_8) YJ33.9(PGND_9) YJ33.10(PGND_10) YJ33.11(PGND_11) YJ33.12(PGND_12) YJ33.13(PGND_13) YJ33.14(PGND_14) YJ34.1(PGND_1) YJ34.2(PGND_2) YJ34.3(PGND_3) YJ34.4(PGND_4) YJ34.5(PGND_5) YJ34.6(PGND_6) YJ34.7(PGND_7) YJ34.8(PGND_8) YJ34.9(PGND_9) YJ34.10(PGND_10) YJ34.11(PGND_11) YJ34.12(PGND_12) YJ34.13(PGND_13) YJ34.14(PGND_14) YJ35.1(PGND_1) YJ35.2(PGND_2) YJ35.3(PGND_3) YJ35.4(PGND_4) YJ35.5(PGND_5) YJ35.6(PGND_6) YJ35.7(PGND_7) YJ35.8(PGND_8) YJ35.9(PGND_9) YJ35.10(PGND_10) YJ35.11(PGND_11) YJ35.12(PGND_12) YJ35.13(PGND_13) YJ35.14(PGND_14) YJ36.1(PGND_1) YJ36.2(PGND_2) YJ36.3(PGND_3) YJ36.4(PGND_4) YJ36.5(PGND_5) YJ36.6(PGND_6) YJ36.7(PGND_7) YJ36.8(PGND_8) YJ36.9(PGND_9) YJ36.10(PGND_10) YJ36.11(PGND_11) YJ36.12(PGND_12) YJ36.13(PGND_13) YJ36.14(PGND_14)
VCC1_0: C2174.2 C2175.1 L236.1 YJ21.A30(VCC1_1)
VCC1_1: C2176.2 C2177.1 L237.1 YJ21.B30(VCC1_2)
VCC1_2: C2203.2 C2205.1 L248.1 YJ22.D30(VCC1_4)
VCC1_3: C2206.2 C2207.1 L249.1 YJ22.C30(VCC1_3)
VCC1_4: C2171.2 C2172.1 L238.1 YJ21.C30(VCC1_3)
VCC1_5: C2173.2 C2178.1 L239.1 YJ21.D30(VCC1_4)
VCC1_6: C2204.2 C2208.1 L250.1 YJ22.B30(VCC1_2)
VCC1_7: C2209.2 C2210.1 L251.1 YJ22.A30(VCC1_1)
VCC1_8: C2238.2 C2239.1 L263.1 YJ23.A30(VCC1_1)
VCC1_9: C2240.2 C2242.1 L261.1 YJ23.B30(VCC1_2)
VCC1_10: C2271.2 C2272.1 L272.1 YJ24.D30(VCC1_4)
VCC1_11: C2273.2 C2274.1 L274.1 YJ24.C30(VCC1_3)
VCC1_12: C2235.2 C2236.1 L260.1 YJ23.C30(VCC1_3)
VCC1_13: C2237.2 C2241.1 L262.1 YJ23.D30(VCC1_4)
VCC1_14: C2267.2 C2268.1 L275.1 YJ24.B30(VCC1_2)
VCC1_15: C2269.2 C2270.1 L273.1 YJ24.A30(VCC1_1)
VCC1_16: C2299.2 C2304.1 L286.1 YJ25.A30(VCC1_1)
VCC1_17: C2305.2 C2306.1 L287.1 YJ25.B30(VCC1_2)
VCC1_18: C2332.2 C2333.1 L296.1 YJ26.D30(VCC1_4)
VCC1_19: C2334.2 C2335.1 L299.1 YJ26.C30(VCC1_3)
VCC1_20: C2300.2 C2301.1 L284.1 YJ25.C30(VCC1_3)
VCC1_21: C2302.2 C2303.1 L285.1 YJ25.D30(VCC1_4)
VCC1_22: C2331.2 C2336.1 L297.1 YJ26.B30(VCC1_2)
VCC1_23: C2337.2 C2338.1 L298.1 YJ26.A30(VCC1_1)
VCC1_24: C2366.2 C2367.1 L311.1 YJ27.A30(VCC1_1)
VCC1_25: C2368.2 C2370.1 L309.1 YJ27.B30(VCC1_2)
VCC1_26: C2395.2 C2396.1 L320.1 YJ28.D30(VCC1_4)
VCC1_27: C2400.2 C2401.1 L322.1 YJ28.C30(VCC1_3)
VCC1_28: C2363.2 C2364.1 L308.1 YJ27.C30(VCC1_3)
VCC1_29: C2365.2 C2369.1 L310.1 YJ27.D30(VCC1_4)
VCC1_30: C2397.2 C2398.1 L323.1 YJ28.B30(VCC1_2)
VCC1_31: C2399.2 C2402.1 L321.1 YJ28.A30(VCC1_1)
VCC1_32: C2427.2 C2428.1 L334.1 YJ29.A30(VCC1_1)
VCC1_33: C2429.2 C2430.1 L335.1 YJ29.B30(VCC1_2)
VCC1_34: C2459.2 C2460.1 L344.1 YJ30.D30(VCC1_4)
VCC1_35: C2461.2 C2462.1 L345.1 YJ30.C30(VCC1_3)
VCC1_36: C2431.2 C2432.1 L332.1 YJ29.C30(VCC1_3)
VCC1_37: C2433.2 C2434.1 L333.1 YJ29.D30(VCC1_4)
VCC1_38: C2463.2 C2464.1 L346.1 YJ30.B30(VCC1_2)
VCC1_39: C2465.2 C2466.1 L347.1 YJ30.A30(VCC1_1)
VCC1_40: C2494.2 C2495.1 L357.1 YJ31.A30(VCC1_1)
VCC1_41: C2496.2 C2498.1 L358.1 YJ31.B30(VCC1_2)
VCC1_42: C2526.2 C2527.1 L368.1 YJ32.D30(VCC1_4)
VCC1_43: C2528.2 C2529.1 L371.1 YJ32.C30(VCC1_3)
VCC1_44: C2491.2 C2492.1 L356.1 YJ31.C30(VCC1_3)
VCC1_45: C2493.2 C2497.1 L359.1 YJ31.D30(VCC1_4)
VCC1_46: C2523.2 C2524.1 L369.1 YJ32.B30(VCC1_2)
VCC1_47: C2525.2 C2530.1 L370.1 YJ32.A30(VCC1_1)
VCC1_48: C2555.2 C2556.1 L383.1 YJ33.A30(VCC1_1)
VCC1_49: C2557.2 C2558.1 L381.1 YJ33.B30(VCC1_2)
VCC1_50: C2591.2 C2592.1 L393.1 YJ34.D30(VCC1_4)
VCC1_51: C2593.2 C2594.1 L394.1 YJ34.C30(VCC1_3)
VCC1_52: C2559.2 C2560.1 L380.1 YJ33.C30(VCC1_3)
VCC1_53: C2561.2 C2562.1 L382.1 YJ33.D30(VCC1_4)
VCC1_54: C2587.2 C2588.1 L395.1 YJ34.B30(VCC1_2)
VCC1_55: C2589.2 C2590.1 L392.1 YJ34.A30(VCC1_1)
VCC1_56: C2620.2 C2624.1 L406.1 YJ35.A30(VCC1_1)
VCC1_57: C2625.2 C2626.1 L407.1 YJ35.B30(VCC1_2)
VCC1_58: C2654.2 C2655.1 L416.1 YJ36.D30(VCC1_4)
VCC1_59: C2656.2 C2657.1 L419.1 YJ36.C30(VCC1_3)
VCC1_60: C2619.2 C2621.1 L404.1 YJ35.C30(VCC1_3)
VCC1_61: C2622.2 C2623.1 L405.1 YJ35.D30(VCC1_4)
VCC1_62: C2651.2 C2652.1 L417.1 YJ36.B30(VCC1_2)
VCC1_63: C2653.2 C2658.1 L418.1 YJ36.A30(VCC1_1)
VCC_RX_0: C2149.2 C2150.1 L230.1 YJ21.A10(VCC RX_1)
VCC_RX_1: C2153.2 C2154.1 L231.1 YJ21.B10(VCC RX_2)
VCC_RX_2: C2181.2 C2182.1 L240.1 YJ22.D10(VCC RX_4)
VCC_RX_3: C2185.2 C2194.1 L241.1 YJ22.C10(VCC RX_3)
VCC_RX_4: C2157.2 C2158.1 L228.1 YJ21.C10(VCC RX_3)
VCC_RX_5: C2161.2 C2162.1 L229.1 YJ21.D10(VCC RX_4)
VCC_RX_6: C2188.2 C2189.1 L242.1 YJ22.B10(VCC RX_2)
VCC_RX_7: C2192.2 C2193.1 L243.1 YJ22.A10(VCC RX_1)
VCC_RX_8: C2219.2 C2220.1 L254.1 YJ23.A10(VCC RX_1)
VCC_RX_9: C2224.2 C2225.1 L255.1 YJ23.B10(VCC RX_2)
VCC_RX_10: C2250.2 C2251.1 L264.1 YJ24.D10(VCC RX_4)
VCC_RX_11: C2255.2 C2258.1 L265.1 YJ24.C10(VCC RX_3)
VCC_RX_12: C2213.2 C2214.1 L252.1 YJ23.C10(VCC RX_3)
VCC_RX_13: C2223.2 C2226.1 L253.1 YJ23.D10(VCC RX_4)
VCC_RX_14: C2245.2 C2246.1 L266.1 YJ24.B10(VCC RX_2)
VCC_RX_15: C2256.2 C2257.1 L267.1 YJ24.A10(VCC RX_1)
VCC_RX_16: C2285.2 C2286.1 L278.1 YJ25.A10(VCC RX_1)
VCC_RX_17: C2289.2 C2290.1 L279.1 YJ25.B10(VCC RX_2)
VCC_RX_18: C2311.2 C2312.1 L288.1 YJ26.D10(VCC RX_4)
VCC_RX_19: C2315.2 C2322.1 L289.1 YJ26.C10(VCC RX_3)
VCC_RX_20: C2277.2 C2278.1 L276.1 YJ25.C10(VCC RX_3)
VCC_RX_21: C2281.2 C2282.1 L277.1 YJ25.D10(VCC RX_4)
VCC_RX_22: C2316.2 C2317.1 L290.1 YJ26.B10(VCC RX_2)
VCC_RX_23: C2320.2 C2321.1 L291.1 YJ26.A10(VCC RX_1)
VCC_RX_24: C2348.2 C2349.1 L302.1 YJ27.A10(VCC RX_1)
VCC_RX_25: C2352.2 C2353.1 L303.1 YJ27.B10(VCC RX_2)
VCC_RX_26: C2379.2 C2380.1 L312.1 YJ28.D10(VCC RX_4)
VCC_RX_27: C2383.2 C2386.1 L313.1 YJ28.C10(VCC RX_3)
VCC_RX_28: C2343.2 C2344.1 L300.1 YJ27.C10(VCC RX_3)
VCC_RX_29: C2347.2 C2354.1 L301.1 YJ27.D10(VCC RX_4)
VCC_RX_30: C2373.2 C2374.1 L314.1 YJ28.B10(VCC RX_2)
VCC_RX_31: C2384.2 C2385.1 L315.1 YJ28.A10(VCC RX_1)
VCC_RX_32: C2408.2 C2409.1 L326.1 YJ29.A10(VCC RX_1)
VCC_RX_33: C2412.2 C2417.1 L327.1 YJ29.B10(VCC RX_2)
VCC_RX_34: C2444.2 C2445.1 L336.1 YJ30.D10(VCC RX_4)
VCC_RX_35: C2448.2 C2449.1 L337.1 YJ30.C10(VCC RX_3)
VCC_RX_36: C2405.2 C2413.1 L324.1 YJ29.C10(VCC RX_3)
VCC_RX_37: C2416.2 C2418.1 L325.1 YJ29.D10(VCC RX_4)
VCC_RX_38: C2437.2 C2438.1 L338.1 YJ30.B10(VCC RX_2)
VCC_RX_39: C2441.2 C2450.1 L339.1 YJ30.A10(VCC RX_1)
VCC_RX_40: C2476.2 C2477.1 L350.1 YJ31.A10(VCC RX_1)
VCC_RX_41: C2480.2 C2481.1 L351.1 YJ31.B10(VCC RX_2)
VCC_RX_42: C2503.2 C2504.1 L360.1 YJ32.D10(VCC RX_4)
VCC_RX_43: C2507.2 C2514.1 L361.1 YJ32.C10(VCC RX_3)
VCC_RX_44: C2471.2 C2472.1 L348.1 YJ31.C10(VCC RX_3)
VCC_RX_45: C2475.2 C2482.1 L349.1 YJ31.D10(VCC RX_4)
VCC_RX_46: C2508.2 C2509.1 L362.1 YJ32.B10(VCC RX_2)
VCC_RX_47: C2512.2 C2513.1 L363.1 YJ32.A10(VCC RX_1)
VCC_RX_48: C2539.2 C2540.1 L374.1 YJ33.A10(VCC RX_1)
VCC_RX_49: C2544.2 C2545.1 L375.1 YJ33.B10(VCC RX_2)
VCC_RX_50: C2570.2 C2571.1 L384.1 YJ34.D10(VCC RX_4)
VCC_RX_51: C2575.2 C2578.1 L385.1 YJ34.C10(VCC RX_3)
VCC_RX_52: C2533.2 C2534.1 L372.1 YJ33.C10(VCC RX_3)
VCC_RX_53: C2543.2 C2546.1 L373.1 YJ33.D10(VCC RX_4)
VCC_RX_54: C2565.2 C2566.1 L386.1 YJ34.B10(VCC RX_2)
VCC_RX_55: C2576.2 C2577.1 L387.1 YJ34.A10(VCC RX_1)
VCC_RX_56: C2597.2 C2598.1 L398.1 YJ35.A10(VCC RX_1)
VCC_RX_57: C2601.2 C2602.1 L399.1 YJ35.B10(VCC RX_2)
VCC_RX_58: C2631.2 C2632.1 L408.1 YJ36.D10(VCC RX_4)
VCC_RX_59: C2635.2 C2642.1 L409.1 YJ36.C10(VCC RX_3)
VCC_RX_60: C2605.2 C2606.1 L396.1 YJ35.C10(VCC RX_3)
VCC_RX_61: C2609.2 C2610.1 L397.1 YJ35.D10(VCC RX_4)
VCC_RX_62: C2636.2 C2637.1 L410.1 YJ36.B10(VCC RX_2)
VCC_RX_63: C2640.2 C2641.1 L411.1 YJ36.A10(VCC RX_1)
VCC_TX_0: C2167.2 C2168.1 L234.1 YJ21.A29(VCC TX_1)
VCC_TX_1: C2169.2 C2170.1 L235.1 YJ21.B29(VCC TX_2)
VCC_TX_2: C2195.2 C2196.1 L244.1 YJ22.D29(VCC TX_4)
VCC_TX_3: C2197.2 C2198.1 L245.1 YJ22.C29(VCC TX_3)
VCC_TX_4: C2163.2 C2164.1 L232.1 YJ21.C29(VCC TX_3)
VCC_TX_5: C2165.2 C2166.1 L233.1 YJ21.D29(VCC TX_4)
VCC_TX_6: C2199.2 C2200.1 L246.1 YJ22.B29(VCC TX_2)
VCC_TX_7: C2201.2 C2202.1 L247.1 YJ22.A29(VCC TX_1)
VCC_TX_8: C2227.2 C2228.1 L258.1 YJ23.A29(VCC TX_1)
VCC_TX_9: C2229.2 C2230.1 L259.1 YJ23.B29(VCC TX_2)
VCC_TX_10: C2259.2 C2264.1 L268.1 YJ24.D29(VCC TX_4)
VCC_TX_11: C2265.2 C2266.1 L269.1 YJ24.C29(VCC TX_3)
VCC_TX_12: C2231.2 C2232.1 L256.1 YJ23.C29(VCC TX_3)
VCC_TX_13: C2233.2 C2234.1 L257.1 YJ23.D29(VCC TX_4)
VCC_TX_14: C2260.2 C2261.1 L270.1 YJ24.B29(VCC TX_2)
VCC_TX_15: C2262.2 C2263.1 L271.1 YJ24.A29(VCC TX_1)
VCC_TX_16: C2293.2 C2294.1 L282.1 YJ25.A29(VCC TX_1)
VCC_TX_17: C2295.2 C2296.1 L283.1 YJ25.B29(VCC TX_2)
VCC_TX_18: C2323.2 C2324.1 L292.1 YJ26.D29(VCC TX_4)
VCC_TX_19: C2325.2 C2326.1 L293.1 YJ26.C29(VCC TX_3)
VCC_TX_20: C2291.2 C2292.1 L280.1 YJ25.C29(VCC TX_3)
VCC_TX_21: C2297.2 C2298.1 L281.1 YJ25.D29(VCC TX_4)
VCC_TX_22: C2327.2 C2328.1 L294.1 YJ26.B29(VCC TX_2)
VCC_TX_23: C2329.2 C2330.1 L295.1 YJ26.A29(VCC TX_1)
VCC_TX_24: C2358.2 C2359.1 L306.1 YJ27.A29(VCC TX_1)
VCC_TX_25: C2361.2 C2362.1 L307.1 YJ27.B29(VCC TX_2)
VCC_TX_26: C2389.2 C2390.1 L316.1 YJ28.D29(VCC TX_4)
VCC_TX_27: C2391.2 C2392.1 L317.1 YJ28.C29(VCC TX_3)
VCC_TX_28: C2355.2 C2356.1 L304.1 YJ27.C29(VCC TX_3)
VCC_TX_29: C2357.2 C2360.1 L305.1 YJ27.D29(VCC TX_4)
VCC_TX_30: C2387.2 C2388.1 L318.1 YJ28.B29(VCC TX_2)
VCC_TX_31: C2393.2 C2394.1 L319.1 YJ28.A29(VCC TX_1)
VCC_TX_32: C2419.2 C2420.1 L330.1 YJ29.A29(VCC TX_1)
VCC_TX_33: C2421.2 C2422.1 L331.1 YJ29.B29(VCC TX_2)
VCC_TX_34: C2451.2 C2452.1 L340.1 YJ30.D29(VCC TX_4)
VCC_TX_35: C2453.2 C2458.1 L341.1 YJ30.C29(VCC TX_3)
VCC_TX_36: C2423.2 C2424.1 L328.1 YJ29.C29(VCC TX_3)
VCC_TX_37: C2425.2 C2426.1 L329.1 YJ29.D29(VCC TX_4)
VCC_TX_38: C2454.2 C2455.1 L342.1 YJ30.B29(VCC TX_2)
VCC_TX_39: C2456.2 C2457.1 L343.1 YJ30.A29(VCC TX_1)
VCC_TX_40: C2486.2 C2487.1 L354.1 YJ31.A29(VCC TX_1)
VCC_TX_41: C2489.2 C2490.1 L355.1 YJ31.B29(VCC TX_2)
VCC_TX_42: C2517.2 C2518.1 L364.1 YJ32.D29(VCC TX_4)
VCC_TX_43: C2519.2 C2520.1 L365.1 YJ32.C29(VCC TX_3)
VCC_TX_44: C2483.2 C2484.1 L352.1 YJ31.C29(VCC TX_3)
VCC_TX_45: C2485.2 C2488.1 L353.1 YJ31.D29(VCC TX_4)
VCC_TX_46: C2515.2 C2516.1 L366.1 YJ32.B29(VCC TX_2)
VCC_TX_47: C2521.2 C2522.1 L367.1 YJ32.A29(VCC TX_1)
VCC_TX_48: C2547.2 C2548.1 L378.1 YJ33.A29(VCC TX_1)
VCC_TX_49: C2549.2 C2550.1 L379.1 YJ33.B29(VCC TX_2)
VCC_TX_50: C2580.2 C2584.1 L388.1 YJ34.D29(VCC TX_4)
VCC_TX_51: C2585.2 C2586.1 L389.1 YJ34.C29(VCC TX_3)
VCC_TX_52: C2551.2 C2552.1 L376.1 YJ33.C29(VCC TX_3)
VCC_TX_53: C2553.2 C2554.1 L377.1 YJ33.D29(VCC TX_4)
VCC_TX_54: C2579.2 C2581.1 L390.1 YJ34.B29(VCC TX_2)
VCC_TX_55: C2582.2 C2583.1 L391.1 YJ34.A29(VCC TX_1)
VCC_TX_56: C2613.2 C2614.1 L402.1 YJ35.A29(VCC TX_1)
VCC_TX_57: C2615.2 C2616.1 L403.1 YJ35.B29(VCC TX_2)
VCC_TX_58: C2643.2 C2644.1 L412.1 YJ36.D29(VCC TX_4)
VCC_TX_59: C2645.2 C2646.1 L413.1 YJ36.C29(VCC TX_3)
VCC_TX_60: C2611.2 C2612.1 L400.1 YJ35.C29(VCC TX_3)
VCC_TX_61: C2617.2 C2618.1 L401.1 YJ35.D29(VCC TX_4)
VCC_TX_62: C2647.2 C2648.1 L414.1 YJ36.B29(VCC TX_2)
VCC_TX_63: C2649.2 C2650.1 L415.1 YJ36.A29(VCC TX_1)
VCCS: C3943.1 R3670.2 U140.43(VCCS)
VDD1.2V: C221.1 C301.1 C305.1 C306.1 C307.1 C308.1 C2723.1 C2866.1 C3095.1 CD16.1 L24.2 L26.1 L437.2 L444.2 L445.2 R1191.1 R3272.2 X28.1
VDD1.2V_EN: Q49.3(C) R3540.2 R3549.1 U44.1(EN)
VDD1.8V: C74.1 C82.1 C86.1 C90.1 C100.1 C2666.1 C2843.1 C2860.1 C2997.1 C3051.1 C3066.1 C3190.1 C3629.1 C3633.1 C3634.1 C3635.1 C3636.2 L422.2 L425.2 L426.2 L428.2 L432.2 L433.2 L436.2 L438.2 L440.2 L441.2 L442.2 L453.1 R3303.2 R3515.1 U1.BG33(VDD1P8) X258.1
VDD1.8V_EN: Q53.3(C) R3553.2 R3559.1 U128.5(EN)
VDD3.3_CLK_MCU: C3434.1 C3435.1 C3465.2 C3606.1 C3609.1 C3610.1 C3611.1 L446.2 L448.2 R3316.2 R3507.1 R3548.1 U126.1(OUT_1) U126.2(OUT_2) X253.1
VDD3.3_CLK_MCU_EN: Q3.3(C) R3528.2 R3534.1 U126.5(EN)
VDD3.3V: C1.2 C2.1 C3.1 C4.1 C27.1 C28.1 C29.1 C30.1 C49.1 C50.1 C51.1 C52.1 C53.1 C54.1 C2684.1 C2695.1 C2714.1 C2720.1 C2754.1 C2758.1 C2765.1 C2774.1 C2787.1 C2791.1 C2857.1 C2894.1 C2933.1 C2952.1 C2971.1 C3011.1 C3021.1 C3034.1 C3036.1 C3044.1 C3047.1 C3067.1 C3079.1 C3087.1 C3112.1 C3116.1 C3130.1 C3152.1 C3184.1 C3189.1 C3478.1 C3620.1 C3625.1 C3626.1 C3627.1 C3628.2 L449.1 L452.1 R2.1 R3.1 R4.1 R6.1 R7.1 R9.1 R18.1 R19.1 R22.2 R23.2 R28.1 R2038.1 R2039.2 R2043.2 R2044.2 R2047.2 R2048.2 R2049.2 R2050.2 R2051.2 R2052.2 R2053.2 R2054.2 R2055.2 R2056.2 R2057.2 R2058.2 R2059.2 R2060.2 R2061.2 R2062.2 R2063.2 R2064.2 R2065.2 R2066.2 R2067.2 R2068.2 R2069.2 R2070.2 R2071.2 R2072.2 R2073.2 R2074.2 R2075.2 R2076.2 R3133.2 R3255.2 R3505.1 R3512.1 R3551.1 U1.AB32(VDDO33_17) U1.AB35(VDDO33_18) U1.BJ20(VDDO33_19) U1.BJ24(VDDO33_20) U1.BJ26(IP_VDDO_0) U1.BJ43(VDDO33_21) U1.BJ47(VDDO33_22) U1.BK26(IP_VDDO_1) U1.BL18(VDDO33_23) U1.BL22(VDDO33_24) U1.BL26(VDDO33_25) U1.BL27(IP_VDDO_2) U1.BL41(VDDO33_26) U1.BL45(VDDO33_27) U1.BL49(VDDO33_28) U1.BN16(VDDO33_29) U1.BN51(VDDO33_30) U1.G51(VDDO33_1) U1.K16(VDDO33_2) U1.M51(VDDO33_3) U1.P15(VDDO33_4) U1.T20(VDDO33_5) U1.T26(VDDO33_6) U1.T32(VDDO33_7) U1.T38(VDDO33_8) U1.T44(VDDO33_9) U1.T50(VDDO33_10) U1.U35(VDDO33_11) U1.V17(VDDO33_12) U1.V23(VDDO33_13) U1.V29(VDDO33_14) U1.V41(VDDO33_15) U1.V47(VDDO33_16) U116.8(VCC) X256.1
VDD3.3V_EN: Q52.3(C) R3554.2 R3558.1 U127.5(EN)
VDD5.0V: C3604.1 C3605.1 C3607.1 C3608.1 C3615.1 C3616.1 C3617.1 C3618.2 C3798.1 C3809.1 C3810.1 C3811.1 C3812.1 C3821.1 C3832.1 C3833.1 C3834.1 C3835.1 C3844.1 C3855.1 C3856.1 C3857.1 C3858.1 C3867.1 C3878.1 C3879.1 C3880.1 C3881.1 C3890.1 C3901.1 C3902.1 C3903.1 C3904.1 C3913.1 C3924.1 C3925.1 C3926.1 C3927.1 D435.1(LGCTRL) D435.2(VCC) D435.3(PVCC) D436.1(LGCTRL) D436.2(VCC) D436.3(PVCC) D437.1(LGCTRL) D437.2(VCC) D437.3(PVCC) D438.1(LGCTRL) D438.2(VCC) D438.3(PVCC) D439.1(LGCTRL) D439.2(VCC) D439.3(PVCC) D440.1(LGCTRL) D440.2(VCC) D440.3(PVCC) D441.1(LGCTRL) D441.2(VCC) D441.3(PVCC) D442.1(LGCTRL) D442.2(VCC) D442.3(PVCC) D443.1(LGCTRL) D443.2(VCC) D443.3(PVCC) D444.1(LGCTRL) D444.2(VCC) D444.3(PVCC) D445.1(LGCTRL) D445.2(VCC) D445.3(PVCC) D446.1(LGCTRL) D446.2(VCC) D446.3(PVCC) L451.1 R3296.2 R3508.1 R3536.1 R3609.1 R3616.1 R3623.1 R3630.1 R3637.1 R3644.1 U126.7(IN_1) U126.8(IN_2) U134.9(VCC) U135.9(VCC) U136.9(VCC) U137.9(VCC) U138.9(VCC) U139.9(VCC) X254.1
VDD5.0V_EN: Q43.3(C) R3521.2 R3524.1 U125.5(EN)
VDD12V: C11.2 C12.2 C13.2 C297.1 C298.1 C299.1 C2109.1 C2110.1 C3488.2 C3489.2 C3490.2 C3612.1 C3613.1 C3614.1 C3622.1 C3623.1 C3624.1 C3630.1 C3631.1 C3632.1 C3639.1 C3640.1 C3641.1 C3650.1 C3651.1 C3654.1 C3655.1 C3656.1 C3657.1 C3658.1 C3659.1 C3660.1 C3661.1 C3662.1 C3663.1 C3664.1 C3665.1 C3666.1 C3667.1 C3692.1 C3694.1 C3695.1 C3696.1 C3697.1 C3698.1 C3699.1 C3701.1 C3702.1 C3703.1 C3704.1 C3705.1 C3706.1 C3707.1 C3708.1 C3709.1 CD1.1 CD63.1 CD65.1 CD66.1 CD67.1 CD68.1 L226.2 R3239.1 R3240.1 R3521.1 R3522.1 R3525.1 R3527.1 R3528.1 R3529.1 R3532.1 R3538.1 R3539.1 R3540.1 R3543.1 R3546.1 R3553.1 R3554.1 R3556.1 R3560.1 R3564.1 R3567.1 U44.8(VIN) U125.3(VIN) U127.3(VIN) U128.3(VIN) U129.3(VIN) U130.12(VIN_6) U130.13(VIN_5) U130.14(VIN_4) U130.15(VIN_3) U130.16(VIN_2) U130.17(VIN_1) U130.19(VDD) U131.12(VIN_6) U131.13(VIN_5) U131.14(VIN_4) U131.15(VIN_3) U131.16(VIN_2) U131.17(VIN_1) U131.19(VDD) U132.12(VIN_6) U132.13(VIN_5) U132.14(VIN_4) U132.15(VIN_3) U132.16(VIN_2) U132.17(VIN_1) U132.19(VDD) U133.12(VIN_6) U133.13(VIN_5) U133.14(VIN_4) U133.15(VIN_3) U133.16(VIN_2) U133.17(VIN_1) U133.19(VDD) YJ1.6 YJ1.7 YJ1.8 YJ1.9 YJ1.10 YJ2.6 YJ2.7 YJ2.8 YJ2.9 YJ2.10
VDD_CORE: C870.1 C871.1 C872.1 C873.1 C874.1 C875.1 C876.1 C877.1 C878.1 C879.1 C882.1 C883.1 C884.1 C885.1 C886.1 C887.1 C923.1 C924.1 C925.1 C926.1 C927.1 C928.1 C929.1 C930.1 C931.1 C932.1 C933.1 C934.1 C935.1 C936.1 C937.1 C938.1 C939.1 C940.1 C941.1 C942.1 C943.1 C944.1 C945.1 C946.1 C947.1 C948.1 C957.1 C958.1 C959.1 C960.1 C961.1 C962.1 C963.1 C964.1 C965.1 C966.1 C967.1 C968.1 C969.1 C970.1 C971.1 C972.1 C973.1 C974.1 C975.1 C976.1 C977.1 C978.1 C979.1 C980.1 C981.1 C982.1 C983.1 C984.1 C985.1 C986.1 C987.1 C988.1 C989.1 C990.1 C991.1 C992.1 C993.1 C994.1 C995.1 C996.1 C997.1 C998.1 C999.1 C1000.1 C1001.1 C1002.1 C1003.1 C1004.1 C1005.1 C1006.1 C1007.1 C1008.1 C1009.1 C1010.1 C1011.1 C1012.1 C1013.1 C1014.1 C1015.1 C1016.1 C1017.1 C1018.1 C1019.1 C1020.1 C1021.1 C1022.1 C1023.1 C1024.1 C1025.1 C1026.1 C1027.1 C1028.1 C1029.1 C1030.1 C1031.1 C1032.1 C1033.1 C1034.1 C1035.1 C1036.1 C1037.1 C1038.1 C1039.1 C1040.1 C1041.1 C1042.1 C1043.1 C1044.1 C1045.1 C1046.1 C1047.1 C1048.1 C1049.1 C1050.1 C1051.1 C1144.1 C1145.1 C1146.1 C1147.1 C1148.1 C1149.1 C1150.1 C1151.1 C1152.1 C1153.1 C1154.1 C1155.1 C1156.1 C1157.1 C1158.1 C1159.1 C1160.1 C1161.1 C1162.1 C1163.1 C1164.1 C1165.1 C1166.1 C1167.1 C1168.1 C1169.1 C1170.1 C1171.1 C1172.1 C1173.1 C1174.1 C1175.1 C1176.1 C1177.1 C1178.1 C1179.1 C1180.1 C1181.1 C1182.1 C1183.1 C1184.1 C1185.1 C1186.1 C1187.1 C1188.1 C1189.1 C1190.1 C1191.1 C1192.1 C1193.1 C1194.1 C1195.1 C1196.1 C1197.1 C1198.1 C1199.1 C1200.1 C1201.1 C1202.1 C1203.1 C1204.1 C1205.1 C1206.1 C1207.1 C1208.1 C1209.1 C1210.1 C1211.1 C1212.1 C1213.1 C1214.1 C1215.1 C1216.1 C1217.1 C1218.1 C1219.1 C1220.1 C1221.1 C1222.1 C1223.1 C1224.1 C1225.1 C1226.1 C1227.1 C1228.1 C1229.1 C1230.1 C1231.1 C1232.1 C1233.1 C1234.1 C1235.1 C1236.1 C1237.1 C1238.1 C1239.1 C1240.1 C1241.1 C1242.1 C1243.1 C1244.1 C1245.1 C1246.1 C1247.1 C1248.1 C1249.1 C1250.1 C1251.1 C1252.1 C1253.1 C1254.1 C1255.1 C1256.1 C1257.1 C1258.1 C1259.1 C1260.1 C1261.1 C1262.1 C1263.1 C1264.1 C1265.1 C1266.1 C1267.1 C1268.1 C1269.1 C2659.1 C2662.1 C2663.1 C2669.1 C2671.1 C2672.1 C2673.1 C2675.1 C2677.1 C2680.1 C2686.1 C2691.1 C2697.1 C2698.1 C2700.1 C2701.1 C2702.1 C2707.1 C2708.1 C2710.1 C2715.1 C2724.1 C2725.1 C2726.1 C2730.1 C2732.1 C2733.1 C2736.1 C2740.1 C2741.1 C2745.1 C2748.1 C2749.1 C2750.1 C2755.1 C2756.1 C2759.1 C2760.1 C2761.1 C2768.1 C2772.1 C2775.1 C2784.1 C2788.1 C2789.1 C2790.1 C2792.1 C2796.1 C2797.1 C2800.1 C2802.1 C2803.1 C2804.1 C2810.1 C2811.1 C2813.1 C2814.1 C2817.1 C2823.1 C2825.1 C2826.1 C2828.1 C2829.1 C2830.1 C2834.1 C2835.1 C2836.1 C2837.1 C2838.1 C2847.1 C2848.1 C2851.1 C2859.1 C2861.1 C2862.1 C2864.1 C2867.1 C2870.1 C2871.1 C2874.1 C2875.1 C2876.1 C2879.1 C2881.1 C2882.1 C2886.1 C2888.1 C2893.1 C2895.1 C2896.1 C2900.1 C2905.1 C2908.1 C2909.1 C2910.1 C2912.1 C2913.1 C2914.1 C2915.1 C2917.1 C2920.1 C2922.1 C2923.1 C2926.1 C2930.1 C2934.1 C2936.1 C2937.1 C2941.1 C2943.1 C2946.1 C2947.1 C2948.1 C2949.1 C2950.1 C2954.1 C2960.1 C2961.1 C2963.1 C2964.1 C2965.1 C2966.1 C2970.1 C2978.1 C2982.1 C2983.1 C2985.1 C2986.1 C2988.1 C2989.1 C2994.1 C2998.1 C2999.1 C3000.1 C3003.1 C3004.1 C3005.1 C3009.1 C3020.1 C3022.1 C3025.1 C3035.1 C3037.1 C3039.1 C3045.1 C3053.1 C3056.1 C3057.1 C3060.1 C3063.1 C3070.1 C3071.1 C3072.1 C3075.1 C3078.1 C3080.1 C3088.1 C3091.1 C3093.1 C3098.1 C3105.1 C3110.1 C3119.1 C3126.1 C3127.1 C3131.1 C3136.1 C3139.1 C3143.1 C3146.1 C3157.1 C3159.1 C3160.1 C3161.1 C3163.1 C3167.1 C3169.1 C3170.1 C3173.1 C3180.1 C3181.1 C3182.1 C3191.1 C3817.1 C3818.1 C3819.1 C3820.1 C3840.1 C3841.1 C3842.1 C3843.1 C3863.1 C3864.1 C3865.1 C3866.1 C3886.1 C3887.1 C3888.1 C3889.1 C3909.1 C3910.1 C3911.1 C3912.1 CD69.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 L491.2 L492.1 L493.2 L494.1 L495.2 L496.1 L497.2 L498.1 L499.2 L500.1 R3131.1 R3275.2 U1.AB21(VDD_258) U1.AB23(VDD_259) U1.AB25(VDD_260) U1.AB27(VDD_261) U1.AB29(VDD_1) U1.AB31(VDD_2) U1.AB37(VDD_3) U1.AB39(VDD_4) U1.AB41(VDD_5) U1.AB43(VDD_6) U1.AB45(VDD_7) U1.AB47(VDD_8) U1.AC20(VDD_9) U1.AC22(VDD_10) U1.AC24(VDD_11) U1.AC26(VDD_12) U1.AC28(VDD_13) U1.AC30(VDD_14) U1.AC36(VDD_15) U1.AC38(VDD_16) U1.AC40(VDD_17) U1.AC42(VDD_18) U1.AC44(VDD_19) U1.AC46(VDD_20) U1.AD21(VDD_21) U1.AD23(VDD_22) U1.AD25(VDD_23) U1.AD27(VDD_24) U1.AD29(VDD_25) U1.AD31(VDD_26) U1.AD32(VDD_27) U1.AD35(VDD_28) U1.AD37(VDD_29) U1.AD39(VDD_30) U1.AD41(VDD_31) U1.AD43(VDD_32) U1.AD45(VDD_33) U1.AD47(VDD_34) U1.AE20(VDD_35) U1.AE22(VDD_36) U1.AE24(VDD_37) U1.AE26(VDD_38) U1.AE28(VDD_39) U1.AE30(VDD_40) U1.AE32(VDD_41) U1.AE34(VDD_42) U1.AE36(VDD_43) U1.AE38(VDD_44) U1.AE40(VDD_45) U1.AE42(VDD_46) U1.AE44(VDD_47) U1.AE46(VDD_48) U1.AF21(VDD_49) U1.AF23(VDD_50) U1.AF25(VDD_51) U1.AF27(VDD_52) U1.AF29(VDD_53) U1.AF31(VDD_54) U1.AF33(VDD_55) U1.AF35(VDD_56) U1.AF37(VDD_57) U1.AF39(VDD_58) U1.AF41(VDD_59) U1.AF43(VDD_60) U1.AF45(VDD_61) U1.AF47(VDD_62) U1.AG20(VDD_63) U1.AG22(VDD_64) U1.AG24(VDD_65) U1.AG26(VDD_66) U1.AG28(VDD_67) U1.AG30(VDD_68) U1.AG32(VDD_69) U1.AG34(VDD_70) U1.AG36(VDD_71) U1.AG38(VDD_72) U1.AG40(VDD_73) U1.AG42(VDD_74) U1.AG44(VDD_75) U1.AG46(VDD_76) U1.AH21(VDD_77) U1.AH23(VDD_78) U1.AH25(VDD_79) U1.AH27(VDD_80) U1.AH29(VDD_81) U1.AH31(VDD_82) U1.AH33(VDD_83) U1.AH35(VDD_84) U1.AH37(VDD_85) U1.AH39(VDD_86) U1.AH41(VDD_87) U1.AH43(VDD_88) U1.AH45(VDD_89) U1.AH47(VDD_90) U1.AJ20(VDD_91) U1.AJ22(VDD_92) U1.AJ24(VDD_93) U1.AJ26(VDD_94) U1.AJ28(VDD_95) U1.AJ30(VDD_96) U1.AJ32(VDD_97) U1.AJ34(VDD_98) U1.AJ36(VDD_99) U1.AJ38(VDD_100) U1.AJ40(VDD_101) U1.AJ42(VDD_102) U1.AJ44(VDD_103) U1.AJ46(VDD_104) U1.AK21(VDD_105) U1.AK23(VDD_106) U1.AK25(VDD_107) U1.AK27(VDD_108) U1.AK29(VDD_109) U1.AK31(VDD_110) U1.AK33(VDD_111) U1.AK35(VDD_112) U1.AK37(VDD_113) U1.AK39(VDD_114) U1.AK41(VDD_115) U1.AK43(VDD_116) U1.AK45(VDD_117) U1.AK47(VDD_118) U1.AL20(VDD_119) U1.AL22(VDD_120) U1.AL24(VDD_121) U1.AL26(VDD_122) U1.AL28(VDD_123) U1.AL30(VDD_124) U1.AL32(VDD_125) U1.AL34(VDD_126) U1.AL36(VDD_127) U1.AL38(VDD_128) U1.AL40(VDD_129) U1.AL42(VDD_130) U1.AL44(VDD_131) U1.AL46(VDD_132) U1.AM21(VDD_133) U1.AM23(VDD_134) U1.AM25(VDD_135) U1.AM27(VDD_136) U1.AM29(VDD_137) U1.AM31(VDD_138) U1.AM33(VDD_139) U1.AM35(VDD_140) U1.AM37(VDD_141) U1.AM39(VDD_142) U1.AM41(VDD_143) U1.AM43(VDD_144) U1.AM45(VDD_145) U1.AM47(VDD_146) U1.AN20(VDD_147) U1.AN22(VDD_148) U1.AN24(VDD_149) U1.AN26(VDD_150) U1.AN28(VDD_151) U1.AN30(VDD_152) U1.AN32(VDD_153) U1.AN34(VDD_154) U1.AN36(VDD_155) U1.AN38(VDD_156) U1.AN40(VDD_157) U1.AN42(VDD_158) U1.AN44(VDD_159) U1.AN46(VDD_160) U1.AP21(VDD_161) U1.AP23(VDD_162) U1.AP25(VDD_163) U1.AP27(VDD_164) U1.AP29(VDD_165) U1.AP31(VDD_166) U1.AP33(VDD_167) U1.AP35(VDD_168) U1.AP37(VDD_169) U1.AP39(VDD_170) U1.AP41(VDD_171) U1.AP43(VDD_172) U1.AP45(VDD_173) U1.AP47(VDD_174) U1.AR20(VDD_175) U1.AR22(VDD_176) U1.AR24(VDD_177) U1.AR26(VDD_178) U1.AR28(VDD_179) U1.AR30(VDD_180) U1.AR32(VDD_181) U1.AR36(VDD_182) U1.AR38(VDD_183) U1.AR40(VDD_184) U1.AR42(VDD_185) U1.AR44(VDD_186) U1.AR46(VDD_187) U1.AT21(VDD_188) U1.AT23(VDD_189) U1.AT25(VDD_190) U1.AT27(VDD_191) U1.AT29(VDD_192) U1.AT31(VDD_193) U1.AT33(VDD_194) U1.AT35(VDD_195) U1.AT37(VDD_196) U1.AT39(VDD_197) U1.AT41(VDD_198) U1.AT43(VDD_199) U1.AT45(VDD_200) U1.AT47(VDD_201) U1.AU20(VDD_202) U1.AU22(VDD_203) U1.AU24(VDD_204) U1.AU26(VDD_205) U1.AU28(VDD_206) U1.AU30(VDD_207) U1.AU32(VDD_208) U1.AU34(VDD_209) U1.AU36(VDD_210) U1.AU38(VDD_211) U1.AU40(VDD_212) U1.AU42(VDD_213) U1.AU44(VDD_214) U1.AU46(VDD_215) U1.AV21(VDD_216) U1.AV23(VDD_217) U1.AV25(VDD_218) U1.AV27(VDD_219) U1.AV29(VDD_220) U1.AV31(VDD_221) U1.AV33(VDD_222) U1.AV35(VDD_223) U1.AV37(VDD_224) U1.AV39(VDD_225) U1.AV41(VDD_226) U1.AV43(VDD_227) U1.AV45(VDD_228) U1.AV47(VDD_229) U1.AW20(VDD_230) U1.AW22(VDD_231) U1.AW24(VDD_232) U1.AW26(VDD_233) U1.AW28(VDD_234) U1.AW30(VDD_235) U1.AW32(VDD_236) U1.AW34(VDD_237) U1.AW36(VDD_238) U1.AW38(VDD_239) U1.AW40(VDD_240) U1.AW42(VDD_241) U1.AW44(VDD_242) U1.AW46(VDD_243) U1.AY21(VDD_244) U1.AY23(VDD_245) U1.AY25(VDD_246) U1.AY27(VDD_247) U1.AY29(VDD_248) U1.AY31(VDD_249) U1.AY33(VDD_250) U1.AY35(VDD_251) U1.AY37(VDD_252) U1.AY39(VDD_253) U1.AY41(VDD_254) U1.AY43(VDD_255) U1.AY45(VDD_256) U1.AY47(VDD_257) U1.BA20(VDD_262) U1.BA22(VDD_263) U1.BA24(VDD_264) U1.BA26(VDD_265) U1.BA28(VDD_266) U1.BA30(VDD_267) U1.BA32(VDD_268) U1.BA34(VDD_269) U1.BA38(VDD_270) U1.BA40(VDD_271) U1.BA42(VDD_272) U1.BA44(VDD_273) U1.BA46(VDD_274) U1.BB21(VDD_275) U1.BB23(VDD_276) U1.BB25(VDD_277) U1.BB27(VDD_278) U1.BB29(VDD_279) U1.BB31(VDD_280) U1.BB33(VDD_281) U1.BB37(VDD_282) U1.BB39(VDD_283) U1.BB41(VDD_284) U1.BB43(VDD_285) U1.BB45(VDD_286) U1.BB47(VDD_287) U1.BC20(VDD_288) U1.BC22(VDD_289) U1.BC24(VDD_290) U1.BC26(VDD_291) U1.BC28(VDD_292) U1.BC30(VDD_293) U1.BC32(VDD_294) U1.BC34(VDD_295) U1.BC36(VDD_296) U1.BC38(VDD_297) U1.BC40(VDD_298) U1.BC42(VDD_299) U1.BC44(VDD_300) U1.BC46(VDD_301) U1.BD21(VDD_302) U1.BD23(VDD_303) U1.BD25(VDD_304) U1.BD27(VDD_305) U1.BD29(VDD_306) U1.BD31(VDD_307) U1.BD34(VDD_308) U1.BD37(VDD_309) U1.BD39(VDD_310) U1.BD41(VDD_311) U1.BD43(VDD_312) U1.BD45(VDD_313) U1.BD47(VDD_314) U1.BE20(VDD_315) U1.BE22(VDD_316) U1.BE24(VDD_317) U1.BE26(VDD_318) U1.BE28(VDD_319) U1.BE30(VDD_320) U1.BE32(VDD_321) U1.BE38(VDD_322) U1.BE40(VDD_323) U1.BE42(VDD_324) U1.BE44(VDD_325) U1.BE46(VDD_326) X92.1
VDD_PLLA: C3430.1 C3431.1 C3432.1 C3433.1 L447.1 U117.38(VDD_PLL2) U117.39(VDD_VCO)
3384_TCK: R3192.2 R3196.2 R3214.2 R3217.1 U120.2(1A0) U120.4(1A1)
3384_TMS: R3195.2 R3201.2 R3220.1 R3223.2 U120.6(1A2) U120.8(1A3)
56970_COREPLL_REFCLK_N: C9.1 R3155.2
56970_COREPLL_REFCLK_P: C10.1 R3156.2
56970_MISC_PLL_REFCLK_N: C2807.1 R3157.2
56970_MISC_PLL_REFCLK_P: C2844.1 R3158.2
56970_PCIE_PLL_REFCLK_N: R24.1 U1.BL39(PCIE_REFCLKN) YJ3.A8_1(RX3-_1)
56970_PCIE_PLL_REFCLK_P: R24.2 U1.BL38(PCIE_REFCLKP) YJ3.A7_1(RX3+_1)
ANALOG_EN: Q56.3(C) R3564.2 R3566.1 R3650.2
ANLGOUT: C276.1 C279.1 C282.1 C351.1 C414.1 C468.1 C495.1 C522.1 C576.1 C603.1 C630.1 C684.1 C711.1 C738.1 C2116.1 C2117.1 C2676.1 C2683.1 C2719.1 C2746.1 C2752.1 C2771.1 C2776.1 C2779.1 C2781.1 C2786.1 C2808.1 C2821.1 C2831.1 C2842.1 C2845.1 C2855.1 C2865.1 C2868.1 C2897.1 C2919.1 C2924.1 C2957.1 C2987.1 C3001.1 C3006.1 C3030.1 C3058.1 C3061.1 C3084.1 C3107.1 C3122.1 C3128.1 C3150.1 C3174.1 C3196.1 C3420.1 C3597.1 C3598.1 C3599.1 C3600.1 C3601.1 C3932.1 C3933.1 C3934.1 C3935.1 CD47.1 CD48.1 CD79.1 CD80.1 L30.2 L31.2 L32.2 L33.2 L34.2 L35.2 L36.2 L37.2 L38.2 L39.2 L40.2 L41.2 L42.2 L43.2 L44.2 L45.2 L46.2 L47.2 L48.2 L49.2 L50.2 L51.2 L52.2 L53.2 L54.2 L55.2 L56.2 L57.2 L58.2 L59.2 L60.2 L61.2 L62.2 L63.2 L64.2 L65.2 L66.2 L67.2 L69.2 L70.2 L71.2 L73.2 L74.2 L75.2 L77.2 L78.2 L79.2 L430.2 L439.2 L501.2 L502.1 R2225.2 R2226.2 R3281.2 X93.1
AVS_IN0: U1.R51(AVS0) U124.B11(PT22A*/PT25A*/PT33A*)
AVS_IN1: U1.T49(AVS1) U124.E14(PR2B/PR3B/PR3B || R_GPLLC_IN**)
AVS_IN2: U1.T48(AVS2) U124.D14(PR1A/PR2A/PR2A || R_GPLLT_FB**)
AVS_IN3: U1.T51(AVS3) U124.G14(PR5B/PR8B/PR9B)
AVS_IN4: U1.H16(AVS4) U124.A14(PT22D/PT26B*/PT34B*)
AVS_IN5: U1.V27(AVS5) U124.B13(PT22C/PT26A*/PT34A*)
AVS_IN6: U1.U23(AVS6) U124.A12(PT22B*/PT25B*/PT33B*)
AVS_IN7: U1.U21(AVS7) U124.A11(PT21A*/PT24A*/PT28A*)
AVS_PVTMON_AVDD1P8: C87.1 C88.1 L425.1 U1.BJ27(AVS_PVTMON_AVDD1P8)
B50610_MDI_0N: C3506.1 D92.3 R3230.2 T1.3(TD1-)
B50610_MDI_0P: C3505.1 D92.4 R3231.1 T1.2(TD1+)
B50610_MDI_1N: C3510.1 D92.6 R3229.1 T1.6(TD2-)
B50610_MDI_1P: C3507.1 D92.1 R3232.2 T1.5(TD2+)
B50610_MDI_2N: C3511.1 D93.3 R3233.2 T1.9(TD3-)
B50610_MDI_2P: C3508.1 D93.4 R3234.1 T1.8(TD3+)
B50610_MDI_3N: C3509.1 D93.6 R3235.1 T1.12(TD4-)
B50610_MDI_3P: C3512.1 D93.1 R3236.2 T1.11(TD4+)
BMC_I2C_SCL: R3502.2 R3658.1 U14.6(SCL) U121.2(SCL) U122.2(SCL) U123.A9(PT18C/PT20C/PT22C || SCL/PCLKT0_0) U124.A9(PT18C/PT20C/PT22C || SCL/PCLKT0_0) U140.18(SCL) YJ3.C8_2(TX3-_2)
BMC_I2C_SDA: R361.2 R3241.2 R3243.2 R3267.2 R3358.2 R3501.2 R3504.2 YJ3.C7_2(TX3+_2)
BMC_STATUS_LED: D429.4 R3352.1 U124.K5(PL12C/PL17C/PL21C)
BS_PLL_0_1_AVDD1P8: C3012.1 C3019.1 C3043.1 L440.1 U1.BH34(BS_PLL0_AVDD1P8) U1.BL34(BS_PLL1_AVDD1P8)
CDCM_STA: R3159.2 R3260.2 U123.C4(PT9A*/PT9A*/PT9A*)
COP_JTAG_TCK: R3202.2 R3203.1 U119.17(2A0) U120.17(2A0)
COP_JTAG_TDI: R3206.1 R3208.2 U119.13(2A2)
COP_JTAG_TDO: J33.3 R3222.2 TP3.1
COP_JTAG_TMS: R3204.1 R3209.2 U119.11(2A3) U120.15(2A1)
COP_JTAG_TRST: R3205.2 R3207.2 R3228.1 U120.13(2A2)
CORE_PLL_AVDD1P8: C83.1 C84.1 L442.1 U1.AN15(CORE_PLL_AVDD1P8)
CORE_TEMP0: C3948.1 D435.32(TMON) D436.32(TMON) D437.32(TMON) D438.32(TMON) D439.32(TMON) D440.32(TMON) D441.32(TMON) D442.32(TMON) D443.32(TMON) D444.32(TMON) U140.44(TMON0)
CORE_TEMP1: C3949.1 D445.32(TMON) D446.32(TMON) U140.45(TMON1)
CPLD3.3V: C111.1 C112.1 C113.1 C114.2 C115.1 C116.1 C117.1 C118.1 C119.1 C2059.1 C2071.1 C2072.1 C3499.2 C3500.1 C3501.1 C3502.2 C3519.2 C3520.2 C3522.2 C3523.2 C3524.2 C3525.2 C3526.2 C3527.2 C3528.2 C3529.2 C3530.2 C3531.2 C3532.2 C3533.2 C3534.2 C3535.2 C3536.2 C3537.2 C3538.2 C3539.2 C3540.2 C3541.2 C3542.2 C3543.2 C3544.2 C3545.2 C3546.2 C3547.2 C3548.1 C3549.2 C3550.2 C3551.2 C3552.2 C3553.2 C3554.2 C3555.2 C3556.2 C3557.2 C3558.2 C3560.1 C3561.2 C3562.2 C3563.2 C3564.2 C3565.1 C3566.2 C3567.2 C3568.2 C3569.2 C3570.2 C3571.2 C3572.2 C3573.2 C3574.2 C3575.2 C3576.2 C3577.2 C3578.2 C3579.2 C3580.2 C3581.2 C3582.2 C3583.2 C3584.2 C3585.2 C3586.1 C3587.2 C3588.2 C3589.2 C3590.2 C3591.2 C3592.2 C3593.2 C3594.2 C3595.2 C3596.2 C3638.1 C3642.1 C3643.1 C3644.1 C3645.2 C3942.1 D92.5 D93.5 J33.4 J34.4 L454.1 R30.2 R31.2 R32.2 R34.2 R35.2 R183.1 R205.1 R216.1 R224.1 R252.1 R285.1 R295.1 R297.1 R312.2 R313.2 R316.2 R317.1 R352.1 R353.1 R374.1 R380.1 R382.1 R429.1 R440.1 R454.1 R457.1 R462.1 R466.1 R470.1 R2022.1 R2023.1 R2024.1 R2025.1 R2026.1 R2030.1 R2963.2 R2964.2 R2965.2 R2966.2 R2971.2 R2972.2 R2973.2 R2974.2 R2979.2 R2980.2 R2981.2 R2982.2 R2987.2 R2988.2 R2989.2 R2990.2 R2995.2 R2996.2 R2997.2 R2998.2 R3003.2 R3004.2 R3005.2 R3006.2 R3011.2 R3012.2 R3013.2 R3014.2 R3019.2 R3020.2 R3021.2 R3022.2 R3027.2 R3028.2 R3029.2 R3030.2 R3035.2 R3036.2 R3037.2 R3038.2 R3043.2 R3044.2 R3045.2 R3046.2 R3051.2 R3052.2 R3053.2 R3054.2 R3059.2 R3060.2 R3061.2 R3062.2 R3067.2 R3068.2 R3069.2 R3070.2 R3075.2 R3076.2 R3077.2 R3078.2 R3083.2 R3084.2 R3085.2 R3086.2 R3187.2 R3188.2 R3189.2 R3190.2 R3199.1 R3208.1 R3209.1 R3223.1 R3225.1 R3226.1 R3227.1 R3247.2 R3259.1 R3284.1 R3286.1 R3295.1 R3312.2 R3314.1 R3320.1 R3325.1 R3357.1 R3365.1 R3374.1 R3376.1 R3377.1 R3384.1 R3389.1 R3395.1 R3401.2 R3402.1 R3403.1 R3406.1 R3408.1 R3410.1 R3411.1 R3518.1 R3520.1 R3651.2 R3654.2 R3656.2 R3658.2 R3659.2 R3660.2 U10.24(VDD) U11.24(VDD) U12.24(VDD) U13.24(VDD) U14.8(VCC) U15.24(VDD) U16.24(VDD) U17.24(VDD) U18.24(VDD) U84.26(VCC) U119.20(POWER) U120.20(POWER) U121.8(VCC) U122.8(VCC) U123.A1(VCC/VCC/VCC#A1) U123.A16(VCC/VCC/VCC#A16) U123.D5(VCCIO0/VCCIO0/VCCIO0#D5) U123.D12(VCCIO0/VCCIO0/VCCIO0#D12) U123.E4(VCCIO5/VCCIO5/VCCIO5) U123.E13(VCCIO1/VCCIO1/VCCIO1#E13) U123.G7(VCC/VCC/VCC#G7) U123.G8(VCCIO0/VCCIO0/VCCIO0#G8) U123.G9(VCCIO0/VCCIO0/VCCIO0#G9) U123.G10(VCC/VCC/VCC#G10) U123.H7(VCCIO4/VCCIO4/VCCIO4#H7) U123.H10(VCCIO1/VCCIO1/VCCIO1#H10) U123.J7(VCCIO4/VCCIO4/VCCIO4#J7) U123.J10(VCCIO1/VCCIO1/VCCIO1#J10) U123.K7(VCC/VCC/VCC#K7) U123.K8(VCCIO2/VCCIO2/VCCIO2#K8) U123.K9(VCCIO2/VCCIO2/VCCIO2#K9) U123.K10(VCC/VCC/VCC#K10) U123.M4(VCCIO3/VCCIO3/VCCIO3) U123.M13(VCCIO1/VCCIO1/VCCIO1#M13) U123.N5(VCCIO2/VCCIO2/VCCIO2#N5) U123.N12(VCCIO2/VCCIO2/VCCIO2#N12) U123.T1(VCC/VCC/VCC#T1) U123.T16(VCC/VCC/VCC#T16) U124.A1(VCC/VCC/VCC#A1) U124.A16(VCC/VCC/VCC#A16) U124.D5(VCCIO0/VCCIO0/VCCIO0#D5) U124.D12(VCCIO0/VCCIO0/VCCIO0#D12) U124.E4(VCCIO5/VCCIO5/VCCIO5) U124.E13(VCCIO1/VCCIO1/VCCIO1#E13) U124.G7(VCC/VCC/VCC#G7) U124.G8(VCCIO0/VCCIO0/VCCIO0#G8) U124.G9(VCCIO0/VCCIO0/VCCIO0#G9) U124.G10(VCC/VCC/VCC#G10) U124.H7(VCCIO4/VCCIO4/VCCIO4#H7) U124.H10(VCCIO1/VCCIO1/VCCIO1#H10) U124.J7(VCCIO4/VCCIO4/VCCIO4#J7) U124.J10(VCCIO1/VCCIO1/VCCIO1#J10) U124.K7(VCC/VCC/VCC#K7) U124.K8(VCCIO2/VCCIO2/VCCIO2#K8) U124.K9(VCCIO2/VCCIO2/VCCIO2#K9) U124.K10(VCC/VCC/VCC#K10) U124.M4(VCCIO3/VCCIO3/VCCIO3) U124.M13(VCCIO1/VCCIO1/VCCIO1#M13) U124.N5(VCCIO2/VCCIO2/VCCIO2#N5) U124.N12(VCCIO2/VCCIO2/VCCIO2#N12) U124.T1(VCC/VCC/VCC#T1) U124.T16(VCC/VCC/VCC#T16) U140.42(VCC) X260.1
CPLD3.3V_EN: Q47.3(C) R3539.2 R3545.1 U129.5(EN)
CPLD_CDCM_MISO: R3136.1 R3251.2 U123.A5(PT11A*/PT11A*/PT11A*)
CPLD_CDCM_MOSI: R3151.2 R3256.2 U117.2(SDI/SDA/PIN1)
CPLD_CDCM_PDN: R3148.2 R3298.2 U117.43(PDN)
CPLD_CDCM_RST: R3152.2 R3258.1 U117.44(RESETN/PWR)
CPLD_CDCM_SCK: R3139.1 R3268.1 U117.5(SCL/PIN4)
CPLD_CDCM_SS: R3150.2 R3257.1 U117.4(SCS/AD1/PIN3)
CPLD_CDCM_SYNCN: R3149.2 R3265.1 U117.42(SYNCN)
CPLD_QSFP_EN: R3535.1 U123.D7(PT13D/PT14D/PT16B*)
CPLD_RESERVE1: R3309.1 U124.C7(PT13B*/PT14B*/PT15B*)
CPLD_RESERVE2: R3297.2 U124.D7(PT13D/PT14D/PT16B*)
CPLD_RESERVE3: R3606.2 U124.B7(PT13A*/PT14A*/PT15A*)
CPLD_RESERVE4: R3294.2 U124.E6(PT13C/PT14C/PT16A*)
CPLD_RESERVE5: R3324.1 U124.F7(PT16A*/PT15A*/PT17A*)
CPU_I2C_RST#: C3480.1 R3359.1 YJ3.A2_1(SIDEBAND0_1)
CPU_I2C_SCL: U10.22(SCL) U11.22(SCL) U12.22(SCL) U13.22(SCL) U15.22(SCL) U16.22(SCL) U17.22(SCL) U18.22(SCL) U123.E9(PT17D/PT19B*/PT21B*) U124.D9(PT18B*/PT20B*/PT22B*) YJ3.C8_1(TX3-_1)
CPU_I2C_SDA: R201.1 R206.1 R254.1 R288.1 R359.1 R367.1 R432.1 R446.1 R3322.2 R3364.1 YJ3.C7_1(TX3+_1)
CPU_STATUS_LED: D430.4 R3379.1 U124.N11(PB21D/PB24D/PB31D)
E2_WP: R314.1 R316.1 R3323.1 U14.7(WP)
FAN_STATUS_LED: D432.4 R3409.1 U124.E15(PR1B/PR2B/PR2B || R_GPLLC_FB**)
FB: C3606.2 R3507.2 R3510.1 U126.3(FB/SNS)
FC0_1_PVDD0P8: C2927.1 C3010.1 C3335.1 L33.1 U1.BG38(FC0_PVDD0P8) U1.BG40(FC1_PVDD0P8)
FC0_15_PVDD1P8: C101.1 C102.1 C103.1 C2696.1 C2713.1 C2778.1 C2819.1 C2907.1 C3166.1 L428.1 U1.AT49(FC14-15_PVDD1P8) U1.AW49(FC12-13_PVDD1P8) U1.BB49(FC10-11_PVDD1P8) U1.BE49(FC8-9_PVDD1P8) U1.BG39(FC0-1_PVDD1P8) U1.BG42(FC2-3_PVDD1P8) U1.BG45(FC4-5_PVDD1P8) U1.BG47(FC6-7_PVDD1P8)
FC0_RDN0: U1.BP37(FC0_RD0N) YJ22.D22(RX2P_4)
FC0_RDN1: U1.BT36(FC0_RD1N) YJ22.D18(RX1N_4)
FC0_RDN2: U1.BV37(FC0_RD2N) YJ22.D25(RX4P_4)
FC0_RDN3: U1.BY36(FC0_RD3N) YJ22.D15(RX3N_4)
FC0_RDP0: U1.BP36(FC0_RD0P) YJ22.D21(RX2N_4)
FC0_RDP1: U1.BT37(FC0_RD1P) YJ22.D17(RX1P_4)
FC0_RDP2: U1.BV36(FC0_RD2P) YJ22.D24(RX4N_4)
FC0_RDP3: U1.BY37(FC0_RD3P) YJ22.D14(RX3P_4)
FC0_TDN0: U1.CC35(FC0_TD0N) YJ22.D6(TX4P_4)
FC0_TDN1: U1.CE36(FC0_TD1N) YJ22.D2(TX2N_4)
FC0_TDN2: U1.CB37(FC0_TD2N) YJ22.D33(TX3P_4)
FC0_TDN3: U1.CD38(FC0_TD3N) YJ22.D37(TX1N_4)
FC0_TDP0: U1.CC36(FC0_TD0P) YJ22.D5(TX4N_4)
FC0_TDP1: U1.CE35(FC0_TD1P) YJ22.D3(TX2P_4)
FC0_TDP2: U1.CB38(FC0_TD2P) YJ22.D34(TX3N_4)
FC0_TDP3: U1.CD37(FC0_TD3P) YJ22.D36(TX1P_4)
FC1_RDN0: U1.BW40(FC1_RD0N) YJ22.C14(RX3P_3)
FC1_RDN1: U1.BU39(FC1_RD1N) YJ22.C24(RX4N_3)
FC1_RDN2: U1.BR40(FC1_RD2N) YJ22.C17(RX1P_3)
FC1_RDN3: U1.BN39(FC1_RD3N) YJ22.C21(RX2N_3)
FC1_RDP0: U1.BW39(FC1_RD0P) YJ22.C15(RX3N_3)
FC1_RDP1: U1.BU40(FC1_RD1P) YJ22.C25(RX4P_3)
FC1_RDP2: U1.BR39(FC1_RD2P) YJ22.C18(RX1N_3)
FC1_RDP3: U1.BN40(FC1_RD3P) YJ22.C22(RX2P_3)
FC1_TDN0: U1.CF37(FC1_TD0N) YJ22.C6(TX4P_3)
FC1_TDN1: U1.CA40(FC1_TD1N) YJ22.C34(TX3N_3)
FC1_TDN2: U1.CC39(FC1_TD2N) YJ22.C3(TX2P_3)
FC1_TDN3: U1.CE40(FC1_TD3N) YJ22.C37(TX1N_3)
FC1_TDP0: U1.CF38(FC1_TD0P) YJ22.C5(TX4N_3)
FC1_TDP1: U1.CA39(FC1_TD1P) YJ22.C33(TX3P_3)
FC1_TDP2: U1.CC40(FC1_TD2P) YJ22.C2(TX2N_3)
FC1_TDP3: U1.CE39(FC1_TD3P) YJ22.C36(TX1P_3)
FC2_3_PVDD0P8: C2945.1 C2991.1 C3342.1 L34.1 U1.BG41(FC2_PVDD0P8) U1.BG43(FC3_PVDD0P8)
FC2_RDN0: U1.BY43(FC2_RD0N) YJ21.A21(RX2N_1)
FC2_RDN1: U1.BV42(FC2_RD1N) YJ21.A14(RX3P_1)
FC2_RDN2: U1.BT43(FC2_RD2N) YJ21.A24(RX4N_1)
FC2_RDN3: U1.BP42(FC2_RD3N) YJ21.A17(RX1P_1)
FC2_RDP0: U1.BY42(FC2_RD0P) YJ21.A22(RX2P_1)
FC2_RDP1: U1.BV43(FC2_RD1P) YJ21.A15(RX3N_1)
FC2_RDP2: U1.BT42(FC2_RD2P) YJ21.A25(RX4P_1)
FC2_RDP3: U1.BP43(FC2_RD3P) YJ21.A18(RX1N_1)
FC2_TDN0: U1.CB41(FC2_TD0N) YJ21.A37(TX1N_1)
FC2_TDN1: U1.CD42(FC2_TD1N) YJ21.A33(TX3P_1)
FC2_TDN2: U1.CF41(FC2_TD2N) YJ21.A5(TX4N_1)
FC2_TDN3: U1.CC44(FC2_TD3N) YJ21.A3(TX2P_1)
FC2_TDP0: U1.CB42(FC2_TD0P) YJ21.A36(TX1P_1)
FC2_TDP1: U1.CD41(FC2_TD1P) YJ21.A34(TX3N_1)
FC2_TDP2: U1.CF42(FC2_TD2P) YJ21.A6(TX4P_1)
FC2_TDP3: U1.CC43(FC2_TD3P) YJ21.A2(TX2N_1)
FC3_RDN0: U1.BY46(FC3_RD0N) YJ21.B21(RX2N_2)
FC3_RDN1: U1.BV45(FC3_RD1N) YJ21.B17(RX1P_2)
FC3_RDN2: U1.BT46(FC3_RD2N) YJ21.B24(RX4N_2)
FC3_RDN3: U1.BP45(FC3_RD3N) YJ21.B14(RX3P_2)
FC3_RDP0: U1.BY45(FC3_RD0P) YJ21.B22(RX2P_2)
FC3_RDP1: U1.BV46(FC3_RD1P) YJ21.B18(RX1N_2)
FC3_RDP2: U1.BT45(FC3_RD2P) YJ21.B25(RX4P_2)
FC3_RDP3: U1.BP46(FC3_RD3P) YJ21.B15(RX3N_2)
FC3_TDN0: U1.CE43(FC3_TD0N) YJ21.B34(TX3N_2)
FC3_TDN1: U1.CB46(FC3_TD1N) YJ21.B3(TX2P_2)
FC3_TDN2: U1.CD45(FC3_TD2N) YJ21.B37(TX1N_2)
FC3_TDN3: U1.CF46(FC3_TD3N) YJ21.B6(TX4P_2)
FC3_TDP0: U1.CE44(FC3_TD0P) YJ21.B33(TX3P_2)
FC3_TDP1: U1.CB45(FC3_TD1P) YJ21.B2(TX2N_2)
FC3_TDP2: U1.CD46(FC3_TD2P) YJ21.B36(TX1P_2)
FC3_TDP3: U1.CF45(FC3_TD3P) YJ21.B5(TX4N_2)
FC4_5_PVDD0P8: C2794.1 C2840.1 C3347.1 L35.1 U1.BG44(FC4_PVDD0P8) U1.BG46(FC5_PVDD0P8)
FC4_RDN0: U1.BY49(FC4_RD0N) YJ22.B14(RX3P_2)
FC4_RDN1: U1.BV48(FC4_RD1N) YJ22.B24(RX4N_2)
FC4_RDN2: U1.BT49(FC4_RD2N) YJ22.B17(RX1P_2)
FC4_RDN3: U1.BP48(FC4_RD3N) YJ22.B21(RX2N_2)
FC4_RDP0: U1.BY48(FC4_RD0P) YJ22.B15(RX3N_2)
FC4_RDP1: U1.BV49(FC4_RD1P) YJ22.B25(RX4P_2)
FC4_RDP2: U1.BT48(FC4_RD2P) YJ22.B18(RX1N_2)
FC4_RDP3: U1.BP49(FC4_RD3P) YJ22.B22(RX2P_2)
FC4_TDN0: U1.CC47(FC4_TD0N) YJ22.B6(TX4P_2)
FC4_TDN1: U1.CE48(FC4_TD1N) YJ22.B2(TX2N_2)
FC4_TDN2: U1.CB49(FC4_TD2N) YJ22.B33(TX3P_2)
FC4_TDN3: U1.CD50(FC4_TD3N) YJ22.B37(TX1N_2)
FC4_TDP0: U1.CC48(FC4_TD0P) YJ22.B5(TX4N_2)
FC4_TDP1: U1.CE47(FC4_TD1P) YJ22.B3(TX2P_2)
FC4_TDP2: U1.CB50(FC4_TD2P) YJ22.B34(TX3N_2)
FC4_TDP3: U1.CD49(FC4_TD3P) YJ22.B36(TX1P_2)
FC5_RDN0: U1.CE53(FC5_RD0N) YJ22.A14(RX3P_1)
FC5_RDN1: U1.CE55(FC5_RD1N) YJ22.A18(RX1N_1)
FC5_RDN2: U1.CC53(FC5_RD2N) YJ22.A25(RX4P_1)
FC5_RDN3: U1.CC55(FC5_RD3N) YJ22.A21(RX2N_1)
FC5_RDP0: U1.CE52(FC5_RD0P) YJ22.A15(RX3N_1)
FC5_RDP1: U1.CE56(FC5_RD1P) YJ22.A17(RX1P_1)
FC5_RDP2: U1.CC52(FC5_RD2P) YJ22.A24(RX4N_1)
FC5_RDP3: U1.CC56(FC5_RD3P) YJ22.A22(RX2P_1)
FC5_TDN0: U1.CF63(FC5_TD0N) YJ22.A3(TX2P_1)
FC5_TDN1: U1.CE61(FC5_TD1N) YJ22.A5(TX4N_1)
FC5_TDN2: U1.CD64(FC5_TD2N) YJ22.A33(TX3P_1)
FC5_TDN3: U1.CC62(FC5_TD3N) YJ22.A37(TX1N_1)
FC5_TDP0: U1.CE63(FC5_TD0P) YJ22.A2(TX2N_1)
FC5_TDP1: U1.CF61(FC5_TD1P) YJ22.A6(TX4P_1)
FC5_TDP2: U1.CC64(FC5_TD2P) YJ22.A34(TX3N_1)
FC5_TDP3: U1.CD62(FC5_TD3P) YJ22.A36(TX1P_1)
FC6_7_PVDD0P8: C274.1 C275.1 C3320.1 L36.1 U1.BG48(FC6_PVDD0P8) U1.BG49(FC7_PVDD0P8)
FC6_RDN0: U1.CE59(FC6_RD0N) YJ21.C25(RX4P_3)
FC6_RDN1: U1.CC58(FC6_RD1N) YJ21.C18(RX1N_3)
FC6_RDN2: U1.CA59(FC6_RD2N) YJ21.C21(RX2N_3)
FC6_RDN3: U1.BW58(FC6_RD3N) YJ21.C14(RX3P_3)
FC6_RDP0: U1.CE58(FC6_RD0P) YJ21.C24(RX4N_3)
FC6_RDP1: U1.CC59(FC6_RD1P) YJ21.C17(RX1P_3)
FC6_RDP2: U1.CA58(FC6_RD2P) YJ21.C22(RX2P_3)
FC6_RDP3: U1.BW59(FC6_RD3P) YJ21.C15(RX3N_3)
FC6_TDN0: U1.CD66(FC6_TD0N) YJ21.C37(TX1N_3)
FC6_TDN1: U1.CA61(FC6_TD1N) YJ21.C33(TX3P_3)
FC6_TDN2: U1.CB63(FC6_TD2N) YJ21.C5(TX4N_3)
FC6_TDN3: U1.CA65(FC6_TD3N) YJ21.C3(TX2P_3)
FC6_TDP0: U1.CC66(FC6_TD0P) YJ21.C36(TX1P_3)
FC6_TDP1: U1.CB61(FC6_TD1P) YJ21.C34(TX3N_3)
FC6_TDP2: U1.CA63(FC6_TD2P) YJ21.C6(TX4P_3)
FC6_TDP3: U1.CB65(FC6_TD3P) YJ21.C2(TX2N_3)
FC7_RDN0: U1.CA53(FC7_RD0N) YJ21.D14(RX3P_4)
FC7_RDN1: U1.CA55(FC7_RD1N) YJ21.D24(RX4N_4)
FC7_RDN2: U1.BW56(FC7_RD2N) YJ21.D17(RX1P_4)
FC7_RDN3: U1.BW52(FC7_RD3N) YJ21.D22(RX2P_4)
FC7_RDP0: U1.CA52(FC7_RD0P) YJ21.D15(RX3N_4)
FC7_RDP1: U1.CA56(FC7_RD1P) YJ21.D25(RX4P_4)
FC7_RDP2: U1.BW55(FC7_RD2P) YJ21.D18(RX1N_4)
FC7_RDP3: U1.BW53(FC7_RD3P) YJ21.D21(RX2N_4)
FC7_TDN0: U1.BY62(FC7_TD0N) YJ21.D37(TX1N_4)
FC7_TDN1: U1.BW64(FC7_TD1N) YJ21.D6(TX4P_4)
FC7_TDN2: U1.BY66(FC7_TD2N) YJ21.D34(TX3N_4)
FC7_TDN3: U1.BU61(FC7_TD3N) YJ21.D3(TX2P_4)
FC7_TDP0: U1.BW62(FC7_TD0P) YJ21.D36(TX1P_4)
FC7_TDP1: U1.BY64(FC7_TD1P) YJ21.D5(TX4N_4)
FC7_TDP2: U1.BW66(FC7_TD2P) YJ21.D33(TX3P_4)
FC7_TDP3: U1.BV61(FC7_TD3P) YJ21.D2(TX2N_4)
FC8_9_PVDD0P8: C277.1 C278.1 C3321.1 L37.1 U1.BD49(FC9_PVDD0P8) U1.BF49(FC8_PVDD0P8)
FC8_RDN0: U1.BU53(FC8_RD0N) YJ24.D21(RX2N_4)
FC8_RDN1: U1.BT57(FC8_RD1N) YJ24.D14(RX3P_4)
FC8_RDN2: U1.BU55(FC8_RD2N) YJ24.D18(RX1N_4)
FC8_RDN3: U1.BT59(FC8_RD3N) YJ24.D25(RX4P_4)
FC8_RDP0: U1.BT53(FC8_RD0P) YJ24.D22(RX2P_4)
FC8_RDP1: U1.BU57(FC8_RD1P) YJ24.D15(RX3N_4)
FC8_RDP2: U1.BT55(FC8_RD2P) YJ24.D17(RX1P_4)
FC8_RDP3: U1.BU59(FC8_RD3P) YJ24.D24(RX4N_4)
FC8_TDN0: U1.BU65(FC8_TD0N) YJ24.D2(TX2N_4)
FC8_TDN1: U1.BV63(FC8_TD1N) YJ24.D6(TX4P_4)
FC8_TDN2: U1.BR66(FC8_TD2N) YJ24.D37(TX1N_4)
FC8_TDN3: U1.BT64(FC8_TD3N) YJ24.D33(TX3P_4)
FC8_TDP0: U1.BV65(FC8_TD0P) YJ24.D3(TX2P_4)
FC8_TDP1: U1.BU63(FC8_TD1P) YJ24.D5(TX4N_4)
FC8_TDP2: U1.BT66(FC8_TD2P) YJ24.D36(TX1P_4)
FC8_TDP3: U1.BR64(FC8_TD3P) YJ24.D34(TX3N_4)
FC9_RDN0: U1.BN54(FC9_RD0N) YJ24.C22(RX2P_3)
FC9_RDN1: U1.BP58(FC9_RD1N) YJ24.C15(RX3N_3)
FC9_RDN2: U1.BN56(FC9_RD2N) YJ24.C17(RX1P_3)
FC9_RDN3: U1.BP60(FC9_RD3N) YJ24.C24(RX4N_3)
FC9_RDP0: U1.BP54(FC9_RD0P) YJ24.C21(RX2N_3)
FC9_RDP1: U1.BN58(FC9_RD1P) YJ24.C14(RX3P_3)
FC9_RDP2: U1.BP56(FC9_RD2P) YJ24.C18(RX1N_3)
FC9_RDP3: U1.BN60(FC9_RD3P) YJ24.C25(RX4P_3)
FC9_TDN0: U1.BT62(FC9_TD0N) YJ24.C3(TX2P_3)
FC9_TDN1: U1.BN65(FC9_TD1N) YJ24.C5(TX4N_3)
FC9_TDN2: U1.BP63(FC9_TD2N) YJ24.C33(TX3P_3)
FC9_TDN3: U1.BL66(FC9_TD3N) YJ24.C37(TX1N_3)
FC9_TDP0: U1.BR62(FC9_TD0P) YJ24.C2(TX2N_3)
FC9_TDP1: U1.BP65(FC9_TD1P) YJ24.C6(TX4P_3)
FC9_TDP2: U1.BN63(FC9_TD2P) YJ24.C34(TX3N_3)
FC9_TDP3: U1.BM66(FC9_TD3P) YJ24.C36(TX1P_3)
FC10_11_PVDD0P8: C280.1 C281.1 C3324.1 L38.1 U1.BA49(FC11_PVDD0P8) U1.BC49(FC10_PVDD0P8)
FC10_RDN0: U1.BL54(FC10_RD0N) YJ23.A17(RX1P_1)
FC10_RDN1: U1.BK58(FC10_RD1N) YJ23.A15(RX3N_1)
FC10_RDN2: U1.BL56(FC10_RD2N) YJ23.A25(RX4P_1)
FC10_RDN3: U1.BK60(FC10_RD3N) YJ23.A21(RX2N_1)
FC10_RDP0: U1.BK54(FC10_RD0P) YJ23.A18(RX1N_1)
FC10_RDP1: U1.BL58(FC10_RD1P) YJ23.A14(RX3P_1)
FC10_RDP2: U1.BK56(FC10_RD2P) YJ23.A24(RX4N_1)
FC10_RDP3: U1.BL60(FC10_RD3P) YJ23.A22(RX2P_1)
FC10_TDN0: U1.BJ63(FC10_TD0N) YJ23.A3(TX2P_1)
FC10_TDN1: U1.BK65(FC10_TD1N) YJ23.A5(TX4N_1)
FC10_TDN2: U1.BL62(FC10_TD2N) YJ23.A36(TX1P_1)
FC10_TDN3: U1.BM64(FC10_TD3N) YJ23.A34(TX3N_1)
FC10_TDP0: U1.BK63(FC10_TD0P) YJ23.A2(TX2N_1)
FC10_TDP1: U1.BJ65(FC10_TD1P) YJ23.A6(TX4P_1)
FC10_TDP2: U1.BM62(FC10_TD2P) YJ23.A37(TX1N_1)
FC10_TDP3: U1.BL64(FC10_TD3P) YJ23.A33(TX3P_1)
FC11_RDN0: U1.BG54(FC11_RD0N) YJ23.B15(RX3N_2)
FC11_RDN1: U1.BH58(FC11_RD1N) YJ23.B17(RX1P_2)
FC11_RDN2: U1.BG56(FC11_RD2N) YJ23.B24(RX4N_2)
FC11_RDN3: U1.BH60(FC11_RD3N) YJ23.B22(RX2P_2)
FC11_RDP0: U1.BH54(FC11_RD0P) YJ23.B14(RX3P_2)
FC11_RDP1: U1.BG58(FC11_RD1P) YJ23.B18(RX1N_2)
FC11_RDP2: U1.BH56(FC11_RD2P) YJ23.B25(RX4P_2)
FC11_RDP3: U1.BG60(FC11_RD3P) YJ23.B21(RX2N_2)
FC11_TDN0: U1.BH66(FC11_TD0N) YJ23.B34(TX3N_2)
FC11_TDN1: U1.BG64(FC11_TD1N) YJ23.B36(TX1P_2)
FC11_TDN2: U1.BH62(FC11_TD2N) YJ23.B2(TX2N_2)
FC11_TDN3: U1.BE65(FC11_TD3N) YJ23.B6(TX4P_2)
FC11_TDP0: U1.BG66(FC11_TD0P) YJ23.B33(TX3P_2)
FC11_TDP1: U1.BH64(FC11_TD1P) YJ23.B37(TX1N_2)
FC11_TDP2: U1.BG62(FC11_TD2P) YJ23.B3(TX2P_2)
FC11_TDP3: U1.BF65(FC11_TD3P) YJ23.B5(TX4N_2)
FC12_13_PVDD0P8: C283.1 C284.1 C3327.1 L39.1 U1.AV49(FC13_PVDD0P8) U1.AY49(FC12_PVDD0P8)
FC12_RDN0: U1.BE54(FC12_RD0N) YJ24.B21(RX2N_2)
FC12_RDN1: U1.BD58(FC12_RD1N) YJ24.B14(RX3P_2)
FC12_RDN2: U1.BE56(FC12_RD2N) YJ24.B18(RX1N_2)
FC12_RDN3: U1.BD60(FC12_RD3N) YJ24.B25(RX4P_2)
FC12_RDP0: U1.BD54(FC12_RD0P) YJ24.B22(RX2P_2)
FC12_RDP1: U1.BE58(FC12_RD1P) YJ24.B15(RX3N_2)
FC12_RDP2: U1.BD56(FC12_RD2P) YJ24.B17(RX1P_2)
FC12_RDP3: U1.BE60(FC12_RD3P) YJ24.B24(RX4N_2)
FC12_TDN0: U1.BC62(FC12_TD0N) YJ24.B34(TX3N_2)
FC12_TDN1: U1.BD64(FC12_TD1N) YJ24.B3(TX2P_2)
FC12_TDN2: U1.BC66(FC12_TD2N) YJ24.B37(TX1N_2)
FC12_TDN3: U1.BF63(FC12_TD3N) YJ24.B6(TX4P_2)
FC12_TDP0: U1.BD62(FC12_TD0P) YJ24.B33(TX3P_2)
FC12_TDP1: U1.BC64(FC12_TD1P) YJ24.B2(TX2N_2)
FC12_TDP2: U1.BD66(FC12_TD2P) YJ24.B36(TX1P_2)
FC12_TDP3: U1.BE63(FC12_TD3P) YJ24.B5(TX4N_2)
FC13_RDN0: U1.BA53(FC13_RD0N) YJ24.A25(RX4P_1)
FC13_RDN1: U1.BB57(FC13_RD1N) YJ24.A18(RX1N_1)
FC13_RDN2: U1.BA55(FC13_RD2N) YJ24.A14(RX3P_1)
FC13_RDN3: U1.BB59(FC13_RD3N) YJ24.A21(RX2N_1)
FC13_RDP0: U1.BB53(FC13_RD0P) YJ24.A24(RX4N_1)
FC13_RDP1: U1.BA57(FC13_RD1P) YJ24.A17(RX1P_1)
FC13_RDP2: U1.BB55(FC13_RD2P) YJ24.A15(RX3N_1)
FC13_RDP3: U1.BA59(FC13_RD3P) YJ24.A22(RX2P_1)
FC13_TDN0: U1.BB65(FC13_TD0N) YJ24.A3(TX2P_1)
FC13_TDN1: U1.BA63(FC13_TD1N) YJ24.A5(TX4N_1)
FC13_TDN2: U1.BB61(FC13_TD2N) YJ24.A36(TX1P_1)
FC13_TDN3: U1.AW66(FC13_TD3N) YJ24.A34(TX3N_1)
FC13_TDP0: U1.BA65(FC13_TD0P) YJ24.A2(TX2N_1)
FC13_TDP1: U1.BB63(FC13_TD1P) YJ24.A6(TX4P_1)
FC13_TDP2: U1.BA61(FC13_TD2P) YJ24.A37(TX1N_1)
FC13_TDP3: U1.AY66(FC13_TD3P) YJ24.A33(TX3P_1)
FC14_15_PVDD0P8: C2911.1 C2958.1 C3331.1 L40.1 U1.AR49(FC15_PVDD0P8) U1.AU49(FC14_PVDD0P8)
FC14_RDN0: U1.AW54(FC14_RD0N) YJ23.C14(RX3P_3)
FC14_RDN1: U1.AV58(FC14_RD1N) YJ23.C18(RX1N_3)
FC14_RDN2: U1.AW56(FC14_RD2N) YJ23.C22(RX2P_3)
FC14_RDN3: U1.AV60(FC14_RD3N) YJ23.C24(RX4N_3)
FC14_RDP0: U1.AV54(FC14_RD0P) YJ23.C15(RX3N_3)
FC14_RDP1: U1.AW58(FC14_RD1P) YJ23.C17(RX1P_3)
FC14_RDP2: U1.AV56(FC14_RD2P) YJ23.C21(RX2N_3)
FC14_RDP3: U1.AW60(FC14_RD3P) YJ23.C25(RX4P_3)
FC14_TDN0: U1.AU63(FC14_TD0N) YJ23.C6(TX4P_3)
FC14_TDN1: U1.AV65(FC14_TD1N) YJ23.C2(TX2N_3)
FC14_TDN2: U1.AW62(FC14_TD2N) YJ23.C33(TX3P_3)
FC14_TDN3: U1.AY64(FC14_TD3N) YJ23.C37(TX1N_3)
FC14_TDP0: U1.AV63(FC14_TD0P) YJ23.C5(TX4N_3)
FC14_TDP1: U1.AU65(FC14_TD1P) YJ23.C3(TX2P_3)
FC14_TDP2: U1.AY62(FC14_TD2P) YJ23.C34(TX3N_3)
FC14_TDP3: U1.AW64(FC14_TD3P) YJ23.C36(TX1P_3)
FC15_RDN0: U1.AR54(FC15_RD0N) YJ23.D15(RX3N_4)
FC15_RDN1: U1.AT58(FC15_RD1N) YJ23.D17(RX1P_4)
FC15_RDN2: U1.AR56(FC15_RD2N) YJ23.D24(RX4N_4)
FC15_RDN3: U1.AT60(FC15_RD3N) YJ23.D22(RX2P_4)
FC15_RDP0: U1.AT54(FC15_RD0P) YJ23.D14(RX3P_4)
FC15_RDP1: U1.AR58(FC15_RD1P) YJ23.D18(RX1N_4)
FC15_RDP2: U1.AT56(FC15_RD2P) YJ23.D25(RX4P_4)
FC15_RDP3: U1.AR60(FC15_RD3P) YJ23.D21(RX2N_4)
FC15_TDN0: U1.AT66(FC15_TD0N) YJ23.D34(TX3N_4)
FC15_TDN1: U1.AR64(FC15_TD1N) YJ23.D36(TX1P_4)
FC15_TDN2: U1.AT62(FC15_TD2N) YJ23.D2(TX2N_4)
FC15_TDN3: U1.AN65(FC15_TD3N) YJ23.D6(TX4P_4)
FC15_TDP0: U1.AR66(FC15_TD0P) YJ23.D33(TX3P_4)
FC15_TDP1: U1.AT64(FC15_TD1P) YJ23.D37(TX1N_4)
FC15_TDP2: U1.AR62(FC15_TD2P) YJ23.D3(TX2P_4)
FC15_TDP3: U1.AP65(FC15_TD3P) YJ23.D5(TX4N_4)
FC16_17_PVDD0P8: C2753.1 C2801.1 C3334.1 L41.1 U1.AL49(FC17_PVDD0P8) U1.AP49(FC16_PVDD0P8)
FC16_31_PVDD1P8: C2685.1 C2705.1 C2735.1 C2769.1 C2993.1 C3024.1 C3069.1 C3111.1 C3156.1 L432.1 U1.AC49(FC22-23_PVDD1P8) U1.AF49(FC20-21_PVDD1P8) U1.AJ49(FC18-19_PVDD1P8) U1.AM49(FC16-17_PVDD1P8) U1.W36(FC30-31_PVDD1P8) U1.Y40(FC28-29_PVDD1P8) U1.Y43(FC26-27_PVDD1P8) U1.Y46(FC24-25_PVDD1P8)
FC16_RDN0: U1.AN54(FC16_RD0N) YJ26.D21(RX2N_4)
FC16_RDN1: U1.AM58(FC16_RD1N) YJ26.D14(RX3P_4)
FC16_RDN2: U1.AN56(FC16_RD2N) YJ26.D18(RX1N_4)
FC16_RDN3: U1.AM60(FC16_RD3N) YJ26.D25(RX4P_4)
FC16_RDP0: U1.AM54(FC16_RD0P) YJ26.D22(RX2P_4)
FC16_RDP1: U1.AN58(FC16_RD1P) YJ26.D15(RX3N_4)
FC16_RDP2: U1.AM56(FC16_RD2P) YJ26.D17(RX1P_4)
FC16_RDP3: U1.AN60(FC16_RD3P) YJ26.D24(RX4N_4)
FC16_TDN0: U1.AL62(FC16_TD0N) YJ26.D34(TX3N_4)
FC16_TDN1: U1.AM64(FC16_TD1N) YJ26.D3(TX2P_4)
FC16_TDN2: U1.AL66(FC16_TD2N) YJ26.D37(TX1N_4)
FC16_TDN3: U1.AP63(FC16_TD3N) YJ26.D6(TX4P_4)
FC16_TDP0: U1.AM62(FC16_TD0P) YJ26.D33(TX3P_4)
FC16_TDP1: U1.AL64(FC16_TD1P) YJ26.D2(TX2N_4)
FC16_TDP2: U1.AM66(FC16_TD2P) YJ26.D36(TX1P_4)
FC16_TDP3: U1.AN63(FC16_TD3P) YJ26.D5(TX4N_4)
FC17_RDN0: U1.AJ53(FC17_RD0N) YJ26.C22(RX2P_3)
FC17_RDN1: U1.AK57(FC17_RD1N) YJ26.C15(RX3N_3)
FC17_RDN2: U1.AJ55(FC17_RD2N) YJ26.C17(RX1P_3)
FC17_RDN3: U1.AK59(FC17_RD3N) YJ26.C24(RX4N_3)
FC17_RDP0: U1.AK53(FC17_RD0P) YJ26.C21(RX2N_3)
FC17_RDP1: U1.AJ57(FC17_RD1P) YJ26.C14(RX3P_3)
FC17_RDP2: U1.AK55(FC17_RD2P) YJ26.C18(RX1N_3)
FC17_RDP3: U1.AJ59(FC17_RD3P) YJ26.C25(RX4P_3)
FC17_TDN0: U1.AK65(FC17_TD0N) YJ26.C6(TX4P_3)
FC17_TDN1: U1.AJ63(FC17_TD1N) YJ26.C2(TX2N_3)
FC17_TDN2: U1.AK61(FC17_TD2N) YJ26.C33(TX3P_3)
FC17_TDN3: U1.AG66(FC17_TD3N) YJ26.C37(TX1N_3)
FC17_TDP0: U1.AJ65(FC17_TD0P) YJ26.C5(TX4N_3)
FC17_TDP1: U1.AK63(FC17_TD1P) YJ26.C3(TX2P_3)
