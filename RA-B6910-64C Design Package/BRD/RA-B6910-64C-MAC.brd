# Allegro board RA-B6910-64C-MAC.brd (continued)
## Nets (continued)
N16772955: D439.28(PWM) U136.10(PWMA)
N16772967: D440.28(PWM) U136.6(PWMB)
N16772987: R3623.2 R3624.1 U136.7(EN_SYNC)
N16773011: R3625.1 U136.8(IOUT)
N16773211: C3859.1 D439.24(PHASE)
N16773923: C3860.1 D440.24(PHASE)
N16773935: C3860.2 D440.25(BOOT)
N16776458: D441.5(NC) X297.1
N16776602: D442.5(NC) X296.1
N16776726: C3868.1 R3628.2 U137.1(CSRTNA)
N16776742: C3869.2 R3629.2 U137.2(CSENA)
N16776790: C3871.1 R3633.2 U137.4(CSRTNB)
N16776822: C3870.2 R3634.2 U137.5(CSENB)
N16776874: D442.28(PWM) U137.10(PWMA)
N16776886: D441.28(PWM) U137.6(PWMB)
N16776906: R3630.2 R3631.1 U137.7(EN_SYNC)
N16776930: R3632.1 U137.8(IOUT)
N16777130: C3882.1 D442.24(PHASE)
N16777146: C3882.2 D442.25(BOOT)
N16777529: C3883.1 D441.24(PHASE)
N16777535: C3883.2 D441.25(BOOT)
N16778933: D444.5(NC) X299.1
N16779067: C3891.1 R3635.2 U138.1(CSRTNA)
N16779075: C3892.2 R3636.2 U138.2(CSENA)
N16779099: C3894.1 R3640.2 U138.4(CSRTNB)
N16779115: C3893.2 R3641.2 U138.5(CSENB)
N16779141: D443.28(PWM) U138.10(PWMA)
N16779147: D444.28(PWM) U138.6(PWMB)
N16779157: R3637.2 R3638.1 U138.7(EN_SYNC)
N16779169: R3639.1 U138.8(IOUT)
N16779269: C3905.1 D443.24(PHASE)
N16779277: C3905.2 D443.25(BOOT)
N16779625: C3906.1 D444.24(PHASE)
N16779631: C3906.2 D444.25(BOOT)
N16779743: D443.5(NC) X298.1
N16792545: D446.5(NC) X301.1
N16792617: D445.5(NC) X300.1
N16792669: C3914.1 R3642.2 U139.1(CSRTNA)
N16792687: C3915.2 R3643.2 U139.2(CSENA)
N16792711: C3917.1 R3647.2 U139.4(CSRTNB)
N16792723: C3916.2 R3648.2 U139.5(CSENB)
N16792753: D445.28(PWM) U139.10(PWMA)
N16792759: D446.28(PWM) U139.6(PWMB)
N16792769: R3644.2 R3645.1 U139.7(EN_SYNC)
N16792781: R3646.1 U139.8(IOUT)
N16792881: C3928.1 D445.24(PHASE)
N16792887: C3928.2 D445.25(BOOT)
N16793229: C3929.1 D446.24(PHASE)
N16793235: C3929.2 D446.25(BOOT)
N16951729: C3836.2 D437.25(BOOT)
N16954792: C3859.2 D439.25(BOOT)
N16962947: R3663.1 U140.21(CONFIG)
N17110091: J33.6 R3205.1 TP1.1
N24036336: R224.2 U11.1(A0)
N24036338: R238.2 U11.2(A1)
N24036350: R241.2 U11.21(A2)
N24036801: R266.2 U12.1(A0)
N24036807: R268.2 U12.21(A2)
N24036811: R267.2 U12.2(A1)
N24037211: R206.2 U11.23(SDA)
N24037257: R288.2 U13.23(SDA)
N24037299: R201.2 U10.23(SDA)
N24037303: R216.2 U10.2(A1)
N24037309: R222.2 U10.1(A0)
N24037315: R230.2 U10.21(A2)
N24037469: R254.2 U12.23(SDA)
N24037653: R297.2 U13.2(A1)
N24037655: R295.2 U13.1(A0)
N24037681: R306.2 U13.21(A2)
N24040052: R310.2 R312.1 U14.1(A0)
N24040054: R308.2 R313.1 U14.2(A1)
N24040056: R305.2 R317.2 U14.3(A2)
N24044300: R446.2 U18.23(SDA)
N24044332: R462.2 U18.1(A0)
N24044364: R470.2 U18.21(A2)
N24044376: R466.2 U18.2(A1)
N24045156: R380.2 U16.21(A2)
N24045160: R384.2 U16.1(A0)
N24045166: R388.2 U16.2(A1)
N24045758: R367.2 U16.23(SDA)
N24045803: R432.2 U17.23(SDA)
N24045845: R359.2 U15.23(SDA)
N24045851: R374.2 U15.1(A0)
N24045855: R382.2 U15.21(A2)
N24045867: R390.2 U15.2(A1)
N24045943: R454.2 U17.2(A1)
N24045961: R457.2 U17.21(A2)
N24045973: R460.2 U17.1(A0)
N24368032: C300.1 U44.7(VBST)
N24368040: C301.2 R1191.2 R1193.2 U44.2(VFB)
N24368048: C302.1 U44.3(VREG5)
N24368090: C300.2 L26.2 U44.6(SW)
N26325701: R2033.1 U84.4(R1IN) U84.6(R3IN) U84.7(R4IN) U84.8(R5IN)
N26325715: C3504.2 Q38.1 R2032.1 U84.5(R2IN)
N26325725: R2027.2 U84.13(T2IN)
N26325727: R2031.2 U84.18(R2OUT)
N26325731: R2026.2 U84.14(T1IN)
N26325733: R2023.2 U84.22(F\O\R\C\E\O\F\F\)
N26325735: R2022.2 U84.23(FORCEON)
N26325749: C2058.2 U84.28(C1+)
N26325751: C2058.1 U84.24(C1-)
N26325755: C2061.2 U84.1(C2+)
N26325757: C2061.1 U84.2(C2-)
N26325765: C2062.1 U84.27(V+)
N26325767: C2063.1 U84.3(V-)
N26325797: C3503.2 Q37.1 R2028.2 R2029.1
N26325817: R2028.1 U84.10(T2OUT)
N26325845: R2030.2 U84.12(T3IN)
N26326739: C2066.2 T1.1(TCT1)
N26326741: C2068.2 T1.4(TCT2)
N26326743: C2069.2 T1.7(TCT3)
N26326745: C2070.2 T1.10(TCT4)
N26326755: R2034.1 RV4.1 T1.24(MCT1)
N26326757: R2035.1 RV3.1 T1.21(MCT2)
N26326759: R2036.1 RV2.1 T1.18(MCT3)
N26326761: R2037.1 RV1.1 T1.15(MCT4)
N26326763: C2067.1 R2034.2 R2035.2 R2036.2 R2037.2
N26328176: R2038.2 RJ1.9
N26328196: R2039.1 RJ1.11
N26328252: R2040.2 RJ1.A4
N26328760: C14.1 C3514.2 C3515.2 D94.5 J29.1(VCC) L222.1
N26920312: R2044.1 U1.R33(JTCE0)
N26921640: C2075.1 U1.CB29(PCIE_TD0N)
N26921643: C2076.1 U1.CB30(PCIE_TD0P)
N26921646: C2077.1 U1.CD29(PCIE_TD1N)
N26921649: C2078.1 U1.CD30(PCIE_TD1P)
N26921652: C2079.1 U1.CF30(PCIE_TD2N)
N26921655: C2080.1 U1.CF29(PCIE_TD2P)
N26921658: C2081.1 U1.CC32(PCIE_TD3N)
N26921661: C2082.1 U1.CC31(PCIE_TD3P)
N27240367: C3950.2 R2194.2 R2196.2 U140.39(RGND0)
N27240376: C3950.1 R2195.2 R3131.2 U140.40(VSEN0)
N27612272: D391.2 R3023.2
N27612274: D391.1 R3019.1 R3465.2
N27612276: D387.2 R3015.2
N27612278: D387.1 R3011.1 R3461.2
N27612284: D383.2 R3007.2
N27612286: D383.1 R3004.1 R3457.2
N27612290: D379.2 R2999.2
N27612292: D379.1 R2996.1 R3453.2
N27612296: D375.2 R2991.2
N27612298: D375.1 R2988.1 R3449.2
N27612302: D371.2 R2983.2
N27612304: D371.1 R2979.1 R3445.2
N27612308: D367.2 R2975.2
N27612310: D367.1 R2971.1 R3441.2
N27612314: D363.2 R2967.2
N27612316: D363.1 R2963.1 R3437.2
N27613363: D392.2 R3024.2
N27613365: D392.1 R3020.1 R3466.2
N27613367: D388.2 R3016.2
N27613369: D388.1 R3012.1 R3462.2
N27613375: D385.2 R3008.2
N27613377: D385.1 R3003.1 R3458.2
N27613381: D380.2 R3000.2
N27613383: D380.1 R2995.1 R3454.2
N27613387: D378.2 R2992.2
N27613389: D378.1 R2987.1 R3450.2
N27613393: D372.2 R2984.2
N27613395: D372.1 R2980.1 R3447.2
N27613399: D368.2 R2976.2
N27613401: D368.1 R2972.1 R3442.2
N27613405: D364.2 R2968.2
N27613407: D364.1 R2964.1 R3438.2
N27614643: D393.2 R3025.2
N27614645: D393.1 R3021.1 R3467.2
N27614647: D389.2 R3017.2
N27614649: D389.1 R3013.1 R3463.2
N27614655: D384.2 R3009.2
N27614657: D384.1 R3005.1 R3460.2
N27614661: D382.2 R3001.2
N27614663: D382.1 R2997.1 R3455.2
N27614667: D376.2 R2993.2
N27614669: D376.1 R2989.1 R3452.2
N27614673: D374.2 R2985.2
N27614675: D374.1 R2981.1 R3448.2
N27614679: D369.2 R2977.2
N27614681: D369.1 R2973.1 R3443.2
N27614685: D365.2 R2969.2
N27614687: D365.1 R2965.1 R3439.2
N27615023: D394.2 R3026.2
N27615025: D394.1 R3022.1 R3468.2
N27615027: D390.2 R3018.2
N27615029: D390.1 R3014.1 R3464.2
N27615035: D386.2 R3010.2
N27615037: D386.1 R3006.1 R3459.2
N27615041: D381.2 R3002.2
N27615043: D381.1 R2998.1 R3456.2
N27615047: D377.2 R2994.2
N27615049: D377.1 R2990.1 R3451.2
N27615053: D373.2 R2986.2
N27615055: D373.1 R2982.1 R3446.2
N27615059: D370.2 R2978.2
N27615061: D370.1 R2974.1 R3444.2
N27615065: D366.2 R2970.2
N27615067: D366.1 R2966.1 R3440.2
N27617200: D423.2 R3087.2
N27617202: D423.1 R3083.1 R3497.2
N27617204: D419.2 R3079.2
N27617206: D419.1 R3075.1 R3493.2
N27617212: D415.2 R3071.2
N27617214: D415.1 R3068.1 R3489.2
N27617218: D411.2 R3063.2
N27617220: D411.1 R3059.1 R3485.2
N27617224: D407.2 R3055.2
N27617226: D407.1 R3052.1 R3481.2
N27617230: D403.2 R3047.2
N27617232: D403.1 R3043.1 R3477.2
N27617236: D399.2 R3039.2
N27617238: D399.1 R3036.1 R3473.2
N27617242: D395.2 R3031.2
N27617244: D395.1 R3027.1 R3469.2
N27617580: D424.2 R3088.2
N27617582: D424.1 R3084.1 R3498.2
N27617584: D420.2 R3080.2
N27617586: D420.1 R3076.1 R3494.2
N27617592: D416.2 R3072.2
N27617594: D416.1 R3067.1 R3490.2
N27617598: D412.2 R3064.2
N27617600: D412.1 R3061.1 R3486.2
N27617604: D410.2 R3056.2
N27617606: D410.1 R3051.1 R3482.2
N27617610: D404.2 R3048.2
N27617612: D404.1 R3044.1 R3478.2
N27617616: D400.2 R3040.2
N27617618: D400.1 R3035.1 R3474.2
N27617622: D396.2 R3032.2
N27617624: D396.1 R3028.1 R3470.2
N27617960: D425.2 R3089.2
N27617962: D425.1 R3085.1 R3500.2
N27617964: D421.2 R3081.2
N27617966: D421.1 R3077.1 R3495.2
N27617972: D418.2 R3073.2
N27617974: D418.1 R3069.1 R3491.2
N27617978: D413.2 R3065.2
N27617980: D413.1 R3060.1 R3487.2
N27617984: D409.2 R3057.2
N27617986: D409.1 R3053.1 R3483.2
N27617990: D405.2 R3049.2
N27617992: D405.1 R3045.1 R3479.2
N27617996: D402.2 R3041.2
N27617998: D402.1 R3037.1 R3475.2
N27618002: D397.2 R3033.2
N27618004: D397.1 R3029.1 R3471.2
N27618320: D426.2 R3090.2
N27618342: D426.1 R3086.1 R3499.2
N27618344: D422.2 R3082.2
N27618346: D422.1 R3078.1 R3496.2
N27618352: D417.2 R3074.2
N27618354: D417.1 R3070.1 R3492.2
N27618358: D414.2 R3066.2
N27618360: D414.1 R3062.1 R3488.2
N27618364: D408.2 R3058.2
N27618366: D408.1 R3054.1 R3484.2
N27618370: D406.2 R3050.2
N27618372: D406.1 R3046.1 R3480.2
N27618376: D401.2 R3042.2
N27618378: D401.1 R3038.1 R3476.2
N27618382: D398.2 R3034.2
N27618384: D398.1 R3030.1 R3472.2
N28237185: Q50.3(C) R3543.2 R3544.1
N28237187: Q47.1(B) R3544.2
N28238012: Q52.1(B) R3557.2
N28238014: Q54.3(C) R3557.1 R3560.2
N28238139: Q54.1(B) R3563.2
N28239892: Q51.3(C) R3546.2 R3547.1 R3555.1 R3565.1
N28239894: Q49.1(B) R3547.2
N28240013: C3649.2 Q51.1(B) R3551.2 R3552.2
N28240364: Q53.1(B) R3555.2
N28246918: Q44.3(C) R3522.2 R3523.1
N28246922: Q43.1(B) R3523.2
N28247037: C3646.1 Q44.1(B) R3525.2 R3526.1
N28252512: Q46.3(C) R3529.2 R3530.1 R3541.1 R3561.1 R3568.1
N28252514: Q45.1(B) R3530.2
N28253687: Q48.1(B) R3541.2
N28254458: Q46.1(B) R3535.2
N28597003: C3368.1 C3369.1 C3803.1 C3804.1 C3805.1 C3806.1 C3807.1 C3808.1 C3826.1 C3827.1 C3828.1 C3829.1 C3830.1 C3831.1 C3849.1 C3850.1 C3851.1 C3852.1 C3853.1 C3854.1 C3872.1 C3873.1 C3874.1 C3875.1 C3876.1 C3877.1 C3895.1 C3896.1 C3897.1 C3898.1 C3899.1 C3900.1 C3918.1 C3919.1 C3920.1 C3921.1 C3922.1 C3923.1 CD58.1 CD59.1 CD60.1 CD61.1 CD62.1 CD64.1 D435.21(VIN) D435.27(VIN_PIN27) D436.21(VIN) D436.27(VIN_PIN27) D437.21(VIN) D437.27(VIN_PIN27) D438.21(VIN) D438.27(VIN_PIN27) D439.21(VIN) D439.27(VIN_PIN27) D440.21(VIN) D440.27(VIN_PIN27) D441.21(VIN) D441.27(VIN_PIN27) D442.21(VIN) D442.27(VIN_PIN27) D443.21(VIN) D443.27(VIN_PIN27) D444.21(VIN) D444.27(VIN_PIN27) D445.21(VIN) D445.27(VIN_PIN27) D446.21(VIN) D446.27(VIN_PIN27) L226.1 R3664.1
N29014642: R3215.2 U120.1(1\O\E\)
N29014660: R3210.1 U120.18(1Y0)
N29014699: R3211.1 U120.16(1Y1)
N29014752: R3212.1 U120.14(1Y2)
N29014770: R3213.1 U120.12(1Y3)
N29014858: R3216.1 U120.3(2Y0)
N29028914: J34.6 R3221.2
N29072461: Q40.1(B) R3228.2
N29447723: R2199.2 U140.41(SA)
N29452507: C3951.1 R2225.1 R2226.1 U140.23(VSEN1)
N29452510: C3951.2 R2223.1 R2224.2 U140.24(RGND1)
N29654131: R2046.1 U1.W33(JTCE1)
N29899967: C3648.2 Q50.1(B) R3548.2 R3550.2
N30065259: R3577.2 U130.22(RF)
N30065276: C3653.2 R3571.1 U130.18(VREG)
N30065280: R3573.2 U130.20(MODE)
N30065284: R3575.2 U130.21(TRIP)
N30065288: C3669.1 R3579.2
N30065298: C3670.2 L456.2 R3579.1 R3583.1 U130.6(LL_1) U130.7(LL_2) U130.8(LL_3) U130.9(LL_4) U130.10(LL_5) U130.11(LL_6)
N30067979: C3691.1 R3585.1 R3586.1 U130.1(VFB)
N30068071: C3671.1 C3691.2 R3583.2
N30068077: C3670.1 R3580.2
N30068127: R3580.1 U130.4(VBST)
N30070660: R3576.2 U131.22(RF)
N30070672: C3652.2 R3570.1 U131.18(VREG)
N30070676: R3572.2 U131.20(MODE)
N30070680: R3574.2 U131.21(TRIP)
N30070684: C3668.1 R3578.2
N30070694: C3672.2 L455.2 R3578.1 R3582.1 U131.6(LL_1) U131.7(LL_2) U131.8(LL_3) U131.9(LL_4) U131.10(LL_5) U131.11(LL_6)
N30070911: C3690.1 R3584.1 R3587.1 U131.1(VFB)
N30071011: C3673.1 C3690.2 R3582.2
N30071017: C3672.1 R3581.2
N30071064: R3581.1 U131.4(VBST)
N30072435: R3591.2 U132.22(RF)
N30072447: C3693.2 R3588.1 U132.18(VREG)
N30072451: R3589.2 U132.20(MODE)
N30072455: R3590.2 U132.21(TRIP)
N30072459: C3710.1 R3596.2
N30072461: C3712.2 L457.2 R3596.1 R3599.1 U132.6(LL_1) U132.7(LL_2) U132.8(LL_3) U132.9(LL_4) U132.10(LL_5) U132.11(LL_6)
N30072683: C3722.1 R3601.1 R3603.1 U132.1(VFB)
N30072786: C3713.1 C3722.2 R3599.2
N30072792: C3712.1 R3597.2
N30072833: R3597.1 U132.4(VBST)
N30074206: R3594.2 U133.22(RF)
N30074218: C3700.2 R3592.1 U133.18(VREG)
N30074222: R3593.2 U133.20(MODE)
N30074226: R3595.2 U133.21(TRIP)
N30074230: C3711.1 R3598.2
N30074232: C3723.2 L458.2 R3598.1 R3602.1 U133.6(LL_1) U133.7(LL_2) U133.8(LL_3) U133.9(LL_4) U133.10(LL_5) U133.11(LL_6)
N30074454: C3733.1 R3604.1 R3605.1 U133.1(VFB)
N30074557: C3724.1 C3733.2 R3602.2
N30074563: C3723.1 R3600.2
N30074604: R3600.1 U133.4(VBST)
N30094229: R2590.1 YJ21.A28(INTL_1)
N30094230: R2589.1 YJ21.A27(MODPRSL_1)
N30103237: R2591.2 YJ21.B27(MODPRSL_2)
N30103238: R2588.2 YJ21.B28(INTL_2)
N30175429: R2592.2 YJ21.D28(INTL_4)
N30175430: R2587.2 YJ21.D27(MODPRSL_4)
N30226025: R2608.2 YJ22.B27(MODPRSL_2)
N30226026: R2610.2 YJ22.B28(INTL_2)
N30288942: R2609.2 YJ22.D28(INTL_4)
N30288943: R2607.2 YJ22.D27(MODPRSL_4)
N30290429: R2613.1 YJ22.C28(INTL_3)
N30290430: R2611.1 YJ22.C27(MODPRSL_3)
N30351256: R2626.1 YJ23.A28(INTL_1)
N30351257: R2625.1 YJ23.A27(MODPRSL_1)
N30351300: R2629.2 YJ23.B28(INTL_2)
N30351301: R2627.2 YJ23.B27(MODPRSL_2)
N30443919: R2637.1 YJ23.C28(INTL_3)
N30443920: R2636.1 YJ23.C27(MODPRSL_3)
N30444155: R2638.2 YJ23.D27(MODPRSL_4)
N30444156: R2628.2 YJ23.D28(INTL_4)
N30464265: R2652.1 YJ24.A28(INTL_1)
N30464266: R2650.1 YJ24.A27(MODPRSL_1)
N30464281: R2648.2 YJ24.B28(INTL_2)
N30464282: R2646.2 YJ24.B27(MODPRSL_2)
N30559943: R2651.1 YJ24.C28(INTL_3)
N30559944: R2649.1 YJ24.C27(MODPRSL_3)
N30559978: R2647.2 YJ24.D28(INTL_4)
N30559979: R2645.2 YJ24.D27(MODPRSL_4)
N30587100: R2665.1 YJ25.A27(MODPRSL_1)
N30587101: R2666.1 YJ25.A28(INTL_1)
N30587306: R2672.2 YJ25.B27(MODPRSL_2)
N30587307: R2667.2 YJ25.B28(INTL_2)
N30626149: R3219.1 U120.7(2Y2)
N30634296: Q39.3(C) R3189.1 U119.1(1\O\E\)
N30634449: R3194.1 U119.14(1Y2)
N30634467: R3195.1 U119.12(1Y3)
N30661246: R3192.1 U119.18(1Y0)
N30661249: R3193.1 U119.16(1Y1)
N30661322: R3196.1 U119.3(2Y0)
N30661343: R3200.1 U119.7(2Y2)
N30661349: R3201.1 U119.9(2Y3)
N30662342: R3218.1 U120.5(2Y1)
N30664870: R3222.1 U120.9(2Y3)
N30697802: R3198.1 U119.5(2Y1)
N30710452: R2670.1 YJ25.C28(INTL_3)
N30710455: R2669.1 YJ25.C27(MODPRSL_3)
N30712785: R2673.2 YJ25.D28(INTL_4)
N30712786: R2671.2 YJ25.D27(MODPRSL_4)
N30738971: R2690.1 YJ26.A28(INTL_1)
N30738974: R2694.1 YJ26.A27(MODPRSL_1)
N30738977: R2687.2 YJ26.B28(INTL_2)
N30738980: R2685.2 YJ26.B27(MODPRSL_2)
N30762684: R2693.2 YJ26.D28(INTL_4)
N30762687: R2686.2 YJ26.D27(MODPRSL_4)
N30762757: R2688.1 YJ26.C28(INTL_3)
N30762760: R2689.1 YJ26.C27(MODPRSL_3)
N30785887: J34.9 R3224.2
N30785890: J34.5 R3220.2
N30785893: J34.1 R3217.2
N30793325: Q39.1(B) R3197.2
N30874928: C3647.1 Q2.1(B) R3536.2 R3537.1
N30874932: Q2.3(C) R3532.2 R3533.1
N30874944: Q3.1(B) R3533.2
N30987892: R2709.2 YJ27.B27(MODPRSL_2)
N30987895: R2711.2 YJ27.B28(INTL_2)
N30987906: R2707.1 YJ27.A28(INTL_1)
N30987909: R2705.1 YJ27.A27(MODPRSL_1)
N31014314: R2706.1 YJ27.C28(INTL_3)
N31014317: R2718.1 YJ27.C27(MODPRSL_3)
N31014328: R2710.2 YJ27.D28(INTL_4)
N31014331: R2708.2 YJ27.D27(MODPRSL_4)
N31076949: R2725.2 YJ28.B28(INTL_2)
N31076952: R2727.2 YJ28.B27(MODPRSL_2)
N31077039: R2732.1 YJ28.A28(INTL_1)
N31077042: R2730.1 YJ28.A27(MODPRSL_1)
N31101246: R2731.1 YJ28.C28(INTL_3)
N31101249: R2729.1 YJ28.C27(MODPRSL_3)
N31101252: R2728.2 YJ28.D28(INTL_4)
N31101255: R2726.2 YJ28.D27(MODPRSL_4)
N31126523: R2745.1 YJ29.A27(MODPRSL_1)
N31126526: R2746.1 YJ29.A28(INTL_1)
N31126552: R2748.2 YJ29.B28(INTL_2)
N31126555: R2756.2 YJ29.B27(MODPRSL_2)
N31182601: R2755.2 YJ29.D27(MODPRSL_4)
N31182604: R2747.2 YJ29.D28(INTL_4)
N31182693: R2754.1 YJ29.C28(INTL_3)
N31182696: R2753.1 YJ29.C27(MODPRSL_3)
N31333317: R2772.1 YJ30.A28(INTL_1)
N31333320: R2770.1 YJ30.A27(MODPRSL_1)
N31333457: R2768.2 YJ30.B28(INTL_2)
N31333460: R2766.2 YJ30.B27(MODPRSL_2)
N31357668: R2771.1 YJ30.C28(INTL_3)
N31357671: R2769.1 YJ30.C27(MODPRSL_3)
N31357703: R2765.2 YJ30.D27(MODPRSL_4)
N31357706: R2767.2 YJ30.D28(INTL_4)
N31392849: R2792.2 YJ31.B28(INTL_2)
N31392860: R2790.2 YJ31.B27(MODPRSL_2)
N31393396: R2788.1 YJ31.A28(INTL_1)
N31393399: R2786.1 YJ31.A27(MODPRSL_1)
N31485105: R2787.1 YJ31.C28(INTL_3)
N31485108: R2785.1 YJ31.C27(MODPRSL_3)
N31485124: R2791.2 YJ31.D28(INTL_4)
N31485127: R2789.2 YJ31.D27(MODPRSL_4)
N31509514: R2808.1 YJ32.A28(INTL_1)
N31509517: R2812.1 YJ32.A27(MODPRSL_1)
N31509804: R2810.2 YJ32.B27(MODPRSL_2)
N31509807: R2806.2 YJ32.B28(INTL_2)
N31535647: R2805.2 YJ32.D28(INTL_4)
N31535650: R2809.2 YJ32.D27(MODPRSL_4)
N31535718: R2807.1 YJ32.C28(INTL_3)
N31535721: R2811.1 YJ32.C27(MODPRSL_3)
N31668297: R2826.1 YJ33.A28(INTL_1)
N31668300: R2825.1 YJ33.A27(MODPRSL_1)
N31668331: R2838.2 YJ33.B27(MODPRSL_2)
N31668334: R2828.2 YJ33.B28(INTL_2)
N31678786: R2837.2 YJ33.D27(MODPRSL_4)
N31678789: R2827.2 YJ33.D28(INTL_4)
N31678800: R2835.1 YJ33.C27(MODPRSL_3)
N31678803: R2836.1 YJ33.C28(INTL_3)
N31687868: R2848.2 YJ34.B28(INTL_2)
N31687871: R2846.2 YJ34.B27(MODPRSL_2)
N31687984: R2850.1 YJ34.A28(INTL_1)
N31687987: R2852.1 YJ34.A27(MODPRSL_1)
N31699202: R2847.2 YJ34.D28(INTL_4)
N31699205: R2845.2 YJ34.D27(MODPRSL_4)
N31699224: R2849.1 YJ34.C28(INTL_3)
N31699227: R2851.1 YJ34.C27(MODPRSL_3)
N31999676: R2866.1 YJ35.A28(INTL_1)
N31999679: R2865.1 YJ35.A27(MODPRSL_1)
N31999724: R2867.2 YJ35.B28(INTL_2)
N31999727: R2872.2 YJ35.B27(MODPRSL_2)
N32008720: R2870.1 YJ35.C28(INTL_3)
N32008723: R2869.1 YJ35.C27(MODPRSL_3)
N32009355: R2871.2 YJ35.D28(INTL_4)
N32009358: R2873.2 YJ35.D27(MODPRSL_4)
N32021119: R2885.2 YJ36.B27(MODPRSL_2)
N32021122: R2887.2 YJ36.B28(INTL_2)
N32021813: R2890.1 YJ36.A28(INTL_1)
N32021816: R2893.1 YJ36.A27(MODPRSL_1)
N32032934: R2886.2 YJ36.D28(INTL_4)
N32032937: R2892.2 YJ36.D27(MODPRSL_4)
N32033441: R2889.1 YJ36.C28(INTL_3)
N32033444: R2888.1 YJ36.C27(MODPRSL_3)
N32118226: R3274.1 U123.G11(PR5C/PR8C/PR10C)
N32118228: R3266.1 U123.G12(PR3D/PR5D/PR6D)
N32118230: R3269.1 U123.F12(PR4C/PR6C/PR7C)
N32118232: R3264.1 U123.F13(PR3C/PR5C/PR6C)
N32118234: R3273.1 U123.G13(PR4D/PR6D/PR7D)
N32118236: R3279.1 U123.H13(PR6C/PR9C/PR11C)
N32118238: R3276.1 U123.H12(PR5D/PR8D/PR10D)
N32118254: R3318.2 R3319.1 R3320.2 R3321.1
N32118290: R3272.1 U123.B9(PT19A*/PT21A*/PT25A*)
N32118294: R3290.1 R3292.1 U123.A11(PT21A*/PT24A*/PT28A*)
N32118315: Q5.1(B) R3315.1
N32118330: R3275.1 U123.F9(PT19C/PT22A*/PT26A*)
N32118356: R3281.1 U123.D10(PT20A*/PT23A*/PT27A*)
N32118384: R3311.1 R3313.1 U123.C12(PT23A*/PT27A*/PT35A*)
N32118454: R34.1 R3244.1 U121.5(A2)
N32118456: R33.1 R3247.1 U121.6(A1)
N32118493: R35.1 R3242.1 U121.7(A0)
N32118597: R3307.1 U123.B13(PT22C/PT26A*/PT34A*)
N32118603: R3255.1 R3263.1 U123.F8(PT18A*/PT20A*/PT22A*)
N32118631: R3316.1 R3317.1 U123.B14(PT24A*/PT28A*/PT36A*)
N32118832: R3296.1 R3299.1 U123.F10(PT21C/PT24C/PT32A*)
N32118872: Q5.3(C) R3312.1 U123.R16(PR14D/PR20D/PR25D)
N32119094: R3257.2 U123.B5(PT9B*/PT9B*/PT9B*)
N32119389: R3258.2 U123.B6(PT11B*/PT11B*/PT11B*)
N32119403: R3271.2 U123.C5(PT10B*/PT10B*/PT10B*)
N32119405: R3268.2 U123.A4(PT10A*/PT10A*/PT10A*)
N32119419: R3280.1 U123.B4(PT11D/PT12B*/PT12B*)
N32119421: R3297.1 U123.L12(PR10D/PR14D/PR17D)
N32119441: R3282.2 U123.D6(PT12A*/PT13A*/PT14A*)
N32119628: R3302.2 U123.E6(PT13C/PT14C/PT16A*)
N32119983: R3308.2 U123.P16(PR13D/PR18D/PR23D)
N32119995: R3306.2 U123.N15(PR13C/PR18C/PR23C)
N32120180: R3241.1 U121.1(SDA)
N32120201: R3344.1 U123.D3(PL1A/PL3A/PL3A || L_GPLLT_FB)
N32120203: R3326.1 U123.H2(PL6B/PL9B/PL10B)
N32120253: U123.A2(NC/NC/NC) X249.1
N32120329: R3323.2 U123.A13(PT24C/PT28C/PT36C || INITN)
N32120333: R3294.1 U123.J11(PR10C/PR14C/PR17C)
N32120418: Q6.3(C) R3295.2 U123.B7(PT13A*/PT14A*/PT15A*)
N32120471: R3262.1 U123.E14(PR2B/PR3B/PR3B || R_GPLLC_IN**)
N32120475: R3333.1 U123.J3(PL7D/PL10D/PL12B || PCLKC4_0)
N32120477: R3329.2 U123.K6(PL10D/PL14D/PL16D)
N32120495: R3254.2 U123.E15(PR1B/PR2B/PR2B || R_GPLLC_FB**)
N32120573: D427.1(ANODE) R3262.2
N32120616: R3334.1 U123.R3(PB3D/PB3D/PB4D)
N32120618: R3331.1 U123.P4(PB3A/PB3A/PB4A)
N32120622: R3338.1 U123.T5(PB6A/PB7A/PB9A)
N32120624: R3340.1 U123.L7(PB8D/PB9D/PB10B)
N32120626: R3342.1 U123.M7(PB9C/PB10C/PB13C)
N32120656: R3346.1 U123.T7(PB11A/PB13A/PB16A || PCLKT2_0)
N32120658: R3327.2 U123.K1(PL9B/PL13B/PL15B)
N32120660: R3350.1 U123.N8(PB12C/PB15C/PB18C)
N32120925: R3303.1 U123.B11(PT22A*/PT25A*/PT33A*)
N32121093: R3284.2 R3287.1 U123.C10(PT20C/PT23C/PT27C || JTAGENB)
N32121131: R3286.2 U123.B10(PT20D/PT23D/PT27D || PROGRAMN)
N32121153: R3265.2 U123.B3(PT9C/PT9C/PT9C)
N32121284: R3289.2 U123.C6(PT12C/PT13C/PT14C || TDO)
N32121533: R3261.1 U123.C16(PR2C/PR4C/PR4C)
N32121535: R3256.1 U123.D15(PR2D/PR4D/PR4D)
N32121537: R3253.1 U123.B16(PR1D/PR2D/PR2D)
N32121547: R3252.1 U123.C15(PR1C/PR2C/PR2C)
N32121612: R3298.1 U123.C7(PT13B*/PT14B*/PT15B*)
N32121756: R3267.1 U123.C9(PT18D/PT20D/PT22D || SDA/PCLKC0_0)
N32121837: R30.1 R3249.1 U122.6(A1)
N32121839: R31.1 R3250.1 U122.5(A2)
N32121881: R32.1 R3245.1 U122.7(A0)
N32121920: R3278.2 U123.A3(PT11C/PT12A*/PT12A*)
N32166567: R3383.1 U124.H11(PR9C/PR13C/PR16C)
N32166569: R3386.1 U124.J11(PR10C/PR14C/PR17C)
N32166575: R3370.1 U124.H13(PR6C/PR9C/PR11C)
N32166577: R3373.1 U124.J12(PR6D/PR9D/PR11D)
N32166579: R3378.1 U124.J16(PR7C/PR10C/PR15A)
N32166581: R3381.1 U124.J14(PR7D/PR10D/PR15B)
N32167148: R3382.2 U124.C6(PT12C/PT13C/PT14C || TDO)
N32167346: R3385.1 U124.J13(PR9D/PR13D/PR16D)
N32167587: R3363.1 U124.F9(PT19C/PT22A*/PT26A*)
N32167649: R3399.2 R3400.1 R3403.2 R3404.1
N32168026: R3376.2 R3380.1 U124.C10(PT20C/PT23C/PT27C || JTAGENB)
N32168064: R3377.2 U124.B10(PT20D/PT23D/PT27D || PROGRAMN)
N32168163: R3392.1 U124.C12(PT23A*/PT27A*/PT35A*)
N32168175: R3393.1 U124.B12(PT23B*/PT27B*/PT35B*)
N32168363: Q42.3(C) R3357.2 U124.B3(PT9C/PT9C/PT9C)
N32168450: R3360.2 U124.C5(PT10B*/PT10B*/PT10B*)
N32168466: R3366.2 U124.A5(PT11A*/PT11A*/PT11A*)
N32168480: R3354.2 U124.B6(PT11B*/PT11B*/PT11B*)
N32168512: R3368.2 U124.B4(PT11D/PT12B*/PT12B*)
N32168516: R3367.2 U124.A3(PT11C/PT12A*/PT12A*)
N32168542: R3372.2 U124.D6(PT12A*/PT13A*/PT14A*)
N32168566: R3375.2 U124.E7(PT12B*/PT13B*/PT14B*)
N32168847: D428.1(ANODE) R3361.2
N32168849: R3361.1 U124.B9(PT19A*/PT21A*/PT25A*)
N32168979: U124.A2(NC/NC/NC) X252.1
N32168993: R3358.1 U124.C9(PT18D/PT20D/PT22D || SDA/PCLKC0_0)
N32240710: C303.1 U44.4(SS)
N32247716: R3353.2 U124.A4(PT10A*/PT10A*/PT10A*)
N32265631: R361.1 U14.5(SDA)
N32287581: R3332.1 U123.L4(PL12D/PL17D/PL21D)
N32287609: R3328.1 U123.K4(PL11C/PL16C/PL19C)
N32287740: R3335.2 U123.N2(PL13C/PL18C/PL23C)
N32287789: R3330.2 U123.N3(PL14B/PL20B/PL25B)
N32287821: R3345.2 U123.F3(PL4A/PL7A/PL8A)
N32287843: R3347.2 U123.G3(PL5B/PL8B/PL9B)
N32288243: R3351.1 U123.F2(PL3B/PL6B/PL6B || PCLKC5_0)
N32288267: R3349.1 U123.C1(PL2C/PL4C/PL4C)
N32288959: R3348.2 U123.T13(PB24B/PB29B/PB37B)
N32288979: R3343.2 U123.T14(PB22D/PB26B/PB34B)
N32289037: R3341.2 U123.M10(PB21C/PB24C/PB31C)
N32289075: R3339.2 U123.M11(PB19D/PB23D/PB28B)
N32289109: R3337.2 U123.M9(PB18C/PB21C/PB26C)
N32289129: R3336.2 U123.N9(PB16D/PB18B/PB21B)
N32289169: R3324.2 U123.N16(PR14A/PR19A/PR24A)
N32289201: R3309.2 U123.K12(PR11D/PR15D/PR19D)
N32289255: R3305.2 U123.L16(PR11A/PR15A/PR18A)
N32289273: R3293.2 U123.K16(PR9B/PR13B/PR16B DQS1N)
N32289333: R3277.2 U123.G14(PR5B/PR8B/PR9B)
N32289353: R3270.2 U123.F14(PR4A/PR6A/PR7A)
N32292935: R3304.2 U123.L13(PR12D/PR16D/PR21D)
N32292939: R3301.2 U123.K11(PR12C/PR16C/PR21C)
N32295057: R3413.1 U124.K4(PL11C/PL16C/PL19C)
N32295185: R3419.1 U124.L2(PL12A/PL17A/PL22A || PCLKT3_0)
N32295247: R3414.2 U124.R1(PL14C/PL20C/PL25C)
N32295323: R3412.2 U124.M3(PL13A/PL19A/PL24A)
N32295386: R3435.2 U124.F5(PL5C/PL8C/PL9C)
N32295430: R3431.2 U124.F3(PL4A/PL7A/PL8A)
N32295474: R3436.1 U124.F4(PL3C/PL6C/PL6C)
N32295554: R3434.1 U124.C1(PL2C/PL4C/PL4C)
N32295598: R3430.1 U124.D3(PL1A/PL3A/PL3A || L_GPLLT_FB)
N32295638: R3432.1 U124.N8(PB12C/PB15C/PB18C)
N32295682: R3428.1 U124.T7(PB11A/PB13A/PB16A || PCLKT2_0)
N32295760: R3426.1 U124.M7(PB9C/PB10C/PB13C)
N32295825: R3424.1 U124.P6(PB8A/PB9A/PB12A || MCLK/CCLK)
N32295869: R3422.1 U124.T5(PB6A/PB7A/PB9A)
N32295913: R3415.1 U124.R5(PB5A/PB4A/PB6A || CSSPIN)
N32295951: R3418.1 U124.P4(PB3A/PB3A/PB4A)
N32296009: R3421.2 U124.R9(PB18A/PB21A/PB26A)
N32296083: R3423.2 U124.N10(PB19C/PB23C/PB28A)
N32296127: R3425.2 U124.T11(PB21A/PB24A/PB31A)
N32296171: R3427.2 U124.R13(PB22C/PB26A/PB34A)
N32296216: R3429.2 U124.P12(PB24A/PB29A/PB37A)
N32296275: R3433.2 U124.T15(PB25C/PB30C/PB38C)
N32296319: R3420.2 U124.K3(PL10A/PL14A/PL17A)
N32296357: R3417.2 U124.H5(PL9C/PL13C/PL15C)
N32296409: R3416.1 U124.H4(PL6C/PL9C/PL10C)
N32296479: R3394.1 U124.P15(PR14C/PR20C/PR25C)
N32296532: R3407.2 U124.N16(PR14A/PR19A/PR24A)
N32296624: R3396.2 U124.L15(PR12A/PR16A/PR21A)
N32296668: R3388.2 U124.L16(PR11A/PR15A/PR18A)
N32296748: R3371.2 U124.G16(PR6A/PR9A/PR11A DQS0)
N32296803: R3362.2 U124.F14(PR4A/PR6A/PR7A)
N32296857: R3356.2 U124.D16(PR2A/PR3A/PR3A || R_GPLLT_IN**)
N32296896: R3364.2 U124.F8(PT18A*/PT20A*/PT22A*)
N32296968: R3398.1 U124.A15(PT24B*/PT28B*/PT36B*)
N32296972: R3397.1 U124.B14(PT24A*/PT28A*/PT36A*)
N32338882: C3436.2 R3140.1 U117.9(PRI_REFN)
N32338926: C3466.1 OSC1.1 R3176.2 R3177.1
N32338934: C3467.1 OSC1.2 R3176.1 R3178.2
N32339065: R3134.2 R3137.2 U117.6(REF_SEL)
N32339113: R3155.1 R3168.2 U117.25(Y4_N)
N32339115: R3156.1 R3169.2 U117.26(Y4_P)
N32339117: R3159.1 U117.46(STATUS0)
N32339133: C3450.1 R3174.2 U117.36(Y7_N)
N32339167: C3475.1 C3476.1 C3477.1 L449.2 R3183.1 R3184.1 U118.5(VDD)
N32339181: R3186.1 U118.4(WDI)
N32340080: R3136.2 U117.3(SDO/AD0/PIN2)
N32340161: C3462.2 C3463.2 C3464.2 L448.1 OSC2.4(VDD) R3179.2
N32340194: C3474.1 OSC2.3(CLK) R3181.1 X303.1
N32340196: OSC2.1(OE/S\T\) R3179.1
N32340280: C3455.1 R3175.2 U117.35(Y7_P)
N32340378: R3185.2 U118.1(R\E\S\E\T\)
N32340543: R3138.1 R3161.2 U117.14(Y0_P)
N32340545: R3142.1 R3160.2 U117.15(Y0_N)
N32340547: R3145.1 R3163.2 U117.17(Y1_P)
N32340549: R3144.1 R3162.2 U117.16(Y1_N)
N32340551: R3147.1 R3165.2 U117.20(Y2_P)
N32340553: R3146.1 R3164.2 U117.21(Y2_N)
N32340606: C3438.2 R3143.2 U117.41(ELF)
N32340616: C3439.2 R3143.1
N32340618: C3437.2 U117.40(REG_CAP)
N32340715: R3141.2 U117.47(SI_MODE1)
N32340717: R3135.2 U117.1(SI_MODE0)
N32344144: C3446.1 R3172.2 U117.33(Y6_N)
N32344146: C3447.1 R3173.2 U117.32(Y6_P)
N32344318: R3153.1 R3166.2 U117.22(Y3_N)
N32344320: R3154.1 R3167.2 U117.23(Y3_P)
N32344332: R3157.1 R3170.2 U117.28(Y5_N)
N32344334: R3158.1 R3171.2 U117.29(Y5_P)
N32352652: R3504.1 R3659.1 U140.19(SDA)
N32365253: C3621.2 L453.2 U128.2(SW)
N32365255: R3514.1 U128.6(VBST)
N32365267: C3629.2 R3515.2 R3516.2 U128.4(VFB)
N32365460: C3621.1 R3514.2
N32365530: C3619.2 L452.2 U127.2(SW)
N32365532: R3511.1 U127.6(VBST)
N32365544: C3620.2 R3512.2 R3513.2 U127.4(VFB)
N32365629: C3619.1 R3511.2
N32600224: D433.1(ANODE) R3411.2
N32600228: D432.1 R3405.2 R3408.2
N32600230: D432.2 R3409.2
N32600337: D431.1 R3387.2 R3389.2
N32600339: D431.2 R3390.2
N32600404: D430.1 R3369.2 R3374.2
N32600406: D430.2 R3379.2
N32600485: D429.1 R3355.2 R3365.2
N32600487: D429.2 R3352.2
N32638646: R3243.1 U122.1(SDA)
N32687454: J35.3 R3231.2
N32687486: J35.5 R3229.2
N32687488: J35.9 R3234.2
N32687490: J35.11 R3235.2
N32687492: J35.2 R3230.1
N32687534: J35.6 R3232.1
N32687536: J35.8 R3233.1
N32687538: J35.12 R3236.1
N32696720: C3603.1 U126.6(NR)
N32696851: C3602.2 L451.2 U125.2(SW)
N32696853: R3506.1 U125.6(VBST)
N32696865: C3607.2 R3508.2 R3509.1 U125.4(VFB)
N32697038: C3602.1 R3506.2
N32723720: J30.1 R3501.1
N32723723: J30.3 R3502.1
N32723749: J30.2 R3503.2
N32816680: C3637.2 L454.2 U129.2(SW)
N32816682: R3517.1 U129.6(VBST)
N32816696: C3638.2 R3518.2 R3519.2 U129.4(VFB)
N32816879: C3637.1 R3517.2
N32816891: D434.1(ANODE) R3520.2
N32819414: Q56.1(B) R3565.2
N32826604: Q55.1(B) R3561.2
N32826884: Q57.1(B) R3568.2
N32827329: R3246.1 U121.3(OS)
N32827380: R3248.1 U122.3(OS)
N32837875: L450.1 SW1.1
N32837877: L450.2 R3237.2
N32839304: R3288.2 R3291.2 U123.H11(PR9C/PR13C/PR16C)
N32840365: R3283.2 R3285.2 U123.J16(PR7C/PR10C/PR15A)
N32893128: R3606.1 U123.J12(PR6D/PR9D/PR11D)
N32899033: U124.E8(PT16B*/PT15B*/PT17B*) X282.1
N32899051: R3675.1 U124.C4(PT9A*/PT9A*/PT9A*) X276.1
N32899085: U124.D10(PT20A*/PT23A*/PT27A*) X280.1
N32899101: U124.E10(PT20B*/PT23B*/PT27B*) X281.1
N32899129: U124.C15(PR1C/PR2C/PR2C) X274.1
N32899145: U124.B16(PR1D/PR2D/PR2D) X275.1
N32899165: U124.C16(PR2C/PR4C/PR4C) X277.1
N32899181: U124.D15(PR2D/PR4D/PR4D) X271.1
N32899201: U124.F13(PR3C/PR5C/PR6C) X272.1
N32899217: U124.G12(PR3D/PR5D/PR6D) X273.1
N32899243: U124.F12(PR4C/PR6C/PR7C) X278.1
N32899259: U124.G13(PR4D/PR6D/PR7D) X279.1
N32899279: U124.H3(PL7A/PL10A/PL11A) X283.1
N32899295: U124.H1(PL7B/PL10B/PL11B) X284.1
N32899315: U124.J1(PL7C/PL10C/PL12A || PCLKT4_0) X285.1
N32899331: U124.J3(PL7D/PL10D/PL12B || PCLKC4_0) X286.1
N33261195: C21.1 R29.2 U124.A10(PT19B*/PT21B*/PT25B*) X250.1
N34483800: R27.1 U123.E8(PT16B*/PT15B*/PT17B*)
N34483802: R26.1 U123.F7(PT16A*/PT15A*/PT17A*)
N34483892: R3676.1 U124.B5(PT9B*/PT9B*/PT9B*) X302.1
N264813220: R2585.1 YJ21.C27(MODPRSL_3)
N264813390: R2586.1 YJ21.C28(INTL_3)
N265383680: R2612.1 YJ22.A27(MODPRSL_1)
N265383760: R2605.1 YJ22.A28(INTL_1)
N321190091: Q6.1(B) R3300.2
N321683591: Q42.1(B) R3359.2
N3212144327: R3322.1 U123.D8(PT17C/PT19A*/PT21A*)

Pads without a net: D94 1 6; FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; FD7 1; FD8 1; J30 5 6 7 8 9 10; J33 7 8; J34 7 8; Q37 3; Q38 3; RJ1 A1 A2 A7 A8; U1 AB15 AB16 AB34 AC51 AD34 AE16 AE51 AE52 AG15 AG16 AH51 AM51 AM52 AP15 AP16 AT15 AT16 AT51 AT52 AU15 AU16 AU51 AU52 AW51 BA35 BA51 BB16 BB51 BE15 BE16 BE51 BE52 BF33 BG16 BG31 BG36 BG51 BH31 BH36 BH38 BH39 BJ21 BJ28 BJ29 BJ33 BJ36 BJ38 BJ39 BJ42 BK33 BK36 BM16 BM30 BM31 BM33 BM36 BM37 BM52 BN30 BN31 BN33 BP51 BP52 H15 J51 L51 R34 R35 R36 R49 R50 T36 U36 W19 W37 W38 Y37 Y38; U84 9 11 15 16 17 19 20 21; U117 45; U130 5; U131 5; U132 5; U133 5; U140 1 9 11 12 46 47 48

## Via types
v1: diameter 0.457, hole 0.229, TOP to BOTTOM, 9799 vias
v2: diameter 0.762, hole 0.381, TOP to BOTTOM, 1179 vias
v3: diameter 0.813, hole 0.406, TOP to BOTTOM, 1379 vias
v4: diameter 0.457, hole 0.203, TOP to BOTTOM, 1030 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
DVDD: length 75.9
  TOP w0.381: 291.68,211.43 C3460.1 ; C3460.1 C3459.1 ; C3460.1 C3456.1 ; C3428.1 C3427.1 293.94,212.82 v1(293.69,212.57) ; C3428.1 293.41,211.68 ; C3428.1 C3461.1 ; 291.63,213.84 C3426.1 ; C3426.1 C3459.1 ; C3426.1 290.94,214.58 ; 291.68,210.28 C3456.1 ; C3456.1 C3457.1 ; C3429.1 297.62,200.02 ; C3429.1 298.41,200.68 ; C3429.1 298.41,199.54 ; C3441.1 C3444.1 ; C3441.1 298.21,204.04 ; C3441.1 C3442.1 ; C3444.1 297.07,204.04 ; C3444.1 C3445.1 ; C3461.1 294.07,210.54 v1(293.66,210.13) ; C3461.1 C3458.1 ; 291.68,208 C3452.1 ; C3452.1 C3453.1 ; C3452.1 C3457.1 ; 295.92,204.04 C3445.1 ; C3445.1 C3443.1 294.78,204.04 ; C3425.1 C3469.1 ; C3425.1 C3468.1 302.32,213.23 ; C3425.1 302.32,211.71 ; C3469.1 302.32,210.56 ; C3469.1 C3471.1 ; C3454.1 C3458.1 ; C3454.1 C3451.1 293.72,207.11 293.54,206.92 v1(293.54,206.63) ; C3454.1 293.41,208.25 ; C3458.1 293.41,209.4 ; C3459.1 291.68,212.57 ; C3449.1 C3448.1 291.68,204.57 ; C3449.1 C3453.1 ; C3449.1 291.68,205.71 ; C3453.1 291.68,206.86 ; 299.35,204.04 C3442.1 ; C3442.1 C3440.1 300.7,204.24 v1(301,203.93) ; C3473.1 C3472.1 302.32,205.99 ; C3473.1 302.32,207.13 ; C3473.1 C3470.1 ; C3471.1 C3470.1 ; C3471.1 302.32,209.42 ; C3470.1 302.32,208.28 ; C3457.1 291.68,209.14
  TOP w0.508: L447.2 292.44,215.62 ; L447.2 291.53,215.01 ; L447.2 292.44,213.89
  BOTTOM w0.254: v1(293.38,208.79) 293.38,208.76 293.51,208.63 U117.31 ; U117.13 300.71,204.23 v1(301,203.93) ; U117.27 v1(293.54,206.63) ; U117.37 295.2,212.15 294.78,212.57 v1(293.69,212.57) ; U117.19 297.71,204.04 v1(297.47,203.81) ; v1(294.91,203.93) 295.2,204.23 U117.24 ; U117.18 298.2,203.94 298.34,203.81 v1(298.36,203.81) ; U117.48 300.71,212.32 300.83,212.44 v1(302.45,212.44) ; U117.10 v1(302.45,206.63) ; v1(293.38,207.9) 293.62,208.13 U117.30 ; U117.34 v1(293.66,210.13) ; U117.7 v1(302.45,208.13)
  BOTTOM w0.381: v2(308.24,214.22) v1(307.48,214.22) R3151.1 ; R3134.1 v1(307.48,207.87) ; R3148.1 v1(299.73,216.28) ; R3150.1 v1(307.48,211.68) ; R3149.1 v1(298.59,216.28)
GND: length 6230.2
  TOP w0.178: U124.N13 v1(406.02,176.85) ; U123.J8 v1(24.05,158.2) ; U123.H8 v1(24.05,159.8) ; U124.E5 v1(398.82,184.05) ; U123.B2 v1(19.25,164.6) ; U124.D13 v1(406.02,184.85) ; U124.B2 v1(396.42,186.45) ; U124.F11 v1(404.42,183.25) ; U123.M12 v1(28.05,155.8) ; U123.F6 v1(22.45,161.4) ; U124.C3 v1(397.22,185.65) ; U123.F11 v1(27.25,161.4) ; U123.L6 v1(22.45,156.6) U123.M5 v1(21.65,155.8) ; U123.B15 v1(30.45,164.6) ; U123.E5 v1(21.65,162.2) ; U124.F6 v1(399.62,183.25) ; U123.P3 v1(20.05,154.2) ; U123.E12 v1(28.05,162.2) ; U124.B15 v1(407.62,186.45) ; U123.N13 v1(28.85,155) ; v1(398.82,177.65) U124.M5 v1(399.62,178.45) U124.L6 ; U124.H8 v1(401.22,181.65) ; U123.N4 v1(20.85,155) ; U124.M12 v1(405.22,177.65) ; U124.C14 v1(406.82,185.65) ; U123.R15 v1(30.45,153.4) ; U124.R2 v1(396.42,175.25) ; U123.J9 v1(25.65,158.2) ; U124.R15 v1(407.62,175.25) ; U124.E12 v1(405.22,184.05) ; U124.N4 v1(398.02,176.85) ; U123.C14 v1(29.65,163.8) ; U124.J9 v1(402.82,180.05) ; U123.P14 v1(29.65,154.2) ; U124.D4 v1(398.02,184.85) ; U123.D13 v1(28.85,163) ; U123.C3 v1(20.05,163.8) ; U124.H9 v1(402.82,181.65) ; U124.L11 v1(404.42,178.45) ; U124.P3 v1(397.22,176.05) ; U123.H9 v1(25.65,159.8) ; U123.D4 v1(20.85,163) ; U123.R2 v1(19.25,153.4) ; U123.L11 v1(27.25,156.6) ; U124.J8 v1(401.22,180.05) ; U124.P14 v1(406.82,176.05)
  TOP w0.203: U140.37 379.45,170.87 v1(379.34,170.99) 379.05,170.71 U140.38 ; v1(373.6,166.37) 373.88,166.66 U140.8 ; v1(373.6,165.45) 374,165.86 U140.10
  TOP w0.229: U1.AF8 v1(223.55,131.34) ; U1.BV34 v1(196.55,164.34) ; U1.K18 213.55,115.34 v1(213.55,115.31) ; v1(174.52,134.37) 174.55,134.34 U1.AJ56 ; U1.F33 198.55,111.34 v1(198.55,111.31) ; U1.BY60 v1(170.55,166.34) ; U1.BT54 176.55,162.34 v1(176.52,162.34) ; U1.BN23 v1(207.55,159.34) U1.BN24 ; v1(221.57,131.34) 221.55,131.34 U1.AF10 ; U1.R12 219.55,120.34 v1(219.57,120.34) ; U1.R39 v1(191.55,120.34) ; U1.CA29 v1(202.55,167.34) ; U1.N50 v1(180.55,118.34) ; U1.BR45 v1(185.55,161.34) ; v1(166.52,118.37) 166.55,118.34 U1.N64 ; U1.BM59 v1(171.55,158.34) ; U1.A24 v1(207.55,106.34) ; U1.C13 v1(218.55,108.34) ; U1.AT55 175.57,142.32 v1(175.52,142.32) ; U1.CE60 v1(170.55,171.34) ; v1(213.6,169.34) 213.55,169.34 U1.CC18 ; v1(176.52,122.34) 176.55,122.34 U1.U54 ; v1(230.58,135.29) 230.56,135.29 230.55,135.3 230.55,135.34 U1.AK1 ; v1(173.52,116.34) 173.55,116.34 U1.L57 ; v1(171.52,128.37) 171.55,128.37 172.02,128.84 U1.AC59 ; U1.H12 v1(219.55,113.34) ; v1(175.52,157.34) 175.55,157.34 U1.BL55 ; U1.BE6 v1(225.55,151.34) ; U1.F49 v1(181.55,111.34) ; U1.BH42 v1(188.55,154.34) ; U1.BU1 230.58,163.37 v1(230.58,163.39) ; U1.K25 206.55,115.34 v1(206.55,115.31) ; U1.AF48 v1(182.55,131.34) ; U1.BF47 v1(183.55,152.34) ; v1(171.52,126.29) 171.55,126.32 171.55,126.34 U1.AA59 ; U1.M48 182.55,117.34 v1(182.55,117.32) ; U1.BR46 184.55,161.34 v1(184.55,161.37) ; v1(209.55,113.31) 209.55,113.34 U1.H22 ; v1(169.55,109.27) 169.55,109.34 U1.D61 ; U1.BW47 v1(183.55,165.34) ; U1.AM6 v1(225.55,137.34) ; U1.F22 209.55,111.34 v1(209.6,111.34) ; U1.AW59 v1(171.55,145.34) ; v1(230.55,151.39) 230.55,151.34 U1.BE1 ; U1.V39 v1(191.55,123.34) ; U1.BV64 166.59,164.3 166.55,164.3 166.55,164.29 v1(166.56,164.29) ; v1(177.55,170.37) 177.55,170.34 U1.CD53 ; v1(171.52,151.29) 171.55,151.29 172,150.84 U1.BE59 ; U1.AD20 v1(211.55,129.34) ; U1.AU55 175.55,143.34 v1(175.52,143.34) ; U1.A36 v1(194.55,106.34) ; v1(228.58,143.39) 228.58,143.37 U1.AU3 ; U1.P18 v1(213.55,119.34) ; U1.AL52 v1(178.55,136.34) ; U1.BA7 v1(224.55,147.34) ; U1.AW61 170,144.84 v1(169.55,144.39) 169.55,144.34 U1.AV61 ; U1.C28 203.55,108.34 v1(203.6,108.34) ; U1.N7 v1(224.55,118.34) ; U1.BB58 172.55,148.34 v1(172.52,148.32) ; v1(228.56,172.34) 228.55,172.34 U1.CF3 ; U1.E56 174.57,110.37 v1(174.52,110.37) ; U1.AP20 v1(211.55,140.34) ; v1(184.55,167.29) 185,166.84 U1.CA46 ; U1.BP34 v1(196.55,160.34) ; U1.BR35 v1(195.55,161.34) ; v1(167.52,158.29) 167.6,158.29 U1.BM63 ; U1.W44 v1(186.55,124.34) ; U1.D41 189.52,109.32 v1(189.5,109.32) ; v1(227.55,165.39) 227.55,165.34 U1.BW4 ; v1(221.58,153.34) 221.55,153.34 U1.BG10 ; v1(171.52,130.34) 171.55,130.34 U1.AE59 ; U1.BH24 v1(207.55,154.34) ; U1.W48 v1(182.55,124.34) ; U1.BC6 225.55,149.34 v1(225.55,149.39) ; U1.R59 v1(171.55,120.34) ; U1.J3 228.5,114.39 v1(228.58,114.39) ; U1.E3 228.55,110.34 v1(228.58,110.34) ; U1.CC30 v1(201.55,169.34) ; v1(169.55,146.29) 169.55,146.34 U1.AY61 ; v1(185.52,113.34) 185.55,113.34 U1.H45 ; U1.BP64 166.55,160.34 v1(166.55,160.29) ; v1(225.58,142.34) 225.55,142.34 U1.AT6 ; U1.BP40 190.55,160.34 v1(190.55,160.37) ; U1.B2 229.55,107.34 v1(229.58,107.34) ; U1.AD14 v1(217.55,129.34) ; v1(228.58,134.34) 228.55,134.34 U1.AJ3 ; U1.BM39 v1(191.55,158.34) ; U1.AY16 v1(215.55,146.34) ; U1.Y35 v1(195.55,125.34) ; U1.M18 v1(213.55,117.34) ; v1(175.52,117.34) 175.55,117.34 U1.M55 ; U1.BJ51 v1(179.55,155.34) ; U1.CD52 v1(178.55,170.34) ; U1.W53 v1(177.55,124.34) ; U1.BH4 227.1,153.84 227.55,154.29 v1(227.58,154.29) ; U1.M14 v1(217.55,117.34) ; v1(221.55,118.34) 221.22,118.67 U1.N10 ; U1.AJ64 167,134.84 v1(166.55,134.39) ; U1.Y19 v1(212.55,125.34) ; U1.W57 v1(173.55,124.34) ; U1.AA55 175.55,126.34 v1(175.55,126.29) ; U1.AH6 v1(225.55,133.34) ; U1.M61 v1(169.55,117.34) ; v1(176.52,134.34) 176.55,134.34 U1.AJ54 ; U1.J27 204.55,114.34 v1(204.55,114.31) ; U1.BW46 v1(184.55,165.34) ; v1(219.58,129.34) 219.55,129.34 U1.AD12 ; U1.AR61 169.55,141.34 169.55,141.37 v1(169.52,141.39) ; U1.P43 v1(187.55,119.34) ; U1.BV40 190.55,164.34 v1(190.57,164.37) ; U1.AF50 v1(180.55,131.34) ; U1.AU12 v1(219.55,143.34) ; U1.CB14 217.55,168.34 v1(217.55,168.37) ; U1.AN19 v1(212.55,138.34) ; U1.P50 v1(180.55,119.34) ; v1(169.57,153.34) 169.55,153.34 U1.BG61 ; U1.AG55 175.55,132.34 v1(175.52,132.34) ; U1.BA11 220.55,147.34 v1(220.56,147.34) ; v1(221.56,159.34) 221.55,159.34 U1.BN10 ; v1(227.58,108.34) 227.55,108.34 U1.C4 ; v1(228.55,123.29) 228.55,123.34 U1.V3 ; U1.BB13 218.55,148.34 v1(218.56,148.34) ; U1.BF57 173.55,152.34 v1(173.55,152.32) ; v1(172.55,123.32) 172.55,123.34 U1.V58 ; U1.BR26 v1(205.55,161.34) ; U1.A49 v1(181.55,106.34) ; U1.A60 171.05,106.79 v1(170.61,106.35) ; v1(173.55,160.32) 173.55,160.34 U1.BP57 ; U1.A16 215.55,106.34 v1(215.6,106.34) ; U1.W46 v1(184.55,124.34) ; v1(169.6,165.34) 169.6,165.29 U1.BW61 ; v1(198.69,172.46) 198.69,172.2 U1.CF32 ; v1(228.58,151.39) 228.56,151.39 228.55,151.39 228.55,151.34 U1.BE3 ; U1.AV17 v1(214.55,144.34) ; U1.L50 v1(180.55,116.34) ; U1.BL28 v1(203.55,157.34) U1.BM27 ; U1.H61 169.55,113.34 v1(169.55,113.29) ; U1.BU11 v1(220.55,163.34) ; v1(221.58,160.34) 221.55,160.34 U1.BP10 ; v1(227.58,124.39) 227.5,124.39 U1.W4 ; v1(227.55,116.39) 227.55,116.34 U1.L4 ; U1.BY11 220.55,166.34 v1(220.55,166.37) ; U1.BU29 v1(202.55,163.34) ; U1.B15 v1(216.55,107.34) ; U1.CB53 v1(177.55,168.34) ; U1.AJ51 v1(179.55,134.34) ; v1(175.52,125.34) 175.55,125.34 U1.Y55 ; U1.B56 v1(174.55,107.34) ; U1.L61 169.55,116.34 v1(169.57,116.34) ; U1.BH6 225.55,154.34 v1(225.58,154.34) ; U1.R57 v1(173.55,120.34) ; U1.H24 v1(207.55,113.34) ; U1.R53 v1(177.55,120.34) ; U1.F18 v1(213.55,111.34) ; v1(190.57,162.37) 190.57,162.32 U1.BT40 ; U1.AR57 173.52,141.37 v1(173.52,141.39) ; U1.AK64 166.52,135.32 v1(166.52,135.29) ; U1.BL10 221.52,157.32 v1(221.58,157.32) ; U1.Y17 v1(214.55,125.34) ; v1(170.55,111.34) 170.55,111.36 ; 170.55,111.36 171.03,111.84 U1.F60 ; 170.55,111.36 171.05,110.86 U1.E60 ; U1.CA25 206.55,167.34 v1(206.55,167.31) ; U1.CA3 228.55,167.34 v1(228.58,167.34) ; U1.CC29 v1(202.55,169.34) ; U1.AC4 227.5,128.39 v1(227.55,128.39) ; v1(212.55,117.31) 212.55,117.34 U1.M19 ; U1.K59 171.55,115.34 171.55,115.34 v1(171.52,115.32) ; U1.BW16 215.55,165.34 v1(215.55,165.37) ; v1(217.51,136.35) 217.05,136.82 U1.AL14 ; v1(195.55,170.37) 195.55,170.34 U1.CD35 ; U1.BH28 v1(203.55,154.34) ; U1.BJ49 v1(181.55,154.34) U1.BH49 ; v1(166.56,163.37) 166.56,163.36 166.56,163.33 U1.BU64 ; U1.E51 v1(179.55,110.34) ; U1.J55 175.55,114.34 v1(175.5,114.34) ; U1.P23 v1(208.55,119.34) ; U1.BR20 211.55,161.34 v1(211.55,161.37) ; v1(223.58,157.34) 223.55,157.34 U1.BL8 ; U1.U1 v1(230.55,122.34) ; U1.M23 v1(208.55,117.34) ; U1.BF14 v1(217.55,152.34) ; U1.BL63 167.55,157.34 v1(167.55,157.39) ; v1(204.55,118.31) 204.55,118.34 U1.N27 ; U1.K50 180.55,115.34 v1(180.55,115.32) ; v1(230.56,144.33) 230.54,144.33 U1.AV1 ; U1.CA32 v1(199.55,167.34) ; U1.AJ60 170.57,134.37 v1(170.52,134.37) ; U1.CA49 181.55,167.34 181.52,167.34 181.5,167.37 v1(181.5,167.37) ; v1(192.55,166.34) U1.BY38 ; U1.BR24 207.55,161.34 v1(207.55,161.35) ; U1.H23 v1(208.55,113.34) ; v1(167.55,170.32) 167.55,170.34 U1.CD63 ; U1.AF59 171.6,131.39 v1(171.52,131.39) ; U1.BN38 v1(193.55,158.34) ; U1.BL24 v1(207.55,157.34) ; U1.AD63 v1(167.55,129.34) ; 169.55,121.34 v1(169.55,121.29) ; 169.55,121.34 U1.R61 ; 169.55,121.34 U1.T61 ; v1(214.5,109.31) 214.5,109.39 U1.D17 ; U1.BC16 v1(215.55,149.34) ; v1(187.55,117.32) 187.55,117.34 U1.M43 ; U1.AN53 v1(177.55,138.34) ; U1.BL40 v1(190.55,157.34) ; v1(170.6,168.32) 170.57,168.32 U1.CB60 ; U1.BU13 218.52,163.32 v1(218.58,163.32) ; v1(219.55,133.34) U1.AH12 ; U1.BF8 v1(223.55,152.34) ; U1.AU10 v1(221.55,143.34) ; v1(225.52,145.34) 225.55,145.34 U1.AW6 ; U1.C24 v1(207.55,108.34) ; U1.Y14 v1(217.55,125.34) ; U1.CD56 174.55,170.34 v1(174.55,170.37) ; U1.BG6 225.55,153.34 v1(225.55,153.39) ; v1(171.55,168.29) 171.6,168.29 U1.CB59 ; U1.BN53 v1(177.55,159.34) ; U1.BR55 v1(175.55,161.34) ; 70.5,182.34 70.5,182.34 D440.4 ; v1(164.52,155.37) 164.55,155.37 164.55,155.34 U1.BJ66 ; U1.BH19 v1(212.55,154.34) ; U1.BP50 v1(180.55,160.34) ; U1.BN25 206.05,158.84 v1(205.55,159.34) U1.BN26 ; U1.L55 175.55,116.34 v1(175.5,116.34) ; U1.BL51 v1(179.55,157.34) ; U1.BG17 v1(214.55,153.34) U1.BH17 ; U1.G63 167.57,112.37 v1(167.52,112.37) ; U1.AH17 v1(214.55,133.34) ; U1.AT53 v1(177.55,142.34) ; U1.G29 202.5,112.39 v1(202.5,112.32) ; U1.K30 201.55,115.34 v1(201.55,115.31) ; v1(175.51,155.37) 175.54,155.37 175.56,155.35 175.55,155.34 U1.BJ55 ; D446.29 v1(348.49,173.77) ; U1.AP48 v1(182.55,140.34) ; U1.AR4 227.55,141.34 v1(227.55,141.39) ; U1.M53 v1(177.55,117.34) ; U1.BW36 194.55,165.34 v1(194.5,165.34) ; v1(201.55,113.31) 201.55,113.34 U1.H30 ; U1.L10 221.55,116.34 v1(221.58,116.34) ; U1.E58 172.55,110.34 v1(172.55,110.37) ; U1.AN3 228.1,138.84 v1(228.55,138.39) ; U1.BE50 v1(180.55,151.34) ; v1(167.52,125.29) 167.52,125.32 U1.Y63 ; U1.L63 167.55,116.34 v1(167.52,116.34) ; U1.BN55 175.55,159.34 v1(175.52,159.34) ; U1.K61 169.55,115.34 v1(169.55,115.32) ; v1(190.57,112.32) 190.57,112.37 U1.G40 ; v1(180.55,117.32) 180.55,117.34 U1.M50 ; U1.U56 174.57,122.37 v1(174.52,122.37) ; U1.AR63 167.55,141.34 v1(167.55,141.39) ; v1(166.52,114.39) 166.55,114.39 167,114.84 U1.J64 ; v1(203.55,162.37) 203.55,162.34 U1.BT28 ; U1.BR22 v1(209.55,161.34) ; U1.M30 v1(201.55,117.34) ; U1.M17 v1(214.55,117.34) ; U1.CD13 v1(218.55,170.34) ; v1(170.55,163.39) 170.55,163.34 U1.BU60 ; U1.AG17 v1(214.55,132.34) ; U1.W63 v1(167.55,124.34) ; U1.W28 v1(203.55,124.34) ; v1(228.58,159.34) 228.55,159.34 U1.BN3 ; U1.AK3 228.55,135.34 v1(228.55,135.29) ; U1.AB8 v1(223.55,127.34) ; U1.AF57 174,131.84 173.55,131.39 v1(173.52,131.39) ; U1.BR25 206.55,161.34 v1(206.55,161.37) ; v1(175.51,130.34) 175.52,130.33 175.54,130.33 U1.AE55 ; U1.AM17 v1(214.55,137.34) ; U1.CF31 v1(200.55,172.34) ; U1.BJ17 v1(214.55,154.34) U1.BJ16 ; v1(202.55,166.34) 202.55,166.34 U1.BY29 ; v1(224.55,136.39) 224.1,136.84 U1.AL7 ; U1.AR50 v1(180.55,141.34) ; U1.AL16 v1(215.55,136.34) ; U1.BG37 v1(193.55,153.34) ; U1.A53 v1(177.55,106.34) ; v1(193.55,165.37) 193.55,165.34 U1.BW37 ; v1(169.55,119.39) 169.55,119.34 U1.P61 ; U1.AN64 167,138.84 166.55,138.39 v1(166.55,138.37) ; U1.G39 v1(191.55,112.34) ; U1.BH8 v1(223.55,154.34) ; U1.U13 218.55,122.34 v1(218.58,122.34) ; U1.R4 227.55,120.34 v1(227.58,120.34) ; U1.BC17 v1(214.55,149.34) ; U1.BF64 167,151.84 166.55,152.29 v1(166.52,152.29) ; U1.K48 v1(182.55,115.34) ; U1.BD48 v1(182.55,150.34) ; U1.AD17 v1(214.55,129.34) ; U1.BT31 v1(200.55,162.34) ; U1.AK58 v1(172.52,135.32) ; U1.K26 v1(205.55,115.34) ; U1.BM38 v1(192.55,158.34) ; U1.BD57 v1(173.55,150.34) ; U1.BH18 v1(213.55,154.34) ; U1.CB8 223.55,168.34 v1(223.55,168.39) ; U1.CD7 224.55,170.34 v1(224.55,170.39) ; U1.C11 v1(220.55,108.34) ; U1.P29 v1(202.55,119.34) ; v1(180.6,169.37) 180.6,169.29 U1.CC50 ; U1.BV60 170.55,164.34 v1(170.55,164.32) ; v1(169.56,155.37) 169.56,155.35 169.55,155.34 U1.BJ61 ; U1.D37 193.55,109.34 v1(193.55,109.32) ; v1(170.55,148.32) 170.55,148.34 U1.BB60 ; v1(187.5,108.32) 187.52,108.32 U1.C43 ; U1.BU25 v1(206.55,163.34) ; U1.G16 215.22,112.67 v1(215.55,112.34) ; U1.AU47 v1(183.55,143.34) ; U1.AV52 v1(178.55,144.34) ; U1.BK35 v1(195.55,156.34) ; U1.T29 v1(202.55,121.34) ; U1.AL63 v1(167.55,136.34) ; U1.BL53 v1(177.55,157.34) ; v1(221.56,144.34) 221.55,144.34 U1.AV10 ; v1(169.57,128.34) 169.55,128.34 U1.AC61 ; v1(230.55,111.29) 230.55,111.34 U1.F1 ; U1.AH57 v1(173.55,133.34) ; v1(227.58,166.29) 227.5,166.29 U1.BY4 ; v1(170.55,170.32) 170.55,170.34 U1.CD60 ; U1.AR15 v1(216.55,141.34) ; U1.AW12 219.55,145.34 v1(219.56,145.34) ; U1.BC10 221.55,149.34 221.56,149.34 v1(221.58,149.37) ; v1(208.55,172.37) 208.55,172.34 U1.CF23 ; U1.AG63 168,132.84 v1(167.55,132.39) ; U1.AC47 v1(183.55,128.34) ; U1.D22 209.58,109.31 v1(209.6,109.31) ; U1.Y53 v1(177.55,125.34) ; U1.AK66 164.55,135.34 v1(164.55,135.29) ; U1.BE64 166.55,151.34 v1(166.55,151.39) ; U1.BM29 v1(202.55,158.34) ; U1.BL30 v1(201.55,157.34) ; U1.CC34 v1(197.55,169.34) ; U1.AC14 v1(217.55,128.34) ; U1.H33 v1(198.55,113.34) ; U1.C63 167.55,108.34 v1(167.52,108.34) ; U1.CA30 v1(201.55,167.34) ; U1.AH7 v1(224.55,133.34) ; v1(175.55,160.32) 175.55,160.34 U1.BP55 ; U1.BA47 v1(183.55,147.34) ; U1.BN42 189.05,158.84 v1(189.55,159.34) U1.BN41 ; U1.K53 v1(177.55,115.34) ; v1(210.5,165.38) 210.05,164.93 U1.BW21 ; U1.BT7 v1(224.55,162.34) ; D444.4 345.59,154.61 345.6,154.61 ; v1(167.55,162.29) 167.55,162.34 U1.BT63 ; v1(176.57,107.34) 176.55,107.34 U1.B54 ; v1(167.52,153.34) 167.55,153.34 U1.BG63 ; v1(184.55,163.37) 184.55,163.34 U1.BU46 ; U1.C54 176.55,108.34 v1(176.57,108.34) ; v1(225.58,117.34) 225.55,117.34 U1.M6 ; U1.P22 v1(209.55,119.34) ; U1.AF66 v1(164.55,131.34) ; U1.W41 v1(189.55,124.34) ; U1.BR17 214.55,161.34 v1(214.55,161.37) ; U1.BJ14 v1(217.55,155.34) ; U1.H46 184.55,113.34 v1(184.57,113.32) ; v1(181.5,172.34) 181.55,172.34 U1.CF49 ; U1.AU50 v1(180.55,143.34) ; U1.Y50 v1(180.55,125.34) ; U1.BR10 v1(221.55,161.34) ; U1.BY58 v1(172.55,166.34) ; v1(166.55,122.39) 166.55,122.34 U1.U64 ; U1.BT56 v1(174.55,162.34) ; U1.N3 v1(228.55,119.34) U1.P3 ; U1.AE47 v1(183.55,130.34) ; U1.Y10 221.55,125.34 v1(221.58,125.34) ; U1.K49 181.55,115.34 v1(181.55,115.32) ; U1.B52 v1(178.55,107.34) ; U1.BY63 167.55,166.34 v1(167.52,166.34) ; U1.N40 v1(190.55,118.34) ; D441.4 345.59,134.29 345.6,134.29 ; U1.BB7 224.55,148.34 v1(224.58,148.34) ; v1(186.62,106.32) 186.62,106.42 U1.A44 ; U1.AF19 v1(212.55,131.34) ; v1(207.55,115.32) 207.55,115.34 U1.K24 ; U1.M44 v1(186.55,117.34) ; v1(175.52,156.34) 175.55,156.34 U1.BK55 ; U1.D57 v1(173.55,109.34) ; U1.AJ13 218.55,134.34 v1(218.58,134.34) ; U1.AV14 v1(217.55,144.34) ; U1.BR16 215.53,161.32 v1(215.53,161.37) ; v1(169.55,160.32) 169.55,160.34 U1.BP61 ; v1(210.55,161.37) 210.55,161.34 U1.BR21 ; U1.BN32 v1(199.55,159.34) ; U1.AY51 v1(179.55,146.34) ; v1(230.58,152.29) 230.55,152.29 230.1,151.84 U1.BF1 ; U1.BM10 v1(221.55,158.34) ; U1.W39 v1(191.55,124.34) ; U1.N1 230.55,118.34 230.55,118.39 230.56,118.39 v1(230.58,118.39) ; U1.G53 v1(177.55,112.34) ; U1.AV15 v1(216.55,144.34) ; v1(164.55,148.29) 165,147.84 U1.BB66 ; D437.29 v1(67.66,153.01) ; 345.59,185.09 D445.4 ; U1.A40 191.05,106.77 v1(190.6,106.32) ; U1.T53 v1(177.55,121.34) ; U1.V52 v1(178.55,123.34) ; U1.M25 v1(206.55,117.34) ; v1(212.5,108.31) 212.5,108.39 U1.C19 ; U1.CA35 v1(195.55,167.34) ; U1.AJ19 v1(212.55,134.34) ; U1.BJ57 173.55,155.34 173.56,155.35 v1(173.56,155.37) ; v1(223.58,120.34) 223.55,120.34 223.22,120.67 U1.R8 ; v1(228.58,126.37) 228.52,126.37 U1.AA3 ; U1.AN49 v1(181.55,138.34) ; v1(170.6,109.34) 170.6,109.39 U1.D60 ; U1.N53 v1(177.55,118.34) ; v1(167.52,150.29) 167.55,150.32 167.55,150.34 U1.BD63 ; v1(184.6,109.32) 184.6,109.39 U1.D46 ; U1.CD54 v1(176.55,170.34) ; v1(221.58,136.34) 221.55,136.34 U1.AL10 ; U1.D53 v1(177.55,109.34) ; U1.BU19 v1(212.55,163.34) ; v1(220.58,135.34) 220.55,135.34 U1.AK11 ; U1.N6 225.55,118.34 225.55,118.39 225.56,118.39 v1(225.58,118.39) ; U1.BG4 227.55,153.34 v1(227.55,153.39) ; U1.R6 225.55,120.34 v1(225.52,120.34) ; v1(170.56,112.37) 170.56,112.35 U1.G60 ; U1.BY6 v1(225.55,166.34) ; U1.BR59 v1(171.55,161.34) ; v1(213.55,163.31) 213.52,163.31 U1.BU18 ; U1.T55 v1(175.55,121.34) ; U1.D50 180.55,109.34 v1(180.55,109.32) ; v1(181.6,163.37) 181.6,163.29 U1.BU49 ; U1.AD19 v1(212.55,129.34) ; U1.V44 v1(186.55,123.34) ; U1.BT58 v1(172.55,162.34) ; U1.BE53 v1(177.55,151.34) ; v1(217.55,166.37) 217.55,166.34 U1.BY14 ; U1.BR61 v1(169.55,161.34) ; U1.BA56 v1(174.52,147.37) ; U1.F23 208.05,111.79 208.5,111.34 v1(208.5,111.31) ; v1(164.52,143.34) 164.55,143.34 U1.AU66 ; v1(170.55,169.37) 170.55,169.34 U1.CC60 ; U1.AV48 v1(182.55,144.34) ; v1(215.55,169.34) U1.CC16 ; U1.K6 v1(225.55,115.34) ; U1.BD19 v1(212.55,150.34) ; U1.M47 v1(183.55,117.34) ; U1.R29 v1(202.55,120.34) ; U1.BW18 213.55,165.34 v1(213.55,165.37) ; U1.A48 182.55,106.34 v1(182.57,106.32) ; U1.BK28 v1(203.55,156.34) ; v1(228.58,155.39) 228.56,155.39 228.55,155.39 228.55,155.34 U1.BJ3 ; U1.AR10 221.55,141.34 v1(221.58,141.34) ; U1.F64 166.55,111.34 v1(166.55,111.29) ; U1.BB64 167,147.84 166.55,148.29 v1(166.52,148.29) ; U1.BT39 v1(191.55,162.34) ; U1.BF3 228.1,151.84 v1(228.55,152.29) ; U1.AL57 v1(173.55,136.34) ; U1.V60 170.55,123.34 v1(170.55,123.32) ; U1.BD20 v1(211.55,150.34) ; U1.AT59 171.55,142.34 v1(171.55,142.32) ; U1.BR43 188.05,160.87 v1(187.55,161.37) ; v1(173.52,142.32) 173.57,142.32 U1.AT57 ; U1.Y32 v1(199.55,125.34) ; U1.A19 212.55,106.34 v1(212.5,106.34) ; v1(199.55,164.34) U1.BV32 ; U1.C9 v1(222.55,108.34) ; v1(188.55,113.32) 188.55,113.34 U1.H42 ; U1.H63 167.55,113.34 v1(167.55,113.27) ; v1(175.52,140.34) 175.55,140.34 U1.AP55 ; v1(230.58,110.34) 230.55,110.34 U1.E1 ; U1.D6 v1(225.55,109.34) ; v1(175.52,137.34) 175.55,137.34 U1.AM55 ; U1.BP35 v1(195.55,160.34) ; U1.E16 215.55,110.34 v1(215.6,110.34) ; U1.AH55 v1(175.55,133.34) ; U1.AJ9 222.55,134.34 v1(222.58,134.34) ; U1.BN35 v1(195.55,159.34) ; v1(175.52,127.34) 175.55,127.34 U1.AB55 ; U1.V56 174.55,123.34 v1(174.55,123.32) ; v1(174.52,163.29) 174.6,163.29 U1.BU56 ; U1.BW51 v1(179.55,165.34) ; v1(205.55,167.33) 205.55,167.34 U1.CA26 ; v1(193.5,169.37) 193.52,169.34 193.55,169.34 U1.CC37 ; U1.M12 219.55,117.34 v1(219.58,117.34) ; v1(190.57,166.37) 190.57,166.32 U1.BY40 ; v1(208.5,106.31) 208.5,106.39 U1.A23 ; U1.BU9 222.55,163.34 v1(222.58,163.34) ; U1.AY60 v1(170.55,146.34) ; v1(169.55,126.3) 169.55,126.34 U1.AA61 ; U1.V26 v1(205.55,123.34) ; U1.AV66 v1(164.55,144.34) ; v1(218.55,166.37) 218.55,166.34 U1.BY13 ; U1.D51 v1(179.55,109.34) ; U1.R14 v1(217.55,120.34) ; U1.BW45 v1(185.55,165.34) ; U1.AW4 227.55,145.34 v1(227.58,145.34) ; U1.BP66 164.55,160.34 v1(164.55,160.29) ; v1(164.55,168.29) 164.55,168.34 U1.CB66 ; v1(169.55,152.32) 169.55,152.34 U1.BF61 ; v1(218.56,147.34) 218.55,147.34 U1.BA13 ; U1.F41 189.55,111.34 v1(189.5,111.34) ; v1(214.55,115.31) 214.55,115.34 U1.K17 ; U1.BU15 v1(216.55,163.34) ; U1.M59 v1(171.55,117.34) ; U1.BY59 v1(171.55,166.34) ; v1(210.55,167.28) 210.55,167.31 210.08,166.84 U1.CA21 ; U1.AE6 225.5,130.39 v1(225.58,130.39) ; U1.BG53 v1(177.55,153.34) ; U1.G6 225.5,112.39 v1(225.55,112.39) ; v1(204.55,162.37) 204.55,162.34 U1.BT27 ; U1.BK1 v1(230.55,156.34) ; U1.P30 v1(201.55,119.34) ; U1.BW29 v1(202.55,165.34) ; U1.F35 195.55,111.34 v1(195.55,111.32) ; v1(171.52,153.34) 171.55,153.34 U1.BG59 ; v1(202.5,109.31) 202.5,109.39 U1.D29 ; U1.R27 v1(204.55,120.34) ; U1.BY26 v1(205.55,166.34) ; U1.AW47 v1(183.55,145.34) ; v1(170.55,135.32) 170.55,135.34 U1.AK60 ; U1.BD53 v1(177.55,150.34) ; U1.BG12 v1(219.55,153.34) ; U1.CA45 v1(185.55,167.34) ; U1.AH10 v1(221.55,133.34) ; U1.BK12 219.55,156.34 v1(219.58,156.34) ; 70.5,172.18 D439.4 ; v1(217.51,138.35) 217.05,138.82 U1.AN14 ; U1.BR63 167.55,161.34 v1(167.52,161.34) ; v1(215.55,117.34) U1.M16 ; U1.AA6 v1(225.55,126.34) ; U1.AY20 v1(211.55,146.34) ; U1.T7 224.22,121.67 v1(224.55,121.34) ; v1(228.55,115.29) 228.55,115.34 U1.K3 ; U1.BN15 v1(216.55,159.34) ; U1.B9 222.55,107.34 v1(222.52,107.34) ; U1.F21 210.55,111.34 v1(210.55,111.31) ; U1.BK37 v1(193.55,156.34) ; U1.U66 164.63,122.42 v1(164.52,122.42) ; U1.BU42 v1(188.55,163.34) ; v1(189.53,115.32) 189.52,115.32 U1.K41 ; v1(225.58,131.34) 225.55,131.34 U1.AF6 ; v1(173.56,112.37) 173.57,112.37 U1.G57 ; U1.BL31 v1(200.55,157.34) ; U1.M35 v1(195.55,117.34) ; v1(175.5,115.34) 175.55,115.34 U1.K55 ; v1(173.55,115.31) 173.55,115.34 U1.K57 ; U1.E54 176.55,110.34 v1(176.52,110.34) ; U1.BC4 227.55,149.34 227.55,149.39 227.56,149.39 v1(227.58,149.39) ; U1.P10 221.55,119.34 v1(221.57,119.34) ; v1(164.55,152.32) 164.55,152.34 U1.BF66 ; v1(225.52,157.34) 225.55,157.34 U1.BL6 ; U1.AT50 v1(180.55,142.34) ; U1.CC51 v1(179.55,169.34) ; v1(214.5,112.34) 214.55,112.34 U1.G17 ; U1.CA38 v1(192.55,167.34) ; U1.P53 v1(177.55,119.34) ; U1.AA12 219.55,126.34 v1(219.58,126.34) ; U1.F47 v1(183.55,111.34) ; U1.A39 v1(191.55,106.34) ; v1(182.6,170.37) 182.57,170.34 182.55,170.34 U1.CD48 ; v1(227.58,142.29) 227.55,142.29 227.1,141.84 U1.AT4 ; v1(173.52,144.39) 173.52,144.37 U1.AV57 ; v1(180.55,161.37) 180.55,161.34 U1.BR50 ; U1.CD32 v1(198.55,169.34) U1.CC33 ; 70.5,162.02 D438.4 ; v1(207.55,163.37) 207.55,163.34 U1.BU24 ; U1.CA34 v1(197.55,166.34) ; U1.AU53 v1(177.55,143.34) ; U1.AR55 175.55,141.34 v1(175.52,141.34) ; U1.Y61 169.55,125.34 v1(169.55,125.3) ; U1.AM8 223.55,137.34 v1(223.58,137.34) ; U1.M57 v1(173.55,117.34) ; v1(220.56,123.34) 220.55,123.34 U1.V11 ; U1.BM40 v1(190.55,158.34) ; U1.V66 164.55,123.34 v1(164.55,123.29) ; U1.BN46 v1(184.55,159.34) 184.05,158.84 U1.BN47 ; U1.BW35 v1(195.55,165.34) ; U1.BY35 v1(195.55,166.34) ; v1(175.52,118.34) 175.55,118.34 U1.N55 ; v1(173.52,154.34) 173.55,154.34 U1.BH57 ; v1(224.58,111.34) 224.55,111.34 U1.F7 ; U1.H44 v1(186.55,113.34) ; U1.H20 v1(211.55,113.34) ; U1.M42 v1(188.55,117.34) ; U1.K21 210.55,115.34 v1(210.55,115.31) ; U1.H57 v1(173.55,113.34) ; v1(211.6,170.34) 211.55,170.34 U1.CD20 ; U1.BU43 187.55,163.34 v1(187.55,163.37) ; U1.G50 v1(180.55,112.34) ; v1(193.55,161.37) 193.55,161.34 U1.BR37 ; v1(228.58,122.34) 228.55,122.34 U1.U3 ; v1(220.57,110.34) 220.55,110.34 U1.E11 ; U1.A55 v1(175.55,106.34) ; v1(199.55,111.34) U1.F32 ; U1.BN29 v1(202.55,159.34) ; U1.BJ50 v1(180.55,154.34) U1.BH50 ; v1(222.55,168.35) 222.55,168.34 U1.CB9 ; U1.AY19 v1(212.55,146.34) ; U1.BN57 v1(173.52,159.37) ; U1.BY33 v1(198.55,166.34) ; U1.AF16 v1(215.55,131.34) ; U1.BV59 171.55,164.34 v1(171.55,164.32) ; v1(190.62,172.37) 190.62,172.27 U1.CF40 ; U1.AY7 v1(224.55,146.34) ; U1.CD43 187.55,170.34 v1(187.52,170.34) ; U1.BN21 v1(210.55,159.34) 211.05,158.84 U1.BN20 ; U1.AK20 v1(211.55,135.34) ; U1.BL12 219.55,157.34 v1(219.56,157.34) ; U1.P17 v1(214.55,119.34) ; U1.BE14 v1(217.55,151.34) ; U1.BJ15 v1(216.55,155.34) ; U1.L53 v1(177.55,116.34) ; v1(175.52,124.34) 175.55,124.34 U1.W55 ; U1.H55 175.55,113.34 v1(175.5,113.34) ; U1.AW16 v1(215.55,145.34) ; U1.AP64 v1(166.55,140.34) ; U1.CD4 227.55,170.34 v1(227.52,170.34) ; U1.G52 178.55,112.34 v1(178.52,112.34) ; U1.BM53 v1(177.55,158.34) ; U1.W52 v1(178.55,124.34) ; v1(173.55,126.29) 173.55,126.34 U1.AA57 ; U1.CD27 204.55,170.34 v1(204.55,170.37) ; U1.D42 v1(188.55,109.34) ; U1.K29 202.55,115.34 v1(202.55,115.31) ; U1.AN18 v1(213.55,138.34) ; U1.BH43 v1(187.55,154.34) ; U1.CA51 v1(179.55,167.34) ; U1.AC6 225.55,128.34 v1(225.55,128.39) ; U1.BK27 v1(204.55,156.34) ; U1.BA15 v1(216.55,147.34) ; U1.M31 200.55,117.34 v1(200.55,117.31) ; U1.F11 220.55,111.34 v1(220.58,111.34) ; U1.CC46 184.55,169.34 v1(184.57,169.34) ; U1.BL59 v1(171.55,157.34) ; U1.BU20 v1(211.55,163.34) ; v1(194.6,172.34) 195.05,171.89 U1.CF36 ; U1.J28 v1(203.55,114.34) ; v1(182.55,108.32) 182.55,108.34 U1.C48 ; U1.L27 v1(204.55,116.34) ; U1.U15 v1(216.55,122.34) ; v1(175.52,128.34) 175.55,128.34 U1.AC55 ; U1.M24 207.55,117.34 v1(207.55,117.31) ; U1.T41 v1(189.55,121.34) ; U1.CA31 v1(200.55,167.34) ; U1.CA42 v1(189.55,166.34) U1.BY41 ; v1(164.55,138.37) 164.55,138.39 165,138.84 U1.AN66 ; U1.CC49 181.55,169.34 v1(181.5,169.34) ; v1(172.55,134.37) 172.55,134.34 U1.AJ58 ; U1.AR6 225.55,141.34 v1(225.55,141.39) ; U1.AE1 230.13,130.84 230.57,130.39 v1(230.58,130.39) ; v1(222.58,122.34) 222.55,122.34 U1.U9 ; U1.T35 v1(195.55,121.34) ; U1.BK66 v1(164.55,156.34) ; U1.BP29 v1(202.55,160.34) ; 70.5,131.54 D435.4 ; U1.W26 v1(205.55,124.34) ; U1.C31 200.52,108.37 v1(200.52,108.31) ; v1(165.52,107.32) U1.B65 ; U1.BP33 v1(198.55,160.34) ; U1.BR41 v1(189.55,161.34) ; v1(207.55,165.37) 207.55,165.34 U1.BW24 ; U1.AT12 219.55,142.34 v1(219.58,142.34) ; U1.BH27 v1(204.55,154.34) 205.05,153.84 U1.BH26 ; v1(209.55,117.31) 209.55,117.34 U1.M22 ; U1.Y49 v1(181.55,125.34) ; v1(227.58,117.29) 227.58,117.31 U1.M4 ; U1.AP8 v1(223.55,140.34) ; v1(222.58,147.34) 222.55,147.34 U1.BA9 ; U1.F54 v1(176.55,111.34) ; v1(169.6,166.34) 169.55,166.34 U1.BY61 ; v1(189.5,112.34) 189.55,112.34 U1.G41 ; U1.P48 v1(182.55,119.34) ; U1.AK13 v1(218.55,135.34) ; U1.BL61 170.01,156.84 v1(169.55,156.38) 169.55,156.34 U1.BK61 ; U1.BT15 v1(216.55,162.34) ; U1.D30 v1(201.55,109.34) ; U1.P46 v1(184.55,119.34) ; U1.AD52 v1(178.55,129.34) ; v1(211.6,172.37) 211.58,172.37 U1.CF20 ; U1.BD59 v1(171.55,150.34) ; U1.CC61 169.55,169.34 v1(169.57,169.37) ; v1(206.55,111.37) 206.55,111.34 U1.F25 ; U1.BC47 v1(183.55,149.34) ; U1.A9 222.55,106.34 v1(222.52,106.34) ; U1.L8 223.07,116.84 223.57,116.34 v1(223.58,116.34) ; v1(227.58,161.34) 227.55,161.34 U1.BR4 ; U1.AL55 175.55,136.34 v1(175.52,136.37) ; v1(164.55,164.29) 164.55,164.34 U1.BV66 ; U1.AC57 173.55,128.34 v1(173.52,128.34) ; U1.BP8 v1(223.55,160.34) ; v1(189.5,169.34) 189.55,169.34 U1.CC41 ; U1.G27 v1(204.55,112.34) ; U1.P6 225.55,119.34 v1(225.58,119.34) ; U1.BW22 v1(209.55,165.34) ; U1.F48 v1(182.55,111.34) ; U1.BT6 225.1,161.84 v1(225.55,162.29) ; U1.W40 v1(190.55,124.34) ; U1.BJ64 166.55,155.34 v1(166.55,155.37) ; U1.BJ6 225.55,155.34 225.55,155.39 225.56,155.39 v1(225.58,155.39) ; U1.BN14 v1(217.55,159.34) ; v1(167.52,137.29) 167.52,137.32 U1.AM63 ; v1(221.58,150.34) 221.55,150.34 U1.BD10 ; U1.V38 v1(192.55,123.34) ; v1(214.5,113.31) 214.5,113.39 U1.H17 ; U1.CD24 v1(207.55,170.34) ; U1.CB13 v1(218.55,168.34) ; U1.BV55 v1(175.55,164.34) ; v1(169.55,151.29) 170,150.84 U1.BE61 ; v1(186.6,108.34) 186.55,108.34 U1.C44 ; U1.BC53 v1(177.55,149.34) ; U1.AD59 v1(171.55,129.34) ; U1.BG14 v1(217.55,153.34) ; U1.BJ53 v1(177.54,155.35) ; U1.AG48 v1(182.55,132.34) ; U1.AB19 v1(212.55,127.34) ; v1(164.52,114.39) 164.55,114.39 164.96,114.81 arc(165,114.83) U1.J66 ; U1.AN17 v1(214.55,138.34) ; U1.AA14 v1(217.55,126.34) ; v1(225.58,143.39) 225.58,143.37 U1.AU6 ; U1.AY4 v1(227.55,146.34) ; U1.BF52 v1(178.56,152.33) ; U1.BN6 v1(225.55,159.34) ; U1.B58 172.55,107.34 v1(172.56,107.34) ; U1.F42 v1(188.55,111.34) ; U1.D55 v1(175.55,109.34) ; U1.D58 v1(172.55,109.34) ; U1.BP59 171.57,160.32 v1(171.52,160.32) ; U1.BE19 v1(212.55,151.34) ; U1.AB12 v1(219.55,127.34) ; U1.CF13 v1(218.55,172.34) ; v1(167.55,146.29) 168,145.84 U1.AY63 ; U1.AF15 v1(216.55,131.34) ; U1.AF17 v1(214.55,131.34) ; U1.BY7 v1(224.55,166.34) ; v1(230.58,127.29) 230.56,127.29 230.55,127.3 230.55,127.34 230.22,127.67 U1.AB1 ; v1(224.58,123.34) 224.55,123.34 U1.V7 ; v1(215.55,111.34) U1.F16 ; v1(167.55,109.27) 167.55,109.34 U1.D63 ; U1.BF6 v1(225.55,152.34) ; U1.K20 v1(211.55,115.34) ; v1(171.52,143.34) 171.55,143.34 U1.AU59 ; U1.BF53 v1(177.55,152.34) ; U1.F13 v1(218.55,111.34) ; U1.BG50 v1(180.55,153.34) ; v1(208.55,170.37) 208.55,170.34 U1.CD23 ; U1.BL43 v1(187.55,157.34) ; U1.BH44 v1(186.55,154.34) ; U1.CA66 164.55,167.34 164.55,167.37 v1(164.52,167.37) ; U1.AJ66 164.63,134.42 v1(164.52,134.42) ; U1.R55 v1(175.55,120.34) ; U1.A3 v1(228.55,106.34) ; U1.CC25 206.55,169.34 v1(206.55,169.37) ; U1.AF20 v1(211.55,131.34) ; U1.AG57 173.55,132.34 v1(173.52,132.34) ; v1(195.54,108.31) 195.54,108.33 196.05,108.84 U1.C35 ; v1(223.58,141.34) 223.55,141.34 U1.AR8 ; U1.D25 206.55,109.34 v1(206.55,109.31) ; U1.K37 193.55,115.34 v1(193.55,115.32) ; U1.BU21 210.55,163.34 v1(210.55,163.37) ; U1.BJ10 v1(221.55,155.34) ; U1.BH37 v1(193.55,154.34) ; U1.CF39 191.55,172.34 v1(191.5,172.34) ; U1.B64 v1(166.55,107.34) ; U1.AA48 v1(182.55,126.34) ; v1(204.55,108.31) 204.55,108.34 U1.C27 ; U1.BA64 166.55,147.34 v1(166.55,147.39) ; v1(166.52,168.32) 166.55,168.34 U1.CB64 ; U1.BT4 227.1,161.84 v1(227.55,162.29) ; U1.D7 v1(224.55,109.34) ; v1(181.55,117.32) 181.55,117.34 U1.M49 ; U1.P19 v1(212.55,119.34) ; U1.AW52 v1(178.55,145.34) ; U1.AC15 v1(216.55,128.34) ; U1.D26 v1(205.55,109.34) ; v1(167.55,142.32) 167.55,142.34 U1.AT63 ; U1.AW19 v1(212.55,145.34) ; U1.F45 v1(185.52,111.32) ; U1.CD6 v1(225.55,170.34) ; U1.Y6 v1(225.55,125.34) ; U1.AM57 v1(173.55,137.34) ; U1.BW19 212.55,165.34 v1(212.55,165.35) ; U1.F66 164.55,111.34 v1(164.55,111.29) ; U1.AN16 v1(215.55,138.34) ; U1.BR19 v1(212.55,161.34) ; U1.BP27 204.55,160.34 v1(204.55,160.35) ; U1.BF17 v1(214.55,152.34) ; U1.AH14 v1(217.55,133.34) ; v1(184.57,117.32) 184.55,117.34 U1.M46 ; v1(230.55,126.39) 230.55,126.34 U1.AA1 ; U1.AP3 228.5,140.29 v1(228.55,140.29) ; v1(230.55,114.39) 230.5,114.39 U1.J1 ; U1.A57 173.57,106.37 v1(173.57,106.34) ; v1(211.6,106.31) 211.6,106.33 211.59,106.34 211.55,106.34 U1.A20 ; U1.T17 v1(214.55,121.34) ; U1.BR49 181.55,161.34 v1(181.55,161.37) ; U1.M33 v1(198.55,117.34) ; U1.F51 v1(179.55,111.34) ; U1.BD6 v1(225.55,150.34) ; U1.BE17 v1(214.55,151.34) ; U1.BE66 164.58,151.31 arc(164.56,151.35) 164.55,151.39 v1(164.52,151.39) ; v1(166.52,156.34) 166.55,156.34 U1.BK64 ; U1.N57 v1(173.55,118.34) ; U1.W25 v1(206.55,124.34) ; U1.P45 v1(185.55,119.34) ; U1.CA44 v1(186.55,167.34) ; U1.AW10 221.55,145.34 v1(221.58,145.34) ; v1(171.55,156.39) 171.55,156.34 U1.BK59 ; v1(219.55,116.34) 219.22,116.67 U1.L12 ; U1.BJ22 v1(209.55,154.34) U1.BH22 ; U1.AU14 v1(217.55,143.34) ; U1.AR12 v1(219.55,141.34) ; U1.H21 v1(210.55,113.34) ; U1.AM20 v1(211.55,137.34) ; U1.BH53 v1(177.55,154.34) ; U1.BB3 228.55,148.34 v1(228.55,148.29) ; v1(224.55,124.39) 224.1,124.84 U1.W7 ; U1.BG32 v1(199.55,153.34) ; U1.BA48 v1(182.55,147.34) ; U1.C6 v1(225.55,108.34) ; v1(214.55,167.37) 214.55,167.34 U1.CA17 ; U1.AH60 v1(170.55,133.34) U1.AG61 ; v1(221.58,137.34) 221.55,137.34 U1.AM10 ; U1.T6 v1(225.55,121.34) ; U1.M8 v1(223.55,117.34) ; U1.C20 211.22,108.67 211.55,108.34 v1(211.6,108.34) ; U1.V35 v1(195.55,123.34) ; U1.CD58 v1(172.55,170.34) ; U1.AT19 v1(212.55,142.34) ; U1.CA1 v1(230.55,167.34) ; U1.BL29 v1(202.55,157.34) ; U1.AD4 227.58,129.31 v1(227.58,129.29) ; v1(213.55,113.31) 213.55,113.34 U1.H18 ; U1.CA20 v1(211.55,167.34) ; v1(208.5,108.31) 208.5,108.39 U1.C23 ; U1.BL36 v1(194.55,157.34) ; U1.BC48 v1(182.55,149.34) ; U1.BH25 v1(206.55,154.34) ; v1(164.52,118.37) 164.55,118.37 164.55,118.34 U1.N66 ; U1.AJ52 v1(178.55,134.34) ; v1(192.55,161.37) 192.55,161.34 U1.BR38 ; U1.CB15 v1(216.55,168.34) ; U1.BR52 v1(178.55,161.34) ; U1.AP12 v1(219.55,140.34) ; U1.M34 v1(196.55,117.34) ; U1.CD44 186.57,170.32 v1(186.57,170.37) ; U1.BE48 v1(182.55,151.34) ; U1.W21 v1(210.55,124.34) ; v1(183.5,106.34) 183.55,106.34 U1.A47 ; U1.AN10 v1(221.55,138.34) ; U1.AK52 v1(178.55,135.34) ; U1.AB53 v1(177.55,127.34) ; U1.AW63 167.55,145.34 167.55,145.37 v1(167.52,145.39) ; v1(207.55,111.31) 207.55,111.34 U1.F24 ; v1(228.58,163.39) 228.58,163.37 U1.BU3 ; U1.AW15 v1(216.55,145.34) ; U1.BJ12 v1(219.55,155.34) ; U1.BF51 v1(179.55,152.34) ; U1.M45 v1(185.55,117.34) ; U1.CB3 228.55,168.34 v1(228.56,168.34) ; U1.BM32 v1(199.55,158.34) ; U1.K31 v1(200.55,115.34) ; U1.E7 v1(224.55,110.34) ; U1.AD6 225.55,129.34 v1(225.58,129.34) ; U1.BN52 v1(178.55,159.34) ; U1.AE48 v1(182.55,130.34) ; U1.BB19 v1(212.55,148.34) ; U1.BC57 v1(173.55,149.34) ; U1.A58 172.55,106.34 v1(172.56,106.34) ; v1(188.52,165.34) 188.55,165.34 U1.BW42 ; U1.BR42 v1(188.55,161.34) ; v1(186.55,161.37) 186.55,161.34 U1.BR44 ; U1.K38 v1(192.55,115.34) ; U1.AM19 v1(212.55,137.34) ; v1(169.55,142.32) 169.55,142.34 U1.AT61 ; U1.BL57 v1(173.55,157.34) ; U1.BY57 v1(173.55,166.34) ; U1.AE66 164.57,130.37 v1(164.52,130.37) ; U1.AV20 v1(211.55,144.34) ; v1(215.55,163.33) 215.55,163.34 U1.BU16 ; U1.BU47 v1(183.55,163.34) ; U1.BV9 v1(222.55,164.34) ; U1.AE64 v1(166.55,130.34) ; v1(228.58,147.34) 228.55,147.34 U1.BA3 ; U1.H8 223.55,113.34 v1(223.58,113.34) ; v1(217.55,170.37) 217.55,170.34 U1.CD14 ; U1.W30 v1(201.55,124.34) ; U1.BP12 219.55,160.34 v1(219.56,160.34) ; U1.A27 v1(204.55,106.34) ; v1(225.52,132.34) 225.55,132.34 U1.AG6 ; U1.CF44 186.55,172.34 v1(186.57,172.37) ; v1(230.58,148.29) 230.13,147.84 U1.BB1 ; U1.CB58 v1(172.55,168.34) ; v1(225.58,160.34) 225.55,160.34 U1.BP6 ; U1.AA51 v1(179.55,126.34) ; U1.BV30 v1(201.55,164.34) ; U1.AF14 v1(217.55,131.34) ; U1.R38 v1(192.55,120.34) ; v1(171.55,155.37) 171.56,155.37 171.56,155.35 171.55,155.34 U1.BJ59 ; U1.BU54 176.55,163.34 v1(176.55,163.29) ; v1(198.5,109.34) 198.05,109.79 U1.D33 ; U1.AU1 230.55,143.34 230.55,143.39 230.56,143.39 v1(230.58,143.39) ; U1.BR31 v1(200.55,160.34) U1.BP31 ; U1.BW60 v1(170.55,165.34) ; D441.29 v1(348.49,133.13) ; U1.CD47 v1(183.55,170.34) ; U1.CF27 v1(204.55,172.34) ; U1.B7 224.55,107.34 v1(224.52,107.34) ; U1.BH35 v1(195.55,154.34) ; U1.BK32 v1(199.55,156.34) ; U1.CE65 v1(165.55,171.34) ; U1.F29 202.55,111.34 v1(202.5,111.34) ; U1.BA50 v1(180.55,147.34) ; U1.AL6 225.1,136.84 v1(225.55,136.39) ; v1(178.52,111.34) 178.55,111.34 U1.F52 ; v1(169.55,131.39) 169.55,131.34 U1.AF61 ; U1.W24 v1(207.55,124.34) ; U1.BJ32 v1(199.55,155.34) ; U1.BE57 174,150.84 173.55,151.29 v1(173.52,151.29) ; 345.6,164.77 345.59,164.77 D443.4 ; U1.A31 200.55,106.34 v1(200.5,106.34) ; U1.CD31 v1(200.55,170.34) ; U1.A43 187.55,106.34 v1(187.5,106.34) ; v1(206.55,113.31) 206.55,113.34 U1.H25 ; U1.BM35 v1(195.55,158.34) ; U1.CF35 195.55,172.34 v1(195.55,172.37) ; U1.AG50 v1(180.55,132.34) ; U1.H48 v1(182.55,113.34) ; U1.D9 v1(222.55,109.34) ; U1.T57 v1(173.55,121.34) ; U1.E9 222.55,110.34 v1(222.58,110.34) ; U1.CB51 v1(179.55,168.34) ; U1.AR47 v1(183.55,141.34) ; v1(220.55,170.37) 220.55,170.34 U1.CD11 ; U1.AP14 v1(217.55,140.34) ; U1.W61 v1(169.55,124.34) ; v1(166.52,143.34) 166.55,143.34 U1.AU64 ; U1.BG35 v1(195.55,153.34) ; U1.M36 194.55,117.34 v1(194.55,117.32) ; U1.BB11 220.55,148.34 v1(220.56,148.34) ; U1.P55 175.55,119.34 v1(175.52,119.34) ; U1.BV52 v1(178.55,164.34) ; U1.AB66 164.55,127.34 v1(164.55,127.29) ; U1.K47 v1(183.55,115.34) ; v1(169.55,127.32) 169.55,127.34 U1.AB61 ; v1(166.52,110.39) 166.6,110.39 U1.E64 ; U1.CD19 212.05,169.89 212.5,170.34 v1(212.5,170.37) ; U1.P41 v1(189.55,119.34) ; v1(169.56,112.37) 169.56,112.35 U1.G61 ; U1.AR59 171.55,141.34 171.55,141.37 v1(171.52,141.39) ; U1.BE55 176,150.84 v1(175.55,151.29) ; U1.H4 v1(227.55,113.34) ; U1.AB57 173.55,127.34 v1(173.55,127.32) ; U1.N17 v1(214.55,118.34) ; v1(171.55,159.37) 171.55,159.34 U1.BN59 ; U1.BR18 213.53,161.32 v1(213.53,161.37) ; U1.AL17 v1(214.55,136.34) ; U1.BY15 v1(216.55,166.34) ; U1.AK48 v1(182.55,135.34) ; v1(166.52,123.29) 166.52,123.32 U1.V64 ; U1.K35 v1(195.55,115.34) ; U1.H10 221.55,113.34 v1(221.58,113.34) ; U1.T52 v1(178.55,121.34) ; v1(227.54,169.34) 227.55,169.34 U1.CC4 ; v1(210.5,109.34) 210.05,109.79 U1.D21 ; U1.J39 v1(191.54,114.33) ; U1.BD8 223.55,150.34 v1(223.58,150.34) ; U1.AL53 v1(177.55,136.34) ; U1.W10 221.52,124.37 v1(221.58,124.37) ; U1.G55 175.57,112.37 v1(175.51,112.37) ; U1.AD55 175.55,129.34 v1(175.52,129.34) ; U1.V36 v1(194.55,123.34) ; U1.BL16 v1(215.55,157.34) ; U1.CA23 v1(208.55,167.34) ; v1(193.55,111.39) 193.6,111.39 U1.F37 ; U1.Y12 v1(219.55,125.34) ; v1(171.52,140.34) 171.55,140.34 U1.AP59 ; U1.B3 v1(228.55,107.34) ; U1.BY12 v1(219.55,166.34) ; U1.BT60 170.55,162.34 v1(170.55,162.29) ; U1.C61 v1(169.55,108.34) ; U1.BR12 v1(219.55,161.34) ; U1.BM6 v1(225.55,158.34) ; v1(219.58,114.34) 219.55,114.34 U1.J12 ; 70.5,151.86 D437.4 ; U1.CC17 214.55,169.34 v1(214.55,169.37) ; U1.BK38 v1(192.55,156.34) ; U1.CC26 v1(205.55,169.34) ; U1.L28 203.55,116.34 v1(203.55,116.31) ; U1.AP17 v1(214.55,140.34) ; v1(218.57,123.34) 218.55,123.34 U1.V13 ; U1.V37 v1(193.55,123.34) ; U1.CB32 v1(199.55,168.34) ; U1.G4 227.5,112.39 v1(227.58,112.39) ; U1.BC55 v1(175.5,149.39) ; U1.W15 v1(216.55,124.34) ; v1(215.55,172.34) U1.CF16 ; v1(164.52,147.42) 164.52,147.37 U1.BA66 ; U1.N59 171.57,118.37 v1(171.52,118.37) ; U1.CA47 183.55,167.34 v1(183.55,167.35) ; U1.CF57 v1(173.55,172.34) ; U1.CE7 v1(224.55,171.34) ; U1.AG12 v1(219.55,132.34) ; U1.AH50 v1(180.55,133.34) ; U1.BU7 v1(224.55,163.34) ; U1.W47 v1(183.55,124.34) ; U1.BH10 v1(221.55,154.34) ; U1.A14 v1(217.55,106.34) ; U1.J61 169.58,114.38 arc(169.56,114.34) 169.55,114.29 v1(169.57,114.29) ; U1.AL47 v1(183.55,136.34) ; U1.BY53 v1(177.55,166.34) ; U1.BN49 v1(181.55,159.34) ; U1.AT8 v1(223.55,142.34) ; U1.AW17 v1(214.55,145.34) ; U1.BJ52 v1(178.55,155.34) ; U1.AK7 224.55,135.34 v1(224.58,135.34) ; U1.G7 224.5,112.39 v1(224.55,112.39) ; U1.BG55 175.55,153.34 v1(175.52,153.34) ; D436.29 v1(67.6,142.85) ; U1.AB6 v1(225.55,127.34) ; U1.BT52 v1(178.55,162.34) ; U1.BF16 v1(215.55,152.34) ; U1.A32 199.58,106.31 v1(199.6,106.31) ; U1.AT48 v1(182.55,142.34) ; U1.BF55 175.55,152.34 v1(175.52,152.34) ; U1.W42 v1(188.55,124.34) ; U1.K46 184.55,115.34 v1(184.57,115.34) ; U1.AM53 v1(177.55,137.34) ; U1.W45 v1(185.55,124.34) ; v1(172.52,163.29) 172.6,163.29 U1.BU58 ; U1.BY28 v1(203.55,166.34) ; U1.F19 v1(212.55,111.34) ; U1.W29 v1(202.55,124.34) ; U1.AB3 228.55,127.34 v1(228.55,127.29) ; U1.D4 v1(227.55,109.34) ; U1.CC42 188.6,169.29 v1(188.6,169.37) ; U1.BA58 172.55,147.34 v1(172.55,147.37) ; U1.J53 v1(177.55,114.34) ; U1.W49 v1(181.55,124.34) ; U1.AJ17 v1(214.55,134.34) ; U1.CD61 v1(169.57,170.32) ; v1(210.5,169.37) 210.5,169.29 U1.CC21 ; U1.D38 v1(192.55,109.34) ; U1.CA60 170.55,167.34 v1(170.6,167.34) ; U1.BW49 181.6,165.29 v1(181.6,165.37) ; U1.P21 v1(210.55,119.34) ; U1.BF15 v1(216.55,152.34) ; U1.H6 v1(225.55,113.34) ; U1.B60 171.05,107.79 v1(170.61,107.35) ; U1.P35 v1(195.55,119.34) ; U1.BU17 214.52,163.31 v1(214.55,163.31) ; U1.BA19 v1(212.55,147.34) ; U1.AA47 v1(183.55,126.34) ; U1.AK50 v1(180.55,135.34) ; U1.BV7 v1(224.55,164.34) ; U1.AA20 v1(211.55,126.34) ; U1.CC7 v1(224.55,169.34) ; v1(166.55,126.39) 167,126.84 U1.AA64 ; U1.BM28 v1(203.55,158.34) ; U1.AV16 v1(215.55,144.34) ; U1.P42 v1(188.55,119.34) ; U1.BG30 v1(201.55,153.34) ; U1.H36 v1(194.55,113.34) ; U1.AJ47 v1(183.55,134.34) ; U1.CE51 v1(179.55,171.34) ; v1(164.52,110.42) 164.63,110.42 U1.E66 ; v1(220.58,162.34) 220.55,162.34 U1.BT11 ; U1.CD9 v1(222.55,170.34) ; 345.6,174.93 345.59,174.93 D446.4 ; v1(223.58,159.37) 223.56,159.34 223.55,159.34 U1.BN8 ; U1.E15 v1(216.55,110.34) ; v1(191.5,170.37) 191.52,170.37 U1.CD39 ; U1.BR53 v1(177.55,161.34) ; U1.AB20 v1(211.55,127.34) ; U1.R40 v1(190.55,120.34) ; U1.B51 v1(179.55,107.34) ; U1.P14 v1(217.55,119.34) ; U1.BB9 v1(222.55,148.34) ; U1.AG19 v1(212.55,132.34) ; U1.BK30 v1(201.55,156.34) ; v1(187.52,172.34) 187.55,172.34 U1.CF43 ; U1.BV15 v1(216.55,164.34) ; v1(201.55,163.34) U1.BU30 v1(201.55,162.34) ; U1.AD50 v1(180.55,129.34) ; U1.BY54 v1(176.55,166.34) ; U1.AY6 v1(225.55,146.34) ; v1(223.58,153.34) 223.55,153.34 U1.BG8 ; v1(219.58,138.34) 219.55,138.34 U1.AN12 ; U1.BM41 v1(189.55,158.34) ; v1(203.55,118.32) 203.55,118.34 U1.N28 ; U1.K45 v1(185.52,115.32) ; U1.J6 v1(225.55,114.34) ; U1.G28 203.55,112.34 v1(203.55,112.31) ; v1(183.5,108.34) 183.55,108.34 U1.C47 ; U1.C51 v1(179.55,108.34) ; U1.BR14 v1(217.55,161.34) ; U1.AN61 169.55,138.34 v1(169.55,138.29) ; D445.29 v1(348.43,183.93) ; U1.J17 v1(214.55,114.34) ; U1.BU35 v1(195.55,163.34) ; U1.CC63 v1(167.52,169.37) ; U1.L17 v1(214.55,116.34) ; U1.BJ45 v1(185.55,155.34) ; U1.AM14 217.05,137.82 v1(217.51,137.35) ; U1.CD51 v1(179.55,170.34) ; U1.BA54 176.55,147.34 v1(176.52,147.34) ; U1.BL14 v1(217.55,157.34) ; U1.F30 v1(201.55,111.34) ; U1.BY27 204.55,166.34 v1(204.55,166.37) ; U1.AC50 v1(180.55,128.34) ; U1.BU23 208.55,163.34 v1(208.55,163.37) ; U1.BA16 v1(215.55,147.34) ; v1(198.55,115.31) 198.55,115.34 U1.K33 ; U1.BU48 182.55,163.34 v1(182.5,163.34) ; U1.P64 v1(166.55,119.34) ; U1.AE53 v1(177.55,130.34) ; U1.CA22 v1(209.55,167.34) ; U1.CB12 219.55,168.34 v1(219.55,168.37) ; U1.P37 v1(193.55,119.34) ; v1(175.52,150.34) 175.55,150.34 U1.BD55 ; v1(221.58,132.34) 221.55,132.34 U1.AG10 ; U1.AP19 v1(212.55,140.34) ; U1.BR8 v1(223.55,161.34) ; U1.AV19 v1(212.55,144.34) ; U1.Y8 223.52,125.37 v1(223.58,125.37) ; U1.CF47 183.55,172.34 v1(183.52,172.34) ; U1.CF51 v1(179.55,172.34) ; U1.BL20 v1(211.55,157.34) ; U1.T14 v1(217.55,121.34) ; U1.P1 v1(230.55,119.34) ; U1.AP10 v1(221.55,140.34) ; U1.AT17 v1(214.55,142.34) ; D438.29 v1(67.6,163.17) ; v1(194.5,163.37) 194.52,163.34 194.55,163.34 U1.BU36 ; U1.T4 v1(227.55,121.34) ; v1(225.58,144.35) 225.56,144.35 U1.AV6 ; U1.CF24 v1(207.55,172.34) ; U1.BW20 211.55,165.34 211.55,165.37 v1(211.55,165.37) ; U1.G26 v1(205.55,112.34) ; v1(171.52,152.32) 171.55,152.34 U1.BF59 ; U1.F38 v1(192.55,111.34) ; U1.BC50 v1(180.55,149.34) ; U1.M63 v1(167.55,117.34) ; U1.CB10 v1(221.55,168.34) ; U1.BH33 v1(198.55,154.34) ; v1(228.55,164.29) 228.55,164.34 U1.BV3 ; v1(180.6,167.34) 180.55,167.34 U1.CA50 ; U1.D12 v1(219.55,109.34) ; U1.V54 v1(176.55,123.34) ; U1.BN66 164.52,159.37 v1(164.52,159.42) ; U1.AW55 175.55,145.34 v1(175.52,145.34) ; U1.AA15 v1(216.55,126.34) ; U1.L39 191.55,116.34 v1(191.55,116.32) ; U1.H35 v1(195.55,113.34) ; U1.AD53 v1(177.55,129.34) ; U1.AP66 v1(164.55,140.34) ; U1.BY9 v1(222.55,166.34) ; v1(173.52,153.34) 173.55,153.34 U1.BG57 ; U1.BH21 v1(210.55,154.34) ; U1.CB52 v1(178.55,168.34) ; U1.L59 171.55,116.34 v1(171.52,116.34) ; U1.AH53 v1(177.55,133.34) ; U1.CE54 v1(176.55,171.34) ; U1.BV1 230.1,163.84 v1(230.55,164.29) ; U1.CF28 203.55,172.34 v1(203.55,172.37) ; U1.AW57 173.55,145.34 v1(173.52,145.34) ; v1(230.58,140.29) 230.5,140.29 U1.AP1 ; v1(203.6,106.31) 203.6,106.34 arc(203.55,106.35) 203.51,106.38 U1.A28 ; U1.P34 v1(196.55,119.34) ; U1.K14 v1(217.55,115.34) ; U1.AV50 v1(180.55,144.34) ; U1.E13 218.55,110.34 v1(218.58,110.34) ; U1.V15 v1(216.55,123.34) ; v1(166.52,127.29) 166.52,127.32 U1.AB64 ; U1.AC48 v1(182.55,128.34) ; U1.G10 221.55,112.34 v1(221.58,112.34) ; U1.AY12 v1(219.55,146.34) ; U1.BL33 v1(198.55,156.34) ; U1.V1 230.55,123.34 230.55,123.3 230.56,123.29 v1(230.58,123.29) ; U1.BY8 223.55,166.34 v1(223.55,166.37) ; U1.AR51 v1(179.55,141.34) ; U1.BL35 v1(195.55,157.34) ; U1.AN59 171.52,138.32 v1(171.52,138.29) ; U1.AE19 v1(212.55,130.34) ; U1.BP28 203.55,160.34 v1(203.55,160.37) ; U1.AH20 v1(211.55,133.34) ; U1.CE3 228.55,171.34 v1(228.56,171.34) ; U1.AE3 228.13,130.84 v1(228.58,130.39) ; D439.29 v1(67.66,173.33) ; U1.CB57 v1(173.55,168.34) ; U1.AD48 v1(182.55,129.34) ; v1(190.6,108.34) 191.05,108.79 U1.C40 ; U1.AV53 v1(177.55,144.34) ; U1.BM4 v1(227.55,158.34) ; v1(174.55,135.32) 174.55,135.34 U1.AK56 ; 70.5,141.7 70.5,141.7 D436.4 ; U1.M20 v1(211.55,117.34) ; U1.BR47 184.05,160.87 v1(183.55,161.37) ; U1.AC63 167.55,128.34 v1(167.52,128.37) ; U1.U7 v1(224.55,122.34) ; U1.W23 v1(208.55,124.34) ; U1.CD36 194.55,170.34 v1(194.6,170.34) ; U1.AP50 v1(180.55,140.34) ; U1.BR51 v1(179.55,161.34) ; U1.BY56 v1(174.55,166.34) ; U1.BJ35 v1(195.55,155.34) ; U1.BN36 v1(194.55,159.34) ; U1.BF50 v1(180.55,152.34) ; U1.A51 v1(179.55,106.34) ; U1.F46 184.55,111.34 v1(184.6,111.34) ; U1.U60 170.55,122.34 v1(170.55,122.37) ; U1.AR53 v1(177.55,141.34) ; U1.J10 v1(221.55,114.34) ; U1.T10 v1(221.55,121.34) ; U1.BJ40 v1(190.55,155.34) ; U1.BT13 v1(218.55,162.34) ; U1.AU17 v1(214.55,143.34) ; v1(219.58,151.34) 219.55,151.34 U1.BE12 ; U1.BV10 v1(221.55,164.34) ; U1.BM55 175.55,158.34 v1(175.52,158.34) ; v1(225.55,116.39) 225.55,116.34 U1.L6 ; U1.BV53 v1(177.55,164.34) ; v1(223.58,128.34) 223.55,128.34 U1.AC8 ; U1.F20 v1(211.55,111.34) ; v1(171.52,114.29) 171.55,114.32 171.55,114.34 U1.J59 ; U1.AF55 175.55,131.34 v1(175.52,131.34) ; U1.BV14 v1(217.55,164.34) ; U1.AU57 v1(173.55,143.34) ; U1.AL60 v1(170.55,136.34) ; U1.AE50 v1(180.55,130.34) ; v1(199.55,117.34) U1.M32 ; U1.BU41 v1(189.55,163.34) ; U1.C58 172.55,108.34 v1(172.56,108.34) ; U1.AJ48 v1(182.55,134.34) ; U1.AP6 v1(225.55,140.34) ; U1.BF19 v1(212.55,152.34) ; U1.CC6 v1(225.55,169.34) ; U1.F58 v1(172.52,111.32) ; U1.CC45 v1(185.55,169.34) ; v1(224.52,106.34) 224.55,106.34 U1.A7 ; v1(214.55,165.37) 214.55,165.34 U1.BW17 ; U1.AW48 v1(182.55,145.34) ; U1.AE14 v1(217.55,130.34) ; U1.AE10 v1(221.55,130.34) ; U1.P8 v1(223.55,119.34) ; U1.AB10 v1(221.55,127.34) ; U1.BM61 169.55,158.34 v1(169.55,158.29) ; U1.M10 v1(221.55,117.34) ; U1.AY15 v1(216.55,146.34) ; U1.CC22 v1(209.55,169.34) ; U1.R63 167.55,120.34 167.55,120.37 v1(167.52,120.39) ; U1.AA16 v1(215.55,126.34) ; U1.F36 v1(194.55,111.34) ; U1.CD8 223.55,170.34 v1(223.55,170.37) ; U1.BM8 v1(223.55,158.34) ; U1.Y57 v1(173.55,125.34) ; U1.BD14 v1(217.55,150.34) ; U1.AB48 v1(182.55,127.34) ; U1.CB1 v1(230.55,168.34) ; v1(228.55,111.29) 228.55,111.34 U1.F3 ; v1(171.52,127.32) U1.AB59 ; v1(190.55,116.32) 190.55,116.34 U1.L40 ; U1.N14 v1(217.55,118.34) ; U1.AK16 v1(215.55,135.34) ; v1(164.52,126.39) 164.55,126.39 164.96,126.81 arc(165,126.83) U1.AA66 ; v1(221.56,156.34) 221.55,156.34 U1.BK10 ; U1.BH45 v1(185.55,154.34) ; U1.CA18 213.55,167.34 v1(213.55,167.39) ; v1(169.55,137.29) 169.55,137.34 U1.AM61 ; U1.AY17 v1(214.55,146.34) ; v1(223.58,145.32) 223.52,145.32 U1.AW8 ; U1.BW44 v1(186.55,165.34) ; U1.BK29 v1(202.55,156.34) ; U1.P25 v1(206.55,119.34) ; U1.BB20 v1(211.55,148.34) ; v1(173.55,164.32) 173.55,164.34 U1.BV57 ; U1.AK17 v1(214.55,135.34) ; U1.J8 v1(223.55,114.34) ; U1.AB17 v1(214.55,127.34) ; U1.BV27 v1(204.55,164.34) ; v1(215.55,171.34) U1.CE16 ; U1.T60 v1(170.55,121.34) ; v1(208.55,165.37) 208.55,165.34 U1.BW23 ; v1(227.58,132.34) 227.57,132.34 227.07,132.84 U1.AG4 ; U1.BK6 225.07,155.84 225.59,156.36 v1(225.59,156.36) ; U1.W60 v1(170.55,124.34) ; U1.AK9 v1(222.55,135.34) ; U1.AM48 v1(182.55,137.34) ; U1.K19 v1(212.55,115.34) ; U1.AV12 219.55,144.34 v1(219.58,144.34) ; U1.P47 v1(183.55,119.34) ; U1.BH30 v1(201.55,154.34) ; U1.CD12 v1(219.55,170.34) ; U1.AG14 v1(217.55,132.34) ; U1.P49 v1(181.55,119.34) ; U1.F34 v1(196.55,111.34) ; U1.BM26 v1(205.55,158.34) ; U1.K10 v1(221.55,115.34) ; v1(182.5,161.34) 182.55,161.34 U1.BR48 ; U1.AH52 v1(178.55,133.34) ; U1.BV39 v1(191.55,164.34) ; U1.AN1 230.1,138.84 v1(230.55,138.39) ; U1.BW50 180.57,165.32 v1(180.57,165.37) ; U1.BV58 172.57,164.32 v1(172.52,164.32) ; U1.CF60 v1(170.55,172.34) ; U1.P20 v1(211.55,119.34) ; U1.BW6 225.55,165.34 v1(225.55,165.39) ; U1.P36 v1(194.55,119.34) ; U1.C36 v1(194.55,108.34) ; U1.N12 v1(219.55,118.34) ; v1(182.6,167.37) 182.57,167.34 182.55,167.34 U1.CA48 ; U1.BA52 v1(178.55,147.34) ; U1.BU26 v1(205.55,163.34) ; U1.AK54 v1(176.55,135.34) ; U1.P32 v1(199.55,119.34) ; U1.K66 164.55,115.34 v1(164.55,115.29) ; U1.P57 173.6,119.39 v1(173.52,119.39) ; v1(202.55,162.37) 202.55,162.34 U1.BT29 ; U1.T47 v1(183.55,121.34) ; U1.BV28 203.55,164.34 203.55,164.35 v1(203.57,164.37) ; U1.BP30 v1(201.55,160.34) ; U1.BH29 v1(202.55,154.34) ; U1.AY57 v1(173.55,146.34) ; U1.BY52 v1(178.55,166.34) ; U1.AY14 v1(217.55,146.34) ; U1.P66 v1(164.55,119.34) ; U1.D45 185.55,109.34 v1(185.5,109.34) ; U1.AV3 v1(228.55,144.34) ; v1(190.6,170.34) 191.05,169.89 U1.CD40 ; U1.AC19 v1(212.55,128.34) ; U1.BN17 v1(214.55,159.34) ; U1.H37 193.55,113.34 v1(193.55,113.32) ; U1.AM4 v1(227.55,137.34) ; U1.AB50 v1(180.55,127.34) ; U1.BN44 187.05,158.84 v1(187.55,159.34) U1.BN43 ; U1.K44 v1(186.55,115.34) ; U1.BV11 v1(220.55,164.34) ; v1(169.55,133.29) 169.55,133.34 U1.AH61 ; U1.AJ50 v1(180.55,134.34) ; v1(217.55,114.34) 217.22,114.67 U1.J14 ; U1.V32 v1(199.55,123.34) ; U1.H50 180.55,113.34 v1(180.55,113.32) ; U1.W6 225.1,124.84 v1(225.55,124.39) ; U1.H49 181.55,113.34 v1(181.55,113.32) ; U1.BK39 v1(191.55,156.34) ; U1.AP61 v1(169.55,140.34) ; U1.AE61 v1(169.55,130.34) ; U1.AG8 223.57,132.32 v1(223.58,132.32) ; U1.CF7 v1(224.55,172.34) ; U1.C56 v1(174.55,108.34) ; v1(166.52,106.34) 166.55,106.34 U1.A64 ; U1.AA8 v1(223.55,126.34) ; U1.BV12 v1(219.55,164.34) ; U1.A12 v1(219.55,106.34) ; U1.K22 v1(209.55,115.34) ; U1.CF19 212.05,171.89 v1(212.5,172.34) ; U1.BM57 v1(173.55,158.34) ; U1.M41 v1(189.55,117.34) ; v1(215.55,167.34) U1.CA16 ; v1(187.53,111.33) 187.52,111.32 187.52,111.32 U1.F43 ; U1.H34 v1(196.55,113.34) ; U1.BB50 v1(180.55,148.34) ; U1.BU45 v1(185.55,163.34) ; U1.AJ7 v1(224.55,134.34) ; v1(173.52,138.29) 173.55,138.32 173.55,138.34 U1.AN57 ; U1.AC12 v1(219.55,128.34) ; U1.AH15 v1(216.55,133.34) ; U1.CA41 v1(189.55,167.34) ; v1(227.58,136.39) 227.5,136.39 U1.AL4 ; U1.AJ1 v1(230.55,134.34) ; v1(199.55,113.34) U1.H32 ; v1(173.52,114.29) 173.52,114.32 U1.J57 ; U1.H47 v1(183.55,113.34) ; U1.BR6 v1(225.55,161.34) ; v1(202.55,117.34) U1.M29 ; U1.AD10 v1(221.55,129.34) ; U1.AL50 v1(180.55,136.34) ; U1.BT9 v1(222.55,162.34) ; U1.CA37 v1(193.55,167.34) ; U1.P38 v1(192.55,119.34) ; v1(191.55,108.32) 191.55,108.34 U1.C39 ; U1.AY55 v1(175.55,146.34) ; U1.AU61 v1(169.55,143.34) ; U1.A50 v1(180.55,106.34) ; U1.M37 v1(193.55,117.34) ; U1.F26 v1(205.55,111.34) ; U1.AY50 v1(180.55,146.34) ; U1.AE8 v1(223.55,130.34) ; U1.BL4 227.55,157.34 v1(227.58,157.34) ; U1.BU66 164.52,163.37 v1(164.52,163.42) ; U1.AA17 v1(214.55,126.34) ; U1.BU22 v1(209.55,163.34) ; U1.BA60 v1(170.52,147.37) ; U1.BU51 v1(179.55,163.34) ; U1.H31 v1(200.55,113.34) ; U1.C32 199.55,108.34 v1(199.6,108.34) ; U1.BB17 v1(214.55,148.34) ; U1.R26 v1(205.55,120.34) ; U1.BN45 v1(185.55,159.34) ; U1.AP53 v1(177.55,140.34) ; U1.BR15 v1(216.55,161.34) ; U1.BD61 169.55,150.34 v1(169.55,150.27) ; U1.BV56 174.55,164.34 v1(174.55,164.32) ; U1.C52 v1(178.55,108.34) ; U1.K23 v1(208.55,115.34) ; U1.AV64 v1(166.55,144.34) ; U1.BM14 v1(217.55,158.34) ; v1(167.52,133.29) 167.55,133.32 167.55,133.34 U1.AH63 ; U1.AC17 v1(214.55,128.34) ; U1.U58 172.55,122.34 v1(172.55,122.37) ; U1.BR23 v1(208.55,161.34) ; v1(230.58,155.39) 230.56,155.39 230.55,155.39 230.55,155.34 U1.BJ1 ; v1(199.55,163.34) U1.BU32 ; U1.K12 v1(219.55,115.34) ; U1.BD4 v1(227.55,150.34) ; U1.D49 v1(181.55,109.34) ; U1.F31 v1(200.55,111.34) ; v1(215.55,170.34) U1.CD16 ; U1.CD57 v1(173.55,170.34) ; U1.BA1 v1(230.55,147.34) ; D442.29 v1(348.43,143.29) ; U1.BC52 v1(178.55,149.34) ; U1.BA17 v1(214.55,147.34) ; v1(219.58,154.34) 219.55,154.34 U1.BH12 ; U1.W32 v1(199.55,124.34) ; U1.Y59 v1(171.55,125.34) ; U1.CA36 194.56,167.33 v1(194.56,167.37) ; U1.Y4 v1(227.55,125.34) ; U1.AU48 v1(182.55,143.34) ; U1.AL19 v1(212.55,136.34) ; U1.K42 188.55,115.34 v1(188.55,115.32) ; U1.AR19 v1(212.55,141.34) ; U1.H19 v1(212.55,113.34) ; U1.CF54 v1(176.55,172.34) ; U1.K1 230.55,115.34 230.55,115.3 230.56,115.29 v1(230.58,115.29) ; U1.N39 191.55,118.34 v1(191.55,118.33) ; U1.AN51 v1(179.55,138.34) ; U1.AN47 v1(183.55,138.34) ; U1.BH23 v1(208.55,154.34) ; U1.BF10 v1(221.55,152.34) ; U1.C16 215.55,108.34 v1(215.6,108.34) ; U1.BP14 v1(217.55,160.34) ; U1.AH48 v1(182.55,133.34) ; U1.BL47 v1(183.55,157.34) ; v1(218.52,107.34) 218.55,107.34 U1.B13 ; U1.AR16 v1(215.55,141.34) ; U1.H14 v1(217.55,113.34) ; U1.BK14 v1(217.55,156.34) ; U1.W22 v1(209.55,124.34) ; U1.CA64 166.55,167.34 v1(166.55,167.37) ; U1.A35 v1(195.52,106.32) ; v1(182.6,172.37) 182.6,172.29 U1.CF48 ; U1.BF46 v1(184.55,152.34) ; v1(169.55,118.37) 169.55,118.34 U1.N61 ; U1.BC15 v1(216.55,149.34) ; U1.CC38 193.05,168.89 v1(192.6,169.34) ; U1.AN50 v1(180.55,138.34) ; U1.AY48 v1(182.55,146.34) ; U1.AW53 v1(177.55,145.34) ; U1.U52 v1(178.55,122.34) ; U1.BN22 v1(209.55,159.34) ; U1.BP39 v1(191.55,160.34) ; U1.CA19 v1(212.55,167.34) ; U1.BY10 v1(221.55,166.34) ; U1.AD57 173.55,129.34 v1(173.52,129.34) ; U1.BK53 v1(177.55,156.34) ; v1(219.58,159.34) 219.55,159.34 U1.BN12 ; U1.BP3 v1(228.55,160.34) ; U1.P52 v1(178.55,119.34) ; U1.AF53 v1(177.55,131.34) ; U1.AG52 v1(178.55,132.34) ; U1.AY52 v1(178.55,146.34) ; U1.F44 v1(186.55,111.34) ; U1.AR48 v1(182.55,141.34) ; U1.AD8 v1(223.55,129.34) ; U1.W35 v1(195.55,124.34) ; U1.AD61 v1(169.55,129.34) ; U1.BK8 v1(223.55,156.34) ; U1.W14 v1(217.55,124.34) ; U1.BD17 v1(214.55,150.34) ; U1.AF12 219.55,131.34 v1(219.58,131.34) ; v1(221.58,120.34) 221.55,120.34 U1.R10 ; U1.BN18 v1(213.55,159.34) ; U1.BH63 v1(167.55,154.34) ; U1.AL15 v1(216.55,136.34) ; U1.G38 v1(192.55,112.34) ; v1(214.5,111.34) 214.55,111.34 214.22,111.67 U1.F17 ; U1.BW7 v1(224.55,165.34) ; U1.K43 v1(187.55,115.34) ; 345.6,144.45 345.59,144.45 D442.4 ; v1(224.55,149.39) 224.55,149.34 U1.BC7 ; U1.AK15 v1(216.55,135.34) ; U1.CB56 v1(174.55,168.34) ; U1.CA24 v1(207.55,167.34) ; U1.AT14 v1(217.55,142.34) ; U1.BH14 v1(217.55,154.34) ; U1.AG47 v1(183.55,132.34) ; U1.J40 v1(190.55,114.34) ; U1.AC10 221.55,128.34 v1(221.58,128.34) ; U1.L14 v1(217.55,116.34) ; U1.D14 v1(217.55,109.34) ; U1.AR14 v1(217.55,141.34) ; U1.BN61 v1(169.52,159.37) ; U1.K36 v1(194.55,115.34) ; v1(230.58,160.34) 230.55,160.34 U1.BP1 ; U1.BY39 v1(191.55,166.34) ; U1.AK19 v1(212.55,135.34) ; U1.CD55 v1(175.55,170.34) ; U1.BE10 v1(221.55,151.34) ; U1.AF64 166.55,131.34 v1(166.52,131.34) ; U1.BC61 v1(169.55,149.34) ; U1.AE17 v1(214.55,130.34) ; U1.BB15 v1(216.55,148.34) ; U1.BN37 v1(193.55,159.34) ; U1.BH55 175.55,154.34 v1(175.52,154.34) ; U1.AM12 v1(219.55,137.34) ; v1(182.5,165.34) 182.55,165.34 U1.BW48 ; U1.D34 v1(196.55,109.34) ; U1.BU34 v1(196.55,163.34) ; v1(166.55,115.29) 166.55,115.34 U1.K64 ; U1.K8 v1(223.55,115.34) ; U1.P59 171.6,119.39 v1(171.52,119.39) ; U1.BF20 v1(211.55,152.34) ; U1.BB56 174.55,148.34 v1(174.55,148.32) ; D444.29 v1(348.49,153.45) ; U1.BH41 v1(189.55,154.34) ; U1.W20 v1(211.55,124.34) ; U1.BJ30 v1(201.55,155.34) ; U1.R28 v1(203.55,120.34) ; U1.CF64 v1(166.55,172.34) ; U1.CB31 v1(200.55,168.34) ; U1.M38 v1(192.55,117.34) ; U1.F50 v1(180.55,111.34) ; U1.H53 v1(177.55,113.34) ; U1.BD50 v1(180.55,150.34) ; U1.K51 v1(179.55,115.34) ; U1.R41 v1(189.55,120.34) ; U1.H43 v1(187.55,113.34) ; U1.BN50 v1(180.55,159.34) ; U1.V50 v1(180.55,123.34) ; U1.BC63 v1(167.55,149.34) ; U1.W27 v1(204.55,124.34) ; U1.BU37 v1(193.55,163.34) ; U1.BU44 v1(186.55,163.34) ; U1.BJ37 v1(193.55,155.34) ; U1.CE64 v1(166.55,171.34) ; U1.BN1 v1(230.55,159.34) ; v1(219.58,119.34) 219.55,119.34 U1.P12 ; U1.BD12 v1(219.55,150.34) ; U1.AA10 v1(221.55,126.34) ; U1.AM59 v1(171.55,137.34) ; U1.W43 v1(187.55,124.34) ; U1.CF50 v1(180.55,172.34) ; U1.T63 167.55,121.34 v1(167.55,121.29) ; U1.AT20 v1(211.55,142.34) ; U1.K34 v1(196.55,115.34) ; U1.AU8 v1(223.55,143.34) ; v1(173.55,156.39) 173.55,156.34 U1.BK57 ; U1.AV59 171.52,144.38 v1(171.52,144.4) ; U1.AF3 v1(228.55,131.34) ; U1.AL48 v1(182.55,136.34) ; U1.AU19 v1(212.55,143.34) ; U1.G14 v1(217.55,112.34) ; U1.T23 v1(208.55,121.34) ; U1.BH61 v1(169.55,154.34) ; D443.29 v1(348.43,163.61) ; U1.P24 v1(207.55,119.34) ; U1.BR57 v1(173.55,161.34) ; U1.BC51 v1(179.55,149.34) ; U1.CA43 v1(187.55,167.34) ; U1.W12 v1(219.55,124.34) ; v1(166.52,159.39) 166.52,159.37 U1.BN64 ; U1.AN55 v1(175.55,138.34) ; U1.BY55 v1(175.55,166.34) ; U1.BG34 v1(196.55,153.34) ; U1.AG59 v1(171.55,132.34) ; U1.AA18 v1(213.55,126.34) ; U1.P44 v1(186.55,119.34) ; v1(220.52,107.34) 220.55,107.34 U1.B11 ; U1.AB14 v1(217.55,127.34) ; U1.AL61 v1(169.55,136.34) ; U1.AV55 175.55,144.34 v1(175.52,144.34) ; U1.BH20 v1(211.55,154.34) ; U1.BH59 v1(171.55,154.34) ; U1.BW63 v1(167.55,165.34) ; U1.CE10 v1(221.55,171.34) ; v1(199.55,115.34) U1.K32 ; U1.BH46 v1(184.55,154.34) ; U1.W31 v1(200.55,124.34) ; U1.AE57 v1(173.55,130.34) ; U1.AA19 v1(212.55,126.34) ; U1.AD51 v1(179.55,129.34) ; D440.29 v1(67.6,183.49) ; U1.AW50 v1(180.55,145.34) ; U1.BF12 v1(219.55,152.34) ; U1.BP53 v1(177.55,160.34) ; v1(170.6,108.34) 170.6,108.39 U1.C60 ; U1.CD10 v1(221.55,170.34) ; U1.J50 v1(180.55,114.34) ; U1.AW14 v1(217.55,145.34) ; U1.AV51 v1(179.55,144.34) ; U1.BE8 v1(223.55,151.34) ; U1.BN19 v1(212.55,159.34) ; U1.CF10 v1(221.55,172.34) ; U1.BM12 v1(219.55,158.34) ; U1.AY53 v1(177.55,146.34) ; U1.M21 v1(210.55,117.34) ; U1.BJ8 v1(223.55,155.34) ; U1.C15 v1(216.55,108.34) ; U1.P26 v1(205.55,119.34) ; U1.F15 v1(216.55,111.34) ; U1.AA49 v1(181.55,126.34) ; U1.AN6 v1(225.55,138.34) ; U1.BC12 v1(219.55,149.34) ; U1.V9 v1(222.55,123.34) ; U1.D10 v1(221.55,109.34) ; U1.AJ15 v1(216.55,134.34) ; U1.BU52 v1(178.55,163.34) ; U1.BR29 v1(202.55,161.34) ; U1.P33 v1(198.55,119.34) ; U1.BV8 v1(223.55,164.34) ; U1.AP57 v1(173.55,140.34) ; U1.BE47 v1(183.55,151.34) ; v1(215.55,109.34) U1.D16 ; U1.AV8 v1(223.55,144.34) ; U1.F56 174.55,111.34 v1(174.55,111.32) ; U1.BT61 169.55,162.34 v1(169.55,162.29) ; v1(214.55,160.34) U1.BP17 ; U1.BT35 v1(195.55,162.34) ; U1.BR36 v1(194.55,161.34) ; U1.AT10 v1(221.55,142.34) ; U1.BC19 v1(212.55,149.34) ; U1.T15 v1(216.55,121.34) ; U1.U11 v1(220.55,122.34) ; U1.BP32 v1(199.55,160.34) ; U1.AG51 v1(179.55,132.34) ; U1.M26 v1(205.55,117.34) ; U1.CB55 v1(175.55,168.34) ; U1.H59 v1(171.55,113.34) ; U1.AH4 v1(227.55,133.34) ; U1.CD59 v1(171.57,170.32) ; U1.BJ41 v1(189.55,155.34) ; U1.AF1 v1(230.55,131.34) ; U1.AC53 v1(177.55,128.34) ; U1.AA52 v1(178.55,126.34) ; U1.BN48 v1(182.55,159.34) ; v1(215.55,107.34) U1.B16 ; U1.AA53 v1(177.55,126.34) ; U1.BC60 v1(170.55,149.34) ; U1.AJ11 220.07,134.84 v1(220.57,134.34) ; U1.A10 v1(221.55,106.34) ; U1.T12 v1(219.55,121.34) ; U1.BW25 v1(206.55,165.34) ; U1.AE12 v1(219.55,130.34) ; U1.BU38 v1(192.55,163.34) ; U1.CB7 v1(224.55,168.34) ; U1.AC16 v1(215.55,128.34) ; U1.AG53 v1(177.55,132.34) ; U1.AM50 v1(180.55,137.34) ; U1.AL12 v1(219.55,136.34) ; v1(215.55,168.34) U1.CB16 ; U1.BC14 v1(217.55,149.34) ; U1.CD28 v1(203.55,170.34) ; U1.P31 v1(200.55,119.34) ; U1.G12 v1(219.55,112.34) ; U1.BH48 v1(182.55,154.34) ; U1.E52 v1(178.55,110.34) ; U1.V20 v1(211.55,123.34) ; U1.BB52 v1(178.55,148.34) ; U1.CA33 v1(198.55,167.34) ; U1.AR17 v1(214.55,141.34) ; U1.BK3 v1(228.55,156.34) ; U1.BB54 v1(176.55,148.34) ; U1.BW43 v1(187.55,165.34) ; U1.BU50 v1(180.55,163.34) ; U1.BK40 v1(190.55,156.34) ; U1.F9 v1(222.55,111.34) ; U1.AY10 v1(221.55,146.34) ; U1.AA50 v1(180.55,126.34) ; U1.AN8 v1(223.55,138.34) ; U1.BW33 v1(198.55,165.34) ; U1.BF48 v1(182.55,152.34) ; U1.CB54 v1(176.55,168.34) ; U1.BB48 v1(182.55,148.34) ; U1.CE13 v1(218.55,171.34) ; U1.CE57 v1(173.55,171.34) ; U1.AR52 v1(178.55,141.34) ; U1.D18 v1(213.55,109.34) ; U1.AH19 v1(212.55,133.34) ; U1.CE2 v1(229.55,171.34) ; U1.AN48 v1(182.55,138.34) ; U1.CA7 v1(224.55,167.34) ; U1.CD15 v1(216.55,170.34) ; U1.BH40 v1(190.55,154.34) ; U1.C7 v1(224.55,108.34) ; U1.BH47 v1(183.55,154.34) ; U1.G15 v1(216.55,112.34) ; U1.CB11 v1(220.55,168.34)
  TOP w0.254: D435.29 v1(67.66,132.69) ; v1(138.24,124.1) 138.24,124.08 138.11,123.95 138.11,113.15 137.73,112.77 R2224.1 ; R2223.2 v1(382.46,157.86) ; R2194.1 v1(379.39,175) ; v1(379.16,156.84) 378.55,157.45 R3665.1
  TOP w0.279: U1.AE23 v1(208.55,130.34) ; U1.AH26 v1(205.55,133.34) ; U1.BD36 v1(194.55,150.34) ; U1.AV32 v1(199.55,144.34) ; U1.AL43 v1(187.55,136.34) ; U1.BF45 v1(185.55,152.34) ; U1.AC29 v1(202.55,128.34) ; U1.BD30 v1(201.55,150.34) ; U1.BE35 v1(195.55,151.34) ; U1.BC43 v1(187.55,149.34) ; U1.BD35 v1(195.55,150.34) ; U1.BE27 v1(204.55,151.34) ; U1.BF40 v1(190.55,152.34) ; U1.AA29 v1(202.55,126.34) ; U1.AP36 v1(194.55,140.34) ; U1.AE31 v1(200.55,130.34) ; U1.AB36 v1(194.55,127.34) ; U1.AJ23 v1(208.55,134.34) ; U1.AU43 v1(187.55,143.34) ; U1.AB42 v1(188.55,127.34) ; U1.AA37 v1(193.55,126.34) ; U1.AA28 v1(203.55,126.34) ; U1.AR41 v1(189.55,141.34) ; U1.AR39 v1(191.55,141.34) ; U1.AA41 v1(189.55,126.34) ; U1.BB34 v1(196.55,148.34) ; U1.AY40 v1(190.55,146.34) ; U1.AJ27 v1(204.55,134.34) ; U1.AK44 v1(186.55,135.34) ; U1.AB40 v1(190.55,127.34) ; U1.AM22 v1(209.55,137.34) ; U1.AN31 v1(200.55,138.34) ; U1.AJ25 v1(206.55,134.34) ; U1.AY44 v1(186.55,146.34) ; U1.AT42 v1(188.55,142.34) ; U1.BB44 v1(186.55,148.34) ; U1.BF39 v1(191.55,152.34) ; U1.BA43 v1(187.55,147.34) ; U1.AN41 v1(189.55,138.34) ; U1.BF23 v1(208.55,152.34) ; U1.AP40 v1(190.55,140.34) ; U1.AW37 v1(193.55,145.34) ; U1.AE21 v1(210.55,130.34) ; U1.AA23 v1(208.55,126.34) ; U1.AD24 v1(207.55,129.34) ; U1.AJ45 v1(185.55,134.34) ; U1.AG33 v1(198.55,132.34) ; U1.AJ33 v1(198.55,134.34) ; U1.AC37 v1(193.55,128.34) ; U1.AG31 v1(200.55,132.34) ; U1.AU39 v1(191.55,143.34) ; U1.AC32 v1(199.55,128.34) ; U1.AM46 v1(184.55,137.34) ; U1.AK34 v1(196.55,135.34) ; U1.AT30 v1(201.55,142.34) ; U1.AP44 v1(186.55,140.34) ; U1.BB30 v1(201.55,148.34) ; U1.AB28 v1(203.55,127.34) ; U1.AN45 v1(185.55,138.34) ; U1.AU41 v1(189.55,143.34) ; U1.BF31 v1(200.55,152.34) ; U1.AP26 v1(205.55,140.34) ; U1.AC45 v1(185.55,128.34) ; U1.AF38 v1(192.55,131.34) ; U1.AC23 v1(208.55,128.34) ; U1.AM30 v1(201.55,137.34) ; U1.AL27 v1(204.55,136.34) ; U1.AA35 v1(195.55,126.34) ; U1.AH38 v1(192.55,133.34) ; U1.BD33 v1(198.55,150.34) ; U1.BF44 v1(186.55,152.34) ; U1.AF28 v1(203.55,131.34) ; U1.BD38 v1(192.55,150.34) ; U1.AA45 v1(185.55,126.34) ; U1.BC41 v1(189.55,149.34) ; U1.AT24 v1(207.55,142.34) ; U1.AK38 v1(192.55,135.34) ; U1.AA36 v1(194.55,126.34) ; U1.AR27 v1(204.55,141.34) ; U1.AY36 v1(194.55,146.34) ; U1.BB28 v1(203.55,148.34) ; U1.AE29 v1(202.55,130.34) ; U1.AU21 v1(210.55,143.34) ; U1.BE29 v1(202.55,151.34) ; U1.AH22 v1(209.55,133.34) ; U1.AB30 v1(201.55,127.34) ; U1.AP46 v1(184.55,140.34) ; U1.AF46 v1(184.55,131.34) ; U1.AU31 v1(200.55,143.34) ; U1.AG41 v1(189.55,132.34) ; U1.AP42 v1(188.55,140.34) ; U1.AT32 v1(199.55,142.34) ; U1.BB40 v1(190.55,148.34) ; U1.AB46 v1(184.55,127.34) ; U1.AR29 v1(202.55,141.34) ; U1.AN29 v1(202.55,138.34) ; U1.AC31 v1(200.55,128.34) ; U1.AG39 v1(191.55,132.34) ; U1.BB42 v1(188.55,148.34) ; U1.AG45 v1(185.55,132.34) ; U1.AL39 v1(191.55,136.34) ; U1.AB24 v1(207.55,127.34) ; U1.BF27 v1(204.55,152.34) ; U1.AE27 v1(204.55,130.34) ; U1.AL35 v1(195.55,136.34) ; U1.AB26 v1(205.55,127.34) ; U1.AM36 v1(194.55,137.34) ; U1.AN43 v1(187.55,138.34) ; U1.AA33 v1(198.55,126.34) ; U1.AG23 v1(208.55,132.34) ; U1.AP22 v1(209.55,140.34) ; U1.AY38 v1(192.55,146.34) ; U1.BA33 v1(198.55,147.34) ; U1.AN37 v1(193.55,138.34) ; U1.AN21 v1(210.55,138.34) ; U1.AK32 v1(199.55,135.34) ; U1.BB46 v1(184.55,148.34) ; U1.AV30 v1(201.55,144.34) ; U1.AE35 v1(195.55,130.34) ; U1.AY28 v1(203.55,146.34) ; U1.AL41 v1(189.55,136.34) ; U1.AG37 v1(193.55,132.34) ; U1.AV36 v1(194.55,144.34) ; U1.AD46 v1(184.55,129.34) ; U1.AK26 v1(205.55,135.34) ; U1.BC25 v1(206.55,149.34) ; U1.BF38 v1(192.55,152.34) ; U1.AC34 v1(196.55,128.34) ; U1.BF42 v1(188.55,152.34) ; U1.AJ21 v1(210.55,134.34) ; U1.AR21 v1(210.55,141.34) ; U1.AD42 v1(188.55,129.34) ; U1.BD44 v1(186.55,150.34) ; U1.BC29 v1(202.55,149.34) ; U1.AE33 v1(198.55,130.34) ; U1.BA29 v1(202.55,147.34) ; U1.AN23 v1(208.55,138.34) ; U1.BE39 v1(191.55,151.34) ; U1.AE41 v1(189.55,130.34) ; U1.AP34 v1(196.55,140.34) ; U1.AP24 v1(207.55,140.34) ; U1.AJ37 v1(193.55,134.34) ; U1.AF42 v1(188.55,131.34) ; U1.AV40 v1(190.55,144.34) ; U1.AD28 v1(203.55,129.34) ; U1.BB26 v1(205.55,148.34) ; U1.BF28 v1(203.55,152.34) ; U1.AH32 v1(199.55,133.34) ; U1.AH28 v1(203.55,133.34) ; U1.BE34 v1(196.55,151.34) ; U1.AD22 v1(209.55,129.34) ; U1.BA23 v1(208.55,147.34) ; U1.AN39 v1(191.55,138.34) ; U1.BE21 v1(210.55,151.34) ; U1.AC41 v1(189.55,128.34) ; U1.AK42 v1(188.55,135.34) ; U1.BC45 v1(185.55,149.34) ; U1.AW43 v1(187.55,145.34) ; U1.AL45 v1(185.55,136.34) ; U1.AA25 v1(206.55,126.34) ; U1.AW23 v1(208.55,145.34) ; U1.AV42 v1(188.55,144.34) ; U1.AR45 v1(185.55,141.34) ; U1.BC27 v1(204.55,149.34) ; U1.BC31 v1(200.55,149.34) ; U1.BC37 v1(193.55,149.34) ; U1.AM38 v1(192.55,137.34) ; U1.BA39 v1(191.55,147.34) ; U1.AY30 v1(201.55,146.34) ; U1.AC39 v1(191.55,128.34) ; U1.AT38 v1(192.55,142.34) ; U1.AM40 v1(190.55,137.34) ; U1.AA26 v1(205.55,126.34) ; U1.BF25 v1(206.55,152.34) ; U1.AE45 v1(185.55,130.34) ; U1.AW39 v1(191.55,145.34) ; U1.AR37 v1(193.55,141.34) ; U1.AB44 v1(186.55,127.34) ; U1.AC27 v1(204.55,128.34) ; U1.BD22 v1(209.55,150.34) ; U1.AJ35 v1(195.55,134.34) ; U1.AP32 v1(199.55,140.34) ; U1.AA44 v1(186.55,126.34) ; U1.AH44 v1(186.55,133.34) ; U1.AE39 v1(191.55,130.34) ; U1.AB38 v1(192.55,127.34) ; U1.AV28 v1(203.55,144.34) ; U1.AD30 v1(201.55,129.34) ; U1.AW31 v1(200.55,145.34) ; U1.AP30 v1(201.55,140.34) ; U1.AN25 v1(206.55,138.34) ; U1.AH24 v1(207.55,133.34) ; U1.AB22 v1(209.55,127.34) ; U1.AA38 v1(192.55,126.34) ; U1.AY22 v1(209.55,146.34) ; U1.AY24 v1(207.55,146.34) ; U1.BF35 v1(195.55,152.34) ; U1.BE31 v1(200.55,151.34) ; U1.AT46 v1(184.55,142.34) ; U1.BA31 v1(200.55,147.34) ; U1.AD26 v1(205.55,129.34) ; U1.AV46 v1(184.55,144.34) ; U1.AP28 v1(203.55,140.34) ; U1.BC39 v1(191.55,149.34) ; U1.BE23 v1(208.55,151.34) ; U1.AM44 v1(186.55,137.34) ; U1.AF32 v1(199.55,131.34) ; U1.AH40 v1(190.55,133.34) ; U1.AY34 v1(196.55,146.34) ; U1.AV34 v1(196.55,144.34) ; U1.AR43 v1(187.55,141.34) ; U1.BE43 v1(187.55,151.34) ; U1.BE36 v1(194.55,151.34) ; U1.AK28 v1(203.55,135.34) ; U1.AA43 v1(187.55,126.34) ; U1.AC33 v1(198.55,128.34) ; U1.AW35 v1(195.55,145.34) ; U1.AD36 v1(194.55,129.34) ; U1.AT22 v1(209.55,142.34) ; U1.AU29 v1(202.55,143.34) ; U1.BC21 v1(210.55,149.34) ; U1.AD40 v1(190.55,129.34) ; U1.AC35 v1(195.55,128.34) ; U1.AF26 v1(205.55,131.34) ; U1.AA27 v1(204.55,126.34) ; U1.AY26 v1(205.55,146.34) ; U1.AL31 v1(200.55,136.34) ; U1.AK22 v1(209.55,135.34) ; U1.BF43 v1(187.55,152.34) ; U1.AD38 v1(192.55,129.34) ; U1.BF24 v1(207.55,152.34) ; U1.AA39 v1(191.55,126.34) ; U1.AN27 v1(204.55,138.34) ; U1.AW45 v1(185.55,145.34) ; U1.BE25 v1(206.55,151.34) ; U1.AH46 v1(184.55,133.34) ; U1.AW27 v1(204.55,145.34) ; U1.BB24 v1(207.55,148.34) ; U1.AA46 v1(184.55,126.34) ; U1.AN33 v1(198.55,138.34) ; U1.AU27 v1(204.55,143.34) ; U1.BF41 v1(189.55,152.34) ; U1.AG29 v1(202.55,132.34) ; U1.BF30 v1(201.55,152.34) ; U1.AK36 v1(194.55,135.34) ; U1.AH30 v1(201.55,133.34) ; U1.AA30 v1(201.55,126.34) ; U1.AV22 v1(209.55,144.34) ; U1.AP38 v1(192.55,140.34) ; U1.AN35 v1(195.55,138.34) ; U1.BE37 v1(193.55,151.34) ; U1.BA25 v1(206.55,147.34) ; U1.AT34 v1(196.55,142.34) ; U1.AG27 v1(204.55,132.34) ; U1.AJ31 v1(200.55,134.34) ; U1.AL23 v1(208.55,136.34) ; U1.AV38 v1(192.55,144.34) ; U1.BA37 v1(193.55,147.34) ; U1.AU35 v1(195.55,143.34) ; U1.AM42 v1(188.55,137.34) ; U1.AA31 v1(200.55,126.34) ; U1.BF22 v1(209.55,152.34) ; U1.AK30 v1(201.55,135.34) ; U1.BD28 v1(203.55,150.34) ; U1.AJ29 v1(202.55,134.34) ; U1.AM26 v1(205.55,137.34) ; U1.AA21 v1(210.55,126.34) ; U1.AR23 v1(208.55,141.34) ; U1.BB38 v1(192.55,148.34) ; U1.BB36 v1(194.55,148.34) ; U1.AG25 v1(206.55,132.34) ; U1.AF34 v1(196.55,131.34) ; U1.AA22 v1(209.55,126.34) ; U1.BB32 v1(199.55,148.34) ; U1.BF29 v1(202.55,152.34) ; U1.AF36 v1(194.55,131.34) ; U1.AG43 v1(187.55,132.34) ; U1.AT44 v1(186.55,142.34) ; U1.AJ41 v1(189.55,134.34) ; U1.AJ43 v1(187.55,134.34) ; U1.BD32 v1(199.55,150.34) ; U1.AF44 v1(186.55,131.34) ; U1.AG21 v1(210.55,132.34) ; U1.BD46 v1(184.55,150.34) ; U1.BA45 v1(185.55,147.34) ; U1.AM34 v1(196.55,137.34) ; U1.AU37 v1(193.55,143.34) ; U1.AC21 v1(210.55,128.34) ; U1.AG35 v1(195.55,132.34) ; U1.AL25 v1(206.55,136.34) ; U1.AY42 v1(188.55,146.34) ; U1.AF30 v1(201.55,131.34) ; U1.BB35 v1(195.55,148.34) ; U1.AR31 v1(200.55,141.34) ; U1.AY46 v1(184.55,146.34) ; U1.AV44 v1(186.55,144.34) ; U1.BD26 v1(205.55,150.34) ; U1.BF32 v1(199.55,152.34) ; U1.BF21 v1(210.55,152.34) ; U1.AK40 v1(190.55,135.34) ; U1.AV24 v1(207.55,144.34) ; U1.AV26 v1(205.55,144.34) ; U1.AK46 v1(184.55,135.34) ; U1.BD42 v1(188.55,150.34) ; U1.AT28 v1(203.55,142.34) ; U1.AH42 v1(188.55,133.34) ; U1.AJ39 v1(191.55,134.34) ; U1.BA41 v1(189.55,147.34) ; U1.AL29 v1(202.55,136.34) ; U1.AC43 v1(187.55,128.34) ; U1.AF22 v1(209.55,131.34) ; U1.BE45 v1(185.55,151.34) ; U1.AF24 v1(207.55,131.34) ; U1.AT40 v1(190.55,142.34) ; U1.AA34 v1(196.55,126.34) ; U1.AK24 v1(207.55,135.34) ; U1.BC33 v1(198.55,149.34) ; U1.AW25 v1(206.55,145.34) ; U1.AT26 v1(205.55,142.34) ; U1.BA21 v1(210.55,147.34) ; U1.AE43 v1(187.55,130.34) ; U1.AE25 v1(206.55,130.34) ; U1.AW29 v1(202.55,145.34) ; U1.AD44 v1(186.55,129.34) ; U1.AY32 v1(199.55,146.34) ; U1.AT36 v1(194.55,142.34) ; U1.AR25 v1(206.55,141.34) ; U1.AU33 v1(198.55,143.34) ; U1.BF26 v1(205.55,152.34) ; U1.BA27 v1(204.55,147.34) ; U1.AL37 v1(193.55,136.34) ; U1.AA42 v1(188.55,126.34) ; U1.AU23 v1(208.55,143.34) ; U1.AA40 v1(190.55,126.34) ; U1.AU45 v1(185.55,143.34) ; U1.BD24 v1(207.55,150.34) ; U1.BE33 v1(198.55,151.34) ; U1.AH34 v1(196.55,133.34) ; U1.AH36 v1(194.55,133.34) ; U1.AL33 v1(198.55,136.34) ; U1.AW21 v1(210.55,145.34) ; U1.AA24 v1(207.55,126.34) ; U1.AL21 v1(210.55,136.34) ; U1.AA32 v1(199.55,126.34) ; U1.AM28 v1(203.55,137.34) ; U1.AU25 v1(206.55,143.34) ; U1.AW41 v1(189.55,145.34) ; U1.BD40 v1(190.55,150.34) ; U1.AC25 v1(206.55,128.34) ; U1.BC23 v1(208.55,149.34) ; U1.BC35 v1(195.55,149.34) ; U1.AW33 v1(198.55,145.34) ; U1.BF37 v1(193.55,152.34) ; U1.AM24 v1(207.55,137.34) ; U1.BB22 v1(209.55,148.34) ; U1.AE37 v1(193.55,130.34) ; U1.AM32 v1(199.55,137.34) ; U1.AR35 v1(195.55,141.34) ; U1.AF40 v1(190.55,131.34) ; U1.BE41 v1(189.55,151.34)
  TOP w0.305: v1(47.18,95.78) 47.82,96.42 U11.12 ; v1(15.94,90.8) 15.68,90.8 15.15,91.34 U12.12 ; U10.12 415.32,119.54 415.73,119.12 v1(415.73,119) ; U18.12 v1(415.64,106.96)
  TOP w0.33: U84.25 v1(406.37,90.17)
  TOP w0.381: v1(385.13,112.01) v1(385.13,110.87) v1(385.13,109.73) 385.13,107.31 385.51,106.93 R3603.2 ; X255.1 387.92,202.18 389.19,200.91 R3509.2 ; C3071.2 148.12,112.37 ; C3071.2 148.6,111.88 ; C3071.2 148.12,111.4 ; R3587.2 32.58,128.27 32.96,128.65 v1(35.37,128.65) v1(36.51,128.65) v1(37.66,128.65) ; C2063.2 v1(402.27,78.23) ; R2704.1 123.74,84.68 123.93,84.49 v1(123.93,84.06) ; C3136.2 153,105.38 ; C3136.2 153,104.42 ; C3136.2 152.51,104.9 ; 321.75,90.04 C2567.1 ; C2567.1 320.97,90.78 ; C2567.1 320.97,89.3 ; C3010.2 176.59,186.66 ; C3010.2 176,186.03 ; C3010.2 177.19,186.03 ; C2792.2 142.84,100.94 ; C2792.2 142.84,99.97 ; C2792.2 142.35,100.45 ; C2309.1 111.32,90.04 ; C2309.1 112.23,90.78 ; C2309.1 112.23,89.3 ; R2703.1 137.2,84.68 137.35,84.83 137.35,85.34 v1(136.59,86.1) ; 252.18,127.02 C2829.2 ; C2829.2 251.7,127.51 ; C2829.2 252.18,127.99 ; C3880.2 347.83,137.05 v1(348.34,137.56) ; v1(354.31,183.16) C3914.2 354.99,183.8 ; C2166.2 31.31,90.42 ; C2166.2 32.09,89.81 ; C2166.2 32.09,91.03 ; C2416.1 223.86,84.6 ; C2416.1 223.86,86.13 ; C2416.1 222.95,85.47 ; C3857.2 68.26,179.58 v1(67.75,179.07) ; C3173.2 217.72,178.84 ; C3173.2 217.23,178.36 ; C3173.2 216.75,178.84 ; v1(240.06,132.36) 240.11,132.31 C3128.2 ; v1(30.29,96.26) C2207.2 ; R3489.1 v1(57.34,79.5) ; C2492.2 281.65,84.43 ; C2510.1 250.41,89.3 ; C2510.1 250.41,90.7 ; C2510.1 249.75,90.04 ; C2832.2 158.03,132.36 ; C2832.2 157.16,131.44 ; C2832.2 156.43,132.36 ; C2334.1 126.91,78.89 ; C2334.1 127.7,79.63 ; C2334.1 126.91,80.36 ; U121.4 v1(203.42,196.06) ; C2485.1 268.06,84.73 ; C2485.1 268.06,86.21 ; C2485.1 267.27,85.47 ; 279.08,85.47 C2483.1 ; C2483.1 278.3,84.73 ; C2483.1 278.3,86.21 ; 152.51,107.19 C2934.2 ; C2934.2 153,106.7 ; C2934.2 153,107.67 ; C2984.2 164.66,186.66 ; C2984.2 164.06,186.03 ; C2984.2 165.25,186.03 ; v1(60.29,156.31) C3822.2 ; C2453.1 210.66,84.73 ; C2453.1 210.66,86.13 ; C2453.1 209.99,85.47 ; C2402.2 187.67,78.59 ; C2250.1 64.71,79.63 ; C2250.1 63.92,78.89 ; C2250.1 63.92,80.36 ; C2954.2 153,103.1 ; C2954.2 152.51,102.61 ; C2954.2 153,102.13 ; C2727.2 183.73,101.83 ; C2727.2 182.94,101.22 ; C2727.2 183.73,100.48 ; v1(213.8,200.02) 213.8,200.31 214.13,200.63 C3058.2 ; 48.53,117.8 C3688.2 49.14,118.44 ; v1(52.51,85.21) 52.77,84.96 C2178.2 ; C2271.1 78.04,85.47 ; C2271.1 77.13,84.73 ; C2271.1 77.13,86.21 ; v1(226.63,78.86) 227.5,78.86 R2759.2 ; C277.2 157.9,157.38 ; C277.2 157.16,156.59 ; C277.2 156.43,157.38 ; v1(210.12,191.89) 210.15,191.92 C3106.2 211.14,191.26 ; Q46.2 v1(31.88,142.62) ; C2957.2 151.32,127.73 151.22,127.84 v1(150.91,127.84) ; R3610.2 v1(49.54,142.34) ; C3611.2 C3610.2 275.78,211.58 v1(275.91,211.71) ; C3611.2 274.51,211.45 v1(274.76,211.71) ; C3611.2 C3609.2 ; R2880.2 R2902.2 376.62,79.47 v1(376.64,79.5) ; C2932.2 238.53,123.34 ; C2932.2 237.93,122.7 ; C2932.2 237.34,123.34 ; C2251.2 63.67,78.59 ; C2549.1 301.28,78.89 ; C2549.1 301.28,80.36 ; C2549.1 302.07,79.63 ; R3452.1 v1(242.51,85.98) ; C3099.2 196.56,100.48 ; C3099.2 196.56,101.95 ; C3099.2 195.77,101.22 ; C2410.1 232.63,90.7 ; C2410.1 231.97,90.04 ; C2410.1 232.63,89.3 ; D394.3 378.86,47.99 v1(378.85,48) ; C2433.1 237.2,84.73 ; C2433.1 236.54,85.47 ; C2433.1 237.2,86.13 ; R3391.1 v1(400.88,193.42) ; C2860.2 181.7,198.73 v1(181.42,199.01) ; C3482.2 v1(89.34,201.67) ; 252.54,85.47 C2517.1 ; C2517.1 251.88,84.81 ; C2517.1 251.88,86.21 ; D429.3 v1(390.65,63.69) ; v1(412.32,61.43) 411.92,61.03 R3405.1 ; C2227.1 66.89,86.21 ; C2227.1 66.1,85.47 ; C2227.1 66.89,84.73 ; C2647.1 386.52,92.71 ; C2647.1 385.74,92.05 ; C2647.1 385.74,93.32 ; 89.98,78.61 89.22,77.85 C2214.2 ; C3457.2 288.89,209.14 ; C2462.2 220.64,78.59 ; v1(251.05,97.03) 251.54,97.51 C2404.2 C2411.2 ; C3487.2 v1(87.31,201.67) ; C2275.1 118.15,89.3 ; C2275.1 119.06,90.04 ; C2275.1 118.15,90.78 ; v1(274,91.82) C2506.2 C2502.2 ; C3937.2 v1(373.09,160.75) ; v1(292.37,198.85) 292.8,198.42 C3434.2 ; v1(6.67,86.23) 7.71,86.23 C2159.1 7.71,87.25 v1(6.67,87.25) ; 257.11,94.61 C2469.1 ; C2469.1 256.45,93.95 ; C2469.1 256.45,95.35 ; C2343.1 184.32,78.89 ; C2343.1 184.32,80.36 ; C2343.1 185.23,79.63 ; v1(379.67,160.78) C3940.2 378.65,161.44 R3663.2 ; C3732.2 396.23,150.44 ; C3732.2 395.54,149.86 ; C3732.2 C3730.2 ; 171.11,84.55 C2395.1 171.84,85.47 ; R3369.1 398.13,60.88 v1(398.38,61.13) ; 236.25,137.06 C83.2 235.65,136.42 ; R3484.1 339.28,79.24 v1(338.97,79.55) ; C3645.1 374.84,215.52 ; C3645.1 375.5,216.18 ; C3645.1 C3644.2 ; C7.1 C8.1 180.94,187.3 v1(180.66,187.58) ; R2664.1 73.88,85.09 v1(74.23,85.09) ; C351.2 221.37,200.63 221.04,200.31 v1(221.04,200.02) ; 316.52,78.89 C2593.1 ; C2593.1 317.31,79.63 ; C2593.1 316.52,80.36 ; 183.73,98.19 C2969.2 ; C2969.2 183.73,99.67 ; C2969.2 182.94,98.93 ; C3647.2 271.49,216.94 v1(271.08,216.53) ; 239.62,161.57 C2785.2 ; C2785.2 240.82,161.57 ; C2785.2 240.22,160.93 ; 142.84,95.4 C2789.2 ; C2789.2 142.35,95.88 ; C2789.2 142.84,96.37 ; C2575.1 304.25,78.89 ; C2575.1 304.25,80.36 ; C2575.1 303.47,79.63 ; C2826.2 252.18,132.56 ; C2826.2 252.18,131.59 ; C2826.2 251.7,132.08 ; v1(150.74,139.55) 150.99,139.8 C3174.2 ; C2499.1 276.82,90.78 ; C2499.1 276.82,89.3 ; C2499.1 276.03,90.04 ; v1(237.85,48) 237.86,47.99 D376.3 ; v1(7.61,127.96) C3653.1 6.79,126.87 v1(6.54,127.12) ; C2603.1 380.28,82.9 ; C2603.1 380.28,81.43 ; C2603.1 381.06,82.17 ; C3443.2 C3445.2 295.92,206.22 v1(296.56,206.86) ; v1(400.09,211.12) 400.09,211.12 C3511.2 ; C3510.2 v1(401.28,211.12) ; 217.83,191.92 C2929.2 216.64,191.92 ; C631.2 243.17,107.13 ; C631.2 242.38,106.54 ; C631.2 242.38,107.73 ; v1(69.65,85.46) 69.65,84.97 69.94,84.68 R2634.1 ; C3948.2 375.02,173.81 v1(374.71,174.11) ; 208.72,191.28 C2991.2 ; C2991.2 209.32,191.92 ; C2991.2 208.13,191.92 ; v1(229.81,177.39) 230.14,177.06 C221.2 ; 11.75,76.32 C2149.1 12.66,75.59 ; C3105.2 249.19,118.36 ; C3105.2 248.7,117.88 ; C3105.2 248.7,118.84 ; C3523.1 v1(15.33,147.34) ; C2503.1 251.88,80.36 ; C2503.1 252.54,79.63 ; C2503.1 251.88,78.97 ; 330.52,79.63 C2576.1 ; C2576.1 329.73,78.89 ; C2576.1 329.73,80.36 ; C91.2 185.48,180.59 ; C91.2 184.75,179.8 ; C91.2 186.22,179.8 ; C2272.2 76.87,84.43 ; C2259.1 63.92,84.73 ; C2259.1 64.71,85.47 ; C2259.1 63.92,86.21 ; R2904.1 R2900.1 v1(380.53,78.84) ; C2161.1 31.97,97.3 ; C2161.1 31.18,98.04 ; C2161.1 31.97,98.78 ; C3426.2 288.89,213.84 v1(288.86,213.87) ; C3043.2 165.29,193.01 ; C3043.2 164.69,192.38 ; C3043.2 165.89,192.38 ; C2861.2 252.18,123.42 ; C2861.2 251.7,122.93 ; C2861.2 252.18,122.45 ; 237.34,161.57 C3097.2 ; C3097.2 237.93,160.93 ; C3097.2 238.53,161.57 ; R3444.1 v1(335.47,78.84) ; C2358.1 160.87,86.21 ; C2358.1 159.96,85.47 ; C2358.1 160.87,84.73 ; v1(210.12,200.02) 210.73,200.63 C2868.2 ; D92.2 v1(410.27,54.73) ; C2657.2 362.24,78.59 ; C2625.1 365.47,78.89 ; C2625.1 365.47,80.36 ; C2625.1 364.68,79.63 ; 380.2,198.47 C3612.2 380.94,199.26 ; R3617.2 v1(49.54,162.66) ; C2643.1 349.29,86.21 ; C2643.1 349.29,84.73 ; C2643.1 350.08,85.47 ; C2858.2 214.95,101.22 ; C2858.2 215.61,101.95 ; C2858.2 215.61,100.61 ; 185.23,85.47 C2355.1 ; C2355.1 184.32,86.21 ; C2355.1 184.32,84.73 ; 226.38,186.86 C2823.2 ; C2823.2 226.86,187.35 ; C2823.2 225.89,187.35 ; 318.71,85.47 C2565.1 ; C2565.1 319.49,86.21 ; C2565.1 319.49,84.73 ; R2622.2 53.18,87.73 v1(52.13,88.77) ; R2678.2 133.54,80.16 v1(134.79,81.4) ; D427.2 v1(40.32,175.77) ; v1(268.19,48.64) 268.19,48.59 268.65,48.13 D389.3 ; C2656.1 363.28,79.63 ; C2656.1 362.5,78.89 ; C2656.1 362.5,80.36 ; 12.26,80.39 C2198.2 12.92,81.13 ; v1(231.33,85.09) 230.98,85.09 R2775.2 ; 387.92,212.52 C108.2 ; R222.1 v1(410.2,129.16) ; C79.2 176.72,193.01 ; C79.2 176.12,192.38 ; C79.2 177.32,192.38 ; C2572.1 335.09,90.04 ; C2572.1 334.3,89.3 ; C2572.1 334.3,90.78 ; R2641.1 83.76,85.47 82.99,86.23 v1(82.87,86.23) ; 20.84,110.82 C3680.2 21.45,111.45 ; C3083.2 179.39,180.59 ; C3083.2 178.78,179.8 ; C3083.2 180.12,179.8 ; C2590.2 v1(331.05,77.19) ; 242.51,136.42 C2699.2 ; C2699.2 243.1,137.06 ; C2699.2 241.91,137.06 ; C2518.2 251.63,84.43 ; C2465.1 237.2,80.29 ; C2465.1 237.2,78.89 ; C2465.1 236.54,79.63 ; v1(414.46,170.56) C3593.1 ; R2668.1 v1(122.24,79.5) ; 142.3,79.63 C2337.1 ; C2337.1 143.22,80.36 ; C2337.1 143.22,78.89 ; C3508.2 v1(396.96,211.12) ; R2803.1 R2824.1 v1(273.75,85.34) ; v1(154.19,137.16) 153.71,136.67 C3196.2 ; 124.8,90.04 C2307.1 ; C2307.1 125.44,89.44 ; C2307.1 125.44,90.64 ; R3469.1 v1(55.94,79.5) ; v1(70.17,80.39) 70.68,79.88 70.68,79.09 R2633.2 ; 352.26,86.21 C2613.1 ; C2613.1 351.47,85.47 ; C2613.1 352.26,84.73 ; v1(27.78,101.7) 27.39,102.08 C2147.1 ; R8.2 167.35,100.48 v1(167.58,100.71) ; R3465.1 59.75,83.97 v1(59.75,83.69) ; C2331.1 143.22,86.21 ; C2331.1 143.22,84.73 ; C2331.1 142.3,85.47 ; C2233.1 79.18,85.47 ; C2233.1 80.1,86.21 ; C2233.1 80.1,84.73 ; C2435.1 225.34,90.78 ; C2435.1 225.34,89.25 ; C2435.1 226.12,90.04 ; 235.05,149.37 C2687.2 ; C2687.2 236.25,149.37 ; C2687.2 235.65,148.74 ; v1(391.1,220.22) 391.3,220.01 J35.18 ; 144.69,89.44 C2318.1 ; C2318.1 145.33,90.04 ; C2318.1 144.69,90.64 ; 280.61,79.63 C2493.1 ; C2493.1 281.39,78.89 ; C2493.1 281.39,80.36 ; C2332.1 127.83,85.47 ; C2332.1 126.91,86.21 ; C2332.1 126.91,84.73 ; R2820.1 v1(273.75,89.41) ; v1(364.78,138.71) 364.76,138.68 R3632.2 ; C3506.2 408.72,211.12 v1(408.73,211.12) ; C114.1 v1(264.6,181.89) ; C2584.2 297.47,84.68 v1(298.26,85.47) ; C2511.2 217.87,91.95 ; v1(392.75,98.8) 392.75,98.42 392.47,98.14 U122.4 ; v1(401.38,98.42) 401.36,98.4 R3250.2 R3249.2 ; R314.2 267.09,182.55 v1(267.02,182.62) ; U14.4 v1(269.46,171.98) ; 12.36,74.55 C2150.2 12.92,75.28 ; v1(267.91,211.07) 267.68,211.3 R1193.1 ; C2528.1 265.09,78.89 ; C2528.1 265.87,79.63 ; C2528.1 265.09,80.36 ; R3487.1 v1(248.09,79.5) ; v1(398.59,220.22) 398.97,220.22 399.3,219.89 J35.10 ; C3509.2 v1(392.65,211.12) ; v1(298.72,198.85) 299.38,199.51 C3429.2 ; C3004.2 252.18,134.85 ; C3004.2 251.7,134.36 ; C3004.2 252.18,133.88 ; v1(225.11,96.42) 224.83,96.14 C3001.2 ; C21.2 403.64,193.77 v1(403.29,193.42) ; C3028.2 238.53,149.37 ; C3028.2 237.93,148.74 ; C3028.2 237.34,149.37 ; 196.56,97.25 C2665.2 ; C2665.2 195.77,96.64 ; C2665.2 196.56,96.03 ; 48.45,79.63 C2209.1 49.24,78.89 ; R2798.2 258.38,79.37 258.13,79.63 v1(257.62,79.63) ; 131.36,89.44 C2287.1 ; C2287.1 131.99,90.04 ; C2287.1 131.36,90.64 ; 170.79,192.38 C2840.2 171.39,193.01 ; 307.91,85.6 C2585.1 ; C2585.1 308.7,84.86 ; C2585.1 308.7,86.33 ; C2470.2 278.98,92.86 v1(279.59,93.47) ; R13.1 v1(257.62,182.75) ; R3238.1 390.26,212.44 ; v1(53.53,86.03) 53.53,85.98 54.19,85.32 R2619.2 ; C2206.1 28.87,97.3 ; C2206.1 28.87,98.78 ; C2206.1 29.65,98.04 ; C2234.2 80.35,84.43 ; R2644.1 R2661.1 v1(72.45,89.41) ; C3451.2 295.95,207.11 296.23,207.39 ; J34.10 v1(39.31,186.69) ; 349.29,78.89 C2631.1 350.08,79.63 ; v1(392.14,189.84) 391.78,189.48 Q42.2 ; 9.44,75.28 C2196.2 10.04,74.55 ; C2213.1 90.34,80.36 ; C2213.1 91.25,79.63 ; C2213.1 90.34,78.89 ; C3821.2 v1(49.54,158.85) ; v1(58.79,104.49) 58.79,104.24 58.26,103.71 R241.1 ; R21.1 v1(228.54,99.18) ; C2527.2 264.83,84.43 ; C2406.1 206.21,89.3 ; C2406.1 205.3,90.04 ; C2406.1 206.21,90.78 ; C3444.2 297.07,206.3 ; C3137.2 155.47,118.39 ; C3137.2 154.88,117.75 ; C3137.2 154.28,118.39 ; C3609.2 273.24,211.45 ; C3609.2 272.5,210.79 ; v1(218.8,48) 218.81,47.99 D369.3 ; v1(267.14,169.03) 266.87,169.31 R308.1 R310.1 ; v1(234.99,146.12) 235.09,146.02 C82.2 ; v1(150.43,154.18) 150.79,154.18 150.81,154.15 C2781.2 ; C3949.2 373.85,174.27 v1(374.71,175.13) ; 365.57,113.92 C3622.2 366.36,113.18 ; R33.2 v1(202.15,204.34) ; C3479.2 v1(42.1,163.7) ; C2605.1 388.84,83.84 ; C2605.1 388.84,85.32 ; C2605.1 388.05,84.58 ; C3627.2 363.79,111.76 v1(364.3,112.27) ; C3627.2 363.51,111.15 ; C3627.2 C3628.1 ; C2215.1 74.87,90.04 ; C2215.1 75.65,90.78 ; C2215.1 75.65,89.3 ; C2749.2 142.33,132.02 ; C2749.2 142.33,130.79 ; C2749.2 141.41,131.44 ; 367.45,83.97 C2633.1 ; C2633.1 367.45,85.44 ; C2633.1 368.24,84.71 ; C2345.1 169.63,89.3 ; C2345.1 168.72,90.04 ; C2345.1 169.63,90.78 ; C496.2 151.54,117.5 ; C496.2 150.34,117.5 ; C496.2 150.94,116.86 ; C3608.2 C3605.2 275.4,212.85 ; C3608.2 274.26,212.85 ; C3608.2 273.65,213.51 ; 241.74,207.39 C308.2 C307.2 242.89,207.52 ; D374.3 221.65,48.13 221.19,48.59 v1(221.19,48.64) ; 141.03,85.47 C2320.1 ; C2320.1 140.12,86.21 ; C2320.1 140.12,84.73 ; 138.65,89.44 C2279.1 ; C2279.1 138.01,90.04 ; C2279.1 138.65,90.64 ; C2621.2 385.48,77.7 ; v1(67.88,138.55) 68.39,139.06 C3811.2 ; v1(395.77,211.12) 395.77,211.12 C3512.2 ; C2898.2 157.76,118.39 ; C2898.2 156.57,118.39 ; C2898.2 157.16,117.75 ; C2611.1 385.74,85.19 ; C2611.1 385.74,83.84 ; C2611.1 386.52,84.58 ; C604.2 243.02,105.62 ; C604.2 242.38,106.22 ; C604.2 242.38,105.02 ; 160.46,83.69 C2359.2 161.13,84.43 ; C3618.1 v1(380.3,200.53) ; C3618.1 380.96,201.32 ; C3618.1 C3617.2 ; C2425.1 223.86,80.29 ; C2425.1 223.2,79.63 ; C2425.1 223.86,78.89 ; C523.2 150.3,134.47 ; C523.2 149.71,133.83 ; C523.2 150.9,133.83 ; C2371.1 188.89,90.78 ; C2371.1 189.8,90.04 ; C2371.1 188.89,89.3 ; C349.2 215.43,191.92 v1(215.71,191.64) ; v1(395.97,25.96) C14.2 v1(397.07,24.76) ; C2412.1 207.68,84.73 ; C2412.1 207.68,86.21 ; C2412.1 208.6,85.47 ; C2563.1 314.26,90.04 ; C2563.1 315.05,90.78 ; C2563.1 315.05,89.3 ; R3475.1 v1(245.43,85.98) ; C2638.1 383.48,97.28 ; C2638.1 384.26,96.54 ; C2638.1 384.26,97.89 ; C2628.2 355.18,88.54 355.66,89.02 v1(356.65,89.02) ; R3471.1 v1(246.7,85.98) ; 208.09,77.85 C2452.2 207.43,78.59 ; C2223.1 80.1,78.89 ; C2223.1 80.1,80.36 ; C2223.1 79.18,79.63 ; C2570.1 301.03,84.86 ; C2570.1 301.82,85.6 ; C2570.1 301.03,86.33 ; J35.13 395.3,220.46 v1(395.54,220.22) ; C2297.1 129.88,78.89 ; C2297.1 129.88,80.36 ; C2297.1 129.1,79.63 ; v1(153.86,127.76) 153.84,127.73 C2719.2 ; v1(288.81,207.24) 289.19,206.86 C3453.2 ; 186.5,79.63 C2399.1 ; C2399.1 187.41,80.36 ; C2399.1 187.41,78.89 ; C3839.2 v1(64.5,163.04) 64.4,163.04 63.3,164.14 57.53,164.14 ; C2843.2 v1(206.18,96.14) ; v1(203.26,204.34) 203.42,204.19 R3244.2 ; Q57.2 v1(375.66,106.24) ; R2597.2 40.32,79.25 v1(40.7,79.63) ; X257.1 362.65,120.9 363.92,122.17 R3513.1 ; R2640.2 82.97,78.84 v1(82.87,78.74) ; R3534.2 v1(281.55,216.28) ; C3470.2 299.91,208.28 ; v1(120.05,88.52) 120.71,87.86 R2683.1 R2701.1 ; R3490.1 v1(152.72,79.5) ; C3077.2 196.56,99.67 ; C3077.2 196.56,98.19 ; C3077.2 195.77,98.93 ; C3454.2 296.13,208.25 ; C3802.2 v1(60.24,140.05) ; 354.31,144.06 v1(354.31,142.77) 354.74,142.77 C3868.2 ; R3474.1 v1(149.92,85.98) ; 48.45,84.2 C2173.1 49.24,84.94 ; R3574.1 v1(31.59,134.01) ; C2526.1 265.09,86.21 ; C2526.1 265.87,85.47 ; C2526.1 265.09,84.73 ; C2392.2 165.32,89.94 ; C2392.2 165.32,91.41 ; C2392.2 164.4,90.68 ; v1(60.39,180.72) 60.36,180.69 C3848.2 ; 46.14,78.89 C2157.1 46.93,79.63 ; C3635.2 143.8,213.26 ; C3635.2 143.19,212.72 ; C3635.2 142.58,213.26 ; C3471.2 299.91,209.42 ; 310.3,89.43 C2537.1 ; C2537.1 310.3,90.9 ; C2537.1 311.09,90.17 ; R3499.1 340.68,79.12 v1(341.06,79.5) ; C2548.2 v1(306.13,83.82) ; R2881.2 v1(345.63,79.5) ; C2400.1 171.11,78.89 ; C2400.1 172.02,79.63 ; C2400.1 171.11,80.36 ; v1(64.07,169.06) 64.22,168.91 v1(67.25,168.91) 67.75,169.42 C3855.2 ; C3476.2 44.34,159.57 44.66,159.89 v1(45.15,159.89) ; v1(223.58,192.28) 223.94,191.92 C2940.2 ; 22.7,111.48 C3679.2 ; 283.65,90.04 C2467.1 ; C2467.1 282.87,89.3 ; C2467.1 282.87,90.78 ; v1(400.67,102.74) C3520.1 R3245.2 ; X259.1 152.21,214.12 153.25,213.08 153.25,211.33 ; C3517.2 32.19,174.5 v1(31.69,175) ; v1(167.58,98.04) 167.22,97.69 R2042.2 ; 162.34,96.3 C2377.1 ; C2377.1 162.34,97.5 ; C2377.1 162.98,96.9 ; C3440.2 301.66,204.37 v1(302.07,203.96) ; C2617.1 371.18,83.28 370.9,83.56 ; C2617.1 371.92,84.07 ; C2617.1 372.66,83.28 ; C2329.1 140.12,80.36 ; C2329.1 140.12,78.89 ; C2329.1 141.03,79.63 ; v1(379.11,133.19) 379.11,133.43 379.33,133.65 C3700.1 380.17,132.97 379.46,132.25 v1(379.08,132.25) ; R3317.2 v1(33.08,171.45) ; 24.4,110.82 C3681.2 23.81,111.5 ; C2397.1 187.41,84.73 ; C2397.1 186.5,85.47 ; C2397.1 187.41,86.21 ; R3443.1 v1(242.51,79.5) ; 317.31,85.47 C2591.1 ; C2591.1 316.52,84.73 ; C2591.1 316.52,86.21 ; C2417.2 207.43,84.43 ; R3569.2 v1(375.37,109.09) ; v1(153.99,174.96) 154.01,174.99 C3122.2 ; 332.83,80.36 C2589.1 332.04,79.63 ; 31.97,91.34 C2165.1 31.18,92.2 ; 254.19,79.63 C2507.1 ; C2507.1 254.85,78.89 ; C2507.1 254.85,80.29 ; R2045.2 v1(178.37,100.71) C3030.2 ; C2854.1 v1(181.55,192.28) ; C2473.1 256.32,89.38 ; C2473.1 256.98,90.04 ; C2473.1 256.32,90.78 ; C2752.2 216.83,200.63 v1(216.22,200.02) ; D391.3 96.86,47.99 v1(96.85,48) ; 237.17,92.45 C2403.1 ; C2403.1 236.51,91.79 ; C2403.1 236.51,93.19 ; C2763.2 v1(187.52,190.78) ; 221.46,191.92 C3162.2 222.66,191.92 ; C2418.2 224.12,84.43 ; C2790.2 142.84,94.08 ; C2790.2 142.84,93.11 ; C2790.2 142.35,93.6 ; v1(181.69,85.1) 181.46,85.1 181.04,84.68 R2742.1 ; 395.97,126.44 C3721.2 395.29,125.85 ; J35.4 v1(405.3,215.84) ; J33.10 v1(19.37,199.64) ; C3507.2 404.41,211.12 v1(404.41,211.12) ; C119.2 v1(424.24,116.58) ; C3066.2 v1(173.29,189.74) ; J35.25 v1(382.45,222.35) ; v1(213.68,79.5) 213.68,79.35 R2752.1 ; C2381.1 162.98,92.33 ; C2381.1 162.34,91.73 ; C2381.1 162.34,92.92 ; 287.97,85.47 C2544.1 ; C2544.1 287.19,84.73 ; C2544.1 287.19,86.21 ; C2405.1 234.1,80.36 ; C2405.1 234.76,79.63 ; C2405.1 234.1,78.97 ; C3075.2 148.6,114.17 ; C3075.2 148.12,113.69 ; C3075.2 148.12,114.65 ; v1(181.85,177.06) 181.29,177.62 C90.2 ; v1(331.85,48) 331.86,47.99 D377.3 ; R2801.1 v1(272.73,89.41) ; v1(348.85,147.72) 348.72,147.72 348.21,147.21 C3878.2 ; 142.33,129.58 C2726.2 141.54,129.03 ; 300.8,78.61 300.29,78.61 299.89,78.2 C2550.2 ; C2236.2 93.69,84.43 ; C2808.2 172.12,184.81 171.64,185.29 v1(171.64,185.37) ; C2595.1 390.31,89.76 ; C2595.1 390.31,88.41 ; C2595.1 391.1,89.15 ; R3591.1 v1(381.37,105.94) ; v1(167.07,183.31) 166.43,183.94 C2776.2 ; R3594.1 v1(381.6,129.94) ; 155.61,132.36 C2801.2 154.27,132.36 ; C2451.1 207.68,78.89 ; C2451.1 207.68,80.36 ; C2451.1 208.6,79.63 ; Q41.3 v1(36.89,171.83) ; J35.1 408.27,222.35 v1(408.5,222.12) ; 332.04,85.47 C2561.1 ; C2561.1 332.83,84.73 ; C2561.1 332.83,86.21 ; 252.54,92.33 C2463.1 ; C2463.1 251.88,91.67 ; C2463.1 251.88,93.06 ; C2205.2 28.61,91.16 ; C2205.2 29.27,90.42 ; C2205.2 28.61,89.81 ; v1(154.91,47.95) 154.91,47.93 154.97,47.99 D380.3 ; C2273.1 78.04,79.63 ; C2273.1 77.13,78.89 ; C2273.1 77.13,80.36 ; C2460.2 220.64,84.43 ; v1(237.77,132.36) 237.82,132.31 C2746.2 ; C2472.2 278.04,78.59 ; R20.1 v1(228.54,98.17) ; 210.25,77.85 C2409.2 210.91,78.59 ; C100.2 184.36,198.73 v1(184.09,199.01) ; v1(177.08,84.33) 177.43,84.68 R2723.1 ; 259.02,89.53 259.4,89.15 R2804.1 ; C2599.1 384.26,88.41 ; C2599.1 384.26,89.89 ; C2599.1 383.48,89.15 ; C3478.2 v1(46.9,162.96) ; D379.3 60.92,47.99 v1(60.91,48) ; C3931.2 v1(351.57,184.07) 351.57,184.04 352.68,182.93 ; C2632.2 347.89,78.2 348.27,78.59 349.03,78.59 ; R3387.1 406.96,61.03 v1(407.36,61.43) ; v1(43.37,86.74) 44.64,86.74 45.28,86.1 R2601.1 ; v1(37.4,159.94) 36.56,159.94 R3285.1 ; C3908.2 v1(351.59,153.59) ; C3505.2 v1(405.6,211.12) ; v1(143.85,48) 143.86,47.99 D378.3 ; C2235.1 93.43,84.73 ; C2235.1 92.52,85.47 ; C2235.1 93.43,86.21 ; v1(317,202.56) C3465.1 ; v1(395.44,168.93) 395.69,169.19 C3587.1 ; C2281.1 129.88,86.21 ; C2281.1 129.88,84.73 ; C2281.1 128.97,85.47 ; C3636.1 144.36,213.13 ; C3636.1 144.97,212.6 ; C3636.1 145.58,213.13 ; C3061.2 240.17,146.02 v1(240.07,146.12) ; C2529.2 264.83,78.59 ; C3170.2 220,178.84 ; C3170.2 219.04,178.84 ; C3170.2 219.52,178.36 ; C2347.1 174.08,78.89 ; C2347.1 174.08,80.36 ; C2347.1 173.16,79.63 ; C3448.2 v1(288.81,204.57) ; R2797.2 271.59,79.37 v1(271.21,79.75) ; v1(218.76,200.02) 218.76,200.15 219.24,200.63 C74.2 ; v1(302.32,83.69) 302.2,83.82 C2571.2 ; Q5.2 38.11,151.57 v1(38.42,151.25) ; D372.3 127.65,48.13 127.19,48.59 v1(127.19,48.64) ; C111.2 v1(424.24,129.16) ; C2594.2 316.27,78.59 ; C3427.2 296.13,212.82 ; C3459.2 289.06,212.57 v1(288.81,212.82) ; 330.52,85.47 C2551.1 ; C2551.1 329.73,84.73 ; C2551.1 329.73,86.21 ; R3476.1 337.88,87.5 v1(338.14,87.75) ; C2667.2 168.75,101.81 ; C2667.2 168.75,100.62 ; C2667.2 168.11,101.22 ; v1(228.28,200.02) 228.28,200.15 228.77,200.63 C2987.2 ; 165.32,91.6 C2391.1 ; C2391.1 165.32,92.8 ; C2391.1 164.68,92.2 ; C2335.2 126.66,78.59 ; C2274.2 76.87,78.59 ; v1(64.5,173.2) C3861.2 ; R3605.2 385.76,130.93 385.38,131.32 v1(385.38,133.73) v1(385.38,134.87) v1(385.38,136.01) ; 174.33,84.43 C2360.2 173.67,83.69 ; 378.9,217.04 380.23,217.04 R3519.1 ; v1(9.33,100.96) R266.1 R267.1 ; D431.3 v1(404.65,63.66) ; R3461.1 v1(60.13,79.5) ; v1(288.81,211.05) 289.19,211.43 C3460.2 ; C2379.1 157.9,78.89 ; C2379.1 158.81,79.63 ; C2379.1 157.9,80.36 ; C3150.2 239.23,170.53 v1(239.18,170.58) 239.13,170.53 C2924.2 ; C2966.2 222.29,178.84 ; C2966.2 221.81,178.36 ; C2966.2 221.32,178.84 ; R230.1 v1(424.24,126.82) ; C2339.1 175.55,90.78 ; C2339.1 176.47,90.04 ; C2339.1 175.55,89.3 ; D428.2 v1(411.82,194.92) ; C2153.1 9.69,82.9 ; C2153.1 10.6,82.17 ; C2153.1 9.69,81.43 ; C3465.1 317.84,201.7 ; C3465.1 317,200.84 ; v1(179.01,89.79) 178.75,89.53 R2722.1 ; C2486.1 254.85,86.13 ; C2486.1 254.19,85.47 ; C2486.1 254.85,84.73 ; C203.2 235.93,111.59 ; C203.2 235.93,110.4 ; C203.2 235.29,111 ; v1(107.92,47.97) 107.94,47.99 D364.3 ; 113.7,84.73 C2323.1 114.62,85.47 ; 306.39,85.6 C2547.1 ; C2547.1 305.6,84.86 ; C2547.1 305.6,86.33 ; C2248.1 88.86,89.3 ; C2248.1 88.86,90.78 ; C2248.1 87.95,90.04 ; C2619.1 385.74,79.47 ; C2619.1 386.52,78.74 ; C2619.1 385.74,78 ; v1(67.88,158.49) 68.4,158.49 68.8,158.89 C3834.2 ; v1(40.58,83.18) R2599.2 R2603.1 ; C2440.2 C2436.2 255.09,97.51 255.58,97.03 v1(255.57,97.03) ; R3457.1 v1(58.74,79.5) ; 218.5,90.04 C2446.1 ; C2446.1 219.42,89.3 ; C2446.1 219.42,90.78 ; R3458.1 v1(154.11,85.98) ; C2821.2 208.5,200.63 208.72,200.4 v1(208.72,200.02) ; v1(167.32,88.39) 166.97,88.75 R2741.1 R2724.1 ; C2468.2 282.11,93.36 v1(282,93.47) ; v1(190.85,48) 190.86,47.99 D392.3 ; R2682.1 133.54,85.07 133.82,85.35 v1(134.44,85.35) ; 142.35,98.17 C2784.2 ; C2784.2 142.84,97.69 ; C2784.2 142.84,98.65 ; C2461.1 220.89,80.36 ; C2461.1 221.55,79.63 ; C2461.1 220.89,78.97 ; R305.1 v1(270.52,169.03) ; 318.71,79.63 C2579.1 ; C2579.1 319.49,78.89 ; C2579.1 319.49,80.36 ; 301.21,78.38 R2833.1 ; 171.51,83.69 C2396.2 170.85,84.43 ; v1(159.45,166.49) 158.71,167.23 R5.2 ; R2779.2 217.46,84.68 217.87,85.09 v1(218,85.09) ; v1(323.13,85.34) 323.15,85.32 R2841.1 ; C2231.1 90.34,86.21 ; C2231.1 91.25,85.47 ; C2231.1 90.34,84.73 ; v1(326.83,85.11) 326.63,85.11 R2862.1 ; 251.7,129.79 C3035.2 ; C3035.2 252.18,129.31 ; C3035.2 252.18,130.27 ; Q45.2 v1(4.2,131.13) ; v1(153.28,153.97) 153.1,154.15 C2771.2 ; C2344.2 184.06,78.59 ; v1(160.97,185.36) 160.93,185.32 C2779.2 ; D390.3 362.65,48.13 362.19,48.59 v1(362.19,48.64) ; C2644.2 349.03,84.43 ; C2062.2 v1(404.3,96.77) ; v1(176.85,79.14) 177.43,79.14 R2720.2 ; C2642.2 352.51,78.59 ; 375.48,214.12 C3639.2 374.74,213.33 ; J33.2 v1(9.21,193.42) ; 141.69,133.73 C2741.2 ; C2741.2 142.33,133.02 ; C2741.2 142.33,134.42 ; C2497.2 281.65,78.59 ; C2322.2 116.93,78.59 ; R3445.1 v1(53.15,79.5) ; 154.14,145.06 C2958.2 ; C2958.2 154.88,144.27 ; C2958.2 155.61,145.06 ; C3617.2 378.78,201.04 v1(379.29,200.53) ; C3617.2 378.17,201.32 ; R3542.2 v1(34.73,138.4) ; C2375.1 182.84,89.3 ; C2375.1 181.93,90.04 ; C2375.1 182.84,90.78 ; C3464.1 v1(322.26,208.3) ; v1(13.91,47.95) 13.94,47.99 D363.3 ; v1(44.39,106.75) 44.01,106.37 44.01,105.28 44.46,104.82 R238.1 ; v1(284.85,48) 284.86,47.99 D393.3 ; v1(354.31,179.09) C3917.2 ; C2671.2 258.51,166.24 ; C299.2 259.12,208.94 ; C299.2 257.65,208.94 ; C299.2 v1(258.38,207.9) ; 157.9,145.06 C283.2 ; C283.2 157.16,144.4 ; C283.2 156.43,145.06 ; J34.2 v1(39.18,196.85) ; C2243.1 81.57,90.78 ; C2243.1 82.36,90.04 ; C2243.1 81.57,89.3 ; X247.1 v1(30.29,176.65) ; 228.7,191.92 C352.2 229.3,191.28 ; C2162.2 v1(34.63,91.56) ; C2623.2 389.09,77.7 ; C2786.2 v1(193.36,98.42) ; 10.1,80.39 C2154.2 9.44,81 ; 180.89,88.75 R2743.1 ; D365.3 201.92,47.99 v1(201.91,48) ; C2380.2 157.65,78.59 ; C3458.2 296.13,209.4 ; v1(231.81,97.38) 231.51,97.08 R10.2 ; C3890.2 v1(364.53,160.04) ; C2151.1 33.97,102.61 34.35,102.99 v1(34.35,103.38) ; 352.23,142.49 352.23,142.79 v1(351.59,143.43) C3884.2 ; C2566.2 319.75,84.43 ; Q48.2 v1(31.88,138.12) ; v1(22.82,171.45) 22.67,171.3 R3310.1 ; v1(288.81,208.38) 289.19,208 C3452.2 ; C274.2 153.61,174.43 ; C274.2 154.2,173.8 ; C274.2 153.01,173.8 ; R3631.2 364.78,136.4 v1(364.81,136.42) ; R2832.2 307.38,82.27 v1(307.15,82.04) ; C2491.1 281.39,84.73 ; C2491.1 280.61,85.47 ; C2491.1 281.39,86.21 ; C3169.2 158.76,111.76 ; C3169.2 158.28,112.24 ; C3169.2 158.28,111.27 ; C2581.2 319.75,78.59 ; C2612.2 385.48,83.54 ; 395.97,122.86 C3720.2 395.34,123.49 ; v1(30.8,48) 30.81,47.99 D367.3 ; 173.16,85.47 C2357.1 174.08,84.73 ; C3862.2 v1(64.53,183.36) 63.34,183.36 62.17,184.53 57.72,184.53 55.56,182.37 ; C2488.2 268.31,84.43 ; 351.47,79.63 C2635.1 352.26,78.89 ; 239.62,149.37 C2722.2 ; C2722.2 240.82,149.37 ; C2722.2 240.22,148.74 ; D368.3 124.81,47.99 v1(124.8,48) ; R14.1 v1(256.6,182.75) ; C2478.1 263.61,89.3 ; C2478.1 263.61,90.7 ; C2478.1 262.95,90.04 ; R3495.1 v1(246.7,79.5) ; v1(57.59,89.15) 57.47,89.02 R2606.1 ; C2458.2 210.91,84.43 ; C2484.2 278.04,84.43 ; C3901.2 347.91,167.41 v1(348.16,167.15) ; 240.37,207.11 C305.2 C306.2 238.85,207.03 ; J35.23 v1(384.45,222.35) ; C2197.1 12.66,82.9 ; C2197.1 12.66,81.43 ; C2197.1 11.75,82.17 ; C2356.2 184.06,84.43 ; C2514.2 255.11,78.59 ; v1(223.46,200.02) 223.46,200.31 223.78,200.63 C2666.2 ; 369.74,82.78 C2618.2 370.52,83.69 ; C2434.2 237.45,84.43 ; R3292.2 27.5,171.32 v1(27.62,171.45) ; v1(153.58,166.52) 153.63,166.47 C279.2 C276.2 ; v1(64.3,132.81) 64.55,132.56 C3815.2 ; C3473.2 299.91,207.13 ; v1(60.36,160.37) C3825.2 ; C2676.2 v1(167.2,189.74) ; 115.76,79.63 C2315.1 116.68,78.89 ; v1(47.69,77.09) 48.04,77.44 R2624.1 ; 383.07,141.45 C3703.2 383.96,140.69 ; C3562.1 v1(413.68,172.62) ; C2298.2 130.14,78.59 ; C3799.2 v1(60.24,135.99) ; C2459.1 220.89,84.73 ; C2459.1 220.89,86.08 ; C2459.1 221.81,85.47 ; v1(161.51,177.06) 161.99,177.06 162.24,177.31 C2723.2 ; C2354.2 174.33,78.59 ; R3467.1 v1(245.3,79.5) ; C3468.2 300.04,213.23 299.66,212.85 ; C2247.1 95.82,90.04 ; C2247.1 94.91,89.3 ; C2247.1 94.91,90.78 ; R3562.2 v1(375.63,133.09) ; v1(77.8,48) 77.81,47.99 D383.3 ; 158.81,85.47 C2389.1 ; C2389.1 157.9,86.21 ; C2389.1 157.9,84.73 ; C3518.2 33.34,175 v1(33.46,175.13) ; C2350.1 162.98,90.04 ; C2350.1 162.34,90.64 ; C2350.1 162.34,89.44 ; D382.3 248.92,47.99 v1(248.91,48) ; C2580.1 292.82,85.06 ; C2580.1 292.82,83.59 ; C2580.1 292.04,84.33 ; C3603.2 v1(279.21,219.33) ; C2989.2 224.57,178.84 ; C2989.2 223.61,178.84 ; C2989.2 224.09,178.36 ; 168.11,98.93 C3041.2 ; C3041.2 168.75,98.33 ; C3041.2 168.75,99.53 ; C3164.2 214.82,96.64 ; C3164.2 215.61,95.91 ; C3164.2 215.61,97.25 ; C1.1 260.29,169.42 260.59,169.11 v1(260.92,169.11) ; R2744.1 167.58,85.09 167.53,85.14 167.53,85.67 168.08,86.23 v1(168.21,86.23) ; C2592.2 316.27,84.43 ; C2155.1 14.14,87.53 v1(14.03,87.63) ; C3127.2 248.7,114.27 ; C3127.2 249.19,113.79 ; C3127.2 248.7,113.31 ; C3513.1 v1(423.61,15.11) ; v1(364.43,180.85) C3913.2 ; v1(147.41,79.5) 147.13,79.22 R3450.1 ; 158.18,83.69 C2390.2 157.65,84.43 ; 240.22,136.42 C3008.2 ; C3008.2 239.62,137.06 ; C3008.2 240.82,137.06 ; R3618.2 v1(49.54,160.12) ; v1(401,208.4) 400.75,208.15 J30.4 ; 14.64,123.21 C3661.2 15.41,123.97 ; R3453.1 v1(58.74,83.69) ; R3483.1 v1(241.11,79.5) ; R3576.1 v1(31.59,132.43) ; C280.2 154.88,156.59 ; C280.2 154.11,157.38 ; C280.2 155.64,157.38 ; 395.31,124.74 C3719.2 ; C2475.1 268.06,80.36 ; C2475.1 268.06,78.89 ; C2475.1 267.27,79.63 ; 152.59,131.72 C75.2 ; C75.2 153.19,132.36 ; C75.2 151.99,132.36 ; C2577.2 329.48,78.59 ; D371.3 33.65,48.17 v1(33.19,48.64) ; 144.63,210.41 C3630.2 145.35,211.33 ; C2321.2 139.87,84.43 ; C2831.2 238.77,146.02 v1(238.67,146.12) ; R3586.2 4.89,121.28 5.27,121.66 v1(7.68,121.66) v1(8.83,121.66) v1(9.97,121.66) ; C3469.2 299.91,210.56 ; C2226.2 80.35,78.59 ; v1(288.81,209.9) 289.19,210.28 C3456.2 ; C3463.1 v1(322.26,207.03) ; C3483.2 v1(91.38,201.67) ; C2504.2 251.63,78.59 ; R2863.1 v1(325.18,89.41) ; D366.3 295.92,47.99 v1(295.91,48) ; C3514.1 v1(395.8,21.71) ; v1(262.19,84.2) 262.19,84.43 261.94,84.68 R2821.1 ; v1(362.27,86.61) 362.78,86.1 363.39,86.1 C2655.2 ; C3095.2 241.14,116.76 v1(241.16,116.79) ; R2598.2 v1(18.22,79.5) ; v1(49.85,48) 49.86,47.99 D375.3 ; D434.2 v1(373.19,208.15) ; C3435.2 293.94,198.65 v1(294.14,198.85) ; D385.3 171.81,47.99 v1(171.8,48) ; 42.33,130.2 C3654.2 43.02,130.96 ; 52.08,117.8 C3689.2 51.5,118.49 ; C2669.2 258.25,122.93 ; v1(80.19,48.64) 80.65,48.17 D387.3 ; C109.2 389.14,212.44 ; v1(386.91,91.31) 386.52,90.93 C2648.2 385.48,91.54 ; 166.43,180.44 C3068.2 167.03,179.8 ; C2892.1 v1(180.53,192.28) ; C3838.2 v1(64.53,152.88) ; 148.02,116.86 C469.2 148.62,117.5 ; v1(120.21,85.34) R2679.2 ; C3551.1 v1(18.28,147.34) ; C2237.1 93.43,80.36 ; C2237.1 93.43,78.89 ; C2237.1 92.52,79.63 ; C2457.2 233.85,84.43 ; R3595.1 v1(380.02,129.94) ; 113.7,78.71 C2311.1 114.44,79.63 ; C3943.2 375.93,173.71 v1(375.68,173.45) ; Q6.2 v1(25.21,173.73) ; R3459.1 343.47,86.23 v1(343.34,86.36) ; C3433.2 v1(296.33,216.25) ; v1(258.25,85.34) 258.38,85.21 R2800.1 ; C2578.2 v1(303.37,77.11) ; R1.2 v1(231.71,101.22) ; v1(174.56,177.06) 174.97,177.06 175.32,177.42 C2842.2 ; C2439.1 212.92,90.04 ; C2439.1 212.13,90.9 ; C2439.1 212.13,89.3 ; v1(401.64,220.22) 401.3,220.55 J35.7 ; C3425.2 299.91,211.71 ; C2626.2 365.72,78.59 ; v1(364.78,139.85) 364.76,139.82 C3867.2 ; C3547.1 v1(31.56,147.34) ; R17.2 176.75,95.4 176.21,94.87 v1(175.6,94.87) ; 372.71,216.18 C3644.2 ; C3644.2 373.32,215.64 ; C2926.2 249.19,116.08 ; C2926.2 248.7,116.56 ; C2926.2 248.7,115.59 ; v1(348.21,178.08) 347.7,177.57 C3924.2 ; R3496.1 342.58,79.18 342.91,79.5 v1(343.32,79.5) R3492.1 ; J35.20 v1(389.3,220.24) ; C2865.2 238.06,158.34 v1(238.04,158.37) ; C2881.2 148.12,110.08 ; C2881.2 148.6,109.6 ; C2881.2 148.12,109.12 ; C113.2 v1(23.94,100.96) ; C2606.2 389.09,83.54 ; C2545.2 v1(287.72,83.69) ; C3472.2 300.29,205.99 299.66,206.63 ; C2471.1 278.3,78.89 ; C2471.1 278.3,80.36 ; C2471.1 279.08,79.63 ; R2751.2 214.19,85.21 v1(214.06,85.34) ; U116.4 255.33,179.07 255.08,179.32 254.55,179.32 v1(254.17,178.94) ; C2757.2 240.82,123.34 ; C2757.2 240.22,122.7 ; C2757.2 239.62,123.34 ; C2456.1 234.1,86.21 ; C2456.1 234.76,85.47 ; C2456.1 234.1,84.81 ; C2258.2 67.15,78.59 ; R2781.1 229.55,89.15 229.3,89.41 v1(229.17,89.41) 229.04,89.41 228.54,88.9 R2764.1 ; v1(58.22,106.94) 57.7,106.42 C112.2 ; C3731.2 395.59,147.5 ; C3731.2 C3730.2 ; C3731.2 396.23,146.89 ; v1(230.44,193.16) 230.72,192.89 R11.2 ; D373.3 315.65,48.13 315.19,48.59 v1(315.19,48.64) ; C3628.1 363.51,113.94 ; C3628.1 v1(364.3,113.28) ; C5.1 v1(179.13,192.28) ; U118.2 v1(40.32,158.87) ; v1(348.09,157.88) 347.58,157.37 C3903.2 ; C2541.1 327.47,90.04 ; C2541.1 328.26,90.78 ; C2541.1 328.26,89.3 ; C2338.2 143.47,78.59 ; v1(354.31,138.45) C3871.2 ; C2963.2 158.76,109.47 ; C2963.2 158.28,109.95 ; C2963.2 158.28,108.99 ; C3809.2 v1(67.75,128.14) ; v1(364.43,177.58) 364.26,177.42 R3645.2 ; C2536.2 287.72,91.44 v1(288.23,91.95) 288.73,91.95 289.12,91.56 C2573.2 ; D370.3 312.81,47.99 v1(312.8,48) ; C2398.2 187.67,84.43 ; C2232.2 90.08,84.43 ; 395.57,148.74 C3730.2 ; C3462.1 v1(322.26,205.76) ; D381.3 342.92,47.99 v1(342.91,48) ; C3926.2 v1(348.34,188.49) ; C3486.2 v1(93.41,201.67) ; R3251.1 v1(19.37,171.45) ; X61.1 v1(385.76,209.8) ; C2282.2 130.14,84.43 ; 252.18,124.74 C3037.2 ; C3037.2 251.7,125.22 ; C3037.2 252.18,125.7 ; 219.05,191.92 C87.2 220.24,191.92 ; D384.3 265.81,47.99 v1(265.8,48) ; v1(378.83,109.65) C3693.1 379.92,108.84 v1(379.67,108.58) ; R3611.2 v1(49.54,139.8) ; C2586.2 308.29,83.82 v1(308.04,84.07) ; C2505.1 269.53,90.78 ; C2505.1 270.32,90.04 ; C2505.1 269.53,89.3 ; R2878.2 372.3,79.58 v1(372.15,79.73) 371.64,79.73 371.28,79.37 R2882.1 ; C3439.1 300.88,215.57 v1(300.88,216.28) ; 158.71,132.36 C2735.2 159.45,131.57 ; v1(35.29,134.95) C3652.1 34.48,133.86 v1(34.23,134.11) ; v1(217.36,86.99) 217.36,88.26 216.88,88.75 R2782.1 R2763.1 ; C3484.2 v1(90.36,201.67) ; C2210.2 49.49,78.59 ; C3441.2 298.21,206.3 ; R3478.1 v1(148.53,79.5) ; 29.65,92.2 C2203.1 28.87,91.46 ; C3428.2 296.13,211.68 ; v1(322.52,79.63) 322.9,79.25 R2840.2 ; 10.6,76.32 C2195.1 9.69,75.59 ; 294.3,89.63 C2568.1 ; C2568.1 294.3,88.16 ; C2568.1 295.08,88.9 ; C2383.1 160.87,80.36 ; C2383.1 160.87,78.89 ; C2383.1 159.96,79.63 ; 358.48,84.94 C2654.1 357.7,84.2 ; R3470.1 v1(149.92,79.5) ; C3936.1 v1(374.1,160.75) ; C2919.2 v1(206.18,100.71) ; D386.3 359.81,47.99 v1(359.8,48) ; 116.68,84.73 C2293.1 115.76,85.47 ; v1(354.31,159.03) 354.56,158.77 C3894.2 ; v1(135.57,89.41) R2702.1 R2684.1 ; C2408.1 210.66,78.89 ; C2408.1 210.66,80.29 ; C2408.1 209.99,79.63 ; D430.3 v1(397.65,63.7) ; C86.2 v1(161.86,189.66) ; C2683.2 v1(225.23,101.72) ; C3442.2 299.35,206.3 ; C3055.2 171.1,186.03 ; C3055.2 170.5,186.66 ; C3055.2 169.9,186.03 ; v1(198.87,203.63) C3519.1 R3242.2 ; C3816.2 v1(64.53,142.72) ; C3907.2 v1(351.57,163.75) 352.36,162.95 ; 374.84,130.24 v1(375.92,130.24) ; C2630.2 355.18,86.26 355.44,86 ; R3472.1 340.68,85.98 v1(341.06,86.36) ; C3461.2 296.13,210.54 ; C3885.2 v1(351.57,133.27) ; v1(236.64,158.37) 236.67,158.34 C2845.2 ; R29.1 v1(399.35,194.43) ; R3590.1 v1(379.77,105.94) ; C3515.1 v1(395.8,22.86) ; C302.2 C303.2 v1(267.5,218.92) ; R3510.2 v1(283.5,206.91) ; R3625.2 v1(49.54,180.44) ; v1(425.72,4.87) 425.72,3.45 SW1.3 ; R3577.1 v1(3.9,125.45) ; C2158.2 45.89,78.59 ; v1(67.93,149.35) 68.06,149.22 C3832.2 ; C2241.2 94.7,78.08 94.17,78.61 93.66,78.61 ; R2715.2 v1(163.64,78.84) ; 383.96,116.69 C3695.2 382.82,117.57 ; C2324.2 113.45,84.43 ; C3891.2 v1(354.26,162.84) 354.26,164.71 ; R3449.1 v1(54.55,79.5) ; C101.2 v1(185.1,190.75) ; C2552.2 329.48,84.43 ; v1(160.92,141.7) 160.92,141.46 160.02,140.55 C3051.2 ; R2843.1 v1(324.17,89.41) ; C2401.2 170.85,78.59 ; C2997.2 235.27,158.34 v1(235.24,158.37) ; R2620.2 R2623.1 16.19,87.12 15.91,87.4 v1(15.56,87.4) ; 50.38,118.46 C3687.2 ; v1(393.3,216.07) J35.16 393.3,219.79 v1(392.87,220.22) ; C2255.1 66.1,79.63 ; C2255.1 66.89,80.36 ; C2255.1 66.89,78.89 ; C3485.2 v1(92.39,201.67) ; D388.3 174.65,48.28 174.29,48.64 v1(174.19,48.64) ; C2294.2 116.93,84.43 ; C2386.2 161.13,78.59 ; R3355.1 v1(393.73,60.88) ; C2622.1 388.84,78 ; C2622.1 388.05,78.74 ; C2622.1 388.84,79.47 ; v1(414.59,186.56) 414.34,186.31 C3565.2 ; C2312.2 113.45,78.59 ; R2762.1 v1(227.52,85.34) ; R3451.1 v1(337.88,79.5) ; R3463.1 v1(243.9,79.5) ; R3460.1 v1(248.09,85.98) ; v1(164.4,85.34) R2716.1 ; C2336.2 143.47,84.43 ; R3638.2 v1(364.53,156.61) ; R3575.1 v1(3.9,127.02) ; C3107.2 v1(193.36,100.71) ; C2897.2 v1(206.18,98.42) ; C3845.2 v1(60.29,176.63) ; R3531.2 v1(7.05,131.42) ; R3624.2 v1(49.54,181.61) ; C3798.2 v1(49.54,138.53) ; C2333.2 126.66,84.43 ; R2857.2 v1(310.2,79.5) ; C2482.2 268.31,78.59 ; R268.1 23.84,99.44 24.96,99.44 v1(25.34,99.06) ; C3477.2 v1(45.28,156.84) ; v1(355.61,83.69) 355.79,83.51 R2903.1 R2883.1 R2899.2 ; C3449.2 v1(288.81,205.71) ; C3578.1 v1(390.36,173.63) ; D432.3 v1(411.65,63.62) ; D93.2 v1(402.65,54.73) ; C2614.2 352.51,84.43 ; C3930.2 v1(351.57,173.91) ; C2413.2 233.85,78.59 ; C2264.2 63.67,84.43 ; C2426.2 224.12,78.59 ; C2562.2 333.08,84.43 ; R3466.1 v1(151.32,79.5) ; C2330.2 139.87,78.59 ; C2228.2 67.15,84.43 ; C3844.2 v1(49.54,179.17) ; C3481.2 v1(88.33,201.67) ; R3454.1 v1(154.11,79.5) ; R12.1 v1(259.72,182.75) ; C3475.2 v1(45.28,157.99) ; C2466.2 237.45,78.59 ; C2487.2 255.11,84.43 ; v1(364.43,179.7) R3646.2 ; R3537.2 v1(275.15,216.66) ; v1(178.37,98.42) C2855.2 ; R3462.1 v1(152.72,85.98) ; R3639.2 v1(364.53,158.9) ; R3442.1 v1(148.53,85.98) ; C6.1 v1(178.12,192.28)
  TOP w0.508: Q38.2 v1(408.24,78.61) ; C3504.1 v1(408.24,76.58) ; Q37.2 v1(413.89,79.94) ; C3503.1 v1(409.51,76.58) ; R2040.1 v1(393.51,37.72)
  GND1 w0.406: J29.4 394.65,16.35 ; J29.4 393.5,18.91 ; J29.4 392.24,16.24
  GND1 w0.762: 13.98,216.3 YJ1.4 ; YJ1.4 15.5,214.78 ; YJ1.4 15.5,217.82 ; YJ1.4 17.03,216.3 ; YJ2.2 61.43,216.3 ; YJ2.2 58.38,216.3 ; YJ2.2 59.9,217.82 ; YJ2.2 59.9,214.78 ; 410.63,9.4 RJ1.A5 ; RJ1.A5 410.63,11.52 ; RJ1.A5 411.69,10.46 ; RJ1.A5 409.58,10.46 ; 22.38,216.3 YJ1.2 ; YJ1.2 25.43,216.3 ; YJ1.2 23.9,214.78 ; YJ1.2 23.9,217.82 ; 19.7,214.78 YJ1.3 ; YJ1.3 21.23,216.3 ; YJ1.3 18.18,216.3 ; YJ1.3 19.7,217.82 ; 62.58,216.3 YJ2.1 ; YJ2.1 65.63,216.3 ; YJ2.1 64.1,214.78 ; YJ2.1 64.1,217.82 ; YJ1.5 12.83,216.3 ; YJ1.5 11.3,214.78 ; YJ1.5 11.3,217.82 ; YJ1.5 9.78,216.3 ; 47.3,214.78 YJ2.5 ; YJ2.5 48.83,216.3 ; YJ2.5 45.78,216.3 ; YJ2.5 47.3,217.82 ; YJ1.1 28.1,217.82 ; YJ1.1 26.58,216.3 ; YJ1.1 28.1,214.78 ; YJ1.1 29.63,216.3 ; YJ2.4 53.03,216.3 ; YJ2.4 49.98,216.3 ; YJ2.4 51.5,217.82 ; YJ2.4 51.5,214.78 ; YJ2.3 55.7,217.82 ; YJ2.3 57.23,216.3 ; YJ2.3 55.7,214.78 ; YJ2.3 54.18,216.3
  SIG1 w0.381: v1(182.69,99.31) v1(182.69,100.58) v1(182.69,101.6) 182.69,102.61 181.04,104.26 169.86,104.26 169.57,104.55 v1(169.57,105.48) v1(167.55,105.48) 162.27,105.48 v1(160.08,107.67) 159.02,106.6 153.53,106.6 152.46,105.53 149.29,105.53 148.27,106.55 142.94,106.55 v1(141.41,108.07) 139.89,109.6 136.97,109.6 136.46,109.09 136.46,108.58 138.11,106.93 140.02,106.93 142.05,104.9 147.38,104.9 148.65,103.63 153.35,103.63 154.52,104.8 v1(160.08,104.8) 160.08,104.77 161.1,103.76 166.56,103.76 v1(167.45,102.87) 167.83,102.49 180.15,102.49 181.04,101.6 181.04,96.64 184.09,93.6 198.06,93.6 v1(200.09,91.56) 202.12,93.6 210.38,93.6 211.49,92.48 216.45,92.48 v1(217.11,91.82) 217.77,92.48 235.37,92.48 239.13,88.72 v1(240.09,88.72) 248.45,88.72 v1(248.98,89.25) 249.72,89.99 257.16,89.99 v1(257.62,89.53) 257.75,89.41 v1(260.41,89.41) 260.41,91.44 v1(259.78,92.07) 259.52,91.82 v1(253.17,91.82) 249.26,91.82 v1(248.68,91.23) 247.79,90.35 v1(245.81,90.35) 240.04,90.35 v1(239.97,90.42) 236.03,94.36 v1(231.97,94.36) v1(212.92,94.36) 212.41,94.36 211.26,95.5 196.02,95.5 v1(195.39,96.14) 194.63,95.37 185.1,95.37 182.69,97.79 v1(182.69,98.3)
  GND2 w0.406: J29.4 393.5,18.91 ; J29.4 394.49,16.51 ; J29.4 392.38,16.38 ; RJ1.A5 409.31,10.46 ; RJ1.A5 412,10.46 ; RJ1.A5 410.63,9.03 ; RJ1.A5 410.63,11.92
  GND2 w0.762: 22.38,216.3 YJ1.2 ; YJ1.2 25.43,216.3 ; YJ1.2 23.9,217.82 ; YJ1.2 23.9,214.78 ; 26.58,216.3 YJ1.1 ; YJ1.1 28.1,217.82 ; YJ1.1 28.1,214.78 ; YJ1.1 29.63,216.3 ; 11.3,214.78 YJ1.5 ; YJ1.5 12.83,216.3 ; YJ1.5 9.78,216.3 ; YJ1.5 11.3,217.82 ; 64.1,214.78 YJ2.1 ; YJ2.1 62.58,216.3 ; YJ2.1 64.1,217.82 ; YJ2.1 65.63,216.3 ; YJ2.3 55.7,217.82 ; YJ2.3 57.23,216.3 ; YJ2.3 54.18,216.3 ; YJ2.3 55.7,214.78 ; YJ2.2 61.43,216.3 ; YJ2.2 59.9,214.78 ; YJ2.2 59.9,217.82 ; YJ2.2 58.38,216.3 ; YJ1.3 21.23,216.3 ; YJ1.3 19.7,214.78 ; YJ1.3 18.18,216.3 ; YJ1.3 19.7,217.82 ; YJ2.4 51.5,217.82 ; YJ2.4 49.98,216.3 ; YJ2.4 53.03,216.3 ; YJ2.4 51.5,214.78 ; YJ2.5 48.83,216.3 ; YJ2.5 45.78,216.3 ; YJ2.5 47.3,214.78 ; YJ2.5 47.3,217.82 ; YJ1.4 15.5,217.82 ; YJ1.4 13.98,216.3 ; YJ1.4 15.5,214.78 ; YJ1.4 17.03,216.3
  GND3 w0.406: RJ1.A5 412,10.46 ; RJ1.A5 409.31,10.46 ; RJ1.A5 410.63,9.03 ; RJ1.A5 410.63,11.92 ; J29.4 394.65,16.35 ; J29.4 392.37,16.37 ; J29.4 393.5,18.78
  GND3 w0.762: 62.58,216.3 YJ2.1 ; YJ2.1 64.1,214.78 ; YJ2.1 65.63,216.3 ; YJ2.1 64.1,217.82 ; YJ1.5 11.3,217.82 ; YJ1.5 11.3,214.78 ; YJ1.5 12.83,216.3 ; YJ1.5 9.78,216.3 ; YJ2.5 47.3,217.82 ; YJ2.5 47.3,214.78 ; YJ2.5 45.78,216.3 ; YJ2.5 48.83,216.3 ; YJ2.2 59.9,217.82 ; YJ2.2 58.38,216.3 ; YJ2.2 59.9,214.78 ; YJ2.2 61.43,216.3 ; YJ1.3 19.7,217.82 ; YJ1.3 18.18,216.3 ; YJ1.3 19.7,214.78 ; YJ1.3 21.23,216.3 ; 23.9,214.78 YJ1.2 ; YJ1.2 22.38,216.3 ; YJ1.2 23.9,217.82 ; YJ1.2 25.43,216.3 ; YJ2.4 51.5,217.82 ; YJ2.4 49.98,216.3 ; YJ2.4 51.5,214.78 ; YJ2.4 53.03,216.3 ; 15.5,214.78 YJ1.4 ; YJ1.4 15.5,217.82 ; YJ1.4 13.98,216.3 ; YJ1.4 17.03,216.3 ; 55.7,214.78 YJ2.3 ; YJ2.3 55.7,217.82 ; YJ2.3 57.23,216.3 ; YJ2.3 54.18,216.3 ; YJ1.1 29.63,216.3 ; YJ1.1 28.1,214.78 ; YJ1.1 26.58,216.3 ; YJ1.1 28.1,217.82
  SIG4 w0.33: v1(210.25,187.58) 210.5,187.83 232.09,187.83 234,189.74 v1(234,190.12)
  SIG4 w0.381: v1(210.25,187.58) v1(207.71,187.58) v1(205.3,187.58) v1(203.01,187.58) 201.88,187.58 197.93,183.63 197.93,174.24 198.69,173.48 v1(198.69,172.46) 199.8,173.58 199.8,183.33 202.45,185.98 v1(203.01,185.98) v1(205.3,185.98) v1(207.58,185.98) v1(209.87,185.98) 211.38,185.98 211.79,186.38 216.95,186.38 v1(217.61,185.72) v1(220.54,185.72) v1(221.42,185.72) v1(222.31,185.72) v1(223.2,185.72) v1(224.09,185.72) v1(224.98,185.72) v1(225.87,185.72) v1(226.76,185.72) v1(227.65,185.72) v1(228.54,185.72) v1(229.43,185.72) v1(230.31,185.72) v1(231.2,185.72) 232.14,185.72 238.19,191.77 v1(239.08,191.77) v1(246.06,191.77) v1(255.21,191.77) v1(261.56,191.77) 262.19,191.77 265.39,188.56 v1(277.05,188.56) v1(284.67,188.56) v1(292.29,188.56) v1(299.91,188.56) v1(307.53,188.56) v1(314.39,188.56) v1(322.04,188.56) 322.36,188.56 327.47,193.67 v1(355.79,193.67) 359.85,193.67 v1(364.43,189.1) 364.81,188.72 364.81,184.02 366.71,182.12 v1(366.71,179.96) v1(366.71,178.81) 367.2,178.33 v1(369.51,178.33) 369.76,178.58 v1(369.76,180.59) 369.76,182.12 366.84,185.04 v1(366.84,187.07) v1(366.84,189.48) 360.87,195.45 v1(355.79,195.45) v1(343.09,195.45) v1(330.26,195.45) 326.96,195.45 321.9,190.39 v1(321.35,190.39) v1(314.39,190.39) v1(307.53,190.39) v1(299.91,190.39) v1(292.29,190.39) v1(284.67,190.39) v1(277.05,190.39) 270.3,190.39 v1(270.26,190.43) 266.19,190.43 263.08,193.55 v1(261.56,193.55) v1(256.98,193.55) v1(254.19,193.55) v1(245.68,193.55) v1(237.93,193.55) 237.81,193.55 234.38,190.12 v1(234,190.12)
  SIG7 w0.381: v1(389.12,160.91) 388.61,160.4 388.61,154.6 383.83,149.82 377.48,149.82 371.13,143.47 366.55,143.47 363.03,139.95 363.03,135.89 361.51,134.36 v1(354.39,134.36) 354.03,134.36 v1(352.96,135.43) 353.25,135.72 353.25,137.03 354.01,137.79 356.04,137.79 357.44,136.4 360.62,136.4 361.25,137.03 361.25,140.43 ; v1(389.12,160.91) 391.48,160.91 392.53,161.96 392.53,168.69 v1(393.66,169.82) 393.28,170.2 v1(393.28,171.96) 391.6,171.96 390.36,173.2 v1(390.36,173.63) 389.92,173.63 388.91,174.64 387.78,174.64 v1(386.33,176.09) 386.33,178.43 384.93,179.83 379.27,179.83 378.9,179.46 374.98,179.46 373.88,178.36 369.53,178.36 v1(369.51,178.33) 368.76,177.58 v1(364.43,177.58) 357.66,177.58 356.21,179.03 356.21,181.25 v1(354.31,183.16) 353.12,181.97 353.12,180.28 v1(354.31,179.09) ; v1(389.12,160.91) 388.61,161.41 388.61,162.99 v1(389.24,163.62) ; 374.15,163.01 374.89,163.75 376.69,163.75 377.23,163.22 ; 374.15,163.01 374.69,162.48 376.49,162.48 377.23,163.22 ; 374.15,163.01 v1(360.36,163.01) ; 383.98,160.25 v1(382.84,160.25) 381.55,161.54 380.43,161.54 v1(379.67,160.78) 379.54,160.78 378.78,161.54 377.96,161.54 377.3,160.88 374.23,160.88 v1(374.1,160.75) 373.98,160.75 373.32,161.41 362.73,161.41 362.27,160.96 362.27,156.97 360.49,155.19 358.98,155.19 v1(358.25,154.45) 357.63,155.06 354.01,155.06 353,156.08 353,156.78 v1(352.66,157.12) 353.9,158.37 354.65,158.37 355.92,157.1 v1(358.84,157.1) 359.09,157.1 v1(360,158.01) 360.24,158.25 360.24,159.27 v1(359.97,159.53) 359.97,160.26 360.36,160.65 v1(360.36,163.01) ; 383.98,160.25 385.13,161.39 385.13,164.56 384.87,164.82 ; 383.98,160.25 v1(384.62,159.61) 384.62,155.31 382.59,153.29 v1(379.16,153.29) 376.24,153.29 369.75,146.8 364.87,146.8 360.44,142.36 354.71,142.36 v1(354.31,142.77) 353.12,141.58 353.12,139.64 v1(354.31,138.45) 356.44,140.59 361.1,140.59 361.25,140.43 ; v1(375.86,177.8) v1(379.92,177.8) 380.17,178.05 384.11,178.05 384.62,177.54 384.62,175.26 385.51,174.37 v1(385.51,173.1) ; v1(375.86,177.8) 375.86,176.91 376.49,176.27 376.49,175 377.1,174.39 378.5,174.39 379.79,173.1 v1(385.51,173.1) ; v1(375.86,177.8) 374.84,176.78 370.64,176.78 369.75,175.89 357.09,175.89 354.52,178.46 354.52,178.88 v1(354.31,179.09) ; 385.13,166.37 385.37,166.13 v1(385.37,165.54) 385.37,165.31 384.87,164.82 ; 385.13,166.37 382.08,166.37 381.06,165.35 v1(379.16,165.35) v1(378.27,165.35) v1(377.25,165.35) v1(376.36,165.35) v1(375.35,165.35) 375.25,165.45 v1(373.6,165.45) 372.78,164.64 358.08,164.64 356.27,162.84 v1(354.26,162.84) 353,161.57 353,160.34 v1(354.31,159.03) 354.9,159.62 354.9,160.27 355.23,160.6 356.4,160.6 358.81,163.01 v1(360.36,163.01) ; 385.13,166.37 385.13,167.03 386.91,168.81 v1(386.91,168.83) ; 384.87,164.82 384.86,164.83 384.48,164.83 383.4,163.75 377.76,163.75 377.23,163.22 ; 361.25,140.43 366.04,145.22 370.4,145.22 376.75,151.57 v1(379.54,151.57) 383.1,151.57 387.01,155.47 v1(387.01,159.61) v1(387.01,161.92) 387.01,164.31 387.54,164.84 387.54,166.11 v1(387.03,166.62) ; v1(386.91,168.83) 385.89,169.85 385.89,171.07 385.56,171.4 379.74,171.4 v1(379.34,170.99) 377.56,172.77 376.37,172.77 v1(375.68,173.45) 375.02,174.11 v1(374.71,174.11) v1(374.71,175.13) 371.41,175.13 370.55,174.27 v1(354.31,174.27) 353.63,174.94 353.52,174.94 352.96,175.5 v1(352.96,176.07) 352.96,177.26 v1(353,177.29) 353,177.65 354.31,178.96 v1(354.31,179.09) ; v1(386.91,168.83) 387.41,168.32 388.02,168.32 389.24,167.1 v1(389.24,163.62) ; v1(385.51,173.1) 386.28,173.1 387.93,171.45 v1(388.68,171.45) 390.91,169.22 v1(390.91,167.89) 390.91,163.51 390.46,163.07 389.8,163.07 v1(389.24,163.62)
  GND10 w0.762: 423.22,191.26 J18.1 ; J18.1 424.62,192.66 ; J18.1 424.62,189.85 ; J18.1 426.03,191.26 ; J18.2 426.03,196.34 ; J18.2 424.62,197.74 ; J18.2 424.62,194.93 ; J18.2 423.22,196.34
  GND11 w0.762: J18.1 426.03,191.26 ; J18.1 424.62,192.66 ; J18.1 424.62,189.85 ; J18.1 423.22,191.26 ; J18.2 426.03,196.34 ; J18.2 424.62,197.74 ; J18.2 423.22,196.34 ; J18.2 424.62,194.93
  GND12 w0.762: J18.2 426.03,196.34 ; J18.2 424.62,197.74 ; J18.2 424.62,194.93 ; J18.2 423.22,196.34 ; J18.1 424.62,192.66 ; J18.1 426.03,191.26 ; J18.1 424.62,189.85 ; J18.1 423.22,191.26
  BOTTOM w0.229: C454.2 169.02,172.55 v1(169.55,173.09) ; v1(181.5,169.34) 182,169.84 C461.2
  BOTTOM w0.254: C3922.2 343.68,123.82 343.68,122.91 345.94,120.65 352.11,120.65 367.31,135.85 367.31,142.46 378.27,153.41 378.27,156.72 378.71,157.16 378.97,157.16 379.16,156.97 v1(379.16,156.84) ; v1(382.46,157.86) 381.94,157.34 380.61,157.34 380.3,157.65 380.3,161.41 378.02,163.7 373.7,163.7 372.36,165.03 371.6,165.03 370.9,165.73 368.41,165.73 365.57,168.57 365.57,188.72 358.2,196.09 339.04,196.09 333.83,201.29 328.61,201.29 328.1,200.78 328.1,198.75 328.87,197.99 C2116.2 ; v1(379.39,175) 379.9,175.51 380.68,175.51 380.94,175.26 380.94,172.93 381.83,172.04 381.83,159.64 382.26,159.2 383.35,159.2 383.97,158.58 383.97,157.36 368.49,141.88 368.49,134.75 353.11,119.38 345,119.38 341.32,123.06 328.36,123.06 327.85,123.57 327.85,124.13 C3889.2
  BOTTOM w0.305: U120.10 v1(22.54,181.86) ; v1(55.31,95.63) 55.31,96.14 55.02,96.42 U15.12 ; v1(418.94,106.96) U13.12 ; U16.12 18.76,91.34 v1(17.97,90.55) ; v1(14.41,185.29) 14.66,185.04 U119.10 ; U17.12 v1(418.94,119.54)
  BOTTOM w0.33: v1(208.55,163.37) 208.55,163.35 208.05,162.85 C745.2 ; C723.2 225.06,160.86 v1(225.55,161.34) ; C3094.2 223.06,160.85 v1(223.55,161.34) ; C703.2 223.06,143.83 v1(223.55,143.34) ; C2793.2 217.06,160.85 v1(217.55,161.34) ; C734.2 220.01,157.88 v1(219.55,158.34) ; C3082.2 221.06,160.85 v1(221.55,161.34) ; v1(223.58,159.37) 223.06,158.84 C722.2 ; v1(224.55,147.34) 224.54,147.34 C698.2 ; C724.2 223.09,154.88 v1(223.55,155.34) ; C2967.2 219.06,160.85 v1(219.55,161.34) ; v1(221.55,155.34) 222.05,154.84 C736.2 ; v1(221.56,156.34) 221.06,155.85 C725.2 ; v1(179.55,171.34) 179.06,170.85 C3141.2 ; v1(221.55,158.34) 222.01,157.88 C733.2 ; C3117.2 182.09,170.85 182.6,170.34 v1(182.6,170.37) ; C732.2 224.05,157.84 v1(223.55,158.34) ; C727.2 220.05,154.84 v1(219.55,155.34) ; v1(224.55,146.34) 224.03,145.82 C697.2
  BOTTOM w0.381: v1(199.55,133.34) 200.03,132.86 C2848.2 ; v1(414.59,186.56) 414.34,186.31 C3565.2 ; v1(211.55,154.34) 212.05,153.85 C2805.2 ; v1(212.55,154.34) 212.06,154.83 C3034.2 ; C2626.2 365.72,78.59 365.7,78.61 ; C1026.2 183.07,145.83 v1(183.55,145.34) ; v1(155.13,156.16) 155.71,156.74 C415.2 ; v1(212.55,148.34) 213.02,148.82 C3333.2 ; C933.2 208.07,141.82 v1(208.55,141.34) ; v1(198.55,138.34) 198.05,137.84 C996.2 ; C2453.1 210.66,86.21 ; C2453.1 210.66,84.73 ; C2453.1 209.87,85.47 ; 31.94,98.8 31.97,98.78 C2161.1 ; C2917.2 204.03,135.83 v1(204.55,136.34) ; C592.2 222.54,109.34 v1(222.55,109.34) ; C479.2 186.1,107.84 v1(186.6,108.34) ; C1209.2 212.03,135.82 v1(212.55,136.34) ; v1(410.2,129.16) 410.86,128.5 C118.2 ; v1(216.55,110.34) 216.55,110.31 C601.2 ; v1(200.09,91.56) 200.11,91.54 C2415.2 C2407.2 ; C2724.2 201.03,145.83 v1(200.55,145.34) ; C3089.2 180.55,106.37 v1(180.55,106.34) ; v1(182.55,124.34) 183.05,123.84 C3047.2 ; C2344.2 184.06,78.59 ; C2896.2 206.03,129.82 v1(206.55,130.34) ; C609.2 203.04,112.82 v1(203.55,112.31) ; v1(180.55,116.34) 180.05,116.84 C3067.2 ; R2033.2 v1(409.36,87.35) ; C1048.2 204.03,126.86 v1(203.55,127.34) ; v1(196.55,115.34) 196.05,114.84 C608.2 ; v1(193.55,134.34) 194.03,133.86 C980.2 ; v1(170.56,112.37) 170.1,111.91 C510.2 ; v1(175.55,121.34) 175.54,121.34 C524.2 ; v1(178.52,112.34) 178.55,112.34 178.55,112.36 C3087.2 ; v1(185.55,141.34) 186.03,140.86 C1007.2 ; C389.2 171.52,158.34 v1(171.55,158.34) ; C465.2 173.06,171.85 v1(173.55,172.34) ; C2739.2 199.06,153.83 v1(198.55,154.34) ; C393.2 167.55,157.33 v1(167.55,157.39) ; R3140.2 v1(310.27,205.33) ; C886.2 200.03,131.83 v1(200.55,132.34) ; C2927.2 191.07,152.82 v1(191.55,152.34) 191.07,151.86 C1034.2 ; C3528.1 31.56,149.88 v1(31.46,149.98) ; v1(201.55,135.34) 202.03,134.86 C2930.2 ; v1(192.55,140.34) 192.03,139.82 C1249.2 ; C1266.2 211.07,143.86 v1(211.55,144.34) ; C3474.2 310.1,206.6 v1(310.32,206.37) ; v1(185.55,136.34) 186.03,135.86 C990.2 ; C738.2 252.64,166.98 v1(253.3,167.64) ; C3092.2 181.05,132.84 v1(180.55,132.34) ; C2439.1 212.13,90.78 ; C2439.1 212.92,90.04 ; C2439.1 212.13,89.3 ; C471.2 177.55,106.21 v1(177.55,106.34) ; v1(174.52,134.37) 174.55,134.37 175.04,133.87 C559.2 ; 81.57,89.43 C2243.1 ; C2243.1 82.36,90.04 ; C2243.1 81.57,90.65 ; C1024.2 192.03,149.82 v1(192.55,150.34) ; C2491.1 281.39,86.21 ; C2491.1 281.39,84.73 ; C2491.1 280.61,85.47 ; C2677.2 202.03,140.82 v1(201.55,140.34) ; v1(167.55,105.48) 168.49,104.54 C481.2 ; v1(176.55,171.34) 176.55,171.33 C457.2 ; C525.2 173.53,121.34 v1(173.55,121.34) ; C3171.2 231.04,144.87 v1(231.56,145.39) ; C3326.2 214.03,145.82 v1(214.55,146.34) ; R2857.2 v1(310.2,79.5) ; C2622.1 388.05,78.74 ; C2622.1 388.84,79.47 ; C2622.1 388.84,78 ; C3488.1 58.46,205.64 v1(58.48,205.61) ; C3488.1 57.47,204.85 ; C3488.1 56.73,205.64 ; C3048.2 169.06,148.85 v1(169.55,149.34) ; v1(25.21,173.73) 24.93,173.45 R3321.2 ; C2690.2 169.04,140.85 v1(169.55,140.34) ; v1(203.55,114.34) 203.06,114.83 C610.2 ; v1(194.55,106.34) 194.05,106.84 C3133.2 ; C511.2 173.07,111.88 v1(173.56,112.37) ; 251.88,80.36 C2503.1 ; C2503.1 251.88,78.89 ; C2503.1 252.67,79.63 ; C2806.2 230.87,172.62 C2921.2 230.01,171.8 v1(229.55,171.34) ; v1(205.55,137.34) 205.07,136.86 C1242.2 ; v1(207.55,152.34) 207.09,152.8 C3121.2 ; C1248.2 196.07,144.82 v1(196.55,144.34) ; C429.2 179.55,163.32 v1(179.55,163.34) ; v1(136.59,86.1) 136.46,85.98 136.46,85.34 136.59,85.21 R2703.1 ; C721.2 227.54,158.34 v1(227.55,158.34) ; v1(206.55,128.34) 206.03,127.82 C882.2 ; v1(398.02,181.65) 398.02,181.14 C3583.1 ; C3436.1 v1(307.61,205.33) ; v1(234.76,108.07) 234.88,107.96 C577.2 ; v1(206.55,113.31) 206.55,113.33 C623.2 ; v1(182.55,142.34) 182.06,142.83 C2907.2 ; v1(177.55,128.34) 177.55,128.33 C535.2 ; v1(202.55,136.34) 202.03,135.83 C2908.2 ; C746.2 208.04,164.84 208.55,165.35 v1(208.55,165.37) ; v1(120.21,85.34) R2679.2 ; v1(204.55,134.34) 204.03,133.83 C934.2 ; 187.41,86.08 C2397.1 ; C2397.1 187.41,84.86 ; C2397.1 186.63,85.47 ; v1(305.75,77.19) 305.52,77.42 R2844.1 ; C2681.2 v1(215.55,168.34) ; C427.2 180.57,165.28 v1(180.57,165.37) ; C671.2 224.03,135.87 v1(224.55,136.39) ; R2841.1 323.15,85.32 v1(323.13,85.34) ; C2970.2 205.67,131.18 205.55,131.3 v1(205.55,131.34) ; v3(78.55,85.42) 78.5,85.47 C2271.1 ; C84.2 215.02,138.82 v1(214.55,138.34) ; 220.89,86.21 C2459.1 ; C2459.1 220.89,84.73 ; C2459.1 221.68,85.47 ; v1(215.55,165.37) 215.99,165.82 C740.2 ; v1(217.55,106.34) 217.56,106.34 C594.2 ; C3554.1 19.85,163.6 v1(20.05,163.8) ; R3152.1 v1(300.88,216.28) ; v1(201.55,169.34) 201.55,169.35 C2712.2 ; v1(227.58,124.39) 227.57,124.39 227.52,124.34 227.51,124.34 C644.2 ; v1(99.64,48) 99.63,47.99 D423.3 ; 189.56,141.34 189.07,140.85 C1222.2 ; 189.56,141.34 C1147.2 ; 189.56,141.34 v1(189.55,141.34) ; v1(136.33,91.18) 135.93,91.18 135.27,91.84 C2319.2 ; C2925.2 190.03,125.86 v1(189.55,126.34) ; C460.2 177.55,168.34 v1(177.55,168.34) ; C582.2 211.57,106.31 v1(211.6,106.31) ; C1223.2 204.03,150.82 v1(203.55,150.34) ; v1(218,85.09) 217.64,85.09 R2779.2 ; v1(224.55,149.39) 224.55,149.34 C688.2 ; C2619.1 385.74,78 ; C2619.1 385.74,79.47 ; C2619.1 386.52,78.74 ; v1(287.64,48) 287.63,47.99 D425.3 ; v1(208.55,154.34) 208.05,153.85 C2678.2 ; C2383.1 160.08,79.63 ; C2383.1 160.87,80.24 ; C2383.1 160.87,79.02 ; C2343.1 185.1,79.63 ; C2343.1 184.32,79.02 ; C2343.1 184.32,80.24 ; C3668.2 34.71,127.23 34.99,127.51 ; C729.2 222.05,151.84 v1(221.55,152.34) ; C412.2 193.55,159.35 v1(193.55,159.34) ; v1(183.55,130.34) 184.03,129.86 C1157.2 ; v1(207.55,133.34) 208.03,132.86 C2886.2 ; C1247.2 195.07,145.82 v1(195.55,145.34) ; 381.32,164.34 381.32,159.37 382.11,158.58 382.88,158.58 383.31,158.16 383.31,157.62 382.66,156.97 v1(382.46,156.97) 382.31,156.81 v1(380.81,156.81) ; 381.32,164.34 381.32,171.61 380.3,172.63 v1(380.3,175) 379.54,174.24 377.63,174.24 377.13,174.75 377.13,175.26 378.4,176.53 381.19,176.53 382.13,175.59 382.13,173.43 382.84,172.72 v1(382.84,160.25) 383.98,160.25 v1(384.62,159.61) 385.05,159.18 385.05,157.08 v1(379.54,151.57) 372.81,144.84 v1(372.81,144.27) 372.29,144.27 369.51,141.49 369.51,134.25 353.49,118.23 344.49,118.23 340.81,121.92 326.96,121.92 v1(326.71,122.17) ; 381.32,164.34 380.17,164.34 v1(379.16,165.35) ; Q51.2 372.04,159.71 v1(373.09,160.75) ; C685.2 243.46,137.08 ; C685.2 242.86,136.45 ; C685.2 242.26,137.08 ; 31.97,91.46 C2165.1 31.18,92.2 ; v1(166.55,126.39) 166.55,126.37 166.52,126.34 166.51,126.34 C532.2 ; Q44.2 v1(375.73,191.77) ; C3016.2 175.12,139.94 v1(175.52,140.34) ; C2227.1 66.89,86.21 ; C2227.1 66.89,84.73 ; C2227.1 66.1,85.47 ; C885.2 208.03,150.82 v1(208.55,151.34) ; v1(217.55,130.34) 217.55,130.31 C679.2 ; C659.2 230.55,126.33 v1(230.55,126.39) ; C3592.1 393.28,186.97 v1(393.26,186.94) ; v1(193.55,145.34) 194.03,144.86 C1015.2 ; v1(209.6,109.31) 209.6,109.33 209.09,109.84 C584.2 ; C2935.2 222.49,164.34 v1(222.55,164.34) ; Q54.2 v1(374.46,128.27) ; v1(199.55,146.34) 200.03,146.82 C930.2 ; v1(250.76,120.39) 250.59,120.22 C630.2 249.97,120.88 v1(250.13,121.03) ; C2471.1 278.3,78.89 ; C2471.1 279.08,79.63 ; C2471.1 278.3,80.36 ; v1(227.58,129.29) 228.04,129.75 C660.2 ; C2231.1 91.12,85.47 ; C2231.1 90.34,84.73 ; C2231.1 90.34,86.21 ; D409.3 240.63,47.99 v1(240.64,48) ; 116.68,79.02 C2315.1 115.89,79.63 ; C641.2 224.57,121.34 v1(224.55,121.34) ; C3498.2 v1(71.95,215.26) ; v1(207.55,167.34) 207.55,167.34 C2818.2 ; 28.61,96.87 C2207.2 29.4,96.26 ; 171.11,79.02 C2400.1 ; C2400.1 171.89,79.63 ; C2400.1 171.11,80.24 ; C3582.1 401.33,181.53 v1(401.22,181.65) 401.46,181.89 C3581.1 ; C998.2 188.03,137.86 v1(187.55,138.34) ; R3469.1 v1(55.94,79.5) ; v1(201.55,131.34) 202.03,130.86 C3181.2 ; C2273.1 77.91,79.63 ; C2273.1 77.13,80.36 ; C2273.1 77.13,79.02 ; v1(204.55,170.37) 204.55,170.35 204.56,170.34 204.57,170.34 C2770.2 ; C3711.2 386.8,131.85 ; C3711.2 386.02,132.59 ; C3711.2 386.8,133.45 v1(386.52,133.73) ; v1(195.55,138.34) 195.55,138.32 C959.2 ; v1(182.6,167.37) 183.06,166.9 C425.2 ; v1(178.55,168.34) 178.55,168.31 C431.2 ; C1025.2 184.07,144.83 v1(184.55,144.34) ; C567.2 173.06,140.93 v1(173.52,141.39) ; C580.2 215.55,108.34 v1(215.6,108.34) ; v1(136.84,79.5) 136.84,79.37 136.59,79.12 R2700.2 ; D407.3 52.63,47.99 v1(52.64,48) ; C669.2 224.04,126.85 v1(223.55,127.34) ; v1(193.55,130.34) 194.03,129.86 C3146.2 ; v1(173.55,152.32) 174.02,151.85 C2980.2 ; C1200.2 210.07,145.82 v1(210.55,145.34) ; R2659.2 73.88,79.25 v1(74.23,79.25) ; v1(262.19,80.13) 261.43,79.37 R2819.2 ; C2971.2 190.08,158.81 v1(190.55,158.34) ; v1(185.55,152.34) 185.06,151.85 C1030.2 ; C994.2 196.03,131.86 v1(195.55,132.34) ; C1193.2 186.03,131.86 v1(185.55,132.34) ; C1050.2 202.03,150.83 v1(202.55,151.34) ; C3541.1 16.09,166.77 v1(16.07,166.75) 16.12,166.7 C3522.1 ; C2837.2 208.02,146.82 v1(207.55,146.34) ; v1(133.29,95.88) 133.67,96.26 C2372.2 ; Q43.2 v1(381.64,191.7) ; C2276.2 111.13,90.55 110.81,90.22 v1(110.81,90.17) ; v1(177.55,158.34) 177.55,158.32 C396.2 ; C3346.2 214.06,152.86 v1(214.55,153.34) ; C3557.1 19.6,154.66 v1(20.05,154.2) ; v1(211.55,165.37) 211.03,164.85 C2938.2 ; C2203.1 28.87,91.46 ; C2203.1 29.65,92.2 ; C2203.1 28.87,92.94 ; C2190.1 44.13,90.04 ; C2190.1 44.92,90.9 ; C2190.1 44.92,89.3 ; C2979.2 166.52,160.34 166.52,160.34 166.55,160.32 v1(166.55,160.29) ; v1(169.55,154.34) 169.54,154.34 C404.2 ; 268.06,78.89 C2475.1 ; C2475.1 267.27,79.63 ; C2475.1 268.06,80.36 ; C565.2 169.53,136.34 v1(169.55,136.34) ; v1(201.55,124.34) 201.06,123.85 C2758.2 ; v1(212.55,161.34) 213.04,161.84 C3176.2 ; C1225.2 204.07,147.83 v1(204.55,147.34) ; C3318.2 211.09,125.88 v1(211.55,126.34) ; C2839.2 205.55,166.32 v1(205.55,166.34) ; v1(401.22,176.85) 401.38,176.68 C3563.1 ; C3172.2 169.55,162.36 v1(169.55,162.29) ; 220.66,78.61 220.64,78.59 C2462.2 ; C650.2 227.53,121.34 v1(227.55,121.34) ; C2197.1 12.66,81.56 ; C2197.1 11.87,82.17 ; C2197.1 12.66,82.78 ; C3493.2 v1(71.95,216.28) ; C2931.2 231.02,166.78 v1(231.46,166.34) ; C2413.2 233.85,78.59 ; C1158.2 190.03,148.86 v1(189.55,149.34) ; C3056.2 184.03,142.86 v1(183.55,143.34) ; 278.3,86.21 C2483.1 ; C2483.1 279.08,85.47 ; C2483.1 278.3,84.73 ; v1(184.55,148.34) 184.03,147.83 C1014.2 ; C648.2 205.08,118.88 v1(205.55,119.34) ; v1(202.55,126.34) 202.03,125.83 C2953.2 ; 350.08,79.63 C2631.1 349.29,78.89 ; v1(216.55,108.34) 216.55,108.33 C595.2 ; v1(188.55,148.34) 188.03,147.83 C1035.2 ; C2284.2 v1(137.35,90.68) ; v1(200.55,119.34) 200.05,118.84 C633.2 ; C944.2 197.05,136.84 v1(196.55,137.34) C995.2 ; v1(187.55,126.34) 188.03,125.86 C2685.2 ; C2191.2 35.88,96.64 v1(35.12,97.41) ; C462.2 184.06,169.83 v1(183.55,170.34) ; C3550.1 34.96,167.36 v1(34.73,167.13) ; C2841.2 210.05,152.84 v1(209.55,152.34) ; C508.2 166.52,114.32 v1(166.52,114.39) ; v1(210.55,143.34) 210.07,143.82 C1202.2 ; C3147.2 219.53,166.34 v1(219.55,166.34) ; C2639.2 347.28,94.1 ; v1(164.55,152.32) 165.06,152.83 C408.2 ; v1(205.55,159.34) 205.07,158.86 C27.2 ; v1(211.55,133.34) 211.07,132.86 C1212.2 ; C502.2 166.05,117.87 166.55,118.37 v1(166.52,118.37) ; v1(402.82,180.05) 402.55,179.78 C3594.1 401.49,179.78 v1(401.22,180.05) ; C2228.2 67.15,84.43 ; R3466.1 v1(151.32,79.5) ; v1(207.55,144.34) 208.02,144.82 C927.2 ; v1(184.57,115.34) 184.06,114.83 C500.2 ; C2561.1 332.83,86.21 ; C2561.1 332.83,84.73 ; C2561.1 332.04,85.47 ; C470.2 178.55,107.34 v1(178.55,107.34) ; C3553.1 29.68,154.18 v1(29.65,154.2) 29.55,154.1 C3524.1 ; C3553.1 C3527.1 ; C3553.1 30.57,153.52 v1(30.45,153.4) ; C2656.1 363.28,79.63 ; C2656.1 362.5,78.89 ; C2656.1 362.5,80.36 ; C939.2 202.03,148.82 v1(201.55,148.34) ; C2714.2 211.05,120.84 v1(210.55,121.34) ; C2157.1 46.14,80.24 ; C2157.1 46.14,79.02 ; C2157.1 46.93,79.63 ; C3183.2 222.55,168.35 v1(222.55,168.35) ; C3497.2 v1(71.95,213.23) ; v1(317.62,48) 317.61,47.99 D406.3 ; v1(203.55,118.32) 203.55,118.34 203.05,118.84 C639.2 ; C518.2 189.5,112.37 v1(189.5,112.34) ; v1(215.55,128.34) 215.54,128.34 C3177.2 ; C2519.1 256.86,89.15 ; C2519.1 256.12,88.36 ; C2519.1 257.59,88.36 ; C682.2 228.55,135.34 v1(228.55,135.29) ; v1(219.55,130.34) 219.55,130.3 C678.2 ; v1(183.55,128.34) 184.03,127.86 C1187.2 ; v1(224.55,167.34) 224.99,166.9 C2863.2 ; C3029.2 199.07,125.83 v1(199.55,125.34) ; v1(201.55,144.34) 202.03,144.82 C923.2 ; v1(187.52,172.34) 188.05,171.82 C467.2 ; C642.2 217.06,120.85 v1(217.55,121.34) ; C1179.2 192.03,147.82 v1(192.55,148.34) ; 237.2,78.89 C2465.1 ; C2465.1 237.2,80.36 ; C2465.1 236.41,79.63 ; C3327.2 182.5,144.34 v1(182.55,144.34) 183.06,143.83 C3088.2 ; C2748.2 210.03,126.86 v1(209.55,127.34) ; C947.2 202.03,129.83 v1(202.55,130.34) ; C528.2 167.55,121.36 v1(167.55,121.29) ; v1(166.52,143.34) 166.5,143.34 C3125.2 ; v1(326.83,79.27) 326.63,79.27 R2860.2 ; C586.2 209.09,110.83 v1(209.6,111.34) ; v1(221.55,143.34) 221.06,143.83 C692.2 ; C948.2 202.03,131.83 v1(202.55,132.34) ; v1(156.15,156.16) 155.71,155.72 C2693.2 ; C3101.2 169.08,164.85 169.57,165.34 v1(169.6,165.34) ; C932.2 202.07,143.83 v1(202.55,143.34) ; v1(208.55,138.34) 208.03,137.82 C2888.2 ; v1(228.56,171.34) 228.55,171.34 229.01,171.8 C2731.2 ; C2899.2 196.02,152.82 v1(195.55,152.34) ; C2725.2 206.03,135.82 v1(206.55,136.34) ; v1(204.55,143.34) 204.07,143.83 C1229.2 ; C2668.2 188.07,110.86 v1(188.55,111.34) ; C2223.1 79.44,79.63 ; C2223.1 80.1,78.76 ; C2223.1 80.1,80.36 ; v1(29.43,150.11) 29.32,150.01 C3555.1 ; C2218.2 v1(87.57,89.66) ; v1(195.55,166.34) 196.05,166.84 C447.2 ; C649.2 203.55,116.33 v1(203.55,116.31) ; D417.3 362.21,48.45 362.21,48.51 362.19,48.54 v1(362.19,48.64) ; v1(215.55,171.34) 215.06,171.83 C3050.2 ; C97.2 215.07,129.82 v1(214.55,130.34) 214.03,129.82 C2877.2 ; C701.2 230.56,140.29 v1(230.58,140.29) ; v1(214.55,135.34) 214.03,134.82 C3337.2 ; v1(212.55,149.34) 212.55,149.33 C1261.2 ; C2705.2 182.03,137.86 v1(182.55,137.34) ; C1148.2 v1(188.55,131.34) ; C3431.2 v1(295.16,216.28) ; v1(203.55,146.34) 204.03,146.82 C1226.2 ; v1(188.55,113.32) 188.55,113.34 189.06,113.86 C516.2 ; C654.2 223.51,119.34 v1(223.55,119.34) ; C2707.2 206.03,132.86 v1(205.55,133.34) ; C424.2 183.05,162.84 v1(183.55,163.34) ; C677.2 225.55,136.35 v1(225.55,136.39) ; C2538.2 v1(326.83,89.66) 326.2,89.02 R2858.2 ; R3566.2 373.95,160.6 v1(374.1,160.75) ; C2235.1 93.43,86.21 ; C2235.1 93.43,84.73 ; C2235.1 92.65,85.47 ; 118.15,89.43 C2275.1 ; C2275.1 118.94,90.04 ; C2275.1 118.15,90.65 ; v1(198.5,109.34) 199,109.84 C215.2 ; C1183.2 190.03,127.86 v1(189.55,128.34) ; C579.2 195.07,107.85 v1(195.54,108.31) ; C2923.2 206.03,126.86 v1(205.55,127.34) ; v1(203.55,137.34) 203.06,136.85 C1241.2 ; C428.2 179.55,168.34 v1(179.55,168.34) ; v1(228.58,147.34) 228.53,147.34 C695.2 ; C625.2 211.08,116.88 v1(211.55,117.34) ; v1(227.58,112.39) 227.58,112.38 C599.2 ; v1(190.55,150.34) 190.03,149.82 C1177.2 ; C3543.1 28.64,159 28.85,159.22 v1(28.85,159.8) ; C2913.2 208.03,126.86 v1(207.55,127.34) ; v1(169.55,161.34) 169.5,161.34 C391.2 ; C3538.1 20.23,164.95 19.89,164.6 v1(19.25,164.6) ; C29.2 205.08,120.81 v1(205.55,120.34) ; C432.2 177.53,166.34 v1(177.55,166.34) ; C603.2 249.98,108.07 v1(249.75,108.3) ; v1(164.55,115.29) 164.55,115.35 C499.2 ; C2961.2 206.03,133.82 v1(206.55,134.34) ; C2692.2 207.02,168.87 206.55,169.34 v1(206.55,169.37) ; C1238.2 205.03,151.83 v1(204.55,151.34) ; C1017.2 194.03,143.82 v1(194.55,144.34) ; v1(203.55,142.34) 204.03,142.82 C1230.2 ; C3571.1 C3561.1 396.59,175.25 v1(396.42,175.25) ; C651.2 227.55,120.34 v1(227.58,120.34) ; C463.2 189.55,166.37 v1(189.55,166.34) ; v1(178.55,129.34) 178.55,129.32 C96.2 ; C2214.2 89.19,78.29 89.52,78.61 89.98,78.61 ; v1(173.55,158.34) 173.52,158.34 C398.2 ; C2611.1 386.52,84.58 ; C2611.1 385.74,85.32 ; C2611.1 385.74,83.84 ; C477.2 190.1,107.84 v1(190.6,108.34) ; C3320.2 181.08,154.81 v1(181.55,154.34) ; v1(188.55,154.34) 188.08,154.81 C3342.2 ; v1(224.55,172.34) 224.05,172.84 C2901.2 ; C2287.1 131.36,90.65 ; C2287.1 131.36,89.43 ; C2287.1 132.14,90.04 ; C2221.1 69.15,92.33 ; C2221.1 68.36,91.72 ; C2221.1 68.36,92.94 ; C717.2 211.04,159.83 v1(210.55,159.34) ; v1(192.55,158.34) 192.55,158.31 C2903.2 ; C624.2 211.08,112.88 v1(211.55,113.34) ; v1(181.42,79.5) 181.42,79.47 R2740.2 ; C1021.2 194.03,147.82 v1(194.55,148.34) ; v1(195.55,150.34) 195.07,150.82 C1018.2 ; 224.09,78.61 224.12,78.59 C2426.2 ; C562.2 173.55,140.23 v1(173.55,140.34) ; v1(212.5,106.34) 212.56,106.34 C581.2 ; v1(183.55,147.34) 184.03,146.86 C1027.2 ; C2762.2 198.03,169.82 v1(197.55,169.34) ; C99.2 197.03,128.83 v1(196.55,128.34) ; v1(228.58,155.39) 228.56,155.39 228.55,155.39 228.55,155.33 C731.2 ; 68.36,89.43 C2252.1 ; C2252.1 69.15,90.04 ; C2252.1 68.36,90.65 ; v1(147.41,79.5) 147.13,79.22 R3450.1 ; v1(167.52,133.29) 167.57,133.34 167.59,133.34 C566.2 ; 113.7,84.86 C2323.1 114.9,85.47 v3(115.13,85.7) ; C1031.2 186.07,146.83 v1(186.55,146.34) ; C12.1 v1(16.65,204.77) ; C12.1 v1(19.16,204.77) ; C12.1 v1(17.84,203.58) ; v1(230.55,122.34) 230.55,122.34 C2664.2 ; C2788.2 208.03,127.82 v1(208.55,128.34) ; C421.2 167.04,162.88 166.56,163.37 v1(166.56,163.37) ; C3437.1 C3438.1 v1(297.45,216.28) ; v1(206.55,124.34) 206.07,124.82 C3340.2 ; v1(380.81,156.81) 380.81,156.2 379.16,154.55 v1(379.16,153.29) 367.9,142.03 367.9,135.17 359.73,127 v1(359.6,127) 352.74,120.14 v1(352.74,120.01) v1(349.82,120.01) 345.5,120.01 341.56,123.95 341.44,123.95 v3(341.44,125.85) ; v1(380.81,156.81) 380.31,156.81 379.78,157.34 379.78,158.27 379.55,158.51 378.54,158.51 377.25,157.22 377.25,153.79 366.33,142.87 366.33,136.65 v1(364.93,135.25) 364.93,135 v1(359.6,129.66) 351.8,121.86 348.73,121.86 v1(348.3,122.3) ; v1(178.52,111.34) 178.55,111.34 179.05,111.84 C3079.2 ; v1(191.55,151.34) 191.55,151.3 C1036.2 ; v1(166.55,134.39) 166.55,134.37 166.52,134.34 166.51,134.34 C2939.2 ; v1(221.58,124.37) 222.02,123.93 C683.2 ; v1(204.55,130.34) 204.03,129.83 C2859.2 ; v1(219.55,143.34) 219.06,143.83 C702.2 ; v1(204.55,156.34) 204.57,156.34 C2.2 ; C1163.2 188.07,142.83 v1(188.55,142.34) ; v1(190.55,152.34) 190.07,152.82 C2945.2 ; v1(200.55,111.34) 200.07,110.86 C213.2 ; C1178.2 189.56,145.34 v1(189.55,145.34) ; v1(230.55,131.34) 230.52,131.34 C2706.2 ; v1(230.58,123.29) 230.56,123.29 230.55,123.3 230.55,123.35 C646.2 ; C2244.2 v1(87.57,90.68) ; v1(124.02,89.58) 124.04,89.58 124.02,89.61 124.02,90.22 124.34,90.55 C2308.2 ; C419.2 191.06,164.83 190.57,164.34 v1(190.57,164.37) ; R390.1 58.03,104.49 v1(58.79,104.49) ; v1(192.55,144.34) 192.03,143.82 C2662.2 ; C2975.2 166.55,119.35 v1(166.55,119.34) ; R3166.1 v1(294.14,198.85) ; R3443.1 v1(242.51,79.5) ; v1(177.54,155.35) 178.03,154.86 C397.2 ; C504.2 196.05,116.84 v1(196.55,117.34) ; C2828.2 208.03,130.86 v1(207.55,131.34) ; C2717.2 214.03,130.82 v1(214.55,131.34) ; v1(227.58,149.39) 227.98,149 C710.2 ; C554.2 175.55,136.34 175.55,136.34 v1(175.52,136.37) ; v1(177.55,115.34) 177.55,115.32 C513.2 ; C2657.2 362.24,78.59 362.27,78.61 ; v1(214.55,143.34) 214.55,143.34 C3317.2 ; R3137.1 R3139.2 v1(307.48,210.41) ; C3341.2 182.04,130.85 v1(182.55,130.34) ; v1(34.77,171.43) 34.61,171.27 R3299.2 ; v1(186.5,199.77) 186.47,199.74 C3084.2 ; C614.2 230.58,115.37 v1(230.58,115.29) ; v1(210.55,138.34) 210.03,137.82 C1145.2 ; v1(223.58,120.34) 223.56,120.34 223.55,120.35 223.55,120.35 C653.2 ; v1(190.55,154.34) 190.08,154.81 C3335.2 ; C575.2 177.55,133.34 v1(177.55,133.34) ; C628.2 220.05,114.81 v1(219.58,114.34) ; C984.2 v1(190.55,135.34) ; v1(219.55,109.34) 219.54,109.34 C600.2 ; v1(169.55,151.29) 169.11,150.85 C2976.2 ; v1(177.55,164.34) 177.53,164.34 C434.2 ; C552.2 166.53,130.34 v1(166.55,130.34) ; 50.86,89.28 50.84,89.3 C2179.1 ; v1(127.19,48.64) 127.19,48.54 127.21,48.51 127.21,48.45 D400.3 ; R3490.1 v1(152.72,79.5) ; C1143.2 202.03,154.82 v1(201.55,154.34) ; C2955.2 169.02,137.82 v1(169.55,137.29) ; C3120.2 171.5,143.34 v1(171.52,143.34) ; 10.48,76.32 C2195.1 9.69,75.71 ; v1(213.55,111.34) 214.05,110.84 C3002.2 ; v1(171.52,115.32) 171.53,115.32 171.55,115.3 171.05,114.8 C497.2 ; R3552.1 C3649.1 v1(368.11,165.22) 364.43,168.91 v1(364.43,177.58) ; D416.3 174.21,48.45 174.21,48.51 174.19,48.54 v1(174.19,48.64) ; C2155.1 14.14,87.53 v1(14.03,87.63) ; v1(227.55,113.34) 227.51,113.34 C3179.2 ; v1(267.5,218.92) 267.3,218.92 Q49.2 ; v1(204.55,124.34) 204.03,123.83 C3021.2 ; v1(212.55,151.34) 213.07,150.82 C3014.2 ; C2853.2 214.03,136.82 v1(214.55,137.34) ; C1166.2 v1(198.55,130.34) ; C3467.2 312.51,203.93 312.99,203.45 v1(312.99,203.07) 312.99,202.18 312.84,202.03 C3466.2 ; C1214.2 211.07,130.86 v1(211.55,131.34) ; v1(208.55,115.34) 208.08,114.88 C626.2 ; v1(167.52,166.34) 167.55,166.34 167.03,166.86 C420.2 ; C612.2 224.07,110.82 v1(224.55,110.34) ; C666.2 228.99,126.85 v1(228.55,127.29) ; C3339.2 213.07,151.82 v1(212.55,152.34) ; R3454.1 v1(154.11,79.5) ; C590.2 203.07,106.84 v1(203.6,106.31) ; D413.3 251.56,47.99 v1(251.57,48) ; v1(175.55,146.34) 175.55,146.32 C3145.2 ; R3202.1 v1(8.06,187.32) ; C3491.2 v1(71.95,217.29) ; C2071.2 v1(410.27,54.73) ; C2298.2 130.14,78.59 130.11,78.61 ; v1(173.55,168.34) 173.55,168.32 C444.2 ; v1(209.55,146.34) 210.02,146.82 C1199.2 ; R3487.1 v1(248.09,79.5) ; C2156.2 50.46,90.95 ; C2156.2 51.24,91.56 ; C2156.2 50.46,92.17 ; v1(206.55,152.34) 207.07,151.82 C936.2 ; v1(231.46,165.34) 231.46,165.35 230.98,164.87 C3040.2 ; C2751.2 219.55,168.32 v1(219.55,168.37) ; C3526.1 31.31,167.87 31.21,167.76 v1(30.92,167.76) ; C2767.2 166.52,110.35 v1(166.52,110.39) ; v1(227.55,105.48) 227.11,105.05 C585.2 ; C2255.1 66.1,79.63 ; C2255.1 66.89,78.89 ; C2255.1 66.89,80.36 ; C2179.1 50.84,90.78 ; C2179.1 51.63,90.04 ; C88.2 204.04,156.84 v1(203.55,156.34) ; C3576.1 v1(393.28,171.96) ; 143.19,212.21 C3634.2 143.93,213 ; C3669.2 7.02,120.24 7.3,120.52 ; v1(384.11,194.56) 383.88,194.79 R3524.2 ; C2684.2 182.05,120.84 v1(182.55,120.34) ; C3502.1 v1(29.65,193.16) ; C3031.2 182.55,108.34 v1(182.55,108.32) ; C2993.2 182.04,128.85 v1(182.55,128.34) ; C1259.2 212.02,150.82 v1(211.55,150.34) ; C2577.2 329.48,78.59 ; C2212.2 v1(74.23,89.53) ; C3044.2 200.05,120.84 v1(200.55,120.34) ; C520.2 188.03,115.83 v1(187.55,115.34) ; C505.2 196.05,118.84 v1(196.55,119.34) 196.69,119.48 R3132.1 ; C2720.2 196.03,122.86 v1(195.55,123.34) ; v1(199.55,144.34) 200.03,144.82 C3126.2 ; R3446.1 v1(335.47,78.84) ; C689.2 219.05,139.85 v1(219.55,140.34) ; v1(187.55,147.34) 188.03,146.86 C1152.2 ; C2409.2 210.91,78.59 210.88,78.61 ; v1(222.55,123.34) 223.06,123.85 C645.2 ; v1(199.55,158.34) 200.03,157.86 C80.2 ; C615.2 218.55,111.35 v1(218.55,111.34) ; C117.2 44.84,106.17 44.39,106.63 v1(44.39,106.75) ; C668.2 222.04,126.85 v1(221.55,127.34) ; v1(210.55,163.37) 210.55,163.35 210.56,163.34 210.57,163.34 C2824.2 ; C1051.2 208.03,135.82 v1(208.55,136.34) ; R2621.1 R2618.2 v1(30.92,107.69) ; C1265.2 212.07,144.82 v1(212.55,144.34) ; R3467.1 v1(245.3,79.5) ; C536.2 177.55,118.33 v1(177.55,118.34) ; C2511.2 217.87,91.95 ; 225.34,90.78 C2435.1 ; C2435.1 226.12,90.04 ; C2435.1 225.34,89.3 ; v1(166.55,147.39) 166.55,147.33 C3124.2 ; C879.2 204.03,128.86 v1(203.55,129.34) ; v1(225.55,153.39) 225.11,152.95 C2661.2 ; C741.2 215.06,161.84 v1(215.53,161.37) ; C1201.2 210.02,144.82 v1(209.55,144.34) ; C410.2 187.08,161.84 v1(187.55,161.37) ; C1255.2 194.03,139.82 v1(194.55,140.34) 195.02,140.82 C1235.2 ; C458.2 179.55,172.38 v1(179.55,172.34) ; C2362.2 140.65,98.55 v1(141.41,99.31) ; v1(228.58,159.34) 228.55,159.34 228.1,158.9 C2992.2 ; v1(195.55,149.34) 195.07,149.82 C1019.2 ; v1(355.61,83.69) 355.79,83.51 R2903.1 ; C556.2 167.55,132.33 v1(167.55,132.39) ; C2894.2 196.06,126.83 v1(196.55,126.34) ; v1(203.55,166.34) 203.54,166.34 C3153.2 ; R3141.1 v1(303.29,216.38) ; C2778.2 185.08,154.81 v1(185.55,154.34) ; C1032.2 186.03,148.86 v1(185.55,149.34) ; C2213.1 90.34,79.02 ; C2213.1 90.34,80.36 ; C2213.1 91.12,79.63 ; C674.2 224.53,134.34 v1(224.55,134.34) ; v1(230.58,143.39) 230.56,143.39 230.55,143.39 230.55,143.36 C700.2 ; C2421.1 203.26,85.72 v1(203.64,85.34) ; C489.2 180.01,109.8 v1(179.55,109.34) ; C3368.2 72.81,194.16 ; C3368.2 73.98,193.55 ; C3368.2 72.81,192.81 72.83,192.78 ; C495.2 140.96,118.51 141.11,118.36 v1(141.41,118.36) ; C2289.1 107.79,84.86 ; C2289.1 106.74,85.47 v1(106.62,85.6) ; C2289.1 107.79,86.08 ; C2457.2 234.63,83.69 v3(235.65,84.71) 236.66,83.69 C2434.2 ; C3103.2 169.54,143.34 v1(169.55,143.34) ; C634.2 211.08,118.88 v1(211.55,119.34) ; v1(205.55,111.34) 205.04,110.84 C587.2 ; v1(200.55,134.34) 200.03,133.83 C929.2 ; v1(212.5,172.34) 213,171.84 C2869.2 ; C1231.2 202.03,127.83 v1(202.55,128.34) ; C54.2 215.07,114.82 214.55,115.33 v1(214.55,115.31) ; v1(206.55,145.34) 206.07,145.82 C2802.2 ; C2968.2 173.53,143.34 v1(173.55,143.34) ; Q47.2 v1(374.21,207.19) ; C2815.2 208.07,124.82 v1(208.55,124.34) ; v1(173.55,133.34) 173.51,133.34 C571.2 ; C1211.2 212.03,133.82 v1(212.55,134.34) ; v1(186.55,161.37) 186.55,161.34 186.08,160.87 C416.2 ; C620.2 208.04,113.84 v1(207.55,113.34) ; R3164.1 v1(295.54,198.85) ; 116.9,78.61 116.93,78.59 C2322.2 ; v1(171.55,117.34) 171.06,116.85 C526.2 ; C3175.2 228.11,166.9 228.56,167.34 v1(228.58,167.34) ; v1(187.55,143.34) 188.03,143.82 C2982.2 ; C436.2 195.55,165.32 v1(195.55,165.34) ; C1181.2 192.03,131.86 v1(191.55,132.34) ; v1(326.71,200.78) 326.71,201.04 328.1,202.44 334.3,202.44 339.51,197.23 v1(343.09,197.23) v1(355.79,197.23) 359.09,197.23 v1(366.84,189.48) v1(366.84,187.07) 366.71,186.94 v1(366.71,179.96) v1(366.71,178.81) 366.71,171.45 v1(366.97,171.19) v1(366.97,168.78) 368.87,166.88 371.54,166.88 372.3,166.11 372.94,166.11 v1(373.6,165.45) 373.7,165.35 v1(375.35,165.35) ; C663.2 224.54,133.34 v1(224.55,133.34) ; C3710.2 386.55,107.59 ; C3710.2 385.89,108.58 ; C3710.2 386.55,109.45 v1(386.27,109.73) ; v1(377.25,195.7) 377.13,195.58 C3646.2 R3526.2 ; C987.2 193.07,142.86 v1(193.55,143.34) ; 126.68,78.61 126.66,78.59 C2335.2 ; C713.2 226.05,151.84 v1(225.55,152.34) ; C1188.2 v1(192.55,129.34) ; R3180.2 v1(304.97,202.54) ; C2988.2 204.03,134.86 v1(203.55,135.34) ; v1(181.69,85.1) 181.46,85.1 181.04,84.68 R2742.1 ; C2794.2 186.08,154.81 v1(186.55,154.34) ; 316.29,78.61 316.27,78.59 C2594.2 ; C3052.2 213.07,149.82 v1(212.55,150.34) ; C1045.2 208.03,129.82 v1(208.55,130.34) ; C2280.2 111.06,89.53 v1(110.81,89.28) ; C1038.2 187.06,151.85 v1(187.55,152.34) ; C957.2 v1(192.55,131.34) ; C3343.2 214.03,139.82 v1(214.55,140.34) ; C2337.1 142.43,79.63 ; C2337.1 143.22,79.02 ; C2337.1 143.22,80.24 ; C2605.1 388.84,85.32 ; C2605.1 388.84,83.84 ; C2605.1 388.05,84.58 ; 139.61,94.21 C2302.1 138.87,94.99 ; R3168.1 v1(288.81,203.05) ; R3135.1 v1(307.48,215.49) ; C2704.2 221.55,168.32 v1(221.55,168.34) ; v1(224.55,171.34) 224.04,171.85 C2744.2 ; C686.2 217.02,139.81 v1(217.55,140.34) ; 157.9,79.02 C2379.1 ; C2379.1 157.9,80.24 ; C2379.1 158.69,79.63 ; v1(182.55,152.34) 182.07,152.83 C278.2 ; C2364.2 192.7,83.44 v1(193.1,83.03) ; C1268.2 211.02,141.82 v1(210.55,141.34) 210.07,141.82 C1204.2 ; C452.2 167.1,170.76 v1(167.55,170.32) ; C3574.1 v1(396.84,189.58) ; v1(182.55,131.34) 182.54,131.34 C3069.2 ; D404.3 129.61,47.99 v1(129.62,48) ; 329.73,86.21 C2551.1 ; C2551.1 329.73,84.73 ; C2551.1 330.52,85.47 ; v1(177.08,84.33) 177.43,84.68 R2723.1 ; C492.2 192.05,110.84 v1(192.55,111.34) ; v1(30.54,171.45) 30.8,171.19 R3313.2 ; R3173.1 v1(288.81,208.38) ; 287.19,86.21 C2544.1 ; C2544.1 287.97,85.47 ; C2544.1 287.19,84.73 ; 316.52,86.21 C2591.1 ; C2591.1 316.52,84.73 ; C2591.1 317.31,85.47 ; C985.2 v1(192.55,135.34) ; C2153.1 10.48,82.17 ; C2153.1 9.69,81.56 ; C2153.1 9.69,82.78 ; C3579.1 410.76,179.42 v1(410.78,179.45) ; v1(141.67,163.7) 141.77,163.6 C414.2 141.11,162.99 v1(141.03,163.07) ; v1(211.55,137.34) 211.07,136.86 C1208.2 ; v1(186.55,142.34) 186.07,142.83 C3020.2 ; v1(230.58,155.39) 230.56,155.39 230.55,155.39 230.55,155.33 C728.2 ; v1(204.55,145.34) 204.07,145.83 C1227.2 ; v1(175.52,158.34) 175.52,158.34 C405.2 ; C1234.2 193.07,140.86 v1(193.55,141.34) ; C2956.2 221.07,172.82 v1(221.55,172.34) ; C2068.1 411.26,53.38 411.59,53.06 v1(411.92,53.06) 412.46,53.59 C2066.1 ; C1215.2 212.03,129.82 v1(212.55,130.34) ; v1(166.55,111.29) 166.55,111.31 C507.2 ; C493.2 175.53,109.34 v1(175.55,109.34) ; v1(224.55,163.34) 224.98,162.91 C2694.2 ; C3115.2 227.04,170.85 227.55,170.34 v1(227.52,170.34) ; C2200.2 32.22,89.68 ; C2200.2 32.22,91.03 ; C2200.2 31.56,90.42 ; v1(221.19,48.64) 221.19,48.54 221.21,48.51 221.21,48.45 D402.3 ; C2416.1 223.08,85.47 ; C2416.1 223.86,84.73 ; C2416.1 223.86,86.21 ; C2613.1 352.26,86.21 ; C2613.1 351.47,85.47 ; C2613.1 352.26,84.73 ; v1(218,79.25) 217.64,79.25 R2780.2 ; v1(212.55,128.34) 212.03,127.82 C2825.2 ; 352.49,78.61 352.51,78.59 C2642.2 ; D397.3 204.56,47.99 v1(204.57,48) ; C538.2 175.53,118.34 v1(175.52,118.34) ; v1(230.55,119.34) 230.53,119.34 C207.2 ; C3542.1 33.72,152.68 v1(33.62,152.78) ; C2696.2 184.07,152.83 v1(184.55,152.34) ; C1205.2 210.02,140.82 v1(209.55,140.34) ; C539.2 184.08,117.83 184.57,117.34 v1(184.57,117.32) ; C2154.2 9.44,81.25 ; Q52.2 367.04,125.4 v1(367.98,124.46) 368.52,123.92 R3558.2 ; v1(188.55,146.34) 188.03,145.83 C1190.2 ; C2900.2 185.06,141.83 v1(184.55,142.34) ; v1(198.55,143.34) 199.03,143.83 C1232.2 ; v1(410.78,174.62) 410.88,174.52 C3575.1 ; C3566.1 399.76,171.85 v1(399.86,171.96) ; v1(210.55,136.34) 210.03,135.82 C1256.2 ; C2378.2 134.81,96.14 134.56,95.88 v1(134.18,95.88) ; v1(231.56,153.39) 231.07,152.91 C726.2 ; R3163.1 v1(298.72,198.85) ; v1(164.4,85.34) R2716.1 ; C2791.2 182.02,121.87 v1(181.55,122.34) ; C2565.1 318.71,85.47 ; C2565.1 319.49,86.21 ; C2565.1 319.49,84.73 ; v1(185.55,145.34) 186.03,144.86 C1146.2 ; v1(166.56,164.29) 166.56,164.29 166.03,164.82 C422.2 ; C578.2 208.55,106.34 208.51,106.34 208.5,106.33 v1(208.5,106.31) ; C2600.2 v1(391.48,88.77) ; v1(196.55,128.34) 196.06,128.83 C971.2 ; v1(196.55,128.34) 197.06,127.83 C98.2 ; C2423.1 231.71,92.33 ; C2423.1 230.92,93.06 ; C2423.1 230.92,91.59 ; v1(189.53,115.32) 189.07,115.78 C503.2 ; C2803.2 204.03,137.83 v1(204.55,138.34) ; C709.2 225.11,143.86 v1(225.58,143.39) ; v1(169.55,144.39) 169.02,143.86 C2884.2 ; 173.29,85.47 C2357.1 174.08,84.86 ; C964.2 v1(196.55,133.34) ; C2363.1 193.46,86.08 ; C2363.1 194.25,85.47 ; C2363.1 193.46,84.86 ; C3334.2 181.02,136.87 v1(180.55,137.34) ; C209.2 231.05,109.87 v1(230.58,110.34) ; v1(207.55,140.34) 208.02,140.82 C884.2 ; C2526.1 265.09,84.73 ; C2526.1 265.09,86.21 ; C2526.1 265.87,85.47 ; C2607.1 347.82,93.06 ; C2607.1 347.03,92.33 ; C2607.1 347.82,91.59 ; v1(200.55,152.34) 201.06,151.83 C1047.2 ; C50.2 216.06,122.85 v1(216.55,123.34) ; v1(187.55,130.34) 188.03,129.86 C1161.2 ; C51.2 215.07,115.83 v1(214.55,116.34) ; R2641.1 83.76,85.47 82.99,86.23 v1(82.87,86.23) ; v1(192.55,163.34) 192.56,163.34 C435.2 ; v1(175.51,130.34) 175.51,130.33 C574.2 ; C1186.2 186.03,127.86 v1(185.55,128.34) ; v1(19.25,153.4) 19.76,153.4 20.13,153.03 C3552.1 C3549.1 ; C3155.2 214.03,140.82 v1(214.55,141.34) ; C551.2 167.04,127.86 167.55,128.37 v1(167.52,128.37) ; C418.2 187.56,167.34 v1(187.55,167.34) ; C3548.2 C3532.1 30.47,164.59 v1(30.45,164.6) ; C977.2 194.03,141.82 v1(194.55,142.34) ; v1(202.55,134.34) 202.03,133.83 C946.2 ; C2297.1 129.1,79.63 ; C2297.1 129.88,79.02 ; C2297.1 129.88,80.24 ; 251.65,78.61 251.63,78.59 C2504.2 ; v1(166.55,144.34) 166.55,144.35 C3186.2 ; v1(225.55,140.34) 225.53,140.34 C2766.2 ; C978.2 v1(186.55,135.34) ; C1206.2 200.03,130.86 v1(199.55,131.34) ; C2703.2 166.04,170.83 v1(166.55,171.34) ; C3633.2 144.97,212.21 ; C3633.2 145.71,213 ; C3633.2 144.31,213 ; v1(193.55,165.37) 193.55,165.34 193.07,164.86 C439.2 ; C2952.2 v1(190.55,124.34) ; v1(166.55,140.34) 166.51,140.34 C3013.2 ; v1(205.55,148.34) 206.02,148.82 C940.2 ; C2906.2 194.09,171.83 v1(194.6,172.34) ; 26.86,103.88 C2180.2 v1(27.78,104.62) ; v1(208.55,149.34) 209.02,149.82 C883.2 ; v1(185.52,111.32) 185.52,111.34 185.05,110.87 C3065.2 ; C1041.2 188.03,144.86 v1(187.55,145.34) ; v1(204.55,128.34) 204.03,127.83 C2814.2 ; C3332.2 v1(195.55,125.34) ; C2743.2 225.06,137.85 v1(225.55,138.34) ; C3942.2 378.88,170.53 v1(379.34,170.99) 379.03,171.3 C3945.2 ; v1(187.55,149.34) 188.03,148.86 C1040.2 ; C11.1 v1(38.14,205.25) ; v1(170.55,166.34) 170.05,166.84 C453.2 ; C1224.2 204.03,148.82 v1(203.55,148.34) ; v1(186.57,172.37) 186.57,172.34 186.07,172.84 C449.2 ; C619.2 228.05,115.89 v1(227.55,116.39) 227.55,116.37 227.52,116.34 227.52,116.34 C216.2 ; C543.2 191.07,117.86 191.55,118.34 v1(191.55,118.33) ; C3158.2 186.08,167.81 v1(186.55,167.34) ; v1(27.78,101.7) C2184.2 26.99,102.61 ; C986.2 v1(194.55,137.34) ; C212.2 228.02,125.86 228.53,126.37 v1(228.58,126.37) ; 67.15,78.59 C2258.2 ; R3449.1 v1(54.55,79.5) ; v1(182.55,159.34) 183.05,159.84 C407.2 ; R3291.1 v1(37.27,155.45) ; v1(123.93,84.06) 123.93,84.47 123.71,84.68 R2704.1 ; v1(200.55,130.34) 200.03,129.83 C2936.2 ; 10.04,74.55 C2196.2 9.44,75.41 ; C1172.2 v1(190.55,129.34) ; v1(182.5,163.34) 182.56,163.34 C423.2 ; v1(216.55,168.34) 216.55,168.34 C3132.2 ; v1(217.55,143.34) 217.06,143.83 C706.2 ; 5.65,107.74 v1(5.65,106.68) ; 5.65,107.74 v1(5.65,108.84) ; 5.65,107.74 v1(6.85,107.74) ; v1(167.52,120.39) 167.55,120.39 168.05,119.89 C530.2 ; C2912.2 201.06,136.85 v1(201.55,137.34) ; C2679.2 192.09,169.85 v1(192.6,169.34) ; R3473.1 v1(58.74,91.95) ; v1(173.55,136.34) 173.55,136.34 C569.2 ; R306.1 v1(410.2,114.25) ; v1(171.55,159.37) 171.03,158.85 C399.2 ; C2618.2 370.52,83.44 ; C92.2 177.59,153.34 v1(177.55,153.34) ; R3207.1 v1(22.92,196.85) ; C573.2 177.53,130.34 v1(177.55,130.34) ; C2398.2 187.67,84.43 ; C1002.2 190.07,144.82 v1(190.55,144.34) ; C448.2 192.04,167.85 v1(192.55,167.34) ; C473.2 172.55,106.21 172.55,106.33 v1(172.56,106.34) ; C1192.2 v1(188.55,129.34) ; v1(182.55,151.34) 182.07,151.83 C2713.2 ; C1006.2 183.07,141.83 v1(183.55,141.34) ; v1(209.55,154.34) 209.08,154.81 C3036.2 ; C2161.1 31.97,97.18 ; C2161.1 31.18,98.04 ; v1(167.55,124.34) 167.07,123.86 C531.2 ; R3470.1 v1(149.92,79.5) ; C1245.2 200.03,128.82 v1(199.55,128.34) ; R3468.1 342.2,79.12 341.82,79.5 v1(341.06,79.5) 340.68,79.12 R3499.1 ; C2962.2 210.99,169.83 210.53,169.37 v1(210.5,169.37) ; C514.2 175.07,111.9 175.53,112.37 v1(175.51,112.37) ; 12.92,75.28 C2150.2 12.32,74.55 ; v1(190.55,146.34) 190.07,146.82 C1164.2 ; v1(205.55,142.34) 206.02,142.82 C928.2 ; C1176.2 190.03,129.86 v1(189.55,130.34) ; 269.53,90.78 C2505.1 ; C2505.1 269.53,89.3 ; C2505.1 270.32,90.04 ; 139.87,78.59 C2330.2 ; v1(196.55,113.34) 196.05,112.84 C621.2 ; C205.2 205.04,107.84 204.55,108.33 v1(204.55,108.31) ; C1149.2 194.03,137.86 v1(193.55,138.34) ; C3521.2 27.24,166.22 v1(27.75,166.72) ; v1(402.82,181.65) 402.4,181.23 C3585.1 ; C3085.2 175.54,152.34 v1(175.52,152.34) ; v1(195.55,128.34) 196.03,127.86 C1191.2 ; 80.35,78.59 C2226.2 ; D424.3 193.63,47.99 v1(193.64,48) ; C960.2 184.03,135.86 v1(183.55,136.34) ; 45.05,91.08 C2160.2 44.39,91.69 ; v1(184.6,109.32) 184.6,109.34 184.21,109.73 184.09,109.86 C485.2 ; C2590.2 v1(331.05,77.19) ; v1(174.55,170.37) 174.55,170.36 C459.2 ; C629.2 225.54,115.34 v1(225.55,115.34) ; C3197.2 214.03,144.82 v1(214.55,145.34) ; v1(207.55,129.34) 208.03,128.86 C3045.2 ; C2798.2 228,156.89 227.55,157.34 v1(227.58,157.34) ; C2812.2 169.52,152.34 169.52,152.34 v1(169.55,152.32) ; C2578.2 v1(303.37,77.11) ; C618.2 230.55,114.33 v1(230.55,114.39) ; v1(166.55,122.39) 166.55,122.37 C3178.2 ; R2663.1 v1(105.98,83.69) ; C227.2 210.98,166.85 v1(210.55,167.28) ; C962.2 196.03,133.86 v1(195.55,134.34) ; v1(189.5,169.34) 190,169.85 C451.2 ; v1(227.55,141.39) 227.55,141.3 C3109.2 ; C2250.1 64.71,79.63 ; C2250.1 63.92,78.89 ; C2250.1 63.92,80.29 ; v1(270.62,48) 270.61,47.99 D421.3 ; v1(227.58,132.34) 228.01,131.91 C661.2 ; v1(200.98,208.53) 200.98,208.53 v2(201.74,208.53) ; v1(167.52,145.39) 167.96,145.83 C3007.2 ; R3215.1 v1(28.38,179.19) ; C2528.1 265.87,79.63 ; C2528.1 265.09,78.89 ; C2528.1 265.09,80.36 ; v1(182.55,141.34) 182.06,141.83 C3331.2 ; C970.2 v1(188.55,135.34) ; v1(187.55,124.34) 188.02,124.81 C3323.2 ; C2332.1 126.91,86.08 ; C2332.1 126.91,84.86 ; C2332.1 127.95,85.47 v3(128.33,85.85) ; C2959.2 214.03,147.82 v1(214.55,148.34) ; v1(225.58,118.39) 225.56,118.39 225.55,118.39 225.55,118.35 C640.2 ; v1(186.62,106.32) 186.62,106.34 186.13,106.84 C484.2 ; v1(223.55,130.34) 223.04,130.85 C676.2 ; 223.86,78.89 C2425.1 ; C2425.1 223.08,79.63 ; C2425.1 223.86,80.36 ; C2417.2 207.43,84.43 ; v1(364.3,113.28) 364.17,113.15 C3626.2 C3625.2 ; C3154.2 175.54,143.34 v1(175.52,143.34) ; v1(187.55,132.34) 188.03,131.86 C1160.2 ; C2329.1 140.12,80.24 ; C2329.1 140.12,79.02 ; C2329.1 140.91,79.63 ; R460.1 v1(426.12,128.17) ; C3194.2 205.07,166.86 v1(205.55,167.33) ; v1(209.55,159.34) 210.07,158.82 C28.2 ; R3263.2 v1(12.51,161.67) ; C247.2 199.03,169.82 v1(198.55,169.34) ; v1(210.55,151.34) 211.02,151.82 C1258.2 ; C486.2 183.03,110.86 v1(182.55,111.34) ; R2623.1 15.71,86.59 15.43,86.87 15.43,87.27 v1(15.56,87.4) 16.22,87.4 16.6,87.78 R2600.1 ; R3495.1 v1(246.7,79.5) ; C2234.2 80.35,84.43 ; C3144.2 209.53,169.34 v1(209.55,169.34) ; v1(34.23,134.11) 34.48,133.86 C3652.1 v1(35.29,134.95) ; C3157.2 204.03,131.83 v1(204.55,132.34) ; v1(183.52,172.34) 183.99,172.81 C443.2 ; C974.2 192.03,129.86 v1(191.55,130.34) ; C1010.2 191.07,140.86 v1(191.55,141.34) ; C2710.2 204.03,130.86 v1(203.55,131.34) ; C3111.2 192.03,125.86 v1(191.55,126.34) ; R3221.1 v1(35.73,192.78) ; C878.2 210.03,128.86 v1(209.55,129.34) ; v1(378.65,210.69) 378.65,210.18 378.24,209.78 R3545.2 ; C693.2 230.05,135.79 230.56,135.29 v1(230.58,135.29) ; 329.73,80.36 C2576.1 ; C2576.1 330.52,79.63 ; C2576.1 329.73,78.89 ; v1(406.37,90.17) 405.84,90.7 C2059.2 ; C3026.2 194.05,107.84 v1(194.55,108.34) ; C3328.2 v1(189.55,124.34) ; C2569.2 v1(313.63,90.55) ; C2405.1 234.89,79.63 ; C2405.1 234.1,80.36 ; C2405.1 234.1,78.89 ; R2660.2 87.24,78.84 87.57,78.52 v1(87.57,78.48) ; v1(231.58,161.39) 231.56,161.39 231.05,160.88 C2880.2 ; D412.3 157.54,47.99 v1(157.57,47.95) ; v1(212.55,145.34) 212.07,145.82 C1264.2 ; C1173.2 194.03,149.82 v1(194.55,150.34) ; v1(364.62,48) 364.61,47.99 D422.3 ; v1(207.55,150.34) 208.03,149.86 C2946.2 ; C2753.2 182.06,140.83 v1(182.55,140.34) 182.16,139.95 R3112.1 ; C1251.2 195.07,141.82 v1(195.55,141.34) ; C2787.2 215.02,119.81 v1(214.55,119.34) ; v1(193.55,147.34) 193.07,146.86 C94.2 ; C2355.1 185.1,85.47 ; C2355.1 184.32,84.86 ; C2355.1 184.32,86.08 ; 157.67,78.61 157.65,78.59 C2380.2 ; v1(206.55,138.34) 206.03,137.82 C2772.2 ; C2643.1 350.08,85.47 ; C2643.1 349.29,86.21 ; C2643.1 349.29,84.73 ; C2634.2 v1(383.1,88.77) ; v1(177.55,124.34) 177.55,124.29 C545.2 ; C2566.2 319.75,84.43 ; C3545.1 25.41,157.96 v1(25.65,158.2) 25.24,158.62 C3556.1 25.24,159.38 v1(25.65,159.8) 25.41,160.04 C3540.1 24.3,160.04 v1(24.05,159.8) 24.04,159.79 C3534.1 24.04,158.21 v1(24.05,158.2) ; v1(199.55,137.34) 199.06,136.85 C2851.2 ; v1(182.55,133.34) 182.03,133.86 C3338.2 ; v1(201.55,150.34) 202.03,149.86 C1220.2 ; R2776.2 230.98,79.25 v1(231.33,79.25) ; C2205.2 29.27,90.42 ; C2205.2 28.61,91.03 ; C2205.2 28.61,89.81 ; v1(169.55,126.3) 169.1,125.85 C2674.2 ; D415.3 80.21,48.45 80.21,48.51 80.19,48.54 v1(80.19,48.64) ; C2209.1 49.24,79.02 ; C2209.1 49.24,80.24 ; C2209.1 48.45,79.63 ; C3319.2 184.01,125.88 v1(183.55,126.34) ; 353.73,93.06 C2627.1 ; C2627.1 353.73,91.59 ; C2627.1 354.52,92.33 ; v1(34.35,103.38) 33.96,103.38 33.69,103.11 C2186.1 ; v1(190.55,142.34) 190.07,142.82 C1012.2 ; C529.2 173.08,126.85 v1(173.55,127.32) ; C611.2 221.06,112.85 221.56,113.34 v1(221.58,113.34) ; v1(196.55,111.34) 196.05,110.84 C490.2 ; C3114.2 206.03,125.82 v1(206.55,126.34) ; 316.52,80.36 C2593.1 ; C2593.1 317.31,79.63 ; C2593.1 316.52,78.89 ; C982.2 188.03,133.86 v1(187.55,134.34) ; C2148.2 v1(6.67,87.25) ; C350.2 214.05,153.85 v1(213.55,154.34) ; v1(191.55,116.32) 191.55,116.32 191.09,115.86 C517.2 ; v1(210.55,124.34) 210.07,124.82 C3344.2 ; 364.05,110.61 C3625.2 ; C3625.2 363.39,109.88 ; C737.2 224.05,151.84 v1(223.55,152.34) ; C2604.2 v1(383.1,89.79) ; v1(208.55,147.34) 208.07,147.82 C2760.2 ; C3430.2 v1(292.67,216.91) ; v1(202.55,152.34) 203.06,151.83 C941.2 ; v1(177.55,112.34) 177.55,112.32 C487.2 ; v1(311.34,79.75) R2859.2 R2864.1 ; v1(205.55,129.34) 206.03,128.86 C1246.2 ; R3483.1 v1(241.11,79.5) ; C1195.2 210.03,134.86 v1(209.55,135.34) ; v1(188.55,152.34) 189.06,151.83 C975.2 ; C2836.2 200.03,148.82 v1(199.55,148.34) ; C2282.2 130.14,84.43 ; v1(20.85,159.8) 20.85,159.19 C3544.1 ; C577.2 235.83,107.24 ; C577.2 235.83,108.66 ; v1(187.55,128.34) 188.03,127.86 C1150.2 ; v1(171.55,161.34) 171.52,161.34 C3192.2 ; v1(168.21,90.04) 168.72,89.53 C2382.2 ; v1(176.55,168.34) 176.57,168.34 C456.2 ; C2324.2 113.45,84.43 ; C3336.2 204.03,125.83 v1(204.55,126.34) ; C2418.2 224.12,84.43 ; C49.2 216.55,159.35 v1(216.55,159.34) ; v1(250.13,114.93) 249.97,114.78 C576.2 250.69,114.22 v1(250.76,114.3) ; C544.2 175.55,124.31 175.55,124.32 v1(175.52,124.34) ; v1(204.55,116.34) 205.04,116.84 C637.2 ; C2288.2 v1(137.35,89.66) ; C602.2 231.03,111.86 231.56,112.39 v1(231.58,112.39) ; 268.06,84.73 C2485.1 ; C2485.1 268.06,86.21 ; C2485.1 267.27,85.47 ; C2777.2 214.03,133.82 v1(214.55,134.34) ; C1039.2 189.56,147.34 v1(189.55,147.34) ; v1(217.55,133.34) 217.06,132.85 C664.2 ; v1(207.55,135.34) 208.03,134.86 C2817.2 ; v1(189.55,163.34) 189.05,162.84 C437.2 ; v1(211.55,146.34) 212.02,146.82 C1263.2 ; v1(228.58,134.34) 228.06,133.82 C672.2 ; v1(211.55,129.34) 211.07,128.86 C1216.2 ; R2739.2 166.43,77.59 v1(166.81,77.21) ; C2152.2 v1(6.67,86.23) ; v1(21.55,205) C2110.2 v1(20.38,203.96) ; C2911.2 182.06,143.83 v1(182.55,143.34) ; C3188.2 v1(189.55,167.34) ; C1029.2 193.55,151.3 v1(193.55,151.34) ; v1(210.55,147.34) 210.07,147.82 C1198.2 ; v1(273.75,85.34) R2824.1 ; C2972.2 173.55,149.31 v1(173.55,149.34) ; 304.25,80.36 C2575.1 ; C2575.1 304.25,78.89 ; C2575.1 303.47,79.63 ; D405.3 223.61,47.99 v1(223.62,48) ; C2644.2 349.03,84.43 ; C2320.1 140.91,85.47 ; C2320.1 140.12,86.08 ; C2320.1 140.12,84.86 ; v1(211.55,124.34) 212.02,124.82 C2977.2 ; C555.2 177.55,136.34 v1(177.55,136.34) ; R3477.1 60.13,91.31 v1(60.77,91.95) C2249.2 ; R2800.1 258.38,85.21 v1(258.25,85.34) ; C3059.2 166.03,168.84 166.55,168.32 v1(166.52,168.32) ; C1049.2 210.02,150.82 v1(209.55,150.34) ; C2208.2 49.49,84.43 ; C2351.2 v1(190.06,90.68) ; v1(182.55,149.34) 182.07,149.83 C281.2 ; v1(298.57,48) 298.56,47.99 D398.3 ; C1196.2 210.03,132.86 v1(209.55,133.34) ; v1(190.55,121.34) 191.04,120.85 C3184.2 ; C961.2 184.03,133.86 v1(183.55,134.34) ; v1(202.55,141.34) 202.07,141.83 C1233.2 ; C636.2 200.05,116.84 200.55,117.33 v1(200.55,117.31) ; v1(96.2,89.58) 96.13,89.66 C2253.2 ; v1(180.55,154.34) 180.05,154.85 C3042.2 ; v1(208.55,161.34) 208.04,160.83 C715.2 ; v1(191.55,143.34) 191.07,142.86 C1001.2 ; v1(219.55,124.34) 220.02,123.87 C681.2 ; C1011.2 192.03,144.86 v1(191.55,145.34) ; R3478.1 v1(148.53,79.5) ; C3580.1 408.72,171.73 v1(408.62,171.83) ; C2782.2 218.55,168.36 v1(218.55,168.34) ; C95.2 218.06,152.83 v1(217.55,153.34) ; C2458.2 210.91,84.43 ; C2360.2 174.33,84.43 ; v1(170.55,136.34) 170.6,136.34 C557.2 ; C3588.1 397.42,186.66 397.2,186.45 v1(396.42,186.45) 396.42,185.91 395.95,185.44 C3577.1 ; C3091.2 192.03,146.86 v1(191.55,147.34) ; C1218.2 210.03,130.86 v1(209.55,131.34) ; v1(173.52,116.34) 173.55,116.34 173.06,116.83 C540.2 ; C2163.1 46.14,86.21 ; C2163.1 46.93,85.47 ; C2163.1 46.14,84.73 ; v1(214.55,128.34) 214.03,127.82 C2795.2 ; v1(188.55,117.34) 188.52,117.34 C548.2 ; v1(175.5,115.34) 175.05,114.9 C512.2 ; C606.2 200.05,114.84 v1(200.55,115.34) ; R3170.1 v1(288.81,205.71) ; v1(193.5,169.37) 193.55,169.32 193.55,169.31 C446.2 ; v1(189.55,154.34) 189.08,154.81 C103.2 ; v1(190.6,106.32) 190.08,106.84 C476.2 ; v1(335.47,90.68) C2574.2 ; C226.2 207.1,169.9 v1(207.55,170.34) ; C937.2 206.07,149.82 v1(206.55,149.34) ; v1(208.55,132.34) 208.03,131.82 C887.2 ; R3169.1 v1(288.81,204.57) ; C1023.2 188.03,150.86 v1(187.55,151.34) ; C2342.2 181.67,90.68 181.06,90.07 v1(181.06,88.88) ; C1252.2 190.03,139.82 v1(190.55,140.34) ; C3432.2 v1(293.89,216.28) ; C501.2 184.03,115.83 v1(183.55,115.34) ; D408.3 334.63,47.99 v1(334.64,48) ; C993.2 v1(194.55,127.34) ; C2206.1 28.87,97.25 ; C2206.1 28.87,98.78 ; C2206.1 29.65,98.04 ; R3549.2 v1(264.22,213.13) ; C568.2 171.55,140.35 171.54,140.34 v1(171.52,140.34) ; C3086.2 166.53,156.34 v1(166.52,156.34) ; 332.83,80.36 C2589.1 332.04,79.63 ; C2581.2 319.75,78.59 319.72,78.61 ; v1(406.02,181.65) 406.02,181.44 C3584.1 ; v1(192.55,146.34) 192.03,145.82 C1009.2 ; v1(202.55,165.34) 202.55,165.3 C2883.2 ; R2602.2 17.08,81.4 v1(17.21,81.28) ; 244.07,161.44 C739.2 ; C739.2 245.26,161.44 ; C739.2 244.67,160.8 ; C3110.2 186.03,133.86 v1(185.55,134.34) ; v1(202.55,154.34) 203.04,154.84 C3134.2 ; C1240.2 206.07,141.82 v1(206.55,141.34) ; v1(169.57,169.37) 169.04,168.83 C450.2 ; R3167.1 v1(292.37,198.85) ; 352.26,78.89 C2635.1 351.47,79.63 ; C632.2 230.55,118.33 230.55,118.39 230.56,118.39 v1(230.58,118.39) ; C1022.2 183.06,148.85 v1(183.55,149.34) ; C1162.2 v1(198.55,136.34) ; v1(208.55,170.37) 208.55,170.34 208.99,169.9 C3018.2 ; C966.2 194.03,127.86 v1(193.55,128.34) ; v1(177.55,146.34) 177.55,146.34 C3140.2 ; C1151.2 199.03,126.83 v1(198.55,126.34) ; C2162.2 v1(34.63,91.56) ; v1(150.3,213.1) 150.69,213.48 152.57,213.48 R3559.2 ; C3011.2 180.52,118.34 v1(180.55,118.34) ; C704.2 217.07,135.91 v1(217.51,136.35) ; C3166.2 182.07,148.83 v1(182.55,148.34) ; v1(16.57,47.95) 16.54,47.99 D395.3 ; v1(177.55,152.34) 177.55,152.32 C3027.2 ; v1(219.55,146.34) 220,145.89 C708.2 ; C3185.2 199.04,159.85 v1(198.55,160.34) ; C1207.2 212.03,137.82 v1(212.55,138.34) ; C2268.2 99.23,83.16 99,82.93 v1(98.79,82.93) ; C466.2 174.55,168.36 v1(174.55,168.34) ; C472.2 175.55,106.21 v1(175.55,106.34) ; C2738.2 166.04,158.85 166.52,159.33 v1(166.52,159.39) ; C2472.2 278.04,78.59 ; v1(208.55,145.34) 208.07,145.82 C2874.2 ; v1(175.55,170.34) 176.03,170.82 C455.2 ; 353.73,90.78 C2629.1 ; C2629.1 354.52,90.04 ; C2629.1 353.73,89.3 ; R2751.2 214.19,85.21 v1(214.06,85.34) ; C1254.2 186.03,143.82 v1(185.55,143.34) ; C1210.2 211.07,134.86 v1(211.55,135.34) ; 207.68,84.86 C2412.1 ; C2412.1 207.68,86.08 ; C2412.1 208.47,85.47 ; C1159.2 v1(192.55,127.34) ; C2340.2 181.8,89.66 v1(181.67,89.53) ; v1(140.91,150.87) 140.98,150.8 C282.2 141.67,151.38 v1(141.54,151.51) ; v1(24.05,155) 24.09,154.96 C3535.1 ; v1(34.23,165.73) C3539.1 33.46,165.71 C3529.1 ; C2338.2 143.47,78.59 ; v1(177.55,143.34) 177.55,143.37 C3090.2 ; C534.2 166.52,123.38 v1(166.52,123.29) ; C2479.2 262.29,89.53 v1(262.06,89.31) ; C691.2 221.06,139.85 v1(221.55,140.34) ; v1(170.55,124.34) 170.55,124.31 C546.2 ; v1(315.19,48.64) 315.19,48.54 315.21,48.51 315.21,48.45 D401.3 ; v1(218.55,171.34) 218.55,171.34 C2904.2 ; C1267.2 211.56,142.34 v1(211.55,142.34) ; v1(393.26,176.4) 393.28,176.43 C3572.1 ; C1016.2 194.03,145.82 v1(194.55,146.34) ; C935.2 199.03,145.83 v1(198.55,145.34) ; v1(219.55,133.34) 219.08,132.87 C665.2 ; R3463.1 v1(243.9,79.5) ; v1(166.55,107.34) 166.51,107.34 C2729.2 ; v1(227.55,109.34) 227.54,109.34 C597.2 ; C667.2 217.05,127.84 v1(217.55,127.34) ; C2259.1 63.92,86.21 ; C2259.1 63.92,84.73 ; C2259.1 64.71,85.47 ; C430.2 179.55,165.32 v1(179.55,165.34) ; v1(245.55,148.21) 245.78,148.44 C712.2 ; C474.2 183.05,111.84 v1(183.55,111.34) ; v1(224.55,165.34) 224.55,165.34 C3033.2 ; C1008.2 184.07,140.83 v1(184.55,140.34) 184.32,140.11 R3111.1 ; v1(214.55,133.34) 214.03,132.82 C3195.2 ; v1(225.59,156.36) 225.59,156.36 226.07,156.84 C735.2 ; C2222.2 v1(74.23,90.55) ; C588.2 202.03,110.88 v1(202.5,111.34) ; v1(219.55,116.34) 219.55,116.33 C627.2 ; C924.2 208.02,142.82 v1(207.55,142.34) ; v1(140.91,135.66) 140.96,135.61 C522.2 140.47,134.54 140.27,134.74 v1(140.27,135.02) ; v1(185.55,147.34) 186.03,147.82 C1033.2 ; v1(182.55,147.34) 182.07,147.83 C3324.2 ; C3025.2 206.07,143.82 v1(206.55,143.34) ; 255.08,78.61 255.11,78.59 C2514.2 ; C2401.2 170.85,78.59 170.88,78.61 ; C1194.2 209.07,136.86 v1(209.55,137.34) ; v1(175.52,127.34) 175.54,127.34 C541.2 ; R3457.1 v1(58.74,79.5) ; C979.2 v1(190.55,133.34) ; C2734.2 212.08,166.88 v1(212.55,167.34) ; v1(169.57,114.29) 169.14,113.85 C2850.2 ; v1(224.55,168.34) 225.04,168.83 C2995.2 ; C2443.2 218.19,89.53 v1(218,89.72) ; C655.2 221.51,118.34 v1(221.55,118.34) ; v1(191.54,114.33) 191.07,113.86 C519.2 ; v1(189.55,151.34) 190.03,150.86 C1042.2 ; v1(180.55,163.34) 180.55,163.31 C426.2 ; v1(110.57,47.95) 110.54,47.99 D396.3 ; v1(172.55,134.37) 172.05,133.87 C572.2 ; v1(328.87,200.78) 333.44,200.78 338.77,195.45 v1(343.09,195.45) v1(355.79,195.45) 358.08,195.45 v1(364.43,189.1) v1(364.43,180.85) ; C3595.1 C3560.2 407.53,176.76 v1(406.82,176.05) ; C204.2 211.08,110.88 v1(211.55,111.34) ; C1000.2 192.03,141.82 v1(192.55,142.34) ; C2474.2 262.32,90.55 v1(262.06,90.29) ; C2461.1 220.89,78.89 ; C2461.1 220.89,80.36 ; C2461.1 221.68,79.63 ; v1(188.55,115.32) 189.02,114.84 C521.2 ; C2204.1 49.24,86.21 ; C2204.1 48.45,85.47 ; C2204.1 49.24,84.73 ; C988.2 192.03,133.86 v1(191.55,134.34) ; D410.3 146.63,47.99 v1(146.64,48) ; v1(177.55,161.34) 177.55,161.32 C413.2 ; v1(182.55,127.34) 182.04,127.85 C3345.2 ; C3537.1 33.59,157.58 v1(33.62,157.6) ; R3160.1 v1(301.89,198.85) ; C1028.2 185.06,145.83 v1(184.55,146.34) ; v1(207.55,154.34) 208.05,154.84 C2857.2 ; R2834.2 v1(302.32,83.69) ; C2895.2 208.03,133.82 v1(208.55,134.34) ; v1(170.55,149.34) 170.57,149.34 C3046.2 ; v1(231.33,85.09) 230.98,85.09 R2775.2 ; C687.2 231.03,148.86 231.56,149.39 v1(231.58,149.39) ; C558.2 171.07,126.84 171.55,127.32 v1(171.52,127.32) ; C589.2 203.1,107.84 v1(203.6,108.34) ; C483.2 167.55,108.33 167.55,108.34 v1(167.52,108.34) ; C411.2 190.08,160.83 v1(190.55,160.37) ; v1(191.55,136.34) 192.03,135.86 C992.2 ; v1(381.64,48) 381.63,47.99 D426.3 ; 349.06,78.61 348.3,78.61 347.89,78.2 C2632.2 ; 334.3,93.19 C2531.1 ; C2531.1 334.3,91.72 ; C2531.1 335.09,92.45 ; v1(206.55,147.34) 206.07,147.82 C2701.2 ; v1(228.58,151.39) 228.56,151.39 228.06,150.9 C719.2 ; v1(185.55,130.34) 186.03,129.86 C1184.2 ; C1219.2 210.03,129.82 v1(210.55,130.34) ; v1(180.55,159.34) 181.05,158.84 C3189.2 ; C593.2 219.11,105.91 v1(219.55,106.34) ; C2210.2 49.49,78.59 ; C2765.2 v1(189.55,155.34) ; v1(230.58,130.39) 230.57,130.39 230.57,130.37 230.55,130.34 230.53,130.34 230.06,129.87 C670.2 ; C2682.2 v1(191.55,124.34) ; v1(279.21,219.33) Q3.2 ; C527.2 177.08,119.87 v1(177.55,120.34) ; v1(141.03,157.1) 141.14,156.99 C3006.2 141.77,157.63 v1(141.67,157.73) ; 63.67,78.59 C2251.2 ; C2716.2 214.03,126.82 v1(214.55,127.34) ; R3489.1 v1(57.34,79.5) ; C3063.2 208.07,143.82 v1(208.55,143.34) ; R388.1 23.36,99.74 23.94,100.33 v1(23.94,100.96) C113.2 ; v1(74.23,85.09) 73.88,85.09 R2664.1 ; v1(207.55,124.34) 207.07,123.86 C30.2 ; C533.2 169.04,117.86 v1(169.55,118.37) ; R3459.1 343.47,86.23 v1(343.34,86.36) ; C742.2 214.55,165.31 v1(214.55,165.37) ; v1(173.55,161.34) 173.52,161.34 C401.2 ; C3019.2 195.07,156.86 v1(195.55,157.34) ; C2233.1 80.1,84.86 ; C2233.1 80.1,86.08 ; C2233.1 79.31,85.47 ; v1(205.55,161.34) 206.03,160.86 C716.2 ; C1228.2 204.03,144.82 v1(203.55,144.34) ; R3174.1 v1(288.81,212.82) ; v1(230.55,138.39) 230.55,138.33 C694.2 ; C547.2 173.55,124.33 v1(173.55,124.34) ; C684.2 v1(253.3,146.56) ; v1(202.55,138.34) 202.03,137.83 C3009.2 ; C478.2 185.03,112.86 v1(184.57,113.32) ; v1(209.55,142.34) 210.02,142.82 C1203.2 ; v1(40.58,92.25) 40.53,92.2 C2201.1 38.65,91.54 38.14,91.03 C2202.2 ; v1(205.55,150.34) 206.02,150.82 C1239.2 ; R3191.1 v1(21.15,179.07) ; R3171.1 v1(288.81,207.24) ; v1(195.55,130.34) 196.03,129.86 C963.2 ; R3445.1 v1(53.15,79.5) ; C1169.2 v1(186.55,129.34) ; C2408.1 210.66,78.89 ; C2408.1 209.87,79.63 ; C2408.1 210.66,80.36 ; v1(192.55,109.34) 192.05,109.84 C475.2 ; v1(164.55,148.29) 164.55,148.33 C3113.2 ; v1(374.84,215.39) 374.71,215.52 C3642.2 C3643.2 ; C652.2 221.51,121.34 v1(221.55,121.34) ; C480.2 170.08,109.82 170.6,110.34 v1(170.6,110.34) ; v1(224.55,112.39) 225.03,112.88 C617.2 ; C2069.1 408,53.59 v1(408.64,52.95) ; C2700.2 206.02,144.82 v1(205.55,144.34) ; C3325.2 v1(214.55,129.34) ; v1(201.55,133.34) 202.03,132.86 C2680.2 ; v1(224.55,124.39) 224.07,124.87 C656.2 ; C1236.2 196.07,146.82 v1(196.55,146.34) ; C2334.1 127.7,79.63 ; C2334.1 126.91,79.02 ; C2334.1 126.91,80.24 ; C638.2 217.05,117.84 v1(217.55,118.34) ; v1(188.55,140.34) 188.07,140.83 C1013.2 ; v1(173.55,146.34) 173.55,146.33 C2973.2 ; 320.97,90.78 C2567.1 ; C2567.1 320.97,89.3 ; C2567.1 321.75,90.04 ; C613.2 221.55,112.33 221.56,112.34 v1(221.58,112.34) ; v1(231.56,162.29) 231.09,162.76 C2783.2 ; C2944.2 214.03,135.82 v1(214.55,136.34) ; v1(204.55,106.34) 205.05,106.84 C206.2 ; C2216.2 96.46,90.68 v1(96.84,90.29) ; C2838.2 202.03,146.82 v1(201.55,146.34) ; C2232.2 90.08,84.43 ; C1154.2 v1(194.55,129.34) ; C2852.2 181.06,129.85 v1(180.55,129.34) ; C284.2 181.04,146.85 v1(180.55,147.34) ; v1(189.55,132.34) 190.03,131.86 C1153.2 ; C3073.2 167.04,150.8 167.55,150.29 v1(167.52,150.29) ; C1180.2 v1(190.55,131.34) ; C3569.1 406.49,171.85 v1(406.59,171.96) ; C3003.2 200.03,140.82 v1(199.55,140.34) ; v1(221.55,109.34) 221.55,109.34 C598.2 ; v1(205.55,140.34) 206.02,140.82 C931.2 ; C1174.2 v1(198.55,132.34) ; v1(215.55,170.34) 216.04,170.83 C2688.2 ; C2518.2 252.79,83.69 ; v1(91.58,76.3) 92.27,76.98 92.27,77.34 91.76,77.85 R2643.1 ; C2663.2 v1(194.55,135.34) ; C1237.2 200.07,149.83 v1(200.55,149.34) ; C3156.2 182.55,134.35 v1(182.55,134.34) ; R3484.1 339.28,79.24 v1(338.97,79.55) ; v1(207.55,148.34) 208.02,148.82 C2875.2 ; v1(224.52,107.34) 224.56,107.34 C596.2 ; R2762.1 v1(227.52,85.34) ; R2868.1 R2901.1 356.81,79.42 v1(356.6,79.63) ; C2376.2 168.59,90.55 v1(168.21,90.93) ; v1(230.55,134.34) 230.55,134.33 C219.2 ; v1(262.19,84.2) 262.19,84.43 261.94,84.68 R2821.1 ; C3648.1 v1(363.18,203.98) ; v1(206.55,132.34) 206.03,131.82 C1244.2 ; C570.2 175.55,133.34 v1(175.55,133.34) ; C1046.2 202.03,128.86 v1(201.55,129.34) ; 92.55,79.98 R2658.2 R2662.1 ; C3586.2 C3596.1 407.62,185.69 v1(407.62,186.45) 407.21,186.45 406.62,187.04 C3591.1 ; C2846.2 231.06,146.83 v1(230.55,147.34) ; C2545.2 v1(287.72,83.69) ; C3551.1 v1(18.28,147.34) ; C2487.2 254.19,83.69 ; C2489.1 254.57,86.1 ; C2489.1 253.84,86.89 ; C2489.1 255.31,86.89 ; C2198.2 12.92,81.25 ; v1(166.52,135.29) 166.55,135.32 166.55,135.33 C564.2 ; v1(187.55,154.34) 187.05,153.85 C52.2 ; v1(210.55,128.34) 210.03,127.82 C2998.2 ; C3062.2 165.05,131.84 v1(164.55,131.34) ; v1(345.57,48) 345.56,47.99 D414.3 ; C743.2 205.55,163.33 v1(205.55,163.34) ; C2596.2 v1(391.48,89.79) ; v1(199.55,135.34) 200.03,134.86 C2800.2 ; v1(199.55,152.34) 199.06,151.85 C945.2 ; C4.2 205.02,153.87 v1(204.55,154.34) ; C958.2 v1(196.55,131.34) ; 171.11,84.68 C2395.1 171.72,85.47 ; C690.2 223.07,139.86 v1(223.55,140.34) ; v1(22.19,167.76) 22.09,167.87 C3536.1 ; R3175.1 v1(288.81,211.05) ; v1(184.55,154.34) 184.08,154.81 C3347.2 ; C275.2 182.08,154.81 v1(182.55,154.34) ; C2264.2 63.67,84.43 ; v1(188.52,165.34) 189.01,164.85 C440.2 ; C1003.2 189.56,143.34 v1(189.55,143.34) ; v1(199.55,113.34) 200.05,112.84 C605.2 ; v1(191.55,149.34) 192.03,148.86 C1189.2 ; 371.44,216.3 C3643.2 ; C3643.2 372.17,215.64 ; v1(217.55,154.34) 218.05,153.84 C2689.2 ; C3104.2 214.03,141.82 v1(214.55,142.34) ; v1(221.55,146.34) 222.02,145.87 C696.2 ; C2321.2 139.87,84.43 ; C2339.1 175.55,90.65 ; C2339.1 175.55,89.43 ; C2339.1 176.34,90.04 ; C1144.2 v1(186.55,127.34) ; C1171.2 v1(188.55,133.34) ; C2754.2 188.05,121.84 v1(188.55,121.34) 188.05,120.84 C3112.2 ; C3039.2 v1(190.55,137.34) ; R3550.1 v1(362.65,206.37) ; C1167.2 192.03,127.86 v1(191.55,128.34) ; C967.2 v1(192.55,137.34) ; C2579.1 319.49,80.36 ; C2579.1 318.71,79.63 ; C2579.1 319.49,78.89 ; C643.2 221.57,117.34 v1(221.55,117.34) ; v1(219.55,164.34) 219.03,163.83 C2902.2 ; C2608.2 347.28,95.12 ; C2532.2 v1(326.83,90.68) ; C561.2 172.02,129.84 v1(171.52,130.34) ; C417.2 186.07,164.86 v1(186.55,165.34) ; C2872.2 203.07,152.83 v1(203.55,152.34) ; C999.2 190.03,137.86 v1(189.55,138.34) ; C926.2 200.07,147.83 v1(200.55,147.34) ; C3495.2 C3494.2 v1(71.95,211.2) ; C2866.2 166.1,138.82 v1(166.55,138.37) 166.55,138.34 C563.2 ; R2879.2 343.6,79.22 v1(343.32,79.5) ; v1(173.55,115.31) 173.55,115.32 173.06,114.83 C498.2 ; C3570.1 410.76,185.57 v1(410.78,185.54) ; C2947.2 194.03,148.86 v1(193.55,149.34) ; Q40.2 v1(33.21,185.8) ; C3.2 204.04,158.84 v1(203.55,158.34) ; v1(199.55,163.34) 199.06,162.86 C2728.2 ; v1(212.55,132.34) 212.03,131.82 C1213.2 ; C925.2 204.07,141.83 v1(204.55,141.34) ; C506.2 191.07,112.82 v1(191.55,112.34) ; C3012.2 195.07,153.86 v1(195.55,154.34) ; v1(187.55,136.34) 188.03,135.86 C1165.2 ; v1(200.55,122.34) 200.05,121.84 C2695.2 ; v1(386.91,24.64) 386.91,25.14 387.16,25.4 D94.2 ; v1(210.55,132.34) 210.03,131.82 C1217.2 ; C2492.2 281.65,84.43 ; 174.31,78.61 174.33,78.59 C2354.2 ; C3480.2 v1(115.61,218.08) ; v1(208.55,119.34) 208.08,118.88 C647.2 ; v1(179.55,138.34) 179.55,138.16 C76.2 ; C989.2 192.03,137.86 v1(191.55,138.34) ; C705.2 219.07,135.86 v1(219.55,136.34) ; v1(185.52,113.34) 185.05,113.82 C509.2 ; v1(189.55,117.34) 189.55,117.37 C542.2 ; v1(210.55,149.34) 211.02,149.82 C1260.2 ; Q2.2 276.22,217.73 v1(275.15,216.66) ; C2660.2 202.55,169.37 v1(202.55,169.34) ; v1(170.55,172.34) 170.06,171.86 C464.2 ; C938.2 204.03,140.82 v1(203.55,140.34) ; v1(193.55,132.34) 194.03,131.86 C2965.2 ; R2882.1 371.28,79.37 371.64,79.73 v1(372.15,79.73) ; C3138.2 169.06,127.83 v1(169.57,128.34) ; v1(397.22,176.05) 396.91,176.05 396.46,176.5 C3573.1 ; v1(190.55,122.34) 191.04,121.85 C2774.2 ; C2507.1 254.85,78.89 ; C2507.1 254.85,80.36 ; C2507.1 254.06,79.63 ; R3287.2 27.62,170.91 v1(27.62,171.45) ; C3564.1 v1(392.14,189.84) ; C2949.2 200.03,135.83 v1(200.55,136.34) ; Q56.2 v1(368.36,158.62) ; C3100.2 172.02,146.84 v1(172.55,147.37) ; v1(177.55,140.34) 177.55,140.16 C3187.2 ; C3567.1 410.02,190.19 410.33,190.5 v1(411.08,190.5) ; v1(204.55,114.31) 204.55,114.33 205.05,114.84 C622.2 ; v1(207.55,137.34) 207.07,136.86 C2740.2 ; C1156.2 v1(198.55,134.34) ; C468.2 v1(141.41,124.33) ; C2527.2 264.83,84.43 ; C494.2 172.55,109.33 v1(172.55,109.34) ; C2347.1 174.08,79.02 ; C2347.1 174.08,80.24 ; C2347.1 173.29,79.63 ; C2386.2 161.13,78.59 161.1,78.61 ; C3190.2 200.03,152.86 v1(199.55,153.34) ; C965.2 v1(186.55,137.34) ; v1(221.58,149.37) 221.06,148.84 C699.2 ; C718.2 220.05,151.84 v1(219.55,152.34) ; D399.3 33.21,48.45 33.21,48.51 33.19,48.54 v1(33.19,48.64) ; C2488.2 268.31,84.43 ; C2974.2 199.59,164.34 v1(199.55,164.34) ; C2933.2 200.54,128.34 v1(200.55,128.34) ; C2254.2 v1(60.77,92.96) ; v1(275.37,79.32) 275.07,79.32 274.76,79.02 R2822.2 ; R2699.2 123.25,79.45 v1(123.2,79.5) ; C1020.2 186.03,150.86 v1(185.55,151.34) ; v1(173.55,130.34) 173.52,130.34 C560.2 ; v1(227.55,128.39) 228.01,127.93 C2816.2 ; D419.3 82.61,47.99 v1(82.62,48) ; v1(225.58,144.35) 225.08,144.85 C707.2 ; C3321.2 182.07,150.83 v1(182.55,150.34) ; 33.34,114.73 v1(33.34,113.66) ; 33.34,114.73 v1(33.34,115.82) ; 33.34,114.73 v1(34.53,114.73) ; C635.2 208.08,116.88 v1(208.55,117.34) ; v1(211.55,152.34) 212.05,152.84 C2764.2 ; v1(184.55,150.34) 184.07,150.83 C1037.2 ; v1(187.55,141.34) 187.55,141.35 C1004.2 ; v1(200.55,141.34) 200.07,141.83 C2775.2 ; R3451.1 v1(337.88,79.5) ; v1(198.55,151.34) 199.06,150.83 C2920.2 ; v1(210.55,134.34) 210.03,133.82 C1257.2 ; C3322.2 210.05,153.85 v1(210.55,154.34) ; C2614.2 352.51,84.43 ; C2981.2 214.03,143.82 v1(214.55,144.34) ; R2904.1 v1(380.53,78.84) ; Q53.2 v1(159.58,212.15) ; C1155.2 v1(190.55,127.34) ; R3162.1 v1(300.49,198.85) ; C2985.2 206.02,146.82 v1(205.55,146.34) ; R3165.1 v1(297.32,198.85) ; R2744.1 167.58,85.6 v1(168.21,86.23) ; C2996.2 v1(183.55,124.34) ; C3525.1 v1(19.67,167.74) ; C744.2 204.05,161.85 203.55,162.35 v1(203.55,162.37) ; C2542.2 v1(335.47,89.66) ; C2887.2 208.03,125.86 v1(207.55,126.34) ; C1269.2 212.02,140.82 v1(211.55,140.34) ; C942.2 202.07,147.83 v1(202.55,147.34) ; C2737.2 218.07,172.82 v1(218.55,172.34) ; C403.2 172.02,151.84 171.55,152.32 v1(171.52,152.32) ; C2310.2 124.93,89.18 124.45,88.69 v1(124.02,88.69) ; C2562.2 333.08,84.43 ; v1(211.55,115.34) 211.08,114.88 C607.2 ; C3568.1 v1(393.28,173.84) ; C2211.1 62.45,89.43 ; C2211.1 62.45,90.65 ; C2211.1 61.66,90.04 ; v1(199.6,108.34) 200.05,107.9 C583.2 ; R3172.1 v1(288.81,209.9) ; v1(214.55,147.34) 214.03,146.82 C2742.2 ; C3081.2 v1(177.55,149.34) ; C2303.2 140.65,94.23 ; v1(195.55,148.34) 195.07,147.86 C1043.2 ; v1(211.55,148.34) 211.55,148.3 C1262.2 ; 217.87,90.55 C2447.2 ; C3499.1 v1(20.99,193.16) ; C3546.1 v1(16.09,154.94) ; C2070.1 403.64,53.11 403.8,52.95 v1(404.3,52.95) ; C1197.2 210.02,148.82 v1(209.55,148.34) ; C2592.2 316.27,84.43 ; C2849.2 225.06,150.83 v1(225.55,150.34) ; C673.2 221.07,135.85 221.56,136.34 v1(221.58,136.34) ; C2187.2 36.92,98.4 v1(36.39,98.93) ; C3076.2 227.55,173.27 v1(227.55,173.2) ; C102.2 191.07,153.86 v1(191.55,154.34) ; C2918.2 169.55,115.35 v1(169.55,115.32) ; R2799.2 v1(271.72,85.34) ; C976.2 v1(184.55,137.34) ; C2271.1 77.13,84.86 ; C2271.1 77.13,86.08 ; C3080.2 196.03,135.86 v1(195.55,136.34) ; C675.2 230.23,127.68 230.55,127.36 230.55,127.3 230.56,127.29 v1(230.58,127.29) ; C2267.1 99.48,86.08 ; C2267.1 100.27,85.47 ; C2267.1 99.48,84.86 ; v1(63.57,48) 63.56,47.99 D411.3 ; v1(203.55,133.34) 204.03,132.86 C2870.2 ; C2564.2 v1(313.63,89.53) ; v1(225.55,127.34) 226.04,126.85 C680.2 ; 264.86,78.61 264.83,78.59 C2529.2 ; C983.2 190.03,135.86 v1(189.55,136.34) ; C2460.2 220.64,84.43 ; C2625.1 364.68,79.63 ; C2625.1 365.47,80.36 ; C2625.1 365.47,78.89 ; C2396.2 170.85,84.43 ; C616.2 223.08,115.85 223.57,116.34 v1(223.58,116.34) ; v1(182.55,145.34) 182.06,145.83 C2819.2 ; C2281.1 129.88,84.86 ; C2281.1 129.88,86.08 ; C2281.1 129.1,85.47 ; C1170.2 190.03,133.86 v1(189.55,134.34) ; v1(173.56,155.37) 173.06,154.87 C409.2 ; v1(195.55,167.34) 195.08,166.88 C445.2 ; C2164.2 45.89,84.43 ; Q39.2 v1(34.42,180.79) ; C3492.2 v1(71.95,212.21) ; 371.92,84.07 C2617.1 ; C2617.1 371.26,83.28 ; C2617.1 372.78,83.28 ; C3152.2 179.05,160.84 v1(178.55,161.34) ; C2294.2 116.93,84.43 ; v1(175.51,155.37) 176.03,154.84 C2827.2 ; v1(172.55,122.37) 173.04,121.88 C537.2 ; v1(268.19,48.64) 268.19,48.54 268.21,48.51 268.21,48.45 D418.3 ; C3116.2 183.05,153.85 v1(183.55,154.34) ; 138.87,99.51 C2361.1 139.92,98.91 v1(140.02,98.8) ; C2780.2 182.03,135.86 v1(182.55,135.34) ; C438.2 192.56,166.34 v1(192.55,166.34) ; C1250.2 195.07,143.82 v1(195.55,143.34) 195.07,142.86 C1253.2 ; C491.2 196.04,109.85 v1(196.55,109.34) ; v1(203.14,82.04) 202.6,82.57 C2422.2 ; C406.2 171.55,154.34 v1(171.55,154.34) ; C3151.2 v1(185.55,124.34) ; C2621.2 385.48,77.7 ; C553.2 v1(169.55,129.34) ; C997.2 186.03,137.86 v1(185.55,138.34) ; C662.2 221.07,133.87 220.6,134.34 v1(220.57,134.34) ; C968.2 v1(188.55,137.34) ; C93.2 195.07,151.82 v1(195.55,151.34) ; C2606.2 389.09,83.54 ; v1(169.52,159.37) 169.55,159.37 169.03,158.85 C395.2 ; C943.2 200.03,137.83 v1(200.55,138.34) ; v1(205.55,135.34) 206.03,134.86 C1243.2 ; C2482.2 268.31,78.59 268.29,78.61 ; v1(7.61,127.96) C3653.1 6.79,126.87 v1(6.54,127.12) ; C2889.2 227.98,168.91 227.55,169.34 v1(227.54,169.34) ; v1(176.62,48) 176.61,47.99 D420.3 ; C2943.2 202.03,142.82 v1(201.55,142.34) ; v1(183.55,132.34) 184.03,131.86 C1168.2 ; C714.2 230.55,151.27 v1(230.55,151.39) ; v1(69.65,85.46) R2634.1 ; C53.2 v1(185.55,155.34) ; C2314.2 133.67,91.44 v1(133.29,91.06) ; C1221.2 204.07,149.83 v1(204.55,149.34) ; C3501.2 v1(35.73,195.32) ; R3214.1 v1(28.66,195.83) ; v1(169.56,112.37) 169.07,111.88 C482.2 ; v1(199.55,142.34) 200.03,142.82 C2715.2 ; v1(209.55,126.34) 210.03,125.86 C3123.2 ; v1(229.58,107.34) 229.56,107.34 C2856.2 ; C981.2 v1(192.55,133.34) ; C2951.2 179.55,126.35 v1(179.55,126.34) ; C730.2 219.06,148.85 v1(219.55,149.34) ; C1005.2 196.07,148.82 v1(196.55,148.34) ; R3182.2 v1(304.99,203.93) ; C3130.2 214.08,158.88 v1(214.55,159.34) ; C515.2 167.04,115.83 167.55,116.34 v1(167.52,116.34) ; C969.2 v1(194.55,133.34) ; C400.2 175.52,161.34 v1(175.55,161.34) ; C3558.1 v1(31.56,147.34) ; C3530.1 16.12,151.97 v1(16.09,151.99) 16.12,152.02 C3533.1 ; R3260.1 v1(17.08,171.45) ; D403.3 35.61,47.99 v1(35.62,48) ; C3023.2 175.5,149.39 v1(175.5,149.39) ; C1182.2 v1(186.55,131.34) ; C2623.2 389.09,77.7 ; C2466.2 237.45,78.59 ; R3380.2 v1(405.96,193.42) ; C2356.2 184.06,84.43 ; C1044.2 183.07,151.83 v1(183.55,151.34) ; v1(214.55,132.34) 214.03,131.82 C3330.2 ; C115.2 v1(410.2,116.58) ; C433.2 174.52,164.34 174.52,164.34 v1(174.55,164.32) ; C3074.2 200.58,167.34 v1(200.55,167.34) ; C3096.2 v1(158.81,130.17) ; R2199.1 375.12,169.39 v1(375.35,169.16) ; v1(210.55,152.34) 210.03,151.82 C2879.2 ; C3500.2 v1(10.73,191.41) ; v1(193.55,136.34) 194.03,135.86 C972.2 ; C973.2 v1(194.55,131.34) ; 12.66,75.71 C2149.1 11.87,76.32 ; C711.2 253.02,152.91 v1(253.3,152.63) ; C591.2 222.21,106.04 v1(222.52,106.34) ; C2552.2 329.48,84.43 ; C747.2 212.06,165.83 v1(212.55,165.35) ; R3404.2 v1(400.88,193.42) ; C3054.2 204.03,124.82 v1(203.55,124.34) ; v1(185.55,126.34) 186.03,125.86 C2769.2 ; 115.89,85.47 C2293.1 116.68,84.86 ; C2236.2 93.69,84.43 ; C2612.2 385.48,83.54 ; R266.1 v1(9.33,100.96) ; C3329.2 205.07,152.83 v1(205.55,152.34) ; C488.2 177.53,109.34 v1(177.55,109.34) ; C1185.2 v1(188.55,127.34) ; v1(260.41,85.34) R2817.2 ; C3589.1 407.49,175.25 v1(407.62,175.25) ; v1(217.55,149.34) 217.06,148.85 C720.2 ; C991.2 v1(196.55,135.34) ; C2158.2 45.89,78.59 ; Q50.2 v1(365.64,207.19) ; C2072.2 v1(402.65,54.73) ; C2484.2 278.04,84.43 ; R3461.1 v1(60.13,79.5) ; C2333.2 126.66,84.43 ; C3496.2 v1(71.95,214.25) ; C1175.2 v1(186.55,133.34) ; C2290.2 v1(108.04,82.83) ; C2272.2 76.87,84.43 ; v1(134.44,85.35) 133.81,85.35 133.54,85.09 R2682.1 ; v1(167.55,154.34) 167.04,154.85 C402.2 ; R3161.1 v1(303.67,198.85) ; R3456.1 v1(345.86,81.51) ; 76.87,78.59 C2274.2 ; C3024.2 v1(195.55,124.34) ; C2346.2 v1(190.06,89.66)
  BOTTOM w0.508: 151.17,144.5 C3015.2 ; C3015.2 150.41,143.79 ; C3015.2 149.57,144.5
  vias: v1(0.75,222.98) v1(0.75,221.71) v1(0.75,220.44) v1(0.75,219.17) v1(0.75,217.9) v1(0.75,216.63) v1(0.75,215.36) v1(0.75,214.09) v1(0.75,212.82) v1(0.75,211.55) v1(0.75,210.28) v1(0.75,209.01) v1(0.75,207.74) v1(0.75,206.47) v1(0.75,205.2) v1(0.75,203.93) v1(0.75,202.66) v1(0.75,201.39) v1(0.75,200.12) v1(0.75,198.85) v1(0.75,197.58) v1(0.75,196.31) v1(0.75,195.04) v1(0.75,193.77) v1(0.75,192.5) v1(0.75,191.23) v1(0.75,189.96) v1(0.75,188.69) v1(0.75,187.42) v1(0.75,186.15) v1(0.75,179.8) v1(0.75,178.53) v1(0.75,177.26) v1(0.75,175.99) v1(0.75,168.37) v1(0.75,167.1) v1(0.75,165.83) v1(0.75,164.56) v1(0.75,163.29) v1(0.75,162.02) v1(0.75,160.75) v1(0.75,159.48) v1(0.75,158.21) v1(0.75,156.94) v1(0.75,155.67) v1(0.75,154.4) v1(0.75,153.13) v1(0.75,151.86) v1(0.75,150.59) v1(0.75,149.32) v1(0.75,148.05) v1(0.75,146.78) v1(0.75,145.51) v1(0.75,144.24) v1(0.75,142.97) v1(0.75,141.7) v1(0.75,140.43) v1(0.75,139.16) v1(0.75,137.89) v1(0.75,136.62) v1(0.75,135.35) v1(0.75,134.08) v1(0.75,132.81) v1(0.75,131.54) v1(0.75,130.27) v1(0.75,129) v1(0.75,127.73) v1(0.75,126.46) v1(0.75,125.19) v1(0.75,123.92) v1(0.75,122.65) v1(0.75,121.38) v1(0.75,120.11) v1(0.75,118.84) v1(0.75,117.57) v1(0.75,116.3) v1(0.75,115.03) v1(0.75,113.76) v1(0.75,112.49) v1(0.75,111.22) v1(0.75,109.95) v1(0.75,108.68) v1(0.75,107.41) v1(0.75,106.14) v1(0.75,104.87) v1(0.75,103.6) v1(0.75,102.33) v1(0.75,101.06) v1(0.75,99.79) v1(0.75,98.52) v1(0.75,97.25) v1(0.75,95.98) v1(0.75,89.63) v1(0.75,88.36) v1(0.75,87.09) v1(0.75,85.82) v1(0.75,84.55) v1(0.75,83.28) v1(0.75,82.01) v1(0.75,80.74) v1(0.75,79.47) v1(0.75,78.2) v1(0.75,76.93) v1(0.75,75.66) v1(0.75,74.39) v1(0.75,73.12) v1(0.75,71.85) v1(0.75,70.58) v1(0.75,69.31) v1(0.75,68.04) v1(0.75,66.77) v1(0.75,65.5) v1(0.75,64.23) v1(0.75,62.96) v1(0.75,61.69) v1(0.75,60.42) v1(0.75,59.15) v1(0.75,57.88) v1(0.75,56.61) v1(0.75,55.34) v1(0.75,54.07) v1(0.75,52.8) v1(0.75,51.53) v1(0.75,50.26) v1(0.75,48.99) v1(0.75,47.72) v1(0.75,46.45) v1(0.75,45.18) v1(0.75,43.91) v1(0.75,42.64) v1(0.75,41.37) v1(0.75,40.1) v1(0.75,38.83) v1(0.75,37.56) v1(0.75,36.29) v1(0.75,35.02) v1(0.75,33.75) v1(0.75,32.48) v1(0.75,31.21) v1(0.75,29.94) v1(0.75,28.67) v1(0.95,174.75) v1(1.13,169.64) v1(1.84,174.11) v1(2.1,223.14) v1(2.4,169.9) v1(3.11,174.11) v1(3.37,223.14) v1(3.8,169.9) v1(4.43,174.09) v1(4.64,223.14) v1(5.19,169.9) v1(5.91,223.14) v1(6.21,173.84) v1(6.21,172.44) v1(6.21,170.91) v1(6.79,163.32) v1(7.18,223.14) v1(7.68,122.81) v1(7.68,120.52) v1(8.45,223.14) v1(8.83,122.81) v1(8.83,120.52) v1(9.72,223.14) v1(9.84,185.42) v1(9.97,122.81) v1(9.97,120.52) v1(10.35,189.48) v1(10.6,162.81) v1(10.6,161.54) v1(10.6,160.53) v1(10.86,184.15) v1(10.86,169.54) v1(10.86,167.51) v1(10.99,223.39) v1(11.11,122.81) v1(11.11,121.66) v1(11.11,120.52) v1(11.37,157.1) v1(11.49,158.24) v1(11.49,155.95) v1(11.49,154.81) v1(11.54,224.25) v1(12.26,122.81) v1(12.26,121.66) v1(12.26,120.52) v1(12.81,224.25) v1(13.02,189.48) v1(13.4,186.56) v1(14.08,224.25) v1(14.03,193.16) v1(14.29,178.05) v1(15.35,224.25) v1(15.56,195.45) v1(15.94,172.46) v1(15.94,91.82) v1(16.57,185.93) v1(16.57,178.05) v1(16.62,224.25) v1(17.21,193.67) v1(17.21,83.94) v1(17.34,173.48) v1(17.89,224.25) v1(18.22,76.2) v1(18.61,186.81) v1(19.16,224.25) v1(20,178.18) v1(20.43,224.25) v1(21.02,194.82) v1(21.7,224.25) v1(22.8,187.83) v1(22.97,224.25) v1(23.69,145.67) v1(23.81,178.18) v1(24.05,165.4) v1(24.24,224.25) v1(24.57,29.46) v1(24.7,44.96) v1(24.7,40.13) v1(24.7,34.16) v1(24.96,141.98) v1(24.96,139.06) v1(25.34,184.78) v1(25.46,101.98) v1(25.51,224.25) v1(25.84,137.67) v1(26.1,187.7) v1(26.78,224.25) v1(26.73,194.05) v1(27.62,145.54) v1(27.88,184.78) v1(28.05,224.25) v1(28.89,187.7) v1(29.27,143.51) v1(29.31,140.92) v1(29.32,224.25) v1(29.65,184.53) v1(29.78,88.87) v1(30.59,224.25) v1(30.92,88.87) v1(31.18,96.9) v1(31.31,205.48) v1(31.31,204.59) v1(31.86,224.25) v1(31.81,190.24) v1(31.94,145.03) v1(32.07,88.87) v1(33.13,224.25) v1(33.34,197.74) v1(33.59,192.66) v1(33.59,189.23) v1(33.62,154.79) v1(33.72,205.48) v1(33.72,204.59) v1(34.4,224.25) v1(35.37,129.79) v1(35.37,127.51) v1(35.67,224.25) v1(36.51,129.79) v1(36.51,127.51) v1(36.94,224.25) v1(37.66,129.79) v1(37.66,127.51) v1(38.21,224.25) v1(38.29,167) v1(38.29,165.86) v1(38.42,168.15) v1(38.8,129.79) v1(38.8,128.65) v1(38.8,127.51) v1(39.18,164.84) v1(39.31,161.24) v1(39.48,224.25) v1(39.81,195.32) v1(39.94,129.79) v1(39.94,128.65) v1(39.94,127.51) v1(40.75,224.25) v1(41.72,80.52) v1(42.02,224.25) v1(42.48,202.56) v1(42.48,200.02) v1(42.48,189.23) v1(42.48,186.69) v1(42.48,44.96) v1(42.48,40.13) v1(42.48,34.16) v1(42.48,29.21) v1(43.29,224.25) v1(43.24,88.64) v1(43.75,202.56) v1(43.75,200.02) v1(43.75,189.23) v1(43.75,186.69) v1(43.85,89.38) v1(44.56,224.25) v1(45.02,202.56) v1(45.02,200.02) v1(45.02,189.23) v1(45.02,186.69) v1(45.28,140.97) v1(45.28,139.7) v1(45.83,224.25) v1(46.55,140.97) v1(46.55,139.7) v1(46.93,171.96) v1(46.93,169.29) v1(47.1,224.25) v1(47.05,151.13) v1(47.05,148.46) v1(47.31,160.65) v1(47.82,140.97) v1(47.82,139.7) v1(48.2,171.96) v1(48.2,169.29) v1(48.37,224.25) v1(48.32,162.94) v1(48.32,151.13) v1(48.32,148.46) v1(49.34,171.96) v1(49.34,169.29) v1(49.59,151.13) v1(49.59,148.46) v1(49.64,224.25) v1(50.36,186.43) v1(50.36,171.96) v1(50.36,169.29) v1(50.36,155.83) v1(50.86,151.13) v1(50.86,148.46) v1(50.91,224.25) v1(52.18,224.25) v1(52.14,184.91) v1(52.14,175.13) v1(52.14,164.72) v1(52.14,155.7) v1(52.26,92.58) v1(53.02,89.79) v1(53.45,224.25) v1(53.66,150.11) v1(53.91,176.78) v1(53.91,169.42) v1(53.91,164.59) v1(54.04,186.31) v1(54.55,181.46) v1(54.57,179.93) v1(54.55,161.14) v1(54.57,159.61) v1(54.55,140.82) v1(54.57,139.29) v1(54.72,224.25) v1(55,151.97) v1(55.13,180.69) v1(55.13,160.37) v1(55.13,140.05) v1(55.18,117.35) v1(55.69,181.46) v1(55.66,179.93) v1(55.69,161.14) v1(55.66,159.61) v1(55.69,140.82) v1(55.66,139.29) v1(55.99,224.25) v1(55.94,193.29) v1(55.94,121.54) v1(55.94,119.12) v1(56.32,83.69) v1(56.45,174.24) v1(56.48,108.2) v1(56.55,178.92) v1(56.55,158.6) v1(56.68,182.34) v1(56.68,162.02) v1(56.71,30.1) v1(56.96,152.52) v1(57.21,108.89) v1(57.26,224.25) v1(57.67,137.39) v1(57.72,176.27) v1(57.85,123.57) v1(57.99,186.18) v1(58.12,165.48) v1(58.48,203.96) v1(58.53,224.25) v1(58.8,193.74) v1(59.69,191.77) v1(59.69,186.18) v1(59.8,224.25) v1(60.13,165.48) v1(60.95,90.55) v1(60.95,89.53) v1(61.02,205.61) v1(61.02,203.96) v1(61.15,122.17) v1(61.4,145.16) v1(61.54,188.08) v1(61.53,182.62) v1(61.53,155.32) v1(61.53,141.98) v1(61.66,162.3) v1(61.91,113.54) v1(62.29,199.77) v1(62.93,113.54) v1(63.13,181.2) v1(63.16,150.59) v1(63.18,149.48) v1(63.44,179.83) v1(63.42,178.45) v1(63.44,159.51) v1(63.46,129.16) v1(63.46,128.24) v1(63.56,144.14) v1(63.55,138.17) v1(63.69,205.61) v1(63.69,203.96) v1(64.4,179.8) v1(64.33,165.1) v1(64.33,159.51) v1(64.4,129.16) v1(64.4,128.24) v1(64.45,169.9) v1(64.53,149.45) v1(64.83,196.85) v1(66.36,205.61) v1(66.36,203.96) v1(66.87,194.91) v1(67.88,44.96) v1(67.88,40.13) v1(67.88,29.08) v1(68.01,198.5) v1(69.28,34.29) v1(69.35,183.49) v1(69.35,182.6) v1(69.35,173.33) v1(69.35,172.44) v1(69.35,163.17) v1(69.35,162.28) v1(69.35,153.01) v1(69.35,152.12) v1(69.35,142.85) v1(69.35,141.96) v1(69.35,132.69) v1(69.35,131.8) v1(69.53,90.5) v1(69.99,183.49) v1(69.99,182.6) v1(69.99,173.33) v1(69.99,172.44) v1(69.99,163.17) v1(69.99,162.28) v1(69.99,153.01) v1(69.99,152.12) v1(69.99,142.85) v1(69.99,141.96) v1(69.99,132.69) v1(69.99,131.8) v1(70.19,91.11) v1(70.8,200.05) v1(71.13,185.77) v1(71.13,184.88) v1(71.13,184) v1(71.13,183.26) v1(71.13,182.34) v1(71.13,177.01) v1(71.13,175.61) v1(71.13,174.72) v1(71.13,173.84) v1(71.13,173.1) v1(71.13,172.18) v1(71.13,165.45) v1(71.13,164.56) v1(71.13,163.68) v1(71.13,162.94) v1(71.13,162.02) v1(71.13,155.29) v1(71.13,154.4) v1(71.13,153.52) v1(71.13,152.78) v1(71.13,151.86) v1(71.13,146.53) v1(71.13,145.13) v1(71.13,144.24) v1(71.13,143.36) v1(71.13,142.62) v1(71.13,141.7) v1(71.13,136.37) v1(71.13,134.97) v1(71.13,134.08) v1(71.13,133.2) v1(71.13,132.46) v1(71.13,131.54) v1(71.23,224.25) v1(71.44,81.28) v1(71.44,74.42) v1(71.64,130.02) v1(71.7,44.96) v1(72.15,185.77) v1(72.15,184.88) v1(72.15,184) v1(72.15,183.23) v1(72.15,182.34) v1(72.15,175.61) v1(72.15,174.72) v1(72.15,173.84) v1(72.15,173.07) v1(72.15,172.18) v1(72.15,165.45) v1(72.15,164.56) v1(72.15,163.68) v1(72.15,162.91) v1(72.15,162.02) v1(72.15,155.29) v1(72.15,154.4) v1(72.15,153.52) v1(72.15,152.75) v1(72.15,151.86) v1(72.15,145.13) v1(72.15,144.24) v1(72.15,143.36) v1(72.15,142.59) v1(72.15,141.7) v1(72.15,134.97) v1(72.15,134.08) v1(72.15,133.2) v1(72.15,132.43) v1(72.15,131.54) v1(72.5,224.25) v1(72.45,76.32) v1(73.77,224.25) v1(74.61,196.85) v1(75.04,224.25) v1(75.76,209.42) v1(76.31,224.25) v1(77.58,224.25) v1(77.91,194.91) v1(78.04,200.15) v1(78.04,198.5) v1(78.85,224.25) v1(80.12,224.25) v1(81.39,224.25) v1(82.66,224.25) v1(82.87,200.15) v1(82.87,198.47) v1(82.87,89.41) v1(83.5,90.04) v1(83.93,224.25) v1(84.9,75.44) v1(85.81,81.3) v1(86.04,76.32) v1(86.68,85.34) v1(87.31,196.85) v1(88.2,44.96) v1(88.2,40.13) v1(88.2,34.16) v1(88.2,29.21) v1(89.01,224.25) v1(89.48,44.96) v1(89.72,216.6) v1(89.72,209) v1(90.28,224.25) v1(90.69,219.2) v1(90.69,211.6) v1(90.61,194.91) v1(90.87,69.87) v1(91.38,200.12) v1(91.5,86.38) v1(91.55,224.25) v1(91.97,220.4) v1(91.97,216.6) v1(91.97,212.8) v1(91.97,209) v1(92.01,85.47) v1(92.39,86.41) v1(92.82,224.25) v1(92.94,223) v1(92.94,219.2) v1(92.94,215.4) v1(92.94,211.6) v1(94.09,224.25) v1(95.36,224.25) v1(95.57,198.5) v1(96.63,224.25) v1(97.9,224.25) v1(99.17,224.25) v1(99.76,73.99) v1(100.01,196.85) v1(100.44,224.25) v1(101.71,224.25) v1(101.72,220.4) v1(101.72,216.6) v1(101.72,209) v1(102.04,86.1) v1(102.69,223) v1(102.69,219.2) v1(102.69,211.6) v1(102.98,224.25) v1(103.31,194.91) v1(103.97,220.4) v1(103.97,216.6) v1(103.97,212.8) v1(103.97,209) v1(104.08,200.17) v1(104.25,224.25) v1(104.94,223) v1(104.94,219.2) v1(104.94,215.4) v1(104.94,211.6) v1(105.52,224.25) v1(106.62,84.71) v1(106.79,224.25) v1(108.06,224.25) v1(109.03,198.5) v1(113.14,224.25) v1(113.47,196.85) v1(113.6,44.96) v1(113.6,40.13) v1(113.6,34.16) v1(113.6,29.08) v1(114.14,189.41) v1(114.14,186.69) v1(114.14,185.8) v1(114.14,183.08) v1(114.41,224.25) v1(115.51,194.82) v1(115.68,224.25) v1(116.01,200.17) v1(116.95,224.25) v1(118.22,224.25) v1(118.94,207.01) v1(119.49,224.25) v1(119.44,90.83) v1(119.95,74.17) v1(120.08,91.46) v1(120.71,198.5) v1(120.97,73.51) v1(121.22,80.39) v1(121.73,207.01) v1(122.24,77.21) v1(122.62,207.01) v1(125.41,207.01) v1(125.41,196.85) v1(126.3,207.01) v1(128.08,187.45) v1(128.08,180.72) v1(128.21,174.11) v1(128.21,168.15) v1(128.21,162) v1(128.21,156.08) v1(128.21,150.19) v1(128.21,141.09) v1(128.71,194.91) v1(128.91,192.02) v1(129.1,207.01) v1(129.48,200.15) v1(129.82,192.02) v1(129.98,207.01) v1(130.04,133.73) v1(130.37,187.45) v1(130.49,143.38) v1(130.62,170.81) v1(130.62,158.49) v1(130.75,178.18) v1(130.92,224.25) v1(130.98,191.77) v1(132.19,224.25) v1(132.65,90.42) v1(132.78,207.01) v1(133.16,191.76) v1(133.29,183.64) v1(133.29,167.13) v1(133.41,175.13) v1(133.46,224.25) v1(133.54,158.49) v1(133.67,198.5) v1(133.92,134.72) v1(134.32,192.02) v1(134.66,77.21) v1(134.73,224.25) v1(135.23,192.02) v1(135.6,75.44) v1(135.7,186.69) v1(135.7,178.18) v1(135.7,169.54) v1(136,224.25) v1(135.95,145.92) v1(136.21,161.16) v1(136.33,149.35) v1(136.94,122.81) v1(137.1,115.69) v1(137.1,110.74) v1(137.27,224.25) v1(137.35,126.18) v1(137.35,120.27) v1(138.11,196.85) v1(138.37,100.07) v1(138.54,224.25) v1(139,40.13) v1(139,34.16) v1(139,29.21) v1(139.81,224.25) v1(140.14,128.98) v1(140.14,120.01) v1(140.14,94.99) v1(140.25,138.05) v1(140.27,123.19) v1(140.4,141.17) v1(140.37,132.15) v1(140.78,129.61) v1(140.91,153.79) v1(140.91,147.57) v1(140.91,144.65) v1(140.88,138.68) v1(140.91,95.76) v1(141.01,132.79) v1(141.08,224.25) v1(141.03,171.88) v1(141.03,168.91) v1(141.03,165.99) v1(141.03,160.07) v1(141.16,175) v1(141.16,103.25) v1(141.39,112.77) v1(141.36,111.76) v1(141.36,110.36) v1(141.41,194.91) v1(141.41,121.28) v1(141.41,117.47) v1(141.41,116.51) v1(141.41,115.62) v1(141.41,100.2) v1(141.49,92.5) v1(141.54,148.21) v1(141.54,145.29) v1(141.54,96.39) v1(141.67,172.51) v1(141.67,169.54) v1(141.67,166.62) v1(141.67,160.7) v1(141.8,175.64) v1(141.8,103.88) v1(142.18,200.2) v1(142.35,224.25) v1(142.38,92.5) v1(142.43,176.27) v1(142.68,110.74) v1(142.68,108.58) v1(142.81,211.83) v1(143.07,184.78) v1(143.07,176.91) v1(143.62,224.25) v1(143.7,211.83) v1(143.7,177.54) v1(144.72,211.83) v1(144.89,224.25) v1(145.86,90.68) v1(145.86,89.66) v1(146.16,224.25) v1(146.24,213.1) v1(146.37,198.5) v1(147.03,75.69) v1(147.03,74.55) v1(147.26,213.1) v1(147.43,224.25) v1(148.27,213.1) v1(148.53,143.25) v1(148.7,224.25) v1(149.16,143.89) v1(149.29,213.1) v1(149.29,115.57) v1(149.39,135.25) v1(149.42,171.45) v1(149.8,111.66) v1(149.8,110.69) v1(149.8,109.5) v1(149.8,108.48) v1(149.8,107.46) v1(149.8,106.32) v1(149.97,224.25) v1(149.92,112.65) v1(150.05,174.97) v1(150.03,135.89) v1(150.05,75.69) v1(150.3,116.33) v1(150.3,102.11) v1(150.66,136.52) v1(151.24,224.25) v1(151.24,112.21) v1(151.24,109.5) v1(151.24,108.48) v1(151.24,107.46) v1(151.24,106.32) v1(151.32,111.12) v1(151.5,114.17) v1(151.5,113.18) v1(151.52,143.3) v1(152.08,75.69) v1(152.21,143.89) v1(152.51,224.25) v1(153.1,174.96) v1(153.23,156.16) v1(153.23,143.85) v1(153.48,116.33) v1(153.48,115.44) v1(153.78,224.25) v1(153.73,130.17) v1(153.96,114.32) v1(154.24,156.16) v1(154.24,143.85) v1(154.37,117.22) v1(154.37,116.33) v1(154.37,115.44) v1(154.75,130.17) v1(155.05,224.25) v1(155.13,143.85) v1(155.38,117.22) v1(155.38,116.33) v1(155.64,130.17) v1(155.87,203.99) v1(156.15,201.83) v1(156.15,143.85) v1(156.32,224.25) v1(156.65,117.22) v1(156.78,130.17) v1(156.83,154.1) v1(156.91,128.01) v1(157.04,156.16) v1(157.04,143.85) v1(157.16,200.28) v1(157.29,141.73) v1(157.59,224.25) v1(157.67,130.17) v1(157.92,198.5) v1(157.92,166.49) v1(158.05,156.16) v1(158.05,143.85) v1(158.51,115.52) v1(158.86,224.25) v1(158.94,156.16) v1(158.94,143.85) v1(159.17,116.18) v1(159.55,154.04) v1(159.8,116.81) v1(159.96,156.16) v1(159.96,143.85) v1(159.96,128.01) v1(160.04,141.7) v1(160.08,108.61) v1(160.08,103.76) v1(160.08,101.98) v1(160.13,224.25) v1(160.34,109.34) v1(161.4,224.25) v1(162.19,210.31) v1(162.67,224.25) v1(162.93,208.53) v1(163,99.82) v1(163,98.93) v1(163,97.91) v1(163,95.88) v1(163.51,170.27) v1(163.51,165.39) v1(163.51,161.42) v1(163.51,157.42) v1(163.51,155.83) v1(163.51,153.4) v1(163.51,149.42) v1(163.51,145.39) v1(163.51,141.39) v1(163.51,136.42) v1(163.51,132.39) v1(163.51,128.4) v1(163.51,124.42) v1(163.51,120.42) v1(163.51,116.39) v1(163.51,112.42) v1(163.51,108.39) v1(163.54,169.4) v1(163.54,166.29) v1(163.54,162.29) v1(163.54,158.29) v1(163.54,154.3) v1(163.54,150.29) v1(163.54,146.29) v1(163.54,142.29) v1(163.54,137.3) v1(163.54,133.29) v1(163.54,129.29) v1(163.54,125.29) v1(163.54,121.29) v1(163.54,117.29) v1(163.54,113.29) v1(163.54,109.29) v1(163.67,206.75) v1(163.67,90.37) v1(163.64,89.48) v1(163.94,224.25) v1(164.27,40.51) v1(164.4,204.98) v1(164.4,44.96) v1(164.4,34.16) v1(164.4,29.21) v1(164.58,90.42) v1(164.66,187.58) v1(164.78,193.93) v1(165.16,73.43) v1(165.21,224.25) v1(165.42,79.5) v1(165.54,187.58) v1(165.67,193.93) v1(166.31,181.23) v1(166.48,224.25) v1(166.43,80.39) v1(167.2,181.23) v1(167.55,173.09) v1(167.58,99.69) v1(167.75,224.25) v1(169.02,224.25) v1(169.99,187.58) v1(170.29,224.25) v1(170.62,208.53) v1(170.62,204.98) v1(170.88,193.55) v1(170.88,187.58) v1(171.56,224.25) v1(171.77,193.55) v1(172.83,224.25) v1(174.1,224.25) v1(175.37,224.25) v1(175.58,91.18) v1(176.09,187.58) v1(176.21,193.55) v1(176.34,91.95) v1(176.64,224.25) v1(176.85,91.06) v1(176.97,187.58) v1(177.1,193.55) v1(177.69,210.31) v1(177.74,206.75) v1(177.91,224.25) v1(178.37,94.46) v1(178.75,82.17) v1(178.88,181.23) v1(179.18,224.25) v1(179.64,189.74) v1(179.77,181.23) v1(179.77,76.32) v1(179.77,74.55) v1(180.55,155.34) v1(180.71,185.44) v1(182.38,189.79) v1(183.32,204.98) v1(183.4,185.37) v1(183.45,208.53) v1(184.6,173.38) v1(184.6,105.31) v1(184.7,181.23) v1(184.72,44.96) v1(184.72,40.13) v1(184.72,34.16) v1(184.72,29.21) v1(185.5,173.38) v1(185.5,105.33) v1(186.75,179.14) v1(186.82,188.5) v1(188.62,173.38) v1(188.62,105.31) v1(189.5,173.35) v1(189.5,105.33) v1(189.87,188.5) v1(190.44,210.31) v1(190.44,206.75) v1(190.61,224.25) v1(191.88,224.25) v1(192.6,105.31) v1(192.62,173.38) v1(193.15,224.25) v1(193.5,173.35) v1(193.5,105.33) v1(194.42,224.25) v1(195.14,85.34) v1(195.39,101.72) v1(195.39,100.71) v1(195.39,99.44) v1(195.39,98.42) v1(195.39,97.15) v1(195.69,224.25) v1(196.66,83.56) v1(196.96,224.25) v1(197.55,173.23) v1(197.6,105.31) v1(197.55,83.56) v1(198.23,224.25) v1(198.5,105.33) v1(199.5,224.25) v1(199.96,206.75) v1(200.09,204.98) v1(200.77,224.25) v1(200.79,178.7) v1(200.79,175.98) v1(200.85,210.31) v1(201.6,105.31) v1(202.04,224.25) v1(202.12,189.1) v1(202.5,105.33) v1(203.31,224.25) v1(204.15,176.53) v1(204.58,224.25) v1(204.55,158.34) v1(204.79,90.55) v1(204.79,89.53) v1(205.6,105.31) v1(205.62,173.38) v1(205.85,224.25) v1(206.08,178.51) v1(206.5,173.35) v1(206.5,105.33) v1(206.65,204.29) v1(207.12,224.25) v1(207.45,188.59) v1(207.71,191.89) v1(207.71,190.88) v1(208.39,224.25) v1(209.55,204.24) v1(209.55,173.25) v1(209.6,105.31) v1(209.66,224.25) v1(209.66,211.57) v1(210.2,205.08) v1(210.12,190.88) v1(210.12,44.96) v1(210.12,40.13) v1(210.12,34.16) v1(210.5,105.33) v1(210.55,173.25) v1(210.93,224.25) v1(211.31,206.75) v1(212.05,208.53) v1(212.2,224.25) v1(212.66,101.98) v1(212.66,101.09) v1(212.66,100.2) v1(212.66,99.31) v1(212.66,98.42) v1(212.66,97.53) v1(212.66,29.46) v1(212.79,210.31) v1(213.47,224.25) v1(213.42,89.72) v1(213.6,173.38) v1(213.6,105.31) v1(214.5,173.35) v1(214.5,105.33) v1(214.44,101.72) v1(214.44,100.71) v1(214.44,97.15) v1(214.44,96.14) v1(214.74,224.25) v1(215.2,81.28) v1(215.2,74.55) v1(215.58,185.8) v1(216.01,224.25) v1(216.26,201.8) v1(216.22,82.17) v1(216.22,76.32) v1(216.34,192.28) v1(217,203.58) v1(217.28,224.25) v1(217.74,205.36) v1(218.12,191.64) v1(218.25,177.42) v1(218.55,224.25) v1(218.76,192.28) v1(219.82,224.25) v1(220.54,191.64) v1(221.09,224.25) v1(221.17,192.28) v1(221.3,177.42) v1(222.36,224.25) v1(222.95,191.64) v1(223.63,224.25) v1(224.35,177.42) v1(224.9,224.25) v1(225.23,177.42) v1(225.36,175.31) v1(225.55,173.2) v1(225.55,105.48) v1(226.17,224.25) v1(226.12,177.42) v1(226.25,175.31) v1(226.76,90.42) v1(227.14,175.31) v1(227.27,89.53) v1(227.39,191.89) v1(227.44,224.25) v1(228.03,175.31) v1(228.28,191.89) v1(228.54,81.28) v1(228.54,75.44) v1(228.71,224.25) v1(228.92,177.42) v1(228.92,175.31) v1(229.17,40.26) v1(229.55,205.36) v1(229.55,201.8) v1(229.55,81.28) v1(229.55,76.32) v1(229.55,29.21) v1(229.81,44.83) v1(229.98,224.25) v1(230.44,34.16) v1(230.82,91.06) v1(231.25,224.25) v1(231.46,170.34) v1(231.46,169.34) v1(231.46,90.42) v1(231.58,158.29) v1(231.56,157.39) v1(231.58,154.29) v1(231.56,150.29) v1(231.58,146.29) v1(231.58,142.29) v1(231.56,141.39) v1(231.56,137.29) v1(231.58,136.39) v1(231.58,133.29) v1(231.56,132.39) v1(231.58,129.29) v1(231.56,128.39) v1(231.56,125.29) v1(231.58,124.39) v1(231.58,121.29) v1(231.56,120.39) v1(231.58,117.29) v1(231.56,116.39) v1(231.56,113.29) v1(231.56,109.29) v1(231.58,108.39) v1(232.52,224.25) v1(233.79,224.25) v1(234.76,109.85) v1(234.76,108.96) v1(234.76,107.19) v1(234.76,106.3) v1(235.06,224.25) v1(235.14,148.21) v1(236.16,148.21) v1(236.33,224.25) v1(236.92,135.89) v1(237.43,160.4) v1(237.43,148.21) v1(237.6,224.25) v1(237.81,135.89) v1(238.44,160.4) v1(238.44,148.21) v1(238.7,135.89) v1(238.87,224.25) v1(238.95,123.06) v1(238.95,122.17) v1(239.33,205.36) v1(239.33,201.8) v1(239.59,135.89) v1(239.71,160.4) v1(239.71,148.21) v1(239.84,122.17) v1(239.84,121.28) v1(240.47,135.89) v1(240.73,160.4) v1(240.73,148.21) v1(240.73,122.17) v1(240.73,121.28) v1(241.36,135.89) v1(241.36,123.06) v1(241.62,122.17) v1(241.62,121.28) v1(241.85,119.15) v1(241.85,116.2) v1(241.85,113.13) v1(242.25,160.4) v1(242.25,135.89) v1(242.51,121.28) v1(242.89,203.58) v1(242.89,200.02) v1(243.14,135.89) v1(243.27,160.4) v1(243.4,121.28) v1(243.4,108.67) v1(243.37,105.71) v1(243.37,104.8) v1(244.03,135.89) v1(244.16,160.4) v1(244.13,150.57) v1(244.18,107.85) v1(244.31,152.07) v1(244.92,107.19) v1(245.05,170.58) v1(245.05,160.4) v1(245.61,138.12) v1(245.77,106.3) v1(246.44,141.3) v1(247.21,172.69) v1(247.33,163.19) v1(247.59,136.14) v1(248.09,157.73) v1(248.22,178.97) v1(248.35,139.32) v1(248.6,151.25) v1(250,189.35) v1(250.13,181.1) v1(250.13,134.49) v1(250.13,133.22) v1(250.13,130.17) v1(250.13,127.12) v1(250.13,124.08) v1(250.13,117.98) v1(250.3,224.25) v1(250.63,205.36) v1(250.63,201.8) v1(250.76,133.86) v1(250.76,132.59) v1(250.76,129.54) v1(250.76,126.49) v1(250.76,123.44) v1(250.76,117.35) v1(250.89,163.83) v1(250.89,159) v1(251.02,151.89) v1(251.27,139.44) v1(251.57,224.25) v1(252.03,184.91) v1(252.84,224.25) v1(253.05,137.67) v1(253.17,173.86) v1(253.17,92.83) v1(253.3,160.78) v1(253.3,149.6) v1(253.3,143.51) v1(253.43,207.77) v1(253.56,205.48) v1(254.11,224.25) v1(254.32,207.77) v1(254.32,184.91) v1(254.7,203.58) v1(254.7,200.02) v1(255.38,224.25) v1(255.71,207.77) v1(255.71,40.13) v1(255.84,44.96) v1(255.84,29.21) v1(256.1,205.48) v1(256.65,224.25) v1(256.73,190.24) v1(256.86,207.77) v1(257.24,34.16) v1(257.87,94.49) v1(257.87,93.47) v1(257.92,224.25) v1(258.38,205.36) v1(259.02,168.02) v1(259.02,164.97) v1(259.02,161.92) v1(259.02,158.87) v1(259.02,155.83) v1(259.02,154.56) v1(259.02,151.51) v1(259.02,149.86) v1(259.02,146.81) v1(259.02,143.89) v1(259.02,140.84) v1(259.02,137.79) v1(259.02,134.74) v1(259.02,131.7) v1(259.02,128.65) v1(259.02,125.6) v1(259.02,124.33) v1(259.02,121.28) v1(259.02,118.23) v1(259.02,115.19) v1(259.19,224.25) v1(259.4,80.39) v1(259.4,75.94) v1(259.65,209.29) v1(259.78,217.04) v1(259.78,215.9) v1(259.78,214.88) v1(260.46,224.25) v1(261.05,217.04) v1(261.05,215.9) v1(261.05,214.88) v1(261.43,196.47) v1(261.73,224.25) v1(262.83,205.36) v1(262.83,201.8) v1(263,224.25) v1(264.27,224.25) v1(265.24,198.5) v1(265.54,224.25) v1(266,203.58) v1(266,200.02) v1(266.64,98.93) v1(266.81,224.25) v1(267.14,165.94) v1(267.14,162.94) v1(267.14,156.84) v1(267.14,142.36) v1(267.14,132.81) v1(267.14,123.64) v1(267.14,116.84) v1(267.14,113.15) v1(267.22,150.75) v1(268.08,224.25) v1(268.73,97.53) v1(269.35,224.25) v1(269.68,196.47) v1(270.62,224.25) v1(270.83,90.68) v1(270.83,89.79) v1(271.89,224.25) v1(272.73,81.28) v1(272.73,75.44) v1(273.16,224.25) v1(273.11,194.56) v1(273.75,212.6) v1(273.75,211.71) v1(273.75,76.32) v1(274.43,224.25) v1(274.76,212.6) v1(275.02,198.5) v1(275.4,107.82) v1(275.4,90.68) v1(275.4,89.66) v1(275.7,224.25) v1(275.65,205.36) v1(275.65,201.8) v1(275.91,212.6) v1(276.16,44.96) v1(276.16,29.21) v1(276.29,192.66) v1(276.42,105.15) v1(276.97,224.25) v1(277.3,34.41) v1(278.07,203.58) v1(278.07,200.02) v1(278.24,224.25) v1(278.32,212.98) v1(278.32,212.09) v1(279.13,192.66) v1(279.46,212.98) v1(279.46,212.09) v1(279.51,224.25) v1(280.78,224.25) v1(281.5,108.33) v1(281.5,106.3) v1(281.88,194.56) v1(281.88,192.33) v1(282.05,224.25) v1(283.32,224.25) v1(284.04,90.68) v1(284.04,89.66) v1(284.59,224.25) v1(284.67,194.56) v1(284.67,192.33) v1(284.76,197.06) v1(284.92,211.07) v1(284.92,209.73) v1(284.92,208.81) v1(284.92,207.06) v1(284.92,206.14) v1(285.57,198.76) v1(285.86,224.25) v1(286.32,213.23) v1(286.32,104.26) v1(286.51,200.34) v1(287.13,224.25) v1(288.4,224.25) v1(288.48,85.98) v1(288.48,85.09) v1(289.67,224.25) v1(290.77,198.75) v1(290.94,224.25) v1(291.59,197.18) v1(291.91,85.34) v1(292.21,224.25) v1(292.29,194.56) v1(292.42,108.33) v1(292.42,106.3) v1(292.8,85.34) v1(293.48,224.25) v1(294.75,224.25) v1(294.77,196.22) v1(295.47,89.02) v1(296.02,224.25) v1(296.1,88.39) v1(296.56,209.9) v1(296.56,208.51) v1(297.29,224.25) v1(297.83,209.9) v1(297.83,208.51) v1(297.83,206.86) v1(298.26,196.22) v1(298.56,224.25) v1(299.22,209.9) v1(299.22,208.51) v1(299.22,206.86) v1(299.78,192.67) v1(301.18,196.22) v1(301.56,40.13) v1(301.56,34.16) v1(301.56,29.21) v1(302.2,44.96) v1(302.32,86.74) v1(302.32,85.85) v1(302.32,84.96) v1(303.21,108.33) v1(304.36,196.21) v1(305.24,194.56) v1(305.24,106.3) v1(305.96,199.16) v1(306.08,196.11) v1(307.78,192.67) v1(307.91,76.32) v1(308.67,195.96) v1(308.72,199.49) v1(309.05,76.32) v1(309.44,208.28) v1(309.82,203.07) v1(309.99,224.25) v1(310.71,199.64) v1(311.26,224.25) v1(312.14,210.81) v1(312.18,195.98) v1(312.48,90.55) v1(312.48,89.53) v1(312.53,224.25) v1(313.25,84.58) v1(313.45,208.3) v1(313.45,199.41) v1(313.8,224.25) v1(313.88,212.47) v1(315.07,224.25) v1(315.23,210.72) v1(315.23,208.43) v1(315.35,199.41) v1(315.35,195.98) v1(315.53,108.33) v1(316.34,224.25) v1(316.5,208.43) v1(316.55,192.67) v1(316.8,212.21) v1(317.56,106.3) v1(317.61,224.25) v1(318.02,199.41) v1(318.4,195.86) v1(318.88,224.25) v1(320.05,199.41) v1(320.15,224.25) v1(320.61,195.58) v1(321.11,192.67) v1(321.42,224.25) v1(322.39,90.8) v1(322.39,89.79) v1(322.69,224.25) v1(323.96,224.25) v1(324.17,81.28) v1(324.17,74.55) v1(325.18,76.32) v1(325.23,224.25) v1(326.5,224.25) v1(326.96,40.13) v1(326.96,34.16) v1(326.96,29.21) v1(327.77,224.25) v1(327.98,108.33) v1(329.04,224.25) v1(330.01,106.3) v1(330.31,224.25) v1(331.58,224.25) v1(332.85,224.25) v1(334.12,224.25) v1(335.39,224.25) v1(336.66,224.25) v1(337.5,108.33) v1(337.63,92.33) v1(337.63,91.44) v1(337.93,224.25) v1(339.2,224.25) v1(339.28,106.55) v1(340.47,224.25) v1(341.74,224.25) v1(343.01,224.25) v1(343.09,199.01) v1(343.95,185.11) v1(343.95,184.22) v1(343.95,183.46) v1(343.95,182.57) v1(343.95,181.68) v1(343.95,174.93) v1(343.95,174.04) v1(343.95,173.27) v1(343.95,172.39) v1(343.95,171.5) v1(343.95,164.77) v1(343.95,163.88) v1(343.95,163.11) v1(343.95,162.23) v1(343.95,161.34) v1(343.95,154.61) v1(343.95,153.72) v1(343.95,152.95) v1(343.95,152.07) v1(343.95,151.18) v1(343.95,144.45) v1(343.95,143.56) v1(343.95,142.79) v1(343.95,141.91) v1(343.95,141.02) v1(343.95,134.29) v1(343.95,133.4) v1(343.95,132.63) v1(343.95,131.75) v1(343.95,130.86) v1(344.28,224.25) v1(344.23,167.13) v1(344.96,185.09) v1(344.96,184.17) v1(344.96,183.43) v1(344.96,182.55) v1(344.96,181.66) v1(344.96,180.26) v1(344.96,174.93) v1(344.96,174.01) v1(344.96,173.27) v1(344.96,172.39) v1(344.96,171.5) v1(344.96,170.1) v1(344.96,164.77) v1(344.96,163.83) v1(344.96,163.11) v1(344.96,162.23) v1(344.96,161.34) v1(344.96,159.94) v1(344.96,154.61) v1(344.96,153.69) v1(344.96,152.95) v1(344.96,152.07) v1(344.96,151.18) v1(344.96,144.45) v1(344.96,143.53) v1(344.96,142.79) v1(344.96,141.91) v1(344.96,141.02) v1(344.96,134.29) v1(344.96,133.37) v1(344.96,132.63) v1(344.96,131.75) v1(344.96,130.86) v1(345.12,115.31) v1(345.38,90.93) v1(345.5,93.98) v1(345.55,224.25) v1(346.1,184.83) v1(346.1,183.94) v1(346.1,174.67) v1(346.1,173.78) v1(346.1,164.51) v1(346.1,163.62) v1(346.1,154.35) v1(346.1,153.46) v1(346.1,144.19) v1(346.1,143.3) v1(346.1,134.03) v1(346.1,133.14) v1(346.34,93.09) v1(346.74,184.83) v1(346.74,183.94) v1(346.74,174.67) v1(346.74,173.78) v1(346.74,164.51) v1(346.74,163.62) v1(346.74,154.35) v1(346.74,153.46) v1(346.74,144.19) v1(346.74,143.3) v1(346.74,134.03) v1(346.74,133.14) v1(346.82,224.25) v1(348.09,224.25) v1(348.11,115.38) v1(348.04,91.31) v1(349.36,224.25) v1(349.44,72.39) v1(349.69,86.48) v1(349.8,78.61) v1(350.46,85.72) v1(350.61,79.5) v1(350.63,224.25) v1(350.69,78.61) v1(350.71,72.34) v1(351.09,85.01) v1(351.57,177.34) v1(351.57,167.18) v1(351.57,78.56) v1(351.64,146.73) v1(351.69,136.83) v1(351.77,157.12) v1(351.9,224.25) v1(351.9,84.45) v1(351.98,187.7) v1(352.02,147.57) v1(352.36,44.96) v1(352.36,40.13) v1(352.36,34.16) v1(352.36,29.21) v1(352.66,136.8) v1(352.87,187.7) v1(352.91,167.15) v1(352.94,186.74) v1(352.94,166.04) v1(353.17,224.25) v1(353.25,71.12) v1(354.37,91.31) v1(354.44,224.25) v1(355.08,90.75) v1(355.66,93.22) v1(355.66,90.04) v1(355.71,224.25) v1(355.79,199.01) v1(356.68,85.85) v1(356.98,224.25) v1(357.39,85.09) v1(358.25,224.25) v1(358.58,160.53) v1(358.88,179.85) v1(358.86,178.33) v1(358.88,159.53) v1(358.86,158.01) v1(358.88,139.21) v1(358.86,137.69) v1(359.41,179.09) v1(359.41,158.77) v1(359.41,138.45) v1(359.97,179.85) v1(360,178.33) v1(359.97,139.21) v1(360,137.69) v1(363.66,79.09) v1(364.3,117.47) v1(364.3,116.46) v1(364.3,111.12) v1(364.25,78.41) v1(364.83,77.72) v1(365.19,113.28) v1(365.19,112.27) v1(365.19,111.12) v1(365.19,80.64) v1(368.11,187.07) v1(368.31,171.19) v1(368.24,168.78) v1(368.24,152.27) v1(368.24,151.25) v1(368.24,148.84) v1(368.24,147.7) v1(368.36,83.69) v1(368.41,189.48) v1(368.47,72.75) v1(369.1,83.18) v1(369.3,189.48) v1(369.3,85.95) v1(369.38,187.07) v1(369.38,171.19) v1(369.38,168.78) v1(369.68,224.25) v1(369.63,151.25) v1(369.63,148.84) v1(370.17,85.09) v1(370.46,137.73) v1(370.52,189.48) v1(370.52,187.07) v1(370.65,171.19) v1(370.65,168.78) v1(370.78,151.25) v1(370.78,148.84) v1(370.9,84.33) v1(370.95,224.25) v1(372.22,224.25) v1(372.68,215.39) v1(372.68,214.5) v1(372.68,169.54) v1(372.68,44.96) v1(372.68,40.13) v1(372.68,34.16) v1(372.68,29.21) v1(372.81,151.76) v1(372.94,85.47) v1(372.94,84.2) v1(373.06,171.32) v1(373.49,224.25) v1(373.82,215.39) v1(373.82,214.5) v1(374.76,224.25) v1(374.84,214.5) v1(374.84,155.32) v1(375.35,167.26) v1(375.53,76.35) v1(376.03,224.25) v1(376.24,184.53) v1(376.36,169.16) v1(376.36,167.26) v1(376.62,181.1) v1(377.3,224.25) v1(377.25,167.26) v1(377.38,169.16) v1(378.02,215.39) v1(378.14,200.53) v1(378.14,199.64) v1(378.27,169.14) v1(378.27,167.26) v1(378.4,184.53) v1(378.57,224.25) v1(379.03,215.39) v1(379.16,169.16) v1(379.16,167.26) v1(379.29,199.64) v1(379.84,224.25) v1(380.3,199.64) v1(381.11,224.25) v1(381.19,184.53) v1(381.7,97.53) v1(381.95,81.4) v1(381.95,80.52) v1(382.21,96.64) v1(383.48,200.53) v1(383.98,173.99) v1(383.98,114.3) v1(383.98,113.15) v1(383.98,112.01) v1(383.98,110.87) v1(383.98,109.73) v1(384.24,138.3) v1(384.24,137.16) v1(384.24,136.01) v1(384.24,134.87) v1(384.24,133.73) v1(384.49,200.53) v1(384.48,182.24) v1(384.62,124.33) v1(384.62,122.81) v1(384.62,121.16) v1(384.62,119.76) v1(384.62,118.49) v1(384.75,148.08) v1(384.75,146.56) v1(384.75,144.9) v1(384.75,143.51) v1(384.75,142.24) v1(385.13,114.3) v1(385.13,113.15) v1(385.38,138.3) v1(385.38,137.16) v1(385.64,124.33) v1(385.64,122.81) v1(385.64,121.16) v1(385.64,119.76) v1(385.64,118.49) v1(385.76,210.94) v1(385.76,148.08) v1(385.76,146.56) v1(385.76,144.9) v1(385.76,143.51) v1(385.76,142.24) v1(386.27,114.3) v1(386.27,113.15) v1(386.27,112.01) v1(386.27,110.87) v1(386.4,184.53) v1(386.52,138.3) v1(386.52,137.16) v1(386.52,136.01) v1(386.52,134.87) v1(386.78,79.25) v1(386.78,78.1) v1(386.91,93.34) v1(386.91,92.33) v1(386.91,85.09) v1(386.91,83.94) v1(387.79,85.09) v1(387.79,83.94) v1(387.79,79.25) v1(387.79,78.1) v1(387.72,33.65) v1(388.05,181.23) v1(388.05,179.96) v1(389.06,212.01) v1(389.06,210.94) v1(389.06,209.93) v1(389.39,175.01) v1(389.57,187.27) v1(390.33,212.01) v1(390.41,33.65) v1(391.48,212.01) v1(392.49,127.51) v1(392.49,126.49) v1(392.49,125.35) v1(392.49,124.2) v1(392.62,151.76) v1(392.62,150.75) v1(392.62,149.6) v1(392.62,148.46) v1(392.87,194.05) v1(393.76,127.51) v1(393.76,126.49) v1(393.76,125.35) v1(393.76,124.2) v1(393.89,151.76) v1(393.89,150.75) v1(393.89,149.6) v1(393.89,148.46) v1(394.53,194.31) v1(394.55,169.82) v1(395.16,153.16) v1(395.29,165.1) v1(395.44,166.52) v1(395.77,208.43) v1(395.8,195.32) v1(396.05,153.16) v1(397.07,194.43) v1(397.95,107.69) v1(398.21,131.7) v1(399.05,108.89) v1(399.22,167.89) v1(399.3,132.89) v1(400.09,208.43) v1(400.11,107.69) v1(400.37,131.7) v1(400.49,63.37) v1(400.88,168.4) v1(401.02,57.28) v1(401.02,52.95) v1(401.22,187.25) v1(401.51,63.37) v1(402.53,131.7) v1(402.65,132.71) v1(403.03,168.02) v1(404.41,208.43) v1(405.2,56.37) v1(405.3,168.53) v1(405.83,210.06) v1(405.93,189.58) v1(408.42,223.62) v1(408.62,57.28) v1(409.05,224.25) v1(409.07,188.69) v1(409.26,127.76) v1(409.69,223.62) v1(409.85,166.49) v1(410.32,224.25) v1(410.77,168.81) v1(410.77,167.72) v1(410.96,223.62) v1(411.59,224.25) v1(411.92,57.17) v1(412.23,223.62) v1(412.86,224.25) v1(413.5,223.62) v1(414.13,224.25) v1(414.77,223.62) v1(415.23,175.51) v1(415.4,224.25) v1(415.35,177.92) v1(415.35,176.78) v1(415.61,186.56) v1(415.61,183.23) v1(416.04,223.62) v1(416.67,224.25) v1(416.88,222.76) v1(417.31,223.62) v1(417.64,222.25) v1(418.07,223.11) v1(418.71,222.48) v1(419.34,223.11) v1(419.98,222.48) v1(420.61,223.11) v1(421.25,222.48) v1(421.58,60.58) v1(421.58,59.69) v1(421.58,58.8) v1(421.88,223.11) v1(422.52,222.48) v1(422.72,60.58) v1(422.72,59.69) v1(422.72,58.8) v1(422.85,203.2) v1(422.97,207.39) v1(422.97,205.74) v1(422.97,204.47) v1(423.15,223.11) v1(423.61,208.02) v1(423.61,206.75) v1(423.61,205.1) v1(423.61,203.83) v1(423.79,222.48) v1(423.86,60.58) v1(423.86,59.69) v1(423.86,58.8) v1(424.42,223.11) v1(424.5,207.52) v1(424.5,202.94) v1(425.06,222.48) v1(425.13,208.15) v1(425.13,202.31) v1(425.69,223.11) v1(425.77,207.52) v1(425.77,202.94) v1(426.02,114.17) v1(426.33,222.48) v1(426.4,208.15) v1(426.53,202.31) v1(426.96,223.11) v1(427.16,202.94) v1(427.29,207.52) v1(427.6,222.48) v1(427.8,202.31) v1(428.1,223.75) v1(428.43,202.94) v1(428.61,222.25) v1(428.61,220.98) v1(428.61,219.71) v1(428.61,218.44) v1(428.61,217.17) v1(428.61,210.82) v1(428.61,209.55) v1(428.61,208.28) v1(428.61,200.66) v1(428.61,199.39) v1(428.61,198.12) v1(428.61,196.85) v1(428.61,195.58) v1(428.61,194.31) v1(428.61,193.04) v1(428.61,191.77) v1(428.61,190.5) v1(428.61,189.23) v1(428.61,187.96) v1(428.61,186.69) v1(428.61,179.07) v1(428.61,177.8) v1(428.61,176.53) v1(428.61,175.26) v1(428.61,173.99) v1(428.61,172.72) v1(428.61,171.45) v1(428.61,170.18) v1(428.61,168.91) v1(428.61,167.64) v1(428.61,166.37) v1(428.61,165.1) v1(428.61,163.83) v1(428.61,162.56) v1(428.61,161.29) v1(428.61,160.02) v1(428.61,158.75) v1(428.61,157.48) v1(428.61,156.21) v1(428.61,154.94) v1(428.61,153.67) v1(428.61,152.4) v1(428.61,151.13) v1(428.61,149.86) v1(428.61,148.59) v1(428.61,147.32) v1(428.61,146.05) v1(428.61,144.78) v1(428.61,143.51) v1(428.61,142.24) v1(428.61,140.97) v1(428.61,139.7) v1(428.61,138.43) v1(428.61,137.16) v1(428.61,135.89) v1(428.61,134.62) v1(428.61,133.35) v1(428.61,132.08) v1(428.61,130.81) v1(428.61,129.54) v1(428.61,128.27) v1(428.61,127) v1(428.61,125.73) v1(428.61,124.46) v1(428.61,123.19) v1(428.61,121.92) v1(428.61,120.65) v1(428.61,119.38) v1(428.61,118.11) v1(428.61,116.84) v1(428.61,115.57) v1(428.61,114.3) v1(428.61,113.03) v1(428.61,111.76) v1(428.61,110.49) v1(428.61,109.22) v1(428.61,107.95) v1(428.61,106.68) v1(428.61,105.41) v1(428.61,104.14) v1(428.61,102.87) v1(428.61,101.6) v1(428.61,100.33) v1(428.61,99.06) v1(428.61,97.79) v1(428.61,96.52) v1(428.61,88.9) v1(428.61,87.63) v1(428.61,86.36) v1(428.61,85.09) v1(428.61,83.82) v1(428.61,82.55) v1(428.61,81.28) v1(428.61,80.01) v1(428.61,78.74) v1(428.61,77.47) v1(428.61,76.2) v1(428.61,74.93) v1(428.61,73.66) v1(428.61,72.39) v1(428.61,71.12) v1(428.61,69.85) v1(428.61,68.58) v1(428.61,67.31) v1(428.61,66.04) v1(428.61,64.77) v1(428.61,63.5) v1(428.61,62.23) v1(428.61,60.96) v1(428.61,59.69) v1(428.61,58.42) v1(428.61,57.15) v1(429.12,202.31) v1(429.25,222.88) v1(429.25,221.61) v1(429.25,220.34) v1(429.25,219.07) v1(429.25,217.8) v1(429.25,216.53) v1(429.25,215.26) v1(429.25,213.99) v1(429.25,212.72) v1(429.25,211.45) v1(429.25,210.18) v1(429.25,208.91) v1(429.25,201.29) v1(429.25,200.02) v1(429.25,198.75) v1(429.25,197.48) v1(429.25,196.21) v1(429.25,194.94) v1(429.25,193.67) v1(429.25,192.4) v1(429.25,191.13) v1(429.25,189.86) v1(429.25,188.59) v1(429.25,187.32) v1(429.25,186.05) v1(429.25,179.7) v1(429.25,178.43) v1(429.25,177.16) v1(429.25,175.89) v1(429.25,174.62) v1(429.25,173.35) v1(429.25,172.08) v1(429.25,170.81) v1(429.25,169.54) v1(429.25,168.27) v1(429.25,167) v1(429.25,165.73) v1(429.25,164.46) v1(429.25,163.19) v1(429.25,161.92) v1(429.25,160.65) v1(429.25,159.38) v1(429.25,158.11) v1(429.25,156.84) v1(429.25,155.57) v1(429.25,154.3) v1(429.25,153.03) v1(429.25,151.76) v1(429.25,150.49) v1(429.25,149.22) v1(429.25,147.95) v1(429.25,146.68) v1(429.25,145.41) v1(429.25,144.14) v1(429.25,142.87) v1(429.25,141.6) v1(429.25,140.33) v1(429.25,139.06) v1(429.25,137.79) v1(429.25,136.52) v1(429.25,135.25) v1(429.25,133.98) v1(429.25,132.71) v1(429.25,131.44) v1(429.25,130.17) v1(429.25,128.9) v1(429.25,127.63) v1(429.25,126.36) v1(429.25,125.09) v1(429.25,123.82) v1(429.25,122.55) v1(429.25,121.28) v1(429.25,120.01) v1(429.25,118.74) v1(429.25,117.47) v1(429.25,116.2) v1(429.25,114.93) v1(429.25,113.66) v1(429.25,112.39) v1(429.25,111.12) v1(429.25,109.85) v1(429.25,108.58) v1(429.25,107.31) v1(429.25,106.04) v1(429.25,104.77) v1(429.25,103.5) v1(429.25,102.23) v1(429.25,100.96) v1(429.25,99.69) v1(429.25,98.42) v1(429.25,97.15) v1(429.25,95.88) v1(429.25,89.53) v1(429.25,88.26) v1(429.25,86.99) v1(429.25,85.72) v1(429.25,84.45) v1(429.25,83.18) v1(429.25,81.91) v1(429.25,80.64) v1(429.25,79.37) v1(429.25,78.1) v1(429.25,76.83) v1(429.25,75.56) v1(429.25,74.29) v1(429.25,73.02) v1(429.25,71.75) v1(429.25,70.48) v1(429.25,69.21) v1(429.25,67.94) v1(429.25,66.67) v1(429.25,65.4) v1(429.25,64.13) v1(429.25,62.86) v1(429.25,61.59) v1(429.25,60.32) v1(429.25,59.05) v1(429.25,57.78) v1(429.25,56.51) v1(429.25,55.5) v1(429.25,54.23) v2(5.14,73.02) v2(7.43,191.39) v2(8.83,159.64) v2(22.54,199.9) v2(23.56,116.2) v2(25.72,141.09) v2(32.45,176.53) v2(32.45,129.03) v2(32.58,203.83) v2(57.47,156.59) v2(60.26,118.23) v2(65.09,102.87) v2(67.5,204.59) v2(76.52,183.89) v2(78.42,143.13) v2(121.35,94.49) v2(147.64,103.76) v2(156.27,85.85) v2(194.88,84.07) v2(213.55,91.44) v2(261.81,93.6) v2(295.59,218.18) v2(310.32,86.1) v2(324.04,94.87) v2(338.01,173.35) v2(356.55,161.8) v2(359.6,85.47) v2(384.11,179.58) v2(390.46,151.51) v2(390.84,127.38) v2(399.73,85.98) v2(403.54,163.7) v2(405.19,197.36) v2(406.59,117.85) v2(426.28,115.31) v3(11.11,82.67) v3(11.11,81.4) v3(11.11,76.32) v3(11.11,75.05) v3(47.56,85.47) v3(47.56,84.15) v3(47.56,80.13) v3(47.56,78.86) v3(65.34,85.98) v3(65.34,84.71) v3(65.34,80.01) v3(65.34,78.74) v3(73.85,187.07) v3(73.85,180.72) v3(73.85,179.45) v3(73.85,178.18) v3(73.85,176.91) v3(73.85,170.56) v3(73.85,169.29) v3(73.85,168.02) v3(73.85,166.75) v3(73.85,160.4) v3(73.85,159.13) v3(73.85,157.86) v3(73.85,156.59) v3(73.85,150.24) v3(73.85,148.97) v3(73.85,147.7) v3(73.85,146.43) v3(73.85,140.08) v3(73.85,138.81) v3(73.85,137.54) v3(73.85,136.27) v3(73.85,129.92) v3(73.85,128.65) v3(75.12,192.15) v3(75.12,190.88) v3(75.12,189.61) v3(75.12,188.34) v3(75.12,187.07) v3(75.12,180.72) v3(75.12,179.45) v3(75.12,178.18) v3(75.12,176.91) v3(75.12,170.56) v3(75.12,169.29) v3(75.12,168.02) v3(75.12,166.75) v3(75.12,160.4) v3(75.12,159.13) v3(75.12,157.86) v3(75.12,156.59) v3(75.12,150.24) v3(75.12,148.97) v3(75.12,147.7) v3(75.12,146.43) v3(75.12,140.08) v3(75.12,138.81) v3(75.12,137.54) v3(75.12,136.27) v3(75.12,129.92) v3(75.12,128.65) v3(76.39,192.15) v3(76.39,190.88) v3(76.39,189.61) v3(76.39,188.34) v3(76.39,187.07) v3(76.39,180.72) v3(76.39,179.45) v3(76.39,178.18) v3(76.39,176.91) v3(76.39,170.56) v3(76.39,169.29) v3(76.39,168.02) v3(76.39,166.75) v3(76.39,160.4) v3(76.39,159.13) v3(76.39,157.86) v3(76.39,156.59) v3(76.39,150.24) v3(76.39,148.97) v3(76.39,147.7) v3(76.39,146.43) v3(76.39,140.08) v3(76.39,138.81) v3(76.39,137.54) v3(76.39,136.27) v3(76.39,129.92) v3(76.39,128.65) v3(77.66,192.15) v3(77.66,190.88) v3(77.66,189.61) v3(77.66,188.34) v3(77.66,187.07) v3(77.66,180.72) v3(77.66,179.45) v3(77.66,178.18) v3(77.66,176.91) v3(77.66,170.56) v3(77.66,169.29) v3(77.66,168.02) v3(77.66,166.75) v3(77.66,160.4) v3(77.66,159.13) v3(77.66,157.86) v3(77.66,156.59) v3(77.66,150.24) v3(77.66,148.97) v3(77.66,147.7) v3(77.66,146.43) v3(77.66,140.08) v3(77.66,138.81) v3(77.66,137.54) v3(77.66,136.27) v3(77.66,129.92) v3(77.66,128.65) v3(78.55,84.15) v3(78.55,80.13) v3(78.55,78.86) v3(78.93,192.15) v3(78.93,190.88) v3(78.93,189.61) v3(78.93,188.34) v3(78.93,187.07) v3(78.93,180.72) v3(78.93,179.45) v3(78.93,178.18) v3(78.93,176.91) v3(78.93,170.56) v3(78.93,169.29) v3(78.93,168.02) v3(78.93,166.75) v3(78.93,160.4) v3(78.93,159.13) v3(78.93,157.86) v3(78.93,156.59) v3(78.93,150.24) v3(78.93,148.97) v3(78.93,147.7) v3(78.93,146.43) v3(78.93,140.08) v3(78.93,138.81) v3(78.93,137.54) v3(78.93,136.27) v3(78.93,129.92) v3(78.93,128.65) v3(80.2,192.15) v3(80.2,190.88) v3(80.2,189.61) v3(80.2,188.34) v3(80.2,187.07) v3(80.2,180.72) v3(80.2,179.45) v3(80.2,178.18) v3(80.2,176.91) v3(80.2,170.56) v3(80.2,169.29) v3(80.2,168.02) v3(80.2,166.75) v3(80.2,160.4) v3(80.2,159.13) v3(80.2,157.86) v3(80.2,156.59) v3(80.2,150.24) v3(80.2,148.97) v3(80.2,147.7) v3(80.2,146.43) v3(80.2,140.08) v3(80.2,138.81) v3(80.2,137.54) v3(80.2,136.27) v3(80.2,129.92) v3(80.2,128.65) v3(81.47,192.15) v3(81.47,190.88) v3(81.47,189.61) v3(81.47,188.34) v3(81.47,187.07) v3(81.47,180.72) v3(81.47,179.45) v3(81.47,178.18) v3(81.47,176.91) v3(81.47,170.56) v3(81.47,169.29) v3(81.47,168.02) v3(81.47,166.75) v3(81.47,160.4) v3(81.47,159.13) v3(81.47,157.86) v3(81.47,156.59) v3(81.47,150.24) v3(81.47,148.97) v3(81.47,147.7) v3(81.47,146.43) v3(81.47,140.08) v3(81.47,138.81) v3(81.47,137.54) v3(81.47,136.27) v3(81.47,129.92) v3(81.47,128.65) v3(82.74,192.15) v3(82.74,190.88) v3(82.74,189.61) v3(82.74,188.34) v3(82.74,187.07) v3(82.74,180.72) v3(82.74,179.45) v3(82.74,178.18) v3(82.74,176.91) v3(82.74,170.56) v3(82.74,169.29) v3(82.74,168.02) v3(82.74,166.75) v3(82.74,160.4) v3(82.74,159.13) v3(82.74,157.86) v3(82.74,156.59) v3(82.74,150.24) v3(82.74,148.97) v3(82.74,147.7) v3(82.74,146.43) v3(82.74,140.08) v3(82.74,138.81) v3(82.74,137.54) v3(82.74,136.27) v3(82.74,129.92) v3(82.74,128.65) v3(84.01,192.15) v3(84.01,190.88) v3(84.01,189.61) v3(84.01,188.34) v3(84.01,187.07) v3(84.01,180.72) v3(84.01,179.45) v3(84.01,178.18) v3(84.01,176.91) v3(84.01,170.56) v3(84.01,169.29) v3(84.01,168.02) v3(84.01,166.75) v3(84.01,160.4) v3(84.01,159.13) v3(84.01,157.86) v3(84.01,156.59) v3(84.01,150.24) v3(84.01,148.97) v3(84.01,147.7) v3(84.01,146.43) v3(84.01,140.08) v3(84.01,138.81) v3(84.01,137.54) v3(84.01,136.27) v3(84.01,129.92) v3(84.01,128.65) v3(85.28,192.15) v3(85.28,190.88) v3(85.28,189.61) v3(85.28,188.34) v3(85.28,187.07) v3(85.28,180.72) v3(85.28,179.45) v3(85.28,178.18) v3(85.28,176.91) v3(85.28,170.56) v3(85.28,169.29) v3(85.28,168.02) v3(85.28,166.75) v3(85.28,160.4) v3(85.28,159.13) v3(85.28,157.86) v3(85.28,156.59) v3(85.28,150.24) v3(85.28,148.97) v3(85.28,147.7) v3(85.28,146.43) v3(85.28,140.08) v3(85.28,138.81) v3(85.28,137.54) v3(85.28,136.27) v3(85.28,129.92) v3(85.28,128.65) v3(91.76,80.39) v3(91.76,79.12) v3(115.13,84.45) v3(115.13,79.5) v3(115.13,78.23) v3(128.33,84.58) v3(128.33,80.13) v3(128.33,78.86) v3(141.67,85.98) v3(141.67,84.71) v3(141.67,80.13) v3(141.67,78.86) v3(159.32,85.6) v3(159.32,84.27) v3(159.32,80.01) v3(159.32,78.74) v3(172.53,85.6) v3(172.53,84.33) v3(172.53,80.13) v3(172.53,78.86) v3(185.74,85.98) v3(185.74,84.71) v3(185.74,80.13) v3(185.74,78.86) v3(209.11,85.98) v3(209.11,84.71) v3(209.11,80.01) v3(209.11,78.74) v3(222.31,85.98) v3(222.31,84.71) v3(222.31,80.13) v3(222.31,78.86) v3(235.65,85.98) v3(235.65,80.08) v3(235.65,78.84) v3(253.3,85.98) v3(253.3,84.71) v3(253.3,80.01) v3(253.3,78.74) v3(266.51,85.98) v3(266.51,84.71) v3(266.51,80.13) v3(266.51,78.86) v3(279.72,85.98) v3(279.72,84.71) v3(279.72,80.13) v3(279.72,78.86) v3(302.7,80.01) v3(302.7,78.74) v3(307.15,86.15) v3(307.15,84.88) v3(318.02,85.98) v3(318.02,84.71) v3(318.02,80.13) v3(318.02,78.86) v3(328.74,185.52) v3(328.74,180.46) v3(328.74,160.14) v3(328.74,155.04) v3(328.74,149.98) v3(328.74,144.88) v3(328.74,139.82) v3(328.74,134.72) v3(328.74,129.66) v3(330.01,185.54) v3(330.01,180.46) v3(330.01,176.65) v3(330.01,175.38) v3(330.01,170.3) v3(330.01,166.49) v3(330.01,165.22) v3(330.01,160.14) v3(330.01,158.87) v3(330.01,157.6) v3(330.01,156.33) v3(330.01,155.06) v3(330.01,149.98) v3(330.01,146.17) v3(330.01,144.9) v3(330.01,139.82) v3(330.01,136.01) v3(330.01,134.74) v3(330.01,129.66) v3(331.15,85.98) v3(331.15,84.71) v3(331.15,80.13) v3(331.15,78.86) v3(331.28,189.35) v3(331.28,188.08) v3(331.28,186.81) v3(331.28,180.46) v3(331.28,179.19) v3(331.28,177.92) v3(331.28,176.65) v3(331.28,170.3) v3(331.28,169.03) v3(331.28,167.76) v3(331.28,166.49) v3(331.28,160.14) v3(331.28,158.87) v3(331.28,157.6) v3(331.28,156.33) v3(331.28,149.98) v3(331.28,148.71) v3(331.28,147.44) v3(331.28,146.17) v3(331.28,139.82) v3(331.28,138.55) v3(331.28,137.28) v3(331.28,136.01) v3(331.28,129.66) v3(331.28,128.39) v3(331.28,127.12) v3(331.28,125.85) v3(332.55,189.35) v3(332.55,188.08) v3(332.55,186.81) v3(332.55,180.46) v3(332.55,179.19) v3(332.55,177.92) v3(332.55,176.65) v3(332.55,170.3) v3(332.55,169.03) v3(332.55,167.76) v3(332.55,166.49) v3(332.55,160.14) v3(332.55,158.87) v3(332.55,157.6) v3(332.55,156.33) v3(332.55,149.98) v3(332.55,148.71) v3(332.55,147.44) v3(332.55,146.17) v3(332.55,139.82) v3(332.55,138.55) v3(332.55,137.28) v3(332.55,136.01) v3(332.55,129.66) v3(332.55,128.39) v3(332.55,127.12) v3(332.55,125.85) v3(333.82,189.35) v3(333.82,188.08) v3(333.82,186.81) v3(333.82,180.46) v3(333.82,179.19) v3(333.82,177.92) v3(333.82,176.65) v3(333.82,170.3) v3(333.82,169.03) v3(333.82,167.76) v3(333.82,166.49) v3(333.82,160.14) v3(333.82,158.87) v3(333.82,157.6) v3(333.82,156.33) v3(333.82,149.98) v3(333.82,148.71) v3(333.82,147.44) v3(333.82,146.17) v3(333.82,139.82) v3(333.82,138.55) v3(333.82,137.28) v3(333.82,136.01) v3(333.82,129.66) v3(333.82,128.39) v3(333.82,127.12) v3(333.82,125.85) v3(335.09,189.35) v3(335.09,188.08) v3(335.09,186.81) v3(335.09,180.46) v3(335.09,179.19) v3(335.09,177.92) v3(335.09,176.65) v3(335.09,170.3) v3(335.09,169.03) v3(335.09,167.76) v3(335.09,166.49) v3(335.09,160.14) v3(335.09,158.87) v3(335.09,157.6) v3(335.09,156.33) v3(335.09,149.98) v3(335.09,148.71) v3(335.09,147.44) v3(335.09,146.17) v3(335.09,139.82) v3(335.09,138.55) v3(335.09,137.28) v3(335.09,136.01) v3(335.09,129.66) v3(335.09,128.39) v3(335.09,127.12) v3(335.09,125.85) v3(336.36,189.35) v3(336.36,188.08) v3(336.36,186.81) v3(336.36,180.46) v3(336.36,179.19) v3(336.36,177.92) v3(336.36,176.65) v3(336.36,170.3) v3(336.36,169.03) v3(336.36,167.76) v3(336.36,166.49) v3(336.36,160.14) v3(336.36,158.87) v3(336.36,157.6) v3(336.36,156.33) v3(336.36,149.98) v3(336.36,148.71) v3(336.36,147.44) v3(336.36,146.17) v3(336.36,139.82) v3(336.36,138.55) v3(336.36,137.28) v3(336.36,136.01) v3(336.36,129.66) v3(336.36,128.39) v3(336.36,127.12) v3(336.36,125.85) v3(337.63,189.35) v3(337.63,188.08) v3(337.63,186.81) v3(337.63,180.46) v3(337.63,179.19) v3(337.63,177.92) v3(337.63,176.65) v3(337.63,170.3) v3(337.63,169.03) v3(337.63,167.76) v3(337.63,166.49) v3(337.63,160.14) v3(337.63,158.87) v3(337.63,157.6) v3(337.63,156.33) v3(337.63,149.98) v3(337.63,148.71) v3(337.63,147.44) v3(337.63,146.17) v3(337.63,139.82) v3(337.63,138.55) v3(337.63,137.28) v3(337.63,136.01) v3(337.63,129.66) v3(337.63,128.39) v3(337.63,127.12) v3(337.63,125.85) v3(338.9,189.35) v3(338.9,188.08) v3(338.9,186.81) v3(338.9,180.46) v3(338.9,179.19) v3(338.9,177.92) v3(338.9,176.65) v3(338.9,170.3) v3(338.9,169.03) v3(338.9,167.76) v3(338.9,166.49) v3(338.9,160.14) v3(338.9,158.87) v3(338.9,157.6) v3(338.9,156.33) v3(338.9,149.98) v3(338.9,148.71) v3(338.9,147.44) v3(338.9,146.17) v3(338.9,139.82) v3(338.9,138.55) v3(338.9,137.28) v3(338.9,136.01) v3(338.9,129.66) v3(338.9,128.39) v3(338.9,127.12) v3(338.9,125.85) v3(340.17,188.08) v3(340.17,186.81) v3(340.17,180.46) v3(340.17,179.19) v3(340.17,177.92) v3(340.17,176.65) v3(340.17,170.3) v3(340.17,169.03) v3(340.17,167.76) v3(340.17,166.49) v3(340.17,160.14) v3(340.17,158.87) v3(340.17,157.6) v3(340.17,156.33) v3(340.17,149.98) v3(340.17,148.71) v3(340.17,147.44) v3(340.17,146.17) v3(340.17,139.82) v3(340.17,138.55) v3(340.17,137.28) v3(340.17,136.01) v3(340.17,129.66) v3(340.17,128.39) v3(340.17,127.12) v3(340.17,125.85) v3(341.44,188.08) v3(341.44,186.81) v3(341.44,180.46) v3(341.44,179.19) v3(341.44,177.92) v3(341.44,176.65) v3(341.44,170.3) v3(341.44,169.03) v3(341.44,167.76) v3(341.44,166.49) v3(341.44,160.14) v3(341.44,158.87) v3(341.44,157.6) v3(341.44,156.33) v3(341.44,149.98) v3(341.44,148.71) v3(341.44,147.44) v3(341.44,146.17) v3(341.44,139.82) v3(341.44,138.55) v3(341.44,137.28) v3(341.44,136.01) v3(341.44,129.66) v3(341.44,128.39) v3(341.44,127.12) v3(342.71,188.08) v3(342.71,179.19) v3(342.71,177.92) v3(342.71,169.03) v3(342.71,167.76) v3(342.71,158.87) v3(342.71,157.6) v3(342.71,148.71) v3(342.71,147.44) v3(342.71,138.55) v3(342.71,137.28) v3(342.71,128.39)
