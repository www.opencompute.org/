# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N32338934: length 13.4
  TOP w0.13: v1(310.81,203.05) 311.11,203.05 311.9,202.26 311.9,198.17 311.44,197.71 OSC1.2
  BOTTOM w0.13: R3178.2 308.17,203.93 308.45,203.65 R3176.1 309.56,203.65 309.84,203.93 C3467.1 310.55,203.48 310.81,203.22 v1(310.81,203.05)
N32339065: length 5.9
  BOTTOM w0.13: U117.6 304,208.63 v2(304.23,208.4) 304.76,207.87 R3134.2 R3137.2
N32339113: length 8.9
  BOTTOM w0.107: R3155.1 288.02,203.54 288.13,203.64 290.33,203.64 290.44,203.54 R3168.2 290.87,203.05 291.02,203.2 291.02,203.51 291.15,203.64 291.53,203.64 293.6,205.71 293.87,205.71 293.96,205.63 U117.25
N32339115: length 8.9
  BOTTOM w0.107: R3156.1 288.02,204.08 288.13,203.97 290.33,203.97 290.44,204.08 R3169.2 290.92,204.57 291.02,204.47 291.02,204.1 291.15,203.97 291.39,203.97 293.46,206.04 293.87,206.04 293.96,206.13 U117.26
N32339117: length 4.3
  BOTTOM w0.13: R3159.1 302.15,214.12 301.84,213.81 300.99,213.81 299.71,212.53 U117.46
N32339133: length 8.9
  BOTTOM w0.107: U117.36 293.96,211.13 293.87,211.04 293.47,211.04 292.41,212.1 291.14,212.1 291.02,212.21 291.02,212.72 290.92,212.82 R3174.2 290.44,212.21 290.33,212.1 288.13,212.1 288.02,212.21 C3450.1
N32339167: length 23
  TOP w0.254: R3183.1 38.65,162.97 v1(39.31,163.63)
  TOP w0.381: R3184.1 41.34,156.46 41.28,156.52 U118.5
  TOP w0.508: C3477.1 C3475.1 C3476.1 43.37,159.89 43.88,160.4 L449.2 ; C3477.1 42.61,156.84 41.97,157.48 U118.5 ; C3477.1 v1(43.37,155.7)
  BOTTOM w0.508: v1(43.37,155.7) 43.37,162.18 42.61,162.94 40,162.94 v1(39.31,163.63)
N32339181: length 2.5
  TOP w0.13: R3186.1 40.2,156.08 39.37,156.91 U118.4
N32340080: length 5.5
  BOTTOM w0.13: U117.3 302.27,210.13 v2(304.48,212.34) 305.09,212.95 R3136.2
N32340161: length 11.9
  TOP w0.508: C3464.2 v1(319.72,208.3) 319.11,208.3 318.53,207.72 OSC2.4 ; C3464.2 320.59,208.91 320.69,209.01 R3179.2 ; C3464.2 C3463.2 C3462.2 320.59,204.44 319.82,203.68 L448.1
N32340194: length 8.5
  TOP w0.13: X303.1 311.56,206.41 OSC2.3
  BOTTOM w0.13: X303.1 310.15,207.82 v2(308.67,207.82) 308.52,207.67 C3474.1 R3181.1
N32340196: length 2.2
  TOP w0.13: OSC2.1 318.54,210.82 v1(319.85,210.82) R3179.1
N32340280: length 8.9
  BOTTOM w0.107: U117.35 293.96,210.63 293.87,210.71 293.33,210.71 292.28,211.77 291.14,211.77 291.02,211.66 291.02,211.2 290.87,211.05 R3175.2 290.44,211.66 290.33,211.77 288.13,211.77 288.02,211.66 C3455.1
N32340378: length 2.4
  TOP w0.13: U118.1 41.28,161.1 41.19,161.19 R3185.2
N32340543: length 10.7
  BOTTOM w0.107: U117.14 300.2,204.38 300.12,204.3 300.12,204 300.88,203.25 302.37,203.25 302.95,202.67 302.95,202.18 303.07,202.05 303.47,202.05 303.67,201.85 R3161.2 303.05,201.24 302.95,201.13 302.95,199.29 303.07,199.16 303.07,198.57 303.18,198.46 303.44,198.46 303.54,198.36 R3138.1
N32340545: length 10.7
  BOTTOM w0.107: R3142.1 302.27,198.36 302.38,198.46 302.64,198.46 302.74,198.57 302.74,199.03 302.62,199.15 302.62,201.13 302.51,201.24 R3160.2 301.89,201.88 302.07,202.05 302.46,202.05 302.62,202.22 302.62,202.54 302.23,202.92 300.74,202.92 299.79,203.87 299.79,204.3 299.71,204.38 U117.15
N32340547: length 8.8
  BOTTOM w0.107: R3145.1 298.97,198.36 299.08,198.46 299.33,198.46 299.44,198.57 299.44,201.13 299.33,201.24 R3163.2 298.72,201.88 298.89,202.05 299.25,202.05 299.37,202.17 299.37,202.5 298.87,203 298.87,204.21 298.71,204.38 U117.17
N32340549: length 8.8
  BOTTOM w0.107: U117.16 299.2,203.13 299.7,202.64 299.7,202.25 299.9,202.05 300.29,202.05 300.49,201.85 R3162.2 299.88,201.24 299.77,201.13 299.77,198.57 299.88,198.46 300.13,198.46 300.24,198.36 R3144.1
N32340551: length 8.8
  BOTTOM w0.107: U117.20 297.2,204.42 297.04,204.25 297.04,202.99 296.6,202.55 296.6,202.28 296.82,202.05 297.12,202.05 297.32,201.85 R3165.2 296.7,201.24 296.6,201.13 296.6,199 296.47,198.87 296.47,198.57 296.58,198.46 296.83,198.46 296.94,198.36 R3147.1
N32340553: length 8.8
  BOTTOM w0.107: R3146.1 295.67,198.36 295.78,198.46 296.03,198.46 296.14,198.57 296.14,199.01 296.27,199.13 296.27,201.13 296.16,201.24 R3164.2 295.54,201.88 295.72,202.05 296.11,202.05 296.27,202.22 296.27,202.69 296.71,203.13 U117.21
N32340606: length 10.3
  TOP w0.13: R3143.2 297.12,215.14 296.86,215.39 296.86,216.66 v1(297.5,217.29)
  BOTTOM w0.13: v2(297.37,218.06) 297.5,217.93 v1(297.5,217.29) 298.01,216.79 298.01,214.75 297.88,214.63 C3438.2 297.45,213.96 297.62,213.78 297.62,213.23 297.2,212.81 U117.41
N32340616: length 1.9
  TOP w0.13: R3143.1 299.78,215.14 300.39,214.53 C3439.2
N32340618: length 3.1
  BOTTOM w0.13: C3437.2 296.3,214.17 296.86,213.61 v2(296.86,213.36) 296.86,212.98 296.71,212.82 U117.40
N32340715: length 5
  BOTTOM w0.13: U117.47 300.2,212.41 301.03,213.23 v2(302.58,213.23) 303.29,213.94 R3141.2
N32340717: length 7
  BOTTOM w0.13: R3135.2 304.97,215.49 v2(304.51,215.03) 303.85,214.37 303.85,213.48 302.96,212.6 302.96,211.96 302.13,211.13 U117.1
N32344144: length 8.2
  BOTTOM w0.107: U117.33 292.12,209.63 291.8,209.31 291.15,209.31 291.02,209.43 291.02,209.8 290.92,209.9 R3172.2 290.44,209.41 290.33,209.31 288.13,209.31 288.02,209.41 C3446.1
N32344146: length 8.2
  BOTTOM w0.107: C3447.1 288.02,208.87 288.13,208.98 290.33,208.98 290.44,208.87 R3173.2 290.87,208.38 291.02,208.53 291.02,208.85 291.15,208.98 291.93,208.98 292.26,209.3 293.85,209.3 294.02,209.13 U117.32
N32344318: length 10.8
  BOTTOM w0.107: R3153.1 293.89,198.36 293.78,198.46 293.53,198.46 293.42,198.57 293.42,201.13 293.53,201.24 R3166.2 294.14,201.85 293.94,202.05 293.55,202.05 293.42,202.18 293.42,202.68 293.66,202.92 295.54,202.92 296.12,203.5 296.12,204.3 296.2,204.38 U117.22
N32344320: length 10.8
  BOTTOM w0.107: U117.23 295.71,204.38 295.79,204.3 295.79,203.63 295.41,203.25 293.53,203.25 293.09,202.81 293.09,202.22 292.93,202.05 292.54,202.05 292.37,201.88 R3167.2 292.98,201.24 293.09,201.13 293.09,198.57 292.98,198.46 292.73,198.46 292.62,198.36 R3154.1
N32344332: length 8.3
  BOTTOM w0.107: U117.28 292.64,207.13 291.82,206.31 291.15,206.31 291.02,206.18 291.02,205.86 290.87,205.71 R3170.2 290.44,206.2 290.33,206.31 288.23,206.31 288.02,206.11 R3157.1
N32344334: length 8.3
  BOTTOM w0.107: R3158.1 288.02,206.84 288.23,206.64 290.33,206.64 290.44,206.75 R3171.2 290.92,207.24 291.02,207.13 291.02,206.92 291.31,206.64 291.68,206.64 292.5,207.46 293.79,207.46 293.96,207.63 U117.29
N32352652: length 8.2
  TOP w0.13: R3504.1 377.61,157.2 377.78,157.37 377.78,159.42 377.61,159.59 R3659.1 377.28,160.03 377.15,160.16 377.15,162.88 377.45,163.19 U140.19
N32365253: length 2.9
  BOTTOM w0.13: v1(147.13,210.31) v2(147.69,209.75)
  BOTTOM w0.381: C3621.2 147.36,211.43 v1(147.13,211.2)
  vias: v1(133.03,210.56) v1(133.03,209.67) v1(133.92,210.56) v1(133.92,209.67) v1(146.24,211.2) v1(146.24,210.31)
N32365255: length 3.1
  TOP w0.254: v1(151.7,211.71) 151.64,211.64 U128.6
  BOTTOM w0.13: v1(151.7,211.71) 151.85,211.86 v2(151.85,212.67)
  BOTTOM w0.254: R3514.1 151.42,211.43 v1(151.7,211.71)
N32365267: length 5.4
  TOP w0.254: R3515.2 155.13,209.85 154.9,210.08 C3629.2 154.11,210.08 153.89,209.85 R3516.2 151.96,209.85 151.84,209.74 U128.4
N32365460: length 3
  BOTTOM w0.381: R3514.2 C3621.1 v2(149.16,208.48)
N32365530: length 2.4
  BOTTOM w0.13: v1(366.08,114.93) v2(366.64,114.37)
  BOTTOM w0.381: C3619.2 365.34,115.97 v1(365.19,115.82)
  vias: v1(365.19,114.93) v1(366.08,115.82) v1(367.47,109.34) v1(367.47,108.46) v1(368.49,109.34) v1(368.49,108.46)
N32365532: length 3.4
  TOP w0.381: U127.6 v1(365.13,120.52)
  BOTTOM w0.381: R3511.1 365.34,120.31 v1(365.13,120.52) v2(365.13,121.28)
N32365544: length 5.6
  TOP w0.381: U127.4 367.03,120.94 366.81,121.16 R3513.2 R3512.2 366.81,124.1 366.43,124.48 C3620.2
N32365629: length 3
  BOTTOM w0.381: R3511.2 C3619.1 366.81,116.23 v2(367.09,115.95)
N32600224: length 5
  TOP w0.381: R3411.2 416.96,65.14 v1(417.3,65.49) 417.63,65.81 D433.1
N32600228: length 6.5
  TOP w0.381: D432.1 412.8,65.6 413.25,65.15 413.25,62.53 R3408.2 ; R3408.2 v1(414.14,62.5) ; R3408.2 R3405.2
N32600230: length 4.2
  TOP w0.13: R3409.2 v1(409.74,63.5) 409.74,64.3 411.04,65.6 D432.2
N32600337: length 6.9
  TOP w0.381: v1(408.39,63.47) 408.34,63.42 R3389.2 R3387.2 406.32,65.26 405.99,65.6 D431.1
N32600339: length 4.6
  TOP w0.13: D431.2 404.05,65.6 403.82,65.37 v1(403.82,63.24) 403.82,62.74 404.05,62.5 R3390.2
N32600404: length 5.6
  TOP w0.381: D430.1 398.55,65.6 399,65.15 399,63.79 399.34,63.45 R3374.2 R3369.2
N32600406: length 4.2
  TOP w0.13: R3379.2 395.92,62.74 396.56,63.37 396.56,64.96 397.19,65.6 D430.2
N32600485: length 7.2
  TOP w0.381: R3365.2 R3355.2 392.82,64.67 391.89,65.6 D429.1 391.35,66.54 v1(391.6,66.8)
N32600487: length 6
  TOP w0.13: v1(390.33,66.8) 390.65,66.48 D429.2 390.3,65.6 390.01,65.31 390.01,62.83 390.49,62.35 R3352.2
N32638646: length 2.9
  TOP w0.13: U122.1 390.23,101.95 389.6,102.59 R3243.1
N32687454: length 9.3
  TOP w0.107: R3231.2 406.91,214.14 407.06,214.29 407.06,215.22 406.14,216.15 406.14,219.76 405.3,220.59 J35.3
N32687486: length 9.4
  TOP w0.107: J35.5 403.3,220.71 403.11,220.52 402.49,220.52 402.14,220.16 402.14,216.25 402.65,215.73 402.65,214.52 R3229.2
N32687488: length 10.1
  TOP w0.107: R3234.2 398.27,214.14 398.42,214.29 398.42,214.98 399.09,215.64 399.85,215.64 400.14,215.92 400.14,219.79 399.3,220.62 J35.9
N32687490: length 10.6
  TOP w0.107: J35.11 397.3,220.79 396.98,220.47 396.5,220.47 396.1,220.07 396.1,216.34 395.28,215.52 394.44,215.52 393.89,214.97 393.89,214.52 R3235.2
N32687492: length 9.3
  TOP w0.107: J35.2 407.3,219.89 407.05,220.14 406.69,220.14 406.47,219.91 406.47,216.28 407.39,215.36 407.39,214.29 407.54,214.14 R3230.1
N32687534: length 9.4
  TOP w0.107: R3232.1 403.14,214.14 402.98,214.3 402.98,215.87 402.47,216.39 402.47,220.03 402.63,220.19 403.16,220.19 403.3,220.05 J35.6
N32687536: length 10.1
  TOP w0.107: J35.8 401.3,219.92 401.1,220.11 400.65,220.11 400.47,219.93 400.47,215.79 399.99,215.31 399.22,215.31 398.75,214.84 398.75,214.29 398.91,214.14 R3233.1
N32687538: length 10.6
  TOP w0.107: R3236.1 394.35,214.14 394.22,214.27 394.22,214.83 394.58,215.19 395.42,215.19 396.43,216.2 396.43,219.94 396.63,220.14 397.17,220.14 397.3,220.01 J35.12
N32696720: length 2.9
  TOP w0.305: U126.6 279.2,216.93 C3603.1
N32696851: length 2.3
  BOTTOM w0.13: v1(375.48,197.36) v2(375.48,198.12)
  BOTTOM w0.381: v1(382.84,199.64) 382.99,199.49 C3602.2
  vias: v1(375.48,196.34) v1(376.36,197.36) v1(376.36,196.34) v1(381.95,199.64) v1(381.95,198.75) v1(382.84,198.75)
N32696853: length 4.2
  TOP w0.381: U125.6 v1(387.54,199.7)
  BOTTOM w0.381: v1(387.54,199.7) 387.33,199.49 R3506.1 v2(385.89,201.04)
N32696865: length 7.1
  TOP w0.381: C3607.2 391.5,198.4 391.12,198.02 R3508.2 R3509.1 388.18,198.02 387.96,197.8 U125.4 386.6,197.31 v1(385.89,196.59)
N32697038: length 3.1
  BOTTOM w0.381: v2(384.37,196.47) C3602.1 R3506.2
N32723720: length 10.4
  TOP w0.13: v1(403.42,196.21) 403.16,196.47 398.72,196.47 398.21,196.97 398.21,199.69
  BOTTOM w0.13: v1(403.42,196.21) R3501.1 v2(404.69,195.3)
N32723723: length 4.9
  TOP w0.13: J30.3 v1(400.75,196.97)
  BOTTOM w0.13: v1(400.75,196.97) 400.75,197.63 v2(400.85,197.74) 401.38,197.74 401.66,197.46 R3502.1
N32723749: length 21.2
  TOP w0.13: v1(407.73,195.07) 407.23,195.58 407.23,202.44 406.84,202.82 398.46,202.82 398.21,203.07 398.21,205.69
  BOTTOM w0.13: v2(406.84,195.07) v1(407.73,195.07) 407.96,195.3 R3503.2
N32816680: length 2.3
  BOTTOM w0.13: v1(377.38,213.61) v2(377.38,212.85)
  BOTTOM w0.381: C3637.2 377.53,214.35 v1(377.38,214.5)
  vias: v1(370.01,212.21) v1(370.01,211.2) v1(370.9,212.21) v1(370.9,211.2) v1(376.49,214.5) v1(376.49,213.61)
N32816682: length 3.4
  TOP w0.381: U129.6 381.14,215.1 v1(380.81,215.44)
  BOTTOM w0.381: R3517.1 380.43,215.06 v1(380.81,215.44) v2(381.91,215.44)
N32816696: length 5.8
  TOP w0.381: C3638.2 386.11,212.24 385.86,211.99 R3518.2 R3519.2 382.37,211.99 v1(382.11,212.25) 381.7,212.66 U129.4
N32816879: length 3.2
  BOTTOM w0.381: R3517.2 C3637.1 378.9,211.94 v2(378.4,211.43)
N32816891: length 2.6
  TOP w0.381: D434.1 R3520.2
N32819414: length 3.3
  BOTTOM w0.254: v2(365.19,155.85) R3565.2 367.22,155.85 367.43,155.64 Q56.1
N32826604: length 2
  TOP w0.254: 374.84,132.14 374.84,132.84 374.33,133.35 R3561.2
N32826884: length 2
  TOP w0.254: Q57.1 374.59,108.84 374.08,109.34 R3568.2
N32827329: length 2.6
  TOP w0.13: U121.3 202.15,193.42 202.27,193.29 v1(202.27,192.78) R3246.1
N32827380: length 6.1
  TOP w0.13: U122.3 390.59,99.41 390.21,99.03 390.21,97.66 391.48,96.39 R3248.1
N32837875: length 4.8
  TOP w0.13: L450.1 422.64,7.16 422.32,6.84 SW1.1
N32837877: length 2
  TOP w0.13: L450.2 R3237.2
N32839304: length 12.4
  TOP w0.13: U123.H11 v1(27.25,159.8)
  SIG2 w0.152: v1(27.25,159.8) 27.25,159.5 28,158.75 30.42,158.75 30.8,159.13 33.06,159.13 v1(33.62,158.57)
  BOTTOM w0.13: v1(33.62,158.57) 34.1,158.09 34.1,157.1 34.61,156.59 R3288.2 R3291.2
N32840365: length 6.4
  TOP w0.13: R3283.2 R3285.2 35.24,160.02 34.86,159.64 34.61,159.64 34.01,159.04 32.31,159.04 31.87,158.6 U123.J16
N32893128: length 12.3
  TOP w0.13: v1(34.61,152.78) 34.86,153.03 R3606.1 ; U123.J12 v1(28.05,158.2)
  SIG2 w0.102: v1(28.05,158.2) 28.45,157.8 30.14,157.8
  SIG2 w0.152: v1(34.61,152.78) 33.72,153.67 32.83,153.67 31.43,155.06 31.43,156.72 30.35,157.8 30.14,157.8
  BOTTOM w0.13: v2(34.23,153.54) 34.61,153.16 v1(34.61,152.78)
N32899033: length 0.6
  TOP w0.13: U124.E8 X282.1
N32899051: length 8.5
  TOP w0.13: R3675.1 391.33,186.13 v1(391.83,185.62) ; U124.C4 X276.1
  SIG4 w0.155: v1(391.83,185.62) 392.65,186.43 394.91,186.43 395.41,185.93 396.68,185.93 396.94,186.18 397.48,186.18 X276.1
N32899085: length 0.6
  TOP w0.13: U124.D10 X280.1
N32899101: length 0.6
  TOP w0.13: U124.E10 X281.1
N32899129: length 7.1
  TOP w0.13: X274.1 412.31,187.96 409.89,187.96 409.51,187.58 409.51,186.94 408.22,185.65 407.62,185.65 U124.C15
N32899145: length 5
  TOP w0.13: X275.1 409.77,188.59 409,187.83 409,187.03 U124.B16
N32899165: length 3.1
  TOP w0.13: X277.1 410.12,187.09 408.27,185.25 U124.C16
N32899181: length 5.5
  TOP w0.13: U124.D15 407.62,184.85 408.33,184.85 409.79,186.31 410.53,186.31 X271.1
N32899201: length 0.6
  TOP w0.13: U124.F13 X272.1
N32899217: length 0.6
  TOP w0.13: U124.G12 X273.1
N32899243: length 0.6
  TOP w0.13: U124.F12 X278.1
N32899259: length 0.6
  TOP w0.13: U124.G13 X279.1
N32899279: length 0.6
  TOP w0.13: U124.H3 X283.1
N32899295: length 4.3
  TOP w0.13: X284.1 394.11,181.52 394.73,181.52 394.93,181.32 395.94,181.32 U124.H1
N32899315: length 3.8
  TOP w0.13: U124.J1 395.94,180.52 395.61,180.52 395.46,180.67 394.66,180.67 394.46,180.87 393.05,180.87 X285.1
N32899331: length 0.6
  TOP w0.13: U124.J3 X286.1
N33261195: length 23.2
  TOP w0.13: U124.A10 403.22,187.88 403.76,188.42 403.76,189.7 405.32,191.26 405.32,194.54 404.69,195.17 402.91,195.17 402.68,194.94 C21.1 R29.2 401.49,194.97 400.37,196.09 394.14,196.09 393.64,195.58 X250.1
N34483800: length 115.9
  TOP w0.13: U123.E8 v1(24.05,162.2)
  SIG4 w0.155: v1(24.05,162.2) 24.66,162.81 24.66,165.55 24.21,166.01 22.01,166.01 21.4,166.62 21.4,167.38 19.62,169.16 14.29,169.16 8.96,174.49 8.96,183.13 11.87,186.05 11.87,191.39 12.51,192.02 12.51,194.18 20.76,202.44 27.24,202.44 32.19,207.39 32.19,212.34 33.83,213.98 64.73,213.98 69.06,218.31 v1(69.66,218.31)
  BOTTOM w0.13: R27.1 v1(69.66,218.31)
N34483802: length 116.9
  TOP w0.13: U123.F7 v1(23.25,161.4)
  SIG4 w0.102: 22.85,164.23 22.85,161.8 v1(23.25,161.4)
  SIG4 w0.155: v1(69.66,219.33) 69.53,219.33 64.57,214.36 30.91,214.36 29.4,212.85 29.4,206.12 26.48,203.2 19.62,203.2 10.16,193.74 10.16,191.96 8.57,190.37 8.57,174.24 15.3,167.51 17.84,167.51 19.37,165.99 21.27,165.99 22.85,164.4 22.85,164.23
  BOTTOM w0.13: R26.1 v1(69.66,219.33)
N34483892: length 8.7
  TOP w0.13: X302.1 391.99,187.58 R3676.1 ; U124.B5 v1(398.82,186.45)
  SIG4 w0.155: X302.1 397.43,187.83 v1(398.82,186.45)
N264813220: length 21.2
  TOP w0.13: v1(46.55,83.82) 46.42,83.94 R2585.1
  SIG1 w0.16: v1(46.55,83.82) 46.29,83.82 45.53,83.06 45.53,76.07 45.02,75.56 45.02,65.76 44.3,65.03 YJ21.C27
N264813390: length 17.9
  SIG3 w0.155: YJ21.C28 43.5,74.93 43.88,75.31 43.88,78.1 43.37,78.61 v1(43.37,81.15)
  BOTTOM w0.13: v1(43.37,81.15) 43.22,81.3 R2586.1 41.64,81.3 v2(41.34,81.61)
N265383680: length 36.2
  TOP w0.13: v1(41.59,76.07) 41.59,76.32 40.83,77.09 40.83,77.72 40.98,77.87 R2612.1
  SIG9 w0.155: v1(53.28,71.5) 53.28,64.64 52.01,63.37 42.15,63.37 YJ22.A27
  BOTTOM w0.13: v1(53.28,71.5) 46.42,71.5 v2(42.61,75.31) 42.35,75.31 v1(41.59,76.07)
N265383760: length 23.2
  TOP w0.13: v1(43.37,84.71) 43.6,84.48 R2605.1
  SIG10 w0.155: YJ22.A28 41.9,67.67 44.88,70.64 44.88,81.93 43.12,83.69 43.12,84.45 v1(43.37,84.71)
  BOTTOM w0.13: v1(43.37,84.71) 42.48,85.6 v2(42.35,85.6)
N321190091: length 4.7
  TOP w0.13: Q6.1 22.36,174.44 22.7,174.77 R3300.2
N321683591: length 5.2
  TOP w0.13: R3359.2 388.81,193.67 388.37,193.23 Q42.1
N3212144327: length 16.4
  TOP w0.13: U123.D8 v1(24.05,163)
  SIG2 w0.152: v1(15.05,168.53) 15.43,168.15 17.21,168.15 19.37,165.99 24.32,165.99 24.66,165.65 24.66,163.61 v1(24.05,163)
  BOTTOM w0.13: v2(14.03,169.8) 14.26,169.57 R3322.1 v1(15.05,168.53)

## Copper pours and planes (outline as drawn)
DVDD on TOP (solid shape): outline of 497 points within 290.64,199.26 307.78,218.56
GND on TOP (solid shape): 49.09,142.49 49.09,137.54 48.96,137.41 44.77,137.41 44.51,137.67 44.51,142.36 44.89,142.75 48.83,142.75
GND on TOP (solid shape): 52.26,152.78 52.26,147.83 52.13,147.7 46.55,147.7 46.16,148.08 46.16,152.78 46.42,153.03 52.01,153.03
GND on TOP (solid shape): 352.87,183 352.87,180.85 354.39,179.32 354.39,178.47 353.22,177.29 353.22,175.69 353.18,175.65 351.55,175.65 351.31,175.89 351.31,181.83 352.23,182.75 352.23,183.33 352.25,183.37 352.29,183.39 352.49,183.39
GND on TOP (solid shape): 300.04,212.98 300.04,206.37 299.91,206.25 299.78,206.25 298.92,206.25 298.92,206.25 298.64,206.25 298.64,206.25 297.78,206.25 297.78,206.25 297.5,206.25 297.5,206.25 296.63,206.25 296.63,206.25 296.36,206.25 296.36,206.25 296.1,206.25 295.97,206.37 295.97,212.98 296.1,213.1 299.91,213.1
GND on TOP (solid shape): 355.48,146.81 355.54,146.81 359.38,142.96 359.39,142.96 359.45,142.87 359.54,142.8 360.24,142.1 360.24,136.01 357.19,132.97 351.47,132.97 351.35,133.09 351.35,133.6 351.56,133.82 353.38,133.82 354.31,134.74 356.55,134.74 358.58,136.78 358.58,141.35 356.55,143.38 354.01,143.38 352.11,145.29 351.18,145.29 351.06,145.41 351.06,147.65 351.26,147.85 354.43,147.85
GND on TOP (solid shape): 352.62,162.94 352.62,160.65 353.89,159.38 354.39,159.38 354.52,159.26 354.52,158.75 354.01,158.24 354.01,158.06 354.01,158.04 354,158.03 353.89,157.76 354,157.48 354.01,157.47 354.01,157.45 354.01,157.1 353.22,156.3 353.22,155.41 353.12,155.31 351.37,155.31 351.31,155.37 351.31,161.63 352.11,162.43 352.11,163.01 352.12,163.05 352.16,163.07 352.49,163.07
GND on TOP (solid shape): 352.74,142.49 352.74,139.44 353.38,138.81 354.27,138.81 354.52,138.55 354.52,137.85 354.51,137.82 354.47,137.8 354.41,137.8 354.09,137.49 354.09,137.48 353.9,137.2 354.03,136.85 354.02,136.81 353.22,136.01 353.22,135.36 352.87,135.01 351.35,135.01 351.31,135.05 351.31,141.19 351.98,141.86 351.98,142.82 352,142.86 352.03,142.87 352.36,142.87
GND on TOP (solid shape): 380.3,217.29 380.3,214.37 380.17,214.25 379.01,214.25 378.02,214.25 377.89,214.37 377.89,214.73 377.89,214.88 377.76,215.01 376.26,215.01 376.11,215.01 375.86,214.75 375.86,213.97 375.84,213.93 375.81,213.92 374.93,213.92 374.93,213.03 374.91,212.99 374.88,212.98 372.55,212.98 372.43,213.1 372.43,216.28 372.55,216.41 372.83,216.41 372.87,216.39 372.88,216.35 372.88,215.74 373.75,215.74 373.75,216.35 373.76,216.39 373.8,216.41 374.36,216.41 374.39,216.39 374.41,216.35 374.41,215.74 375.27,215.74 375.27,216.35 375.29,216.39 375.32,216.41 375.48,216.41 376.62,217.55 380.05,217.55
GND on TOP (solid shape): 385.76,202.44 385.76,199.51 385.64,199.39 384.47,199.39 383.48,199.39 383.35,199.51 383.35,199.87 383.35,200.02 383.22,200.15 383.07,200.15 381.72,200.15 381.57,200.15 381.32,199.9 381.32,199.11 381.3,199.07 381.27,199.06 380.39,199.06 380.39,198.17 380.38,198.13 380.34,198.12 378.02,198.12 377.89,198.24 377.89,201.42 378.02,201.55 378.29,201.55 378.33,201.53 378.35,201.5 378.35,200.89 379.21,200.89 379.21,201.5 379.22,201.53 379.26,201.55 379.82,201.55 379.85,201.53 379.87,201.5 379.87,200.89 380.73,200.89 380.73,201.5 380.75,201.53 380.78,201.55 380.94,201.55 382.08,202.69 385.51,202.69
GND on TOP (solid shape): 365.44,118.62 365.44,117.45 365.44,117.45 365.44,116.46 365.32,116.33 364.96,116.33 364.81,116.33 364.68,116.2 364.68,114.7 364.68,114.55 364.93,114.3 365.72,114.3 365.76,114.28 365.77,114.25 365.77,113.37 366.66,113.37 366.7,113.36 366.71,113.32 366.71,111.06 366.71,111 366.59,110.87 363.41,110.87 363.28,111 363.28,111.27 363.3,111.31 363.33,111.33 363.94,111.33 363.94,112.19 363.33,112.19 363.3,112.2 363.28,112.24 363.28,112.8 363.3,112.83 363.33,112.85 363.94,112.85 363.94,113.71 363.33,113.71 363.3,113.73 363.28,113.76 363.28,113.92 362.14,115.06 362.14,118.49 362.39,118.74 365.32,118.74
GND on TOP (solid shape): 50.48,130.68 50.48,129.28 54.42,125.35 54.42,117.98 53.91,117.47 51.98,117.47 51.95,117.49 51.93,117.52 51.93,118.23 51.07,118.23 51.07,117.52 51.05,117.49 51.02,117.47 50.86,117.47 50.83,117.49 50.81,117.52 50.81,118.23 49.95,118.23 49.95,117.52 49.93,117.49 49.9,117.47 49.62,117.47 49.58,117.49 49.57,117.52 49.57,118.23 48.7,118.23 48.7,117.52 48.69,117.49 48.65,117.47 46.67,117.47 46.04,118.11 46.04,125.98 45.02,127 33.39,127 33.35,127.01 33.34,127.05 33.34,130.05 33.59,130.3 41.72,130.3 41.79,130.38 42.88,130.38 42.88,131.26 42.89,131.3 42.93,131.31 49.85,131.31
GND on TOP (solid shape): 29.4,133.6 29.4,111.12 29.27,111 24.96,111 24.45,110.49 24.3,110.49 24.26,110.5 24.25,110.54 24.25,111.25 23.38,111.25 23.38,110.54 23.37,110.5 23.33,110.49 23.18,110.49 23.14,110.5 23.13,110.54 23.13,111.25 22.26,111.25 22.26,110.54 22.25,110.5 22.21,110.49 21.93,110.49 21.9,110.5 21.88,110.54 21.88,111.25 21.02,111.25 21.02,110.54 21,110.5 20.97,110.49 18.99,110.49 18.35,111.12 18.35,119 17.34,120.01 5.7,120.01 5.67,120.03 5.65,120.06 5.65,123.06 5.91,123.31 14.03,123.31 14.11,123.39 15.19,123.39 15.19,124.28 15.2,124.31 15.24,124.33 23.5,124.33 24.06,124.89 24.06,133.53 24.44,133.91 29.1,133.91
GND on TOP (solid shape): 396.3,128.27 396.3,126.34 396.29,126.3 396.25,126.29 395.54,126.29 395.54,125.42 396.25,125.42 396.29,125.41 396.3,125.37 396.3,125.22 396.29,125.18 396.25,125.17 395.54,125.17 395.54,124.3 396.25,124.3 396.29,124.29 396.3,124.25 396.3,123.98 396.29,123.94 396.25,123.92 395.54,123.92 395.54,123.06 396.25,123.06 396.29,123.05 396.3,123.01 396.3,121.03 395.67,120.39 387.79,120.39 386.78,119.38 386.78,107.74 386.76,107.71 386.73,107.69 383.73,107.69 383.48,107.95 383.48,115.82 383.33,115.97 383.31,116.07 383.4,116.14 383.4,117.23 382.52,117.23 382.48,117.25 382.47,117.28 382.47,125.54 381.9,126.11 376.62,126.11 376.12,125.6 376.12,121 375.77,120.65 373.73,120.65 373.54,120.85 373.54,128.34 373.98,128.78 395.8,128.78
GND on TOP (solid shape): outline of 107 points within 373.79,131.7 396.56,155.83
GND on TOP (solid shape): outline of 173 points within 284.42,203.96 289.24,215.26
GND on TOP (solid shape): outline of 285 points within 68.85,126.59 86.94,193.55
GND on TOP (solid shape): outline of 417 points within 327.72,114.58 347.25,201.17
GND on BOTTOM (solid shape): 56.71,141.86 56.71,138.17 56.58,138.05 53.78,138.05 53.53,138.3 53.53,141.6 53.98,142.05 56.52,142.05
GND on BOTTOM (solid shape): 380.68,202.05 380.68,198.37 380.43,198.12 376.87,198.12 376.62,198.37 376.62,202.05 376.75,202.18 380.56,202.18
GND on BOTTOM (solid shape): 26.73,123.31 26.73,111 26.23,110.49 18.99,110.49 18.35,111.12 18.35,119 17.34,120.01 7.36,120.01 7.16,120.21 7.16,123 7.48,123.31 13.78,123.31 14.79,124.33 25.72,124.33
GND on BOTTOM (solid shape): 50.36,130.8 50.36,127.63 54.42,123.57 54.42,117.98 53.91,117.47 46.67,117.47 46.04,118.11 46.04,125.98 45.02,127 35.05,127 34.85,127.2 34.85,130.76 35.4,131.31 49.85,131.31
GND on BOTTOM (solid shape): 359.6,160.93 359.73,160.91 359.85,160.93 359.86,160.93 361.67,160.93 362.06,160.55 362.06,156.87 361.93,156.74 357.74,156.74 357.48,156.99 357.48,160.8 357.61,160.93 359.59,160.93
GND on BOTTOM (solid shape): 360.23,181.12 360.24,181.12 360.38,181.03 360.51,181 360.53,181 360.66,180.87 360.66,177.57 360.21,177.12 357.67,177.12 357.48,177.31 357.48,181 357.61,181.12
GND on BOTTOM (solid shape): 366.71,113.41 366.71,109.85 366.46,109.6 363.28,109.6 363.03,109.85 363.03,110.02 363.04,110.05 363.08,110.07 363.97,110.07 363.97,111.16 363.08,111.16 363.04,111.18 363.03,111.21 363.03,112.56 363.04,112.59 363.08,112.61 363.97,112.61 363.97,113.61 363.98,113.65 364.02,113.66 366.46,113.66
GND on BOTTOM (solid shape): 371.58,216.66 371.61,216.64 371.63,216.61 371.63,215.72 372.72,215.72 372.72,216.61 372.74,216.64 372.77,216.66 374.12,216.66 374.15,216.64 374.17,216.61 374.17,215.72 375.17,215.72 375.21,215.7 375.22,215.67 375.22,213.23 374.97,212.98 371.41,212.98 371.16,213.23 371.16,216.41 371.41,216.66
GND on BOTTOM (solid shape): outline of 381 points within 53.53,127.89 64.82,186.56
GND on BOTTOM (solid shape): outline of 439 points within 68.9,126.59 86.94,194.41
GND on BOTTOM (solid shape): outline of 500 points within 327.72,123.76 347.2,200.15
GND on TOP: 250.51,89.02 248.86,89.02 248.73,89.15 248.73,90.04 248.48,90.29 248.48,91.44 248.6,91.56 249.11,91.56 249.24,91.44 250.51,91.44 250.76,91.18 250.76,89.28
GND on TOP: 165.67,187.83 163.89,187.83 163.77,187.7 163.77,185.8 163.89,185.67 165.67,185.67 165.8,185.8 165.8,187.7
GND on TOP: 225.23,89.02 224.98,89.28 224.98,90.93 225.23,91.18 226.63,91.18 227.52,90.29 227.52,89.28 227.27,89.02
GND on TOP: 165.93,181.48 165.8,181.35 165.8,179.58 165.93,179.45 167.31,179.45 167.44,179.58 167.44,181.37 167.33,181.48
GND on TOP: 304.1,78.36 300.93,78.36 300.8,78.48 300.8,80.39 301.05,80.64 304.48,80.64 304.61,80.52 304.61,78.86
GND on TOP: 177.23,187.83 175.96,187.83 175.74,187.62 175.74,185.89 175.96,185.67 177.23,185.67 177.36,185.8 177.36,185.81 177.42,185.87 177.42,187.64
GND on TOP: 160.34,144.99 160.34,143.76 160.08,143.51 154.5,143.51 153.73,142.75 148.47,142.75 148.21,143.01 148.21,145.18 148.35,145.31 160.01,145.31
GND on TOP: 328.36,89.02 326.71,89.02 326.58,89.15 326.58,90.93 326.71,91.06 328.36,91.06 328.61,90.8 328.61,89.28
GND on TOP: 62.55,89.02 61.15,89.02 60.9,89.28 60.9,90.8 61.15,91.06 62.55,91.06 62.8,90.8 62.8,89.28
GND on TOP: 214.19,97.53 215.84,97.53 215.96,97.41 215.96,95.88 215.84,95.76 214.19,95.76 214.06,95.88 214.06,97.41
GND on TOP: 167.32,99.82 168.97,99.82 169.1,99.69 169.1,98.17 168.97,98.04 167.32,98.04 167.2,98.17 167.2,99.69
GND on TOP: 45.66,186.05 40.83,186.05 40.32,186.56 40.32,202.05 41.08,202.82 45.15,202.82 45.91,202.05 45.91,186.31
GND on TOP: 243.52,113.15 243.14,112.77 241.87,112.77 240.92,113.73 240.92,115.91 240.35,116.48 240.35,119.45 240.73,119.83 243.27,119.83 243.52,119.58
GND on TOP: 282.77,91.06 284.16,91.06 284.42,90.8 284.42,89.28 284.16,89.02 282.77,89.02 282.51,89.28 282.51,90.8
GND on TOP: 381.44,98.17 384.49,98.17 384.62,98.04 384.62,96.39 384.49,96.26 381.44,96.26 381.32,96.39 381.32,98.04
GND on TOP: 391.72,209.42 387.67,209.42 387.41,209.67 387.41,213.38 387.54,213.51 391.72,213.51 391.93,213.29 391.93,209.63
GND on TOP: 180.02,181.48 180.15,181.35 180.15,180.97 180.4,180.72 180.4,179.7 180.15,179.45 178.63,179.45 178.5,179.58 178.5,181.35 178.63,181.48
GND on TOP: 93.79,78.48 93.66,78.36 89.98,78.36 89.85,78.48 89.85,80.9 89.98,81.02 93.66,81.02 93.79,80.9
GND on TOP: 47.05,83.56 47.05,85.85 47.18,85.98 47.82,85.98 48.2,85.6 49.34,85.6 49.59,85.34 49.59,83.69 49.34,83.44 47.18,83.44
GND on TOP: 405.96,126.74 404.3,126.74 404.18,126.87 404.18,130.17 403.67,130.68 400.24,130.68 400.11,130.81 400.11,132.97 400.49,133.35 405.7,133.35 406.34,132.71 406.34,127.12
GND on TOP: 55.94,159.13 56.2,158.87 56.58,158.87 56.9,158.56 56.9,156.4 57.85,155.45 59.63,155.45 60.01,155.83 60.01,157.6 60.26,157.86 61.02,157.86 61.91,156.97 61.91,153.29 64.96,150.24 64.96,149.35 64.58,148.97 63.18,148.97 60.01,152.14 56.83,152.14 55.44,153.54 55.44,157.48 54.29,158.62 54.29,162.05 56.58,164.34 57.59,164.34 57.85,164.08 57.85,162.81 56.83,161.8 56.07,161.8 55.94,161.67
GND on TOP: 237.55,84.33 237.43,84.2 233.74,84.2 233.62,84.33 233.62,86.23 233.87,86.48 237.3,86.48 237.55,86.23
GND on TOP: 68.26,89.02 68.01,89.28 68.01,91.31 68.26,91.56 70.29,91.56 70.55,91.31 70.55,89.28 70.29,89.02
GND on TOP: 390.21,90.17 391.6,90.17 391.86,89.91 391.86,88.39 391.6,88.14 390.21,88.14 389.95,88.39 389.95,89.91
GND on TOP: 294.07,90.17 296.61,90.17 296.74,90.04 296.74,88.26 296.48,88.01 294.07,88.01 293.94,88.14 293.94,90.04
GND on TOP: 117.16,84.33 117.03,84.2 116.52,84.2 116.14,83.82 114.36,83.82 113.98,84.2 113.35,84.2 113.22,84.33 113.22,86.1 113.35,86.23 117.03,86.23 117.16,86.1
GND on TOP: 170.62,85.98 170.75,86.1 174.43,86.1 174.56,85.98 174.56,83.43 174.56,83.43 170.72,83.43 170.62,83.52
GND on TOP: 419.67,57.02 424.37,57.02 424.5,57.15 424.5,61.08 424.37,61.21 419.67,61.21 419.54,61.08 419.54,57.15
GND on TOP: 271.72,213.79 275.93,213.79 276.39,213.33 282.87,213.33 283.12,213.08 283.12,210.41 282.92,210.21 279.82,210.21 279.67,210.36 279.67,211.66 279.51,211.81 277.41,211.81 276.09,210.49 271.64,210.49 271.44,210.69 271.44,213.51
GND on TOP: 207.2,80.39 207.45,80.64 210.88,80.64 211.14,80.39 211.14,77.57 211.12,77.55 207.32,77.55 207.2,77.67
GND on TOP: 195.14,99.82 196.79,99.82 196.91,99.69 196.91,98.17 196.79,98.04 195.14,98.04 195.01,98.17 195.01,99.69
GND on TOP: 287.08,86.48 288.61,86.48 288.86,86.23 288.86,84.83 288.48,84.45 287.08,84.45 286.7,84.83 286.7,86.1
GND on TOP: 55.94,142.62 56.96,143.63 61.79,143.63 63.18,142.24 64.45,142.24 64.71,142.49 64.71,143.76 64.07,144.4 62.93,144.4 62.67,144.14 55.82,144.14 54.29,142.62 54.29,138.94 55.18,138.05 55.18,136.78 51.12,132.71 51.12,129.41 53.91,126.62 67.37,126.62 68.01,127.25 68.01,128.27 67.88,128.39 67.25,128.39 66.99,128.65 66.99,130.43 66.61,130.81 63.94,130.81 62.29,132.46 62.29,136.14 61.15,137.28 60.13,137.28 60.01,137.16 60.01,135.51 59.88,135.38 57.98,135.38 56.58,136.78 56.58,138.05 55.94,138.68
GND on TOP: 140.02,92.07 136.39,95.7 136.39,126.8 126.83,136.35 126.83,192.62 127.5,193.29 135.6,193.29 137.3,191.58 137.3,188.2 150.91,174.59 150.91,170.15 150.43,169.67 148.53,169.67 148.4,169.8 148.4,173.92 148.02,174.3 143.89,174.3 143.19,173.61 143.19,143.51 142.9,143.23 141.07,143.23 141.03,143.19 141.03,142.24 141.67,141.6 142.62,141.6 142.73,141.5 142.73,126.97 142.94,126.75 142.94,125.57 142.94,125.56 142.94,92.33 142.68,92.07 ; 1 cut-out
GND on TOP: 212.03,89.02 211.77,89.28 211.77,91.82 212.03,92.07 212.28,92.33 216.85,92.33 218,92.33 218.25,92.07 218.25,91.31 218.5,91.06 219.52,91.06 219.77,90.8 219.77,89.28 219.52,89.02 217.74,89.02 217.74,89.03 217.29,89.03 217.06,89.26 214.29,89.26 214.06,89.02
GND on TOP: 75.76,89.02 73.98,89.02 73.85,89.15 73.85,90.93 73.98,91.06 75.76,91.06 76.01,90.8 76.01,89.28
GND on TOP: 302.83,86.87 302.7,86.99 300.8,86.99 300.67,86.87 300.67,84.58 300.8,84.45 302.7,84.45 302.83,84.58
GND on TOP: 211.65,185.93 211.39,185.67 202.76,185.67 202.63,185.8 202.63,187.58 202.88,187.83 211.39,187.83 211.65,187.58
GND on TOP: 148.53,101.22 148.02,101.72 148.02,114.81 148.15,114.93 152.97,114.93 153.29,114.62 153.29,101.6 152.9,101.22
GND on TOP: 231.71,184.15 231.58,184.02 216.6,184.02 216.47,184.15 216.47,187.45 216.6,187.58 231.58,187.58 231.71,187.45
GND on TOP: 160.21,132.71 160.34,132.59 160.34,130.3 159.96,129.92 152.21,129.92 151.83,130.3 151.83,132.59 151.96,132.71
GND on TOP: 169.99,89.02 169.86,88.9 168.08,88.9 167.83,89.15 167.83,91.06 167.96,91.18 169.86,91.18 169.99,91.06
GND on TOP: 88.96,89.02 87.57,89.02 87.31,89.28 87.31,90.8 87.57,91.06 88.96,91.06 89.22,90.8 89.22,89.28
GND on TOP: 150.94,133.47 151.07,133.6 151.07,136.65 150.94,136.78 149.16,136.78 149.03,136.65 149.03,133.6 149.16,133.47
GND on TOP: 143.57,84.33 143.45,84.2 139.76,84.2 139.64,84.33 139.64,86.23 139.89,86.48 143.32,86.48 143.57,86.23
GND on TOP: 160.21,118.74 160.34,118.62 160.34,116.96 158.56,115.19 148.07,115.19 147.77,115.49 147.77,117.98 151.57,117.98 151.83,118.23 153.73,118.23 154.24,118.74
GND on TOP: 216.6,178.94 228.03,178.94 229.17,177.8 229.17,175 229.04,174.88 224.35,174.88 222.31,176.91 216.47,176.91 216.34,177.04 216.34,178.69
GND on TOP: 54.42,182.75 55.82,182.75 55.94,182.62 55.94,179.45 56.2,179.19 56.58,179.19 57.34,178.43 57.34,176.91 58.23,176.02 60.01,176.02 60.13,176.15 60.13,177.92 60.26,178.05 61.28,178.05 62.17,177.16 62.17,173.48 64.83,170.81 64.83,168.91 64.58,168.65 64.07,168.65 59.63,173.1 56.96,173.1 55.18,174.88 55.18,178.43 54.29,179.32 54.29,182.62
GND on TOP: 169.1,101.98 169.1,100.45 168.97,100.33 167.58,100.33 167.2,100.71 167.2,102.99 167.45,103.25 167.83,103.25
GND on TOP: 239.33,147.95 239.33,149.6 239.46,149.73 240.98,149.73 241.11,149.6 241.11,147.95 240.98,147.83 239.46,147.83
GND on TOP: 123.89,91.06 125.54,91.06 125.79,90.8 125.79,88.77 125.67,88.64 124.52,88.64 124.27,88.39 123.76,88.39 123.51,88.64 123.51,90.68
GND on TOP: 241.95,108.66 242.46,109.17 243.78,109.17 246.32,106.63 246.32,104.8 245.81,104.29 242.15,104.29 241.95,104.49
GND on TOP: 171.13,187.83 169.86,187.83 169.74,187.7 169.74,185.8 169.86,185.67 171.13,185.67 171.26,185.8 171.26,187.7
GND on TOP: 9.21,76.58 9.46,76.83 12.89,76.83 13.14,76.58 13.14,74.17 12.89,73.91 9.33,73.91 9.21,74.04
GND on TOP: 195.14,97.53 196.79,97.53 196.91,97.41 196.91,95.88 196.79,95.76 195.14,95.76 195.01,95.88 195.01,97.41
GND on TOP: 315.15,89.02 310.07,89.02 309.82,89.28 309.82,91.06 309.94,91.18 315.15,91.18 315.4,90.93 315.4,89.28
GND on TOP: 61.02,162.68 62.42,162.68 63.94,161.16 64.71,161.16 65.09,160.78 65.09,153.79 64.71,153.41 64.71,152.65 64.58,152.52 64.45,152.52 63.18,153.79 63.18,157.73 61.15,159.76 60.13,159.76 60.13,161.8
GND on TOP: 112.59,90.68 112.59,89.28 112.33,89.02 110.55,89.02 110.43,89.15 110.43,90.68 110.81,91.06 112.2,91.06
GND on TOP: 380.05,83.18 382.08,83.18 382.33,82.93 382.33,80.39 382.21,80.26 380.05,80.26 379.79,80.52 379.79,82.93
GND on TOP: 154.37,173.57 154.24,173.44 152.84,173.44 152.72,173.57 152.72,175.09 152.84,175.22 154.24,175.22 154.37,175.09
GND on TOP: 195.14,102.11 196.79,102.11 196.91,101.98 196.91,100.45 196.79,100.33 195.14,100.33 195.01,100.45 195.01,101.98
GND on TOP: 212.92,102.36 211.01,102.36 210.88,102.23 210.88,96.14 211.01,96.01 212.79,96.01 213.04,96.26 213.04,102.23
GND on TOP: 351.47,173.61 351.35,173.73 351.35,174.24 351.6,174.5 353.89,174.5 354.77,175.38 356.3,175.38 358.58,177.67 358.58,182.37 357.19,183.77 354.65,183.77 354.52,183.64 354.52,181.99 354.39,181.86 354.27,181.86 354.14,181.99 354.14,183.77 352.11,185.8 352.11,186.94 350.84,188.21 348.17,188.21 348.04,188.34 348.04,189.1 348.3,189.35 353.63,189.35 360.24,182.75 360.24,177.42 356.43,173.61
GND on TOP: 117.16,78.48 117.03,78.36 116.52,78.36 115.89,77.72 114.49,77.72 113.86,78.36 113.35,78.36 113.22,78.48 113.22,80.13 113.35,80.26 114.49,80.26 114.62,80.13 115.76,80.13 115.89,80.26 117.03,80.26 117.16,80.13
GND on TOP: 248.55,113.03 248.45,113.13 248.45,133.93 247.64,134.74 235.52,134.74 235.27,135 235.27,137.28 235.39,137.41 243.14,137.41 243.4,137.67 243.4,158.87 242.13,160.14 236.97,160.14 236.77,160.35 236.77,161.72 236.97,161.92 241.87,161.92 242.51,162.56 242.51,173.35 247.97,178.81 247.97,187.83 247.9,187.89 247.9,188.66 247.08,189.48 239.33,189.48 238.82,189.99 238.82,200.53 239.33,201.04 271.21,201.04 273.37,198.88 283.91,198.88 286.45,196.34 286.45,188.34 285.56,187.45 259.52,187.45 254.32,182.24 254.32,174.88 253.3,173.86 253.3,168.91 253.75,168.46 253.75,137.09 252.4,135.75 252.4,113.27 252.16,113.03
GND on TOP: 425.5,206.1 424.79,205.81 424.5,205.1 424.5,204.8 424.79,204.09 425.5,203.8 428,203.8 429.41,203.21 430,201.8 429.7,201.8 429.45,201.55 429.45,201.04 428.82,200.4 422.47,200.4 421.83,201.04 421.83,208.15 422.21,208.53 429.32,208.53 429.76,208.1 430,208.1 429.41,206.69 428,206.1
GND on TOP: 230.06,190.75 229.93,190.62 227.14,190.62 227.01,190.75 227.01,192.02 227.14,192.15 229.93,192.15 230.06,192.02
GND on TOP: 366.97,83.94 366.97,86.1 367.09,86.23 374.33,86.23 374.84,85.72 374.84,83.56 374.46,83.18 370.4,83.18 370.27,83.06 370.27,82.67 370.01,82.42 368.49,82.42
GND on TOP: 253.17,93.34 251.78,93.34 251.52,93.09 251.52,91.69 251.78,91.44 253.17,91.44 253.43,91.69 253.43,93.09
GND on TOP: 52.13,172.59 52.13,169.03 51.88,168.78 46.16,168.78 46.04,168.91 46.04,172.72 46.16,172.84 51.88,172.84
GND on TOP: 236.28,106.12 235.98,105.81 234.43,105.81 234.12,106.12 234.12,111.91 234.43,112.21 236.06,112.21 236.28,111.99
GND on TOP: 9.33,81.55 9.33,82.93 9.59,83.18 13.02,83.18 13.27,82.93 13.27,80.15 13.18,80.06 9.23,80.06 9.18,80.1 9.18,81.4
GND on TOP: 165.93,194.18 164.66,194.18 164.53,194.05 164.53,192.15 164.66,192.02 165.93,192.02 166.05,192.15 166.05,194.05
GND on TOP: 215.96,101.98 215.96,100.45 215.84,100.33 214.19,100.33 214.06,100.45 214.06,101.98 214.25,102.17 215.77,102.17
GND on TOP: 160.21,157.73 160.34,157.6 160.34,155.95 160.21,155.83 153.18,155.83 152.85,156.15 152.85,157.26 153.33,157.73
GND on TOP: 237.05,147.95 237.05,149.6 237.17,149.73 238.7,149.73 238.82,149.6 238.82,147.95 238.7,147.83 237.17,147.83
GND on TOP: 83.5,201.04 83.5,196.59 82.99,196.09 76.9,196.09 76.64,196.34 76.64,201.67 76.9,201.93 82.61,201.93
GND on TOP: 183.2,90.93 183.2,88.77 183.07,88.64 181.87,88.64 181.62,88.39 180.91,88.39 180.66,88.64 180.66,90.05 181.66,91.06 183.07,91.06
GND on TOP: 214.69,192.53 225.11,192.53 225.23,192.4 225.23,191.64 224.85,191.26 214.57,191.26 214.57,192.4
GND on TOP: 93.79,84.33 93.66,84.2 89.98,84.2 89.85,84.33 89.85,86.48 90.11,86.74 93.66,86.74 93.79,86.61
GND on TOP: 334.2,91.06 335.6,91.06 335.85,90.8 335.85,89.28 335.6,89.02 334.2,89.02 333.95,89.28 333.95,90.8
GND on TOP: 60.9,142.24 61.79,142.24 62.93,141.09 64.96,141.09 65.47,140.59 65.47,133.47 64.96,132.97 64.83,132.97 64.58,132.71 64.58,132.59 63.82,132.59 63.31,133.09 63.31,136.9 60.64,139.57 60.26,139.57 60.01,139.82 60.01,141.35
GND on TOP: 131.25,89.02 131,89.28 131,91.18 131.13,91.31 133.54,91.31 133.67,91.18 133.67,89.15 133.54,89.02
GND on TOP: 385.38,93.6 387.03,93.6 387.16,93.47 387.16,90.68 387.03,90.55 385.38,90.55 385.25,90.68 385.25,93.47
GND on TOP: 175.96,193.8 177.36,193.8 177.48,193.67 177.48,192.15 177.36,192.02 175.96,192.02 175.83,192.15 175.83,193.67
GND on TOP: 291.53,85.6 293.05,85.6 293.18,85.47 293.18,83.44 293.05,83.31 291.53,83.31 291.4,83.44 291.4,85.47
GND on TOP: 255.33,84.33 255.21,84.2 251.52,84.2 251.4,84.33 251.4,86.23 251.65,86.48 255.08,86.48 255.33,86.23
GND on TOP: 320.87,89.02 320.61,89.28 320.61,91.31 320.87,91.56 322.9,91.56 323.15,91.31 323.15,89.28 322.9,89.02
GND on TOP: 0.68,28.32 0.51,28.49 0.51,168.75 0,168.75 0.59,170.16 2,170.75 4.5,170.75 5.21,171.04 5.5,171.75 5.5,172.25 5.21,172.96 4.5,173.25 2,173.25 0.59,173.84 0,175.25 0.51,175.25 0.51,223 0.94,224.05 2,224.49 381.95,224.49 381.95,224.41 381.44,223.9 9.84,223.9 8.7,222.76 3.75,222.76 2.1,221.1 2.1,215.26 10.35,207.01 10.35,203.07 5.14,197.86 5.14,187.7 7.68,185.16 7.68,168.4 1.21,161.92 1.21,99.95 4.13,97.03 4.13,89.41 2.86,88.14 2.86,34.51 3.17,34.2 9.56,34.2 9.92,34.56 9.92,46.72 10.32,47.11 383.22,47.11 384.24,46.1 384.24,29.17 383.39,28.32
GND on TOP: 234.76,147.95 234.76,149.6 234.89,149.73 236.41,149.73 236.54,149.6 236.54,147.95 236.41,147.83 234.89,147.83
GND on TOP: 383.35,159.26 382.59,160.02 382.59,160.4 382.71,160.53 385.13,160.53 385.51,160.91 385.51,165.1 385.13,165.48 385.13,165.73 385.25,165.86 385.76,165.86 386.27,166.37 386.27,170.43 385.25,171.45 385.25,173.99 383.53,175.72 383.53,180.13 380.71,182.95 380.56,182.79 380.56,174.75 380.43,174.62 380.43,171.32 379.79,170.69 379.29,170.69 379.03,170.94 379.03,171.32 379.94,172.23 379.94,177.14 379.29,177.8 379.03,177.8 378.27,178.56 377.38,178.56 377.13,178.31 377.13,174.75 376.87,174.5 375.73,174.5 374.97,173.73 372.94,173.73 371.16,171.96 371.16,168.4 370.9,168.15 366.2,168.15 365.95,168.4 365.95,194.18 366.46,194.69 385.38,194.69 385.64,194.43 385.64,177.04 387.67,175 387.67,172.21 388.18,171.7 390.84,171.7 391.6,170.94 391.6,160.65 390.21,159.26
GND on TOP: 188.79,91.06 190.18,91.06 190.44,90.8 190.44,89.28 190.18,89.02 188.79,89.02 188.53,89.28 188.53,90.8
GND on TOP: 237.05,123.7 243.65,123.7 243.78,123.57 243.78,121.16 243.52,120.9 236.92,120.9 236.79,121.03 236.79,123.44
GND on TOP: 185.99,181.48 184.47,181.48 184.34,181.35 184.34,180.85 184.47,180.72 184.47,179.58 184.59,179.45 185.99,179.45 186.63,178.81 187.01,178.81 187.13,178.94 187.13,180.34
GND on TOP: 209.87,192.28 209.99,192.4 211.65,192.4 211.65,190.75 211.39,190.5 209.99,190.5 209.87,190.62
GND on TOP: 164.91,95.76 164.66,95.5 162.12,95.5 161.99,95.63 161.99,97.75 161.1,98.64 161.1,99.82 161.23,99.95 164.78,99.95 164.91,99.82
GND on TOP: 157.42,86.23 157.67,86.48 161.1,86.48 161.35,86.23 161.35,83.51 161.32,83.47 157.5,83.47 157.42,83.56 157.42,84.32
GND on TOP: 316.42,201.17 316.67,201.42 316.67,202.56 316.93,202.82 320.36,202.82 322.01,204.47 322.01,210.94 320.99,211.96 317.7,211.96 317.51,211.77 317.51,207.93 317.14,207.55 311.97,207.55 311.59,207.18 311.59,205.99 310.71,205.1 308.53,205.1 308.29,205.34 308.29,210.06 311.72,213.48 323.41,213.48 323.91,212.98 323.91,203.58 321.63,201.29 321.63,195.58 321.12,195.07 305.12,195.07 305.11,195.07 304.46,195.07 304.11,195.41 304.11,196.58 304.11,199.27 308.67,203.83 312.86,203.83 313.75,202.94 313.75,201.8 314.39,201.17
GND on TOP: 240.67,88.83 240.22,88.39 239.84,88.39 239.2,89.02 238.57,89.02 236.16,91.44 236.16,93.09 236.54,93.47 237.3,93.47 240.67,90.1
GND on TOP: 209.49,190.37 209.36,190.24 207.58,190.24 207.45,190.37 207.45,192.28 207.58,192.4 209.36,192.4 209.49,192.28
GND on TOP: 142.48,213.53 145.62,213.53 146.76,214.67 150.52,214.67 150.79,214.41 150.79,212.53 150.33,212.07 149.28,212.07 148.55,211.34 147.54,211.34 147.54,211.55 147.4,211.69 145.95,211.69 145.75,211.49 145.75,211.21 145.64,211.1 144.81,211.1 144.72,211.01 144.72,210.16 144.62,210.06 142.52,210.06 142.3,210.29 142.3,213.35
GND on TOP: 81.47,89.02 81.22,89.28 81.22,91.31 81.47,91.56 83.5,91.56 83.76,91.31 83.76,89.28 83.5,89.02
GND on TOP: 232.73,89.02 230.7,89.02 230.44,89.28 230.44,91.18 230.6,91.34 232.89,91.34 232.98,91.25 232.98,89.28
GND on TOP: 144.59,91.06 145.99,91.06 146.24,90.8 146.24,89.28 145.99,89.02 144.59,89.02 144.34,89.28 144.34,90.8
GND on TOP: 118.05,89.02 117.79,89.28 117.79,91.44 118.17,91.82 120.21,91.82 120.33,91.69 120.33,89.28 120.08,89.02
GND on TOP: 252.92,209.42 259.27,209.42 259.4,209.55 259.4,217.17 259.14,217.42 257.24,217.42 256.98,217.68 256.98,218.56 257.24,218.82 261.68,218.82 261.94,218.56 261.94,204.85 258.51,201.42 238.95,201.42 238.57,201.8 238.57,207.01 238.82,207.26 241.11,207.26 241.36,207.52 243.14,207.52 245.05,205.61 251.02,205.61 251.78,206.37 251.78,208.28
GND on TOP: 256.22,89.02 255.97,89.28 255.97,95.37 257.49,96.9 257.49,168.15 257.62,168.27 259.14,168.27 260.03,167.38 267.14,167.38 268.67,165.86 268.67,114.93 270.83,112.77 341.19,112.77 364.55,136.14 364.55,140.59 364.97,141 364.97,155.6 366.08,156.72 372.81,156.72 372.81,156.71 374.54,156.71 375.68,155.58 379.85,155.58 380.42,156.14 380.42,157.16 380.61,157.35 380.98,157.35 381.14,157.19 381.95,157.19 381.95,157.19 382.26,157.19 382.42,157.34 383.04,157.34 383.35,157.03 383.35,155.22 381.09,152.96 373.95,152.96 373.06,152.08 373.06,135.38 358.33,120.65 358.33,104.65 346.39,92.71 278.96,92.71 278.19,93.47 275.65,93.47 275.53,93.34 275.53,91.69 275.27,91.44 271.84,91.44 271.72,91.31 271.72,89.28 271.46,89.02 269.43,89.02 269.18,89.28 269.18,91.06 268.54,91.69 264.86,91.69 263.97,90.8 263.97,89.28 263.72,89.02 261.05,89.02 260.79,89.28 258.89,89.28 258.64,89.02
GND on TOP: 161.99,89.28 162.08,89.19 165.46,89.19 165.67,89.41 165.67,93.14 165.54,93.27 162.09,93.27 161.99,93.17
GND on TOP: 187.77,78.48 187.64,78.36 183.96,78.36 183.83,78.48 183.83,80.39 184.09,80.64 187.52,80.64 187.77,80.39
GND on TOP: 28.32,92.64 28.58,92.9 32,92.9 32.26,92.64 32.26,88.58 32.07,88.39 28.51,88.39 28.32,88.58
GND on TOP: 61.02,183 61.66,183 62.93,181.73 64.58,181.73 64.83,181.48 64.83,175.51 64.07,174.75 64.07,174.24 64.71,173.61 64.71,172.97 64.58,172.84 64.33,172.84 63.06,174.11 63.06,177.92 60.9,180.08 60.39,180.08 60.13,180.34 60.13,182.12
GND on TOP: 63.18,114.04 56.2,114.04 55.94,113.79 55.94,108.33 56.32,107.95 63.18,107.95 63.31,108.07 63.31,113.92
GND on TOP: 355.41,83.31 355.28,83.44 355.28,86.1 355.41,86.23 356.68,86.23 357.7,85.21 358.84,85.21 358.97,85.09 358.97,83.69 358.58,83.31
GND on TOP: 175.2,89.15 175.2,92.07 175.45,92.33 177.1,92.33 177.29,92.14 177.29,89.72 176.59,89.02 175.32,89.02
GND on TOP: 331.41,78.36 329.37,78.36 329.25,78.48 329.25,80.39 329.5,80.64 333.18,80.64 333.31,80.52 333.31,79.37 333.18,79.25 332.3,79.25
GND on TOP: 29.14,97.03 28.45,97.03 28.32,97.15 28.32,99.06 28.58,99.31 32,99.31 32.26,99.06 32.26,96.76 31.52,96.02 30.08,96.02 29.4,96.7 29.4,96.76
GND on TOP: 384.37,88.14 382.97,88.14 382.71,88.39 382.71,89.91 382.97,90.17 384.37,90.17 384.62,89.91 384.62,88.39
GND on TOP: 182.31,99.82 183.96,99.82 184.09,99.69 184.09,98.17 183.96,98.04 182.31,98.04 182.18,98.17 182.18,99.69
GND on TOP: 94.81,91.06 96.84,91.06 97.22,90.68 97.22,90.04 96.2,89.02 94.81,89.02 94.55,89.28 94.55,90.8
GND on TOP: 351.22,167.51 354.27,167.51 359.47,162.3 359.47,160.91 360.24,160.14 360.24,155.7 357.82,153.29 351.47,153.29 351.35,153.41 351.35,153.79 351.85,154.3 353.5,154.3 354.14,154.94 356.81,154.94 358.58,156.72 358.58,160.02 357.82,160.78 357.82,162.56 356.81,163.57 354.52,163.57 354.27,163.32 353.89,163.32 353.76,163.45 353.76,163.7 351.09,166.37 351.09,167.38
GND on TOP: 309.18,84.58 309.05,84.45 305.37,84.45 305.24,84.58 305.24,86.48 305.37,86.61 309.05,86.61 309.18,86.48
GND on TOP: 138.75,89.02 137.35,89.02 137.1,89.28 137.1,90.8 137.35,91.06 138.75,91.06 139,90.8 139,89.28
GND on TOP: 170.62,193.8 172.02,193.8 172.15,193.67 172.15,192.15 172.02,192.02 170.62,192.02 170.5,192.15 170.5,193.67
GND on TOP: 276.92,89.02 275.27,89.02 275.02,89.28 275.02,90.93 275.15,91.06 276.92,91.06 277.18,90.8 277.18,89.28
GND on TOP: 206.31,89.02 204.53,89.02 204.41,89.15 204.41,90.93 204.53,91.06 206.31,91.06 206.57,90.8 206.57,89.28
GND on TOP: 160.21,101.72 158.31,101.72 158.18,101.85 158.18,113.03 158.43,113.28 160.21,113.28 161.03,112.47 161.03,102.54
GND on TOP: 182.31,102.11 183.96,102.11 184.09,101.98 184.09,100.45 183.96,100.33 182.31,100.33 182.18,100.45 182.18,101.98
GND on TOP, BOTTOM: 281.75,84.33 281.62,84.2 277.94,84.2 277.81,84.33 277.81,86.23 278.07,86.48 281.5,86.48 281.75,86.23
GND on TOP, BOTTOM: 224.35,78.48 224.22,78.36 220.54,78.36 220.41,78.48 220.41,80.39 220.66,80.64 224.09,80.64 224.35,80.39
GND on TOP, BOTTOM: 268.54,84.33 268.41,84.2 264.73,84.2 264.6,84.33 264.6,86.23 264.86,86.48 268.29,86.48 268.54,86.23
GND on TOP, BOTTOM: 174.56,78.48 174.43,78.36 170.75,78.36 170.62,78.48 170.62,80.39 170.88,80.64 174.31,80.64 174.56,80.39
GND on TOP, BOTTOM: 319.98,78.48 319.85,78.36 316.17,78.36 316.04,78.48 316.04,80.39 316.29,80.64 319.72,80.64 319.98,80.39
GND on TOP, BOTTOM: 333.18,84.33 333.06,84.2 329.37,84.2 329.25,84.33 329.25,86.23 329.5,86.48 332.93,86.48 333.18,86.23
GND on TOP, BOTTOM: 389.19,77.59 389.06,77.47 385.38,77.47 385.25,77.59 385.25,79.5 385.51,79.75 388.94,79.75 389.19,79.5
GND on TOP, BOTTOM: 130.37,84.33 130.24,84.2 129.48,84.2 129.1,83.82 127.57,83.82 127.19,84.2 126.56,84.2 126.43,84.33 126.43,86.23 126.68,86.48 130.11,86.48 130.37,86.23
GND on TOP, BOTTOM: 161.35,78.48 161.23,78.36 157.54,78.36 157.42,78.48 157.42,80.39 157.67,80.64 161.1,80.64 161.35,80.39
GND on TOP, BOTTOM: 80.58,84.33 80.45,84.2 79.82,84.2 79.31,83.69 77.91,83.69 77.41,84.2 76.77,84.2 76.64,84.33 76.64,86.23 76.9,86.48 80.33,86.48 80.58,86.23
GND on TOP, BOTTOM: 80.58,78.48 80.45,78.36 76.77,78.36 76.64,78.48 76.64,80.39 76.9,80.64 80.33,80.64 80.58,80.39
GND on TOP, BOTTOM: 352.74,78.48 352.62,78.36 348.93,78.36 348.81,78.48 348.81,80.13 348.93,80.26 352.62,80.26 352.74,80.13
GND on TOP, BOTTOM: 281.75,78.48 281.62,78.36 277.94,78.36 277.81,78.48 277.81,80.39 278.07,80.64 281.5,80.64 281.75,80.39
GND on TOP, BOTTOM: 49.59,78.48 49.47,78.36 45.78,78.36 45.66,78.48 45.66,80.39 45.91,80.64 49.34,80.64 49.59,80.39
GND on TOP, BOTTOM: 365.95,78.48 365.82,78.36 365.32,78.36 365.19,78.23 365.19,77.59 365.06,77.47 363.03,77.47 362.9,77.59 362.9,78.23 362.78,78.36 362.14,78.36 362.01,78.48 362.01,80.77 362.14,80.9 365.82,80.9 365.95,80.77
GND on TOP, BOTTOM: 319.98,84.33 319.85,84.2 316.17,84.2 316.04,84.33 316.04,86.23 316.29,86.48 319.72,86.48 319.98,86.23
GND on TOP, BOTTOM: 237.55,78.48 237.43,78.36 233.74,78.36 233.62,78.48 233.62,80.39 233.87,80.64 237.3,80.64 237.55,80.39
GND on TOP, BOTTOM: 211.14,84.33 211.01,84.2 207.33,84.2 207.2,84.33 207.2,86.23 207.45,86.48 210.88,86.48 211.14,86.23
GND on TOP, BOTTOM: 143.57,78.48 143.45,78.36 139.76,78.36 139.64,78.48 139.64,80.39 139.89,80.64 143.32,80.64 143.57,80.39
GND on TOP, BOTTOM: 224.35,84.33 224.22,84.2 220.54,84.2 220.41,84.33 220.41,86.23 220.66,86.48 224.09,86.48 224.35,86.23
GND on TOP, BOTTOM: 130.37,78.48 130.24,78.36 126.56,78.36 126.43,78.48 126.43,80.39 126.68,80.64 130.11,80.64 130.37,80.39
GND on TOP, BOTTOM: 255.33,78.48 255.21,78.36 251.52,78.36 251.4,78.48 251.4,80.39 251.65,80.64 255.08,80.64 255.33,80.39
GND on TOP, BOTTOM: 352.74,84.33 352.62,84.2 348.93,84.2 348.81,84.33 348.81,86.61 348.93,86.74 352.62,86.74 352.74,86.61
GND on TOP, BOTTOM: 67.37,84.33 67.25,84.2 63.56,84.2 63.44,84.33 63.44,86.23 63.69,86.48 67.12,86.48 67.37,86.23
GND on TOP, BOTTOM: 389.19,83.44 389.06,83.31 385.38,83.31 385.25,83.44 385.25,85.34 385.51,85.6 388.94,85.6 389.19,85.34
