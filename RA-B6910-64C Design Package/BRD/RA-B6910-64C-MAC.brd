# Allegro board RA-B6910-64C-MAC.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
Q3  MMBT3904LT1G  [SOT_23]  280.35 217.29 180 bottom
Q5  MMBT3904LT1G  [SOT_23]  39.05 151.25 90 top
Q6  MMBT3904LT1G  [SOT_23]  23.3 174.88 270 top
Q37  SM12  [SOT_23]  412.94 79.75 270 top
Q38  SM12  [SOT_23]  406.34 79.75 270 top
Q39  MMBT3904LT1G  [SOT_23]  35.37 180.72 270 bottom
Q40  MMBT3904LT1G  [SOT_23]  35.37 186.94 270 bottom
Q41  APL431LAAC_TRG  [SOT_23]  36.89 171.83 90 top
Q42  MMBT3904LT1G  [SOT_23]  389.32 190.62 270 top
Q43  MMBT3904LT1G  [SOT_23]  381.7 190.75 180 bottom
Q44  MMBT3904LT1G  [SOT_23]  375.73 190.62 90 bottom
Q45  MMBT3904LT1G  [SOT_23]  5.14 131.06 90 top
Q46  MMBT3904LT1G  [SOT_23]  32.83 142.75 90 top
Q47  MMBT3904LT1G  [SOT_23]  373.95 206.25 180 bottom
Q48  MMBT3904LT1G  [SOT_23]  32.83 138.05 90 top
Q49  MMBT3904LT1G  [SOT_23]  265.62 217.04 90 bottom
Q50  MMBT3904LT1G  [SOT_23]  367.86 206.25 180 bottom
Q51  MMBT3904LT1G  [SOT_23]  369.51 160.65 0 bottom
Q52  MMBT3904LT1G  [SOT_23]  367.98 127 270 bottom
Q53  MMBT3904LT1G  [SOT_23]  159.58 211.2 180 bottom
Q54  MMBT3904LT1G  [SOT_23]  371.92 127.12 90 bottom
Q55  MMBT3904LT1G  [SOT_23]  375.98 131.19 180 top
Q56  MMBT3904LT1G  [SOT_23]  369.51 156.59 180 bottom
Q57  MMBT3904LT1G  [SOT_23]  375.73 107.19 180 top
R1  4.7K  [R0402]  230.57 101.22 0 top
R2  X  [R0402]  260.74 181.35 270 top
R3  X  [R0402]  258.64 181.35 270 top
R4  X  [R0402]  255.59 181.35 270 top
R5  4.53k_1%  [R0402]  159.19 167.76 180 top
R6  X  [R0402]  259.27 170.3 90 top
R7  4.7K  [R0402]  258 169.92 270 top
R8  4.53k_1%  [R0402]  166.43 100.96 270 top
R9  4.7K  [R0402]  253.81 169.92 270 top
R10  4.53k_1%  [R0402]  230.57 97.08 0 top
R11  4.53k_1%  [R0402]  231.33 192.4 90 top
R12  X  [R0402]  259.72 181.35 270 top
R13  X  [R0402]  257.62 181.35 270 top
R14  X  [R0402]  256.6 181.35 270 top
R15  X  [R0402]  256.6 169.92 270 top
R16  X  [R0402]  255.21 169.92 270 top
R17  4.7K  [R0402]  177.23 95.88 180 top
R18  X  [R0402]  227.39 97.15 180 top
R19  X  [R0402]  227.39 100.2 180 top
R20  4.7K  [R0402]  227.39 98.17 180 top
R21  4.7K  [R0402]  227.39 99.18 180 top
R22  4.7K  [R0402]  230.57 98.17 0 top
R23  4.7K  [R0402]  230.57 99.18 0 top
R24  200  [R0402]  191.56 157.86 0 bottom
R26  X  [R0402]  70.8 219.33 0 bottom
R27  X  [R0402]  70.8 218.31 0 bottom
R28  X  [R0402]  15.94 170.18 90 top
R29  X  [R0402]  401 194.43 0 top
R30  X  [R0402]  394.4 101.6 180 bottom
R31  X  [R0402]  400.19 97.38 0 top
R32  X  [R0402]  394.4 102.61 180 bottom
R33  X  [R0402]  202.15 203.15 90 top
R34  X  [R0402]  203.39 205.48 90 top
R35  X  [R0402]  200.85 205.48 90 top
R163  10K_1%  [R0402]  411.34 125.7 0 top
R164  10K_1%  [R0402]  411.34 124.58 0 top
R165  10K_1%  [R0402]  411.34 123.47 0 top
R166  10K_1%  [R0402]  411.34 122.35 0 top
R167  10K_1%  [R0402]  411.34 121.23 0 top
R168  10K_1%  [R0402]  411.34 120.11 0 top
R169  10K_1%  [R0402]  411.34 119 0 top
R170  10K_1%  [R0402]  411.34 117.88 0 top
R171  10K_1%  [R0402]  423.1 117.88 180 top
R172  10K_1%  [R0402]  423.1 119 180 top
R173  10K_1%  [R0402]  423.1 120.11 180 top
R174  10K_1%  [R0402]  423.1 121.23 180 top
R175  10K_1%  [R0402]  423.1 122.35 180 top
R176  10K_1%  [R0402]  423.1 123.47 180 top
R177  10K_1%  [R0402]  423.1 124.58 180 top
R178  10K_1%  [R0402]  423.1 125.7 180 top
R179  10K_1%  [R0402]  45.33 95.88 0 top
R180  10K_1%  [R0402]  45.33 94.76 0 top
R181  10K_1%  [R0402]  57.21 94.64 180 top
R182  10K_1%  [R0402]  57.21 95.88 180 top
R183  4.7K  [R0402]  411.34 126.82 0 top
R185  10K_1%  [R0402]  45.33 102.59 0 top
R186  10K_1%  [R0402]  45.33 101.47 0 top
R187  10K_1%  [R0402]  45.33 100.35 0 top
R188  10K_1%  [R0402]  45.33 99.24 0 top
R189  10K_1%  [R0402]  45.33 98.12 0 top
R190  10K_1%  [R0402]  45.33 97 0 top
R191  10K_1%  [R0402]  57.21 97 180 top
R192  10K_1%  [R0402]  57.21 98.12 180 top
R193  10K_1%  [R0402]  57.21 99.24 180 top
R194  10K_1%  [R0402]  57.21 100.35 180 top
R195  10K_1%  [R0402]  57.21 101.47 180 top
R196  10K_1%  [R0402]  57.21 102.59 180 top
R201  33  [R0402]  423.1 127.94 180 top
R205  4.7K  [R0402]  45.33 103.71 0 top
R206  33  [R0402]  57.21 104.82 180 top
R216  4.7K  [R0402]  411.34 127.94 0 top
R222  4.7K  [R0402]  411.34 129.16 0 top
R224  4.7K  [R0402]  45.33 106.04 0 top
R230  4.7K  [R0402]  423.1 126.82 180 top
R238  4.7K  [R0402]  45.33 104.82 0 top
R241  4.7K  [R0402]  57.21 103.71 180 top
R246  10K_1%  [R0402]  10.66 97.51 0 top
R247  10K_1%  [R0402]  10.66 96.39 0 top
R248  10K_1%  [R0402]  10.66 95.27 0 top
R249  10K_1%  [R0402]  10.66 94.16 0 top
R250  10K_1%  [R0402]  10.66 93.04 0 top
R251  10K_1%  [R0402]  10.66 91.92 0 top
R252  4.7K  [R0402]  10.66 98.63 0 top
R254  33  [R0402]  22.54 99.74 180 top
R266  4.7K  [R0402]  10.66 100.96 0 top
R267  4.7K  [R0402]  10.66 99.74 0 top
R268  4.7K  [R0402]  22.54 98.63 180 top
R269  10K_1%  [R0402]  423.1 113.13 180 bottom
R270  10K_1%  [R0402]  423.1 112.01 180 bottom
R271  10K_1%  [R0402]  423.1 110.89 180 bottom
R272  10K_1%  [R0402]  423.1 109.78 180 bottom
R273  10K_1%  [R0402]  423.1 108.66 180 bottom
R274  10K_1%  [R0402]  423.1 107.54 180 bottom
R275  10K_1%  [R0402]  423.1 106.42 180 bottom
R276  10K_1%  [R0402]  423.1 105.31 180 bottom
R277  10K_1%  [R0402]  411.34 105.31 0 bottom
R278  10K_1%  [R0402]  411.34 106.42 0 bottom
R279  10K_1%  [R0402]  411.34 107.54 0 bottom
R280  10K_1%  [R0402]  411.34 108.66 0 bottom
R281  10K_1%  [R0402]  411.34 109.78 0 bottom
R282  10K_1%  [R0402]  411.34 110.89 0 bottom
R283  10K_1%  [R0402]  411.34 112.01 0 bottom
R284  10K_1%  [R0402]  411.34 113.13 0 bottom
R285  4.7K  [R0402]  423.1 114.25 180 bottom
R288  33  [R0402]  411.34 115.36 0 bottom
R295  4.7K  [R0402]  423.1 116.58 180 bottom
R297  4.7K  [R0402]  423.1 115.36 180 bottom
R305  X  [R0402]  270.52 170.33 90 top
R306  4.7K  [R0402]  411.34 114.25 0 bottom
R308  X  [R0402]  266.87 170.33 90 top
R310  X  [R0402]  265.65 170.33 90 top
R312  4.7K  [R0402]  264.43 170.33 270 top
R313  4.7K  [R0402]  268.08 170.33 270 top
R314  X  [R0603]  268.19 181.81 90 top
R316  4.7K  [R0402]  266.76 181.4 90 top
R317  4.7K  [R0402]  269.3 170.33 90 top
R320  10K_1%  [R0402]  22.54 97.51 180 bottom
R321  10K_1%  [R0402]  22.54 96.39 180 bottom
R322  10K_1%  [R0402]  22.54 95.27 180 bottom
R323  10K_1%  [R0402]  22.54 94.16 180 bottom
R324  10K_1%  [R0402]  22.54 93.04 180 bottom
R325  10K_1%  [R0402]  22.54 91.95 180 bottom
R326  10K_1%  [R0402]  22.54 90.8 180 bottom
R327  10K_1%  [R0402]  22.54 89.68 180 bottom
R328  10K_1%  [R0402]  10.66 89.68 0 bottom
R329  10K_1%  [R0402]  10.66 90.8 0 bottom
R330  10K_1%  [R0402]  10.66 91.92 0 bottom
R331  10K_1%  [R0402]  10.66 93.04 0 bottom
R332  10K_1%  [R0402]  10.66 94.16 0 bottom
R333  10K_1%  [R0402]  10.66 95.27 0 bottom
R334  10K_1%  [R0402]  10.66 96.39 0 bottom
R335  10K_1%  [R0402]  10.66 97.51 0 bottom
R336  10K_1%  [R0402]  57.21 102.59 180 bottom
R337  10K_1%  [R0402]  57.21 101.47 180 bottom
R338  10K_1%  [R0402]  57.21 100.35 180 bottom
R339  10K_1%  [R0402]  57.21 99.24 180 bottom
R340  10K_1%  [R0402]  57.21 98.12 180 bottom
R341  10K_1%  [R0402]  57.21 97 180 bottom
R342  10K_1%  [R0402]  57.21 95.88 180 bottom
R343  10K_1%  [R0402]  57.21 94.64 180 bottom
R344  10K_1%  [R0402]  45.33 94.76 0 bottom
R345  10K_1%  [R0402]  45.33 95.88 0 bottom
R346  10K_1%  [R0402]  45.33 97 0 bottom
R347  10K_1%  [R0402]  45.33 98.12 0 bottom
R348  10K_1%  [R0402]  45.33 99.24 0 bottom
R349  10K_1%  [R0402]  45.33 100.35 0 bottom
R350  10K_1%  [R0402]  45.33 101.47 0 bottom
R351  10K_1%  [R0402]  45.33 102.59 0 bottom
R352  4.7K  [R0402]  57.21 103.71 180 bottom
R353  4.7K  [R0402]  22.54 98.63 180 bottom
R359  33  [R0402]  45.33 104.82 0 bottom
R361  0  [R0402]  269.61 181.3 90 top
R367  33  [R0402]  10.66 99.74 0 bottom
R374  4.7K  [R0402]  57.21 106.04 180 bottom
R380  4.7K  [R0402]  10.66 98.63 0 bottom
R382  4.7K  [R0402]  45.33 103.71 0 bottom
R384  4.7K  [R0402]  22.54 100.96 180 bottom
R388  4.7K  [R0402]  22.54 99.74 180 bottom
R390  4.7K  [R0402]  57.21 104.82 180 bottom
R402  10K_1%  [R0402]  423.1 125.7 180 bottom
R403  10K_1%  [R0402]  423.1 124.58 180 bottom
R404  10K_1%  [R0402]  423.1 123.47 180 bottom
R405  10K_1%  [R0402]  423.1 122.35 180 bottom
R406  10K_1%  [R0402]  423.1 121.23 180 bottom
R407  10K_1%  [R0402]  423.1 120.11 180 bottom
R408  10K_1%  [R0402]  423.1 119 180 bottom
R409  10K_1%  [R0402]  423.1 117.88 180 bottom
R410  10K_1%  [R0402]  411.34 117.88 0 bottom
R411  10K_1%  [R0402]  411.34 119 0 bottom
R412  10K_1%  [R0402]  411.34 120.11 0 bottom
R413  10K_1%  [R0402]  411.34 121.23 0 bottom
R414  10K_1%  [R0402]  411.34 122.35 0 bottom
R415  10K_1%  [R0402]  411.34 123.47 0 bottom
R416  10K_1%  [R0402]  411.34 124.58 0 bottom
R417  10K_1%  [R0402]  411.34 125.7 0 bottom
R418  10K_1%  [R0402]  411.34 113.13 0 top
R419  10K_1%  [R0402]  411.34 112.01 0 top
R420  10K_1%  [R0402]  411.34 110.89 0 top
R421  10K_1%  [R0402]  411.34 108.66 0 top
R422  10K_1%  [R0402]  411.34 107.54 0 top
R423  10K_1%  [R0402]  411.34 106.42 0 top
R424  10K_1%  [R0402]  411.34 105.31 0 top
R425  10K_1%  [R0402]  423.1 105.31 180 top
R426  10K_1%  [R0402]  423.1 106.42 180 top
R427  10K_1%  [R0402]  423.1 112.01 180 top
R428  10K_1%  [R0402]  423.1 113.13 180 top
R429  4.7K  [R0402]  423.1 126.82 180 bottom
R432  33  [R0402]  407.91 126.79 0 bottom
R435  10K_1%  [R0402]  411.34 109.78 0 top
R436  10K_1%  [R0402]  423.1 107.54 180 top
R437  10K_1%  [R0402]  423.1 108.66 180 top
R438  10K_1%  [R0402]  423.1 109.78 180 top
R439  10K_1%  [R0402]  423.1 110.89 180 top
R440  4.7K  [R0402]  411.34 114.25 0 top
R446  33  [R0402]  423.1 115.36 180 top
R454  4.7K  [R0402]  423.1 127.94 180 bottom
R457  4.7K  [R0402]  411.34 126.82 0 bottom
R460  4.7K  [R0402]  425.64 129.16 180 bottom
R462  4.7K  [R0402]  411.34 116.71 180 top
R466  4.7K  [R0402]  411.34 115.36 0 top
R470  4.7K  [R0402]  423.1 114.25 180 top
R1191  6.04K_1%  [R0603]  266.94 213.66 180 top
R1193  10K_1%  [R0603]  266.94 212.01 180 top
R1956  10K_1%  [R0402]  10.66 90.8 0 top
R1957  10K_1%  [R0402]  10.66 89.68 0 top
R2022  4.7K  [R0402]  407.23 94.87 270 top
R2023  4.7K  [R0402]  408.5 94.87 270 top
R2024  X  [R0402]  419.54 83.18 270 top
R2025  X  [R0402]  413.19 97.28 0 top
R2026  4.7K  [R0402]  413.19 86.87 270 bottom
R2027  220  [R1206]  418.02 80.64 180 top
R2028  75_1%  [R0805]  409.64 79.88 270 top
R2029  150_1%  [R1206]  418.02 76.58 0 top
R2030  4.7K  [R0402]  412.18 86.87 270 bottom
R2031  220  [R1206]  412.18 95.25 180 top
R2032  220  [R1206]  401.26 76.58 180 top
R2033  4.7K  [R0402]  408.5 86.87 90 bottom
R2034  75_1%  [R0805]  413.45 31.11 180 bottom
R2035  75_1%  [R0805]  409 31.11 180 bottom
R2036  75_1%  [R0805]  404.56 31.11 180 bottom
R2037  75_1%  [R0805]  400.11 31.11 180 bottom
R2038  499_1%  [R0603]  395.8 33.53 270 top
R2039  499_1%  [R0603]  395.8 36.7 90 top
R2040  220  [R1206]  393.51 34.92 270 top
R2042  4.7K  [R0402]  166.43 98.17 270 top
R2043  4.7K  [R0402]  179.51 97.15 0 top
R2044  X  [R0402]  179.51 101.85 0 top
R2045  4.7K  [R0402]  179.51 100.71 180 top
R2046  0  [R0402]  179.51 99.44 0 top
R2047  4.7K  [R0402]  183.05 156.33 270 bottom
R2048  4.7K  [R0402]  189.05 158.33 90 bottom
R2049  4.7K  [R0402]  188.05 156.33 270 bottom
R2050  4.7K  [R0402]  181.05 156.33 270 bottom
R2051  4.7K  [R0402]  182.05 156.33 270 bottom
R2052  4.7K  [R0402]  180.05 158.33 90 bottom
R2053  4.7K  [R0402]  184.05 156.33 270 bottom
R2054  4.7K  [R0402]  186.05 156.33 90 bottom
R2055  4.7K  [R0402]  211.06 158.34 90 bottom
R2056  4.7K  [R0402]  183.05 158.33 90 bottom
R2057  4.7K  [R0402]  188.05 158.33 90 bottom
R2058  4.7K  [R0402]  213.07 156.33 270 bottom
R2059  4.7K  [R0402]  212.08 156.33 270 bottom
R2060  4.7K  [R0402]  208.04 158.34 90 bottom
R2061  4.7K  [R0402]  187.05 158.33 90 bottom
R2062  4.7K  [R0402]  187.05 156.33 270 bottom
R2063  4.7K  [R0402]  214.07 156.33 270 bottom
R2064  4.7K  [R0402]  211.06 156.33 270 bottom
R2065  4.7K  [R0402]  186.05 158.33 90 bottom
R2066  4.7K  [R0402]  182.05 158.33 270 bottom
R2067  4.7K  [R0402]  212.08 158.34 90 bottom
R2068  4.7K  [R0402]  210.07 156.33 270 bottom
R2069  4.7K  [R0402]  209.05 156.33 270 bottom
R2070  4.7K  [R0402]  208.04 156.33 270 bottom
R2071  4.7K  [R0402]  240.35 173.23 90 top
R2072  4.7K  [R0402]  207.05 156.33 270 bottom
R2073  4.7K  [R0402]  213.07 158.34 270 bottom
R2074  4.7K  [R0402]  238.82 173.23 90 top
R2075  4.7K  [R0402]  206.06 158.35 90 bottom
R2076  4.7K  [R0402]  207.05 158.34 90 bottom
R2097  10K_1%  [R0402]  22.54 89.68 180 top
R2098  10K_1%  [R0402]  22.54 90.8 180 top
R2099  10K_1%  [R0402]  22.54 91.92 180 top
R2100  10K_1%  [R0402]  22.54 93.04 180 top
R2101  10K_1%  [R0402]  22.54 94.16 180 top
R2102  10K_1%  [R0402]  22.54 95.27 180 top
R2103  10K_1%  [R0402]  22.54 96.39 180 top
R2104  10K_1%  [R0402]  22.54 97.51 180 top
R2194  100_1%  [R0402]  379.39 173.78 270 top
R2195  0  [R0402]  377.91 176.27 270 top
R2196  0  [R0402]  379.13 176.27 270 top
R2199  0  [R0402]  375.6 170.56 0 bottom
R2223  100_1%  [R0402]  382.46 159.08 270 top
R2224  0  [R0402]  137.73 111.89 270 top
R2225  100_1%  [R0402]  138.87 111.88 90 top
R2226  0  [R0402]  380.86 159.08 270 top
R2585  33  [R0402]  46.42 84.96 90 top
R2586  33  [R0402]  42.61 81.79 90 bottom
R2587  33  [R0402]  54.42 87.25 270 top
R2588  33  [R0402]  17.21 78.36 270 bottom
R2589  33  [R0402]  17.34 88.26 90 top
R2590  33  [R0402]  29.65 106.42 90 bottom
R2591  33  [R0402]  16.19 78.36 270 top
R2592  33  [R0402]  47.56 77.85 180 bottom
R2593  4.7K  [R0402]  55.44 87.25 270 top
R2594  4.7K  [R0402]  17.34 86.1 270 bottom
R2595  4.7K  [R0402]  42.61 81.79 270 top
R2596  4.7K  [R0402]  19.24 78.36 270 bottom
R2597  100_1%  [R0402]  40.32 78.36 90 top
R2598  100_1%  [R0402]  18.22 78.36 90 top
R2599  100_1%  [R0402]  40.58 81.79 90 top
R2600  100_1%  [R0402]  17.34 88.26 90 bottom
R2601  100_1%  [R0402]  45.28 84.96 270 top
R2602  100_1%  [R0402]  17.08 82.55 270 bottom
R2603  100_1%  [R0402]  41.59 81.79 270 top
R2604  100_1%  [R0402]  16.19 86.1 270 bottom
R2605  33  [R0402]  44.13 84.96 90 top
R2606  100_1%  [R0402]  57.47 88.01 270 top
R2607  33  [R0402]  16.19 82.55 270 top
R2608  33  [R0402]  56.45 84.83 270 top
R2609  33  [R0402]  16.19 78.36 270 bottom
R2610  33  [R0402]  42.61 78.36 270 top
R2611  33  [R0402]  17.21 78.36 90 top
R2612  33  [R0402]  41.47 78.36 90 top
R2613  33  [R0402]  18.22 78.36 90 bottom
R2614  4.7K  [R0402]  18.22 82.55 270 bottom
R2615  4.7K  [R0402]  56.45 88.01 270 top
R2616  4.7K  [R0402]  17.34 82.55 90 top
R2617  4.7K  [R0402]  55.44 84.83 90 top
R2618  100_1%  [R0402]  30.92 106.42 90 bottom
R2619  100_1%  [R0402]  54.42 84.83 90 top
R2620  100_1%  [R0402]  17.34 86.1 90 top
R2621  100_1%  [R0402]  32.07 106.42 270 bottom
R2622  100_1%  [R0402]  53.4 87.25 90 top
R2623  100_1%  [R0402]  16.19 86.1 270 top
R2624  100_1%  [R0402]  47.56 77.85 180 top
R2625  33  [R0402]  73.47 78.36 90 top
R2626  33  [R0402]  72.45 78.36 90 bottom
R2627  33  [R0402]  72.45 88.26 270 bottom
R2628  33  [R0402]  85.79 84.2 270 top
R2629  33  [R0402]  72.45 84.2 270 top
R2630  4.7K  [R0402]  84.77 84.2 90 bottom
R2631  4.7K  [R0402]  71.44 84.2 90 bottom
R2632  4.7K  [R0402]  70.42 78.36 270 bottom
R2633  100_1%  [R0402]  70.42 78.36 90 top
R2634  100_1%  [R0402]  70.42 84.2 270 top
R2635  100_1%  [R0402]  70.42 84.2 90 bottom
R2636  33  [R0402]  86.8 78.36 90 top
R2637  33  [R0402]  85.79 78.36 90 bottom
R2638  33  [R0402]  90.87 77.85 180 top
R2639  4.7K  [R0402]  83.76 78.36 270 bottom
R2640  100_1%  [R0402]  83.76 78.36 90 top
R2641  100_1%  [R0402]  83.76 84.2 270 top
R2642  100_1%  [R0402]  83.76 84.2 90 bottom
R2643  100_1%  [R0402]  90.87 77.85 180 bottom
R2644  100_1%  [R0402]  71.44 88.26 270 top
R2645  33  [R0402]  71.44 88.26 270 bottom
R2646  33  [R0402]  93.03 77.85 0 top
R2647  33  [R0402]  71.44 84.2 270 top
R2648  33  [R0402]  84.77 84.2 270 top
R2649  33  [R0402]  71.44 78.36 90 top
R2650  33  [R0402]  84.77 78.36 90 top
R2651  33  [R0402]  71.44 78.36 90 bottom
R2652  33  [R0402]  84.77 78.36 90 bottom
R2653  4.7K  [R0402]  72.45 78.36 270 top
R2654  4.7K  [R0402]  85.79 78.36 270 top
R2655  4.7K  [R0402]  72.45 84.2 90 bottom
R2656  4.7K  [R0402]  95.31 79.5 90 bottom
R2657  100_1%  [R0402]  73.47 84.2 90 bottom
R2658  100_1%  [R0402]  93.28 79.5 90 bottom
R2659  100_1%  [R0402]  73.47 78.36 90 bottom
R2660  100_1%  [R0402]  86.8 78.36 90 bottom
R2661  100_1%  [R0402]  72.45 88.26 270 top
R2662  100_1%  [R0402]  94.3 79.5 270 bottom
R2663  100_1%  [R0402]  104.71 83.69 180 bottom
R2664  100_1%  [R0402]  73.47 84.2 270 top
R2665  33  [R0402]  123.25 78.36 90 top
R2666  33  [R0402]  122.24 78.36 90 bottom
R2667  33  [R0402]  122.24 84.2 270 top
R2668  100_1%  [R0402]  122.24 78.36 270 top
R2669  33  [R0402]  136.59 78.36 90 top
R2670  33  [R0402]  135.57 78.36 90 top
R2671  33  [R0402]  135.57 88.26 270 bottom
R2672  33  [R0402]  122.24 87.37 270 bottom
R2673  33  [R0402]  135.57 84.2 270 top
R2674  4.7K  [R0402]  135.57 84.2 90 bottom
R2675  4.7K  [R0402]  121.22 84.2 90 bottom
R2676  4.7K  [R0402]  134.56 78.36 270 bottom
R2677  4.7K  [R0402]  120.21 78.36 270 bottom
R2678  100_1%  [R0402]  133.54 78.36 90 top
R2679  100_1%  [R0402]  120.21 84.2 90 top
R2680  100_1%  [R0402]  133.54 84.2 90 bottom
R2681  100_1%  [R0402]  120.21 84.2 90 bottom
R2682  100_1%  [R0402]  133.54 84.2 270 top
R2683  100_1%  [R0402]  121.22 87.37 270 top
R2684  100_1%  [R0402]  134.56 88.26 270 top
R2685  33  [R0402]  134.56 88.26 270 bottom
R2686  33  [R0402]  121.22 87.37 270 bottom
R2687  33  [R0402]  134.56 84.2 270 top
R2688  33  [R0402]  121.22 78.36 90 bottom
R2689  33  [R0402]  121.22 78.36 90 top
R2690  33  [R0402]  133.54 78.36 90 bottom
R2691  4.7K  [R0402]  135.57 78.36 270 bottom
R2692  4.7K  [R0402]  134.56 84.2 90 bottom
R2693  33  [R0402]  121.22 84.2 270 top
R2694  33  [R0402]  134.56 78.36 90 top
R2695  4.7K  [R0402]  120.08 78.36 270 top
R2696  4.7K  [R0402]  122.24 84.2 90 bottom
R2697  100_1%  [R0402]  123.25 84.2 90 bottom
R2698  100_1%  [R0402]  136.59 84.2 90 bottom
R2699  100_1%  [R0402]  123.25 78.36 90 bottom
R2700  100_1%  [R0402]  136.59 78.36 90 bottom
R2701  100_1%  [R0402]  122.24 87.37 270 top
R2702  100_1%  [R0402]  135.57 88.26 270 top
R2703  100_1%  [R0402]  136.59 84.2 270 top
R2704  100_1%  [R0402]  123.25 84.2 270 top
R2705  33  [R0402]  167.45 78.36 90 top
R2706  33  [R0402]  179.77 78.36 90 bottom
R2707  33  [R0402]  167.45 78.36 90 bottom
R2708  33  [R0402]  179.77 88.26 270 bottom
R2709  33  [R0402]  166.43 88.26 270 bottom
R2710  33  [R0402]  179.77 84.2 270 top
R2711  33  [R0402]  166.43 84.2 270 top
R2712  4.7K  [R0402]  178.75 84.2 90 bottom
R2713  4.7K  [R0402]  165.42 84.2 90 bottom
R2714  4.7K  [R0402]  165.42 78.36 270 top
R2715  100_1%  [R0402]  164.4 78.36 90 top
R2716  100_1%  [R0402]  164.4 84.2 270 top
R2717  100_1%  [R0402]  164.4 84.2 90 bottom
R2718  33  [R0402]  180.78 78.36 90 top
R2719  4.7K  [R0402]  177.74 78.36 270 bottom
R2720  100_1%  [R0402]  177.74 78.36 90 top
R2721  100_1%  [R0402]  177.74 84.2 90 bottom
R2722  100_1%  [R0402]  178.75 88.26 270 top
R2723  100_1%  [R0402]  177.74 84.2 270 top
R2724  100_1%  [R0402]  165.42 88.26 270 top
R2725  33  [R0402]  178.75 84.2 270 top
R2726  33  [R0402]  165.42 88.26 270 bottom
R2727  33  [R0402]  178.75 88.26 270 bottom
R2728  33  [R0402]  165.42 84.2 270 top
R2729  33  [R0402]  165.42 78.36 90 bottom
R2730  33  [R0402]  178.75 78.36 90 top
R2731  33  [R0402]  164.4 78.36 90 bottom
R2732  33  [R0402]  178.75 78.36 90 bottom
R2733  4.7K  [R0402]  166.43 78.36 270 top
R2734  4.7K  [R0402]  179.77 78.36 270 top
R2735  4.7K  [R0402]  166.43 84.2 90 bottom
R2736  4.7K  [R0402]  179.77 84.2 90 bottom
R2737  100_1%  [R0402]  167.58 84.2 90 bottom
R2738  100_1%  [R0402]  180.78 84.2 90 bottom
R2739  100_1%  [R0402]  166.43 78.36 270 bottom
R2740  100_1%  [R0402]  180.78 78.36 90 bottom
R2741  100_1%  [R0402]  166.43 88.26 270 top
R2742  100_1%  [R0402]  180.78 84.2 270 top
R2743  100_1%  [R0402]  179.77 88.26 270 top
R2744  100_1%  [R0402]  167.58 84.2 270 top
R2745  33  [R0402]  217.23 78.36 90 top
R2746  33  [R0402]  216.22 78.36 90 bottom
R2747  33  [R0402]  229.55 84.2 270 top
R2748  33  [R0402]  216.22 84.2 270 top
R2749  4.7K  [R0402]  215.2 84.2 90 bottom
R2750  4.7K  [R0402]  215.2 78.36 270 top
R2751  100_1%  [R0402]  214.19 84.2 90 top
R2752  100_1%  [R0402]  214.19 78.36 270 top
R2753  33  [R0402]  230.57 78.36 90 top
R2754  33  [R0402]  229.55 78.36 90 bottom
R2755  33  [R0402]  229.55 88.26 270 bottom
R2756  33  [R0402]  216.22 88.26 270 bottom
R2757  4.7K  [R0402]  228.54 84.2 90 bottom
R2758  4.7K  [R0402]  227.52 78.36 270 bottom
R2759  100_1%  [R0402]  227.52 78.36 90 top
R2760  100_1%  [R0402]  227.52 84.2 90 bottom
R2761  100_1%  [R0402]  214.19 84.2 90 bottom
R2762  100_1%  [R0402]  227.52 84.2 270 top
R2763  100_1%  [R0402]  215.2 88.26 270 top
R2764  100_1%  [R0402]  228.54 88.26 270 top
R2765  33  [R0402]  215.2 88.26 270 bottom
R2766  33  [R0402]  228.54 88.26 270 bottom
R2767  33  [R0402]  215.2 84.2 270 top
R2768  33  [R0402]  228.54 84.2 270 top
R2769  33  [R0402]  214.19 78.36 90 bottom
R2770  33  [R0402]  228.54 78.36 90 top
R2771  33  [R0402]  215.2 78.36 90 bottom
R2772  33  [R0402]  228.54 78.36 90 bottom
R2773  4.7K  [R0402]  229.55 78.36 270 top
R2774  4.7K  [R0402]  229.55 84.2 90 bottom
R2775  100_1%  [R0402]  230.57 84.2 90 top
R2776  100_1%  [R0402]  230.57 78.36 90 bottom
R2777  4.7K  [R0402]  216.22 78.36 270 top
R2778  4.7K  [R0402]  216.22 84.2 90 bottom
R2779  33  [R0402]  217.23 84.2 90 top
R2780  100_1%  [R0402]  217.23 78.36 90 bottom
R2781  100_1%  [R0402]  229.55 88.26 270 top
R2782  33  [R0402]  216.22 88.26 270 top
R2783  100_1%  [R0402]  230.57 84.2 270 bottom
R2784  100_1%  [R0402]  217.23 84.2 270 bottom
R2785  33  [R0402]  274.76 78.36 90 top
R2786  33  [R0402]  261.43 78.36 90 top
R2787  33  [R0402]  273.75 78.36 90 bottom
R2788  33  [R0402]  260.41 78.36 90 bottom
R2789  33  [R0402]  273.75 88.26 270 bottom
R2790  33  [R0402]  260.41 88.26 270 bottom
R2791  33  [R0402]  274.76 84.2 270 top
R2792  33  [R0402]  260.41 84.2 270 top
R2793  4.7K  [R0402]  272.73 84.2 90 bottom
R2794  4.7K  [R0402]  259.4 84.2 90 bottom
R2795  4.7K  [R0402]  271.59 78.36 270 bottom
R2796  4.7K  [R0402]  258.38 78.36 270 bottom
R2797  100_1%  [R0402]  271.59 78.36 90 top
R2798  100_1%  [R0402]  258.38 78.36 90 top
R2799  100_1%  [R0402]  271.72 84.2 90 bottom
R2800  100_1%  [R0402]  258.38 84.2 270 top
R2801  100_1%  [R0402]  272.73 88.26 270 top
R2802  100_1%  [R0402]  258.38 84.2 90 bottom
R2803  100_1%  [R0402]  272.73 84.2 270 top
R2804  100_1%  [R0402]  259.4 88.26 270 top
R2805  33  [R0402]  259.4 84.2 270 top
R2806  33  [R0402]  271.72 84.2 270 top
R2807  33  [R0402]  259.4 78.36 90 bottom
R2808  33  [R0402]  272.73 78.36 90 bottom
R2809  33  [R0402]  259.4 88.26 270 bottom
R2810  33  [R0402]  272.73 88.26 270 bottom
R2811  33  [R0402]  259.4 78.36 90 top
R2812  33  [R0402]  272.73 78.36 90 top
R2813  4.7K  [R0402]  260.41 78.36 270 top
R2814  4.7K  [R0402]  273.75 78.36 270 top
R2815  4.7K  [R0402]  260.41 88.26 90 top
R2816  4.7K  [R0402]  274.76 84.2 90 bottom
R2817  100_1%  [R0402]  260.41 84.2 90 bottom
R2818  100_1%  [R0402]  273.75 84.2 90 bottom
R2819  100_1%  [R0402]  261.43 78.36 90 bottom
R2820  100_1%  [R0402]  273.75 88.26 270 top
R2821  100_1%  [R0402]  261.56 84.2 270 top
R2822  100_1%  [R0402]  274.76 78.36 90 bottom
R2823  100_1%  [R0402]  261.56 84.2 270 bottom
R2824  100_1%  [R0402]  273.75 84.2 270 top
R2825  33  [R0402]  312.48 78.36 90 top
R2826  33  [R0402]  310.2 81.79 90 top
R2827  33  [R0402]  325.18 84.2 270 top
R2828  33  [R0402]  312.36 81.79 270 top
R2829  4.7K  [R0402]  324.17 84.2 90 bottom
R2830  4.7K  [R0402]  312.36 85.47 270 top
R2831  4.7K  [R0402]  307.91 78.36 90 top
R2832  100_1%  [R0402]  307.91 81.79 90 top
R2833  100_1%  [R0402]  301.69 77.85 0 top
R2834  100_1%  [R0402]  301.05 83.69 0 bottom
R2835  33  [R0402]  326.2 78.36 90 top
R2836  33  [R0402]  325.18 78.36 90 bottom
R2837  33  [R0402]  325.18 88.26 270 bottom
R2838  33  [R0402]  309.05 78.36 270 bottom
R2839  4.7K  [R0402]  322.9 78.36 270 bottom
R2840  100_1%  [R0402]  322.9 78.36 90 top
R2841  100_1%  [R0402]  323.15 84.2 270 top
R2842  100_1%  [R0402]  323.15 84.2 90 bottom
R2843  100_1%  [R0402]  324.17 88.26 270 top
R2844  100_1%  [R0402]  306.01 77.85 0 bottom
R2845  33  [R0402]  307.91 78.36 270 bottom
R2846  33  [R0402]  324.17 88.26 270 bottom
R2847  33  [R0402]  311.34 78.36 270 top
R2848  33  [R0402]  324.17 84.2 270 top
R2849  33  [R0402]  309.05 81.79 90 top
R2850  33  [R0402]  324.17 78.36 90 bottom
R2851  33  [R0402]  306.01 77.85 180 top
R2852  33  [R0402]  324.17 78.36 90 top
R2853  4.7K  [R0402]  311.34 81.79 270 top
R2854  4.7K  [R0402]  325.18 78.36 270 top
R2855  4.7K  [R0402]  309.05 78.36 90 top
R2856  4.7K  [R0402]  325.18 84.2 90 bottom
R2857  100_1%  [R0402]  310.2 78.36 90 top
R2858  100_1%  [R0402]  326.2 88.26 90 bottom
R2859  100_1%  [R0402]  311.34 78.36 90 bottom
R2860  100_1%  [R0402]  326.2 78.36 90 bottom
R2861  100_1%  [R0402]  310.2 78.36 270 bottom
R2862  100_1%  [R0402]  326.2 84.2 270 top
R2863  100_1%  [R0402]  325.18 88.26 270 top
R2864  100_1%  [R0402]  312.48 78.36 270 bottom
R2865  33  [R0402]  356.81 81.79 90 bottom
R2866  33  [R0402]  357.82 81.79 90 bottom
R2867  33  [R0402]  355.79 78.36 270 top
R2868  100_1%  [R0402]  355.79 78.36 270 bottom
R2869  33  [R0402]  377.63 78.36 90 top
R2870  33  [R0402]  376.62 78.36 90 bottom
R2871  33  [R0402]  370.14 78.36 270 top
R2872  33  [R0402]  350.08 77.85 180 bottom
R2873  33  [R0402]  373.57 78.36 270 bottom
R2874  4.7K  [R0402]  369 78.36 90 bottom
R2875  4.7K  [R0402]  358.84 81.79 270 top
R2876  4.7K  [R0402]  374.59 78.36 270 bottom
R2877  4.7K  [R0402]  358.84 81.79 90 bottom
R2878  100_1%  [R0402]  372.3 78.36 90 top
R2879  100_1%  [R0402]  343.6 78.36 90 bottom
R2880  100_1%  [R0402]  375.6 78.36 90 top
R2881  100_1%  [R0402]  345.63 78.36 90 top
R2882  100_1%  [R0402]  371.28 78.36 270 top
R2883  100_1%  [R0402]  356.81 81.79 270 top
R2884  100_1%  [R0402]  371.28 78.36 270 bottom
R2885  33  [R0402]  373.57 78.36 270 top
R2886  33  [R0402]  356.81 78.36 270 top
R2887  33  [R0402]  370.14 78.36 270 bottom
R2888  33  [R0402]  344.61 78.36 90 bottom
R2889  33  [R0402]  345.63 78.36 90 bottom
R2890  33  [R0402]  374.59 78.36 90 top
R2891  4.7K  [R0402]  369 78.36 270 top
R2892  33  [R0402]  350.08 77.85 180 top
R2893  33  [R0402]  372.3 78.36 90 bottom
R2894  4.7K  [R0402]  358.84 78.36 270 bottom
R2895  4.7K  [R0402]  358.84 78.36 90 top
R2896  4.7K  [R0402]  375.6 78.36 90 bottom
R2897  100_1%  [R0402]  355.79 81.79 90 bottom
R2898  100_1%  [R0402]  378.65 78.36 90 bottom
R2899  100_1%  [R0402]  357.82 81.79 90 top
R2900  100_1%  [R0402]  379.67 78.36 270 top
R2901  100_1%  [R0402]  356.81 78.36 270 bottom
R2902  100_1%  [R0402]  376.62 78.36 90 top
R2903  100_1%  [R0402]  355.79 81.79 270 top
R2904  100_1%  [R0402]  378.65 78.36 270 top
R2963  499_1%  [R0603]  55.94 81.15 90 bottom
R2964  499_1%  [R0603]  149.92 81.15 90 bottom
R2965  499_1%  [R0603]  243.9 81.15 90 bottom
R2966  499_1%  [R0603]  339.28 81.15 90 bottom
R2967  1.5K_1%  [R0402]  6.29 51.81 0 top
R2968  1.5K_1%  [R0402]  6.21 42.67 0 bottom
R2969  1.5K_1%  [R0402]  389.57 43.81 180 bottom
R2970  1.5K_1%  [R0402]  389.57 52.96 180 bottom
R2971  499_1%  [R0603]  54.55 81.15 90 bottom
R2972  499_1%  [R0603]  148.53 87.63 90 top
R2973  499_1%  [R0603]  242.51 81.15 90 top
R2974  499_1%  [R0603]  336.49 81.15 90 top
R2975  1.5K_1%  [R0402]  6.29 50.67 0 top
R2976  1.5K_1%  [R0402]  6.29 41.53 0 top
R2977  1.5K_1%  [R0402]  389.57 43.81 180 top
R2978  1.5K_1%  [R0402]  389.57 52.96 180 top
R2979  499_1%  [R0603]  53.15 81.15 90 top
R2980  499_1%  [R0603]  148.53 81.15 90 bottom
R2981  499_1%  [R0603]  241.11 81.15 90 bottom
R2982  499_1%  [R0603]  336.49 81.15 90 bottom
R2983  1.5K_1%  [R0402]  6.29 49.53 0 top
R2984  1.5K_1%  [R0402]  6.29 40.38 0 top
R2985  1.5K_1%  [R0402]  389.57 46.1 180 top
R2986  1.5K_1%  [R0402]  389.57 55.24 180 top
R2987  499_1%  [R0603]  147.13 81.15 90 top
R2988  499_1%  [R0603]  54.55 81.15 90 top
R2989  499_1%  [R0603]  241.11 84.83 90 top
R2990  499_1%  [R0603]  337.88 81.15 90 top
R2991  1.5K_1%  [R0402]  6.21 48.38 0 bottom
R2992  1.5K_1%  [R0402]  6.21 39.24 0 bottom
R2993  1.5K_1%  [R0402]  389.57 46.1 180 bottom
R2994  1.5K_1%  [R0402]  389.57 55.24 180 bottom
R2995  499_1%  [R0603]  154.11 81.15 90 top
R2996  499_1%  [R0603]  58.74 88.01 90 top
R2997  499_1%  [R0603]  248.09 81.15 90 bottom
R2998  499_1%  [R0603]  343.73 81.15 90 bottom
R2999  1.5K_1%  [R0402]  6.21 47.24 0 bottom
R3000  1.5K_1%  [R0402]  6.21 38.1 0 bottom
R3001  1.5K_1%  [R0402]  389.57 48.38 180 top
R3002  1.5K_1%  [R0402]  389.57 57.53 180 top
R3003  499_1%  [R0603]  154.11 87.63 90 top
R3004  499_1%  [R0603]  58.74 81.15 90 top
R3005  499_1%  [R0603]  248.09 88.52 90 top
R3006  499_1%  [R0603]  342.07 85.21 90 top
R3007  1.5K_1%  [R0402]  6.29 46.1 0 top
R3008  1.5K_1%  [R0402]  6.29 36.95 0 top
R3009  1.5K_1%  [R0402]  389.57 48.38 180 bottom
R3010  1.5K_1%  [R0402]  389.57 57.53 180 bottom
R3011  499_1%  [R0603]  60.13 81.15 90 top
R3012  499_1%  [R0603]  152.72 87.63 90 top
R3013  499_1%  [R0603]  243.9 81.15 90 top
R3014  499_1%  [R0603]  340.68 81.15 90 bottom
R3015  1.5K_1%  [R0402]  6.29 44.96 0 top
R3016  1.5K_1%  [R0402]  6.29 35.81 0 top
R3017  1.5K_1%  [R0402]  389.57 50.67 180 bottom
R3018  1.5K_1%  [R0402]  389.57 58.67 180 bottom
R3019  499_1%  [R0603]  60.13 88.01 90 top
R3020  499_1%  [R0603]  151.32 81.15 90 top
R3021  499_1%  [R0603]  245.3 81.15 90 top
R3022  499_1%  [R0603]  342.2 81.15 90 bottom
R3023  1.5K_1%  [R0402]  6.21 43.81 0 bottom
R3024  1.5K_1%  [R0402]  6.21 34.67 0 bottom
R3025  1.5K_1%  [R0402]  389.57 50.67 180 top
R3026  1.5K_1%  [R0402]  389.57 59.81 180 top
R3027  499_1%  [R0603]  55.94 81.15 90 top
R3028  499_1%  [R0603]  149.92 81.15 90 top
R3029  499_1%  [R0603]  246.7 88.52 90 top
R3030  499_1%  [R0603]  339.28 85.21 90 top
R3031  1.5K_1%  [R0402]  6.21 51.81 0 bottom
R3032  1.5K_1%  [R0402]  6.29 42.67 0 top
R3033  1.5K_1%  [R0402]  389.57 42.67 180 bottom
R3034  1.5K_1%  [R0402]  389.57 51.81 180 bottom
R3035  499_1%  [R0603]  149.92 87.63 90 top
R3036  499_1%  [R0603]  58.74 88.01 90 bottom
R3037  499_1%  [R0603]  245.3 88.52 90 top
R3038  499_1%  [R0603]  336.49 85.21 90 top
R3039  1.5K_1%  [R0402]  6.21 50.67 0 bottom
R3040  1.5K_1%  [R0402]  6.21 41.53 0 bottom
R3041  1.5K_1%  [R0402]  389.57 42.67 180 top
R3042  1.5K_1%  [R0402]  389.57 51.81 180 top
R3043  499_1%  [R0603]  60.13 88.01 90 bottom
R3044  499_1%  [R0603]  148.53 81.15 90 top
R3045  499_1%  [R0603]  242.51 81.15 90 bottom
R3046  499_1%  [R0603]  337.88 81.15 90 bottom
R3047  1.5K_1%  [R0402]  6.21 49.53 0 bottom
R3048  1.5K_1%  [R0402]  6.21 40.38 0 bottom
R3049  1.5K_1%  [R0402]  389.57 44.96 180 top
R3050  1.5K_1%  [R0402]  389.57 54.1 180 top
R3051  499_1%  [R0603]  147.13 81.15 90 bottom
R3052  499_1%  [R0603]  53.15 81.15 90 bottom
R3053  499_1%  [R0603]  241.11 81.15 90 top
R3054  499_1%  [R0603]  339.28 81.15 90 top
R3055  1.5K_1%  [R0402]  6.29 48.38 0 top
R3056  1.5K_1%  [R0402]  6.29 39.24 0 top
R3057  1.5K_1%  [R0402]  389.57 44.96 180 bottom
R3058  1.5K_1%  [R0402]  389.57 54.1 180 bottom
R3059  499_1%  [R0603]  60.13 81.15 90 bottom
R3060  499_1%  [R0603]  248.09 81.15 90 top
R3061  499_1%  [R0603]  154.11 81.15 90 bottom
R3062  499_1%  [R0603]  342.07 85.21 90 bottom
R3063  1.5K_1%  [R0402]  6.29 47.24 0 top
R3064  1.5K_1%  [R0402]  6.29 38.1 0 top
R3065  1.5K_1%  [R0402]  389.57 47.24 180 top
R3066  1.5K_1%  [R0402]  389.57 56.39 180 top
R3067  499_1%  [R0603]  152.72 81.15 90 top
R3068  499_1%  [R0603]  57.34 81.15 90 top
R3069  499_1%  [R0603]  246.7 81.15 90 bottom
R3070  499_1%  [R0603]  343.98 81.15 90 top
R3071  1.5K_1%  [R0402]  6.21 46.1 0 bottom
R3072  1.5K_1%  [R0402]  6.21 36.95 0 bottom
R3073  1.5K_1%  [R0402]  389.57 47.24 180 bottom
R3074  1.5K_1%  [R0402]  389.57 56.39 180 bottom
R3075  499_1%  [R0603]  58.74 81.15 90 bottom
R3076  499_1%  [R0603]  152.72 81.15 90 bottom
R3077  499_1%  [R0603]  246.7 81.15 90 top
R3078  499_1%  [R0603]  342.58 81.15 90 top
R3079  1.5K_1%  [R0402]  6.21 44.96 0 bottom
R3080  1.5K_1%  [R0402]  6.21 35.81 0 bottom
R3081  1.5K_1%  [R0402]  389.57 49.53 180 bottom
R3082  1.5K_1%  [R0402]  389.57 59.81 180 bottom
R3083  499_1%  [R0603]  57.34 81.15 90 bottom
R3084  499_1%  [R0603]  151.32 81.15 90 bottom
R3085  499_1%  [R0603]  245.3 81.15 90 bottom
R3086  499_1%  [R0603]  340.68 81.15 90 top
R3087  1.5K_1%  [R0402]  6.29 43.81 0 top
R3088  1.5K_1%  [R0402]  6.29 34.67 0 top
R3089  1.5K_1%  [R0402]  389.57 49.53 180 top
R3090  1.5K_1%  [R0402]  389.57 58.67 180 top
R3111  X  [R0402]  183.83 139.57 180 bottom
R3112  X  [R0402]  181.67 139.57 180 bottom
R3131  100_1%  [R0402]  377.79 173.78 270 top
R3132  4.7K  [R0402]  197.17 120.65 0 bottom
R3133  4.7K  [R0402]  179.51 95.76 0 top
R3134  X  [R0402]  306.21 207.87 180 bottom
R3135  4.7K  [R0402]  306.21 215.49 180 bottom
R3136  33  [R0402]  306.21 212.95 180 bottom
R3137  4.7K  [R0402]  306.21 209.14 180 bottom
R3138  0  [R0402]  303.54 197.46 270 bottom
R3139  X  [R0402]  306.21 210.41 0 bottom
R3140  1K  [R0402]  309 205.33 0 bottom
R3141  4.7K  [R0402]  303.29 215.11 270 bottom
R3142  0  [R0402]  302.27 197.46 270 bottom
R3143  499_1%  [R0603]  298.39 215.14 180 top
R3144  0  [R0402]  300.24 197.46 270 bottom
R3145  0  [R0402]  298.97 197.46 270 bottom
R3146  0  [R0402]  295.67 197.46 270 bottom
R3147  0  [R0402]  296.94 197.46 270 bottom
R3148  4.7K  [R0402]  299.73 215.11 270 bottom
R3149  4.7K  [R0402]  298.59 215.11 270 bottom
R3150  X  [R0402]  306.21 211.68 180 bottom
R3151  X  [R0402]  306.21 214.22 180 bottom
R3152  4.7K  [R0402]  300.88 215.11 270 bottom
R3153  0  [R0402]  293.89 197.46 270 bottom
R3154  0  [R0402]  292.62 197.46 270 bottom
R3155  0  [R0402]  287.54 203.05 180 bottom
R3156  0  [R0402]  287.54 204.57 180 bottom
R3157  0  [R0402]  287.54 205.71 180 bottom
R3158  0  [R0402]  287.54 207.24 180 bottom
R3159  33  [R0402]  302.15 215.11 90 bottom
R3160  150_1%  [R0603]  301.89 200.51 90 bottom
R3161  150_1%  [R0603]  303.67 200.51 90 bottom
R3162  150_1%  [R0603]  300.49 200.51 90 bottom
R3163  150_1%  [R0603]  298.72 200.51 90 bottom
R3164  150_1%  [R0603]  295.54 200.51 90 bottom
R3165  150_1%  [R0603]  297.32 200.51 90 bottom
R3166  150_1%  [R0603]  294.14 200.51 90 bottom
R3167  150_1%  [R0603]  292.37 200.51 90 bottom
R3168  49.9_1%  [R0402]  289.95 203.05 0 bottom
R3169  49.9_1%  [R0402]  289.95 204.57 0 bottom
R3170  49.9_1%  [R0402]  289.95 205.71 0 bottom
R3171  49.9_1%  [R0402]  289.95 207.24 0 bottom
R3172  X  [R0402]  289.95 209.9 0 bottom
R3173  X  [R0402]  289.95 208.38 0 bottom
R3174  X  [R0402]  289.95 212.82 0 bottom
R3175  X  [R0402]  289.95 211.05 0 bottom
R3176  X  [R0402]  309 203.17 270 bottom
R3177  X  [R0402]  307.23 202.54 180 bottom
R3178  X  [R0402]  307.23 203.93 0 bottom
R3179  4.7K  [R0402]  320.69 210.33 270 top
R3180  1K  [R0402]  306.26 202.54 180 bottom
R3181  33  [R0402]  306.21 206.6 180 bottom
R3182  1K  [R0402]  306.26 203.93 180 bottom
R3183  X  [R0402]  38.16 162.43 180 top
R3184  X  [R0402]  41.34 154.81 270 top
R3185  X  [R0402]  40.7 162.43 0 top
R3186  X  [R0402]  40.2 154.81 270 top
R3187  4.7K  [R0402]  17.72 180.34 270 bottom
R3188  4.7K  [R0402]  15.43 180.34 270 bottom
R3189  4.7K  [R0402]  22.42 180.34 270 bottom
R3190  X  [R0402]  17.59 191.89 90 bottom
R3191  4.7K  [R0402]  21.15 180.34 90 bottom
R3192  33  [R0402]  19.88 191.89 90 bottom
R3193  33  [R0402]  18.73 191.89 90 bottom
R3194  33  [R0402]  15.3 191.89 90 bottom
R3195  33  [R0402]  14.16 191.89 90 bottom
R3196  33  [R0402]  20 180.34 270 bottom
R3197  4.7K  [R0402]  35.24 183.77 0 bottom
R3198  33  [R0402]  18.86 180.34 270 bottom
R3199  4.7K  [R0402]  16.45 191.89 270 bottom
R3200  33  [R0402]  16.57 180.33 270 bottom
R3201  33  [R0402]  14.29 180.34 270 bottom
R3202  4.7K  [R0402]  9.33 187.32 0 bottom
R3203  100_1%  [R0402]  9.33 188.59 180 bottom
R3204  100_1%  [R0402]  12 188.59 180 bottom
R3205  100_1%  [R0402]  19.24 196.85 0 bottom
R3206  100_1%  [R0402]  17.46 183.51 270 top
R3207  10K_1%  [R0402]  21.53 196.85 180 bottom
R3208  4.7K  [R0402]  16.19 183.51 90 top
R3209  4.7K  [R0402]  12 187.32 0 bottom
R3210  33  [R0402]  27.37 191.89 90 bottom
R3211  33  [R0402]  26.23 191.89 90 bottom
R3212  33  [R0402]  25.08 191.89 90 bottom
R3213  33  [R0402]  23.94 191.89 90 bottom
R3214  4.7K  [R0402]  29.15 196.85 0 bottom
R3215  4.7K  [R0402]  28.38 180.34 90 bottom
R3216  33  [R0402]  27.24 180.34 270 bottom
R3217  100_1%  [R0402]  31.56 196.85 0 bottom
R3218  33  [R0402]  26.1 180.34 270 bottom
R3219  33  [R0402]  24.96 180.34 270 bottom
R3220  100_1%  [R0402]  31.05 189.35 0 bottom
R3221  4.7K  [R0402]  35.24 191.77 180 bottom
R3222  33  [R0402]  23.81 180.34 270 bottom
R3223  4.7K  [R0402]  31.05 188.08 180 bottom
R3224  100_1%  [R0402]  31.05 186.69 0 bottom
R3225  4.7K  [R0402]  22.8 191.89 270 bottom
R3226  4.7K  [R0402]  31.05 185.42 180 bottom
R3227  4.7K  [R0402]  28.51 191.89 270 bottom
R3228  4.7K  [R0402]  35.24 190.12 0 bottom
R3229  0  [R0402]  402.27 213.66 90 top
R3230  0  [R0402]  407.86 213.66 270 top
R3231  0  [R0402]  406.59 213.66 90 top
R3232  0  [R0402]  403.54 213.66 270 top
R3233  0  [R0402]  399.22 213.66 270 top
R3234  0  [R0402]  397.95 213.66 90 top
R3235  0  [R0402]  393.51 213.66 90 top
R3236  0  [R0402]  394.78 213.66 270 top
R3237  100_1%  [R0402]  423.61 11.58 270 top
R3238  1K  [R0402]  390.26 213.61 90 top
R3239  3.01K_1%  [R0603]  36.13 175.77 270 top
R3240  3.01K_1%  [R0603]  37.66 175.77 270 top
R3241  33  [R0402]  200.09 191.89 0 top
R3242  4.7K  [R0402]  200.88 203.15 90 top
R3243  33  [R0402]  388.81 102.11 270 top
R3244  4.7K  [R0402]  203.42 203.15 90 top
R3245  4.7K  [R0402]  400.19 100.68 0 top
R3246  33  [R0402]  202.76 191.89 0 top
R3247  4.7K  [R0402]  202.12 205.48 90 top
R3248  33  [R0402]  393.51 96.39 0 top
R3249  4.7K  [R0402]  400.19 99.41 0 top
R3250  4.7K  [R0402]  400.19 98.4 0 top
R3251  X  [R0402]  19.37 170.18 270 top
R3252  33  [R0402]  36 167 0 top
R3253  33  [R0402]  36 168.15 0 top
R3254  X  [R0402]  36 162.43 180 top
R3255  10K_1%  [R0402]  13.78 160.53 180 bottom
R3256  33  [R0402]  36 164.84 0 top
R3257  33  [R0402]  19.37 170.18 270 bottom
R3258  33  [R0402]  20.51 170.18 270 top
R3259  X  [R0402]  36 163.45 180 top
R3260  X  [R0402]  17.08 170.18 270 bottom
R3261  33  [R0402]  36 165.86 0 top
R3262  499_1%  [R0603]  40.07 168.4 90 top
R3263  10K_1%  [R0402]  13.78 161.67 180 bottom
R3264  33  [R0402]  36 165.86 0 bottom
R3265  X  [R0402]  13.78 166.24 0 top
R3266  33  [R0402]  36 160.02 0 bottom
R3267  33  [R0402]  25.08 170.18 90 bottom
R3268  33  [R0402]  18.22 170.18 270 top
R3269  33  [R0402]  36 163.57 0 bottom
R3270  33  [R0402]  36 164.72 180 bottom
R3271  33  [R0402]  18.22 170.18 270 bottom
R3272  10K_1%  [R0402]  25.46 170.18 90 top
R3273  33  [R0402]  36 162.43 0 bottom
R3274  33  [R0402]  36 157.73 0 bottom
R3275  10K_1%  [R0402]  29.65 170.18 90 bottom
R3276  33  [R0402]  36 158.87 0 bottom
R3277  33  [R0402]  36 161.29 180 bottom
R3278  10K_1%  [R0402]  13.78 167.38 0 top
R3279  33  [R0402]  36 161.16 0 top
R3280  33  [R0402]  17.08 170.18 90 top
R3281  10K_1%  [R0402]  26.23 170.18 90 bottom
R3282  33  [R0402]  13.78 166.24 0 bottom
R3283  10K_1%  [R0402]  36 158.87 180 top
R3284  4.7K  [R0402]  28.51 170.18 90 bottom
R3285  10K_1%  [R0402]  36 160.02 180 top
R3286  4.7K  [R0402]  26.48 170.18 270 top
R3287  X  [R0402]  27.37 170.18 90 bottom
R3288  10K_1%  [R0402]  36 156.59 180 bottom
R3289  33  [R0402]  20.51 170.18 270 bottom
R3290  10K_1%  [R0402]  28.64 170.18 90 top
R3291  10K_1%  [R0402]  36 155.45 180 bottom
R3292  10K_1%  [R0402]  27.5 170.18 90 top
R3293  33  [R0402]  36 157.73 180 top
R3294  33  [R0402]  29.4 147.83 270 bottom
R3295  4.7K  [R0402]  21.65 170.18 270 top
R3296  10K_1%  [R0402]  35.75 170.18 90 bottom
R3297  33  [R0402]  36 151.89 0 top
R3298  X  [R0402]  21.65 170.18 90 bottom
R3299  10K_1%  [R0402]  34.61 170.18 90 bottom
R3300  4.7K  [R0402]  26.23 175.26 270 top
R3301  0  [R0402]  214.19 188.08 90 top
R3302  33  [R0402]  13.78 165.1 0 bottom
R3303  10K_1%  [R0402]  29.65 170.18 90 top
R3304  0  [R0402]  154.75 169.42 180 top
R3305  33  [R0402]  36 156.59 180 top
R3306  0  [R0402]  154.75 167.64 180 top
R3307  10K_1%  [R0402]  31.94 170.18 90 top
R3308  0  [R0402]  215.33 188.08 90 top
R3309  33  [R0402]  36 154.3 180 bottom
R3310  4.7K  [R0402]  22.67 170.18 270 top
R3311  10K_1%  [R0402]  31.94 170.18 90 bottom
R3312  4.7K  [R0402]  36 150.11 0 top
R3313  10K_1%  [R0402]  30.8 170.18 90 bottom
R3314  4.7K  [R0402]  24.45 170.18 270 top
R3315  4.7K  [R0402]  41.59 152.27 270 top
R3316  10K_1%  [R0402]  34.23 170.18 90 top
R3317  10K_1%  [R0402]  33.08 170.18 90 top
R3318  49.9_1%  [R0402]  23.94 170.18 90 bottom
R3319  49.9_1%  [R0402]  22.8 170.18 270 bottom
R3320  10K_1%  [R0402]  22.77 172.97 270 bottom
R3321  10K_1%  [R0402]  23.94 172.97 90 bottom
R3322  33  [R0402]  13.78 168.53 180 bottom
R3323  33  [R0402]  30.8 170.18 270 top
R3324  33  [R0402]  36 155.45 180 top
R3325  4.7K  [R0402]  33.08 170.18 270 bottom
R3326  33  [R0402]  13.78 160.53 180 top
R3327  33  [R0402]  13.78 158.24 0 top
R3328  33  [R0402]  13.78 158.24 180 bottom
R3329  33  [R0402]  13.78 157.1 0 bottom
R3330  33  [R0402]  13.78 154.81 0 bottom
R3331  33  [R0402]  20.26 147.83 270 bottom
R3332  33  [R0402]  13.78 155.95 180 bottom
R3333  33  [R0402]  13.78 159.38 180 bottom
R3334  33  [R0402]  17.46 147.83 270 top
R3335  33  [R0402]  13.78 155.95 0 top
R3336  33  [R0402]  24.83 147.83 90 bottom
R3337  33  [R0402]  25.97 147.83 90 bottom
R3338  33  [R0402]  20.26 147.83 270 top
R3339  33  [R0402]  28.26 147.83 90 bottom
R3340  33  [R0402]  23.69 147.83 270 bottom
R3341  33  [R0402]  27.11 147.83 90 bottom
R3342  33  [R0402]  21.4 147.83 270 bottom
R3343  33  [R0402]  29.27 147.83 90 top
R3344  33  [R0402]  13.78 167.38 180 bottom
R3345  33  [R0402]  13.78 163.95 0 bottom
R3346  33  [R0402]  21.4 147.83 270 top
R3347  33  [R0402]  13.78 162.81 0 bottom
R3348  33  [R0402]  28.13 147.83 90 top
R3349  33  [R0402]  13.78 163.95 180 top
R3350  33  [R0402]  23.69 147.83 270 top
R3351  33  [R0402]  13.78 162.81 180 top
R3352  1.24K_1%  [R0603]  391.26 61.61 90 top
R3353  33  [R0402]  395.8 192.02 270 top
R3354  33  [R0402]  398.34 192.02 270 top
R3355  3.01K_1%  [R0603]  392.82 61.61 90 top
R3356  33  [R0402]  413.19 185.04 180 top
R3357  4.7K  [R0402]  391.99 192.02 270 top
R3358  33  [R0402]  403.42 192.02 90 bottom
R3359  4.7K  [R0402]  390.08 193.67 180 top
R3360  33  [R0402]  394.53 192.02 270 bottom
R3361  499_1%  [R0603]  408.62 192.53 90 top
R3362  33  [R0402]  413.19 185.04 180 bottom
R3363  33  [R0402]  404.69 192.02 90 bottom
R3364  33  [R0402]  404.69 192.02 270 top
R3365  499_1%  [R0603]  394.53 61.61 90 top
R3366  33  [R0402]  397.07 192.02 270 top
R3367  33  [R0402]  393.26 192.02 270 top
R3368  33  [R0402]  394.53 192.02 270 top
R3369  3.01K_1%  [R0603]  397.48 61.61 90 top
R3370  33  [R0402]  413.19 181.23 0 top
R3371  33  [R0402]  413.19 182.5 180 top
R3372  33  [R0402]  395.8 192.02 270 bottom
R3373  33  [R0402]  413.19 182.5 0 bottom
R3374  499_1%  [R0603]  399.34 61.61 90 top
R3375  33  [R0402]  398.34 192.02 270 bottom
R3376  4.7K  [R0402]  407.23 192.02 270 bottom
R3377  4.7K  [R0402]  405.96 192.02 270 top
R3378  33  [R0402]  413.19 179.96 0 top
R3379  1.24K_1%  [R0603]  395.92 61.61 90 top
R3380  X  [R0402]  405.96 192.02 90 bottom
R3381  33  [R0402]  413.19 179.96 0 bottom
R3382  33  [R0402]  397.07 192.02 270 bottom
R3383  33  [R0402]  413.19 183.77 0 bottom
R3384  4.7K  [R0402]  399.61 192.02 270 top
R3385  33  [R0402]  413.19 181.23 0 bottom
R3386  33  [R0402]  413.19 178.69 0 bottom
R3387  3.01K_1%  [R0603]  406.32 61.77 90 top
R3388  33  [R0402]  413.19 178.69 180 top
R3389  499_1%  [R0603]  408.34 61.77 90 top
R3390  1.24K_1%  [R0603]  404.77 61.77 90 top
R3391  4.7K  [R0402]  400.88 192.02 270 top
R3392  0  [R0402]  204.15 190.24 270 top
R3393  0  [R0402]  203.01 190.24 270 top
R3394  33  [R0402]  413.19 174.88 0 top
R3395  4.7K  [R0402]  402.15 192.02 270 top
R3396  33  [R0402]  413.19 177.42 180 top
R3397  0  [R0402]  205.3 190.24 270 top
R3398  0  [R0402]  206.44 190.24 270 top
R3399  49.9_1%  [R0402]  402.15 192.02 90 bottom
R3400  49.9_1%  [R0402]  400.88 192.02 270 bottom
R3401  4.7K  [R0402]  413.19 183.77 0 top
R3402  4.7K  [R0402]  407.23 192.02 270 top
R3403  10K_1%  [R0402]  402.15 194.82 90 bottom
R3404  10K_1%  [R0402]  400.88 194.82 270 bottom
R3405  3.01K_1%  [R0603]  411.39 61.77 90 top
R3406  4.7K  [R0402]  408.5 192.02 270 bottom
R3407  33  [R0402]  413.19 176.15 180 top
R3408  499_1%  [R0603]  413.23 61.77 90 top
R3409  1.24K_1%  [R0603]  409.74 61.77 90 top
R3410  4.7K  [R0402]  403.42 192.02 270 top
R3411  1.24K_1%  [R0603]  416.96 61.77 90 top
R3412  33  [R0402]  390.84 178.69 0 bottom
R3413  33  [R0402]  390.84 181.23 180 bottom
R3414  33  [R0402]  390.84 175.77 0 top
R3415  33  [R0402]  397.32 169.67 270 top
R3416  33  [R0402]  390.84 182.5 180 top
R3417  33  [R0402]  390.84 182.5 0 bottom
R3418  33  [R0402]  397.32 169.67 270 bottom
R3419  33  [R0402]  390.84 179.96 180 top
R3420  33  [R0402]  390.84 179.96 0 bottom
R3421  33  [R0402]  402.4 169.67 90 top
R3422  33  [R0402]  398.59 169.67 270 top
R3423  33  [R0402]  402.4 169.67 90 bottom
R3424  33  [R0402]  399.86 169.67 270 bottom
R3425  33  [R0402]  403.67 169.67 90 top
R3426  33  [R0402]  401.13 169.67 270 bottom
R3427  33  [R0402]  407.1 169.67 90 top
R3428  33  [R0402]  399.86 169.67 270 top
R3429  33  [R0402]  403.67 169.67 90 bottom
R3430  33  [R0402]  390.84 187.58 180 bottom
R3431  33  [R0402]  390.84 185.04 0 bottom
R3432  33  [R0402]  401.13 169.67 270 top
R3433  33  [R0402]  413.19 171.83 180 top
R3434  33  [R0402]  390.84 183.77 180 top
R3435  33  [R0402]  390.84 183.77 0 bottom
R3436  33  [R0402]  390.84 186.31 180 bottom
R3437  3.3K_1%  [R0402]  55.94 78.36 270 bottom
R3438  3.3K_1%  [R0402]  149.92 78.36 270 bottom
R3439  3.3K_1%  [R0402]  243.9 78.36 270 bottom
R3440  3.3K_1%  [R0402]  339.28 78.36 270 bottom
R3441  3.3K_1%  [R0402]  54.55 78.36 270 bottom
R3442  3.3K_1%  [R0402]  148.53 84.83 270 top
R3443  3.3K_1%  [R0402]  242.51 78.36 270 top
R3444  3.3K_1%  [R0402]  336.49 78.36 270 top
R3445  3.3K_1%  [R0402]  53.15 78.36 270 top
R3446  3.3K_1%  [R0402]  336.23 78.36 270 bottom
R3447  3.3K_1%  [R0402]  148.53 78.36 270 bottom
R3448  3.3K_1%  [R0402]  241.11 78.36 270 bottom
R3449  3.3K_1%  [R0402]  54.55 78.36 270 top
R3450  3.3K_1%  [R0402]  147.13 78.36 270 top
R3451  3.3K_1%  [R0402]  337.88 78.36 270 top
R3452  3.3K_1%  [R0402]  242.51 84.83 270 top
R3453  3.3K_1%  [R0402]  58.74 84.83 90 top
R3454  3.3K_1%  [R0402]  154.11 78.36 270 top
R3455  3.3K_1%  [R0402]  248.09 78.36 270 bottom
R3456  3.3K_1%  [R0402]  345 81.02 270 bottom
R3457  3.3K_1%  [R0402]  58.74 78.36 270 top
R3458  3.3K_1%  [R0402]  154.11 84.83 270 top
R3459  3.3K_1%  [R0402]  343.47 85.09 270 top
R3460  3.3K_1%  [R0402]  248.09 84.83 270 top
R3461  3.3K_1%  [R0402]  60.13 78.36 270 top
R3462  3.3K_1%  [R0402]  152.72 84.83 270 top
R3463  3.3K_1%  [R0402]  243.9 78.36 270 top
R3464  3.3K_1%  [R0402]  340.68 78.36 270 bottom
R3465  3.3K_1%  [R0402]  60.13 84.83 90 top
R3466  3.3K_1%  [R0402]  151.32 78.36 270 top
R3467  3.3K_1%  [R0402]  245.3 78.36 270 top
R3468  3.3K_1%  [R0402]  342.2 78.36 270 bottom
R3469  3.3K_1%  [R0402]  55.94 78.36 270 top
R3470  3.3K_1%  [R0402]  149.92 78.36 270 top
R3471  3.3K_1%  [R0402]  246.7 84.83 270 top
R3472  3.3K_1%  [R0402]  340.68 85.09 270 top
R3473  3.3K_1%  [R0402]  58.74 90.8 270 bottom
R3474  3.3K_1%  [R0402]  149.92 84.83 270 top
R3475  3.3K_1%  [R0402]  245.43 84.83 270 top
R3476  3.3K_1%  [R0402]  337.88 85.09 270 top
R3477  3.3K_1%  [R0402]  60.13 90.8 270 bottom
R3478  3.3K_1%  [R0402]  148.53 78.36 270 top
R3479  3.3K_1%  [R0402]  242.51 78.36 270 bottom
R3480  3.3K_1%  [R0402]  337.88 78.36 270 bottom
R3481  3.3K_1%  [R0402]  53.15 78.36 270 bottom
R3482  3.3K_1%  [R0402]  147.13 78.36 270 bottom
R3483  3.3K_1%  [R0402]  241.11 78.36 270 top
R3484  3.3K_1%  [R0402]  339.28 78.36 270 top
R3485  3.3K_1%  [R0402]  60.13 78.36 270 bottom
R3486  3.3K_1%  [R0402]  154.11 78.36 270 bottom
R3487  3.3K_1%  [R0402]  248.09 78.36 270 top
R3488  3.3K_1%  [R0402]  343.47 85.09 270 bottom
R3489  3.3K_1%  [R0402]  57.34 78.36 270 top
R3490  3.3K_1%  [R0402]  152.72 78.36 270 top
R3491  3.3K_1%  [R0402]  246.7 78.36 270 bottom
R3492  3.3K_1%  [R0402]  343.98 78.36 270 top
R3493  3.3K_1%  [R0402]  58.74 78.36 270 bottom
R3494  3.3K_1%  [R0402]  152.72 78.36 270 bottom
R3495  3.3K_1%  [R0402]  246.7 78.36 270 top
R3496  3.3K_1%  [R0402]  342.58 78.36 270 top
R3497  3.3K_1%  [R0402]  57.34 78.36 270 bottom
R3498  3.3K_1%  [R0402]  151.32 78.36 270 bottom
R3499  3.3K_1%  [R0402]  340.68 78.36 270 top
R3500  3.3K_1%  [R0402]  245.3 78.36 270 bottom
R3501  33  [R0402]  403.42 194.82 270 bottom
R3502  33  [R0402]  402.15 196.97 270 bottom
R3503  33  [R0402]  408.5 194.82 90 bottom
R3504  33  [R0402]  377.25 156.72 270 top
R3505  1K  [R0402]  371.92 163.95 270 bottom
R3506  0  [R0603]  385.89 198.75 270 bottom
R3507  30.1K_1%  [R0603]  280.99 207.64 90 top
R3508  60.4K_1%  [R0603]  390.72 198.75 270 top
R3509  11K_1%  [R0603]  389.19 198.75 90 top
R3510  9.31K_1%  [R0603]  282.51 207.64 270 top
R3511  0  [R0603]  366.08 118.87 0 bottom
R3512  33K_1%  [R0603]  366.08 123.7 0 top
R3513  10K_1%  [R0603]  366.08 122.17 0 top
R3514  0  [R0603]  150.69 210.69 270 bottom
R3515  12.7K_1%  [R0603]  155.92 210.59 270 top
R3516  9.31K_1%  [R0603]  153.25 210.59 270 top
R3517  0  [R0603]  380.43 213.61 270 bottom
R3518  33K_1%  [R0603]  385.21 212.72 270 top
R3519  10K_1%  [R0603]  383.81 212.72 270 top
