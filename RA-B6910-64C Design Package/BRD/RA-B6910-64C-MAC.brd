# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LINKACT44: length 290.1
  TOP w0.13: R3064.1 v1(4.64,38.1) ; U123.P6 v1(22.45,154.2)
  SIG3 w0.155: v1(22.45,154.2) 22.45,149.31 25.34,146.43 25.34,144.52 26.67,143.19 26.67,142.16 28.89,139.94 28.89,109.34 28.64,109.09 28.64,106.26 24.45,102.07 24.45,100.71 22.29,98.55 22.29,97.53 21.78,97.03 21.15,97.03 20.26,96.14 20.26,94.99 18.48,93.22 16.32,93.22 8.19,85.09 8.19,83.44 5.91,81.15 5.91,39.37 v1(4.64,38.1)
  SIG6 w0.155: v1(4.64,38.1) 6.79,38.1 7.43,37.46 9.85,37.46 10.1,37.21 145.48,37.21 152.97,44.7 152.97,46.86 154.02,47.91 v1(154.02,47.95)
  BOTTOM w0.13: v1(154.02,47.95) 154.47,47.5 155.16,47.5 155.66,47.99 D412.4
LINKACT45: length 314.2
  TOP w0.13: v1(19.65,151.13) 19.65,151.51 20.85,152.71 20.85,153.4 U123.R4
  SIG3 w0.155: v1(19.65,151.13) 19.11,150.59 19.11,148.97 19.12,148.97 19.12,143.46 24.37,138.21 26.13,138.21 26.6,137.74 26.6,106.39 22.03,101.82 22.03,100.46 19.36,97.79 15.68,97.79 13.17,95.27 13.17,92.6 7.3,86.74 6.29,86.74 2.52,82.98 2.52,37.8 v1(3.37,36.95)
  SIG6 w0.155: v1(3.37,36.95) 3.87,37.46 6.62,37.46 7.63,36.45 9.97,36.45 10.35,36.83 158.85,36.83 v1(170.02,48)
  BOTTOM w0.13: R3072.1 5.22,37.46 4.38,37.46 3.87,36.95 v1(3.37,36.95) ; v2(18.96,150.47) 18.99,150.47 v1(19.65,151.13) ; v1(170.02,48) 170.55,47.48 171.9,47.48 172.42,47.99 D416.4
LINKACT46: length 329.1
  TOP w0.13: U123.M3 v1(20.05,155.8)
  SIG3 w0.155: v1(3.37,35.81) 2.14,37.04 2.14,83.37 6.79,88.02 7.82,88.02 8.83,89.02 8.83,89.91 9.21,90.29 9.62,90.29 12.32,92.99 12.32,95.37 15.37,98.42 19.35,98.42 21.56,100.63 21.56,101.9 26.1,106.44 26.1,135.76 17.59,144.27 17.59,152.02 17.97,152.4 17.97,154.3 19.47,155.8 v1(20.05,155.8)
  SIG6 w0.155: v1(177.51,48) 177.51,44.1 166.43,33.02 11.02,33.02 9.87,34.17 7.11,34.17 4.96,36.32 3.87,36.32 v1(3.37,35.81)
  BOTTOM w0.13: v1(177.51,48) 177,47.5 175.23,47.5 175.05,47.67 D420.4 ; v1(3.37,35.81) 3.87,36.32 v2(3.98,36.32) 5.22,36.32 R3080.1
LINKACT47: length 338
  TOP w0.13: R3088.1 v1(4.64,34.67) ; U123.N7 v1(23.25,155)
  SIG3 w0.102: v1(23.25,155) 23.65,154.6 23.65,153.7 23.98,153.38
  SIG3 w0.155: 23.98,153.38 24.32,153.03 26.61,153.03 28.26,151.38 28.26,149.48 30.54,147.19 30.54,109.34 31.81,108.07 31.81,107.44 31.05,106.68 30.67,106.68 29.79,105.8 29.79,105.79 29.15,105.14 29.15,104.01 28.64,103.5 28.64,101.6 26.92,99.88 26.92,97.6 18.99,89.66 15.81,89.66 15.37,89.21 15.37,88.2 13.53,86.36 13.53,85.47 11.87,83.82 10.99,83.82 9.91,82.74 9.91,81.21 7.06,78.36 7.06,59.3 7.94,58.42 7.94,57.15 7.06,56.27 7.06,37.09 v1(4.64,34.67)
  SIG6 w0.155: v1(189.96,48) 183.04,48 166.9,31.87 10.23,31.87 9.08,33.02 6.29,33.02 v1(4.64,34.67)
  BOTTOM w0.13: v1(189.96,48) 190.47,47.5 191.1,47.5 191.6,47.99 D424.4 ; v1(4.64,34.67) v2(4.64,33.91)
LINKACT48: length 366.4
  TOP w0.13: v1(411.67,179.45) 411.21,178.98 409.58,178.98 409.32,179.25 407.62,179.25 U124.K15
  SIG7 w0.152: 415.61,148.26 423.1,140.77 423.1,135.41 416.61,128.93 416.61,108.96 415.79,108.14 415.29,108.14 414.72,107.58 414.72,106.17 400.11,91.56 400.11,83.44 401,82.55 401,73.94 403.16,71.78 403.16,67.43 400.01,64.28 400.01,51.46 392.37,43.81 392.37,43.36 v1(391.68,42.67)
  SIG7 w0.155: v1(391.68,42.67) 391.68,42.39 385.61,36.32 225.84,36.32 213.7,48.46 201.48,48.46 v1(201.02,48) ; 415.61,148.26 415.61,172.21 413.58,174.24 413.58,177.54 v1(411.67,179.45)
  BOTTOM w0.13: v2(391.73,41.91) 391.73,42.62 v1(391.68,42.67) 391.17,43.18 390.21,43.18 390.06,43.03 R3033.1 ; v1(201.02,48) 201.53,47.5 202.16,47.5 202.66,47.99 D397.4
LINKACT49: length 345.8
  TOP w0.13: U124.H12 v1(405.22,181.65) ; R3041.1 v1(390.72,42.67)
  SIG4 w0.155: v1(405.22,181.65) 405.76,181.1 406.97,181.1 408.9,179.17 408.9,176.12 409.28,175.74 409.28,174.34 410.05,173.58 410.05,170.66 411.42,169.29 411.42,163.57 412.81,162.18 412.81,141.6 411.23,140.02 411.23,135.06 417,129.28 417,105.79 400.81,89.6 400.81,74.01 402.78,72.04 402.78,68.51 399.9,65.62 399.9,51.38 391.69,43.18 391.22,43.18 v1(390.72,42.67) 390.72,41.83 385.92,37.03 266.56,37.03 261.29,42.3 228.01,42.3 223.16,47.16 217.86,47.16 v1(217.02,48)
  BOTTOM w0.13: D402.4 219.42,47.99 218.91,47.48 217.55,47.48 v1(217.02,48) ; v2(390.46,41.4) 390.46,41.53 390.72,41.78 v1(390.72,42.67)
LINKACT50: length 330.9
  TOP w0.13: R3049.1 v1(390.72,44.96) ; U124.K14 v1(406.82,179.25)
  SIG4 w0.155: v1(224.51,48) 229.44,43.07 262.68,43.07 267.95,37.8 385.6,37.8 389.82,42.02 389.82,44.06 v1(390.72,44.96) 391.22,45.46 392.49,45.46 397.95,50.92 397.95,55.24 v1(398.72,56) 399.13,56.42 399.13,65.15 398.14,66.14 398.14,80.54 399.63,82.04 399.63,89.5 414.97,104.84 414.97,130.09 410.46,134.61 410.46,140.33 412.05,141.92 412.05,161.77 408.37,165.45 408.37,170.43 409.26,171.32 409.26,173.23 408.75,173.73 408.37,173.73 407.86,174.24 407.86,174.75 408.11,175 408.11,175.51 407.99,175.64 407.99,178.43 407.17,179.25 v1(406.82,179.25)
  BOTTOM w0.13: v1(224.51,48) 224,47.5 222.23,47.5 222.05,47.67 D405.4
LINKACT51: length 326.9
  TOP w0.13: U124.G15 407.62,182.45 408.73,182.45 409.08,182.8 409.69,182.8 v1(409.77,182.88)
  SIG7 w0.152: 412.19,160.68 412.19,142.63 410.54,140.98 410.54,135.14 414.34,131.34 414.34,108.27 413.54,107.48 413.54,106.16 410.33,102.95 409.02,102.95 399.27,93.21 399.27,86.79 398.46,85.98 398.46,65.72 399.25,64.93 399.25,62.86 397.61,61.23 397.61,50.89 v1(391.68,44.96)
  SIG7 w0.155: v1(236.96,48) 237.51,48.56 242.08,48.56 247.75,42.88 263.25,42.88 268.93,37.2 385.41,37.2 389.87,41.67 389.87,43.73 390.46,44.32 391.05,44.32 v1(391.68,44.96) ; v1(409.77,182.88) 409.26,182.37 409.26,177.67 409.7,177.23 411.35,177.23 412.31,176.27 412.31,173.86 413.19,172.97 413.19,161.68 412.19,160.68
  BOTTOM w0.13: D409.4 238.6,47.99 238.1,47.5 237.47,47.5 v1(236.96,48) ; R3057.1 390.06,45.31 390.21,45.46 391.17,45.46 v1(391.68,44.96) 391.93,44.7 v2(392.49,44.7)
LINKACT52: length 305.4
  TOP w0.13: R3065.1 v1(390.72,47.24) ; U124.K12 v1(405.22,179.25)
  SIG4 w0.102: v1(405.22,179.25) 405.62,178.85 405.62,175.42
  SIG4 w0.155: v1(248.02,48) 248.48,48.46 258.48,48.46 268.3,38.64 385.36,38.64 389.06,42.34 389.06,45.58 v1(390.72,47.24) 391.22,47.75 392.98,47.75 396.59,51.36 396.59,62 398.34,63.74 398.34,64.73 397.37,65.7 397.37,88.95 402.5,94.08 v1(402.5,94.77) 403.81,94.77 414.08,105.04 414.08,129.9 409.69,134.29 409.69,140.77 411.28,142.35 411.28,161.07 407.6,164.75 407.6,170.69 407.1,171.19 407.1,173.35 405.62,174.83 405.62,175.42
  BOTTOM w0.13: v1(248.02,48) 248.53,47.5 249.16,47.5 249.66,47.99 D413.4
LINKACT53: length 292.3
  TOP w0.13: U124.L14 v1(406.82,178.45)
  SIG7 w0.152: v1(391.68,47.24) 396.85,52.41 396.85,61.54 398.49,63.18 398.49,64.62 397.7,65.4 397.7,92.71 409.32,104.33 410.47,104.33 412.24,106.1 412.24,107.25 413.57,108.58 413.57,131.03 409.77,134.83 409.77,141.36 411.41,142.99 411.41,162.17
  SIG7 w0.155: v1(391.68,47.24) 391.05,46.61 390.46,46.61 389.11,45.25 389.11,42.2 384.87,37.97 270.67,37.97 264.02,44.62 v1(264.02,48) ; v1(406.82,178.45) 407.86,177.4 407.86,176.91 409.28,175.49 409.28,174.22 410.65,172.85 410.65,170.55 411.41,169.8 411.41,162.17
  BOTTOM w0.13: R3073.1 390.06,47.6 390.21,47.75 391.17,47.75 v1(391.68,47.24) v2(392.49,47.24) ; v1(264.02,48) 264.55,47.48 265.9,47.48 266.42,47.99 D418.4
LINKACT54: length 280.1
  TOP w0.13: U124.L13 v1(406.02,178.45)
  SIG7 w0.102: 406.47,175.5 406.42,175.56 406.42,178.05 v1(406.02,178.45)
  SIG7 w0.152: v1(391.68,49.53) 396.09,53.94 396.09,62.14 396.94,62.98 396.94,93.03 407.51,103.6 407.51,105.06 408.24,105.79 410.27,105.79 410.91,106.42 410.91,107 411.8,107.89 411.8,131.72 409.01,134.51 409.01,142.1 409.96,143.05 409.96,143.06 410.2,143.3 410.2,161.36 408.24,163.32
  SIG7 w0.155: v1(271.51,48) 272.27,47.24 275.78,47.24 284.29,38.73 382.11,38.73 386.42,43.04 386.42,48.15 387.16,48.89 391.05,48.89 v1(391.68,49.53) ; 408.24,163.32 408.14,163.42 408.14,173.84 406.47,175.5
  BOTTOM w0.13: R3081.1 390.06,49.88 390.21,50.04 391.17,50.04 v1(391.68,49.53) 391.93,49.78 v2(392.49,49.78) ; v1(271.51,48) 271,47.5 269.23,47.5 269.05,47.67 D421.4
LINKACT55: length 261
  TOP w0.13: v1(405.09,172.97) 405.09,173.63 405.22,173.76 405.22,175.25 U124.R12 ; R3089.1 v1(390.72,49.53)
  SIG4 w0.155: v1(390.72,49.53) 391.22,50.04 391.86,50.04 395.83,54 395.83,62.36 396.61,63.14 396.61,90.09 403.84,97.32 405.28,97.32 413.19,105.23 413.19,129.54 v1(412.69,130.05) 412.69,130.21 408.93,133.97 408.93,141.18 410.51,142.76 410.51,160.75 406.83,164.43 406.83,170.28 405.57,171.54 405.57,172.65 405.25,172.97 v1(405.09,172.97)
  SIG10 w0.155: v1(283.96,48) 284.42,48.46 292.43,48.46 293.78,47.11 298.25,47.11 303.96,41.4 331.2,41.4 332.43,42.63 383.82,42.63 384.5,43.3 389.57,43.3 389.7,43.43 389.7,48.51 v1(390.72,49.53)
  BOTTOM w0.13: v1(283.96,48) 284.47,47.5 285.1,47.5 285.6,47.99 D425.4
LINKACT56: length 247.4
  TOP w0.13: U124.M10 v1(403.62,177.65)
  SIG7 w0.102: v1(403.62,177.65) 404.02,177.25 404.02,175.76
  SIG7 w0.152: v1(391.68,51.81) 395.33,55.46 395.33,62.83 395.47,62.97 395.47,94.32 405.7,104.56 405.7,106.74 407.86,108.9 407.86,142.58 409.01,143.72 409.01,160.4
  SIG7 w0.155: 404.02,175.76 404.02,175.04 405.57,173.48 405.57,170.43 406.76,169.24 406.76,162.64 409.01,160.4 ; v1(391.68,51.81) 391.05,51.18 387.16,51.18 385.65,49.67 385.65,45.38 382.64,42.37 311.64,42.37 305.45,48.56 295.57,48.56 v1(295.02,48)
  BOTTOM w0.13: v2(392.49,52.32) 391.99,51.81 v1(391.68,51.81) 391.17,52.32 390.21,52.32 390.06,52.17 R3034.1 ; D398.4 296.66,47.99 296.16,47.5 295.53,47.5 v1(295.02,48)
LINKACT57: length 235.8
  TOP w0.13: U124.L10 v1(403.62,178.45) ; R3042.1 v1(390.72,51.81)
  SIG4 w0.102: v1(403.62,178.45) 403.22,178.05 403.22,175.43
  SIG4 w0.155: v1(390.72,51.81) 391.22,52.32 393.06,52.32 395.06,54.32 395.06,64.41 395.84,65.19 395.84,90.41 403.52,98.09 404.96,98.09 411.54,104.67 411.54,129.28 409.26,131.57 v1(409.26,132.08) 408.16,133.18 408.16,141.52 409.74,143.1 409.74,160.44 406.06,164.11 406.06,169.31 403.54,171.83 403.54,173.99 403.22,174.31 403.22,175.43
  SIG10 w0.155: v1(390.72,51.81) 390.08,51.18 386.16,51.18 385.53,50.54 385.53,45.41 383.51,43.39 332.11,43.39 331.03,42.31 320.81,42.31 316.13,46.98 312.04,46.98 v1(311.02,48)
  BOTTOM w0.13: D401.4 313.42,47.99 312.91,47.48 311.55,47.48 v1(311.02,48)
LINKACT58: length 222.4
  TOP w0.13: R3050.1 v1(390.72,54.1) ; U124.L9 v1(402.82,178.45)
  SIG4 w0.155: v1(390.72,54.1) 391.22,54.61 391.99,54.61 394.29,56.91 394.29,65.03 395.07,65.81 395.07,90.72 407.39,103.05 407.39,129.2 v1(408.5,130.3) 408.5,130.93 407.39,132.04 407.39,141.84 408.97,143.42 408.97,160.12 404.45,164.64 404.45,169.09 401.51,172.03 401.51,173.35 402.27,174.11 402.27,177.9 v1(402.82,178.45)
  SIG10 w0.155: v1(318.51,48) 323.34,43.17 329.22,43.17 332.88,46.84 374.23,46.84 374.69,46.38 379.57,46.38 380.3,47.11 382.97,47.11 384.76,48.9 384.76,52.45 385.78,53.46 390.08,53.46 v1(390.72,54.1)
  BOTTOM w0.13: v1(318.51,48) 318,47.5 316.23,47.5 316.05,47.67 D406.4
LINKACT59: length 210.5
  TOP w0.13: U124.M9 v1(402.82,177.65)
  SIG7 w0.152: v1(391.68,54.1) 394.57,56.98 394.57,68.36 394.65,68.45 394.65,94.77 404.94,105.06 404.94,107.06 407.07,109.19 407.07,142.9 408.24,144.07 408.24,159.87 405.96,162.15 405.96,164.33
  SIG7 w0.155: v1(391.68,54.1) 391.05,53.46 387.16,53.46 384.89,51.19 384.89,45.7 382.33,43.14 356.34,43.14 350.92,48.56 331.51,48.56 v1(330.96,48) ; v1(402.82,177.65) 402.27,177.1 402.27,174.88 403.69,173.46 403.69,168.63 403.92,168.4 403.92,166.36 405.96,164.33
  BOTTOM w0.13: v2(392.49,54.86) 391.73,54.1 v1(391.68,54.1) 391.17,54.61 390.21,54.61 390.06,54.46 R3058.1 ; v1(330.96,48) 331.47,47.5 332.1,47.5 332.6,47.99 D408.4
LINKACT60: length 196.4
  TOP w0.13: U124.K6 v1(399.62,179.25) ; R3066.1 v1(390.72,56.39)
  SIG4 w0.102: 400.02,175.64 400.02,178.85 v1(399.62,179.25)
  SIG4 w0.155: v1(390.72,56.39) 391.22,56.89 392.11,56.89 392.52,57.3 392.52,64.82 394.3,66.6 394.3,91.04 398.72,95.45 398.72,96.52 406.63,104.43 406.63,142.4 408.11,143.89 408.11,157.22 v1(405.19,160.14) 405.19,162.81 403.67,164.34 403.67,168.79 401.65,170.81 399.7,170.81 398.97,171.54 398.97,173.51 400.02,174.56 400.02,175.64
  SIG10 w0.155: v1(342.02,48) 342.57,48.56 361.03,48.56 361.62,49.14 363.38,49.14 363.96,48.56 375.14,48.56 376.54,47.16 379.19,47.16 380.59,48.56 383.02,48.56 383.99,49.53 383.99,54.35 385.39,55.75 390.08,55.75 v1(390.72,56.39)
  BOTTOM w0.13: D414.4 343.66,47.99 343.16,47.5 342.53,47.5 v1(342.02,48)
LINKACT61: length 185.4
  TOP w0.13: U124.M8 v1(401.22,177.65)
  SIG7 w0.102: v1(401.22,177.65) 400.82,177.25 400.82,175.51
  SIG7 w0.152: v1(391.68,56.39) 393,57.71 393,61.69 392.11,62.58 392.11,64.48 390.75,65.85 388.84,65.85 387.79,66.9 387.79,74.7 393.89,80.8 393.89,95.09 400.22,101.41 400.22,103.41 406.31,109.51 406.31,143.22 407.45,144.36 407.45,156.87 404.56,159.76 404.56,161.67 400.08,166.15 400.08,170.2
  SIG7 w0.155: v1(358.02,48) 358.91,47.11 383,47.11 384.12,48.23 384.12,52.71 387.16,55.75 391.05,55.75 v1(391.68,56.39) ; 400.08,170.2 399.4,170.88 399.4,173.9 400.82,175.32 400.82,175.51
  BOTTOM w0.13: R3074.1 390.06,56.74 390.21,56.89 391.17,56.89 v1(391.68,56.39) 392.49,57.2 v2(392.49,57.4) ; D417.4 360.42,47.99 359.91,47.48 358.55,47.48 v1(358.02,48)
LINKACT62: length 175.7
  TOP w0.13: U124.L5 v1(398.82,178.45)
  SIG7 w0.102: v1(398.82,178.45) 398.42,178.05 396.93,178.05 396.67,177.78
  SIG7 w0.155: v1(365.51,48) 366.27,48.77 375.22,48.77 376.49,50.04 382.33,50.04 382.97,50.67 382.97,55.12 387.16,59.31 391.17,59.31 v1(391.68,59.81) 391.68,61.39 386.65,66.42 386.65,75.18 392.75,81.27 392.75,96.9 395.92,100.07 396.3,100.07 398.21,101.98 398.21,103.02 405.16,109.98 405.16,143.7 406.3,144.84 406.3,156.24 397.57,164.97 397.57,174.88 396.43,176.02 396.43,177.54 396.67,177.78
  BOTTOM w0.13: v1(365.51,48) 365,47.5 363.23,47.5 363.05,47.67 D422.4 ; v1(391.68,59.81) 390.41,61.08 v2(390.08,61.08) 390.06,61.06 R3082.1
LINKACT63: length 160.8
  TOP w0.13: R3090.1 v1(390.72,58.67) ; U124.J5 v1(398.82,180.05)
  SIG4 w0.102: 398.42,175.77 398.42,179.65 v1(398.82,180.05)
  SIG4 w0.155: 398.42,175.77 398.42,174.12 397.57,173.27 397.57,170.65 398.18,170.04 401.33,170.04 402.19,169.18 402.19,163.27 v1(403.92,161.54) 403.92,160.02 407.35,156.59 407.35,144.21 405.86,142.72 405.86,104.93 397.69,96.76 397.69,95.51 393.39,91.21 393.39,79.84 388.31,74.76 388.31,65.02 391.2,62.13 391.2,59.15 v1(390.72,58.67)
  SIG10 w0.155: v1(377.96,48) 378.9,48.94 379.34,48.94 380.25,49.86 382.67,49.86 383.23,50.42 383.23,55.24 386.02,58.04 390.08,58.04 v1(390.72,58.67)
  BOTTOM w0.13: v1(377.96,48) 378.47,47.5 379.1,47.5 379.6,47.99 D426.4
LM75_4A_INT#: length 268.2
  TOP w0.13: v1(204.79,204.21) 204.79,202.57 204.28,202.06 204.28,193.67 203.24,192.63 R3246.2 ; U124.C13 v1(406.02,185.65)
  SIG6 w0.155: v1(406.02,185.65) 407.31,186.94 407.99,186.94 408.5,186.43 411.92,186.43 412.18,186.69 412.18,193.25 403.8,201.63 387.5,201.63 383.5,197.63 383.5,196.36 381.85,194.71 371.43,194.71 359.21,206.93 331.01,206.93 318.78,219.16 283.87,219.16 282.46,217.75 264.02,217.75 262.95,218.82 245.41,218.82 234.45,207.86 207.92,207.86 204.79,204.72 v1(204.79,204.21)
  BOTTOM w0.13: v1(406.02,185.65) 405.81,185.85 405.81,187.69 406.46,188.34 406.46,188.85 406.72,189.1 407.99,189.1 408.37,189.48 408.37,191.41 R3406.2 409.74,191.54 v2(409.77,191.51)
LM75_48_INT#: length 142.6
  TOP w0.13: U124.A13 405.62,187.27 406.39,188.04 406.39,189.02 v1(406.95,189.58) 407.23,189.86 R3402.2 ; v1(402.02,90.04) 395.67,96.39 R3248.2
  SIG10 w0.155: v1(406.95,189.58) 407.43,189.1 408.14,189.1 408.45,188.8 408.45,188.33 408.95,187.83 415.48,187.83 418.15,185.16 418.15,175.09 426.4,166.84 426.4,134.99 419.8,128.38 419.8,104.9 418.67,103.77 418.67,98.78 411.59,91.69 403.67,91.69 v1(402.02,90.04)
LOCATOR_LED: length 157.4
  TOP w0.13: v1(409.64,68.32) 410.53,67.43 419.65,67.43 420.07,67.01 420.07,64.53 419.72,64.19 D433.2 ; U124.F15 407.62,183.25 408.61,183.25 409.03,183.66 411.32,183.66 v1(411.8,184.15)
  SIG7 w0.155: v1(409.64,68.32) 408.79,68.32 403.28,73.84 403.28,82.44 402.53,83.19 402.53,91.44 418.15,107.06 418.15,127.8 425.01,134.65 425.01,143.85 419.54,149.31 419.54,180.97 416.24,184.27 411.92,184.27 v1(411.8,184.15)
  BOTTOM w0.13: v1(409.64,68.32) v2(409.64,67.56)
LPC_LAD0: length 602.1
  TOP w0.13: C3487.1 87.31,204.64 v1(87.44,204.77)
  SIG1 w0.16: YJ3.A1_1 106.15,220.07 104.4,220.07 104.25,219.92 103.4,219.92 103.25,220.07 102.14,220.07 101.99,219.92 100.82,219.92 99.43,218.53 99.43,216.4 95.25,212.21 89.22,212.21 87.95,210.94 87.95,205.28 v1(87.44,204.77) 86.3,205.91 72.15,205.91 68.59,209.47 62.38,209.47 60.39,211.45 60.01,211.45 57.73,213.73 40.76,213.73 39.85,212.81 39.85,205.84 34.58,200.57 34.58,181.7 33.72,180.85 33.72,178.05 34.1,177.67 34.1,173.35 33.8,173.06 33.8,170.39 33.21,169.8 33.21,165.35 35.53,163.03 37.87,163.03 v1(38.42,163.57)
  SIG6 w0.155: v1(38.42,163.57) 39.16,164.32 39.54,164.32 39.81,164.59 39.81,173.18 39.07,173.92 39.07,181.51 37.99,182.6 37.99,188.79 57.3,208.11 111.28,208.11 114.85,211.68 114.85,215.55 121.98,222.68 378.12,222.68 384.28,216.53 384.28,209.09 388.2,205.16 407.43,205.16 418.94,193.66 418.94,182.27 v1(415.61,178.94)
  BOTTOM w0.13: v1(415.61,178.94) 415.48,179.07 414.46,179.07 414.08,178.69 R3386.2 ; v1(38.42,163.57) 38.42,163.5 v2(37.91,162.99) 37.81,162.89 37.17,162.89 R3269.2
LPC_LAD1: length 586.5
  TOP w0.13: v1(91.25,204.72) 91.38,204.59 C3483.1 ; v1(414.59,179.96) R3378.2
  SIG1 w0.16: v1(42.1,162.18) 42.61,162.68 42.61,164.79 37.31,170.09 37.31,171.31 37.8,171.81 37.8,200.37 46.53,209.09 54.29,209.09 55.98,207.4 67.74,207.4 71.38,203.76 84.72,203.76 86.27,202.21 89.62,202.21 91.25,203.83 v1(91.25,204.72) 93.39,206.86 97.83,206.86 100.27,209.29 100.27,211.07 101.28,212.08 103.2,212.08 103.35,211.93 104.47,211.93 104.62,212.08 107.12,212.08 107.89,212.85 107.89,216.39 YJ3.B1_1
  SIG6 w0.155: v1(414.59,179.96) 415.11,180.47 415.11,183.53 415.42,183.84 416.19,183.84 417.01,184.65 417.01,192.72 406.31,203.42 386.94,203.42 381.57,208.79 381.57,216.29 376.84,221.02 122.67,221.02 116.5,214.86 116.5,210.99 111.96,206.45 57.99,206.45 40.77,189.24 40.77,184.3 42.63,182.44 42.63,172.69 42.99,172.34 42.99,162.81 42.35,162.18 v1(42.1,162.18)
  BOTTOM w0.13: R3273.2 36.54,162.38 v2(39.18,162.38) 41.9,162.38 v1(42.1,162.18)
LPC_LAD2: length 587.9
  TOP w0.13: C3484.1 v1(90.36,204.72) ; v1(414.59,181.23) R3370.2
  SIG1 w0.16: YJ3.C1_1 106.15,212.47 104.46,212.47 104.31,212.32 103.51,212.32 103.36,212.47 101.11,212.47 99.88,211.23 99.88,209.45 97.67,207.25 92.89,207.25 v1(90.36,204.72) 90.36,204.09 89.09,202.82 86.3,202.82 84.97,204.15 71.55,204.15 67.9,207.79 56.14,207.79 54.45,209.48 46.37,209.48 37.34,200.45 37.34,174.18 36.28,173.12 36.28,171.64 36.64,171.28 36.64,166.88 37.02,166.49 39.56,166.49 41.1,164.96 41.1,162.32 39.31,160.53 38.93,160.53 38.42,160.02 v1(38.42,159.94)
  SIG6 w0.155: v1(38.42,159.94) 39.13,160.65 41.72,160.65 43.54,162.47 43.54,172.43 43.1,172.86 43.1,183.06 41.24,184.92 41.24,189.16 58.15,206.07 97.01,206.07 97.73,205.36 111.41,205.36 116.89,210.83 116.89,214.7 122.83,220.64 376.29,220.64 380.3,216.63 380.3,209.04 386.31,203.03 406.15,203.03 416.62,192.56 416.62,184.89 416.04,184.3 414.18,184.3 413.87,183.99 413.87,181.95 v1(414.59,181.23)
  BOTTOM w0.13: R3266.2 36.49,160.5 36.64,160.65 37.78,160.65 v2(37.9,160.54) 38.42,160.02 v1(38.42,159.94)
LPC_LAD3: length 601.8
  TOP w0.13: v1(37.4,161.24) 37.4,161.29 37.27,161.16 R3279.2 ; C3481.1 v1(88.33,204.72)
  SIG1 w0.16: v1(37.4,161.24) 38.83,162.67 39.16,162.67 39.81,163.32 39.81,163.9 39.38,164.34 36.77,164.34 35.35,165.75 35.35,169.85 34.27,170.94 34.27,172.72 34.61,173.06 34.61,174.51 35.62,175.51 35.62,176.52 34.86,177.27 34.86,179.47 35.04,179.65 35.04,200.42 40.31,205.68 40.31,212.66 40.99,213.34 55.56,213.34 56.32,212.58 56.32,212.09 56.96,211.45 58.23,211.45 58.74,210.94 58.74,210.18 59.84,209.08 68.43,209.08 72.08,205.43 85.84,205.43 87.06,204.21 87.82,204.21 v1(88.33,204.72) 88.52,204.91 88.52,206.05 91,208.53 95.02,208.53 95.71,209.23 95.71,212.13 99.82,216.23 99.82,218.37 100.98,219.53 102.15,219.53 102.3,219.68 103.09,219.68 103.24,219.53 104.41,219.53 104.56,219.68 105.25,219.68 YJ3.B2_1
  SIG6 w0.155: v1(415.61,181.23) 418.55,184.17 418.55,193.5 407.36,204.69 388.08,204.69 383.89,208.88 383.89,216.3 377.89,222.3 122.14,222.3 115.23,215.39 115.23,211.52 111.44,207.73 57.46,207.73 38.61,188.87 38.61,183.53 39.69,182.44 39.69,174.23 40.58,173.34 40.58,163.96 39.3,162.68 38.8,162.68 37.4,161.29 v1(37.4,161.24)
  BOTTOM w0.13: v1(415.61,181.23) 415.61,181.1 v2(415.1,180.59) 413.96,180.59 413.68,180.87 R3385.2
LPC_LCLK: length 591.9
  TOP w0.13: C3482.1 v1(89.34,204.72)
  SIG1 w0.16: v1(38.42,161.24) 39.1,161.92 39.33,161.92 40.46,163.05 40.46,164.33 39.43,165.35 36.89,165.35 36,166.25 36,171.01 35.51,171.5 35.51,174.5 36.26,175.25 36.26,176.78 35.51,177.53 35.51,179.2 36.28,179.98 36.28,200.3 42.86,206.88 42.86,208.79 43.37,209.29 44.51,209.29 46.42,211.2 55.94,211.2 56.45,210.69 56.45,209.58 57.59,208.43 68.17,208.43 71.81,204.79 85.34,204.79 86.65,203.48 88.48,203.48 89.22,204.21 89.22,204.59 v1(89.34,204.72) 89.6,204.98 89.6,206.12 91.37,207.89 95.28,207.89 96.36,208.96 96.36,211.86 100.39,215.9 105.23,215.9 YJ3.C2_1
  SIG6 w0.155: v1(38.42,161.24) 39.1,161.92 40.24,161.92 41.55,163.23 41.55,182.13 39.85,183.84 39.85,189.21 57.73,207.09 111.7,207.09 115.87,211.26 115.87,215.12 122.4,221.66 377.5,221.66 383.11,216.04 383.11,208.52 387.57,204.05 406.82,204.05 417.9,192.98 417.9,184.63 v1(415.61,182.34)
  BOTTOM w0.13: v1(89.34,204.72) v2(89.34,203.58) ; R3373.2 413.68,182.14 413.83,181.99 415.25,181.99 v1(415.61,182.34) ; v1(38.42,161.24) 37.91,161.74 36.59,161.74 36.49,161.64 R3277.1
LPC_LFRAME#: length 588.4
  TOP w0.13: C3486.1 93.41,204.34 v1(93.03,204.72)
  SIG1 w0.16: v1(38.42,157.6) 39.3,158.49 39.3,159.28 39.52,159.5 41.53,159.5 44.03,161.99 44.03,164.47 38.08,170.41 38.08,170.92 38.58,171.42 38.58,199.91 45.29,206.63 67.42,206.63 71.06,202.98 84.1,202.98 86.42,200.66 92.14,200.66 92.9,201.42 92.9,204.59 v1(93.03,204.72) 94.3,205.99 104.71,205.99 107.89,209.17 107.89,210.44 107.32,211 YJ3.D2_1
  SIG6 w0.155: v1(415.61,179.96) 415,179.34 414.18,179.34 413.1,180.43 413.1,185.08 413.56,185.54 413.56,187.43 414.21,188.08 414.21,193.55 405.49,202.27 385.42,202.27 381.32,206.37 372.3,206.37 370.36,208.32 330.82,208.32 319.28,219.86 283.49,219.86 282.01,218.39 271.33,218.39 270.24,219.47 122.75,219.47 117.66,214.38 117.66,210.52 111.73,204.59 94.17,204.59 93.53,205.23 86.05,205.23 85.41,204.59 57.76,204.59 44.49,191.33 44.49,186.63 44.18,186.32 44.18,173.43 44.47,173.14 44.47,162.14 39.94,157.6 v1(38.42,157.6)
  BOTTOM w0.13: R3274.2 36.49,158.11 36.61,158.24 v2(37.91,158.24) 38.42,157.73 v1(38.42,157.6) ; v1(415.61,179.96) 415.1,179.45 413.83,179.45 413.68,179.6 R3381.2
LPC_SERIRQ: length 576.4
  TOP w0.13: v1(92.14,204.72) 92.39,204.47 C3485.1
  SIG1 w0.16: v1(38.42,158.98) 39.4,159.96 41.38,159.96 43.56,162.15 43.56,164.39 37.7,170.25 37.7,171.15 38.19,171.65 38.19,200.07 45.13,207.02 67.58,207.02 71.22,203.37 84.47,203.37 86.68,201.17 90.61,201.17 90.87,201.42 90.87,202.31 92.14,203.58 v1(92.14,204.72) 93.89,206.47 103.95,206.47 YJ3.D1_1
  SIG6 w0.155: v1(415.61,184.78) 416.12,185.29 416.12,192.53 406,202.65 385.8,202.65 379.67,208.78 330.98,208.78 319.5,220.26 122.99,220.26 117.27,214.54 117.27,210.68 111.57,204.97 95.19,204.97 94.52,205.64 85.05,205.64 84.39,204.97 57.6,204.97 43.1,190.48 43.1,185.7 43.72,185.08 43.72,173.13 44.09,172.76 44.09,162.29 41.81,160.02 39.46,160.02 v1(38.42,158.98)
  BOTTOM w0.13: R3276.2 36.49,159.23 36.74,159.48 37.91,159.48 v1(38.42,158.98) 38.54,158.98 v2(39.03,159.46) ; v1(415.61,184.78) 415.1,184.78 414.59,184.27 413.83,184.27 413.68,184.12 R3383.2
LPMODE0: length 15.6
  TOP w0.13: v1(17.21,75.44) 17.72,75.94 17.72,77.72 17.87,77.87 R2598.1
  SIG1 w0.16: YJ21.A31 17.21,70.71 v1(17.21,75.44)
  BOTTOM w0.13: v1(17.21,75.44) v2(18.12,75.44)
LPMODE1: length 34.3
  SIG3 w0.155: YJ21.B31 21.12,58.8 16.07,58.8 13.4,61.47 13.4,74.55 15.68,76.83 15.68,81.53 v1(15.18,82.04)
  BOTTOM w0.13: R2602.1 16.68,83.03 16.19,82.55 v2(15.81,82.55) 15.68,82.55 v1(15.18,82.04)
LPMODE2: length 101
  SIG2 w0.152: v1(30.92,105.15) 30.67,105.15 29.65,104.14 26.23,104.14 19.18,97.09 16.64,97.09 15.05,95.5 15.05,92.58 9.59,87.12 9.59,75.56 9.6,75.55 9.6,66.94 4,61.34 4,57.91 8.95,52.96 9.46,52.96 10.1,52.32 10.1,49.73 11.39,48.44 22.97,48.44 25.21,50.67 25.84,50.67 v1(26.35,50.16)
  SIG9 w0.155: YJ22.D31 25.3,57.21 25.97,56.54 25.97,53.78 25.59,53.4 25.59,53.16 25.6,53.16 25.6,52.91 25.97,52.54 25.97,50.54 v1(26.35,50.16)
  BOTTOM w0.13: R2618.1 v1(30.92,105.15) v2(30.37,104.59)
LPMODE3: length 24.3
  TOP w0.13: v1(18.22,84.58) 18.22,85.09 17.69,85.62 R2620.1
  SIG10 w0.155: YJ22.C31 25.3,67.43 20.57,72.16 20.57,77.4 18.99,78.99 18.08,78.99 17.72,79.36 17.72,84.07 v1(18.22,84.58)
LPMODE4: length 13.2
  TOP w0.13: v1(40.58,76.58) 40.32,76.83 R2597.1
  SIG3 w0.155: YJ21.C31 41.1,76.05 v1(40.58,76.58)
  BOTTOM w0.13: v2(40.7,77.34) 40.58,77.21 v1(40.58,76.58)
LPMODE5: length 27.5
  TOP w0.13: R2599.1 40.09,81.3 39.69,80.9 39.69,76.58 v1(40.58,75.69)
  SIG2 w0.152: YJ21.D31 41.1,59.54 40.48,60.16 40.48,60.59 40.86,60.97 40.86,61.29 40.52,61.64 40.52,64.63 40.86,64.97 40.86,65.29 40.47,65.68 40.47,66.18 41.97,67.69 41.97,74.29 v1(40.58,75.69)
  BOTTOM w0.13: v2(41.34,75.31) 40.96,75.69 v1(40.58,75.69)
LPMODE6: length 35.7
  TOP w0.13: R2619.1 v1(54.42,83.69)
  SIG9 w0.155: YJ22.B31 45.28,58.8 51.24,58.8 54.8,62.35 54.8,77.46 55.18,77.85 55.18,82.93 v1(54.42,83.69)
  BOTTOM w0.13: v1(54.42,83.69) 53.91,83.69 v2(53.66,83.44)
LPMODE7: length 26.7
  TOP w0.13: v1(53.53,85.09) 52.77,85.85 52.77,86.59 52.95,86.76 R2622.1
  SIG8 w0.155: v1(53.53,85.09) 53.91,84.71 53.91,79.37 51.78,77.24 51.78,74.7 50.86,73.78 50.86,72.38 YJ22.A31
  BOTTOM w0.13: v2(54.29,85.09) v1(53.53,85.09)
LPMODE8: length 13.4
  TOP w0.13: v1(71.44,76.25) 70.42,77.26 R2633.1
  SIG4 w0.155: v1(71.44,76.25) 70.52,75.33 70.52,67.24 YJ23.A31
LPMODE9: length 35.5
  SIG3 w0.155: YJ23.B31 69.1,59.54 68.48,60.16 68.48,60.58 68.86,60.96 68.86,61.29 68.52,61.64 68.52,64.63 68.86,64.97 68.86,65.29 68.47,65.68 68.47,66.88 69.41,67.82 69.41,82.55 70.68,83.82 70.68,86.61 v1(70.17,87.12)
  BOTTOM w0.13: v1(70.17,87.12) 70.29,86.99 70.29,86.1 v2(70.42,85.98) 70.93,85.47 70.93,83.82 70.83,83.72 R2635.1
LPMODE10: length 30.8
  SIG9 w0.155: YJ24.D31 72.9,58.42 72.9,60.61 72.52,60.99 72.52,61.27 72.93,61.68 72.93,64.58 72.52,64.99 72.52,65.27 73.06,65.81 73.06,66.56 73.43,66.93 73.43,73.91 74.87,75.35 74.87,81.02 v1(74.23,81.66)
  BOTTOM w0.13: v2(73.6,85.85) 72.96,85.21 72.96,84.22 R2657.1 73.6,83.59 73.6,82.8 74.23,82.17 v1(74.23,81.66)
LPMODE11: length 12.9
  SIG9 w0.155: YJ24.C31 72.3,66.39 72.92,67.01 72.92,74.89 v1(72.45,75.36)
  BOTTOM w0.13: R2659.1 73.47,76.71 v2(73.34,76.58) 72.77,76 72.77,75.67 v1(72.45,75.36)
LPMODE12: length 14.3
  TOP w0.13: R2640.1 83.76,76.71 84.14,76.32 v1(84.9,76.32)
  SIG3 w0.155: YJ23.C31 88.1,71.6 85.53,74.17 85.53,75.69 v1(84.9,76.32)
LPMODE13: length 28.9
  SIG2 w0.152: v1(84.77,80.39) 84.04,79.65 84.04,73.63 87.47,70.2 87.47,65.68 87.86,65.29 87.86,64.97 87.52,64.63 87.52,61.64 87.86,61.29 87.86,60.97 87.48,60.59 87.48,60.16 88.1,59.54 YJ23.D31
  BOTTOM w0.13: R2642.1 83.76,83.31 83.88,83.18 v2(83.88,82.29) 83.88,81.28 v1(84.77,80.39)
LPMODE14: length 28.4
  SIG8 w0.155: v1(96.71,71.88) 97.98,70.61 97.98,60.96 95.95,58.93 92.41,58.93 YJ24.B31
  BOTTOM w0.13: v1(96.71,71.88) 94.81,73.78 94.81,75.94 94.68,76.07 v2(94.68,77.34) 93.92,77.34 93.28,77.98 R2658.1
LPMODE15: length 14.5
  SIG10 w0.155: v1(86.04,75.44) 87.19,74.29 87.19,71.37 91.3,67.26 YJ24.A31
  BOTTOM w0.13: R2660.1 v2(86.8,76.58) 86.8,76.2 v1(86.04,75.44)
LPMODE16: length 21.2
  TOP w0.13: v1(117.39,74.42) 117.39,75.92 118.68,77.21 118.68,78.48 119.06,78.86 119.06,80.9 120.21,82.04 R2679.1
  SIG1 w0.16: v1(117.39,74.42) 116.1,73.13 YJ25.A31
  BOTTOM w0.13: v2(117.41,76.05) 117.39,76.02 v1(117.39,74.42)
LPMODE17: length 28.7
  SIG3 w0.155: YJ25.B31 116.1,59.54 115.48,60.16 115.48,60.59 115.86,60.97 115.86,61.29 115.52,61.64 115.52,64.63 115.8,64.91 115.86,64.97 115.86,65.28 115.47,65.67 115.47,66.4 117.39,68.32 v1(117.39,73.53)
  BOTTOM w0.13: v1(117.39,73.53) 118.68,74.83 v2(118.68,75.31) 118.68,78.18 118.94,78.44 118.94,80.26 119.96,81.28 119.96,83.06 120.21,83.31 R2681.1
LPMODE18: length 30.6
  SIG9 w0.155: v1(123.31,81.28) 122.72,80.69 122.72,79.12 122.59,78.99 121.73,78.99 120.46,77.72 120.46,71.37 117.53,68.44 117.53,65.68 117.12,65.27 117.12,64.99 117.5,64.61 117.5,63.06 117.92,62.64 117.92,61.61 118.26,61.27 118.26,60.95 117.92,60.61 117.92,59.2 YJ26.D31
  BOTTOM w0.13: v1(123.31,81.28) 123,81.58 v2(123,82.29) 122.77,82.52 122.77,83.23 R2697.1
LPMODE19: length 14.1
  SIG9 w0.155: YJ26.C31 119.3,67.67 121.96,70.33 v1(121.96,73.68)
  BOTTOM w0.13: R2699.1 123.25,77.21 123.36,77.11 v2(123.36,76.25) 123.36,74.61 122.43,73.68 v1(121.96,73.68)
LPMODE20: length 12.8
  TOP w0.13: R2678.1 133.54,74.91 133.91,74.55 133.91,72.66 v1(134.68,71.88)
  SIG3 w0.155: v1(134.68,71.88) 135.19,71.37 135.19,66.41 135.1,66.32 YJ25.C31
LPMODE21: length 28.6
  SIG2 w0.152: YJ25.D31 135.1,59.54 134.48,60.16 134.48,60.59 134.86,60.97 134.86,61.29 134.52,61.64 134.52,64.63 134.86,64.97 134.86,65.29 134.47,65.68 134.47,66.46 134.18,66.75 134.18,72.39 v1(134.68,72.9)
  BOTTOM w0.13: v1(134.68,72.9) 133.88,73.7 133.88,74.34 133.46,74.75 133.34,74.75 132.4,75.69 132.4,80.01 132.78,80.39 132.78,81.53 133.41,82.17 v2(133.41,82.62) 133.54,82.75 R2680.1
LPMODE22: length 29.8
  SIG8 w0.155: v1(137.35,82.14) 137.88,82.14 140.78,79.25 140.78,68.32 138.93,66.47 138.93,65.65 138.9,65.62 138.89,65.62 138.52,65.25 138.52,64.99 138.93,64.58 138.93,61.68 138.52,61.27 138.52,60.99 138.9,60.61 138.9,58.42 YJ26.B31
  BOTTOM w0.13: R2698.1 v2(136.59,82.62) 136.59,82.6 137.05,82.14 v1(137.35,82.14)
LPMODE23: length 15.8
  SIG10 w0.155: YJ26.A31 138.3,70.34 v1(138.87,70.91)
  BOTTOM w0.13: R2700.1 136.94,77.87 137.1,77.72 137.1,76.83 v2(136.84,76.58) 136.08,75.82 136.08,75.18 135.83,74.93 135.19,74.93 135.06,74.8 135.06,74.29 138.44,70.91 v1(138.87,70.91)
LPMODE24: length 14.1
  TOP w0.13: R2715.1 164.4,77.09 v1(165.16,76.32)
  SIG3 w0.155: v1(165.16,76.32) 163.69,74.85 163.69,66.41 YJ27.A31
  BOTTOM w0.13: v2(164.4,76.58) 164.91,76.58 v1(165.16,76.32)
LPMODE25: length 28.7
  SIG3 w0.155: YJ27.B31 163.1,59.54 162.48,60.16 162.48,60.58 162.86,60.96 162.86,61.29 162.52,61.64 162.52,64.62 162.86,64.96 162.86,65.29 162.47,65.68 162.47,66.02 163.12,66.67 163.12,77.2 164.78,78.86 164.78,81.53 v1(165.42,82.17)
  BOTTOM w0.13: v1(165.42,82.17) 164.99,82.17 v2(164.53,82.62) 164.4,82.75 R2717.1
LPMODE26: length 27.6
  SIG9 w0.155: YJ28.D31 166.9,58.42 166.9,60.61 166.52,60.99 166.52,61.27 166.93,61.68 166.93,64.57 166.52,64.98 166.52,65.27 166.86,65.61 166.86,66.74 167.28,67.16 167.28,80.47 v1(168.21,81.4)
  BOTTOM w0.13: v1(168.21,81.4) 167.58,82.04 v2(167.58,82.29) R2737.1
LPMODE27: length 14.5
  SIG7 w0.155: YJ28.C31 166.3,69.09 165.8,69.59 165.8,73.53 v1(166.81,74.55)
  BOTTOM w0.13: R2739.1 166.03,78.84 165.93,78.74 v2(165.93,76.58) 165.93,75.44 v1(166.81,74.55)
LPMODE28: length 13.9
  TOP w0.13: v1(178.75,76.32) 177.74,77.34 R2720.1
  SIG3 w0.155: YJ27.C31 182.1,71.45 179.26,74.29 179.26,75.82 v1(178.75,76.32)
LPMODE29: length 29.4
  SIG2 w0.152: v1(178.75,83.06) 177.89,82.19 177.89,73.66 178.68,72.86 178.68,71.81 181.47,69.03 181.47,65.68 181.86,65.29 181.86,64.96 181.52,64.62 181.52,61.61 181.86,61.27 181.86,60.97 181.48,60.59 181.48,60.16 182.1,59.54 YJ27.D31
  BOTTOM w0.13: R2721.1 177.74,83.44 178.12,83.06 v1(178.75,83.06)
LPMODE30: length 28.9
  SIG8 w0.155: YJ28.B31 185.9,58.42 185.9,60.61 185.52,60.99 185.52,61.27 185.93,61.68 185.93,64.58 185.52,64.99 185.52,65.27 185.93,65.68 185.93,74.74 184.09,76.58 184.09,79.5 v1(181.42,82.17)
  BOTTOM w0.13: R2738.1 180.78,82.8 v1(181.42,82.17)
LPMODE31: length 14
  SIG6 w0.155: YJ28.A31 185.3,71.56 v1(181.42,75.44)
  BOTTOM w0.13: v1(181.42,75.44) 180.66,76.2 v2(180.66,76.58) 180.78,76.71 R2740.1
LPMODE32: length 21
  TOP w0.13: R2751.1 214.19,83.18 214.31,83.06 v1(215.2,83.06)
  SIG3 w0.155: v1(215.2,83.06) 214.44,82.29 214.44,76.58 213.55,75.69 213.55,70.86 210.1,67.41 YJ29.A31
LPMODE33: length 29.4
  SIG3 w0.155: v1(213.42,82.17) 212.79,81.53 212.79,76.2 212.92,76.07 212.92,70.99 209.47,67.54 209.47,65.68 209.86,65.29 209.86,64.97 209.8,64.91 209.52,64.63 209.52,61.64 209.86,61.29 209.86,60.97 209.48,60.59 209.48,60.16 210.1,59.54 YJ29.B31
  BOTTOM w0.13: v1(213.42,82.17) 213.83,82.57 v2(214.44,82.57) 214.44,83.46 R2761.1
LPMODE34: length 28.7
  TOP w0.13: v1(217.87,82.29) 217.23,82.93 R2779.1
  SIG9 w0.155: v1(217.87,82.29) 217.11,81.53 217.11,73.91 216.8,73.61 216.8,69.67 213.93,66.8 213.93,65.68 213.52,65.27 213.52,64.99 213.93,64.58 213.93,61.68 213.52,61.27 213.52,60.98 213.9,60.6 213.9,58.42 YJ30.D31
LPMODE35: length 13.9
  SIG8 w0.155: v1(216.22,74.55) 216.47,74.29 216.47,70.37 213.3,67.2 YJ30.C31
  BOTTOM w0.13: v1(216.22,74.55) v2(217.23,75.56) R2780.1
LPMODE36: length 14.2
  TOP w0.13: R2759.1 227.52,75.56 v1(226.76,74.8)
  SIG4 w0.155: YJ29.C31 229.1,72.46 v1(226.76,74.8)
  BOTTOM w0.13: v1(226.76,74.8) 226.63,74.93 v2(226,74.93)
LPMODE37: length 28.2
  SIG2 w0.152: v1(227.27,82.29) 227.7,81.86 227.7,72.65 228.47,71.88 228.47,65.68 228.86,65.29 228.86,64.97 228.52,64.63 228.52,61.64 228.86,61.29 228.86,60.97 228.48,60.59 228.48,60.16 229.1,59.54 YJ29.D31
  BOTTOM w0.13: v2(227.39,81.53) 227.27,81.66 v1(227.27,82.29) 227.27,83.46 R2760.1
LPMODE38: length 28.9
  TOP w0.13: v1(229.55,82.17) 230.57,83.18 R2775.1
  SIG8 w0.155: v1(229.55,82.17) 230.44,81.28 230.44,77.47 231.08,76.83 231.46,76.83 232.93,75.36 232.93,65.66 232.52,65.25 232.52,64.99 232.93,64.58 232.93,61.68 232.52,61.27 232.52,60.99 232.9,60.61 232.9,58.42 YJ30.B31
LPMODE39: length 13.5
  SIG8 w0.155: v1(231.33,75.31) 232.3,74.34 YJ30.A31
  BOTTOM w0.13: R2776.1 230.57,77.47 230.82,77.21 230.82,76.2 230.44,75.82 v2(230.44,75.44) 230.57,75.31 v1(231.33,75.31)
LPMODE40: length 14.5
  TOP w0.13: v1(257.62,76.2) 257.11,76.71 257.11,77.47 257.52,77.87 R2798.1
  SIG3 w0.155: YJ31.A31 257.1,75.68 v1(257.62,76.2)
  BOTTOM w0.13: v2(256.98,75.44) 257.62,76.07 v1(257.62,76.2)
LPMODE41: length 28.2
  SIG3 w0.155: v1(257.62,82.29) 256.98,81.66 256.98,77.34 256.47,76.82 256.47,65.68 256.86,65.29 256.86,64.97 256.52,64.63 256.52,61.64 256.86,61.29 256.86,60.97 256.48,60.59 256.48,60.16 257.1,59.54 YJ31.B31
  BOTTOM w0.13: v1(257.62,82.29) 258.38,82.29 v2(258.64,82.55) 258.64,83.46 R2802.1
LPMODE42: length 28
  SIG9 w0.155: YJ32.D31 260.9,58.42 260.9,60.61 260.52,60.99 260.52,61.27 260.93,61.68 260.93,64.58 260.52,64.99 260.52,65.27 260.91,65.66 260.91,66.66 261.43,67.18 261.43,80.26 v1(260.41,81.28)
  BOTTOM w0.13: v1(260.41,81.28) 260.87,81.73 260.87,83.56 260.72,83.72 R2817.1
LPMODE43: length 13.2
  SIG9 w0.155: v1(260.41,75.94) 260.92,75.44 260.92,67.31 260.3,66.69 YJ32.C31
  BOTTOM w0.13: R2819.1 v2(261.43,76.58) 260.79,75.94 v1(260.41,75.94)
LPMODE44: length 18.3
  TOP w0.13: R2797.1 271.59,77.47 v1(272.73,76.32)
  SIG1 w0.16: v1(272.73,76.32) 273.24,76.83 273.24,77.47 273.49,77.72 274,77.72 274.26,77.47 274.26,73.66 276.1,71.81 YJ31.C31
  BOTTOM w0.13: v2(271.97,75.31) 272.73,76.07 v1(272.73,76.32)
LPMODE45: length 28.7
  SIG2 w0.152: v1(271.21,82.42) 271.89,81.73 271.89,73.73 275.47,70.16 275.47,65.66 275.86,65.27 275.86,64.97 275.52,64.63 275.52,61.64 275.86,61.29 275.86,60.97 275.48,60.59 275.48,60.16 276.1,59.54 YJ31.D31
  BOTTOM w0.13: R2799.1 271.49,83.49 271.49,82.7 v1(271.21,82.42)
LPMODE46: length 29.8
  SIG8 w0.155: YJ32.B31 279.9,58.42 279.9,60.61 279.52,60.99 279.52,61.27 279.93,61.68 279.93,64.58 279.52,64.99 279.52,65.27 279.93,65.68 279.93,68.26 274.89,73.29 274.89,80.13 v1(273.75,81.28)
  BOTTOM w0.13: R2818.1 273.24,83.21 273.24,81.79 v1(273.75,81.28)
LPMODE47: length 14.5
  SIG6 w0.155: YJ32.A31 275.91,69.21 275.91,72.51 274.76,73.66 274.76,74.83 v1(275.4,75.46)
  BOTTOM w0.13: v1(275.4,75.46) 275.4,76.2 v2(275.02,76.58) 274.76,76.83 R2822.1
LPMODE48: length 19.4
  TOP w0.13: v1(307.15,81.15) 307.3,81.3 R2832.1
  SIG4 w0.155: v1(307.15,81.15) 306.39,80.39 306.39,74.93 305.88,74.42 305.88,67.6 YJ33.A31
  BOTTOM w0.13: v2(307.91,82.8) 307.91,82.17 307.15,81.4 v1(307.15,81.15)
LPMODE49: length 27.9
  SIG3 w0.155: YJ33.B31 304.1,59.54 303.48,60.16 303.48,60.59 303.86,60.97 303.86,61.29 303.52,61.64 303.52,64.63 303.86,64.97 303.86,65.29 303.47,65.68 303.47,69.19 302.2,70.46 v1(302.2,76.2)
  BOTTOM w0.13: v1(302.2,76.2) 300.57,77.82 v2(300.57,80.01) R2834.1
LPMODE50: length 22.4
  TOP w0.13: R2857.1 v1(310.2,77.21)
  SIG9 w0.155: v1(310.2,77.21) 310.83,76.58 310.83,75.82 310.32,75.31 310.32,74.17 307.93,71.77 307.93,65.68 307.66,65.41 307.66,65.39 307.6,65.33 307.6,64.91 307.93,64.58 307.93,61.68 307.52,61.27 307.52,60.98 307.9,60.6 307.9,58.42 YJ34.D31
LPMODE51: length 19
  SIG8 w0.155: YJ34.C31 307.3,72.92 309.56,75.18 309.56,77.47 309.82,77.72 310.45,77.72 310.83,77.34 310.83,76.83 v1(311.34,76.32)
  BOTTOM w0.13: v2(312.48,75.56) 312.1,75.56 v1(311.34,76.32) 311.85,76.83 311.85,77.72 311.7,77.87 R2859.1
LPMODE52: length 13.7
  TOP w0.13: v1(324.17,76.32) 323.79,76.32 322.9,77.21 R2840.1
  SIG1 w0.16: YJ33.C31 324.68,67.4 324.68,75.82 v1(324.17,76.32)
LPMODE53: length 28.2
  SIG2 w0.152: YJ33.D31 323.1,59.54 322.48,60.16 322.48,60.59 322.86,60.97 322.86,61.29 322.52,61.64 322.52,64.62 322.86,64.96 322.86,65.27 322.47,65.66 322.47,66.24 323.23,67 323.23,78.18 323.41,78.36 323.41,81.4 v1(322.64,82.17)
  BOTTOM w0.13: v1(322.64,82.17) 323.15,82.17 v2(323.41,82.42) 323.41,83.46 R2842.1
LPMODE54: length 31.5
  SIG8 w0.155: YJ34.B31 326.9,58.42 326.9,60.61 326.52,60.99 326.52,61.27 326.93,61.68 326.93,64.58 326.52,64.99 326.52,65.25 326.6,65.33 326.6,65.33 326.89,65.62 326.89,65.62 326.93,65.66 326.93,66.13 327.34,66.55 327.34,86.1 v1(326.33,87.12)
  BOTTOM w0.13: v1(326.33,87.12) 326.2,87.25 R2858.1
LPMODE55: length 12.9
  SIG9 w0.155: YJ34.A31 326.3,73.43 v1(325.18,74.55)
  BOTTOM w0.13: R2860.1 325.95,77.62 v2(325.95,76.45) 325.95,75.31 v1(325.18,74.55)
LPMODE56: length 15.2
  SIG2 w0.152: v1(345.63,74.67) 348.49,71.82 348.49,70.42 351.1,67.81 YJ35.A31
  BOTTOM w0.13: R2879.1 343.6,77.09 v2(344.11,76.58) 344.11,76.2 v1(345.63,74.67)
LPMODE57: length 22.9
  TOP w0.13: R2881.1 v1(345.63,77.21)
  SIG3 w0.155: YJ35.B31 351.1,59.54 350.48,60.16 350.48,60.59 350.86,60.97 350.86,61.29 350.52,61.64 350.52,64.63 350.8,64.91 350.86,64.97 350.86,65.27 350.51,65.62 350.5,65.62 350.47,65.66 350.47,67.18 347.79,69.86 347.79,73.4 346.14,75.05 346.14,76.71 v1(345.63,77.21)
LPMODE58: length 27.9
  SIG9 w0.155: YJ36.D31 354.9,58.42 354.9,60.61 354.52,60.99 354.52,61.27 354.93,61.68 354.93,64.58 354.52,64.99 354.52,65.27 354.93,65.68 354.93,66.46 354.61,66.77 354.61,72.93 v1(354.01,73.53)
  BOTTOM w0.13: v1(354.01,73.53) 353.5,74.04 353.5,74.55 354.27,75.31 v2(354.52,75.31) 355.41,75.31 357.31,77.21 357.31,79.62 355.79,81.15 R2897.1
LPMODE59: length 19.3
  TOP w0.13: v1(354.01,72.01) 354.52,72.01 358.2,75.69 358.2,80.64 357.82,81.02 R2899.1
  SIG9 w0.155: v1(354.01,72.01) 353.25,72.01 352.74,71.5 352.74,67.98 354.3,66.42 YJ36.C31
LPMODE60: length 14.3
  TOP w0.13: v1(371.92,76.96) 372.3,77.34 R2878.1
  SIG1 w0.16: v1(371.92,76.96) 372.43,76.45 372.43,69.47 370.1,67.14 YJ35.C31
  BOTTOM w0.13: v1(371.92,76.96) 371.79,76.83 v2(371.79,76.07)
LPMODE61: length 30.4
  TOP w0.13: R2880.1 375.6,77.09 375.98,76.71 375.98,75.82 373.06,72.9 373.06,70.36 372.86,70.15 369.33,70.15 368.94,70.54 368.94,71.35 v1(368.47,71.82)
  SIG2 w0.152: v1(368.47,71.82) 367.98,71.33 367.98,68.85 369.47,67.37 369.47,65.66 369.86,65.27 369.86,64.97 369.52,64.63 369.52,61.61 369.86,61.27 369.86,60.96 369.48,60.58 369.48,59.71 370.1,59.09 YJ35.D31
LPMODE62: length 23.6
  SIG8 w0.155: YJ36.B31 373.9,58.42 373.9,60.61 373.52,60.99 373.52,61.27 373.93,61.68 373.93,64.58 373.6,64.91 373.6,64.92 373.52,65 373.52,65.27 373.93,65.68 373.93,66.78 v1(378.02,70.86)
  BOTTOM w0.13: R2898.1 378.17,77.87 378.02,77.72 378.02,76.45 v2(378.52,75.94) 378.52,71.37 v1(378.02,70.86)
LPMODE63: length 14.8
  TOP w0.13: R2902.1 376.62,76.96 377.13,76.45 377.13,75.96 376.87,75.7 v1(376.87,75.26)
  SIG8 w0.155: YJ36.A31 373.3,67.04 376.87,70.61 v1(376.87,75.26)
  BOTTOM w0.13: v2(375.98,75.44) 376.16,75.26 v1(376.87,75.26)
MAC_BCM56970_RST#: length 284.7
  TOP w0.13: R17.1 177.71,95.5 177.85,95.36 v1(178.36,95.36) ; U1.K52 v1(178.55,115.34)
  SIG7 w0.155: v1(178.55,115.34) 178.01,114.81 176.26,114.81 176.03,114.58 176.03,104.59 173.55,102.11 173.55,97.79 175.97,95.36 v1(178.36,95.36)
  SIG10 w0.155: v1(18.22,173.48) 18.22,173.67 21.34,176.78 24.89,176.78 25.59,177.48 27.56,177.48 32.06,181.98 35.5,181.98 40.83,187.31 40.83,188.44 56.88,204.49 62.41,204.49 64.34,202.56 71.18,202.56 71.39,202.35 79.94,202.35 80.13,202.16 109.06,202.16 119.76,191.46 119.76,133.8 139.68,113.87 143.48,113.87 145.1,112.26 146.2,112.26 149.5,108.96 151.46,108.96 154.52,105.9 157.13,105.9 159.96,103.07 160.74,103.07 161.16,102.65 163.33,102.65 165.41,100.58 166.95,100.58 167.3,100.23 169.78,100.23 171.08,98.93 174.43,98.93 178,95.36 v1(178.36,95.36)
  BOTTOM w0.13: R3271.1 17.87,170.66 17.72,170.81 17.72,171.83 17.46,172.08 v2(17.46,172.21) 17.46,172.72 v1(18.22,173.48)
MAC_GND_SENSE: length 246.1
  TOP w0.254: v1(367.73,179.84) 368,179.58 376.78,179.58 378.74,177.61 378.74,177.15 R2196.1
  TOP w0.279: U1.AR33 v1(198.55,141.34)
  SIG4 w0.254: v1(198.69,175.12) 199.22,175.64 199.22,183.53 202.25,186.56 211.04,186.56 211.41,186.93 232.56,186.93 238.04,192.4 262.54,192.4 265.59,189.35 322.29,189.35 327.25,194.31 360.36,194.31 365.7,188.97 365.7,184.37 368.62,181.45 368.62,179.83 368.36,179.58 368,179.58 v1(367.73,179.84)
  BOTTOM w0.254: v1(198.55,141.34) 197.96,141.94 197.96,162 197.45,162.51 197.45,165.48 197.04,165.89 197.04,169.57 196.53,170.08 196.53,173.99 196.81,174.27 v2(197.42,174.27) 197.42,174.88 197.93,175.38 198.43,175.38 v1(198.69,175.12)
MAC_JTAG_TCK: length 284.3
  TOP w0.13: U1.T33 v1(198.55,121.34)
  SIG10 w0.155: v1(39.05,194.56) 40.48,194.56 54.67,208.75 65.78,208.75 67.52,207.02 71.78,207.02 72.26,206.53 110.5,206.53 123.33,193.7 123.33,143.31 140.59,126.04 141.86,126.04 144.59,123.31 144.59,119.31 145.38,118.52 145.83,118.52 148.53,115.82 148.53,115.44 149.16,114.81 151.7,114.81 154.62,111.88 160.72,111.88 162.24,110.36 162.24,108.08 163.33,106.99 164.47,106.99 166.64,104.82 168.04,104.82 168.66,104.2 182.7,104.2 183.01,103.89 194.63,103.89 197.04,106.3 197.04,116.53 197.42,116.9 197.42,117.68 197.11,117.99 197.11,118.61 197.73,119.23 197.73,120.52 v1(198.55,121.34)
  BOTTOM w0.13: R3216.2 27.24,179.07 27.62,178.69 28.64,178.69 32.19,182.24 32.19,183.64 33.21,184.66 37.02,184.66 37.66,185.29 37.66,193.16 v2(38.1,193.61) v1(39.05,194.56) ; v1(198.55,121.34) 197.85,120.65 R3132.2
MAC_JTAG_TDI: length 301.6
  TOP w0.13: R2043.1 v1(178.12,97.15) ; U1.V34 v1(196.55,123.34)
  SIG7 w0.155: v1(196.55,123.34) 196.55,122.59 195.82,121.87 195.21,121.87 194.12,120.77 180.66,120.77 179.01,119.12 179.01,115.01 177.91,113.92 177.36,113.92 177.03,113.59 177.03,103.63 176.21,102.81 176.21,97.92 177.1,97.03 177.99,97.03 v1(178.12,97.15)
  SIG10 w0.155: v1(178.12,97.15) 177.87,97.4 177.87,100.2 176.81,101.25 170.93,101.25 170.46,101.72 165.81,101.72 163.8,103.73 161.94,103.73 160.42,105.26 159.8,105.26 157.91,107.14 154.79,107.14 151.32,110.61 150.72,110.61 150.16,111.17 148.73,111.17 145.86,114.04 144.81,114.04 143.71,115.15 141.07,115.15 120.78,135.44 120.78,191.96 109.37,203.37 71.82,203.37 70.72,204.47 65.63,204.47 63.94,206.15 57.1,206.15 37.83,186.88 37.83,186.1 34.73,183 29.15,183 25.59,179.45 25.59,178.56 24.7,177.67 21.53,177.67 20.51,178.69 20.51,179.45 20.26,179.7 19.62,179.7 v1(18.86,178.94)
  BOTTOM w0.13: v1(178.12,97.15) v2(177.36,97.15) ; v1(18.86,178.94) R3198.2
MAC_JTAG_TDO: length 283.8
  TOP w0.13: U1.V33 v1(198.55,123.34)
  SIG10 w0.155: v1(198.55,123.34) 197.01,121.81 197.01,119.13 196.64,118.76 196.64,117.99 197.04,117.59 197.04,116.99 196.02,115.97 196.02,105.9 194.94,104.82 183.63,104.82 183.47,104.97 169.07,104.97 168.12,105.92 166.18,105.92 164.53,107.57 163.74,107.57 163,108.3 163,110.36 160.58,112.78 154.74,112.78 151.96,115.57 150.05,115.57 145.73,119.89 145.73,124.08 143,126.81 140.97,126.81 123.96,143.81 123.96,193.98 110.77,207.17 72.53,207.17 72.04,207.66 67.78,207.66 66.05,209.39 52.48,209.39 48.96,205.86 42.35,205.86 35.5,199.01 28.38,199.01 23.43,194.05 23.43,192.28 v1(21.91,190.75)
  BOTTOM w0.13: v2(21.65,189.99) 21.65,190.5 v1(21.91,190.75) 21.91,190.88 22.44,191.41 R3225.2 22.8,190.75 22.54,190.49 U120.11
MAC_JTAG_TMS: length 305.5
  TOP w0.13: v1(178.37,96.26) 178.5,96.39 178.88,96.39 179.03,96.24 R3133.1 ; U1.R18 v1(213.55,120.34)
  SIG7 w0.155: v1(213.55,120.34) 212.1,121.79 199.33,121.79 199.07,121.54 199.07,120.73 196.02,117.68 196.02,117.06 195.79,116.82 184.25,116.82 183.99,116.57 183.99,112.15 183.67,111.83 182.26,111.83 182,111.58 182,98.24 180.78,97.03 179.13,97.03 v1(178.37,96.26)
  SIG10 w0.155: v1(178.37,96.26) 178.12,96.26 177.23,97.15 177.23,99.4 176.46,100.17 170.92,100.17 169.88,101.21 165.7,101.21 163.62,103.29 161.45,103.29 160.53,104.21 159.91,104.21 157.44,106.68 154.71,106.68 151.28,110.11 149.25,110.11 146.33,113.03 145.22,113.03 143.7,114.55 140.14,114.55 120.39,134.3 120.39,191.8 109.38,202.82 80.38,202.82 80.2,202.99 71.66,202.99 71.45,203.2 65.34,203.2 63.41,205.13 56.62,205.13 38.21,186.73 38.21,185.6 35.24,182.62 30.8,182.62 27.24,179.07 v1(26.1,179.07)
  BOTTOM w0.13: v2(27.11,178.31) 26.86,178.31 v1(26.1,179.07) R3218.2
MAC_JTAG_TRST: length 291.5
  TOP w0.13: U1.U33 v1(198.55,122.34) ; v1(180.47,98.68) 180,99.15 R2046.2 R2045.1
  SIG7 w0.155: v1(180.47,98.68) 179.76,99.39 179.76,101.65 180.02,101.92 180.02,112.42 180.45,112.85 182.67,112.85 183.01,113.18 183.01,117.52 183.32,117.83 194.79,117.83 195.1,118.14 195.1,118.61 195.4,118.92 195.87,118.92 196.02,119.07 196.02,119.69 196.8,120.47 197.73,120.47 198.06,120.79 198.06,121.85 v1(198.55,122.34)
  SIG10 w0.155: v1(180.47,98.68) 179.9,99.25 179.9,101.42 178.61,102.72 168.67,102.72 168.32,102.36 166.16,102.36 163.87,104.65 162.73,104.65 161.1,106.27 159.77,106.27 156.95,109.09 153.79,109.09 152.02,110.86 152.02,111.31 151.7,111.63 150.94,111.63 150.43,112.14 148.88,112.14 146.29,114.73 145.2,114.73 142.42,117.52 142.42,119.11 121.41,140.11 121.41,192.23 109.63,204.01 72.08,204.01 70.99,205.1 65.89,205.1 64.21,206.79 56.6,206.79 34.53,184.72 33.66,184.72 32.64,183.7 28.4,183.7 24.66,179.96 24.66,179.36 v1(24.96,179.07)
  BOTTOM w0.13: v2(25.84,178.31) 25.72,178.31 v1(24.96,179.07) R3219.2
MAC_MC_RDN0: length 16.4
  TOP w0.097: U1.BW34 arc(196.98,165) 196.83,165.06 196.8,165.06 arc(196.55,165.16) 196.45,165.41 196.45,172.24 arc(196.44,172.28) 196.42,172.32 arc(196.39,172.35) 196.39,172.39
  TOP w0.107: C3421.2 192.79,179.28 arc(192.9,179.11) 192.94,178.92 192.94,178.67 arc(193.06,178.05) 193.41,177.53 195.32,175.62 arc(195.44,175.45) 195.48,175.24 195.48,174.06 arc(195.56,173.63) 195.8,173.28 196.31,172.77 arc(196.37,172.68) 196.39,172.58 196.39,172.39
MAC_MC_RDN2: length 13.2
  TOP w0.107: U1.BU33 v1(198.55,163.34)
  BOTTOM w0.097: 199.71,170.25 arc(199.72,170.21) 199.74,170.18 arc(199.76,170.14) 199.77,170.1 199.77,169.95 arc(199.73,169.75) 199.62,169.58 199.32,169.28 arc(199.04,168.87) 198.95,168.38 198.95,167.32 arc(198.92,167.18) 198.84,167.05 arc(198.71,166.97) 198.57,166.94 198.36,166.94 arc(198.07,166.82) 197.95,166.53 197.95,163.92 arc(197.97,163.79) 198.05,163.68 arc(198.16,163.6) 198.29,163.57 198.32,163.57 arc(198.48,163.51) v1(198.55,163.34)
  BOTTOM w0.107: C3423.2 200.07,173.91 arc(200.1,173.86) 200.11,173.79 200.11,173.46 arc(200.11,173.45) 200.11,173.43 arc(200.09,173.37) 200.05,173.32 199.86,173.13 arc(199.75,172.95) 199.71,172.75 199.71,170.25
MAC_MC_RDP0: length 16.4
  TOP w0.097: U1.BY34 197.05,165.52 arc(196.97,165.34) 196.8,165.27 arc(196.7,165.31) 196.65,165.41 196.65,172.24 arc(196.66,172.28) 196.69,172.32 arc(196.71,172.35) 196.72,172.39
  TOP w0.107: 196.72,172.39 196.72,172.58 arc(196.67,172.81) 196.54,173 196.47,173.08 196.03,173.51 arc(195.87,173.76) 195.81,174.06 195.81,175.24 arc(195.74,175.57) 195.56,175.85 193.64,177.77 arc(193.37,178.18) 193.27,178.67 arc(193.35,179.1) 193.6,179.46 C3422.2
MAC_MC_RDP2: length 13.2
  TOP w0.107: U1.BV33 v1(198.55,164.34)
  BOTTOM w0.097: v1(198.55,164.34) 198.55,163.93 arc(198.5,163.82) 198.39,163.78 198.29,163.78 arc(198.24,163.79) 198.19,163.82 arc(198.16,163.87) 198.15,163.92 198.15,166.53 arc(198.21,166.68) 198.36,166.74 198.57,166.74 arc(198.79,166.78) 198.98,166.91 arc(199.11,167.1) 199.15,167.32 199.15,168.38 arc(199.23,168.79) 199.46,169.14 199.76,169.44 arc(199.92,169.67) 199.97,169.95 199.97,170.1 arc(199.98,170.14) 200.01,170.18 arc(200.03,170.21) 200.04,170.25
  BOTTOM w0.107: 200.04,170.25 200.04,172.75 arc(200.05,172.83) 200.1,172.89 200.29,173.08 arc(200.39,173.22) 200.44,173.39 arc(200.53,173.82) 200.77,174.19 C3424.2
MAC_PCIE_INT#: length 356.4
  TOP w0.13: R23.1 v1(229.43,99.18) ; U123.B1 17.4,165.66 16.65,165.66 v1(16.09,165.1) ; U1.M15 v1(216.55,117.34)
  SIG7 w0.155: v1(216.55,117.34) 217.02,116.87 217.7,116.87 218,116.58 218,116.08 218.25,115.82 219.77,115.82 220.03,115.57 220.03,115.06 220.28,114.81 222.69,114.81 223.05,114.45 223.05,106.19 228.41,100.84 228.79,100.84 229.43,100.2 v1(229.43,99.18)
  SIG10 w0.155: v1(229.43,99.18) 228.92,98.68 215.2,98.68 214.44,97.91 214.06,97.91 212.16,96.01 207.45,96.01 205.8,97.66 189.55,97.66 187.26,99.95 185.23,99.95 181.75,103.42 168.29,103.42 167.67,104.04 166.43,104.04 164.31,106.17 163.22,106.17 161.48,107.91 161.48,110.11 160.46,111.12 154.37,111.12 151.83,113.66 150.94,113.66 150.56,114.04 148.89,114.04 147.2,115.74 147.2,116.16 145.76,117.6 144.84,117.6 143.93,118.51 143.93,122.84 141.42,125.35 140.27,125.35 122.69,142.93 122.69,192.79 114.55,200.92 114.55,201.48 110.15,205.89 72.01,205.89 71.52,206.38 67.25,206.38 65.52,208.11 55.05,208.11 38.19,191.26 25.34,191.26 14.8,180.72 14.8,174.62 13.91,173.73 13.91,167.28 v1(16.09,165.1)
  BOTTOM w0.13: v1(229.43,99.18) v2(230.19,99.18)
