# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N6023843: length 41.4
  TOP w0.107: U1.BK34 197,155.84 v4(196.55,156.29) ; C7.2 182.22,185.99 182.22,185.73 v1(182.51,185.44)
  SIG2 w0.102: v4(196.55,156.29) 196.55,155.89 196.49,155.83 196.13,155.83 196.01,155.94 194.67,155.94 194.14,156.46 194.14,158.7 193.91,158.93 192.39,158.93 192.15,159.17 192.15,173.51 192.22,173.58 192.22,173.61
  SIG2 w0.14: v1(182.51,185.44) 182.18,185.11 182.18,184.27 183.05,183.41 185.59,183.41 192.22,176.78 192.22,173.61
N6023847: length 41.5
  TOP w0.107: U1.BJ34 197.05,154.89 v4(196.55,155.39) ; C8.2 181.89,185.99 181.89,185.73 v1(181.6,185.44)
  SIG2 w0.102: v4(196.55,155.39) 196.31,155.63 196.04,155.63 195.93,155.74 194.58,155.74 193.95,156.38 193.95,158.62 193.83,158.74 192.3,158.74 191.96,159.08 191.96,173.51 191.89,173.58 191.89,173.61
  SIG2 w0.14: v1(181.6,185.44) 181.85,185.19 181.85,184.14 182.91,183.08 185.45,183.08 191.89,176.64 191.89,173.61
N6690559: length 2.8
  TOP w0.13: R16.1 255.21,171.83 255.33,171.96 U116.5
N6690593: length 2.7
  TOP w0.13: R15.1 U116.6
N7135035: length 8.1
  TOP w0.13: U1.AK51 v1(179.55,135.34)
  BOTTOM w0.13: R3111.2 183.35,139.19 183.1,138.94 180.4,138.94 180.02,138.55 180.02,135.82 v1(179.55,135.34)
N7135039: length 9.3
  TOP w0.13: U1.AL51 v1(179.55,136.34)
  BOTTOM w0.13: R3112.2 178.2,139.57 177.1,138.47 177.1,137.21 177.41,136.9 178.99,136.9 v1(179.55,136.34)
N16666084: length 5.4
  TOP w0.254: U134.1 56.87,139.05 57.09,138.83 57.09,137.01 58.1,135.99 C3799.1 R3607.2
N16666182: length 3.2
  TOP w0.254: U134.2 57.26,139.55 57.77,139.04 C3800.2 R3608.2
N16666238: length 3.2
  TOP w0.254: U134.4 57.78,140.55 58.28,140.05 C3802.1 R3612.2
N16666262: length 3.4
  TOP w0.254: C3801.2 R3613.2 58.18,142.09 57.15,141.05 U134.5
N16666338: length 19.1
  TOP w0.229: D435.28 65.7,133.2 65.19,133.7 v1(64.3,133.7)
  TOP w0.254: U134.10 53.39,139.05 53.23,138.88 53.23,138.5 v1(54.78,136.95)
  SIG8 w0.381: v1(54.78,136.95) 56.65,136.95 59.91,133.7 v1(64.3,133.7)
  BOTTOM w0.13: v2(63.56,133.47) 63.79,133.7 v1(64.3,133.7)
N16666350: length 18.6
  TOP w0.229: D436.28 65.88,143.36 65.47,143.76
  TOP w0.254: 53.1,142.19 52.97,142.06 52.97,141.45 53.37,141.05 U134.6
  TOP w0.381: 53.1,142.19 55.44,144.52 62.29,144.52 62.55,144.78 64.45,144.78 65.47,143.76
N16666382: length 3.7
  TOP w0.254: 53.03,140.55 U134.7
  TOP w0.381: R3610.1 R3609.2 52.13,141.07 52.65,140.55 53.03,140.55
N16666394: length 2.4
  TOP w0.254: R3611.1 52.18,139.8 52.44,140.05 U134.8
N16666626: length 2
  TOP w0.254: D435.24 67.88,135.2 67.62,135.46 C3813.1
N16666634: length 2
  TOP w0.254: C3813.2 66.73,134.49 66.93,134.7 D435.25
N16667636: length 2
  TOP w0.254: D436.24 67.32,145.36 67.06,145.62 C3814.1
N16667644: length 2
  TOP w0.254: D436.25 66.93,144.86 66.73,144.65 C3814.2
N16708373: length 2
  TOP w0.229: D435.5 71,130.4 70.68,130.07 X290.1
N16708525: length 7
  TOP w0.178: 380.96,165.2 380.7,165.46 U140.26
  TOP w0.254: R3673.2 R3674.2 384.01,162.13 C3947.1 382.87,162.33 380.96,164.23 380.96,165.2
N16709370: length 1.9
  TOP w0.203: X291.1 71,139.12 D436.5
N16768622: length 1.9
  TOP w0.229: D438.5 71,159.45 X293.1
N16768766: length 1.9
  TOP w0.229: D437.5 71,149.29 X292.1
N16768890: length 5.3
  TOP w0.254: R3614.2 C3822.1 58.13,156.31 57.82,156.62 57.82,158.42 56.87,159.37 U135.1
N16768906: length 3.2
  TOP w0.254: U135.2 57.13,159.87 57.65,159.36 C3823.2 R3615.2
N16768954: length 3.2
  TOP w0.254: U135.4 57.78,160.87 58.28,160.37 C3825.1 R3619.2
N16768986: length 3.4
  TOP w0.254: C3824.2 R3620.2 58.08,162.41 57.05,161.37 U135.5
N16769038: length 19
  TOP w0.229: v1(64.68,153.9) 65.06,153.52 D437.28
  TOP w0.254: v1(54.78,157.27) 53.23,158.82 53.23,159.2 53.39,159.37 U135.10
  SIG8 w0.381: v1(54.78,157.27) 58.15,153.9 v1(64.68,153.9)
  BOTTOM w0.13: v1(54.78,157.27) v2(54.78,156.49)
N16769050: length 18
  TOP w0.229: 64.94,163.8 65.29,163.8 65.42,163.68 D438.28
  TOP w0.254: 53.12,161.77 53.12,161.64 53.39,161.37 U135.6
  TOP w0.381: 53.12,161.77 53.12,162.41 55.44,164.72 63.54,164.72 64.45,163.8 64.94,163.8
N16769070: length 3.7
  TOP w0.254: 53.03,160.87 U135.7
  TOP w0.381: R3617.1 R3616.2 52.03,161.39 52.55,160.87 53.03,160.87
N16769094: length 2.4
  TOP w0.254: R3618.1 52.18,160.12 52.44,160.37 U135.8
N16769294: length 2
  TOP w0.254: C3836.1 67.06,155.78 67.32,155.52 D437.24
N16770006: length 2
  TOP w0.254: D438.24 67.32,165.68 67.06,165.94 C3837.1
N16770018: length 2
  TOP w0.254: C3837.2 66.73,164.97 66.93,165.18 D438.25
N16772539: length 1.9
  TOP w0.229: X295.1 71,179.77 D440.5
N16772683: length 1.9
  TOP w0.229: X294.1 71,169.61 D439.5
N16772807: length 5.2
  TOP w0.254: U136.1 56.84,179.69 57.85,178.69 57.85,177.11 58.33,176.63 C3845.1 R3621.2
N16772823: length 3.2
  TOP w0.254: U136.2 56.98,180.19 57.49,179.68 C3846.2 R3622.2
N16772871: length 3.2
  TOP w0.254: R3626.2 C3848.1 58.28,180.69 57.78,181.19 U136.4
N16772903: length 3.4
  TOP w0.254: C3847.2 R3627.2 58.18,182.73 57.15,181.69 U136.5
N16772955: length 19
  TOP w0.229: D439.28 65.01,173.84 v1(64.5,174.34)
  TOP w0.254: U136.10 53.39,179.69 53.23,179.52 53.23,179.14 v1(54.78,177.59)
  SIG8 w0.381: v1(54.78,177.59) 58.03,174.34 v1(64.5,174.34)
  BOTTOM w0.13: v1(54.78,177.59) v2(54.78,176.81)
N16772967: length 18.3
  TOP w0.229: 63.89,185.16 65.14,183.92 67.04,183.92 67.12,184 D440.28
  TOP w0.254: 53.12,182.09 53.12,181.89 53.32,181.69 U136.6
  TOP w0.381: 63.89,185.16 55.56,185.16 53.12,182.73 53.12,182.09
N16772987: length 6.2
  TOP w0.254: U136.7 53.03,181.19
  TOP w0.381: 53.03,181.19 52.77,181.19 52.35,181.61 R3624.1 51.42,182.19 51.15,182.46 49.53,182.46 R3623.2
N16773011: length 2.4
  TOP w0.254: U136.8 52.49,180.69 52.24,180.44 R3625.1
N16773211: length 2
  TOP w0.254: D439.24 67.32,175.84 67.06,176.1 C3859.1
N16773923: length 2
  TOP w0.254: C3860.1 67.25,186.26 67.51,186 D440.24
N16773935: length 2
  TOP w0.254: D440.25 66.94,185.5 66.74,185.29 C3860.2
N16776458: length 2
  TOP w0.229: X297.1 345.09,137 D441.5
N16776602: length 1.9
  TOP w0.229: X296.1 345.09,147.03 D442.5
N16776726: length 5.4
  TOP w0.254: R3628.2 C3868.1 356.47,142.52 356.72,142.26 356.72,140.36 357.63,139.45 U137.1
N16776742: length 3.2
  TOP w0.254: U137.2 357.49,138.95 356.98,139.47 C3869.2 R3629.2
N16776790: length 3.2
  TOP w0.254: R3633.2 C3871.1 356.21,138.45 356.71,137.95 U137.4
N16776822: length 3.4
  TOP w0.254: C3870.2 R3634.2 356.47,136.42 357.5,137.45 U137.5
N16776874: length 18.6
  TOP w0.229: v1(351.59,142.29) 351.59,142.49 351.29,142.79 D442.28
  TOP w0.254: v1(359.73,143.13) 361.55,141.31 361.55,139.72 361.28,139.45 U137.10
  SIG9 w0.229: v1(359.73,143.13) 358.61,142.01 351.87,142.01 v1(351.59,142.29)
  BOTTOM w0.13: v1(359.73,143.13) v2(359.73,143.89)
N16776886: length 16.8
  TOP w0.229: 351.16,132.51 350.95,132.71 348.93,132.71 348.86,132.63 D441.28
  TOP w0.254: 361.45,137.08 361.45,137.21 361.2,137.45 U137.6
  TOP w0.381: 351.16,132.51 v1(354.77,132.51) 357.38,132.51 361.45,136.57 361.45,137.08
N16776906: length 3.5
  TOP w0.254: U137.7 361.79,137.95 361.85,137.89 361.85,137.82
  TOP w0.381: 361.85,137.82 362.13,137.54 R3630.2 R3631.1
N16776930: length 2.3
  TOP w0.254: R3632.1 362.16,138.68 361.93,138.45 U137.8
N16777130: length 2
  TOP w0.254: D442.24 348.47,140.79 348.73,140.53 C3882.1
N16777146: length 2
  TOP w0.254: D442.25 348.98,141.29 349.19,141.5 C3882.2
N16777529: length 2
  TOP w0.254: D441.24 348.85,130.63 349.11,130.37 C3883.1
N16777535: length 2
  TOP w0.254: D441.25 349.13,131.13 349.34,131.34 C3883.2
N16778933: length 1.9
  TOP w0.229: X299.1 345.09,157.19 D444.5
N16779067: length 5.2
  TOP w0.254: R3635.2 C3891.1 356.21,162.84 357.26,161.79 357.26,160.19 357.68,159.77 U138.1
N16779075: length 3.2
  TOP w0.254: R3636.2 C3892.2 356.9,159.79 357.42,159.27 U138.2
N16779099: length 3.2
  TOP w0.254: R3640.2 C3894.1 356.21,158.77 356.71,158.27 U138.4
N16779115: length 3.4
  TOP w0.254: C3893.2 R3641.2 356.45,156.74 357.48,157.77 U138.5
N16779141: length 17
  TOP w0.229: D443.28 351.22,163.11 v1(351.6,162.73)
  TOP w0.254: v1(359.73,161.29) 360.74,161.29 361.51,160.53 361.51,160.02 361.26,159.77 U138.10
  SIG9 w0.229: v1(351.6,162.73) 352.11,162.23 358.73,162.23 359.73,161.23 v1(359.73,161.29)
  BOTTOM w0.13: v2(350.96,163.19) 351.42,162.73 v1(351.6,162.73)
N16779147: length 17.3
  TOP w0.229: D444.28 351.03,152.95 351.16,152.83
  TOP w0.254: U138.6 361.2,157.77 361.45,157.53 361.45,157.4
  TOP w0.381: 351.16,152.83 358.25,152.83 v1(359.47,154.05) 361.45,156.02 361.45,157.4
N16779157: length 3.3
  TOP w0.254: 362.18,157.76 361.67,158.27 U138.7
  TOP w0.381: R3638.1 R3637.2 362.18,157.76
N16779169: length 2
  TOP w0.229: U138.8 362.06,158.77 362.18,158.9 R3639.1
N16779269: length 2
  TOP w0.254: D443.24 348.92,161.11 349.18,160.85 C3905.1
N16779277: length 2
  TOP w0.254: C3905.2 349.23,161.82 349.02,161.61 D443.25
N16779625: length 2
  TOP w0.254: C3906.1 349.03,150.69 348.77,150.95 D444.24
N16779631: length 2
  TOP w0.254: D444.25 349.16,151.45 349.37,151.66 C3906.2
N16779743: length 1.9
  TOP w0.229: X298.1 345.09,167.35 D443.5
N16792545: length 1.9
  TOP w0.229: X301.1 345.09,177.51 D446.5
N16792617: length 2
  TOP w0.229: D445.5 345.09,187.42 X300.1
N16792669: length 5.5
  TOP w0.254: U139.1 357.68,180.09 357.26,180.51 v1(357.26,181.99) 357.26,182.62 356.72,183.16 C3914.1 R3642.2
N16792687: length 3.2
  TOP w0.254: R3643.2 C3915.2 356.9,180.11 357.42,179.59 U139.2
N16792711: length 3.2
  TOP w0.254: R3647.2 C3917.1 356.26,179.09 356.76,178.59 U139.4
N16792723: length 3.4
  TOP w0.254: C3916.2 R3648.2 356.37,177.06 357.4,178.09 U139.5
N16792753: length 16.9
  TOP w0.229: v1(351.54,183.05) 351.16,183.43 D445.28
  TOP w0.254: v1(360.53,181.38) 360.53,181.25 360.86,180.92 U139.10
  SIG9 w0.254: v1(360.53,181.38) 357.61,184.3 352.78,184.3 v1(351.54,183.05)
  BOTTOM w0.13: v1(351.54,183.05) 351.9,183.05 v2(352.23,183.39)
N16792759: length 16.7
  TOP w0.229: D446.28 351.03,173.27 351.16,173.15
  TOP w0.254: 361.12,176.91 361.51,177.29 361.51,177.67 361.08,178.09 U139.6
  TOP w0.381: 361.12,176.91 357.36,173.15 v1(352.49,173.15) 351.16,173.15
N16792769: length 3.1
  TOP w0.254: 361.88,178.58 361.48,178.58 361.47,178.59 U139.7
  TOP w0.381: 361.88,178.58 v1(362.04,178.58) 362.78,178.58 R3644.2 R3645.1
N16792781: length 2.2
  TOP w0.254: U139.8 361.55,179.09 361.67,179.22
  TOP w0.381: R3646.1 362.16,179.7 361.67,179.22
N16792881: length 2
  TOP w0.254: D445.24 348.68,181.43 348.94,181.17 C3928.1
N16792887: length 2
  TOP w0.254: C3928.2 349.39,182.14 349.19,181.93 D445.25
N16793229: length 2
  TOP w0.254: D446.24 348.93,171.27 349.19,171.01 C3929.1
N16793235: length 2
  TOP w0.254: D446.25 348.98,171.77 349.19,171.98 C3929.2
N16951729: length 2
  TOP w0.254: C3836.2 66.73,154.81 66.93,155.02 D437.25
N16954792: length 2
  TOP w0.254: D439.25 66.93,175.34 66.73,175.13 C3859.2
N16962947: length 2.1
  TOP w0.203: U140.21 378.25,163.46 378.65,163.07 R3663.1
N17110091: length 4.6
  TOP w0.13: J33.6 v1(15.56,196.42)
  BOTTOM w0.13: v1(15.56,196.42) 15.99,196.85 TP1.1 R3205.1
N24036336: length 4.6
  TOP w0.13: R224.2 46.8,106.04 47.56,105.28 47.56,103.74 47.73,103.57 U11.1
N24036338: length 4
  TOP w0.13: U11.2 47.71,102.92 47.02,103.61 47.02,104.55 46.75,104.82 R238.2
N24036350: length 3.9
  TOP w0.13: R241.2 56.73,103.27 56.58,103.12 56.15,103.12 55.44,102.41 55.44,101.85 55.21,101.62 U11.21
N24036801: length 4.1
  TOP w0.13: R266.2 11.62,100.96 13.02,99.57 13.02,98.8 13.33,98.49 U12.1
N24036807: length 4
  TOP w0.13: R268.2 22.06,98.22 21.91,98.07 21.17,98.07 20.64,97.53 20.64,96.77 20.41,96.54 U12.21
N24036811: length 3.8
  TOP w0.13: R267.2 11.82,99.74 12.38,99.18 12.38,98.5 13.04,97.84 U12.2
N24037211: length 3.6
  TOP w0.13: U11.23 55.11,102.92 55.82,103.63 55.82,103.91 56.17,104.26 56.58,104.26 56.73,104.42 R206.2
N24037257: length 3.8
  BOTTOM w0.13: R288.2 412.64,115.36 v2(412.94,115.06) 412.94,114.17 413.65,113.46 U13.23
N24037299: length 3.7
  TOP w0.13: R201.2 422.14,127.94 421.32,127.12 421.32,126.29 421.07,126.04 U10.23
N24037303: length 3.7
  TOP w0.13: R216.2 412.38,127.94 412.69,127.63 412.69,127 413.65,126.04 U10.2
N24037309: length 4.1
  TOP w0.13: U10.1 413.76,126.69 413.32,127.12 413.32,127.66 412.46,128.52 412.05,128.52 411.82,128.75 R222.2
N24037315: length 3.9
  TOP w0.13: R230.2 422.03,126.82 421.77,126.56 421.77,125.89 421.32,125.44 421.32,124.97 421.09,124.74 U10.21
N24037469: length 3.6
  TOP w0.13: R254.2 21.7,99.74 21.15,99.18 21.15,98.5 20.49,97.84 U12.23
N24037653: length 4.3
  BOTTOM w0.13: U13.2 420.87,113.46 421.32,113.92 v2(421.32,115.57) 421.96,115.57 422.16,115.36 R297.2
N24037655: length 6.4
  BOTTOM w0.13: R295.2 421.98,117.22 421.2,117.22 v2(420.81,116.84) 419.29,115.31 419.29,114.3 419.47,114.11 U13.1
N24037681: length 3.8
  BOTTOM w0.13: U13.21 413.68,112.16 412.94,112.9 v2(412.94,113.28) 412.94,113.66 412.36,114.25 R306.2
N24040052: length 3.5
  TOP w0.13: R312.1 R310.2 v1(265.65,171.64) U14.1
N24040054: length 3.5
  TOP w0.13: R313.1 R308.2 266.87,171.57 v1(266.92,171.63) U14.2
N24040056: length 4.9
  TOP w0.13: v1(270.52,171.78) R305.2 R317.2 268.19,171.93 U14.3
N24044300: length 3.7
  TOP w0.13: R446.2 422.14,115.36 421.32,114.55 421.32,113.72 421.07,113.46 U18.23
N24044332: length 5
  TOP w0.13: R462.2 411.62,115.95 412.46,115.95 413.32,115.08 413.32,114.42 413.63,114.11 U18.1
N24044364: length 3.9
  TOP w0.13: R470.2 422.03,114.25 421.7,113.92 421.7,113.41 421.32,113.03 421.32,112.39 421.09,112.16 U18.21
N24044376: length 3.7
  TOP w0.13: R466.2 412.38,115.36 412.69,115.06 412.69,114.42 413.65,113.46 U18.2
N24045156: length 3.9
  BOTTOM w0.13: R380.2 11.14,98.4 12.26,97.28 v2(12.26,96.9) 12.61,96.54 U16.21
N24045160: length 6.2
  BOTTOM w0.13: U16.1 20.33,98.49 20.51,98.68 20.51,98.93 19.49,99.95 v2(19.49,100.71) 19.93,101.14 21.09,101.14 21.27,100.96 R384.2
N24045166: length 4.3
  BOTTOM w0.13: U16.2 20.31,97.84 21.02,98.55 21.02,99.06 20.76,99.31 v2(20.76,99.74) R388.2
N24045758: length 3.7
  BOTTOM w0.13: R367.2 11.62,99.74 v2(12.24,99.12) 12.38,98.98 12.38,98.5 13.04,97.84 U16.23
N24045803: length 8.2
  BOTTOM w0.13: v2(408.39,125.58) R432.2 408.39,127.15 408.5,127.25 409.77,127.25 409.89,127.38 412.26,127.38 413.6,126.04 U17.23
N24045845: length 3.9
  BOTTOM w0.13: R359.2 46.65,104.82 v2(46.93,104.54) 47.18,104.29 47.18,103.45 47.71,102.92 U15.23
N24045851: length 4.3
  BOTTOM w0.13: R374.2 55.82,106.04 v2(55.44,105.66) 55.03,105.26 55.03,103.73 54.87,103.57 U15.1
N24045855: length 3.9
  BOTTOM w0.13: U15.21 47.18,101.62 v2(46.94,101.86) 46.94,102.47 45.81,103.6 R382.2
N24045867: length 3.7
  BOTTOM w0.13: U15.2 54.98,102.92 55.64,103.58 v2(55.64,104.39) 56.07,104.82 R390.2
N24045943: length 4.9
  BOTTOM w0.13: U17.2 420.87,126.04 421.32,126.49 421.32,127.25 422.01,127.94 R454.2 422.62,128.55 v2(423.1,129.03)
N24045961: length 3.8
  BOTTOM w0.13: R457.2 412.1,126.82 412.94,125.98 v2(412.94,125.73) 412.94,125.35 413.55,124.74 U17.21
N24045973: length 7
  BOTTOM w0.13: U17.1 420.76,126.69 420.94,126.87 420.94,127.89 v2(421.32,128.27) 421.45,128.27 422.85,129.66 424.65,129.66 R460.2
N24368032: length 2.9
  TOP w0.381: U44.7 v1(256.65,215.34)
  BOTTOM w0.381: C300.1 256.68,215.36 v1(256.65,215.34) v2(255.84,215.34)
N24368040: length 6.4
  TOP w0.381: R1193.2 R1191.2 C301.2 266.18,215.34 U44.2
N24368048: length 3.5
  TOP w0.381: U44.3 265.14,216.61 265.37,216.84 C302.1
N24368090: length 1.8
  BOTTOM w0.381: v2(255.84,216.66) v1(256.6,216.66) 256.78,216.84 C300.2
N26325701: length 10.8
  TOP w0.13: U84.8 408.97,85.3 408.81,85.47 v1(408.62,85.47) 408.49,85.47 408.32,85.3 U84.7 408.32,83.26 408.21,83.15 407.77,83.15 407.67,83.24 U84.6 407.67,85.28 407.48,85.47 406.63,85.47 406.37,85.21 U84.4
  BOTTOM w0.13: v2(408.62,84.71) v1(408.62,85.47) 408.5,85.6 R2033.1
N26325715: length 11.6
  TOP w0.33: 407.02,82.98 U84.5
  TOP w0.508: 407.02,82.98 v1(406.46,82.42) 406.08,82.42 405.39,81.73 Q38.1 405.39,77.68 405.73,77.34 C3504.2 R2032.1
N26325725: length 7.4
  TOP w0.13: U84.13 412.22,83.27 412.81,82.67 416.24,82.67 416.45,82.47 v1(416.45,81.91) R2027.2
N26325727: length 5.4
  TOP w0.13: U84.18 410.92,93.6 410.6,93.92 R2031.2 409.71,96.14 v1(409.38,96.14)
N26325731: length 3.1
  TOP w0.13: U84.14 412.87,85.53 v1(413.07,85.72)
  BOTTOM w0.13: v2(413.45,84.96) 413.07,85.34 v1(413.07,85.72) 413.19,85.85 R2026.2
N26325733: length 2.9
  TOP w0.13: R2023.2 408.5,93.52 408.32,93.34 U84.22
N26325735: length 3
  TOP w0.13: R2022.2 407.23,93.47 407.67,93.02 U84.23
N26325749: length 9.5
  TOP w0.13: C2058.2 405.83,97.03 405.57,97.28 403.8,97.28 403.54,97.03 403.54,93.6 404.42,92.72 U84.28
N26325751: length 3.3
  TOP w0.13: U84.24 407.02,92.66 405.83,93.85 C2058.1
N26325755: length 9.3
  TOP w0.33: C2061.2 400.24,79.14 399.86,79.52 399.86,81.79 401.13,83.06 403.92,83.06 404.42,83.55 U84.1
N26325757: length 6.9
  TOP w0.33: U84.2 405.07,83.46 403.97,82.36 401.57,82.36 400.75,81.53 C2061.1
N26325765: length 3.1
  TOP w0.13: U84.27 405.07,92.83 404.3,93.6 C2062.1
N26325767: length 6
  TOP w0.33: C2063.1 402.27,81.4 402.65,81.79 404.14,81.79 405.72,83.37 U84.3
N26325797: length 8.9
  TOP w0.508: R2029.1 v1(414.46,76.58) C3503.2 411.99,76.61 Q37.1 410.78,78.61 410.48,78.92 R2028.2
N26325817: length 5.3
  TOP w0.33: 410.27,83.06 U84.10
  TOP w0.508: v1(408.24,81.4) 408.8,80.85 R2028.1 409.64,82.42 410.27,83.06
N26325845: length 3.3
  TOP w0.13: v1(412.18,85.72) 411.8,85.72 411.57,85.5 U84.12
  BOTTOM w0.13: R2030.2 v1(412.18,85.72) v2(412.18,84.96)
N26326739: length 5.1
  TOP w0.381: T1.1 v1(414.08,52.32)
  BOTTOM w0.381: v1(414.08,52.32) 413.93,52.47 C2066.2 v2(413.93,54.84)
N26326741: length 5.3
  TOP w0.381: T1.4 v1(410.27,52.32)
  BOTTOM w0.381: v1(410.27,52.32) 410.3,52.35 C2068.2 409.28,54.61 v2(409.26,54.61)
N26326743: length 5.1
  TOP w0.381: T1.7 v1(406.46,52.32)
  BOTTOM w0.381: v2(406.62,54.86) C2069.2 406.46,53.44 v1(406.46,52.32)
N26326745: length 5.3
  TOP w0.381: T1.10 v1(402.65,52.32)
  BOTTOM w0.381: v1(402.65,52.32) 402.68,52.35 C2070.2 402.65,53.59 v2(401.64,54.61)
N26326755: length 4.8
  TOP w0.635: T1.24 v1(414.08,32.23)
  BOTTOM w0.635: R2034.1 414.41,31.9 v1(414.08,32.23) RV4.1
N26326757: length 5
  TOP w0.635: T1.21 v1(410.27,32.22)
  BOTTOM w0.635: R2035.1 409.97,31.92 v1(410.27,32.22) 409.89,32.61 RV3.1
N26326759: length 5.5
  TOP w0.635: T1.18 v1(406.46,32.2)
  BOTTOM w0.635: RV2.1 v1(406.46,32.2) 406.46,31.41 406.17,31.11 R2036.1
N26326761: length 5.7
  TOP w0.635: T1.15 v1(402.65,32.2)
  BOTTOM w0.635: RV1.1 v1(402.65,32.2) 401.56,31.11 R2037.1
N26326763: length 27.1
  BOTTOM w0.13: R2037.2 v2(399.15,33.14)
  BOTTOM w1.016: 403.59,29.76 399.56,29.76 399.15,30.17 R2037.2 ; 403.59,29.76 R2036.2 ; 403.59,29.76 408.04,29.76 ; R2035.2 408.04,29.76 ; 408.04,29.76 412.48,29.76 ; 412.48,29.76 C2067.1 ; 412.48,29.76 R2034.2
N26328176: length 18.2
  TOP w0.508: R2038.2 v1(395.8,31.87)
  SIG4 w0.508: v1(395.8,31.87) 394.85,31.87 393.88,30.91 393.88,27.97 394.87,26.98 395.99,26.98 399.81,23.16 RJ1.9
  BOTTOM w0.13: v2(395.8,31.11) v1(395.8,31.87)
N26328196: length 58.3
  TOP w0.508: v1(395.8,35.15) R2039.1
  SIG2 w0.508: v1(395.8,35.15) 396.67,34.27 396.67,26.26 398.53,24.4 398.53,16.04 400.24,14.33 419.45,14.33 421,15.88 421,21 420.07,21.93 415.56,21.93 414.33,23.16 RJ1.11
  BOTTOM w0.13: v2(395.03,35.18) 395.77,35.18 v1(395.8,35.15)
N26328252: length 33.9
  TOP w0.508: R2040.2 v1(393.51,32.13)
  SIG4 w0.508: v1(393.51,32.13) 392.87,31.49 392.87,27.43 398.72,21.59 398.72,15.87 402.91,11.68 407.48,11.68 408.8,13 RJ1.A4
  BOTTOM w0.13: v2(393.51,31.37) v1(393.51,32.13)
N26328760: length 7.1
  TOP w0.381: C3515.2 393.51,22.86 ; C3514.2 393.38,21.71
  SIG2 w0.406: 392.7,11.5 J29.1 ; J29.1 393.5,10.7 ; J29.1 393.5,12.3 ; J29.1 394.3,11.5
  BOTTOM w0.13: v2(392.62,23.49) v1(392.62,22.73)
  BOTTOM w0.381: D94.5 391.35,25.4 391.6,25.14 v1(391.6,24.64)
  vias: v1(391.73,22.73) v1(391.73,21.84) v1(392.62,21.84)
N26920312: length 38.4
  TOP w0.13: R2044.1 178.5,101.85 v1(178.37,101.72) ; U1.R33 v1(197.55,121.34)
  SIG7 w0.155: v1(197.55,121.34) 196.9,121.34 195.1,119.54 195.1,119.07 194.84,118.81 181.2,118.81 181,118.61 181,114.11 180.7,113.81 180.3,113.81 179.01,112.52 179.01,102.36 v1(178.37,101.72)
  BOTTOM w0.13: v1(178.37,101.72) 177.86,101.72 v2(177.61,101.47)
N26921640: length 4.7
  TOP w0.107: U1.CB29 202.5,168.29 v1(202.5,168.34)
  BOTTOM w0.097: 202.22,170.94 arc(202.21,170.9) 202.19,170.86 arc(202.16,170.83) 202.16,170.79 202.16,169.17 arc(202.16,169.13) 202.16,169.1 arc(202.16,169.07) 202.16,169.05 arc(202.17,169) 202.17,168.96 arc(202.29,168.62) v1(202.5,168.34)
  BOTTOM w0.107: 202.22,170.94 202.22,171.58 arc(202.24,171.69) 202.3,171.78 C2075.1
N26921643: length 4.8
  TOP w0.107: U1.CB30 201.55,168.34 v1(201.6,168.34)
  BOTTOM w0.097: v1(201.6,168.34) 201.72,168.46 arc(201.89,168.72) 201.95,169.03 201.95,170.79 arc(201.94,170.83) 201.92,170.86 arc(201.9,170.9) 201.89,170.94
  BOTTOM w0.107: C2076.1 201.69,171.91 arc(201.81,171.73) 201.88,171.53 arc(201.88,171.5) 201.89,171.46 arc(201.89,171.44) 201.89,171.42 201.89,170.94
N26921646: length 12.6
  TOP w0.097: U1.CD29 201.8,170.09 arc(201.69,170.26) 201.65,170.46 201.65,170.9 arc(201.75,171.14) 201.99,171.24 202.25,171.24 arc(202.53,171.36) 202.65,171.64 202.65,172.4 arc(202.66,172.44) 202.68,172.47 arc(202.71,172.51) 202.71,172.55
  TOP w0.107: 202.71,172.55 202.71,172.97 arc(202.73,173.05) 202.77,173.12 207.53,177.87 arc(207.64,178.04) 207.68,178.25 207.68,178.85 arc(207.72,179.05) 207.84,179.22 C2077.1
N26921649: length 12.6
  TOP w0.097: U1.CD30 201.29,170.09 arc(201.41,170.26) 201.45,170.46 201.45,170.9 arc(201.61,171.28) 201.99,171.44 202.25,171.44 arc(202.39,171.5) 202.45,171.64 202.45,172.4 arc(202.44,172.44) 202.42,172.47 arc(202.39,172.51) 202.38,172.55
  TOP w0.107: 202.38,172.55 202.38,172.97 arc(202.42,173.18) 202.54,173.35 207.29,178.1 arc(207.34,178.17) 207.35,178.25 207.35,178.85 arc(207.31,179.05) 207.2,179.22 C2078.1
N26921652: length 9.1
  TOP w0.107: C2079.1 198.05,179.22 arc(198.17,179.05) 198.21,178.85 198.21,178.63 arc(198.27,178.33) 198.44,178.08 199.31,177.2 arc(199.45,177) 199.5,176.76 199.5,175.95 arc(199.58,175.54) 199.82,175.19 201.11,173.9 arc(201.31,173.59) 201.38,173.23 201.38,172.49 arc(201.33,172.2) 201.16,171.95 U1.CF30
N26921655: length 9.1
  TOP w0.107: C2080.1 198.7,179.22 arc(198.58,179.05) 198.54,178.85 198.54,178.63 arc(198.57,178.46) 198.67,178.31 198.87,178.11 199.55,177.43 arc(199.76,177.12) 199.83,176.76 199.83,175.95 arc(199.89,175.67) 200.05,175.42 201.34,174.13 arc(201.62,173.72) 201.71,173.23 201.71,172.41 arc(201.76,172.19) 201.88,172.01 U1.CF29
N26921658: length 12.4
  TOP w0.097: U1.CC32 199.21,169 arc(199.38,169.27) 199.45,169.58 199.45,172.27 arc(199.44,172.31) 199.42,172.35 arc(199.39,172.39) 199.38,172.43
  TOP w0.107: C2081.1 195.39,179.22 arc(195.5,179.05) 195.54,178.85 195.54,178.58 arc(195.61,178.22) 195.81,177.92 197.22,176.52 arc(197.47,176.14) 197.56,175.69 197.56,175.12 arc(197.6,174.85) 197.69,174.59 arc(197.78,174.46) 197.89,174.33 197.89,174.33 199.23,172.99 arc(199.34,172.82) 199.38,172.62 199.38,172.43
N26921661: length 12.4
  TOP w0.097: U1.CC31 199.89,169 arc(199.71,169.27) 199.65,169.58 199.65,172.27 arc(199.66,172.31) 199.68,172.35 arc(199.71,172.39) 199.71,172.43
  TOP w0.107: C2082.1 196.03,179.22 arc(195.91,179.05) 195.87,178.85 195.87,178.58 arc(195.92,178.35) 196.05,178.15 197.45,176.75 arc(197.78,176.26) 197.89,175.69 197.89,175.12 arc(197.92,174.93) 197.99,174.75 arc(198.05,174.65) 198.12,174.56 198.13,174.56 199.47,173.22 arc(199.65,172.95) 199.71,172.62 199.71,172.43
N27240367: length 6.6
  TOP w0.203: U140.39 378.65,171.81 C3950.2
  TOP w0.254: R2196.2 378.79,175.45 378.79,173.43 378.92,173.3 R2194.2 379.39,172.54 C3950.2
N27240376: length 6.5
  TOP w0.203: U140.40 378.25,172 C3950.1
  TOP w0.254: R2195.2 378.35,175.36 378.35,173.43 378.22,173.3 R3131.2 377.79,172.46 C3950.1
N27612272: length 101.4
  TOP w0.13: v1(96.85,49.4) 97.06,49.19 D391.2
  SIG7 w0.155: v1(96.85,49.4) 96.09,48.64 95.31,48.64 84.01,37.34 12.93,37.34 9.38,40.89 8.96,40.89 8.73,41.12 8.73,43.33 v1(9.21,43.81)
  BOTTOM w0.13: R3023.2 7.2,44.32 8.7,44.32 v1(9.21,43.81)
N27612274: length 94.6
  TOP w0.254: D391.1 98.96,49.19 99.39,48.77 100.02,48.77 v1(100.53,49.27) ; v1(60.87,85.32) R3465.2 59.63,85.82 59.63,86.76 R3019.1
  SIG5 w0.254: v1(100.53,49.27) 99.9,48.64 95.06,48.64 93.92,47.5 77.85,47.5 77.34,46.99 67.63,46.99 63.95,43.3 59.63,43.3 57.92,45.01 57.92,74.09 57.65,74.36 57.65,78.23 58.23,78.81 58.23,79.88 59.25,80.9 59.25,84.58 59.98,85.32 v1(60.87,85.32)
  BOTTOM w0.13: v2(61.15,86.03) 60.87,85.75 v1(60.87,85.32)
N27612276: length 93.9
  TOP w0.13: D387.2 80.65,48.98 81.14,48.49 84.51,48.49 v1(85.42,49.4) ; R3015.2 v1(7.79,44.96)
  SIG7 w0.155: v1(85.42,49.4) 84.78,48.77 82.01,48.77 80.1,46.86 78.84,46.86 69.7,37.72 13.09,37.72 9.67,41.14 9.67,44.27 9.46,44.48 8.42,44.48 7.94,44.96 v1(7.79,44.96)
N27612278: length 68.1
  TOP w0.254: v1(58.23,75.69) 59.63,77.09 59.63,77.72 59.78,77.87 R3461.2 60.64,77.87 60.9,78.13 60.9,80.13 60.62,80.41 R3011.1 ; D387.1 81.94,49.19 82.24,48.89 84.02,48.89 v1(84.53,49.4)
  SIG5 w0.254: v1(58.23,75.69) 59.09,74.83 59.09,53.77 58.41,53.08 58.41,47.44 58.86,46.99 66.1,46.99 67.75,48.64 78.12,48.64 78.76,48 81.13,48 81.77,48.64 83.77,48.64 v1(84.53,49.4)
  BOTTOM w0.13: v1(58.23,75.69) 58.61,75.31 v2(58.99,75.31)
N27612284: length 81.6
  TOP w0.13: v1(77.8,49.4) 78.01,49.19 D383.2 ; R3007.2 v1(7.79,46.1)
  SIG7 w0.155: v1(7.79,46.1) 7.94,46.1 8.45,45.59 9.59,45.59 10.44,44.74 10.44,41.46 13.4,38.49 63.63,38.49 73.9,48.77 77.16,48.77 v1(77.8,49.4)
N27612286: length 55.8
  TOP w0.254: v1(58.23,76.58) 58.74,77.09 R3457.2 58.23,77.87 58.1,78 58.1,80.26 58.26,80.41 R3004.1 ; D383.1 79.35,48.92 79.06,48.63 77.68,48.63 v1(76.91,49.4)
  SIG10 w0.254: v1(58.23,76.58) 58.86,75.94 58.86,73 58.29,72.43 58.29,50.36 59.83,48.81 67.19,48.81 68.41,50.04 76.27,50.04 v1(76.91,49.4)
  BOTTOM w0.13: v2(57.47,76.58) v1(58.23,76.58)
N27612290: length 60.8
  TOP w0.13: v1(60.91,49.4) 60.91,49.41 61.12,49.19 D379.2
  SIG7 w0.155: v1(60.91,49.4) 60.27,48.77 60.01,48.77 54.09,42.84 12.94,42.84 11.6,44.18 11.6,45.28 9.64,47.24 v1(9.21,47.24)
  BOTTOM w0.13: R2999.2 7.33,47.88 8.57,47.88 v1(9.21,47.24)
N27612292: length 49.7
  TOP w0.254: v1(64.46,49.4) 63.95,48.89 63.19,48.89 62.89,49.19 D379.1 ; R2996.1 58.26,87.27 57.98,86.99 57.98,85.6 58.26,85.32 R3453.2 58.74,85.98 v1(58.99,86.23)
  SIG10 w0.254: v1(64.46,49.4) 63.85,50.01 60.29,50.01 58.99,51.31 58.99,72.01 59.5,72.51 59.5,79.75 60.39,80.64 60.39,83.94 59.5,84.83 59.5,85.72 v1(58.99,86.23)
  BOTTOM w0.13: v2(58.99,85.47) v1(58.99,86.23)
N27612296: length 49.5
  TOP w0.13: v1(49.85,49.4) 50.06,49.19 D375.2
  SIG7 w0.155: v1(49.85,49.4) 49.21,48.77 47.56,48.77 42.43,43.63 13.25,43.63 12.46,44.42 12.46,45.64 9.72,48.38 v1(9.21,48.38)
  BOTTOM w0.13: v1(9.21,48.38) 8.7,48.89 7.2,48.89 R2991.2
N27612298: length 38.6
  TOP w0.254: v1(53.02,75.69) 54.55,77.21 R3449.2 54.04,77.87 53.91,78 53.91,80.26 54.06,80.41 R2988.1 ; v1(53.53,49.27) 53.02,48.77 52.39,48.77 51.96,49.19 D375.1
  SIG10 w0.254: v1(53.02,75.69) 56.1,72.62 56.1,51.84 v1(53.53,49.27)
  BOTTOM w0.13: v2(53.78,75.44) 53.28,75.44 v1(53.02,75.69)
N27612302: length 39.9
  TOP w0.13: v1(38.42,49.4) 37.51,48.49 34.04,48.49 33.65,48.88 D371.2 ; R2983.2 v1(7.79,49.53)
  SIG7 w0.155: v1(38.42,49.4) 38.42,48.37 37.01,46.96 11.77,46.96 9.72,49.02 8.7,49.02 8.19,49.53 v1(7.79,49.53)
N27612304: length 58.1
  TOP w0.254: v1(53.02,74.8) 52.51,75.31 52.51,76.96 53.15,77.59 R3445.2 52.72,77.87 52.4,78.2 52.4,80.15 52.67,80.41 R2979.1 ; D371.1 34.94,49.19 35.24,48.89 37.02,48.89 v1(37.53,49.4)
  SIG8 w0.254: v1(53.02,74.8) 53.43,74.39 53.43,72.74 53.91,72.26 53.91,57.08 55.45,55.54 55.45,48.78 53.99,47.32 43.16,47.32 42.23,48.26 38.8,48.26 37.66,49.4 v1(37.53,49.4)
  BOTTOM w0.13: v1(53.02,74.8) 52.87,74.8 v2(52.34,75.33)
N27612308: length 26.3
  TOP w0.13: D367.2 31.01,49.19 v1(30.8,49.4) ; R2975.2 v1(7.79,50.67)
  SIG7 w0.155: v1(30.8,49.4) 30.16,48.77 28.38,48.77 28.11,48.49 11.52,48.49 9.84,50.16 8.45,50.16 7.94,50.67 v1(7.79,50.67)
N27612310: length 64.5
  TOP w0.254: D367.1 32.35,48.92 32.06,48.63 30.68,48.63 v1(29.91,49.4)
  SIG10 w0.254: v1(29.91,49.4) 30.42,49.91 39.56,49.91 40.58,48.89 51.12,48.89 51.37,48.64 54.01,48.64 56.58,51.21 56.58,73.02 v1(53.02,76.58)
  BOTTOM w0.254: v1(53.02,76.58) 53.78,76.58 v2(53.91,76.71) 54.55,77.34 R3441.2 54.04,77.87 53.91,78 53.91,80.26 54.06,80.41 R2971.1
N27612314: length 9.8
  TOP w0.13: v1(13.91,49.4) 13.91,49.41 14.12,49.19 D363.2 ; R2967.2 v1(7.79,51.81)
  SIG5 w0.155: v1(13.91,49.4) 13.14,48.64 11.87,48.64 10.1,50.42 10.1,50.67 9.59,51.18 8.57,51.18 7.94,51.81 v1(7.79,51.81)
N27612316: length 83.4
  TOP w0.254: D363.1 15.89,49.19 16.19,48.89 18.55,48.89 v1(19.49,47.95)
  SIG8 w0.254: v1(19.49,47.95) 20.05,47.95 25.46,42.54 53.8,42.54 56.58,45.32 56.58,56 55.05,57.53 55.05,75.56 v1(56.07,76.58)
  BOTTOM w0.254: R2963.1 55.46,80.41 55.31,80.26 55.31,77.98 55.41,77.87 R3437.2 55.94,76.71 v1(56.07,76.58) 55.31,76.58 v2(55.18,76.71)
N27613363: length 199.8
  TOP w0.13: v1(190.85,49.4) 191.06,49.19 D392.2
  SIG3 w0.155: v1(190.85,49.4) 190.34,48.89 182.66,48.89 161.96,28.19 13.02,28.19 9.21,32 v1(9.21,34.67)
  BOTTOM w0.13: v1(9.21,34.67) 8.7,35.18 7.2,35.18 R3024.2 6.69,33.8 v2(6.41,33.53)
N27613365: length 88.9
  TOP w0.254: v1(150.05,72.13) 150.94,73.02 150.94,76.96 151.32,77.34 R3466.2 151.7,77.87 152.03,78.2 152.03,80.19 151.8,80.41 R3020.1 ; D392.1 192.96,49.19 193.39,48.77 194.02,48.77 v1(194.53,49.27)
  SIG5 w0.254: v1(194.53,49.27) 193.9,48.64 189.8,48.64 188.66,47.5 165.8,47.5 161.06,42.76 153.72,42.76 149.92,46.56 149.92,53.72 151.79,55.59 151.79,57.24 152.34,57.78 152.34,69.85 v1(150.05,72.13)
N27613367: length 193.4
  TOP w0.13: R3016.2 v1(7.79,35.81) ; v1(179.42,49.4) 178.51,48.49 175.19,48.49 174.65,49.03 D388.2
  SIG3 w0.155: v1(7.79,35.81) 7.94,35.81 8.45,35.3 9.33,35.3 9.72,34.92 9.72,32.13 13.27,28.58 157.29,28.58 168.47,39.75 168.47,43.18 172.91,47.62 174.43,47.62 175.45,48.64 178.66,48.64 v1(179.42,49.4)
N27613369: length 82.6
  TOP w0.254: D388.1 175.94,49.19 176.24,48.89 178.02,48.89 v1(178.53,49.4) ; R3012.1 151.98,86.89 151.83,86.74 151.83,84.83 152.31,84.35 R3462.2 152.72,83.94 152.46,83.69 152.11,83.69 v1(151.45,84.35)
  SIG5 w0.254: v1(151.45,84.35) 150.69,83.59 150.69,74.04 152.84,71.88 152.84,55.88 150.43,53.46 150.43,46.73 153.92,43.24 160.86,43.24 165.62,48 168.85,48 169.35,48.51 172.66,48.51 173.04,48.13 176.03,48.13 176.41,48.51 177.64,48.51 v1(178.53,49.4)
  BOTTOM w0.13: v1(151.45,84.35) 151.35,84.35 v2(150.81,83.82)
N27613375: length 177.6
  TOP w0.13: D385.2 172.01,49.19 v1(171.67,49.53) ; R3008.2 v1(7.79,36.95)
  SIG3 w0.155: v1(7.79,36.95) 7.94,36.95 8.45,36.45 9.46,36.45 10.73,35.18 10.73,33.96 12.38,32.31 156.58,32.31 162.12,37.84 162.12,40.89 169.74,48.51 170.65,48.51 v1(171.67,49.53)
N27613377: length 64.5
  TOP w0.254: v1(170.78,49.53) 171.68,48.63 173.06,48.63 173.35,48.92 D385.1 ; v1(153.48,83.56) 153.73,83.56 154.11,83.94 R3458.2 153.58,84.35 153.48,84.45 153.48,86.74 153.63,86.89 R3003.1
  SIG5 w0.254: v1(170.78,49.53) 169.51,50.8 157.64,50.8 155.86,49.02 153.73,49.02 153.48,49.27 153.48,52.67 155.26,54.45 155.26,70.74 156.53,72.01 156.53,79.12 153.48,82.17 v1(153.48,83.56)
  BOTTOM w0.13: v1(153.48,83.56) 153.23,83.82 v2(152.72,83.82)
N27613381: length 157.3
  TOP w0.13: v1(154.91,49.65) 154.91,49.66 155.38,49.19 D380.2
  SIG3 w0.155: v1(9.21,38.1) 9.88,38.1 10.51,37.46 144.97,37.46 149.67,42.16 149.67,46.14 152.42,48.89 154.14,48.89 v1(154.91,49.65)
  BOTTOM w0.13: R3000.2 7.33,38.73 8.57,38.73 v1(9.21,38.1)
N27613383: length 43.9
  TOP w0.254: v1(154.11,74.55) 153.35,75.31 153.35,76.58 154.11,77.34 R3454.2 154.62,77.87 154.75,78 154.75,80.26 154.6,80.41 R2995.1 ; D380.1 156.89,49.19 157.19,48.89 157.95,48.89 v1(158.46,49.4)
  SIG5 w0.254: v1(158.46,49.4) 158.46,49.3 157.67,48.51 153.48,48.51 153,48.99 153,53.11 154.78,54.89 154.78,73.89 v1(154.11,74.55)
  BOTTOM w0.13: v2(155,75.31) 154.24,74.55 v1(154.11,74.55)
N27613387: length 143.4
  TOP w0.13: D378.2 144.06,49.19 v1(143.85,49.4)
  SIG3 w0.155: v1(9.21,39.24) 10.1,39.24 10.99,38.35 124.78,38.35 135.06,48.64 143.09,48.64 v1(143.85,49.4)
  BOTTOM w0.13: R2992.2 7.23,39.77 8.67,39.77 v1(9.21,39.24)
N27613389: length 39
  TOP w0.254: D378.1 145.96,49.19 146.39,48.77 147.02,48.77 v1(147.53,49.27) ; R2987.1 146.65,80.41 146.37,80.13 146.37,78.05 146.55,77.87 R3450.2 147.13,77.47 146.49,76.83 146.49,72.03 v1(147.03,71.5)
  SIG5 w0.254: v1(147.03,71.5) 148.02,71.5 150.81,68.7 150.81,58.49 150.25,57.93 150.25,56.18 148.4,54.33 148.4,50.14 v1(147.53,49.27)
N27613393: length 138
  TOP w0.13: R2984.2 v1(7.79,40.38) ; v1(132.42,49.4) 131.51,48.49 127.92,48.49 127.65,48.77 D372.2
  SIG3 w0.155: v1(7.79,40.38) 7.94,40.38 8.45,39.88 10.22,39.88 11.24,38.86 124.65,38.86 132.42,46.63 v1(132.42,49.4)
N27613395: length 58.3
  TOP w0.254: D372.1 128.94,49.19 129.24,48.89 131.02,48.89 v1(131.53,49.4)
  SIG8 w0.254: v1(131.53,49.4) 131.64,49.4 133.54,47.5 147.78,47.5 149.67,49.38 149.67,53.62 146.01,57.28 146.01,71.37 v1(147.03,72.39)
  BOTTOM w0.254: v1(147.03,72.39) 148.58,73.94 148.58,76.12 v2(149.03,76.58) 148.53,77.09 R3447.2 148.02,77.87 147.92,77.98 147.92,80.29 148.04,80.41 R2980.1
N27613399: length 122.7
  TOP w0.13: R2976.2 v1(7.79,41.53) ; v1(124.8,49.4) 125.01,49.19 D368.2
  SIG3 w0.155: v1(124.8,49.4) 124.04,48.64 120.08,48.64 113.86,42.42 13.4,42.42 12,41.02 8.45,41.02 7.94,41.53 v1(7.79,41.53)
N27613401: length 70.2
  TOP w0.254: v1(148.53,83.69) R3442.2 149.03,84.35 149.16,84.48 149.16,86.74 149.01,86.89 R2972.1 ; v1(123.91,49.4) 124.68,48.63 126.06,48.63 126.35,48.92 D368.1
  SIG9 w0.254: v1(148.53,83.69) 148.02,83.18 148.02,81.24 146.49,79.72 146.49,55.24 148.78,52.96 148.78,49.78 147.76,48.77 128.59,48.77 128.08,49.27 125.67,49.27 124.9,50.04 124.54,50.04 v1(123.91,49.4)
  BOTTOM w0.13: v1(148.53,83.69) 148.4,83.82 v2(147.64,83.82)
N27613405: length 105.4
  TOP w0.13: D364.2 108.12,49.19 107.91,49.41 v1(107.91,49.4)
  SIG3 w0.155: v1(9.21,42.67) 11.86,42.67 12.87,43.69 101.01,43.69 106.22,48.89 107.4,48.89 v1(107.91,49.4)
  BOTTOM w0.13: R2968.2 7.33,43.3 8.57,43.3 v1(9.21,42.67)
N27613407: length 83.5
  TOP w0.254: v1(111.46,49.4) 110.95,48.89 110.19,48.89 109.89,49.19 D364.1
  SIG8 w0.254: v1(111.46,49.4) 117.2,43.67 148.25,43.67 150.69,46.1 150.69,54.48 148.65,56.51 148.65,75.18 v1(150.05,76.58)
  BOTTOM w0.13: v2(149.29,75.31) 149.29,75.82 v1(150.05,76.58)
  BOTTOM w0.254: v1(150.05,76.58) 149.92,76.71 R3438.2 149.54,77.87 149.29,78.13 149.29,80.26 149.44,80.41 R2964.1
N27614643: length 114.4
  TOP w0.13: v1(284.85,49.4) 285.06,49.19 D393.2 ; R3025.2 v1(388.43,50.67)
  SIG6 w0.155: v1(284.85,49.4) 285.31,49.86 289.17,49.86 296.72,42.3 383.2,42.3 385.12,44.22 385.12,46.14 386.04,47.06 386.04,49.29 386.91,50.16 387.92,50.16 v1(388.43,50.67)
N27614645: length 89.1
  TOP w0.254: v1(288.53,49.4) 287.9,48.77 287.39,48.77 286.96,49.19 D393.1 ; R3021.1 245.78,80.41 245.94,80.26 245.94,78.1 245.71,77.87 R3467.2 245.3,76.71 v1(244.03,75.44)
  SIG5 w0.254: v1(244.03,75.44) 245.3,74.17 245.3,54.73 244.16,53.58 244.16,46.35 247.77,42.74 251.08,42.74 255.33,46.99 266.31,46.99 266.79,47.48 282.53,47.48 283.69,48.64 287.77,48.64 v1(288.53,49.4)
  BOTTOM w0.13: v2(242.89,75.31) 243.9,75.31 v1(244.03,75.44)
N27614647: length 128.3
  TOP w0.13: v1(273.42,49.4) 272.51,48.49 268.92,48.49 268.65,48.77 D389.2
  SIG4 w0.155: v1(273.42,49.4) 275.5,49.4 281.21,43.69 382.35,43.69 385.22,46.57 385.22,48.35 v1(387.54,50.67)
  BOTTOM w0.13: R3017.2 389.09,51.03 388.94,51.18 388.05,51.18 v1(387.54,50.67)
N27614649: length 73.5
  TOP w0.254: R3013.1 243.42,80.41 243.27,80.26 243.27,78.13 243.52,77.87 R3463.2 244.38,77.87 244.51,77.74 244.51,76.86 v1(243.98,76.32) ; v1(272.53,49.4) 272.02,48.89 270.24,48.89 269.94,49.19 D389.1
  SIG5 w0.254: v1(272.53,49.4) 271.89,48.77 270.35,48.77 269.58,48 266.64,48 266.13,47.5 255.08,47.5 250.8,43.22 248.05,43.22 244.67,46.61 244.67,53.41 245.78,54.53 245.78,74.52 v1(243.98,76.32)
  BOTTOM w0.13: v2(244.79,75.31) 243.98,76.12 v1(243.98,76.32)
N27614655: length 130.1
  TOP w0.13: D384.2 266.01,49.19 v1(265.8,49.4)
  SIG4 w0.155: v1(265.8,49.4) 267.65,47.54 276.27,47.54 280.89,42.93 382.67,42.93 385.99,46.25 385.99,46.83 v1(387.54,48.38)
  BOTTOM w0.13: v1(387.54,48.38) 388.05,48.89 388.94,48.89 389.09,48.74 R3009.2
N27614657: length 66.7
  TOP w0.254: v1(248.09,83.69) R3460.2 247.59,84.35 247.46,84.48 247.46,87.63 247.61,87.78 R3005.1 ; v1(264.91,49.4) 265.68,48.63 267.06,48.63 267.35,48.92 D384.1
  SIG5 w0.254: v1(264.91,49.4) 263.26,51.05 256.35,51.05 252.77,47.48 247.61,47.48 246.19,48.89 246.19,52.89 247.23,53.93 247.23,82.83 v1(248.09,83.69)
  BOTTOM w0.13: v1(248.09,83.69) v2(248.98,84.58)
N27614661: length 152.9
  TOP w0.13: D382.2 249.12,49.19 248.91,49.41 v1(248.91,49.4) ; R3001.2 v1(388.43,48.38)
  SIG6 w0.155: v1(388.43,48.38) 387.92,47.88 387.31,47.88 386.8,47.37 386.8,46.74 385.88,45.82 385.88,42.17 381.73,38.02 266.37,38.02 254.53,49.86 249.37,49.86 v1(248.91,49.4)
N27614663: length 40.1
  TOP w0.254: D382.1 250.89,49.19 251.19,48.89 251.95,48.89 v1(252.46,49.4)
  SIG5 w0.254: v1(248.09,77.21) 248.25,77.06 248.25,53.58 247.33,52.66 247.33,51.18 248.58,49.93 251.93,49.93 v1(252.46,49.4)
  BOTTOM w0.254: v1(248.09,77.21) R3455.2 249.26,77.87 v2(249.36,77.98) 249.36,78.48 248.98,78.86 248.98,80.09 248.66,80.41 R2997.1
N27614667: length 161.9
  TOP w0.13: D376.2 238.06,49.19 v1(237.85,49.4)
  SIG3 w0.155: v1(387.54,46.1) 387.54,45.6 386.4,44.46 386.4,43.26 381.62,38.48 270.42,38.48 265.21,43.69 248.25,43.69 242.01,49.94 238.38,49.94 v1(237.85,49.4)
  BOTTOM w0.13: v1(387.54,46.1) 388.05,46.61 388.94,46.61 389.09,46.45 R2993.2
N27614669: length 41.7
  TOP w0.254: v1(241.53,49.4) 240.9,48.77 240.39,48.77 239.96,49.19 D376.1 ; R2989.1 241.74,84.1 242,84.35 R3452.2 v1(242.51,83.69)
  SIG8 w0.254: v1(242.51,83.69) 242,83.18 242,81.66 240.35,80.01 240.35,54.86 242,53.21 242,49.87 v1(241.53,49.4)
  BOTTOM w0.13: v2(242.51,84.58) v1(242.51,83.69)
N27614673: length 178.7
  TOP w0.13: v1(226.42,49.4) 225.51,48.49 221.92,48.49 221.65,48.77 D374.2 ; R2985.2 v1(388.43,46.1)
  SIG6 w0.155: v1(388.43,46.1) 387.92,45.59 387.53,45.59 386.65,44.71 386.65,41.86 382.05,37.26 240.15,37.26 228.01,49.4 v1(226.42,49.4)
N27614675: length 57.5
  TOP w0.254: v1(225.53,49.4) 225.02,48.89 223.24,48.89 222.94,49.19 D374.1
  SIG8 w0.254: v1(240.86,76.58) 241.36,76.07 241.36,55.37 243.01,53.72 243.01,48.6 241.91,47.5 229.93,47.5 227.39,50.04 226.16,50.04 v1(225.53,49.4)
  BOTTOM w0.254: v1(240.86,76.58) 241.11,76.83 R3448.2 240.32,77.87 v2(239.84,78.36) 240.32,78.84 240.32,80.24 240.5,80.41 R2981.1
N27614679: length 181.7
  TOP w0.13: v1(218.8,49.4) 219.01,49.19 D369.2 ; R2977.2 v1(388.43,43.81)
  SIG6 w0.155: v1(218.8,49.4) 219.78,49.4 222.01,47.16 228.62,47.16 239.67,36.1 382.53,36.1 387.69,41.27 388.17,41.27 388.94,42.03 388.94,43.3 v1(388.43,43.81)
N27614681: length 71.7
  TOP w0.254: v1(242,76.58) 242.51,77.09 R3443.2 242.1,77.87 241.87,78.1 241.87,80.26 242.02,80.41 R2973.1 ; v1(217.91,49.4) 218.68,48.63 220.06,48.63 220.35,48.92 D369.1
  SIG8 w0.254: v1(217.91,49.4) 218.54,48.77 219.77,48.77 220.54,48 222.83,48 224.6,46.23 235.65,46.23 238.19,43.69 241.36,43.69 244.16,46.48 244.16,54.1 242.51,55.75 242.51,74.17 242.76,74.42 242.76,75.82 v1(242,76.58)
  BOTTOM w0.13: v1(242,76.58) 241.49,76.07 240.47,76.07 v2(239.97,76.58)
N27614685: length 196.8
  TOP w0.13: D365.2 202.12,49.19 201.91,49.41 v1(201.91,49.4)
  SIG3 w0.155: v1(387.54,43.81) 387.54,43.32 381.93,37.71 270.11,37.71 264.89,42.93 215.11,42.93 208.1,49.94 202.44,49.94 v1(201.91,49.4)
  BOTTOM w0.13: R2969.2 389.09,44.17 388.94,44.32 388.05,44.32 v1(387.54,43.81)
N27614687: length 84.2
  TOP w0.254: v1(205.46,49.4) 204.95,48.89 204.19,48.89 203.89,49.19 D365.1
  SIG8 w0.254: v1(205.46,49.4) 206.95,49.4 212.68,43.67 235.67,43.67 236.92,42.42 241.87,42.42 245.17,45.72 245.17,54.86 243.52,56.51 243.52,72.77 244.54,73.78 244.54,76.58 v1(243.9,77.21)
  BOTTOM w0.13: v2(244.79,76.58) 244.16,77.21 v1(243.9,77.21)
  BOTTOM w0.254: R2965.1 243.24,79.75 243.24,78.53 R3439.2 v1(243.9,77.21)
N27615023: length 18.9
  TOP w0.13: v1(378.85,49.4) 379.06,49.19 D394.2 ; R3026.2 v1(388.43,59.81)
  SIG6 w0.155: v1(388.43,59.81) 387.92,59.31 385.76,59.31 382.97,56.51 382.97,50.67 382.36,50.06 379.51,50.06 v1(378.85,49.4)
N27615025: length 81.5
  TOP w0.254: D394.1 380.96,49.19 381.39,48.77 381.9,48.77 v1(382.53,49.4)
  SIG4 w0.254: v1(341.06,74.93) 341.19,74.8 341.19,72.26 341.95,71.5 341.95,56.89 339.53,54.48 339.53,49.15 341.19,47.5 367.67,47.5 368.79,48.62 381.75,48.62 v1(382.53,49.4)
  BOTTOM w0.254: v1(341.06,74.93) 341.44,75.31 v2(341.82,75.31) 342.58,76.07 342.58,76.96 342.2,77.34 R3468.2 342.61,77.87 342.84,78.1 342.84,79.25 342.2,79.88 R3022.1
N27615027: length 35.2
  TOP w0.13: v1(367.42,49.4) 366.51,48.49 362.92,48.49 362.65,48.77 D390.2
  SIG8 w0.155: v1(367.42,49.4) 376.87,49.4 377.33,48.94 382.88,48.94 383.61,49.67 383.61,54.74 v1(387.54,58.67)
  BOTTOM w0.13: R3018.2 389.09,59.03 388.94,59.18 388.05,59.18 v1(387.54,58.67)
N27615029: length 65.4
  TOP w0.254: v1(366.53,49.4) 366.02,48.89 364.24,48.89 363.94,49.19 D390.1
  SIG4 w0.254: v1(366.53,49.4) 365.89,48.77 364.5,48.77 363.87,48.13 361.12,48.13 360.69,48.56 341.21,48.56 340.04,49.73 340.04,54.22 342.46,56.63 342.46,71.84 341.95,72.35 341.95,75.05 v1(341.06,75.94)
  BOTTOM w0.254: v1(341.06,75.94) 340.93,75.82 v2(340.3,75.82) 340.3,77.09 340.68,77.47 R3464.2 340.27,77.87 339.92,78.23 339.92,79.08 340.68,79.84 R3014.1
N27615035: length 37.5
  TOP w0.13: v1(359.8,49.4) 360.01,49.19 D386.2
  SIG8 w0.155: v1(359.8,49.4) 362.78,49.4 363.62,48.56 383.04,48.56 383.99,49.51 383.99,53.98 v1(387.54,57.53)
  BOTTOM w0.13: v1(387.54,57.53) 388.05,58.04 388.94,58.04 389.09,57.88 R3010.2
N27615037: length 69.1
  TOP w0.254: v1(358.91,49.4) 359.68,48.63 361.06,48.63 361.35,48.92 D386.1 ; R3006.1 342.71,84.48 342.84,84.6 R3459.2 343.47,84.2 v1(343.22,83.94)
  SIG2 w0.254: v1(343.22,83.94) 342.58,83.31 342.58,57.02 339.66,54.1 339.66,44.96 340.89,43.73 346.56,43.73 349.31,46.48 355.41,46.48 357.44,48.51 358.02,48.51 v1(358.91,49.4)
  BOTTOM w0.13: v1(343.22,83.94) 343.47,83.94 v2(344.11,83.31)
N27615041: length 54.4
  TOP w0.13: D381.2 343.25,49.19 342.91,49.53 v1(342.91,49.56) ; R3002.2 v1(388.43,57.53)
  SIG6 w0.155: v1(342.91,49.56) 342.91,49.53 343.24,49.86 344.82,49.86 345.12,50.16 346.77,50.16 347.08,49.86 362.7,49.86 364.05,48.51 382.83,48.51 383.74,49.41 383.74,53.85 386.91,57.02 387.92,57.02 v1(388.43,57.53)
N27615043: length 43.4
  TOP w0.254: v1(346.46,49.56) 346.46,49.53 345.83,48.89 345.19,48.89 344.89,49.19 D381.1
  SIG2 w0.254: v1(345.86,80.54) 344.36,79.04 344.36,56.51 341.31,53.46 341.31,49.27 341.59,48.99 345.93,48.99 346.46,49.53 v1(346.46,49.56)
  BOTTOM w0.254: R2998.1 344.36,80.41 344.49,80.54 R3456.2 v1(345.86,80.54)
N27615047: length 65.5
  TOP w0.13: D377.2 332.06,49.19 v1(331.85,49.4)
  SIG8 w0.155: v1(331.85,49.4) 332.38,49.94 338.53,49.94 341.3,47.16 382.88,47.16 384.76,49.04 384.76,52.46 v1(387.54,55.24)
  BOTTOM w0.13: R2994.2 389.09,55.6 388.94,55.75 388.05,55.75 v1(387.54,55.24)
N27615049: length 43
  TOP w0.254: D377.1 333.96,49.19 334.39,48.77 335.02,48.77 335.66,49.4 v1(335.68,49.4) ; R2990.1 338.41,79.88 338.41,79.36 338.57,79.2 338.57,78.18 338.26,77.87 R3451.2 337.88,77.09 336.74,75.94 v1(335.47,75.94)
  SIG2 w0.254: v1(335.68,49.4) 338.14,51.85 338.14,54.99 341.06,57.91 341.06,72.77 337.88,75.94 v1(335.47,75.94)
  BOTTOM w0.13: v2(334.71,75.94) v1(335.47,75.94)
N27615053: length 81.2
  TOP w0.13: D373.2 315.65,48.77 315.92,48.49 319.51,48.49 v1(320.42,49.4) ; R2986.2 v1(388.43,55.24)
  SIG6 w0.155: v1(320.42,49.4) 326.66,49.4 328.9,47.16 383.42,47.16 384.5,48.24 384.5,52.59 386.65,54.73 387.92,54.73 v1(388.43,55.24)
N27615055: length 56.7
  TOP w0.254: v1(319.53,49.4) 319.02,48.89 317.24,48.89 316.95,49.19 D373.1
  SIG3 w0.254: v1(335.47,76.96) 336.8,75.63 336.8,74.48 339.74,71.55 339.74,52.52 337.12,49.91 320.04,49.91 v1(319.53,49.4)
  BOTTOM w0.254: v1(335.47,76.96) 335.85,76.58 v2(336.23,76.58) R3446.2 336.74,77.87 336.87,78 336.87,79.5 336.49,79.88 R2982.1
N27615059: length 87.1
  TOP w0.13: R2978.2 v1(388.43,52.96) ; D370.2 313.01,49.19 v1(312.8,49.4)
  SIG6 w0.155: v1(312.8,49.4) 314.83,47.37 327.3,47.37 331.6,43.07 382.89,43.07 384.35,44.53 384.35,46.46 385.27,47.38 385.27,50.81 386.91,52.45 387.92,52.45 v1(388.43,52.96)
N27615061: length 73.1
  TOP w0.254: R2974.1 336.97,80.41 337.12,80.26 337.12,78.1 336.89,77.87 R3444.2 v1(335.47,77.87) ; D370.1 314.35,48.92 314.06,48.63 312.68,48.63 v1(311.91,49.4)
  SIG2 w0.254: v1(335.47,77.87) 336.72,77.87 341.54,73.05 341.54,57.63 338.65,54.73 338.65,49.53 336.61,47.5 331.41,47.5 327.98,44.07 320.48,44.07 317.06,47.5 315.53,47.5 312.99,50.04 312.54,50.04 v1(311.91,49.4)
  BOTTOM w0.13: v1(335.47,77.87) 335.45,77.85 v2(334.71,77.85)
N27615065: length 104
  TOP w0.13: v1(295.91,49.4) 295.91,49.41 296.12,49.19 D366.2
  SIG2 w0.155: v1(295.91,49.4) 296.44,49.94 299.58,49.94 306.44,43.07 381.34,43.07 386.14,47.87 386.14,51.56 v1(387.54,52.96)
  BOTTOM w0.13: v1(387.54,52.96) 388.05,53.46 388.94,53.46 389.09,53.31 R2970.2
N27615067: length 78.4
  TOP w0.254: v1(299.46,49.4) 298.95,48.89 298.19,48.89 297.9,49.19 D366.1
  SIG3 w0.254: v1(299.46,49.4) 300.22,48.64 300.22,48.58 301.43,47.37 336.23,47.37 340.93,52.07 340.93,72.07 339.28,73.72 339.28,76.71 v1(338.77,77.21)
  BOTTOM w0.254: v2(339.15,76.45) 338.77,76.83 v1(338.77,77.21) 339.03,77.21 339.28,77.47 R3440.2 338.77,77.87 338.57,78.08 338.57,79.18 338.41,79.33 338.41,79.72 339.11,80.41 R2966.1
N27617200: length 103.5
  TOP w0.13: R3087.2 v1(7.79,43.81)
  SIG7 w0.155: v1(99.64,49.27) 87.32,36.95 12.71,36.95 9.75,39.91 8.66,39.91 8.29,40.28 8.29,43.3 v1(7.79,43.81)
  BOTTOM w0.13: D423.2 99.56,49.19 v1(99.64,49.27)
N27617202: length 87.7
  SIG5 w0.254: v1(100.53,48) 99.51,46.99 78.17,46.99 77.47,46.29 67.82,46.29 64.33,42.8 59.43,42.8 57.44,44.78 57.44,73.43 v1(56.07,74.8)
  BOTTOM w0.254: v1(100.53,48) 99.9,48.64 98.23,48.64 98.05,48.82 D423.1 ; R3083.1 56.86,80.41 56.71,80.26 56.71,78.1 56.93,77.87 R3497.2 57.34,77.54 56.58,76.78 56.58,76.32 57.09,75.82 v2(57.09,75.31) 56.58,74.8 v1(56.07,74.8)
N27617204: length 86.8
  SIG7 w0.155: v1(82.62,49.4) 82.1,49.4 79.94,47.24 78.68,47.24 69.54,38.11 13.24,38.11 10.05,41.3 10.05,44.43 9.53,44.96 v1(9.21,44.96)
  BOTTOM w0.13: D419.2 82.41,49.19 v1(82.62,49.4) ; v1(9.21,44.96) 8.57,45.59 7.33,45.59 R3079.2
N27617206: length 64.9
  SIG5 w0.254: v1(60.13,76.58) 59.58,76.02 59.58,53.57 58.89,52.88 58.89,48.11 59.52,47.48 65.85,47.48 68.41,50.04 77.89,50.04 78.41,49.52 81.84,49.52 82.36,50.04 82.88,50.04 v1(83.51,49.4)
  BOTTOM w0.254: D419.1 81.05,48.82 81.23,48.64 82.75,48.64 v1(83.51,49.4) ; R3075.1 58.26,80.41 58.1,80.26 58.1,78.1 58.33,77.87 R3493.2 58.74,77 v2(59.09,76.65) 59.16,76.58 v1(60.13,76.58)
N27617212: length 83.6
  SIG7 w0.155: v1(75.13,49.4) 73.98,49.4 63.56,38.99 13.47,38.99 10.83,41.63 10.83,44.96 9.69,46.1 v1(9.21,46.1)
  BOTTOM w0.13: R3071.2 7.2,46.61 8.7,46.61 v1(9.21,46.1) ; v1(75.13,49.4) 76.05,48.49 79.45,48.49 79.75,48.79 D415.2
N27617214: length 56.3
  TOP w0.254: v1(58.23,74.67) 57.34,75.56 R3489.2 56.93,77.87 56.71,78.1 56.71,80.26 56.86,80.41 R3068.1
  SIG10 w0.254: v1(76.02,49.4) 75.26,48.64 68.52,48.64 67.37,47.5 59.12,47.5 57.59,49.02 57.59,74.04 v1(58.23,74.67)
  BOTTOM w0.254: v1(76.02,49.4) 76.53,48.89 78.05,48.89 78.35,49.19 D415.1
N27617218: length 63.2
  TOP w0.13: R3063.2 v1(7.79,47.24)
  SIG7 w0.155: v1(63.57,49.4) 63.18,49.4 61.28,47.5 61.02,47.5 55.99,42.46 12.78,42.46 11.21,44.02 11.21,45.12 9.6,46.73 8.45,46.73 7.94,47.24 v1(7.79,47.24)
  BOTTOM w0.13: D411.2 63.36,49.19 v1(63.57,49.4)
N27617220: length 42.2
  SIG5 w0.254: v1(64.46,48) 63.7,48.77 59.63,48.77 59.37,49.02 59.37,52.68 60.06,53.37 60.06,75.61 v1(60.13,75.69)
  BOTTOM w0.254: v1(64.46,48) 63.83,48.64 62.18,48.64 62.05,48.77 D411.1 ; v1(60.13,75.69) v2(61.02,76.58) 61.02,76.98 R3485.2 59.63,77.87 59.5,78 59.5,80.29 59.63,80.41 R3059.1
N27617224: length 52.1
  TOP w0.13: v1(7.79,48.38) R3055.2
  SIG7 w0.155: v1(7.79,48.38) 7.94,48.38 8.45,47.88 9.54,47.88 11.98,45.44 11.98,44.34 13.1,43.23 46.6,43.23 v1(52.64,49.27)
  BOTTOM w0.13: v1(52.64,49.27) 52.56,49.19 D407.2
N27617226: length 40.2
  SIG8 w0.254: v1(53.53,48) 54.16,48.63 54.16,49.54 54.67,50.05 54.67,55.62 53.4,56.89 53.4,70.1 52.39,71.12 52.39,73.38 v1(52.92,73.91)
  BOTTOM w0.254: v1(53.53,48) 52.9,48.64 51.24,48.64 51.05,48.83 D407.1 ; v1(52.92,73.91) 52.77,73.91 51.63,75.05 51.63,76.48 v2(51.99,76.84) 52.36,77.21 52.9,77.21 53.15,77.47 R3481.2 52.49,77.87 52.39,77.98 52.39,80.26 52.54,80.41 R3052.1
N27617230: length 32.2
  SIG7 w0.155: v1(9.21,49.53) 9.84,49.53 12,47.37 30.92,47.37 32.96,49.4 v1(35.62,49.4)
  BOTTOM w0.13: R3047.2 7.33,50.16 8.57,50.16 v1(9.21,49.53) ; D403.2 35.41,49.19 v1(35.62,49.4)
N27617232: length 77.2
  SIG8 w0.254: v1(36.51,49.4) 37.21,48.7 37.54,48.7 38.81,47.43 41.91,47.43 45.78,43.56 54.13,43.56 56.07,45.5 56.07,55.62 54.57,57.12 54.57,76.48 56.83,78.74 56.83,79.88 59.25,82.29 59.25,85.72 59.75,86.23 v1(60.13,86.23)
  BOTTOM w0.254: v1(36.51,49.4) 35.75,48.64 34.23,48.64 34.05,48.82 D403.1 ; v1(60.13,86.23) R3043.1 59.45,87.96 59.45,90.12 59.65,90.32 ; 59.65,90.32 59.37,90.6 v2(59.37,92.58) ; 59.65,90.32 R3477.2
N27617236: length 29.6
  SIG5 w0.155: v1(28.13,49.4) 18.61,49.4 17.72,48.51 15.81,48.51 14.67,47.37 12.51,47.37 v1(9.21,50.67)
  BOTTOM w0.13: v1(9.21,50.67) 8.7,51.18 7.2,51.18 R3039.2 ; v1(28.13,49.4) 29.05,48.49 32.45,48.49 32.75,48.79 D399.2
N27617238: length 77.9
  SIG10 w0.254: v1(59.75,82.8) 58.23,81.28 58.23,80.13 57.98,79.88 57.98,78.23 57.09,77.34 57.09,50.54 54.04,47.5 39.27,47.5 38,48.77 35.37,48.77 34.73,49.4 31.75,49.4 31.18,48.83 29.59,48.83 v1(29.02,49.4)
  BOTTOM w0.254: v1(29.02,49.4) 29.53,48.89 31.05,48.89 31.35,49.19 D399.1 ; R3473.2 57.62,90.32 57.09,89.79 57.09,88.52 v2(57.28,88.33) 58.33,87.27 R3036.1 58.74,86.74 58.23,86.23 58.23,84.96 59.25,83.94 59.25,83.31 v1(59.75,82.8)
