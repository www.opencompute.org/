# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC8_TDP0: length 190.9
  TOP w0.147: U1.BV65 166,163.84 arc(165.68,163.97) v4(165.55,164.29)
  SIG7 w0.112: 163.26,163.09 163.28,163.09 163.38,163 164.68,163 arc(164.71,163) 164.75,163.02 arc(164.76,163.03) 164.77,163.04 164.87,163.14 arc(164.91,163.2) 164.92,163.26 164.92,163.55 arc(165.04,163.83) 165.31,163.94 165.38,163.94 arc(165.5,163.99) 165.55,164.1 v4(165.55,164.29)
  SIG7 w0.16: YJ24.D3 76.3,52.74 arc(76.25,53.01) 76.09,53.24 75.75,53.58 arc(75.57,53.85) 75.51,54.16 75.51,54.48 arc(75.51,54.53) 75.5,54.58 arc(75.46,54.68) 75.39,54.77 75.35,54.82 75.26,54.9 arc(75.14,54.98) 74.99,55.01 63.13,55.01 arc(62.84,55.07) 62.59,55.24 58.28,59.55 arc(58.11,59.8) 58.05,60.09 58.05,70.99 arc(58.11,71.28) 58.28,71.53 63.07,76.32 arc(63.15,76.44) 63.18,76.59 63.18,90.26 arc(63.24,90.56) 63.41,90.8 69.02,96.42 arc(69.27,96.59) 69.56,96.64 87.78,96.64 arc(87.93,96.67) 88.05,96.76 116.28,124.99 arc(116.37,125.11) 116.4,125.26 116.4,127.78 arc(116.45,128.07) 116.62,128.32 151.57,163.27 arc(151.82,163.44) 152.11,163.5 162.1,163.5 arc(162.35,163.45) 162.57,163.3 162.7,163.18 arc(162.79,163.11) 162.9,163.09 163.26,163.09
FC8_TDP1: length 190.9
  TOP w0.147: v4(167.57,163.39) 167.57,163.32 U1.BU63
  SIG6 w0.112: v4(167.57,163.39) 167.57,163.62 arc(167.54,163.71) 167.45,163.74 167.29,163.74 arc(167.06,163.84) 166.96,164.07 166.96,164.56 arc(166.95,164.6) 166.93,164.65 166.87,164.7 arc(166.83,164.73) 166.78,164.74 163.38,164.74 163.28,164.64 163.26,164.64
  SIG6 w0.16: YJ24.D5 74.85,53.97 arc(74.96,54.14) 75,54.34 75,54.52 arc(74.9,54.76) 74.66,54.86 73.76,54.86 arc(73.46,54.92) 73.22,55.08 73.13,55.17 arc(72.88,55.34) 72.59,55.39 63.78,55.39 arc(63.64,55.42) 63.51,55.51 62.28,56.74 62.28,57.08 61.97,57.39 61.63,57.39 61.29,57.73 61.29,58.04 60.95,58.38 60.64,58.38 60.3,58.72 60.3,59.03 59.96,59.37 59.65,59.37 59.31,59.71 59.31,60.02 58.97,60.36 58.65,60.36 58.09,60.93 arc(58,61.06) 57.98,61.2 57.98,70.48 arc(58,70.62) 58.09,70.75 63.23,75.89 arc(63.48,76.26) 63.56,76.7 63.56,90.08 arc(63.62,90.37) 63.79,90.62 69.21,96.04 arc(69.46,96.21) 69.75,96.26 87.63,96.26 arc(88.06,96.35) 88.43,96.6 116.44,124.61 arc(116.69,124.98) 116.78,125.41 116.78,127.62 arc(116.83,127.91) 117,128.16 151.73,162.89 arc(151.98,163.06) 152.27,163.12 159.06,163.12 arc(159.35,163.17) 159.6,163.34 160.68,164.42 arc(160.76,164.49) 160.85,164.55 arc(161.02,164.62) 161.22,164.64 163.26,164.64
FC8_TDP2: length 178.8
  TOP w0.147: U1.BT66 165,161.84 arc(164.68,161.97) v4(164.55,162.29)
  SIG7 w0.112: v4(164.55,162.29) 164.55,162.1 arc(164.5,161.99) 164.38,161.94 164.24,161.94 arc(164.01,161.85) 163.92,161.62 163.92,161.29 arc(163.9,161.2) 163.84,161.12 163.76,161.04 arc(163.75,161.03) 163.74,161.02 arc(163.71,161) 163.67,161 163.23,161 163.14,161.09 163.11,161.09
  SIG7 w0.16: 163.11,161.09 161.77,161.09 arc(161.71,161.1) 161.66,161.13 161.54,161.26 arc(161.37,161.37) 161.17,161.41 153.03,161.41 arc(152.74,161.36) 152.49,161.19 118.78,127.48 arc(118.61,127.23) 118.55,126.94 118.55,124.49 arc(118.53,124.35) 118.44,124.22 88.82,94.6 arc(88.69,94.51) 88.55,94.49 75.08,94.49 arc(74.78,94.43) 74.54,94.26 66.58,86.31 arc(66.42,86.06) 66.36,85.77 66.36,73.72 arc(66.33,73.57) 66.25,73.45 60.36,67.56 arc(60.19,67.31) 60.13,67.02 60.13,61.95 arc(60.19,61.65) 60.36,61.41 62.53,59.24 arc(62.77,59.07) 63.07,59.01 74.99,59.01 arc(75.14,58.98) 75.26,58.9 75.35,58.82 75.39,58.77 arc(75.45,58.7) 75.49,58.61 arc(75.49,58.6) 75.5,58.59 arc(75.51,58.53) 75.51,58.48 75.51,58.16 arc(75.57,57.85) 75.75,57.58 76.06,57.28 arc(76.24,57.01) 76.3,56.69 YJ24.D36
FC8_TDP3: length 178.8
  TOP w0.147: v4(166.55,161.39) 166.55,161.34 U1.BR64
  SIG6 w0.112: v4(166.55,161.39) 166.55,161.62 arc(166.51,161.71) 166.42,161.74 166.25,161.74 arc(166.02,161.84) 165.92,162.07 165.92,162.56 arc(165.91,162.6) 165.89,162.65 165.83,162.7 arc(165.79,162.73) 165.74,162.74 163.38,162.74 163.28,162.64 163.26,162.64
  SIG6 w0.16: YJ24.D34 74.85,57.97 arc(74.96,58.14) 75,58.34 75,58.52 arc(74.9,58.76) 74.66,58.86 73.76,58.86 arc(73.46,58.92) 73.22,59.08 73.13,59.17 arc(72.88,59.34) 72.59,59.39 63.66,59.39 arc(63.52,59.42) 63.39,59.51 61.94,60.96 61.94,61.3 61.62,61.62 61.28,61.62 60.37,62.53 arc(60.29,62.65) 60.26,62.8 60.26,63.28 60.48,63.5 60.48,63.98 60.26,64.2 60.26,64.68 60.48,64.9 60.48,65.38 60.26,65.6 60.26,66.21 60.48,66.43 60.48,66.91 60.26,67.13 60.26,67.78 arc(60.29,67.93) 60.37,68.05 61.08,68.76 62.07,69.75 62.07,69.75 62.72,70.4 66.52,74.2 arc(66.68,74.44) 66.74,74.74 66.74,85.74 arc(66.77,85.89) 66.85,86.01 74.83,93.99 arc(74.95,94.08) 75.1,94.1 88.39,94.1 arc(88.83,94.19) 89.2,94.44 118.6,123.84 arc(118.85,124.21) 118.94,124.65 118.94,126.89 arc(118.96,127.03) 119.05,127.16 152.81,160.92 arc(152.94,161) 153.08,161.03 160.18,161.03 arc(160.47,161.09) 160.72,161.26 161.88,162.42 arc(162.13,162.59) 162.42,162.64 163.26,162.64
FC9_RDN0: length 174.6
  TOP w0.147: U1.BN54 176.55,159.34 v4(176.55,159.39)
  SIG8 w0.112: v4(176.55,159.39) 176.55,159.64 arc(176.52,159.71) 176.45,159.74 176.22,159.74 arc(176.15,159.71) 176.12,159.64 176.12,158.18 arc(176.09,158.01) 175.99,157.87 175.93,157.81 175.92,157.81 arc(175.8,157.76) 175.68,157.74 170.23,157.74 arc(170.11,157.72) 170.01,157.65 169.45,157.08 arc(169.07,156.83) 168.63,156.74 163.32,156.74 163.22,156.65 163.2,156.65
  SIG8 w0.16: 163.2,156.65 162.56,156.65 arc(162.26,156.59) 162,156.41 160.86,155.27 arc(160.61,155.09) 160.33,154.97 arc(160.19,154.95) 160.05,154.94 153.28,154.94 arc(152.97,154.88) 152.71,154.7 123.49,125.48 arc(123.31,125.22) 123.25,124.91 123.25,111.07 arc(123.16,110.62) 122.91,110.24 112.52,99.85 arc(112.14,99.6) 111.69,99.51 100.67,99.51 arc(100.36,99.45) 100.1,99.27 93.12,92.29 arc(92.74,92.04) 92.28,91.95 73.1,91.95 arc(72.79,91.88) 72.53,91.71 69.04,88.23 arc(68.88,87.98) 68.82,87.69 68.82,80.01 69.05,79.78 69.05,79.22 68.82,78.99 68.82,78.48 69.05,78.25 69.05,77.7 68.82,77.47 68.82,76.96 69.05,76.73 69.05,76.17 68.82,75.94 68.82,75.44 69.05,75.21 69.05,74.65 68.82,74.42 68.82,73.91 69.08,73.66 69.08,73.15 68.82,72.9 68.82,71.98 arc(68.73,71.53) 68.48,71.15 66.44,69.11 arc(66.06,68.86) 65.6,68.77 65.26,68.77 arc(64.95,68.7) 64.69,68.53 64,67.84 arc(63.92,67.72) 63.89,67.57 63.89,67.07 arc(63.95,66.92) 64.1,66.86 64.9,66.86 arc(65.1,66.82) 65.26,66.71 65.32,66.65 arc(65.38,66.56) 65.4,66.45 65.4,66.34 arc(65.36,66.14) 65.25,65.97 YJ24.C22
FC9_RDN1: length 182.1
  TOP w0.147: v4(172.55,160.29) 172.55,160.22 arc(172.56,160.15) 172.6,160.09 172.71,159.98 arc(172.86,159.88) U1.BP58
  SIG9 w0.112: v4(172.55,160.29) 172.55,160.07 arc(172.54,160.03) 172.52,159.99 172.49,159.97 arc(172.46,159.95) 172.42,159.94 172.22,159.94 arc(172.15,159.97) 172.12,160.04 172.12,160.5 arc(172.09,160.66) 172,160.8 arc(171.85,160.9) 171.69,160.93 163.55,160.93 arc(163.49,160.94) 163.44,160.98 163.43,160.99 arc(163.39,161.02) 163.34,161.02 163.29,161.02
  SIG9 w0.16: 163.29,161.02 162.8,161.02 arc(162.51,160.97) 162.26,160.8 160.82,159.35 arc(160.57,159.19) 160.28,159.13 153.94,159.13 arc(153.65,159.07) 153.4,158.91 126.94,132.44 120.94,126.44 arc(120.77,126.19) 120.71,125.9 120.71,111.82 arc(120.66,111.53) 120.49,111.29 119.82,110.62 arc(119.4,110.33) 118.9,110.23 115.72,110.23 arc(115.05,110.1) 114.49,109.73 114.11,109.34 arc(113.83,108.92) 113.73,108.42 113.73,105.16 arc(113.61,104.57) 113.28,104.08 111.38,102.18 arc(111.13,102.01) 110.84,101.95 102.56,101.95 arc(102.27,101.9) 102.02,101.73 92.84,92.55 arc(92.59,92.38) 92.3,92.33 69.34,92.33 arc(69.05,92.27) 68.8,92.1 66.58,89.88 arc(66.42,89.64) 66.36,89.34 66.36,72.89 arc(66.3,72.59) 66.13,72.35 63.33,69.55 62.4,68.61 arc(62.23,68.37) 62.18,68.07 62.18,64.69 arc(62.26,64.25) 62.51,63.88 63.05,63.35 arc(63.42,63.1) 63.86,63.01 65.39,63.01 arc(65.54,62.98) 65.66,62.9 65.75,62.82 65.79,62.77 arc(65.85,62.7) 65.89,62.61 arc(65.9,62.59) 65.9,62.57 arc(65.91,62.53) 65.91,62.48 65.91,62.16 arc(65.97,61.85) 66.15,61.58 66.5,61.24 arc(66.65,61.01) 66.7,60.75 YJ24.C15
FC9_RDN2: length 182.4
  TOP w0.147: v4(174.55,159.39) 174.55,159.34 U1.BN56
  SIG8 w0.112: v4(174.55,159.39) 174.55,159.64 arc(174.52,159.71) 174.45,159.74 174.22,159.74 arc(174.15,159.71) 174.12,159.64 174.12,159.05 arc(174.03,158.84) 173.82,158.75 163.29,158.75 163.2,158.66 163.17,158.66
  SIG8 w0.16: 163.17,158.66 154.05,158.66 arc(153.75,158.6) 153.49,158.42 121.33,126.27 arc(121.16,126.01) 121.09,125.7 121.09,111.96 arc(121,111.51) 120.75,111.13 119.82,110.2 arc(119.44,109.94) 118.99,109.85 115.46,109.85 arc(115.15,109.79) 114.89,109.62 114.34,109.07 arc(114.17,108.81) 114.11,108.5 114.11,104.88 arc(114.02,104.43) 113.76,104.05 111.64,101.92 arc(111.25,101.66) 110.8,101.57 99.71,101.57 arc(99.41,101.51) 99.15,101.34 92.26,94.45 arc(91.88,94.19) 91.43,94.1 71.67,94.1 arc(71.37,94.04) 71.11,93.87 66.97,89.74 arc(66.8,89.48) 66.74,89.17 66.74,80.82 66.97,80.59 66.97,80.03 66.74,79.8 66.74,79.3 66.97,79.07 66.97,78.51 66.74,78.28 66.74,77.77 66.97,77.54 66.97,76.98 66.74,76.76 66.74,75.11 66.99,74.85 66.99,74.34 66.74,74.09 66.74,73.05 arc(66.65,72.6) 66.39,72.22 62.06,67.89 arc(61.89,67.63) 61.83,67.32 61.83,63.92 61.83,63.92 arc(61.87,63.72) 61.98,63.55 arc(62.15,63.43) 62.35,63.39 62.99,63.39 arc(63.28,63.34) 63.53,63.17 63.61,63.09 arc(63.87,62.92) 64.17,62.86 65.04,62.86 arc(65.19,62.83) 65.32,62.74 arc(65.38,62.65) 65.4,62.54 65.4,62.35 arc(65.36,62.14) 65.25,61.97 YJ24.C17
FC9_RDN3: length 167.9
  TOP w0.147: v4(170.55,160.29) 170.55,160.22 arc(170.56,160.15) 170.6,160.09 170.71,159.98 arc(170.86,159.88) U1.BP60
  SIG9 w0.112: v4(170.55,160.29) 170.55,160.07 arc(170.54,160.02) 170.51,159.98 170.51,159.98 arc(170.46,159.95) 170.42,159.94 170.22,159.94 arc(170.01,159.85) 169.93,159.64 169.93,159.18 arc(169.92,159.13) 169.89,159.09 169.77,158.97 arc(169.73,158.95) 169.68,158.94 163.51,158.94 arc(163.39,158.96) 163.28,159.03
  SIG9 w0.16: 163.28,159.03 163.12,159.03 arc(162.69,158.94) 162.31,158.69 161.69,158.07 arc(161.44,157.7) 161.35,157.26 161.35,156.68 arc(161.35,156.68) 161.35,156.68 arc(161.35,156.63) 161.35,156.58 161.35,156.56 161.35,156.51 arc(161.32,156.37) 161.23,156.24 160.59,155.6 arc(160.56,155.57) 160.53,155.55 160.22,155.35 arc(160.11,155.33) 159.99,155.32 153.29,155.32 arc(152.85,155.23) 152.48,154.98 123.21,125.71 arc(122.96,125.34) 122.87,124.9 122.87,110.9 arc(122.84,110.76) 122.76,110.64 117.44,105.32 112.13,100 arc(112,99.92) 111.86,99.89 104.84,99.89 arc(104.4,99.8) 104.03,99.55 98.19,93.71 92.35,87.87 arc(92.22,87.78) 92.08,87.75 77.21,87.75 arc(77.07,87.78) 76.94,87.87 76.58,88.23 arc(76.21,88.48) 75.77,88.57 69.77,88.57 arc(69.33,88.48) 68.96,88.23 68.78,88.04 arc(68.53,87.67) 68.44,87.24 68.44,71.35 arc(68.41,71.2) 68.33,71.08 65.67,68.41 arc(65.35,67.66) 65.67,66.9 65.75,66.82 65.79,66.77 arc(65.85,66.7) 65.89,66.61 arc(65.89,66.6) 65.89,66.59 arc(65.91,66.54) 65.91,66.48 65.91,66.16 arc(65.97,65.85) 66.15,65.58 66.5,65.24 arc(66.65,65.01) 66.7,64.75 YJ24.C24
FC9_RDP0: length 174.6
  TOP w0.147: U1.BP54 177.02,159.84 arc(176.84,159.88) 176.69,159.98 176.61,160.06 arc(176.56,160.13) 176.55,160.21 v4(176.55,160.29)
  SIG8 w0.112: v4(176.55,160.29) 176.55,160.04 arc(176.52,159.97) 176.45,159.94 176.22,159.94 arc(176.01,159.85) 175.92,159.64 175.92,158.18 arc(175.9,158.09) 175.85,158.01 arc(175.83,157.99) 175.81,157.98 arc(175.75,157.95) 175.68,157.94 170.23,157.94 arc(170.04,157.9) 169.87,157.79 169.52,157.43 169.38,157.29 169.31,157.22 arc(168.99,157.01) 168.63,156.94 163.32,156.94 163.22,157.03 163.2,157.03
  SIG8 w0.16: YJ24.C21 64.3,64.86 arc(64.27,65.02) 64.17,65.16 63.64,65.69 arc(63.55,65.84) 63.51,66.01 63.51,67.57 arc(63.57,67.87) 63.73,68.11 64.42,68.8 arc(64.8,69.06) 65.26,69.15 65.6,69.15 arc(65.91,69.21) 66.17,69.38 68.21,71.42 arc(68.38,71.68) 68.44,71.98 68.44,87.69 arc(68.53,88.12) 68.78,88.5 72.26,91.98 arc(72.64,92.24) 73.1,92.33 92.28,92.33 arc(92.59,92.39) 92.85,92.56 99.83,99.54 arc(100.21,99.8) 100.67,99.89 111.69,99.89 arc(111.99,99.95) 112.25,100.12 122.64,110.51 arc(122.81,110.77) 122.87,111.07 122.87,124.91 arc(122.96,125.37) 123.22,125.75 152.44,154.97 arc(152.83,155.23) 153.28,155.32 160.05,155.32 arc(160.14,155.32) 160.23,155.34 arc(160.42,155.42) 160.59,155.54 161.73,156.68 arc(162.11,156.94) 162.56,157.03 163.2,157.03
FC9_RDP1: length 182.1
  TOP w0.147: v4(172.55,159.39) 172.55,159.34 U1.BN58
  SIG9 w0.112: v4(172.55,159.39) 172.55,159.61 arc(172.54,159.66) 172.51,159.7 172.51,159.71 arc(172.46,159.73) 172.42,159.74 172.22,159.74 arc(172.01,159.83) 171.93,160.04 171.93,160.5 arc(171.91,160.59) 171.86,160.67 arc(171.78,160.72) 171.69,160.74 163.53,160.74 arc(163.49,160.73) 163.45,160.7 163.43,160.68 arc(163.39,160.65) 163.34,160.64 163.29,160.64
  SIG9 w0.16: YJ24.C14 67.65,61.97 arc(67.76,62.14) 67.8,62.34 67.8,62.52 arc(67.7,62.76) 67.46,62.86 66.68,62.86 arc(66.27,62.94) 65.93,63.17 arc(65.68,63.34) 65.39,63.39 63.86,63.39 arc(63.56,63.45) 63.32,63.62 62.78,64.15 arc(62.62,64.4) 62.56,64.69 62.56,66.55 62.79,66.78 62.79,67.34 62.56,67.57 62.56,68.07 arc(62.59,68.22) 62.67,68.34 63.03,68.7 63.36,68.7 63.75,69.09 63.75,69.42 64.17,69.85 64.51,69.85 64.83,70.17 64.83,70.51 65.19,70.87 65.53,70.87 65.91,71.25 65.91,71.59 66.4,72.08 arc(66.65,72.45) 66.74,72.89 66.74,89.34 arc(66.77,89.49) 66.85,89.61 67.96,90.72 69.07,91.83 arc(69.19,91.92) 69.34,91.95 92.3,91.95 arc(92.74,92.03) 93.11,92.28 102.29,101.46 arc(102.41,101.54) 102.56,101.57 110.84,101.57 arc(111.28,101.66) 111.65,101.91 113.55,103.81 arc(113.96,104.43) 114.11,105.16 114.11,108.42 arc(114.18,108.78) 114.38,109.07 114.76,109.46 arc(115.2,109.75) 115.72,109.85 118.9,109.85 arc(119.54,109.98) 120.09,110.35 120.76,111.02 arc(121.01,111.39) 121.09,111.82 121.09,125.9 arc(121.12,126.05) 121.21,126.17 126.94,131.9 137.44,142.4 153.67,158.64 arc(153.8,158.72) 153.94,158.75 160.28,158.75 arc(160.71,158.83) 161.08,159.08 162.53,160.53 arc(162.66,160.61) 162.8,160.64 163.29,160.64
FC9_RDP2: length 182.4
  TOP w0.147: U1.BP56 175.02,159.84 arc(174.84,159.88) 174.69,159.98 174.61,160.06 arc(174.56,160.13) 174.55,160.21 v4(174.55,160.29)
  SIG8 w0.112: v4(174.55,160.29) 174.55,160.04 arc(174.52,159.97) 174.45,159.94 174.22,159.94 arc(174.01,159.85) 173.92,159.64 173.92,159.05 arc(173.89,158.98) 173.82,158.95 163.29,158.95 163.2,159.04 163.17,159.04
  SIG8 w0.16: 163.17,159.04 154.05,159.04 arc(153.6,158.95) 153.22,158.69 121.06,126.54 arc(120.8,126.15) 120.71,125.7 120.71,111.96 arc(120.65,111.66) 120.48,111.4 119.55,110.47 arc(119.29,110.29) 118.99,110.23 115.46,110.23 arc(115.01,110.14) 114.62,109.89 114.07,109.34 arc(113.82,108.96) 113.73,108.5 113.73,104.88 arc(113.67,104.57) 113.49,104.32 111.37,102.19 arc(111.11,102.01) 110.8,101.95 99.71,101.95 arc(99.26,101.86) 98.88,101.61 91.99,94.72 arc(91.73,94.55) 91.43,94.49 71.67,94.49 arc(71.22,94.4) 70.84,94.14 66.7,90.01 arc(66.45,89.62) 66.36,89.17 66.36,73.05 arc(66.3,72.75) 66.12,72.49 61.79,68.16 arc(61.54,67.77) 61.45,67.32 61.45,63.92 arc(61.51,63.57) 61.71,63.28 arc(62,63.08) 62.35,63.01 62.99,63.01 arc(63.14,62.98) 63.26,62.9 63.35,62.82 63.39,62.77 arc(63.44,62.71) 63.48,62.64 arc(63.49,62.62) 63.49,62.61 arc(63.49,62.61) 63.49,62.6 arc(63.51,62.54) 63.51,62.48 63.51,62.07 arc(63.56,61.84) 63.69,61.65 63.93,61.41 64.12,61.22 arc(64.25,61.02) 64.3,60.78 YJ24.C18
FC9_RDP3: length 167.9
  TOP w0.147: U1.BN60 170.55,159.34 v4(170.55,159.39)
  SIG9 w0.112: 163.28,158.65 163.29,158.65 arc(163.4,158.71) 163.52,158.74 169.68,158.74 arc(169.81,158.76) 169.91,158.83 170.03,158.95 arc(170.1,159.05) 170.12,159.18 170.12,159.64 arc(170.15,159.71) 170.22,159.74 170.42,159.74 arc(170.46,159.74) 170.49,159.71 170.52,159.69 arc(170.54,159.66) 170.55,159.62 v4(170.55,159.39)
  SIG9 w0.16: YJ24.C25 67.65,65.97 arc(67.76,66.14) 67.8,66.34 67.8,66.52 arc(67.7,66.76) 67.46,66.86 66.67,66.86 arc(66.27,66.94) 65.94,67.17 arc(65.73,67.66) 65.94,68.15 66.29,68.5 66.63,68.5 67.01,68.89 67.01,69.22 67.37,69.58 67.71,69.58 68.09,69.97 68.09,70.3 68.6,70.81 arc(68.76,71.06) 68.82,71.35 68.82,71.85 69.05,72.08 69.05,72.64 68.82,72.87 68.82,73.38 69.05,73.61 69.05,74.17 68.82,74.39 68.82,87.24 arc(68.88,87.53) 69.04,87.77 69.23,87.96 arc(69.48,88.13) 69.77,88.19 75.77,88.19 arc(76.06,88.13) 76.31,87.96 76.68,87.6 arc(76.92,87.43) 77.21,87.37 92.08,87.37 arc(92.37,87.43) 92.62,87.6 104.3,99.28 arc(104.55,99.45) 104.84,99.51 111.86,99.51 arc(112.15,99.57) 112.4,99.73 123.03,110.37 arc(123.2,110.61) 123.25,110.9 123.25,124.9 arc(123.31,125.2) 123.48,125.44 152.75,154.71 arc(153,154.88) 153.29,154.94 159.99,154.94 arc(160.19,154.95) 160.39,155.01 160.73,155.23 arc(160.8,155.28) 160.86,155.33 161.5,155.97 arc(161.67,156.22) 161.73,156.51 161.73,156.54 arc(161.73,156.61) 161.73,156.68 161.73,157.26 arc(161.79,157.55) 161.96,157.8 162.58,158.42 arc(162.83,158.59) 163.12,158.65 163.28,158.65
FC9_TDN0: length 185.1
  TOP w0.147: U1.BT62 169,161.84 arc(168.68,161.97) v4(168.55,162.29)
  SIG6 w0.112: 163.16,161.01 163.18,161.01 163.27,160.92 167.74,160.92 arc(167.79,160.93) 167.83,160.96 167.89,161.01 arc(167.91,161.05) 167.92,161.1 167.92,161.62 arc(168.02,161.85) 168.25,161.94 168.42,161.94 arc(168.51,161.98) 168.55,162.07 v4(168.55,162.29)
  SIG6 w0.16: 163.16,161.01 162.62,161.01 arc(162.18,160.93) 161.81,160.68 159.23,158.1 arc(159.11,158.01) 158.96,157.99 152.99,157.99 arc(152.55,157.9) 152.18,157.65 121.05,126.52 arc(120.8,126.15) 120.71,125.71 120.71,111.95 arc(120.66,111.65) 120.49,111.41 119.48,110.4 arc(119.23,110.23) 118.94,110.17 115.38,110.17 arc(114.94,110.09) 114.57,109.84 114.06,109.33 arc(113.82,108.96) 113.73,108.52 113.73,104.68 arc(113.7,104.54) 113.62,104.41 111.29,102.09 arc(111.17,102.01) 111.03,101.98 99.56,101.98 arc(99.27,101.92) 99.02,101.76 89.82,92.55 arc(89.57,92.38) 89.28,92.33 78.38,92.33 arc(77.95,92.24) 77.57,91.99 75.4,89.82 arc(75.16,89.45) 75.07,89.01 75.07,74.69 arc(75.01,74.4) 74.85,74.15 73.31,72.61 arc(73.06,72.45) 72.77,72.39 69.07,72.39 arc(68.63,72.3) 68.26,72.05 62.55,66.34 arc(62.3,65.97) 62.21,65.53 62.21,64.35 arc(62.27,64.06) 62.44,63.82 63.02,63.24 arc(63.26,63.07) 63.55,63.01 74.99,63.01 arc(75.14,62.98) 75.26,62.9 75.35,62.82 75.39,62.77 arc(75.46,62.69) 75.5,62.58 arc(75.51,62.53) 75.51,62.48 75.51,62.16 arc(75.57,61.85) 75.75,61.58 76.14,61.19 arc(76.26,61.02) 76.3,60.81 YJ24.C3
FC9_TDN1: length 179.2
  TOP w0.147: v4(165.55,159.39) 165.55,159.34 U1.BN65
  SIG7 w0.112: v4(165.55,159.39) 165.55,159.58 arc(165.5,159.7) 165.38,159.74 165.25,159.74 arc(165.16,159.71) 165.12,159.62 165.12,159.29 arc(165.09,159.12) 164.99,158.98 164.91,158.9 arc(164.88,158.87) 164.85,158.85 arc(164.77,158.81) 164.68,158.8 163.38,158.8 163.28,158.71 163.26,158.71
  SIG7 w0.16: YJ24.C5 74.85,61.97 arc(74.96,62.14) 75,62.34 75,62.52 arc(74.9,62.76) 74.66,62.86 73.88,62.86 arc(73.47,62.94) 73.13,63.17 arc(72.88,63.34) 72.59,63.39 63.51,63.39 arc(63.36,63.42) 63.24,63.51 62.71,64.04 arc(62.62,64.16) 62.59,64.31 62.59,66.05 arc(62.62,66.2) 62.71,66.32 64.21,67.83 arc(64.34,67.91) 64.48,67.94 65.02,67.94 65.17,67.79 65.68,67.79 65.84,67.94 66.3,67.94 66.43,67.82 67,67.82 67.12,67.94 68.84,67.94 arc(69.13,68) 69.38,68.17 69.82,68.61 70.04,68.61 70.37,68.94 70.37,69.16 70.7,69.49 70.93,69.49 71.26,69.82 71.26,70.05 71.59,70.38 71.82,70.38 72.14,70.71 72.14,70.94 72.47,71.26 72.7,71.26 73.03,71.59 73.03,71.82 75.23,74.02 arc(75.39,74.27) 75.45,74.56 75.45,89.2 arc(75.48,89.34) 75.56,89.47 77.93,91.83 arc(78.05,91.92) 78.2,91.95 89.41,91.95 arc(89.7,92) 89.95,92.17 99.27,101.49 arc(99.39,101.57) 99.54,101.6 111,101.6 arc(111.29,101.66) 111.54,101.82 113.89,104.17 arc(114.05,104.42) 114.11,104.71 114.11,108.52 arc(114.17,108.81) 114.33,109.06 114.9,109.63 arc(115.15,109.79) 115.44,109.85 119,109.85 arc(119.44,109.94) 119.81,110.19 120.76,111.14 arc(121.01,111.51) 121.09,111.95 121.09,125.87 arc(121.12,126.02) 121.21,126.14 152.43,157.37 arc(152.55,157.45) 152.7,157.48 159.64,157.48 arc(159.93,157.54) 160.18,157.7 161.08,158.6 arc(161.2,158.68) 161.35,158.71 163.26,158.71
FC9_TDN2: length 155.1
  TOP w0.147: U1.BP63 168,159.84 arc(167.68,159.97) v4(167.55,160.29)
  SIG6 w0.112: v4(167.55,160.29) 167.55,160.07 arc(167.51,159.98) 167.42,159.94 167.25,159.94 arc(167.02,159.85) 166.92,159.62 166.92,159.13 arc(166.91,159.08) 166.89,159.04 166.83,158.99 arc(166.79,158.96) 166.74,158.95 163.38,158.95 163.28,159.04 163.26,159.04
  SIG6 w0.16: YJ24.C33 73.9,64.76 arc(73.85,65.01) 73.71,65.23 73.35,65.58 arc(73.17,65.85) 73.11,66.16 73.11,68.89 arc(73.2,69.33) 73.45,69.7 77.04,73.3 arc(77.12,73.42) 77.15,73.57 77.15,85.51 arc(77.24,85.95) 77.49,86.32 78.97,87.8 arc(79.34,88.05) 79.78,88.14 92.27,88.14 arc(92.57,88.19) 92.81,88.36 104.12,99.66 arc(104.37,99.83) 104.66,99.89 111.7,99.89 arc(111.99,99.95) 112.24,100.11 122.65,110.52 arc(122.81,110.77) 122.87,111.06 122.87,124.9 arc(122.96,125.34) 123.21,125.71 152.48,154.98 arc(152.85,155.23) 153.29,155.32 160.27,155.32 arc(160.42,155.35) 160.54,155.43 161.5,156.38 arc(161.58,156.5) 161.61,156.65 161.61,157.83 arc(161.67,158.12) 161.83,158.37 162.28,158.82 arc(162.53,158.98) 162.82,159.04 163.26,159.04
FC9_TDN3: length 150
  TOP w0.147: U1.BL66 164.55,157.34 v4(164.55,157.39)
  SIG7 w0.112: 163.16,156.71 163.18,156.71 163.27,156.8 163.67,156.8 arc(163.76,156.81) 163.85,156.85 arc(163.88,156.87) 163.9,156.9 163.98,156.98 arc(164.08,157.12) 164.11,157.29 164.11,157.62 arc(164.15,157.71) 164.24,157.74 164.38,157.74 arc(164.5,157.7) 164.55,157.58 v4(164.55,157.39)
  SIG7 w0.16: YJ24.C37 77.25,65.97 arc(77.36,66.14) 77.4,66.34 77.4,66.52 arc(77.3,66.76) 77.06,66.86 76.28,66.86 arc(75.87,66.94) 75.53,67.17 75.52,67.18 75.39,67.31 arc(75.1,67.74) 75,68.24 75,70.59 arc(75.03,70.73) 75.12,70.86 75.61,71.35 75.86,71.35 76.17,71.65 76.17,71.91 76.49,72.24 76.77,72.24 77.05,72.51 77.05,72.79 77.31,73.05 arc(77.48,73.3) 77.53,73.59 77.53,74.63 77.74,74.84 77.74,75.25 77.53,75.45 77.53,75.92 77.71,76.1 77.71,76.56 77.53,76.74 77.53,77.2 77.71,77.38 77.71,77.85 77.53,78.03 77.53,85.69 arc(77.56,85.84) 77.65,85.96 79.33,87.64 arc(79.45,87.73) 79.6,87.75 92.46,87.75 arc(92.75,87.81) 93,87.98 104.41,99.4 arc(104.54,99.48) 104.68,99.51 111.83,99.51 arc(112.12,99.56) 112.37,99.73 123.03,110.39 arc(123.2,110.64) 123.25,110.93 123.25,125.06 arc(123.28,125.21) 123.37,125.33 152.86,154.83 arc(152.98,154.91) 153.13,154.94 160.15,154.94 arc(160.44,155) 160.69,155.16 162.13,156.6 arc(162.25,156.68) 162.4,156.71 163.16,156.71
FC9_TDP0: length 185.1
  TOP w0.147: U1.BR62 168.55,161.34 v4(168.55,161.39)
  SIG6 w0.112: v4(168.55,161.39) 168.55,161.58 arc(168.54,161.63) 168.51,161.67 168.48,161.71 arc(168.44,161.73) 168.39,161.74 168.25,161.74 arc(168.16,161.71) 168.12,161.62 168.12,161.1 arc(168.09,160.98) 168.02,160.87 167.97,160.82 arc(167.87,160.75) 167.74,160.73 163.27,160.73 163.18,160.63 163.16,160.63
  SIG6 w0.16: 163.16,160.63 162.62,160.63 arc(162.33,160.58) 162.08,160.41 159.5,157.83 arc(159.25,157.66) 158.96,157.6 152.99,157.6 arc(152.69,157.55) 152.45,157.38 121.32,126.25 arc(121.15,126) 121.1,125.71 121.09,111.95 arc(121.01,111.51) 120.76,111.14 119.75,110.13 arc(119.38,109.88) 118.94,109.79 115.38,109.79 arc(115.09,109.73) 114.84,109.57 114.33,109.06 arc(114.17,108.81) 114.11,108.52 114.11,104.68 arc(114.05,104.39) 113.89,104.14 111.56,101.82 arc(111.32,101.66) 111.03,101.6 99.56,101.6 arc(99.42,101.57) 99.29,101.49 90.09,92.28 arc(89.72,92.03) 89.28,91.95 78.38,91.95 arc(78.09,91.89) 77.84,91.72 75.67,89.55 arc(75.51,89.31) 75.45,89.01 75.45,74.69 arc(75.36,74.25) 75.12,73.88 73.58,72.34 arc(73.21,72.09) 72.77,72.01 69.07,72.01 arc(68.78,71.95) 68.53,71.78 67.56,70.81 67.56,70.47 67.24,70.15 66.9,70.15 66.56,69.81 66.56,69.48 66.25,69.16 65.91,69.16 65.57,68.82 65.57,68.49 65.26,68.17 64.92,68.17 64.58,67.83 64.58,67.49 64.27,67.18 63.93,67.18 62.82,66.07 arc(62.65,65.82) 62.59,65.53 62.59,64.36 arc(62.62,64.21) 62.71,64.09 63.29,63.51 arc(63.41,63.42) 63.55,63.39 74.99,63.39 arc(75.28,63.34) 75.53,63.17 75.62,63.08 arc(75.86,62.92) 76.16,62.86 77.06,62.86 arc(77.3,62.76) 77.4,62.52 77.4,62.34 arc(77.36,62.14) 77.25,61.97 YJ24.C2
FC9_TDP1: length 179.2
  TOP w0.147: U1.BP65 166,159.84 arc(165.68,159.97) v4(165.55,160.29)
  SIG7 w0.112: 163.26,159.09 163.28,159.09 163.38,159 164.68,159 arc(164.71,159) 164.75,159.02 arc(164.76,159.03) 164.77,159.04 164.85,159.12 arc(164.9,159.2) 164.92,159.29 164.92,159.62 arc(165.02,159.85) 165.25,159.94 165.38,159.94 arc(165.5,159.99) 165.55,160.1 v4(165.55,160.29)
  SIG7 w0.16: 163.26,159.09 161.35,159.09 arc(161.06,159.03) 160.81,158.87 159.91,157.97 arc(159.79,157.89) 159.64,157.86 152.7,157.86 arc(152.41,157.8) 152.16,157.64 120.94,126.41 arc(120.77,126.17) 120.71,125.87 120.71,111.95 arc(120.66,111.65) 120.49,111.41 119.54,110.46 arc(119.29,110.29) 119,110.23 115.44,110.23 arc(115,110.15) 114.63,109.9 114.06,109.33 arc(113.82,108.96) 113.73,108.52 113.73,104.71 arc(113.7,104.56) 113.62,104.44 111.27,102.09 arc(111.15,102.01) 111,101.98 99.54,101.98 arc(99.24,101.92) 99,101.76 89.68,92.44 arc(89.56,92.36) 89.41,92.33 78.2,92.33 arc(77.91,92.27) 77.66,92.1 75.29,89.74 arc(75.13,89.49) 75.07,89.2 75.07,74.56 arc(75.04,74.41) 74.96,74.29 69.11,68.44 arc(68.98,68.35) 68.84,68.32 64.48,68.32 arc(64.19,68.27) 63.94,68.1 62.44,66.59 arc(62.27,66.35) 62.21,66.05 62.21,64.31 arc(62.27,64.02) 62.44,63.77 62.97,63.24 arc(63.22,63.07) 63.51,63.01 72.59,63.01 arc(72.74,62.98) 72.86,62.9 72.95,62.82 72.99,62.77 arc(73.05,62.69) 73.09,62.6 arc(73.09,62.6) 73.09,62.59 arc(73.11,62.54) 73.11,62.48 73.11,62.16 arc(73.17,61.85) 73.35,61.58 73.68,61.26 arc(73.84,61.01) 73.9,60.72 YJ24.C6
FC9_TDP2: length 155.1
  TOP w0.147: U1.BN63 167.55,159.34 v4(167.55,159.39)
  SIG6 w0.112: 163.26,158.66 163.28,158.66 163.38,158.75 166.74,158.75 arc(166.87,158.78) 166.97,158.85 167.02,158.9 arc(167.09,159) 167.12,159.13 167.12,159.62 arc(167.16,159.71) 167.25,159.74 167.39,159.74 arc(167.44,159.73) 167.48,159.71 167.51,159.67 arc(167.54,159.63) 167.55,159.58 v4(167.55,159.39)
  SIG6 w0.16: YJ24.C34 74.85,65.97 arc(74.96,66.14) 75,66.34 75,66.52 arc(74.9,66.76) 74.66,66.86 73.73,66.86 arc(73.56,66.93) 73.49,67.1 73.49,68.89 arc(73.55,69.18) 73.71,69.43 74.05,69.77 74.36,69.77 74.71,70.12 74.71,70.42 75.05,70.76 75.32,70.76 75.7,71.14 75.7,71.42 76.04,71.75 76.32,71.75 76.69,72.13 76.69,72.41 77.31,73.03 arc(77.48,73.28) 77.53,73.57 77.53,74.21 77.78,74.46 77.78,74.89 77.53,75.13 77.53,75.61 77.78,75.86 77.78,76.29 77.53,76.54 77.53,85.51 arc(77.59,85.8) 77.76,86.05 79.24,87.53 arc(79.49,87.7) 79.78,87.75 92.27,87.75 arc(92.71,87.84) 93.08,88.09 104.39,99.4 arc(104.51,99.48) 104.66,99.51 111.7,99.51 arc(112.14,99.59) 112.51,99.84 122.92,110.25 arc(123.17,110.63) 123.25,111.06 123.25,124.9 arc(123.31,125.19) 123.48,125.44 152.75,154.71 arc(153,154.88) 153.29,154.93 160.27,154.93 arc(160.57,154.99) 160.81,155.16 161.77,156.11 arc(161.93,156.36) 161.99,156.65 161.99,157.83 arc(162.02,157.97) 162.1,158.1 162.55,158.55 arc(162.67,158.63) 162.82,158.66 163.26,158.66
FC9_TDP3: length 150
  TOP w0.147: U1.BM66 165,157.84 arc(164.68,157.97) v4(164.55,158.29)
  SIG7 w0.112: v4(164.55,158.29) 164.55,158.1 arc(164.5,157.99) 164.38,157.94 164.24,157.94 arc(164.01,157.85) 163.92,157.62 163.92,157.29 arc(163.9,157.2) 163.84,157.12 163.76,157.04 arc(163.75,157.03) 163.74,157.02 arc(163.71,157) 163.67,157 163.27,157 163.18,157.09 163.16,157.09
  SIG7 w0.16: YJ24.C36 76.3,64.76 arc(76.25,65.01) 76.11,65.23 75.75,65.58 arc(75.57,65.85) 75.51,66.16 75.51,66.48 arc(75.51,66.53) 75.5,66.58 arc(75.49,66.6) 75.49,66.61 arc(75.45,66.7) 75.39,66.77 75.35,66.82 75.12,67.04 arc(74.75,67.59) 74.62,68.24 74.62,70.59 arc(74.68,70.88) 74.85,71.13 77.04,73.32 arc(77.12,73.45) 77.15,73.59 77.15,85.69 arc(77.21,85.98) 77.38,86.23 79.06,87.91 arc(79.3,88.08) 79.6,88.14 92.46,88.14 arc(92.6,88.16) 92.73,88.25 104.15,99.66 arc(104.39,99.83) 104.68,99.89 111.83,99.89 arc(111.98,99.92) 112.1,100 122.76,110.66 arc(122.84,110.78) 122.87,110.93 122.87,125.06 arc(122.93,125.35) 123.1,125.6 152.59,155.1 arc(152.84,155.26) 153.13,155.32 160.15,155.32 arc(160.29,155.35) 160.42,155.43 161.86,156.87 arc(162.1,157.03) 162.4,157.09 163.16,157.09
FC10_11_PVDD0P8: length 5.6
  TOP w0.229: U1.BC49 v1(181.55,149.34) ; U1.BA49 v1(181.55,147.34)
  TOP w0.381: C280.1 154.88,159.64 ; C280.1 155.49,158.85 ; C280.1 154.27,158.85
  BOTTOM w0.13: v1(155.38,160.02) v2(155.94,160.58)
  BOTTOM w0.381: C281.1 181.07,149.83 v1(181.55,149.34) ; C3324.1 181.07,147.83 v1(181.55,147.34)
  vias: v1(154.37,160.02)
FC10_RDN0: length 157.6
  TOP w0.147: v4(176.55,157.29) 176.65,157.29 arc(176.75,157.27) 176.83,157.22 176.97,157.07 arc(177.03,156.99) 177.05,156.89 U1.BL54
  SIG2 w0.112: v4(176.55,157.29) 176.55,157.07 arc(176.51,156.98) 176.42,156.94 176.25,156.94 arc(176.02,156.85) 175.93,156.62 175.93,155.17 arc(175.92,155.12) 175.89,155.08 175.8,154.98 arc(175.76,154.95) 175.71,154.95 163.3,154.95 163.21,155.04 163.18,155.04
  SIG2 w0.16: 163.18,155.04 162.32,155.04 arc(162.14,155.07) 162,155.17 161.91,155.26 arc(161.86,155.29) 161.79,155.3 153.25,155.3 arc(152.81,155.22) 152.44,154.97 144.14,146.67 arc(144.01,146.58) 143.87,146.56 141.22,146.56 arc(140.78,146.47) 140.41,146.22 88.79,94.6 arc(88.67,94.51) 88.52,94.49 86.08,94.49 arc(85.65,94.4) 85.28,94.15 77.49,86.36 arc(77.24,85.99) 77.15,85.55 77.15,77.65 arc(77.21,77.34) 77.39,77.07 arc(77.4,77.05) 77.41,77.03 77.41,68.26 arc(77.49,67.82) 77.74,67.45 78.57,66.62 arc(78.65,66.5) 78.68,66.35 78.68,64.13 arc(78.59,63.69) 78.34,63.32 78.04,63.02 arc(77.87,62.9) 77.66,62.86 76.28,62.86 arc(76.09,62.78) 76.01,62.59 76.01,62.43 arc(76.06,62.14) 76.23,61.89 YJ23.A17
FC10_RDN1: length 156.2
  TOP w0.147: v4(172.55,156.39) 172.55,156.34 U1.BK58
  SIG3 w0.112: 163.24,154.65 163.26,154.65 163.36,154.74 171.73,154.74 arc(171.86,154.77) 171.96,154.84 172.05,154.93 arc(172.12,155.03) 172.14,155.16 172.14,156.62 arc(172.18,156.71) 172.27,156.74 172.42,156.74 arc(172.51,156.71) 172.55,156.62 v4(172.55,156.39)
  SIG3 w0.16: YJ23.A15 74.7,60.78 arc(74.75,61.01) 74.88,61.22 75.34,61.67 arc(75.46,61.86) 75.51,62.08 75.51,62.23 75.51,62.35 75.51,62.57 arc(75.54,62.72) 75.63,62.86 75.68,62.91 arc(75.81,63) 75.95,63.03 77.39,63.03 arc(77.83,63.11) 78.2,63.36 78.73,63.89 arc(78.97,64.26) 79.06,64.69 79.06,66.09 arc(79.12,66.39) 79.28,66.63 79.73,67.08 arc(79.9,67.33) 79.96,67.62 79.96,69.39 arc(79.9,69.69) 79.73,69.93 77.76,71.91 arc(77.59,72.16) 77.53,72.45 77.53,72.96 77.76,73.19 77.76,73.74 77.53,73.97 77.53,74.48 77.76,74.71 77.76,75.27 77.53,75.5 77.53,85.53 arc(77.59,85.83) 77.76,86.07 85.57,93.88 arc(85.81,94.05) 86.1,94.1 88.52,94.1 arc(88.81,94.16) 89.06,94.33 140.68,145.95 arc(140.93,146.12) 141.22,146.17 143.89,146.17 arc(144.18,146.23) 144.43,146.4 152.73,154.7 arc(152.98,154.87) 153.27,154.92 161.42,154.92 arc(161.59,154.89) 161.74,154.79 arc(161.89,154.69) 162.07,154.65 163.24,154.65
FC10_RDN2: length 154.7
  TOP w0.147: v4(174.57,157.29) 174.67,157.29 arc(174.77,157.27) 174.85,157.22 174.99,157.08 arc(175.03,157.01) 175.05,156.93 U1.BL56
  SIG2 w0.112: v4(174.57,157.29) 174.57,157.07 arc(174.54,156.98) 174.45,156.94 174.28,156.94 arc(174.05,156.85) 173.96,156.62 173.96,156.2 arc(173.95,156.15) 173.92,156.11 173.82,156.01 arc(173.78,155.99) 173.73,155.98 169.34,155.98 arc(169.29,155.99) 169.25,156.01 169.18,156.09 arc(169.15,156.13) 169.14,156.18 169.14,156.18 169.14,156.62 arc(169.04,156.85) 168.82,156.95 163.38,156.95 163.28,157.04 163.26,157.04
  SIG2 w0.16: YJ23.A25 73.75,65.97 arc(73.64,66.13) 73.61,66.32 73.61,66.57 arc(73.69,66.78) 73.89,66.86 74.57,66.86 arc(74.78,66.9) 74.96,67.02 arc(75.08,67.2) 75.13,67.41 75.13,71.55 75.07,71.61 75.07,88.53 arc(75.16,88.97) 75.4,89.34 82.37,96.31 arc(82.75,96.56) 83.18,96.64 87.76,96.64 arc(87.9,96.67) 88.03,96.76 140.41,149.14 arc(140.78,149.39) 141.22,149.48 143.68,149.48 arc(143.98,149.53) 144.22,149.7 151.68,157.16 arc(151.93,157.33) 152.22,157.38 161.96,157.38 arc(162.19,157.34) 162.38,157.21 arc(162.57,157.08) 162.8,157.04 163.26,157.04
FC10_RDN3: length 150.8
  TOP w0.147: v4(170.55,156.39) 170.55,156.34 U1.BK60
  SIG3 w0.112: 163.11,156.65 163.14,156.65 163.23,156.74 168.84,156.74 arc(169,156.77) 169.13,156.86 arc(169.13,156.87) 169.14,156.87 169.53,156.87 arc(170.03,156.77) 170.46,156.48 v4(170.55,156.39)
  SIG3 w0.16: YJ23.A21 77.1,64.79 arc(77.15,65.02) 77.28,65.21 77.74,65.67 arc(77.86,65.86) 77.91,66.08 77.91,66.57 arc(77.93,66.71) 78.01,66.83 arc(78.02,66.85) 78.03,66.86 78.07,66.9 arc(78.25,67.16) 78.31,67.47 78.31,67.76 arc(78.25,68.04) 78.1,68.27 77.79,68.58 77.79,68.91 77.49,69.21 77.15,69.21 76.75,69.61 76.75,69.95 76.37,70.33 76.03,70.33 75.67,70.69 arc(75.51,70.94) 75.45,71.23 75.45,89.04 arc(75.51,89.33) 75.67,89.58 82.14,96.04 arc(82.38,96.21) 82.68,96.26 87.74,96.26 arc(88.03,96.32) 88.28,96.49 140.66,148.87 arc(140.91,149.04) 141.2,149.1 143.84,149.1 arc(144.13,149.15) 144.38,149.32 151.84,156.78 arc(152.09,156.95) 152.38,157 161.58,157 arc(161.65,157) 161.72,156.99 arc(161.87,156.93) 162,156.83 arc(162.2,156.7) 162.43,156.65 163.11,156.65
FC10_RDP0: length 157.6
  TOP w0.147: v4(176.55,156.39) 176.55,156.34 U1.BK54
  SIG2 w0.112: v4(176.55,156.39) 176.55,156.62 arc(176.51,156.71) 176.42,156.74 176.25,156.74 arc(176.16,156.71) 176.13,156.62 176.13,155.17 arc(176.1,155.04) 176.03,154.94 175.94,154.84 arc(175.83,154.77) 175.71,154.75 163.3,154.75 163.21,154.66 163.18,154.66
  SIG2 w0.16: 163.18,154.66 162.32,154.66 arc(162,154.72) 161.73,154.9 161.7,154.92 153.25,154.92 arc(152.96,154.87) 152.71,154.7 144.41,146.4 arc(144.16,146.23) 143.87,146.17 141.22,146.17 arc(140.93,146.12) 140.68,145.95 89.06,94.33 arc(88.81,94.16) 88.52,94.1 86.08,94.1 arc(85.79,94.05) 85.55,93.88 77.76,86.09 arc(77.59,85.85) 77.53,85.55 77.53,77.65 arc(77.57,77.48) 77.66,77.34 arc(77.75,77.2) 77.79,77.03 77.79,72.83 78.04,72.58 78.04,72.07 77.79,71.81 77.79,71.31 78.04,71.05 78.04,70.54 77.79,70.29 77.79,69.78 78.04,69.53 78.04,69.02 77.79,68.77 77.79,68.26 arc(77.85,67.97) 78.01,67.72 78.84,66.89 arc(79,66.65) 79.06,66.35 79.06,64.13 arc(78.94,63.55) 78.61,63.05 78.04,62.48 arc(78.04,62.48) 78.04,62.48 arc(77.94,62.33) 77.91,62.15 77.91,62.08 arc(77.86,61.86) 77.74,61.67 77.29,61.22 arc(77.15,61.01) 77.1,60.76 YJ23.A18
FC10_RDP1: length 156.2
  TOP w0.147: v4(172.55,157.29) 172.55,157.22 arc(172.56,157.15) 172.6,157.09 172.71,156.98 arc(172.86,156.88) U1.BL58
  SIG3 w0.112: 163.24,155.03 163.26,155.03 163.36,154.94 171.73,154.94 arc(171.78,154.95) 171.82,154.98 171.91,155.07 arc(171.94,155.11) 171.95,155.16 171.95,156.62 arc(172.04,156.85) 172.27,156.94 172.42,156.94 arc(172.51,156.98) 172.55,157.07 v4(172.55,157.29)
  SIG3 w0.16: 163.24,155.03 162.07,155.03 arc(162.04,155.04) 162.01,155.06 arc(161.74,155.24) 161.42,155.3 153.27,155.3 arc(152.84,155.22) 152.47,154.97 144.16,146.67 arc(144.04,146.58) 143.89,146.56 141.22,146.56 arc(140.78,146.47) 140.41,146.22 88.79,94.6 arc(88.67,94.51) 88.52,94.49 86.1,94.49 arc(85.67,94.4) 85.3,94.15 77.49,86.34 arc(77.24,85.97) 77.15,85.53 77.15,72.45 arc(77.24,72.01) 77.49,71.64 79.46,69.66 arc(79.55,69.54) 79.58,69.39 79.58,67.62 arc(79.55,67.48) 79.46,67.35 79.01,66.9 arc(78.77,66.53) 78.68,66.09 78.68,64.69 arc(78.62,64.4) 78.46,64.16 77.93,63.63 arc(77.68,63.46) 77.39,63.41 75.95,63.41 arc(75.66,63.35) 75.41,63.18 75.36,63.13 75.32,63.08 arc(75.07,62.92) 74.78,62.86 73.93,62.86 arc(73.7,62.77) 73.61,62.54 73.61,62.32 arc(73.64,62.13) 73.75,61.97 YJ23.A14
FC10_RDP2: length 154.7
  TOP w0.147: v4(174.57,156.39) 174.57,156.32 U1.BK56
  SIG2 w0.112: 163.26,156.66 163.28,156.66 163.38,156.75 168.82,156.75 arc(168.91,156.71) 168.94,156.62 168.94,156.18 arc(168.97,156.05) 169.04,155.95 169.11,155.87 arc(169.22,155.8) 169.34,155.78 173.73,155.78 arc(173.86,155.8) 173.96,155.87 174.06,155.97 arc(174.13,156.07) 174.15,156.2 174.15,156.62 arc(174.19,156.71) 174.28,156.74 174.45,156.74 arc(174.54,156.71) 174.57,156.62 v4(174.57,156.39)
  SIG2 w0.16: YJ23.A24 74.7,64.78 arc(74.75,65.02) 74.88,65.21 75.34,65.67 arc(75.46,65.86) 75.51,66.08 75.51,68.02 75.71,68.22 75.71,68.83 75.51,69.03 75.51,71.71 75.45,71.77 75.45,88.53 arc(75.51,88.82) 75.67,89.07 82.64,96.04 arc(82.89,96.21) 83.18,96.26 87.76,96.26 arc(88.05,96.32) 88.3,96.49 140.68,148.87 arc(140.93,149.04) 141.22,149.1 143.68,149.1 arc(144.12,149.18) 144.49,149.43 151.95,156.89 arc(152.08,156.97) 152.22,157 161.96,157 arc(162.04,156.99) 162.11,156.94 162.11,156.94 arc(162.43,156.73) 162.8,156.66 163.26,156.66
FC10_RDP3: length 150.8
  TOP w0.147: v4(170.55,157.29) 170.55,157.22 arc(170.56,157.15) 170.6,157.09 170.71,156.98 arc(170.86,156.88) U1.BL60
  SIG3 w0.112: 163.11,157.03 163.14,157.03 163.23,156.94 168.84,156.94 arc(168.92,156.96) 168.99,157 arc(169.06,157.05) 169.14,157.06 169.53,157.06 arc(169.8,157.04) 170.06,156.97 arc(170.17,156.96) 170.27,157.02 v4(170.55,157.29)
  SIG3 w0.16: YJ23.A22 76.15,65.97 arc(76.04,66.13) 76.01,66.32 76.01,66.57 arc(76.09,66.78) 76.3,66.86 77.18,66.86 arc(77.47,66.92) 77.72,67.08 77.8,67.17 arc(77.89,67.31) 77.92,67.47 77.92,67.76 arc(77.9,67.89) 77.83,68 75.4,70.42 arc(75.16,70.79) 75.07,71.23 75.07,89.04 arc(75.16,89.48) 75.4,89.85 81.87,96.31 arc(82.24,96.56) 82.68,96.64 87.74,96.64 arc(87.89,96.67) 88.01,96.76 140.39,149.14 arc(140.77,149.39) 141.2,149.48 143.84,149.48 arc(143.99,149.51) 144.11,149.59 151.57,157.05 arc(151.94,157.3) 152.38,157.38 161.58,157.38 arc(161.69,157.38) 161.8,157.36 arc(162.06,157.26) 162.27,157.1 arc(162.34,157.05) 162.43,157.03 163.11,157.03
FC10_TDN0: length 164.9
  TOP w0.147: U1.BJ63 167.55,155.34 v4(167.55,155.39)
  SIG4 w0.112: v4(167.55,155.39) 167.55,155.62 arc(167.51,155.71) 167.42,155.74 167.25,155.74 arc(167.02,155.84) 166.92,156.07 166.92,156.54 arc(166.91,156.59) 166.89,156.63 166.8,156.71 arc(166.76,156.74) 166.71,156.75 163.34,156.75 163.25,156.66 163.22,156.66
  SIG4 w0.16: 163.22,156.66 162.88,156.66 arc(162.59,156.6) 162.34,156.43 161.11,155.2 arc(160.8,155) 160.44,154.92 153.22,154.92 arc(152.93,154.87) 152.68,154.7 144.43,146.45 arc(144.13,146.25) 143.77,146.17 141.2,146.17 arc(140.91,146.12) 140.66,145.95 86.67,91.97 arc(86.37,91.76) 86.01,91.69 78.04,91.69 arc(77.83,91.65) 77.65,91.53 75.66,89.54 arc(75.5,89.29) 75.44,89 75.44,70.72 arc(75.5,70.43) 75.66,70.18 76.68,69.16 76.99,69.16 77.4,68.75 77.4,68.44 77.76,68.08 78.07,68.08 78.48,67.67 78.48,67.36 78.78,67.06 arc(78.99,66.75) 79.06,66.39 79.06,64.33 arc(78.99,63.97) 78.78,63.66 78.42,63.3 arc(78.12,63.1) 77.76,63.03 66.35,63.03 arc(66.21,63) 66.08,62.91 66.03,62.86 arc(65.94,62.72) 65.91,62.57 65.91,62.09 arc(65.86,61.86) 65.73,61.67 65.32,61.25 arc(65.16,61.01) 65.1,60.73 YJ23.A3
FC10_TDN1: length 159.9
  TOP w0.147: U1.BK65 166,155.84 arc(165.68,155.97) v4(165.55,156.29)
  SIG5 w0.112: 163.26,155.02 163.28,155.02 163.38,154.93 164.73,154.93 arc(164.78,154.94) 164.82,154.97 164.89,155.04 arc(164.92,155.08) 164.92,155.13 164.92,155.62 arc(165.02,155.85) 165.25,155.94 165.42,155.94 arc(165.51,155.98) 165.55,156.07 v4(165.55,156.29)
  SIG5 w0.16: 163.26,155.02 161.45,155.02 arc(161.27,155.06) 161.11,155.16 arc(160.96,155.27) 160.77,155.3 153.09,155.3 arc(152.8,155.25) 152.55,155.08 144.25,146.78 arc(144,146.61) 143.71,146.56 141.06,146.56 arc(140.77,146.5) 140.53,146.33 88.9,94.71 arc(88.65,94.54) 88.36,94.49 80.55,94.49 arc(80.11,94.4) 79.74,94.15 75.46,89.87 arc(75.21,89.5) 75.12,89.06 75.12,70.29 arc(75.18,70) 75.34,69.75 78.46,66.63 arc(78.63,66.38) 78.69,66.09 78.69,64.33 arc(78.63,64.04) 78.46,63.79 78.3,63.63 arc(78.05,63.46) 77.76,63.41 68.75,63.41 arc(68.46,63.35) 68.21,63.18 68.16,63.13 68.12,63.08 arc(67.87,62.92) 67.58,62.86 66.71,62.86 arc(66.5,62.77) 66.41,62.56 66.41,62.32 arc(66.44,62.13) 66.55,61.97 YJ23.A5
FC10_TDN2: length 155.9
  TOP w0.147: v4(168.55,157.39) 168.55,157.34 U1.BL62
  SIG4 w0.112: v4(168.55,157.39) 168.55,157.62 arc(168.51,157.71) 168.42,157.74 168.25,157.74 arc(168.02,157.84) 167.92,158.07 167.92,158.54 arc(167.91,158.59) 167.89,158.63 167.8,158.71 arc(167.76,158.74) 167.71,158.75 163.38,158.75 163.28,158.66 163.26,158.66
  SIG4 w0.16: 163.26,158.66 162.39,158.66 arc(162.1,158.6) 161.85,158.43 160.7,157.28 arc(160.39,157.08) 160.03,157 152.36,157 arc(152.06,156.95) 151.82,156.78 144.41,149.37 arc(144.1,149.17) 143.74,149.1 141.2,149.1 arc(140.91,149.04) 140.66,148.87 86.04,94.25 arc(85.73,94.05) 85.37,93.98 75.03,93.98 arc(74.81,93.93) 74.63,93.81 66.96,86.14 arc(66.8,85.9) 66.74,85.6 66.74,76.66 arc(66.67,76.3) 66.46,75.99 66.13,75.66 arc(65.96,75.41) 65.91,75.12 65.91,69.43 66.08,69.26 66.08,68.76 65.91,68.59 65.91,68.11 66.08,67.94 66.08,67.44 65.91,67.27 65.91,66.09 arc(65.86,65.86) 65.73,65.67 65.23,65.17 arc(65.13,65.02) 65.1,64.85 YJ23.A36
FC10_TDN3: length 154.2
  TOP w0.147: U1.BM64 167,157.84 arc(166.68,157.97) v4(166.55,158.29)
  SIG5 w0.112: 163.26,157.04 163.28,157.04 163.38,156.95 165.73,156.95 arc(165.78,156.96) 165.82,156.99 165.89,157.05 arc(165.92,157.09) 165.92,157.14 165.92,157.62 arc(166.02,157.85) 166.25,157.94 166.42,157.94 arc(166.51,157.98) 166.55,158.07 v4(166.55,158.29)
  SIG5 w0.16: 163.26,157.04 162.36,157.04 arc(162.07,157.1) 161.82,157.26 161.29,157.8 arc(161.04,157.96) 160.75,158.02 153.02,158.02 arc(152.58,157.93) 152.21,157.69 144.11,149.59 arc(143.99,149.51) 143.84,149.48 141.06,149.48 arc(140.77,149.42) 140.53,149.25 123.76,132.49 88.14,96.87 arc(87.89,96.7) 87.6,96.64 77.37,96.64 arc(76.93,96.56) 76.56,96.31 66.69,86.44 arc(66.44,86.07) 66.36,85.63 66.36,71.56 arc(66.44,71.12) 66.69,70.75 67.81,69.63 arc(67.9,69.51) 67.93,69.36 67.93,67.08 arc(67.86,66.93) 67.7,66.86 66.72,66.86 arc(66.5,66.77) 66.41,66.55 66.41,66.32 arc(66.44,66.13) 66.55,65.97 YJ23.A34
FC10_TDP0: length 164.9
  TOP w0.147: v4(167.55,156.29) 167.66,156.29 arc(167.76,156.27) 167.85,156.21 167.93,156.13 arc(168.02,156) U1.BK63
  SIG4 w0.112: 163.22,157.04 163.25,157.04 163.34,156.95 166.71,156.95 arc(166.84,156.92) 166.94,156.85 167.02,156.77 arc(167.09,156.66) 167.12,156.54 167.12,156.07 arc(167.16,155.98) 167.25,155.94 167.42,155.94 arc(167.51,155.98) 167.55,156.07 v4(167.55,156.29)
  SIG4 w0.16: YJ23.A2 64.15,61.97 arc(64.04,62.13) 64.01,62.32 64.01,62.48 arc(64.12,62.75) 64.39,62.86 65.18,62.86 arc(65.47,62.92) 65.72,63.08 65.81,63.18 arc(66.06,63.35) 66.35,63.41 77.76,63.41 arc(77.97,63.45) 78.15,63.57 78.52,63.93 arc(78.64,64.11) 78.68,64.33 78.68,66.39 arc(78.64,66.61) 78.52,66.79 75.39,69.91 arc(75.14,70.28) 75.06,70.72 75.06,89 arc(75.14,89.44) 75.39,89.81 77.38,91.8 arc(77.68,92) 78.04,92.07 86.01,92.07 arc(86.22,92.12) 86.4,92.24 140.39,146.22 arc(140.76,146.47) 141.2,146.56 143.77,146.56 arc(143.98,146.6) 144.16,146.72 152.41,154.97 arc(152.79,155.22) 153.22,155.3 160.44,155.3 arc(160.66,155.35) 160.84,155.47 162.07,156.7 arc(162.44,156.95) 162.88,157.04 163.22,157.04
FC10_TDP1: length 160
  TOP w0.147: U1.BJ65 165.55,155.34 v4(165.55,155.39)
  SIG5 w0.112: 163.26,154.64 163.28,154.64 163.38,154.74 164.73,154.74 arc(164.85,154.76) 164.96,154.83 165.03,154.9 arc(165.1,155) 165.12,155.13 165.12,155.62 arc(165.16,155.71) 165.25,155.74 165.42,155.74 arc(165.51,155.71) 165.55,155.62 v4(165.55,155.39)
  SIG5 w0.16: 163.26,154.64 161.45,154.64 arc(161.12,154.71) 160.84,154.9 arc(160.81,154.92) 160.77,154.92 153.09,154.92 arc(152.94,154.89) 152.82,154.81 144.52,146.51 arc(144.15,146.26) 143.71,146.17 141.06,146.17 arc(140.92,146.15) 140.79,146.06 89.17,94.44 arc(88.8,94.19) 88.36,94.1 80.55,94.1 arc(80.26,94.05) 80.01,93.88 75.73,89.6 arc(75.56,89.35) 75.5,89.06 75.5,72.12 75.65,71.97 75.65,71.2 75.5,71.05 75.5,70.29 arc(75.53,70.14) 75.61,70.02 76.33,69.31 76.54,69.31 76.99,68.86 76.99,68.64 77.44,68.19 77.66,68.19 78.19,67.66 78.19,67.44 78.73,66.9 arc(78.98,66.53) 79.07,66.09 79.07,64.33 arc(78.98,63.89) 78.73,63.52 78.57,63.36 arc(78.2,63.11) 77.76,63.03 68.75,63.03 arc(68.61,63) 68.48,62.91 68.46,62.89 68.43,62.86 arc(68.34,62.72) 68.31,62.57 68.31,62.08 arc(68.26,61.86) 68.14,61.67 67.61,61.15 arc(67.53,61.02) 67.5,60.87 YJ23.A6
FC10_TDP2: length 155.9
  TOP w0.147: v4(168.55,158.29) 168.66,158.29 arc(168.76,158.27) 168.85,158.21 168.93,158.13 arc(169.02,158) U1.BM62
  SIG4 w0.112: v4(168.55,158.29) 168.55,158.07 arc(168.51,157.98) 168.42,157.94 168.25,157.94 arc(168.16,157.98) 168.12,158.07 168.12,158.54 arc(168.09,158.66) 168.02,158.77 167.94,158.85 arc(167.84,158.92) 167.71,158.95 163.38,158.95 163.28,159.04 163.26,159.04
  SIG4 w0.16: 163.26,159.04 162.39,159.04 arc(161.95,158.95) 161.58,158.7 160.43,157.55 arc(160.25,157.43) 160.03,157.38 152.36,157.38 arc(151.92,157.3) 151.55,157.05 144.14,149.64 arc(143.96,149.52) 143.74,149.48 141.2,149.48 arc(140.76,149.39) 140.39,149.14 85.77,94.52 arc(85.59,94.4) 85.37,94.36 75.03,94.36 arc(74.67,94.29) 74.36,94.08 66.69,86.41 arc(66.44,86.04) 66.36,85.6 66.36,76.66 arc(66.32,76.44) 66.19,76.26 65.86,75.93 arc(65.61,75.56) 65.53,75.12 65.53,67.05 arc(65.47,66.92) 65.34,66.86 64.39,66.86 arc(64.12,66.75) 64.01,66.48 64.01,66.32 arc(64.04,66.13) 64.15,65.97 YJ23.A37
FC10_TDP3: length 154.2
  TOP w0.147: v4(166.55,157.39) 166.55,157.34 U1.BL64
  SIG5 w0.112: 163.26,156.66 163.28,156.66 163.38,156.75 165.73,156.75 arc(165.85,156.78) 165.96,156.85 166.03,156.91 arc(166.1,157.02) 166.12,157.14 166.12,157.62 arc(166.16,157.71) 166.25,157.74 166.42,157.74 arc(166.51,157.71) 166.55,157.62 v4(166.55,157.39)
  SIG5 w0.16: YJ23.A33 67.5,64.84 arc(67.54,65.02) 67.64,65.17 68.14,65.67 arc(68.26,65.86) 68.31,66.08 68.31,69.36 arc(68.25,69.65) 68.08,69.9 66.96,71.02 arc(66.8,71.27) 66.74,71.56 66.74,85.63 arc(66.8,85.92) 66.96,86.17 76.83,96.04 arc(77.08,96.21) 77.37,96.26 87.6,96.26 arc(88.04,96.35) 88.41,96.6 140.79,148.98 arc(140.92,149.07) 141.06,149.1 143.84,149.1 arc(144.13,149.15) 144.38,149.32 152.48,157.42 arc(152.73,157.58) 153.02,157.64 157.09,157.64 157.27,157.46 157.98,157.46 158.16,157.64 158.92,157.64 159.1,157.46 159.81,157.46 159.99,157.64 160.75,157.64 arc(160.89,157.61) 161.02,157.53 161.55,156.99 arc(161.92,156.75) 162.36,156.66 163.26,156.66
FC11_RDN0: length 167.8
  TOP w0.147: U1.BG54 176.55,153.34 v4(176.55,153.39)
  SIG2 w0.112: v4(176.55,153.39) 176.55,153.62 arc(176.51,153.71) 176.42,153.74 176.25,153.74 arc(176.16,153.71) 176.12,153.62 176.12,152.2 arc(176.09,152.07) 176.02,151.97 175.86,151.8 arc(175.75,151.73) 175.63,151.71 169.4,151.71 arc(169.35,151.7) 169.31,151.67 169.18,151.54 arc(169.15,151.5) 169.14,151.45 169.14,151.05 arc(169.05,150.82) 168.82,150.73 163.38,150.73 163.28,150.64 163.26,150.64
  SIG2 w0.16: YJ23.B15 74.7,52.75 arc(74.75,53.01) 74.9,53.23 75.34,53.67 arc(75.46,53.86) 75.51,54.08 75.51,54.57 arc(75.54,54.72) 75.63,54.86 75.68,54.91 arc(75.73,54.95) 75.78,54.98 arc(75.86,55.01) 75.95,55.03 78.27,55.03 arc(78.71,55.11) 79.08,55.36 81.39,57.67 arc(81.63,58.04) 81.72,58.48 81.72,66.71 81.72,66.71 arc(81.76,66.91) 81.88,67.08 arc(81.99,67.25) 82.03,67.45 arc(82.03,67.45) 82.03,67.45 82.03,67.96 82.26,68.19 82.26,68.74 82.03,68.97 82.03,69.48 82.26,69.71 82.26,70.27 82.03,70.5 82.03,83.01 arc(82.09,83.31) 82.25,83.55 82.55,83.85 arc(82.8,84.01) 83.09,84.07 92.2,84.07 arc(92.5,84.13) 92.74,84.29 93.82,85.37 arc(94.07,85.54) 94.36,85.6 99.82,85.6 arc(100.26,85.68) 100.63,85.93 127.24,112.53 arc(127.48,112.91) 127.57,113.34 127.57,123.27 arc(127.63,123.56) 127.8,123.81 154.4,150.41 arc(154.64,150.58) 154.93,150.64 163.26,150.64
FC11_RDN1: length 163.1
  TOP w0.147: v4(172.55,154.29) 172.55,154.22 arc(172.56,154.15) 172.6,154.09 172.71,153.98 arc(172.86,153.88) U1.BH58
  SIG3 w0.112: v4(172.55,154.29) 172.55,154.07 arc(172.51,153.98) 172.42,153.94 172.25,153.94 arc(172.02,153.85) 171.92,153.62 171.92,153.15 arc(171.91,153.1) 171.89,153.06 171.78,152.96 arc(171.74,152.93) 171.69,152.92 170.34,152.92 arc(170.22,152.89) 170.11,152.82 170.04,152.75 arc(169.97,152.65) 169.95,152.52 169.95,152.09 arc(169.94,152.04) 169.91,152 169.84,151.93 arc(169.8,151.9) 169.75,151.89 169.34,151.89 arc(169.21,151.87) 169.11,151.8 169.05,151.74 arc(168.98,151.63) 168.95,151.51 168.95,151.2 arc(168.94,151.16) 168.92,151.11 168.8,151 arc(168.76,150.97) 168.71,150.96 163.38,150.96 163.28,151.05 163.26,151.05
  SIG3 w0.16: 163.26,151.05 154.97,151.05 arc(154.53,150.97) 154.16,150.72 127.53,124.08 arc(127.28,123.71) 127.19,123.27 127.19,113.22 arc(127.16,113.07) 127.08,112.95 100.22,86.09 arc(100.1,86.01) 99.95,85.98 95.76,85.98 arc(95.32,85.89) 94.95,85.64 93.87,84.56 arc(93.75,84.48) 93.6,84.45 83.06,84.45 arc(82.62,84.37) 82.25,84.12 81.98,83.85 arc(81.74,83.48) 81.65,83.04 81.65,73.8 arc(81.74,73.36) 81.98,72.99 83.52,71.45 arc(83.6,71.33) 83.63,71.18 83.63,68.17 arc(83.6,68.02) 83.52,67.9 81.55,65.93 arc(81.39,65.68) 81.33,65.39 81.33,57.69 arc(81.27,57.4) 81.11,57.15 79.58,55.63 arc(79.33,55.46) 79.04,55.41 78.35,55.41 arc(78.06,55.35) 77.81,55.18 77.76,55.13 77.72,55.08 arc(77.47,54.92) 77.18,54.86 76.34,54.86 arc(76.1,54.76) 76.01,54.53 76.01,54.32 arc(76.04,54.13) 76.15,53.97 YJ23.B17
FC11_RDN2: length 163.5
  TOP w0.147: v4(174.55,153.39) 174.55,153.34 U1.BG56
  SIG2 w0.112: v4(174.55,153.39) 174.55,153.58 arc(174.54,153.63) 174.51,153.67 174.47,153.71 arc(174.43,153.73) 174.38,153.74 174.25,153.74 arc(174.16,153.71) 174.12,153.62 174.12,153.16 arc(174.09,153.03) 174.02,152.93 173.87,152.78 arc(173.83,152.75) 173.78,152.74 163.38,152.74 163.28,152.65 163.26,152.65
  SIG2 w0.16: YJ23.B24 74.7,56.76 arc(74.75,57.01) 74.9,57.23 75.1,57.44 75.34,57.67 arc(75.46,57.86) 75.51,58.08 75.51,58.57 arc(75.51,58.61) 75.51,58.65 arc(75.52,58.65) 75.52,58.66 arc(75.52,58.66) 75.52,58.66 arc(75.56,58.76) 75.63,58.86 75.68,58.91 arc(75.73,58.95) 75.78,58.98 arc(75.86,59.01) 75.95,59.03 78.46,59.03 arc(78.9,59.11) 79.27,59.36 80.04,60.13 arc(80.29,60.5) 80.38,60.94 80.38,68.35 arc(80.32,68.63) 80.16,68.87 arc(80,69.11) 79.95,69.39 79.95,69.9 80.18,70.13 80.18,70.69 79.95,70.91 79.95,71.42 80.2,71.68 80.2,72.18 79.95,72.44 79.95,84.26 arc(80,84.56) 80.17,84.8 82.9,87.53 arc(83.15,87.7) 83.44,87.75 99.06,87.75 arc(99.5,87.84) 99.87,88.09 125.08,113.3 arc(125.33,113.67) 125.41,114.11 125.41,124.13 125.41,124.13 arc(125.47,124.42) 125.64,124.67 153.59,152.62 arc(153.83,152.79) 154.12,152.84 161.2,152.84 arc(161.42,152.7) 161.69,152.65 163.26,152.65
