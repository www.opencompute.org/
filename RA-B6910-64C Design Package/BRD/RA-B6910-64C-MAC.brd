# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC24_RDP0: length 81.2
  TOP w0.147: v4(176.55,113.39) 176.55,113.48 arc(176.57,113.56) 176.61,113.63 176.68,113.71 arc(176.84,113.81) 177.01,113.84 U1.H54
  SIG8 w0.112: 163.31,111.66 163.33,111.66 163.43,111.75 175.67,111.75 arc(175.84,111.78) 175.99,111.88 arc(176.08,112.02) 176.11,112.19 176.11,113.64 arc(176.14,113.71) 176.22,113.74 176.45,113.74 arc(176.52,113.71) 176.55,113.64 v4(176.55,113.39)
  SIG8 w0.16: 163.31,111.66 161.7,111.66 arc(161.41,111.6) 161.16,111.44 159.42,109.69 arc(159.25,109.45) 159.19,109.16 159.19,101.71 arc(159.25,101.42) 159.42,101.17 159.81,100.78 arc(159.98,100.53) 160.04,100.24 160.04,91.32 arc(159.95,90.89) 159.7,90.52 158.42,89.23 arc(158.33,89.11) 158.31,88.96 158.31,78.18 158.56,77.92 158.56,77.42 158.31,77.16 158.31,75.21 158.55,74.97 158.55,74.43 158.31,74.19 158.31,72.99 arc(158.22,72.55) 157.97,72.18 156.74,70.95 156.74,70.64 156.33,70.23 156.02,70.23 155.67,69.87 155.67,69.57 155.25,69.16 154.95,69.16 154.59,68.8 arc(154.5,68.67) 154.48,68.53 154.48,62.42 arc(154.53,62.12) 154.7,61.88 156.96,59.62 arc(157.21,59.45) 157.5,59.39 159.39,59.39 arc(159.68,59.34) 159.93,59.17 160.02,59.09 arc(160.26,58.92) 160.56,58.86 161.3,58.86 arc(161.53,58.82) 161.72,58.69 arc(161.8,58.57) 161.83,58.43 161.83,58.39 arc(161.78,58.17) 161.65,57.97 YJ28.D25
FC24_RDP1: length 85.7
  TOP w0.147: U1.J58 172.55,114.34 v4(172.55,114.29)
  SIG9 w0.112: v4(172.55,114.29) 172.55,114.07 arc(172.54,114.03) 172.52,113.99 172.49,113.97 arc(172.46,113.95) 172.42,113.94 172.22,113.94 arc(172.15,113.97) 172.12,114.04 172.12,115.41 arc(172.08,115.61) 171.97,115.78 arc(171.8,115.89) 171.6,115.93 163.35,115.93 163.26,116.02
  SIG9 w0.16: 163.26,116.02 160.72,116.02 arc(160.28,115.93) 159.91,115.68 156.99,112.76 arc(156.74,112.39) 156.65,111.95 156.65,99.25 arc(156.74,98.81) 156.99,98.44 157.22,98.2 157.39,98.04 157.46,97.97 arc(157.54,97.85) 157.57,97.7 157.57,92.03 arc(157.54,91.89) 157.46,91.76 156.18,90.48 arc(155.93,90.11) 155.84,89.67 155.84,75.24 arc(155.81,75.1) 155.73,74.97 154.58,73.82 arc(154.33,73.45) 154.24,73.01 154.24,72.58 arc(154.21,72.43) 154.13,72.31 151.53,69.71 arc(151.28,69.33) 151.19,68.9 151.19,61.44 arc(151.28,61.01) 151.53,60.63 157.25,54.92 arc(157.44,54.62) 157.51,54.28 157.51,54.03 arc(157.55,53.84) 157.66,53.68 158.23,53.11 arc(158.28,53.03) 158.3,52.93 YJ28.D18
FC24_RDP2: length 87
  TOP w0.147: v4(174.55,113.39) 174.55,113.48 arc(174.57,113.56) 174.61,113.63 174.68,113.71 arc(174.84,113.81) 175.01,113.84 U1.H56
  SIG8 w0.112: v4(174.55,113.39) 174.55,113.64 arc(174.52,113.71) 174.45,113.74 174.22,113.74 arc(174.01,113.83) 173.92,114.04 173.92,114.5 arc(173.91,114.55) 173.89,114.59 173.79,114.68 arc(173.75,114.71) 173.7,114.71 169.53,114.71 arc(169.39,114.69) 169.27,114.61 169.24,114.58 arc(169.18,114.49) 169.16,114.39 169.16,114.28 arc(169.12,114.07) 169.01,113.9 arc(168.84,113.79) 168.64,113.75 163.38,113.75 163.28,113.66 163.26,113.66
  SIG8 w0.16: 163.26,113.66 160.65,113.66 arc(160.36,113.6) 160.11,113.43 157.26,110.58 arc(157.09,110.34) 157.04,110.04 157.04,99.45 arc(157.09,99.16) 157.26,98.91 157.73,98.44 arc(157.9,98.19) 157.96,97.9 157.96,92.2 arc(157.87,91.76) 157.62,91.39 156.33,90.1 arc(156.25,89.98) 156.22,89.83 156.22,75.24 arc(156.16,74.95) 156,74.7 154.64,73.34 arc(154.47,73.09) 154.42,72.8 154.42,72.05 arc(154.33,71.61) 154.08,71.24 152.43,69.58 arc(152.35,69.46) 152.32,69.31 152.32,62.61 152.5,62.43 152.5,61.77 152.32,61.59 152.32,60.76 152.32,60.77 arc(152.37,60.47) 152.54,60.23 153.3,59.46 153.64,59.46 154.02,59.08 154.02,58.74 154.38,58.38 154.74,58.38 155.1,58.02 155.1,57.67 155.46,57.31 155.82,57.31 156.18,56.95 156.18,56.59 157.15,55.62 arc(157.4,55.45) 157.69,55.39 159.39,55.39 arc(159.68,55.34) 159.93,55.17 160.11,54.99 arc(160.25,54.89) 160.42,54.86 161.4,54.86 arc(161.55,54.83) 161.68,54.75 arc(161.77,54.61) 161.8,54.45 161.8,54.34 arc(161.76,54.14) 161.65,53.97 YJ28.D14
FC24_RDP3: length 73.6
  TOP w0.147: v4(170.55,114.29) 170.55,114.34 U1.J60
  SIG9 w0.112: 163.16,114.05 163.25,113.95 169.05,113.95 169.12,113.89 169.57,113.89 arc(170.1,113.99) v4(170.55,114.29)
  SIG9 w0.16: 163.16,114.05 161.55,114.05 arc(161.26,113.99) 161.01,113.82 159.04,111.85 arc(158.87,111.61) 158.81,111.31 158.81,101.12 arc(158.87,100.83) 159.04,100.58 159.43,100.19 arc(159.59,99.94) 159.65,99.65 159.65,91.3 arc(159.59,91.01) 159.43,90.76 158.13,89.46 arc(157.96,89.22) 157.91,88.93 157.91,73.43 arc(157.85,73.14) 157.68,72.89 153.5,68.7 arc(153.33,68.46) 153.28,68.17 153.28,63.2 arc(153.33,62.91) 153.5,62.66 157.35,58.82 157.39,58.77 arc(157.45,58.69) 157.49,58.59 arc(157.51,58.54) 157.51,58.48 157.51,58.02 arc(157.55,57.84) 157.65,57.69 158.15,57.19 arc(158.26,57.02) 158.3,56.82 YJ28.D21
FC24_TDN0: length 77.8
  TOP w0.147: U1.G62 169,112.84 arc(168.68,112.71) v4(168.55,112.39)
  SIG6 w0.112: 162.9,111.63 162.93,111.63 163.02,111.72 167.82,111.72 arc(167.87,111.73) 167.91,111.76 168.02,111.87 arc(168.09,111.98) 168.12,112.1 168.12,112.62 arc(168.16,112.71) 168.25,112.74 168.39,112.74 arc(168.44,112.73) 168.48,112.71 168.51,112.67 arc(168.54,112.63) 168.55,112.58 v4(168.55,112.39)
  SIG6 w0.16: YJ28.D34 168.85,57.97 arc(168.96,58.14) 169,58.34 169,58.52 arc(168.9,58.76) 168.66,58.86 167.87,58.86 arc(167.47,58.94) 167.14,59.17 167.13,59.17 arc(166.88,59.34) 166.59,59.39 158.03,59.39 arc(157.74,59.45) 157.49,59.62 154.74,62.37 arc(154.57,62.62) 154.51,62.91 154.51,67.65 arc(154.54,67.79) 154.63,67.91 154.97,68.25 155.3,68.25 155.62,68.57 155.62,68.91 155.96,69.25 156.29,69.25 156.61,69.56 156.61,69.9 156.95,70.24 157.29,70.24 157.6,70.55 157.6,70.89 157.94,71.23 158.25,71.23 158.59,71.57 158.59,71.88 160.38,73.67 arc(160.63,74.04) 160.72,74.48 160.72,91.22 160.72,91.22 arc(160.78,91.52) 160.94,91.76 161.44,92.26 161.94,92.76 arc(162.11,93.01) 162.17,93.3 162.17,111.23 arc(162.2,111.37) 162.28,111.5 162.3,111.52 arc(162.42,111.6) 162.57,111.63 162.9,111.63
FC24_TDN1: length 88.4
  TOP w0.147: U1.H64 166.55,113.34 v4(166.55,113.29)
  SIG7 w0.112: 163.61,114.21 163.64,114.21 163.73,114.12 163.98,114.12 arc(164.13,114.09) 164.26,114 164.32,113.95 arc(164.39,113.9) 164.47,113.89 165.71,113.89 arc(165.86,113.86) 165.98,113.77 166,113.75 arc(166.09,113.63) 166.12,113.47 166.12,113.09 arc(166.16,112.99) 166.27,112.94 166.38,112.94 arc(166.5,112.99) 166.55,113.1 v4(166.55,113.29)
  SIG7 w0.16: 163.61,114.21 160.67,114.21 arc(160.37,114.16) 160.13,113.99 156.88,110.74 arc(156.71,110.49) 156.65,110.2 156.65,99.25 arc(156.71,98.95) 156.88,98.71 157.43,98.15 arc(157.51,98.03) 157.54,97.88 157.54,92.01 arc(157.51,91.86) 157.43,91.74 156.07,90.37 arc(155.9,90.12) 155.84,89.83 155.84,75.26 arc(155.81,75.12) 155.73,74.99 154.08,73.35 arc(153.92,73.1) 153.86,72.81 153.86,70.54 arc(153.83,70.4) 153.75,70.27 152.28,68.8 arc(152.11,68.55) 152.05,68.26 152.05,60.09 arc(152.11,59.8) 152.28,59.55 156.59,55.24 arc(156.84,55.07) 157.13,55.01 168.99,55.01 arc(169.14,54.98) 169.26,54.9 169.35,54.82 169.39,54.77 arc(169.45,54.69) 169.49,54.6 arc(169.5,54.59) 169.5,54.57 arc(169.51,54.53) 169.51,54.48 169.51,54.16 arc(169.57,53.85) 169.75,53.58 170.1,53.23 arc(170.25,53.01) 170.3,52.75 YJ28.D3
FC24_TDN2: length 78.5
  TOP w0.147: U1.G66 165,112.84 arc(164.68,112.71) v4(164.55,112.39)
  SIG7 w0.112: v4(164.55,112.39) 164.55,112.58 arc(164.5,112.7) 164.38,112.74 164.24,112.74 arc(164.15,112.71) 164.11,112.62 164.11,112.21 arc(164.08,112.06) 164,111.94 163.98,111.92 arc(163.85,111.83) 163.7,111.8 163.29,111.8 163.2,111.71 163.17,111.71
  SIG7 w0.16: 163.17,111.71 161.59,111.71 arc(161.45,111.68) 161.32,111.6 159.31,109.58 arc(159.22,109.46) 159.19,109.31 159.19,101.25 arc(159.22,101.1) 159.31,100.98 159.84,100.45 arc(160,100.2) 160.06,99.91 160.06,92.03 arc(160.09,91.89) 160.17,91.76 160.5,91.44 arc(160.66,91.19) 160.72,90.9 160.72,74.34 arc(160.61,73.8) 160.3,73.34 160.05,73.08 160.05,72.88 159.67,72.5 159.47,72.5 159.14,72.18 159.14,72 158.74,71.6 158.56,71.6 158.24,71.27 158.24,71.07 157.86,70.69 157.66,70.69 157.33,70.36 157.33,70.12 157,69.79 156.75,69.79 156.43,69.46 156.43,69.21 156.1,68.88 155.85,68.88 155.52,68.55 155.52,68.31 155.19,67.98 155.07,67.98 154.94,67.98 154.73,67.77 arc(154.57,67.53) 154.51,67.24 154.51,61.95 arc(154.54,61.8) 154.63,61.68 156.8,59.51 arc(156.92,59.42) 157.06,59.39 168.99,59.39 arc(169.28,59.34) 169.53,59.17 169.62,59.08 arc(169.86,58.92) 170.16,58.86 171.06,58.86 arc(171.3,58.76) 171.4,58.52 171.4,58.34 arc(171.36,58.14) 171.25,57.97 YJ28.D37
FC24_TDN3: length 85.9
  TOP w0.147: v4(167.55,115.29) 167.55,115.34 U1.K63
  SIG6 w0.112: 163.26,114.03 163.28,114.03 163.38,113.94 166.74,113.94 arc(166.79,113.95) 166.83,113.97 166.89,114.03 arc(166.91,114.07) 166.92,114.12 166.92,114.62 arc(167.02,114.85) 167.25,114.94 167.42,114.94 arc(167.51,114.98) 167.55,115.07 v4(167.55,115.29)
  SIG6 w0.16: YJ28.D6 167.9,52.72 arc(167.84,53.01) 167.68,53.26 167.35,53.58 arc(167.17,53.85) 167.11,54.16 167.11,54.48 arc(167.11,54.53) 167.1,54.59 arc(167.09,54.6) 167.09,54.61 arc(167.05,54.7) 166.99,54.77 166.95,54.82 166.86,54.9 arc(166.74,54.98) 166.59,55.01 157.97,55.01 arc(157.53,55.1) 157.16,55.35 152.29,60.22 arc(152.04,60.59) 151.96,61.02 151.96,68.77 arc(152.01,69.06) 152.18,69.31 153.64,70.77 arc(153.8,71.01) 153.86,71.31 153.86,72.81 arc(153.92,73.11) 154.08,73.35 155.67,74.94 arc(155.83,75.19) 155.89,75.48 155.89,89.7 arc(155.98,90.14) 156.23,90.51 159.59,93.87 arc(159.67,93.99) 159.7,94.14 159.7,100.29 arc(159.67,100.44) 159.59,100.56 159.15,101 arc(158.9,101.37) 158.81,101.81 158.81,111.16 arc(158.9,111.6) 159.15,111.97 160.87,113.69 arc(161.24,113.94) 161.68,114.03 163.26,114.03
FC24_TDP0: length 77.8
  TOP w0.147: v4(168.55,113.29) 168.55,113.34 U1.H62
  SIG6 w0.112: 162.9,112.01 162.93,112.01 163.02,111.92 167.74,111.92 arc(167.79,111.93) 167.83,111.96 167.89,112.01 arc(167.91,112.05) 167.92,112.1 167.92,112.62 arc(168.02,112.85) 168.25,112.94 168.42,112.94 arc(168.51,112.98) 168.55,113.07 v4(168.55,113.29)
  SIG6 w0.16: YJ28.D33 167.9,56.73 arc(167.84,57.01) 167.68,57.25 167.35,57.58 arc(167.17,57.85) 167.11,58.16 167.11,58.48 arc(167.11,58.53) 167.1,58.58 arc(167.09,58.59) 167.09,58.61 arc(167.05,58.7) 166.99,58.77 166.95,58.82 166.86,58.9 arc(166.74,58.98) 166.59,59.01 158.03,59.01 arc(157.59,59.1) 157.22,59.35 154.47,62.1 arc(154.22,62.47) 154.13,62.91 154.13,67.65 arc(154.19,67.94) 154.36,68.18 160.11,73.94 arc(160.28,74.19) 160.34,74.48 160.34,91.22 arc(160.42,91.66) 160.67,92.03 161.67,93.03 arc(161.76,93.16) 161.79,93.3 161.79,111.23 arc(161.84,111.52) 162.01,111.77 162.03,111.79 arc(162.28,111.95) 162.57,112.01 162.9,112.01
FC24_TDP1: length 88.4
  TOP w0.147: U1.G64 167,112.84 arc(166.68,112.71) v4(166.55,112.39)
  SIG7 w0.112: 163.61,113.83 163.64,113.83 163.73,113.93 163.98,113.93 arc(164.06,113.91) 164.12,113.86 164.18,113.81 arc(164.31,113.72) 164.47,113.69 165.71,113.69 arc(165.78,113.67) 165.85,113.63 165.86,113.61 arc(165.91,113.55) 165.92,113.47 165.92,113.09 arc(166.02,112.85) 166.27,112.74 166.38,112.74 arc(166.5,112.7) 166.55,112.58 v4(166.55,112.39)
  SIG7 w0.16: YJ28.D2 171.25,53.97 arc(171.36,54.14) 171.4,54.34 171.4,54.52 arc(171.3,54.76) 171.06,54.86 170.28,54.86 arc(169.87,54.94) 169.53,55.17 arc(169.28,55.34) 168.99,55.39 157.13,55.39 arc(156.98,55.42) 156.86,55.51 156.5,55.87 156.5,56.14 156.17,56.47 155.9,56.47 155.57,56.8 155.57,57.06 155.24,57.39 154.97,57.39 154.64,57.72 154.64,57.99 154.31,58.32 154.05,58.32 153.72,58.65 153.72,58.92 153.39,59.25 153.12,59.25 152.55,59.82 arc(152.46,59.94) 152.43,60.09 152.43,68.26 arc(152.46,68.41) 152.55,68.53 154.02,70.01 arc(154.18,70.25) 154.24,70.54 154.24,71.08 154.42,71.26 154.42,71.72 154.24,71.9 154.24,72.81 arc(154.27,72.95) 154.35,73.08 156,74.72 arc(156.16,74.97) 156.22,75.26 156.22,89.83 arc(156.25,89.98) 156.33,90.1 157.7,91.47 arc(157.87,91.72) 157.92,92.01 157.92,97.88 arc(157.87,98.18) 157.7,98.42 157.15,98.98 arc(157.06,99.1) 157.04,99.25 157.04,110.2 arc(157.06,110.35) 157.15,110.47 160.4,113.72 arc(160.52,113.8) 160.67,113.83 163.61,113.83
FC24_TDP2: length 78.5
  TOP w0.147: v4(164.55,113.29) 164.55,113.34 U1.H66
  SIG7 w0.112: 163.17,112.09 163.23,112.09 163.32,112 163.7,112 arc(163.78,112.01) 163.84,112.06 163.86,112.08 arc(163.9,112.14) 163.92,112.21 163.92,112.62 arc(164.01,112.85) 164.24,112.94 164.38,112.94 arc(164.5,112.99) 164.55,113.1 v4(164.55,113.29)
  SIG7 w0.16: YJ28.D36 170.3,56.73 arc(170.24,57.01) 170.09,57.25 169.93,57.4 169.75,57.58 arc(169.57,57.85) 169.51,58.16 169.51,58.48 arc(169.51,58.53) 169.5,58.57 arc(169.46,58.68) 169.39,58.77 169.35,58.82 169.26,58.9 arc(169.14,58.98) 168.99,59.01 157.06,59.01 arc(156.77,59.07) 156.53,59.24 154.36,61.41 arc(154.19,61.65) 154.13,61.95 154.13,67.24 arc(154.22,67.67) 154.46,68.04 160.03,73.61 arc(160.26,73.94) 160.34,74.34 160.34,90.9 arc(160.31,91.04) 160.23,91.17 159.9,91.49 arc(159.74,91.74) 159.68,92.03 159.68,99.91 arc(159.65,100.06) 159.57,100.18 159.04,100.71 arc(158.87,100.96) 158.81,101.25 158.81,109.31 arc(158.87,109.61) 159.04,109.85 161.05,111.87 arc(161.3,112.03) 161.59,112.09 163.17,112.09
FC24_TDP3: length 85.9
  TOP w0.147: U1.J63 168,114.84 arc(167.68,114.71) v4(167.55,114.39)
  SIG6 w0.112: v4(167.55,114.39) 167.55,114.62 arc(167.51,114.71) 167.42,114.74 167.25,114.74 arc(167.16,114.71) 167.12,114.62 167.12,114.12 arc(167.09,113.99) 167.02,113.89 166.91,113.78 arc(166.87,113.75) 166.82,113.74 163.38,113.74 163.28,113.65 163.26,113.65
  SIG6 w0.16: YJ28.D5 168.85,53.97 arc(168.96,54.14) 169,54.34 169,54.52 arc(168.9,54.76) 168.66,54.86 167.88,54.86 arc(167.47,54.94) 167.13,55.17 arc(166.88,55.34) 166.59,55.39 157.97,55.39 arc(157.67,55.45) 157.43,55.62 156.53,56.52 156.53,56.83 156.19,57.17 155.87,57.17 155.53,57.51 155.53,57.82 155.2,58.16 154.88,58.16 154.54,58.5 154.54,58.84 154.23,59.15 153.89,59.15 153.55,59.49 153.55,59.83 153.24,60.15 152.9,60.15 152.56,60.48 arc(152.39,60.73) 152.34,61.02 152.34,61.02 152.34,68.77 arc(152.37,68.92) 152.45,69.04 153.91,70.5 arc(154.15,70.87) 154.24,71.31 154.24,72.81 arc(154.27,72.96) 154.35,73.08 155.94,74.67 arc(156.19,75.04) 156.27,75.48 156.27,89.7 arc(156.33,89.99) 156.5,90.24 159.86,93.6 arc(160.03,93.85) 160.08,94.14 160.08,100.29 arc(160.03,100.58) 159.86,100.83 159.42,101.27 arc(159.25,101.52) 159.19,101.81 159.19,111.16 arc(159.25,111.45) 159.42,111.7 161.14,113.42 arc(161.39,113.59) 161.68,113.65 163.26,113.65
FC25_RDN0: length 62.7
  TOP w0.147: v4(177.55,111.29) 177.55,111.34 U1.F53
  SIG8 w0.112: 164.75,106.58 164.75,106.6 164.84,106.69 164.84,107.4 arc(164.88,107.61) 165,107.78 arc(165.17,107.9) 165.38,107.94 169.78,107.94 arc(169.83,107.95) 169.87,107.98 169.93,108.04 arc(169.96,108.08) 169.97,108.13 169.97,108.54 arc(170,108.67) 170.07,108.77 170.13,108.84 arc(170.24,108.91) 170.36,108.94 176.68,108.94 arc(176.77,108.96) 176.85,109.01 arc(176.9,109.09) 176.92,109.18 176.92,110.74 arc(177.02,110.97) 177.25,111.07 arc(177.32,111.08) 177.38,111.12 v4(177.55,111.29)
  SIG8 w0.16: 164.75,106.58 164.75,104.44 arc(164.72,104.3) 164.64,104.17 164.36,103.89 arc(164.11,103.52) 164.02,103.09 164.02,95.59 arc(164.11,95.15) 164.36,94.78 165.31,93.83 arc(165.39,93.71) 165.42,93.56 165.42,90.33 arc(165.36,90.04) 165.19,89.79 162.64,87.24 arc(162.48,86.99) 162.42,86.7 162.42,70.7 arc(162.36,70.4) 162.2,70.16 160.13,68.09 arc(159.97,67.85) 159.91,67.56 159.91,66.03 arc(159.95,65.84) 160.06,65.68 160.6,65.14 arc(160.67,65.02) 160.7,64.89 YJ28.C24
FC25_RDN1: length 69.9
  TOP w0.147: v4(175.55,110.39) 175.55,110.48 arc(175.57,110.56) 175.61,110.63 175.68,110.71 arc(175.84,110.81) 176.01,110.84 U1.E55
  SIG8 w0.112: v4(175.55,110.39) 175.55,110.64 arc(175.52,110.71) 175.45,110.74 175.22,110.74 arc(175.15,110.71) 175.12,110.64 175.12,110.05 arc(175.03,109.84) 174.82,109.75 163.38,109.75 163.28,109.66 163.26,109.66
  SIG8 w0.16: YJ28.C14 161.65,61.97 arc(161.76,62.14) 161.8,62.35 161.8,62.54 arc(161.78,62.65) 161.72,62.74 arc(161.59,62.83) 161.44,62.86 160.47,62.86 arc(160.26,62.9) 160.08,63.02 160.06,63.04 159.93,63.17 arc(159.68,63.34) 159.39,63.39 157.82,63.39 arc(157.52,63.45) 157.28,63.62 156.86,64.04 arc(156.69,64.28) 156.63,64.58 156.63,64.57 156.63,67.2 arc(156.66,67.35) 156.75,67.47 157.11,67.83 157.46,67.83 157.82,68.19 157.82,68.55 158.18,68.91 158.54,68.91 158.9,69.27 158.9,69.63 159.26,69.98 159.62,69.98 159.98,70.34 159.98,70.7 160.38,71.11 arc(160.63,71.48) 160.72,71.92 160.72,72.42 160.87,72.58 160.87,73.29 160.72,73.44 160.72,88.33 arc(160.75,88.47) 160.83,88.6 161.78,89.55 arc(162.03,89.92) 162.12,90.36 162.12,108.77 arc(162.17,109.06) 162.34,109.31 162.48,109.45 arc(162.71,109.6) 162.97,109.66 163.26,109.66
FC25_RDN2: length 69
  TOP w0.147: U1.F57 173.55,111.34 v4(173.55,111.29)
  SIG9 w0.112: v4(173.55,111.29) 173.55,111.07 arc(173.54,111.03) 173.52,110.99 173.49,110.97 arc(173.46,110.95) 173.42,110.94 173.22,110.94 arc(173.15,110.97) 173.12,111.04 173.12,111.5 arc(173.1,111.63) 173.03,111.73 172.91,111.85 arc(172.81,111.92) 172.68,111.95 163.38,111.95 163.28,112.04 163.26,112.04
  SIG9 w0.16: 163.26,112.04 162.37,112.04 arc(161.93,111.95) 161.56,111.7 161.31,111.45 arc(161.06,111.08) 160.97,110.64 160.97,104.71 arc(161.06,104.27) 161.31,103.9 161.47,103.74 161.62,103.58 arc(161.71,103.46) 161.73,103.31 161.73,90.23 arc(161.71,90.08) 161.62,89.96 160.67,89.01 arc(160.42,88.64) 160.34,88.2 160.34,76.71 arc(160.32,76.62) 160.27,76.54 arc(160.05,76.21) 159.97,75.83 159.97,73.28 arc(159.91,72.99) 159.75,72.74 155.86,68.86 arc(155.7,68.61) 155.64,68.32 155.64,65 arc(155.73,64.56) 155.97,64.19 157.35,62.82 157.39,62.77 arc(157.46,62.69) 157.5,62.59 arc(157.51,62.53) 157.51,62.48 157.51,62.03 arc(157.55,61.84) 157.66,61.67 158.13,61.2 arc(158.26,61.02) 158.3,60.79 YJ28.C18
FC25_RDN3: length 61.9
  TOP w0.147: U1.E59 171.95,110.84 arc(171.86,110.82) 171.78,110.77 171.65,110.64 arc(171.58,110.53) v4(171.55,110.39)
  SIG9 w0.112: v4(171.55,110.39) 171.55,110.62 arc(171.54,110.66) 171.52,110.69 171.49,110.71 arc(171.46,110.74) 171.42,110.74 170.54,110.74 arc(170.41,110.72) 170.3,110.65 170.27,110.61 arc(170.22,110.54) 170.2,110.45 170.2,110.25 arc(170.16,110.05) 170.05,109.89 arc(169.88,109.77) 169.68,109.73 163.35,109.73 163.28,109.67
  SIG9 w0.16: YJ28.C22 159.25,65.97 arc(159.36,66.14) 159.4,66.34 159.4,66.52 arc(159.3,66.76) 159.06,66.86 158.16,66.86 arc(158.09,66.86) 158.02,66.87 arc(157.8,66.95) 157.62,67.08 157.54,67.17 arc(157.33,67.66) 157.54,68.15 arc(157.7,68.26) 157.9,68.3 158.63,68.3 arc(159.06,68.39) 159.43,68.63 159.79,68.99 160.15,68.99 160.51,69.35 160.51,69.71 160.87,70.07 161.23,70.07 161.59,70.43 161.59,70.79 162.47,71.67 arc(162.71,72.04) 162.8,72.47 162.8,72.98 163.03,73.21 163.03,73.77 162.8,74 162.8,74.51 163.03,74.74 163.03,75.29 162.8,75.52 162.8,86.7 arc(162.83,86.85) 162.91,86.97 163.55,87.61 164.19,88.25 165.46,89.52 arc(165.71,89.89) 165.8,90.33 165.8,92.14 arc(165.74,92.43) 165.58,92.68 165.13,93.12 arc(164.97,93.37) 164.91,93.66 164.91,105.47 arc(164.85,105.76) 164.69,106.01 162.92,107.77 arc(162.76,108.02) 162.7,108.31 162.7,109.12 arc(162.7,109.15) 162.71,109.18 162.79,109.37 arc(162.87,109.49) 162.99,109.58 162.99,109.58 163.2,109.66 arc(163.21,109.67) 163.23,109.67 163.28,109.67
FC25_RDP0: length 62.7
  TOP w0.147: v4(177.55,110.39) 177.55,110.48 arc(177.57,110.56) 177.61,110.63 177.68,110.71 arc(177.84,110.81) 178.01,110.84 U1.E53
  SIG8 w0.112: 165.13,106.58 165.13,106.6 165.04,106.69 165.04,107.4 arc(165.06,107.53) 165.14,107.64 arc(165.25,107.72) 165.38,107.74 169.78,107.74 arc(169.91,107.77) 170.01,107.84 170.07,107.9 arc(170.14,108) 170.17,108.13 170.17,108.54 arc(170.18,108.59) 170.2,108.63 170.27,108.7 arc(170.32,108.73) 170.36,108.74 176.68,108.74 arc(176.85,108.77) 176.99,108.87 arc(177.09,109.01) 177.12,109.18 177.12,110.74 arc(177.16,110.83) 177.25,110.87 177.37,110.87 arc(177.42,110.86) 177.46,110.83 177.49,110.8 arc(177.53,110.74) 177.55,110.65 v4(177.55,110.39)
  SIG8 w0.16: 165.13,106.58 165.13,104.44 arc(165.07,104.15) 164.91,103.9 164.63,103.62 arc(164.46,103.38) 164.4,103.09 164.4,95.59 arc(164.46,95.3) 164.63,95.05 165.58,94.1 arc(165.74,93.85) 165.8,93.56 165.8,90.33 arc(165.71,89.89) 165.46,89.52 162.91,86.97 arc(162.83,86.85) 162.8,86.7 162.8,73.94 163.03,73.71 163.03,73.15 162.8,72.92 162.8,72.41 163.03,72.18 163.03,71.63 162.8,71.4 162.8,70.7 arc(162.71,70.26) 162.47,69.89 160.4,67.82 arc(160.32,67.7) 160.29,67.56 160.29,67.1 arc(160.36,66.93) 160.53,66.86 161.3,66.86 arc(161.5,66.82) 161.66,66.71 161.72,66.65 arc(161.78,66.56) 161.8,66.45 161.8,66.34 arc(161.76,66.14) 161.65,65.97 YJ28.C25
FC25_RDP1: length 69.9
  TOP w0.147: U1.F55 175.55,111.34 v4(175.55,111.29)
  SIG8 w0.112: v4(175.55,111.29) 175.55,111.04 arc(175.52,110.97) 175.45,110.94 175.22,110.94 arc(175.01,110.85) 174.92,110.64 174.92,110.05 arc(174.89,109.98) 174.82,109.95 163.38,109.95 163.28,110.04 163.26,110.04
  SIG8 w0.16: 163.26,110.04 162.97,110.04 arc(162.56,109.96) 162.21,109.72 162.07,109.58 arc(161.82,109.21) 161.73,108.77 161.73,90.36 161.73,90.36 arc(161.68,90.06) 161.51,89.82 160.56,88.87 arc(160.4,88.62) 160.34,88.33 160.34,71.92 arc(160.28,71.62) 160.11,71.38 156.48,67.74 arc(156.31,67.49) 156.25,67.2 156.25,64.58 arc(156.34,64.14) 156.59,63.77 157.01,63.35 arc(157.38,63.1) 157.82,63.01 159.39,63.01 arc(159.54,62.98) 159.66,62.9 159.75,62.82 159.79,62.77 arc(159.8,62.76) 159.82,62.74 arc(159.85,62.69) 159.88,62.64 arc(159.88,62.63) 159.88,62.63 arc(159.89,62.62) 159.89,62.61 arc(159.89,62.61) 159.89,62.6 arc(159.91,62.54) 159.91,62.48 159.91,62.07 arc(159.96,61.84) 160.09,61.65 160.33,61.41 160.45,61.29 arc(160.47,61.27) 160.49,61.24 arc(160.49,61.24) 160.49,61.24 arc(160.5,61.22) 160.51,61.21 arc(160.65,60.96) 160.7,60.68 YJ28.C15
FC25_RDP2: length 69
  TOP w0.147: U1.E57 173.95,110.84 arc(173.86,110.82) 173.78,110.77 173.65,110.64 arc(173.58,110.53) v4(173.55,110.39)
  SIG9 w0.112: v4(173.55,110.39) 173.55,110.61 arc(173.54,110.66) 173.51,110.7 173.51,110.71 arc(173.46,110.73) 173.42,110.74 173.22,110.74 arc(173.01,110.83) 172.93,111.04 172.93,111.5 arc(172.92,111.55) 172.89,111.59 172.77,111.71 arc(172.73,111.74) 172.68,111.75 163.38,111.75 163.28,111.66 163.26,111.66
  SIG9 w0.16: 163.26,111.66 162.37,111.66 arc(162.08,111.6) 161.83,111.43 161.58,111.18 arc(161.41,110.93) 161.35,110.64 161.35,104.71 arc(161.41,104.42) 161.58,104.17 161.89,103.85 arc(162.06,103.61) 162.12,103.31 162.12,90.23 arc(162.06,89.94) 161.89,89.69 160.94,88.74 arc(160.78,88.49) 160.72,88.2 160.72,76.71 arc(160.67,76.47) 160.54,76.27 arc(160.4,76.07) 160.35,75.83 160.35,74.81 160.58,74.58 160.58,74.02 160.35,73.79 160.35,73.28 arc(160.27,72.85) 160.02,72.47 159.1,71.55 159.1,71.22 158.71,70.83 158.38,70.83 158.02,70.47 158.02,70.14 157.63,69.75 157.3,69.75 156.13,68.59 arc(156.05,68.46) 156.02,68.32 156.02,66.52 156.25,66.29 156.25,65.73 156.02,65.51 156.02,65 arc(156.08,64.71) 156.24,64.46 157.62,63.08 arc(157.86,62.92) 158.16,62.86 159.06,62.86 arc(159.3,62.76) 159.4,62.52 159.4,62.34 arc(159.36,62.14) 159.25,61.97 YJ28.C17
FC25_RDP3: length 61.9
  TOP w0.147: U1.F59 171.55,111.34 v4(171.55,111.29)
  SIG9 w0.112: v4(171.55,111.29) 171.55,111.07 arc(171.54,111.02) 171.51,110.98 171.51,110.98 arc(171.46,110.95) 171.42,110.94 170.54,110.94 arc(170.33,110.9) 170.16,110.78 170.13,110.75 arc(170.04,110.62) 170,110.45 170,110.25 arc(169.98,110.13) 169.91,110.03 arc(169.8,109.96) 169.68,109.93 163.4,109.93 163.28,110.05
  SIG9 w0.16: YJ28.C21 158.3,64.88 arc(158.27,65.02) 158.19,65.15 157.64,65.7 arc(157.54,65.84) 157.51,66.01 157.51,66.42 arc(157.47,66.64) 157.35,66.82 157.27,66.9 arc(156.95,67.66) 157.27,68.41 arc(157.56,68.61) 157.9,68.68 158.63,68.68 arc(158.92,68.74) 159.16,68.9 162.2,71.94 arc(162.36,72.18) 162.42,72.47 162.42,86.7 arc(162.48,86.99) 162.64,87.24 165.19,89.79 arc(165.36,90.04) 165.42,90.33 165.42,92.14 arc(165.39,92.28) 165.31,92.41 164.86,92.85 arc(164.62,93.22) 164.53,93.66 164.53,105.47 arc(164.5,105.62) 164.42,105.74 162.65,107.51 arc(162.41,107.88) 162.32,108.31 162.32,109.23 162.44,109.52 arc(162.6,109.76) 162.85,109.93 163.07,110.02 arc(163.14,110.04) 163.21,110.05 163.28,110.05
FC25_TDN0: length 50
  TOP w0.147: U1.C66 165,108.84 arc(164.68,108.71) v4(164.55,108.39)
  SIG7 w0.112: v4(164.55,108.39) 164.55,108.64 arc(164.55,108.68) 164.53,108.71 164.52,108.75 arc(164.48,108.81) 164.42,108.85 164.4,108.86 arc(164.37,108.87) 164.34,108.87 164.24,108.87 arc(164.15,108.83) 164.11,108.74 164.11,107.84 164.21,107.74 164.21,107.72
  SIG7 w0.16: 164.21,107.72 164.21,95.81 arc(164.26,95.52) 164.43,95.27 167.33,92.37 arc(167.58,92.21) 167.87,92.15 168.74,92.15 arc(169.03,92.09) 169.28,91.93 169.77,91.44 arc(169.93,91.19) 169.99,90.9 169.99,75.92 arc(169.86,75.28) 169.5,74.74 arc(169.14,74.2) 169.01,73.56 169.01,69.22 169.2,69.03 169.2,68.57 169.01,68.38 169.01,68.07 arc(169.14,67.66) 169.39,67.31 169.7,67 arc(169.86,66.9) 170.04,66.86 171.06,66.86 arc(171.3,66.76) 171.4,66.52 171.4,66.34 arc(171.36,66.14) 171.25,65.97 YJ28.C37
FC25_TDN1: length 49.3
  TOP w0.147: U1.F61 169.55,111.34 v4(169.55,111.29)
  SIG6 w0.112: v4(169.55,111.29) 169.74,111.1 arc(169.79,111.07) 169.85,111.05 arc(169.98,111.03) 170.1,110.95 arc(170.17,110.84) 170.2,110.7 170.2,107.71 170.21,107.7 170.21,105.29 170.3,105.19 170.3,105.17
  SIG6 w0.16: YJ28.C34 168.85,65.97 arc(168.96,66.14) 169,66.34 169,66.52 arc(168.9,66.76) 168.66,66.86 167.68,66.86 arc(167.55,66.92) 167.49,67.05 167.49,68.23 arc(167.52,68.38) 167.6,68.5 167.93,68.83 168.1,68.83 168.57,69.29 168.57,69.47 169.1,70 arc(169.34,70.37) 169.43,70.8 169.43,91.4 arc(169.49,91.69) 169.65,91.93 170.08,92.36 arc(170.24,92.6) 170.3,92.9 170.3,103.79 170.53,104.02 170.53,104.48 170.3,104.71 170.3,105.17
FC25_TDN2: length 70.9
  TOP w0.147: U1.E63 168,110.84 arc(167.68,110.71) v4(167.55,110.39)
  SIG6 w0.112: 164.23,107.7 164.23,107.72 164.13,107.82 164.13,109.53 arc(164.14,109.58) 164.17,109.62 164.26,109.71 arc(164.3,109.74) 164.35,109.75 166.74,109.75 arc(166.87,109.78) 166.97,109.85 167.02,109.9 arc(167.09,110) 167.12,110.13 167.12,110.72 arc(167.15,110.8) 167.22,110.84 arc(167.24,110.84) 167.25,110.84 167.4,110.84 arc(167.47,110.83) 167.53,110.79 167.55,110.77 arc(167.57,110.74) 167.58,110.71 167.58,110.46 arc(167.57,110.42) v4(167.55,110.39)
  SIG6 w0.16: YJ28.C2 171.25,61.97 arc(171.36,62.14) 171.4,62.34 171.4,62.52 arc(171.3,62.76) 171.06,62.86 170.38,62.86 arc(169.87,62.96) 169.43,63.26 arc(169.22,63.36) 168.99,63.39 157.71,63.39 arc(157.42,63.45) 157.17,63.62 156.82,63.97 arc(156.65,64.22) 156.59,64.51 156.59,66.02 arc(156.65,66.31) 156.82,66.56 157.93,67.67 158.24,67.67 158.58,68.01 158.58,68.32 162.58,72.32 arc(162.74,72.56) 162.8,72.86 162.8,90.39 arc(162.86,90.68) 163.02,90.92 164.69,92.59 arc(164.85,92.83) 164.91,93.12 164.91,105.35 arc(164.85,105.64) 164.69,105.88 164.45,106.12 arc(164.28,106.37) 164.23,106.66 164.23,107.7
FC25_TDN3: length 68.4
  TOP w0.147: U1.F65 165.55,111.34 v4(165.55,111.29)
  SIG7 w0.112: v4(165.55,111.29) 165.55,111.1 arc(165.5,110.99) 165.38,110.94 165.25,110.94 arc(165.02,110.85) 164.92,110.62 164.92,110.21 arc(164.91,110.14) 164.86,110.08 164.85,110.06 arc(164.78,110.01) 164.71,110 163.29,110 163.2,110.09 163.15,110.09
  SIG7 w0.16: YJ28.C6 167.9,60.81 arc(167.86,61.02) 167.74,61.2 167.35,61.58 arc(167.17,61.85) 167.11,62.16 167.11,62.48 arc(167.11,62.53) 167.1,62.58 arc(167.09,62.59) 167.09,62.61 arc(167.05,62.7) 166.99,62.77 166.95,62.82 166.86,62.9 arc(166.74,62.98) 166.59,63.01 157.51,63.01 arc(157.22,63.07) 156.97,63.24 156.44,63.77 arc(156.27,64.02) 156.21,64.31 156.21,66.2 arc(156.27,66.49) 156.44,66.74 162.31,72.61 arc(162.39,72.74) 162.42,72.88 162.42,91.86 arc(162.39,92.01) 162.31,92.13 161.98,92.46 arc(161.82,92.71) 161.76,93 161.76,100.88 arc(161.73,101.02) 161.65,101.14 161.2,101.6 arc(161.03,101.84) 160.97,102.14 160.97,108.3 arc(161.03,108.59) 161.2,108.84 162.23,109.87 arc(162.47,110.03) 162.77,110.09 163.15,110.09
FC25_TDP0: length 50
  TOP w0.147: U1.D66 164.55,109.34 v4(164.55,109.29)
  SIG7 w0.112: v4(164.55,109.29) 164.46,109.2 arc(164.34,109.11) 164.19,109.06 arc(163.99,108.95) 163.92,108.74 163.92,107.85 163.82,107.75 163.82,107.72
  SIG7 w0.16: 163.82,107.72 163.82,95.81 arc(163.91,95.37) 164.16,95 167.06,92.1 arc(167.43,91.85) 167.87,91.77 168.74,91.77 arc(168.89,91.74) 169.01,91.66 169.5,91.17 arc(169.58,91.04) 169.61,90.9 169.61,75.92 arc(169.51,75.43) 169.23,75.01 arc(168.79,74.35) 168.63,73.56 168.63,68.03 168.64,68.03 arc(168.8,67.49) 169.12,67.04 169.35,66.82 169.39,66.77 arc(169.45,66.7) 169.49,66.62 arc(169.49,66.6) 169.5,66.58 arc(169.51,66.53) 169.51,66.48 169.51,66.16 arc(169.57,65.85) 169.75,65.58 170.11,65.22 arc(170.25,65.01) 170.3,64.77 YJ28.C36
FC25_TDP1: length 49.3
  TOP w0.147: U1.E61 170.04,110.84 arc(169.85,110.8) 169.69,110.7 169.61,110.61 arc(169.56,110.55) 169.55,110.47 v4(169.55,110.39)
  SIG6 w0.112: 169.92,105.17 169.92,105.19 170.01,105.29 170.01,107.62 170,107.63 170,110.7 arc(169.99,110.76) 169.96,110.81 arc(169.91,110.85) 169.85,110.86 169.71,110.86 arc(169.6,110.81) 169.55,110.7 v4(169.55,110.39)
  SIG6 w0.16: YJ28.C33 167.9,64.94 arc(167.88,65.03) 167.83,65.1 167.77,65.16 167.35,65.58 arc(167.17,65.85) 167.11,66.16 167.11,68.23 arc(167.17,68.52) 167.33,68.77 168.83,70.26 arc(168.99,70.51) 169.05,70.8 169.05,91.4 arc(169.14,91.83) 169.38,92.2 169.81,92.63 arc(169.89,92.75) 169.92,92.9 169.92,105.17
FC25_TDP2: length 70.9
  TOP w0.147: U1.F63 167.55,111.34 v4(167.55,111.29)
  SIG6 w0.112: v4(167.55,111.29) 167.35,111.09 arc(167.34,111.08) 167.33,111.07 arc(167.33,111.07) 167.33,111.07 arc(167.3,111.06) 167.27,111.05 167.19,111.04 arc(167,110.92) 166.92,110.72 166.92,110.13 arc(166.91,110.08) 166.89,110.04 166.83,109.99 arc(166.79,109.96) 166.74,109.95 164.35,109.95 arc(164.23,109.92) 164.12,109.85 164.03,109.76 arc(163.96,109.66) 163.94,109.53 163.94,107.82 163.84,107.72 163.84,107.7
  SIG6 w0.16: 163.84,107.7 163.84,106.58 163.85,106.58 arc(163.95,106.19) 164.18,105.85 164.42,105.62 arc(164.5,105.49) 164.53,105.35 164.53,93.12 arc(164.5,92.98) 164.42,92.86 162.76,91.19 arc(162.51,90.82) 162.42,90.39 162.42,72.86 arc(162.39,72.71) 162.31,72.59 156.55,66.83 arc(156.3,66.45) 156.21,66.02 156.21,64.51 arc(156.3,64.08) 156.55,63.7 156.9,63.35 arc(157.28,63.1) 157.71,63.01 168.99,63.01 arc(169.14,62.98) 169.26,62.9 169.35,62.82 169.39,62.77 arc(169.45,62.7) 169.49,62.61 arc(169.49,62.61) 169.49,62.6 arc(169.49,62.6) 169.5,62.59 arc(169.5,62.58) 169.5,62.58 arc(169.51,62.53) 169.51,62.48 169.51,62.16 arc(169.57,61.85) 169.75,61.58 170.14,61.19 arc(170.26,61.02) 170.3,60.81 YJ28.C3
FC25_TDP3: length 68.4
  TOP w0.147: U1.E65 166,110.84 arc(165.68,110.71) v4(165.55,110.39)
  SIG7 w0.112: 163.15,109.71 163.18,109.71 163.27,109.8 164.71,109.8 arc(164.86,109.83) 164.98,109.92 165,109.94 arc(165.09,110.06) 165.12,110.21 165.12,110.62 arc(165.16,110.71) 165.25,110.74 165.38,110.74 arc(165.5,110.7) 165.55,110.58 v4(165.55,110.39)
  SIG7 w0.16: 163.15,109.71 162.77,109.71 arc(162.62,109.68) 162.5,109.6 161.47,108.57 arc(161.38,108.44) 161.35,108.3 161.35,102.14 arc(161.38,101.99) 161.47,101.87 161.92,101.41 arc(162.08,101.17) 162.14,100.88 162.14,93 arc(162.17,92.85) 162.25,92.73 162.58,92.4 arc(162.74,92.16) 162.8,91.86 162.8,72.88 arc(162.74,72.59) 162.58,72.34 162.17,71.93 162.17,71.73 161.82,71.38 161.61,71.38 161.28,71.05 161.28,70.82 160.96,70.49 160.73,70.49 160.4,70.16 160.4,69.96 160.05,69.61 159.84,69.61 159.51,69.28 159.51,69.07 159.16,68.72 158.96,68.72 158.63,68.39 158.63,68.16 158.3,67.83 158.07,67.83 157.74,67.51 157.74,67.28 157.41,66.95 157.19,66.95 156.71,66.47 arc(156.62,66.35) 156.59,66.2 156.59,64.31 arc(156.62,64.16) 156.71,64.04 157.24,63.51 arc(157.36,63.42) 157.51,63.39 166.59,63.39 arc(166.88,63.34) 167.13,63.17 167.3,63 arc(167.46,62.9) 167.64,62.86 168.66,62.86 arc(168.9,62.76) 169,62.52 169,62.34 arc(168.96,62.14) 168.85,61.97 YJ28.C5
FC26_27_PVDD0P8: length 5.5
  TOP w0.229: U1.Y44 v1(186.55,125.34) ; U1.Y45 v1(185.55,125.34)
  TOP w0.381: 170.22,100.62 C2667.1 ; C2667.1 170.22,101.81 ; C2667.1 170.85,101.22
  BOTTOM w0.13: v1(171.39,101.72) v2(172.15,101.72)
  BOTTOM w0.381: v1(186.55,125.34) 187.07,124.82 C3323.1 ; C3151.1 185.07,124.86 v1(185.55,125.34)
  vias: v1(171.39,100.71)
FC26_RDN0: length 56.1
  TOP w0.147: U1.C53 177.52,108.32 v4(177.52,108.29)
  SIG3 w0.112: v4(177.52,108.29) 177.69,108.12 arc(177.75,108.08) 177.83,108.07 arc(178.06,107.97) 178.15,107.74 178.15,106.06 178.24,105.97 178.24,105.94
  SIG3 w0.16: YJ27.A15 168.7,60.85 arc(168.73,61.02) 168.83,61.17 169.34,61.67 arc(169.46,61.86) 169.51,62.08 169.51,62.48 169.51,62.57 arc(169.54,62.72) 169.63,62.86 169.68,62.91 arc(169.81,63) 169.95,63.03 171.39,63.03 arc(171.83,63.11) 172.2,63.36 172.72,63.89 arc(172.97,64.26) 173.06,64.69 173.06,66.25 arc(173.09,66.4) 173.17,66.52 173.98,67.33 arc(174.23,67.7) 174.31,68.14 174.31,68.89 arc(174.25,69.18) 174.09,69.43 171.74,71.78 arc(171.57,72.03) 171.51,72.32 171.51,88.42 arc(171.57,88.72) 171.74,88.96 176.88,94.1 arc(177.04,94.35) 177.1,94.64 177.1,102.14 arc(177.16,102.43) 177.33,102.68 178.02,103.37 arc(178.18,103.62) 178.24,103.91 178.24,105.94
FC26_RDN1: length 49.1
  TOP w0.147: U1.B55 175.99,107.84 arc(175.82,107.81) 175.68,107.71 175.62,107.65 arc(175.57,107.57) 175.55,107.49 v4(175.55,107.39)
  SIG3 w0.112: 175.86,105.94 175.98,106.06 175.98,107.74 arc(175.94,107.83) 175.85,107.87 175.75,107.87 arc(175.67,107.86) 175.61,107.81 arc(175.56,107.75) 175.55,107.67 v4(175.55,107.39)
  SIG3 w0.16: YJ27.A22 170.15,65.97 arc(170.04,66.13) 170.01,66.32 170.01,66.5 arc(170.11,66.76) 170.36,66.86 171.18,66.86 arc(171.47,66.92) 171.71,67.08 arc(171.81,67.23) 171.85,67.41 171.85,67.68 arc(171.82,67.82) 171.74,67.94 170.78,68.9 170.42,68.9 170.06,69.26 170.06,69.62 169.38,70.29 arc(169.14,70.67) 169.05,71.1 169.05,89.39 arc(169.14,89.83) 169.38,90.2 173.05,93.87 arc(173.14,93.99) 173.16,94.14 173.16,94.93 arc(173.25,95.37) 173.5,95.74 174.32,96.56 arc(174.41,96.69) 174.43,96.83 174.43,103.16 arc(174.52,103.59) 174.77,103.96 175.75,104.94 arc(175.83,105.05) 175.86,105.18 arc(175.86,105.2) 175.86,105.21 175.86,105.94
FC26_RDN2: length 51.1
  TOP w0.147: v4(173.57,108.29) 173.57,108.37 U1.C57
  SIG2 w0.112: v4(173.57,108.29) 173.4,108.11 arc(173.35,108.08) 173.29,108.07 arc(173.06,107.97) 172.96,107.74 172.96,106.06 172.87,105.97 172.87,105.94
  SIG2 w0.16: 172.87,105.94 172.87,105.76 arc(172.93,105.44) 173.11,105.17 173.13,105.16 arc(173.15,105.13) 173.16,105.09 arc(173.16,105.08) 173.16,105.07 173.16,94.17 arc(173.14,94.02) 173.05,93.9 171.47,92.31 arc(171.22,91.94) 171.13,91.5 171.13,70.8 170.85,70.52 170.85,70.06 171.13,69.78 171.13,69.27 arc(171.22,68.84) 171.47,68.47 172.57,67.37 arc(172.65,67.24) 172.68,67.1 172.68,64.64 arc(172.57,64.07) 172.25,63.59 171.74,63.08 arc(171.67,63.03) 171.6,62.98 arc(171.58,62.97) 171.57,62.96 arc(171.39,62.89) 171.2,62.86 170.39,62.86 arc(170.12,62.75) 170.01,62.48 170.01,62.32 arc(170.04,62.13) 170.15,61.97 YJ27.A17
FC26_RDN3: length 46.3
  TOP w0.147: U1.B59 171.95,107.84 arc(171.85,107.82) 171.77,107.77 171.6,107.6 arc(171.56,107.54) 171.55,107.47 v4(171.55,107.39)
  SIG2 w0.112: v4(171.55,107.39) 171.55,107.69 arc(171.56,107.76) 171.6,107.82 arc(171.66,107.86) 171.73,107.87 171.84,107.87 arc(171.93,107.83) 171.97,107.74 171.97,106.06 171.87,105.97 171.87,105.94
  SIG2 w0.16: YJ27.A25 167.75,65.97 arc(167.64,66.13) 167.61,66.32 167.61,66.5 arc(167.71,66.76) 167.96,66.86 168.72,66.86 arc(168.95,66.96) 169.05,67.19 169.05,67.7 168.8,67.95 168.8,68.46 169.05,68.71 169.05,69.22 168.77,69.5 168.77,69.96 169.05,70.24 169.05,92.85 arc(169.14,93.29) 169.38,93.66 169.5,93.77 arc(169.58,93.89) 169.61,94.04 169.61,102.68 arc(169.7,103.12) 169.94,103.49 171.75,105.3 arc(171.78,105.33) 171.81,105.36 arc(171.86,105.47) 171.87,105.59 171.87,105.94
FC26_RDP0: length 56.1
  TOP w0.147: U1.B53 177.99,107.84 arc(177.82,107.81) 177.68,107.71 177.64,107.67 arc(177.55,107.54) v4(177.52,107.39)
  SIG3 w0.112: 177.86,105.94 177.86,105.97 177.95,106.06 177.95,107.74 arc(177.92,107.83) 177.83,107.87 177.73,107.87 arc(177.65,107.86) 177.58,107.81 arc(177.54,107.75) 177.52,107.67 v4(177.52,107.39)
  SIG3 w0.16: 177.86,105.94 177.86,103.91 arc(177.83,103.77) 177.75,103.64 177.06,102.95 arc(176.81,102.58) 176.72,102.14 176.72,94.64 arc(176.69,94.5) 176.61,94.37 171.47,89.23 arc(171.22,88.86) 171.13,88.42 171.13,72.32 arc(171.22,71.88) 171.47,71.51 172.09,70.89 172.09,70.53 172.45,70.17 172.81,70.17 173.82,69.16 arc(173.9,69.04) 173.93,68.89 173.93,68.14 arc(173.87,67.85) 173.71,67.6 172.9,66.79 arc(172.74,66.54) 172.68,66.25 172.68,64.69 arc(172.62,64.4) 172.46,64.16 171.93,63.63 arc(171.68,63.46) 171.39,63.41 169.95,63.41 arc(169.66,63.35) 169.41,63.18 169.36,63.13 169.31,63.08 arc(169.07,62.92) 168.78,62.86 167.89,62.86 arc(167.69,62.78) 167.61,62.58 167.61,62.32 arc(167.64,62.13) 167.75,61.97 YJ27.A14
FC26_RDP1: length 49.1
  TOP w0.147: v4(175.55,108.29) 175.55,108.34 U1.C55
  SIG3 w0.112: v4(175.55,108.29) 175.72,108.12 arc(175.78,108.08) 175.85,108.07 arc(176.08,107.97) 176.18,107.74 176.18,106.01 176.24,105.94
  SIG3 w0.16: YJ27.A21 171.1,64.76 arc(171.15,65.01) 171.29,65.23 171.74,65.67 arc(171.86,65.86) 171.91,66.08 171.91,66.57 arc(171.93,66.71) 172.01,66.83 arc(172.17,67.08) 172.23,67.38 172.23,67.68 arc(172.17,67.97) 172.01,68.21 169.65,70.56 arc(169.49,70.81) 169.43,71.1 169.43,89.39 arc(169.49,89.68) 169.65,89.93 173.32,93.6 arc(173.49,93.84) 173.55,94.14 173.55,94.93 arc(173.6,95.22) 173.77,95.47 174.59,96.29 arc(174.76,96.54) 174.82,96.83 174.82,103.16 arc(174.87,103.45) 175.04,103.69 176.02,104.67 arc(176.17,104.89) 176.24,105.15 arc(176.24,105.18) 176.24,105.21 176.24,105.94
FC26_RDP2: length 51.1
  TOP w0.147: v4(173.57,107.39) 173.57,107.42 arc(173.61,107.58) 173.7,107.72 173.74,107.76 arc(173.83,107.82) 173.93,107.84 U1.B57
  SIG2 w0.112: v4(173.57,107.39) 173.57,107.69 arc(173.56,107.76) 173.52,107.82 arc(173.47,107.86) 173.4,107.87 173.29,107.87 arc(173.2,107.83) 173.16,107.74 173.16,106.06 173.25,105.97 173.25,105.94
  SIG2 w0.16: 173.25,105.94 173.25,105.76 arc(173.29,105.59) 173.38,105.44 173.4,105.43 arc(173.49,105.3) 173.54,105.15 arc(173.54,105.11) 173.55,105.07 173.55,94.17 arc(173.49,93.87) 173.32,93.63 171.74,92.04 arc(171.57,91.79) 171.51,91.5 171.51,69.27 arc(171.57,68.98) 171.74,68.74 172.84,67.64 arc(173,67.39) 173.06,67.1 173.06,64.64 arc(172.92,63.93) 172.51,63.32 172.1,62.91 arc(172,62.78) 171.94,62.64 arc(171.91,62.54) 171.91,62.44 171.91,62.35 171.91,62.08 arc(171.86,61.86) 171.74,61.67 171.28,61.21 arc(171.15,61.02) 171.1,60.78 YJ27.A18
FC26_RDP3: length 46.3
  TOP w0.147: v4(171.55,108.29) 171.55,108.34 U1.C59
  SIG2 w0.112: 172.25,105.94 172.25,105.97 172.16,106.06 172.16,107.74 arc(172.07,107.97) 171.84,108.07 arc(171.78,108.08) 171.72,108.12 v4(171.55,108.29)
  SIG2 w0.16: YJ27.A24 168.7,64.81 arc(168.74,65.02) 168.86,65.2 169.34,65.67 arc(169.46,65.86) 169.51,66.08 169.51,66.75 arc(169.5,66.8) 169.47,66.84 arc(169.44,66.88) 169.43,66.93 169.43,92.85 arc(169.49,93.14) 169.65,93.39 169.77,93.5 arc(169.93,93.75) 169.99,94.04 169.99,102.68 arc(170.05,102.97) 170.21,103.22 172.02,105.03 arc(172.08,105.09) 172.12,105.15 arc(172.22,105.36) 172.25,105.59 172.25,105.94
FC26_TDN0: length 47.1
  TOP w0.147: U1.A63 168,106.84 arc(167.68,106.71) v4(167.55,106.39)
  SIG5 w0.112: v4(167.55,106.39) 167.55,106.65 arc(167.54,106.7) 167.51,106.74 167.41,106.84 arc(167.37,106.87) 167.32,106.88 167.25,106.88 arc(167.16,106.84) 167.12,106.75 167.12,105.26 167.24,105.15
  SIG5 w0.16: 167.24,105.15 167.24,104.85 arc(167.16,104.44) 166.92,104.09 165.02,102.19 arc(164.94,102.06) 164.91,101.92 164.91,93.25 arc(164.82,92.81) 164.57,92.44 162.91,90.78 arc(162.83,90.66) 162.8,90.51 162.8,72.25 arc(162.74,71.95) 162.58,71.71 161.42,70.55 160.13,69.26 arc(159.96,69.01) 159.91,68.72 159.91,66.08 arc(159.86,65.86) 159.74,65.67 159.3,65.23 arc(159.15,65.01) 159.1,64.76 YJ27.A36
FC26_TDN1: length 62
  TOP w0.147: v4(169.57,107.28) 169.57,107.37 U1.B61
  SIG5 w0.112: 168.86,105.15 168.96,105.25 168.96,106.73 arc(169.06,106.96) 169.29,107.05 arc(169.34,107.06) 169.38,107.09 v4(169.57,107.28)
  SIG5 w0.16: 168.86,105.15 168.86,96.31 arc(168.92,96.02) 169.09,95.77 169.64,95.22 arc(169.8,94.97) 169.86,94.68 169.86,71.48 169.76,71.38 169.76,70.52 169.86,70.42 169.86,69.66 arc(169.92,69.36) 170.09,69.12 170.62,68.58 170.62,68.36 171.16,67.82 171.38,67.82 172.46,66.75 arc(172.62,66.5) 172.68,66.21 172.68,64.39 arc(172.62,64.1) 172.46,63.85 172.24,63.63 arc(171.99,63.46) 171.7,63.41 160.35,63.41 arc(160.06,63.35) 159.81,63.18 159.76,63.13 159.71,63.08 arc(159.47,62.92) 159.18,62.86 158.37,62.86 arc(158.11,62.76) 158.01,62.5 158.01,62.32 arc(158.04,62.13) 158.15,61.97 YJ27.A2
FC26_TDN2: length 47.7
  TOP w0.147: U1.C64 167.01,108.84 arc(166.83,108.81) 166.69,108.71 166.62,108.64 arc(166.57,108.57) 166.55,108.48 166.55,108.39 v4(166.55,108.4)
  SIG4 w0.112: v4(166.55,108.4) 166.55,108.68 arc(166.53,108.75) 166.49,108.82 arc(166.44,108.85) 166.39,108.87 166.25,108.87 arc(166.16,108.83) 166.12,108.74 166.12,105.98 166.22,105.89 166.22,105.86
  SIG4 w0.16: YJ27.A33 161.5,64.83 arc(161.53,65.01) 161.63,65.17 arc(161.64,65.17) 161.64,65.18 161.9,65.44 162.14,65.67 arc(162.26,65.86) 162.31,66.08 162.31,71.88 arc(162.36,72.17) 162.53,72.42 162.58,72.47 arc(162.74,72.72) 162.8,73.01 162.8,90.36 arc(162.86,90.65) 163.02,90.9 164.69,92.56 arc(164.85,92.81) 164.91,93.1 164.91,101.89 arc(164.97,102.18) 165.13,102.43 165.53,102.83 165.88,103.18 arc(166.13,103.55) 166.22,103.99 166.22,105.86
FC26_TDN3: length 62.1
  TOP w0.147: v4(168.57,109.29) 168.57,109.37 U1.D62
  SIG4 w0.112: v4(168.57,109.29) 168.38,109.1 arc(168.34,109.07) 168.28,109.06 168.25,109.06 arc(168.02,108.97) 167.93,108.74 167.93,107.94 167.96,107.91 167.96,105.27 167.87,105.18 167.87,105.15
  SIG4 w0.16: 167.87,105.15 167.87,104.74 arc(167.93,104.45) 168.09,104.2 168.21,104.09 arc(168.37,103.84) 168.43,103.55 168.43,96.71 arc(168.49,96.42) 168.66,96.17 169.19,95.64 169.26,95.57 arc(169.42,95.33) 169.48,95.03 169.48,70.67 arc(169.57,70.23) 169.82,69.86 170.41,69.27 170.41,69.07 170.93,68.55 171.13,68.55 171.49,68.19 171.49,67.99 172.01,67.47 172.21,67.47 172.57,67.11 arc(172.65,66.99) 172.68,66.84 172.68,64.25 arc(172.65,64.11) 172.57,63.99 172.1,63.52 arc(171.98,63.44) 171.83,63.41 162.75,63.41 arc(162.46,63.35) 162.21,63.18 162.16,63.13 162.11,63.08 arc(161.87,62.92) 161.58,62.86 160.73,62.86 arc(160.5,62.77) 160.41,62.54 160.41,62.32 arc(160.44,62.13) 160.55,61.97 YJ27.A5
FC26_TDP0: length 47.1
  TOP w0.147: v4(167.55,107.28) 167.55,107.34 U1.B63
  SIG5 w0.112: 166.86,105.15 166.92,105.21 166.92,106.75 arc(167.02,106.98) 167.25,107.08 arc(167.33,107.09) 167.41,107.14 v4(167.55,107.28)
  SIG5 w0.16: YJ27.A37 158.15,65.97 arc(158.04,66.13) 158.01,66.32 158.01,66.59 arc(158.09,66.78) 158.28,66.86 159.32,66.86 arc(159.47,66.92) 159.53,67.06 159.53,68.72 arc(159.61,69.16) 159.86,69.53 160.4,70.07 160.4,70.21 161.01,70.82 161.15,70.82 162.31,71.98 arc(162.39,72.1) 162.42,72.25 162.42,73.01 162.29,73.13 162.29,73.95 162.42,74.07 162.42,90.51 arc(162.48,90.8) 162.64,91.05 164.31,92.71 arc(164.47,92.96) 164.53,93.25 164.53,101.92 arc(164.59,102.21) 164.75,102.46 165.36,103.06 165.36,103.21 165.96,103.82 166.11,103.82 166.65,104.36 arc(166.8,104.58) 166.86,104.85 166.86,105.15
FC26_TDP1: length 62
  TOP w0.147: U1.A61 170.03,106.84 arc(169.71,106.71) v4(169.57,106.39)
  SIG5 w0.112: v4(169.57,106.39) 169.57,106.68 arc(169.56,106.73) 169.54,106.77 169.49,106.82 arc(169.45,106.85) 169.4,106.86 169.29,106.86 arc(169.2,106.82) 169.16,106.73 169.16,105.23 169.24,105.15
  SIG5 w0.16: YJ27.A3 159.1,60.78 arc(159.15,61.02) 159.28,61.22 159.74,61.67 arc(159.86,61.86) 159.91,62.08 159.91,62.57 arc(159.91,62.6) 159.91,62.63 arc(159.95,62.75) 160.03,62.86 160.06,62.89 160.08,62.91 arc(160.21,63) 160.35,63.03 171.7,63.03 arc(172.14,63.11) 172.51,63.36 172.73,63.58 arc(172.97,63.95) 173.06,64.39 173.06,66.21 arc(172.97,66.65) 172.73,67.02 170.36,69.39 arc(170.27,69.51) 170.24,69.66 170.24,94.68 arc(170.16,95.12) 169.91,95.49 169.36,96.04 arc(169.27,96.16) 169.24,96.31 169.24,105.15
FC26_TDP2: length 47.7
  TOP w0.147: v4(166.55,109.29) 166.55,109.34 U1.D64
  SIG4 w0.112: 165.84,105.86 165.84,105.89 165.93,105.98 165.93,108.74 arc(166.01,108.95) 166.2,109.06 arc(166.24,109.07) 166.28,109.08 arc(166.33,109.09) 166.38,109.12 v4(166.55,109.29)
  SIG4 w0.16: 165.84,105.86 165.84,103.99 arc(165.78,103.7) 165.61,103.45 165.26,103.1 164.86,102.7 arc(164.62,102.33) 164.53,101.89 164.53,93.1 arc(164.5,92.95) 164.42,92.83 162.76,91.17 arc(162.51,90.8) 162.42,90.36 162.42,73.01 arc(162.39,72.86) 162.31,72.74 162.26,72.69 arc(162.01,72.32) 161.93,71.88 161.93,70.33 161.73,70.14 161.73,69.51 161.93,69.32 161.93,68.81 161.73,68.62 161.73,67.98 161.93,67.79 161.93,67.08 arc(161.86,66.92) 161.71,66.86 160.74,66.86 arc(160.5,66.76) 160.41,66.53 160.41,66.32 arc(160.44,66.13) 160.55,65.97 YJ27.A34
FC26_TDP3: length 62.1
  TOP w0.147: U1.C62 168.93,108.84 arc(168.82,108.82) 168.72,108.76 168.68,108.71 arc(168.58,108.57) 168.55,108.4 v4(168.55,108.4)
  SIG4 w0.112: 168.25,105.15 168.25,105.18 168.16,105.27 168.16,107.99 168.12,108.03 168.12,108.74 arc(168.16,108.83) 168.25,108.87 168.42,108.87 arc(168.51,108.83) 168.55,108.74 v4(168.55,108.4)
  SIG4 w0.16: 168.25,105.15 168.25,104.74 arc(168.28,104.6) 168.36,104.47 168.48,104.36 arc(168.73,103.99) 168.81,103.55 168.81,96.71 arc(168.84,96.57) 168.93,96.44 169.45,95.92 169.64,95.73 arc(169.8,95.48) 169.86,95.19 169.86,70.67 arc(169.92,70.38) 170.09,70.13 172.84,67.38 arc(173,67.13) 173.06,66.84 173.06,64.25 arc(173,63.96) 172.84,63.72 172.37,63.25 arc(172.12,63.08) 171.83,63.03 162.75,63.03 arc(162.61,63) 162.48,62.91 162.43,62.86 arc(162.34,62.72) 162.31,62.57 162.31,62.08 arc(162.26,61.86) 162.14,61.67 161.92,61.46 161.63,61.16 arc(161.53,61.02) 161.5,60.86 YJ27.A6
FC27_RDN0: length 67.1
  TOP w0.147: U1.G49 182.05,112.78 arc(182.02,112.61) 181.92,112.47 181.86,112.41 arc(181.79,112.36) 181.7,112.34 v4(181.6,112.34)
  SIG3 w0.112: 181.86,105.94 181.86,105.97 181.95,106.06 181.95,111.94 arc(181.94,111.99) 181.91,112.03 v4(181.6,112.34)
  SIG3 w0.16: 181.86,105.94 181.86,103.34 arc(181.83,103.19) 181.75,103.07 181.68,103 arc(181.43,102.63) 181.34,102.19 181.34,91.07 arc(181.31,90.92) 181.23,90.8 175.96,85.53 arc(175.72,85.16) 175.63,84.72 175.63,73.67 arc(175.72,73.23) 175.96,72.86 178.01,70.82 arc(178.09,70.69) 178.12,70.55 178.12,68.65 arc(178.09,68.51) 178.01,68.38 176.83,67.21 175.66,66.04 arc(175.42,65.67) 175.33,65.23 175.33,59.01 arc(175.27,58.72) 175.11,58.47 173.96,57.33 173.6,57.33 173.24,56.97 173.24,56.61 171.71,55.08 arc(171.65,55.03) 171.58,54.98 arc(171.38,54.89) 171.18,54.86 170.36,54.86 arc(170.11,54.76) 170.01,54.51 170.01,54.32 arc(170.04,54.13) 170.15,53.97 YJ27.B17
FC27_RDN1: length 66.2
  TOP w0.147: v4(182.5,114.34) 182.55,114.34 U1.J48
  SIG3 w0.112: 180.24,105.94 180.24,105.97 180.15,106.06 180.15,113.5 arc(180.16,113.55) 180.19,113.59 180.27,113.68 arc(180.31,113.71) 180.36,113.72 181.82,113.72 arc(182.05,113.81) 182.15,114.04 182.15,114.21 arc(182.18,114.3) 182.27,114.34 v4(182.5,114.34)
  SIG3 w0.16: 180.24,105.94 180.24,103.75 arc(180.18,103.46) 180.02,103.21 179.87,103.06 arc(179.7,102.81) 179.64,102.52 179.64,92 arc(179.58,91.71) 179.42,91.46 174.15,86.19 arc(173.98,85.95) 173.93,85.66 173.93,72.83 arc(173.98,72.54) 174.15,72.29 176.16,70.29 arc(176.32,70.04) 176.38,69.75 176.38,68.42 arc(176.32,68.13) 176.16,67.88 174.6,66.33 arc(174.44,66.08) 174.38,65.79 174.38,62.04 arc(174.22,61.27) 173.79,60.62 172.11,58.94 172.11,58.94 arc(172.1,58.93) 172.08,58.91 arc(171.95,58.72) 171.91,58.49 171.91,58.08 arc(171.86,57.86) 171.74,57.67 171.28,57.21 arc(171.15,57.02) 171.1,56.78 YJ27.B21
FC27_RDN2: length 74.1
  TOP w0.147: U1.L49 182.05,116.76 arc(182.03,116.66) 181.97,116.58 181.79,116.39 arc(181.73,116.35) 181.67,116.34 v4(181.6,116.34)
  SIG2 w0.112: 179.86,105.97 179.86,105.99 179.95,106.08 179.95,115.49 arc(179.98,115.62) 180.05,115.72 180.14,115.82 arc(180.25,115.89) 180.37,115.91 181.82,115.91 arc(181.91,115.95) 181.95,116.04 181.95,116.21 arc(181.91,116.3) 181.82,116.34 v4(181.6,116.34)
  SIG2 w0.16: YJ27.B14 167.75,53.97 arc(167.64,54.13) 167.61,54.32 167.61,54.53 arc(167.7,54.76) 167.94,54.86 168.78,54.86 arc(169.07,54.92) 169.31,55.08 169.36,55.13 169.41,55.18 arc(169.5,55.26) 169.6,55.32 arc(169.77,55.38) 169.95,55.41 172.25,55.41 arc(172.54,55.46) 172.79,55.63 175.12,57.96 arc(175.28,58.2) 175.34,58.5 175.34,66.74 arc(175.41,67.07) 175.6,67.36 arc(175.62,67.39) 175.63,67.44 175.63,70.3 175.35,70.58 175.35,71.04 175.63,71.32 175.63,87.74 arc(175.72,88.18) 175.96,88.55 181.25,93.83 arc(181.33,93.96) 181.36,94.1 181.36,102.99 arc(181.33,103.14) 181.25,103.26 180.2,104.31 arc(179.95,104.69) 179.86,105.12 179.86,105.97
FC27_RDN3: length 72.1
  TOP w0.147: v4(182.5,118.34) 182.55,118.34 U1.N48
  SIG2 w0.112: v4(182.5,118.34) 182.27,118.34 arc(182.18,118.3) 182.15,118.21 182.15,118.04 arc(182.05,117.81) 181.82,117.72 179.34,117.72 arc(179.29,117.71) 179.25,117.68 179.19,117.61 arc(179.16,117.57) 179.15,117.52 179.15,106.08 179.24,105.99 179.24,105.97
  SIG2 w0.16: YJ27.B24 168.7,56.8 arc(168.74,57.02) 168.86,57.2 169.34,57.67 arc(169.46,57.86) 169.51,58.08 169.51,58.57 arc(169.54,58.72) 169.63,58.86 169.68,58.91 arc(169.73,58.95) 169.78,58.98 arc(169.86,59.01) 169.95,59.03 172.7,59.03 arc(173.13,59.11) 173.5,59.36 174.04,59.9 arc(174.29,60.27) 174.38,60.71 174.38,68.83 arc(174.32,69.12) 174.15,69.37 174.15,69.37 arc(173.98,69.62) 173.93,69.91 173.93,90.87 arc(173.98,91.16) 174.15,91.41 176.88,94.14 arc(177.04,94.38) 177.1,94.67 177.1,102.68 arc(177.16,102.97) 177.33,103.22 179.02,104.91 arc(179.11,105.02) 179.18,105.15 arc(179.23,105.3) 179.24,105.45 179.24,105.97
FC27_RDP0: length 67.1
  TOP w0.147: U1.G48 182.55,112.34 v4(182.5,112.34)
  SIG3 w0.112: 182.24,105.94 182.24,105.97 182.15,106.06 182.15,111.94 arc(182.16,111.99) 182.18,112.03 v4(182.5,112.34)
  SIG3 w0.16: YJ27.B18 171.1,52.76 arc(171.15,53.01) 171.3,53.23 171.5,53.43 171.74,53.67 arc(171.86,53.86) 171.91,54.08 171.91,54.45 arc(171.96,54.71) 172.11,54.94 172.15,54.98 175.37,58.21 arc(175.62,58.58) 175.71,59.01 175.71,65.23 arc(175.77,65.53) 175.93,65.77 178.28,68.12 arc(178.44,68.36) 178.5,68.65 178.5,70.55 arc(178.44,70.84) 178.28,71.09 176.23,73.13 arc(176.07,73.38) 176.01,73.67 176.01,84.72 arc(176.07,85.01) 176.23,85.26 181.5,90.53 arc(181.67,90.78) 181.72,91.07 181.72,102.19 arc(181.78,102.48) 181.95,102.73 182.02,102.8 arc(182.18,103.04) 182.24,103.34 182.24,105.94
