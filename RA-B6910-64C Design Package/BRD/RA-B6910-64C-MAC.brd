# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC6_RDN0: length 183.7
  TOP w0.147: v4(171.6,171.34) 171.67,171.34 arc(171.74,171.33) 171.8,171.29 171.91,171.18 arc(172.01,171.02) U1.CE59
  SIG3 w0.112: v4(171.6,171.34) 171.85,171.34 arc(171.93,171.33) 171.99,171.29 172.04,171.24 arc(172.06,171.2) 172.07,171.15 172.07,171.05 arc(172.07,171.02) 172.05,170.98 arc(172.01,170.94) 171.95,170.92 165.62,170.92 arc(165.31,170.99) 165.05,171.16 164.43,171.78 arc(164.28,171.88) 164.09,171.92 163.86,171.92 163.75,172.03
  SIG3 w0.16: 163.75,172.03 151.71,172.03 arc(151.26,171.94) 150.87,171.69 84.7,105.51 arc(84.44,105.34) 84.14,105.28 67.2,105.28 arc(66.75,105.19) 66.36,104.93 48.92,87.5 arc(48.67,87.11) 48.58,86.66 48.58,68.69 arc(48.52,68.37) 48.34,68.11 47.47,67.24 47.31,67.08 arc(47.24,67.02) 47.17,66.97 arc(46.98,66.89) 46.78,66.86 45.99,66.86 arc(45.72,66.75) 45.61,66.48 45.61,66.32 arc(45.64,66.13) 45.75,65.97 YJ21.C25
FC6_RDN1: length 184.2
  TOP w0.147: v4(172.5,169.34) 172.55,169.34 U1.CC58
  SIG3 w0.112: 161.73,169.54 161.76,169.54 161.85,169.63 162.06,169.63 arc(162.27,169.59) 162.46,169.47 162.91,169.01 arc(163.23,168.8) 163.62,168.72 171.95,168.72 arc(172.13,168.78) 172.25,168.94 172.26,168.97 arc(172.36,169.17) v4(172.5,169.34)
  SIG3 w0.16: 161.73,169.54 152.55,169.54 arc(152.24,169.48) 151.98,169.31 85.76,103.09 arc(85.38,102.83) 84.92,102.74 68.34,102.74 arc(68.03,102.68) 67.77,102.51 51.35,86.08 arc(51.18,85.82) 51.12,85.52 51.12,80.32 arc(51.18,80.03) 51.34,79.78 51.4,79.72 arc(51.57,79.48) 51.63,79.18 51.63,67.82 51.85,67.59 51.85,67.03 51.63,66.8 51.63,66.29 51.88,66.04 51.88,65.53 51.63,65.28 51.63,64.94 arc(51.54,64.49) 51.28,64.11 50.13,62.95 50.1,62.93 arc(49.96,62.71) 49.91,62.46 49.91,62.08 arc(49.86,61.86) 49.74,61.67 49.3,61.23 arc(49.15,61.01) 49.1,60.75 YJ21.C18
FC6_RDN2: length 186.7
  TOP w0.147: v4(171.6,167.39) 171.6,167.3 arc(171.62,167.22) 171.66,167.15 171.92,166.9 arc(171.98,166.86) U1.CA59
  SIG2 w0.112: v4(171.6,167.39) 171.67,167.46 arc(171.83,167.68) 171.93,167.94 arc(171.94,167.99) 171.94,168.04 arc(171.95,168.09) 171.95,168.14 171.95,168.53 arc(171.94,168.59) 171.9,168.65 arc(171.85,168.68) 171.78,168.7 171.39,168.7 arc(171.22,168.73) 171.08,168.82 arc(170.99,168.97) 170.96,169.13 170.96,170.43 arc(170.93,170.55) 170.87,170.65 170.87,170.65 arc(170.77,170.71) 170.65,170.74 165.63,170.74 arc(165.25,170.81) 164.92,171.03 164.3,171.65 arc(164.2,171.72) 164.08,171.74 163.76,171.74 163.67,171.65 163.64,171.65
  SIG2 w0.16: 163.64,171.65 151.73,171.65 arc(151.42,171.59) 151.16,171.42 84.99,105.25 arc(84.61,104.99) 84.16,104.9 67.2,104.9 arc(66.89,104.84) 66.63,104.67 49.19,87.23 arc(49.02,86.97) 48.96,86.66 48.96,80.11 49.19,79.88 49.19,79.32 48.96,79.09 48.96,78.59 49.2,78.34 49.2,77.81 48.96,77.57 48.96,74.57 49.21,74.32 49.21,73.81 48.96,73.56 48.96,73.05 49.21,72.79 49.21,72.29 48.96,72.03 48.96,71.48 arc(49.02,71.17) 49.19,70.91 50.45,69.65 arc(50.71,69.27) 50.8,68.82 50.8,68.65 arc(50.61,67.71) 50.08,66.91 50.03,66.86 arc(49.94,66.72) 49.91,66.57 49.91,66.08 arc(49.86,65.86) 49.74,65.67 49.26,65.19 arc(49.14,65.02) 49.1,64.81 YJ21.C21
FC6_RDN3: length 190.3
  TOP w0.147: v4(172.5,165.39) 172.5,165.39 U1.BW58
  SIG2 w0.112: 161.73,169.92 161.76,169.92 161.85,169.83 162.25,169.83 arc(162.45,169.79) 162.61,169.68 163.11,169.18 arc(163.37,169.01) 163.68,168.95 169.62,168.95 arc(169.84,168.9) 170.03,168.78 arc(170.16,168.59) 170.2,168.36 170.2,167.17 arc(170.21,167.12) 170.24,167.07 170.28,167.03 arc(170.38,166.97) 170.5,166.94 171.69,166.94 arc(171.87,166.91) 172.01,166.81 arc(172.11,166.66) 172.15,166.49 172.15,166.3 arc(172.16,166.14) 172.21,165.99 172.43,165.46 v4(172.5,165.39)
  SIG2 w0.16: 161.73,169.92 152.57,169.92 arc(152.11,169.83) 151.73,169.58 85.51,103.36 arc(85.25,103.18) 84.94,103.12 68.34,103.12 arc(67.89,103.03) 67.5,102.78 51.07,86.34 arc(50.82,85.97) 50.74,85.53 50.74,82.12 arc(50.83,81.67) 51.08,81.29 51.25,81.12 arc(51.43,80.86) 51.49,80.55 51.49,71.41 arc(51.55,71.12) 51.71,70.87 52,70.58 52.29,70.29 arc(52.46,70.05) 52.51,69.75 52.51,65.61 arc(52.45,65.3) 52.28,65.04 50.88,63.64 arc(50.62,63.47) 50.31,63.41 47.95,63.41 arc(47.77,63.38) 47.6,63.32 arc(47.5,63.26) 47.41,63.18 47.31,63.08 arc(47.07,62.92) 46.78,62.86 45.88,62.86 arc(45.69,62.78) 45.61,62.58 45.61,62.32 arc(45.64,62.13) 45.75,61.97 YJ21.C14
FC6_RDP0: length 183.7
  TOP w0.147: U1.CE58 172.55,171.34 v4(172.5,171.34)
  SIG3 w0.112: 163.77,171.65 163.85,171.72 164.09,171.72 arc(164.2,171.7) 164.29,171.64 164.91,171.02 arc(165.24,170.8) 165.62,170.73 171.95,170.73 arc(172.14,170.79) 172.25,170.95 arc(172.31,171.09) 172.39,171.21 arc(172.44,171.28) v4(172.5,171.34)
  SIG3 w0.16: 163.77,171.65 151.71,171.65 arc(151.4,171.59) 151.14,171.42 84.97,105.25 arc(84.59,104.99) 84.14,104.9 67.2,104.9 arc(66.89,104.84) 66.63,104.67 49.19,87.23 arc(49.02,86.97) 48.96,86.66 48.96,71.74 49.19,71.51 49.19,70.95 48.96,70.72 48.96,70.21 49.19,69.98 49.19,69.42 48.96,69.2 48.96,68.69 arc(48.87,68.23) 48.61,67.84 47.67,66.9 arc(47.55,66.72) 47.51,66.51 47.51,66.08 arc(47.46,65.86) 47.34,65.67 46.97,65.31 arc(46.77,65.01) 46.7,64.65 YJ21.C24
FC6_RDP1: length 184.2
  TOP w0.147: v4(171.6,169.34) 171.68,169.34 arc(171.76,169.33) 171.82,169.28 171.91,169.2 arc(172.01,169.04) 172.05,168.86 U1.CC59
  SIG3 w0.112: 161.73,169.92 161.76,169.92 161.85,169.83 162.06,169.83 arc(162.35,169.77) 162.6,169.61 163.05,169.15 arc(163.31,168.98) 163.62,168.92 171.95,168.92 arc(172.04,168.96) 172.07,169.05 172.07,169.16 arc(172.06,169.21) 172.04,169.25 172.01,169.28 arc(171.94,169.33) 171.86,169.34 v4(171.6,169.34)
  SIG3 w0.16: 161.73,169.92 152.55,169.92 arc(152.09,169.83) 151.71,169.58 85.49,103.36 arc(85.23,103.18) 84.92,103.12 68.34,103.12 arc(67.89,103.03) 67.5,102.78 51.08,86.35 arc(50.83,85.97) 50.74,85.52 50.74,80.32 arc(50.82,79.89) 51.07,79.51 51.13,79.45 arc(51.22,79.33) 51.24,79.18 51.24,64.94 arc(51.18,64.64) 51.01,64.38 49.72,63.09 arc(49.67,63.04) 49.61,63 arc(49.6,62.99) 49.58,62.98 arc(49.39,62.89) 49.18,62.86 48.33,62.86 arc(48.1,62.77) 48.01,62.54 48.01,62.32 arc(48.04,62.13) 48.15,61.97 YJ21.C17
FC6_RDP2: length 186.7
  TOP w0.147: U1.CA58 v4(172.5,167.39)
  SIG2 w0.112: 163.64,172.03 163.67,172.03 163.76,171.94 164.08,171.94 arc(164.27,171.9) 164.44,171.79 164.79,171.44 165.06,171.17 arc(165.32,170.99) 165.63,170.93 170.65,170.93 arc(170.84,170.9) 171.01,170.79 arc(171.11,170.62) 171.15,170.43 171.15,169.13 arc(171.17,169.04) 171.22,168.96 arc(171.3,168.91) 171.39,168.89 171.78,168.89 arc(171.92,168.87) 172.04,168.79 arc(172.12,168.67) 172.15,168.53 172.15,168.14 arc(172.15,168.08) 172.14,168.02 arc(172.13,167.96) 172.12,167.9 172.12,167.88 arc(172.12,167.68) 172.22,167.51 172.23,167.5 arc(172.35,167.42) v4(172.5,167.39)
  SIG2 w0.16: YJ21.C22 48.15,65.97 arc(48.04,66.13) 48.01,66.32 48.01,66.56 arc(48.09,66.77) 48.3,66.86 49.18,66.86 arc(49.47,66.92) 49.71,67.08 49.81,67.18 arc(50.26,67.86) 50.42,68.65 50.42,68.82 arc(50.36,69.12) 50.19,69.38 48.92,70.64 arc(48.67,71.03) 48.58,71.48 48.58,86.66 arc(48.67,87.11) 48.92,87.5 66.36,104.93 arc(66.75,105.19) 67.2,105.28 84.16,105.28 arc(84.46,105.34) 84.72,105.51 150.89,171.69 arc(151.28,171.94) 151.73,172.03 163.64,172.03
FC6_RDP3: length 190.3
  TOP w0.147: v4(171.6,165.39) 171.6,165.29 arc(171.62,165.2) 171.67,165.12 171.88,164.91 arc(171.95,164.86) U1.BW59
  SIG2 w0.112: 161.73,169.54 161.76,169.54 161.85,169.63 162.25,169.63 arc(162.37,169.61) 162.47,169.54 162.97,169.04 arc(163.3,168.82) 163.68,168.75 169.62,168.75 arc(169.77,168.72) 169.89,168.64 arc(169.97,168.51) 170,168.36 170,167.17 arc(170.03,167.04) 170.1,166.93 170.15,166.89 arc(170.31,166.78) 170.5,166.75 171.69,166.75 arc(171.79,166.73) 171.88,166.67 arc(171.93,166.59) 171.95,166.49 171.95,166.14 arc(171.96,165.99) 171.99,165.85 arc(171.99,165.72) 171.92,165.6 171.78,165.46 arc(171.7,165.41) v4(171.6,165.39)
  SIG2 w0.16: YJ21.C15 46.7,60.67 arc(46.77,61.01) 46.96,61.29 47.34,61.67 arc(47.46,61.86) 47.51,62.08 47.51,62.57 arc(47.54,62.72) 47.63,62.86 47.68,62.91 arc(47.73,62.95) 47.78,62.98 arc(47.86,63.01) 47.95,63.03 50.31,63.03 arc(50.77,63.12) 51.15,63.37 52.55,64.77 arc(52.81,65.15) 52.9,65.61 52.9,66.6 53.15,66.85 53.15,67.36 52.9,67.61 52.9,68.12 53.12,68.35 53.12,68.91 52.9,69.14 52.9,69.75 arc(52.81,70.19) 52.56,70.56 51.98,71.14 arc(51.9,71.27) 51.87,71.41 51.87,73.02 52.1,73.25 52.1,73.81 51.87,74.04 51.87,80.55 arc(51.78,81) 51.52,81.39 51.35,81.56 arc(51.18,81.82) 51.12,82.12 51.12,85.53 arc(51.18,85.83) 51.34,86.07 67.77,102.51 arc(68.03,102.68) 68.34,102.74 84.94,102.74 arc(85.4,102.83) 85.78,103.09 152,169.31 arc(152.26,169.48) 152.57,169.54 161.73,169.54
FC6_TDN0: length 184.5
  TOP w0.147: U1.CD66 165,169.84 arc(164.68,169.97) v4(164.55,170.29)
  SIG5 w0.112: 163.15,171.03 163.18,171.03 163.27,170.94 163.61,170.94 arc(163.72,170.93) 163.82,170.9 163.82,170.9 arc(163.9,170.85) 163.97,170.79 arc(164.08,170.63) 164.12,170.43 164.12,170.08 arc(164.16,169.99) 164.25,169.95 164.42,169.95 arc(164.51,169.99) 164.55,170.08 v4(164.55,170.29)
  SIG5 w0.16: 163.15,171.03 150.71,171.03 arc(150.28,170.95) 149.91,170.7 85.67,106.46 arc(85.49,106.34) 85.27,106.3 59.27,106.3 arc(58.91,106.22) 58.61,106.02 41.87,89.28 arc(41.66,88.98) 41.59,88.62 41.59,82.86 arc(41.53,82.57) 41.37,82.32 38.82,79.77 arc(38.62,79.47) 38.54,79.11 38.54,69.86 arc(38.5,69.64) 38.38,69.46 37.86,68.94 arc(37.61,68.57) 37.53,68.13 37.53,67.42 arc(37.36,67.03) 36.97,66.86 36.35,66.86 arc(36.11,66.76) 36.01,66.52 36.01,66.32 arc(36.04,66.13) 36.15,65.97 YJ21.C37
FC6_TDN1: length 191.4
  TOP w0.147: U1.CA61 169.57,167.32 v4(169.57,167.39)
  SIG4 w0.112: v4(169.57,167.39) 169.57,167.62 arc(169.54,167.71) 169.45,167.74 169.29,167.74 arc(169.06,167.84) 168.96,168.07 168.96,170.52 arc(168.95,170.56) 168.93,170.6 168.84,170.69 arc(168.8,170.71) 168.76,170.72 165.52,170.72 arc(165.23,170.78) 164.98,170.94 164.34,171.58 arc(164.16,171.7) 163.95,171.75 163.58,171.75 163.49,171.65 163.46,171.65
  SIG4 w0.16: 163.46,171.65 151.69,171.65 arc(151.4,171.6) 151.15,171.43 84.9,105.17 arc(84.59,104.97) 84.23,104.9 64.08,104.9 arc(63.87,104.86) 63.68,104.74 55.87,96.92 arc(55.56,96.72) 55.2,96.64 49.98,96.64 arc(49.76,96.6) 49.58,96.48 45.44,92.34 arc(45.32,92.16) 45.28,91.94 45.28,74.55 arc(45.2,74.2) 45,73.89 42.36,71.25 42.36,70.97 42.06,70.67 41.78,70.67 40.53,69.42 arc(40.36,69.17) 40.31,68.88 40.31,66.09 arc(40.26,65.86) 40.13,65.67 39.62,65.15 arc(39.62,65.15) 39.61,65.15 arc(39.53,65.02) 39.5,64.87 YJ21.C33
FC6_TDN2: length 192.8
  TOP w0.147: v4(167.55,168.29) 167.66,168.29 arc(167.77,168.27) 167.86,168.21 167.92,168.14 arc(168.02,168) U1.CB63
  SIG4 w0.112: 161.71,169.87 161.74,169.87 161.83,169.78 162.15,169.78 arc(162.44,169.72) 162.68,169.56 163.13,169.11 arc(163.31,168.99) 163.53,168.95 166.71,168.95 arc(166.84,168.92) 166.94,168.85 167.02,168.77 arc(167.09,168.66) 167.12,168.54 167.12,168.07 arc(167.16,167.98) 167.25,167.94 167.42,167.94 arc(167.51,167.98) 167.55,168.07 v4(167.55,168.29)
  SIG4 w0.16: 161.71,169.87 152.53,169.87 arc(152.09,169.79) 151.72,169.54 85.46,103.29 arc(85.28,103.16) 85.07,103.12 64.94,103.12 arc(64.58,103.05) 64.27,102.85 48.85,87.43 arc(48.65,87.12) 48.58,86.76 48.58,70.04 arc(48.66,69.6) 48.91,69.23 50.65,67.49 arc(50.77,67.31) 50.81,67.1 50.81,64.47 arc(50.77,64.26) 50.65,64.08 50.09,63.52 arc(50.06,63.49) 50.03,63.47 arc(49.93,63.42) 49.82,63.41 40.75,63.41 arc(40.46,63.35) 40.21,63.18 40.11,63.08 arc(39.87,62.92) 39.58,62.86 38.78,62.86 arc(38.52,62.75) 38.41,62.49 38.41,62.32 arc(38.44,62.13) 38.55,61.97 YJ21.C5
FC6_TDN3: length 198.8
  TOP w0.147: v4(165.55,167.39) 165.55,167.34 U1.CA65
  SIG5 w0.112: v4(165.55,167.39) 165.55,167.62 arc(165.51,167.71) 165.42,167.74 165.25,167.74 arc(165.16,167.71) 165.12,167.62 165.12,167.26 arc(165.08,167.07) 164.97,166.9 arc(164.9,166.84) 164.82,166.8 164.82,166.8 arc(164.72,166.76) 164.61,166.75 164.41,166.75 arc(164.12,166.81) 163.87,166.97 163.4,167.45 arc(163.3,167.52) 163.18,167.54 162.84,167.54 162.75,167.45 162.73,167.45
  SIG5 w0.16: 162.73,167.45 161.99,167.45 161.84,167.3 161.07,167.3 160.92,167.45 153.39,167.45 arc(153.18,167.41) 153,167.28 146.19,160.48 arc(145.82,160.23) 145.39,160.14 143.07,160.14 arc(142.86,160.1) 142.68,159.98 85.66,102.96 arc(85.36,102.76) 85,102.69 58.95,102.69 arc(58.74,102.65) 58.55,102.53 45.44,89.41 arc(45.32,89.23) 45.28,89.02 45.28,75.98 45.43,75.83 45.43,75.07 45.28,74.91 45.28,74.15 45.43,74 45.43,73.24 45.28,73.08 45.28,72.4 arc(45.32,72.18) 45.44,72 50.85,66.59 arc(51.1,66.22) 51.19,65.78 51.19,64.52 arc(51.1,64.08) 50.85,63.71 50.51,63.36 50.5,63.35 arc(50.13,63.11) 49.7,63.03 38.35,63.03 arc(38.21,63) 38.08,62.91 38.03,62.86 arc(37.94,62.72) 37.91,62.57 37.91,62.09 arc(37.86,61.86) 37.73,61.67 37.24,61.18 arc(37.14,61.02) 37.1,60.83 YJ21.C3
FC6_TDP0: length 184.5
  TOP w0.147: v4(164.55,169.4) 164.55,169.34 U1.CC66
  SIG5 w0.112: 163.15,170.65 163.18,170.65 163.27,170.75 163.61,170.75 arc(163.68,170.74) 163.74,170.72 arc(163.79,170.69) 163.83,170.65 arc(163.9,170.55) 163.92,170.43 163.92,170.08 arc(164.02,169.85) 164.25,169.75 164.38,169.75 arc(164.44,169.74) 164.5,169.7 arc(164.54,169.65) 164.55,169.58 v4(164.55,169.4)
  SIG5 w0.16: 163.15,170.65 162.42,170.65 162.22,170.46 161.55,170.46 161.35,170.65 150.71,170.65 arc(150.42,170.59) 150.18,170.43 85.94,106.19 arc(85.63,105.99) 85.27,105.92 59.27,105.92 arc(59.06,105.87) 58.88,105.75 42.14,89.01 arc(42.02,88.83) 41.97,88.62 41.97,82.86 arc(41.89,82.43) 41.64,82.05 39.09,79.51 arc(38.97,79.32) 38.93,79.11 38.93,69.86 arc(38.85,69.5) 38.65,69.19 38.13,68.67 arc(37.96,68.42) 37.91,68.13 37.91,66.09 arc(37.86,65.86) 37.73,65.67 37.3,65.23 arc(37.15,65.01) 37.1,64.75 YJ21.C36
FC6_TDP1: length 191.4
  TOP w0.147: v4(169.57,168.29) 169.68,168.29 arc(169.77,168.27) 169.85,168.22 169.92,168.14 arc(170.02,168) U1.CB61
  SIG4 w0.112: 163.46,172.03 163.49,172.03 163.58,171.94 163.95,171.94 arc(164.24,171.88) 164.48,171.72 165.12,171.08 arc(165.3,170.96) 165.52,170.92 168.76,170.92 arc(168.88,170.9) 168.98,170.83 169.07,170.74 arc(169.14,170.64) 169.16,170.52 169.16,168.07 arc(169.2,167.98) 169.29,167.94 169.45,167.94 arc(169.54,167.98) 169.57,168.07 v4(169.57,168.29)
  SIG4 w0.16: 163.46,172.03 151.69,172.03 arc(151.25,171.95) 150.88,171.7 84.63,105.44 arc(84.44,105.32) 84.23,105.28 64.08,105.28 arc(63.72,105.21) 63.42,105.01 55.6,97.19 arc(55.42,97.07) 55.2,97.03 49.98,97.03 arc(49.62,96.95) 49.31,96.75 45.17,92.61 arc(44.97,92.3) 44.89,91.94 44.89,74.55 arc(44.85,74.34) 44.73,74.16 40.26,69.69 arc(40.01,69.32) 39.93,68.88 39.93,67.42 arc(39.76,67.03) 39.37,66.86 38.68,66.86 arc(38.49,66.78) 38.41,66.59 38.41,66.32 arc(38.44,66.13) 38.55,65.97 YJ21.C34
FC6_TDP2: length 192.9
  TOP w0.147: U1.CA63 167.55,167.34 v4(167.55,167.39)
  SIG4 w0.112: v4(167.55,167.39) 167.55,167.62 arc(167.51,167.71) 167.42,167.74 167.25,167.74 arc(167.02,167.84) 166.92,168.07 166.92,168.54 arc(166.91,168.59) 166.89,168.63 166.8,168.71 arc(166.76,168.74) 166.71,168.75 163.53,168.75 arc(163.33,168.77) 163.15,168.85 arc(163.07,168.9) 162.99,168.97 162.54,169.42 arc(162.36,169.54) 162.15,169.58 161.83,169.58 161.74,169.49 161.71,169.49
  SIG4 w0.16: YJ21.C6 39.5,60.79 arc(39.55,61.02) 39.67,61.21 39.92,61.46 40.13,61.67 arc(40.26,61.86) 40.31,62.09 40.31,62.57 arc(40.34,62.72) 40.43,62.86 40.48,62.91 arc(40.61,63) 40.75,63.03 49.82,63.03 arc(50.03,63.06) 50.23,63.14 arc(50.3,63.19) 50.36,63.25 50.92,63.81 arc(51.12,64.11) 51.19,64.47 51.19,64.91 51.4,65.11 51.4,65.72 51.19,65.92 51.19,67.1 arc(51.12,67.46) 50.92,67.76 50.33,68.35 50.33,68.68 49.95,69.06 49.62,69.06 49.18,69.5 arc(49.02,69.74) 48.96,70.04 48.96,86.76 arc(49,86.97) 49.12,87.16 64.54,102.58 arc(64.72,102.7) 64.94,102.74 85.07,102.74 arc(85.43,102.81) 85.73,103.02 151.99,169.27 arc(152.23,169.43) 152.53,169.49 161.71,169.49
FC6_TDP3: length 198.8
  TOP w0.147: U1.CB65 166,167.84 arc(165.68,167.97) v4(165.55,168.29)
  SIG5 w0.112: v4(165.55,168.29) 165.55,168.07 arc(165.51,167.98) 165.42,167.94 165.25,167.94 arc(165.02,167.85) 164.92,167.62 164.92,167.26 arc(164.9,167.14) 164.83,167.04 arc(164.79,167) 164.74,166.98 arc(164.68,166.96) 164.61,166.95 164.41,166.95 arc(164.19,166.99) 164.01,167.11 163.54,167.59 arc(163.37,167.7) 163.18,167.74 162.84,167.74 162.75,167.83 162.73,167.83
  SIG5 w0.16: 162.73,167.83 153.39,167.83 arc(153.04,167.76) 152.73,167.55 145.93,160.75 arc(145.68,160.58) 145.39,160.53 143.07,160.53 arc(142.71,160.45) 142.41,160.25 85.39,103.23 arc(85.21,103.11) 85,103.07 58.95,103.07 arc(58.59,103) 58.28,102.8 45.17,89.68 arc(44.97,89.38) 44.89,89.02 44.89,72.4 arc(44.97,72.04) 45.17,71.73 50.58,66.32 arc(50.75,66.07) 50.81,65.78 50.81,64.52 arc(50.75,64.23) 50.58,63.98 50.23,63.63 arc(50.23,63.63) 50.23,63.62 arc(49.98,63.46) 49.7,63.41 38.35,63.41 arc(38.06,63.35) 37.81,63.18 37.76,63.13 37.71,63.08 arc(37.47,62.92) 37.18,62.86 36.34,62.86 arc(36.1,62.76) 36.01,62.53 36.01,62.32 arc(36.04,62.13) 36.15,61.97 YJ21.C2
FC7_RDN0: length 194.3
  TOP w0.147: v4(177.6,167.39) 177.6,167.3 arc(177.62,167.22) 177.66,167.15 177.92,166.9 arc(177.98,166.86) U1.CA53
  SIG2 w0.112: 163.26,165.03 163.28,165.03 163.38,164.94 166.7,164.94 arc(166.87,164.91) 167.02,164.81 arc(167.12,164.66) 167.16,164.48 167.16,163.21 arc(167.18,163.11) 167.24,163.02 arc(167.33,162.96) 167.43,162.94 170.74,162.94 arc(170.82,162.95) 170.89,163 arc(170.94,163.07) 170.95,163.16 170.95,163.49 arc(170.99,163.66) 171.08,163.79 arc(171.22,163.89) 171.38,163.92 176.68,163.92 arc(176.76,163.93) 176.83,163.98 176.86,164.01 arc(176.93,164.11) 176.95,164.23 176.95,166.54 arc(176.98,166.66) 177.05,166.77 177.14,166.86 arc(177.24,166.93) 177.37,166.95 177.89,166.95 arc(177.98,166.99) 178.02,167.08 178.02,167.27 arc(177.98,167.36) 177.89,167.39 v4(177.6,167.39)
  SIG2 w0.16: YJ21.D14 45.75,53.97 arc(45.64,54.13) 45.61,54.32 45.61,54.56 arc(45.69,54.77) 45.91,54.86 46.72,54.86 arc(47.06,54.93) 47.36,55.13 47.41,55.18 arc(47.5,55.26) 47.6,55.32 arc(47.77,55.38) 47.95,55.41 49.82,55.41 arc(50.03,55.44) 50.23,55.52 arc(50.3,55.57) 50.36,55.63 66.13,71.4 arc(66.3,71.65) 66.36,71.94 66.36,85.63 arc(66.44,86.07) 66.69,86.44 78.72,98.47 arc(79.09,98.72) 79.53,98.8 86.97,98.8 arc(87.12,98.83) 87.24,98.92 153.6,165.27 arc(153.97,165.52) 154.41,165.61 160.15,165.61 arc(160.44,165.55) 160.69,165.38 160.75,165.32 160.81,165.26 arc(160.83,165.24) 160.85,165.23 arc(161.08,165.08) 161.35,165.03 163.26,165.03
FC7_RDN1: length 192.9
  TOP w0.147: U1.CA55 v4(175.5,167.39)
  SIG2 w0.112: v4(175.5,167.39) 175.42,167.39 arc(175.37,167.38) 175.33,167.36 175.25,167.28 arc(175.23,167.24) 175.22,167.19 175.22,167.08 arc(175.12,166.85) 174.89,166.75 174.37,166.75 arc(174.32,166.75) 174.28,166.72 174.19,166.63 arc(174.16,166.59) 174.15,166.54 174.15,165.18 arc(174.12,165.05) 174.05,164.95 173.95,164.84 arc(173.84,164.77) 173.72,164.75 169.53,164.75 arc(169.32,164.79) 169.15,164.9 arc(169.03,165.07) 168.99,165.28 168.99,166.34 arc(168.96,166.49) 168.87,166.63 arc(168.74,166.72) 168.58,166.75 163.38,166.75 163.28,166.66 163.26,166.66
  SIG2 w0.16: YJ21.D24 46.7,56.64 arc(46.77,57) 46.98,57.31 47.34,57.67 arc(47.46,57.86) 47.51,58.08 47.51,58.49 arc(47.55,58.72) 47.68,58.91 arc(47.73,58.95) 47.78,58.98 arc(47.86,59.01) 47.95,59.03 50.14,59.03 arc(50.21,59.03) 50.27,59.03 50.27,59.03 arc(50.64,59.14) 50.95,59.36 51.43,59.85 51.66,59.85 52.15,60.34 52.15,60.56 52.51,60.92 52.74,60.92 53.23,61.42 53.23,61.64 63.22,71.63 arc(63.47,72.01) 63.56,72.46 63.56,93.23 arc(63.62,93.54) 63.8,93.8 70.35,100.35 arc(70.6,100.52) 70.91,100.58 85.91,100.58 arc(86.36,100.67) 86.74,100.93 152.94,167.12 arc(153.2,167.3) 153.51,167.36 160.89,167.36 arc(161.2,167.3) 161.46,167.12 161.58,167 arc(161.96,166.75) 162.41,166.66 163.26,166.66
FC7_RDN2: length 183.8
  TOP w0.147: U1.BW56 175.05,164.87 arc(175.01,165.05) 174.91,165.2 174.83,165.28 arc(174.77,165.33) 174.69,165.34 v4(174.6,165.34)
  SIG3 w0.112: v4(174.6,165.34) 174.9,165.34 arc(174.95,165.33) 175,165.3 175.04,165.26 arc(175.07,165.22) 175.08,165.17 175.08,165.05 arc(175.04,164.96) 174.96,164.92 162.78,164.92 162.68,165.02
  SIG3 w0.16: YJ21.D17 48.15,53.97 arc(48.04,54.13) 48.01,54.32 48.01,54.5 arc(48.11,54.76) 48.37,54.86 49.18,54.86 arc(49.39,54.89) 49.58,54.98 arc(49.65,55.03) 49.71,55.08 49.76,55.13 49.81,55.18 arc(49.84,55.21) 49.86,55.23 49.86,55.23 65.62,70.99 arc(66.17,71.8) 66.36,72.76 66.36,85.58 arc(66.44,86.02) 66.69,86.39 78.77,98.47 arc(79.14,98.72) 79.58,98.8 86.97,98.8 arc(87.12,98.83) 87.24,98.92 153.6,165.27 arc(153.97,165.52) 154.41,165.61 160.94,165.61 arc(161.23,165.55) 161.48,165.38 161.61,165.25 arc(161.86,165.08) 162.15,165.02 162.68,165.02
FC7_RDN3: length 189
  TOP w0.147: U1.BW52 178.55,165.34 v4(178.5,165.34)
  SIG3 w0.112: 163.26,167.03 163.28,167.03 163.38,166.94 177.74,166.94 arc(178.04,166.81) 178.15,166.5 178.15,166.11 arc(178.22,165.72) 178.44,165.4 v4(178.5,165.34)
  SIG3 w0.16: YJ21.D22 48.15,57.97 arc(48.04,58.13) 48.01,58.32 48.01,58.52 arc(48.11,58.76) 48.35,58.86 49.18,58.86 arc(49.38,58.89) 49.57,58.97 arc(49.65,59.03) 49.71,59.08 49.81,59.18 arc(49.84,59.21) 49.86,59.23 49.86,59.23 62.52,71.88 arc(63.01,72.62) 63.18,73.49 63.18,90.09 arc(63.27,90.54) 63.53,90.93 73.22,100.62 arc(73.6,100.87) 74.06,100.96 85.81,100.96 arc(86.11,101.02) 86.37,101.2 123.76,138.59 126.94,141.76 152.57,167.39 arc(152.95,167.65) 153.41,167.74 160.94,167.74 arc(161.39,167.65) 161.78,167.39 161.91,167.26 arc(162.16,167.09) 162.47,167.03 163.26,167.03
FC7_RDP0: length 194.3
  TOP w0.147: U1.CA52 v4(178.5,167.39)
  SIG2 w0.112: v4(178.5,167.39) 178.42,167.39 arc(178.37,167.38) 178.33,167.36 178.25,167.28 arc(178.23,167.24) 178.22,167.19 178.22,167.08 arc(178.12,166.85) 177.89,166.75 177.37,166.75 arc(177.32,166.75) 177.28,166.72 177.19,166.63 arc(177.16,166.59) 177.15,166.54 177.15,164.23 arc(177.11,164.04) 177,163.87 176.97,163.84 arc(176.84,163.75) 176.68,163.72 171.38,163.72 arc(171.29,163.7) 171.22,163.65 arc(171.17,163.58) 171.15,163.49 171.15,163.16 arc(171.12,163) 171.03,162.86 arc(170.9,162.77) 170.74,162.74 167.43,162.74 arc(167.25,162.78) 167.1,162.88 arc(167,163.03) 166.96,163.21 166.96,164.48 arc(166.94,164.58) 166.88,164.67 arc(166.8,164.72) 166.7,164.75 163.38,164.75 163.28,164.65 163.26,164.65
  SIG2 w0.16: YJ21.D15 46.7,52.81 arc(46.74,53.02) 46.86,53.19 47.34,53.67 arc(47.46,53.86) 47.51,54.08 47.51,54.57 arc(47.51,54.62) 47.52,54.66 arc(47.56,54.77) 47.63,54.86 47.68,54.91 arc(47.73,54.95) 47.78,54.98 arc(47.86,55.01) 47.95,55.03 49.82,55.03 arc(50.14,55.07) 50.43,55.2 arc(50.54,55.27) 50.63,55.36 51.04,55.77 51.45,55.77 51.76,56.08 51.76,56.49 66.4,71.13 arc(66.65,71.5) 66.74,71.94 66.74,85.63 arc(66.8,85.92) 66.96,86.17 78.99,98.2 arc(79.24,98.36) 79.53,98.42 86.97,98.42 arc(87.26,98.48) 87.51,98.65 153.87,165 arc(154.11,165.17) 154.41,165.22 160.15,165.22 arc(160.29,165.2) 160.42,165.11 160.54,164.99 arc(160.57,164.96) 160.59,164.94 160.59,164.94 arc(160.95,164.73) 161.35,164.65 163.26,164.65
FC7_RDP1: length 192.9
  TOP w0.147: v4(174.6,167.39) 174.6,167.32 arc(174.61,167.25) 174.65,167.19 174.96,166.88 arc(175,166.85) U1.CA56
  SIG2 w0.112: v4(174.6,167.39) 174.89,167.39 arc(174.98,167.36) 175.02,167.27 175.02,167.08 arc(174.98,166.99) 174.89,166.95 174.37,166.95 arc(174.24,166.93) 174.14,166.86 174.05,166.77 arc(173.98,166.66) 173.95,166.54 173.95,165.18 arc(173.94,165.13) 173.92,165.09 173.81,164.98 arc(173.77,164.95) 173.72,164.94 169.53,164.94 arc(169.4,164.97) 169.29,165.04 arc(169.21,165.15) 169.19,165.28 169.19,166.34 arc(169.14,166.57) 169.01,166.77 169.01,166.77 arc(168.81,166.9) 168.58,166.95 163.38,166.95 163.28,167.04 163.26,167.04
  SIG2 w0.16: 163.26,167.04 162.41,167.04 arc(162.11,167.1) 161.85,167.27 161.73,167.39 arc(161.34,167.65) 160.89,167.74 153.51,167.74 arc(153.05,167.65) 152.67,167.39 86.47,101.2 arc(86.22,101.02) 85.91,100.96 70.91,100.96 arc(70.46,100.87) 70.08,100.62 63.53,94.07 arc(63.27,93.69) 63.18,93.23 63.18,72.46 arc(63.12,72.16) 62.95,71.9 50.68,59.63 arc(50.47,59.48) 50.23,59.41 arc(50.18,59.41) 50.14,59.41 47.95,59.41 arc(47.77,59.38) 47.6,59.32 arc(47.5,59.26) 47.41,59.18 47.31,59.08 arc(47.24,59.02) 47.17,58.97 arc(46.98,58.89) 46.78,58.86 45.95,58.86 arc(45.71,58.76) 45.61,58.52 45.61,58.32 arc(45.64,58.13) 45.75,57.97 YJ21.D25
FC7_RDP2: length 183.8
  TOP w0.147: v4(175.5,165.34) 175.55,165.34 U1.BW55
  SIG3 w0.112: v4(175.5,165.34) 175.31,165.16 arc(175.28,165.11) 175.27,165.06 175.27,165.05 arc(175.18,164.82) 174.96,164.73 162.76,164.73 162.68,164.64
  SIG3 w0.16: 162.68,164.64 162.15,164.64 arc(161.71,164.73) 161.34,164.98 161.21,165.11 arc(161.08,165.2) 160.94,165.22 154.4,165.22 arc(154.11,165.17) 153.87,165 87.51,98.65 arc(87.26,98.48) 86.97,98.42 79.58,98.42 arc(79.28,98.36) 79.04,98.2 66.96,86.12 arc(66.8,85.88) 66.74,85.58 66.74,72.76 arc(66.52,71.66) 65.89,70.72 52.39,57.22 52.39,56.89 52.01,56.5 51.68,56.5 51.32,56.14 51.32,55.81 50.93,55.42 50.6,55.42 50.11,54.94 50.1,54.93 arc(49.96,54.71) 49.91,54.45 49.91,54.08 arc(49.86,53.86) 49.74,53.67 49.3,53.23 arc(49.15,53.01) 49.1,52.75 YJ21.D18
FC7_RDP3: length 189
  TOP w0.147: v4(177.6,165.34) 177.69,165.34 arc(177.77,165.33) 177.83,165.28 177.91,165.2 arc(178.01,165.05) 178.05,164.87 U1.BW53
  SIG3 w0.112: v4(177.6,165.34) 177.91,165.34 arc(177.97,165.36) 178.01,165.4 178.05,165.43 arc(178.08,165.5) 178.07,165.58 arc(177.98,165.84) 177.95,166.11 177.95,166.53 arc(177.89,166.68) 177.74,166.74 163.38,166.74 163.28,166.65 163.26,166.65
  SIG3 w0.16: 163.26,166.65 162.47,166.65 arc(162.02,166.74) 161.64,166.99 161.51,167.12 arc(161.25,167.3) 160.94,167.36 153.41,167.36 arc(153.1,167.3) 152.84,167.12 126.94,141.22 123.76,138.05 86.64,100.93 arc(86.26,100.67) 85.81,100.58 74.06,100.58 arc(73.75,100.52) 73.49,100.35 63.8,90.66 arc(63.62,90.4) 63.56,90.09 63.56,73.49 arc(63.36,72.47) 62.79,71.61 53.32,62.14 53.32,61.84 52.91,61.43 52.6,61.43 52.05,60.87 52.05,60.54 51.66,60.16 51.33,60.16 50.21,59.03 50.12,58.94 arc(49.96,58.71) 49.91,58.43 49.91,58.08 arc(49.86,57.86) 49.74,57.67 49.31,57.25 arc(49.16,57.01) 49.1,56.73 YJ21.D21
FC7_TDN0: length 197.9
  TOP w0.147: v4(168.55,166.29) 168.66,166.29 arc(168.77,166.27) 168.86,166.21 168.92,166.14 arc(169.02,166) U1.BY62
  SIG4 w0.112: v4(168.55,166.29) 168.55,166.07 arc(168.51,165.98) 168.42,165.94 168.25,165.94 arc(168.16,165.98) 168.12,166.07 168.12,166.54 arc(168.09,166.66) 168.02,166.77 167.94,166.85 arc(167.84,166.92) 167.71,166.95 163.38,166.95 163.28,167.04 163.26,167.04
  SIG4 w0.16: YJ21.D37 36.15,57.97 arc(36.04,58.13) 36.01,58.32 36.01,58.48 arc(36.12,58.75) 36.39,58.86 37.18,58.86 arc(37.47,58.92) 37.71,59.08 37.81,59.18 arc(38.06,59.35) 38.35,59.41 49.88,59.41 arc(49.97,59.42) 50.06,59.45 arc(50.11,59.48) 50.15,59.52 53.49,62.86 arc(53.62,63.04) 53.66,63.26 53.66,67.55 arc(53.62,67.77) 53.49,67.95 53.19,68.26 53.19,68.26 52.47,68.97 51.07,70.37 arc(50.82,70.74) 50.74,71.18 50.74,85.51 arc(50.82,85.95) 51.07,86.32 65.44,100.69 arc(65.75,100.89) 66.11,100.96 85.93,100.96 arc(86.15,101.01) 86.33,101.13 152.61,167.4 arc(152.98,167.65) 153.41,167.74 161.06,167.74 arc(161.5,167.65) 161.87,167.4 162.08,167.2 arc(162.26,167.08) 162.47,167.04 163.26,167.04
FC7_TDN1: length 198.7
  TOP w0.147: U1.BW64 166.57,165.32 v4(166.57,165.39)
  SIG5 w0.112: v4(166.57,165.39) 166.57,165.62 arc(166.54,165.71) 166.45,165.74 166.29,165.74 arc(166.2,165.71) 166.16,165.62 166.16,163.14 arc(166.14,163.02) 166.07,162.91 166,162.85 arc(165.89,162.78) 165.77,162.75 163.38,162.75 163.28,162.66 163.26,162.66
  SIG5 w0.16: YJ21.D6 39.5,52.83 arc(39.54,53.02) 39.64,53.17 40.14,53.67 arc(40.26,53.86) 40.31,54.08 40.31,54.57 arc(40.34,54.72) 40.43,54.86 40.46,54.89 40.48,54.91 arc(40.61,55) 40.75,55.03 50.2,55.03 arc(50.22,55.03) 50.24,55.03 arc(50.66,55.12) 51.01,55.36 53.17,57.52 53.38,57.52 53.92,58.06 53.92,58.27 55.01,59.36 arc(55.26,59.73) 55.35,60.17 55.35,60.93 55.5,61.08 55.5,61.85 55.35,62 55.35,62.76 55.5,62.91 55.5,63.67 55.35,63.83 55.35,67.46 arc(55.26,67.9) 55.01,68.27 51.23,72.05 arc(51.15,72.18) 51.12,72.32 51.12,85.69 arc(51.15,85.84) 51.23,85.96 63.58,98.31 arc(63.7,98.39) 63.85,98.42 86.81,98.42 arc(87.25,98.51) 87.62,98.76 143.69,154.83 arc(143.81,154.91) 143.96,154.94 146.33,154.94 arc(146.76,155.02) 147.13,155.27 154.41,162.55 arc(154.53,162.63) 154.68,162.66 163.26,162.66
FC7_TDN2: length 193.7
  TOP w0.147: U1.BY66 165,165.84 arc(164.68,165.97) v4(164.55,166.29)
  SIG5 w0.112: v4(164.55,166.29) 164.55,166.07 arc(164.51,165.98) 164.42,165.94 164.25,165.94 arc(164.02,165.85) 163.92,165.62 163.92,165.26 arc(163.9,165.14) 163.83,165.04 arc(163.79,165) 163.74,164.98 arc(163.68,164.96) 163.61,164.95 163.3,164.95 163.2,165.04 163.18,165.04
  SIG5 w0.16: YJ21.D34 38.55,57.97 arc(38.44,58.13) 38.41,58.32 38.41,58.54 arc(38.5,58.77) 38.73,58.86 39.58,58.86 arc(39.87,58.92) 40.11,59.08 40.21,59.18 arc(40.46,59.35) 40.75,59.41 49.89,59.41 arc(50.06,59.43) 50.23,59.49 arc(50.33,59.55) 50.43,59.63 52.66,61.87 arc(52.83,62.11) 52.89,62.41 52.89,66.62 arc(52.83,66.91) 52.66,67.16 48.85,70.97 arc(48.65,71.27) 48.58,71.63 48.58,86.76 arc(48.65,87.12) 48.85,87.43 62.11,100.69 arc(62.42,100.89) 62.78,100.96 85.91,100.96 arc(86.12,101.01) 86.3,101.13 142.38,157.2 arc(142.68,157.41) 143.04,157.48 145.49,157.48 arc(145.78,157.54) 146.03,157.7 153.68,165.36 arc(153.99,165.56) 154.35,165.63 160.94,165.63 arc(161.3,165.56) 161.6,165.36 161.7,165.26 arc(161.94,165.1) 162.23,165.04 163.18,165.04
FC7_TDN3: length 195.1
  TOP w0.147: U1.BU61 169.55,163.34 v4(169.55,163.39)
  SIG4 w0.112: v4(169.55,163.39) 169.55,163.61 arc(169.51,163.7) 169.42,163.73 169.25,163.73 arc(169.02,163.83) 168.92,164.06 168.92,164.53 arc(168.91,164.58) 168.89,164.62 168.8,164.7 arc(168.76,164.73) 168.71,164.74 163.33,164.74 163.23,164.65 163.21,164.65
  SIG4 w0.16: 163.21,164.65 161.19,164.65 arc(161.01,164.67) 160.85,164.73 arc(160.74,164.79) 160.65,164.87 160.52,165 arc(160.27,165.17) 159.98,165.22 154.38,165.22 arc(154.09,165.17) 153.84,165 87.54,98.7 arc(87.23,98.49) 86.87,98.42 72.26,98.42 arc(71.62,98.29) 71.07,97.93 64.5,91.35 arc(63.81,90.32) 63.56,89.1 63.56,71.28 arc(63.49,70.92) 63.29,70.61 58.2,65.52 arc(58.03,65.28) 57.98,64.99 57.98,62.87 arc(57.9,62.51) 57.7,62.21 54.09,58.6 54.09,58.42 53.76,58.09 53.58,58.09 53.25,57.76 53.25,57.58 52.93,57.25 52.75,57.25 52.42,56.92 52.42,56.74 52.09,56.41 51.91,56.41 51.58,56.09 51.58,55.91 51.25,55.58 51.07,55.58 50.74,55.25 arc(50.51,55.09) 50.23,55.03 arc(50.22,55.03) 50.2,55.03 38.35,55.03 arc(38.21,55) 38.08,54.91 38.03,54.86 arc(37.94,54.72) 37.91,54.57 37.91,54.12 37.91,54.08 arc(37.86,53.86) 37.74,53.67 37.36,53.29 arc(37.17,53.01) 37.1,52.67 YJ21.D3
FC7_TDP0: length 197.9
  TOP w0.147: U1.BW62 168.55,165.34 v4(168.55,165.39)
  SIG4 w0.112: 163.26,166.66 163.28,166.66 163.38,166.75 167.71,166.75 arc(167.76,166.74) 167.8,166.71 167.89,166.63 arc(167.91,166.59) 167.92,166.54 167.92,166.07 arc(168.02,165.84) 168.25,165.74 168.42,165.74 arc(168.51,165.71) 168.55,165.62 v4(168.55,165.39)
  SIG4 w0.16: 163.26,166.66 162.47,166.66 arc(162.11,166.73) 161.81,166.93 161.6,167.13 arc(161.36,167.3) 161.06,167.36 153.41,167.36 arc(153.12,167.3) 152.88,167.13 86.6,100.86 arc(86.29,100.65) 85.93,100.58 66.11,100.58 arc(65.89,100.54) 65.71,100.42 51.34,86.05 arc(51.18,85.8) 51.12,85.51 51.12,71.18 arc(51.18,70.89) 51.34,70.64 53.76,68.22 arc(53.97,67.91) 54.04,67.55 54.04,63.26 arc(53.97,62.9) 53.76,62.59 52.58,61.4 52.58,61.12 52.14,60.69 51.86,60.69 51.5,60.33 51.5,60.02 51.09,59.61 50.78,59.61 50.42,59.25 arc(50.33,59.17) 50.23,59.11 arc(50.06,59.05) 49.88,59.03 38.35,59.03 arc(38.21,59) 38.08,58.91 38.03,58.86 arc(37.94,58.72) 37.91,58.57 37.91,58.09 arc(37.86,57.86) 37.73,57.67 37.25,57.19 arc(37.14,57.02) 37.1,56.82 YJ21.D36
FC7_TDP1: length 198.7
  TOP w0.147: U1.BY64 167.02,165.84 arc(166.71,165.97) v4(166.57,166.29)
  SIG5 w0.112: v4(166.57,166.29) 166.57,166.07 arc(166.54,165.98) 166.45,165.94 166.29,165.94 arc(166.06,165.85) 165.96,165.62 165.96,163.14 arc(165.95,163.09) 165.93,163.05 165.86,162.99 arc(165.82,162.96) 165.77,162.95 163.38,162.95 163.28,163.04 163.26,163.04
  SIG5 w0.16: YJ21.D5 38.55,53.97 arc(38.44,54.13) 38.41,54.32 38.41,54.53 arc(38.5,54.76) 38.74,54.86 39.58,54.86 arc(39.87,54.92) 40.11,55.08 40.16,55.13 40.21,55.18 arc(40.46,55.35) 40.75,55.41 50.2,55.41 arc(50.22,55.41) 50.23,55.41 arc(50.51,55.47) 50.74,55.63 54.74,59.63 arc(54.91,59.88) 54.97,60.17 54.97,67.46 arc(54.91,67.75) 54.74,68 50.96,71.78 arc(50.79,72.03) 50.74,72.32 50.74,85.69 arc(50.79,85.98) 50.96,86.23 63.31,98.58 arc(63.56,98.75) 63.85,98.8 86.81,98.8 arc(87.11,98.86) 87.35,99.03 143.42,155.1 arc(143.67,155.26) 143.96,155.32 146.33,155.32 arc(146.62,155.38) 146.86,155.54 154.14,162.82 arc(154.39,162.98) 154.68,163.04 163.26,163.04
FC7_TDP2: length 193.7
  TOP w0.147: v4(164.55,165.39) 164.55,165.34 U1.BW66
  SIG5 w0.112: v4(164.55,165.39) 164.55,165.6 arc(164.54,165.66) 164.51,165.7 arc(164.46,165.73) 164.41,165.74 164.25,165.74 arc(164.16,165.71) 164.12,165.62 164.12,165.26 arc(164.08,165.07) 163.97,164.9 arc(163.9,164.84) 163.82,164.8 163.82,164.8 arc(163.72,164.76) 163.61,164.75 163.3,164.75 163.2,164.66 163.18,164.66
  SIG5 w0.16: YJ21.D33 39.5,56.81 arc(39.54,57.02) 39.66,57.19 40.13,57.67 arc(40.26,57.86) 40.31,58.09 40.31,58.57 arc(40.34,58.72) 40.43,58.86 40.48,58.91 arc(40.61,59) 40.75,59.03 49.89,59.03 arc(50.15,59.06) 50.4,59.15 arc(50.56,59.24) 50.69,59.36 52.93,61.6 arc(53.18,61.97) 53.27,62.41 53.27,66.62 arc(53.18,67.06) 52.93,67.43 49.12,71.24 arc(49,71.42) 48.96,71.63 48.96,72.32 49.03,72.4 49.03,73.31 48.96,73.39 48.96,74.15 49.03,74.23 49.03,75.14 48.96,75.22 48.96,77.77 49.03,77.85 49.03,78.61 48.96,78.69 48.96,79.45 49.03,79.52 49.03,80.29 48.96,80.36 48.96,86.76 arc(49,86.97) 49.12,87.16 62.38,100.42 arc(62.57,100.54) 62.78,100.58 85.91,100.58 arc(86.27,100.65) 86.57,100.86 142.65,156.93 arc(142.83,157.05) 143.04,157.1 145.49,157.1 arc(145.93,157.18) 146.3,157.43 153.95,165.09 arc(154.13,165.21) 154.35,165.25 159.18,165.25 159.34,165.1 160.1,165.1 160.25,165.25 160.94,165.25 arc(161.15,165.21) 161.33,165.09 161.43,164.99 arc(161.8,164.75) 162.23,164.66 163.18,164.66
FC7_TDP3: length 195.1
  TOP w0.147: v4(169.55,164.28) 169.67,164.28 arc(169.78,164.26) 169.88,164.2 169.92,164.15 arc(170.02,164.01) U1.BV61
  SIG4 w0.112: 163.21,165.03 163.23,165.03 163.33,164.94 168.71,164.94 arc(168.84,164.91) 168.94,164.84 169.02,164.76 arc(169.09,164.65) 169.12,164.53 169.12,164.06 arc(169.16,163.97) 169.25,163.93 169.42,163.93 arc(169.51,163.97) 169.55,164.06 v4(169.55,164.28)
  SIG4 w0.16: YJ21.D2 36.15,53.97 arc(36.04,54.13) 36.01,54.32 36.01,54.59 arc(36.09,54.78) 36.28,54.86 37.18,54.86 arc(37.47,54.92) 37.71,55.08 37.81,55.18 arc(38.06,55.35) 38.35,55.41 50.2,55.41 50.22,55.41 arc(50.36,55.44) 50.47,55.52 57.43,62.48 arc(57.55,62.66) 57.59,62.87 57.59,64.99 arc(57.68,65.42) 57.93,65.79 63.02,70.88 arc(63.14,71.06) 63.18,71.28 63.18,89.1 arc(63.45,90.47) 64.23,91.62 70.8,98.2 arc(71.47,98.65) 72.26,98.8 86.87,98.8 arc(87.09,98.85) 87.27,98.97 153.57,165.27 arc(153.94,165.52) 154.38,165.61 159.98,165.61 arc(160.41,165.52) 160.79,165.27 160.92,165.14 arc(160.96,165.1) 161.02,165.07 arc(161.1,165.04) 161.19,165.03 163.21,165.03
FC8_9_PVDD0P8: length 5.4
  TOP w0.229: U1.BF49 v1(181.55,152.34) ; U1.BD49 v1(181.55,150.34)
  TOP w0.381: 157.77,158.85 C277.1 ; C277.1 156.55,158.85 ; C277.1 157.16,159.51
  BOTTOM w0.13: v1(157.67,160.02) v2(157.67,160.78)
  BOTTOM w0.381: v1(181.55,150.34) 181.07,150.83 C3321.1 ; C278.1 181.07,152.83 v1(181.55,152.34)
  vias: v1(156.65,160.02)
FC8_RDN0: length 187
  TOP w0.147: v4(177.55,163.29) 177.55,163.21 arc(177.56,163.13) 177.61,163.06 177.69,162.98 arc(177.84,162.88) 178.02,162.84 U1.BU53
  SIG8 w0.112: v4(177.55,163.29) 177.55,163.04 arc(177.52,162.97) 177.45,162.94 177.22,162.94 arc(177.01,162.85) 176.92,162.64 176.92,161.14 arc(176.91,161.09) 176.89,161.05 176.8,160.96 arc(176.76,160.93) 176.71,160.92 163.28,160.92 163.19,161.02 163.17,161.02
  SIG8 w0.16: 163.17,161.02 161.5,161.02 arc(161.24,161.07) 161.02,161.22 arc(160.8,161.36) 160.54,161.41 153.23,161.41 arc(152.78,161.32) 152.4,161.07 118.89,127.56 arc(118.64,127.19) 118.55,126.75 118.55,124.66 arc(118.49,124.36) 118.32,124.1 91.1,96.88 arc(90.84,96.71) 90.54,96.64 69.74,96.64 arc(69.29,96.55) 68.9,96.3 64.29,91.69 arc(64.03,91.3) 63.94,90.85 63.94,73.41 arc(63.92,73.27) 63.83,73.14 59.71,69.02 arc(59.45,68.64) 59.36,68.19 59.36,60.98 arc(59.45,60.53) 59.71,60.15 60.5,59.36 arc(60.88,59.1) 61.33,59.01 62.99,59.01 arc(63.14,58.98) 63.26,58.9 63.35,58.82 arc(63.42,58.73) 63.47,58.63 arc(63.5,58.53) 63.51,58.42 63.51,58.15 arc(63.57,57.85) 63.74,57.59 64,57.34 arc(64.22,57) 64.3,56.61 YJ24.D21
FC8_RDN1: length 192.3
  TOP w0.147: v4(173.55,162.39) 173.55,162.34 U1.BT57
  SIG9 w0.112: 163.28,164.64 163.38,164.73 172.62,164.73 arc(172.74,164.71) 172.84,164.64 arc(172.9,164.54) 172.93,164.43 172.93,163.04 arc(173.01,162.83) 173.22,162.74 173.42,162.74 arc(173.47,162.73) 173.51,162.71 173.51,162.7 arc(173.54,162.66) 173.55,162.61 v4(173.55,162.39)
  SIG9 w0.16: 163.28,164.64 162.22,164.64 arc(162.08,164.61) 161.95,164.52 160.88,163.45 arc(160.51,163.2) 160.07,163.12 152.14,163.12 arc(151.99,163.09) 151.87,163 123.76,134.9 116.89,128.02 arc(116.81,127.9) 116.78,127.75 116.78,125.41 arc(116.69,124.97) 116.44,124.6 88.44,96.6 arc(88.07,96.35) 87.63,96.26 67.07,96.26 arc(66.44,96.14) 65.91,95.78 62.28,92.15 arc(62.2,92.03) 62.17,91.88 62.17,75.32 arc(62.08,74.89) 61.83,74.52 60.09,72.78 59.07,71.75 58.35,71.04 arc(58.27,70.91) 58.24,70.77 58.24,61.01 arc(58.3,60.72) 58.46,60.47 58.8,60.13 59.12,60.13 59.44,59.81 59.44,59.5 59.78,59.15 60.11,59.15 60.5,58.77 60.5,58.44 60.86,58.08 61.19,58.08 61.58,57.69 61.58,57.36 61.93,57 62.27,57 62.65,56.61 62.65,56.28 63.32,55.62 arc(63.56,55.45) 63.85,55.39 65.39,55.39 arc(65.68,55.34) 65.93,55.17 66.02,55.08 arc(66.26,54.92) 66.56,54.86 67.46,54.86 arc(67.7,54.76) 67.8,54.52 67.8,54.34 arc(67.76,54.14) 67.65,53.97 YJ24.D14
FC8_RDN2: length 192.6
  TOP w0.147: v4(175.55,163.29) 175.55,163.21 arc(175.56,163.13) 175.61,163.06 175.69,162.98 arc(175.84,162.88) 176.02,162.84 U1.BU55
  SIG8 w0.112: v4(175.55,163.29) 175.55,163.04 arc(175.52,162.97) 175.45,162.94 175.22,162.94 arc(175.15,162.97) 175.12,163.04 175.12,163.5 arc(175.09,163.63) 175.02,163.73 174.93,163.82 arc(174.83,163.89) 174.71,163.92 171.42,163.92 arc(171.24,163.88) 171.09,163.78 arc(170.99,163.63) 170.95,163.45 170.95,163.24 arc(170.93,163.13) 170.87,163.03 arc(170.77,162.97) 170.66,162.95 163.39,162.95 163.29,163.04 163.27,163.04
  SIG8 w0.16: YJ24.D18 64.3,52.68 arc(64.23,53.01) 64.05,53.29 63.71,53.63 arc(63.56,53.84) 63.51,54.1 63.51,54.48 arc(63.51,54.54) 63.49,54.61 arc(63.45,54.7) 63.39,54.77 63.35,54.81 63.35,54.82 63.26,54.9 arc(63.14,54.98) 62.99,55.01 61.99,55.01 arc(61.54,55.1) 61.15,55.36 57.6,58.91 arc(57.34,59.3) 57.25,59.75 57.25,69.98 arc(57.34,70.44) 57.6,70.82 61.63,74.85 arc(61.8,75.11) 61.86,75.41 61.86,91.79 arc(61.95,92.24) 62.21,92.62 68.04,98.46 arc(68.43,98.71) 68.88,98.8 89.74,98.8 arc(90.05,98.86) 90.31,99.04 116.16,124.89 arc(116.33,125.15) 116.4,125.45 116.4,127.61 arc(116.49,128.06) 116.74,128.44 151.47,163.17 arc(151.85,163.42) 152.3,163.51 161.74,163.51 arc(162.03,163.45) 162.27,163.29 162.29,163.28 arc(162.55,163.1) 162.86,163.04 163.27,163.04
FC8_RDN3: length 179.9
  TOP w0.147: v4(171.57,162.39) 171.55,162.37 171.55,162.34 U1.BT59
  SIG9 w0.112: 162.85,162.66 162.9,162.66 arc(162.95,162.67) 162.99,162.69 163.01,162.72 arc(163.05,162.74) 163.09,162.75 170.72,162.75 arc(171.18,162.66) v4(171.57,162.39)
  SIG9 w0.16: YJ24.D25 67.62,57.94 arc(67.75,58.13) 67.79,58.35 67.79,58.53 arc(67.7,58.77) 67.46,58.86 66.61,58.86 arc(66.27,58.93) 65.98,59.12 65.93,59.17 arc(65.68,59.34) 65.39,59.39 63.92,59.39 arc(63.63,59.45) 63.38,59.62 62.15,60.85 62.15,61.19 61.76,61.57 61.43,61.57 60.42,62.58 arc(60.33,62.7) 60.3,62.85 60.3,63.36 60.53,63.59 60.53,64.15 60.3,64.37 60.3,64.88 60.53,65.11 60.53,65.67 60.3,65.9 60.3,66.41 60.53,66.63 60.53,67.19 60.3,67.42 60.3,68.77 arc(60.33,68.91) 60.42,69.04 64.1,72.72 arc(64.27,72.97) 64.33,73.26 64.33,90.48 arc(64.45,91.1) 64.8,91.63 66.8,93.63 arc(67.33,93.98) 67.95,94.1 88.57,94.1 arc(88.86,94.16) 89.11,94.33 103.91,109.13 118.71,123.93 arc(118.88,124.18) 118.94,124.47 118.94,126.76 arc(118.94,126.86) 118.96,126.95 arc(119.04,127.14) 119.16,127.3 152.67,160.81 arc(152.92,160.98) 153.21,161.03 160.07,161.03 arc(160.6,161.14) 161.05,161.44 162.21,162.6 arc(162.27,162.64) 162.35,162.66 162.85,162.66
FC8_RDP0: length 187
  TOP w0.147: U1.BT53 177.55,162.34 v4(177.55,162.39)
  SIG8 w0.112: 163.17,160.64 163.19,160.64 163.28,160.73 176.71,160.73 arc(176.83,160.75) 176.94,160.82 177.02,160.91 arc(177.09,161.01) 177.12,161.14 177.12,162.64 arc(177.15,162.71) 177.22,162.74 177.45,162.74 arc(177.52,162.71) 177.55,162.64 v4(177.55,162.39)
  SIG8 w0.16: YJ24.D22 65.25,57.97 arc(65.38,58.17) 65.43,58.39 65.43,58.43 arc(65.4,58.57) 65.32,58.69 arc(65.13,58.82) 64.9,58.86 64.02,58.86 arc(63.99,58.86) 63.95,58.87 arc(63.82,58.91) 63.71,58.99 63.53,59.17 arc(63.28,59.34) 62.99,59.39 61.33,59.39 arc(61.03,59.46) 60.77,59.63 59.98,60.42 arc(59.8,60.68) 59.74,60.98 59.74,68.19 arc(59.8,68.49) 59.98,68.75 64.1,72.88 arc(64.27,73.12) 64.33,73.41 64.33,74.06 64.58,74.32 64.58,74.83 64.33,75.08 64.33,75.59 64.58,75.84 64.58,76.35 64.33,76.6 64.33,77.11 64.58,77.37 64.58,77.87 64.33,78.13 64.33,87.3 64.48,87.45 64.48,88.16 64.33,88.31 64.33,90.85 arc(64.39,91.16) 64.56,91.42 69.17,96.03 arc(69.43,96.2) 69.74,96.26 90.54,96.26 arc(90.99,96.35) 91.37,96.61 118.59,123.83 arc(118.85,124.21) 118.94,124.66 118.94,126.75 arc(118.99,127.04) 119.16,127.29 152.67,160.8 arc(152.93,160.97) 153.23,161.03 160.54,161.03 arc(160.65,161.01) 160.75,160.95 arc(161.09,160.72) 161.5,160.64 163.17,160.64
FC8_RDP1: length 192.3
  TOP w0.147: U1.BU57 173.98,162.84 arc(173.81,162.87) 173.67,162.97 173.62,163.02 arc(173.57,163.1) 173.55,163.19 v4(173.55,163.29)
  SIG9 w0.112: 163.28,165.02 163.37,164.93 172.62,164.93 arc(172.81,164.89) 172.98,164.78 arc(173.09,164.62) 173.12,164.43 173.12,163.04 arc(173.15,162.97) 173.22,162.94 173.42,162.94 arc(173.46,162.95) 173.49,162.97 173.52,162.99 arc(173.54,163.03) 173.55,163.07 v4(173.55,163.29)
  SIG9 w0.16: 163.28,165.02 162.22,165.02 arc(161.93,164.96) 161.68,164.79 160.61,163.72 arc(160.36,163.56) 160.07,163.5 152.14,163.5 arc(151.85,163.44) 151.6,163.27 126.94,138.61 116.62,128.29 arc(116.45,128.05) 116.4,127.75 116.4,125.41 arc(116.34,125.12) 116.17,124.87 88.17,96.87 arc(87.92,96.7) 87.63,96.64 67.07,96.64 arc(66.29,96.49) 65.64,96.05 62.01,92.42 arc(61.84,92.18) 61.79,91.88 61.79,75.32 arc(61.73,75.03) 61.56,74.79 58.95,72.18 58.08,71.31 arc(57.92,71.06) 57.86,70.77 57.86,61.01 arc(57.95,60.57) 58.19,60.2 63.05,55.35 arc(63.42,55.1) 63.85,55.01 65.39,55.01 arc(65.54,54.98) 65.66,54.9 65.75,54.82 65.79,54.77 arc(65.86,54.69) 65.9,54.58 arc(65.91,54.53) 65.91,54.48 65.91,54.16 arc(65.97,53.85) 66.15,53.58 66.53,53.2 arc(66.66,53.02) 66.7,52.8 YJ24.D15
FC8_RDP2: length 192.6
  TOP w0.147: U1.BT55 175.55,162.34 v4(175.55,162.39)
  SIG8 w0.112: 163.27,162.66 163.29,162.66 163.39,162.75 170.66,162.75 arc(170.85,162.79) 171.01,162.89 arc(171.11,163.05) 171.15,163.24 171.15,163.45 arc(171.17,163.55) 171.23,163.64 arc(171.32,163.7) 171.42,163.72 174.7,163.72 arc(174.75,163.71) 174.79,163.68 174.89,163.59 arc(174.91,163.55) 174.92,163.5 174.92,163.04 arc(175.01,162.83) 175.22,162.74 175.45,162.74 arc(175.52,162.71) 175.55,162.64 v4(175.55,162.39)
  SIG8 w0.16: YJ24.D17 65.25,53.97 arc(65.36,54.14) 65.4,54.34 65.4,54.45 arc(65.37,54.61) 65.28,54.75 65.28,54.75 arc(65.15,54.83) 65,54.86 64.02,54.86 arc(63.85,54.89) 63.71,54.99 63.53,55.17 arc(63.28,55.34) 62.99,55.39 61.99,55.39 arc(61.68,55.46) 61.42,55.63 57.87,59.18 arc(57.7,59.44) 57.64,59.75 57.64,69.98 arc(57.7,70.29) 57.87,70.55 58.79,71.47 59.15,71.47 59.51,71.83 59.51,72.19 59.87,72.55 60.23,72.55 60.59,72.91 60.59,73.26 61.9,74.58 arc(62.15,74.96) 62.24,75.41 62.24,76.07 62.45,76.27 62.45,76.88 62.24,77.09 62.24,77.59 62.45,77.8 62.45,78.4 62.24,78.61 62.24,91.79 arc(62.3,92.09) 62.48,92.35 68.31,98.19 arc(68.57,98.36) 68.88,98.42 89.74,98.42 arc(90.2,98.51) 90.58,98.77 116.43,124.62 arc(116.69,125) 116.78,125.45 116.78,127.61 arc(116.84,127.91) 117.01,128.17 151.74,162.9 arc(151.99,163.07) 152.3,163.13 161.74,163.13 arc(161.88,163.1) 162,163.02 162.02,163.01 arc(162.4,162.75) 162.86,162.66 163.27,162.66
FC8_RDP3: length 179.9
  TOP w0.147: U1.BU59 171.92,162.84 arc(171.81,162.86) 171.71,162.93 171.69,162.95 arc(171.6,163.08) 171.57,163.22 v4(171.57,163.29)
  SIG9 w0.112: 162.85,163.04 162.9,163.04 arc(162.95,163.03) 162.99,163 163,162.99 arc(163.05,162.96) 163.11,162.95 170.74,162.95 arc(171.19,163.03) v4(171.57,163.29)
  SIG9 w0.16: 162.85,163.04 162.35,163.04 arc(162.12,162.99) 161.94,162.87 160.78,161.71 arc(160.6,161.56) 160.39,161.47 arc(160.23,161.43) 160.07,161.41 153.21,161.41 arc(152.77,161.33) 152.4,161.08 118.89,127.57 arc(118.71,127.33) 118.59,127.05 arc(118.56,127) 118.55,126.95 118.55,124.47 arc(118.53,124.32) 118.44,124.2 88.84,94.6 arc(88.72,94.51) 88.57,94.49 67.95,94.49 arc(67.18,94.33) 66.53,93.9 64.54,91.9 arc(64.1,91.25) 63.94,90.48 63.94,73.26 arc(63.92,73.12) 63.83,72.99 60.15,69.31 arc(59.98,69.06) 59.92,68.77 59.92,62.85 arc(59.98,62.56) 60.15,62.31 63.11,59.35 arc(63.48,59.1) 63.92,59.01 65.39,59.01 arc(65.54,58.98) 65.66,58.9 65.75,58.82 65.79,58.77 arc(65.84,58.71) 65.88,58.63 arc(65.88,58.62) 65.89,58.61 arc(65.89,58.61) 65.89,58.6 arc(65.9,58.59) 65.9,58.58 arc(65.91,58.53) 65.91,58.48 65.91,58.16 arc(65.97,57.85) 66.15,57.58 66.35,57.38 arc(66.61,57) 66.7,56.54 YJ24.D24
FC8_TDN0: length 190.9
  TOP w0.147: v4(165.55,163.39) 165.55,163.34 U1.BU65
  SIG7 w0.112: v4(165.55,163.39) 165.55,163.58 arc(165.5,163.7) 165.38,163.74 165.31,163.74 arc(165.17,163.69) 165.12,163.55 165.12,163.26 arc(165.09,163.12) 165.01,163 164.91,162.9 arc(164.88,162.87) 164.85,162.85 arc(164.77,162.81) 164.68,162.8 163.38,162.8 163.28,162.71 163.26,162.71
  SIG7 w0.16: YJ24.D2 77.25,53.97 arc(77.36,54.14) 77.4,54.34 77.4,54.52 arc(77.3,54.76) 77.06,54.86 76.16,54.86 arc(75.86,54.92) 75.62,55.08 75.53,55.17 arc(75.28,55.34) 74.99,55.39 63.13,55.39 arc(62.98,55.42) 62.86,55.51 58.55,59.82 arc(58.46,59.94) 58.43,60.09 58.43,70.99 arc(58.46,71.13) 58.55,71.26 58.96,71.67 59.16,71.67 59.52,72.03 59.52,72.23 59.85,72.56 60.05,72.56 60.4,72.91 60.4,73.11 61.48,74.19 61.69,74.19 62.04,74.55 62.04,74.75 62.37,75.08 62.55,75.08 62.93,75.46 62.93,75.64 63.34,76.05 arc(63.51,76.3) 63.56,76.59 63.56,77.01 63.74,77.19 63.74,77.66 63.56,77.84 63.56,78.3 63.74,78.48 63.74,78.94 63.56,79.12 63.56,90.26 arc(63.59,90.41) 63.68,90.53 69.29,96.15 arc(69.42,96.23) 69.56,96.26 87.78,96.26 arc(88.08,96.32) 88.32,96.49 116.55,124.72 arc(116.72,124.96) 116.78,125.26 116.78,127.78 arc(116.81,127.93) 116.89,128.05 151.84,163 arc(151.97,163.09) 152.11,163.12 162.1,163.12 arc(162.21,163.09) 162.3,163.03 162.43,162.91 arc(162.64,162.76) 162.9,162.71 163.26,162.71
FC8_TDN1: length 190.9
  TOP w0.147: U1.BV63 168.02,163.84 arc(167.71,163.97) v4(167.57,164.29)
  SIG6 w0.112: 163.26,165.02 163.28,165.02 163.38,164.93 166.78,164.93 arc(166.91,164.91) 167.01,164.84 167.06,164.78 arc(167.13,164.68) 167.16,164.56 167.16,164.07 arc(167.2,163.98) 167.29,163.94 167.41,163.94 arc(167.46,163.95) 167.5,163.98 167.54,164.01 arc(167.56,164.05) 167.57,164.1 v4(167.57,164.29)
  SIG6 w0.16: YJ24.D6 73.9,52.82 arc(73.86,53.02) 73.75,53.19 73.35,53.58 arc(73.17,53.85) 73.11,54.16 73.11,54.48 arc(73.11,54.53) 73.1,54.57 arc(73.06,54.68) 72.99,54.77 72.95,54.82 72.86,54.9 arc(72.74,54.98) 72.59,55.01 63.78,55.01 arc(63.49,55.07) 63.24,55.24 57.82,60.66 arc(57.65,60.91) 57.59,61.2 57.59,70.48 arc(57.65,70.77) 57.82,71.02 62.96,76.16 arc(63.12,76.4) 63.18,76.7 63.18,90.08 arc(63.27,90.52) 63.52,90.89 68.94,96.31 arc(69.31,96.56) 69.75,96.64 87.63,96.64 arc(87.92,96.7) 88.17,96.87 116.17,124.87 arc(116.34,125.12) 116.4,125.41 116.4,127.62 arc(116.48,128.06) 116.73,128.43 151.46,163.16 arc(151.83,163.41) 152.27,163.5 159.06,163.5 arc(159.2,163.53) 159.33,163.61 160.41,164.69 arc(160.53,164.79) 160.66,164.88 arc(160.93,164.99) 161.22,165.02 163.26,165.02
FC8_TDN2: length 178.8
  TOP w0.147: v4(164.55,161.39) 164.55,161.34 U1.BR66
  SIG7 w0.112: v4(164.55,161.39) 164.55,161.58 arc(164.5,161.7) 164.38,161.74 164.24,161.74 arc(164.15,161.71) 164.11,161.62 164.11,161.29 arc(164.08,161.12) 163.98,160.98 163.9,160.9 arc(163.88,160.87) 163.85,160.85 arc(163.76,160.81) 163.67,160.8 163.23,160.8 163.14,160.71 163.11,160.71
  SIG7 w0.16: 163.11,160.71 161.77,160.71 arc(161.57,160.75) 161.4,160.86 161.27,160.99 arc(161.22,161.02) 161.17,161.03 153.03,161.03 arc(152.88,161) 152.76,160.92 119.05,127.21 arc(118.96,127.09) 118.94,126.94 118.94,124.49 arc(118.88,124.2) 118.71,123.95 89.09,94.33 arc(88.84,94.16) 88.55,94.1 75.08,94.1 arc(74.93,94.08) 74.81,93.99 66.85,86.04 arc(66.77,85.91) 66.74,85.77 66.74,78.84 66.94,78.63 66.94,78.22 66.74,78.02 66.74,77.55 66.92,77.37 66.92,76.91 66.74,76.73 66.74,73.72 arc(66.68,73.43) 66.52,73.18 66.2,72.86 66.2,72.61 65.87,72.28 65.62,72.28 65.29,71.95 65.29,71.67 64.99,71.37 64.71,71.37 64.38,71.04 64.38,70.81 64.02,70.46 63.79,70.46 60.63,67.29 arc(60.54,67.17) 60.51,67.02 60.51,61.95 arc(60.54,61.8) 60.63,61.68 62.8,59.51 arc(62.92,59.42) 63.07,59.39 74.99,59.39 arc(75.28,59.34) 75.53,59.17 arc(75.87,58.94) 76.28,58.86 77.06,58.86 arc(77.3,58.76) 77.4,58.52 77.4,58.34 arc(77.36,58.14) 77.25,57.97 YJ24.D37
FC8_TDN3: length 178.8
  TOP w0.147: U1.BT64 167,161.84 arc(166.68,161.97) v4(166.55,162.29)
  SIG6 w0.112: 163.26,163.02 163.28,163.02 163.38,162.93 165.74,162.93 arc(165.87,162.91) 165.97,162.84 166.02,162.78 arc(166.09,162.68) 166.12,162.56 166.12,162.07 arc(166.16,161.98) 166.25,161.94 166.39,161.94 arc(166.44,161.95) 166.48,161.98 166.51,162.01 arc(166.54,162.05) 166.55,162.1 v4(166.55,162.29)
  SIG6 w0.16: 163.26,163.02 162.42,163.02 arc(161.98,162.94) 161.61,162.69 160.45,161.53 arc(160.33,161.44) 160.18,161.41 153.08,161.41 arc(152.79,161.36) 152.54,161.19 126.94,135.58 118.78,127.43 arc(118.61,127.18) 118.55,126.89 118.55,124.65 arc(118.5,124.36) 118.33,124.11 88.93,94.71 arc(88.68,94.54) 88.39,94.49 75.1,94.49 arc(74.81,94.43) 74.56,94.26 66.58,86.28 arc(66.42,86.03) 66.36,85.74 66.36,74.74 arc(66.33,74.59) 66.25,74.47 63.53,71.75 62.45,70.67 61.69,69.91 61.69,69.91 61.46,69.68 60.74,68.96 60.7,68.92 60.1,68.32 arc(59.94,68.08) 59.88,67.78 59.88,62.8 arc(59.94,62.51) 60.1,62.26 63.13,59.24 arc(63.37,59.07) 63.66,59.01 72.59,59.01 arc(72.74,58.98) 72.86,58.9 72.95,58.82 72.99,58.77 arc(73.05,58.69) 73.1,58.59 arc(73.11,58.53) 73.11,58.48 73.11,58.16 arc(73.17,57.85) 73.35,57.58 73.76,57.18 arc(73.86,57.02) 73.9,56.84 YJ24.D33
