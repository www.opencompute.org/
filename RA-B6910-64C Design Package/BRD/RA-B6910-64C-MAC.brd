# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC42_RDP1: length 92.5
  TOP w0.147: v4(222.55,119.39) 222.44,119.39 arc(222.34,119.41) 222.26,119.47 222.17,119.56 arc(222.08,119.69) U1.P9
  SIG3 w0.112: v4(222.55,119.39) 222.55,119.62 arc(222.59,119.71) 222.68,119.74 222.88,119.74 arc(222.99,119.77) 223.09,119.83 arc(223.16,119.93) 223.18,120.05 223.18,120.35 arc(223.21,120.5) 223.3,120.63 arc(223.42,120.71) 223.57,120.74 225.59,120.74 arc(225.72,120.72) 225.82,120.65 arc(225.89,120.54) 225.91,120.42 225.91,120.21 arc(225.95,120.03) 226.05,119.88 arc(226.2,119.78) 226.38,119.74 231.94,119.74 232.04,119.65 232.06,119.65
  SIG3 w0.16: YJ31.A14 261.75,61.97 arc(261.64,62.13) 261.61,62.32 261.61,62.55 arc(261.7,62.77) 261.92,62.86 262.78,62.86 arc(263.07,62.92) 263.31,63.08 263.36,63.13 263.41,63.18 arc(263.66,63.35) 263.95,63.41 265.39,63.41 arc(265.68,63.46) 265.93,63.63 266.46,64.16 arc(266.62,64.4) 266.68,64.69 266.68,66.09 arc(266.77,66.53) 267.01,66.9 267.24,67.13 arc(267.32,67.25) 267.35,67.4 267.35,69.05 arc(267.32,69.2) 267.24,69.32 266.86,69.7 266.52,69.7 266.14,70.08 266.14,70.42 265.78,70.78 arc(265.53,71.15) 265.44,71.59 265.44,72.09 265.19,72.35 265.19,72.86 265.44,73.11 265.44,73.62 265.19,73.87 265.19,74.38 265.44,74.63 265.44,75.14 265.19,75.4 265.19,75.9 265.44,76.16 265.44,77.64 arc(265.43,77.71) 265.39,77.77 arc(265.18,78.08) 265.11,78.44 265.11,91.91 arc(265.08,92.06) 265,92.18 258.75,98.44 arc(258.62,98.52) 258.48,98.55 255.2,98.55 arc(254.76,98.64) 254.39,98.88 233.73,119.54 arc(233.62,119.62) 233.49,119.65 arc(233.48,119.65) 233.46,119.65 232.06,119.65
FC42_RDP2: length 91.8
  TOP w0.147: U1.R11 220.55,120.34 v4(220.55,120.29)
  SIG2 w0.112: v4(220.55,120.29) 220.55,120.07 arc(220.59,119.98) 220.68,119.94 220.88,119.94 arc(220.92,119.95) 220.95,119.97 arc(220.98,120.01) 220.99,120.05 220.99,120.35 arc(221.03,120.58) 221.16,120.77 arc(221.35,120.89) 221.57,120.94 225.59,120.94 arc(225.79,120.9) 225.96,120.79 arc(226.07,120.62) 226.11,120.42 226.11,120.21 arc(226.13,120.11) 226.19,120.02 arc(226.28,119.96) 226.38,119.94 231.97,119.94 232.06,120.03 232.09,120.03
  SIG2 w0.16: YJ31.A18 265.1,60.8 arc(265.14,61.02) 265.26,61.2 265.81,61.75 arc(265.88,61.85) 265.91,61.97 265.91,62.57 arc(265.94,62.72) 266.03,62.86 266.08,62.91 266.55,63.38 arc(266.93,63.95) 267.06,64.61 267.06,66.02 arc(267,66.31) 266.84,66.55 265.72,67.67 arc(265.55,67.92) 265.49,68.21 265.49,91.76 arc(265.41,92.19) 265.16,92.57 259.13,98.6 arc(258.76,98.84) 258.32,98.93 255.04,98.93 arc(254.89,98.96) 254.77,99.04 234.12,119.7 arc(233.74,119.95) 233.31,120.03 232.09,120.03
FC42_RDP3: length 80.5
  TOP w0.147: v4(224.55,119.39) 224.44,119.39 arc(224.34,119.41) 224.26,119.47 224.17,119.56 arc(224.08,119.69) U1.P7
  SIG3 w0.112: v4(224.55,119.39) 224.55,119.62 arc(224.59,119.71) 224.68,119.74 224.88,119.74 arc(224.92,119.73) 224.95,119.71 arc(224.98,119.68) 224.99,119.63 224.99,118.15 arc(225.02,118) 225.1,117.86 arc(225.23,117.78) 225.39,117.75 231.72,117.75 231.81,117.66 231.84,117.66
  SIG3 w0.16: YJ31.A22 264.15,65.97 arc(264.04,66.13) 264.01,66.32 264.01,66.59 arc(264.09,66.78) 264.28,66.86 265.32,66.86 arc(265.45,66.92) 265.5,67.05 265.5,67.59 arc(265.47,67.74) 265.39,67.86 265.03,68.22 264.7,68.22 264.31,68.6 264.31,68.94 263.36,69.89 arc(263.12,70.26) 263.03,70.7 263.03,71.2 262.75,71.48 262.75,71.94 263.03,72.22 263.03,72.73 262.75,73.01 262.75,73.47 263.03,73.74 263.03,74.25 262.75,74.53 262.75,74.99 263.03,75.27 263.03,90.39 arc(263,90.54) 262.92,90.66 258.19,95.39 arc(258.07,95.47) 257.92,95.5 255.3,95.5 arc(254.86,95.59) 254.49,95.84 232.78,117.54 arc(232.66,117.63) 232.51,117.66 231.84,117.66
FC42_TDN0: length 70.6
  TOP w0.147: v4(227.55,119.29) 227.55,119.34 U1.P4
  SIG4 w0.112: v4(227.55,119.29) 227.55,119.07 arc(227.59,118.98) 227.68,118.94 227.83,118.94 arc(227.97,118.91) 228.08,118.84 228.08,118.84 arc(228.16,118.72) 228.18,118.59 228.18,118.21 arc(228.2,118.11) 228.26,118.02 arc(228.35,117.96) 228.46,117.94 231.72,117.94 231.81,118.03 231.84,118.03
  SIG4 w0.155: 256.31,65.97 arc(256.29,65.88) 256.25,65.8
  SIG4 w0.16: 256.31,65.97 256.31,67.54 arc(256.25,67.83) 256.08,68.08 254.92,69.24 arc(254.76,69.49) 254.7,69.78 254.7,95.83 arc(254.64,96.12) 254.48,96.37 233.03,117.81 arc(232.79,117.97) 232.5,118.03 231.84,118.03 ; YJ31.A33 255.5,64.78 arc(255.55,65.01) 255.68,65.22 256.15,65.68 arc(256.2,65.74) 256.25,65.8
FC42_TDN1: length 67.6
  TOP w0.147: U1.N2 229.1,118.84 arc(229.42,118.71) v4(229.55,118.39)
  SIG5 w0.112: v4(229.55,118.39) 229.55,118.62 arc(229.59,118.71) 229.68,118.74 229.84,118.74 arc(229.88,118.73) 229.93,118.71 229.94,118.69 arc(229.97,118.64) 229.99,118.58 229.99,118.14 arc(230.02,117.99) 230.1,117.86 arc(230.23,117.77) 230.39,117.74 231.72,117.74 231.81,117.65 231.84,117.65
  SIG5 w0.16: 231.84,117.65 232.36,117.65 arc(232.65,117.59) 232.9,117.43 233.44,116.89 234.73,115.59 234.73,115.38 235.27,114.84 235.49,114.84 236.03,114.3 236.03,114.08 236.57,113.55 236.78,113.55 237.32,113.01 237.32,112.79 237.86,112.25 238.08,112.25 249.62,100.7 arc(249.79,100.46) 249.85,100.16 249.85,78.51 249.72,78.38 249.72,77.57 249.85,77.44 249.85,75.94 249.75,75.84 249.75,75 249.85,74.9 249.85,74.51 arc(249.93,74.07) 250.18,73.7 250.83,73.05 250.83,72.86 251.39,72.3 251.58,72.3 252.12,71.76 252.12,71.57 252.68,71.01 252.87,71.01 253.41,70.47 arc(253.5,70.34) 253.53,70.2 253.53,69.11 253.4,68.99 253.4,68.17 253.53,68.05 253.53,67.12 arc(253.45,66.94) 253.26,66.86 252.28,66.86 arc(252.09,66.78) 252.01,66.59 252.01,66.32 arc(252.04,66.13) 252.15,65.97 YJ31.A37
FC42_TDN2: length 94
  TOP w0.147: U1.T5 226.55,121.34 v4(226.55,121.29)
  SIG4 w0.112: v4(226.55,121.29) 226.55,121.07 arc(226.59,120.98) 226.68,120.94 226.83,120.94 arc(226.97,120.91) 227.08,120.84 227.08,120.84 arc(227.16,120.72) 227.18,120.59 227.18,120.21 arc(227.2,120.11) 227.26,120.02 arc(227.35,119.96) 227.46,119.94 232.1,119.94 232.19,120.03 232.22,120.03
  SIG4 w0.155: 256.31,61.97 arc(256.3,61.91) 256.28,61.84
  SIG4 w0.16: 256.31,61.97 256.31,62.57 arc(256.34,62.72) 256.43,62.86 256.48,62.91 arc(256.61,63) 256.75,63.03 265.72,63.03 arc(266.01,63.08) 266.26,63.25 266.84,63.82 arc(267,64.07) 267.06,64.36 267.06,66.47 arc(267,66.76) 266.84,67.01 263.96,69.88 arc(263.79,70.13) 263.74,70.42 263.74,76.56 arc(263.69,76.77) 263.57,76.95 arc(263.45,77.13) 263.41,77.34 263.41,90.44 arc(263.35,90.73) 263.19,90.98 257.34,96.83 arc(257.17,97.08) 257.11,97.37 257.11,99.31 arc(257.05,99.6) 256.89,99.85 240.61,116.12 arc(240.24,116.37) 239.8,116.46 237.56,116.46 arc(237.41,116.49) 237.29,116.57 237.02,116.84 234.05,119.81 arc(233.8,119.97) 233.51,120.03 232.22,120.03 ; YJ31.A6 255.5,60.85 arc(255.53,61.02) 255.63,61.16 256.19,61.72 arc(256.24,61.78) 256.28,61.84
FC42_TDN3: length 94.3
  TOP w0.147: U1.R3 228.1,120.84 arc(228.42,120.71) v4(228.55,120.39)
  SIG5 w0.112: v4(228.55,120.39) 228.55,120.62 arc(228.59,120.71) 228.68,120.74 228.84,120.74 arc(228.88,120.73) 228.93,120.71 228.94,120.69 arc(228.97,120.64) 228.99,120.58 228.99,120.14 arc(229.02,119.99) 229.1,119.86 arc(229.23,119.77) 229.39,119.74 231.89,119.74 231.98,119.65 232.01,119.65
  SIG5 w0.16: 232.01,119.65 233.47,119.65 arc(233.48,119.65) 233.49,119.65 arc(233.62,119.62) 233.74,119.54 254.21,99.07 arc(254.29,98.94) 254.32,98.8 254.32,76.89 arc(254.4,76.46) 254.65,76.09 257.91,72.82 arc(258.29,72.58) 258.72,72.49 260.5,72.49 arc(260.65,72.46) 260.77,72.38 261.15,72 261.15,71.73 261.52,71.36 261.79,71.36 262.12,71.03 262.12,70.76 262.49,70.39 262.76,70.39 263.09,70.06 263.09,69.79 263.46,69.42 263.73,69.42 264.06,69.09 264.06,68.82 264.43,68.45 264.7,68.45 265.03,68.12 265.03,67.85 265.4,67.48 265.67,67.48 266.57,66.58 arc(266.65,66.46) 266.68,66.31 266.68,64.36 arc(266.65,64.22) 266.57,64.09 265.99,63.52 arc(265.87,63.44) 265.72,63.41 254.35,63.41 arc(254.06,63.35) 253.81,63.18 253.76,63.13 253.72,63.08 arc(253.47,62.92) 253.18,62.86 252.28,62.86 arc(252.09,62.78) 252.01,62.59 252.01,62.32 arc(252.04,62.13) 252.15,61.97 YJ31.A2
FC42_TDP0: length 70.6
  TOP w0.147: v4(227.55,118.39) 227.55,118.48 arc(227.53,118.56) 227.49,118.62 227.41,118.7 arc(227.25,118.81) 227.07,118.84 U1.N4
  SIG4 w0.112: 231.84,117.65 231.81,117.65 231.72,117.74 228.46,117.74 arc(228.28,117.78) 228.12,117.88 arc(228.02,118.03) 227.99,118.21 227.99,118.59 arc(227.97,118.65) 227.94,118.7 arc(227.89,118.73) 227.83,118.74 227.68,118.74 arc(227.59,118.71) 227.55,118.62 v4(227.55,118.39)
  SIG4 w0.16: YJ31.A34 254.55,65.97 arc(254.44,66.13) 254.41,66.32 254.41,66.57 arc(254.49,66.78) 254.7,66.86 255.71,66.86 arc(255.86,66.92) 255.93,67.07 255.93,67.54 arc(255.9,67.69) 255.81,67.81 254.65,68.97 arc(254.4,69.34) 254.32,69.78 254.32,70.29 254.11,70.49 254.11,71.1 254.32,71.31 254.32,71.81 254.11,72.02 254.11,72.63 254.32,72.83 254.32,73.34 254.14,73.52 254.14,74.18 254.32,74.35 254.32,75.18 254.06,75.44 254.06,75.94 254.32,76.2 254.32,76.83 254.09,77.06 254.09,77.62 254.32,77.85 254.32,95.83 arc(254.29,95.97) 254.21,96.1 232.77,117.54 arc(232.64,117.62) 232.5,117.65 231.84,117.65
FC42_TDP1: length 67.6
  TOP w0.147: v4(229.55,119.29) 229.55,119.34 U1.P2
  SIG5 w0.112: 231.84,118.03 231.81,118.03 231.72,117.94 230.39,117.94 arc(230.31,117.95) 230.24,118 arc(230.2,118.06) 230.18,118.14 230.18,118.58 arc(230.15,118.72) 230.08,118.83 230.07,118.85 arc(229.96,118.92) 229.84,118.94 229.68,118.94 arc(229.59,118.98) 229.55,119.07 v4(229.55,119.29)
  SIG5 w0.16: 231.84,118.03 232.36,118.03 arc(232.8,117.94) 233.17,117.69 249.89,100.97 arc(250.14,100.6) 250.23,100.16 250.23,74.51 arc(250.29,74.21) 250.45,73.97 253.68,70.74 arc(253.85,70.49) 253.91,70.2 253.91,65.97 arc(253.88,65.85) 253.81,65.75 253.28,65.21 arc(253.15,65.01) 253.1,64.78 YJ31.A36
FC42_TDP2: length 94
  TOP w0.147: v4(226.55,120.39) 226.55,120.48 arc(226.53,120.56) 226.49,120.62 226.41,120.7 arc(226.25,120.81) 226.07,120.84 U1.R5
  SIG4 w0.112: v4(226.55,120.39) 226.55,120.62 arc(226.59,120.71) 226.68,120.74 226.83,120.74 arc(226.89,120.73) 226.94,120.7 arc(226.97,120.65) 226.99,120.59 226.99,120.21 arc(227.02,120.03) 227.12,119.88 arc(227.28,119.78) 227.46,119.74 232.1,119.74 232.19,119.65 232.22,119.65
  SIG4 w0.16: 232.22,119.65 233.51,119.65 arc(233.66,119.62) 233.78,119.54 237.02,116.3 arc(237.27,116.13) 237.56,116.08 239.8,116.08 arc(240.1,116.02) 240.34,115.85 256.62,99.58 arc(256.7,99.45) 256.73,99.31 256.73,97.37 arc(256.82,96.93) 257.07,96.56 262.92,90.71 arc(263,90.59) 263.03,90.44 263.03,77.34 arc(263.1,76.98) 263.3,76.68 arc(263.34,76.62) 263.35,76.56 263.35,73.47 263.1,73.22 263.1,72.71 263.35,72.45 263.35,71.95 263.1,71.69 263.1,71.18 263.35,70.93 263.35,70.42 arc(263.44,69.98) 263.69,69.61 264.41,68.89 264.41,68.56 264.8,68.17 265.13,68.17 265.49,67.81 265.49,67.48 265.87,67.09 266.21,67.09 266.57,66.74 arc(266.65,66.61) 266.68,66.47 266.68,64.36 arc(266.65,64.22) 266.57,64.09 265.99,63.52 arc(265.87,63.44) 265.72,63.41 256.75,63.41 arc(256.46,63.35) 256.21,63.18 256.16,63.13 256.12,63.08 arc(255.87,62.92) 255.58,62.86 254.68,62.86 arc(254.49,62.78) 254.41,62.59 254.41,62.32 arc(254.44,62.13) 254.55,61.97 YJ31.A5
FC42_TDP3: length 94.3
  TOP w0.147: U1.T3 228.55,121.34 v4(228.55,121.29)
  SIG5 w0.112: 232.01,120.03 231.98,120.03 231.89,119.94 229.39,119.94 arc(229.31,119.95) 229.24,120 arc(229.2,120.06) 229.18,120.14 229.18,120.58 arc(229.15,120.72) 229.08,120.83 229.07,120.85 arc(228.96,120.92) 228.84,120.94 228.68,120.94 arc(228.59,120.98) 228.55,121.07 v4(228.55,121.29)
  SIG5 w0.16: YJ31.A3 253.1,60.73 arc(253.16,61.01) 253.31,61.25 253.81,61.75 arc(253.88,61.85) 253.91,61.97 253.91,62.57 arc(253.91,62.6) 253.91,62.64 arc(253.95,62.76) 254.03,62.86 254.08,62.91 arc(254.21,63) 254.35,63.03 265.72,63.03 arc(266.01,63.08) 266.26,63.25 266.84,63.82 arc(267,64.07) 267.06,64.36 267.06,66.31 arc(267,66.61) 266.84,66.85 261.04,72.65 arc(260.8,72.81) 260.5,72.87 258.72,72.87 arc(258.43,72.93) 258.18,73.09 254.92,76.36 arc(254.76,76.6) 254.7,76.89 254.7,98.8 arc(254.64,99.09) 254.48,99.34 234.01,119.81 arc(233.78,119.96) 233.51,120.03 arc(233.49,120.03) 233.47,120.03 232.01,120.03
FC43_RDN0: length 104.8
  TOP w0.147: v4(217.55,123.29) 217.55,123.34 U1.V14
  SIG2 w0.112: 231.96,122.03 231.88,121.94 218.57,121.94 arc(218.42,121.97) 218.3,122.06 arc(218.21,122.18) 218.18,122.33 218.18,122.63 arc(218.16,122.75) 218.09,122.85 arc(217.99,122.92) 217.88,122.94 217.68,122.94 arc(217.59,122.98) 217.55,123.07 v4(217.55,123.29)
  SIG2 w0.16: 231.96,122.03 234.28,122.03 arc(234.35,122.03) 234.43,122.02 arc(234.79,121.91) 235.09,121.69 255.46,101.33 arc(255.58,101.25) 255.73,101.22 259.59,101.22 arc(260.03,101.13) 260.4,100.88 267.57,93.71 arc(267.82,93.34) 267.91,92.9 267.91,71.51 arc(267.94,71.36) 268.02,71.24 268.24,71.02 arc(268.49,70.65) 268.57,70.21 268.57,66.65 arc(268.55,66.52) 268.48,66.41 arc(268.4,66.31) 268.38,66.18 268.38,61.44 arc(268.29,61) 268.04,60.63 266.77,59.36 arc(266.4,59.11) 265.96,59.03 263.95,59.03 arc(263.86,59.01) 263.78,58.98 arc(263.73,58.95) 263.68,58.91 263.63,58.86 arc(263.54,58.72) 263.51,58.57 263.51,57.97 arc(263.48,57.85) 263.41,57.75 262.86,57.19 arc(262.74,57.02) 262.7,56.81 YJ31.B24
FC43_RDN1: length 99.3
  TOP w0.147: v4(221.55,122.39) 221.44,122.39 arc(221.34,122.41) 221.26,122.47 221.17,122.56 arc(221.08,122.69) U1.U10
  SIG3 w0.112: 232.01,121.65 231.92,121.75 222.57,121.75 arc(222.35,121.79) 222.16,121.92 arc(222.03,122.11) 221.99,122.33 221.99,122.63 arc(221.98,122.68) 221.95,122.71 arc(221.92,122.73) 221.88,122.74 221.68,122.74 arc(221.59,122.71) 221.55,122.62 v4(221.55,122.39)
  SIG3 w0.16: YJ31.B22 264.15,57.97 arc(264.04,58.13) 264.01,58.32 264.01,58.59 arc(264.09,58.78) 264.28,58.86 265.18,58.86 arc(265.47,58.92) 265.71,59.08 265.76,59.13 265.81,59.18 arc(265.84,59.21) 265.86,59.23 266.22,59.59 266.22,59.95 266.58,60.31 266.94,60.31 267.52,60.89 arc(267.87,61.41) 268,62.04 268,62.54 267.74,62.8 267.74,63.31 268,63.56 268,65.79 arc(268.08,66.22) 268.33,66.6 269.27,67.53 arc(269.35,67.66) 269.38,67.8 269.38,68.31 269.15,68.54 269.15,69.1 269.38,69.33 269.38,69.94 arc(269.35,70.08) 269.27,70.21 268.96,70.51 268.6,70.51 268.24,70.87 268.24,71.23 267.86,71.62 arc(267.61,71.99) 267.53,72.42 267.53,93.06 arc(267.5,93.2) 267.41,93.33 260.02,100.72 arc(259.89,100.81) 259.75,100.84 255.88,100.84 arc(255.45,100.92) 255.08,101.17 234.71,121.54 arc(234.59,121.62) 234.44,121.65 232.01,121.65
FC43_RDN2: length 111.3
  TOP w0.147: v4(219.55,123.29) 219.55,123.34 U1.V12
  SIG2 w0.112: v4(219.55,123.29) 219.55,123.07 arc(219.59,122.98) 219.68,122.94 219.85,122.94 arc(219.89,122.95) 219.93,122.97 arc(219.95,123.01) 219.96,123.05 219.96,123.36 arc(220,123.58) 220.13,123.77 arc(220.32,123.9) 220.54,123.94 231.97,123.94 232.06,124.04 232.09,124.04
  SIG2 w0.16: YJ31.B15 262.7,52.81 arc(262.74,53.02) 262.86,53.2 263.41,53.75 arc(263.48,53.85) 263.51,53.97 263.51,54.57 arc(263.54,54.72) 263.63,54.86 263.68,54.91 arc(263.73,54.95) 263.78,54.98 arc(263.86,55.01) 263.95,55.03 265.9,55.03 arc(266.34,55.11) 266.71,55.36 269.39,58.04 arc(269.63,58.41) 269.72,58.85 269.72,65.27 arc(269.78,65.56) 269.94,65.81 270.71,66.57 arc(270.87,66.82) 270.93,67.11 270.93,70.85 arc(270.87,71.14) 270.71,71.39 270.21,71.88 arc(270.05,72.13) 269.99,72.42 269.99,93.83 arc(269.9,94.27) 269.65,94.64 260.62,103.68 arc(260.25,103.92) 259.81,104.01 255.9,104.01 arc(255.76,104.04) 255.63,104.12 236.06,123.7 arc(235.68,123.95) 235.25,124.04 232.09,124.04
FC43_RDN3: length 105.7
  TOP w0.147: v4(223.55,122.39) 223.44,122.39 arc(223.34,122.41) 223.26,122.47 223.17,122.56 arc(223.08,122.69) U1.U8
  SIG3 w0.112: 232.22,123.65 232.19,123.65 232.1,123.75 224.57,123.75 arc(224.42,123.72) 224.3,123.63 arc(224.21,123.51) 224.18,123.36 224.18,123.05 arc(224.16,122.93) 224.09,122.83 arc(223.99,122.77) 223.88,122.74 223.68,122.74 arc(223.59,122.71) 223.55,122.62 v4(223.55,122.39)
  SIG3 w0.16: YJ31.B17 264.15,53.97 arc(264.04,54.13) 264.01,54.32 264.01,54.59 arc(264.09,54.78) 264.28,54.86 265.18,54.86 arc(265.47,54.92) 265.71,55.08 266.07,55.44 266.07,55.9 266.34,56.16 266.79,56.16 267.15,56.52 267.15,56.98 267.42,57.24 267.87,57.24 268.21,57.58 268.21,58.04 268.52,58.34 268.97,58.34 269.11,58.48 arc(269.27,58.72) 269.33,59.01 269.33,65.39 arc(269.39,65.68) 269.55,65.93 271.48,67.86 arc(271.56,67.98) 271.59,68.13 271.59,70.78 arc(271.56,70.92) 271.48,71.05 269.94,72.58 arc(269.7,72.95) 269.61,73.39 269.61,93.99 arc(269.58,94.14) 269.5,94.26 260.24,103.52 arc(260.12,103.6) 259.97,103.63 256.06,103.63 arc(255.62,103.72) 255.25,103.96 235.68,123.54 arc(235.56,123.62) 235.41,123.65 232.73,123.65 232.73,123.65 232.22,123.65
FC43_RDP0: length 104.8
  TOP w0.147: v4(217.55,122.39) 217.55,122.47 arc(217.53,122.54) 217.5,122.6 217.32,122.77 arc(217.24,122.82) 217.14,122.84 U1.U14
  SIG2 w0.112: v4(217.55,122.39) 217.55,122.62 arc(217.59,122.71) 217.68,122.74 217.88,122.74 arc(217.92,122.73) 217.95,122.71 arc(217.98,122.68) 217.99,122.63 217.99,122.33 arc(218.03,122.11) 218.16,121.92 arc(218.35,121.79) 218.57,121.75 231.87,121.75 231.96,121.65
  SIG2 w0.16: 231.96,121.65 234.28,121.65 arc(234.33,121.65) 234.38,121.64 arc(234.62,121.57) 234.82,121.43 255.19,101.06 arc(255.43,100.89) 255.73,100.84 259.59,100.84 arc(259.88,100.78) 260.13,100.61 267.3,93.44 arc(267.47,93.19) 267.53,92.9 267.53,76.08 267.3,75.85 267.3,75.29 267.53,75.07 267.53,74.56 267.27,74.3 267.27,73.8 267.53,73.54 267.53,73.03 267.27,72.78 267.27,72.27 267.53,72.02 267.53,71.51 arc(267.58,71.22) 267.75,70.97 267.97,70.75 arc(268.13,70.5) 268.19,70.21 268.19,69.7 267.94,69.45 267.94,68.94 268.19,68.69 268.19,66.67 arc(268.05,66.44) 268,66.18 268,61.44 268,61.44 arc(267.94,61.15) 267.77,60.9 266.5,59.63 arc(266.25,59.46) 265.96,59.41 263.95,59.41 arc(263.77,59.38) 263.6,59.32 arc(263.5,59.26) 263.41,59.18 263.36,59.13 263.31,59.08 arc(263.07,58.92) 262.78,58.86 261.91,58.86 arc(261.7,58.77) 261.61,58.56 261.61,58.32 arc(261.64,58.13) 261.75,57.97 YJ31.B25
FC43_RDP1: length 99.3
  TOP w0.147: v4(221.55,123.29) 221.55,123.34 U1.V10
  SIG3 w0.112: 232.01,122.03 231.93,121.94 222.57,121.94 arc(222.42,121.97) 222.3,122.06 arc(222.21,122.18) 222.18,122.33 222.18,122.63 arc(222.16,122.75) 222.09,122.85 arc(221.99,122.92) 221.88,122.94 221.68,122.94 arc(221.59,122.98) 221.55,123.07 v4(221.55,123.29)
  SIG3 w0.16: 232.01,122.03 234.44,122.03 arc(234.73,121.97) 234.98,121.81 255.34,101.44 arc(255.59,101.27) 255.88,101.22 259.75,101.22 arc(260.04,101.16) 260.29,100.99 267.68,93.6 arc(267.85,93.35) 267.91,93.06 267.91,72.42 arc(267.96,72.13) 268.13,71.88 269.54,70.48 arc(269.7,70.23) 269.76,69.94 269.76,67.8 arc(269.7,67.51) 269.54,67.26 268.6,66.33 arc(268.44,66.08) 268.38,65.79 268.38,62.04 arc(268.22,61.27) 267.79,60.62 266.11,58.94 266.11,58.94 arc(266.1,58.93) 266.08,58.91 266.03,58.86 arc(265.94,58.72) 265.91,58.57 265.91,57.97 arc(265.88,57.85) 265.81,57.75 265.27,57.21 arc(265.27,57.21) 265.27,57.2 arc(265.14,57.01) 265.1,56.79 YJ31.B21
FC43_RDP2: length 111.3
  TOP w0.147: v4(219.55,122.39) 219.55,122.47 arc(219.53,122.54) 219.49,122.6 219.33,122.77 arc(219.25,122.82) 219.15,122.84 U1.U12
  SIG2 w0.112: 232.09,123.65 232.06,123.65 231.97,123.75 220.54,123.75 arc(220.4,123.72) 220.27,123.63 arc(220.19,123.51) 220.16,123.36 220.16,123.05 arc(220.13,122.93) 220.07,122.83 arc(219.97,122.77) 219.85,122.74 219.68,122.74 arc(219.59,122.71) 219.55,122.62 v4(219.55,122.39)
  SIG2 w0.16: 232.09,123.65 235.25,123.65 arc(235.54,123.6) 235.79,123.43 255.36,103.85 arc(255.61,103.69) 255.9,103.63 259.81,103.63 arc(260.1,103.57) 260.35,103.41 269.39,94.37 arc(269.55,94.13) 269.61,93.83 269.61,72.42 arc(269.7,71.99) 269.94,71.62 270.44,71.12 arc(270.52,71) 270.55,70.85 270.55,70.16 270.32,69.93 270.32,69.37 270.55,69.14 270.55,68.63 270.32,68.41 270.32,67.85 270.55,67.62 270.55,67.11 arc(270.52,66.96) 270.44,66.84 269.68,66.08 arc(269.43,65.71) 269.34,65.27 269.34,58.85 arc(269.28,58.56) 269.12,58.31 268.59,57.79 268.24,57.79 267.88,57.43 267.88,57.07 267.52,56.71 267.16,56.71 266.8,56.35 266.8,55.99 266.44,55.63 arc(266.19,55.46) 265.9,55.41 263.95,55.41 arc(263.77,55.38) 263.6,55.32 arc(263.5,55.26) 263.41,55.18 263.36,55.13 263.31,55.08 arc(263.07,54.92) 262.78,54.86 261.84,54.86 arc(261.68,54.79) 261.61,54.63 261.61,54.32 arc(261.64,54.13) 261.75,53.97 YJ31.B14
FC43_RDP3: length 105.8
  TOP w0.147: v4(223.55,123.29) 223.55,123.34 U1.V8
  SIG3 w0.112: 232.22,124.04 232.19,124.04 232.1,123.94 224.57,123.94 arc(224.35,123.9) 224.16,123.77 arc(224.03,123.58) 223.99,123.36 223.99,123.05 arc(223.98,123.01) 223.95,122.97 arc(223.92,122.95) 223.88,122.94 223.68,122.94 arc(223.59,122.98) 223.55,123.07 v4(223.55,123.29)
  SIG3 w0.16: 232.22,124.04 232.89,124.04 232.89,124.03 235.41,124.03 arc(235.7,123.97) 235.95,123.81 255.52,104.23 arc(255.77,104.07) 256.06,104.01 259.97,104.01 arc(260.26,103.95) 260.51,103.79 269.77,94.53 arc(269.93,94.28) 269.99,93.99 269.99,73.39 arc(270.05,73.1) 270.21,72.85 271.75,71.32 arc(271.91,71.07) 271.97,70.78 271.97,68.13 arc(271.91,67.83) 271.75,67.59 269.82,65.66 arc(269.74,65.54) 269.71,65.39 269.71,59.01 arc(269.62,58.58) 269.37,58.21 266.03,54.86 arc(265.94,54.72) 265.91,54.57 265.91,53.97 arc(265.88,53.85) 265.81,53.75 265.33,53.27 265.27,53.2 arc(265.14,53.02) 265.1,52.8 YJ31.B18
FC43_TDN0: length 98.6
  TOP w0.147: U1.R1 230.1,120.84 arc(230.42,120.71) v4(230.55,120.39)
  SIG5 w0.112: 232.09,121.65 232.06,121.65 231.97,121.75 231.39,121.75 arc(231.31,121.73) 231.24,121.69 arc(231.2,121.62) 231.18,121.54 231.18,121.11 arc(231.15,120.97) 231.08,120.85 231.07,120.84 arc(230.96,120.77) 230.84,120.74 230.68,120.74 arc(230.59,120.71) 230.55,120.62 v4(230.55,120.39)
  SIG5 w0.16: YJ31.B37 252.15,57.97 arc(252.04,58.13) 252.01,58.32 252.01,58.59 arc(252.09,58.78) 252.28,58.86 253.18,58.86 arc(253.47,58.92) 253.72,59.08 253.76,59.13 253.81,59.18 arc(254.06,59.35) 254.35,59.41 265.79,59.41 arc(265.93,59.44) 266.06,59.52 266.92,60.38 266.92,60.68 267.26,61.03 267.56,61.03 267.89,61.35 arc(267.97,61.47) 268,61.62 268,68.43 arc(267.97,68.57) 267.89,68.69 267.56,69.02 267.29,69.02 266.92,69.39 266.92,69.66 266.5,70.08 266.23,70.08 265.85,70.45 265.85,70.73 265.53,71.05 265.26,71.05 264.88,71.42 264.88,71.7 264.56,72.02 264.29,72.02 263.91,72.39 263.91,72.67 263.36,73.22 arc(263.12,73.59) 263.03,74.02 263.03,93.03 arc(263,93.18) 262.92,93.3 234.68,121.54 arc(234.55,121.63) 234.41,121.65 232.09,121.65
FC43_TDN1: length 113.1
  TOP w0.147: U1.V6 225.55,123.34 v4(225.55,123.29)
  SIG4 w0.112: 231.96,124.04 231.94,124.04 231.84,123.94 226.46,123.94 arc(226.28,123.91) 226.12,123.8 arc(226.02,123.65) 225.99,123.47 225.99,123.09 arc(225.97,123.04) 225.94,122.99 arc(225.89,122.95) 225.83,122.94 225.68,122.94 arc(225.59,122.98) 225.55,123.07 v4(225.55,123.29)
  SIG4 w0.16: YJ31.B6 255.5,52.7 arc(255.56,53.01) 255.74,53.27 256.21,53.75 arc(256.28,53.85) 256.31,53.97 256.31,54.57 arc(256.34,54.72) 256.43,54.86 256.48,54.91 arc(256.61,55) 256.75,55.03 266.1,55.03 arc(266.4,55.08) 266.64,55.25 269.47,58.08 arc(269.64,58.33) 269.7,58.62 269.7,69.88 arc(269.64,70.17) 269.47,70.41 268.13,71.76 arc(267.96,72.01) 267.91,72.3 267.91,81.69 267.91,91.08 267.91,91.91 arc(267.85,92.21) 267.68,92.45 261.53,98.61 arc(261.36,98.86) 261.3,99.15 261.3,103.41 arc(260.91,105.4) 259.78,107.09 242.76,124.11 arc(242.51,124.27) 242.22,124.33 236.67,124.33 arc(236.52,124.32) 236.38,124.27 235.94,124.09 arc(235.8,124.05) 235.65,124.04 231.96,124.04
FC43_TDN2: length 101
  TOP w0.147: U1.U4 227.07,122.84 arc(227.25,122.81) 227.41,122.7 227.49,122.62 arc(227.53,122.56) 227.55,122.48 v4(227.55,122.39)
  SIG4 w0.112: v4(227.55,122.39) 227.55,122.62 arc(227.59,122.71) 227.68,122.74 227.83,122.74 arc(227.89,122.73) 227.94,122.7 arc(227.97,122.65) 227.99,122.59 227.99,122.21 arc(228.02,122.03) 228.12,121.88 arc(228.28,121.78) 228.46,121.74 231.97,121.74 232.06,121.65 232.09,121.65
  SIG4 w0.16: 232.09,121.65 232.55,121.65 232.78,121.42 233.23,121.42 233.46,121.65 234.51,121.65 arc(234.66,121.62) 234.78,121.54 236.13,120.18 arc(236.38,120.02) 236.67,119.96 237.2,119.96 237.45,119.71 237.86,119.71 238.11,119.96 238.97,119.96 arc(239.26,119.9) 239.5,119.74 258.61,100.63 arc(258.82,100.32) 258.89,99.96 258.89,98.13 arc(258.98,97.7) 259.22,97.33 265,91.55 arc(265.08,91.43) 265.11,91.28 265.11,78.18 arc(265.18,77.82) 265.39,77.52 arc(265.43,77.46) 265.44,77.39 265.44,71.35 arc(265.53,70.91) 265.78,70.54 267.89,68.44 arc(267.97,68.31) 268,68.17 268,62.61 267.74,62.35 267.74,61.95 268,61.69 268,61.24 arc(267.97,61.09) 267.89,60.97 267.48,60.56 267.13,60.56 266.83,60.26 266.83,59.91 266.44,59.52 arc(266.31,59.44) 266.17,59.41 256.75,59.41 arc(256.46,59.35) 256.21,59.18 256.16,59.13 256.12,59.08 arc(255.87,58.92) 255.58,58.86 254.68,58.86 arc(254.49,58.78) 254.41,58.59 254.41,58.32 arc(254.44,58.13) 254.55,57.97 YJ31.B34
FC43_TDN3: length 111.9
  TOP w0.147: v4(229.55,123.29) 229.55,123.34 U1.V2
  SIG5 w0.112: v4(229.55,123.29) 229.55,123.07 arc(229.59,122.98) 229.68,122.94 229.84,122.94 arc(229.88,122.95) 229.93,122.98 229.94,122.99 arc(229.97,123.04) 229.99,123.11 229.99,123.54 arc(230.02,123.7) 230.1,123.83 arc(230.23,123.91) 230.39,123.94 231.97,123.94 232.06,124.04 232.09,124.04
  SIG5 w0.16: 232.09,124.04 234.55,124.04 arc(234.82,124.09) 235.06,124.25 arc(235.29,124.4) 235.57,124.46 242.1,124.46 arc(242.39,124.4) 242.63,124.23 265.16,101.71 arc(265.41,101.34) 265.49,100.9 265.49,75.12 arc(265.55,74.82) 265.72,74.58 269.47,70.82 arc(269.64,70.57) 269.7,70.28 269.7,58.62 arc(269.64,58.33) 269.47,58.08 266.64,55.25 arc(266.4,55.08) 266.1,55.03 254.35,55.03 arc(254.21,55) 254.08,54.91 254.03,54.86 arc(253.96,54.76) 253.91,54.65 arc(253.91,54.64) 253.91,54.64 arc(253.91,54.6) 253.91,54.57 253.91,53.97 arc(253.88,53.85) 253.81,53.75 253.27,53.2 arc(253.14,53.02) 253.1,52.8 YJ31.B3
FC43_TDP0: length 98.6
  TOP w0.147: v4(230.55,121.29) 230.55,121.34 U1.T1
  SIG5 w0.112: 232.09,122.04 232.06,122.04 231.97,121.94 231.39,121.94 arc(231.23,121.91) 231.1,121.83 arc(231.02,121.7) 230.99,121.54 230.99,121.11 arc(230.97,121.04) 230.94,120.99 230.93,120.98 arc(230.88,120.95) 230.84,120.94 230.68,120.94 arc(230.59,120.98) 230.55,121.07 v4(230.55,121.29)
  SIG5 w0.16: YJ31.B36 253.1,56.82 arc(253.14,57.02) 253.25,57.19 253.81,57.75 arc(253.88,57.85) 253.91,57.97 253.91,58.57 arc(253.91,58.61) 253.91,58.64 arc(253.95,58.76) 254.03,58.86 254.08,58.91 arc(254.21,59) 254.35,59.03 265.79,59.03 arc(266.08,59.08) 266.33,59.25 268.15,61.08 arc(268.32,61.33) 268.38,61.62 268.38,68.43 arc(268.32,68.72) 268.15,68.96 263.63,73.48 arc(263.47,73.73) 263.41,74.02 263.41,93.03 arc(263.35,93.32) 263.19,93.57 234.95,121.81 arc(234.7,121.98) 234.41,122.04 232.09,122.04
FC43_TDP1: length 113.1
  TOP w0.147: U1.U6 225.07,122.84 arc(225.25,122.81) 225.41,122.7 225.49,122.62 arc(225.53,122.56) 225.55,122.48 v4(225.55,122.39)
  SIG4 w0.112: 231.96,123.65 231.94,123.65 231.84,123.75 226.46,123.75 arc(226.35,123.73) 226.26,123.66 arc(226.2,123.58) 226.18,123.47 226.18,123.09 arc(226.16,122.96) 226.08,122.85 arc(225.97,122.77) 225.83,122.74 225.68,122.74 arc(225.59,122.71) 225.55,122.62 v4(225.55,122.39)
  SIG4 w0.16: 231.96,123.65 232.42,123.65 232.65,123.43 233.11,123.43 233.33,123.65 233.79,123.65 234.02,123.43 234.48,123.43 234.71,123.65 235.65,123.65 arc(235.88,123.68) 236.09,123.74 236.52,123.92 arc(236.6,123.94) 236.67,123.95 242.22,123.95 arc(242.37,123.92) 242.49,123.84 259.51,106.82 arc(260.55,105.26) 260.92,103.41 260.92,99.15 arc(261.01,98.71) 261.26,98.34 267.41,92.18 arc(267.5,92.06) 267.53,91.91 267.53,91.08 267.53,81.69 267.53,72.3 arc(267.61,71.86) 267.86,71.49 269.2,70.15 arc(269.29,70.02) 269.32,69.88 269.32,59.99 269.15,59.83 269.15,59.24 269.32,59.08 269.32,58.62 arc(269.29,58.47) 269.2,58.35 268.4,57.54 268.15,57.54 267.75,57.14 267.75,56.89 267.43,56.57 267.18,56.57 266.78,56.17 266.78,55.93 266.37,55.52 arc(266.25,55.44) 266.1,55.41 256.75,55.41 arc(256.46,55.35) 256.21,55.18 256.16,55.13 256.12,55.08 arc(255.87,54.92) 255.58,54.86 254.71,54.86 arc(254.5,54.77) 254.41,54.56 254.41,54.32 arc(254.44,54.13) 254.55,53.97 YJ31.B5
FC43_TDP2: length 101
  TOP w0.147: v4(227.55,123.29) 227.55,123.34 U1.V4
  SIG4 w0.112: v4(227.55,123.29) 227.55,123.07 arc(227.59,122.98) 227.68,122.94 227.83,122.94 arc(227.97,122.91) 228.08,122.84 228.08,122.84 arc(228.16,122.72) 228.18,122.59 228.18,122.21 arc(228.2,122.11) 228.26,122.02 arc(228.35,121.96) 228.46,121.94 231.97,121.94 232.06,122.03 232.09,122.03
  SIG4 w0.16: YJ31.B33 255.5,56.85 arc(255.53,57.02) 255.63,57.17 256.21,57.75 arc(256.28,57.85) 256.31,57.97 256.31,58.57 arc(256.34,58.72) 256.43,58.86 256.48,58.91 arc(256.61,59) 256.75,59.03 266.17,59.03 arc(266.46,59.08) 266.71,59.25 268.15,60.7 arc(268.32,60.94) 268.38,61.24 268.38,68.17 arc(268.32,68.46) 268.15,68.7 266.05,70.81 arc(265.88,71.06) 265.82,71.35 265.82,77.39 arc(265.78,77.6) 265.66,77.79 arc(265.54,77.97) 265.49,78.18 265.49,78.18 265.49,91.28 arc(265.44,91.57) 265.27,91.82 259.49,97.6 arc(259.33,97.84) 259.27,98.13 259.27,99.96 arc(259.17,100.47) 258.88,100.9 239.77,120.01 arc(239.4,120.26) 238.97,120.34 236.67,120.34 arc(236.52,120.37) 236.4,120.45 235.05,121.81 arc(234.8,121.97) 234.51,122.03 232.09,122.03
FC43_TDP3: length 111.9
  TOP w0.147: U1.U2 229.1,122.84 arc(229.42,122.71) v4(229.55,122.39)
  SIG5 w0.112: v4(229.55,122.39) 229.55,122.62 arc(229.59,122.71) 229.68,122.74 229.84,122.74 arc(229.96,122.77) 230.07,122.84 230.08,122.85 arc(230.15,122.97) 230.18,123.11 230.18,123.54 arc(230.2,123.62) 230.24,123.69 arc(230.31,123.73) 230.39,123.75 231.97,123.75 232.06,123.65 232.09,123.65
  SIG5 w0.16: YJ31.B2 252.15,53.97 arc(252.04,54.13) 252.01,54.32 252.01,54.59 arc(252.09,54.78) 252.28,54.86 253.29,54.86 arc(253.48,54.9) 253.64,55.01 253.76,55.13 253.81,55.18 arc(254.06,55.35) 254.35,55.41 266.1,55.41 arc(266.25,55.44) 266.37,55.52 269.2,58.35 arc(269.29,58.47) 269.32,58.62 269.32,70.28 arc(269.29,70.43) 269.2,70.55 268.66,71.09 268.45,71.09 267.91,71.63 267.91,71.84 267.37,72.38 267.16,72.38 266.62,72.92 266.62,73.14 265.45,74.31 arc(265.2,74.68) 265.11,75.12 265.11,100.9 arc(265.05,101.19) 264.89,101.44 242.36,123.96 arc(242.24,124.05) 242.1,124.08 241.05,124.08 240.9,123.92 240.14,123.92 239.99,124.08 239.22,124.08 239.05,123.9 238.34,123.9 238.16,124.08 237.4,124.08 237.22,123.9 236.51,123.9 236.33,124.08 235.57,124.08 arc(235.44,124.05) 235.33,123.98 arc(234.97,123.74) 234.55,123.65 233.92,123.65 233.77,123.5 233,123.5 232.85,123.65 232.09,123.65
FC44_45_PVDD0P8: length 4.1
  TOP w0.229: U1.AH18 v1(213.55,133.34) ; U1.AK18 v1(213.55,135.34)
  TOP w0.381: 242.51,139.16 C2699.1 241.91,138.53
  BOTTOM w0.381: C3195.1 213.07,132.86 v1(213.55,133.34) ; C3337.1 213.07,134.86 v1(213.55,135.34)
  vias: v1(241.36,139.7) v1(242.25,139.7)
FC44_RDN0: length 111.6
  TOP w0.147: v4(218.55,125.39) 218.55,125.48 arc(218.53,125.56) 218.49,125.63 218.41,125.71 arc(218.26,125.81) 218.09,125.84 U1.Y13
  SIG8 w0.112: v4(218.55,125.39) 218.55,125.64 arc(218.58,125.71) 218.65,125.74 218.87,125.74 arc(218.99,125.77) 219.09,125.84 arc(219.16,125.94) 219.18,126.06 219.18,126.43 arc(219.2,126.52) 219.25,126.6 219.29,126.64 arc(219.4,126.71) 219.54,126.74 225.62,126.74 arc(225.75,126.72) 225.85,126.64 arc(225.93,126.54) 225.95,126.41 225.95,126.23 arc(225.98,126.06) 226.08,125.92 226.1,125.9 arc(226.27,125.78) 226.47,125.74 231.72,125.74 231.81,125.65 231.84,125.65
  SIG8 w0.16: 231.84,125.65 233.25,125.65 arc(233.54,125.71) 233.79,125.87 234.56,126.65 arc(234.81,126.81) 235.1,126.87 242.19,126.87 arc(242.48,126.81) 242.73,126.65 264.89,104.49 arc(265.05,104.24) 265.11,103.95 265.11,73.73 264.86,73.48 264.86,72.97 265.11,72.72 265.11,72.21 264.86,71.96 264.86,71.45 265.11,71.19 265.11,70.55 arc(265.2,70.11) 265.45,69.74 267.9,67.29 arc(267.98,67.16) 268.01,67.02 268.01,61.76 arc(268.1,61.32) 268.35,60.95 269.95,59.35 arc(270.32,59.1) 270.76,59.01 272.39,59.01 arc(272.54,58.98) 272.66,58.9 272.75,58.82 arc(272.82,58.73) 272.87,58.63 arc(272.87,58.62) 272.88,58.61 arc(272.9,58.52) 272.91,58.42 272.91,58.15 arc(272.97,57.85) 273.14,57.59 273.4,57.34 arc(273.62,57) 273.7,56.61 YJ32.B24
FC44_RDN1: length 106.2
  TOP w0.147: U1.AA9 222.55,126.34 v4(222.55,126.29)
  SIG9 w0.112: 231.96,124.03 231.94,124.03 arc(231.83,123.96) 231.71,123.94 223.45,123.94 arc(223.35,123.96) 223.26,124.02 arc(223.2,124.1) 223.18,124.2 223.18,125.63 arc(223.16,125.75) 223.09,125.85 arc(222.99,125.92) 222.87,125.94 222.65,125.94 arc(222.58,125.97) 222.55,126.04 v4(222.55,126.29)
  SIG9 w0.16: 231.96,124.03 232.35,124.03 arc(232.45,124.03) 232.54,124.01 arc(232.73,123.93) 232.89,123.81 236.09,120.62 arc(236.33,120.45) 236.62,120.39 246,120.39 arc(246.44,120.31) 246.81,120.06 263.08,103.79 arc(263.32,103.42) 263.41,102.98 263.41,69.71 arc(263.44,69.56) 263.52,69.44 266.66,66.3 arc(266.91,65.93) 267,65.49 267,59.02 arc(267.06,58.73) 267.22,58.48 270.69,55.01 arc(270.86,54.9) 271.06,54.86 272.06,54.86 arc(272.3,54.76) 272.4,54.52 272.4,54.34 arc(272.36,54.14) 272.25,53.97 YJ32.B17
FC44_RDN2: length 111
  TOP w0.147: v4(220.55,125.39) 220.55,125.48 arc(220.53,125.56) 220.49,125.63 220.41,125.71 arc(220.26,125.81) 220.09,125.84 U1.Y11
  SIG8 w0.112: 231.94,123.65 231.91,123.65 231.82,123.75 221.42,123.75 arc(221.25,123.78) 221.11,123.87 arc(221.02,124.01) 220.99,124.18 220.99,125.63 arc(220.98,125.68) 220.95,125.71 arc(220.92,125.73) 220.88,125.74 220.65,125.74 arc(220.58,125.71) 220.55,125.64 v4(220.55,125.39)
  SIG8 w0.16: YJ32.B15 273.7,52.68 arc(273.63,53.01) 273.45,53.29 273.11,53.63 arc(272.96,53.84) 272.91,54.1 272.91,54.48 arc(272.91,54.54) 272.89,54.61 arc(272.89,54.61) 272.89,54.62 arc(272.85,54.7) 272.79,54.77 272.75,54.81 272.75,54.82 272.66,54.9 arc(272.54,54.98) 272.39,55.01 270.95,55.01 arc(270.51,55.1) 270.14,55.35 266.95,58.53 arc(266.7,58.91) 266.62,59.34 266.62,65.64 arc(266.59,65.79) 266.5,65.91 263.36,69.05 arc(263.12,69.42) 263.03,69.86 263.03,71.19 262.75,71.47 262.75,71.93 263.03,72.21 263.03,72.72 262.78,72.97 262.78,73.48 263.03,73.73 263.03,102.98 arc(262.97,103.28) 262.81,103.52 242.1,124.23 arc(241.85,124.4) 241.56,124.46 235.76,124.46 arc(235.47,124.4) 235.22,124.23 234.87,123.88 arc(234.62,123.71) 234.33,123.65 231.94,123.65
FC44_RDN3: length 100.8
  TOP w0.147: v4(224.55,126.29) 224.55,126.34 U1.AA7
  SIG9 w0.112: v4(224.55,126.29) 224.68,126.16 arc(224.92,126) 225.22,125.94 231.89,125.94 arc(232.01,125.96) 232.11,126.03
  SIG9 w0.16: YJ32.B22 272.25,57.97 arc(272.36,58.14) 272.4,58.34 272.4,58.52 arc(272.3,58.76) 272.06,58.86 271.05,58.86 arc(270.86,58.9) 270.69,59.01 268.49,61.21 arc(268.33,61.46) 268.27,61.75 268.27,67.32 arc(268.21,67.61) 268.04,67.86 265.72,70.18 arc(265.55,70.43) 265.49,70.72 265.49,103.95 arc(265.41,104.39) 265.16,104.76 247.7,122.22 arc(247.33,122.47) 246.89,122.55 244.19,122.55 arc(244.04,122.58) 243.92,122.66 242.64,123.94 arc(242.27,124.19) 241.83,124.28 235.13,124.28 arc(234.98,124.31) 234.86,124.39 233.55,125.7 arc(233.18,125.95) 232.74,126.03 232.11,126.03
FC44_RDP0: length 111.6
  TOP w0.147: v4(218.55,126.29) 218.55,126.34 U1.AA13
  SIG8 w0.112: v4(218.55,126.29) 218.55,126.04 arc(218.58,125.97) 218.65,125.94 218.87,125.94 arc(218.91,125.95) 218.95,125.97 arc(218.98,126.01) 218.99,126.06 218.99,126.43 arc(219.02,126.6) 219.12,126.74 219.15,126.78 arc(219.33,126.9) 219.54,126.94 225.62,126.94 arc(225.82,126.9) 225.99,126.78 arc(226.11,126.61) 226.15,126.41 226.15,126.23 226.15,126.23 arc(226.17,126.14) 226.22,126.05 226.24,126.03 arc(226.35,125.96) 226.47,125.94 231.72,125.94 231.81,126.03 231.84,126.03
  SIG8 w0.16: 231.84,126.03 233.25,126.03 arc(233.4,126.06) 233.52,126.14 234.29,126.92 arc(234.66,127.16) 235.1,127.25 242.19,127.25 arc(242.63,127.16) 243,126.92 265.16,104.76 arc(265.41,104.39) 265.49,103.95 265.49,70.55 arc(265.55,70.26) 265.72,70.01 268.17,67.56 arc(268.34,67.31) 268.39,67.02 268.39,61.76 arc(268.45,61.46) 268.62,61.22 270.22,59.62 arc(270.46,59.45) 270.76,59.39 272.39,59.39 arc(272.68,59.34) 272.93,59.17 272.99,59.11 arc(273.27,58.93) 273.6,58.86 274.3,58.86 arc(274.53,58.82) 274.72,58.69 arc(274.8,58.57) 274.83,58.43 274.83,58.39 arc(274.78,58.17) 274.65,57.97 YJ32.B25
FC44_RDP1: length 106.2
  TOP w0.147: v4(222.55,125.39) 222.55,125.48 arc(222.53,125.56) 222.49,125.62 222.41,125.7 arc(222.25,125.81) 222.07,125.84 U1.Y9
  SIG9 w0.112: v4(222.55,125.39) 222.55,125.64 arc(222.58,125.71) 222.65,125.74 222.87,125.74 arc(222.91,125.73) 222.95,125.71 arc(222.98,125.67) 222.99,125.63 222.99,124.2 arc(223.02,124.03) 223.12,123.88 arc(223.27,123.78) 223.45,123.74 231.74,123.74 arc(231.86,123.72) 231.96,123.65
  SIG9 w0.16: YJ32.B18 271.3,52.87 arc(271.27,53.02) 271.18,53.15 270.69,53.65 arc(270.56,53.84) 270.51,54.07 270.51,54.48 arc(270.51,54.53) 270.5,54.58 arc(270.49,54.6) 270.49,54.62 arc(270.45,54.7) 270.39,54.77 270.35,54.82 269.72,55.45 269.31,55.45 268.87,55.88 268.87,56.29 268.64,56.52 268.52,56.64 268.21,56.64 267.87,56.98 267.87,57.29 266.95,58.21 arc(266.7,58.58) 266.62,59.02 266.62,65.49 arc(266.56,65.78) 266.39,66.03 263.25,69.17 arc(263.09,69.41) 263.03,69.71 263.03,102.98 arc(262.97,103.28) 262.81,103.52 246.54,119.79 arc(246.29,119.95) 246,120.01 236.62,120.01 arc(236.19,120.1) 235.82,120.35 232.62,123.54 arc(232.54,123.6) 232.45,123.64 arc(232.4,123.65) 232.35,123.65 231.96,123.65
FC44_RDP2: length 111
  TOP w0.147: v4(220.55,126.29) 220.55,126.34 U1.AA11
  SIG8 w0.112: 231.94,124.04 231.91,124.04 231.82,123.94 221.42,123.94 arc(221.33,123.96) 221.25,124.01 arc(221.2,124.09) 221.18,124.18 221.18,125.63 arc(221.16,125.75) 221.09,125.85 arc(220.99,125.92) 220.88,125.94 220.65,125.94 arc(220.58,125.97) 220.55,126.04 v4(220.55,126.29)
  SIG8 w0.16: 231.94,124.04 234.33,124.04 arc(234.47,124.06) 234.6,124.15 234.95,124.5 arc(235.32,124.75) 235.76,124.84 241.56,124.84 arc(241.99,124.75) 242.36,124.5 263.08,103.79 arc(263.32,103.42) 263.41,102.98 263.41,69.86 arc(263.47,69.57) 263.63,69.32 266.77,66.18 arc(266.94,65.93) 267,65.64 267,59.34 arc(267.06,59.05) 267.22,58.8 270.41,55.62 arc(270.65,55.45) 270.95,55.39 272.39,55.39 arc(272.68,55.34) 272.93,55.17 273.14,54.96 arc(273.25,54.89) 273.38,54.86 274.38,54.86 arc(274.53,54.83) 274.66,54.75 274.67,54.73 arc(274.78,54.56) 274.82,54.36 arc(274.79,54.16) 274.67,53.99 274.5,53.82 YJ32.B14
FC44_RDP3: length 100.8
  TOP w0.147: U1.Y7 224.07,125.84 arc(224.25,125.81) 224.41,125.7 224.49,125.62 arc(224.53,125.56) 224.55,125.48 v4(224.55,125.39)
  SIG9 w0.112: v4(224.55,125.39) 224.68,125.52 arc(224.92,125.69) 225.22,125.74 231.84,125.74 arc(231.97,125.72) 232.07,125.65
  SIG9 w0.16: YJ32.B21 271.3,56.67 arc(271.23,57.01) 271.04,57.29 270.69,57.65 arc(270.56,57.84) 270.51,58.07 270.51,58.48 arc(270.51,58.54) 270.49,58.6 arc(270.49,58.61) 270.49,58.62 arc(270.45,58.7) 270.39,58.77 270.35,58.82 269.94,59.22 269.53,59.22 269.17,59.58 269.17,59.99 268.22,60.94 arc(267.97,61.31) 267.89,61.75 267.89,67.32 arc(267.86,67.46) 267.77,67.59 265.45,69.91 arc(265.2,70.28) 265.11,70.72 265.11,103.95 arc(265.05,104.24) 264.89,104.49 247.43,121.95 arc(247.18,122.11) 246.89,122.17 244.19,122.17 arc(243.9,122.23) 243.65,122.39 242.37,123.68 arc(242.12,123.84) 241.83,123.9 235.13,123.9 arc(234.83,123.96) 234.59,124.12 234.15,124.56 233.82,124.56 233.41,124.97 233.41,125.3 233.28,125.43 arc(233.03,125.59) 232.74,125.65 232.07,125.65
FC44_TDN0: length 109.4
  TOP w0.147: U1.AB4 227.55,127.34 v4(227.55,127.29)
  SIG6 w0.112: v4(227.55,127.29) 227.55,127.07 arc(227.59,126.98) 227.68,126.94 227.84,126.94 arc(227.96,126.92) 228.07,126.85 228.08,126.83 arc(228.15,126.72) 228.18,126.58 228.18,126.14 arc(228.2,126.06) 228.24,126 arc(228.31,125.95) 228.39,125.94 231.72,125.94 231.81,126.03 231.84,126.03
  SIG6 w0.16: 231.84,126.03 233.3,126.03 arc(233.44,126.06) 233.57,126.14 234.34,126.92 arc(234.71,127.16) 235.15,127.25 242.2,127.25 arc(242.64,127.16) 243.01,126.92 267.57,102.35 arc(267.82,101.98) 267.91,101.54 267.91,69.63 arc(267.96,69.34) 268.13,69.09 268.18,69.04 arc(268.35,68.79) 268.4,68.5 268.4,61.54 arc(268.46,61.25) 268.63,61 270.01,59.62 arc(270.26,59.45) 270.55,59.39 279.59,59.39 arc(279.88,59.34) 280.13,59.17 280.22,59.08 arc(280.46,58.92) 280.76,58.86 281.66,58.86 arc(281.9,58.76) 282,58.52 282,58.34 arc(281.96,58.14) 281.85,57.97 YJ32.B34
FC44_TDN1: length 109.7
  TOP w0.147: U1.W1 230.1,124.84 arc(230.42,124.71) v4(230.55,124.39)
  SIG7 w0.112: v4(230.55,124.39) 230.55,124.6 arc(230.59,124.7) 230.69,124.74 230.83,124.74 arc(230.88,124.73) 230.93,124.7 230.94,124.69 arc(230.97,124.64) 230.99,124.58 230.99,124.14 arc(231.02,123.99) 231.1,123.86 arc(231.23,123.77) 231.39,123.74 231.86,123.74 231.95,123.65 231.98,123.65
  SIG7 w0.16: YJ32.B3 283.3,52.8 arc(283.26,53.02) 283.13,53.2 282.68,53.65 arc(282.56,53.84) 282.51,54.07 282.51,54.48 arc(282.51,54.53) 282.5,54.57 arc(282.46,54.68) 282.39,54.77 282.35,54.82 282.26,54.9 arc(282.14,54.98) 281.99,55.01 270.62,55.01 arc(270.18,55.1) 269.81,55.35 267.04,58.12 arc(266.79,58.49) 266.7,58.93 266.7,67.51 266.5,67.71 266.5,68.17 266.7,68.37 266.7,68.83 266.54,69 266.54,69.53 266.7,69.7 266.7,71.09 arc(266.67,71.24) 266.59,71.36 266.27,71.68 266.07,71.68 265.66,72.1 265.66,72.29 263.35,74.6 arc(263.1,74.97) 263.02,75.41 263.02,102.68 arc(262.9,103.26) 262.56,103.76 242.12,124.2 arc(241.99,124.3) 241.82,124.33 238.73,124.33 arc(238.58,124.3) 238.46,124.22 238.11,123.87 arc(237.86,123.71) 237.57,123.65 231.98,123.65
FC44_TDN2: length 110.6
  TOP w0.147: U1.Y3 228.22,125.67 228.55,125.34 v4(228.55,125.29)
  SIG7 w0.112: 231.84,126.04 231.81,126.04 231.72,125.94 229.39,125.94 arc(229.23,125.91) 229.1,125.83 arc(229.02,125.7) 228.99,125.54 228.99,125.11 arc(228.97,125.04) 228.94,124.99 228.93,124.98 arc(228.88,124.95) 228.83,124.94 228.69,124.94 arc(228.59,124.98) 228.55,125.09 v4(228.55,125.29)
  SIG7 w0.16: YJ32.B37 284.25,57.97 arc(284.36,58.14) 284.4,58.34 284.4,58.52 arc(284.3,58.76) 284.06,58.86 283.04,58.86 arc(282.86,58.9) 282.7,59 282.53,59.17 arc(282.28,59.34) 281.99,59.39 270.81,59.39 arc(270.51,59.45) 270.27,59.62 268.63,61.26 arc(268.46,61.51) 268.4,61.8 268.4,74.39 arc(268.31,74.88) 268.03,75.29 265.67,77.65 arc(265.54,77.85) 265.49,78.08 265.49,103.63 arc(265.35,104.36) 264.93,104.98 243.26,126.66 arc(242.6,127.1) 241.82,127.25 234.54,127.25 arc(234.24,127.19) 234,127.03 233.12,126.15 arc(232.99,126.06) 232.85,126.04 231.84,126.04
FC44_TDN3: length 111.5
  TOP w0.147: U1.W5 226.1,124.84 arc(226.42,124.71) v4(226.55,124.39)
  SIG6 w0.112: 232.42,123.65 232.39,123.65 232.3,123.74 227.39,123.74 arc(227.23,123.77) 227.1,123.86 arc(227.02,123.99) 226.99,124.14 226.99,124.58 arc(226.97,124.64) 226.94,124.69 226.93,124.71 arc(226.88,124.73) 226.84,124.74 226.68,124.74 arc(226.59,124.71) 226.55,124.62 v4(226.55,124.39)
  SIG6 w0.16: YJ32.B6 280.9,52.83 arc(280.86,53.02) 280.75,53.18 280.28,53.65 arc(280.16,53.84) 280.11,54.07 280.11,54.48 arc(280.11,54.53) 280.1,54.59 arc(280.05,54.69) 279.99,54.77 279.95,54.82 279.86,54.9 arc(279.74,54.98) 279.59,55.01 270.48,55.01 arc(270.05,55.1) 269.67,55.35 267.04,57.98 arc(266.79,58.36) 266.7,58.79 266.7,66.52 arc(266.67,66.66) 266.59,66.79 265.45,67.93 arc(265.2,68.3) 265.11,68.74 265.11,69.22 264.94,69.39 264.94,69.97 265.11,70.14 265.11,70.62 264.94,70.79 264.94,71.37 265.11,71.54 265.11,72.03 264.94,72.2 264.94,72.78 265.11,72.95 265.11,100.9 arc(265.05,101.19) 264.89,101.43 242.09,124.23 arc(241.84,124.4) 241.55,124.46 236.55,124.46 arc(236.26,124.4) 236.01,124.23 235.65,123.87 arc(235.4,123.71) 235.11,123.65 232.42,123.65
FC44_TDP0: length 109.4
  TOP w0.147: U1.AA4 227.1,126.84 arc(227.42,126.71) v4(227.55,126.39)
  SIG6 w0.112: 231.84,125.65 231.81,125.65 231.72,125.74 228.39,125.74 arc(228.23,125.77) 228.1,125.86 arc(228.02,125.99) 227.99,126.14 227.99,126.58 arc(227.97,126.64) 227.94,126.69 227.93,126.71 arc(227.88,126.73) 227.84,126.74 227.68,126.74 arc(227.59,126.71) 227.55,126.62 v4(227.55,126.39)
  SIG6 w0.155: 280.13,57.94 arc(280.11,58) 280.11,58.07
  SIG6 w0.16: 231.84,125.65 233.3,125.65 arc(233.59,125.71) 233.84,125.87 234.61,126.65 arc(234.86,126.81) 235.15,126.87 242.2,126.87 arc(242.49,126.81) 242.74,126.65 267.3,102.08 arc(267.47,101.83) 267.53,101.54 267.53,73.84 267.36,73.67 267.36,73.08 267.53,72.91 267.53,72.43 267.36,72.26 267.36,71.68 267.53,71.51 267.53,71.03 267.36,70.86 267.36,70.28 267.53,70.11 267.53,69.63 arc(267.61,69.19) 267.86,68.82 267.91,68.77 arc(267.99,68.65) 268.02,68.5 268.02,61.54 arc(268.11,61.1) 268.36,60.73 269.74,59.35 arc(270.11,59.1) 270.55,59.01 279.59,59.01 arc(279.74,58.98) 279.86,58.9 279.95,58.82 279.99,58.77 arc(280.05,58.69) 280.09,58.59 arc(280.11,58.54) 280.11,58.48 280.11,58.07 ; YJ32.B33 280.9,56.75 arc(280.85,57.01) 280.7,57.24 280.5,57.44 280.29,57.64 arc(280.19,57.78) 280.13,57.94
FC44_TDP1: length 109.7
  TOP w0.147: v4(230.55,125.29) 230.55,125.34 U1.Y1
  SIG7 w0.112: v4(230.55,125.29) 230.55,125.1 arc(230.6,124.99) 230.71,124.94 230.83,124.94 arc(230.96,124.92) 231.07,124.84 231.08,124.83 arc(231.15,124.72) 231.18,124.58 231.18,124.14 arc(231.2,124.06) 231.24,124 arc(231.31,123.95) 231.39,123.94 231.86,123.94 231.95,124.03 231.98,124.03
  SIG7 w0.16: YJ32.B2 284.25,53.97 arc(284.36,54.14) 284.4,54.34 284.4,54.52 arc(284.3,54.76) 284.06,54.86 283.16,54.86 arc(282.86,54.92) 282.62,55.08 282.53,55.17 arc(282.28,55.34) 281.99,55.39 270.62,55.39 arc(270.32,55.45) 270.08,55.62 267.31,58.39 arc(267.14,58.63) 267.08,58.93 267.08,71.09 arc(267.03,71.38) 266.86,71.63 263.62,74.87 arc(263.46,75.12) 263.4,75.41 263.4,102.68 arc(263.25,103.41) 262.83,104.03 242.39,124.47 arc(242.13,124.65) 241.82,124.71 238.73,124.71 arc(238.44,124.65) 238.19,124.49 237.84,124.14 arc(237.72,124.06) 237.57,124.03 231.98,124.03
FC44_TDP2: length 110.6
  TOP w0.147: U1.W3 228.1,124.84 arc(228.42,124.71) v4(228.55,124.39)
  SIG7 w0.112: v4(228.55,124.39) 228.55,124.58 arc(228.6,124.7) 228.71,124.74 228.83,124.74 arc(228.96,124.77) 229.07,124.84 229.08,124.85 arc(229.15,124.97) 229.18,125.11 229.18,125.54 arc(229.2,125.62) 229.24,125.69 arc(229.31,125.73) 229.39,125.75 231.66,125.75 arc(231.71,125.74) 231.76,125.71 231.81,125.65 231.84,125.65
  SIG7 w0.16: YJ32.B36 283.3,56.77 arc(283.25,57.01) 283.11,57.22 282.69,57.65 arc(282.56,57.84) 282.51,58.07 282.51,58.48 arc(282.51,58.53) 282.5,58.58 arc(282.49,58.6) 282.49,58.62 arc(282.45,58.7) 282.39,58.77 282.35,58.82 282.26,58.9 arc(282.14,58.98) 281.99,59.01 270.81,59.01 arc(270.37,59.1) 270,59.35 268.36,60.99 arc(268.11,61.36) 268.02,61.8 268.02,73.07 267.88,73.21 267.88,73.8 268.02,73.94 268.02,74.39 arc(267.95,74.73) 267.76,75.02 267.27,75.52 266.98,75.52 266.66,75.84 266.66,76.13 266.33,76.45 266.05,76.45 265.72,76.77 265.72,77.06 265.4,77.38 arc(265.19,77.7) 265.11,78.08 265.11,103.63 arc(265,104.22) 264.66,104.72 242.99,126.39 arc(242.45,126.74) 241.82,126.87 234.54,126.87 arc(234.39,126.84) 234.27,126.76 233.39,125.88 arc(233.14,125.71) 232.85,125.65 231.84,125.65
FC44_TDP3: length 111.5
  TOP w0.147: U1.Y5 226.55,125.34 v4(226.55,125.29)
  SIG6 w0.112: v4(226.55,125.29) 226.55,125.07 arc(226.59,124.98) 226.68,124.94 226.84,124.94 arc(226.96,124.92) 227.07,124.85 227.08,124.83 arc(227.15,124.72) 227.18,124.58 227.18,124.14 arc(227.2,124.06) 227.24,124 arc(227.31,123.95) 227.39,123.94 232.3,123.94 232.39,124.03 232.42,124.03
  SIG6 w0.16: YJ32.B5 281.85,53.97 arc(281.96,54.14) 282,54.34 282,54.52 arc(281.9,54.76) 281.66,54.86 280.76,54.86 arc(280.46,54.92) 280.22,55.08 280.13,55.17 arc(279.88,55.34) 279.59,55.39 270.48,55.39 arc(270.19,55.45) 269.94,55.62 267.31,58.25 arc(267.14,58.5) 267.08,58.79 267.08,66.52 arc(267.03,66.81) 266.86,67.06 265.72,68.2 arc(265.55,68.45) 265.49,68.74 265.49,100.9 arc(265.41,101.33) 265.16,101.7 242.36,124.5 arc(241.99,124.75) 241.55,124.84 236.55,124.84 arc(236.11,124.75) 235.74,124.5 235.38,124.14 arc(235.25,124.06) 235.11,124.03 232.42,124.03
FC45_RDN0: length 106
  TOP w0.147: v4(218.55,129.29) 218.55,129.34 U1.AD13
  SIG8 w0.112: v4(218.55,129.29) 218.55,129.04 arc(218.58,128.97) 218.65,128.94 218.87,128.94 arc(218.91,128.95) 218.95,128.97 arc(218.98,129.01) 218.99,129.06 218.99,129.43 arc(219.02,129.6) 219.12,129.74 219.15,129.77 arc(219.33,129.9) 219.54,129.94 230.62,129.94 arc(230.74,129.96) 230.84,130.03 232.01,131.21 arc(232.24,131.36) 232.51,131.41 233.08,131.41 233.18,131.51
  SIG8 w0.16: 233.18,131.51 244.03,131.51 arc(244.47,131.42) 244.84,131.17 269.65,106.36 arc(269.9,105.99) 269.99,105.55 269.99,71.61 arc(270.05,71.32) 270.21,71.07 270.49,70.8 arc(270.79,70.35) 270.89,69.82 270.89,67.2 arc(270.99,66.96) 271.23,66.86 271.9,66.86 arc(272.1,66.82) 272.26,66.71 272.32,66.65 arc(272.38,66.56) 272.4,66.45 272.4,66.34 arc(272.36,66.14) 272.25,65.97 YJ32.A22
FC45_RDN1: length 106.1
  TOP w0.147: U1.AC9 222.07,128.84 arc(222.25,128.81) 222.41,128.7 222.49,128.62 arc(222.53,128.56) 222.55,128.48 v4(222.55,128.39)
  SIG9 w0.112: v4(222.55,128.39) 222.55,128.64 arc(222.58,128.71) 222.65,128.74 222.87,128.74 arc(222.91,128.73) 222.95,128.71 arc(222.98,128.67) 222.99,128.63 222.99,128.25 arc(223.02,128.08) 223.12,127.94 223.15,127.9 arc(223.33,127.78) 223.54,127.74 227.8,127.74 227.8,127.74 231.84,127.74 arc(231.94,127.72) 232.03,127.66 232.04,127.64 232.07,127.64
  SIG9 w0.16: 232.07,127.64 232.68,127.64 arc(232.97,127.7) 233.22,127.87 234.08,128.73 arc(234.33,128.9) 234.62,128.95 235.13,128.95 235.38,128.7 235.89,128.7 236.14,128.95 236.65,128.95 236.93,128.67 237.39,128.67 237.67,128.95 243.31,128.95 arc(243.46,128.92) 243.58,128.84 253.81,118.62 267.41,105.01 arc(267.5,104.89) 267.53,104.74 267.53,71.23 arc(267.61,70.79) 267.86,70.42 269.75,68.54 arc(269.91,68.29) 269.97,68 269.97,66.98 arc(269.92,66.75) 269.79,66.56 269.62,66.38 arc(269.37,66.01) 269.28,65.57 269.28,64.7 arc(269.37,64.26) 269.62,63.89 270.16,63.35 arc(270.53,63.1) 270.97,63.01 272.39,63.01 arc(272.54,62.98) 272.66,62.9 272.75,62.82 272.79,62.77 arc(272.85,62.7) 272.89,62.61 arc(272.89,62.6) 272.9,62.59 arc(272.9,62.58) 272.9,62.57 arc(272.91,62.53) 272.91,62.48 272.91,62.07 arc(272.96,61.84) 273.09,61.65 273.45,61.29 arc(273.63,61.01) 273.7,60.68 YJ32.A15
