# Allegro board RA-B6910-64C-MAC.brd (continued)
## Nets (continued)
FC_TRVDD0P8_3: C685.1 C686.1 C687.1 C688.1 C689.1 C690.1 C691.1 C692.1 C693.1 C694.1 C695.1 C696.1 C697.1 C698.1 C699.1 C700.1 C701.1 C702.1 C703.1 C704.1 C705.1 C706.1 C707.1 C708.1 C709.1 C710.1 C712.1 C713.1 C714.1 C715.1 C716.1 C717.1 C718.1 C719.1 C720.1 C721.1 C722.1 C723.1 C724.1 C725.1 C726.1 C727.1 C728.1 C729.1 C730.1 C731.1 C732.1 C733.1 C734.1 C735.1 C736.1 C737.1 C739.1 C740.1 C741.1 C742.1 C743.1 C744.1 C745.1 C746.1 C747.1 C2681.1 C2688.1 C2692.1 C2704.1 C2737.1 C2744.1 C2751.1 C2782.1 C2783.1 C2793.1 C2818.1 C2824.1 C2839.1 C2863.1 C2869.1 C2880.1 C2883.1 C2901.1 C2902.1 C2904.1 C2931.1 C2935.1 C2938.1 C2956.1 C2962.1 C2967.1 C2995.1 C3018.1 C3040.1 C3050.1 C3076.1 C3082.1 C3094.1 C3115.1 C3132.1 C3144.1 C3147.1 C3153.1 C3175.1 C3176.1 C3183.1 C3194.1 L77.1 L78.1 L79.1 U1.AL2(FC_TRVDD0P8_3_1) U1.AL11(FC_TRVDD0P8_3_2) U1.AL13(FC_TRVDD0P8_3_3) U1.AM2(FC_TRVDD0P8_3_4) U1.AP7(FC_TRVDD0P8_3_5) U1.AP9(FC_TRVDD0P8_3_6) U1.AP11(FC_TRVDD0P8_3_7) U1.AP13(FC_TRVDD0P8_3_8) U1.AR2(FC_TRVDD0P8_3_9) U1.AT2(FC_TRVDD0P8_3_10) U1.AU5(FC_TRVDD0P8_3_11) U1.AU7(FC_TRVDD0P8_3_12) U1.AU9(FC_TRVDD0P8_3_13) U1.AU11(FC_TRVDD0P8_3_14) U1.AU13(FC_TRVDD0P8_3_15) U1.AV5(FC_TRVDD0P8_3_16) U1.AY8(FC_TRVDD0P8_3_17) U1.AY9(FC_TRVDD0P8_3_18) U1.AY11(FC_TRVDD0P8_3_19) U1.AY13(FC_TRVDD0P8_3_20) U1.BA5(FC_TRVDD0P8_3_21) U1.BB5(FC_TRVDD0P8_3_22) U1.BC2(FC_TRVDD0P8_3_23) U1.BC8(FC_TRVDD0P8_3_24) U1.BC9(FC_TRVDD0P8_3_25) U1.BC11(FC_TRVDD0P8_3_26) U1.BC13(FC_TRVDD0P8_3_27) U1.BD2(FC_TRVDD0P8_3_28) U1.BF7(FC_TRVDD0P8_3_29) U1.BF9(FC_TRVDD0P8_3_30) U1.BF11(FC_TRVDD0P8_3_31) U1.BF13(FC_TRVDD0P8_3_32) U1.BG2(FC_TRVDD0P8_3_33) U1.BH2(FC_TRVDD0P8_3_34) U1.BJ5(FC_TRVDD0P8_3_35) U1.BJ7(FC_TRVDD0P8_3_36) U1.BJ9(FC_TRVDD0P8_3_37) U1.BJ11(FC_TRVDD0P8_3_38) U1.BJ13(FC_TRVDD0P8_3_39) U1.BK5(FC_TRVDD0P8_3_40) U1.BM7(FC_TRVDD0P8_3_41) U1.BM9(FC_TRVDD0P8_3_42) U1.BM11(FC_TRVDD0P8_3_43) U1.BM13(FC_TRVDD0P8_3_44) U1.BN5(FC_TRVDD0P8_3_45) U1.BP5(FC_TRVDD0P8_3_46) U1.BP20(FC_TRVDD0P8_3_47) U1.BP23(FC_TRVDD0P8_3_48) U1.BP26(FC_TRVDD0P8_3_49) U1.BR2(FC_TRVDD0P8_3_50) U1.BR7(FC_TRVDD0P8_3_51) U1.BR9(FC_TRVDD0P8_3_52) U1.BR11(FC_TRVDD0P8_3_53) U1.BR13(FC_TRVDD0P8_3_54) U1.BT2(FC_TRVDD0P8_3_55) U1.BT16(FC_TRVDD0P8_3_56) U1.BT17(FC_TRVDD0P8_3_57) U1.BT20(FC_TRVDD0P8_3_58) U1.BT23(FC_TRVDD0P8_3_59) U1.BT26(FC_TRVDD0P8_3_60) U1.BV13(FC_TRVDD0P8_3_61) U1.BV16(FC_TRVDD0P8_3_62) U1.BV17(FC_TRVDD0P8_3_63) U1.BV20(FC_TRVDD0P8_3_64) U1.BV23(FC_TRVDD0P8_3_65) U1.BV26(FC_TRVDD0P8_3_66) U1.BV29(FC_TRVDD0P8_3_67) U1.BW2(FC_TRVDD0P8_3_68) U1.BW10(FC_TRVDD0P8_3_69) U1.BW13(FC_TRVDD0P8_3_70) U1.BW26(FC_TRVDD0P8_3_71) U1.BY2(FC_TRVDD0P8_3_72) U1.BY16(FC_TRVDD0P8_3_73) U1.BY17(FC_TRVDD0P8_3_74) U1.BY20(FC_TRVDD0P8_3_75) U1.BY23(FC_TRVDD0P8_3_76) U1.CA5(FC_TRVDD0P8_3_77) U1.CA10(FC_TRVDD0P8_3_78) U1.CA13(FC_TRVDD0P8_3_79) U1.CB5(FC_TRVDD0P8_3_80) U1.CB23(FC_TRVDD0P8_3_81) U1.CB24(FC_TRVDD0P8_3_82) U1.CB27(FC_TRVDD0P8_3_83) U1.CB28(FC_TRVDD0P8_3_84) U1.CC10(FC_TRVDD0P8_3_85) U1.CC13(FC_TRVDD0P8_3_86) U1.CE5(FC_TRVDD0P8_3_87) U1.CE17(FC_TRVDD0P8_3_88) U1.CE18(FC_TRVDD0P8_3_89) U1.CE21(FC_TRVDD0P8_3_90) U1.CE22(FC_TRVDD0P8_3_91) U1.CF5(FC_TRVDD0P8_3_92) U1.CF8(FC_TRVDD0P8_3_93) U1.CF9(FC_TRVDD0P8_3_94) U1.CF11(FC_TRVDD0P8_3_95) U1.CF12(FC_TRVDD0P8_3_96) U1.CF14(FC_TRVDD0P8_3_97) U1.CF15(FC_TRVDD0P8_3_98)
FC_TVDD1P2_0: C2679.1 C2690.1 C2703.1 C2738.1 C2812.1 C2906.1 C2976.1 C3059.1 C3068.1 C3086.1 C3101.1 C3117.1 C3124.1 C3141.1 C3158.1 C3172.1 C3186.1 C3188.1 L24.1 U1.AP62(FC_TVDD1P2_0_1) U1.AW65(FC_TVDD1P2_0_2) U1.AY65(FC_TVDD1P2_0_3) U1.BE62(FC_TVDD1P2_0_4) U1.BF62(FC_TVDD1P2_0_5) U1.BL65(FC_TVDD1P2_0_6) U1.BM65(FC_TVDD1P2_0_7) U1.BU62(FC_TVDD1P2_0_8) U1.BV62(FC_TVDD1P2_0_9) U1.CB43(FC_TVDD1P2_0_10) U1.CB44(FC_TVDD1P2_0_11) U1.CC65(FC_TVDD1P2_0_12) U1.CD65(FC_TVDD1P2_0_13) U1.CE37(FC_TVDD1P2_0_14) U1.CE38(FC_TVDD1P2_0_15) U1.CE49(FC_TVDD1P2_0_16) U1.CE50(FC_TVDD1P2_0_17)
FC_TVDD1P2_1: C2668.1 C2674.1 C2729.1 C2767.1 C2850.1 C2918.1 C2939.1 C2955.1 C2975.1 C3026.1 C3031.1 C3062.1 C3065.1 C3089.1 C3096.1 C3133.1 C3138.1 C3178.1 L437.1 U1.AA62(FC_TVDD1P2_1_13) U1.AB62(FC_TVDD1P2_1_14) U1.AG65(FC_TVDD1P2_1_15) U1.AH65(FC_TVDD1P2_1_16) U1.AN62(FC_TVDD1P2_1_17) U1.B37(FC_TVDD1P2_1_1) U1.B38(FC_TVDD1P2_1_2) U1.B49(FC_TVDD1P2_1_3) U1.B50(FC_TVDD1P2_1_4) U1.C65(FC_TVDD1P2_1_5) U1.D65(FC_TVDD1P2_1_6) U1.E43(FC_TVDD1P2_1_7) U1.E44(FC_TVDD1P2_1_8) U1.J62(FC_TVDD1P2_1_9) U1.K62(FC_TVDD1P2_1_10) U1.R65(FC_TVDD1P2_1_11) U1.T65(FC_TVDD1P2_1_12)
FC_TVDD1P2_2: C203.1 C204.1 C205.1 C206.1 C207.1 C209.1 C212.1 C213.1 C215.1 C216.1 C219.1 C2664.1 C2706.1 C2743.1 C2816.1 C2856.1 C3002.1 C3179.1 L444.1 U1.AA5(FC_TVDD1P2_2_13) U1.AB5(FC_TVDD1P2_2_14) U1.AG2(FC_TVDD1P2_2_15) U1.AH2(FC_TVDD1P2_2_16) U1.AN5(FC_TVDD1P2_2_17) U1.B25(FC_TVDD1P2_2_1) U1.B26(FC_TVDD1P2_2_2) U1.C2(FC_TVDD1P2_2_3) U1.D2(FC_TVDD1P2_2_4) U1.E19(FC_TVDD1P2_2_5) U1.E20(FC_TVDD1P2_2_6) U1.E31(FC_TVDD1P2_2_7) U1.E32(FC_TVDD1P2_2_8) U1.J5(FC_TVDD1P2_2_9) U1.K5(FC_TVDD1P2_2_10) U1.R2(FC_TVDD1P2_2_11) U1.T2(FC_TVDD1P2_2_12)
FC_TVDD1P2_3: C226.1 C227.1 C2661.1 C2694.1 C2731.1 C2734.1 C2766.1 C2770.1 C2798.1 C2806.1 C2846.1 C2849.1 C2889.1 C2921.1 C2992.1 C3033.1 C3109.1 C3171.1 L445.1 U1.AP5(FC_TVDD1P2_3_1) U1.AW2(FC_TVDD1P2_3_2) U1.AY2(FC_TVDD1P2_3_3) U1.BE5(FC_TVDD1P2_3_4) U1.BF5(FC_TVDD1P2_3_5) U1.BL2(FC_TVDD1P2_3_6) U1.BM2(FC_TVDD1P2_3_7) U1.BU5(FC_TVDD1P2_3_8) U1.BV5(FC_TVDD1P2_3_9) U1.CB19(FC_TVDD1P2_3_10) U1.CB20(FC_TVDD1P2_3_11) U1.CC2(FC_TVDD1P2_3_12) U1.CD2(FC_TVDD1P2_3_13) U1.CE25(FC_TVDD1P2_3_14) U1.CE26(FC_TVDD1P2_3_15)
G_GPIO0: U1.T34(IP_G_GPIO0)
G_GPIO1: U1.J52(IP_G_GPIO1)
G_GPIO2: U1.U34(IP_G_GPIO2)
G_GPIO3: U1.J16(IP_G_GPIO3)
G_GPIO4: U1.W34(IP_G_GPIO4)
G_GPIO5: U1.P16(IP_G_GPIO5)
IMN1: D435.31(IMON) R3608.1 R3655.1
IMN2: D436.31(IMON) R3613.1 R3657.1
IMN3: D437.31(IMON) R3615.1 R3661.1
IMN4: D438.31(IMON) R3620.1 R3662.1
IMN5: D439.31(IMON) R3622.1 R3666.1
IMN6: D440.31(IMON) R3627.1 R3667.1
IMN7: D442.31(IMON) R3629.1 R3668.1
IMN8: D441.31(IMON) R3634.1 R3669.1
IMN9: D443.31(IMON) R3636.1 R3671.1
IMN10: D444.31(IMON) R3641.1 R3672.1
IMN11: D445.31(IMON) R3643.1 R3673.1
IMN12: D446.31(IMON) R3648.1 R3674.1
INTL0: R2590.2 U123.T2(PB3C/PB3C/PB4C)
INTL1: R2588.1 U123.D2(PL2D/PL4D/PL4D)
INTL2: R2586.2 U123.H4(PL6C/PL9C/PL10C)
INTL3: R2592.1 U123.L1(PL11A/PL16A/PL19A)
INTL4: R2626.2 U123.T3(PB6C/PB6A/PB7A)
INTL5: R2629.1 U123.P1(PL13D/PL18D/PL23D)
INTL6: R2637.2 U123.T9(PB16A/PB20A/PB23A || PCLKT2_1)
INTL7: R2628.1 U123.P7(PB9B/PB10B/PB13B)
INTL8: R2666.2 U123.T15(PB25C/PB30C/PB38C)
INTL9: R2667.1 U123.R11(PB22A/PB27A/PB35A)
INTL10: R2670.2 U123.P13(PB25B/PB30B/PB38B || SI/SISPI)
INTL11: R2673.1 U123.M15(PR13B/PR18B/PR23B)
INTL12: R2707.2 U123.H16(PR7B/PR10B/PR12B || PCLKC1_0)
INTL13: R2711.1 U123.F16(PR4B/PR6B/PR7B)
INTL14: R2706.2 U123.E3(PL2B/PL4B/PL4B || L_GPLLC_IN)
INTL15: R2710.1 U123.G6(PL3D/PL6D/PL6D)
INTL16: R2746.2 U124.D1(PL1B/PL3B/PL3B || L_GPLLC_FB)
INTL17: R2748.1 U124.C2(PL1D/PL2D/PL2D)
INTL18: R2754.2 U124.T2(PB3C/PB3C/PB4C)
INTL19: R2747.1 U124.E2(PL2A/PL4A/PL4A || L_GPLLT_IN)
INTL20: R2788.2 U124.K1(PL9B/PL13B/PL15B)
INTL21: R2792.1 U124.J2(PL9A/PL13A/PL15A)
INTL22: R2787.2 U124.P1(PL13D/PL18D/PL23D)
INTL23: R2791.1 U124.M2(PL14A/PL20A/PL25A)
INTL24: R2826.2 U124.R7(PB9A/PB10A/PB13A)
INTL25: R2828.1 U124.R6(PB6B/PB7B/PB9B)
INTL26: R2836.2 U124.R11(PB22A/PB27A/PB35A)
INTL27: R2827.1 U124.P9(PB16B/PB20B/PB23B || PCLKC2_1)
INTL28: R2866.2 U124.P13(PB25B/PB30B/PB38B || SI/SISPI)
INTL29: R2867.1 U124.N14(PR14B/PR19B/PR24B)
INTL30: R2870.2 U124.N7(PB9D/PB10D/PB13D)
INTL31: R2871.1 U124.G4(PL4D/PL7D/PL7D)
INTL32: R2609.1 U123.E1(PL3A/PL6A/PL6A || PCLKT5_0)
INTL33: R2613.2 U123.C2(PL1D/PL2D/PL2D)
INTL34: R2610.1 U123.J2(PL9A/PL13A/PL15A)
INTL35: R2605.2 U123.J1(PL7C/PL10C/PL12A || PCLKT4_0)
INTL36: R2647.1 U123.R1(PL14C/PL20C/PL25C)
INTL37: R2651.2 U123.N1(PL13B/PL19B/PL24B)
INTL38: R2648.1 U123.R7(PB9A/PB10A/PB13A)
INTL39: R2652.2 U123.T11(PB21A/PB24A/PB31A)
INTL40: R2693.1 U123.T10(PB18B/PB21B/PB26B)
INTL41: R2688.2 U123.T12(PB22B/PB27B/PB35B)
INTL42: R2687.1 U123.M16(PR12B/PR16B/PR21B)
INTL43: R2690.2 U123.M14(PR13A/PR18A/PR23A)
INTL44: R2728.1 U123.H15(PR6B/PR9B/PR11B DQS0N)
INTL45: R2731.2 U123.J15(PR9A/PR13A/PR16A DQS1)
INTL46: R2725.1 U123.E7(PT12B*/PT13B*/PT14B*)
INTL47: R2732.2 U123.F15(PR3B/PR5B/PR5B)
INTL48: R2767.1 U124.F10(PT21C/PT24C/PT32A*)
INTL49: R2771.2 U124.D2(PL2D/PL4D/PL4D)
INTL50: R2768.1 U124.E1(PL3A/PL6A/PL6A || PCLKT5_0)
INTL51: R2772.2 U124.R4(PB6D/PB6B/PB7B)
INTL52: R2805.1 U124.G2(PL5A/PL8A/PL9A)
INTL53: R2807.2 U124.G1(PL6A/PL9A/PL10A)
INTL54: R2806.1 U124.L1(PL11A/PL16A/PL19A)
INTL55: R2808.2 U124.P2(PL14D/PL20D/PL25D)
INTL56: R2847.1 U124.R8(PB11B/PB13B/PB16B || PCLKC2_0)
INTL57: R2849.2 U124.T6(PB8B/PB9B/PB12B || SO/SPISO)
INTL58: R2848.1 U124.P8(PB12A/PB15A/PB18A)
INTL59: R2850.2 U124.T12(PB22B/PB27B/PB35B)
INTL60: R2886.1 U124.R14(PB25D/PB30D/PB38D)
INTL61: R2889.2 U124.P11(PB21B/PB24B/PB31B)
INTL62: R2887.1 U124.G5(PL4C/PL7C/PL7C)
INTL63: R2890.2 U124.N6(PB8C/PB9C/PB10A)
IP_BS0_CLK: U1.BK50(IP_BS0_CLK)
IP_BS0_HB: U1.BM45(IP_BS0_HB)
IP_BS0_TC: U1.BM18(IP_BS0_TC)
IP_BS1_CLK: U1.BL17(IP_BS1_CLK)
IP_BS1_HB: U1.BK42(IP_BS1_HB)
IP_BS1_TC: U1.BK48(IP_BS1_TC)
IP_BSC_SCL0: R7.2 R15.2 R2074.1 U1.BK18(IP_BSC0_SCL)
IP_BSC_SCL1: R2075.1 U1.BL25(IP_BSC1_SCL)
IP_BSC_SCL2: R2076.1 U1.BM24(IP_BSC2_SCL)
IP_BSC_SDA0: R9.2 R16.2 R2071.1 U1.BM25(IP_BSC0_SDA)
IP_BSC_SDA1: R2072.1 U1.BK25(IP_BSC1_SDA)
IP_BSC_SDA2: R2073.1 U1.BM19(IP_BSC2_SDA)
IP_PLL_AVDD1P8: C79.1 C80.1 L422.1 U1.BL32(IP_PLL_AVDD1P8)
IREF1: C3800.1 C3801.1 C3815.1 C3816.1 C3823.1 C3824.1 C3838.1 C3839.1 C3846.1 C3847.1 C3861.1 C3862.1 C3869.1 C3870.1 C3884.1 C3885.1 C3892.1 C3893.1 C3907.1 C3908.1 C3915.1 C3916.1 C3930.1 C3931.1 C3938.2 C3939.2 C3941.2 C3944.2 C3945.1 C3946.2 C3947.2 D435.30(REFIN) D436.30(REFIN) D437.30(REFIN) D438.30(REFIN) D439.30(REFIN) D440.30(REFIN) D441.30(REFIN) D442.30(REFIN) D443.30(REFIN) D444.30(REFIN) D445.30(REFIN) D446.30(REFIN) R3607.1 R3612.1 R3614.1 R3619.1 R3621.1 R3626.1 R3628.1 R3633.1 R3635.1 R3640.1 R3642.1 R3647.1 R3670.1 U140.25(CSRTN6) U140.27(CSRTN5) U140.29(CSRTN4) U140.31(CSRTN3) U140.33(CSRTN2) U140.35(CSRTN1)
ISL68127_PG0: R3654.1 U124.K16(PR9B/PR13B/PR16B DQS1N) U140.16(PG0)
ISL68127_PG1: R3505.2 R3649.2 R3656.1 U124.J15(PR9A/PR13A/PR16A DQS1) U140.17(PG1)
ISL68127_SALRT: R3503.1 R3660.1 U124.H14(PR7A/PR10A/PR12A || PCLKT1_0) U140.20(SALRT)
ISL68127_TWARN: R3651.1 U124.H16(PR7B/PR10B/PR12B || PCLKC1_0) U140.15(TWARN)
JTAG_EN: Q40.3(C) R3227.2 U119.19(2\O\E\) U120.19(2\O\E\)
L1_RCVRD_CLK: U1.N52(L1_RCVRD_CLK)
L1_RCVRD_CLK_BKUP: U1.U51(L1_RCVRD_CLK_BKUP)
L1_RCVRD_CLK_VALID: U1.U48(L1_RCVRD_CLK_VALID)
L1_RCVRD_CLK_VALID_BKUP: U1.L52(L1_RCVRD_CLK_VALID_BKUP)
LED_CLK0: R3306.1 U1.BJ48(IP_LED0_CLK)
LED_CLK1: R3301.1 U1.BM15(IP_LED1_CLK)
LED_CLK2: R3393.2 U1.BL21(IP_LED2_CLK)
LED_CLK3: R3398.2 U1.BK46(IP_LED3_CLK)
LED_CLK4: U1.BK24(IP_LED4_CLK)
LED_DATA0: R3308.1 U1.BJ23(IP_LED0_DATA)
LED_DATA1: R3304.1 U1.BK49(IP_LED1_DATA)
LED_DATA2: R3392.2 U1.BK45(IP_LED2_DATA)
LED_DATA3: R3397.2 U1.BK41(IP_LED3_DATA)
LED_DATA4: U1.BM46(IP_LED4_DATA)
LINKACT0: D363.4 R2967.1 U123.J4(PL9D/PL13D/PL15D)
LINKACT1: D367.4 R2975.1 U123.K3(PL10A/PL14A/PL17A)
LINKACT2: D371.4 R2983.1 U123.L3(PL11B/PL16B/PL19B)
LINKACT3: D375.4 R2991.1 U123.H5(PL9C/PL13C/PL15C)
LINKACT4: D379.4 R2999.1 U123.G5(PL4C/PL7C/PL7C)
LINKACT5: D383.4 R3007.1 U123.J6(PL6D/PL9D/PL10D)
LINKACT6: D387.4 R3015.1 U123.L10(PB18D/PB21D/PB26D)
LINKACT7: D391.4 R3023.1 U123.L9(PB12D/PB15D/PB18D)
LINKACT8: D364.4 R2968.1 U123.L8(PB11D/PB12B/PB15B)
LINKACT9: D368.4 R2976.1 U123.L14(PR11B/PR15B/PR18B)
LINKACT10: D372.4 R2984.1 U123.K13(PR11C/PR15C/PR19C)
LINKACT11: D378.4 R2992.1 U123.R6(PB6B/PB7B/PB9B)
LINKACT12: D380.4 R3000.1 U123.P5(PB5B/PB4B/PB6B)
LINKACT13: D385.4 R3008.1 U123.T8(PB12B/PB15B/PB18B)
LINKACT14: D388.4 R3016.1 U123.N6(PB8C/PB9C/PB10A)
LINKACT15: D392.4 R3024.1 U123.M2(PL14A/PL20A/PL25A)
LINKACT16: D365.4 R2969.1 U124.M16(PR12B/PR16B/PR21B)
LINKACT17: D369.4 R2977.1 U124.G11(PR5C/PR8C/PR10C)
LINKACT18: D374.4 R2985.1 U124.K13(PR11C/PR15C/PR19C)
LINKACT19: D376.4 R2993.1 U124.E16(PR3A/PR5A/PR5A)
LINKACT20: D382.4 R3001.1 U124.K11(PR12C/PR16C/PR21C)
LINKACT21: D384.4 R3009.1 U124.M14(PR13A/PR18A/PR23A)
LINKACT22: D389.4 R3017.1 U124.L12(PR10D/PR14D/PR17D)
LINKACT23: D393.4 R3025.1 U124.M11(PB19D/PB23D/PB28B)
LINKACT24: D366.4 R2970.1 U124.N9(PB16D/PB18B/PB21B)
LINKACT25: D370.4 R2978.1 U124.T10(PB18B/PB21B/PB26B)
LINKACT26: D373.4 R2986.1 U124.G6(PL3D/PL6D/PL6D)
LINKACT27: D377.4 R2994.1 U124.L8(PB11D/PB12B/PB15B)
LINKACT28: D381.4 R3002.1 U124.J6(PL6D/PL9D/PL10D)
LINKACT29: D386.4 R3010.1 U124.L7(PB8D/PB9D/PB10B)
LINKACT30: D390.4 R3018.1 U124.M6(PB11C/PB12A/PB15A)
LINKACT31: D394.4 R3026.1 U124.H6(PL5D/PL8D/PL9D)
LINKACT32: D395.4 R3031.1 U123.J5(PL10C/PL14C/PL16C)
LINKACT33: D399.4 R3039.1 U123.H6(PL5D/PL8D/PL9D)
LINKACT34: D403.4 R3047.1 U123.H3(PL7A/PL10A/PL11A)
LINKACT35: D407.4 R3055.1 U123.L5(PL11D/PL16D/PL19D)
LINKACT36: D411.4 R3063.1 U123.K5(PL12C/PL17C/PL21C)
LINKACT37: D415.4 R3071.1 U123.F1(PL4B/PL7B/PL8B)
LINKACT38: D419.4 R3079.1 U123.P9(PB16B/PB20B/PB23B || PCLKC2_1)
LINKACT39: D423.4 R3087.1 U123.N10(PB19C/PB23C/PB28A)
LINKACT40: D396.4 R3032.1 U123.N11(PB21D/PB24D/PB31D)
LINKACT41: D400.4 R3040.1 U123.P8(PB12A/PB15A/PB18A)
LINKACT42: D404.4 R3048.1 U123.M8(PB16C/PB18A/PB21A)
LINKACT43: D410.4 R3056.1 U123.M6(PB11C/PB12A/PB15A)
LINKACT44: D412.4 R3064.1 U123.P6(PB8A/PB9A/PB12A || MCLK/CCLK)
LINKACT45: D416.4 R3072.1 U123.R4(PB6D/PB6B/PB7B)
LINKACT46: D420.4 R3080.1 U123.M3(PL13A/PL19A/PL24A)
LINKACT47: D424.4 R3088.1 U123.N7(PB9D/PB10D/PB13D)
LINKACT48: D397.4 R3033.1 U124.K15(PR10B/PR14B/PR17B)
LINKACT49: D402.4 R3041.1 U124.H12(PR5D/PR8D/PR10D)
LINKACT50: D405.4 R3049.1 U124.K14(PR10A/PR14A/PR17A)
LINKACT51: D409.4 R3057.1 U124.G15(PR5A/PR8A/PR9A)
LINKACT52: D413.4 R3065.1 U124.K12(PR11D/PR15D/PR19D)
LINKACT53: D418.4 R3073.1 U124.L14(PR11B/PR15B/PR18B)
LINKACT54: D421.4 R3081.1 U124.L13(PR12D/PR16D/PR21D)
LINKACT55: D425.4 R3089.1 U124.R12(PB25A/PB30A/PB38A || SN)
LINKACT56: D398.4 R3034.1 U124.M10(PB21C/PB24C/PB31C)
LINKACT57: D401.4 R3042.1 U124.L10(PB18D/PB21D/PB26D)
LINKACT58: D406.4 R3050.1 U124.L9(PB12D/PB15D/PB18D)
LINKACT59: D408.4 R3058.1 U124.M9(PB18C/PB21C/PB26C)
LINKACT60: D414.4 R3066.1 U124.K6(PL10D/PL14D/PL16D)
LINKACT61: D417.4 R3074.1 U124.M8(PB16C/PB18A/PB21A)
LINKACT62: D422.4 R3082.1 U124.L5(PL11D/PL16D/PL19D)
LINKACT63: D426.4 R3090.1 U124.J5(PL10C/PL14C/PL16C)
LM75_4A_INT#: R3246.2 R3406.2 U124.C13(PT24D/PT28D/PT36D || DONE)
LM75_48_INT#: R3248.2 R3402.2 U124.A13(PT24C/PT28C/PT36C || INITN)
LOCATOR_LED: D433.2(CATHODE) U124.F15(PR3B/PR5B/PR5B)
LPC_LAD0: C3487.1 R3269.2 R3386.2 YJ3.A1_1(SIDEBAND7_1)
LPC_LAD1: C3483.1 R3273.2 R3378.2 YJ3.B1_1(SIDEBAND3_1)
LPC_LAD2: C3484.1 R3266.2 R3370.2 YJ3.C1_1(SIDEBAND4_1)
LPC_LAD3: C3481.1 R3279.2 R3385.2 YJ3.B2_1(SIDEBAND1_1)
LPC_LCLK: C3482.1 R3277.1 R3373.2 YJ3.C2_1(SIDEBAND2_1)
LPC_LFRAME#: C3486.1 R3274.2 R3381.2 YJ3.D2_1(SIDEBAND6_1)
LPC_SERIRQ: C3485.1 R3276.2 R3383.2 YJ3.D1_1(SIDEBAND5_1)
LPMODE0: R2598.1 YJ21.A31(LPMODE_1)
LPMODE1: R2602.1 YJ21.B31(LPMODE_2)
LPMODE2: R2618.1 YJ22.D31(LPMODE_4)
LPMODE3: R2620.1 YJ22.C31(LPMODE_3)
LPMODE4: R2597.1 YJ21.C31(LPMODE_3)
LPMODE5: R2599.1 YJ21.D31(LPMODE_4)
LPMODE6: R2619.1 YJ22.B31(LPMODE_2)
LPMODE7: R2622.1 YJ22.A31(LPMODE_1)
LPMODE8: R2633.1 YJ23.A31(LPMODE_1)
LPMODE9: R2635.1 YJ23.B31(LPMODE_2)
LPMODE10: R2657.1 YJ24.D31(LPMODE_4)
LPMODE11: R2659.1 YJ24.C31(LPMODE_3)
LPMODE12: R2640.1 YJ23.C31(LPMODE_3)
LPMODE13: R2642.1 YJ23.D31(LPMODE_4)
LPMODE14: R2658.1 YJ24.B31(LPMODE_2)
LPMODE15: R2660.1 YJ24.A31(LPMODE_1)
LPMODE16: R2679.1 YJ25.A31(LPMODE_1)
LPMODE17: R2681.1 YJ25.B31(LPMODE_2)
LPMODE18: R2697.1 YJ26.D31(LPMODE_4)
LPMODE19: R2699.1 YJ26.C31(LPMODE_3)
LPMODE20: R2678.1 YJ25.C31(LPMODE_3)
LPMODE21: R2680.1 YJ25.D31(LPMODE_4)
LPMODE22: R2698.1 YJ26.B31(LPMODE_2)
LPMODE23: R2700.1 YJ26.A31(LPMODE_1)
LPMODE24: R2715.1 YJ27.A31(LPMODE_1)
LPMODE25: R2717.1 YJ27.B31(LPMODE_2)
LPMODE26: R2737.1 YJ28.D31(LPMODE_4)
LPMODE27: R2739.1 YJ28.C31(LPMODE_3)
LPMODE28: R2720.1 YJ27.C31(LPMODE_3)
LPMODE29: R2721.1 YJ27.D31(LPMODE_4)
LPMODE30: R2738.1 YJ28.B31(LPMODE_2)
LPMODE31: R2740.1 YJ28.A31(LPMODE_1)
LPMODE32: R2751.1 YJ29.A31(LPMODE_1)
LPMODE33: R2761.1 YJ29.B31(LPMODE_2)
LPMODE34: R2779.1 YJ30.D31(LPMODE_4)
LPMODE35: R2780.1 YJ30.C31(LPMODE_3)
LPMODE36: R2759.1 YJ29.C31(LPMODE_3)
LPMODE37: R2760.1 YJ29.D31(LPMODE_4)
LPMODE38: R2775.1 YJ30.B31(LPMODE_2)
LPMODE39: R2776.1 YJ30.A31(LPMODE_1)
LPMODE40: R2798.1 YJ31.A31(LPMODE_1)
LPMODE41: R2802.1 YJ31.B31(LPMODE_2)
LPMODE42: R2817.1 YJ32.D31(LPMODE_4)
LPMODE43: R2819.1 YJ32.C31(LPMODE_3)
LPMODE44: R2797.1 YJ31.C31(LPMODE_3)
LPMODE45: R2799.1 YJ31.D31(LPMODE_4)
LPMODE46: R2818.1 YJ32.B31(LPMODE_2)
LPMODE47: R2822.1 YJ32.A31(LPMODE_1)
LPMODE48: R2832.1 YJ33.A31(LPMODE_1)
LPMODE49: R2834.1 YJ33.B31(LPMODE_2)
LPMODE50: R2857.1 YJ34.D31(LPMODE_4)
LPMODE51: R2859.1 YJ34.C31(LPMODE_3)
LPMODE52: R2840.1 YJ33.C31(LPMODE_3)
LPMODE53: R2842.1 YJ33.D31(LPMODE_4)
LPMODE54: R2858.1 YJ34.B31(LPMODE_2)
LPMODE55: R2860.1 YJ34.A31(LPMODE_1)
LPMODE56: R2879.1 YJ35.A31(LPMODE_1)
LPMODE57: R2881.1 YJ35.B31(LPMODE_2)
LPMODE58: R2897.1 YJ36.D31(LPMODE_4)
LPMODE59: R2899.1 YJ36.C31(LPMODE_3)
LPMODE60: R2878.1 YJ35.C31(LPMODE_3)
LPMODE61: R2880.1 YJ35.D31(LPMODE_4)
LPMODE62: R2898.1 YJ36.B31(LPMODE_2)
LPMODE63: R2902.1 YJ36.A31(LPMODE_1)
MAC_BCM56970_RST#: R17.1 R3271.1 U1.K52(S\Y\S\_\R\S\T\)
MAC_GND_SENSE: R2196.1 U1.AR33(GND_SENSE)
MAC_GPIO0: U1.BJ25(IP_GPIO0)
MAC_GPIO1: U1.BK16(IP_GPIO1)
MAC_GPIO2: U1.BK15(IP_GPIO2)
MAC_GPIO3: U1.BM47(IP_GPIO3)
MAC_JTAG_TCK: R3132.2 R3216.2 U1.T33(JTCK)
MAC_JTAG_TDI: R2043.1 R3198.2 U1.V34(JTDI)
MAC_JTAG_TDO: R3225.2 U1.V33(JTDO) U120.11(2A3)
MAC_JTAG_TMS: R3133.1 R3218.2 U1.R18(JTMS)
MAC_JTAG_TRST: R2045.1 R2046.2 R3219.2 U1.U33(J\T\R\S\T\)
MAC_MC_RDN0: C3421.2 U1.BW34(MC_RD0N)
MAC_MC_RDN1: U1.BT34(MC_RD1N)
MAC_MC_RDN2: C3423.2 U1.BU33(MC_RD2N)
MAC_MC_RDN3: U1.BT32(MC_RD3N)
MAC_MC_RDP0: C3422.2 U1.BY34(MC_RD0P)
MAC_MC_RDP1: U1.BR34(MC_RD1P)
MAC_MC_RDP2: C3424.2 U1.BV33(MC_RD2P)
MAC_MC_RDP3: U1.BR32(MC_RD3P)
MAC_PCIE_INT#: R23.1 U1.M15(P\C\I\E\_\I\N\T\R\) U123.B1(PL1C/PL2C/PL2C)
MAC_PCIE_RST#: R28.2 R2042.1 R3280.2 U1.Y33(P\C\I\E\_\P\E\R\S\T\)
MAC_PCIE_RXN0: U1.BY32(PCIE_RD0N) X1.1 YJ3.B4_1(RX0+_1)
MAC_PCIE_RXN1: U1.BV31(PCIE_RD1N) X2.1 YJ3.A5_1(RX1-_1)
MAC_PCIE_RXN2: U1.BY30(PCIE_RD2N) X72.1 YJ3.B5_2(RX0-_2)
MAC_PCIE_RXN3: U1.BT30(PCIE_RD3N) X73.1 YJ3.A5_2(RX1-_2)
MAC_PCIE_RXP0: U1.BW32(PCIE_RD0P) X3.1 YJ3.B5_1(RX0-_1)
MAC_PCIE_RXP1: U1.BU31(PCIE_RD1P) X4.1 YJ3.A4_1(RX1+_1)
MAC_PCIE_RXP2: U1.BW30(PCIE_RD2P) X74.1 YJ3.B4_2(RX0+_2)
MAC_PCIE_RXP3: U1.BR30(PCIE_RD3P) X75.1 YJ3.A4_2(RX1+_2)
MAC_PCIE_TXN0: C2075.2 YJ3.D5_1(TX0-_1)
MAC_PCIE_TXN1: C2077.2 YJ3.C5_1(TX1-_1)
MAC_PCIE_TXN2: C2079.2 YJ3.D5_2(TX0-_2)
MAC_PCIE_TXN3: C2081.2 YJ3.C5_2(TX1-_2)
MAC_PCIE_TXP0: C2076.2 YJ3.D4_1(TX0+_1)
MAC_PCIE_TXP1: C2078.2 YJ3.C4_1(TX1+_1)
MAC_PCIE_TXP2: C2080.2 YJ3.D4_2(TX0+_2)
MAC_PCIE_TXP3: C2082.2 YJ3.C4_2(TX1+_2)
MAC_TS_GPIO0: U1.BK19(IP_TS_GPIO0)
MAC_TS_GPIO1: U1.BM22(IP_TS_GPIO1)
MAC_VDD_SENSE: R2195.1 U1.AR34(VDD_SENSE)
MAIN_PWR_EN: R3563.1 U123.P15(PR14C/PR20C/PR25C)
MASTER_CPLD_CLK_N: C3450.2 R3319.2 U123.A8(PT17B*/PT18B*/PT18B* || PCLKC0_1)
MASTER_CPLD_CLK_P: C3455.2 R3318.1 U123.C8(PT17A*/PT18A*/PT18A* || PCLKT0_1)
MASTER_CPLD_JTAG_TCK: R3210.2 R3310.2 U123.A7(PT16C/PT15C/PT17C || TCK)
MASTER_CPLD_JTAG_TDI: R3194.2 R3200.2 R3224.1 R3226.2 U123.A6(PT12D/PT13D/PT14D || TDI)
MASTER_CPLD_JTAG_TDO: R3289.1 R3384.2 U124.A6(PT12D/PT13D/PT14D || TDI)
MASTER_CPLD_JTAG_TMS: R3212.2 R3314.2 U123.B8(PT16D/PT15D/PT17D || TMS)
MC_LOS0: U1.U44(MC_LOS0)
MC_LOS1: U1.T46(MC_LOS1)
MC_PVDD0P8: C2899.1 C3055.1 L439.1 U1.BF36(MC_PVDD0P8)
MC_RDN0: C3421.1 YJ3.B8_2(RX2-_2)
MC_RDN2: C3423.1 YJ3.B7_1(RX2+_1)
MC_RDP0: C3422.1 YJ3.B7_2(RX2+_2)
MC_RDP2: C3424.1 YJ3.B8_1(RX2-_1)
MC_TDN0: U1.CF33(MC_TD0N) YJ3.D7_2(TX2+_2)
MC_TDN1: U1.CD34(MC_TD1N)
MC_TDN2: U1.CB33(MC_TD2N) YJ3.D7_1(TX2+_1)
MC_TDN3: U1.CE32(MC_TD3N)
MC_TDP0: U1.CF34(MC_TD0P) YJ3.D8_2(TX2-_2)
MC_TDP1: U1.CD33(MC_TD1P)
MC_TDP2: U1.CB34(MC_TD2P) YJ3.D8_1(TX2-_1)
MC_TDP3: U1.CE31(MC_TD3P)
MC_TRVDD0P8: C247.1 C2728.1 C2762.1 C2763.1 C3185.1 L430.1 U1.BR33(MC_TRVDD0P8_1) U1.BT33(MC_TRVDD0P8_2) U1.CE33(MC_TRVDD0P8_3) U1.CE34(MC_TRVDD0P8_4)
MDC0: R2059.1 U1.BK20(IP_MDC_0)
MDC1: R2060.1 U1.BM23(IP_MDC_1)
MDC2: R2061.1 U1.BM43(IP_MDC_2)
MDC3: R2062.1 U1.BL44(IP_MDC_3)
MDC4: R2063.1 U1.BK17(IP_MDC_4)
MDC5: R2064.1 U1.BK21(IP_MDC_5)
MDC6: R2065.1 U1.BM44(IP_MDC_6)
MDC7: R2066.1 U1.BM49(IP_MDC_7)
MDC8: R2067.1 U1.BM20(IP_MDC_8)
MDC9: R2068.1 U1.BK22(IP_MDC_9)
MDC10: R2069.1 U1.BL23(IP_MDC_10)
MDC11: R2070.1 U1.BK23(IP_MDC_11)
MDI_A+: RJ1.B1 T1.23(MX1+)
MDI_A-: RJ1.B2 T1.22(MX1-)
MDI_B+: RJ1.B3 T1.20(MX2+)
MDI_B-: RJ1.B6 T1.19(MX2-)
MDI_C+: RJ1.B4 T1.17(MX3+)
MDI_C-: RJ1.B5 T1.16(MX3-)
MDI_D+: RJ1.B7 T1.14(MX4+)
MDI_D-: RJ1.B8 T1.13(MX4-)
MDIO0: R2047.1 U1.BK47(IP_MDIO_0)
MDIO1: R2048.1 U1.BL42(IP_MDIO_1)
MDIO2: R2049.1 U1.BK43(IP_MDIO_2)
MDIO3: R2050.1 U1.BL50(IP_MDIO_3)
MDIO4: R2051.1 U1.BL48(IP_MDIO_4)
MDIO5: R2052.1 U1.BM50(IP_MDIO_5)
MDIO6: R2053.1 U1.BL46(IP_MDIO_6)
MDIO7: R2054.1 U1.BK44(IP_MDIO_7)
MDIO8: R2055.1 U1.BM21(IP_MDIO_8)
MDIO9: R2056.1 U1.BM48(IP_MDIO_9)
MDIO10: R2057.1 U1.BM42(IP_MDIO_10)
MDIO11: R2058.1 U1.BL19(IP_MDIO_11)
MGMT_LED_GREEN: J35.24 RJ1.10
MGMT_LED_LINKACT: J35.26 RJ1.12
MHOST0_BOOT_DEV: R19.2 R21.2 U1.T31(MHOST0_BOOT_DEV)
MHOST1_BOOT_DEV: R18.2 R20.2 U1.R32(MHOST1_BOOT_DEV)
MISC_PLL_AVDD1P8: C75.1 C76.1 L441.1 U1.AN52(MISC_PLL_AVDD1P8)
MODPRSL0: R2589.2 U123.G1(PL6A/PL9A/PL10A)
MODPRSL1: R2591.1 U123.E2(PL2A/PL4A/PL4A || L_GPLLT_IN)
MODPRSL2: R2585.2 U123.K2(PL10B/PL14B/PL17B)
MODPRSL3: R2587.1 U123.M1(PL12B/PL17B/PL22B || PCLKC3_0)
MODPRSL4: R2625.2 U123.T6(PB8B/PB9B/PB12B || SO/SPISO)
MODPRSL5: R2627.1 U123.T4(PB3B/PB3B/PB4B)
MODPRSL6: R2636.2 U123.R9(PB18A/PB21A/PB26A)
MODPRSL7: R2638.1 U123.R12(PB25A/PB30A/PB38A || SN)
MODPRSL8: R2665.2 U123.P11(PB21B/PB24B/PB31B)
MODPRSL9: R2672.1 U123.P10(PB19A/PB23A/PB29A)
MODPRSL10: R2669.2 U123.N14(PR14B/PR19B/PR24B)
MODPRSL11: R2671.1 U123.K15(PR10B/PR14B/PR17B)
MODPRSL12: R2705.2 U123.G16(PR6A/PR9A/PR11A DQS0)
MODPRSL13: R2709.1 U123.E16(PR3A/PR5A/PR5A)
MODPRSL14: R2718.2 U123.G4(PL4D/PL7D/PL7D)
MODPRSL15: R2708.1 U123.F4(PL3C/PL6C/PL6C)
MODPRSL16: R2745.2 U124.M15(PR13B/PR18B/PR23B)
MODPRSL17: R2756.1 U124.C11(PT21B*/PT24B*/PT28B*)
MODPRSL18: R2753.2 U124.F2(PL3B/PL6B/PL6B || PCLKC5_0)
MODPRSL19: R2755.1 U124.E3(PL2B/PL4B/PL4B || L_GPLLC_IN)
MODPRSL20: R2786.2 U124.K2(PL10B/PL14B/PL17B)
MODPRSL21: R2790.1 U124.H2(PL6B/PL9B/PL10B)
MODPRSL22: R2785.2 U124.N3(PL14B/PL20B/PL25B)
MODPRSL23: R2789.1 U124.N1(PL13B/PL19B/PL24B)
MODPRSL24: R2825.2 U124.P5(PB5B/PB4B/PB6B)
MODPRSL25: R2838.1 U124.T4(PB3B/PB3B/PB4B)
MODPRSL26: R2835.2 U124.T13(PB24B/PB29B/PB37B)
MODPRSL27: R2837.1 U124.R10(PB19B/PB23B/PB29B)
MODPRSL28: R2865.2 U124.T14(PB22D/PB26B/PB34B)
MODPRSL29: R2872.1 U124.N15(PR13C/PR18C/PR23C)
MODPRSL30: R2869.2 U124.P7(PB9B/PB10B/PB13B)
MODPRSL31: R2873.1 U124.L4(PL12D/PL17D/PL21D)
MODPRSL32: R2607.1 U123.G2(PL5A/PL8A/PL9A)
MODPRSL33: R2611.2 U123.D1(PL1B/PL3B/PL3B || L_GPLLC_FB)
MODPRSL34: R2608.1 U123.L2(PL12A/PL17A/PL22A || PCLKT3_0)
MODPRSL35: R2612.2 U123.H1(PL7B/PL10B/PL11B)
MODPRSL36: R2645.1 U123.P2(PL14D/PL20D/PL25D)
MODPRSL37: R2649.2 U123.R5(PB5A/PB4A/PB6A || CSSPIN)
MODPRSL38: R2646.1 U123.R10(PB19B/PB23B/PB29B)
MODPRSL39: R2650.2 U123.R8(PB11B/PB13B/PB16B || PCLKC2_0)
MODPRSL40: R2686.1 U123.R13(PB22C/PB26A/PB34A)
MODPRSL41: R2689.2 U123.R14(PB25D/PB30D/PB38D)
MODPRSL42: R2685.1 U123.L15(PR12A/PR16A/PR21A)
MODPRSL43: R2694.2 U123.P12(PB24A/PB29A/PB37A)
MODPRSL44: R2726.1 U123.H14(PR7A/PR10A/PR12A || PCLKT1_0)
MODPRSL45: R2729.2 U123.K14(PR10A/PR14A/PR17A)
MODPRSL46: R2727.1 U123.F5(PL5C/PL8C/PL9C)
MODPRSL47: R2730.2 U123.G15(PR5A/PR8A/PR9A)
MODPRSL48: R2765.1 U124.D11(PT21D/PT24D/PT32B*)
MODPRSL49: R2769.2 U124.B1(PL1C/PL2C/PL2C)
MODPRSL50: R2766.1 U124.D8(PT17C/PT19A*/PT21A*)
MODPRSL51: R2770.2 U124.P16(PR13D/PR18D/PR23D)
MODPRSL52: R2809.1 U124.G3(PL5B/PL8B/PL9B)
MODPRSL53: R2811.2 U124.F1(PL4B/PL7B/PL8B)
MODPRSL54: R2810.1 U124.N2(PL13C/PL18C/PL23C)
MODPRSL55: R2812.2 U124.M1(PL12B/PL17B/PL22B || PCLKC3_0)
MODPRSL56: R2845.1 U124.T3(PB6C/PB6A/PB7A)
MODPRSL57: R2851.2 U124.R3(PB3D/PB3D/PB4D)
MODPRSL58: R2846.1 U124.T9(PB16A/PB20A/PB23A || PCLKT2_1)
MODPRSL59: R2852.2 U124.T8(PB12B/PB15B/PB18B)
MODPRSL60: R2892.1 U124.R16(PR14D/PR20D/PR25D)
MODPRSL61: R2888.2 U124.P10(PB19A/PB23A/PB29A)
MODPRSL62: R2885.1 U124.L3(PL11B/PL16B/PL19B)
MODPRSL63: R2893.2 U124.J4(PL9D/PL13D/PL15D)
MODSELL0: R2600.2 YJ21.A8(MODSELL_1)
MODSELL1: R2604.2 YJ21.B8(MODSELL_2)
MODSELL2: R2623.2 YJ22.D8(MODSELL_4)
MODSELL3: R2621.2 YJ22.C8(MODSELL_3)
MODSELL4: R2603.2 YJ21.C8(MODSELL_3)
MODSELL5: R2601.2 YJ21.D8(MODSELL_4)
MODSELL6: R2606.2 YJ22.B8(MODSELL_2)
MODSELL7: R2624.2 YJ22.A8(MODSELL_1)
MODSELL8: R2634.2 YJ23.A8(MODSELL_1)
MODSELL9: R2644.2 YJ23.B8(MODSELL_2)
MODSELL10: R2661.2 YJ24.D8(MODSELL_4)
MODSELL11: R2664.2 YJ24.C8(MODSELL_3)
MODSELL12: R2641.2 YJ23.C8(MODSELL_3)
MODSELL13: R2643.2 YJ23.D8(MODSELL_4)
MODSELL14: R2663.2 YJ24.B8(MODSELL_2)
MODSELL15: R2662.2 YJ24.A8(MODSELL_1)
MODSELL16: R2668.2 YJ25.A8(MODSELL_1)
MODSELL17: R2683.2 YJ25.B8(MODSELL_2)
MODSELL18: R2701.2 YJ26.D8(MODSELL_4)
MODSELL19: R2704.2 YJ26.C8(MODSELL_3)
MODSELL20: R2682.2 YJ25.C8(MODSELL_3)
MODSELL21: R2684.2 YJ25.D8(MODSELL_4)
MODSELL22: R2702.2 YJ26.B8(MODSELL_2)
MODSELL23: R2703.2 YJ26.A8(MODSELL_1)
MODSELL24: R2716.2 YJ27.A8(MODSELL_1)
MODSELL25: R2724.2 YJ27.B8(MODSELL_2)
MODSELL26: R2741.2 YJ28.D8(MODSELL_4)
MODSELL27: R2744.2 YJ28.C8(MODSELL_3)
MODSELL28: R2723.2 YJ27.C8(MODSELL_3)
MODSELL29: R2722.2 YJ27.D8(MODSELL_4)
MODSELL30: R2743.2 YJ28.B8(MODSELL_2)
MODSELL31: R2742.2 YJ28.A8(MODSELL_1)
MODSELL32: R2752.2 YJ29.A8(MODSELL_1)
MODSELL33: R2763.2 YJ29.B8(MODSELL_2)
MODSELL34: R2782.2 YJ30.D8(MODSELL_4)
MODSELL35: R2784.2 YJ30.C8(MODSELL_3)
MODSELL36: R2762.2 YJ29.C8(MODSELL_3)
MODSELL37: R2764.2 YJ29.D8(MODSELL_4)
MODSELL38: R2781.2 YJ30.B8(MODSELL_2)
MODSELL39: R2783.2 YJ30.A8(MODSELL_1)
MODSELL40: R2800.2 YJ31.A8(MODSELL_1)
MODSELL41: R2804.2 YJ31.B8(MODSELL_2)
MODSELL42: R2823.2 YJ32.D8(MODSELL_4)
MODSELL43: R2821.2 YJ32.C8(MODSELL_3)
MODSELL44: R2803.2 YJ31.C8(MODSELL_3)
MODSELL45: R2801.2 YJ31.D8(MODSELL_4)
MODSELL46: R2820.2 YJ32.B8(MODSELL_2)
MODSELL47: R2824.2 YJ32.A8(MODSELL_1)
MODSELL48: R2833.2 YJ33.A8(MODSELL_1)
MODSELL49: R2844.2 YJ33.B8(MODSELL_2)
MODSELL50: R2861.2 YJ34.D8(MODSELL_4)
MODSELL51: R2864.2 YJ34.C8(MODSELL_3)
MODSELL52: R2841.2 YJ33.C8(MODSELL_3)
MODSELL53: R2843.2 YJ33.D8(MODSELL_4)
MODSELL54: R2863.2 YJ34.B8(MODSELL_2)
MODSELL55: R2862.2 YJ34.A8(MODSELL_1)
MODSELL56: R2868.2 YJ35.A8(MODSELL_1)
MODSELL57: R2883.2 YJ35.B8(MODSELL_2)
MODSELL58: R2903.2 YJ36.D8(MODSELL_4)
MODSELL59: R2901.2 YJ36.C8(MODSELL_3)
MODSELL60: R2882.2 YJ35.C8(MODSELL_3)
MODSELL61: R2884.2 YJ35.D8(MODSELL_4)
MODSELL62: R2900.2 YJ36.B8(MODSELL_2)
MODSELL63: R2904.2 YJ36.A8(MODSELL_1)
ONLINE_CPLD_UPDATE: C3493.1 R3197.1 YJ3.C2_2(SIDEBAND2_2)
ONLINE_TCK: C3495.1 R3191.2 U119.2(1A0) YJ3.C1_2(SIDEBAND4_2)
ONLINE_TDI: C3498.1 R3190.1 R3193.2 YJ3.A1_2(SIDEBAND7_2)
ONLINE_TDO: C3494.1 R3187.1 U119.6(1A2) YJ3.B1_2(SIDEBAND3_2)
ONLINE_TMS: C3492.1 R3188.1 U119.8(1A3) YJ3.B2_2(SIDEBAND1_2)
PCIE_PVDD0P8: C2903.1 C2984.1 L31.1 U1.BL37(PCIE_PVDD0P8)
PCIE_TRVDD0P8: C2660.1 C2712.1 C2974.1 C3074.1 C3106.1 L32.1 U1.BW31(PCIE_TRVDD0P8_1) U1.BY31(PCIE_TRVDD0P8_2) U1.CE29(PCIE_TRVDD0P8_3) U1.CE30(PCIE_TRVDD0P8_4)
PCIE_WAKE_L: R22.1 U1.U32(\P\C\I\E\_\W\A\K\E)
PH1: D435.9(SW) L492.2
PH2: D436.9(SW) L491.1
PH3: D437.9(SW) L494.2
PH4: D438.9(SW) L493.1
PH5: D439.9(SW) L496.2
PH6: D440.9(SW) L495.1
PH7: D442.9(SW) L498.2
PH8: D441.9(SW) L497.1
PH9: D443.9(SW) L500.2
PH10: D444.9(SW) L499.1
PH11: D445.9(SW) L502.2
PH12: D446.9(SW) L501.1
PVTMON_AVDD1P8: C91.1 C92.1 C93.1 C94.1 C95.1 C96.1 C97.1 C98.1 C99.1 L426.1 U1.AB33(PVTMON7_AVDD1P8) U1.AC52(PVTMON1_AVDD1P8) U1.AD33(PVTMON6_AVDD1P8) U1.AE15(PVTMON2_AVDD1P8) U1.BA36(PVTMON5_AVDD1P8) U1.BF34(PVTMON4_AVDD1P8) U1.BG15(PVTMON3_AVDD1P8) U1.BG52(PVTMON0_AVDD1P8)
PWM1: U134.3(PWMIN) U140.2(PWM1)
PWM2: U135.3(PWMIN) U140.3(PWM2)
PWM3: U136.3(PWMIN) U140.4(PWM3)
PWM4: U137.3(PWMIN) U140.5(PWM4)
PWM5: U138.3(PWMIN) U140.6(PWM5)
PWM6: U139.3(PWMIN) U140.7(PWM6)
PWR_STATUS_LED: D431.4 R3390.1 U124.H15(PR6B/PR9B/PR11B DQS0N)
REF_25M: R3181.2 U117.8(PRI_REFP)
RESCAL_AVDD0P8: C2689.1 C2951.1 C3042.1 C3083.1 C3177.1 L30.1 U1.AB52(RESCAL1_AVDD0P8) U1.AD15(RESCAL2_AVDD0P8) U1.BH15(RESCAL3_AVDD0P8) U1.BH52(RESCAL0_AVDD0P8)
RESETL0: R2596.2 R3344.2 YJ21.A9(RESETL_1)
RESETL1: R2594.1 R3345.1 YJ21.B9(RESETL_2)
RESETL2: R2595.2 R3282.1 YJ21.C9(RESETL_3)
RESETL3: R2593.1 R3327.1 YJ21.D9(RESETL_4)
RESETL4: R2632.2 R3328.2 YJ23.A9(RESETL_1)
RESETL5: R2631.1 R3332.2 YJ23.B9(RESETL_2)
RESETL6: R2639.2 R3331.2 YJ23.C9(RESETL_3)
RESETL7: R2630.1 R3336.1 YJ23.D9(RESETL_4)
RESETL8: R2677.2 R3351.2 YJ25.A9(RESETL_1)
RESETL9: R2675.1 R3334.2 YJ25.B9(RESETL_2)
RESETL10: R2676.2 R3338.2 YJ25.C9(RESETL_3)
RESETL11: R2674.1 R3340.2 YJ25.D9(RESETL_4)
RESETL12: R2714.2 R3337.1 YJ27.A9(RESETL_1)
RESETL13: R2713.1 R3348.1 YJ27.B9(RESETL_2)
RESETL14: R2719.2 R3264.2 YJ27.C9(RESETL_3)
RESETL15: R2712.1 R3252.2 YJ27.D9(RESETL_4)
RESETL16: R2750.2 R3396.1 YJ29.A9(RESETL_1)
RESETL17: R2749.1 R3407.1 YJ29.B9(RESETL_2)
RESETL18: R2758.2 R3412.1 YJ29.C9(RESETL_3)
RESETL19: R2757.1 R3414.1 YJ29.D9(RESETL_4)
RESETL20: R2796.2 R3431.1 YJ31.A9(RESETL_1)
RESETL21: R2794.1 R3434.2 YJ31.B9(RESETL_2)
RESETL22: R2795.2 R3420.1 YJ31.C9(RESETL_3)
RESETL23: R2793.1 R3417.1 YJ31.D9(RESETL_4)
RESETL24: R2830.2 R3422.2 YJ33.A9(RESETL_1)
RESETL25: R2831.1 R3418.2 YJ33.B9(RESETL_2)
RESETL26: R2839.2 R3424.2 YJ33.C9(RESETL_3)
RESETL27: R2829.1 R3432.2 YJ33.D9(RESETL_4)
RESETL28: R2877.2 R3423.1 YJ35.A9(RESETL_1)
RESETL29: R2875.1 R3429.1 YJ35.B9(RESETL_2)
RESETL30: R2876.2 R3388.1 YJ35.C9(RESETL_3)
RESETL31: R2874.1 R3371.1 YJ35.D9(RESETL_4)
RESETL32: R2616.1 R3349.2 YJ22.D9(RESETL_4)
RESETL33: R2614.2 R3347.1 YJ22.C9(RESETL_3)
RESETL34: R2617.1 R3333.2 YJ22.B9(RESETL_2)
RESETL35: R2615.2 R3270.1 YJ22.A9(RESETL_1)
RESETL36: R2655.1 R3330.1 YJ24.D9(RESETL_4)
RESETL37: R2653.2 R3329.1 YJ24.C9(RESETL_3)
RESETL38: R2656.1 R3346.2 YJ24.B9(RESETL_2)
RESETL39: R2654.2 R3342.2 YJ24.A9(RESETL_1)
RESETL40: R2696.1 R3335.1 YJ26.D9(RESETL_4)
RESETL41: R2695.2 R3326.2 YJ26.C9(RESETL_3)
RESETL42: R2692.1 R3341.1 YJ26.B9(RESETL_2)
RESETL43: R2691.2 R3350.2 YJ26.A9(RESETL_1)
RESETL44: R2735.1 R3339.1 YJ28.D9(RESETL_4)
RESETL45: R2733.2 R3343.1 YJ28.C9(RESETL_3)
RESETL46: R2736.1 R3253.2 YJ28.B9(RESETL_2)
RESETL47: R2734.2 R3261.2 YJ28.A9(RESETL_1)
RESETL48: R2778.1 R3433.1 YJ30.D9(RESETL_4)
RESETL49: R2777.2 R3394.2 YJ30.C9(RESETL_3)
RESETL50: R2774.1 R3430.2 YJ30.B9(RESETL_2)
RESETL51: R2773.2 R3419.2 YJ30.A9(RESETL_1)
RESETL52: R2815.1 R3436.2 YJ32.D9(RESETL_4)
RESETL53: R2813.2 R3435.1 YJ32.C9(RESETL_3)
RESETL54: R2816.1 R3413.2 YJ32.B9(RESETL_2)
RESETL55: R2814.2 R3416.2 YJ32.A9(RESETL_1)
RESETL56: R2855.1 R3415.2 YJ34.D9(RESETL_4)
RESETL57: R2853.2 R3428.2 YJ34.C9(RESETL_3)
RESETL58: R2856.1 R3426.2 YJ34.B9(RESETL_2)
RESETL59: R2854.2 R3421.1 YJ34.A9(RESETL_1)
RESETL60: R2895.1 R3427.1 YJ36.D9(RESETL_4)
RESETL61: R2894.2 R3425.1 YJ36.C9(RESETL_3)
RESETL62: R2896.1 R3362.1 YJ36.B9(RESETL_2)
RESETL63: R2891.2 R3356.1 YJ36.A9(RESETL_1)
RS232_UART0_SIN: R2032.2 RJ1.A6
RS232_UART0_SOUT: R2029.2 RJ1.A3
RST#_9548_0: R252.2 R3353.1 U12.3(R\E\S\E\T\)
RST#_9548_1: R205.2 R3360.1 U11.3(R\E\S\E\T\)
RST#_9548_2: R183.2 R3366.1 U10.3(R\E\S\E\T\)
RST#_9548_3: R285.2 R3354.1 U13.3(R\E\S\E\T\)
RST#_9548_4: R353.2 R3367.1 U16.3(R\E\S\E\T\)
RST#_9548_5: R352.2 R3368.1 U15.3(R\E\S\E\T\)
RST#_9548_6: R429.2 R3372.1 U17.3(R\E\S\E\T\)
RST#_9548_7: R440.2 R3375.1 U18.3(R\E\S\E\T\)
RX_OOBFC0_CLK: U1.U43(RX_OOBFC0_CLK)
RX_OOBFC0_DATA0: U1.T43(RX_OOBFC0_DATA0)
RX_OOBFC0_DATA1: U1.T45(RX_OOBFC0_DATA1)
RX_OOBFC0_SYNC: U1.U39(RX_OOBFC0_SYNC)
RX_OOBFC1_CLK: U1.R47(RX_OOBFC1_CLK)
RX_OOBFC1_DATA0: U1.R25(RX_OOBFC1_DATA0)
RX_OOBFC1_DATA1: U1.R30(RX_OOBFC1_DATA1)
RX_OOBFC1_SYNC: U1.T40(RX_OOBFC1_SYNC)
RX_OOBFC2_CLK: U1.V30(RX_OOBFC2_CLK)
RX_OOBFC2_DATA0: U1.T22(RX_OOBFC2_DATA0)
RX_OOBFC2_DATA1: U1.T24(RX_OOBFC2_DATA1)
RX_OOBFC2_SYNC: U1.T25(RX_OOBFC2_SYNC)
RX_OOBFC3_CLK: U1.V22(RX_OOBFC3_CLK)
RX_OOBFC3_DATA0: U1.U29(RX_OOBFC3_DATA0)
RX_OOBFC3_DATA1: U1.U30(RX_OOBFC3_DATA1)
RX_OOBFC3_SYNC: U1.V24(RX_OOBFC3_SYNC)
SECOND_CPLD_CLK_N: C3446.2 R3400.2 U124.A8(PT17B*/PT18B*/PT18B* || PCLKC0_1)
SECOND_CPLD_CLK_P: C3447.2 R3399.1 U124.C8(PT17A*/PT18A*/PT18A* || PCLKT0_1)
SECOND_CPLD_INT#: R3325.2 R3363.2 U123.C13(PT24D/PT28D/PT36D || DONE)
SECOND_CPLD_JTAG_TCK: R3211.2 R3391.2 U124.A7(PT16C/PT15C/PT17C || TCK)
SECOND_CPLD_JTAG_TDO: J34.3 R3199.2 R3382.1 U119.4(1A1) U119.15(2A1)
SECOND_CPLD_JTAG_TMS: R3213.2 R3395.2 U124.B8(PT16D/PT15D/PT17D || TMS)
SECOND_CPLD_OE_N: R3293.1 U124.E11(PT19D/PT22B*/PT26B*)
SECOND_CPLD_RST#: R3305.1 R3410.2 U124.E9(PT17D/PT19B*/PT21B*)
SPI2_CS#: U1.BK51(IP_SPI2_SS_N)
SPI2_MISO: U1.BM17(IP_SPI2_MISO)
SPI2_MOSI: U1.BL15(IP_SPI2_MOSI)
SPI2_SCK: U1.BP15(IP_SPI2_SCK)
SPS_FAULT0: D435.26(F\A\U\L\T\#\) D436.26(F\A\U\L\T\#\) D437.26(F\A\U\L\T\#\) D438.26(F\A\U\L\T\#\) D439.26(F\A\U\L\T\#\) D440.26(F\A\U\L\T\#\) D441.26(F\A\U\L\T\#\) D442.26(F\A\U\L\T\#\) D443.26(F\A\U\L\T\#\) D444.26(F\A\U\L\T\#\) R3652.2
SPS_FAULT1: D445.26(F\A\U\L\T\#\) D446.26(F\A\U\L\T\#\) R3653.2
SW_BOARD_INT#: C3491.1 R3302.1 YJ3.A2_2(SIDEBAND0_2)
SW_BOARD_PWR_EN: C3497.1 R3315.2 YJ3.D2_2(SIDEBAND6_2)
SW_BOARD_RST#: C3496.1 R3300.1 YJ3.D1_2(SIDEBAND5_2)
SW_RESERVE1: R26.2 R3675.2 YJ3.A8_2(RX3-_2)
SW_RESERVE2: R27.2 R3676.2 YJ3.A7_2(RX3+_2)
SWITCH: C3513.2 R3237.1 R3401.1 U124.F16(PR4B/PR6B/PR7B)
TCK: J33.1 R3203.2 TP2.1
TDI: J33.9 R3206.2 TP5.1
TEST1.24V: C3517.1 C3518.1 Q41.1(REF) Q41.2(CATHODE) R3239.2 R3240.2 R3307.2 X248.1
TMS: J33.5 R3204.2 TP4.1
TPS3823_MR_N: R3183.2 R3254.1 U118.3(M\R\)
TPS3823_RESET#: C3479.1 R3185.1 R3259.2 U123.D16(PR2A/PR3A/PR3A || R_GPLLT_IN**)
TPS3823_WDI: R3184.2 R3186.2 U123.D14(PR1A/PR2A/PR2A || R_GPLLT_FB**)
TS_PLL_AVDD1P8: C2739.1 C2940.1 L433.1 U1.BH32(TS_PLL_AVDD1P8)
TX_OOB_STATS_CLK: U1.R44(TX_OOB_STATS_CLK)
TX_OOB_STATS_DATA0: U1.R37(TX_OOB_STATS_DATA0)
TX_OOB_STATS_DATA1: U1.R22(TX_OOB_STATS_DATA1)
TX_OOB_STATS_DATA2: U1.U24(TX_OOB_STATS_DATA2)
TX_OOB_STATS_DATA3: U1.U25(TX_OOB_STATS_DATA3)
TX_OOB_STATS_SYNC: U1.R43(TX_OOB_STATS_SYNC)
TX_OOBFC0_CLK: U1.V45(TX_OOBFC0_CLK)
TX_OOBFC0_DATA0: U1.V43(TX_OOBFC0_DATA0)
TX_OOBFC0_DATA1: U1.V40(TX_OOBFC0_DATA1)
TX_OOBFC0_SYNC: U1.U45(TX_OOBFC0_SYNC)
TX_OOBFC1_CLK: U1.U47(TX_OOBFC1_CLK)
TX_OOBFC1_DATA0: U1.T37(TX_OOBFC1_DATA0)
TX_OOBFC1_DATA1: U1.T39(TX_OOBFC1_DATA1)
TX_OOBFC1_SYNC: U1.U40(TX_OOBFC1_SYNC)
TX_OOBFC2_CLK: U1.R31(TX_OOBFC2_CLK)
TX_OOBFC2_DATA0: U1.U26(TX_OOBFC2_DATA0)
TX_OOBFC2_DATA1: U1.R21(TX_OOBFC2_DATA1)
TX_OOBFC2_SYNC: U1.R42(TX_OOBFC2_SYNC)
TX_OOBFC3_CLK: U1.V28(TX_OOBFC3_CLK)
TX_OOBFC3_DATA0: U1.V25(TX_OOBFC3_DATA0)
TX_OOBFC3_DATA1: U1.U27(TX_OOBFC3_DATA1)
TX_OOBFC3_SYNC: U1.T27(TX_OOBFC3_SYNC)
UART0_SIN: J35.19 R2025.2 R2031.1
UART0_SIN_INS26330952: U1.BJ18(IP_UART0_SIN)
UART0_SOUT: J35.17 R2024.2 R2027.1
UART0_SOUT_INS26330952: U1.BM51(IP_UART0_SOUT)
UART1_SIN: U1.BJ46(IP_UART1_SIN)
UART1_SOUT: U1.BK52(IP_UART1_SOUT)
UART2_SIN: U1.BJ19(IP_UART2_SIN)
UART2_SOUT: U1.BJ44(IP_UART2_SOUT)
UART3_SIN: U1.BL52(IP_UART3_SIN)
UART3_SOUT: U1.BP16(IP_UART3_SOUT)
USB0_DM: D94.3 J29.2(D-) J35.15
USB0_DP: D94.4 J29.3(D+) J35.14
USB5V: C108.1 C109.1 C110.1 C3516.2 J35.21 J35.22 L222.2 R3238.2
VMON_PWM_OUT: C3521.1 R3278.1 U123.A10(PT19B*/PT21B*/PT25B*) U123.A12(PT22B*/PT25B*/PT33B*) U123.A14(PT22D/PT26B*/PT34B*) U123.A15(PT24B*/PT28B*/PT36B*) U123.B12(PT23B*/PT27B*/PT35B*) U123.C11(PT21B*/PT24B*/PT28B*) U123.D9(PT18B*/PT20B*/PT22B*) U123.D11(PT21D/PT24D/PT32B*) U123.E10(PT20B*/PT23B*/PT27B*) U123.E11(PT19D/PT22B*/PT26B*) U123.J13(PR9D/PR13D/PR16D) U123.J14(PR7D/PR10D/PR15B)
XIN: R3177.2 R3180.1 U117.12(SEC_REFN)
XOUT: R3178.1 R3182.1 U117.11(SEC_REFP)
ZQSFP+1_3.3V: C2147.2 C2148.1 C2151.2 C2152.1 C2155.2 C2156.1 C2159.2 C2160.1 C2179.2 C2180.1 C2183.2 C2184.1 C2186.2 C2187.1 C2190.2 C2191.1 C2211.2 C2212.1 C2215.2 C2216.1 C2217.2 C2218.1 C2221.2 C2222.1 C2243.2 C2244.1 C2247.2 C2248.2 C2249.1 C2252.2 C2253.1 C2254.1 C3671.2 C3674.1 C3675.1 C3676.1 C3677.1 C3678.1 C3679.1 C3680.1 C3681.1 L228.2 L229.2 L230.2 L231.2 L232.2 L233.2 L234.2 L235.2 L236.2 L237.2 L238.2 L239.2 L240.2 L241.2 L242.2 L243.2 L244.2 L245.2 L246.2 L247.2 L248.2 L249.2 L250.2 L251.2 L252.2 L253.2 L254.2 L255.2 L256.2 L257.2 L258.2 L259.2 L260.2 L261.2 L262.2 L263.2 L264.2 L265.2 L266.2 L267.2 L268.2 L269.2 L270.2 L271.2 L272.2 L273.2 L274.2 L275.2 L456.1 R246.1 R247.1 R248.1 R249.1 R250.1 R251.1 R320.1 R321.1 R322.1 R323.1 R324.1 R325.1 R326.1 R327.1 R328.1 R329.1 R330.1 R331.1 R332.1 R333.1 R334.1 R335.1 R1956.1 R1957.1 R2097.1 R2098.1 R2099.1 R2100.1 R2101.1 R2102.1 R2103.1 R2104.1 R2593.2 R2594.2 R2595.1 R2596.1 R2614.1 R2615.1 R2616.2 R2617.2 R2630.2 R2631.2 R2632.1 R2639.1 R2653.1 R2654.1 R2655.2 R2656.2 R3290.2 R3585.2 X263.1
ZQSFP+1_3.3V_EN: Q45.3(C) R3527.2 R3531.1 U130.2(EN)
ZQSFP+1_3.3V_PG: R3571.2 R3573.1 U130.3(PGOOD)
ZQSFP+2_3.3V: C2275.2 C2276.1 C2279.2 C2280.1 C2283.2 C2284.1 C2287.2 C2288.1 C2307.2 C2308.1 C2309.2 C2310.1 C2313.2 C2314.1 C2318.2 C2319.1 C2339.2 C2340.1 C2341.2 C2342.1 C2345.2 C2346.1 C2350.2 C2351.1 C2371.2 C2372.1 C2375.2 C2376.1 C2377.2 C2378.1 C2381.2 C2382.1 C3673.2 C3682.1 C3683.1 C3684.1 C3685.1 C3686.1 C3687.1 C3688.1 C3689.1 L276.2 L277.2 L278.2 L279.2 L280.2 L281.2 L282.2 L283.2 L284.2 L285.2 L286.2 L287.2 L288.2 L289.2 L290.2 L291.2 L292.2 L293.2 L294.2 L295.2 L296.2 L297.2 L298.2 L299.2 L300.2 L301.2 L302.2 L303.2 L304.2 L305.2 L306.2 L307.2 L308.2 L309.2 L310.2 L311.2 L312.2 L313.2 L314.2 L315.2 L316.2 L317.2 L318.2 L319.2 L320.2 L321.2 L322.2 L323.2 L455.1 R179.1 R180.1 R181.1 R182.1 R185.1 R186.1 R187.1 R188.1 R189.1 R190.1 R191.1 R192.1 R193.1 R194.1 R195.1 R196.1 R336.1 R337.1 R338.1 R339.1 R340.1 R341.1 R342.1 R343.1 R344.1 R345.1 R346.1 R347.1 R348.1 R349.1 R350.1 R351.1 R2674.2 R2675.2 R2676.1 R2677.1 R2691.1 R2692.2 R2695.1 R2696.2 R2712.2 R2713.2 R2714.1 R2719.1 R2733.1 R2734.1 R2735.2 R2736.2 R3311.2 R3584.2 X262.1
ZQSFP+2_3.3V_EN: Q48.3(C) R3538.2 R3542.1 U131.2(EN)
ZQSFP+2_3.3V_PG: R3570.2 R3572.1 U131.3(PGOOD)
ZQSFP+3_3.3V: C2403.2 C2404.1 C2406.2 C2407.1 C2410.2 C2411.1 C2414.2 C2415.1 C2435.2 C2436.1 C2439.2 C2440.1 C2442.2 C2443.1 C2446.2 C2447.1 C2467.2 C2468.1 C2469.2 C2470.1 C2473.2 C2474.1 C2478.2 C2479.1 C2499.2 C2500.1 C2501.2 C2502.1 C2505.2 C2506.1 C2510.2 C2511.1 C3724.2 C3725.1 C3726.1 C3727.1 C3728.1 C3729.1 C3730.1 C3731.1 C3732.1 L324.2 L325.2 L326.2 L327.2 L328.2 L329.2 L330.2 L331.2 L332.2 L333.2 L334.2 L335.2 L336.2 L337.2 L338.2 L339.2 L340.2 L341.2 L342.2 L343.2 L344.2 L345.2 L346.2 L347.2 L348.2 L349.2 L350.2 L351.2 L352.2 L353.2 L354.2 L355.2 L356.2 L357.2 L358.2 L359.2 L360.2 L361.2 L362.2 L363.2 L364.2 L365.2 L366.2 L367.2 L368.2 L369.2 L370.2 L371.2 L458.1 R163.1 R164.1 R165.1 R166.1 R167.1 R168.1 R169.1 R170.1 R171.1 R172.1 R173.1 R174.1 R175.1 R176.1 R177.1 R178.1 R402.1 R403.1 R404.1 R405.1 R406.1 R407.1 R408.1 R409.1 R410.1 R411.1 R412.1 R413.1 R414.1 R415.1 R416.1 R417.1 R2749.2 R2750.1 R2757.2 R2758.1 R2773.1 R2774.2 R2777.1 R2778.2 R2793.2 R2794.2 R2795.1 R2796.1 R2813.1 R2814.1 R2815.2 R2816.2 R3288.1 R3604.2 X268.1
ZQSFP+3_3.3V_EN: Q55.3(C) R3556.2 R3562.1 U133.2(EN)
ZQSFP+3_3.3V_PG: R3592.2 R3593.1 U133.3(PGOOD)
ZQSFP+4_3.3V: C2531.2 C2532.1 C2535.2 C2536.1 C2537.2 C2538.1 C2541.2 C2542.1 C2563.2 C2564.1 C2567.2 C2568.2 C2569.1 C2572.2 C2573.1 C2574.1 C2595.2 C2596.1 C2599.2 C2600.1 C2603.2 C2604.1 C2607.2 C2608.1 C2627.2 C2628.1 C2629.2 C2630.1 C2633.2 C2634.1 C2638.2 C2639.1 C3713.2 C3714.1 C3715.1 C3716.1 C3717.1 C3718.1 C3719.1 C3720.1 C3721.1 L372.2 L373.2 L374.2 L375.2 L376.2 L377.2 L378.2 L379.2 L380.2 L381.2 L382.2 L383.2 L384.2 L385.2 L386.2 L387.2 L388.2 L389.2 L390.2 L391.2 L392.2 L393.2 L394.2 L395.2 L396.2 L397.2 L398.2 L399.2 L400.2 L401.2 L402.2 L403.2 L404.2 L405.2 L406.2 L407.2 L408.2 L409.2 L410.2 L411.2 L412.2 L413.2 L414.2 L415.2 L416.2 L417.2 L418.2 L419.2 L457.1 R269.1 R270.1 R271.1 R272.1 R273.1 R274.1 R275.1 R276.1 R277.1 R278.1 R279.1 R280.1 R281.1 R282.1 R283.1 R284.1 R418.1 R419.1 R420.1 R421.1 R422.1 R423.1 R424.1 R425.1 R426.1 R427.1 R428.1 R435.1 R436.1 R437.1 R438.1 R439.1 R2829.2 R2830.1 R2831.2 R2839.1 R2853.1 R2854.1 R2855.2 R2856.2 R2874.2 R2875.2 R2876.1 R2877.1 R2891.1 R2894.1 R2895.2 R2896.2 R3283.1 R3601.2 X266.1
ZQSFP+4_3.3V_EN: Q57.3(C) R3567.2 R3569.1 U132.2(EN)
ZQSFP+4_3.3V_PG: R3588.2 R3589.1 U132.3(PGOOD)
ZQSFP+_SCL_0: R247.2 U12.5(SC0) YJ21.A11(SCL_1)
ZQSFP+_SCL_1: R249.2 U12.7(SC1) YJ21.B11(SCL_2)
ZQSFP+_SCL_2: R251.2 U12.9(SC2) YJ21.C11(SCL_3)
ZQSFP+_SCL_3: R1957.2 U12.11(SC3) YJ21.D11(SCL_4)
ZQSFP+_SCL_4: R2098.2 U12.14(SC4) YJ23.A11(SCL_1)
ZQSFP+_SCL_5: R2100.2 U12.16(SC5) YJ23.B11(SCL_2)
ZQSFP+_SCL_6: R2102.2 U12.18(SC6) YJ23.C11(SCL_3)
ZQSFP+_SCL_7: R2104.2 U12.20(SC7) YJ23.D11(SCL_4)
ZQSFP+_SCL_8: R186.2 U11.5(SC0) YJ25.A11(SCL_1)
ZQSFP+_SCL_9: R188.2 U11.7(SC1) YJ25.B11(SCL_2)
ZQSFP+_SCL_10: R190.2 U11.9(SC2) YJ25.C11(SCL_3)
ZQSFP+_SCL_11: R180.2 U11.11(SC3) YJ25.D11(SCL_4)
ZQSFP+_SCL_12: R182.2 U11.14(SC4) YJ27.A11(SCL_1)
ZQSFP+_SCL_13: R192.2 U11.16(SC5) YJ27.B11(SCL_2)
ZQSFP+_SCL_14: R194.2 U11.18(SC6) YJ27.C11(SCL_3)
ZQSFP+_SCL_15: R196.2 U11.20(SC7) YJ27.D11(SCL_4)
ZQSFP+_SCL_16: R164.2 U10.5(SC0) YJ29.A11(SCL_1)
ZQSFP+_SCL_17: R166.2 U10.7(SC1) YJ29.B11(SCL_2)
ZQSFP+_SCL_18: R168.2 U10.9(SC2) YJ29.C11(SCL_3)
ZQSFP+_SCL_19: R170.2 U10.11(SC3) YJ29.D11(SCL_4)
ZQSFP+_SCL_20: R172.2 U10.14(SC4) YJ31.A11(SCL_1)
ZQSFP+_SCL_21: R174.2 U10.16(SC5) YJ31.B11(SCL_2)
ZQSFP+_SCL_22: R176.2 U10.18(SC6) YJ31.C11(SCL_3)
ZQSFP+_SCL_23: R178.2 U10.20(SC7) YJ31.D11(SCL_4)
ZQSFP+_SCL_24: R270.2 U13.5(SC0) YJ33.A11(SCL_1)
ZQSFP+_SCL_25: R272.2 U13.7(SC1) YJ33.B11(SCL_2)
ZQSFP+_SCL_26: R274.2 U13.9(SC2) YJ33.C11(SCL_3)
ZQSFP+_SCL_27: R276.2 U13.11(SC3) YJ33.D11(SCL_4)
ZQSFP+_SCL_28: R278.2 U13.14(SC4) YJ35.A11(SCL_1)
ZQSFP+_SCL_29: R280.2 U13.16(SC5) YJ35.B11(SCL_2)
ZQSFP+_SCL_30: R282.2 U13.18(SC6) YJ35.C11(SCL_3)
ZQSFP+_SCL_31: R284.2 U13.20(SC7) YJ35.D11(SCL_4)
ZQSFP+_SCL_32: R321.2 U16.5(SC0) YJ22.D11(SCL_4)
ZQSFP+_SCL_33: R323.2 U16.7(SC1) YJ22.C11(SCL_3)
ZQSFP+_SCL_34: R325.2 U16.9(SC2) YJ22.B11(SCL_2)
ZQSFP+_SCL_35: R327.2 U16.11(SC3) YJ22.A11(SCL_1)
ZQSFP+_SCL_36: R329.2 U16.14(SC4) YJ24.D11(SCL_4)
ZQSFP+_SCL_37: R331.2 U16.16(SC5) YJ24.C11(SCL_3)
ZQSFP+_SCL_38: R333.2 U16.18(SC6) YJ24.B11(SCL_2)
ZQSFP+_SCL_39: R335.2 U16.20(SC7) YJ24.A11(SCL_1)
ZQSFP+_SCL_40: R337.2 U15.5(SC0) YJ26.D11(SCL_4)
ZQSFP+_SCL_41: R339.2 U15.7(SC1) YJ26.C11(SCL_3)
ZQSFP+_SCL_42: R341.2 U15.9(SC2) YJ26.B11(SCL_2)
ZQSFP+_SCL_43: R343.2 U15.11(SC3) YJ26.A11(SCL_1)
ZQSFP+_SCL_44: R345.2 U15.14(SC4) YJ28.D11(SCL_4)
ZQSFP+_SCL_45: R347.2 U15.16(SC5) YJ28.C11(SCL_3)
ZQSFP+_SCL_46: R349.2 U15.18(SC6) YJ28.B11(SCL_2)
ZQSFP+_SCL_47: R351.2 U15.20(SC7) YJ28.A11(SCL_1)
ZQSFP+_SCL_48: R403.2 U17.5(SC0) YJ30.D11(SCL_4)
ZQSFP+_SCL_49: R405.2 U17.7(SC1) YJ30.C11(SCL_3)
ZQSFP+_SCL_50: R407.2 U17.9(SC2) YJ30.B11(SCL_2)
ZQSFP+_SCL_51: R409.2 U17.11(SC3) YJ30.A11(SCL_1)
ZQSFP+_SCL_52: R411.2 U17.14(SC4) YJ32.D11(SCL_4)
ZQSFP+_SCL_53: R413.2 U17.16(SC5) YJ32.C11(SCL_3)
ZQSFP+_SCL_54: R415.2 U17.18(SC6) YJ32.B11(SCL_2)
ZQSFP+_SCL_55: R417.2 U17.20(SC7) YJ32.A11(SCL_1)
ZQSFP+_SCL_56: R419.2 U18.5(SC0) YJ34.D11(SCL_4)
ZQSFP+_SCL_57: R435.2 U18.7(SC1) YJ34.C11(SCL_3)
ZQSFP+_SCL_58: R422.2 U18.9(SC2) YJ34.B11(SCL_2)
ZQSFP+_SCL_59: R424.2 U18.11(SC3) YJ34.A11(SCL_1)
ZQSFP+_SCL_60: R426.2 U18.14(SC4) YJ36.D11(SCL_4)
ZQSFP+_SCL_61: R437.2 U18.16(SC5) YJ36.C11(SCL_3)
ZQSFP+_SCL_62: R439.2 U18.18(SC6) YJ36.B11(SCL_2)
ZQSFP+_SCL_63: R428.2 U18.20(SC7) YJ36.A11(SCL_1)
ZQSFP+_SDA_0: R246.2 U12.4(SD0) YJ21.A12(SDA_1)
ZQSFP+_SDA_1: R248.2 U12.6(SD1) YJ21.B12(SDA_2)
ZQSFP+_SDA_2: R250.2 U12.8(SD2) YJ21.C12(SDA_3)
ZQSFP+_SDA_3: R1956.2 U12.10(SD3) YJ21.D12(SDA_4)
ZQSFP+_SDA_4: R2097.2 U12.13(SD4) YJ23.A12(SDA_1)
ZQSFP+_SDA_5: R2099.2 U12.15(SD5) YJ23.B12(SDA_2)
ZQSFP+_SDA_6: R2101.2 U12.17(SD6) YJ23.C12(SDA_3)
ZQSFP+_SDA_7: R2103.2 U12.19(SD7) YJ23.D12(SDA_4)
ZQSFP+_SDA_8: R185.2 U11.4(SD0) YJ25.A12(SDA_1)
ZQSFP+_SDA_9: R187.2 U11.6(SD1) YJ25.B12(SDA_2)
ZQSFP+_SDA_10: R189.2 U11.8(SD2) YJ25.C12(SDA_3)
ZQSFP+_SDA_11: R179.2 U11.10(SD3) YJ25.D12(SDA_4)
ZQSFP+_SDA_12: R181.2 U11.13(SD4) YJ27.A12(SDA_1)
ZQSFP+_SDA_13: R191.2 U11.15(SD5) YJ27.B12(SDA_2)
ZQSFP+_SDA_14: R193.2 U11.17(SD6) YJ27.C12(SDA_3)
ZQSFP+_SDA_15: R195.2 U11.19(SD7) YJ27.D12(SDA_4)
ZQSFP+_SDA_16: R163.2 U10.4(SD0) YJ29.A12(SDA_1)
ZQSFP+_SDA_17: R165.2 U10.6(SD1) YJ29.B12(SDA_2)
ZQSFP+_SDA_18: R167.2 U10.8(SD2) YJ29.C12(SDA_3)
ZQSFP+_SDA_19: R169.2 U10.10(SD3) YJ29.D12(SDA_4)
ZQSFP+_SDA_20: R171.2 U10.13(SD4) YJ31.A12(SDA_1)
ZQSFP+_SDA_21: R173.2 U10.15(SD5) YJ31.B12(SDA_2)
ZQSFP+_SDA_22: R175.2 U10.17(SD6) YJ31.C12(SDA_3)
ZQSFP+_SDA_23: R177.2 U10.19(SD7) YJ31.D12(SDA_4)
ZQSFP+_SDA_24: R269.2 U13.4(SD0) YJ33.A12(SDA_1)
ZQSFP+_SDA_25: R271.2 U13.6(SD1) YJ33.B12(SDA_2)
ZQSFP+_SDA_26: R273.2 U13.8(SD2) YJ33.C12(SDA_3)
ZQSFP+_SDA_27: R275.2 U13.10(SD3) YJ33.D12(SDA_4)
ZQSFP+_SDA_28: R277.2 U13.13(SD4) YJ35.A12(SDA_1)
ZQSFP+_SDA_29: R279.2 U13.15(SD5) YJ35.B12(SDA_2)
ZQSFP+_SDA_30: R281.2 U13.17(SD6) YJ35.C12(SDA_3)
ZQSFP+_SDA_31: R283.2 U13.19(SD7) YJ35.D12(SDA_4)
ZQSFP+_SDA_32: R320.2 U16.4(SD0) YJ22.D12(SDA_4)
ZQSFP+_SDA_33: R322.2 U16.6(SD1) YJ22.C12(SDA_3)
ZQSFP+_SDA_34: R324.2 U16.8(SD2) YJ22.B12(SDA_2)
ZQSFP+_SDA_35: R326.2 U16.10(SD3) YJ22.A12(SDA_1)
ZQSFP+_SDA_36: R328.2 U16.13(SD4) YJ24.D12(SDA_4)
ZQSFP+_SDA_37: R330.2 U16.15(SD5) YJ24.C12(SDA_3)
ZQSFP+_SDA_38: R332.2 U16.17(SD6) YJ24.B12(SDA_2)
ZQSFP+_SDA_39: R334.2 U16.19(SD7) YJ24.A12(SDA_1)
ZQSFP+_SDA_40: R336.2 U15.4(SD0) YJ26.D12(SDA_4)
ZQSFP+_SDA_41: R338.2 U15.6(SD1) YJ26.C12(SDA_3)
ZQSFP+_SDA_42: R340.2 U15.8(SD2) YJ26.B12(SDA_2)
ZQSFP+_SDA_43: R342.2 U15.10(SD3) YJ26.A12(SDA_1)
ZQSFP+_SDA_44: R344.2 U15.13(SD4) YJ28.D12(SDA_4)
ZQSFP+_SDA_45: R346.2 U15.15(SD5) YJ28.C12(SDA_3)
ZQSFP+_SDA_46: R348.2 U15.17(SD6) YJ28.B12(SDA_2)
ZQSFP+_SDA_47: R350.2 U15.19(SD7) YJ28.A12(SDA_1)
ZQSFP+_SDA_48: R402.2 U17.4(SD0) YJ30.D12(SDA_4)
ZQSFP+_SDA_49: R404.2 U17.6(SD1) YJ30.C12(SDA_3)
ZQSFP+_SDA_50: R406.2 U17.8(SD2) YJ30.B12(SDA_2)
ZQSFP+_SDA_51: R408.2 U17.10(SD3) YJ30.A12(SDA_1)
ZQSFP+_SDA_52: R410.2 U17.13(SD4) YJ32.D12(SDA_4)
ZQSFP+_SDA_53: R412.2 U17.15(SD5) YJ32.C12(SDA_3)
ZQSFP+_SDA_54: R414.2 U17.17(SD6) YJ32.B12(SDA_2)
ZQSFP+_SDA_55: R416.2 U17.19(SD7) YJ32.A12(SDA_1)
ZQSFP+_SDA_56: R418.2 U18.4(SD0) YJ34.D12(SDA_4)
ZQSFP+_SDA_57: R420.2 U18.6(SD1) YJ34.C12(SDA_3)
ZQSFP+_SDA_58: R421.2 U18.8(SD2) YJ34.B12(SDA_2)
ZQSFP+_SDA_59: R423.2 U18.10(SD3) YJ34.A12(SDA_1)
ZQSFP+_SDA_60: R425.2 U18.13(SD4) YJ36.D12(SDA_4)
ZQSFP+_SDA_61: R436.2 U18.15(SD5) YJ36.C12(SDA_3)
ZQSFP+_SDA_62: R438.2 U18.17(SD6) YJ36.B12(SDA_2)
ZQSFP+_SDA_63: R427.2 U18.19(SD7) YJ36.A12(SDA_1)
N00477: C3938.1 R3655.2 R3657.2 U140.36(CS1)
N01461: C3939.1 R3661.2 R3662.2 U140.34(CS2)
N01835: C3941.1 R3666.2 R3667.2 U140.32(CS3)
N01986: C3944.1 R3668.2 R3669.2 U140.30(CS4)
N02139: C3946.1 R3671.2 R3672.2 U140.28(CS5)
N04017: C3937.1 R3649.1 R3652.1 U140.13(EN0)
N04101: C3936.2 R3650.1 R3653.1 U140.14(EN1)
N05390: C3940.1 R3664.2 R3665.2 U140.22(VINSEN)
N5081897: R8.1 U1.AB51(RESCAL1_REXT)
N5081901: R5.1 U1.BH51(RESCAL0_REXT)
N5081913: R11.1 U1.BH16(RESCAL3_REXT)
N5081917: R10.1 U1.AD16(RESCAL2_REXT)
N5100206: R1.1 U1.Y34(CORE_PLL_BYP_RESERVED)
N5113286: R6.2 U116.7(WP)
N5113366: R2.2 R12.2 U116.1(A0)
N5113378: R4.2 R14.2 U116.3(A2)
N5113382: R3.2 R13.2 U116.2(A1)
N5117511: C9.2 U1.AM15(CORE_PLL_REFCLKN)
N5117515: C10.2 U1.AM16(CORE_PLL_REFCLKP)
N5121590: C2844.2 U1.AP51(MISC_PLL_REFCLKP)
N5121594: C2807.2 U1.AP52(MISC_PLL_REFCLKN)
N5121846: C2854.2 U1.BK31(TS_PLL_REFCLKN)
N5121850: C2892.2 U1.BJ31(TS_PLL_REFCLKP)
N5126296: C2928.2 U1.BD51(FC6-7_REFCLKP)
N5126300: C2721.2 U1.BD52(FC6-7_REFCLKN)
N5126304: C19.2 U1.AH16(FC38-39_REFCLKN)
N5126308: C18.2 U1.AF51(FC24-25_REFCLKP)
N5126312: C17.2 U1.AF52(FC24-25_REFCLKN)
N5126316: C3142.2 U1.BD16(FC56-57_REFCLKP)
N5126320: C3108.2 U1.BD15(FC56-57_REFCLKN)
N5126324: C20.2 U1.AJ16(FC38-39_REFCLKP)
N6023779: C6.2 U1.BN34(BS_PLL1_REFCLKP)
N6023783: C5.2 U1.BM34(BS_PLL1_REFCLKN)
N6023843: C7.2 U1.BK34(BS_PLL0_REFCLKN)
N6023847: C8.2 U1.BJ34(BS_PLL0_REFCLKP)
N6690559: R16.1 U116.5(SDA)
N6690593: R15.1 U116.6(SCL)
N7135035: R3111.2 U1.AK51(MISC_PLL_BYP_RESERVED_CLK125_RESERVED)
N7135039: R3112.2 U1.AL51(MISC_PLL_BYP_RESERVED_CLK25_RESERVED)
N16666084: C3799.1 R3607.2 U134.1(CSRTNA)
N16666182: C3800.2 R3608.2 U134.2(CSENA)
N16666238: C3802.1 R3612.2 U134.4(CSRTNB)
N16666262: C3801.2 R3613.2 U134.5(CSENB)
N16666338: D435.28(PWM) U134.10(PWMA)
N16666350: D436.28(PWM) U134.6(PWMB)
N16666382: R3609.2 R3610.1 U134.7(EN_SYNC)
N16666394: R3611.1 U134.8(IOUT)
N16666626: C3813.1 D435.24(PHASE)
N16666634: C3813.2 D435.25(BOOT)
N16667636: C3814.1 D436.24(PHASE)
N16667644: C3814.2 D436.25(BOOT)
N16708373: D435.5(NC) X290.1
N16708525: C3947.1 R3673.2 R3674.2 U140.26(CS6)
N16709370: D436.5(NC) X291.1
N16768622: D438.5(NC) X293.1
N16768766: D437.5(NC) X292.1
N16768890: C3822.1 R3614.2 U135.1(CSRTNA)
N16768906: C3823.2 R3615.2 U135.2(CSENA)
N16768954: C3825.1 R3619.2 U135.4(CSRTNB)
N16768986: C3824.2 R3620.2 U135.5(CSENB)
N16769038: D437.28(PWM) U135.10(PWMA)
N16769050: D438.28(PWM) U135.6(PWMB)
N16769070: R3616.2 R3617.1 U135.7(EN_SYNC)
N16769094: R3618.1 U135.8(IOUT)
N16769294: C3836.1 D437.24(PHASE)
N16770006: C3837.1 D438.24(PHASE)
N16770018: C3837.2 D438.25(BOOT)
N16772539: D440.5(NC) X295.1
N16772683: D439.5(NC) X294.1
N16772807: C3845.1 R3621.2 U136.1(CSRTNA)
N16772823: C3846.2 R3622.2 U136.2(CSENA)
N16772871: C3848.1 R3626.2 U136.4(CSRTNB)
N16772903: C3847.2 R3627.2 U136.5(CSENB)
