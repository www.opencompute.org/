# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC39_RDP1: length 71.9
  TOP w0.147: U1.F10 221.55,111.34 v4(221.55,111.29)
  SIG3 w0.112: 231.98,110.03 231.95,110.03 231.86,109.94 222.57,109.94 arc(222.42,109.97) 222.3,110.05 arc(222.21,110.18) 222.18,110.32 222.18,110.63 arc(222.16,110.75) 222.09,110.85 arc(221.99,110.92) 221.88,110.94 221.68,110.94 arc(221.59,110.98) 221.55,111.07 v4(221.55,111.29)
  SIG3 w0.16: YJ29.D21 237.1,56.78 arc(237.15,57.01) 237.28,57.21 237.81,57.75 arc(237.88,57.85) 237.91,57.97 237.91,58.57 arc(237.94,58.72) 238.02,58.85 241.62,62.45 arc(241.78,62.69) 241.84,62.99 241.84,68.04 arc(241.78,68.33) 241.62,68.58 237.26,72.93 arc(237.1,73.18) 237.04,73.47 237.04,90.8 arc(236.98,91.09) 236.82,91.33 233.33,94.82 arc(233.17,95.07) 233.11,95.36 233.11,109.16 arc(233.1,109.24) 233.09,109.33 arc(233.01,109.52) 232.89,109.69 232.77,109.81 arc(232.53,109.97) 232.23,110.03 231.98,110.03
FC39_RDP2: length 94.7
  TOP w0.147: U1.E12 219.14,110.84 arc(219.23,110.82) 219.32,110.77 219.5,110.58 arc(219.54,110.53) 219.55,110.46 v4(219.55,110.39)
  SIG2 w0.112: 232.47,111.65 232.44,111.65 232.35,111.75 220.57,111.75 arc(220.42,111.72) 220.3,111.63 arc(220.21,111.51) 220.18,111.36 220.18,111.05 arc(220.16,110.93) 220.09,110.83 arc(219.99,110.77) 219.88,110.74 219.68,110.74 arc(219.59,110.71) 219.55,110.62 v4(219.55,110.39)
  SIG2 w0.16: YJ29.D14 233.75,53.97 arc(233.64,54.13) 233.61,54.32 233.61,54.54 arc(233.7,54.77) 233.93,54.86 234.78,54.86 arc(235.07,54.92) 235.31,55.08 235.36,55.13 235.41,55.18 arc(235.5,55.26) 235.6,55.32 arc(235.77,55.38) 235.95,55.41 238.04,55.41 arc(238.18,55.44) 238.31,55.52 238.67,55.88 238.67,56.24 239.02,56.6 239.38,56.6 239.74,56.96 239.74,57.31 240.1,57.67 240.46,57.67 240.82,58.03 240.82,58.39 241.18,58.75 241.54,58.75 241.9,59.11 241.9,59.44 242.28,59.83 242.62,59.83 242.98,60.19 243.69,60.91 243.7,60.91 250.27,67.48 arc(250.35,67.6) 250.38,67.75 250.38,94.17 arc(250.32,94.46) 250.16,94.71 245.65,99.22 arc(245.4,99.38) 245.11,99.44 239.14,99.44 arc(238.7,99.53) 238.33,99.77 235.98,102.12 arc(235.74,102.49) 235.65,102.93 235.65,110.04 arc(235.62,110.19) 235.54,110.31 234.31,111.54 arc(234.19,111.62) 234.04,111.65 232.47,111.65
FC39_RDP3: length 79.7
  TOP w0.147: U1.F8 223.55,111.34 v4(223.55,111.29)
  SIG3 w0.112: 232.22,112.04 232.19,112.04 232.1,111.94 224.57,111.94 arc(224.35,111.9) 224.16,111.77 arc(224.03,111.58) 223.99,111.36 223.99,111.05 arc(223.98,111.01) 223.95,110.97 arc(223.92,110.95) 223.88,110.94 223.68,110.94 arc(223.59,110.98) 223.55,111.07 v4(223.55,111.29)
  SIG3 w0.16: YJ29.D18 237.1,52.77 arc(237.15,53.01) 237.29,53.22 237.81,53.75 arc(237.88,53.85) 237.91,53.97 237.91,54.57 arc(237.94,54.72) 238.03,54.86 238.08,54.91 arc(238.21,55) 238.35,55.03 239.54,55.03 arc(239.97,55.11) 240.34,55.36 243.59,58.61 arc(243.84,58.98) 243.93,59.42 243.93,68.87 arc(243.87,69.16) 243.71,69.41 239.34,73.77 arc(239.18,74.02) 239.12,74.31 239.12,91.64 arc(239.06,91.93) 238.9,92.18 236.25,94.82 arc(236.09,95.07) 236.03,95.36 236.03,109.97 arc(235.97,110.26) 235.81,110.51 234.5,111.81 arc(234.25,111.98) 233.96,112.04 232.22,112.04
FC39_TDN0: length 81.7
  TOP w0.147: U1.E2 229.1,110.84 arc(229.42,110.71) v4(229.55,110.39)
  SIG5 w0.112: 232.09,109.65 232.06,109.65 231.97,109.74 230.39,109.74 arc(230.23,109.77) 230.1,109.86 arc(230.02,109.99) 229.99,110.14 229.99,110.58 arc(229.97,110.64) 229.94,110.69 229.93,110.71 arc(229.88,110.73) 229.84,110.74 229.68,110.74 arc(229.59,110.71) 229.55,110.62 v4(229.55,110.39)
  SIG5 w0.16: 232.09,109.65 232.37,109.65 arc(232.51,109.62) 232.62,109.54 arc(232.7,109.44) 232.73,109.32 arc(232.73,109.31) 232.73,109.29 232.73,107.08 232.6,106.96 232.6,106.14 232.73,106.02 232.73,105.26 232.6,105.13 232.6,104.32 232.73,104.19 232.73,103.43 232.6,103.3 232.6,102.49 232.73,102.36 232.73,95.2 arc(232.79,94.91) 232.95,94.67 236.44,91.18 arc(236.61,90.93) 236.66,90.64 236.66,75.12 arc(236.72,74.82) 236.89,74.58 242.94,68.53 arc(243.1,68.28) 243.16,67.99 243.16,62.13 243.03,62 243.03,61.19 243.16,61.06 243.16,60.28 arc(243.13,60.13) 243.05,60.01 242.45,59.41 242.21,59.41 241.69,58.89 241.69,58.65 241.15,58.11 240.91,58.11 240.4,57.6 240.4,57.36 239.94,56.9 239.75,56.9 239.3,56.45 239.3,56.26 238.56,55.52 arc(238.44,55.44) 238.29,55.41 226.35,55.41 arc(226.06,55.35) 225.81,55.18 arc(225.46,54.95) 225.04,54.86 224.28,54.86 arc(224.09,54.78) 224.01,54.59 224.01,54.32 arc(224.04,54.13) 224.15,53.97 YJ29.D2
FC39_TDN1: length 76.3
  TOP w0.147: v4(227.55,111.29) 227.55,111.34 U1.F4
  SIG4 w0.112: v4(227.55,111.29) 227.55,111.07 arc(227.59,110.98) 227.68,110.94 227.83,110.94 arc(227.97,110.91) 228.08,110.84 arc(228.16,110.72) 228.18,110.59 228.18,110.21 arc(228.2,110.11) 228.26,110.02 arc(228.35,109.96) 228.46,109.94 231.79,109.94 231.88,110.03 231.91,110.03
  SIG4 w0.16: 231.91,110.03 232.54,110.03 arc(232.83,109.97) 233.08,109.81 233.27,109.62 arc(233.29,109.59) 233.32,109.56 arc(233.45,109.33) 233.49,109.08 233.49,95.01 arc(233.55,94.72) 233.71,94.47 236.82,91.36 arc(236.99,91.11) 237.05,90.82 237.05,74.35 arc(237.1,74.06) 237.27,73.82 241.79,69.3 arc(241.95,69.05) 242.01,68.76 242.01,62.42 arc(241.95,62.13) 241.79,61.88 239.15,59.25 arc(238.91,59.08) 238.61,59.03 228.75,59.03 arc(228.61,59) 228.48,58.91 228.46,58.89 228.43,58.86 arc(228.34,58.72) 228.31,58.57 228.31,57.97 arc(228.28,57.85) 228.21,57.75 227.65,57.18 arc(227.54,57.02) 227.5,56.83 YJ29.D33
FC39_TDN2: length 95.7
  TOP w0.147: U1.E6 225.07,110.84 arc(225.26,110.81) 225.41,110.7 225.49,110.62 arc(225.53,110.56) 225.55,110.48 v4(225.55,110.39)
  SIG4 w0.112: 232.09,111.65 232.08,111.65 231.98,111.75 226.46,111.75 arc(226.35,111.73) 226.26,111.67 arc(226.2,111.58) 226.18,111.47 226.18,111.09 arc(226.16,110.96) 226.08,110.85 arc(225.97,110.77) 225.83,110.74 225.68,110.74 arc(225.59,110.71) 225.55,110.62 v4(225.55,110.39)
  SIG4 w0.16: 232.09,111.65 234.42,111.65 arc(234.57,111.63) 234.69,111.54 235.79,110.44 arc(235.87,110.32) 235.9,110.17 235.9,102.35 arc(235.99,101.91) 236.24,101.54 238.13,99.65 arc(238.5,99.4) 238.94,99.31 244.86,99.31 arc(245,99.28) 245.13,99.2 249.74,94.59 arc(249.82,94.47) 249.85,94.32 249.85,67.09 arc(249.82,66.94) 249.74,66.82 243.16,60.25 242.83,60.25 242.44,59.86 242.44,59.53 242.09,59.17 241.73,59.17 241.37,58.81 241.37,58.45 241.01,58.09 240.65,58.09 240.29,57.73 240.29,57.37 239.93,57.01 239.57,57.01 239.21,56.65 239.21,56.3 238.43,55.52 arc(238.31,55.44) 238.16,55.41 228.75,55.41 arc(228.46,55.35) 228.21,55.18 228.16,55.13 228.12,55.08 arc(227.87,54.92) 227.58,54.86 226.75,54.86 arc(226.51,54.76) 226.41,54.52 226.41,54.32 arc(226.44,54.13) 226.55,53.97 YJ29.D5
FC39_TDN3: length 72.2
  TOP w0.147: U1.D1 230.55,109.34 v4(230.55,109.29)
  SIG5 w0.112: 231.27,107.82 231.27,107.85 231.18,107.94 231.18,108.73 arc(231.16,108.87) 231.08,108.98 231.07,108.99 arc(230.96,109.06) 230.84,109.09 230.68,109.09 arc(230.59,109.12) 230.55,109.21 v4(230.55,109.29)
  SIG5 w0.16: YJ29.D36 225.1,56.73 arc(225.16,57.01) 225.31,57.25 225.51,57.44 225.81,57.75 arc(225.88,57.85) 225.91,57.97 225.91,58.57 arc(225.91,58.6) 225.91,58.64 arc(225.95,58.76) 226.03,58.86 226.08,58.91 arc(226.21,59) 226.35,59.03 237.97,59.03 arc(238.26,59.08) 238.51,59.25 241.16,61.9 arc(241.33,62.14) 241.38,62.44 241.38,67.1 arc(241.3,67.54) 241.05,67.91 234.74,74.21 arc(234.66,74.34) 234.63,74.48 234.63,88.8 arc(234.55,89.24) 234.3,89.61 231.73,92.18 231.3,92.61 230.87,93.04 arc(230.79,93.16) 230.76,93.31 230.76,105.99 arc(230.82,106.31) 231,106.58 231,106.58 arc(231.2,106.88) 231.27,107.23 231.27,107.82
FC39_TDP0: length 81.7
  TOP w0.147: U1.F2 229.55,111.34 v4(229.55,111.29)
  SIG5 w0.112: v4(229.55,111.29) 229.55,111.07 arc(229.59,110.98) 229.68,110.94 229.84,110.94 arc(229.96,110.92) 230.07,110.85 230.08,110.83 arc(230.15,110.72) 230.18,110.58 230.18,110.14 arc(230.2,110.06) 230.24,110 arc(230.31,109.95) 230.39,109.94 231.97,109.94 232.06,110.03 232.09,110.03
  SIG5 w0.16: YJ29.D3 225.1,52.75 arc(225.15,53.01) 225.3,53.23 225.81,53.75 arc(225.88,53.85) 225.91,53.97 225.91,54.57 arc(225.91,54.61) 225.91,54.65 arc(225.91,54.65) 225.91,54.65 arc(225.96,54.76) 226.03,54.86 226.08,54.91 arc(226.21,55) 226.35,55.03 238.29,55.03 arc(238.58,55.08) 238.83,55.25 243.32,59.74 arc(243.48,59.99) 243.54,60.28 243.54,67.99 arc(243.46,68.43) 243.21,68.8 237.16,74.85 arc(237.07,74.97) 237.05,75.12 237.05,90.64 arc(236.96,91.07) 236.71,91.44 233.22,94.94 arc(233.14,95.06) 233.11,95.2 233.11,109.29 arc(233.11,109.32) 233.11,109.34 arc(233.04,109.6) 232.89,109.81 arc(232.65,109.97) 232.37,110.03 232.09,110.03
FC39_TDP1: length 76.3
  TOP w0.147: U1.E4 227.07,110.84 arc(227.26,110.81) 227.41,110.7 227.49,110.62 arc(227.53,110.56) 227.55,110.48 v4(227.55,110.39)
  SIG4 w0.112: 231.91,109.65 231.88,109.65 231.79,109.74 228.46,109.74 arc(228.28,109.78) 228.12,109.88 arc(228.02,110.03) 227.99,110.21 227.99,110.59 arc(227.97,110.65) 227.94,110.7 arc(227.89,110.73) 227.83,110.74 227.68,110.74 arc(227.59,110.71) 227.55,110.62 v4(227.55,110.39)
  SIG4 w0.16: YJ29.D34 226.55,57.97 arc(226.44,58.13) 226.41,58.32 226.41,58.57 arc(226.49,58.78) 226.7,58.86 227.58,58.86 arc(227.87,58.92) 228.12,59.08 228.16,59.13 228.21,59.18 arc(228.46,59.35) 228.75,59.41 238.61,59.41 arc(238.76,59.44) 238.88,59.52 239.24,59.88 239.24,60.24 239.6,60.6 239.96,60.6 240.32,60.96 240.32,61.31 240.68,61.67 241.04,61.67 241.52,62.15 arc(241.6,62.27) 241.63,62.42 241.63,63.09 241.45,63.26 241.45,63.92 241.63,64.1 241.63,64.61 241.45,64.79 241.45,65.45 241.63,65.63 241.63,68.6 arc(241.57,68.89) 241.4,69.14 237,73.55 arc(236.75,73.92) 236.66,74.35 236.66,90.82 arc(236.64,90.97) 236.55,91.09 233.44,94.2 arc(233.2,94.57) 233.11,95.01 233.11,107.71 232.96,107.86 232.96,108.47 233.11,108.62 233.11,109.08 arc(233.09,109.21) 233.03,109.32 arc(233.01,109.33) 233,109.35 232.81,109.54 arc(232.69,109.62) 232.54,109.65 231.91,109.65
FC39_TDP2: length 95.7
  TOP w0.147: v4(225.55,111.29) 225.55,111.34 U1.F6
  SIG4 w0.112: 232.09,112.04 232.06,112.04 231.97,111.94 226.46,111.94 arc(226.28,111.91) 226.12,111.8 arc(226.02,111.65) 225.99,111.47 225.99,111.09 arc(225.97,111.04) 225.94,110.99 arc(225.89,110.95) 225.83,110.94 225.68,110.94 arc(225.59,110.98) 225.55,111.07 v4(225.55,111.29)
  SIG4 w0.16: 232.09,112.04 234.42,112.04 arc(234.71,111.98) 234.96,111.81 236.06,110.71 arc(236.23,110.46) 236.28,110.17 236.28,102.35 arc(236.34,102.06) 236.51,101.81 238.4,99.92 arc(238.65,99.75) 238.94,99.69 244.86,99.69 arc(245.15,99.63) 245.4,99.47 250.01,94.86 arc(250.17,94.61) 250.23,94.32 250.23,67.09 arc(250.17,66.8) 250.01,66.55 238.7,55.25 arc(238.46,55.08) 238.16,55.03 228.75,55.03 arc(228.61,55) 228.48,54.91 228.43,54.86 arc(228.34,54.72) 228.31,54.57 228.31,53.97 arc(228.28,53.85) 228.21,53.75 227.75,53.28 arc(227.57,53.01) 227.5,52.68 YJ29.D6
FC39_TDP3: length 72.2
  TOP w0.147: U1.C1 230.1,108.84 arc(230.42,108.71) v4(230.55,108.39)
  SIG5 w0.112: 230.89,107.82 230.89,107.85 230.99,107.94 230.99,108.73 arc(230.97,108.79) 230.94,108.84 230.93,108.85 arc(230.89,108.88) 230.84,108.89 230.68,108.89 arc(230.59,108.85) 230.55,108.76 v4(230.55,108.39)
  SIG5 w0.16: YJ29.D37 224.15,57.97 arc(224.04,58.13) 224.01,58.32 224.01,58.59 arc(224.09,58.78) 224.28,58.86 225.18,58.86 arc(225.47,58.92) 225.72,59.08 225.76,59.13 225.81,59.18 arc(226.06,59.35) 226.35,59.41 237.97,59.41 arc(238.12,59.44) 238.24,59.52 240.89,62.17 arc(240.97,62.29) 241,62.44 241,67.1 arc(240.94,67.39) 240.78,67.64 234.48,73.94 arc(234.31,74.19) 234.25,74.48 234.25,88.8 arc(234.19,89.1) 234.03,89.34 230.6,92.77 arc(230.44,93.02) 230.38,93.31 230.38,102.77 230.25,102.9 230.25,103.71 230.38,103.84 230.38,104.6 230.23,104.75 230.23,105.51 230.38,105.66 230.38,105.99 arc(230.47,106.46) 230.74,106.85 arc(230.85,107.03) 230.89,107.23 230.89,107.82
FC40_41_PVDD0P8: length 5.4
  TOP w0.229: U1.AD18 v1(213.55,129.34) ; U1.AB18 v1(213.55,127.34)
  TOP w0.381: C2757.1 240.22,125.45 ; C2757.1 239.62,124.81 ; C2757.1 240.82,124.81
  BOTTOM w0.13: v1(239.71,125.98) v2(239.71,125.22)
  BOTTOM w0.381: v1(213.55,127.34) 213.07,126.86 C2716.1 ; C3325.1 213.07,128.86 v1(213.55,129.34)
  vias: v1(240.6,125.98)
FC40_RDN0: length 91.7
  TOP w0.147: v4(218.55,113.39) 218.55,113.48 arc(218.53,113.56) 218.49,113.63 218.41,113.71 arc(218.26,113.81) 218.09,113.84 U1.H13
  SIG8 w0.112: 231.99,113.65 231.96,113.65 231.87,113.74 226.47,113.74 arc(226.27,113.78) 226.1,113.9 226.08,113.92 arc(225.98,114.06) 225.95,114.23 225.95,114.41 arc(225.93,114.54) 225.85,114.64 arc(225.75,114.72) 225.62,114.74 219.54,114.74 arc(219.4,114.71) 219.29,114.64 219.25,114.6 arc(219.2,114.52) 219.18,114.43 219.18,114.06 arc(219.16,113.94) 219.09,113.84 arc(218.99,113.77) 218.87,113.74 218.65,113.74 arc(218.58,113.71) 218.55,113.64 v4(218.55,113.39)
  SIG8 w0.16: YJ32.D24 254.7,56.61 arc(254.63,56.98) 254.42,57.31 arc(254.41,57.32) 254.4,57.34 254.14,57.59 arc(253.97,57.85) 253.91,58.15 253.91,58.42 arc(253.9,58.51) 253.88,58.6 arc(253.87,58.62) 253.87,58.63 arc(253.82,58.73) 253.75,58.82 253.66,58.9 arc(253.54,58.98) 253.39,59.01 251.5,59.01 arc(251.06,59.1) 250.69,59.35 248.43,61.61 arc(248.18,61.98) 248.09,62.42 248.09,68.34 arc(248.15,68.63) 248.32,68.88 248.78,69.34 248.78,69.7 249.14,70.05 249.5,70.05 249.85,70.41 249.85,70.77 250.21,71.13 250.57,71.13 251.68,72.24 arc(251.85,72.49) 251.9,72.78 251.9,101.05 arc(251.85,101.35) 251.68,101.59 239.87,113.41 234.16,113.41 arc(234.14,113.41) 234.13,113.41 arc(233.99,113.45) 233.87,113.53 arc(233.73,113.62) 233.57,113.65 231.99,113.65
FC40_RDN1: length 87.6
  TOP w0.147: U1.J9 222.55,114.34 v4(222.55,114.29)
  SIG9 w0.112: 231.97,112.03 231.94,112.03 arc(231.92,112.03) 231.9,112.01 231.87,111.99 arc(231.82,111.95) 231.76,111.94 223.45,111.94 arc(223.35,111.96) 223.26,112.02 arc(223.2,112.1) 223.18,112.2 223.18,113.63 arc(223.16,113.75) 223.09,113.85 arc(222.99,113.92) 222.87,113.94 222.65,113.94 arc(222.58,113.97) 222.55,114.04 v4(222.55,114.29)
  SIG9 w0.16: YJ32.D17 253.25,53.97 arc(253.36,54.14) 253.4,54.34 253.4,54.53 arc(253.31,54.76) 253.07,54.86 252.05,54.86 arc(251.86,54.9) 251.69,55.01 246.01,60.69 arc(245.85,60.94) 245.79,61.23 245.79,71.19 arc(245.82,71.34) 245.9,71.46 247.88,73.45 249.87,75.43 arc(250.12,75.8) 250.2,76.24 250.2,100.19 arc(250.12,100.63) 249.87,101 240,110.87 arc(239.63,111.12) 239.19,111.2 233.85,111.2 arc(233.73,111.21) 233.62,111.24 arc(233.45,111.32) 233.31,111.43 232.93,111.81 arc(232.68,111.97) 232.39,112.03 231.97,112.03
FC40_RDN2: length 91.5
  TOP w0.147: v4(220.55,113.39) 220.55,113.48 arc(220.53,113.56) 220.49,113.63 220.41,113.71 arc(220.26,113.81) 220.09,113.84 U1.H11
  SIG8 w0.112: 231.66,111.28 231.63,111.28 231.54,111.38 231.26,111.38 arc(231.07,111.42) 230.9,111.53 230.83,111.6 arc(230.67,111.71) 230.47,111.75 221.42,111.75 arc(221.25,111.78) 221.11,111.87 arc(221.02,112.01) 220.99,112.18 220.99,113.63 arc(220.98,113.68) 220.95,113.71 arc(220.92,113.73) 220.88,113.74 220.65,113.74 arc(220.58,113.71) 220.55,113.64 v4(220.55,113.39)
  SIG8 w0.16: YJ32.D15 254.7,52.68 arc(254.63,53.01) 254.45,53.29 254.11,53.63 arc(253.96,53.84) 253.91,54.1 253.91,54.48 arc(253.91,54.54) 253.89,54.61 arc(253.85,54.7) 253.79,54.77 253.75,54.81 253.75,54.82 253.66,54.9 arc(253.54,54.98) 253.39,55.01 251.69,55.01 arc(251.25,55.1) 250.88,55.35 246.27,59.96 arc(246.02,60.33) 245.94,60.77 245.94,71.21 arc(246.02,71.65) 246.27,72.02 246.63,72.38 246.63,72.73 246.99,73.09 247.35,73.09 247.71,73.45 247.71,73.81 248.07,74.17 248.43,74.17 249.71,75.46 arc(249.79,75.58) 249.82,75.73 249.82,100.19 arc(249.77,100.48) 249.6,100.73 239.27,111.06 arc(239.02,111.23) 238.73,111.28 231.66,111.28
FC40_RDN3: length 82.2
  TOP w0.147: v4(224.55,114.29) 224.55,114.34 U1.J7
  SIG9 w0.112: v4(224.55,114.29) 224.68,114.16 arc(224.92,114) 225.22,113.94 231.76,113.94 arc(231.82,113.95) 231.87,113.99 231.9,114.01 arc(231.92,114.03) 231.94,114.03 231.97,114.03
  SIG9 w0.16: 231.97,114.03 233.95,114.03 arc(234.11,114) 234.25,113.91 arc(234.37,113.83) 234.51,113.79 arc(234.52,113.79) 234.54,113.79 240.02,113.79 251.84,101.97 arc(251.99,101.8) 252.09,101.6 252.29,101.13 252.29,73.69 arc(252.23,73.4) 252.06,73.15 248.17,69.26 arc(248.01,69.01) 247.95,68.72 247.95,63.07 arc(248.01,62.78) 248.17,62.53 251.49,59.21 arc(251.88,58.95) 252.33,58.86 253.06,58.86 arc(253.3,58.76) 253.4,58.52 253.4,58.34 arc(253.36,58.14) 253.25,57.97 YJ32.D22
FC40_RDP0: length 91.7
  TOP w0.147: v4(218.55,114.29) 218.55,114.34 U1.J13
  SIG8 w0.112: v4(218.55,114.29) 218.55,114.04 arc(218.58,113.97) 218.65,113.94 218.87,113.94 arc(218.91,113.95) 218.95,113.97 arc(218.98,114.01) 218.99,114.06 218.99,114.43 arc(219.02,114.6) 219.12,114.74 219.15,114.78 arc(219.33,114.9) 219.54,114.94 225.62,114.94 arc(225.82,114.9) 225.99,114.78 arc(226.11,114.61) 226.15,114.41 226.15,114.23 226.15,114.23 arc(226.17,114.14) 226.22,114.05 226.24,114.03 arc(226.35,113.97) 226.47,113.94 231.87,113.94 231.96,114.03 231.99,114.03
  SIG8 w0.16: 231.99,114.03 233.57,114.03 arc(233.88,113.97) 234.13,113.8 234.16,113.79 234.16,113.79 240.02,113.79 251.95,101.86 arc(252.2,101.49) 252.28,101.05 252.28,72.78 arc(252.2,72.34) 251.95,71.97 248.59,68.61 arc(248.5,68.48) 248.48,68.34 248.48,62.42 arc(248.53,62.12) 248.7,61.88 250.96,59.62 arc(251.21,59.45) 251.5,59.39 253.39,59.39 arc(253.68,59.34) 253.93,59.17 253.96,59.14 arc(254.27,58.93) 254.63,58.86 255.2,58.86 arc(255.48,58.81) 255.72,58.65 255.72,58.65 arc(255.76,58.6) 255.79,58.55 255.8,58.53 arc(255.82,58.46) 255.83,58.39 arc(255.78,58.17) 255.65,57.97 YJ32.D25
FC40_RDP1: length 87.6
  TOP w0.147: U1.H9 222.07,113.84 arc(222.25,113.81) 222.41,113.7 222.49,113.62 arc(222.53,113.56) 222.55,113.48 v4(222.55,113.39)
  SIG9 w0.112: v4(222.55,113.39) 222.55,113.64 arc(222.58,113.71) 222.65,113.74 222.87,113.74 arc(222.91,113.73) 222.95,113.71 arc(222.98,113.67) 222.99,113.63 222.99,112.2 arc(223.02,112.03) 223.12,111.88 arc(223.27,111.78) 223.45,111.74 231.76,111.74 arc(231.82,111.73) 231.87,111.7 231.9,111.67 arc(231.92,111.66) 231.94,111.65 231.97,111.65
  SIG9 w0.16: YJ32.D18 252.3,52.85 arc(252.27,53.02) 252.17,53.17 251.91,53.42 251.69,53.65 arc(251.56,53.84) 251.51,54.07 251.51,54.48 arc(251.51,54.54) 251.49,54.6 arc(251.49,54.61) 251.49,54.62 arc(251.45,54.7) 251.39,54.77 251.35,54.82 249.8,56.36 248.72,57.44 248.34,57.44 248.01,57.77 248.01,58.16 247.58,58.58 247.22,58.58 246.86,58.94 246.86,59.3 245.74,60.42 arc(245.49,60.79) 245.41,61.23 245.41,71.19 arc(245.47,71.49) 245.63,71.73 246.62,72.72 249.6,75.7 arc(249.76,75.95) 249.82,76.24 249.82,100.19 arc(249.76,100.48) 249.6,100.73 239.73,110.6 arc(239.48,110.76) 239.19,110.82 233.85,110.82 arc(233.67,110.84) 233.5,110.88 arc(233.25,110.99) 233.04,111.16 232.66,111.54 arc(232.54,111.62) 232.39,111.65 231.97,111.65
FC40_RDP2: length 91.5
  TOP w0.147: v4(220.55,114.29) 220.55,114.34 U1.J11
  SIG8 w0.112: 231.66,111.67 231.63,111.67 231.54,111.57 231.26,111.57 arc(231.14,111.6) 231.04,111.66 230.97,111.74 arc(230.74,111.89) 230.47,111.94 221.42,111.94 arc(221.33,111.96) 221.25,112.01 arc(221.2,112.09) 221.18,112.18 221.18,113.63 arc(221.16,113.75) 221.09,113.85 arc(220.99,113.92) 220.88,113.94 220.65,113.94 arc(220.58,113.97) 220.55,114.04 v4(220.55,114.29)
  SIG8 w0.16: YJ32.D14 255.65,53.97 arc(255.76,54.14) 255.8,54.34 255.8,54.45 arc(255.77,54.61) 255.68,54.75 arc(255.55,54.83) 255.4,54.86 254.42,54.86 arc(254.25,54.89) 254.11,54.99 253.93,55.17 arc(253.68,55.34) 253.39,55.39 251.69,55.39 arc(251.4,55.45) 251.15,55.62 246.54,60.23 arc(246.37,60.47) 246.32,60.77 246.32,71.21 arc(246.37,71.5) 246.54,71.75 249.98,75.19 arc(250.15,75.44) 250.2,75.73 250.2,100.19 arc(250.12,100.63) 249.87,101 239.54,111.33 arc(239.16,111.58) 238.73,111.67 231.66,111.67
FC40_RDP3: length 82.2
  TOP w0.147: v4(224.55,113.39) 224.55,113.48 arc(224.53,113.56) 224.49,113.62 224.41,113.7 arc(224.25,113.81) 224.07,113.84 U1.H7
  SIG9 w0.112: 231.97,113.65 231.94,113.65 arc(231.92,113.66) 231.9,113.67 231.87,113.7 arc(231.82,113.73) 231.76,113.74 225.22,113.74 arc(224.92,113.69) 224.68,113.52 v4(224.55,113.39)
  SIG9 w0.16: 231.97,113.65 233.95,113.65 arc(233.97,113.65) 233.98,113.64 arc(234.21,113.48) 234.48,113.41 arc(234.51,113.41) 234.54,113.41 239.87,113.41 240.34,112.94 251.57,101.7 arc(251.67,101.58) 251.74,101.45 251.9,101.05 251.9,73.69 arc(251.88,73.54) 251.79,73.42 247.9,69.53 arc(247.65,69.16) 247.57,68.72 247.57,63.07 arc(247.65,62.63) 247.9,62.26 248.26,61.9 248.26,61.54 248.62,61.18 248.98,61.18 249.34,60.82 249.34,60.47 249.7,60.11 250.06,60.11 251.35,58.82 251.39,58.77 arc(251.45,58.7) 251.49,58.6 arc(251.49,58.6) 251.5,58.59 arc(251.51,58.54) 251.51,58.48 251.51,58.07 arc(251.56,57.84) 251.69,57.65 252.2,57.14 arc(252.27,57.02) 252.3,56.89 YJ32.D21
FC40_TDN0: length 88.9
  TOP w0.147: U1.K4 227.55,115.34 v4(227.55,115.29)
  SIG6 w0.112: 232.34,114.03 232.32,114.03 232.22,113.94 228.39,113.94 arc(228.31,113.95) 228.24,114 arc(228.2,114.06) 228.18,114.14 228.18,114.58 arc(228.15,114.72) 228.08,114.83 228.07,114.85 arc(227.96,114.92) 227.84,114.94 227.68,114.94 arc(227.59,114.98) 227.55,115.07 v4(227.55,115.29)
  SIG6 w0.16: YJ32.D34 262.85,57.97 arc(262.96,58.14) 263,58.34 263,58.52 arc(262.9,58.76) 262.66,58.86 261.76,58.86 arc(261.46,58.92) 261.22,59.08 261.13,59.17 arc(260.88,59.34) 260.59,59.39 252.08,59.39 arc(251.79,59.45) 251.54,59.62 248.74,62.42 arc(248.57,62.67) 248.51,62.96 248.51,67.79 arc(248.54,67.94) 248.63,68.06 251.95,71.39 arc(252.2,71.76) 252.29,72.2 252.29,101.05 arc(252.2,101.49) 251.95,101.86 240.36,113.45 arc(239.99,113.7) 239.55,113.79 234.14,113.79 arc(233.99,113.81) 233.86,113.88 233.79,113.92 arc(233.61,114) 233.41,114.03 232.34,114.03
FC40_TDN1: length 90.2
  TOP w0.147: U1.G1 230.1,112.84 arc(230.42,112.71) v4(230.55,112.39)
  SIG7 w0.112: v4(230.55,112.39) 230.55,112.6 arc(230.59,112.7) 230.69,112.74 230.83,112.74 arc(230.88,112.73) 230.93,112.7 230.94,112.69 arc(230.97,112.64) 230.99,112.58 230.99,112.14 arc(231.02,111.99) 231.1,111.86 arc(231.23,111.77) 231.39,111.74 231.8,111.74 arc(231.85,111.73) 231.89,111.7 231.95,111.65 231.98,111.65
  SIG7 w0.16: YJ32.D3 264.3,52.77 arc(264.25,53.01) 264.11,53.23 263.69,53.65 arc(263.56,53.84) 263.51,54.07 263.51,54.48 arc(263.51,54.53) 263.5,54.58 arc(263.46,54.69) 263.39,54.77 263.35,54.82 263.26,54.9 arc(263.14,54.98) 262.99,55.01 251.31,55.01 arc(250.87,55.1) 250.5,55.35 249.97,55.88 249.71,55.88 249.36,56.23 249.36,56.49 249.04,56.82 248.81,56.82 248.42,57.2 248.42,57.43 248.1,57.75 247.87,57.75 247.49,58.13 247.49,58.36 246.39,59.46 arc(246.14,59.83) 246.05,60.27 246.05,71.66 arc(246.14,72.09) 246.39,72.46 249.71,75.79 arc(249.79,75.91) 249.82,76.06 249.82,99.5 arc(249.64,100.43) 249.11,101.22 238.92,111.41 arc(238.65,111.59) 238.34,111.65 231.98,111.65
FC40_TDN2: length 90.8
  TOP w0.147: v4(228.55,113.29) 228.55,113.34 U1.H3
  SIG7 w0.112: 232.01,114.04 231.98,114.04 231.89,113.94 229.39,113.94 arc(229.23,113.91) 229.1,113.83 arc(229.02,113.7) 228.99,113.54 228.99,113.11 arc(228.97,113.04) 228.94,112.99 228.93,112.98 arc(228.88,112.95) 228.83,112.94 228.69,112.94 arc(228.59,112.98) 228.55,113.09 v4(228.55,113.29)
  SIG7 w0.16: 232.01,114.04 234.08,114.04 arc(234.3,114) 234.51,113.91 arc(234.58,113.86) 234.64,113.8 arc(234.66,113.79) 234.67,113.79 240.02,113.79 251.76,102.06 arc(252.15,101.47) 252.29,100.78 252.29,73.57 arc(252.23,73.28) 252.06,73.03 248.74,69.7 arc(248.57,69.46) 248.51,69.16 248.51,62.13 arc(248.57,61.84) 248.74,61.59 250.71,59.62 arc(250.96,59.45) 251.25,59.39 262.99,59.39 arc(263.28,59.34) 263.53,59.17 arc(263.87,58.94) 264.28,58.86 264.99,58.86 arc(265.28,58.74) 265.4,58.45 265.4,58.34 arc(265.36,58.14) 265.25,57.97 YJ32.D37
FC40_TDN3: length 91.5
  TOP w0.147: U1.G5 226.1,112.84 arc(226.42,112.71) v4(226.55,112.39)
  SIG6 w0.112: 232.01,111.65 231.98,111.65 231.89,111.74 227.39,111.74 arc(227.23,111.77) 227.1,111.86 arc(227.02,111.99) 226.99,112.14 226.99,112.58 arc(226.97,112.64) 226.94,112.69 226.93,112.71 arc(226.88,112.73) 226.84,112.74 226.68,112.74 arc(226.59,112.71) 226.55,112.62 v4(226.55,112.39)
  SIG6 w0.155: 261.13,53.94 arc(261.11,54) 261.11,54.07
  SIG6 w0.16: 232.01,111.65 232.29,111.65 arc(232.44,111.62) 232.56,111.54 233.02,111.08 arc(233.25,110.9) 233.51,110.79 arc(233.67,110.75) 233.83,110.74 239.27,110.74 arc(239.56,110.68) 239.81,110.52 249.71,100.62 arc(249.79,100.49) 249.82,100.35 249.82,76.18 arc(249.79,76.04) 249.71,75.91 246.27,72.47 arc(246.02,72.1) 245.94,71.67 245.94,61.04 arc(246.02,60.61) 246.27,60.24 248.2,58.3 248.2,58.05 248.6,57.65 248.85,57.65 249.17,57.33 249.17,57.1 249.59,56.68 249.83,56.68 250.17,56.34 250.17,56.1 250.58,55.69 250.82,55.69 251.16,55.35 arc(251.53,55.1) 251.97,55.01 260.59,55.01 arc(260.74,54.98) 260.86,54.9 260.95,54.82 260.99,54.77 arc(261.06,54.69) 261.1,54.58 arc(261.11,54.53) 261.11,54.48 261.11,54.07 ; YJ32.D6 261.9,52.72 arc(261.84,53.01) 261.68,53.26 261.29,53.64 arc(261.19,53.78) 261.13,53.94
FC40_TDP0: length 88.9
  TOP w0.147: U1.J4 227.1,114.84 arc(227.42,114.71) v4(227.55,114.39)
  SIG6 w0.112: 232.34,113.65 232.32,113.65 232.22,113.74 228.39,113.74 arc(228.23,113.77) 228.1,113.86 arc(228.02,113.99) 227.99,114.14 227.99,114.58 arc(227.97,114.64) 227.94,114.69 227.93,114.71 arc(227.88,114.73) 227.84,114.74 227.68,114.74 arc(227.59,114.71) 227.55,114.62 v4(227.55,114.39)
  SIG6 w0.155: 261.13,57.94 arc(261.11,58) 261.11,58.07
  SIG6 w0.16: 261.11,58.07 261.11,58.48 arc(261.11,58.53) 261.1,58.58 arc(261.06,58.68) 260.99,58.77 260.95,58.82 260.86,58.9 arc(260.74,58.98) 260.59,59.01 252.08,59.01 arc(251.64,59.1) 251.27,59.35 250.96,59.66 250.59,59.66 250.28,59.98 250.28,60.34 249.94,60.68 249.58,60.68 249.26,60.99 249.26,61.36 248.47,62.15 arc(248.22,62.52) 248.13,62.96 248.13,67.79 arc(248.19,68.08) 248.36,68.33 251.68,71.66 arc(251.85,71.9) 251.9,72.2 251.9,101.05 arc(251.85,101.34) 251.68,101.59 240.09,113.19 arc(239.84,113.35) 239.55,113.41 234.15,113.41 arc(233.89,113.45) 233.65,113.56 233.58,113.6 arc(233.5,113.64) 233.41,113.65 232.34,113.65 ; YJ32.D33 261.9,56.77 arc(261.85,57.01) 261.71,57.22 261.29,57.64 arc(261.19,57.78) 261.13,57.94
FC40_TDP1: length 90.2
  TOP w0.147: U1.H1 230.55,113.34 v4(230.55,113.29)
  SIG7 w0.112: 231.98,112.03 231.95,112.03 231.86,111.94 231.39,111.94 arc(231.31,111.95) 231.24,112 arc(231.2,112.06) 231.18,112.14 231.18,112.58 arc(231.15,112.72) 231.08,112.83 231.07,112.84 arc(230.96,112.92) 230.83,112.94 230.71,112.94 arc(230.6,112.99) 230.55,113.1 v4(230.55,113.29)
  SIG7 w0.16: YJ32.D2 265.25,53.97 arc(265.36,54.14) 265.4,54.34 265.4,54.52 arc(265.3,54.76) 265.06,54.86 264.16,54.86 arc(263.86,54.92) 263.62,55.08 263.53,55.17 arc(263.28,55.34) 262.99,55.39 251.31,55.39 arc(251.02,55.45) 250.77,55.62 246.66,59.73 arc(246.49,59.98) 246.43,60.27 246.43,71.66 arc(246.49,71.95) 246.66,72.19 249.98,75.52 arc(250.14,75.76) 250.2,76.06 250.2,99.5 arc(249.99,100.57) 249.38,101.49 239.19,111.68 arc(238.8,111.94) 238.34,112.03 231.98,112.03
FC40_TDP2: length 90.8
  TOP w0.147: U1.G3 228.1,112.84 arc(228.42,112.71) v4(228.55,112.39)
  SIG7 w0.112: v4(228.55,112.39) 228.55,112.58 arc(228.59,112.69) 228.7,112.74 228.7,112.74 228.83,112.74 arc(228.96,112.77) 229.07,112.84 229.08,112.85 arc(229.15,112.97) 229.18,113.11 229.18,113.54 arc(229.2,113.62) 229.24,113.69 arc(229.31,113.73) 229.39,113.75 231.83,113.75 arc(231.88,113.74) 231.92,113.71 231.98,113.65 232.01,113.65
  SIG7 w0.16: YJ32.D36 264.3,56.68 arc(264.24,57.01) 264.05,57.28 263.69,57.65 arc(263.56,57.84) 263.51,58.07 263.51,58.48 arc(263.51,58.53) 263.5,58.58 arc(263.5,58.58) 263.5,58.59 arc(263.45,58.69) 263.39,58.77 263.35,58.82 263.26,58.9 arc(263.14,58.98) 262.99,59.01 251.25,59.01 arc(250.81,59.1) 250.44,59.35 248.47,61.32 arc(248.22,61.69) 248.13,62.13 248.13,69.16 arc(248.22,69.6) 248.47,69.97 248.8,70.31 248.8,70.58 249.14,70.92 249.41,70.92 249.93,71.43 249.93,71.68 250.29,72.04 250.54,72.04 250.86,72.36 250.86,72.61 251.22,72.97 251.47,72.97 251.79,73.3 arc(251.88,73.42) 251.9,73.57 251.9,100.78 arc(251.8,101.32) 251.49,101.79 240.09,113.19 arc(239.84,113.35) 239.55,113.41 234.67,113.41 arc(234.51,113.44) 234.37,113.53 234.37,113.53 arc(234.34,113.56) 234.3,113.59 arc(234.2,113.64) 234.08,113.65 232.01,113.65
FC40_TDP3: length 91.5
  TOP w0.147: v4(226.55,113.29) 226.55,113.34 U1.H5
  SIG6 w0.112: v4(226.55,113.29) 226.55,113.07 arc(226.59,112.98) 226.68,112.94 226.84,112.94 arc(226.96,112.92) 227.07,112.85 227.08,112.83 arc(227.15,112.72) 227.18,112.58 227.18,112.14 arc(227.2,112.06) 227.24,112 arc(227.31,111.95) 227.39,111.94 231.89,111.94 231.98,112.03 232.01,112.03
  SIG6 w0.16: 232.01,112.03 232.29,112.03 arc(232.58,111.97) 232.83,111.81 233.29,111.35 arc(233.44,111.23) 233.62,111.15 arc(233.72,111.13) 233.83,111.12 239.27,111.12 arc(239.71,111.04) 240.08,110.79 249.98,100.89 arc(250.14,100.64) 250.2,100.35 250.2,76.18 arc(250.14,75.89) 249.98,75.64 246.54,72.2 arc(246.37,71.96) 246.32,71.67 246.32,61.04 arc(246.37,60.75) 246.54,60.5 251.43,55.62 arc(251.67,55.45) 251.97,55.39 260.59,55.39 arc(260.88,55.34) 261.13,55.17 261.22,55.08 arc(261.46,54.92) 261.76,54.86 262.66,54.86 arc(262.9,54.76) 263,54.52 263,54.34 arc(262.96,54.14) 262.85,53.97 YJ32.D5
FC41_RDN0: length 86.1
  TOP w0.147: v4(218.55,117.29) 218.55,117.34 U1.M13
  SIG8 w0.112: 232.16,118.73 232.06,118.64 231.72,118.64 arc(231.52,118.6) 231.36,118.49 230.96,118.09 arc(230.79,117.98) 230.6,117.94 219.54,117.94 arc(219.33,117.9) 219.15,117.78 219.12,117.74 arc(219.02,117.6) 218.99,117.43 218.99,117.06 arc(218.98,117.01) 218.95,116.97 arc(218.91,116.95) 218.87,116.94 218.65,116.94 arc(218.58,116.97) 218.55,117.04 v4(218.55,117.29)
  SIG8 w0.16: YJ32.C25 255.65,65.97 arc(255.76,66.14) 255.8,66.34 255.8,66.45 arc(255.78,66.56) 255.72,66.65 255.66,66.71 arc(255.5,66.82) 255.3,66.86 254.61,66.86 arc(254.39,66.96) 254.29,67.18 254.29,67.47 arc(254.32,67.62) 254.4,67.74 256.43,69.77 arc(256.68,70.15) 256.77,70.58 256.77,102.51 arc(256.68,102.95) 256.43,103.32 241.36,118.4 arc(240.99,118.65) 240.55,118.73 232.16,118.73
FC41_RDN1: length 83.9
  TOP w0.147: v4(222.55,116.39) 222.55,116.48 arc(222.53,116.56) 222.49,116.62 222.41,116.7 arc(222.25,116.81) 222.07,116.84 U1.L9
  SIG9 w0.112: 232.07,115.65 231.97,115.75 223.54,115.75 arc(223.33,115.79) 223.15,115.91 223.12,115.94 arc(223.02,116.08) 222.99,116.25 222.99,116.63 arc(222.98,116.67) 222.95,116.71 arc(222.91,116.73) 222.87,116.74 222.65,116.74 arc(222.58,116.71) 222.55,116.64 v4(222.55,116.39)
  SIG9 w0.16: 232.07,115.65 234,115.65 234.24,115.41 234.79,115.41 235.03,115.65 235.51,115.65 235.78,115.38 236.28,115.38 236.55,115.65 240.26,115.65 arc(240.55,115.59) 240.79,115.43 253.42,102.8 254.09,102.13 arc(254.26,101.88) 254.32,101.59 254.32,74 arc(254.26,73.71) 254.09,73.46 249.95,69.31 arc(249.78,69.07) 249.73,68.78 249.73,64.91 arc(249.81,64.47) 250.06,64.1 251.35,62.82 251.39,62.77 arc(251.45,62.69) 251.49,62.6 arc(251.51,62.54) 251.51,62.48 251.51,62.07 arc(251.56,61.84) 251.69,61.65 252.15,61.19 arc(252.26,61.02) 252.3,60.82 YJ32.C18
FC41_RDN2: length 88.1
  TOP w0.147: U1.M11 220.22,117.67 220.55,117.34 v4(220.55,117.29)
  SIG8 w0.112: v4(220.55,117.29) 220.55,117.04 arc(220.58,116.97) 220.65,116.94 220.87,116.94 arc(220.99,116.92) 221.09,116.85 arc(221.16,116.75) 221.18,116.63 221.18,116.25 arc(221.2,116.16) 221.25,116.08 221.29,116.05 arc(221.4,115.97) 221.54,115.94 231.75,115.94 231.84,116.03
  SIG8 w0.16: 231.84,116.03 232.83,116.03 arc(232.88,116.04) 232.92,116.07 233.2,116.35 arc(233.49,116.54) 233.83,116.61 239.68,116.61 arc(240.11,116.52) 240.48,116.27 254.35,102.4 arc(254.6,102.03) 254.69,101.6 254.69,71.7 arc(254.63,71.41) 254.47,71.16 250.86,67.56 arc(250.69,67.31) 250.63,67.02 250.63,64.58 arc(250.69,64.28) 250.86,64.04 251.28,63.62 arc(251.52,63.45) 251.82,63.39 253.39,63.39 arc(253.68,63.34) 253.93,63.17 254.16,62.94 arc(254.25,62.88) 254.35,62.86 255.44,62.86 arc(255.59,62.83) 255.72,62.74 arc(255.78,62.65) 255.8,62.54 255.8,62.35 arc(255.76,62.14) 255.65,61.97 YJ32.C14
FC41_RDN3: length 81.3
  TOP w0.147: U1.L7 224.07,116.84 arc(224.25,116.81) 224.41,116.7 224.49,116.62 arc(224.53,116.56) 224.55,116.48 v4(224.55,116.39)
  SIG9 w0.112: 232.04,117.65 231.95,117.75 225.54,117.75 arc(225.4,117.72) 225.29,117.64 225.25,117.61 arc(225.2,117.53) 225.18,117.44 225.18,117.06 arc(225.16,116.94) 225.09,116.84 arc(224.99,116.77) 224.87,116.74 224.65,116.74 arc(224.58,116.71) 224.55,116.64 v4(224.55,116.39)
  SIG9 w0.16: 232.04,117.65 233.19,117.65 arc(233.22,117.66) 233.25,117.67 233.81,117.9 arc(233.88,117.92) 233.96,117.93 234.46,117.93 234.72,117.68 235.23,117.68 235.27,117.72 235.48,117.93 235.99,117.93 236.24,117.68 236.75,117.68 237,117.93 241.13,117.93 arc(241.28,117.9) 241.4,117.82 245.12,114.1 253.81,105.41 256.29,102.93 arc(256.37,102.8) 256.4,102.66 256.4,73.54 arc(256.37,73.39) 256.29,73.27 251.49,68.47 arc(251.24,68.1) 251.15,67.66 251.15,67.28 arc(251.2,67.03) 251.35,66.82 251.39,66.77 arc(251.46,66.69) 251.5,66.59 arc(251.51,66.53) 251.51,66.48 251.51,66.07 arc(251.56,65.84) 251.69,65.65 252.17,65.16 arc(252.27,65.02) 252.3,64.86 YJ32.C21
FC41_RDP0: length 86.1
  TOP w0.147: U1.L13 218.09,116.84 arc(218.26,116.81) 218.41,116.71 218.49,116.63 arc(218.53,116.56) 218.55,116.48 v4(218.55,116.39)
  SIG8 w0.112: v4(218.55,116.39) 218.55,116.64 arc(218.58,116.71) 218.65,116.74 218.87,116.74 arc(218.99,116.77) 219.09,116.84 arc(219.16,116.94) 219.18,117.06 219.18,117.43 arc(219.2,117.52) 219.25,117.6 219.29,117.64 arc(219.4,117.71) 219.54,117.74 230.6,117.74 arc(230.87,117.79) 231.1,117.95 231.5,118.35 arc(231.6,118.41) 231.72,118.44 232.07,118.44 232.16,118.35
  SIG8 w0.16: YJ32.C24 254.7,64.67 arc(254.63,65.01) 254.45,65.29 254.09,65.65 arc(253.96,65.84) 253.91,66.07 253.91,67.47 arc(253.97,67.77) 254.13,68.01 254.64,68.52 254.64,68.91 254.98,69.24 255.36,69.24 256.17,70.04 arc(256.33,70.29) 256.39,70.58 256.39,102.51 arc(256.33,102.8) 256.17,103.05 241.09,118.13 arc(240.84,118.29) 240.55,118.35 232.16,118.35
FC41_RDP1: length 83.9
  TOP w0.147: v4(222.55,117.29) 222.55,117.34 U1.M9
  SIG9 w0.112: 232.07,116.03 231.98,115.94 223.54,115.94 arc(223.4,115.97) 223.29,116.05 223.25,116.08 arc(223.2,116.16) 223.18,116.25 223.18,116.63 arc(223.16,116.75) 223.09,116.85 arc(222.99,116.92) 222.87,116.94 222.65,116.94 arc(222.58,116.97) 222.55,117.04 v4(222.55,117.29)
  SIG9 w0.16: YJ32.C17 253.25,61.97 arc(253.36,62.14) 253.4,62.34 253.4,62.52 arc(253.3,62.76) 253.06,62.86 252.16,62.86 arc(251.86,62.92) 251.62,63.08 250.33,64.37 arc(250.16,64.62) 250.11,64.91 250.11,68.78 arc(250.14,68.92) 250.22,69.04 254.36,73.19 arc(254.61,73.56) 254.7,74 254.7,101.59 arc(254.61,102.02) 254.36,102.4 253.69,103.07 241.06,115.69 arc(240.69,115.94) 240.26,116.03 232.07,116.03
FC41_RDP2: length 88.1
  TOP w0.147: v4(220.55,116.39) 220.55,116.48 arc(220.53,116.56) 220.49,116.63 220.41,116.71 arc(220.26,116.81) 220.09,116.84 U1.L11
  SIG8 w0.112: v4(220.55,116.39) 220.55,116.64 arc(220.58,116.71) 220.65,116.74 220.87,116.74 arc(220.91,116.73) 220.95,116.71 arc(220.98,116.67) 220.99,116.63 220.99,116.25 arc(221.02,116.08) 221.12,115.94 221.15,115.91 arc(221.33,115.79) 221.54,115.75 231.74,115.75 231.84,115.65
  SIG8 w0.16: 231.84,115.65 232.83,115.65 arc(233.02,115.69) 233.19,115.8 233.47,116.08 arc(233.63,116.19) 233.83,116.23 239.68,116.23 arc(239.97,116.17) 240.22,116 254.08,102.14 arc(254.25,101.89) 254.31,101.6 254.31,71.7 arc(254.28,71.56) 254.2,71.43 252.81,70.04 252.42,70.04 252.09,69.71 252.09,69.32 251.73,68.97 251.37,68.97 251.01,68.61 251.01,68.25 250.59,67.83 arc(250.34,67.45) 250.25,67.02 250.25,64.58 arc(250.34,64.14) 250.59,63.77 251.01,63.35 arc(251.38,63.1) 251.82,63.01 253.39,63.01 arc(253.54,62.98) 253.66,62.9 253.75,62.82 253.79,62.77 arc(253.84,62.71) 253.88,62.64 arc(253.89,62.62) 253.89,62.61 arc(253.89,62.61) 253.89,62.6 arc(253.91,62.54) 253.91,62.48 253.91,62.07 arc(253.96,61.84) 254.09,61.65 254.33,61.41 254.45,61.29 arc(254.47,61.27) 254.49,61.24 arc(254.49,61.24) 254.49,61.24 arc(254.5,61.22) 254.51,61.21 arc(254.65,60.96) 254.7,60.68 YJ32.C15
FC41_RDP3: length 81.3
  TOP w0.147: v4(224.55,117.29) 224.55,117.34 U1.M7
  SIG9 w0.112: 232.04,118.04 231.95,117.94 225.54,117.94 arc(225.33,117.9) 225.15,117.78 225.12,117.75 arc(225.02,117.6) 224.99,117.44 224.99,117.06 arc(224.98,117.01) 224.95,116.97 arc(224.91,116.95) 224.87,116.94 224.65,116.94 arc(224.58,116.97) 224.55,117.04 v4(224.55,117.29)
  SIG9 w0.16: 232.04,118.04 233.15,118.04 233.66,118.25 arc(233.81,118.3) 233.96,118.31 241.13,118.31 arc(241.42,118.25) 241.67,118.09 249.11,110.64 253.81,105.95 256.56,103.2 arc(256.72,102.95) 256.78,102.66 256.78,73.54 arc(256.72,73.24) 256.56,73 251.76,68.2 arc(251.59,67.95) 251.54,67.66 251.54,67.28 arc(251.56,67.18) 251.62,67.08 arc(251.86,66.92) 252.16,66.86 253.06,66.86 arc(253.3,66.76) 253.4,66.52 253.4,66.34 arc(253.36,66.14) 253.25,65.97 YJ32.C22
FC41_TDN0: length 76.5
  TOP w0.147: U1.L1 230.1,116.84 arc(230.42,116.71) v4(230.55,116.39)
  SIG7 w0.112: v4(230.55,116.39) 230.55,116.5 arc(230.59,116.62) 230.7,116.67 230.7,116.67 230.83,116.67 arc(230.96,116.69) 231.07,116.76 231.08,116.77 arc(231.15,116.89) 231.18,117.03 231.18,117.34 arc(231.22,117.52) 231.32,117.67 231.42,117.78 231.55,117.78 231.57,117.8
  SIG7 w0.16: 231.57,117.8 232.05,118.27 arc(232.43,118.53) 232.88,118.62 239.79,118.62 arc(240.54,118.47) 241.17,118.04 255.89,103.32 arc(256.27,102.76) 256.4,102.1 256.4,76.06 arc(256.49,75.62) 256.74,75.25 257.57,74.41 257.57,74.16 257.94,73.78 258.2,73.78 258.55,73.43 258.55,73.19 258.91,72.82 259.16,72.82 259.48,72.5 259.48,72.28 259.87,71.89 260.09,71.89 260.42,71.57 260.42,71.34 260.8,70.96 261.03,70.96 261.35,70.63 261.35,70.35 261.67,70.02 261.96,70.02 262.51,69.47 arc(262.59,69.35) 262.62,69.2 262.62,68.24 arc(262.75,67.59) 263.12,67.04 263.35,66.82 263.39,66.77 arc(263.46,66.68) 263.5,66.57 arc(263.51,66.53) 263.51,66.48 263.51,66.07 arc(263.56,65.84) 263.69,65.65 264.13,65.2 arc(264.26,65.02) 264.3,64.8 YJ32.C36
FC41_TDN1: length 89.4
  TOP w0.147: U1.M3 228.55,117.34 v4(228.55,117.29)
  SIG6 w0.112: v4(228.55,117.29) 228.55,117.07 arc(228.59,116.98) 228.68,116.94 228.84,116.94 arc(228.96,116.92) 229.07,116.85 229.08,116.83 arc(229.15,116.72) 229.18,116.58 229.18,116.14 arc(229.2,116.06) 229.24,116 arc(229.31,115.95) 229.39,115.94 231.72,115.94 231.81,116.03 231.84,116.03
  SIG6 w0.16: YJ32.C2 265.25,61.97 arc(265.36,62.14) 265.4,62.34 265.4,62.52 arc(265.3,62.76) 265.06,62.86 263.96,62.86 arc(263.85,62.88) 263.76,62.95 263.53,63.17 arc(263.28,63.34) 262.99,63.39 251.71,63.39 arc(251.42,63.45) 251.17,63.62 250.82,63.97 arc(250.65,64.22) 250.59,64.51 250.59,65.48 arc(250.65,65.77) 250.82,66.02 252.26,67.46 254.48,69.68 arc(254.64,69.92) 254.7,70.21 254.7,101.58 arc(254.61,102.02) 254.36,102.39 241.06,115.69 arc(240.69,115.94) 240.25,116.03 231.84,116.03
FC41_TDN2: length 80.5
  TOP w0.147: U1.L5 226.1,116.84 arc(226.42,116.71) v4(226.55,116.39)
  SIG6 w0.112: 231.84,117.65 231.81,117.65 231.72,117.75 227.39,117.75 arc(227.31,117.73) 227.24,117.69 arc(227.2,117.62) 227.18,117.54 227.18,117.11 arc(227.15,116.97) 227.08,116.85 227.07,116.84 arc(226.96,116.77) 226.84,116.74 226.68,116.74 arc(226.59,116.71) 226.55,116.62 v4(226.55,116.39)
  SIG6 w0.16: YJ32.C33 261.9,64.84 arc(261.86,65.02) 261.76,65.17 261.33,65.6 arc(261.26,65.68) 261.2,65.76 261.2,65.76 arc(261.13,65.91) 261.11,66.07 261.11,67.61 260.92,67.8 260.92,68.39 261.11,68.58 261.11,69.04 260.92,69.23 260.92,69.76 261.11,69.95 261.11,72.9 arc(261.2,73.33) 261.45,73.7 262.92,75.18 arc(263,75.3) 263.03,75.45 263.03,95.87 arc(262.97,96.16) 262.81,96.41 241.46,117.76 arc(241.21,117.92) 240.92,117.98 233.29,117.98 arc(233.07,117.94) 232.89,117.82 arc(232.71,117.7) 232.5,117.65 231.84,117.65
FC41_TDN3: length 86.5
  TOP w0.147: U1.K2 229.55,115.34 v4(229.55,115.29)
  SIG7 w0.112: 231.84,116.04 231.81,116.04 231.72,115.94 230.39,115.94 arc(230.23,115.91) 230.1,115.83 arc(230.02,115.7) 229.99,115.54 229.99,115.11 arc(229.97,115.04) 229.94,114.99 229.93,114.98 arc(229.88,114.95) 229.83,114.94 229.69,114.94 arc(229.59,114.98) 229.55,115.09 v4(229.55,115.29)
  SIG7 w0.16: 231.84,116.04 232.22,116.04 arc(232.27,116.04) 232.31,116.07 232.85,116.61 arc(233.1,116.78) 233.39,116.84 238.94,116.84 arc(239.85,116.66) 240.62,116.14 253.98,102.78 arc(254.51,101.98) 254.7,101.04 254.7,72.25 arc(254.62,71.84) 254.38,71.49 251,68.11 arc(250.7,67.65) 250.59,67.12 250.59,64.49 arc(250.65,64.2) 250.82,63.95 251.15,63.62 arc(251.4,63.45) 251.69,63.39 260.59,63.39 arc(260.88,63.34) 261.13,63.17 261.3,63.01 arc(261.46,62.9) 261.65,62.86 262.66,62.86 arc(262.9,62.76) 263,62.52 263,62.34 arc(262.96,62.14) 262.85,61.97 YJ32.C5
FC41_TDP0: length 76.5
  TOP w0.147: v4(230.55,117.29) 230.55,117.34 U1.M1
  SIG7 w0.112: 231.3,118.07 231.28,118.05 231.28,117.92 231.18,117.81 arc(231.04,117.6) 230.99,117.34 230.99,117.03 arc(230.97,116.97) 230.94,116.91 230.93,116.9 arc(230.88,116.87) 230.83,116.86 230.69,116.86 arc(230.59,116.91) 230.55,117.01 v4(230.55,117.29)
  SIG7 w0.16: YJ32.C37 265.25,65.97 arc(265.36,66.14) 265.4,66.34 265.4,66.52 arc(265.3,66.76) 265.06,66.86 264.16,66.86 arc(263.86,66.92) 263.62,67.08 263.39,67.31 arc(263.1,67.74) 263,68.24 263,69.2 arc(262.95,69.49) 262.78,69.74 257,75.52 arc(256.84,75.76) 256.78,76.06 256.78,102.1 arc(256.62,102.91) 256.16,103.59 241.44,118.31 arc(240.69,118.82) 239.79,119 232.88,119 arc(232.28,118.88) 231.78,118.54 231.3,118.07
FC41_TDP1: length 89.4
  TOP w0.147: U1.L3 228.1,116.84 arc(228.42,116.71) v4(228.55,116.39)
  SIG6 w0.112: 231.84,115.65 231.81,115.65 231.72,115.74 229.39,115.74 arc(229.23,115.77) 229.1,115.86 arc(229.02,115.99) 228.99,116.14 228.99,116.58 arc(228.97,116.64) 228.94,116.69 228.93,116.71 arc(228.88,116.73) 228.84,116.74 228.68,116.74 arc(228.59,116.71) 228.55,116.62 v4(228.55,116.39)
  SIG6 w0.16: YJ32.C3 264.3,60.88 arc(264.27,61.02) 264.19,61.14 263.69,61.65 arc(263.56,61.84) 263.51,62.07 263.51,62.48 arc(263.51,62.53) 263.5,62.58 arc(263.49,62.59) 263.49,62.61 arc(263.49,62.62) 263.48,62.63 arc(263.44,62.71) 263.39,62.77 263.35,62.82 263.26,62.9 arc(263.14,62.98) 262.99,63.01 251.71,63.01 arc(251.28,63.1) 250.9,63.35 250.55,63.7 arc(250.3,64.08) 250.21,64.51 250.21,65.48 arc(250.3,65.92) 250.55,66.29 250.89,66.63 250.89,66.89 251.28,67.28 251.54,67.28 251.88,67.62 251.88,67.88 252.27,68.27 252.53,68.27 252.87,68.61 252.87,68.85 253.29,69.26 253.52,69.26 254.21,69.95 arc(254.29,70.07) 254.32,70.21 254.32,101.58 arc(254.26,101.87) 254.09,102.12 240.79,115.43 arc(240.54,115.59) 240.25,115.65 231.84,115.65
FC41_TDP2: length 80.5
  TOP w0.147: v4(226.55,117.29) 226.55,117.34 U1.M5
  SIG6 w0.112: v4(226.55,117.29) 226.55,117.07 arc(226.59,116.98) 226.68,116.94 226.84,116.94 arc(226.88,116.95) 226.93,116.98 226.94,116.99 arc(226.97,117.04) 226.99,117.11 226.99,117.54 arc(227.02,117.7) 227.1,117.83 arc(227.23,117.91) 227.39,117.94 231.72,117.94 231.81,118.04 231.84,118.04
  SIG6 w0.16: YJ32.C34 262.85,65.97 arc(262.96,66.14) 263,66.34 263,66.52 arc(262.9,66.76) 262.66,66.86 261.68,66.86 arc(261.55,66.92) 261.49,67.05 261.49,72.9 arc(261.55,73.19) 261.71,73.43 263.19,74.91 arc(263.35,75.15) 263.41,75.45 263.41,95.87 arc(263.32,96.31) 263.08,96.68 241.73,118.03 arc(241.36,118.27) 240.92,118.36 233.29,118.36 arc(232.93,118.29) 232.62,118.09 arc(232.56,118.05) 232.5,118.04 231.84,118.04
FC41_TDP3: length 86.5
  TOP w0.147: U1.J2 229.1,114.84 arc(229.42,114.71) v4(229.55,114.39)
  SIG7 w0.112: 231.84,115.65 231.81,115.65 231.76,115.71 arc(231.71,115.74) 231.66,115.75 230.39,115.75 arc(230.31,115.73) 230.24,115.69 arc(230.2,115.62) 230.18,115.54 230.18,115.11 arc(230.15,114.97) 230.08,114.85 230.07,114.84 arc(229.96,114.77) 229.83,114.74 229.7,114.74 229.7,114.74 arc(229.59,114.69) 229.55,114.58 v4(229.55,114.39)
  SIG7 w0.16: 231.84,115.65 232.22,115.65 arc(232.42,115.69) 232.58,115.8 233.12,116.34 arc(233.25,116.43) 233.39,116.46 238.94,116.46 arc(239.7,116.3) 240.35,115.87 253.71,102.51 arc(254.16,101.84) 254.32,101.04 254.32,72.25 arc(254.26,71.98) 254.11,71.76 253.54,71.18 253.34,71.18 252.92,70.77 252.92,70.57 252.6,70.24 252.31,70.24 251.99,69.92 251.99,69.63 251.67,69.31 251.38,69.31 251.06,68.99 251.06,68.7 250.73,68.38 arc(250.35,67.8) 250.21,67.12 250.21,64.49 arc(250.3,64.06) 250.55,63.69 250.88,63.35 arc(251.26,63.1) 251.69,63.01 260.59,63.01 arc(260.74,62.98) 260.86,62.9 260.95,62.82 260.99,62.77 arc(261.05,62.69) 261.09,62.6 arc(261.09,62.6) 261.09,62.59 arc(261.11,62.54) 261.11,62.48 261.11,62.07 arc(261.13,61.93) 261.18,61.8 261.18,61.8 arc(261.24,61.71) 261.32,61.62 261.71,61.23 arc(261.85,61.01) 261.9,60.76 YJ32.C6
FC42_43_PVDD0P8: length 5.5
  TOP w0.229: U1.AG18 v1(213.55,132.34) ; U1.AE18 v1(213.55,130.34)
  TOP w0.381: C2932.1 237.93,125.45 ; C2932.1 237.34,124.81 ; C2932.1 238.53,124.81
  BOTTOM w0.13: v1(238.44,125.98) v2(238.44,126.74)
  BOTTOM w0.381: C3330.1 213.07,131.86 v1(213.55,132.34) ; v1(213.55,130.34) 213.07,129.86 C2877.1
  vias: v1(237.43,125.98)
FC42_RDN0: length 85.1
  TOP w0.147: U1.P13 218.14,119.84 arc(218.23,119.82) 218.32,119.77 218.5,119.59 arc(218.54,119.53) 218.55,119.46 v4(218.55,119.39)
  SIG2 w0.112: 231.84,117.65 231.81,117.65 231.72,117.74 225.37,117.74 arc(225.24,117.77) 225.12,117.85 225.09,117.88 arc(224.99,118.03) 224.95,118.21 224.95,118.47 arc(224.93,118.57) 224.87,118.66 arc(224.78,118.72) 224.67,118.75 219.57,118.75 arc(219.35,118.79) 219.16,118.92 arc(219.03,119.11) 218.99,119.33 218.99,119.63 arc(218.98,119.68) 218.95,119.71 arc(218.92,119.73) 218.88,119.74 218.68,119.74 arc(218.59,119.71) 218.55,119.62 v4(218.55,119.39)
  SIG2 w0.16: YJ31.A25 261.75,65.97 arc(261.64,66.13) 261.61,66.32 261.61,66.54 arc(261.7,66.77) 261.93,66.86 262.79,66.86 arc(262.88,66.88) 262.96,66.93 arc(263.01,67.01) 263.03,67.1 263.03,67.61 262.8,67.84 262.8,68.4 263.03,68.63 263.03,69.13 262.8,69.36 262.8,69.92 263.03,70.15 263.03,70.66 262.83,70.86 262.83,71.47 263.03,71.67 263.03,72.18 262.83,72.39 262.83,73 263.03,73.2 263.03,73.71 262.83,73.91 262.83,74.52 263.03,74.72 263.03,75.23 262.85,75.41 262.85,75.97 263.03,76.15 263.03,90.23 arc(262.97,90.52) 262.81,90.77 258.3,95.28 arc(258.05,95.44) 257.76,95.5 255.14,95.5 arc(254.85,95.56) 254.6,95.72 232.9,117.43 arc(232.65,117.59) 232.36,117.65 231.84,117.65
FC42_RDN1: length 92.5
  TOP w0.147: v4(222.55,120.29) 222.55,120.34 U1.R9
  SIG3 w0.112: v4(222.55,120.29) 222.55,120.07 arc(222.59,119.98) 222.68,119.94 222.88,119.94 arc(222.92,119.95) 222.95,119.97 arc(222.98,120.01) 222.99,120.05 222.99,120.35 arc(223.03,120.58) 223.16,120.77 arc(223.35,120.89) 223.57,120.94 225.59,120.94 arc(225.79,120.9) 225.96,120.79 arc(226.07,120.62) 226.11,120.42 226.11,120.21 arc(226.13,120.11) 226.19,120.02 arc(226.28,119.96) 226.38,119.94 231.94,119.94 232.04,120.03 232.06,120.03
  SIG3 w0.16: 232.06,120.03 233.46,120.03 arc(233.49,120.03) 233.51,120.03 arc(233.78,119.97) 234,119.81 254.66,99.15 arc(254.91,98.99) 255.2,98.93 258.48,98.93 arc(258.77,98.87) 259.02,98.71 265.27,92.45 arc(265.44,92.21) 265.49,91.91 265.49,78.44 arc(265.54,78.22) 265.66,78.04 arc(265.78,77.86) 265.82,77.64 265.82,71.59 arc(265.88,71.29) 266.05,71.05 267.51,69.59 arc(267.67,69.34) 267.73,69.05 267.73,67.4 arc(267.67,67.1) 267.51,66.86 267.28,66.63 arc(267.12,66.39) 267.06,66.09 267.06,64.69 arc(266.97,64.26) 266.72,63.89 266.2,63.36 arc(265.83,63.11) 265.39,63.03 263.95,63.03 arc(263.81,63) 263.68,62.91 263.63,62.86 arc(263.54,62.72) 263.51,62.57 263.51,61.97 arc(263.48,61.85) 263.41,61.75 262.9,61.23 arc(262.89,61.23) 262.89,61.22 arc(262.75,61) 262.7,60.75 YJ31.A15
FC42_RDN2: length 91.8
  TOP w0.147: U1.P11 220.14,119.84 arc(220.24,119.82) 220.32,119.77 220.5,119.6 arc(220.53,119.54) 220.55,119.47 v4(220.55,119.39)
  SIG2 w0.112: 232.09,119.65 232.06,119.65 231.97,119.74 226.38,119.74 arc(226.2,119.78) 226.05,119.88 arc(225.95,120.03) 225.91,120.21 225.91,120.42 arc(225.89,120.54) 225.82,120.65 arc(225.72,120.72) 225.59,120.74 221.57,120.74 arc(221.42,120.71) 221.3,120.63 arc(221.21,120.5) 221.18,120.35 221.18,120.05 arc(221.16,119.93) 221.09,119.83 arc(220.99,119.77) 220.88,119.74 220.68,119.74 arc(220.59,119.71) 220.55,119.62 v4(220.55,119.39)
  SIG2 w0.16: YJ31.A17 264.15,61.97 arc(264.04,62.13) 264.01,62.32 264.01,62.59 arc(264.09,62.78) 264.28,62.86 265.18,62.86 arc(265.47,62.92) 265.71,63.08 265.76,63.13 265.81,63.18 266.28,63.65 arc(266.57,64.09) 266.68,64.61 266.68,66.02 arc(266.65,66.16) 266.57,66.28 265.45,67.4 arc(265.2,67.78) 265.11,68.21 265.11,68.72 264.86,68.97 264.86,69.48 265.11,69.74 265.11,70.24 264.86,70.5 264.86,71.01 265.11,71.26 265.11,71.77 264.86,72.02 264.86,72.53 265.11,72.78 265.11,73.29 264.88,73.52 264.88,74.08 265.11,74.31 265.11,91.76 arc(265.05,92.05) 264.89,92.3 258.86,98.33 arc(258.61,98.49) 258.32,98.55 255.04,98.55 arc(254.75,98.61) 254.5,98.77 233.85,119.43 arc(233.6,119.59) 233.31,119.65 232.09,119.65
FC42_RDN3: length 80.4
  TOP w0.147: U1.R7 224.55,120.34 v4(224.55,120.29)
  SIG3 w0.112: 231.84,118.04 231.81,118.04 231.72,117.94 225.39,117.94 arc(225.31,117.96) 225.24,118 arc(225.2,118.07) 225.18,118.15 225.18,119.63 arc(225.16,119.75) 225.09,119.85 arc(224.99,119.92) 224.88,119.94 224.68,119.94 arc(224.59,119.98) 224.55,120.07 v4(224.55,120.29)
  SIG3 w0.16: 231.84,118.04 232.51,118.04 arc(232.8,117.98) 233.05,117.81 254.76,96.11 arc(255,95.94) 255.3,95.88 257.92,95.88 arc(258.21,95.82) 258.46,95.66 263.19,90.93 arc(263.35,90.68) 263.41,90.39 263.41,70.7 arc(263.47,70.4) 263.63,70.16 265.66,68.13 arc(265.83,67.88) 265.88,67.59 265.88,65.99 arc(265.85,65.83) 265.77,65.7 265.29,65.22 arc(265.28,65.21) 265.26,65.2 arc(265.14,65) 265.1,64.77 YJ31.A21
FC42_RDP0: length 85.1
  TOP w0.147: U1.R13 218.55,120.34 v4(218.55,120.29)
  SIG2 w0.112: 231.84,118.03 231.81,118.03 231.72,117.94 225.37,117.94 arc(225.31,117.95) 225.26,117.99 225.23,118.02 arc(225.17,118.11) 225.15,118.21 225.15,118.47 arc(225.11,118.65) 225.01,118.8 arc(224.85,118.91) 224.67,118.94 219.57,118.94 arc(219.42,118.97) 219.3,119.06 arc(219.21,119.18) 219.18,119.33 219.18,119.63 arc(219.16,119.75) 219.09,119.85 arc(218.99,119.92) 218.88,119.94 218.68,119.94 arc(218.59,119.98) 218.55,120.07 v4(218.55,120.29)
  SIG2 w0.16: YJ31.A24 262.7,64.78 arc(262.75,65.02) 262.88,65.22 263.41,65.75 arc(263.48,65.85) 263.51,65.97 263.51,66.72 arc(263.49,66.78) 263.46,66.84 arc(263.42,66.89) 263.41,66.95 263.41,90.23 arc(263.32,90.67) 263.08,91.04 258.57,95.55 arc(258.2,95.8) 257.76,95.88 255.14,95.88 arc(254.99,95.91) 254.87,95.99 233.17,117.7 arc(232.79,117.95) 232.36,118.03 231.84,118.03
