# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC36_RDP0: length 64
  TOP w0.147: U1.G22 209.55,112.34 v4(209.6,112.34)
  SIG9 w0.112: 210.86,104.98 210.86,105 arc(210.87,105.02) 210.88,105.04 210.91,105.07 arc(210.94,105.12) 210.95,105.18 210.95,111.35 arc(210.93,111.49) 210.85,111.6 210.82,111.64 arc(210.74,111.69) 210.64,111.71 210.26,111.71 arc(210.14,111.73) 210.04,111.8 arc(209.97,111.9) 209.95,112.02 209.95,112.24 arc(209.92,112.31) 209.85,112.34 v4(209.6,112.34)
  SIG9 w0.16: 210.86,104.98 210.86,104.1 arc(210.95,103.66) 211.2,103.29 211.28,103.2 arc(211.36,103.08) 211.39,102.93 211.39,97.57 arc(211.48,97.13) 211.73,96.76 215.32,93.17 arc(215.69,92.92) 216.13,92.83 217.2,92.83 arc(217.35,92.81) 217.47,92.72 220.81,89.39 arc(220.89,89.26) 220.92,89.12 220.92,61.7 arc(221.01,61.26) 221.26,60.89 223.13,59.02 arc(223.17,58.98) 223.21,58.94 223.26,58.9 arc(223.27,58.89) 223.29,58.88 223.35,58.82 223.39,58.77 arc(223.46,58.68) 223.5,58.57 arc(223.51,58.53) 223.51,58.48 223.51,58.07 arc(223.56,57.84) 223.69,57.65 224.12,57.21 arc(224.25,57.02) 224.3,56.78 YJ30.B21
FC36_RDP1: length 69.8
  TOP w0.147: v4(210.5,114.34) 210.42,114.34 arc(210.34,114.36) 210.27,114.4 210.19,114.48 arc(210.09,114.64) 210.05,114.83 U1.J21
  SIG9 w0.112: 209.24,104.99 209.24,105.01 arc(209.23,105.03) 209.22,105.05 209.19,105.08 arc(209.16,105.13) 209.14,105.19 209.14,113.35 arc(209.17,113.49) 209.25,113.6 209.28,113.64 arc(209.36,113.69) 209.46,113.71 209.83,113.71 arc(209.95,113.73) 210.06,113.8 arc(210.12,113.9) 210.15,114.02 210.15,114.24 arc(210.18,114.31) 210.25,114.34 v4(210.5,114.34)
  SIG9 w0.16: 209.24,104.99 209.24,102.88 arc(209.29,102.63) 209.43,102.42 arc(209.56,102.21) 209.61,101.97 209.61,96.78 arc(209.67,96.49) 209.84,96.24 218.98,87.1 arc(219.15,86.85) 219.2,86.56 219.2,66.92 arc(219.23,66.78) 219.32,66.65 219.72,66.24 arc(219.97,65.87) 220.06,65.44 220.06,58.96 arc(220.12,58.67) 220.28,58.42 220.64,58.06 220.93,58.06 221.36,57.62 221.36,57.34 223.62,55.08 arc(223.87,54.92) 224.16,54.86 225.09,54.86 arc(225.31,54.77) 225.4,54.55 225.4,54.34 arc(225.36,54.14) 225.25,53.97 YJ30.B17
FC36_RDP2: length 70.2
  TOP w0.147: U1.L22 209.55,116.34 v4(209.6,116.34)
  SIG8 w0.112: v4(209.6,116.34) 209.85,116.34 arc(209.92,116.31) 209.95,116.24 209.95,116.02 arc(209.97,115.9) 210.04,115.8 arc(210.14,115.73) 210.26,115.71 210.64,115.71 arc(210.73,115.69) 210.81,115.64 210.84,115.6 arc(210.92,115.49) 210.95,115.35 210.95,104.99 210.86,104.9
  SIG8 w0.16: 210.86,104.9 210.86,103.84 arc(210.95,103.4) 211.2,103.03 211.28,102.95 arc(211.36,102.82) 211.39,102.68 211.39,97.57 arc(211.48,97.13) 211.73,96.76 215.32,93.17 arc(215.69,92.92) 216.13,92.83 217.1,92.83 arc(217.39,92.78) 217.63,92.61 220.71,89.53 arc(220.88,89.28) 220.94,88.99 220.94,61.88 arc(221.02,61.45) 221.27,61.07 223,59.35 arc(223.37,59.1) 223.81,59.01 225.39,59.01 arc(225.54,58.98) 225.66,58.9 225.75,58.82 arc(225.82,58.73) 225.87,58.63 arc(225.9,58.53) 225.91,58.42 225.91,58.15 arc(225.97,57.85) 226.14,57.59 226.51,57.23 arc(226.65,57.01) 226.7,56.76 YJ30.B24
FC36_RDP3: length 75.9
  TOP w0.147: U1.N21 210.05,118.73 arc(210.07,118.62) 210.13,118.53 210.19,118.47 arc(210.33,118.37) v4(210.5,118.34)
  SIG8 w0.112: 209.24,104.9 209.15,104.99 209.15,117.35 arc(209.18,117.49) 209.25,117.6 209.29,117.64 arc(209.37,117.69) 209.46,117.71 209.83,117.71 arc(209.95,117.73) 210.06,117.8 arc(210.12,117.9) 210.15,118.02 210.15,118.24 arc(210.18,118.31) 210.25,118.34 v4(210.5,118.34)
  SIG8 w0.16: 209.24,104.9 209.24,102.55 arc(209.29,102.3) 209.43,102.09 arc(209.56,101.88) 209.61,101.64 209.61,96.78 arc(209.67,96.49) 209.84,96.24 219.02,87.06 arc(219.18,86.82) 219.24,86.52 219.24,69.01 219.44,68.81 219.44,68.2 219.24,67.99 219.24,67.04 arc(219.3,66.75) 219.46,66.5 219.77,66.19 arc(219.94,65.94) 220,65.65 220,59.39 arc(220.06,59.1) 220.22,58.85 223.46,55.62 arc(223.7,55.45) 224,55.39 225.39,55.39 arc(225.68,55.34) 225.93,55.17 226.11,54.99 arc(226.25,54.89) 226.42,54.86 227.4,54.86 arc(227.55,54.83) 227.68,54.75 227.68,54.75 arc(227.77,54.61) 227.8,54.45 227.8,54.34 arc(227.76,54.14) 227.65,53.97 YJ30.B14
FC36_TDN0: length 73.8
  TOP w0.147: v4(209.6,106.34) 209.55,106.34 209.22,106.67 U1.A22
  SIG7 w0.112: v4(209.6,106.34) 209.8,106.34 arc(209.91,106.3) 209.95,106.2 209.95,106.06 arc(209.94,106.01) 209.91,105.96 209.9,105.95 arc(209.85,105.92) 209.79,105.91 209.35,105.91 arc(209.19,105.87) 209.06,105.79 arc(208.98,105.66) 208.95,105.5 208.95,104.77 208.86,104.68 208.86,104.65
  SIG7 w0.16: 208.86,104.65 208.86,104.22 arc(208.9,103.99) 209.03,103.8 209.16,103.67 arc(209.21,103.59) 209.23,103.5 209.23,96.62 arc(209.29,96.33) 209.46,96.09 218.42,87.12 arc(218.73,86.66) 218.83,86.13 218.83,69.58 arc(218.92,69.14) 219.17,68.77 219.59,68.35 arc(219.67,68.22) 219.7,68.08 219.7,58.87 arc(219.79,58.44) 220.04,58.07 222.76,55.35 arc(223.13,55.1) 223.56,55.01 234.99,55.01 arc(235.14,54.98) 235.26,54.9 235.35,54.82 235.39,54.77 arc(235.45,54.7) 235.49,54.62 arc(235.49,54.6) 235.5,54.58 arc(235.51,54.53) 235.51,54.48 235.51,54.07 arc(235.56,53.84) 235.69,53.65 235.9,53.43 236.12,53.21 arc(236.25,53.01) 236.3,52.78 YJ30.B3
FC36_TDN1: length 69.6
  TOP w0.147: U1.C21 210.05,108.79 arc(210.18,108.47) v4(210.5,108.34)
  SIG6 w0.112: 211.24,104.65 211.24,104.68 211.15,104.77 211.15,107.5 arc(211.12,107.66) 211.03,107.79 arc(210.9,107.87) 210.75,107.91 210.31,107.91 arc(210.25,107.92) 210.2,107.95 210.19,107.96 arc(210.16,108.01) 210.15,108.05 210.15,108.21 arc(210.18,108.3) 210.27,108.34 v4(210.5,108.34)
  SIG6 w0.16: 211.24,104.65 211.24,103.46 arc(211.3,103.17) 211.47,102.92 211.55,102.84 arc(211.71,102.59) 211.77,102.3 211.77,97.54 arc(211.83,97.25) 212,97.01 215.56,93.44 arc(215.81,93.27) 216.1,93.22 217.23,93.22 arc(217.52,93.16) 217.77,92.99 221.06,89.7 arc(221.22,89.46) 221.28,89.16 221.28,76.32 arc(221.29,76.2) 221.32,76.08 221.38,75.91 arc(221.4,75.84) 221.4,75.76 221.4,62.89 221.62,62.67 221.62,62.19 221.4,61.97 221.4,61.49 arc(221.46,61.2) 221.63,60.95 222.96,59.62 arc(223.2,59.45) 223.5,59.39 232.59,59.39 arc(232.88,59.34) 233.13,59.17 arc(233.47,58.94) 233.88,58.86 234.66,58.86 arc(234.9,58.76) 235,58.52 235,58.34 arc(234.96,58.14) 234.85,57.97 YJ30.B34
FC36_TDN2: length 75.4
  TOP w0.147: v4(209.6,110.34) 209.55,110.34 U1.E22
  SIG6 w0.112: 208.86,104.78 208.86,104.8 208.95,104.89 208.95,109.5 arc(208.98,109.66) 209.06,109.79 arc(209.19,109.87) 209.35,109.91 209.79,109.91 arc(209.85,109.92) 209.9,109.95 209.91,109.96 arc(209.94,110.01) 209.95,110.05 209.95,110.21 arc(209.91,110.3) 209.82,110.34 v4(209.6,110.34)
  SIG6 w0.16: 208.86,104.78 208.86,102.88 arc(208.93,102.49) 209.16,102.16 209.16,102.16 arc(209.21,102.07) 209.23,101.97 209.23,96.62 arc(209.29,96.33) 209.46,96.09 218.61,86.93 arc(218.78,86.68) 218.83,86.39 218.83,69.45 arc(218.89,69.16) 219.06,68.91 219.48,68.49 arc(219.65,68.24) 219.7,67.95 219.7,58.87 arc(219.79,58.43) 220.04,58.06 222.75,55.35 arc(223.12,55.1) 223.56,55.01 232.59,55.01 arc(232.74,54.98) 232.86,54.9 232.95,54.82 232.99,54.77 arc(233.06,54.68) 233.1,54.58 arc(233.11,54.53) 233.11,54.48 233.11,54.07 arc(233.16,53.84) 233.29,53.65 233.72,53.21 arc(233.85,53.01) 233.9,52.78 YJ30.B6
FC36_TDN3: length 70.8
  TOP w0.147: U1.B19 212.05,107.79 arc(212.18,107.47) v4(212.5,107.34)
  SIG7 w0.112: 211.77,105 211.77,105.03 211.68,105.12 211.68,105.26 arc(211.62,105.55) 211.46,105.8 211.29,105.96 arc(211.18,106.13) 211.14,106.32 211.14,106.5 arc(211.16,106.58) 211.2,106.65 arc(211.27,106.69) 211.35,106.71 211.79,106.71 arc(211.92,106.74) 212.04,106.81 212.05,106.82 arc(212.12,106.93) 212.15,107.06 212.15,107.18 arc(212.2,107.29) 212.31,107.34 v4(212.5,107.34)
  SIG7 w0.16: 211.77,105 211.77,97.41 arc(211.8,97.27) 211.88,97.14 215.7,93.33 arc(215.82,93.24) 215.97,93.22 216.91,93.22 arc(217.47,93.1) 217.95,92.79 220.79,89.94 arc(221.17,89.38) 221.3,88.71 221.3,61.85 arc(221.36,61.56) 221.52,61.31 221.92,60.91 222.23,60.91 222.55,60.59 222.55,60.29 223.22,59.62 arc(223.46,59.45) 223.76,59.39 234.99,59.39 arc(235.28,59.34) 235.53,59.17 235.62,59.08 arc(235.86,58.92) 236.16,58.86 237.06,58.86 arc(237.3,58.76) 237.4,58.52 237.4,58.34 arc(237.36,58.14) 237.25,57.97 YJ30.B37
FC36_TDP0: length 73.8
  TOP w0.147: U1.A21 210.05,106.79 arc(210.18,106.47) v4(210.5,106.34)
  SIG7 w0.112: 209.24,104.65 209.24,104.68 209.18,104.73 arc(209.15,104.77) 209.14,104.82 209.14,105.5 arc(209.16,105.58) 209.2,105.65 arc(209.27,105.69) 209.35,105.71 209.79,105.71 arc(209.92,105.74) 210.04,105.81 210.05,105.82 arc(210.12,105.93) 210.15,106.06 210.15,106.18 arc(210.2,106.29) 210.31,106.34 v4(210.5,106.34)
  SIG7 w0.16: YJ30.B2 237.25,53.97 arc(237.36,54.14) 237.4,54.34 237.4,54.52 arc(237.3,54.76) 237.06,54.86 236.04,54.86 arc(235.86,54.9) 235.7,55 235.53,55.17 arc(235.28,55.34) 234.99,55.39 223.56,55.39 arc(223.27,55.45) 223.03,55.62 222.13,56.52 222.13,56.82 221.83,57.11 221.53,57.11 220.31,58.34 arc(220.14,58.58) 220.08,58.87 220.08,68.08 arc(220.03,68.37) 219.86,68.62 219.44,69.04 arc(219.27,69.29) 219.21,69.58 219.21,86.13 arc(219.08,86.81) 218.69,87.39 209.73,96.35 arc(209.64,96.48) 209.61,96.62 209.61,103.5 arc(209.57,103.74) 209.43,103.94 209.3,104.07 arc(209.25,104.14) 209.24,104.22 209.24,104.65
FC36_TDP1: length 69.6
  TOP w0.147: v4(209.6,108.34) 209.55,108.34 U1.C22
  SIG6 w0.112: 210.86,104.65 210.86,104.68 210.95,104.77 210.95,107.5 arc(210.94,107.58) 210.89,107.65 arc(210.83,107.69) 210.75,107.71 210.31,107.71 arc(210.17,107.74) 210.06,107.81 210.05,107.83 arc(209.98,107.93) 209.95,108.05 209.95,108.21 arc(209.91,108.3) 209.82,108.34 v4(209.6,108.34)
  SIG6 w0.155: 233.13,57.94 arc(233.11,58) 233.11,58.07
  SIG6 w0.16: 210.86,104.65 210.86,103.46 arc(210.95,103.02) 211.2,102.65 211.28,102.57 arc(211.36,102.44) 211.39,102.3 211.39,97.54 arc(211.48,97.11) 211.73,96.74 215.29,93.17 arc(215.66,92.92) 216.1,92.83 217.23,92.83 arc(217.37,92.81) 217.5,92.72 220.79,89.43 arc(220.87,89.31) 220.9,89.16 220.9,76.32 arc(220.91,76.14) 220.96,75.96 221.02,75.79 arc(221.02,75.77) 221.02,75.76 221.02,61.49 arc(221.11,61.05) 221.36,60.68 222.69,59.35 arc(223.06,59.1) 223.5,59.01 232.59,59.01 arc(232.74,58.98) 232.86,58.9 232.95,58.82 232.99,58.77 arc(233.05,58.7) 233.09,58.6 arc(233.1,58.59) 233.1,58.58 arc(233.11,58.53) 233.11,58.48 233.11,58.07 ; YJ30.B33 233.9,56.78 arc(233.85,57.01) 233.72,57.22 233.29,57.64 arc(233.19,57.78) 233.13,57.94
FC36_TDP2: length 75.4
  TOP w0.147: U1.E21 210.05,110.79 arc(210.18,110.47) v4(210.5,110.34)
  SIG6 w0.112: v4(210.5,110.34) 210.27,110.34 arc(210.18,110.3) 210.15,110.21 210.15,110.05 arc(210.12,109.93) 210.05,109.83 210.04,109.81 arc(209.92,109.74) 209.79,109.71 209.35,109.71 arc(209.27,109.69) 209.2,109.65 arc(209.16,109.58) 209.14,109.5 209.14,104.9 209.24,104.8 209.24,104.78
  SIG6 w0.16: 209.24,104.78 209.24,102.88 arc(209.29,102.63) 209.43,102.42 arc(209.56,102.22) 209.61,101.97 209.61,96.62 arc(209.64,96.48) 209.73,96.35 218.88,87.2 arc(219.13,86.83) 219.21,86.39 219.21,69.45 arc(219.24,69.31) 219.33,69.18 219.75,68.76 arc(220,68.39) 220.08,67.95 220.08,58.87 arc(220.14,58.58) 220.31,58.33 222.03,56.61 222.32,56.61 222.68,56.24 222.68,55.96 223.02,55.62 arc(223.27,55.45) 223.56,55.39 232.59,55.39 arc(232.88,55.34) 233.13,55.17 233.22,55.08 arc(233.46,54.92) 233.76,54.86 234.66,54.86 arc(234.9,54.76) 235,54.52 235,54.34 arc(234.96,54.14) 234.85,53.97 YJ30.B5
FC36_TDP3: length 70.8
  TOP w0.147: v4(211.6,107.34) 211.55,107.34 U1.B20
  SIG7 w0.112: 211.39,105 211.39,105.03 211.48,105.12 211.48,105.26 arc(211.44,105.48) 211.32,105.66 211.15,105.82 arc(211,106.05) 210.95,106.32 210.95,106.5 arc(210.98,106.66) 211.06,106.79 arc(211.19,106.87) 211.35,106.91 211.79,106.91 arc(211.85,106.92) 211.9,106.95 211.91,106.96 arc(211.94,107.01) 211.95,107.06 211.95,107.2 arc(211.91,107.3) 211.8,107.34 v4(211.6,107.34)
  SIG7 w0.16: 211.39,105 211.39,97.41 arc(211.45,97.12) 211.62,96.87 215.43,93.06 arc(215.68,92.89) 215.97,92.83 216.91,92.83 arc(217.33,92.75) 217.68,92.52 220.52,89.67 arc(220.82,89.23) 220.92,88.71 220.92,61.85 arc(221.01,61.41) 221.26,61.04 222.95,59.35 arc(223.32,59.1) 223.76,59.01 234.99,59.01 arc(235.14,58.98) 235.26,58.9 235.35,58.82 235.39,58.77 arc(235.46,58.68) 235.5,58.58 arc(235.51,58.53) 235.51,58.48 235.51,58.07 arc(235.56,57.84) 235.69,57.65 236.08,57.26 arc(236.24,57.01) 236.3,56.72 YJ30.B36
FC37_RDN0: length 61
  TOP w0.147: v4(213.5,112.34) 213.42,112.34 arc(213.34,112.36) 213.27,112.4 213.19,112.48 arc(213.09,112.64) 213.05,112.83 U1.G18
  SIG9 w0.112: v4(213.5,112.34) 213.37,112.21 arc(213.21,111.97) 213.15,111.68 213.15,105.08 arc(213.16,105.02) 213.19,104.97 213.24,104.92 213.24,104.9
  SIG9 w0.16: YJ30.A14 227.65,61.97 arc(227.76,62.14) 227.8,62.34 227.8,62.53 arc(227.71,62.76) 227.47,62.86 226.56,62.86 arc(226.26,62.92) 226.02,63.08 225.93,63.17 arc(225.68,63.34) 225.39,63.39 223.97,63.39 arc(223.68,63.45) 223.43,63.62 222.89,64.16 arc(222.72,64.41) 222.66,64.7 222.66,65.34 222.67,65.48 arc(222.69,65.62) 222.77,65.73 223.49,66.46 arc(223.66,66.7) 223.72,66.99 223.72,90.39 arc(223.66,90.68) 223.49,90.92 219.33,95.09 arc(219.08,95.25) 218.79,95.31 218.12,95.31 arc(217.83,95.37) 217.58,95.54 216.44,96.68 arc(216.28,96.92) 216.22,97.21 216.22,101.34 arc(216.16,101.63) 215.99,101.88 214.51,103.37 214.51,103.67 214.1,104.08 213.79,104.08 213.43,104.44 arc(213.29,104.65) 213.24,104.9
FC37_RDN1: length 58.2
  TOP w0.147: U1.J19 212.55,114.34 v4(212.6,114.34)
  SIG9 w0.112: 215.83,105.4 215.81,105.4 arc(215.78,105.4) 215.76,105.42 215.74,105.44 arc(215.68,105.48) 215.62,105.49 215.33,105.49 arc(215.06,105.6) 214.95,105.87 214.95,113.44 arc(214.93,113.54) 214.87,113.63 arc(214.79,113.69) 214.69,113.71 213.26,113.71 arc(213.14,113.73) 213.04,113.8 arc(212.97,113.9) 212.95,114.02 212.95,114.24 arc(212.92,114.31) 212.85,114.34 v4(212.6,114.34)
  SIG9 w0.16: 215.83,105.4 216.29,105.4 arc(216.35,105.39) 216.4,105.35 216.85,104.9 216.85,104.67 217.31,104.21 217.54,104.21 219.66,102.09 arc(219.74,101.97) 219.77,101.82 219.77,97.63 arc(219.86,97.19) 220.11,96.82 225.3,91.62 arc(225.39,91.5) 225.42,91.35 225.42,68.58 arc(225.37,68.47) 225.35,68.34 225.35,67.71 arc(225.42,67.27) 225.67,66.9 225.75,66.82 225.79,66.77 arc(225.85,66.69) 225.89,66.6 arc(225.89,66.6) 225.89,66.59 arc(225.91,66.54) 225.91,66.48 225.91,66.07 arc(225.96,65.84) 226.09,65.65 226.5,65.23 arc(226.65,65.01) 226.7,64.75 YJ30.A24
FC37_RDN2: length 63.3
  TOP w0.147: U1.L18 213.05,116.73 arc(213.07,116.62) 213.13,116.53 213.19,116.47 arc(213.33,116.37) v4(213.5,116.34)
  SIG8 w0.112: v4(213.5,116.34) 213.14,116.34 arc(213.05,116.3) 213.02,116.21 213.02,116.03 arc(213.05,115.94) 213.14,115.91 214.71,115.91 arc(214.88,115.87) 215.02,115.78 arc(215.11,115.64) 215.14,115.47 215.14,105.84 arc(215.18,105.68) 215.27,105.53 arc(215.41,105.44) 215.58,105.41 216.2,105.41 216.29,105.5 216.32,105.5
  SIG8 w0.16: YJ30.A22 225.25,65.97 arc(225.36,66.14) 225.4,66.34 225.4,66.45 arc(225.38,66.56) 225.32,66.65 225.26,66.71 arc(225.1,66.82) 224.9,66.86 224.13,66.86 arc(223.96,66.93) 223.89,67.1 223.89,67.36 arc(223.91,67.45) 223.96,67.53 225.57,69.14 arc(225.74,69.39) 225.8,69.68 225.8,91.96 arc(225.74,92.25) 225.57,92.5 224.44,93.63 arc(224.28,93.87) 224.22,94.17 224.22,101.89 arc(224.13,102.32) 223.88,102.69 221.41,105.16 arc(221.04,105.41) 220.6,105.5 216.32,105.5
FC37_RDN3: length 68.6
  TOP w0.147: U1.N19 212.55,118.34 v4(212.6,118.34)
  SIG8 w0.112: 212.86,105.03 212.86,105.06 212.95,105.15 212.95,110.42 arc(212.93,110.55) 212.86,110.65 212.84,110.67 arc(212.75,110.73) 212.66,110.75 212.48,110.75 arc(212.28,110.79) 212.11,110.9 arc(211.99,111.07) 211.95,111.27 211.95,117.35 arc(212,117.56) 212.12,117.74 212.15,117.78 arc(212.29,117.87) 212.46,117.91 212.83,117.91 arc(212.88,117.91) 212.92,117.94 arc(212.94,117.98) 212.95,118.02 212.95,118.24 arc(212.92,118.31) 212.85,118.34 v4(212.6,118.34)
  SIG8 w0.16: YJ30.A18 224.3,60.66 arc(224.23,61.01) 224.03,61.3 223.69,61.65 arc(223.56,61.84) 223.51,62.07 223.51,62.48 arc(223.51,62.54) 223.49,62.6 arc(223.45,62.7) 223.39,62.77 223.35,62.82 223.26,62.9 arc(223.14,62.98) 222.99,63.01 arc(222.8,63.05) 222.63,63.16 222.57,63.23 arc(222.45,63.4) 222.41,63.61 222.41,68.97 arc(222.5,69.41) 222.75,69.78 223.22,70.26 arc(223.31,70.38) 223.34,70.52 223.34,91.01 arc(223.31,91.16) 223.22,91.28 221.12,93.38 arc(220.88,93.75) 220.79,94.19 220.79,101.12 arc(220.73,101.42) 220.57,101.66 219.84,102.39 arc(219.59,102.56) 219.3,102.61 215.03,102.61 arc(214.74,102.67) 214.5,102.84 213.05,104.28 arc(212.91,104.5) 212.86,104.75 212.86,105.03
FC37_RDP0: length 61
  TOP w0.147: v4(212.6,112.34) 212.1,112.84 U1.G19
  SIG9 w0.112: v4(212.6,112.34) 212.73,112.21 arc(212.89,111.97) 212.95,111.68 212.95,105.08 arc(212.94,105.02) 212.9,104.97 212.86,104.93 212.86,104.9
  SIG9 w0.16: YJ30.A15 226.7,60.84 arc(226.66,61.02) 226.56,61.18 226.08,61.65 arc(225.96,61.84) 225.91,62.07 225.91,62.48 arc(225.91,62.53) 225.9,62.58 arc(225.86,62.68) 225.79,62.77 225.75,62.82 225.66,62.9 arc(225.54,62.98) 225.39,63.01 223.97,63.01 arc(223.53,63.1) 223.16,63.35 222.62,63.89 arc(222.37,64.26) 222.28,64.7 222.28,65.34 222.28,65.48 arc(222.34,65.76) 222.5,66 223.22,66.72 arc(223.31,66.85) 223.34,66.99 223.34,90.38 arc(223.31,90.53) 223.22,90.65 219.06,94.82 arc(218.94,94.9) 218.79,94.93 218.12,94.93 arc(217.68,95.02) 217.31,95.27 216.17,96.41 arc(215.92,96.78) 215.84,97.21 215.84,101.34 arc(215.81,101.48) 215.72,101.61 213.16,104.17 arc(212.94,104.51) 212.86,104.9
FC37_RDP1: length 58.2
  TOP w0.147: U1.J18 213.05,114.83 arc(213.09,114.64) 213.19,114.48 213.27,114.4 arc(213.34,114.36) 213.42,114.34 v4(213.5,114.34)
  SIG9 w0.112: 215.83,105.78 215.8,105.78 arc(215.77,105.77) 215.75,105.76 215.72,105.73 arc(215.67,105.7) 215.61,105.69 215.33,105.69 arc(215.2,105.74) 215.15,105.87 215.15,113.44 arc(215.11,113.62) 215.01,113.77 arc(214.86,113.87) 214.69,113.91 213.26,113.91 arc(213.22,113.91) 213.18,113.94 arc(213.16,113.98) 213.15,114.02 213.15,114.24 arc(213.18,114.31) 213.25,114.34 v4(213.5,114.34)
  SIG9 w0.16: 215.83,105.78 216.29,105.78 arc(216.5,105.74) 216.67,105.62 216.87,105.42 217.14,105.15 219.93,102.36 arc(220.1,102.11) 220.15,101.82 220.15,97.63 arc(220.21,97.33) 220.38,97.09 225.57,91.89 arc(225.74,91.64) 225.8,91.35 225.8,68.49 arc(225.79,68.45) 225.77,68.42 arc(225.74,68.38) 225.73,68.34 225.73,67.69 arc(225.78,67.41) 225.94,67.17 226.11,66.99 arc(226.25,66.9) 226.43,66.86 227.46,66.86 arc(227.7,66.76) 227.8,66.52 227.8,66.34 arc(227.76,66.14) 227.65,65.97 YJ30.A25
FC37_RDP2: length 63.3
  TOP w0.147: v4(212.6,116.34) 212.55,116.34 U1.L19
  SIG8 w0.112: v4(212.6,116.34) 212.62,116.34 arc(212.66,116.33) 212.71,116.3 212.78,116.23 arc(212.81,116.19) 212.82,116.14 212.82,116.03 arc(212.92,115.8) 213.14,115.71 214.71,115.71 arc(214.8,115.69) 214.88,115.64 arc(214.93,115.56) 214.95,115.47 214.95,105.84 arc(215,105.6) 215.13,105.4 arc(215.34,105.26) 215.58,105.21 216.2,105.21 216.29,105.12 216.32,105.12
  SIG8 w0.16: YJ30.A21 224.3,64.67 arc(224.23,65.01) 224.04,65.29 223.69,65.65 arc(223.56,65.84) 223.51,66.07 223.51,67.36 arc(223.56,67.6) 223.69,67.8 225.3,69.41 arc(225.39,69.53) 225.42,69.68 225.42,70.19 225.29,70.31 225.29,71.08 225.42,71.2 225.42,71.71 225.26,71.86 225.26,72.57 225.42,72.73 225.42,91.96 arc(225.39,92.1) 225.3,92.23 224.17,93.36 arc(223.92,93.73) 223.84,94.17 223.84,101.89 arc(223.78,102.18) 223.61,102.42 221.14,104.9 arc(220.9,105.06) 220.6,105.12 216.32,105.12
FC37_RDP3: length 68.6
  TOP w0.147: U1.N18 213.05,118.73 arc(213.07,118.62) 213.13,118.53 213.19,118.47 arc(213.33,118.37) v4(213.5,118.34)
  SIG8 w0.112: v4(213.5,118.34) 213.25,118.34 arc(213.18,118.31) 213.15,118.24 213.15,118.02 arc(213.12,117.9) 213.06,117.8 arc(212.95,117.73) 212.83,117.71 212.46,117.71 arc(212.37,117.69) 212.29,117.64 212.25,117.6 arc(212.18,117.49) 212.15,117.35 212.15,111.27 arc(212.17,111.14) 212.25,111.04 arc(212.35,110.97) 212.48,110.94 212.66,110.94 arc(212.83,110.91) 212.98,110.81 213,110.79 arc(213.11,110.62) 213.15,110.42 213.15,105.15 213.24,105.06 213.24,105.03
  SIG8 w0.16: YJ30.A17 225.32,62.04 arc(225.38,62.13) 225.4,62.24 225.4,62.45 arc(225.38,62.56) 225.32,62.65 225.22,62.76 arc(225.1,62.83) 224.96,62.86 224.28,62.86 arc(223.87,62.94) 223.53,63.17 arc(223.28,63.34) 222.99,63.4 arc(222.94,63.4) 222.9,63.43 222.84,63.49 arc(222.8,63.55) 222.79,63.61 222.79,68.97 arc(222.85,69.26) 223.02,69.51 223.49,69.99 arc(223.66,70.23) 223.72,70.52 223.72,73.45 223.97,73.71 223.97,74.22 223.72,74.47 223.72,91.01 arc(223.66,91.31) 223.49,91.55 221.39,93.65 arc(221.23,93.9) 221.17,94.19 221.17,101.12 arc(221.08,101.56) 220.84,101.93 220.11,102.66 arc(219.74,102.91) 219.3,102.99 215.03,102.99 arc(214.89,103.02) 214.77,103.11 213.32,104.55 arc(213.26,104.64) 213.24,104.75 213.24,105.03
FC37_TDN0: length 68.9
  TOP w0.147: U1.D20 211.55,109.34 v4(211.6,109.34)
  SIG6 w0.112: v4(211.6,109.34) 211.82,109.34 arc(211.91,109.3) 211.95,109.21 211.95,109.05 arc(211.98,108.93) 212.05,108.83 212.06,108.81 arc(212.17,108.74) 212.31,108.71 212.75,108.71 arc(212.83,108.69) 212.89,108.65 arc(212.94,108.58) 212.95,108.5 212.95,105.12 212.86,105.03 212.86,105
  SIG6 w0.16: 212.86,105 212.86,104.3 arc(212.9,104.01) 213.01,103.74 arc(213.09,103.61) 213.2,103.5 213.72,102.97 arc(214.09,102.73) 214.53,102.64 214.72,102.64 arc(214.91,102.6) 215.06,102.5 216.02,101.54 arc(216.19,101.29) 216.24,101 216.24,96.88 arc(216.33,96.45) 216.58,96.08 217.5,95.15 arc(217.75,94.99) 218.04,94.93 218.6,94.93 arc(218.89,94.87) 219.14,94.71 221.55,92.3 arc(221.8,92.13) 222.09,92.07 223.17,92.07 arc(223.32,92.04) 223.44,91.96 225.25,90.15 arc(225.33,90.03) 225.36,89.88 225.36,70.68 arc(225.3,70.39) 225.14,70.14 222.68,67.67 arc(222.43,67.3) 222.34,66.87 222.34,64.69 arc(222.43,64.25) 222.68,63.88 223.21,63.35 arc(223.58,63.1) 224.02,63.01 232.59,63.01 arc(232.74,62.98) 232.86,62.9 232.95,62.82 232.99,62.77 arc(233.05,62.69) 233.1,62.59 arc(233.11,62.53) 233.11,62.48 233.11,62.07 arc(233.13,61.93) 233.18,61.8 arc(233.24,61.71) 233.32,61.62 233.74,61.2 arc(233.86,61.02) 233.9,60.8 YJ30.A6
FC37_TDN1: length 65.4
  TOP w0.147: U1.A17 214.05,106.79 arc(214.18,106.47) v4(214.5,106.34)
  SIG7 w0.112: v4(214.5,106.34) 214.24,106.34 arc(214.12,106.29) 214.07,106.18 214.07,106.06 arc(214.05,105.93) 213.97,105.82 213.96,105.81 arc(213.85,105.74) 213.71,105.71 213.48,105.71 arc(213.35,105.68) 213.24,105.61 arc(213.17,105.5) 213.14,105.37 213.14,105.29 arc(213.19,105.07) 213.31,104.89 213.48,104.72 arc(213.52,104.69) 213.57,104.68 213.65,104.68
  SIG7 w0.16: YJ30.A2 237.25,61.97 arc(237.36,62.14) 237.4,62.34 237.4,62.62 arc(237.33,62.79) 237.16,62.86 236.13,62.86 arc(235.86,62.91) 235.64,63.07 235.53,63.17 arc(235.28,63.34) 234.99,63.39 223.88,63.39 arc(223.58,63.45) 223.34,63.62 222.94,64.01 arc(222.78,64.26) 222.72,64.55 222.72,66.26 arc(222.78,66.55) 222.94,66.8 223.49,67.34 arc(223.65,67.59) 223.71,67.88 223.71,90.39 arc(223.65,90.68) 223.49,90.93 219.42,95 arc(219.07,95.23) 218.66,95.31 217.96,95.31 arc(217.82,95.34) 217.69,95.42 216.46,96.66 arc(216.37,96.78) 216.34,96.93 216.34,101.67 arc(216.29,101.96) 216.12,102.21 213.65,104.68
FC37_TDN2: length 53.8
  TOP w0.147: U1.C18 213.55,108.34 v4(213.6,108.34)
  SIG7 w0.112: 215.41,105.43 215.41,105.5 arc(215.4,105.55) 215.37,105.59 215.18,105.79 arc(215.01,106.04) 214.95,106.33 214.95,107.5 arc(214.94,107.58) 214.89,107.65 arc(214.83,107.69) 214.75,107.71 214.24,107.71 arc(214.1,107.74) 213.98,107.81 213.97,107.82 arc(213.9,107.93) 213.87,108.06 213.87,108.19 213.87,108.19 arc(213.82,108.3) 213.71,108.34 v4(213.6,108.34)
  SIG7 w0.16: 215.41,105.43 217.12,103.72 arc(217.36,103.56) 217.64,103.5 217.82,103.5 arc(217.95,103.48) 218.07,103.4 218.72,102.74 219.38,102.09 arc(219.48,101.93) 219.52,101.75 219.52,97.85 arc(219.61,97.41) 219.85,97.04 225.3,91.59 arc(225.38,91.47) 225.41,91.32 225.41,74.82 arc(225.5,74.39) 225.75,74.02 232.05,67.71 232.05,67.48 232.45,67.08 232.68,67.08 232.95,66.82 232.99,66.77 arc(233.06,66.69) 233.1,66.58 arc(233.11,66.53) 233.11,66.48 233.11,66.07 arc(233.13,65.91) 233.2,65.76 arc(233.26,65.68) 233.34,65.6 233.51,65.43 233.76,65.18 arc(233.86,65.02) 233.9,64.83 YJ30.A33
FC37_TDN3: length 58.6
  TOP w0.147: U1.E17 214.05,110.79 arc(214.18,110.47) v4(214.5,110.34)
  SIG6 w0.112: 215.6,105.75 215.58,105.77 215.45,105.77 215.28,105.94 arc(215.18,106.08) 215.15,106.25 215.15,109.5 arc(215.12,109.66) 215.03,109.79 arc(214.9,109.87) 214.75,109.91 214.24,109.91 arc(214.17,109.92) 214.12,109.95 214.11,109.96 arc(214.08,110.01) 214.07,110.05 214.07,110.21 arc(214.11,110.3) 214.2,110.34 v4(214.5,110.34)
  SIG6 w0.16: YJ30.A37 237.25,65.97 arc(237.36,66.14) 237.4,66.34 237.4,66.52 arc(237.3,66.76) 237.06,66.86 236.31,66.86 arc(236.15,66.89) 236.01,66.98 arc(235.92,67.12) 235.89,67.28 235.89,68.12 arc(235.83,68.41) 235.67,68.66 235.33,69 235.33,69.15 234.75,69.73 234.6,69.73 232.82,71.5 arc(232.66,71.75) 232.6,72.04 232.6,72.04 232.6,87.59 arc(232.51,88.03) 232.27,88.4 226.39,94.28 arc(226.01,94.53) 225.58,94.61 222.98,94.61 arc(222.83,94.64) 222.71,94.72 220.4,97.03 arc(220.24,97.28) 220.18,97.57 220.18,101.59 arc(220.09,102.02) 219.85,102.4 219.02,103.22 arc(218.65,103.47) 218.21,103.55 217.95,103.55 arc(217.81,103.58) 217.68,103.67 215.6,105.75
FC37_TDP0: length 68.9
  TOP w0.147: U1.D19 212.05,109.79 arc(212.18,109.47) v4(212.5,109.34)
  SIG6 w0.112: v4(212.5,109.34) 212.27,109.34 arc(212.18,109.3) 212.15,109.21 212.15,109.05 arc(212.16,109.01) 212.18,108.96 212.2,108.95 arc(212.25,108.92) 212.31,108.91 212.75,108.91 arc(212.9,108.87) 213.03,108.79 arc(213.12,108.66) 213.15,108.5 213.15,105.12 213.24,105.03 213.24,105
  SIG6 w0.16: YJ30.A5 234.85,61.97 arc(234.96,62.14) 235,62.34 235,62.52 arc(234.9,62.76) 234.66,62.86 233.76,62.86 arc(233.46,62.92) 233.22,63.08 233.13,63.17 arc(232.88,63.34) 232.59,63.39 224.02,63.39 arc(223.73,63.45) 223.48,63.62 222.94,64.15 arc(222.78,64.4) 222.72,64.69 222.72,66.87 arc(222.78,67.16) 222.94,67.4 223.59,68.05 223.89,68.05 224.24,68.4 224.24,68.7 225.41,69.87 arc(225.66,70.24) 225.74,70.68 225.74,89.88 arc(225.68,90.17) 225.52,90.42 223.71,92.23 arc(223.46,92.4) 223.17,92.45 222.09,92.45 arc(221.94,92.48) 221.82,92.57 219.41,94.98 arc(219.04,95.23) 218.6,95.31 218.04,95.31 arc(217.89,95.34) 217.77,95.42 216.85,96.34 arc(216.68,96.59) 216.62,96.88 216.62,101 arc(216.54,101.44) 216.29,101.81 215.33,102.77 arc(215.05,102.95) 214.72,103.02 214.53,103.02 arc(214.24,103.08) 213.99,103.24 213.47,103.77 arc(213.4,103.84) 213.34,103.93 arc(213.27,104.11) 213.24,104.3 213.24,105
FC37_TDP1: length 65.4
  TOP w0.147: v4(213.6,106.34) 213.55,106.34 U1.A18
  SIG7 w0.112: v4(213.6,106.34) 213.73,106.34 arc(213.83,106.3) 213.87,106.2 213.87,106.06 arc(213.86,106.01) 213.84,105.96 213.83,105.95 arc(213.77,105.92) 213.71,105.91 213.48,105.91 arc(213.28,105.86) 213.1,105.75 arc(212.99,105.57) 212.95,105.37 212.95,105.29 arc(213.01,104.99) 213.17,104.75 213.34,104.58 arc(213.37,104.54) 213.38,104.49 213.38,104.41
  SIG7 w0.16: 213.38,104.41 215.85,101.94 arc(215.93,101.81) 215.96,101.67 215.96,96.93 arc(216.02,96.64) 216.19,96.39 217.42,95.15 arc(217.67,94.99) 217.96,94.93 218.66,94.93 arc(218.93,94.88) 219.15,94.73 223.22,90.66 arc(223.3,90.54) 223.33,90.39 223.33,69.15 223.13,68.94 223.13,68.46 223.33,68.26 223.33,67.88 arc(223.3,67.73) 223.22,67.61 222.68,67.06 arc(222.43,66.69) 222.34,66.26 222.34,64.55 arc(222.43,64.11) 222.68,63.74 223.07,63.35 arc(223.44,63.1) 223.88,63.01 234.99,63.01 arc(235.14,62.98) 235.26,62.9 235.35,62.82 arc(235.42,62.72) 235.48,62.62 arc(235.48,62.61) 235.48,62.6 arc(235.49,62.58) 235.49,62.56 arc(235.51,62.49) 235.51,62.42 235.51,62.07 arc(235.56,61.84) 235.69,61.65 236.09,61.24 arc(236.25,61.01) 236.3,60.74 YJ30.A3
FC37_TDP2: length 53.8
  TOP w0.147: U1.C17 214.05,108.79 arc(214.18,108.47) v4(214.5,108.34)
  SIG7 w0.112: 215.68,105.7 215.6,105.7 arc(215.55,105.71) 215.51,105.73 215.32,105.93 arc(215.19,106.11) 215.15,106.33 215.15,107.5 arc(215.12,107.66) 215.03,107.79 arc(214.9,107.87) 214.75,107.91 214.24,107.91 arc(214.17,107.92) 214.12,107.95 214.11,107.96 arc(214.08,108.01) 214.07,108.06 214.07,108.2 arc(214.11,108.3) 214.22,108.34 v4(214.5,108.34)
  SIG7 w0.16: 215.68,105.7 217.39,103.99 arc(217.5,103.91) 217.64,103.88 217.82,103.88 arc(218.1,103.83) 218.34,103.67 219.65,102.36 arc(219.83,102.08) 219.9,101.75 219.9,97.85 arc(219.96,97.56) 220.12,97.31 225.57,91.86 arc(225.74,91.62) 225.79,91.32 225.79,74.82 arc(225.85,74.53) 226.02,74.29 233.22,67.08 arc(233.46,66.92) 233.76,66.86 234.66,66.86 arc(234.9,66.76) 235,66.52 235,66.34 arc(234.96,66.14) 234.85,65.97 YJ30.A34
FC37_TDP3: length 58.6
  TOP w0.147: U1.E18 213.22,110.67 213.55,110.34 v4(213.6,110.34)
  SIG6 w0.112: v4(213.6,110.34) 213.75,110.34 arc(213.84,110.3) 213.87,110.21 213.87,110.05 arc(213.9,109.93) 213.97,109.83 213.98,109.81 arc(214.1,109.74) 214.24,109.71 214.75,109.71 arc(214.83,109.69) 214.89,109.65 arc(214.94,109.58) 214.95,109.5 214.95,106.25 arc(215,106.01) 215.14,105.8 215.14,105.8 215.15,105.79 215.31,105.63 215.31,105.5 215.33,105.48
  SIG6 w0.16: 215.33,105.48 217.41,103.4 arc(217.66,103.23) 217.95,103.17 218.21,103.17 arc(218.51,103.11) 218.75,102.95 219.58,102.13 arc(219.74,101.88) 219.8,101.59 219.8,97.57 arc(219.89,97.13) 220.13,96.76 222.44,94.45 arc(222.69,94.29) 222.98,94.23 225.58,94.23 arc(225.87,94.17) 226.12,94.01 232,88.13 arc(232.16,87.88) 232.22,87.59 232.22,72.04 arc(232.31,71.61) 232.55,71.23 235.4,68.39 arc(235.48,68.27) 235.51,68.12 235.51,66.07 arc(235.56,65.84) 235.69,65.65 236.12,65.21 arc(236.25,65.01) 236.3,64.78 YJ30.A36
FC38_39_PVDD0P8: length 5.7
  TOP w0.229: U1.Y22 v1(209.55,125.34) ; U1.Y20 v1(211.55,125.34)
  TOP w0.381: C3164.1 217.08,97.25 ; C3164.1 217.08,95.91 ; C3164.1 217.87,96.64
  BOTTOM w0.13: v1(218.25,97.15) v2(217.49,97.15)
  BOTTOM w0.381: v1(209.55,125.34) 209.07,125.82 C3123.1 ; C3318.1 212.04,125.83 v1(211.55,125.34)
  vias: v1(218.25,96.14)
FC38_RDN0: length 53.7
  TOP w0.147: U1.C14 217.55,108.34 v4(217.55,108.29)
  SIG2 w0.112: 219.5,105.69 219.37,105.69 219.25,105.8 arc(219.15,105.96) 219.11,106.15 219.11,107.51 arc(219.08,107.67) 218.99,107.81 arc(218.85,107.91) 218.68,107.94 218.01,107.94 arc(217.91,107.96) 217.82,108.02 v4(217.55,108.29)
  SIG2 w0.16: 219.5,105.69 221.3,103.89 arc(221.58,103.47) 221.68,102.97 221.68,100.64 arc(221.74,100.35) 221.9,100.1 223.87,98.14 arc(224.03,97.89) 224.09,97.6 224.09,96.43 arc(224.12,96.28) 224.2,96.16 232.2,88.16 arc(232.45,87.79) 232.54,87.35 232.54,75.02 arc(232.6,74.73) 232.76,74.49 237.68,69.57 arc(237.85,69.32) 237.91,69.03 237.91,65.97 arc(237.88,65.85) 237.81,65.75 237.28,65.22 arc(237.15,65.01) 237.1,64.78 YJ29.C21
FC38_RDN1: length 62.7
  TOP w0.147: U1.B12 219.14,107.84 arc(219.24,107.82) 219.32,107.77 219.5,107.59 arc(219.54,107.53) 219.55,107.47 v4(219.55,107.39)
  SIG2 w0.112: v4(219.55,107.39) 219.55,107.58 arc(219.56,107.63) 219.59,107.67 219.62,107.71 arc(219.66,107.73) 219.71,107.74 220.74,107.74 arc(220.8,107.73) 220.86,107.69 arc(220.9,107.63) 220.91,107.56 220.91,106.35 arc(220.97,106.1) 221.11,105.88 221.11,105.88 221.17,105.82 221.31,105.68 221.31,105.55 221.33,105.53
  SIG2 w0.16: 221.33,105.53 221.62,105.24 arc(222,104.99) 222.45,104.9 223.49,104.9 arc(223.78,104.84) 224.03,104.68 226.92,101.79 arc(227.08,101.54) 227.14,101.25 227.14,96.55 arc(227.2,96.26) 227.36,96.01 234.03,89.35 arc(234.19,89.1) 234.25,88.81 234.25,76.24 arc(234.34,75.8) 234.58,75.43 240.08,69.93 arc(240.16,69.81) 240.19,69.66 240.19,68.36 239.96,68.13 239.96,67.57 240.19,67.34 240.19,66.83 239.99,66.63 239.99,66.02 240.19,65.82 240.19,65.31 arc(240.16,65.16) 240.08,65.04 239.64,64.6 239.35,64.6 238.92,64.16 238.92,63.88 238.56,63.52 arc(238.44,63.44) 238.29,63.41 235.95,63.41 arc(235.77,63.38) 235.6,63.32 arc(235.5,63.26) 235.41,63.18 235.36,63.13 235.31,63.08 arc(235.07,62.92) 234.78,62.86 233.87,62.86 arc(233.68,62.78) 233.61,62.6 233.61,62.32 arc(233.64,62.13) 233.75,61.97 YJ29.C14
FC38_RDN2: length 51.1
  TOP w0.147: v4(221.55,108.29) 221.55,108.34 U1.C10
  SIG3 w0.112: 223.2,105.73 223.2,105.75 223.11,105.85 223.11,107.56 arc(223.08,107.71) 223,107.83 arc(222.88,107.91) 222.74,107.94 222.4,107.94 arc(221.94,108.03) v4(221.55,108.29)
  SIG3 w0.16: YJ29.C24 234.7,64.78 arc(234.75,65.02) 234.88,65.21 235.36,65.69 arc(235.45,65.83) 235.48,66 235.48,67.54 arc(235.43,67.83) 235.26,68.08 232.77,70.56 arc(232.61,70.81) 232.55,71.1 232.55,87.8 arc(232.49,88.09) 232.33,88.34 226.88,93.78 arc(226.71,93.92) 226.52,94.03 226.26,94.13 arc(226.2,94.17) 226.14,94.21 224.32,96.04 arc(224.15,96.29) 224.09,96.58 224.09,101.92 arc(224.03,102.21) 223.87,102.46 223.43,102.9 arc(223.26,103.14) 223.2,103.44 223.2,105.73
FC38_RDN3: length 56.4
  TOP w0.147: v4(223.55,107.39) 223.44,107.39 arc(223.34,107.41) 223.26,107.47 223.17,107.56 arc(223.08,107.69) U1.B8
  SIG3 w0.112: v4(223.55,107.39) 223.55,107.63 arc(223.65,107.82) 223.87,107.85 arc(224.13,107.77) 224.4,107.74 224.4,107.74 224.74,107.74 arc(224.8,107.73) 224.86,107.69 arc(224.9,107.63) 224.91,107.56 224.91,105.27 224.82,105.18 224.82,105.15
  SIG3 w0.16: YJ29.C17 236.15,61.97 arc(236.04,62.13) 236.01,62.32 236.01,62.6 arc(236.08,62.79) 236.27,62.86 237.18,62.86 arc(237.47,62.92) 237.72,63.08 238.94,64.31 arc(239.02,64.43) 239.05,64.58 239.05,67.53 arc(239.02,67.67) 238.94,67.79 238.46,68.28 238.07,68.28 237.74,68.61 237.74,69 234.58,72.15 arc(234.34,72.52) 234.25,72.96 234.25,89.35 arc(234.22,89.49) 234.14,89.62 227.47,96.28 arc(227.23,96.65) 227.14,97.09 227.14,101.74 arc(227.08,102.03) 226.92,102.27 225.16,104.03 arc(224.91,104.4) 224.82,104.84 224.82,105.15
FC38_RDP0: length 53.7
  TOP w0.147: U1.B14 217.13,107.84 arc(217.23,107.82) 217.31,107.77 217.5,107.58 arc(217.54,107.53) 217.55,107.46 v4(217.55,107.39)
  SIG2 w0.112: 219.23,105.42 219.21,105.44 219.21,105.57 219.11,105.66 arc(218.97,105.88) 218.91,106.15 218.91,107.51 arc(218.9,107.6) 218.85,107.67 arc(218.77,107.73) 218.68,107.74 217.68,107.74 arc(217.59,107.71) 217.55,107.62 v4(217.55,107.39)
  SIG2 w0.16: YJ29.C22 236.15,65.97 arc(236.04,66.13) 236.01,66.32 236.01,66.6 arc(236.08,66.79) 236.26,66.86 237.19,66.86 arc(237.32,66.89) 237.43,66.96 arc(237.44,66.97) 237.45,66.99 arc(237.51,67.08) 237.53,67.19 237.53,69.03 arc(237.5,69.17) 237.41,69.3 237.05,69.66 236.8,69.66 236.34,70.12 236.34,70.37 235.98,70.73 235.72,70.73 235.26,71.19 235.26,71.45 234.9,71.81 234.62,71.81 234.18,72.25 234.18,72.53 233.82,72.89 233.56,72.89 233.1,73.35 233.1,73.61 232.49,74.22 arc(232.25,74.59) 232.16,75.03 232.16,87.35 arc(232.1,87.64) 231.94,87.89 223.93,95.89 arc(223.77,96.13) 223.71,96.43 223.71,97.6 arc(223.68,97.74) 223.6,97.87 221.63,99.83 arc(221.38,100.21) 221.3,100.64 221.3,102.97 arc(221.23,103.32) 221.03,103.62 219.23,105.42
FC38_RDP1: length 62.7
  TOP w0.147: v4(219.55,108.29) 219.55,108.34 U1.C12
  SIG2 w0.112: v4(219.55,108.29) 219.81,108.03 arc(219.91,107.96) 220.03,107.94 220.74,107.94 arc(220.88,107.91) 221,107.83 arc(221.08,107.71) 221.11,107.56 221.11,106.35 arc(221.15,106.17) 221.25,106.02 221.45,105.82 221.58,105.82 221.6,105.8
  SIG2 w0.16: 221.6,105.8 221.89,105.51 arc(222.15,105.34) 222.45,105.28 223.49,105.28 arc(223.93,105.19) 224.3,104.95 227.19,102.06 arc(227.43,101.69) 227.52,101.25 227.52,96.55 arc(227.55,96.4) 227.63,96.28 234.3,89.62 arc(234.54,89.24) 234.63,88.81 234.63,76.24 234.63,76.24 arc(234.69,75.94) 234.85,75.7 240.35,70.2 arc(240.51,69.96) 240.57,69.66 240.57,65.31 arc(240.51,65.02) 240.35,64.77 238.83,63.25 arc(238.58,63.08) 238.29,63.03 235.95,63.03 arc(235.86,63.01) 235.78,62.98 arc(235.73,62.95) 235.68,62.91 235.63,62.86 arc(235.54,62.72) 235.51,62.57 235.51,61.97 arc(235.48,61.85) 235.41,61.75 234.86,61.19 arc(234.74,61.02) 234.7,60.81 YJ29.C15
FC38_RDP2: length 51.1
  TOP w0.147: v4(221.55,107.39) 221.44,107.39 arc(221.34,107.41) 221.26,107.47 221.17,107.56 arc(221.08,107.69) U1.B10
  SIG3 w0.112: v4(221.55,107.39) 221.55,107.63 arc(221.65,107.82) 221.87,107.85 arc(222.13,107.77) 222.4,107.74 222.4,107.74 222.74,107.74 arc(222.8,107.73) 222.86,107.69 arc(222.9,107.63) 222.91,107.56 222.91,105.85 222.82,105.75 222.82,105.73
  SIG3 w0.16: YJ29.C25 233.75,65.97 arc(233.64,66.13) 233.61,66.32 233.61,66.6 arc(233.68,66.78) 233.87,66.86 234.79,66.86 arc(234.9,66.88) 234.99,66.94 235,66.95 arc(235.08,67.06) 235.1,67.19 235.1,67.54 arc(235.07,67.68) 234.99,67.81 234.63,68.17 234.3,68.17 233.91,68.55 233.91,68.88 233.56,69.24 233.29,69.24 232.78,69.75 232.78,70.02 232.5,70.29 arc(232.26,70.66) 232.17,71.1 232.17,87.8 arc(232.14,87.94) 232.06,88.07 226.61,93.51 arc(226.5,93.6) 226.37,93.67 226.12,93.78 arc(225.99,93.85) 225.87,93.94 224.05,95.77 arc(223.8,96.14) 223.71,96.58 223.71,101.92 arc(223.68,102.06) 223.6,102.19 223.16,102.63 arc(222.91,103) 222.82,103.44 222.82,105.73
FC38_RDP3: length 56.4
  TOP w0.147: v4(223.55,108.29) 223.55,108.34 U1.C8
  SIG3 w0.112: 225.2,105.15 225.2,105.18 225.11,105.27 225.11,107.56 arc(225.08,107.71) 225,107.83 arc(224.88,107.91) 224.74,107.94 224.4,107.94 arc(223.94,108.03) v4(223.55,108.29)
  SIG3 w0.16: 225.2,105.15 225.2,104.84 arc(225.26,104.55) 225.43,104.3 227.19,102.54 arc(227.44,102.17) 227.52,101.74 227.52,97.09 arc(227.58,96.8) 227.74,96.55 234.41,89.88 arc(234.57,89.64) 234.63,89.35 234.63,72.96 arc(234.69,72.67) 234.85,72.42 239.21,68.06 arc(239.38,67.82) 239.43,67.53 239.43,64.58 arc(239.38,64.29) 239.21,64.04 238.03,62.86 arc(237.94,62.72) 237.91,62.57 237.91,61.97 arc(237.88,61.85) 237.81,61.75 237.3,61.23 arc(237.15,61.01) 237.1,60.75 YJ29.C18
FC38_TDN0: length 63.1
  TOP w0.147: U1.A4 227.1,106.84 arc(227.42,106.71) v4(227.55,106.39)
  SIG5 w0.112: 227.23,105.1 227.13,105.2 227.13,106.73 arc(227.15,106.79) 227.18,106.84 227.19,106.85 arc(227.23,106.88) 227.28,106.89 227.42,106.89 arc(227.51,106.85) 227.55,106.76 v4(227.55,106.39)
  SIG5 w0.155: 228.31,61.97 arc(228.3,61.91) 228.28,61.84
  SIG5 w0.16: 227.23,105.1 227.23,103.07 227.23,103.07 arc(227.25,102.95) 227.33,102.84 227.37,102.79 arc(227.58,102.49) 227.65,102.13 227.65,93.17 arc(227.68,93.03) 227.76,92.9 232.22,88.45 arc(232.46,88.08) 232.55,87.64 232.55,73.2 arc(232.61,72.91) 232.77,72.66 238.97,66.46 arc(239.14,66.22) 239.19,65.92 239.19,64.44 arc(239.14,64.15) 238.97,63.9 238.32,63.25 arc(238.07,63.08) 237.78,63.03 228.75,63.03 arc(228.61,63) 228.48,62.91 228.43,62.86 arc(228.35,62.76) 228.31,62.64 arc(228.31,62.6) 228.31,62.57 228.31,61.97 ; YJ29.C6 227.5,60.76 arc(227.55,61.01) 227.69,61.23 227.9,61.43 228.19,61.72 arc(228.24,61.78) 228.28,61.84
FC38_TDN1: length 46.7
  TOP w0.147: U1.B6 225.55,107.34 v4(225.55,107.29)
  SIG5 w0.112: 224.85,105.15 224.94,105.24 224.94,106.73 arc(224.96,106.87) 225.04,106.98 225.05,106.99 arc(225.16,107.06) 225.28,107.09 225.42,107.09 arc(225.51,107.12) 225.55,107.21 v4(225.55,107.29)
  SIG5 w0.16: 224.85,105.15 224.85,103.53 arc(224.82,103.38) 224.74,103.26 224.05,102.57 arc(223.8,102.2) 223.71,101.76 223.71,94.15 223.71,94.15 arc(223.66,93.9) 223.52,93.69 arc(223.38,93.48) 223.33,93.23 223.33,75.98 arc(223.42,75.54) 223.67,75.17 227.81,71.02 arc(227.9,70.9) 227.93,70.75 227.93,70.3 227.75,70.12 227.75,69.56 227.93,69.38 227.93,68.92 227.77,68.77 227.77,68.16 227.93,68.01 227.93,67.06 arc(227.9,66.97) 227.83,66.89 arc(227.8,66.88) 227.77,66.87 arc(227.75,66.86) 227.72,66.86 226.68,66.86 arc(226.49,66.78) 226.41,66.59 226.41,66.32 arc(226.44,66.13) 226.55,65.97 YJ29.C34
FC38_TDN2: length 66.6
  TOP w0.147: U1.C3 228.07,108.84 arc(228.26,108.81) 228.41,108.7 228.49,108.62 arc(228.53,108.56) 228.55,108.48 v4(228.55,108.39)
  SIG4 w0.112: 229.42,106.35 229.4,106.37 229.4,106.42 229.41,106.5 229.13,106.77 arc(229.02,106.93) 228.99,107.12 228.99,108.64 arc(228.97,108.7) 228.94,108.75 arc(228.89,108.78) 228.83,108.79 228.68,108.79 arc(228.59,108.76) 228.55,108.67 v4(228.55,108.39)
  SIG4 w0.16: YJ29.C2 224.15,61.97 arc(224.04,62.13) 224.01,62.32 224.01,62.52 arc(224.11,62.76) 224.35,62.86 225.18,62.86 arc(225.47,62.92) 225.72,63.08 225.76,63.13 225.81,63.18 arc(226.06,63.35) 226.35,63.41 237.78,63.41 arc(237.93,63.44) 238.05,63.52 238.69,64.16 arc(238.78,64.28) 238.81,64.43 238.81,66.29 238.63,66.47 238.63,67.13 238.81,67.31 238.81,67.9 arc(238.78,68.04) 238.69,68.17 238.37,68.49 238.05,68.49 237.72,68.81 237.72,69.14 237.4,69.46 237.08,69.46 236.75,69.78 236.75,70.11 234.59,72.28 arc(234.34,72.65) 234.25,73.08 234.25,77.18 arc(234.22,77.32) 234.14,77.45 232.81,78.78 arc(232.56,79.15) 232.47,79.59 232.47,90.77 arc(232.44,90.91) 232.36,91.04 230.78,92.62 arc(230.53,92.99) 230.44,93.43 230.44,104.93 arc(230.44,105.04) 230.42,105.15 arc(230.32,105.4) 230.16,105.61 229.42,106.35
FC38_TDN3: length 47.6
  TOP w0.147: U1.D5 226.55,109.34 v4(226.55,109.29)
  SIG4 w0.112: 227.23,105.18 227.11,105.3 227.11,107.59 arc(227.12,107.64) 227.15,107.68 arc(227.17,107.72) 227.18,107.76 227.18,108.72 arc(227.16,108.85) 227.08,108.96 arc(226.97,109.04) 226.83,109.07 226.78,109.07 arc(226.73,109.08) 226.7,109.1 226.58,109.22 arc(226.56,109.25) v4(226.55,109.29)
  SIG4 w0.16: YJ29.C36 225.1,64.85 arc(225.13,65.02) 225.23,65.16 225.52,65.46 225.81,65.75 arc(225.88,65.85) 225.91,65.97 225.91,75.06 arc(225.85,75.35) 225.68,75.6 225.46,75.82 arc(225.29,76.07) 225.23,76.36 225.23,91.48 arc(225.29,91.77) 225.46,92.02 227.42,93.98 arc(227.59,94.23) 227.65,94.52 227.65,103.69 arc(227.59,103.96) 227.44,104.19 227.39,104.24 arc(227.27,104.42) 227.23,104.63 227.23,105.18
FC38_TDP0: length 63.1
  TOP w0.147: U1.B4 227.55,107.34 v4(227.55,107.29)
  SIG5 w0.112: v4(227.55,107.29) 227.55,107.21 arc(227.51,107.12) 227.42,107.09 227.28,107.09 arc(227.16,107.06) 227.05,106.99 227.04,106.98 arc(226.96,106.87) 226.94,106.73 226.94,105.19 226.85,105.1
  SIG5 w0.16: YJ29.C5 226.55,61.97 arc(226.44,62.13) 226.41,62.32 226.41,62.59 arc(226.49,62.78) 226.68,62.86 227.58,62.86 arc(227.87,62.92) 228.12,63.08 228.16,63.13 228.21,63.18 arc(228.46,63.35) 228.75,63.41 237.78,63.41 arc(237.93,63.44) 238.05,63.52 238.7,64.17 arc(238.78,64.29) 238.81,64.44 238.81,65.92 arc(238.78,66.07) 238.7,66.19 237.65,67.24 237.33,67.24 237.01,67.57 237.01,67.89 236.68,68.21 232.5,72.39 arc(232.26,72.76) 232.17,73.2 232.17,87.64 arc(232.11,87.93) 231.95,88.18 227.49,92.63 arc(227.32,92.88) 227.27,93.17 227.27,102.13 arc(227.22,102.34) 227.1,102.52 227.06,102.57 arc(226.9,102.8) 226.85,103.07 226.85,105.1
FC38_TDP1: length 46.7
  TOP w0.147: U1.A6 225.1,106.84 arc(225.42,106.71) v4(225.55,106.39)
  SIG5 w0.112: v4(225.55,106.39) 225.55,106.76 arc(225.51,106.85) 225.42,106.89 225.28,106.89 arc(225.23,106.88) 225.19,106.85 225.18,106.84 arc(225.15,106.79) 225.13,106.73 225.13,105.25 225.23,105.15
  SIG5 w0.16: 225.23,105.15 225.23,103.53 arc(225.17,103.24) 225.01,102.99 224.32,102.3 arc(224.15,102.05) 224.09,101.76 224.09,94.15 arc(224.01,93.75) 223.79,93.42 arc(223.73,93.33) 223.71,93.23 223.71,75.98 arc(223.77,75.69) 223.94,75.44 228.08,71.29 arc(228.25,71.04) 228.31,70.75 228.31,66.06 arc(228.27,65.86) 228.15,65.69 228.08,65.62 227.62,65.15 arc(227.53,65.02) 227.5,64.86 YJ29.C33
FC38_TDP2: length 66.6
  TOP w0.147: U1.D3 228.55,109.34 v4(228.55,109.29)
  SIG4 w0.112: v4(228.55,109.29) 228.55,109.27 arc(228.57,109.16) 228.63,109.07 228.67,109.03 arc(228.72,109) 228.77,108.99 228.83,108.99 arc(228.97,108.96) 229.08,108.89 arc(229.16,108.77) 229.18,108.64 229.18,107.12 arc(229.21,107.01) 229.27,106.91 229.54,106.64 229.67,106.64 229.69,106.62
  SIG4 w0.16: 229.69,106.62 230.43,105.88 arc(230.65,105.58) 230.79,105.24 arc(230.81,105.09) 230.82,104.93 230.82,93.43 arc(230.88,93.14) 231.05,92.89 232.63,91.31 arc(232.8,91.06) 232.85,90.77 232.85,79.59 arc(232.91,79.29) 233.08,79.05 234.41,77.72 arc(234.57,77.47) 234.63,77.18 234.63,73.08 arc(234.69,72.79) 234.86,72.55 238.96,68.44 arc(239.13,68.19) 239.19,67.9 239.19,64.43 arc(239.13,64.14) 238.96,63.89 238.32,63.25 arc(238.07,63.08) 237.78,63.03 226.35,63.03 arc(226.21,63) 226.08,62.91 226.03,62.86 arc(225.94,62.72) 225.91,62.57 225.91,61.97 arc(225.88,61.85) 225.81,61.75 225.28,61.21 arc(225.15,61.02) 225.1,60.78 YJ29.C3
FC38_TDP3: length 47.6
  TOP w0.147: v4(226.55,108.39) 226.55,108.48 arc(226.53,108.56) 226.49,108.62 226.41,108.7 arc(226.26,108.81) 226.07,108.84 U1.C5
  SIG4 w0.112: 226.85,105.18 226.91,105.25 226.91,107.59 arc(226.93,107.7) 226.99,107.79 226.99,108.72 arc(226.97,108.78) 226.94,108.83 arc(226.89,108.86) 226.83,108.87 226.68,108.87 arc(226.59,108.83) 226.55,108.74 v4(226.55,108.39)
  SIG4 w0.16: 226.85,105.18 226.85,104.63 arc(226.92,104.27) 227.12,103.97 227.17,103.92 arc(227.24,103.82) 227.27,103.69 227.27,94.52 arc(227.24,94.38) 227.15,94.25 225.19,92.29 arc(224.94,91.91) 224.85,91.48 224.85,76.36 arc(224.94,75.92) 225.19,75.55 225.41,75.33 arc(225.5,75.2) 225.53,75.06 225.53,70.15 225.35,69.97 225.35,69.41 225.53,69.23 225.53,68.78 225.32,68.57 225.32,67.96 225.53,67.76 225.53,67.08 arc(225.46,66.92) 225.31,66.86 224.3,66.86 arc(224.09,66.78) 224.01,66.57 224.01,66.32 arc(224.04,66.13) 224.15,65.97 YJ29.C37
FC39_RDN0: length 79.5
  TOP w0.147: v4(217.55,111.29) 217.55,111.34 U1.F14
  SIG2 w0.112: 231.96,110.04 231.94,110.04 231.84,109.94 218.57,109.94 arc(218.42,109.97) 218.3,110.06 arc(218.21,110.18) 218.18,110.33 218.18,110.63 arc(218.16,110.75) 218.09,110.85 arc(217.99,110.92) 217.88,110.94 217.68,110.94 arc(217.59,110.98) 217.55,111.07 v4(217.55,111.29)
  SIG2 w0.16: YJ29.D24 234.7,56.79 arc(234.75,57.02) 234.88,57.21 235.41,57.75 arc(235.48,57.85) 235.51,57.97 235.51,58.57 arc(235.54,58.72) 235.63,58.86 235.68,58.91 arc(235.73,58.95) 235.78,58.98 arc(235.86,59.01) 235.95,59.03 238.23,59.03 arc(238.52,59.08) 238.77,59.25 242.76,63.24 arc(243,63.61) 243.09,64.05 243.09,69.91 arc(243,70.34) 242.76,70.72 239.81,73.66 arc(239.64,73.91) 239.59,74.2 239.59,78.19 arc(239.53,78.48) 239.36,78.73 238.03,80.06 arc(237.87,80.31) 237.81,80.6 237.81,89.87 arc(237.72,90.31) 237.47,90.68 233.22,94.94 arc(233.14,95.06) 233.11,95.2 233.11,109.41 arc(233.07,109.62) 232.95,109.79 232.91,109.84 arc(232.69,109.98) 232.43,110.04 231.96,110.04
FC39_RDN1: length 71.9
  TOP w0.147: v4(221.55,110.39) 221.44,110.39 arc(221.34,110.41) 221.26,110.47 221.17,110.56 arc(221.08,110.69) U1.E10
  SIG3 w0.112: v4(221.55,110.39) 221.55,110.62 arc(221.59,110.71) 221.68,110.74 221.88,110.74 arc(221.92,110.73) 221.95,110.71 arc(221.98,110.68) 221.99,110.63 221.99,110.32 arc(222.03,110.1) 222.16,109.91 arc(222.35,109.79) 222.57,109.74 231.86,109.74 231.95,109.65 231.98,109.65
  SIG3 w0.16: YJ29.D22 236.15,57.97 arc(236.04,58.13) 236.01,58.32 236.01,58.56 arc(236.09,58.77) 236.31,58.86 237.18,58.86 arc(237.47,58.92) 237.72,59.09 238.08,59.45 238.08,59.8 238.44,60.16 238.8,60.16 239.15,60.52 239.15,60.86 239.54,61.24 239.87,61.24 240.23,61.6 240.23,61.93 240.62,62.32 240.95,62.32 241.35,62.72 arc(241.43,62.84) 241.46,62.99 241.46,63.49 241.21,63.75 241.21,64.26 241.46,64.51 241.46,68.04 arc(241.43,68.18) 241.35,68.31 237,72.66 arc(236.75,73.03) 236.66,73.47 236.66,90.8 arc(236.63,90.94) 236.55,91.07 233.06,94.55 arc(232.81,94.92) 232.73,95.36 232.73,109.16 arc(232.73,109.2) 232.72,109.24 arc(232.68,109.34) 232.62,109.43 232.5,109.54 arc(232.38,109.62) 232.23,109.65 231.98,109.65
FC39_RDN2: length 94.8
  TOP w0.147: v4(219.55,111.29) 219.55,111.34 U1.F12
  SIG2 w0.112: 232.47,112.04 232.44,112.04 232.35,111.94 220.57,111.94 arc(220.35,111.9) 220.16,111.77 arc(220.03,111.58) 219.99,111.36 219.99,111.05 arc(219.98,111.01) 219.95,110.97 arc(219.92,110.95) 219.88,110.94 219.68,110.94 arc(219.59,110.98) 219.55,111.07 v4(219.55,111.29)
  SIG2 w0.16: 232.47,112.04 234.04,112.04 arc(234.33,111.98) 234.58,111.81 235.81,110.58 arc(235.97,110.34) 236.03,110.04 236.03,102.93 arc(236.09,102.64) 236.25,102.39 238.6,100.04 arc(238.85,99.88) 239.14,99.82 245.11,99.82 arc(245.55,99.73) 245.92,99.48 250.43,94.98 arc(250.67,94.61) 250.76,94.17 250.76,67.75 arc(250.7,67.46) 250.54,67.21 238.58,55.25 arc(238.33,55.08) 238.04,55.03 235.95,55.03 arc(235.86,55.01) 235.78,54.98 arc(235.73,54.95) 235.68,54.91 235.63,54.86 arc(235.54,54.72) 235.51,54.57 235.51,53.97 arc(235.48,53.85) 235.41,53.75 234.87,53.21 arc(234.75,53.02) 234.7,52.79 YJ29.D15
FC39_RDN3: length 79.7
  TOP w0.147: v4(223.55,110.39) 223.44,110.39 arc(223.34,110.41) 223.26,110.47 223.17,110.56 arc(223.08,110.69) U1.E8
  SIG3 w0.112: v4(223.55,110.39) 223.55,110.62 arc(223.59,110.71) 223.68,110.74 223.88,110.74 arc(223.99,110.77) 224.09,110.83 arc(224.16,110.93) 224.18,111.05 224.18,111.36 arc(224.21,111.51) 224.3,111.63 arc(224.42,111.72) 224.57,111.75 232.1,111.75 232.19,111.65 232.22,111.65
  SIG3 w0.16: 232.22,111.65 233.96,111.65 arc(234.11,111.62) 234.23,111.54 235.54,110.24 arc(235.62,110.11) 235.65,109.97 235.65,95.36 arc(235.74,94.92) 235.98,94.55 238.63,91.91 arc(238.71,91.78) 238.74,91.64 238.74,74.31 arc(238.83,73.87) 239.08,73.5 243.44,69.14 arc(243.52,69.02) 243.55,68.87 243.55,62.47 243.29,62.21 243.29,61.7 243.55,61.45 243.55,60.94 243.29,60.69 243.29,60.18 243.55,59.93 243.55,59.42 arc(243.49,59.13) 243.32,58.88 242.41,57.96 242.05,57.96 241.69,57.6 241.69,57.25 241.15,56.71 240.79,56.71 240.43,56.35 240.43,55.99 240.07,55.63 arc(239.83,55.46) 239.54,55.41 238.35,55.41 arc(238.06,55.35) 237.81,55.18 237.76,55.13 237.72,55.08 arc(237.47,54.92) 237.18,54.86 236.36,54.86 arc(236.11,54.76) 236.01,54.51 236.01,54.32 arc(236.04,54.13) 236.15,53.97 YJ29.D17
FC39_RDP0: length 79.5
  TOP w0.147: U1.E14 217.16,110.84 arc(217.25,110.82) 217.33,110.77 217.49,110.61 arc(217.53,110.55) 217.55,110.47 v4(217.55,110.39)
  SIG2 w0.112: 231.96,109.65 231.94,109.65 231.84,109.75 218.57,109.75 arc(218.35,109.79) 218.16,109.92 arc(218.03,110.11) 217.99,110.33 217.99,110.63 arc(217.98,110.68) 217.95,110.71 arc(217.92,110.73) 217.88,110.74 217.68,110.74 arc(217.59,110.71) 217.55,110.62 v4(217.55,110.39)
  SIG2 w0.16: 231.96,109.65 232.43,109.65 arc(232.54,109.63) 232.64,109.57 232.68,109.52 arc(232.72,109.47) 232.73,109.41 232.73,95.2 arc(232.79,94.91) 232.95,94.67 237.2,90.41 arc(237.37,90.17) 237.43,89.87 237.43,80.6 arc(237.51,80.17) 237.76,79.79 239.09,78.46 arc(239.18,78.34) 239.2,78.19 239.2,74.2 arc(239.29,73.76) 239.54,73.39 242.49,70.45 arc(242.65,70.2) 242.71,69.91 242.71,65.57 242.46,65.32 242.46,64.81 242.71,64.56 242.71,64.05 arc(242.65,63.76) 242.49,63.51 241.73,62.75 241.37,62.75 241.01,62.39 241.01,62.03 240.65,61.67 240.29,61.67 239.93,61.31 239.93,60.96 239.57,60.6 239.27,60.6 238.86,60.19 238.86,59.88 238.5,59.52 arc(238.37,59.44) 238.23,59.41 235.95,59.41 arc(235.77,59.38) 235.6,59.32 arc(235.5,59.26) 235.41,59.18 235.36,59.13 235.31,59.08 arc(235.07,58.92) 234.78,58.86 233.88,58.86 arc(233.69,58.78) 233.61,58.58 233.61,58.32 arc(233.64,58.13) 233.75,57.97 YJ29.D25
