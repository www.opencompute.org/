# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC_RX_60: length 44.1
  TOP w0.508: v1(391.48,82.42) 391.1,82.8 C2606.1 390.06,83.41 390.31,83.67 C2605.2 390.54,84.81 L396.1
  SIG1 w0.508: YJ35.C10 371.7,60.03 372.3,59.43 379.41,59.43 384.11,64.13 384.11,72.77 388.56,77.21 388.56,79.5 v1(391.48,82.42)
  BOTTOM w0.13: v1(391.48,82.42) 391.6,82.55 v2(392.62,82.55)
VCC_RX_61: length 46.4
  SIG1 w0.508: v1(368.16,80.79) 367.47,80.11 367.47,75.31 362.26,70.09 362.26,57.25 364.42,55.1 370.82,55.1 371.7,54.21 YJ35.D10
  BOTTOM w0.13: L397.1 374.13,84 v2(374.33,84.2)
  BOTTOM w0.508: L397.1 373.19,82.17 372.83,81.81 C2609.2 C2610.1 369.18,81.81 v1(368.16,80.79)
VCC_RX_62: length 38.7
  POWER2 w0.508: YJ36.B10 371.7,54.21 370.82,55.1 364.42,55.1 362.26,57.25 362.26,72.63 v1(365.7,76.07)
  BOTTOM w0.508: L410.1 367.17,79.86 C2636.2 366.94,78.59 366.69,78.33 C2637.1 366.69,76.73 v2(366.71,76.71) 366.08,76.07 v1(365.7,76.07)
VCC_RX_63: length 45.8
  POWER2 w0.508: v1(391.48,83.44) 389.08,81.04 389.08,77.86 384.87,73.65 384.87,64.26 379.92,59.31 372.3,59.31 371.7,59.91 YJ36.A10
  BOTTOM w0.13: v1(391.48,83.44) 392.11,84.07 v2(392.11,84.45)
  BOTTOM w0.508: L411.1 390.54,84.81 C2640.2 390.31,83.92 390.06,83.67 C2641.1 390.84,82.8 v1(391.48,83.44)
VCC_TX_0: length 24.3
  POWER2 w0.508: v1(15.18,80.01) 15.18,79.12 15.81,78.48 15.81,76.93 15.56,76.68 15.56,74.93 23.7,66.78 YJ21.A29
  BOTTOM w0.508: v1(15.18,80.01) 14.92,80.01 14.54,80.39 C2168.1 13.88,81.02 14.14,81.28 C2167.2 14.14,83.18 14.36,83.41 L234.1
VCC_TX_1: length 33.2
  POWER2 w0.508: v1(8.04,71.75) 8.06,71.75 9,70.81 9,69.51 14.13,64.39 14.13,63.13 15.02,62.24 15.02,60.94 16.92,59.03 23.15,59.03 23.7,58.48 YJ21.B29
  BOTTOM w0.508: v1(8.04,71.75) 7.81,71.75 7.18,72.39 v2(7.18,73.78) 7.94,74.55 C2170.1 8.47,75.41 8.22,75.66 C2169.2 8.22,77.09 7.99,77.32 L235.1
VCC_TX_2: length 32.6
  TOP w0.508: v1(8.47,73.51) C2196.1 8.22,74.8 C2195.2 7.99,76.55 L244.1
  SIG10 w0.508: YJ22.D29 23.7,58.45 23.12,59.03 16.91,59.03 15.01,60.94 15.01,66.97 v1(8.47,73.51)
  BOTTOM w0.13: v1(8.47,73.51) 8.47,73.28 v2(7.96,72.77)
VCC_TX_3: length 27.7
  TOP w0.508: v1(15.18,81.02) 14.54,80.39 C2198.1 13.88,81.13 14.14,81.38 C2197.2 14.14,82.93 14.36,83.16 L245.1
  SIG10 w0.508: v1(15.18,81.02) 14.41,80.26 14.41,79.25 15.68,77.98 18.73,77.98 19.24,77.47 19.24,72.13 23.7,67.67 YJ22.C29
VCC_TX_4: length 27.8
  SIG10 w0.508: v1(43.8,83.82) 44.51,83.82 45.02,83.31 45.02,82.63 45.53,82.12 45.53,69.59 42.7,66.76 YJ21.C29
  BOTTOM w0.254: v2(42.68,84.35) 42.96,84.07 43.55,84.07 v1(43.8,83.82)
  BOTTOM w0.508: v1(43.8,83.82) 43.93,83.69 C2164.1 44.92,84.43 44.67,84.68 C2163.2 44.67,86.51 44.44,86.74 L232.1
VCC_TX_5: length 48.3
  TOP w0.508: L233.1 33.67,93.42 33.44,93.19 C2165.2 33.44,91.41 33.06,91.03 C2166.1 33.06,89.81 37.72,85.15 37.72,81.28 35.5,79.06 v1(35.5,71.88)
  SIG10 w0.508: YJ21.D29 42.7,58.4 42.07,59.03 35.92,59.03 34.01,60.94 34.01,70.39 v1(35.5,71.88)
VCC_TX_6: length 50.8
  POWER2 w0.508: YJ22.B29 42.7,58.4 42.07,59.03 35.92,59.03 34.02,60.94 34.02,66.59 39.81,72.39 v1(39.81,73.28)
  BOTTOM w0.508: v1(39.81,73.28) 38.54,74.55 v2(38.54,76.2) 38.54,81.53 39.05,82.04 39.05,85.34 34.45,89.94 34.11,89.94 33.63,90.42 C2200.1 33.19,91.95 C2199.2 33.44,94.26 L246.1
VCC_TX_7: length 34.2
  POWER2 w0.508: YJ22.A29 42.7,72.97 45.02,75.29 45.02,81.53 43.58,82.97 43.18,82.97 v1(42.84,83.31)
  BOTTOM w0.508: L247.1 36.94,92.43 C2201.2 C2202.1 37.17,89.51 v2(40.77,85.91) 41.59,85.09 41.59,84.07 42.35,83.31 v1(42.84,83.31)
VCC_TX_8: length 25.3
  TOP w0.508: v1(69.66,83.82) 69.53,83.69 C2228.1 68.11,84.3 68.36,84.55 C2227.2 68.36,86.46 68.59,86.69 L258.1
  POWER2 w0.508: YJ23.A29 70.7,72.57 69.28,73.99 69.28,83.44 v1(69.66,83.82)
VCC_TX_9: length 40.9
  POWER2 w0.508: YJ23.B29 70.7,58.48 70.15,59.03 63.92,59.03 62.02,60.94 62.02,70.08 63.16,71.22 63.16,80.97 v1(60.95,83.18)
  BOTTOM w0.508: v1(60.95,83.18) 61.46,83.69 v2(61.53,83.69) C2230.1 62.7,84.45 62.45,84.71 C2229.2 62.45,86.36 62.22,86.59 L259.1
VCC_TX_10: length 42.7
  TOP w0.508: v1(60.95,84.2) 61.46,83.69 C2264.1 62.7,84.17 62.45,84.43 C2259.2 62.45,86.46 62.22,86.69 L268.1
  SIG10 w0.508: v1(60.95,84.2) 61.66,83.49 61.66,76.18 62.42,75.42 62.42,70.48 61.5,69.56 61.5,61.45 63.92,59.03 70.12,59.03 70.7,58.45 YJ24.D29
  BOTTOM w0.13: v1(60.95,84.2) 60.39,84.2 v2(60.13,84.45)
VCC_TX_11: length 25.9
  SIG10 w0.508: v1(67.6,73.53) 70.7,70.43 YJ24.C29
  BOTTOM w0.508: L269.1 68.59,86.59 68.36,86.36 C2265.2 68.36,84.55 68.11,84.3 C2266.1 68.64,83.69 69.66,82.67 69.66,80.9 69.41,80.64 69.41,78.61 69.01,78.22 69.01,75.93 v2(68.64,75.56) 67.6,74.52 v1(67.6,73.53)
VCC_TX_12: length 31.6
  TOP w0.508: L256.1 88.63,86.84 88.86,86.61 C2231.2 88.86,84.71 89.12,84.45 C2232.1 88.58,83.69 87.69,84.58 v1(87.69,85.47)
  SIG1 w0.508: YJ23.C29 89.7,66.16 92.39,68.86 92.39,74.42 90.74,76.07 90.74,77.21 88.84,79.12 88.84,83.44 87.69,84.58 v1(87.69,85.47)
  BOTTOM w0.13: v1(87.69,85.47) 87.31,85.47 v2(86.68,86.1)
VCC_TX_13: length 46.1
  TOP w0.508: v1(82.87,85.34) 82.87,84.2 82.36,83.69 C2234.1 81.32,84.3 81.57,84.55 C2233.2 81.57,86.36 81.8,86.59 L257.1
  SIG1 w0.508: v1(82.87,85.34) 82.87,84.83 83.76,83.94 83.76,80.64 84.14,80.26 84.14,78.61 83.76,78.23 83.76,76.71 v1(82.99,75.94)
  SIG10 w0.508: YJ23.D29 89.7,58.4 89.71,58.4 89.71,58.43 89.12,59.03 81.88,59.03 80.99,59.91 80.99,73.94 v1(82.99,75.94)
  BOTTOM w0.13: v2(82.11,75.56) 82.49,75.94 v1(82.99,75.94)
VCC_TX_14: length 43
  POWER2 w0.508: v1(82.87,82.93) 83.74,82.06 83.74,80.52 84.14,80.11 84.14,73.81 81.02,70.69 81.02,60.94 82.93,59.03 89.07,59.03 89.7,58.4 YJ24.B29
  BOTTOM w0.508: v2(83.88,87.75) L270.1 81.8,86.46 81.57,86.23 C2260.2 81.57,84.55 81.32,84.3 C2261.1 82.11,83.69 v1(82.87,82.93)
VCC_TX_15: length 26.7
  POWER2 w0.508: YJ24.A29 89.7,68.29 88.58,69.41 88.58,82.42 v1(87.82,83.18)
  BOTTOM w0.508: v2(86.68,88.01) 86.93,87.75 L271.1 88.63,86.71 88.86,86.48 C2262.2 88.86,84.83 89.12,84.58 C2263.1 88.71,83.69 88.2,83.18 v1(87.82,83.18)
VCC_TX_16: length 27.5
  TOP w0.508: L282.1 118.38,86.59 118.15,86.36 C2293.2 118.15,84.68 117.89,84.43 C2294.1 118.94,83.69 v1(119.44,84.2)
  POWER2 w0.508: YJ25.A29 117.7,72.04 118.55,72.9 118.55,83.31 v1(119.44,84.2)
  BOTTOM w0.13: v1(119.44,84.2) 119.44,85.72 v2(119.57,85.85)
VCC_TX_17: length 42.8
  POWER2 w0.508: YJ25.B29 117.7,58.48 117.15,59.03 110.92,59.03 109.02,60.94 109.02,67.15 112.46,70.59 112.46,74.97 111.58,75.84 111.58,82.41 v1(110.81,83.18)
  BOTTOM w0.13: C2296.1 v2(112.48,82.42)
  BOTTOM w0.508: v1(110.81,83.18) 111.32,83.69 C2296.1 112.48,84.17 112.23,84.43 C2295.2 112.23,86.36 112,86.59 L283.1
VCC_TX_18: length 42
  TOP w0.508: v1(110.81,84.2) 111.32,83.69 C2324.1 112.48,84.33 112.23,84.58 C2323.2 112.23,86.23 112,86.46 L292.1
  SIG10 w0.508: YJ26.D29 117.7,58.45 117.12,59.03 110.91,59.03 109.01,60.94 109.01,82.4 v1(110.81,84.2)
  BOTTOM w0.13: v2(110.71,84.96) 110.81,84.86 v1(110.81,84.2)
VCC_TX_19: length 30.1
  SIG3 w0.508: v1(119.44,82.93) 119.44,77.59 115.89,74.04 v1(114.62,74.04)
  SIG10 w0.508: YJ26.C29 117.7,70.96 v1(114.62,74.04)
  BOTTOM w0.13: v1(114.62,74.04) 114.62,75.82 v2(114.87,76.07)
  BOTTOM w0.508: L293.1 118.38,86.94 118.15,86.71 C2325.2 118.15,84.68 117.89,84.43 C2326.1 118.68,83.69 v1(119.44,82.93)
VCC_TX_20: length 19.9
  SIG10 w0.508: v1(138.24,78.1) 139.76,76.58 139.76,73.78 136.7,70.72 YJ25.C29
  BOTTOM w0.508: v1(138.24,78.1) 138.49,77.85 C2292.1 138.9,78.59 138.65,78.84 C2291.2 138.65,80.92 138.42,81.15 L280.1
VCC_TX_21: length 35.2
  TOP w0.508: L281.1 131.58,80.62 131.36,80.39 C2297.2 131.36,78.46 131.1,78.2 C2298.1 131.1,74.22 v1(133.16,72.16)
  SIG10 w0.508: YJ25.D29 136.7,58.4 136.07,59.03 129.92,59.03 128.01,60.94 128.01,67.01 v1(133.16,72.16)
VCC_TX_22: length 36.5
  POWER2 w0.508: v1(133.29,73.15) 132.91,73.15 128.02,68.26 128.02,60.94 129.93,59.03 136.07,59.03 136.7,58.4 YJ26.B29
  BOTTOM w0.508: L294.1 131.58,80.46 131.36,80.24 C2327.2 131.36,78.86 131.1,78.61 C2328.1 131.1,76.68 v2(130.62,76.2) 130.62,74.8 132.27,73.15 v1(133.29,73.15)
VCC_TX_23: length 20.1
  TOP w0.508: v1(138.11,77.21) 138.62,77.21 138.9,77.49 C2330.1 138.9,78.59 138.65,78.84 C2329.2 138.65,80.9 138.42,81.13 L295.1
  POWER2 w0.508: YJ26.A29 136.7,71.23 138.87,73.4 138.87,76.45 v1(138.11,77.21)
  BOTTOM w0.13: v1(138.11,77.21) 138.49,77.21 v2(139.13,76.58)
VCC_TX_24: length 27.5
  TOP w0.508: L306.1 162.57,86.59 162.34,86.36 C2358.2 162.34,84.81 162.09,84.55 C2359.1 163,83.69 v1(163.64,84.33)
  POWER2 w0.508: YJ27.A29 164.7,70.76 162.62,72.83 162.62,83.69 163.26,84.33 v1(163.64,84.33)
  BOTTOM w0.13: v2(162.88,84.33) v1(163.64,84.33)
VCC_TX_25: length 63.8
  POWER2 w0.508: v1(154.62,83.56) 157.16,81.02 157.16,71.22 156.02,70.08 156.02,60.94 157.92,59.03 164.15,59.03 164.7,58.48 YJ27.B29
  BOTTOM w0.508: L307.1 136.82,97.43 C2361.2 139.79,97.43 140.04,97.18 C2362.1 141.77,97.18 v2(142.94,96.01) 144.34,94.61 144.34,87.37 146.62,85.09 153.99,85.09 154.62,84.45 v1(154.62,83.56)
VCC_TX_26: length 43.5
  TOP w0.508: L316.1 156.2,86.48 156.43,86.26 C2389.2 156.43,84.43 156.68,84.17 C2390.1 156.02,83.69 155,82.67 155,81.02 155.38,80.64 155.38,76.71 v1(154.11,75.44)
  SIG10 w0.508: YJ28.D29 164.7,58.45 164.12,59.03 157.91,59.03 156.01,60.94 156.01,70.07 157.16,71.22 157.16,73.02 154.75,75.44 v1(154.11,75.44)
  BOTTOM w0.13: v2(155,76.58) 155,76.32 v1(154.11,75.44)
VCC_TX_27: length 38.9
  TOP w0.508: v1(168.21,88.52) 168.21,88.75 C2392.1 166.28,91.06 166.79,91.56 C2391.2 166.79,93.37 165.54,94.61 L317.1
  SIG4 w0.508: v1(168.21,88.52) 167.7,89.02 167.06,89.02 166.69,88.65 166.69,86.99 167.45,86.23 167.45,76.96 v1(168.21,76.2)
  SIG10 w0.508: YJ28.C29 164.7,68.24 168.21,71.75 v1(168.21,76.2)
  BOTTOM w0.13: v2(168.97,76.2) v1(168.21,76.2)
VCC_TX_28: length 24.8
  TOP w0.508: L304.1 182.61,86.87 182.84,86.64 C2355.2 182.84,84.43 183.1,84.17 C2356.1 183.1,83.21 182.94,83.06 182.05,83.06 v1(181.93,83.18)
  SIG10 w0.508: YJ27.C29 183.7,81.41 v1(181.93,83.18)
VCC_TX_29: length 41.6
  TOP w0.508: v1(176.97,81.91) 176.85,82.04 176.85,82.93 176.09,83.69 C2360.1 175.3,84.43 175.55,84.68 C2357.2 175.55,86.71 175.78,86.94 L305.1
  SIG1 w0.508: v1(176.97,81.91) 177.86,81.02 v1(177.86,72.77)
  SIG10 w0.508: YJ27.D29 183.7,58.4 183.07,59.03 176.92,59.03 175.01,60.94 175.01,69.91 v1(177.86,72.77)
  BOTTOM w0.13: v1(176.97,81.91) v2(177.86,81.91)
VCC_TX_30: length 40.9
  POWER2 w0.508: YJ28.B29 183.7,58.4 183.07,59.03 176.92,59.03 175.02,60.94 175.02,71.19 177.74,73.92 177.74,82.54 v1(177.48,82.8)
  BOTTOM w0.508: v1(177.48,82.8) 177.36,82.8 v2(176.47,83.69) C2388.1 175.3,84.3 175.55,84.55 C2387.2 175.55,86.71 175.78,86.94 L318.1
VCC_TX_31: length 25.6
  POWER2 w0.508: YJ28.A29 183.7,82.9 182.53,84.07 v1(181.93,84.07)
  BOTTOM w0.508: v1(181.93,84.07) 182.44,84.07 182.82,83.69 C2394.1 183.1,84.43 182.84,84.68 C2393.2 182.84,86.46 182.61,86.69 L319.1
VCC_TX_32: length 25.5
  POWER2 w0.508: YJ29.A29 211.7,67.74 214.31,70.36 214.31,82.29 v1(213.42,83.18)
  BOTTOM w0.508: v1(213.42,83.18) 212.92,83.69 C2420.1 211.87,84.43 212.13,84.68 C2419.2 212.13,86.36 212.36,86.59 L330.1
VCC_TX_33: length 41.1
  POWER2 w0.508: v1(205.42,72.13) 202.89,69.6 202.89,61.06 204.92,59.03 211.15,59.03 211.7,58.48 YJ29.B29
  BOTTOM w0.508: v1(205.42,72.13) 204.41,73.15 v2(204.41,78.1) 204.41,79.5 201.64,82.27 C2422.1 201.64,84.83 201.26,85.21 C2421.2 201.26,86.46 200.65,87.07 L331.1
VCC_TX_34: length 35.8
  TOP w0.508: L340.1 205.98,80.49 206.21,80.26 C2451.2 206.21,78.86 206.46,78.61 C2452.1 206.46,74.32 v1(205.42,73.28)
  SIG1 w0.508: YJ30.D29 211.7,58.45 211.12,59.03 204.92,59.03 203.01,60.94 203.01,70.86 v1(205.42,73.28)
  BOTTOM w0.13: v1(205.42,73.28) 205.8,73.66 v2(205.8,75.31)
VCC_TX_35: length 25.8
  TOP w0.508: v1(213.42,84.2) 213.17,84.2 212.66,83.69 C2458.1 211.87,84.43 212.13,84.68 C2453.2 212.13,86.36 212.36,86.59 L341.1
  SIG1 w0.508: YJ30.C29 211.7,68.89 212.66,69.85 212.66,83.44 v1(213.42,84.2)
VCC_TX_36: length 34.7
  SIG1 w0.508: v1(231.33,83.18) 232.09,82.42 232.09,73.89 230.7,72.5 YJ29.C29
  BOTTOM w0.508: v1(231.33,83.18) 231.84,83.69 C2424.1 v2(232.88,85.85) 232.88,87.09 229.45,90.52 C2423.2 L328.1
VCC_TX_37: length 36
  TOP w0.508: L329.1 225.56,79.86 C2425.2 225.34,78.84 225.08,78.59 C2426.1 225.97,76.96 v1(226.63,76.96)
  SIG1 w0.508: YJ29.D29 230.7,58.4 230.07,59.03 223.92,59.03 222.01,60.94 222.01,72.34 v1(226.63,76.96)
  BOTTOM w0.13: v1(226.63,76.96) 226.4,76.73 v2(225.9,76.73)
VCC_TX_38: length 36.1
  POWER2 w0.508: YJ30.B29 230.7,58.4 230.07,59.03 223.93,59.03 222.02,60.94 222.02,71.33 v1(226.63,75.94)
  BOTTOM w0.508: v1(226.63,75.94) 224.98,75.94 v2(224.6,76.32) 224.57,76.35 224.57,76.93 225.08,77.44 C2455.1 225.08,78.59 225.34,78.84 C2454.2 225.56,79.86 L342.1
VCC_TX_39: length 26.9
  TOP w0.508: L343.1 232.4,85.7 C2456.2 232.63,84.71 232.88,84.45 C2457.1 231.84,83.69 v1(231.33,84.2)
  POWER2 w0.508: YJ30.A29 230.7,67.82 232.09,69.21 232.09,83.44 v1(231.33,84.2)
  BOTTOM w0.13: v2(231.99,84.71) 231.48,84.2 v1(231.33,84.2)
VCC_TX_40: length 26.5
  TOP w0.508: v1(257.62,84.2) 257.11,83.69 C2487.1 256.07,84.55 256.32,84.81 C2486.2 256.55,85.7 L354.1
  POWER2 w0.508: YJ31.A29 258.7,83.12 v1(257.62,84.2)
  BOTTOM w0.13: v2(257.24,84.96) 257.62,84.58 v1(257.62,84.2)
VCC_TX_41: length 46.2
  POWER2 w0.508: v1(248.98,81.4) 251.16,79.23 251.16,71.22 250.02,70.08 250.02,60.94 251.92,59.03 258.15,59.03 258.7,58.48 YJ31.B29
  BOTTOM w0.508: v1(248.98,81.4) 248.98,82.67 250,83.69 C2490.1 v2(250.66,85.11) 253.3,87.75 253.56,87.75 254.17,88.36 C2489.2 L355.1
VCC_TX_42: length 43.9
  TOP w0.508: v1(248.09,82.8) 248.73,82.8 249.62,83.69 C2518.1 250.66,84.43 250.41,84.68 C2517.2 250.18,85.7 L364.1
  SIG1 w0.508: v1(248.09,82.8) 248.09,80.9 251.16,77.83 251.16,71.22 250.01,70.07 250.01,60.94 251.91,59.03 258.12,59.03 258.7,58.45 YJ32.D29
  BOTTOM w0.13: v1(248.09,82.8) 247.59,83.31 247.59,84.45 v2(247.71,84.58)
VCC_TX_43: length 31.1
  SIG1 w0.508: v1(257.62,83.18) 258,83.18 258.7,82.48 YJ32.C29
  BOTTOM w0.508: L365.1 257.82,91.62 258.38,91.06 258.38,87.63 257.65,86.89 C2519.2 256.86,85.85 v2(255.97,84.96) 255.97,84.33 256.07,84.22 C2520.1 257.11,83.69 v1(257.62,83.18)
VCC_TX_44: length 26.2
  TOP w0.508: v1(275.4,84.2) 275.91,83.69 C2484.1 277.08,84.43 276.82,84.68 C2483.2 276.59,85.7 L352.1
  SIG1 w0.508: v1(275.4,84.2) 277.7,81.9 YJ31.C29
VCC_TX_45: length 41
  TOP w0.508: L353.1 269.76,86.61 269.53,86.38 C2485.2 269.53,84.55 269.28,84.3 C2488.1 269.74,83.69 270.24,84.2 v1(270.83,84.2)
  SIG1 w0.508: YJ31.D29 277.7,58.4 277.07,59.03 270.92,59.03 269.04,60.91 269.04,71.74 270.19,72.9 270.19,83.56 v1(270.83,84.2)
VCC_TX_46: length 40.1
  POWER2 w0.508: v1(270.83,83.26) 270.32,82.75 270.32,75.4 269.02,74.1 269.02,60.94 270.93,59.03 277.07,59.03 277.7,58.4 YJ32.B29
  BOTTOM w0.508: v1(270.83,83.26) 270.4,83.69 C2516.1 269.28,84.3 269.53,84.55 C2515.2 269.76,85.7 L366.1
VCC_TX_47: length 27.4
  POWER2 w0.508: YJ32.A29 277.7,80.59 v1(275.24,83.05)
  BOTTOM w0.13: L367.1 276.59,89.71 v2(276.67,89.79)
  BOTTOM w0.508: L367.1 276.59,85.7 C2521.2 276.82,84.83 277.08,84.58 C2522.1 275.87,83.69 v1(275.24,83.05)
VCC_TX_48: length 25.4
  TOP w0.508: v1(303.59,83.82) C2548.1 304.38,84.58 304.13,84.83 C2547.2 303.9,85.82 L378.1
  SIG1 w0.508: v1(303.59,83.82) 305.12,82.29 305.12,68.14 305.7,67.56 YJ33.A29
  BOTTOM w0.13: v2(304.36,83.82) v1(303.59,83.82)
VCC_TX_49: length 34.1
  TOP w0.508: v1(298.92,77.09) C2550.1 298.92,78.25 299.81,79.14 C2549.2 299.58,79.86 L379.1
  SIG1 w0.508: YJ33.B29 305.7,58.45 305.12,59.03 298.91,59.03 297.01,60.94 297.01,75.18 v1(298.92,77.09)
  BOTTOM w0.13: v2(298.89,77.85) 298.92,77.82 v1(298.92,77.09)
VCC_TX_50: length 41.2
  TOP w0.508: v1(298.89,76.07) 297.75,77.21 297.75,81.4 296.48,82.67 C2584.1 294.91,83.72 C2580.2 294.3,85.21 294.53,85.44 L388.1
  POWER2 w0.508: v1(298.89,76.07) 297.02,74.2 297.02,60.94 298.92,59.03 305.15,59.03 305.7,58.48 YJ34.D29
  BOTTOM w0.13: v2(299.66,76.07) v1(298.89,76.07)
VCC_TX_51: length 27.5
  TOP w0.508: L389.1 310.4,85.82 C2585.2 310.17,84.81 309.92,84.55 C2586.1 309.92,83.65 309.33,83.06 307.15,83.06 v1(307.02,82.93)
  POWER2 w0.508: v1(307.02,82.93) 304.99,80.9 304.99,74.72 305.7,74.01 YJ34.C29
  BOTTOM w0.13: v1(307.02,82.93) v2(307.02,83.82)
VCC_TX_52: length 27
  TOP w0.508: v1(326.83,84.2) 326.96,84.2 327.47,83.69 C2552.1 328.51,84.45 328.26,84.71 C2551.2 328.03,85.7 L376.1
  POWER2 w0.508: YJ33.C29 324.7,70.63 327.85,73.78 327.85,83.18 v1(326.83,84.2)
VCC_TX_53: length 34.4
  POWER2 w0.508: v1(320.27,75.68) 316.02,71.43 316.02,60.94 317.92,59.03 324.07,59.03 324.7,58.4 YJ33.D29
  BOTTOM w0.508: L377.1 321.2,79.86 C2553.2 320.97,78.97 320.71,78.71 C2554.1 320.71,77.47 320.99,77.19 v2(320.99,76.4) v1(320.27,75.68)
VCC_TX_54: length 35.2
  TOP w0.508: v1(320.28,76.83) 320.71,77.26 C2581.1 320.71,78.46 320.97,78.71 C2579.2 321.2,79.86 L390.1
  SIG1 w0.508: YJ34.B29 324.7,58.4 324.07,59.03 317.92,59.03 316.01,60.94 316.01,72.56 v1(320.28,76.83)
  BOTTOM w0.13: v1(320.28,76.83) 320.03,76.58 v2(319.34,76.58)
VCC_TX_55: length 25.7
  SIG1 w0.508: YJ34.A29 324.7,66.19 327.6,69.09 327.6,82.42 v1(326.83,83.18)
  BOTTOM w0.508: L391.1 328.03,85.7 C2582.2 328.26,84.68 328.51,84.43 C2583.1 327.98,83.69 327.47,83.18 v1(326.83,83.18)
VCC_TX_56: length 25.3
  TOP w0.508: v1(353.15,82.95) 353.12,82.95 353.48,83.31 C2614.1 353.48,84.45 353.73,84.71 C2613.2 353.73,87.4 353.38,87.75 L402.1
  POWER2 w0.508: v1(353.15,82.95) 353.63,82.47 353.63,75.82 354.99,74.46 354.99,70.95 352.7,68.66 YJ35.A29
VCC_TX_57: length 43
  POWER2 w0.508: v1(346.52,82.93) 347.41,82.04 347.41,74.29 344.02,70.9 344.02,60.94 345.92,59.03 352.15,59.03 352.7,58.48 YJ35.B29
  BOTTOM w0.13: L403.1 v2(345.5,87.75)
  BOTTOM w0.508: L403.1 347.59,85.7 C2615.2 347.82,84.43 348.07,84.17 C2616.1 347.28,83.69 v1(346.52,82.93)
VCC_TX_58: length 45.2
  TOP w0.508: L412.1 346.44,85.79 346.77,85.47 C2643.2 347.82,84.43 348.07,84.17 C2644.1 347.15,83.69 346.9,83.94 v1(346.14,83.94)
  SIG1 w0.508: YJ36.D29 352.7,58.45 352.12,59.03 345.91,59.03 344.01,60.94 344.01,66.83 348.04,70.86 348.04,82.55 346.65,83.94 v1(346.14,83.94)
  BOTTOM w0.13: v2(346.14,84.96) v1(346.14,83.94)
VCC_TX_59: length 28.6
  SIG1 w0.508: v1(354.9,84.45) 354.01,83.56 354.01,82.42 353.63,82.04 353.63,76.83 355.03,75.44 355.03,70.86 352.7,68.53 YJ36.C29
  BOTTOM w0.13: v1(354.9,84.45) 355.41,84.96 v2(355.41,85.47)
  BOTTOM w0.508: v1(354.9,84.45) 354.14,83.69 C2646.1 353.48,84.17 353.73,84.43 C2645.2 353.96,85.7 L413.1
VCC_TX_60: length 31.5
  TOP w0.508: L400.1 384.04,84.81 C2611.2 384.26,83.69 384.52,83.44 C2612.1 383.35,82.8 v1(382.84,83.31)
  SIG1 w0.508: YJ35.C29 371.7,66.33 374.21,68.83 374.21,77.47 374.84,78.1 377.63,78.1 v1(382.84,83.31)
  BOTTOM w0.13: v2(382.08,83.06) 382.33,83.31 v1(382.84,83.31)
VCC_TX_61: length 41.2
  TOP w0.508: v1(368.8,80.13) 370.47,81.81 C2618.1 C2617.2 372.83,81.81 373.19,82.17 L401.1
  SIG1 w0.508: YJ35.D29 371.7,58.4 371.07,59.03 364.92,59.03 363.01,60.94 363.01,69.45 369.13,75.56 369.13,78.1 368.8,78.43 v1(368.8,80.13)
  BOTTOM w0.13: v1(368.8,80.13) 367.86,79.19 v2(367.86,78.36)
VCC_TX_62: length 64.5
  TOP w0.508: v1(381.95,84.45) 381.95,90.04 382.84,90.93 C2648.1 384.52,91.41 384.26,91.67 C2647.2 384.04,92.94 L414.1
  POWER2 w0.508: YJ36.B29 371.7,58.4 371.07,59.03 364.93,59.03 363.02,60.94 363.02,66.79 364.81,68.58 377.13,68.58 381.19,72.64 381.19,76.07 379.54,77.72 379.54,82.04 v1(381.95,84.45)
  BOTTOM w0.13: v2(381.19,84.45) v1(381.95,84.45)
VCC_TX_63: length 32.8
  POWER2 w0.508: v1(382.84,82.29) 382.84,80.3 381.95,79.41 381.95,72.26 377.19,67.5 372.49,67.5 371.7,66.71 YJ36.A29
  BOTTOM w0.13: v2(381.95,86.87) L415.1
  BOTTOM w0.508: v1(382.84,82.29) 383.35,82.8 C2650.1 384.52,83.41 384.26,83.67 C2649.2 384.04,84.81 L415.1
VCCS: length 5.2
  TOP w0.203: 376.49,171.71 376.49,171.4 377.05,170.83 U140.43
  TOP w0.381: 376.49,171.71 C3943.1 375.93,172.23 v1(375.7,172.46)
  BOTTOM w0.381: v2(374.94,172.46) v1(375.7,172.46) 376.09,172.84 R3670.2
VDD1.2V: length 259.2
  TOP w0.381: v1(268.67,215.31) C301.1 R1191.1 ; C305.1 C306.1 ; C305.1 240.98,209.29 ; C305.1 240.37,210.16 ; C306.1 238.85,210.16 ; C306.1 237.93,209.29 ; v1(25.31,171.45) 25.34,171.45 25.46,171.32 R3272.2 ; 239.03,115.8 C3095.1 ; C3095.1 239.51,115.32 ; C3095.1 239.99,115.8 ; C308.1 241.14,209.01 ; C308.1 C307.1 v1(242.89,209.8) ; C308.1 241.74,209.8 ; C2723.1 162.24,179.58
  TOP w0.508: v1(230.82,179.47) 231.2,179.09 C221.1
  SIG1 w0.381: v1(79.69,123.57) 79.31,123.19 64.58,123.19 61.79,125.98 53.28,125.98 50,129.26 50,132.88 44.39,138.49 44.39,144.14 45.15,144.9 45.15,148.46 41.59,152.02 36.64,152.02 35.5,153.16 35.5,153.79 32.45,153.79 31.69,154.56 31.69,164.59 32.07,164.97 32.07,168.15 30.67,169.54 27.24,169.54 25.34,171.45 v1(25.31,171.45)
  SIG2 w0.381: v1(163.59,181.2) 163.59,185.09 162.12,186.56 160.08,186.56 158.31,188.34 144.21,188.34 124.14,168.27 124.14,162.43 94.42,132.71 89.85,132.71 87.57,130.43 87.57,128.14 84.01,124.58 80.71,124.58 v1(79.69,123.57)
  SIG4 w0.381: v1(268.67,215.31) 264.27,215.31 261.68,212.72 245.81,212.72 v1(242.89,209.8)
  BOTTOM w0.381: 164.27,139.06 164.82,139.06 C2866.1 ; v1(79.69,123.57) v2(79.69,122.68) ; v1(242.89,209.8) v2(242.89,210.69)
  vias: v1(162.7,181.23) v1(164.53,181.23) v1(165.42,181.23) v1(228.79,179.5) v1(229.68,179.5) v1(232.52,181.56) v1(233.41,181.58) v1(234.02,179.45) v1(234.3,181.58) v2(173.8,180.34)
VDD1.2V_EN: length 6
  TOP w0.381: U44.1 v1(264.22,214.07)
  BOTTOM w0.381: v2(263.46,214.07) v1(264.22,214.07) 264.25,214.09 R3549.1 R3540.2 266.26,215.26 Q49.3
VDD1.8V: length 262.1
  TOP w0.229: U1.BG33 v1(198.55,153.34)
  TOP w0.381: C2997.1 v1(235.9,156.33) ; 183.2,197.28 C2860.1 ; C2860.1 182.71,197.76 ; C2860.1 183.68,197.76 ; C2666.1 224.47,199.01 ; L426.2 183.93,179.8 ; L426.2 182.46,179.8 ; L426.2 183.2,180.46 ; 185.36,197.1 185.36,197.1 C100.1 184.75,197.76 ; v1(28.89,172.46) 29.65,171.7 R3303.2 ; 203.14,96.64 L438.2 202.35,95.91 ; C2843.1 203.97,96.14 ; C2843.1 204.56,95.53 ; C2843.1 204.56,96.75 ; 159.65,139.1 C3051.1 ; C3051.1 159.16,139.58 ; C3051.1 160.13,139.58 ; 144.97,214.75 C3636.2 144.36,214.09 ; 155.92,211.33 155.38,211.33 155.11,211.05 C3629.1 154.62,212.72 152.21,215.14 145.1,215.14 ; C74.1 219.65,198.88 ; C3066.1 173.29,192.02 ; C3635.1 143.19,214.7 ; 184.51,196.31 L428.2 185.1,196.95 ; C82.1 235.65,144.65 235.78,144.52 v1(235.78,144.02) ; L425.2 220.24,197.58 ; L425.2 219.05,197.58 ; L425.2 219.65,198.22 ; C90.1 181.29,179.58
  TOP w0.508: 163.26,193.29 L440.2 ; v1(234.89,144.02) 234.89,143.1 L442.2 ; v1(235.01,156.33) 235.14,156.21 L436.2 ; L441.2 150.89,138.15 150.05,138.99 150.05,139.85 150.69,140.48 157.88,140.48 158.84,139.52 ; 161.86,193.16 C86.1 ; L432.2 159.7,138.81
  TOP w0.762: L433.2 224.47,197.74 ; L422.2 174.03,192.38
  TOP w1.016: 182.44,194.94 172.91,194.94 ; 182.82,191.51 184.34,189.99 184.34,184.02 183.07,182.75 183.07,181.23
  SIG3 w0.508: v1(28.89,172.46) 29.15,172.46 29.91,173.23 29.91,174.62 28.91,175.63 13.13,175.63 v1(11.62,174.11)
  SIG10 w0.508: 140.27,202.82 116.14,202.82 111.21,207.74 72.75,207.74 72.28,208.22 68.91,208.22 65.8,211.33 46.93,211.33 45.53,209.93 45.53,208.15 43.8,206.42 42.12,206.42 35.59,199.9 21.12,199.9 15.71,194.49 15.71,187.86 12.76,184.91 12.76,175.26 v1(11.62,174.11)
  BOTTOM w0.381: 144.97,215.26 C3633.1 144.31,214.48 ; C3190.1 199.06,152.83 v1(198.55,153.34) ; C3634.1 142.46,214.48 ; C3634.1 143.93,214.48 ; C3634.1 143.19,215.26 ; v2(234.51,198.88) v1(233.74,198.88) ; v2(252.92,111.38) v1(252.16,111.38)
  vias: v1(134.56,216.41) v1(135.83,216.41) v1(137.1,216.41) v1(138.37,216.41) v1(139.64,216.41) v1(140.91,216.41) v1(142.18,216.41) v1(143.45,216.41) v1(144.72,216.41) v1(162.32,174.95) v1(163.26,172.9) v1(165.29,174.95) v1(180.84,181.21) v1(181.73,181.21) v1(218.63,198.88) v1(218.63,197.86) v1(223.46,198.88) v1(223.46,197.86) v1(233.74,197.86) v1(251.14,111.5) v1(251.14,110.11) v1(252.16,110.11) v2(137.6,217.8)
VDD1.8V_EN: length 11.6
  TOP w0.254: U128.5 v1(151.7,210.69)
  BOTTOM w0.254: v1(151.7,210.69) 151.8,210.79 R3553.2 R3559.1 155.54,211.99 v2(155.64,212.09) 156.78,212.09 157.67,211.2 Q53.3
VDD3.3_CLK_MCU: length 345.7
  TOP w0.381: C3434.1 C3435.1 ; C3434.1 292.8,196.47 ; C3434.1 292.19,197.13 ; C3435.1 294.73,197.13 ; C3435.1 293.94,196.47 ; C3610.1 C3611.1 ; C3610.1 275.78,209.17 ; C3610.1 276.39,209.83 ; C3611.1 274.51,209.17 ; C3611.1 C3609.1 273.24,209.04 v1(273.37,208.91) ; v1(34.86,172.34) 34.1,171.57 34.1,171.19 34.23,171.07 R3316.2 ; 278.35,206.91 C3606.1 R3507.1 ; 315.38,201.7 C3465.2 316.04,202.44 v1(315.91,202.56)
  TOP w0.762: 301.18,197.86 302.07,197.86 302.83,198.63 302.83,199.26 308.04,204.47 313.25,204.47 314.13,203.58 314.77,203.58
  SIG4 w0.508: v1(273.37,208.91) 265.87,208.91 264.86,209.93 258.25,209.93 257.24,208.91 216.09,208.91 212.15,212.85 161.23,212.85 156.15,207.77 153.48,207.77 149.46,203.75 129.24,203.75 124.62,199.13 72.58,199.13 71.23,197.79 66.69,197.79 65.08,196.19 62.77,196.19 58.99,192.4 58.99,191.64 56.14,188.78 55.37,188.78 53.28,186.69 53.28,184.4 50.36,181.48 50.36,177.8 47.31,174.75 40.7,174.75 38.93,172.97 35.5,172.97 v1(34.86,172.34)
  BOTTOM w0.381: v1(34.86,172.34) 34.99,172.21 v2(35.75,172.21) ; R3548.1 362.53,207.64 358.4,203.51 v2(323.28,203.51) 316.87,203.51 v1(315.91,202.56) ; v1(273.37,208.91) v2(273.37,208.15)
VDD3.3_CLK_MCU_EN: length 8.7
  TOP w0.305: v1(280.58,219.3) R3528.2 R3534.1 280.58,216.15 279.85,215.42 U126.5
  BOTTOM w0.13: v1(280.58,219.3) v2(280.58,220.06)
  BOTTOM w0.381: v1(280.58,219.3) 280.58,218.72 281.5,217.8 Q3.3
VDD3.3V: length 547.5
  TOP w0.229: U1.BL27 v1(204.55,157.34) ; U1.BJ24 v1(207.55,155.34) ; U1.BJ47 v1(183.55,155.34) ; U1.T26 v1(205.55,121.34) ; U1.U35 v1(195.55,122.34) ; v1(215.55,115.34) U1.K16 ; U1.V47 v1(183.55,123.34) ; U1.T20 v1(211.55,121.34) ; U1.BJ20 v1(211.55,155.34) ; U1.BL41 v1(189.55,157.34) ; v1(179.55,117.32) 179.55,117.34 U1.M51 ; U1.BN51 v1(179.55,159.34) ; U1.BL49 v1(181.55,157.34) ; U1.BK26 v1(205.55,156.34) ; U1.P15 v1(216.55,119.34) ; U1.BL18 v1(213.55,157.34) ; U1.T32 v1(199.55,121.34) ; U1.BL26 v1(205.55,157.34) ; U1.T50 v1(180.55,121.34) ; U1.V41 v1(189.55,123.34) ; U1.T38 v1(192.55,121.34) ; U1.BJ43 v1(187.55,155.34) ; U1.BN16 v1(215.55,159.34) ; U1.BL22 v1(209.55,157.34) ; U1.V23 v1(208.55,123.34) ; v1(179.55,112.34) U1.G51 ; U1.BL45 v1(185.55,157.34) ; U1.BJ26 v1(205.55,155.34) ; U1.T44 v1(186.55,121.34) ; U1.V29 v1(202.55,123.34) ; U1.V17 v1(214.55,123.34)
  TOP w0.279: U1.AB32 v1(199.55,127.34) ; U1.AB35 v1(195.55,127.34)
  TOP w0.381: v1(361,113.15) 361,122.17 363.79,124.97 C3620.1 365.47,124.58 365.34,124.46 R3512.1 ; R2074.2 R2071.2 241.08,173.71 247.08,179.7 v1(247.08,182.37) ; U116.8 259.14,172.59 260.29,171.45 C1.2 261.4,170.79 261.94,171.32 v1(261.94,175.13) ; R4.1 v1(255.59,182.75) ; R22.2 R23.2 v1(231.71,99.18) ; C3627.1 361.76,111.76 ; C3627.1 362.55,111.27 ; C3627.1 C3628.2 361.89,113.28 ; R2043.2 180,96.86 v1(180.47,96.39) ; R3.1 v1(258.64,182.75) ; R2044.2 180.78,101.85 181.42,101.22 181.42,96.9 180.91,96.39 v1(180.47,96.39) ; R3133.2 180,95.92 v1(180.47,96.39) ; R9.1 254.29,170.41 254.57,170.69 254.57,174.37 256.22,176.02 v1(261.05,176.02) ; R18.1 v1(228.54,97.15) ; R28.1 v1(15.94,168.65) ; R19.1 v1(228.54,100.2) ; X256.1 363.79,101.47 385.25,101.47 392.75,93.98 392.75,75.69 391.63,74.57 389.52,74.57 386.29,71.34 386.29,42.29 387.44,41.15 393.93,41.15 395.8,39.28 R2039.2 395.16,37.44 394.91,37.18 394.91,34.54 395.19,34.26 R2038.1 ; R7.1 258.43,170.41 259.02,169.82 R6.1 259.27,169.42 260.16,168.53 261.94,168.53 263.08,169.67 v1(263.08,174.11) ; R2.1 v1(260.74,182.75)
  TOP w0.508: v1(46.9,163.93) C3478.1 45.5,163.93 44.84,163.27 L449.1
  SIG1 w0.508: 165.8,94.36 158.92,94.36 151.8,101.47 148.91,101.47 147.76,102.61 140.78,102.61 130.56,112.84 70.99,112.84 69.15,114.68 69.15,117.47 61.66,124.97 53.15,124.97 49.11,129.01 49.11,132.63 43.5,138.24 43.5,145.03 v1(44.39,145.92)
  SIG3 w0.381: v1(12.51,160.53) 13.53,161.54 13.53,165.86 15.94,168.27 v1(15.94,168.65) 17.08,169.8 27.75,169.8 31.18,173.23 38.29,173.23 46.9,164.61 v1(46.9,163.93)
  SIG3 w0.508: v1(46.9,163.93) 46.77,163.93 44.39,161.54 v1(44.39,145.92)
  SIG8 w0.508: v1(361,113.15) 361,117.85 367.22,124.08 367.22,152.91 369.13,154.81 369.13,163.7 v1(370.65,165.22)
  BOTTOM w0.254: v2(248.86,86.87) v1(248.09,86.87)
  BOTTOM w0.381: C2787.1 216.08,119.81 v1(216.55,119.34) ; C3130.1 214.07,157.86 v1(213.55,157.34) 213.07,157.82 R2073.2 ; v1(208.55,123.34) 208.07,123.82 C30.1 ; C29.1 206.05,120.84 v1(205.55,121.34) ; C3021.1 203.03,123.83 v1(202.55,123.34) 202.07,123.83 C2758.1 ; R2052.2 180.05,158.84 v1(179.55,159.34) C3152.1 ; R2060.2 208.04,158.83 v1(208.55,159.34) ; C3116.1 183.05,154.84 v1(183.55,155.34) ; v1(195.55,127.34) 195.07,126.86 C2894.1 ; C3079.1 179.55,112.33 v1(179.55,112.34) 179.55,112.4 C3087.1 ; v1(215.55,159.34) 215.55,159.38 C49.1 ; C3184.1 192.06,120.85 v1(192.55,121.34) 192.04,121.85 C2774.1 ; C3067.1 179.07,116.84 v1(179.55,117.32) 179.55,117.4 C3011.1 ; C3034.1 211.1,154.89 v1(211.55,155.34) 211.06,155.83 R2064.2 ; R2065.2 186.05,158.84 v1(186.55,159.34) 187.05,158.84 R2061.2 ; C28.1 210.07,157.86 v1(209.55,157.34) ; R2054.2 186.05,156.84 v1(185.55,157.34) 185.05,156.84 C53.1 ; R3255.2 v1(12.51,160.53) ; v1(189.55,123.34) 189.07,123.82 C2952.1 ; R2056.2 183.05,158.84 v1(183.55,159.34) ; C2791.1 181.04,121.84 v1(180.55,121.34) 181.05,120.84 C2684.1 ; R2047.2 v1(183.55,155.34) ; v1(183.55,155.34) 184.05,155.84 R2053.2 ; C2857.1 207.08,154.88 v1(207.55,155.34) ; R2068.2 210.06,155.85 v1(209.55,155.34) ; R2075.2 206.06,158.85 v1(206.55,159.34) 207.05,158.84 R2076.2 ; C50.1 215.04,122.85 v1(214.55,123.34) ; C2720.1 195.07,122.82 v1(195.55,122.34) ; v1(209.55,155.34) 209.05,155.84 R2069.2 ; v1(209.55,155.34) C3036.1 ; v1(183.55,123.34) 184.02,123.81 C3047.1 ; v2(359.09,111.63) 359.6,112.14 v1(360.11,112.14) ; R2072.2 207.05,155.84 v1(207.55,155.34) ; C2765.1 189.05,156.84 v1(189.55,157.34) 190.05,157.84 C2971.1 ; v1(207.55,155.34) 208.04,155.83 R2070.2 ; C3189.1 v1(181.55,157.34) 182.05,157.84 R2066.2 ; v1(211.55,121.34) 212.05,120.84 C2714.1 ; v1(370.65,165.22) R3551.1 R3505.1 ; R2063.2 214.07,155.82 v1(214.55,155.34) ; C3112.1 187.05,120.84 v1(186.55,121.34) 187.05,121.84 C2754.1 ; v1(205.55,157.34) 205.07,157.82 C27.1 ; C2.1 205.08,155.87 v1(205.55,156.34) ; v1(260.74,182.75) 260.79,182.81 v2(260.79,183.64) ; C3044.1 199.08,120.88 v1(199.55,121.34) 199.08,121.81 C2695.1 ; R2049.2 188.05,155.84 v1(187.55,155.34) ; v1(199.55,127.34) 199.07,127.83 C2933.1 ; C54.1 216.03,114.86 v1(215.55,115.34) 216.02,115.81 C51.1 ; v1(361,110.23) 361.38,110.61 C3625.1 ; 361.91,110 C3625.1 ; C3625.1 C3626.1 v1(361,113.15) ; v1(204.55,157.34) 204.05,157.84 C3.1 ; C52.1 187.05,154.84 v1(187.55,155.34) ; v1(187.55,155.34) R2062.2 ; R2059.2 212.08,155.87 v1(212.55,156.34) 213.04,155.85 R2058.2 ; R2055.2 211.06,158.85 v1(211.55,159.34) 212.07,158.82 R2067.2 ; R2050.2 v1(181.55,155.34) 182.05,155.84 R2051.2 ; R2048.2 189.05,158.84 v1(188.55,159.34) 188.05,158.84 R2057.2 ; C4.1 v1(205.55,155.34)
  vias: v1(174.89,95.43) v1(227.39,91.06) v1(227.9,90.29) v1(242.51,86.87) v1(243.78,86.87) v1(243.78,85.98) v1(245.43,86.87) v1(246.7,86.87) v1(360.11,113.15) v1(360.11,111.12) v1(360.11,110.23) v1(361,112.14) v1(361,111.12)
VDD3.3V_EN: length 14.2
  TOP w0.381: U127.5 v1(366.08,120.52)
  BOTTOM w0.381: Q52.3 367.22,128.14 365.95,126.87 365.95,124.2 v2(366.46,123.7) 367.2,122.96 R3558.1 R3554.2 367.2,121.64 v1(366.08,120.52)
VDD5.0V: length 88.9
  TOP w0.254: 52.75,139.32 52.98,139.55 U134.9 ; v1(361.67,180.11) 361.67,180 361.27,179.59 U139.9 ; 362.08,139.49 361.54,138.95 U137.9 ; 52.75,179.96 52.98,180.19 U136.9 ; 361.87,159.47 361.67,159.27 U138.9 ; U135.9 52.98,159.87 52.75,159.64
  TOP w0.381: C3617.1 378.78,203.07 ; C3617.1 378.3,202.28 ; C3617.1 C3618.2 380.3,202.94 ; 52.75,139.32 51.96,138.53 C3798.1 51.42,137.64 51.45,137.61 v1(51.45,137.51) ; R3609.1 v1(49.54,141.07) ; 361.87,159.47 362.44,160.04 C3890.1 v1(362.84,160.72) ; 52.75,159.64 51.96,158.85 C3821.1 51.42,157.96 51.45,157.93 50.86,157.35 v1(49.59,157.35) ; 380.05,203.32 389.7,203.32 391.99,201.04 C3607.1 391.6,199.36 391.48,199.49 R3508.1 ; R3637.1 v1(364.53,157.76) ; R3623.1 47.71,179.93 v1(49.59,178.05) 51.24,178.05 51.45,178.25 51.42,178.28 C3844.1 51.96,179.17 52.75,179.96 ; C3605.1 276.14,214.48 ; C3605.1 275.4,215.14 ; C3605.1 C3608.1 ; C3811.1 69.76,140.18 ; C3608.1 274.26,215.14 ; C3608.1 273.52,214.48 ; R3536.1 273.88,216.02 ; R3616.1 v1(49.54,161.39) ; v1(361.67,180.11) 362.41,180.85 C3913.1 ; R3644.1 v1(364.43,178.56) ; C3857.1 69.76,180.44 ; C3901.1 346.33,166.42 ; R3630.1 364.83,137.54 v1(364.85,137.56) ; C3855.1 69.76,170.28 ; 346.59,187.45 C3926.1 ; C3834.1 69.76,160.17 ; C3832.1 69.76,150.21 ; 69.51,129.18 C3809.1 ; C3924.1 346.33,176.45 ; 362.08,139.49 362.41,139.82 C3867.1 363.06,140.24 363.63,140.82 v1(364.81,140.82) ; C3903.1 346.33,156.46 ; C3880.1 346.33,136.19 ; C3878.1 346.33,146.35
  SIG1 w0.381: v1(38.54,170.66) 40.81,168.4 49.34,168.4
  BOTTOM w0.381: R3296.2 v1(38.54,170.66) ; v2(349.57,188.85) 349.57,187.83 ; v2(379.16,207.01) v1(379.16,205.74) ; C3858.1 v2(66.18,183.26)
  vias: v1(65.8,169.77) v1(65.8,149.45) v1(66.33,179.93) v1(66.33,179.04) v1(66.33,159.61) v1(66.33,158.72) v1(66.33,139.29) v1(66.33,138.4) v1(67.12,150.62) v1(67.12,149.73) v1(67.25,170.94) v1(67.25,170.05) v1(67.63,180.97) v1(67.63,179.96) v1(67.63,140.33) v1(67.63,139.44) v1(67.75,160.78) v1(67.75,159.64) v1(67.75,130.17) v1(67.75,129.03) v1(68.64,130.17) v1(68.64,129.03) v1(271.72,215.77) v1(272.86,215.77) v1(274.13,215.77) v1(276.54,215.77) v1(348.34,156.99) v1(348.34,155.85) v1(348.47,177.19) v1(348.47,176.3) v1(348.47,136.67) v1(348.47,135.66) v1(348.85,187.47) v1(348.85,186.46) v1(348.85,146.58) v1(348.85,145.69) v1(348.97,166.77) v1(348.97,165.88) v1(349.76,178.23) v1(349.76,177.34) v1(349.76,157.91) v1(349.76,157.02) v1(349.76,137.59) v1(349.76,136.7) v1(350.3,187.63) v1(350.3,167.18) v1(350.3,146.86) v1(377.25,205.74) v1(377.25,204.59) v1(378.14,205.74) v1(378.14,204.59) v1(379.16,204.59) v1(380.17,205.74) v1(380.17,204.59)
VDD5.0V_EN: length 13.9
  TOP w0.381: U125.5 v1(387.54,198.75)
  BOTTOM w0.13: Q43.3 382.84,191.77 381.32,193.29 R3521.2 R3524.1 384.26,193.82 387.54,197.1 v2(387.54,197.61) v1(387.54,198.75)
VDD12V: length 277.7
  TOP w0.203: 38.29,132.33 37.91,132.33 37.66,132.08 U131.17
  TOP w0.251: 10.48,125.22 10.22,125.22 9.97,124.97 U130.17
  TOP w0.254: U133.19 382.1,135.01 381.95,134.87 v1(381.7,134.87) ; v1(381.47,110.87) 381.7,110.87 381.84,111.01 U132.19 ; v1(36.51,132.33) 36.51,132.08 36.66,131.93 U131.19 ; U130.19 8.97,124.95 8.83,125.09 v1(8.83,125.35)
  TOP w0.381: C3639.1 376.34,211.86 ; C3639.1 375.48,211.07 ; C3639.1 374.61,211.86 ; C3622.1 367.83,113.05 ; C3622.1 368.62,113.92 ; C3622.1 367.83,114.78 ; C3661.1 14.64,126.34 ; C3661.1 13.81,125.45 ; C3661.1 15.41,125.45 ; R3556.1 375.63,136.88 375.6,136.9 ; C3630.1 145.35,208.15 ; C3630.1 146.09,208.94 ; C3630.1 144.62,208.94 ; v1(375.63,112.9) 375.35,112.9 375.37,112.88 R3567.1 ; C3695.1 380.33,116.69 ; C3695.1 381.34,115.85 ; C3695.1 381.34,117.57 ; R3532.1 v1(276.42,219.2) ; v1(36.51,177.8) 36.13,177.42 R3239.1 R3240.1 ; CD65.1 40.83,139.7 38.8,141.73 R3529.1 ; v1(38.29,138.43) 38.27,138.4 R3538.1 ; v1(10.6,131.44) 10.58,131.42 R3527.1 ; C3654.1 43.09,132.43 ; C3654.1 41.62,132.43 ; C3654.1 42.33,133.2 ; R3528.1 v1(281.55,219.2) ; v1(258.25,211.71) 258.38,211.58 C299.1 257.39,210.41 ; 381.8,197 C3612.1 ; C3612.1 380.07,197 ; C3612.1 380.94,196.21 ; C3703.1 381.6,139.98 ; C3703.1 380.84,140.69 ; C3703.1 381.6,141.45
  TOP w0.762: 64.1,218.98 YJ2.6 ; YJ2.6 64.1,222.02 ; YJ2.6 65.63,220.5 ; YJ2.6 62.58,220.5 ; YJ1.10 12.83,220.5 ; YJ1.10 11.3,222.02 ; YJ1.10 11.3,218.98 ; YJ1.10 9.78,220.5 ; YJ2.9 53.03,220.5 ; YJ2.9 49.98,220.5 ; YJ2.9 51.5,222.02 ; YJ2.9 51.5,218.98 ; 19.7,218.98 YJ1.8 ; YJ1.8 18.18,220.5 ; YJ1.8 19.7,222.02 ; YJ1.8 21.23,220.5 ; YJ1.9 17.03,220.5 ; YJ1.9 13.98,220.5 ; YJ1.9 15.5,218.98 ; YJ1.9 15.5,222.02 ; YJ2.7 59.9,222.02 ; YJ2.7 61.43,220.5 ; YJ2.7 59.9,218.98 ; YJ2.7 58.38,220.5 ; 28.1,218.98 YJ1.6 ; YJ1.6 29.63,220.5 ; YJ1.6 28.1,222.02 ; YJ1.6 26.58,220.5 ; 54.18,220.5 YJ2.8 ; YJ2.8 55.7,218.98 ; YJ2.8 55.7,222.02 ; YJ2.8 57.23,220.5 ; 23.9,218.98 YJ1.7 ; YJ1.7 22.38,220.5 ; YJ1.7 23.9,222.02 ; YJ1.7 25.43,220.5 ; 45.78,220.5 YJ2.10 ; YJ2.10 48.83,220.5 ; YJ2.10 47.3,222.02 ; YJ2.10 47.3,218.98
  SIG5 w0.762: 51.5,218.98 YJ2.9 ; YJ2.9 49.98,220.5 ; YJ2.9 53.03,220.5 ; YJ2.9 51.5,222.02 ; YJ1.8 21.23,220.5 ; YJ1.8 19.7,218.98 ; YJ1.8 18.18,220.5 ; YJ1.8 19.7,222.02 ; YJ1.7 25.43,220.5 ; YJ1.7 23.9,222.02 ; YJ1.7 22.38,220.5 ; YJ1.7 23.9,218.98 ; 15.5,218.98 YJ1.9 ; YJ1.9 17.03,220.5 ; YJ1.9 13.98,220.5 ; YJ1.9 15.5,222.02 ; YJ2.6 65.63,220.5 ; YJ2.6 64.1,222.02 ; YJ2.6 62.58,220.5 ; YJ2.6 64.1,218.98 ; YJ2.8 55.7,222.02 ; YJ2.8 54.18,220.5 ; YJ2.8 55.7,218.98 ; YJ2.8 57.23,220.5 ; 28.1,218.98 YJ1.6 ; YJ1.6 29.63,220.5 ; YJ1.6 26.58,220.5 ; YJ1.6 28.1,222.02 ; 9.78,220.5 YJ1.10 ; YJ1.10 11.3,222.02 ; YJ1.10 11.3,218.98 ; YJ1.10 12.83,220.5 ; 59.9,218.98 YJ2.7 ; YJ2.7 58.38,220.5 ; YJ2.7 59.9,222.02 ; YJ2.7 61.43,220.5 ; 47.3,218.98 YJ2.10 ; YJ2.10 45.78,220.5 ; YJ2.10 47.3,222.02 ; YJ2.10 48.83,220.5
  BOTTOM w0.381: 10.99,126.87 C3650.1 9.54,125.9 8.99,125.35 v1(8.83,125.35) ; v1(381.57,195.7) 381.32,195.45 R3521.1 ; R3525.1 v1(378.52,195.7) ; 38.67,133.86 C3651.1 37.22,132.88 36.67,132.33 v1(36.51,132.33) ; C2110.1 20.38,207.17 ; C2110.1 21.24,206.47 ; C2110.1 19.72,206.47 ; R3540.1 266.26,210.94 v1(266,210.69) ; C3488.2 58.33,207.11 ; C3488.2 56.6,207.11 ; C3488.2 57.47,207.9 ; R3522.1 379.92,195.32 v1(379.54,195.7) ; R3546.1 R3553.1 153.1,209.09 152.54,208.53 150.94,208.53 149.8,207.39 147.64,207.39 v1(147.51,207.52) ; R3539.1 R3543.1 v1(375.09,210.56) ; v1(257.37,211.71) v2(257.37,210.82) ; C11.2 37.27,207.52 ; C11.2 38.01,206.73 ; C11.2 36.54,206.73 ; R3564.1 371.89,154.81 v1(370.9,154.81) ; v1(369.13,114.55) 368.87,114.81 R3554.1 R3560.1 ; v1(381.47,110.87) 380.76,111.58 C3692.1 379.84,111.58 378.52,112.9 v1(375.63,112.9)
  BOTTOM w0.762: YJ2.6 64.1,222.02 ; YJ2.6 62.58,220.5 ; YJ2.6 64.1,218.98 ; YJ2.6 65.63,220.5 ; 18.18,220.5 YJ1.8 ; YJ1.8 21.23,220.5 ; YJ1.8 19.7,218.98 ; YJ1.8 19.7,222.02 ; YJ1.9 15.5,222.02 ; YJ1.9 15.5,218.98 ; YJ1.9 13.98,220.5 ; YJ1.9 17.03,220.5 ; YJ1.10 12.83,220.5 ; YJ1.10 11.3,218.98 ; YJ1.10 11.3,222.02 ; YJ1.10 9.78,220.5 ; 45.78,220.5 YJ2.10 ; YJ2.10 47.3,222.02 ; YJ2.10 48.83,220.5 ; YJ2.10 47.3,218.98 ; YJ2.9 53.03,220.5 ; YJ2.9 49.98,220.5 ; YJ2.9 51.5,222.02 ; YJ2.9 51.5,218.98 ; YJ1.7 25.43,220.5 ; YJ1.7 22.38,220.5 ; YJ1.7 23.9,218.98 ; YJ1.7 23.9,222.02 ; YJ1.6 28.1,222.02 ; YJ1.6 26.58,220.5 ; YJ1.6 28.1,218.98 ; YJ1.6 29.63,220.5 ; 54.18,220.5 YJ2.8 ; YJ2.8 57.23,220.5 ; YJ2.8 55.7,218.98 ; YJ2.8 55.7,222.02 ; 58.38,220.5 YJ2.7 ; YJ2.7 59.9,222.02 ; YJ2.7 59.9,218.98 ; YJ2.7 61.43,220.5
  vias: v1(10.73,212.21) v1(10.73,210.31) v1(10.73,208.4) v1(13.27,212.21) v1(13.27,210.31) v1(13.27,208.4) v1(15.81,212.21) v1(15.81,210.31) v1(15.81,208.4) v1(16.45,129.41) v1(16.45,128.27) v1(17.72,127) v1(17.84,129.41) v1(17.84,128.27) v1(18.35,212.21) v1(18.35,210.31) v1(18.35,208.4) v1(19.24,128.27) v1(19.24,127) v1(20.64,127) v1(20.89,212.21) v1(20.89,210.31) v1(20.89,208.4) v1(23.43,212.21) v1(23.43,210.31) v1(23.43,208.4) v1(25.97,212.21) v1(25.97,210.31) v1(25.97,208.4) v1(28.51,212.21) v1(28.51,210.31) v1(28.51,208.4) v1(31.05,212.21) v1(31.05,210.31) v1(31.05,208.4) v1(33.59,212.21) v1(33.59,210.31) v1(33.59,208.4) v1(36.13,212.21) v1(36.13,210.31) v1(36.13,208.4) v1(38.67,212.21) v1(38.67,210.31) v1(38.67,208.4) v1(40.07,137.28) v1(40.96,136.65) v1(41.21,212.21) v1(41.21,210.31) v1(41.21,208.4) v1(41.72,135.89) v1(42.61,135.13) v1(43.5,134.24) v1(43.75,212.21) v1(43.75,210.31) v1(43.75,208.4) v1(44.26,133.47) v1(47.56,212.49) v1(47.56,210.31) v1(47.56,208.28) v1(50.1,212.49) v1(50.1,210.31) v1(50.1,208.28) v1(52.64,212.49) v1(52.64,210.31) v1(52.64,208.28) v1(55.18,212.49) v1(55.18,210.31) v1(57.72,212.49) v1(57.72,210.31) v1(60.26,212.49) v1(60.26,210.31) v1(62.8,212.49) v1(62.8,210.31) v1(65.34,212.49) v1(65.34,210.31) v1(67.88,212.49) v1(68.26,210.31) v1(143.45,207.52) v1(144.46,207.52) v1(145.48,207.52) v1(146.49,207.52) v1(254.44,211.71) v1(255.33,211.71) v1(256.35,211.71) v1(369.13,113.54) v1(369.13,112.52) v1(369.13,111.5) v1(373.06,210.56) v1(374.08,210.56) v1(376.11,210.56) v1(380.56,195.7) v2(20.89,128.14) v2(22.54,207.01) v2(28.51,207.01) v2(42.48,136.52) v2(42.74,207.26) v2(54.93,207.26) v2(67.63,207.39) v2(145.61,208.53) v2(368.24,114.04) v2(375.6,211.45) v2(378.78,144.65) v2(379.79,118.36) v2(380.17,137.67) v2(381.19,196.72) v3(379.92,123.95) v3(379.92,122.68) v3(379.92,121.41) v3(379.92,120.14) v3(380.3,147.19) v3(380.3,145.92) v3(380.3,144.65) v3(380.3,143.38)
VDD_CORE: length 673.5
  TOP w0.229: U1.AH47 v1(183.55,133.34) ; U1.AF47 v1(183.55,131.34) ; U1.AK47 v1(183.55,135.34) ; U1.AG20 v1(211.55,132.34) ; U1.AB47 v1(183.55,127.34) ; U1.AC20 v1(211.55,128.34) ; U1.AP47 v1(183.55,140.34) ; U1.BE20 v1(211.55,151.34) ; U1.BD47 v1(183.55,150.34) ; U1.AU20 v1(211.55,143.34) ; U1.BA20 v1(211.55,147.34) ; U1.AT47 v1(183.55,142.34) ; U1.BB47 v1(183.55,148.34) ; U1.AN20 v1(211.55,138.34) ; U1.AE20 v1(211.55,130.34) ; U1.AV47 v1(183.55,144.34) ; U1.AR20 v1(211.55,141.34) ; U1.AY47 v1(183.55,146.34) ; U1.AM47 v1(183.55,137.34) ; U1.AW20 v1(211.55,145.34) ; U1.AJ20 v1(211.55,134.34) ; U1.AD47 v1(183.55,129.34) ; U1.AL20 v1(211.55,136.34) ; U1.BC20 v1(211.55,149.34)
  TOP w0.254: v1(377.74,175) 377.79,174.95 R3131.1
  TOP w0.279: U1.AJ40 v1(190.55,134.34) ; U1.BA22 v1(209.55,147.34) ; U1.BA42 v1(188.55,147.34) ; U1.AW30 v1(201.55,145.34) ; U1.AF35 v1(195.55,131.34) ; U1.AV35 v1(195.55,144.34) ; U1.AC30 v1(201.55,128.34) ; U1.AM21 v1(210.55,137.34) ; U1.BB29 v1(202.55,148.34) ; U1.AG34 v1(196.55,132.34) ; U1.AL30 v1(201.55,136.34) ; U1.BD31 v1(200.55,150.34) ; U1.AT39 v1(191.55,142.34) ; U1.AC36 v1(194.55,128.34) ; U1.AN40 v1(190.55,138.34) ; U1.AR44 v1(186.55,141.34) ; U1.AH31 v1(200.55,133.34) ; U1.AV25 v1(206.55,144.34) ; U1.AH33 v1(198.55,133.34) ; U1.AJ24 v1(207.55,134.34) ; U1.AH37 v1(193.55,133.34) ; U1.AM27 v1(204.55,137.34) ; U1.AV39 v1(191.55,144.34) ; U1.AF21 v1(210.55,131.34) ; U1.AK31 v1(200.55,135.34) ; U1.AH27 v1(204.55,133.34) ; U1.AU22 v1(209.55,143.34) ; U1.AL38 v1(192.55,136.34) ; U1.AN28 v1(203.55,138.34) ; U1.AN26 v1(205.55,138.34) ; U1.AW28 v1(203.55,145.34) ; U1.AD37 v1(193.55,129.34) ; U1.AY45 v1(185.55,146.34) ; U1.BC42 v1(188.55,149.34) ; U1.AU26 v1(205.55,143.34) ; U1.AU36 v1(194.55,143.34) ; U1.AB25 v1(206.55,127.34) ; U1.AL40 v1(190.55,136.34) ; U1.AP37 v1(193.55,140.34) ; U1.AB43 v1(187.55,127.34) ; U1.BB31 v1(200.55,148.34) ; U1.AU24 v1(207.55,143.34) ; U1.AY29 v1(202.55,146.34) ; U1.AK29 v1(202.55,135.34) ; U1.BC32 v1(199.55,149.34) ; U1.BA38 v1(192.55,147.34) ; U1.BA40 v1(190.55,147.34) ; U1.AV27 v1(204.55,144.34) ; U1.BD29 v1(202.55,150.34) ; U1.AG22 v1(209.55,132.34) ; U1.AY25 v1(206.55,146.34) ; U1.AC46 v1(184.55,128.34) ; U1.AT37 v1(193.55,142.34) ; U1.AL22 v1(209.55,136.34) ; U1.AL44 v1(186.55,136.34) ; U1.BB21 v1(210.55,148.34) ; U1.BC28 v1(203.55,149.34) ; U1.AB45 v1(185.55,127.34) ; U1.AV23 v1(208.55,144.34) ; U1.AG42 v1(188.55,132.34) ; U1.AL34 v1(196.55,136.34) ; U1.BB41 v1(189.55,148.34) ; U1.BA46 v1(184.55,147.34) ; U1.BB39 v1(191.55,148.34) ; U1.AE30 v1(201.55,130.34) ; U1.AK21 v1(210.55,135.34) ; U1.AF39 v1(191.55,131.34) ; U1.BD21 v1(210.55,150.34) ; U1.AH35 v1(195.55,133.34) ; U1.AY21 v1(210.55,146.34) ; U1.AT43 v1(187.55,142.34) ; U1.BE40 v1(190.55,151.34) ; U1.BA44 v1(186.55,147.34) ; U1.AF43 v1(187.55,131.34) ; U1.AJ46 v1(184.55,134.34) ; U1.AW38 v1(192.55,145.34) ; U1.AN34 v1(196.55,138.34) ; U1.AB27 v1(204.55,127.34) ; U1.AH45 v1(185.55,133.34) ; U1.AB37 v1(193.55,127.34) ; U1.AE36 v1(194.55,130.34) ; U1.AP39 v1(191.55,140.34) ; U1.BB33 v1(198.55,148.34) ; U1.AH41 v1(189.55,133.34) ; U1.AG24 v1(207.55,132.34) ; U1.AV21 v1(210.55,144.34) ; U1.AC26 v1(205.55,128.34) ; U1.AR30 v1(201.55,141.34) ; U1.BA28 v1(203.55,147.34) ; U1.AP21 v1(210.55,140.34) ; U1.AR42 v1(188.55,141.34) ; U1.AB29 v1(202.55,127.34) ; U1.AB23 v1(208.55,127.34) ; U1.AF27 v1(204.55,131.34) ; U1.AK23 v1(208.55,135.34) ; U1.AN32 v1(199.55,138.34) ; U1.AG38 v1(192.55,132.34) ; U1.BD39 v1(191.55,150.34) ; U1.AW32 v1(199.55,145.34) ; U1.BE24 v1(207.55,151.34) ; U1.AW40 v1(190.55,145.34) ; U1.BD37 v1(193.55,150.34) ; U1.BE46 v1(184.55,151.34) ; U1.AW22 v1(209.55,145.34) ; U1.AW34 v1(196.55,145.34) ; U1.AY37 v1(193.55,146.34) ; U1.AN38 v1(192.55,138.34) ; U1.AC28 v1(203.55,128.34) ; U1.AD41 v1(189.55,129.34) ; U1.AH21 v1(210.55,133.34) ; U1.AC42 v1(188.55,128.34) ; U1.AE34 v1(196.55,130.34) ; U1.AE44 v1(186.55,130.34) ; U1.BC34 v1(196.55,149.34) ; U1.AJ36 v1(194.55,134.34) ; U1.AW24 v1(207.55,145.34) ; U1.AU40 v1(190.55,143.34) ; U1.AK25 v1(206.55,135.34) ; U1.BC36 v1(194.55,149.34) ; U1.BB37 v1(193.55,148.34) ; U1.AJ42 v1(188.55,134.34) ; U1.AF33 v1(198.55,131.34) ; U1.AP29 v1(202.55,140.34) ; U1.AM25 v1(206.55,137.34) ; U1.BD25 v1(206.55,150.34) ; U1.AN44 v1(186.55,138.34) ; U1.AD27 v1(204.55,129.34) ; U1.AJ38 v1(192.55,134.34) ; U1.BA24 v1(207.55,147.34) ; U1.AN24 v1(207.55,138.34) ; U1.AJ32 v1(199.55,134.34) ; U1.AD32 v1(199.55,129.34) ; U1.AR24 v1(207.55,141.34) ; U1.BC40 v1(190.55,149.34) ; U1.AK37 v1(193.55,135.34) ; U1.AK39 v1(191.55,135.34) ; U1.AM29 v1(202.55,137.34) ; U1.AE38 v1(192.55,130.34) ; U1.AG44 v1(186.55,132.34) ; U1.AV29 v1(202.55,144.34) ; U1.AB31 v1(200.55,127.34) ; U1.BA30 v1(201.55,147.34) ; U1.BC44 v1(186.55,149.34) ; U1.BD27 v1(204.55,150.34) ; U1.AB21 v1(210.55,127.34) ; U1.AE40 v1(190.55,130.34) ; U1.AR26 v1(205.55,141.34) ; U1.AT29 v1(202.55,142.34) ; U1.AT31 v1(200.55,142.34) ; U1.AP31 v1(200.55,140.34) ; U1.AG46 v1(184.55,132.34) ; U1.BC26 v1(205.55,149.34) ; U1.AT21 v1(210.55,142.34) ; U1.AT41 v1(189.55,142.34) ; U1.AR46 v1(184.55,141.34) ; U1.BE26 v1(205.55,151.34) ; U1.AV37 v1(193.55,144.34) ; U1.AR22 v1(209.55,141.34) ; U1.AF29 v1(202.55,131.34) ; U1.AC40 v1(190.55,128.34) ; U1.AK45 v1(185.55,135.34) ; U1.AY33 v1(198.55,146.34) ; U1.AE32 v1(199.55,130.34) ; U1.AM45 v1(185.55,137.34) ; U1.BC46 v1(184.55,149.34) ; U1.AC22 v1(209.55,128.34) ; U1.AY39 v1(191.55,146.34) ; U1.AE28 v1(203.55,130.34) ; U1.AY35 v1(195.55,146.34) ; U1.AW26 v1(205.55,145.34) ; U1.AM31 v1(200.55,137.34) ; U1.AD21 v1(210.55,129.34) ; U1.AN36 v1(194.55,138.34) ; U1.AF31 v1(200.55,131.34) ; U1.AJ30 v1(201.55,134.34) ; U1.BE38 v1(192.55,151.34) ; U1.AR36 v1(194.55,141.34) ; U1.AV43 v1(187.55,144.34) ; U1.AY27 v1(204.55,146.34) ; U1.AM35 v1(195.55,137.34) ; U1.AD31 v1(200.55,129.34) ; U1.AM41 v1(189.55,137.34) ; U1.AP45 v1(185.55,140.34) ; U1.AH39 v1(191.55,133.34) ; U1.BE42 v1(188.55,151.34) ; U1.AT25 v1(206.55,142.34) ; U1.AU38 v1(192.55,143.34) ; U1.AC38 v1(192.55,128.34) ; U1.BB43 v1(187.55,148.34) ; U1.AK33 v1(198.55,135.34) ; U1.AG30 v1(201.55,132.34) ; U1.AM23 v1(208.55,137.34) ; U1.AP41 v1(189.55,140.34) ; U1.AC44 v1(186.55,128.34) ; U1.AR28 v1(203.55,141.34) ; U1.AK27 v1(204.55,135.34) ; U1.AR38 v1(192.55,141.34) ; U1.BA26 v1(205.55,147.34) ; U1.BB27 v1(204.55,148.34) ; U1.AE42 v1(188.55,130.34) ; U1.BD23 v1(208.55,150.34) ; U1.AJ22 v1(209.55,134.34) ; U1.AP27 v1(204.55,140.34) ; U1.AL26 v1(205.55,136.34) ; U1.AP23 v1(208.55,140.34) ; U1.AN42 v1(188.55,138.34) ; U1.AP43 v1(187.55,140.34) ; U1.AM39 v1(191.55,137.34) ; U1.AG28 v1(203.55,132.34) ; U1.AJ28 v1(203.55,134.34) ; U1.AU32 v1(199.55,143.34) ; U1.BC22 v1(209.55,149.34) ; U1.AV45 v1(185.55,144.34) ; U1.AE26 v1(205.55,130.34) ; U1.AB39 v1(191.55,127.34) ; U1.AR32 v1(199.55,141.34) ; U1.BB23 v1(208.55,148.34) ; U1.AH25 v1(206.55,133.34) ; U1.AL36 v1(194.55,136.34) ; U1.AU44 v1(186.55,143.34) ; U1.AY43 v1(187.55,146.34) ; U1.AU46 v1(184.55,143.34) ; U1.AU42 v1(188.55,143.34) ; U1.BD41 v1(189.55,150.34) ; U1.BE30 v1(201.55,151.34) ; U1.AW42 v1(188.55,145.34) ; U1.AL32 v1(199.55,136.34) ; U1.AL46 v1(184.55,136.34) ; U1.AP33 v1(198.55,140.34) ; U1.AK43 v1(187.55,135.34) ; U1.AD43 v1(187.55,129.34) ; U1.AD45 v1(185.55,129.34) ; U1.AE22 v1(209.55,130.34) ; U1.AV41 v1(189.55,144.34) ; U1.AW44 v1(186.55,145.34) ; U1.AY41 v1(189.55,146.34) ; U1.BE22 v1(209.55,151.34) ; U1.AL42 v1(188.55,136.34) ; U1.AF23 v1(208.55,131.34) ; U1.AV33 v1(198.55,144.34) ; U1.AM43 v1(187.55,137.34) ; U1.BC30 v1(201.55,149.34) ; U1.AC24 v1(207.55,128.34) ; U1.AN46 v1(184.55,138.34) ; U1.AV31 v1(200.55,144.34) ; U1.AG40 v1(190.55,132.34) ; U1.BE32 v1(199.55,151.34) ; U1.AY31 v1(200.55,146.34) ; U1.BB25 v1(206.55,148.34) ; U1.AT33 v1(198.55,142.34) ; U1.AU28 v1(203.55,143.34) ; U1.AW36 v1(194.55,145.34) ; U1.AF37 v1(193.55,131.34) ; U1.BC38 v1(192.55,149.34) ; U1.AF25 v1(206.55,131.34) ; U1.BC24 v1(207.55,149.34) ; U1.AH29 v1(202.55,133.34) ; U1.AH43 v1(187.55,133.34) ; U1.AM37 v1(193.55,137.34) ; U1.AT23 v1(208.55,142.34) ; U1.BD34 v1(196.55,150.34) ; U1.AG32 v1(199.55,132.34) ; U1.AJ34 v1(196.55,134.34) ; U1.AW46 v1(184.55,145.34) ; U1.BB45 v1(185.55,148.34) ; U1.AU30 v1(201.55,143.34) ; U1.BE44 v1(186.55,151.34) ; U1.AK35 v1(195.55,135.34) ; U1.AL28 v1(203.55,136.34) ; U1.AE24 v1(207.55,130.34) ; U1.AD39 v1(191.55,129.34) ; U1.AJ26 v1(205.55,134.34) ; U1.AD35 v1(195.55,129.34) ; U1.AB41 v1(189.55,127.34) ; U1.AR40 v1(190.55,141.34) ; U1.AF45 v1(185.55,131.34) ; U1.BD45 v1(185.55,150.34) ; U1.AG36 v1(194.55,132.34) ; U1.BD43 v1(187.55,150.34) ; U1.AG26 v1(205.55,132.34) ; U1.AH23 v1(208.55,133.34) ; U1.AM33 v1(198.55,137.34) ; U1.AN22 v1(209.55,138.34) ; U1.AP35 v1(195.55,140.34) ; U1.AT27 v1(204.55,142.34) ; U1.AU34 v1(196.55,143.34) ; U1.AD23 v1(208.55,129.34) ; U1.AP25 v1(206.55,140.34) ; U1.AD25 v1(206.55,129.34) ; U1.AN30 v1(201.55,138.34) ; U1.AT45 v1(185.55,142.34) ; U1.AT35 v1(195.55,142.34) ; U1.AD29 v1(202.55,129.34) ; U1.BE28 v1(203.55,151.34) ; U1.AY23 v1(208.55,146.34) ; U1.AF41 v1(189.55,131.34) ; U1.AE46 v1(184.55,130.34) ; U1.AK41 v1(189.55,135.34) ; U1.AL24 v1(207.55,136.34) ; U1.BA32 v1(199.55,147.34) ; U1.AJ44 v1(186.55,134.34) ; U1.BA34 v1(196.55,147.34)
  TOP w0.381: C2861.1 253.63,122.93 ; C2861.1 253.15,123.42 ; C2861.1 253.15,122.45 ; C2749.1 143.78,131.44 ; C2749.1 143.29,131.93 ; C2749.1 143.29,130.96 ; 253.15,124.74 C3037.1 ; C3037.1 253.15,125.7 ; C3037.1 253.63,125.22 ; 146.67,109.6 C2881.1 ; C2881.1 147.16,110.08 ; C2881.1 147.16,109.12 ; C2784.1 144.29,98.17 ; C2784.1 143.8,98.65 ; C2784.1 143.8,97.69 ; C2792.1 144.29,100.45 ; C2792.1 143.8,99.97 ; C2792.1 143.8,100.94 ; 219.04,179.8 C3170.1 ; C3170.1 220,179.8 ; C3170.1 219.52,180.29 ; 153.96,102.13 C2954.1 ; C2954.1 154.45,102.61 ; C2954.1 153.96,103.1 ; C2789.1 144.29,95.88 ; C2789.1 143.8,95.4 ; C2789.1 143.8,96.37 ; C2966.1 222.29,179.8 ; C2966.1 221.81,180.29 ; C2966.1 221.32,179.8 ; 153.96,104.42 C3136.1 ; C3136.1 154.45,104.9 ; C3136.1 153.96,105.38 ; C3004.1 253.15,134.85 ; C3004.1 253.15,133.88 ; C3004.1 253.63,134.36 ; 143.8,93.11 C2790.1 ; C2790.1 143.8,94.08 ; C2790.1 144.29,93.6 ; 147.16,111.4 C3071.1 ; C3071.1 146.67,111.88 ; C3071.1 147.16,112.37 ; 247.74,113.31 C3127.1 ; C3127.1 247.74,114.27 ; C3127.1 247.26,113.79 ; 153.96,106.7 C2934.1 ; C2934.1 154.45,107.19 ; C2934.1 153.96,107.67 ; C3035.1 253.63,129.79 ; C3035.1 253.15,130.27 ; C3035.1 253.15,129.31 ; 143.78,129.03 C2726.1 143.29,129.51 ; 253.15,131.59 C2826.1 ; C2826.1 253.63,132.08 ; C2826.1 253.15,132.56 ; C2741.1 143.29,134.21 ; C2741.1 143.29,133.25 ; C2741.1 143.78,133.73 ; 247.74,117.88 C3105.1 ; C3105.1 247.74,118.84 ; C3105.1 247.26,118.36 ; C2671.1 256.1,166.24 ; 156.83,111.76 C3169.1 ; C3169.1 157.32,111.27 ; C3169.1 157.32,112.24 ; 216.75,179.8 C3173.1 ; C3173.1 217.72,179.8 ; C3173.1 217.23,180.29 ; 223.61,179.8 C2989.1 ; C2989.1 224.09,180.29 ; C2989.1 224.57,179.8 ; C2829.1 253.63,127.51 ; C2829.1 253.15,127.99 ; C2829.1 253.15,127.02 ; 146.67,114.17 C3075.1 ; C3075.1 147.16,114.65 ; C3075.1 147.16,113.69 ; 157.32,108.99 C2963.1 ; C2963.1 156.83,109.47 ; C2963.1 157.32,109.95 ; 247.74,115.59 C2926.1 ; C2926.1 247.74,116.56 ; C2926.1 247.26,116.08 ; C2823.1 226.38,188.8 ; C2823.1 226.86,188.31 ; C2823.1 225.89,188.31 ; C2669.1 255.84,122.93
  SIG4 w0.508: v1(28.89,173.61) 28.89,176.4 36.51,184.02 36.51,185.37 41.64,190.5 44.01,190.5 56.58,203.07 66.43,203.07 67.32,203.96 v1(69.15,203.96)
  BOTTOM w0.254: v1(377.74,175) 378.73,175.99 380.84,175.99 381.44,175.38 381.44,173.18 382.27,172.35 382.27,159.82 382.43,159.67 383.74,159.67 384.43,158.98 384.43,157.19 368.94,141.7 368.94,134.57 353.24,118.87 344.74,118.87 341.06,122.55 328.23,122.55 327.34,123.44 327.34,124.13 C3889.1
  BOTTOM w0.381: v1(196.55,130.34) 197.06,129.83 C1166.1 ; v1(205.55,136.34) 205.07,135.86 C2725.1 ; C2662.1 191.02,143.82 v1(190.55,143.34) ; C937.1 205.07,149.82 v1(205.55,149.34) ; v1(192.55,134.34) 193.06,133.83 C980.1 ; v1(198.55,146.34) 199.03,146.83 C930.1 ; v1(183.55,142.34) 183.07,142.83 C3056.1 ; v1(196.55,138.34) 197.05,137.84 C996.1 ; v1(202.55,148.34) 203.03,148.83 C1224.1 ; v1(200.55,146.34) 201.03,146.83 C2838.1 ; v1(203.55,138.34) 203.06,137.85 C2803.1 ; v1(195.55,131.34) 195.07,130.86 C958.1 ; C1031.1 185.07,146.83 v1(185.55,146.34) ; v1(192.55,147.34) 193.02,147.82 C1021.1 ; v1(184.55,128.34) 185.06,127.83 C1186.1 ; v1(196.55,147.34) 196.07,147.82 C1043.1 ; v1(209.55,138.34) 209.07,137.86 C1145.1 ; v1(204.55,150.34) 205.02,150.82 C1239.1 ; v1(190.55,147.34) 191.02,147.82 C1179.1 ; v1(185.55,150.34) 185.07,150.83 C1020.1 ; C1267.1 211.02,142.82 v1(210.55,142.34) ; C1227.1 203.07,145.83 v1(203.55,145.34) ; v1(201.55,143.34) 201.07,143.83 C932.1 ; C938.1 203.03,140.83 v1(202.55,140.34) ; v1(209.55,136.34) 209.07,135.86 C1256.1 ; v1(194.55,141.34) 194.03,140.82 C1234.1 ; C1034.1 192.07,151.82 v1(192.55,151.34) ; C884.1 207.02,140.82 v1(206.55,140.34) ; v1(195.55,129.34) 195.07,128.86 C971.1 ; C2875.1 207.02,148.82 v1(206.55,148.34) ; v1(196.55,149.34) 196.07,149.82 C1019.1 ; v1(207.55,130.34) 207.07,129.86 C1045.1 ; C990.1 185.06,135.83 v1(184.55,136.34) ; C991.1 195.07,134.86 v1(195.55,135.34) ; C887.1 207.07,131.86 v1(207.55,132.34) ; C1159.1 191.07,126.86 v1(191.55,127.34) ; C2943.1 201.03,142.83 v1(200.55,142.34) ; v1(188.55,141.34) 189.02,141.82 C1147.1 ; v1(194.55,138.34) 195.05,137.84 C959.1 ; C1165.1 187.06,135.83 v1(186.55,136.34) ; v1(206.55,135.34) 207.07,134.82 C2817.1 ; C1027.1 183.07,146.83 v1(183.55,146.34) ; v1(194.55,136.34) 195.06,135.83 C3080.1 ; C1004.1 187.03,141.83 v1(186.55,141.34) ; C987.1 194.03,142.82 v1(194.55,143.34) ; C984.1 189.07,134.86 v1(189.55,135.34) ; v1(200.55,137.34) 200.03,136.83 C2851.1 ; v1(187.55,137.34) 187.07,136.86 C968.1 ; C1228.1 203.03,144.83 v1(202.55,144.34) ; v1(210.55,137.34) 210.03,136.82 C1194.1 ; v1(204.55,146.34) 205.02,146.82 C2985.1 ; C3088.1 184.03,143.86 v1(183.55,144.34) 183.07,144.83 C1025.1 ; v1(185.55,127.34) 185.07,126.86 C1144.1 ; C2836.1 199.03,148.83 v1(198.55,148.34) ; C1163.1 187.07,142.83 v1(187.55,142.34) ; C1251.1 196.03,141.86 v1(195.55,142.34) ; v1(187.55,133.34) 187.07,132.86 C1171.1 ; C1192.1 187.07,128.86 v1(187.55,129.34) ; v1(191.55,129.34) 191.07,128.86 C1188.1 ; C1205.1 209.02,140.82 v1(208.55,140.34) ; v1(190.55,145.34) 191.02,145.82 C1009.1 ; v1(186.55,149.34) 187.06,148.83 C1040.1 ; C928.1 205.02,142.82 v1(204.55,142.34) ; v1(206.55,142.34) 207.02,142.82 C924.1 ; C1015.1 193.07,144.82 v1(192.55,145.34) ; v1(191.55,140.34) 191.07,139.86 C1249.1 ; C962.1 195.06,133.83 v1(194.55,134.34) ; v1(183.55,127.34) 183.55,127.35 C1187.1 ; v1(189.55,144.34) 189.07,144.82 C1002.1 ; v1(185.55,148.34) 185.07,148.83 C1032.1 ; v1(201.55,147.34) 201.07,147.83 C942.1 ; v1(186.55,130.34) 187.06,129.83 C1161.1 ; C1212.1 212.02,132.82 v1(211.55,132.34) ; v1(194.55,149.34) 195.07,148.82 C1005.1 ; C1023.1 187.07,150.83 v1(187.55,150.34) ; C2814.1 203.06,127.85 v1(203.55,128.34) ; C2912.1 202.03,136.83 v1(202.55,137.34) ; v1(209.55,130.34) 209.07,129.86 C1219.1 ; v1(211.55,141.34) 212.02,141.82 C1268.1 ; v1(211.55,145.34) 211.07,145.82 C1264.1 ; C1037.1 183.07,150.83 v1(183.55,150.34) ; C1226.1 203.03,146.83 v1(202.55,146.34) ; v1(201.55,128.34) 201.06,127.85 C1231.1 ; C936.1 208.02,151.82 v1(207.55,151.34) ; C2895.1 207.07,133.86 v1(207.55,134.34) ; v1(189.55,142.34) 189.07,142.82 C1012.1 ; v1(186.55,145.34) 186.07,145.83 C1028.1 ; v1(200.55,140.34) 201.03,140.83 C2677.1 ; v1(196.55,132.34) 197.06,131.83 C1174.1 ; v1(189.55,131.34) 189.07,130.86 C1180.1 ; C1232.1 200.03,143.82 v1(199.55,143.34) ; v1(199.55,145.34) 200.03,145.82 C935.1 ; C1156.1 197.06,133.83 v1(196.55,134.34) ; C2740.1 208.03,136.82 v1(208.55,137.34) ; C2663.1 193.07,134.86 v1(193.55,135.34) ; C1263.1 211.02,146.82 v1(210.55,146.34) ; v1(210.55,144.34) 211.02,144.82 C1265.1 ; v1(191.55,146.34) 191.07,146.82 C3091.1 ; C883.1 210.02,149.82 v1(209.55,149.34) ; v1(210.55,127.34) 211.02,127.82 C2825.1 ; v1(192.55,141.34) 192.03,140.82 C1010.1 ; C1213.1 211.02,131.82 v1(210.55,131.34) ; C1220.1 201.07,149.83 v1(201.55,149.34) ; v1(189.55,140.34) 189.07,139.86 C1252.1 ; C1044.1 184.07,151.83 v1(184.55,151.34) ; C923.1 201.03,144.83 v1(200.55,144.34) ; v1(186.55,132.34) 187.06,131.83 C1160.1 ; C1149.1 193.06,137.83 v1(192.55,138.34) ; C2874.1 207.07,145.82 v1(207.55,145.34) ; C1201.1 209.02,144.82 v1(208.55,144.34) ; C1214.1 212.02,130.82 v1(211.55,130.34) ; v1(189.55,146.34) 189.07,146.82 C1164.1 ; v1(209.55,141.34) 209.07,141.82 C1204.1 ; v1(205.55,128.34) 205.07,127.86 C882.1 ; v1(203.55,130.34) 203.06,129.85 C2859.1 ; C999.1 189.06,137.83 v1(188.55,138.34) ; C1206.1 199.06,130.83 v1(198.55,131.34) ; C966.1 193.06,127.83 v1(192.55,128.34) ; C947.1 201.06,129.85 v1(201.55,130.34) ; v1(183.55,148.34) 183.06,147.85 C1014.1 ; v1(198.55,142.34) 199.03,142.83 C2715.1 ; C981.1 191.07,132.86 v1(191.55,133.34) ; C2680.1 201.06,132.83 v1(200.55,133.34) ; v1(191.55,137.34) 191.07,136.86 C967.1 ; C2848.1 199.06,132.83 v1(198.55,133.34) ; v1(186.55,151.34) 186.07,151.83 C1030.1 ; v1(188.55,147.34) 189.02,147.82 C1039.1 ; v1(195.55,140.34) 196.02,140.82 C1235.1 ; C1229.1 203.07,143.83 v1(203.55,143.34) ; C1013.1 187.07,140.83 v1(187.55,140.34) ; v1(199.55,138.34) 199.06,137.85 C943.1 ; v1(190.55,130.34) 191.06,129.83 C974.1 ; v1(205.55,147.34) 205.07,147.82 C2701.1 ; v1(28.89,173.61) 29.65,172.84 R3275.2 ; C1157.1 183.07,129.82 v1(183.55,129.34) ; v1(208.55,146.34) 209.02,146.82 C1199.1 ; C965.1 185.07,136.86 v1(185.55,137.34) ; C1051.1 207.07,135.86 v1(207.55,136.34) ; C1011.1 191.07,144.82 v1(191.55,144.34) ; v1(190.55,151.34) 190.07,151.83 C975.1 ; C3063.1 207.07,143.82 v1(207.55,143.34) ; v1(188.55,132.34) 189.06,131.83 C1153.1 ; C886.1 199.06,131.85 v1(199.55,132.34) ; v1(204.55,127.34) 205.07,126.82 C2923.1 ; v1(210.55,133.34) 211.02,133.82 C1211.1 ; C3003.1 199.03,140.83 v1(198.55,140.34) ; C2900.1 186.03,141.86 v1(185.55,142.34) 185.07,142.83 C3020.1 ; v1(207.55,147.34) 207.07,147.82 C2760.1 ; v1(204.55,133.34) 205.07,132.82 C2707.1 ; C2772.1 205.07,137.86 v1(205.55,138.34) ; C2961.1 205.07,133.86 v1(205.55,134.34) ; v1(209.55,145.34) 209.07,145.82 C1200.1 ; C940.1 205.02,148.82 v1(204.55,148.34) ; C1050.1 201.03,150.83 v1(200.55,150.34) ; v1(207.55,149.34) 207.54,149.34 C2946.1 ; C2896.1 205.55,130.3 v1(205.55,130.34) ; v1(195.55,144.34) 196.03,143.86 C1250.1 ; C1195.1 209.07,134.82 v1(208.55,135.34) ; v1(202.55,133.34) 203.06,132.83 C2870.1 ; C1238.1 206.03,151.82 v1(205.55,151.34) ; v1(208.55,142.34) 209.02,142.82 C1203.1 ; v1(202.55,150.34) 203.03,150.83 C1223.1 ; v1(191.55,135.34) 191.07,134.86 C985.1 ; v1(188.55,130.34) 189.06,129.83 C1176.1 ; C1233.1 201.07,141.83 v1(201.55,141.34) ; C957.1 191.07,130.86 v1(191.55,131.34) ; C998.1 187.06,137.83 v1(186.55,138.34) ; v1(199.55,136.34) 199.06,135.85 C2949.1 ; C1168.1 183.07,131.82 v1(183.55,131.34) ; v1(210.55,140.34) 211.02,140.82 C1269.1 ; C2775.1 199.07,141.83 v1(199.55,141.34) ; C1001.1 192.03,142.82 v1(192.55,143.34) ; v1(206.55,129.34) 207.07,128.82 C3045.1 ; v1(200.55,127.34) 200.03,126.83 C1151.1 ; C3009.1 201.06,137.85 v1(201.55,138.34) ; C1189.1 191.07,148.82 v1(191.55,148.34) ; C3039.1 189.07,136.86 v1(189.55,137.34) ; v1(188.55,136.34) 189.06,135.83 C983.1 ; C1170.1 189.06,133.83 v1(188.55,134.34) ; C1196.1 209.07,132.82 v1(208.55,133.34) ; C1042.1 189.07,150.82 v1(189.55,150.34) ; v1(184.55,132.34) 185.06,131.83 C1193.1 ; v1(188.55,128.34) 189.06,127.83 C1183.1 ; v1(193.55,148.34) 193.07,148.82 C2947.1 ; v1(207.55,141.34) 207.07,141.82 C933.1 ; C1190.1 187.55,146.31 v1(187.55,146.34) ; C1260.1 212.02,149.82 v1(211.55,149.34) ; v1(184.55,145.34) 184.07,145.83 C1026.1 ; C1172.1 189.07,128.86 v1(189.55,129.34) ; C2917.1 203.06,135.85 v1(203.55,136.34) ; v1(208.55,129.34) 209.07,128.82 C878.1 ; v1(208.55,150.34) 209.02,150.82 C1049.1 ; v1(191.55,150.34) 191.07,150.82 C1036.1 ; v1(202.55,129.34) 203.06,128.83 C879.1 ; C1017.1 193.07,143.86 v1(193.55,144.34) ; v1(190.55,128.34) 191.06,127.83 C1167.1 ; v1(186.55,134.34) 187.06,133.83 C982.1 ; C992.1 191.06,135.83 v1(190.55,136.34) ; C2908.1 201.06,135.85 v1(201.55,136.34) ; C970.1 187.07,134.86 v1(187.55,135.34) ; C2988.1 203.06,134.83 v1(202.55,135.34) ; C2970.1 205.07,130.82 v1(204.55,131.34) ; C994.1 195.06,131.83 v1(194.55,132.34) ; v1(183.55,135.34) 183.07,135.82 C960.1 ; C1173.1 193.02,149.82 v1(192.55,149.34) ; v1(187.55,131.34) 187.07,130.86 C1148.1 ; v1(184.55,138.34) 185.06,137.83 C997.1 ; C1245.1 199.06,128.85 v1(199.55,129.34) ; v1(196.55,136.34) 197.06,135.83 C1162.1 ; C1243.1 205.07,134.82 v1(204.55,135.34) ; C1197.1 209.02,148.82 v1(208.55,148.34) ; C973.1 193.55,131.31 v1(193.55,131.34) ; v1(203.55,147.34) 203.07,147.83 C1225.1 ; v1(202.55,131.34) 203.06,130.83 C2710.1 ; C2748.1 209.07,126.82 v1(208.55,127.34) ; C2788.1 207.07,127.86 v1(207.55,128.34) ; v1(210.55,150.34) 211.02,150.82 C1259.1 ; C1210.1 212.02,134.82 v1(211.55,134.34) ; v1(184.55,149.34) 184.03,148.83 C1022.1 ; v1(194.55,130.34) 195.06,129.83 C963.1 ; v1(211.55,143.34) 212.02,143.82 C1266.1 ; v1(209.55,132.34) 209.07,131.86 C1217.1 ; v1(188.55,143.34) 189.02,143.82 C1003.1 ; C993.1 193.07,126.86 v1(193.55,127.34) ; C976.1 183.07,136.86 v1(183.55,137.34) ; C1000.1 191.07,141.86 v1(191.55,142.34) ; C986.1 193.07,136.86 v1(193.55,137.34) ; v1(189.55,127.34) 189.07,126.86 C1155.1 ; v1(185.55,131.34) 185.07,130.86 C1182.1 ; C1221.1 203.07,149.83 v1(203.55,149.34) ; v1(187.55,127.34) 187.07,126.86 C1185.1 ; v1(202.55,127.34) 203.06,126.83 C1048.1 ; C964.1 195.07,132.86 v1(195.55,133.34) ; v1(186.55,143.34) 187.03,143.83 C2982.1 ; C2886.1 207.07,132.82 v1(206.55,133.34) ; C1237.1 199.07,149.83 v1(199.55,149.34) ; v1(194.55,145.34) 195.07,144.82 C1248.1 ; v1(206.55,144.34) 207.02,144.82 C927.1 ; C1242.1 206.03,136.82 v1(206.55,137.34) ; v1(196.55,150.34) 196.07,150.82 C1018.1 ; v1(205.55,141.34) 205.07,141.82 C1240.1 ; C1222.1 190.03,140.82 v1(190.55,141.34) ; C1177.1 189.02,149.82 v1(188.55,149.34) ; C1246.1 205.07,128.82 v1(204.55,129.34) ; v1(210.55,148.34) 211.02,148.82 C1261.1 ; C1258.1 211.56,151.34 v1(211.55,151.34) ; v2(146.37,113.54) v1(145.48,113.54) ; v1(192.55,136.34) 193.06,135.83 C972.1 ; v1(203.55,151.34) 204.03,151.82 C941.1 ; C989.1 191.06,137.83 v1(190.55,138.34) ; v1(195.55,137.34) 195.07,136.86 C995.1 ; v1(200.55,135.34) 201.06,134.83 C2930.1 ; v1(198.55,144.34) 199.03,144.83 C3126.1 ; C946.1 201.06,133.85 v1(201.55,134.34) ; v1(199.55,147.34) 199.07,147.83 C926.1 ; C934.1 203.06,133.85 v1(203.55,134.34) ; v1(205.55,143.34) 205.07,143.82 C3025.1 ; v1(210.55,135.34) 211.02,135.82 C1209.1 ; C1236.1 195.07,146.82 v1(195.55,146.34) ; v1(185.55,135.34) 185.07,134.86 C978.1 ; v1(211.55,147.34) 212.02,147.82 C1262.1 ; C2802.1 205.07,145.82 v1(205.55,145.34) ; v1(193.55,140.34) 193.07,139.86 C1255.1 ; C925.1 203.07,141.83 v1(203.55,141.34) ; v1(185.55,133.34) 185.07,132.86 C1175.1 ; C1207.1 211.07,137.86 v1(211.55,138.34) ; C2936.1 199.06,129.85 v1(199.55,130.34) ; v1(193.55,129.34) 193.07,128.86 C1154.1 ; C1047.1 202.03,151.82 v1(201.55,151.34) ; C1191.1 195.06,127.83 v1(194.55,128.34) ; C1152.1 187.06,146.83 v1(186.55,147.34) ; v1(193.55,150.34) 193.54,150.34 C1029.1 ; v1(206.55,146.34) 207.02,146.82 C2837.1 ; v1(192.55,130.34) 193.06,129.83 C3146.1 ; C948.1 201.06,131.85 v1(201.55,132.34) ; v1(186.55,128.34) 187.06,127.83 C1150.1 ; v1(184.55,130.34) 185.06,129.83 C1184.1 ; v1(184.55,147.34) 185.03,147.83 C1033.1 ; C1016.1 193.07,145.86 v1(193.55,146.34) ; v1(200.55,148.34) 201.03,148.83 C939.1 ; v1(188.55,151.34) 188.07,151.83 C1038.1 ; C977.1 193.07,141.86 v1(193.55,142.34) ; C1254.1 185.03,143.83 v1(184.55,143.34) ; v1(192.55,132.34) 193.06,131.83 C2965.1 ; v1(205.55,132.34) 205.07,131.86 C1244.1 ; v1(209.55,128.34) 209.07,127.86 C2998.1 ; v1(187.55,148.34) 187.06,147.85 C1035.1 ; v1(189.55,133.34) 189.07,132.86 C979.1 ; v1(201.55,145.34) 202.03,145.82 C2724.1 ; v1(193.55,133.34) 193.07,132.86 C969.1 ; C2888.1 207.07,137.86 v1(207.55,138.34) ; v1(209.55,143.34) 209.07,143.82 C1202.1 ; v1(196.55,143.34) 196.03,142.82 C1253.1 ; C1158.1 189.07,148.82 v1(189.55,148.34) ; v1(187.55,144.34) 187.07,144.83 C1041.1 ; v1(183.55,140.34) 183.07,140.83 C1008.1 ; v1(188.55,145.34) 189.02,145.82 C1178.1 ; v1(196.55,145.34) 196.07,145.82 C1247.1 ; v1(209.55,134.34) 209.07,133.86 C1257.1 ; C2879.1 209.07,151.82 v1(209.55,151.34) ; v1(184.55,141.34) 184.07,141.83 C1006.1 ; v1(185.55,144.34) 185.07,144.83 C1146.1 ; v1(183.55,133.34) 183.07,133.82 C961.1 ; C931.1 205.02,140.82 v1(204.55,140.34) ; v1(200.55,129.34) 201.06,128.83 C1046.1 ; v1(202.55,142.34) 203.03,142.83 C1230.1 ; v1(190.55,132.34) 191.06,131.83 C1181.1 ; C1216.1 212.02,128.82 v1(211.55,128.34) ; C944.1 198.05,136.84 v1(198.55,137.34) ; C1215.1 211.02,129.82 v1(210.55,129.34) ; C2913.1 207.07,126.82 v1(206.55,127.34) ; C2920.1 200.03,150.86 v1(199.55,151.34) 200.03,151.82 C945.1 ; v1(184.55,134.34) 185.06,133.83 C3110.1 ; C1208.1 212.02,136.82 v1(211.55,136.34) ; v1(185.55,129.34) 185.07,128.86 C1169.1 ; C2828.1 207.07,130.82 v1(206.55,131.34) ; v1(204.55,137.34) 204.03,136.83 C1241.1 ; C2800.1 199.06,134.83 v1(198.55,135.34) ; v1(203.55,132.34) 203.06,131.85 C3157.1 ; C1218.1 209.07,130.82 v1(208.55,131.34) ; C929.1 199.06,133.85 v1(199.55,134.34) ; C1024.1 191.02,149.82 v1(190.55,149.34) ; C885.1 207.02,150.82 v1(206.55,150.34) ; C1198.1 209.07,147.82 v1(209.55,147.34) ; C988.1 191.06,133.83 v1(190.55,134.34) ; v1(200.55,131.34) 201.06,130.83 C3181.1 ; v1(204.55,144.34) 205.02,144.82 C2700.1 ; C1007.1 185.07,140.83 v1(185.55,140.34)
  vias: v1(143.98,147.7) v1(144.31,130.17) v1(144.51,145.29) v1(144.59,139.32) v1(144.59,124.46) v1(144.62,133.45) v1(144.95,130.81) v1(145.22,139.95) v1(145.22,122.17) v1(145.22,121.28) v1(145.22,120.27) v1(145.22,119.38) v1(145.48,170.43) v1(145.48,167.51) v1(145.48,164.51) v1(145.48,161.49) v1(145.48,158.37) v1(145.48,149.22) v1(145.48,146.25) v1(145.48,143.28) v1(145.48,128.39) v1(145.48,116.28) v1(145.48,115.31) v1(145.48,111.71) v1(145.48,110.74) v1(145.48,109.73) v1(145.48,108.71) v1(145.48,107.19) v1(145.61,125.52) v1(145.61,104.26) v1(145.61,103.38) v1(145.61,100.45) v1(145.86,140.59) v1(146.06,162.18) v1(146.11,171.07) v1(146.11,168.15) v1(146.11,165.15) v1(146.11,149.86) v1(146.11,143.91) v1(146.11,129.03) v1(146.39,156.33) v1(146.49,141.22) v1(147.03,156.97) v1(154.37,101.47) v1(154.5,100.33) v1(155.38,107.62) v1(155.38,104.14) v1(155.38,101.47) v1(155.38,100.33) v1(155.38,99.06) v1(156.27,113.28) v1(156.91,113.92) v1(157.54,114.55) v1(157.92,100.33) v1(157.92,99.44) v1(163,101.98) v1(163,100.84) v1(203.01,185.09) v1(205.3,185.09) v1(205.3,184.2) v1(207.58,185.09) v1(207.58,184.2) v1(208.34,101.09) v1(208.34,100.2) v1(208.34,99.31) v1(208.34,98.42) v1(208.34,97.53) v1(208.34,96.64) v1(209.66,185.09) v1(216.8,189.9) v1(217.69,189.9) v1(219.09,189.9) v1(219.39,181.58) v1(219.98,189.9) v1(221.37,189.9) v1(222.26,189.9) v1(222.31,181.58) v1(223.2,181.58) v1(223.66,189.9) v1(224.09,181.58) v1(224.55,189.9) v1(224.98,181.58) v1(225.87,181.58) v1(225.95,189.9) v1(226.76,181.58) v1(226.83,189.9) v1(227.9,181.58) v1(228.23,189.9) v1(228.92,181.58) v1(229.12,189.9) v1(230.06,181.58) v1(230.26,189.9) v1(231.08,181.58) v1(231.15,189.9) v1(245.68,119.12) v1(245.68,117.85) v1(245.68,116.58) v1(245.68,115.31) v1(246.32,118.49) v1(246.32,117.22) v1(246.32,115.95) v1(246.32,114.68) v1(254.44,166.49) v1(254.57,136.14) v1(254.57,133.09) v1(254.57,130.05) v1(254.57,128.78) v1(254.57,122.68) v1(254.57,119.63) v1(254.57,116.58) v1(254.57,113.54) v1(255.21,165.73) v1(255.21,162.68) v1(255.21,159.64) v1(255.21,158.37) v1(255.21,155.32) v1(255.21,153.67) v1(255.21,150.62) v1(255.21,147.7) v1(255.21,144.65) v1(255.21,141.6) v1(255.21,138.55) v1(255.21,135.51) v1(255.21,132.46) v1(255.21,129.41) v1(255.21,128.14) v1(255.21,125.09) v1(255.21,122.04) v1(255.21,119) v1(255.21,115.95) v2(95.06,133.47) v2(319.47,137.79) v3(88.58,128.52) v3(89.85,190.24) v3(89.85,187.7) v3(89.85,180.08) v3(89.85,177.54) v3(89.85,169.92) v3(89.85,167.38) v3(89.85,159.76) v3(89.85,157.22) v3(89.85,149.6) v3(89.85,147.06) v3(89.85,131.06) v3(89.85,129.79) v3(89.85,128.52) v3(91.12,191.51) v3(91.12,188.97) v3(91.12,186.43) v3(91.12,181.35) v3(91.12,178.81) v3(91.12,176.27) v3(91.12,171.19) v3(91.12,168.65) v3(91.12,166.11) v3(91.12,161.03) v3(91.12,158.49) v3(91.12,155.95) v3(91.12,150.87) v3(91.12,148.33) v3(91.12,145.79) v3(91.12,140.71) v3(91.12,138.17) v3(91.12,135.63) v3(91.12,131.06) v3(91.12,129.79) v3(92.39,190.24) v3(92.39,187.7) v3(92.39,180.08) v3(92.39,177.54) v3(92.39,169.92) v3(92.39,167.38) v3(92.39,159.76) v3(92.39,157.22) v3(92.39,149.6) v3(92.39,147.06) v3(92.39,139.44) v3(92.39,136.9) v3(93.66,191.51) v3(93.66,188.97) v3(93.66,186.43) v3(93.66,181.35) v3(93.66,178.81) v3(93.66,176.27) v3(93.66,171.19) v3(93.66,168.65) v3(93.66,166.11) v3(93.66,161.03) v3(93.66,158.49) v3(93.66,155.95) v3(93.66,150.87) v3(93.66,148.33) v3(93.66,145.79) v3(93.66,140.71) v3(93.66,138.17) v3(93.66,135.63) v3(94.93,190.24) v3(94.93,187.7) v3(94.93,185.16) v3(94.93,182.62) v3(94.93,180.08) v3(94.93,177.54) v3(94.93,175) v3(94.93,172.46) v3(94.93,169.92) v3(94.93,167.38) v3(94.93,164.84) v3(94.93,162.3) v3(94.93,159.76) v3(94.93,157.22) v3(94.93,154.68) v3(94.93,152.14) v3(94.93,149.6) v3(94.93,147.06) v3(94.93,144.52) v3(94.93,141.98) v3(94.93,139.44) v3(94.93,136.9) v3(96.2,191.51) v3(96.2,188.97) v3(96.2,186.43) v3(96.2,183.89) v3(96.2,181.35) v3(96.2,178.81) v3(96.2,176.27) v3(96.2,173.73) v3(96.2,171.19) v3(96.2,168.65) v3(96.2,166.11) v3(96.2,163.57) v3(96.2,161.03) v3(96.2,158.49) v3(96.2,155.95) v3(96.2,153.41) v3(96.2,150.87) v3(96.2,148.33) v3(96.2,145.79) v3(96.2,143.25) v3(96.2,140.71) v3(97.47,190.24) v3(97.47,187.7) v3(97.47,185.16) v3(97.47,182.62) v3(97.47,180.08) v3(97.47,177.54) v3(97.47,175) v3(97.47,172.46) v3(97.47,169.92) v3(97.47,167.38) v3(97.47,164.84) v3(97.47,162.3) v3(97.47,159.76) v3(97.47,157.22) v3(97.47,154.68) v3(97.47,152.14) v3(97.47,149.6) v3(97.47,147.06) v3(97.47,144.52) v3(97.47,141.98) v3(98.74,191.51) v3(98.74,188.97) v3(98.74,186.43) v3(98.74,183.89) v3(98.74,181.35) v3(98.74,178.81) v3(98.74,176.27) v3(98.74,173.73) v3(98.74,171.19) v3(98.74,168.65) v3(98.74,166.11) v3(98.74,163.57) v3(98.74,161.03) v3(98.74,158.49) v3(98.74,155.95) v3(98.74,153.41) v3(98.74,150.87) v3(98.74,148.33) v3(98.74,145.79) v3(98.74,143.25) v3(100.01,190.24) v3(100.01,187.7) v3(100.01,185.16) v3(100.01,182.62) v3(100.01,180.08) v3(100.01,177.54) v3(100.01,175) v3(100.01,172.46) v3(100.01,169.92) v3(100.01,167.38) v3(100.01,164.84) v3(100.01,162.3) v3(100.01,159.76) v3(100.01,157.22) v3(100.01,154.68) v3(100.01,152.14) v3(100.01,149.6) v3(100.01,147.06) v3(100.01,144.52) v3(101.28,191.51) v3(101.28,188.97) v3(101.28,186.43) v3(101.28,183.89) v3(101.28,181.35) v3(101.28,178.81) v3(101.28,176.27) v3(101.28,173.73) v3(101.28,171.19) v3(101.28,168.65) v3(101.28,166.11) v3(101.28,163.57) v3(101.28,161.03) v3(101.28,158.49) v3(101.28,155.95) v3(101.28,153.41) v3(101.28,150.87) v3(101.28,148.33) v3(101.28,145.79) v3(102.55,190.24) v3(102.55,187.7) v3(102.55,185.16) v3(102.55,182.62) v3(102.55,180.08) v3(102.55,177.54) v3(102.55,175) v3(102.55,172.46) v3(102.55,169.92) v3(102.55,167.38) v3(102.55,164.84) v3(102.55,162.3) v3(102.55,159.76) v3(102.55,157.22) v3(102.55,154.68) v3(102.55,152.14) v3(102.55,149.6) v3(102.55,147.06) v3(103.82,191.51) v3(103.82,188.97) v3(103.82,186.43) v3(103.82,183.89) v3(103.82,181.35) v3(103.82,178.81) v3(103.82,176.27) v3(103.82,173.73) v3(103.82,171.19) v3(103.82,168.65) v3(103.82,166.11) v3(103.82,163.57) v3(103.82,161.03) v3(103.82,158.49) v3(103.82,155.95) v3(103.82,153.41) v3(105.09,190.24) v3(105.09,187.7) v3(105.09,185.16) v3(105.09,182.62) v3(105.09,180.08) v3(105.09,177.54) v3(105.09,175) v3(105.09,172.46) v3(105.09,169.92) v3(105.09,167.38) v3(105.09,164.84) v3(105.09,162.3) v3(105.09,159.76) v3(105.09,157.22) v3(105.09,154.68) v3(106.36,191.51) v3(106.36,188.97) v3(106.36,186.43) v3(106.36,183.89) v3(106.36,181.35) v3(106.36,178.81) v3(106.36,176.27) v3(106.36,173.73) v3(106.36,171.19) v3(106.36,168.65) v3(106.36,166.11) v3(106.36,163.57) v3(106.36,161.03) v3(106.36,158.49) v3(106.36,155.95) v3(106.36,153.41) v3(107.63,190.24) v3(107.63,187.7) v3(107.63,185.16) v3(107.63,182.62) v3(107.63,180.08) v3(107.63,177.54) v3(107.63,175) v3(107.63,172.46) v3(107.63,169.92) v3(107.63,167.38) v3(107.63,164.84) v3(107.63,162.3) v3(107.63,159.76) v3(107.63,157.22) v3(107.63,154.68) v3(288.1,163.95) v3(288.1,161.41) v3(288.1,158.87) v3(288.1,156.33) v3(289.37,165.22) v3(289.37,162.68) v3(289.37,160.14) v3(289.37,157.6) v3(289.37,155.06) v3(290.64,163.95) v3(290.64,161.41) v3(290.64,158.87) v3(290.64,156.33) v3(290.64,153.79) v3(291.91,165.22) v3(291.91,162.68) v3(291.91,160.14) v3(291.91,157.6) v3(291.91,155.06) v3(293.18,163.95) v3(293.18,161.41) v3(293.18,158.87) v3(293.18,156.33) v3(293.18,153.79) v3(294.45,165.22) v3(294.45,162.68) v3(294.45,160.14) v3(294.45,157.6) v3(294.45,155.06) v3(294.45,152.52) v3(295.72,163.95) v3(295.72,161.41) v3(295.72,158.87) v3(295.72,156.33) v3(295.72,153.79) v3(296.99,165.22) v3(296.99,162.68) v3(296.99,160.14) v3(296.99,157.6) v3(296.99,155.06) v3(296.99,152.52) v3(298.26,163.95) v3(298.26,161.41) v3(298.26,158.87) v3(298.26,156.33) v3(298.26,153.79) v3(299.53,165.22) v3(299.53,162.68) v3(299.53,160.14) v3(299.53,157.6) v3(299.53,155.06) v3(299.53,152.52) v3(300.8,163.95) v3(300.8,161.41) v3(300.8,158.87) v3(300.8,156.33) v3(302.07,165.22) v3(302.07,162.68) v3(302.07,160.14) v3(302.07,157.6) v3(303.34,163.95) v3(303.34,161.41) v3(303.34,158.87) v3(304.61,165.22) v3(304.61,162.68) v3(304.61,160.14) v3(305.88,163.95) v3(305.88,161.41) v3(305.88,158.87) v3(307.15,165.22) v3(307.15,162.68) v3(307.15,160.14) v3(308.42,163.95) v3(308.42,161.41) v3(308.42,158.87) v3(309.69,165.22) v3(309.69,162.68) v3(309.69,160.14) v3(309.69,157.6) v3(310.96,163.95) v3(310.96,161.41) v3(310.96,158.87) v3(310.96,156.33) v3(312.23,165.22) v3(312.23,162.68) v3(312.23,160.14) v3(312.23,157.6) v3(312.23,155.06) v3(312.23,152.52) v3(312.23,149.98) v3(312.23,147.44) v3(313.5,163.95) v3(313.5,161.41) v3(313.5,158.87) v3(313.5,156.33) v3(313.5,153.79) v3(313.5,151.25) v3(313.5,148.71) v3(313.5,146.17) v3(314.77,165.22) v3(314.77,162.68) v3(314.77,160.14) v3(314.77,157.6) v3(314.77,155.06) v3(314.77,152.52) v3(314.77,149.98) v3(314.77,147.44) v3(314.77,144.9) v3(316.04,163.95) v3(316.04,161.41) v3(316.04,158.87) v3(316.04,156.33) v3(316.04,153.79) v3(316.04,151.25) v3(316.04,148.71) v3(316.04,146.17) v3(316.04,143.63) v3(317.31,165.22) v3(317.31,162.68) v3(317.31,160.14) v3(317.31,157.6) v3(317.31,155.06) v3(317.31,152.52) v3(317.31,149.98) v3(317.31,147.44) v3(317.31,144.9) v3(317.31,142.36) v3(318.58,163.95) v3(318.58,161.41) v3(318.58,158.87) v3(318.58,156.33) v3(318.58,153.79) v3(318.58,151.25) v3(318.58,148.71) v3(318.58,146.17) v3(318.58,143.63) v3(318.58,141.09) v3(319.85,165.22) v3(319.85,162.68) v3(319.85,160.14) v3(319.85,157.6) v3(319.85,155.06) v3(319.85,152.52) v3(319.85,149.98) v3(319.85,147.44) v3(319.85,144.9) v3(319.85,142.36) v3(319.85,139.82) v3(321.12,163.95) v3(321.12,161.41) v3(321.12,158.87) v3(321.12,156.33) v3(321.12,153.79) v3(321.12,151.25) v3(321.12,148.71) v3(321.12,146.17) v3(321.12,143.63) v3(321.12,141.09) v3(321.12,138.55) v3(322.39,165.22) v3(322.39,160.14) v3(322.39,157.6) v3(322.39,149.98) v3(322.39,147.44) v3(322.39,139.82) v3(322.39,137.28) v3(323.66,158.87) v3(323.66,156.33) v3(323.66,148.71) v3(323.66,146.17) v3(323.66,138.55) v3(323.66,136.01) v3(324.93,165.22)
