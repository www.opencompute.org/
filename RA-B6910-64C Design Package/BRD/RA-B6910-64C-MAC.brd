# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC58_TDN0: length 197
  TOP w0.147: U1.CD1 230.1,169.84 arc(230.42,169.97) v4(230.55,170.29)
  SIG5 w0.112: v4(230.55,170.29) 230.83,170.01 arc(230.91,169.96) 231,169.94 231.7,169.94 231.79,170.03 231.81,170.03
  SIG5 w0.16: YJ35.A3 347.1,60.77 arc(347.15,61.01) 347.29,61.22 347.81,61.75 arc(347.88,61.85) 347.91,61.97 347.91,62.57 arc(347.91,62.6) 347.91,62.64 arc(347.91,62.64) 347.91,62.65 arc(347.96,62.76) 348.03,62.86 348.08,62.91 arc(348.21,63) 348.35,63.03 359.83,63.03 arc(360.12,63.08) 360.37,63.25 360.84,63.72 arc(361,63.96) 361.06,64.25 361.06,65.91 arc(360.97,66.35) 360.73,66.72 355.39,72.05 arc(355.31,72.18) 355.28,72.32 355.28,76.1 arc(355.2,76.54) 354.95,76.91 348.16,83.71 arc(348.07,83.83) 348.04,83.98 348.04,86.39 arc(347.96,86.83) 347.71,87.2 305.71,129.2 arc(305.34,129.45) 304.9,129.54 287.27,129.54 arc(287.13,129.57) 287,129.65 249.32,167.33 arc(248.95,167.58) 248.52,167.66 235.08,167.66 arc(234.79,167.72) 234.54,167.89 232.6,169.83 arc(232.37,169.98) 232.1,170.03 231.81,170.03
FC58_TDN1: length 199
  TOP w0.147: v4(225.55,167.39) 225.55,167.34 U1.CA6
  SIG4 w0.112: v4(225.55,167.39) 225.55,167.62 arc(225.59,167.71) 225.68,167.74 225.88,167.74 arc(225.99,167.77) 226.09,167.83 arc(226.16,167.93) 226.18,168.05 226.18,168.36 arc(226.21,168.51) 226.3,168.63 arc(226.42,168.72) 226.57,168.75 231.97,168.75 232.06,168.65 232.09,168.65
  SIG4 w0.16: YJ35.A5 348.55,61.97 arc(348.44,62.13) 348.41,62.32 348.41,62.54 arc(348.5,62.77) 348.72,62.86 349.58,62.86 arc(349.87,62.92) 350.12,63.08 350.16,63.13 350.21,63.18 arc(350.46,63.35) 350.75,63.41 359.88,63.41 arc(360.03,63.44) 360.15,63.52 360.57,63.93 arc(360.65,64.06) 360.68,64.2 360.68,66.47 arc(360.65,66.61) 360.57,66.74 360.21,67.09 359.85,67.09 359.49,67.45 359.49,67.81 359.08,68.22 358.72,68.22 358.36,68.58 358.36,68.94 358,69.3 357.64,69.3 357.28,69.66 357.28,70.02 356.92,70.38 356.59,70.38 356.2,70.77 356.2,71.1 355.76,71.54 arc(355.59,71.79) 355.54,72.08 355.54,78.52 arc(355.48,78.81) 355.31,79.06 308.33,126.04 arc(302.49,129.94) 295.59,131.32 294.81,131.32 arc(285.58,133.15) 277.76,138.38 246.89,169.25 arc(246.76,169.34) 246.62,169.36 234.14,169.36 arc(234.06,169.36) 233.99,169.34 arc(233.93,169.3) 233.87,169.25 233.6,168.99 arc(233.23,168.74) 232.79,168.65 232.09,168.65
FC58_TDN2: length 175.3
  TOP w0.147: v4(227.55,168.29) 227.55,168.21 arc(227.53,168.13) 227.49,168.06 227.41,167.98 arc(227.26,167.88) 227.07,167.84 U1.CB4
  SIG4 w0.112: 232.09,167.03 232.06,167.03 231.97,166.94 228.57,166.94 arc(228.42,166.97) 228.3,167.05 arc(228.21,167.18) 228.18,167.32 228.18,167.63 arc(228.16,167.75) 228.09,167.85 arc(227.99,167.92) 227.88,167.94 227.68,167.94 arc(227.59,167.98) 227.55,168.07 v4(227.55,168.29)
  SIG4 w0.155: 350.31,65.97 arc(350.29,65.88) 350.25,65.8
  SIG4 w0.16: 232.09,167.03 233.87,167.03 233.87,167.03 245.02,167.03 arc(245.31,166.97) 245.56,166.8 274.42,137.94 arc(283.73,131.72) 294.7,129.54 295.21,129.54 arc(301.78,128.23) 307.35,124.51 347.99,83.87 arc(348.15,83.63) 348.21,83.33 348.21,70.95 arc(348.27,70.66) 348.43,70.41 350.08,68.76 arc(350.25,68.52) 350.31,68.22 350.31,65.97 ; YJ35.A33 349.5,64.8 arc(349.54,65.02) 349.66,65.2 350.15,65.68 arc(350.2,65.74) 350.25,65.8
FC58_TDN3: length 174.3
  TOP w0.147: U1.CA2 229.55,167.34 v4(229.55,167.39)
  SIG5 w0.112: v4(229.55,167.39) 229.83,167.67 arc(229.91,167.72) 230,167.74 230.82,167.74 230.91,167.65 230.94,167.65
  SIG5 w0.16: 230.94,167.65 231.26,167.65 arc(231.55,167.59) 231.79,167.43 233.8,165.42 arc(234.05,165.26) 234.34,165.2 235.1,165.2 235.23,165.07 235.99,165.07 236.12,165.2 236.88,165.2 237.01,165.07 237.77,165.07 237.89,165.2 238.66,165.2 238.78,165.07 239.55,165.07 239.67,165.2 240.43,165.2 240.56,165.07 241.32,165.07 241.45,165.2 242.21,165.2 242.34,165.07 243.1,165.07 243.23,165.2 246.28,165.2 arc(246.57,165.14) 246.82,164.98 284.57,127.22 arc(284.82,127.06) 285.11,127 304.04,127 arc(304.33,126.94) 304.58,126.77 336.14,95.22 arc(336.3,94.97) 336.36,94.68 336.36,78.29 arc(336.45,77.85) 336.69,77.48 340.86,73.32 340.86,73.14 341.4,72.6 341.58,72.6 342.12,72.06 342.12,71.86 342.63,71.34 342.83,71.34 343.37,70.8 343.37,70.6 343.89,70.09 344.09,70.09 344.63,69.55 arc(345,69.3) 345.44,69.21 346.08,69.21 arc(346.22,69.18) 346.35,69.1 347.41,68.03 arc(347.5,67.91) 347.53,67.76 347.53,67.05 arc(347.47,66.92) 347.33,66.86 346.28,66.86 arc(346.09,66.78) 346.01,66.59 346.01,66.32 arc(346.04,66.13) 346.15,65.97 YJ35.A37
FC58_TDP0: length 197
  TOP w0.147: v4(230.55,169.39) 230.55,169.34 U1.CC1
  SIG5 w0.112: 231.81,169.65 231.79,169.65 231.7,169.74 231,169.74 arc(230.91,169.72) 230.83,169.67 v4(230.55,169.39)
  SIG5 w0.16: 231.81,169.65 232.1,169.65 arc(232.23,169.63) 232.33,169.56 234.27,167.62 arc(234.64,167.37) 235.08,167.28 248.52,167.28 arc(248.81,167.22) 249.05,167.06 249.59,166.52 249.59,166.34 250.13,165.8 250.31,165.8 250.85,165.26 250.85,165.08 251.39,164.54 251.57,164.54 252.11,164.01 252.11,163.85 252.67,163.29 252.83,163.29 253.37,162.75 253.37,162.59 253.93,162.03 254.08,162.03 286.73,129.38 arc(286.98,129.21) 287.27,129.16 304.9,129.16 arc(305.19,129.1) 305.44,128.93 347.44,86.93 arc(347.6,86.68) 347.66,86.39 347.66,83.98 arc(347.72,83.68) 347.89,83.44 353.42,77.9 353.42,77.72 353.96,77.18 354.14,77.18 354.68,76.64 arc(354.84,76.4) 354.9,76.1 354.9,72.32 arc(354.96,72.03) 355.13,71.78 356.28,70.63 356.28,70.45 356.82,69.91 357,69.91 357.54,69.37 357.54,69.19 358.08,68.65 358.26,68.65 358.8,68.11 358.8,67.93 359.34,67.39 359.52,67.39 360.46,66.45 arc(360.62,66.21) 360.68,65.91 360.68,64.25 arc(360.65,64.11) 360.57,63.99 360.1,63.52 arc(359.98,63.44) 359.83,63.41 348.35,63.41 arc(348.06,63.35) 347.81,63.18 arc(347.46,62.95) 347.04,62.86 346.28,62.86 arc(346.09,62.78) 346.01,62.59 346.01,62.32 arc(346.04,62.13) 346.15,61.97 YJ35.A2
FC58_TDP1: length 199
  TOP w0.147: v4(225.55,168.29) 225.55,168.21 arc(225.53,168.13) 225.49,168.06 225.41,167.98 arc(225.26,167.88) 225.07,167.84 U1.CB6
  SIG4 w0.112: 232.09,169.03 232.06,169.03 231.97,168.94 226.57,168.94 arc(226.35,168.9) 226.16,168.77 arc(226.03,168.58) 225.99,168.36 225.99,168.05 arc(225.98,168.01) 225.95,167.97 arc(225.92,167.95) 225.88,167.94 225.68,167.94 arc(225.59,167.98) 225.55,168.07 v4(225.55,168.29)
  SIG4 w0.155: 350.31,61.97 arc(350.3,61.91) 350.28,61.84
  SIG4 w0.16: 232.09,169.03 232.79,169.03 arc(233.09,169.09) 233.33,169.26 233.6,169.52 arc(233.71,169.62) 233.85,169.69 arc(233.99,169.73) 234.14,169.75 246.62,169.75 arc(246.91,169.69) 247.16,169.52 278.03,138.65 arc(285.73,133.5) 294.81,131.7 295.59,131.7 arc(302.63,130.3) 308.6,126.31 355.58,79.33 arc(355.83,78.96) 355.92,78.52 355.92,72.08 arc(355.95,71.94) 356.03,71.81 360.84,67.01 arc(361,66.76) 361.06,66.47 361.06,64.2 arc(361,63.91) 360.84,63.67 360.42,63.25 arc(360.17,63.08) 359.88,63.03 350.75,63.03 arc(350.61,63) 350.48,62.91 350.43,62.86 arc(350.34,62.72) 350.31,62.57 350.31,61.97 ; YJ35.A6 349.5,60.83 arc(349.54,61.02) 349.64,61.18 350.19,61.72 arc(350.24,61.78) 350.28,61.84
FC58_TDP2: length 175.3
  TOP w0.147: U1.CA4 227.55,167.34 v4(227.55,167.39)
  SIG4 w0.112: v4(227.55,167.39) 227.55,167.62 arc(227.59,167.71) 227.68,167.74 227.88,167.74 arc(227.92,167.73) 227.95,167.71 arc(227.98,167.68) 227.99,167.63 227.99,167.32 arc(228.03,167.1) 228.16,166.91 arc(228.35,166.78) 228.57,166.74 231.98,166.74 232.08,166.65 232.09,166.65
  SIG4 w0.16: 232.09,166.65 233.71,166.65 233.71,166.65 245.02,166.65 arc(245.16,166.62) 245.29,166.54 274.15,137.67 arc(283.58,131.37) 294.7,129.16 295.21,129.16 arc(301.64,127.88) 307.08,124.24 347.72,83.6 arc(347.8,83.48) 347.83,83.33 347.83,77.05 347.58,76.79 347.58,76.28 347.83,76.03 347.83,75.52 347.6,75.29 347.6,74.74 347.83,74.51 347.83,74 347.6,73.77 347.6,73.21 347.83,72.98 347.83,72.47 347.64,72.28 347.64,71.65 347.83,71.46 347.83,70.95 arc(347.92,70.51) 348.16,70.14 348.74,69.57 348.74,69.31 349.19,68.85 349.45,68.85 349.81,68.49 arc(349.9,68.37) 349.93,68.22 349.93,67.09 arc(349.86,66.93) 349.69,66.86 348.71,66.86 arc(348.5,66.77) 348.41,66.56 348.41,66.32 arc(348.44,66.13) 348.55,65.97 YJ35.A34
FC58_TDP3: length 174.3
  TOP w0.147: U1.CB2 229.1,167.84 arc(229.42,167.97) v4(229.55,168.29)
  SIG5 w0.112: 230.94,168.03 230.91,168.03 230.82,167.94 230,167.94 arc(229.91,167.96) 229.83,168.01 v4(229.55,168.29)
  SIG5 w0.16: 230.94,168.03 231.26,168.03 arc(231.69,167.95) 232.06,167.7 234.07,165.69 arc(234.19,165.61) 234.34,165.58 246.28,165.58 arc(246.72,165.49) 247.09,165.25 284.84,127.49 arc(284.97,127.41) 285.11,127.38 304.04,127.38 arc(304.48,127.29) 304.85,127.04 336.41,95.49 arc(336.65,95.12) 336.74,94.68 336.74,78.29 336.74,78.29 arc(336.8,78) 336.96,77.75 344.9,69.82 arc(345.15,69.65) 345.44,69.59 346.08,69.59 arc(346.37,69.54) 346.62,69.37 347.68,68.3 arc(347.85,68.06) 347.91,67.76 347.91,65.97 arc(347.88,65.85) 347.81,65.75 347.25,65.18 arc(347.14,65.02) 347.1,64.82 YJ35.A36
FC59_RDN0: length 222.8
  TOP w0.147: U1.CE14 217.05,170.86 arc(217.09,171.04) 217.19,171.2 217.27,171.28 arc(217.34,171.33) 217.41,171.34 v4(217.5,171.34)
  SIG3 w0.112: v4(217.5,171.34) 217.37,171.47 arc(217.21,171.72) 217.15,172.01 217.15,172.72 217.24,172.81 217.24,172.84
  SIG3 w0.16: YJ35.B17 358.15,53.97 arc(358.04,54.13) 358.01,54.32 358.01,54.53 arc(358.1,54.77) 358.33,54.86 359.3,54.86 arc(359.48,54.9) 359.63,55 359.93,55.3 360.08,55.45 360.08,55.84 360.33,56.08 360.71,56.08 360.98,56.35 360.98,56.74 361.22,56.98 361.61,56.98 361.88,57.25 361.88,57.63 362.12,57.88 362.51,57.88 362.84,58.21 arc(363.2,58.75) 363.33,59.38 363.33,65.39 arc(363.39,65.68) 363.55,65.93 365.16,67.54 arc(365.33,67.79) 365.39,68.08 365.39,74.11 arc(365.36,74.26) 365.27,74.38 364.63,75.02 arc(364.39,75.39) 364.3,75.83 364.3,76.26 arc(364.27,76.41) 364.19,76.53 303.04,137.68 arc(302.92,137.76) 302.77,137.79 284.89,137.79 arc(284.45,137.88) 284.08,138.13 248.79,173.42 arc(248.67,173.5) 248.52,173.53 238.2,173.53 arc(237.76,173.62) 237.39,173.87 233.11,178.14 arc(232.99,178.23) 232.84,178.25 221.08,178.25 arc(220.93,178.23) 220.81,178.14 220.46,177.79 220.46,177.38 220.16,177.09 219.75,177.09 219.44,176.78 219.44,176.37 219.1,176.02 218.69,176.02 218.38,175.71 218.38,175.3 218.03,174.95 217.62,174.95 217.35,174.68 arc(217.27,174.56) 217.24,174.41 217.24,172.84
FC59_RDN1: length 210
  TOP w0.147: U1.CE12 219.55,171.34 v4(219.6,171.34)
  SIG3 w0.112: 219.86,172.84 219.86,172.81 219.95,172.72 219.95,172.01 arc(219.89,171.72) 219.73,171.47 v4(219.6,171.34)
  SIG3 w0.16: YJ35.B21 359.1,56.81 arc(359.14,57.02) 359.26,57.19 359.74,57.67 arc(359.86,57.86) 359.91,58.08 359.91,58.57 arc(359.91,58.63) 359.93,58.7 arc(359.97,58.78) 360.03,58.86 360.08,58.91 arc(360.1,58.93) 360.11,58.94 360.11,58.94 361.79,60.62 arc(362.23,61.27) 362.38,62.04 362.38,65.79 arc(362.44,66.08) 362.6,66.33 363.38,67.11 arc(363.55,67.36) 363.61,67.65 363.61,73.3 arc(363.55,73.59) 363.38,73.84 362.75,74.48 arc(362.58,74.72) 362.52,75.01 362.52,75.28 arc(362.46,75.57) 362.3,75.82 302.32,135.79 arc(302.08,135.96) 301.79,136.01 284,136.01 arc(283.71,136.07) 283.46,136.24 248.1,171.61 arc(247.85,171.77) 247.56,171.83 237.36,171.83 arc(237.07,171.89) 236.82,172.05 232.57,176.3 arc(232.32,176.47) 232.03,176.53 222.83,176.53 arc(222.4,176.44) 222.02,176.19 220.19,174.36 arc(219.95,173.99) 219.86,173.55 219.86,172.84
FC59_RDN2: length 225.4
  TOP w0.147: v4(217.5,169.34) 217.42,169.34 arc(217.35,169.33) 217.29,169.29 217.12,169.12 arc(217.07,169.04) 217.05,168.94 U1.CC14
  SIG2 w0.112: v4(217.5,169.34) 217.27,169.34 arc(217.18,169.38) 217.15,169.47 217.15,169.62 arc(217.16,169.68) 217.19,169.73 arc(217.24,169.77) 217.3,169.78 217.68,169.78 arc(217.86,169.81) 218.01,169.92 arc(218.11,170.07) 218.15,170.25 218.15,172.72 218.24,172.81 218.24,172.84
  SIG2 w0.16: 218.24,172.84 218.24,173.09 218.5,173.34 218.5,173.86 218.24,174.11 218.24,175.74 arc(218.27,175.9) 218.36,176.03 arc(218.49,176.12) 218.65,176.15 219.15,176.15 219.41,175.89 219.92,175.89 220.17,176.15 220.68,176.15 220.91,175.92 221.46,175.92 221.69,176.15 222.2,176.15 222.43,175.92 222.99,175.92 223.22,176.15 228.98,176.15 arc(229.27,176.09) 229.52,175.92 231.69,173.75 arc(231.94,173.59) 232.23,173.53 248.36,173.53 arc(248.65,173.47) 248.9,173.31 284.19,138.02 arc(284.44,137.85) 284.73,137.79 302.62,137.79 arc(302.91,137.73) 303.16,137.57 364.05,76.67 arc(364.22,76.43) 364.27,76.14 364.27,66.89 arc(364.25,66.74) 364.16,66.62 363.68,66.13 arc(363.43,65.76) 363.34,65.32 363.34,60.37 363.09,60.12 363.09,59.61 363.34,59.35 363.34,58.85 arc(363.28,58.56) 363.12,58.31 362.59,57.79 362.24,57.79 361.88,57.43 361.88,57.07 361.52,56.71 361.16,56.71 360.8,56.35 360.8,55.99 360.44,55.63 arc(360.19,55.46) 359.9,55.41 357.95,55.41 arc(357.77,55.38) 357.6,55.32 arc(357.5,55.26) 357.41,55.18 357.36,55.13 357.32,55.08 arc(357.07,54.92) 356.78,54.86 355.93,54.86 arc(355.7,54.77) 355.61,54.53 355.61,54.32 arc(355.64,54.13) 355.75,53.97 YJ35.B14
FC59_RDN3: length 211.6
  TOP w0.147: v4(219.6,169.34) 219.55,169.34 U1.CC12
  SIG2 w0.112: v4(219.6,169.34) 219.82,169.34 arc(219.91,169.38) 219.95,169.47 219.95,169.62 arc(219.98,169.76) 220.05,169.87 arc(220.17,169.95) 220.3,169.98 220.68,169.98 arc(220.78,170) 220.87,170.06 arc(220.93,170.15) 220.95,170.25 220.95,172.72 220.86,172.81 220.86,172.84
  SIG2 w0.16: 220.86,172.84 220.86,173.28 arc(221.14,173.96) 221.83,174.24 227.97,174.24 arc(228.4,174.15) 228.78,173.91 230.74,171.94 arc(230.87,171.86) 231.01,171.83 247.4,171.83 arc(247.84,171.74) 248.21,171.49 283.57,136.13 arc(283.7,136.04) 283.84,136.01 301.63,136.01 arc(302.06,135.93) 302.44,135.68 362.24,75.88 arc(362.49,75.51) 362.57,75.07 362.57,66.58 arc(362.56,66.52) 362.53,66.47 362.47,66.41 arc(362.4,66.3) 362.38,66.18 362.38,61.44 arc(362.29,61) 362.04,60.63 360.77,59.36 arc(360.4,59.11) 359.96,59.03 357.95,59.03 arc(357.86,59.01) 357.78,58.98 arc(357.73,58.95) 357.68,58.91 357.63,58.86 arc(357.54,58.72) 357.51,58.57 357.51,58.08 arc(357.46,57.86) 357.34,57.67 356.91,57.24 arc(356.75,57.01) 356.7,56.74 YJ35.B24
FC59_RDP0: length 222.8
  TOP w0.147: U1.CE15 216.55,171.34 v4(216.6,171.34)
  SIG3 w0.112: v4(216.6,171.34) 216.73,171.47 arc(216.89,171.72) 216.95,172.01 216.95,172.72 216.86,172.81 216.86,172.84
  SIG3 w0.16: YJ35.B18 359.1,52.75 arc(359.15,53.01) 359.3,53.23 359.74,53.67 arc(359.86,53.86) 359.91,54.08 359.91,54.57 arc(359.91,54.61) 359.92,54.66 arc(359.96,54.77) 360.03,54.86 360.07,54.9 363.11,57.95 arc(363.55,58.6) 363.71,59.38 363.71,65.39 arc(363.74,65.54) 363.82,65.66 365.43,67.27 arc(365.68,67.64) 365.77,68.08 365.77,74.11 arc(365.71,74.4) 365.54,74.65 364.9,75.29 arc(364.74,75.54) 364.68,75.83 364.68,76.26 arc(364.62,76.55) 364.46,76.8 303.31,137.95 arc(303.06,138.12) 302.77,138.17 284.89,138.17 arc(284.6,138.23) 284.35,138.4 249.06,173.69 arc(248.81,173.85) 248.52,173.91 238.2,173.91 arc(237.91,173.97) 237.66,174.13 233.38,178.41 arc(233.14,178.58) 232.84,178.64 221.08,178.64 arc(220.79,178.58) 220.54,178.41 217.08,174.95 arc(216.92,174.71) 216.86,174.41 216.86,172.84
FC59_RDP1: length 210
  TOP w0.147: U1.CE11 220.05,170.91 arc(220.08,171.07) 220.18,171.21 220.23,171.27 arc(220.31,171.32) 220.4,171.34 v4(220.5,171.34)
  SIG3 w0.112: 220.24,172.84 220.24,172.81 220.15,172.72 220.15,172.01 arc(220.21,171.72) 220.37,171.47 v4(220.5,171.34)
  SIG3 w0.16: 220.24,172.84 220.24,173.55 arc(220.3,173.84) 220.46,174.09 220.73,174.36 221.09,174.36 221.36,174.63 221.36,174.99 222.29,175.92 arc(222.54,176.09) 222.83,176.15 232.03,176.15 arc(232.18,176.12) 232.3,176.03 232.57,175.77 232.57,175.43 232.86,175.14 233.2,175.14 233.47,174.87 233.47,174.53 233.76,174.24 234.1,174.24 234.37,173.97 234.37,173.64 234.66,173.34 234.99,173.34 235.26,173.07 235.26,172.74 235.56,172.44 235.89,172.44 236.55,171.78 arc(236.92,171.53) 237.36,171.45 247.56,171.45 arc(247.7,171.42) 247.83,171.34 283.19,135.97 arc(283.56,135.72) 284,135.63 301.79,135.63 arc(301.93,135.6) 302.05,135.52 362.03,75.55 arc(362.11,75.42) 362.14,75.28 362.14,75.01 arc(362.23,74.58) 362.48,74.21 363.12,73.57 arc(363.2,73.44) 363.23,73.3 363.23,72.88 362.97,72.63 362.97,72.25 363.23,71.99 363.23,67.65 arc(363.2,67.5) 363.12,67.38 362.33,66.6 arc(362.08,66.22) 362,65.79 362,62.04 arc(361.87,61.41) 361.52,60.89 360.76,60.13 360.4,60.13 360.13,59.86 360.13,59.5 359.86,59.23 arc(359.84,59.21) 359.81,59.18 359.76,59.13 359.72,59.08 arc(359.55,58.96) 359.36,58.88 arc(359.27,58.87) 359.18,58.86 358.33,58.86 arc(358.1,58.77) 358.01,58.54 358.01,58.32 arc(358.04,58.13) 358.15,57.97 YJ35.B22
FC59_RDP2: length 225.4
  TOP w0.147: v4(216.6,169.34) 216.55,169.34 U1.CC15
  SIG2 w0.112: 217.86,172.84 217.86,172.81 217.95,172.72 217.95,170.25 arc(217.93,170.15) 217.87,170.06 arc(217.78,170) 217.68,169.98 217.3,169.98 arc(217.17,169.95) 217.05,169.87 arc(216.98,169.76) 216.95,169.62 216.95,169.47 arc(216.91,169.38) 216.82,169.34 v4(216.6,169.34)
  SIG2 w0.16: 217.86,172.84 217.86,175.74 arc(217.92,176.04) 218.09,176.3 arc(218.35,176.47) 218.65,176.53 228.98,176.53 arc(229.42,176.44) 229.79,176.19 231.96,174.02 arc(232.08,173.94) 232.23,173.91 248.36,173.91 arc(248.8,173.82) 249.17,173.58 284.46,138.29 arc(284.59,138.2) 284.73,138.17 302.62,138.17 arc(303.06,138.09) 303.43,137.84 364.32,76.94 arc(364.57,76.57) 364.66,76.14 364.66,66.89 arc(364.6,66.6) 364.43,66.35 363.94,65.86 arc(363.78,65.61) 363.72,65.32 363.72,58.85 arc(363.63,58.41) 363.39,58.04 360.71,55.36 arc(360.34,55.11) 359.9,55.03 357.95,55.03 arc(357.86,55.01) 357.78,54.98 arc(357.73,54.95) 357.68,54.91 357.63,54.86 arc(357.54,54.72) 357.51,54.57 357.51,54.08 arc(357.46,53.86) 357.34,53.67 356.86,53.2 arc(356.74,53.02) 356.7,52.8 YJ35.B15
FC59_RDP3: length 211.6
  TOP w0.147: v4(220.5,169.34) 220.42,169.34 arc(220.35,169.33) 220.29,169.29 220.12,169.12 arc(220.07,169.04) 220.05,168.94 U1.CC11
  SIG2 w0.112: 221.24,172.84 221.24,172.81 221.15,172.72 221.15,170.25 arc(221.11,170.07) 221.01,169.92 arc(220.86,169.81) 220.68,169.78 220.3,169.78 arc(220.24,169.77) 220.19,169.73 arc(220.16,169.68) 220.15,169.62 220.15,169.47 arc(220.18,169.38) 220.27,169.34 v4(220.5,169.34)
  SIG2 w0.16: 221.24,172.84 221.24,173.28 arc(221.41,173.69) 221.83,173.86 222.31,173.86 222.56,173.61 223.12,173.61 223.38,173.86 223.83,173.86 224.09,173.61 224.65,173.61 224.9,173.86 227.97,173.86 arc(228.26,173.8) 228.51,173.64 230.47,171.67 arc(230.72,171.51) 231.01,171.45 247.4,171.45 arc(247.69,171.39) 247.94,171.22 283.3,135.86 arc(283.55,135.69) 283.84,135.63 301.63,135.63 arc(301.92,135.58) 302.17,135.41 361.97,75.61 arc(362.13,75.36) 362.19,75.07 362.19,74.29 361.96,74.06 361.96,73.5 362.19,73.27 362.19,72.76 361.96,72.54 361.96,71.98 362.19,71.75 362.19,71.24 361.96,71.01 361.96,70.45 362.19,70.22 362.19,69.72 361.94,69.46 361.94,68.95 362.19,68.7 362.19,68.19 361.94,67.94 361.94,67.43 362.19,67.18 362.19,66.67 arc(362.05,66.44) 362,66.18 362,61.44 362,61.44 arc(361.94,61.15) 361.77,60.9 360.5,59.63 arc(360.25,59.46) 359.96,59.41 357.95,59.41 arc(357.77,59.38) 357.6,59.32 arc(357.5,59.26) 357.41,59.18 357.36,59.13 357.32,59.08 arc(357.07,58.92) 356.78,58.86 355.92,58.86 arc(355.7,58.77) 355.61,58.55 355.61,58.32 arc(355.64,58.13) 355.75,57.97 YJ35.B25
FC59_TDN0: length 207.8
  TOP w0.147: U1.CF4 227.1,171.84 arc(227.42,171.97) v4(227.55,172.29)
  SIG5 w0.112: v4(227.55,172.29) 227.83,172.01 arc(227.91,171.96) 228,171.94 229.84,171.94 229.93,172.03 229.96,172.03
  SIG5 w0.16: 229.96,172.03 232.42,172.03 arc(232.58,172.02) 232.73,171.97 arc(232.85,171.9) 232.96,171.81 234.8,169.97 arc(235.04,169.8) 235.34,169.75 249.48,169.75 arc(249.92,169.66) 250.29,169.41 287.89,131.81 arc(288.02,131.73) 288.16,131.7 305.91,131.7 arc(306.35,131.61) 306.72,131.36 357.49,80.6 arc(357.74,80.23) 357.82,79.79 357.82,73.49 arc(357.88,73.2) 358.05,72.95 362.15,68.84 arc(362.32,68.6) 362.38,68.3 362.38,61.57 arc(362.32,61.28) 362.15,61.03 360.37,59.25 arc(360.12,59.08) 359.83,59.03 348.35,59.03 arc(348.21,59) 348.08,58.91 348.03,58.86 arc(347.94,58.72) 347.91,58.57 347.91,57.97 arc(347.88,57.85) 347.81,57.75 347.27,57.2 arc(347.26,57.2) 347.26,57.2 arc(347.14,57.01) 347.1,56.8 YJ35.B36
FC59_TDN1: length 219.6
  TOP w0.147: U1.CE6 225.55,171.34 v4(225.55,171.39)
  SIG5 w0.112: 226.77,173.34 226.64,173.34 226.31,173.01 arc(226.22,172.86) 226.18,172.69 226.18,172.06 arc(226.15,171.91) 226.07,171.79 arc(225.97,171.72) 225.84,171.69 arc(225.64,171.61) 225.55,171.4 v4(225.55,171.39)
  SIG5 w0.16: YJ35.B2 346.15,53.97 arc(346.04,54.13) 346.01,54.32 346.01,54.59 arc(346.09,54.78) 346.28,54.86 347.19,54.86 arc(347.47,54.92) 347.71,55.08 347.81,55.18 arc(348.06,55.35) 348.35,55.41 359.96,55.41 arc(360.1,55.44) 360.23,55.52 363.2,58.5 arc(363.29,58.62) 363.32,58.76 363.32,70.2 363.16,70.36 363.16,71.12 363.32,71.27 363.32,72.03 363.16,72.18 363.16,72.95 363.32,73.1 363.32,74.45 arc(363.26,74.74) 363.09,74.99 362.55,75.53 362.34,75.53 361.8,76.07 361.8,76.29 361.26,76.82 361.04,76.82 360.51,77.36 360.51,77.58 359.75,78.34 arc(359.58,78.58) 359.52,78.88 359.52,80.88 arc(359.47,81.17) 359.3,81.42 358.76,81.96 358.6,81.96 358.01,82.55 358.01,82.71 357.47,83.25 357.3,83.25 356.71,83.84 356.71,84.01 307.47,133.25 arc(307.22,133.42) 306.93,133.47 289.05,133.47 arc(288.76,133.53) 288.51,133.7 254.54,167.67 254.43,167.67 253.89,168.21 253.89,168.31 253.36,168.85 253.25,168.85 252.71,169.39 252.71,169.5 252.17,170.04 252.06,170.04 251.52,170.58 251.52,170.69 250.99,171.22 arc(250.74,171.39) 250.45,171.45 236.5,171.45 arc(236.07,171.53) 235.69,171.78 233.5,173.98 arc(233.38,174.06) 233.23,174.09 231.74,174.09 231.61,173.96 230.85,173.96 230.72,174.09 229.96,174.09 229.83,173.96 229.07,173.96 228.95,174.09 228.21,174.09 arc(227.58,173.96) 227.04,173.6 226.77,173.34
FC59_TDN2: length 204.4
  TOP w0.147: v4(228.55,170.29) 228.55,170.21 arc(228.53,170.13) 228.49,170.06 228.41,169.98 arc(228.26,169.88) 228.07,169.84 U1.CD3
  SIG4 w0.112: 230.28,171.41 230.26,171.39 230.26,171.26 230.16,171.17 230.05,171.05 arc(229.93,170.97) 229.78,170.94 229.57,170.94 arc(229.35,170.9) 229.16,170.77 arc(229.03,170.58) 228.99,170.36 228.99,169.97 arc(228.98,169.93) 228.95,169.9 arc(228.92,169.87) 228.88,169.86 228.68,169.86 arc(228.59,169.9) 228.55,169.99 v4(228.55,170.29)
  SIG4 w0.16: YJ35.B33 349.5,56.79 arc(349.55,57.02) 349.68,57.21 350.21,57.75 arc(350.28,57.85) 350.31,57.97 350.31,58.57 arc(350.34,58.72) 350.43,58.86 350.48,58.91 arc(350.61,59) 350.75,59.03 360.27,59.03 arc(360.57,59.08) 360.81,59.25 362.15,60.59 arc(362.32,60.84) 362.38,61.13 362.38,68.79 arc(362.32,69.08) 362.15,69.33 358.3,73.18 arc(358.13,73.43) 358.08,73.72 358.08,79.7 arc(358.02,79.99) 357.85,80.24 309.5,128.59 arc(303.67,132.49) 296.79,133.86 295.7,133.86 arc(286.62,135.66) 278.92,140.81 248.12,171.61 arc(247.87,171.77) 247.58,171.83 231.12,171.83 arc(230.73,171.75) 230.39,171.52 230.28,171.41
FC59_TDN3: length 216.6
  TOP w0.147: v4(226.55,169.39) 226.55,169.34 U1.CC5
  SIG4 w0.112: v4(226.55,169.39) 226.65,169.5 arc(226.8,169.61) 226.98,169.68 arc(227,169.68) 227.02,169.69 arc(227.15,169.72) 227.28,169.74 arc(227.31,169.74) 227.35,169.74 arc(227.36,169.74) 227.37,169.74 227.63,169.74 arc(227.82,169.78) 227.97,169.88 arc(228.08,170.04) 228.11,170.22 228.11,170.65 arc(228.12,170.68) 228.13,170.71 arc(228.15,170.73) 228.16,170.76 228.16,172.41 arc(228.19,172.58) 228.28,172.72 228.35,172.78 228.53,172.97 228.67,172.97
  SIG4 w0.16: 228.67,172.97 228.97,173.27 arc(229.25,173.46) 229.58,173.53 230.04,173.53 230.21,173.35 230.78,173.35 230.95,173.53 248.55,173.53 arc(248.7,173.5) 248.82,173.42 279.54,142.69 arc(287.36,137.47) 296.59,135.63 298.6,135.63 arc(304.55,134.45) 309.59,131.08 359.74,80.93 arc(359.83,80.8) 359.85,80.66 359.85,78.55 arc(359.94,78.11) 360.19,77.74 364.06,73.87 arc(364.14,73.74) 364.17,73.6 364.17,72.2 363.97,71.99 363.97,71.38 364.17,71.18 364.17,70.67 363.97,70.47 363.97,69.86 364.17,69.66 364.17,68.77 arc(364.14,68.62) 364.06,68.5 363.65,68.09 arc(363.4,67.72) 363.32,67.28 363.32,60.03 363.06,59.78 363.06,59.27 363.32,59.02 363.32,58.51 arc(363.29,58.37) 363.2,58.24 362.64,57.67 362.28,57.67 361.92,57.31 361.92,56.96 361.56,56.6 361.2,56.6 360.84,56.24 360.84,55.88 360.48,55.52 arc(360.36,55.44) 360.21,55.41 350.75,55.41 arc(350.46,55.35) 350.21,55.18 350.16,55.13 350.12,55.08 arc(349.87,54.92) 349.58,54.86 348.74,54.86 arc(348.5,54.77) 348.41,54.53 348.41,54.32 arc(348.44,54.13) 348.55,53.97 YJ35.B5
FC59_TDP0: length 207.8
  TOP w0.147: U1.CE4 227.55,171.34 v4(227.55,171.39)
  SIG5 w0.112: v4(227.55,171.39) 227.83,171.67 arc(227.91,171.72) 228,171.74 229.84,171.74 229.93,171.65 229.96,171.65
  SIG5 w0.16: 229.96,171.65 232.42,171.65 arc(232.5,171.64) 232.57,171.62 arc(232.63,171.58) 232.69,171.54 234.53,169.7 arc(234.9,169.45) 235.34,169.36 249.48,169.36 arc(249.77,169.31) 250.02,169.14 250.56,168.6 250.56,168.49 251.1,167.96 251.21,167.96 251.74,167.42 251.74,167.31 252.28,166.77 252.39,166.77 252.93,166.23 252.93,166.12 253.47,165.59 253.58,165.59 254.11,165.05 254.11,164.94 254.65,164.4 254.76,164.4 255.3,163.86 255.3,163.75 255.84,163.21 255.95,163.21 287.62,131.54 arc(287.87,131.37) 288.16,131.32 305.91,131.32 arc(306.21,131.26) 306.45,131.09 357.22,80.33 arc(357.38,80.08) 357.44,79.79 357.44,78.82 357.34,78.72 357.34,77.91 357.44,77.81 357.44,77.05 357.31,76.92 357.31,76.16 357.44,76.03 357.44,75.27 357.31,75.14 357.31,74.38 357.44,74.25 357.44,73.49 arc(357.53,73.05) 357.78,72.68 359.37,71.09 359.37,70.91 359.91,70.37 360.09,70.37 360.63,69.83 360.63,69.65 361.17,69.11 361.35,69.11 361.89,68.57 arc(361.97,68.45) 362,68.3 362,61.57 arc(361.97,61.43) 361.89,61.3 360.1,59.52 arc(359.98,59.44) 359.83,59.41 348.35,59.41 arc(348.06,59.35) 347.81,59.18 347.76,59.13 347.72,59.08 arc(347.47,58.92) 347.18,58.86 346.32,58.86 arc(346.1,58.77) 346.01,58.55 346.01,58.32 arc(346.04,58.13) 346.15,57.97 YJ35.B37
FC59_TDP1: length 219.6
  TOP w0.147: U1.CF6 225.1,171.84 arc(225.42,171.97) v4(225.55,172.29)
  SIG5 w0.112: 226.5,173.61 226.48,173.59 226.48,173.46 226.17,173.15 arc(226.15,173.12) 226.13,173.1 arc(226.02,172.91) 225.99,172.69 225.99,172.06 arc(225.97,171.99) 225.93,171.93 arc(225.89,171.9) 225.84,171.89 225.71,171.89 arc(225.66,171.9) 225.62,171.93 225.59,171.96 arc(225.56,172) 225.55,172.05 v4(225.55,172.29)
  SIG5 w0.16: 226.5,173.61 226.77,173.87 arc(227.43,174.32) 228.21,174.47 233.23,174.47 arc(233.52,174.41) 233.77,174.25 235.96,172.05 arc(236.21,171.89) 236.5,171.83 250.45,171.83 arc(250.88,171.74) 251.25,171.49 288.78,133.97 arc(288.9,133.88) 289.05,133.86 306.93,133.86 arc(307.37,133.77) 307.74,133.52 359.57,81.69 arc(359.82,81.32) 359.91,80.88 359.91,78.88 arc(359.93,78.73) 360.02,78.61 363.36,75.26 arc(363.61,74.89) 363.7,74.45 363.7,58.76 arc(363.64,58.47) 363.47,58.23 360.5,55.25 arc(360.25,55.08) 359.96,55.03 348.35,55.03 arc(348.21,55) 348.08,54.91 348.03,54.86 arc(347.96,54.77) 347.92,54.66 arc(347.92,54.66) 347.91,54.65 arc(347.91,54.65) 347.91,54.64 arc(347.91,54.64) 347.91,54.64 arc(347.91,54.6) 347.91,54.57 347.91,53.97 arc(347.88,53.85) 347.81,53.75 347.37,53.3 arc(347.17,53) 347.1,52.65 YJ35.B3
FC59_TDP2: length 204.4
  TOP w0.147: v4(228.55,169.39) 228.55,169.34 U1.CC3
  SIG4 w0.112: 230.55,171.14 230.53,171.12 230.4,171.12 230.3,171.03 230.19,170.91 arc(230,170.79) 229.78,170.75 229.57,170.75 arc(229.42,170.72) 229.3,170.63 arc(229.21,170.51) 229.18,170.36 229.18,169.97 arc(229.16,169.86) 229.09,169.76 arc(228.99,169.69) 228.88,169.67 228.68,169.67 arc(228.59,169.63) 228.55,169.54 v4(228.55,169.39)
  SIG4 w0.16: 230.55,171.14 230.66,171.25 arc(230.87,171.4) 231.12,171.45 231.58,171.45 231.81,171.22 232.27,171.22 232.5,171.45 232.95,171.45 233.18,171.22 233.64,171.22 233.87,171.45 247.58,171.45 arc(247.73,171.42) 247.85,171.34 278.65,140.54 arc(286.47,135.31) 295.7,133.47 296.78,133.47 arc(303.52,132.13) 309.23,128.32 357.58,79.97 arc(357.67,79.84) 357.7,79.7 357.7,73.72 arc(357.78,73.28) 358.03,72.91 359.73,71.21 359.73,70.85 360.09,70.49 360.45,70.49 360.81,70.13 360.81,69.77 361.17,69.41 361.53,69.41 361.89,69.06 arc(361.97,68.93) 362,68.79 362,62.54 361.81,62.35 361.81,61.78 362,61.59 362,61.13 arc(361.97,60.98) 361.89,60.86 361.59,60.57 361.32,60.57 360.87,60.12 360.87,59.85 360.54,59.52 arc(360.42,59.44) 360.27,59.41 350.75,59.41 arc(350.46,59.35) 350.21,59.18 350.16,59.13 350.12,59.08 arc(349.87,58.92) 349.58,58.86 348.68,58.86 arc(348.49,58.78) 348.41,58.59 348.41,58.32 arc(348.44,58.13) 348.55,57.97 YJ35.B34
FC59_TDP3: length 216.6
  TOP w0.147: v4(226.55,170.29) 226.55,170.21 arc(226.53,170.13) 226.49,170.06 226.41,169.98 arc(226.26,169.88) 226.07,169.84 U1.CD5
  SIG4 w0.112: v4(226.55,170.29) 226.66,170.01 arc(226.71,169.94) 226.78,169.9 226.86,169.86 arc(226.91,169.87) 226.96,169.88 arc(227.11,169.92) 227.27,169.94 arc(227.3,169.94) 227.34,169.94 arc(227.36,169.94) 227.37,169.94 227.63,169.94 arc(227.74,169.96) 227.83,170.02 arc(227.89,170.11) 227.91,170.22 227.91,170.65 arc(227.93,170.73) 227.96,170.8 227.96,172.41 arc(228.01,172.65) 228.14,172.86 228.4,173.11 228.4,173.24
  SIG4 w0.16: 228.4,173.24 228.7,173.54 arc(229.11,173.81) 229.58,173.91 248.55,173.91 arc(248.84,173.85) 249.09,173.69 279.81,142.96 arc(287.51,137.82) 296.59,136.01 298.6,136.01 arc(304.69,134.8) 309.85,131.35 360.01,81.2 arc(360.18,80.95) 360.24,80.66 360.24,78.55 arc(360.29,78.25) 360.46,78.01 364.33,74.13 arc(364.5,73.89) 364.55,73.6 364.55,68.77 arc(364.5,68.47) 364.33,68.23 363.92,67.82 arc(363.75,67.57) 363.7,67.28 363.7,58.51 arc(363.64,58.22) 363.47,57.97 360.75,55.25 arc(360.5,55.08) 360.21,55.03 350.75,55.03 arc(350.61,55) 350.48,54.91 350.43,54.86 arc(350.34,54.72) 350.31,54.57 350.31,53.97 arc(350.28,53.85) 350.21,53.75 349.87,53.4 349.75,53.28 arc(349.57,53.01) 349.5,52.68 YJ35.B6
FC60_61_PVDD0P8: length 5.4
  TOP w0.229: U1.BG24 v1(207.55,153.34) ; U1.BG26 v1(205.55,153.34)
  TOP w0.381: C3162.1 222.66,193.39 ; C3162.1 221.46,193.39 ; C3162.1 222.06,194.03
  BOTTOM w0.13: v1(221.04,194.18) v2(220.28,194.18)
  BOTTOM w0.381: C3329.1 206.03,152.86 v1(205.55,153.34) ; C3121.1 208.04,152.85 v1(207.55,153.34)
  vias: v1(221.04,193.16)
FC60_RDN0: length 225.8
  TOP w0.147: U1.BY18 213.05,165.94 arc(213.07,166.04) 213.12,166.12 213.29,166.29 arc(213.35,166.33) 213.42,166.34 v4(213.5,166.34)
  SIG9 w0.112: v4(213.5,166.34) 213.27,166.34 arc(213.2,166.37) 213.17,166.44 213.17,166.66 arc(213.21,166.74) 213.29,166.78 214.61,166.78 arc(214.82,166.82) 214.99,166.93 arc(215.1,167.11) 215.14,167.31 215.14,174.12 215.24,174.21 215.24,174.24
  SIG9 w0.16: 215.24,174.24 215.24,175.26 arc(215.29,175.55) 215.46,175.79 219.78,180.11 arc(220.03,180.28) 220.32,180.34 231.27,180.34 arc(231.42,180.31) 231.54,180.23 235.8,175.97 arc(236.17,175.73) 236.61,175.64 252.51,175.64 arc(252.65,175.61) 252.78,175.53 294.5,133.81 arc(294.87,133.56) 295.3,133.47 303.94,133.47 arc(304.09,133.45) 304.21,133.36 320.74,116.84 359.41,78.16 arc(359.5,78.04) 359.52,77.89 359.52,77.15 359.27,76.9 359.27,76.51 359.52,76.26 359.52,75.7 359.27,75.45 359.27,75.07 359.52,74.81 359.52,74.43 arc(359.61,73.99) 359.86,73.62 360.86,72.62 360.86,72.26 361.13,71.99 361.49,71.99 361.77,71.71 arc(361.86,71.58) 361.89,71.44 361.89,70.61 361.63,70.36 361.63,69.85 361.89,69.59 361.89,69.09 361.63,68.83 361.63,68.32 361.89,68.07 361.89,60.77 arc(361.97,60.33) 362.22,59.96 362.83,59.35 arc(363.2,59.1) 363.64,59.01 363.99,59.01 arc(364.14,58.98) 364.26,58.9 364.35,58.82 364.39,58.77 arc(364.45,58.7) 364.49,58.61 arc(364.5,58.59) 364.5,58.57 arc(364.51,58.52) 364.51,58.48 364.51,58.07 arc(364.56,57.84) 364.69,57.65 365.18,57.15 arc(365.27,57.02) 365.3,56.86 YJ36.B21
FC60_RDN1: length 226.6
  TOP w0.147: U1.BV19 212.55,164.34 v4(212.6,164.34)
  SIG9 w0.112: 215.86,172.91 215.86,172.86 215.95,172.77 215.95,165.09 arc(215.92,165.01) 215.84,164.98 213.29,164.98 arc(213.07,164.88) 212.98,164.66 212.98,164.52 arc(212.92,164.4) 212.79,164.34 v4(212.6,164.34)
  SIG9 w0.16: YJ36.B17 366.25,53.97 arc(366.36,54.14) 366.4,54.34 366.4,54.56 arc(366.39,54.65) 366.34,54.72 366.33,54.73 arc(366.18,54.83) 366.01,54.86 365.02,54.86 arc(364.85,54.89) 364.71,54.99 361.69,58.01 arc(361.18,58.78) 361,59.69 361,66.13 arc(360.94,66.43) 360.77,66.67 356.78,70.67 arc(356.61,70.92) 356.55,71.21 356.55,78.05 arc(356.49,78.34) 356.33,78.59 318.08,116.84 303.44,131.47 arc(303.19,131.64) 302.9,131.7 294.42,131.7 arc(294.12,131.75) 293.88,131.92 252.11,173.69 arc(251.86,173.85) 251.57,173.91 235.48,173.91 230.95,178.44 arc(230.7,178.6) 230.41,178.66 221.28,178.66 arc(220.85,178.57) 220.47,178.33 216.19,174.04 arc(215.95,173.67) 215.86,173.24 215.86,172.91
FC60_RDN2: length 236.9
  TOP w0.147: v4(213.5,162.34) 213.42,162.34 arc(213.34,162.33) 213.28,162.28 213.19,162.2 arc(213.09,162.04) 213.05,161.85 U1.BT18
  SIG8 w0.112: 215.24,173.98 215.24,173.96 arc(215.17,173.93) 215.15,173.87 215.15,164.12 arc(215.12,163.96) 215.03,163.83 arc(214.89,163.74) 214.73,163.71 213.46,163.71 arc(213.34,163.68) 213.24,163.62 arc(213.17,163.52) 213.15,163.4 213.15,162.44 arc(213.18,162.37) 213.25,162.34 v4(213.5,162.34)
  SIG8 w0.16: 215.24,173.98 215.24,178.18 arc(215.29,178.47) 215.46,178.72 216.86,180.11 arc(217.11,180.28) 217.4,180.34 231.1,180.34 arc(231.4,180.28) 231.64,180.11 235.92,175.84 arc(236.17,175.67) 236.46,175.61 252.38,175.61 arc(252.67,175.56) 252.92,175.39 294.61,133.7 arc(294.85,133.53) 295.15,133.47 310.16,133.47 arc(310.45,133.42) 310.7,133.25 359.68,84.27 arc(359.85,84.02) 359.91,83.73 359.91,77.96 359.68,77.73 359.68,77.17 359.91,76.94 359.91,76.44 359.65,76.18 359.65,75.67 359.91,75.42 359.91,74.91 359.65,74.66 359.65,74.15 359.91,73.9 359.91,73.39 359.65,73.13 359.65,72.63 359.91,72.37 359.91,71.86 359.65,71.61 359.65,71.1 359.91,70.85 359.91,70.34 arc(359.96,70.05) 360.13,69.8 361.79,68.14 arc(361.96,67.89) 362.01,67.6 362.01,61.76 arc(362.1,61.32) 362.35,60.95 363.95,59.35 arc(364.32,59.1) 364.76,59.01 366.39,59.01 arc(366.54,58.98) 366.66,58.9 366.75,58.82 arc(366.82,58.73) 366.87,58.63 arc(366.9,58.53) 366.91,58.42 366.91,58.15 arc(366.97,57.85) 367.14,57.59 367.4,57.34 arc(367.62,57) 367.7,56.61 YJ36.B24
FC60_RDN3: length 238
  TOP w0.147: v4(212.6,160.34) 212.55,160.34 U1.BP19
  SIG8 w0.112: 215.86,172.9 215.86,172.87 215.95,172.78 215.95,161.35 arc(215.92,161.21) 215.84,161.09 arc(215.72,161) 215.57,160.98 213.4,160.98 arc(213.23,160.94) 213.08,160.84 arc(212.98,160.7) 212.95,160.53 212.95,160.44 arc(212.92,160.37) 212.85,160.34 v4(212.6,160.34)
  SIG8 w0.16: 215.86,172.9 215.86,173.19 arc(215.92,173.48) 216.08,173.72 216.26,173.91 arc(216.43,174.15) 216.49,174.45 216.49,176.89 arc(216.57,177.33) 216.82,177.7 217.43,178.3 arc(217.8,178.55) 218.24,178.64 230.22,178.64 arc(230.66,178.55) 231.03,178.3 235.31,174.02 arc(235.43,173.94) 235.58,173.91 251.41,173.91 arc(251.85,173.82) 252.22,173.58 293.99,131.81 arc(294.11,131.73) 294.26,131.7 309.28,131.7 arc(309.57,131.64) 309.82,131.47 357.6,83.69 arc(357.76,83.44) 357.82,83.15 357.82,69.88 arc(357.88,69.59) 358.05,69.34 360.77,66.62 arc(360.94,66.37) 361,66.08 361,59.34 arc(361.06,59.05) 361.22,58.8 364.41,55.62 arc(364.65,55.45) 364.95,55.39 366.39,55.39 arc(366.68,55.34) 366.93,55.17 367.11,54.99 arc(367.25,54.89) 367.42,54.86 368.4,54.86 arc(368.55,54.83) 368.68,54.75 368.68,54.75 arc(368.77,54.61) 368.8,54.45 368.8,54.34 arc(368.76,54.14) 368.65,53.97 YJ36.B14
FC60_RDP0: length 225.8
  TOP w0.147: v4(212.6,166.34) 212.55,166.34 U1.BY19
  SIG9 w0.112: v4(212.6,166.34) 212.79,166.34 arc(212.92,166.4) 212.98,166.52 212.98,166.66 arc(213.07,166.88) 213.29,166.98 214.61,166.98 arc(214.74,167) 214.85,167.07 arc(214.92,167.18) 214.95,167.31 214.95,174.12 214.86,174.21 214.86,174.24
  SIG9 w0.16: 214.86,174.24 214.86,175.26 arc(214.94,175.69) 215.19,176.06 219.51,180.38 arc(219.88,180.63) 220.32,180.72 231.27,180.72 arc(231.57,180.66) 231.81,180.5 236.07,176.24 arc(236.31,176.08) 236.61,176.02 252.51,176.02 arc(252.8,175.96) 253.05,175.8 294.77,134.08 arc(295.01,133.91) 295.3,133.86 303.94,133.86 arc(304.24,133.8) 304.48,133.63 321.28,116.84 359.68,78.43 arc(359.85,78.19) 359.91,77.89 359.91,74.43 arc(359.96,74.14) 360.13,73.89 362.04,71.98 arc(362.21,71.73) 362.27,71.44 362.27,60.77 arc(362.33,60.47) 362.49,60.23 363.1,59.62 arc(363.35,59.45) 363.64,59.39 363.99,59.39 arc(364.28,59.34) 364.53,59.17 364.62,59.08 364.72,58.98 arc(364.85,58.89) 365.01,58.86 366.06,58.86 arc(366.3,58.76) 366.4,58.52 366.4,58.34 arc(366.36,58.14) 366.25,57.97 YJ36.B22
FC60_RDP1: length 226.6
  TOP w0.147: v4(213.5,164.34) 213.42,164.34 arc(213.35,164.33) 213.29,164.29 213.12,164.12 arc(213.07,164.04) 213.05,163.94 U1.BV18
  SIG9 w0.112: v4(213.5,164.34) 213.27,164.34 arc(213.2,164.37) 213.17,164.44 213.17,164.66 arc(213.21,164.74) 213.29,164.78 215.84,164.78 arc(216.06,164.87) 216.15,165.09 216.15,172.77 216.24,172.86
  SIG9 w0.16: 216.24,172.86 216.24,173.24 arc(216.3,173.53) 216.46,173.78 216.73,174.04 217.07,174.04 217.36,174.34 217.36,174.67 220.74,178.06 arc(220.99,178.22) 221.28,178.28 230.41,178.28 arc(230.56,178.25) 230.68,178.17 235.32,173.53 251.57,173.53 arc(251.72,173.5) 251.84,173.42 293.61,131.65 arc(293.98,131.4) 294.42,131.32 302.9,131.32 arc(303.05,131.29) 303.17,131.2 317.54,116.84 356.06,78.32 arc(356.14,78.19) 356.17,78.05 356.17,71.21 arc(356.26,70.77) 356.51,70.4 360.5,66.4 arc(360.59,66.28) 360.62,66.13 360.62,64.2 360.36,63.94 360.36,63.56 360.62,63.31 360.62,62.93 360.36,62.67 360.36,62.29 360.62,62.04 360.62,59.69 arc(360.83,58.63) 361.42,57.74 362.1,57.06 362.1,56.7 362.46,56.34 362.82,56.34 363.18,55.98 363.18,55.65 363.56,55.27 363.9,55.27 364.35,54.82 364.39,54.77 arc(364.45,54.7) 364.49,54.62 arc(364.5,54.55) 364.51,54.48 364.51,54.07 arc(364.56,53.84) 364.69,53.65 365.16,53.17 arc(365.26,53.02) 365.3,52.84 YJ36.B18
FC60_RDP2: length 236.9
  TOP w0.147: U1.BT19 212.55,162.34 v4(212.6,162.34)
  SIG8 w0.112: 214.86,173.98 214.95,173.89 214.95,164.12 arc(214.93,164.04) 214.89,163.97 arc(214.82,163.92) 214.73,163.9 213.46,163.9 arc(213.26,163.87) 213.1,163.76 arc(212.99,163.59) 212.95,163.4 212.95,162.44 arc(212.92,162.37) 212.85,162.34 v4(212.6,162.34)
  SIG8 w0.16: YJ36.B25 368.65,57.97 arc(368.78,58.17) 368.83,58.39 368.83,58.43 arc(368.8,58.57) 368.72,58.69 arc(368.53,58.82) 368.3,58.86 367.42,58.86 arc(367.39,58.86) 367.35,58.87 arc(367.22,58.91) 367.11,58.99 366.93,59.17 arc(366.68,59.34) 366.39,59.39 364.76,59.39 arc(364.46,59.45) 364.22,59.62 362.62,61.22 arc(362.45,61.46) 362.4,61.76 362.39,67.6 arc(362.31,68.04) 362.06,68.41 360.4,70.07 arc(360.32,70.2) 360.29,70.34 360.29,83.73 arc(360.2,84.17) 359.95,84.54 310.97,133.52 arc(310.6,133.77) 310.16,133.86 295.15,133.86 arc(295,133.88) 294.88,133.97 253.18,175.66 arc(252.81,175.91) 252.38,175.99 236.46,175.99 arc(236.31,176.02) 236.19,176.11 231.91,180.38 arc(231.54,180.63) 231.1,180.72 217.4,180.72 arc(216.96,180.63) 216.59,180.38 215.19,178.99 arc(214.94,178.61) 214.86,178.18 214.86,173.98
FC60_RDP3: length 238
  TOP w0.147: U1.BP18 213.05,159.85 arc(213.09,160.04) 213.19,160.2 213.28,160.28 arc(213.34,160.33) 213.42,160.34 v4(213.5,160.34)
  SIG8 w0.112: 216.24,172.9 216.24,172.87 216.15,172.78 216.15,161.35 arc(216.1,161.13) 215.98,160.95 arc(215.79,160.82) 215.57,160.78 213.4,160.78 arc(213.3,160.76) 213.22,160.7 arc(213.17,160.62) 213.15,160.53 213.15,160.44 arc(213.18,160.37) 213.25,160.34 v4(213.5,160.34)
  SIG8 w0.16: 216.24,172.9 216.24,173.19 arc(216.27,173.33) 216.35,173.46 216.53,173.64 arc(216.78,174.01) 216.87,174.45 216.87,176.89 arc(216.93,177.18) 217.09,177.43 217.7,178.03 arc(217.94,178.2) 218.24,178.25 230.22,178.25 arc(230.51,178.2) 230.76,178.03 235.04,173.75 arc(235.28,173.59) 235.58,173.53 251.41,173.53 arc(251.7,173.47) 251.95,173.31 255.97,169.29 293.72,131.54 arc(293.97,131.37) 294.26,131.32 309.28,131.32 arc(309.42,131.29) 309.55,131.2 357.33,83.42 arc(357.41,83.3) 357.44,83.15 357.44,77.54 357.21,77.32 357.21,76.76 357.44,76.53 357.44,76.02 357.19,75.77 357.19,75.26 357.44,75 357.44,74.5 357.19,74.24 357.19,73.73 357.44,73.48 357.44,72.97 357.19,72.72 357.19,72.21 357.44,71.96 357.44,71.45 357.19,71.19 357.19,70.69 357.44,70.43 357.44,69.88 arc(357.53,69.45) 357.78,69.08 360.5,66.35 arc(360.59,66.22) 360.62,66.08 360.62,59.34 arc(360.7,58.91) 360.95,58.53 364.14,55.35 arc(364.51,55.1) 364.95,55.01 366.39,55.01 arc(366.54,54.98) 366.66,54.9 366.75,54.82 366.75,54.81 366.79,54.77 arc(366.85,54.7) 366.89,54.61 arc(366.91,54.54) 366.91,54.48 366.91,54.1 arc(366.96,53.84) 367.11,53.63 367.45,53.29 arc(367.63,53.01) 367.7,52.68 YJ36.B15
FC60_TDN0: length 230.2
  TOP w0.147: v4(211.6,169.34) 211.55,169.34 U1.CC20
  SIG6 w0.112: v4(211.6,169.34) 211.75,169.34 arc(211.84,169.38) 211.87,169.47 211.87,169.63 arc(211.9,169.75) 211.97,169.86 211.98,169.87 arc(212.1,169.95) 212.24,169.98 212.75,169.98 arc(212.83,169.99) 212.89,170.04 arc(212.94,170.1) 212.95,170.18 212.95,173.42 arc(213.01,173.7) 213.17,173.93 213.38,174.14 213.38,174.27 213.4,174.29
  SIG6 w0.16: YJ36.B34 375.85,57.97 arc(375.96,58.14) 376,58.34 376,58.52 arc(375.9,58.76) 375.66,58.86 374.62,58.86 arc(374.45,58.9) 374.31,58.99 374.13,59.17 arc(373.88,59.34) 373.59,59.39 364.34,59.39 arc(364.19,59.42) 364.07,59.51 362.51,61.06 arc(362.43,61.18) 362.4,61.33 362.4,68 arc(362.32,68.44) 362.07,68.81 360.46,70.42 arc(360.29,70.66) 360.24,70.96 360.24,80.71 arc(360.18,81) 360.01,81.25 303.31,137.95 arc(303.06,138.12) 302.77,138.17 287.94,138.17 arc(287.65,138.23) 287.4,138.4 250.03,175.77 arc(249.78,175.94) 249.49,175.99 233.63,175.99 arc(233.34,176.05) 233.09,176.22 232.98,176.33 arc(232.73,176.49) 232.44,176.55 216.13,176.55 arc(215.69,176.47) 215.32,176.22 213.4,174.29
FC60_TDN1: length 229.2
  TOP w0.147: U1.CF17 214.05,171.89 arc(214.18,172.21) v4(214.5,172.34)
  SIG7 w0.112: v4(214.5,172.34) 214.25,172.34 arc(214.23,172.34) 214.2,172.35 214.16,172.37 arc(214.13,172.39) 214.11,172.42 214.1,172.43 arc(214.1,172.45) 214.1,172.47 214.1,172.63 arc(214.09,172.66) 214.09,172.7 arc(214.06,172.79) 214,172.86 213.99,172.87 arc(213.87,172.95) 213.73,172.98 213.35,172.98 arc(213.27,172.99) 213.2,173.04 arc(213.16,173.1) 213.14,173.18 213.14,173.37 arc(213.18,173.56) 213.3,173.73 213.48,173.92 arc(213.52,173.94) 213.57,173.95 213.65,173.95 213.67,173.97
  SIG7 w0.16: YJ36.B36 377.3,56.7 arc(377.24,57.01) 377.06,57.27 376.69,57.65 arc(376.56,57.84) 376.51,58.07 376.51,58.34 arc(376.45,58.63) 376.29,58.87 376.26,58.9 arc(376.14,58.98) 375.99,59.01 364.81,59.01 arc(364.37,59.1) 364,59.35 363.36,59.99 363.1,59.99 362.75,60.34 362.75,60.6 362.36,60.99 arc(362.11,61.36) 362.02,61.8 362.02,69.31 361.84,69.49 361.84,70 362.02,70.18 362.02,70.63 361.82,70.84 361.82,71.3 362.02,71.5 362.02,71.96 361.82,72.16 361.82,72.62 362.02,72.82 362.02,75.53 361.89,75.66 361.89,76.08 362.02,76.21 362.02,77.88 arc(361.87,78.64) 361.44,79.28 303.05,137.68 arc(302.92,137.76) 302.78,137.79 287.78,137.79 arc(287.49,137.85) 287.24,138.02 249.76,175.5 arc(249.63,175.58) 249.49,175.61 233.5,175.61 arc(233.21,175.67) 232.96,175.84 232.74,176.06 arc(232.61,176.14) 232.47,176.17 216.02,176.17 arc(215.88,176.14) 215.75,176.06 213.67,173.97
FC60_TDN2: length 229.1
  TOP w0.147: U1.CD18 213.55,170.34 v4(213.6,170.34)
  SIG7 w0.112: 215.3,173.1 215.28,173.08 215.28,173 arc(215.27,172.95) 215.24,172.91 215.14,172.8 arc(215,172.6) 214.95,172.36 214.95,171.18 arc(214.94,171.1) 214.89,171.04 arc(214.83,170.99) 214.75,170.98 214.26,170.98 arc(214.12,170.95) 214.01,170.87 214,170.86 arc(213.92,170.75) 213.9,170.63 arc(213.82,170.43) 213.62,170.34 v4(213.6,170.34)
  SIG7 w0.16: 215.3,173.1 215.89,173.68 arc(216.1,173.86) 216.34,173.99 arc(216.63,174.08) 216.93,174.11 224.25,174.11 arc(224.33,174.13) 224.41,174.18 arc(224.73,174.39) 225.11,174.47 231.6,174.47 arc(231.9,174.41) 232.14,174.25 232.37,174.02 arc(232.49,173.94) 232.64,173.91 248.52,173.91 arc(248.81,173.85) 249.06,173.69 286.62,136.13 arc(286.75,136.04) 286.89,136.01 301.78,136.01 arc(302.08,135.96) 302.32,135.79 358.3,79.82 359.14,78.97 arc(359.56,78.35) 359.7,77.62 359.7,69.56 arc(359.77,69.24) 359.95,68.97 360.86,68.05 arc(361.03,67.81) 361.08,67.51 361.08,58.93 arc(361.14,58.63) 361.31,58.39 364.08,55.62 arc(364.32,55.45) 364.62,55.39 375.99,55.39 arc(376.28,55.34) 376.53,55.17 376.62,55.08 arc(376.86,54.92) 377.16,54.86 378.06,54.86 arc(378.3,54.76) 378.4,54.52 378.4,54.34 arc(378.36,54.14) 378.25,53.97 YJ36.B2
FC60_TDN3: length 228.9
  TOP w0.147: U1.CB17 214.05,167.89 arc(214.18,168.21) v4(214.5,168.34)
  SIG6 w0.112: 215.57,172.98 215.55,172.96 215.42,172.96 215.3,172.84 arc(215.19,172.67) 215.15,172.47 215.15,169.18 arc(215.12,169.03) 215.03,168.9 arc(214.9,168.81) 214.75,168.78 214.24,168.78 arc(214.17,168.77) 214.12,168.73 214.11,168.72 arc(214.08,168.68) 214.07,168.63 214.07,168.47 arc(214.11,168.38) 214.2,168.34 v4(214.5,168.34)
  SIG6 w0.16: YJ36.B6 374.9,52.74 arc(374.85,53.01) 374.69,53.24 374.29,53.65 arc(374.16,53.84) 374.11,54.07 374.11,54.48 arc(374.11,54.53) 374.1,54.58 arc(374.06,54.69) 373.99,54.77 373.95,54.82 373.86,54.9 arc(373.74,54.98) 373.59,55.01 364.35,55.01 arc(364.06,55.07) 363.81,55.24 360.93,58.12 arc(360.76,58.37) 360.7,58.66 360.7,65.89 arc(360.67,66.03) 360.59,66.16 357.78,68.97 arc(357.53,69.34) 357.44,69.78 357.44,70.26 357.22,70.48 357.22,70.96 357.44,71.18 357.44,71.66 357.22,71.89 357.22,72.37 357.44,72.59 357.44,73.07 357.22,73.29 357.22,73.77 357.44,73.99 357.44,74.47 357.22,74.69 357.22,75.17 357.44,75.39 357.44,79.82 arc(357.38,80.11) 357.22,80.36 302.17,135.41 arc(301.92,135.58) 301.63,135.63 287.05,135.63 arc(286.61,135.72) 286.24,135.97 248.79,173.42 arc(248.67,173.5) 248.52,173.53 232.84,173.53 arc(232.76,173.53) 232.67,173.54 arc(232.33,173.65) 232.03,173.87 231.92,173.98 arc(231.8,174.06) 231.65,174.09 225.08,174.09 arc(224.85,174.04) 224.65,173.91 arc(224.45,173.78) 224.22,173.73 216.94,173.73 arc(216.63,173.7) 216.34,173.61 arc(216.1,173.48) 215.89,173.3 215.57,172.98
FC60_TDP0: length 230.2
  TOP w0.147: U1.CC19 212.05,168.89 arc(212.18,169.21) v4(212.5,169.34)
  SIG6 w0.112: 213.65,174 213.52,174 213.43,173.91 213.3,173.79 arc(213.19,173.62) 213.15,173.42 213.15,170.18 arc(213.12,170.03) 213.03,169.9 arc(212.9,169.81) 212.75,169.78 212.24,169.78 arc(212.17,169.77) 212.12,169.73 212.11,169.72 arc(212.08,169.68) 212.07,169.63 212.07,169.47 arc(212.11,169.38) 212.2,169.34 v4(212.5,169.34)
  SIG6 w0.155: 374.13,57.94 arc(374.11,58) 374.11,58.07
  SIG6 w0.16: YJ36.B33 374.9,56.82 arc(374.86,57.02) 374.75,57.19 374.29,57.64 arc(374.19,57.78) 374.13,57.94 ; 374.11,58.07 374.11,58.48 arc(374.11,58.54) 374.1,58.59 arc(374.1,58.59) 374.1,58.59 arc(374.05,58.69) 373.99,58.77 373.95,58.82 373.86,58.9 arc(373.74,58.98) 373.59,59.01 364.34,59.01 arc(364.05,59.07) 363.8,59.24 362.25,60.79 arc(362.08,61.04) 362.02,61.33 362.02,68 arc(361.96,68.29) 361.8,68.54 360.19,70.15 arc(359.94,70.52) 359.85,70.96 359.85,71.44 359.63,71.66 359.63,72.14 359.85,72.36 359.85,72.84 359.63,73.06 359.63,73.54 359.85,73.76 359.85,74.24 359.63,74.46 359.63,74.94 359.85,75.16 359.85,75.64 359.63,75.86 359.63,76.34 359.85,76.56 359.85,80.71 arc(359.83,80.85) 359.74,80.98 303.04,137.68 arc(302.92,137.76) 302.77,137.79 287.94,137.79 arc(287.5,137.88) 287.13,138.13 249.76,175.5 arc(249.63,175.58) 249.49,175.61 233.63,175.61 arc(233.19,175.7) 232.82,175.95 232.71,176.06 arc(232.59,176.14) 232.44,176.17 216.13,176.17 arc(215.84,176.11) 215.59,175.95 213.65,174
FC60_TDP1: length 229.2
  TOP w0.147: U1.CF18 213.55,172.34 v4(213.6,172.34)
  SIG7 w0.112: 213.4,174.24 213.38,174.22 213.38,174.15 arc(213.37,174.1) 213.34,174.06 213.23,173.95 213.16,173.87 arc(213,173.64) 212.95,173.37 212.95,173.18 arc(212.98,173.03) 213.06,172.9 arc(213.19,172.81) 213.35,172.78 213.73,172.78 arc(213.8,172.77) 213.85,172.73 213.86,172.72 arc(213.88,172.69) 213.9,172.66 arc(213.9,172.64) 213.9,172.63 arc(213.89,172.57) 213.88,172.52 arc(213.86,172.48) 213.82,172.44 213.81,172.43 arc(213.71,172.36) v4(213.6,172.34)
  SIG7 w0.16: 213.4,174.24 215.48,176.33 arc(215.73,176.49) 216.02,176.55 232.47,176.55 arc(232.76,176.49) 233.01,176.33 233.23,176.11 arc(233.35,176.02) 233.5,175.99 249.49,175.99 arc(249.78,175.94) 250.03,175.77 287.51,138.29 arc(287.63,138.2) 287.78,138.17 302.78,138.17 arc(303.07,138.12) 303.31,137.95 361.71,79.55 arc(362.22,78.79) 362.4,77.88 362.4,61.8 arc(362.46,61.51) 362.63,61.26 364.27,59.62 arc(364.51,59.45) 364.81,59.39 375.99,59.39 arc(376.28,59.34) 376.53,59.17 376.72,58.98 arc(376.77,58.94) 376.82,58.91 arc(376.91,58.87) 377.01,58.86 378.06,58.86 arc(378.3,58.76) 378.4,58.52 378.4,58.34 arc(378.36,58.14) 378.25,57.97 YJ36.B37
FC60_TDP2: length 229.1
  TOP w0.147: U1.CD17 214.05,169.89 arc(214.18,170.21) v4(214.5,170.34)
  SIG7 w0.112: v4(214.5,170.34) 214.24,170.34 arc(214.14,170.38) 214.1,170.49 214.1,170.63 arc(214.11,170.68) 214.14,170.72 214.15,170.73 arc(214.2,170.77) 214.26,170.78 214.75,170.78 arc(214.9,170.81) 215.03,170.9 arc(215.12,171.03) 215.15,171.18 215.15,172.36 arc(215.18,172.53) 215.28,172.66 215.38,172.77 arc(215.43,172.8) 215.48,172.81 215.55,172.81 215.57,172.83
  SIG7 w0.16: 215.57,172.83 216.16,173.41 arc(216.31,173.54) 216.49,173.64 arc(216.7,173.71) 216.93,173.73 224.25,173.73 arc(224.48,173.78) 224.68,173.91 arc(224.87,174.04) 225.11,174.09 231.6,174.09 arc(231.75,174.06) 231.87,173.98 232.1,173.75 arc(232.35,173.59) 232.64,173.53 248.52,173.53 arc(248.67,173.5) 248.79,173.42 286.35,135.86 arc(286.6,135.69) 286.89,135.63 301.78,135.63 arc(301.93,135.6) 302.05,135.52 358.03,79.55 358.87,78.7 arc(359.2,78.21) 359.32,77.62 359.32,76.07 359.17,75.92 359.17,75.36 359.32,75.21 359.32,74.75 359.17,74.6 359.17,74.04 359.32,73.89 359.32,73.43 359.14,73.25 359.14,72.74 359.32,72.57 359.32,72.11 359.12,71.9 359.12,71.45 359.32,71.24 359.32,70.79 359.12,70.58 359.12,70.13 359.32,69.92 359.32,69.56 arc(359.41,69.09) 359.68,68.7 360.59,67.78 arc(360.67,67.66) 360.7,67.51 360.7,58.93 arc(360.79,58.49) 361.04,58.12 363.81,55.35 arc(364.18,55.1) 364.62,55.01 375.99,55.01 arc(376.14,54.98) 376.26,54.9 376.35,54.82 376.39,54.77 arc(376.45,54.69) 376.49,54.6 arc(376.51,54.54) 376.51,54.48 376.51,54.07 arc(376.56,53.84) 376.68,53.65 377.05,53.29 arc(377.23,53.01) 377.3,52.68 YJ36.B3
