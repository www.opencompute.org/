# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC50_RDP3: length 143
  TOP w0.147: U1.AV7 224.55,144.34 v4(224.55,144.39)
  SIG3 w0.112: v4(224.55,144.39) 224.55,144.62 arc(224.59,144.71) 224.68,144.74 224.88,144.74 arc(224.92,144.73) 224.95,144.71 arc(224.98,144.68) 224.99,144.63 224.99,143.15 arc(225.02,143) 225.1,142.86 arc(225.23,142.78) 225.39,142.75 232.1,142.75 232.19,142.66 232.22,142.66
  SIG3 w0.16: YJ33.A22 311.15,65.97 arc(311.04,66.13) 311.01,66.32 311.01,66.59 arc(311.09,66.78) 311.28,66.86 312.31,66.86 arc(312.45,66.92) 312.5,67.06 312.5,67.57 312.25,67.82 312.25,68.33 312.5,68.58 312.5,68.96 312.22,69.24 312.22,69.69 312.5,69.97 312.5,70.48 312.25,70.73 312.25,71.24 312.5,71.49 312.5,71.94 arc(312.59,72.38) 312.84,72.75 313.28,73.19 313.28,73.55 313.64,73.91 314,73.91 314.36,74.27 arc(314.45,74.4) 314.47,74.54 314.47,92.03 arc(314.45,92.18) 314.36,92.3 292.73,113.93 arc(292.61,114.01) 292.46,114.04 272.32,114.04 arc(271.88,114.13) 271.51,114.38 243.34,142.54 arc(243.22,142.63) 243.07,142.66 235.78,142.66 235.77,142.66 232.22,142.66
FC50_TDN0: length 124.6
  TOP w0.147: U1.AV4 227.07,143.84 arc(227.26,143.88) 227.41,143.98 227.49,144.06 arc(227.53,144.13) 227.55,144.21 v4(227.55,144.29)
  SIG4 w0.112: 232.22,143.03 232.19,143.03 232.1,142.94 228.46,142.94 arc(228.35,142.96) 228.26,143.02 arc(228.2,143.11) 228.18,143.21 228.18,143.59 arc(228.16,143.72) 228.08,143.84 228.08,143.84 arc(227.97,143.91) 227.83,143.94 227.68,143.94 arc(227.59,143.98) 227.55,144.07 v4(227.55,144.29)
  SIG4 w0.155: 303.31,65.97 arc(303.29,65.88) 303.25,65.8
  SIG4 w0.16: YJ33.A33 302.5,64.89 arc(302.53,65.02) 302.6,65.13 303.14,65.68 arc(303.2,65.74) 303.25,65.8 ; 303.31,65.97 303.31,68.04 arc(303.25,68.33) 303.08,68.58 297.59,74.07 arc(297.43,74.32) 297.37,74.61 297.37,95.47 arc(297.31,95.76) 297.15,96 284.86,108.29 arc(282.85,109.64) 280.48,110.11 279.97,110.11 arc(276.6,110.78) 273.74,112.69 243.62,142.8 arc(243.37,142.97) 243.08,143.03 235.78,143.03 235.77,143.03 232.22,143.03
FC50_TDN1: length 122.1
  TOP w0.147: v4(229.55,143.39) 229.55,143.34 U1.AU2
  SIG5 w0.112: 232.09,142.65 232.06,142.65 231.97,142.74 230.39,142.74 arc(230.23,142.77) 230.1,142.86 arc(230.02,142.99) 229.99,143.14 229.99,143.58 arc(229.97,143.64) 229.94,143.69 229.93,143.71 arc(229.88,143.73) 229.84,143.74 229.68,143.74 arc(229.59,143.71) 229.55,143.62 v4(229.55,143.39)
  SIG5 w0.16: 232.09,142.65 232.85,142.65 233,142.5 233.77,142.5 233.92,142.65 234.68,142.65 234.83,142.5 235.6,142.5 235.75,142.65 236.51,142.65 236.66,142.5 237.42,142.5 237.58,142.65 238.34,142.65 238.49,142.5 239.25,142.5 239.41,142.65 242.92,142.65 arc(243.21,142.59) 243.46,142.43 275.94,109.95 arc(276.19,109.78) 276.48,109.73 282.55,109.73 arc(282.84,109.67) 283.09,109.5 296.77,95.82 arc(296.93,95.57) 296.99,95.28 296.99,73.97 arc(297.08,73.54) 297.32,73.16 298.01,72.48 298.01,72.27 298.55,71.73 298.76,71.73 299.12,71.37 299.12,71.15 299.66,70.61 299.87,70.61 300.41,70.08 arc(300.5,69.95) 300.53,69.81 300.53,69.24 300.4,69.11 300.4,68.45 300.53,68.32 300.53,67.04 arc(300.47,66.91) 300.34,66.86 299.28,66.86 arc(299.09,66.78) 299.01,66.59 299.01,66.32 arc(299.04,66.13) 299.15,65.97 YJ33.A37
FC50_TDN2: length 150.6
  TOP w0.147: U1.AY5 226.07,145.84 arc(226.26,145.88) 226.41,145.98 226.49,146.06 arc(226.53,146.13) 226.55,146.21 v4(226.55,146.29)
  SIG4 w0.112: 232.09,145.03 232.06,145.03 231.97,144.94 227.46,144.94 arc(227.35,144.96) 227.26,145.02 arc(227.2,145.11) 227.18,145.21 227.18,145.59 arc(227.16,145.72) 227.08,145.84 227.08,145.84 arc(226.97,145.91) 226.83,145.94 226.68,145.94 arc(226.59,145.98) 226.55,146.07 v4(226.55,146.29)
  SIG4 w0.155: 303.31,61.97 arc(303.3,61.91) 303.28,61.84
  SIG4 w0.16: 303.31,61.97 303.31,62.57 arc(303.34,62.72) 303.43,62.86 303.48,62.91 arc(303.61,63) 303.75,63.03 312.83,63.03 arc(313.12,63.08) 313.37,63.25 313.84,63.72 arc(314,63.96) 314.06,64.25 314.06,66.52 arc(314,66.81) 313.84,67.06 313.47,67.42 arc(313.3,67.67) 313.25,67.96 313.25,73.09 arc(313.3,73.38) 313.47,73.63 314.61,74.77 arc(314.78,75.02) 314.84,75.31 314.84,85.65 arc(314.78,85.94) 314.61,86.19 298.41,102.39 arc(298.17,102.56) 297.87,102.61 293.77,102.61 arc(293.48,102.67) 293.24,102.84 285.44,110.63 arc(283.63,111.84) 281.5,112.27 280.86,112.27 arc(277.49,112.94) 274.63,114.85 244.41,145.06 arc(244.16,145.23) 243.87,145.29 233.77,145.29 arc(233.61,145.25) 233.46,145.16 arc(233.32,145.06) 233.15,145.03 232.09,145.03 ; YJ33.A6 302.5,60.75 arc(302.55,61.01) 302.7,61.23 303.19,61.72 arc(303.24,61.78) 303.28,61.84
FC50_TDN3: length 152.7
  TOP w0.147: v4(228.55,145.39) 228.55,145.34 U1.AW3
  SIG5 w0.112: 232.15,144.65 232.13,144.65 232.03,144.74 229.39,144.74 arc(229.23,144.77) 229.1,144.86 arc(229.02,144.99) 228.99,145.14 228.99,145.58 arc(228.97,145.64) 228.94,145.69 228.93,145.71 arc(228.88,145.73) 228.84,145.74 228.68,145.74 arc(228.59,145.71) 228.55,145.62 v4(228.55,145.39)
  SIG5 w0.16: YJ33.A2 299.15,61.97 arc(299.04,62.13) 299.01,62.32 299.01,62.59 arc(299.09,62.78) 299.28,62.86 300.18,62.86 arc(300.47,62.92) 300.72,63.08 300.76,63.13 300.81,63.18 arc(301.06,63.35) 301.35,63.41 312.59,63.41 arc(312.73,63.44) 312.85,63.52 313.57,64.23 arc(313.65,64.35) 313.68,64.5 313.68,66.3 arc(313.65,66.45) 313.57,66.57 312.84,67.3 312.49,67.3 312.2,67.6 312.2,67.95 311.87,68.27 311.52,68.27 311.23,68.57 311.23,68.92 310.9,69.24 310.55,69.24 310.26,69.54 310.26,69.89 309.93,70.21 309.58,70.21 309.29,70.51 309.29,70.86 308.75,71.39 arc(308.63,71.47) 308.49,71.5 304.67,71.5 arc(304.23,71.59) 303.86,71.83 300.63,75.07 arc(300.38,75.44) 300.29,75.88 300.29,99.6 arc(300.23,99.89) 300.07,100.14 298.2,102.01 arc(297.95,102.17) 297.66,102.23 293.75,102.23 arc(293.31,102.32) 292.94,102.57 283.74,111.77 arc(283.61,111.86) 283.47,111.88 277.37,111.88 arc(277.07,111.94) 276.83,112.11 244.25,144.68 arc(244.01,144.85) 243.72,144.9 234.03,144.9 arc(233.88,144.89) 233.73,144.85 233.4,144.71 arc(233.25,144.66) 233.1,144.65 232.15,144.65
FC50_TDP0: length 124.6
  TOP w0.147: U1.AU4 227.55,143.34 v4(227.55,143.39)
  SIG4 w0.112: v4(227.55,143.39) 227.55,143.62 arc(227.59,143.71) 227.68,143.74 227.83,143.74 arc(227.89,143.73) 227.94,143.7 arc(227.97,143.65) 227.99,143.59 227.99,143.21 arc(228.02,143.03) 228.12,142.88 arc(228.28,142.78) 228.46,142.74 232.11,142.74 232.2,142.65 232.22,142.65
  SIG4 w0.16: YJ33.A34 301.55,65.97 arc(301.44,66.13) 301.41,66.32 301.41,66.64 arc(301.47,66.8) 301.62,66.86 302.7,66.86 arc(302.86,66.93) 302.93,67.09 302.93,68.04 arc(302.9,68.19) 302.81,68.31 302.45,68.67 302.07,68.67 301.74,69 301.74,69.39 301.38,69.75 300.99,69.75 300.66,70.08 300.66,70.47 300.3,70.83 299.94,70.83 299.58,71.18 299.58,71.54 299.22,71.9 298.86,71.9 298.5,72.26 298.5,72.62 297.32,73.8 arc(297.08,74.17) 296.99,74.61 296.99,95.47 arc(296.96,95.61) 296.88,95.73 284.59,108.02 arc(282.7,109.28) 280.48,109.73 279.97,109.73 arc(276.45,110.43) 273.47,112.42 243.35,142.53 arc(243.23,142.62) 243.08,142.65 235.62,142.65 235.62,142.65 232.22,142.65
FC50_TDP1: length 122.1
  TOP w0.147: U1.AV2 229.1,143.84 arc(229.42,143.97) v4(229.55,144.29)
  SIG5 w0.112: v4(229.55,144.29) 229.55,144.07 arc(229.59,143.98) 229.68,143.94 229.84,143.94 arc(229.96,143.92) 230.07,143.85 230.08,143.83 arc(230.15,143.72) 230.18,143.58 230.18,143.14 arc(230.2,143.06) 230.24,143 arc(230.31,142.95) 230.39,142.94 231.97,142.94 232.06,143.03 232.09,143.03
  SIG5 w0.16: 232.09,143.03 242.92,143.03 arc(243.36,142.94) 243.73,142.69 276.21,110.22 arc(276.33,110.14) 276.48,110.11 282.55,110.11 arc(282.98,110.02) 283.35,109.77 297.04,96.09 arc(297.28,95.72) 297.37,95.28 297.37,73.97 arc(297.43,73.68) 297.59,73.43 300.68,70.35 arc(300.85,70.1) 300.91,69.81 300.91,65.97 arc(300.88,65.85) 300.81,65.75 300.36,65.3 arc(300.17,65.01) 300.1,64.66 YJ33.A36
FC50_TDP2: length 150.7
  TOP w0.147: v4(226.55,145.39) 226.55,145.34 U1.AW5
  SIG4 w0.112: v4(226.55,145.39) 226.55,145.62 arc(226.59,145.71) 226.68,145.74 226.83,145.74 arc(226.89,145.73) 226.94,145.7 arc(226.97,145.65) 226.99,145.59 226.99,145.21 arc(227.02,145.03) 227.12,144.88 arc(227.28,144.78) 227.46,144.74 231.97,144.74 232.06,144.65 232.09,144.65
  SIG4 w0.16: YJ33.A5 301.55,61.97 arc(301.44,62.13) 301.41,62.32 301.41,62.55 arc(301.5,62.77) 301.72,62.86 302.58,62.86 arc(302.87,62.92) 303.12,63.08 303.16,63.13 303.21,63.18 arc(303.46,63.35) 303.75,63.41 312.83,63.41 arc(312.98,63.44) 313.1,63.52 313.57,63.99 arc(313.65,64.11) 313.68,64.25 313.68,66.52 arc(313.65,66.66) 313.57,66.79 313.2,67.15 arc(312.95,67.53) 312.86,67.96 312.86,68.47 312.61,68.72 312.61,69.23 312.86,69.49 312.86,69.99 312.64,70.22 312.64,70.78 312.86,71.01 312.86,71.52 312.61,71.77 312.61,72.28 312.86,72.53 312.86,73.09 arc(312.95,73.53) 313.2,73.9 314.34,75.04 arc(314.42,75.16) 314.45,75.31 314.45,78.86 314.2,79.12 314.2,79.63 314.45,79.88 314.45,85.65 arc(314.42,85.8) 314.34,85.92 298.14,102.12 arc(298.02,102.2) 297.87,102.23 293.77,102.23 arc(293.34,102.32) 292.97,102.57 285.17,110.36 arc(283.49,111.49) 281.5,111.88 280.86,111.88 arc(277.34,112.58) 274.36,114.58 244.14,144.79 arc(244.02,144.88) 243.87,144.9 233.77,144.9 arc(233.75,144.9) 233.73,144.89 arc(233.47,144.71) 233.15,144.65 232.09,144.65
FC50_TDP3: length 152.7
  TOP w0.147: U1.AY3 228.1,145.84 arc(228.42,145.97) v4(228.55,146.29)
  SIG5 w0.112: 232.15,145.03 232.13,145.03 232.03,144.94 229.39,144.94 arc(229.31,144.95) 229.24,145 arc(229.2,145.06) 229.18,145.14 229.18,145.58 arc(229.15,145.72) 229.08,145.83 229.07,145.85 arc(228.96,145.92) 228.84,145.94 228.68,145.94 arc(228.59,145.98) 228.55,146.07 v4(228.55,146.29)
  SIG5 w0.16: YJ33.A3 300.1,60.83 arc(300.14,61.02) 300.24,61.18 300.81,61.75 arc(300.88,61.85) 300.91,61.97 300.91,62.57 arc(300.91,62.6) 300.91,62.64 arc(300.95,62.75) 301.03,62.86 301.08,62.91 arc(301.21,63) 301.35,63.03 312.59,63.03 arc(312.88,63.08) 313.12,63.25 313.84,63.96 arc(314,64.21) 314.06,64.5 314.06,66.3 arc(314,66.6) 313.84,66.84 309.02,71.66 arc(308.78,71.82) 308.49,71.88 304.67,71.88 arc(304.38,71.94) 304.13,72.1 300.9,75.34 arc(300.73,75.59) 300.67,75.88 300.67,75.88 300.67,99.6 arc(300.59,100.04) 300.34,100.41 298.47,102.28 arc(298.1,102.53) 297.66,102.61 293.75,102.61 arc(293.46,102.67) 293.21,102.84 284.01,112.04 arc(283.76,112.21) 283.47,112.27 277.37,112.27 arc(277.22,112.29) 277.1,112.38 244.52,144.95 arc(244.15,145.2) 243.72,145.29 234.03,145.29 arc(233.8,145.26) 233.59,145.2 233.25,145.06 arc(233.18,145.04) 233.1,145.03 232.15,145.03
FC51_RDN0: length 168.6
  TOP w0.147: v4(217.55,148.29) 217.55,148.22 arc(217.53,148.15) 217.5,148.09 217.32,147.92 arc(217.24,147.86) 217.15,147.84 U1.BB14
  SIG2 w0.112: 232.03,147.03 231.95,146.94 218.54,146.94 arc(218.4,146.97) 218.27,147.06 arc(218.19,147.18) 218.16,147.33 218.16,147.63 arc(218.13,147.75) 218.07,147.85 arc(217.97,147.92) 217.85,147.94 217.68,147.94 arc(217.59,147.98) 217.55,148.07 v4(217.55,148.29)
  SIG2 w0.16: 232.03,147.03 232.58,147.03 arc(232.66,147.04) 232.72,147.09 arc(233.03,147.3) 233.4,147.37 244.68,147.37 arc(245.12,147.28) 245.49,147.03 273.67,118.85 arc(273.79,118.77) 273.94,118.74 294.1,118.74 arc(294.54,118.66) 294.91,118.41 319.08,94.24 arc(319.33,93.87) 319.42,93.43 319.42,71.92 arc(319.36,71.62) 319.19,71.38 315.6,67.78 arc(315.44,67.54) 315.38,67.24 315.38,61.44 arc(315.29,61) 315.04,60.63 313.77,59.36 arc(313.4,59.11) 312.96,59.03 310.95,59.03 arc(310.86,59.01) 310.78,58.98 arc(310.73,58.95) 310.68,58.91 310.63,58.86 arc(310.54,58.72) 310.51,58.57 310.51,57.97 arc(310.48,57.85) 310.41,57.75 309.84,57.18 arc(309.74,57.02) 309.7,56.83 YJ33.B24
FC51_RDN1: length 162
  TOP w0.147: v4(221.55,147.39) 221.55,147.34 U1.BA10
  SIG3 w0.112: 232.34,146.65 232.25,146.75 222.57,146.75 arc(222.35,146.79) 222.16,146.92 arc(222.03,147.11) 221.99,147.33 221.99,147.63 arc(221.98,147.68) 221.95,147.71 arc(221.92,147.73) 221.88,147.74 221.68,147.74 arc(221.59,147.71) 221.55,147.62 v4(221.55,147.39)
  SIG3 w0.16: YJ33.B22 311.15,57.97 arc(311.04,58.13) 311.01,58.32 311.01,58.54 arc(311.1,58.77) 311.33,58.86 312.18,58.86 arc(312.47,58.92) 312.72,59.09 312.99,59.36 312.99,59.69 313.47,60.17 313.8,60.17 314.72,61.08 arc(314.92,61.39) 315,61.76 315,65.79 arc(315.08,66.22) 315.33,66.6 316.18,67.45 arc(316.26,67.57) 316.29,67.72 316.29,67.83 arc(316.38,68.27) 316.63,68.64 316.99,69 316.99,69.36 317.35,69.72 317.71,69.72 318.02,70.04 318.02,70.4 318.29,70.67 318.65,70.67 318.92,70.94 arc(319,71.06) 319.03,71.2 319.03,72.24 318.78,72.49 318.78,73 319.03,73.25 319.03,93.59 arc(319,93.74) 318.92,93.86 294.53,118.25 arc(294.41,118.33) 294.26,118.36 274.1,118.36 arc(273.66,118.45) 273.29,118.7 245.11,146.88 arc(244.98,146.96) 244.84,146.99 233.7,146.99 arc(233.48,146.94) 233.3,146.82 arc(233.11,146.69) 232.89,146.65 232.34,146.65
FC51_RDN2: length 174.9
  TOP w0.147: U1.BB12 219.13,147.84 arc(219.22,147.86) 219.31,147.92 219.5,148.11 arc(219.54,148.16) 219.55,148.23 v4(219.55,148.29)
  SIG2 w0.112: v4(219.55,148.29) 219.55,148.07 arc(219.59,147.98) 219.68,147.94 219.85,147.94 arc(219.89,147.95) 219.93,147.97 arc(219.95,148.01) 219.96,148.05 219.96,148.36 arc(220,148.58) 220.13,148.77 arc(220.32,148.9) 220.54,148.94 232.1,148.94 232.19,149.04 232.22,149.04
  SIG2 w0.16: 232.22,149.04 232.63,149.04 arc(232.75,149.06) 232.86,149.13 arc(233.21,149.37) 233.63,149.45 245.65,149.45 arc(246.08,149.36) 246.45,149.12 274.56,121.01 arc(274.68,120.93) 274.83,120.9 295.02,120.9 arc(295.46,120.81) 295.83,120.57 321.17,95.23 arc(321.41,94.86) 321.5,94.42 321.5,70.73 arc(321.44,70.44) 321.28,70.19 316.94,65.86 arc(316.78,65.61) 316.72,65.32 316.72,58.85 arc(316.63,58.41) 316.39,58.04 313.71,55.36 arc(313.34,55.11) 312.9,55.03 310.95,55.03 arc(310.86,55.01) 310.78,54.98 arc(310.73,54.95) 310.68,54.91 310.63,54.86 arc(310.54,54.72) 310.51,54.57 310.51,53.97 arc(310.48,53.85) 310.41,53.75 309.85,53.19 arc(309.74,53.02) 309.7,52.82 YJ33.B15
FC51_RDN3: length 168.5
  TOP w0.147: v4(223.55,147.39) 223.55,147.34 U1.BA8
  SIG3 w0.112: 231.99,148.65 231.97,148.65 231.87,148.75 224.57,148.75 arc(224.42,148.72) 224.3,148.63 arc(224.21,148.51) 224.18,148.36 224.18,148.05 arc(224.16,147.93) 224.09,147.83 arc(223.99,147.77) 223.88,147.74 223.68,147.74 arc(223.59,147.71) 223.55,147.62 v4(223.55,147.39)
  SIG3 w0.16: 231.99,148.65 232.35,148.65 arc(232.62,148.71) 232.85,148.86 arc(233.08,149.02) 233.35,149.07 245.8,149.07 arc(245.95,149.04) 246.07,148.96 274.18,120.86 arc(274.55,120.61) 274.98,120.52 295.18,120.52 arc(295.33,120.49) 295.45,120.41 321,94.86 arc(321.08,94.73) 321.11,94.59 321.11,70.68 arc(321.08,70.53) 321,70.41 316.66,66.07 arc(316.42,65.7) 316.33,65.26 316.33,60.54 316.1,60.31 316.1,59.75 316.33,59.52 316.33,59.01 arc(316.27,58.72) 316.11,58.47 315.77,58.14 315.41,58.14 315.14,57.87 315.14,57.51 314.87,57.24 314.51,57.24 314.15,56.88 314.15,56.52 313.79,56.16 313.43,56.16 313.07,55.8 313.07,55.44 312.72,55.08 arc(312.47,54.92) 312.18,54.86 311.32,54.86 arc(311.1,54.77) 311.01,54.55 311.01,54.32 arc(311.04,54.13) 311.15,53.97 YJ33.B17
FC51_RDP0: length 168.6
  TOP w0.147: U1.BA14 217.55,147.34 v4(217.55,147.39)
  SIG2 w0.112: v4(217.55,147.39) 217.55,147.62 arc(217.59,147.71) 217.68,147.74 217.85,147.74 arc(217.89,147.73) 217.93,147.71 arc(217.95,147.68) 217.96,147.63 217.96,147.33 arc(218,147.11) 218.13,146.92 arc(218.32,146.79) 218.54,146.75 231.93,146.75 232.03,146.65
  SIG2 w0.16: 232.03,146.65 232.58,146.65 arc(232.8,146.69) 232.99,146.82 arc(233.18,146.94) 233.4,146.99 244.68,146.99 arc(244.97,146.93) 245.22,146.76 273.4,118.58 arc(273.65,118.42) 273.94,118.36 294.1,118.36 arc(294.39,118.3) 294.64,118.14 318.81,93.97 arc(318.98,93.72) 319.04,93.43 319.04,93.43 319.04,73.44 318.83,73.24 318.83,72.63 319.04,72.42 319.04,71.92 arc(319.01,71.77) 318.93,71.65 318.57,71.29 318.21,71.29 317.85,70.93 317.85,70.57 317.49,70.21 317.13,70.21 316.77,69.85 316.77,69.49 316.41,69.13 316.05,69.13 315.69,68.77 315.69,68.41 315.33,68.05 arc(315.08,67.68) 315,67.24 315,61.44 arc(314.94,61.15) 314.77,60.9 313.5,59.63 arc(313.26,59.46) 312.96,59.41 310.95,59.41 arc(310.77,59.38) 310.6,59.32 arc(310.5,59.26) 310.41,59.18 310.36,59.13 310.32,59.08 arc(310.07,58.92) 309.78,58.86 308.86,58.86 arc(308.68,58.79) 308.61,58.61 308.61,58.32 arc(308.64,58.13) 308.75,57.97 YJ33.B25
FC51_RDP1: length 162
  TOP w0.147: v4(221.55,148.29) 221.44,148.29 arc(221.34,148.27) 221.26,148.21 221.17,148.12 arc(221.08,147.99) U1.BB10
  SIG3 w0.112: 232.34,147.03 232.26,146.94 222.57,146.94 arc(222.42,146.97) 222.3,147.06 arc(222.21,147.18) 222.18,147.33 222.18,147.63 arc(222.16,147.75) 222.09,147.85 arc(221.99,147.92) 221.88,147.94 221.68,147.94 arc(221.59,147.98) 221.55,148.07 v4(221.55,148.29)
  SIG3 w0.16: 232.34,147.03 232.89,147.03 arc(232.96,147.04) 233.03,147.09 arc(233.34,147.3) 233.7,147.37 244.84,147.37 arc(245.13,147.31) 245.38,147.14 273.56,118.97 arc(273.8,118.8) 274.1,118.74 294.26,118.74 arc(294.55,118.68) 294.8,118.52 319.19,94.13 arc(319.36,93.88) 319.41,93.59 319.41,71.2 arc(319.36,70.91) 319.19,70.67 316.9,68.37 arc(316.73,68.13) 316.67,67.83 316.67,67.72 arc(316.62,67.42) 316.45,67.18 315.6,66.33 arc(315.44,66.08) 315.38,65.79 315.38,61.76 arc(315.28,61.25) 314.99,60.82 313.02,58.85 arc(312.94,58.72) 312.91,58.57 312.91,57.97 arc(312.88,57.85) 312.81,57.75 312.29,57.22 arc(312.28,57.22) 312.28,57.21 arc(312.15,57.01) 312.1,56.77 YJ33.B21
FC51_RDP2: length 174.9
  TOP w0.147: U1.BA12 219.55,147.34 v4(219.55,147.39)
  SIG2 w0.112: 232.22,148.65 232.19,148.65 232.1,148.75 220.54,148.75 arc(220.4,148.72) 220.27,148.63 arc(220.19,148.51) 220.16,148.36 220.16,148.05 arc(220.13,147.93) 220.07,147.83 arc(219.97,147.77) 219.85,147.74 219.68,147.74 arc(219.59,147.71) 219.55,147.62 v4(219.55,147.39)
  SIG2 w0.16: 232.22,148.65 232.63,148.65 arc(232.9,148.71) 233.13,148.86 arc(233.36,149.02) 233.63,149.07 245.65,149.07 arc(245.94,149.01) 246.18,148.85 274.29,120.74 arc(274.53,120.58) 274.83,120.52 295.02,120.52 arc(295.31,120.46) 295.56,120.3 320.9,94.96 arc(321.06,94.72) 321.12,94.42 321.12,70.73 arc(321.09,70.59) 321.01,70.46 319.91,69.36 319.57,69.36 319.19,68.98 319.19,68.64 318.83,68.29 318.5,68.29 318.11,67.9 318.11,67.57 317.75,67.21 317.75,67.21 317.03,66.49 316.68,66.13 arc(316.43,65.76) 316.34,65.32 316.34,58.85 arc(316.28,58.56) 316.12,58.31 315.59,57.79 315.24,57.79 314.88,57.43 314.88,57.07 314.52,56.71 314.16,56.71 313.8,56.35 313.8,55.99 313.44,55.63 arc(313.19,55.46) 312.9,55.41 310.95,55.41 arc(310.77,55.38) 310.6,55.32 arc(310.5,55.26) 310.41,55.18 310.36,55.13 310.32,55.08 arc(310.07,54.92) 309.78,54.86 308.9,54.86 arc(308.69,54.78) 308.61,54.57 308.61,54.32 arc(308.64,54.13) 308.75,53.97 YJ33.B14
FC51_RDP3: length 168.5
  TOP w0.147: v4(223.55,148.29) 223.44,148.29 arc(223.34,148.27) 223.26,148.21 223.17,148.12 arc(223.08,147.99) U1.BB8
  SIG3 w0.112: v4(223.55,148.29) 223.55,148.07 arc(223.59,147.98) 223.68,147.94 223.88,147.94 arc(223.92,147.95) 223.95,147.97 arc(223.98,148.01) 223.99,148.05 223.99,148.36 arc(224.03,148.58) 224.16,148.77 arc(224.35,148.9) 224.57,148.94 231.88,148.94 231.97,149.04 231.99,149.04
  SIG3 w0.16: 231.99,149.04 232.35,149.04 arc(232.47,149.06) 232.58,149.13 arc(232.93,149.37) 233.35,149.45 245.8,149.45 arc(246.1,149.39) 246.34,149.23 274.45,121.12 arc(274.69,120.96) 274.98,120.9 295.18,120.9 arc(295.47,120.84) 295.72,120.68 321.27,95.13 arc(321.44,94.88) 321.49,94.59 321.49,70.68 arc(321.44,70.38) 321.27,70.14 316.93,65.8 arc(316.77,65.55) 316.71,65.26 316.71,59.01 arc(316.62,58.58) 316.37,58.21 313.03,54.86 arc(312.94,54.72) 312.91,54.57 312.91,53.97 arc(312.88,53.85) 312.81,53.75 312.28,53.21 arc(312.27,53.21) 312.27,53.2 arc(312.14,53.01) 312.1,52.79 YJ33.B18
FC51_TDN0: length 167.7
  TOP w0.147: U1.BA2 229.55,147.34 v4(229.55,147.39)
  SIG5 w0.112: 232.12,148.65 232.09,148.65 232,148.75 230.39,148.75 arc(230.31,148.73) 230.24,148.69 arc(230.2,148.62) 230.18,148.54 230.18,148.11 arc(230.15,147.97) 230.08,147.85 230.07,147.84 arc(229.96,147.77) 229.84,147.74 229.68,147.74 arc(229.59,147.71) 229.55,147.62 v4(229.55,147.39)
  SIG5 w0.16: 232.12,148.65 233.01,148.65 arc(233.28,148.71) 233.51,148.86 arc(233.74,149.02) 234.01,149.07 245.65,149.07 arc(245.94,149.01) 246.18,148.85 278.61,116.43 arc(278.85,116.26) 279.14,116.2 293.19,116.2 arc(293.49,116.14) 293.73,115.98 316.42,93.29 arc(316.59,93.04) 316.65,92.75 316.65,85.05 316.52,84.92 316.52,84.16 316.65,84.04 316.65,83.27 316.52,83.15 316.52,82.38 316.65,82.26 316.65,81.5 316.52,81.37 316.52,80.61 316.65,80.48 316.65,79.72 316.52,79.59 316.52,78.83 316.65,78.7 316.65,77.94 316.52,77.81 316.52,77.05 316.65,76.92 316.65,76.16 316.52,76.03 316.52,75.27 316.65,75.15 316.65,74.38 316.52,74.26 316.52,73.49 316.65,73.37 316.65,72.61 arc(316.73,72.17) 316.98,71.8 317.2,71.58 arc(317.28,71.46) 317.31,71.31 317.31,69.75 317.21,69.64 317.21,68.78 317.31,68.68 317.31,67.62 arc(317.25,67.33) 317.09,67.08 316.54,66.54 arc(316.37,66.29) 316.32,66 316.32,58.88 arc(316.29,58.74) 316.2,58.61 313.11,55.52 arc(312.99,55.44) 312.84,55.41 301.35,55.41 arc(301.06,55.35) 300.81,55.18 300.76,55.13 300.72,55.08 arc(300.47,54.92) 300.18,54.86 299.28,54.86 arc(299.09,54.78) 299.01,54.59 299.01,54.32 arc(299.04,54.13) 299.15,53.97 YJ33.B2
FC51_TDN1: length 159.4
  TOP w0.147: U1.BB4 227.07,147.84 arc(227.26,147.88) 227.41,147.98 227.49,148.06 arc(227.53,148.13) 227.55,148.21 v4(227.55,148.29)
  SIG4 w0.112: 232.15,147.03 232.12,147.03 232.03,146.94 228.46,146.94 arc(228.35,146.96) 228.26,147.02 arc(228.2,147.11) 228.18,147.21 228.18,147.59 arc(228.16,147.72) 228.08,147.84 228.08,147.84 arc(227.97,147.91) 227.83,147.94 227.68,147.94 arc(227.59,147.98) 227.55,148.07 v4(227.55,148.29)
  SIG4 w0.16: YJ33.B33 302.5,56.84 arc(302.54,57.02) 302.64,57.17 303.21,57.75 arc(303.28,57.85) 303.31,57.97 303.31,58.57 arc(303.34,58.72) 303.43,58.86 303.48,58.91 arc(303.61,59) 303.75,59.03 313.28,59.03 arc(313.58,59.08) 313.82,59.25 315.16,60.58 arc(315.32,60.83) 315.38,61.12 315.38,68.87 arc(315.44,69.16) 315.6,69.41 316.71,70.51 arc(316.87,70.76) 316.93,71.05 316.93,89.93 arc(316.87,90.22) 316.71,90.47 292.98,114.2 arc(292.73,114.37) 292.44,114.42 286.83,114.42 arc(278.79,116.02) 271.97,120.58 245.4,147.14 arc(245.16,147.31) 244.86,147.37 233.7,147.37 arc(233.48,147.32) 233.29,147.2 arc(233.11,147.07) 232.89,147.03 232.15,147.03
FC51_TDN2: length 169.8
  TOP w0.147: U1.BA6 225.55,147.34 v4(225.55,147.39)
  SIG4 w0.112: v4(225.55,147.39) 225.55,147.62 arc(225.59,147.71) 225.68,147.74 225.83,147.74 arc(225.97,147.77) 226.08,147.85 arc(226.16,147.96) 226.18,148.09 226.18,148.47 arc(226.2,148.58) 226.26,148.66 arc(226.35,148.73) 226.46,148.75 231.97,148.75 232.06,148.65 232.09,148.65
  SIG4 w0.16: YJ33.B5 301.55,53.97 arc(301.44,54.13) 301.41,54.32 301.41,54.54 arc(301.5,54.77) 301.72,54.86 302.58,54.86 arc(302.67,54.87) 302.77,54.89 arc(302.95,54.96) 303.12,55.08 303.16,55.13 303.21,55.18 arc(303.46,55.35) 303.75,55.41 313.09,55.41 arc(313.24,55.44) 313.36,55.52 313.72,55.88 313.72,56.21 314.11,56.6 314.44,56.6 314.8,56.96 314.8,57.29 315.19,57.67 315.52,57.67 316.2,58.36 arc(316.29,58.48) 316.32,58.63 316.32,67.14 arc(316.4,67.58) 316.65,67.95 318.93,70.22 arc(319.01,70.35) 319.04,70.49 319.04,71 318.78,71.26 318.78,71.76 319.04,72.02 319.04,72.53 318.78,72.78 318.78,73.29 319.04,73.54 319.04,90.54 arc(319.01,90.69) 318.93,90.81 293.65,116.09 arc(293.52,116.17) 293.38,116.2 290.26,116.2 arc(279.72,118.3) 270.79,124.27 268.36,126.69 246.1,148.96 arc(245.97,149.04) 245.83,149.07 233.22,149.07 arc(233.09,149.05) 232.99,148.97 232.93,148.91 arc(232.64,148.72) 232.3,148.65 232.09,148.65
FC51_TDN3: length 158
  TOP w0.147: U1.AY1 230.1,145.84 arc(230.42,145.97) v4(230.55,146.29)
  SIG5 w0.112: v4(230.55,146.29) 230.55,146.07 arc(230.59,145.98) 230.68,145.94 230.84,145.94 arc(230.88,145.95) 230.93,145.98 230.94,145.99 arc(230.97,146.04) 230.99,146.11 230.99,146.54 arc(231.02,146.7) 231.1,146.83 arc(231.23,146.91) 231.39,146.94 231.86,146.94 231.95,147.04 231.98,147.04
  SIG5 w0.16: YJ33.B36 300.1,56.83 arc(300.14,57.02) 300.24,57.18 300.81,57.75 arc(300.88,57.85) 300.91,57.97 300.91,58.57 arc(300.91,58.6) 300.91,58.63 arc(300.95,58.75) 301.03,58.86 301.08,58.91 arc(301.21,59) 301.35,59.03 312.65,59.03 arc(312.94,59.08) 313.19,59.25 315.16,61.22 arc(315.32,61.46) 315.38,61.75 315.38,68.16 arc(315.32,68.45) 315.16,68.7 315.06,68.8 arc(314.89,69.05) 314.83,69.34 314.83,91.9 arc(314.75,92.33) 314.5,92.71 293.11,114.09 arc(292.74,114.34) 292.31,114.42 278.26,114.42 arc(278.11,114.45) 277.99,114.54 245.49,147.03 arc(245.12,147.28) 244.68,147.37 233.75,147.37 arc(233.39,147.3) 233.08,147.09 arc(233.02,147.05) 232.95,147.04 231.98,147.04
FC51_TDP0: length 167.7
  TOP w0.147: U1.BB2 229.1,147.84 arc(229.42,147.97) v4(229.55,148.29)
  SIG5 w0.112: 232.12,149.04 232.09,149.04 232,148.94 230.39,148.94 arc(230.23,148.91) 230.1,148.83 arc(230.02,148.7) 229.99,148.54 229.99,148.11 arc(229.97,148.04) 229.94,147.99 229.93,147.98 arc(229.88,147.95) 229.84,147.94 229.68,147.94 arc(229.59,147.98) 229.55,148.07 v4(229.55,148.29)
  SIG5 w0.16: YJ33.B3 300.1,52.87 arc(300.13,53.02) 300.22,53.15 300.81,53.75 arc(300.88,53.85) 300.91,53.97 300.91,54.57 arc(300.91,54.6) 300.91,54.63 arc(300.95,54.75) 301.03,54.86 301.08,54.91 arc(301.21,55) 301.35,55.03 312.84,55.03 arc(313.13,55.08) 313.38,55.25 316.47,58.34 arc(316.64,58.59) 316.7,58.88 316.7,66 arc(316.73,66.14) 316.81,66.27 317.36,66.81 arc(317.6,67.19) 317.69,67.62 317.69,71.31 arc(317.63,71.6) 317.47,71.85 317.25,72.07 arc(317.08,72.31) 317.03,72.61 317.03,72.61 317.03,92.75 arc(316.94,93.19) 316.69,93.56 294,116.25 arc(293.63,116.5) 293.19,116.58 279.14,116.58 arc(279,116.61) 278.87,116.7 246.45,149.12 arc(246.08,149.36) 245.65,149.45 234.01,149.45 arc(233.59,149.37) 233.24,149.13 arc(233.13,149.06) 233.01,149.04 232.12,149.04
FC51_TDP1: length 159.4
  TOP w0.147: U1.BA4 227.55,147.34 v4(227.55,147.39)
  SIG4 w0.112: 232.15,146.65 232.12,146.65 232.03,146.74 228.46,146.74 arc(228.28,146.78) 228.12,146.88 arc(228.02,147.03) 227.99,147.21 227.99,147.59 arc(227.97,147.65) 227.94,147.7 arc(227.89,147.73) 227.83,147.74 227.68,147.74 arc(227.59,147.71) 227.55,147.62 v4(227.55,147.39)
  SIG4 w0.16: YJ33.B34 301.55,57.97 arc(301.44,58.13) 301.41,58.32 301.41,58.6 arc(301.48,58.78) 301.67,58.86 302.58,58.86 arc(302.87,58.92) 303.12,59.08 303.16,59.13 303.21,59.18 arc(303.46,59.35) 303.75,59.41 313.28,59.41 arc(313.43,59.44) 313.55,59.52 313.93,59.89 313.93,60.24 314.26,60.58 314.61,60.58 314.89,60.85 arc(314.97,60.97) 315,61.12 315,61.63 314.77,61.86 314.77,62.42 315,62.64 315,68.87 arc(315.08,69.31) 315.33,69.68 316.44,70.78 arc(316.52,70.91) 316.55,71.05 316.55,71.56 316.3,71.82 316.3,72.32 316.55,72.58 316.55,73.09 316.3,73.34 316.3,73.85 316.55,74.1 316.55,89.93 arc(316.52,90.08) 316.44,90.2 292.71,113.93 arc(292.58,114.01) 292.44,114.04 286.83,114.04 arc(278.64,115.67) 271.7,120.31 245.13,146.88 arc(245.01,146.96) 244.86,146.99 233.7,146.99 arc(233.63,146.97) 233.56,146.93 arc(233.25,146.72) 232.89,146.65 232.15,146.65
FC51_TDP2: length 169.8
  TOP w0.147: U1.BB6 225.07,147.84 arc(225.26,147.88) 225.41,147.98 225.49,148.06 arc(225.53,148.13) 225.55,148.21 v4(225.55,148.29)
  SIG4 w0.112: 232.09,149.04 232.06,149.04 231.97,148.94 226.46,148.94 arc(226.28,148.91) 226.12,148.8 arc(226.02,148.65) 225.99,148.47 225.99,148.09 arc(225.97,148.04) 225.94,147.99 arc(225.89,147.95) 225.83,147.94 225.68,147.94 arc(225.59,147.98) 225.55,148.07 v4(225.55,148.29)
  SIG4 w0.16: 232.09,149.04 232.3,149.04 arc(232.49,149.07) 232.66,149.18 232.72,149.24 arc(232.95,149.4) 233.22,149.45 245.83,149.45 arc(246.12,149.39) 246.37,149.23 268.63,126.96 271.06,124.54 arc(279.87,118.65) 290.26,116.58 293.38,116.58 arc(293.67,116.53) 293.92,116.36 319.19,91.08 arc(319.36,90.83) 319.42,90.54 319.42,70.49 arc(319.36,70.2) 319.19,69.95 316.92,67.68 arc(316.75,67.43) 316.7,67.14 316.7,58.63 arc(316.64,58.34) 316.47,58.09 313.63,55.25 arc(313.39,55.08) 313.09,55.03 303.75,55.03 arc(303.61,55) 303.48,54.91 303.43,54.86 arc(303.34,54.72) 303.31,54.57 303.31,54.14 arc(303.25,53.86) 303.09,53.63 302.66,53.2 arc(302.54,53.02) 302.5,52.8 YJ33.B6
FC51_TDP3: length 158
  TOP w0.147: U1.AW1 230.55,145.34 v4(230.55,145.39)
  SIG5 w0.112: v4(230.55,145.39) 230.55,145.62 arc(230.59,145.71) 230.68,145.74 230.84,145.74 arc(230.96,145.77) 231.07,145.84 231.08,145.85 arc(231.15,145.97) 231.18,146.11 231.18,146.54 arc(231.2,146.62) 231.24,146.69 arc(231.31,146.73) 231.39,146.75 231.86,146.75 231.95,146.65 231.98,146.65
  SIG5 w0.16: 231.98,146.65 232.95,146.65 arc(233.16,146.7) 233.35,146.82 arc(233.53,146.94) 233.75,146.99 244.68,146.99 arc(244.97,146.93) 245.22,146.76 277.72,114.27 arc(277.96,114.1) 278.26,114.04 292.31,114.04 arc(292.6,113.99) 292.84,113.82 314.23,92.44 arc(314.39,92.19) 314.45,91.9 314.45,73.45 314.2,73.2 314.2,72.79 314.45,72.54 314.45,72.08 314.2,71.83 314.2,71.42 314.45,71.17 314.45,70.71 314.2,70.46 314.2,70.05 314.45,69.8 314.45,69.34 arc(314.54,68.9) 314.79,68.53 314.89,68.43 arc(314.97,68.31) 315,68.16 315,61.75 arc(314.97,61.61) 314.89,61.49 314.56,61.16 314.24,61.16 313.92,60.84 313.92,60.52 312.92,59.52 arc(312.79,59.44) 312.65,59.41 301.35,59.41 arc(301.06,59.35) 300.81,59.18 300.76,59.13 300.72,59.08 arc(300.47,58.92) 300.18,58.86 299.28,58.86 arc(299.09,58.78) 299.01,58.59 299.01,58.32 arc(299.04,58.13) 299.15,57.97 YJ33.B37
FC52_53_PVDD0P8: length 4.7
  TOP w0.229: U1.BA18 v1(213.55,147.34) ; U1.BC18 v1(213.55,149.34)
  TOP w0.381: 239.62,163.04 C2785.1 ; C2785.1 240.82,163.04 ; C2785.1 240.22,163.68
  BOTTOM w0.381: v1(213.55,149.34) 214.03,148.86 C3333.1 ; C2742.1 213.07,146.86 v1(213.55,147.34)
  vias: v1(239.71,164.21) v1(240.73,164.21)
FC52_RDN0: length 165.9
  TOP w0.147: v4(218.55,150.39) 218.55,150.34 U1.BD13
  SIG8 w0.112: v4(218.55,150.39) 218.55,150.64 arc(218.58,150.71) 218.65,150.74 218.87,150.74 arc(218.99,150.77) 219.09,150.84 arc(219.16,150.94) 219.18,151.06 219.18,151.43 arc(219.2,151.53) 219.25,151.61 219.29,151.64 arc(219.4,151.72) 219.54,151.74 225.62,151.74 arc(225.75,151.72) 225.85,151.65 arc(225.92,151.54) 225.95,151.42 225.95,151.23 arc(225.98,151.06) 226.08,150.92 226.1,150.9 arc(226.27,150.78) 226.47,150.74 231.84,150.74 231.94,150.65 231.96,150.65
  SIG8 w0.16: YJ34.B24 320.7,56.74 arc(320.65,57.01) 320.5,57.24 320.14,57.59 arc(319.97,57.85) 319.91,58.15 319.91,58.42 arc(319.9,58.53) 319.87,58.63 arc(319.82,58.73) 319.75,58.82 319.66,58.9 arc(319.54,58.98) 319.39,59.01 317.76,59.01 arc(317.32,59.1) 316.95,59.35 315.35,60.95 arc(315.1,61.32) 315.01,61.76 315.01,66.98 arc(314.98,67.12) 314.9,67.25 314.6,67.55 arc(314.35,67.92) 314.26,68.36 314.26,70.49 arc(314.35,70.93) 314.6,71.3 316.44,73.14 arc(316.52,73.26) 316.55,73.41 316.55,74.06 316.29,74.32 316.29,74.83 316.55,75.08 316.55,75.59 316.29,75.84 316.29,76.35 316.55,76.6 316.55,92.9 arc(316.49,93.19) 316.32,93.44 293.78,115.98 arc(293.54,116.14) 293.25,116.2 279.14,116.2 arc(278.85,116.26) 278.61,116.43 246.18,148.85 arc(245.94,149.01) 245.65,149.07 235.94,149.07 arc(235.5,149.16) 235.13,149.4 234,150.54 arc(233.87,150.62) 233.73,150.65 231.96,150.65
FC52_RDN1: length 161.1
  TOP w0.147: U1.BE9 222.16,150.84 arc(222.27,150.86) 222.35,150.92 222.43,150.99 arc(222.52,151.13) v4(222.55,151.29)
  SIG9 w0.112: v4(222.55,151.29) 222.55,151.04 arc(222.58,150.97) 222.65,150.94 222.87,150.94 arc(222.99,150.92) 223.09,150.85 arc(223.16,150.75) 223.18,150.63 223.18,149.2 arc(223.2,149.1) 223.26,149.02 arc(223.35,148.96) 223.45,148.94 231.76,148.94 arc(231.87,148.96) 231.97,149.03
  SIG9 w0.16: 231.97,149.03 232.45,149.03 arc(232.89,148.94) 233.26,148.69 234.5,147.45 arc(234.62,147.37) 234.77,147.34 250.8,147.34 arc(251.24,147.26) 251.61,147.01 253.81,144.81 281.78,116.84 284.08,114.54 arc(284.21,114.45) 284.35,114.42 292.36,114.42 arc(292.79,114.34) 293.16,114.09 314.51,92.74 arc(314.76,92.37) 314.85,91.93 314.85,77.1 arc(314.79,76.81) 314.62,76.56 313.16,75.1 arc(313,74.85) 312.94,74.56 312.94,67.58 arc(313,67.29) 313.16,67.04 313.66,66.54 arc(313.91,66.17) 314,65.73 314,59.02 arc(314.06,58.73) 314.22,58.48 317.62,55.08 arc(317.78,54.96) 317.98,54.88 arc(318.07,54.87) 318.16,54.86 319.06,54.86 arc(319.3,54.76) 319.4,54.52 319.4,54.34 arc(319.36,54.14) 319.25,53.97 YJ34.B17
FC52_RDN2: length 165.4
  TOP w0.147: U1.BD11 220.55,150.34 v4(220.55,150.39)
  SIG8 w0.112: 233.03,146.96 233,146.96 232.91,147.05 232.72,147.05 arc(232.43,147.11) 232.18,147.28 230.94,148.52 arc(230.69,148.69) 230.4,148.75 221.42,148.75 arc(221.25,148.78) 221.11,148.87 arc(221.02,149.01) 220.99,149.18 220.99,150.63 arc(220.98,150.68) 220.95,150.71 arc(220.92,150.73) 220.88,150.74 220.65,150.74 arc(220.58,150.71) 220.55,150.64 v4(220.55,150.39)
  SIG8 w0.16: YJ34.B15 320.7,52.68 arc(320.63,53.01) 320.45,53.29 320.11,53.63 arc(319.96,53.84) 319.91,54.1 319.91,54.48 arc(319.91,54.54) 319.89,54.61 arc(319.85,54.7) 319.79,54.77 319.75,54.81 319.75,54.82 319.66,54.9 arc(319.54,54.98) 319.39,55.01 317.95,55.01 arc(317.51,55.1) 317.14,55.35 313.95,58.53 arc(313.7,58.91) 313.62,59.34 313.62,65.96 arc(313.59,66.11) 313.51,66.23 312.69,67.04 arc(312.44,67.41) 312.36,67.85 312.36,68.36 312.1,68.61 312.1,69.12 312.36,69.38 312.36,69.88 312.1,70.14 312.1,70.65 312.36,70.9 312.36,71.51 arc(312.44,71.94) 312.69,72.32 314.35,73.98 arc(314.44,74.1) 314.46,74.25 314.46,91.88 arc(314.41,92.17) 314.24,92.42 292.84,113.82 arc(292.59,113.99) 292.3,114.04 278.26,114.04 arc(277.96,114.1) 277.72,114.27 245.24,146.74 arc(245,146.9) 244.71,146.96 233.03,146.96
FC52_RDN3: length 155.6
  TOP w0.147: U1.BE7 224.16,150.84 arc(224.27,150.86) 224.35,150.92 224.43,150.99 arc(224.52,151.13) v4(224.55,151.29)
  SIG9 w0.112: v4(224.55,151.29) 224.68,151.16 arc(224.92,151) 225.22,150.94 231.74,150.94 arc(231.86,150.96) 231.97,151.03
  SIG9 w0.16: 231.97,151.03 233.65,151.03 arc(233.94,150.97) 234.19,150.81 235.32,149.67 arc(235.57,149.51) 235.86,149.45 251.74,149.45 arc(252.18,149.36) 252.55,149.12 253.81,147.86 284.97,116.7 arc(285.09,116.61) 285.24,116.58 293.25,116.58 arc(293.68,116.5) 294.05,116.25 316.59,93.71 arc(316.84,93.34) 316.93,92.9 316.93,76.01 arc(316.87,75.71) 316.71,75.47 315.49,74.25 arc(315.33,74) 315.27,73.71 315.27,61.75 arc(315.33,61.46) 315.49,61.21 317.62,59.08 arc(317.87,58.92) 318.16,58.86 319.06,58.86 arc(319.3,58.76) 319.4,58.52 319.4,58.34 arc(319.36,58.14) 319.25,57.97 YJ34.B22
FC52_RDP0: length 165.9
  TOP w0.147: v4(218.55,151.29) 218.55,151.21 arc(218.53,151.13) 218.49,151.06 218.41,150.98 arc(218.25,150.88) 218.07,150.84 U1.BE13
  SIG8 w0.112: v4(218.55,151.29) 218.55,151.04 arc(218.58,150.97) 218.65,150.94 218.87,150.94 arc(218.91,150.95) 218.95,150.97 arc(218.98,151.01) 218.99,151.06 218.99,151.43 arc(219.02,151.6) 219.12,151.75 219.15,151.78 arc(219.33,151.9) 219.54,151.94 225.62,151.94 arc(225.82,151.9) 225.99,151.79 arc(226.1,151.62) 226.14,151.42 226.14,151.23 226.14,151.23 arc(226.16,151.14) 226.22,151.05 226.24,151.03 arc(226.34,150.96) 226.47,150.94 231.84,150.94 231.94,151.03 231.96,151.03
  SIG8 w0.16: YJ34.B25 321.65,57.97 arc(321.78,58.17) 321.83,58.39 321.83,58.43 arc(321.8,58.57) 321.72,58.69 arc(321.53,58.82) 321.3,58.86 320.42,58.86 arc(320.39,58.86) 320.35,58.87 arc(320.27,58.89) 320.2,58.92 arc(320.16,58.95) 320.11,58.99 319.93,59.17 arc(319.68,59.34) 319.39,59.39 317.76,59.39 arc(317.46,59.45) 317.22,59.62 315.62,61.22 arc(315.45,61.46) 315.39,61.76 315.39,66.98 arc(315.34,67.27) 315.17,67.52 314.87,67.82 arc(314.7,68.07) 314.64,68.36 314.64,70.49 arc(314.7,70.78) 314.87,71.03 316.71,72.87 arc(316.87,73.12) 316.93,73.41 316.93,92.9 arc(316.84,93.34) 316.59,93.71 294.05,116.25 arc(293.68,116.5) 293.25,116.58 279.14,116.58 arc(279,116.61) 278.87,116.7 246.45,149.12 arc(246.08,149.36) 245.65,149.45 235.94,149.45 arc(235.65,149.51) 235.4,149.67 234.27,150.81 arc(234.02,150.97) 233.73,151.03 231.96,151.03
FC52_RDP1: length 161.1
  TOP w0.147: U1.BD9 222.55,150.34 v4(222.55,150.39)
  SIG9 w0.112: v4(222.55,150.39) 222.55,150.64 arc(222.58,150.71) 222.65,150.74 222.87,150.74 arc(222.91,150.73) 222.95,150.71 arc(222.98,150.67) 222.99,150.63 222.99,149.2 arc(223.02,149.03) 223.12,148.88 arc(223.27,148.78) 223.45,148.74 231.73,148.74 arc(231.86,148.72) 231.97,148.65
  SIG9 w0.16: YJ34.B18 318.3,52.86 arc(318.27,53.02) 318.18,53.16 317.7,53.64 arc(317.56,53.84) 317.51,54.09 317.51,54.48 arc(317.51,54.54) 317.49,54.61 arc(317.45,54.7) 317.39,54.77 317.35,54.82 313.95,58.21 arc(313.7,58.58) 313.62,59.02 313.62,65.73 arc(313.56,66.02) 313.39,66.27 312.89,66.77 arc(312.65,67.14) 312.56,67.58 312.56,68.09 312.31,68.34 312.31,68.85 312.56,69.1 312.56,69.61 312.31,69.86 312.31,70.37 312.56,70.63 312.56,74.56 arc(312.65,75) 312.89,75.37 314.35,76.83 arc(314.44,76.95) 314.46,77.1 314.46,91.93 314.46,91.93 arc(314.41,92.23) 314.24,92.47 292.9,113.82 arc(292.65,113.99) 292.36,114.04 284.35,114.04 arc(284.06,114.1) 283.81,114.27 281.24,116.84 253.81,144.27 251.34,146.74 arc(251.09,146.9) 250.8,146.96 234.77,146.96 arc(234.47,147.02) 234.23,147.19 232.99,148.42 arc(232.74,148.59) 232.45,148.65 231.97,148.65
FC52_RDP2: length 165.4
  TOP w0.147: U1.BE11 220.07,150.84 arc(220.25,150.88) 220.41,150.98 220.49,151.06 arc(220.53,151.13) 220.55,151.21 v4(220.55,151.29)
  SIG8 w0.112: 233.03,147.34 233,147.34 232.91,147.25 232.72,147.25 arc(232.51,147.29) 232.32,147.42 231.08,148.66 arc(230.77,148.87) 230.4,148.94 221.42,148.94 arc(221.33,148.96) 221.25,149.01 arc(221.2,149.09) 221.18,149.18 221.18,150.63 arc(221.16,150.75) 221.09,150.85 arc(220.99,150.92) 220.88,150.94 220.65,150.94 arc(220.58,150.97) 220.55,151.04 v4(220.55,151.29)
  SIG8 w0.16: 233.03,147.34 244.71,147.34 arc(245.14,147.26) 245.51,147.01 277.99,114.54 arc(278.11,114.45) 278.26,114.42 292.3,114.42 arc(292.74,114.34) 293.11,114.09 314.51,92.69 arc(314.76,92.32) 314.85,91.88 314.85,74.25 arc(314.79,73.96) 314.62,73.71 312.96,72.05 arc(312.8,71.8) 312.74,71.51 312.74,67.85 arc(312.8,67.56) 312.96,67.31 313.77,66.5 arc(313.94,66.25) 314,65.96 314,59.34 arc(314.06,59.05) 314.22,58.8 317.41,55.62 arc(317.65,55.45) 317.95,55.39 319.39,55.39 arc(319.68,55.34) 319.93,55.17 320.11,54.99 arc(320.25,54.89) 320.42,54.86 321.4,54.86 arc(321.55,54.83) 321.68,54.75 321.68,54.75 arc(321.77,54.61) 321.8,54.45 321.8,54.34 arc(321.76,54.14) 321.65,53.97 YJ34.B14
FC52_RDP3: length 155.6
  TOP w0.147: U1.BD7 224.55,150.34 v4(224.55,150.39)
  SIG9 w0.112: v4(224.55,150.39) 224.68,150.52 arc(224.92,150.69) 225.22,150.74 231.72,150.74 arc(231.84,150.72) 231.94,150.65
  SIG9 w0.16: 231.94,150.65 233.65,150.65 arc(233.8,150.62) 233.92,150.54 235.05,149.4 arc(235.43,149.16) 235.86,149.07 251.74,149.07 arc(252.03,149.01) 252.28,148.85 253.81,147.32 284.29,116.84 284.7,116.43 arc(284.95,116.26) 285.24,116.2 293.25,116.2 arc(293.54,116.14) 293.78,115.98 316.32,93.44 arc(316.49,93.19) 316.55,92.9 316.55,76.01 arc(316.52,75.86) 316.44,75.74 315.22,74.52 arc(314.97,74.15) 314.89,73.71 314.89,70.48 314.63,70.23 314.63,69.72 314.89,69.47 314.89,68.96 314.63,68.7 314.63,68.2 314.89,67.94 314.89,61.75 arc(314.97,61.31) 315.22,60.94 317.35,58.82 317.39,58.77 arc(317.46,58.69) 317.5,58.58 arc(317.51,58.53) 317.51,58.48 317.51,58.07 arc(317.56,57.84) 317.69,57.65 318.15,57.18 arc(318.26,57.02) 318.3,56.82 YJ34.B21
FC52_TDN0: length 168.8
  TOP w0.147: U1.BF4 227.1,151.84 arc(227.42,151.97) v4(227.55,152.29)
  SIG6 w0.112: 232.09,151.03 232.06,151.03 231.97,150.94 228.39,150.94 arc(228.31,150.95) 228.24,151 arc(228.2,151.06) 228.18,151.14 228.18,151.58 arc(228.15,151.72) 228.08,151.83 228.07,151.85 arc(227.96,151.92) 227.84,151.94 227.68,151.94 arc(227.59,151.98) 227.55,152.07 v4(227.55,152.29)
  SIG6 w0.16: 232.09,151.03 233.99,151.03 arc(234.28,150.97) 234.53,150.81 235.38,149.95 arc(235.63,149.79) 235.92,149.73 245.52,149.73 arc(245.81,149.67) 246.06,149.51 274.44,121.12 arc(274.69,120.96) 274.98,120.9 295.18,120.9 arc(295.47,120.84) 295.71,120.68 319.19,97.2 arc(319.36,96.95) 319.42,96.66 319.42,73.54 arc(319.36,73.25) 319.19,73 315.63,69.43 arc(315.46,69.19) 315.4,68.9 315.4,61.44 arc(315.46,61.14) 315.63,60.9 316.91,59.62 arc(317.15,59.45) 317.44,59.39 326.59,59.39 arc(326.88,59.34) 327.13,59.17 327.14,59.16 arc(327.47,58.94) 327.87,58.86 328.66,58.86 arc(328.9,58.76) 329,58.52 329,58.34 arc(328.96,58.14) 328.85,57.97 YJ34.B34
FC52_TDN1: length 170.3
  TOP w0.147: v4(230.55,149.39) 230.55,149.34 U1.BC1
  SIG7 w0.112: 231.26,148.51 231.26,148.64 231.14,148.76 arc(231.03,148.94) 230.99,149.14 230.99,149.65 arc(230.97,149.72) 230.94,149.77 230.93,149.78 arc(230.88,149.81) 230.83,149.82 230.69,149.82 arc(230.59,149.78) 230.55,149.67 v4(230.55,149.39)
  SIG7 w0.16: 231.26,148.51 232.41,147.36 arc(232.87,147.06) 233.41,146.95 244.88,146.95 arc(245.02,146.92) 245.15,146.84 273.4,118.58 arc(273.65,118.42) 273.94,118.36 293.63,118.36 arc(294.34,118.22) 294.95,117.82 318.5,94.26 arc(318.9,93.67) 319.04,92.97 319.04,76.62 319.04,76.62 arc(318.96,76.23) 318.74,75.91 314.15,71.31 arc(313.82,70.82) 313.7,70.24 313.7,68.47 313.55,68.31 313.55,67.76 313.7,67.6 313.7,58.93 arc(313.79,58.49) 314.04,58.12 316.81,55.35 arc(317.18,55.1) 317.62,55.01 328.99,55.01 arc(329.14,54.98) 329.26,54.9 329.35,54.82 329.39,54.77 arc(329.46,54.69) 329.5,54.59 arc(329.51,54.53) 329.51,54.48 329.51,54.07 arc(329.56,53.84) 329.69,53.65 330.15,53.19 arc(330.26,53.02) 330.3,52.82 YJ34.B3
FC52_TDN2: length 171.6
  TOP w0.147: U1.BD3 228.1,149.84 arc(228.42,149.97) v4(228.55,150.29)
  SIG7 w0.112: 232.09,151.04 232.06,151.04 231.97,150.94 229.39,150.94 arc(229.23,150.91) 229.1,150.83 arc(229.02,150.7) 228.99,150.54 228.99,150.11 arc(228.97,150.04) 228.94,149.99 228.93,149.98 arc(228.88,149.95) 228.83,149.94 228.69,149.94 arc(228.59,149.98) 228.55,150.09 v4(228.55,150.29)
  SIG7 w0.16: 232.09,151.04 232.54,151.04 arc(232.83,150.98) 233.07,150.81 234.04,149.84 arc(234.17,149.76) 234.31,149.73 245.49,149.73 arc(245.78,149.67) 246.03,149.51 274.53,121.01 arc(274.65,120.93) 274.8,120.9 294.55,120.9 arc(295.38,120.74) 296.08,120.27 320.89,95.45 arc(321.34,94.78) 321.5,93.99 321.5,74.25 arc(321.44,73.96) 321.28,73.71 315.63,68.06 arc(315.46,67.82) 315.4,67.52 315.4,61.8 arc(315.46,61.51) 315.63,61.26 317.27,59.62 arc(317.51,59.45) 317.81,59.39 328.99,59.39 arc(329.28,59.34) 329.53,59.17 329.62,59.08 arc(329.86,58.92) 330.16,58.86 331.06,58.86 arc(331.3,58.76) 331.4,58.52 331.4,58.34 arc(331.36,58.14) 331.25,57.97 YJ34.B37
FC52_TDN3: length 170.1
  TOP w0.147: v4(226.55,149.39) 226.55,149.34 U1.BC5
  SIG6 w0.112: 232.12,148.65 232.09,148.65 232,148.74 227.39,148.74 arc(227.23,148.77) 227.1,148.86 arc(227.02,148.99) 226.99,149.14 226.99,149.58 arc(226.97,149.64) 226.94,149.69 226.93,149.71 arc(226.88,149.73) 226.84,149.74 226.68,149.74 arc(226.59,149.71) 226.55,149.62 v4(226.55,149.39)
  SIG6 w0.16: YJ34.B6 327.9,52.8 arc(327.86,53.02) 327.73,53.2 327.49,53.45 327.29,53.65 arc(327.16,53.84) 327.11,54.07 327.11,54.48 arc(327.11,54.53) 327.1,54.58 arc(327.06,54.69) 326.99,54.77 326.95,54.82 326.86,54.9 arc(326.74,54.98) 326.59,55.01 317.51,55.01 arc(317.07,55.1) 316.7,55.35 316.38,55.67 316.1,55.67 315.73,56.05 315.73,56.32 315.32,56.72 315.05,56.72 314.68,57.1 314.68,57.37 314.04,58.01 arc(313.79,58.38) 313.7,58.82 313.7,59.27 313.58,59.4 313.58,60.06 313.7,60.19 313.7,71.26 arc(313.79,71.7) 314.04,72.07 316.44,74.47 arc(316.52,74.59) 316.55,74.74 316.55,95.95 arc(316.49,96.24) 316.32,96.49 294.67,118.14 arc(294.43,118.3) 294.13,118.36 273.94,118.36 arc(273.65,118.42) 273.4,118.58 245.11,146.88 arc(244.98,146.96) 244.84,146.99 234.92,146.99 arc(234.49,147.07) 234.11,147.32 232.9,148.54 arc(232.78,148.62) 232.63,148.65 232.12,148.65
FC52_TDP0: length 168.8
  TOP w0.147: U1.BE4 227.55,151.34 v4(227.55,151.39)
  SIG6 w0.112: v4(227.55,151.39) 227.55,151.62 arc(227.59,151.71) 227.68,151.74 227.84,151.74 arc(227.88,151.73) 227.93,151.71 227.94,151.69 arc(227.97,151.64) 227.99,151.58 227.99,151.14 arc(228.02,150.99) 228.1,150.86 arc(228.23,150.77) 228.39,150.74 231.97,150.74 232.06,150.65 232.09,150.65
  SIG6 w0.155: 327.13,57.94 arc(327.11,58) 327.11,58.07
  SIG6 w0.16: YJ34.B33 327.9,56.77 arc(327.85,57.01) 327.71,57.22 327.29,57.64 arc(327.19,57.78) 327.13,57.94 ; 327.11,58.07 327.11,58.48 arc(327.11,58.53) 327.1,58.58 arc(327.09,58.59) 327.09,58.61 arc(327.05,58.7) 326.99,58.77 326.95,58.82 326.86,58.9 arc(326.74,58.98) 326.59,59.01 317.44,59.01 arc(317.01,59.1) 316.64,59.35 315.36,60.63 arc(315.11,61) 315.02,61.44 315.02,68.9 arc(315.11,69.33) 315.36,69.7 315.7,70.04 315.7,70.41 315.99,70.7 316.35,70.7 316.69,71.03 316.69,71.37 317,71.69 317.34,71.69 318.93,73.27 arc(319.01,73.4) 319.04,73.54 319.04,96.66 arc(319.01,96.8) 318.93,96.93 295.44,120.41 arc(295.32,120.49) 295.18,120.52 274.98,120.52 arc(274.54,120.61) 274.17,120.86 245.79,149.24 arc(245.67,149.32) 245.52,149.35 235.92,149.35 arc(235.48,149.44) 235.11,149.68 234.26,150.54 arc(234.13,150.62) 233.99,150.65 232.09,150.65
FC52_TDP1: length 170.3
  TOP w0.147: U1.BD1 230.1,149.84 arc(230.42,149.97) v4(230.55,150.29)
  SIG7 w0.112: v4(230.55,150.29) 230.55,150.18 arc(230.6,150.06) 230.71,150.02 230.83,150.02 arc(230.96,149.99) 231.07,149.92 231.08,149.91 arc(231.15,149.79) 231.18,149.65 231.18,149.14 arc(231.21,149.01) 231.28,148.9 231.4,148.78 231.53,148.78
  SIG7 w0.16: 231.53,148.78 232.68,147.63 arc(233.02,147.41) 233.41,147.33 244.88,147.33 arc(245.17,147.27) 245.42,147.11 273.67,118.85 arc(273.79,118.77) 273.94,118.74 293.63,118.74 arc(294.49,118.57) 295.21,118.08 318.77,94.53 arc(319.25,93.81) 319.42,92.97 319.42,76.62 arc(319.31,76.09) 319.01,75.64 314.42,71.04 arc(314.17,70.68) 314.08,70.24 314.08,58.93 arc(314.14,58.63) 314.31,58.39 317.08,55.62 arc(317.32,55.45) 317.62,55.39 328.99,55.39 arc(329.28,55.34) 329.53,55.17 329.62,55.08 arc(329.86,54.92) 330.16,54.86 331.06,54.86 arc(331.3,54.76) 331.4,54.52 331.4,54.34 arc(331.36,54.14) 331.25,53.97 YJ34.B2
FC52_TDP2: length 171.6
  TOP w0.147: v4(228.55,149.39) 228.55,149.34 U1.BC3
  SIG7 w0.112: v4(228.55,149.39) 228.55,149.58 arc(228.59,149.69) 228.7,149.74 228.7,149.74 228.83,149.74 arc(228.96,149.77) 229.07,149.84 229.08,149.85 arc(229.15,149.97) 229.18,150.11 229.18,150.54 arc(229.2,150.62) 229.24,150.69 arc(229.31,150.73) 229.39,150.75 231.97,150.75 232.06,150.65 232.09,150.65
  SIG7 w0.16: 232.09,150.65 232.54,150.65 arc(232.68,150.62) 232.8,150.54 233.77,149.57 arc(234.02,149.41) 234.31,149.35 245.49,149.35 arc(245.64,149.32) 245.76,149.24 274.26,120.74 arc(274.5,120.58) 274.8,120.52 294.55,120.52 arc(295.23,120.39) 295.81,120 320.62,95.18 arc(320.99,94.64) 321.12,93.99 321.12,74.25 arc(321.09,74.11) 321.01,73.98 318.69,71.67 318.42,71.67 318.08,71.33 318.08,71.06 317.76,70.73 317.51,70.73 317.15,70.37 317.15,70.12 316.83,69.8 316.6,69.8 316.21,69.41 316.21,69.19 315.36,68.33 arc(315.11,67.96) 315.02,67.52 315.02,61.8 arc(315.11,61.36) 315.36,60.99 317,59.35 arc(317.37,59.1) 317.81,59.01 328.99,59.01 arc(329.14,58.98) 329.26,58.9 329.35,58.82 329.39,58.77 arc(329.46,58.68) 329.5,58.58 arc(329.51,58.53) 329.51,58.48 329.51,58.07 arc(329.56,57.84) 329.68,57.65 330.11,57.22 arc(330.25,57.02) 330.3,56.77 YJ34.B36
FC52_TDP3: length 170.1
  TOP w0.147: U1.BD5 226.1,149.84 arc(226.42,149.97) v4(226.55,150.29)
  SIG6 w0.112: v4(226.55,150.29) 226.55,150.07 arc(226.59,149.98) 226.68,149.94 226.84,149.94 arc(226.96,149.92) 227.07,149.85 227.08,149.83 arc(227.15,149.72) 227.18,149.58 227.18,149.14 arc(227.2,149.06) 227.24,149 arc(227.31,148.95) 227.39,148.94 232,148.94 232.09,149.03 232.12,149.03
  SIG6 w0.16: 232.12,149.03 232.63,149.03 arc(232.92,148.97) 233.17,148.81 234.38,147.59 arc(234.63,147.43) 234.92,147.37 244.84,147.37 arc(245.13,147.31) 245.38,147.14 273.67,118.85 arc(273.79,118.77) 273.94,118.74 294.13,118.74 arc(294.57,118.66) 294.94,118.41 316.59,96.76 arc(316.84,96.39) 316.93,95.95 316.93,74.74 arc(316.87,74.44) 316.71,74.2 314.31,71.8 arc(314.14,71.55) 314.08,71.26 314.08,58.82 arc(314.14,58.53) 314.31,58.28 316.97,55.62 arc(317.22,55.45) 317.51,55.39 326.59,55.39 arc(326.88,55.34) 327.13,55.17 327.22,55.08 arc(327.46,54.92) 327.76,54.86 328.66,54.86 arc(328.9,54.76) 329,54.52 329,54.34 arc(328.96,54.14) 328.85,53.97 YJ34.B5
FC53_RDN0: length 161.6
  TOP w0.147: U1.BH13 218.07,153.84 arc(218.25,153.88) 218.41,153.98 218.49,154.06 arc(218.53,154.13) 218.55,154.21 v4(218.55,154.29)
  SIG8 w0.112: v4(218.55,154.29) 218.55,154.04 arc(218.58,153.97) 218.65,153.94 218.87,153.94 arc(218.91,153.95) 218.95,153.97 arc(218.98,154.01) 218.99,154.06 218.99,154.43 arc(219.02,154.6) 219.12,154.75 219.15,154.78 arc(219.33,154.9) 219.54,154.94 231.84,154.94 231.94,155.03
  SIG8 w0.16: 231.94,155.03 232.74,155.03 arc(232.88,155.06) 233.01,155.15 233.02,155.16 arc(233.39,155.41) 233.83,155.5 245.7,155.5 arc(246.13,155.41) 246.5,155.16 280.65,121.01 arc(280.78,120.93) 280.92,120.9 295.05,120.9 arc(295.49,120.81) 295.86,120.57 321.17,95.26 arc(321.41,94.89) 321.5,94.45 321.5,71.66 arc(321.44,71.37) 321.28,71.12 318.11,67.96 arc(317.95,67.71) 317.89,67.42 317.89,67.26 arc(317.92,67.11) 318.01,66.98 arc(318.08,66.92) 318.17,66.88 arc(318.23,66.87) 318.29,66.86 318.97,66.86 arc(319.12,66.83) 319.26,66.74 319.33,66.67 arc(319.38,66.59) 319.4,66.49 319.4,66.23 arc(319.38,66.13) 319.33,66.05 YJ34.A22
FC53_RDN1: length 160.5
  TOP w0.147: v4(222.55,153.39) 222.55,153.34 U1.BG9
  SIG9 w0.112: v4(222.55,153.39) 222.55,153.64 arc(222.58,153.71) 222.65,153.74 222.87,153.74 arc(222.91,153.73) 222.95,153.71 arc(222.98,153.67) 222.99,153.63 222.99,153.25 arc(223.02,153.08) 223.12,152.94 223.15,152.9 arc(223.33,152.78) 223.54,152.74 231.72,152.74 arc(231.84,152.72) 231.94,152.65
  SIG9 w0.16: YJ34.A15 320.7,60.79 arc(320.65,61.02) 320.53,61.21 320.09,61.65 arc(319.96,61.84) 319.91,62.07 319.91,62.48 arc(319.91,62.53) 319.9,62.57 arc(319.86,62.68) 319.79,62.77 319.75,62.82 319.66,62.9 arc(319.54,62.98) 319.39,63.01 317.97,63.01 arc(317.53,63.1) 317.16,63.35 316.62,63.89 arc(316.37,64.26) 316.28,64.7 316.28,65.84 arc(316.37,66.28) 316.62,66.65 317.2,67.23 arc(317.28,67.35) 317.31,67.5 317.31,70.67 arc(317.4,71.11) 317.64,71.48 317.92,71.76 317.92,72.08 318.31,72.48 318.64,72.48 318.93,72.76 arc(319.01,72.89) 319.04,73.03 319.04,73.54 318.76,73.82 318.76,74.28 319.04,74.56 319.04,93.59 arc(319.01,93.74) 318.93,93.86 315.88,96.91 312.83,99.96 294.54,118.25 arc(294.41,118.33) 294.27,118.36 286.19,118.36 arc(285.75,118.45) 285.38,118.7 251.15,152.92 arc(251.03,153) 250.88,153.03 234.9,153.03 arc(234.73,153.01) 234.57,152.94 arc(234.5,152.89) 234.44,152.84 arc(234.23,152.7) 233.98,152.65 231.94,152.65
