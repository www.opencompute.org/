# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC33_RDP1: length 60.8
  TOP w0.147: v4(201.5,114.34) 201.42,114.34 arc(201.34,114.36) 201.27,114.4 201.19,114.48 arc(201.09,114.64) 201.05,114.83 U1.J30
  SIG9 w0.112: 203.24,104.92 203.24,104.95 arc(203.24,104.97) 203.23,104.99 203.2,105.02 arc(203.16,105.08) 203.15,105.14 203.15,113.44 arc(203.11,113.62) 203.01,113.77 arc(202.86,113.87) 202.69,113.91 201.26,113.91 arc(201.22,113.91) 201.18,113.94 arc(201.16,113.98) 201.15,114.02 201.15,114.24 arc(201.18,114.31) 201.25,114.34 v4(201.5,114.34)
  SIG9 w0.16: 203.24,104.92 203.24,103.96 arc(203.27,103.82) 203.36,103.7 204.71,102.34 arc(204.95,101.97) 205.04,101.54 205.04,95.94 arc(205.1,95.65) 205.27,95.41 206.85,93.82 arc(207.1,93.65) 207.39,93.6 208.28,93.6 arc(208.57,93.54) 208.82,93.37 210.79,91.41 arc(210.95,91.16) 211.01,90.87 211.01,73.21 arc(210.92,72.77) 210.68,72.4 208.26,69.99 208.26,69.71 207.83,69.27 207.54,69.27 207.19,68.91 arc(206.81,68.66) 206.38,68.58 205.27,68.58 arc(204.99,68.52) 204.75,68.36 204.54,68.15 arc(204.33,67.66) 204.54,67.17 204.69,67.01 arc(204.86,66.9) 205.06,66.86 206.06,66.86 arc(206.3,66.76) 206.4,66.52 206.4,66.34 arc(206.36,66.14) 206.25,65.97 YJ30.C22
FC33_RDP2: length 60.3
  TOP w0.147: v4(200.6,116.34) 200.55,116.34 U1.L31
  SIG8 w0.112: v4(200.6,116.34) 200.85,116.34 arc(200.92,116.31) 200.95,116.24 200.95,116.02 arc(200.97,115.9) 201.04,115.8 arc(201.14,115.73) 201.26,115.71 202.71,115.71 arc(202.8,115.69) 202.88,115.64 arc(202.93,115.56) 202.95,115.47 202.95,105.02 202.86,104.93 202.86,104.9
  SIG8 w0.16: 202.86,104.9 202.86,104.28 arc(202.91,103.99) 203.08,103.74 204.84,101.97 arc(205.09,101.81) 205.38,101.75 206.25,101.75 arc(206.54,101.69) 206.79,101.53 206.88,101.44 arc(206.96,101.34) 207.03,101.22 arc(207.08,101.06) 207.1,100.9 207.1,95.26 arc(207.19,94.82) 207.43,94.45 210.39,91.49 arc(210.47,91.37) 210.5,91.22 210.5,71.74 arc(210.44,71.45) 210.28,71.2 207.13,68.05 arc(206.97,67.81) 206.91,67.51 206.91,66.07 arc(206.96,65.84) 207.09,65.65 207.43,65.31 arc(207.63,65.01) 207.7,64.65 YJ30.C24
FC33_RDP3: length 67.9
  TOP w0.147: U1.N30 201.05,118.73 arc(201.07,118.62) 201.13,118.53 201.19,118.47 arc(201.33,118.37) v4(201.5,118.34)
  SIG8 w0.112: v4(201.5,118.34) 201.25,118.34 arc(201.18,118.31) 201.15,118.24 201.15,118.02 arc(201.12,117.9) 201.06,117.8 arc(200.95,117.73) 200.83,117.71 200.46,117.71 arc(200.37,117.69) 200.29,117.64 200.25,117.6 arc(200.18,117.49) 200.15,117.35 200.15,111.27 arc(200.17,111.14) 200.25,111.04 arc(200.35,110.97) 200.48,110.94 200.66,110.94 arc(200.83,110.91) 200.98,110.81 201,110.79 arc(201.11,110.62) 201.15,110.42 201.15,105.02 201.24,104.93 201.24,104.9
  SIG8 w0.16: 201.24,104.9 201.24,97.99 arc(201.3,97.7) 201.46,97.45 207.87,91.05 arc(208.03,90.8) 208.09,90.51 208.09,72.17 arc(208.03,71.88) 207.87,71.63 205.08,68.85 205.08,68.56 204.65,68.13 204.36,68.13 203.78,67.55 arc(203.62,67.3) 203.56,67.01 203.56,64.66 arc(203.62,64.37) 203.78,64.12 204.29,63.62 arc(204.53,63.45) 204.83,63.39 206.39,63.39 arc(206.68,63.34) 206.93,63.17 207.16,62.94 arc(207.25,62.88) 207.35,62.86 208.44,62.86 arc(208.59,62.83) 208.72,62.74 arc(208.78,62.65) 208.8,62.54 208.8,62.35 arc(208.76,62.14) 208.65,61.97 YJ30.C14
FC33_TDN0: length 67.9
  TOP w0.147: U1.D32 199.55,109.34 v4(199.6,109.34)
  SIG6 w0.112: 200.86,104.65 200.86,104.68 200.95,104.77 200.95,108.5 arc(200.94,108.58) 200.89,108.65 arc(200.83,108.69) 200.75,108.71 200.31,108.71 arc(200.17,108.74) 200.06,108.81 200.05,108.83 arc(199.98,108.93) 199.95,109.05 199.95,109.21 arc(199.91,109.3) 199.82,109.34 v4(199.6,109.34)
  SIG6 w0.16: 200.86,104.65 200.86,102.32 200.86,102.31 200.86,97.81 arc(200.91,97.52) 201.08,97.27 207.49,90.87 arc(207.65,90.62) 207.71,90.33 207.71,71.66 arc(207.68,71.52) 207.6,71.39 203.55,67.34 arc(203.3,66.97) 203.21,66.54 203.21,64.63 arc(203.3,64.19) 203.55,63.82 204.02,63.35 arc(204.39,63.1) 204.83,63.01 215.99,63.01 arc(216.14,62.98) 216.26,62.9 216.35,62.82 216.39,62.77 arc(216.44,62.71) 216.48,62.63 arc(216.49,62.62) 216.49,62.61 arc(216.49,62.6) 216.5,62.59 arc(216.51,62.53) 216.51,62.48 216.51,62.07 arc(216.56,61.84) 216.69,61.65 217.18,61.15 arc(217.27,61.02) 217.3,60.86 YJ30.C3
FC33_TDN1: length 62.7
  TOP w0.147: U1.A29 202.05,106.79 arc(202.18,106.47) v4(202.5,106.34)
  SIG7 w0.112: v4(202.5,106.34) 202.24,106.34 arc(202.12,106.29) 202.07,106.18 202.07,106.06 arc(202.05,105.93) 201.97,105.82 201.96,105.81 arc(201.85,105.74) 201.71,105.71 201.48,105.71 arc(201.35,105.68) 201.24,105.61 arc(201.17,105.5) 201.14,105.37 201.14,105.29 arc(201.19,105.07) 201.31,104.89 201.48,104.72 arc(201.52,104.69) 201.57,104.68 201.65,104.68
  SIG7 w0.16: YJ30.C5 215.85,61.97 arc(215.96,62.14) 216,62.34 216,62.56 arc(215.91,62.77) 215.7,62.86 214.76,62.86 arc(214.46,62.92) 214.22,63.08 214.13,63.17 arc(213.88,63.34) 213.59,63.39 204.7,63.39 arc(204.41,63.45) 204.16,63.62 203.82,63.96 arc(203.65,64.21) 203.59,64.5 203.59,65.82 arc(203.65,66.12) 203.82,66.36 207.87,70.41 arc(208.03,70.66) 208.09,70.95 208.09,88.96 arc(208.05,89.16) 207.94,89.33 205.18,92.09 arc(205.08,92.24) 205.04,92.42 205.04,101.54 arc(204.98,101.83) 204.82,102.07 202.93,103.97 arc(202.74,104.09) 202.51,104.14 202.4,104.14 arc(202.21,104.18) 202.04,104.29 201.65,104.68
FC33_TDN2: length 51.5
  TOP w0.147: U1.C30 201.55,108.34 v4(201.6,108.34)
  SIG7 w0.112: 203.43,105.46 203.43,105.59 203.18,105.85 arc(203.01,106.1) 202.95,106.39 202.95,107.5 arc(202.94,107.58) 202.89,107.65 arc(202.83,107.69) 202.75,107.71 202.24,107.71 arc(202.1,107.74) 201.98,107.81 201.97,107.82 arc(201.9,107.93) 201.87,108.06 201.87,108.18 arc(201.83,108.29) 201.71,108.34 v4(201.6,108.34)
  SIG7 w0.16: 203.43,105.46 206.68,102.22 arc(206.97,101.78) 207.07,101.26 207.07,94.96 arc(207.15,94.59) 207.36,94.27 210.02,91.61 arc(210.19,91.36) 210.25,91.05 210.25,73.86 arc(210.42,72.99) 210.92,72.25 214.76,68.4 214.76,68.18 215.19,67.76 215.41,67.76 216.35,66.82 216.39,66.77 arc(216.45,66.7) 216.49,66.6 arc(216.49,66.6) 216.49,66.6 arc(216.5,66.59) 216.5,66.58 arc(216.51,66.53) 216.51,66.48 216.51,66.07 arc(216.56,65.84) 216.69,65.65 217.09,65.25 arc(217.25,65.01) 217.3,64.74 YJ30.C36
FC33_TDN3: length 52.4
  TOP w0.147: U1.E29 202.05,110.79 arc(202.18,110.47) v4(202.5,110.34)
  SIG6 w0.112: v4(202.5,110.34) 202.2,110.34 arc(202.11,110.3) 202.07,110.21 202.07,110.05 arc(202.08,110.01) 202.11,109.96 202.12,109.95 arc(202.17,109.92) 202.24,109.91 202.75,109.91 arc(202.9,109.87) 203.03,109.79 arc(203.12,109.66) 203.15,109.5 203.15,106.23 arc(203.2,106) 203.33,105.8 203.69,105.44 203.82,105.44 203.84,105.42
  SIG6 w0.16: 203.84,105.42 205.22,104.04 206.79,102.47 arc(207.19,101.93) 207.41,101.29 arc(207.44,101.08) 207.46,100.86 207.45,95.31 arc(207.51,95.02) 207.68,94.77 210.84,91.61 arc(211,91.36) 211.06,91.07 211.06,72.27 arc(211.12,71.98) 211.28,71.73 213.28,69.74 213.43,69.74 213.93,69.24 213.93,69.09 214.27,68.75 arc(214.43,68.5) 214.49,68.21 214.49,67.28 arc(214.52,67.12) 214.61,66.98 arc(214.75,66.89) 214.91,66.86 215.66,66.86 arc(215.9,66.76) 216,66.52 216,66.34 arc(215.96,66.14) 215.85,65.97 YJ30.C34
FC33_TDP0: length 67.9
  TOP w0.147: U1.D31 200.05,109.79 arc(200.18,109.47) v4(200.5,109.34)
  SIG6 w0.112: 201.24,104.65 201.24,104.68 201.15,104.77 201.15,108.5 arc(201.12,108.66) 201.03,108.79 arc(200.9,108.87) 200.75,108.91 200.31,108.91 arc(200.25,108.92) 200.2,108.95 200.19,108.96 arc(200.16,109.01) 200.15,109.05 200.15,109.21 arc(200.18,109.3) 200.27,109.34 v4(200.5,109.34)
  SIG6 w0.16: 201.24,104.65 201.24,102.62 201.24,102.62 201.24,97.81 arc(201.27,97.67) 201.35,97.54 207.75,91.14 arc(208,90.77) 208.09,90.33 208.09,71.66 arc(208.03,71.37) 207.87,71.12 205.13,68.38 205.13,68.1 204.76,67.73 204.47,67.73 203.82,67.07 arc(203.65,66.83) 203.59,66.54 203.59,64.63 arc(203.65,64.33) 203.82,64.09 204.29,63.62 arc(204.53,63.45) 204.83,63.39 215.99,63.39 arc(216.28,63.34) 216.53,63.17 216.6,63.1 216.75,62.95 arc(216.85,62.88) 216.97,62.86 218.06,62.86 arc(218.3,62.76) 218.4,62.52 218.4,62.34 arc(218.36,62.14) 218.25,61.97 YJ30.C2
FC33_TDP1: length 62.7
  TOP w0.147: v4(201.6,106.34) 201.55,106.34 U1.A30
  SIG7 w0.112: 201.38,104.41 201.38,104.49 arc(201.37,104.54) 201.34,104.58 201.17,104.75 arc(201.01,104.99) 200.95,105.29 200.95,105.37 arc(200.99,105.57) 201.1,105.75 arc(201.28,105.86) 201.48,105.91 201.71,105.91 arc(201.77,105.92) 201.83,105.95 201.84,105.96 arc(201.86,106.01) 201.87,106.06 201.87,106.2 arc(201.83,106.3) 201.73,106.34 v4(201.6,106.34)
  SIG7 w0.16: YJ30.C6 214.9,60.76 arc(214.85,61.01) 214.71,61.23 214.49,61.44 214.32,61.61 arc(214.24,61.7) 214.18,61.8 214.18,61.8 arc(214.13,61.93) 214.11,62.07 214.11,62.48 arc(214.11,62.52) 214.1,62.56 arc(214.1,62.57) 214.1,62.57 arc(214.1,62.58) 214.1,62.58 arc(214.06,62.68) 213.99,62.77 213.95,62.82 213.86,62.9 arc(213.74,62.98) 213.59,63.01 204.7,63.01 arc(204.26,63.1) 203.89,63.35 203.55,63.69 arc(203.3,64.06) 203.21,64.5 203.21,65.82 arc(203.3,66.26) 203.55,66.63 203.87,66.96 203.87,67.18 204.3,67.6 204.52,67.6 207.6,70.68 arc(207.68,70.8) 207.71,70.95 207.71,88.96 arc(207.7,89.01) 207.67,89.06 204.91,91.82 arc(204.73,92.09) 204.66,92.42 204.66,101.54 arc(204.63,101.68) 204.55,101.81 202.66,103.7 arc(202.59,103.74) 202.51,103.76 202.4,103.76 arc(202.06,103.82) 201.77,104.02 201.38,104.41
FC33_TDP2: length 51.4
  TOP w0.147: U1.C29 202.05,108.79 arc(202.18,108.47) v4(202.5,108.34)
  SIG7 w0.112: 203.7,105.73 203.57,105.73 203.32,105.99 arc(203.19,106.17) 203.15,106.39 203.15,107.5 arc(203.12,107.66) 203.03,107.79 arc(202.9,107.87) 202.75,107.91 202.24,107.91 arc(202.17,107.92) 202.12,107.95 202.11,107.96 arc(202.08,108.01) 202.07,108.06 202.07,108.2 arc(202.11,108.3) 202.22,108.34 v4(202.5,108.34)
  SIG7 w0.16: 203.7,105.73 206.95,102.49 arc(207.32,101.93) 207.45,101.26 207.45,94.96 arc(207.5,94.73) 207.63,94.54 210.29,91.88 arc(210.54,91.5) 210.63,91.05 210.63,73.86 arc(210.77,73.13) 211.19,72.52 216.51,67.2 arc(216.88,66.95) 217.31,66.86 218.06,66.86 arc(218.3,66.76) 218.4,66.52 218.4,66.34 arc(218.36,66.14) 218.25,65.97 YJ30.C37
FC33_TDP3: length 52.4
  TOP w0.147: v4(201.6,110.34) 201.55,110.34 U1.E30
  SIG6 w0.112: v4(201.6,110.34) 201.75,110.34 arc(201.84,110.3) 201.87,110.21 201.87,110.05 arc(201.9,109.93) 201.97,109.83 201.98,109.81 arc(202.1,109.74) 202.24,109.71 202.75,109.71 arc(202.83,109.69) 202.89,109.65 arc(202.94,109.58) 202.95,109.5 202.95,106.23 arc(203.01,105.92) 203.19,105.66 203.55,105.3 203.55,105.17 203.57,105.15
  SIG6 w0.16: 203.57,105.15 204.95,103.77 206.52,102.2 arc(206.85,101.75) 207.04,101.22 arc(207.07,101.04) 207.07,100.86 207.07,95.31 arc(207.16,94.87) 207.41,94.5 210.57,91.34 arc(210.65,91.22) 210.68,91.07 210.68,72.27 arc(210.77,71.83) 211.02,71.46 214,68.48 arc(214.08,68.36) 214.11,68.21 214.11,66.07 arc(214.13,65.91) 214.2,65.76 arc(214.26,65.68) 214.33,65.6 214.77,65.16 arc(214.87,65.02) 214.9,64.85 YJ30.C33
FC34_35_PVDD0P8: length 5.6
  TOP w0.229: U1.Y26 v1(205.55,125.34) ; U1.Y28 v1(203.55,125.34)
  TOP w0.381: C3099.1 198.03,100.61 ; C3099.1 198.03,101.83 ; C3099.1 198.82,101.22
  BOTTOM w0.13: v1(199.2,101.72) v2(198.44,101.72)
  BOTTOM w0.381: v1(205.55,125.34) 205.07,124.86 C3340.1 ; v1(203.55,125.34) 203.06,124.85 C3054.1
  vias: v1(199.2,100.71)
FC34_RDN0: length 62.8
  TOP w0.147: v4(204.5,113.34) 204.4,113.34 arc(204.32,113.36) 204.24,113.41 204.18,113.47 arc(204.08,113.62) 204.05,113.79 U1.H27
  SIG3 w0.112: v4(204.5,113.34) 204.27,113.34 arc(204.18,113.3) 204.15,113.21 204.15,113.02 arc(204.12,112.9) 204.06,112.8 arc(203.96,112.73) 203.84,112.71 203.53,112.71 arc(203.38,112.68) 203.26,112.59 arc(203.17,112.47) 203.14,112.32 203.14,104.9 203.24,104.8 203.24,104.78
  SIG3 w0.16: YJ29.A21 218.1,64.79 arc(218.15,65.02) 218.27,65.21 218.77,65.7 arc(218.85,65.83) 218.88,65.99 218.88,71.21 arc(218.93,71.42) 219.04,71.59 arc(219.16,71.77) 219.2,71.98 219.2,86.61 arc(219.15,86.9) 218.98,87.15 217.95,88.18 arc(217.7,88.35) 217.41,88.4 209.06,88.4 arc(208.77,88.46) 208.52,88.63 205.52,91.63 arc(205.35,91.87) 205.3,92.17 205.3,101.15 arc(205.3,101.19) 205.29,101.22 arc(205.23,101.47) 205.07,101.69 203.46,103.31 arc(203.29,103.55) 203.24,103.85 203.24,104.78
FC34_RDN1: length 70.8
  TOP w0.147: v4(203.6,115.34) 203.55,115.34 U1.K28
  SIG3 w0.112: v4(203.6,115.34) 203.82,115.34 arc(203.91,115.3) 203.95,115.21 203.95,115.02 arc(203.97,114.9) 204.04,114.8 arc(204.14,114.73) 204.26,114.71 204.56,114.71 arc(204.71,114.68) 204.83,114.59 arc(204.92,114.47) 204.95,114.32 204.95,104.86 204.86,104.78
  SIG3 w0.16: YJ29.A14 214.75,61.97 arc(214.64,62.13) 214.61,62.32 214.61,62.59 arc(214.69,62.78) 214.88,62.86 215.78,62.86 arc(216.07,62.92) 216.32,63.08 216.36,63.13 216.41,63.18 arc(216.66,63.35) 216.95,63.41 218.39,63.41 arc(218.68,63.46) 218.93,63.63 219.46,64.16 arc(219.62,64.4) 219.68,64.69 219.68,66.09 arc(219.77,66.53) 220.01,66.9 220.53,67.42 arc(220.81,67.84) 220.91,68.32 220.91,68.83 220.65,69.09 220.65,69.59 220.91,69.85 220.91,88.34 arc(220.88,88.48) 220.79,88.61 218.97,90.44 arc(218.84,90.52) 218.7,90.55 211.83,90.55 arc(211.4,90.64) 211.03,90.88 207.41,94.5 arc(207.16,94.87) 207.07,95.31 207.07,101.28 arc(207.04,101.43) 206.96,101.55 205.2,103.32 arc(204.95,103.69) 204.86,104.13 204.86,104.78
FC34_RDN2: length 67.7
  TOP w0.147: U1.M27 204.05,117.76 arc(204.07,117.66) 204.12,117.58 204.31,117.39 arc(204.36,117.35) 204.43,117.34 v4(204.5,117.34)
  SIG2 w0.112: 203.24,104.78 203.24,104.8 203.14,104.9 203.14,116.32 arc(203.17,116.47) 203.26,116.59 arc(203.38,116.68) 203.53,116.71 203.84,116.71 arc(203.96,116.73) 204.06,116.8 arc(204.12,116.9) 204.15,117.02 204.15,117.21 arc(204.18,117.3) 204.27,117.34 v4(204.5,117.34)
  SIG2 w0.16: 203.24,104.78 203.24,104.39 arc(203.25,104.3) 203.31,104.22 204.41,103.12 arc(204.69,102.7) 204.79,102.2 204.79,92.64 arc(204.85,92.35) 205.01,92.1 208.49,88.63 arc(208.73,88.46) 209.03,88.4 217.29,88.4 arc(217.72,88.32) 218.09,88.07 218.87,87.29 arc(219.12,86.92) 219.21,86.48 219.21,71.43 arc(219.15,71.13) 218.98,70.89 216.85,68.75 arc(216.68,68.5) 216.63,68.21 216.63,67.04 arc(216.62,66.96) 216.6,66.89 216.54,66.67 arc(216.51,66.57) 216.51,66.46 216.51,65.97 arc(216.48,65.85) 216.41,65.75 215.85,65.18 arc(215.74,65.02) 215.7,64.82 YJ29.A24
FC34_RDN3: length 72.3
  TOP w0.147: v4(203.6,119.34) 203.55,119.34 U1.P28
  SIG2 w0.112: v4(203.6,119.34) 203.82,119.34 arc(203.91,119.3) 203.95,119.21 203.95,119.02 arc(203.97,118.9) 204.04,118.8 arc(204.14,118.73) 204.26,118.71 204.56,118.71 arc(204.71,118.68) 204.83,118.59 arc(204.92,118.47) 204.95,118.32 204.95,104.77 arc(205.01,104.48) 205.17,104.23 205.24,104.16 205.24,104.03 205.26,104.01
  SIG2 w0.16: YJ29.A17 217.15,61.97 arc(217.04,62.13) 217.01,62.32 217.01,62.54 arc(217.1,62.77) 217.33,62.86 218.18,62.86 arc(218.47,62.92) 218.72,63.08 218.76,63.13 218.81,63.18 219.28,63.65 arc(219.58,64.09) 219.68,64.61 219.68,64.61 219.68,68.62 arc(219.77,69.06) 220.01,69.43 220.81,70.23 arc(220.89,70.35) 220.92,70.5 220.92,71.01 220.69,71.23 220.69,71.79 220.92,72.02 220.92,72.53 220.72,72.73 220.72,73.34 220.92,73.55 220.92,87.82 220.92,87.82 arc(220.86,88.11) 220.7,88.35 218.73,90.33 arc(218.48,90.49) 218.19,90.55 212.22,90.55 arc(211.78,90.64) 211.41,90.88 207.41,94.88 arc(207.16,95.25) 207.07,95.69 207.07,101.82 arc(207,102.17) 206.8,102.47 205.26,104.01
FC34_RDP0: length 62.8
  TOP w0.147: U1.H28 203.55,113.34 v4(203.6,113.34)
  SIG3 w0.112: 202.86,104.78 202.86,104.8 202.95,104.89 202.95,112.32 arc(202.99,112.54) 203.12,112.73 arc(203.31,112.86) 203.53,112.91 203.84,112.91 arc(203.88,112.91) 203.92,112.94 arc(203.94,112.97) 203.95,113.02 203.95,113.21 arc(203.91,113.3) 203.82,113.34 v4(203.6,113.34)
  SIG3 w0.16: YJ29.A22 217.15,65.97 arc(217.04,66.13) 217.01,66.32 217.01,66.59 arc(217.08,66.78) 217.27,66.86 218.22,66.86 arc(218.42,66.94) 218.5,67.14 218.5,67.65 218.33,67.83 218.33,68.49 218.5,68.66 218.5,69.17 218.3,69.38 218.3,69.99 218.5,70.19 218.5,71.21 arc(218.57,71.56) 218.77,71.86 arc(218.81,71.92) 218.82,71.98 218.82,86.61 arc(218.79,86.76) 218.71,86.88 217.68,87.91 arc(217.56,87.99) 217.41,88.02 209.06,88.02 arc(208.62,88.11) 208.25,88.36 205.25,91.36 arc(205,91.73) 204.91,92.17 204.91,101.15 arc(204.91,101.17) 204.91,101.19 204.91,101.19 arc(204.88,101.31) 204.8,101.42 203.19,103.04 arc(202.94,103.41) 202.86,103.85 202.86,104.78
FC34_RDP1: length 70.8
  TOP w0.147: v4(204.5,115.34) 204.4,115.34 arc(204.32,115.36) 204.24,115.41 204.18,115.47 arc(204.08,115.62) 204.05,115.79 U1.K27
  SIG3 w0.112: 205.24,104.78 205.14,104.87 205.14,114.32 arc(205.1,114.54) 204.97,114.73 arc(204.78,114.86) 204.56,114.91 204.26,114.91 arc(204.22,114.91) 204.18,114.94 arc(204.16,114.97) 204.15,115.02 204.15,115.21 arc(204.18,115.3) 204.27,115.34 v4(204.5,115.34)
  SIG3 w0.16: YJ29.A15 215.7,60.79 arc(215.75,61.02) 215.87,61.21 216.41,61.75 arc(216.48,61.85) 216.51,61.97 216.51,62.57 arc(216.54,62.72) 216.63,62.86 216.68,62.91 arc(216.81,63) 216.95,63.03 218.39,63.03 arc(218.83,63.11) 219.2,63.36 219.72,63.89 arc(219.97,64.26) 220.06,64.69 220.06,66.09 arc(220.12,66.39) 220.28,66.63 220.8,67.15 arc(221.16,67.69) 221.29,68.32 221.29,88.34 arc(221.23,88.63) 221.06,88.88 219.24,90.71 arc(218.99,90.87) 218.7,90.93 211.83,90.93 arc(211.54,90.99) 211.3,91.15 207.68,94.77 arc(207.51,95.02) 207.45,95.31 207.45,101.28 arc(207.4,101.57) 207.23,101.82 205.47,103.59 arc(205.3,103.83) 205.24,104.13 205.24,104.78
FC34_RDP2: length 67.7
  TOP w0.147: v4(203.6,117.34) 203.55,117.34 U1.M28
  SIG2 w0.112: 202.86,104.78 202.86,104.8 202.95,104.89 202.95,116.32 arc(202.99,116.54) 203.12,116.73 arc(203.31,116.86) 203.53,116.91 203.84,116.91 arc(203.88,116.91) 203.92,116.94 arc(203.94,116.97) 203.95,117.02 203.95,117.21 arc(203.91,117.3) 203.82,117.34 v4(203.6,117.34)
  SIG2 w0.16: 202.86,104.78 202.86,104.39 arc(202.9,104.15) 203.04,103.95 204.14,102.85 arc(204.34,102.55) 204.41,102.2 204.41,92.64 arc(204.49,92.2) 204.74,91.83 208.22,88.36 arc(208.59,88.11) 209.03,88.02 217.29,88.02 arc(217.58,87.96) 217.82,87.8 218.6,87.02 arc(218.77,86.77) 218.83,86.48 218.83,73.13 218.55,72.85 218.55,72.39 218.83,72.11 218.83,71.43 arc(218.8,71.28) 218.71,71.16 216.58,69.02 arc(216.33,68.65) 216.24,68.21 216.24,67.23 arc(216.24,67.16) 216.22,67.11 216.19,67.02 arc(216.13,66.94) 216.04,66.89 215.97,66.87 arc(215.93,66.86) 215.9,66.86 214.83,66.86 arc(214.67,66.8) 214.61,66.64 214.61,66.32 arc(214.64,66.13) 214.75,65.97 YJ29.A25
FC34_RDP3: length 72.3
  TOP w0.147: U1.P27 204.05,119.74 arc(204.07,119.64) 204.12,119.56 204.29,119.4 arc(204.35,119.36) 204.42,119.34 v4(204.5,119.34)
  SIG2 w0.112: v4(204.5,119.34) 204.27,119.34 arc(204.18,119.3) 204.15,119.21 204.15,119.02 arc(204.16,118.97) 204.18,118.94 arc(204.22,118.91) 204.26,118.91 204.56,118.91 arc(204.78,118.86) 204.97,118.73 arc(205.1,118.54) 205.14,118.32 205.14,104.85 arc(205.2,104.56) 205.37,104.31 205.38,104.3 205.51,104.3 205.53,104.28
  SIG2 w0.16: 205.53,104.28 207.07,102.74 arc(207.36,102.32) 207.45,101.82 207.45,95.69 arc(207.51,95.4) 207.68,95.15 211.68,91.15 arc(211.92,90.99) 212.22,90.93 218.19,90.93 arc(218.63,90.84) 219,90.59 220.97,88.62 arc(221.21,88.25) 221.3,87.82 221.3,70.5 arc(221.24,70.21) 221.08,69.96 220.28,69.16 arc(220.12,68.92) 220.06,68.62 220.06,64.61 arc(219.93,63.95) 219.55,63.38 219.08,62.91 219.03,62.86 arc(218.94,62.72) 218.91,62.57 218.91,61.97 arc(218.88,61.85) 218.81,61.75 218.29,61.23 arc(218.15,61.01) 218.1,60.76 YJ29.A18
FC34_TDN0: length 47.2
  TOP w0.147: U1.B28 203.55,107.34 v4(203.6,107.34)
  SIG5 w0.112: 202.86,105 202.86,105.03 202.95,105.12 202.95,106.5 arc(202.98,106.66) 203.06,106.79 arc(203.19,106.87) 203.35,106.91 203.79,106.91 arc(203.85,106.92) 203.9,106.95 203.91,106.96 arc(203.94,107.01) 203.95,107.05 203.95,107.21 arc(203.91,107.3) 203.82,107.34 v4(203.6,107.34)
  SIG5 w0.16: YJ29.A37 205.15,65.97 arc(205.04,66.13) 205.01,66.32 205.01,66.59 arc(205.09,66.78) 205.28,66.86 206.34,66.86 arc(206.47,66.92) 206.53,67.05 206.53,68.18 arc(206.5,68.32) 206.41,68.44 203.51,71.35 arc(203.26,71.72) 203.18,72.16 203.18,79.65 arc(203.15,79.8) 203.07,79.92 202.2,80.78 arc(201.95,81.16) 201.87,81.59 201.87,100.26 201.71,100.41 201.71,101.17 201.87,101.32 201.87,102.09 201.69,102.26 201.69,102.98 201.87,103.15 201.87,103.31 arc(201.88,103.46) 201.9,103.6 arc(202.02,103.88) 202.2,104.12 202.83,104.75 arc(202.85,104.78) 202.86,104.81 202.86,105
FC34_TDN1: length 68
  TOP w0.147: v4(204.5,109.34) 204.5,109.47 arc(204.48,109.58) 204.41,109.68 204.37,109.72 arc(204.23,109.81) 204.07,109.84 U1.D27
  SIG4 w0.112: v4(204.5,109.34) 204.27,109.34 arc(204.18,109.3) 204.15,109.21 204.15,109.06 arc(204.16,109) 204.19,108.95 arc(204.24,108.92) 204.3,108.91 204.68,108.91 arc(204.86,108.87) 205.01,108.77 arc(205.11,108.61) 205.15,108.43 205.15,104.74 205.24,104.65
  SIG4 w0.155: 209.31,61.97 arc(209.3,61.91) 209.28,61.84
  SIG4 w0.16: 209.31,61.97 209.31,62.57 arc(209.34,62.72) 209.43,62.86 209.48,62.91 arc(209.61,63) 209.75,63.03 218.73,63.03 arc(219.02,63.08) 219.27,63.25 219.84,63.81 arc(220,64.06) 220.06,64.35 220.06,66.47 arc(220,66.76) 219.84,67.01 217.98,68.86 arc(217.73,69.03) 217.44,69.09 216.18,69.09 arc(215.89,69.14) 215.64,69.31 207.68,77.27 arc(207.51,77.52) 207.45,77.81 207.45,101.51 arc(207.4,101.8) 207.23,102.05 205.38,103.9 arc(205.28,104.05) 205.24,104.23 205.24,104.42 205.24,104.42 205.24,104.65 ; YJ29.A6 208.5,60.81 arc(208.54,61.02) 208.66,61.2 209.19,61.72 arc(209.24,61.78) 209.28,61.84
FC34_TDN2: length 53.4
  TOP w0.147: v4(203.6,111.34) 203.55,111.34 U1.F28
  SIG4 w0.112: 202.86,104.9 202.86,104.93 202.95,105.02 202.95,110.43 arc(202.98,110.61) 203.09,110.77 arc(203.24,110.87) 203.42,110.91 203.8,110.91 arc(203.86,110.92) 203.91,110.95 arc(203.94,111) 203.95,111.06 203.95,111.21 arc(203.91,111.3) 203.82,111.34 v4(203.6,111.34)
  SIG4 w0.16: YJ29.A34 207.55,65.97 arc(207.44,66.13) 207.41,66.32 207.41,66.57 arc(207.49,66.78) 207.7,66.86 208.7,66.86 arc(208.86,66.93) 208.93,67.09 208.93,67.79 208.77,67.95 208.77,68.66 208.93,68.81 208.93,69.32 208.72,69.52 208.72,70.13 208.93,70.33 208.93,71.59 arc(208.9,71.74) 208.81,71.86 205.25,75.43 arc(205,75.8) 204.91,76.23 204.91,78.14 arc(204.89,78.29) 204.8,78.41 202.2,81.01 arc(201.95,81.38) 201.87,81.82 201.87,90.56 arc(201.95,90.99) 202.2,91.37 204.29,93.46 arc(204.38,93.58) 204.41,93.73 204.41,101.92 arc(204.38,102.07) 204.29,102.19 203.19,103.3 arc(202.94,103.67) 202.86,104.1 202.86,104.9
FC34_TDN3: length 67.3
  TOP w0.147: U1.A25 206.05,106.79 arc(206.18,106.47) v4(206.5,106.34)
  SIG5 w0.112: v4(206.5,106.34) 206.27,106.34 arc(206.18,106.3) 206.15,106.21 206.15,106.05 arc(206.12,105.93) 206.05,105.83 206.04,105.81 arc(205.92,105.74) 205.79,105.71 205.35,105.71 arc(205.27,105.69) 205.2,105.65 arc(205.16,105.58) 205.14,105.5 205.14,104.77 205.24,104.68 205.24,104.65
  SIG5 w0.16: YJ29.A3 206.1,60.79 arc(206.15,61.02) 206.27,61.21 206.81,61.75 arc(206.88,61.85) 206.91,61.97 206.91,62.57 arc(206.91,62.6) 206.91,62.64 arc(206.95,62.76) 207.03,62.86 207.08,62.91 arc(207.21,63) 207.35,63.03 218.61,63.03 arc(218.9,63.08) 219.14,63.25 219.84,63.94 arc(220,64.19) 220.06,64.48 220.06,66.47 arc(220,66.76) 219.84,67.01 215.31,71.53 arc(215.07,71.69) 214.77,71.75 213.59,71.75 arc(213.3,71.81) 213.05,71.98 206.96,78.07 arc(206.79,78.31) 206.73,78.61 206.73,91.46 arc(206.67,91.75) 206.51,92 205.47,93.04 arc(205.31,93.29) 205.25,93.58 205.25,97.02 205.24,97.03 205.24,104.65
FC34_TDP0: length 47.2
  TOP w0.147: U1.B27 204.05,107.79 arc(204.18,107.47) v4(204.5,107.34)
  SIG5 w0.112: 203.24,105 203.24,105.03 203.14,105.12 203.14,106.5 arc(203.16,106.58) 203.2,106.65 arc(203.27,106.69) 203.35,106.71 203.79,106.71 arc(203.92,106.74) 204.04,106.81 204.05,106.83 arc(204.12,106.93) 204.15,107.05 204.15,107.21 arc(204.18,107.3) 204.27,107.34 v4(204.5,107.34)
  SIG5 w0.16: 203.24,105 203.24,104.81 arc(203.2,104.63) 203.1,104.48 202.47,103.85 arc(202.35,103.69) 202.27,103.5 arc(202.25,103.41) 202.25,103.31 202.25,81.59 arc(202.31,81.3) 202.47,81.05 203.33,80.19 arc(203.5,79.94) 203.56,79.65 203.56,72.16 arc(203.62,71.86) 203.78,71.62 206.68,68.71 arc(206.85,68.47) 206.91,68.18 206.91,65.97 arc(206.88,65.85) 206.81,65.75 206.5,65.43 206.24,65.18 arc(206.14,65.02) 206.1,64.84 YJ29.A36
FC34_TDP1: length 68
  TOP w0.147: v4(203.6,109.34) 203.55,109.34 U1.D28
  SIG4 w0.112: v4(203.6,109.34) 203.82,109.34 arc(203.91,109.3) 203.95,109.21 203.95,109.06 arc(203.98,108.92) 204.05,108.81 arc(204.17,108.73) 204.3,108.71 204.68,108.71 arc(204.78,108.69) 204.87,108.63 arc(204.93,108.54) 204.95,108.43 204.95,104.74 204.86,104.65
  SIG4 w0.16: YJ29.A5 207.55,61.97 arc(207.44,62.13) 207.41,62.32 207.41,62.6 arc(207.48,62.79) 207.66,62.86 208.58,62.86 arc(208.87,62.92) 209.12,63.08 209.16,63.13 209.21,63.18 arc(209.46,63.35) 209.75,63.41 218.73,63.41 arc(218.88,63.44) 219,63.52 219.57,64.08 arc(219.65,64.21) 219.68,64.35 219.68,66.47 arc(219.65,66.61) 219.57,66.74 218.98,67.32 218.62,67.32 218.26,67.68 218.26,68.04 217.71,68.59 arc(217.59,68.68) 217.44,68.7 216.18,68.7 arc(215.74,68.79) 215.37,69.04 207.41,77 arc(207.16,77.37) 207.07,77.81 207.07,101.51 arc(207.04,101.66) 206.96,101.78 205.11,103.63 arc(204.93,103.91) 204.86,104.23 204.86,104.26 204.86,104.27 204.86,104.65
FC34_TDP2: length 53.4
  TOP w0.147: v4(204.5,111.34) 204.5,111.47 arc(204.48,111.58) 204.41,111.68 204.37,111.72 arc(204.23,111.81) 204.07,111.84 U1.F27
  SIG4 w0.112: v4(204.5,111.34) 204.27,111.34 arc(204.18,111.3) 204.15,111.21 204.15,111.06 arc(204.12,110.92) 204.04,110.81 arc(203.93,110.73) 203.8,110.71 203.42,110.71 arc(203.32,110.69) 203.23,110.63 arc(203.17,110.54) 203.14,110.43 203.14,105.02 203.24,104.93 203.24,104.9
  SIG4 w0.155: 209.31,65.97 arc(209.29,65.88) 209.25,65.8
  SIG4 w0.16: 203.24,104.9 203.24,104.1 arc(203.29,103.81) 203.46,103.57 204.56,102.46 arc(204.73,102.21) 204.79,101.92 204.79,93.73 arc(204.73,93.44) 204.56,93.19 202.47,91.1 arc(202.31,90.85) 202.25,90.56 202.25,81.82 arc(202.31,81.53) 202.47,81.28 205.07,78.68 arc(205.24,78.43) 205.3,78.14 205.3,76.23 arc(205.35,75.94) 205.52,75.69 209.08,72.13 arc(209.25,71.88) 209.31,71.59 209.31,65.97 ; YJ29.A33 208.5,64.75 arc(208.55,65.01) 208.7,65.23 209.14,65.67 arc(209.2,65.74) 209.25,65.8
FC34_TDP3: length 67.3
  TOP w0.147: U1.A26 205.1,106.84 v4(205.6,106.34)
  SIG5 w0.112: 204.86,104.65 204.86,104.68 204.95,104.77 204.95,105.5 arc(204.98,105.66) 205.06,105.79 arc(205.19,105.87) 205.35,105.91 205.79,105.91 arc(205.85,105.92) 205.9,105.95 205.91,105.96 arc(205.94,106.01) 205.95,106.05 205.95,106.21 arc(205.91,106.3) 205.82,106.34 v4(205.6,106.34)
  SIG5 w0.16: 204.86,104.65 204.86,103.89 204.7,103.73 204.7,102.97 204.86,102.82 204.86,102.06 204.73,101.93 204.73,101.12 204.86,100.99 204.86,96.87 204.87,96.86 204.87,93.58 arc(204.95,93.14) 205.2,92.77 206.24,91.73 arc(206.32,91.61) 206.35,91.46 206.35,78.61 arc(206.44,78.17) 206.69,77.8 212.78,71.71 arc(213.15,71.46) 213.59,71.37 214.77,71.37 arc(214.92,71.34) 215.04,71.26 219.57,66.74 arc(219.65,66.61) 219.68,66.47 219.68,64.48 arc(219.65,64.33) 219.57,64.21 218.87,63.52 arc(218.75,63.44) 218.61,63.41 207.35,63.41 arc(207.06,63.35) 206.81,63.18 206.76,63.13 206.72,63.08 arc(206.47,62.92) 206.18,62.86 205.32,62.86 arc(205.1,62.77) 205.01,62.54 205.01,62.32 arc(205.04,62.13) 205.15,61.97 YJ29.A2
FC35_RDN0: length 77.4
  TOP w0.147: v4(207.5,112.34) 207.4,112.34 arc(207.32,112.36) 207.24,112.41 207.18,112.47 arc(207.08,112.62) 207.05,112.79 U1.G24
  SIG3 w0.112: v4(207.5,112.34) 207.27,112.34 arc(207.18,112.3) 207.15,112.21 207.15,112.02 arc(207.16,111.97) 207.18,111.94 arc(207.22,111.91) 207.26,111.91 208.57,111.91 arc(208.79,111.86) 208.98,111.73 arc(209.1,111.55) 209.15,111.32 209.15,105.35 arc(209.19,105.13) 209.31,104.95 209.6,104.66 209.73,104.66
  SIG3 w0.16: 209.73,104.66 211.44,102.95 arc(211.69,102.58) 211.77,102.14 211.77,97.47 arc(211.83,97.18) 212,96.93 213.4,95.52 arc(213.65,95.36) 213.94,95.3 221.75,95.3 arc(222.04,95.24) 222.28,95.07 225.57,91.79 arc(225.73,91.54) 225.79,91.25 225.79,68.97 arc(225.73,68.68) 225.57,68.43 222.93,65.8 arc(222.77,65.55) 222.71,65.26 222.71,59.01 arc(222.62,58.58) 222.37,58.21 221.56,57.39 220.67,56.5 219.03,54.86 arc(218.94,54.72) 218.91,54.57 218.91,53.97 arc(218.88,53.85) 218.81,53.75 218.3,53.23 arc(218.15,53.01) 218.1,52.75 YJ29.B18
FC35_RDN1: length 74.3
  TOP w0.147: v4(206.6,114.34) 206.55,114.34 U1.J25
  SIG3 w0.112: v4(206.6,114.34) 206.82,114.34 arc(206.91,114.3) 206.95,114.21 206.95,114.02 arc(206.94,113.97) 206.92,113.94 arc(206.88,113.91) 206.84,113.91 206.54,113.91 arc(206.31,113.86) 206.12,113.73 arc(206,113.54) 205.95,113.32 205.95,111.3 arc(205.99,111.1) 206.1,110.93 arc(206.27,110.82) 206.47,110.78 206.68,110.78 arc(206.79,110.76) 206.87,110.7 arc(206.93,110.61) 206.95,110.51 206.95,104.89 206.86,104.8 206.86,104.78
  SIG3 w0.16: YJ29.B22 217.15,57.97 arc(217.04,58.13) 217.01,58.32 217.01,58.58 arc(217.09,58.78) 217.29,58.86 218.18,58.86 arc(218.47,58.92) 218.72,59.08 218.76,59.13 218.81,59.18 arc(218.84,59.21) 218.86,59.23 219.22,59.59 219.22,59.95 219.58,60.31 219.94,60.31 220.52,60.89 arc(220.87,61.41) 221,62.04 221,65.79 arc(221.08,66.22) 221.33,66.6 222.58,67.85 arc(222.67,67.97) 222.69,68.12 222.69,68.64 arc(222.78,69.08) 223.03,69.45 223.22,69.64 arc(223.3,69.76) 223.33,69.91 223.33,90.39 arc(223.3,90.54) 223.22,90.66 221.16,92.72 arc(221.03,92.81) 220.89,92.83 212.6,92.83 arc(212.16,92.92) 211.79,93.17 209.66,95.3 arc(209.41,95.67) 209.33,96.1 209.33,101.44 arc(209.3,101.59) 209.21,101.71 207.16,103.76 arc(206.94,104.1) 206.86,104.5 206.86,104.78
FC35_RDN2: length 78.6
  TOP w0.147: U1.L24 207.05,116.74 arc(207.07,116.64) 207.12,116.56 207.29,116.4 arc(207.35,116.36) 207.42,116.34 v4(207.5,116.34)
  SIG2 w0.112: 207.57,104.66 207.44,104.66 207.25,104.85 arc(207.17,104.96) 207.15,105.1 207.15,110.51 arc(207.11,110.69) 207.01,110.84 arc(206.86,110.94) 206.68,110.98 206.47,110.98 arc(206.35,111) 206.24,111.07 arc(206.17,111.17) 206.15,111.3 206.15,115.32 arc(206.18,115.47) 206.26,115.59 arc(206.39,115.68) 206.54,115.71 206.84,115.71 arc(206.96,115.73) 207.06,115.8 arc(207.12,115.9) 207.15,116.02 207.15,116.21 arc(207.18,116.3) 207.27,116.34 v4(207.5,116.34)
  SIG2 w0.16: YJ29.B24 215.7,56.79 arc(215.75,57.02) 215.87,57.21 216.41,57.75 arc(216.48,57.85) 216.51,57.97 216.51,58.57 arc(216.54,58.72) 216.63,58.86 216.68,58.91 arc(216.73,58.95) 216.78,58.98 arc(216.86,59.01) 216.95,59.03 218.96,59.03 arc(219.4,59.11) 219.77,59.36 221.04,60.63 arc(221.29,61) 221.38,61.44 221.38,66.94 arc(221.44,67.23) 221.6,67.48 223.49,69.37 arc(223.65,69.61) 223.71,69.9 223.71,90.23 arc(223.63,90.67) 223.38,91.04 221.54,92.88 arc(221.17,93.13) 220.73,93.22 213.1,93.22 arc(212.81,93.27) 212.57,93.44 209.84,96.17 arc(209.67,96.41) 209.61,96.71 209.61,101.99 arc(209.5,102.57) 209.17,103.06 207.57,104.66
FC35_RDN3: length 85.5
  TOP w0.147: v4(206.6,118.34) 206.55,118.34 U1.N25
  SIG2 w0.112: 209.52,104.33 209.5,104.35 209.5,104.48 209.09,104.89 arc(208.99,105.05) 208.95,105.23 208.95,111.52 arc(208.94,111.58) 208.9,111.63 208.87,111.66 arc(208.79,111.72) 208.68,111.74 208.43,111.74 arc(208.24,111.78) 208.09,111.88 arc(207.98,112.04) 207.95,112.22 207.95,117.32 arc(207.92,117.47) 207.83,117.59 arc(207.71,117.68) 207.56,117.71 207.26,117.71 arc(207.14,117.73) 207.04,117.8 arc(206.97,117.9) 206.95,118.02 206.95,118.21 arc(206.91,118.3) 206.82,118.34 v4(206.6,118.34)
  SIG2 w0.16: 209.52,104.33 211,102.85 arc(211.29,102.42) 211.39,101.9 211.39,97.47 arc(211.48,97.03) 211.73,96.66 213.25,95.14 arc(213.49,94.98) 213.78,94.92 221.57,94.92 arc(221.86,94.86) 222.11,94.69 225.19,91.61 arc(225.35,91.36) 225.41,91.07 225.41,72.23 225.21,72.03 225.21,71.42 225.41,71.21 225.41,70.71 225.2,70.49 225.2,69.91 225.41,69.69 225.41,69.18 arc(225.35,68.89) 225.19,68.64 222.56,66.02 arc(222.4,65.77) 222.34,65.48 222.34,58.85 arc(222.28,58.56) 222.12,58.31 219.44,55.63 arc(219.19,55.46) 218.9,55.41 216.95,55.41 arc(216.77,55.38) 216.6,55.32 arc(216.5,55.26) 216.41,55.18 216.36,55.13 216.32,55.08 arc(216.07,54.92) 215.78,54.86 214.86,54.86 arc(214.68,54.79) 214.61,54.61 214.61,54.32 arc(214.64,54.13) 214.75,53.97 YJ29.B14
FC35_RDP0: length 77.4
  TOP w0.147: v4(206.6,112.34) 206.55,112.34 U1.G25
  SIG3 w0.112: v4(206.6,112.34) 206.82,112.34 arc(206.91,112.3) 206.95,112.21 206.95,112.02 arc(206.97,111.9) 207.04,111.8 arc(207.14,111.73) 207.26,111.71 208.57,111.71 arc(208.71,111.68) 208.84,111.6 arc(208.92,111.47) 208.95,111.32 208.95,105.35 arc(209.01,105.05) 209.17,104.81 209.46,104.52 209.46,104.39
  SIG3 w0.16: YJ29.B17 217.15,53.97 arc(217.04,54.13) 217.01,54.32 217.01,54.58 arc(217.09,54.78) 217.29,54.86 218.18,54.86 arc(218.47,54.92) 218.72,55.08 218.76,55.13 218.81,55.18 219.41,55.78 219.41,56.09 219.82,56.5 220.13,56.5 220.81,57.18 220.81,57.48 221.22,57.89 221.52,57.89 222.11,58.48 arc(222.27,58.72) 222.33,59.01 222.33,65.26 arc(222.42,65.7) 222.66,66.07 225.3,68.7 arc(225.38,68.83) 225.41,68.97 225.41,91.25 arc(225.38,91.4) 225.3,91.52 222.02,94.81 arc(221.89,94.89) 221.75,94.92 213.94,94.92 arc(213.51,95) 213.13,95.25 211.73,96.66 arc(211.48,97.03) 211.39,97.47 211.39,102.14 211.39,102.14 arc(211.33,102.43) 211.17,102.68 209.46,104.39
FC35_RDP1: length 74.3
  TOP w0.147: U1.J24 207.05,114.79 arc(207.08,114.62) 207.18,114.47 207.24,114.41 arc(207.32,114.36) 207.4,114.34 v4(207.5,114.34)
  SIG3 w0.112: 207.24,104.78 207.24,104.8 207.15,104.9 207.15,110.51 arc(207.11,110.69) 207.01,110.84 arc(206.86,110.94) 206.68,110.98 206.47,110.98 arc(206.35,111) 206.24,111.07 arc(206.17,111.17) 206.15,111.3 206.15,113.32 arc(206.18,113.47) 206.26,113.59 arc(206.39,113.68) 206.54,113.71 206.84,113.71 arc(206.96,113.73) 207.06,113.8 arc(207.12,113.9) 207.15,114.02 207.15,114.21 arc(207.18,114.3) 207.27,114.34 v4(207.5,114.34)
  SIG3 w0.16: 207.24,104.78 207.24,104.5 arc(207.29,104.25) 207.43,104.03 209.48,101.98 arc(209.65,101.73) 209.71,101.44 209.71,96.1 arc(209.77,95.81) 209.93,95.57 212.06,93.44 arc(212.3,93.27) 212.6,93.22 220.89,93.22 arc(221.18,93.16) 221.43,92.99 223.49,90.93 arc(223.65,90.68) 223.71,90.39 223.71,69.91 arc(223.65,69.62) 223.49,69.37 223.3,69.18 arc(223.13,68.93) 223.08,68.64 223.08,68.12 arc(223.02,67.82) 222.85,67.58 221.6,66.33 arc(221.44,66.08) 221.38,65.79 221.38,62.04 arc(221.23,61.27) 220.79,60.62 219.11,58.94 219.11,58.94 arc(219.1,58.93) 219.08,58.91 219.03,58.86 arc(218.94,58.72) 218.91,58.57 218.91,57.97 arc(218.88,57.85) 218.81,57.75 218.28,57.21 arc(218.15,57.02) 218.1,56.78 YJ29.B21
FC35_RDP2: length 78.6
  TOP w0.147: U1.L25 206.55,116.34 v4(206.6,116.34)
  SIG2 w0.112: v4(206.6,116.34) 206.82,116.34 arc(206.91,116.3) 206.95,116.21 206.95,116.02 arc(206.94,115.97) 206.92,115.94 arc(206.88,115.91) 206.84,115.91 206.54,115.91 arc(206.31,115.86) 206.12,115.73 arc(206,115.54) 205.95,115.32 205.95,111.3 arc(205.99,111.1) 206.1,110.93 arc(206.27,110.82) 206.47,110.78 206.68,110.78 arc(206.79,110.76) 206.87,110.7 arc(206.93,110.61) 206.95,110.51 206.95,105.1 arc(206.99,104.89) 207.11,104.71 207.3,104.52 207.3,104.39
  SIG2 w0.16: 207.3,104.39 208.9,102.79 arc(209.15,102.42) 209.23,101.99 209.23,96.71 arc(209.32,96.27) 209.57,95.9 212.3,93.17 arc(212.67,92.92) 213.1,92.83 220.73,92.83 arc(221.02,92.78) 221.27,92.61 223.11,90.77 arc(223.27,90.52) 223.33,90.23 223.33,72.95 223.13,72.75 223.13,72.14 223.33,71.94 223.33,71.43 223.1,71.2 223.1,70.64 223.33,70.41 223.33,69.91 arc(223.3,69.76) 223.22,69.64 221.33,67.75 arc(221.08,67.38) 221,66.94 221,61.44 arc(220.94,61.15) 220.77,60.9 219.5,59.63 arc(219.25,59.46) 218.96,59.41 216.95,59.41 arc(216.77,59.38) 216.6,59.32 arc(216.5,59.26) 216.41,59.18 216.36,59.13 216.32,59.08 arc(216.07,58.92) 215.78,58.86 214.89,58.86 arc(214.69,58.78) 214.61,58.57 214.61,58.32 arc(214.64,58.13) 214.75,57.97 YJ29.B25
FC35_RDP3: length 85.5
  TOP w0.147: U1.N24 207.05,118.75 arc(207.07,118.65) 207.12,118.57 207.29,118.4 arc(207.35,118.36) 207.42,118.34 v4(207.5,118.34)
  SIG2 w0.112: 209.79,104.6 209.77,104.62 209.64,104.62 209.23,105.03 arc(209.17,105.12) 209.15,105.23 209.15,111.52 arc(209.12,111.65) 209.04,111.77 209.01,111.8 arc(208.86,111.9) 208.68,111.94 208.43,111.94 arc(208.32,111.96) 208.23,112.02 arc(208.17,112.11) 208.14,112.22 208.14,117.32 arc(208.1,117.54) 207.97,117.73 arc(207.78,117.86) 207.56,117.91 207.26,117.91 arc(207.22,117.91) 207.18,117.94 arc(207.16,117.97) 207.15,118.02 207.15,118.21 arc(207.18,118.3) 207.27,118.34 v4(207.5,118.34)
  SIG2 w0.16: YJ29.B15 215.7,52.8 arc(215.74,53.02) 215.87,53.2 216.41,53.75 arc(216.48,53.85) 216.51,53.97 216.51,54.57 arc(216.54,54.72) 216.63,54.86 216.68,54.91 arc(216.73,54.95) 216.78,54.98 arc(216.86,55.01) 216.95,55.03 218.9,55.03 arc(219.34,55.11) 219.71,55.36 222.39,58.04 arc(222.63,58.41) 222.72,58.85 222.72,65.48 arc(222.75,65.63) 222.83,65.75 225.46,68.37 arc(225.71,68.74) 225.79,69.18 225.79,91.07 arc(225.71,91.51) 225.46,91.88 222.37,94.96 arc(222,95.21) 221.57,95.3 213.78,95.3 arc(213.64,95.33) 213.52,95.41 212,96.93 arc(211.83,97.18) 211.77,97.47 211.77,97.47 211.77,101.9 arc(211.64,102.56) 211.27,103.12 209.79,104.6
FC35_TDN0: length 72.5
  TOP w0.147: v4(205.6,108.34) 205.55,108.34 U1.C26
  SIG5 w0.112: 206.86,104.9 206.86,104.93 206.95,105.02 206.95,107.51 arc(206.94,107.59) 206.89,107.66 arc(206.83,107.7) 206.75,107.72 206.31,107.72 arc(206.17,107.74) 206.06,107.82 206.05,107.83 arc(205.98,107.94) 205.95,108.06 205.95,108.21 arc(205.91,108.3) 205.82,108.34 v4(205.6,108.34)
  SIG5 w0.16: YJ29.B37 205.15,57.97 arc(205.04,58.13) 205.01,58.32 205.01,58.53 arc(205.1,58.77) 205.34,58.86 206.18,58.86 arc(206.47,58.92) 206.72,59.08 206.76,59.13 206.81,59.18 arc(207.06,59.35) 207.35,59.41 218.67,59.41 arc(218.81,59.44) 218.94,59.52 220.89,61.47 arc(220.97,61.59) 221,61.73 221,68.43 arc(220.97,68.58) 220.89,68.7 219.16,70.42 arc(218.91,70.8) 218.83,71.23 218.83,71.99 218.7,72.12 218.7,72.93 218.83,73.06 218.83,86.4 arc(218.77,86.69) 218.6,86.94 209.46,96.09 arc(209.29,96.33) 209.23,96.62 209.23,100.87 arc(209.21,101.05) 209.15,101.22 arc(209.09,101.32) 209.01,101.41 208.38,102.04 208.16,102.04 207.62,102.58 207.62,102.8 207.08,103.33 arc(206.92,103.58) 206.86,103.87 206.86,104.9
FC35_TDN1: length 72.3
  TOP w0.147: U1.E25 206.07,110.84 arc(206.23,110.81) 206.37,110.72 206.41,110.68 arc(206.48,110.58) 206.5,110.47 v4(206.5,110.34)
  SIG4 w0.112: 207.24,104.85 207.24,104.88 207.15,104.97 207.15,109.43 arc(207.11,109.61) 207.01,109.77 arc(206.86,109.87) 206.68,109.91 206.3,109.91 arc(206.24,109.92) 206.19,109.95 arc(206.16,110) 206.15,110.06 206.15,110.21 arc(206.18,110.3) 206.27,110.34 v4(206.5,110.34)
  SIG4 w0.16: YJ29.B33 208.5,56.83 arc(208.54,57.02) 208.64,57.18 209.13,57.66 arc(209.26,57.86) 209.31,58.09 209.31,58.57 arc(209.34,58.72) 209.43,58.86 209.48,58.91 arc(209.61,59) 209.75,59.03 219.05,59.03 arc(219.34,59.08) 219.59,59.25 221.16,60.81 arc(221.32,61.06) 221.38,61.35 221.38,68.22 arc(221.32,68.51) 221.16,68.76 219.43,70.48 arc(219.27,70.73) 219.21,71.02 219.21,86.58 arc(219.15,86.87) 218.99,87.12 209.84,96.27 arc(209.67,96.52) 209.61,96.81 209.61,101.64 arc(209.56,101.93) 209.39,102.18 207.47,104.1 arc(207.3,104.35) 207.24,104.64 207.24,104.85
FC35_TDN2: length 77.4
  TOP w0.147: U1.B24 207.55,107.34 v4(207.6,107.34)
  SIG5 w0.112: v4(207.6,107.34) 207.75,107.34 arc(207.84,107.3) 207.87,107.21 207.87,107.08 arc(207.9,106.95) 207.97,106.85 207.98,106.84 arc(208.1,106.76) 208.24,106.73 208.75,106.73 arc(208.89,106.67) 208.95,106.53 208.95,105.19 arc(208.95,105.17) 208.96,105.15 arc(208.99,105.02) 209.07,104.91 209.31,104.67 209.31,104.54 209.33,104.52
  SIG5 w0.16: YJ29.B2 205.15,53.97 arc(205.04,54.13) 205.01,54.32 205.01,54.59 arc(205.09,54.78) 205.28,54.86 206.18,54.86 arc(206.47,54.92) 206.72,55.08 206.76,55.13 206.81,55.18 arc(207.06,55.35) 207.35,55.41 219.37,55.41 arc(219.51,55.44) 219.64,55.52 221.23,57.11 221.23,57.39 221.61,57.76 221.88,57.76 222.2,58.08 arc(222.29,58.21) 222.32,58.35 222.32,70.54 arc(222.29,70.69) 222.2,70.81 221.26,71.76 arc(221.01,72.13) 220.92,72.57 220.92,88.96 arc(220.86,89.25) 220.7,89.5 217.58,92.61 arc(217.34,92.78) 217.05,92.83 216.13,92.83 arc(215.69,92.92) 215.32,93.17 211.67,96.82 arc(211.5,97.07) 211.44,97.36 211.44,98.43 211.32,98.56 211.32,99.37 211.44,99.5 211.44,100.26 211.32,100.39 211.32,101.2 211.44,101.33 211.44,102.09 arc(211.38,102.38) 211.22,102.63 210.35,103.5 210.11,103.5 209.69,103.92 209.69,104.16 209.33,104.52
FC35_TDN3: length 76.5
  TOP w0.147: U1.D23 208.07,109.84 arc(208.23,109.81) 208.37,109.72 208.41,109.68 arc(208.48,109.58) 208.5,109.47 v4(208.5,109.34)
  SIG4 w0.112: 209.24,104.9 209.24,104.94 209.15,105.03 209.15,108.43 arc(209.11,108.61) 209.01,108.77 arc(208.86,108.87) 208.68,108.91 208.3,108.91 arc(208.24,108.92) 208.19,108.95 arc(208.16,109) 208.15,109.06 208.15,109.21 arc(208.18,109.3) 208.27,109.34 v4(208.5,109.34)
  SIG4 w0.16: YJ29.B6 208.5,52.67 arc(208.57,53.01) 208.76,53.29 208.88,53.42 209.21,53.75 arc(209.28,53.85) 209.31,53.97 209.31,54.57 arc(209.34,54.72) 209.43,54.86 209.48,54.91 arc(209.61,55) 209.75,55.03 218.99,55.03 arc(219.28,55.08) 219.53,55.25 222.47,58.2 arc(222.64,58.44) 222.7,58.73 222.7,69.91 arc(222.64,70.2) 222.47,70.45 221.53,71.4 arc(221.36,71.64) 221.3,71.93 221.3,89.14 arc(221.25,89.43) 221.08,89.68 217.64,93.12 arc(217.39,93.28) 217.1,93.34 216,93.34 arc(215.71,93.4) 215.46,93.57 212,97.03 arc(211.83,97.28) 211.77,97.57 211.77,101.64 arc(211.71,101.93) 211.55,102.18 209.47,104.26 arc(209.3,104.51) 209.24,104.8 209.24,104.9
FC35_TDP0: length 72.5
  TOP w0.147: U1.C25 206.05,108.79 arc(206.18,108.47) v4(206.5,108.34)
  SIG5 w0.112: 207.24,104.9 207.24,104.93 207.15,105.02 207.15,107.51 arc(207.12,107.67) 207.03,107.8 arc(206.9,107.88) 206.75,107.91 206.31,107.91 arc(206.25,107.93) 206.2,107.96 206.19,107.97 arc(206.16,108.01) 206.15,108.06 206.15,108.21 arc(206.18,108.3) 206.27,108.34 v4(206.5,108.34)
  SIG5 w0.16: YJ29.B36 206.1,56.78 arc(206.15,57.02) 206.28,57.22 206.81,57.75 arc(206.88,57.85) 206.91,57.97 206.91,58.57 arc(206.91,58.6) 206.91,58.63 arc(206.95,58.75) 207.03,58.86 207.08,58.91 arc(207.21,59) 207.35,59.03 218.67,59.03 arc(218.96,59.08) 219.21,59.25 221.16,61.2 arc(221.32,61.44) 221.38,61.73 221.38,68.43 arc(221.32,68.72) 221.16,68.97 219.43,70.69 arc(219.26,70.94) 219.21,71.23 219.21,86.4 arc(219.12,86.84) 218.87,87.21 209.73,96.35 arc(209.64,96.48) 209.61,96.62 209.61,100.87 arc(209.58,101.14) 209.49,101.39 arc(209.4,101.54) 209.28,101.68 207.35,103.6 arc(207.27,103.73) 207.24,103.87 207.24,104.9
FC35_TDP1: length 72.3
  TOP w0.147: U1.E26 205.55,110.34 v4(205.6,110.34)
  SIG4 w0.112: v4(205.6,110.34) 205.82,110.34 arc(205.91,110.3) 205.95,110.21 205.95,110.06 arc(205.98,109.92) 206.05,109.81 arc(206.17,109.73) 206.3,109.71 206.68,109.71 arc(206.78,109.69) 206.87,109.63 arc(206.93,109.54) 206.95,109.43 206.95,104.97 206.86,104.88 206.86,104.85
  SIG4 w0.16: YJ29.B34 207.55,57.97 arc(207.44,58.13) 207.41,58.32 207.41,58.57 arc(207.49,58.78) 207.69,58.86 208.58,58.86 arc(208.75,58.88) 208.91,58.94 arc(209.02,59) 209.12,59.08 209.16,59.13 209.21,59.18 arc(209.46,59.35) 209.75,59.41 219.05,59.41 arc(219.2,59.44) 219.32,59.52 219.78,59.98 219.78,60.34 220.14,60.7 220.5,60.7 220.89,61.08 arc(220.97,61.21) 221,61.35 221,68.22 arc(220.97,68.36) 220.89,68.49 219.16,70.21 arc(218.92,70.58) 218.83,71.02 218.83,86.58 arc(218.8,86.73) 218.72,86.85 209.57,96 arc(209.32,96.37) 209.23,96.81 209.23,101.64 arc(209.2,101.78) 209.12,101.91 207.2,103.83 arc(206.95,104.2) 206.86,104.64 206.86,104.85
FC35_TDP2: length 77.4
  TOP w0.147: U1.B23 208.05,107.79 arc(208.18,107.47) v4(208.5,107.34)
  SIG5 w0.112: 209.6,104.79 209.58,104.81 209.45,104.81 209.21,105.05 arc(209.17,105.1) 209.15,105.15 arc(209.15,105.17) 209.15,105.19 209.15,106.53 arc(209.03,106.81) 208.75,106.93 208.24,106.93 arc(208.17,106.94) 208.12,106.98 208.11,106.99 arc(208.08,107.03) 208.07,107.08 208.07,107.21 arc(208.11,107.3) 208.2,107.34 v4(208.5,107.34)
  SIG5 w0.16: YJ29.B3 206.1,52.82 arc(206.14,53.02) 206.25,53.18 206.81,53.75 arc(206.88,53.85) 206.91,53.97 206.91,54.57 arc(206.91,54.6) 206.91,54.64 arc(206.91,54.64) 206.91,54.64 arc(206.95,54.76) 207.03,54.86 207.08,54.91 arc(207.21,55) 207.35,55.03 219.37,55.03 arc(219.66,55.08) 219.91,55.25 222.47,57.81 arc(222.64,58.06) 222.7,58.35 222.7,70.54 arc(222.64,70.83) 222.47,71.08 221.53,72.03 arc(221.36,72.28) 221.3,72.57 221.3,88.96 arc(221.21,89.4) 220.97,89.77 217.85,92.88 arc(217.48,93.13) 217.05,93.22 216.13,93.22 arc(215.84,93.27) 215.59,93.44 211.94,97.09 arc(211.85,97.22) 211.82,97.36 211.82,102.09 arc(211.74,102.53) 211.49,102.9 209.6,104.79
FC35_TDP3: length 76.5
  TOP w0.147: v4(207.6,109.34) 207.55,109.34 U1.D24
  SIG4 w0.112: 208.86,104.9 208.86,104.93 208.95,105.03 208.95,108.43 arc(208.93,108.54) 208.87,108.63 arc(208.78,108.69) 208.68,108.71 208.3,108.71 arc(208.17,108.73) 208.05,108.81 arc(207.98,108.92) 207.95,109.06 207.95,109.21 arc(207.91,109.3) 207.82,109.34 v4(207.6,109.34)
  SIG4 w0.16: 208.86,104.9 208.86,104.8 arc(208.95,104.36) 209.2,103.99 211.28,101.91 arc(211.36,101.78) 211.39,101.64 211.39,97.57 arc(211.48,97.13) 211.73,96.76 215.19,93.3 arc(215.56,93.05) 216,92.96 217.1,92.96 arc(217.25,92.93) 217.37,92.85 220.81,89.41 arc(220.89,89.29) 220.92,89.14 220.92,71.93 arc(221.01,71.5) 221.26,71.13 222.2,70.18 arc(222.29,70.06) 222.32,69.91 222.32,58.73 arc(222.29,58.59) 222.2,58.47 221.2,57.46 220.84,57.46 220.48,57.1 220.48,56.74 219.26,55.52 arc(219.13,55.44) 218.99,55.41 209.75,55.41 arc(209.46,55.35) 209.21,55.18 209.16,55.13 209.12,55.08 arc(208.87,54.92) 208.58,54.86 207.68,54.86 arc(207.49,54.78) 207.41,54.59 207.41,54.32 arc(207.44,54.13) 207.55,53.97 YJ29.B5
FC36_37_PVDD0P8: length 5.8
  TOP w0.229: U1.Y23 v1(208.55,125.34) ; U1.Y25 v1(206.55,125.34)
  TOP w0.381: C2858.1 217.08,100.56 ; C2858.1 217.08,101.83 ; C2858.1 218,101.22
  BOTTOM w0.13: v1(218.25,100.71) v2(217.49,100.71)
  BOTTOM w0.381: v1(208.55,125.34) 209.07,124.82 C3344.1 ; v1(206.55,125.34) 207.07,124.82 C2815.1
  vias: v1(218.25,101.72)
FC36_RDN0: length 64
  TOP w0.147: U1.G21 210.05,112.83 arc(210.09,112.64) 210.19,112.48 210.27,112.4 arc(210.34,112.36) 210.42,112.34 v4(210.5,112.34)
  SIG9 w0.112: v4(210.5,112.34) 210.25,112.34 arc(210.18,112.31) 210.15,112.24 210.15,112.02 arc(210.16,111.98) 210.18,111.94 arc(210.22,111.91) 210.26,111.91 210.64,111.91 arc(210.81,111.87) 210.96,111.78 210.99,111.74 arc(211.11,111.56) 211.15,111.35 211.15,105.18 arc(211.16,105.12) 211.2,105.07 211.22,105.04 arc(211.24,105.02) 211.24,105 211.24,104.98
  SIG9 w0.16: YJ30.B22 225.25,57.97 arc(225.36,58.14) 225.4,58.34 225.4,58.52 arc(225.3,58.76) 225.06,58.86 224.16,58.86 arc(223.87,58.92) 223.62,59.08 223.56,59.15 arc(223.53,59.17) 223.5,59.19 223.45,59.24 arc(223.43,59.26) 223.4,59.28 222.6,60.08 222.6,60.39 222.19,60.8 221.88,60.8 221.53,61.16 arc(221.36,61.41) 221.3,61.7 221.3,89.12 arc(221.24,89.41) 221.08,89.66 217.74,92.99 arc(217.49,93.16) 217.2,93.22 216.13,93.22 arc(215.84,93.27) 215.59,93.44 212,97.03 arc(211.83,97.28) 211.77,97.57 211.77,102.93 arc(211.71,103.22) 211.55,103.47 211.47,103.56 arc(211.3,103.8) 211.24,104.1 211.24,104.98
FC36_RDN1: length 69.8
  TOP w0.147: v4(209.6,114.34) 209.55,114.34 U1.J22
  SIG9 w0.112: v4(209.6,114.34) 209.85,114.34 arc(209.92,114.31) 209.95,114.24 209.95,114.02 arc(209.94,113.98) 209.92,113.94 arc(209.88,113.91) 209.83,113.91 209.46,113.91 arc(209.29,113.87) 209.14,113.78 209.11,113.74 arc(208.99,113.56) 208.95,113.35 208.95,105.19 arc(208.94,105.13) 208.9,105.08 208.87,105.05 arc(208.86,105.03) 208.86,105.01 208.86,104.99
  SIG9 w0.16: 208.86,104.99 208.86,102.88 arc(208.93,102.48) 209.16,102.15 arc(209.21,102.07) 209.23,101.97 209.23,96.78 arc(209.32,96.34) 209.57,95.97 218.71,86.83 arc(218.79,86.71) 218.82,86.56 218.82,66.92 arc(218.88,66.63) 219.05,66.38 219.46,65.97 arc(219.62,65.73) 219.68,65.44 219.68,65.44 219.68,58.96 arc(219.77,58.52) 220.01,58.15 223.35,54.82 223.39,54.77 arc(223.45,54.69) 223.5,54.59 arc(223.51,54.54) 223.51,54.48 223.51,54.07 arc(223.56,53.84) 223.69,53.65 224.13,53.2 arc(224.26,53.02) 224.3,52.8 YJ30.B18
FC36_RDN2: length 70.2
  TOP w0.147: U1.L21 210.05,116.73 arc(210.07,116.62) 210.13,116.53 210.19,116.47 arc(210.33,116.37) v4(210.5,116.34)
  SIG8 w0.112: 211.24,104.9 211.14,105 211.14,115.35 arc(211.1,115.56) 210.98,115.74 210.95,115.78 arc(210.81,115.87) 210.64,115.91 210.26,115.91 arc(210.22,115.91) 210.18,115.94 arc(210.16,115.98) 210.15,116.02 210.15,116.24 arc(210.18,116.31) 210.25,116.34 v4(210.5,116.34)
  SIG8 w0.16: YJ30.B25 227.65,57.97 arc(227.78,58.17) 227.83,58.39 227.83,58.43 arc(227.8,58.57) 227.72,58.69 arc(227.53,58.82) 227.3,58.86 226.42,58.86 arc(226.39,58.86) 226.35,58.87 arc(226.22,58.91) 226.11,58.99 225.93,59.17 arc(225.68,59.34) 225.39,59.39 223.81,59.39 arc(223.51,59.45) 223.27,59.62 221.54,61.34 arc(221.38,61.59) 221.32,61.88 221.32,61.88 221.32,71.17 221.53,71.38 221.53,71.98 221.32,72.18 221.32,88.99 arc(221.23,89.43) 220.98,89.8 217.9,92.88 arc(217.53,93.13) 217.1,93.22 216.13,93.22 arc(215.84,93.27) 215.59,93.44 212,97.03 arc(211.83,97.28) 211.77,97.57 211.77,102.68 arc(211.71,102.97) 211.55,103.22 211.47,103.3 arc(211.3,103.55) 211.24,103.84 211.24,104.9
FC36_RDN3: length 75.9
  TOP w0.147: v4(209.6,118.34) 209.55,118.34 U1.N22
  SIG8 w0.112: 208.86,104.9 208.95,105 208.95,117.35 arc(209,117.56) 209.12,117.74 209.15,117.78 arc(209.29,117.87) 209.46,117.91 209.83,117.91 arc(209.88,117.91) 209.92,117.94 arc(209.94,117.98) 209.95,118.02 209.95,118.24 arc(209.92,118.31) 209.85,118.34 v4(209.6,118.34)
  SIG8 w0.16: 208.86,104.9 208.86,102.55 arc(208.93,102.15) 209.16,101.82 arc(209.21,101.74) 209.23,101.64 209.23,96.78 arc(209.32,96.34) 209.57,95.97 218.75,86.79 arc(218.83,86.67) 218.86,86.52 218.86,67.04 arc(218.95,66.6) 219.19,66.23 219.51,65.92 arc(219.59,65.8) 219.62,65.65 219.62,59.39 arc(219.7,58.96) 219.95,58.59 223.19,55.35 arc(223.56,55.1) 224,55.01 225.39,55.01 arc(225.54,54.98) 225.66,54.9 225.75,54.82 225.75,54.81 225.79,54.77 arc(225.85,54.7) 225.89,54.61 arc(225.91,54.54) 225.91,54.48 225.91,54.1 arc(225.96,53.84) 226.11,53.63 226.45,53.29 arc(226.63,53.01) 226.7,52.68 YJ30.B15
