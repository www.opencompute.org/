# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N27617242: length 13.2
  SIG5 w0.155: v1(9.21,51.81) 10.1,51.81 11.87,50.04 14.41,50.04 15.05,49.4 v1(16.57,49.4)
  BOTTOM w0.13: D395.2 16.36,49.19 v1(16.57,49.4) ; v1(9.21,51.81) 7.88,53.14 v2(7.77,53.14) 7.49,53.14 6.69,52.35 R3031.2
N27617244: length 77.4
  TOP w0.254: v1(56.07,75.69) 55.56,76.2 55.56,77.09 55.94,77.47 R3469.2 55.54,77.87 55.31,78.1 55.31,80.26 55.46,80.41 R3027.1
  SIG5 w0.254: v1(17.46,47.95) 18.05,47.37 26.23,47.37 27.62,48.77 31.94,48.77 32.7,48 33.85,48 34.61,48.77 54.42,48.77 56.96,51.31 56.96,72.9 55.56,74.29 55.56,75.18 v1(56.07,75.69)
  BOTTOM w0.13: v2(55.31,75.44) 55.82,75.44 v1(56.07,75.69)
  BOTTOM w0.254: v1(17.46,47.95) 16.78,48.64 15.18,48.64 15.05,48.77 D395.1
N27617580: length 201.6
  TOP w0.13: R3088.2 v1(7.79,34.67)
  SIG3 w0.155: v1(193.64,49.27) 192.88,48.51 182.82,48.51 162.12,27.81 12.64,27.81 8.13,32.32 8.13,34.48 7.94,34.67 v1(7.79,34.67)
  BOTTOM w0.13: v1(7.79,34.67) v2(7.79,33.91) ; v1(193.64,49.27) 193.56,49.19 D424.2
N27617582: length 93.5
  SIG5 w0.254: v1(194.53,48) 193.54,47.01 167.7,47.01 159.92,39.23 154.64,39.23 153.73,40.13 153.73,41.91 149.42,46.23 149.42,53.97 151.27,55.83 151.27,57.48 151.83,58.04 151.83,69.34 150.05,71.12 v1(150.05,71.24)
  BOTTOM w0.254: v1(150.05,71.24) 151.57,72.77 151.57,76.32 v2(151.32,76.58) R3498.2 150.94,77.87 150.69,78.13 150.69,80.26 150.84,80.41 R3084.1 ; v1(194.53,48) 193.9,48.64 192.34,48.64 192.05,48.93 D424.1
N27617584: length 183
  SIG3 w0.155: v1(176.62,49.4) 176.25,49.02 175.29,49.02 174.28,48.01 172.75,48.01 167.56,42.81 167.56,39.48 160.01,31.93 12.08,31.93 10.22,33.78 10.22,35.05 9.46,35.81 v1(9.21,35.81)
  BOTTOM w0.13: v1(176.62,49.4) 176.41,49.19 D420.2 ; v1(9.21,35.81) 8.57,36.45 7.33,36.45 R3080.2
N27617586: length 71.7
  SIG5 w0.254: v1(152.08,76.58) 151.32,75.82 151.32,74.29 153.33,72.29 153.33,55.67 150.94,53.29 150.94,46.91 154.12,43.73 160.66,43.73 165.58,48.64 167.96,48.64 168.31,48.99 172.91,48.99 173.06,49.15 175.07,49.15 175.96,50.04 176.88,50.04 v1(177.51,49.4)
  BOTTOM w0.254: v1(177.51,49.4) 176.75,48.64 175.23,48.64 175.05,48.82 D420.1 ; v1(152.08,76.58) v2(152.97,76.58) 152.97,77.09 152.72,77.34 R3494.2 152.21,77.87 152.08,78 152.08,80.26 152.24,80.41 R3076.1
N27617592: length 180.5
  SIG3 w0.155: v1(169,49.53) 169,48.32 161.73,41.05 161.73,38.1 156.33,32.69 12.54,32.69 11.12,34.12 11.12,35.55 9.72,36.95 v1(9.21,36.95)
  BOTTOM w0.13: D416.2 173.75,48.79 173.45,48.49 170.05,48.49 v1(169,49.53) ; v1(9.21,36.95) 8.7,37.46 7.2,37.46 R3072.2
N27617594: length 60
  TOP w0.254: v1(152.08,74.8) 152.72,75.44 R3490.2 153.23,77.87 153.35,78 153.35,80.28 153.22,80.41 R3067.1
  SIG5 w0.254: v1(169.89,49.53) 169.26,50.16 161.99,50.16 158.74,46.91 153.56,46.91 151.42,49.04 151.42,53.06 153.81,55.45 153.81,73.07 v1(152.08,74.8)
  BOTTOM w0.13: v1(152.08,74.8) 152.46,74.8 v2(152.97,75.31)
  BOTTOM w0.254: v1(169.89,49.53) 170.4,49.02 172.18,49.02 172.35,49.19 D416.1
N27617598: length 163.8
  TOP w0.13: R3064.2 v1(7.79,38.1)
  SIG3 w0.155: v1(157.57,49.4) 156.66,48.49 152.59,48.49 150.25,46.15 150.25,42.2 141.12,33.08 12.7,33.08 11.87,33.91 11.87,35.56 9.97,37.46 8.57,37.46 7.94,38.1 v1(7.79,38.1)
  BOTTOM w0.13: v1(157.57,49.4) 157.36,49.19 D412.2
N27617600: length 45
  SIG5 w0.254: v1(158.46,47.95) 157.95,47.44 153.78,47.44 152.51,48.71 152.51,53.39 154.29,55.17 154.29,73.48 153.35,74.42 153.35,75.82 v1(154.11,76.58)
  BOTTOM w0.254: v1(158.46,47.95) 157.78,48.64 156.18,48.64 156.05,48.77 D412.1 ; R3061.1 154.6,80.41 154.75,80.26 154.75,79.25 155.38,78.61 v2(155.38,77.98) 155.28,77.87 R3486.2 v1(154.11,76.58)
N27617604: length 146.1
  TOP w0.13: R3056.2 v1(7.79,39.24)
  SIG3 w0.155: v1(146.64,49.27) 144.79,47.42 134.74,47.42 125.16,37.84 10.73,37.84 9.84,38.73 8.45,38.73 7.94,39.24 v1(7.79,39.24)
  BOTTOM w0.13: D410.2 146.56,49.19 v1(146.64,49.27)
N27617606: length 40.4
  SIG5 w0.254: v1(147.53,48) 148.91,49.38 148.91,54.15 150.75,55.99 150.75,57.72 151.32,58.29 151.32,68.96 148.91,71.37 148.91,71.4 v1(147.03,73.28)
  BOTTOM w0.254: v1(147.53,48) 146.9,48.64 145.22,48.64 145.05,48.81 D410.1 ; v1(147.03,73.28) 147,73.28 v2(146.37,73.91) 146.37,77.11 R3482.2 146.43,78.57 146.43,80.2 146.65,80.41 R3051.1
N27617610: length 132
  SIG3 w0.155: v1(9.21,40.38) 10.26,40.38 11.4,39.24 124.4,39.24 129.1,43.94 129.1,48.64 129.62,49.17 v1(129.62,49.4)
  BOTTOM w0.13: v1(129.62,49.4) 129.41,49.19 D404.2 ; v1(9.21,40.38) 8.57,41.02 7.33,41.02 R3048.2
N27617612: length 60.5
  TOP w0.254: v1(148.02,76.58) 148.53,77.09 R3478.2 148.81,77.87 149.16,78.23 149.16,80.26 149.01,80.41 R3044.1
  SIG8 w0.254: v1(130.51,49.4) 131.4,48.51 131.76,48.51 133.35,46.92 148.33,46.92 150.18,48.77 150.18,54.1 146.62,57.66 146.62,69.72 148.02,71.12 v1(148.02,76.58)
  BOTTOM w0.13: v1(148.02,76.58) 147.89,76.45 v2(147.89,75.69)
  BOTTOM w0.254: D404.1 128.05,48.82 128.23,48.64 129.75,48.64 v1(130.51,49.4)
N27617616: length 124.6
  SIG3 w0.155: v1(9.21,41.53) 11.97,41.53 13.24,42.8 113.35,42.8 119.95,49.4 v1(122.13,49.4)
  BOTTOM w0.13: v1(122.13,49.4) 123.05,48.49 126.45,48.49 126.75,48.79 D400.2 ; v1(9.21,41.53) 8.7,42.03 7.2,42.03 R3040.2
N27617618: length 73
  TOP w0.254: v1(149.92,83.69) R3474.2 150.43,84.35 150.69,84.6 150.69,86.74 150.53,86.89 R3035.1
  SIG9 w0.254: v1(149.92,83.69) 149.42,84.2 147.51,84.2 146.75,83.44 146.75,82.04 145.1,80.39 145.1,55.75 148.15,52.7 148.15,51.31 146.75,49.91 129.22,49.91 129.1,49.78 126.05,49.78 125.29,50.54 124.16,50.54 v1(123.02,49.4)
  BOTTOM w0.13: v1(149.92,83.69) 149.8,83.69 v2(149.29,84.2)
  BOTTOM w0.254: D400.1 125.35,49.19 125.05,48.89 123.53,48.89 v1(123.02,49.4)
N27617622: length 107.9
  TOP w0.13: R3032.2 v1(7.79,42.67)
  SIG3 w0.155: v1(7.79,42.67) 7.94,42.67 8.45,42.16 12.06,42.16 13.08,43.18 101.16,43.18 106.49,48.51 109.68,48.51 v1(110.57,49.4)
  BOTTOM w0.13: v1(110.57,49.4) 110.36,49.19 D396.2
N27617624: length 84.5
  TOP w0.254: R3028.1 150.41,80.41 150.56,80.26 150.56,78.2 150.23,77.87 R3470.2 149.92,77.47 149.42,76.96 149.42,75.44 v1(150.05,74.8)
  SIG8 w0.254: v1(111.46,47.93) 112.15,47.93 116.9,43.18 148.98,43.18 151.32,45.52 151.32,54.68 149.2,56.8 149.2,73.95 v1(150.05,74.8)
  BOTTOM w0.13: v1(150.05,74.8) 150.3,74.8 v2(150.81,75.31)
  BOTTOM w0.254: D396.1 109.05,48.77 109.18,48.64 110.75,48.64 v1(111.46,47.93)
N27617960: length 116.4
  TOP w0.13: R3089.2 v1(388.43,49.53)
  SIG6 w0.155: v1(287.64,49.4) 288.1,48.94 288.43,48.94 293.43,43.94 293.43,40.76 295.79,38.41 381.57,38.41 385.5,42.33 385.5,45.98 386.42,46.9 386.42,48.28 387.16,49.02 387.92,49.02 v1(388.43,49.53)
  BOTTOM w0.13: v1(287.64,49.4) 287.43,49.19 D425.2
N27617962: length 93.7
  SIG5 w0.254: v1(244.03,74.17) 244.82,73.38 244.82,54.93 243.65,53.76 243.65,44.33 248.75,39.23 251.64,39.23 258.89,46.48 266.54,46.48 267.03,46.97 287.5,46.97 v1(288.53,48)
  BOTTOM w0.254: D425.1 286.05,48.78 286.19,48.64 287.9,48.64 v1(288.53,48) ; R3085.1 244.82,80.41 244.67,80.26 244.67,78 244.79,77.87 R3500.2 245.3,77.21 245.53,76.98 245.53,76.1 246.06,75.56 v2(246.06,75.31) 246.06,75.05 245.17,74.17 v1(244.03,74.17)
N27617964: length 125.8
  SIG4 w0.155: v1(387.54,49.53) 385.61,47.59 385.61,46.41 382.51,43.31 281.05,43.31 275.72,48.64 271.39,48.64 v1(270.62,49.4)
  BOTTOM w0.13: v1(387.54,49.53) 388.05,50.04 388.94,50.04 389.09,49.88 R3081.2 ; D421.2 270.41,49.19 v1(270.62,49.4)
N27617966: length 70.8
  TOP w0.254: v1(246.05,76.34) 246.7,76.98 R3495.2 247.08,77.87 247.33,78.13 247.33,80.26 247.18,80.41 R3077.1
  SIG5 w0.254: v1(271.51,49.4) 270.88,50.04 269.56,50.04 268.92,49.4 267.02,49.4 266.51,48.89 255.71,48.89 250.55,43.73 248.31,43.73 245.17,46.86 245.17,53.24 246.27,54.33 246.27,76.12 v1(246.05,76.34)
  BOTTOM w0.13: v2(247.33,75.31) 247.21,75.31 246.18,76.34 v1(246.05,76.34)
  BOTTOM w0.254: v1(271.51,49.4) 270.75,48.64 269.23,48.64 269.05,48.82 D421.1
N27617972: length 137.2
  SIG4 w0.155: v1(263.13,49.4) 263.77,48.77 265.89,48.77 267.49,47.16 276.11,47.16 280.73,42.54 382.82,42.54 386.37,46.09 386.37,46.58 387.03,47.24 v1(387.54,47.24)
  BOTTOM w0.13: D418.2 267.75,48.79 267.45,48.49 264.05,48.49 v1(263.13,49.4) ; R3073.2 389.09,47.6 388.94,47.75 388.05,47.75 v1(387.54,47.24)
N27617974: length 59.2
  SIG5 w0.254: v1(246.05,77.23) 246.75,76.53 246.75,54.13 245.68,53.06 245.68,48.38 247.21,46.86 252.92,46.86 255.97,49.91 263.51,49.91 v1(264.02,49.4)
  BOTTOM w0.13: v1(246.05,77.23) 246.05,76.97 246.44,76.58 v2(246.82,76.58)
  BOTTOM w0.254: v1(264.02,49.4) 264.53,48.89 266.05,48.89 266.35,49.19 D418.1 ; v1(246.05,77.23) 246.33,77.23 246.7,77.59 R3491.2 246.32,77.87 246.06,78.13 246.06,80.26 246.22,80.41 R3069.1
N27617978: length 149.4
  TOP w0.13: R3065.2 v1(388.43,47.24)
  SIG6 w0.155: v1(251.57,49.4) 252.08,48.89 254.95,48.89 266.21,37.64 381.89,37.64 386.27,42.02 386.27,45.59 387.41,46.73 387.92,46.73 v1(388.43,47.24)
  BOTTOM w0.13: v1(251.57,49.4) 251.36,49.19 D413.2
N27617980: length 43.5
  TOP w0.254: R3060.1 248.6,80.41 248.83,80.19 248.83,78.2 248.5,77.87 R3487.2 247.74,77.87 247.46,77.59 247.46,76.6 v1(247.74,76.32)
  SIG5 w0.254: v1(247.74,76.32) 247.74,53.75 246.82,52.84 246.82,49.27 247.35,48.75 251.72,48.75 v1(252.46,48)
  BOTTOM w0.13: v1(247.74,76.32) 248.35,76.32 v2(248.6,76.58)
  BOTTOM w0.254: v1(252.46,48) 251.83,48.64 250.18,48.64 250.05,48.77 D413.1
N27617984: length 158.2
  SIG3 w0.155: v1(387.54,44.96) 386.78,44.19 386.78,43.1 381.78,38.09 270.26,38.09 265.05,43.31 248.09,43.31 242.46,48.94 241.1,48.94 v1(240.64,49.4)
  BOTTOM w0.13: v1(387.54,44.96) 388.05,45.46 388.94,45.46 389.09,45.31 R3057.2 ; D409.2 240.43,49.19 v1(240.64,49.4)
N27617986: length 39.3
  TOP w0.254: R3053.1 240.5,80.41 240.35,80.26 240.35,78.2 240.67,77.87 R3483.2 241.11,77.34 241.49,76.96 241.49,76.25 v1(240.86,75.61)
  SIG8 w0.254: v1(240.86,75.61) 240.86,55.12 242.51,53.46 242.51,48.98 v1(241.53,48)
  BOTTOM w0.13: v1(240.86,75.61) 240.55,75.31 v2(239.97,75.31)
  BOTTOM w0.254: v1(241.53,48) 240.9,48.64 239.33,48.64 239.05,48.92 D409.1
N27617990: length 176.5
  TOP w0.13: R3049.2 v1(388.43,44.96)
  SIG6 w0.155: v1(388.43,44.96) 387.92,44.45 387.19,44.45 387.03,44.29 387.03,41.7 382.21,36.87 239.99,36.87 228.1,48.77 224.26,48.77 v1(223.62,49.4)
  BOTTOM w0.13: v1(223.62,49.4) 223.41,49.19 D405.2
N27617992: length 57.6
  SIG8 w0.254: v1(242,75.69) 242,55.5 243.65,53.85 243.65,48.51 242.15,47.01 227.5,47.01 226,48.51 225.4,48.51 v1(224.51,49.4)
  BOTTOM w0.254: 242.87,76.6 242.51,76.96 R3479.2 241.87,78.51 241.87,79.78 R3045.1 ; 242.87,76.6 v2(242.89,76.58) ; 242.87,76.6 242.87,76.56 v1(242,75.69) ; D405.1 222.05,48.82 222.23,48.64 223.75,48.64 v1(224.51,49.4)
N27617996: length 187
  TOP w0.13: R3041.2 v1(388.43,42.67)
  SIG6 w0.155: v1(216.13,49.4) 216.77,50.04 220.44,50.04 222.93,47.54 228.78,47.54 239.83,36.49 382.37,36.49 387.41,41.54 387.41,41.65 v1(388.43,42.67)
  BOTTOM w0.13: D402.2 220.75,48.79 220.45,48.49 217.05,48.49 v1(216.13,49.4)
N27617998: length 82.3
  TOP w0.254: v1(245.3,83.69) 245.43,83.82 R3475.2 244.77,84.35 244.54,84.58 244.54,87.63 244.69,87.78 R3037.1
  SIG8 w0.254: v1(217.02,49.4) 216.47,48.85 216.47,47.75 216.77,47.46 222.61,47.46 224.35,45.72 235.14,45.72 237.68,43.18 241.86,43.18 244.67,45.98 244.67,54.61 243.01,56.26 243.01,73.91 243.4,74.29 243.4,79.75 243.78,80.13 243.78,81.02 244.79,82.04 244.79,83.18 v1(245.3,83.69)
  BOTTOM w0.13: v1(245.3,83.69) 245.17,83.82 v2(245.17,84.58)
  BOTTOM w0.254: v1(217.02,49.4) 217.53,48.89 219.05,48.89 219.35,49.19 D402.1
N27618002: length 194.5
  SIG3 w0.155: v1(387.54,42.67) 382.2,37.33 269.95,37.33 264.73,42.54 214.95,42.54 208.55,48.94 205.03,48.94 v1(204.57,49.4)
  BOTTOM w0.13: v2(389.09,41.4) R3033.2 389.09,43.03 388.94,43.18 388.05,43.18 v1(387.54,42.67) ; D397.2 204.36,49.19 v1(204.57,49.4)
N27618004: length 99.1
  TOP w0.254: R3029.1 246.22,87.78 246.06,87.63 246.06,84.6 246.32,84.35 R3471.2 v1(246.7,83.69)
  SIG8 w0.254: v1(205.46,48) 205.47,48.01 206.32,48.01 215.85,38.48 242.25,38.48 245.68,41.91 245.68,55.24 244.03,56.89 244.03,72.01 245.43,73.4 245.43,78.48 244.67,79.25 244.67,80.39 246.19,81.91 246.19,83.18 v1(246.7,83.69)
  BOTTOM w0.13: v2(246.44,84.58) 246.44,83.94 v1(246.7,83.69)
  BOTTOM w0.254: D397.1 203.05,48.77 203.18,48.64 204.83,48.64 v1(205.46,48)
N27618320: length 16
  TOP w0.13: R3090.2 v1(388.43,58.67)
  SIG6 w0.155: v1(388.43,58.67) 387.92,58.16 386.14,58.16 383.35,55.37 383.35,49.57 382.72,48.94 382.1,48.94 v1(381.64,49.4)
  BOTTOM w0.13: v1(381.64,49.4) 381.43,49.19 D426.2
N27618342: length 83.7
  TOP w0.254: v1(341.06,76.83) 340.68,77.21 R3499.2 341.31,77.87 341.57,78.13 341.57,80.26 341.41,80.41 R3086.1
  SIG4 w0.254: v1(382.53,48) 382,47.48 368.6,47.48 368.14,47.01 340.82,47.01 338.96,48.88 338.96,54.83 341.34,57.22 341.34,71.17 340.42,72.08 340.42,76.2 v1(341.06,76.83)
  BOTTOM w0.13: v1(341.06,76.83) 341.31,76.58 v2(341.82,76.58)
  BOTTOM w0.254: v1(382.53,48) 381.9,48.64 380.18,48.64 380.05,48.77 D426.1
N27618344: length 34
  SIG8 w0.155: v1(387.54,59.81) 383.22,55.5 383.22,51.05 382.21,50.04 365.26,50.04 v1(364.62,49.4)
  BOTTOM w0.13: R3082.2 389.09,60.81 v2(388.81,61.08) v1(387.54,59.81) ; D422.2 364.41,49.19 v1(364.62,49.4)
N27618346: length 62.5
  TOP w0.254: v1(343.22,76.83) 343.09,76.83 342.58,77.34 R3496.2 342.18,77.87 342.02,78.03 342.02,79.45 342.58,80.01 R3078.1
  SIG4 w0.254: v1(365.51,49.4) 365,49.91 363.79,49.91 363.41,49.53 360.49,49.53 360.11,49.91 356.68,49.91 355.82,49.04 341.41,49.04 340.56,49.9 340.56,53.86 342.94,56.24 342.94,72.39 342.46,72.88 342.46,76.07 v1(343.22,76.83)
  BOTTOM w0.254: D422.1 363.05,48.82 363.23,48.64 364.75,48.64 v1(365.51,49.4)
N27618352: length 44.9
  SIG8 w0.155: v1(357.13,49.4) 357.89,48.64 361.12,48.64 362.22,47.54 382.72,47.54 384.37,49.2 384.37,53.22 v1(387.54,56.39)
  BOTTOM w0.13: v1(387.54,56.39) 388.05,56.89 388.94,56.89 389.09,56.74 R3074.2 ; D417.2 361.75,48.79 361.45,48.49 358.05,48.49 v1(357.13,49.4)
N27618354: length 59
  TOP w0.254: v1(343.22,75.94) 343.98,76.71 R3492.2 344.49,77.87 344.61,78 344.61,80.24 344.44,80.41 R3070.1
  SIG2 w0.254: v1(343.22,75.94) 343.22,56.89 340.17,53.85 340.17,48.38 341.44,47.11 354.01,47.11 356.81,49.91 357.51,49.91 v1(358.02,49.4)
  BOTTOM w0.13: v2(344.11,75.31) 343.47,75.94 v1(343.22,75.94)
  BOTTOM w0.254: v1(358.02,49.4) 358.53,48.89 360.05,48.89 360.35,49.19 D417.1
N27618358: length 52
  TOP w0.13: R3066.2 v1(388.43,56.39)
  SIG6 w0.155: v1(345.57,49.56) 345.57,49.53 346.21,48.89 360.36,48.89 361.71,47.54 383.26,47.54 384.12,48.4 384.12,53.47 386.52,55.88 387.92,55.88 v1(388.43,56.39)
  BOTTOM w0.13: D414.2 345.24,49.19 345.57,49.53 v1(345.57,49.56)
N27618360: length 50.4
  SIG2 w0.254: v1(345.38,84.45) 343.85,82.93 343.85,56.77 340.8,53.72 340.8,49.02 341.31,48.51 345.95,48.51 v1(346.46,48)
  BOTTOM w0.254: v1(346.46,48) 345.83,48.64 344.18,48.64 344.05,48.77 D414.1 ; v1(345.38,84.45) v2(344.74,85.09) 344.26,84.6 R3488.2 342.86,84.6 342.74,84.48 R3062.1
N27618364: length 66.7
  SIG8 w0.155: v1(387.54,54.1) 386.94,54.1 385.14,52.3 385.14,45.56 383.28,43.7 341.57,43.7 336.5,48.77 335.28,48.77 v1(334.64,49.4)
  BOTTOM w0.13: v1(387.54,54.1) 388.05,54.61 388.94,54.61 389.09,54.46 R3058.2 ; v1(334.64,49.4) 334.43,49.19 D408.2
N27618366: length 42.3
  TOP w0.254: R3054.1 339.76,80.41 339.92,80.26 339.92,78 339.79,77.87 R3484.2 339.28,75.82 v1(337.76,74.29)
  SIG2 w0.254: v1(337.76,74.29) 340.55,71.5 340.55,58.16 337.63,55.24 337.63,52.07 335.17,49.6 335.17,48.37 v1(335.53,48)
  BOTTOM w0.13: v2(336.74,75.31) v1(337.76,74.29)
  BOTTOM w0.254: D408.1 333.05,48.9 333.31,48.64 334.9,48.64 v1(335.53,48)
N27618370: length 82.9
  TOP w0.13: R3050.2 v1(388.43,54.1)
  SIG6 w0.155: v1(317.62,49.4) 318.13,48.89 326.63,48.89 332.06,43.46 382.73,43.46 383.96,44.69 383.96,47.16 384.89,48.08 384.89,51.7 386.78,53.59 387.92,53.59 v1(388.43,54.1)
  BOTTOM w0.13: D406.2 317.41,49.19 v1(317.62,49.4)
N27618372: length 56.5
  SIG3 w0.254: v1(337.76,75.18) 338.39,74.55 338.39,73.78 340.3,71.88 340.3,52.32 336.87,48.89 319.02,48.89 v1(318.51,49.4)
  BOTTOM w0.254: v1(337.76,75.18) 337.88,75.31 v2(337.88,76.45) R3480.2 337.48,77.87 337.32,78.03 337.32,79.86 R3046.1 ; v1(318.51,49.4) 317.75,48.64 316.23,48.64 316.05,48.82 D406.1
N27618376: length 93.7
  TOP w0.13: R3042.2 v1(388.43,51.81)
  SIG6 w0.155: v1(310.13,49.4) 311.02,48.51 313.12,48.51 314.65,46.98 327.14,46.98 331.44,42.69 383.05,42.69 384.73,44.37 384.73,46.3 385.65,47.22 385.65,49.8 387.16,51.31 387.92,51.31 v1(388.43,51.81)
  BOTTOM w0.13: D401.2 314.75,48.79 314.45,48.49 311.05,48.49 v1(310.13,49.4)
N27618378: length 77.6
  TOP w0.254: v1(337.88,83.94) R3476.2 337.38,84.6 337.25,84.48 R3038.1
  SIG2 w0.254: v1(311.02,49.4) 311.91,48.51 313.75,48.51 315.25,47.01 316.55,47.01 320,43.56 328.49,43.56 331.94,47.01 337.02,47.01 339.15,49.15 339.15,54.35 342.07,57.27 342.07,80.77 338.9,83.94 v1(337.88,83.94)
  BOTTOM w0.13: v2(337.88,84.83) v1(337.88,83.94)
  BOTTOM w0.254: D401.1 313.35,49.19 313.05,48.89 311.53,48.89 v1(311.02,49.4)
N27618382: length 100.4
  SIG2 w0.155: v1(298.57,49.4) 299.03,48.94 299.86,48.94 306.12,42.69 381.5,42.69 386.52,47.71 386.52,50.8 v1(387.54,51.81)
  BOTTOM w0.13: v1(387.54,51.81) 388.05,52.32 388.94,52.32 389.09,52.17 R3034.2 ; D398.2 298.36,49.19 v1(298.57,49.4)
N27618384: length 83.9
  TOP w0.254: v1(341.06,83.94) 340.93,83.94 340.68,84.2 R3472.2 340.17,84.6 340.04,84.48 R3030.1
  SIG3 w0.254: v1(299.46,48) 300.61,46.86 336.49,46.86 341.44,51.81 341.44,72.39 340.04,73.78 340.04,82.93 v1(341.06,83.94)
  BOTTOM w0.13: v1(341.06,83.94) v2(340.3,83.94)
  BOTTOM w0.254: v1(299.46,48) 298.83,48.64 297.18,48.64 297.05,48.77 D398.1
N28237185: length 8.3
  BOTTOM w0.13: R3543.2 v2(371.28,208.81) 370.9,208.43 R3544.1 370.24,206.47 370.01,206.25 369,206.25
N28237187: length 3.3
  BOTTOM w0.13: v2(370.9,204.21) R3544.2 371.67,205.51 371.88,205.3 Q47.1
N28238012: length 4.4
  BOTTOM w0.13: Q52.1 369.76,125.85 370.14,125.47 R3557.2 371.35,123.92 v2(371.52,124.1)
N28238014: length 6.4
  BOTTOM w0.13: R3560.2 R3557.1 370.75,122.96 370.88,122.83 v2(371.52,122.83) 372.3,123.61 372.3,124.71 371.92,125.09 Q54.3
N28238139: length 3.4
  BOTTOM w0.13: v2(371.51,131.47) R3563.2 371.51,129.77 370.97,129.23 Q54.1
N28239892: length 294.3
  SIG4 w0.155: v1(157.19,210.79) 165.85,219.45 261.68,219.45 263.21,217.93 264.1,217.93 265.62,219.45 273.75,219.45 274.89,218.31 282.38,218.31 283.53,219.45 345.54,219.45 376.75,188.24 376.75,183.51 381.32,178.94 381.32,160.78 379.66,159.13 371.18,159.13 368.87,156.82 v1(365.6,156.82)
  BOTTOM w0.13: v1(157.19,210.79) R3555.1 R3547.1 R3546.2
  BOTTOM w0.254: Q51.3 366.97,160.65 366.46,160.14 v2(366.46,159.26) R3565.1 v1(365.6,156.82)
N28239894: length 118.5
  SIG4 w0.155: v1(155.38,209.04) 155.38,211.2 164.65,220.47 262.04,220.47 v1(263.59,218.92)
  BOTTOM w0.13: v2(262.7,218.82) 263.46,218.82 263.59,218.95 v1(263.59,218.92) 263.74,219.07 264.48,219.07 264.67,218.88 Q49.1 ; R3547.2 v1(155.38,209.04)
N28240013: length 5.7
  BOTTOM w0.254: Q51.1 R3551.2 R3552.2 C3649.2 v2(366.84,163.47)
N28240364: length 3.4
  BOTTOM w0.13: v2(156.53,208.53) R3555.2 157.32,209.83 157.74,210.25 Q53.1
N28246918: length 7.1
  BOTTOM w0.13: R3522.2 379.92,193.67 v2(378.65,192.4) 378.52,192.28 R3523.1 377.86,191.11 377.38,190.62 377.38,189.99 376.87,189.48 Q44.3
N28246922: length 3.5
  BOTTOM w0.13: v2(378.52,188.85) R3523.2 379.39,190.14 379.73,189.8 Q43.1
N28247037: length 6.2
  BOTTOM w0.13: R3525.2 C3646.1 R3526.1 374.61,193.82 v2(374.46,193.67) 374.46,193.04 374.78,192.71 Q44.1
N28252512: length 556.9
  TOP w0.13: v1(374.33,135.76) R3561.1 373.55,134.85 372.94,134.24 372.94,111.35 373.44,110.84 R3568.1 ; R3541.1 36.49,140.1 36.26,140.33 35.75,140.33 35.52,140.56 R3529.2 34.61,141.73 34.48,141.6 Q46.3 v1(31.81,141.6) 26.86,136.65 19.88,136.65 15.81,132.59 9.97,132.59 9.84,132.71 R3530.1
  SIG4 w0.155: v1(34.86,176.27) 36.51,176.27 38.1,177.86 42.42,177.86 48.39,183.83 50.04,183.83 52.13,185.93 52.13,187.58 54.67,190.12 56.13,190.12 57.53,191.51 57.53,193.23 58.61,194.31 59.56,194.31 62.38,197.13 63.79,197.13 66.07,199.42 71.09,199.42 72.83,201.17 94.17,201.17 94.55,200.78 124.93,200.78 128.84,204.69 148.75,204.69 154.11,210.06 154.11,210.69 164.4,220.98 375.86,220.98 380.3,216.53 380.3,207.77 385.25,202.82 385.25,187.7 382.08,184.53 382.08,159.76 383.1,158.75 383.1,153.29 374.33,144.52 v1(374.33,135.76)
  SIG6 w0.155: v1(31.81,141.6) 30.67,142.75 29.15,142.75 28.77,143.13 28.77,152.4 30.54,154.18 30.54,162.56 32.58,164.59 32.58,172.72 34.1,174.24 34.1,175.51 v1(34.86,176.27)
  BOTTOM w0.13: v1(31.81,141.6) v2(31.81,140.84)
N28252514: length 2
  TOP w0.254: Q45.1 6.79,132.2 7.3,132.71 R3530.2
N28253687: length 2
  TOP w0.254: R3541.2 34.99,139.7 34.48,139.19 Q48.1
N28254458: length 2.9
  TOP w0.13: Q46.1 34.86,143.89 v1(35.24,144.27) 35.52,143.99 R3535.2
N28597003: length 77
  TOP w0.203: D446.27 v1(348.44,172.77) ; D441.27 v1(348.44,132.13) ; v1(67.65,174.34) D439.27 69.22,174.34 ; v1(67.65,164.18) D438.27 69.09,164.18 v1(69.35,164.44) ; v1(67.65,154.02) D437.27 69.28,154.02 ; 69.36,143.86 D436.27 v1(67.65,143.86) ; D443.27 v1(348.44,162.61) ; D444.27 v1(348.44,152.45) ; D442.27 v1(348.44,142.29) ; D445.27 v1(348.44,182.93)
  TOP w0.229: v1(69.35,184.76) 68.9,184.76 68.64,184.5 D440.27 v1(67.65,184.5)
  TOP w0.254: v1(379.16,157.86) 379.37,157.86 379.69,158.18 R3664.1 ; v1(67.67,133.7) D435.27 69.09,133.7 v1(69.35,133.96)
  BOTTOM w0.254: C3922.1 344.19,124 344.19,123.04 346.07,121.16 351.98,121.16 366.86,136.04 366.86,142.64 377.82,153.6 377.82,156.9 378.52,157.6 378.9,157.6 v1(379.16,157.86)
  BOTTOM w0.381: C3368.1 71.34,192.68 ; C3368.1 71.34,194.33 ; C3368.1 70.21,193.55 v1(70.17,193.51)
  vias: v1(62.8,190.88) v1(62.8,189.99) v1(62.8,189.1) v1(62.8,188.21) v1(63.69,189.61) v1(63.82,188.34) v1(63.82,187.45) v1(64.83,188.34) v1(64.83,187.45) v1(68.14,201.67) v1(68.21,187.96) v1(68.21,187.07) v1(69.02,201.67) v1(69.02,191.64) v1(69.02,190.24) v1(69.1,187.96) v1(69.1,187.07) v1(69.1,177.8) v1(69.1,176.91) v1(69.1,167.64) v1(69.1,166.75) v1(69.1,157.5) v1(69.1,156.61) v1(69.1,147.32) v1(69.1,146.43) v1(69.1,137.16) v1(69.1,136.27) v1(69.15,193.51) v1(69.35,185.52) v1(69.35,175.36) v1(69.35,174.6) v1(69.35,165.2) v1(69.35,155.04) v1(69.35,154.28) v1(69.35,144.88) v1(69.35,144.12) v1(69.35,134.72) v1(69.91,201.67) v1(69.99,187.98) v1(69.99,187.09) v1(69.99,185.52) v1(69.99,184.76) v1(69.99,177.82) v1(69.99,176.93) v1(69.99,175.36) v1(69.99,174.6) v1(69.99,167.66) v1(69.99,166.77) v1(69.99,165.2) v1(69.99,164.44) v1(69.99,157.5) v1(69.99,156.61) v1(69.99,155.04) v1(69.99,154.28) v1(69.99,147.34) v1(69.99,146.45) v1(69.99,144.88) v1(69.99,144.12) v1(69.99,137.18) v1(69.99,136.29) v1(69.99,134.72) v1(69.99,133.96) v1(70.04,191.64) v1(70.04,190.24) v1(70.8,201.67) v1(346.1,182.67) v1(346.1,181.91) v1(346.1,180.34) v1(346.1,179.45) v1(346.1,172.51) v1(346.1,171.75) v1(346.1,170.18) v1(346.1,169.29) v1(346.1,162.35) v1(346.1,161.59) v1(346.1,160.02) v1(346.1,159.13) v1(346.1,152.19) v1(346.1,151.43) v1(346.1,149.86) v1(346.1,148.97) v1(346.1,142.03) v1(346.1,141.27) v1(346.1,139.7) v1(346.1,138.81) v1(346.1,131.87) v1(346.1,131.11) v1(346.74,182.67) v1(346.74,181.91) v1(346.74,172.51) v1(346.74,171.75) v1(346.74,162.35) v1(346.74,161.59) v1(346.74,152.19) v1(346.74,151.43) v1(346.74,142.03) v1(346.74,141.27) v1(346.74,131.87) v1(346.74,131.11) v1(346.99,180.36) v1(346.99,179.47) v1(346.99,170.2) v1(346.99,169.31) v1(346.99,160.02) v1(346.99,159.13) v1(346.99,149.88) v1(346.99,148.99) v1(346.99,139.72) v1(346.99,138.83) v1(357.44,151.13) v1(357.44,149.86) v1(357.44,148.59) v1(357.95,171.96) v1(357.95,168.65) v1(358.08,189.48) v1(358.08,186.94) v1(358.46,151.25) v1(358.46,148.59) v1(358.46,147.57) v1(358.97,189.48) v1(358.97,186.94) v1(359.22,171.96) v1(359.22,168.65) v1(359.85,189.48) v1(359.85,186.94) v1(360.11,151.25) v1(360.11,147.83) v1(360.36,171.96) v1(360.36,168.65) v1(360.74,189.48) v1(360.74,186.94) v1(361.51,171.96) v1(361.51,168.65) v2(48.32,194.31) v2(68.26,145.03) v2(347.66,140.59) v3(47.18,191.26) v3(48.07,188.08) v3(48.2,192.28) v3(48.96,188.97) v3(49.09,193.16) v3(49.85,189.86) v3(49.97,194.18) v3(50.74,190.75) v3(50.99,195.07) v3(51.63,191.64) v3(51.88,196.09) v3(52.51,192.53) v3(52.77,196.97) v3(53.4,193.42) v3(53.66,197.86) v3(54.29,194.31) v3(54.67,198.75) v3(55.18,195.2) v3(56.07,196.09) v3(56.96,196.97) v3(57.98,197.99) v3(58.86,198.88) v3(59.75,199.77) v3(60.64,200.66) v3(61.53,201.55) v3(352.23,128.9) v3(352.23,127.63) v3(353.5,128.9) v3(353.5,127.63) v3(354.77,128.9) v3(354.77,127.63)
N29014642: length 3.8
  BOTTOM w0.13: U120.1 28.39,180.82 R3215.2 v2(29.68,180.82)
N29014660: length 2.5
  BOTTOM w0.13: R3210.1 27.37,190.51 v2(27.18,190.32) 27.09,190.23 U120.18
N29014699: length 2.6
  BOTTOM w0.13: U120.16 25.79,190.2 v2(25.91,190.32) 26.23,190.63 R3211.1
N29014752: length 2.6
  BOTTOM w0.13: U120.14 24.49,190.17 v2(24.64,190.32) 25.08,190.76 R3212.1
N29014770: length 2.7
  BOTTOM w0.13: U120.12 23.19,190.14 v2(23.37,190.32) 23.94,190.89 R3213.1
N29014858: length 2.6
  BOTTOM w0.13: U120.3 27.09,182.04 v2(27.14,181.99) 27.24,181.89 R3216.1
N29028914: length 4.8
  TOP w0.13: J34.6 v1(33.59,191.77)
  BOTTOM w0.13: v2(33.59,190.93) v1(33.59,191.77) R3221.2
N29072461: length 5.9
  BOTTOM w0.13: v2(37.02,190.12) R3228.2 35.73,189.51 36.32,188.92 Q40.1
N29447723: length 4.6
  TOP w0.203: v1(377.29,172.18) 377.28,172.05 377.28,171.98 377.85,171.41 U140.41
  BOTTOM w0.381: v1(377.29,172.18) 376.8,171.7 v2(376.49,171.7) 376.49,170.96 R2199.2
N29452507: length 304.6
  TOP w0.203: U140.23 379.05,163.93 379.67,163.32 379.74,163.32
  TOP w0.254: 379.74,163.32 381.09,161.97 381.09,161.26 ; 381.09,161.26 380.81,160.98 380.81,160.45 381.01,160.25 381.01,159.71 R2226.1 381.44,158.98 381.44,155.83 380.25,154.63 373.39,154.63 371.46,152.7 371.46,140.64 338.47,107.64 276.24,107.64 259.78,91.18 v1(259.78,91.18) ; 381.09,161.26 C3951.1 ; v1(139.26,108.96) 138.62,109.6 138.62,111.14 R2225.1
  SIG1 w0.254: v1(139.26,108.96) 138.87,108.96 138.49,108.58 138.49,108.2 138.62,108.07 140.53,108.07 142.61,105.99 147.94,105.99 149.03,104.89 152.71,104.89 153.85,106.04 160.6,106.04 161.73,104.9 167.96,104.9 169.23,103.63 180.78,103.63 182.08,102.33 182.08,97.38 184.72,94.74 211.14,94.74 212.15,93.72 235.78,93.72 239.71,89.79 248.02,89.79 249.42,91.18 v1(259.78,91.18)
  BOTTOM w0.13: v2(258.89,92.2) 259.78,91.31 v1(259.78,91.18)
N29452510: length 307.6
  TOP w0.203: U140.24 379.45,164.17 379.79,163.83
  TOP w0.254: v1(137.1,108.84) 137.86,108.84 138.11,109.09 138.11,111.03 R2224.2 ; 379.79,163.83 379.95,163.83 381.58,162.19 381.58,161.22 C3951.2 381.8,160.42 381.95,160.27 381.95,160.07 R2223.1 381.89,158.99 381.89,155.39 380.51,154 373.65,154 372.09,152.44 372.09,140.38 338.73,107.01 276.5,107.01 v1(259.78,90.29)
  SIG1 w0.254: v1(137.1,108.84) 137.73,108.84 137.99,108.58 137.99,107.95 138.37,107.57 140.27,107.57 142.35,105.48 147.69,105.48 148.91,104.26 152.97,104.26 154.11,105.41 160.34,105.41 161.35,104.39 167.7,104.39 168.97,103.12 180.4,103.12 181.6,101.93 181.6,96.97 184.34,94.23 210.76,94.23 211.9,93.09 235.65,93.09 239.46,89.28 248.22,89.28 249.49,90.55 259.52,90.55 v1(259.78,90.29)
  BOTTOM w0.13: v1(259.78,90.29) 260.67,91.18 v2(260.67,91.56)
N29654131: length 44.6
  TOP w0.13: R2046.1 v1(178.37,99.44) ; U1.W33 v1(198.55,124.34)
  SIG7 w0.155: v1(198.55,124.34) 198.55,123.98 197.39,122.83 197.39,122.46 194.79,119.85 180.38,119.85 180.02,119.49 180.02,114.93 177.99,112.9 177.99,103.12 177.48,102.61 177.48,100.33 v1(178.37,99.44)
  BOTTOM w0.13: v1(178.37,99.44) v2(177.61,99.44)
N29899967: length 6.7
  BOTTOM w0.13: R3548.2 R3550.2 364.4,205.74 364.66,205.48 C3648.2 365.25,204.98 365.57,205.3 Q50.1 v2(366.71,203.58)
N30065259: length 2.7
  TOP w0.229: U130.22 7.47,124.46 7.22,124.71 6.41,124.71 6.29,124.58 R3577.2
N30065276: length 5.1
  TOP w0.229: U130.18 9.47,126.11 9.54,126.18 C3653.2
  TOP w0.381: C3653.2 9.54,128.29 9.44,128.39 R3571.1
N30065280: length 5.4
  TOP w0.229: R3573.2 5.37,127.15 5.52,127 5.91,127 7.18,125.73 7.43,125.73 8.47,124.69 U130.20
N30065284: length 3.8
  TOP w0.229: U130.21 7.97,124.58 7.33,125.22 7.05,125.22 6.03,126.24 R3575.2
N30065288: length 3.7
  BOTTOM w0.381: v2(5.14,118.77) C3669.1 7.79,118.77 8.06,118.49 R3579.2
N30065298: length 5.4
  BOTTOM w0.381: R3583.1 v1(9.33,111) ; C3670.2 v1(9.33,112.42)
  vias: v2(14.16,114.04)
N30067979: length 6.3
  TOP w0.229: U130.1 7.47,118.91 6.82,118.26 6.29,118.26 ; C3691.1 6.29,118.26 ; 6.29,118.26 R3586.1 R3585.1
N30068071: length 7.6
  TOP w0.381: C3691.2 6.29,115.29 v1(5.8,114.81)
  BOTTOM w0.381: C3671.1 R3583.2 v1(5.8,114.81) 5.4,114.81 v2(4.64,115.57)
N30068077: length 3.2
  BOTTOM w0.381: v2(8.06,113.89) C3670.1 R3580.2
N30068127: length 5
  TOP w0.229: U130.4 8.97,117.74 v1(8.45,117.22)
  BOTTOM w0.381: v1(8.45,117.22) 8.45,116.84 v2(8.06,116.46) 7.4,116.46 6.79,117.07 R3580.1
N30070660: length 2.7
  TOP w0.229: U131.22 35.16,131.44 34.9,131.7 34.1,131.7 33.97,131.57 R3576.2
N30070672: length 5.1
  TOP w0.229: C3652.2 37.22,133.16 37.16,133.09 U131.18
  TOP w0.381: R3570.1 37.12,135.38 37.22,135.28 C3652.2
N30070676: length 5.4
  TOP w0.229: R3572.2 33.06,134.13 33.21,133.98 33.59,133.98 34.86,132.71 35.12,132.71 36.16,131.67 U131.20
N30070680: length 3.8
  TOP w0.229: U131.21 35.66,131.57 35.02,132.2 34.73,132.2 33.72,133.22 R3574.2
N30070684: length 3.8
  BOTTOM w0.381: R3578.2 35.75,125.47 35.47,125.75 C3668.1 v2(32.73,125.75)
N30070694: length 5.4
  BOTTOM w0.381: C3672.2 v1(37.02,119.4) ; R3582.1 v1(37.02,117.98)
  vias: v2(40.45,122.3)
N30070911: length 6.3
  TOP w0.229: R3584.1 R3587.1 33.97,125.24 ; 33.97,125.24 C3690.1 ; 33.97,125.24 34.51,125.24 35.16,125.89 U131.1
N30071011: length 7.3
  TOP w0.381: v1(33.49,121.79) 33.97,122.27 C3690.2
  BOTTOM w0.381: v2(32.58,122.55) 33.34,121.79 v1(33.49,121.79) R3582.2 C3673.1
N30071017: length 3.1
  BOTTOM w0.381: R3581.2 C3672.1 v2(35.62,120.88)
N30071064: length 5.2
  TOP w0.229: U131.4 36.66,124.73 v1(36.13,124.2)
  BOTTOM w0.381: v1(36.13,124.2) 36.13,123.7 35.75,123.31 v2(35.62,123.31) 35.22,123.31 34.48,124.05 R3581.1
N30072435: length 2.7
  TOP w0.229: U132.22 382.33,109.51 382.08,109.26 382.08,108.46 382.21,108.33 R3591.2
N30072447: length 4.9
  TOP w0.229: C3693.2 380.61,111.58 380.68,111.51 U132.18
  TOP w0.381: R3588.1 378.4,111.48 378.5,111.58 C3693.2
N30072451: length 5.4
  TOP w0.229: U132.20 382.1,110.51 381.06,109.47 381.06,109.22 379.79,107.95 379.79,107.57 379.64,107.41 R3589.2
N30072455: length 3.8
  TOP w0.229: R3590.2 380.56,108.07 381.57,109.09 381.57,109.38 382.21,110.01 U132.21
N30072459: length 3.7
  BOTTOM w0.508: v2(388.02,107.19) C3710.1 388.02,110.54 R3596.2
N30072461: length 6.5
  BOTTOM w0.381: R3599.1 v1(395.8,111.38) ; C3712.2 v2(394.37,110.23) v1(394.37,111.38)
  BOTTOM w0.508: R3596.1 v1(388.3,115.06)
N30072683: length 7.4
  TOP w0.13: R3603.1 v1(388.53,105.81)
  TOP w0.229: R3601.1 R3603.1 388.53,108.33 ; 388.53,108.33 C3722.1 ; 388.53,108.33 388.53,108.86 387.88,109.51 U132.1
N30072786: length 6.9
  TOP w0.381: v1(391.99,107.85) 391.5,108.33 C3722.2
  BOTTOM w0.381: v2(391.99,107.06) v1(391.99,107.85) R3599.2 C3713.1
N30072792: length 3.1
  BOTTOM w0.381: R3597.2 C3712.1 v2(392.9,109.98)
N30072833: length 5.1
  TOP w0.229: v1(389.57,110.49) 389.05,111.01 U132.4
  BOTTOM w0.381: v1(389.57,110.49) 389.98,110.49 v2(390.36,110.11) 390.49,109.98 390.49,109.63 389.73,108.87 R3597.1
N30074206: length 2.7
  TOP w0.229: R3594.2 382.46,132.33 382.33,132.46 382.33,133.26 382.59,133.51 U133.22
N30074218: length 4.9
  TOP w0.229: C3700.2 380.87,135.58 380.94,135.51 U133.18
  TOP w0.381: C3700.2 378.75,135.58 378.65,135.48 R3592.1
N30074222: length 5.4
  TOP w0.229: R3593.2 379.9,131.42 380.05,131.57 380.05,131.95 381.32,133.22 381.32,133.47 382.36,134.51 U133.20
N30074226: length 3.8
  TOP w0.229: R3595.2 380.81,132.08 381.83,133.09 381.83,133.38 382.46,134.01 U133.21
N30074230: length 3.7
  BOTTOM w0.13: C3711.1 v2(388.28,131.19)
  BOTTOM w0.508: R3598.2 388.56,134.24 388.28,133.96 C3711.1
N30074232: length 6.5
  BOTTOM w0.381: v1(396.05,135.38) R3602.1 ; v1(394.63,135.38) v2(394.63,134.24) C3723.2
  BOTTOM w0.508: R3598.1 v1(388.56,139.06)
N30074454: length 7.2
  TOP w0.13: R3604.1 v1(390.23,129.94)
  TOP w0.229: U133.1 388.14,133.51 388.79,132.86 388.79,132.33 ; R3604.1 R3605.1 388.79,132.33 ; 388.79,132.33 C3733.1
N30074557: length 6.8
  TOP w0.381: v1(392.24,131.85) 391.76,132.33 C3733.2
  BOTTOM w0.381: v2(392.24,131.09) v1(392.24,131.85) R3602.2 C3724.1
N30074563: length 3.1
  BOTTOM w0.381: v2(393.15,134.01) C3723.1 R3600.2
N30074604: length 5
  TOP w0.229: U133.4 389.3,135.01 v1(389.83,134.49)
  BOTTOM w0.381: R3600.1 389.98,132.83 390.61,133.47 v2(390.61,133.98) 390.61,134.11 390.23,134.49 v1(389.83,134.49)
N30094229: length 48.1
  SIG3 w0.155: v1(29.65,105) 29.65,103.76 29.15,103.25 29.15,99.18 18.99,89.02 18.99,71.5 24.5,65.99 YJ21.A28
  BOTTOM w0.13: v1(29.65,105) R2590.1 v2(28.38,105.94)
N30094230: length 37.1
  TOP w0.13: v1(18.22,86.87) 18.22,87.25 17.69,87.78 R2589.1
  SIG2 w0.152: YJ21.A27 25.3,63.84 24.83,63.37 16.7,63.37 15.56,64.51 15.56,71.75 17.72,73.91 17.72,85.11 18.22,85.62 v1(18.22,86.87)
  BOTTOM w0.13: v2(19.19,87.37) 18.68,86.87 v1(18.22,86.87)
N30103237: length 34.7
  TOP w0.13: v1(15.05,77.09) 15.41,77.09 R2591.2
  SIG3 w0.155: YJ21.B27 25.3,56.22 24.5,55.42 16.78,55.42 12.89,59.31 12.89,74.93 v1(15.05,77.09)
N30103238: length 66.5
  SIG1 w0.16: YJ21.B28 24.5,58.62 23.94,59.18 15.56,59.18 7.3,67.43 7.3,71.88 8.45,73.02 12.89,73.02 v1(16.19,76.32)
  SIG3 w0.155: YJ21.B28 24.03,57.82 22.42,59.43 16.57,59.43 13.91,62.1 13.91,74.04 v1(16.19,76.32)
  BOTTOM w0.13: v1(16.19,76.32) 16.7,76.83 16.7,77.72 16.85,77.87 R2588.2
N30175429: length 33.4
  SIG1 w0.16: v1(46.42,77.21) 46.8,77.59 48.2,77.59 49.59,76.2 50.4,76.2 51.5,75.1 51.5,60.41 50.27,59.18 44.26,59.18 43.5,58.42 YJ21.D28
  BOTTOM w0.13: v2(47.05,75.69) 47.05,76.58 v1(46.42,77.21) 46.42,77.72 46.55,77.85 R2592.2
N30175430: length 44.7
  TOP w0.13: R2587.2 v1(54.42,86.1)
  SIG1 w0.16: v1(53.78,55.75) 50.86,58.67 45.66,58.67 44.89,57.91 44.89,57.63 44.3,57.03 YJ21.D27
  SIG7 w0.155: v1(54.42,86.1) 54.42,84.45 53.78,83.82 53.78,79.37 53.91,79.25 53.91,73.66 53.4,73.15 53.4,72.26 53.78,71.88 v1(53.78,55.75)
  BOTTOM w0.13: v2(54.55,86.87) 54.55,86.23 v1(54.42,86.1)
N30226025: length 43.6
  TOP w0.13: R2608.2 v1(57.59,84.35)
  SIG9 w0.155: v1(57.59,84.35) 57.59,83.69 56.58,82.67 56.58,78.61 55.18,77.21 55.18,60.7 49.95,55.47 41.62,55.47 41.1,55.99 YJ22.B27
  BOTTOM w0.13: v2(57.21,83.56) 57.21,83.97 v1(57.59,84.35)
N30226026: length 40.7
  TOP w0.13: R2610.2 42.61,77.14 v1(42.56,77.09)
  SIG9 w0.155: v1(53.94,73.02) 54.29,72.67 54.29,63.12 50.65,59.48 43.56,59.48 YJ22.B28
  BOTTOM w0.13: v1(53.94,73.02) 52.79,71.88 47.05,71.88 42.56,76.38 v1(42.56,77.09) 42.56,77.72 v2(42.43,77.85)
N30288942: length 49
  SIG2 w0.152: v1(16.19,75.31) 15.55,75.31 14.16,73.92 14.16,66.16 12.26,64.26 12.26,50.54 12.76,50.04 21.91,50.04 v1(22.92,51.05)
  SIG9 w0.155: YJ22.D28 22.9,57.2 23.56,56.54 23.56,53.69 23.18,53.31 23.18,52.92 23.56,52.54 23.56,51.69 v1(22.92,51.05)
  BOTTOM w0.13: R2609.2 15.71,77.39 15.71,76.73 15.53,76.55 v2(15.53,75.69) 15.91,75.31 v1(16.19,75.31)
N30288943: length 51.9
  TOP w0.13: v1(15.18,83.44) 15.18,82.67 15.79,82.06 R2607.2
  SIG10 w0.155: v1(15.18,83.44) 15.18,84.58 15.94,85.34 18.11,85.34 18.86,84.59 18.86,82.55 32.32,69.09 32.32,57.15 30.54,55.37 24.32,55.37 23.94,55.75 22.77,55.75 YJ22.D27
N30290429: length 15
  SIG10 w0.155: v1(17.21,76.32) 17.97,75.56 17.97,72.13 22.9,67.2 YJ22.C28
  BOTTOM w0.13: v1(17.21,76.32) 17.72,76.83 17.72,77.72 17.87,77.87 R2613.1
N30290430: length 15.9
  TOP w0.13: R2611.1 v1(17.21,77.21)
  SIG10 w0.155: YJ22.C27 22.1,65.04 21.53,65.61 21.53,67.43 16.7,72.26 16.7,76.71 v1(17.21,77.21)
N30351256: length 15.1
  SIG4 w0.155: v1(72.45,74.47) 71.95,73.96 71.95,72.83 71.5,72.39 YJ23.A28
  BOTTOM w0.13: R2626.1 72.1,77.87 71.95,77.72 71.95,74.98 v1(72.45,74.47) 73.27,74.47 v2(74.1,75.31)
N30351257: length 16.6
  TOP w0.13: v1(74.1,76.2) 74.1,76.71 73.47,77.34 R2625.1
  SIG4 w0.155: v1(74.1,76.2) 72.96,75.05 72.96,74.55 72.92,74.51 72.92,65.65 72.3,65.03 YJ23.A27
  BOTTOM w0.13: v1(74.1,76.2) 74.87,75.44 v2(75.88,75.44)
N30351300: length 27.8
  TOP w0.13: R2629.2 v1(72.45,83.06)
  SIG2 w0.152: v1(72.45,83.06) 72.92,82.59 72.92,74 71.17,72.24 71.17,66.3 70.92,66.05 70.92,65.64 71.26,65.29 71.26,64.97 70.88,64.59 70.88,61.67 71.28,61.27 71.28,60.99 70.91,60.62 70.9,60.62 70.9,58.98 71.5,58.38 YJ23.B28
N30351301: length 35.1
  SIG2 w0.152: v1(72.45,86.23) 72,85.77 72,78.53 70.53,77.07 70.53,65.66 70.16,65.29 70.16,64.93 70.5,64.6 70.5,61.64 70.12,61.26 70.12,60.94 70.5,60.56 70.5,58.06 71.41,57.15 71.57,57.15 YJ23.B27
  BOTTOM w0.13: R2627.2 73.19,87.78 73.6,87.37 v2(73.6,87.25) 72.58,86.23 v1(72.45,86.23)
N30443919: length 15.5
  SIG2 w0.152: YJ23.C28 90.74,66.06 90.74,67.05 89.34,68.45 89.34,71.24 v1(86.04,74.55)
  BOTTOM w0.13: v2(86.8,75.31) v1(86.04,74.55) 85.53,75.05 85.53,77.62 R2637.1
N30443920: length 19
  TOP w0.13: R2636.1 87.16,77.87 87.36,77.67 87.36,77.39 86.93,76.96 86.93,76.45 v1(87.57,75.82)
  SIG1 w0.16: YJ23.C27 91.3,64.06 91,63.75 90.34,63.75 89.07,65.02 88.18,65.02 87.57,65.63 v1(87.57,75.82)
  BOTTOM w0.13: v2(88.2,75.31) 87.69,75.82 v1(87.57,75.82)
N30444155: length 24.6
  TOP w0.13: R2638.2 90.39,75.71 90.23,75.56 v1(89.22,75.56)
  SIG3 w0.155: YJ23.D27 90.57,57.15 90.41,57.15 89.5,58.06 89.5,60.61 89.12,60.99 89.12,61.25 89.49,61.62 89.5,61.62 89.5,64.62 89.49,64.62 89.16,64.95 89.16,65.29 89.53,65.66 89.53,68.32 88.58,69.27 88.58,73.15 89.22,73.78 v1(89.22,75.56)
N30444156: length 29.8
  TOP w0.13: v1(86.76,82.47) 86.3,82.93 86.3,83.56 86.14,83.72 R2628.2
  SIG3 w0.155: v1(86.76,82.47) 87.27,82.47 90.23,79.5 90.23,73.15 89.47,72.39 89.47,69.34 90.17,68.64 90.17,66.3 89.92,66.05 89.92,65.61 90.26,65.27 90.26,64.96 89.88,64.58 89.88,61.69 90.01,61.56 90.01,61.56 90.07,61.47 90.15,61.39 90.24,61.33 90.24,61.33 90.28,61.29 90.28,60.99 89.9,60.61 89.9,58.98 90.5,58.38 YJ23.D28
N30464265: length 13.8
  SIG10 w0.155: YJ24.A28 88.9,67.88 85.53,71.24 85.53,76.58 v1(84.9,77.21)
  BOTTOM w0.13: R2652.1 84.77,77.34 v1(84.9,77.21)
N30464266: length 19.8
  TOP w0.13: R2650.1 85.13,77.87 85.28,77.72 85.28,77.47 85.41,77.34 85.41,74.17 85.03,73.78 84.14,73.78 v1(83.38,74.55)
  SIG10 w0.155: YJ24.A27 88.1,65.04 87.44,65.7 87.44,68.45 84.39,71.5 84.39,73.53 v1(83.38,74.55)
  BOTTOM w0.13: v1(83.38,74.55) 83.63,74.8 v2(83.63,75.44)
N30464281: length 29.7
  TOP w0.13: R2648.2 84.77,83.23 85.18,82.83 85.89,82.83 86.3,82.42 86.3,81.71 v1(86.73,81.28)
  SIG1 w0.16: v1(86.73,81.28) 87.19,80.82 87.19,79.12 87.06,78.99 87.06,78.23 88.33,76.96 88.33,71.52 v1(89.98,69.87)
  SIG8 w0.155: YJ24.B28 89.74,58.66 89.74,60.37 89.2,60.91 89.2,61.34 89.47,61.61 89.47,64.64 89.2,64.91 89.2,65.34 89.47,65.61 89.47,66.94 89.98,67.45 v1(89.98,69.87)
N30464282: length 39.1
  TOP w0.13: v1(98.82,74.29) 98.7,74.17 96.96,74.17 94.17,76.96 93.89,76.96 93.51,77.34 R2646.2
  SIG9 w0.155: v1(98.82,74.29) 99.28,73.84 99.28,72.24 101.03,70.48 101.03,59.31 97.47,55.75 88.77,55.75 YJ24.B27
  BOTTOM w0.13: v2(97.6,74.67) 97.98,74.29 v1(98.82,74.29)
N30559943: length 14.1
  SIG8 w0.155: YJ24.C28 69.9,66.82 71.95,68.86 71.95,74.85 v1(71.44,75.36)
  BOTTOM w0.13: R2651.1 71.08,77.87 70.98,77.77 70.98,77.09 70.55,76.65 v2(70.55,76.58) 70.55,76.25 v1(71.44,75.36)
N30559944: length 21.5
  TOP w0.13: R2649.1 v1(71.44,77.21)
  SIG10 w0.155: v1(71.44,77.21) 71.95,76.71 71.95,73.06 71.65,72.77 71.18,72.77 69.79,74.17 67.12,74.17 66.61,73.66 66.61,67.82 68.52,65.91 68.52,65.61 69.1,65.03 YJ24.C27
N30559978: length 29
  TOP w0.13: R2647.2 71.79,83.72 71.95,83.56 71.95,82.67 v1(71.44,82.17)
  SIG8 w0.155: v1(71.44,82.17) 71.93,81.67 71.93,78.5 72.93,77.5 72.93,69.09 70.53,66.68 70.53,65.68 70.14,65.29 70.14,64.97 70.52,64.59 70.52,61.65 70.14,61.27 70.14,60.97 70.52,60.59 70.52,59.43 69.9,58.81 YJ24.D28
N30559979: length 36.6
  SIG8 w0.155: YJ24.D27 68.86,56.66 68.86,57.27 68.3,57.83 68.3,60.41 68.86,60.97 68.86,61.27 68.47,61.66 68.47,64.58 68.86,64.97 68.86,65.27 68.52,65.61 68.52,66.04 71.44,68.96 71.44,72.01 70.96,72.49 70.96,85.75 v1(71.44,86.23)
  BOTTOM w0.13: v2(70.29,89.41) 70.91,87.93 71.06,87.78 R2645.2 71.95,87.27 71.95,86.74 v1(71.44,86.23)
N30587100: length 15.5
  TOP w0.13: v1(122.24,76.32) 123.25,77.34 R2665.1
  SIG4 w0.155: v1(122.24,76.32) 122.75,75.82 122.75,72.64 121.98,71.88 121.98,68.58 119.92,66.52 119.92,65.65 119.3,65.03 YJ25.A27
N30587101: length 14.2
  SIG4 w0.155: YJ25.A28 121.48,68.8 121.48,74.67 v1(122.24,75.44)
  BOTTOM w0.13: v1(122.24,75.44) 122.75,75.94 122.75,77.59 122.47,77.87 R2666.1
N30587306: length 35.8
  SIG2 w0.152: v1(123.13,86.36) 122.75,85.98 122.75,83.56 121.73,82.55 121.73,76.71 121.6,76.58 121.6,74.42 121.48,74.29 121.48,73.02 117.53,69.08 117.53,65.67 117.16,65.3 117.16,64.95 117.5,64.61 117.5,61.64 117.12,61.26 117.12,60.94 117.5,60.56 117.5,58.06 118.41,57.15 118.57,57.15 YJ25.B27
  BOTTOM w0.13: R2672.2 122.85,86.89 123.13,86.61 v1(123.13,86.36) v2(123.69,85.8)
N30587307: length 29.4
  TOP w0.13: v1(122.24,81.28) 122.75,81.79 122.75,82.29 122.24,82.8 R2667.2
  SIG2 w0.152: v1(122.24,81.28) 122.75,80.77 122.75,73.28 118.17,68.7 118.17,66.3 117.92,66.05 117.92,65.64 118.26,65.29 118.26,64.97 117.88,64.59 117.88,61.65 118.28,61.25 118.28,60.99 117.9,60.61 117.9,58.98 118.5,58.38 YJ25.B28
N30626149: length 2.7
  BOTTOM w0.13: R3219.1 24.96,181.61 v2(24.57,181.99) 24.49,182.07 U120.7
N30634296: length 21.5
  BOTTOM w0.13: U119.1 20.51,182.52 20.79,182.24 21.27,182.24 21.78,181.73 21.78,180.97 21.93,180.82 R3189.1 22.95,180.82 23.18,180.59 23.18,177.92 23.69,177.42 28.77,177.42 v2(31.88,180.53) 33.21,181.86 Q39.3
N30634449: length 3
  BOTTOM w0.13: R3194.1 15.3,190.83 v2(15.81,190.32) 16.61,189.52 U119.14
N30634467: length 3
  BOTTOM w0.13: U119.12 15.31,189.55 v2(14.54,190.32) 14.16,190.7 R3195.1
N30661246: length 2.8
  BOTTOM w0.13: R3192.1 19.88,190.7 v2(19.49,190.32) 19.21,190.04 U119.18
N30661249: length 2.8
  BOTTOM w0.13: R3193.1 18.73,190.83 v2(18.22,190.32) 17.91,190.01 U119.16
N30661322: length 2.7
  BOTTOM w0.13: U119.3 19.21,182.06 v2(19.37,181.91) 20,181.28 R3196.1
N30661343: length 2.4
  BOTTOM w0.13: U119.7 v2(16.61,181.91) 16.61,181.78 16.57,181.73 R3200.1
N30661349: length 2.8
  BOTTOM w0.13: U119.9 15.31,182.43 v2(14.8,181.91) 14.29,181.4 R3201.1
N30662342: length 2.6
  BOTTOM w0.13: R3218.1 26.1,181.73 v2(25.84,181.99) 25.79,182.04 U120.5
N30664870: length 2.8
  BOTTOM w0.13: R3222.1 23.81,181.48 v2(23.3,181.99) 23.19,182.1 U120.9
N30697802: length 2.8
  BOTTOM w0.13: U119.5 17.91,183.19 17.91,182.1 v2(18.1,181.91) 18.86,181.15 R3198.1
N30710452: length 14.9
  TOP w0.13: R2670.1 135.22,77.87 135.12,77.77 135.12,74.88 v1(135.57,74.42)
  SIG4 w0.155: YJ25.C28 137.5,68.56 136.33,69.72 136.33,73.66 v1(135.57,74.42)
  BOTTOM w0.13: v2(136.72,75.28) 135.85,74.42 v1(135.57,74.42)
N30710455: length 16
  TOP w0.13: v1(135.57,77.21) 136.33,77.21 136.59,77.47 R2669.1
  SIG4 w0.155: v1(135.57,77.21) 137.35,75.44 137.35,69.51 138.92,67.94 138.92,65.65 138.3,65.03 YJ25.C27
N30712785: length 28.1
  TOP w0.13: v1(135.78,82.67) 135.57,82.88 R2673.2
  SIG3 w0.155: YJ25.D28 137.5,58.38 136.9,58.98 136.9,60.61 137.28,60.99 137.28,61.25 136.88,61.65 136.88,64.6 136.9,64.62 136.91,64.62 137.2,64.91 137.2,64.92 137.26,64.98 137.26,65.29 136.92,65.64 136.92,72.33 137.6,73.02 137.6,79.75 137.35,80.01 137.35,81.46 136.13,82.67 v1(135.78,82.67)
N30712786: length 36.3
  SIG3 w0.155: YJ25.D27 137.57,57.15 137.41,57.15 136.5,58.06 136.5,60.61 136.12,60.99 136.12,61.24 136.2,61.32 136.2,61.33 136.49,61.62 136.5,61.62 136.5,64.61 136.16,64.95 136.16,65.29 136.53,65.66 136.53,73.34 136.21,73.66 136.21,74.86 136.53,75.18 136.53,79.05 136.33,79.25 136.33,80.5 136.35,80.52 136.33,80.53 136.33,80.82 136.08,81.07 135.55,81.07 135.27,81.36 135.27,84.37 136.08,85.19 136.08,86.74 v1(136.46,87.12)
  BOTTOM w0.13: R2671.2 135.98,87.78 136.21,88.01 v2(136.97,88.01) 136.97,87.63 v1(136.46,87.12)
N30738971: length 15.2
  SIG9 w0.155: v1(134.66,75.44) 135.16,74.93 135.95,74.93 136.21,74.67 136.21,73.64 135.9,73.33 YJ26.A28
  BOTTOM w0.13: v1(134.66,75.44) 134.58,75.36 v2(133.67,75.36) 132.91,76.12 132.91,77.72 133.06,77.87 R2690.1
N30738974: length 14.6
  TOP w0.13: v1(134.68,74.04) 134.68,74.55 134.18,75.05 134.18,77.37 134.56,77.75 R2694.1
  SIG9 w0.155: YJ26.A27 135.1,65.04 134.53,65.61 134.53,66.14 135.32,66.93 135.32,73.4 v1(134.68,74.04)
N30738977: length 28.3
  TOP w0.13: R2687.2 134.56,83.31 135.32,82.55 135.32,82.12 v1(135.88,81.56)
  SIG9 w0.155: v1(135.88,81.56) 136.33,81.1 136.33,75.69 137.35,74.67 137.35,72.9 136.53,72.07 136.53,65.68 136.14,65.29 136.14,64.97 136.52,64.59 136.52,61.67 136.14,61.29 136.14,60.97 136.52,60.59 136.52,59.43 135.9,58.81 YJ26.B28
N30738980: length 40.3
  SIG1 w0.16: v1(133.03,87.81) 133.16,87.68 133.16,85.18 133.54,84.8 133.54,78.86 134.18,78.23 135.7,78.23 136.59,77.34 136.59,76.45 136.84,76.2 v1(136.84,73.91)
  SIG8 w0.155: YJ26.B27 135.95,57.27 136.14,57.27 136.59,57.72 136.59,60.53 136.5,60.62 136.49,60.62 136.2,60.91 136.2,60.92 136.18,60.93 136.18,61.31 136.59,61.72 136.59,61.97 134.47,64.1 134.47,64.58 134.86,64.97 134.86,65.27 134.52,65.61 134.52,66.12 135.51,67.12 135.51,67.88 136.59,68.96 136.59,73.66 v1(136.84,73.91)
  BOTTOM w0.13: v2(137.99,75.18) 137.56,74.76 137.56,74.63 v1(136.84,73.91) ; R2685.2 133.06,87.78 v1(133.03,87.81)
N30762684: length 29.4
  TOP w0.13: v1(122.24,82.17) 121.73,82.67 121.73,83.56 121.58,83.72 R2693.2
  SIG8 w0.155: v1(122.24,82.17) 121.73,81.66 121.73,74.42 121.48,74.17 121.48,70.86 117.53,66.92 117.53,65.68 117.14,65.29 117.14,64.97 117.52,64.59 117.52,61.65 117.14,61.27 117.14,60.97 117.52,60.59 117.52,59.43 116.9,58.81 YJ26.D28
N30762687: length 35.3
  SIG8 w0.155: v1(120.21,80.39) 120.71,79.88 120.71,78.48 120.49,78.25 120.49,71.02 115.52,66.05 115.52,65.61 115.86,65.27 115.86,64.95 115.47,64.56 115.47,61.66 115.86,61.27 115.86,60.97 115.3,60.41 115.3,57.84 115.86,57.28 115.86,56.66 YJ26.D27
  BOTTOM w0.13: v2(119.55,80.01) 119.93,80.39 v1(120.21,80.39) 120.33,80.52 120.33,82.8 120.71,83.18 120.71,86.74 120.87,86.89 R2686.2
N30762757: length 14.4
  SIG6 w0.155: v1(121.04,75.18) 120.46,74.6 120.46,72.9 116.9,69.34 YJ26.C28
  BOTTOM w0.13: R2688.1 121.45,77.87 121.73,77.59 121.73,75.87 v1(121.04,75.18)
N30762760: length 16.1
  TOP w0.13: R2689.1 121.22,77.25 v1(120.97,76.99)
  SIG6 w0.155: YJ26.C27 116.1,65.03 115.41,65.72 115.41,68.48 118.94,72.01 118.94,74.96 v1(120.97,76.99)
N30785887: length 5.2
  TOP w0.13: J34.9 v1(33.21,186.69)
  BOTTOM w0.13: v1(33.21,186.69) 33.21,186.87 v2(32.75,187.32) 32.17,187.32 R3224.2
N30785890: length 3.7
  TOP w0.13: J34.5 30.34,190.83 v1(30.82,190.35)
  BOTTOM w0.13: v2(31.18,191.03) 30.82,190.68 v1(30.82,190.35) 31.53,189.63 R3220.2
N30785893: length 5.1
  TOP w0.13: J34.1 v1(33.34,196.85)
  BOTTOM w0.13: v2(34.1,196.85) v1(33.34,196.85) R3217.2
N30793325: length 5.7
  BOTTOM w0.13: Q39.1 36.32,182.57 35.73,183.16 R3197.2 v2(37.02,183.77)
N30874928: length 6.5
  TOP w0.254: C3647.1 R3536.2 R3537.1 v1(275.15,219.33)
  BOTTOM w0.13: v1(275.15,219.33) v2(275.15,220.09)
  BOTTOM w0.254: v1(275.15,219.33) 274.64,219.33 274.33,219.01 Q2.1
N30874932: length 5.9
  TOP w0.254: v1(276.42,216.66) R3532.2 R3533.1
  BOTTOM w0.13: Q2.3 v2(275.27,213.61)
  BOTTOM w0.381: Q2.3 275.27,215.9 276.03,216.66 v1(276.42,216.66)
N30874944: length 5.7
  TOP w0.254: R3533.2 v1(277.81,219.33)
  BOTTOM w0.13: v1(277.81,219.33) v2(277.81,220.09)
  BOTTOM w0.254: Q3.1 278.38,216.35 277.81,216.91 v1(277.81,219.33)
N30987892: length 34.4
  SIG2 w0.152: YJ27.B27 165.57,57.15 165.41,57.15 164.5,58.06 164.5,60.56 164.12,60.94 164.12,61.25 164.49,61.62 164.5,61.62 164.5,64.6 164.16,64.93 164.16,65.29 164.53,65.66 164.53,77.47 165.91,78.84 165.91,85.7 v1(166.43,86.23)
  BOTTOM w0.13: R2709.2 v1(166.43,86.23) 167.07,86.23 v2(167.2,86.36)
N30987895: length 27.8
  TOP w0.13: v1(166.43,83.06) R2711.2
  SIG2 w0.152: v1(166.43,83.06) 166.92,82.57 166.92,78.36 165.67,77.11 165.67,73.28 165.17,72.77 165.17,66.3 164.92,66.05 164.92,65.64 165.26,65.29 165.26,64.97 164.88,64.59 164.88,61.67 165.28,61.27 165.28,60.98 164.9,60.6 164.9,58.98 165.5,58.38 YJ27.B28
N30987906: length 12.9
  SIG2 w0.152: v1(166.81,75.44) 166.18,74.8 166.18,72.9 165.67,72.39 165.67,66.55 165.5,66.37 YJ27.A28
  BOTTOM w0.13: R2707.1 167.45,77.34 167.54,77.25 v2(167.54,76.59) 167.54,76.16 v1(166.81,75.44)
N30987909: length 14.4
  TOP w0.13: v1(166.81,76.32) 167.45,76.96 R2705.1
  SIG4 w0.155: YJ27.A27 166.3,65.03 166.92,65.65 166.92,66.31 166.81,66.42 166.81,72.13 167.32,72.64 167.32,75.82 v1(166.81,76.32)
N31014314: length 15.8
  SIG2 w0.152: YJ27.C28 184.72,66.04 184.72,68.7 180.4,73.02 180.4,74.8 v1(179.77,75.44)
  BOTTOM w0.13: R2706.1 179.41,77.87 179.26,77.72 179.26,75.94 v1(179.77,75.44) 179.9,75.31 v2(180.66,75.31)
N31014317: length 16.8
  TOP w0.13: R2718.1 180.78,76.65 181.11,76.32 v1(181.42,76.32)
  SIG1 w0.16: YJ27.C27 185.3,65.03 185.97,65.7 185.97,71.78 v1(181.42,76.32)
  BOTTOM w0.13: v2(182.18,76.32) v1(181.42,76.32)
N31014328: length 29.3
  TOP w0.13: R2710.2 180.12,83.72 180.28,83.56 180.28,82.67 v1(179.77,82.17)
  SIG3 w0.155: YJ27.D28 184.5,58.38 183.9,58.98 183.9,60.61 184.28,60.99 184.28,61.26 183.88,61.66 183.88,64.6 183.9,64.62 183.91,64.62 184.2,64.91 184.2,64.92 184.26,64.98 184.26,65.27 184.2,65.32 184.2,65.33 183.92,65.61 183.92,66.05 184.17,66.3 184.17,71.75 181.97,73.95 181.97,77.94 180.78,79.12 180.78,81.15 v1(179.77,82.17)
N31014331: length 35.1
  SIG3 w0.155: v1(179.77,81.28) 180.28,80.77 180.28,78.72 180.51,78.48 180.51,74.52 183.53,71.5 183.53,65.66 183.49,65.62 183.49,65.62 183.16,65.29 183.16,64.95 183.5,64.61 183.5,61.62 183.49,61.62 183.12,61.25 183.12,60.99 183.5,60.61 183.5,58.06 184.41,57.15 184.57,57.15 YJ27.D27
  BOTTOM w0.13: R2708.2 179.77,87.12 180.15,86.74 180.15,85.72 180.28,85.6 180.28,82.67 180.53,82.42 v2(180.53,81.91) 179.9,81.28 v1(179.77,81.28)
