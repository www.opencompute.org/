# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ZQSFP+_SCL_63: length 125.5
  TOP w0.13: v1(426.15,113.1) 425.64,112.6 422.75,112.6 422.62,112.72 R428.2 422.06,113.13 421.93,113 421.93,112.41 421.03,111.51 U18.20
  SIG3 w0.155: v1(426.15,113.1) 425.56,112.52 422.5,112.52 417.49,107.51 417.49,82.12 403.32,67.94 396.05,67.94 392.49,64.38 392.49,62.98 390.26,60.75 390.26,55.04 388.68,53.46 386.91,53.46 384.74,51.3 384.74,49.33 382.96,47.54 374.15,47.54 v1(370.64,51.06)
  SIG10 w0.155: YJ36.A11 370.27,61.19 370.1,61.19 369.5,60.58 369.5,57.63 369.88,57.25 369.88,56.97 369.5,56.58 369.5,53.63 369.8,53.33 369.8,52.91 369.5,52.61 369.5,51.74 370.18,51.06 v1(370.64,51.06)
  BOTTOM w0.13: v1(426.15,113.1) v2(426.91,113.1)
ZQSFP+_SDA_0: length 60.9
  TOP w0.13: U12.4 12.48,96.54 11.52,97.51 R246.2 10.6,98.04 8.83,98.04 8.32,97.53 v1(8.32,97.51)
  SIG1 w0.16: v1(7.94,70.74) 15.3,63.37 23.43,63.37 24.19,62.61 25.59,62.61 25.86,62.34 25.86,61.59 25.3,61.03 YJ21.A12
  SIG9 w0.155: v1(7.94,70.74) 7.43,71.24 7.43,75.66 8.1,76.33 8.1,82.17 9.81,83.88 9.81,86.87 11.34,88.39 11.34,95.21 9.52,97.03 8.8,97.03 v1(8.32,97.51)
  BOTTOM w0.13: v1(7.94,70.74) v2(8.7,70.74)
ZQSFP+_SDA_1: length 67.5
  TOP w0.13: v1(8.32,95.27) 8.32,95.3 8.83,95.81 10.99,95.81 11.14,95.65 R248.2 11.98,95.27 12.01,95.24 U12.6
  SIG1 w0.16: YJ21.B12 25.3,53.03 25.86,53.6 25.86,54.1 25.47,54.49 23.93,54.49 23.34,55.08 16.23,55.08 15.11,56.19 15.11,58.86 6.79,67.18 6.79,72.64 v1(4.76,74.67)
  SIG9 w0.155: v1(8.32,95.27) 8.85,94.74 9.63,94.74 10.41,93.96 10.41,88.78 8.88,87.25 8.88,84.27 6.38,81.77 6.38,76.29 v1(4.76,74.67)
  BOTTOM w0.13: v1(4.76,74.67) v2(4,74.67)
ZQSFP+_SDA_2: length 73.7
  TOP w0.13: v1(6.16,85.09) 5.52,85.72 5.52,89.91 7.05,91.44 7.56,91.44 7.81,91.69 7.81,92.56 8.83,93.57 10.99,93.57 11.14,93.42 R250.2 11.57,93.04 12.47,93.94 U12.8
  SIG1 w0.16: YJ21.C12 44.3,61.03 44.86,61.6 44.86,62.48 44.69,62.66 42.95,62.66 41.85,63.76 35.68,63.76 34.83,64.61 34.83,69.25 28.89,75.18 26.1,75.18 21.46,79.82 21.46,82.86 18.67,85.66 15.6,85.66 14.92,86.33 13.3,86.33 11.54,84.58 6.67,84.58 v1(6.16,85.09)
  BOTTOM w0.13: v1(6.16,85.09) v2(5.02,85.09)
ZQSFP+_SDA_3: length 80.7
  TOP w0.13: U12.10 12.98,92.64 12.13,91.79 12.13,91.18 11.75,90.8 R1956.2 11.14,91.18 10.99,91.34 8.83,91.34 8.32,90.83 v1(8.32,90.8)
  SIG1 w0.16: v1(4.89,79.25) 5.78,80.13 12,80.13 13.91,78.23 21.15,78.23 25.46,73.91 28.51,73.91 33.69,68.73 33.69,57.53 35.72,55.5 42.48,55.5 43.5,54.48 44.64,54.48 44.86,54.26 44.86,53.6 44.3,53.03 YJ21.D12
  SIG9 w0.155: v1(8.32,90.8) 7.81,90.29 7.81,88.28 7.31,87.77 7.31,84.69 4.89,82.27 v1(4.89,79.25)
  BOTTOM w0.13: v1(4.89,79.25) v2(4.13,79.25)
ZQSFP+_SDA_4: length 82
  TOP w0.13: v1(20.13,89.15) 20.38,88.9 21.91,88.9 22.06,89.05 R2097.2 21.5,89.68 19.84,91.34 U12.13
  SIG1 w0.16: YJ23.A12 72.3,61.03 72.86,61.6 72.86,62.2 72.45,62.61 70.93,62.61 69.95,63.59 63.85,63.59 60.77,66.67 60.77,79.88 58.23,82.42 58.23,84.58 57.59,85.21 54.17,85.21 53.83,85.55 52.94,85.55 52.39,86.1 51.5,86.1 50.1,87.5 44.39,87.5 44.13,87.25 41.17,87.25 39.03,89.38 20.82,89.38 20.59,89.15 v1(20.13,89.15)
  BOTTOM w0.13: v1(20.13,89.15) 19.49,89.15 v2(19.37,89.28)
ZQSFP+_SDA_5: length 101.5
  TOP w0.13: v1(13.14,88.52) 14.03,88.52 14.29,88.77 14.29,89.66 14.61,89.98 16.38,89.98 17.34,90.93 17.34,91.69 18.29,92.64 U12.15 20.58,92.64 21.3,91.92 R2099.2
  SIG1 w0.16: YJ23.B12 72.3,53.03 72.86,53.6 72.86,54.07 72.33,54.61 70.93,54.61 70.14,55.39 63.41,55.39 57.59,61.21 57.59,77.47 57.85,77.72 57.85,79.88 56.77,80.96 55.63,80.96 52.77,83.82 50.36,83.82 47.94,86.23 46.55,86.23 45.66,85.34 44.69,85.34 43.57,84.22 42.2,84.22 38.67,87.75 15.86,87.75 15.1,88.52 v1(13.14,88.52)
  BOTTOM w0.13: v1(13.14,88.52) v2(12.38,88.52)
ZQSFP+_SDA_6: length 100.5
  TOP w0.13: v1(25.13,94.1) 24.63,93.6 22.16,93.6 22.06,93.7 R2101.2 20.94,94.16 20.73,93.94 U12.17
  SIG1 w0.16: YJ23.C12 91.3,61.03 91.86,61.6 91.86,62.48 91.62,62.73 89.86,62.73 89.03,63.56 82.76,63.56 81.96,64.36 81.96,75.2 80.58,76.58 80.58,85.09 77.05,88.62 63.34,88.62 61.91,90.04 60.52,90.04 60.01,90.55 54.29,90.55 53.78,91.06 51.75,91.06 50.8,92.01 42.8,92.01 40.7,94.1 v1(25.13,94.1)
  BOTTOM w0.13: v1(25.13,94.1) v2(25.13,93.34)
ZQSFP+_SDA_7: length 107.2
  TOP w0.13: U12.19 20.25,95.24 20.89,95.88 21.91,95.88 22.06,96.03 R2103.2 v1(21.4,96.39)
  SIG1 w0.16: v1(21.4,96.39) 21.4,96.01 26.35,91.06 40.96,91.06 41.34,90.68 49.97,90.68 51.24,89.41 52.39,89.41 53.78,88.01 58.36,88.01 58.74,87.63 73.6,87.63 76.9,84.33 76.9,78.1 80.96,74.04 80.96,57.53 83.12,55.37 89.34,55.37 89.93,54.79 91.18,54.79 91.86,54.1 91.86,53.6 91.3,53.03 YJ23.D12
ZQSFP+_SDA_8: length 124.9
  TOP w0.13: U11.4 47.03,101.62 46.06,102.59 R185.2 45.81,102.84 45.53,103.12 41.95,103.12 v1(41.31,103.76)
  SIG1 w0.16: YJ25.A12 119.3,61.03 119.86,61.6 119.86,62.23 119.61,62.48 117.79,62.48 116.71,63.56 110.43,63.56 109.66,64.32 109.66,66.8 110.43,67.56 110.43,80.77 109.46,81.74 109.46,85.44 108.31,86.59 102.95,86.59 93.86,95.68 86.48,95.68 85.24,94.44 56.84,94.44 56.52,94.12 46.82,94.12 45.89,95.06 43.31,95.06 41.91,96.46 41.91,98.7 41.39,99.21 41.39,103.67 v1(41.31,103.76)
  BOTTOM w0.13: v2(40.58,104.01) 40.83,103.76 v1(41.31,103.76)
ZQSFP+_SDA_9: length 138.9
  TOP w0.13: v1(39.81,101.98) 40.91,100.89 45.64,100.89 45.81,100.71 R187.2 48.44,100.35 U11.6
  SIG1 w0.16: v1(39.81,101.98) 40.36,101.44 40.36,98.89 40.95,98.3 40.95,95.81 43.6,93.16 55.4,93.16 56.11,92.45 61.53,92.45 61.78,92.2 77.55,92.2 77.87,92.52 86.04,92.52 87.28,93.76 93.03,93.76 95.14,91.65 95.14,88.52 100.6,83.06 105.09,83.06 108.3,79.85 108.3,75.34 103.95,70.99 103.95,55.75 104.97,54.73 106.11,54.73 106.62,55.24 117.41,55.24 117.9,54.75 119.21,54.75 119.86,54.1 119.86,53.6 119.3,53.03 YJ25.B12
  BOTTOM w0.13: v1(39.81,101.98) v2(39.03,101.98)
ZQSFP+_SDA_10: length 135.9
  TOP w0.13: U11.8 47.4,99.02 46.49,98.12 R189.2 45.81,97.66 45.68,97.53 44.51,97.53 43.5,98.55 42.99,98.55 42.82,98.37 42.82,97.31 v1(42.41,96.9)
  SIG1 w0.16: YJ25.C12 138.3,61.03 138.86,61.6 138.86,62.48 138.69,62.65 137.18,62.65 136.46,63.37 130.27,63.37 128.71,64.93 128.71,76.07 127.25,77.53 127.25,83.88 123.13,88.01 119.7,88.01 116.51,91.19 103.83,91.19 95.45,99.57 84.7,99.57 81.63,96.49 61.43,96.49 60.39,97.53 59.75,97.53 59.25,97.03 54,97.03 53.87,96.9 v1(42.41,96.9)
  BOTTOM w0.13: v2(43.07,96.47) 42.63,96.9 v1(42.41,96.9)
ZQSFP+_SDA_11: length 140.7
  TOP w0.13: U11.10 47.65,97.72 R179.2 45.81,95.58 45.58,95.35 44.49,95.35 44.18,95.04 44.18,94.28 45.01,93.46 48.47,93.46 50.08,95.06 v1(50.08,95.76)
  SIG1 w0.16: YJ25.D12 138.3,53.03 139,53.74 139,54.23 138.62,54.61 136.84,54.61 136.08,55.37 129.73,55.37 127.57,57.53 127.57,75.44 125.98,77.02 125.98,81.91 124.84,83.06 124.84,83.88 124.02,84.71 117.92,84.71 116.9,83.69 113.93,83.69 109.11,88.51 103.79,88.51 94.67,97.64 85.64,97.64 83.41,95.4 55.88,95.4 55.56,95.08 50.75,95.08 v1(50.08,95.76)
  BOTTOM w0.13: v2(51.5,94.87) 50.61,95.76 v1(50.08,95.76)
ZQSFP+_SDA_12: length 148
  TOP w0.13: v1(80.45,101.85) 75.12,96.52 62.17,96.52 58.85,93.2 56.89,93.2 56.58,93.51 56.58,93.97 56.73,94.13 R181.2 56.17,94.64 55.82,94.99 55.82,95.88 55.28,96.42 U11.13
  SIG1 w0.16: v1(80.45,101.85) 82.01,103.41 97.05,103.41 105.42,95.03 126.9,95.03 130.11,91.82 138.62,91.82 140.27,90.17 140.27,89.28 141.16,88.39 144.08,88.39 148.02,84.45 148.02,81.79 149.42,80.39 149.42,69.09 154.87,63.63 163.51,63.63 164.28,62.86 166.18,62.86 166.86,62.18 166.86,61.6 166.3,61.03 YJ27.A12
  BOTTOM w0.13: v1(80.45,101.85) v2(80.45,102.61)
ZQSFP+_SDA_13: length 150.6
  TOP w0.13: v1(78.04,101.8) 73.77,97.53 61.66,97.53 60.54,96.42 56.92,96.42 56.73,96.61 R191.2 56.1,97 55.37,97.72 U11.15
  SIG1 w0.16: v1(78.04,101.8) 78.04,101.72 79.56,100.21 82.62,100.21 83.9,101.49 96.25,101.49 104.62,93.11 122.67,93.11 127.65,88.14 128.84,88.14 130.79,86.18 130.79,72.53 135.16,68.16 145.21,68.16 150.94,62.43 150.94,56.64 152.08,55.5 164.02,55.5 164.85,54.67 166.37,54.67 166.86,54.18 166.86,53.6 166.3,53.03 YJ27.B12
  BOTTOM w0.13: v1(78.04,101.8) v2(78.04,102.61)
ZQSFP+_SDA_14: length 167.2
  TOP w0.13: v1(79.06,107.74) 69.89,98.57 62.14,98.57 62.04,98.68 56.86,98.68 56.73,98.8 R193.2 56.07,99.24 55.86,99.02 U11.17
  SIG1 w0.16: v1(79.06,107.74) 79.49,107.31 96.16,107.31 106.2,97.27 127.71,97.27 129.6,95.37 136.72,95.37 137.99,94.1 144.21,94.1 150.43,87.88 158.56,87.88 158.71,88.03 161.84,88.03 163.13,86.74 168.47,86.74 171.7,83.5 172.85,83.5 173.29,83.06 173.29,78.61 175.89,76.01 175.89,64.52 176.85,63.56 182.31,63.56 183.01,62.86 185.48,62.86 185.86,62.48 185.86,61.6 185.3,61.03 YJ27.C12
  BOTTOM w0.13: v1(79.06,107.74) v2(79.06,108.51)
ZQSFP+_SDA_15: length 172.8
  TOP w0.13: U11.19 55.05,100.32 56.2,101.47 R195.2 56.73,101.19 56.99,100.94 64.06,100.94 v1(70.87,107.74)
  SIG1 w0.16: v1(70.87,107.74) 73.28,105.33 96.57,105.33 105.71,96.19 127.31,96.19 130.54,92.96 140.27,92.96 141.29,91.95 142.68,91.95 148.02,86.61 154.75,86.61 156.43,84.94 160.24,84.94 161.35,83.82 164.02,83.82 164.4,84.2 168.97,84.2 170.88,82.29 170.88,77.98 171.26,77.59 171.26,72.13 174.82,68.58 174.82,57.66 177.23,55.24 183.35,55.24 183.73,54.86 185.48,54.86 185.86,54.48 185.86,53.6 185.3,53.03 YJ27.D12
  BOTTOM w0.13: v1(70.87,107.74) v2(70.87,108.52)
ZQSFP+_SDA_16: length 306.1
  TOP w0.13: v1(415.73,125.35) 415.12,124.74 U10.4 413.3,124.74 412.33,125.7 R163.2
  SIG2 w0.155: YJ29.A12 213.3,58.79 213.86,58.24 213.86,57.59 213.6,57.34 213.6,56.91 213.93,56.58 213.93,56.13 211.92,54.12 211.92,53.61 212.2,53.33 212.2,52.91 211.92,52.63 211.92,50.52 v1(212.79,49.65)
  SIG6 w0.155: v1(385.27,32.78) 385.64,33.14 385.64,36.7 389.57,40.64 389.57,60.44 394.78,65.64 394.78,73.45 v1(399.39,78.06) 404.31,82.97 404.31,95.1 411.08,101.87 411.08,120.69 v1(415.73,125.35)
  SIG10 w0.155: v1(212.79,49.65) 212.79,49.07 233.28,28.58 381.73,28.58 382.71,29.56 382.71,30.22 v1(385.27,32.78)
ZQSFP+_SDA_17: length 293.3
  TOP w0.13: U10.6 413.07,123.44 413.04,123.47 R165.2 411.82,123.06 411.7,122.93 409.69,122.93 v1(409.31,123.31)
  SIG2 w0.152: YJ29.B12 213.3,51.18 v1(212.79,50.67)
  SIG9 w0.155: v1(212.79,50.67) 213.3,50.16 213.3,48.81 225.77,36.33 387.31,36.33 393.26,42.29 393.26,58.77 394.19,59.7 394.19,62.67 397.32,65.8 397.32,74.04 403.45,80.16 404.21,80.16 404.78,80.74 404.78,81.69 407.96,84.86 409.03,84.86 410.4,86.23 410.4,92.05 410.93,92.58 410.93,102.17 413.87,105.12 413.87,121.62 412.56,122.93 409.69,122.93 v1(409.31,123.31)
  BOTTOM w0.13: v1(409.31,123.31) v2(407.56,123.31)
ZQSFP+_SDA_18: length 284.3
  TOP w0.13: v1(415.86,121.79) 415.86,122.02 415.74,122.14 U10.8 413.41,122.14 412.51,121.23 R167.2
  SIG2 w0.155: YJ29.C12 232.3,59.78 230.92,58.4 230.92,57.64 231.3,57.25 231.3,57.01 230.92,56.63 230.92,53.61 231.2,53.33 231.2,52.91 230.92,52.63 v1(230.92,48.51)
  SIG3 w0.155: v1(405.83,85.85) 406.43,86.45 406.43,88.24 407.52,89.32 407.52,96.14 412.18,100.8 412.18,118.11 v1(415.86,121.79)
  SIG10 w0.155: v1(230.92,48.51) 230.92,46.22 244.06,33.08 382.03,33.08 384.97,36.02 390.11,36.02 394.97,40.88 394.97,57.46 396.52,59.01 396.52,62.05 396.83,62.36 396.83,76.31 402.25,81.73 404.11,81.73 405.97,83.59 405.97,85.71 v1(405.83,85.85)
  BOTTOM w0.13: v1(405.83,85.85) v2(405.83,85.09)
ZQSFP+_SDA_19: length 265.8
  TOP w0.13: U10.10 413.64,120.84 412.79,119.98 412.79,119.38 412.4,119 R169.2 411.82,118.59 411.7,118.46 409.82,118.46 v1(409.31,118.97)
  SIG3 w0.155: v1(232.3,49.4) YJ29.D12
  SIG9 w0.155: v1(232.3,49.4) 232.3,44.68 238.79,38.19 385.98,38.19 389.54,41.76 389.54,60.66 391.25,62.36 391.25,63.2 395.35,67.29 395.35,76.52 401.49,82.66 402.87,82.66 405.04,84.83 405.04,93.51 405.66,94.13 405.66,96.26 408.35,98.96 408.35,102.63 411.39,105.66 411.39,114.73 410.77,115.35 410.77,118.05 410.46,118.36 409.92,118.36 v1(409.31,118.97)
  BOTTOM w0.13: v1(409.31,118.97) v2(407.73,118.97)
ZQSFP+_SDA_20: length 260.8
  TOP w0.13: U10.13 420.96,119.54 421.2,119.3 421.2,118.62 421.93,117.88 R171.2 422.62,117.47 422.75,117.35 425.64,117.35 v1(426.15,117.85)
  SIG3 w0.155: v1(259.5,50.54) 259.5,51.51 258.95,52.07 258.95,52.65 259.3,53 259.3,53.23 258.92,53.61 258.92,56.63 259.23,56.94 259.23,57.3 258.92,57.61 258.92,58.4 260.3,59.78 YJ31.A12
  SIG10 w0.155: v1(259.5,50.54) 259.5,49.25 270.86,37.88 389.08,37.88 393.11,41.91 393.11,65.31 394.35,66.55 394.35,77.55 401.17,84.37 401.17,84.68 404.57,88.08 413.08,88.08 420.07,95.07 420.07,102.37 421.31,103.61 421.31,117.68 423.13,119.5 425.34,119.5 425.64,119.2 425.64,118.36 v1(426.15,117.85)
  BOTTOM w0.13: v1(426.15,117.85) v2(427.55,117.85)
ZQSFP+_SDA_21: length 251.7
  TOP w0.13: U10.15 421.26,120.84 421.98,120.11 R173.2 422.62,119.71 422.75,119.58 425.64,119.58 v1(426.15,120.09)
  SIG2 w0.155: YJ31.B12 260.3,51.8 v1(261.68,50.42)
  SIG8 w0.155: v1(426.15,120.09) 425.59,120.65 423.35,120.65 418.59,115.88 418.59,114.49 415.1,111 415.1,104.78 405.19,94.88 405.19,82.82 397.45,75.07 397.45,64.39 397.14,64.08 397.14,62.67 396.67,62.21 396.67,50.66 395.54,49.53 395.54,38.61 392.23,35.3 384.97,35.3 382.2,32.53 314.02,32.53 309.29,37.26 280.06,37.26 269.21,48.11 266.78,48.11 266.43,48.46 262.88,48.46 261.68,49.65 v1(261.68,50.42)
  BOTTOM w0.13: v1(426.15,120.09) v2(427.55,120.09)
ZQSFP+_SDA_22: length 241.1
  TOP w0.13: U10.17 421.16,122.14 421.37,122.35 R175.2 422.62,121.94 422.75,121.82 425.64,121.82 v1(426.15,122.32)
  SIG3 w0.155: YJ31.C12 279.3,59.45 279.92,58.83 279.92,57.66 279.59,57.33 279.59,56.89 279.84,56.64 279.84,55.5 279.59,55.24 278.89,55.24 278,54.35 278,53.59 278.2,53.39 278.2,52.91 277.81,52.52 277.81,50.92 279.21,49.53 280.23,49.53 282.77,46.99 289.12,46.99 293.8,42.3 374.4,42.3 377.72,38.99 381.47,38.99 385.74,43.26 385.74,44.46 386.37,45.09 386.37,46.03 386.95,46.61 391.99,46.61 396.36,50.98 396.36,60.04 400.55,64.22 411.39,64.22 415.26,68.1 415.26,74.41 422.08,81.23 422.08,98.47 427.56,103.94 427.56,122.04 427.27,122.32 v1(426.15,122.32)
  BOTTOM w0.13: v1(426.15,122.32) v2(427.55,122.32)
ZQSFP+_SDA_23: length 237.7
  TOP w0.13: U10.19 421.18,123.44 422.33,124.58 R177.2 422.62,124.18 422.75,124.05 425.64,124.05 v1(426.15,124.56)
  SIG2 w0.155: v1(279.08,50.67) 279.08,51.13 279.3,51.35 YJ31.D12
  SIG8 w0.155: v1(426.15,124.56) 425.62,125.09 420.94,125.09 420.18,125.85 415.54,125.85 413.25,123.57 413.25,115.35 412.63,114.73 412.63,105.28 404.97,97.62 404.19,97.62 401.86,95.28 401.86,92.93 401.48,92.54 401.48,83.44 395.04,77 395.04,66.77 394.19,65.93 394.19,51.73 392.87,50.42 392.87,40.75 389.29,37.16 312.64,37.16 306.72,43.08 286,43.08 279.41,49.67 279.41,50.35 v1(279.08,50.67)
  BOTTOM w0.13: v1(426.15,124.56) v2(427.55,124.56)
ZQSFP+_SDA_24: length 192.5
  SIG3 w0.155: v1(303.91,47.97) 305.63,49.68 305.63,52.48 305.19,52.92 305.19,53.32 305.88,54.01 305.88,56.59 306.26,56.97 306.26,57.27 305.88,57.66 305.88,58.42 307.3,59.84 YJ33.A12
  SIG4 w0.155: v1(425.13,113.1) 424.55,112.52 423.9,112.52 420.69,109.31 420.69,102.8 407.54,89.66 402.65,89.66 v1(402.02,89.02)
  SIG9 w0.155: v1(303.91,47.97) 308.19,43.69 321.25,43.69 324.64,47.07 383.43,47.07 384.59,48.23 384.59,72.11 387.71,75.23 388.38,75.23 400.45,87.31 402.25,87.31 402.56,87.62 402.56,88.48 v1(402.02,89.02)
  BOTTOM w0.13: v1(402.02,89.02) 401.38,89.02 v2(401.26,89.15) ; U13.4 421.35,112.16 422.31,113.13 R269.2 422.62,112.72 422.75,112.6 424.62,112.6 v1(425.13,113.1)
ZQSFP+_SDA_25: length 181.4
  SIG2 w0.152: v1(308.04,49.27) 307.3,50.01 YJ33.B12
  SIG5 w0.155: v1(398.59,89.28) 398.6,89.28 419.69,110.36 424.62,110.36 v1(425.13,110.87)
  SIG8 w0.155: v1(308.04,49.27) 308.04,48.58 314.32,42.3 384.25,42.3 386.34,44.39 388.62,44.39 388.89,44.66 388.89,51.77 390.16,53.05 390.16,60.82 387.38,63.6 387.38,74.76 397.6,84.99 397.6,88.29 v1(398.59,89.28)
  BOTTOM w0.13: v1(398.59,89.28) v2(397.83,89.28) ; U13.6 421.45,110.86 421.48,110.89 R271.2 422.62,110.49 422.75,110.36 424.62,110.36 v1(425.13,110.87)
ZQSFP+_SDA_26: length 170.4
  SIG2 w0.152: YJ33.C12 326.3,59.69 324.92,58.31 324.92,57.64 325.26,57.29 325.26,56.97 324.88,56.59 324.88,56.2 324.9,56.18 324.9,54.77 324.53,54.4 324.53,53.66 324.17,53.3 324.17,52.94 324.49,52.62 324.5,52.62 324.5,46.78 v1(326.71,44.57)
  SIG4 w0.155: v1(425.13,108.63) 424.57,108.07 423.94,108.07 421.93,106.06 421.93,102.18 407.98,88.24 405.55,88.24 v1(403.54,86.23)
  SIG9 w0.155: v1(326.71,44.57) 327.3,45.17 328.03,45.17 330.43,42.77 383.74,42.77 386.45,45.48 386.45,71.2 389.03,73.78 391.99,73.78 393.11,74.91 393.11,77.07 401.18,85.14 402.45,85.14 v1(403.54,86.23)
  BOTTOM w0.13: v1(425.13,108.63) 424.62,108.13 422.75,108.13 422.62,108.25 R273.2 422.01,108.66 421.1,109.56 U13.8 ; v1(403.54,86.23) v2(403.54,86.99)
ZQSFP+_SDA_27: length 161.5
  SIG5 w0.155: YJ33.D12 326.3,49.69 332.98,43.01 350.01,43.01 350.99,42.04 373.93,42.04 377.15,38.81 388.6,38.81 393.88,44.09 393.88,58.38 394.81,59.31 394.81,60.93 397.07,63.19 397.07,63.96 397.45,64.34 397.45,82.51 406.28,91.34 409.69,91.34 423.48,105.13 423.48,105.53 423.86,105.92 424.65,105.92 v1(425.13,106.4)
  BOTTOM w0.13: U13.10 420.96,108.26 421.96,107.26 421.96,106.55 422.08,106.42 R275.2 422.62,106.02 422.75,105.89 424.62,105.89 v1(425.13,106.4)
ZQSFP+_SDA_28: length 141.9
  SIG3 w0.155: v1(418.91,106.04) 418.54,105.67 418.54,81.36 412.4,75.23 412.4,68.95 410.15,66.7 397.14,66.7 395.12,64.69 395.12,62.98 393.11,60.97 393.11,52.3 391.99,51.18 386.91,51.18 385.83,50.1 385.83,48.22 384.51,46.91 384.51,45.87 382.35,43.7 376.29,43.7 371.26,48.73 363.82,48.73 363.21,49.35 361.71,49.35 361.25,48.89 356.22,48.89 352.2,52.91 352.2,53.33 352.62,53.75 352.62,54.1 352.87,54.35 352.87,56.58 353.26,56.97 353.26,57.27 352.92,57.61 352.92,58.31 354.3,59.69 YJ35.A12
  BOTTOM w0.13: v1(418.91,106.04) 418.17,105.31 v2(413.96,105.31) R277.2 411.82,105.69 412.05,105.92 412.56,105.92 413.61,106.96 U13.13
ZQSFP+_SDA_29: length 116.2
  SIG2 w0.152: v1(357.44,50.54) 356.18,50.54 YJ35.B12
  SIG5 w0.155: v1(409.31,107.52) 409.31,102.58 395.19,88.47 395.19,65.22 390.16,60.2 390.16,47.65 389.13,46.61 385.34,46.61 382.35,43.62 378.55,43.62 372.15,50.02 364.43,50.02 363.81,49.4 360.98,49.4 360.36,50.02 357.97,50.02 v1(357.44,50.54)
  BOTTOM w0.13: U13.15 412.55,108.26 R279.2 411.82,107.13 411.7,107.01 410.07,107.01 409.74,106.68 409.51,106.68 v2(409.44,106.75) 409.31,106.88 v1(409.31,107.52)
ZQSFP+_SDA_30: length 104.5
  SIG3 w0.155: YJ35.C12 373.3,58.69 373.95,58.04 373.95,57.68 373.6,57.33 373.6,56.91 373.95,56.56 373.95,56.13 371.92,54.1 371.92,53.61 372.2,53.33 372.2,52.91 371.95,52.66 371.95,52.07 372.59,51.43 373.95,51.43 376.44,48.94 382.78,48.94 383.5,49.66 383.5,52.6 386.65,55.75 388.51,55.75 389.08,56.32 389.08,61.13 391.25,63.29 391.25,64.69 399,72.44 403.08,72.44 416.56,85.92 416.56,108.52 v1(415.86,109.22)
  BOTTOM w0.13: v1(415.86,109.22) 415.52,109.56 U13.17 413.03,109.56 v2(412.94,109.47) 412.64,109.78 R281.2
ZQSFP+_SDA_31: length 94.8
  SIG5 w0.155: v1(409.31,111.99) 408.83,111.5 408.16,111.5 406.43,109.78 406.43,102.58 392.95,89.1 392.95,74.45 392.49,73.99 388.93,73.99 388,73.06 388,61.28 386.8,60.08 386.8,52.1 383.6,48.89 376.83,48.89 376.17,49.55 375.94,49.55 373.66,51.83 373.66,52.07 YJ35.D12
  BOTTOM w0.13: U13.19 413.68,110.86 412.53,112.01 R283.2 411.82,111.61 411.7,111.48 409.99,111.48 409.77,111.25 v2(409.51,111.25) 409.31,111.45 v1(409.31,111.99)
ZQSFP+_SDA_32: length 71.4
  SIG9 w0.155: YJ22.D12 22.1,51.62 20.38,49.91 12.95,49.91 12.09,50.76 12.09,57.06 10.48,58.67 10.48,61.85 9.21,63.12 9.21,65.02 10.38,66.19 10.38,73.03 11.8,74.45 11.8,78.66 12.89,79.75 12.89,83.62 15.05,85.78 15.05,87.63 15.43,88.01 15.43,92.07 15.88,92.52 16.51,92.52 17.08,93.09 17.59,93.09 17.84,93.34 17.84,96.14 17.39,96.59 v1(17.32,96.59)
  BOTTOM w0.13: v2(24.19,98.04) 22.29,98.04 22.06,97.81 R320.2 22.06,97.05 21.93,96.92 21.04,96.92 20.66,96.54 U16.4 17.37,96.54 v1(17.32,96.59)
ZQSFP+_SDA_33: length 81.2
  SIG8 w0.155: YJ22.C12 22.1,59.75 23.56,58.29 23.56,57.7 23.18,57.32 23.18,56.92 23.56,56.54 23.56,53.77 23.18,53.39 23.18,52.93 23.56,52.55 23.56,52.07 23.05,51.56 22.03,51.56 20.51,50.04 16.32,50.04 15.2,48.92 11.6,48.92 11.37,49.15 11.37,53.72 9.46,55.62 9.46,66.29 8.99,66.77 v1(8.99,67.18)
  SIG9 w0.155: v1(8.99,67.18) 8.99,75.66 9.17,75.84 9.17,81.93 12.27,85.02 12.27,87.38 12.64,87.75 12.64,92.3 v1(15.97,95.63)
  BOTTOM w0.13: R322.2 21.15,95.27 21.12,95.24 U16.6 17.97,95.24 17.89,95.17 16.43,95.17 v1(15.97,95.63) ; v1(8.99,67.18) 8.61,66.8 v2(7.81,66.8)
ZQSFP+_SDA_34: length 91
  SIG9 w0.155: v1(15.97,94.66) 16.45,94.19 16.45,93.47 16.07,93.09 15.68,93.09 14.92,92.33 14.92,88.26 14.55,87.89 14.55,87.49 13.2,86.14 13.2,84.59 12.42,83.81 12.42,80.76 11.79,80.13 10.99,80.13 10.38,79.53 10.38,75.22 9.92,74.76 9.92,66.75 8.7,65.53 8.7,59.56 11.37,56.89 11.37,49.15 13.02,47.49 33.2,47.49 33.98,48.26 33.98,49.41 35.75,51.18 40.58,51.18 41.1,51.7 YJ22.B12
  BOTTOM w0.13: R324.2 21.58,93.04 20.67,93.94 U16.8 17.84,93.94 17.63,94.16 16.48,94.16 v1(15.97,94.66)
ZQSFP+_SDA_35: length 98.5
  SIG8 w0.155: YJ22.A12 41.1,59.42 42.45,58.07 42.45,57.59 42.08,57.22 42.08,57.03 42.48,56.63 42.48,53.61 42.1,53.23 42.1,53 42.48,52.62 42.48,51.94 41.34,50.8 34.98,50.8 33.84,49.65 31.94,49.65 31.56,50.04 27.88,50.04 27.11,49.27 17.87,49.27 17.52,48.92 15.96,48.92 15.47,48.44 11.19,48.44 10.8,48.83 10.8,53.62 8.95,55.46 8.95,65.91 8.32,66.55 8.32,67.69 8.83,68.2 10.22,68.2 v1(10.86,68.83)
  SIG9 w0.155: v1(17.34,92.58) 16.52,91.77 16.52,86.6 13.35,83.42 13.35,79.56 12.27,78.47 12.27,74.14 10.86,72.73 v1(10.86,68.83)
  BOTTOM w0.13: R326.2 21.63,90.8 21.4,91.03 21.4,91.64 v2(20.97,92.07) 20.4,92.64 U16.10 17.4,92.64 v1(17.34,92.58)
ZQSFP+_SDA_36: length 122.6
  SIG9 w0.155: v1(7.3,89.68) v2(7.3,88.9) 5.52,87.12 5.52,84.2 3.81,82.48 3.81,77.66 2.98,76.83 2.98,58.43 6.81,54.61 6.81,47.48 7.56,46.73 9.59,46.73 13.04,43.28 37.5,43.28 42.99,48.77 66.59,48.77 69.1,51.27 YJ24.D12
  BOTTOM w0.13: v2(7.3,88.9) v1(7.3,89.68) 7.84,90.22 10.86,90.22 11.14,89.94 R328.2 11.39,89.68 13.05,91.34 U16.13
ZQSFP+_SDA_37: length 135.7
  SIG9 w0.155: v1(7.3,91.92) 7.3,91.46 6.79,90.95 6.79,89.28 5.02,87.5 5.02,84.43 2.18,81.59 2.18,58.33 6.29,54.23 6.29,46.86 7.56,45.59 9.59,45.59 12.38,42.8 37.77,42.8 42.42,47.45 66.15,47.45 70.48,51.79 70.48,52.62 70.15,52.96 70.15,53.34 70.53,53.72 70.53,56.57 70.15,56.95 70.15,57.36 70.48,57.69 70.48,58.08 69.1,59.47 YJ24.C12
  BOTTOM w0.13: U16.15 12.95,92.64 12.23,91.92 R330.2 11.14,92.17 10.83,92.48 v2(8.8,92.48) 7.86,92.48 v1(7.3,91.92)
ZQSFP+_SDA_38: length 139.2
  SIG10 w0.155: v1(7.3,94.16) 7.86,93.6 9.59,93.6 10.22,92.96 10.22,86.74 7.3,83.82 7.3,83.44 6.16,82.29 6.16,68.7 12.38,62.48 12.38,48 13.47,46.91 84.19,46.91 88.1,50.82 YJ24.B12
  BOTTOM w0.13: U16.17 12.39,93.94 v2(12.36,93.98) 12.18,94.16 R332.2 11.14,94.41 10.83,94.71 7.86,94.71 v1(7.3,94.16)
ZQSFP+_SDA_39: length 184.3
  SIG1 w0.16: v1(7.3,96.39) 7.81,95.88 8.45,95.88 8.83,95.5 8.83,89.41 8.32,88.9 5.65,88.9 3.87,87.12 v1(3.11,87.12)
  SIG10 w0.155: v1(3.11,87.12) 3.65,86.59 3.65,69.82 10.91,62.56 10.91,44.9 12.69,43.12 82.2,43.12 86.45,47.37 100.8,47.37 101.39,47.96 101.39,54.27 97.12,58.54 90.72,58.54 89.51,59.76 88.76,59.76 YJ24.A12
  BOTTOM w0.13: U16.19 12.51,95.24 11.37,96.39 R334.2 11.14,96.64 10.86,96.92 7.84,96.92 v1(7.3,96.39) 6.54,97.15 v2(6.54,97.3)
ZQSFP+_SDA_40: length 111.4
  SIG1 w0.16: v1(104.98,52.19) 101.99,55.19 101.99,66.85 97.66,71.18 97.66,74.48 97.09,75.05 97.09,78.48 95.82,79.75 95.82,81.05 97.19,82.42 97.19,83.97 93.68,87.49 93.68,91.08 92.43,92.32 87.88,92.32 86.28,90.73 v1(86.28,89.64)
  SIG9 w0.155: v1(104.98,52.19) 104.98,49.5 106.05,48.44 115.17,48.44 116.1,49.37 YJ26.D12
  BOTTOM w0.13: v1(86.28,89.64) 86.28,90.69 82.23,94.74 77.53,94.74 70.17,102.11 v2(62.67,102.11) 62.36,101.79 62.36,101.53 62.04,101.22 61.4,101.22 60.51,102.11 56.96,102.11 56.73,102.34 R336.2 56.43,102.59 55.46,101.62 U15.4
ZQSFP+_SDA_41: length 127.7
  SIG1 w0.16: v1(75.76,93.16) 76.24,92.68 77.35,92.68 77.68,93 85.84,93 87.08,94.24 93.23,94.24 95.62,91.85 95.62,89.35 100.77,84.2 104.71,84.2 108.78,80.13 108.78,68.58 107.63,67.43 107.63,59.81 104.46,56.64 104.46,56.02 v1(105.08,55.39)
  SIG9 w0.155: YJ26.C12 116.1,59.47 117.48,58.08 117.48,57.69 117.15,57.36 117.15,56.95 117.53,56.57 117.53,53.72 117.15,53.34 117.15,52.96 117.48,52.62 117.48,49.38 115.51,47.4 106.22,47.4 104.46,49.16 104.46,54.77 v1(105.08,55.39)
  BOTTOM w0.13: U15.6 56.07,100.32 56.1,100.35 R338.2 56.73,99.92 56.83,99.82 61.66,99.82 v2(61.79,99.95) 62.04,99.95 63.06,100.96 69.35,100.96 75.76,94.56 v1(75.76,93.16)
ZQSFP+_SDA_42: length 261.8
  SIG1 w0.16: v1(62.55,99.06) 62.55,99.95 61.15,101.34 59.75,101.34 59.5,101.09 46.42,101.09 42.63,104.87 39.59,104.87 39.31,105.15 37.66,105.15 34.86,102.36 31.81,102.36 31.05,101.6 29.15,101.6 28.26,102.49 24.73,102.49 19.39,97.15 16.57,97.15 12,92.58 12,89.41 8.32,85.72 6.03,85.72 3.62,83.31 3.62,66.8 v1(4.51,65.91)
  SIG10 w0.155: YJ26.B12 135.1,48.05 130.04,42.99 84.94,42.99 81.09,39.14 12.61,39.14 9.84,41.91 9.84,55.37 9.46,55.75 9.46,59.1 5.96,62.61 5.96,64.46 v1(4.51,65.91)
  BOTTOM w0.13: v1(62.55,99.06) 61.4,97.91 v2(59.75,97.91) 58.99,97.91 58.61,97.53 57.2,97.53 56.73,98 R340.2 56.25,98.12 55.34,99.02 U15.8
ZQSFP+_SDA_43: length 308.3
  SIG1 w0.16: v1(4.54,64.13) 2.48,66.19 2.48,83.94 6.29,87.75 8.83,87.75 10.86,89.79 10.86,92.96 16.07,98.17 18.99,98.17 26.99,106.17 39.66,106.17 39.98,105.85 43.18,105.85 46.8,102.23 55.05,102.23 55.56,102.74 63.06,102.74 v1(66.1,99.69)
  SIG10 w0.155: v1(4.54,64.13) 4.99,63.68 4.99,62.13 7.94,59.18 7.94,52.7 7.29,52.06 7.29,40.14 7.56,39.88 9.59,39.88 11.45,38.01 126.51,38.01 135.86,47.37 147.8,47.37 148.39,47.96 148.39,54.27 143.99,58.67 137.59,58.67 136.51,59.76 135.76,59.76 YJ26.A12
  BOTTOM w0.13: v1(66.1,99.69) 66.1,98.93 62.04,94.87 v2(58.86,94.87) 58.46,95.27 57.14,95.27 56.73,95.68 R342.2 56.34,95.88 56.21,96.01 56.21,96.68 55.17,97.72 U15.10
ZQSFP+_SDA_44: length 161.3
  SIG1 w0.16: v1(52.24,97.91) 54.21,97.91 54.59,97.53 58.74,97.53 59.37,98.17 60.52,98.17 61.7,96.99 81.44,96.99 84.5,100.05 95.65,100.05 104.02,91.67 116.71,91.67 119.36,89.02 120.33,89.02 120.71,88.64 123.38,88.64 127.7,84.33 127.7,84.07 128.21,83.56 128.59,83.56 129.35,82.8 129.35,71.9 134.53,66.72 143.77,66.72 146.81,63.68 148.99,61.5 148.99,53.66 v1(151.98,50.67)
  SIG9 w0.155: v1(151.98,50.67) 151.98,49.5 153.05,48.44 162.17,48.44 163.1,49.37 YJ28.D12
  BOTTOM w0.13: v1(52.24,97.91) 50.71,96.39 49.97,96.39 48.45,94.87 v2(48.2,94.87) 48.1,94.76 R344.2 45.81,94.92 46.13,95.25 47.31,95.25 47.64,95.58 47.64,96.34 47.72,96.42 U15.13
ZQSFP+_SDA_45: length 189.3
  SIG1 w0.16: v1(152.34,56.16) 151.77,56.72 151.77,62.31 145.44,68.64 135.51,68.64 131.28,72.87 131.28,86.84 129.48,88.64 127.95,88.64 123,93.59 104.82,93.59 96.45,101.97 83.7,101.97 82.42,100.69 80.1,100.69 78.42,102.36 75.37,102.36 71.06,98.04 62.09,98.04 60.33,99.8 51.99,99.8 50.31,98.13 43.86,98.13 43.31,98.68 42.61,98.68 v1(42.1,99.18)
  SIG9 w0.155: v1(152.34,56.16) 151.46,55.28 151.46,49.16 153.16,47.45 162.56,47.45 164.48,49.38 164.48,52.62 164.15,52.96 164.15,53.34 164.53,53.72 164.53,56.57 164.15,56.95 164.15,57.36 164.48,57.69 164.48,58.08 163.1,59.47 YJ28.C12
  BOTTOM w0.13: v2(41.59,98.55) 41.59,98.68 v1(42.1,99.18) 42.82,98.47 42.82,97.58 43.93,96.47 45.73,96.47 45.81,96.54 R346.2 46.65,97 47.37,97.72 U15.15
ZQSFP+_SDA_46: length 279.4
  SIG2 w0.152: v1(6.92,57.91) 6.92,60.07 13.53,66.67 13.53,86 13.88,86.36 15.56,86.36 20.26,91.06 20.26,93.09 22.16,94.99 24.07,94.99 27.24,98.17 27.24,98.8 27.75,99.31 30.29,99.31 v1(32.58,101.6)
  SIG10 w0.155: YJ28.B12 182.1,50.21 175.26,43.37 133.6,43.37 127.09,36.86 10.7,36.86 9.97,37.59 7.56,37.59 6.29,38.86 6.29,57.27 v1(6.92,57.91)
  BOTTOM w0.13: v1(32.58,101.6) 32.7,101.47 34.61,101.47 36.94,99.13 40.04,99.13 v2(40.7,99.79) 45.68,99.79 45.81,99.67 R348.2 46.29,99.24 46.5,99.02 U15.17
ZQSFP+_SDA_47: length 325.8
  SIG2 w0.152: v1(5.14,58.42) 6.16,59.43 6.16,60.38 13.02,67.24 13.02,86.36 13.65,86.99 14.54,86.99 15.05,87.5 15.05,88.82 15.89,89.66 17.78,89.66 19.49,91.37 19.49,93.4 21.85,95.76 22.16,95.76 24.03,97.63 25.88,97.63 26.48,98.23 26.48,99.12 27.43,100.07 29.78,100.07 32.83,103.12 v1(32.83,104.75)
  SIG10 w0.155: v1(5.14,58.42) 4,57.27 4,39.11 4.38,38.73 4.89,38.73 6.41,37.21 6.41,35.18 8.66,32.93 168.81,32.93 183.24,47.37 194.8,47.37 195.39,47.96 195.39,54.27 190.99,58.67 184.59,58.67 183.51,59.76 182.76,59.76 YJ28.A12
  BOTTOM w0.13: U15.19 46.97,100.32 46.82,100.48 46.8,100.48 R350.2 45.81,101.85 45.63,102.03 44.49,102.03 44.31,101.85 43.88,101.85 43.62,101.6 41.97,101.6 v2(41.47,101.09) 40.45,101.09 39.31,99.95 37.4,99.95 36.74,100.61 36.74,102.38 34.54,104.58 32.99,104.58 v1(32.83,104.75)
ZQSFP+_SDA_48: length 301.2
  SIG4 w0.155: v1(414.21,100.45) 414.63,100.45 417.74,103.57 417.74,120.47 422.5,125.22 424.68,125.22 v1(425.13,125.68)
  SIG9 w0.155: YJ30.D12 210.1,51.23 228.56,32.77 382.33,32.77 385.37,35.81 387.44,35.81 393.73,42.09 393.73,58.17 394.74,59.18 394.74,61.51 396.52,63.29 396.52,64.07 397.86,65.42 397.86,72.8 413.7,88.64 413.7,99.95 v1(414.21,100.45)
  BOTTOM w0.13: v1(414.21,100.45) v2(414.97,100.45) ; U17.4 421.35,124.74 422.31,125.7 R402.2 422.62,125.3 422.75,125.17 424.62,125.17 v1(425.13,125.68)
ZQSFP+_SDA_49: length 318
  SIG10 w0.155: 211.16,57.31 211.41,57.56 211.41,57.61 ; 211.16,57.31 211.16,56.95 211.75,56.36 211.75,53.78 212.2,53.33 212.2,52.91 211.91,52.62 211.9,52.62 211.9,52.61 211.77,52.48 211.77,49.15 232.81,28.11 382,28.11 387.07,33.18 387.07,34.17 387.48,34.58 392.02,34.58 396.36,38.93 396.36,56.55 401.01,61.2 401.01,65.62 403.02,67.63 403.02,72.25 410.02,79.25 410.02,80.52 422.08,92.58 422.08,95.52 422.7,96.14 422.7,100.63 426.73,104.66 426.73,121.59 426.53,121.79 423.99,121.79 423.61,122.17 423.61,122.68 423.86,122.93 424.47,122.93 v1(425.13,123.59) ; 211.16,57.31 211.16,57.36 211.41,57.61 ; 211.41,57.61 211.41,58.14 210.1,59.46 YJ30.C12
  BOTTOM w0.13: v1(425.13,123.59) 424.47,122.93 422.75,122.93 422.62,123.06 R404.2 421.48,123.47 421.45,123.44 U17.6
ZQSFP+_SDA_50: length 275.3
  SIG4 w0.155: v1(409.38,94.87) 410.89,94.87 419.45,103.42 419.45,116.23 423.86,120.65 424.57,120.65 v1(425.13,121.21)
  SIG9 w0.155: YJ30.B12 229.1,46.49 237.86,37.73 386.6,37.73 390.16,41.29 390.16,60.2 391.87,61.9 391.87,63.14 395.84,67.11 395.84,76.09 401.64,81.89 403.01,81.89 406.21,85.09 406.21,85.09 407.56,86.44 407.56,93.05 v1(409.38,94.87)
  BOTTOM w0.13: U17.8 421.1,122.14 422.01,121.23 R406.2 422.62,120.83 422.75,120.7 424.62,120.7 v1(425.13,121.21) ; v1(409.38,94.87) v2(410.15,94.87)
ZQSFP+_SDA_51: length 293.3
  SIG10 w0.155: 230.41,57.61 230.16,57.36 230.16,57.31 ; 230.41,57.61 230.41,57.56 230.16,57.31 ; 230.41,57.61 230.41,58.14 229.1,59.46 YJ30.A12 ; 230.16,57.31 230.16,56.95 230.54,56.57 230.54,53.7 230.44,53.6 230.44,53.57 230.2,53.33 230.2,52.91 230.57,52.54 230.57,51.85 230.45,51.73 230.45,46.02 230.57,45.91 230.57,42.16 240.12,32.61 382.31,32.61 385.21,35.51 390.34,35.51 395.43,40.6 395.43,57.17 397.14,58.87 397.14,61.9 398.22,62.98 398.22,67.01 397.45,67.79 397.45,76.15 398.76,77.47 399.61,77.47 402.53,80.39 406.04,80.39 420.69,95.03 420.69,101.74 422.86,103.91 422.86,117.74 423.48,118.36 424.52,118.36 v1(425.13,118.97)
  BOTTOM w0.13: U17.10 421.13,120.84 421.96,120.01 421.96,119.25 422.21,119 R408.2 422.62,118.59 422.75,118.46 424.62,118.46 v1(425.13,118.97)
ZQSFP+_SDA_52: length 245.5
  SIG3 w0.155: v1(415.35,102.99) 414.72,103.63 414.72,117.09 v1(415.73,118.11)
  SIG8 w0.155: YJ32.D12 257.1,51.82 261.43,47.49 269.17,47.49 279.87,36.8 308.98,36.8 313.71,32.07 382.73,32.07 385.46,34.8 392.65,34.8 396.18,38.32 396.18,49.27 397.29,50.39 397.29,61.9 398.11,62.72 398.11,72.87 407.99,82.75 407.99,96.77 414.21,102.99 v1(415.35,102.99)
  BOTTOM w0.13: v1(415.73,118.11) 415.35,118.11 414.36,119.1 U17.13 413.48,119.54 413.19,119.25 413.19,118.34 v2(413.07,118.21) 412.74,117.88 R410.2
ZQSFP+_SDA_53: length 250.3
  SIG9 w0.155: v1(409.31,120.09) 409.44,120.09 409.89,119.63 410.37,119.63 411.55,118.45 411.55,115.66 412.01,115.2 412.01,105.51 409,102.5 409,98.55 406.43,95.98 406.43,91.49 405.83,90.89 v1(405.83,87.5)
  SIG10 w0.155: v1(405.83,87.5) 404.92,87.5 404.11,86.69 404.11,84.99 403.02,83.9 401.63,83.9 394.97,77.24 394.97,66.34 394.2,65.57 394.2,59.36 393.57,58.73 393.57,41.6 389.39,37.42 270.4,37.42 258.48,49.33 258.48,52.63 258.09,53.02 258.09,53.25 258.54,53.7 258.54,56.57 258.16,56.95 258.16,57.31 ; 258.41,57.61 258.41,57.56 258.16,57.31 ; 258.41,57.61 258.41,58.14 257.1,59.46 YJ32.C12 ; 258.41,57.61 258.16,57.36 258.16,57.31
  BOTTOM w0.13: U17.15 413.38,120.84 412.66,120.11 R412.2 411.82,119.71 411.7,119.58 409.82,119.58 v1(409.31,120.09) v2(408.42,120.09)
ZQSFP+_SDA_54: length 221.7
  SIG8 w0.155: v1(415.86,122.68) 415.61,122.68 413.87,120.94 413.87,114.89 413.25,114.27 413.25,104.97 403.33,95.06 403.33,87.93 402.25,86.85 402.25,83.28 395.54,76.57 395.54,65.88 394.81,65.15 394.81,51.47 393.64,50.29 393.64,40.58 389.75,36.7 312.33,36.7 306.41,42.62 285.81,42.62 276.1,52.32 YJ32.B12
  BOTTOM w0.13: v1(415.86,122.68) 415.32,122.14 U17.17 413.16,122.14 v2(412.94,121.92) 412.51,122.35 R414.2
ZQSFP+_SDA_55: length 246.1
  SIG9 w0.155: v1(409.31,124.56) 409.41,124.56 409.89,124.08 412.31,124.08 414.49,121.89 414.49,105.03 412.43,102.97 v1(412.43,90.17)
  SIG10 w0.155: 277.16,57.31 277.41,57.56 277.41,57.61 ; 277.16,57.31 277.16,57.36 277.41,57.61 ; 277.16,57.31 277.16,56.95 277.54,56.57 277.54,53.69 277.16,53.31 277.16,52.95 277.67,52.44 277.67,45.82 284.21,39.28 387.99,39.28 391.2,42.48 391.2,61.8 387.84,65.15 387.84,73.21 389.54,74.91 391.71,74.91 392.49,75.69 392.49,78.79 401.01,87.31 401.01,87.61 401.79,88.39 402.24,88.39 404.73,90.87 411.73,90.87 v1(412.43,90.17) ; 277.41,57.61 277.41,58.14 276.1,59.46 YJ32.A12
  BOTTOM w0.13: U17.19 413.58,123.44 412.43,124.58 R416.2 411.82,124.23 411.65,124.05 409.82,124.05 v1(409.31,124.56) 408.62,124.56 v2(408.37,124.31)
ZQSFP+_SDA_56: length 186.4
  TOP w0.13: v1(408.42,113.1) 408.93,112.6 411.7,112.6 411.82,112.72 R418.2 412.33,113.13 413.3,112.16 U18.4
  SIG8 w0.155: YJ34.D12 304.1,50.04 316.05,38.09 388.05,38.09 391.2,41.24 391.2,50.9 391.6,51.31 391.86,51.31 392.64,52.09 392.64,66.55 393.98,67.88 393.98,78.11 400.08,84.21 400.08,95.21 404.05,99.18 404.83,99.18 411.39,105.75 411.39,111.53 410.4,112.52 409,112.52 v1(408.42,113.1)
  BOTTOM w0.13: v1(408.42,113.1) v2(407.66,113.1)
ZQSFP+_SDA_57: length 173
  TOP w0.13: v1(408.42,110.87) 408.93,110.36 411.7,110.36 411.82,110.49 R420.2 413.04,110.89 413.07,110.86 U18.6
  SIG9 w0.155: v1(408.42,110.87) 406.69,109.14 406.69,104.49 405.45,103.25 405.45,101.34 397.32,93.22 397.32,86.31 387.72,76.71 386.91,76.71 382.88,72.68 382.88,50.74 382.11,49.97 376.55,49.97 375.6,49.02 368.68,49.02 367.73,49.97 364.29,49.97 363.47,49.15 360.87,49.15 360.67,48.94 317.01,48.94 316.67,49.27 314.13,49.27 313.28,50.12 304.44,50.12 v1(303.72,49.4)
  SIG10 w0.155: YJ34.C12 304.1,59.46 305.41,58.14 305.41,57.56 305.16,57.31 305.16,56.95 305.54,56.57 305.54,53.69 305.16,53.31 305.16,52.95 305.67,52.44 305.67,51.35 v1(303.72,49.4)
  BOTTOM w0.13: v1(408.42,110.87) v2(407.66,110.87)
ZQSFP+_SDA_58: length 153.6
  TOP w0.13: U18.8 413.41,109.56 412.51,108.66 R421.2 411.82,108.25 411.7,108.13 408.93,108.13 v1(408.42,108.63)
  SIG8 w0.155: YJ34.B12 323.1,50.65 330.98,42.77 383.94,42.77 386.65,45.48 386.65,51.81 387.29,52.45 388.91,52.45 389.54,53.08 389.54,60.35 386.76,63.14 386.76,75.22 396.98,85.45 396.98,94.72 408.02,105.76 408.46,105.76 409,106.3 409,106.8 408.75,107.06 408.75,108.3 v1(408.42,108.63)
  BOTTOM w0.13: v1(408.42,108.63) v2(407.66,108.63)
ZQSFP+_SDA_59: length 160.5
  TOP w0.13: U18.10 413.64,108.26 412.79,107.41 412.79,106.78 412.43,106.42 R423.2 411.82,106.02 411.7,105.89 408.93,105.89 v1(408.42,106.4)
  SIG9 w0.155: v1(324.42,44.57) 325.94,46.1 329.58,46.1 331.98,43.7 382.19,43.7 385.21,46.72 385.21,72.03 387.93,74.75 389.07,74.75 390.94,76.62 390.94,77.08 400.55,86.69 402.4,86.69 403.16,87.45 403.16,97.66 406.59,101.09 406.59,103.02 407.86,104.29 407.86,105.84 v1(408.42,106.4)
  SIG10 w0.155: v1(324.42,44.57) 324.42,50.92 324.93,51.43 324.93,52.64 325.21,52.92 325.21,53.32 324.54,53.99 324.54,56.57 324.16,56.95 324.16,57.31 324.41,57.56 324.41,58.14 323.1,59.46 YJ34.A12
  BOTTOM w0.13: v1(408.42,106.4) v2(407.63,106.4)
ZQSFP+_SDA_60: length 141.8
  TOP w0.13: v1(426.15,105.28) 425.64,104.77 422.75,104.77 422.62,104.9 R425.2 421.42,105.31 421.2,105.53 421.2,106.73 420.96,106.96 U18.13
  SIG5 w0.155: v1(426.15,105.28) 426.15,105.41 425.64,105.92 425.64,106.68 425.39,106.93 423.99,106.93 418.27,101.21 418.27,101.01 409.22,91.96 405.07,91.96 402.68,89.57 401.72,89.57 400.86,88.7 400.86,87.93 396.93,84 396.93,64.5 396.45,64.02 396.45,63.23 394.35,61.13 394.35,59.58 393.42,58.65 393.42,44.55 392.13,43.26 389.95,43.26 385.97,39.28 377.35,39.28 374.09,42.53 359.15,42.53 351.35,50.34 v1(351.35,50.8)
  SIG9 w0.155: YJ36.D12 351.1,51.5 351.35,51.26 v1(351.35,50.8)
  BOTTOM w0.13: v1(426.15,105.28) v2(427.55,105.28)
ZQSFP+_SDA_61: length 144.7
  TOP w0.13: U18.15 421.26,108.26 421.98,107.54 R436.2 422.62,107.13 422.75,107.01 425.64,107.01 v1(426.15,107.52)
  SIG3 w0.155: v1(426.15,107.52) 425.65,107.01 425.65,104.82 419,98.17 419,80.43 413.1,74.52 413.1,68.72 410.46,66.08 398.07,66.08 396.52,64.53 396.52,63.14 394.5,61.13 394.5,52.55 391.99,50.04 387.16,50.04 386.31,49.19 386.31,48.05 384.98,46.72 384.98,45.67 382.54,43.23 375.98,43.23 371.88,47.34 356.62,47.34 354.54,49.42 353.81,49.42 v1(352.67,50.56)
  SIG10 w0.155: YJ36.C12 351.1,59.46 352.41,58.14 352.41,57.56 352.16,57.31 352.16,56.95 352.54,56.57 352.54,53.69 352.16,53.31 352.16,52.95 352.67,52.44 v1(352.67,50.56)
  BOTTOM w0.13: v1(426.15,107.52) v2(427.55,107.52)
ZQSFP+_SDA_62: length 119.3
  TOP w0.13: U18.17 421.16,109.56 421.37,109.78 R438.2 422.62,109.37 422.75,109.24 425.64,109.24 v1(426.15,109.75)
  SIG5 w0.155: v1(426.15,109.75) 426.15,109.85 425.64,110.36 425.64,111.12 425.26,111.5 423.96,111.5 423.46,111 415.55,111 413.78,109.22 408.35,109.22 407.67,108.54 407.67,102.03 394.7,89.06 394.7,65.39 389.7,60.39 389.7,48.57 388.87,47.75 384.38,47.75 383.5,46.87 376.28,46.87 372.94,50.21 v1(372.94,50.67)
  SIG9 w0.155: v1(372.94,50.67) 372.58,50.67 371.58,51.67 370.85,51.67 YJ36.B12
  BOTTOM w0.13: v1(426.15,109.75) v2(427.55,109.75)
ZQSFP+_SDA_63: length 124.2
  TOP w0.13: v1(426.15,111.99) 425.64,111.48 422.75,111.48 422.62,111.61 R427.2 422.3,112.01 421.16,110.86 U18.19
  SIG3 w0.155: v1(426.15,111.99) 426.63,112.46 426.63,113.44 426.4,113.66 422.56,113.66 417.03,108.13 417.03,83.44 415.73,82.14 415.73,81.02 403.28,68.56 395.9,68.56 391.87,64.53 391.87,63.14 389.7,60.97 389.7,55.5 388.81,54.61 387.16,54.61 384.12,51.57 384.12,49.5 383.09,48.48 374.11,48.48 v1(371.67,50.92)
  SIG10 w0.155: v1(371.67,50.92) 371.67,52.44 371.16,52.95 371.16,53.34 371.54,53.72 371.54,56.57 371.16,56.95 371.16,57.31 371.41,57.56 371.41,58.14 370.1,59.46 YJ36.A12
  BOTTOM w0.13: v1(426.15,111.99) v2(427.55,111.99)
N00477: length 4.9
  TOP w0.178: U140.36 380.39,169.46 380.91,169.97 380.91,170.61
  TOP w0.254: 380.91,170.61 C3938.1 380.91,172.18 380.94,172.21 R3655.2 R3657.2
N01461: length 6.5
  TOP w0.178: U140.34 380.86,168.66 382.08,169.87 382.08,170.43
  TOP w0.254: R3661.2 R3662.2 383.35,171.8 383.35,171.29 C3939.1 382.44,170.79 382.08,170.43
N01835: length 5.7
  TOP w0.178: C3941.1 382.23,168.63 381.46,167.86 U140.32
  TOP w0.254: C3941.1 383.12,168.91 R3667.2 R3666.2
N01986: length 5.5
  TOP w0.178: 381.87,167.06 U140.30
  TOP w0.254: 381.87,167.06 382.38,166.55 C3944.1 383.78,166.55 383.86,166.62 R3668.2 R3669.2
N02139: length 6.6
  TOP w0.178: 381.98,165.4 381.12,166.26 U140.28
  TOP w0.254: 381.98,165.4 381.98,164.69 382.38,164.28 C3946.1 383.17,164.28 383.6,164.72 R3671.2 R3672.2
N04017: length 7.9
  TOP w0.13: U140.13 374.48,164.36 373.09,162.96 C3937.1 R3649.1 371.41,162.38 371.16,162.13 371.16,160.65 371.67,160.14 R3652.1
N04101: length 7.3
  TOP w0.13: R3653.1 R3650.1 373.95,159.89 373.6,160.25 373.6,162.18 373.8,162.38 C3936.2 374.1,163.22 374.56,163.68 375.12,163.68 375.45,164.01 U140.14
N05390: length 7
  TOP w0.203: R3665.2 R3664.2 380.25,160.14 380.25,162.12 379.96,162.41 C3940.1 379.67,162.68 378.65,163.7 U140.22
N5081897: length 43.6
  TOP w0.13: U1.AB51 v1(179.55,127.34) ; v1(166.43,99.69) 166.05,99.69 165.8,99.95 165.8,101.19 166.05,101.45 R8.1
  SIG7 w0.155: v1(179.55,127.34) 179.01,126.8 179.01,124.08 178.75,123.82 172.4,123.82 172.05,123.47 172.05,106.07 170.24,104.26 166.94,104.26 165.8,103.12 165.8,100.07 166.18,99.69 v1(166.43,99.69)
  BOTTOM w0.13: v1(166.43,99.69) v2(166.43,100.45)
N5081901: length 34.5
  TOP w0.13: U1.BH51 v1(179.55,154.34) ; v1(160.34,166.49) 159.68,167.15 R5.1
  SIG8 w0.155: v1(179.55,154.34) 179.01,154.88 179.01,166.75 178.88,166.88 163.13,166.88 162.75,166.49 v1(160.34,166.49)
  BOTTOM w0.13: v1(160.34,166.49) v2(160.34,167.26)
N5081913: length 63.9
  TOP w0.13: U1.BH16 v1(215.55,154.34) ; R11.1 230.47,191.92 v1(230.44,191.89)
  SIG8 w0.155: v1(215.55,154.34) 215.08,154.81 208.47,154.81 208.09,155.19 208.09,168.53 208.34,168.78 208.72,168.78 209.11,169.16 209.11,181.23 214.45,186.57 227.28,186.57 229.68,188.97 229.68,191.13 v1(230.44,191.89)
  BOTTOM w0.13: v1(230.44,191.89) v2(229.68,191.89)
N5081917: length 45.8
  TOP w0.13: v1(229.43,97.15) 229.5,97.08 R10.1 ; U1.AD16 v1(215.55,129.34)
  SIG7 w0.155: v1(215.55,129.34) 215.99,128.9 215.99,124.2 216.37,123.82 222.69,123.82 223.05,123.47 223.05,119.12 223.33,118.84 225.74,118.84 226.05,118.54 226.05,105.36 230.19,101.22 230.19,97.91 v1(229.43,97.15)
  BOTTOM w0.13: v2(230.19,97.15) v1(229.43,97.15)
N5100206: length 53.6
  TOP w0.13: R1.1 v1(229.43,101.22) ; U1.Y34 v1(196.55,125.34)
  SIG7 w0.155: v1(229.43,101.22) 228.69,101.95 228.34,101.95 225.06,105.24 225.06,117.52 224.73,117.85 222.26,117.85 222.01,118.11 222.01,120.7 221.81,120.9 217.23,120.9 216.98,121.16 216.98,121.64 216.82,121.79 216.34,121.79 215.84,122.3 215.84,122.93 213.93,124.84 197.05,124.84 v1(196.55,125.34)
N5113286: length 2.9
  TOP w0.13: U116.7 257.87,172.59 259.27,171.19 R6.2
N5113366: length 3.7
  TOP w0.13: U116.1 259.14,179.51 259.72,180.08 R12.2 R2.2
N5113378: length 3.5
  TOP w0.13: R4.2 R14.2 U116.3
N5113382: length 3.6
  TOP w0.13: R3.2 R13.2 257.62,179.83 257.87,179.58 U116.2
N5117511: length 39.6
  TOP w0.107: v1(246.24,137.49) 246.56,137.49 247.09,138.02 249.42,138.02 249.52,138.12 C9.2 ; U1.AM15 v1(216.54,137.35)
  SIG7 w0.102: 231.2,139.25 231.18,139.25 231.11,139.19 230.31,139.19 229.91,138.78 229.2,138.78 228.79,139.19 228.16,139.19 227.77,138.81 227.39,138.81 226.63,139.57 218.76,139.57 217.93,138.74 217.93,137.09 217.79,136.95 216.32,136.95 216.14,137.13 216.14,137.27 216.22,137.35 v1(216.54,137.35)
  SIG7 w0.14: v1(246.24,137.49) 246.24,137.2 245.94,136.9 245.3,136.9 244.47,137.74 236.17,137.74 234.65,139.25 231.2,139.25
N5117515: length 40
  TOP w0.107: v1(246.88,136.85) 246.88,137.34 247.23,137.69 249.42,137.69 249.52,137.59 C10.2 ; U1.AM16 v1(215.54,137.35)
  SIG7 w0.102: v1(215.54,137.35) 215.86,137.35 215.95,137.26 215.95,137.05 216.24,136.76 217.87,136.76 218.13,137.01 218.13,138.66 218.84,139.37 226.55,139.37 227.31,138.61 227.86,138.61 228.24,138.99 228.71,138.99 229.12,138.59 229.99,138.59 230.4,138.99 231.11,138.99 231.18,138.93 231.2,138.93
  SIG7 w0.14: 231.2,138.93 234.51,138.93 236.03,137.41 244.33,137.41 245.16,136.57 246.07,136.57 246.34,136.84 246.47,136.84 246.47,136.85 v1(246.88,136.85)
N5121590: length 26.4
  TOP w0.107: U1.AP51 v1(179.55,140.34) ; v1(159.15,141.7) 158.99,141.86 158.99,142.19 158.56,142.62 157,142.62 156.77,142.39 156.22,142.39 C2844.2
  SIG9 w0.102: v1(179.55,140.34) 179.13,140.34 179.02,140.45 179.02,140.71 178.78,140.95 163.24,140.95 163.19,141
  SIG9 w0.14: v1(159.15,141.7) 158.86,141.42 158.86,141.2 159.06,141 163.19,141
N5121594: length 26.4
  TOP w0.107: U1.AP52 v1(178.55,140.34) ; C2807.2 155.99,141.83 156.22,142.06 156.91,142.06 157.13,142.29 158.42,142.29 158.66,142.05 158.66,141.81 158.56,141.7 v1(158.23,141.7)
  SIG9 w0.102: 163.19,140.67 163.26,140.75 178.7,140.75 178.82,140.63 178.82,140.43 178.74,140.34 v1(178.55,140.34)
  SIG9 w0.14: v1(158.23,141.7) 158.53,141.4 158.53,141.06 158.92,140.67 163.19,140.67
N5121846: length 49.5
  TOP w0.107: v4(200.55,156.29) 200.1,155.84 U1.BK31 ; v1(181.5,189.76) 181.2,190.05 181.2,190.31 C2854.2
  SIG2 w0.102: 194.18,173.61 194.18,173.58 194.11,173.51 194.11,168.02 193.83,167.74 193.35,167.74 193.16,167.54 193.16,160.17 193.39,159.93 194.8,159.93 195.14,159.59 195.14,158.13 195.33,157.95 196.85,157.95 197.56,157.24 197.56,156.35 197.97,155.94 200,155.94 200.15,155.79 200.43,155.79 200.55,155.9 v4(200.55,156.29)
  SIG2 w0.14: 194.18,173.61 194.18,177.32 183.33,188.16 181.85,188.16 181.2,188.81 181.2,189.47 v1(181.5,189.76)
N5121850: length 49.6
  TOP w0.107: v1(180.58,189.76) 180.87,190.05 180.87,190.31 C2892.2 ; v4(200.55,155.39) 200.05,154.89 U1.BJ31
  SIG2 w0.102: v4(200.55,155.39) 200.35,155.59 200.07,155.59 199.92,155.74 197.89,155.74 197.36,156.27 197.36,157.16 196.77,157.75 195.25,157.75 194.95,158.05 194.95,159.51 194.72,159.74 193.31,159.74 192.96,160.09 192.96,167.62 193.27,167.93 193.75,167.93 193.92,168.1 193.92,173.51 193.85,173.58 193.85,173.61
  SIG2 w0.14: v1(180.58,189.76) 180.87,189.47 180.87,188.67 181.71,187.83 183.2,187.83 193.85,177.18 193.85,173.61
N5126296: length 30.4
  TOP w0.107: U1.BD51 v1(179.55,150.34) ; C2928.2 156.22,153.39 156.39,153.39 156.57,153.21 158.04,153.21 158.48,153.66 158.48,153.93 v1(158.65,154.1)
  SIG9 w0.102: v1(179.55,150.34) 179.34,150.34 179.06,150.62 179.06,151.08 178.15,151.98 178.15,154.65 177.86,154.94 163.22,154.94 163.16,155.01 163.13,155.01
  SIG9 w0.14: v1(158.65,154.1) 158.33,153.78 158.33,153.63 158.57,153.39 160.61,153.39 162.23,155.01 163.13,155.01
N5126300: length 30.4
  TOP w0.107: U1.BD52 v1(178.55,150.34) ; v1(157.73,154.1) 158.03,154.1 158.15,153.97 158.15,153.79 157.9,153.54 156.71,153.54 156.53,153.72 156.12,153.72 155.99,153.85 C2721.2
  SIG9 w0.102: 163.13,154.68 163.16,154.68 163.22,154.75 177.77,154.75 177.96,154.57 177.96,151.9 178.86,150.99 178.86,150.65 v1(178.55,150.34)
  SIG9 w0.14: v1(157.73,154.1) 158,153.83 158,153.49 158.43,153.06 160.74,153.06 162.37,154.68 163.13,154.68
N5126304: length 42.6
  TOP w0.107: v1(247.75,140.02) 247.75,140.23 248.09,140.58 248.09,141.73 247.5,142.33 247.5,142.68 C19.2 ; U1.AH16 v1(215.55,133.34)
  SIG9 w0.102: v1(215.55,133.34) 215.55,133.82 215.71,133.98 215.92,133.98 216.16,134.21 216.16,135.57 216.32,135.74 217.79,135.74 218.12,136.06 218.12,138.65 218.46,138.99 226.8,138.99 227.06,138.74 227.98,138.74 228.11,138.87 228.96,138.87 229.09,138.74 230.12,138.74 230.5,139.12 231.06,139.12 231.13,139.05 231.15,139.05
  SIG9 w0.14: 231.15,139.05 233.61,139.05 234.81,140.26 245.5,140.26 245.94,139.82 246.94,139.82 247.24,140.13 247.64,140.13 v1(247.75,140.02)
N5126308: length 28.9
  TOP w0.107: U1.AF51 v1(179.55,131.34) ; C18.2 156.22,129.05 158.24,129.05 158.66,128.63 158.66,128.2 v1(158.84,128.01)
  SIG9 w0.102: v1(179.55,131.34) 179.21,131.34 179.15,131.28 179.15,131 178.89,130.74 169.17,130.74 168.95,130.96 168.95,131.57 168.78,131.74 164.04,131.74 163.53,131.23 163.53,131.14 163.51,131.12
  SIG9 w0.14: v1(158.84,128.01) 158.43,128.42 158.43,128.83 158.77,129.16 161.56,129.16 161.74,129.35 161.83,129.44 162.58,130.19 163.51,131.12
N5126312: length 28.9
  TOP w0.107: C17.2 155.99,128.6 156.12,128.72 158.1,128.72 158.33,128.5 158.33,128.14 158.2,128.01 v1(157.93,128.01) ; U1.AF52 v1(178.55,131.34)
  SIG9 w0.102: v1(178.55,131.34) 178.85,131.34 178.96,131.24 178.96,131.09 178.81,130.94 169.25,130.94 169.15,131.04 169.15,131.65 168.86,131.94 163.96,131.94 163.39,131.37 163.29,131.37 163.28,131.35
  SIG9 w0.14: v1(157.93,128.01) 158.1,128.19 158.1,128.96 158.63,129.49 161.42,129.49 163.28,131.35
N5126316: length 37.2
  TOP w0.107: U1.BD16 v1(215.55,150.34) ; v1(245.05,150.64) 245.21,150.81 245.86,150.81 246.38,151.33 246.38,152.59 246.47,152.68 C3142.2
  SIG5 w0.102: 232.08,151.14 232.06,151.14 231.99,151.2 231.53,151.2 231.08,150.75 226.38,150.75 226.14,150.51 226.14,149.14 225.74,148.75 216.18,148.75 215.95,148.98 215.95,149.64 216.14,149.83 216.14,150.14 215.94,150.34 v1(215.55,150.34)
  SIG5 w0.14: 232.08,151.14 244.71,151.14 245.05,150.8 v1(245.05,150.64)
N5126320: length 36.1
  TOP w0.107: U1.BD15 v1(216.55,150.34) ; C3108.2 245.91,152.68 246.05,152.53 246.05,151.47 245.72,151.14 245.17,151.14 245.05,151.26 v1(245.05,151.55)
  SIG5 w0.102: v1(216.55,150.34) 216.34,150.13 216.34,149.75 216.15,149.56 216.15,149.06 216.27,148.95 225.66,148.95 225.94,149.23 225.94,150.59 226.3,150.94 230.99,150.94 231.45,151.4 231.99,151.4 232.06,151.47 232.08,151.47
  SIG5 w0.14: v1(245.05,151.55) 244.96,151.47 232.08,151.47
N5126324: length 41.7
  TOP w0.107: v1(247.1,140.67) 247.28,140.48 247.54,140.48 247.76,140.71 247.76,141.59 247.17,142.19 247.17,142.68 C20.2 ; U1.AJ16 v1(215.55,134.34)
  SIG9 w0.102: v1(215.55,134.34) 215.71,134.18 215.84,134.18 215.96,134.3 215.96,135.65 216.24,135.93 217.71,135.93 217.92,136.14 217.92,138.73 218.38,139.19 226.89,139.19 227.14,138.94 227.9,138.94 228.03,139.06 229.04,139.06 229.17,138.94 230.04,138.94 230.42,139.32 231.06,139.32 231.13,139.38 231.15,139.38
  SIG9 w0.14: 231.15,139.38 233.47,139.38 234.67,140.59 245.64,140.59 246.07,140.15 246.8,140.15 247.1,140.46 v1(247.1,140.67)
N6023779: length 45.9
  TOP w0.107: C6.2 178.35,190.42 178.35,190.14 177.96,189.76 v1(177.83,189.76) ; U1.BN34 196.97,158.84 v4(196.55,159.27)
  SIG2 w0.102: v4(196.55,159.27) 196.47,159.19 196.32,159.19 196.14,159.37 196.14,173.1 196.21,173.17 196.21,173.19
  SIG2 w0.14: v1(177.83,189.76) 177.97,189.9 177.97,190.46 178.63,191.13 183.16,191.13 196.21,178.08 196.21,173.19
N6023783: length 45.9
  TOP w0.107: v4(196.55,158.37) 197.05,157.87 U1.BM34 ; C5.2 178.83,190.65 178.68,190.5 178.68,189.82 v1(178.74,189.76)
  SIG2 w0.102: 195.88,173.19 195.88,173.17 195.94,173.1 195.94,159.28 196.55,158.68 v4(196.55,158.37)
  SIG2 w0.14: v1(178.74,189.76) 178.45,189.76 178.3,189.91 178.3,190.33 178.77,190.8 183.02,190.8 185.72,188.1 195.77,178.05 195.88,177.95 195.88,173.19
