# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC21_RDP2: length 97.6
  TOP w0.147: v4(175.55,123.29) 175.55,123.34 U1.V55
  SIG8 w0.112: 163.26,122.04 163.28,122.04 163.38,121.95 174.82,121.95 arc(174.89,121.98) 174.92,122.05 174.92,122.64 arc(175.01,122.85) 175.22,122.94 175.45,122.94 arc(175.52,122.97) 175.55,123.04 v4(175.55,123.29)
  SIG8 w0.16: YJ26.A15 132.7,60.68 arc(132.65,60.96) 132.51,61.21 arc(132.5,61.22) 132.49,61.24 arc(132.49,61.24) 132.49,61.24 arc(132.47,61.27) 132.45,61.29 132.33,61.41 132.09,61.65 arc(131.96,61.84) 131.91,62.07 131.91,62.48 arc(131.91,62.54) 131.89,62.6 arc(131.89,62.61) 131.89,62.61 arc(131.89,62.62) 131.88,62.62 arc(131.88,62.63) 131.88,62.64 arc(131.84,62.71) 131.79,62.77 131.75,62.82 131.66,62.9 arc(131.54,62.98) 131.39,63.01 129.82,63.01 arc(129.38,63.1) 129.01,63.35 128.59,63.77 arc(128.41,64.01) 128.29,64.28 arc(128.26,64.33) 128.25,64.39 128.25,65.87 arc(128.34,66.31) 128.59,66.68 129.72,67.81 arc(129.8,67.93) 129.83,68.08 129.83,75.6 arc(129.89,75.89) 130.06,76.14 131.17,77.26 arc(131.34,77.5) 131.39,77.79 131.39,84.48 arc(131.48,84.92) 131.73,85.29 134.62,88.18 arc(134.99,88.43) 135.43,88.52 137.16,88.52 arc(137.45,88.57) 137.7,88.74 139.79,90.83 arc(139.96,91.08) 140.02,91.37 140.02,93.31 arc(140.08,93.6) 140.24,93.85 148.35,101.96 arc(148.52,102.21) 148.58,102.5 148.58,112.69 arc(148.66,113.12) 148.91,113.49 155.27,119.86 arc(155.64,120.1) 156.08,120.19 158.78,120.19 arc(159.07,120.25) 159.32,120.41 160.72,121.82 arc(160.97,121.98) 161.26,122.04 163.26,122.04
FC21_RDP3: length 84.5
  TOP w0.147: U1.U59 171.95,122.84 arc(171.86,122.82) 171.78,122.77 171.65,122.64 arc(171.58,122.53) v4(171.55,122.39)
  SIG9 w0.112: v4(171.55,122.39) 171.55,122.62 arc(171.54,122.66) 171.52,122.69 171.49,122.71 arc(171.46,122.74) 171.42,122.74 171.25,122.74 arc(171.18,122.71) 171.15,122.64 171.15,122.16 arc(171.12,122) 171.03,121.86 arc(170.89,121.77) 170.73,121.74 163.21,121.74 arc(163.15,121.73) 163.1,121.69 163.07,121.67 arc(163.05,121.65) 163.03,121.65
  SIG9 w0.16: YJ26.A22 131.25,65.97 arc(131.36,66.14) 131.4,66.34 131.4,66.54 arc(131.31,66.77) 131.09,66.86 130.16,66.86 arc(129.86,66.92) 129.62,67.08 129.44,67.26 arc(129.39,67.34) 129.37,67.43 129.37,67.62 arc(129.41,67.8) 129.51,67.95 129.79,68.23 130.12,68.23 130.46,68.57 130.46,68.9 130.77,69.21 131.1,69.21 131.46,69.57 131.46,69.9 131.64,70.09 arc(131.89,70.46) 131.98,70.9 131.98,71.41 132.21,71.63 132.21,72.19 131.98,72.42 131.98,74.45 arc(132.01,74.59) 132.09,74.72 133.62,76.24 arc(133.78,76.49) 133.84,76.78 133.84,77.98 134.07,78.2 134.07,78.76 133.84,78.99 133.84,82.4 arc(133.9,82.69) 134.06,82.94 134.97,83.85 arc(135.22,84.01) 135.51,84.07 136.3,84.07 arc(136.6,84.13) 136.84,84.29 139.83,87.28 arc(140.07,87.44) 140.36,87.5 141.99,87.5 arc(142.28,87.56) 142.53,87.72 143.48,88.67 arc(143.64,88.92) 143.7,89.21 143.7,93.41 arc(143.76,93.7) 143.92,93.95 153,103.03 arc(153.17,103.27) 153.23,103.56 153.23,111.09 arc(153.28,111.38) 153.45,111.63 162.02,120.2 arc(162.18,120.44) 162.24,120.73 162.24,121.02 arc(162.28,121.22) 162.37,121.4 arc(162.4,121.43) 162.43,121.47 162.46,121.5 arc(162.62,121.61) 162.82,121.65 163.03,121.65
FC21_TDN0: length 97.3
  TOP w0.147: v4(165.55,123.29) 165.55,123.34 U1.V65
  SIG7 w0.112: 163.15,122.09 163.18,122.09 163.27,122 164.71,122 arc(164.78,122.01) 164.85,122.06 164.86,122.08 arc(164.91,122.14) 164.92,122.21 164.92,122.62 arc(165.02,122.85) 165.25,122.94 165.38,122.94 arc(165.5,122.99) 165.55,123.1 v4(165.55,123.29)
  SIG7 w0.16: 163.15,122.09 161.34,122.09 arc(161.04,122.03) 160.8,121.87 159.23,120.3 arc(159.11,120.22) 158.96,120.19 155.85,120.19 arc(155.56,120.13) 155.31,119.97 148.8,113.46 arc(148.64,113.21) 148.58,112.92 148.58,102.35 arc(148.55,102.2) 148.47,102.08 140.24,93.85 arc(140.08,93.6) 140.02,93.31 140.02,75.79 arc(139.94,75.39) 139.71,75.05 133.68,69.02 arc(133.19,68.69) 132.61,68.58 131.03,68.58 arc(130.74,68.52) 130.49,68.35 128.56,66.43 arc(128.4,66.18) 128.34,65.89 128.34,64.36 arc(128.4,64.07) 128.56,63.82 129.15,63.24 arc(129.4,63.07) 129.69,63.01 140.99,63.01 arc(141.14,62.98) 141.26,62.9 141.35,62.82 141.39,62.77 arc(141.45,62.69) 141.49,62.6 arc(141.49,62.59) 141.5,62.58 arc(141.51,62.53) 141.51,62.48 141.51,62.16 arc(141.57,61.85) 141.75,61.58 142.06,61.27 arc(142.24,61.01) 142.3,60.7 YJ26.A3
FC21_TDN1: length 97.2
  TOP w0.147: U1.U63 168,122.84 arc(167.68,122.71) v4(167.55,122.39)
  SIG6 w0.112: 163.12,123.65 163.14,123.65 163.23,123.74 166.74,123.74 arc(166.79,123.73) 166.83,123.7 166.89,123.65 arc(166.91,123.61) 166.92,123.56 166.92,123.07 arc(167.02,122.84) 167.25,122.74 167.42,122.74 arc(167.51,122.71) 167.55,122.62 v4(167.55,122.39)
  SIG6 w0.16: 163.12,123.65 162.33,123.65 arc(162.18,123.62) 162.06,123.54 160,121.47 arc(159.91,121.35) 159.88,121.2 159.88,118.71 arc(159.83,118.41) 159.66,118.17 153.45,111.96 arc(153.28,111.71) 153.23,111.42 153.23,106.74 arc(153.14,106.3) 152.89,105.93 140.51,93.55 arc(140.43,93.43) 140.4,93.28 140.4,74.13 arc(140.31,73.69) 140.06,73.32 136.54,69.8 arc(136.17,69.55) 135.73,69.47 134.76,69.47 134.51,69.22 134.08,69.22 133.83,69.47 133.35,69.47 133.11,69.22 132.68,69.22 132.43,69.47 131.95,69.47 arc(131.81,69.44) 131.68,69.35 131.06,68.74 131.06,68.42 130.72,68.08 130.41,68.08 130.07,67.75 130.07,67.43 129.73,67.09 129.42,67.09 128.83,66.51 arc(128.75,66.38) 128.72,66.24 128.72,64.69 arc(128.78,64.4) 128.94,64.15 129.48,63.62 arc(129.73,63.45) 130.02,63.39 138.59,63.39 arc(138.88,63.34) 139.13,63.17 139.22,63.08 arc(139.46,62.92) 139.76,62.86 140.66,62.86 arc(140.9,62.76) 141,62.52 141,62.34 arc(140.96,62.14) 140.85,61.97 YJ26.A5
FC21_TDN2: length 75.3
  TOP w0.147: v4(169.55,123.29) 169.55,123.34 U1.V61
  SIG6 w0.112: 163.24,122.04 163.27,122.04 163.36,121.95 168.74,121.95 arc(168.79,121.96) 168.83,121.99 168.89,122.04 arc(168.91,122.08) 168.92,122.13 168.92,122.62 arc(169.02,122.85) 169.25,122.94 169.42,122.94 arc(169.51,122.98) 169.55,123.07 v4(169.55,123.29)
  SIG6 w0.16: YJ26.A36 142.3,64.9 arc(142.27,65.02) 142.2,65.13 142.04,65.3 141.75,65.58 arc(141.57,65.85) 141.51,66.16 141.51,71.89 arc(141.6,72.33) 141.85,72.7 143.21,74.06 arc(143.29,74.18) 143.32,74.33 143.32,93.57 arc(143.38,93.86) 143.54,94.1 156.05,106.61 arc(156.22,106.86) 156.27,107.15 156.27,111.77 arc(156.33,112.06) 156.5,112.31 161.51,117.33 arc(161.68,117.57) 161.73,117.86 161.73,121.02 arc(161.79,121.31) 161.96,121.56 162.21,121.82 arc(162.25,121.85) 162.28,121.88 arc(162.5,122) 162.75,122.04 163.24,122.04
FC21_TDN3: length 70.8
  TOP w0.147: U1.R66 164.99,120.84 arc(164.68,120.71) v4(164.55,120.4)
  SIG7 w0.112: 163.15,119.56 163.18,119.56 163.27,119.65 163.7,119.65 arc(163.99,119.77) 164.11,120.06 164.11,120.62 arc(164.15,120.71) 164.24,120.74 164.42,120.74 arc(164.51,120.71) 164.55,120.62 v4(164.55,120.4)
  SIG7 w0.16: YJ26.A34 140.85,65.97 arc(140.96,66.14) 141,66.34 141,66.52 arc(140.9,66.76) 140.66,66.86 139.76,66.86 arc(139.46,66.92) 139.22,67.08 138.99,67.31 arc(138.7,67.74) 138.6,68.24 138.6,68.4 arc(138.66,68.77) 138.81,69.11 arc(138.89,69.22) 138.99,69.32 139.45,69.79 139.63,69.79 140.01,70.17 140.01,70.35 140.34,70.68 140.52,70.68 140.9,71.06 140.9,71.23 141.22,71.56 141.4,71.56 141.78,71.94 141.78,72.12 142.11,72.45 142.31,72.45 142.67,72.8 142.67,73.01 143.19,73.53 arc(143.57,74.09) 143.7,74.76 143.7,75.25 143.9,75.45 143.9,75.92 143.7,76.12 143.7,76.59 143.9,76.79 143.9,77.26 143.7,77.46 143.7,93.57 arc(143.73,93.71) 143.81,93.84 153,103.03 arc(153.17,103.27) 153.23,103.56 153.23,111.6 arc(153.25,111.75) 153.34,111.87 159.08,117.61 arc(159.21,117.7) 159.35,117.73 159.97,117.73 arc(160.41,117.81) 160.78,118.06 162.16,119.45 arc(162.29,119.53) 162.43,119.56 163.15,119.56
FC21_TDP0: length 97.3
  TOP w0.147: U1.U65 166,122.84 arc(165.68,122.71) v4(165.55,122.39)
  SIG7 w0.112: 163.15,121.71 163.18,121.71 163.27,121.8 164.71,121.8 arc(164.86,121.83) 164.98,121.92 165,121.94 arc(165.09,122.06) 165.12,122.21 165.12,122.62 arc(165.16,122.71) 165.25,122.74 165.38,122.74 arc(165.5,122.7) 165.55,122.58 v4(165.55,122.39)
  SIG7 w0.16: 163.15,121.71 161.34,121.71 arc(161.19,121.68) 161.07,121.6 159.5,120.03 arc(159.25,119.87) 158.96,119.81 155.85,119.81 arc(155.7,119.78) 155.58,119.7 149.07,113.19 arc(148.99,113.07) 148.96,112.92 148.96,102.35 arc(148.9,102.05) 148.74,101.81 140.51,93.58 arc(140.43,93.46) 140.4,93.31 140.4,75.79 arc(140.29,75.25) 139.98,74.78 139.44,74.25 139.44,74.05 139.06,73.67 138.87,73.67 138.54,73.34 138.54,73.14 138.16,72.76 137.96,72.76 137.63,72.44 137.63,72.24 137.25,71.86 137.06,71.86 136.73,71.53 136.73,71.31 136.37,70.95 136.15,70.95 135.82,70.62 135.82,70.38 135.49,70.05 135.25,70.05 134.92,69.72 134.92,69.47 134.59,69.14 134.34,69.14 133.95,68.75 arc(133.33,68.34) 132.61,68.2 131.03,68.2 arc(130.89,68.17) 130.76,68.08 128.83,66.16 arc(128.75,66.03) 128.72,65.89 128.72,64.36 arc(128.75,64.21) 128.83,64.09 129.42,63.51 arc(129.54,63.42) 129.69,63.39 140.99,63.39 arc(141.28,63.34) 141.53,63.17 arc(141.87,62.94) 142.28,62.86 143.06,62.86 arc(143.3,62.76) 143.4,62.52 143.4,62.34 arc(143.36,62.14) 143.25,61.97 YJ26.A2
FC21_TDP1: length 97.2
  TOP w0.147: v4(167.55,123.29) 167.55,123.34 U1.V63
  SIG6 w0.112: 163.12,124.03 163.14,124.03 163.23,123.94 166.74,123.94 arc(166.87,123.91) 166.97,123.84 167.02,123.79 arc(167.09,123.69) 167.12,123.56 167.12,123.07 arc(167.16,122.98) 167.25,122.94 167.42,122.94 arc(167.51,122.98) 167.55,123.07 v4(167.55,123.29)
  SIG6 w0.16: 163.12,124.03 162.33,124.03 arc(162.04,123.97) 161.79,123.81 159.73,121.74 arc(159.56,121.5) 159.5,121.2 159.5,118.71 arc(159.47,118.56) 159.39,118.44 153.18,112.22 arc(152.93,111.85) 152.84,111.42 152.84,106.74 arc(152.79,106.45) 152.62,106.2 140.24,93.82 arc(140.08,93.57) 140.02,93.28 140.02,74.13 arc(139.96,73.84) 139.79,73.59 136.27,70.07 arc(136.03,69.91) 135.73,69.85 131.95,69.85 arc(131.66,69.79) 131.41,69.62 128.56,66.78 arc(128.4,66.53) 128.34,66.24 128.34,64.69 arc(128.43,64.25) 128.68,63.88 129.21,63.35 arc(129.58,63.1) 130.02,63.01 138.59,63.01 arc(138.74,62.98) 138.86,62.9 138.95,62.82 138.99,62.77 arc(139.06,62.69) 139.1,62.58 arc(139.11,62.53) 139.11,62.48 139.11,62.16 arc(139.17,61.85) 139.35,61.58 139.74,61.19 arc(139.86,61.02) 139.9,60.81 YJ26.A6
FC21_TDP2: length 75.3
  TOP w0.147: U1.U61 170,122.84 arc(169.68,122.71) v4(169.55,122.39)
  SIG6 w0.112: v4(169.55,122.39) 169.55,122.61 arc(169.54,122.66) 169.51,122.7 169.5,122.71 arc(169.46,122.73) 169.41,122.74 169.25,122.74 arc(169.16,122.71) 169.12,122.62 169.12,122.13 arc(169.09,122) 169.02,121.9 168.97,121.85 arc(168.87,121.78) 168.74,121.75 163.36,121.75 163.27,121.66 163.24,121.66
  SIG6 w0.16: YJ26.A37 143.25,65.97 arc(143.36,66.14) 143.4,66.34 143.4,66.52 arc(143.3,66.76) 143.06,66.86 142.31,66.86 arc(142.15,66.89) 142.01,66.98 arc(141.92,67.12) 141.89,67.28 141.89,67.76 142.14,68 142.14,68.43 141.89,68.68 141.89,69.16 142.14,69.41 142.14,69.83 141.89,70.08 141.89,71.89 arc(141.95,72.18) 142.11,72.43 142.45,72.77 142.79,72.77 143.11,73.08 143.11,73.42 143.48,73.79 arc(143.64,74.04) 143.7,74.33 143.7,74.81 143.95,75.06 143.95,75.48 143.7,75.73 143.7,76.21 143.92,76.43 143.92,76.91 143.7,77.13 143.7,93.57 arc(143.73,93.71) 143.81,93.84 156.32,106.34 arc(156.57,106.71) 156.65,107.15 156.65,111.77 arc(156.68,111.92) 156.77,112.04 161.78,117.06 arc(162.03,117.43) 162.12,117.86 162.12,121.02 arc(162.14,121.17) 162.23,121.29 162.48,121.55 arc(162.5,121.56) 162.52,121.58 arc(162.63,121.64) 162.75,121.66 163.24,121.66
FC21_TDP3: length 70.8
  TOP w0.147: v4(164.55,121.29) 164.55,121.34 U1.T66
  SIG7 w0.112: v4(164.55,121.29) 164.55,121.07 arc(164.55,121.05) 164.54,121.02 arc(164.49,120.96) 164.42,120.94 164.24,120.94 arc(164.01,120.85) 163.92,120.62 163.92,120.06 arc(163.85,119.91) 163.7,119.85 163.27,119.85 163.18,119.94 163.15,119.94
  SIG7 w0.16: 163.15,119.94 162.43,119.94 arc(162.14,119.88) 161.9,119.72 160.51,118.33 arc(160.26,118.17) 159.97,118.11 159.35,118.11 arc(159.06,118.05) 158.81,117.88 153.07,112.14 arc(152.9,111.89) 152.84,111.6 152.84,103.56 arc(152.82,103.42) 152.73,103.29 143.54,94.1 arc(143.38,93.86) 143.32,93.57 143.32,74.76 arc(143.22,74.24) 142.92,73.8 138.86,69.74 138.72,69.59 arc(138.6,69.46) 138.49,69.32 arc(138.29,68.88) 138.22,68.4 138.22,68.24 arc(138.35,67.59) 138.72,67.04 138.95,66.82 138.99,66.77 arc(139.06,66.68) 139.1,66.57 arc(139.11,66.52) 139.11,66.48 139.11,66.16 arc(139.17,65.85) 139.35,65.58 139.74,65.19 arc(139.86,65.02) 139.9,64.81 YJ26.A33
FC22_23_PVDD0P8: length 5.6
  TOP w0.229: U1.AB49 v1(181.55,127.34) ; U1.AD49 v1(181.55,129.34)
  TOP w0.381: C2898.1 157.16,120.65 ; C2898.1 157.76,119.86 ; C2898.1 156.57,119.86
  BOTTOM w0.13: v1(157.67,121.03) v2(157.67,121.79)
  BOTTOM w0.381: C2852.1 182.03,129.82 v1(181.55,129.34) ; C3345.1 181.06,127.83 v1(181.55,127.34)
  vias: v1(156.65,121.03)
FC22_RDN0: length 86.8
  TOP w0.147: v4(176.55,120.29) 176.55,120.34 U1.R54
  SIG2 w0.112: v4(176.55,120.29) 176.55,120.07 arc(176.51,119.98) 176.42,119.94 176.25,119.94 arc(176.02,119.85) 175.92,119.62 175.92,118.16 arc(175.91,118.11) 175.89,118.07 175.79,117.97 arc(175.75,117.95) 175.7,117.94 163.43,117.94 163.33,118.03 163.31,118.03
  SIG2 w0.16: YJ25.C14 139.75,61.97 arc(139.64,62.13) 139.61,62.32 139.61,62.55 arc(139.7,62.77) 139.91,62.86 140.78,62.86 arc(141.07,62.92) 141.31,63.08 141.36,63.13 141.41,63.18 arc(141.5,63.26) 141.6,63.32 arc(141.77,63.38) 141.95,63.41 144.18,63.41 arc(144.47,63.46) 144.72,63.63 145.38,64.29 arc(145.55,64.54) 145.61,64.83 145.61,70.29 arc(145.58,70.44) 145.49,70.56 143.65,72.4 arc(143.41,72.77) 143.32,73.21 143.32,93.38 arc(143.41,93.81) 143.65,94.19 156.16,106.69 arc(156.24,106.82) 156.27,106.96 156.27,111.7 arc(156.33,111.99) 156.5,112.23 156.78,112.52 162.07,117.81 arc(162.32,117.97) 162.61,118.03 163.31,118.03
FC22_RDN1: length 79.7
  TOP w0.147: U1.P58 173,119.84 arc(172.83,119.81) 172.68,119.71 172.61,119.64 arc(172.57,119.57) 172.55,119.48 v4(172.55,119.39)
  SIG3 w0.112: v4(172.55,119.39) 172.55,119.62 arc(172.51,119.71) 172.42,119.74 172.25,119.74 arc(172.16,119.71) 172.12,119.62 172.12,118.16 arc(172.09,118.03) 172.02,117.93 171.94,117.84 arc(171.83,117.77) 171.71,117.75 163.38,117.75 163.28,117.66 163.26,117.66
  SIG3 w0.16: 163.26,117.66 162.74,117.66 arc(162.45,117.6) 162.2,117.43 156.88,112.11 arc(156.71,111.86) 156.65,111.57 156.65,106.99 arc(156.6,106.7) 156.43,106.45 143.92,93.95 arc(143.76,93.7) 143.7,93.41 143.7,74.23 arc(143.76,73.94) 143.92,73.69 145.26,72.36 arc(145.42,72.11) 145.48,71.82 145.48,67.94 145.71,67.71 145.71,67.16 145.48,66.93 145.48,66.3 145.71,66.07 145.71,65.52 145.48,65.29 145.48,64.78 arc(145.39,64.34) 145.14,63.97 144.02,62.85 arc(143.94,62.72) 143.91,62.57 143.91,62.08 arc(143.86,61.86) 143.74,61.67 143.31,61.24 arc(143.15,61.01) 143.1,60.74 YJ25.C18
FC22_RDN2: length 81.2
  TOP w0.147: U1.R56 174.55,120.34 v4(174.55,120.29)
  SIG2 w0.112: 163.23,120.08 163.34,119.98 168.83,119.98 arc(169.06,119.88) 169.15,119.65 169.15,119.18 169.15,119.18 arc(169.16,119.13) 169.19,119.09 169.26,119.01 arc(169.3,118.99) 169.35,118.98 173.7,118.98 arc(173.75,118.99) 173.79,119.01 173.89,119.11 arc(173.91,119.15) 173.92,119.2 173.92,119.62 arc(174.02,119.85) 174.25,119.94 174.42,119.94 arc(174.51,119.98) 174.55,120.07 v4(174.55,120.29)
  SIG2 w0.16: 163.23,120.08 161.69,120.08 arc(161.26,120) 160.89,119.75 153.18,112.04 arc(152.93,111.67) 152.84,111.23 152.84,106.82 arc(152.79,106.52) 152.62,106.28 140.51,94.16 arc(140.34,93.92) 140.29,93.63 140.29,72.31 arc(140.34,72.02) 140.51,71.77 143.3,68.98 arc(143.47,68.73) 143.53,68.44 143.53,67.32 arc(143.49,67.15) 143.39,67 143.34,66.95 arc(143.25,66.88) 143.13,66.86 142.34,66.86 arc(142.1,66.77) 142.01,66.53 142.01,66.32 arc(142.04,66.13) 142.15,65.97 YJ25.C22
FC22_RDN3: length 75.5
  TOP w0.147: U1.P60 171,119.84 arc(170.83,119.81) 170.68,119.71 170.61,119.64 arc(170.57,119.57) 170.55,119.48 v4(170.55,119.39)
  SIG3 w0.112: 163.26,119.65 163.28,119.65 163.38,119.74 168.84,119.74 arc(169,119.77) 169.13,119.86 arc(169.13,119.87) 169.14,119.87 169.53,119.87 arc(170.03,119.77) 170.46,119.48 v4(170.55,119.39)
  SIG3 w0.16: 163.26,119.65 161.44,119.65 arc(161.14,119.59) 160.9,119.43 153.45,111.98 arc(153.28,111.73) 153.23,111.44 153.23,106.61 arc(153.17,106.32) 153,106.07 140.89,93.96 arc(140.72,93.71) 140.67,93.42 140.67,73.96 arc(140.72,73.67) 140.89,73.42 142.09,72.22 arc(142.26,71.97) 142.31,71.68 142.31,70.91 142.54,70.68 142.54,70.12 142.31,69.89 142.31,69.38 142.54,69.16 142.54,68.6 142.31,68.37 142.31,67.86 arc(142.26,67.57) 142.09,67.32 141.7,66.93 arc(141.56,66.72) 141.51,66.46 141.51,66.08 arc(141.46,65.86) 141.34,65.67 141.08,65.41 140.88,65.21 arc(140.75,65.02) 140.7,64.78 YJ25.C24
FC22_RDP0: length 86.8
  TOP w0.147: U1.P54 176.96,119.84 arc(176.86,119.82) 176.78,119.77 176.6,119.59 arc(176.56,119.53) 176.55,119.46 v4(176.55,119.39)
  SIG2 w0.112: v4(176.55,119.39) 176.55,119.62 arc(176.51,119.71) 176.42,119.74 176.25,119.74 arc(176.16,119.71) 176.12,119.62 176.12,118.16 arc(176.09,118.04) 176.02,117.93 175.93,117.84 arc(175.82,117.77) 175.7,117.74 163.43,117.74 163.33,117.65 163.31,117.65
  SIG2 w0.16: 163.31,117.65 162.61,117.65 arc(162.46,117.62) 162.34,117.54 156.77,111.97 arc(156.68,111.84) 156.65,111.7 156.65,106.96 arc(156.6,106.67) 156.43,106.42 143.92,93.92 arc(143.76,93.67) 143.7,93.38 143.7,73.21 arc(143.76,72.92) 143.92,72.67 145.76,70.83 arc(145.93,70.59) 145.99,70.29 145.99,69.4 146.22,69.17 146.22,68.61 145.99,68.39 145.99,67.88 146.22,67.65 146.22,67.09 145.99,66.86 145.99,64.83 arc(145.9,64.39) 145.65,64.02 144.99,63.36 arc(144.62,63.11) 144.18,63.03 141.95,63.03 arc(141.86,63.01) 141.78,62.98 arc(141.73,62.95) 141.68,62.91 141.63,62.86 arc(141.54,62.72) 141.51,62.57 141.51,62.08 arc(141.46,61.86) 141.34,61.67 140.86,61.19 arc(140.74,61.02) 140.7,60.81 YJ25.C15
FC22_RDP1: length 79.7
  TOP w0.147: U1.R58 172.55,120.34 v4(172.55,120.29)
  SIG3 w0.112: v4(172.55,120.29) 172.55,120.07 arc(172.51,119.98) 172.42,119.94 172.25,119.94 arc(172.02,119.85) 171.92,119.62 171.92,118.16 arc(171.91,118.11) 171.89,118.07 171.8,117.98 arc(171.76,117.95) 171.71,117.94 163.38,117.94 163.28,118.04 163.26,118.04
  SIG3 w0.16: YJ25.C17 142.15,61.97 arc(142.04,62.13) 142.01,62.32 142.01,62.54 arc(142.1,62.77) 142.33,62.86 143.18,62.86 arc(143.47,62.92) 143.72,63.08 144.87,64.24 arc(145.04,64.49) 145.1,64.78 145.1,71.82 arc(145.07,71.96) 144.99,72.09 143.65,73.42 arc(143.41,73.79) 143.32,74.23 143.32,93.41 arc(143.41,93.85) 143.65,94.22 156.16,106.72 arc(156.24,106.85) 156.27,106.99 156.27,111.57 arc(156.36,112.01) 156.61,112.38 161.93,117.7 arc(162.3,117.95) 162.74,118.04 163.26,118.04
FC22_RDP2: length 81.2
  TOP w0.147: v4(174.55,119.39) 174.55,119.45 arc(174.56,119.51) 174.59,119.56 174.8,119.77 arc(174.88,119.82) 174.98,119.84 U1.P56
  SIG2 w0.112: v4(174.55,119.39) 174.55,119.62 arc(174.51,119.71) 174.42,119.74 174.25,119.74 arc(174.16,119.71) 174.12,119.62 174.12,119.2 arc(174.09,119.07) 174.02,118.97 173.93,118.87 arc(173.82,118.8) 173.7,118.78 169.35,118.78 arc(169.23,118.8) 169.12,118.87 169.05,118.95 arc(168.98,119.05) 168.95,119.18 168.95,119.65 arc(168.92,119.74) 168.83,119.78 163.31,119.78 163.23,119.7
  SIG2 w0.16: YJ25.C21 143.1,64.79 arc(143.14,65.02) 143.27,65.2 143.74,65.67 arc(143.86,65.86) 143.91,66.08 143.91,68.44 arc(143.82,68.87) 143.57,69.25 143.21,69.6 143.21,69.96 142.85,70.32 142.49,70.32 140.78,72.04 arc(140.7,72.16) 140.67,72.31 140.67,93.63 arc(140.7,93.77) 140.78,93.89 152.89,106.01 arc(153.14,106.38) 153.23,106.82 153.23,111.23 153.23,111.23 arc(153.28,111.53) 153.45,111.77 161.16,119.48 arc(161.4,119.64) 161.69,119.7 163.23,119.7
FC22_RDP3: length 75.5
  TOP w0.147: v4(170.55,120.29) 170.55,120.34 U1.R60
  SIG3 w0.112: v4(170.55,120.29) 170.27,120.02 arc(170.17,119.96) 170.06,119.97 arc(169.8,120.04) 169.53,120.06 169.14,120.06 arc(169.06,120.05) 168.99,120 arc(168.92,119.96) 168.84,119.94 163.38,119.94 163.28,120.03 163.26,120.03
  SIG3 w0.16: 163.26,120.03 161.44,120.03 arc(161,119.95) 160.63,119.7 153.18,112.25 arc(152.93,111.88) 152.84,111.44 152.84,106.61 arc(152.82,106.47) 152.73,106.34 140.62,94.23 arc(140.37,93.86) 140.29,93.42 140.29,73.96 arc(140.37,73.52) 140.62,73.15 141.82,71.95 arc(141.9,71.83) 141.93,71.68 141.93,67.86 arc(141.9,67.71) 141.82,67.59 141.68,67.45 141.31,67.08 arc(141.25,67.03) 141.18,66.98 arc(140.99,66.89) 140.78,66.86 139.96,66.86 arc(139.71,66.76) 139.61,66.51 139.61,66.32 arc(139.64,66.13) 139.75,65.97 YJ25.C25
FC22_TDN0: length 87.5
  TOP w0.147: U1.N63 167.94,118.84 arc(167.84,118.82) 167.75,118.76 167.67,118.69 arc(167.58,118.55) v4(167.55,118.39)
  SIG4 w0.112: v4(167.55,118.39) 167.55,118.61 arc(167.51,118.7) 167.42,118.74 167.25,118.74 arc(167.16,118.7) 167.12,118.61 167.12,118.15 arc(167.09,118.03) 167.02,117.92 166.94,117.84 arc(166.84,117.77) 166.71,117.75 163.38,117.75 163.29,117.66 163.27,117.66
  SIG4 w0.16: YJ25.C6 133.5,60.74 arc(133.55,61.01) 133.71,61.24 134.14,61.67 arc(134.26,61.86) 134.31,62.08 134.31,62.57 arc(134.34,62.72) 134.43,62.86 134.48,62.91 arc(134.61,63) 134.75,63.03 144.05,63.03 arc(144.34,63.08) 144.59,63.25 144.97,63.63 arc(145.14,63.88) 145.19,64.17 145.19,65.9 arc(145.14,66.19) 144.97,66.44 140.5,70.91 arc(140.33,71.16) 140.27,71.45 140.27,72.01 140.5,72.24 140.5,72.79 140.27,73.02 140.27,73.53 140.5,73.76 140.5,74.32 140.27,74.55 140.27,93 arc(140.33,93.29) 140.5,93.54 153,106.05 arc(153.17,106.3) 153.23,106.59 153.23,110.71 arc(153.28,111) 153.45,111.24 153.99,111.79 arc(154.24,111.95) 154.53,112.01 156.42,112.01 arc(156.71,112.07) 156.95,112.23 162.15,117.43 arc(162.4,117.6) 162.69,117.66 163.27,117.66
FC22_TDN1: length 88.1
  TOP w0.147: U1.P65 165.55,119.34 v4(165.55,119.28)
  SIG5 w0.112: v4(165.55,119.28) 165.55,119.06 arc(165.51,118.97) 165.42,118.93 165.25,118.93 arc(165.02,118.84) 164.92,118.61 164.92,118.14 arc(164.92,118.09) 164.89,118.05 164.82,117.98 arc(164.78,117.95) 164.73,117.94 163.38,117.94 163.28,118.03 163.26,118.03
  SIG5 w0.16: YJ25.C2 130.15,61.97 arc(130.04,62.13) 130.01,62.32 130.01,62.59 arc(130.09,62.78) 130.28,62.86 131.12,62.86 arc(131.46,62.93) 131.76,63.13 131.81,63.18 arc(132.06,63.35) 132.35,63.41 143.82,63.41 arc(143.97,63.44) 144.09,63.52 144.69,64.12 arc(144.78,64.24) 144.81,64.39 144.81,65.78 arc(144.75,66.07) 144.58,66.32 140.24,70.66 arc(140.08,70.91) 140.02,71.2 140.02,93.15 arc(140.1,93.59) 140.35,93.96 152.73,106.34 arc(152.82,106.47) 152.84,106.61 152.84,111.44 arc(152.93,111.88) 153.18,112.25 158.63,117.7 arc(159,117.95) 159.44,118.03 163.26,118.03
FC22_TDN2: length 81.3
  TOP w0.147: v4(168.55,120.4) 168.55,120.39 168.55,120.47 arc(168.57,120.55) 168.61,120.61 168.69,120.7 arc(168.85,120.8) 169.04,120.84 U1.R62
  SIG4 w0.112: 163.26,119.65 163.28,119.65 163.38,119.75 167.71,119.75 arc(167.84,119.77) 167.94,119.84 168.02,119.92 arc(168.09,120.03) 168.12,120.15 168.12,120.62 arc(168.16,120.71) 168.25,120.75 168.42,120.75 arc(168.51,120.71) 168.55,120.62 v4(168.55,120.4)
  SIG4 w0.16: 163.26,119.65 161.72,119.65 arc(161.43,119.6) 161.18,119.43 160.01,118.26 arc(159.76,118.09) 159.47,118.04 154.31,118.04 arc(154.02,117.98) 153.77,117.81 149.13,113.17 arc(148.97,112.93) 148.91,112.64 148.91,105.27 arc(148.85,104.97) 148.68,104.73 132,88.04 arc(131.83,87.79) 131.77,87.5 131.77,71.32 arc(131.83,71.03) 132,70.78 132.32,70.46 132.55,70.46 132.92,70.09 132.92,69.86 133.19,69.59 133.46,69.59 133.85,69.21 133.85,68.93 134.08,68.7 arc(134.25,68.45) 134.31,68.16 134.31,65.95 arc(134.29,65.85) 134.23,65.77 133.7,65.24 arc(133.55,65.01) 133.5,64.75 YJ25.C33
FC22_TDN3: length 78.4
  TOP w0.147: v4(166.55,121.29) 166.55,121.34 U1.T64
  SIG5 w0.112: v4(166.55,121.29) 166.55,121.07 arc(166.51,120.98) 166.42,120.94 166.25,120.94 arc(166.02,120.85) 165.92,120.62 165.92,120.15 arc(165.92,120.1) 165.89,120.06 165.82,119.99 arc(165.78,119.96) 165.73,119.95 163.38,119.95 163.28,120.04 163.26,120.04
  SIG5 w0.16: 163.26,120.04 155.96,120.04 arc(155.52,119.96) 155.15,119.71 148.93,113.49 arc(148.69,113.12) 148.6,112.68 148.6,105.34 arc(148.57,105.19) 148.49,105.07 131.73,88.31 arc(131.48,87.94) 131.39,87.5 131.39,71.3 131.53,70.92 131.53,67.08 arc(131.46,66.93) 131.31,66.86 130.28,66.86 arc(130.09,66.78) 130.01,66.59 130.01,66.32 arc(130.04,66.13) 130.15,65.97 YJ25.C37
FC22_TDP0: length 87.5
  TOP w0.147: U1.P63 167.55,119.34 v4(167.55,119.28)
  SIG4 w0.112: 163.27,118.04 163.29,118.04 163.38,117.95 166.71,117.95 arc(166.76,117.95) 166.8,117.98 166.89,118.06 arc(166.91,118.1) 166.92,118.15 166.92,118.61 arc(167.02,118.84) 167.25,118.93 167.42,118.93 arc(167.51,118.97) 167.55,119.06 v4(167.55,119.28)
  SIG4 w0.16: 163.27,118.04 162.69,118.04 arc(162.25,117.95) 161.88,117.7 156.68,112.5 arc(156.56,112.42) 156.42,112.39 154.53,112.39 arc(154.09,112.31) 153.72,112.06 153.18,111.51 arc(152.93,111.14) 152.84,110.71 152.84,106.59 arc(152.82,106.44) 152.73,106.32 140.23,93.81 arc(139.98,93.44) 139.89,93 139.89,71.45 arc(139.98,71.02) 140.23,70.64 140.65,70.22 144.45,66.42 144.7,66.17 arc(144.78,66.05) 144.81,65.9 144.81,64.17 arc(144.78,64.02) 144.7,63.9 144.32,63.52 arc(144.2,63.44) 144.05,63.41 134.75,63.41 arc(134.46,63.35) 134.21,63.18 134.16,63.13 134.12,63.08 arc(133.87,62.92) 133.58,62.86 132.73,62.86 arc(132.5,62.77) 132.41,62.54 132.41,62.32 arc(132.44,62.13) 132.55,61.97 YJ25.C5
FC22_TDP1: length 88.1
  TOP w0.147: U1.N65 166,118.84 arc(165.68,118.71) v4(165.55,118.39)
  SIG5 w0.112: 163.26,117.65 163.28,117.65 163.38,117.74 164.73,117.74 arc(164.85,117.77) 164.96,117.84 165.03,117.91 arc(165.1,118.01) 165.12,118.14 165.12,118.61 arc(165.16,118.7) 165.25,118.74 165.42,118.74 arc(165.51,118.7) 165.55,118.61 v4(165.55,118.39)
  SIG5 w0.16: YJ25.C3 131.1,60.91 arc(131.12,61.03) 131.19,61.12 131.35,61.29 131.74,61.67 arc(131.86,61.86) 131.91,62.08 131.91,62.57 arc(131.91,62.6) 131.91,62.63 arc(131.91,62.64) 131.91,62.65 arc(131.96,62.76) 132.03,62.86 132.08,62.91 arc(132.21,63) 132.35,63.03 143.82,63.03 arc(144.11,63.08) 144.36,63.25 144.96,63.85 arc(145.13,64.1) 145.19,64.39 145.19,65.78 arc(145.1,66.22) 144.85,66.59 140.51,70.93 arc(140.43,71.05) 140.4,71.2 140.4,93.15 arc(140.46,93.45) 140.62,93.69 153,106.07 arc(153.17,106.32) 153.23,106.61 153.23,111.44 arc(153.28,111.73) 153.45,111.98 155.02,113.55 155.23,113.55 155.49,113.81 155.77,114.09 155.77,114.3 156.31,114.84 156.53,114.84 157.07,115.38 157.07,115.6 157.6,116.14 157.82,116.14 158.36,116.68 158.36,116.89 158.9,117.43 arc(159.14,117.59) 159.44,117.65 163.26,117.65
FC22_TDP2: length 81.3
  TOP w0.147: U1.T62 168.55,121.34 v4(168.55,121.29)
  SIG4 w0.112: v4(168.55,121.29) 168.55,121.07 arc(168.51,120.98) 168.42,120.94 168.25,120.94 arc(168.02,120.85) 167.92,120.62 167.92,120.15 arc(167.91,120.1) 167.89,120.06 167.8,119.98 arc(167.76,119.95) 167.71,119.94 163.38,119.94 163.28,120.03 163.26,120.03
  SIG4 w0.16: YJ25.C34 132.55,65.97 arc(132.44,66.13) 132.41,66.32 132.41,66.59 arc(132.49,66.78) 132.68,66.86 133.67,66.86 arc(133.7,66.86) 133.73,66.87 arc(133.78,66.89) 133.83,66.92 arc(133.9,67.01) 133.93,67.12 133.93,68.16 arc(133.9,68.3) 133.81,68.43 133.57,68.67 132.74,69.5 131.73,70.51 arc(131.48,70.88) 131.39,71.32 131.39,87.5 arc(131.48,87.94) 131.73,88.31 148.41,105 arc(148.5,105.12) 148.53,105.27 148.53,112.64 arc(148.61,113.07) 148.86,113.44 153.5,118.08 arc(153.87,118.33) 154.31,118.42 159.47,118.42 arc(159.61,118.45) 159.74,118.53 160.91,119.7 arc(161.28,119.95) 161.72,120.03 163.26,120.03
FC22_TDP3: length 78.4
  TOP w0.147: U1.R64 166.99,120.84 arc(166.68,120.71) v4(166.55,120.4)
  SIG5 w0.112: v4(166.55,120.4) 166.55,120.62 arc(166.51,120.71) 166.42,120.75 166.25,120.75 arc(166.16,120.71) 166.12,120.62 166.12,120.15 arc(166.1,120.02) 166.03,119.92 165.96,119.85 arc(165.85,119.78) 165.73,119.75 163.38,119.75 163.28,119.66 163.26,119.66
  SIG5 w0.16: YJ25.C36 131.1,64.86 arc(131.13,65.02) 131.22,65.16 131.74,65.67 arc(131.86,65.86) 131.91,66.08 131.91,70.99 131.77,71.36 131.77,87.5 arc(131.83,87.79) 132,88.04 148.76,104.8 arc(148.92,105.05) 148.98,105.34 148.98,112.68 arc(149.04,112.97) 149.2,113.22 154.13,118.15 154.41,118.15 154.88,118.62 154.88,118.9 155.42,119.44 arc(155.67,119.6) 155.96,119.66 156.72,119.66 156.9,119.48 157.61,119.48 157.79,119.66 163.26,119.66
FC23_RDN0: length 89.5
  TOP w0.147: v4(176.55,116.39) 176.55,116.47 arc(176.56,116.53) 176.6,116.59 176.78,116.77 arc(176.86,116.82) 176.96,116.84 U1.L54
  SIG2 w0.112: 163.28,111.65 163.31,111.65 163.4,111.74 175.74,111.74 arc(175.79,111.75) 175.83,111.78 176.02,111.96 arc(176.09,112.07) 176.11,112.19 176.11,116.62 arc(176.15,116.71) 176.24,116.74 176.42,116.74 arc(176.51,116.71) 176.55,116.62 v4(176.55,116.39)
  SIG2 w0.16: YJ25.D15 140.7,52.82 arc(140.74,53.02) 140.85,53.19 141.34,53.67 arc(141.46,53.86) 141.51,54.08 141.51,54.57 arc(141.54,54.72) 141.63,54.86 141.68,54.91 arc(141.73,54.95) 141.78,54.98 arc(141.86,55.01) 141.95,55.03 143.68,55.03 arc(144.11,55.11) 144.48,55.36 144.96,55.83 145.29,55.83 145.68,56.22 145.68,56.55 146.04,56.91 146.34,56.91 146.75,57.32 146.75,57.63 160.38,71.26 arc(160.63,71.63) 160.72,72.07 160.72,88.25 arc(160.78,88.54) 160.94,88.79 161.89,89.74 arc(162.06,89.99) 162.12,90.28 162.12,110.81 arc(162.17,111.1) 162.34,111.35 162.42,111.42 arc(162.66,111.59) 162.96,111.65 163.28,111.65
FC23_RDN1: length 82.4
  TOP w0.147: v4(172.55,117.29) 172.55,117.34 U1.M58
  SIG3 w0.112: v4(172.55,117.29) 172.55,117.07 arc(172.51,116.98) 172.42,116.94 172.25,116.94 arc(172.02,116.85) 171.92,116.62 171.92,116.15 arc(171.91,116.1) 171.89,116.06 171.78,115.96 arc(171.74,115.93) 171.69,115.92 170.34,115.92 arc(170.22,115.89) 170.11,115.82 170.04,115.75 arc(169.97,115.65) 169.95,115.52 169.95,115.09 arc(169.94,115.04) 169.91,115 169.84,114.93 arc(169.8,114.9) 169.75,114.89 169.36,114.89 arc(169.24,114.87) 169.13,114.8 169.07,114.74 arc(169,114.63) 168.98,114.51 168.98,114.2 arc(168.97,114.16) 168.94,114.11 168.82,114 arc(168.78,113.97) 168.73,113.96 163.41,113.96 arc(163.35,113.99) 163.32,114.05 163.26,114.05
  SIG3 w0.16: 163.26,114.05 163.14,114.05 arc(162.88,114) 162.66,113.85 162.07,113.27 arc(161.82,112.9) 161.73,112.46 161.73,90.28 arc(161.71,90.13) 161.62,90.01 160.67,89.06 arc(160.42,88.69) 160.34,88.25 160.34,72.66 arc(160.16,71.78) 159.66,71.03 143.76,55.13 143.71,55.08 arc(143.47,54.92) 143.18,54.86 142.34,54.86 arc(142.1,54.76) 142.01,54.53 142.01,54.32 arc(142.04,54.13) 142.15,53.97 YJ25.D17
FC23_RDN2: length 83.9
  TOP w0.147: v4(174.55,116.39) 174.55,116.47 arc(174.56,116.54) 174.6,116.6 174.77,116.77 arc(174.85,116.82) 174.95,116.84 U1.L56
  SIG2 w0.112: 163.26,115.65 163.28,115.65 163.38,115.74 173.78,115.74 arc(173.83,115.75) 173.87,115.78 174.02,115.93 arc(174.09,116.03) 174.12,116.16 174.12,116.62 arc(174.16,116.71) 174.25,116.74 174.42,116.74 arc(174.51,116.71) 174.55,116.62 v4(174.55,116.39)
  SIG2 w0.16: YJ25.D24 140.7,56.84 arc(140.74,57.02) 140.84,57.17 141.34,57.67 arc(141.46,57.86) 141.51,58.08 141.51,58.57 arc(141.54,58.72) 141.63,58.86 141.68,58.91 arc(141.73,58.95) 141.78,58.98 arc(141.86,59.01) 141.95,59.03 144.5,59.03 arc(144.94,59.11) 145.31,59.36 153.65,67.7 arc(153.9,68.07) 153.99,68.51 153.99,69.24 154.19,69.44 154.19,70.05 153.99,70.25 153.99,70.76 154.22,70.99 154.22,71.55 153.99,71.78 153.99,72.37 arc(154.05,72.66) 154.21,72.91 156.43,75.13 arc(156.6,75.38) 156.65,75.67 156.65,90.11 arc(156.71,90.4) 156.88,90.64 158.97,92.74 arc(159.14,92.99) 159.19,93.28 159.19,111.95 arc(159.22,112.1) 159.31,112.22 162.62,115.53 arc(162.75,115.62) 162.89,115.65 163.26,115.65
FC23_RDN3: length 77.2
  TOP w0.147: U1.M60 170.55,117.34 v4(170.55,117.29)
  SIG3 w0.112: 163.26,116.01 163.28,116.01 163.38,115.92 168.75,115.92 arc(168.8,115.93) 168.84,115.96 168.94,116.06 arc(168.97,116.1) 168.98,116.15 168.98,116.62 arc(169.07,116.85) 169.3,116.94 170.42,116.94 arc(170.51,116.98) 170.55,117.07 v4(170.55,117.29)
  SIG3 w0.16: 163.26,116.01 162.75,116.01 arc(162.31,115.92) 161.94,115.68 159.15,112.89 arc(158.9,112.51) 158.81,112.08 158.81,93.28 arc(158.78,93.13) 158.7,93.01 156.61,90.91 arc(156.36,90.54) 156.27,90.11 156.27,75.67 arc(156.24,75.52) 156.16,75.4 153.94,73.18 arc(153.69,72.81) 153.61,72.37 153.61,70.07 arc(153.41,69.06) 152.84,68.21 143.87,59.24 143.64,59.01 arc(143.48,58.9) 143.29,58.86 142.31,58.86 arc(142.1,58.77) 142.01,58.55 142.01,58.32 arc(142.04,58.13) 142.15,57.97 YJ25.D22
FC23_RDP0: length 89.5
  TOP w0.147: v4(176.55,117.29) 176.55,117.34 U1.M54
  SIG2 w0.112: v4(176.55,117.29) 176.55,117.07 arc(176.51,116.98) 176.42,116.94 176.24,116.94 arc(176.01,116.85) 175.91,116.62 175.91,112.19 arc(175.9,112.14) 175.88,112.1 175.75,111.97 arc(175.71,111.94) 175.66,111.94 163.4,111.94 163.31,112.03 163.28,112.03
  SIG2 w0.16: 163.28,112.03 162.96,112.03 arc(162.52,111.94) 162.15,111.69 162.07,111.62 arc(161.82,111.24) 161.73,110.81 161.73,90.28 arc(161.71,90.13) 161.62,90.01 160.67,89.06 arc(160.42,88.69) 160.34,88.25 160.34,72.07 arc(160.28,71.78) 160.11,71.53 144.22,55.63 arc(143.97,55.46) 143.68,55.41 141.95,55.41 arc(141.77,55.38) 141.6,55.32 arc(141.5,55.26) 141.41,55.18 141.36,55.13 141.31,55.08 arc(141.07,54.92) 140.78,54.86 139.88,54.86 arc(139.69,54.78) 139.61,54.59 139.61,54.32 arc(139.64,54.13) 139.75,53.97 YJ25.D14
FC23_RDP1: length 82.4
  TOP w0.147: v4(172.55,116.39) 172.55,116.48 arc(172.57,116.57) 172.61,116.64 172.68,116.71 arc(172.83,116.81) 173,116.84 U1.L58
  SIG3 w0.112: v4(172.55,116.39) 172.55,116.62 arc(172.51,116.71) 172.42,116.74 172.25,116.74 arc(172.16,116.71) 172.12,116.62 172.12,116.15 arc(172.09,116.03) 172.02,115.92 171.92,115.82 arc(171.82,115.75) 171.69,115.72 170.34,115.72 arc(170.29,115.71) 170.25,115.68 170.18,115.61 arc(170.15,115.57) 170.14,115.52 170.14,115.09 arc(170.12,114.96) 170.05,114.86 169.98,114.79 arc(169.88,114.72) 169.75,114.7 169.36,114.7 arc(169.31,114.69) 169.27,114.66 169.21,114.6 arc(169.19,114.56) 169.18,114.51 169.18,114.2 arc(169.15,114.08) 169.08,113.98 168.96,113.86 arc(168.86,113.79) 168.73,113.76 163.48,113.76 arc(163.38,113.74) 163.3,113.69 arc(163.28,113.68) 163.26,113.67
  SIG3 w0.16: YJ25.D18 143.1,52.78 arc(143.15,53.01) 143.28,53.21 143.74,53.67 arc(143.86,53.86) 143.91,54.08 143.91,54.57 arc(143.94,54.72) 144.03,54.86 144.39,55.22 144.74,55.22 145.1,55.57 145.1,55.93 145.46,56.29 145.8,56.29 146.18,56.68 146.18,57.01 159.93,70.76 arc(160.51,71.63) 160.72,72.66 160.72,88.25 arc(160.78,88.54) 160.94,88.79 161.89,89.74 arc(162.06,89.99) 162.12,90.28 162.12,112.46 arc(162.17,112.75) 162.34,113 162.93,113.59 arc(163.02,113.65) 163.14,113.67 163.26,113.67
FC23_RDP2: length 83.9
  TOP w0.147: v4(174.55,117.29) 174.55,117.34 U1.M56
  SIG2 w0.112: v4(174.55,117.29) 174.55,117.07 arc(174.51,116.98) 174.42,116.94 174.25,116.94 arc(174.02,116.85) 173.92,116.62 173.92,116.16 arc(173.91,116.11) 173.89,116.07 173.79,115.97 arc(173.75,115.95) 173.7,115.94 163.38,115.94 163.28,116.03 163.26,116.03
  SIG2 w0.16: 163.26,116.03 162.89,116.03 arc(162.6,115.97) 162.35,115.8 159.04,112.49 arc(158.87,112.24) 158.81,111.95 158.81,93.28 arc(158.78,93.13) 158.7,93.01 156.61,90.91 arc(156.36,90.54) 156.27,90.11 156.27,75.67 arc(156.24,75.52) 156.16,75.4 153.94,73.18 arc(153.69,72.81) 153.61,72.37 153.61,68.51 arc(153.55,68.22) 153.38,67.97 145.04,59.63 arc(144.79,59.46) 144.5,59.41 141.95,59.41 arc(141.77,59.38) 141.6,59.32 arc(141.5,59.26) 141.41,59.18 141.36,59.13 141.31,59.08 arc(141.07,58.92) 140.78,58.86 139.94,58.86 arc(139.7,58.76) 139.61,58.53 139.61,58.32 arc(139.64,58.13) 139.75,57.97 YJ25.D25
FC23_RDP3: length 77.2
  TOP w0.147: v4(170.55,116.39) 170.55,116.48 arc(170.57,116.57) 170.61,116.64 170.68,116.71 arc(170.83,116.81) 171,116.84 U1.L60
  SIG3 w0.112: v4(170.55,116.39) 170.55,116.62 arc(170.51,116.71) 170.42,116.74 169.3,116.74 arc(169.21,116.71) 169.18,116.62 169.18,116.15 arc(169.15,116.03) 169.08,115.92 168.98,115.82 arc(168.87,115.75) 168.75,115.72 163.38,115.72 163.28,115.63 163.26,115.63
  SIG3 w0.16: YJ25.D21 143.1,56.78 arc(143.15,57.01) 143.28,57.21 143.52,57.46 143.74,57.67 arc(143.86,57.86) 143.91,58.08 143.91,58.57 arc(143.91,58.61) 143.92,58.66 arc(143.92,58.67) 143.92,58.67 arc(143.96,58.77) 144.03,58.86 144.39,59.22 144.72,59.22 145.1,59.6 145.1,59.93 145.7,60.53 146.04,60.53 146.42,60.92 146.42,61.25 153.11,67.94 arc(153.76,68.91) 153.99,70.07 153.99,72.37 arc(154.05,72.66) 154.21,72.91 156.43,75.13 arc(156.6,75.38) 156.65,75.67 156.65,90.11 arc(156.71,90.4) 156.88,90.64 158.97,92.74 arc(159.14,92.99) 159.19,93.28 159.19,112.08 arc(159.25,112.37) 159.42,112.62 162.21,115.41 arc(162.46,115.57) 162.75,115.63 163.26,115.63
FC23_TDN0: length 85.8
  TOP w0.147: v4(164.55,117.29) 164.55,117.34 U1.M66
  SIG5 w0.112: 163.26,116.04 163.29,116.04 163.38,115.95 163.75,115.95 arc(163.79,115.96) 163.83,115.99 163.89,116.04 arc(163.92,116.08) 163.92,116.13 163.92,116.62 arc(164.02,116.85) 164.25,116.94 164.42,116.94 arc(164.51,116.98) 164.55,117.07 v4(164.55,117.29)
  SIG5 w0.16: YJ25.D34 132.55,57.97 arc(132.44,58.13) 132.41,58.32 132.41,58.59 arc(132.49,58.78) 132.68,58.86 133.44,58.86 arc(133.86,58.95) 134.21,59.18 arc(134.46,59.35) 134.75,59.41 143.82,59.41 arc(144.12,59.46) 144.36,59.63 146.66,61.93 arc(146.83,62.18) 146.89,62.47 146.89,66.65 arc(146.83,66.94) 146.66,67.18 142.58,71.27 arc(142.41,71.52) 142.35,71.81 142.35,77.33 arc(142.44,77.77) 142.69,78.14 143.21,78.66 arc(143.29,78.78) 143.32,78.93 143.32,93.38 arc(143.41,93.81) 143.65,94.19 156.16,106.69 arc(156.24,106.82) 156.27,106.96 156.27,111.62 arc(156.36,112.06) 156.61,112.43 159.89,115.71 arc(160.26,115.95) 160.69,116.04 163.26,116.04
FC23_TDN1: length 88.9
  TOP w0.147: U1.L64 166.93,116.84 arc(166.83,116.82) 166.74,116.76 166.68,116.7 arc(166.58,116.56) v4(166.55,116.39)
  SIG4 w0.112: 163.23,115.65 163.26,115.65 163.35,115.74 165.71,115.74 arc(165.84,115.76) 165.94,115.83 166.02,115.91 arc(166.09,116.02) 166.12,116.14 166.12,116.62 arc(166.16,116.71) 166.25,116.74 166.42,116.74 arc(166.51,116.71) 166.55,116.62 v4(166.55,116.39)
  SIG4 w0.16: 163.23,115.65 162.97,115.65 arc(162.72,115.6) 162.52,115.46 159.42,112.36 arc(159.25,112.11) 159.19,111.82 159.19,109.51 arc(159.14,109.22) 158.97,108.97 143.92,93.92 arc(143.76,93.67) 143.7,93.38 143.7,78.9 arc(143.64,78.61) 143.48,78.36 142.96,77.84 arc(142.79,77.6) 142.74,77.3 142.74,71.94 arc(142.79,71.64) 142.96,71.4 147.16,67.2 arc(147.33,66.95) 147.38,66.66 147.38,62.53 arc(147.33,62.24) 147.16,61.99 146.67,61.5 146.67,61.17 146.29,60.78 145.95,60.78 145.5,60.33 145.5,59.99 145.11,59.61 144.78,59.61 144.42,59.25 arc(144.17,59.08) 143.88,59.03 132.35,59.03 arc(132.21,59) 132.08,58.91 132.03,58.86 arc(131.94,58.72) 131.91,58.57 131.91,58.08 arc(131.86,57.86) 131.74,57.67 131.26,57.2 arc(131.14,57.02) 131.1,56.8 YJ25.D36
FC23_TDN2: length 100.1
  TOP w0.147: v4(168.56,117.29) 168.55,117.29 168.55,117.34 U1.M62
  SIG4 w0.112: v4(168.56,117.29) 168.56,117.07 arc(168.52,116.98) 168.43,116.94 168.26,116.94 arc(168.03,116.85) 167.93,116.62 167.93,115.98 167.96,115.95 167.96,114.14 167.96,114.14 arc(167.95,114.09) 167.93,114.05 167.84,113.97 arc(167.8,113.95) 167.76,113.94 163.35,113.94 163.26,114.03
  SIG4 w0.16: YJ25.D2 130.15,53.97 arc(130.04,54.13) 130.01,54.32 130.01,54.56 arc(130.09,54.77) 130.3,54.86 131.18,54.86 arc(131.39,54.89) 131.58,54.98 arc(131.65,55.03) 131.72,55.08 131.76,55.13 131.81,55.18 arc(132.06,55.35) 132.35,55.41 144.31,55.41 arc(144.46,55.44) 144.58,55.52 149.05,59.99 arc(149.13,60.11) 149.16,60.26 149.16,67.44 arc(149.13,67.59) 149.05,67.71 144.77,71.99 arc(144.52,72.36) 144.44,72.8 144.44,76.47 arc(144.52,76.9) 144.77,77.27 146.08,78.58 arc(146.16,78.7) 146.19,78.85 146.19,85.81 arc(146.28,86.25) 146.52,86.62 146.95,87.04 arc(147.32,87.29) 147.76,87.37 155.86,87.37 arc(156,87.4) 156.13,87.49 161.62,92.98 arc(161.71,93.11) 161.73,93.25 161.73,112.46 arc(161.82,112.9) 162.07,113.27 162.62,113.82 arc(162.85,113.97) 163.12,114.03 163.26,114.03
FC23_TDN3: length 93
  TOP w0.147: U1.J65 166,114.84 arc(165.68,114.71) v4(165.55,114.39)
  SIG5 w0.112: 162.12,113.03 162.12,113.05 162.02,113.14 162.02,113.56 arc(162.03,113.6) 162.06,113.65 162.13,113.71 arc(162.17,113.74) 162.22,113.75 164.73,113.75 arc(164.85,113.78) 164.96,113.85 165.03,113.91 arc(165.1,114.02) 165.12,114.14 165.12,114.73 arc(165.14,114.8) 165.2,114.85 arc(165.22,114.85) 165.25,114.86 165.37,114.86 arc(165.5,114.8) 165.55,114.67 v4(165.55,114.39)
  SIG5 w0.16: 162.12,113.03 162.12,93.4 arc(162.03,92.97) 161.78,92.6 156.51,87.33 arc(156.14,87.08) 155.7,86.99 147.7,86.99 arc(147.41,86.93) 147.16,86.77 146.79,86.4 arc(146.63,86.16) 146.57,85.86 146.57,78.37 arc(146.51,78.08) 146.35,77.83 145.04,76.52 arc(144.88,76.28) 144.82,75.98 144.82,72.67 arc(144.85,72.53) 144.93,72.4 149.01,68.32 arc(149.26,67.95) 149.35,67.51 149.35,60.12 arc(149.26,59.69) 149.01,59.31 145.06,55.36 arc(144.69,55.11) 144.25,55.03 134.75,55.03 arc(134.61,55) 134.48,54.91 134.46,54.89 134.43,54.86 arc(134.35,54.76) 134.31,54.64 arc(134.31,54.6) 134.31,54.57 134.31,54.08 arc(134.26,53.86) 134.14,53.67 133.67,53.21 arc(133.55,53.02) 133.5,52.79 YJ25.D6
FC23_TDP0: length 85.8
  TOP w0.147: U1.L66 165,116.84 arc(164.68,116.71) v4(164.55,116.39)
  SIG5 w0.112: v4(164.55,116.39) 164.55,116.62 arc(164.51,116.71) 164.42,116.74 164.25,116.74 arc(164.16,116.71) 164.12,116.62 164.12,116.13 arc(164.1,116) 164.03,115.9 163.92,115.79 arc(163.88,115.76) 163.83,115.75 163.38,115.75 163.29,115.66 163.26,115.66
  SIG5 w0.16: 163.26,115.66 160.69,115.66 arc(160.4,115.6) 160.16,115.44 159.62,114.9 159.62,114.68 159.08,114.14 158.86,114.14 158.32,113.6 158.32,113.39 157.78,112.85 157.57,112.85 156.88,112.16 arc(156.71,111.91) 156.65,111.62 156.65,110.86 156.78,110.73 156.78,109.92 156.65,109.79 156.65,106.96 arc(156.6,106.67) 156.43,106.42 143.92,93.92 arc(143.76,93.67) 143.7,93.38 143.7,78.93 arc(143.64,78.63) 143.48,78.39 142.96,77.87 arc(142.79,77.62) 142.74,77.33 142.74,71.81 arc(142.76,71.66) 142.85,71.54 146.93,67.45 arc(147.18,67.08) 147.27,66.65 147.27,62.47 arc(147.18,62.03) 146.93,61.66 144.63,59.36 arc(144.26,59.11) 143.82,59.03 134.75,59.03 arc(134.61,59) 134.48,58.91 134.46,58.89 134.43,58.86 arc(134.36,58.76) 134.31,58.65 arc(134.31,58.64) 134.31,58.63 arc(134.31,58.6) 134.31,58.57 134.31,58.08 arc(134.26,57.86) 134.14,57.67 133.84,57.38 133.59,57.12 arc(133.52,57.03) 133.5,56.91 YJ25.D33
FC23_TDP1: length 88.9
  TOP w0.147: U1.M64 166.55,117.34 v4(166.55,117.29)
  SIG4 w0.112: v4(166.55,117.29) 166.55,117.07 arc(166.51,116.98) 166.42,116.94 166.25,116.94 arc(166.02,116.85) 165.92,116.62 165.92,116.14 arc(165.91,116.09) 165.89,116.05 165.8,115.97 arc(165.76,115.95) 165.71,115.94 163.35,115.94 163.26,116.03 163.23,116.03
  SIG4 w0.16: YJ25.D37 130.15,57.97 arc(130.04,58.13) 130.01,58.32 130.01,58.55 arc(130.1,58.77) 130.31,58.86 131.18,58.86 arc(131.47,58.92) 131.72,59.08 131.76,59.13 131.81,59.18 arc(132.06,59.35) 132.35,59.41 143.88,59.41 arc(144.03,59.44) 144.15,59.52 146.89,62.26 arc(146.97,62.38) 147,62.53 147,66.66 arc(146.97,66.8) 146.89,66.93 142.69,71.13 arc(142.44,71.5) 142.35,71.94 142.35,77.3 arc(142.44,77.74) 142.69,78.11 143.21,78.63 arc(143.29,78.75) 143.32,78.9 143.32,93.38 arc(143.41,93.82) 143.65,94.19 158.7,109.24 arc(158.78,109.36) 158.81,109.51 158.81,111.82 arc(158.9,112.26) 159.15,112.63 162.25,115.73 arc(162.58,115.95) 162.97,116.03 163.23,116.03
FC23_TDP2: length 100.1
  TOP w0.147: v4(168.56,116.39) 168.56,116.47 arc(168.56,116.49) 168.56,116.52 arc(168.6,116.58) 168.64,116.64 168.78,116.77 arc(168.86,116.82) 168.95,116.84 U1.L62
  SIG4 w0.112: 163.26,113.65 163.35,113.74 167.76,113.74 arc(167.88,113.76) 167.98,113.83 168.07,113.91 arc(168.14,114.02) 168.16,114.14 168.16,116.03 168.13,116.06 168.13,116.62 arc(168.17,116.71) 168.26,116.74 168.43,116.74 arc(168.52,116.71) 168.56,116.62 v4(168.56,116.39)
  SIG4 w0.16: 163.26,113.65 163.12,113.65 arc(163,113.62) 162.89,113.55 162.34,113 arc(162.17,112.75) 162.12,112.46 162.12,93.25 arc(162.06,92.96) 161.89,92.71 156.4,87.22 arc(156.15,87.05) 155.86,86.99 147.76,86.99 arc(147.46,86.93) 147.22,86.77 146.79,86.35 arc(146.63,86.1) 146.57,85.81 146.57,78.85 arc(146.51,78.56) 146.35,78.31 145.04,77 arc(144.88,76.76) 144.82,76.47 144.82,72.8 arc(144.88,72.51) 145.04,72.26 149.32,67.98 arc(149.48,67.74) 149.54,67.44 149.54,60.26 arc(149.48,59.97) 149.32,59.72 148.08,58.48 147.36,57.76 147.01,57.4 147.01,57.07 146.62,56.69 146.29,56.69 145.93,56.33 145.93,55.99 145.54,55.61 145.21,55.61 144.85,55.25 arc(144.6,55.08) 144.31,55.03 132.35,55.03 arc(132.21,55) 132.08,54.91 arc(131.95,54.72) 131.91,54.49 131.91,54.08 arc(131.86,53.86) 131.74,53.67 131.24,53.17 arc(131.14,53.02) 131.1,52.84 YJ25.D3
FC23_TDP3: length 93
  TOP w0.147: U1.K65 165.55,115.34 v4(165.55,115.29)
  SIG5 w0.112: v4(165.55,115.29) 165.4,115.15 arc(165.35,115.1) 165.29,115.07 arc(165.23,115.06) 165.17,115.05 165.12,115.02 arc(164.98,114.91) 164.92,114.73 164.92,114.14 164.92,114.14 arc(164.92,114.09) 164.89,114.05 164.82,113.99 arc(164.78,113.96) 164.73,113.95 162.22,113.95 arc(162.1,113.92) 161.99,113.85 161.92,113.78 arc(161.85,113.68) 161.83,113.56 161.83,113.15 161.73,113.05 161.73,113.03
  SIG5 w0.16: YJ25.D5 132.55,53.97 arc(132.44,54.13) 132.41,54.32 132.41,54.49 arc(132.52,54.75) 132.78,54.86 133.58,54.86 arc(133.87,54.92) 134.12,55.08 134.16,55.13 134.21,55.18 arc(134.46,55.35) 134.75,55.41 144.25,55.41 arc(144.54,55.46) 144.79,55.63 148.74,59.58 arc(148.91,59.83) 148.97,60.12 148.97,67.51 arc(148.91,67.8) 148.74,68.05 144.66,72.13 arc(144.5,72.38) 144.44,72.67 144.44,75.98 arc(144.52,76.42) 144.77,76.79 146.08,78.1 arc(146.16,78.22) 146.19,78.37 146.19,85.86 arc(146.28,86.3) 146.52,86.67 146.89,87.04 arc(147.26,87.29) 147.7,87.37 155.7,87.37 arc(156,87.43) 156.24,87.6 161.51,92.87 arc(161.68,93.11) 161.73,93.4 161.73,109.37 161.61,109.5 161.61,110.31 161.73,110.44 161.73,111.2 161.58,111.35 161.58,112.11 161.73,112.27 161.73,113.03
FC24_25_PVDD0P8: length 5.4
  TOP w0.229: U1.Y48 v1(182.55,125.34) ; U1.Y47 v1(183.55,125.34)
  TOP w0.381: 170.22,98.33 C3041.1 ; C3041.1 170.85,98.93 ; C3041.1 170.22,99.53
  BOTTOM w0.13: v1(171.39,99.44) v2(172.15,99.44)
  BOTTOM w0.381: C2996.1 183.06,124.83 v1(182.55,125.34) ; C3319.1 183.06,125.83 v1(183.55,125.34)
  vias: v1(171.39,98.42)
FC24_RDN0: length 81.2
  TOP w0.147: U1.J54 176.55,114.34 v4(176.55,114.29)
  SIG8 w0.112: 163.31,112.04 163.33,112.04 163.43,111.95 175.67,111.95 arc(175.77,111.97) 175.85,112.02 175.85,112.02 arc(175.9,112.1) 175.92,112.19 175.92,113.64 arc(176,113.85) 176.22,113.94 176.45,113.94 arc(176.52,113.97) 176.55,114.04 v4(176.55,114.29)
  SIG8 w0.16: 163.31,112.04 161.7,112.04 arc(161.26,111.95) 160.89,111.71 159.15,109.96 arc(158.9,109.59) 158.81,109.16 158.81,101.71 arc(158.9,101.27) 159.15,100.9 159.54,100.51 arc(159.63,100.38) 159.65,100.24 159.65,91.32 arc(159.6,91.03) 159.43,90.78 158.15,89.5 arc(157.98,89.25) 157.92,88.96 157.92,72.99 arc(157.87,72.7) 157.7,72.45 154.32,69.07 arc(154.15,68.82) 154.09,68.53 154.09,62.42 arc(154.18,61.98) 154.43,61.61 156.69,59.35 arc(157.06,59.1) 157.5,59.01 159.39,59.01 arc(159.54,58.98) 159.66,58.9 159.75,58.82 arc(159.82,58.73) 159.87,58.63 arc(159.87,58.62) 159.88,58.61 arc(159.9,58.52) 159.91,58.42 159.91,58.15 arc(159.97,57.85) 160.14,57.59 160.4,57.34 arc(160.62,57) 160.7,56.61 YJ28.D24
FC24_RDN1: length 85.7
  TOP w0.147: U1.H58 172.95,113.84 arc(172.86,113.82) 172.78,113.77 172.65,113.64 arc(172.58,113.53) v4(172.55,113.39)
  SIG9 w0.112: v4(172.55,113.39) 172.55,113.61 arc(172.54,113.66) 172.51,113.7 172.51,113.71 arc(172.46,113.73) 172.42,113.74 172.22,113.74 arc(172.01,113.83) 171.93,114.04 171.93,115.41 arc(171.9,115.53) 171.83,115.64 arc(171.72,115.71) 171.6,115.73 163.36,115.73 163.26,115.64
  SIG9 w0.16: 163.26,115.64 160.72,115.64 arc(160.43,115.58) 160.18,115.41 157.26,112.49 arc(157.09,112.24) 157.04,111.95 157.04,99.25 arc(157.09,98.95) 157.26,98.71 157.73,98.24 arc(157.89,97.99) 157.95,97.7 157.95,92.03 arc(157.89,91.74) 157.73,91.49 156.45,90.21 arc(156.28,89.97) 156.22,89.67 156.22,75.24 arc(156.16,74.95) 156,74.7 154.85,73.55 arc(154.68,73.3) 154.62,73.01 154.62,72.58 arc(154.56,72.28) 154.4,72.04 151.8,69.44 arc(151.63,69.19) 151.57,68.9 151.57,61.44 arc(151.63,61.15) 151.8,60.9 152.44,60.26 152.78,60.26 153.16,59.87 153.16,59.54 153.59,59.11 153.92,59.11 154.31,58.73 154.31,58.39 154.67,58.03 154.98,58.03 155.39,57.62 155.39,57.32 155.75,56.96 156.08,56.96 156.46,56.57 156.46,56.24 157.62,55.08 157.69,55.01 arc(157.76,54.96) 157.83,54.91 arc(157.93,54.87) 158.05,54.86 159.06,54.86 arc(159.3,54.76) 159.4,54.52 159.4,54.34 arc(159.36,54.14) 159.25,53.97 YJ28.D17
FC24_RDN2: length 87
  TOP w0.147: U1.J56 174.55,114.34 v4(174.55,114.29)
  SIG8 w0.112: 163.26,114.04 163.28,114.04 163.38,113.95 168.64,113.95 arc(168.76,113.97) 168.87,114.04 arc(168.94,114.15) 168.97,114.28 168.97,114.39 arc(169,114.57) 169.1,114.72 169.13,114.75 arc(169.31,114.87) 169.53,114.91 173.7,114.91 arc(173.83,114.89) 173.93,114.82 174.02,114.73 arc(174.09,114.62) 174.12,114.5 174.12,114.04 arc(174.15,113.97) 174.22,113.94 174.45,113.94 arc(174.52,113.97) 174.55,114.04 v4(174.55,114.29)
  SIG8 w0.16: YJ28.D15 160.7,52.68 arc(160.63,53.01) 160.45,53.29 160.11,53.63 arc(159.96,53.84) 159.91,54.1 159.91,54.48 arc(159.91,54.54) 159.89,54.61 arc(159.85,54.7) 159.79,54.77 159.75,54.81 159.66,54.9 arc(159.54,54.98) 159.39,55.01 157.69,55.01 arc(157.25,55.1) 156.88,55.35 152.27,59.96 arc(152.02,60.33) 151.94,60.77 151.94,69.31 arc(151.99,69.61) 152.16,69.85 153.81,71.51 arc(153.98,71.75) 154.04,72.05 154.04,72.8 arc(154.12,73.24) 154.37,73.61 155.73,74.97 arc(155.81,75.09) 155.84,75.24 155.84,89.83 arc(155.9,90.12) 156.07,90.37 157.35,91.66 arc(157.52,91.9) 157.57,92.2 157.57,97.9 arc(157.55,98.04) 157.46,98.17 156.99,98.64 arc(156.74,99.01) 156.65,99.45 156.65,110.04 arc(156.74,110.48) 156.99,110.85 159.84,113.7 arc(160.21,113.95) 160.65,114.04 163.26,114.04
FC24_RDN3: length 73.6
  TOP w0.147: U1.H60 170.95,113.84 arc(170.86,113.82) 170.78,113.77 170.65,113.64 arc(170.58,113.53) v4(170.55,113.39)
  SIG9 w0.112: 163.16,113.67 163.25,113.76 168.97,113.76 169.03,113.69 169.57,113.69 arc(169.72,113.7) 169.87,113.72 arc(170.14,113.7) 170.38,113.56 v4(170.55,113.39)
  SIG9 w0.16: YJ28.D22 159.25,57.97 arc(159.36,58.14) 159.4,58.34 159.4,58.52 arc(159.3,58.76) 159.06,58.86 158.16,58.86 arc(157.86,58.92) 157.62,59.08 157.15,59.55 156.43,60.27 156.43,60.6 156.05,60.99 155.71,60.99 155.35,61.35 155.35,61.68 154.97,62.07 154.64,62.07 153.77,62.93 arc(153.69,63.06) 153.66,63.2 153.66,63.71 153.89,63.94 153.89,64.5 153.66,64.73 153.66,65.23 153.89,65.46 153.89,66.02 153.66,66.25 153.66,68.17 arc(153.69,68.31) 153.77,68.44 157.95,72.62 arc(158.2,72.99) 158.29,73.43 158.29,88.93 arc(158.32,89.07) 158.4,89.19 159.7,90.49 arc(159.95,90.86) 160.03,91.3 160.03,99.65 arc(159.95,100.09) 159.7,100.46 159.31,100.85 arc(159.22,100.97) 159.19,101.12 159.19,111.31 arc(159.22,111.46) 159.31,111.58 160.29,112.57 161.28,113.56 arc(161.4,113.64) 161.55,113.67 163.16,113.67
