# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC60_TDP3: length 228.9
  TOP w0.147: v4(213.6,168.34) 213.55,168.34 U1.CB18
  SIG6 w0.112: v4(213.6,168.34) 213.75,168.34 arc(213.84,168.38) 213.87,168.47 213.87,168.63 arc(213.9,168.75) 213.97,168.86 213.98,168.87 arc(214.1,168.95) 214.24,168.98 214.75,168.98 arc(214.83,168.99) 214.89,169.04 arc(214.94,169.1) 214.95,169.18 214.95,172.47 arc(215.01,172.75) 215.16,172.98 215.28,173.1 215.28,173.23 215.3,173.25
  SIG6 w0.16: 215.3,173.25 215.62,173.57 arc(215.89,173.79) 216.19,173.96 arc(216.56,174.08) 216.94,174.11 224.22,174.11 arc(224.31,174.13) 224.38,174.18 arc(224.7,174.39) 225.08,174.47 231.65,174.47 arc(231.94,174.41) 232.19,174.25 232.3,174.13 arc(232.5,173.99) 232.73,173.92 arc(232.78,173.91) 232.84,173.91 248.52,173.91 arc(248.81,173.85) 249.06,173.69 286.51,136.24 arc(286.76,136.07) 287.05,136.01 301.63,136.01 arc(302.06,135.93) 302.44,135.68 357.49,80.63 arc(357.74,80.26) 357.82,79.82 357.82,69.78 arc(357.88,69.49) 358.05,69.24 360.86,66.43 arc(361.03,66.18) 361.08,65.89 361.08,58.66 arc(361.11,58.51) 361.2,58.39 364.08,55.51 arc(364.2,55.42) 364.35,55.39 373.59,55.39 arc(373.88,55.34) 374.13,55.17 374.22,55.08 arc(374.46,54.92) 374.76,54.86 375.66,54.86 arc(375.9,54.76) 376,54.52 376,54.34 arc(375.96,54.14) 375.85,53.97 YJ36.B5
FC61_RDN0: length 230.3
  TOP w0.147: U1.BY21 210.05,165.94 arc(210.07,166.04) 210.12,166.12 210.29,166.29 arc(210.35,166.33) 210.42,166.34 v4(210.5,166.34)
  SIG9 w0.112: 211.24,173.86 211.24,173.83 arc(211.17,173.73) 211.15,173.61 211.15,168.24 arc(211.11,168.02) 210.99,167.84 210.96,167.81 arc(210.81,167.72) 210.64,167.68 210.35,167.68 arc(210.27,167.67) 210.21,167.62 arc(210.16,167.56) 210.15,167.48 210.15,166.44 arc(210.18,166.37) 210.25,166.34 v4(210.5,166.34)
  SIG9 w0.16: YJ36.A24 367.7,64.84 arc(367.66,65.02) 367.56,65.17 367.09,65.65 arc(366.96,65.84) 366.91,66.07 366.91,66.48 arc(366.91,66.53) 366.9,66.57 arc(366.89,66.6) 366.89,66.62 arc(366.85,66.7) 366.79,66.77 366.75,66.82 366.59,66.97 arc(366.34,67.34) 366.26,67.78 366.26,68.19 arc(366.34,68.62) 366.59,68.99 366.98,69.39 arc(367.06,69.51) 367.09,69.66 367.09,70.16 366.84,70.42 366.84,70.93 367.09,71.18 367.09,71.69 366.84,71.94 366.84,72.45 367.09,72.7 367.09,73.21 366.87,73.44 366.87,74 367.09,74.23 367.09,76.67 arc(367.06,76.82) 366.98,76.94 362.67,81.26 327.09,116.84 306.25,137.68 arc(306.12,137.76) 305.98,137.79 297.08,137.79 arc(296.64,137.88) 296.27,138.13 254.71,179.69 arc(254.59,179.77) 254.44,179.8 240.57,179.8 arc(240.36,179.85) 240.18,179.96 237.04,183.1 236,184.15 arc(235.6,184.41) 235.14,184.5 218.54,184.5 arc(218.25,184.45) 218,184.28 211.47,177.74 arc(211.3,177.5) 211.24,177.21 211.24,176.4 211.5,176.14 211.5,175.76 211.24,175.51 211.24,175.13 211.5,174.87 211.5,174.49 211.24,174.24 211.24,173.86
FC61_RDN1: length 232.8
  TOP w0.147: U1.BV22 209.55,164.34 v4(209.6,164.34)
  SIG9 w0.112: 212.86,173.98 212.86,173.96 212.95,173.87 212.95,168.14 arc(212.94,168.06) 212.89,168 arc(212.83,167.95) 212.75,167.94 212.3,167.94 arc(212.18,167.91) 212.08,167.85 212.06,167.83 arc(211.98,167.71) 211.95,167.56 211.95,165.31 arc(211.93,165.18) 211.86,165.07 arc(211.75,165) 211.62,164.98 210.29,164.98 arc(210.07,164.88) 209.98,164.66 209.98,164.52 arc(209.92,164.4) 209.79,164.34 v4(209.6,164.34)
  SIG9 w0.16: YJ36.A14 368.65,61.97 arc(368.76,62.14) 368.8,62.34 368.8,62.52 arc(368.7,62.76) 368.46,62.86 367.68,62.86 arc(367.27,62.94) 366.93,63.17 arc(366.68,63.34) 366.39,63.39 365.1,63.39 arc(364.81,63.45) 364.56,63.62 363.89,64.29 arc(363.72,64.54) 363.66,64.83 363.66,65.34 363.67,65.34 arc(363.67,65.44) 363.69,65.54 arc(363.77,65.72) 363.89,65.88 364.33,66.32 arc(364.5,66.57) 364.55,66.86 364.55,74.23 arc(364.5,74.52) 364.33,74.77 362.87,76.23 arc(362.71,76.48) 362.65,76.77 362.65,78.29 arc(362.59,78.59) 362.43,78.83 305.47,135.79 arc(305.22,135.96) 304.93,136.01 296.19,136.01 arc(295.9,136.07) 295.65,136.24 254.01,177.88 arc(253.77,178.04) 253.47,178.1 240.83,178.1 arc(239.66,178.33) 238.67,179 235.05,182.62 arc(234.85,182.75) 234.61,182.8 219.38,182.8 arc(218.94,182.71) 218.57,182.47 213.19,177.09 arc(213,176.83) 212.88,176.52 arc(212.86,176.4) 212.86,176.28 212.86,173.98
FC61_RDN2: length 239.7
  TOP w0.147: U1.BT21 210.05,161.85 arc(210.09,162.04) 210.19,162.2 210.28,162.28 arc(210.34,162.33) 210.42,162.34 v4(210.5,162.34)
  SIG8 w0.112: v4(210.5,162.34) 210.25,162.34 arc(210.18,162.37) 210.15,162.44 210.15,162.66 arc(210.16,162.71) 210.18,162.74 arc(210.22,162.77) 210.26,162.78 210.64,162.78 arc(210.81,162.81) 210.95,162.91 210.98,162.94 arc(211.1,163.12) 211.14,163.33 211.14,173.51 211.24,173.6
  SIG8 w0.16: YJ36.A21 365.3,64.57 arc(365.21,65) 364.97,65.37 364.72,65.61 arc(364.57,65.85) 364.51,66.12 364.51,67.51 arc(364.58,67.87) 364.79,68.19 366.85,70.25 arc(366.94,70.37) 366.97,70.52 366.97,71.03 366.71,71.28 366.71,71.79 366.97,72.04 366.97,72.55 366.71,72.8 366.71,73.31 366.97,73.57 366.97,74.07 366.71,74.33 366.71,74.84 366.97,75.09 366.97,75.6 366.74,75.83 366.74,76.39 366.97,76.61 366.97,82.87 arc(366.91,83.16) 366.74,83.41 312.58,137.57 arc(312.33,137.73) 312.04,137.79 296.92,137.79 arc(296.63,137.85) 296.39,138.02 254.82,179.58 arc(254.57,179.75) 254.28,179.8 240.69,179.8 arc(240.28,179.89) 239.93,180.12 235.77,184.28 arc(235.52,184.44) 235.23,184.5 215.72,184.5 arc(215.43,184.45) 215.18,184.28 211.47,180.56 arc(211.3,180.32) 211.24,180.02 211.24,173.6
FC61_RDN3: length 239.7
  TOP w0.147: U1.BP22 209.55,160.34 v4(209.6,160.34)
  SIG8 w0.112: v4(209.6,160.34) 209.85,160.34 arc(209.92,160.37) 209.95,160.44 209.95,160.66 arc(209.97,160.78) 210.04,160.88 210.04,160.88 arc(210.14,160.95) 210.26,160.98 211.73,160.98 arc(211.82,160.99) 211.89,161.04 arc(211.94,161.11) 211.95,161.2 211.95,167.51 arc(211.99,167.67) 212.08,167.81 arc(212.22,167.9) 212.38,167.94 212.71,167.94 arc(212.8,167.96) 212.88,168.01 arc(212.93,168.09) 212.95,168.18 212.95,173.64 212.86,173.73 212.86,173.76
  SIG8 w0.16: 212.86,173.76 212.86,179.1 arc(212.95,179.54) 213.19,179.91 215.75,182.47 arc(216.12,182.71) 216.56,182.8 234.51,182.8 arc(234.82,182.74) 235.08,182.56 238.97,178.67 arc(239.6,178.25) 240.35,178.1 253.32,178.1 arc(253.75,178.02) 254.12,177.77 295.77,136.13 arc(295.89,136.04) 296.04,136.01 311.17,136.01 arc(311.61,135.93) 311.98,135.68 362.31,85.35 arc(362.56,84.98) 362.65,84.54 362.65,71.53 362.65,71.53 arc(362.71,71.24) 362.87,71 363.57,70.3 arc(363.73,70.05) 363.79,69.76 363.79,63.88 arc(363.82,63.69) 363.9,63.51 363.97,63.44 arc(364.03,63.4) 364.1,63.39 arc(364.33,63.31) 364.53,63.17 364.62,63.09 364.66,63.04 arc(364.66,63.04) 364.66,63.04 arc(364.69,63.01) 364.72,62.98 arc(364.81,62.9) 364.91,62.86 arc(364.94,62.86) 364.96,62.86 365.9,62.86 arc(366.1,62.82) 366.26,62.71 366.32,62.65 arc(366.38,62.56) 366.4,62.45 366.4,62.34 arc(366.36,62.14) 366.25,61.97 YJ36.A17
FC61_RDP0: length 230.3
  TOP w0.147: v4(209.6,166.34) 209.55,166.34 U1.BY22
  SIG9 w0.112: v4(209.6,166.34) 209.85,166.34 arc(209.92,166.37) 209.95,166.44 209.95,167.48 arc(209.98,167.63) 210.07,167.76 210.07,167.76 arc(210.2,167.85) 210.35,167.88 210.64,167.88 arc(210.74,167.9) 210.82,167.95 210.85,167.98 arc(210.93,168.1) 210.95,168.24 210.95,173.64 arc(210.93,173.76) 210.86,173.86
  SIG9 w0.16: 210.86,173.86 210.86,177.21 arc(210.95,177.64) 211.2,178.01 217.73,184.55 arc(218.1,184.8) 218.54,184.88 235.14,184.88 arc(235.75,184.76) 236.27,184.42 237.72,182.97 240.45,180.23 arc(240.5,180.2) 240.57,180.19 254.44,180.19 arc(254.73,180.13) 254.98,179.96 296.54,138.4 arc(296.79,138.23) 297.08,138.17 305.98,138.17 arc(306.27,138.12) 306.52,137.95 327.63,116.84 364.19,80.28 367.25,77.21 arc(367.42,76.97) 367.47,76.67 367.47,69.66 arc(367.42,69.36) 367.25,69.12 366.86,68.72 arc(366.69,68.48) 366.64,68.19 366.64,67.78 arc(366.69,67.49) 366.86,67.24 367.09,67.01 arc(367.26,66.9) 367.45,66.86 368.46,66.86 arc(368.7,66.76) 368.8,66.52 368.8,66.34 arc(368.76,66.14) 368.65,65.97 YJ36.A25
FC61_RDP1: length 232.8
  TOP w0.147: v4(210.5,164.34) 210.42,164.34 arc(210.35,164.33) 210.29,164.29 210.12,164.12 arc(210.07,164.04) 210.05,163.94 U1.BV21
  SIG9 w0.112: 213.24,173.98 213.24,173.96 213.15,173.86 213.15,168.14 arc(213.12,167.98) 213.03,167.86 arc(212.9,167.77) 212.75,167.74 212.3,167.74 arc(212.26,167.73) 212.22,167.71 212.2,167.69 arc(212.16,167.63) 212.15,167.56 212.15,165.31 arc(212.11,165.11) 212,164.93 arc(211.82,164.82) 211.62,164.78 210.29,164.78 arc(210.21,164.74) 210.17,164.66 210.17,164.44 arc(210.2,164.37) 210.27,164.34 v4(210.5,164.34)
  SIG9 w0.16: YJ36.A15 367.7,60.66 arc(367.63,61.01) 367.43,61.3 367.09,61.65 arc(366.96,61.84) 366.91,62.07 366.91,62.48 arc(366.91,62.54) 366.89,62.6 arc(366.85,62.7) 366.79,62.77 366.66,62.9 arc(366.54,62.98) 366.39,63.01 365.1,63.01 arc(364.66,63.1) 364.29,63.35 363.62,64.02 arc(363.37,64.39) 363.28,64.83 363.28,65.53 arc(363.29,65.58) 363.32,65.63 arc(363.44,65.91) 363.62,66.15 364.06,66.59 arc(364.14,66.72) 364.17,66.86 364.17,67.24 363.92,67.5 363.92,67.88 364.17,68.13 364.17,68.51 363.92,68.77 363.92,69.15 364.17,69.4 364.17,69.78 363.92,70.04 363.92,70.42 364.17,70.67 364.17,71.05 363.92,71.31 363.92,71.69 364.17,71.94 364.17,72.32 363.94,72.55 363.94,72.98 364.17,73.21 364.17,74.23 arc(364.14,74.38) 364.06,74.5 362.6,75.96 arc(362.35,76.33) 362.27,76.77 362.27,78.29 arc(362.24,78.44) 362.16,78.56 305.2,135.52 arc(305.07,135.6) 304.93,135.63 296.19,135.63 arc(295.76,135.72) 295.38,135.97 253.74,177.61 arc(253.62,177.69) 253.47,177.72 240.83,177.72 arc(239.52,177.98) 238.4,178.73 234.78,182.35 arc(234.7,182.4) 234.61,182.42 219.38,182.42 arc(219.09,182.36) 218.84,182.2 213.46,176.82 arc(213.33,176.65) 213.26,176.44 arc(213.24,176.36) 213.24,176.28 213.24,173.98
FC61_RDP2: length 239.7
  TOP w0.147: U1.BT22 209.55,162.34 v4(209.6,162.34)
  SIG8 w0.112: v4(209.6,162.34) 209.85,162.34 arc(209.92,162.37) 209.95,162.44 209.95,162.66 arc(209.97,162.78) 210.04,162.88 arc(210.14,162.95) 210.26,162.98 210.64,162.98 arc(210.73,162.99) 210.81,163.05 210.84,163.08 arc(210.92,163.2) 210.95,163.33 210.95,173.52 210.86,173.6
  SIG8 w0.16: YJ36.A22 366.25,65.97 arc(366.36,66.14) 366.4,66.34 366.4,66.45 arc(366.38,66.56) 366.32,66.65 366.26,66.71 arc(366.1,66.82) 365.9,66.86 365.23,66.86 arc(364.99,66.96) 364.89,67.2 364.89,67.51 arc(364.94,67.73) 365.06,67.92 367.12,69.98 arc(367.29,70.23) 367.35,70.52 367.35,82.87 arc(367.26,83.3) 367.01,83.68 312.85,137.84 arc(312.48,138.09) 312.04,138.17 296.92,138.17 arc(296.78,138.2) 296.65,138.29 255.09,179.85 arc(254.72,180.1) 254.28,180.19 240.69,180.19 arc(240.43,180.24) 240.2,180.39 236.04,184.55 arc(235.67,184.8) 235.23,184.88 215.72,184.88 arc(215.28,184.8) 214.91,184.55 211.2,180.83 arc(210.95,180.46) 210.86,180.02 210.86,173.6
FC61_RDP3: length 239.7
  TOP w0.147: U1.BP21 210.05,159.85 arc(210.09,160.04) 210.19,160.2 210.28,160.28 arc(210.34,160.33) 210.42,160.34 v4(210.5,160.34)
  SIG8 w0.112: v4(210.5,160.34) 210.25,160.34 arc(210.18,160.37) 210.15,160.44 210.15,160.66 arc(210.16,160.71) 210.18,160.74 arc(210.22,160.77) 210.26,160.78 211.73,160.78 arc(211.89,160.81) 212.03,160.9 arc(212.12,161.04) 212.15,161.2 212.15,167.51 arc(212.17,167.6) 212.22,167.67 arc(212.29,167.72) 212.38,167.74 212.71,167.74 arc(212.88,167.77) 213.02,167.87 arc(213.11,168.01) 213.15,168.18 213.15,173.64 213.24,173.73 213.24,173.76
  SIG8 w0.16: 213.24,173.76 213.24,179.1 arc(213.3,179.39) 213.46,179.64 216.02,182.2 arc(216.27,182.36) 216.56,182.42 234.51,182.42 arc(234.67,182.39) 234.81,182.29 238.7,178.4 arc(239.46,177.9) 240.35,177.72 253.32,177.72 arc(253.61,177.66) 253.86,177.5 295.5,135.86 arc(295.74,135.69) 296.04,135.63 311.17,135.63 arc(311.46,135.58) 311.71,135.41 362.04,85.08 arc(362.21,84.83) 362.27,84.54 362.27,79.15 362.04,78.93 362.04,78.37 362.27,78.14 362.27,77.63 362.04,77.4 362.04,76.84 362.27,76.61 362.27,76.11 362.01,75.85 362.01,75.34 362.27,75.09 362.27,74.58 362.01,74.33 362.01,73.82 362.27,73.57 362.27,73.06 362.01,72.8 362.01,72.3 362.27,72.04 362.27,71.53 arc(362.35,71.1) 362.6,70.73 363.3,70.03 arc(363.38,69.91) 363.41,69.76 363.41,63.88 arc(363.46,63.56) 363.6,63.27 363.7,63.17 arc(363.86,63.06) 364.06,63.01 arc(364.17,62.97) 364.26,62.9 364.35,62.82 364.39,62.77 arc(364.4,62.76) 364.42,62.74 arc(364.49,62.62) 364.51,62.48 364.51,62.14 arc(364.57,61.85) 364.73,61.6 365.07,61.27 arc(365.24,61.01) 365.3,60.71 YJ36.A18
FC61_TDN0: length 224.8
  TOP w0.147: U1.CF22 209.55,172.34 v4(209.6,172.34)
  SIG7 w0.112: v4(209.6,172.34) 209.78,172.52 arc(209.91,172.71) 209.95,172.93 209.95,173.62 209.86,173.71 209.86,173.73
  SIG7 w0.16: 209.86,173.73 209.86,176.99 arc(209.92,177.29) 210.08,177.53 213.04,180.5 arc(213.29,180.66) 213.58,180.72 234.2,180.72 arc(234.49,180.66) 234.73,180.5 234.91,180.32 arc(235.03,180.24) 235.18,180.21 251.37,180.21 arc(251.66,180.15) 251.91,179.99 289.29,142.6 arc(289.41,142.52) 289.56,142.49 304.83,142.49 arc(305.12,142.43) 305.37,142.27 369.13,78.51 arc(369.6,77.81) 369.76,76.99 369.76,74.96 arc(369.82,74.67) 369.98,74.42 373.38,71.03 arc(373.55,70.78) 373.6,70.49 373.6,68.24 arc(373.7,67.74) 373.99,67.31 374,67.3 arc(374.49,66.97) 375.06,66.86 375.66,66.86 arc(375.9,66.76) 376,66.52 376,66.34 arc(375.96,66.14) 375.85,65.97 YJ36.A34
FC61_TDN1: length 228.9
  TOP w0.147: U1.CD21 210.05,169.89 arc(210.18,170.21) v4(210.5,170.34)
  SIG6 w0.112: 209.24,173.98 209.24,173.96 209.14,173.86 209.14,171.18 arc(209.16,171.1) 209.2,171.04 arc(209.27,170.99) 209.35,170.98 209.79,170.98 arc(209.92,170.95) 210.04,170.87 210.05,170.86 arc(210.12,170.75) 210.15,170.63 210.15,170.47 arc(210.18,170.38) 210.27,170.34 v4(210.5,170.34)
  SIG6 w0.16: 209.24,173.98 209.24,175.38 arc(209.27,175.53) 209.35,175.65 213.92,180.23 arc(214.05,180.31) 214.19,180.34 234.24,180.34 arc(234.39,180.31) 234.51,180.23 234.57,180.16 arc(234.94,179.92) 235.38,179.83 251.37,179.83 arc(251.51,179.8) 251.64,179.72 288.91,142.45 arc(289.28,142.2) 289.72,142.11 304.83,142.11 arc(304.98,142.08) 305.1,142 372.86,74.24 372.86,73.93 373.21,73.59 373.52,73.59 374.42,72.69 374.42,72.37 374.76,72.03 375.07,72.03 375.41,71.69 375.41,71.38 375.75,71.04 376.06,71.04 376.4,70.7 arc(376.48,70.58) 376.51,70.43 376.51,69.81 376.29,69.58 376.29,69.1 376.51,68.88 376.51,68.4 376.29,68.18 376.29,67.7 376.51,67.48 376.51,66.07 arc(376.56,65.84) 376.69,65.65 377.11,65.23 arc(377.25,65.01) 377.3,64.76 YJ36.A36
FC61_TDN2: length 233
  TOP w0.147: U1.CB22 209.55,168.34 v4(209.6,168.34)
  SIG6 w0.112: 210.86,173.73 210.86,173.7 210.95,173.61 210.95,169.18 arc(210.94,169.1) 210.89,169.04 arc(210.83,168.99) 210.75,168.98 210.31,168.98 arc(210.17,168.95) 210.06,168.87 210.05,168.86 arc(209.98,168.75) 209.95,168.63 209.95,168.47 arc(209.91,168.38) 209.82,168.34 v4(209.6,168.34)
  SIG6 w0.16: 210.86,173.73 210.86,174.37 arc(210.92,174.66) 211.08,174.9 214.59,178.41 arc(214.84,178.58) 215.13,178.64 233.3,178.64 arc(233.59,178.58) 233.84,178.41 233.9,178.35 arc(234.15,178.19) 234.44,178.13 250.4,178.13 arc(250.69,178.07) 250.94,177.9 288.29,140.56 arc(288.54,140.39) 288.83,140.33 303.66,140.33 arc(304.1,140.25) 304.47,140 362.3,82.17 arc(362.46,81.92) 362.52,81.63 362.52,77.55 arc(362.58,77.26) 362.75,77.02 363.5,76.26 arc(363.66,76.02) 363.72,75.72 363.72,64.58 arc(363.75,64.44) 363.83,64.31 364.64,63.51 arc(364.76,63.42) 364.91,63.39 373.59,63.39 arc(373.88,63.34) 374.13,63.17 374.22,63.08 arc(374.46,62.92) 374.76,62.86 375.66,62.86 arc(375.9,62.76) 376,62.52 376,62.34 arc(375.96,62.14) 375.85,61.97 YJ36.A5
FC61_TDN3: length 235.2
  TOP w0.147: U1.CE19 212.05,170.89 arc(212.18,171.21) v4(212.5,171.34)
  SIG7 w0.112: v4(212.5,171.34) 212.31,171.34 arc(212.2,171.39) 212.15,171.51 212.15,171.63 arc(212.12,171.75) 212.05,171.86 212.04,171.87 arc(211.92,171.95) 211.79,171.98 211.35,171.98 arc(211.27,171.99) 211.2,172.04 arc(211.16,172.1) 211.14,172.18 211.14,172.49 arc(211.19,172.71) 211.31,172.89 211.5,173.08 arc(211.61,173.24) 211.65,173.43 211.65,173.68 arc(211.66,173.73) 211.68,173.78 211.74,173.83 211.74,173.86
  SIG7 w0.16: YJ36.A3 377.3,60.77 arc(377.25,61.01) 377.12,61.22 376.69,61.65 arc(376.56,61.84) 376.51,62.07 376.51,62.48 arc(376.51,62.53) 376.5,62.58 arc(376.46,62.68) 376.39,62.77 376.35,62.82 376.26,62.9 arc(376.14,62.98) 375.99,63.01 364.87,63.01 arc(364.43,63.1) 364.06,63.35 363.68,63.74 arc(363.43,64.11) 363.34,64.54 363.34,65.8 arc(363.43,66.24) 363.68,66.61 364,66.94 364,67.23 364.31,67.55 364.61,67.55 364.93,67.87 364.93,68.19 365.22,68.48 365.54,68.48 366.6,69.54 arc(366.68,69.66) 366.71,69.81 366.71,70.26 366.51,70.47 366.51,70.93 366.71,71.13 366.71,71.6 366.51,71.8 366.51,72.26 366.71,72.46 366.71,72.92 366.51,73.12 366.51,73.58 366.71,73.78 366.71,74.24 366.51,74.44 366.51,74.9 366.71,75.11 366.71,76.55 arc(366.59,77.16) 366.24,77.68 304.09,139.84 arc(303.96,139.92) 303.82,139.95 288.67,139.95 arc(288.38,140.01) 288.13,140.17 250.67,177.63 arc(250.55,177.72) 250.4,177.75 234.31,177.75 arc(234.02,177.8) 233.77,177.97 233.6,178.14 arc(233.48,178.23) 233.33,178.25 215.18,178.25 arc(215.04,178.23) 214.91,178.14 211.85,175.08 arc(211.77,174.96) 211.74,174.81 211.74,173.86
FC61_TDP0: length 224.8
  TOP w0.147: U1.CF21 210.05,171.89 arc(210.18,172.21) v4(210.5,172.34)
  SIG7 w0.112: 210.24,173.73 210.24,173.71 210.15,173.62 210.15,172.93 arc(210.19,172.71) 210.31,172.52 v4(210.5,172.34)
  SIG7 w0.155: 374.2,65.76 arc(374.13,65.91) 374.11,66.07
  SIG7 w0.16: YJ36.A33 374.9,64.7 arc(374.84,65.01) 374.66,65.27 374.34,65.6 arc(374.26,65.68) 374.2,65.76 ; 374.11,66.07 374.11,66.3 arc(374.1,66.41) 374.08,66.52 arc(374.08,66.52) 374.08,66.52 arc(374.08,66.53) 374.07,66.54 arc(374.07,66.55) 374.07,66.56 arc(374.07,66.56) 374.07,66.56 arc(374.06,66.58) 374.06,66.59 arc(374.06,66.6) 374.06,66.6 arc(373.97,66.76) 373.86,66.9 373.72,67.04 arc(373.35,67.59) 373.22,68.24 373.22,68.7 373.02,68.9 373.02,69.36 373.22,69.56 373.22,70.49 arc(373.19,70.64) 373.11,70.76 372.53,71.34 372.24,71.34 371.92,71.67 371.92,71.95 371.59,72.28 371.31,72.28 370.98,72.6 370.98,72.89 370.65,73.22 370.43,73.22 370.04,73.61 370.04,73.83 369.71,74.16 arc(369.47,74.53) 369.38,74.96 369.38,75.44 369.23,75.59 369.23,76.15 369.38,76.3 369.38,76.99 arc(369.24,77.67) 368.86,78.24 368.21,78.89 367.98,78.89 367.6,79.27 367.6,79.5 367.21,79.89 366.98,79.89 366.6,80.27 366.6,80.5 305.1,142 arc(304.98,142.08) 304.83,142.11 289.56,142.11 arc(289.27,142.17) 289.02,142.33 251.64,179.72 arc(251.51,179.8) 251.37,179.83 235.18,179.83 arc(234.89,179.89) 234.64,180.05 234.47,180.23 arc(234.34,180.31) 234.2,180.34 213.58,180.34 arc(213.44,180.31) 213.31,180.23 210.35,177.26 arc(210.27,177.14) 210.24,176.99 210.24,173.73
FC61_TDP1: length 228.9
  TOP w0.147: U1.CD22 209.55,170.34 v4(209.6,170.34)
  SIG6 w0.112: 208.86,173.98 208.86,173.96 208.95,173.87 208.95,171.18 arc(208.98,171.03) 209.06,170.9 arc(209.19,170.81) 209.35,170.78 209.79,170.78 arc(209.85,170.77) 209.9,170.73 209.91,170.72 arc(209.94,170.68) 209.95,170.63 209.95,170.47 arc(209.91,170.38) 209.82,170.34 v4(209.6,170.34)
  SIG6 w0.16: 208.86,173.98 208.86,175.38 arc(208.91,175.67) 209.08,175.92 213.65,180.5 arc(213.9,180.66) 214.19,180.72 234.24,180.72 arc(234.53,180.66) 234.78,180.5 234.84,180.43 arc(235.09,180.27) 235.38,180.21 251.37,180.21 arc(251.66,180.15) 251.91,179.99 289.18,142.71 arc(289.42,142.55) 289.72,142.49 304.83,142.49 arc(305.12,142.43) 305.37,142.27 374.69,72.96 376.67,70.97 arc(376.83,70.72) 376.89,70.43 376.89,67.05 arc(376.95,66.92) 377.08,66.86 378.06,66.86 arc(378.3,66.76) 378.4,66.52 378.4,66.34 arc(378.36,66.14) 378.25,65.97 YJ36.A37
FC61_TDP2: length 233
  TOP w0.147: U1.CB21 210.05,167.89 arc(210.18,168.21) v4(210.5,168.34)
  SIG6 w0.112: 211.24,173.73 211.24,173.7 211.15,173.61 211.15,169.18 arc(211.12,169.03) 211.03,168.9 arc(210.9,168.81) 210.75,168.78 210.31,168.78 arc(210.25,168.77) 210.2,168.73 210.19,168.72 arc(210.16,168.68) 210.15,168.63 210.15,168.47 arc(210.18,168.38) 210.27,168.34 v4(210.5,168.34)
  SIG6 w0.155: 374.18,61.8 arc(374.13,61.93) 374.11,62.07
  SIG6 w0.16: YJ36.A6 374.9,60.85 arc(374.87,61.02) 374.77,61.16 374.69,61.24 374.51,61.43 374.32,61.62 arc(374.24,61.7) 374.18,61.8 ; 374.11,62.07 374.11,62.48 arc(374.11,62.53) 374.1,62.58 arc(374.06,62.68) 373.99,62.77 373.95,62.82 373.86,62.9 arc(373.74,62.98) 373.59,63.01 364.91,63.01 arc(364.62,63.07) 364.37,63.24 363.56,64.04 arc(363.4,64.29) 363.34,64.58 363.34,69.51 363.12,69.73 363.12,70.21 363.34,70.44 363.34,70.92 363.12,71.14 363.12,71.62 363.34,71.84 363.34,72.32 363.12,72.54 363.12,73.02 363.34,73.24 363.34,73.72 363.12,73.94 363.12,74.42 363.34,74.64 363.34,75.72 arc(363.31,75.87) 363.23,75.99 362.48,76.75 arc(362.23,77.12) 362.14,77.55 362.14,78.28 361.97,78.45 361.97,79.03 362.14,79.2 362.14,79.68 361.97,79.85 361.97,80.43 362.14,80.6 362.14,81.63 arc(362.11,81.77) 362.03,81.9 304.2,139.73 arc(303.95,139.89) 303.66,139.95 288.83,139.95 arc(288.39,140.04) 288.02,140.29 250.67,177.63 arc(250.55,177.72) 250.4,177.75 234.44,177.75 arc(234,177.83) 233.63,178.08 233.57,178.14 arc(233.45,178.23) 233.3,178.25 215.13,178.25 arc(214.99,178.23) 214.86,178.14 211.35,174.64 arc(211.27,174.51) 211.24,174.37 211.24,173.73
FC61_TDP3: length 235.2
  TOP w0.147: U1.CE20 211.55,171.34 v4(211.6,171.34)
  SIG7 w0.112: 211.36,173.86 211.36,173.83 211.45,173.74 211.45,173.43 arc(211.43,173.32) 211.36,173.22 211.17,173.03 arc(211.01,172.78) 210.95,172.49 210.95,172.18 arc(210.98,172.03) 211.06,171.9 arc(211.19,171.81) 211.35,171.78 211.79,171.78 arc(211.85,171.77) 211.9,171.73 211.91,171.72 arc(211.94,171.68) 211.95,171.63 211.95,171.49 arc(211.91,171.38) 211.8,171.34 v4(211.6,171.34)
  SIG7 w0.16: YJ36.A2 378.25,61.97 arc(378.36,62.14) 378.4,62.34 378.4,62.52 arc(378.3,62.76) 378.06,62.86 377.16,62.86 arc(376.86,62.92) 376.62,63.08 376.53,63.17 arc(376.28,63.34) 375.99,63.39 364.87,63.39 arc(364.58,63.45) 364.33,63.62 363.94,64 arc(363.78,64.25) 363.72,64.54 363.72,65.8 arc(363.78,66.1) 363.94,66.34 366.87,69.27 arc(367.04,69.52) 367.09,69.81 367.09,76.55 arc(366.94,77.31) 366.51,77.95 304.36,140.11 arc(304.11,140.27) 303.82,140.33 288.67,140.33 arc(288.52,140.36) 288.4,140.44 250.94,177.9 arc(250.69,178.07) 250.4,178.13 234.31,178.13 arc(234.17,178.16) 234.04,178.24 233.87,178.41 arc(233.62,178.58) 233.33,178.64 215.18,178.64 arc(214.89,178.58) 214.64,178.41 211.58,175.35 arc(211.41,175.1) 211.36,174.81 211.36,173.86
FC62_63_PVDD0P8: length 5.5
  TOP w0.229: U1.BG27 v1(204.55,153.34) ; U1.BG29 v1(202.55,153.34)
  TOP w0.381: 216.64,193.39 C2929.1 ; C2929.1 217.23,194.03 ; C2929.1 217.83,193.39
  BOTTOM w0.13: v1(216.22,194.18) v2(215.46,194.18)
  BOTTOM w0.381: v1(204.55,153.34) 204.54,153.34 C2872.1 ; v1(202.55,153.34) 202.05,153.84 C1143.1
  vias: v1(216.22,193.16)
FC62_RDN0: length 241.9
  TOP w0.147: U1.BY24 207.05,165.87 arc(207.09,166.05) 207.19,166.2 207.27,166.28 arc(207.33,166.33) 207.41,166.34 v4(207.5,166.34)
  SIG3 w0.112: 207.24,173.88 207.24,173.86 207.15,173.76 207.15,166.75 arc(207.16,166.7) 207.18,166.66 v4(207.5,166.34)
  SIG3 w0.16: 207.24,173.88 207.24,174.68 arc(207.3,174.97) 207.46,175.21 214.45,182.2 arc(214.69,182.36) 214.98,182.42 235.66,182.42 arc(235.95,182.36) 236.2,182.2 240.45,177.94 arc(240.7,177.78) 240.99,177.72 250.43,177.72 arc(250.57,177.69) 250.7,177.61 285.86,142.45 arc(286.23,142.2) 286.67,142.11 304.85,142.11 arc(305,142.08) 305.12,142 376.24,70.88 376.24,70.52 376.51,70.25 376.87,70.25 377.14,69.98 377.14,69.62 377.41,69.36 377.77,69.36 378.03,69.09 378.03,68.65 378.36,68.33 378.79,68.33 379.11,68.01 379.11,67.55 379.41,67.25 379.87,67.25 380.19,66.93 arc(380.27,66.81) 380.3,66.66 380.3,66.1 380.05,65.85 380.05,65.46 380.3,65.21 380.3,64.83 arc(380.27,64.68) 380.19,64.56 379.79,64.16 379.36,64.16 379.04,63.84 379.04,63.41 378.72,63.08 arc(378.47,62.92) 378.18,62.86 377.27,62.86 arc(377.08,62.79) 377.01,62.6 377.01,62.44 arc(377.07,62.14) 377.23,61.89 YJ35.C17
FC62_RDN1: length 233.3
  TOP w0.147: v4(206.6,164.34) 206.55,164.34 U1.BV25
  SIG3 w0.112: 208.86,173.56 208.86,173.53 208.95,173.44 208.95,165.17 arc(208.94,165.1) 208.9,165.03 arc(208.83,164.99) 208.76,164.98 207.29,164.98 arc(207.05,164.88) 206.95,164.64 206.95,164.47 arc(206.91,164.38) 206.82,164.34 v4(206.6,164.34)
  SIG3 w0.16: 208.86,173.56 208.86,173.76 arc(208.91,174.07) 209.04,174.37 arc(209.11,174.47) 209.2,174.57 215.01,180.38 arc(215.38,180.63) 215.82,180.72 233.68,180.72 arc(234.59,180.54) 235.36,180.02 239.34,176.04 arc(239.39,176.01) 239.45,175.99 249.49,175.99 arc(249.78,175.94) 250.03,175.77 285.24,140.56 arc(285.49,140.39) 285.78,140.33 303.84,140.33 arc(304.13,140.27) 304.38,140.11 376.26,68.22 arc(376.43,67.98) 376.48,67.68 376.48,66 arc(376.45,65.83) 376.36,65.69 375.84,65.18 arc(375.74,65.02) 375.7,64.83 YJ35.C24
FC62_RDN2: length 236.4
  TOP w0.147: U1.BT24 207.05,161.94 arc(207.07,162.04) 207.12,162.12 207.29,162.29 arc(207.35,162.33) 207.42,162.34 v4(207.5,162.34)
  SIG2 w0.112: v4(207.5,162.34) 207.27,162.34 arc(207.18,162.38) 207.15,162.47 207.15,162.64 arc(207.19,162.74) 207.29,162.78 208.76,162.78 arc(208.91,162.81) 209.04,162.89 arc(209.12,163.02) 209.15,163.17 209.15,173.51 209.24,173.61
  SIG2 w0.16: 209.24,173.61 209.24,173.84 arc(209.27,173.99) 209.36,174.11 210.06,174.81 arc(211.37,175.94) 212.83,176.87 arc(215.51,177.9) 218.37,178.25 229.8,178.25 arc(230.09,178.2) 230.33,178.03 232.5,175.86 arc(232.75,175.7) 233.04,175.64 249.3,175.64 arc(249.59,175.58) 249.84,175.42 285.08,140.17 arc(285.33,140.01) 285.62,139.95 303.68,139.95 arc(303.97,139.89) 304.22,139.73 367.49,76.46 367.49,76.12 367.87,75.74 368.21,75.74 368.57,75.38 368.57,75.04 368.95,74.66 369.29,74.66 369.64,74.3 369.64,73.97 370.03,73.58 370.36,73.58 370.72,73.22 370.72,72.89 371.11,72.5 371.44,72.5 371.8,72.15 371.8,71.81 372.19,71.43 372.52,71.43 372.88,71.07 372.88,70.73 373.26,70.35 373.6,70.35 373.99,69.95 arc(374.36,69.71) 374.8,69.62 376.65,69.62 376.85,69.42 377.46,69.42 377.67,69.62 378.18,69.62 arc(378.31,69.59) 378.42,69.52 arc(378.5,69.4) 378.53,69.27 378.53,68.72 378.3,68.49 378.3,67.93 378.53,67.7 378.53,67.19 arc(378.5,67.07) 378.43,66.96 arc(378.42,66.95) 378.42,66.95 arc(378.32,66.88) 378.19,66.86 377.3,66.86 arc(377.09,66.78) 377.01,66.57 377.01,66.32 arc(377.04,66.13) 377.15,65.97 YJ35.C22
FC62_RDN3: length 252.8
  TOP w0.147: U1.BP25 206.55,160.34 v4(206.6,160.34)
  SIG2 w0.112: 206.86,173.61 206.86,173.58 206.95,173.49 206.95,168.15 arc(206.93,168.05) 206.88,167.98 arc(206.8,167.92) 206.71,167.9 206.36,167.9 arc(206.2,167.87) 206.07,167.79 arc(205.98,167.66) 205.95,167.5 205.95,161.23 arc(205.99,161.06) 206.08,160.91 arc(206.23,160.81) 206.4,160.78 206.81,160.78 arc(206.86,160.77) 206.91,160.74 arc(206.94,160.69) 206.95,160.63 206.95,160.47 arc(206.91,160.38) 206.82,160.34 v4(206.6,160.34)
  SIG2 w0.16: YJ35.C15 375.7,60.75 arc(375.75,61.01) 375.9,61.24 376.26,61.59 arc(376.44,61.87) 376.51,62.19 376.51,62.57 arc(376.54,62.72) 376.63,62.86 376.68,62.91 arc(376.73,62.95) 376.78,62.98 arc(376.86,63.01) 376.95,63.03 379.82,63.03 arc(380.26,63.11) 380.63,63.36 380.93,63.67 arc(381.18,64.04) 381.27,64.47 381.27,69.71 arc(381.18,70.15) 380.93,70.52 379.65,71.8 arc(379.28,72.05) 378.84,72.13 375.68,72.13 arc(375.54,72.16) 375.41,72.25 305.5,142.16 arc(305.13,142.4) 304.69,142.49 286.51,142.49 arc(286.36,142.52) 286.24,142.6 251.08,177.77 arc(250.71,178.02) 250.27,178.1 234.14,178.1 arc(233.99,178.13) 233.87,178.21 231.7,180.38 arc(231.33,180.63) 230.89,180.72 218.32,180.72 arc(214.57,180.21) 211.09,178.74 arc(210.07,178.07) 209.11,177.32 arc(208.7,176.95) 208.3,176.57 207.2,175.46 arc(206.95,175.09) 206.86,174.65 206.86,173.61
FC62_RDP0: length 241.9
  TOP w0.147: v4(206.6,166.34) 206.55,166.34 U1.BY25
  SIG3 w0.112: v4(206.6,166.34) 206.91,166.66 arc(206.94,166.7) 206.95,166.75 206.95,173.76 206.86,173.86 206.86,173.88
  SIG3 w0.16: 206.86,173.88 206.86,174.68 arc(206.95,175.11) 207.19,175.48 214.18,182.47 arc(214.55,182.71) 214.98,182.8 235.66,182.8 arc(236.1,182.71) 236.47,182.47 240.72,178.21 arc(240.85,178.13) 240.99,178.1 250.43,178.1 arc(250.72,178.04) 250.97,177.88 286.13,142.71 arc(286.38,142.55) 286.67,142.49 304.85,142.49 arc(305.14,142.43) 305.39,142.27 380.46,67.2 arc(380.62,66.95) 380.68,66.66 380.68,64.83 arc(380.62,64.54) 380.46,64.29 379.03,62.86 arc(378.94,62.72) 378.91,62.57 378.91,62.08 arc(378.86,61.86) 378.74,61.67 378.28,61.21 arc(378.27,61.21) 378.27,61.21 arc(378.14,61.01) 378.1,60.79 YJ35.C18
FC62_RDP1: length 233.3
  TOP w0.147: v4(207.5,164.34) 207.4,164.34 arc(207.32,164.32) 207.24,164.28 207.18,164.21 arc(207.08,164.07) 207.05,163.9 U1.BV24
  SIG3 w0.112: v4(207.5,164.34) 207.27,164.34 arc(207.18,164.38) 207.15,164.47 207.15,164.64 arc(207.19,164.74) 207.29,164.78 208.76,164.78 arc(208.91,164.81) 209.04,164.89 arc(209.12,165.02) 209.15,165.17 209.15,173.44 209.24,173.53 209.24,173.56
  SIG3 w0.16: YJ35.C25 374.75,65.97 arc(374.64,66.13) 374.61,66.32 374.61,66.6 arc(374.68,66.78) 374.87,66.86 375.91,66.86 arc(376.05,66.92) 376.1,67.06 376.1,67.68 arc(376.07,67.83) 375.99,67.95 375.63,68.31 375.2,68.31 374.84,68.67 374.84,69.1 374.48,69.46 374.05,69.46 373.69,69.82 373.69,70.25 373.33,70.61 372.9,70.61 372.54,70.97 372.54,71.4 304.11,139.84 arc(303.98,139.92) 303.84,139.95 285.78,139.95 arc(285.34,140.04) 284.97,140.29 249.76,175.5 arc(249.63,175.58) 249.49,175.61 239.45,175.61 arc(239.25,175.65) 239.07,175.77 235.09,179.75 arc(234.44,180.19) 233.68,180.34 215.82,180.34 arc(215.53,180.28) 215.28,180.11 212.91,177.75 212.91,177.34 212.53,176.95 212.12,176.95 211.76,176.6 211.76,176.19 211.38,175.81 210.97,175.81 210.62,175.45 210.62,175.01 210.26,174.66 209.82,174.66 209.47,174.3 arc(209.41,174.23) 209.36,174.16 arc(209.27,173.97) 209.24,173.76 209.24,173.56
FC62_RDP2: length 236.4
  TOP w0.147: v4(206.6,162.34) 206.55,162.34 U1.BT25
  SIG2 w0.112: v4(206.6,162.34) 206.82,162.34 arc(206.91,162.38) 206.95,162.47 206.95,162.64 arc(207.05,162.88) 207.29,162.98 208.76,162.98 arc(208.83,162.99) 208.9,163.03 arc(208.94,163.1) 208.95,163.17 208.95,173.52 208.86,173.61
  SIG2 w0.16: 208.86,173.61 208.86,173.84 arc(208.92,174.13) 209.09,174.38 209.79,175.08 arc(211.14,176.25) 212.65,177.2 arc(215.42,178.27) 218.37,178.64 229.8,178.64 arc(230.23,178.55) 230.6,178.3 232.77,176.13 arc(232.9,176.05) 233.04,176.02 249.3,176.02 arc(249.74,175.93) 250.11,175.68 285.35,140.44 arc(285.48,140.36) 285.62,140.33 303.68,140.33 arc(304.12,140.25) 304.49,140 374.26,70.22 arc(374.51,70.06) 374.8,70 378.18,70 arc(378.69,69.79) 378.91,69.27 378.91,66.08 arc(378.86,65.86) 378.74,65.67 378.25,65.19 arc(378.14,65.02) 378.1,64.82 YJ35.C21
FC62_RDP3: length 252.8
  TOP w0.147: v4(207.5,160.34) 207.42,160.34 arc(207.35,160.33) 207.29,160.29 207.12,160.12 arc(207.07,160.04) 207.05,159.94 U1.BP24
  SIG2 w0.112: v4(207.5,160.34) 207.27,160.34 arc(207.18,160.38) 207.15,160.47 207.15,160.63 arc(207.12,160.76) 207.05,160.88 arc(206.94,160.95) 206.81,160.98 206.4,160.98 arc(206.31,160.99) 206.22,161.05 arc(206.17,161.13) 206.15,161.23 206.15,167.5 arc(206.17,167.58) 206.21,167.65 arc(206.28,167.69) 206.36,167.71 206.71,167.71 arc(206.88,167.74) 207.02,167.84 arc(207.12,167.98) 207.15,168.15 207.15,173.49 207.24,173.58 207.24,173.61
  SIG2 w0.16: YJ35.C14 374.75,61.97 arc(374.64,62.13) 374.61,62.32 374.61,62.53 arc(374.7,62.76) 374.94,62.86 375.78,62.86 arc(375.87,62.87) 375.95,62.88 arc(376.15,62.96) 376.31,63.08 376.36,63.13 376.41,63.18 arc(376.5,63.26) 376.6,63.32 arc(376.77,63.38) 376.95,63.41 379.82,63.41 arc(380.11,63.46) 380.36,63.63 380.66,63.93 arc(380.83,64.18) 380.89,64.47 380.89,64.98 380.63,65.24 380.63,65.74 380.89,66 380.89,66.51 380.63,66.76 380.63,67.27 380.89,67.52 380.89,68.03 380.63,68.28 380.63,68.79 380.89,69.05 380.89,69.71 arc(380.83,70) 380.66,70.25 379.38,71.53 arc(379.13,71.69) 378.84,71.75 375.68,71.75 arc(375.39,71.81) 375.14,71.98 305.23,141.89 arc(304.99,142.05) 304.69,142.11 286.51,142.11 arc(286.22,142.17) 285.97,142.33 250.81,177.5 arc(250.56,177.66) 250.27,177.72 234.14,177.72 arc(233.84,177.78) 233.6,177.94 231.43,180.11 arc(231.18,180.28) 230.89,180.34 224.42,180.34 224.19,180.11 223.63,180.11 223.4,180.34 222.89,180.34 222.67,180.11 222.11,180.11 221.88,180.34 221.37,180.34 221.14,180.11 220.58,180.11 220.35,180.34 219.85,180.34 219.59,180.08 219.08,180.08 218.83,180.34 218.32,180.34 arc(214.68,179.85) 211.29,178.41 arc(210.29,177.76) 209.36,177.03 arc(208.96,176.67) 208.57,176.3 207.47,175.19 arc(207.3,174.94) 207.24,174.65 207.24,173.61
FC62_TDN0: length 244.4
  TOP w0.147: v4(205.6,170.34) 205.55,170.34 U1.CD26
  SIG5 w0.112: 206.86,173.86 206.86,173.83 206.95,173.74 206.95,171.18 arc(206.94,171.1) 206.89,171.04 arc(206.83,170.99) 206.75,170.98 206.31,170.98 arc(206.17,170.95) 206.06,170.87 206.05,170.86 arc(205.98,170.75) 205.95,170.63 205.95,170.47 arc(205.91,170.38) 205.82,170.34 v4(205.6,170.34)
  SIG5 w0.155: 369.31,61.97 arc(369.3,61.91) 369.28,61.84
  SIG5 w0.16: 206.86,173.86 206.86,174.37 arc(206.95,174.81) 207.2,175.18 209.55,177.54 arc(209.92,177.79) 210.36,177.87 213.79,177.87 arc(213.94,177.9) 214.06,177.99 214.38,178.3 arc(214.75,178.55) 215.19,178.64 235.16,178.64 arc(235.45,178.58) 235.7,178.41 237.87,176.24 arc(238.12,176.08) 238.41,176.02 252.35,176.02 arc(252.79,175.93) 253.16,175.68 290.56,138.29 arc(290.68,138.2) 290.83,138.17 309.01,138.17 arc(309.45,138.09) 309.82,137.84 379.86,67.8 arc(380.11,67.43) 380.19,66.99 380.19,64.17 arc(380.14,63.88) 379.97,63.63 379.59,63.25 arc(379.34,63.08) 379.05,63.03 369.75,63.03 arc(369.61,63) 369.48,62.91 369.43,62.86 arc(369.35,62.75) 369.31,62.63 arc(369.31,62.6) 369.31,62.57 369.31,61.97 ; YJ35.C6 368.5,60.78 arc(368.55,61.02) 368.68,61.21 369.19,61.72 arc(369.24,61.78) 369.28,61.84
FC62_TDN1: length 247.2
  TOP w0.147: v4(206.5,168.34) 206.4,168.34 arc(206.31,168.32) 206.24,168.27 206.18,168.21 arc(206.08,168.07) 206.05,167.9 U1.CB25
  SIG4 w0.112: 207.24,174.04 207.24,174.01 207.15,173.92 207.15,169.25 arc(207.11,169.07) 207.01,168.92 arc(206.86,168.81) 206.68,168.78 206.3,168.78 arc(206.24,168.77) 206.19,168.73 arc(206.16,168.68) 206.15,168.62 206.15,168.47 arc(206.18,168.38) 206.27,168.34 v4(206.5,168.34)
  SIG4 w0.16: YJ35.C2 365.15,61.97 arc(365.04,62.13) 365.01,62.32 365.01,62.58 arc(365.09,62.78) 365.28,62.86 366.18,62.86 arc(366.47,62.92) 366.72,63.08 366.76,63.13 366.81,63.18 arc(367.06,63.35) 367.35,63.41 379.06,63.41 arc(379.21,63.44) 379.33,63.52 379.69,63.88 arc(379.78,64) 379.81,64.15 379.81,65.59 379.6,65.79 379.6,66.4 379.81,66.6 379.81,67.11 arc(379.78,67.26) 379.69,67.38 379.34,67.74 379,67.74 378.62,68.13 378.62,68.46 378.26,68.82 377.9,68.82 377.54,69.18 377.54,69.54 377.18,69.9 376.82,69.9 376.46,70.26 376.46,70.61 376.1,70.97 375.74,70.97 375.38,71.33 375.38,71.69 375.02,72.05 374.66,72.05 374.31,72.41 374.31,72.77 373.6,73.48 373.24,73.48 372.88,73.84 372.88,74.19 313.11,133.97 312.05,135.03 arc(306.59,138.67) 300.16,139.95 298.72,139.95 arc(289.17,141.85) 281.06,147.27 250.72,177.61 arc(250.6,177.69) 250.45,177.72 240.36,177.72 arc(239.93,177.81) 239.56,178.06 239.47,178.14 arc(239.35,178.23) 239.2,178.25 215,178.25 arc(214.86,178.23) 214.73,178.14 213.33,176.74 arc(213.18,176.61) 213.01,176.51 arc(212.77,176.43) 212.52,176.4 208.99,176.4 arc(208.7,176.34) 208.45,176.18 207.47,175.19 arc(207.3,174.94) 207.24,174.65 207.24,174.04
FC62_TDN2: length 218.3
  TOP w0.147: v4(207.6,171.34) 207.55,171.34 U1.CE24
  SIG5 w0.112: v4(207.6,171.34) 207.75,171.34 arc(207.84,171.38) 207.87,171.47 207.87,171.63 arc(207.9,171.75) 207.97,171.86 207.98,171.87 arc(208.1,171.95) 208.24,171.98 208.75,171.98 arc(208.83,171.99) 208.89,172.04 arc(208.94,172.1) 208.95,172.18 208.95,173.37 arc(209,173.59) 209.12,173.77 209.18,173.84 209.18,173.96 209.2,173.98
  SIG5 w0.155: 369.31,65.97 arc(369.29,65.88) 369.25,65.8
  SIG5 w0.16: 369.31,65.97 369.31,67.85 arc(369.25,68.14) 369.08,68.39 367.7,69.78 arc(367.53,70.02) 367.48,70.32 367.47,70.32 367.47,76.54 arc(367.39,76.97) 367.14,77.34 360.25,84.23 308.8,135.68 arc(308.43,135.93) 308,136.01 289.94,136.01 arc(289.79,136.04) 289.67,136.13 252.22,173.58 arc(251.85,173.82) 251.41,173.91 237.57,173.91 arc(237.28,173.97) 237.03,174.13 234.84,176.33 arc(234.59,176.49) 234.3,176.55 215.89,176.55 arc(215.6,176.49) 215.35,176.33 213.87,174.85 arc(213.62,174.68) 213.33,174.62 210.45,174.62 arc(209.89,174.51) 209.41,174.19 209.2,173.98 ; YJ35.C33 368.5,64.8 arc(368.54,65.02) 368.66,65.2 369.14,65.67 arc(369.2,65.73) 369.25,65.8
FC62_TDN3: length 218.1
  TOP w0.147: U1.CC23 208.05,168.9 arc(208.08,169.07) 208.18,169.21 208.24,169.27 arc(208.31,169.32) 208.4,169.34 v4(208.5,169.34)
  SIG4 w0.112: 209.24,173.58 209.24,173.55 209.15,173.46 209.15,170.25 arc(209.11,170.07) 209.01,169.92 arc(208.86,169.81) 208.68,169.78 208.3,169.78 arc(208.24,169.77) 208.19,169.73 arc(208.16,169.68) 208.15,169.62 208.15,169.47 arc(208.18,169.38) 208.27,169.34 v4(208.5,169.34)
  SIG4 w0.16: YJ35.C37 365.15,65.97 arc(365.04,66.13) 365.01,66.32 365.01,66.59 arc(365.09,66.78) 365.28,66.86 366.33,66.86 arc(366.41,66.88) 366.47,66.92 arc(366.51,66.98) 366.53,67.05 366.53,67.76 366.27,68.01 366.27,68.52 366.53,68.78 366.53,69.28 366.27,69.54 366.27,70.05 366.53,70.3 366.53,70.81 366.27,71.06 366.27,71.57 366.53,71.82 366.53,72.33 366.27,72.59 366.27,73.09 366.53,73.35 366.53,73.86 366.27,74.11 366.27,74.62 366.53,74.87 366.53,77.24 arc(366.5,77.39) 366.41,77.51 363.83,80.09 363.47,80.09 363.11,80.45 363.11,80.81 362.75,81.17 362.4,81.17 362.04,81.53 362.04,81.89 311.85,132.08 311.43,132.5 arc(305.56,136.42) 298.64,137.79 297.12,137.79 arc(288.22,139.56) 280.68,144.6 249.78,175.5 arc(249.66,175.58) 249.51,175.61 239.53,175.61 arc(239.09,175.7) 238.72,175.95 238.61,176.06 arc(238.48,176.14) 238.34,176.17 215.92,176.17 arc(215.77,176.14) 215.65,176.06 214.16,174.58 arc(213.79,174.33) 213.36,174.24 209.66,174.24 arc(209.5,174.21) 209.36,174.11 arc(209.27,173.98) 209.24,173.82 209.24,173.58
FC62_TDP0: length 244.4
  TOP w0.147: U1.CD25 206.05,169.89 arc(206.18,170.21) v4(206.5,170.34)
  SIG5 w0.112: 207.24,173.86 207.24,173.83 207.15,173.74 207.15,171.18 arc(207.12,171.03) 207.03,170.9 arc(206.9,170.81) 206.75,170.78 206.31,170.78 arc(206.25,170.77) 206.2,170.73 206.19,170.72 arc(206.16,170.68) 206.15,170.63 206.15,170.47 arc(206.18,170.38) 206.27,170.34 v4(206.5,170.34)
  SIG5 w0.16: 207.24,173.86 207.24,174.37 arc(207.3,174.67) 207.47,174.91 209.82,177.27 arc(210.07,177.43) 210.36,177.49 210.82,177.49 211.05,177.26 211.5,177.26 211.73,177.49 212.38,177.49 212.61,177.26 213.07,177.26 213.3,177.49 213.79,177.49 arc(214.09,177.55) 214.33,177.72 214.65,178.03 arc(214.9,178.2) 215.19,178.25 235.16,178.25 arc(235.31,178.23) 235.43,178.14 237.6,175.97 arc(237.97,175.73) 238.41,175.64 252.35,175.64 arc(252.64,175.58) 252.89,175.42 290.29,138.02 arc(290.54,137.85) 290.83,137.79 309.01,137.79 arc(309.3,137.73) 309.55,137.57 374.72,72.4 374.72,72.13 375.09,71.76 375.36,71.76 375.69,71.43 375.69,71.16 376.06,70.79 376.33,70.79 376.66,70.46 376.66,70.17 377,69.82 377.3,69.82 377.63,69.49 377.63,69.2 377.97,68.85 378.27,68.85 378.62,68.5 378.62,68.2 378.97,67.85 379.27,67.85 379.59,67.53 arc(379.76,67.28) 379.81,66.99 379.81,66.53 379.58,66.31 379.58,65.85 379.81,65.62 379.81,64.17 arc(379.78,64.02) 379.7,63.9 379.32,63.52 arc(379.2,63.44) 379.05,63.41 369.75,63.41 arc(369.46,63.35) 369.21,63.18 369.16,63.13 369.12,63.08 arc(368.87,62.92) 368.58,62.86 367.68,62.86 arc(367.49,62.78) 367.41,62.59 367.41,62.32 arc(367.44,62.13) 367.55,61.97 YJ35.C5
FC62_TDP1: length 247.2
  TOP w0.147: U1.CB26 205.55,168.34 v4(205.6,168.34)
  SIG4 w0.112: 206.86,174.04 206.86,174.01 206.95,173.92 206.95,169.25 arc(206.93,169.15) 206.87,169.06 arc(206.78,169) 206.68,168.98 206.3,168.98 arc(206.17,168.95) 206.05,168.87 arc(205.98,168.76) 205.95,168.62 205.95,168.47 arc(205.91,168.38) 205.82,168.34 v4(205.6,168.34)
  SIG4 w0.16: YJ35.C3 366.1,60.79 arc(366.15,61.02) 366.28,61.21 366.81,61.75 arc(366.88,61.85) 366.91,61.97 366.91,62.57 arc(366.94,62.72) 367.03,62.86 367.08,62.91 arc(367.21,63) 367.35,63.03 379.06,63.03 arc(379.36,63.08) 379.6,63.25 379.96,63.61 arc(380.13,63.86) 380.19,64.15 380.19,67.11 arc(380.13,67.4) 379.96,67.65 313.38,134.24 312.31,135.3 arc(306.74,139.02) 300.17,140.33 298.72,140.33 arc(289.31,142.2) 281.33,147.54 250.99,177.88 arc(250.74,178.04) 250.45,178.1 240.36,178.1 arc(240.07,178.16) 239.83,178.33 239.74,178.41 arc(239.49,178.58) 239.2,178.64 215,178.64 arc(214.71,178.58) 214.46,178.41 213.06,177 arc(212.96,176.92) 212.84,176.85 arc(212.68,176.8) 212.52,176.78 208.99,176.78 arc(208.55,176.69) 208.18,176.45 207.2,175.46 arc(206.95,175.09) 206.86,174.65 206.86,174.04
FC62_TDP2: length 218.3
  TOP w0.147: U1.CE23 208.05,170.89 arc(208.18,171.21) v4(208.5,171.34)
  SIG5 w0.112: v4(208.5,171.34) 208.2,171.34 arc(208.11,171.38) 208.07,171.47 208.07,171.63 arc(208.08,171.68) 208.11,171.72 208.12,171.73 arc(208.17,171.77) 208.24,171.78 208.75,171.78 arc(208.9,171.81) 209.03,171.9 arc(209.12,172.03) 209.15,172.18 209.15,173.37 arc(209.18,173.51) 209.26,173.63 209.32,173.7 209.45,173.7 209.47,173.72
  SIG5 w0.16: 209.47,173.72 209.68,173.92 arc(210.03,174.16) 210.45,174.24 211.5,174.24 211.65,174.09 212.42,174.09 212.57,174.24 213.33,174.24 arc(213.77,174.33) 214.14,174.58 215.62,176.06 arc(215.75,176.14) 215.89,176.17 216.65,176.17 216.81,176.02 217.57,176.02 217.72,176.17 218.48,176.17 218.64,176.02 219.4,176.02 219.55,176.17 220.31,176.17 220.46,176.02 221.23,176.02 221.38,176.17 222.14,176.17 222.29,176.02 223.06,176.02 223.21,176.17 234.3,176.17 arc(234.44,176.14) 234.57,176.06 236.76,173.87 arc(237.13,173.62) 237.57,173.53 251.41,173.53 arc(251.7,173.47) 251.95,173.31 289.4,135.86 arc(289.65,135.69) 289.94,135.63 308,135.63 arc(308.29,135.58) 308.54,135.41 359.23,84.72 360.52,83.43 360.52,83.43 361.27,82.67 361.81,82.13 366.87,77.08 arc(367.04,76.83) 367.09,76.54 367.09,74.43 366.89,74.23 366.89,73.72 367.09,73.52 367.09,73.06 366.87,72.83 366.87,72.37 367.09,72.14 367.09,71.69 366.87,71.46 366.87,71 367.09,70.77 367.09,70.32 arc(367.18,69.88) 367.43,69.51 368.81,68.12 arc(368.9,68) 368.93,67.85 368.93,67.04 arc(368.92,66.98) 368.89,66.93 arc(368.82,66.88) 368.74,66.86 367.68,66.86 arc(367.49,66.78) 367.41,66.59 367.41,66.32 arc(367.44,66.13) 367.55,65.97 YJ35.C34
FC62_TDP3: length 218.1
  TOP w0.147: v4(207.6,169.34) 207.55,169.34 U1.CC24
  SIG4 w0.112: 208.86,173.58 208.86,173.55 208.95,173.46 208.95,170.25 arc(208.93,170.15) 208.87,170.06 arc(208.78,170) 208.68,169.98 208.3,169.98 arc(208.17,169.95) 208.05,169.87 arc(207.98,169.76) 207.95,169.62 207.95,169.47 arc(207.91,169.38) 207.82,169.34 v4(207.6,169.34)
  SIG4 w0.16: 208.86,173.58 208.86,173.82 arc(208.92,174.12) 209.08,174.38 arc(209.35,174.56) 209.66,174.62 213.36,174.62 arc(213.65,174.68) 213.9,174.85 215.38,176.33 arc(215.63,176.49) 215.92,176.55 238.34,176.55 arc(238.63,176.49) 238.87,176.33 238.99,176.22 arc(239.23,176.05) 239.53,175.99 249.51,175.99 arc(249.8,175.94) 250.05,175.77 280.95,144.87 arc(288.37,139.91) 297.12,138.17 298.64,138.17 arc(305.71,136.77) 311.7,132.77 312.12,132.35 366.68,77.78 arc(366.85,77.53) 366.91,77.24 366.91,65.97 arc(366.88,65.85) 366.81,65.75 366.28,65.21 arc(366.27,65.2) 366.26,65.19 arc(366.14,65) 366.1,64.78 YJ35.C36
FC63_RDN0: length 255.8
  TOP w0.147: v4(204.5,165.34) 204.42,165.34 arc(204.35,165.33) 204.29,165.29 204.19,165.19 arc(204.09,165.03) U1.BW27
  SIG3 w0.112: v4(204.5,165.34) 204.27,165.34 arc(204.18,165.38) 204.15,165.47 204.15,165.62 arc(204.16,165.68) 204.19,165.73 arc(204.24,165.77) 204.3,165.78 204.68,165.78 arc(204.86,165.81) 205.01,165.92 arc(205.11,166.07) 205.15,166.25 205.15,174.01 205.24,174.1 205.24,174.13
  SIG3 w0.16: 205.24,174.13 205.24,175.6 arc(205.28,175.84) 205.39,176.05 arc(205.43,176.1) 205.47,176.14 213.61,184.28 arc(213.85,184.45) 214.15,184.5 236.37,184.5 arc(236.67,184.45) 236.91,184.28 241.17,180.03 arc(241.41,179.86) 241.7,179.8 251.39,179.8 arc(251.54,179.77) 251.66,179.69 286.75,144.6 arc(287.12,144.36) 287.56,144.27 305.74,144.27 arc(305.89,144.24) 306.01,144.16 381.23,68.94 381.23,68.66 381.57,68.31 381.86,68.31 382.55,67.62 arc(382.63,67.49) 382.66,67.35 382.66,66.85 382.41,66.59 382.41,66.29 382.66,66.03 382.66,65.73 382.41,65.48 382.41,65.09 382.66,64.84 382.66,64.46 382.41,64.21 382.41,63.82 382.66,63.57 382.66,63.19 arc(382.63,63.04) 382.55,62.92 381.54,61.91 381.18,61.91 380.91,61.64 380.91,61.28 380.64,61.01 380.28,61.01 380.02,60.74 380.02,60.38 379.75,60.11 379.39,60.11 379.12,59.84 379.12,59.49 378.85,59.22 arc(378.83,59.2) 378.81,59.18 378.76,59.13 378.72,59.08 arc(378.47,58.92) 378.18,58.86 377.33,58.86 arc(377.1,58.77) 377.01,58.54 377.01,58.43 arc(377.07,58.14) 377.23,57.89 YJ35.D22
FC63_RDN1: length 271.7
  TOP w0.147: U1.BU28 203.55,163.34 v4(203.6,163.34)
  SIG3 w0.112: 202.86,172.97 202.95,172.87 202.95,164.18 arc(202.98,164.03) 203.07,163.9 arc(203.2,163.81) 203.35,163.78 203.79,163.78 arc(203.85,163.77) 203.9,163.73 203.91,163.72 arc(203.94,163.68) 203.95,163.63 203.95,163.47 arc(203.91,163.38) 203.82,163.34 v4(203.6,163.34)
  SIG3 w0.16: 202.86,172.97 202.86,176.51 arc(202.94,176.95) 203.19,177.32 214.73,188.86 arc(214.98,189.03) 215.27,189.08 245.54,189.08 arc(245.83,189.03) 246.08,188.86 287.78,147.16 arc(288.03,146.99) 288.32,146.94 306.81,146.94 arc(307.11,146.88) 307.35,146.71 337.23,116.84 384.9,69.16 arc(385.07,68.91) 385.13,68.62 385.13,61.27 arc(385.07,60.98) 384.9,60.74 379.04,54.87 379.03,54.86 arc(378.94,54.72) 378.91,54.57 378.91,54.08 arc(378.86,53.86) 378.74,53.67 378.25,53.19 arc(378.14,53.02) 378.1,52.82 YJ35.D18
FC63_RDN2: length 262.5
  TOP w0.147: U1.BR27 204.05,160.94 arc(204.07,161.04) 204.12,161.12 204.29,161.29 arc(204.35,161.33) 204.42,161.34 v4(204.5,161.34)
  SIG2 w0.112: 205.24,173.61 205.14,173.51 205.14,162.25 arc(205.11,162.07) 205.01,161.92 arc(204.85,161.81) 204.67,161.78 204.3,161.78 arc(204.24,161.77) 204.19,161.73 arc(204.16,161.68) 204.15,161.62 204.15,161.47 arc(204.18,161.38) 204.27,161.34 v4(204.5,161.34)
  SIG2 w0.16: 205.24,173.61 205.24,174.06 205.42,174.24 205.42,174.62 205.24,174.8 205.24,175 arc(205.3,175.5) 205.47,175.97 arc(205.66,176.29) 205.89,176.57 207.1,177.77 arc(212.25,181.21) 218.32,182.42 236.43,182.42 arc(236.57,182.39) 236.69,182.31 238.84,180.16 arc(239.21,179.92) 239.65,179.83 251.21,179.83 arc(251.5,179.77) 251.75,179.61 286.86,144.49 arc(287.11,144.33) 287.4,144.27 305.58,144.27 arc(305.88,144.21) 306.12,144.05 375.91,74.26 arc(376.15,74.1) 376.45,74.04 379.86,74.04 arc(380,74.01) 380.13,73.93 383.11,70.94 arc(383.19,70.82) 383.22,70.67 383.22,70.11 382.97,69.86 382.97,69.35 383.22,69.09 383.22,68.59 382.97,68.33 382.97,67.82 383.22,67.57 383.22,67.06 382.97,66.81 382.97,66.3 383.22,66.05 383.22,65.54 382.97,65.28 382.97,64.78 383.22,64.52 383.22,64.01 arc(383.09,63.33) 382.7,62.75 381.62,61.67 381.26,61.67 380.9,61.31 380.9,60.96 380.54,60.6 380.18,60.6 379.83,60.24 379.83,59.88 379.47,59.52 arc(379.34,59.44) 379.2,59.41 376.95,59.41 arc(376.66,59.35) 376.41,59.18 376.31,59.08 arc(376.07,58.92) 375.78,58.86 374.93,58.86 arc(374.7,58.77) 374.61,58.54 374.61,58.32 arc(374.64,58.13) 374.75,57.97 YJ35.D25
FC63_RDN3: length 276.8
  TOP w0.147: v4(203.6,159.34) 203.55,159.34 U1.BN28
  SIG2 w0.112: v4(203.6,159.34) 203.82,159.34 arc(203.91,159.38) 203.95,159.47 203.95,159.63 arc(203.94,159.68) 203.91,159.72 203.9,159.73 arc(203.85,159.77) 203.79,159.78 203.35,159.78 arc(203.2,159.81) 203.07,159.9 arc(202.98,160.03) 202.95,160.18 202.95,172.87 202.86,172.97
  SIG2 w0.16: YJ35.D15 375.7,52.79 arc(375.75,53.02) 375.87,53.21 376.34,53.67 arc(376.46,53.86) 376.51,54.08 376.51,54.57 arc(376.54,54.72) 376.63,54.86 376.68,54.91 arc(376.73,54.95) 376.78,54.98 arc(376.86,55.01) 376.95,55.03 378.9,55.03 arc(379.34,55.11) 379.71,55.36 382.11,57.76 382.74,58.39 385.76,61.41 385.76,70.58 arc(385.51,71.87) 384.77,72.97 380.48,77.26 arc(379.13,78.17) 377.54,78.48 376.29,78.48 arc(375.64,78.61) 375.08,78.98 307.59,146.47 arc(307.22,146.72) 306.78,146.81 305.75,146.81 arc(289.35,150.07) 275.45,159.36 248.3,186.51 arc(245.71,188.24) 242.66,188.85 241.94,188.85 arc(240.12,188.48) 238.57,187.45 arc(235.73,185.55) 232.38,184.88 218.37,184.88 arc(211.28,183.48) 205.28,179.46 203.12,177.31 arc(202.93,177.01) 202.86,176.66 202.86,172.97
FC63_RDP0: length 255.8
  TOP w0.147: U1.BW28 203.55,165.34 v4(203.6,165.34)
  SIG3 w0.112: v4(203.6,165.34) 203.82,165.34 arc(203.91,165.38) 203.95,165.47 203.95,165.62 arc(203.98,165.76) 204.05,165.87 arc(204.17,165.95) 204.3,165.98 204.68,165.98 arc(204.78,166) 204.87,166.06 arc(204.93,166.15) 204.95,166.25 204.95,174.01 204.86,174.1 204.86,174.13
  SIG3 w0.16: 204.86,174.13 204.86,175.6 arc(204.92,175.96) 205.08,176.28 arc(205.14,176.34) 205.2,176.41 213.34,184.55 arc(213.71,184.8) 214.15,184.88 236.37,184.88 arc(236.81,184.8) 237.18,184.55 241.44,180.3 arc(241.56,180.21) 241.7,180.19 251.39,180.19 arc(251.68,180.13) 251.93,179.96 287.02,144.87 arc(287.27,144.71) 287.56,144.65 305.74,144.65 arc(306.03,144.59) 306.28,144.43 382.82,67.89 arc(382.99,67.64) 383.04,67.35 383.04,63.19 arc(382.99,62.9) 382.82,62.65 379.11,58.94 arc(379.1,58.93) 379.08,58.91 379.03,58.86 arc(378.94,58.72) 378.91,58.57 378.91,58.08 arc(378.86,57.86) 378.74,57.67 378.28,57.22 arc(378.28,57.21) 378.28,57.21 arc(378.27,57.2) 378.26,57.19 arc(378.14,57) 378.1,56.77 YJ35.D21
FC63_RDP1: length 271.7
  TOP w0.147: v4(204.5,163.34) 204.41,163.34 arc(204.33,163.33) 204.27,163.28 204.19,163.2 arc(204.08,163.05) 204.05,162.87 U1.BU27
  SIG3 w0.112: v4(204.5,163.34) 204.27,163.34 arc(204.18,163.38) 204.15,163.47 204.15,163.63 arc(204.12,163.75) 204.05,163.86 204.04,163.87 arc(203.92,163.95) 203.79,163.98 203.35,163.98 arc(203.28,163.99) 203.21,164.04 arc(203.17,164.1) 203.15,164.18 203.15,172.88 203.24,172.97
  SIG3 w0.16: YJ35.D17 377.15,53.97 arc(377.04,54.13) 377.01,54.32 377.01,54.57 arc(377.09,54.78) 377.3,54.86 378.18,54.86 arc(378.47,54.92) 378.72,55.08 378.77,55.14 379.07,55.44 379.07,55.8 379.34,56.07 379.7,56.07 379.97,56.34 379.97,56.7 380.24,56.97 380.6,56.97 380.87,57.24 380.87,57.6 381.14,57.86 381.49,57.86 381.76,58.13 381.76,58.49 382.03,58.76 382.39,58.76 382.66,59.03 382.66,59.39 382.93,59.66 383.29,59.66 383.56,59.93 383.56,60.29 383.83,60.56 384.19,60.56 384.63,61 arc(384.72,61.13) 384.75,61.27 384.75,61.66 384.57,61.83 384.57,62.37 384.75,62.54 384.75,68.62 arc(384.72,68.77) 384.63,68.89 336.69,116.84 307.08,146.44 arc(306.96,146.53) 306.81,146.56 288.32,146.56 arc(287.88,146.64) 287.51,146.89 245.81,188.59 arc(245.69,188.67) 245.54,188.7 215.27,188.7 arc(215.12,188.67) 215,188.59 203.46,177.05 arc(203.29,176.81) 203.24,176.51 203.24,176.52 203.24,172.97
