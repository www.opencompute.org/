# Allegro board RA-B6910-64C-MAC.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
G24101MK
  oval 0.635x2.591 smd: 1(-6.985,-7.5) 2(-5.715,-7.5) 3(-4.445,-7.5) 4(-3.175,-7.5) 5(-1.905,-7.5) 6(-0.635,-7.5) 7(0.635,-7.5) 8(1.905,-7.5) 9(3.175,-7.5) 10(4.445,-7.5) 11(5.715,-7.5) 12(6.985,-7.5) 13(6.985,7.5) 14(5.715,7.5) 15(4.445,7.5) 16(3.175,7.5) 17(1.905,7.5) 18(0.635,7.5) 19(-0.635,7.5) 20(-1.905,7.5) 21(-3.175,7.5) 22(-4.445,7.5) 23(-5.715,7.5) 24(-6.985,7.5)
ICT_PAD_B_R30
  round 0.762 smd: 1(0,0)
ISL99227B
  oval 0.6x0.25 smd: 1(-2.4,1.75) 2(-2.4,1.25) 3(-2.4,0.75) 4(-2.4,0.25) 5(-2.4,-0.25)
  custom 0.506x0.506 smd: 6(0,-0.861)
  custom 0.15x0.15 smd: 9(0,-2.4)
  custom 0.331x0.331 smd: 21(1.45,1.213)
  oval 0.25x0.6 smd: 24(2,2.4) 25(1.5,2.4) 26(1,2.4) 27(0.5,2.4) 28(0,2.4) 29(-0.5,2.4) 30(-1,2.4) 31(-1.5,2.4) 32(-2,2.4)
  rect 1.5x1.15 smd: 33(-0.95,1.125)
L0603
  rect 0.864x0.787 smd: 1(-0.737,0) 2(0.737,0)
L0805
  rect 1.118x1.27 smd: 1(-0.965,0) 2(0.965,0)
L_7M2X6M5X3
  rect 2.2x3.4 smd: 1(-2.95,0) 2(2.95,0)
L_7M50X7M50X4M70
  rect 2.1x2.3 smd: 1(-3.15,0) 2(3.15,0)
L_9M00X3M10X2M80
  rect 2.2x1.6 smd: 1(-3.9,0) 2(3.9,0)
L_11M50X7M00X9M20
  rect 4.5x2.9 smd: 1(-4.55,0) 2(4.55,0)
L_13M50X12M50X4M80
  rect 3x5 smd: 1(-5.75,0) 2(5.75,0)
LED_2_GR
  rect 0.5x0.4 smd: 1(0.6,-0.35) 2(0.6,0.35) 3(-0.6,0.35) 4(-0.6,-0.35)
LED_SMT0603
  custom 0.191x0.191 smd: 1(0.813,0) 2(-0.813,0)
LED_SMT0805
  rect 1.524x1.397 smd: 1(1.118,0) 2(-1.118,0)
MARK
  round 1.016 smd: 1(0,0)
OSC_SMD7MX5MX1M4_4
  rect 1.5x1.8 smd: 1(-2.54,-2.25) 2(2.54,-2.25) 3(2.54,2.15) 4(-2.54,2.15)
QFN_10_EP2M00X1M60
  oval 0.7x0.25 smd: 1(-1.45,1) 2(-1.45,0.5) 3(-1.45,0) 4(-1.45,-0.5) 5(-1.45,-1) 6(1.45,-1) 7(1.45,-0.5) 8(1.45,0) 9(1.45,0.5) 10(1.45,1)
  rect 1.6x2 smd: 11(0,0)
QFN_22_EPAD5M48X3M24
  oval 0.254x0.85 smd: 1(-2.5,-2.375) 2(-2,-2.375) 3(-1.5,-2.375) 4(-1,-2.375) 5(-0.5,-2.375) 6(0,-2.375) 7(0.5,-2.375) 8(1,-2.375) 9(1.5,-2.375) 10(2,-2.375) 11(2.5,-2.375) 12(2.5,2.375) 13(2,2.375) 14(1.5,2.375) 15(1,2.375) 16(0.5,2.375) 17(0,2.375) 18(-0.5,2.375) 19(-1,2.375) 20(-1.5,2.375) 21(-2,2.375) 22(-2.5,2.375)
  rect 5.58x3.34 smd: 23(0,0)
QFN_48_EP4M40
  oval 0.7x0.2 smd: 1(-2.9,2.2) 2(-2.9,1.8) 3(-2.9,1.4) 4(-2.9,1) 5(-2.9,0.6) 6(-2.9,0.2) 7(-2.9,-0.2) 8(-2.9,-0.6) 9(-2.9,-1) 10(-2.9,-1.4) 11(-2.9,-1.8) 12(-2.9,-2.2) 25(2.9,-2.2) 26(2.9,-1.8) 27(2.9,-1.4) 28(2.9,-1) 29(2.9,-0.6) 30(2.9,-0.2) 31(2.9,0.2) 32(2.9,0.6) 33(2.9,1) 34(2.9,1.4) 35(2.9,1.8) 36(2.9,2.2)
  oval 0.2x0.7 smd: 13(-2.2,-2.9) 14(-1.8,-2.9) 15(-1.4,-2.9) 16(-1,-2.9) 17(-0.6,-2.9) 18(-0.2,-2.9) 19(0.2,-2.9) 20(0.6,-2.9) 21(1,-2.9) 22(1.4,-2.9) 23(1.8,-2.9) 24(2.2,-2.9) 37(2.2,2.9) 38(1.8,2.9) 39(1.4,2.9) 40(1,2.9) 41(0.6,2.9) 42(0.2,2.9) 43(-0.2,2.9) 44(-0.6,2.9) 45(-1,2.9) 46(-1.4,2.9) 47(-1.8,2.9) 48(-2.2,2.9)
  rect 4.4x4.4 smd: 49(0,0)
R0402
  rect 0.559x0.559 smd: 1(-0.483,0) 2(0.483,0)
R0603
  rect 0.864x0.787 smd: 1(-0.737,0) 2(0.737,0)
R0805
  rect 1.118x1.27 smd: 1(-0.965,0) 2(0.965,0)
R1206
  rect 1.321x1.6 smd: 1(-1.575,0) 2(1.575,0)
R1210_ANT
  rect 1.1x2.8 smd: 1(-1.55,0) 2(1.55,0)
RJ45_2X1_LED_45110_2
  round 3.25 hole 3.25 unplated: (0,0) (12.69,0)
  round 2.17 hole 1.57: 1(-1.78,15.49) 2(-1.78,7.11) 3(14.47,15.49) 4(14.47,7.11)
  round 1.5 hole 1.1: 9(-0.515,20.95) 10(2.025,20.95) 11(10.665,20.95) 12(13.205,20.95) A1(1.9,8.25) A2(3.17,10.79) A3(4.44,8.25) A4(5.71,10.79) A5(6.98,8.25) A6(8.25,10.79) A7(9.52,8.25) A8(10.79,10.79) B1(10.79,17.02) B2(9.52,14.48) B3(8.25,17.02) B4(6.98,14.48) B5(5.71,17.02) B6(4.44,14.48) B7(3.17,17.02) B8(1.9,14.48)
SCREW_HOLE_3_5MM_1
  round 6 hole 3.5: 1(0,0)
SCREW_HOLE_5_5MM
  round 10 hole 5.5: 1(0,0)
SCREW_N_M_3_5MM
  round 3.5 hole 3.5 unplated: (0,0)
  round 1.016 hole 0.508: 2(2.373,2.373) 3(0,3.355) 4(-2.373,2.373) 5(-3.355,0) 6(-2.373,-2.373) 7(0,-3.355) 8(2.373,-2.373) 9(3.355,0)
  custom 1.08x1.08 smd: 10(0,0) 11(0,0) 12(0,0) 13(0,0)
SO_8
  oval 0.711x1.778 smd: 1(-1.905,-2.87) 2(-0.635,-2.87) 3(0.635,-2.87) 4(1.905,-2.87) 5(1.905,2.87) 6(0.635,2.87) 7(-0.635,2.87) 8(-1.905,2.87)
SON_8_1M75X1M50
  oval 0.35x0.8 smd: 1(-0.975,-1.45) 2(-0.325,-1.45) 3(0.325,-1.45) 4(0.975,-1.45) 5(0.975,1.45) 6(0.325,1.45) 7(-0.325,1.45) 8(-0.975,1.45)
  custom 0.375x0.375 smd: 9(0,0)
SOP_8
  rect 0.72x1.35 smd: 1(-1.905,-2.625) 2(-0.635,-2.625) 3(0.635,-2.625) 4(1.905,-2.625) 5(1.905,2.625) 6(0.635,2.625) 7(-0.635,2.625) 8(-1.905,2.625)
SOP_8_EP2M90X2M00
  oval 0.72x1.35 smd: 1(-1.905,-2.625) 2(-0.635,-2.625) 3(0.635,-2.625) 4(1.905,-2.625) 5(1.905,2.625) 6(0.635,2.625) 7(-0.635,2.625) 8(-1.905,2.625)
  rect 2.9x2 smd: 9(0,0)
SOT23_6_1M10
  rect 1.016x0.559 smd: 1(-1.35,0.95) 2(-1.35,0) 3(-1.35,-0.95) 4(1.35,-0.95) 5(1.35,0) 6(1.35,0.95)
SOT_23
  rect 1.321x1.016 smd: 1(1.143,-0.947) 2(1.143,0.947) 3(-1.143,0)
SOT_23_6
  rect 0.9x0.55 smd: 1(-1.25,0.95) 2(-1.25,0) 3(-1.25,-0.95) 4(1.25,-0.95) 5(1.25,0) 6(1.25,0.95)
SSOP_28
  oval 0.33x1.651 smd: 1(-4.225,-3.645) 2(-3.575,-3.645) 3(-2.925,-3.645) 4(-2.275,-3.645) 5(-1.625,-3.645) 6(-0.975,-3.645) 7(-0.325,-3.645) 8(0.325,-3.645) 9(0.975,-3.645) 10(1.625,-3.645) 11(2.275,-3.645) 12(2.925,-3.645) 13(3.575,-3.645) 14(4.225,-3.645) 15(4.225,3.645) 16(3.575,3.645) 17(2.925,3.645) 18(2.275,3.645) 19(1.625,3.645) 20(0.975,3.645) 21(0.325,3.645) 22(-0.325,3.645) 23(-0.975,3.645) 24(-1.625,3.645) 25(-2.275,3.645) 26(-2.925,3.645) 27(-3.575,3.645) 28(-4.225,3.645)
TEST_018_1
  round 0.457 smd: 1(0,0)
TEST_40
  round 1.016 smd: 1(0,0)
TPS3823
  rect 1.27x0.508 smd: 1(1.27,-0.953) 2(1.27,0) 3(1.27,0.953) 4(-1.27,0.953) 5(-1.27,-0.953)
TS11C_2JL
  rect 0.7x1 smd: 1(-1.7,1.45) 3(1.7,1.45)
  rect 1.3x1.2 smd: 2(0,1.65)
  round 1.2 hole 0.9: 4(-2.2,0.15) 5(2.2,0.15)
  rect 1.1x0.7 smd: 6(-2.1,-0.8) 7(2.1,-0.8)
TSSOP_20
  oval 0.3x1.5 smd: 1(-2.925,-2.86) 2(-2.275,-2.86) 3(-1.625,-2.86) 4(-0.975,-2.86) 5(-0.325,-2.86) 6(0.325,-2.86) 7(0.975,-2.86) 8(1.625,-2.86) 9(2.275,-2.86) 10(2.925,-2.86) 11(2.925,2.86) 12(2.275,2.86) 13(1.625,2.86) 14(0.975,2.86) 15(0.325,2.86) 16(-0.325,2.86) 17(-0.975,2.86) 18(-1.625,2.86) 19(-2.275,2.86) 20(-2.925,2.86)
TSSOP_24
  oval 0.305x1.524 smd: 1(-3.575,-2.925) 2(-2.925,-2.925) 3(-2.275,-2.925) 4(-1.625,-2.925) 5(-0.975,-2.925) 6(-0.325,-2.925) 7(0.325,-2.925) 8(0.975,-2.925) 9(1.625,-2.925) 10(2.275,-2.925) 11(2.925,-2.925) 12(3.575,-2.925) 13(3.575,2.925) 14(2.925,2.925) 15(2.275,2.925) 16(1.625,2.925) 17(0.975,2.925) 18(0.325,2.925) 19(-0.325,2.925) 20(-0.975,2.925) 21(-1.625,2.925) 22(-2.275,2.925) 23(-2.925,2.925) 24(-3.575,2.925)
unnamed#2
  round 3.1 hole 3.1 unplated: (0,0) (66,9)
unnamed#3
  round 2.5 hole 2.5 unplated: (0,0)
USB_A_09F
  oval 1.5x1.2 hole 0.9: 1(0,0) 2(0,-2) 3(0,-4) 4(0,-6)
  oval 1.6x2.1 hole 1x1.5: 5(-2.75,0.5) 6(-2.75,-6.5) 7(2.75,0.5) 8(2.75,-6.5)
VQFN_48_EP4M08
  oval 0.75x0.25 smd: 1(-3.425,2.75) 2(-3.425,2.25) 3(-3.425,1.75) 4(-3.425,1.25) 5(-3.425,0.75) 6(-3.425,0.25) 7(-3.425,-0.25) 8(-3.425,-0.75) 9(-3.425,-1.25) 10(-3.425,-1.75) 11(-3.425,-2.25) 12(-3.425,-2.75) 25(3.425,-2.75) 26(3.425,-2.25) 27(3.425,-1.75) 28(3.425,-1.25) 29(3.425,-0.75) 30(3.425,-0.25) 31(3.425,0.25) 32(3.425,0.75) 33(3.425,1.25) 34(3.425,1.75) 35(3.425,2.25) 36(3.425,2.75)
  oval 0.25x0.75 smd: 13(-2.75,-3.425) 14(-2.25,-3.425) 15(-1.75,-3.425) 16(-1.25,-3.425) 17(-0.75,-3.425) 18(-0.25,-3.425) 19(0.25,-3.425) 20(0.75,-3.425) 21(1.25,-3.425) 22(1.75,-3.425) 23(2.25,-3.425) 24(2.75,-3.425) 37(2.75,3.425) 38(2.25,3.425) 39(1.75,3.425) 40(1.25,3.425) 41(0.75,3.425) 42(0.25,3.425) 43(-0.25,3.425) 44(-0.75,3.425) 45(-1.25,3.425) 46(-1.75,3.425) 47(-2.25,3.425) 48(-2.75,3.425)
  rect 4.08x4.08 smd: 49(0,0)
ZQ20100076_150MX100MX23M5
  round 8 hole 3.5: 1(-45,45) 2(45,45.005) 3(-45,-45) 4(45,-45)
ZQSFP_2X2_LED
  round 2.5 hole 2.5 unplated: (0.2,-0.01) (37.8,-0.01)
  oval 2.9x2.5 hole 2.9x2.5 unplated: (19,-0.01)
  round 1.35 hole 1.05: 1(-0.2,-6.61) 2(-0.2,-17.31) 3(-0.2,-26.31) 4(-0.2,-35.31) 5(-0.2,-44.31) 11(37.8,-11.11) 12(37.8,-21.81) 13(37.8,-30.81) 14(37.8,-39.81)
  oval 1.75x1.35 hole 1.45x1.05: 6(19,-44.31) 7(19,-35.31) 8(19,-26.31) 9(19,-17.31) 10(19,-6.61)
  round 0.62 hole 0.37: A1(2.3,9.22) A2(3.1,9.92) A3(3.9,8.52) A4(4.7,9.22) A5(5.5,9.92) A6(6.3,8.52) A7(7.1,9.22) A8(7.9,9.92) A9(8.7,8.52) A10(9.5,9.22) A11(10.3,9.92) A12(11.1,8.52) A13(11.9,9.22) A14(12.7,9.92) A15(13.5,8.52) A16(14.3,9.22) A17(15.1,9.92) A18(15.9,8.52) A19(16.7,9.22) A20(16.7,13.22) A21(15.9,12.52) A22(15.1,13.92) A23(14.3,13.22) A24(13.5,12.52) A25(12.7,13.92) A26(11.9,13.22) A27(11.1,12.52) A28(10.3,13.92) A29(9.5,13.22) A30(8.7,12.52) A31(7.9,13.92) A32(7.1,13.22) A33(6.3,12.52) A34(5.5,13.92) A35(4.7,13.22) A36(3.9,12.52) A37(3.1,13.92) A38(2.3,13.22) B1(2.3,1.22) B2(3.1,1.92) B3(3.9,0.52) B4(4.7,1.22) B5(5.5,1.92) B6(6.3,0.52) B7(7.1,1.22) B8(7.9,1.92) B9(8.7,0.52) B10(9.5,1.22) B11(10.3,1.92) B12(11.1,0.52) B13(11.9,1.22) B14(12.7,1.92) B15(13.5,0.52) B16(14.3,1.22) B17(15.1,1.92) B18(15.9,0.52) B19(16.7,1.22) B20(16.7,5.22) B21(15.9,4.52) B22(15.1,5.92) B23(14.3,5.22) B24(13.5,4.52) B25(12.7,5.92) B26(11.9,5.22) B27(11.1,4.52) B28(10.3,5.92) B29(9.5,5.22) B30(8.7,4.52) B31(7.9,5.92) B32(7.1,5.22) B33(6.3,4.52) B34(5.5,5.92) B35(4.7,5.22) B36(3.9,4.52) B37(3.1,5.92) B38(2.3,5.22) C1(21.3,9.22) C2(22.1,9.92) C3(22.9,8.52) C4(23.7,9.22) C5(24.5,9.92) C6(25.3,8.52) C7(26.1,9.22) C8(26.9,9.92) C9(27.7,8.52) C10(28.5,9.22) C11(29.3,9.92) C12(30.1,8.52) C13(30.9,9.22) C14(31.7,9.92) C15(32.5,8.52) C16(33.3,9.22) C17(34.1,9.92) C18(34.9,8.52) C19(35.7,9.22) C20(35.7,13.22) C21(34.9,12.52) C22(34.1,13.92) C23(33.3,13.22) C24(32.5,12.52) C25(31.7,13.92) C26(30.9,13.22) C27(30.1,12.52) C28(29.3,13.92) C29(28.5,13.22) C30(27.7,12.52) C31(26.9,13.92) C32(26.1,13.22) C33(25.3,12.52) C34(24.5,13.92) C35(23.7,13.22) C36(22.9,12.52) C37(22.1,13.92) C38(21.3,13.22) D1(21.3,1.22) D2(22.1,1.92) D3(22.9,0.52) D4(23.7,1.22) D5(24.5,1.92) D6(25.3,0.52) D7(26.1,1.22) D8(26.9,1.92) D9(27.7,0.52) D10(28.5,1.22) D11(29.3,1.92) D12(30.1,0.52) D13(30.9,1.22) D14(31.7,1.92) D15(32.5,0.52) D16(33.3,1.22) D17(34.1,1.92) D18(34.9,0.52) D19(35.7,1.22) D20(35.7,5.22) D21(34.9,4.52) D22(34.1,5.92) D23(33.3,5.22) D24(32.5,4.52) D25(31.7,5.92) D26(30.9,5.22) D27(30.1,4.52) D28(29.3,5.92) D29(28.5,5.22) D30(27.7,4.52) D31(26.9,5.92) D32(26.1,5.22) D33(25.3,4.52) D34(24.5,5.92) D35(23.7,5.22) D36(22.9,4.52) D37(22.1,5.92) D38(21.3,5.22)

## Nets
DVDD: C3425.1 C3426.1 C3427.1 C3428.1 C3429.1 C3440.1 C3441.1 C3442.1 C3443.1 C3444.1 C3445.1 C3448.1 C3449.1 C3451.1 C3452.1 C3453.1 C3454.1 C3456.1 C3457.1 C3458.1 C3459.1 C3460.1 C3461.1 C3468.1 C3469.1 C3470.1 C3471.1 C3472.1 C3473.1 L446.1 L447.2 R3134.1 R3148.1 R3149.1 R3150.1 R3151.1 U117.7(VDD_PRI_REF) U117.10(VDD_SEC_REF) U117.13(VDD_Y0_Y1_1) U117.18(VDD_Y0_Y1_2) U117.19(VDD_Y2_Y3_1) U117.24(VDD_Y2_Y3_2) U117.27(VDD_Y4) U117.30(VDD_Y5) U117.31(VDD_Y6) U117.34(VDD_Y7) U117.37(VDD_PLL1) U117.48(DVDD)
