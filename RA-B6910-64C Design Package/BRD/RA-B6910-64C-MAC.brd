# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC1_TDN1: length 230.3
  TOP w0.147: U1.CA40 191.05,166.89 arc(190.92,167.21) v4(190.6,167.34)
  SIG6 w0.112: 189.87,173.65 189.87,173.62 189.96,173.53 189.96,168.15 arc(189.98,168.02) 190.05,167.92 190.11,167.87 arc(190.21,167.8) 190.33,167.77 190.82,167.77 arc(190.91,167.73) 190.95,167.64 190.95,167.48 arc(190.94,167.43) 190.91,167.38 arc(190.86,167.35) 190.81,167.34 v4(190.6,167.34)
  SIG6 w0.16: 189.87,173.65 189.87,173.91 arc(189.82,174.16) 189.68,174.36 188.06,175.99 arc(187.81,176.15) 187.52,176.21 184.47,176.21 arc(184.03,176.3) 183.66,176.54 182.47,177.73 arc(182.29,177.85) 182.08,177.89 161.47,177.89 arc(161.18,177.84) 160.93,177.67 159.32,176.07 arc(159.02,175.86) 158.66,175.79 149.94,175.79 arc(149.65,175.73) 149.4,175.57 106.21,132.37 arc(106.04,132.13) 105.98,131.83 105.98,129.68 arc(105.89,129.24) 105.65,128.87 85.64,108.86 arc(85.33,108.65) 84.97,108.58 58.84,108.58 arc(58.63,108.54) 58.45,108.42 39.72,89.7 arc(39.6,89.51) 39.56,89.3 39.56,83.63 arc(39.47,83.19) 39.23,82.82 36.88,80.47 arc(36.8,80.35) 36.77,80.2 36.77,79.88 arc(36.76,79.83) 36.73,79.78 arc(36.61,79.5) 36.43,79.26 35.53,78.36 35.53,78.07 35.16,77.7 34.88,77.7 34.54,77.36 34.54,77.08 34.17,76.71 33.88,76.71 33.54,76.37 33.54,76.09 33.18,75.72 32.89,75.72 32.55,75.38 32.55,75.09 32.19,74.73 31.9,74.73 31.56,74.39 31.56,74.08 31.22,73.74 30.91,73.74 30.57,73.4 30.57,73.11 30.2,72.75 29.92,72.75 29.58,72.41 29.58,72.09 29.24,71.75 28.93,71.75 28.59,71.42 28.59,71.1 28.25,70.76 27.93,70.76 27.59,70.42 27.59,70.11 27.25,69.77 26.94,69.77 26.66,69.48 arc(26.53,69.3) 26.49,69.09 26.49,67.28 arc(26.52,67.12) 26.61,66.98 arc(26.63,66.97) 26.65,66.95 arc(26.66,66.95) 26.66,66.94 arc(26.78,66.88) 26.91,66.86 27.66,66.86 arc(27.9,66.76) 28,66.52 28,66.34 arc(27.96,66.14) 27.85,65.97 YJ22.C34
FC1_TDN2: length 259.1
  TOP w0.147: U1.CC39 191.55,169.34 v4(191.5,169.34)
  SIG6 w0.112: v4(191.5,169.34) 191.27,169.34 arc(191.18,169.38) 191.15,169.47 191.15,169.64 arc(191.18,169.73) 191.27,169.77 191.77,169.77 arc(191.89,169.8) 192,169.87 192.05,169.92 arc(192.12,170.02) 192.14,170.15 192.14,173.66 192.24,173.75 192.24,173.77
  SIG6 w0.16: 192.24,173.77 192.24,174.97 arc(192.17,175.33) 191.96,175.64 187.52,180.08 arc(187.21,180.28) 186.85,180.36 160.6,180.36 arc(160.16,180.27) 159.79,180.02 157.42,177.66 arc(157.24,177.54) 157.03,177.49 148.31,177.49 arc(147.88,177.41) 147.5,177.16 103.78,133.43 arc(103.53,133.06) 103.44,132.62 103.44,130.46 arc(103.38,130.17) 103.22,129.92 83.95,110.65 arc(83.76,110.53) 83.55,110.49 57.45,110.49 arc(57.09,110.42) 56.78,110.21 34.74,88.17 arc(34.56,88.05) 34.35,88.01 28.87,88.01 arc(28.51,87.94) 28.21,87.73 26.31,85.83 arc(26.06,85.46) 25.97,85.03 25.97,77.09 arc(25.79,76.15) 25.25,75.35 17.56,67.66 arc(17.31,67.49) 17.02,67.43 16.96,67.43 arc(16.67,67.38) 16.42,67.21 15.55,66.34 arc(15.3,65.97) 15.21,65.53 15.21,64.51 arc(15.3,64.08) 15.55,63.7 15.9,63.35 arc(16.28,63.1) 16.71,63.01 27.99,63.01 arc(28.14,62.98) 28.26,62.9 28.32,62.85 arc(28.46,62.63) 28.51,62.38 28.51,62.16 arc(28.57,61.85) 28.75,61.58 28.9,61.43 29.12,61.22 arc(29.25,61.01) 29.3,60.77 YJ22.C3
FC1_TDN3: length 228.1
  TOP w0.147: U1.CE40 191.05,170.89 arc(190.92,171.21) v4(190.6,171.34)
  SIG7 w0.112: 189.92,173.48 189.92,173.45 190.01,173.36 190.01,172.21 arc(190.02,172.12) 190.06,172.04 arc(190.08,172.01) 190.1,171.98 190.19,171.9 arc(190.33,171.81) 190.5,171.77 190.82,171.77 arc(190.91,171.73) 190.95,171.64 190.95,171.51 arc(190.9,171.39) 190.79,171.34 v4(190.6,171.34)
  SIG7 w0.16: YJ22.C37 30.25,65.97 arc(30.36,66.14) 30.4,66.34 30.4,66.52 arc(30.3,66.76) 30.06,66.86 29.24,66.86 arc(28.99,66.96) 28.89,67.21 28.89,67.43 arc(28.84,67.7) 28.69,67.92 28.4,68.21 28.07,68.54 arc(28.02,68.62) 28,68.7 28,68.9 28.13,69.02 28.13,69.59 28,69.72 28,70.07 arc(28.03,70.22) 28.12,70.34 28.52,70.75 28.75,70.75 29.13,71.12 29.13,71.35 29.46,71.68 29.71,71.68 30.06,72.04 30.06,72.29 30.39,72.62 30.53,72.62 30.53,72.62 30.67,72.62 31,72.95 31,73.09 31,73.09 31,73.23 31.33,73.55 31.47,73.55 31.61,73.55 31.94,73.88 31.94,74.02 31.94,74.16 32.27,74.49 32.41,74.49 32.54,74.49 32.87,74.82 32.87,74.96 32.87,75.1 33.2,75.43 33.34,75.43 33.48,75.43 33.81,75.76 33.81,75.89 33.81,76.03 36.49,78.72 arc(36.7,79.02) 36.77,79.38 36.77,80.16 arc(36.81,80.37) 36.93,80.55 39.23,82.85 arc(39.47,83.22) 39.56,83.66 39.56,89.3 arc(39.6,89.51) 39.72,89.7 59.97,109.94 arc(60.15,110.06) 60.37,110.11 86.92,110.11 arc(87.28,110.18) 87.59,110.38 105.37,128.17 arc(105.82,128.84) 105.98,129.64 105.98,134.89 arc(106.02,135.11) 106.15,135.29 146.48,175.62 arc(146.66,175.75) 146.88,175.79 158.62,175.79 arc(158.98,175.86) 159.29,176.06 160.96,177.74 arc(161.15,177.86) 161.36,177.9 184.76,177.9 184.92,177.75 185.43,177.75 185.58,177.9 186.01,177.9 arc(186.23,177.86) 186.41,177.74 187,177.15 187,176.93 187.36,176.57 187.57,176.57 187.93,176.21 187.93,176 188.29,175.64 188.51,175.64 188.87,175.28 188.87,175.06 189.23,174.7 189.44,174.7 189.75,174.39 arc(189.87,174.21) 189.92,174 189.92,173.48
FC1_TDP0: length 255.5
  TOP w0.147: U1.CF38 193.05,171.89 arc(192.92,172.21) v4(192.6,172.34)
  SIG7 w0.112: 191.85,173.65 191.85,173.62 191.94,173.53 191.94,173.22 arc(191.96,173.13) 191.99,173.04 arc(192.01,173.01) 192.04,172.99 192.14,172.89 arc(192.26,172.8) 192.4,172.78 192.76,172.78 arc(192.89,172.72) 192.95,172.59 192.95,172.51 arc(192.9,172.39) 192.79,172.34 v4(192.6,172.34)
  SIG7 w0.16: 191.85,173.65 191.85,175.01 arc(191.81,175.22) 191.69,175.4 187.27,179.82 arc(187.09,179.94) 186.88,179.98 160.49,179.98 arc(160.28,179.94) 160.1,179.82 157.66,177.38 arc(157.36,177.18) 157,177.11 145.27,177.11 arc(145.06,177.06) 144.88,176.94 103.99,136.05 arc(103.87,135.87) 103.82,135.66 103.82,129.93 arc(103.75,129.57) 103.55,129.26 86.57,112.29 arc(86.27,112.08) 85.91,112.01 59.35,112.01 arc(59.14,111.97) 58.95,111.85 35.01,87.9 arc(34.71,87.7) 34.35,87.63 28.74,87.63 arc(28.53,87.58) 28.35,87.46 26.58,85.69 arc(26.41,85.44) 26.35,85.15 26.35,79.83 26.56,79.63 26.56,79.12 26.35,78.92 26.35,77.46 arc(26.21,76.73) 25.8,76.12 23.58,73.9 23.58,73.6 23.25,73.27 22.95,73.27 22.62,72.95 22.62,72.65 22.3,72.32 22,72.32 21.67,71.99 21.67,71.69 21.34,71.36 21.04,71.36 20.71,71.03 20.71,70.73 20.38,70.41 20.08,70.41 19.75,70.08 19.75,69.78 19.43,69.45 19.13,69.45 18.8,69.12 18.8,68.87 18.42,68.49 18.17,68.49 17.84,68.16 17.84,67.92 17.46,67.54 17.21,67.54 15.76,66.08 arc(15.64,65.9) 15.59,65.68 15.59,64.38 arc(15.64,64.17) 15.76,63.99 16.19,63.56 arc(16.37,63.44) 16.58,63.39 25.59,63.39 arc(25.88,63.34) 26.13,63.17 26.29,63.02 arc(26.46,62.9) 26.66,62.86 27.66,62.86 arc(27.9,62.76) 28,62.52 28,62.34 arc(27.96,62.14) 27.85,61.97 YJ22.C5
FC1_TDP1: length 230.3
  TOP w0.147: v4(191.5,167.34) 191.55,167.34 U1.CA39
  SIG6 w0.112: v4(191.5,167.34) 191.27,167.34 arc(191.18,167.38) 191.15,167.47 191.15,167.64 arc(191.05,167.87) 190.82,167.97 190.33,167.97 arc(190.29,167.98) 190.24,168.01 190.19,168.06 arc(190.16,168.1) 190.16,168.15 190.16,173.53 190.25,173.62 190.25,173.65
  SIG6 w0.16: YJ22.C33 26.9,64.84 arc(26.86,65.02) 26.76,65.17 26.35,65.58 arc(26.17,65.85) 26.11,66.16 26.11,69.09 arc(26.18,69.45) 26.39,69.75 36.16,79.53 arc(36.28,79.69) 36.36,79.87 arc(36.38,79.97) 36.39,80.07 36.39,80.2 arc(36.44,80.49) 36.61,80.74 38.96,83.09 arc(39.12,83.33) 39.18,83.63 39.18,89.3 arc(39.25,89.66) 39.46,89.97 58.18,108.69 arc(58.48,108.89) 58.84,108.96 84.97,108.96 arc(85.19,109.01) 85.37,109.13 105.38,129.14 arc(105.54,129.38) 105.6,129.68 105.6,131.83 arc(105.69,132.27) 105.94,132.64 149.13,175.84 arc(149.5,176.08) 149.94,176.17 158.66,176.17 arc(158.87,176.21) 159.05,176.34 160.66,177.94 arc(161.03,178.19) 161.47,178.27 182.08,178.27 arc(182.44,178.2) 182.74,178 183.93,176.81 arc(184.17,176.65) 184.47,176.59 187.52,176.59 arc(187.96,176.5) 188.33,176.26 189.95,174.63 arc(190.17,174.3) 190.25,173.91 190.25,173.65
FC1_TDP2: length 259.1
  TOP w0.147: U1.CC40 191.05,168.89 arc(190.92,169.21) v4(190.6,169.34)
  SIG6 w0.112: 191.86,173.77 191.86,173.75 191.95,173.66 191.95,170.15 arc(191.94,170.1) 191.91,170.06 191.86,170.01 arc(191.82,169.98) 191.77,169.97 191.27,169.97 arc(191.05,169.87) 190.95,169.64 190.95,169.47 arc(190.91,169.38) 190.82,169.34 v4(190.6,169.34)
  SIG6 w0.16: 191.86,173.77 191.86,174.97 arc(191.81,175.19) 191.69,175.37 187.25,179.81 arc(187.07,179.93) 186.85,179.97 160.6,179.97 arc(160.3,179.92) 160.06,179.75 157.69,177.39 arc(157.39,177.18) 157.03,177.11 148.31,177.11 arc(148.02,177.05) 147.77,176.89 104.05,133.16 arc(103.88,132.91) 103.82,132.62 103.82,130.46 arc(103.74,130.03) 103.49,129.65 84.22,110.38 arc(83.91,110.18) 83.55,110.11 57.45,110.11 arc(57.23,110.06) 57.05,109.94 35.01,87.9 arc(34.71,87.7) 34.35,87.63 28.87,87.63 arc(28.66,87.58) 28.47,87.46 26.58,85.56 arc(26.41,85.32) 26.35,85.03 26.35,79.7 26.56,79.5 26.56,78.99 26.35,78.79 26.35,77.09 arc(26.14,76) 25.52,75.08 23.78,73.34 23.78,73 23.46,72.69 23.13,72.69 22.79,72.35 22.79,72.01 22.47,71.69 22.13,71.69 21.79,71.35 21.79,71.04 21.46,70.7 21.14,70.7 20.8,70.36 20.8,70.03 20.49,69.71 20.15,69.71 19.81,69.37 19.81,69.03 19.5,68.72 19.16,68.72 18.82,68.38 18.82,68.04 18.51,67.73 18.17,67.73 17.83,67.39 arc(17.46,67.14) 17.02,67.05 16.96,67.05 arc(16.81,67.02) 16.69,66.94 15.82,66.07 arc(15.65,65.82) 15.59,65.53 15.59,64.51 arc(15.65,64.22) 15.82,63.97 16.17,63.62 arc(16.42,63.45) 16.71,63.39 27.99,63.39 arc(28.28,63.34) 28.53,63.17 28.62,63.08 arc(28.71,63.01) 28.81,62.95 arc(28.98,62.88) 29.16,62.86 30.06,62.86 arc(30.3,62.76) 30.4,62.52 30.4,62.34 arc(30.36,62.14) 30.25,61.97 YJ22.C2
FC1_TDP3: length 228.1
  TOP w0.147: U1.CE39 191.55,171.34 v4(191.5,171.34)
  SIG7 w0.112: v4(191.5,171.34) 191.31,171.34 arc(191.2,171.39) 191.15,171.51 191.15,171.64 arc(191.05,171.87) 190.82,171.97 190.5,171.97 arc(190.4,171.99) 190.32,172.04 190.24,172.12 arc(190.23,172.13) 190.23,172.14 arc(190.21,172.18) 190.21,172.21 190.21,173.36 190.3,173.45 190.3,173.48
  SIG7 w0.16: YJ22.C36 29.3,64.87 arc(29.27,65.02) 29.18,65.15 28.99,65.34 28.75,65.58 arc(28.57,65.85) 28.51,66.16 28.51,67.43 arc(28.49,67.55) 28.42,67.65 27.8,68.27 arc(27.67,68.47) 27.62,68.7 27.62,70.07 arc(27.68,70.36) 27.85,70.61 36.22,78.99 arc(36.34,79.17) 36.39,79.38 36.39,80.16 arc(36.46,80.52) 36.66,80.82 38.96,83.12 arc(39.12,83.36) 39.18,83.66 39.18,89.3 arc(39.25,89.66) 39.46,89.97 59.7,110.21 arc(60.01,110.42) 60.37,110.49 86.92,110.49 arc(87.14,110.53) 87.32,110.65 105.1,128.44 arc(105.47,128.99) 105.6,129.64 105.6,134.89 arc(105.67,135.25) 105.88,135.56 146.21,175.89 arc(146.52,176.1) 146.88,176.17 158.62,176.17 arc(158.84,176.21) 159.02,176.33 160.69,178.01 arc(161,178.21) 161.36,178.28 186.01,178.28 arc(186.37,178.21) 186.68,178.01 190.02,174.66 arc(190.23,174.36) 190.3,174 190.3,173.48
FC2_3_PVDD0P8: length 5.4
  TOP w0.229: U1.BG43 v1(187.55,153.34) ; U1.BG41 v1(189.55,153.34)
  TOP w0.381: C2991.1 208.72,194.03 ; C2991.1 208.13,193.39 ; C2991.1 209.32,193.39
  BOTTOM w0.13: v1(207.71,193.93) v2(206.95,193.93)
  BOTTOM w0.381: v1(189.55,153.34) 189.07,152.86 C2945.1 ; v1(187.55,153.34) 188.05,153.84 C3342.1
  vias: v1(207.71,193.04)
FC2_RDN0: length 243.4
  TOP w0.147: U1.BY43 188.05,165.91 arc(188.02,166.07) 187.92,166.22 187.86,166.27 arc(187.79,166.32) 187.7,166.34 v4(187.6,166.34)
  SIG3 w0.112: 187.86,173.63 187.86,173.61 187.95,173.51 187.95,166.75 arc(187.94,166.7) 187.91,166.66 v4(187.6,166.34)
  SIG3 w0.16: 187.86,173.63 187.86,176 arc(187.85,176.14) 187.81,176.27 arc(187.73,176.41) 187.63,176.54 184.42,179.75 arc(184.16,179.92) 183.86,179.98 148.26,179.98 arc(147.95,179.92) 147.69,179.75 87.8,119.85 arc(87.41,119.59) 86.96,119.5 66.94,119.5 arc(66.64,119.44) 66.38,119.27 51.21,104.1 arc(50.83,103.85) 50.37,103.76 43.7,103.76 arc(43.4,103.7) 43.14,103.52 39.78,100.17 arc(39.4,99.91) 38.94,99.82 36.32,99.82 arc(36.01,99.76) 35.75,99.59 22.27,86.1 arc(22.1,85.84) 22.03,85.54 22.03,80.34 arc(22.1,80.03) 22.27,79.77 23.52,78.52 arc(23.77,78.14) 23.86,77.69 23.86,75.84 arc(23.92,75.54) 24.1,75.28 24.53,74.85 25.6,73.77 25.96,73.77 26.32,73.41 26.32,73.05 26.68,72.69 27.04,72.69 27.4,72.33 27.4,71.98 27.76,71.62 28.12,71.62 28.48,71.26 28.48,70.9 28.94,70.44 29.24,70.44 29.66,70.02 29.66,69.72 30.01,69.36 30.29,69.36 30.73,68.92 30.73,68.64 31.09,68.28 arc(31.25,68.05) 31.31,67.77 31.31,67.47 arc(31.25,67.16) 31.07,66.9 31.03,66.86 arc(30.94,66.72) 30.91,66.57 30.91,66.08 arc(30.86,65.86) 30.74,65.67 30.28,65.22 arc(30.15,65.01) 30.1,64.77 YJ21.A21
FC2_RDN1: length 244.7
  TOP w0.147: U1.BV42 188.67,164.22 arc(188.59,164.27) v4(188.5,164.29)
  SIG3 w0.112: v4(188.5,164.29) 188.27,164.29 arc(188.18,164.33) 188.15,164.42 188.15,164.61 arc(188.05,164.84) 187.82,164.93 186.36,164.93 arc(186.32,164.94) 186.27,164.97 186.19,165.06 arc(186.16,165.1) 186.15,165.14 186.15,173.4 arc(186.17,173.5) 186.23,173.59 186.24,173.6 186.24,173.63
  SIG3 w0.16: YJ21.A14 26.75,61.97 arc(26.64,62.13) 26.61,62.32 26.61,62.54 arc(26.7,62.77) 26.93,62.86 27.76,62.86 arc(28.07,62.92) 28.33,63.1 28.41,63.18 arc(28.66,63.35) 28.95,63.41 30.38,63.41 arc(30.68,63.47) 30.94,63.64 31.44,64.14 arc(31.62,64.4) 31.68,64.71 31.68,66.08 arc(31.77,66.53) 32.02,66.91 32.34,67.23 arc(32.51,67.49) 32.58,67.8 32.58,69.33 arc(32.51,69.64) 32.34,69.9 26.32,75.92 arc(26.06,76.31) 25.97,76.76 25.97,86.45 arc(26.06,86.9) 26.32,87.29 32.89,93.86 arc(33.27,94.12) 33.73,94.21 40.47,94.21 arc(40.78,94.27) 41.04,94.44 48.1,101.51 arc(48.49,101.76) 48.94,101.85 53.96,101.85 arc(54.27,101.91) 54.53,102.09 69.82,117.38 arc(70.21,117.64) 70.66,117.73 87.75,117.73 arc(88.05,117.79) 88.31,117.96 110.03,139.68 148.29,177.93 arc(148.67,178.19) 149.12,178.28 182.76,178.28 arc(183.22,178.19) 183.6,177.93 184.64,176.89 arc(184.83,176.65) 184.94,176.37 arc(184.97,176.23) 184.97,176.09 184.97,175.56 arc(185.04,175.26) 185.21,175 186.01,174.2 arc(186.18,173.94) 186.24,173.63
FC2_RDN2: length 248.2
  TOP w0.147: v4(187.6,162.34) 187.6,162.22 arc(187.62,162.13) 187.67,162.04 187.75,161.96 arc(187.89,161.87) U1.BT43
  SIG2 w0.112: v4(187.6,162.34) 187.82,162.34 arc(187.91,162.38) 187.95,162.47 187.95,162.64 arc(187.91,162.73) 187.82,162.77 187.37,162.77 arc(187.25,162.8) 187.14,162.87 187.05,162.96 arc(186.98,163.07) 186.95,163.19 186.95,167.54 arc(186.98,167.66) 187.05,167.77 187.12,167.84 arc(187.23,167.91) 187.35,167.94 187.83,167.94 arc(187.92,167.97) 187.96,168.06 187.96,173.62 187.86,173.71 187.86,173.73
  SIG2 w0.16: YJ21.A24 27.7,64.79 arc(27.75,65.02) 27.88,65.21 28.34,65.67 arc(28.46,65.86) 28.51,66.08 28.51,66.41 arc(28.51,66.51) 28.53,66.61 arc(28.61,66.81) 28.74,66.97 29.07,67.3 arc(29.32,67.67) 29.4,68.09 29.4,68.6 29.55,68.76 29.55,69.47 29.4,69.62 29.4,70.53 arc(29.31,70.98) 29.05,71.37 28.63,71.79 28.63,72.15 28.27,72.51 27.91,72.51 27.55,72.87 27.55,73.23 27.2,73.59 26.84,73.59 26.48,73.95 26.48,74.3 26.12,74.66 25.76,74.66 25.4,75.02 25.4,75.41 25.07,75.74 24.68,75.74 24.1,76.32 arc(23.92,76.58) 23.86,76.89 23.86,77.72 arc(23.77,78.17) 23.52,78.56 22.27,79.8 arc(22.1,80.06) 22.03,80.37 22.03,85.52 arc(22.1,85.82) 22.27,86.08 43.64,107.46 arc(43.9,107.63) 44.21,107.69 51.9,107.69 arc(52.35,107.78) 52.73,108.04 56.47,111.78 arc(56.73,111.95) 57.04,112.01 79.48,112.01 arc(79.94,112.1) 80.32,112.36 110.3,142.34 147.7,179.74 arc(147.96,179.91) 148.27,179.97 183.48,179.97 arc(183.79,179.91) 184.05,179.74 187.63,176.16 arc(187.8,175.9) 187.86,175.59 187.86,173.73
FC2_RDN3: length 245.7
  TOP w0.147: v4(188.5,160.34) 188.55,160.34 U1.BP42
  SIG2 w0.112: v4(188.5,160.34) 188.27,160.34 arc(188.18,160.38) 188.15,160.47 188.15,160.64 arc(188.05,160.87) 187.82,160.97 186.37,160.97 arc(186.32,160.98) 186.28,161.01 186.18,161.1 arc(186.15,161.14) 186.14,161.19 186.14,173.49 186.24,173.58 186.24,173.61
  SIG2 w0.16: YJ21.A17 29.15,61.97 arc(29.04,62.13) 29.01,62.32 29.01,62.51 arc(29.11,62.76) 29.36,62.86 30.18,62.86 arc(30.36,62.88) 30.54,62.95 arc(30.54,62.95) 30.54,62.96 arc(30.63,63.01) 30.71,63.08 30.96,63.33 arc(31.49,64.13) 31.68,65.06 31.68,71.18 arc(31.62,71.48) 31.44,71.74 26.32,76.87 arc(26.06,77.25) 25.97,77.7 25.97,86.42 arc(26.06,86.86) 26.31,87.23 43.12,104.05 arc(43.5,104.3) 43.96,104.39 53.55,104.39 arc(53.86,104.45) 54.12,104.63 59.63,110.14 arc(60.01,110.4) 60.47,110.49 80.52,110.49 arc(80.83,110.55) 81.09,110.72 148.3,177.93 arc(148.68,178.19) 149.13,178.27 182.52,178.27 arc(182.97,178.19) 183.35,177.93 184.63,176.65 arc(184.7,176.57) 184.76,176.49 arc(184.92,176.18) 184.97,175.84 184.97,175.56 arc(185.03,175.26) 185.2,175 185.92,174.28 186.07,174.13 arc(186.19,173.95) 186.24,173.73 186.24,173.61
FC2_RDP0: length 243.3
  TOP w0.147: U1.BY42 188.55,166.34 v4(188.5,166.34)
  SIG3 w0.112: 188.24,173.63 188.24,173.61 188.15,173.51 188.15,166.75 arc(188.16,166.7) 188.18,166.66 v4(188.5,166.34)
  SIG3 w0.16: YJ21.A22 29.15,65.97 arc(29.04,66.13) 29.01,66.32 29.01,66.51 arc(29.11,66.76) 29.36,66.86 30.18,66.86 arc(30.35,66.88) 30.52,66.94 arc(30.53,66.95) 30.54,66.95 arc(30.54,66.95) 30.54,66.96 arc(30.63,67.01) 30.71,67.08 30.8,67.17 arc(30.89,67.31) 30.92,67.47 30.92,67.77 arc(30.9,67.9) 30.82,68.01 30.82,68.01 23.83,75.01 arc(23.57,75.39) 23.48,75.84 23.48,77.69 arc(23.42,78) 23.25,78.26 22,79.5 arc(21.74,79.89) 21.65,80.34 21.65,85.54 arc(21.74,85.99) 22,86.37 35.48,99.85 arc(35.86,100.11) 36.32,100.2 38.94,100.2 arc(39.25,100.26) 39.51,100.43 42.87,103.79 arc(43.25,104.05) 43.7,104.14 50.37,104.14 arc(50.68,104.2) 50.94,104.37 66.11,119.54 arc(66.49,119.8) 66.94,119.89 86.96,119.89 arc(87.27,119.95) 87.53,120.12 147.42,180.02 arc(147.81,180.27) 148.26,180.36 183.86,180.36 arc(184.31,180.27) 184.69,180.02 187.9,176.8 arc(188.05,176.62) 188.16,176.41 arc(188.22,176.21) 188.24,176 188.24,173.63
FC2_RDP1: length 244.7
  TOP w0.147: v4(187.6,164.29) 187.7,164.29 arc(187.81,164.27) 187.9,164.21 arc(188.01,164.04) U1.BV43
  SIG3 w0.112: v4(187.6,164.29) 187.79,164.29 arc(187.81,164.29) 187.84,164.3 187.87,164.31 arc(187.91,164.34) 187.93,164.38 187.94,164.4 arc(187.95,164.42) 187.95,164.45 187.95,164.61 arc(187.91,164.7) 187.82,164.73 186.36,164.73 arc(186.24,164.76) 186.14,164.83 185.99,164.97 arc(185.96,165.01) 185.95,165.06 185.95,173.41 arc(185.93,173.53) 185.86,173.63
  SIG3 w0.16: YJ21.A15 27.7,60.85 arc(27.73,61.02) 27.83,61.17 28.34,61.67 arc(28.46,61.86) 28.51,62.08 28.51,62.35 28.51,62.35 28.51,62.57 arc(28.54,62.72) 28.63,62.86 28.68,62.91 arc(28.81,63) 28.95,63.03 30.38,63.03 arc(30.83,63.12) 31.21,63.37 31.71,63.87 arc(31.97,64.26) 32.06,64.71 32.06,66.08 arc(32.12,66.39) 32.29,66.64 32.61,66.96 arc(32.87,67.34) 32.96,67.8 32.96,69.33 arc(32.87,69.78) 32.61,70.17 32.37,70.4 32.37,70.76 32.02,71.12 31.66,71.12 31.3,71.48 31.3,71.84 30.94,72.2 30.58,72.2 30.22,72.56 30.22,72.92 29.86,73.28 29.5,73.28 29.14,73.64 29.14,73.94 28.73,74.36 28.42,74.36 28.06,74.72 28.06,74.99 27.62,75.43 27.34,75.43 26.59,76.19 arc(26.41,76.45) 26.35,76.76 26.35,86.45 arc(26.41,86.76) 26.59,87.02 33.16,93.59 arc(33.42,93.76) 33.73,93.83 40.47,93.83 arc(40.93,93.91) 41.31,94.17 48.37,101.24 arc(48.63,101.41) 48.94,101.47 53.96,101.47 arc(54.41,101.56) 54.8,101.82 70.09,117.11 arc(70.35,117.28) 70.66,117.35 87.75,117.35 arc(88.2,117.44) 88.58,117.69 89.74,118.85 89.74,118.85 110.3,139.41 148.56,177.66 arc(148.82,177.84) 149.12,177.9 182.76,177.9 arc(183.07,177.84) 183.33,177.66 184.37,176.62 arc(184.49,176.46) 184.57,176.27 arc(184.59,176.18) 184.59,176.09 184.59,175.56 arc(184.68,175.11) 184.94,174.73 185.74,173.93 arc(185.83,173.79) 185.86,173.63
FC2_RDP2: length 248.2
  TOP w0.147: U1.BT42 189.01,161.86 arc(188.96,161.88) 188.93,161.91 v4(188.5,162.34)
  SIG2 w0.112: 188.24,173.73 188.24,173.71 188.15,173.62 188.15,168.06 arc(188.06,167.84) 187.83,167.74 187.35,167.74 arc(187.3,167.73) 187.26,167.7 187.19,167.63 arc(187.16,167.59) 187.15,167.54 187.15,163.19 arc(187.16,163.14) 187.19,163.1 187.28,163.01 arc(187.32,162.98) 187.37,162.97 187.82,162.97 arc(188.05,162.87) 188.15,162.64 188.15,162.47 arc(188.18,162.38) 188.27,162.34 v4(188.5,162.34)
  SIG2 w0.16: 188.24,173.73 188.24,175.59 arc(188.15,176.05) 187.9,176.43 184.32,180.01 arc(183.94,180.27) 183.48,180.36 148.27,180.36 arc(147.81,180.27) 147.43,180.01 109.92,142.5 80.05,112.63 arc(79.79,112.45) 79.48,112.39 57.04,112.39 arc(56.59,112.3) 56.2,112.05 52.46,108.31 arc(52.2,108.14) 51.9,108.07 44.21,108.07 arc(43.76,107.98) 43.37,107.73 22,86.35 arc(21.74,85.97) 21.65,85.52 21.65,80.37 arc(21.74,79.92) 22,79.53 23.25,78.29 arc(23.42,78.03) 23.48,77.72 23.48,76.89 arc(23.57,76.44) 23.83,76.05 28.79,71.1 arc(28.96,70.84) 29.02,70.53 29.02,68.09 arc(28.96,67.81) 28.8,67.57 28.43,67.2 arc(28.06,66.95) 27.62,66.86 26.92,66.86 arc(26.7,66.77) 26.61,66.54 26.61,66.32 arc(26.64,66.13) 26.75,65.97 YJ21.A25
FC2_RDP3: length 245.7
  TOP w0.147: v4(187.6,160.34) 187.6,160.24 arc(187.62,160.14) 187.67,160.06 187.79,159.95 arc(187.91,159.87) U1.BP43
  SIG2 w0.112: v4(187.6,160.34) 187.82,160.34 arc(187.91,160.38) 187.95,160.47 187.95,160.64 arc(187.91,160.73) 187.82,160.77 186.37,160.77 arc(186.24,160.8) 186.14,160.87 186.04,160.96 arc(185.97,161.07) 185.95,161.19 185.95,173.49 185.86,173.58 185.86,173.61
  SIG2 w0.16: YJ21.A18 30.1,60.77 arc(30.15,61.01) 30.29,61.23 30.74,61.67 arc(30.86,61.86) 30.91,62.08 30.91,62.41 arc(30.97,62.71) 31.14,62.97 31.23,63.06 arc(31.84,63.98) 32.06,65.06 32.06,69.67 32.24,69.84 32.24,70.51 32.06,70.68 32.06,71.18 arc(31.97,71.63) 31.71,72.01 31.13,72.59 31.13,72.95 30.78,73.31 30.42,73.31 30.06,73.67 30.06,74.03 29.7,74.39 29.34,74.39 28.98,74.75 28.98,75.1 28.62,75.46 28.26,75.46 27.9,75.82 27.9,76.18 27.54,76.54 27.18,76.54 26.59,77.14 arc(26.41,77.4) 26.35,77.7 26.35,86.42 26.35,86.42 arc(26.41,86.71) 26.58,86.96 43.39,103.78 arc(43.65,103.95) 43.96,104.01 53.55,104.01 arc(54,104.1) 54.38,104.36 59.9,109.87 arc(60.16,110.05) 60.47,110.11 80.52,110.11 arc(80.98,110.2) 81.36,110.45 148.57,177.66 arc(148.83,177.83) 149.13,177.89 182.52,177.89 arc(182.82,177.83) 183.08,177.66 184.36,176.38 arc(184.41,176.33) 184.45,176.27 arc(184.55,176.07) 184.59,175.84 184.59,175.56 arc(184.68,175.11) 184.93,174.73 185.65,174.01 185.71,173.95 arc(185.82,173.79) 185.86,173.61
FC2_TDN0: length 239.7
  TOP w0.147: U1.CB41 189.55,168.34 v4(189.5,168.34)
  SIG4 w0.112: 188.23,173.61 188.23,173.58 188.14,173.49 188.14,169.18 arc(188.15,169.13) 188.18,169.09 188.26,169.01 arc(188.3,168.98) 188.35,168.97 188.82,168.97 arc(189.05,168.87) 189.15,168.64 189.15,168.47 arc(189.18,168.38) 189.27,168.34 v4(189.5,168.34)
  SIG4 w0.16: YJ21.A37 17.15,65.97 arc(17.04,66.13) 17.01,66.32 17.01,66.53 arc(17.1,66.76) 17.34,66.86 18.18,66.86 arc(18.35,66.88) 18.52,66.94 arc(18.53,66.95) 18.54,66.95 arc(18.54,66.95) 18.54,66.96 arc(18.63,67.01) 18.71,67.08 19.81,68.17 arc(20.05,68.53) 20.13,68.96 20.13,78.76 arc(20.2,79.12) 20.41,79.42 20.98,80 arc(21.1,80.18) 21.15,80.4 21.15,85.11 arc(21.22,85.47) 21.42,85.77 43.45,107.8 arc(43.75,108) 44.11,108.07 51.11,108.07 arc(51.32,108.12) 51.5,108.24 60.21,116.94 arc(60.51,117.15) 60.87,117.22 84.38,117.22 arc(84.6,117.26) 84.78,117.38 147.42,180.02 arc(147.79,180.27) 148.23,180.36 183.83,180.36 arc(184.27,180.27) 184.64,180.02 187.9,176.76 arc(188.03,176.61) 188.13,176.43 arc(188.21,176.2) 188.23,175.95 188.23,173.61
FC2_TDN1: length 241.5
  TOP w0.147: U1.CD42 189.05,169.89 arc(188.92,170.21) v4(188.6,170.34)
  SIG5 w0.112: v4(188.6,170.34) 188.82,170.34 arc(188.91,170.38) 188.95,170.47 188.95,170.64 arc(189.05,170.87) 189.27,170.97 189.63,170.97 arc(189.75,170.99) 189.85,171.06 arc(189.89,171.1) 189.91,171.15 arc(189.94,171.21) 189.94,171.28 189.94,173.52 189.85,173.62 189.85,173.64
  SIG5 w0.16: YJ21.A33 20.5,64.73 arc(20.56,65.01) 20.71,65.25 20.9,65.44 21.13,65.67 arc(21.26,65.86) 21.31,66.09 21.31,66.51 arc(21.35,66.72) 21.47,66.9 21.57,67.01 arc(21.7,67.2) 21.75,67.43 21.75,67.94 arc(21.65,68.44) 21.37,68.86 21.08,69.15 20.73,69.5 arc(20.57,69.74) 20.51,70.04 20.51,70.8 20.66,70.95 20.66,71.71 20.51,71.86 20.51,72.63 20.66,72.78 20.66,73.54 20.51,73.69 20.51,74.46 20.66,74.61 20.66,75.37 20.51,75.52 20.51,76.9 arc(20.42,77.34) 20.18,77.71 19.91,77.97 arc(19.79,78.15) 19.75,78.37 19.75,84.52 arc(19.81,84.81) 19.97,85.06 29.18,94.26 arc(29.42,94.43) 29.72,94.49 30.2,94.49 arc(30.63,94.57) 31.01,94.82 43.84,107.66 arc(44.02,107.78) 44.24,107.82 48.06,107.82 arc(48.42,107.89) 48.73,108.1 59.97,119.34 arc(60.15,119.46) 60.37,119.5 87.05,119.5 arc(87.41,119.58) 87.72,119.78 147.7,179.77 arc(147.95,179.93) 148.24,179.99 183.43,179.99 183.55,179.86 184.37,179.86 184.49,179.99 185.23,179.99 185.33,179.89 186.14,179.89 186.25,179.99 186.78,179.99 arc(187.08,179.93) 187.32,179.77 188.33,178.76 188.33,178.59 188.92,178 189.09,178 189.63,177.46 arc(189.79,177.22) 189.85,176.92 189.85,176.47 189.65,176.26 189.65,175.76 189.85,175.55 189.85,175.1 189.67,174.92 189.67,174.36 189.85,174.18 189.85,173.64
FC2_TDN2: length 248.9
  TOP w0.147: U1.CF41 189.55,172.34 v4(189.5,172.34)
  SIG5 w0.112: v4(189.5,172.34) 189.27,172.34 arc(189.18,172.38) 189.15,172.47 189.15,172.64 arc(189.05,172.87) 188.82,172.97 188.47,172.97 arc(188.35,172.99) 188.25,173.06 arc(188.21,173.1) 188.18,173.15 arc(188.16,173.21) 188.16,173.28 188.16,173.59 188.25,173.69 188.25,173.71
  SIG5 w0.16: YJ21.A5 19.55,61.97 arc(19.44,62.13) 19.41,62.32 19.41,62.56 arc(19.5,62.77) 19.71,62.86 20.58,62.86 arc(20.87,62.92) 21.12,63.08 21.16,63.13 21.21,63.18 arc(21.46,63.35) 21.75,63.41 30.9,63.41 arc(31.19,63.46) 31.44,63.63 31.46,63.66 arc(31.63,63.9) 31.69,64.19 31.69,66.28 arc(31.64,66.5) 31.52,66.68 23,75.2 arc(22.76,75.57) 22.67,76.01 22.67,78.6 arc(22.63,78.82) 22.51,79 21.99,79.51 arc(21.74,79.89) 21.65,80.32 21.65,83.68 arc(21.74,84.12) 21.99,84.49 28.97,91.47 arc(29.22,91.63) 29.51,91.69 30.54,91.69 arc(30.75,91.73) 30.93,91.86 43.45,104.37 arc(43.75,104.57) 44.11,104.65 47.68,104.65 arc(47.89,104.69) 48.08,104.81 60.72,117.45 arc(61.02,117.65) 61.38,117.73 87.81,117.73 arc(88.03,117.77) 88.21,117.89 148.27,177.96 arc(148.64,178.2) 149.08,178.29 184.4,178.29 arc(184.86,178.2) 185.25,177.94 187.91,175.27 arc(188.16,174.9) 188.25,174.46 188.25,173.71
FC2_TDN3: length 247.9
  TOP w0.147: v4(186.6,169.34) 186.69,169.34 arc(186.78,169.32) 186.85,169.28 186.92,169.21 arc(187.01,169.07) 187.05,168.89 U1.CC44
  SIG4 w0.112: v4(186.6,169.34) 186.82,169.34 arc(186.91,169.38) 186.95,169.47 186.95,169.64 arc(186.91,169.73) 186.82,169.77 186.35,169.77 arc(186.23,169.8) 186.12,169.87 186.04,169.95 arc(185.97,170.05) 185.95,170.18 185.95,173.54 185.85,173.63
  SIG4 w0.16: YJ21.A3 18.1,60.77 arc(18.15,61.01) 18.29,61.22 18.54,61.48 18.73,61.67 arc(18.86,61.86) 18.91,62.09 18.91,62.57 arc(18.94,62.72) 19.03,62.86 19.08,62.91 arc(19.21,63) 19.35,63.03 30.76,63.03 arc(31.12,63.1) 31.42,63.3 31.78,63.66 arc(31.99,63.97) 32.06,64.33 32.06,66.44 arc(31.99,66.8) 31.78,67.11 31.48,67.42 31.48,67.77 31.12,68.13 30.76,68.13 30.4,68.49 30.4,68.85 30.04,69.21 29.68,69.21 29.32,69.57 29.32,69.93 28.96,70.29 28.6,70.29 28.24,70.65 28.24,70.98 27.86,71.37 27.53,71.37 27.18,71.72 arc(27.17,71.72) 27.17,71.72 27.14,71.75 26.66,72.28 arc(26.58,72.4) 26.53,72.53 26.36,73.24 arc(26.36,73.28) 26.35,73.33 26.35,73.33 26.35,73.96 26.56,74.17 26.56,74.67 26.35,74.88 26.35,86.51 arc(26.4,86.72) 26.52,86.9 43.08,103.47 arc(43.26,103.59) 43.48,103.63 50.35,103.63 arc(50.71,103.7) 51.01,103.9 58.95,111.85 arc(59.14,111.97) 59.35,112.01 82.5,112.01 arc(82.86,112.08) 83.17,112.29 148.55,177.67 arc(148.8,177.84) 149.09,177.89 182.73,177.89 arc(183.03,177.84) 183.27,177.67 184.4,176.55 arc(184.5,176.42) 184.57,176.27 arc(184.61,176.14) 184.62,176.01 184.62,175.5 arc(184.71,175.07) 184.95,174.69 185.74,173.91 arc(185.82,173.78) 185.85,173.63
FC2_TDP0: length 239.7
  TOP w0.147: U1.CB42 189.05,167.89 arc(189.01,168.07) 188.92,168.21 188.85,168.28 arc(188.78,168.32) 188.69,168.34 v4(188.6,168.34)
  SIG4 w0.112: 187.85,173.61 187.85,173.58 187.95,173.49 187.95,169.18 arc(187.97,169.05) 188.04,168.95 188.12,168.87 arc(188.23,168.8) 188.35,168.77 188.82,168.77 arc(188.91,168.73) 188.95,168.64 188.95,168.47 arc(188.91,168.38) 188.82,168.34 v4(188.6,168.34)
  SIG4 w0.16: 187.85,173.61 187.85,175.95 arc(187.84,176.12) 187.78,176.27 arc(187.72,176.39) 187.63,176.49 184.37,179.75 arc(184.12,179.92) 183.83,179.97 148.23,179.97 arc(147.93,179.92) 147.69,179.75 85.05,117.11 arc(84.74,116.91) 84.38,116.84 60.87,116.84 arc(60.66,116.79) 60.48,116.67 51.77,107.97 arc(51.47,107.77) 51.11,107.69 44.11,107.69 arc(43.9,107.65) 43.71,107.53 21.69,85.51 arc(21.57,85.32) 21.53,85.11 21.53,80.4 arc(21.46,80.04) 21.25,79.73 20.67,79.16 arc(20.55,78.97) 20.51,78.76 20.51,76.39 20.74,76.16 20.74,75.6 20.51,75.37 20.51,74.86 20.74,74.63 20.74,74.07 20.51,73.85 20.51,73.34 20.74,73.11 20.74,72.55 20.51,72.32 20.51,71.81 20.74,71.59 20.74,71.03 20.51,70.8 20.51,70.29 20.79,70.01 20.79,69.55 20.51,69.27 20.51,68.96 arc(20.4,68.39) 20.07,67.91 19.07,66.9 arc(18.95,66.72) 18.91,66.51 18.91,66.09 arc(18.86,65.86) 18.73,65.67 18.29,65.22 arc(18.15,65.01) 18.1,64.76 YJ21.A36
FC2_TDP1: length 241.5
  TOP w0.147: U1.CD41 189.55,170.34 v4(189.5,170.34)
  SIG5 w0.112: v4(189.5,170.34) 189.29,170.34 arc(189.23,170.35) 189.19,170.38 arc(189.16,170.43) 189.15,170.48 189.15,170.64 arc(189.18,170.73) 189.27,170.77 189.63,170.77 arc(189.82,170.81) 189.99,170.92 arc(190.05,170.99) 190.09,171.07 arc(190.13,171.17) 190.14,171.28 190.14,173.52 190.23,173.62 190.23,173.64
  SIG5 w0.16: YJ21.A34 19.55,65.97 arc(19.44,66.13) 19.41,66.32 19.41,66.52 arc(19.51,66.76) 19.75,66.86 20.58,66.86 arc(20.76,66.88) 20.94,66.95 arc(20.94,66.95) 20.94,66.96 arc(21.03,67.01) 21.12,67.08 21.31,67.27 arc(21.35,67.35) 21.37,67.43 21.37,67.94 arc(21.3,68.29) 21.1,68.59 20.81,68.88 20.46,69.23 arc(20.22,69.6) 20.13,70.04 20.13,76.9 arc(20.07,77.19) 19.91,77.44 19.64,77.7 arc(19.44,78.01) 19.37,78.37 19.37,84.52 arc(19.45,84.96) 19.7,85.33 28.91,94.53 arc(29.28,94.78) 29.72,94.87 30.2,94.87 arc(30.49,94.92) 30.74,95.09 43.57,107.93 arc(43.88,108.13) 44.24,108.2 48.06,108.2 arc(48.28,108.24) 48.46,108.37 59.7,119.61 arc(60.01,119.81) 60.37,119.89 87.05,119.89 arc(87.26,119.93) 87.45,120.05 147.43,180.04 arc(147.8,180.28) 148.24,180.37 186.78,180.37 arc(187.22,180.28) 187.59,180.04 189.9,177.73 arc(190.14,177.36) 190.23,176.92 190.23,173.64
FC2_TDP2: length 248.9
  TOP w0.147: U1.CF42 189.05,171.89 arc(188.92,172.21) v4(188.6,172.34)
  SIG5 w0.112: v4(188.6,172.34) 188.81,172.34 arc(188.86,172.35) 188.91,172.38 arc(188.94,172.43) 188.95,172.48 188.95,172.64 arc(188.91,172.73) 188.82,172.77 188.47,172.77 arc(188.27,172.81) 188.11,172.92 arc(188.05,172.99) 188,173.07 arc(187.97,173.17) 187.96,173.28 187.96,173.59 187.87,173.69 187.87,173.71
  SIG5 w0.16: YJ21.A6 20.5,60.85 arc(20.53,61.02) 20.63,61.16 21.13,61.67 arc(21.26,61.86) 21.31,62.09 21.31,62.57 arc(21.34,62.72) 21.43,62.86 21.48,62.91 arc(21.61,63) 21.75,63.03 30.9,63.03 arc(31.34,63.11) 31.71,63.36 31.73,63.39 arc(31.98,63.76) 32.07,64.19 32.07,66.28 arc(32,66.64) 31.79,66.95 31.24,67.5 31.24,67.72 30.7,68.26 30.48,68.26 29.95,68.79 29.95,69.01 29.41,69.55 29.19,69.55 28.65,70.09 28.65,70.3 28.11,70.84 27.9,70.84 27.36,71.38 27.36,71.57 26.79,72.14 26.6,72.14 26.07,72.67 26.07,72.86 25.5,73.43 25.31,73.43 24.77,73.97 24.77,74.18 24.23,74.72 24.02,74.72 23.27,75.47 arc(23.11,75.71) 23.05,76.01 23.05,78.6 arc(22.98,78.96) 22.78,79.27 22.26,79.78 arc(22.09,80.03) 22.03,80.32 22.03,83.68 arc(22.09,83.97) 22.26,84.22 29.24,91.2 arc(29.36,91.28) 29.51,91.31 30.54,91.31 arc(30.89,91.38) 31.2,91.59 43.71,104.1 arc(43.9,104.22) 44.11,104.26 47.68,104.26 arc(48.04,104.34) 48.35,104.54 60.99,117.18 arc(61.17,117.3) 61.38,117.35 87.81,117.35 arc(88.17,117.42) 88.48,117.62 148.54,177.69 arc(148.79,177.85) 149.08,177.91 182.59,177.91 182.74,177.76 183.51,177.76 183.66,177.91 184.4,177.91 arc(184.71,177.85) 184.98,177.67 185.5,177.15 185.5,176.93 186.04,176.39 186.25,176.39 187.64,175 arc(187.81,174.76) 187.87,174.46 187.87,173.71
FC2_TDP3: length 247.9
  TOP w0.147: v4(187.5,169.34) 187.55,169.34 U1.CC43
  SIG4 w0.112: 186.23,173.63 186.23,173.61 186.14,173.51 186.14,170.18 arc(186.15,170.13) 186.18,170.09 186.26,170.01 arc(186.3,169.98) 186.35,169.97 186.82,169.97 arc(187.05,169.87) 187.15,169.64 187.15,169.47 arc(187.18,169.38) 187.27,169.34 v4(187.5,169.34)
  SIG4 w0.16: YJ21.A2 17.15,61.97 arc(17.04,62.13) 17.01,62.32 17.01,62.56 arc(17.1,62.77) 17.31,62.86 18.18,62.86 arc(18.47,62.92) 18.71,63.08 18.81,63.18 arc(19.06,63.35) 19.35,63.41 30.76,63.41 arc(30.97,63.45) 31.15,63.57 31.52,63.93 arc(31.64,64.11) 31.68,64.33 31.68,66.44 arc(31.64,66.66) 31.52,66.84 26.9,71.46 26.63,71.75 26.21,72.21 25.99,73.16 arc(25.98,73.24) 25.97,73.33 25.97,86.51 arc(26.04,86.87) 26.25,87.17 42.81,103.74 arc(43.12,103.94) 43.48,104.01 50.35,104.01 arc(50.56,104.05) 50.74,104.17 58.69,112.12 arc(58.99,112.32) 59.35,112.39 82.5,112.39 arc(82.72,112.44) 82.9,112.56 148.28,177.94 arc(148.65,178.19) 149.09,178.27 182.73,178.27 arc(183.17,178.19) 183.54,177.94 184.67,176.82 arc(184.82,176.63) 184.93,176.41 arc(184.98,176.21) 185,176.01 185,175.5 arc(185.06,175.21) 185.22,174.96 186.01,174.18 arc(186.18,173.93) 186.23,173.63
FC3_RDN0: length 227.5
  TOP w0.147: v4(184.6,166.34) 184.7,166.34 arc(184.79,166.32) 184.87,166.27 184.92,166.22 arc(185.02,166.08) 185.05,165.91 U1.BY46
  SIG3 w0.112: v4(184.6,166.34) 184.82,166.34 arc(184.91,166.38) 184.95,166.47 184.95,167.58 arc(184.91,167.67) 184.82,167.71 184.38,167.71 arc(184.26,167.73) 184.15,167.8 184.05,167.9 arc(183.98,168.01) 183.95,168.13 183.95,172.26 arc(183.89,172.57) 183.72,172.83 183.35,173.2 arc(183.24,173.37) 183.2,173.56 183.2,173.84 183.11,173.94 183.11,173.96
  SIG3 w0.16: YJ21.B21 30.1,56.78 arc(30.15,57.02) 30.28,57.22 30.74,57.67 arc(30.86,57.86) 30.91,58.08 30.91,58.57 arc(30.94,58.72) 31.03,58.86 31.39,59.22 31.74,59.22 32.1,59.57 32.1,59.93 33.03,60.86 arc(33.29,61.25) 33.38,61.7 33.38,65.77 arc(33.44,66.08) 33.61,66.34 34.38,67.11 arc(34.55,67.36) 34.61,67.65 34.61,68.16 34.86,68.41 34.86,68.92 34.61,69.17 34.61,69.68 34.86,69.93 34.86,70.44 34.61,70.7 34.61,72.26 34.84,72.49 34.84,72.9 34.61,73.12 34.61,73.78 34.79,73.96 34.79,74.47 34.61,74.65 34.61,77.9 arc(34.67,78.2) 34.84,78.46 39.21,82.84 arc(39.47,83.22) 39.56,83.67 39.56,89.07 arc(39.62,89.38) 39.8,89.64 49.23,99.08 arc(49.49,99.25) 49.8,99.31 54.85,99.31 arc(55.3,99.4) 55.69,99.66 64.38,108.35 arc(64.64,108.52) 64.94,108.58 81.93,108.58 arc(82.38,108.67) 82.77,108.93 149.42,175.58 arc(149.68,175.76) 149.98,175.82 181.64,175.82 arc(181.95,175.76) 182.21,175.58 182.87,174.92 arc(183.04,174.66) 183.11,174.35 183.11,173.96
FC3_RDN1: length 229.3
  TOP w0.147: U1.BV45 185.67,164.22 arc(185.59,164.27) v4(185.5,164.29)
  SIG3 w0.112: 182.26,172.72 182.26,172.69 182.17,172.6 182.17,167.22 arc(182.18,167.17) 182.2,167.13 182.34,166.99 arc(182.38,166.97) 182.43,166.96 183.75,166.96 arc(183.87,166.93) 183.98,166.86 184.05,166.79 arc(184.12,166.69) 184.14,166.56 184.14,165.16 arc(184.15,165.11) 184.18,165.07 184.29,164.97 arc(184.33,164.94) 184.38,164.93 184.82,164.93 arc(185.05,164.84) 185.15,164.61 185.15,164.42 arc(185.18,164.33) 185.27,164.29 v4(185.5,164.29)
  SIG3 w0.16: YJ21.B17 29.15,53.97 arc(29.04,54.13) 29.01,54.32 29.01,54.54 arc(29.1,54.77) 29.32,54.86 30.16,54.86 arc(30.47,54.92) 30.73,55.1 33.99,58.36 arc(34.24,58.73) 34.33,59.18 34.33,65.22 arc(34.42,65.67) 34.67,66.05 36.22,67.6 arc(36.4,67.86) 36.46,68.17 36.46,75.68 arc(36.55,76.14) 36.8,76.52 38.31,78.03 arc(38.48,78.29) 38.54,78.59 38.54,79.04 arc(38.63,79.49) 38.89,79.88 41.36,82.34 arc(41.53,82.6) 41.59,82.91 41.59,88.54 arc(41.68,88.99) 41.94,89.38 49.31,96.74 arc(49.69,97) 50.14,97.09 55.14,97.09 arc(55.44,97.15) 55.7,97.32 64.94,106.56 arc(65.32,106.82) 65.77,106.91 82.82,106.91 arc(83.13,106.97) 83.38,107.14 150.01,173.77 arc(150.4,174.02) 150.85,174.11 180.99,174.11 arc(181.44,174.02) 181.82,173.77 182.04,173.55 arc(182.2,173.31) 182.26,173.02 182.26,172.72
FC3_RDN2: length 234
  TOP w0.147: v4(184.6,162.34) 184.6,162.25 arc(184.62,162.15) 184.67,162.07 184.8,161.94 arc(184.91,161.87) U1.BT46
  SIG2 w0.112: 183.11,173.96 183.11,173.94 183.21,173.84 183.21,173.56 arc(183.24,173.37) 183.35,173.2 183.72,172.84 arc(183.89,172.58) 183.95,172.27 183.95,163.11 arc(183.96,163.06) 183.99,163.02 184.14,162.87 arc(184.25,162.8) 184.37,162.77 184.82,162.77 arc(184.91,162.73) 184.95,162.64 184.95,162.49 arc(184.94,162.43) 184.91,162.39 arc(184.86,162.35) 184.8,162.34 v4(184.6,162.34)
  SIG2 w0.16: 183.11,173.96 183.11,174.52 arc(183.08,174.66) 183,174.79 182.21,175.58 arc(181.95,175.75) 181.64,175.81 150,175.81 arc(149.69,175.75) 149.43,175.58 82.78,108.93 arc(82.4,108.67) 81.95,108.58 61.89,108.58 arc(61.59,108.52) 61.33,108.35 54.42,101.44 arc(54.03,101.18) 53.58,101.09 51.61,101.09 arc(51.3,101.03) 51.04,100.86 39.8,89.61 arc(39.62,89.35) 39.56,89.04 39.56,83.64 arc(39.47,83.19) 39.21,82.81 38.11,81.7 38.11,81.41 37.75,81.06 37.46,81.06 37.11,80.7 37.11,80.41 36.75,80.05 36.46,80.05 36.03,79.62 36.03,79.33 35.67,78.97 35.38,78.97 34.84,78.43 arc(34.67,78.17) 34.61,77.87 34.61,76.16 34.81,75.96 34.81,75.45 34.61,75.25 34.61,73.32 34.81,73.12 34.81,72.61 34.61,72.4 34.61,70.47 34.81,70.27 34.81,69.76 34.61,69.56 34.61,69.05 arc(34.52,68.61) 34.27,68.24 33.61,67.58 arc(33.44,67.32) 33.38,67.02 33.38,61.46 arc(33.29,61) 33.03,60.62 31.78,59.37 arc(31.4,59.12) 30.95,59.03 29.03,59.03 arc(28.81,58.98) 28.63,58.86 arc(28.54,58.72) 28.51,58.57 28.51,58.22 arc(28.44,57.87) 28.24,57.57 27.85,57.18 arc(27.74,57.02) 27.7,56.83 YJ21.B24
FC3_RDN3: length 235.7
  TOP w0.147: v4(185.5,160.34) 185.55,160.34 U1.BP45
  SIG2 w0.112: 182.22,172.69 182.22,172.67 182.13,172.57 182.13,167.27 arc(182.15,167.16) 182.22,167.06 182.25,167.03 arc(182.31,166.98) 182.39,166.97 182.7,166.97 arc(182.86,166.94) 183,166.85 arc(183.09,166.71) 183.12,166.55 183.12,161.32 arc(183.14,161.18) 183.22,161.07 arc(183.33,160.99) 183.47,160.97 184.82,160.97 arc(185.05,160.87) 185.15,160.64 185.15,160.47 arc(185.18,160.38) 185.27,160.34 v4(185.5,160.34)
  SIG2 w0.16: 182.22,172.69 182.22,172.87 arc(182.17,173.16) 182,173.41 181.64,173.77 arc(181.26,174.02) 180.8,174.11 150.86,174.11 arc(150.41,174.02) 150.03,173.77 83.38,107.12 arc(83.12,106.94) 82.81,106.88 65.75,106.88 arc(65.3,106.79) 64.91,106.53 55.64,97.26 arc(55.38,97.09) 55.07,97.03 50.08,97.03 arc(49.63,96.94) 49.24,96.68 41.94,89.38 arc(41.68,88.99) 41.59,88.54 41.59,82.88 arc(41.53,82.57) 41.36,82.31 38.88,79.83 arc(38.63,79.46) 38.54,79.03 38.54,70.31 arc(38.48,70) 38.31,69.74 34.69,66.12 arc(34.43,65.73) 34.34,65.28 34.34,58.86 arc(34.28,58.56) 34.11,58.3 31.45,55.64 arc(31.19,55.47) 30.88,55.41 29.03,55.41 arc(28.67,55.33) 28.36,55.13 28.31,55.08 arc(28.23,55.01) 28.14,54.96 arc(28.14,54.95) 28.14,54.95 arc(28.13,54.95) 28.12,54.94 arc(27.95,54.88) 27.78,54.86 26.85,54.86 arc(26.68,54.79) 26.61,54.62 26.61,54.32 arc(26.64,54.13) 26.75,53.97 YJ21.B14
FC3_RDP0: length 227.5
  TOP w0.147: v4(185.5,166.34) 185.55,166.34 U1.BY45
  SIG3 w0.112: v4(185.5,166.34) 185.27,166.34 arc(185.18,166.38) 185.15,166.47 185.15,167.58 arc(185.05,167.81) 184.82,167.9 184.38,167.9 arc(184.33,167.91) 184.29,167.94 184.19,168.04 arc(184.16,168.08) 184.15,168.13 184.15,172.26 arc(184.08,172.65) 183.86,172.97 183.49,173.34 arc(183.42,173.44) 183.39,173.56 183.39,173.84 183.49,173.94 183.49,173.96
  SIG3 w0.16: YJ21.B22 29.15,57.97 arc(29.04,58.13) 29.01,58.32 29.01,58.54 arc(29.1,58.77) 29.33,58.86 30.16,58.86 arc(30.47,58.92) 30.73,59.1 32.76,61.13 arc(32.94,61.39) 33,61.7 33,65.77 arc(33.09,66.22) 33.34,66.61 34.11,67.38 arc(34.2,67.5) 34.23,67.65 34.23,77.9 arc(34.32,78.35) 34.57,78.73 38.95,83.11 arc(39.12,83.37) 39.18,83.67 39.18,89.07 arc(39.27,89.53) 39.53,89.91 48.96,99.35 arc(49.35,99.6) 49.8,99.69 54.85,99.69 arc(55.16,99.75) 55.42,99.93 64.11,108.62 arc(64.49,108.87) 64.94,108.96 81.93,108.96 arc(82.24,109.02) 82.5,109.2 149.15,175.85 arc(149.53,176.11) 149.98,176.2 181.64,176.2 arc(182.1,176.11) 182.48,175.85 183.14,175.19 arc(183.4,174.81) 183.49,174.35 183.49,173.96
FC3_RDP1: length 229.3
  TOP w0.147: v4(184.6,164.29) 184.7,164.29 arc(184.78,164.27) 184.86,164.22 184.92,164.16 arc(185.02,164.02) 185.05,163.85 U1.BV46
  SIG3 w0.112: v4(184.6,164.29) 184.82,164.29 arc(184.91,164.33) 184.95,164.42 184.95,164.61 arc(184.91,164.7) 184.82,164.73 184.38,164.73 arc(184.25,164.76) 184.15,164.83 184.04,164.93 arc(183.97,165.04) 183.95,165.16 183.95,166.56 arc(183.94,166.61) 183.91,166.65 183.84,166.72 arc(183.8,166.75) 183.75,166.76 182.43,166.76 arc(182.3,166.78) 182.2,166.85 182.01,167.04 arc(181.98,167.09) 181.97,167.13 181.97,172.6 181.88,172.69 181.88,172.72
  SIG3 w0.16: 181.88,172.72 181.88,173.02 arc(181.85,173.16) 181.77,173.28 181.55,173.5 arc(181.29,173.67) 180.99,173.73 150.85,173.73 arc(150.54,173.67) 150.28,173.5 83.65,106.87 arc(83.27,106.61) 82.82,106.53 65.77,106.53 arc(65.47,106.46) 65.21,106.29 55.97,97.05 arc(55.59,96.8) 55.14,96.71 50.14,96.71 arc(49.83,96.65) 49.58,96.47 42.21,89.11 arc(42.03,88.85) 41.97,88.54 41.97,82.91 arc(41.88,82.46) 41.63,82.07 39.16,79.61 arc(38.99,79.35) 38.93,79.04 38.93,78.59 arc(38.84,78.14) 38.58,77.76 37.07,76.25 arc(36.9,75.99) 36.84,75.68 36.84,68.17 arc(36.75,67.72) 36.49,67.33 34.94,65.78 arc(34.77,65.52) 34.71,65.22 34.71,64.26 34.94,64.03 34.94,63.47 34.71,63.24 34.71,62.71 34.94,62.48 34.94,61.92 34.71,61.69 34.71,60.42 34.91,60.22 34.91,59.71 34.71,59.51 34.71,59.18 arc(34.59,58.59) 34.26,58.09 33.18,57.01 33.18,56.65 32.82,56.29 32.46,56.29 32.1,55.93 32.1,55.57 31.74,55.22 31.39,55.22 31.03,54.86 arc(30.94,54.72) 30.91,54.57 30.91,54.08 arc(30.86,53.86) 30.74,53.67 30.28,53.22 arc(30.15,53.01) 30.1,52.77 YJ21.B18
FC3_RDP2: length 234
  TOP w0.147: v4(185.5,162.34) 185.55,162.34 U1.BT45
  SIG2 w0.112: v4(185.5,162.34) 185.27,162.34 arc(185.18,162.38) 185.15,162.47 185.15,162.64 arc(185.05,162.87) 184.82,162.97 184.37,162.97 arc(184.32,162.98) 184.28,163.01 184.19,163.1 arc(184.16,163.14) 184.15,163.19 184.15,172.27 arc(184.07,172.66) 183.86,172.98 183.49,173.34 arc(183.43,173.44) 183.4,173.56 183.4,173.84 183.49,173.94 183.49,173.96
  SIG2 w0.16: YJ21.B25 26.75,57.97 arc(26.64,58.13) 26.61,58.32 26.61,58.59 arc(26.69,58.78) 26.88,58.86 27.78,58.86 arc(27.95,58.88) 28.12,58.94 arc(28.12,58.95) 28.13,58.95 arc(28.13,58.95) 28.14,58.95 arc(28.14,58.95) 28.14,58.96 arc(28.23,59.01) 28.31,59.08 28.36,59.13 arc(28.67,59.33) 29.03,59.41 30.95,59.41 arc(31.25,59.47) 31.51,59.64 32.76,60.89 arc(32.94,61.15) 33,61.46 33,67.02 arc(33.09,67.47) 33.34,67.85 34,68.51 arc(34.17,68.76) 34.23,69.05 34.23,69.05 34.23,77.87 arc(34.32,78.32) 34.57,78.7 38.95,83.08 arc(39.12,83.33) 39.18,83.64 39.18,89.04 arc(39.27,89.5) 39.53,89.88 50.77,101.12 arc(51.16,101.38) 51.61,101.47 53.58,101.47 arc(53.89,101.53) 54.15,101.7 61.06,108.62 arc(61.44,108.87) 61.89,108.96 81.95,108.96 arc(82.25,109.02) 82.51,109.2 149.16,175.85 arc(149.55,176.1) 150,176.19 181.64,176.19 arc(182.1,176.1) 182.48,175.85 183.27,175.06 arc(183.44,174.81) 183.49,174.52 183.49,173.96
FC3_RDP3: length 235.7
  TOP w0.147: U1.BP46 185,159.84 arc(184.91,159.86) 184.82,159.92 184.67,160.07 arc(184.62,160.15) 184.6,160.24 v4(184.6,160.34)
  SIG2 w0.112: 181.84,172.69 181.84,172.67 181.93,172.57 181.93,167.27 arc(181.97,167.08) 182.08,166.92 182.11,166.89 arc(182.24,166.8) 182.39,166.77 182.7,166.77 arc(182.79,166.76) 182.86,166.71 arc(182.9,166.64) 182.92,166.55 182.92,161.32 arc(182.96,161.11) 183.08,160.93 arc(183.26,160.81) 183.47,160.77 184.82,160.77 arc(184.91,160.73) 184.95,160.64 184.95,160.47 arc(184.91,160.38) 184.82,160.34 v4(184.6,160.34)
  SIG2 w0.16: 181.84,172.69 181.84,172.87 arc(181.81,173.01) 181.73,173.14 181.37,173.5 arc(181.11,173.67) 180.8,173.73 150.86,173.73 arc(150.56,173.67) 150.3,173.5 83.65,106.85 arc(83.26,106.59) 82.81,106.5 65.75,106.5 arc(65.44,106.44) 65.18,106.27 55.91,96.99 arc(55.53,96.73) 55.07,96.64 50.08,96.64 arc(49.77,96.58) 49.51,96.41 42.21,89.11 arc(42.03,88.85) 41.97,88.54 41.97,85.93 42.18,85.72 42.18,85.21 41.97,85.01 41.97,82.88 arc(41.88,82.43) 41.63,82.04 40.15,80.57 40.15,80.28 39.8,79.92 39.51,79.92 39.15,79.56 arc(38.98,79.32) 38.93,79.03 38.93,78.2 39.13,78 39.13,77.49 38.93,77.29 38.93,76.78 39.13,76.58 39.13,76.07 38.93,75.87 38.93,75.36 39.13,75.16 39.13,74.65 38.93,74.44 38.93,71.83 39.13,71.63 39.13,71.12 38.93,70.91 38.93,70.31 arc(38.84,69.85) 38.58,69.47 34.96,65.85 arc(34.78,65.59) 34.72,65.28 34.72,58.86 arc(34.63,58.41) 34.38,58.03 31.72,55.37 arc(31.34,55.12) 30.88,55.03 29.03,55.03 arc(28.81,54.98) 28.63,54.86 arc(28.54,54.72) 28.51,54.57 28.51,54.08 arc(28.46,53.86) 28.34,53.67 27.87,53.2 arc(27.74,53.02) 27.7,52.8 YJ21.B15
FC3_TDN0: length 246.4
  TOP w0.147: U1.CE43 187.55,171.34 v4(187.5,171.34)
  SIG5 w0.112: 186.25,173.63 186.25,173.6 186.16,173.51 186.16,172.28 arc(186.16,172.21) 186.18,172.15 arc(186.21,172.1) 186.25,172.06 arc(186.35,171.99) 186.47,171.97 186.82,171.97 arc(187.05,171.87) 187.15,171.64 187.15,171.47 arc(187.18,171.38) 187.27,171.34 v4(187.5,171.34)
  SIG5 w0.16: YJ21.B34 19.55,57.97 arc(19.44,58.13) 19.41,58.32 19.41,58.51 arc(19.51,58.76) 19.76,58.86 20.58,58.86 arc(20.87,58.92) 21.12,59.08 21.21,59.18 arc(21.46,59.35) 21.75,59.41 32.45,59.41 arc(32.84,59.57) 33.01,59.97 33.01,69.03 arc(32.96,69.24) 32.84,69.42 26.2,76.07 arc(26.03,76.32) 25.97,76.61 25.97,85.23 arc(26.03,85.53) 26.2,85.77 28.15,87.73 arc(28.46,87.94) 28.82,88.01 34.35,88.01 arc(34.56,88.05) 34.74,88.17 58.69,112.12 arc(58.99,112.32) 59.35,112.39 85.48,112.39 arc(85.69,112.44) 85.87,112.56 149.19,175.88 arc(149.56,176.12) 150,176.21 183.14,176.21 arc(183.91,176.06) 184.57,175.62 186.02,174.16 arc(186.19,173.92) 186.25,173.63
FC3_TDN1: length 239.8
  TOP w0.147: v4(184.6,168.32) 184.7,168.32 arc(184.8,168.3) 184.88,168.24 184.93,168.19 arc(185.02,168.06) 185.05,167.9 U1.CB46
  SIG4 w0.112: v4(184.6,168.32) 184.82,168.32 arc(184.91,168.35) 184.95,168.44 184.95,168.59 arc(184.91,168.69) 184.81,168.73 182.31,168.73 arc(182.05,168.84) 181.95,169.09 181.95,172.52 181.85,172.62 181.85,172.64
  SIG4 w0.16: YJ21.B3 18.1,52.8 arc(18.14,53.02) 18.26,53.2 18.73,53.67 arc(18.86,53.86) 18.91,54.09 18.91,54.57 arc(18.94,54.72) 19.03,54.86 19.08,54.91 arc(19.21,55) 19.35,55.03 31.33,55.03 arc(31.69,55.1) 32,55.3 32.31,55.61 32.67,55.61 33.02,55.97 33.02,56.33 33.38,56.69 33.74,56.69 34.1,57.04 34.1,57.4 34.42,57.72 arc(34.62,58.03) 34.7,58.39 34.7,61.85 34.93,62.08 34.93,62.63 34.7,62.86 34.7,63.5 34.93,63.73 34.93,64.28 34.7,64.51 34.7,65.78 34.93,66.01 34.93,66.57 34.7,66.8 34.7,68.96 arc(34.75,69.25) 34.92,69.5 35.28,69.86 37.62,72.2 38.65,73.23 arc(38.85,73.53) 38.93,73.89 38.93,79.06 arc(38.98,79.35) 39.15,79.6 41.7,82.15 arc(41.9,82.45) 41.97,82.81 41.97,91.53 arc(42.03,91.82) 42.2,92.07 49.28,99.15 arc(49.46,99.27) 49.67,99.31 54.92,99.31 arc(55.28,99.38) 55.58,99.59 62.36,106.36 arc(62.54,106.48) 62.75,106.53 82.91,106.53 arc(83.27,106.6) 83.57,106.8 150.28,173.51 arc(150.53,173.68) 150.82,173.73 180.93,173.73 arc(181.22,173.68) 181.47,173.51 181.68,173.29 arc(181.81,173.1) 181.85,172.88 181.85,172.64
FC3_TDN2: length 238.5
  TOP w0.147: U1.CD45 185.55,170.34 v4(185.5,170.34)
  SIG4 w0.112: v4(185.5,170.34) 185.27,170.34 arc(185.18,170.38) 185.15,170.47 185.15,170.64 arc(185.05,170.87) 184.82,170.97 184.35,170.97 arc(184.3,170.98) 184.26,171.01 184.18,171.09 arc(184.15,171.13) 184.14,171.18 184.14,172.35 arc(184.08,172.64) 183.92,172.88 183.51,173.29 arc(183.44,173.39) 183.42,173.51 183.42,173.79 183.51,173.89 183.51,173.91
  SIG4 w0.16: YJ21.B37 17.15,57.97 arc(17.04,58.13) 17.01,58.32 17.01,58.52 arc(17.11,58.76) 17.35,58.86 18.18,58.86 arc(18.47,58.92) 18.71,59.08 18.81,59.18 arc(19.06,59.35) 19.35,59.41 30.76,59.41 arc(30.97,59.45) 31.15,59.57 31.46,59.88 32.07,60.48 32.83,61.25 arc(32.95,61.43) 33,61.65 33,68.02 arc(32.95,68.23) 32.83,68.42 32.02,69.23 arc(31.77,69.6) 31.69,70.04 31.69,74.95 arc(31.76,75.31) 31.96,75.61 35.74,79.39 35.73,79.39 36.78,80.9 36.83,80.96 39.02,83.15 arc(39.14,83.33) 39.18,83.54 39.18,92.22 arc(39.25,92.58) 39.46,92.89 47.89,101.32 arc(48.2,101.53) 48.56,101.6 53.81,101.6 arc(54.02,101.64) 54.2,101.76 62.65,110.21 arc(62.96,110.42) 63.32,110.49 83.55,110.49 arc(83.76,110.53) 83.94,110.65 149.15,175.86 arc(149.52,176.11) 149.96,176.19 182.05,176.19 arc(182.48,176.11) 182.85,175.86 183.18,175.54 arc(183.43,175.17) 183.51,174.73 183.51,173.91
FC3_TDN3: length 234.7
  TOP w0.147: U1.CF46 185.05,171.89 arc(184.92,172.21) v4(184.6,172.34)
  SIG5 w0.112: v4(184.6,172.34) 184.85,172.34 arc(184.94,172.38) 184.98,172.47 184.98,172.64 arc(184.94,172.73) 184.85,172.77 184.32,172.77 arc(184.03,172.83) 183.79,172.99 183.02,173.76 arc(182.95,173.81) 182.86,173.83 182.55,173.83 182.46,173.73 182.44,173.73
  SIG5 w0.16: 182.44,173.73 181.93,173.73 181.8,173.61 181.24,173.61 181.11,173.73 180.61,173.73 180.48,173.61 179.92,173.61 179.79,173.73 179.26,173.73 179.13,173.61 178.6,173.61 178.47,173.73 150.82,173.73 arc(150.53,173.68) 150.28,173.51 87.16,110.38 arc(86.85,110.18) 86.49,110.11 60.37,110.11 arc(60.15,110.06) 59.97,109.94 39.72,89.7 arc(39.6,89.51) 39.56,89.3 39.56,83.57 arc(39.49,83.21) 39.29,82.91 36.99,80.61 arc(36.82,80.36) 36.77,80.07 36.77,78.55 36.84,78.47 36.84,77.71 36.77,77.63 36.77,76.87 36.84,76.79 36.84,76.03 36.77,75.95 36.77,75.19 36.84,75.12 36.84,74.35 36.77,74.28 36.77,73.52 36.84,73.44 36.84,72.53 36.77,72.45 36.77,71.69 arc(36.68,71.25) 36.43,70.88 34.87,69.31 arc(34.75,69.13) 34.7,68.92 34.7,55.97 arc(34.43,55.3) 33.76,55.03 21.75,55.03 arc(21.61,55) 21.48,54.91 21.43,54.86 arc(21.36,54.76) 21.31,54.65 arc(21.31,54.61) 21.31,54.57 21.31,54.09 arc(21.26,53.86) 21.13,53.67 20.73,53.27 arc(20.56,53.01) 20.5,52.7 YJ21.B6
FC3_TDP0: length 246.4
  TOP w0.147: U1.CE44 187.05,170.89 arc(186.92,171.21) v4(186.6,171.34)
  SIG5 w0.112: 185.87,173.63 185.87,173.6 185.96,173.51 185.96,172.28 arc(185.97,172.17) 186,172.07 arc(186.05,171.99) 186.11,171.92 arc(186.27,171.81) 186.47,171.77 186.82,171.77 arc(186.91,171.73) 186.95,171.64 186.95,171.48 arc(186.94,171.43) 186.91,171.38 arc(186.86,171.35) 186.81,171.34 v4(186.6,171.34)
  SIG5 w0.16: YJ21.B33 20.5,56.84 arc(20.54,57.02) 20.64,57.17 21.13,57.67 arc(21.26,57.86) 21.31,58.09 21.31,58.57 arc(21.34,58.72) 21.43,58.86 21.48,58.91 arc(21.61,59) 21.75,59.03 32.45,59.03 arc(33.11,59.3) 33.39,59.97 33.39,69.03 arc(33.31,69.39) 33.11,69.69 32.62,70.18 32.62,70.4 32.09,70.93 31.87,70.93 31.33,71.47 31.33,71.69 30.79,72.23 30.58,72.23 30.04,72.77 30.04,72.98 29.5,73.52 29.28,73.52 28.74,74.06 28.74,74.28 28.2,74.81 27.99,74.81 27.45,75.35 27.45,75.57 26.91,76.11 26.7,76.11 26.52,76.28 arc(26.4,76.47) 26.35,76.69 26.35,78.67 26.51,78.82 26.51,79.59 26.35,79.74 26.35,80.5 26.48,80.63 26.48,81.44 26.35,81.57 26.35,85.08 arc(26.41,85.37) 26.58,85.62 28.42,87.46 arc(28.61,87.58) 28.82,87.63 34.35,87.63 arc(34.71,87.7) 35.01,87.9 58.95,111.85 arc(59.14,111.97) 59.35,112.01 85.48,112.01 arc(85.84,112.08) 86.14,112.29 149.46,175.61 arc(149.71,175.77) 150,175.83 181.31,175.83 181.46,175.68 182.22,175.68 182.37,175.83 183.14,175.83 arc(183.77,175.7) 184.3,175.35 185.75,173.89 arc(185.84,173.77) 185.87,173.63
