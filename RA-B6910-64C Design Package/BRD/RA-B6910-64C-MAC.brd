# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDD_PLLA: length 8.1
  TOP w0.381: v1(294.2,213.87) 293.92,214.14 L447.1 294.7,215.01 ; v1(295.16,213.87) 295.36,214.07 C3433.1 294.83,215.14
  BOTTOM w0.254: 295.71,212.61 U117.38 ; 296.2,212.82 U117.39
  BOTTOM w0.381: C3430.1 292.67,213.99 ; C3431.1 v1(295.16,213.87) ; v1(294.2,213.87) 293.89,214.17 C3432.1
  vias: v2(293.23,213.48)
3384_TCK: length 44.4
  SIG4 w0.155: v1(29.63,195.83) 29.12,196.34 23.81,196.34 21.53,194.05 20.64,194.05 v1(19.88,193.29)
  SIG6 w0.155: v1(20,179.07) 19.11,179.96 19.11,189.23 19.88,189.99 v1(19.88,193.29)
  SIG8 w0.155: v1(20,179.07) 21.65,180.72 22.92,180.72 v1(26.99,184.78)
  BOTTOM w0.13: R3192.2 v1(19.88,193.29) ; U120.4 26.44,184.23 v1(26.99,184.78) 27.74,184.03 U120.2 ; R3196.2 v1(20,179.07) ; v1(29.63,195.83) R3214.2 R3217.1 v2(31.08,198.12)
3384_TMS: length 55.3
  SIG3 w0.155: v1(29.78,188.08) 27.75,190.12 16.07,190.12 v1(13.02,193.16)
  SIG6 w0.155: v1(14.29,179.07) 13.14,180.21 13.14,185.54 13.91,186.31 13.91,192.28 v1(13.02,193.16)
  SIG8 w0.155: v1(14.29,179.07) 16.07,180.85 19.24,180.85 23.18,184.78 v1(24.45,184.78)
  BOTTOM w0.13: R3201.2 v1(14.29,179.07) ; U120.6 25.14,184.35 24.7,184.78 v1(24.45,184.78) 24.16,184.78 23.84,184.46 U120.8 ; R3195.2 12.97,192.38 v2(12.94,192.4) 12.94,193.09 v1(13.02,193.16) ; R3220.1 R3223.2 v1(29.78,188.08)
56970_COREPLL_REFCLK_N: length 94.6
  TOP w0.107: C9.1 250.48,138.12 250.58,138.02 251.29,138.02 252.08,138.82 252.08,175.52 252.92,176.36 252.92,185.12 260.53,192.73 269.42,192.73 270.44,193.75 277.41,193.75 277.81,193.34 277.81,192.83 277.93,192.71 v1(278.23,192.71)
  BOTTOM w0.107: v1(278.23,192.71) 278.06,192.71 277.84,192.94 277.84,195.22 286.26,203.64 286.95,203.64 287.06,203.54 R3155.2
56970_COREPLL_REFCLK_P: length 94.1
  TOP w0.107: v1(277.32,192.71) 277.48,192.88 277.48,193.21 277.27,193.42 270.57,193.42 269.56,192.4 260.67,192.4 253.25,184.99 253.25,176.22 252.41,175.38 252.41,138.68 251.42,137.69 250.58,137.69 250.48,137.59 C10.1
  BOTTOM w0.107: R3156.2 287.06,204.08 286.95,203.97 286.12,203.97 277.51,195.36 277.51,192.9 v1(277.32,192.71)
56970_MISC_PLL_REFCLK_N: length 237.6
  TOP w0.107: C2807.1 154.8,141.83 154.19,141.83 154.08,141.95 141.62,141.95 131.76,151.8 131.76,190.98 v1(131.61,191.13)
  SIG4 w0.14: v1(131.61,191.13) 131.8,191.13 132.02,191.35 132.02,192.63 132.67,193.29 154.49,193.29 162.12,200.91 191.67,200.91 195.4,197.18 210.39,197.18 212.49,195.07 231.71,195.07 236.03,199.39 280.61,199.39 286.75,205.53 286.75,206.25 286.37,206.63 285.99,206.63 285.81,206.45 v1(285.81,206.14)
  BOTTOM w0.107: R3157.2 287.06,206.17 286.87,206.36 286.03,206.36 v1(285.81,206.14)
56970_MISC_PLL_REFCLK_P: length 237.6
  TOP w0.107: C2844.1 155.03,142.35 154.84,142.16 154.33,142.16 154.21,142.28 141.76,142.28 132.09,151.94 132.09,191.01 132.22,191.13 v1(132.52,191.13)
  SIG4 w0.14: v1(132.52,191.13) 132.35,191.31 132.35,192.5 132.81,192.96 154.63,192.96 162.25,200.58 191.53,200.58 195.26,196.85 210.25,196.85 212.36,194.74 231.85,194.74 236.17,199.06 280.74,199.06 287.08,205.4 287.08,206.38 286.51,206.96 285.92,206.96 v1(285.81,207.06)
  BOTTOM w0.107: v1(285.81,207.06) 286.18,206.69 286.92,206.69 287.06,206.83 R3158.2
56970_PCIE_PLL_REFCLK_N: length 168.1
  TOP w0.107: U1.BL39 v1(191.55,157.34)
  SIG7 w0.102: 205.22,173.98 205.22,173.95 205.16,173.88 205.16,162.22 arc(205.02,161.9) 204.71,161.77 202.41,161.77 arc(202.23,161.7) 202.15,161.51 202.15,159.98 arc(202.11,159.79) 202,159.62 199.27,156.89 arc(199.1,156.78) 198.91,156.74 192.09,156.74 arc(191.91,156.8) 191.8,156.95 arc(191.72,157.13) 191.6,157.29 v1(191.55,157.34)
  SIG7 w0.14: 205.22,173.98 205.22,175.57 arc(205.24,175.64) 205.27,175.69 206.75,177.17 arc(206.86,177.33) 206.9,177.53 206.9,179.35 arc(206.86,179.54) 206.75,179.7 198.92,187.53 arc(198.88,187.59) 198.87,187.66 198.87,191.51 arc(198.83,191.7) 198.72,191.87 188.25,202.34 arc(188.09,202.45) 187.89,202.48 162.73,202.48 arc(162.67,202.5) 162.61,202.54 160.37,204.78 arc(160.2,204.89) 160.01,204.92 117.41,204.92 arc(117.34,204.94) 117.28,204.98 113.78,208.48 arc(113.74,208.54) 113.73,208.61 113.73,214.88 arc(113.69,215.08) 113.58,215.24 108.21,220.62 arc(108.17,220.67) 108.15,220.74 108.15,222.36 arc(108.12,222.55) 108.01,222.72 107.08,223.64 arc(106.92,223.75) 106.72,223.79 103.76,223.79 arc(103.52,223.74) 103.32,223.61 arc(103.19,223.41) 103.14,223.17 103.14,223 arc(103.1,222.82) 102.99,222.67 arc(102.7,222.47) 102.35,222.4 YJ3.A8_1
  BOTTOM w0.107: R24.1 191.08,157.79 191.52,157.34 v1(191.55,157.34)
56970_PCIE_PLL_REFCLK_P: length 168.1
  TOP w0.107: U1.BL38 v1(192.55,157.34)
  SIG7 w0.102: 204.89,173.98 204.89,173.95 204.96,173.88 204.96,162.22 arc(204.89,162.04) 204.71,161.97 202.41,161.97 arc(202.09,161.84) 201.96,161.51 201.96,159.98 arc(201.93,159.86) 201.86,159.76 199.13,157.03 arc(199.03,156.96) 198.91,156.94 192.09,156.94 arc(192.02,156.97) 191.99,157.04 191.99,157.24 arc(192.02,157.31) 192.09,157.34 v1(192.55,157.34)
  SIG7 w0.14: 204.89,173.98 204.89,175.57 arc(204.93,175.76) 205.04,175.93 206.51,177.4 arc(206.55,177.46) 206.57,177.53 206.57,179.35 arc(206.55,179.41) 206.51,179.47 198.69,187.3 arc(198.58,187.46) 198.54,187.66 198.54,191.51 arc(198.52,191.58) 198.48,191.63 188.02,202.1 arc(187.96,202.14) 187.89,202.15 162.73,202.15 arc(162.54,202.19) 162.37,202.3 160.14,204.54 arc(160.08,204.58) 160.01,204.59 117.41,204.59 arc(117.21,204.63) 117.05,204.74 113.55,208.25 arc(113.44,208.41) 113.4,208.61 113.4,214.88 arc(113.38,214.95) 113.35,215.01 107.97,220.38 arc(107.86,220.55) 107.82,220.74 107.82,222.36 arc(107.81,222.43) 107.77,222.49 106.85,223.41 arc(106.79,223.45) 106.72,223.46 103.76,223.46 arc(103.65,223.44) 103.55,223.38 arc(103.49,223.28) 103.47,223.17 103.47,223 arc(103.41,222.69) 103.22,222.43 103.14,222.34 102.98,222.21 102.88,222.12 102.61,221.71 102.31,221.53 arc(102.2,221.14) YJ3.A7_1
  BOTTOM w0.107: v1(192.55,157.34) 192.04,157.85 R24.2
ANALOG_EN: length 6.1
  TOP w0.13: R3650.2 v1(373.95,157.96)
  BOTTOM w0.254: R3566.1 v1(373.95,157.96) v2(373.95,156.97) 373.55,156.56 R3564.2 371.67,156.56 371.64,156.59 Q56.3
ANLGOUT: length 273.7
  TOP w0.254: R2226.2 v1(380.86,157.86) ; R2225.2 138.87,112.77 138.62,113.03 138.62,123.7 138.87,123.95 v1(138.87,124.74)
  TOP w0.381: C3001.1 v1(222.57,96.14) ; 151.63,126.29 C2957.1 ; C2957.1 152.11,126.77 ; C2957.1 151.14,126.77 ; C3061.1 240.73,144.37 241.08,144.02 ; L30.2 176.44,179.8 ; L30.2 177.97,179.8 ; L30.2 177.1,180.59 ; C3128.1 240.73,130.43 v1(240.86,130.3) ; C351.1 222.06,198.88 ; 151.19,152.52 151.22,152.55 C2781.1 150.58,153.18 150.56,153.16 ; C3196.1 153.45,137.64 153.86,138.05 ; C2719.1 153.53,126.77 ; C2719.1 152.56,126.77 ; C2719.1 153.05,126.29 ; v1(203.52,100.71) C2919.1 ; C3174.1 153.76,138.83 ; L31.2 162.37,186.66 ; L31.2 161.77,186.03 ; L31.2 162.97,186.03 ; C2752.1 217.23,198.88 ; v1(222.57,101.72) C2683.1 ; C2855.1 v1(175.7,98.42) ; C2746.1 238.44,130.82 ; v1(190.69,100.71) C3107.1 ; L439.2 168.81,186.03 ; L439.2 168.21,186.66 ; L439.2 167.61,186.03 ; C2868.1 211.14,198.88 ; C2924.1 238.44,168.65 ; C2987.1 229.3,199.01 ; C276.1 155.26,164.72 ; C2808.1 172.89,185.77 173.04,185.93 ; C2821.1 v1(207.71,198.88) ; C3122.1 154.98,175.37 v1(155.38,174.96) ; C3150.1 239.97,168.65 v1(240.09,168.53) ; C2842.1 175.32,179.58 ; C3030.1 v1(175.7,100.71) ; 152.46,152.52 152.44,152.55 C2771.1 ; C279.1 154.24,164.46 ; v1(238.7,156.33) C2865.1 ; C2676.1 167.2,192.15 ; 239.33,144.04 C2831.1 ; v1(237.3,156.33) C2845.1 ; v1(203.52,98.42) C2897.1 ; v1(190.69,98.42) C2786.1 ; C3058.1 214.82,198.75
  TOP w0.508: 167.04,185.77 C2776.1 ; C2779.1 160.69,186.28
  SIG4 w0.508: v1(27.62,173.73) 27.62,176.4 35.24,184.02 35.24,185.15 41.61,191.51 43.98,191.51 57.31,204.85 69.91,204.85 70.55,205.48 93.54,205.48 96.2,202.82 v1(112.46,202.82)
  BOTTOM w0.254: C2116.1 327.47,199.06 327.47,201.04 328.23,201.8 334.04,201.8 339.25,196.6 358.42,196.6 366.08,188.94 366.08,168.78 368.62,166.24 371.28,166.24 371.98,165.54 372.62,165.54 373.95,164.21 378.27,164.21 380.78,161.69 380.78,157.93 v1(380.86,157.86)
  BOTTOM w0.381: 249.49,119.25 C630.1 ; C630.1 249.97,118.77 ; C630.1 250.46,119.25 ; 250.94,146.56 C684.1 ; C684.1 251.42,146.07 ; C684.1 251.42,147.04 ; C282.1 142.15,149.83 ; C282.1 141.67,149.35 ; C282.1 141.19,149.83 ; 252.06,166.01 C738.1 ; C738.1 253.02,166.01 ; C738.1 252.54,165.53 ; C711.1 252.34,154.51 ; C711.1 251.83,153.87 ; C711.1 253,153.87 ; 249.49,113.26 C576.1 ; C576.1 249.97,112.78 ; C576.1 250.46,113.26 ; C603.1 251.17,109.04 ; C603.1 250.2,109.04 ; C603.1 250.69,109.52 ; C3006.1 142.25,156.03 ; C3006.1 141.29,156.03 ; C3006.1 141.77,155.55 ; v1(186.47,198.88) 185.99,198.88 185.89,198.78 C3084.1 ; 141.29,162.02 C414.1 ; C414.1 142.25,162.02 ; C414.1 141.77,161.54 ; 141.54,120.01 C495.1 140.96,120.6 ; R3281.2 26.28,170.66 26.86,171.24 26.86,172.97 v2(26.99,173.1) v1(27.62,173.73)
  BOTTOM w0.508: C468.1 140.07,125.3 ; C468.1 140.75,125.96 ; C468.1 141.36,125.3 ; 141.52,133.58 C522.1 140.3,133.58 ; v1(112.46,202.82) 119.95,202.82
  vias: v1(135.29,154.38) v1(136.21,155.27) v1(136.46,152.52) v1(137.58,153.67) v1(137.83,150.75) v1(139.13,152.14) v1(145.68,152.35) v1(146.16,153.11) v1(146.85,126.74) v1(146.98,153.92) v1(147.49,151.25) v1(147.56,127.45) v1(148.27,128.17) v1(148.88,125.83) v1(154.37,139.61) v1(154.72,164.34) v1(155.31,139.61) v1(155.61,164.34) v1(156.2,139.61) v1(156.27,174.96) v1(156.5,164.34) v1(157.09,139.61) v1(161.61,187.58) v1(162.5,187.58) v1(166.94,187.58) v1(167.2,193.55) v1(167.83,187.58) v1(168.08,193.55) v1(168.08,183.28) v1(168.97,183.28) v1(169.86,183.28) v1(170.75,183.28) v1(173.29,187.58) v1(174.18,187.58) v1(175.7,101.72) v1(175.7,99.44) v1(186.47,197.86) v1(190.69,101.72) v1(190.69,99.44) v1(203.52,101.72) v1(203.52,99.44) v1(207.71,197.86) v1(210.12,198.88) v1(210.12,197.86) v1(213.8,198.88) v1(213.8,197.86) v1(216.22,198.88) v1(216.22,197.86) v1(221.04,198.88) v1(221.04,197.86) v1(222.57,100.71) v1(222.57,97.15) v1(228.28,198.88) v1(228.28,197.86) v1(237.68,168.53) v1(237.81,130.3) v1(238.7,144.07) v1(238.82,130.3) v1(239.08,168.53) v1(239.71,130.3) v1(240.2,144.02) v2(279.59,158.49) v2(301.69,169.54) v3(277.43,163.95) v3(277.43,162.68) v3(278.7,163.95) v3(278.7,162.68) v3(278.7,161.41) v3(279.97,163.95) v3(279.97,162.68) v3(279.97,161.41) v3(279.97,160.14) v3(281.24,163.95) v3(281.24,162.68) v3(281.24,161.41) v3(281.24,160.14) v3(281.24,158.87) v3(282.51,163.95) v3(282.51,162.68) v3(282.51,161.41) v3(282.51,160.14) v3(282.51,158.87) v3(283.78,163.95) v3(283.78,162.68) v3(283.78,161.41) v3(283.78,160.14) v3(283.78,158.87) v3(294.07,182.24) v3(294.07,179.7) v3(294.07,177.16) v3(294.07,174.62) v3(294.07,172.08) v3(296.61,182.24) v3(296.61,179.7) v3(296.61,177.16) v3(296.61,174.62) v3(296.61,172.08) v3(299.15,182.24) v3(299.15,179.7) v3(299.15,177.16) v3(299.15,174.62) v3(299.15,172.08) v3(301.69,182.24) v3(301.69,179.7) v3(301.69,177.16) v3(301.69,174.62) v3(301.69,172.08) v3(304.23,184.78) v3(304.23,182.24) v3(304.23,179.7) v3(304.23,177.16) v3(304.23,174.62) v3(304.23,172.08) v3(304.23,169.54) v3(306.77,184.78) v3(306.77,182.24) v3(306.77,179.7) v3(306.77,177.16) v3(306.77,174.62) v3(306.77,172.08) v3(306.77,169.54) v3(309.31,184.78) v3(309.31,182.24) v3(309.31,179.7) v3(309.31,177.16) v3(309.31,174.62) v3(309.31,172.08) v3(309.31,169.54) v3(311.85,184.78) v3(311.85,182.24) v3(311.85,179.7) v3(311.85,177.16) v3(311.85,174.62) v3(311.85,172.08) v3(311.85,169.54) v3(314.39,184.78) v3(314.39,182.24) v3(314.39,179.7) v3(314.39,177.16) v3(314.39,174.62) v3(314.39,172.08) v3(314.39,169.54) v3(316.93,184.78) v3(316.93,182.24) v3(316.93,179.7) v3(316.93,177.16) v3(316.93,174.62) v3(316.93,172.08) v3(316.93,169.54) v3(319.47,184.78) v3(319.47,182.24) v3(319.47,179.7) v3(319.47,177.16) v3(319.47,174.62) v3(319.47,172.08) v3(319.47,169.54) v3(322.01,179.7) v3(322.01,177.16) v3(324.55,179.7) v3(324.55,177.16)
AVS_IN0: length 380.1
  TOP w0.13: U1.R51 v1(179.55,120.34) ; v1(404.91,188.57) 404.91,188.18 404.42,187.69 404.42,186.45 U124.B11
  SIG6 w0.155: v1(180.47,100.07) 179.9,100.64 179.9,104.39 178.12,106.17 178.12,110.61 178.37,110.87 178.75,110.87 179.13,111.24 179.13,111.52 179.37,111.76 179.88,111.76 180.13,112.01 180.13,119.76 v1(179.55,120.34)
  SIG10 w0.155: v1(180.47,100.07) 183.32,100.07 188.15,95.25 230.31,95.25 231.08,96.01 236.8,96.01 240.26,99.47 246.64,99.47 261.31,114.14 261.31,168.12 261.79,168.6 261.79,170.65 260.59,171.85 260.59,176.61 263.59,179.61 263.59,188.97 268.67,194.06 268.67,197.1 269.49,197.92 269.49,217.12 274.13,221.75 376.1,221.75 388.43,209.42 390.46,209.42 401.51,198.37 401.51,196.34 403.79,194.06 403.79,191.64 404.43,191.01 404.43,189.42 404.91,188.93 v1(404.91,188.57)
  BOTTOM w0.13: v1(180.47,100.07) v2(180.47,100.9)
AVS_IN1: length 391.4
  TOP w0.13: U1.T49 v1(181.55,121.34) ; U124.E14 v1(406.82,184.05)
  SIG6 w0.155: v1(181.55,121.34) 182.05,120.84 182.05,120.14 182.31,119.89 182.69,119.89 183.07,119.5 183.07,112.14 182.72,111.78 182.33,111.78 182.05,111.5 182.05,111.12 181.8,110.87 180.4,110.87 180.02,110.49 180.02,106.08 180.3,105.81 181.43,104.68 181.43,96.08 v1(180.47,95.12)
  SIG10 w0.155: v1(180.47,95.12) 181.15,94.43 206.46,94.43 207.27,93.62 213.48,93.62 214.29,94.43 230.59,94.43 231.39,95.24 237.18,95.24 240.63,98.69 246.95,98.69 262.08,113.82 262.08,167.8 262.56,168.28 262.56,172.95 265.28,175.67 265.28,189.42 270.57,194.71 270.57,216.91 273.49,219.83 273.49,219.84 274.64,220.99 358.9,220.99 360.11,219.78 360.11,214.63 365.18,209.56 383.34,209.56 384.47,208.43 388.06,208.43 401.51,194.98 401.51,191.89 402.8,190.6 402.8,189.26 402.96,189.11 403.49,189.11 403.8,188.8 403.8,188.02 404.25,187.57 405.83,187.57 407.61,185.8 407.61,184.4 407.25,184.05 v1(406.82,184.05)
  BOTTOM w0.13: v2(181.29,95.25) 181.17,95.12 v1(180.47,95.12)
AVS_IN2: length 386.9
  TOP w0.13: U1.T48 v1(182.55,121.34) ; U124.D14 v1(406.82,184.85)
  SIG6 w0.155: v1(182.55,121.34) 183.12,120.77 183.83,120.77 184.09,120.52 184.09,112.27 183.71,111.88 183.32,111.88 183.07,111.63 183.07,111.12 182.82,110.87 182.31,110.87 182.05,110.61 182.05,105.53 181.81,105.29 181.81,95.58 v1(180.47,94.23)
  SIG10 w0.102: 406.15,186.49 406.42,186.22 406.42,185.25 v1(406.82,184.85)
  SIG10 w0.155: 406.15,186.49 405.57,187.07 404.11,187.07 402.42,188.76 402.42,189.46 400.37,191.51 400.37,195.58 387.92,208.02 383.35,208.02 382.28,209.09 358.56,209.09 357.63,210.02 339.65,210.02 338.26,208.63 332.38,208.63 320.41,220.6 274.9,220.6 272.35,218.06 272.35,214.88 271.46,213.99 271.46,194.98 266.52,190.04 266.52,176.17 262.94,172.59 262.94,168.12 262.46,167.64 262.46,113.66 247.1,98.3 240.82,98.3 237.37,94.86 231.55,94.86 230.7,94 215.1,94 214.03,92.94 204.94,92.94 203.87,94 180.69,94 v1(180.47,94.23)
  BOTTOM w0.13: v2(181.29,93.98) 181.04,94.23 v1(180.47,94.23)
AVS_IN3: length 390.5
  TOP w0.13: U1.T51 v1(179.55,121.34) ; U124.G14 v1(406.82,182.45)
  SIG6 w0.155: v1(180.47,97.79) 181.04,98.36 181.04,104.01 179.01,106.04 179.01,110.49 179.29,110.77 179.67,110.77 180.13,111.23 180.13,111.52 180.37,111.76 180.66,111.76 181.04,112.14 181.04,119.5 179.55,120.99 v1(179.55,121.34)
  SIG10 w0.155: v1(180.47,97.79) 183.41,94.84 230.45,94.84 231.24,95.63 236.99,95.63 240.45,99.08 246.79,99.08 261.69,113.98 261.69,167.96 262.18,168.44 262.18,174.72 263.97,176.51 263.97,188.7 269.05,193.79 269.05,196.6 270.09,197.63 270.09,217.07 271.59,218.56 271.59,218.58 274.38,221.37 375.72,221.37 382.73,214.36 382.73,211.08 384.9,208.91 390.08,208.91 392.37,206.63 392.37,204.66 402.65,194.38 402.65,191.77 403.29,191.13 403.29,190.5 403.92,189.86 403.92,189.34 404.35,188.91 404.35,188.42 404.81,187.96 406.97,187.96 408.37,186.56 408.37,183.64 407.17,182.45 v1(406.82,182.45)
  BOTTOM w0.13: v1(180.47,97.79) v2(181.24,97.79)
AVS_IN4: length 330.5
  TOP w0.13: v1(407.84,189.58) 407.45,189.2 407.45,188.19 406.42,187.15 U124.A14 ; v1(215.55,113.34) U1.H16
  SIG6 w0.155: v1(215.55,113.34) 216.16,113.34 217.04,112.46 217.04,109.15 217.36,108.84 217.87,108.84 218.12,108.58 218.12,108.07 218.38,107.82 218.76,107.82 219.01,107.57 219.01,107.19 219.39,106.8 219.77,106.8 220.03,106.55 220.03,106.04 223.58,102.49 232.85,102.49 v1(234.76,100.58)
  SIG10 w0.155: v1(407.84,189.58) 407.84,193.55 407.1,194.28 407.1,195.83 392.1,210.83 392.1,212.33 391.45,212.98 387.54,212.98 377.23,223.29 272.63,223.29 266.96,217.62 266.96,194.89 261.94,189.86 261.94,180.13 259.06,177.25 259.06,168.63 259.65,168.03 259.65,114.81 247.92,103.07 244.61,103.07 243.53,101.98 240.42,101.98 239.02,100.58 v1(234.76,100.58)
  BOTTOM w0.13: v1(234.76,100.58) v2(234,100.58)
AVS_IN5: length 347.6
  TOP w0.13: v1(406.95,188.57) 406.95,188.14 406.02,187.21 406.02,186.45 U124.B13 ; U1.V27 v1(204.55,123.34)
  SIG6 w0.155: v1(204.55,123.34) 206.99,120.9 214.69,120.9 215.07,120.52 215.07,117.09 217.36,114.81 218.76,114.81 219.08,114.49 219.08,113.98 219.27,113.79 219.77,113.79 220.03,113.54 220.03,110.11 220.37,109.76 220.88,109.76 221.13,109.51 221.13,109.17 221.37,108.92 221.85,108.92 222.06,108.71 222.06,105.66 224.22,103.5 233.62,103.5 236.41,100.71 v1(243.65,100.71)
  SIG10 w0.155: v1(406.95,188.57) 406.46,189.05 406.46,195.7 390.84,211.33 390.84,212.21 390.59,212.47 387.41,212.47 376.98,222.9 273.01,222.9 267.37,217.27 267.37,194.76 262.32,189.7 262.32,179.97 259.44,177.09 259.44,168.79 260.16,168.07 260.16,114.62 247.52,101.98 245.56,101.98 244.28,100.71 v1(243.65,100.71)
AVS_IN6: length 341.5
  TOP w0.13: v1(208.55,122.34) U1.U23 ; v1(405.93,190.6) 405.37,190.04 405.37,188.18 404.82,187.62 U124.A12
  SIG6 w0.155: v1(208.55,122.34) 209.1,121.79 214.95,121.79 216.09,120.65 216.09,116.84 217.17,115.76 219.72,115.76 219.97,115.52 219.97,115.17 220.22,114.92 220.67,114.92 221.13,114.47 221.13,114.17 221.51,113.79 221.81,113.79 222.06,113.54 222.06,110.24 222.37,109.92 222.72,109.92 223.06,109.58 223.06,105.93 224.98,104.01 233.65,104.01 236.32,101.34 244.54,101.34 v1(245.17,100.71)
  SIG10 w0.155: v1(405.93,190.6) 405.93,192.05 405.32,192.66 405.32,196.09 389.95,211.45 387.79,211.45 376.73,222.52 273.39,222.52 267.78,216.91 267.78,213.74 268.54,212.98 268.54,198.74 267.78,197.98 267.78,194.43 262.7,189.36 262.7,179.81 259.82,176.93 259.82,168.99 260.54,168.27 260.54,114.46 247.68,101.6 246.07,101.6 v1(245.17,100.71)
AVS_IN7: length 340.1
  TOP w0.13: v1(404.91,189.58) 404.91,189.46 404.43,188.97 404.43,188.16 404.02,187.75 U124.A11 ; U1.U21 v1(210.55,122.34)
  SIG6 w0.155: v1(210.55,122.34) 215.54,122.34 216.12,121.76 220.72,121.76 221.04,121.44 221.04,116.25 221.47,115.82 221.68,115.82 222.13,115.37 222.13,115.17 222.37,114.92 222.58,114.92 223.08,114.42 223.08,110.11 223.33,109.85 224.73,109.85 225.06,109.52 225.06,105.08 225.67,104.47 233.92,104.47 236.66,101.73 245.43,101.73 v1(246.44,100.71)
  SIG10 w0.155: v1(246.44,100.71) 246.95,101.22 247.84,101.22 260.93,114.3 260.93,168.28 261.41,168.76 261.41,170.49 260.21,171.69 260.21,176.77 263.09,179.65 263.09,189.2 268.29,194.4 268.29,197.48 269.05,198.24 269.05,213.74 268.19,214.6 268.19,216.56 273.77,222.14 376.48,222.14 388.18,210.44 390.08,210.44 404.18,196.34 404.18,192.02 404.91,191.28 v1(404.91,189.58)
AVS_PVTMON_AVDD1P8: length 5.9
  TOP w0.229: U1.BJ27 v1(204.55,155.34)
  TOP w0.381: 219.05,196.11 L425.1 ; L425.1 219.65,195.48 ; L425.1 220.24,196.11 ; C87.1 220.24,193.39 ; C87.1 219.65,194.03 ; C87.1 219.05,193.39
  BOTTOM w0.381: v1(204.55,155.34) 204.05,155.84 C88.1 ; v1(218.63,194.18) v2(217.87,194.18)
  vias: v1(218.63,193.16)
B50610_MDI_0N: length 186.9
  TOP w0.107: v1(407.73,210.59) 407.43,210.59 407.17,210.84 407.17,211.17 407.32,211.32 407.6,211.32 407.76,211.48 C3506.1 407.37,212.27 407.37,212.94 407.6,213.18 R3230.2 ; v1(411.92,53.97) 411.82,53.87 D92.3 411.22,55.05 411.4,55.23 412.38,55.23 412.61,55 412.61,52.97 411.96,52.32 411.96,51.61 411.54,51.19 T1.3
  SIG9 w0.14: v1(407.73,210.59) 407.48,210.59 407.3,210.41 407.3,209.94 407.57,209.67 410.4,209.67 422.8,197.28 422.8,181.64 427.42,177.02 427.42,99.35 422.08,94.02 422.08,80.39 415.43,73.73 415.43,56.71 412.93,54.2 412.15,54.2 v1(411.92,53.97)
B50610_MDI_0P: length 186.9
  TOP w0.107: v1(406.82,210.59) 406.84,210.61 406.84,211.33 406.57,211.6 C3505.1 406.57,211.94 407.04,212.4 407.04,213.01 406.87,213.18 R3231.1 ; T1.2 412.81,51.2 412.29,51.72 412.29,52.18 412.94,52.83 412.94,55.14 412.52,55.56 411.45,55.56 411.22,55.79 D92.4 411.82,56.37 v1(411.92,56.26)
  SIG9 w0.14: v1(411.92,56.26) 411.92,54.81 412.2,54.53 412.79,54.53 415.1,56.84 415.1,73.87 421.75,80.53 421.75,94.16 427.09,99.49 427.09,176.88 422.47,181.51 422.47,197.14 410.26,209.34 407.43,209.34 406.97,209.8 406.97,210.43 v1(406.82,210.59)
B50610_MDI_1N: length 188.9
  TOP w0.107: v1(404.41,209.32) 404.26,209.47 403.42,209.47 402.53,210.36 402.53,211.02 402.25,211.3 C3510.1 402.72,212.35 402.72,213.05 402.59,213.18 R3229.1 ; T1.6 407.73,51.34 408.17,51.78 408.17,52.18 407.78,52.57 407.78,54.77 408.57,55.56 409.22,55.56 409.32,55.67 D92.6 v1(408.62,56.37)
  SIG9 w0.14: v1(404.41,209.32) 404.83,209.32 406.71,207.44 409.05,207.44 420.99,195.5 420.99,181.34 425.95,176.39 425.95,132.26 423.28,129.59 423.28,100.97 419.98,97.67 419.98,84.25 412.31,76.58 412.31,63.28 410.83,61.81 410.83,56.9 409.44,55.51 409.44,54.74 409.27,54.58 408.93,54.58 408.62,54.89 v1(408.62,56.37)
B50610_MDI_1P: length 188.9
  TOP w0.107: T1.5 409,51.25 408.5,51.76 408.5,52.32 408.11,52.7 408.11,54.63 408.71,55.23 409.17,55.23 409.32,55.07 D92.1 v1(408.64,53.87) ; v1(404.41,210.23) 404.41,209.99 404.22,209.8 403.55,209.8 402.86,210.49 402.86,211.17 403,211.32 403.33,211.32 403.44,211.43 C3507.1 403.05,212.27 403.05,212.96 403.26,213.18 R3232.2
  SIG9 w0.14: v1(404.41,210.23) 404.41,210 404.77,209.65 404.97,209.65 406.84,207.77 409.19,207.77 421.32,195.64 421.32,181.48 426.28,176.53 426.28,132.12 423.61,129.45 423.61,100.84 420.31,97.53 420.31,84.11 412.64,76.44 412.64,63.14 411.16,61.67 411.16,56.77 409.77,55.37 409.77,54.61 409.41,54.25 409.03,54.25 v1(408.64,53.87)
B50610_MDI_2N: length 193.2
  TOP w0.107: R3233.2 398.91,213.18 398.75,213.02 398.75,212.25 C3511.1 399.12,211.43 399.02,211.32 398.71,211.32 398.54,211.15 398.54,210.49 399.23,209.8 399.9,209.8 400.09,209.99 v1(400.09,210.23) ; v1(404.3,53.87) D93.3 403.6,55.05 403.78,55.23 404.76,55.23 404.99,55 404.99,52.97 404.34,52.32 404.34,51.61 403.92,51.19 T1.9
  SIG9 w0.14: v1(400.09,210.23) 400.09,210 400.45,209.65 401.29,209.65 404.69,206.24 408.32,206.24 419.93,194.64 419.93,181.31 425.21,176.03 425.21,132.45 422.59,129.83 422.59,101.85 419.04,98.3 419.04,85.85 410.4,77.21 410.4,75.86 407.43,72.89 407.43,63.21 406.74,62.52 406.74,55.92 405.07,54.25 404.69,54.25 v1(404.3,53.87)
B50610_MDI_2P: length 193.2
  TOP w0.107: T1.8 405.19,51.2 404.67,51.72 404.67,52.18 405.32,52.83 405.32,55.14 404.9,55.56 403.83,55.56 403.6,55.79 D93.4 v1(404.28,56.37) ; R3234.1 398.24,213.18 398.42,212.99 398.42,212.38 C3508.1 397.93,211.3 398.21,211.02 398.21,210.36 399.1,209.47 399.94,209.47 v1(400.09,209.32)
  SIG9 w0.14: v1(404.28,56.37) 404.28,54.89 404.59,54.58 404.94,54.58 406.41,56.06 406.41,62.66 407.1,63.34 407.1,73.02 410.07,75.99 410.07,77.35 418.71,85.99 418.71,98.43 422.26,101.99 422.26,129.97 424.88,132.59 424.88,175.89 419.6,181.18 419.6,194.5 408.18,205.91 404.55,205.91 401.15,209.32 v1(400.09,209.32)
B50610_MDI_3N: length 195.9
  TOP w0.107: T1.12 400.11,51.34 400.55,51.78 400.55,52.18 400.16,52.57 400.16,55 400.73,55.56 401.6,55.56 401.7,55.67 D93.6 v1(401.02,56.37) ; R3235.1 393.83,213.18 394.01,213 394.01,212.27 C3509.1 393.61,211.3 393.89,211.02 393.89,210.36 394.78,209.47 395.62,209.47 v1(395.77,209.32)
  SIG9 w0.14: v1(395.77,209.32) 397.59,209.32 402.52,204.39 406.77,204.39 418.2,192.96 418.2,180.92 423.79,175.33 423.79,133.03 419.8,129.04 419.8,102.7 416.93,99.83 416.93,86.62 405.24,74.94 405.24,58.81 401.84,55.4 401.84,54.74 401.67,54.58 401.3,54.58 401.02,54.86 v1(401.02,56.37)
B50610_MDI_3P: length 195.9
  TOP w0.107: R3236.2 394.52,213.18 394.34,212.99 394.34,212.35 C3512.1 394.81,211.43 394.7,211.32 394.39,211.32 394.22,211.15 394.22,210.49 394.92,209.8 395.58,209.8 395.77,209.99 v1(395.77,210.23) ; v1(401.02,53.87) D93.1 401.7,55.07 401.55,55.23 400.86,55.23 400.49,54.86 400.49,52.7 400.88,52.32 400.88,51.76 401.38,51.25 T1.11
  SIG9 w0.14: v1(395.77,210.23) 395.77,210 396.13,209.65 397.73,209.65 402.66,204.72 406.91,204.72 418.53,193.1 418.53,181.06 424.12,175.47 424.12,132.89 420.13,128.9 420.13,102.56 417.26,99.69 417.26,86.48 405.57,74.8 405.57,58.67 402.17,55.26 402.17,54.61 401.81,54.25 401.41,54.25 v1(401.02,53.87)
BMC_I2C_SCL: length 628.8
  TOP w0.13: U14.6 v1(268.19,179.93) ; U140.18 377.05,163.25 376.84,163.03 376.84,160.29 R3658.1 376.63,159.09 376.63,157.73 376.11,157.21 v1(376.11,156.97) ; U123.A9 25.25,166.11 v1(24.83,166.54) ; U121.2 v1(200.88,196.06) ; v1(393.18,101.22) 392.65,100.68 U122.2 ; U124.A9 402.42,188.74 v1(403.26,189.58)
  SIG5 w0.155: v1(200.88,196.06) 204.53,192.4 213.55,192.4 214.82,191.13 232.47,191.13 232.85,191.51 238.06,191.51 238.82,190.75 255.08,190.75 263.59,182.24 263.59,181.23 264.86,179.96 268.16,179.96 v1(268.19,179.93)
  SIG6 w0.155: v1(393.18,101.22) 391.78,99.82 379.92,99.82 371.54,108.2 371.54,137.28 375.35,141.09 375.35,156.21 v1(376.11,156.97) 375.6,157.48 375.6,160.65 381.06,166.11 381.06,177.54 377,181.61 363.79,181.61 362.52,182.88 358.58,182.88 348.17,193.29 329.88,193.29 322.9,186.31 287.98,186.31 281.12,179.45 271.21,179.45 270.7,178.94 269.18,178.94 v1(268.19,179.93) ; v1(108.14,194.18) 108.14,193.29 108.65,192.78 109.44,192.78 110.3,193.65 150.03,193.65 150.89,194.51 196.96,194.51 199.58,191.89 201.1,191.89 201.49,192.28 201.49,195.45 v1(200.88,196.06)
  SIG7 w0.155: v1(108.14,194.18) 107.89,194.18 105.73,196.34 88.58,196.34 76.14,208.79 75.5,208.79 v1(74.87,209.42) 74.87,209.17 74.23,208.53 74.23,201.67 68.9,196.34 60.67,196.34 51.88,187.55 50.71,187.55 41.85,178.69 34.48,178.69 29.4,173.61 29.4,171.19 24.83,166.62 v1(24.83,166.54)
  SIG8 w0.155: YJ3.C8_2 86.85,214.8 80.99,208.94 75.35,208.94 v1(74.87,209.42)
  SIG9 w0.155: v1(403.26,189.58) 403.26,191.05 403.73,191.51 408.75,191.51 409.64,190.62 409.64,188.21 409.38,187.96 409.38,186.94 410.15,186.18 410.81,186.18 412.56,184.43 412.56,174.08 394.81,156.33 376.75,156.33 v1(376.11,156.97)
  BOTTOM w0.13: v2(107.25,194.18) v1(108.14,194.18) ; v1(403.26,189.58) 403.06,189.58 402.6,190.04 402.6,190.95 402.76,191.11 402.76,196.39 402.65,196.49 R3502.2
BMC_I2C_SDA: length 601.5
  TOP w0.13: v1(388.56,100.58) 388.81,100.84 R3243.2 ; R361.2 270.65,181.79 270.95,181.48 270.95,180.21 v1(270.19,179.45) ; R3241.2 200.57,192.89 v1(200.85,193.16) ; v1(376.11,155.95) 376.39,156.23 R3504.2
  SIG5 w0.155: v1(200.85,193.16) 202.76,191.26 206.57,191.26 207.45,190.37 232.79,190.37 233.17,190.75 237.75,190.75 238.51,189.99 254.76,189.99 262.83,181.93 262.83,180.91 264.54,179.19 269.94,179.19 v1(270.19,179.45)
  SIG6 w0.155: v1(109.05,193.31) 110.05,194.31 149.71,194.31 150.6,195.2 198.82,195.2 v1(200.85,193.16) ; v1(270.19,179.45) 271.08,180.34 280.84,180.34 287.47,186.97 322.49,186.97 329.74,194.22 348.26,194.22 358.84,183.64 363.16,183.64 364.5,182.3 377.7,182.3 381.83,178.18 381.83,165.73 376.64,160.55 376.64,156.49 v1(376.11,155.95) 376.11,140.59 372.3,136.78 372.3,108.46 380.17,100.58 v1(388.56,100.58)
  SIG7 w0.155: v1(109.05,193.31) 109.05,193.94 105.51,197.48 88.71,197.48 76.14,210.06 74.61,210.06 v1(73.98,209.42) 73.22,208.66 73.22,201.8 68.9,197.48 60.81,197.48 51.92,188.59 50.48,188.59 41.34,179.45 34.23,179.45 29.02,174.24 26.86,174.24 v1(26.23,173.61)
  SIG8 w0.155: v1(73.98,209.42) 73.98,209.17 74.87,208.28 81.24,208.28 86.36,213.4 YJ3.C7_2
  SIG9 w0.155: v1(404.69,194.43) 405.45,193.67 405.45,193.16 406.25,192.36 408.92,192.36 410.31,190.97 410.31,189.11 411.08,188.33 411.08,186.94 413.41,184.61 413.41,174.02 394.96,155.57 376.49,155.57 v1(376.11,155.95)
  BOTTOM w0.13: v1(26.23,173.61) 25.77,173.15 v2(25.77,172.08) 25.77,171.12 25.31,170.66 R3267.2 ; R3358.2 403.77,192.5 404.05,192.78 404.05,193.7 R3501.2 404.58,194.33 v1(404.69,194.43)
BMC_STATUS_LED: length 141.9
  TOP w0.13: U124.K5 v1(398.82,179.25) ; v1(388.94,63.37) 388.94,62.35 390.41,60.88 R3352.1 391.77,60.88 392.02,61.13 392.02,62.98 391.35,63.66 D429.4
  SIG7 w0.102: 396.7,178.85 398.42,178.85 v1(398.82,179.25)
  SIG7 w0.155: v1(388.94,63.37) 386.27,66.04 386.27,75.34 392.36,81.43 392.36,97.15 395.16,99.95 395.16,100.71 395.89,101.44 396.08,101.44 404.78,110.14 404.78,143.86 405.92,145 405.92,155.99 396.3,165.61 396.3,174.62 395.67,175.26 395.67,178.31 396.21,178.85 396.7,178.85
  BOTTOM w0.13: v1(388.94,63.37) 388.94,62.99 v2(389.32,62.61)
BS_PLL_0_1_AVDD1P8: length 6.8
  TOP w0.229: U1.BH34 v1(196.55,154.34) ; U1.BL34 v1(196.55,157.34)
  TOP w0.381: 163.86,190.9 L440.1 163.26,190.27 ; 164.69,190.9 C3043.1 ; C3043.1 165.29,190.27 ; C3043.1 165.89,190.9
  BOTTOM w0.13: v1(164.78,189.66) v2(164.78,190.5)
  BOTTOM w0.381: C3019.1 196.03,156.82 v1(196.55,157.34) ; v1(196.55,154.34) 196.03,153.82 C3012.1
  vias: v1(165.67,189.66)
CDCM_STA: length 335.6
  TOP w0.13: U123.C4 v1(20.85,163.8)
  SIG9 w0.155: v1(302.15,216.35) 302.15,217.73 296.73,223.14 121.48,223.14 115.25,216.91 115.25,211.71 111.47,207.92 72.67,207.92 71.65,208.94 54.7,208.94 36.72,190.96 29.61,190.96 27.62,188.97 27.62,187.2 26.35,185.93 26.35,184.53 21.91,180.08 21.91,177.42 20.64,176.15 16.95,176.15 14.03,173.23 14.03,170.69 v1(14.92,169.8)
  BOTTOM w0.13: v1(20.85,163.8) 20.85,165.64 20.51,165.99 18.61,165.99 17.84,166.75 17.84,167.89 17.08,168.65 R3260.2 v2(15.81,169.69) 15.02,169.69 v1(14.92,169.8) ; R3159.2 v1(302.15,216.35)
COP_JTAG_TCK: length 29.2
  SIG8 w0.155: v1(9.82,186.41) 10.88,186.41 13.53,183.77 17.46,183.77 19.24,185.54 19.24,187.03 v1(18.56,187.7) 18.95,188.08 19.75,188.08 21.4,186.43 25.72,186.43 v1(26.99,187.7)
  BOTTOM w0.13: v2(9.21,185.93) 9.33,185.93 v1(9.82,186.41) R3202.2 R3203.1 ; U119.17 v1(18.56,187.7) ; U120.17 26.44,188.25 v1(26.99,187.7)
COP_JTAG_TDI: length 6.5
  TOP w0.13: R3206.1 R3208.2 16.19,184.76 v1(16.47,185.04)
  BOTTOM w0.13: v1(16.47,185.04) 15.96,185.54 U119.13
COP_JTAG_TDO: length 23.5
  TOP w0.13: J33.3 11.75,186.31 12.76,185.29 TP3.1 v1(11.87,184.15)
  SIG3 w0.155: v1(23.81,179.07) 21.4,181.48 14.54,181.48 v1(11.87,184.15)
  BOTTOM w0.13: v2(24.57,178.31) v1(23.81,179.07) R3222.2
COP_JTAG_TMS: length 25.9
  SIG8 w0.155: v1(25.14,187.77) 24.56,187.2 21.68,187.2 20.03,188.85 18.61,188.85 17.34,187.58 17.34,184.91 16.95,184.53 13.91,184.53 12.48,185.95 v1(12.48,186.59)
  BOTTOM w0.13: U120.15 v1(25.14,187.77) ; R3204.1 R3209.2 ; R3209.2 v1(12.48,186.59) v2(11.91,186.01) ; R3209.2 14.53,187.32 14.66,187.45 U119.11
COP_JTAG_TRST: length 25.8
  SIG6 w0.155: v1(21.04,195.86) 21.91,194.99 21.91,192.79 23.84,190.86 v1(23.84,187.86)
  SIG8 w0.155: v1(33.59,190.12) 32.7,190.12 32.19,189.61 25.59,189.61 v1(23.84,187.86)
  BOTTOM w0.13: R3207.2 v2(21.04,198.09) ; R3207.2 v1(21.04,195.86) ; R3207.2 R3205.2 ; R3228.1 v1(33.59,190.12) ; U120.13 v1(23.84,187.86)
CORE_PLL_AVDD1P8: length 4.2
  TOP w0.13: U1.AN15 v1(216.55,138.34)
  TOP w0.381: 235.05,138.53 C83.1 ; C83.1 236.25,138.53 ; C83.1 235.65,139.16
  TOP w0.508: L442.1 235.14,140.46
  BOTTOM w0.381: C84.1 216.07,138.82 v1(216.55,138.34)
  vias: v1(235.14,139.7) v1(236.16,139.7)
CORE_TEMP0: length 502.9
  TOP w0.178: 375.83,171.5 376.65,170.68 U140.44
  TOP w0.229: D439.32 v1(67.25,171.84) ; D440.32 v1(67.25,182) ; v1(348.43,134.63) D441.32 ; D442.32 v1(348.43,144.79) ; D437.32 v1(67.12,151.52) ; D435.32 67.68,131.2 v1(67.67,131.21) ; D444.32 v1(348.43,154.95) ; D438.32 v1(67.25,161.68) ; D443.32 v1(348.43,165.11) ; D436.32 v1(67.12,141.36)
  TOP w0.305: 375.83,171.5 v1(375.6,171.5) 375.2,171.5 375.02,171.68 C3948.1
  SIG4 w0.381: v1(67.67,131.21) 66.98,131.21 65.72,132.47 65.72,139.96 v1(67.12,141.36) 65.47,143.01 65.47,145.92 66.48,146.94 66.48,150.88 v1(67.12,151.52) 65.72,152.91 65.72,160.15 v1(67.25,161.68) 65.98,162.95 65.98,167 66.48,167.51 66.48,171.07 v1(67.25,171.84) 65.85,173.23 65.85,175.51 66.99,176.65 66.99,181.74 v1(67.25,182) 65.85,183.39 65.85,188.21 68.01,190.37 68.01,192.02 68.57,192.58 73.42,192.58 74.75,193.91 107.52,193.91 107.87,193.56 108.41,193.56 108.76,193.91 126.8,193.91 132.14,199.26 155.13,199.26 159.07,203.2 192.95,203.2 194.75,201.39 210.88,201.39 211.87,200.4 211.87,198.9 213.62,197.16 228.61,197.16 233.88,202.42 274.49,202.42 286.56,214.5 306.39,214.5 306.77,214.88 309.31,214.88 309.38,214.96 310.88,214.96 311.47,214.37 322.01,214.37 335.72,200.66 358.46,200.66 368.57,190.55 369.05,190.55 369.95,189.65 369.95,185.1 371.28,183.77 371.28,177.8 370.01,176.53 370.01,170.3 371.54,168.78 373.57,168.78 375.6,170.81 v1(375.6,171.5)
  SIG6 w0.381: v1(348.43,165.11) 347.4,164.08 347.4,161.06 348.18,160.29 348.18,158.89 346.94,157.65 346.94,155.64 347.62,154.95 v1(348.43,154.95) 348.43,154.5 347.4,153.47 347.4,150.95 348.21,150.14 348.21,145.02 v1(348.43,144.79) 349.39,143.84 349.39,138.12 349.19,137.92 349.19,135.39 v1(348.43,134.63)
  SIG7 w0.381: v1(348.43,165.11) 353.1,165.11 358.8,170.81 362.27,170.81 363.41,171.96 375.15,171.96 v1(375.6,171.5)
  BOTTOM w0.13: v1(67.67,131.21) 67.67,131.74 v2(67.88,131.95)
CORE_TEMP1: length 43.6
  TOP w0.203: U140.45 376.25,170.52 375.86,170.91 375.5,170.91
  TOP w0.229: D446.32 v1(348.43,175.27) ; D445.32 v1(348.43,185.43)
  TOP w0.381: v1(372.96,172.82) 372.96,172.44 373.32,172.08 C3949.1 374.35,171.59 375.02,170.91 375.5,170.91
  SIG6 w0.381: v1(348.43,175.27) 349.04,175.88 349.04,179.3 349.37,179.63 349.37,184.5 v1(348.43,185.43)
  SIG7 w0.381: v1(348.43,175.27) 352.09,175.27 353.89,173.48 372.3,173.48 v1(372.96,172.82)
  BOTTOM w0.13: v1(348.43,185.43) 347.92,184.92 v2(347.92,184.78)
CPLD3.3V: length 414.5
  TOP w0.178: U123.A1 v1(18.45,165.4) ; U124.K7 v1(401.22,179.25) U124.K8 ; U124.K7 v1(400.42,180.05) U124.J7 ; U124.K7 v1(400.42,179.25) ; U123.G7 v1(23.25,159.8) U123.H7 ; U123.G7 v1(24.05,160.6) U123.G8 ; U123.G7 v1(23.25,160.6) ; U124.T16 v1(408.42,174.45) ; U124.G8 v1(401.22,182.45) U124.G7 ; U123.N5 v1(21.65,155) ; U124.H10 v1(403.62,181.65) U124.G10 ; U124.K10 v1(403.62,179.25) ; U124.K10 v1(402.82,179.25) U124.K9 ; U124.K10 v1(403.62,180.05) U124.J10 ; U123.D5 v1(21.65,163) ; U124.M4 v1(398.02,177.65) ; U123.E4 v1(20.85,162.2) ; U124.G9 v1(402.82,182.45) U124.G10 ; U124.D5 v1(398.82,184.85) ; U123.K10 v1(26.45,158.2) U123.J10 ; U123.K10 v1(25.65,157.4) U123.K9 ; U123.K10 v1(26.45,157.4) ; U124.D12 v1(405.22,184.85) ; U124.G7 v1(400.42,181.65) U124.H7 ; U124.G7 v1(400.42,182.45) ; U124.T1 v1(395.62,174.45) ; U124.E13 v1(406.02,184.05) ; U123.M4 v1(20.85,155.8) ; U124.N12 v1(405.22,176.85) ; U124.G10 v1(403.62,182.45) ; U124.E4 v1(398.02,184.05) ; U124.A1 v1(395.62,187.25) ; U123.G10 v1(25.65,160.6) U123.G9 ; U123.G10 v1(26.45,159.8) U123.H10 ; U123.G10 v1(26.45,160.6) ; U123.K7 v1(23.25,158.2) U123.J7 ; U123.K7 v1(23.25,157.4) ; U123.K7 v1(24.05,157.4) U123.K8 ; U123.T16 v1(31.25,152.6) ; U123.N12 v1(28.05,155) ; U124.M13 v1(406.02,177.65) ; U123.A16 v1(31.25,165.4) ; U124.A16 v1(408.42,187.25) ; U123.M13 v1(28.85,155.8) ; U123.E13 v1(28.85,162.2) ; U123.T1 v1(18.45,152.6) ; U123.D12 v1(28.05,163)
  TOP w0.203: U140.42 377.45,171.12 v1(377.28,171.3)
  TOP w0.229: U124.N5 v1(398.82,176.85)
  TOP w0.305: v1(421.7,129.28) 422.49,129.28 C111.1 422.62,128.65 422.49,128.52 421.93,128.52 420.91,127.51 420.91,126.87 420.73,126.69 U10.24 ; U12.24 20.45,98.49 20.64,98.68 20.64,99.54 C113.1 ; v1(421.81,116.71) 422.49,116.71 C119.1 422.62,116.08 422.49,115.95 421.93,115.95 420.91,114.93 420.91,114.3 420.73,114.11 U18.24 ; C112.1 56.07,106.04 55.44,105.41 55.44,104.14 54.87,103.57 U11.24
  TOP w0.33: U84.26 v1(405.72,92.99)
  TOP w0.381: R3295.1 v1(21.65,171.45) ; R462.1 412.56,116.71 v1(412.69,116.58) ; R3208.1 16.19,180.59 v1(17.72,179.07) ; R2989.2 241.11,86.23 v1(241.36,86.48) ; v1(412.32,60.51) 412.85,61.03 R3408.1 ; R440.1 R466.1 v1(410.2,115.36) ; 366.59,215.9 365.21,214.53 R3520.1 X260.1 ; R3654.2 R3658.2 v1(376.14,157.96) ; R3011.2 R3004.2 R3068.2 57.34,82.42 v1(57.72,82.8) ; R3357.1 v1(391.99,193.18) ; R3314.1 24.45,170.94 24.32,171.07 v1(24.32,171.45) ; v1(268.16,168.02) 265.24,168.02 264.43,168.83 R312.2 ; v1(377.15,157.96) 377.28,158.09 R3659.2 ; v1(54.55,82.8) R2988.2 R2979.2 ; R3003.2 v1(154.98,88.36) ; R252.1 v1(9.28,98.63) ; v1(393.73,59.89) 394.04,59.89 394.53,60.37 R3365.1 ; R3286.1 26.48,171.19 v1(26.23,171.45) ; v1(338.9,86.87) 339.28,86.48 R3030.2 ; R3656.2 376.26,160.4 v1(376.14,160.27) ; R3060.2 R3077.2 ; R3077.2 v1(246.7,82.8) ; R3077.2 R3021.2 v1(245.3,82.8) ; v1(341.06,82.8) 340.68,82.42 R3086.2 ; R3518.1 385.8,213.46 386.05,213.21 C3638.1 386.61,213.65 385.76,214.5 383.98,214.5 379.79,218.69 v1(374.71,218.69) ; R316.2 266.28,181.89 266,181.61 v1(266,181.35) ; v1(42.1,104.39) 42.79,103.71 R205.1 ; R2995.2 R3067.2 v1(152.72,82.8) ; R3027.2 v1(55.94,82.8) ; v1(343.22,82.8) 342.58,82.17 R3078.2 R3070.2 ; R2022.1 R2023.1 v1(408.5,96.14) ; 372.83,217.14 C3644.1 ; C3644.1 C3645.2 374.84,217.8 ; C3644.1 373.32,217.93 ; D92.5 v1(410.27,57.27) ; R3651.2 v1(375.12,160.27) ; J34.4 v1(33.59,194.31) ; v1(54.75,106.42) 55,106.68 56.58,106.68 56.73,106.53 C112.1 ; R3038.2 v1(335.47,85.95) ; v1(402.15,193.42) R3395.1 R3410.1 ; C3551.2 v1(18.28,148.31) ; R34.2 R3247.2 R35.2 200.06,205.97 v1(198.82,204.72) ; R183.1 v1(410.2,126.82) ; U14.8 265.65,179.73 265.29,180.08 C114.2 v1(264.6,180.92) ; v1(394.25,173.89) 394.25,173.66 393.73,173.15 392.95,173.15 391.73,174.37 C3578.2 ; R3037.2 R3029.2 246.7,90.8 v1(246.44,91.06) ; R3035.2 v1(150.71,88.36) ; R3389.1 407.89,61.03 v1(407.36,60.51) ; R470.1 v1(424.24,114.25) ; R3053.2 R2973.2 v1(242.51,82.8) ; v1(399.81,96.67) 400.35,96.67 400.67,96.99 R31.2 ; R3012.2 v1(151.83,88.36) ; C113.1 21.04,100.96 v1(20.76,100.68) ; U121.8 C3519.2 v1(198.84,202.66) ; v1(37.4,163.57) 37.27,163.45 R3259.1 ; C3523.2 v1(15.33,148.31) ; C3587.2 395.74,170.15 v1(395.52,169.92) ; v1(377.63,160.4) 377.61,160.42 R3660.2 ; v1(338.9,82.8) 339.28,82.42 R3054.2 ; R2024.1 v1(420.69,83.67) ; R3411.1 v1(416.96,60.05) ; R3044.2 v1(148.53,82.8) ; C3547.2 v1(31.53,148.31) ; R3019.2 60.13,89.53 v1(60.01,89.66) ; v1(407.23,193.29) R3402.1 R3377.1 ; v1(337.88,82.8) R2990.2 R2974.2 ; v1(47.31,106.8) 45.28,106.8 44.84,106.37 R224.1 ; R3028.2 v1(149.92,82.8) ; R3374.1 399.06,60.88 v1(398.38,60.2) ; v1(341.06,87.25) 342.07,86.23 R3006.2 ; R216.1 v1(410.2,127.94) ; R2025.1 v1(411.92,97.28) ; R3005.2 248.09,90.04 247.71,90.42 v1(247.71,91.56) ; R2972.2 v1(147.64,88.36) ; R3013.2 v1(243.9,82.8) ; J33.4 v1(11.75,193.29) ; R317.1 R313.2 v1(268.08,169.03) ; R3384.1 399.61,193.16 v1(399.35,193.42) ; R2996.2 v1(58.74,89.66) ; v1(414.46,183.77) R3401.2 ; C3593.2 v1(411.8,170.56) ; D93.5 v1(402.65,57.27) ; R2987.2 147.13,82.52 v1(147.41,82.8) ; C3562.2 v1(412.71,172.62) ; C3565.1 v1(412.71,187.17) ; R3020.2 v1(151.32,82.8) ; R3312.2 v1(37.27,150.11)
  TOP w0.508: v1(399.73,102.61) 399.71,102.59 C3520.2 U122.8
  BOTTOM w0.279: 20.51,190.15 U119.20
  BOTTOM w0.305: U17.24 413.76,126.69 413.45,127 413.45,127.63 412.98,128.1 C118.1 ; C117.1 46.19,105.66 46.8,105.66 47.69,104.77 47.69,103.76 47.87,103.57 U15.24 ; U13.24 413.89,114.11 413.7,114.3 413.7,115.44 413.19,115.95 411.92,115.95 411.82,116.05 C115.1 v1(412.69,116.58) ; U120.20 28.39,189.74 29.65,191.01 C3502.2 ; C116.1 11.49,100.96 12.93,99.53 12.93,98.65 13.09,98.49 U16.24
  BOTTOM w0.381: v1(54.75,106.42) 55.13,106.8 57.47,106.8 57.7,106.58 R374.1 58.99,106.04 59.63,105.41 59.63,104.26 59.25,103.88 57.87,103.88 R352.1 ; C3568.2 v1(394.25,173.89) ; C3501.1 v1(33.59,194.31) ; R3189.2 v1(22.42,179.07) ; C3552.2 18.55,152.7 v1(18.45,152.6) ; 408.39,174.47 C3589.2 ; 408.39,174.47 408.39,175.49 C3560.1 ; 408.39,174.47 v1(408.42,174.45) ; C3500.1 v1(11.75,193.29) ; v1(31.46,151.13) 31.74,150.85 C3528.2 ; v1(411.08,189.57) 411.08,189.42 410.41,188.74 C3567.2 ; R2026.1 R2030.1 v1(411.42,87.35) ; C3522.2 17.08,166.72 v1(17.11,166.75) 17.06,166.8 C3541.2 ; R3209.1 v1(10.6,187.32) ; v1(22.19,166.75) 22.03,166.9 C3536.2 ; C3569.2 406.44,172.82 v1(406.59,172.97) ; v1(18.45,152.6) 18.45,152.3 19.06,151.69 C3549.2 ; v1(18.45,152.6) 18.45,153.64 C3557.2 ; 401.99,178.81 401.65,178.81 v1(401.22,179.25) ; 401.99,178.81 402.39,178.81 v1(402.82,179.25) ; 401.99,178.81 402.02,178.79 C3563.2 ; C3527.2 C3553.2 31.53,153.64 31.31,153.41 31.31,152.65 v1(31.25,152.6) 30.54,152.6 C3524.2 ; v1(409.77,185.54) 409.79,185.57 C3570.2 ; C3564.2 v1(392.14,188.87) ; C3538.2 18.5,165.35 v1(18.45,165.4) 18.38,165.32 C3554.2 ; v1(31.25,165.4) 32.19,164.46 C3529.2 ; v1(31.25,165.4) 31.25,164.01 C3532.2 C3548.1 ; v1(31.25,165.4) 31.59,165.73 C3539.2 ; v1(424.24,114.25) R470.1 R297.1 ; 20.51,190.15 20.99,190.62 C3499.2 21.63,191.49 21.91,191.77 21.91,192.66 22.42,193.16 v1(22.8,193.16) R3225.1 ; R2995.2 R3067.2 v1(152.72,82.8) ; C3643.1 C3642.1 v1(374.71,218.69) ; C3643.1 372.17,218.31 v1(371.79,218.69) ; C3643.1 371.56,217.78 ; R3325.1 33.06,170.66 32.46,171.25 32.46,171.97 32.96,172.46 v1(33.21,172.46) ; v1(24.05,157.4) 24.46,156.99 C3545.2 ; C3582.2 C3583.2 ; C3582.2 400.37,181.59 v1(400.42,181.65) ; C3582.2 400.37,180.1 v1(400.42,180.05) ; C3558.2 v1(31.53,148.31) ; v1(42.1,104.39) 42.79,103.71 R205.1 ; C2071.1 v1(410.27,57.27) ; R3199.1 R3190.2 17.59,192.78 v1(17.84,193.04) ; C3574.2 396.79,188.62 v1(396.84,188.57) ; v1(246.7,82.8) R3077.2 R3060.2 ; R2974.2 R2990.2 v1(337.88,82.8) ; C3572.2 394.25,176.43 v1(394.27,176.4) ; v1(393.13,102.61) R32.2 R30.2 ; v1(412.69,129.16) 412.31,129.16 411.82,128.67 C118.1 ; C3533.2 v1(17.08,152.04) C3530.2 ; v1(198.84,202.66) 198.82,202.69 v2(198.06,202.69) ; C3543.2 27.25,159 v1(26.45,158.2) 26.2,158.46 C3556.2 ; R3188.2 v1(15.43,179.07) ; C3584.2 404.39,180.82 v1(403.62,180.05) 403.36,180.3 C3585.2 403.36,181.39 v1(403.62,181.65) ; v1(408.62,172.97) 408.9,172.69 C3580.2 ; R3226.1 v1(31.53,184.53) ; v1(409.77,179.45) 409.79,179.42 C3579.2 ; R3223.1 v1(32.45,188.08) ; v1(341.06,82.8) 340.68,82.42 R3086.2 R3022.2 ; C3502.2 30.32,191.41 30.8,191.89 v1(30.8,193.16) ; v1(32.6,157.6) 32.63,157.58 C3537.2 ; v1(424.24,115.36) R297.1 ; R297.1 R295.1 ; R3227.1 v1(28.51,193.16) ; v1(23.25,159.8) 23.08,159.62 C3534.2 ; C3595.2 409.77,175.13 v1(409.77,174.62) 409.92,174.47 C3575.2 ; C3576.2 v1(394.25,171.96) ; v1(338.9,82.8) 339.28,82.42 R3054.2 ; v1(23.25,158.2) 23.08,158.38 C3534.2 ; C3591.2 408.34,187.32 v1(408.42,187.25) 408.42,185.85 C3596.2 C3586.1 ; v1(405.72,92.99) 405.45,92.71 C2059.1 ; R353.1 23.51,98.63 23.69,98.8 v1(24.32,98.8) ; v1(25.65,160.6) 25.25,161.01 C3540.2 24.46,161.01 v1(24.05,160.6) ; v1(19.67,166.72) 19.62,166.77 C3525.2 ; C3526.2 31.08,166.9 v1(30.92,166.75) ; C3551.2 v1(18.28,148.31) ; C3581.2 401.63,182.85 v1(401.22,182.45) ; v1(33.72,167) 34,167.28 C3550.2 ; C2072.1 v1(402.65,57.27) ; R2987.2 147.13,82.52 v1(147.41,82.8) ; v1(54.55,82.8) R2988.2 R2979.2 ; R3403.1 v1(402.15,193.42) ; C3542.2 32.75,152.63 v1(32.6,152.78) ; C3544.2 C3534.2 ; 395.67,174.5 395.72,174.55 C3561.2 C3571.2 ; 395.67,174.5 v1(395.62,174.45) ; 395.67,174.5 C3573.2 ; v1(424.24,127.94) R454.1 R429.1 ; R2998.2 R3022.2 ; R3022.2 342.2,82.67 342.33,82.8 v1(343.22,82.8) ; v1(60.01,89.66) 60.13,89.53 R3019.2 ; v1(377.28,171.3) 377.3,171.27 C3942.1 ; v1(341.06,87.25) 342.07,86.23 R3006.2 ; v1(29.43,151.13) 29.27,150.98 C3555.2 ; R3020.2 v1(151.32,82.8) ; R3320.1 22.77,173.58 v1(23.3,174.11) ; v1(394.27,186.94) 394.25,186.97 C3592.2 ; v1(371.79,219.58) 371.28,219.58 v2(370.4,218.69) ; C3565.1 v1(412.71,187.17) ; R3053.2 241.11,82.42 241.49,82.8 v1(242.51,82.8) R2973.2 R3013.2 v1(243.9,82.8) v2(243.9,84.58) ; R3028.2 v1(149.92,82.8) ; C3566.2 399.71,172.82 v1(399.86,172.97) ; R2996.2 v1(58.74,89.66) ; R3021.2 v1(245.3,82.8) ; v1(57.72,82.8) 57.34,82.42 R3068.2 R3004.2 R3011.2 ; R183.1 v1(410.2,126.82) ; C3545.2 25.25,156.99 v1(25.65,157.4) ; C3545.2 C3535.2 ; R3406.1 R3402.1 v1(407.23,193.29) ; v1(12.51,100.96) 12,101.47 11.37,101.47 11.14,101.24 C116.1 ; v1(17.11,154.94) 17.06,154.89 C3546.2 ; R252.1 v1(9.28,98.63) ; R3187.2 v1(17.72,179.07) ; R3044.2 v1(148.53,82.8) ; R3284.1 v1(28.51,168.78) ; C3577.2 395.54,187.17 v1(395.62,187.25) 395.7,187.32 C3588.2 ; R3027.2 v1(55.94,82.8)
  BOTTOM w0.508: C117.1 46.06,106.3 46.8,106.3 v1(47.31,106.8)
  vias: v1(372.68,219.58) v1(372.68,218.69) v1(373.7,219.58) v1(373.7,218.69) v1(374.71,219.58)
CPLD3.3V_EN: length 12.3
  TOP w0.381: U129.5 v1(382.08,213.61)
  BOTTOM w0.13: v1(382.08,213.61) 381.32,212.85 381.32,211.83 v2(380.11,210.63) 378.3,208.81 R3545.1 R3539.2 376.36,208.4 375.09,207.13 375.09,206.25
CPLD_CDCM_MISO: length 334.4
  TOP w0.13: v1(19.37,172.46) 18.86,171.96 18.86,169.82 18.99,169.69 R3251.2 19.37,169.03 19.55,168.86 20.11,168.86 20.8,168.16 20.8,166.56 22.05,165.31 U123.A5
  SIG9 w0.155: v1(307.53,213.23) 306.4,214.36 290.96,214.36 284.35,220.97 122.2,220.97 117.29,216.07 117.29,210.86 112.31,205.88 71.82,205.88 70.8,206.9 56.85,206.9 34.87,184.92 33.46,184.92 30.16,181.62 30.16,180.21 27.11,177.16 27.11,171.07 26.48,170.43 20.26,170.43 19.86,170.83 19.86,171.97 v1(19.37,172.46)
  BOTTOM w0.13: v2(18.83,173.99) 18.83,173 v1(19.37,172.46)
  BOTTOM w0.381: R3136.1 307.25,212.95 v1(307.53,213.23)
CPLD_CDCM_MOSI: length 333.2
  TOP w0.13: R3256.2 v1(37.4,164.84)
  SIG9 w0.155: v1(308.37,215.49) 309.44,214.42 309.44,211.33 309.05,210.94 300.55,210.94 300.38,211.11 292.4,211.11 285.89,217.61 274.08,217.61 271.87,219.82 168.15,219.82 153.06,204.73 94.34,204.73 93.47,203.86 72.22,203.86 71.22,204.85 57.09,204.85 40.83,188.59 40.83,185.67 31.05,175.89 31.05,169.92 33.08,167.89 35.37,167.89 36,167.26 36,166.24 v1(37.4,164.84)
  BOTTOM w0.13: U117.2 302.26,210.63 303.52,211.89 303.52,212.41 304.47,213.36 304.47,213.69 v2(304.51,213.73) 305,214.22 R3151.2 305.73,214.63 305.96,214.86 307.73,214.86 v1(308.37,215.49)
CPLD_CDCM_PDN: length 320
  SIG9 w0.155: v1(299.78,217.29) 299.2,216.71 299.2,215.95 298.89,215.65 293.08,215.65 286.48,222.25 121.68,222.25 116.02,216.6 116.02,211.39 111.79,207.15 72.35,207.15 71.33,208.17 55.02,208.17 35.57,188.72 31.56,188.72 30.29,187.45 30.29,184.35 25.59,179.65 25.59,178.69 21.02,174.11 21.02,173.23 v1(20.51,172.72)
  BOTTOM w0.13: v1(299.78,217.29) 300.29,216.79 300.29,214.75 300.16,214.63 R3148.2 299.73,214.26 298.2,212.73 U117.43 ; v1(20.51,172.72) v2(21.15,172.08) 21.15,170.81 21.3,170.66 R3298.2
CPLD_CDCM_RST: length 319.9
  TOP w0.13: R3258.1 v1(20.51,171.45)
  SIG9 w0.155: v1(300.93,217.29) 300.29,216.66 300.29,215.64 299.65,215.01 291.91,215.01 285.3,221.61 121.94,221.61 116.66,216.33 116.66,211.12 112.05,206.52 72.09,206.52 71.07,207.54 55.64,207.54 35.3,187.2 32.58,187.2 31.05,185.67 31.05,183.89 26.86,179.7 26.86,178.69 22.34,174.16 22.34,173.27 v1(20.51,171.45)
  BOTTOM w0.13: v1(300.93,217.29) 301.43,217.29 v2(301.69,217.04) 301.69,216.79 301.43,216.53 301.43,214.83 301.24,214.63 R3152.2 298.71,212.46 U117.44
CPLD_CDCM_SCK: length 332.1
  TOP w0.13: R3268.1 v1(18.22,171.45)
  SIG9 w0.155: v1(308.75,211.68) 308.09,212.34 306.74,212.34 305.97,211.57 292.55,211.57 285.89,218.23 274.27,218.23 272.3,220.21 165.66,220.21 150.57,205.11 94.18,205.11 93.31,204.24 72.38,204.24 70.48,206.13 57.74,206.13 35.94,184.34 35.94,183.58 29.78,177.42 29.78,172.21 26.86,169.29 18.86,169.29 18.22,169.92 v1(18.22,171.45)
  BOTTOM w0.13: v1(308.75,211.68) 308.11,211.05 305.96,211.05 305.73,210.82 R3139.1 304.88,210.41 v2(304.23,209.76) 303.59,209.13 U117.5
CPLD_CDCM_SS: length 335.7
  SIG9 w0.155: v1(308.55,213.23) 308.04,212.72 306.9,212.72 306.34,213.28 291.5,213.28 284.19,220.59 122.36,220.59 117.68,215.91 117.68,210.7 112.47,205.5 71.66,205.5 70.64,206.52 57.11,206.52 35.05,184.46 35.05,183.58 28.26,176.78 28.26,171.32 26.86,169.92 19.37,169.92 18.73,170.56 18.73,171.83 18.22,172.34 v1(18.22,172.46)
  BOTTOM w0.13: v1(18.22,172.46) 18.86,171.83 18.86,170.84 19.04,170.66 R3257.1 ; v1(308.55,213.23) 307.66,212.34 305.88,212.34 305.73,212.19 R3150.2 304.84,211.68 v2(304.23,211.07) 302.79,209.63 U117.4
CPLD_CDCM_SYNCN: length 330
  TOP w0.13: v1(12.26,166.24) R3265.1
  SIG9 w0.155: v1(298.64,217.29) 293.18,222.76 121.64,222.76 115.64,216.75 115.64,211.55 111.63,207.54 72.51,207.54 71.49,208.56 54.86,208.56 36.88,190.57 33.29,190.57 32.32,189.61 29.91,189.61 28.38,188.08 28.38,184.4 23.05,179.07 23.05,177.54 20.13,174.62 17.21,174.62 16.45,173.86 16.45,170.3 15.3,169.16 14.29,169.16 13.91,168.78 13.91,167.89 v1(12.26,166.24)
  BOTTOM w0.13: U117.42 297.71,212.8 298.59,213.69 R3149.2 299.02,214.63 299.15,214.75 299.15,216.79 v1(298.64,217.29) v2(298.64,218.06)
CPLD_QSFP_EN: length 30.3
  TOP w0.13: v1(33.08,151.13) 36.49,147.72 R3535.1 ; U123.D7 v1(23.25,163)
  SIG8 w0.102: v1(23.25,163) U123.D7 24.53,162.6 24.83,162.3 24.83,161.97
  SIG8 w0.155: 24.83,161.97 24.83,159.38 25.21,159 30.42,159 31.94,157.48 31.94,152.27 v1(33.08,151.13)
  BOTTOM w0.13: v1(33.08,151.13) v2(33.64,150.57)
CPLD_RESERVE1: length 419.9
  TOP w0.13: U124.C7 v1(400.42,185.65)
  SIG6 w0.155: v1(38.29,154.3) 38.93,153.67 42.86,153.67 47.43,158.24 49.97,158.24 50.38,158.65 50.38,167.88 51.2,168.69 51.2,182.27 64.12,195.2 64.71,195.2 65.73,196.22 72.2,196.22 73.48,197.49 176.33,197.49 176.46,197.36 187.51,197.36 188.05,197.91 206.48,197.91 207.43,196.95 248.88,196.95 250.79,195.04 280.1,195.04 281.6,193.55 286.56,193.55 290.61,189.49 321.65,189.49 329.85,197.69 347.93,197.69 353.66,191.96 359.96,191.96 362.43,189.49 362.43,187.87 366.3,183.99 382.26,183.99 383.26,184.99 388.13,184.99 391.16,188.02 391.16,189.67 392.75,191.26 399.44,191.26 400.42,190.28 v1(400.42,185.65)
  BOTTOM w0.13: R3309.1 36.49,153.92 36.74,153.67 v2(37.86,153.67) 38.29,154.1 v1(38.29,154.3)
CPLD_RESERVE2: length 417
  TOP w0.13: v1(36.64,151) 36.49,151.15 R3297.2 ; U124.D7 v1(400.42,184.85)
  SIG6 w0.102: v1(400.42,184.85) 400.02,185.25 400.02,186.61
  SIG6 w0.155: 400.02,186.61 400.02,187.42 399.34,188.1 393.57,188.1 392.42,186.94 391.41,186.94 387.62,183.15 365.3,183.15 362.9,185.54 358.31,185.54 347.76,196.09 330.25,196.09 322.27,188.11 262.56,188.11 257.58,193.09 250.21,193.09 247.21,196.09 206.44,196.09 205.42,197.1 188.34,197.1 187.83,196.6 139.64,196.6 138.9,195.86 73.84,195.86 73.31,195.33 69.25,195.33 68.08,194.16 64.17,194.16 51.96,181.96 51.96,175.95 52.64,175.28 52.64,174.63 51.96,173.96 51.96,168.22 51.15,167.41 51.15,157.89 43.5,150.24 38.29,150.24 37.53,151 v1(36.64,151)
  BOTTOM w0.13: v1(36.64,151) v2(36.64,151.76)
