# Allegro board RA-B6910-64C-MAC.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
VDD5.0V on BOTTOM (solid shape): 350.63,157.88 350.63,154.96 350.5,154.83 349,154.83 348.81,155.03 348.81,155.04 348.7,155.22 348.52,155.33 348.51,155.33 348.09,155.75 348.09,157.47 348.11,157.5 348.13,157.5 348.36,157.62 348.47,157.86 348.47,157.88 348.85,158.26 350.24,158.26
VDD5.0V on BOTTOM (solid shape): 350.5,137.69 350.5,134.77 350.37,134.64 349.09,134.64 348.21,135.52 348.21,137.08 348.24,137.15 348.32,137.18 348.64,137.33 348.7,137.68 348.72,137.77 348.8,137.82 350.37,137.82
VDD5.0V on BOTTOM (solid shape): 67.2,181.44 67.68,181.44 67.88,181.24 67.88,179.55 67.85,179.48 67.77,179.45 67.45,179.3 67.39,178.95 67.38,178.86 67.3,178.81 65.72,178.81 65.6,178.94 65.6,181.86 65.72,181.99 66.65,181.99
VDD5.0V on BOTTOM (solid shape): 66.73,141.22 66.76,141.21 66.77,141.19 67.06,140.98 67.43,141.1 67.46,141.09 67.88,140.67 67.88,138.98 67.87,138.95 67.84,138.93 67.6,138.81 67.5,138.57 67.5,138.55 67.12,138.17 65.72,138.17 65.6,138.3 65.6,141.09 65.72,141.22
VDD5.0V on TOP: 271.46,216.2 278.12,216.2 278.73,215.59 278.73,213.69 278.65,213.61 276.85,213.61 276.29,214.17 271.59,214.17 271.34,214.42 271.34,216.08
VDD5.0V on BOTTOM: 350.46,187.96 350.46,185.16 350.33,185.04 349.19,185.04 348.55,185.67 348.55,187.7 348.93,188.08 350.33,188.08
VDD5.0V on BOTTOM: 65.6,171.7 67.12,171.7 67.5,171.32 67.5,169.8 67.25,169.54 65.6,169.54 65.47,169.67 65.47,171.57
VDD5.0V on SIG1: 51.22,136.27 49.15,138.34 49.15,171.76 39.31,181.61 39.31,199.9 45.59,206.18 67.31,206.18 70.8,202.69 83.76,202.69 86.3,200.15 92.77,200.15 93.92,201.29 93.92,204.98 94.42,205.48 105.35,205.48 123,223.14 377.76,223.14 381.7,219.2 381.7,199.39 369.91,187.6 369.91,135.3 368.03,133.42 348.17,133.42 347.28,134.31 347.28,185.93 346.77,186.43 344.6,186.43 338.7,192.33 338.65,192.33 325.76,205.22 325.69,205.22 323.02,207.89 323.02,211.45 321.37,213.1 312.1,213.1 311.34,212.34 311.34,205.73 310.83,205.22 257.32,205.22 257.27,205.17 135.29,205.17 123.41,193.29 70.64,193.29 69.02,191.67 69.02,128.9 68.79,128.66 64.71,128.66 57.1,136.27
VDD12V on TOP (solid shape): 369.51,117.35 369.51,111.38 369.38,111.25 367.6,111.25 367.47,111.38 367.47,113.32 367.49,113.35 367.53,113.37 368.42,113.37 368.42,114.46 367.53,114.46 367.49,114.48 367.47,114.51 367.47,114.68 366.84,115.31 366.84,117.35 366.97,117.47 369.38,117.47
VDD12V on TOP (solid shape): 384.49,198 384.49,195.7 384.24,195.45 378.4,195.45 378.27,195.58 378.27,197.23 378.4,197.36 380.34,197.36 380.38,197.34 380.39,197.3 380.39,196.42 381.48,196.42 381.48,197.3 381.5,197.34 381.53,197.36 381.7,197.36 382.42,198.08 384.41,198.08
VDD12V on TOP (solid shape): 379.03,212.88 379.03,211.04 378.97,210.95 378.87,210.96 378.31,210.69 378.87,210.42 378.97,210.44 379.03,210.34 379.03,210.31 378.9,210.18 372.94,210.18 372.81,210.31 372.81,212.09 372.94,212.21 374.88,212.21 374.91,212.2 374.93,212.16 374.93,211.27 376.02,211.27 376.02,212.16 376.04,212.2 376.07,212.21 376.24,212.21 376.96,212.94 378.97,212.94
VDD12V on TOP (solid shape): 43.75,139.21 43.75,137.35 44.45,136.65 49.27,136.65 49.32,136.69 49.35,136.71 49.39,136.69 49.85,136.23 49.85,132.28 49.47,131.9 43.17,131.9 43.09,131.91 43.02,131.91 42.93,131.91 42.89,131.93 42.88,131.96 42.88,133.02 41.78,133.02 41.78,131.95 41.77,131.92 41.73,131.9 41.42,131.9 40.34,130.83 40.07,130.83 40.03,130.84 40.02,130.88 40.02,131.39 39.97,131.44 39.82,131.44 39.79,131.4 39.79,130.88 39.77,130.84 39.73,130.83 39.57,130.83 39.53,130.84 39.52,130.88 39.52,131.36 39.46,131.42 39.35,131.42 39.29,131.35 39.29,130.88 39.27,130.84 39.23,130.83 39.08,130.83 39.04,130.84 39.03,130.88 39.03,131.36 38.96,131.42 38.84,131.42 38.79,131.37 38.79,130.88 38.77,130.84 38.74,130.83 38.58,130.83 38.54,130.84 38.53,130.88 38.53,131.38 38.47,131.43 38.36,131.43 38.28,131.36 38.28,130.88 38.27,130.84 38.23,130.83 38.08,130.83 38.05,130.84 38.03,130.88 38.03,130.96 38.03,131.02 38.03,132.43 38.3,132.69 38.3,136.31 38.08,136.53 38.08,139.02 38.52,139.45 43.51,139.45
VDD12V on TOP (solid shape): 381.88,124.98 381.88,117.73 381.87,117.65 381.86,117.57 381.86,117.28 381.85,117.25 381.81,117.23 380.76,117.23 380.76,116.14 381.83,116.14 381.86,116.12 381.88,116.09 381.88,115.48 382.05,115.31 382.46,115.31 382.95,114.82 382.95,114.43 382.93,114.39 382.9,114.37 382.39,114.37 382.34,114.33 382.34,114.18 382.38,114.14 382.9,114.14 382.93,114.13 382.95,114.09 382.95,113.92 382.93,113.89 382.9,113.87 382.42,113.87 382.36,113.81 382.36,113.71 382.42,113.64 382.9,113.64 382.93,113.63 382.95,113.59 382.95,113.43 382.93,113.4 382.9,113.38 382.41,113.38 382.35,113.32 382.35,113.19 382.4,113.14 382.9,113.14 382.93,113.13 382.95,113.09 382.95,112.94 382.93,112.9 382.9,112.88 382.4,112.88 382.34,112.83 382.34,112.71 382.41,112.64 382.9,112.64 382.93,112.62 382.95,112.59 382.95,112.44 382.93,112.4 382.9,112.39 382.37,112.39 382.3,112.32 382.3,112.22 382.38,112.15 382.9,112.15 382.93,112.13 382.95,112.1 382.95,111.92 382.93,111.89 382.9,111.87 381.7,111.87 380.93,112.65 374.55,112.65 374.32,112.88 374.32,119.75 374.59,120.01 376.25,120.01 376.78,120.55 376.78,124.96 377.25,125.43 381.43,125.43
VDD12V on TOP (solid shape): outline of 81 points within 374.58,135.88 383.2,149.43
VDD12V on BOTTOM (solid shape): 376.36,212.09 376.36,210.44 376.24,210.31 372.81,210.31 372.68,210.44 372.68,212.09 372.81,212.21 375.28,212.21 376.24,212.21
VDD12V on BOTTOM (solid shape): 23.39,131.74 23.39,125.36 23.12,125.09 14.48,125.09 14.3,124.92 13.85,124.92 13.01,124.08 9.88,124.08 9.85,124.09 9.83,124.13 9.83,125.63 10.4,126.2 10.4,132.03 10.59,132.22 22.91,132.22
VDD12V on BOTTOM (solid shape): 46.51,137.33 50.01,137.33 51.07,136.27 51.07,133.12 50.85,132.56 50.7,131.98 50.69,131.97 50.65,131.92 50.32,131.92 50.16,132.07 39.19,132.07 38.08,133.18 38.08,139.02 38.52,139.45 44.39,139.45
VDD12V on BOTTOM (solid shape): 381.83,197.23 381.83,195.58 381.7,195.45 378.27,195.45 378.21,195.51 378.2,195.53 378.19,195.56 378.2,195.8 378.14,196.05 378.14,197.23 378.27,197.35 380.74,197.35 380.74,197.36 381.7,197.36
VDD12V on BOTTOM (solid shape): 369.38,114.68 369.38,111.25 369.25,111.12 367.6,111.12 367.48,111.25 367.48,113.72 367.47,114.08 367.48,114.08 367.53,114.37 367.48,114.65 367.48,114.66 367.49,114.69 367.6,114.81 369.25,114.81
VDD12V on TOP: 148.59,210.05 147.58,210.05 146.9,209.37 142.72,209.37 142.57,209.22 142.57,207.26 142.78,207.06 148.52,207.06 148.66,207.2 148.66,209.98
VDD12V on TOP: 10.18,125.27 9.98,125.27 9.83,125.12 9.83,123.69 9.93,123.59 10,123.59 10.1,123.69 10.1,124.41 10.18,124.49 10.28,124.49 10.34,124.43 10.34,123.59 10.35,123.59 10.6,123.59 10.6,124.38 10.67,124.45 10.78,124.45 10.84,124.39 10.84,123.59 11.1,123.59 11.1,124.39 11.15,124.44 11.28,124.44 11.34,124.38 11.34,123.59 11.34,123.59 11.6,123.59 11.6,124.37 11.67,124.44 11.77,124.44 11.83,124.37 11.83,123.59 11.83,123.59 12.1,123.59 12.1,124.41 12.14,124.45 12.28,124.45 12.33,124.4 12.33,123.6 12.34,123.59 12.47,123.59 12.47,123.65 13.73,124.92 22.37,124.92 22.54,125.09 22.54,131.82 22.16,132.2 16.93,132.2 16.04,131.32 11.37,131.32 10.73,130.68 10.73,125.83
VDD12V on TOP: 258.25,214.5 255.84,214.5 253.05,211.71 253.05,210.31 253.3,210.06 258.51,210.06 258.76,210.31 258.76,213.99
VDD12V on TOP: 60.64,223.07 61.09,222.63 70.55,222.63 71.18,221.99 71.18,209.29 71.82,208.66 75.37,208.66 75.88,208.15 75.88,199.64 75.63,199.39 72.58,199.39 71.95,200.02 71.95,203.58 71.06,204.47 60.52,204.47 59.18,203.13 59.18,201.04 58.23,200.09 48.39,200.09 47.5,200.97 47.5,203.07 46.58,203.99 39.47,203.99 37.15,201.67 18.1,201.67 8.95,210.82 8.95,221.36 10.67,223.07
VDD12V on BOTTOM: 67.88,223.07 68.9,222.06 68.9,207.83 67.63,206.56 39.18,206.56 38.86,206.25 21.4,206.25 21.15,205.99 13.53,205.99 13.51,206 12.73,206 8.95,209.77 8.95,221.36 10.67,223.07
VDD12V on BOTTOM: 378.78,124.58 381.83,124.58 381.95,124.46 381.95,117.73 381.7,117.47 378.78,117.47 378.52,117.73 378.52,124.33
VDD12V on BOTTOM: 379.1,148.71 382.14,148.71 382.27,148.59 382.27,141.86 382.25,141.83 382.25,135.1 381.72,134.58 381.34,134.58 380.93,134.98 378.58,134.98 377.27,136.29 375.58,136.29 375.05,136.82 375.05,144.66
VDD12V on BOTTOM: 142.67,209.32 148.38,209.32 148.6,209.1 148.6,207.3 148.4,207.09 142.82,207.09 142.57,207.34 142.57,209.22
VDD12V on SIG5: 356.43,109.47 355.66,110.23 355.66,146.94 352.11,150.49 327.47,150.49 326.07,151.89 326.07,165.61 325.18,166.49 281.37,166.49 252.92,194.94 70.55,194.94 68.39,192.78 68.39,187.5 66.22,185.33 66.22,142.23 49.21,125.22 5.91,125.22 1.02,130.12 1.02,168.56 2.04,169.58 6.07,169.58 6.07,174.39 1.88,174.39 1.02,175.25 1.02,220.79 1.08,220.85 1.08,222.37 2.66,223.96 71.51,223.96 74.23,221.23 74.23,212.47 78.55,208.15 110.17,208.15 125.98,223.96 395.17,223.96 397.32,223.39 397.83,222.88 397.83,203.07 389.95,195.2 389.95,113.28 386.14,109.47 ; 2 cut-outs
VDD_CORE on TOP (solid shape): outline of 296 points within 87.74,127.1 118.2,193.07
VDD_CORE on BOTTOM (solid shape): 96.97,193.42 102.47,193.42 102.49,193.4 107.98,193.4 108.78,192.61 108.78,129.97 106.26,127.45 88.27,127.45 87.74,127.99 87.74,193.11 88.04,193.42 96.96,193.42
VDD_CORE on TOP: 153.61,100.32 155.13,98.8 158.31,98.8 158.43,98.93 158.43,100.84 157.42,101.85 157.42,113.03 157.92,113.54 157.92,114.68 157.8,114.81 153.99,114.81 153.61,114.43
VDD_CORE on TOP: 211.65,183.89 211.52,183.77 202.88,183.77 202.76,183.89 202.76,185.29 202.88,185.42 211.52,185.42 211.65,185.29
VDD_CORE on TOP: 286.32,164.84 287.21,165.73 325.18,165.73 327.09,163.83 327.09,123.95 326.58,123.44 289.12,123.44 286.32,126.24
VDD_CORE on TOP: 231.71,181.35 231.52,181.16 228.47,181.16 227.01,179.7 216.6,179.7 216.47,179.83 216.47,183.13 216.6,183.26 231.58,183.26 231.71,183.13
VDD_CORE on TOP: 145.86,128.14 146.88,129.16 146.88,141.35 146.75,141.48 143.32,141.48 143,141.16 143,128.23 143.09,128.14
VDD_CORE on TOP: 145.61,143 146.37,143.76 146.37,150.81 145.41,151.76 143.83,151.76 143.7,151.64 143.7,143.25 143.95,143
VDD_CORE on TOP: 147.01,92.33 147.44,92.75 147.44,115.03 147.43,115.04 147.43,117.21 145.86,118.77 145.86,126.24 145.73,126.36 143.83,126.36 143.52,126.05 143.52,92.57 143.76,92.33
VDD_CORE on TOP: 254.44,167.13 256.6,167.13 256.73,167 256.73,113.15 256.6,113.03 253.17,113.03 253.05,113.15 253.05,135 254.25,136.2 254.25,166.94
VDD_CORE on TOP: 161.23,101.98 164.78,101.98 164.91,101.85 164.91,100.71 164.78,100.58 161.23,100.58 161.1,100.71 161.1,101.85
VDD_CORE on TOP: 216.47,190.12 231.58,190.12 231.71,189.99 231.71,188.34 231.58,188.21 216.47,188.21 216.34,188.34 216.34,189.99
VDD_CORE on TOP: 208.09,101.98 209.99,101.98 210.12,101.85 210.12,95.63 209.99,95.5 208.09,95.5 207.96,95.63 207.96,101.85
VDD_CORE on TOP: 143.95,156.21 144.08,156.08 147.17,156.08 147.64,156.55 147.64,173.73 147.51,173.86 144.08,173.86 143.95,173.73
VDD_CORE on TOP: 247.76,119.5 248.04,119.23 248.04,113.13 247.94,113.03 244.16,113.03 244.03,113.15 244.03,119.25 244.28,119.5
VDD_CORE on BOTTOM: 285.62,164.14 287.21,165.73 325.18,165.73 327.09,163.83 327.09,123.95 326.58,123.44 286.96,123.44 285.62,124.77
VDD_CORE on SIG1: 88.33,192.66 108.78,192.66 109.03,192.4 109.03,129.28 107.25,127.51 88.71,127.51 87.95,128.27 87.95,192.28
VDD_CORE on SIG2: 184.59,154.43 210.63,154.43 210.88,154.18 210.88,127.38 210.38,126.87 184.47,126.87 183.96,127.38 183.96,143 184.34,143.38 184.34,154.18
VDD_CORE on SIG3: 185.48,152.02 209.36,152.02 209.74,151.64 209.74,147.19 210.38,146.56 211.9,146.56 212.15,146.3 212.15,128.39 210.64,126.87 183.45,126.87 183.07,127.25 183.07,140.46 185.1,142.49 185.1,151.64
VDD_CORE on SIG3, SIG4, SIG5: 90.69,189.7 90.69,135.2 91.23,134.67 98.77,134.67 111.59,147.49 111.59,184.46 105.38,190.68 91.68,190.68
VDD_CORE on SIG4: 288.23,166.24 325.95,166.24 326.83,165.35 326.83,136.01 325.69,134.87 323.41,134.87 306.64,151.64 291.02,151.64 287.34,155.32 287.34,165.35
VDD_CORE on SIG4: 184.47,150.87 208.47,150.87 208.98,150.37 208.98,145.79 209.23,145.54 211.77,145.54 211.9,145.41 211.9,127.38 211.52,127 185.36,127 185.1,127.25 185.1,131.44 184.59,131.95 184.47,131.95 184.34,132.08 184.34,150.75
VDD_CORE on SIG5: 183.2,148.71 200.47,148.71 201.1,149.35 201.1,151.76 201.23,151.89 213.17,151.89 213.3,151.76 213.3,119.76 213.04,119.5 190.44,119.5 182.94,127 182.94,148.46
VDD_CORE on SIG6: 183.2,149.86 195.64,149.86 197.68,151.89 211.77,151.89 212.15,151.51 212.15,129.03 212.03,128.9 183.07,128.9 182.82,129.16 182.82,149.48
VDD_CORE on SIG6: 308.2,146.34 319.2,135.34 324.32,135.34 324.78,135.81 324.78,164.47 322.46,166.79 288.99,166.79 287.28,165.09 287.28,150.22 291.16,146.34
VDD_CORE on SIG7: 181.29,152.02 213.68,152.02 213.8,151.89 213.8,126.62 213.17,125.98 193.76,125.98 193.76,126.15 193.44,126.47 181.71,126.47 181.64,126.39 181.04,127 181.04,151.76
VDD_CORE on SIG7: 287.46,166.49 324.88,166.49 325.84,165.53 325.84,136.07 324.73,134.95 316.98,134.95 306.62,145.31 291.43,145.31 286.68,150.06 286.68,165.71
VDD_CORE on SIG10: 88.41,127.52 109.17,127.52 109.99,128.34 109.99,189.04 106.23,192.8 89.43,192.8 87.97,191.34 87.97,127.97
VDD_CORE on SIG10: 288.23,165.99 325.44,165.99 326.45,164.97 326.45,136.27 325.31,135.13 288.86,135.13 287.34,136.65 287.34,165.1
VDD_PLLA on TOP (solid shape): 294.88,215.39 294.92,215.37 294.93,215.34 294.93,214.7 295.54,214.7 295.58,214.69 295.59,214.65 295.59,213.61 295.47,213.48 293.56,213.48 293.43,213.61 293.43,214.41 293.45,214.45 293.48,214.46 294.5,214.46 294.5,215.34 294.52,215.37 294.55,215.39
VDD_PLLA on BOTTOM (solid shape): 296.32,213.39 296.33,213.28 296.35,213.19 296.35,212.6 296.23,212.47 295.59,212.47 294.96,213.1 292.42,213.1 292.29,213.23 292.29,213.99 292.42,214.12 295.59,214.12
(no net) on TOP: 407.48,137.03 406.97,136.52 397.45,136.52 396.94,137.03 396.94,150.62 397.57,151.25 397.57,155.57 397.83,155.83 406.97,155.83 407.48,155.32
(no net) on TOP: 345.98,155.11 346.1,154.99 346.99,154.99 347.37,155.37 349.15,155.37 349.28,155.24 350.42,155.24 350.55,155.37 350.55,156.64 350.78,156.87 350.78,158.29 350.65,158.42 349.28,158.42 347.6,156.74 346.05,156.74 345.98,156.66
(no net) on TOP: 395.8,128.78 373.98,128.78 373.54,128.34 373.54,120.85 373.73,120.65 375.77,120.65 376.12,121 376.12,125.6 376.62,126.11 381.9,126.11 382.47,125.54 382.47,116.83 383.48,115.82 383.48,107.95 383.73,107.69 386.78,107.69 386.78,119.38 387.79,120.39 395.67,120.39 396.3,121.03 396.3,128.27
(no net) on TOP: 70.12,141.2 69.99,141.32 69,141.32 68.62,140.94 66.33,140.94 65.85,140.46 65.85,138.15 66.1,137.89 67.6,137.89 67.73,138.02 67.73,138.81 68.49,139.57 70.04,139.57 70.12,139.65
(no net) on TOP: 379.03,210.31 378.9,210.18 372.94,210.18 372.81,210.31 372.81,212.09 372.94,212.21 376.24,212.21 376.96,212.94 378.97,212.94 379.03,212.88
(no net) on TOP: 362.78,110.87 362.78,113.54 362.65,113.66 359.73,113.66 359.6,113.54 359.6,100.07 359.85,99.82 364.55,99.82 364.81,100.07 364.81,108.84
(no net) on TOP: 296.1,206.25 299.91,206.25 300.04,206.37 300.04,212.98 299.91,213.1 296.1,213.1 295.97,212.98 295.97,206.37
(no net) on TOP: 54.42,117.98 54.42,125.35 50.48,129.28 50.48,130.68 49.85,131.31 42.48,131.31 42.11,130.95 42.11,130.69 41.72,130.3 33.59,130.3 33.34,130.05 33.34,127 45.02,127 46.04,125.98 46.04,118.11 46.67,117.47 53.91,117.47
(no net) on TOP: 72.78,141.58 72.78,145.13 72.91,145.26 79.26,145.26 79.27,145.25 84.68,145.25 85.03,144.9 85.03,141.73 84.62,141.32 73.04,141.32
(no net) on TOP: 72.78,151.74 72.78,155.29 72.91,155.42 84.44,155.42 84.83,155.03 84.83,151.94 84.38,151.48 73.04,151.48
(no net) on TOP: 70.24,153.77 70.24,157.72 70.05,157.92 70.03,157.91 69.06,157.91 68.83,157.68 68.83,155.69 69.02,155.5 69.02,153.67 69.05,153.64 70.12,153.64
(no net) on TOP: 88.81,127.1 87.74,128.17 87.74,192.02 88.78,193.07 112.47,193.07 118.19,187.35 118.2,187.35 118.2,128.59 116.71,127.1
(no net) on TOP: 24.06,124.89 23.5,124.33 15.05,124.33 14.03,123.31 5.91,123.31 5.65,123.06 5.65,120.01 17.34,120.01 18.35,119 18.35,111.12 18.99,110.49 24.45,110.49 24.96,111 29.27,111 29.4,111.12 29.4,133.6 29.1,133.91 24.44,133.91 24.06,133.53
(no net) on TOP: 54.42,116.84 54.42,109.34 53.91,108.84 35.5,108.84 34.99,109.34 34.99,116.46 35.62,117.09 54.17,117.09
(no net) on TOP: 345.85,173.02 345.85,168.56 346.01,168.4 361.63,168.4 361.89,168.65 361.89,172.08 361.63,172.34 352.11,172.34 350.3,170.53 347.83,170.53 347.08,171.29 347.08,173.05 346.98,173.15 345.98,173.15
(no net) on TOP: 377.76,213.99 378.9,213.99 379.03,213.87 379.03,213.48 378.9,213.36 376.36,213.36 376.24,213.48 376.24,214.63 376.36,214.75 377.51,214.75 377.63,214.63 377.63,214.12
(no net) on TOP: 343.31,134.41 343.31,130.86 343.18,130.73 331.1,130.73 330.9,130.93 330.9,134.41 331.15,134.67 343.06,134.67
(no net) on TOP: 351.31,135.05 351.44,134.92 353.09,134.92 353.22,135.05 353.22,136.01 354.52,137.32 354.52,138.55 354.27,138.81 353.38,138.81 352.74,139.44 352.74,142.49 352.36,142.87 351.98,142.87 351.98,141.86 351.31,141.19
(no net) on TOP: 345.98,175.43 346.1,175.31 346.99,175.31 347.37,175.69 350.09,175.69 350.55,176.15 350.55,178.47 350.28,178.74 348.49,178.74 348.37,178.61 348.37,177.82 347.6,177.06 346.05,177.06 345.98,176.98
(no net) on TOP: 345.98,134.79 346.1,134.67 346.99,134.67 347.45,135.13 350.3,135.13 350.55,135.38 350.55,137.83 350.46,137.92 349.31,137.92 347.81,136.42 346.05,136.42 345.98,136.34
(no net) on TOP: 396.94,128.78 402.27,128.78 402.65,128.39 402.65,126.24 403.03,125.85 405.96,125.85 406.46,125.35 406.46,112.9 406.21,112.65 397.45,112.65 396.68,113.41 396.68,128.52
(no net) on TOP: 72.78,182.22 72.78,185.77 72.91,185.9 84.62,185.9 84.85,185.67 84.85,182.39 84.42,181.96 73.04,181.96
(no net) on TOP: 71.69,126.59 71.68,126.6 71.45,126.6 71.31,126.74 71.31,131.06 70.93,131.44 69.02,131.44 68.9,131.57 68.9,132.97 69.02,133.09 70.5,133.09 70.55,133.14 70.55,137.92 71.39,138.76 71.39,141.45 71.26,141.58 68.97,141.58 68.85,141.7 68.85,142.97 68.97,143.1 70.52,143.1 70.58,143.16 70.58,146.74 70.88,147.04 70.88,148.82 71.01,148.94 71.01,149.32 71.37,149.69 71.37,151.63 71.26,151.74 68.97,151.74 68.85,151.86 68.85,153.11 69,153.26 70.37,153.26 70.57,153.46 70.57,156.89 70.88,157.2 70.88,159.2 71.31,159.64 71.31,161.67 71.06,161.92 69.02,161.92 68.9,162.05 68.9,163.32 69.02,163.45 70.42,163.45 70.55,163.57 70.55,169.19 71.39,170.03 71.39,171.93 71.26,172.06 69.15,172.06 69.02,172.18 69.02,173.45 69.15,173.58 70.52,173.58 70.56,173.62 70.56,179.22 71.39,180.05 71.39,182.09 71.26,182.22 69.05,182.22 69.02,182.24 69.02,183.61 69.15,183.74 70.37,183.74 70.56,183.93 70.56,186.45 70.9,186.79 70.9,189.89 71.56,190.55 71.56,192.02 73.09,193.55 86.3,193.55 86.94,192.91 86.94,127.61 85.91,126.59
(no net) on TOP: 70.12,181.84 69.99,181.96 69.1,181.96 68.72,181.58 65.63,181.58 65.11,181.06 65.11,178.87 65.44,178.53 67.16,178.53 67.73,179.1 67.73,179.45 68.49,180.21 70.04,180.21 70.12,180.29
(no net) on TOP: 381.43,125.43 377.25,125.43 376.78,124.96 376.78,120.55 376.25,120.01 374.59,120.01 374.32,119.75 374.32,112.88 374.55,112.65 380.93,112.65 381.7,111.87 383.1,111.87 383.2,111.97 383.2,112.05 383.1,112.15 382.38,112.15 382.3,112.22 382.3,112.32 382.37,112.39 383.2,112.39 383.2,112.39 383.2,112.64 382.41,112.64 382.34,112.71 382.34,112.83 382.4,112.88 383.2,112.88 383.2,113.14 382.4,113.14 382.35,113.19 382.35,113.32 382.41,113.38 383.2,113.38 383.2,113.39 383.2,113.64 382.42,113.64 382.36,113.71 382.36,113.81 382.42,113.87 383.2,113.87 383.2,113.88 383.2,114.14 382.38,114.14 382.34,114.18 382.34,114.33 382.39,114.37 383.19,114.37 383.2,114.38 383.2,114.57 382.46,115.31 382.05,115.31 381.88,115.48 381.88,124.98
(no net) on TOP: 343.31,164.89 343.31,161.34 343.18,161.21 331.1,161.21 330.9,161.41 330.9,165.02 331.03,165.15 343.06,165.15
(no net) on TOP: 43.98,137.43 43.98,138.98 43.51,139.45 38.52,139.45 38.08,139.02 38.08,136.53 38.3,136.31 38.3,132.69 37.86,132.26 37.67,132.26 37.52,132.11 37.52,130.67 37.62,130.57 37.69,130.57 37.79,130.67 37.79,131.4 37.87,131.48 37.96,131.48 38.03,131.41 38.03,130.58 38.03,130.57 38.28,130.57 38.28,131.36 38.36,131.43 38.47,131.43 38.53,131.38 38.53,130.57 38.79,130.57 38.79,131.37 38.84,131.42 38.96,131.42 39.03,131.36 39.03,130.58 39.03,130.57 39.29,130.57 39.29,131.35 39.35,131.42 39.46,131.42 39.52,131.36 39.52,130.58 39.52,130.57 39.79,130.57 39.79,131.4 39.82,131.44 39.97,131.44 40.02,131.39 40.02,130.58 40.03,130.57 40.15,130.57 40.15,130.64 41.42,131.9 49.47,131.9 49.85,132.28 49.85,136.23 49.21,136.87 44.55,136.87
(no net) on TOP: 288.99,203.96 289.24,204.21 289.24,215.14 289.12,215.26 284.54,215.26 284.42,215.14 284.42,204.21 284.67,203.96
(no net) on TOP: 383.48,199.39 385.64,199.39 385.76,199.51 385.76,202.44 385.51,202.69 382.08,202.69 380.94,201.55 378.02,201.55 377.89,201.42 377.89,198.24 378.02,198.12 381.19,198.12 381.32,198.24 381.32,199.9 381.57,200.15 383.22,200.15 383.35,200.02 383.35,199.51
(no net) on TOP: 26.73,103.5 26.73,102.49 26.23,101.98 7.81,101.98 7.3,102.49 7.3,109.47 7.94,110.11 24.83,110.11 25.34,109.6 29.02,109.6 29.27,109.34 29.27,105.53 27.62,103.88 27.11,103.88
(no net) on TOP: 70.12,171.68 69.99,171.8 69.1,171.8 68.72,171.42 66.94,171.42 66.81,171.55 65.67,171.55 65.54,171.42 65.54,169.39 65.67,169.26 67.48,169.26 68.14,169.92 70.04,169.92 70.12,170
(no net) on TOP: 372.43,216.91 375.09,216.91 375.22,217.04 375.22,219.96 375.09,220.09 365.44,220.09 365.06,219.71 365.06,215.26 365.25,215.07 370.59,215.07
(no net) on TOP: 345.85,162.86 345.85,159 345.98,158.87 347.63,158.87 347.76,159 347.76,160.45 347.13,161.08 347.13,162.93 347.06,162.99 345.98,162.99
(no net) on TOP: 381.69,149.43 377.51,149.43 377.04,148.96 377.04,144.55 376.5,144.02 374.84,144.02 374.58,143.75 374.58,136.88 374.81,136.65 381.06,136.65 381.84,135.88 383.36,135.88 383.46,135.98 383.46,136.05 383.36,136.15 382.63,136.15 382.55,136.23 382.55,136.32 382.62,136.39 383.45,136.39 383.46,136.39 383.46,136.64 382.67,136.64 382.6,136.71 382.6,136.83 382.65,136.89 383.46,136.89 383.46,137.15 382.66,137.15 382.61,137.2 382.61,137.32 382.67,137.38 383.45,137.38 383.46,137.39 383.46,137.64 382.68,137.64 382.61,137.71 382.61,137.81 382.67,137.88 383.45,137.88 383.46,137.88 383.46,138.14 382.63,138.14 382.59,138.18 382.59,138.33 382.64,138.38 383.45,138.38 383.46,138.39 383.46,138.57 382.71,139.31 382.71,139.31 382.21,139.81 382.21,148.91
(no net) on TOP: 72.78,131.42 72.78,134.97 72.91,135.1 79.26,135.1 79.27,135.09 84.68,135.09 85.03,134.74 85.03,131.44 84.75,131.16 73.04,131.16
(no net) on TOP: 383.22,199.13 384.37,199.13 384.49,199.01 384.49,198.63 384.37,198.5 381.83,198.5 381.7,198.63 381.7,199.77 381.83,199.9 382.97,199.9 383.1,199.77 383.1,199.26
(no net) on TOP: 343.31,154.73 343.31,151.18 343.18,151.05 331.15,151.05 330.9,151.3 330.9,154.86 331.03,154.99 343.06,154.99
(no net) on TOP: 345.85,152.7 345.85,148.87 346.01,148.71 347.53,148.71 348.04,149.22 354.14,149.22 355.79,147.57 361.76,147.57 362.01,147.83 362.01,151.25 361.76,151.51 351.73,151.51 350.2,149.98 348.06,149.98 347.09,150.95 347.09,152.71 346.98,152.83 345.98,152.83
(no net) on TOP: 369.38,105.53 369.38,109.6 369.25,109.73 366.84,109.73 366.71,109.6 366.71,105.53 366.84,105.41 369.25,105.41
(no net) on TOP: 302.2,204.47 301.94,204.21 294.32,204.21 293.94,204.59 293.94,212.72 293.05,213.61 293.05,215.77 294.83,217.55 297.62,217.55 297.88,217.29 297.88,216.28 298.13,216.02 299.91,216.02 300.29,216.41 300.29,218.18 299.91,218.56 292.67,218.56 290.64,216.53 290.64,214.25 291.53,213.36 291.53,202.69 294.96,199.26 298.51,199.26 298.77,199.51 298.77,201.67 299.02,201.93 303.72,201.93 307.78,205.99 307.78,217.68 307.15,218.31 302.7,218.31 302.2,217.8
(no net) on TOP: 384.49,195.7 384.24,195.45 378.4,195.45 378.27,195.58 378.27,197.23 378.4,197.36 381.7,197.36 382.42,198.08 384.41,198.08 384.49,198
(no net) on TOP: 345.98,166.29 345.98,165.27 346.1,165.15 347.07,165.15 347.45,165.53 349.15,165.53 349.28,165.4 350.42,165.4 350.55,165.53 350.55,167.56 350.42,167.69 349.03,167.69 348.77,167.43 348.77,166.92 348.39,166.54 346.23,166.54
(no net) on TOP: 351.06,145.41 351.18,145.29 352.11,145.29 354.01,143.38 356.55,143.38 358.58,141.35 358.58,136.78 356.55,134.74 354.01,134.74 353.5,134.24 351.98,134.24 351.35,133.6 351.35,133.09 351.47,132.97 357.19,132.97 360.24,136.01 360.24,142.11 354.5,147.85 351.26,147.85 351.06,147.65
(no net) on TOP: 345.85,132.38 345.85,129.28 346.27,128.87 346.27,127.38 346.65,127 354.65,127 355.28,127.63 355.28,130.93 354.75,131.47 351.01,131.47 350.88,131.34 350.88,130.07 350.6,129.79 347.93,129.79 347.25,130.48 347.25,132.38 347.12,132.51 345.98,132.51
(no net) on TOP: 343.31,144.57 343.31,141.02 343.18,140.89 331.15,140.89 330.9,141.14 330.9,144.7 331.03,144.83 343.06,144.83
(no net) on TOP: 365.7,116.2 365.7,117.35 365.82,117.47 366.2,117.47 366.33,117.35 366.33,114.81 366.2,114.68 365.06,114.68 364.93,114.81 364.93,115.95 365.06,116.08 365.57,116.08
(no net) on TOP: 345.98,144.95 346.1,144.83 346.99,144.83 347.37,145.21 349.15,145.21 349.28,145.08 350.42,145.08 350.55,145.21 350.55,147.24 350.42,147.37 348.62,147.37 347.96,146.71 346.05,146.71 345.98,146.63
(no net) on TOP: 70.12,131.04 69.99,131.16 69.1,131.16 68.72,130.78 67.5,130.78 67.25,130.53 67.25,128.92 67.5,128.66 68.76,128.66 68.77,128.65 69.91,128.65 70.12,128.85
(no net) on TOP: 351.31,155.37 351.44,155.24 353.09,155.24 353.22,155.37 353.22,156.3 354.01,157.1 354.01,158.24 354.52,158.75 354.52,159.26 354.39,159.38 353.89,159.38 352.62,160.65 352.62,162.94 352.49,163.07 352.11,163.07 352.11,162.43 351.31,161.63
(no net) on TOP: 70.24,184.25 70.24,189.75 70.68,190.18 70.68,195.25 71.18,195.76 71.18,202.69 70.8,203.07 61.02,203.07 60.52,202.56 60.52,201.17 58.61,199.26 50.48,199.26 46.75,195.53 46.75,187.63 47.71,186.67 65.21,186.67 65.63,187.08 67.92,187.08 69.02,185.98 69.02,184.27 69.18,184.12 70.12,184.12
(no net) on TOP: 345.85,183.18 345.85,178.96 345.98,178.84 347.63,178.84 347.76,178.96 347.76,180.75 347.09,181.42 347.09,183.2 346.98,183.31 345.98,183.31
(no net) on TOP: 70.24,178.18 69.99,178.43 68.47,178.43 68.34,178.31 68.34,176.5 68.93,175.91 68.93,174.1 69.06,173.97 70.14,173.97 70.24,174.08
(no net) on TOP: 70.12,161.52 69.99,161.64 69.1,161.64 68.72,161.26 66.94,161.26 66.81,161.39 65.67,161.39 65.54,161.26 65.54,159.99 65.32,159.76 65.32,158.34 65.44,158.21 66.81,158.21 68.49,159.89 70.04,159.89 70.12,159.97
(no net) on TOP: 365.44,116.46 365.44,118.62 365.32,118.74 362.39,118.74 362.14,118.49 362.14,115.06 363.28,113.92 363.28,111 363.41,110.87 366.59,110.87 366.71,111 366.71,114.17 366.59,114.3 364.93,114.3 364.68,114.55 364.68,116.2 364.81,116.33 365.32,116.33
(no net) on TOP: 387.92,119.89 395.54,119.89 396.3,119.12 396.3,111.5 395.92,111.12 389.83,111.12 389.06,111.88 387.15,111.88 387.07,111.96 387.07,112.07 387.14,112.14 387.17,112.14 387.8,112.14 387.9,112.24 387.9,112.3 387.82,112.38 387.15,112.38 387.08,112.46 387.08,112.57 387.15,112.64 387.84,112.64 387.9,112.71 387.9,112.81 387.83,112.88 387.15,112.88 387.07,112.96 387.07,113.08 387.14,113.14 387.85,113.14 387.9,113.2 387.9,113.32 387.84,113.39 387.14,113.39 387.08,113.45 387.08,113.58 387.14,113.64 387.81,113.64 387.9,113.73 387.9,113.79 387.81,113.88 387.15,113.88 387.08,113.96 387.08,114.07 387.15,114.14 387.86,114.14 387.9,114.19 387.9,114.33 387.85,114.39 387.14,114.39 387.03,114.49 387.03,119
(no net) on TOP: 367.09,210.31 371.16,210.31 371.28,210.44 371.28,212.85 371.16,212.98 367.09,212.98 366.97,212.85 366.97,210.44
(no net) on TOP: 378.65,201.04 381.32,201.04 381.44,201.17 381.44,205.86 380.56,206.75 376.87,206.75 376.11,205.99 368.11,205.99 367.6,205.48 367.6,199.26 367.86,199.01 376.62,199.01
(no net) on TOP: 72.78,172.06 72.78,175.61 72.91,175.74 84.55,175.74 84.88,175.41 84.88,172.2 84.49,171.8 73.04,171.8
(no net) on TOP: 351.31,175.89 351.64,175.56 353.09,175.56 353.22,175.69 353.22,177.29 354.39,178.47 354.39,179.32 352.87,180.85 352.87,183 352.49,183.39 352.23,183.39 352.23,182.75 351.31,181.83
(no net) on TOP: 72.78,161.9 72.78,165.45 72.91,165.58 84.43,165.58 84.83,165.18 84.83,162.28 84.2,161.64 73.04,161.64
(no net) on TOP: 390.33,152.78 374.23,152.78 373.79,152.34 373.79,144.85 373.99,144.66 376.02,144.66 376.37,145.01 376.37,149.6 376.88,150.11 382.16,150.11 382.84,149.42 382.84,140.71 383.07,140.49 383.34,140.49 383.73,140.1 383.73,131.95 383.98,131.7 387.03,131.7 387.03,143.38 388.05,144.4 395.92,144.4 396.56,145.03 396.56,155.45 396.18,155.83 391.48,155.83 390.84,155.19 390.84,153.29
(no net) on TOP: 345.85,142.54 345.85,138.45 346.1,138.2 347.63,138.2 347.76,138.32 347.76,140.13 347.13,140.75 347.13,142.6 347.06,142.67 345.98,142.67
(no net) on TOP: 45.53,125.85 45.53,118.23 44.77,117.47 37.15,117.47 36.77,117.85 36.77,123.95 37.53,124.71 37.53,126.63 37.6,126.7 37.71,126.7 37.78,126.63 37.78,126.6 37.78,125.97 37.88,125.87 37.94,125.87 38.03,125.96 38.03,126.63 38.1,126.7 38.21,126.7 38.28,126.63 38.28,125.94 38.35,125.87 38.46,125.87 38.53,125.94 38.53,126.62 38.61,126.7 38.72,126.7 38.78,126.64 38.78,125.93 38.84,125.87 38.97,125.87 39.03,125.94 39.03,126.64 39.09,126.7 39.22,126.7 39.28,126.64 39.28,125.97 39.38,125.87 39.43,125.87 39.53,125.97 39.53,126.63 39.6,126.7 39.72,126.7 39.78,126.63 39.78,125.92 39.83,125.87 39.98,125.87 40.03,125.93 40.03,126.64 40.14,126.74 44.64,126.74
(no net) on TOP: 17.84,118.87 17.84,111.25 17.08,110.49 9.46,110.49 9.08,110.87 9.08,116.96 9.84,117.73 9.84,119.64 9.92,119.72 10.03,119.72 10.1,119.65 10.1,118.99 10.2,118.89 10.26,118.89 10.34,118.97 10.34,119.64 10.41,119.71 10.53,119.71 10.6,119.64 10.6,118.95 10.66,118.89 10.77,118.89 10.84,118.96 10.84,119.64 10.92,119.72 11.04,119.72 11.1,119.65 11.1,118.95 11.16,118.89 11.28,118.89 11.34,118.95 11.34,119.65 11.41,119.71 11.54,119.71 11.6,119.65 11.6,118.98 11.69,118.89 11.75,118.89 11.84,118.98 11.84,119.64 11.91,119.71 12.03,119.71 12.1,119.65 12.1,118.93 12.14,118.89 12.29,118.89 12.34,118.94 12.34,119.65 12.45,119.76 16.95,119.76
(no net) on TOP: 366.97,117.47 369.38,117.47 369.51,117.35 369.51,111.38 369.38,111.25 367.6,111.25 367.47,111.38 367.47,114.68 366.84,115.31 366.84,117.35
(no net) on TOP: 70.24,143.61 70.24,147.7 70.12,147.83 68.39,147.83 68.12,148.1 63.22,148.1 59.72,151.6 55.89,151.6 55.21,150.93 55.21,147.64 56.55,146.3 68.06,146.3 68.85,145.51 68.85,143.61 68.97,143.48 70.12,143.48
(no net) on TOP: 275.15,200.15 272.86,202.44 272.86,210.06 272.99,210.18 276.16,210.18 277.56,211.58 278.65,211.58 278.75,211.48 278.75,205.69 281.31,203.13 287.15,203.13 292.29,197.99 292.29,197.43 294.2,197.43 295.21,198.45 300.98,198.45 301.82,197.61 301.82,195.32 301.53,195.04 290.86,195.04 285.75,200.15
(no net) on TOP: 372.55,195.45 376.62,195.45 376.75,195.58 376.75,197.99 376.62,198.12 372.55,198.12 372.43,197.99 372.43,195.58
(no net) on TOP: 70.24,163.93 70.24,167.76 69.79,168.22 63.37,168.22 59.63,171.96 55.8,171.96 55.16,171.32 55.16,166.75 56.2,165.71 64.56,165.71 65.47,166.62 68.06,166.62 69.02,165.66 69.02,163.86 69.08,163.8 70.12,163.8
(no net) on TOP: 345.98,185.59 346.1,185.47 346.99,185.47 347.45,185.93 350.42,185.93 350.55,186.05 350.55,187.88 350.48,187.95 346.15,187.95 345.98,187.78
(no net) on TOP: 293.56,213.48 295.47,213.48 295.59,213.61 295.59,215.26 295.47,215.39 293.56,215.39 293.43,215.26 293.43,213.61
(no net) on TOP: 388.18,143.89 395.8,143.89 396.56,143.13 396.56,135.51 396.18,135.13 390.08,135.13 389.32,135.89 387.4,135.89 387.33,135.96 387.33,136.07 387.4,136.14 387.43,136.14 388.06,136.14 388.16,136.24 388.16,136.3 388.07,136.39 387.4,136.39 387.33,136.46 387.33,136.57 387.4,136.64 388.09,136.64 388.16,136.71 388.16,136.81 388.09,136.89 387.41,136.89 387.33,136.96 387.33,137.08 387.39,137.14 388.1,137.14 388.16,137.2 388.16,137.33 388.09,137.39 387.39,137.39 387.33,137.45 387.33,137.58 387.39,137.64 388.06,137.64 388.16,137.74 388.16,137.79 388.06,137.89 387.4,137.89 387.33,137.96 387.33,138.08 387.4,138.14 388.11,138.14 388.16,138.19 388.16,138.34 388.1,138.39 387.39,138.39 387.29,138.5 387.29,143
(no net) on TOP: 70.12,150.34 70.12,151.36 69.99,151.48 69.02,151.48 68.64,151.1 66.94,151.1 66.81,151.23 65.67,151.23 65.54,151.1 65.54,149.07 65.67,148.94 67.07,148.94 67.32,149.2 67.32,149.71 67.7,150.09 69.86,150.09
(no net) on TOP: 378.02,214.25 380.17,214.25 380.3,214.37 380.3,217.29 380.05,217.55 376.62,217.55 375.48,216.41 372.55,216.41 372.43,216.28 372.43,213.1 372.55,212.98 375.73,212.98 375.86,213.1 375.86,214.75 376.11,215.01 377.76,215.01 377.89,214.88 377.89,214.37
(no net) on TOP: 344.64,190.03 344.74,189.93 344.74,185.61 345.16,185.19 347.07,185.19 347.2,185.06 347.2,183.66 347.07,183.54 345.6,183.54 345.55,183.49 345.55,178.94 344.71,178.1 344.71,175.18 344.83,175.05 347.12,175.05 347.25,174.93 347.25,173.66 347.12,173.53 345.57,173.53 345.47,173.43 345.47,169.85 345.22,169.59 345.22,167.81 345.09,167.69 345.09,167.31 344.71,166.92 344.71,165.02 344.83,164.89 347.12,164.89 347.25,164.77 347.25,163.52 347.1,163.37 345.72,163.37 345.47,163.11 345.47,159.69 345.22,159.43 345.22,157.43 344.78,156.99 344.78,154.96 345.04,154.71 347.07,154.71 347.2,154.58 347.2,153.31 347.07,153.18 345.67,153.18 345.55,153.06 345.55,147.44 344.71,146.6 344.71,144.7 344.83,144.57 347.12,144.57 347.25,144.45 347.25,143.18 347.12,143.05 345.64,143.05 345.51,142.92 345.51,137.39 344.71,136.58 344.71,134.54 344.83,134.41 347.12,134.41 347.25,134.29 347.25,133.04 347.1,132.89 345.72,132.89 345.47,132.63 345.47,118.22 341.82,114.58 328.59,114.58 327.72,115.44 327.72,190.78 327.77,190.83 327.77,200.45 328.49,201.17 343.09,201.17 344.64,199.61 ; 2 cut-outs
(no net) on TOP: 343.31,175.05 343.31,171.5 343.18,171.37 331.1,171.37 330.9,171.57 330.9,175.05 331.15,175.31 343.06,175.31
(no net) on BOTTOM: 65.6,178.94 65.6,181.86 65.72,181.99 66.65,181.99 67.2,181.44 67.68,181.44 67.88,181.24 67.88,179.07 67.63,178.81 65.72,178.81
(no net) on BOTTOM: 65.47,158.75 65.47,161.67 65.6,161.8 66.74,161.8 66.87,161.67 66.87,158.62 66.61,158.37 65.85,158.37
(no net) on BOTTOM: 54.42,116.84 54.42,110.87 52.64,109.09 36.26,109.09 34.73,110.61 32.58,110.61 32.32,110.87 32.32,112.77 32.58,113.03 34.61,113.03 34.99,113.41 34.99,116.46 35.62,117.09 54.17,117.09
(no net) on BOTTOM: 350.5,137.69 350.5,134.77 350.37,134.64 349.09,134.64 348.21,135.52 348.21,137.56 348.47,137.82 350.37,137.82
(no net) on BOTTOM: 350.63,167.41 350.63,165.38 350.5,165.25 349.26,165.25 348.72,165.79 348.72,167.28 348.97,167.53 350.5,167.53
(no net) on BOTTOM: 51.07,132.34 51.07,136.27 50.01,137.33 46.51,137.33 44.39,139.45 38.52,139.45 38.08,139.02 38.08,133.18 39.35,131.92 50.65,131.92
(no net) on BOTTOM: 371.41,216.66 375.09,216.66 375.22,216.53 375.22,213.23 374.97,212.98 371.41,212.98 371.16,213.23 371.16,216.41
(no net) on BOTTOM: 26.73,109.85 26.73,106.04 26.23,105.53 23.43,105.53 23.18,105.28 23.18,102.23 22.92,101.98 7.81,101.98 7.3,102.49 7.3,103.38 7.05,103.63 4.89,103.63 4.64,103.88 4.64,105.79 4.89,106.04 6.92,106.04 7.3,106.42 7.3,109.47 7.94,110.11 26.48,110.11
(no net) on BOTTOM: 88.27,127.45 87.74,127.99 87.74,193.11 88.04,193.42 96.96,193.42 96.97,193.42 102.48,193.42 102.49,193.4 107.98,193.4 108.78,192.61 108.78,129.97 106.26,127.45
(no net) on BOTTOM: 350.5,178.33 350.5,175.54 350.37,175.41 348.98,175.41 348.21,176.18 348.21,177.32 349.35,178.46 350.37,178.46
(no net) on BOTTOM: outline of 83 points within 46.29,133.35 71.69,202.18
(no net) on BOTTOM: 23.39,125.36 23.39,131.74 22.91,132.22 10.59,132.22 10.4,132.03 10.4,126.2 9.83,125.63 9.83,124.02 10,123.85 12.79,123.85 13.85,124.92 22.94,124.92
(no net) on BOTTOM: 380.68,198.37 380.43,198.12 376.87,198.12 376.62,198.37 376.62,202.05 376.75,202.18 380.56,202.18 380.68,202.05
(no net) on BOTTOM: 64.82,186.45 64.71,186.56 63.44,186.56 61.15,184.27 61.15,183.64 60.64,183.13 53.78,183.13 53.53,182.88 53.53,178.81 53.78,178.56 58.1,178.56 58.61,179.07 60.9,179.07 61.15,178.81 61.15,128.14 61.4,127.89 64.71,127.89 64.82,128
(no net) on BOTTOM: 294.96,213.1 295.59,212.47 296.23,212.47 296.35,212.6 296.35,213.36 295.59,214.12 292.42,214.12 292.29,213.99 292.29,213.23 292.42,213.1
(no net) on BOTTOM: 71.69,126.59 71.68,126.6 71.45,126.6 71.31,126.74 71.31,129.66 69.53,131.44 69.02,131.44 68.9,131.57 68.9,132.97 69.02,133.09 70.5,133.09 70.8,133.4 70.8,141.32 70.55,141.58 69.29,141.58 69.1,141.77 69.1,143 69.21,143.1 70.52,143.1 70.62,143.2 70.62,146.78 70.88,147.04 70.88,151.38 70.52,151.74 69.35,151.74 69.09,152 69.09,153.14 69.21,153.26 70.37,153.26 70.62,153.52 70.62,156.94 70.88,157.2 70.88,159.36 70.92,159.4 70.92,161.55 70.42,162.05 69.28,162.05 69.09,162.24 69.09,163.31 69.23,163.45 70.42,163.45 70.68,163.7 70.68,166.27 70.8,166.39 70.8,171.83 70.55,172.08 69.41,172.08 69.11,172.39 69.11,173.46 69.23,173.58 70.52,173.58 70.71,173.77 70.71,177.35 70.88,177.52 70.88,182.17 70.68,182.37 69.24,182.37 69.09,182.52 69.09,183.62 69.22,183.74 70.37,183.74 70.62,184 70.62,184.02 70.84,184.24 70.84,185.96 72.45,187.58 72.45,194.18 72.68,194.41 86.5,194.41 86.94,193.97 86.94,127.61 85.91,126.59
(no net) on BOTTOM: 371.28,217.29 375.09,217.29 375.22,217.42 375.22,219.83 375.09,219.96 371.28,219.96 371.16,219.83 371.16,217.42
(no net) on BOTTOM: 357.48,160.8 357.48,156.99 357.74,156.74 361.93,156.74 362.06,156.87 362.06,160.55 361.67,160.93 357.61,160.93
(no net) on BOTTOM: 56.71,138.17 56.71,141.86 56.52,142.05 53.98,142.05 53.53,141.6 53.53,138.3 53.78,138.05 56.58,138.05
(no net) on BOTTOM: 372.81,212.21 376.24,212.21 376.36,212.09 376.36,210.44 376.24,210.31 372.81,210.31 372.68,210.44 372.68,212.09
(no net) on BOTTOM: 347.07,185.19 347.2,185.06 347.2,183.66 347.07,183.54 345.6,183.54 345.29,183.23 345.29,175.31 345.65,174.95 346.81,174.95 346.98,174.78 346.98,173.65 346.85,173.53 345.57,173.53 345.47,173.43 345.47,169.85 345.22,169.59 345.22,165.25 345.57,164.89 346.7,164.89 346.98,164.61 346.98,163.51 346.84,163.37 345.72,163.37 345.47,163.11 345.47,159.69 345.22,159.43 345.22,157.27 345.18,157.23 345.18,154.86 345.46,154.58 346.83,154.58 346.98,154.42 346.98,153.34 346.83,153.18 345.67,153.18 345.36,152.87 345.36,149.7 345.27,149.61 345.27,144.74 345.61,144.4 346.88,144.4 346.98,144.3 346.98,143.19 346.85,143.05 345.57,143.05 345.4,142.88 345.39,142.87 345.39,139.27 345.22,139.1 345.22,134.59 345.53,134.27 346.87,134.27 346.97,134.17 346.97,133.02 346.86,132.9 345.64,132.9 345.48,132.74 345.48,130.73 343.53,128.78 343.53,123.95 343.33,123.76 328.04,123.76 327.72,124.08 327.72,195.7 328.87,196.85 328.87,199.77 329.25,200.15 333.18,200.15 338.65,194.69 345.76,194.69 347.07,193.38
(no net) on BOTTOM: 378.27,197.36 381.7,197.36 381.83,197.23 381.83,195.58 381.7,195.45 378.27,195.45 378.14,195.58 378.14,197.23
(no net) on BOTTOM: 65.47,128.78 65.47,130.81 65.6,130.93 68.9,130.93 69.41,130.43 69.41,128.65 69.28,128.52 65.72,128.52
(no net) on BOTTOM: 350.63,146.96 350.63,144.93 350.5,144.8 348.72,144.8 348.59,144.93 348.59,147.09 348.72,147.21 350.37,147.21
(no net) on BOTTOM: 65.47,149.22 65.47,151.25 65.6,151.38 67.25,151.38 67.37,151.25 67.37,149.35 67.12,149.1 65.6,149.1
(no net) on BOTTOM: 350.63,157.88 350.63,154.96 350.5,154.83 349,154.83 348.09,155.75 348.09,157.5 348.85,158.26 350.24,158.26
(no net) on BOTTOM: 376.87,203.07 380.68,203.07 380.81,203.2 380.81,206.12 380.56,206.37 377,206.37 376.75,206.12 376.75,203.2
(no net) on BOTTOM: 357.48,181 357.48,177.31 357.67,177.12 360.21,177.12 360.66,177.57 360.66,180.87 360.4,181.12 357.61,181.12
(no net) on BOTTOM: 362.39,109.73 362.39,113.54 362.27,113.66 359.85,113.66 359.73,113.54 359.73,109.73 359.85,109.6 362.27,109.6
(no net) on BOTTOM: 65.6,138.3 65.6,141.09 65.72,141.22 67.33,141.22 67.88,140.67 67.88,138.94 67.12,138.17 65.72,138.17
(no net) on BOTTOM: 367.47,111.25 367.47,114.68 367.6,114.81 369.25,114.81 369.38,114.68 369.38,111.25 369.25,111.12 367.6,111.12
(no net) on BOTTOM: 363.03,109.85 363.03,113.54 363.16,113.66 366.46,113.66 366.71,113.41 366.71,109.85 366.46,109.6 363.28,109.6
(no net) on POWER1: 159.02,93.72 153.82,98.93 130.58,98.93 127.53,101.98 106.95,101.98 98.7,110.23 71.9,110.23 64.71,117.43 64.71,185.46 75.12,195.88 75.12,195.89 79.79,200.56 103.25,200.56 114.09,211.4 114.09,222.84 115.23,223.98 329.08,223.98 330.01,223.05 330.01,111.46 329.29,110.74 264.78,110.74 252.2,98.17 239.5,98.17 237.72,96.39 197.21,96.39 194.54,93.72 ; 1 cut-out
(no net) on SIG1: 329.37,193.8 328.49,194.69 305.5,194.69 304.61,195.58 304.61,203.71 303.59,204.72 234.88,204.72 234.88,204.76 136.56,204.76 115.09,183.29 115.09,122.22 121.11,116.2 153.73,116.2 160.21,122.68 195.64,122.68 197.8,120.52 197.8,106.68 198.82,105.66 320.23,105.66 329.37,114.81 ; 36 cut-outs
(no net) on SIG2: 142.56,194.43 136.33,188.21 117.03,188.21 115.13,190.12 113.6,190.12 112.01,188.53 108.84,188.53 105.35,192.02 91.25,192.02 90.23,191.01 90.23,138.81 82.36,130.93 65.34,130.93 60.64,126.24 52.01,126.24 42.99,135.25 42.99,212.85 44.13,213.99 64.96,213.99 65.03,214.06 72.39,214.06 78.3,208.15 110.17,208.15 125.16,223.14 378.9,223.14 383.98,218.06 383.98,124.84 383.1,123.95 344.74,123.95 342.33,126.36 342.33,130.17 328.36,130.17 324.55,133.98 324.55,164.46 323.28,165.73 275.02,165.73 246.32,194.43 ; 1 cut-out
(no net) on SIG4: 368.87,108.07 368.87,116.33 368.74,116.46 363.54,116.46 363.28,116.2 363.28,108.07 363.41,107.95 368.74,107.95
(no net) on SIG4: 369.76,209.42 378.02,209.42 378.14,209.55 378.14,214.75 377.89,215.01 369.76,215.01 369.63,214.88 369.63,209.55
(no net) on POWER2: 115.21,223.98 354.1,223.98 355.03,223.05 355.03,107.14 352.15,104.26 155.84,104.26 155.38,104.61 154.93,104.26 66.44,104.26 60.44,110.27 60.4,199.26 66.62,205.48 108.14,205.48 114.11,211.45 114.11,222.88 ; 1 cut-out
ANLGOUT on TOP: 209.49,199.01 209.49,197.36 209.36,197.23 207.58,197.23 207.45,197.36 207.45,199.01 207.58,199.13 209.36,199.13
ANLGOUT on TOP: 218,199.01 218,197.36 217.87,197.23 216.09,197.23 215.96,197.36 215.96,199.01 216.09,199.13 217.87,199.13
ANLGOUT on TOP: 189.17,99.69 189.29,99.82 191.07,99.82 191.2,99.69 191.2,98.17 191.07,98.04 189.29,98.04 189.17,98.17
ANLGOUT on TOP: 327.34,200.15 327.34,167 326.58,166.24 286.45,166.24 285.18,164.97 285.18,158.24 284.42,157.48 272.61,157.48 272.22,157.86 272.22,181.73 273.49,183 286.96,183 297.5,193.55 320.87,193.55 322.26,194.94 322.26,200.02 322.64,200.4 327.09,200.4
ANLGOUT on TOP: 239.59,156.84 240.09,156.33 240.09,154.81 239.97,154.68 236.66,154.68 236.54,154.81 236.54,156.72 236.66,156.84
ANLGOUT on TOP: 237.17,128.78 237.05,128.9 237.05,131.32 237.17,131.44 241.11,131.44 241.24,131.32 241.24,128.9 241.11,128.78
ANLGOUT on TOP: 222.82,199.01 222.82,197.36 222.69,197.23 220.92,197.23 220.79,197.36 220.79,199.01 220.92,199.13 222.69,199.13
ANLGOUT on TOP: 221.04,101.98 221.17,102.11 222.95,102.11 223.08,101.98 223.08,100.45 222.95,100.33 221.17,100.33 221.04,100.45
ANLGOUT on TOP: 157.92,162.81 154.24,162.81 153.86,163.19 153.86,164.84 153.99,164.97 157.92,164.97 158.05,164.84 158.05,162.94
ANLGOUT on TOP: 221.04,97.41 221.17,97.53 222.95,97.53 223.08,97.41 223.08,95.88 222.95,95.76 221.17,95.76 221.04,95.88
ANLGOUT on TOP: 160.46,187.7 160.59,187.83 163,187.83 163.13,187.7 163.13,185.8 163,185.67 160.59,185.67 160.46,185.8
ANLGOUT on TOP: 169.86,179.45 169.74,179.58 167.96,179.58 167.76,179.77 167.76,181.62 167.45,181.93 167.45,183.13 167.83,183.51 170.88,183.51 171.01,183.39 171.01,183.26 171.64,182.62 176.97,182.62 178.24,181.35 178.24,179.58 178.12,179.45
ANLGOUT on TOP: 201.99,99.69 202.12,99.82 203.9,99.82 204.03,99.69 204.03,98.17 203.9,98.04 202.12,98.04 201.99,98.17
ANLGOUT on TOP: 186.12,199.13 186.25,199.26 188.55,199.26 188.72,199.09 188.72,196.8 188.52,196.6 186.64,196.6 186.12,197.11
ANLGOUT on TOP: 158.05,151.38 158.05,149.86 157.8,149.6 148,149.6 145.37,152.23 145.37,153.55 145.98,154.16 145.99,154.16 146.51,154.68 149.23,154.68 150.43,153.48 153.07,153.48 154.98,151.57 157.86,151.57
ANLGOUT on TOP: 215.58,199.01 215.58,197.36 215.46,197.23 213.68,197.23 213.55,197.36 213.55,199.01 213.68,199.13 215.46,199.13
ANLGOUT on TOP: 241.74,144.52 242,144.27 242,142.62 241.87,142.49 238.19,142.49 238.06,142.62 238.06,144.4 238.19,144.52
ANLGOUT on TOP: 211.9,199.01 211.9,197.36 211.77,197.23 209.99,197.23 209.87,197.36 209.87,199.01 209.99,199.13 211.77,199.13
ANLGOUT on TOP: 240.86,167 237.17,167 237.05,167.13 237.05,168.91 237.17,169.03 240.35,169.03 240.98,168.4 240.98,167.13
ANLGOUT on TOP: 166.56,187.7 166.69,187.83 169.1,187.83 169.23,187.7 169.23,185.93 168.97,185.67 167.07,185.67 166.94,185.8 166.94,186.43 166.56,186.81
ANLGOUT on TOP: 174.18,99.69 174.31,99.82 176.09,99.82 176.21,99.69 176.21,98.17 176.09,98.04 174.31,98.04 174.18,98.17
ANLGOUT on TOP: 230.06,199.01 230.06,197.36 229.93,197.23 228.16,197.23 228.03,197.36 228.03,199.01 228.16,199.13 229.93,199.13
ANLGOUT on TOP: 155,175.09 155.13,175.22 156.53,175.22 156.65,175.09 156.65,173.57 156.53,173.44 155.13,173.44 155,173.57
ANLGOUT on TOP: 175.45,185.8 175.32,185.67 173.04,185.67 172.91,185.8 172.91,187.7 173.04,187.83 175.32,187.83 175.45,187.7
ANLGOUT on TOP: 169.86,192.15 169.74,192.02 167.07,192.02 166.94,192.15 166.94,193.67 167.07,193.8 169.74,193.8 169.86,193.67
ANLGOUT on TOP: 201.99,101.98 202.12,102.11 203.9,102.11 204.03,101.98 204.03,100.45 203.9,100.33 202.12,100.33 201.99,100.45
ANLGOUT on TOP: 189.17,101.98 189.29,102.11 191.07,102.11 191.2,101.98 191.2,100.45 191.07,100.33 189.29,100.33 189.17,100.45
ANLGOUT on TOP: 158.31,139.4 158.31,137.92 158.18,137.79 153.86,137.79 153.73,137.92 153.73,139.82 153.86,139.95 157.75,139.95
ANLGOUT on TOP: 174.18,101.98 174.31,102.11 176.09,102.11 176.21,101.98 176.21,100.45 176.09,100.33 174.31,100.33 174.18,100.45
ANLGOUT on TOP: 157.92,125.85 158.05,125.73 158.05,123.95 157.92,123.82 146.7,123.82 146.43,124.09 146.43,127.44 147.42,128.43 149.77,128.43 150.87,127.33 156.48,127.33 157.92,125.89
ANLGOUT on BOTTOM: 116.9,114.3 115.13,116.08 115.13,181.23 118.05,184.15 118.05,201.67 120.21,203.83 148.53,203.83 151.57,206.88 156.27,206.88 172.59,223.19 244.36,223.19 276.42,191.13 297.75,191.13 300.29,193.67 321.25,193.67 322.01,194.43 322.01,200.02 322.39,200.4 326.83,200.4 327.09,200.15 327.09,166.88 327.09,166.88 327.09,165.86 326.83,165.61 325.82,165.61 325.18,166.24 259.4,166.24 252.41,173.23 245.17,173.23 235.01,183.39 211.26,183.39 210.25,184.4 198.56,184.4 197.29,183.13 172.13,183.13 171.62,183.64 171.62,183.66 171.39,183.89 168.08,183.89 167.32,183.13 161.1,183.13 156.78,178.81 156.78,164.09 156.27,163.59 147.96,163.59 147.71,163.33 147.71,151.59 147.08,151.25 147.71,150.91 147.71,145.42 147.71,145.41 147.71,143.08 148.1,142.69 157.04,142.69 157.42,142.31 157.42,137.67 157.41,137.67 157.41,136.77 157.16,136.52 147.76,136.52 146.24,135.01 146.24,130.55 147.13,129.66 148.53,129.66 149.29,128.9 149.29,124.97 148.91,124.58 145.99,124.58 144.72,123.31 144.72,115.95 143.07,114.3 ; 29 cut-outs
ANLGOUT on BOTTOM: 190.44,91.31 189.8,91.95 179.01,91.95 177.1,93.85 175.32,93.85 174.69,94.49 174.69,101.72 175.2,102.23 191.83,102.23 192.85,103.25 242.63,103.25 244.92,105.53 244.92,121.79 237.93,128.78 236.16,128.78 235.39,129.54 235.39,132.71 236.66,133.98 247.46,133.98 248.73,135.25 248.73,144.9 247.46,146.17 241.49,146.17 240.98,145.67 240.98,143.89 240.86,143.76 238.57,143.76 238.32,144.02 238.32,147.57 239.08,148.33 246.3,148.33 246.3,148.37 246.62,148.69 246.62,155.18 245.34,156.46 240.6,156.46 239.97,155.83 237.43,155.83 236.92,156.33 236.92,158.62 237.55,159.26 246.82,159.26 247.84,160.27 247.84,168.23 246.94,169.13 241.08,169.13 240.09,168.15 236.79,168.15 236.41,168.53 236.41,171.45 236.79,171.83 247.97,171.83 250.13,169.67 253.43,169.67 258.38,164.72 284.04,164.72 284.29,164.46 284.29,115.57 270.07,101.34 261.56,101.34 259.4,99.18 238.06,99.18 231.58,92.71 196.15,92.71 194.75,91.31
ANLGOUT on SIG4: 280.99,158.37 284.16,158.37 284.67,158.87 284.67,165.35 286.19,166.88 326.2,166.88 326.83,167.51 326.83,188.34 325.56,189.61 324.29,189.61 322.77,188.08 277.69,188.08 276.03,186.43 276.03,163.32
ANLGOUT on SIG6: 289.3,185.7 324.32,185.7 324.93,185.08 324.93,168.96 324.16,168.19 288.06,168.19 285.58,165.71 285.58,157.03 284.03,155.48 281.24,155.48 276.28,160.44 276.28,172.68
ANLGOUT on SIG10: 126.33,202.21 124.65,200.53 124.65,151.13 125.19,150.59 147.38,150.59 147.77,150.98 147.77,163.53 166.42,182.17 227.87,182.17 228.8,183.11 228.8,201.75 228.33,202.21
ANLGOUT on SIG10: 279.59,158.11 285.94,158.11 286.83,159 286.83,165.73 287.72,166.62 326.71,166.62 326.96,166.88 326.96,187.96 326.07,188.85 323.91,188.85 322.9,187.83 310.58,187.83 308.93,186.18 293.81,186.18 276.42,168.78 276.42,161.29
AVS_PVTMON_AVDD1P8 on TOP: 218.5,192.78 220.28,192.78 220.41,192.91 220.41,196.34 220.28,196.47 218.5,196.47 218.38,196.34 218.38,192.91
AVS_PVTMON_AVDD1P8 on SIG8: 207.07,154.68 207.33,154.94 207.33,177.29 208.36,178.32 208.36,178.33 208.86,178.84 208.86,181.24 214.69,187.07 218,187.07 220.41,189.48 220.41,194.05 220.03,194.43 217.61,194.43 217.11,193.93 217.11,190.75 216.22,189.86 214.19,189.86 203.42,179.09 203.42,173.84 204.79,172.46 204.79,164.72 202.37,162.3 202.37,154.94 202.63,154.68
BS_PLL_0_1_AVDD1P8 on TOP: 166.05,191.13 166.05,189.48 165.93,189.35 162.88,189.35 162.7,189.53 162.7,191.26 162.8,191.36 165.82,191.36
BS_PLL_0_1_AVDD1P8 on SIG4: 196.15,153.92 197.8,153.92 198.18,154.3 198.18,170.81 198.69,171.32 198.69,172.97 196.79,174.88 196.79,184.47 189.19,192.07 165.1,192.07 164.15,191.12 164.15,186.31 164.66,185.8 186.5,185.8 194.88,177.42 194.88,171.96 195.14,171.7 195.64,171.7 195.9,171.45 195.9,154.18
CORE_PLL_AVDD1P8 on TOP: 234.76,138.3 234.76,140.59 234.89,140.71 235.9,140.71 236.54,140.08 236.54,138.3 236.41,138.17 234.89,138.17
CORE_PLL_AVDD1P8 on SIG5: 236.54,137.67 228.16,137.67 227.14,138.68 218.5,138.68 217.49,137.67 215.96,137.67 215.71,137.92 215.71,140.84 215.96,141.09 236.54,141.09 236.79,140.84 236.79,137.92
CPLD3.3V on TOP (solid shape): 375.22,219.96 375.22,217.63 375.21,217.59 375.17,217.57 374.41,217.57 374.41,216.96 374.39,216.93 374.36,216.91 373.8,216.91 373.76,216.93 373.75,216.96 373.75,217.57 372.88,217.57 372.88,216.96 372.87,216.93 372.83,216.91 372.43,216.91 370.59,215.07 365.25,215.07 365.06,215.26 365.06,219.71 365.44,220.09 375.09,220.09
