# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC3_TDP1: length 239.8
  TOP w0.147: U1.CB45 185.57,168.32 v4(185.5,168.32)
  SIG4 w0.112: v4(185.5,168.32) 185.27,168.32 arc(185.18,168.35) 185.15,168.44 185.15,168.59 arc(185.05,168.83) 184.81,168.93 182.31,168.93 arc(182.19,168.98) 182.14,169.09 182.14,172.52 182.23,172.62 182.23,172.64
  SIG4 w0.16: 182.23,172.64 182.23,172.88 arc(182.16,173.25) 181.95,173.56 181.73,173.78 arc(181.36,174.03) 180.93,174.11 150.82,174.11 arc(150.39,174.03) 150.02,173.78 83.31,107.07 arc(83.12,106.95) 82.91,106.91 62.75,106.91 arc(62.39,106.83) 62.09,106.63 55.31,99.86 arc(55.13,99.74) 54.92,99.69 49.67,99.69 arc(49.31,99.62) 49.01,99.42 41.93,92.34 arc(41.68,91.97) 41.59,91.53 41.59,82.81 arc(41.55,82.6) 41.43,82.41 38.88,79.87 arc(38.63,79.49) 38.54,79.06 38.54,73.89 arc(38.5,73.68) 38.38,73.5 34.65,69.77 arc(34.4,69.4) 34.32,68.96 34.32,58.39 arc(34.27,58.17) 34.15,57.99 31.73,55.57 arc(31.55,55.45) 31.33,55.41 19.35,55.41 arc(19.06,55.35) 18.81,55.18 18.71,55.08 arc(18.47,54.92) 18.18,54.86 17.3,54.86 arc(17.09,54.77) 17.01,54.57 17.01,54.32 arc(17.04,54.13) 17.15,53.97 YJ21.B2
FC3_TDP2: length 238.6
  TOP w0.147: v4(184.6,170.34) 184.69,170.34 arc(184.78,170.32) 184.85,170.28 184.92,170.21 arc(185.01,170.07) 185.05,169.89 U1.CD46
  SIG4 w0.112: 183.13,173.91 183.13,173.89 183.22,173.79 183.22,173.51 arc(183.26,173.32) 183.37,173.15 183.78,172.74 arc(183.9,172.56) 183.95,172.35 183.95,171.18 arc(183.97,171.05) 184.04,170.95 184.12,170.87 arc(184.23,170.8) 184.35,170.77 184.82,170.77 arc(184.91,170.73) 184.95,170.64 184.95,170.47 arc(184.91,170.38) 184.82,170.34 v4(184.6,170.34)
  SIG4 w0.16: 183.13,173.91 183.13,174.73 arc(183.07,175.02) 182.91,175.27 182.59,175.59 arc(182.34,175.76) 182.05,175.81 149.96,175.81 arc(149.67,175.76) 149.42,175.59 84.21,110.38 arc(83.9,110.18) 83.55,110.11 63.32,110.11 arc(63.1,110.06) 62.92,109.94 54.47,101.49 arc(54.17,101.29) 53.81,101.22 48.56,101.22 arc(48.34,101.17) 48.16,101.05 39.72,92.62 arc(39.6,92.44) 39.56,92.22 39.56,83.54 arc(39.49,83.18) 39.29,82.88 37.09,80.68 36,79.12 34.33,77.45 34.33,77.14 33.92,76.73 33.62,76.73 33.26,76.37 33.26,76.06 32.85,75.65 32.54,75.65 32.23,75.35 arc(32.11,75.16) 32.07,74.95 32.07,74.55 32.32,74.29 32.32,73.78 32.07,73.53 32.07,72.77 32.32,72.51 32.32,72.01 32.07,71.75 32.07,71.24 32.3,71.02 32.3,70.46 32.07,70.23 32.07,70.04 arc(32.13,69.74) 32.29,69.5 33.1,68.69 arc(33.31,68.38) 33.38,68.02 33.38,61.65 arc(33.31,61.29) 33.1,60.98 32.45,60.33 31.42,59.3 arc(31.12,59.1) 30.76,59.03 19.35,59.03 arc(19.21,59) 19.08,58.91 19.03,58.86 arc(18.94,58.72) 18.91,58.57 18.91,58.09 arc(18.86,57.86) 18.73,57.67 18.52,57.45 18.27,57.2 arc(18.14,57.02) 18.1,56.8 YJ21.B36
FC3_TDP3: length 234.7
  TOP w0.147: U1.CF45 185.55,172.34 v4(185.5,172.34)
  SIG5 w0.112: 182.44,174.11 182.46,174.11 182.55,174.02 182.86,174.02 arc(183.02,173.99) 183.16,173.9 183.93,173.13 arc(184.11,173.01) 184.32,172.97 184.85,172.97 arc(185.08,172.87) 185.17,172.64 arc(185.19,172.58) 185.22,172.52 185.37,172.38 arc(185.41,172.35) 185.45,172.34 v4(185.5,172.34)
  SIG5 w0.16: 182.44,174.11 150.82,174.11 arc(150.39,174.03) 150.02,173.78 86.89,110.65 arc(86.71,110.53) 86.49,110.49 60.37,110.49 arc(60.01,110.42) 59.7,110.21 39.46,89.97 arc(39.25,89.66) 39.18,89.3 39.18,83.57 arc(39.14,83.36) 39.02,83.18 36.72,80.88 arc(36.47,80.51) 36.39,80.07 36.39,71.69 arc(36.33,71.4) 36.16,71.15 34.6,69.58 arc(34.39,69.28) 34.32,68.92 34.32,55.97 arc(34.16,55.57) 33.76,55.41 21.75,55.41 arc(21.46,55.35) 21.21,55.18 arc(20.86,54.95) 20.44,54.86 19.65,54.86 arc(19.48,54.79) 19.41,54.61 19.41,54.32 arc(19.44,54.13) 19.55,53.97 YJ21.B5
FC4_5_PVDD0P8: length 5.5
  TOP w0.229: U1.BG44 v1(186.55,153.34) ; U1.BG46 v1(184.55,153.34)
  TOP w0.381: C2840.1 171.98,190.9 ; C2840.1 171.39,190.27 ; C2840.1 170.79,190.9
  BOTTOM w0.13: v1(170.88,189.74) v2(170.88,190.57)
  BOTTOM w0.381: C2794.1 v1(186.55,153.34) ; C3347.1 v1(184.55,153.34)
  vias: v1(171.77,189.74)
FC4_RDN0: length 240.1
  TOP w0.147: U1.BY49 182.05,165.89 arc(181.92,166.21) v4(181.6,166.34)
  SIG9 w0.112: 181.85,172.73 181.85,172.7 arc(181.86,172.68) 181.87,172.66 181.9,172.63 arc(181.93,172.58) 181.95,172.52 181.95,166.74 arc(181.94,166.69) 181.91,166.65 v4(181.6,166.34)
  SIG9 w0.16: 181.85,172.73 181.85,174.61 arc(181.94,175.06) 182.2,175.45 182.46,175.7 arc(182.63,175.96) 182.69,176.27 182.69,177.23 arc(182.63,177.52) 182.47,177.77 180.49,179.75 arc(180.23,179.92) 179.92,179.98 163.54,179.98 arc(163.23,179.92) 162.97,179.75 159.36,176.14 arc(158.98,175.88) 158.53,175.79 152.9,175.79 arc(152.59,175.73) 152.33,175.56 108.38,131.6 arc(108.2,131.34) 108.14,131.03 108.14,128.5 arc(108.05,128.05) 107.8,127.67 89.06,108.93 arc(88.67,108.67) 88.22,108.58 62.02,108.58 arc(61.71,108.52) 61.45,108.35 42.21,89.11 arc(42.03,88.85) 41.97,88.54 41.97,83.11 arc(41.87,82.61) 41.59,82.19 41.54,82.14 41.54,82.14 34.36,74.96 34.36,74.5 33.99,74.14 33.54,74.14 31.92,72.52 31.92,72.11 31.54,71.73 31.13,71.73 30.78,71.38 arc(30.6,71.12) 30.54,70.81 30.54,70.36 30.8,70.1 30.8,69.59 30.54,69.34 30.54,68.84 30.8,68.59 30.8,68.08 30.54,67.83 30.54,67.45 arc(30.6,67.15) 30.77,66.91 31.72,65.95 arc(31.98,65.57) 32.07,65.12 32.07,59.46 arc(32.13,59.15) 32.3,58.89 32.57,58.62 32.93,58.62 33.29,58.27 33.29,57.91 33.65,57.55 34.03,57.55 34.37,57.21 34.37,56.83 35.57,55.63 arc(35.83,55.46) 36.13,55.39 37.39,55.39 arc(37.68,55.34) 37.93,55.17 38.01,55.1 arc(38.27,54.92) 38.57,54.86 39.46,54.86 arc(39.7,54.76) 39.8,54.52 39.8,54.34 arc(39.76,54.14) 39.65,53.97 YJ22.B14
FC4_RDN1: length 233.1
  TOP w0.147: U1.BV48 182.55,164.34 v4(182.5,164.34)
  SIG9 w0.112: 180.24,172.7 180.24,172.68 arc(180.24,172.65) 180.22,172.63 180.2,172.6 arc(180.16,172.55) 180.15,172.49 180.15,165.28 arc(180.17,165.16) 180.24,165.06 arc(180.34,164.99) 180.46,164.96 181.85,164.96 arc(182.06,164.88) 182.15,164.67 182.15,164.47 arc(182.16,164.42) 182.18,164.38 182.19,164.38 arc(182.23,164.35) 182.28,164.34 v4(182.5,164.34)
  SIG9 w0.16: 180.24,172.7 180.24,176.99 arc(180.15,177.44) 179.9,177.83 179.79,177.93 arc(179.41,178.19) 178.95,178.28 164.4,178.28 arc(163.95,178.19) 163.57,177.93 161.72,176.09 159.98,174.35 arc(159.72,174.18) 159.42,174.11 153.79,174.11 arc(153.33,174.02) 152.95,173.77 126.94,147.75 110.26,131.08 arc(110.01,130.7) 109.92,130.25 109.92,127.74 arc(109.86,127.43) 109.68,127.18 86.18,103.67 arc(85.57,103.26) 84.85,103.12 59.2,103.12 arc(58.66,103.01) 58.19,102.7 44.99,89.5 arc(44.73,89.11) 44.64,88.66 44.64,80.53 arc(44.61,80.38) 44.53,80.26 43.17,78.9 arc(42.91,78.72) 42.6,78.66 41.06,78.66 arc(40.61,78.57) 40.23,78.32 32.69,70.78 arc(32.44,70.4) 32.35,69.95 32.35,66.94 arc(32.43,66.5) 32.68,66.13 32.77,66.04 arc(32.95,65.78) 33.01,65.47 33.01,61.6 arc(33.1,61.16) 33.34,60.79 34.79,59.35 arc(35.01,59.18) 35.26,59.07 arc(35.42,59.03) 35.6,59.01 37.39,59.01 arc(37.54,58.98) 37.66,58.9 37.74,58.83 37.75,58.81 37.79,58.77 arc(37.83,58.72) 37.87,58.66 arc(37.88,58.63) 37.89,58.6 arc(37.9,58.59) 37.9,58.58 arc(37.91,58.53) 37.91,58.48 37.91,58.16 arc(37.97,57.85) 38.15,57.58 38.45,57.28 arc(38.64,57.01) 38.7,56.68 YJ22.B24
FC4_RDN2: length 245.4
  TOP w0.147: U1.BT49 182.05,161.85 arc(182.01,162.04) 181.91,162.2 181.82,162.28 arc(181.76,162.33) 181.68,162.34 v4(181.6,162.34)
  SIG8 w0.112: 181.86,172.69 181.86,172.67 181.96,172.57 181.96,167.33 arc(181.95,167.25) 181.92,167.17 arc(181.89,167.12) 181.85,167.08 arc(181.73,167) 181.6,166.97 181.39,166.97 arc(181.1,166.86) 180.99,166.57 180.99,163.19 arc(181.01,163.06) 181.08,162.96 181.17,162.87 arc(181.28,162.8) 181.4,162.77 181.85,162.77 arc(181.92,162.74) 181.95,162.67 181.95,162.44 arc(181.92,162.37) 181.85,162.34 v4(181.6,162.34)
  SIG8 w0.16: YJ22.B17 37.25,53.97 arc(37.36,54.14) 37.4,54.34 37.4,54.45 arc(37.37,54.61) 37.28,54.75 37.28,54.75 arc(37.15,54.83) 37,54.86 36.02,54.86 arc(35.85,54.89) 35.71,54.99 35.53,55.17 arc(35.28,55.34) 34.99,55.39 33.85,55.39 arc(33.54,55.46) 33.28,55.63 32.26,56.65 arc(32.09,56.91) 32.03,57.21 32.03,69.95 32.26,70.18 32.26,70.74 32.03,70.97 32.03,71.47 32.26,71.7 32.26,72.26 32.03,72.49 32.03,73 32.26,73.23 32.26,73.79 32.03,74.01 32.03,74.52 32.26,74.75 32.26,75.31 32.03,75.54 32.03,76.05 arc(32.06,76.19) 32.14,76.32 32.52,76.7 32.86,76.7 33.24,77.08 33.24,77.42 33.6,77.78 33.94,77.78 34.32,78.16 34.32,78.5 34.68,78.85 35.04,78.85 35.4,79.21 35.4,79.57 36.06,80.24 arc(36.11,80.28) 36.16,80.32 38.02,81.67 arc(38.1,81.72) 38.17,81.79 39.2,82.82 arc(39.47,83.22) 39.56,83.69 39.56,89.07 arc(39.62,89.38) 39.8,89.64 49.23,99.08 arc(49.49,99.25) 49.8,99.31 54.87,99.31 arc(55.32,99.4) 55.71,99.66 64.4,108.35 arc(64.66,108.52) 64.96,108.58 88.22,108.58 arc(88.67,108.67) 89.06,108.93 107.71,127.58 arc(108.03,128.06) 108.14,128.62 108.14,131.03 arc(108.2,131.34) 108.38,131.6 150.22,173.45 arc(150.48,173.62) 150.79,173.68 156.43,173.68 arc(156.88,173.77) 157.27,174.03 162.99,179.75 arc(163.25,179.92) 163.55,179.98 180.12,179.98 arc(180.43,179.92) 180.69,179.75 182.46,177.98 arc(182.63,177.72) 182.69,177.42 182.69,176.91 arc(182.63,176.6) 182.46,176.34 182.21,176.1 arc(181.95,175.71) 181.86,175.26 181.86,172.69
FC4_RDN3: length 235.2
  TOP w0.147: U1.BP48 182.55,160.34 v4(182.5,160.34)
  SIG8 w0.112: v4(182.5,160.34) 182.25,160.34 arc(182.18,160.37) 182.15,160.44 182.15,160.67 arc(182.06,160.88) 181.85,160.97 180.38,160.97 arc(180.29,160.99) 180.21,161.04 180.18,161.07 arc(180.16,161.11) 180.15,161.16 180.15,172.6 180.24,172.69
  SIG8 w0.16: 180.24,172.69 180.24,176.99 arc(180.15,177.44) 179.89,177.83 179.78,177.93 arc(179.4,178.19) 178.95,178.28 164.41,178.28 arc(163.96,178.19) 163.58,177.93 158.11,172.47 arc(157.57,172.11) 156.93,171.98 151.68,171.98 arc(151.23,171.89) 150.84,171.63 110.26,131.06 arc(110.01,130.67) 109.92,130.22 109.92,127.93 arc(109.82,127.45) 109.55,127.04 88.02,105.51 arc(87.76,105.34) 87.46,105.28 64.18,105.28 arc(63.73,105.19) 63.34,104.93 55.67,97.26 arc(55.41,97.09) 55.1,97.03 50.1,97.03 arc(49.65,96.94) 49.27,96.68 41.94,89.35 arc(41.68,88.97) 41.59,88.52 41.59,82.91 arc(41.53,82.6) 41.36,82.34 38.88,79.87 arc(38.63,79.49) 38.54,79.06 38.54,74.02 arc(38.48,73.71) 38.31,73.45 33.3,68.44 arc(33.04,68.06) 32.95,67.61 32.95,60.41 arc(33.04,59.95) 33.3,59.57 33.51,59.36 arc(33.89,59.1) 34.34,59.01 34.99,59.01 arc(35.14,58.98) 35.26,58.9 35.35,58.82 arc(35.35,58.81) 35.35,58.81 arc(35.42,58.73) 35.47,58.63 arc(35.47,58.63) 35.47,58.62 arc(35.5,58.52) 35.51,58.42 35.51,58.15 arc(35.57,57.85) 35.74,57.59 36,57.34 arc(36.22,57) 36.3,56.61 YJ22.B21
FC4_RDP0: length 240.1
  TOP w0.147: v4(182.5,166.34) 182.55,166.34 U1.BY48
  SIG9 w0.112: v4(182.5,166.34) 182.18,166.66 arc(182.15,166.7) 182.14,166.75 182.14,172.54 arc(182.15,172.58) 182.18,172.62 182.22,172.66 arc(182.23,172.68) 182.23,172.7 182.23,172.73
  SIG9 w0.16: YJ22.B15 38.7,52.71 arc(38.64,53.01) 38.47,53.26 38.15,53.58 arc(37.97,53.85) 37.91,54.16 37.91,54.48 arc(37.91,54.53) 37.9,54.58 arc(37.86,54.69) 37.79,54.77 37.75,54.81 37.74,54.83 37.66,54.9 arc(37.54,54.98) 37.39,55.01 36.13,55.01 arc(35.68,55.1) 35.3,55.36 32.03,58.62 arc(31.78,59.01) 31.69,59.46 31.69,65.12 arc(31.63,65.42) 31.45,65.68 30.5,66.64 arc(30.25,67.01) 30.16,67.45 30.16,70.81 arc(30.25,71.26) 30.51,71.65 34.09,75.23 41.32,82.46 arc(41.52,82.76) 41.59,83.11 41.59,88.54 arc(41.68,88.99) 41.94,89.38 61.18,108.62 arc(61.56,108.87) 62.02,108.96 88.22,108.96 arc(88.53,109.02) 88.79,109.2 107.53,127.94 arc(107.7,128.2) 107.76,128.5 107.76,131.03 arc(107.85,131.49) 108.11,131.87 152.06,175.83 arc(152.45,176.08) 152.9,176.17 158.53,176.17 arc(158.83,176.23) 159.09,176.41 160.84,178.16 162.7,180.02 arc(163.09,180.27) 163.54,180.36 179.92,180.36 arc(180.37,180.27) 180.76,180.02 182.74,178.04 arc(182.98,177.67) 183.07,177.23 183.07,176.27 arc(182.98,175.82) 182.72,175.43 182.47,175.18 arc(182.3,174.92) 182.23,174.61 182.23,172.73
FC4_RDP1: length 233.1
  TOP w0.147: U1.BV49 182.05,163.89 arc(181.92,164.21) v4(181.6,164.34)
  SIG9 w0.112: 179.86,172.7 179.86,172.68 arc(179.87,172.65) 179.88,172.63 179.91,172.6 arc(179.94,172.55) 179.95,172.49 179.95,165.28 arc(179.99,165.08) 180.1,164.92 arc(180.27,164.81) 180.46,164.77 181.85,164.77 arc(181.92,164.74) 181.95,164.67 181.95,164.47 arc(181.94,164.43) 181.92,164.4 181.9,164.37 arc(181.86,164.35) 181.82,164.34 v4(181.6,164.34)
  SIG9 w0.16: YJ22.B25 39.65,57.97 arc(39.76,58.14) 39.8,58.34 39.8,58.52 arc(39.7,58.76) 39.46,58.86 38.68,58.86 arc(38.27,58.94) 37.93,59.17 arc(37.68,59.34) 37.39,59.39 35.6,59.39 arc(35.48,59.4) 35.37,59.43 arc(35.2,59.5) 35.06,59.62 34.69,59.99 34.69,60.37 34.31,60.76 33.92,60.76 33.61,61.06 arc(33.45,61.31) 33.39,61.6 33.39,65.47 arc(33.3,65.92) 33.04,66.31 32.95,66.4 arc(32.79,66.65) 32.73,66.94 32.73,69.95 arc(32.79,70.25) 32.96,70.51 33.41,70.96 33.82,70.96 34.18,71.32 34.18,71.73 35.38,72.93 35.74,72.93 36.1,73.29 36.1,73.65 37.36,74.91 37.77,74.91 38.13,75.27 38.13,75.68 38.55,76.1 38.94,76.1 39.32,76.49 39.32,76.87 40.49,78.05 arc(40.75,78.22) 41.06,78.28 42.6,78.28 arc(43.05,78.37) 43.44,78.63 43.67,78.86 44.06,78.86 44.44,79.25 44.44,79.63 44.8,79.99 arc(44.96,80.23) 45.02,80.53 45.02,88.66 arc(45.08,88.97) 45.26,89.23 58.46,102.43 arc(58.8,102.66) 59.2,102.74 84.85,102.74 arc(85.72,102.91) 86.45,103.4 109.95,126.91 arc(110.21,127.29) 110.3,127.74 110.3,130.25 arc(110.36,130.55) 110.53,130.81 153.22,173.5 arc(153.48,173.67) 153.79,173.73 159.42,173.73 arc(159.87,173.82) 160.25,174.08 163.84,177.66 arc(164.1,177.84) 164.4,177.9 178.95,177.9 arc(179.26,177.84) 179.52,177.66 179.63,177.56 arc(179.8,177.3) 179.86,176.99 179.86,172.7
FC4_RDP2: length 245.4
  TOP w0.147: v4(182.5,162.34) 183,161.84 U1.BT48
  SIG8 w0.112: 182.24,172.69 182.24,172.67 182.15,172.57 182.15,167.33 arc(182.14,167.21) 182.09,167.08 arc(182.05,167.01) 181.99,166.94 arc(181.81,166.82) 181.6,166.78 181.39,166.78 arc(181.24,166.72) 181.18,166.57 181.18,163.19 arc(181.19,163.14) 181.22,163.1 181.31,163.01 arc(181.35,162.98) 181.4,162.97 181.85,162.97 arc(182.06,162.88) 182.15,162.67 182.15,162.44 arc(182.18,162.37) 182.25,162.34 v4(182.5,162.34)
  SIG8 w0.16: 182.24,172.69 182.24,175.26 arc(182.31,175.57) 182.48,175.83 182.72,176.07 arc(182.98,176.46) 183.07,176.91 183.07,177.42 arc(182.98,177.87) 182.72,178.25 180.96,180.02 arc(180.58,180.27) 180.12,180.36 163.55,180.36 arc(163.1,180.27) 162.72,180.02 157,174.3 arc(156.74,174.12) 156.43,174.06 150.79,174.06 arc(150.34,173.97) 149.95,173.72 108.11,131.87 arc(107.85,131.49) 107.76,131.03 107.76,128.62 arc(107.68,128.21) 107.44,127.85 88.79,109.2 arc(88.53,109.02) 88.22,108.96 64.96,108.96 arc(64.51,108.87) 64.13,108.62 55.44,99.93 arc(55.18,99.75) 54.87,99.69 49.8,99.69 arc(49.35,99.6) 48.96,99.35 39.53,89.91 arc(39.27,89.53) 39.18,89.07 39.18,83.69 arc(39.12,83.37) 38.93,83.09 37.9,82.06 arc(37.85,82.02) 37.8,81.98 35.94,80.63 arc(35.86,80.57) 35.79,80.51 31.87,76.59 arc(31.71,76.34) 31.65,76.05 31.65,57.21 arc(31.74,56.76) 31.99,56.38 33.01,55.36 arc(33.39,55.1) 33.85,55.01 34.99,55.01 arc(35.14,54.98) 35.26,54.9 35.35,54.82 35.35,54.81 35.39,54.77 arc(35.45,54.7) 35.49,54.61 arc(35.51,54.54) 35.51,54.48 35.51,54.1 arc(35.56,53.84) 35.71,53.63 36.05,53.29 arc(36.23,53.01) 36.3,52.68 YJ22.B18
FC4_RDP3: length 235.2
  TOP w0.147: U1.BP49 182.05,159.85 arc(182.01,160.04) 181.91,160.2 181.82,160.28 arc(181.76,160.33) 181.68,160.34 v4(181.6,160.34)
  SIG8 w0.112: 179.86,172.69 179.95,172.6 179.95,161.16 arc(179.98,161.03) 180.05,160.93 180.08,160.9 arc(180.21,160.8) 180.38,160.77 181.85,160.77 arc(181.92,160.74) 181.95,160.67 181.95,160.44 arc(181.92,160.37) 181.85,160.34 v4(181.6,160.34)
  SIG8 w0.16: YJ22.B22 37.25,57.97 arc(37.38,58.17) 37.43,58.39 37.43,58.43 arc(37.4,58.57) 37.32,58.69 arc(37.13,58.82) 36.9,58.86 35.92,58.86 arc(35.85,58.88) 35.78,58.92 35.53,59.17 arc(35.28,59.34) 34.99,59.39 34.34,59.39 arc(34.04,59.46) 33.78,59.63 33.57,59.84 arc(33.39,60.1) 33.33,60.41 33.33,67.61 arc(33.39,67.91) 33.57,68.17 34.25,68.86 34.57,68.86 34.96,69.25 34.96,69.57 35.36,69.96 35.67,69.96 36.06,70.36 36.06,70.67 36.46,71.06 36.77,71.06 37.17,71.46 37.17,71.77 38.58,73.18 arc(38.84,73.57) 38.93,74.02 38.93,74.57 39.18,74.83 39.18,75.33 38.93,75.59 38.93,76.1 39.18,76.35 39.18,76.86 38.93,77.11 38.93,77.62 39.15,77.85 39.15,78.41 38.93,78.64 38.93,79.06 arc(38.98,79.35) 39.15,79.6 41.63,82.07 arc(41.88,82.46) 41.97,82.91 41.97,83.83 42.19,84.05 42.19,84.6 41.97,84.83 41.97,88.52 arc(42.03,88.82) 42.21,89.08 49.54,96.41 arc(49.8,96.58) 50.1,96.64 55.1,96.64 arc(55.56,96.73) 55.94,96.99 63.61,104.67 arc(63.87,104.84) 64.18,104.9 87.46,104.9 arc(87.91,104.99) 88.29,105.25 109.82,126.77 arc(110.17,127.3) 110.3,127.93 110.3,130.22 arc(110.36,130.53) 110.53,130.79 151.11,171.37 arc(151.37,171.54) 151.68,171.6 156.93,171.6 arc(157.72,171.76) 158.38,172.2 163.85,177.66 arc(164.1,177.84) 164.41,177.9 178.95,177.9 arc(179.26,177.84) 179.52,177.66 179.62,177.56 arc(179.79,177.3) 179.86,176.99 179.86,172.69
FC4_TDN0: length 237.7
  TOP w0.147: v4(183.5,169.34) 183.55,169.34 U1.CC47
  SIG6 w0.112: v4(183.5,169.34) 183.33,169.34 arc(183.26,169.36) 183.2,169.4 arc(183.16,169.46) 183.15,169.53 183.15,169.64 arc(183.05,169.87) 182.82,169.97 182.33,169.97 arc(182.29,169.98) 182.24,170.01 182.19,170.06 arc(182.16,170.1) 182.16,170.15 182.16,172.57 182.25,172.67 182.25,172.69
  SIG6 w0.16: 182.25,172.69 182.25,174.11 arc(182.16,174.55) 181.91,174.92 180.98,175.86 arc(180.6,176.11) 180.17,176.19 162.24,176.19 arc(161.88,176.12) 161.58,175.92 159.9,174.24 arc(159.65,174.08) 159.36,174.02 150.76,174.02 arc(150.32,173.93) 149.95,173.68 108.09,131.83 arc(107.85,131.46) 107.76,131.02 107.76,128.73 arc(107.73,128.58) 107.65,128.46 86.26,107.07 arc(86.08,106.95) 85.86,106.91 59.88,106.91 arc(59.52,106.83) 59.22,106.63 41.87,89.28 arc(41.66,88.98) 41.59,88.62 41.59,82.86 arc(41.53,82.57) 41.37,82.32 38.82,79.77 arc(38.62,79.47) 38.54,79.11 38.54,76.94 arc(38.5,76.73) 38.38,76.55 32.04,70.2 arc(31.79,69.83) 31.7,69.4 31.7,58.82 arc(31.79,58.38) 32.04,58.01 34.7,55.35 arc(34.98,55.14) 35.3,55.03 arc(35.4,55.02) 35.51,55.01 44.59,55.01 arc(44.74,54.98) 44.86,54.9 44.95,54.81 44.99,54.77 arc(45.06,54.69) 45.1,54.58 arc(45.11,54.53) 45.11,54.48 45.11,54.16 arc(45.17,53.85) 45.35,53.58 45.71,53.22 arc(45.85,53.01) 45.9,52.77 YJ22.B6
FC4_TDN1: length 240
  TOP w0.147: U1.CE48 183.05,170.89 arc(182.92,171.21) v4(182.6,171.34)
  SIG7 w0.112: 181.85,172.69 181.85,172.67 181.94,172.57 181.94,172.21 arc(181.96,172.12) 181.99,172.04 arc(182.01,172.01) 182.04,171.98 182.14,171.88 arc(182.26,171.8) 182.4,171.77 182.76,171.77 arc(182.9,171.72) 182.95,171.58 182.95,171.51 arc(182.9,171.39) 182.79,171.34 v4(182.6,171.34)
  SIG7 w0.16: YJ22.B2 49.25,53.97 arc(49.36,54.14) 49.4,54.34 49.4,54.45 arc(49.38,54.56) 49.32,54.65 49.26,54.71 arc(49.1,54.82) 48.9,54.86 48.01,54.86 arc(47.85,54.89) 47.72,54.98 47.53,55.17 arc(47.28,55.34) 46.99,55.39 35.51,55.39 arc(35.29,55.44) 35.11,55.56 32.25,58.42 arc(32.13,58.6) 32.08,58.82 32.08,69.51 arc(32.13,69.72) 32.25,69.9 35.15,72.8 35.4,72.8 35.73,73.13 35.73,73.38 36.06,73.71 36.29,73.71 36.64,74.06 36.64,74.29 37.87,75.53 38.08,75.53 38.43,75.88 38.43,76.08 38.7,76.35 arc(38.87,76.6) 38.93,76.89 38.93,77.4 39.13,77.61 39.13,78.11 38.93,78.32 38.93,79.14 arc(38.97,79.35) 39.09,79.54 39.49,79.94 39.78,79.94 40.14,80.3 40.14,80.58 40.63,81.08 40.92,81.08 41.28,81.44 41.28,81.73 41.64,82.09 arc(41.89,82.46) 41.97,82.89 41.97,83.74 42.18,83.94 42.18,84.45 41.97,84.66 41.97,85.16 42.18,85.37 42.18,85.87 41.97,86.08 41.97,86.59 42.18,86.79 42.18,87.3 41.97,87.5 41.97,88.62 arc(42.02,88.83) 42.14,89.01 61.55,108.42 arc(61.73,108.54) 61.94,108.58 88.32,108.58 arc(88.68,108.65) 88.99,108.86 107.87,127.74 arc(108.07,128.04) 108.14,128.4 108.14,134.08 arc(108.18,134.3) 108.3,134.48 147.42,173.6 arc(147.6,173.72) 147.82,173.76 158.48,173.76 arc(158.84,173.83) 159.15,174.03 160.77,175.66 arc(160.95,175.78) 161.16,175.82 179.99,175.82 arc(180.21,175.78) 180.39,175.66 181.69,174.36 arc(181.81,174.17) 181.85,173.96 181.85,172.69
FC4_TDN2: length 229.4
  TOP w0.147: U1.CB49 181.55,168.34 v4(181.5,168.34)
  SIG6 w0.112: 180.24,172.69 180.24,172.67 180.14,172.57 180.14,169.15 arc(180.15,169.1) 180.18,169.06 180.23,169.01 arc(180.28,168.98) 180.32,168.97 180.82,168.97 arc(181.05,168.87) 181.15,168.64 181.15,168.53 arc(181.16,168.46) 181.2,168.4 arc(181.26,168.36) 181.33,168.34 v4(181.5,168.34)
  SIG6 w0.16: 180.24,172.69 180.24,173.06 arc(180.16,173.42) 179.96,173.72 179.85,173.84 arc(179.54,174.04) 179.18,174.11 163.09,174.11 arc(162.73,174.04) 162.42,173.84 160.75,172.16 arc(160.5,172) 160.21,171.94 151.62,171.94 arc(151.19,171.85) 150.82,171.6 110.25,131.04 arc(110.01,130.67) 109.92,130.23 109.92,128.1 arc(109.86,127.81) 109.7,127.56 85.42,103.29 arc(85.24,103.16) 85.02,103.12 59,103.12 arc(58.64,103.05) 58.34,102.85 45.17,89.68 arc(44.97,89.38) 44.89,89.02 44.89,76.69 arc(44.85,76.47) 44.73,76.29 38.83,70.39 arc(38.65,70.27) 38.43,70.23 36.07,70.23 arc(35.63,70.14) 35.26,69.89 33.36,67.99 arc(33.11,67.62) 33.02,67.18 33.02,61.44 arc(33.11,61) 33.36,60.63 34.64,59.35 arc(34.96,59.12) 35.33,59.02 arc(35.39,59.02) 35.44,59.01 44.59,59.01 arc(44.74,58.98) 44.86,58.9 44.95,58.81 arc(45.07,58.64) 45.11,58.42 45.11,58.16 arc(45.17,57.85) 45.35,57.58 45.74,57.19 arc(45.86,57.02) 45.9,56.81 YJ22.B33
FC4_TDN3: length 232.1
  TOP w0.147: U1.CD50 181.05,169.9 arc(180.92,170.21) 180.6,170.34 v4(180.6,170.34)
  SIG7 w0.112: 179.86,172.69 179.86,172.67 179.95,172.57 179.95,171.21 arc(179.97,171.12) 180,171.04 arc(180.02,171.01) 180.05,170.98 180.15,170.88 arc(180.27,170.8) 180.41,170.77 180.76,170.77 arc(180.9,170.72) 180.95,170.58 180.95,170.51 arc(180.9,170.39) 180.79,170.34 v4(180.6,170.34)
  SIG7 w0.16: 179.86,172.69 179.86,173.1 arc(179.85,173.16) 179.81,173.22 179.45,173.58 arc(179.27,173.7) 179.06,173.74 160.99,173.74 arc(160.77,173.7) 160.59,173.58 159.73,172.72 arc(159.43,172.51) 159.07,172.44 149.42,172.44 arc(149.21,172.4) 149.03,172.28 110.46,133.71 arc(110.34,133.53) 110.3,133.32 110.3,127.64 arc(110.23,127.28) 110.02,126.98 86.06,103.02 arc(85.76,102.81) 85.4,102.74 59,102.74 arc(58.79,102.7) 58.6,102.58 45.44,89.41 arc(45.32,89.23) 45.28,89.02 45.28,83.57 45.45,83.39 45.45,82.92 45.28,82.75 45.28,82.28 45.45,82.1 45.45,81.64 45.28,81.46 45.28,81 45.45,80.82 45.45,80.35 45.28,80.18 45.28,79.71 45.45,79.53 45.45,79.07 45.28,78.89 45.28,78.43 45.45,78.25 45.45,77.78 45.28,77.61 45.28,76.33 arc(45.2,75.97) 45,75.67 44.2,74.87 44.2,74.64 43.87,74.31 43.64,74.31 43.31,73.98 43.31,73.75 42.99,73.43 42.76,73.43 42.43,73.1 42.43,72.92 42.05,72.54 41.87,72.54 41.54,72.21 41.54,71.98 41.21,71.65 40.99,71.65 40.66,71.32 40.66,71.1 40.33,70.77 40.1,70.77 39.46,70.12 arc(39.15,69.92) 38.79,69.85 35.35,69.85 arc(35.13,69.8) 34.95,69.68 33.57,68.3 arc(33.45,68.12) 33.4,67.9 33.4,61.69 arc(33.45,61.47) 33.57,61.29 35.3,59.56 arc(35.48,59.44) 35.7,59.39 46.99,59.39 arc(47.28,59.34) 47.53,59.17 arc(47.87,58.94) 48.28,58.86 49.06,58.86 arc(49.3,58.76) 49.4,58.52 49.4,58.34 arc(49.36,58.14) 49.25,57.97 YJ22.B37
FC4_TDP0: length 237.8
  TOP w0.147: U1.CC48 183.05,168.89 arc(182.92,169.21) v4(182.6,169.34)
  SIG6 w0.112: v4(182.6,169.34) 182.79,169.34 arc(182.84,169.35) 182.88,169.38 182.91,169.41 arc(182.94,169.45) 182.95,169.5 182.95,169.64 arc(182.91,169.73) 182.82,169.77 182.33,169.77 arc(182.21,169.8) 182.11,169.87 182.05,169.92 arc(181.98,170.02) 181.96,170.15 181.96,172.57 181.87,172.67 181.87,172.69
  SIG6 w0.16: YJ22.B5 46.85,53.97 arc(46.96,54.14) 47,54.34 47,54.52 arc(46.9,54.76) 46.66,54.86 45.76,54.86 arc(45.46,54.92) 45.22,55.08 45.13,55.17 arc(44.88,55.34) 44.59,55.39 35.51,55.39 arc(35.44,55.4) 35.37,55.41 arc(35.15,55.48) 34.97,55.62 34.29,56.3 34.29,56.58 33.93,56.95 33.64,56.95 33.3,57.29 33.3,57.57 32.93,57.94 32.65,57.94 32.31,58.28 arc(32.14,58.53) 32.08,58.82 32.08,69.4 arc(32.14,69.69) 32.31,69.94 32.65,70.27 32.93,70.27 33.3,70.64 33.3,70.93 33.64,71.27 33.93,71.27 34.29,71.63 34.29,71.92 35.31,72.94 35.6,72.94 35.96,73.3 35.96,73.59 37.41,75.03 37.69,75.03 38.06,75.4 38.06,75.69 38.65,76.28 arc(38.85,76.58) 38.93,76.94 38.93,77.35 39.15,77.57 39.15,78.05 38.93,78.27 38.93,79.11 arc(38.97,79.32) 39.09,79.51 41.64,82.05 arc(41.89,82.43) 41.97,82.86 41.97,85.14 42.18,85.34 42.18,85.85 41.97,86.05 41.97,88.62 arc(42.02,88.83) 42.14,89.01 59.49,106.36 arc(59.67,106.48) 59.88,106.53 85.86,106.53 arc(86.22,106.6) 86.53,106.8 107.92,128.19 arc(108.08,128.44) 108.14,128.73 108.14,131.02 arc(108.2,131.31) 108.36,131.56 150.22,173.41 arc(150.47,173.58) 150.76,173.64 159.36,173.64 arc(159.8,173.73) 160.17,173.97 161.85,175.65 arc(162.03,175.77) 162.24,175.81 180.17,175.81 arc(180.46,175.76) 180.71,175.59 181.64,174.65 arc(181.81,174.41) 181.87,174.11 181.87,172.69
FC4_TDP1: length 240
  TOP w0.147: U1.CE47 183.55,171.34 v4(183.5,171.34)
  SIG7 w0.112: v4(183.5,171.34) 183.31,171.34 arc(183.2,171.39) 183.15,171.51 183.15,171.58 arc(183.03,171.86) 182.76,171.97 182.4,171.97 arc(182.34,171.98) 182.28,172.02 182.18,172.12 arc(182.17,172.13) 182.16,172.14 arc(182.14,172.18) 182.14,172.21 182.14,172.57 182.23,172.67 182.23,172.69
  SIG7 w0.16: YJ22.B3 48.3,52.75 arc(48.25,53.01) 48.1,53.24 47.75,53.58 arc(47.57,53.85) 47.51,54.16 47.51,54.48 arc(47.51,54.54) 47.49,54.61 arc(47.45,54.7) 47.39,54.77 47.35,54.81 47.26,54.9 arc(47.14,54.98) 46.99,55.01 35.51,55.01 arc(35.15,55.09) 34.84,55.29 31.98,58.15 arc(31.78,58.46) 31.7,58.82 31.7,69.51 arc(31.78,69.87) 31.98,70.17 38.43,76.62 arc(38.52,76.75) 38.54,76.89 38.54,79.14 arc(38.62,79.5) 38.82,79.81 41.37,82.36 arc(41.53,82.6) 41.59,82.89 41.59,88.62 arc(41.66,88.97) 41.87,89.28 61.28,108.69 arc(61.58,108.89) 61.94,108.96 88.32,108.96 arc(88.53,109.01) 88.72,109.13 107.6,128.01 arc(107.72,128.19) 107.76,128.4 107.76,134.08 arc(107.83,134.44) 108.04,134.75 147.15,173.86 arc(147.46,174.07) 147.82,174.14 158.48,174.14 arc(158.69,174.18) 158.88,174.3 160.5,175.93 arc(160.8,176.13) 161.16,176.2 179.99,176.2 arc(180.35,176.13) 180.66,175.93 181.96,174.63 arc(182.16,174.32) 182.23,173.96 182.23,172.69
FC4_TDP2: length 229.4
  TOP w0.147: U1.CB50 181.05,167.89 arc(180.92,168.21) v4(180.6,168.34)
  SIG6 w0.112: v4(180.6,168.34) 180.79,168.34 arc(180.84,168.35) 180.88,168.38 180.91,168.41 arc(180.94,168.45) 180.95,168.5 180.95,168.64 arc(180.91,168.73) 180.82,168.77 180.32,168.77 arc(180.2,168.8) 180.1,168.87 180.04,168.92 arc(179.97,169.02) 179.95,169.15 179.95,172.57 179.86,172.67 179.86,172.69
  SIG6 w0.16: YJ22.B34 46.85,57.97 arc(46.96,58.14) 47,58.34 47,58.52 arc(46.9,58.76) 46.66,58.86 45.76,58.86 arc(45.58,58.88) 45.42,58.94 arc(45.31,59) 45.22,59.08 45.13,59.17 arc(44.88,59.34) 44.59,59.39 35.44,59.39 arc(35.41,59.4) 35.37,59.4 arc(35.12,59.47) 34.91,59.62 33.63,60.9 arc(33.46,61.14) 33.4,61.44 33.4,67.18 arc(33.46,67.48) 33.63,67.72 35.53,69.62 arc(35.77,69.79) 36.07,69.85 36.55,69.85 36.77,69.63 37.25,69.63 37.47,69.85 38.43,69.85 arc(38.79,69.92) 39.1,70.12 39.39,70.41 39.72,70.41 40.04,70.72 40.04,71.06 40.38,71.4 40.72,71.4 41.03,71.72 41.03,72.05 41.37,72.39 41.71,72.39 42.02,72.71 42.02,73.05 42.36,73.38 42.7,73.38 43.01,73.7 43.01,74.04 43.35,74.38 43.69,74.38 44.01,74.69 44.01,75.03 45,76.02 arc(45.2,76.33) 45.28,76.69 45.28,77.9 45.5,78.12 45.5,78.6 45.28,78.82 45.28,89.02 arc(45.32,89.23) 45.44,89.41 58.6,102.58 arc(58.79,102.7) 59,102.74 85.02,102.74 arc(85.38,102.81) 85.69,103.02 109.96,127.29 arc(110.21,127.66) 110.3,128.1 110.3,130.23 arc(110.36,130.53) 110.52,130.77 151.08,171.33 arc(151.33,171.5) 151.62,171.56 160.21,171.56 arc(160.65,171.64) 161.02,171.89 162.69,173.57 arc(162.88,173.69) 163.09,173.73 179.18,173.73 arc(179.4,173.69) 179.58,173.57 179.69,173.46 arc(179.81,173.27) 179.86,173.06 179.86,172.69
FC4_TDP3: length 232.1
  TOP w0.147: v4(181.5,170.34) 181.55,170.34 U1.CD49
  SIG7 w0.112: v4(181.5,170.34) 181.31,170.34 arc(181.2,170.39) 181.15,170.51 181.15,170.58 arc(181.03,170.86) 180.76,170.97 180.41,170.97 arc(180.35,170.98) 180.29,171.02 180.19,171.12 arc(180.18,171.13) 180.17,171.14 arc(180.16,171.18) 180.15,171.21 180.15,172.57 180.24,172.67 180.24,172.69
  SIG7 w0.16: YJ22.B36 48.3,56.82 arc(48.26,57.02) 48.15,57.18 48.08,57.26 47.9,57.43 47.75,57.58 arc(47.57,57.85) 47.51,58.16 47.51,58.48 arc(47.51,58.53) 47.5,58.58 arc(47.49,58.59) 47.49,58.61 arc(47.45,58.7) 47.39,58.77 47.35,58.81 47.26,58.9 arc(47.14,58.98) 46.99,59.01 35.7,59.01 arc(35.34,59.09) 35.03,59.29 33.3,61.02 arc(33.09,61.33) 33.02,61.69 33.02,67.9 arc(33.09,68.26) 33.3,68.57 34.68,69.95 arc(34.99,70.16) 35.35,70.23 38.79,70.23 arc(39,70.27) 39.19,70.39 44.73,75.94 arc(44.85,76.12) 44.89,76.33 44.89,89.02 arc(44.97,89.38) 45.17,89.68 58.34,102.85 arc(58.64,103.05) 59,103.12 85.4,103.12 arc(85.61,103.16) 85.79,103.29 109.75,127.25 arc(109.88,127.43) 109.92,127.64 109.92,133.32 arc(109.99,133.68) 110.19,133.98 148.76,172.55 arc(149.06,172.75) 149.42,172.82 159.07,172.82 arc(159.28,172.86) 159.46,172.99 160.32,173.84 arc(160.63,174.05) 160.99,174.12 179.06,174.12 arc(179.42,174.05) 179.72,173.84 180.08,173.49 arc(180.2,173.31) 180.24,173.1 180.24,172.69
FC5_RDN0: length 212
  TOP w0.147: v4(177.6,171.34) 177.68,171.34 arc(177.76,171.33) 177.83,171.28 177.91,171.2 arc(178.01,171.04) 178.05,170.86 U1.CE53
  SIG8 w0.112: v4(177.6,171.34) 177.73,171.47 arc(177.89,171.72) 177.95,172.01 177.95,172.57 177.86,172.67 177.86,172.69
  SIG8 w0.16: 177.86,172.69 177.86,175.28 arc(177.83,175.42) 177.75,175.55 177.59,175.7 arc(177.47,175.79) 177.32,175.82 165.27,175.82 arc(164.96,175.76) 164.7,175.58 160.29,171.17 159.73,170.61 arc(158.49,169.78) 157.04,169.49 152.54,169.49 arc(152.24,169.43) 151.98,169.26 112.69,129.97 arc(112.52,129.71) 112.46,129.41 112.46,127.3 arc(112.31,126.55) 111.89,125.92 89.06,103.09 arc(88.67,102.83) 88.22,102.74 65.04,102.74 arc(64.73,102.68) 64.47,102.51 53.62,91.66 arc(53.24,91.4) 52.79,91.31 48.05,91.31 arc(47.74,91.25) 47.49,91.08 45.26,88.85 arc(45.08,88.59) 45.02,88.28 45.02,83.39 45.25,83.16 45.25,82.6 45.02,82.37 45.02,81.86 45.25,81.63 45.25,81.07 45.02,80.85 45.02,80.34 45.25,80.11 45.25,79.55 45.02,79.32 45.02,78.81 45.22,78.61 45.22,78 45.02,77.8 45.02,77.07 arc(44.93,76.62) 44.68,76.23 44.33,75.88 44.33,75.53 43.97,75.17 43.61,75.17 43.25,74.81 43.25,74.45 42.89,74.09 42.53,74.09 42.17,73.73 42.17,73.37 41.81,73.01 41.45,73.01 34.87,66.43 arc(34.7,66.17) 34.63,65.86 34.63,64.59 arc(34.7,64.28) 34.87,64.03 35.27,63.63 arc(35.52,63.46) 35.83,63.39 37.39,63.39 arc(37.68,63.34) 37.93,63.17 38.16,62.94 arc(38.25,62.88) 38.35,62.86 39.44,62.86 arc(39.59,62.83) 39.72,62.74 arc(39.78,62.65) 39.8,62.54 39.8,62.35 arc(39.76,62.14) 39.65,61.97 YJ22.A14
FC5_RDN1: length 208.5
  TOP w0.147: v4(175.5,171.34) 175.55,171.34 U1.CE55
  SIG9 w0.112: v4(175.5,171.34) 175.5,171.35 175.37,171.48 arc(175.21,171.73) 175.15,172.02 175.15,172.6 arc(175.16,172.66) 175.19,172.71 175.2,172.72 arc(175.23,172.76) 175.24,172.81 175.24,172.87
  SIG9 w0.16: 175.24,172.87 175.24,174.52 arc(175.15,174.96) 174.9,175.33 174.37,175.86 arc(174,176.11) 173.56,176.2 165.25,176.2 arc(164.81,176.11) 164.44,175.86 162.57,173.99 160.7,172.12 arc(160.57,172.04) 160.43,172.01 154.63,172.01 arc(154.2,171.92) 153.83,171.67 112.41,130.26 arc(112.23,130.02) 112.12,129.74 arc(112.09,129.69) 112.08,129.64 112.08,126.81 arc(112.05,126.66) 111.97,126.54 87.29,101.86 arc(86.3,101.2) 85.13,100.96 63.02,100.96 arc(62.46,100.85) 61.98,100.53 48.8,87.35 arc(48.79,87.33) 48.77,87.32 arc(48.63,87.01) 48.58,86.68 48.58,76.13 arc(48.52,75.84) 48.35,75.59 45.37,72.61 arc(45.12,72.45) 44.83,72.39 37.72,72.39 arc(37.28,72.3) 36.91,72.05 34,69.15 arc(33.75,68.78) 33.67,68.34 33.67,67.29 arc(33.75,66.86) 34,66.48 34.11,66.37 arc(34.2,66.25) 34.23,66.1 34.23,64.41 arc(34.31,63.97) 34.56,63.6 35.35,62.82 35.39,62.77 arc(35.45,62.7) 35.49,62.62 arc(35.49,62.6) 35.5,62.58 arc(35.51,62.53) 35.51,62.48 35.51,62.2 35.51,62.32 35.51,62.16 arc(35.57,61.85) 35.75,61.58 36.13,61.21 arc(36.26,61.02) 36.3,60.79 YJ22.A18
FC5_RDN2: length 199.2
  TOP w0.147: U1.CC53 178.05,168.86 arc(178.01,169.04) 177.91,169.2 177.83,169.28 arc(177.76,169.33) 177.68,169.34 v4(177.6,169.34)
  SIG8 w0.112: v4(177.6,169.34) 177.82,169.34 arc(177.86,169.35) 177.9,169.37 177.92,169.4 arc(177.94,169.43) 177.95,169.47 177.95,169.67 arc(177.92,169.74) 177.85,169.77 177.39,169.77 arc(177.26,169.79) 177.16,169.86 177.04,169.98 arc(176.97,170.08) 176.95,170.21 176.95,172.57 176.86,172.67 176.86,172.69
  SIG8 w0.16: YJ22.A25 39.65,65.97 arc(39.76,66.14) 39.8,66.34 39.8,66.45 arc(39.78,66.56) 39.72,66.65 39.66,66.71 arc(39.5,66.82) 39.3,66.86 38.53,66.86 arc(38.36,66.93) 38.29,67.1 38.29,67.76 arc(38.32,67.91) 38.4,68.03 38.76,68.39 39.12,68.39 39.48,68.75 39.48,69.11 39.84,69.47 40.2,69.47 40.56,69.82 40.56,70.18 41.26,70.88 arc(41.52,71.06) 41.82,71.12 43.9,71.12 arc(44.35,71.21) 44.73,71.46 45.08,71.81 45.36,71.81 45.8,72.25 45.8,72.53 46.16,72.89 46.47,72.89 46.88,73.3 46.88,73.61 47.24,73.97 47.55,73.97 47.96,74.38 47.96,74.69 48.62,75.35 arc(48.87,75.73) 48.96,76.16 48.96,83.33 arc(49.02,83.63) 49.19,83.89 65.65,100.35 arc(65.91,100.52) 66.21,100.58 88.98,100.58 arc(89.43,100.67) 89.82,100.93 113.87,124.98 arc(114.42,125.81) 114.62,126.79 114.62,128.6 arc(114.68,128.9) 114.85,129.16 152.84,167.15 arc(153.1,167.32) 153.4,167.38 156.91,167.38 arc(159,167.75) 160.85,168.81 arc(161.05,168.99) 161.25,169.18 165.56,173.5 arc(165.82,173.67) 166.13,173.73 171.44,173.73 171.69,173.48 172.2,173.48 172.45,173.73 173.16,173.73 173.42,173.48 173.93,173.48 174.18,173.73 174.82,173.73 175.07,173.48 175.58,173.48 175.83,173.73 176.41,173.73 arc(176.55,173.7) 176.67,173.62 176.74,173.55 arc(176.83,173.43) 176.86,173.28 176.86,172.69
FC5_RDN3: length 201.7
  TOP w0.147: v4(175.5,169.34) 175.55,169.34 U1.CC55
  SIG9 w0.112: 174.24,172.87 174.14,172.77 174.14,170.21 arc(174.15,170.16) 174.18,170.12 174.3,170 arc(174.34,169.97) 174.39,169.96 174.85,169.96 arc(175.06,169.88) 175.15,169.67 175.15,169.47 arc(175.16,169.42) 175.18,169.38 175.19,169.38 arc(175.23,169.35) 175.28,169.34 v4(175.5,169.34)
  SIG9 w0.16: YJ22.A21 36.3,64.81 arc(36.26,65.02) 36.14,65.2 35.75,65.58 arc(35.57,65.85) 35.51,66.16 35.51,66.29 35.51,66.26 35.51,66.48 arc(35.51,66.53) 35.5,66.58 arc(35.46,66.69) 35.39,66.77 35.35,66.82 35.17,66.99 arc(35.04,67.19) 34.99,67.43 34.99,67.62 arc(35.05,67.95) 35.24,68.22 36.53,69.51 arc(36.9,69.76) 37.34,69.85 45.64,69.85 arc(45.93,69.91) 46.18,70.07 50.56,74.46 arc(50.73,74.7) 50.79,74.99 50.79,85.74 arc(50.85,86.03) 51.01,86.28 63.07,98.34 arc(63.58,98.68) 64.18,98.8 86.87,98.8 arc(87.16,98.86) 87.41,99.03 114.01,125.63 arc(114.18,125.88) 114.24,126.17 114.24,128.74 arc(114.29,129.04) 114.46,129.28 154.88,169.7 arc(155.12,169.87) 155.42,169.92 161.13,169.92 arc(161.43,169.98) 161.67,170.15 165.42,173.89 arc(165.66,174.06) 165.96,174.11 173.47,174.11 arc(174.02,173.89) 174.24,173.35 174.24,173.26 174.24,172.87
FC5_RDP0: length 212
  TOP w0.147: U1.CE52 178.55,171.34 v4(178.5,171.34)
  SIG8 w0.112: 178.24,172.69 178.24,172.67 178.15,172.57 178.15,172.01 arc(178.21,171.72) 178.37,171.47 v4(178.5,171.34)
  SIG8 w0.16: 178.24,172.69 178.24,175.28 arc(178.18,175.57) 178.02,175.82 177.86,175.97 arc(177.61,176.14) 177.32,176.2 165.27,176.2 arc(164.82,176.11) 164.44,175.85 160.02,171.44 159.74,171.16 159.46,170.88 arc(158.35,170.13) 157.04,169.87 152.54,169.87 arc(152.09,169.78) 151.71,169.53 112.42,130.24 arc(112.17,129.86) 112.08,129.41 112.08,127.3 arc(111.96,126.7) 111.62,126.19 88.79,103.36 arc(88.53,103.18) 88.22,103.12 65.04,103.12 arc(64.59,103.03) 64.2,102.78 53.35,91.93 arc(53.09,91.75) 52.79,91.69 48.05,91.69 arc(47.6,91.6) 47.22,91.35 44.99,89.12 arc(44.73,88.73) 44.64,88.28 44.64,77.07 arc(44.58,76.76) 44.41,76.5 34.6,66.7 arc(34.34,66.31) 34.25,65.86 34.25,64.59 arc(34.34,64.14) 34.6,63.76 35,63.36 arc(35.38,63.1) 35.83,63.01 37.39,63.01 arc(37.54,62.98) 37.66,62.9 37.75,62.82 37.79,62.77 arc(37.84,62.71) 37.88,62.64 arc(37.89,62.62) 37.89,62.61 arc(37.89,62.61) 37.89,62.6 arc(37.91,62.54) 37.91,62.48 37.91,62.07 arc(37.96,61.84) 38.09,61.65 38.33,61.41 38.62,61.12 arc(38.68,61.03) 38.7,60.92 YJ22.A15
FC5_RDP1: length 208.5
  TOP w0.147: U1.CE56 175.05,170.89 arc(174.92,171.21) v4(174.6,171.34)
  SIG9 w0.112: 174.86,172.87 174.86,172.78 arc(174.87,172.72) 174.9,172.67 174.9,172.67 arc(174.94,172.62) 174.95,172.56 174.95,172.01 arc(174.89,171.72) 174.73,171.47 v4(174.6,171.34)
  SIG9 w0.16: 174.86,172.87 174.86,174.52 arc(174.8,174.81) 174.63,175.06 174.1,175.59 arc(173.85,175.76) 173.56,175.82 173.05,175.82 172.85,175.61 172.34,175.61 172.14,175.82 171.63,175.82 171.43,175.61 170.92,175.61 170.72,175.82 170.19,175.82 169.99,175.61 169.48,175.61 169.28,175.82 168.77,175.82 168.57,175.61 168.06,175.61 167.86,175.82 165.25,175.82 arc(164.96,175.76) 164.71,175.59 160.97,171.85 arc(160.72,171.68) 160.43,171.63 154.63,171.63 arc(154.34,171.57) 154.1,171.4 112.68,129.99 arc(112.56,129.83) 112.48,129.64 arc(112.47,129.55) 112.46,129.45 112.46,126.81 arc(112.4,126.51) 112.24,126.27 87.56,101.59 arc(86.44,100.84) 85.13,100.58 63.02,100.58 arc(62.6,100.5) 62.25,100.26 49.09,87.1 arc(48.99,86.9) 48.96,86.68 48.96,76.13 arc(48.87,75.69) 48.62,75.32 45.64,72.34 arc(45.27,72.09) 44.83,72.01 43.7,72.01 43.42,71.73 42.96,71.73 42.68,72.01 42.18,72.01 41.9,71.73 41.44,71.73 41.16,72.01 40.65,72.01 40.37,71.73 39.92,71.73 39.64,72.01 39.13,72.01 38.87,71.75 38.37,71.75 38.11,72.01 37.72,72.01 arc(37.43,71.95) 37.18,71.78 34.27,68.88 arc(34.11,68.63) 34.05,68.34 34.05,67.29 arc(34.11,67) 34.27,66.75 34.38,66.64 arc(34.55,66.39) 34.61,66.1 34.61,64.41 arc(34.67,64.12) 34.83,63.87 35.51,63.19 35.71,63 arc(35.86,62.9) 36.03,62.86 37.06,62.86 arc(37.3,62.76) 37.4,62.52 37.4,62.34 arc(37.36,62.14) 37.25,61.97 YJ22.A17
FC5_RDP2: length 199.2
  TOP w0.147: U1.CC52 178.55,169.34 v4(178.5,169.34)
  SIG8 w0.112: v4(178.5,169.34) 178.28,169.34 arc(178.23,169.35) 178.19,169.38 178.18,169.38 arc(178.16,169.43) 178.15,169.47 178.15,169.67 arc(178.06,169.88) 177.85,169.96 177.39,169.96 arc(177.34,169.97) 177.3,170 177.18,170.12 arc(177.15,170.16) 177.14,170.21 177.14,172.57 177.24,172.67 177.24,172.69
  SIG8 w0.16: YJ22.A24 38.7,64.78 arc(38.65,65.01) 38.52,65.21 38.07,65.67 arc(37.95,65.84) 37.91,66.04 37.91,66.48 37.91,66.67 37.91,67.76 arc(37.97,68.05) 38.13,68.3 40.99,71.15 arc(41.37,71.41) 41.82,71.5 43.9,71.5 arc(44.2,71.56) 44.46,71.73 48.35,75.62 arc(48.52,75.87) 48.58,76.16 48.58,83.33 arc(48.67,83.78) 48.92,84.16 65.38,100.62 arc(65.76,100.87) 66.21,100.96 88.98,100.96 arc(89.29,101.02) 89.55,101.2 113.6,125.25 arc(114.07,125.95) 114.24,126.79 114.24,128.6 arc(114.33,129.05) 114.58,129.43 152.57,167.42 arc(152.95,167.67) 153.4,167.76 156.91,167.76 arc(158.87,168.11) 160.6,169.11 arc(160.79,169.27) 160.98,169.45 161.27,169.75 161.85,170.32 165.29,173.77 arc(165.68,174.02) 166.13,174.11 176.41,174.11 arc(176.7,174.06) 176.94,173.89 177.01,173.82 arc(177.18,173.57) 177.24,173.28 177.24,172.69
FC5_RDP3: length 201.7
  TOP w0.147: U1.CC56 175.05,168.89 arc(174.92,169.21) v4(174.6,169.34)
  SIG9 w0.112: v4(174.6,169.34) 174.82,169.34 arc(174.86,169.35) 174.9,169.37 174.92,169.4 arc(174.94,169.43) 174.95,169.47 174.95,169.67 arc(174.92,169.74) 174.85,169.77 174.39,169.77 arc(174.26,169.79) 174.16,169.86 174.04,169.98 arc(173.97,170.08) 173.95,170.21 173.95,172.79 173.86,172.87
  SIG9 w0.16: YJ22.A22 37.25,65.97 arc(37.36,66.14) 37.4,66.34 37.4,66.52 arc(37.3,66.76) 37.06,66.86 36.16,66.86 arc(35.86,66.92) 35.62,67.08 35.44,67.26 arc(35.39,67.34) 35.37,67.43 35.37,67.62 arc(35.41,67.8) 35.51,67.95 36.8,69.24 arc(37.04,69.41) 37.34,69.47 37.84,69.47 38.1,69.21 38.61,69.21 38.86,69.47 39.37,69.47 39.62,69.21 40.13,69.21 40.38,69.47 40.89,69.47 41.15,69.21 41.65,69.21 41.91,69.47 42.42,69.47 42.67,69.21 43.18,69.21 43.43,69.47 43.94,69.47 44.19,69.21 44.73,69.21 44.98,69.47 45.64,69.47 arc(46.08,69.55) 46.45,69.8 46.81,70.16 47.19,70.16 47.58,70.55 47.58,70.93 47.94,71.29 48.2,71.29 48.58,71.67 48.58,71.94 50.83,74.19 arc(51.08,74.56) 51.17,74.99 51.17,85.74 arc(51.2,85.89) 51.28,86.01 63.34,98.07 arc(63.73,98.33) 64.18,98.42 86.87,98.42 arc(87.31,98.51) 87.68,98.76 114.28,125.36 arc(114.53,125.73) 114.62,126.17 114.62,128.74 arc(114.65,128.89) 114.73,129.01 155.15,169.43 arc(155.27,169.51) 155.42,169.54 161.13,169.54 arc(161.57,169.63) 161.94,169.88 165.69,173.62 arc(165.81,173.7) 165.96,173.73 173.47,173.73 arc(173.75,173.62) 173.86,173.35 173.86,173.23 173.86,172.87
FC5_TDN0: length 206.1
  TOP w0.147: v4(167.55,172.29) 167.6,172.29 arc(167.92,172.16) U1.CF63
  SIG7 w0.112: v4(167.55,172.29) 167.37,172.11 arc(167.18,171.98) 166.96,171.94 165.18,171.94 165.09,172.03 165.06,172.03
  SIG7 w0.16: YJ22.A3 48.3,60.76 arc(48.25,61.01) 48.11,61.23 47.75,61.58 arc(47.57,61.85) 47.51,62.16 47.51,62.48 arc(47.51,62.53) 47.5,62.58 arc(47.49,62.59) 47.49,62.6 arc(47.45,62.7) 47.39,62.77 47.35,62.81 47.34,62.83 47.26,62.9 arc(47.14,62.98) 46.99,63.01 35.86,63.01 arc(35.41,63.1) 35.03,63.36 34.69,63.7 arc(34.43,64.08) 34.34,64.53 34.34,66.07 arc(34.43,66.53) 34.69,66.91 35.5,67.72 arc(35.88,67.98) 36.34,68.07 39.16,68.07 arc(40.02,68.24) 40.75,68.73 46.7,74.67 46.76,74.74 arc(47.14,74.99) 47.59,75.08 arc(47.82,75.13) 48.02,75.26 48.34,75.58 arc(48.52,75.84) 48.58,76.15 48.58,86.66 arc(48.67,87.11) 48.92,87.5 62.04,100.62 arc(62.43,100.87) 62.88,100.96 86.07,100.96 arc(86.37,101.02) 86.63,101.2 111.84,126.41 arc(112.02,126.67) 112.08,126.97 112.08,132.38 arc(112.17,132.83) 112.42,133.22 150.36,171.16 arc(150.75,171.41) 151.2,171.5 159.9,171.5 arc(160.05,171.53) 160.17,171.62 160.25,171.69 arc(160.63,171.94) 161.08,172.03 165.06,172.03
FC5_TDN1: length 204.3
  TOP w0.147: v4(169.55,171.39) 169.55,171.34 U1.CE61
  SIG6 w0.112: v4(169.55,171.39) 169.55,171.68 arc(169.51,171.77) 169.42,171.8 169.25,171.8 arc(169.16,171.77) 169.12,171.68 169.12,171.11 arc(169.09,170.99) 169.02,170.88 168.97,170.83 arc(168.87,170.76) 168.74,170.73 163.49,170.73 arc(163.23,170.68) 163,170.53 162.84,170.36 162.84,170.23 162.82,170.21
  SIG6 w0.16: 162.82,170.21 162.41,169.81 arc(162.04,169.56) 161.61,169.48 152.49,169.48 arc(152.2,169.42) 151.95,169.25 112.62,129.93 arc(112.5,129.74) 112.46,129.53 112.46,127.24 arc(112.37,126.81) 112.12,126.43 86.55,100.86 arc(86.24,100.65) 85.88,100.58 62.78,100.58 arc(62.57,100.54) 62.38,100.42 49.12,87.16 arc(49,86.97) 48.96,86.76 48.96,75.63 arc(48.87,75.19) 48.62,74.82 44.29,70.49 44.29,70.2 43.93,69.84 43.64,69.84 43.3,69.5 43.3,69.24 42.91,68.85 42.65,68.85 42.31,68.51 42.31,68.24 41.92,67.85 41.66,67.85 41.32,67.52 arc(40.95,67.27) 40.51,67.18 36.27,67.18 arc(36.05,67.14) 35.87,67.02 34.89,66.03 arc(34.76,65.85) 34.72,65.63 34.72,64.61 arc(34.76,64.39) 34.89,64.21 35.59,63.51 arc(35.6,63.5) 35.61,63.48 arc(35.73,63.42) 35.86,63.39 44.59,63.39 arc(44.88,63.34) 45.13,63.17 45.22,63.08 arc(45.46,62.92) 45.76,62.86 46.66,62.86 arc(46.9,62.76) 47,62.52 47,62.34 arc(46.96,62.14) 46.85,61.97 YJ22.A5
FC5_TDN2: length 181
  TOP w0.147: v4(166.55,170.29) 166.6,170.29 arc(166.92,170.16) U1.CD64
  SIG7 w0.112: 163.28,171.02 163.31,171.02 163.4,170.93 165.71,170.93 arc(165.86,170.9) 165.98,170.82 166,170.8 arc(166.09,170.67) 166.12,170.52 166.12,170.07 arc(166.16,169.98) 166.25,169.94 166.38,169.94 arc(166.5,169.99) 166.55,170.1 v4(166.55,170.29)
  SIG7 w0.16: YJ22.A33 45.9,64.73 arc(45.85,65.01) 45.69,65.25 45.35,65.58 arc(45.17,65.85) 45.11,66.16 45.11,66.48 arc(45.11,66.53) 45.1,66.58 arc(45.09,66.6) 45.09,66.62 arc(45.05,66.7) 44.99,66.77 44.95,66.82 44.72,67.04 arc(44.4,67.49) 44.24,68.01 44.23,68.02 44.23,68.07 arc(44.3,68.39) 44.48,68.66 50.48,74.65 arc(50.67,74.94) 50.74,75.29 50.74,85.69 arc(50.79,85.98) 50.96,86.23 63.31,98.58 arc(63.56,98.75) 63.85,98.8 87.02,98.8 arc(87.17,98.83) 87.29,98.92 114.12,125.75 arc(114.21,125.87) 114.24,126.02 114.24,131.79 arc(114.29,132.08) 114.46,132.33 151.78,169.65 arc(152.03,169.81) 152.32,169.87 160.99,169.87 arc(161.13,169.9) 161.26,169.98 162.07,170.8 arc(162.32,170.96) 162.61,171.02 163.28,171.02
FC5_TDN3: length 178.4
  TOP w0.147: v4(168.55,169.39) 168.55,169.34 U1.CC62
  SIG6 w0.112: v4(168.55,169.39) 168.55,169.57 arc(168.54,169.64) 168.5,169.69 arc(168.45,169.73) 168.4,169.74 168.25,169.74 arc(168.16,169.71) 168.12,169.62 168.12,169.13 arc(168.09,169) 168.02,168.9 167.97,168.85 arc(167.87,168.78) 167.74,168.75 164.56,168.75 arc(164.32,168.7) 164.11,168.56 163.95,168.41 163.95,168.28 163.93,168.26
  SIG6 w0.16: YJ22.A37 49.25,65.97 arc(49.36,66.14) 49.4,66.34 49.4,66.52 arc(49.3,66.76) 49.06,66.86 48.1,66.86 arc(47.95,66.92) 47.89,67.07 47.89,67.76 48.07,67.94 48.07,68.5 47.89,68.68 47.89,70.09 arc(47.95,70.38) 48.11,70.63 48.45,70.97 48.71,70.97 49.11,71.37 49.11,71.62 49.45,71.96 49.7,71.96 50.1,72.36 50.1,72.61 50.84,73.36 arc(51.05,73.66) 51.12,74.02 51.12,74.43 51.3,74.61 51.3,75.17 51.12,75.35 51.12,85.51 arc(51.18,85.8) 51.34,86.05 63.49,98.2 arc(63.74,98.36) 64.03,98.42 86.81,98.42 arc(87.25,98.51) 87.62,98.76 114.28,125.42 arc(114.53,125.79) 114.62,126.23 114.62,128.58 arc(114.68,128.87) 114.84,129.12 152.9,167.19 arc(153.15,167.35) 153.44,167.41 162.37,167.41 arc(163.03,167.54) 163.59,167.92 163.93,168.26
FC5_TDP0: length 206.1
  TOP w0.147: U1.CE63 167.55,171.34 v4(167.55,171.39)
  SIG7 w0.112: v4(167.55,171.39) 167.37,171.58 arc(167.18,171.7) 166.96,171.74 165.18,171.74 165.09,171.65 165.06,171.65
  SIG7 w0.16: 165.06,171.65 161.08,171.65 arc(160.77,171.59) 160.52,171.42 160.44,171.35 arc(160.2,171.18) 159.9,171.12 151.2,171.12 arc(150.89,171.06) 150.63,170.89 112.69,132.95 arc(112.52,132.69) 112.46,132.38 112.46,126.97 arc(112.37,126.52) 112.11,126.14 86.9,100.93 arc(86.52,100.67) 86.07,100.58 62.88,100.58 arc(62.57,100.52) 62.31,100.35 49.19,87.23 arc(49.02,86.97) 48.96,86.66 48.96,76.15 arc(48.87,75.7) 48.61,75.31 48.29,74.99 arc(47.97,74.77) 47.59,74.7 arc(47.29,74.64) 47.03,74.47 45.91,73.34 45.91,73.09 45.58,72.76 45.33,72.76 45,72.44 45,72.19 44.67,71.86 44.42,71.86 44.09,71.53 44.09,71.23 43.82,70.95 43.52,70.95 43.19,70.62 43.19,70.38 42.86,70.05 42.61,70.05 42.28,69.72 42.28,69.44 41.98,69.14 41.7,69.14 41.02,68.46 arc(40.17,67.89) 39.16,67.69 36.34,67.69 arc(36.03,67.63) 35.77,67.45 34.96,66.64 arc(34.78,66.38) 34.72,66.07 34.72,64.53 arc(34.78,64.23) 34.96,63.97 35.29,63.63 arc(35.55,63.46) 35.86,63.39 46.99,63.39 arc(47.28,63.34) 47.53,63.17 arc(47.87,62.94) 48.28,62.86 49.06,62.86 arc(49.3,62.76) 49.4,62.52 49.4,62.34 arc(49.36,62.14) 49.25,61.97 YJ22.A2
FC5_TDP1: length 204.3
  TOP w0.147: U1.CF61 170,171.84 arc(169.68,171.97) v4(169.55,172.29)
  SIG6 w0.112: 162.55,170.48 162.57,170.5 162.7,170.5 162.87,170.67 arc(163.15,170.86) 163.49,170.93 168.74,170.93 arc(168.79,170.94) 168.83,170.97 168.89,171.02 arc(168.91,171.06) 168.92,171.11 168.92,171.68 arc(169.02,171.91) 169.25,172 169.37,172 arc(169.41,172.01) 169.46,172.04 169.51,172.09 arc(169.54,172.13) 169.55,172.18 v4(169.55,172.29)
  SIG6 w0.16: 162.55,170.48 162.14,170.08 arc(161.9,169.92) 161.61,169.86 152.49,169.86 arc(152.05,169.77) 151.68,169.52 112.35,130.2 arc(112.15,129.89) 112.08,129.53 112.08,127.24 arc(112.02,126.95) 111.85,126.7 86.28,101.13 arc(86.1,101.01) 85.88,100.96 62.78,100.96 arc(62.42,100.89) 62.11,100.69 48.85,87.43 arc(48.65,87.12) 48.58,86.76 48.58,75.63 arc(48.52,75.34) 48.35,75.09 41.05,67.78 arc(40.8,67.62) 40.51,67.56 36.27,67.56 arc(35.91,67.49) 35.6,67.29 34.62,66.3 arc(34.41,65.99) 34.34,65.63 34.34,64.61 arc(34.41,64.25) 34.62,63.94 35.32,63.24 arc(35.34,63.21) 35.37,63.19 arc(35.6,63.06) 35.86,63.01 44.59,63.01 arc(44.74,62.98) 44.86,62.9 44.95,62.81 44.99,62.77 arc(45.06,62.69) 45.1,62.58 arc(45.11,62.53) 45.11,62.48 45.11,62.16 arc(45.17,61.85) 45.35,61.58 45.73,61.2 arc(45.86,61.02) 45.9,60.79 YJ22.A6
FC5_TDP2: length 181.1
  TOP w0.147: U1.CC64 166.55,169.34 v4(166.55,169.39)
  SIG7 w0.112: v4(166.55,169.39) 166.55,169.58 arc(166.5,169.7) 166.38,169.74 166.25,169.74 arc(166.02,169.84) 165.92,170.07 165.92,170.52 arc(165.91,170.59) 165.86,170.66 165.85,170.68 arc(165.78,170.72) 165.71,170.73 163.4,170.73 163.31,170.64 163.28,170.64
  SIG7 w0.16: 163.28,170.64 162.61,170.64 arc(162.46,170.61) 162.34,170.53 161.53,169.71 arc(161.28,169.55) 160.99,169.49 152.32,169.49 arc(152.17,169.46) 152.05,169.38 114.73,132.06 arc(114.65,131.94) 114.62,131.79 114.62,126.02 arc(114.56,125.73) 114.39,125.48 87.56,98.65 arc(87.31,98.48) 87.02,98.42 63.85,98.42 arc(63.7,98.39) 63.58,98.31 51.23,85.96 arc(51.15,85.84) 51.12,85.69 51.12,75.29 arc(51.02,74.8) 50.75,74.39 49.34,72.99 49.34,72.75 49.02,72.42 48.9,72.42 48.78,72.42 48.45,72.09 48.45,71.83 48.15,71.53 48,71.53 47.89,71.53 47.56,71.2 47.56,70.93 47.25,70.63 47.11,70.63 46.99,70.63 46.66,70.3 46.66,70.04 46.36,69.74 46.22,69.74 46.1,69.74 45.77,69.41 45.77,69.15 45.47,68.84 45.32,68.84 45.2,68.84 44.75,68.39 arc(44.65,68.24) 44.62,68.07 arc(44.74,67.66) 44.99,67.31 45.22,67.08 45.29,67.01 arc(45.46,66.9) 45.66,66.86 46.66,66.86 arc(46.9,66.76) 47,66.52 47,66.34 arc(46.96,66.14) 46.85,65.97 YJ22.A34
FC5_TDP3: length 178.4
  TOP w0.147: U1.CD62 169,169.84 arc(168.68,169.97) v4(168.55,170.29)
  SIG6 w0.112: v4(168.55,170.29) 168.23,170 arc(168.17,169.95) 168.1,169.91 arc(167.97,169.79) 167.92,169.62 167.92,169.13 arc(167.91,169.08) 167.89,169.04 167.83,168.99 arc(167.79,168.96) 167.74,168.95 164.56,168.95 arc(164.24,168.88) 163.97,168.7 163.81,168.55 163.68,168.55 163.66,168.53
  SIG6 w0.16: 163.66,168.53 163.32,168.18 arc(162.88,167.89) 162.37,167.79 153.44,167.79 arc(153.01,167.7) 152.63,167.46 114.57,129.39 arc(114.32,129.02) 114.24,128.58 114.24,126.23 arc(114.18,125.93) 114.01,125.69 87.35,99.03 arc(87.11,98.86) 86.81,98.8 64.03,98.8 arc(63.59,98.72) 63.22,98.47 51.07,86.32 arc(50.82,85.95) 50.74,85.51 50.74,74.02 arc(50.69,73.81) 50.57,73.63 47.85,70.9 arc(47.6,70.53) 47.51,70.09 47.51,66.16 arc(47.57,65.85) 47.75,65.58 48.14,65.19 arc(48.26,65.02) 48.3,64.81 YJ22.A36
FC6_7_PVDD0P8: length 5.4
  TOP w0.229: U1.BG48 v1(182.55,153.34) ; U1.BG49 v1(181.55,153.34)
  TOP w0.381: 153.01,172.32 C274.1 ; C274.1 154.2,172.32 ; C274.1 153.61,171.69
  BOTTOM w0.13: v1(157.67,168.65) v2(157.67,169.42)
  BOTTOM w0.381: C275.1 v1(182.55,153.34) ; C3320.1 v1(181.55,153.34)
  vias: v1(156.78,168.65)
