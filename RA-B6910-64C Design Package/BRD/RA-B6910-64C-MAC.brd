# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC47_TDP0: length 135.3
  TOP w0.147: U1.AK2 229.55,135.34 v4(229.55,135.29)
  SIG5 w0.112: v4(229.55,135.29) 229.55,135.07 arc(229.59,134.98) 229.68,134.94 229.84,134.94 arc(229.88,134.95) 229.93,134.98 229.94,134.99 arc(229.97,135.04) 229.99,135.11 229.99,135.54 arc(230.02,135.7) 230.1,135.83 arc(230.23,135.91) 230.39,135.94 231.97,135.94 232.06,136.04 232.09,136.04
  SIG5 w0.16: 232.09,136.04 234.93,136.04 arc(235.17,136) 235.38,135.89 arc(235.43,135.85) 235.47,135.81 236.01,135.27 arc(236.26,135.11) 236.55,135.05 246.59,135.05 arc(247.02,134.96) 247.39,134.71 274.29,107.82 arc(274.45,107.57) 274.51,107.28 274.51,100.64 arc(274.57,100.35) 274.73,100.1 280.89,93.95 arc(281.06,93.7) 281.11,93.41 281.11,91.37 arc(281.14,91.23) 281.23,91.1 284.97,87.36 arc(285.22,86.99) 285.31,86.55 285.31,76.13 arc(285.33,75.99) 285.42,75.86 290.81,70.47 arc(291.06,70.1) 291.15,69.66 291.15,61.05 arc(291.06,60.61) 290.81,60.24 285.82,55.25 arc(285.57,55.08) 285.28,55.03 273.35,55.03 arc(273.21,55) 273.08,54.91 273.03,54.86 arc(272.95,54.75) 272.91,54.64 arc(272.91,54.6) 272.91,54.57 272.91,53.97 arc(272.88,53.85) 272.81,53.75 272.28,53.21 arc(272.15,53.01) 272.1,52.78 YJ31.D3
FC47_TDP1: length 127.7
  TOP w0.147: v4(227.55,134.39) 227.55,134.48 arc(227.53,134.56) 227.49,134.62 227.41,134.7 arc(227.25,134.81) 227.07,134.84 U1.AJ4
  SIG4 w0.112: v4(227.55,134.39) 227.55,134.62 arc(227.59,134.71) 227.68,134.74 227.83,134.74 arc(227.89,134.73) 227.94,134.7 arc(227.97,134.65) 227.99,134.59 227.99,134.21 arc(228.02,134.03) 228.12,133.88 arc(228.28,133.78) 228.46,133.74 232.1,133.74 232.19,133.65 232.22,133.65
  SIG4 w0.16: YJ31.D34 273.55,57.97 arc(273.44,58.13) 273.41,58.32 273.41,58.58 arc(273.49,58.78) 273.68,58.86 274.58,58.86 arc(274.87,58.92) 275.12,59.08 275.16,59.13 275.21,59.18 arc(275.46,59.35) 275.75,59.41 285.34,59.41 arc(285.49,59.44) 285.61,59.52 285.97,59.88 285.97,60.21 286.36,60.6 286.69,60.6 287.05,60.96 287.05,61.29 287.44,61.67 287.77,61.67 288.37,62.27 arc(288.45,62.4) 288.48,62.54 288.48,63.05 288.23,63.31 288.23,63.81 288.48,64.07 288.48,64.58 288.23,64.83 288.23,65.34 288.48,65.59 288.48,68.36 arc(288.45,68.51) 288.37,68.63 281.07,75.93 arc(280.82,76.3) 280.73,76.74 280.73,86.45 arc(280.63,86.95) 280.35,87.37 arc(280.07,87.56) 279.74,87.63 279.58,87.63 arc(278.69,88) 278.32,88.89 278.32,91.82 arc(278.23,92.29) 277.96,92.69 267.88,102.76 arc(267.62,103.16) 267.53,103.63 267.53,110.61 arc(267.46,110.97) 267.26,111.26 243.98,134.54 arc(243.85,134.63) 243.71,134.66 234.2,134.66 arc(234.05,134.63) 233.93,134.54 233.37,133.98 arc(233,133.74) 232.56,133.65 232.22,133.65
FC47_TDP2: length 137.7
  TOP w0.147: v4(225.55,135.29) 225.55,135.34 U1.AK6
  SIG4 w0.112: 232.09,136.04 232.06,136.04 231.97,135.94 226.46,135.94 arc(226.28,135.91) 226.12,135.8 arc(226.02,135.65) 225.99,135.47 225.99,135.09 arc(225.97,135.04) 225.94,134.99 arc(225.89,134.95) 225.83,134.94 225.68,134.94 arc(225.59,134.98) 225.55,135.07 v4(225.55,135.29)
  SIG4 w0.16: YJ31.D6 274.5,52.77 arc(274.55,53.01) 274.69,53.22 275.21,53.75 arc(275.28,53.85) 275.31,53.97 275.31,54.57 arc(275.34,54.72) 275.43,54.86 275.48,54.91 arc(275.61,55) 275.75,55.03 285.03,55.03 arc(285.32,55.08) 285.57,55.25 290.92,60.61 arc(291.09,60.85) 291.15,61.15 291.15,69.18 arc(291.09,69.47) 290.92,69.72 285.53,75.11 arc(285.36,75.36) 285.31,75.65 285.31,86.71 arc(285.25,87) 285.08,87.25 281.34,90.99 arc(281.17,91.24) 281.11,91.53 281.11,93.44 arc(281.06,93.73) 280.89,93.98 274.73,100.14 arc(274.57,100.38) 274.51,100.67 274.51,107.28 arc(274.45,107.57) 274.29,107.82 245.17,136.93 arc(244.93,137.1) 244.64,137.16 233.91,137.16 arc(233.62,137.1) 233.37,136.93 232.6,136.17 arc(232.45,136.07) 232.28,136.04 232.09,136.04
FC47_TDP3: length 125.7
  TOP w0.147: v4(230.55,132.39) 230.55,132.49 arc(230.53,132.57) 230.48,132.65 230.42,132.71 arc(230.27,132.81) 230.1,132.84 U1.AG1
  SIG5 w0.112: v4(230.55,132.39) 230.55,132.62 arc(230.59,132.71) 230.68,132.74 230.84,132.74 arc(230.96,132.77) 231.07,132.84 231.08,132.85 arc(231.15,132.97) 231.18,133.11 231.18,133.54 arc(231.2,133.62) 231.24,133.69 arc(231.31,133.73) 231.39,133.75 231.86,133.75 231.95,133.65 231.98,133.65
  SIG5 w0.16: YJ31.D37 271.15,57.97 arc(271.04,58.13) 271.01,58.32 271.01,58.59 arc(271.09,58.78) 271.28,58.86 272.3,58.86 arc(272.48,58.9) 272.63,59 272.81,59.18 arc(273.06,59.35) 273.35,59.41 284.96,59.41 arc(285.11,59.44) 285.23,59.52 285.95,60.24 285.95,60.51 286.33,60.88 286.6,60.88 286.92,61.21 286.92,61.48 287.3,61.85 287.57,61.85 287.89,62.18 arc(287.97,62.3) 288,62.45 288,68.56 arc(287.94,68.85) 287.78,69.1 287.46,69.42 287.18,69.42 286.81,69.8 286.81,70.07 286.49,70.39 286.21,70.39 285.84,70.77 285.84,71.04 285.52,71.36 285.24,71.36 284.87,71.74 284.87,72.01 280.96,75.92 arc(280.79,76.17) 280.73,76.46 280.73,86.68 arc(280.68,86.97) 280.51,87.22 280.3,87.42 arc(280.08,87.57) 279.81,87.63 279.53,87.63 arc(279.09,87.71) 278.72,87.96 278.66,88.02 arc(278.41,88.39) 278.32,88.83 278.32,92.01 arc(278.26,92.3) 278.1,92.55 272.07,98.58 arc(271.9,98.83) 271.84,99.12 271.84,106.34 arc(271.79,106.63) 271.62,106.88 245.52,132.97 arc(245.28,133.14) 244.99,133.2 234.87,133.2 arc(234.43,133.28) 234.06,133.53 234.05,133.54 arc(233.93,133.63) 233.78,133.65 231.98,133.65
FC48_49_PVDD0P8: length 4.7
  TOP w0.229: U1.AR18 v1(213.55,141.34) ; U1.AU18 v1(213.55,143.34)
  TOP w0.381: C2722.1 240.82,150.85 ; C2722.1 240.22,151.48 ; C2722.1 239.62,150.85
  BOTTOM w0.381: C3317.1 213.06,142.86 v1(213.55,143.34) ; C3155.1 213.07,140.86 v1(213.55,141.34)
  vias: v1(239.2,152.02) v1(240.22,152.02)
FC48_63_PVDD1P8: length 13.6
  TOP w0.229: U1.BG22 v1(209.55,153.34) ; U1.BG20 v1(211.55,153.34) ; U1.BE18 v1(213.55,151.34) ; U1.BG28 v1(203.55,153.34) ; v1(206.5,153.37) 206.5,153.29 U1.BG25 ; U1.AW18 v1(213.55,145.34) ; U1.BB18 v1(213.55,148.34) ; U1.AT18 v1(213.55,142.34)
  TOP w0.381: 235.65,151.48 C2687.1 235.05,150.85
  TOP w0.508: L436.1 235.14,152.65
  BOTTOM w0.381: C3197.1 213.07,144.86 v1(213.55,145.34) ; C3014.1 214.03,150.86 v1(213.55,151.34) ; v1(213.55,148.34) 213.07,147.86 C2959.1 ; v1(203.55,153.34) 203.06,153.83 C3134.1 ; v1(211.55,153.34) 211.09,152.88 C2764.1 ; C3104.1 213.07,141.86 v1(213.55,142.34) ; v1(206.5,153.37) 206.61,153.37 C2678.1 ; C2841.1 209.09,152.88 v1(209.55,153.34)
  vias: v1(235.14,152.02) v1(236.03,152.02)
FC48_RDN0: length 134.3
  TOP w0.147: v4(218.55,137.39) 218.55,137.48 arc(218.53,137.56) 218.49,137.63 218.41,137.71 arc(218.26,137.81) 218.09,137.84 U1.AM13
  SIG8 w0.112: 231.89,137.65 231.86,137.65 231.77,137.74 226.47,137.74 arc(226.27,137.78) 226.1,137.9 226.08,137.92 arc(225.98,138.06) 225.95,138.23 225.95,138.42 arc(225.93,138.54) 225.85,138.65 arc(225.75,138.72) 225.62,138.75 219.54,138.75 arc(219.4,138.72) 219.29,138.64 219.25,138.61 arc(219.2,138.53) 219.18,138.44 219.18,138.06 arc(219.16,137.94) 219.09,137.84 arc(218.99,137.77) 218.87,137.74 218.65,137.74 arc(218.58,137.71) 218.55,137.64 v4(218.55,137.39)
  SIG8 w0.16: YJ34.D24 301.7,56.61 arc(301.62,57) 301.4,57.34 301.14,57.59 arc(300.97,57.85) 300.91,58.15 300.91,58.42 arc(300.9,58.53) 300.87,58.63 arc(300.82,58.73) 300.75,58.82 300.66,58.9 arc(300.54,58.98) 300.39,59.01 298.63,59.01 arc(298.19,59.1) 297.82,59.35 296.71,60.46 296.35,60.46 295.99,60.82 295.99,61.18 295.63,61.54 295.27,61.54 294.91,61.9 294.91,62.26 285.13,72.04 arc(284.88,72.41) 284.8,72.85 284.8,77.21 arc(284.77,77.35) 284.69,77.48 281.07,81.1 arc(280.82,81.47) 280.73,81.9 280.73,93.43 arc(280.7,93.58) 280.62,93.7 274.59,99.73 arc(274.34,100.1) 274.26,100.54 274.26,107 arc(274.2,107.29) 274.03,107.54 245.02,136.55 arc(244.77,136.72) 244.48,136.78 235.2,136.78 arc(234.85,136.83) 234.54,136.99 arc(234.46,137.05) 234.39,137.11 233.97,137.54 arc(233.84,137.62) 233.7,137.65 231.89,137.65
FC48_RDN1: length 130.9
  TOP w0.147: U1.AN9 222.55,138.34 v4(222.55,138.29)
  SIG9 w0.112: v4(222.55,138.29) 222.55,138.04 arc(222.58,137.97) 222.65,137.94 222.87,137.94 arc(222.99,137.92) 223.09,137.85 arc(223.16,137.75) 223.18,137.63 223.18,136.2 arc(223.2,136.1) 223.26,136.02 arc(223.35,135.96) 223.45,135.94 231.74,135.94 arc(231.86,135.96) 231.97,136.03
  SIG9 w0.16: 231.97,136.03 232.27,136.03 arc(232.7,135.95) 233.08,135.7 234.17,134.6 arc(234.29,134.52) 234.44,134.49 244.1,134.49 arc(244.53,134.4) 244.9,134.16 271.89,107.17 arc(272.14,106.8) 272.22,106.36 272.22,99.25 arc(272.28,98.95) 272.45,98.71 277.08,94.07 arc(277.25,93.83) 277.3,93.53 277.3,76.52 arc(277.33,76.38) 277.42,76.25 292.45,61.22 arc(292.64,60.98) 292.75,60.7 arc(292.78,60.65) 292.79,60.6 292.79,59.17 arc(292.82,59.02) 292.9,58.9 296.29,55.51 arc(296.41,55.42) 296.56,55.39 297.99,55.39 arc(298.28,55.34) 298.53,55.17 298.71,54.99 arc(298.86,54.9) 299.03,54.86 300.06,54.86 arc(300.3,54.76) 300.4,54.52 300.4,54.34 arc(300.36,54.14) 300.25,53.97 YJ34.D17
FC48_RDN2: length 134.3
  TOP w0.147: U1.AM11 220.09,137.84 arc(220.26,137.81) 220.41,137.71 220.49,137.63 arc(220.53,137.56) 220.55,137.48 v4(220.55,137.39)
  SIG8 w0.112: v4(220.55,137.39) 220.55,137.64 arc(220.58,137.71) 220.65,137.74 220.88,137.74 arc(220.92,137.73) 220.95,137.71 arc(220.98,137.68) 220.99,137.63 220.99,136.18 arc(221.02,136.01) 221.11,135.87 arc(221.25,135.78) 221.42,135.75 230.5,135.75 arc(230.79,135.69) 231.03,135.52 232.13,134.42 arc(232.38,134.26) 232.67,134.2 233.01,134.2 233.11,134.11 233.13,134.11
  SIG8 w0.16: 233.13,134.11 244.1,134.11 arc(244.39,134.05) 244.64,133.89 271.62,106.9 arc(271.79,106.65) 271.84,106.36 271.84,97.09 arc(271.93,96.65) 272.18,96.28 276.81,91.65 arc(276.89,91.52) 276.92,91.38 276.92,76.66 arc(277.01,76.22) 277.26,75.85 294.88,58.22 294.88,57.84 295.22,57.5 295.6,57.5 295.96,57.14 295.96,56.78 296.32,56.42 296.68,56.42 297.76,55.35 arc(298.13,55.1) 298.57,55.01 300.39,55.01 arc(300.54,54.98) 300.66,54.9 300.75,54.82 300.75,54.81 300.79,54.77 arc(300.85,54.7) 300.89,54.61 arc(300.91,54.54) 300.91,54.48 300.91,54.1 arc(300.96,53.84) 301.11,53.63 301.43,53.31 arc(301.63,53) 301.7,52.65 YJ34.D15
FC48_RDN3: length 124.5
  TOP w0.147: v4(224.55,138.29) 224.55,138.34 U1.AN7
  SIG9 w0.112: v4(224.55,138.29) 224.68,138.16 arc(224.92,138) 225.22,137.94 231.74,137.94 arc(231.86,137.96) 231.97,138.03
  SIG9 w0.16: 231.97,138.03 233.44,138.03 arc(233.73,137.97) 233.98,137.81 234.41,137.38 arc(234.57,137.26) 234.76,137.18 arc(234.85,137.16) 234.95,137.16 244.48,137.16 arc(244.91,137.07) 245.29,136.82 274.3,107.81 arc(274.55,107.43) 274.64,107 274.64,100.64 arc(274.7,100.35) 274.86,100.1 280.89,94.07 arc(281.06,93.83) 281.11,93.53 281.11,76.9 arc(281.17,76.61) 281.34,76.36 298.62,59.08 arc(298.86,58.92) 299.16,58.86 300.06,58.86 arc(300.3,58.76) 300.4,58.52 300.4,58.34 arc(300.36,58.14) 300.25,57.97 YJ34.D22
FC48_RDP0: length 134.3
  TOP w0.147: v4(218.55,138.29) 218.55,138.34 U1.AN13
  SIG8 w0.112: 231.89,138.03 231.86,138.03 231.77,137.94 226.47,137.94 arc(226.35,137.96) 226.24,138.03 226.22,138.05 arc(226.17,138.14) 226.15,138.23 226.15,138.23 226.15,138.42 arc(226.11,138.62) 225.99,138.79 arc(225.82,138.9) 225.62,138.94 219.54,138.94 arc(219.33,138.9) 219.15,138.78 219.12,138.75 arc(219.02,138.6) 218.99,138.44 218.99,138.06 arc(218.98,138.01) 218.95,137.97 arc(218.91,137.95) 218.87,137.94 218.65,137.94 arc(218.58,137.97) 218.55,138.04 v4(218.55,138.29)
  SIG8 w0.16: 231.89,138.03 233.7,138.03 arc(233.99,137.97) 234.24,137.81 234.66,137.38 arc(234.71,137.34) 234.76,137.3 arc(234.97,137.19) 235.2,137.16 244.48,137.16 arc(244.91,137.07) 245.29,136.82 274.3,107.81 arc(274.55,107.43) 274.64,107 274.64,100.54 274.64,100.54 arc(274.7,100.25) 274.86,100 280.89,93.97 arc(281.06,93.72) 281.11,93.43 281.11,81.9 arc(281.17,81.61) 281.34,81.36 284.96,77.75 arc(285.12,77.5) 285.18,77.21 285.18,72.85 arc(285.24,72.55) 285.4,72.31 298.09,59.62 arc(298.34,59.45) 298.63,59.39 300.39,59.39 arc(300.68,59.34) 300.93,59.17 301.11,58.99 arc(301.22,58.91) 301.35,58.87 arc(301.39,58.86) 301.42,58.86 302.3,58.86 arc(302.47,58.83) 302.62,58.73 302.72,58.63 arc(302.8,58.51) 302.83,58.37 302.83,58.31 arc(302.8,58.15) 302.71,58.02 302.51,57.82 YJ34.D25
FC48_RDP1: length 130.9
  TOP w0.147: v4(222.55,137.39) 222.55,137.48 arc(222.53,137.56) 222.49,137.62 222.41,137.7 arc(222.25,137.81) 222.07,137.84 U1.AM9
  SIG9 w0.112: v4(222.55,137.39) 222.55,137.64 arc(222.58,137.71) 222.65,137.74 222.87,137.74 arc(222.91,137.73) 222.95,137.71 arc(222.98,137.67) 222.99,137.63 222.99,136.2 arc(223.02,136.03) 223.12,135.88 arc(223.27,135.78) 223.45,135.74 231.72,135.74 arc(231.84,135.72) 231.94,135.65 231.97,135.65
  SIG9 w0.16: 231.97,135.65 232.27,135.65 arc(232.56,135.59) 232.81,135.43 233.9,134.33 arc(234.15,134.17) 234.44,134.11 244.1,134.11 arc(244.39,134.05) 244.64,133.89 271.62,106.9 arc(271.79,106.65) 271.84,106.36 271.84,99.25 arc(271.93,98.81) 272.18,98.44 276.81,93.8 arc(276.89,93.68) 276.92,93.53 276.92,76.52 arc(276.98,76.23) 277.15,75.98 288.95,64.18 290.03,63.1 290.03,63.1 290.75,62.38 291.11,62.02 291.11,62.02 291.83,61.31 292.18,60.95 arc(292.31,60.79) 292.38,60.6 arc(292.4,60.51) 292.41,60.41 292.41,59.17 arc(292.47,58.87) 292.63,58.63 293.73,57.53 293.73,57.17 294.09,56.81 294.45,56.81 294.89,56.37 294.89,55.98 295.28,55.6 295.66,55.6 296.02,55.24 arc(296.27,55.07) 296.56,55.01 297.99,55.01 arc(298.14,54.98) 298.26,54.9 298.35,54.82 298.39,54.77 arc(298.45,54.7) 298.49,54.62 arc(298.49,54.6) 298.5,54.59 arc(298.51,54.53) 298.51,54.48 298.51,54.07 arc(298.56,53.84) 298.69,53.65 299.21,53.13 arc(299.28,53.02) 299.3,52.91 YJ34.D18
FC48_RDP2: length 134.3
  TOP w0.147: v4(220.55,138.29) 220.55,138.34 U1.AN11
  SIG8 w0.112: v4(220.55,138.29) 220.55,138.04 arc(220.58,137.97) 220.65,137.94 220.88,137.94 arc(220.99,137.92) 221.09,137.85 arc(221.16,137.75) 221.18,137.63 221.18,136.18 arc(221.2,136.09) 221.25,136.01 arc(221.33,135.96) 221.42,135.94 230.5,135.94 arc(230.86,135.87) 231.17,135.66 232.27,134.56 arc(232.46,134.44) 232.67,134.4 233.01,134.4 233.11,134.49 233.13,134.49
  SIG8 w0.16: YJ34.D14 302.72,54.04 arc(302.78,54.13) 302.8,54.24 302.8,54.45 arc(302.77,54.61) 302.68,54.75 302.68,54.75 arc(302.55,54.83) 302.4,54.86 301.42,54.86 arc(301.25,54.89) 301.11,54.99 300.93,55.17 arc(300.68,55.34) 300.39,55.39 298.57,55.39 arc(298.27,55.45) 298.03,55.62 277.53,76.12 arc(277.36,76.36) 277.3,76.66 277.3,91.38 arc(277.25,91.67) 277.08,91.91 272.45,96.55 arc(272.28,96.8) 272.23,97.09 272.22,97.09 272.22,106.36 arc(272.14,106.8) 271.89,107.17 244.9,134.16 arc(244.53,134.4) 244.1,134.49 233.13,134.49
FC48_RDP3: length 124.5
  TOP w0.147: v4(224.55,137.39) 224.55,137.48 arc(224.53,137.56) 224.49,137.62 224.41,137.7 arc(224.25,137.81) 224.07,137.84 U1.AM7
  SIG9 w0.112: 232.01,137.65 231.97,137.65 ; v4(224.55,137.39) 224.68,137.52 arc(224.92,137.69) 225.22,137.74 231.74,137.74 arc(231.86,137.72) 231.96,137.65
  SIG9 w0.16: 232.01,137.65 233.44,137.65 arc(233.59,137.62) 233.71,137.54 234.14,137.11 arc(234.38,136.93) 234.67,136.81 arc(234.81,136.79) 234.95,136.78 244.48,136.78 arc(244.77,136.72) 245.02,136.55 274.03,107.54 arc(274.2,107.29) 274.26,107 274.26,100.64 arc(274.34,100.21) 274.59,99.83 280.62,93.8 arc(280.7,93.68) 280.73,93.53 280.73,76.9 arc(280.82,76.47) 281.07,76.09 295.67,61.5 295.67,61.14 296.03,60.78 296.39,60.78 296.81,60.35 296.81,59.99 297.17,59.63 297.53,59.63 298.35,58.82 298.39,58.77 arc(298.45,58.7) 298.49,58.62 arc(298.49,58.61) 298.49,58.6 arc(298.51,58.54) 298.51,58.48 298.51,58.07 arc(298.56,57.84) 298.69,57.65 299.1,57.24 arc(299.25,57.01) 299.3,56.75 YJ34.D21 ; 231.97,137.65 231.96,137.65
FC48_TDN0: length 140.3
  TOP w0.147: U1.AP4 227.1,139.84 arc(227.42,139.97) v4(227.55,140.29)
  SIG6 w0.112: 231.07,139.22 231.05,139.22 230.95,139.13 230.49,139.13 arc(230.25,139.08) 230.05,138.95 arc(229.97,138.9) 229.88,138.88 229.54,138.88 arc(229.25,138.94) 229.01,139.1 228.67,139.43 228.34,139.77 arc(228.15,139.89) 227.92,139.94 227.68,139.94 arc(227.59,139.98) 227.55,140.07 v4(227.55,140.29)
  SIG6 w0.16: YJ34.D34 309.85,57.97 arc(309.96,58.14) 310,58.34 310,58.52 arc(309.9,58.76) 309.66,58.86 308.76,58.86 arc(308.46,58.92) 308.22,59.08 308.13,59.17 arc(307.88,59.34) 307.59,59.39 299.03,59.39 arc(298.74,59.45) 298.49,59.62 295.74,62.37 arc(295.57,62.62) 295.51,62.91 295.51,68.18 arc(295.57,68.47) 295.74,68.72 297.15,70.13 arc(297.31,70.38) 297.37,70.67 297.37,96.07 arc(297.31,96.37) 297.15,96.61 283.88,109.88 arc(283.63,110.05) 283.34,110.11 272.31,110.11 arc(272.02,110.16) 271.77,110.33 245.17,136.93 arc(244.93,137.1) 244.63,137.15 234.5,137.15 arc(234.21,137.21) 233.96,137.38 232.34,139 arc(232.09,139.17) 231.8,139.22 231.07,139.22
FC48_TDN1: length 132.9
  TOP w0.147: U1.AL1 230.1,136.84 arc(230.42,136.71) v4(230.55,136.39)
  SIG7 w0.112: 231.26,135.51 231.26,135.64 231.14,135.76 arc(231.03,135.94) 230.99,136.14 230.99,136.65 arc(230.97,136.72) 230.94,136.77 230.93,136.78 arc(230.88,136.81) 230.83,136.82 230.69,136.82 arc(230.59,136.78) 230.55,136.67 v4(230.55,136.39)
  SIG7 w0.16: YJ34.D3 311.3,52.7 arc(311.24,53.01) 311.07,53.27 310.69,53.65 arc(310.56,53.84) 310.51,54.07 310.51,54.48 arc(310.51,54.53) 310.5,54.59 arc(310.46,54.69) 310.39,54.77 310.35,54.82 310.26,54.9 arc(310.14,54.98) 309.99,55.01 298.26,55.01 arc(297.82,55.1) 297.45,55.35 296.86,55.95 296.64,55.95 296.24,56.34 296.24,56.56 293.39,59.41 arc(293.14,59.78) 293.05,60.22 293.05,63.79 arc(293.02,63.94) 292.94,64.06 281.07,75.93 arc(280.82,76.3) 280.73,76.74 280.73,92.89 arc(280.61,93.51) 280.25,94.05 280.11,94.19 274.84,99.46 arc(274.41,100.1) 274.26,100.86 274.26,104.11 arc(274.23,104.25) 274.14,104.38 245.44,133.08 arc(245.31,133.17) 245.17,133.2 234.29,133.2 arc(233.63,133.33) 233.08,133.7 231.26,135.51
FC48_TDN2: length 148.4
  TOP w0.147: v4(228.55,137.29) 228.55,137.34 U1.AM3
  SIG7 w0.112: v4(228.55,137.29) 228.55,137.09 arc(228.59,136.98) 228.69,136.94 228.83,136.94 arc(228.88,136.95) 228.93,136.98 228.94,136.99 arc(228.97,137.04) 228.99,137.11 228.99,137.54 arc(229.02,137.7) 229.1,137.83 arc(229.23,137.91) 229.39,137.94 232,137.94 232.09,138.04 232.12,138.04
  SIG7 w0.16: 232.12,138.04 232.68,138.04 arc(232.97,137.98) 233.22,137.81 235.83,135.2 arc(236.08,135.03) 236.37,134.97 246.82,134.97 arc(247.11,134.92) 247.36,134.75 271.78,110.33 arc(272.03,110.16) 272.32,110.11 283.21,110.11 arc(283.65,110.02) 284.02,109.77 294.75,99.04 arc(295,98.67) 295.08,98.23 295.08,96.71 arc(295.03,96.41) 294.86,96.17 285.53,86.83 arc(285.36,86.59) 285.31,86.3 285.31,76.81 arc(285.43,76.18) 285.79,75.64 295.13,66.3 arc(295.41,65.88) 295.51,65.38 295.51,62.13 arc(295.57,61.84) 295.74,61.59 297.71,59.62 arc(297.96,59.45) 298.25,59.39 309.99,59.39 arc(310.28,59.34) 310.53,59.17 310.62,59.08 310.69,59.01 arc(310.86,58.9) 311.05,58.86 312.06,58.86 arc(312.3,58.76) 312.4,58.52 312.4,58.34 arc(312.36,58.14) 312.25,57.97 YJ34.D37
FC48_TDN3: length 134.2
  TOP w0.147: U1.AL5 226.1,136.84 arc(226.42,136.71) v4(226.55,136.39)
  SIG6 w0.112: 232.06,135.65 232.04,135.65 231.94,135.74 227.39,135.74 arc(227.23,135.77) 227.1,135.86 arc(227.02,135.99) 226.99,136.14 226.99,136.58 arc(226.97,136.64) 226.94,136.69 226.93,136.71 arc(226.88,136.73) 226.84,136.74 226.68,136.74 arc(226.59,136.71) 226.55,136.62 v4(226.55,136.39)
  SIG6 w0.16: 232.06,135.65 232.35,135.65 arc(232.47,135.62) 232.57,135.56 233.69,134.44 arc(234.06,134.19) 234.49,134.11 244.25,134.11 arc(244.4,134.08) 244.52,134 274.14,104.37 arc(274.23,104.25) 274.26,104.1 274.26,100.49 arc(274.34,100.05) 274.59,99.68 280.62,93.65 arc(280.7,93.53) 280.73,93.38 280.73,76.74 arc(280.82,76.3) 281.07,75.93 285.7,71.3 arc(285.78,71.18) 285.81,71.03 285.81,68.17 arc(285.9,67.73) 286.15,67.36 294.9,58.6 294.9,58.4 295.34,57.96 295.55,57.96 295.93,57.58 295.93,57.32 296.32,56.93 296.58,56.93 296.92,56.59 296.92,56.32 297.31,55.93 297.57,55.93 298.16,55.35 arc(298.53,55.1) 298.97,55.01 307.59,55.01 arc(307.74,54.98) 307.86,54.9 307.95,54.82 307.99,54.77 arc(308.06,54.69) 308.1,54.59 arc(308.11,54.53) 308.11,54.48 308.11,54.07 arc(308.16,53.84) 308.29,53.65 308.73,53.2 arc(308.86,53.02) 308.9,52.8 YJ34.D6
FC48_TDP0: length 140.3
  TOP w0.147: U1.AN4 227.55,139.34 v4(227.55,139.39)
  SIG6 w0.112: 231.07,138.84 231.05,138.84 230.95,138.94 230.49,138.94 arc(230.33,138.9) 230.19,138.81 arc(230.05,138.71) 229.88,138.68 229.54,138.68 arc(229.18,138.75) 228.87,138.96 228.2,139.63 arc(228.07,139.71) 227.92,139.74 227.68,139.74 arc(227.59,139.71) 227.55,139.62 v4(227.55,139.39)
  SIG6 w0.155: 308.13,57.94 arc(308.11,58) 308.11,58.07
  SIG6 w0.16: 231.07,138.84 231.8,138.84 arc(231.94,138.81) 232.07,138.73 233.69,137.11 arc(234.06,136.86) 234.5,136.77 244.63,136.77 arc(244.78,136.74) 244.9,136.66 271.51,110.06 arc(271.88,109.81) 272.31,109.73 283.34,109.73 arc(283.48,109.7) 283.61,109.61 296.88,96.34 arc(296.96,96.22) 296.99,96.07 296.99,70.67 arc(296.96,70.53) 296.88,70.4 295.47,68.99 arc(295.22,68.62) 295.13,68.18 295.13,62.91 arc(295.22,62.47) 295.47,62.1 296.24,61.33 296.24,60.97 296.53,60.68 296.89,60.68 297.23,60.34 297.23,59.98 297.52,59.69 297.88,59.69 298.22,59.35 arc(298.59,59.1) 299.03,59.01 307.59,59.01 arc(307.74,58.98) 307.86,58.9 307.95,58.82 307.99,58.77 arc(308.06,58.68) 308.1,58.57 arc(308.11,58.53) 308.11,58.48 308.11,58.07 ; YJ34.D33 308.9,56.78 arc(308.85,57.01) 308.72,57.21 308.29,57.64 arc(308.19,57.78) 308.13,57.94
FC48_TDP1: length 132.9
  TOP w0.147: U1.AM1 230.55,137.34 v4(230.55,137.29)
  SIG7 w0.112: v4(230.55,137.29) 230.55,137.18 arc(230.6,137.06) 230.71,137.02 230.83,137.02 arc(230.96,136.99) 231.07,136.92 231.08,136.91 arc(231.15,136.79) 231.18,136.65 231.18,136.14 arc(231.21,136.01) 231.28,135.9 231.4,135.78 231.53,135.78
  SIG7 w0.16: YJ34.D2 312.25,53.97 arc(312.36,54.14) 312.4,54.34 312.4,54.52 arc(312.3,54.76) 312.06,54.86 311.16,54.86 arc(310.86,54.92) 310.62,55.08 310.53,55.17 arc(310.28,55.34) 309.99,55.39 298.26,55.39 arc(297.97,55.45) 297.72,55.62 293.66,59.68 arc(293.49,59.93) 293.43,60.22 293.43,63.79 arc(293.38,64.08) 293.21,64.33 281.34,76.2 arc(281.17,76.45) 281.11,76.74 281.11,92.89 arc(280.96,93.66) 280.52,94.32 275.1,99.73 arc(274.76,100.25) 274.64,100.86 274.64,104.11 arc(274.58,104.4) 274.41,104.65 245.71,133.35 arc(245.46,133.52) 245.17,133.58 234.29,133.58 arc(233.78,133.68) 233.35,133.97 231.53,135.78
FC48_TDP2: length 148.4
  TOP w0.147: U1.AL3 228.1,136.84 arc(228.42,136.71) v4(228.55,136.39)
  SIG7 w0.112: v4(228.55,136.39) 228.55,136.58 arc(228.6,136.7) 228.71,136.74 228.83,136.74 arc(228.96,136.77) 229.07,136.84 229.08,136.85 arc(229.15,136.97) 229.18,137.11 229.18,137.54 arc(229.2,137.62) 229.24,137.69 arc(229.31,137.73) 229.39,137.75 232,137.75 232.09,137.65 232.12,137.65
  SIG7 w0.16: 232.12,137.65 232.68,137.65 arc(232.82,137.63) 232.95,137.54 235.56,134.93 arc(235.93,134.68) 236.37,134.59 246.82,134.59 arc(246.97,134.56) 247.09,134.48 271.51,110.06 arc(271.88,109.81) 272.32,109.73 283.21,109.73 arc(283.5,109.67) 283.75,109.5 294.48,98.77 arc(294.65,98.53) 294.7,98.23 294.7,96.71 arc(294.67,96.56) 294.59,96.44 285.26,87.1 arc(285.01,86.73) 284.92,86.3 284.92,76.81 arc(285.08,76.03) 285.52,75.37 292.79,68.1 292.79,67.87 293.17,67.49 293.4,67.49 293.73,67.17 293.73,66.91 294.08,66.56 294.34,66.56 294.86,66.03 arc(295.06,65.73) 295.13,65.38 295.13,62.13 arc(295.22,61.69) 295.47,61.32 295.97,60.82 295.97,60.56 296.34,60.19 296.6,60.19 297.12,59.67 297.12,59.67 297.44,59.35 arc(297.81,59.1) 298.25,59.01 309.99,59.01 arc(310.14,58.98) 310.26,58.9 310.35,58.82 310.39,58.77 arc(310.45,58.7) 310.49,58.61 arc(310.49,58.59) 310.5,58.58 arc(310.51,58.53) 310.51,58.48 310.51,58.07 arc(310.56,57.84) 310.69,57.65 311.15,57.18 arc(311.26,57.02) 311.3,56.82 YJ34.D36
FC48_TDP3: length 134.2
  TOP w0.147: v4(226.55,137.29) 226.55,137.34 U1.AM5
  SIG6 w0.112: v4(226.55,137.29) 226.55,137.07 arc(226.59,136.98) 226.68,136.94 226.84,136.94 arc(226.96,136.92) 227.07,136.85 227.08,136.83 arc(227.15,136.72) 227.18,136.58 227.18,136.14 arc(227.2,136.06) 227.24,136 arc(227.31,135.95) 227.39,135.94 231.94,135.94 232.04,136.03 232.06,136.03
  SIG6 w0.16: 232.06,136.03 232.35,136.03 arc(232.61,135.98) 232.84,135.83 233.95,134.71 arc(234.2,134.55) 234.49,134.49 244.25,134.49 arc(244.54,134.43) 244.79,134.26 274.41,104.64 arc(274.58,104.39) 274.64,104.1 274.64,100.49 arc(274.7,100.2) 274.86,99.95 280.89,93.92 arc(281.06,93.67) 281.11,93.38 281.11,76.74 arc(281.17,76.45) 281.34,76.2 285.97,71.57 arc(286.14,71.32) 286.19,71.03 286.19,68.17 arc(286.25,67.87) 286.42,67.63 298.43,55.62 arc(298.67,55.45) 298.97,55.39 307.59,55.39 arc(307.88,55.34) 308.13,55.17 308.22,55.08 arc(308.46,54.92) 308.76,54.86 309.66,54.86 arc(309.9,54.76) 310,54.52 310,54.34 arc(309.96,54.14) 309.85,53.97 YJ34.D5
FC49_RDN0: length 137
  TOP w0.147: v4(218.55,142.29) 218.55,142.21 arc(218.53,142.13) 218.49,142.06 218.41,141.98 arc(218.25,141.88) 218.07,141.84 U1.AT13
  SIG8 w0.112: 231.92,143.2 231.82,143.1 231.23,143.1 arc(231.09,143.07) 230.98,142.99 230.94,142.96 arc(230.92,142.94) 230.89,142.94 219.54,142.94 arc(219.33,142.9) 219.15,142.78 219.12,142.74 arc(219.02,142.6) 218.99,142.43 218.99,142.06 arc(218.98,142.01) 218.95,141.97 arc(218.91,141.95) 218.87,141.94 218.65,141.94 arc(218.58,141.97) 218.55,142.04 v4(218.55,142.29)
  SIG8 w0.16: 231.92,143.2 245.8,143.2 arc(246.24,143.11) 246.61,142.86 277.1,112.38 arc(277.22,112.29) 277.37,112.27 283.49,112.27 arc(283.78,112.21) 284.03,112.04 290.95,105.12 arc(291.2,104.96) 291.49,104.9 294.93,104.9 arc(295.22,104.84) 295.47,104.68 300.34,99.8 arc(300.59,99.43) 300.67,99 300.67,74.96 arc(300.7,74.82) 300.78,74.69 300.96,74.52 arc(301.2,74.15) 301.29,73.71 301.29,67.13 arc(301.37,66.94) 301.56,66.86 302.3,66.86 arc(302.5,66.82) 302.66,66.71 302.72,66.65 arc(302.78,66.56) 302.8,66.45 302.8,66.34 arc(302.76,66.14) 302.65,65.97 YJ34.C25
FC49_RDN1: length 135.4
  TOP w0.147: U1.AR9 222.55,141.34 v4(222.55,141.39)
  SIG9 w0.112: v4(222.55,141.39) 222.55,141.64 arc(222.58,141.71) 222.65,141.74 222.87,141.74 arc(222.91,141.73) 222.95,141.71 arc(222.98,141.67) 222.99,141.63 222.99,141.25 arc(223.02,141.08) 223.12,140.94 223.15,140.91 arc(223.33,140.79) 223.54,140.75 231.74,140.75 231.84,140.65
  SIG9 w0.16: YJ34.C18 299.3,60.84 arc(299.26,61.02) 299.16,61.17 298.69,61.65 arc(298.56,61.84) 298.51,62.07 298.51,62.48 arc(298.51,62.52) 298.5,62.57 arc(298.46,62.68) 298.39,62.77 298.35,62.82 297.37,63.79 297.01,63.79 296.65,64.15 296.65,64.51 296.21,64.96 arc(295.96,65.33) 295.87,65.76 295.87,66.55 295.62,66.8 295.62,67.31 295.87,67.56 295.87,68.67 arc(295.96,69.11) 296.21,69.48 296.88,70.15 arc(296.96,70.27) 296.99,70.42 296.99,98.49 arc(296.93,98.78) 296.77,99.03 294.17,101.63 arc(293.92,101.79) 293.63,101.85 290.45,101.85 arc(290.16,101.91) 289.91,102.07 249.6,142.38 arc(249.48,142.46) 249.33,142.49 234.41,142.49 arc(234.26,142.46) 234.14,142.38 232.74,140.98 arc(232.37,140.73) 231.93,140.65 231.84,140.65
FC49_RDN2: length 137.2
  TOP w0.147: v4(220.55,142.29) 220.55,142.21 arc(220.53,142.13) 220.49,142.06 220.41,141.98 arc(220.25,141.88) 220.07,141.84 U1.AT11
  SIG8 w0.112: v4(220.55,142.29) 220.55,142.04 arc(220.58,141.97) 220.65,141.94 220.87,141.94 arc(220.99,141.92) 221.09,141.85 arc(221.16,141.75) 221.18,141.63 221.18,141.25 arc(221.2,141.16) 221.25,141.08 221.29,141.05 arc(221.4,140.97) 221.54,140.94 231.75,140.94 231.84,141.03
  SIG8 w0.16: YJ34.C14 302.65,61.97 arc(302.73,62.09) 302.76,62.24 302.76,62.55 arc(302.74,62.64) 302.7,62.71 302.66,62.74 arc(302.53,62.83) 302.37,62.86 301.35,62.86 arc(301.25,62.88) 301.16,62.94 300.93,63.17 arc(300.68,63.34) 300.39,63.39 299.03,63.39 arc(298.74,63.45) 298.49,63.62 297.59,64.52 arc(297.43,64.77) 297.37,65.06 297.37,98.93 294.07,102.23 290.57,102.23 arc(290.28,102.29) 290.04,102.46 282.61,109.88 arc(282.36,110.05) 282.07,110.11 276.48,110.11 arc(276.33,110.14) 276.21,110.22 245.73,140.69 arc(245.36,140.94) 244.92,141.03 231.84,141.03
FC49_RDN3: length 134.1
  TOP w0.147: U1.AR7 224.55,141.34 v4(224.55,141.39)
  SIG9 w0.112: 231.33,142.97 231.32,142.96 231.25,142.96 arc(231.19,142.95) 231.14,142.92 231.1,142.87 arc(230.96,142.78) 230.8,142.75 225.54,142.75 arc(225.4,142.72) 225.29,142.64 225.25,142.61 arc(225.2,142.53) 225.18,142.44 225.18,141.98 arc(225.16,141.86) 225.09,141.76 arc(224.99,141.69) 224.87,141.67 224.65,141.67 arc(224.58,141.64) 224.55,141.57 v4(224.55,141.39)
  SIG9 w0.16: YJ34.C21 299.3,64.78 arc(299.25,65.02) 299.12,65.21 298.69,65.65 arc(298.56,65.84) 298.51,66.07 298.51,66.48 arc(298.51,66.53) 298.5,66.58 arc(298.46,66.69) 298.39,66.77 298.35,66.82 298.27,66.9 arc(297.95,67.66) 298.27,68.41 298.54,68.68 298.54,69.02 298.83,69.31 299.16,69.31 300.07,70.22 arc(300.23,70.46) 300.29,70.76 300.29,71.14 300.09,71.34 300.09,71.82 300.29,72.03 300.29,72.41 300.09,72.61 300.09,73.09 300.29,73.3 300.29,99.12 arc(300.26,99.27) 300.18,99.39 295.17,104.41 arc(295.04,104.49) 294.9,104.52 290.99,104.52 arc(290.55,104.61) 290.18,104.85 250.23,144.8 arc(250.1,144.89) 249.96,144.92 233.43,144.92 arc(233.29,144.89) 233.16,144.8 232.23,143.87 232.23,143.51 231.96,143.24 231.6,143.24 231.33,142.97
FC49_RDP0: length 137
  TOP w0.147: v4(218.55,141.39) 218.55,141.34 U1.AR13
  SIG8 w0.112: v4(218.55,141.39) 218.55,141.64 arc(218.58,141.71) 218.65,141.74 218.87,141.74 arc(218.99,141.77) 219.09,141.84 arc(219.16,141.94) 219.18,142.06 219.18,142.43 arc(219.2,142.52) 219.25,142.6 219.29,142.64 arc(219.4,142.71) 219.54,142.74 230.89,142.74 arc(230.99,142.76) 231.08,142.82 231.12,142.86 arc(231.17,142.89) 231.23,142.9 231.83,142.9 231.92,142.82
  SIG8 w0.16: 231.92,142.82 245.8,142.82 arc(246.09,142.76) 246.34,142.59 276.83,112.11 arc(277.07,111.94) 277.37,111.88 283.49,111.88 arc(283.64,111.86) 283.76,111.77 290.68,104.85 arc(291.05,104.61) 291.49,104.52 294.93,104.52 arc(295.07,104.49) 295.2,104.41 300.07,99.53 arc(300.23,99.29) 300.29,99 300.29,74.96 arc(300.35,74.67) 300.52,74.42 300.69,74.25 arc(300.85,74.01) 300.91,73.71 300.91,70.86 300.78,70.74 300.78,69.97 300.91,69.85 300.91,69.34 300.76,69.19 300.76,68.48 300.91,68.32 300.91,66.09 arc(300.96,65.84) 301.1,65.64 301.14,65.59 301.46,65.28 arc(301.64,65.01) 301.7,64.69 YJ34.C24
FC49_RDP1: length 135.4
  TOP w0.147: U1.AT9 222.16,141.84 arc(222.27,141.86) 222.35,141.92 222.43,141.99 arc(222.52,142.13) v4(222.55,142.29)
  SIG9 w0.112: 231.84,141.03 231.75,140.94 223.54,140.94 arc(223.4,140.97) 223.29,141.05 223.25,141.08 arc(223.2,141.16) 223.18,141.25 223.18,141.63 arc(223.16,141.75) 223.09,141.85 arc(222.99,141.92) 222.87,141.94 222.65,141.94 arc(222.58,141.97) 222.55,142.04 v4(222.55,142.29)
  SIG9 w0.16: 231.84,141.03 231.93,141.03 arc(232.22,141.09) 232.47,141.25 233.87,142.65 arc(234.12,142.81) 234.41,142.87 249.33,142.87 arc(249.63,142.81) 249.87,142.65 290.18,102.34 arc(290.3,102.26) 290.45,102.23 293.63,102.23 arc(294.06,102.15) 294.43,101.9 297.04,99.3 arc(297.28,98.93) 297.37,98.49 297.37,70.42 arc(297.31,70.13) 297.15,69.88 296.48,69.21 arc(296.31,68.96) 296.25,68.67 296.25,65.76 arc(296.31,65.47) 296.48,65.23 298.62,63.08 arc(298.86,62.92) 299.16,62.86 300.06,62.86 arc(300.3,62.76) 300.4,62.52 300.4,62.34 arc(300.36,62.14) 300.25,61.97 YJ34.C17
FC49_RDP2: length 137.2
  TOP w0.147: U1.AR11 220.55,141.34 v4(220.55,141.39)
  SIG8 w0.112: v4(220.55,141.39) 220.55,141.64 arc(220.58,141.71) 220.65,141.74 220.87,141.74 arc(220.91,141.73) 220.95,141.71 arc(220.98,141.67) 220.99,141.63 220.99,141.25 arc(221.02,141.08) 221.12,140.94 221.15,140.91 arc(221.33,140.79) 221.54,140.75 231.74,140.75 231.84,140.65
  SIG8 w0.16: YJ34.C15 301.7,60.68 arc(301.65,60.96) 301.51,61.21 arc(301.5,61.22) 301.49,61.24 arc(301.49,61.24) 301.49,61.24 arc(301.47,61.27) 301.45,61.29 301.33,61.41 301.09,61.65 arc(300.96,61.84) 300.91,62.07 300.91,62.48 arc(300.91,62.54) 300.89,62.6 arc(300.89,62.61) 300.89,62.61 arc(300.89,62.62) 300.88,62.64 arc(300.84,62.71) 300.79,62.77 300.75,62.82 300.66,62.9 arc(300.54,62.98) 300.39,63.01 299.03,63.01 arc(298.6,63.1) 298.23,63.35 297.32,64.25 arc(297.08,64.62) 296.99,65.06 296.99,66.09 296.74,66.34 296.74,66.85 296.99,67.1 296.99,67.61 296.73,67.87 296.73,68.37 296.99,68.63 296.99,98.77 293.96,101.8 arc(293.91,101.84) 293.84,101.85 290.57,101.85 arc(290.14,101.94) 289.77,102.19 282.34,109.61 arc(282.21,109.7) 282.07,109.73 276.48,109.73 arc(276.19,109.78) 275.94,109.95 269.05,116.84 253.81,132.08 245.46,140.43 arc(245.21,140.59) 244.92,140.65 231.84,140.65
FC49_RDP3: length 134.1
  TOP w0.147: U1.AT7 224.16,141.84 arc(224.27,141.86) 224.35,141.92 224.43,141.99 arc(224.52,142.13) v4(224.55,142.29)
  SIG9 w0.112: 231.06,143.24 231.04,143.22 231.05,143.21 arc(231.06,143.14) 231.03,143.08 230.96,143.01 arc(230.89,142.96) 230.8,142.94 225.54,142.94 arc(225.33,142.9) 225.15,142.78 225.12,142.75 arc(225.02,142.6) 224.99,142.44 224.99,141.98 arc(224.98,141.94) 224.95,141.9 arc(224.91,141.87) 224.87,141.86 224.65,141.86 arc(224.58,141.89) 224.55,141.97 v4(224.55,142.29)
  SIG9 w0.16: 231.06,143.24 232.89,145.07 arc(233.14,145.24) 233.43,145.3 249.96,145.3 arc(250.25,145.24) 250.5,145.07 290.45,105.12 arc(290.69,104.96) 290.99,104.9 294.9,104.9 arc(295.19,104.84) 295.43,104.68 300.45,99.66 arc(300.61,99.41) 300.67,99.12 300.67,70.76 arc(300.59,70.32) 300.34,69.95 298.54,68.15 arc(298.33,67.66) 298.54,67.17 298.62,67.08 arc(298.86,66.92) 299.16,66.86 300.06,66.86 arc(300.3,66.76) 300.4,66.52 300.4,66.34 arc(300.36,66.14) 300.25,65.97 YJ34.C22
FC49_TDN0: length 139.7
  TOP w0.147: U1.AR1 230.55,141.34 v4(230.55,141.39)
  SIG7 w0.112: 231.57,142.8 231.55,142.78 231.42,142.78 231.32,142.67 arc(231.22,142.52) 231.18,142.34 231.18,142.03 arc(231.15,141.89) 231.08,141.77 231.07,141.76 arc(230.96,141.69) 230.83,141.67 230.71,141.67 arc(230.6,141.62) 230.55,141.5 v4(230.55,141.39)
  SIG7 w0.16: YJ34.C36 311.3,64.73 arc(311.24,65.01) 311.09,65.25 310.69,65.65 arc(310.56,65.84) 310.51,66.07 310.51,66.48 arc(310.51,66.53) 310.5,66.58 arc(310.49,66.6) 310.49,66.62 arc(310.45,66.7) 310.39,66.77 310.35,66.82 310.12,67.04 arc(309.75,67.59) 309.62,68.24 309.62,69.36 arc(309.71,69.8) 309.96,70.17 310.23,70.44 310.23,70.75 310.55,71.07 310.86,71.07 311.13,71.34 311.13,71.67 311.42,71.97 311.75,71.97 312.02,72.24 312.02,72.55 312.34,72.87 312.65,72.87 312.92,73.14 312.92,73.44 313.24,73.76 313.55,73.76 314.66,74.87 arc(314.74,75) 314.77,75.14 314.77,94.28 arc(314.65,94.89) 314.3,95.41 293.97,115.75 arc(293.46,116.08) 292.86,116.2 273.05,116.2 arc(272.76,116.26) 272.51,116.43 246.39,142.54 arc(246.27,142.62) 246.12,142.65 234.86,142.65 arc(234.42,142.74) 234.05,142.99 234,143.04 arc(233.88,143.12) 233.73,143.15 232.19,143.15 arc(231.95,143.1) 231.74,142.97 231.57,142.8
FC49_TDN1: length 144
  TOP w0.147: U1.AT3 228.1,141.84 arc(228.42,141.97) v4(228.55,142.29)
  SIG6 w0.112: v4(228.55,142.29) 228.55,142.07 arc(228.59,141.98) 228.68,141.94 228.84,141.94 arc(228.96,141.92) 229.07,141.85 229.08,141.83 arc(229.15,141.72) 229.18,141.58 229.18,141.14 arc(229.2,141.06) 229.24,141 arc(229.31,140.95) 229.39,140.94 231.72,140.94 231.81,141.03 231.84,141.03
  SIG6 w0.16: 231.84,141.03 233.25,141.03 arc(233.36,141.02) 233.46,140.98 233.53,140.94 arc(233.61,140.91) 233.69,140.9 245.2,140.9 arc(245.5,140.84) 245.74,140.68 274.05,112.38 arc(274.17,112.29) 274.31,112.27 284.36,112.27 arc(284.79,112.18) 285.16,111.93 294.37,102.73 arc(294.49,102.64) 294.64,102.61 297.82,102.61 arc(298.11,102.56) 298.36,102.39 300.45,100.3 arc(300.61,100.05) 300.67,99.76 300.67,69.24 arc(300.61,68.95) 300.45,68.7 297.82,66.07 arc(297.65,65.82) 297.59,65.53 297.59,64.56 arc(297.65,64.27) 297.82,64.03 298.22,63.62 arc(298.47,63.45) 298.76,63.39 309.99,63.39 arc(310.28,63.34) 310.53,63.17 310.62,63.08 arc(310.86,62.92) 311.16,62.86 312.06,62.86 arc(312.3,62.76) 312.4,62.52 312.4,62.34 arc(312.36,62.14) 312.25,61.97 YJ34.C2
FC49_TDN2: length 143.3
  TOP w0.147: U1.AR5 226.55,141.34 v4(226.55,141.39)
  SIG6 w0.112: v4(226.55,141.39) 226.55,141.62 arc(226.59,141.71) 226.68,141.74 226.84,141.74 arc(226.96,141.77) 227.07,141.84 227.08,141.85 arc(227.15,141.97) 227.18,142.11 227.18,142.54 arc(227.2,142.62) 227.24,142.69 arc(227.31,142.73) 227.39,142.75 231.97,142.75 232.06,142.65 232.09,142.65
  SIG6 w0.155: 308.2,65.76 arc(308.13,65.91) 308.11,66.07
  SIG6 w0.16: YJ34.C33 308.9,64.81 arc(308.86,65.02) 308.74,65.19 308.33,65.6 arc(308.26,65.68) 308.2,65.76 ; 232.09,142.65 245.97,142.65 arc(246.26,142.6) 246.5,142.43 272.51,116.43 arc(272.76,116.26) 273.05,116.2 293.25,116.2 arc(293.54,116.14) 293.78,115.98 314.24,95.52 arc(314.41,95.27) 314.46,94.98 314.46,94.98 314.46,76.34 arc(314.44,76.19) 314.35,76.07 309.44,71.15 309.16,71.15 308.78,70.77 308.78,70.5 308.45,70.16 arc(308.2,69.79) 308.11,69.35 308.11,68.78 307.96,68.63 307.96,68.01 308.11,67.87 308.11,66.07
FC49_TDN3: length 136
  TOP w0.147: U1.AP2 229.1,139.84 arc(229.42,139.97) v4(229.55,140.29)
  SIG7 w0.112: v4(229.55,140.29) 229.55,140.09 arc(229.59,139.98) 229.69,139.94 229.83,139.94 arc(229.88,139.95) 229.93,139.98 229.94,139.99 arc(229.97,140.04) 229.99,140.11 229.99,140.54 arc(230.02,140.7) 230.1,140.83 arc(230.23,140.91) 230.39,140.94 231.72,140.94 231.81,141.03 231.84,141.03
  SIG7 w0.16: 231.84,141.03 245.07,141.03 arc(245.36,140.98) 245.61,140.81 253.81,132.61 269.59,116.84 274.05,112.38 arc(274.17,112.29) 274.31,112.27 284.32,112.27 arc(284.76,112.18) 285.13,111.93 297.15,99.92 arc(297.31,99.67) 297.37,99.38 297.37,84 arc(297.38,83.93) 297.4,83.86 297.51,83.58 arc(297.57,83.38) 297.59,83.17 297.59,64.49 arc(297.65,64.2) 297.82,63.95 298.15,63.62 arc(298.4,63.45) 298.69,63.39 307.59,63.39 arc(307.88,63.34) 308.13,63.17 arc(308.47,62.94) 308.88,62.86 309.66,62.86 arc(309.9,62.76) 310,62.52 310,62.34 arc(309.96,62.14) 309.85,61.97 YJ34.C5
FC49_TDP0: length 139.7
  TOP w0.147: U1.AT1 230.1,141.84 arc(230.42,141.97) v4(230.55,142.29)
  SIG7 w0.112: 231.3,143.07 231.28,143.05 231.28,142.92 231.18,142.81 arc(231.04,142.6) 230.99,142.34 230.99,142.03 arc(230.97,141.97) 230.94,141.91 230.93,141.9 arc(230.88,141.87) 230.83,141.86 230.69,141.86 arc(230.59,141.91) 230.55,142.01 v4(230.55,142.29)
  SIG7 w0.16: YJ34.C37 312.25,65.97 arc(312.36,66.14) 312.4,66.34 312.4,66.52 arc(312.3,66.76) 312.06,66.86 311.07,66.86 arc(310.86,66.9) 310.68,67.02 310.39,67.31 arc(310.1,67.74) 310,68.24 310,69.36 arc(310.06,69.65) 310.23,69.9 314.93,74.6 arc(315.09,74.85) 315.15,75.14 315.15,94.28 arc(315,95.04) 314.57,95.68 294.24,116.01 arc(293.61,116.44) 292.86,116.58 273.05,116.58 arc(272.9,116.61) 272.78,116.7 246.66,142.81 arc(246.42,142.98) 246.12,143.04 234.86,143.04 arc(234.57,143.09) 234.32,143.26 234.27,143.31 arc(234.02,143.47) 233.73,143.53 232.19,143.53 arc(231.8,143.46) 231.48,143.24 231.3,143.07
FC49_TDP1: length 144
  TOP w0.147: v4(228.55,141.39) 228.55,141.34 U1.AR3
  SIG6 w0.112: v4(228.55,141.39) 228.55,141.62 arc(228.59,141.71) 228.68,141.74 228.84,141.74 arc(228.88,141.73) 228.93,141.71 228.94,141.69 arc(228.97,141.64) 228.99,141.58 228.99,141.14 arc(229.02,140.99) 229.1,140.86 arc(229.23,140.77) 229.39,140.74 231.72,140.74 231.81,140.65 231.84,140.65
  SIG6 w0.16: 231.84,140.65 233.25,140.65 arc(233.27,140.65) 233.29,140.64 233.36,140.6 arc(233.52,140.54) 233.69,140.52 245.2,140.52 arc(245.35,140.49) 245.47,140.41 273.78,112.11 arc(274.02,111.94) 274.31,111.88 284.36,111.88 arc(284.65,111.83) 284.89,111.66 294.1,102.46 arc(294.35,102.29) 294.64,102.23 297.82,102.23 arc(297.96,102.2) 298.09,102.12 300.18,100.03 arc(300.26,99.9) 300.29,99.76 300.29,69.24 arc(300.26,69.09) 300.18,68.97 299.53,68.32 299.17,68.32 298.88,68.03 298.88,67.67 298.54,67.33 298.18,67.33 297.89,67.04 297.89,66.68 297.55,66.34 arc(297.3,65.97) 297.21,65.53 297.21,64.56 arc(297.3,64.13) 297.55,63.76 297.96,63.35 arc(298.33,63.1) 298.76,63.01 309.99,63.01 arc(310.14,62.98) 310.26,62.9 310.35,62.82 310.39,62.77 arc(310.46,62.68) 310.5,62.57 arc(310.51,62.53) 310.51,62.48 310.51,62.07 arc(310.56,61.84) 310.69,61.65 311.11,61.22 arc(311.25,61.01) 311.3,60.76 YJ34.C3
FC49_TDP2: length 143.3
  TOP w0.147: U1.AT5 226.1,141.84 arc(226.42,141.97) v4(226.55,142.29)
  SIG6 w0.112: 232.09,143.04 232.06,143.04 231.97,142.94 227.39,142.94 arc(227.23,142.91) 227.1,142.83 arc(227.02,142.7) 226.99,142.54 226.99,142.11 arc(226.97,142.04) 226.94,141.99 226.93,141.98 arc(226.88,141.95) 226.84,141.94 226.68,141.94 arc(226.59,141.98) 226.55,142.07 v4(226.55,142.29)
  SIG6 w0.16: YJ34.C34 309.85,65.97 arc(309.96,66.14) 310,66.34 310,66.52 arc(309.9,66.76) 309.66,66.86 308.75,66.86 arc(308.57,66.94) 308.49,67.12 308.49,69.35 arc(308.55,69.64) 308.71,69.89 314.62,75.8 arc(314.79,76.04) 314.85,76.34 314.85,94.98 arc(314.76,95.42) 314.51,95.79 294.05,116.25 arc(293.68,116.5) 293.25,116.58 273.05,116.58 arc(272.9,116.61) 272.78,116.7 246.77,142.7 arc(246.4,142.95) 245.97,143.04 232.09,143.04
FC49_TDP3: length 136
  TOP w0.147: U1.AN2 229.55,139.34 v4(229.55,139.39)
  SIG7 w0.112: v4(229.55,139.39) 229.55,139.58 arc(229.6,139.7) 229.71,139.74 229.83,139.74 arc(229.96,139.77) 230.07,139.84 230.08,139.85 arc(230.15,139.97) 230.18,140.11 230.18,140.54 arc(230.2,140.62) 230.24,140.69 arc(230.31,140.73) 230.39,140.75 231.66,140.75 arc(231.71,140.74) 231.76,140.71 231.81,140.65 231.84,140.65
  SIG7 w0.155: 308.18,61.8 308.18,61.8 arc(308.13,61.93) 308.11,62.07
  SIG7 w0.16: YJ34.C6 308.9,60.68 arc(308.83,61.01) 308.65,61.29 308.32,61.62 arc(308.24,61.7) 308.18,61.8 ; 308.11,62.07 308.11,62.48 arc(308.11,62.53) 308.1,62.58 arc(308.1,62.59) 308.09,62.6 arc(308.05,62.69) 307.99,62.77 307.95,62.82 307.86,62.9 arc(307.74,62.98) 307.59,63.01 298.69,63.01 arc(298.26,63.1) 297.89,63.35 297.55,63.69 arc(297.3,64.06) 297.21,64.49 297.21,66.9 297.04,67.07 297.04,67.59 297.21,67.76 297.21,68.22 297.04,68.39 297.04,68.91 297.21,69.09 297.21,69.54 297.04,69.72 297.04,70.23 297.21,70.41 297.21,83.17 arc(297.2,83.31) 297.16,83.44 297.05,83.71 arc(297,83.85) 296.99,84 296.99,99.38 arc(296.96,99.52) 296.88,99.65 284.86,111.66 arc(284.62,111.83) 284.32,111.88 274.31,111.88 arc(274.02,111.94) 273.78,112.11 245.34,140.54 arc(245.22,140.62) 245.07,140.65 231.84,140.65
FC50_51_PVDD0P8: length 4.1
  TOP w0.229: U1.AV18 v1(213.55,144.34) ; U1.AY18 v1(213.55,146.34)
  TOP w0.381: 237.34,150.85 C3028.1 237.93,151.48
  BOTTOM w0.381: C2981.1 213.07,143.86 v1(213.55,144.34) ; v1(213.55,146.34) 213.07,145.86 C3326.1
  vias: v1(237.05,152.02) v1(237.93,152.02)
FC50_RDN0: length 149.5
  TOP w0.147: v4(218.55,144.39) 218.55,144.34 U1.AV13
  SIG2 w0.112: 231.84,142.65 231.81,142.65 231.72,142.74 225.37,142.74 arc(225.24,142.77) 225.12,142.85 225.09,142.88 arc(224.99,143.03) 224.95,143.21 224.95,143.47 arc(224.93,143.57) 224.87,143.66 arc(224.78,143.72) 224.67,143.75 219.57,143.75 arc(219.35,143.79) 219.16,143.92 arc(219.03,144.11) 218.99,144.33 218.99,144.63 arc(218.98,144.68) 218.95,144.71 arc(218.92,144.73) 218.88,144.74 218.68,144.74 arc(218.59,144.71) 218.55,144.62 v4(218.55,144.39)
  SIG2 w0.16: 231.84,142.65 232.64,142.65 arc(232.75,142.67) 232.84,142.73 arc(232.85,142.74) 232.86,142.75 arc(232.94,142.8) 233.04,142.82 242.75,142.82 arc(243.05,142.76) 243.29,142.59 271.62,114.27 arc(271.87,114.1) 272.16,114.04 292.31,114.04 arc(292.6,113.99) 292.84,113.82 314.24,92.42 arc(314.41,92.18) 314.46,91.88 314.46,91.88 314.46,77.3 arc(314.15,75.72) 313.26,74.38 312.67,73.8 312.31,73.8 311.95,73.44 311.95,73.08 311.59,72.72 311.23,72.72 310.87,72.36 310.87,72 310.51,71.64 arc(310.31,71.34) 310.24,71 310.24,70.28 309.99,70.02 309.99,69.51 310.24,69.26 310.24,68.75 309.99,68.5 309.99,67.99 310.24,67.74 310.24,67.23 arc(310.24,67.16) 310.22,67.11 310.19,67.02 arc(310.13,66.94) 310.04,66.89 309.97,66.87 arc(309.93,66.86) 309.9,66.86 308.91,66.86 arc(308.69,66.77) 308.61,66.56 308.61,66.32 arc(308.64,66.13) 308.75,65.97 YJ33.A25
FC50_RDN1: length 155.1
  TOP w0.147: v4(222.55,145.29) 222.44,145.29 arc(222.34,145.27) 222.26,145.21 222.17,145.12 arc(222.08,144.99) U1.AW9
  SIG3 w0.112: 232.09,145.03 232.06,145.03 231.97,144.94 226.38,144.94 arc(226.28,144.96) 226.19,145.02 arc(226.13,145.1) 226.11,145.21 226.11,145.43 arc(226.07,145.62) 225.96,145.79 arc(225.79,145.9) 225.59,145.94 223.57,145.94 arc(223.35,145.9) 223.16,145.77 arc(223.03,145.58) 222.99,145.36 222.99,145.05 arc(222.98,145.01) 222.95,144.97 arc(222.92,144.95) 222.88,144.94 222.68,144.94 arc(222.59,144.98) 222.55,145.07 v4(222.55,145.29)
  SIG3 w0.16: 232.09,145.03 233.72,145.03 arc(233.88,145.06) 234.02,145.16 234.03,145.16 arc(234.17,145.25) 234.34,145.29 243.87,145.29 arc(244.16,145.23) 244.41,145.06 272.67,116.81 arc(272.91,116.64) 273.21,116.58 293.35,116.58 arc(293.64,116.53) 293.89,116.36 316.71,93.54 arc(316.88,93.29) 316.94,93 316.94,72.05 arc(316.88,71.76) 316.71,71.51 315.18,69.98 arc(315.01,69.73) 314.96,69.44 314.96,67.62 arc(314.9,67.33) 314.73,67.08 314.28,66.63 arc(314.12,66.39) 314.06,66.09 314.06,64.69 arc(313.97,64.26) 313.73,63.89 313.2,63.36 arc(312.83,63.11) 312.39,63.03 310.95,63.03 arc(310.81,63) 310.68,62.91 310.63,62.86 arc(310.54,62.72) 310.51,62.57 310.51,61.97 arc(310.48,61.85) 310.41,61.75 309.91,61.24 arc(309.89,61.23) 309.88,61.21 arc(309.75,60.99) 309.7,60.74 YJ33.A15
FC50_RDN2: length 155.4
  TOP w0.147: v4(220.55,144.39) 220.55,144.34 U1.AV11
  SIG2 w0.112: v4(220.55,144.39) 220.55,144.62 arc(220.59,144.71) 220.68,144.74 220.88,144.74 arc(220.99,144.77) 221.09,144.83 arc(221.16,144.93) 221.18,145.05 221.18,145.35 arc(221.21,145.5) 221.3,145.63 arc(221.42,145.71) 221.57,145.74 225.62,145.74 arc(225.74,145.72) 225.85,145.65 arc(225.92,145.54) 225.94,145.42 225.94,145.21 arc(225.98,145.03) 226.08,144.88 arc(226.23,144.78) 226.4,144.74 231.97,144.74 232.06,144.65 232.09,144.65
  SIG2 w0.16: YJ33.A17 311.15,61.97 arc(311.04,62.13) 311.01,62.32 311.01,62.56 arc(311.1,62.77) 311.31,62.86 312.18,62.86 arc(312.47,62.92) 312.72,63.08 312.76,63.13 312.81,63.18 313.28,63.65 arc(313.58,64.09) 313.68,64.61 313.68,64.61 313.68,66.02 arc(313.65,66.16) 313.57,66.28 313.44,66.41 arc(313.2,66.78) 313.11,67.22 313.11,68.66 arc(313.2,69.1) 313.44,69.47 313.8,69.83 313.8,70.19 314.16,70.54 314.52,70.54 314.88,70.9 314.88,71.26 315.24,71.62 315.6,71.62 316.44,72.46 arc(316.52,72.58) 316.55,72.73 316.55,73.25 316.29,73.51 316.29,74.01 316.55,74.27 316.55,74.78 316.32,75 316.32,75.56 316.55,75.79 316.55,92.87 arc(316.49,93.16) 316.32,93.41 293.75,115.98 arc(293.51,116.14) 293.21,116.2 273.05,116.2 arc(272.76,116.26) 272.51,116.43 244.25,144.68 arc(244.01,144.85) 243.72,144.9 234.05,144.9 arc(233.88,144.87) 233.74,144.78 arc(233.6,144.68) 233.44,144.65 232.09,144.65
FC50_RDN3: length 143
  TOP w0.147: v4(224.55,145.29) 224.44,145.29 arc(224.34,145.27) 224.26,145.21 224.17,145.12 arc(224.08,144.99) U1.AW7
  SIG3 w0.112: 232.22,143.04 232.2,143.04 232.11,142.94 225.39,142.94 arc(225.31,142.96) 225.24,143 arc(225.2,143.07) 225.18,143.15 225.18,144.63 arc(225.16,144.75) 225.09,144.85 arc(224.99,144.92) 224.88,144.94 224.68,144.94 arc(224.59,144.98) 224.55,145.07 v4(224.55,145.29)
  SIG3 w0.16: 232.22,143.04 235.62,143.04 235.62,143.04 243.07,143.04 arc(243.36,142.98) 243.61,142.81 271.78,114.65 arc(272.03,114.48) 272.32,114.42 292.46,114.42 arc(292.75,114.37) 293,114.2 314.63,92.57 arc(314.8,92.32) 314.86,92.03 314.86,74.54 arc(314.8,74.25) 314.63,74 313.11,72.48 arc(312.94,72.23) 312.88,71.94 312.88,65.99 arc(312.85,65.83) 312.77,65.7 312.39,65.33 arc(312.18,65) 312.1,64.62 YJ33.A21
FC50_RDP0: length 149.5
  TOP w0.147: v4(218.55,145.29) 218.55,145.22 arc(218.54,145.16) 218.5,145.1 218.31,144.92 arc(218.23,144.86) 218.13,144.84 U1.AW13
  SIG2 w0.112: v4(218.55,145.29) 218.55,145.07 arc(218.59,144.98) 218.68,144.94 218.88,144.94 arc(218.99,144.92) 219.09,144.85 arc(219.16,144.75) 219.18,144.63 219.18,144.33 arc(219.21,144.18) 219.3,144.06 arc(219.42,143.97) 219.57,143.94 224.67,143.94 arc(224.85,143.91) 225.01,143.8 arc(225.11,143.65) 225.15,143.47 225.15,143.21 arc(225.17,143.1) 225.23,143.02 225.26,142.99 arc(225.31,142.95) 225.37,142.94 231.72,142.94 231.81,143.03 231.84,143.03
  SIG2 w0.16: YJ33.A24 309.7,64.8 arc(309.74,65.02) 309.87,65.2 310.41,65.75 arc(310.48,65.85) 310.51,65.97 310.51,66.46 arc(310.51,66.57) 310.54,66.67 310.6,66.89 arc(310.62,66.96) 310.63,67.04 310.63,71 arc(310.67,71.2) 310.78,71.37 313.53,74.11 arc(314.5,75.58) 314.85,77.3 314.85,91.88 arc(314.76,92.32) 314.51,92.69 293.11,114.09 arc(292.74,114.34) 292.31,114.42 272.16,114.42 arc(272.01,114.45) 271.89,114.54 243.56,142.86 arc(243.19,143.11) 242.75,143.2 233.04,143.2 arc(232.81,143.16) 232.6,143.03 231.84,143.03
FC50_RDP1: length 155.1
  TOP w0.147: v4(222.55,144.39) 222.55,144.34 U1.AV9
  SIG3 w0.112: 232.09,144.65 232.06,144.65 231.97,144.74 226.38,144.74 arc(226.2,144.78) 226.05,144.88 arc(225.95,145.03) 225.91,145.21 225.91,145.43 arc(225.89,145.55) 225.82,145.65 arc(225.72,145.72) 225.59,145.75 223.57,145.75 arc(223.42,145.72) 223.3,145.63 arc(223.21,145.51) 223.18,145.36 223.18,145.05 arc(223.16,144.93) 223.09,144.83 arc(222.99,144.77) 222.88,144.74 222.68,144.74 arc(222.59,144.71) 222.55,144.62 v4(222.55,144.39)
  SIG3 w0.16: YJ33.A14 308.75,61.97 arc(308.64,62.13) 308.61,62.32 308.61,62.55 arc(308.7,62.77) 308.92,62.86 309.78,62.86 arc(310.07,62.92) 310.32,63.08 310.36,63.13 310.41,63.18 arc(310.66,63.35) 310.95,63.41 312.39,63.41 arc(312.68,63.46) 312.93,63.63 313.46,64.16 arc(313.62,64.4) 313.68,64.69 313.68,66.09 arc(313.77,66.53) 314.01,66.9 314.46,67.35 arc(314.55,67.48) 314.58,67.62 314.58,69.44 arc(314.66,69.88) 314.91,70.25 315.27,70.61 315.27,70.97 315.63,71.33 315.99,71.33 316.45,71.78 arc(316.53,71.91) 316.56,72.05 316.56,72.56 316.3,72.81 316.3,73.32 316.56,73.58 316.56,74.08 316.3,74.34 316.3,74.85 316.56,75.1 316.56,75.66 316.33,75.89 316.33,76.45 316.56,76.68 316.56,93 arc(316.53,93.14) 316.45,93.27 293.62,116.09 arc(293.5,116.17) 293.35,116.2 273.21,116.2 arc(272.77,116.29) 272.4,116.54 244.14,144.79 arc(244.02,144.88) 243.87,144.9 234.34,144.9 234.29,144.88 234.29,144.88 arc(234.03,144.71) 233.72,144.65 232.09,144.65
FC50_RDP2: length 155.4
  TOP w0.147: U1.AW11 220.14,144.84 arc(220.24,144.86) 220.32,144.92 220.5,145.09 arc(220.54,145.15) 220.55,145.22 v4(220.55,145.29)
  SIG2 w0.112: v4(220.55,145.29) 220.55,145.07 arc(220.59,144.98) 220.68,144.94 220.88,144.94 arc(220.92,144.95) 220.95,144.97 arc(220.98,145.01) 220.99,145.05 220.99,145.35 arc(221.03,145.58) 221.16,145.77 arc(221.35,145.89) 221.57,145.94 225.62,145.94 arc(225.82,145.9) 225.99,145.79 arc(226.1,145.62) 226.14,145.42 226.14,145.21 arc(226.16,145.1) 226.22,145.02 arc(226.3,144.96) 226.4,144.94 231.97,144.94 232.06,145.03 232.09,145.03
  SIG2 w0.16: YJ33.A18 312.1,60.81 arc(312.14,61.02) 312.26,61.19 312.81,61.75 arc(312.88,61.85) 312.91,61.97 312.91,62.57 arc(312.94,62.72) 313.03,62.86 313.08,62.91 313.55,63.38 arc(313.93,63.95) 314.06,64.61 314.06,66.02 arc(314,66.31) 313.84,66.55 313.71,66.68 arc(313.55,66.93) 313.49,67.22 313.49,68.66 arc(313.55,68.95) 313.71,69.2 316.71,72.19 arc(316.87,72.44) 316.93,72.73 316.93,92.87 arc(316.84,93.31) 316.59,93.68 294.02,116.25 arc(293.65,116.5) 293.21,116.58 273.05,116.58 arc(272.9,116.61) 272.78,116.7 244.52,144.95 arc(244.15,145.2) 243.72,145.29 234.05,145.29 arc(233.74,145.22) 233.47,145.05 arc(233.46,145.04) 233.44,145.03 232.09,145.03
