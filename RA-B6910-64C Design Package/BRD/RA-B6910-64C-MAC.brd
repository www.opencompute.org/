# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC30_RDP0: length 52.4
  TOP w0.147: U1.H39 191.55,113.34 v4(191.5,113.34)
  SIG3 w0.112: 190.24,105.04 190.24,105.06 190.15,105.15 190.15,112.48 arc(190.16,112.53) 190.19,112.57 190.29,112.68 arc(190.33,112.71) 190.38,112.72 190.82,112.72 arc(191.05,112.81) 191.15,113.04 191.15,113.21 arc(191.18,113.3) 191.27,113.34 v4(191.5,113.34)
  SIG3 w0.16: YJ27.C24 187.7,64.75 arc(187.75,65.01) 187.9,65.24 188.34,65.67 arc(188.46,65.86) 188.51,66.08 188.51,66.57 arc(188.53,66.71) 188.61,66.83 arc(188.62,66.85) 188.63,66.86 189.09,67.32 arc(189.26,67.57) 189.31,67.86 189.31,71.68 arc(189.26,71.97) 189.09,72.22 188.55,72.76 arc(188.38,73.01) 188.32,73.3 188.32,90.25 arc(188.38,90.54) 188.55,90.79 189.63,91.87 arc(189.79,92.12) 189.85,92.41 189.85,97.16 189.85,97.16 189.85,103.42 190.24,103.81 190.24,105.04
FC30_RDP1: length 57.5
  TOP w0.147: v4(190.6,115.34) 190.67,115.34 arc(190.74,115.36) 190.8,115.39 190.91,115.51 arc(191.01,115.66) U1.K40
  SIG3 w0.112: 191.86,105.04 191.95,105.12 191.95,114.5 arc(191.94,114.55) 191.91,114.59 191.81,114.69 arc(191.77,114.72) 191.72,114.73 191.27,114.73 arc(191.05,114.83) 190.95,115.05 190.95,115.21 arc(190.91,115.3) 190.82,115.34 v4(190.6,115.34)
  SIG3 w0.16: 191.86,105.04 191.86,67.43 191.61,67.18 191.61,66.67 191.86,66.42 191.86,64.54 arc(191.8,64.25) 191.64,64 190.72,63.08 arc(190.47,62.92) 190.18,62.86 189.32,62.86 arc(189.1,62.77) 189.01,62.55 189.01,62.32 arc(189.04,62.13) 189.15,61.97 YJ27.C17
FC30_RDP2: length 59.9
  TOP w0.147: U1.M39 191.55,117.34 v4(191.5,117.34)
  SIG2 w0.112: v4(191.5,117.34) 191.27,117.34 arc(191.18,117.3) 191.15,117.21 191.15,117.04 arc(191.05,116.81) 190.82,116.72 190.37,116.72 arc(190.32,116.71) 190.28,116.68 190.18,116.58 arc(190.15,116.54) 190.14,116.49 190.14,105.17 190.24,105.08 190.24,105.05
  SIG2 w0.16: YJ27.C21 190.1,64.77 arc(190.15,65.02) 190.29,65.22 190.74,65.67 arc(190.86,65.86) 190.91,66.08 190.91,67.19 arc(190.83,67.6) 190.59,67.94 185.69,72.85 184.67,73.87 arc(184.48,74.15) 184.42,74.48 184.42,89.8 arc(184.47,90.09) 184.64,90.34 189.63,95.33 arc(189.79,95.58) 189.85,95.87 189.85,103.03 arc(189.86,103.11) 189.87,103.19 arc(189.94,103.35) 190.04,103.49 arc(190.19,103.7) 190.24,103.95 190.24,105.05
FC30_RDP3: length 68.4
  TOP w0.147: v4(190.6,119.34) 190.68,119.34 arc(190.75,119.36) 190.81,119.4 190.97,119.56 arc(191.03,119.64) 191.05,119.74 U1.P40
  SIG2 w0.112: v4(190.6,119.34) 190.82,119.34 arc(190.91,119.3) 190.95,119.21 190.95,119.05 arc(191.05,118.82) 191.27,118.73 191.73,118.73 arc(191.77,118.72) 191.82,118.69 191.91,118.6 arc(191.94,118.55) 191.95,118.51 191.95,105.17 191.86,105.08 191.86,105.05
  SIG2 w0.16: YJ27.C14 186.75,61.97 arc(186.64,62.13) 186.61,62.32 186.61,62.52 arc(186.71,62.76) 186.95,62.86 187.78,62.86 arc(188.07,62.92) 188.31,63.08 188.36,63.13 188.41,63.18 arc(188.5,63.26) 188.6,63.32 arc(188.77,63.38) 188.95,63.41 191.17,63.41 arc(191.46,63.46) 191.71,63.63 192.48,64.4 arc(192.64,64.64) 192.7,64.94 192.7,65.44 192.42,65.72 192.42,66.18 192.7,66.46 192.7,68.03 arc(192.64,68.32) 192.48,68.57 187.61,73.43 arc(187.45,73.68) 187.39,73.97 187.39,90.11 arc(187.48,90.54) 187.72,90.91 191.74,94.93 arc(191.83,95.06) 191.86,95.2 191.86,105.05
FC30_TDN0: length 61.7
  TOP w0.147: v4(193.5,106.34) 193.55,106.34 U1.A37
  SIG5 w0.112: v4(193.5,106.34) 193.27,106.34 arc(193.18,106.3) 193.15,106.21 193.15,106.04 arc(193.05,105.81) 192.82,105.72 192.35,105.72 arc(192.3,105.71) 192.26,105.68 192.19,105.61 arc(192.16,105.57) 192.16,105.52 192.16,105.07 192.25,104.98 192.25,104.95
  SIG5 w0.16: 192.25,104.95 192.25,89.37 arc(192.16,88.93) 191.91,88.56 187.88,84.53 arc(187.8,84.41) 187.77,84.26 187.77,72.83 arc(187.8,72.68) 187.88,72.56 191.86,68.58 arc(192.11,68.21) 192.19,67.77 192.19,64.3 arc(192.11,63.86) 191.86,63.49 191.73,63.36 arc(191.36,63.11) 190.92,63.03 181.75,63.03 arc(181.61,63) 181.48,62.91 181.46,62.89 181.43,62.86 arc(181.34,62.72) 181.31,62.57 181.31,62.08 arc(181.26,61.86) 181.14,61.67 180.67,61.2 arc(180.54,61.02) 180.5,60.8 YJ27.C6
FC30_TDN1: length 53.6
  TOP w0.147: v4(190.6,111.34) 190.6,111.44 arc(190.62,111.53) 190.67,111.61 190.8,111.74 arc(190.91,111.81) U1.F40
  SIG4 w0.112: 189.85,105.04 189.85,105.06 189.95,105.15 189.95,110.51 arc(189.97,110.63) 190.04,110.74 190.12,110.82 arc(190.23,110.89) 190.35,110.91 190.82,110.91 arc(190.91,110.95) 190.95,111.04 190.95,111.21 arc(190.91,111.3) 190.82,111.34 v4(190.6,111.34)
  SIG4 w0.16: YJ27.C37 177.15,65.97 arc(177.04,66.13) 177.01,66.32 177.01,66.62 arc(177.08,66.79) 177.25,66.86 177.78,66.86 arc(178.27,66.96) 178.68,67.23 178.74,67.29 178.89,67.44 178.89,67.72 179.33,68.16 179.61,68.16 179.97,68.52 179.97,68.8 180.41,69.24 180.69,69.24 183.86,72.42 arc(184.03,72.67) 184.09,72.96 184.09,72.96 184.09,90.74 arc(184.17,91.18) 184.42,91.55 189.36,96.49 arc(189.44,96.61) 189.47,96.76 189.47,102.72 arc(189.55,103.12) 189.77,103.45 arc(189.82,103.52) 189.85,103.59 arc(189.85,103.62) 189.85,103.65 189.85,105.04
FC30_TDN2: length 67.1
  TOP w0.147: v4(191.5,109.34) 191.55,109.34 U1.D39
  SIG4 w0.112: v4(191.5,109.34) 191.27,109.34 arc(191.18,109.3) 191.15,109.21 191.15,109.04 arc(191.18,108.95) 191.27,108.91 191.75,108.91 arc(191.87,108.89) 191.98,108.82 192.06,108.74 arc(192.13,108.63) 192.15,108.51 192.15,105.13 192.24,105.04 192.24,105.02
  SIG4 w0.16: YJ27.C3 178.1,60.69 arc(178.16,61.01) 178.34,61.28 178.74,61.67 arc(178.86,61.86) 178.91,62.08 178.91,62.57 arc(178.94,62.72) 179.03,62.86 179.08,62.91 arc(179.21,63) 179.35,63.03 191.06,63.03 arc(191.36,63.08) 191.6,63.25 191.96,63.61 arc(192.13,63.86) 192.19,64.15 192.19,67.78 arc(192.13,68.07) 191.96,68.32 187.99,72.29 arc(187.83,72.54) 187.77,72.83 187.77,90.49 arc(187.83,90.78) 187.99,91.03 192.02,95.05 arc(192.19,95.3) 192.24,95.59 192.24,104.06 192.24,104.06 192.24,105.02
FC30_TDN3: length 48.6
  TOP w0.147: U1.B40 191.05,107.79 arc(190.92,107.47) v4(190.6,107.34)
  SIG5 w0.112: 189.87,104.95 189.87,104.98 189.96,105.07 189.96,106.52 arc(189.98,106.65) 190.05,106.75 190.12,106.82 arc(190.23,106.89) 190.35,106.91 190.82,106.91 arc(190.91,106.95) 190.95,107.04 190.95,107.21 arc(190.91,107.3) 190.82,107.34 v4(190.6,107.34)
  SIG5 w0.16: YJ27.C34 179.55,65.97 arc(179.44,66.13) 179.41,66.32 179.41,66.54 arc(179.43,66.65) 179.49,66.75 arc(179.62,66.83) 179.77,66.86 180.76,66.86 arc(180.88,66.91) 180.93,67.03 180.93,68.66 arc(181.01,69.09) 181.26,69.46 181.8,70 181.8,70.15 182.38,70.74 182.53,70.74 183.97,72.18 arc(184.06,72.3) 184.09,72.45 184.09,73.21 183.99,73.31 183.99,74.18 184.09,74.28 184.09,89.82 arc(184.17,90.26) 184.42,90.63 189.31,95.52 arc(189.39,95.64) 189.42,95.79 189.42,101.1 189.29,101.23 189.29,102.04 189.42,102.17 189.42,102.93 arc(189.43,103.1) 189.47,103.26 arc(189.58,103.52) 189.76,103.74 arc(189.84,103.86) 189.87,104.01 189.87,104.95
FC30_TDP0: length 61.7
  TOP w0.147: U1.A38 193.05,106.79 arc(192.92,106.47) v4(192.6,106.34)
  SIG5 w0.112: 191.87,104.95 191.87,104.98 191.96,105.07 191.96,105.52 arc(191.98,105.65) 192.05,105.75 192.12,105.82 arc(192.23,105.89) 192.35,105.91 192.82,105.91 arc(192.91,105.95) 192.95,106.04 192.95,106.21 arc(192.91,106.3) 192.82,106.34 v4(192.6,106.34)
  SIG5 w0.16: YJ27.C5 179.55,61.97 arc(179.44,62.13) 179.41,62.32 179.41,62.54 arc(179.5,62.77) 179.73,62.86 180.58,62.86 arc(180.87,62.92) 181.11,63.08 181.16,63.13 181.21,63.18 arc(181.46,63.35) 181.75,63.41 190.92,63.41 arc(191.21,63.46) 191.46,63.63 191.59,63.76 arc(191.75,64.01) 191.81,64.3 191.81,67.77 arc(191.75,68.07) 191.59,68.31 191.05,68.85 190.86,68.85 190.3,69.42 190.3,69.61 189.76,70.15 189.57,70.15 189,70.71 189,70.9 187.61,72.29 arc(187.45,72.54) 187.39,72.83 187.39,84.26 arc(187.45,84.56) 187.61,84.8 191.64,88.83 arc(191.81,89.08) 191.87,89.37 191.87,104.95
FC30_TDP1: length 53.6
  TOP w0.147: U1.F39 191.55,111.34 v4(191.5,111.34)
  SIG4 w0.112: v4(191.5,111.34) 191.27,111.34 arc(191.18,111.3) 191.15,111.21 191.15,111.04 arc(191.05,110.81) 190.82,110.72 190.35,110.72 arc(190.3,110.71) 190.26,110.68 190.18,110.6 arc(190.15,110.56) 190.14,110.51 190.14,105.15 190.23,105.06 190.23,105.04
  SIG4 w0.16: YJ27.C36 178.1,64.79 arc(178.14,65.02) 178.27,65.21 178.74,65.67 arc(178.86,65.86) 178.91,66.08 178.91,66.76 arc(178.91,66.77) 178.91,66.78 arc(178.94,66.92) 179.02,67.04 179.38,67.4 179.38,67.4 180.1,68.12 184.13,72.15 arc(184.38,72.52) 184.47,72.96 184.47,90.74 arc(184.53,91.03) 184.69,91.28 189.63,96.22 arc(189.79,96.47) 189.85,96.76 189.85,102.72 arc(189.9,102.97) 190.04,103.19 arc(190.15,103.33) 190.22,103.5 arc(190.23,103.57) 190.23,103.65 190.23,105.04
FC30_TDP2: length 67.1
  TOP w0.147: v4(190.6,109.34) 190.6,109.44 arc(190.62,109.53) 190.67,109.61 190.8,109.74 arc(190.91,109.81) U1.D40
  SIG4 w0.112: v4(190.6,109.34) 190.82,109.34 arc(190.91,109.3) 190.95,109.21 190.95,109.04 arc(191.05,108.81) 191.27,108.72 191.75,108.72 arc(191.8,108.71) 191.84,108.68 191.92,108.6 arc(191.95,108.56) 191.96,108.51 191.96,105.13 191.86,105.04 191.86,105.02
  SIG4 w0.16: 191.86,105.02 191.86,103.9 191.86,103.9 191.86,95.59 arc(191.83,95.45) 191.75,95.32 187.72,91.3 arc(187.48,90.92) 187.39,90.49 187.39,72.83 arc(187.48,72.39) 187.72,72.02 190.62,69.13 190.62,68.77 190.98,68.41 191.33,68.41 191.69,68.05 arc(191.78,67.93) 191.81,67.78 191.81,64.15 arc(191.78,64) 191.69,63.88 191.33,63.52 arc(191.21,63.44) 191.06,63.41 179.35,63.41 arc(179.06,63.35) 178.81,63.18 178.76,63.13 178.71,63.08 arc(178.47,62.92) 178.18,62.86 177.33,62.86 arc(177.1,62.77) 177.01,62.54 177.01,62.32 arc(177.04,62.13) 177.15,61.97 YJ27.C2
FC30_TDP3: length 48.6
  TOP w0.147: U1.B39 191.55,107.34 v4(191.5,107.34)
  SIG5 w0.112: 190.25,104.95 190.25,104.98 190.16,105.07 190.16,106.52 arc(190.16,106.57) 190.19,106.61 190.26,106.68 arc(190.3,106.71) 190.35,106.72 190.82,106.72 arc(191.05,106.81) 191.15,107.04 191.15,107.21 arc(191.18,107.3) 191.27,107.34 v4(191.5,107.34)
  SIG5 w0.16: YJ27.C33 180.5,64.76 arc(180.55,65.01) 180.7,65.23 181.14,65.67 arc(181.26,65.86) 181.31,66.08 181.31,68.66 arc(181.36,68.95) 181.53,69.2 184.24,71.91 arc(184.41,72.16) 184.47,72.45 184.47,89.82 arc(184.53,90.11) 184.69,90.36 189.58,95.25 arc(189.74,95.49) 189.8,95.79 189.8,102.93 arc(189.81,103.05) 189.83,103.15 arc(189.91,103.32) 190.02,103.47 190.02,103.47 arc(190.19,103.72) 190.25,104.01 190.25,104.95
FC31_RDN0: length 74.3
  TOP w0.147: U1.G37 194.05,112.81 arc(194.02,112.64) 193.92,112.5 193.86,112.43 arc(193.78,112.38) 193.69,112.37 v4(193.6,112.37)
  SIG3 w0.112: v4(193.6,112.37) 193.77,112.37 arc(193.9,112.32) 193.95,112.19 193.95,112.06 arc(194.05,111.84) 194.27,111.74 195.74,111.74 arc(195.78,111.73) 195.83,111.7 195.91,111.62 arc(195.94,111.57) 195.95,111.53 195.95,105.14 195.86,105.05
  SIG3 w0.16: YJ27.D17 189.15,53.97 arc(189.04,54.13) 189.01,54.32 189.01,54.56 arc(189.1,54.77) 189.31,54.86 190.18,54.86 arc(190.47,54.92) 190.71,55.08 190.76,55.13 191.57,55.94 191.57,56.29 191.92,56.65 192.28,56.65 206.85,71.22 arc(207.02,71.47) 207.07,71.76 207.07,85.15 arc(207.04,85.3) 206.96,85.42 201.88,90.5 arc(201.64,90.87) 201.55,91.31 201.55,91.69 arc(201.52,91.84) 201.44,91.96 196.61,96.79 arc(196.37,97.16) 196.28,97.6 196.28,103.65 arc(196.27,103.72) 196.23,103.78 196.18,103.82 arc(195.94,104.18) 195.86,104.6 195.86,105.05
FC31_RDN1: length 69.6
  TOP w0.147: v4(194.5,114.34) 194.55,114.34 U1.J36
  SIG3 w0.112: 194.24,105.08 194.24,105.1 194.14,105.19 194.14,110.59 arc(194.12,110.71) 194.05,110.81 193.98,110.88 arc(193.88,110.95) 193.75,110.98 193.35,110.98 193.35,110.98 arc(193.31,110.99) 193.27,111.01 193.19,111.09 arc(193.16,111.13) 193.15,111.18 193.15,113.48 arc(193.16,113.53) 193.19,113.57 193.29,113.68 arc(193.33,113.71) 193.38,113.72 193.82,113.72 arc(194.05,113.81) 194.15,114.04 194.15,114.21 arc(194.18,114.3) 194.27,114.34 v4(194.5,114.34)
  SIG3 w0.16: YJ27.D21 190.1,56.72 arc(190.16,57.01) 190.32,57.25 190.74,57.67 arc(190.86,57.86) 190.91,58.08 190.91,58.57 arc(190.94,58.72) 191.03,58.86 203.18,71.01 arc(203.43,71.38) 203.52,71.82 203.52,79.56 arc(203.46,79.86) 203.29,80.1 202.09,81.31 arc(201.92,81.56) 201.87,81.85 201.87,86.57 arc(201.81,86.86) 201.64,87.11 194.79,93.96 arc(194.62,94.21) 194.57,94.5 194.57,103.71 arc(194.52,103.93) 194.4,104.11 arc(194.28,104.29) 194.24,104.51 194.24,105.08
FC31_RDN2: length 71.1
  TOP w0.147: v4(193.6,116.34) 193.68,116.34 arc(193.75,116.36) 193.8,116.4 193.97,116.56 arc(194.03,116.65) 194.05,116.74 U1.L37
  SIG2 w0.112: v4(193.6,116.34) 193.82,116.34 arc(193.91,116.3) 193.95,116.21 193.95,116.04 arc(193.91,115.95) 193.82,115.91 193.37,115.91 arc(193.25,115.89) 193.14,115.82 193.05,115.72 arc(192.98,115.62) 192.95,115.49 192.95,111.19 arc(192.98,111.03) 193.07,110.9 arc(193.21,110.81) 193.37,110.78 193.7,110.78 arc(193.79,110.76) 193.88,110.7 arc(193.93,110.62) 193.95,110.52 193.95,105.17 193.86,105.08 193.86,105.05
  SIG2 w0.16: YJ27.D25 186.75,57.97 arc(186.64,58.13) 186.61,58.32 186.61,58.54 arc(186.7,58.77) 186.92,58.86 187.78,58.86 arc(188.07,58.92) 188.31,59.08 188.36,59.13 188.41,59.18 arc(188.5,59.26) 188.6,59.32 arc(188.77,59.38) 188.95,59.41 191.24,59.41 arc(191.53,59.46) 191.78,59.63 192.14,59.99 192.14,60.37 192.47,60.71 192.85,60.71 194.56,62.42 arc(194.73,62.66) 194.78,62.95 194.78,68.99 arc(194.73,69.29) 194.56,69.53 189.77,74.32 arc(189.61,74.57) 189.55,74.86 189.55,81.47 arc(189.63,81.91) 189.88,82.28 194.07,86.47 arc(194.16,86.59) 194.18,86.74 194.18,102.07 arc(194.18,102.07) 194.18,102.08 194.13,102.12 arc(193.93,102.43) 193.86,102.78 193.86,105.05
FC31_RDN3: length 78
  TOP w0.147: v4(194.5,118.34) 194.55,118.34 U1.N36
  SIG2 w0.112: v4(194.5,118.34) 194.27,118.34 arc(194.18,118.3) 194.15,118.21 194.15,118.04 arc(194.18,117.95) 194.27,117.91 194.73,117.91 arc(194.85,117.89) 194.95,117.82 195.05,117.72 arc(195.12,117.62) 195.14,117.49 195.14,112.18 arc(195.16,112.09) 195.22,112.01 arc(195.3,111.95) 195.39,111.94 195.39,111.94 195.69,111.94 arc(195.87,111.9) 196.01,111.8 arc(196.11,111.66) 196.14,111.48 196.14,106.08 196.24,105.99 196.24,105.97
  SIG2 w0.16: 196.24,105.97 196.24,104.48 arc(196.29,104.2) 196.45,103.97 arc(196.6,103.75) 196.66,103.5 arc(196.66,103.48) 196.66,103.46 196.66,85.15 arc(196.6,84.86) 196.44,84.61 192.44,80.61 arc(192.27,80.36) 192.21,80.07 192.21,75.5 arc(192.24,75.35) 192.33,75.23 196.99,70.56 arc(197.24,70.19) 197.32,69.76 197.32,60.92 arc(197.24,60.48) 196.99,60.11 193.31,56.44 192.24,55.36 arc(191.87,55.11) 191.43,55.03 188.95,55.03 arc(188.86,55.01) 188.78,54.98 arc(188.73,54.95) 188.68,54.91 188.63,54.86 arc(188.54,54.72) 188.51,54.57 188.51,54.08 arc(188.46,53.86) 188.34,53.67 187.86,53.19 arc(187.74,53.02) 187.7,52.81 YJ27.D15
FC31_RDP0: length 74.3
  TOP w0.147: v4(194.5,112.37) 194.57,112.37 U1.G36
  SIG3 w0.112: 196.24,105.05 196.15,105.15 196.15,111.61 arc(196.14,111.66) 196.11,111.7 195.96,111.84 arc(195.86,111.91) 195.74,111.94 194.27,111.94 arc(194.18,111.97) 194.15,112.06 194.15,112.19 arc(194.2,112.32) 194.32,112.37 v4(194.5,112.37)
  SIG3 w0.16: YJ27.D18 190.1,52.76 arc(190.15,53.01) 190.29,53.23 190.74,53.67 arc(190.86,53.86) 190.91,54.08 190.91,54.57 arc(190.94,54.72) 191.03,54.86 207.12,70.95 arc(207.37,71.32) 207.45,71.76 207.45,85.15 arc(207.4,85.44) 207.23,85.69 202.15,90.77 arc(201.99,91.02) 201.93,91.31 201.93,91.69 arc(201.87,91.98) 201.71,92.23 196.88,97.06 arc(196.72,97.3) 196.66,97.6 196.66,103.65 arc(196.62,103.87) 196.5,104.05 196.45,104.09 arc(196.3,104.32) 196.24,104.6 196.24,105.05
FC31_RDP1: length 69.6
  TOP w0.147: v4(193.6,114.34) 193.67,114.34 arc(193.74,114.36) 193.8,114.39 193.91,114.51 arc(194.01,114.66) U1.J37
  SIG3 w0.112: 193.86,105.08 193.86,105.1 193.95,105.19 193.95,110.59 arc(193.94,110.63) 193.91,110.67 193.84,110.74 arc(193.8,110.77) 193.75,110.78 193.35,110.78 arc(193.23,110.8) 193.13,110.87 193.05,110.95 arc(192.98,111.06) 192.95,111.18 192.95,113.48 arc(192.98,113.61) 193.05,113.71 193.15,113.82 arc(193.26,113.89) 193.38,113.91 193.82,113.91 arc(193.91,113.95) 193.95,114.04 193.95,114.21 arc(193.91,114.3) 193.82,114.34 v4(193.6,114.34)
  SIG3 w0.16: 193.86,105.08 193.86,104.51 arc(193.93,104.15) 194.13,103.84 arc(194.17,103.78) 194.18,103.71 194.18,94.5 arc(194.27,94.06) 194.52,93.69 201.37,86.84 arc(201.46,86.71) 201.49,86.57 201.49,81.85 arc(201.57,81.41) 201.82,81.04 203.02,79.83 arc(203.11,79.71) 203.14,79.56 203.14,71.82 arc(203.08,71.53) 202.91,71.28 191.94,60.3 191.58,60.3 191.22,59.95 191.22,59.59 190.71,59.08 arc(190.47,58.92) 190.18,58.86 189.3,58.86 arc(189.09,58.77) 189.01,58.56 189.01,58.32 arc(189.04,58.13) 189.15,57.97 YJ27.D22
FC31_RDP2: length 71.1
  TOP w0.147: v4(194.5,116.34) 194.55,116.34 U1.L36
  SIG2 w0.112: 194.24,105.05 194.24,105.08 194.15,105.17 194.15,110.52 arc(194.12,110.7) 194.02,110.84 arc(193.87,110.94) 193.7,110.98 193.36,110.98 arc(193.28,110.99) 193.21,111.04 arc(193.17,111.11) 193.15,111.19 193.15,115.49 193.15,115.49 arc(193.16,115.54) 193.19,115.58 193.28,115.68 arc(193.32,115.71) 193.37,115.72 193.82,115.72 arc(194.05,115.81) 194.15,116.04 194.15,116.21 arc(194.18,116.3) 194.27,116.34 v4(194.5,116.34)
  SIG2 w0.16: 194.24,105.05 194.24,102.78 arc(194.28,102.57) 194.4,102.39 194.45,102.35 arc(194.54,102.22) 194.57,102.07 194.57,86.74 arc(194.51,86.45) 194.34,86.2 190.15,82.01 arc(189.99,81.76) 189.93,81.47 189.93,81.47 189.93,74.86 arc(189.96,74.72) 190.04,74.59 194.83,69.8 arc(195.08,69.43) 195.17,68.99 195.17,62.95 arc(195.08,62.52) 194.83,62.15 192.05,59.36 arc(191.67,59.11) 191.24,59.03 188.95,59.03 arc(188.86,59.01) 188.78,58.98 arc(188.73,58.95) 188.68,58.91 188.63,58.86 arc(188.54,58.72) 188.51,58.57 188.51,58.08 arc(188.46,57.86) 188.34,57.67 187.88,57.21 arc(187.75,57.02) 187.7,56.79 YJ27.D24
FC31_RDP3: length 78
  TOP w0.147: v4(193.6,118.34) 193.66,118.34 arc(193.71,118.35) 193.76,118.38 193.97,118.6 arc(194.03,118.68) 194.05,118.78 U1.N37
  SIG2 w0.112: 195.86,105.97 195.86,105.99 195.95,106.08 195.95,111.48 arc(195.93,111.58) 195.87,111.66 arc(195.79,111.72) 195.69,111.74 195.39,111.74 arc(195.22,111.77) 195.08,111.87 arc(194.98,112.01) 194.95,112.18 194.95,117.49 arc(194.94,117.54) 194.91,117.58 194.82,117.68 arc(194.77,117.71) 194.73,117.72 194.27,117.72 arc(194.05,117.81) 193.95,118.04 193.95,118.21 arc(193.91,118.3) 193.82,118.34 v4(193.6,118.34)
  SIG2 w0.16: 195.86,105.97 195.86,104.48 arc(195.94,104.06) 196.18,103.7 arc(196.25,103.6) 196.28,103.48 arc(196.28,103.47) 196.28,103.46 196.28,85.15 arc(196.25,85) 196.17,84.88 192.17,80.88 arc(191.92,80.51) 191.83,80.07 191.83,75.5 arc(191.89,75.21) 192.06,74.96 196.72,70.29 arc(196.89,70.05) 196.94,69.76 196.94,60.92 arc(196.89,60.63) 196.72,60.38 193.04,56.71 192.66,56.71 192.33,56.37 192.33,55.99 191.97,55.63 arc(191.72,55.46) 191.43,55.41 188.95,55.41 arc(188.77,55.38) 188.6,55.32 arc(188.5,55.26) 188.41,55.18 188.36,55.13 188.31,55.08 arc(188.07,54.92) 187.78,54.86 186.93,54.86 arc(186.7,54.77) 186.61,54.54 186.61,54.32 arc(186.64,54.13) 186.75,53.97 YJ27.D14
FC31_TDN0: length 74.5
  TOP w0.147: v4(195.5,109.34) 195.55,109.34 U1.D35
  SIG4 w0.112: v4(195.5,109.34) 195.27,109.34 arc(195.18,109.3) 195.15,109.21 195.15,109.04 arc(195.18,108.95) 195.27,108.91 195.74,108.91 arc(195.86,108.89) 195.97,108.82 196.05,108.74 arc(196.12,108.63) 196.14,108.51 196.14,105.06 196.24,104.97 196.24,104.94
  SIG4 w0.16: 196.24,104.94 196.24,104.33 arc(196.29,104.05) 196.45,103.82 arc(196.56,103.67) 196.63,103.5 arc(196.65,103.4) 196.66,103.3 196.66,85.14 arc(196.6,84.85) 196.44,84.6 192.44,80.61 arc(192.27,80.36) 192.21,80.07 192.21,75.9 arc(192.27,75.61) 192.44,75.36 196.31,71.49 arc(196.47,71.25) 196.53,70.95 196.53,60.77 arc(196.47,60.47) 196.31,60.23 191.33,55.25 arc(191.08,55.08) 190.79,55.03 181.75,55.03 arc(181.61,55) 181.48,54.91 181.43,54.86 arc(181.34,54.72) 181.31,54.57 181.31,54.08 arc(181.26,53.86) 181.14,53.67 180.61,53.15 arc(180.53,53.02) 180.5,52.87 YJ27.D6
FC31_TDN1: length 75.7
  TOP w0.147: U1.B36 195.05,107.79 arc(194.92,107.47) v4(194.6,107.34)
  SIG5 w0.112: v4(194.6,107.34) 194.82,107.34 arc(194.91,107.3) 194.95,107.21 194.95,107.04 arc(195.05,106.81) 195.27,106.72 195.75,106.72 arc(195.8,106.71) 195.84,106.68 195.91,106.61 arc(195.93,106.57) 195.94,106.52 195.94,105.17 195.85,105.08 195.85,105.05
  SIG5 w0.16: 195.85,105.05 195.85,104.49 arc(195.91,104.21) 196.06,103.97 arc(196.21,103.76) 196.28,103.5 arc(196.28,103.48) 196.28,103.45 196.28,85.31 arc(196.22,85.02) 196.06,84.77 192.06,80.77 arc(191.89,80.52) 191.83,80.23 191.83,75.72 arc(191.89,75.43) 192.06,75.18 196.42,70.82 arc(196.5,70.69) 196.53,70.55 196.53,63.83 196.41,63.7 196.41,62.89 196.53,62.76 196.53,62 196.41,61.87 196.41,61.06 196.53,60.93 196.53,60.15 arc(196.5,60) 196.42,59.88 192.17,55.63 arc(191.92,55.46) 191.63,55.41 179.35,55.41 arc(179.06,55.35) 178.81,55.18 178.76,55.13 178.71,55.08 arc(178.47,54.92) 178.18,54.86 177.32,54.86 arc(177.1,54.77) 177.01,54.55 177.01,54.32 arc(177.04,54.13) 177.15,53.97 YJ27.D2
FC31_TDN2: length 71
  TOP w0.147: U1.E37 193.55,110.34 v4(193.5,110.34)
  SIG4 w0.112: v4(193.5,110.34) 193.27,110.34 arc(193.18,110.3) 193.15,110.21 193.15,110.04 arc(193.18,109.95) 193.27,109.91 193.74,109.91 arc(193.86,109.89) 193.97,109.82 194.05,109.74 arc(194.12,109.63) 194.14,109.51 194.14,105.17 194.24,105.08 194.24,105.05
  SIG4 w0.16: 194.24,105.05 194.24,102.65 arc(194.28,102.44) 194.4,102.26 arc(194.52,102.07) 194.57,101.86 194.57,86.73 arc(194.51,86.44) 194.34,86.19 190.15,82 arc(189.99,81.76) 189.93,81.46 189.93,74.96 arc(189.99,74.67) 190.15,74.42 194.15,70.43 arc(194.32,70.18) 194.37,69.89 194.37,62.04 arc(194.32,61.74) 194.15,61.5 191.9,59.25 arc(191.66,59.08) 191.36,59.03 181.75,59.03 arc(181.61,59) 181.48,58.91 181.43,58.86 arc(181.34,58.72) 181.31,58.57 181.31,58.08 arc(181.26,57.86) 181.14,57.67 180.67,57.2 arc(180.54,57.02) 180.5,56.8 YJ27.D33
FC31_TDN3: length 71.1
  TOP w0.147: U1.C38 193.05,108.79 arc(192.92,108.47) v4(192.6,108.34)
  SIG5 w0.112: v4(192.6,108.34) 192.82,108.34 arc(192.91,108.3) 192.95,108.21 192.95,108.04 arc(193.05,107.81) 193.27,107.72 193.75,107.72 arc(193.8,107.71) 193.84,107.68 193.91,107.61 arc(193.93,107.57) 193.94,107.52 193.94,105.07 193.85,104.98 193.85,104.95
  SIG5 w0.16: YJ27.D37 177.15,57.97 arc(177.04,58.13) 177.01,58.32 177.01,58.53 arc(177.1,58.76) 177.34,58.86 178.18,58.86 arc(178.47,58.92) 178.71,59.08 178.76,59.13 178.81,59.18 arc(179.06,59.35) 179.35,59.41 190.7,59.41 arc(190.99,59.46) 191.24,59.63 193.78,62.17 arc(193.94,62.42) 194,62.71 194,69.74 arc(193.94,70.04) 193.78,70.28 193.24,70.82 193.05,70.82 192.49,71.39 192.49,71.58 191.95,72.12 191.76,72.12 191.19,72.68 191.19,72.87 189.77,74.29 arc(189.61,74.54) 189.55,74.83 189.55,81.72 arc(189.61,82.02) 189.77,82.26 193.96,86.45 arc(194.13,86.7) 194.18,86.99 194.18,102.82 arc(194.14,103.04) 194.02,103.22 arc(193.92,103.35) 193.86,103.5 arc(193.85,103.56) 193.85,103.63 193.85,104.95
FC31_TDP0: length 74.4
  TOP w0.147: v4(194.6,109.34) 194.6,109.44 arc(194.62,109.53) 194.67,109.61 194.8,109.74 arc(194.91,109.81) U1.D36
  SIG4 w0.112: v4(194.6,109.34) 194.82,109.34 arc(194.91,109.3) 194.95,109.21 194.95,109.04 arc(195.05,108.81) 195.27,108.72 195.74,108.72 arc(195.79,108.71) 195.83,108.68 195.91,108.6 arc(195.94,108.56) 195.95,108.51 195.95,105.06 195.86,104.97 195.86,104.94
  SIG4 w0.16: 195.86,104.94 195.86,104.33 arc(195.94,103.9) 196.18,103.55 arc(196.23,103.48) 196.27,103.4 arc(196.28,103.35) 196.28,103.31 196.28,85.14 arc(196.25,85) 196.17,84.87 192.17,80.88 arc(191.92,80.5) 191.83,80.07 191.83,75.9 arc(191.92,75.47) 192.17,75.1 196.04,71.22 arc(196.12,71.1) 196.15,70.95 196.15,60.77 arc(196.12,60.62) 196.04,60.5 194.72,59.17 194.36,59.17 194,58.81 194,58.45 191.06,55.52 arc(190.94,55.44) 190.79,55.41 181.75,55.41 arc(181.46,55.35) 181.21,55.18 181.16,55.13 181.11,55.08 arc(180.87,54.92) 180.58,54.86 179.68,54.86 arc(179.49,54.78) 179.41,54.59 179.41,54.32 arc(179.44,54.13) 179.55,53.97 YJ27.D5
FC31_TDP1: length 75.7
  TOP w0.147: U1.B35 195.55,107.34 v4(195.5,107.34)
  SIG5 w0.112: v4(195.5,107.34) 195.27,107.34 arc(195.18,107.3) 195.15,107.21 195.15,107.04 arc(195.18,106.95) 195.27,106.91 195.75,106.91 arc(195.87,106.89) 195.98,106.82 196.04,106.75 arc(196.11,106.65) 196.14,106.52 196.14,105.17 196.23,105.08 196.23,105.05
  SIG5 w0.16: 196.23,105.05 196.23,104.49 arc(196.26,104.35) 196.33,104.24 arc(196.56,103.91) 196.66,103.53 196.66,103.53 arc(196.66,103.49) 196.66,103.45 196.66,85.31 arc(196.57,84.87) 196.32,84.5 192.33,80.5 arc(192.24,80.38) 192.21,80.23 192.21,75.72 arc(192.24,75.57) 192.33,75.45 196.69,71.09 arc(196.86,70.84) 196.91,70.55 196.91,60.15 arc(196.86,59.86) 196.69,59.61 192.44,55.36 arc(192.07,55.11) 191.63,55.03 179.35,55.03 arc(179.21,55) 179.08,54.91 179.06,54.89 179.03,54.86 arc(178.95,54.76) 178.91,54.64 arc(178.91,54.6) 178.91,54.57 178.91,54.08 arc(178.86,53.86) 178.74,53.67 178.33,53.27 arc(178.16,53.01) 178.1,52.71 YJ27.D3
FC31_TDP2: length 71
  TOP w0.147: v4(192.6,110.34) 192.6,110.44 arc(192.62,110.53) 192.67,110.61 192.8,110.74 arc(192.91,110.81) U1.E38
  SIG4 w0.112: v4(192.6,110.34) 192.82,110.34 arc(192.91,110.3) 192.95,110.21 192.95,110.04 arc(193.05,109.81) 193.27,109.72 193.74,109.72 arc(193.79,109.71) 193.83,109.68 193.91,109.6 arc(193.94,109.56) 193.95,109.51 193.95,105.17 193.86,105.08 193.86,105.05
  SIG4 w0.16: YJ27.D34 179.55,57.97 arc(179.44,58.13) 179.41,58.32 179.41,58.59 arc(179.49,58.78) 179.68,58.86 180.58,58.86 arc(180.87,58.92) 181.11,59.08 181.16,59.13 181.21,59.18 arc(181.46,59.35) 181.75,59.41 191.36,59.41 arc(191.51,59.44) 191.63,59.52 192.54,60.42 192.54,60.78 192.9,61.14 193.26,61.14 193.88,61.77 arc(193.96,61.89) 193.99,62.04 193.99,69.89 arc(193.96,70.03) 193.88,70.16 189.88,74.16 arc(189.63,74.53) 189.55,74.96 189.55,81.46 arc(189.63,81.9) 189.88,82.27 194.07,86.46 arc(194.16,86.59) 194.18,86.73 194.18,101.86 arc(194.17,101.93) 194.13,101.99 arc(193.93,102.29) 193.86,102.65 193.86,105.05
FC31_TDP3: length 71.1
  TOP w0.147: U1.C37 193.55,108.34 v4(193.5,108.34)
  SIG5 w0.112: v4(193.5,108.34) 193.27,108.34 arc(193.18,108.3) 193.15,108.21 193.15,108.04 arc(193.18,107.95) 193.27,107.91 193.75,107.91 arc(193.87,107.89) 193.98,107.82 194.04,107.75 arc(194.11,107.65) 194.14,107.52 194.14,105.07 194.23,104.98 194.23,104.95
  SIG5 w0.16: YJ27.D36 178.1,56.87 arc(178.13,57.02) 178.22,57.15 178.74,57.67 arc(178.86,57.86) 178.91,58.08 178.91,58.57 arc(178.91,58.6) 178.91,58.64 arc(178.95,58.76) 179.03,58.86 179.08,58.91 arc(179.21,59) 179.35,59.03 190.7,59.03 arc(191.14,59.11) 191.51,59.36 194.05,61.9 arc(194.3,62.27) 194.38,62.71 194.38,69.74 arc(194.3,70.18) 194.05,70.55 190.04,74.56 arc(189.96,74.69) 189.93,74.83 189.93,81.72 arc(189.96,81.87) 190.04,81.99 194.23,86.18 arc(194.48,86.55) 194.57,86.99 194.57,102.82 arc(194.49,103.18) 194.29,103.49 arc(194.26,103.54) 194.24,103.59 arc(194.23,103.61) 194.23,103.63 194.23,104.95
FC32_33_PVDD0P8: length 5.6
  TOP w0.229: U1.Y31 v1(200.55,125.34) ; U1.Y29 v1(202.55,125.34)
  TOP w0.381: C3077.1 198.82,98.93 ; C3077.1 198.03,98.32 ; C3077.1 198.03,99.54
  BOTTOM w0.13: v1(199.2,99.44) v2(198.44,99.44)
  BOTTOM w0.381: v1(202.55,125.34) 203.03,125.83 C3336.1 ; v1(200.55,125.34) 200.19,125.7 200.07,125.83 C3029.1
  vias: v1(199.2,98.42)
FC32_47_PVDD1P8: length 14.9
  TOP w0.229: U1.AJ18 v1(213.55,134.34) ; U1.AF18 v1(213.55,131.34) ; U1.Y24 v1(207.55,125.34) ; U1.Y27 v1(204.55,125.34) ; U1.Y30 v1(201.55,125.34) ; U1.Y21 v1(210.55,125.34) ; U1.AC18 v1(213.55,128.34) ; U1.AM18 v1(213.55,137.34)
  TOP w0.381: C2665.1 198.03,96.03 ; C2665.1 198.03,97.25 ; C2665.1 198.82,96.64
  TOP w0.508: L438.1 200.09,96.64
  BOTTOM w0.13: v1(199.2,97.15) v2(199.96,97.15)
  BOTTOM w0.381: C2977.1 211.07,124.82 v1(210.55,125.34) ; C2795.1 213.07,127.86 v1(213.55,128.34) ; v1(207.55,125.34) 207.07,125.82 C2887.1 ; v1(201.55,125.34) 201.07,125.83 C2953.1 ; v1(213.55,137.34) 213.07,136.86 C2853.1 ; v1(213.55,134.34) 213.07,133.86 C2777.1 ; C2717.1 213.07,130.86 v1(213.55,131.34) ; C3114.1 205.02,125.82 v1(204.55,125.34)
  vias: v1(199.2,96.14)
FC32_RDN0: length 65.7
  TOP w0.147: U1.G33 198.05,112.72 arc(198.07,112.61) 198.13,112.52 198.18,112.47 arc(198.32,112.38) 198.5,112.34 v4(198.5,112.34)
  SIG9 w0.112: v4(198.5,112.34) 198.25,112.34 arc(198.18,112.31) 198.15,112.24 198.15,112.02 arc(198.16,111.98) 198.18,111.94 arc(198.22,111.91) 198.26,111.91 198.64,111.91 arc(198.81,111.87) 198.95,111.78 198.99,111.74 arc(199.11,111.56) 199.15,111.35 199.15,105.07 arc(199.16,105) 199.21,104.94 arc(199.23,104.9) 199.24,104.85
  SIG9 w0.16: YJ30.D22 206.25,57.97 arc(206.36,58.14) 206.4,58.34 206.4,58.52 arc(206.3,58.76) 206.06,58.86 205.03,58.86 arc(204.86,58.9) 204.71,58.99 202.67,61.04 202.67,61.35 202.25,61.76 201.95,61.76 201.15,62.55 arc(200.98,62.8) 200.93,63.09 200.93,69.73 arc(200.98,70.03) 201.15,70.27 205.78,74.91 arc(205.95,75.15) 206.01,75.45 206.01,86.63 arc(205.95,86.92) 205.78,87.17 201.85,91.1 arc(201.69,91.35) 201.63,91.64 201.63,91.91 arc(201.58,92.16) 201.44,92.38 197.67,96.14 arc(197.5,96.39) 197.44,96.68 197.44,100.92 arc(197.5,101.22) 197.67,101.46 199.02,102.81 arc(199.18,103.06) 199.24,103.35 199.24,103.5 arc(199.24,103.51) 199.24,103.51 199.24,104.85
FC32_RDN1: length 72.1
  TOP w0.147: v4(197.6,114.34) 197.55,114.34 U1.J34
  SIG9 w0.112: 196.86,104.82 196.86,104.85 arc(196.86,104.87) 196.87,104.89 196.9,104.92 arc(196.94,104.97) 196.95,105.03 196.95,112.43 arc(197.02,112.8) 197.23,113.11 197.78,113.67 arc(197.91,113.85) 197.95,114.07 197.95,114.24 arc(197.92,114.31) 197.85,114.34 v4(197.6,114.34)
  SIG9 w0.16: 196.86,104.82 196.86,104.52 arc(196.8,104.23) 196.63,103.98 196.38,103.73 arc(196.13,103.56) 195.84,103.5 195.45,103.5 arc(195.01,103.42) 194.64,103.17 194.52,103.04 arc(194.27,102.67) 194.18,102.23 194.18,95.92 arc(194.53,94.16) 195.53,92.66 198.33,89.86 200.96,87.23 arc(201.35,86.65) 201.49,85.97 201.49,82.1 arc(201.57,81.66) 201.82,81.29 202.01,81.1 arc(202.09,80.98) 202.12,80.83 202.12,75.88 arc(202.09,75.73) 202.01,75.61 198.8,72.4 arc(198.55,72.03) 198.46,71.59 198.46,61.17 arc(198.55,60.74) 198.8,60.37 204.35,54.82 204.39,54.77 arc(204.46,54.68) 204.5,54.58 arc(204.51,54.53) 204.51,54.48 204.51,54.07 arc(204.56,53.84) 204.69,53.65 205.03,53.31 arc(205.23,53) 205.3,52.65 YJ30.D18
FC32_RDN2: length 70.9
  TOP w0.147: U1.L33 198.05,116.73 arc(198.07,116.62) 198.13,116.53 198.19,116.47 arc(198.33,116.37) v4(198.5,116.34)
  SIG8 w0.112: 199.24,104.98 199.14,105.08 199.14,115.35 arc(199.1,115.56) 198.98,115.74 198.95,115.78 arc(198.81,115.87) 198.64,115.91 198.26,115.91 arc(198.22,115.91) 198.18,115.94 arc(198.16,115.98) 198.15,116.02 198.15,116.24 arc(198.18,116.31) 198.25,116.34 v4(198.5,116.34)
  SIG8 w0.16: YJ30.D25 208.65,57.97 arc(208.78,58.17) 208.83,58.39 208.83,58.43 arc(208.8,58.57) 208.72,58.69 arc(208.53,58.82) 208.3,58.86 207.42,58.86 arc(207.39,58.86) 207.35,58.87 arc(207.22,58.91) 207.11,58.99 206.93,59.17 arc(206.68,59.34) 206.39,59.39 204.79,59.39 arc(204.49,59.45) 204.25,59.62 201.62,62.24 arc(201.46,62.49) 201.4,62.78 201.4,70.21 arc(201.46,70.5) 201.62,70.75 203.06,72.18 203.35,72.18 203.78,72.61 203.78,72.9 205.78,74.91 arc(205.95,75.15) 206.01,75.45 206.01,86.61 arc(205.95,86.9) 205.78,87.15 202.47,90.46 arc(202.31,90.71) 202.25,91 202.25,91.58 arc(202.19,91.87) 202.02,92.12 198.41,95.74 arc(198.24,95.98) 198.18,96.27 198.18,101.64 arc(198.24,101.93) 198.41,102.18 199.02,102.79 arc(199.18,103.04) 199.24,103.33 199.24,104.98
FC32_RDN3: length 79.2
  TOP w0.147: U1.N34 197.55,118.34 v4(197.6,118.34)
  SIG8 w0.112: 196.55,105.63 196.64,105.73 196.64,106.28 arc(196.67,106.48) 196.75,106.66 arc(196.8,106.72) 196.85,106.78 196.86,106.8 arc(196.93,106.9) 196.95,107.01 196.95,117.35 arc(197,117.56) 197.11,117.74 197.15,117.78 arc(197.29,117.87) 197.46,117.91 197.83,117.91 arc(197.88,117.91) 197.92,117.94 arc(197.94,117.98) 197.95,118.02 197.95,118.24 arc(197.92,118.31) 197.85,118.34 v4(197.6,118.34)
  SIG8 w0.16: 196.55,105.63 196.55,104.77 arc(196.52,104.63) 196.43,104.5 194.52,102.58 arc(194.27,102.21) 194.18,101.78 194.18,94.57 arc(194.27,94.13) 194.52,93.76 201.75,86.52 arc(201.84,86.4) 201.87,86.25 201.87,81.92 arc(201.95,81.49) 202.2,81.11 203.15,80.16 arc(203.23,80.04) 203.26,79.89 203.26,76.28 arc(203.23,76.14) 203.15,76.02 199.19,72.06 arc(198.95,71.69) 198.86,71.25 198.86,60.39 arc(198.95,59.96) 199.19,59.59 203.43,55.35 arc(203.8,55.1) 204.24,55.01 206.39,55.01 arc(206.54,54.98) 206.66,54.9 206.75,54.82 206.75,54.81 206.79,54.77 arc(206.85,54.7) 206.89,54.61 arc(206.91,54.54) 206.91,54.48 206.91,54.1 arc(206.96,53.84) 207.11,53.63 207.45,53.29 arc(207.63,53.01) 207.7,52.68 YJ30.D15
FC32_RDP0: length 65.7
  TOP w0.147: v4(197.6,112.34) 197.55,112.34 U1.G34
  SIG9 w0.112: v4(197.6,112.34) 197.85,112.34 arc(197.92,112.31) 197.95,112.24 197.95,112.02 arc(197.97,111.9) 198.04,111.8 arc(198.14,111.73) 198.26,111.71 198.64,111.71 arc(198.74,111.69) 198.82,111.64 198.85,111.6 arc(198.93,111.49) 198.95,111.35 198.95,105.07 arc(198.94,105) 198.9,104.94 arc(198.87,104.9) 198.86,104.85
  SIG9 w0.16: 198.86,104.85 198.86,103.51 arc(198.86,103.51) 198.86,103.5 arc(198.86,103.5) 198.86,103.5 198.86,103.35 arc(198.83,103.21) 198.75,103.08 197.4,101.73 arc(197.15,101.36) 197.06,100.92 197.06,96.68 arc(197.15,96.25) 197.4,95.87 201.17,92.11 arc(201.23,92.02) 201.25,91.91 201.25,91.64 arc(201.33,91.2) 201.58,90.83 205.51,86.9 arc(205.6,86.78) 205.63,86.63 205.63,75.45 arc(205.6,75.3) 205.51,75.18 200.88,70.54 arc(200.63,70.17) 200.55,69.73 200.55,63.09 arc(200.63,62.65) 200.88,62.28 204.35,58.82 204.39,58.77 arc(204.45,58.7) 204.49,58.62 arc(204.49,58.61) 204.5,58.59 arc(204.51,58.54) 204.51,58.48 204.51,58.07 arc(204.56,57.84) 204.69,57.65 205.21,57.13 arc(205.28,57.03) 205.3,56.91 YJ30.D21
FC32_RDP1: length 72.1
  TOP w0.147: U1.J33 198.05,114.72 arc(198.07,114.61) 198.13,114.52 198.18,114.47 arc(198.32,114.38) 198.5,114.34 v4(198.5,114.34)
  SIG9 w0.112: 197.24,104.82 197.24,104.85 arc(197.23,104.87) 197.22,104.89 197.19,104.92 arc(197.16,104.97) 197.14,105.03 197.14,112.43 arc(197.2,112.73) 197.37,112.97 197.92,113.53 arc(198.09,113.78) 198.15,114.07 198.15,114.24 arc(198.18,114.31) 198.25,114.34 v4(198.5,114.34)
  SIG9 w0.16: YJ30.D17 206.25,53.97 arc(206.36,54.14) 206.4,54.34 206.4,54.52 arc(206.3,54.76) 206.06,54.86 205.16,54.86 arc(205.09,54.86) 205.02,54.87 arc(204.8,54.95) 204.62,55.08 201.87,57.83 201.87,58.12 201.43,58.55 201.15,58.55 199.07,60.63 arc(198.9,60.88) 198.84,61.17 198.84,71.59 arc(198.9,71.88) 199.07,72.13 202.28,75.34 arc(202.44,75.59) 202.5,75.88 202.5,80.83 arc(202.44,81.13) 202.28,81.37 202.09,81.56 arc(201.92,81.81) 201.87,82.1 201.87,85.97 arc(201.7,86.8) 201.23,87.5 198.6,90.13 198.44,90.29 195.8,92.93 arc(194.89,94.3) 194.56,95.92 194.56,102.23 arc(194.62,102.52) 194.79,102.77 194.91,102.9 arc(195.16,103.06) 195.45,103.12 195.84,103.12 arc(196.27,103.21) 196.64,103.46 196.9,103.71 arc(197.15,104.08) 197.24,104.52 197.24,104.82
FC32_RDP2: length 70.9
  TOP w0.147: v4(197.6,116.34) 197.55,116.34 U1.L34
  SIG8 w0.112: 198.86,104.98 198.95,105.07 198.95,115.35 arc(198.92,115.49) 198.84,115.6 198.81,115.64 arc(198.73,115.69) 198.64,115.71 198.26,115.71 arc(198.14,115.73) 198.04,115.8 arc(197.97,115.9) 197.95,116.02 197.95,116.24 arc(197.92,116.31) 197.85,116.34 v4(197.6,116.34)
  SIG8 w0.16: YJ30.D24 207.7,56.82 arc(207.66,57.02) 207.55,57.19 207.14,57.59 arc(206.97,57.85) 206.91,58.15 206.91,58.42 arc(206.9,58.53) 206.87,58.63 arc(206.82,58.73) 206.75,58.82 206.66,58.9 arc(206.54,58.98) 206.39,59.01 204.79,59.01 arc(204.35,59.1) 203.98,59.35 201.35,61.97 arc(201.1,62.34) 201.02,62.78 201.02,70.21 arc(201.1,70.64) 201.35,71.02 205.51,75.18 arc(205.6,75.3) 205.63,75.45 205.63,86.61 arc(205.6,86.75) 205.51,86.88 202.2,90.19 arc(201.95,90.56) 201.87,91 201.87,91.58 arc(201.84,91.72) 201.75,91.85 198.14,95.47 arc(197.89,95.84) 197.8,96.27 197.8,101.64 arc(197.89,102.07) 198.14,102.45 198.75,103.06 arc(198.83,103.18) 198.86,103.33 198.86,104.98
FC32_RDP3: length 79.2
  TOP w0.147: U1.N33 198.05,118.73 arc(198.07,118.62) 198.13,118.53 198.19,118.47 arc(198.33,118.37) v4(198.5,118.34)
  SIG8 w0.112: 196.93,105.63 196.84,105.72 196.84,106.28 arc(196.86,106.42) 196.92,106.55 arc(196.95,106.6) 196.99,106.64 197,106.66 arc(197.11,106.82) 197.15,107.01 197.15,117.35 arc(197.18,117.49) 197.25,117.6 197.29,117.64 arc(197.37,117.69) 197.46,117.71 197.83,117.71 arc(197.95,117.73) 198.06,117.8 arc(198.12,117.9) 198.15,118.02 198.15,118.24 arc(198.18,118.31) 198.25,118.34 v4(198.5,118.34)
  SIG8 w0.16: 196.93,105.63 196.93,104.77 arc(196.87,104.48) 196.7,104.23 194.79,102.31 arc(194.62,102.07) 194.56,101.78 194.56,94.57 arc(194.62,94.27) 194.79,94.03 202.02,86.79 arc(202.19,86.54) 202.25,86.25 202.25,81.92 arc(202.31,81.63) 202.47,81.38 203.42,80.43 arc(203.59,80.19) 203.64,79.89 203.64,76.28 arc(203.59,75.99) 203.42,75.75 199.46,71.79 arc(199.3,71.54) 199.24,71.25 199.24,60.39 arc(199.3,60.1) 199.46,59.86 201.25,58.07 201.56,58.07 201.97,57.66 201.97,57.35 203.7,55.62 arc(203.95,55.45) 204.24,55.39 206.39,55.39 arc(206.68,55.34) 206.93,55.17 207.11,54.99 arc(207.25,54.89) 207.42,54.86 208.4,54.86 arc(208.55,54.83) 208.68,54.75 208.68,54.75 arc(208.77,54.61) 208.8,54.45 208.8,54.34 arc(208.76,54.14) 208.65,53.97 YJ30.D14
FC32_TDN0: length 74.6
  TOP w0.147: U1.A34 197.55,106.34 v4(197.6,106.34)
  SIG7 w0.112: v4(197.6,106.34) 197.8,106.34 arc(197.91,106.3) 197.95,106.2 197.95,106.06 arc(197.94,106.01) 197.91,105.96 197.9,105.95 arc(197.85,105.92) 197.78,105.91 197.35,105.91 arc(197.19,105.87) 197.06,105.79 arc(196.98,105.66) 196.95,105.5 196.95,104.77 196.86,104.68 196.86,104.65
  SIG7 w0.16: YJ30.D3 217.3,52.83 arc(217.26,53.02) 217.16,53.18 216.69,53.65 arc(216.56,53.84) 216.51,54.07 216.51,54.48 arc(216.51,54.53) 216.5,54.58 arc(216.5,54.58) 216.5,54.58 arc(216.49,54.59) 216.49,54.61 arc(216.45,54.7) 216.39,54.77 216.35,54.82 216.26,54.9 arc(216.14,54.98) 215.99,55.01 204.13,55.01 arc(203.92,55.06) 203.74,55.18 199.22,59.7 arc(199.1,59.88) 199.05,60.09 199.05,71.56 arc(199.11,71.85) 199.28,72.09 203.15,75.97 arc(203.23,76.09) 203.26,76.24 203.26,78.78 arc(203.23,78.93) 203.15,79.05 202.09,80.11 arc(201.92,80.36) 201.87,80.65 201.87,86.29 arc(201.84,86.43) 201.75,86.56 197.19,91.12 arc(196.94,91.49) 196.86,91.93 196.86,104.65
FC32_TDN1: length 70.8
  TOP w0.147: U1.C33 198.05,108.79 arc(198.18,108.47) v4(198.5,108.34)
  SIG6 w0.112: v4(198.5,108.34) 198.27,108.34 arc(198.18,108.3) 198.15,108.21 198.15,108.05 arc(198.16,108.01) 198.18,107.96 198.2,107.95 arc(198.25,107.92) 198.31,107.91 198.75,107.91 arc(198.9,107.87) 199.03,107.79 arc(199.12,107.66) 199.15,107.5 199.15,104.92 199.24,104.83 199.24,104.8
  SIG6 w0.16: 199.24,104.8 199.24,103.4 arc(199.18,103.11) 199.02,102.86 198.13,101.97 arc(197.96,101.73) 197.9,101.43 197.9,95.57 arc(197.96,95.28) 198.13,95.03 199.38,93.78 200.23,93.78 arc(200.52,93.72) 200.77,93.55 202.01,92.31 arc(202.18,92.06) 202.24,91.77 202.24,91.24 arc(202.3,90.94) 202.46,90.7 205.78,87.37 arc(205.95,87.13) 206.01,86.83 206.01,75.73 arc(205.92,75.29) 205.67,74.92 201.63,70.88 arc(201.54,70.75) 201.51,70.61 201.51,62.91 arc(201.57,62.62) 201.74,62.37 203.07,61.04 203.36,61.04 203.72,60.68 203.72,60.39 204.49,59.62 arc(204.74,59.45) 205.03,59.39 213.59,59.39 arc(213.88,59.34) 214.13,59.17 214.3,59 arc(214.46,58.9) 214.64,58.86 215.66,58.86 arc(215.9,58.76) 216,58.52 216,58.34 arc(215.96,58.14) 215.85,57.97 YJ30.D34
FC32_TDN2: length 77.9
  TOP w0.147: U1.E34 197.55,110.34 v4(197.6,110.34)
  SIG6 w0.112: v4(197.6,110.34) 197.73,110.34 arc(197.81,110.33) 197.89,110.28 arc(197.93,110.21) 197.95,110.12 197.95,109.8 arc(197.93,109.7) 197.87,109.62 197.14,108.89 arc(197,108.67) 196.95,108.42 196.95,107.1 196.86,107.01
  SIG6 w0.16: YJ30.D6 214.9,52.83 arc(214.86,53.02) 214.76,53.18 214.29,53.65 arc(214.16,53.84) 214.11,54.07 214.11,54.48 arc(214.11,54.53) 214.1,54.58 arc(214.1,54.59) 214.09,54.6 arc(214.09,54.62) 214.08,54.64 arc(214.04,54.71) 213.99,54.77 213.95,54.82 213.86,54.9 arc(213.74,54.98) 213.59,55.01 204.44,55.01 arc(204.01,55.1) 203.63,55.35 199.28,59.7 arc(199.03,60.07) 198.95,60.51 198.95,71.31 arc(199.03,71.75) 199.28,72.12 203.15,75.99 arc(203.23,76.11) 203.26,76.26 203.26,78.54 arc(203.21,78.83) 203.04,79.08 202.09,80.03 arc(201.92,80.28) 201.87,80.57 201.87,86.23 arc(201.84,86.38) 201.75,86.5 194.41,93.85 arc(194.24,94.09) 194.18,94.39 194.18,103.63 arc(194.27,104.07) 194.52,104.44 196.83,106.75 arc(196.85,106.78) 196.86,106.81 196.86,107.01
FC32_TDN3: length 71
  TOP w0.147: U1.B31 200.05,107.79 arc(200.06,107.74) 200.09,107.69 200.4,107.38 arc(200.44,107.35) v4(200.5,107.34)
  SIG7 w0.112: v4(200.5,107.34) 200.27,107.34 arc(200.18,107.3) 200.15,107.21 200.15,107.05 arc(200.12,106.93) 200.05,106.83 200.04,106.81 arc(199.92,106.74) 199.79,106.71 199.35,106.71 arc(199.27,106.69) 199.2,106.65 arc(199.16,106.58) 199.14,106.5 199.14,104.9 199.24,104.81 199.24,104.78
  SIG7 w0.16: YJ30.D37 218.25,57.97 arc(218.36,58.14) 218.4,58.34 218.4,58.52 arc(218.3,58.76) 218.06,58.86 217.16,58.86 arc(216.86,58.92) 216.62,59.08 216.53,59.17 arc(216.28,59.34) 215.99,59.39 204.25,59.39 arc(203.96,59.45) 203.71,59.62 203.03,60.3 203.03,60.6 202.68,60.95 202.38,60.95 201.74,61.59 arc(201.57,61.84) 201.51,62.13 201.51,70.3 arc(201.57,70.59) 201.74,70.84 205.78,74.88 arc(205.95,75.13) 206.01,75.42 206.01,86.75 arc(205.95,87.04) 205.78,87.29 201.58,91.49 arc(201.42,91.74) 201.36,92.03 201.36,101.54 arc(201.3,101.83) 201.14,102.07 199.46,103.75 arc(199.29,104) 199.24,104.29 199.24,104.78
FC32_TDP0: length 74.6
  TOP w0.147: U1.A33 198.05,106.79 arc(198.18,106.47) v4(198.5,106.34)
  SIG7 w0.112: v4(198.5,106.34) 198.31,106.34 arc(198.2,106.29) 198.15,106.18 198.15,106.06 arc(198.12,105.93) 198.05,105.82 198.04,105.81 arc(197.92,105.74) 197.78,105.71 197.35,105.71 arc(197.27,105.69) 197.2,105.65 arc(197.16,105.58) 197.14,105.5 197.14,104.77 197.24,104.68 197.24,104.65
  SIG7 w0.16: YJ30.D2 218.25,53.97 arc(218.36,54.14) 218.4,54.34 218.4,54.52 arc(218.3,54.76) 218.06,54.86 217.06,54.86 arc(216.86,54.9) 216.69,55.02 216.53,55.17 arc(216.28,55.34) 215.99,55.39 204.13,55.39 arc(204.06,55.41) 204.01,55.45 202.78,56.67 202.78,56.95 202.46,57.28 202.17,57.28 199.48,59.97 arc(199.45,60.02) 199.43,60.09 199.43,71.56 arc(199.46,71.7) 199.55,71.82 203.42,75.7 arc(203.59,75.95) 203.64,76.24 203.64,78.78 arc(203.59,79.07) 203.42,79.32 202.36,80.38 arc(202.28,80.51) 202.25,80.65 202.25,86.29 arc(202.19,86.58) 202.02,86.83 197.46,91.39 arc(197.29,91.64) 197.24,91.93 197.24,104.65
FC32_TDP1: length 70.8
  TOP w0.147: v4(197.6,108.34) 197.55,108.34 U1.C34
  SIG6 w0.112: 198.86,104.8 198.86,104.83 198.95,104.92 198.95,107.5 arc(198.94,107.58) 198.89,107.65 arc(198.83,107.69) 198.75,107.71 198.31,107.71 arc(198.17,107.74) 198.06,107.81 198.05,107.83 arc(197.98,107.93) 197.95,108.05 197.95,108.21 arc(197.91,108.3) 197.82,108.34 v4(197.6,108.34)
  SIG6 w0.155: 214.13,57.94 arc(214.11,58) 214.11,58.07
  SIG6 w0.16: 198.86,104.8 198.86,103.4 arc(198.83,103.26) 198.75,103.13 197.86,102.24 arc(197.61,101.87) 197.52,101.43 197.52,95.57 arc(197.61,95.13) 197.86,94.76 199.18,93.44 arc(199.23,93.41) 199.29,93.4 200.23,93.4 arc(200.37,93.37) 200.5,93.28 201.75,92.04 arc(201.83,91.91) 201.86,91.77 201.86,91.24 arc(201.94,90.8) 202.19,90.43 205.51,87.1 arc(205.6,86.98) 205.63,86.83 205.63,75.73 arc(205.57,75.44) 205.4,75.19 201.36,71.15 arc(201.19,70.9) 201.13,70.61 201.13,62.91 arc(201.22,62.47) 201.47,62.1 204.22,59.35 arc(204.59,59.1) 205.03,59.01 213.59,59.01 arc(213.74,58.98) 213.86,58.9 213.95,58.82 213.99,58.77 arc(214.05,58.7) 214.09,58.61 arc(214.1,58.59) 214.1,58.58 arc(214.11,58.53) 214.11,58.48 214.11,58.07 ; YJ30.D33 214.9,56.81 arc(214.86,57.02) 214.74,57.19 214.29,57.64 arc(214.19,57.78) 214.13,57.94
FC32_TDP2: length 77.9
  TOP w0.147: U1.E33 198.05,110.79 arc(198.18,110.47) v4(198.5,110.34)
  SIG6 w0.112: v4(198.5,110.34) 198.35,110.34 arc(198.27,110.33) 198.21,110.28 arc(198.16,110.22) 198.15,110.14 198.15,109.8 arc(198.11,109.63) 198.01,109.48 197.28,108.75 arc(197.18,108.6) 197.15,108.42 197.15,107.1 197.24,107.01
  SIG6 w0.16: 197.24,107.01 197.24,106.81 arc(197.2,106.63) 197.1,106.48 194.79,104.17 arc(194.62,103.92) 194.57,103.63 194.57,94.39 arc(194.59,94.24) 194.68,94.12 202.02,86.77 arc(202.19,86.52) 202.25,86.23 202.25,80.57 arc(202.28,80.43) 202.36,80.3 203.31,79.35 arc(203.56,78.98) 203.64,78.54 203.64,76.26 arc(203.59,75.97) 203.42,75.72 199.55,71.85 arc(199.38,71.6) 199.33,71.31 199.33,60.51 arc(199.38,60.22) 199.55,59.97 202.75,56.78 203.01,56.78 203.4,56.38 203.4,56.12 203.9,55.62 arc(204.15,55.45) 204.44,55.39 213.59,55.39 arc(213.88,55.34) 214.13,55.17 214.36,54.94 arc(214.45,54.88) 214.55,54.86 215.66,54.86 arc(215.9,54.76) 216,54.52 216,54.34 arc(215.96,54.14) 215.85,53.97 YJ30.D5
FC32_TDP3: length 71
  TOP w0.147: U1.B32 199.55,107.34 v4(199.6,107.34)
  SIG7 w0.112: 198.86,104.78 198.86,104.81 198.95,104.9 198.95,106.5 arc(198.98,106.66) 199.06,106.79 arc(199.19,106.87) 199.35,106.91 199.79,106.91 arc(199.85,106.92) 199.9,106.95 199.91,106.96 arc(199.94,107.01) 199.95,107.05 199.95,107.21 arc(199.91,107.3) 199.82,107.34 v4(199.6,107.34)
  SIG7 w0.16: YJ30.D36 217.3,56.78 arc(217.25,57.02) 217.12,57.21 216.69,57.65 arc(216.56,57.84) 216.51,58.07 216.51,58.48 arc(216.51,58.53) 216.5,58.57 arc(216.46,58.68) 216.39,58.77 216.35,58.82 216.26,58.9 arc(216.14,58.98) 215.99,59.01 204.25,59.01 arc(203.81,59.1) 203.44,59.35 201.47,61.32 arc(201.22,61.69) 201.13,62.13 201.13,70.3 arc(201.22,70.73) 201.47,71.11 205.51,75.15 arc(205.6,75.28) 205.63,75.42 205.63,86.75 arc(205.6,86.9) 205.51,87.02 201.31,91.22 arc(201.06,91.6) 200.98,92.03 200.98,101.54 arc(200.95,101.68) 200.87,101.81 199.19,103.48 arc(198.94,103.85) 198.86,104.29 198.86,104.78
FC33_RDN0: length 59
  TOP w0.147: v4(201.5,112.34) 201.42,112.34 arc(201.34,112.36) 201.27,112.4 201.19,112.48 arc(201.09,112.64) 201.05,112.83 U1.G30
  SIG9 w0.112: v4(201.5,112.34) 201.37,112.21 arc(201.21,111.97) 201.15,111.68 201.15,105.15 arc(201.16,105.07) 201.2,105.01 arc(201.23,104.97) 201.24,104.92
  SIG9 w0.16: YJ30.C17 206.25,61.97 arc(206.36,62.14) 206.4,62.34 206.4,62.52 arc(206.3,62.76) 206.06,62.86 205.16,62.86 arc(204.86,62.92) 204.62,63.08 203.23,64.47 arc(203.06,64.72) 203.01,65.01 203.01,68.51 arc(203.06,68.8) 203.23,69.05 204.62,70.44 arc(204.86,70.6) 205.15,70.66 205.33,70.66 arc(205.63,70.72) 205.89,70.89 206.43,71.43 206.73,71.43 207.14,71.84 207.14,72.15 207.75,72.76 arc(208,73.13) 208.09,73.57 208.09,88.87 arc(208.03,89.16) 207.87,89.41 207.07,90.21 201.46,95.81 arc(201.3,96.06) 201.24,96.35 201.24,104.92
FC33_RDN1: length 60.8
  TOP w0.147: U1.J31 200.55,114.34 v4(200.6,114.34)
  SIG9 w0.112: v4(200.6,114.34) 200.85,114.34 arc(200.92,114.31) 200.95,114.24 200.95,114.02 arc(200.97,113.9) 201.04,113.8 arc(201.14,113.73) 201.26,113.71 202.69,113.71 arc(202.79,113.69) 202.87,113.63 arc(202.93,113.54) 202.95,113.44 202.95,105.12 arc(202.94,105.07) 202.91,105.02 202.88,104.99 arc(202.87,104.97) 202.86,104.95 202.86,104.92
  SIG9 w0.16: YJ30.C21 205.3,64.85 arc(205.27,65.02) 205.17,65.16 204.69,65.65 arc(204.56,65.84) 204.51,66.07 204.51,66.48 arc(204.51,66.53) 204.5,66.59 arc(204.49,66.6) 204.49,66.6 arc(204.45,66.7) 204.39,66.77 204.35,66.82 204.27,66.9 arc(203.95,67.66) 204.27,68.41 204.48,68.63 arc(204.85,68.87) 205.27,68.96 206.38,68.96 arc(206.67,69.02) 206.92,69.18 210.41,72.67 arc(210.57,72.92) 210.63,73.21 210.63,90.87 arc(210.6,91.01) 210.52,91.14 208.55,93.1 arc(208.43,93.19) 208.28,93.22 207.39,93.22 arc(206.95,93.3) 206.58,93.55 205,95.14 arc(204.75,95.51) 204.66,95.94 204.66,101.54 arc(204.6,101.83) 204.44,102.07 203.09,103.43 arc(202.92,103.67) 202.86,103.96 202.86,104.92
FC33_RDN2: length 60.3
  TOP w0.147: U1.L30 201.05,116.73 arc(201.07,116.62) 201.13,116.53 201.19,116.47 arc(201.33,116.37) v4(201.5,116.34)
  SIG8 w0.112: 203.24,104.9 203.24,104.93 203.14,105.02 203.14,115.47 arc(203.11,115.64) 203.02,115.78 arc(202.88,115.87) 202.71,115.91 201.26,115.91 arc(201.22,115.91) 201.18,115.94 arc(201.16,115.97) 201.15,116.02 201.15,116.24 arc(201.18,116.31) 201.25,116.34 v4(201.5,116.34)
  SIG8 w0.16: 203.24,104.9 203.24,104.28 arc(203.27,104.13) 203.35,104.01 205.11,102.24 arc(205.24,102.16) 205.38,102.13 206.25,102.13 arc(206.69,102.04) 207.06,101.8 207.15,101.71 arc(207.28,101.55) 207.38,101.37 arc(207.45,101.14) 207.48,100.9 207.48,95.26 arc(207.54,94.97) 207.7,94.72 210.66,91.76 arc(210.83,91.52) 210.88,91.22 210.88,71.74 arc(210.8,71.3) 210.55,70.93 209.78,70.16 209.78,69.84 209.39,69.45 209.07,69.45 208.71,69.09 208.71,68.75 208.32,68.37 207.99,68.37 207.4,67.78 arc(207.32,67.66) 207.29,67.51 207.29,67.2 arc(207.39,66.96) 207.63,66.86 208.3,66.86 arc(208.5,66.82) 208.66,66.71 208.72,66.65 arc(208.78,66.56) 208.8,66.45 208.8,66.34 arc(208.76,66.14) 208.65,65.97 YJ30.C25
FC33_RDN3: length 67.9
  TOP w0.147: U1.N31 200.55,118.34 v4(200.6,118.34)
  SIG8 w0.112: 200.86,104.9 200.86,104.93 200.95,105.02 200.95,110.42 arc(200.93,110.55) 200.86,110.65 200.84,110.67 arc(200.75,110.73) 200.66,110.75 200.48,110.75 arc(200.28,110.79) 200.11,110.9 arc(199.99,111.07) 199.95,111.27 199.95,117.35 arc(200,117.56) 200.12,117.74 200.15,117.78 arc(200.29,117.87) 200.46,117.91 200.83,117.91 arc(200.88,117.91) 200.92,117.94 arc(200.94,117.98) 200.95,118.02 200.95,118.24 arc(200.92,118.31) 200.85,118.34 v4(200.6,118.34)
  SIG8 w0.16: YJ30.C15 207.7,60.9 arc(207.68,61.03) 207.61,61.13 207.33,61.41 207.09,61.65 arc(206.96,61.84) 206.91,62.07 206.91,62.48 arc(206.91,62.54) 206.89,62.6 arc(206.89,62.61) 206.89,62.61 arc(206.89,62.62) 206.88,62.64 arc(206.84,62.71) 206.79,62.77 206.75,62.82 206.66,62.9 arc(206.54,62.98) 206.39,63.01 204.83,63.01 arc(204.39,63.1) 204.02,63.35 203.51,63.85 arc(203.26,64.22) 203.18,64.66 203.18,67.01 arc(203.26,67.44) 203.51,67.81 207.6,71.9 arc(207.68,72.02) 207.71,72.17 207.71,90.51 arc(207.68,90.66) 207.6,90.78 201.19,97.19 arc(200.95,97.56) 200.86,97.99 200.86,104.9
FC33_RDP0: length 59
  TOP w0.147: U1.G31 200.55,112.34 v4(200.6,112.34)
  SIG9 w0.112: v4(200.6,112.34) 200.73,112.21 arc(200.89,111.97) 200.95,111.68 200.95,105.15 arc(200.94,105.07) 200.89,105.01 arc(200.87,104.97) 200.86,104.92
  SIG9 w0.16: YJ30.C18 205.3,60.84 arc(205.26,61.02) 205.16,61.17 204.69,61.65 arc(204.56,61.84) 204.51,62.07 204.51,62.48 arc(204.51,62.54) 204.5,62.59 arc(204.45,62.69) 204.39,62.77 204.35,62.82 202.96,64.2 arc(202.71,64.58) 202.62,65.01 202.62,68.51 arc(202.71,68.95) 202.96,69.32 204.35,70.71 arc(204.72,70.95) 205.15,71.04 205.33,71.04 arc(205.49,71.07) 205.62,71.16 207.49,73.03 arc(207.65,73.28) 207.71,73.57 207.71,88.87 arc(207.68,89.01) 207.6,89.14 204.4,92.34 201.19,95.54 arc(200.95,95.91) 200.86,96.35 200.86,104.92
