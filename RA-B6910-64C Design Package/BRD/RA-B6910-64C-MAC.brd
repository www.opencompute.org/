# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC16_RDP1: length 134.9
  TOP w0.147: U1.AN58 172.55,138.34 v4(172.55,138.29)
  SIG9 w0.112: 164,139.05 164.05,139.05 arc(164.09,139.05) 164.13,139.02 164.14,139.01 arc(164.19,138.97) 164.25,138.96 165.06,138.96 165.17,138.85 165.87,138.85 165.98,138.96 167.04,138.96 167.18,138.83 168,138.83 168.16,138.99 171.49,138.99 arc(171.94,138.8) 172.12,138.35 172.12,138.04 arc(172.15,137.97) 172.22,137.94 172.42,137.94 arc(172.46,137.95) 172.49,137.97 172.52,137.99 arc(172.54,138.03) 172.55,138.07 v4(172.55,138.29)
  SIG9 w0.16: YJ26.D15 113.7,52.83 arc(113.66,53.02) 113.56,53.18 113.15,53.58 arc(112.97,53.85) 112.91,54.16 112.91,54.48 arc(112.91,54.53) 112.9,54.58 arc(112.86,54.68) 112.79,54.77 112.75,54.82 112.66,54.9 arc(112.54,54.98) 112.39,55.01 110.84,55.01 arc(110.41,55.1) 110.04,55.35 105.35,60.03 arc(105.1,60.4) 105.02,60.84 105.02,69.58 arc(105.1,70.02) 105.35,70.39 111.53,76.57 arc(111.62,76.7) 111.65,76.84 111.65,87.13 arc(111.73,87.57) 111.98,87.94 113.27,89.23 arc(113.64,89.48) 114.07,89.56 116.16,89.56 arc(116.31,89.59) 116.43,89.67 123.76,97.01 133.56,106.8 arc(133.64,106.92) 133.67,107.07 133.67,120.76 arc(133.75,121.2) 134,121.57 150.87,138.44 arc(151.24,138.69) 151.68,138.77 160.11,138.77 160.65,139 arc(160.79,139.04) 160.94,139.05 164,139.05
FC16_RDP2: length 136.9
  TOP w0.147: v4(174.55,137.39) 174.55,137.48 arc(174.57,137.56) 174.61,137.63 174.68,137.71 arc(174.84,137.81) 175.01,137.84 U1.AM56
  SIG8 w0.112: v4(174.55,137.39) 174.55,137.64 arc(174.52,137.71) 174.45,137.74 174.22,137.74 arc(174.01,137.83) 173.92,138.04 173.92,138.51 arc(173.91,138.56) 173.89,138.6 173.79,138.69 arc(173.75,138.72) 173.7,138.73 169.4,138.73 arc(169.35,138.72) 169.31,138.69 169.19,138.56 arc(169.16,138.52) 169.15,138.47 169.15,138.22 arc(169.13,138.1) 169.06,137.99 168.9,137.84 arc(168.8,137.77) 168.68,137.75 163.38,137.75 163.28,137.66 163.26,137.66
  SIG8 w0.16: YJ26.D17 112.25,53.97 arc(112.36,54.14) 112.4,54.34 112.4,54.45 arc(112.37,54.61) 112.28,54.75 arc(112.15,54.83) 112,54.86 111.02,54.86 arc(110.85,54.89) 110.71,54.99 110.53,55.17 arc(110.28,55.34) 109.99,55.39 108.74,55.39 arc(108.44,55.45) 108.2,55.62 107.66,56.15 107.66,56.51 107.3,56.87 106.94,56.87 106.57,57.25 106.57,57.6 106.21,57.96 105.85,57.96 104.86,58.96 arc(104.69,59.2) 104.64,59.5 104.64,60.42 104.84,60.63 104.84,61.24 104.64,61.44 104.64,61.95 104.84,62.15 104.84,62.76 104.64,62.96 104.64,71.74 arc(104.69,72.03) 104.86,72.28 109.44,76.86 arc(109.61,77.11) 109.66,77.4 109.66,84.74 arc(109.72,85.03) 109.89,85.28 113.57,88.96 arc(113.81,89.12) 114.11,89.18 115.98,89.18 arc(116.42,89.27) 116.79,89.52 133.71,106.44 arc(133.96,106.81) 134.05,107.25 134.05,120.81 134.05,120.81 arc(134.11,121.1) 134.27,121.35 151.1,138.17 arc(151.34,138.33) 151.64,138.39 160.97,138.39 arc(161.12,138.36) 161.24,138.28 161.53,137.99 arc(161.9,137.74) 162.34,137.66 163.26,137.66
FC16_RDP3: length 122.9
  TOP w0.147: U1.AN60 170.55,138.34 v4(170.55,138.29)
  SIG9 w0.112: 163.16,138.06 163.27,137.94 169.06,137.94 169.11,137.89 169.63,137.89 arc(170.11,137.98) 170.51,138.25 v4(170.55,138.29)
  SIG9 w0.16: 163.16,138.06 162.35,138.06 arc(161.91,137.97) 161.54,137.73 160.69,136.87 arc(160.23,136.53) 159.7,136.32 arc(159.47,136.28) 159.23,136.27 152.12,136.27 arc(151.68,136.18) 151.31,135.93 136.16,120.78 arc(135.91,120.41) 135.83,119.98 135.83,106.18 arc(135.8,106.03) 135.71,105.91 116.48,86.67 arc(116.29,86.43) 116.18,86.16 arc(116.15,86.11) 116.14,86.05 116.14,84.01 arc(116.11,83.86) 116.03,83.74 115.86,83.57 arc(115.74,83.49) 115.59,83.46 114.96,83.46 arc(114.52,83.37) 114.15,83.12 114.06,83.04 arc(113.82,82.67) 113.73,82.23 113.73,75.5 arc(113.7,75.35) 113.62,75.23 107.43,69.04 arc(107.19,68.67) 107.1,68.24 107.1,62.82 arc(107.19,62.39) 107.43,62.01 110.1,59.35 arc(110.47,59.1) 110.91,59.01 112.39,59.01 arc(112.54,58.98) 112.66,58.9 112.75,58.82 112.79,58.77 arc(112.85,58.7) 112.89,58.6 arc(112.89,58.6) 112.9,58.59 arc(112.91,58.53) 112.91,58.48 112.91,58.16 arc(112.97,57.85) 113.15,57.58 113.53,57.2 arc(113.66,57.02) 113.7,56.8 YJ26.D24
FC16_TDN0: length 128.3
  TOP w0.147: U1.AL62 169,136.84 arc(168.86,136.82) 168.73,136.76 arc(168.6,136.6) v4(168.55,136.39)
  SIG6 w0.112: 163.26,137.65 163.28,137.65 163.38,137.74 167.74,137.74 arc(167.79,137.73) 167.83,137.7 167.89,137.65 arc(167.91,137.61) 167.92,137.56 167.92,137.07 arc(168.02,136.84) 168.25,136.74 168.42,136.74 arc(168.51,136.71) 168.55,136.62 v4(168.55,136.39)
  SIG6 w0.16: YJ26.D34 121.85,57.97 arc(121.96,58.14) 122,58.34 122,58.52 arc(121.9,58.76) 121.66,58.86 120.88,58.86 arc(120.47,58.94) 120.13,59.17 arc(119.88,59.34) 119.59,59.39 111.03,59.39 arc(110.74,59.45) 110.49,59.62 107.74,62.37 arc(107.57,62.62) 107.51,62.91 107.51,68.5 arc(107.54,68.65) 107.63,68.77 107.97,69.11 108.28,69.11 108.62,69.45 108.62,69.77 108.96,70.1 109.27,70.1 109.61,70.44 109.61,70.76 111.21,72.35 111.54,72.35 111.86,72.67 111.86,73.01 112.2,73.35 112.55,73.35 112.85,73.64 112.85,74 113.19,74.34 116.19,77.34 arc(116.44,77.71) 116.52,78.14 116.52,80.66 arc(116.55,80.81) 116.63,80.93 118.27,82.57 arc(118.52,82.94) 118.61,83.38 118.61,87.95 arc(118.66,88.24) 118.83,88.49 135.98,105.64 arc(136.15,105.89) 136.21,106.18 136.21,119.97 arc(136.27,120.26) 136.43,120.51 151.58,135.66 arc(151.83,135.83) 152.12,135.89 155.83,135.89 arc(156.12,135.95) 156.37,136.11 156.44,136.18 arc(156.57,136.26) 156.71,136.29 160.17,136.29 arc(160.47,136.35) 160.71,136.52 161.62,137.43 arc(161.87,137.59) 162.16,137.65 163.26,137.65
FC16_TDN1: length 138.3
  TOP w0.147: U1.AM64 166.55,137.34 v4(166.55,137.29)
  SIG7 w0.112: v4(166.55,137.29) 166.55,137.09 arc(166.54,137.04) 166.51,137 166.49,136.98 arc(166.45,136.95) 166.4,136.94 166.25,136.94 arc(166.16,136.98) 166.12,137.07 166.12,137.49 arc(166.09,137.64) 166,137.77 165.98,137.79 arc(165.86,137.88) 165.71,137.91 164.49,137.91 arc(164.35,137.93) 164.23,138.01 arc(164.11,138.09) 163.97,138.12 163.73,138.12 163.64,138.21 163.61,138.21
  SIG7 w0.16: 163.61,138.21 162.3,138.21 arc(162.16,138.24) 162.03,138.33 161.81,138.55 arc(161.56,138.72) 161.27,138.77 151.52,138.77 arc(151.23,138.72) 150.98,138.55 133.89,121.46 arc(133.73,121.21) 133.67,120.92 133.67,107.12 arc(133.64,106.97) 133.56,106.85 116.37,89.66 arc(116.2,89.41) 116.14,89.12 116.14,77.91 arc(116.11,77.76) 116.03,77.64 112.03,73.64 arc(111.91,73.56) 111.76,73.53 110.46,73.53 arc(110.17,73.47) 109.92,73.31 105.28,68.66 arc(105.11,68.42) 105.05,68.13 105.05,60.09 arc(105.11,59.8) 105.28,59.55 109.59,55.24 arc(109.84,55.07) 110.13,55.01 121.99,55.01 arc(122.14,54.98) 122.26,54.9 122.35,54.82 122.39,54.77 arc(122.46,54.68) 122.5,54.58 arc(122.51,54.53) 122.51,54.48 122.51,54.16 arc(122.57,53.85) 122.75,53.58 123.12,53.22 arc(123.25,53.02) 123.3,52.78 YJ26.D3
FC16_TDN2: length 129.7
  TOP w0.147: U1.AL66 165,136.84 arc(164.68,136.71) v4(164.55,136.39)
  SIG7 w0.112: v4(164.55,136.39) 164.55,136.58 arc(164.5,136.7) 164.38,136.74 164.3,136.74 arc(164.17,136.69) 164.11,136.55 164.11,136.26 arc(164.09,136.12) 164.01,136 163.9,135.9 arc(163.88,135.87) 163.85,135.85 arc(163.76,135.81) 163.67,135.8 163.29,135.8 163.2,135.71 163.17,135.71
  SIG7 w0.16: YJ26.D37 124.25,57.97 arc(124.36,58.14) 124.4,58.34 124.4,58.52 arc(124.3,58.76) 124.06,58.86 123.28,58.86 arc(122.87,58.94) 122.53,59.17 arc(122.28,59.34) 121.99,59.39 110.07,59.39 arc(109.92,59.42) 109.8,59.51 107.63,61.68 arc(107.54,61.8) 107.51,61.95 107.51,67.16 arc(107.54,67.3) 107.63,67.43 109.68,69.48 arc(109.8,69.56) 109.95,69.59 114.94,69.59 arc(115.23,69.65) 115.48,69.82 118.38,72.72 arc(118.55,72.97) 118.61,73.26 118.61,73.9 118.76,74.05 118.76,74.57 118.61,74.72 118.61,75.19 118.76,75.34 118.76,75.85 118.61,76.01 118.61,76.47 118.76,76.62 118.76,77.14 118.61,77.29 118.61,77.76 118.73,77.88 118.73,78.45 118.61,78.58 118.61,79.04 118.78,79.22 118.78,79.68 118.61,79.86 118.61,80.33 118.78,80.51 118.78,80.97 118.61,81.15 118.61,85.21 arc(118.63,85.35) 118.72,85.48 122.78,89.54 arc(122.94,89.79) 123,90.08 123,92.45 arc(123.03,92.59) 123.11,92.72 135.98,105.59 arc(136.15,105.84) 136.21,106.13 136.21,120.13 arc(136.24,120.28) 136.32,120.4 151.52,135.6 arc(151.83,135.81) 152.21,135.89 160.43,135.89 160.61,135.71 163.17,135.71
FC16_TDN3: length 135.8
  TOP w0.147: U1.AP63 168,139.84 arc(167.68,139.97) v4(167.55,140.29)
  SIG6 w0.112: v4(167.55,140.29) 167.55,140.12 arc(167.54,140.07) 167.51,140.03 167.46,139.98 arc(167.42,139.95) 167.37,139.94 167.14,139.94 arc(166.95,139.9) 166.78,139.79 166.07,139.08 arc(165.91,138.97) 165.72,138.94 165.25,138.94 arc(165.12,138.96) 165.01,139.03 arc(164.9,139.11) 164.77,139.13 164.19,139.13 164.1,139.22 164.07,139.22
  SIG6 w0.16: 164.07,139.22 160.43,139.22 arc(160,139.14) 159.63,138.89 159.62,138.89 arc(159.5,138.8) 159.35,138.77 151.68,138.77 arc(151.25,138.69) 150.87,138.44 134,121.57 arc(133.75,121.2) 133.67,120.76 133.67,107.09 arc(133.64,106.95) 133.56,106.83 116.48,89.75 arc(116.23,89.37) 116.14,88.94 116.14,84.08 arc(116.11,83.93) 116.03,83.81 115.79,83.57 arc(115.67,83.49) 115.52,83.46 114.77,83.46 arc(114.48,83.4) 114.23,83.24 113.95,82.95 arc(113.79,82.71) 113.73,82.42 113.73,78.95 arc(113.7,78.81) 113.62,78.68 105.39,70.45 arc(105.14,70.08) 105.05,69.64 105.05,60.42 arc(105.11,60.13) 105.28,59.89 109.92,55.24 arc(110.17,55.07) 110.46,55.01 119.59,55.01 arc(119.74,54.98) 119.86,54.9 119.95,54.82 119.99,54.77 arc(120.05,54.7) 120.09,54.62 arc(120.09,54.6) 120.1,54.57 arc(120.11,54.53) 120.11,54.48 120.11,54.16 arc(120.17,53.85) 120.35,53.58 120.79,53.15 arc(120.87,53.02) 120.9,52.87 YJ26.D6
FC16_TDP0: length 128.3
  TOP w0.147: v4(168.55,137.29) 168.55,137.34 U1.AM62
  SIG6 w0.112: v4(168.55,137.29) 168.55,137.07 arc(168.51,136.98) 168.42,136.94 168.25,136.94 arc(168.16,136.98) 168.12,137.07 168.12,137.56 arc(168.09,137.69) 168.02,137.79 167.97,137.84 arc(167.87,137.91) 167.74,137.94 163.38,137.94 163.28,138.03 163.26,138.03
  SIG6 w0.16: YJ26.D33 120.9,56.72 arc(120.84,57.01) 120.68,57.25 120.35,57.58 arc(120.17,57.85) 120.11,58.16 120.11,58.48 arc(120.11,58.53) 120.1,58.58 arc(120.1,58.59) 120.09,58.6 arc(120.05,58.69) 119.99,58.77 119.95,58.82 119.86,58.9 arc(119.74,58.98) 119.59,59.01 111.03,59.01 arc(110.59,59.1) 110.22,59.35 107.47,62.1 arc(107.22,62.47) 107.13,62.91 107.13,68.5 arc(107.19,68.8) 107.36,69.04 111.52,73.21 112.81,74.49 113.57,75.26 115.92,77.61 arc(116.08,77.85) 116.14,78.14 116.14,80.66 arc(116.2,80.95) 116.37,81.2 118,82.84 arc(118.17,83.09) 118.22,83.38 118.22,87.95 arc(118.31,88.38) 118.56,88.76 135.71,105.91 arc(135.8,106.03) 135.83,106.18 135.83,119.97 arc(135.91,120.41) 136.16,120.78 151.31,135.93 arc(151.69,136.18) 152.12,136.27 155.83,136.27 arc(155.98,136.3) 156.1,136.38 156.17,136.45 arc(156.42,136.62) 156.71,136.67 160.17,136.67 arc(160.32,136.7) 160.44,136.79 161.35,137.7 arc(161.72,137.94) 162.16,138.03 163.26,138.03
FC16_TDP1: length 138.3
  TOP w0.147: U1.AL64 167,136.84 arc(166.68,136.71) v4(166.55,136.39)
  SIG7 w0.112: v4(166.55,136.39) 166.55,136.58 arc(166.5,136.7) 166.38,136.74 166.25,136.74 arc(166.02,136.84) 165.92,137.07 165.92,137.49 arc(165.91,137.57) 165.86,137.63 165.85,137.65 arc(165.78,137.7) 165.71,137.71 164.49,137.71 arc(164.27,137.75) 164.09,137.88 arc(164.04,137.91) 163.97,137.93 163.73,137.93 163.64,137.83 163.61,137.83
  SIG7 w0.16: YJ26.D2 124.25,53.97 arc(124.36,54.14) 124.4,54.34 124.4,54.52 arc(124.3,54.76) 124.06,54.86 123.16,54.86 arc(122.86,54.92) 122.62,55.08 122.53,55.17 arc(122.28,55.34) 121.99,55.39 110.13,55.39 arc(109.98,55.42) 109.86,55.51 108.58,56.79 108.58,57.06 108.25,57.39 108.11,57.39 107.97,57.39 107.64,57.72 107.64,58 107.31,58.33 107.17,58.33 107.04,58.33 106.71,58.66 106.71,58.94 106.38,59.27 106.24,59.26 106.1,59.26 105.55,59.82 arc(105.46,59.94) 105.43,60.09 105.43,68.13 arc(105.46,68.27) 105.55,68.4 108.47,71.32 108.62,71.32 109.03,71.73 109.03,71.88 109.36,72.21 109.53,72.21 109.91,72.59 109.91,72.76 110.19,73.04 arc(110.31,73.12) 110.46,73.15 111.76,73.15 arc(112.05,73.21) 112.3,73.37 112.63,73.7 112.78,73.7 113.19,74.11 113.19,74.26 116.3,77.37 arc(116.46,77.62) 116.52,77.91 116.52,89.12 arc(116.55,89.27) 116.63,89.39 133.83,106.58 arc(133.99,106.83) 134.05,107.12 134.05,120.92 arc(134.08,121.07) 134.16,121.19 151.25,138.28 arc(151.37,138.36) 151.52,138.39 161.27,138.39 arc(161.42,138.36) 161.54,138.28 161.77,138.06 arc(162.01,137.89) 162.3,137.83 163.61,137.83
FC16_TDP2: length 129.7
  TOP w0.147: U1.AM66 164.55,137.34 v4(164.55,137.29)
  SIG7 w0.112: v4(164.55,137.29) 164.55,137.1 arc(164.5,136.99) 164.38,136.94 164.3,136.94 arc(164.03,136.83) 163.92,136.55 163.92,136.26 arc(163.9,136.2) 163.87,136.14 163.76,136.04 arc(163.75,136.03) 163.74,136.02 arc(163.71,136) 163.67,136 163.29,136 163.2,136.09 163.17,136.09
  SIG7 w0.16: YJ26.D36 123.3,56.72 arc(123.24,57.01) 123.08,57.26 122.75,57.58 arc(122.57,57.85) 122.51,58.16 122.51,58.48 arc(122.51,58.53) 122.5,58.58 arc(122.5,58.59) 122.49,58.59 arc(122.49,58.61) 122.49,58.62 arc(122.45,58.7) 122.39,58.77 122.35,58.82 122.26,58.9 arc(122.14,58.98) 121.99,59.01 110.07,59.01 arc(109.77,59.07) 109.53,59.24 107.36,61.41 arc(107.19,61.65) 107.13,61.95 107.13,67.16 arc(107.19,67.45) 107.36,67.7 109.41,69.75 arc(109.66,69.92) 109.95,69.97 114.94,69.97 arc(115.08,70) 115.21,70.09 118.11,72.99 arc(118.2,73.12) 118.22,73.26 118.22,85.21 arc(118.28,85.5) 118.45,85.75 122.51,89.81 arc(122.59,89.93) 122.62,90.08 122.62,92.45 arc(122.68,92.74) 122.84,92.99 135.71,105.86 arc(135.8,105.98) 135.83,106.13 135.83,120.13 arc(135.88,120.43) 136.05,120.67 151.25,135.87 arc(151.69,136.17) 152.21,136.27 160.59,136.27 160.77,136.09 163.17,136.09
FC16_TDP3: length 135.8
  TOP w0.147: v4(167.55,139.39) 167.55,139.34 U1.AN63
  SIG6 w0.112: 164.07,138.84 164.1,138.84 164.19,138.94 164.77,138.94 arc(164.82,138.92) 164.87,138.89 arc(165.04,138.78) 165.25,138.74 165.72,138.74 arc(165.99,138.79) 166.21,138.94 166.92,139.65 arc(167.02,139.72) 167.14,139.74 167.39,139.74 arc(167.44,139.73) 167.48,139.71 167.51,139.68 arc(167.54,139.64) 167.55,139.59 v4(167.55,139.39)
  SIG6 w0.16: 164.07,138.84 160.43,138.84 arc(160.14,138.79) 159.9,138.62 159.89,138.62 arc(159.65,138.45) 159.35,138.39 151.68,138.39 arc(151.39,138.34) 151.14,138.17 134.27,121.3 arc(134.11,121.05) 134.05,120.76 134.05,107.09 arc(133.99,106.8) 133.83,106.56 116.75,89.48 arc(116.58,89.23) 116.52,88.94 116.52,84.08 arc(116.46,83.78) 116.3,83.54 116.06,83.3 arc(115.82,83.14) 115.52,83.08 114.77,83.08 arc(114.63,83.05) 114.5,82.97 114.22,82.68 arc(114.14,82.56) 114.11,82.42 114.11,78.95 arc(114.05,78.66) 113.89,78.41 107.23,71.75 105.66,70.18 arc(105.49,69.94) 105.43,69.64 105.43,61.83 105.65,61.61 105.65,61.13 105.43,60.9 105.43,60.42 arc(105.46,60.28) 105.55,60.15 106.8,58.9 107.11,58.9 107.45,58.56 107.45,58.25 107.79,57.91 108.1,57.91 108.44,57.57 108.44,57.26 108.78,56.92 109.12,56.92 109.43,56.6 109.43,56.27 110.19,55.51 arc(110.32,55.42) 110.46,55.39 119.59,55.39 arc(119.88,55.34) 120.13,55.17 120.28,55.02 arc(120.46,54.9) 120.67,54.86 121.66,54.86 arc(121.9,54.76) 122,54.52 122,54.34 arc(121.96,54.14) 121.85,53.97 YJ26.D5
FC17_RDN0: length 114.6
  TOP w0.147: U1.AJ53 178.01,134.84 arc(177.84,134.81) 177.68,134.71 177.61,134.63 arc(177.57,134.56) 177.55,134.48 v4(177.55,134.39)
  SIG8 w0.112: 163.26,131.65 163.28,131.65 163.38,131.74 168.97,131.74 arc(169.08,131.76) 169.18,131.83 169.51,132.16 169.92,132.58 arc(170.11,132.7) 170.32,132.74 176.68,132.74 arc(176.85,132.77) 176.99,132.87 arc(177.09,133.01) 177.12,133.18 177.12,134.64 arc(177.15,134.71) 177.22,134.74 177.45,134.74 arc(177.52,134.71) 177.55,134.64 v4(177.55,134.39)
  SIG8 w0.16: 163.26,131.65 162.74,131.65 arc(162.45,131.59) 162.2,131.43 162.01,131.23 arc(161.76,131.07) 161.47,131.01 153.17,131.01 arc(152.89,130.96) 152.65,130.81 arc(152.64,130.8) 152.63,130.79 140.75,118.91 arc(140.58,118.66) 140.53,118.37 140.53,118.37 140.53,104.81 arc(140.44,104.37) 140.19,104 125.35,89.16 arc(125.26,89.03) 125.23,88.89 125.23,87.1 arc(125.15,86.67) 124.9,86.3 118.83,80.22 arc(118.74,80.1) 118.71,79.95 118.71,77.32 118.94,77.09 118.94,76.53 118.71,76.3 118.71,75.79 118.94,75.56 118.94,75 118.71,74.78 118.71,73.53 arc(118.63,73.09) 118.38,72.72 117.74,72.08 117.74,71.75 117.36,71.37 117.02,71.37 116.67,71.01 116.67,70.67 116.28,70.29 115.95,70.29 115.59,69.93 arc(115.22,69.68) 114.78,69.59 113.78,69.59 113.55,69.36 112.99,69.36 112.76,69.59 112.16,69.59 arc(111.87,69.54) 111.63,69.37 111.11,68.86 arc(110.95,68.61) 110.89,68.32 110.89,67.1 arc(110.96,66.93) 111.13,66.86 111.9,66.86 arc(112.1,66.82) 112.26,66.71 112.32,66.65 arc(112.38,66.56) 112.4,66.45 112.4,66.34 arc(112.36,66.14) 112.25,65.97 YJ26.C22
FC17_RDN1: length 117.9
  TOP w0.147: v4(173.55,135.29) 173.55,135.34 U1.AK57
  SIG9 w0.112: v4(173.55,135.29) 173.55,135.07 arc(173.54,135.03) 173.52,134.99 173.49,134.97 arc(173.46,134.95) 173.42,134.94 173.22,134.94 arc(173.15,134.97) 173.12,135.04 173.12,135.53 arc(173.09,135.69) 173.01,135.82 arc(172.88,135.9) 172.73,135.93 163.37,135.93 arc(163.31,135.94) 163.25,135.98 arc(163.2,136.01) 163.14,136.02 163.11,136.02
  SIG9 w0.16: YJ26.C15 113.7,60.81 arc(113.66,61.02) 113.54,61.2 113.15,61.58 arc(112.97,61.85) 112.91,62.16 112.91,62.48 arc(112.91,62.53) 112.9,62.59 arc(112.86,62.69) 112.79,62.77 112.75,62.82 112.66,62.9 arc(112.54,62.98) 112.39,63.01 110.72,63.01 arc(110.28,63.1) 109.91,63.35 109.54,63.72 arc(109.29,64.09) 109.2,64.53 109.2,67.14 arc(109.26,67.44) 109.43,67.68 113.49,71.75 115.92,74.18 arc(116.08,74.42) 116.14,74.72 116.14,80.74 arc(116.2,81.03) 116.37,81.28 118,82.91 arc(118.17,83.16) 118.22,83.45 118.22,84.52 arc(118.24,84.67) 118.28,84.81 118.75,85.95 arc(118.82,86.08) 118.92,86.19 126.94,94.21 137.76,105.04 arc(137.93,105.28) 137.99,105.58 137.99,119.32 arc(138.04,119.61) 138.21,119.86 151.73,133.38 arc(151.97,133.54) 152.27,133.6 159.46,133.6 arc(159.75,133.66) 160,133.82 161.97,135.8 arc(162.22,135.97) 162.51,136.02 163.11,136.02
FC17_RDN2: length 118.4
  TOP w0.147: v4(175.55,134.39) 175.55,134.48 arc(175.57,134.56) 175.61,134.63 175.68,134.71 arc(175.84,134.81) 176.01,134.84 U1.AJ55
  SIG8 w0.112: v4(175.55,134.39) 175.55,134.64 arc(175.52,134.71) 175.45,134.74 175.22,134.74 arc(175.15,134.71) 175.12,134.64 175.12,134.05 arc(175.03,133.84) 174.82,133.75 163.38,133.75 163.28,133.66 163.26,133.66
  SIG8 w0.16: YJ26.C17 112.25,61.97 arc(112.36,62.14) 112.4,62.35 112.4,62.54 arc(112.38,62.65) 112.32,62.74 arc(112.19,62.83) 112.04,62.86 110.95,62.86 arc(110.85,62.88) 110.76,62.94 110.53,63.17 arc(110.28,63.34) 109.99,63.39 109.2,63.39 arc(108.94,63.5) 108.83,63.77 108.83,69.74 arc(108.86,69.89) 108.94,70.01 109.64,70.71 109.97,70.71 110.35,71.09 110.35,71.43 111.08,72.16 111.42,72.16 111.8,72.54 111.8,72.87 112.16,73.23 112.5,73.23 112.88,73.62 112.88,73.95 113.24,74.31 113.57,74.31 113.96,74.7 113.96,75.03 116.19,77.26 arc(116.44,77.63) 116.52,78.07 116.52,80.68 arc(116.55,80.83) 116.63,80.95 118.27,82.59 arc(118.52,82.96) 118.61,83.4 118.61,85.02 arc(118.66,85.31) 118.83,85.56 138.14,104.87 arc(138.31,105.12) 138.37,105.41 138.37,119.21 arc(138.42,119.5) 138.59,119.75 151.71,132.87 arc(151.96,133.04) 152.25,133.09 160.96,133.09 arc(161.1,133.11) 161.23,133.14 arc(161.37,133.21) 161.5,133.32 161.62,133.44 arc(161.87,133.6) 162.16,133.66 163.26,133.66
FC17_RDN3: length 106
  TOP w0.147: v4(171.55,135.29) 171.55,135.34 U1.AK59
  SIG9 w0.112: v4(171.55,135.29) 171.55,135.07 arc(171.54,135.02) 171.51,134.98 171.51,134.98 arc(171.46,134.95) 171.42,134.94 171.22,134.94 arc(171.01,134.85) 170.93,134.64 170.93,134.13 arc(170.91,134.06) 170.87,134 arc(170.81,133.96) 170.74,133.95 163.42,133.95 arc(163.36,133.96) 163.3,133.99 arc(163.25,134.03) 163.19,134.04 163.16,134.04
  SIG9 w0.16: YJ26.C24 113.7,64.71 arc(113.64,65.01) 113.47,65.27 113.15,65.58 arc(112.97,65.85) 112.91,66.16 112.91,66.48 arc(112.91,66.52) 112.9,66.57 arc(112.86,66.68) 112.79,66.77 112.75,66.82 112.67,66.9 arc(112.35,67.66) 112.67,68.41 112.88,68.63 arc(113.25,68.87) 113.67,68.96 113.83,68.96 arc(113.97,68.99) 114.09,69.07 118,72.98 arc(118.17,73.22) 118.22,73.52 118.22,79.85 arc(118.28,80.14) 118.45,80.39 123.76,85.7 124.63,86.57 arc(124.8,86.82) 124.85,87.11 124.85,88.84 arc(124.91,89.13) 125.08,89.38 126.94,91.24 139.92,104.22 arc(140.09,104.47) 140.14,104.76 140.14,118.51 arc(140.2,118.8) 140.37,119.05 152.54,131.22 arc(152.79,131.38) 153.08,131.44 159.61,131.44 arc(159.9,131.5) 160.15,131.67 162.3,133.82 arc(162.55,133.98) 162.84,134.04 163.16,134.04
FC17_RDP0: length 114.6
  TOP w0.147: v4(177.55,135.29) 177.55,135.34 U1.AK53
  SIG8 w0.112: v4(177.55,135.29) 177.55,135.04 arc(177.52,134.97) 177.45,134.94 177.22,134.94 arc(177.01,134.85) 176.92,134.64 176.92,133.18 arc(176.9,133.09) 176.85,133.01 arc(176.77,132.96) 176.68,132.94 170.32,132.94 arc(170.03,132.88) 169.79,132.72 169.51,132.44 169.12,132.05 arc(169,131.97) 168.85,131.94 163.38,131.94 163.28,132.03 163.26,132.03
  SIG8 w0.16: YJ26.C21 111.3,64.75 arc(111.25,65.01) 111.1,65.24 110.65,65.69 arc(110.55,65.84) 110.51,66.02 110.51,68.32 arc(110.6,68.76) 110.85,69.13 111.36,69.64 arc(111.73,69.89) 112.16,69.97 114.78,69.97 arc(115.07,70.03) 115.32,70.2 118.11,72.99 arc(118.28,73.24) 118.33,73.53 118.33,79.95 arc(118.39,80.25) 118.56,80.49 124.63,86.57 arc(124.8,86.81) 124.85,87.1 124.85,88.89 arc(124.91,89.18) 125.08,89.43 139.92,104.27 arc(140.09,104.52) 140.14,104.81 140.14,118.37 arc(140.23,118.81) 140.48,119.18 152.36,131.06 arc(152.37,131.07) 152.39,131.09 arc(152.75,131.31) 153.17,131.39 161.47,131.39 arc(161.62,131.42) 161.74,131.5 161.93,131.7 arc(162.3,131.94) 162.74,132.03 163.26,132.03
FC17_RDP1: length 117.9
  TOP w0.147: U1.AJ57 173.95,134.84 arc(173.86,134.82) 173.78,134.77 173.65,134.64 arc(173.58,134.53) v4(173.55,134.39)
  SIG9 w0.112: v4(173.55,134.39) 173.55,134.61 arc(173.54,134.66) 173.51,134.7 173.51,134.71 arc(173.46,134.73) 173.42,134.74 173.22,134.74 arc(173.01,134.83) 172.93,135.04 172.93,135.53 arc(172.91,135.61) 172.87,135.68 arc(172.8,135.72) 172.73,135.74 163.37,135.74 arc(163.3,135.72) 163.25,135.69 arc(163.2,135.66) 163.14,135.64 163.11,135.64
  SIG9 w0.16: YJ26.C14 114.65,61.97 arc(114.76,62.14) 114.8,62.34 114.8,62.48 arc(114.69,62.75) 114.42,62.86 113.56,62.86 arc(113.26,62.92) 113.02,63.08 112.93,63.17 arc(112.68,63.34) 112.39,63.39 110.72,63.39 arc(110.43,63.45) 110.18,63.62 109.81,63.99 arc(109.64,64.24) 109.58,64.53 109.58,67.14 arc(109.61,67.29) 109.69,67.41 110.05,67.77 110.39,67.77 110.77,68.16 110.77,68.49 112.63,70.35 112.97,70.35 113.35,70.74 113.35,71.07 113.71,71.43 114.04,71.43 114.43,71.81 114.43,72.15 114.79,72.51 115.12,72.51 115.51,72.89 115.51,73.23 116.19,73.91 arc(116.44,74.28) 116.52,74.72 116.52,80.74 arc(116.55,80.88) 116.63,81.01 117.04,81.42 117.45,81.83 118.27,82.64 arc(118.52,83.02) 118.61,83.45 118.61,84.52 arc(118.61,84.59) 118.63,84.67 119.1,85.8 arc(119.14,85.87) 119.19,85.92 126.94,93.67 138.03,104.77 arc(138.28,105.14) 138.37,105.58 138.37,119.32 arc(138.4,119.47) 138.48,119.59 145.24,126.35 152,133.11 arc(152.12,133.19) 152.27,133.22 159.46,133.22 arc(159.9,133.31) 160.27,133.56 162.24,135.53 arc(162.37,135.61) 162.51,135.64 163.11,135.64
FC17_RDP2: length 118.4
  TOP w0.147: U1.AK55 175.55,135.34 v4(175.55,135.29)
  SIG8 w0.112: v4(175.55,135.29) 175.55,135.04 arc(175.52,134.97) 175.45,134.94 175.22,134.94 arc(175.01,134.85) 174.92,134.64 174.92,134.05 arc(174.89,133.98) 174.82,133.95 163.38,133.95 163.28,134.04 163.26,134.04
  SIG8 w0.16: 163.26,134.04 162.16,134.04 arc(161.72,133.95) 161.35,133.71 161.23,133.59 arc(161.17,133.54) 161.09,133.5 arc(161.03,133.48) 160.96,133.47 152.25,133.47 arc(151.82,133.39) 151.44,133.14 138.32,120.02 arc(138.07,119.64) 137.99,119.21 137.99,105.41 arc(137.96,105.27) 137.87,105.14 118.56,85.83 arc(118.31,85.46) 118.22,85.02 118.22,83.4 arc(118.17,83.1) 118,82.86 116.37,81.22 arc(116.2,80.97) 116.14,80.68 116.14,78.07 arc(116.08,77.78) 115.92,77.53 108.67,70.28 arc(108.5,70.03) 108.45,69.74 108.45,63.77 arc(108.67,63.23) 109.2,63.01 109.99,63.01 arc(110.14,62.98) 110.26,62.9 110.35,62.82 110.39,62.77 arc(110.44,62.71) 110.48,62.64 arc(110.49,62.62) 110.49,62.61 arc(110.49,62.61) 110.49,62.6 arc(110.51,62.54) 110.51,62.48 110.51,61.94 arc(110.53,61.83) 110.6,61.74 110.8,61.53 110.93,61.41 111.2,61.13 arc(111.27,61.02) 111.3,60.89 YJ26.C18
FC17_RDP3: length 105.9
  TOP w0.147: U1.AJ59 171.95,134.84 arc(171.86,134.82) 171.78,134.77 171.65,134.64 arc(171.58,134.53) v4(171.55,134.39)
  SIG9 w0.112: v4(171.55,134.39) 171.55,134.62 arc(171.54,134.66) 171.52,134.69 171.49,134.71 arc(171.46,134.74) 171.42,134.74 171.22,134.74 arc(171.15,134.71) 171.12,134.64 171.12,134.13 arc(171.09,133.99) 171.01,133.86 arc(170.89,133.78) 170.74,133.75 163.42,133.75 arc(163.36,133.74) 163.3,133.7 arc(163.25,133.67) 163.19,133.66 163.16,133.66
  SIG9 w0.16: 163.16,133.66 162.84,133.66 arc(162.69,133.63) 162.57,133.55 160.42,131.4 arc(160.05,131.15) 159.61,131.06 153.08,131.06 arc(152.93,131.03) 152.81,130.95 146.72,124.86 140.64,118.78 arc(140.55,118.65) 140.53,118.51 140.53,104.76 arc(140.44,104.33) 140.19,103.96 132.77,96.53 126.94,90.7 125.35,89.11 arc(125.26,88.99) 125.23,88.84 125.23,87.11 arc(125.15,86.67) 124.9,86.3 121.81,83.21 120.26,81.67 118.72,80.12 arc(118.63,80) 118.61,79.85 118.61,73.52 arc(118.52,73.08) 118.27,72.71 117.75,72.19 117.75,71.78 117.39,71.42 116.98,71.42 116.6,71.03 116.6,70.6 116.29,70.29 115.85,70.29 115.47,69.9 115.47,69.47 115.11,69.11 114.67,69.11 114.36,68.8 arc(114.12,68.64) 113.83,68.58 113.67,68.58 arc(113.39,68.52) 113.15,68.36 112.94,68.15 arc(112.73,67.66) 112.94,67.17 113.02,67.08 arc(113.26,66.92) 113.56,66.86 114.47,66.86 arc(114.71,66.76) 114.8,66.53 114.8,66.34 arc(114.76,66.14) 114.65,65.97 YJ26.C25
FC17_TDN0: length 120.4
  TOP w0.147: U1.AK65 165.55,135.34 v4(165.55,135.29)
  SIG7 w0.112: 163.15,134.09 163.18,134.09 163.27,134 164.71,134 arc(164.78,134.01) 164.85,134.06 164.86,134.08 arc(164.91,134.14) 164.92,134.21 164.92,134.55 arc(165.04,134.83) 165.31,134.94 165.38,134.94 arc(165.5,134.99) 165.55,135.1 v4(165.55,135.29)
  SIG7 w0.16: 163.15,134.09 161.28,134.09 arc(160.98,134.03) 160.74,133.87 160.5,133.63 arc(160.38,133.55) 160.23,133.52 152.19,133.52 arc(151.9,133.46) 151.65,133.3 138.21,119.86 arc(138.04,119.61) 137.99,119.32 137.99,105.37 arc(137.96,105.22) 137.87,105.1 125.07,92.3 arc(124.91,92.05) 124.85,91.76 124.85,75.57 arc(124.82,75.42) 124.74,75.3 117.37,67.93 arc(117.24,67.84) 117.1,67.82 110.84,67.82 arc(110.55,67.76) 110.3,67.59 109.44,66.73 arc(109.27,66.48) 109.21,66.19 109.21,64.31 arc(109.27,64.02) 109.44,63.77 109.97,63.24 arc(110.22,63.07) 110.51,63.01 119.59,63.01 arc(119.74,62.98) 119.86,62.9 119.95,62.82 119.99,62.77 arc(120.05,62.7) 120.09,62.61 arc(120.09,62.59) 120.1,62.58 arc(120.11,62.53) 120.11,62.48 120.11,62.16 arc(120.17,61.85) 120.35,61.58 120.69,61.24 arc(120.85,61.01) 120.9,60.74 YJ26.C6
FC17_TDN1: length 121.5
  TOP w0.147: U1.AJ63 168,134.84 arc(167.68,134.71) v4(167.55,134.39)
  SIG6 w0.112: 163.26,135.65 163.28,135.65 163.38,135.74 166.74,135.74 arc(166.79,135.73) 166.83,135.7 166.89,135.65 arc(166.91,135.61) 166.92,135.56 166.92,135.07 arc(167.02,134.84) 167.25,134.74 167.42,134.74 arc(167.51,134.71) 167.55,134.62 v4(167.55,134.39)
  SIG6 w0.16: 163.26,135.65 162.57,135.65 arc(162.28,135.59) 162.03,135.43 160.06,133.45 arc(159.81,133.28) 159.52,133.22 152.46,133.22 arc(152.16,133.16) 151.92,133 138.59,119.67 arc(138.42,119.43) 138.37,119.13 138.37,105.37 arc(138.31,105.08) 138.14,104.83 125.48,92.17 arc(125.32,91.92) 125.26,91.63 125.26,86.97 arc(125.2,86.68) 125.04,86.43 118.91,80.3 arc(118.74,80.05) 118.68,79.76 118.68,77.22 arc(118.62,76.93) 118.46,76.69 116.75,74.97 arc(116.58,74.73) 116.52,74.43 116.52,73.85 arc(116.46,73.55) 116.3,73.31 113.78,70.79 113.78,70.45 113.47,70.14 113.13,70.14 112.79,69.8 112.79,69.46 112.48,69.15 112.14,69.15 111.8,68.81 111.8,68.5 111.46,68.16 111.15,68.16 110.81,67.82 110.81,67.5 110.47,67.16 110.16,67.16 109.82,66.83 arc(109.65,66.58) 109.59,66.29 109.59,64.51 arc(109.65,64.22) 109.82,63.97 110.17,63.62 arc(110.42,63.45) 110.71,63.39 121.99,63.39 arc(122.28,63.34) 122.53,63.17 122.7,63 arc(122.86,62.9) 123.04,62.86 124.06,62.86 arc(124.3,62.76) 124.4,62.52 124.4,62.34 arc(124.36,62.14) 124.25,61.97 YJ26.C2
FC17_TDN2: length 100.2
  TOP w0.147: U1.AK61 169.55,135.34 v4(169.55,135.29)
  SIG6 w0.112: 163.26,134.04 163.28,134.04 163.38,133.95 168.74,133.95 arc(168.79,133.96) 168.83,133.98 168.89,134.04 arc(168.91,134.08) 168.92,134.12 168.92,134.62 arc(169.02,134.85) 169.25,134.94 169.37,134.94 arc(169.42,134.95) 169.46,134.98 169.51,135.03 arc(169.54,135.07) 169.55,135.12 v4(169.55,135.29)
  SIG6 w0.16: YJ26.C33 120.9,64.82 arc(120.86,65.02) 120.75,65.19 120.35,65.58 arc(120.17,65.85) 120.11,66.16 120.11,69.06 arc(120.17,69.35) 120.33,69.59 126.72,75.98 arc(126.89,76.23) 126.95,76.52 126.95,90.93 arc(127,91.23) 127.17,91.47 139.92,104.22 arc(140.09,104.47) 140.14,104.76 140.14,118.48 arc(140.2,118.77) 140.37,119.02 152.57,131.22 arc(152.82,131.38) 153.11,131.44 160.02,131.44 arc(160.17,131.47) 160.29,131.55 162.55,133.81 arc(162.8,133.98) 163.1,134.04 163.26,134.04
FC17_TDN3: length 94
  TOP w0.147: U1.AG66 165,132.84 arc(164.68,132.71) v4(164.55,132.39)
  SIG7 w0.112: v4(164.55,132.39) 164.55,132.58 arc(164.5,132.7) 164.38,132.74 164.24,132.74 arc(164.15,132.71) 164.11,132.62 164.11,132.21 arc(164.08,132.06) 164,131.93 163.94,131.87 arc(163.87,131.82) 163.79,131.79 arc(163.75,131.78) 163.71,131.78 163.27,131.78 163.18,131.68 163.15,131.68
  SIG7 w0.16: YJ26.C37 124.25,65.97 arc(124.36,66.14) 124.4,66.34 124.4,66.52 arc(124.3,66.76) 124.06,66.86 123.27,66.86 arc(122.87,66.94) 122.53,67.17 122.39,67.31 arc(122.1,67.74) 122,68.24 122,68.27 arc(122.15,69.01) 122.57,69.65 122.99,70.06 123.19,70.06 123.57,70.44 123.57,70.64 123.9,70.97 124.09,70.97 124.47,71.35 124.47,71.54 124.8,71.87 125.05,71.87 125.38,72.2 125.38,72.45 125.71,72.78 125.9,72.78 126.28,73.16 126.28,73.35 126.91,73.98 arc(127.22,74.44) 127.33,74.98 127.33,75.45 127.41,75.54 127.5,75.62 127.5,76.09 127.41,76.17 127.33,76.25 127.33,76.72 127.41,76.8 127.5,76.89 127.5,77.35 127.41,77.44 127.33,77.52 127.33,90.93 arc(127.36,91.08) 127.44,91.2 140.3,104.07 arc(140.47,104.31) 140.53,104.61 140.53,118.48 arc(140.55,118.63) 140.64,118.75 152.83,130.95 arc(152.96,131.03) 153.1,131.06 161.16,131.06 arc(161.46,131.12) 161.7,131.28 161.99,131.57 arc(162.12,131.66) 162.26,131.68 163.15,131.68
FC17_TDP0: length 120.4
  TOP w0.147: U1.AJ65 166,134.84 arc(165.68,134.71) v4(165.55,134.39)
  SIG7 w0.112: 163.15,133.71 163.18,133.71 163.27,133.8 164.71,133.8 arc(164.86,133.83) 164.98,133.92 165,133.94 arc(165.09,134.06) 165.12,134.21 165.12,134.55 arc(165.17,134.69) 165.31,134.74 165.38,134.74 arc(165.5,134.7) 165.55,134.58 v4(165.55,134.39)
  SIG7 w0.16: YJ26.C5 121.85,61.97 arc(121.96,62.14) 122,62.34 122,62.52 arc(121.9,62.76) 121.66,62.86 120.63,62.86 arc(120.46,62.9) 120.31,63 120.13,63.17 arc(119.88,63.34) 119.59,63.39 110.51,63.39 arc(110.36,63.42) 110.24,63.51 109.71,64.04 arc(109.62,64.16) 109.59,64.31 109.59,66.19 arc(109.62,66.34) 109.71,66.46 110.57,67.32 arc(110.69,67.41) 110.84,67.43 111.42,67.43 111.58,67.28 112.09,67.28 112.24,67.43 112.71,67.43 112.84,67.31 113.4,67.31 113.53,67.43 113.99,67.43 114.15,67.28 114.66,67.28 114.81,67.43 115.28,67.43 115.43,67.28 115.95,67.28 116.1,67.43 117.1,67.43 arc(117.39,67.49) 117.64,67.66 118.09,68.12 118.32,68.12 118.65,68.45 118.65,68.67 118.98,69 119.21,69 119.54,69.33 119.54,69.56 125.01,75.03 arc(125.17,75.28) 125.23,75.57 125.23,91.76 arc(125.26,91.91) 125.34,92.03 138.14,104.83 arc(138.31,105.08) 138.37,105.37 138.37,119.32 arc(138.4,119.47) 138.48,119.59 151.92,133.03 arc(152.04,133.11) 152.19,133.14 160.23,133.14 arc(160.53,133.2) 160.77,133.36 161.01,133.6 arc(161.13,133.68) 161.28,133.71 163.15,133.71
FC17_TDP1: length 121.5
  TOP w0.147: v4(167.55,135.29) 167.55,135.34 U1.AK63
  SIG6 w0.112: v4(167.55,135.29) 167.55,135.07 arc(167.51,134.98) 167.42,134.94 167.25,134.94 arc(167.16,134.98) 167.12,135.07 167.12,135.56 arc(167.09,135.69) 167.02,135.79 166.97,135.84 arc(166.87,135.91) 166.74,135.94 163.38,135.94 163.28,136.03 163.26,136.03
  SIG6 w0.16: YJ26.C3 123.3,60.8 arc(123.26,61.02) 123.14,61.2 122.75,61.58 arc(122.57,61.85) 122.51,62.16 122.51,62.48 arc(122.51,62.53) 122.5,62.58 arc(122.5,62.59) 122.49,62.6 arc(122.45,62.69) 122.39,62.77 122.35,62.82 122.26,62.9 arc(122.14,62.98) 121.99,63.01 110.71,63.01 arc(110.28,63.1) 109.9,63.35 109.55,63.7 arc(109.37,63.94) 109.25,64.22 arc(109.22,64.27) 109.21,64.32 109.21,66.29 arc(109.3,66.72) 109.55,67.09 116.03,73.58 arc(116.11,73.7) 116.14,73.85 116.14,74.43 arc(116.23,74.87) 116.48,75.24 118.19,76.95 arc(118.27,77.08) 118.3,77.22 118.3,79.76 arc(118.39,80.2) 118.64,80.57 124.77,86.7 arc(124.85,86.83) 124.88,86.97 124.88,91.63 arc(124.97,92.07) 125.21,92.44 137.87,105.1 arc(137.96,105.22) 137.99,105.37 137.99,119.13 arc(138.07,119.57) 138.32,119.94 151.65,133.27 arc(152.02,133.52) 152.46,133.6 159.52,133.6 arc(159.66,133.63) 159.79,133.72 161.77,135.7 arc(162.14,135.94) 162.57,136.03 163.26,136.03
FC17_TDP2: length 100.2
  TOP w0.147: U1.AJ61 170,134.84 arc(169.68,134.71) v4(169.55,134.39)
  SIG6 w0.112: v4(169.55,134.39) 169.55,134.58 arc(169.54,134.63) 169.51,134.67 169.48,134.71 arc(169.44,134.73) 169.39,134.74 169.25,134.74 arc(169.16,134.71) 169.12,134.62 169.12,134.12 arc(169.09,134) 169.02,133.9 168.97,133.84 arc(168.87,133.77) 168.74,133.75 163.38,133.75 163.28,133.66 163.26,133.66
  SIG6 w0.16: 163.26,133.66 163.1,133.66 arc(162.95,133.63) 162.82,133.54 160.56,131.28 arc(160.31,131.12) 160.02,131.06 153.11,131.06 arc(152.96,131.03) 152.84,130.95 140.64,118.75 arc(140.55,118.62) 140.53,118.48 140.53,104.76 arc(140.44,104.33) 140.19,103.96 127.44,91.2 arc(127.36,91.08) 127.33,90.93 127.33,76.52 arc(127.24,76.09) 126.99,75.71 125.56,74.28 125.56,74.01 125.18,73.63 124.91,73.63 124.57,73.29 124.57,73.04 124.17,72.64 123.92,72.64 123.58,72.3 123.58,72.03 123.2,71.65 122.93,71.65 122.59,71.31 122.59,70.97 122.27,70.66 121.93,70.66 121.59,70.32 121.59,69.98 121.28,69.66 120.94,69.66 120.6,69.32 arc(120.52,69.2) 120.49,69.06 120.49,67.06 arc(120.55,66.92) 120.69,66.86 121.66,66.86 arc(121.9,66.76) 122,66.52 122,66.34 arc(121.96,66.14) 121.85,65.97 YJ26.C34
FC17_TDP3: length 94
  TOP w0.147: v4(164.55,133.29) 164.55,133.34 U1.AH66
  SIG7 w0.112: v4(164.55,133.29) 164.55,133.1 arc(164.5,132.99) 164.38,132.94 164.24,132.94 arc(164.01,132.85) 163.92,132.62 163.92,132.21 arc(163.9,132.13) 163.86,132.07 163.8,132.01 arc(163.77,131.99) 163.74,131.98 arc(163.73,131.97) 163.71,131.97 163.27,131.97 163.18,132.07 163.15,132.07
  SIG7 w0.16: YJ26.C36 123.3,64.72 arc(123.24,65.01) 123.08,65.26 122.75,65.58 arc(122.57,65.85) 122.51,66.16 122.51,66.48 arc(122.51,66.53) 122.5,66.58 arc(122.49,66.6) 122.49,66.61 arc(122.45,66.7) 122.39,66.77 122.35,66.82 122.12,67.04 arc(121.75,67.59) 121.62,68.24 121.62,68.27 arc(121.8,69.16) 122.3,69.91 126.64,74.25 arc(126.87,74.59) 126.95,74.98 126.95,90.93 arc(127,91.23) 127.17,91.47 140.03,104.34 arc(140.12,104.46) 140.14,104.61 140.14,118.48 arc(140.2,118.77) 140.37,119.02 152.57,131.22 arc(152.81,131.38) 153.1,131.44 161.16,131.44 arc(161.31,131.47) 161.43,131.55 161.72,131.84 arc(161.97,132.01) 162.26,132.07 163.15,132.07
FC18_19_PVDD0P8: length 6
  TOP w0.229: U1.AH49 v1(181.55,133.34) ; U1.AK49 v1(181.55,135.34)
  TOP w0.508: 157.16,134.62 C2832.1 ; C2832.1 158.03,133.83 ; C2832.1 156.43,133.83
  BOTTOM w0.13: v1(158.05,135) v2(158.05,135.76)
  BOTTOM w0.381: v1(181.55,135.34) 181.06,135.83 C2780.1 ; C3338.1 181.06,133.83 v1(181.55,133.34)
  vias: v1(157.04,135)
FC18_RDN0: length 109.6
  TOP w0.147: U1.AG54 176.55,132.34 v4(176.55,132.29)
  SIG2 w0.112: v4(176.55,132.29) 176.55,132.07 arc(176.51,131.98) 176.42,131.94 176.25,131.94 arc(176.02,131.85) 175.92,131.62 175.92,130.16 arc(175.91,130.11) 175.89,130.07 175.79,129.97 arc(175.75,129.95) 175.7,129.94 163.43,129.94 163.33,130.03 163.31,130.03
  SIG2 w0.16: 163.31,130.03 161.94,130.03 arc(161.79,130.06) 161.67,130.14 160.77,131.04 arc(160.4,131.29) 159.96,131.38 153.17,131.38 arc(152.77,131.3) 152.42,131.09 arc(152.39,131.07) 152.36,131.04 140.48,119.16 arc(140.23,118.79) 140.14,118.35 140.14,104.68 arc(140.12,104.54) 140.03,104.41 127.28,91.66 arc(127.03,91.29) 126.95,90.85 126.95,72.08 arc(126.92,71.93) 126.83,71.81 126.01,70.99 arc(125.77,70.62) 125.68,70.18 125.68,64.64 arc(125.57,64.09) 125.26,63.63 125.01,63.38 124.71,63.08 arc(124.47,62.92) 124.18,62.86 123.3,62.86 arc(123.09,62.77) 123.01,62.56 123.01,62.35 arc(123.05,62.13) 123.18,61.94 YJ25.A17
FC18_RDN1: length 107.8
  TOP w0.147: U1.AF58 173,131.84 arc(172.83,131.81) 172.68,131.71 172.61,131.64 arc(172.57,131.57) 172.55,131.48 v4(172.55,131.39)
  SIG3 w0.112: 163.26,129.65 163.35,129.74 171.71,129.74 arc(171.83,129.77) 171.94,129.84 172.02,129.92 arc(172.09,130.03) 172.12,130.15 172.12,131.62 arc(172.16,131.71) 172.25,131.74 172.42,131.74 arc(172.51,131.71) 172.55,131.62 v4(172.55,131.39)
  SIG3 w0.16: YJ25.A15 121.7,60.79 arc(121.74,61.02) 121.87,61.2 122.34,61.67 arc(122.46,61.86) 122.51,62.08 122.51,62.57 arc(122.54,62.72) 122.63,62.86 122.68,62.91 arc(122.81,63) 122.95,63.03 124.39,63.03 arc(124.83,63.11) 125.2,63.36 125.72,63.89 arc(125.97,64.26) 126.06,64.69 126.06,66.25 arc(126.09,66.4) 126.17,66.52 126.98,67.33 arc(127.23,67.7) 127.31,68.14 127.31,68.64 127.54,68.87 127.54,69.43 127.31,69.66 127.31,70.17 127.54,70.4 127.54,70.96 127.31,71.18 127.31,90.84 arc(127.37,91.13) 127.54,91.38 140.3,104.14 arc(140.47,104.39) 140.53,104.68 140.53,118.35 arc(140.58,118.64) 140.75,118.89 152.7,130.84 arc(152.94,131) 153.24,131.06 160.14,131.06 arc(160.43,131) 160.68,130.84 161.64,129.88 arc(161.89,129.71) 162.18,129.65 163.26,129.65
FC18_RDN2: length 106.6
  TOP w0.147: v4(174.55,132.29) 174.55,132.34 U1.AG56
  SIG2 w0.112: 163.26,132.04 163.28,132.04 163.38,131.95 168.82,131.95 arc(169.05,131.85) 169.14,131.62 169.14,131.18 169.14,131.18 arc(169.15,131.13) 169.18,131.09 169.26,131.01 arc(169.3,130.99) 169.35,130.98 173.7,130.98 arc(173.75,130.99) 173.79,131.01 173.89,131.11 arc(173.91,131.15) 173.92,131.2 173.92,131.62 arc(174.02,131.85) 174.25,131.94 174.42,131.94 arc(174.51,131.98) 174.55,132.07 v4(174.55,132.29)
  SIG2 w0.16: 163.26,132.04 162.25,132.04 arc(161.96,132.1) 161.71,132.26 161.06,132.91 arc(160.81,133.07) 160.52,133.13 151.9,133.13 arc(151.54,133.07) 151.22,132.9 arc(151.16,132.85) 151.1,132.8 138.32,120.02 arc(138.07,119.65) 137.99,119.21 137.99,105.44 arc(137.96,105.3) 137.87,105.17 125.19,92.49 arc(124.94,92.12) 124.85,91.68 124.85,72.9 arc(124.82,72.76) 124.74,72.63 123.35,71.25 arc(123.11,70.88) 123.02,70.44 123.02,68.65 arc(122.86,67.86) 122.41,67.18 122.36,67.13 122.31,67.08 arc(122.07,66.92) 121.78,66.86 120.93,66.86 arc(120.7,66.77) 120.61,66.54 120.61,66.32 arc(120.64,66.13) 120.75,65.97 YJ25.A25
FC18_RDN3: length 100.1
  TOP w0.147: U1.AF60 171,131.84 arc(170.83,131.81) 170.68,131.71 170.61,131.64 arc(170.57,131.57) 170.55,131.48 v4(170.55,131.39)
  SIG3 w0.112: 163.26,131.65 163.28,131.65 163.38,131.74 168.84,131.74 arc(169,131.77) 169.13,131.86 arc(169.13,131.87) 169.14,131.87 169.53,131.87 arc(170.03,131.77) 170.46,131.48 v4(170.55,131.39)
  SIG3 w0.16: YJ25.A21 124.1,64.78 arc(124.15,65.01) 124.28,65.21 124.74,65.67 arc(124.86,65.86) 124.91,66.08 124.91,66.57 arc(124.93,66.71) 125.01,66.83 arc(125.17,67.08) 125.23,67.38 125.23,68.2 125.46,68.43 125.46,68.98 125.23,69.21 125.23,69.72 125.46,69.95 125.46,70.51 125.23,70.74 125.23,91.68 arc(125.29,91.97) 125.45,92.21 138.14,104.9 arc(138.31,105.15) 138.37,105.44 138.37,119.23 arc(138.42,119.52) 138.59,119.76 151.26,132.43 arc(151.35,132.51) 151.45,132.57 arc(151.62,132.63) 151.8,132.65 160.84,132.65 arc(161.04,132.63) 161.23,132.55 arc(161.31,132.5) 161.38,132.43 161.94,131.87 arc(162.18,131.71) 162.48,131.65 163.26,131.65
FC18_RDP0: length 109.5
  TOP w0.147: v4(176.55,131.39) 176.55,131.46 arc(176.56,131.52) 176.6,131.57 176.79,131.77 arc(176.87,131.82) 176.97,131.84 U1.AF54
  SIG2 w0.112: v4(176.55,131.39) 176.55,131.62 arc(176.51,131.71) 176.42,131.74 176.25,131.74 arc(176.16,131.71) 176.12,131.62 176.12,130.16 arc(176.09,130.04) 176.02,129.93 175.93,129.84 arc(175.82,129.77) 175.7,129.74 163.43,129.74 163.33,129.65 163.31,129.65
  SIG2 w0.16: 163.31,129.65 161.94,129.65 arc(161.65,129.71) 161.4,129.87 160.5,130.77 arc(160.25,130.94) 159.96,131 153.17,131 arc(152.9,130.95) 152.67,130.81 arc(152.65,130.79) 152.63,130.77 140.75,118.89 arc(140.58,118.64) 140.53,118.35 140.53,104.68 arc(140.47,104.39) 140.3,104.14 127.55,91.39 arc(127.39,91.14) 127.33,90.85 127.33,75.16 127.56,74.93 127.56,74.37 127.33,74.14 127.33,73.63 127.56,73.4 127.56,72.84 127.33,72.62 127.33,72.08 arc(127.27,71.79) 127.1,71.54 126.28,70.72 arc(126.12,70.47) 126.06,70.18 126.06,64.64 arc(125.92,63.95) 125.53,63.36 125.29,63.12 125.03,62.86 arc(124.94,62.72) 124.91,62.57 124.91,62.08 arc(124.86,61.86) 124.74,61.67 124.27,61.2 arc(124.14,61.02) 124.1,60.8 YJ25.A18
FC18_RDP1: length 107.8
  TOP w0.147: U1.AG58 172.55,132.34 v4(172.55,132.29)
  SIG3 w0.112: v4(172.55,132.29) 172.55,132.07 arc(172.51,131.98) 172.42,131.94 172.25,131.94 arc(172.02,131.85) 171.92,131.62 171.92,130.15 arc(171.91,130.1) 171.89,130.06 171.8,129.97 arc(171.76,129.95) 171.71,129.94 163.35,129.94 163.26,130.03
  SIG3 w0.16: YJ25.A14 120.75,61.97 arc(120.64,62.13) 120.61,62.32 120.61,62.54 arc(120.7,62.77) 120.93,62.86 121.78,62.86 arc(122.07,62.92) 122.31,63.08 122.36,63.13 122.41,63.18 arc(122.66,63.35) 122.95,63.41 124.39,63.41 arc(124.68,63.46) 124.93,63.63 125.46,64.16 arc(125.62,64.4) 125.68,64.69 125.68,66.25 arc(125.74,66.54) 125.9,66.79 126.71,67.6 arc(126.87,67.85) 126.93,68.14 126.93,90.84 arc(127.02,91.27) 127.27,91.65 140.03,104.41 arc(140.12,104.54) 140.14,104.68 140.14,118.35 arc(140.23,118.79) 140.48,119.16 152.43,131.11 arc(152.8,131.36) 153.24,131.44 160.14,131.44 arc(160.58,131.36) 160.95,131.11 161.91,130.15 arc(162.03,130.06) 162.18,130.03 163.26,130.03
FC18_RDP2: length 106.6
  TOP w0.147: v4(174.55,131.39) 174.55,131.46 arc(174.56,131.53) 174.6,131.58 174.79,131.77 arc(174.87,131.82) 174.96,131.84 U1.AF56
  SIG2 w0.112: 163.26,131.66 163.28,131.66 163.38,131.75 168.82,131.75 arc(168.91,131.71) 168.95,131.62 168.95,131.18 arc(168.97,131.05) 169.04,130.95 169.12,130.87 arc(169.22,130.8) 169.35,130.78 173.7,130.78 arc(173.82,130.8) 173.93,130.87 174.02,130.97 arc(174.09,131.07) 174.12,131.2 174.12,131.62 arc(174.16,131.71) 174.25,131.74 174.42,131.74 arc(174.51,131.71) 174.55,131.62 v4(174.55,131.39)
  SIG2 w0.16: YJ25.A24 121.7,64.79 arc(121.74,65.02) 121.87,65.2 122.34,65.67 arc(122.46,65.86) 122.51,66.08 122.51,66.57 arc(122.54,66.72) 122.63,66.86 122.68,66.91 arc(123.21,67.71) 123.4,68.65 123.4,70.44 arc(123.46,70.73) 123.62,70.98 125.01,72.36 arc(125.17,72.61) 125.23,72.9 125.23,73.41 125.47,73.65 125.47,74.19 125.23,74.43 125.23,74.94 125.45,75.15 125.46,75.16 125.46,75.72 125.23,75.95 125.23,91.68 arc(125.29,91.97) 125.46,92.22 138.14,104.9 arc(138.31,105.15) 138.37,105.44 138.37,119.21 arc(138.42,119.51) 138.59,119.75 151.37,132.53 arc(151.41,132.57) 151.45,132.6 arc(151.66,132.71) 151.9,132.75 160.52,132.75 arc(160.67,132.72) 160.79,132.64 161.44,131.99 arc(161.81,131.74) 162.25,131.66 163.26,131.66
FC18_RDP3: length 100.1
  TOP w0.147: U1.AG60 170.55,132.34 v4(170.55,132.29)
  SIG3 w0.112: 163.26,132.03 163.28,132.03 163.38,131.94 168.84,131.94 arc(168.92,131.96) 168.99,132 arc(169.06,132.05) 169.14,132.06 169.53,132.06 arc(169.8,132.04) 170.06,131.97 arc(170.17,131.96) 170.27,132.02 v4(170.55,132.29)
  SIG3 w0.16: YJ25.A22 123.15,65.97 arc(123.04,66.13) 123.01,66.32 123.01,66.54 arc(123.1,66.77) 123.33,66.86 124.18,66.86 arc(124.47,66.92) 124.72,67.08 arc(124.81,67.23) 124.85,67.41 124.85,91.68 arc(124.94,92.11) 125.18,92.48 137.87,105.17 arc(137.96,105.3) 137.99,105.44 137.99,119.23 arc(138.07,119.66) 138.32,120.03 150.99,132.7 arc(151.12,132.82) 151.27,132.91 arc(151.53,133) 151.8,133.03 160.84,133.03 arc(161.14,133) 161.42,132.88 arc(161.54,132.8) 161.65,132.7 162.21,132.14 arc(162.33,132.06) 162.48,132.03 163.26,132.03
FC18_TDN0: length 111.9
  TOP w0.147: v4(167.55,130.39) 167.55,130.47 arc(167.56,130.54) 167.6,130.59 167.71,130.7 arc(167.86,130.81) U1.AE63
  SIG4 w0.112: 163.22,131.66 163.25,131.66 163.34,131.75 166.71,131.75 arc(166.76,131.74) 166.8,131.71 166.89,131.63 arc(166.91,131.59) 166.92,131.54 166.92,131.07 arc(167.02,130.84) 167.25,130.74 167.42,130.74 arc(167.51,130.71) 167.55,130.62 v4(167.55,130.39)
  SIG4 w0.16: 163.22,131.66 162.66,131.66 arc(162.37,131.6) 162.13,131.43 161.98,131.28 arc(161.73,131.12) 161.44,131.06 153.21,131.06 arc(152.92,131) 152.67,130.84 140.75,118.91 arc(140.58,118.67) 140.53,118.38 140.53,107.76 arc(140.44,107.32) 140.19,106.95 125.35,92.1 arc(125.26,91.98) 125.23,91.83 125.23,70.99 125.46,70.76 125.46,70.2 125.23,69.97 125.23,69.47 125.46,69.24 125.46,68.68 125.23,68.45 125.23,67.67 arc(125.29,67.38) 125.46,67.13 125.84,66.76 arc(126,66.51) 126.06,66.22 126.06,64.25 arc(126,63.96) 125.84,63.72 125.37,63.25 arc(125.12,63.08) 124.83,63.03 113.35,63.03 arc(113.21,63) 113.08,62.91 113.03,62.86 arc(112.94,62.72) 112.91,62.57 112.91,62.08 arc(112.86,61.86) 112.74,61.67 112.28,61.21 arc(112.15,61.02) 112.1,60.78 YJ25.A3
FC18_TDN1: length 106.8
  TOP w0.147: U1.AF65 165.55,131.34 v4(165.55,131.29)
  SIG5 w0.112: 163.26,130.04 163.28,130.04 163.38,129.95 164.73,129.95 arc(164.78,129.96) 164.82,129.99 164.89,130.05 arc(164.92,130.09) 164.92,130.14 164.92,130.62 arc(165.02,130.85) 165.25,130.94 165.42,130.94 arc(165.51,130.98) 165.55,131.07 v4(165.55,131.29)
  SIG5 w0.16: YJ25.A5 113.55,61.97 arc(113.44,62.13) 113.41,62.32 113.41,62.56 arc(113.49,62.77) 113.71,62.86 114.58,62.86 arc(114.87,62.92) 115.12,63.08 115.16,63.13 115.21,63.18 arc(115.46,63.35) 115.75,63.41 125.01,63.41 arc(125.15,63.44) 125.28,63.52 125.58,63.82 arc(125.66,63.94) 125.69,64.09 125.69,66.21 arc(125.66,66.36) 125.58,66.48 125.19,66.87 arc(124.94,67.24) 124.85,67.67 124.85,91.71 arc(124.94,92.14) 125.19,92.51 140.03,107.36 arc(140.12,107.48) 140.14,107.63 140.14,118.35 arc(140.23,118.79) 140.48,119.16 150.27,128.95 arc(150.64,129.2) 151.08,129.28 159.01,129.28 arc(159.3,129.34) 159.55,129.51 159.86,129.82 arc(160.1,129.98) 160.39,130.04 163.26,130.04
FC18_TDN2: length 103.9
  TOP w0.147: v4(168.55,132.39) 168.55,132.47 arc(168.56,132.54) 168.6,132.59 168.71,132.7 arc(168.86,132.81) U1.AG62
  SIG4 w0.112: 163.26,133.66 163.28,133.66 163.38,133.75 167.71,133.75 arc(167.76,133.74) 167.8,133.71 167.89,133.63 arc(167.91,133.59) 167.92,133.54 167.92,133.07 arc(168.02,132.84) 168.25,132.74 168.42,132.74 arc(168.51,132.71) 168.55,132.62 v4(168.55,132.39)
  SIG4 w0.16: 163.26,133.66 162.66,133.66 arc(162.37,133.6) 162.13,133.43 161.57,132.87 arc(161.41,132.75) 161.23,132.68 arc(161.13,132.66) 161.03,132.65 151.83,132.65 arc(151.63,132.62) 151.45,132.55 arc(151.36,132.49) 151.29,132.43 138.59,119.73 arc(138.42,119.48) 138.37,119.19 138.37,108.36 arc(138.31,108.07) 138.14,107.83 118.83,88.51 arc(118.66,88.26) 118.61,87.97 118.61,72.94 arc(118.52,72.5) 118.27,72.13 116.25,70.1 116.25,69.85 115.78,69.38 115.53,69.38 115.17,69.02 115.17,68.77 114.7,68.31 114.45,68.31 114.09,67.95 114.09,67.82 113.5,67.23 113.37,67.23 113.01,66.87 113.03,66.86 arc(112.94,66.72) 112.91,66.57 112.91,66.08 arc(112.86,65.86) 112.74,65.67 112.27,65.21 arc(112.15,65.02) 112.1,64.79 YJ25.A36
FC18_TDN3: length 100.1
  TOP w0.147: v4(166.55,133.29) 166.55,133.34 U1.AH64
  SIG5 w0.112: v4(166.55,133.29) 166.55,133.07 arc(166.51,132.98) 166.42,132.94 166.25,132.94 arc(166.02,132.85) 165.92,132.62 165.92,132.14 arc(165.92,132.09) 165.89,132.05 165.82,131.99 arc(165.78,131.96) 165.73,131.95 163.38,131.95 163.28,132.04 163.26,132.04
  SIG5 w0.16: 163.26,132.04 162.99,132.04 arc(162.73,131.99) 162.52,131.85 162.26,131.59 arc(162.02,131.42) 161.72,131.37 150.14,131.37 arc(149.7,131.28) 149.33,131.03 138.32,120.02 arc(138.07,119.65) 137.99,119.21 137.99,108.52 arc(137.93,108.23) 137.76,107.98 118.45,88.67 arc(118.28,88.42) 118.22,88.13 118.22,72.99 arc(118.17,72.69) 118,72.45 115.15,69.59 arc(114.98,69.35) 114.93,69.05 114.93,67.04 arc(114.87,66.91) 114.74,66.86 113.68,66.86 arc(113.49,66.78) 113.41,66.59 113.41,66.32 arc(113.44,66.13) 113.55,65.97 YJ25.A34
FC18_TDP0: length 112
  TOP w0.147: U1.AF63 167.55,131.34 v4(167.55,131.29)
  SIG4 w0.112: v4(167.55,131.29) 167.55,131.07 arc(167.51,130.98) 167.42,130.94 167.25,130.94 arc(167.16,130.98) 167.12,131.07 167.12,131.54 arc(167.09,131.66) 167.02,131.77 166.94,131.85 arc(166.84,131.92) 166.71,131.95 163.34,131.95 163.25,132.04 163.22,132.04
  SIG4 w0.16: 163.22,132.04 162.66,132.04 arc(162.23,131.95) 161.86,131.7 161.71,131.55 arc(161.58,131.47) 161.44,131.44 153.21,131.44 arc(152.77,131.36) 152.4,131.11 140.48,119.18 arc(140.23,118.81) 140.14,118.38 140.14,107.76 arc(140.09,107.46) 139.92,107.22 125.08,92.37 arc(124.91,92.12) 124.85,91.83 124.85,67.67 arc(124.94,67.24) 125.19,66.87 125.57,66.49 arc(125.65,66.36) 125.68,66.22 125.68,64.25 arc(125.65,64.11) 125.57,63.99 125.1,63.52 arc(124.98,63.44) 124.83,63.41 113.35,63.41 arc(113.06,63.35) 112.81,63.18 112.76,63.13 112.72,63.08 arc(112.47,62.92) 112.18,62.86 111.3,62.86 arc(111.09,62.77) 111.01,62.56 111.01,62.32 arc(111.04,62.13) 111.15,61.97 111.3,61.82 YJ25.A2
FC18_TDP1: length 106.8
  TOP w0.147: U1.AE65 166,130.84 arc(165.68,130.71) v4(165.55,130.39)
  SIG5 w0.112: 163.26,129.66 163.28,129.66 163.38,129.75 164.73,129.75 arc(164.85,129.78) 164.96,129.85 165.03,129.91 arc(165.1,130.02) 165.12,130.14 165.12,130.62 arc(165.16,130.71) 165.25,130.74 165.42,130.74 arc(165.51,130.71) 165.55,130.62 v4(165.55,130.39)
  SIG5 w0.16: 163.26,129.66 162.5,129.66 162.34,129.51 161.58,129.51 161.43,129.66 160.39,129.66 arc(160.25,129.63) 160.12,129.55 159.81,129.24 arc(159.44,128.99) 159.01,128.9 156.43,128.9 156.27,128.75 155.51,128.75 155.36,128.9 154.6,128.9 154.44,128.75 153.68,128.75 153.53,128.9 151.08,128.9 arc(150.79,128.84) 150.54,128.68 140.75,118.89 arc(140.58,118.64) 140.53,118.35 140.53,107.63 arc(140.47,107.34) 140.3,107.09 125.46,92.24 arc(125.29,92) 125.23,91.71 125.23,67.67 arc(125.29,67.38) 125.46,67.13 125.84,66.75 arc(126.01,66.5) 126.07,66.21 126.07,64.09 arc(126.01,63.8) 125.84,63.55 125.55,63.25 arc(125.3,63.08) 125.01,63.03 115.75,63.03 arc(115.61,63) 115.48,62.91 115.43,62.86 arc(115.34,62.72) 115.31,62.57 115.31,62.08 arc(115.26,61.86) 115.14,61.68 114.92,61.45 114.66,61.19 arc(114.65,61.18) 114.64,61.18 arc(114.54,61.01) 114.5,60.82 YJ25.A6
