# Allegro board RA-B6910-64C-MAC.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R3520  499_1%  [R0603]  365.95 208.15 0 top
R3521  10K_1%  [R0402]  381.32 194.31 270 bottom
R3522  10K_1%  [R0402]  379.92 194.31 270 bottom
R3523  1K  [R0402]  378.52 190.62 270 bottom
R3524  2.2K  [R0402]  382.84 194.31 90 bottom
R3525  10K_1%  [R0402]  378.52 194.31 270 bottom
R3526  1K  [R0402]  375.73 194.31 90 bottom
R3527  10K_1%  [R0402]  9.08 130.93 270 top
R3528  10K_1%  [R0402]  281.06 218.49 180 top
R3529  10K_1%  [R0402]  36 141.73 180 top
R3530  4.7K  [R0402]  8.32 132.71 180 top
R3531  2.2K  [R0402]  7.81 130.93 90 top
R3532  10K_1%  [R0402]  276.42 217.93 270 top
R3533  1K  [R0402]  277.81 217.93 90 top
R3534  2.2K  [R0402]  281.06 217.22 0 top
R3535  2.2K  [R0402]  36 143.13 180 top
R3536  4.7K  [R0402]  273.88 217.93 90 top
R3537  2.2K  [R0402]  275.15 217.93 270 top
R3538  10K_1%  [R0402]  36.77 137.92 270 top
R3539  10K_1%  [R0402]  376.36 209.29 270 bottom
R3540  10K_1%  [R0402]  266.26 213.61 90 bottom
R3541  4.7K  [R0402]  36 139.7 180 top
R3542  2.2K  [R0402]  35.5 137.92 90 top
R3543  10K_1%  [R0402]  375.09 209.29 270 bottom
R3544  1K  [R0402]  370.9 205.99 270 bottom
R3545  2.2K  [R0402]  377.63 209.29 90 bottom
R3546  10K_1%  [R0402]  154.24 210.31 90 bottom
R3547  4.7K  [R0402]  155.38 210.31 270 bottom
R3548  4.7K  [R0402]  363.92 207.64 0 bottom
R3549  2.2K  [R0402]  265.11 213.61 270 bottom
R3550  2.2K  [R0402]  363.92 206.37 0 bottom
R3551  1K  [R0402]  370.65 163.95 270 bottom
R3552  X  [R0402]  369.38 163.95 270 bottom
R3553  10K_1%  [R0402]  153.1 210.31 90 bottom
R3554  10K_1%  [R0402]  368.87 121.16 90 bottom
R3555  4.7K  [R0402]  156.53 210.31 270 bottom
R3556  10K_1%  [R0402]  376.11 135.13 0 top
R3557  1K  [R0402]  370.14 123.44 90 bottom
R3558  2.2K  [R0402]  368.87 123.44 90 bottom
R3559  2.2K  [R0402]  153.1 212.47 90 bottom
R3560  10K_1%  [R0402]  370.14 121.16 90 bottom
R3561  4.7K  [R0402]  374.33 134.36 270 top
R3562  2.2K  [R0402]  376.11 133.86 180 top
R3563  2.2K  [R0402]  371.03 130.17 0 bottom
R3564  10K_1%  [R0402]  372.68 156.08 90 bottom
R3565  4.7K  [R0402]  366.46 156.33 270 bottom
R3566  4.7K  [R0402]  373.95 159.38 90 bottom
R3567  10K_1%  [R0402]  375.86 111.12 0 top
R3568  4.7K  [R0402]  374.08 110.36 270 top
R3569  2.2K  [R0402]  375.86 109.85 180 top
R3570  100K_1%  [R0603]  36.39 136.01 180 top
R3571  100K_1%  [R0603]  8.7 129.03 180 top
R3572  100K_1%  [R0603]  32.32 134.8 0 top
R3573  100K_1%  [R0603]  4.64 127.81 0 top
R3574  110K_1%  [R0603]  32.32 133.22 0 top
R3575  110K_1%  [R0603]  4.64 126.24 0 top
R3576  X  [R0603]  32.32 131.57 0 top
R3577  X  [R0603]  4.64 124.58 0 top
R3578  3.3_1%  [R1206]  38.04 125.47 180 bottom
R3579  3.3_1%  [R1206]  10.35 118.49 180 bottom
R3580  2.7  [R0603]  6.54 116.33 270 bottom
R3581  2.7  [R0603]  34.23 123.31 270 bottom
R3582  15K_1%  [R0402]  33.97 117.98 180 bottom
R3583  15K_1%  [R0402]  6.29 111 180 bottom
R3584  30.1K_1%  [R0603]  32.58 123.06 270 top
R3585  30.1K_1%  [R0603]  4.89 116.08 270 top
R3586  6.81K_1%  [R0603]  4.89 119 90 top
R3587  6.81K_1%  [R0603]  32.58 125.98 90 top
R3588  100K_1%  [R0603]  377.89 110.74 270 top
R3589  100K_1%  [R0603]  378.98 106.68 90 top
R3590  110K_1%  [R0603]  380.56 106.68 90 top
R3591  X  [R0603]  382.21 106.68 90 top
R3592  100K_1%  [R0603]  378.14 134.74 270 top
R3593  100K_1%  [R0603]  379.23 130.68 90 top
R3594  X  [R0603]  382.46 130.68 90 top
R3595  110K_1%  [R0603]  380.81 130.68 90 top
R3596  3.3_1%  [R1206]  388.3 112.39 270 bottom
R3597  2.7  [R0603]  390.46 108.58 0 bottom
R3598  3.3_1%  [R1206]  388.56 136.4 270 bottom
R3599  15K_1%  [R0402]  395.8 108.33 270 bottom
R3600  2.7  [R0603]  390.72 132.59 0 bottom
R3601  30.1K_1%  [R0603]  390.72 106.93 0 top
R3602  15K_1%  [R0402]  396.05 132.33 270 bottom
R3603  6.81K_1%  [R0603]  387.79 106.93 180 top
R3604  30.1K_1%  [R0603]  390.97 130.93 0 top
R3605  6.81K_1%  [R0603]  388.05 130.93 180 top
R3606  33  [R0402]  36 153.03 0 top
R3607  4.7K  [R0402]  59.07 137.01 180 top
R3608  100_1%  [R0402]  59.07 138.02 180 top
R3609  10K_1%  [R0402]  50.94 141.07 0 top
R3610  15K_1%  [R0402]  50.94 142.34 180 top
R3611  1.5K_1%  [R0402]  50.94 139.8 180 top
R3612  4.7K  [R0402]  59.07 141.07 180 top
R3613  100_1%  [R0402]  59.07 142.09 180 top
R3614  4.7K  [R0402]  59.07 157.33 180 top
R3615  100_1%  [R0402]  59.07 158.34 180 top
R3616  10K_1%  [R0402]  50.94 161.39 0 top
R3617  15K_1%  [R0402]  50.94 162.66 180 top
R3618  1.5K_1%  [R0402]  50.94 160.12 180 top
R3619  4.7K  [R0402]  59.07 161.39 180 top
R3620  100_1%  [R0402]  59.07 162.41 180 top
R3621  4.7K  [R0402]  59.07 177.65 180 top
R3622  100_1%  [R0402]  59.07 178.66 180 top
R3623  10K_1%  [R0402]  48.2 181.61 0 top
R3624  15K_1%  [R0402]  50.94 181.61 180 top
R3625  1.5K_1%  [R0402]  50.94 180.44 180 top
R3626  4.7K  [R0402]  59.07 181.71 180 top
R3627  100_1%  [R0402]  59.07 182.73 180 top
R3628  4.7K  [R0402]  355.48 141.5 0 top
R3629  100_1%  [R0402]  355.48 140.48 0 top
R3630  10K_1%  [R0402]  363.54 137.54 180 top
R3631  15K_1%  [R0402]  363.54 136.4 0 top
R3632  1.5K_1%  [R0402]  363.54 138.68 0 top
R3633  4.7K  [R0402]  355.48 137.44 0 top
R3634  100_1%  [R0402]  355.48 136.42 0 top
R3635  4.7K  [R0402]  355.48 161.82 0 top
R3636  100_1%  [R0402]  355.48 160.8 0 top
R3637  10K_1%  [R0402]  363.33 157.76 180 top
R3638  15K_1%  [R0402]  363.33 156.61 0 top
R3639  1.5K_1%  [R0402]  363.33 158.9 0 top
R3640  4.7K  [R0402]  355.48 157.76 0 top
R3641  100_1%  [R0402]  355.48 156.74 0 top
R3642  4.7K  [R0402]  355.48 182.14 0 top
R3643  100_1%  [R0402]  355.48 181.12 0 top
R3644  10K_1%  [R0402]  363.28 178.56 180 top
R3645  15K_1%  [R0402]  363.28 177.42 0 top
R3646  1.5K_1%  [R0402]  363.28 179.7 0 top
R3647  4.7K  [R0402]  355.48 178.08 0 top
R3648  100_1%  [R0402]  355.48 177.06 0 top
R3649  1K  [R0402]  371.92 161.9 270 top
R3650  1K  [R0402]  373.95 159.1 270 top
R3651  1K  [R0402]  375.12 161.9 270 top
R3652  0  [R0402]  371.67 159.1 270 top
R3653  0  [R0402]  372.81 159.1 270 top
R3654  X  [R0402]  375.12 159.1 270 top
R3655  200  [R0402]  380.94 173.35 270 top
R3656  X  [R0402]  376.26 161.9 270 top
R3657  200  [R0402]  381.95 173.35 270 top
R3658  X  [R0402]  376.14 159.1 270 top
R3659  X  [R0402]  377.28 159.1 270 top
R3660  1K  [R0402]  377.61 161.92 270 top
R3661  200  [R0402]  384.65 172.44 270 top
R3662  200  [R0402]  383.5 172.44 270 top
R3663  3.3K_1%  [R0402]  378.65 161.92 270 top
R3664  59K_1%  [R0402]  379.69 159.1 90 top
R3665  15K_1%  [R0402]  378.55 159.1 90 top
R3666  200  [R0402]  384.75 170.05 180 top
R3667  200  [R0402]  384.75 168.91 180 top
R3668  200  [R0402]  384.75 166.62 180 top
R3669  200  [R0402]  384.75 167.76 180 top
R3670  100_1%  [R0402]  377.25 172.84 180 bottom
R3671  200  [R0402]  384.52 164.72 180 top
R3672  200  [R0402]  384.52 163.42 180 top
R3673  200  [R0402]  384.52 161.14 180 top
R3674  200  [R0402]  384.52 162.15 180 top
R3675  X  [R0402]  390.84 186.31 180 top
R3676  X  [R0402]  390.84 187.58 180 top
RJ1  45110_25M151  [RJ45_2X1_LED_45110_2]  403.66 2.21 0 top
RV1  75V_150A  [R1210_ANT]  402.65 34.8 90 bottom
RV2  75V_150A  [R1210_ANT]  406.46 34.8 90 bottom
RV3  75V_150A  [R1210_ANT]  409.89 34.8 90 bottom
RV4  75V_150A  [R1210_ANT]  414.08 34.8 90 bottom
SINK1  -  [ZQ20100076_150MX100MX23M5]  197.5 139.3 0 top
SW1  -  [TS11C_2JL]  424.02 2 0 top
T1  G2405CG  [G24101MK]  407.1 42.29 180 top
TP1  ICT_PAD  [ICT_PAD_B_R30]  17.46 196.85 180 top
TP2  ICT_PAD  [ICT_PAD_B_R30]  8.95 189.99 0 top
TP3  ICT_PAD  [ICT_PAD_B_R30]  12.76 184.15 180 bottom
TP4  ICT_PAD  [ICT_PAD_B_R30]  11.75 189.99 0 top
TP5  ICT_PAD  [ICT_PAD_B_R30]  18.99 184.15 0 bottom
U1  BCM56970A0KFSBG  [FCBGA_4344]  197.55 139.34 180 top
U10  PCA9548APW  [TSSOP_24]  417.28 123.11 270 top
U11  PCA9548APW  [TSSOP_24]  51.4 100 270 top
U12  PCA9548APW  [TSSOP_24]  16.73 94.92 270 top
U13  PCA9548APW  [TSSOP_24]  417.28 110.54 270 bottom
U14  AT24C02C_SSHM_T  [SOP_8]  267.55 175.74 0 top
U15  PCA9548APW  [TSSOP_24]  51.4 100 270 bottom
U16  PCA9548APW  [TSSOP_24]  16.73 94.92 270 bottom
U17  PCA9548APW  [TSSOP_24]  417.28 123.11 270 bottom
U18  PCA9548APW  [TSSOP_24]  417.28 110.54 270 top
U44  TPS54527  [SOP_8_EP2M90X2M00]  260.46 215.97 90 top
U84  MAX3243CDBRG4  [SSOP_28]  408.65 87.93 0 top
U116  AT24C02C_SSHM_T  [SOP_8]  257.24 175.77 180 top
U117  CDCM6208  [VQFN_48_EP4M08]  297.95 208.38 180 bottom
U118  TPS3823_33DBVRG4  [TPS3823]  40.32 158.75 90 top
U119  SN74LVC244APWRG4  [TSSOP_20]  17.59 186.05 180 bottom
U120  SN74LVC244APWRG4  [TSSOP_20]  25.46 186.18 180 bottom
U121  LM75AIM  [SO_8]  201.51 197.3 0 top
U122  LM75AIM  [SO_8]  394.35 100.05 270 top
U123  LCMXO3LF_1300C_5BG256C  [CABAG_256_R014_1M70]  24.85 159 0 top
U124  LCMXO3LF_1300C_5BG256C  [CABAG_256_R014_1M70]  402.02 180.85 0 top
U125  TPS563201  [SOT23_6_1M10]  385.25 198.75 0 top
U126  TPS7A8101DRBR  [SON_8_1M75X1M50]  278.88 212.57 0 top
U127  TPS563201  [SOT23_6_1M10]  366.08 118.23 90 top
U128  TPS563201  [SOT23_6_1M10]  149.42 210.69 0 top
U129  TPS563201  [SOT23_6_1M10]  379.79 213.61 0 top
U130  TPS53353  [QFN_22_EPAD5M48X3M24]  9.97 121.66 0 top
U131  TPS53353  [QFN_22_EPAD5M48X3M24]  37.66 128.65 0 top
U132  TPS53353  [QFN_22_EPAD5M48X3M24]  385.13 112.01 90 top
U133  TPS53353  [QFN_22_EPAD5M48X3M24]  385.38 136.01 90 top
U134  ISL6617AFRZ-T  [QFN_10_EP2M00X1M60]  55.13 140.05 180 top
U135  ISL6617AFRZ-T  [QFN_10_EP2M00X1M60]  55.13 160.37 180 top
U136  ISL6617AFRZ-T  [QFN_10_EP2M00X1M60]  55.13 180.69 180 top
U137  ISL6617AFRZ-T  [QFN_10_EP2M00X1M60]  359.41 138.45 0 top
U138  ISL6617AFRZ-T  [QFN_10_EP2M00X1M60]  359.41 158.77 0 top
U139  ISL6617AFRZ-T  [QFN_10_EP2M00X1M60]  359.41 179.09 0 top
U140  ISL68127IRAZ-T  [QFN_48_EP4M40]  377.25 167.26 0 top
X1  TEST_018  [TEST_018_1]  199.55 166.34 180 bottom
X2  TEST_018  [TEST_018_1]  200.55 164.34 180 bottom
X3  TEST_018  [TEST_018_1]  199.55 165.34 180 bottom
X4  TEST_018  [TEST_018_1]  200.55 163.34 180 bottom
X28  -  [TEST_40]  236.92 218.82 90 top
X52  -  [SCREW_N_M_3_5MM]  103 78 0 top
X53  -  [SCREW_N_M_3_5MM]  286 99 0 top
X54  -  [SCREW_N_M_3_5MM]  367.42 94.29 0 top
X55  -  [SCREW_N_M_3_5MM]  79 214 0 top
X56  -  [SCREW_N_M_3_5MM]  197 78 0 top
X57  -  [SCREW_N_M_3_5MM]  55.44 131.06 0 top
X58  -  [SCREW_N_M_3_5MM]  224 214 0 top
X61  -  [TEST_40]  385.76 208.79 0 top
X62  -  [TEST_40]  366.59 142.11 270 top
X63  -  [SCREW_N_M_3_5MM]  124 214 0 top
X64  -  [SCREW_N_M_3_5MM]  334 214 0 top
X65  -  [SCREW_N_M_3_5MM]  424 214 0 top
X66  -  [SCREW_N_M_3_5MM]  109.12 106.42 0 top
X67  -  [SCREW_N_M_3_5MM]  292 78 0 top
X68  -  [SCREW_N_M_3_5MM]  424 47.6 0 top
X69  -  [SCREW_N_M_3_5MM]  305.5 152.3 0 top
X70  -  [SCREW_N_M_3_5MM]  31 83 0 top
X72  TEST_018  [TEST_018_1]  201.55 166.34 180 bottom
X73  TEST_018  [TEST_018_1]  200.55 161.34 180 bottom
X74  TEST_018  [TEST_018_1]  201.55 165.34 180 bottom
X75  TEST_018  [TEST_018_1]  201.55 161.34 180 bottom
X82  -  [SCREW_N_M_3_5MM]  6 205 0 top
X92  -  [TEST_40]  317.18 137.28 90 top
X93  -  [TEST_40]  316.04 178.05 270 top
X235  -  [SCREW_HOLE_3_5MM_1]  3.5 183 0 top
X237  -  [SCREW_HOLE_3_5MM_1]  3.5 93 0 top
X238  -  [SCREW_HOLE_3_5MM_1]  426.5 183 0 top
X239  -  [SCREW_HOLE_3_5MM_1]  426.5 93 0 top
X240  -  [SCREW_HOLE_5_5MM]  13 138 0 top
X241  -  [SCREW_HOLE_5_5MM]  417 138 0 top
X247  -  [TEST_40]  29.27 176.65 90 top
X248  -  [TEST_40]  32.7 176.65 90 top
X249  TEST_018  [TEST_018_1]  11.37 166.24 180 bottom
X250  -  [TEST_40]  393.64 194.69 0 top
X251  -  [TEST_40]  391.1 210.06 0 top
X252  TEST_018  [TEST_018_1]  395.16 188.59 180 bottom
X253  -  [TEST_40]  276.8 207.39 90 top
X254  -  [TEST_40]  368.24 201.29 180 top
X255  -  [TEST_40]  384.37 202.18 180 top
X256  -  [TEST_40]  363.54 101.22 270 top
X257  -  [TEST_40]  362.65 117.35 270 top
X258  -  [TEST_40]  159.32 193.42 180 top
X259  -  [TEST_40]  148.53 214.12 180 top
X260  -  [TEST_40]  362.65 208.15 180 top
X261  -  [TEST_40]  377 216.79 180 top
X262  -  [TEST_40]  50.36 112.39 180 top
X263  -  [TEST_40]  23.94 104.39 180 top
X264  -  [TEST_40]  51.75 123.31 180 top
X265  -  [TEST_40]  24.07 116.33 180 top
X266  -  [TEST_40]  405.96 124.08 270 top
X267  -  [TEST_40]  390.46 126.11 270 top
X268  -  [TEST_40]  406.72 151.64 270 top
X269  -  [TEST_40]  390.72 150.11 270 top
X271  TEST_018  [TEST_018_1]  411.54 187.32 180 bottom
X272  TEST_018  [TEST_018_1]  406.02 183.25 180 bottom
X273  TEST_018  [TEST_018_1]  405.22 182.45 180 bottom
X274  TEST_018  [TEST_018_1]  412.69 188.34 180 bottom
X275  TEST_018  [TEST_018_1]  411.54 188.59 180 bottom
X276  TEST_018  [TEST_018_1]  398.02 185.65 180 bottom
X277  TEST_018  [TEST_018_1]  410.12 187.3 180 bottom
X278  TEST_018  [TEST_018_1]  405.22 183.25 180 bottom
X279  TEST_018  [TEST_018_1]  406.02 182.45 180 bottom
X280  TEST_018  [TEST_018_1]  403.62 184.85 180 bottom
X281  TEST_018  [TEST_018_1]  403.62 184.05 180 bottom
X282  TEST_018  [TEST_018_1]  401.22 184.05 180 bottom
X283  TEST_018  [TEST_018_1]  397.22 181.65 180 bottom
X284  TEST_018  [TEST_018_1]  392.49 183.13 180 bottom
X285  TEST_018  [TEST_018_1]  392.62 181.3 180 bottom
X286  TEST_018  [TEST_018_1]  397.22 180.05 180 bottom
X287  -  [TEST_40]  332.55 123.7 270 top
X288  -  [TEST_40]  282.38 212.34 90 top
X289  -  [TEST_40]  261.43 210.69 0 top
X290  TEST_018  [TEST_018_1]  70.68 128.9 90 top
X291  TEST_018  [TEST_018_1]  71.06 139.06 90 top
X292  TEST_018  [TEST_018_1]  70.93 149.22 90 top
X293  TEST_018  [TEST_018_1]  70.93 159.38 90 top
X294  TEST_018  [TEST_018_1]  70.93 169.54 90 top
X295  TEST_018  [TEST_018_1]  70.93 179.7 90 top
X296  TEST_018  [TEST_018_1]  345.12 147.06 270 top
X297  TEST_018  [TEST_018_1]  345.12 137.03 270 top
X298  TEST_018  [TEST_018_1]  345.12 167.38 270 top
X299  TEST_018  [TEST_018_1]  345.12 157.22 270 top
X300  TEST_018  [TEST_018_1]  345.38 187.7 270 top
X301  TEST_018  [TEST_018_1]  345.12 177.54 270 top
X302  TEST_018  [TEST_018_1]  392.24 187.83 0 top
X303  TEST_018  [TEST_018_1]  310.32 207.64 0 top
YJ1  -  [438790025]  28.1 216.3 180 top
YJ2  -  [438790025]  64.1 216.3 180 top
YJ3  -  [10120667-101LF]  86.08 222.33 270 top
YJ21  2308171-9  [ZQSFP_2X2_LED]  14.2 51.9 0 top
YJ22  2308171-9  [ZQSFP_2X2_LED]  52.2 51.9 180 bottom
YJ23  2308171-9  [ZQSFP_2X2_LED]  61.2 51.9 0 top
YJ24  2308171-9  [ZQSFP_2X2_LED]  99.2 51.9 180 bottom
YJ25  2308171-9  [ZQSFP_2X2_LED]  108.2 51.9 0 top
YJ26  2308171-9  [ZQSFP_2X2_LED]  146.2 51.9 180 bottom
YJ27  2308171-9  [ZQSFP_2X2_LED]  155.2 51.9 0 top
YJ28  2308171-9  [ZQSFP_2X2_LED]  193.2 51.9 180 bottom
YJ29  2308171-9  [ZQSFP_2X2_LED]  202.2 51.9 0 top
YJ30  2308171-9  [ZQSFP_2X2_LED]  240.2 51.9 180 bottom
YJ31  2308171-9  [ZQSFP_2X2_LED]  249.2 51.9 0 top
YJ32  2308171-9  [ZQSFP_2X2_LED]  287.2 51.9 180 bottom
YJ33  2308171-9  [ZQSFP_2X2_LED]  296.2 51.9 0 top
YJ34  2308171-9  [ZQSFP_2X2_LED]  334.2 51.9 180 bottom
YJ35  2308171-9  [ZQSFP_2X2_LED]  343.2 51.9 0 top
YJ36  2308171-9  [ZQSFP_2X2_LED]  381.2 51.9 180 bottom

## Library data of the parts
C1-C4 C21 C27-C30 C49-C54 C74 C76 C80 C82 C84 C86 C88 C90 C92-C99 C102 C103 C108 C109 C111-C119 C205-C207 C209 C212 C213 C215 C216 C219 C221 C226 C227 C275 C276 C279 C281 C282 C284 C302 C303 C307 C308 C350 C351 C396-C414 C416-C440 C443-C468 C470-C495 C497-C522 C524-C548 C551-C576 C578-C603 C605-C630 C632-C656 C659-C684 C686 C688 C690 C692 C694 C696 C698 C700 C702 C704 C706 C708 C710 C714 C716 C718 C720 C722 C724 C726 C728 C730 C732 C734 C736 C738 C740 C742 C744 C746 C1143 C2066 C2068-C2072 C2075-C2082 C2148 C2150 C2152 C2154 C2156 C2158 C2160 C2162 C2164 C2166 C2168 C2170 C2172 C2175 C2177 C2178 C2180 C2182 C2184 C2187 C2189 C2191 C2193 C2194 C2196 C2198 C2200 C2202 C2205 C2207 C2208 C2210 C2212 C2214 C2216 C2218 C2220 C2222 C2225 C2226 C2228 C2230 C2232 C2234 C2236 C2239 C2241 C2242 C2244 C2246 C2249 C2251 C2253 C2254 C2257 C2258 C2261 C2263 C2264 C2266 C2268 C2270 C2272 C2274 C2276 C2278 C2280 C2282 C2284 C2286 C2288 C2290 C2292 C2294 C2296 C2298 C2301 C2303 C2304 C2306 C2308 C2310 C2312 C2314 C2317 C2319 C2321 C2322 C2324 C2326 C2328 C2330 C2333 C2335 C2336 C2338 C2340 C2342 C2344 C2346 C2349 C2351 C2353 C2354 C2356 C2359 C2360 C2362 C2364 C2367 C2369 C2370 C2372 C2374 C2376 C2378 C2380 C2382 C2385 C2386 C2388 C2390 C2392 C2394 C2396 C2398 C2401 C2402 C2404 C2407 C2409 C2411 C2413 C2415 C2417 C2418 C2420 C2422 C2424 C2426 C2428 C2430 C2432 C2434 C2436 C2438 C2440 C2443 C2445 C2447 C2449 C2450 C2452 C2455 C2457 C2458 C2460 C2462 C2464 C2466 C2468 C2470 C2472 C2474 C2477 C2479 C2481 C2482 C2484 C2487 C2488 C2490 C2492 C2495 C2497 C2498 C2500 C2502 C2504 C2506 C2509 C2511 C2513 C2514 C2516 C2518 C2520 C2522 C2524 C2527 C2529 C2530 C2532 C2534 C2536 C2538 C2540 C2542 C2545 C2546 C2548 C2550 C2552 C2554 C2556 C2558 C2560 C2562 C2564 C2566 C2569 C2571 C2573 C2574 C2577 C2578 C2581 C2583 C2584 C2586 C2588 C2590 C2592 C2594 C2596 C2598 C2600 C2602 C2604 C2606 C2608 C2610 C2612 C2614 C2616 C2618 C2621 C2623 C2624 C2626 C2628 C2630 C2632 C2634 C2637 C2639 C2641 C2642 C2644 C2646 C2648 C2650 C2652 C2655 C2657 C2658 C2660 C2661 C2664 C2666 C2668 C2674 C2676 C2678 C2679 C2681-C2685 C2688-C2690 C2692 C2694-C2696 C2703-C2706 C2712-C2714 C2716 C2717 C2719 C2720 C2723 C2728 C2729 C2731 C2734 C2737-C2739 C2742-C2744 C2746 C2751-C2754 C2758 C2762 C2764-C2767 C2769-C2771 C2774 C2776-C2783 C2786 C2787 C2791 C2793-C2795 C2798 C2805 C2808 C2812 C2815 C2816 C2818 C2819 C2821 C2824 C2827 C2831 C2839 C2841-C2843 C2845 C2846 C2849 C2850 C2852 C2853 C2855-C2857 C2860 C2863 C2865 C2866 C2868 C2869 C2872 C2877 C2880 C2883 C2884 C2887 C2889 C2894 C2897 C2899 C2901-C2904 C2906 C2907 C2911 C2918 C2919 C2921 C2924 C2925 C2927 C2931 C2933 C2935 C2938 C2939 C2944 C2945 C2951-C2953 C2955-C2957 C2959 C2962 C2967 C2968 C2971-C2977 C2979-C2981 C2987 C2992 C2993 C2995-C2997 C3001 C3002 C3006 C3007 C3011-C3014 C3016 C3018 C3019 C3021 C3023 C3024 C3026 C3027 C3029-C3031 C3033 C3034 C3036 C3040 C3042 C3044 C3046-C3048 C3050-C3052 C3054 C3058 C3059 C3061 C3062 C3065-C3067 C3069 C3073 C3074 C3076 C3079 C3081 C3082 C3084-C3087 C3089 C3090 C3092 C3094 C3095 C3100 C3101 C3103 C3104 C3107 C3109 C3111-C3117 C3120-C3125 C3128 C3130 C3132-C3134 C3138 C3140 C3141 C3144 C3145 C3147 C3150-C3156 C3158 C3166 C3171 C3172 C3174-C3179 C3183-C3190 C3192 C3194-C3197 C3317-C3347 C3421-C3424 C3426-C3436 C3438-C3461 C3463-C3465 C3468-C3487 C3491-C3502 C3505-C3515 C3517-C3521 C3523-C3526 C3529-C3532 C3534 C3535 C3537 C3538 C3540-C3548 C3551-C3554 C3556 C3557 C3561-C3564 C3567-C3570 C3572 C3573 C3576-C3586 C3589-C3592 C3594 C3595 C3605 C3607-C3609 C3611 C3617 C3618 C3620 C3627-C3629 C3635 C3636 C3638 C3644-C3646 C3649 C3671 C3673 C3680 C3681 C3688-C3691 C3713 C3720-C3722 C3724 C3731-C3733 C3798-C3802 C3809 C3811 C3813-C3816 C3821-C3825 C3832 C3834 C3836-C3839 C3844-C3848 C3855 C3857 C3859-C3862 C3867-C3871 C3878 C3880 C3882-C3885 C3890-C3894 C3901 C3903 C3905-C3908 C3913-C3917 C3924 C3926 C3928-C3931 C3936-C3942 C3944-C3951 = C0402: alternate symbols: (c0402;c0402_p;c0402_ap)
C5-C10 C17-C20 C2721 C2807 C2844 C2854 C2892 C2928 C3108 C3142 = C0402: alternate symbols: (c0402;c0402_p;c0402_ap); signal model: C0402_P_C0402_103_V-23030019-000_C0402;C0402_P_103
C11 C75 C79 C83 C87 C91 C274 C277 C280 C283 C299 C300 C305 C306 C349 C352 C415 C469 C496 C523 C577 C604 C631 C712 C2058 C2059 C2061-C2063 C2110 C2147 C2149 C2151 C2153 C2155 C2157 C2159 C2161 C2163 C2165 C2167 C2169 C2171 C2173 C2174 C2176 C2179 C2181 C2183 C2185 C2186 C2188 C2190 C2192 C2195 C2197 C2199 C2201 C2203 C2204 C2206 C2209 C2211 C2213 C2215 C2217 C2219 C2221 C2223 C2224 C2227 C2229 C2231 C2233 C2235 C2237 C2238 C2240 C2243 C2245 C2247 C2248 C2250 C2252 C2255 C2256 C2259 C2260 C2262 C2265 C2267 C2269 C2271 C2273 C2275 C2277 C2279 C2281 C2283 C2285 C2287 C2289 C2291 C2293 C2295 C2297 C2299 C2300 C2302 C2305 C2307 C2309 C2311 C2313 C2315 C2316 C2318 C2320 C2323 C2325 C2327 C2329 C2331 C2332 C2334 C2337 C2339 C2341 C2343 C2345 C2347 C2348 C2350 C2352 C2355 C2357 C2358 C2361 C2363 C2365 C2366 C2368 C2371 C2373 C2375 C2377 C2379 C2381 C2383 C2384 C2387 C2389 C2391 C2393 C2395 C2397 C2399 C2400 C2403 C2405 C2406 C2408 C2410 C2412 C2414 C2416 C2419 C2421 C2423 C2425 C2427 C2429 C2431 C2433 C2435 C2437 C2439 C2441 C2442 C2444 C2446 C2448 C2451 C2453 C2454 C2456 C2459 C2461 C2463 C2465 C2467 C2469 C2471 C2473 C2475 C2476 C2478 C2480 C2483 C2485 C2486 C2489 C2491 C2493 C2494 C2496 C2499 C2501 C2503 C2505 C2507 C2508 C2510 C2512 C2515 C2517 C2519 C2521 C2523 C2525 C2526 C2528 C2531 C2533 C2535 C2537 C2539 C2541 C2543 C2544 C2547 C2549 C2551 C2553 C2555 C2557 C2559 C2561 C2563 C2565 C2567 C2568 C2570 C2572 C2575 C2576 C2579 C2580 C2582 C2585 C2587 C2589 C2591 C2593 C2595 C2597 C2599 C2601 C2603 C2605 C2607 C2609 C2611 C2613 C2615 C2617 C2619 C2620 C2622 C2625 C2627 C2629 C2631 C2633 C2635 C2636 C2638 C2640 C2643 C2645 C2647 C2649 C2651 C2653 C2654 C2656 C2665 C2667 C2687 C2693 C2699 C2722 C2727 C2735 C2757 C2763 C2785 C2801 C2806 C2832 C2840 C2858 C2898 C2929 C2932 C2940 C2958 C2969 C2984 C2991 C3008 C3010 C3015 C3028 C3041 C3043 C3055 C3068 C3077 C3083 C3096 C3097 C3099 C3106 C3137 C3162 C3164 C3368 C3466 C3467 C3488 C3503 C3504 C3602 C3603 C3606 C3612 C3619 C3621 C3622 C3625 C3626 C3630 C3633 C3634 C3637 C3639 C3642 C3643 C3647 C3648 C3654 C3661 C3668-C3670 C3672 C3695 C3703 C3710-C3712 C3723 C3943 = C0603: alternate symbols: (C0603;C0603_ap)
C12 C13 C297 C298 C2109 C2659 C2672 C2673 C2675 C2686 C2691 C2697 C2698 C2702 C2708 C2730 C2732 C2733 C2736 C2745 C2750 C2755 C2756 C2759 C2761 C2768 C2796 C2797 C2804 C2810 C2811 C2813 C2830 C2834 C2835 C2847 C2862 C2864 C2867 C2871 C2876 C2882 C2893 C2905 C2909 C2910 C2914 C2915 C2922 C2937 C2941 C2948 C2950 C2960 C2964 C2978 C2983 C2986 C2994 C2999 C3000 C3005 C3022 C3053 C3057 C3060 C3070 C3072 C3078 C3093 C3098 C3119 C3131 C3139 C3143 C3159-C3161 C3163 C3167 C3180 C3182 C3191 C3369 C3489 C3490 C3604 C3613-C3616 C3623 C3624 C3631 C3632 C3640 C3641 C3650-C3653 C3655-C3660 C3662-C3667 C3692-C3694 C3696-C3702 C3704-C3709 C3803-C3808 C3810 C3812 C3817-C3820 C3826-C3831 C3833 C3835 C3840-C3843 C3849-C3854 C3856 C3858 C3863-C3866 C3872-C3877 C3879 C3881 C3886-C3889 C3895-C3900 C3902 C3904 C3909-C3912 C3918-C3923 C3925 C3927 C3932-C3935 = C0805: alternate symbols: (C0805;C0805_ap)
C14 C110 C2116 C2117 C3370 C3371 C3420 C3516 C3597-C3601 C3674-C3678 C3682-C3686 C3714-C3718 C3725-C3729 = C1206: alternate symbols: (C1206;C1206_ap)
C100 C204 = C0402: alternate symbols: (c0402;c0402_p;c0402_ap); signal model: C0402_C0402_103_V-23030019-000_C0402;C0402_P;C0402_AP_103
C101 C203 = C0603: alternate symbols: (C0603;C0603_ap); signal model: C0402_C0402_103_V-23030019-000_C0402;C0402_P;C0402_AP_103
C247 C278 = C0402: alternate symbols: (c0402;c0402_p;c0402_ap); signal model: CAP_NP_C0603_X_X
C301 = CAP_NP: signal model: CAP_NP_C0603_X_X
C389 C391 C393 C395 = C0402: alternate symbols: (c0402;c0402_p;c0402_ap); signal model: C0402_P_C0402_104_V-23030236-000_C0402;C0402_P_104
C685 C739 = C0603: alternate symbols: (C0603;C0603_ap); signal model: C0402_P_C0402_104_V-23030010-000_C0402;C0402_P_104
C687 C689 C691 C693 C695 C697 C699 C701 C703 C705 C707 C709 C711 C713 C715 C717 C719 C721 C723 C725 C727 C729 C731 C733 C735 C737 C741 C743 C745 C747 = C0402: alternate symbols: (c0402;c0402_p;c0402_ap); signal model: C0402_P_C0402_104_V-23030010-000_C0402;C0402_P_104
C870 C871 = C0805: alternate symbols: (C0805;C0805_ap); signal model: C0402_P_C0402_104_V-23030236-000_C0402;C0402_P_104
C872-C877 = C0805: alternate symbols: (C0805;C0805_ap); signal model: C0402_C0402_103_V-23030019-000_C0402;C0402_P;C0402_AP_103
C878 C879 C882-C887 = C0402_P: alternate symbols: (c0402;c0402_p); signal model: C0402_C0402_103_V-23030019-000_C0402;C0402_P;C0402_AP_103
C923-C948 C957-C1051 C1144-C1269 C2662 C2663 C2669 C2671 C2677 C2680 C2700 C2701 C2707 C2710 C2715 C2724-C2726 C2740 C2741 C2748 C2749 C2760 C2772 C2775 C2784 C2788-C2790 C2792 C2800 C2802 C2803 C2814 C2817 C2823 C2825 C2826 C2828 C2829 C2836-C2838 C2848 C2851 C2859 C2861 C2870 C2874 C2875 C2879 C2881 C2886 C2888 C2895 C2896 C2900 C2908 C2912 C2913 C2917 C2920 C2923 C2926 C2930 C2934 C2936 C2943 C2946 C2947 C2949 C2954 C2961 C2963 C2965 C2966 C2970 C2982 C2985 C2988 C2989 C2998 C3003 C3004 C3009 C3020 C3025 C3035 C3037 C3039 C3045 C3056 C3063 C3071 C3075 C3080 C3088 C3091 C3105 C3110 C3126 C3127 C3136 C3146 C3157 C3169 C3170 C3173 C3181 C3425 C3437 C3462 C3522 C3527 C3528 C3533 C3536 C3539 C3549 C3550 C3555 C3558 C3560 C3565 C3566 C3571 C3574 C3575 C3587 C3588 C3593 C3596 C3610 C3679 C3687 C3719 C3730 = C0402_P: alternate symbols: (c0402;c0402_p)
C2067 = CAP_NP
CD1 CD16 CD63 CD65-CD68 = CDNCC_0810_AP: alternate symbols: (CDNCC_0810;CDNCC_0810_AP)
CD47 CD48 CD58-CD62 CD64 CD69-CD80 = CAP_POL
D92-D94 = SRV05_4TCT: signal model: SRV05_4TCT_SOT_23_6_SRV05_4TCT_V-31090003-000_SRV05_4TCT
D363-D426 D429-D432 = LED_2_GR
D427 D428 D434 = LED_2P
D433 = LED_SMT0603_AP: alternate symbols: (LED_SMT0603;LED_SMT0603_AP)
D435-D446 = ISL99227BFRZ-T
FD1-FD8 = MARK
J18 = 1125_1103SNR23801
J29 = USB_A_09F
J30 J33 J34 = JP_10
J35 = CON_2X13_N
L24 L32-L64 L222 L228-L419 L430 L437 L444-L446 L448-L450 = L0805: alternate symbols: (L0805;L0805_AP)
L26 L66 L67 L70 L71 L74 L75 L78 L79 L226 L451-L454 L491-L502 = Inductor
L30 L31 L422 L425 L426 L428 L432 L433 L436 L438-L442 L447 = L0603: alternate symbols: (L0603;L0603_AP)
L65 L69 L73 L77 = BPH853225W4-101T
L455-L458 = TMPC1205HP-1R0MG-D
OSC1 = CRYSTAL_AP: alternate symbols: (CRYSTAL;CRYSTAL_AP)
OSC2 = SIT8103AI_83_33E
Q2 Q3 Q5 Q6 Q39 Q40 Q42-Q57 = BCE_NPN_AP: alternate symbols: (SOT_23;SOT_23_AP)
Q37 Q38 = SM12
Q41 = APL431LAAC_TRG_AP: alternate symbols: (SOT_23;SOT_23_AP)
R1-R23 R26-R35 R163-R183 R185-R196 R205 R216 R222 R224 R230 R238 R241 R246-R252 R266-R285 R295 R297 R305 R306 R308 R310 R312 R313 R316 R317 R320-R353 R374 R380 R382 R384 R388 R390 R402-R429 R435-R440 R454 R457 R460 R462 R466 R470 R1956 R1957 R2022-R2026 R2030 R2033 R2042-R2076 R2097-R2104 R2194-R2196 R2199 R2223-R2226 R2585-R2904 R2967-R2970 R2975-R2978 R2983-R2986 R2991-R2994 R2999-R3002 R3007-R3010 R3015-R3018 R3023-R3026 R3031-R3034 R3039-R3042 R3047-R3050 R3055-R3058 R3063-R3066 R3071-R3074 R3079-R3082 R3087-R3090 R3111 R3112 R3131-R3142 R3144-R3159 R3168-R3238 R3241-R3261 R3263-R3351 R3353 R3354 R3356-R3360 R3362-R3364 R3366-R3368 R3370-R3373 R3375-R3378 R3380-R3386 R3388 R3391-R3404 R3406 R3407 R3410 R3412-R3505 R3521-R3569 R3582 R3583 R3599 R3602 R3606-R3676 = R0402: alternate symbols: (r0402,r0402_p,R0402_AP)
R24 = R0402: alternate symbols: (r0402,r0402_p,R0402_AP); signal model: R0603_R0603_200_1%_V-21010066-000_R0603_R0603_AP_200_1%
R201 R206 R254 R288 R359 R367 R432 R446 = R0402: alternate symbols: (r0402,r0402_p,R0402_AP); signal model: R0402_P_R0402_33_V-21010237-000_R0402;R0402_P_33
R314 R1191 R1193 R2038 R2039 R2963-R2966 R2971-R2974 R2979-R2982 R2987-R2990 R2995-R2998 R3003-R3006 R3011-R3014 R3019-R3022 R3027-R3030 R3035-R3038 R3043-R3046 R3051-R3054 R3059-R3062 R3067-R3070 R3075-R3078 R3083-R3086 R3143 R3160-R3167 R3239 R3240 R3262 R3352 R3355 R3361 R3365 R3369 R3374 R3379 R3387 R3389 R3390 R3405 R3408 R3409 R3411 R3506-R3520 R3570-R3577 R3580 R3581 R3584-R3595 R3597 R3600 R3601 R3603-R3605 = R0603: alternate symbols: (R0603,R0603_AP)
R361 = R0402: alternate symbols: (r0402,r0402_p,R0402_AP); signal model: R0402_P_R0402_0_V-21010235-000_R0402;R0402_P_0
R2027 R2029 R2031 R2032 R2040 R3578 R3579 R3596 R3598 = R1206: alternate symbols: (R1206,R1206_AP)
R2028 R2034-R2037 = R0805: alternate symbols: (R0805,R0805_AP)
RJ1 = RJ45_2X1_LED_45110
RV1-RV4 = Resistor_VAR
SINK1 = HEAT_SINK_PTH_4PIN
SW1 = TS11C_2JL
T1 = G2405CG
TP1-TP5 = ICT_PAD: alternate symbols: (ICT_PAD_T_R40;ICT_PAD_B_R30)
U1 = BCM56970A0KFSBG
U10-U13 U15-U18 = PCA9548APW
U14 U116 = 24C02
U44 = TPS54227
U84 = MAX3243CDBRG4
U117 = CDCM6208
U118 = TPS3823_33DBVRG4
U119 U120 = 74LVC244A
U121 U122 = LM75A
U123 U124 = LCMXO3LF_1300C_5BG256C: tolerance: V10C
U125 U127-U129 = TPS563201
U126 = TPS7A8101DRBR
U130-U133 = TPS53353
U134-U139 = ISL6617AFRZ-T
U140 = ISL68127IRAZ-T
X1-X4 X72-X75 = TEST_018: alternate symbols: (test_018;test_018_1); signal model: TEST_018_TEST_018_1_TEST_018_TEST_018;TEST_018_1_TEST_018
X28 X61 X62 X92 X93 X247 X248 X250 X251 X253-X269 X287-X289 = TEST_40
X52-X58 X63-X70 X82 = SCREW_N
X235 X237-X241 = SCREW_HOLE_4_5MM
X249 X252 X271-X286 X290-X303 = TEST_018: alternate symbols: (test_018;test_018_1)
YJ1 YJ2 = 438790025
YJ3 = 10120667-101LF: tolerance: V10C
YJ21-YJ36 = 2308171_9

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1125_1103SN
  round 2.2 hole 1.2: 1(-2.54,0) 2(2.54,0)
3110_10G0BK00T1
  rect 1.02x4.5 smd: 1(-5.08,-3) 2(-5.08,3) 3(-2.54,-3) 4(-2.54,3) 5(0,-3) 6(0,3) 7(2.54,-3) 8(2.54,3) 9(5.08,-3) 10(5.08,3)
10120667-101LF
  round 2.8 hole 2.2: 1(0,0) 2(12.03,0) 3(12.03,12) 4(12.03,24) 5(0,24)
  round 0.77 hole 0.37: A1_1(1.33,21) A1_2(1.33,9) A2_1(-0.07,20.25) A2_2(-0.07,8.25) A3_1(0.63,19.5) A3_2(0.63,7.5) A4_1(1.33,18.75) A4_2(1.33,6.75) A5_1(-0.07,18) A5_2(-0.07,6) A6_1(0.63,17.25) A6_2(0.63,5.25) A7_1(1.33,16.5) A7_2(1.33,4.5) A8_1(-0.07,15.75) A8_2(-0.07,3.75) A9_1(0.63,15) A9_2(0.63,3) B1_1(5.13,21) B1_2(5.13,9) B2_1(3.73,20.25) B2_2(3.73,8.25) B3_1(4.43,19.5) B3_2(4.43,7.5) B4_1(5.13,18.75) B4_2(5.13,6.75) B5_1(3.73,18) B5_2(3.73,6) B6_1(4.43,17.25) B6_2(4.43,5.25) B7_1(5.13,16.5) B7_2(5.13,4.5) B8_1(3.73,15.75) B8_2(3.73,3.75) B9_1(4.43,15) B9_2(4.43,3) C1_1(8.93,21) C1_2(8.93,9) C2_1(7.53,20.25) C2_2(7.53,8.25) C3_1(8.23,19.5) C3_2(8.23,7.5) C4_1(8.93,18.75) C4_2(8.93,6.75) C5_1(7.53,18) C5_2(7.53,6) C6_1(8.23,17.25) C6_2(8.23,5.25) C7_1(8.93,16.5) C7_2(8.93,4.5) C8_1(7.53,15.75) C8_2(7.53,3.75) C9_1(8.23,15) C9_2(8.23,3) D1_1(12.73,21) D1_2(12.73,9) D2_1(11.33,20.25) D2_2(11.33,8.25) D3_1(12.03,19.5) D3_2(12.03,7.5) D4_1(12.73,18.75) D4_2(12.73,6.75) D5_1(11.33,18) D5_2(11.33,6) D6_1(12.03,17.25) D6_2(12.03,5.25) D7_1(12.73,16.5) D7_2(12.73,4.5) D8_1(11.33,15.75) D8_2(11.33,3.75) D9_1(12.03,15) D9_2(12.03,3)
438790025
  round 2.43 hole 1.83: 1(0,0) 2(4.2,0) 3(8.4,0) 4(12.6,0) 5(16.8,0) 6(0,-4.2) 7(4.2,-4.2) 8(8.4,-4.2) 9(12.6,-4.2) 10(16.8,-4.2)
74279225101
  rect 1.9x4.06 smd: 1(-4.105,0) 2(4.095,0)
C0402
  rect 0.559x0.559 smd: 1(-0.483,0) 2(0.483,0)
C0603
  rect 0.864x0.787 smd: 1(-0.737,0) 2(0.737,0)
C0805
  rect 1.118x1.27 smd: 1(-0.965,0) 2(0.965,0)
C1206
  rect 1.321x1.6 smd: 1(-1.575,0) 2(1.575,0)
C2220
  rect 2.5x5 smd: 1(-2.75,0) 2(2.75,0)
C200126080S9001R
  rect 0.8x3.3 smd: 1(-12,-2.1) 2(-12,2.1) 3(-10,-2.1) 4(-10,2.1) 5(-8,-2.1) 6(-8,2.1) 7(-6,-2.1) 8(-6,2.1) 9(-4,-2.1) 10(-4,2.1) 11(-2,-2.1) 12(-2,2.1) 13(0,-2.1) 14(0,2.1) 15(2,-2.1) 16(2,2.1) 17(4,-2.1) 18(4,2.1) 19(6,-2.1) 20(6,2.1) 21(8,-2.1) 22(8,2.1) 23(10,-2.1) 24(10,2.1) 25(12,-2.1) 26(12,2.1)
CABAG_256_R014_1M70
  round 0.356 smd: A1(-6,6) A2(-5.2,6) A3(-4.4,6) A4(-3.6,6) A5(-2.8,6) A6(-2,6) A7(-1.2,6) A8(-0.4,6) A9(0.4,6) A10(1.2,6) A11(2,6) A12(2.8,6) A13(3.6,6) A14(4.4,6) A15(5.2,6) A16(6,6) B1(-6,5.2) B2(-5.2,5.2) B3(-4.4,5.2) B4(-3.6,5.2) B5(-2.8,5.2) B6(-2,5.2) B7(-1.2,5.2) B8(-0.4,5.2) B9(0.4,5.2) B10(1.2,5.2) B11(2,5.2) B12(2.8,5.2) B13(3.6,5.2) B14(4.4,5.2) B15(5.2,5.2) B16(6,5.2) C1(-6,4.4) C2(-5.2,4.4) C3(-4.4,4.4) C4(-3.6,4.4) C5(-2.8,4.4) C6(-2,4.4) C7(-1.2,4.4) C8(-0.4,4.4) C9(0.4,4.4) C10(1.2,4.4) C11(2,4.4) C12(2.8,4.4) C13(3.6,4.4) C14(4.4,4.4) C15(5.2,4.4) C16(6,4.4) D1(-6,3.6) D2(-5.2,3.6) D3(-4.4,3.6) D4(-3.6,3.6) D5(-2.8,3.6) D6(-2,3.6) D7(-1.2,3.6) D8(-0.4,3.6) D9(0.4,3.6) D10(1.2,3.6) D11(2,3.6) D12(2.8,3.6) D13(3.6,3.6) D14(4.4,3.6) D15(5.2,3.6) D16(6,3.6) E1(-6,2.8) E2(-5.2,2.8) E3(-4.4,2.8) E4(-3.6,2.8) E5(-2.8,2.8) E6(-2,2.8) E7(-1.2,2.8) E8(-0.4,2.8) E9(0.4,2.8) E10(1.2,2.8) E11(2,2.8) E12(2.8,2.8) E13(3.6,2.8) E14(4.4,2.8) E15(5.2,2.8) E16(6,2.8) F1(-6,2) F2(-5.2,2) F3(-4.4,2) F4(-3.6,2) F5(-2.8,2) F6(-2,2) F7(-1.2,2) F8(-0.4,2) F9(0.4,2) F10(1.2,2) F11(2,2) F12(2.8,2) F13(3.6,2) F14(4.4,2) F15(5.2,2) F16(6,2) G1(-6,1.2) G2(-5.2,1.2) G3(-4.4,1.2) G4(-3.6,1.2) G5(-2.8,1.2) G6(-2,1.2) G7(-1.2,1.2) G8(-0.4,1.2) G9(0.4,1.2) G10(1.2,1.2) G11(2,1.2) G12(2.8,1.2) G13(3.6,1.2) G14(4.4,1.2) G15(5.2,1.2) G16(6,1.2) H1(-6,0.4) H2(-5.2,0.4) H3(-4.4,0.4) H4(-3.6,0.4) H5(-2.8,0.4) H6(-2,0.4) H7(-1.2,0.4) H8(-0.4,0.4) H9(0.4,0.4) H10(1.2,0.4) H11(2,0.4) H12(2.8,0.4) H13(3.6,0.4) H14(4.4,0.4) H15(5.2,0.4) H16(6,0.4) J1(-6,-0.4) J2(-5.2,-0.4) J3(-4.4,-0.4) J4(-3.6,-0.4) J5(-2.8,-0.4) J6(-2,-0.4) J7(-1.2,-0.4) J8(-0.4,-0.4) J9(0.4,-0.4) J10(1.2,-0.4) J11(2,-0.4) J12(2.8,-0.4) J13(3.6,-0.4) J14(4.4,-0.4) J15(5.2,-0.4) J16(6,-0.4) K1(-6,-1.2) K2(-5.2,-1.2) K3(-4.4,-1.2) K4(-3.6,-1.2) K5(-2.8,-1.2) K6(-2,-1.2) K7(-1.2,-1.2) K8(-0.4,-1.2) K9(0.4,-1.2) K10(1.2,-1.2) K11(2,-1.2) K12(2.8,-1.2) K13(3.6,-1.2) K14(4.4,-1.2) K15(5.2,-1.2) K16(6,-1.2) L1(-6,-2) L2(-5.2,-2) L3(-4.4,-2) L4(-3.6,-2) L5(-2.8,-2) L6(-2,-2) L7(-1.2,-2) L8(-0.4,-2) L9(0.4,-2) L10(1.2,-2) L11(2,-2) L12(2.8,-2) L13(3.6,-2) L14(4.4,-2) L15(5.2,-2) L16(6,-2) M1(-6,-2.8) M2(-5.2,-2.8) M3(-4.4,-2.8) M4(-3.6,-2.8) M5(-2.8,-2.8) M6(-2,-2.8) M7(-1.2,-2.8) M8(-0.4,-2.8) M9(0.4,-2.8) M10(1.2,-2.8) M11(2,-2.8) M12(2.8,-2.8) M13(3.6,-2.8) M14(4.4,-2.8) M15(5.2,-2.8) M16(6,-2.8) N1(-6,-3.6) N2(-5.2,-3.6) N3(-4.4,-3.6) N4(-3.6,-3.6) N5(-2.8,-3.6) N6(-2,-3.6) N7(-1.2,-3.6) N8(-0.4,-3.6) N9(0.4,-3.6) N10(1.2,-3.6) N11(2,-3.6) N12(2.8,-3.6) N13(3.6,-3.6) N14(4.4,-3.6) N15(5.2,-3.6) N16(6,-3.6) P1(-6,-4.4) P2(-5.2,-4.4) P3(-4.4,-4.4) P4(-3.6,-4.4) P5(-2.8,-4.4) P6(-2,-4.4) P7(-1.2,-4.4) P8(-0.4,-4.4) P9(0.4,-4.4) P10(1.2,-4.4) P11(2,-4.4) P12(2.8,-4.4) P13(3.6,-4.4) P14(4.4,-4.4) P15(5.2,-4.4) P16(6,-4.4) R1(-6,-5.2) R2(-5.2,-5.2) R3(-4.4,-5.2) R4(-3.6,-5.2) R5(-2.8,-5.2) R6(-2,-5.2) R7(-1.2,-5.2) R8(-0.4,-5.2) R9(0.4,-5.2) R10(1.2,-5.2) R11(2,-5.2) R12(2.8,-5.2) R13(3.6,-5.2) R14(4.4,-5.2) R15(5.2,-5.2) R16(6,-5.2) T1(-6,-6) T2(-5.2,-6) T3(-4.4,-6) T4(-3.6,-6) T5(-2.8,-6) T6(-2,-6) T7(-1.2,-6) T8(-0.4,-6) T9(0.4,-6) T10(1.2,-6) T11(2,-6) T12(2.8,-6) T13(3.6,-6) T14(4.4,-6) T15(5.2,-6) T16(6,-6)
CDNCC_10M30X12M2
  rect 3.75x1.4 smd: 1(4.125,0) 2(-4.125,0)
CDNCC_0810
  rect 3.45x1.4 smd: 1(3.275,0) 2(-3.275,0)
CDRUB_7M3X4M3
  rect 3.18x2.54 smd: 1(3.62,0) 2(-3.62,0)
CRYSTAL
  rect 5.5x2 smd: 1(-4.75,0) 2(4.75,0)
FCBGA_4344
  round 0.457 smd: A3(-30.5,32.5) A4(-29.5,32.5) A5(-28.5,32.5) A6(-27.5,32.5) A7(-26.5,32.5) A8(-25.5,32.5) A9(-24.5,32.5) A10(-23.5,32.5) A11(-22.5,32.5) A12(-21.5,32.5) A13(-20.5,32.5) A14(-19.5,32.5) A15(-18.5,32.5) A16(-17.5,32.5) A17(-16.5,32.5) A18(-15.5,32.5) A19(-14.5,32.5) A20(-13.5,32.5) A21(-12.5,32.5) A22(-11.5,32.5) A23(-10.5,32.5) A24(-9.5,32.5) A25(-8.5,32.5) A26(-7.5,32.5) A27(-6.5,32.5) A28(-5.5,32.5) A29(-4.5,32.5) A30(-3.5,32.5) A31(-2.5,32.5) A32(-1.5,32.5) A33(-0.5,32.5) A34(0.5,32.5) A35(1.5,32.5) A36(2.5,32.5) A37(3.5,32.5) A38(4.5,32.5) A39(5.5,32.5) A40(6.5,32.5) A41(7.5,32.5) A42(8.5,32.5) A43(9.5,32.5) A44(10.5,32.5) A45(11.5,32.5) A46(12.5,32.5) A47(13.5,32.5) A48(14.5,32.5) A49(15.5,32.5) A50(16.5,32.5) A51(17.5,32.5) A52(18.5,32.5) A53(19.5,32.5) A54(20.5,32.5) A55(21.5,32.5) A56(22.5,32.5) A57(23.5,32.5) A58(24.5,32.5) A59(25.5,32.5) A60(26.5,32.5) A61(27.5,32.5) A62(28.5,32.5) A63(29.5,32.5) A64(30.5,32.5) AA1(-32.5,12.5) AA2(-31.5,12.5) AA3(-30.5,12.5) AA4(-29.5,12.5) AA5(-28.5,12.5) AA6(-27.5,12.5) AA7(-26.5,12.5) AA8(-25.5,12.5) AA9(-24.5,12.5) AA10(-23.5,12.5) AA11(-22.5,12.5) AA12(-21.5,12.5) AA13(-20.5,12.5) AA14(-19.5,12.5) AA15(-18.5,12.5) AA16(-17.5,12.5) AA17(-16.5,12.5) AA18(-15.5,12.5) AA19(-14.5,12.5) AA20(-13.5,12.5) AA21(-12.5,12.5) AA22(-11.5,12.5) AA23(-10.5,12.5) AA24(-9.5,12.5) AA25(-8.5,12.5) AA26(-7.5,12.5) AA27(-6.5,12.5) AA28(-5.5,12.5) AA29(-4.5,12.5) AA30(-3.5,12.5) AA31(-2.5,12.5) AA32(-1.5,12.5) AA33(-0.5,12.5) AA34(0.5,12.5) AA35(1.5,12.5) AA36(2.5,12.5) AA37(3.5,12.5) AA38(4.5,12.5) AA39(5.5,12.5) AA40(6.5,12.5) AA41(7.5,12.5) AA42(8.5,12.5) AA43(9.5,12.5) AA44(10.5,12.5) AA45(11.5,12.5) AA46(12.5,12.5) AA47(13.5,12.5) AA48(14.5,12.5) AA49(15.5,12.5) AA50(16.5,12.5) AA51(17.5,12.5) AA52(18.5,12.5) AA53(19.5,12.5) AA54(20.5,12.5) AA55(21.5,12.5) AA56(22.5,12.5) AA57(23.5,12.5) AA58(24.5,12.5) AA59(25.5,12.5) AA60(26.5,12.5) AA61(27.5,12.5) AA62(28.5,12.5) AA63(29.5,12.5) AA64(30.5,12.5) AA65(31.5,12.5) AA66(32.5,12.5) AB1(-32.5,11.5) AB2(-31.5,11.5) AB3(-30.5,11.5) AB4(-29.5,11.5) AB5(-28.5,11.5) AB6(-27.5,11.5) AB7(-26.5,11.5) AB8(-25.5,11.5) AB9(-24.5,11.5) AB10(-23.5,11.5) AB11(-22.5,11.5) AB12(-21.5,11.5) AB13(-20.5,11.5) AB14(-19.5,11.5) AB15(-18.5,11.5) AB16(-17.5,11.5) AB17(-16.5,11.5) AB18(-15.5,11.5) AB19(-14.5,11.5) AB20(-13.5,11.5) AB21(-12.5,11.5) AB22(-11.5,11.5) AB23(-10.5,11.5) AB24(-9.5,11.5) AB25(-8.5,11.5) AB26(-7.5,11.5) AB27(-6.5,11.5) AB28(-5.5,11.5) AB29(-4.5,11.5) AB30(-3.5,11.5) AB31(-2.5,11.5) AB32(-1.5,11.5) AB33(-0.5,11.5) AB34(0.5,11.5) AB35(1.5,11.5) AB36(2.5,11.5) AB37(3.5,11.5) AB38(4.5,11.5) AB39(5.5,11.5) AB40(6.5,11.5) AB41(7.5,11.5) AB42(8.5,11.5) AB43(9.5,11.5) AB44(10.5,11.5) AB45(11.5,11.5) AB46(12.5,11.5) AB47(13.5,11.5) AB48(14.5,11.5) AB49(15.5,11.5) AB50(16.5,11.5) AB51(17.5,11.5) AB52(18.5,11.5) AB53(19.5,11.5) AB54(20.5,11.5) AB55(21.5,11.5) AB56(22.5,11.5) AB57(23.5,11.5) AB58(24.5,11.5) AB59(25.5,11.5) AB60(26.5,11.5) AB61(27.5,11.5) AB62(28.5,11.5) AB63(29.5,11.5) AB64(30.5,11.5) AB65(31.5,11.5) AB66(32.5,11.5) AC1(-32.5,10.5) AC2(-31.5,10.5) AC3(-30.5,10.5) AC4(-29.5,10.5) AC5(-28.5,10.5) AC6(-27.5,10.5) AC7(-26.5,10.5) AC8(-25.5,10.5) AC9(-24.5,10.5) AC10(-23.5,10.5) AC11(-22.5,10.5) AC12(-21.5,10.5) AC13(-20.5,10.5) AC14(-19.5,10.5) AC15(-18.5,10.5) AC16(-17.5,10.5) AC17(-16.5,10.5) AC18(-15.5,10.5) AC19(-14.5,10.5) AC20(-13.5,10.5) AC21(-12.5,10.5) AC22(-11.5,10.5) AC23(-10.5,10.5) AC24(-9.5,10.5) AC25(-8.5,10.5) AC26(-7.5,10.5) AC27(-6.5,10.5) AC28(-5.5,10.5) AC29(-4.5,10.5) AC30(-3.5,10.5) AC31(-2.5,10.5) AC32(-1.5,10.5) AC33(-0.5,10.5) AC34(0.5,10.5) AC35(1.5,10.5) AC36(2.5,10.5) AC37(3.5,10.5) AC38(4.5,10.5) AC39(5.5,10.5) AC40(6.5,10.5) AC41(7.5,10.5) AC42(8.5,10.5) AC43(9.5,10.5) AC44(10.5,10.5) AC45(11.5,10.5) AC46(12.5,10.5) AC47(13.5,10.5) AC48(14.5,10.5) AC49(15.5,10.5) AC50(16.5,10.5) AC51(17.5,10.5) AC52(18.5,10.5) AC53(19.5,10.5) AC54(20.5,10.5) AC55(21.5,10.5) AC56(22.5,10.5) AC57(23.5,10.5) AC58(24.5,10.5) AC59(25.5,10.5) AC60(26.5,10.5) AC61(27.5,10.5) AC62(28.5,10.5) AC63(29.5,10.5) AC64(30.5,10.5) AC65(31.5,10.5) AC66(32.5,10.5) AD1(-32.5,9.5) AD2(-31.5,9.5) AD3(-30.5,9.5) AD4(-29.5,9.5) AD5(-28.5,9.5) AD6(-27.5,9.5) AD7(-26.5,9.5) AD8(-25.5,9.5) AD9(-24.5,9.5) AD10(-23.5,9.5) AD11(-22.5,9.5) AD12(-21.5,9.5) AD13(-20.5,9.5) AD14(-19.5,9.5) AD15(-18.5,9.5) AD16(-17.5,9.5) AD17(-16.5,9.5) AD18(-15.5,9.5) AD19(-14.5,9.5) AD20(-13.5,9.5) AD21(-12.5,9.5) AD22(-11.5,9.5) AD23(-10.5,9.5) AD24(-9.5,9.5) AD25(-8.5,9.5) AD26(-7.5,9.5) AD27(-6.5,9.5) AD28(-5.5,9.5) AD29(-4.5,9.5) AD30(-3.5,9.5) AD31(-2.5,9.5) AD32(-1.5,9.5) AD33(-0.5,9.5) AD34(0.5,9.5) AD35(1.5,9.5) AD36(2.5,9.5) AD37(3.5,9.5) AD38(4.5,9.5) AD39(5.5,9.5) AD40(6.5,9.5) AD41(7.5,9.5) AD42(8.5,9.5) AD43(9.5,9.5) AD44(10.5,9.5) AD45(11.5,9.5) AD46(12.5,9.5) AD47(13.5,9.5) AD48(14.5,9.5) AD49(15.5,9.5) AD50(16.5,9.5) AD51(17.5,9.5) AD52(18.5,9.5) AD53(19.5,9.5) AD54(20.5,9.5) AD55(21.5,9.5) AD56(22.5,9.5) AD57(23.5,9.5) AD58(24.5,9.5) AD59(25.5,9.5) AD60(26.5,9.5) AD61(27.5,9.5) AD62(28.5,9.5) AD63(29.5,9.5) AD64(30.5,9.5) AD65(31.5,9.5) AD66(32.5,9.5) AE1(-32.5,8.5) AE2(-31.5,8.5) AE3(-30.5,8.5) AE4(-29.5,8.5) AE5(-28.5,8.5) AE6(-27.5,8.5) AE7(-26.5,8.5) AE8(-25.5,8.5) AE9(-24.5,8.5) AE10(-23.5,8.5) AE11(-22.5,8.5) AE12(-21.5,8.5) AE13(-20.5,8.5) AE14(-19.5,8.5) AE15(-18.5,8.5) AE16(-17.5,8.5) AE17(-16.5,8.5) AE18(-15.5,8.5) AE19(-14.5,8.5) AE20(-13.5,8.5) AE21(-12.5,8.5) AE22(-11.5,8.5) AE23(-10.5,8.5) AE24(-9.5,8.5) AE25(-8.5,8.5) AE26(-7.5,8.5) AE27(-6.5,8.5) AE28(-5.5,8.5) AE29(-4.5,8.5) AE30(-3.5,8.5) AE31(-2.5,8.5) AE32(-1.5,8.5) AE33(-0.5,8.5) AE34(0.5,8.5) AE35(1.5,8.5) AE36(2.5,8.5) AE37(3.5,8.5) AE38(4.5,8.5) AE39(5.5,8.5) AE40(6.5,8.5) AE41(7.5,8.5) AE42(8.5,8.5) AE43(9.5,8.5) AE44(10.5,8.5) AE45(11.5,8.5) AE46(12.5,8.5) AE47(13.5,8.5) AE48(14.5,8.5) AE49(15.5,8.5) AE50(16.5,8.5) AE51(17.5,8.5) AE52(18.5,8.5) AE53(19.5,8.5) AE54(20.5,8.5) AE55(21.5,8.5) AE56(22.5,8.5) AE57(23.5,8.5) AE58(24.5,8.5) AE59(25.5,8.5) AE60(26.5,8.5) AE61(27.5,8.5) AE62(28.5,8.5) AE63(29.5,8.5) AE64(30.5,8.5) AE65(31.5,8.5) AE66(32.5,8.5) AF1(-32.5,7.5) AF2(-31.5,7.5) AF3(-30.5,7.5) AF4(-29.5,7.5) AF5(-28.5,7.5) AF6(-27.5,7.5) AF7(-26.5,7.5) AF8(-25.5,7.5) AF9(-24.5,7.5) AF10(-23.5,7.5) AF11(-22.5,7.5) AF12(-21.5,7.5) AF13(-20.5,7.5) AF14(-19.5,7.5) AF15(-18.5,7.5) AF16(-17.5,7.5) AF17(-16.5,7.5) AF18(-15.5,7.5) AF19(-14.5,7.5) AF20(-13.5,7.5) AF21(-12.5,7.5) AF22(-11.5,7.5) AF23(-10.5,7.5) AF24(-9.5,7.5) AF25(-8.5,7.5) AF26(-7.5,7.5) AF27(-6.5,7.5) AF28(-5.5,7.5) AF29(-4.5,7.5) AF30(-3.5,7.5) AF31(-2.5,7.5) AF32(-1.5,7.5) AF33(-0.5,7.5) AF34(0.5,7.5) AF35(1.5,7.5) AF36(2.5,7.5) AF37(3.5,7.5) AF38(4.5,7.5) AF39(5.5,7.5) AF40(6.5,7.5) AF41(7.5,7.5) AF42(8.5,7.5) AF43(9.5,7.5) AF44(10.5,7.5) AF45(11.5,7.5) AF46(12.5,7.5) AF47(13.5,7.5) AF48(14.5,7.5) AF49(15.5,7.5) AF50(16.5,7.5) AF51(17.5,7.5) AF52(18.5,7.5) AF53(19.5,7.5) AF54(20.5,7.5) AF55(21.5,7.5) AF56(22.5,7.5) AF57(23.5,7.5) AF58(24.5,7.5) AF59(25.5,7.5) AF60(26.5,7.5) AF61(27.5,7.5) AF62(28.5,7.5) AF63(29.5,7.5) AF64(30.5,7.5) AF65(31.5,7.5) AF66(32.5,7.5) AG1(-32.5,6.5) AG2(-31.5,6.5) AG3(-30.5,6.5) AG4(-29.5,6.5) AG5(-28.5,6.5) AG6(-27.5,6.5) AG7(-26.5,6.5) AG8(-25.5,6.5) AG9(-24.5,6.5) AG10(-23.5,6.5) AG11(-22.5,6.5) AG12(-21.5,6.5) AG13(-20.5,6.5) AG14(-19.5,6.5) AG15(-18.5,6.5) AG16(-17.5,6.5) AG17(-16.5,6.5) AG18(-15.5,6.5) AG19(-14.5,6.5) AG20(-13.5,6.5) AG21(-12.5,6.5) AG22(-11.5,6.5) AG23(-10.5,6.5) AG24(-9.5,6.5) AG25(-8.5,6.5) AG26(-7.5,6.5) AG27(-6.5,6.5) AG28(-5.5,6.5) AG29(-4.5,6.5) AG30(-3.5,6.5) AG31(-2.5,6.5) AG32(-1.5,6.5) AG33(-0.5,6.5) AG34(0.5,6.5) AG35(1.5,6.5) AG36(2.5,6.5) AG37(3.5,6.5) AG38(4.5,6.5) AG39(5.5,6.5) AG40(6.5,6.5) AG41(7.5,6.5) AG42(8.5,6.5) AG43(9.5,6.5) AG44(10.5,6.5) AG45(11.5,6.5) AG46(12.5,6.5) AG47(13.5,6.5) AG48(14.5,6.5) AG49(15.5,6.5) AG50(16.5,6.5) AG51(17.5,6.5) AG52(18.5,6.5) AG53(19.5,6.5) AG54(20.5,6.5) AG55(21.5,6.5) AG56(22.5,6.5) AG57(23.5,6.5) AG58(24.5,6.5) AG59(25.5,6.5) AG60(26.5,6.5) AG61(27.5,6.5) AG62(28.5,6.5) AG63(29.5,6.5) AG64(30.5,6.5) AG65(31.5,6.5) AG66(32.5,6.5) AH1(-32.5,5.5) AH2(-31.5,5.5) AH3(-30.5,5.5) AH4(-29.5,5.5) AH5(-28.5,5.5) AH6(-27.5,5.5) AH7(-26.5,5.5) AH8(-25.5,5.5) AH9(-24.5,5.5) AH10(-23.5,5.5) AH11(-22.5,5.5) AH12(-21.5,5.5) AH13(-20.5,5.5) AH14(-19.5,5.5) AH15(-18.5,5.5) AH16(-17.5,5.5) AH17(-16.5,5.5) AH18(-15.5,5.5) AH19(-14.5,5.5) AH20(-13.5,5.5) AH21(-12.5,5.5) AH22(-11.5,5.5) AH23(-10.5,5.5) AH24(-9.5,5.5) AH25(-8.5,5.5) AH26(-7.5,5.5) AH27(-6.5,5.5) AH28(-5.5,5.5) AH29(-4.5,5.5) AH30(-3.5,5.5) AH31(-2.5,5.5) AH32(-1.5,5.5) AH33(-0.5,5.5) AH34(0.5,5.5) AH35(1.5,5.5) AH36(2.5,5.5) AH37(3.5,5.5) AH38(4.5,5.5) AH39(5.5,5.5) AH40(6.5,5.5) AH41(7.5,5.5) AH42(8.5,5.5) AH43(9.5,5.5) AH44(10.5,5.5) AH45(11.5,5.5) AH46(12.5,5.5) AH47(13.5,5.5) AH48(14.5,5.5) AH49(15.5,5.5) AH50(16.5,5.5) AH51(17.5,5.5) AH52(18.5,5.5) AH53(19.5,5.5) AH54(20.5,5.5) AH55(21.5,5.5) AH56(22.5,5.5) AH57(23.5,5.5) AH58(24.5,5.5) AH59(25.5,5.5) AH60(26.5,5.5) AH61(27.5,5.5) AH62(28.5,5.5) AH63(29.5,5.5) AH64(30.5,5.5) AH65(31.5,5.5) AH66(32.5,5.5) AJ1(-32.5,4.5) AJ2(-31.5,4.5) AJ3(-30.5,4.5) AJ4(-29.5,4.5) AJ5(-28.5,4.5) AJ6(-27.5,4.5) AJ7(-26.5,4.5) AJ8(-25.5,4.5) AJ9(-24.5,4.5) AJ10(-23.5,4.5) AJ11(-22.5,4.5) AJ12(-21.5,4.5) AJ13(-20.5,4.5) AJ14(-19.5,4.5) AJ15(-18.5,4.5) AJ16(-17.5,4.5) AJ17(-16.5,4.5) AJ18(-15.5,4.5) AJ19(-14.5,4.5) AJ20(-13.5,4.5) AJ21(-12.5,4.5) AJ22(-11.5,4.5) AJ23(-10.5,4.5) AJ24(-9.5,4.5) AJ25(-8.5,4.5) AJ26(-7.5,4.5) AJ27(-6.5,4.5) AJ28(-5.5,4.5) AJ29(-4.5,4.5) AJ30(-3.5,4.5) AJ31(-2.5,4.5) AJ32(-1.5,4.5) AJ33(-0.5,4.5) AJ34(0.5,4.5) AJ35(1.5,4.5) AJ36(2.5,4.5) AJ37(3.5,4.5) AJ38(4.5,4.5) AJ39(5.5,4.5) AJ40(6.5,4.5) AJ41(7.5,4.5) AJ42(8.5,4.5) AJ43(9.5,4.5) AJ44(10.5,4.5) AJ45(11.5,4.5) AJ46(12.5,4.5) AJ47(13.5,4.5) AJ48(14.5,4.5) AJ49(15.5,4.5) AJ50(16.5,4.5) AJ51(17.5,4.5) AJ52(18.5,4.5) AJ53(19.5,4.5) AJ54(20.5,4.5) AJ55(21.5,4.5) AJ56(22.5,4.5) AJ57(23.5,4.5) AJ58(24.5,4.5) AJ59(25.5,4.5) AJ60(26.5,4.5) AJ61(27.5,4.5) AJ62(28.5,4.5) AJ63(29.5,4.5) AJ64(30.5,4.5) AJ65(31.5,4.5) AJ66(32.5,4.5) AK1(-32.5,3.5) AK2(-31.5,3.5) AK3(-30.5,3.5) AK4(-29.5,3.5) AK5(-28.5,3.5) AK6(-27.5,3.5) AK7(-26.5,3.5) AK8(-25.5,3.5) AK9(-24.5,3.5) AK10(-23.5,3.5) AK11(-22.5,3.5) AK12(-21.5,3.5) AK13(-20.5,3.5) AK14(-19.5,3.5) AK15(-18.5,3.5) AK16(-17.5,3.5) AK17(-16.5,3.5) AK18(-15.5,3.5) AK19(-14.5,3.5) AK20(-13.5,3.5) AK21(-12.5,3.5) AK22(-11.5,3.5) AK23(-10.5,3.5) AK24(-9.5,3.5) AK25(-8.5,3.5) AK26(-7.5,3.5) AK27(-6.5,3.5) AK28(-5.5,3.5) AK29(-4.5,3.5) AK30(-3.5,3.5) AK31(-2.5,3.5) AK32(-1.5,3.5) AK33(-0.5,3.5) AK34(0.5,3.5) AK35(1.5,3.5) AK36(2.5,3.5) AK37(3.5,3.5) AK38(4.5,3.5) AK39(5.5,3.5) AK40(6.5,3.5) AK41(7.5,3.5) AK42(8.5,3.5) AK43(9.5,3.5) AK44(10.5,3.5) AK45(11.5,3.5) AK46(12.5,3.5) AK47(13.5,3.5) AK48(14.5,3.5) AK49(15.5,3.5) AK50(16.5,3.5) AK51(17.5,3.5) AK52(18.5,3.5) AK53(19.5,3.5) AK54(20.5,3.5) AK55(21.5,3.5) AK56(22.5,3.5) AK57(23.5,3.5) AK58(24.5,3.5) AK59(25.5,3.5) AK60(26.5,3.5) AK61(27.5,3.5) AK62(28.5,3.5) AK63(29.5,3.5) AK64(30.5,3.5) AK65(31.5,3.5) AK66(32.5,3.5) AL1(-32.5,2.5) AL2(-31.5,2.5) AL3(-30.5,2.5) AL4(-29.5,2.5) AL5(-28.5,2.5) AL6(-27.5,2.5) AL7(-26.5,2.5) AL8(-25.5,2.5) AL9(-24.5,2.5) AL10(-23.5,2.5) AL11(-22.5,2.5) AL12(-21.5,2.5) AL13(-20.5,2.5) AL14(-19.5,2.5) AL15(-18.5,2.5) AL16(-17.5,2.5) AL17(-16.5,2.5) AL18(-15.5,2.5) AL19(-14.5,2.5) AL20(-13.5,2.5) AL21(-12.5,2.5) AL22(-11.5,2.5) AL23(-10.5,2.5) AL24(-9.5,2.5) AL25(-8.5,2.5) AL26(-7.5,2.5) AL27(-6.5,2.5) AL28(-5.5,2.5) AL29(-4.5,2.5) AL30(-3.5,2.5) AL31(-2.5,2.5) AL32(-1.5,2.5) AL33(-0.5,2.5) AL34(0.5,2.5) AL35(1.5,2.5) AL36(2.5,2.5) AL37(3.5,2.5) AL38(4.5,2.5) AL39(5.5,2.5) AL40(6.5,2.5) AL41(7.5,2.5) AL42(8.5,2.5) AL43(9.5,2.5) AL44(10.5,2.5) AL45(11.5,2.5) AL46(12.5,2.5) AL47(13.5,2.5) AL48(14.5,2.5) AL49(15.5,2.5) AL50(16.5,2.5) AL51(17.5,2.5) AL52(18.5,2.5) AL53(19.5,2.5) AL54(20.5,2.5) AL55(21.5,2.5) AL56(22.5,2.5) AL57(23.5,2.5) AL58(24.5,2.5) AL59(25.5,2.5) AL60(26.5,2.5) AL61(27.5,2.5) AL62(28.5,2.5) AL63(29.5,2.5) AL64(30.5,2.5) AL65(31.5,2.5) AL66(32.5,2.5) AM1(-32.5,1.5) AM2(-31.5,1.5) AM3(-30.5,1.5) AM4(-29.5,1.5) AM5(-28.5,1.5) AM6(-27.5,1.5) AM7(-26.5,1.5) AM8(-25.5,1.5) AM9(-24.5,1.5) AM10(-23.5,1.5) AM11(-22.5,1.5) AM12(-21.5,1.5) AM13(-20.5,1.5) AM14(-19.5,1.5) AM15(-18.5,1.5) AM16(-17.5,1.5) AM17(-16.5,1.5) AM18(-15.5,1.5) AM19(-14.5,1.5) AM20(-13.5,1.5) AM21(-12.5,1.5) AM22(-11.5,1.5) AM23(-10.5,1.5) AM24(-9.5,1.5) AM25(-8.5,1.5) AM26(-7.5,1.5) AM27(-6.5,1.5) AM28(-5.5,1.5) AM29(-4.5,1.5) AM30(-3.5,1.5) AM31(-2.5,1.5) AM32(-1.5,1.5) AM33(-0.5,1.5) AM34(0.5,1.5) AM35(1.5,1.5) AM36(2.5,1.5) AM37(3.5,1.5) AM38(4.5,1.5) AM39(5.5,1.5) AM40(6.5,1.5) AM41(7.5,1.5) AM42(8.5,1.5) AM43(9.5,1.5) AM44(10.5,1.5) AM45(11.5,1.5) AM46(12.5,1.5) AM47(13.5,1.5) AM48(14.5,1.5) AM49(15.5,1.5) AM50(16.5,1.5) AM51(17.5,1.5) AM52(18.5,1.5) AM53(19.5,1.5) AM54(20.5,1.5) AM55(21.5,1.5) AM56(22.5,1.5) AM57(23.5,1.5) AM58(24.5,1.5) AM59(25.5,1.5) AM60(26.5,1.5) AM61(27.5,1.5) AM62(28.5,1.5) AM63(29.5,1.5) AM64(30.5,1.5) AM65(31.5,1.5) AM66(32.5,1.5) AN1(-32.5,0.5) AN2(-31.5,0.5) AN3(-30.5,0.5) AN4(-29.5,0.5) AN5(-28.5,0.5) AN6(-27.5,0.5) AN7(-26.5,0.5) AN8(-25.5,0.5) AN9(-24.5,0.5) AN10(-23.5,0.5) AN11(-22.5,0.5) AN12(-21.5,0.5) AN13(-20.5,0.5) AN14(-19.5,0.5) AN15(-18.5,0.5) AN16(-17.5,0.5) AN17(-16.5,0.5) AN18(-15.5,0.5) AN19(-14.5,0.5) AN20(-13.5,0.5) AN21(-12.5,0.5) AN22(-11.5,0.5) AN23(-10.5,0.5) AN24(-9.5,0.5) AN25(-8.5,0.5) AN26(-7.5,0.5) AN27(-6.5,0.5) AN28(-5.5,0.5) AN29(-4.5,0.5) AN30(-3.5,0.5) AN31(-2.5,0.5) AN32(-1.5,0.5) AN33(-0.5,0.5) AN34(0.5,0.5) AN35(1.5,0.5) AN36(2.5,0.5) AN37(3.5,0.5) AN38(4.5,0.5) AN39(5.5,0.5) AN40(6.5,0.5) AN41(7.5,0.5) AN42(8.5,0.5) AN43(9.5,0.5) AN44(10.5,0.5) AN45(11.5,0.5) AN46(12.5,0.5) AN47(13.5,0.5) AN48(14.5,0.5) AN49(15.5,0.5) AN50(16.5,0.5) AN51(17.5,0.5) AN52(18.5,0.5) AN53(19.5,0.5) AN54(20.5,0.5) AN55(21.5,0.5) AN56(22.5,0.5) AN57(23.5,0.5) AN58(24.5,0.5) AN59(25.5,0.5) AN60(26.5,0.5) AN61(27.5,0.5) AN62(28.5,0.5) AN63(29.5,0.5) AN64(30.5,0.5) AN65(31.5,0.5) AN66(32.5,0.5) AP1(-32.5,-0.5) AP2(-31.5,-0.5) AP3(-30.5,-0.5) AP4(-29.5,-0.5) AP5(-28.5,-0.5) AP6(-27.5,-0.5) AP7(-26.5,-0.5) AP8(-25.5,-0.5) AP9(-24.5,-0.5) AP10(-23.5,-0.5) AP11(-22.5,-0.5) AP12(-21.5,-0.5) AP13(-20.5,-0.5) AP14(-19.5,-0.5) AP15(-18.5,-0.5) AP16(-17.5,-0.5) AP17(-16.5,-0.5) AP18(-15.5,-0.5) AP19(-14.5,-0.5) AP20(-13.5,-0.5) AP21(-12.5,-0.5) AP22(-11.5,-0.5) AP23(-10.5,-0.5) AP24(-9.5,-0.5) AP25(-8.5,-0.5) AP26(-7.5,-0.5) AP27(-6.5,-0.5) AP28(-5.5,-0.5) AP29(-4.5,-0.5) AP30(-3.5,-0.5) AP31(-2.5,-0.5) AP32(-1.5,-0.5) AP33(-0.5,-0.5) AP34(0.5,-0.5) AP35(1.5,-0.5) AP36(2.5,-0.5) AP37(3.5,-0.5) AP38(4.5,-0.5) AP39(5.5,-0.5) AP40(6.5,-0.5) AP41(7.5,-0.5) AP42(8.5,-0.5) AP43(9.5,-0.5) AP44(10.5,-0.5) AP45(11.5,-0.5) AP46(12.5,-0.5) AP47(13.5,-0.5) AP48(14.5,-0.5) AP49(15.5,-0.5) AP50(16.5,-0.5) AP51(17.5,-0.5) AP52(18.5,-0.5) AP53(19.5,-0.5) AP54(20.5,-0.5) AP55(21.5,-0.5) AP56(22.5,-0.5) AP57(23.5,-0.5) AP58(24.5,-0.5) AP59(25.5,-0.5) AP60(26.5,-0.5) AP61(27.5,-0.5) AP62(28.5,-0.5) AP63(29.5,-0.5) AP64(30.5,-0.5) AP65(31.5,-0.5) AP66(32.5,-0.5) AR1(-32.5,-1.5) AR2(-31.5,-1.5) AR3(-30.5,-1.5) AR4(-29.5,-1.5) AR5(-28.5,-1.5) AR6(-27.5,-1.5) AR7(-26.5,-1.5) AR8(-25.5,-1.5) AR9(-24.5,-1.5) AR10(-23.5,-1.5) AR11(-22.5,-1.5) AR12(-21.5,-1.5) AR13(-20.5,-1.5) AR14(-19.5,-1.5) AR15(-18.5,-1.5) AR16(-17.5,-1.5) AR17(-16.5,-1.5) AR18(-15.5,-1.5) AR19(-14.5,-1.5) AR20(-13.5,-1.5) AR21(-12.5,-1.5) AR22(-11.5,-1.5) AR23(-10.5,-1.5) AR24(-9.5,-1.5) AR25(-8.5,-1.5) AR26(-7.5,-1.5) AR27(-6.5,-1.5) AR28(-5.5,-1.5) AR29(-4.5,-1.5) AR30(-3.5,-1.5) AR31(-2.5,-1.5) AR32(-1.5,-1.5) AR33(-0.5,-1.5) AR34(0.5,-1.5) AR35(1.5,-1.5) AR36(2.5,-1.5) AR37(3.5,-1.5) AR38(4.5,-1.5) AR39(5.5,-1.5) AR40(6.5,-1.5) AR41(7.5,-1.5) AR42(8.5,-1.5) AR43(9.5,-1.5) AR44(10.5,-1.5) AR45(11.5,-1.5) AR46(12.5,-1.5) AR47(13.5,-1.5) AR48(14.5,-1.5) AR49(15.5,-1.5) AR50(16.5,-1.5) AR51(17.5,-1.5) AR52(18.5,-1.5) AR53(19.5,-1.5) AR54(20.5,-1.5) AR55(21.5,-1.5) AR56(22.5,-1.5) AR57(23.5,-1.5) AR58(24.5,-1.5) AR59(25.5,-1.5) AR60(26.5,-1.5) AR61(27.5,-1.5) AR62(28.5,-1.5) AR63(29.5,-1.5) AR64(30.5,-1.5) AR65(31.5,-1.5) AR66(32.5,-1.5) AT1(-32.5,-2.5) AT2(-31.5,-2.5) AT3(-30.5,-2.5) AT4(-29.5,-2.5) AT5(-28.5,-2.5) AT6(-27.5,-2.5) AT7(-26.5,-2.5) AT8(-25.5,-2.5) AT9(-24.5,-2.5) AT10(-23.5,-2.5) AT11(-22.5,-2.5) AT12(-21.5,-2.5) AT13(-20.5,-2.5) AT14(-19.5,-2.5) AT15(-18.5,-2.5) AT16(-17.5,-2.5) AT17(-16.5,-2.5) AT18(-15.5,-2.5) AT19(-14.5,-2.5) AT20(-13.5,-2.5) AT21(-12.5,-2.5) AT22(-11.5,-2.5) AT23(-10.5,-2.5) AT24(-9.5,-2.5) AT25(-8.5,-2.5) AT26(-7.5,-2.5) AT27(-6.5,-2.5) AT28(-5.5,-2.5) AT29(-4.5,-2.5) AT30(-3.5,-2.5) AT31(-2.5,-2.5) AT32(-1.5,-2.5) AT33(-0.5,-2.5) AT34(0.5,-2.5) AT35(1.5,-2.5) AT36(2.5,-2.5) AT37(3.5,-2.5) AT38(4.5,-2.5) AT39(5.5,-2.5) AT40(6.5,-2.5) AT41(7.5,-2.5) AT42(8.5,-2.5) AT43(9.5,-2.5) AT44(10.5,-2.5) AT45(11.5,-2.5) AT46(12.5,-2.5) AT47(13.5,-2.5) AT48(14.5,-2.5) AT49(15.5,-2.5) AT50(16.5,-2.5) AT51(17.5,-2.5) AT52(18.5,-2.5) AT53(19.5,-2.5) AT54(20.5,-2.5) AT55(21.5,-2.5) AT56(22.5,-2.5) AT57(23.5,-2.5) AT58(24.5,-2.5) AT59(25.5,-2.5) AT60(26.5,-2.5) AT61(27.5,-2.5) AT62(28.5,-2.5) AT63(29.5,-2.5) AT64(30.5,-2.5) AT65(31.5,-2.5) AT66(32.5,-2.5) AU1(-32.5,-3.5) AU2(-31.5,-3.5) AU3(-30.5,-3.5) AU4(-29.5,-3.5) AU5(-28.5,-3.5) AU6(-27.5,-3.5) AU7(-26.5,-3.5) AU8(-25.5,-3.5) AU9(-24.5,-3.5) AU10(-23.5,-3.5) AU11(-22.5,-3.5) AU12(-21.5,-3.5) AU13(-20.5,-3.5) AU14(-19.5,-3.5) AU15(-18.5,-3.5) AU16(-17.5,-3.5) AU17(-16.5,-3.5) AU18(-15.5,-3.5) AU19(-14.5,-3.5) AU20(-13.5,-3.5) AU21(-12.5,-3.5) AU22(-11.5,-3.5) AU23(-10.5,-3.5) AU24(-9.5,-3.5) AU25(-8.5,-3.5) AU26(-7.5,-3.5) AU27(-6.5,-3.5) AU28(-5.5,-3.5) AU29(-4.5,-3.5) AU30(-3.5,-3.5) AU31(-2.5,-3.5) AU32(-1.5,-3.5) AU33(-0.5,-3.5) AU34(0.5,-3.5) AU35(1.5,-3.5) AU36(2.5,-3.5) AU37(3.5,-3.5) AU38(4.5,-3.5) AU39(5.5,-3.5) AU40(6.5,-3.5) AU41(7.5,-3.5) AU42(8.5,-3.5) AU43(9.5,-3.5) AU44(10.5,-3.5) AU45(11.5,-3.5) AU46(12.5,-3.5) AU47(13.5,-3.5) AU48(14.5,-3.5) AU49(15.5,-3.5) AU50(16.5,-3.5) AU51(17.5,-3.5) AU52(18.5,-3.5) AU53(19.5,-3.5) AU54(20.5,-3.5) AU55(21.5,-3.5) AU56(22.5,-3.5) AU57(23.5,-3.5) AU58(24.5,-3.5) AU59(25.5,-3.5) AU60(26.5,-3.5) AU61(27.5,-3.5) AU62(28.5,-3.5) AU63(29.5,-3.5) AU64(30.5,-3.5) AU65(31.5,-3.5) AU66(32.5,-3.5) AV1(-32.5,-4.5) AV2(-31.5,-4.5) AV3(-30.5,-4.5) AV4(-29.5,-4.5) AV5(-28.5,-4.5) AV6(-27.5,-4.5) AV7(-26.5,-4.5) AV8(-25.5,-4.5) AV9(-24.5,-4.5) AV10(-23.5,-4.5) AV11(-22.5,-4.5) AV12(-21.5,-4.5) AV13(-20.5,-4.5) AV14(-19.5,-4.5) AV15(-18.5,-4.5) AV16(-17.5,-4.5) AV17(-16.5,-4.5) AV18(-15.5,-4.5) AV19(-14.5,-4.5) AV20(-13.5,-4.5) AV21(-12.5,-4.5) AV22(-11.5,-4.5) AV23(-10.5,-4.5) AV24(-9.5,-4.5) AV25(-8.5,-4.5) AV26(-7.5,-4.5) AV27(-6.5,-4.5) AV28(-5.5,-4.5) AV29(-4.5,-4.5) AV30(-3.5,-4.5) AV31(-2.5,-4.5) AV32(-1.5,-4.5) AV33(-0.5,-4.5) AV34(0.5,-4.5) AV35(1.5,-4.5) AV36(2.5,-4.5) AV37(3.5,-4.5) AV38(4.5,-4.5) AV39(5.5,-4.5) AV40(6.5,-4.5) AV41(7.5,-4.5) AV42(8.5,-4.5) AV43(9.5,-4.5) AV44(10.5,-4.5) AV45(11.5,-4.5) AV46(12.5,-4.5) AV47(13.5,-4.5) AV48(14.5,-4.5) AV49(15.5,-4.5) AV50(16.5,-4.5) AV51(17.5,-4.5) AV52(18.5,-4.5) AV53(19.5,-4.5) AV54(20.5,-4.5) AV55(21.5,-4.5) AV56(22.5,-4.5) AV57(23.5,-4.5) AV58(24.5,-4.5) AV59(25.5,-4.5) AV60(26.5,-4.5) AV61(27.5,-4.5) AV62(28.5,-4.5) AV63(29.5,-4.5) AV64(30.5,-4.5) AV65(31.5,-4.5) AV66(32.5,-4.5) AW1(-32.5,-5.5) AW2(-31.5,-5.5) AW3(-30.5,-5.5) AW4(-29.5,-5.5) AW5(-28.5,-5.5) AW6(-27.5,-5.5) AW7(-26.5,-5.5) AW8(-25.5,-5.5) AW9(-24.5,-5.5) AW10(-23.5,-5.5) AW11(-22.5,-5.5) AW12(-21.5,-5.5) AW13(-20.5,-5.5) AW14(-19.5,-5.5) AW15(-18.5,-5.5) AW16(-17.5,-5.5) AW17(-16.5,-5.5) AW18(-15.5,-5.5) AW19(-14.5,-5.5) AW20(-13.5,-5.5) AW21(-12.5,-5.5) AW22(-11.5,-5.5) AW23(-10.5,-5.5) AW24(-9.5,-5.5) AW25(-8.5,-5.5) AW26(-7.5,-5.5) AW27(-6.5,-5.5) AW28(-5.5,-5.5) AW29(-4.5,-5.5) AW30(-3.5,-5.5) AW31(-2.5,-5.5) AW32(-1.5,-5.5) AW33(-0.5,-5.5) AW34(0.5,-5.5) AW35(1.5,-5.5) AW36(2.5,-5.5) AW37(3.5,-5.5) AW38(4.5,-5.5) AW39(5.5,-5.5) AW40(6.5,-5.5) AW41(7.5,-5.5) AW42(8.5,-5.5) AW43(9.5,-5.5) AW44(10.5,-5.5) AW45(11.5,-5.5) AW46(12.5,-5.5) AW47(13.5,-5.5) AW48(14.5,-5.5) AW49(15.5,-5.5) AW50(16.5,-5.5) AW51(17.5,-5.5) AW52(18.5,-5.5) AW53(19.5,-5.5) AW54(20.5,-5.5) AW55(21.5,-5.5) AW56(22.5,-5.5) AW57(23.5,-5.5) AW58(24.5,-5.5) AW59(25.5,-5.5) AW60(26.5,-5.5) AW61(27.5,-5.5) AW62(28.5,-5.5) AW63(29.5,-5.5) AW64(30.5,-5.5) AW65(31.5,-5.5) AW66(32.5,-5.5) AY1(-32.5,-6.5) AY2(-31.5,-6.5) AY3(-30.5,-6.5) AY4(-29.5,-6.5) AY5(-28.5,-6.5) AY6(-27.5,-6.5) AY7(-26.5,-6.5) AY8(-25.5,-6.5) AY9(-24.5,-6.5) AY10(-23.5,-6.5) AY11(-22.5,-6.5) AY12(-21.5,-6.5) AY13(-20.5,-6.5) AY14(-19.5,-6.5) AY15(-18.5,-6.5) AY16(-17.5,-6.5) AY17(-16.5,-6.5) AY18(-15.5,-6.5) AY19(-14.5,-6.5) AY20(-13.5,-6.5) AY21(-12.5,-6.5) AY22(-11.5,-6.5) AY23(-10.5,-6.5) AY24(-9.5,-6.5) AY25(-8.5,-6.5) AY26(-7.5,-6.5) AY27(-6.5,-6.5) AY28(-5.5,-6.5) AY29(-4.5,-6.5) AY30(-3.5,-6.5) AY31(-2.5,-6.5) AY32(-1.5,-6.5) AY33(-0.5,-6.5) AY34(0.5,-6.5) AY35(1.5,-6.5) AY36(2.5,-6.5) AY37(3.5,-6.5) AY38(4.5,-6.5) AY39(5.5,-6.5) AY40(6.5,-6.5) AY41(7.5,-6.5) AY42(8.5,-6.5) AY43(9.5,-6.5) AY44(10.5,-6.5) AY45(11.5,-6.5) AY46(12.5,-6.5) AY47(13.5,-6.5) AY48(14.5,-6.5) AY49(15.5,-6.5) AY50(16.5,-6.5) AY51(17.5,-6.5) AY52(18.5,-6.5) AY53(19.5,-6.5) AY54(20.5,-6.5) AY55(21.5,-6.5) AY56(22.5,-6.5) AY57(23.5,-6.5) AY58(24.5,-6.5) AY59(25.5,-6.5) AY60(26.5,-6.5) AY61(27.5,-6.5) AY62(28.5,-6.5) AY63(29.5,-6.5) AY64(30.5,-6.5) AY65(31.5,-6.5) AY66(32.5,-6.5) B2(-31.5,31.5) B3(-30.5,31.5) B4(-29.5,31.5) B5(-28.5,31.5) B6(-27.5,31.5) B7(-26.5,31.5) B8(-25.5,31.5) B9(-24.5,31.5) B10(-23.5,31.5) B11(-22.5,31.5) B12(-21.5,31.5) B13(-20.5,31.5) B14(-19.5,31.5) B15(-18.5,31.5) B16(-17.5,31.5) B17(-16.5,31.5) B18(-15.5,31.5) B19(-14.5,31.5) B20(-13.5,31.5) B21(-12.5,31.5) B22(-11.5,31.5) B23(-10.5,31.5) B24(-9.5,31.5) B25(-8.5,31.5) B26(-7.5,31.5) B27(-6.5,31.5) B28(-5.5,31.5) B29(-4.5,31.5) B30(-3.5,31.5) B31(-2.5,31.5) B32(-1.5,31.5) B33(-0.5,31.5) B34(0.5,31.5) B35(1.5,31.5) B36(2.5,31.5) B37(3.5,31.5) B38(4.5,31.5) B39(5.5,31.5) B40(6.5,31.5) B41(7.5,31.5) B42(8.5,31.5) B43(9.5,31.5) B44(10.5,31.5) B45(11.5,31.5) B46(12.5,31.5) B47(13.5,31.5) B48(14.5,31.5) B49(15.5,31.5) B50(16.5,31.5) B51(17.5,31.5) B52(18.5,31.5) B53(19.5,31.5) B54(20.5,31.5) B55(21.5,31.5) B56(22.5,31.5) B57(23.5,31.5) B58(24.5,31.5) B59(25.5,31.5) B60(26.5,31.5) B61(27.5,31.5) B62(28.5,31.5) B63(29.5,31.5) B64(30.5,31.5) B65(31.5,31.5) BA1(-32.5,-7.5) BA2(-31.5,-7.5) BA3(-30.5,-7.5) BA4(-29.5,-7.5) BA5(-28.5,-7.5) BA6(-27.5,-7.5) BA7(-26.5,-7.5) BA8(-25.5,-7.5) BA9(-24.5,-7.5) BA10(-23.5,-7.5) BA11(-22.5,-7.5) BA12(-21.5,-7.5) BA13(-20.5,-7.5) BA14(-19.5,-7.5) BA15(-18.5,-7.5) BA16(-17.5,-7.5) BA17(-16.5,-7.5) BA18(-15.5,-7.5) BA19(-14.5,-7.5) BA20(-13.5,-7.5) BA21(-12.5,-7.5) BA22(-11.5,-7.5) BA23(-10.5,-7.5) BA24(-9.5,-7.5) BA25(-8.5,-7.5) BA26(-7.5,-7.5) BA27(-6.5,-7.5) BA28(-5.5,-7.5) BA29(-4.5,-7.5) BA30(-3.5,-7.5) BA31(-2.5,-7.5) BA32(-1.5,-7.5) BA33(-0.5,-7.5) BA34(0.5,-7.5) BA35(1.5,-7.5) BA36(2.5,-7.5) BA37(3.5,-7.5) BA38(4.5,-7.5) BA39(5.5,-7.5) BA40(6.5,-7.5) BA41(7.5,-7.5) BA42(8.5,-7.5) BA43(9.5,-7.5) BA44(10.5,-7.5) BA45(11.5,-7.5) BA46(12.5,-7.5) BA47(13.5,-7.5) BA48(14.5,-7.5) BA49(15.5,-7.5) BA50(16.5,-7.5) BA51(17.5,-7.5) BA52(18.5,-7.5) BA53(19.5,-7.5) BA54(20.5,-7.5) BA55(21.5,-7.5) BA56(22.5,-7.5) BA57(23.5,-7.5) BA58(24.5,-7.5) BA59(25.5,-7.5) BA60(26.5,-7.5) BA61(27.5,-7.5) BA62(28.5,-7.5) BA63(29.5,-7.5) BA64(30.5,-7.5) BA65(31.5,-7.5) BA66(32.5,-7.5) BB1(-32.5,-8.5) BB2(-31.5,-8.5) BB3(-30.5,-8.5) BB4(-29.5,-8.5) BB5(-28.5,-8.5) BB6(-27.5,-8.5) BB7(-26.5,-8.5) BB8(-25.5,-8.5) BB9(-24.5,-8.5) BB10(-23.5,-8.5) BB11(-22.5,-8.5) BB12(-21.5,-8.5) BB13(-20.5,-8.5) BB14(-19.5,-8.5) BB15(-18.5,-8.5) BB16(-17.5,-8.5) BB17(-16.5,-8.5) BB18(-15.5,-8.5) BB19(-14.5,-8.5) BB20(-13.5,-8.5) BB21(-12.5,-8.5) BB22(-11.5,-8.5) BB23(-10.5,-8.5) BB24(-9.5,-8.5) BB25(-8.5,-8.5) BB26(-7.5,-8.5) BB27(-6.5,-8.5) BB28(-5.5,-8.5) BB29(-4.5,-8.5) BB30(-3.5,-8.5) BB31(-2.5,-8.5) BB32(-1.5,-8.5) BB33(-0.5,-8.5) BB34(0.5,-8.5) BB35(1.5,-8.5) BB36(2.5,-8.5) BB37(3.5,-8.5) BB38(4.5,-8.5) BB39(5.5,-8.5) BB40(6.5,-8.5) BB41(7.5,-8.5) BB42(8.5,-8.5) BB43(9.5,-8.5) BB44(10.5,-8.5) BB45(11.5,-8.5) BB46(12.5,-8.5) BB47(13.5,-8.5) BB48(14.5,-8.5) BB49(15.5,-8.5) BB50(16.5,-8.5) BB51(17.5,-8.5) BB52(18.5,-8.5) BB53(19.5,-8.5) BB54(20.5,-8.5) BB55(21.5,-8.5) BB56(22.5,-8.5) BB57(23.5,-8.5) BB58(24.5,-8.5) BB59(25.5,-8.5) BB60(26.5,-8.5) BB61(27.5,-8.5) BB62(28.5,-8.5) BB63(29.5,-8.5) BB64(30.5,-8.5) BB65(31.5,-8.5) BB66(32.5,-8.5) BC1(-32.5,-9.5) BC2(-31.5,-9.5) BC3(-30.5,-9.5) BC4(-29.5,-9.5) BC5(-28.5,-9.5) BC6(-27.5,-9.5) BC7(-26.5,-9.5) BC8(-25.5,-9.5) BC9(-24.5,-9.5) BC10(-23.5,-9.5) BC11(-22.5,-9.5) BC12(-21.5,-9.5) BC13(-20.5,-9.5) BC14(-19.5,-9.5) BC15(-18.5,-9.5) BC16(-17.5,-9.5) BC17(-16.5,-9.5) BC18(-15.5,-9.5) BC19(-14.5,-9.5) BC20(-13.5,-9.5) BC21(-12.5,-9.5) BC22(-11.5,-9.5) BC23(-10.5,-9.5) BC24(-9.5,-9.5) BC25(-8.5,-9.5) BC26(-7.5,-9.5) BC27(-6.5,-9.5) BC28(-5.5,-9.5) BC29(-4.5,-9.5) BC30(-3.5,-9.5) BC31(-2.5,-9.5) BC32(-1.5,-9.5) BC33(-0.5,-9.5) BC34(0.5,-9.5) BC35(1.5,-9.5) BC36(2.5,-9.5) BC37(3.5,-9.5) BC38(4.5,-9.5) BC39(5.5,-9.5) BC40(6.5,-9.5) BC41(7.5,-9.5) BC42(8.5,-9.5) BC43(9.5,-9.5) BC44(10.5,-9.5) BC45(11.5,-9.5) BC46(12.5,-9.5) BC47(13.5,-9.5) BC48(14.5,-9.5) BC49(15.5,-9.5) BC50(16.5,-9.5) BC51(17.5,-9.5) BC52(18.5,-9.5) BC53(19.5,-9.5) BC54(20.5,-9.5) BC55(21.5,-9.5) BC56(22.5,-9.5) BC57(23.5,-9.5) BC58(24.5,-9.5) BC59(25.5,-9.5) BC60(26.5,-9.5) BC61(27.5,-9.5) BC62(28.5,-9.5) BC63(29.5,-9.5) BC64(30.5,-9.5) BC65(31.5,-9.5) BC66(32.5,-9.5) BD1(-32.5,-10.5) BD2(-31.5,-10.5) BD3(-30.5,-10.5) BD4(-29.5,-10.5) BD5(-28.5,-10.5) BD6(-27.5,-10.5) BD7(-26.5,-10.5) BD8(-25.5,-10.5) BD9(-24.5,-10.5) BD10(-23.5,-10.5) BD11(-22.5,-10.5) BD12(-21.5,-10.5) BD13(-20.5,-10.5) BD14(-19.5,-10.5) BD15(-18.5,-10.5) BD16(-17.5,-10.5) BD17(-16.5,-10.5) BD18(-15.5,-10.5) BD19(-14.5,-10.5) BD20(-13.5,-10.5) BD21(-12.5,-10.5) BD22(-11.5,-10.5) BD23(-10.5,-10.5) BD24(-9.5,-10.5) BD25(-8.5,-10.5) BD26(-7.5,-10.5) BD27(-6.5,-10.5) BD28(-5.5,-10.5) BD29(-4.5,-10.5) BD30(-3.5,-10.5) BD31(-2.5,-10.5) BD32(-1.5,-10.5) BD33(-0.5,-10.5) BD34(0.5,-10.5) BD35(1.5,-10.5) BD36(2.5,-10.5) BD37(3.5,-10.5) BD38(4.5,-10.5) BD39(5.5,-10.5) BD40(6.5,-10.5) BD41(7.5,-10.5) BD42(8.5,-10.5) BD43(9.5,-10.5) BD44(10.5,-10.5) BD45(11.5,-10.5) BD46(12.5,-10.5) BD47(13.5,-10.5) BD48(14.5,-10.5) BD49(15.5,-10.5) BD50(16.5,-10.5) BD51(17.5,-10.5) BD52(18.5,-10.5) BD53(19.5,-10.5) BD54(20.5,-10.5) BD55(21.5,-10.5) BD56(22.5,-10.5) BD57(23.5,-10.5) BD58(24.5,-10.5) BD59(25.5,-10.5) BD60(26.5,-10.5) BD61(27.5,-10.5) BD62(28.5,-10.5) BD63(29.5,-10.5) BD64(30.5,-10.5) BD65(31.5,-10.5) BD66(32.5,-10.5) BE1(-32.5,-11.5) BE2(-31.5,-11.5) BE3(-30.5,-11.5) BE4(-29.5,-11.5) BE5(-28.5,-11.5) BE6(-27.5,-11.5) BE7(-26.5,-11.5) BE8(-25.5,-11.5) BE9(-24.5,-11.5) BE10(-23.5,-11.5) BE11(-22.5,-11.5) BE12(-21.5,-11.5) BE13(-20.5,-11.5) BE14(-19.5,-11.5) BE15(-18.5,-11.5) BE16(-17.5,-11.5) BE17(-16.5,-11.5) BE18(-15.5,-11.5) BE19(-14.5,-11.5) BE20(-13.5,-11.5) BE21(-12.5,-11.5) BE22(-11.5,-11.5) BE23(-10.5,-11.5) BE24(-9.5,-11.5) BE25(-8.5,-11.5) BE26(-7.5,-11.5) BE27(-6.5,-11.5) BE28(-5.5,-11.5) BE29(-4.5,-11.5) BE30(-3.5,-11.5) BE31(-2.5,-11.5) BE32(-1.5,-11.5) BE33(-0.5,-11.5) BE34(0.5,-11.5) BE35(1.5,-11.5) BE36(2.5,-11.5) BE37(3.5,-11.5) BE38(4.5,-11.5) BE39(5.5,-11.5) BE40(6.5,-11.5) BE41(7.5,-11.5) BE42(8.5,-11.5) BE43(9.5,-11.5) BE44(10.5,-11.5) BE45(11.5,-11.5) BE46(12.5,-11.5) BE47(13.5,-11.5) BE48(14.5,-11.5) BE49(15.5,-11.5) BE50(16.5,-11.5) BE51(17.5,-11.5) BE52(18.5,-11.5) BE53(19.5,-11.5) BE54(20.5,-11.5) BE55(21.5,-11.5) BE56(22.5,-11.5) BE57(23.5,-11.5) BE58(24.5,-11.5) BE59(25.5,-11.5) BE60(26.5,-11.5) BE61(27.5,-11.5) BE62(28.5,-11.5) BE63(29.5,-11.5) BE64(30.5,-11.5) BE65(31.5,-11.5) BE66(32.5,-11.5) BF1(-32.5,-12.5) BF2(-31.5,-12.5) BF3(-30.5,-12.5) BF4(-29.5,-12.5) BF5(-28.5,-12.5) BF6(-27.5,-12.5) BF7(-26.5,-12.5) BF8(-25.5,-12.5) BF9(-24.5,-12.5) BF10(-23.5,-12.5) BF11(-22.5,-12.5) BF12(-21.5,-12.5) BF13(-20.5,-12.5) BF14(-19.5,-12.5) BF15(-18.5,-12.5) BF16(-17.5,-12.5) BF17(-16.5,-12.5) BF18(-15.5,-12.5) BF19(-14.5,-12.5) BF20(-13.5,-12.5) BF21(-12.5,-12.5) BF22(-11.5,-12.5) BF23(-10.5,-12.5) BF24(-9.5,-12.5) BF25(-8.5,-12.5) BF26(-7.5,-12.5) BF27(-6.5,-12.5) BF28(-5.5,-12.5) BF29(-4.5,-12.5) BF30(-3.5,-12.5) BF31(-2.5,-12.5) BF32(-1.5,-12.5) BF33(-0.5,-12.5) BF34(0.5,-12.5) BF35(1.5,-12.5) BF36(2.5,-12.5) BF37(3.5,-12.5) BF38(4.5,-12.5) BF39(5.5,-12.5) BF40(6.5,-12.5) BF41(7.5,-12.5) BF42(8.5,-12.5) BF43(9.5,-12.5) BF44(10.5,-12.5) BF45(11.5,-12.5) BF46(12.5,-12.5) BF47(13.5,-12.5) BF48(14.5,-12.5) BF49(15.5,-12.5) BF50(16.5,-12.5) BF51(17.5,-12.5) BF52(18.5,-12.5) BF53(19.5,-12.5) BF54(20.5,-12.5) BF55(21.5,-12.5) BF56(22.5,-12.5) BF57(23.5,-12.5) BF58(24.5,-12.5) BF59(25.5,-12.5) BF60(26.5,-12.5) BF61(27.5,-12.5) BF62(28.5,-12.5) BF63(29.5,-12.5) BF64(30.5,-12.5) BF65(31.5,-12.5) BF66(32.5,-12.5) BG1(-32.5,-13.5) BG2(-31.5,-13.5) BG3(-30.5,-13.5) BG4(-29.5,-13.5) BG5(-28.5,-13.5) BG6(-27.5,-13.5) BG7(-26.5,-13.5) BG8(-25.5,-13.5) BG9(-24.5,-13.5) BG10(-23.5,-13.5) BG11(-22.5,-13.5) BG12(-21.5,-13.5) BG13(-20.5,-13.5) BG14(-19.5,-13.5) BG15(-18.5,-13.5) BG16(-17.5,-13.5) BG17(-16.5,-13.5) BG18(-15.5,-13.5) BG19(-14.5,-13.5) BG20(-13.5,-13.5) BG21(-12.5,-13.5) BG22(-11.5,-13.5) BG23(-10.5,-13.5) BG24(-9.5,-13.5) BG25(-8.5,-13.5) BG26(-7.5,-13.5) BG27(-6.5,-13.5) BG28(-5.5,-13.5) BG29(-4.5,-13.5) BG30(-3.5,-13.5) BG31(-2.5,-13.5) BG32(-1.5,-13.5) BG33(-0.5,-13.5) BG34(0.5,-13.5) BG35(1.5,-13.5) BG36(2.5,-13.5) BG37(3.5,-13.5) BG38(4.5,-13.5) BG39(5.5,-13.5) BG40(6.5,-13.5) BG41(7.5,-13.5) BG42(8.5,-13.5) BG43(9.5,-13.5) BG44(10.5,-13.5) BG45(11.5,-13.5) BG46(12.5,-13.5) BG47(13.5,-13.5) BG48(14.5,-13.5) BG49(15.5,-13.5) BG50(16.5,-13.5) BG51(17.5,-13.5) BG52(18.5,-13.5) BG53(19.5,-13.5) BG54(20.5,-13.5) BG55(21.5,-13.5) BG56(22.5,-13.5) BG57(23.5,-13.5) BG58(24.5,-13.5) BG59(25.5,-13.5) BG60(26.5,-13.5) BG61(27.5,-13.5) BG62(28.5,-13.5) BG63(29.5,-13.5) BG64(30.5,-13.5) BG65(31.5,-13.5) BG66(32.5,-13.5) BH1(-32.5,-14.5) BH2(-31.5,-14.5) BH3(-30.5,-14.5) BH4(-29.5,-14.5) BH5(-28.5,-14.5) BH6(-27.5,-14.5) BH7(-26.5,-14.5) BH8(-25.5,-14.5) BH9(-24.5,-14.5) BH10(-23.5,-14.5) BH11(-22.5,-14.5) BH12(-21.5,-14.5) BH13(-20.5,-14.5) BH14(-19.5,-14.5) BH15(-18.5,-14.5) BH16(-17.5,-14.5) BH17(-16.5,-14.5) BH18(-15.5,-14.5) BH19(-14.5,-14.5) BH20(-13.5,-14.5) BH21(-12.5,-14.5) BH22(-11.5,-14.5) BH23(-10.5,-14.5) BH24(-9.5,-14.5) BH25(-8.5,-14.5) BH26(-7.5,-14.5) BH27(-6.5,-14.5) BH28(-5.5,-14.5) BH29(-4.5,-14.5) BH30(-3.5,-14.5) BH31(-2.5,-14.5) BH32(-1.5,-14.5) BH33(-0.5,-14.5) BH34(0.5,-14.5) BH35(1.5,-14.5) BH36(2.5,-14.5) BH37(3.5,-14.5) BH38(4.5,-14.5) BH39(5.5,-14.5) BH40(6.5,-14.5) BH41(7.5,-14.5) BH42(8.5,-14.5) BH43(9.5,-14.5) BH44(10.5,-14.5) BH45(11.5,-14.5) BH46(12.5,-14.5) BH47(13.5,-14.5) BH48(14.5,-14.5) BH49(15.5,-14.5) BH50(16.5,-14.5) BH51(17.5,-14.5) BH52(18.5,-14.5) BH53(19.5,-14.5) BH54(20.5,-14.5) BH55(21.5,-14.5) BH56(22.5,-14.5) BH57(23.5,-14.5) BH58(24.5,-14.5) BH59(25.5,-14.5) BH60(26.5,-14.5) BH61(27.5,-14.5) BH62(28.5,-14.5) BH63(29.5,-14.5) BH64(30.5,-14.5) BH65(31.5,-14.5) BH66(32.5,-14.5) BJ1(-32.5,-15.5) BJ2(-31.5,-15.5) BJ3(-30.5,-15.5) BJ4(-29.5,-15.5) BJ5(-28.5,-15.5) BJ6(-27.5,-15.5) BJ7(-26.5,-15.5) BJ8(-25.5,-15.5) BJ9(-24.5,-15.5) BJ10(-23.5,-15.5) BJ11(-22.5,-15.5) BJ12(-21.5,-15.5) BJ13(-20.5,-15.5) BJ14(-19.5,-15.5) BJ15(-18.5,-15.5) BJ16(-17.5,-15.5) BJ17(-16.5,-15.5) BJ18(-15.5,-15.5) BJ19(-14.5,-15.5) BJ20(-13.5,-15.5) BJ21(-12.5,-15.5) BJ22(-11.5,-15.5) BJ23(-10.5,-15.5) BJ24(-9.5,-15.5) BJ25(-8.5,-15.5) BJ26(-7.5,-15.5) BJ27(-6.5,-15.5) BJ28(-5.5,-15.5) BJ29(-4.5,-15.5) BJ30(-3.5,-15.5) BJ31(-2.5,-15.5) BJ32(-1.5,-15.5) BJ33(-0.5,-15.5) BJ34(0.5,-15.5) BJ35(1.5,-15.5) BJ36(2.5,-15.5) BJ37(3.5,-15.5) BJ38(4.5,-15.5) BJ39(5.5,-15.5) BJ40(6.5,-15.5) BJ41(7.5,-15.5) BJ42(8.5,-15.5) BJ43(9.5,-15.5) BJ44(10.5,-15.5) BJ45(11.5,-15.5) BJ46(12.5,-15.5) BJ47(13.5,-15.5) BJ48(14.5,-15.5) BJ49(15.5,-15.5) BJ50(16.5,-15.5) BJ51(17.5,-15.5) BJ52(18.5,-15.5) BJ53(19.5,-15.5) BJ54(20.5,-15.5) BJ55(21.5,-15.5) BJ56(22.5,-15.5) BJ57(23.5,-15.5) BJ58(24.5,-15.5) BJ59(25.5,-15.5) BJ60(26.5,-15.5) BJ61(27.5,-15.5) BJ62(28.5,-15.5) BJ63(29.5,-15.5) BJ64(30.5,-15.5) BJ65(31.5,-15.5) BJ66(32.5,-15.5) BK1(-32.5,-16.5) BK2(-31.5,-16.5) BK3(-30.5,-16.5) BK4(-29.5,-16.5) BK5(-28.5,-16.5) BK6(-27.5,-16.5) BK7(-26.5,-16.5) BK8(-25.5,-16.5) BK9(-24.5,-16.5) BK10(-23.5,-16.5) BK11(-22.5,-16.5) BK12(-21.5,-16.5) BK13(-20.5,-16.5) BK14(-19.5,-16.5) BK15(-18.5,-16.5) BK16(-17.5,-16.5) BK17(-16.5,-16.5) BK18(-15.5,-16.5) BK19(-14.5,-16.5) BK20(-13.5,-16.5) BK21(-12.5,-16.5) BK22(-11.5,-16.5) BK23(-10.5,-16.5) BK24(-9.5,-16.5) BK25(-8.5,-16.5) BK26(-7.5,-16.5) BK27(-6.5,-16.5) BK28(-5.5,-16.5) BK29(-4.5,-16.5) BK30(-3.5,-16.5) BK31(-2.5,-16.5) BK32(-1.5,-16.5) BK33(-0.5,-16.5) BK34(0.5,-16.5) BK35(1.5,-16.5) BK36(2.5,-16.5) BK37(3.5,-16.5) BK38(4.5,-16.5) BK39(5.5,-16.5) BK40(6.5,-16.5) BK41(7.5,-16.5) BK42(8.5,-16.5) BK43(9.5,-16.5) BK44(10.5,-16.5) BK45(11.5,-16.5) BK46(12.5,-16.5) BK47(13.5,-16.5) BK48(14.5,-16.5) BK49(15.5,-16.5) BK50(16.5,-16.5) BK51(17.5,-16.5) BK52(18.5,-16.5) BK53(19.5,-16.5) BK54(20.5,-16.5) BK55(21.5,-16.5) BK56(22.5,-16.5) BK57(23.5,-16.5) BK58(24.5,-16.5) BK59(25.5,-16.5) BK60(26.5,-16.5) BK61(27.5,-16.5) BK62(28.5,-16.5) BK63(29.5,-16.5) BK64(30.5,-16.5) BK65(31.5,-16.5) BK66(32.5,-16.5) BL1(-32.5,-17.5) BL2(-31.5,-17.5) BL3(-30.5,-17.5) BL4(-29.5,-17.5) BL5(-28.5,-17.5) BL6(-27.5,-17.5) BL7(-26.5,-17.5) BL8(-25.5,-17.5) BL9(-24.5,-17.5) BL10(-23.5,-17.5) BL11(-22.5,-17.5) BL12(-21.5,-17.5) BL13(-20.5,-17.5) BL14(-19.5,-17.5) BL15(-18.5,-17.5) BL16(-17.5,-17.5) BL17(-16.5,-17.5) BL18(-15.5,-17.5) BL19(-14.5,-17.5) BL20(-13.5,-17.5) BL21(-12.5,-17.5) BL22(-11.5,-17.5) BL23(-10.5,-17.5) BL24(-9.5,-17.5) BL25(-8.5,-17.5) BL26(-7.5,-17.5) BL27(-6.5,-17.5) BL28(-5.5,-17.5) BL29(-4.5,-17.5) BL30(-3.5,-17.5) BL31(-2.5,-17.5) BL32(-1.5,-17.5) BL33(-0.5,-17.5) BL34(0.5,-17.5) BL35(1.5,-17.5) BL36(2.5,-17.5) BL37(3.5,-17.5) BL38(4.5,-17.5) BL39(5.5,-17.5) BL40(6.5,-17.5) BL41(7.5,-17.5) BL42(8.5,-17.5) BL43(9.5,-17.5) BL44(10.5,-17.5) BL45(11.5,-17.5) BL46(12.5,-17.5) BL47(13.5,-17.5) BL48(14.5,-17.5) BL49(15.5,-17.5) BL50(16.5,-17.5) BL51(17.5,-17.5) BL52(18.5,-17.5) BL53(19.5,-17.5) BL54(20.5,-17.5) BL55(21.5,-17.5) BL56(22.5,-17.5) BL57(23.5,-17.5) BL58(24.5,-17.5) BL59(25.5,-17.5) BL60(26.5,-17.5) BL61(27.5,-17.5) BL62(28.5,-17.5) BL63(29.5,-17.5) BL64(30.5,-17.5) BL65(31.5,-17.5) BL66(32.5,-17.5) BM1(-32.5,-18.5) BM2(-31.5,-18.5) BM3(-30.5,-18.5) BM4(-29.5,-18.5) BM5(-28.5,-18.5) BM6(-27.5,-18.5) BM7(-26.5,-18.5) BM8(-25.5,-18.5) BM9(-24.5,-18.5) BM10(-23.5,-18.5) BM11(-22.5,-18.5) BM12(-21.5,-18.5) BM13(-20.5,-18.5) BM14(-19.5,-18.5) BM15(-18.5,-18.5) BM16(-17.5,-18.5) BM17(-16.5,-18.5) BM18(-15.5,-18.5) BM19(-14.5,-18.5) BM20(-13.5,-18.5) BM21(-12.5,-18.5) BM22(-11.5,-18.5) BM23(-10.5,-18.5) BM24(-9.5,-18.5) BM25(-8.5,-18.5) BM26(-7.5,-18.5) BM27(-6.5,-18.5) BM28(-5.5,-18.5) BM29(-4.5,-18.5) BM30(-3.5,-18.5) BM31(-2.5,-18.5) BM32(-1.5,-18.5) BM33(-0.5,-18.5) BM34(0.5,-18.5) BM35(1.5,-18.5) BM36(2.5,-18.5) BM37(3.5,-18.5) BM38(4.5,-18.5) BM39(5.5,-18.5) BM40(6.5,-18.5) BM41(7.5,-18.5) BM42(8.5,-18.5) BM43(9.5,-18.5) BM44(10.5,-18.5) BM45(11.5,-18.5) BM46(12.5,-18.5) BM47(13.5,-18.5) BM48(14.5,-18.5) BM49(15.5,-18.5) BM50(16.5,-18.5) BM51(17.5,-18.5) BM52(18.5,-18.5) BM53(19.5,-18.5) BM54(20.5,-18.5) BM55(21.5,-18.5) BM56(22.5,-18.5) BM57(23.5,-18.5) BM58(24.5,-18.5) BM59(25.5,-18.5) BM60(26.5,-18.5) BM61(27.5,-18.5) BM62(28.5,-18.5) BM63(29.5,-18.5) BM64(30.5,-18.5) BM65(31.5,-18.5) BM66(32.5,-18.5) BN1(-32.5,-19.5) BN2(-31.5,-19.5) BN3(-30.5,-19.5) BN4(-29.5,-19.5) BN5(-28.5,-19.5) BN6(-27.5,-19.5) BN7(-26.5,-19.5) BN8(-25.5,-19.5) BN9(-24.5,-19.5) BN10(-23.5,-19.5) BN11(-22.5,-19.5) BN12(-21.5,-19.5) BN13(-20.5,-19.5) BN14(-19.5,-19.5) BN15(-18.5,-19.5) BN16(-17.5,-19.5) BN17(-16.5,-19.5) BN18(-15.5,-19.5) BN19(-14.5,-19.5) BN20(-13.5,-19.5) BN21(-12.5,-19.5) BN22(-11.5,-19.5) BN23(-10.5,-19.5) BN24(-9.5,-19.5) BN25(-8.5,-19.5) BN26(-7.5,-19.5) BN27(-6.5,-19.5) BN28(-5.5,-19.5) BN29(-4.5,-19.5) BN30(-3.5,-19.5) BN31(-2.5,-19.5) BN32(-1.5,-19.5) BN33(-0.5,-19.5) BN34(0.5,-19.5) BN35(1.5,-19.5) BN36(2.5,-19.5) BN37(3.5,-19.5) BN38(4.5,-19.5) BN39(5.5,-19.5) BN40(6.5,-19.5) BN41(7.5,-19.5) BN42(8.5,-19.5) BN43(9.5,-19.5) BN44(10.5,-19.5) BN45(11.5,-19.5) BN46(12.5,-19.5) BN47(13.5,-19.5) BN48(14.5,-19.5) BN49(15.5,-19.5) BN50(16.5,-19.5) BN51(17.5,-19.5) BN52(18.5,-19.5) BN53(19.5,-19.5) BN54(20.5,-19.5) BN55(21.5,-19.5) BN56(22.5,-19.5) BN57(23.5,-19.5) BN58(24.5,-19.5) BN59(25.5,-19.5) BN60(26.5,-19.5) BN61(27.5,-19.5) BN62(28.5,-19.5) BN63(29.5,-19.5) BN64(30.5,-19.5) BN65(31.5,-19.5) BN66(32.5,-19.5) BP1(-32.5,-20.5) BP2(-31.5,-20.5) BP3(-30.5,-20.5) BP4(-29.5,-20.5) BP5(-28.5,-20.5) BP6(-27.5,-20.5) BP7(-26.5,-20.5) BP8(-25.5,-20.5) BP9(-24.5,-20.5) BP10(-23.5,-20.5) BP11(-22.5,-20.5) BP12(-21.5,-20.5) BP13(-20.5,-20.5) BP14(-19.5,-20.5) BP15(-18.5,-20.5) BP16(-17.5,-20.5) BP17(-16.5,-20.5) BP18(-15.5,-20.5) BP19(-14.5,-20.5) BP20(-13.5,-20.5) BP21(-12.5,-20.5) BP22(-11.5,-20.5) BP23(-10.5,-20.5) BP24(-9.5,-20.5) BP25(-8.5,-20.5) BP26(-7.5,-20.5) BP27(-6.5,-20.5) BP28(-5.5,-20.5) BP29(-4.5,-20.5) BP30(-3.5,-20.5) BP31(-2.5,-20.5) BP32(-1.5,-20.5) BP33(-0.5,-20.5) BP34(0.5,-20.5) BP35(1.5,-20.5) BP36(2.5,-20.5) BP37(3.5,-20.5) BP38(4.5,-20.5) BP39(5.5,-20.5) BP40(6.5,-20.5) BP41(7.5,-20.5) BP42(8.5,-20.5) BP43(9.5,-20.5) BP44(10.5,-20.5) BP45(11.5,-20.5) BP46(12.5,-20.5) BP47(13.5,-20.5) BP48(14.5,-20.5) BP49(15.5,-20.5) BP50(16.5,-20.5) BP51(17.5,-20.5) BP52(18.5,-20.5) BP53(19.5,-20.5) BP54(20.5,-20.5) BP55(21.5,-20.5) BP56(22.5,-20.5) BP57(23.5,-20.5) BP58(24.5,-20.5) BP59(25.5,-20.5) BP60(26.5,-20.5) BP61(27.5,-20.5) BP62(28.5,-20.5) BP63(29.5,-20.5) BP64(30.5,-20.5) BP65(31.5,-20.5) BP66(32.5,-20.5) BR1(-32.5,-21.5) BR2(-31.5,-21.5) BR3(-30.5,-21.5) BR4(-29.5,-21.5) BR5(-28.5,-21.5) BR6(-27.5,-21.5) BR7(-26.5,-21.5) BR8(-25.5,-21.5) BR9(-24.5,-21.5) BR10(-23.5,-21.5) BR11(-22.5,-21.5) BR12(-21.5,-21.5) BR13(-20.5,-21.5) BR14(-19.5,-21.5) BR15(-18.5,-21.5) BR16(-17.5,-21.5) BR17(-16.5,-21.5) BR18(-15.5,-21.5) BR19(-14.5,-21.5) BR20(-13.5,-21.5) BR21(-12.5,-21.5) BR22(-11.5,-21.5) BR23(-10.5,-21.5) BR24(-9.5,-21.5) BR25(-8.5,-21.5) BR26(-7.5,-21.5) BR27(-6.5,-21.5) BR28(-5.5,-21.5) BR29(-4.5,-21.5) BR30(-3.5,-21.5) BR31(-2.5,-21.5) BR32(-1.5,-21.5) BR33(-0.5,-21.5) BR34(0.5,-21.5) BR35(1.5,-21.5) BR36(2.5,-21.5) BR37(3.5,-21.5) BR38(4.5,-21.5) BR39(5.5,-21.5) BR40(6.5,-21.5) BR41(7.5,-21.5) BR42(8.5,-21.5) BR43(9.5,-21.5) BR44(10.5,-21.5) BR45(11.5,-21.5) BR46(12.5,-21.5) BR47(13.5,-21.5) BR48(14.5,-21.5) BR49(15.5,-21.5) BR50(16.5,-21.5) BR51(17.5,-21.5) BR52(18.5,-21.5) BR53(19.5,-21.5) BR54(20.5,-21.5) BR55(21.5,-21.5) BR56(22.5,-21.5) BR57(23.5,-21.5) BR58(24.5,-21.5) BR59(25.5,-21.5) BR60(26.5,-21.5) BR61(27.5,-21.5) BR62(28.5,-21.5) BR63(29.5,-21.5) BR64(30.5,-21.5) BR65(31.5,-21.5) BR66(32.5,-21.5) BT1(-32.5,-22.5) BT2(-31.5,-22.5) BT3(-30.5,-22.5) BT4(-29.5,-22.5) BT5(-28.5,-22.5) BT6(-27.5,-22.5) BT7(-26.5,-22.5) BT8(-25.5,-22.5) BT9(-24.5,-22.5) BT10(-23.5,-22.5) BT11(-22.5,-22.5) BT12(-21.5,-22.5) BT13(-20.5,-22.5) BT14(-19.5,-22.5) BT15(-18.5,-22.5) BT16(-17.5,-22.5) BT17(-16.5,-22.5) BT18(-15.5,-22.5) BT19(-14.5,-22.5) BT20(-13.5,-22.5) BT21(-12.5,-22.5) BT22(-11.5,-22.5) BT23(-10.5,-22.5) BT24(-9.5,-22.5) BT25(-8.5,-22.5) BT26(-7.5,-22.5) BT27(-6.5,-22.5) BT28(-5.5,-22.5) BT29(-4.5,-22.5) BT30(-3.5,-22.5) BT31(-2.5,-22.5) BT32(-1.5,-22.5) BT33(-0.5,-22.5) BT34(0.5,-22.5) BT35(1.5,-22.5) BT36(2.5,-22.5) BT37(3.5,-22.5) BT38(4.5,-22.5) BT39(5.5,-22.5) BT40(6.5,-22.5) BT41(7.5,-22.5) BT42(8.5,-22.5) BT43(9.5,-22.5) BT44(10.5,-22.5) BT45(11.5,-22.5) BT46(12.5,-22.5) BT47(13.5,-22.5) BT48(14.5,-22.5) BT49(15.5,-22.5) BT50(16.5,-22.5) BT51(17.5,-22.5) BT52(18.5,-22.5) BT53(19.5,-22.5) BT54(20.5,-22.5) BT55(21.5,-22.5) BT56(22.5,-22.5) BT57(23.5,-22.5) BT58(24.5,-22.5) BT59(25.5,-22.5) BT60(26.5,-22.5) BT61(27.5,-22.5) BT62(28.5,-22.5) BT63(29.5,-22.5) BT64(30.5,-22.5) BT65(31.5,-22.5) BT66(32.5,-22.5) BU1(-32.5,-23.5) BU2(-31.5,-23.5) BU3(-30.5,-23.5) BU4(-29.5,-23.5) BU5(-28.5,-23.5) BU6(-27.5,-23.5) BU7(-26.5,-23.5) BU8(-25.5,-23.5) BU9(-24.5,-23.5) BU10(-23.5,-23.5) BU11(-22.5,-23.5) BU12(-21.5,-23.5) BU13(-20.5,-23.5) BU14(-19.5,-23.5) BU15(-18.5,-23.5) BU16(-17.5,-23.5) BU17(-16.5,-23.5) BU18(-15.5,-23.5) BU19(-14.5,-23.5) BU20(-13.5,-23.5) BU21(-12.5,-23.5) BU22(-11.5,-23.5) BU23(-10.5,-23.5) BU24(-9.5,-23.5) BU25(-8.5,-23.5) BU26(-7.5,-23.5) BU27(-6.5,-23.5) BU28(-5.5,-23.5) BU29(-4.5,-23.5) BU30(-3.5,-23.5) BU31(-2.5,-23.5) BU32(-1.5,-23.5) BU33(-0.5,-23.5) BU34(0.5,-23.5) BU35(1.5,-23.5) BU36(2.5,-23.5) BU37(3.5,-23.5) BU38(4.5,-23.5) BU39(5.5,-23.5) BU40(6.5,-23.5) BU41(7.5,-23.5) BU42(8.5,-23.5) BU43(9.5,-23.5) BU44(10.5,-23.5) BU45(11.5,-23.5) BU46(12.5,-23.5) BU47(13.5,-23.5) BU48(14.5,-23.5) BU49(15.5,-23.5) BU50(16.5,-23.5) BU51(17.5,-23.5) BU52(18.5,-23.5) BU53(19.5,-23.5) BU54(20.5,-23.5) BU55(21.5,-23.5) BU56(22.5,-23.5) BU57(23.5,-23.5) BU58(24.5,-23.5) BU59(25.5,-23.5) BU60(26.5,-23.5) BU61(27.5,-23.5) BU62(28.5,-23.5) BU63(29.5,-23.5) BU64(30.5,-23.5) BU65(31.5,-23.5) BU66(32.5,-23.5) BV1(-32.5,-24.5) BV2(-31.5,-24.5) BV3(-30.5,-24.5) BV4(-29.5,-24.5) BV5(-28.5,-24.5) BV6(-27.5,-24.5) BV7(-26.5,-24.5) BV8(-25.5,-24.5) BV9(-24.5,-24.5) BV10(-23.5,-24.5) BV11(-22.5,-24.5) BV12(-21.5,-24.5) BV13(-20.5,-24.5) BV14(-19.5,-24.5) BV15(-18.5,-24.5) BV16(-17.5,-24.5) BV17(-16.5,-24.5) BV18(-15.5,-24.5) BV19(-14.5,-24.5) BV20(-13.5,-24.5) BV21(-12.5,-24.5) BV22(-11.5,-24.5) BV23(-10.5,-24.5) BV24(-9.5,-24.5) BV25(-8.5,-24.5) BV26(-7.5,-24.5) BV27(-6.5,-24.5) BV28(-5.5,-24.5) BV29(-4.5,-24.5) BV30(-3.5,-24.5) BV31(-2.5,-24.5) BV32(-1.5,-24.5) BV33(-0.5,-24.5) BV34(0.5,-24.5) BV35(1.5,-24.5) BV36(2.5,-24.5) BV37(3.5,-24.5) BV38(4.5,-24.5) BV39(5.5,-24.5) BV40(6.5,-24.5) BV41(7.5,-24.5) BV42(8.5,-24.5) BV43(9.5,-24.5) BV44(10.5,-24.5) BV45(11.5,-24.5) BV46(12.5,-24.5) BV47(13.5,-24.5) BV48(14.5,-24.5) BV49(15.5,-24.5) BV50(16.5,-24.5) BV51(17.5,-24.5) BV52(18.5,-24.5) BV53(19.5,-24.5) BV54(20.5,-24.5) BV55(21.5,-24.5) BV56(22.5,-24.5) BV57(23.5,-24.5) BV58(24.5,-24.5) BV59(25.5,-24.5) BV60(26.5,-24.5) BV61(27.5,-24.5) BV62(28.5,-24.5) BV63(29.5,-24.5) BV64(30.5,-24.5) BV65(31.5,-24.5) BV66(32.5,-24.5) BW1(-32.5,-25.5) BW2(-31.5,-25.5) BW3(-30.5,-25.5) BW4(-29.5,-25.5) BW5(-28.5,-25.5) BW6(-27.5,-25.5) BW7(-26.5,-25.5) BW8(-25.5,-25.5) BW9(-24.5,-25.5) BW10(-23.5,-25.5) BW11(-22.5,-25.5) BW12(-21.5,-25.5) BW13(-20.5,-25.5) BW14(-19.5,-25.5) BW15(-18.5,-25.5) BW16(-17.5,-25.5) BW17(-16.5,-25.5) BW18(-15.5,-25.5) BW19(-14.5,-25.5) BW20(-13.5,-25.5) BW21(-12.5,-25.5) BW22(-11.5,-25.5) BW23(-10.5,-25.5) BW24(-9.5,-25.5) BW25(-8.5,-25.5) BW26(-7.5,-25.5) BW27(-6.5,-25.5) BW28(-5.5,-25.5) BW29(-4.5,-25.5) BW30(-3.5,-25.5) BW31(-2.5,-25.5) BW32(-1.5,-25.5) BW33(-0.5,-25.5) BW34(0.5,-25.5) BW35(1.5,-25.5) BW36(2.5,-25.5) BW37(3.5,-25.5) BW38(4.5,-25.5) BW39(5.5,-25.5) BW40(6.5,-25.5) BW41(7.5,-25.5) BW42(8.5,-25.5) BW43(9.5,-25.5) BW44(10.5,-25.5) BW45(11.5,-25.5) BW46(12.5,-25.5) BW47(13.5,-25.5) BW48(14.5,-25.5) BW49(15.5,-25.5) BW50(16.5,-25.5) BW51(17.5,-25.5) BW52(18.5,-25.5) BW53(19.5,-25.5) BW54(20.5,-25.5) BW55(21.5,-25.5) BW56(22.5,-25.5) BW57(23.5,-25.5) BW58(24.5,-25.5) BW59(25.5,-25.5) BW60(26.5,-25.5) BW61(27.5,-25.5) BW62(28.5,-25.5) BW63(29.5,-25.5) BW64(30.5,-25.5) BW65(31.5,-25.5) BW66(32.5,-25.5) BY1(-32.5,-26.5) BY2(-31.5,-26.5) BY3(-30.5,-26.5) BY4(-29.5,-26.5) BY5(-28.5,-26.5) BY6(-27.5,-26.5) BY7(-26.5,-26.5) BY8(-25.5,-26.5) BY9(-24.5,-26.5) BY10(-23.5,-26.5) BY11(-22.5,-26.5) BY12(-21.5,-26.5) BY13(-20.5,-26.5) BY14(-19.5,-26.5) BY15(-18.5,-26.5) BY16(-17.5,-26.5) BY17(-16.5,-26.5) BY18(-15.5,-26.5) BY19(-14.5,-26.5) BY20(-13.5,-26.5) BY21(-12.5,-26.5) BY22(-11.5,-26.5) BY23(-10.5,-26.5) BY24(-9.5,-26.5) BY25(-8.5,-26.5) BY26(-7.5,-26.5) BY27(-6.5,-26.5) BY28(-5.5,-26.5) BY29(-4.5,-26.5) BY30(-3.5,-26.5) BY31(-2.5,-26.5) BY32(-1.5,-26.5) BY33(-0.5,-26.5) BY34(0.5,-26.5) BY35(1.5,-26.5) BY36(2.5,-26.5) BY37(3.5,-26.5) BY38(4.5,-26.5) BY39(5.5,-26.5) BY40(6.5,-26.5) BY41(7.5,-26.5) BY42(8.5,-26.5) BY43(9.5,-26.5) BY44(10.5,-26.5) BY45(11.5,-26.5) BY46(12.5,-26.5) BY47(13.5,-26.5) BY48(14.5,-26.5) BY49(15.5,-26.5) BY50(16.5,-26.5) BY51(17.5,-26.5) BY52(18.5,-26.5) BY53(19.5,-26.5) BY54(20.5,-26.5) BY55(21.5,-26.5) BY56(22.5,-26.5) BY57(23.5,-26.5) BY58(24.5,-26.5) BY59(25.5,-26.5) BY60(26.5,-26.5) BY61(27.5,-26.5) BY62(28.5,-26.5) BY63(29.5,-26.5) BY64(30.5,-26.5) BY65(31.5,-26.5) BY66(32.5,-26.5) C1(-32.5,30.5) C2(-31.5,30.5) C3(-30.5,30.5) C4(-29.5,30.5) C5(-28.5,30.5) C6(-27.5,30.5) C7(-26.5,30.5) C8(-25.5,30.5) C9(-24.5,30.5) C10(-23.5,30.5) C11(-22.5,30.5) C12(-21.5,30.5) C13(-20.5,30.5) C14(-19.5,30.5) C15(-18.5,30.5) C16(-17.5,30.5) C17(-16.5,30.5) C18(-15.5,30.5) C19(-14.5,30.5) C20(-13.5,30.5) C21(-12.5,30.5) C22(-11.5,30.5) C23(-10.5,30.5) C24(-9.5,30.5) C25(-8.5,30.5) C26(-7.5,30.5) C27(-6.5,30.5) C28(-5.5,30.5) C29(-4.5,30.5) C30(-3.5,30.5) C31(-2.5,30.5) C32(-1.5,30.5) C33(-0.5,30.5) C34(0.5,30.5) C35(1.5,30.5) C36(2.5,30.5) C37(3.5,30.5) C38(4.5,30.5) C39(5.5,30.5) C40(6.5,30.5) C41(7.5,30.5) C42(8.5,30.5) C43(9.5,30.5) C44(10.5,30.5) C45(11.5,30.5) C46(12.5,30.5) C47(13.5,30.5) C48(14.5,30.5) C49(15.5,30.5) C50(16.5,30.5) C51(17.5,30.5) C52(18.5,30.5) C53(19.5,30.5) C54(20.5,30.5) C55(21.5,30.5) C56(22.5,30.5) C57(23.5,30.5) C58(24.5,30.5) C59(25.5,30.5) C60(26.5,30.5) C61(27.5,30.5) C62(28.5,30.5) C63(29.5,30.5) C64(30.5,30.5) C65(31.5,30.5) C66(32.5,30.5) CA1(-32.5,-27.5) CA2(-31.5,-27.5) CA3(-30.5,-27.5) CA4(-29.5,-27.5) CA5(-28.5,-27.5) CA6(-27.5,-27.5) CA7(-26.5,-27.5) CA8(-25.5,-27.5) CA9(-24.5,-27.5) CA10(-23.5,-27.5) CA11(-22.5,-27.5) CA12(-21.5,-27.5) CA13(-20.5,-27.5) CA14(-19.5,-27.5) CA15(-18.5,-27.5) CA16(-17.5,-27.5) CA17(-16.5,-27.5) CA18(-15.5,-27.5) CA19(-14.5,-27.5) CA20(-13.5,-27.5) CA21(-12.5,-27.5) CA22(-11.5,-27.5) CA23(-10.5,-27.5) CA24(-9.5,-27.5) CA25(-8.5,-27.5) CA26(-7.5,-27.5) CA27(-6.5,-27.5) CA28(-5.5,-27.5) CA29(-4.5,-27.5) CA30(-3.5,-27.5) CA31(-2.5,-27.5) CA32(-1.5,-27.5) CA33(-0.5,-27.5) CA34(0.5,-27.5) CA35(1.5,-27.5) CA36(2.5,-27.5) CA37(3.5,-27.5) CA38(4.5,-27.5) CA39(5.5,-27.5) CA40(6.5,-27.5) CA41(7.5,-27.5) CA42(8.5,-27.5) CA43(9.5,-27.5) CA44(10.5,-27.5) CA45(11.5,-27.5) CA46(12.5,-27.5) CA47(13.5,-27.5) CA48(14.5,-27.5) CA49(15.5,-27.5) CA50(16.5,-27.5) CA51(17.5,-27.5) CA52(18.5,-27.5) CA53(19.5,-27.5) CA54(20.5,-27.5) CA55(21.5,-27.5) CA56(22.5,-27.5) CA57(23.5,-27.5) CA58(24.5,-27.5) CA59(25.5,-27.5) CA60(26.5,-27.5) CA61(27.5,-27.5) CA62(28.5,-27.5) CA63(29.5,-27.5) CA64(30.5,-27.5) CA65(31.5,-27.5) CA66(32.5,-27.5) CB1(-32.5,-28.5) CB2(-31.5,-28.5) CB3(-30.5,-28.5) CB4(-29.5,-28.5) CB5(-28.5,-28.5) CB6(-27.5,-28.5) CB7(-26.5,-28.5) CB8(-25.5,-28.5) CB9(-24.5,-28.5) CB10(-23.5,-28.5) CB11(-22.5,-28.5) CB12(-21.5,-28.5) CB13(-20.5,-28.5) CB14(-19.5,-28.5) CB15(-18.5,-28.5) CB16(-17.5,-28.5) CB17(-16.5,-28.5) CB18(-15.5,-28.5) CB19(-14.5,-28.5) CB20(-13.5,-28.5) CB21(-12.5,-28.5) CB22(-11.5,-28.5) CB23(-10.5,-28.5) CB24(-9.5,-28.5) CB25(-8.5,-28.5) CB26(-7.5,-28.5) CB27(-6.5,-28.5) CB28(-5.5,-28.5) CB29(-4.5,-28.5) CB30(-3.5,-28.5) CB31(-2.5,-28.5) CB32(-1.5,-28.5) CB33(-0.5,-28.5) CB34(0.5,-28.5) CB35(1.5,-28.5) CB36(2.5,-28.5) CB37(3.5,-28.5) CB38(4.5,-28.5) CB39(5.5,-28.5) CB40(6.5,-28.5) CB41(7.5,-28.5) CB42(8.5,-28.5) CB43(9.5,-28.5) CB44(10.5,-28.5) CB45(11.5,-28.5) CB46(12.5,-28.5) CB47(13.5,-28.5) CB48(14.5,-28.5) CB49(15.5,-28.5) CB50(16.5,-28.5) CB51(17.5,-28.5) CB52(18.5,-28.5) CB53(19.5,-28.5) CB54(20.5,-28.5) CB55(21.5,-28.5) CB56(22.5,-28.5) CB57(23.5,-28.5) CB58(24.5,-28.5) CB59(25.5,-28.5) CB60(26.5,-28.5) CB61(27.5,-28.5) CB62(28.5,-28.5) CB63(29.5,-28.5) CB64(30.5,-28.5) CB65(31.5,-28.5) CB66(32.5,-28.5) CC1(-32.5,-29.5) CC2(-31.5,-29.5) CC3(-30.5,-29.5) CC4(-29.5,-29.5) CC5(-28.5,-29.5) CC6(-27.5,-29.5) CC7(-26.5,-29.5) CC8(-25.5,-29.5) CC9(-24.5,-29.5) CC10(-23.5,-29.5) CC11(-22.5,-29.5) CC12(-21.5,-29.5) CC13(-20.5,-29.5) CC14(-19.5,-29.5) CC15(-18.5,-29.5) CC16(-17.5,-29.5) CC17(-16.5,-29.5) CC18(-15.5,-29.5) CC19(-14.5,-29.5) CC20(-13.5,-29.5) CC21(-12.5,-29.5) CC22(-11.5,-29.5) CC23(-10.5,-29.5) CC24(-9.5,-29.5) CC25(-8.5,-29.5) CC26(-7.5,-29.5) CC27(-6.5,-29.5) CC28(-5.5,-29.5) CC29(-4.5,-29.5) CC30(-3.5,-29.5) CC31(-2.5,-29.5) CC32(-1.5,-29.5) CC33(-0.5,-29.5) CC34(0.5,-29.5) CC35(1.5,-29.5) CC36(2.5,-29.5) CC37(3.5,-29.5) CC38(4.5,-29.5) CC39(5.5,-29.5) CC40(6.5,-29.5) CC41(7.5,-29.5) CC42(8.5,-29.5) CC43(9.5,-29.5) CC44(10.5,-29.5) CC45(11.5,-29.5) CC46(12.5,-29.5) CC47(13.5,-29.5) CC48(14.5,-29.5) CC49(15.5,-29.5) CC50(16.5,-29.5) CC51(17.5,-29.5) CC52(18.5,-29.5) CC53(19.5,-29.5) CC54(20.5,-29.5) CC55(21.5,-29.5) CC56(22.5,-29.5) CC57(23.5,-29.5) CC58(24.5,-29.5) CC59(25.5,-29.5) CC60(26.5,-29.5) CC61(27.5,-29.5) CC62(28.5,-29.5) CC63(29.5,-29.5) CC64(30.5,-29.5) CC65(31.5,-29.5) CC66(32.5,-29.5) CD1(-32.5,-30.5) CD2(-31.5,-30.5) CD3(-30.5,-30.5) CD4(-29.5,-30.5) CD5(-28.5,-30.5) CD6(-27.5,-30.5) CD7(-26.5,-30.5) CD8(-25.5,-30.5) CD9(-24.5,-30.5) CD10(-23.5,-30.5) CD11(-22.5,-30.5) CD12(-21.5,-30.5) CD13(-20.5,-30.5) CD14(-19.5,-30.5) CD15(-18.5,-30.5) CD16(-17.5,-30.5) CD17(-16.5,-30.5) CD18(-15.5,-30.5) CD19(-14.5,-30.5) CD20(-13.5,-30.5) CD21(-12.5,-30.5) CD22(-11.5,-30.5) CD23(-10.5,-30.5) CD24(-9.5,-30.5) CD25(-8.5,-30.5) CD26(-7.5,-30.5) CD27(-6.5,-30.5) CD28(-5.5,-30.5) CD29(-4.5,-30.5) CD30(-3.5,-30.5) CD31(-2.5,-30.5) CD32(-1.5,-30.5) CD33(-0.5,-30.5) CD34(0.5,-30.5) CD35(1.5,-30.5) CD36(2.5,-30.5) CD37(3.5,-30.5) CD38(4.5,-30.5) CD39(5.5,-30.5) CD40(6.5,-30.5) CD41(7.5,-30.5) CD42(8.5,-30.5) CD43(9.5,-30.5) CD44(10.5,-30.5) CD45(11.5,-30.5) CD46(12.5,-30.5) CD47(13.5,-30.5) CD48(14.5,-30.5) CD49(15.5,-30.5) CD50(16.5,-30.5) CD51(17.5,-30.5) CD52(18.5,-30.5) CD53(19.5,-30.5) CD54(20.5,-30.5) CD55(21.5,-30.5) CD56(22.5,-30.5) CD57(23.5,-30.5) CD58(24.5,-30.5) CD59(25.5,-30.5) CD60(26.5,-30.5) CD61(27.5,-30.5) CD62(28.5,-30.5) CD63(29.5,-30.5) CD64(30.5,-30.5) CD65(31.5,-30.5) CD66(32.5,-30.5) CE2(-31.5,-31.5) CE3(-30.5,-31.5) CE4(-29.5,-31.5) CE5(-28.5,-31.5) CE6(-27.5,-31.5) CE7(-26.5,-31.5) CE8(-25.5,-31.5) CE9(-24.5,-31.5) CE10(-23.5,-31.5) CE11(-22.5,-31.5) CE12(-21.5,-31.5) CE13(-20.5,-31.5) CE14(-19.5,-31.5) CE15(-18.5,-31.5) CE16(-17.5,-31.5) CE17(-16.5,-31.5) CE18(-15.5,-31.5) CE19(-14.5,-31.5) CE20(-13.5,-31.5) CE21(-12.5,-31.5) CE22(-11.5,-31.5) CE23(-10.5,-31.5) CE24(-9.5,-31.5) CE25(-8.5,-31.5) CE26(-7.5,-31.5) CE27(-6.5,-31.5) CE28(-5.5,-31.5) CE29(-4.5,-31.5) CE30(-3.5,-31.5) CE31(-2.5,-31.5) CE32(-1.5,-31.5) CE33(-0.5,-31.5) CE34(0.5,-31.5) CE35(1.5,-31.5) CE36(2.5,-31.5) CE37(3.5,-31.5) CE38(4.5,-31.5) CE39(5.5,-31.5) CE40(6.5,-31.5) CE41(7.5,-31.5) CE42(8.5,-31.5) CE43(9.5,-31.5) CE44(10.5,-31.5) CE45(11.5,-31.5) CE46(12.5,-31.5) CE47(13.5,-31.5) CE48(14.5,-31.5) CE49(15.5,-31.5) CE50(16.5,-31.5) CE51(17.5,-31.5) CE52(18.5,-31.5) CE53(19.5,-31.5) CE54(20.5,-31.5) CE55(21.5,-31.5) CE56(22.5,-31.5) CE57(23.5,-31.5) CE58(24.5,-31.5) CE59(25.5,-31.5) CE60(26.5,-31.5) CE61(27.5,-31.5) CE62(28.5,-31.5) CE63(29.5,-31.5) CE64(30.5,-31.5) CE65(31.5,-31.5) CF3(-30.5,-32.5) CF4(-29.5,-32.5) CF5(-28.5,-32.5) CF6(-27.5,-32.5) CF7(-26.5,-32.5) CF8(-25.5,-32.5) CF9(-24.5,-32.5) CF10(-23.5,-32.5) CF11(-22.5,-32.5) CF12(-21.5,-32.5) CF13(-20.5,-32.5) CF14(-19.5,-32.5) CF15(-18.5,-32.5) CF16(-17.5,-32.5) CF17(-16.5,-32.5) CF18(-15.5,-32.5) CF19(-14.5,-32.5) CF20(-13.5,-32.5) CF21(-12.5,-32.5) CF22(-11.5,-32.5) CF23(-10.5,-32.5) CF24(-9.5,-32.5) CF25(-8.5,-32.5) CF26(-7.5,-32.5) CF27(-6.5,-32.5) CF28(-5.5,-32.5) CF29(-4.5,-32.5) CF30(-3.5,-32.5) CF31(-2.5,-32.5) CF32(-1.5,-32.5) CF33(-0.5,-32.5) CF34(0.5,-32.5) CF35(1.5,-32.5) CF36(2.5,-32.5) CF37(3.5,-32.5) CF38(4.5,-32.5) CF39(5.5,-32.5) CF40(6.5,-32.5) CF41(7.5,-32.5) CF42(8.5,-32.5) CF43(9.5,-32.5) CF44(10.5,-32.5) CF45(11.5,-32.5) CF46(12.5,-32.5) CF47(13.5,-32.5) CF48(14.5,-32.5) CF49(15.5,-32.5) CF50(16.5,-32.5) CF51(17.5,-32.5) CF52(18.5,-32.5) CF53(19.5,-32.5) CF54(20.5,-32.5) CF55(21.5,-32.5) CF56(22.5,-32.5) CF57(23.5,-32.5) CF58(24.5,-32.5) CF59(25.5,-32.5) CF60(26.5,-32.5) CF61(27.5,-32.5) CF62(28.5,-32.5) CF63(29.5,-32.5) CF64(30.5,-32.5) D1(-32.5,29.5) D2(-31.5,29.5) D3(-30.5,29.5) D4(-29.5,29.5) D5(-28.5,29.5) D6(-27.5,29.5) D7(-26.5,29.5) D8(-25.5,29.5) D9(-24.5,29.5) D10(-23.5,29.5) D11(-22.5,29.5) D12(-21.5,29.5) D13(-20.5,29.5) D14(-19.5,29.5) D15(-18.5,29.5) D16(-17.5,29.5) D17(-16.5,29.5) D18(-15.5,29.5) D19(-14.5,29.5) D20(-13.5,29.5) D21(-12.5,29.5) D22(-11.5,29.5) D23(-10.5,29.5) D24(-9.5,29.5) D25(-8.5,29.5) D26(-7.5,29.5) D27(-6.5,29.5) D28(-5.5,29.5) D29(-4.5,29.5) D30(-3.5,29.5) D31(-2.5,29.5) D32(-1.5,29.5) D33(-0.5,29.5) D34(0.5,29.5) D35(1.5,29.5) D36(2.5,29.5) D37(3.5,29.5) D38(4.5,29.5) D39(5.5,29.5) D40(6.5,29.5) D41(7.5,29.5) D42(8.5,29.5) D43(9.5,29.5) D44(10.5,29.5) D45(11.5,29.5) D46(12.5,29.5) D47(13.5,29.5) D48(14.5,29.5) D49(15.5,29.5) D50(16.5,29.5) D51(17.5,29.5) D52(18.5,29.5) D53(19.5,29.5) D54(20.5,29.5) D55(21.5,29.5) D56(22.5,29.5) D57(23.5,29.5) D58(24.5,29.5) D59(25.5,29.5) D60(26.5,29.5) D61(27.5,29.5) D62(28.5,29.5) D63(29.5,29.5) D64(30.5,29.5) D65(31.5,29.5) D66(32.5,29.5) E1(-32.5,28.5) E2(-31.5,28.5) E3(-30.5,28.5) E4(-29.5,28.5) E5(-28.5,28.5) E6(-27.5,28.5) E7(-26.5,28.5) E8(-25.5,28.5) E9(-24.5,28.5) E10(-23.5,28.5) E11(-22.5,28.5) E12(-21.5,28.5) E13(-20.5,28.5) E14(-19.5,28.5) E15(-18.5,28.5) E16(-17.5,28.5) E17(-16.5,28.5) E18(-15.5,28.5) E19(-14.5,28.5) E20(-13.5,28.5) E21(-12.5,28.5) E22(-11.5,28.5) E23(-10.5,28.5) E24(-9.5,28.5) E25(-8.5,28.5) E26(-7.5,28.5) E27(-6.5,28.5) E28(-5.5,28.5) E29(-4.5,28.5) E30(-3.5,28.5) E31(-2.5,28.5) E32(-1.5,28.5) E33(-0.5,28.5) E34(0.5,28.5) E35(1.5,28.5) E36(2.5,28.5) E37(3.5,28.5) E38(4.5,28.5) E39(5.5,28.5) E40(6.5,28.5) E41(7.5,28.5) E42(8.5,28.5) E43(9.5,28.5) E44(10.5,28.5) E45(11.5,28.5) E46(12.5,28.5) E47(13.5,28.5) E48(14.5,28.5) E49(15.5,28.5) E50(16.5,28.5) E51(17.5,28.5) E52(18.5,28.5) E53(19.5,28.5) E54(20.5,28.5) E55(21.5,28.5) E56(22.5,28.5) E57(23.5,28.5) E58(24.5,28.5) E59(25.5,28.5) E60(26.5,28.5) E61(27.5,28.5) E62(28.5,28.5) E63(29.5,28.5) E64(30.5,28.5) E65(31.5,28.5) E66(32.5,28.5) F1(-32.5,27.5) F2(-31.5,27.5) F3(-30.5,27.5) F4(-29.5,27.5) F5(-28.5,27.5) F6(-27.5,27.5) F7(-26.5,27.5) F8(-25.5,27.5) F9(-24.5,27.5) F10(-23.5,27.5) F11(-22.5,27.5) F12(-21.5,27.5) F13(-20.5,27.5) F14(-19.5,27.5) F15(-18.5,27.5) F16(-17.5,27.5) F17(-16.5,27.5) F18(-15.5,27.5) F19(-14.5,27.5) F20(-13.5,27.5) F21(-12.5,27.5) F22(-11.5,27.5) F23(-10.5,27.5) F24(-9.5,27.5) F25(-8.5,27.5) F26(-7.5,27.5) F27(-6.5,27.5) F28(-5.5,27.5) F29(-4.5,27.5) F30(-3.5,27.5) F31(-2.5,27.5) F32(-1.5,27.5) F33(-0.5,27.5) F34(0.5,27.5) F35(1.5,27.5) F36(2.5,27.5) F37(3.5,27.5) F38(4.5,27.5) F39(5.5,27.5) F40(6.5,27.5) F41(7.5,27.5) F42(8.5,27.5) F43(9.5,27.5) F44(10.5,27.5) F45(11.5,27.5) F46(12.5,27.5) F47(13.5,27.5) F48(14.5,27.5) F49(15.5,27.5) F50(16.5,27.5) F51(17.5,27.5) F52(18.5,27.5) F53(19.5,27.5) F54(20.5,27.5) F55(21.5,27.5) F56(22.5,27.5) F57(23.5,27.5) F58(24.5,27.5) F59(25.5,27.5) F60(26.5,27.5) F61(27.5,27.5) F62(28.5,27.5) F63(29.5,27.5) F64(30.5,27.5) F65(31.5,27.5) F66(32.5,27.5) G1(-32.5,26.5) G2(-31.5,26.5) G3(-30.5,26.5) G4(-29.5,26.5) G5(-28.5,26.5) G6(-27.5,26.5) G7(-26.5,26.5) G8(-25.5,26.5) G9(-24.5,26.5) G10(-23.5,26.5) G11(-22.5,26.5) G12(-21.5,26.5) G13(-20.5,26.5) G14(-19.5,26.5) G15(-18.5,26.5) G16(-17.5,26.5) G17(-16.5,26.5) G18(-15.5,26.5) G19(-14.5,26.5) G20(-13.5,26.5) G21(-12.5,26.5) G22(-11.5,26.5) G23(-10.5,26.5) G24(-9.5,26.5) G25(-8.5,26.5) G26(-7.5,26.5) G27(-6.5,26.5) G28(-5.5,26.5) G29(-4.5,26.5) G30(-3.5,26.5) G31(-2.5,26.5) G32(-1.5,26.5) G33(-0.5,26.5) G34(0.5,26.5) G35(1.5,26.5) G36(2.5,26.5) G37(3.5,26.5) G38(4.5,26.5) G39(5.5,26.5) G40(6.5,26.5) G41(7.5,26.5) G42(8.5,26.5) G43(9.5,26.5) G44(10.5,26.5) G45(11.5,26.5) G46(12.5,26.5) G47(13.5,26.5) G48(14.5,26.5) G49(15.5,26.5) G50(16.5,26.5) G51(17.5,26.5) G52(18.5,26.5) G53(19.5,26.5) G54(20.5,26.5) G55(21.5,26.5) G56(22.5,26.5) G57(23.5,26.5) G58(24.5,26.5) G59(25.5,26.5) G60(26.5,26.5) G61(27.5,26.5) G62(28.5,26.5) G63(29.5,26.5) G64(30.5,26.5) G65(31.5,26.5) G66(32.5,26.5) H1(-32.5,25.5) H2(-31.5,25.5) H3(-30.5,25.5) H4(-29.5,25.5) H5(-28.5,25.5) H6(-27.5,25.5) H7(-26.5,25.5) H8(-25.5,25.5) H9(-24.5,25.5) H10(-23.5,25.5) H11(-22.5,25.5) H12(-21.5,25.5) H13(-20.5,25.5) H14(-19.5,25.5) H15(-18.5,25.5) H16(-17.5,25.5) H17(-16.5,25.5) H18(-15.5,25.5) H19(-14.5,25.5) H20(-13.5,25.5) H21(-12.5,25.5) H22(-11.5,25.5) H23(-10.5,25.5) H24(-9.5,25.5) H25(-8.5,25.5) H26(-7.5,25.5) H27(-6.5,25.5) H28(-5.5,25.5) H29(-4.5,25.5) H30(-3.5,25.5) H31(-2.5,25.5) H32(-1.5,25.5) H33(-0.5,25.5) H34(0.5,25.5) H35(1.5,25.5) H36(2.5,25.5) H37(3.5,25.5) H38(4.5,25.5) H39(5.5,25.5) H40(6.5,25.5) H41(7.5,25.5) H42(8.5,25.5) H43(9.5,25.5) H44(10.5,25.5) H45(11.5,25.5) H46(12.5,25.5) H47(13.5,25.5) H48(14.5,25.5) H49(15.5,25.5) H50(16.5,25.5) H51(17.5,25.5) H52(18.5,25.5) H53(19.5,25.5) H54(20.5,25.5) H55(21.5,25.5) H56(22.5,25.5) H57(23.5,25.5) H58(24.5,25.5) H59(25.5,25.5) H60(26.5,25.5) H61(27.5,25.5) H62(28.5,25.5) H63(29.5,25.5) H64(30.5,25.5) H65(31.5,25.5) H66(32.5,25.5) J1(-32.5,24.5) J2(-31.5,24.5) J3(-30.5,24.5) J4(-29.5,24.5) J5(-28.5,24.5) J6(-27.5,24.5) J7(-26.5,24.5) J8(-25.5,24.5) J9(-24.5,24.5) J10(-23.5,24.5) J11(-22.5,24.5) J12(-21.5,24.5) J13(-20.5,24.5) J14(-19.5,24.5) J15(-18.5,24.5) J16(-17.5,24.5) J17(-16.5,24.5) J18(-15.5,24.5) J19(-14.5,24.5) J20(-13.5,24.5) J21(-12.5,24.5) J22(-11.5,24.5) J23(-10.5,24.5) J24(-9.5,24.5) J25(-8.5,24.5) J26(-7.5,24.5) J27(-6.5,24.5) J28(-5.5,24.5) J29(-4.5,24.5) J30(-3.5,24.5) J31(-2.5,24.5) J32(-1.5,24.5) J33(-0.5,24.5) J34(0.5,24.5) J35(1.5,24.5) J36(2.5,24.5) J37(3.5,24.5) J38(4.5,24.5) J39(5.5,24.5) J40(6.5,24.5) J41(7.5,24.5) J42(8.5,24.5) J43(9.5,24.5) J44(10.5,24.5) J45(11.5,24.5) J46(12.5,24.5) J47(13.5,24.5) J48(14.5,24.5) J49(15.5,24.5) J50(16.5,24.5) J51(17.5,24.5) J52(18.5,24.5) J53(19.5,24.5) J54(20.5,24.5) J55(21.5,24.5) J56(22.5,24.5) J57(23.5,24.5) J58(24.5,24.5) J59(25.5,24.5) J60(26.5,24.5) J61(27.5,24.5) J62(28.5,24.5) J63(29.5,24.5) J64(30.5,24.5) J65(31.5,24.5) J66(32.5,24.5) K1(-32.5,23.5) K2(-31.5,23.5) K3(-30.5,23.5) K4(-29.5,23.5) K5(-28.5,23.5) K6(-27.5,23.5) K7(-26.5,23.5) K8(-25.5,23.5) K9(-24.5,23.5) K10(-23.5,23.5) K11(-22.5,23.5) K12(-21.5,23.5) K13(-20.5,23.5) K14(-19.5,23.5) K15(-18.5,23.5) K16(-17.5,23.5) K17(-16.5,23.5) K18(-15.5,23.5) K19(-14.5,23.5) K20(-13.5,23.5) K21(-12.5,23.5) K22(-11.5,23.5) K23(-10.5,23.5) K24(-9.5,23.5) K25(-8.5,23.5) K26(-7.5,23.5) K27(-6.5,23.5) K28(-5.5,23.5) K29(-4.5,23.5) K30(-3.5,23.5) K31(-2.5,23.5) K32(-1.5,23.5) K33(-0.5,23.5) K34(0.5,23.5) K35(1.5,23.5) K36(2.5,23.5) K37(3.5,23.5) K38(4.5,23.5) K39(5.5,23.5) K40(6.5,23.5) K41(7.5,23.5) K42(8.5,23.5) K43(9.5,23.5) K44(10.5,23.5) K45(11.5,23.5) K46(12.5,23.5) K47(13.5,23.5) K48(14.5,23.5) K49(15.5,23.5) K50(16.5,23.5) K51(17.5,23.5) K52(18.5,23.5) K53(19.5,23.5) K54(20.5,23.5) K55(21.5,23.5) K56(22.5,23.5) K57(23.5,23.5) K58(24.5,23.5) K59(25.5,23.5) K60(26.5,23.5) K61(27.5,23.5) K62(28.5,23.5) K63(29.5,23.5) K64(30.5,23.5) K65(31.5,23.5) K66(32.5,23.5) L1(-32.5,22.5) L2(-31.5,22.5) L3(-30.5,22.5) L4(-29.5,22.5) L5(-28.5,22.5) L6(-27.5,22.5) L7(-26.5,22.5) L8(-25.5,22.5) L9(-24.5,22.5) L10(-23.5,22.5) L11(-22.5,22.5) L12(-21.5,22.5) L13(-20.5,22.5) L14(-19.5,22.5) L15(-18.5,22.5) L16(-17.5,22.5) L17(-16.5,22.5) L18(-15.5,22.5) L19(-14.5,22.5) L20(-13.5,22.5) L21(-12.5,22.5) L22(-11.5,22.5) L23(-10.5,22.5) L24(-9.5,22.5) L25(-8.5,22.5) L26(-7.5,22.5) L27(-6.5,22.5) L28(-5.5,22.5) L29(-4.5,22.5) L30(-3.5,22.5) L31(-2.5,22.5) L32(-1.5,22.5) L33(-0.5,22.5) L34(0.5,22.5) L35(1.5,22.5) L36(2.5,22.5) L37(3.5,22.5) L38(4.5,22.5) L39(5.5,22.5) L40(6.5,22.5) L41(7.5,22.5) L42(8.5,22.5) L43(9.5,22.5) L44(10.5,22.5) L45(11.5,22.5) L46(12.5,22.5) L47(13.5,22.5) L48(14.5,22.5) L49(15.5,22.5) L50(16.5,22.5) L51(17.5,22.5) L52(18.5,22.5) L53(19.5,22.5) L54(20.5,22.5) L55(21.5,22.5) L56(22.5,22.5) L57(23.5,22.5) L58(24.5,22.5) L59(25.5,22.5) L60(26.5,22.5) L61(27.5,22.5) L62(28.5,22.5) L63(29.5,22.5) L64(30.5,22.5) L65(31.5,22.5) L66(32.5,22.5) M1(-32.5,21.5) M2(-31.5,21.5) M3(-30.5,21.5) M4(-29.5,21.5) M5(-28.5,21.5) M6(-27.5,21.5) M7(-26.5,21.5) M8(-25.5,21.5) M9(-24.5,21.5) M10(-23.5,21.5) M11(-22.5,21.5) M12(-21.5,21.5) M13(-20.5,21.5) M14(-19.5,21.5) M15(-18.5,21.5) M16(-17.5,21.5) M17(-16.5,21.5) M18(-15.5,21.5) M19(-14.5,21.5) M20(-13.5,21.5) M21(-12.5,21.5) M22(-11.5,21.5) M23(-10.5,21.5) M24(-9.5,21.5) M25(-8.5,21.5) M26(-7.5,21.5) M27(-6.5,21.5) M28(-5.5,21.5) M29(-4.5,21.5) M30(-3.5,21.5) M31(-2.5,21.5) M32(-1.5,21.5) M33(-0.5,21.5) M34(0.5,21.5) M35(1.5,21.5) M36(2.5,21.5) M37(3.5,21.5) M38(4.5,21.5) M39(5.5,21.5) M40(6.5,21.5) M41(7.5,21.5) M42(8.5,21.5) M43(9.5,21.5) M44(10.5,21.5) M45(11.5,21.5) M46(12.5,21.5) M47(13.5,21.5) M48(14.5,21.5) M49(15.5,21.5) M50(16.5,21.5) M51(17.5,21.5) M52(18.5,21.5) M53(19.5,21.5) M54(20.5,21.5) M55(21.5,21.5) M56(22.5,21.5) M57(23.5,21.5) M58(24.5,21.5) M59(25.5,21.5) M60(26.5,21.5) M61(27.5,21.5) M62(28.5,21.5) M63(29.5,21.5) M64(30.5,21.5) M65(31.5,21.5) M66(32.5,21.5) N1(-32.5,20.5) N2(-31.5,20.5) N3(-30.5,20.5) N4(-29.5,20.5) N5(-28.5,20.5) N6(-27.5,20.5) N7(-26.5,20.5) N8(-25.5,20.5) N9(-24.5,20.5) N10(-23.5,20.5) N11(-22.5,20.5) N12(-21.5,20.5) N13(-20.5,20.5) N14(-19.5,20.5) N15(-18.5,20.5) N16(-17.5,20.5) N17(-16.5,20.5) N18(-15.5,20.5) N19(-14.5,20.5) N20(-13.5,20.5) N21(-12.5,20.5) N22(-11.5,20.5) N23(-10.5,20.5) N24(-9.5,20.5) N25(-8.5,20.5) N26(-7.5,20.5) N27(-6.5,20.5) N28(-5.5,20.5) N29(-4.5,20.5) N30(-3.5,20.5) N31(-2.5,20.5) N32(-1.5,20.5) N33(-0.5,20.5) N34(0.5,20.5) N35(1.5,20.5) N36(2.5,20.5) N37(3.5,20.5) N38(4.5,20.5) N39(5.5,20.5) N40(6.5,20.5) N41(7.5,20.5) N42(8.5,20.5) N43(9.5,20.5) N44(10.5,20.5) N45(11.5,20.5) N46(12.5,20.5) N47(13.5,20.5) N48(14.5,20.5) N49(15.5,20.5) N50(16.5,20.5) N51(17.5,20.5) N52(18.5,20.5) N53(19.5,20.5) N54(20.5,20.5) N55(21.5,20.5) N56(22.5,20.5) N57(23.5,20.5) N58(24.5,20.5) N59(25.5,20.5) N60(26.5,20.5) N61(27.5,20.5) N62(28.5,20.5) N63(29.5,20.5) N64(30.5,20.5) N65(31.5,20.5) N66(32.5,20.5) P1(-32.5,19.5) P2(-31.5,19.5) P3(-30.5,19.5) P4(-29.5,19.5) P5(-28.5,19.5) P6(-27.5,19.5) P7(-26.5,19.5) P8(-25.5,19.5) P9(-24.5,19.5) P10(-23.5,19.5) P11(-22.5,19.5) P12(-21.5,19.5) P13(-20.5,19.5) P14(-19.5,19.5) P15(-18.5,19.5) P16(-17.5,19.5) P17(-16.5,19.5) P18(-15.5,19.5) P19(-14.5,19.5) P20(-13.5,19.5) P21(-12.5,19.5) P22(-11.5,19.5) P23(-10.5,19.5) P24(-9.5,19.5) P25(-8.5,19.5) P26(-7.5,19.5) P27(-6.5,19.5) P28(-5.5,19.5) P29(-4.5,19.5) P30(-3.5,19.5) P31(-2.5,19.5) P32(-1.5,19.5) P33(-0.5,19.5) P34(0.5,19.5) P35(1.5,19.5) P36(2.5,19.5) P37(3.5,19.5) P38(4.5,19.5) P39(5.5,19.5) P40(6.5,19.5) P41(7.5,19.5) P42(8.5,19.5) P43(9.5,19.5) P44(10.5,19.5) P45(11.5,19.5) P46(12.5,19.5) P47(13.5,19.5) P48(14.5,19.5) P49(15.5,19.5) P50(16.5,19.5) P51(17.5,19.5) P52(18.5,19.5) P53(19.5,19.5) P54(20.5,19.5) P55(21.5,19.5) P56(22.5,19.5) P57(23.5,19.5) P58(24.5,19.5) P59(25.5,19.5) P60(26.5,19.5) P61(27.5,19.5) P62(28.5,19.5) P63(29.5,19.5) P64(30.5,19.5) P65(31.5,19.5) P66(32.5,19.5) R1(-32.5,18.5) R2(-31.5,18.5) R3(-30.5,18.5) R4(-29.5,18.5) R5(-28.5,18.5) R6(-27.5,18.5) R7(-26.5,18.5) R8(-25.5,18.5) R9(-24.5,18.5) R10(-23.5,18.5) R11(-22.5,18.5) R12(-21.5,18.5) R13(-20.5,18.5) R14(-19.5,18.5) R15(-18.5,18.5) R16(-17.5,18.5) R17(-16.5,18.5) R18(-15.5,18.5) R19(-14.5,18.5) R20(-13.5,18.5) R21(-12.5,18.5) R22(-11.5,18.5) R23(-10.5,18.5) R24(-9.5,18.5) R25(-8.5,18.5) R26(-7.5,18.5) R27(-6.5,18.5) R28(-5.5,18.5) R29(-4.5,18.5) R30(-3.5,18.5) R31(-2.5,18.5) R32(-1.5,18.5) R33(-0.5,18.5) R34(0.5,18.5) R35(1.5,18.5) R36(2.5,18.5) R37(3.5,18.5) R38(4.5,18.5) R39(5.5,18.5) R40(6.5,18.5) R41(7.5,18.5) R42(8.5,18.5) R43(9.5,18.5) R44(10.5,18.5) R45(11.5,18.5) R46(12.5,18.5) R47(13.5,18.5) R48(14.5,18.5) R49(15.5,18.5) R50(16.5,18.5) R51(17.5,18.5) R52(18.5,18.5) R53(19.5,18.5) R54(20.5,18.5) R55(21.5,18.5) R56(22.5,18.5) R57(23.5,18.5) R58(24.5,18.5) R59(25.5,18.5) R60(26.5,18.5) R61(27.5,18.5) R62(28.5,18.5) R63(29.5,18.5) R64(30.5,18.5) R65(31.5,18.5) R66(32.5,18.5) T1(-32.5,17.5) T2(-31.5,17.5) T3(-30.5,17.5) T4(-29.5,17.5) T5(-28.5,17.5) T6(-27.5,17.5) T7(-26.5,17.5) T8(-25.5,17.5) T9(-24.5,17.5) T10(-23.5,17.5) T11(-22.5,17.5) T12(-21.5,17.5) T13(-20.5,17.5) T14(-19.5,17.5) T15(-18.5,17.5) T16(-17.5,17.5) T17(-16.5,17.5) T18(-15.5,17.5) T19(-14.5,17.5) T20(-13.5,17.5) T21(-12.5,17.5) T22(-11.5,17.5) T23(-10.5,17.5) T24(-9.5,17.5) T25(-8.5,17.5) T26(-7.5,17.5) T27(-6.5,17.5) T28(-5.5,17.5) T29(-4.5,17.5) T30(-3.5,17.5) T31(-2.5,17.5) T32(-1.5,17.5) T33(-0.5,17.5) T34(0.5,17.5) T35(1.5,17.5) T36(2.5,17.5) T37(3.5,17.5) T38(4.5,17.5) T39(5.5,17.5) T40(6.5,17.5) T41(7.5,17.5) T42(8.5,17.5) T43(9.5,17.5) T44(10.5,17.5) T45(11.5,17.5) T46(12.5,17.5) T47(13.5,17.5) T48(14.5,17.5) T49(15.5,17.5) T50(16.5,17.5) T51(17.5,17.5) T52(18.5,17.5) T53(19.5,17.5) T54(20.5,17.5) T55(21.5,17.5) T56(22.5,17.5) T57(23.5,17.5) T58(24.5,17.5) T59(25.5,17.5) T60(26.5,17.5) T61(27.5,17.5) T62(28.5,17.5) T63(29.5,17.5) T64(30.5,17.5) T65(31.5,17.5) T66(32.5,17.5) U1(-32.5,16.5) U2(-31.5,16.5) U3(-30.5,16.5) U4(-29.5,16.5) U5(-28.5,16.5) U6(-27.5,16.5) U7(-26.5,16.5) U8(-25.5,16.5) U9(-24.5,16.5) U10(-23.5,16.5) U11(-22.5,16.5) U12(-21.5,16.5) U13(-20.5,16.5) U14(-19.5,16.5) U15(-18.5,16.5) U16(-17.5,16.5) U17(-16.5,16.5) U18(-15.5,16.5) U19(-14.5,16.5) U20(-13.5,16.5) U21(-12.5,16.5) U22(-11.5,16.5) U23(-10.5,16.5) U24(-9.5,16.5) U25(-8.5,16.5) U26(-7.5,16.5) U27(-6.5,16.5) U28(-5.5,16.5) U29(-4.5,16.5) U30(-3.5,16.5) U31(-2.5,16.5) U32(-1.5,16.5) U33(-0.5,16.5) U34(0.5,16.5) U35(1.5,16.5) U36(2.5,16.5) U37(3.5,16.5) U38(4.5,16.5) U39(5.5,16.5) U40(6.5,16.5) U41(7.5,16.5) U42(8.5,16.5) U43(9.5,16.5) U44(10.5,16.5) U45(11.5,16.5) U46(12.5,16.5) U47(13.5,16.5) U48(14.5,16.5) U49(15.5,16.5) U50(16.5,16.5) U51(17.5,16.5) U52(18.5,16.5) U53(19.5,16.5) U54(20.5,16.5) U55(21.5,16.5) U56(22.5,16.5) U57(23.5,16.5) U58(24.5,16.5) U59(25.5,16.5) U60(26.5,16.5) U61(27.5,16.5) U62(28.5,16.5) U63(29.5,16.5) U64(30.5,16.5) U65(31.5,16.5) U66(32.5,16.5) V1(-32.5,15.5) V2(-31.5,15.5) V3(-30.5,15.5) V4(-29.5,15.5) V5(-28.5,15.5) V6(-27.5,15.5) V7(-26.5,15.5) V8(-25.5,15.5) V9(-24.5,15.5) V10(-23.5,15.5) V11(-22.5,15.5) V12(-21.5,15.5) V13(-20.5,15.5) V14(-19.5,15.5) V15(-18.5,15.5) V16(-17.5,15.5) V17(-16.5,15.5) V18(-15.5,15.5) V19(-14.5,15.5) V20(-13.5,15.5) V21(-12.5,15.5) V22(-11.5,15.5) V23(-10.5,15.5) V24(-9.5,15.5) V25(-8.5,15.5) V26(-7.5,15.5) V27(-6.5,15.5) V28(-5.5,15.5) V29(-4.5,15.5) V30(-3.5,15.5) V31(-2.5,15.5) V32(-1.5,15.5) V33(-0.5,15.5) V34(0.5,15.5) V35(1.5,15.5) V36(2.5,15.5) V37(3.5,15.5) V38(4.5,15.5) V39(5.5,15.5) V40(6.5,15.5) V41(7.5,15.5) V42(8.5,15.5) V43(9.5,15.5) V44(10.5,15.5) V45(11.5,15.5) V46(12.5,15.5) V47(13.5,15.5) V48(14.5,15.5) V49(15.5,15.5) V50(16.5,15.5) V51(17.5,15.5) V52(18.5,15.5) V53(19.5,15.5) V54(20.5,15.5) V55(21.5,15.5) V56(22.5,15.5) V57(23.5,15.5) V58(24.5,15.5) V59(25.5,15.5) V60(26.5,15.5) V61(27.5,15.5) V62(28.5,15.5) V63(29.5,15.5) V64(30.5,15.5) V65(31.5,15.5) V66(32.5,15.5) W1(-32.5,14.5) W2(-31.5,14.5) W3(-30.5,14.5) W4(-29.5,14.5) W5(-28.5,14.5) W6(-27.5,14.5) W7(-26.5,14.5) W8(-25.5,14.5) W9(-24.5,14.5) W10(-23.5,14.5) W11(-22.5,14.5) W12(-21.5,14.5) W13(-20.5,14.5) W14(-19.5,14.5) W15(-18.5,14.5) W16(-17.5,14.5) W17(-16.5,14.5) W18(-15.5,14.5) W19(-14.5,14.5) W20(-13.5,14.5) W21(-12.5,14.5) W22(-11.5,14.5) W23(-10.5,14.5) W24(-9.5,14.5) W25(-8.5,14.5) W26(-7.5,14.5) W27(-6.5,14.5) W28(-5.5,14.5) W29(-4.5,14.5) W30(-3.5,14.5) W31(-2.5,14.5) W32(-1.5,14.5) W33(-0.5,14.5) W34(0.5,14.5) W35(1.5,14.5) W36(2.5,14.5) W37(3.5,14.5) W38(4.5,14.5) W39(5.5,14.5) W40(6.5,14.5) W41(7.5,14.5) W42(8.5,14.5) W43(9.5,14.5) W44(10.5,14.5) W45(11.5,14.5) W46(12.5,14.5) W47(13.5,14.5) W48(14.5,14.5) W49(15.5,14.5) W50(16.5,14.5) W51(17.5,14.5) W52(18.5,14.5) W53(19.5,14.5) W54(20.5,14.5) W55(21.5,14.5) W56(22.5,14.5) W57(23.5,14.5) W58(24.5,14.5) W59(25.5,14.5) W60(26.5,14.5) W61(27.5,14.5) W62(28.5,14.5) W63(29.5,14.5) W64(30.5,14.5) W65(31.5,14.5) W66(32.5,14.5) Y1(-32.5,13.5) Y2(-31.5,13.5) Y3(-30.5,13.5) Y4(-29.5,13.5) Y5(-28.5,13.5) Y6(-27.5,13.5) Y7(-26.5,13.5) Y8(-25.5,13.5) Y9(-24.5,13.5) Y10(-23.5,13.5) Y11(-22.5,13.5) Y12(-21.5,13.5) Y13(-20.5,13.5) Y14(-19.5,13.5) Y15(-18.5,13.5) Y16(-17.5,13.5) Y17(-16.5,13.5) Y18(-15.5,13.5) Y19(-14.5,13.5) Y20(-13.5,13.5) Y21(-12.5,13.5) Y22(-11.5,13.5) Y23(-10.5,13.5) Y24(-9.5,13.5) Y25(-8.5,13.5) Y26(-7.5,13.5) Y27(-6.5,13.5) Y28(-5.5,13.5) Y29(-4.5,13.5) Y30(-3.5,13.5) Y31(-2.5,13.5) Y32(-1.5,13.5) Y33(-0.5,13.5) Y34(0.5,13.5) Y35(1.5,13.5) Y36(2.5,13.5) Y37(3.5,13.5) Y38(4.5,13.5) Y39(5.5,13.5) Y40(6.5,13.5) Y41(7.5,13.5) Y42(8.5,13.5) Y43(9.5,13.5) Y44(10.5,13.5) Y45(11.5,13.5) Y46(12.5,13.5) Y47(13.5,13.5) Y48(14.5,13.5) Y49(15.5,13.5) Y50(16.5,13.5) Y51(17.5,13.5) Y52(18.5,13.5) Y53(19.5,13.5) Y54(20.5,13.5) Y55(21.5,13.5) Y56(22.5,13.5) Y57(23.5,13.5) Y58(24.5,13.5) Y59(25.5,13.5) Y60(26.5,13.5) Y61(27.5,13.5) Y62(28.5,13.5) Y63(29.5,13.5) Y64(30.5,13.5) Y65(31.5,13.5) Y66(32.5,13.5)
