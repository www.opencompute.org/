# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MODPRSL12: length 191.4
  TOP w0.13: v1(168.21,79.25) 167.81,78.84 R2705.2 ; U123.G16 31.62,160.2 31.89,160.47 32.19,160.47 32.32,160.6 33.79,160.6 34.35,161.16 v1(34.61,161.16)
  SIG10 w0.155: v1(168.21,79.25) 168.72,79.75 168.72,83.56 167.26,85.02 167.26,86.07 166.59,86.74 161.58,86.74 160.28,88.03 157.24,88.03 155.9,86.69 146.44,86.69 143.33,89.81 143.33,95.59 141.76,97.15 139.38,97.15 111.42,125.12 79.71,125.12 77,122.41 72.03,122.41 66.75,127.69 66.75,131.62 66.19,132.19 66.19,136.89 65.1,137.98 65.1,140.79 64.48,141.41 64.48,142 62.78,143.71 62.78,144.79 58.59,148.98 57.97,148.98 55.49,151.46 52.71,151.46 v1(48.21,155.95) 45.42,155.95 39.66,161.71 36.46,161.71 36.04,161.29 34.73,161.29 v1(34.61,161.16)
MODPRSL13: length 240.3
  TOP w0.13: U123.E16 31.67,161.8 32.55,162.68 v1(32.6,162.68)
  SIG10 w0.155: v1(166.56,89.48) 166.56,89.97 165.63,90.9 160.56,90.9 158.93,92.52 157.96,92.52 155.23,89.8 149.53,89.8 146.62,92.71 146.62,97.22 142.38,101.46 137.7,101.46 111.01,128.15 111.01,189.2 106.66,193.55 73.84,193.55 72.75,192.45 68.69,192.45 68.01,191.78 68.01,190.39 66.46,188.85 66.46,187.93 63.88,185.34 56.26,185.34 50.97,180.06 50.97,177.87 49.96,176.86 46.77,176.86 43.99,174.07 43.99,168.81 39.39,164.21 35.94,164.21 35.67,163.94 33.86,163.94 v1(32.6,162.68)
  BOTTOM w0.13: v2(167.2,90.04) 167.12,90.04 v1(166.56,89.48) 166.43,89.35 R2709.1
MODPRSL14: length 286.9
  TOP w0.13: U123.G4 v1(20.85,160.6) ; v1(181.42,80.39) 180.78,79.75 R2718.2
  SIG10 w0.102: 19.1,161.17 19.27,161 20.45,161 v1(20.85,160.6)
  SIG10 w0.155: v1(181.42,80.39) 181.93,80.9 181.93,82.37 181.29,83 181.29,84.33 181.6,84.63 181.88,84.63 183.2,85.95 183.2,89.02 181.16,91.06 179.7,91.06 176.63,94.13 175.3,94.13 173.42,96.01 171.52,96.01 170.3,97.23 164.73,97.23 163.49,98.47 162.2,98.47 157.09,103.58 153.88,103.58 151.71,105.75 149.7,105.75 146.18,109.26 144.97,109.26 144.73,109.51 141.17,109.51 118.09,132.59 118.09,191.47 112.52,197.04 112.52,197.67 108.98,201.22 99.56,201.22 99.41,201.07 80.31,201.07 79.67,201.71 77.28,201.71 76.09,200.53 65.47,200.53 62.99,203 60.45,203 46.04,188.59 46.04,186.08 41.2,181.24 v1(40.59,181.24) 40.59,180.63 34.33,174.37 30.92,174.37 29.53,172.97 27.37,172.97 26.48,172.08 20.38,172.08 20,171.7 20,170.69 18.86,169.54 18.86,166.16 18.99,166.03 18.99,165.17 18.73,164.91 18.73,161.54 19.1,161.17
MODPRSL15: length 263.3
  TOP w0.13: U123.F4 v1(20.85,161.4)
  SIG10 w0.102: 21.15,165.23 21.15,164.21 21.25,164.1 21.25,161.8 v1(20.85,161.4)
  SIG10 w0.155: 21.15,165.23 21.15,167.51 23.97,170.33 32.98,170.33 33.97,171.32 33.97,172.72 34.43,173.17 34.64,173.17 57.42,195.95 59.96,195.95 63.37,199.36 68.55,199.36 69.08,198.83 73.08,198.83 73.56,199.31 76.19,199.31 77.66,200.78 79.28,200.78 80.46,199.61 84.12,199.61 84.42,199.31 94.07,199.31 94.7,199.94 96.43,199.94 97.05,199.31 107.56,199.31 107.89,199.64 109.13,199.64 111.01,197.76 111.01,197.18 117.12,191.06 117.12,132.24 140.83,108.53 141.85,108.53 142.62,107.76 146,107.76 148.95,104.82 150.78,104.82 152.95,102.65 156.67,102.65 162.59,96.72 163.35,96.72 163.78,96.3 169.68,96.3 171.62,94.36 172.86,94.36 174.8,92.42 176.66,92.42 177.39,91.69 v1(177.74,91.69)
  BOTTOM w0.13: v1(177.74,91.69) 177.99,91.69 179.64,90.04 v2(179.77,90.04) R2708.1
MODPRSL16: length 299.7
  TOP w0.13: U124.M15 407.62,177.65 408.5,177.65 408.72,177.42 410.33,177.42 v1(410.78,177.87) ; v1(218,80.26) 217.23,79.5 R2745.2
  SIG10 w0.155: v1(218,80.26) 228.38,69.87 366.74,69.87 368.01,71.14 371.18,71.14 371.4,71.36 380.41,71.36 385.38,76.33 385.38,81.15 386.78,82.55 387.87,82.55 406.79,101.47 410.15,101.47 413.45,104.77 413.45,131.7 411.13,134.02 411.13,141.06 413.35,143.28 413.35,153.57 v1(413.83,154.05) 413.35,154.53 413.35,170.66 412.05,171.96 412.05,173.35 412.56,173.86 412.56,175.64 411.67,176.53 411.67,176.98 v1(410.78,177.87)
MODPRSL17: length 325.9
  TOP w0.13: U124.C11 v1(404.42,185.65)
  SIG10 w0.155: v1(216.22,91.82) 217.75,93.35 238.43,93.35 242.13,89.66 244.03,89.66 248.22,93.86 248.22,98.88 263.33,113.99 263.33,172.43 267.61,176.71 267.61,190.5 271.95,194.84 271.95,213.28 273.65,214.98 273.65,218.72 275.15,220.22 320.25,220.22 333.54,206.92 360.11,206.92 361.89,208.71 382.12,208.71 383.29,207.54 387.69,207.54 398.84,196.39 398.84,192.49 402.04,189.3 402.04,188.6 403.95,186.68 404.18,186.68 404.42,186.44 v1(404.42,185.65)
  BOTTOM w0.13: v1(216.22,91.82) 216.09,91.82 v2(215.58,91.31) 216.22,90.68 R2756.1
MODPRSL18: length 270.6
  TOP w0.13: v1(394.27,183.94) 394.74,183.94 395.44,183.25 396.42,183.25 U124.F2 ; R2753.2 230.57,79.4 v1(231.31,80.13)
  SIG10 w0.155: v1(394.27,183.94) 393.71,184.5 392.14,184.5 390.11,186.53 390.11,187.48 389.85,187.74 389.05,187.74 386.83,189.97 374.59,189.97 373.59,190.96 367.36,190.96 357.68,200.65 330.52,200.65 324.84,194.98 306.95,194.98 306.03,194.06 291.66,194.06 288.99,191.39 288.99,189.94 271.74,172.69 271.74,113.98 258.62,100.86 258.62,93.47 257.11,91.96 257.11,86.73 255.97,85.59 255.97,85.2 254.18,83.41 252.89,83.41 252.42,82.93 252.42,82.03 248.62,78.23 240.22,78.23 239.46,77.47 234.76,77.47 232.09,80.13 v1(231.31,80.13)
MODPRSL19: length 296.3
  TOP w0.13: U124.E3 v1(397.22,184.05)
  SIG10 w0.155: v1(397.22,184.05) 395.16,186.1 395.16,187.07 394.27,187.96 393.64,187.96 392.64,188.95 392.64,190.04 389.39,193.29 383.74,193.29 383.12,193.91 376.37,193.91 375.91,194.37 369.4,194.37 359.8,203.98 332.22,203.98 319.2,216.99 301.69,216.99 301.51,216.81 293.48,216.81 293.04,216.37 284.65,216.37 281.86,213.59 281.86,211 279.69,208.83 279.69,186.05 279.34,185.7 279.34,184.72 267.51,172.9 267.51,171.04 266.06,169.58 266.06,113 253.04,99.99 253.04,95.68 251.49,94.13 251.49,88.39 249.32,86.23 249.32,85.76 248.39,84.83 240.18,84.83 237.08,87.93 233.99,87.93 233.65,88.26 v1(230.31,88.26)
  BOTTOM w0.13: v2(230.7,87.5) 230.31,87.88 v1(230.31,88.26) 230.31,88.52 230.09,88.75 R2755.1
MODPRSL20: length 235.2
  TOP w0.13: R2786.2 261.43,81.15 v1(262.19,81.91) ; U124.K2 396.42,179.25 395.09,179.25 394.78,179.56 393.91,179.56 393.6,179.87 392.71,179.87 v1(392.24,180.34)
  SIG10 w0.155: v1(262.19,81.91) 264.07,81.91 265.28,83.13 265.28,100.03 276.62,111.36 276.62,171.15 v1(288.1,182.63) 292,186.54 308.78,186.54 310.26,188.02 322.58,188.02 323.65,189.09 327.56,189.09 331.6,193.13 348.33,193.13 357.78,183.68 363.36,183.68 363.67,183.99 388.08,183.99 391.74,180.34 v1(392.24,180.34)
MODPRSL21: length 231
  TOP w0.13: U124.H2 396.42,181.65 395.06,181.65 394.72,181.99 v1(394.4,181.99)
  SIG10 w0.155: v1(394.4,181.99) 394.19,181.78 391.63,181.78 385.89,187.53 364.94,187.53 363.82,188.64 363.82,190.19 357.94,196.08 354.99,196.08 354.37,196.7 330.67,196.7 325.71,191.74 309.75,191.74 307.87,189.86 291.97,189.86 274.11,172.01 274.11,112.49 262.7,101.08 262.7,88.9 v1(262.06,88.26)
  BOTTOM w0.13: v1(262.06,88.26) 262.03,88.26 v2(261.51,88.78) 261.06,88.78 261.02,88.75 R2790.1
MODPRSL22: length 198
  TOP w0.13: v1(275.12,82.04) 274.51,81.43 274.51,80.52 274.76,80.26 R2785.2 ; U124.N3 v1(397.22,176.85)
  SIG10 w0.155: v1(275.12,82.04) 275.86,82.78 275.86,91.01 276.55,91.7 276.55,93.22 280.93,97.6 280.93,101.67 296.79,117.52 v1(341.31,117.52) 351.84,117.52 358.66,124.35 358.66,135.45 360.73,137.52 360.73,145.57 361.97,146.81 361.97,155.02 363.21,156.26 363.21,159.51 365.3,161.6 365.3,170.18 371.18,176.07 379.91,176.07 380.56,176.71 382.88,176.71 383.76,177.59 389.92,177.59 391.62,175.89 394.65,175.89 395.61,176.85 v1(397.22,176.85)
MODPRSL23: length 189.8
  TOP w0.13: v1(393.26,177.8) 393.81,177.25 U124.N1
  SIG10 w0.155: v1(273.75,90.42) 274.11,90.79 274.11,91.18 274.64,91.71 274.64,99.31 279.34,104.01 281.52,104.01 296.12,118.61 350.11,118.61 357.73,126.22 357.73,140.11 358.84,141.22 358.84,145.38 361.04,147.58 361.04,155.79 362.28,157.03 362.28,162.3 363.84,163.86 363.84,165.16 364.37,165.69 364.37,170.73 370.96,177.33 378.7,177.33 379.92,178.55 390.31,178.55 391.56,177.29 392.45,177.29 392.96,177.8 v1(393.26,177.8)
  BOTTOM w0.13: v2(274.38,90.93) 274.26,90.93 v1(273.75,90.42) 273.24,89.91 273.24,88.9 273.39,88.75 R2789.1
MODPRSL24: length 164.8
  TOP w0.13: U124.P5 v1(398.82,176.05) ; R2825.2 312.97,78.84 313.63,79.5 v1(313.63,80.64)
  SIG10 w0.155: v1(313.63,80.64) 315.66,82.68 315.66,93.25 323.39,100.98 370.51,100.98 371.88,102.35 371.88,129.45 372.81,130.38 372.81,135.76 373.48,136.43 373.48,141.05 375.83,143.4 375.83,149.79 378.86,152.82 381.63,152.82 383.23,154.43 385.38,154.43 v1(394.97,164.02) 397.91,166.96 397.91,168.81 399.38,170.28 399.38,173.68 398.82,174.24 v1(398.82,176.05)
MODPRSL25: length 162.1
  TOP w0.13: U124.T4 398.42,174.5 397.32,173.4 397.32,172.71 396.81,172.2 v1(396.81,171.96)
  SIG10 w0.155: v1(396.81,171.96) 396.81,171.7 395.64,170.53 392.47,170.53 389.19,167.26 387.84,167.26 387.53,166.95 387.53,166.46 387.12,166.04 383.35,166.04 383.04,165.73 383.04,164.32 380.09,161.37 377.61,161.37 376.68,160.44 376.68,160.08 375.6,159 375.6,157.82 373.19,155.41 373.19,154.6 370.27,151.67 370.27,148.6 369.71,148.05 369.71,144.25 367.82,142.36 367.82,134.8 366.08,133.06 366.08,121.66 365.6,121.18 365.6,120.29 365.19,119.89 363.89,119.89 351.92,107.92 338.57,107.92 337.64,106.99 321.4,106.99 305.5,91.09 305.5,82.15 307.01,80.64 v1(307.91,80.64)
  BOTTOM w0.13: R2838.1 308.7,78.84 308.55,78.99 308.55,80.01 v1(307.91,80.64) 307.91,81.28 v2(308.17,81.53)
MODPRSL26: length 162.2
  TOP w0.13: v1(405.09,171.83) 405.54,172.28 405.54,173.53 405.62,173.61 U124.T13 ; v1(326.83,80.26) 326.2,79.63 R2835.2
  SIG10 w0.155: v1(405.09,171.83) 405.09,169.68 404.78,169.37 404.78,163.75 393.34,152.3 393.34,151.53 393.11,151.3 392.35,151.3 386.46,145.41 384.59,145.41 384.28,145.1 384.28,142.18 381.8,139.7 381.8,136.74 380.87,135.81 380.87,134.54 381.33,134.08 381.33,130.69 381.02,130.38 381.02,126.46 378.91,124.34 378.91,117.06 379.75,116.21 379.75,109.27 380.25,108.77 380.25,99.64 379.9,99.29 379.9,92.4 373.43,85.93 370.14,85.93 369.66,85.45 369.14,85.45 368.91,85.68 361.84,85.68 359.26,88.26 335.72,88.26 334.2,86.74 329.88,86.74 329.37,86.23 329.37,82.19 327.44,80.26 v1(326.83,80.26)
  BOTTOM w0.13: v1(405.09,171.83) 405.09,171.42 v2(405.96,170.56)
MODPRSL27: length 159.1
  TOP w0.13: U124.R10 403.62,175.25 403.62,174.32 403.37,174.07 403.37,172.29 v1(402.91,171.83)
  SIG10 w0.155: v1(325.18,90.55) 325.18,90.81 330.05,95.68 356.95,95.68 364.28,88.35 367.94,88.35 368.48,88.89 372.48,88.89 377,93.42 377,106.36 376.22,107.15 376.22,109.59 375.85,109.95 375.85,111.43 376.83,112.41 376.83,114.17 375.78,115.23 375.78,126.42 377.61,128.25 377.61,133.95 378.1,134.44 378.1,139.78 381.33,143.01 381.33,147.04 384.2,149.91 386.87,149.91 401.97,165 401.97,169.48 402.56,170.08 402.56,171.48 v1(402.91,171.83)
  BOTTOM w0.13: R2837.1 325.56,88.75 325.69,88.87 325.69,89.79 v2(326.07,90.17) 325.69,90.55 v1(325.18,90.55)
MODPRSL28: length 134.8
  TOP w0.13: v1(407.61,171.83) 407.48,171.83 407.1,172.21 407.1,173.38 406.42,174.06 U124.T14
  SIG10 w0.155: v1(356.43,82.93) 356.75,82.6 362.03,82.6 363.55,81.07 364.49,81.07 364.82,81.4 366.92,81.4 367.23,81.72 370.04,81.72 370.39,82.07 376.21,82.07 382.57,88.43 382.57,90.72 383.97,92.11 383.97,97.96 390.89,104.89 400.61,104.89 405.04,109.31 405.04,142.93 407.49,145.39 407.49,171.26 407.61,171.38 v1(407.61,171.83)
  BOTTOM w0.13: R2865.2 356.81,82.67 356.55,82.93 v1(356.43,82.93) 356.43,83.69 v2(356.55,83.82)
MODPRSL29: length 147.9
  TOP w0.13: v1(409.77,176.63) 409.63,176.77 408.32,176.77 408.24,176.85 407.62,176.85 U124.N15
  SIG10 w0.155: v1(409.77,176.63) 409.77,175.89 410.27,175.38 410.27,171.72 408.91,170.36 408.91,144.48 406.94,142.51 406.94,108.73 401.7,103.49 396.3,103.49 385.67,92.86 385.67,88.65 382.31,85.29 381.41,85.29 380.05,83.93 380.05,80.29 378.64,78.88 373.2,78.88 373.06,78.74 364.67,78.74 363.84,79.56 362.84,79.56 361.25,77.98 352.08,77.98 351.82,77.72 v1(351.22,77.72)
  BOTTOM w0.13: R2872.1 351.09,77.85 v1(351.22,77.72) 351.6,77.34 v2(351.6,76.83)
MODPRSL30: length 115.9
  TOP w0.13: R2869.2 v1(377.63,79.5) ; U124.P7 v1(400.42,176.05)
  SIG8 w0.155: v1(400.42,176.05) 400.55,175.92 400.55,175.16 399.22,173.84 399.22,171.07 398.34,170.18 398.34,163.96 382.58,148.21 379.17,148.21 374.84,143.88 374.84,137.03 373.82,136.01 373.82,104.77 380.56,98.04 380.56,82.42 v1(377.63,79.5)
  BOTTOM w0.13: v1(377.63,79.5) 377.76,79.5 v2(378.4,80.13)
MODPRSL31: length 117.8
  TOP w0.13: U124.L4 v1(398.02,178.45)
  SIG8 w0.102: v1(398.02,178.45) 397.62,178.05 397.62,175.63
  SIG8 w0.155: v1(375.09,80.26) 378.39,83.56 378.39,97.29 372.17,103.5 372.17,137.41 373.32,138.55 373.32,144.68 378.37,149.73 381.78,149.73 396.18,164.13 396.18,173.73 397.62,175.18 397.62,175.63
  BOTTOM w0.13: R2873.1 373.57,79.37 v2(374.33,80.13) 374.46,80.26 v1(375.09,80.26)
MODPRSL32: length 102.5
  TOP w0.13: R2607.1 v1(16.19,83.82) ; v1(17.11,161.16) 17.6,161.16 18.15,160.6 19.25,160.6 U123.G2
  SIG4 w0.155: v1(16.19,83.82) 15.3,84.71 15.3,85.98 15.05,86.23 15.05,89.66 13.78,90.93 13.78,98.35 9.94,102.18 6.84,102.18 5.15,103.88 5.15,112.78 6.29,113.92 6.29,124.46 7,125.17 7,127.59 6.45,128.14 6.45,162.25 8.54,164.34 13.4,164.34 15.56,162.18 16.32,162.18 17.11,161.39 v1(17.11,161.16)
MODPRSL33: length 112.1
  TOP w0.13: U123.D1 18.45,162.6 17.42,163.62 16.55,163.62 v1(16.09,164.08) ; R2611.2 v1(17.21,79.5)
  SIG4 w0.155: v1(17.21,79.5) 16.57,78.86 15.02,78.86 13.52,80.36 13.52,84.13 12.58,85.08 12.58,87.46 12.11,87.93 12.11,97.69 9.86,99.94 6.29,99.94 3.69,102.55 3.69,124.28 5.13,125.73 5.13,163.62 7.75,166.24 v1(8.95,166.24) 9.59,166.88 13.3,166.88 v1(16.09,164.08)
MODPRSL34: length 126.7
  TOP w0.13: U123.L2 19.25,156.6 17.72,156.6 17.55,156.77 16.55,156.77 v1(16.09,157.22) ; R2608.1 v1(56.45,85.98)
  SIG10 w0.155: v1(16.09,157.22) 15.74,157.22 13.45,159.51 8.45,159.51 5.47,156.54 5.47,133.96 9.98,129.45 14.11,129.45 20.63,122.93 20.63,101.72 21.4,100.95 21.4,98.95 23.3,97.05 23.3,96.26 24.14,95.43 24.9,95.43 27.96,92.37 33.11,92.37 33.63,92.37 33.85,92.58 35.12,92.58 36.28,91.42 37.61,91.42 41.78,87.25 46.51,87.25 47.53,86.23 53,86.23 53.33,86.56 55.87,86.56 v1(56.45,85.98)
  BOTTOM w0.13: v2(56.96,84.86) 56.96,85.47 v1(56.45,85.98)
MODPRSL35: length 134.6
  TOP w0.13: R2612.2 42,78.84 42.1,78.74 42.1,77.59 41.72,77.21 v1(41.47,77.21) ; U123.H1 18.78,159.48 17.79,159.48 17.51,159.76 v1(17.08,159.76)
  SIG10 w0.155: v1(17.08,159.76) 16.52,159.2 15.78,159.2 12.67,162.3 12.26,162.3 12,162.05 8.35,162.05 4.05,157.75 4.05,133.02 4.83,132.24 4.83,123.72 4,122.89 4,101.47 5.55,99.92 13.42,99.92 15.88,97.47 17.39,97.47 23.89,90.97 33.68,90.97 34.71,89.94 37,89.94 42.23,84.72 42.23,83.18 42.71,82.7 43.5,82.7 44.49,81.7 44.49,80.24 v1(41.47,77.21)
  BOTTOM w0.13: v2(41.31,78.48) 41.47,78.33 v1(41.47,77.21)
MODPRSL36: length 106.8
  TOP w0.13: v1(17.11,153.54) 17.84,153.54 18.5,154.2 19.25,154.2 U123.P2
  SIG10 w0.155: v1(71.44,89.41) 68.52,89.41 66.74,91.19 64.57,91.19 61.65,94.11 58.51,94.11 57.72,94.9 52.71,94.9 50.84,96.77 49.72,96.77 45.66,100.84 41.97,100.84 41.45,101.36 39.59,101.36 38.35,102.6 35.96,102.6 34.42,104.14 32.58,104.14 32.32,104.39 32.32,106.24 32.04,106.52 30.03,106.52 27.81,108.73 27.81,130.85 22.1,136.56 22.1,141.9 17.22,146.78 17.22,150.64 17.54,150.96 17.54,153.11 v1(17.11,153.54)
  BOTTOM w0.13: R2645.1 v1(71.44,89.41) v2(71.44,90.29)
MODPRSL37: length 120.3
  TOP w0.13: v1(19.65,149.22) 20.48,150.05 20.48,151.42 21.65,152.6 21.65,153.4 U123.R5 ; R2649.2 v1(71.44,79.5)
  SIG10 w0.155: v1(71.44,79.5) 71.95,78.99 72.71,78.99 73.39,79.67 73.39,86.5 75.25,88.36 75.25,90.96 73.3,92.92 64.7,92.92 62.19,95.42 59.06,95.42 55.93,98.55 50.45,98.55 45.26,103.73 42.01,103.73 41.39,104.35 40.77,104.35 40.46,104.04 38.89,104.04 38.29,104.65 35.78,104.65 32.36,108.07 31.94,108.07 29.64,110.38 29.64,131.54 23.97,137.21 23.97,143.3 22.84,144.43 22.84,146.38 20,149.22 v1(19.65,149.22)
  BOTTOM w0.13: v2(17.46,149.6) 17.59,149.73 19.14,149.73 v1(19.65,149.22)
MODPRSL38: length 119.2
  TOP w0.13: R2646.1 92.55,77.06 93.28,76.32 v1(94.04,76.32) ; U123.R10 26.45,153.4 26.45,151.99 26.08,151.62 26.08,150.55 v1(25.51,149.98)
  SIG10 w0.155: v1(94.04,76.32) 93.41,75.69 91.38,75.69 90.96,76.11 90.96,78.9 90.49,79.37 90.49,85.34 86.93,88.89 86.93,90.33 77.86,99.4 70.55,99.4 68.22,101.74 67,101.74 62.77,105.97 61.47,105.97 52.49,114.96 52.49,118.82 51.99,119.32 51.99,122.07 36.9,137.16 36.9,137.91 32.66,142.15 31.52,142.15 29.65,144.02 29,144.02 28.64,144.38 28.64,145.31 28.22,145.72 28.22,146.79 26.1,148.91 26.1,149.4 v1(25.51,149.98)
  BOTTOM w0.13: v2(93.15,76.32) v1(94.04,76.32)
MODPRSL39: length 121.9
  TOP w0.13: v1(86.7,80.39) 86.26,79.95 85.6,79.95 85.28,79.63 85.28,78.99 85.13,78.84 R2650.2 ; v1(23.36,151.13) 23.36,151.53 24.05,152.23 24.05,153.4 U123.R8
  SIG10 w0.155: v1(86.7,80.39) 87.44,81.13 87.44,82.7 87.21,82.93 87.21,85.57 85.92,86.87 84.6,86.87 81.52,89.94 81.52,92.3 76.29,97.53 67.42,97.53 61.92,103.04 53.28,103.04 47.23,109.09 37.28,109.09 34.42,111.95 34.42,114.11 33.96,114.58 33.96,114.89 34.47,115.4 34.47,133.27 34.69,133.49 34.69,134.76 32.56,136.88 32.56,138.29 31.94,138.9 30.55,138.9 27.49,141.96 27.49,142.59 25.67,144.4 25.67,146.82 23.94,148.55 23.94,150.54 v1(23.36,151.13)
MODPRSL40: length 126.2
  TOP w0.13: v1(29.4,149.22) 28.85,149.77 28.85,153.4 U123.R13
  SIG10 w0.155: v1(29.4,149.22) 29.91,149.22 31.31,147.83 33.56,147.83 48.35,133.03 48.35,130.03 56.53,121.85 56.53,120.77 59.91,117.38 60.61,117.38 67.49,110.5 76.95,110.5 94.92,92.53 115.68,92.53 118.78,89.43 v1(120.97,89.43)
  BOTTOM w0.13: R2686.1 121.22,89.18 v1(120.97,89.43) v2(120.97,90.29)
MODPRSL41: length 139.8
  TOP w0.13: U123.R14 29.65,153.4 29.65,152.27 30.49,151.43 v1(30.49,151.13) ; R2689.2 v1(121.22,79.5)
  SIG10 w0.155: v1(30.49,151.13) 30.8,151.13 31.31,150.62 32.93,150.62 50.1,133.45 50.1,130.14 57.87,122.37 57.87,121.48 60.43,118.91 60.93,118.91 67.75,112.1 77.21,112.1 95.03,94.28 119.73,94.28 123.51,90.5 123.51,88.3 124.78,87.04 124.78,79.75 124.4,79.37 123.76,79.37 123.38,78.99 121.73,78.99 v1(121.22,79.5)
MODPRSL42: length 141.1
  TOP w0.13: v1(34.61,156.08) 34.2,156.49 31.84,156.49 31.73,156.6 30.45,156.6 U123.L15
  SIG10 w0.155: v1(134.56,89.41) 133.89,90.07 133.89,91.18 124.59,100.48 97.75,100.48 79.04,119.19 69.94,119.19 62.5,126.63 62.5,135.18 60.92,136.76 60.92,138.15 60.64,138.43 59.12,138.43 58.23,139.32 58.23,140.21 56.32,142.11 54.93,142.11 51.75,145.29 48.7,145.29 40.21,153.78 36.9,153.78 35.91,154.77 35.91,154.81 34.64,156.08 v1(34.61,156.08)
  BOTTOM w0.13: v2(134.43,90.29) 134.43,89.53 v1(134.56,89.41) R2685.1
MODPRSL43: length 153
  TOP w0.13: R2694.2 134.18,78.84 134.05,78.97 134.05,79.63 v1(134.89,80.46) ; U123.P12 v1(28.05,154.2)
  SIG10 w0.155: v1(28.05,154.2) 28.05,154 28.77,153.29 29.82,153.29 31.04,152.07 33.66,152.07 34.1,151.62 34.1,150.69 40.9,143.89 41.97,143.89 42.99,142.87 42.99,142.49 45.03,140.45 45.58,140.45 45.89,140.14 45.89,138.9 48.83,135.96 57.51,135.96 60.16,133.31 60.16,125.25 68.58,116.83 77.53,116.83 96.2,98.16 122.15,98.16 128.09,92.22 129.24,91.07 129.24,88.38 131.41,86.2 131.41,83.69 132.3,82.8 133.57,82.8 134,83.23 134.64,83.23 135.27,82.6 135.27,80.85 v1(134.89,80.46)
  BOTTOM w0.13: v1(134.89,80.46) 134.73,80.46 v2(134.05,81.15)
MODPRSL44: length 243.9
  TOP w0.13: U123.H14 v1(29.65,159.8)
  SIG10 w0.155: v1(167.07,90.8) 166.56,91.31 160.69,91.31 159.09,92.91 157.7,92.91 155,90.21 149.76,90.21 147,92.96 147,97.38 142.54,101.85 137.86,101.85 111.39,128.31 111.39,189.38 106.84,193.93 71.08,193.93 70.68,194.33 68.54,194.33 67.88,193.67 64.05,193.67 50.59,180.21 50.59,178.03 49.8,177.24 46.62,177.24 43.61,174.23 43.61,168.97 39.97,165.33 36.23,165.33 35.62,164.72 33.46,164.72 30.67,161.92 30.67,160.82 v1(29.65,159.8)
  BOTTOM w0.13: R2726.1 165.42,89.79 v2(165.8,90.17) 166.43,90.8 v1(167.07,90.8)
MODPRSL45: length 185
  TOP w0.13: U123.K14 v1(29.65,157.4)
  SIG10 w0.155: v1(163.64,79.75) 163,79.75 160.65,77.39 141.02,77.39 139.64,78.78 139.64,83.27 137.46,85.45 136.53,85.45 135.95,86.02 135.95,88.77 136.22,89.04 136.22,90.56 135.75,91.03 135.75,91.96 108.48,119.23 82.28,119.23 80.95,120.55 70.9,120.55 64.88,126.57 64.88,129.98 63.84,131.02 63.84,135.83 62.47,137.2 62.47,139.78 60.64,141.6 59.78,141.6 57.24,144.14 55.94,144.14 52.77,147.32 50.86,147.32 50.1,148.08 50.1,148.71 48.29,150.53 46.97,150.53 40.44,157.06 36.41,157.06 35.38,158.09 32.3,158.09 31.61,157.4 v1(29.65,157.4)
  BOTTOM w0.13: v1(163.64,79.75) 163.97,80.08 v2(164.53,80.08) 164.91,79.7 164.91,78.99 165.06,78.84 R2729.2
MODPRSL46: length 263.5
  TOP w0.13: U123.F5 v1(21.65,161.4)
  SIG10 w0.102: v1(21.65,161.4) 22.05,161.8 22.05,164.19 22.16,164.3 22.16,165.23
  SIG10 w0.155: v1(178.09,88.92) 178.05,88.96 177.79,88.96 176.19,90.56 176.19,91.34 175.57,91.96 174.66,91.96 172.83,93.79 171.57,93.79 169.53,95.83 163.7,95.83 163.19,96.34 161.58,96.34 160.9,97.02 159.35,97.02 157.44,98.93 157.44,100.48 155.74,102.18 152.64,102.18 150.47,104.35 148,104.35 146.45,105.91 145.51,105.91 144.23,107.18 139.77,107.18 116.65,130.3 116.65,190.42 109.79,197.28 109.79,198.42 109.08,199.13 108.01,199.13 107.81,198.93 96.9,198.93 96.27,199.56 94.86,199.56 94.23,198.93 84.26,198.93 83.97,199.23 80.3,199.23 79.97,199.56 77.34,199.56 76.71,198.93 73.72,198.93 73.24,198.45 68.92,198.45 68.39,198.98 63.53,198.98 60.12,195.57 58.17,195.57 56.6,194 56.6,193.3 55.6,192.3 54.31,192.3 35.88,173.87 35.88,170.69 35.09,169.89 26,169.89 22.16,166.05 22.16,165.23
  BOTTOM w0.13: R2727.1 178.27,88.75 v1(178.09,88.92) 178.09,89.81 v2(178.24,89.96)
MODPRSL47: length 202.5
  TOP w0.13: v1(176.85,80.03) 177,79.88 177.74,79.88 178.24,79.37 178.24,78.99 178.4,78.84 R2730.2 ; U123.G15 30.45,160.6 31.56,160.6 31.75,160.79 32.03,160.79 32.43,161.19 v1(32.63,161.19)
  SIG10 w0.155: v1(176.85,80.03) 175.04,80.03 173.8,81.28 173.8,82.55 172.78,83.56 172.15,83.56 171.7,84.01 171.7,84.52 168.34,87.88 166.57,87.88 166.05,88.39 161.24,88.39 159.53,90.1 158.53,90.1 157.91,89.48 156.82,89.48 155.12,87.77 147.06,87.77 144.89,89.94 144.89,96.34 142.61,98.62 141.24,98.62 140.52,99.34 140.52,99.61 139.6,100.53 137.31,100.53 111.49,126.35 79.29,126.35 76.28,123.34 72.81,123.34 69.28,126.87 69.28,130.38 68.51,131.16 68.51,136.43 67.11,137.82 67.11,140.3 66.26,141.15 66.26,143.31 65.88,143.69 65.88,144.75 52.39,158.24 47.82,158.24 44.91,161.14 42.21,161.14 40.72,162.64 35.69,162.64 35.28,162.22 34.04,162.22 33.8,161.99 33.43,161.99 v1(32.63,161.19)
MODPRSL48: length 324.3
  TOP w0.13: U124.D11 v1(404.42,184.85)
  SIG10 w0.102: v1(404.42,184.85) 404.02,185.25 404.02,185.96 403.67,186.31
  SIG10 w0.155: v1(214.57,89.66) 216.09,91.18 217.74,91.18 219.45,92.89 238.21,92.89 241.82,89.28 245.56,89.28 247,90.72 247,91.86 248.73,93.59 248.73,98.85 263.73,113.85 263.73,172.29 273.49,182.06 273.49,183.64 273.8,183.95 273.8,208.32 276.75,211.26 276.75,213.12 283.44,219.81 320.12,219.81 333.47,206.46 360.42,206.46 362.28,208.33 367.98,208.33 370.14,206.16 374.63,206.16 375.62,207.16 387.53,207.16 397.7,196.99 397.7,192.53 400.49,189.74 400.49,189.31 400.79,189.02 401.24,189.02 401.54,188.72 401.54,188.55 403.67,186.43 403.67,186.31
  BOTTOM w0.13: v1(214.57,89.66) 214.95,90.04 v2(215.46,90.04) 215.46,89 R2765.1
MODPRSL49: length 319.2
  TOP w0.13: U124.B1 395.16,186.9 395.16,187.7 394.53,188.34 394.53,189.1 v1(394.02,189.61)
  SIG10 w0.155: v1(394.02,189.61) 394.02,190.21 389.39,194.84 385.36,194.84 385.05,195.15 383.5,195.15 383.19,194.84 377.3,194.84 376.84,195.3 370.02,195.3 360.42,204.91 332.84,204.91 319.51,218.23 284.89,218.23 280.93,214.27 280.93,211.9 276.67,207.64 276.67,194.76 275.2,193.29 275.2,181.9 265.05,171.75 265.05,113.31 252.11,100.37 252.11,96.81 250.56,95.26 250.56,89.17 248.8,87.41 239.61,87.41 237.55,89.47 237.55,90.1 236.31,91.34 234.79,91.34 232.73,89.28 229.76,89.28 229.34,88.86 226.24,88.86 225.38,88.01 215.2,88.01 214.57,87.37 214.57,81.28 v1(213.68,80.39)
  BOTTOM w0.13: v1(213.68,80.39) 214.06,80.39 v2(214.44,80.01) 214.44,79.75 214.19,79.5 R2769.2
MODPRSL50: length 306.9
  TOP w0.13: U124.D8 v1(401.22,184.85)
  SIG10 w0.102: 399.93,186.26 400.01,186.17 400.01,185.46 400.22,185.25 400.81,185.25 v1(401.22,184.85)
  SIG10 w0.155: v1(228.16,89.41) 230.55,91.8 236.46,91.8 238.32,89.94 238.32,89.24 239.77,87.79 248.41,87.79 250.1,89.48 250.1,95.34 251.65,96.89 251.65,100.45 264.66,113.47 264.66,171.91 274.73,181.98 274.73,193.6 276.11,194.98 276.11,207.97 280.47,212.33 280.47,214.37 284.8,218.7 319.67,218.7 332.99,205.37 361.27,205.37 361.41,205.23 388.14,205.23 395.03,198.34 395.03,193.38 398.38,190.04 398.38,187.56 399.67,186.26 399.93,186.26
  BOTTOM w0.13: v2(228.66,90.17) 228.16,89.66 v1(228.16,89.41) 228.54,89.02 R2766.1
MODPRSL51: length 296
  TOP w0.13: R2770.2 226.73,80.64 v1(226.63,80.64) ; v1(410.78,176.63) 410.32,176.17 409.18,176.17 408.98,176.37 408.09,176.37 U124.P16
  SIG10 w0.155: v1(410.78,176.63) 412.18,175.23 412.18,174.24 411.55,173.61 411.55,171.75 412.96,170.34 412.96,143.44 411.13,141.61 411.13,141.61 410.74,141.22 410.74,133.64 412.18,132.2 412.18,116.28 412.97,115.5 412.97,104.92 409.9,101.86 406.57,101.86 387.89,83.18 386.87,83.18 385,81.31 385,76.72 380.56,72.28 374.83,72.28 373.83,73.28 367.73,73.28 364.73,70.28 228.7,70.28 225.31,73.68 225.31,79.32 v1(226.63,80.64)
  BOTTOM w0.13: v1(410.78,176.63) v2(410.78,175.77)
MODPRSL52: length 232.4
  TOP w0.13: U124.G3 v1(397.22,182.45)
  SIG10 w0.155: v1(397.22,182.45) 397.17,182.5 393.76,182.5 393.43,182.16 391.81,182.16 386.06,187.91 366.72,187.91 358.09,196.54 355.46,196.54 354.06,197.94 331.29,197.94 325.55,192.2 309.44,192.2 308.37,191.13 292,191.13 291.47,190.6 291.47,189.91 273.65,172.09 273.65,112.57 261.49,100.41 261.49,89.97 v1(261.3,89.79)
  BOTTOM w0.13: R2809.1 259.4,89.28 260.41,90.29 v2(260.67,90.29) 260.79,90.29 v1(261.3,89.79)
MODPRSL53: length 245.4
  TOP w0.13: U124.F1 395.38,182.85 394.74,183.49 393.92,183.49 393.46,183.94 v1(393.26,183.94) ; v1(257.62,81.4) 258.89,80.13 258.89,79.12 259.17,78.84 R2811.2
  SIG10 w0.155: v1(257.62,81.4) 256.86,82.17 256.86,85.76 257.75,86.65 257.75,88.65 258.48,89.38 258.48,92.59 259.55,93.66 259.55,101.25 272.13,113.83 272.13,172.54 289.5,189.91 289.5,190.75 292.42,193.68 306.57,193.68 307.43,194.53 324.94,194.53 330.67,200.26 357.52,200.26 367.29,190.5 373.43,190.5 374.35,189.58 386.49,189.58 391.97,184.1 393.1,184.1 v1(393.26,183.94)
  BOTTOM w0.13: v2(258.64,81.28) 257.75,81.28 v1(257.62,81.4)
MODPRSL54: length 194.5
  TOP w0.13: U124.N2 396.42,176.85 395.8,176.85 395.72,176.92 393.12,176.92 v1(392.24,177.8)
  SIG10 w0.155: v1(392.24,177.8) 391.6,177.8 388.93,180.46 386.76,180.46 386.14,179.84 378.81,179.84 378.32,179.35 371.18,179.35 363.08,171.25 363.08,166.92 360.88,164.72 360.88,157.5 358.71,155.33 358.71,153.78 356.41,151.48 356.41,142.03 355.61,141.23 355.61,137.98 356.41,137.18 356.41,126.71 350.86,121.15 345.14,121.15 344.15,120.16 295.12,120.16 282.14,107.17 280.49,107.17 272.48,99.16 272.48,90.68 v1(272.73,90.42)
  BOTTOM w0.13: R2810.1 272.38,88.75 272.22,88.9 272.22,89.91 v1(272.73,90.42) 272.61,90.55 v2(272.61,91.18)
MODPRSL55: length 208.4
  TOP w0.13: R2812.2 272.4,78.84 272.22,79.02 272.22,80.52 v1(271.21,81.53) ; v1(393.26,179.07) 393.26,178.81 393.79,178.28 394.48,178.28 394.72,178.05 U124.M1
  SIG10 w0.155: v1(393.26,179.07) 393,179.32 391.4,179.32 388.23,182.5 386.29,182.5 385.39,181.59 368.21,181.59 367.22,180.6 367.22,178.56 362.43,173.77 357.95,173.77 355.61,171.43 355.61,153.96 354.53,152.87 354.53,146.5 352.98,144.95 352.98,140.46 352.16,139.64 352.16,135.58 352.87,134.87 352.87,132.14 v1(347.12,126.4) 343.36,122.64 292.4,122.64 269.47,99.71 269.47,83.27 v1(271.21,81.53)
MODPRSL56: length 160.7
  TOP w0.13: U124.T3 397.62,174.62 396.25,173.24 396.25,171.9 v1(395.41,171.07)
  SIG10 w0.155: v1(307.91,79.5) 307.4,80.01 307.1,80.01 304.99,82.12 304.99,91.12 321.26,107.39 331.55,107.39 333.12,108.96 352.42,108.96 365.57,122.11 365.57,133.09 367.43,134.96 367.43,142.7 369.13,144.39 369.13,151.89 370.39,153.16 370.94,153.16 372.81,155.02 372.81,155.7 374.59,157.48 374.59,159 375.64,160.06 375.64,160.47 376.07,160.9 376.29,160.9 377.23,161.84 379.78,161.84 382.42,164.47 382.42,166.17 383.35,167.1 387.07,167.1 388.07,168.1 388.39,168.1 391.22,170.94 395.29,170.94 v1(395.41,171.07)
  BOTTOM w0.13: v2(394.53,170.94) 395.29,170.94 v1(395.41,171.07) ; R2845.1 v1(307.91,79.5)
MODPRSL57: length 163.9
  TOP w0.13: v1(306.92,79.5) 305.52,78.1 R2851.2 ; U124.R3 397.22,175.25 397.22,174.67 395.92,173.38 395.92,172.46 v1(395.41,171.96)
  SIG10 w0.155: v1(306.92,79.5) 304.48,81.94 304.48,91.16 321.1,107.78 331.39,107.78 332.96,109.34 352.26,109.34 365.18,122.27 365.18,133.25 367.05,135.12 367.05,142.85 368.74,144.55 368.74,152.05 370.23,153.54 370.79,153.54 372.43,155.18 372.43,156.59 373.32,157.48 373.32,158.6 374.61,159.89 374.61,160.69 375.29,161.37 376,161.37 376.93,162.3 379.63,162.3 381.95,164.63 381.95,167.23 383.07,168.34 387.38,168.34 387.84,168.81 388.33,168.81 390.97,171.45 394.91,171.45 v1(395.41,171.96)
  BOTTOM w0.13: v2(396.18,171.07) 396.18,171.19 v1(395.41,171.96)
MODPRSL58: length 159.7
  TOP w0.13: v1(401.99,172.97) 401.99,173.4 402.34,173.75 402.34,174.77 U124.T9
  SIG10 w0.155: v1(324.17,90.55) 324.38,90.55 329.97,96.14 357.04,96.14 364.44,88.74 367.78,88.74 368.32,89.28 372.32,89.28 376.62,93.58 376.62,106.2 375.83,106.99 375.83,109.43 375.47,109.79 375.47,111.59 376.45,112.57 376.45,114.02 375.39,115.07 375.39,126.57 377.23,128.41 377.23,134.18 377.71,134.66 377.71,140.33 378.14,140.76 378.14,140.79 379.31,141.96 379.31,147.6 379.91,148.2 381.93,148.2 384.1,150.37 386.79,150.37 401.58,165.16 401.58,169.64 402.15,170.21 402.15,172.82 v1(401.99,172.97)
  BOTTOM w0.13: R2846.1 324.52,88.75 324.68,88.9 324.68,90.04 v1(324.17,90.55) v2(324.17,91.31)
MODPRSL59: length 158.1
  TOP w0.13: U124.T8 401.62,173.97 401.22,173.57 401.22,172.4 v1(400.78,171.96) ; R2852.2 v1(324.17,79.5)
  SIG10 w0.155: v1(324.17,79.5) 324.04,79.5 323.07,80.47 323.07,80.72 320.92,82.88 320.92,90.64 329.52,99.24 371.42,99.24 v1(371.7,99.53) 373.63,101.45 373.63,128.41 374.59,129.38 374.59,134.47 375.47,135.35 375.47,140.58 377.57,142.68 377.57,148.32 379.19,149.94 381.21,149.94 383.49,152.23 385.93,152.23 399.8,166.1 399.8,169.25 400.86,170.31 400.86,171.88 v1(400.78,171.96)
MODPRSL60: length 148.8
  TOP w0.13: R2892.1 v1(350.56,76.98) ; U124.R16 408.15,175.51 410.78,175.51 v1(411.67,174.62)
  SIG10 w0.155: v1(350.56,76.98) 351.63,76.98 352.23,77.59 362.78,77.59 363.54,76.83 364.68,76.83 365.95,78.1 373.67,78.1 374.07,78.5 379.18,78.5 380.86,80.17 380.86,84.2 381.57,84.91 382.47,84.91 386.19,88.63 386.19,90.09 386.65,90.55 387.03,90.55 394.91,98.42 394.91,100.84 395.67,101.6 400.42,101.6 407.32,108.5 407.32,142.32 409.3,144.29 409.3,169.97 410.93,171.6 410.93,173.88 v1(411.67,174.62)
  BOTTOM w0.13: v1(350.56,76.98) 350.46,76.88 v2(350.46,76.2)
MODPRSL61: length 148.3
  TOP w0.13: U124.P10 v1(403.62,176.05)
  SIG10 w0.155: v1(346.77,80.52) 346.77,81.02 349.69,83.94 352.09,83.94 354.5,86.35 359.36,86.35 361.72,83.99 364.69,83.99 365.06,84.37 368.41,84.37 368.91,83.87 369.43,83.87 369.84,83.47 375.63,83.47 381.18,89.01 381.18,98.66 382.29,99.77 382.29,125.3 383.19,126.2 383.19,139.21 384.69,140.72 386.53,140.72 387.53,141.72 387.53,144.68 391.99,149.13 394.19,149.13 397.45,152.39 397.45,153.55 401.82,157.92 402.07,157.92 406.07,161.92 406.07,168.63 405.57,169.12 405.57,173.48 403.62,175.44 v1(403.62,176.05)
  BOTTOM w0.13: v2(345.5,82.8) 346.37,81.94 346.37,80.92 v1(346.77,80.52) 346.27,80.01 345.25,80.01 344.61,79.37 R2888.2
MODPRSL62: length 117.9
  TOP w0.13: U124.L3 v1(397.22,178.45) ; v1(374.21,81.15) 373.57,80.52 R2885.1
  SIG8 w0.155: v1(374.21,81.15) 374.21,85.81 377.77,89.38 377.77,97.02 v1(375.73,99.06) 371.67,103.12 371.67,143.89 378.02,150.24 381.67,150.24 392.62,161.19 392.62,172.02 393.13,172.53 394.34,172.53 394.91,173.1 394.91,175 395.41,175.51 395.41,176.64 v1(397.22,178.45)
MODPRSL63: length 122.4
  TOP w0.13: U124.J4 v1(398.02,180.05)
  SIG8 w0.102: 396.94,179.64 397.61,179.64 v1(398.02,180.05)
  SIG8 w0.155: 396.94,179.64 396.49,179.64 395.92,179.07 395.92,178.18 394.78,177.04 393,177.04 392.62,176.65 392.62,172.72 392.11,172.21 392.11,161.3 381.55,150.75 377.98,150.75 371.16,143.92 371.16,102.74 377.3,96.59 377.3,89.46 373.44,85.6 373.44,79.83 v1(372.99,79.37)
  BOTTOM w0.13: R2893.2 372.78,78.84 372.99,79.04 v1(372.99,79.37) 373.06,79.45 v2(373.06,80.13)
MODSELL0: length 36.9
  SIG3 w0.155: YJ21.A8 22.1,61.91 21.27,62.74 15.94,62.74 14.54,64.13 14.54,71.88 16.7,74.04 16.7,81.66 17.72,82.67 17.72,86.61 v1(16.07,88.26)
  BOTTOM w0.13: R2600.2 16.55,88.75 v1(16.07,88.26) v2(15.3,88.26)
MODSELL1: length 42.7
  SIG2 w0.152: v1(14.03,85.85) 15.7,85.85 16.7,84.85 16.7,73.66 15.18,72.13 15.18,56.64 17.04,54.77 21.87,54.77 22.1,54.54 YJ21.B8
  BOTTOM w0.13: v1(14.03,85.85) 14.26,85.62 R2604.2
MODSELL2: length 61.5
  TOP w0.13: R2623.2 v1(16.19,84.71)
  SIG7 w0.155: YJ22.D8 25.3,53.2 25.97,52.53 25.97,52.19 25.21,51.43 25.21,50.67 23.43,48.89 12.72,48.89 12.38,49.23 12.38,49.65 10.86,51.18 9.08,51.18 8.24,52.02 8.24,58.75 7.68,59.31 7.68,68.58 8.57,69.47 8.57,72.77 9.08,73.28 9.08,74.42 10.1,75.44 10.1,76.58 10.73,77.21 12.13,77.21 14.29,79.37 14.29,83.31 15.68,84.71 v1(16.19,84.71)
MODSELL3: length 108.6
  SIG2 w0.152: v1(31.81,105.28) 31.43,105.66 27.11,105.66 18.93,97.49 16.27,97.49 14.54,95.76 14.54,92.71 9.21,87.37 9.21,68.2 8.08,67.07 8.08,66.02 3.49,61.44 3.49,57.66 8.57,52.58 9.21,52.58 9.72,52.07 9.72,49.4 11.62,47.5 22.8,47.5 v1(25.46,50.16)
  SIG8 w0.155: YJ22.C8 25.3,61.21 25.97,60.54 25.97,57.71 25.56,57.3 25.56,56.94 25.97,56.53 25.97,53.78 25.6,53.41 25.6,52.91 25.97,52.54 25.97,50.67 v1(25.46,50.16)
  BOTTOM w0.13: v1(31.81,105.28) 32.07,105.53 R2621.2 32.47,105.94 32.58,106.04 32.58,106.42 v2(33.34,107.19)
MODSELL4: length 22.2
  TOP w0.13: v1(41.59,79.63) 41.21,80.01 41.21,81.15 41.36,81.3 R2603.2
  SIG2 w0.152: v1(41.59,79.63) 41.97,79.25 41.97,76.71 42.53,76.15 42.53,65.67 42.17,65.31 42.17,64.95 42.2,64.92 42.2,64.91 42.5,64.61 42.5,63.99 41.1,62.59 YJ21.C8
  BOTTOM w0.13: v1(41.59,79.63) 40.96,80.26 v2(40.96,80.39)
MODSELL5: length 34.9
  TOP w0.13: v1(46.29,82.93) 46.01,82.93 45.28,83.67 R2601.2
  SIG2 w0.152: YJ21.D8 41.1,54.33 42.5,55.73 42.5,56.6 42.17,56.93 42.17,57.3 42.53,57.66 42.53,58.97 42.88,59.32 42.88,60.62 42.91,60.62 43.26,60.97 43.26,61.29 42.92,61.64 42.92,62.5 43.92,63.5 44.42,63.5 44.9,63.97 44.9,64.59 44.57,64.92 44.57,65.3 44.93,65.66 44.93,66.38 44.51,66.8 44.51,81.15 v1(46.29,82.93)
MODSELL6: length 43.7
  TOP w0.13: R2606.2 v1(57.47,86.87)
  SIG9 w0.155: v1(57.47,86.87) 58.1,86.23 58.1,83.31 58.23,83.18 58.23,81.02 57.98,80.77 57.98,79.25 55.56,76.83 55.56,59.69 50.71,54.84 45.32,54.84 YJ22.B8
  BOTTOM w0.13: v2(57.47,86.1) v1(57.47,86.87)
MODSELL7: length 32.8
  TOP w0.13: R2624.2 47.08,76.98 v1(46.42,76.32)
  SIG9 w0.155: YJ22.A8 45.34,62.86 52.22,62.86 53.78,64.43 53.78,72.13 v1(52.9,73.02)
  BOTTOM w0.13: v1(46.42,76.32) v2(45.53,76.32) 45.53,74.29 47.56,72.26 52.14,72.26 v1(52.9,73.02)
MODSELL8: length 24.5
  TOP w0.13: R2634.2 70.42,83.18 70.55,83.06 v1(71.44,83.06)
  SIG3 w0.155: YJ23.A8 69.1,62.59 70.5,63.99 70.5,64.6 70.17,64.93 70.17,65.3 70.53,65.66 70.53,77.36 71.91,78.74 71.91,82.59 v1(71.44,83.06)
MODSELL9: length 38.1
  TOP w0.13: R2644.2 v1(71.44,87.12)
  SIG3 w0.155: YJ23.B8 69.1,54.33 70.5,55.73 70.5,56.62 70.49,56.62 70.17,56.94 70.17,57.31 70.53,57.67 70.53,60.24 71.26,60.97 71.26,61.27 70.92,61.61 70.92,62.5 71.92,63.5 72.42,63.5 72.9,63.97 72.9,64.59 72.57,64.92 72.57,65.3 72.93,65.66 72.93,66.45 71.95,67.43 71.95,77.89 72.96,78.9 72.96,83.31 71.91,84.37 71.91,86.65 v1(71.44,87.12)
MODSELL10: length 37.2
  TOP w0.13: R2661.2 v1(72.45,87.12)
  SIG8 w0.155: v1(72.45,87.12) 73.72,85.85 73.72,79.91 73.88,79.75 74.49,79.75 74.74,79.5 74.74,75.18 74.36,74.8 74.36,68.58 72.96,67.18 72.96,65.7 72.53,65.27 72.53,64.98 72.93,64.58 72.93,61.66 72.54,61.27 72.54,60.97 72.92,60.59 72.92,59.45 72.93,59.43 72.93,58.15 72.93,58.15 72.93,57.66 72.54,57.27 72.54,56.97 72.92,56.59 72.92,55.48 72.3,54.86 YJ24.D8
MODSELL11: length 25.4
  TOP w0.13: R2664.2 73.47,82.8 72.83,82.17 v1(72.45,82.17)
  SIG9 w0.155: v1(72.45,82.17) 73.47,81.15 73.47,76.45 72.86,75.84 72.1,75.84 71.91,75.65 71.91,67.04 70.92,66.05 70.92,65.61 71.26,65.27 71.26,64.95 70.88,64.57 70.88,63.9 72.3,62.48 YJ24.C8
MODSELL12: length 25.9
  TOP w0.13: R2641.2 83.76,82.29 v1(84.77,81.28)
  SIG2 w0.152: YJ23.C8 88.1,62.59 89.5,63.99 89.5,64.6 89.17,64.93 89.17,65.3 89.53,65.66 89.53,66.23 88.04,67.72 88.04,70.26 84.42,73.89 84.42,78.13 85.28,78.99 85.28,80.77 v1(84.77,81.28)
MODSELL13: length 27.7
  SIG2 w0.152: v1(91.51,70.53) 91.93,70.12 91.93,65.66 91.57,65.3 91.57,64.92 91.9,64.59 91.9,63.97 91.42,63.5 90.92,63.5 89.92,62.5 89.92,61.68 90.26,61.34 90.26,60.97 89.88,60.59 89.88,59.32 89.53,58.97 89.53,57.67 89.17,57.31 89.17,56.93 89.5,56.6 89.5,55.73 88.1,54.33 YJ23.D8
  BOTTOM w0.13: R2643.2 90.39,77.37 90.11,77.09 90.11,75.94 v2(90.74,75.31) 91.63,74.42 91.63,70.65 v1(91.51,70.53)
MODSELL14: length 45.2
  SIG9 w0.155: v1(100.65,73.12) 102.04,71.73 102.04,59.31 97.6,54.86 92.34,54.86 YJ24.B8
  SIG10 w0.155: v1(100.65,73.12) 100.65,73.91 97.47,77.09 97.47,80.01 101.16,83.69 v1(103.44,83.69)
  BOTTOM w0.13: v2(104.23,84.96) R2663.2 v1(103.44,83.69)
MODSELL15: length 25.9
  SIG9 w0.155: YJ24.A8 92.34,62.86 97.22,62.86 98.8,64.44 v1(98.8,73.12)
  BOTTOM w0.13: v1(98.8,73.12) 98.74,73.07 97.43,73.07 96.03,74.47 96.03,75.94 v2(95.69,76.28) 95.69,77.24 94.3,78.64 R2662.2
MODSELL16: length 19.7
  TOP w0.13: v1(120.97,76.1) 121.73,76.86 121.73,77.72 121.88,77.87 R2668.2
  SIG3 w0.155: v1(120.97,76.1) 120.56,75.69 119.44,75.69 118.43,74.67 118.43,67.82 117.53,66.92 117.53,65.65 117.5,65.62 117.49,65.62 117.17,65.3 117.17,64.94 117.5,64.61 117.5,63.99 116.1,62.59 YJ25.A8
MODSELL17: length 36.7
  TOP w0.13: v1(121.22,86.23) R2683.2
  SIG2 w0.152: v1(121.22,86.23) 120.71,85.72 120.71,82.29 119.44,81.02 119.44,73.78 v1(119.95,73.28)
  SIG3 w0.155: YJ25.B8 116.1,54.33 117.5,55.73 117.5,56.61 117.17,56.94 117.17,57.3 117.53,57.66 117.53,58.97 117.88,59.32 117.88,60.59 118.26,60.97 118.26,61.28 117.92,61.62 117.92,62.5 118.92,63.5 119.42,63.5 119.9,63.97 119.9,64.59 119.57,64.92 119.57,65.29 119.6,65.32 119.6,65.33 119.93,65.66 119.93,72.11 119.95,72.13 v1(119.95,73.28)
MODSELL18: length 37.7
  TOP w0.13: R2701.2 123.36,86.89 124.4,85.85 124.4,80.26 v1(124.02,79.88)
  SIG8 w0.155: YJ26.D8 119.3,54.86 119.92,55.48 119.92,56.59 119.54,56.97 119.54,57.27 119.93,57.66 119.93,58.15 119.93,58.15 119.93,59.43 119.92,59.45 119.92,60.59 119.54,60.97 119.54,61.27 119.93,61.66 119.93,64.58 119.53,64.98 119.53,65.27 119.95,65.69 119.95,67.31 123.38,70.74 123.38,78.61 124.02,79.25 v1(124.02,79.88)
MODSELL19: length 26.8
  TOP w0.13: R2704.2 v1(123.25,83.06)
  SIG9 w0.155: v1(123.25,83.06) 123.76,82.55 124.14,82.55 124.52,82.17 124.52,79.63 124.02,79.12 123.76,79.12 122.75,78.1 122.11,78.1 121.6,77.59 121.6,75.08 121.48,74.95 121.48,70.99 118.17,67.69 118.17,66.31 117.92,66.05 117.92,65.61 118.26,65.27 118.26,64.95 117.88,64.57 117.88,63.9 119.3,62.48 YJ26.C8
MODSELL20: length 25.5
  TOP w0.13: v1(132.63,82.29) 133.54,83.21 R2682.2
  SIG2 w0.152: v1(132.63,82.29) 133.29,82.29 134.18,81.4 134.18,73.66 134.3,73.53 134.87,73.53 135.38,73.02 135.38,72.7 135.8,72.29 135.8,66.96 136.53,66.22 136.53,65.67 136.17,65.31 136.17,64.93 136.5,64.6 136.5,63.99 135.1,62.59 YJ25.C8
MODSELL21: length 45
  TOP w0.13: R2684.2 134.02,87.78 133.79,88.01 v1(133.79,88.64)
  SIG1 w0.16: v1(133.79,88.64) 133.79,85.1 133.93,84.96 133.93,79.31 134.5,78.74 136.33,78.74 137.35,77.72 137.35,76.83 v1(138.24,75.94)
  SIG2 w0.152: v1(138.24,75.94) 137.35,75.05 137.35,67.69 138.93,66.11 138.93,65.66 138.57,65.3 138.57,64.92 138.9,64.59 138.9,63.97 138.42,63.5 137.92,63.5 136.92,62.5 136.92,61.61 137.26,61.27 137.26,60.97 136.88,60.59 136.88,59.32 136.53,58.97 136.53,57.67 136.17,57.31 136.17,56.93 136.5,56.6 136.5,55.73 135.1,54.33 YJ25.D8
  BOTTOM w0.13: v1(138.24,75.94) v2(140.27,75.94)
MODSELL22: length 40.3
  TOP w0.13: R2702.2 135.57,87.25 v1(135.45,87.12)
  SIG1 w0.16: v1(135.45,87.12) 135.95,86.61 136.97,86.61 139.89,83.69 139.89,76.81 v1(141.52,75.18)
  SIG9 w0.155: YJ26.B8 138.3,54.86 138.92,55.48 138.92,56.59 138.54,56.97 138.54,57.29 138.93,57.68 138.93,58.15 138.93,58.15 138.93,60.58 138.54,60.97 138.54,61.29 138.93,61.68 138.93,64.58 138.53,64.98 138.53,65.32 138.81,65.6 138.81,69.27 139.38,69.85 139.38,73.05 v1(141.52,75.18)
  BOTTOM w0.13: v2(142.3,75.44) 142.05,75.18 v1(141.52,75.18)
MODSELL23: length 24.8
  TOP w0.13: v1(136.87,81.28) 136.36,81.79 136.36,83.08 136.59,83.31 R2703.2
  SIG8 w0.155: v1(136.87,81.28) 136.33,80.74 136.33,78.61 137.1,77.85 137.1,75.94 138.37,74.67 138.37,67.69 136.92,66.24 136.92,65.61 137.26,65.27 137.26,64.97 136.88,64.59 136.88,63.9 138.3,62.48 YJ26.A8
MODSELL24: length 24.8
  TOP w0.13: v1(165.42,83.06) 164.53,83.06 164.4,83.18 R2716.2
  SIG3 w0.155: v1(165.42,83.06) 165.91,82.57 165.91,78.74 165.67,78.5 165.67,75.28 165.34,74.95 164.81,74.95 164.47,74.61 164.47,65.6 164.17,65.3 164.17,64.94 164.5,64.61 164.5,63.99 163.1,62.59 YJ27.A8
MODSELL25: length 40.4
  TOP w0.13: v1(164.4,87.25) 164.4,87.53 164.66,87.78 R2724.2
  SIG3 w0.155: v1(164.4,87.25) 164.91,86.74 164.91,85.72 166.93,83.7 166.93,78.85 166.31,78.23 166.31,74.34 166.43,74.22 166.43,72.97 165.8,72.34 165.8,67.29 166.93,66.16 166.93,65.66 166.57,65.3 166.57,64.92 166.9,64.59 166.9,63.97 166.42,63.5 165.92,63.5 164.92,62.5 164.92,61.62 165.26,61.28 165.26,60.97 164.88,60.59 164.88,59.32 164.53,58.97 164.53,57.66 164.17,57.3 164.17,56.94 164.5,56.61 164.5,55.73 163.1,54.33 YJ27.B8
  BOTTOM w0.13: v1(164.4,87.25) v2(163.64,87.25)
MODSELL26: length 36.1
  TOP w0.13: v1(167.32,87.37) 167.32,87.5 167.04,87.78 R2741.2
  SIG8 w0.155: YJ28.D8 166.3,54.86 166.92,55.48 166.92,56.59 166.54,56.97 166.54,57.27 166.93,57.66 166.93,58.15 166.93,58.15 166.93,59.43 166.92,59.45 166.92,60.59 166.54,60.97 166.54,61.27 166.93,61.66 166.93,64.57 166.6,64.9 166.6,65.33 166.81,65.54 166.81,65.55 166.97,65.71 166.97,70.89 167.45,71.37 167.45,86.79 167.32,86.91 v1(167.32,87.37)
MODSELL27: length 24.6
  TOP w0.13: R2744.2 167.58,83.31 v1(166.43,82.17)
  SIG9 w0.155: v1(166.43,82.17) 165.93,81.66 165.93,73.28 166.81,72.39 166.81,67.95 164.92,66.05 164.92,65.61 165.26,65.27 165.26,64.95 164.88,64.57 164.88,63.9 166.3,62.48 YJ28.C8
MODSELL28: length 26
  TOP w0.13: v1(178.75,80.39) 178.12,81.02 178.12,82.8 177.74,83.18 R2723.2
  SIG2 w0.152: YJ27.C8 182.1,62.59 183.5,63.99 183.5,64.6 183.14,64.95 183.14,65.27 183.53,65.66 183.53,66.04 183.2,66.37 183.2,68.2 179.13,72.26 179.13,73.02 178.3,73.86 178.3,77.92 179.24,78.86 179.24,79.9 v1(178.75,80.39)
MODSELL29: length 41.1
  TOP w0.13: R2722.2 v1(178.75,86.23)
  SIG2 w0.152: YJ27.D8 182.1,54.33 183.5,55.73 183.5,56.61 183.17,56.94 183.17,57.3 183.53,57.66 183.53,58.97 183.88,59.32 183.88,60.59 184.26,60.97 184.26,61.34 183.92,61.68 183.92,62.5 184.92,63.5 185.42,63.5 185.9,63.97 185.9,64.61 185.57,64.94 185.57,65.3 185.93,65.66 185.93,68.26 180.91,73.28 180.91,75.18 180.28,75.82 180.28,83.54 179.24,84.58 179.24,85.74 v1(178.75,86.23)
  BOTTOM w0.13: v1(178.75,86.23) 177.94,87.04 v2(177.61,87.04)
MODSELL30: length 38
  TOP w0.13: R2743.2 180.38,87.78 181.67,86.48 v1(181.67,86.23)
  SIG9 w0.155: v1(181.67,86.23) 183.2,84.71 183.2,74.67 185.23,72.64 185.23,67.05 185.86,66.42 185.86,65.65 185.53,65.32 185.53,64.98 185.93,64.58 185.93,61.68 185.54,61.29 185.54,60.97 185.92,60.59 185.92,59.45 185.93,59.43 185.93,58.15 185.93,58.15 185.93,57.68 185.54,57.29 185.54,56.97 185.92,56.59 185.92,55.48 185.3,54.86 YJ28.B8
MODSELL31: length 24.4
  TOP w0.13: R2742.2 180.78,81.91 v1(181.42,81.28)
  SIG8 w0.155: YJ28.A8 185.3,62.48 183.88,63.9 183.88,64.59 184.26,64.97 184.26,65.27 183.92,65.61 183.92,66.05 184.3,66.44 184.3,73.57 182.94,74.93 182.94,79.75 v1(181.42,81.28)
MODSELL32: length 19.7
  TOP w0.13: R2752.2 214.19,77.34 v1(215.2,76.32)
  SIG3 w0.155: v1(215.2,76.32) 214.19,75.31 214.19,70.86 211.53,68.21 211.53,65.65 211.5,65.62 211.49,65.62 211.17,65.3 211.17,64.94 211.5,64.61 211.5,63.99 210.1,62.59 YJ29.A8
  BOTTOM w0.13: v1(215.2,76.32) 214.95,76.58 v2(214.44,76.58)
MODSELL33: length 38.5
  TOP w0.13: R2763.2 v1(215.2,87.12)
  SIG3 w0.155: YJ29.B8 210.1,54.33 211.5,55.73 211.5,56.61 211.17,56.94 211.17,57.3 211.53,57.66 211.53,58.97 211.88,59.32 211.88,60.59 212.26,60.97 212.26,61.29 211.92,61.64 211.92,62.5 212.92,63.5 213.42,63.5 213.9,63.97 213.9,64.61 213.57,64.94 213.57,65.3 213.93,65.66 213.93,67.5 216.22,69.79 216.22,73.66 216.73,74.17 216.73,83.31 215.71,84.33 215.71,86.61 v1(215.2,87.12)
MODSELL34: length 37.2
  TOP w0.13: R2782.2 v1(216.22,87.12)
  SIG8 w0.155: v1(216.22,87.12) 215.71,86.61 215.71,84.33 216.98,83.06 216.98,69.97 213.8,66.8 213.8,65.59 213.53,65.32 213.53,64.98 213.93,64.58 213.93,61.66 213.54,61.27 213.54,60.97 213.93,60.58 213.93,57.67 213.54,57.28 213.54,56.97 213.92,56.58 213.92,55.48 213.3,54.86 YJ30.D8
MODSELL35: length 25.5
  SIG9 w0.155: v1(216.22,80.39) 216.7,79.91 216.7,74.34 216.34,73.99 216.34,70.48 211.92,66.05 211.92,65.61 212.26,65.27 212.26,64.95 211.88,64.57 211.88,63.9 213.3,62.48 YJ30.C8
  BOTTOM w0.13: R2784.2 217.23,83.54 217.36,83.41 217.36,81.53 v2(217.23,81.4) v1(216.22,80.39)
MODSELL36: length 24.9
  TOP w0.13: v1(228.54,83.06) 227.65,83.06 227.52,83.18 R2762.2
  SIG2 w0.152: v1(228.54,83.06) 228.08,82.6 228.08,72.97 230.53,70.52 230.53,65.62 230.49,65.62 230.17,65.3 230.17,64.93 230.5,64.6 230.5,63.99 229.1,62.59 YJ29.C8
MODSELL37: length 40.6
  TOP w0.13: v1(227.48,87.31) 227.95,87.78 R2764.2
  SIG2 w0.152: v1(227.48,87.31) 228.05,86.73 228.05,84.43 229.04,83.44 229.04,78.48 230.06,77.47 230.06,73.02 232.93,70.15 232.93,65.66 232.57,65.3 232.57,64.94 232.89,64.62 232.9,64.62 232.9,63.97 232.42,63.5 231.92,63.5 230.92,62.5 230.92,61.64 231.26,61.29 231.26,60.97 230.88,60.59 230.88,59.32 230.53,58.97 230.53,57.66 230.17,57.3 230.17,56.93 230.5,56.6 230.5,55.73 229.1,54.33 YJ29.D8
  BOTTOM w0.13: v1(227.48,87.31) 227.42,87.37 v2(227.42,88.14)
MODSELL38: length 37
  TOP w0.13: v1(229.03,87.16) 229.55,87.68 R2781.2
  SIG9 w0.155: v1(229.03,87.16) 229.03,84.47 232.92,80.57 232.92,65.71 232.53,65.32 232.53,64.98 232.93,64.58 232.93,61.68 232.54,61.29 232.54,60.97 232.92,60.59 232.92,59.45 232.93,59.43 232.93,58.15 232.93,58.15 232.93,57.68 232.54,57.29 232.54,56.98 232.6,56.92 232.6,56.91 232.92,56.59 232.92,55.48 232.3,54.86 YJ30.B8
MODSELL39: length 23.9
  SIG8 w0.155: YJ30.A8 232.3,62.48 230.88,63.9 230.88,64.59 231.26,64.97 231.26,65.27 230.92,65.61 230.92,74.07 v1(229.55,75.44)
  BOTTOM w0.13: R2783.2 230.57,83.56 230.64,83.49 230.64,80.59 230.06,80.01 230.06,77.47 230.19,77.34 v2(230.19,76.76) 230.19,76.32 229.55,75.69 v1(229.55,75.44)
MODSELL40: length 24.1
  TOP w0.13: v1(259.4,83.06) 258.51,83.06 258.38,83.18 R2800.2
  SIG3 w0.155: YJ31.A8 257.1,62.59 258.5,63.99 258.5,64.61 258.17,64.94 258.17,65.31 258.53,65.67 258.53,82.19 v1(259.4,83.06)
MODSELL41: length 37.3
  TOP w0.13: R2804.2 v1(259.4,87.12)
  SIG3 w0.155: v1(259.4,87.12) 259.91,86.61 259.91,67.18 260.93,66.16 260.93,65.66 260.57,65.3 260.57,64.92 260.9,64.59 260.9,63.97 260.42,63.5 259.92,63.5 258.92,62.5 258.92,61.64 259.26,61.29 259.26,60.97 258.88,60.59 258.88,59.32 258.53,58.97 258.53,57.66 258.17,57.3 258.17,56.94 258.5,56.61 258.5,55.73 257.1,54.33 YJ31.B8
MODSELL42: length 31.9
  SIG8 w0.155: v1(262.19,81.02) 261.56,80.39 261.56,74.28 260.92,73.64 260.92,65.66 260.53,65.27 260.53,64.98 260.93,64.58 260.93,61.66 260.54,61.27 260.54,60.97 260.93,60.58 260.93,57.66 260.54,57.27 260.54,56.97 260.92,56.59 260.92,55.48 260.3,54.86 YJ32.D8
  BOTTOM w0.13: v1(262.19,81.02) 261.56,81.66 R2823.2
MODSELL43: length 23.9
  TOP w0.13: v1(260.41,82.17) 261.56,83.31 R2821.2
  SIG9 w0.155: YJ32.C8 260.3,62.48 258.88,63.9 258.88,64.57 259.26,64.95 259.26,65.27 258.92,65.61 258.92,66.05 259.91,67.04 259.91,81.66 v1(260.41,82.17)
MODSELL44: length 25.5
  TOP w0.13: R2803.2 v1(272.73,83.06)
  SIG2 w0.152: YJ31.C8 276.1,62.59 277.5,63.99 277.5,64.62 277.49,64.62 277.17,64.94 277.17,65.3 277.53,65.66 277.53,68.83 272.28,74.08 272.28,77.9 273.24,78.86 273.24,82.55 v1(272.73,83.06)
MODSELL45: length 39.7
  TOP w0.13: R2801.2 v1(272.73,87.12)
  SIG2 w0.152: v1(272.73,87.12) 273.24,86.61 273.24,84.58 274.26,83.56 274.26,73.91 279.93,68.24 279.93,65.66 279.57,65.3 279.57,64.94 279.9,64.61 279.9,63.97 279.42,63.5 278.92,63.5 277.92,62.5 277.92,61.61 278.26,61.27 278.26,60.97 277.88,60.59 277.88,59.32 277.53,58.97 277.53,57.66 277.17,57.3 277.17,56.94 277.5,56.61 277.5,55.73 276.1,54.33 YJ31.D8
MODSELL46: length 37.8
  TOP w0.13: R2820.2 v1(273.75,87.12)
  SIG9 w0.155: YJ32.B8 279.3,54.86 279.92,55.48 279.92,56.59 279.54,56.97 279.54,57.29 279.93,57.68 279.93,58.15 279.93,58.15 279.93,60.58 279.54,60.97 279.54,61.29 279.93,61.68 279.93,64.58 279.53,64.98 279.53,65.32 279.97,65.76 279.97,69.09 274.89,74.17 274.89,80.39 274.51,80.77 274.51,86.36 v1(273.75,87.12)
MODSELL47: length 25.8
  TOP w0.13: v1(273.75,82.17) 273.24,82.67 273.24,83.44 273.52,83.72 R2824.2
  SIG8 w0.155: YJ32.A8 279.3,62.48 277.88,63.9 277.88,64.59 278.26,64.97 278.26,65.27 278.2,65.33 278.2,65.33 277.92,65.61 277.92,66.01 278.06,66.15 278.07,66.17 278.15,66.25 278.17,66.26 278.17,66.3 278.3,66.44 278.3,69.23 274.26,73.28 274.26,77.59 273.24,78.61 273.24,81.66 v1(273.75,82.17)
MODSELL48: length 19.2
  TOP w0.13: R2833.2 v1(302.17,77.09)
  SIG3 w0.155: YJ33.A8 304.1,62.59 305.5,63.99 305.5,64.61 305.17,64.94 305.17,65.3 305.53,65.66 305.53,69.47 302.83,72.16 302.83,76.43 v1(302.17,77.09)
  BOTTOM w0.13: v2(301.82,77.85) 302.17,77.49 v1(302.17,77.09)
MODSELL49: length 29.8
  SIG3 w0.155: v1(304.36,73.91) 307.93,70.34 307.93,65.66 307.6,65.33 307.6,64.91 307.89,64.62 307.9,64.62 307.9,63.97 307.42,63.5 306.92,63.5 305.92,62.5 305.92,61.64 306.26,61.29 306.26,60.96 305.88,60.58 305.88,59.32 305.53,58.97 305.53,57.65 305.5,57.62 305.49,57.62 305.2,57.33 305.2,57.32 305.17,57.29 305.17,56.94 305.5,56.61 305.5,55.73 304.1,54.33 YJ33.B8
  BOTTOM w0.13: R2844.2 v2(306.49,76.6) 306.26,76.38 306.26,74.67 305.5,73.91 v1(304.36,73.91)
