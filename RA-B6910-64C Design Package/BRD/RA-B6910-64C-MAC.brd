# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC63_RDP2: length 262.5
  TOP w0.147: U1.BR28 203.55,161.34 v4(203.6,161.34)
  SIG2 w0.112: 204.86,173.61 204.95,173.52 204.95,162.25 arc(204.93,162.15) 204.87,162.06 arc(204.78,162) 204.67,161.98 204.3,161.98 arc(204.17,161.95) 204.05,161.87 arc(203.98,161.76) 203.95,161.62 203.95,161.47 arc(203.91,161.38) 203.82,161.34 v4(203.6,161.34)
  SIG2 w0.16: 204.86,173.61 204.86,175 arc(204.93,175.59) 205.13,176.14 arc(205.35,176.51) 205.62,176.84 206.83,178.04 arc(212.1,181.56) 218.32,182.8 236.43,182.8 arc(236.72,182.74) 236.96,182.58 239.11,180.43 arc(239.36,180.27) 239.65,180.21 251.21,180.21 arc(251.65,180.12) 252.02,179.88 287.13,144.76 arc(287.25,144.68) 287.4,144.65 305.58,144.65 arc(306.02,144.56) 306.39,144.32 376.18,74.53 arc(376.3,74.45) 376.45,74.42 379.86,74.42 arc(380.15,74.36) 380.4,74.2 383.38,71.21 arc(383.55,70.97) 383.6,70.67 383.6,64.01 arc(383.43,63.17) 382.94,62.45 379.74,59.25 arc(379.49,59.08) 379.2,59.03 376.95,59.03 arc(376.81,59) 376.68,58.91 376.63,58.86 arc(376.54,58.72) 376.51,58.57 376.51,58.08 arc(376.46,57.86) 376.34,57.67 375.86,57.19 arc(375.74,57.02) 375.7,56.81 YJ35.D24
FC63_RDP3: length 276.8
  TOP w0.147: U1.BN27 204.05,158.94 arc(204.07,159.04) 204.12,159.12 204.29,159.29 arc(204.35,159.33) 204.42,159.34 v4(204.5,159.34)
  SIG2 w0.112: v4(204.5,159.34) 204.27,159.34 arc(204.18,159.38) 204.15,159.47 204.15,159.63 arc(204.12,159.75) 204.05,159.86 204.04,159.87 arc(203.92,159.95) 203.79,159.98 203.35,159.98 arc(203.28,159.99) 203.21,160.04 arc(203.17,160.1) 203.15,160.18 203.15,172.88 203.24,172.97
  SIG2 w0.16: YJ35.D14 374.75,53.97 arc(374.64,54.13) 374.61,54.32 374.61,54.57 arc(374.69,54.78) 374.9,54.86 375.78,54.86 arc(376.07,54.92) 376.31,55.08 376.36,55.13 376.41,55.18 arc(376.5,55.26) 376.6,55.32 arc(376.77,55.38) 376.95,55.41 378.9,55.41 arc(379.19,55.46) 379.44,55.63 379.8,55.99 379.8,56.3 380.21,56.71 380.52,56.71 380.88,57.07 380.88,57.4 381.26,57.79 381.59,57.79 381.95,58.14 381.95,58.48 382.34,58.86 382.67,58.86 383.03,59.22 383.03,59.56 383.42,59.94 383.75,59.94 384.11,60.3 384.11,60.6 384.53,61.02 384.83,61.02 385.38,61.57 385.38,62.08 385.15,62.31 385.15,62.87 385.38,63.1 385.38,70.58 arc(385.15,71.73) 384.5,72.7 380.21,76.99 arc(378.98,77.81) 377.54,78.1 376.29,78.1 arc(375.49,78.26) 374.82,78.71 307.32,146.21 arc(307.07,146.37) 306.78,146.43 305.75,146.43 arc(289.21,149.72) 275.18,159.09 248.03,186.24 arc(245.57,187.89) 242.66,188.47 241.94,188.47 arc(240.26,188.13) 238.84,187.18 arc(235.87,185.2) 232.38,184.5 218.37,184.5 arc(211.43,183.12) 205.55,179.19 203.39,177.04 arc(203.28,176.86) 203.24,176.66 203.24,176.66 203.24,176.02 203.42,175.84 203.42,175.18 203.24,175 203.24,174.49 203.42,174.31 203.42,173.66 203.24,173.48 203.24,172.97
FC63_TDN0: length 270.4
  TOP w0.147: U1.CE28 203.55,171.34 v4(203.6,171.34)
  SIG5 w0.112: v4(203.6,171.34) 203.82,171.34 arc(203.91,171.38) 203.95,171.47 203.95,171.63 arc(203.94,171.68) 203.91,171.72 203.9,171.73 arc(203.85,171.77) 203.79,171.78 203.35,171.78 arc(203.19,171.81) 203.06,171.9 arc(202.98,172.03) 202.95,172.18 202.95,172.85 202.86,172.94 202.86,172.97
  SIG5 w0.16: YJ35.D3 366.1,52.73 arc(366.16,53.01) 366.31,53.25 366.81,53.75 arc(366.88,53.85) 366.91,53.97 366.91,54.57 arc(366.91,54.61) 366.91,54.65 arc(366.91,54.65) 366.92,54.65 arc(366.96,54.76) 367.03,54.86 367.08,54.91 arc(367.21,55) 367.35,55.03 379.26,55.03 arc(379.55,55.08) 379.8,55.25 383.6,59.05 384.32,59.77 arc(384.48,60.02) 384.54,60.31 384.54,69.05 arc(384.46,69.49) 384.21,69.86 311.91,142.16 arc(311.54,142.4) 311.1,142.49 292.76,142.49 arc(292.47,142.55) 292.23,142.71 265.65,169.29 254.98,179.96 arc(254.73,180.13) 254.44,180.19 240.31,180.19 arc(240.16,180.21) 240.04,180.3 237.67,182.67 arc(237.29,182.92) 236.86,183 209.37,183 arc(208.63,182.86) 208,182.44 203.19,177.63 arc(202.94,177.26) 202.86,176.82 202.86,172.97
FC63_TDN1: length 256.4
  TOP w0.147: U1.CC27 204.05,168.9 arc(204.08,169.07) 204.18,169.21 204.24,169.27 arc(204.31,169.32) 204.4,169.34 v4(204.5,169.34)
  SIG4 w0.112: v4(204.5,169.34) 204.27,169.34 arc(204.18,169.38) 204.15,169.47 204.15,169.62 arc(204.16,169.68) 204.19,169.73 arc(204.24,169.77) 204.3,169.78 204.68,169.78 arc(204.86,169.81) 205.01,169.92 arc(205.11,170.07) 205.15,170.25 205.15,173.69 205.24,173.78 205.24,173.81
  SIG4 w0.16: 205.24,173.81 205.24,175.75 arc(205.27,175.9) 205.36,176.02 207.78,178.45 arc(207.9,178.53) 208.05,178.56 211.71,178.56 arc(212.14,178.65) 212.51,178.89 213.85,180.23 arc(213.97,180.31) 214.11,180.34 240.06,180.34 arc(240.21,180.31) 240.33,180.23 240.42,180.14 arc(240.79,179.89) 241.23,179.8 251.42,179.8 arc(251.56,179.77) 251.69,179.69 281.92,149.46 arc(290.06,144.02) 299.66,142.11 301.43,142.11 arc(307.51,140.9) 312.66,137.46 313.74,136.38 376.08,74.04 arc(376.36,73.85) 376.7,73.78 arc(376.74,73.78) 376.77,73.75 377.53,72.99 378.61,71.92 378.61,71.58 378.99,71.2 379.33,71.2 379.69,70.84 379.69,70.51 380.07,70.12 380.4,70.12 380.76,69.76 380.76,69.43 381.15,69.04 381.48,69.04 382.02,68.51 arc(382.1,68.38) 382.13,68.24 382.13,66.4 381.88,66.15 381.88,65.64 382.13,65.39 382.13,64.88 381.88,64.63 381.88,64.12 382.13,63.86 382.13,63.36 381.9,63.13 381.9,62.57 382.13,62.34 382.13,61.83 arc(382.1,61.69) 382.02,61.56 381.15,60.7 380.79,60.7 380.43,60.34 380.43,59.98 379.97,59.52 arc(379.85,59.44) 379.71,59.41 369.75,59.41 arc(369.46,59.35) 369.21,59.18 369.16,59.13 369.12,59.08 arc(368.87,58.92) 368.58,58.86 367.72,58.86 arc(367.5,58.77) 367.41,58.55 367.41,58.32 arc(367.44,58.13) 367.55,57.97 YJ35.D34
FC63_TDN2: length 274.6
  TOP w0.147: U1.CA28 203.55,167.34 v4(203.6,167.34)
  SIG4 w0.112: 202.86,172.97 202.95,172.87 202.95,168.18 arc(202.98,168.03) 203.07,167.9 arc(203.2,167.81) 203.35,167.78 203.79,167.78 arc(203.85,167.77) 203.9,167.73 203.91,167.72 arc(203.94,167.68) 203.95,167.63 203.95,167.47 arc(203.91,167.38) 203.82,167.34 v4(203.6,167.34)
  SIG4 w0.16: 202.86,172.97 202.86,176.75 arc(202.91,177.04) 203.08,177.29 206.67,180.88 arc(206.91,181.04) 207.21,181.1 210.92,181.1 arc(211.21,181.16) 211.46,181.32 213.55,183.42 arc(213.8,183.58) 214.09,183.64 229.04,183.64 arc(231.27,184.08) 233.15,185.34 233.61,185.8 arc(237.27,188.24) 241.58,189.1 242.51,189.1 arc(245.56,188.49) 248.15,186.76 283.35,151.56 arc(291.01,146.45) 300.04,144.65 303.11,144.65 arc(308.93,143.49) 313.87,140.19 384.65,69.41 arc(384.82,69.16) 384.87,68.87 384.87,60.64 arc(384.82,60.35) 384.65,60.1 379.8,55.25 arc(379.55,55.08) 379.26,55.03 369.75,55.03 arc(369.61,55) 369.48,54.91 369.43,54.86 arc(369.34,54.72) 369.31,54.57 369.31,53.97 arc(369.28,53.85) 369.21,53.75 368.59,53.13 arc(368.52,53.02) 368.5,52.9 YJ35.D6
FC63_TDN3: length 256.8
  TOP w0.147: U1.CF25 206.05,171.89 arc(206.18,172.21) v4(206.5,172.34)
  SIG5 w0.112: 205.24,173.71 205.24,173.68 205.14,173.59 205.14,173.18 arc(205.16,173.1) 205.2,173.04 arc(205.27,172.99) 205.35,172.98 205.79,172.98 arc(205.92,172.95) 206.04,172.87 206.05,172.86 arc(206.12,172.75) 206.15,172.63 206.15,172.47 arc(206.18,172.38) 206.27,172.34 v4(206.5,172.34)
  SIG5 w0.16: YJ35.D37 365.15,57.97 arc(365.04,58.13) 365.01,58.32 365.01,58.59 arc(365.09,58.78) 365.28,58.86 366.12,58.86 arc(366.46,58.93) 366.76,59.13 366.81,59.18 arc(367.06,59.35) 367.35,59.41 378.88,59.41 arc(379.03,59.44) 379.15,59.52 379.55,59.92 379.55,60.27 379.85,60.57 380.2,60.57 380.72,61.09 380.72,61.44 381.02,61.73 381.37,61.73 381.89,62.26 arc(381.97,62.38) 382,62.53 382,67.85 arc(381.94,68.14) 381.78,68.39 310.44,139.73 arc(310.19,139.89) 309.9,139.95 291.88,139.95 arc(291.44,140.04) 291.07,140.29 253.74,177.61 arc(253.62,177.69) 253.47,177.72 239.27,177.72 arc(238.83,177.81) 238.46,178.06 236.29,180.23 arc(236.17,180.31) 236.02,180.34 213.96,180.34 213.73,180.11 213.27,180.11 213.04,180.34 212.48,180.34 212.26,180.11 211.8,180.11 211.57,180.34 211.11,180.34 210.86,180.08 210.45,180.08 210.2,180.34 209.74,180.34 arc(209.62,180.31) 209.52,180.25 209.07,179.79 206.43,177.15 206.43,176.8 206.13,176.51 205.78,176.51 205.46,176.18 arc(205.41,176.13) 205.37,176.07 arc(205.27,175.87) 205.24,175.64 205.24,175.08 205.49,174.83 205.49,174.42 205.24,174.17 205.24,173.71
FC63_TDP0: length 270.3
  TOP w0.147: U1.CE27 204.05,170.89 arc(204.18,171.21) v4(204.5,171.34)
  SIG5 w0.112: v4(204.5,171.34) 204.27,171.34 arc(204.18,171.38) 204.15,171.47 204.15,171.63 arc(204.12,171.75) 204.05,171.86 204.04,171.87 arc(203.92,171.95) 203.79,171.98 203.35,171.98 arc(203.27,171.99) 203.2,172.04 arc(203.16,172.1) 203.14,172.18 203.14,172.85 203.24,172.94 203.24,172.97
  SIG5 w0.16: 203.24,172.97 203.24,176.82 arc(203.29,177.11) 203.46,177.36 208.27,182.17 arc(208.77,182.5) 209.37,182.62 213.74,182.62 213.89,182.47 214.65,182.47 214.81,182.62 215.57,182.62 215.72,182.47 216.48,182.47 216.64,182.62 217.4,182.62 217.55,182.47 218.31,182.47 218.46,182.62 219.23,182.62 219.38,182.47 220.14,182.47 220.29,182.62 221.05,182.62 221.21,182.47 221.97,182.47 222.12,182.62 222.88,182.62 223.01,182.5 223.82,182.5 223.95,182.62 224.71,182.62 224.84,182.5 225.65,182.5 225.78,182.62 236.86,182.62 arc(237.15,182.57) 237.4,182.4 239.77,180.03 arc(240.02,179.86) 240.31,179.8 254.44,179.8 arc(254.59,179.77) 254.71,179.69 291.96,142.45 arc(292.33,142.2) 292.76,142.11 311.1,142.11 arc(311.39,142.05) 311.64,141.89 383.94,69.59 arc(384.1,69.34) 384.16,69.05 384.16,67.17 384.09,67.09 384.09,66.33 384.16,66.25 384.16,65.49 384.09,65.41 384.09,64.65 384.16,64.57 384.16,63.81 384.09,63.74 384.09,62.97 384.16,62.9 384.16,62.14 384.01,61.98 384.01,61.22 384.16,61.07 384.16,60.31 arc(384.13,60.16) 384.05,60.04 383.23,59.21 383.01,59.21 382.47,58.68 382.47,58.46 381.93,57.92 381.72,57.92 381.18,57.38 381.18,57.17 379.53,55.52 arc(379.41,55.44) 379.26,55.41 367.35,55.41 arc(367.06,55.35) 366.81,55.18 arc(366.46,54.95) 366.04,54.86 365.28,54.86 arc(365.09,54.78) 365.01,54.59 365.01,54.32 arc(365.04,54.13) 365.15,53.97 YJ35.D2
FC63_TDP1: length 256.4
  TOP w0.147: v4(203.6,169.34) 203.55,169.34 U1.CC28
  SIG4 w0.112: v4(203.6,169.34) 203.82,169.34 arc(203.91,169.38) 203.95,169.47 203.95,169.62 arc(203.98,169.76) 204.05,169.87 arc(204.17,169.95) 204.3,169.98 204.68,169.98 arc(204.78,170) 204.87,170.06 arc(204.93,170.15) 204.95,170.25 204.95,173.69 204.86,173.78 204.86,173.81
  SIG4 w0.16: YJ35.D33 368.5,56.62 arc(368.58,57) 368.79,57.33 369.21,57.75 arc(369.28,57.85) 369.31,57.97 369.31,58.57 arc(369.34,58.72) 369.43,58.86 369.48,58.91 arc(369.61,59) 369.75,59.03 379.71,59.03 arc(380,59.08) 380.24,59.25 382.29,61.29 arc(382.45,61.54) 382.51,61.83 382.51,68.24 arc(382.45,68.53) 382.29,68.78 377.04,74.02 arc(376.88,74.13) 376.7,74.17 arc(376.51,74.2) 376.35,74.31 314.01,136.65 312.92,137.73 arc(307.65,141.25) 301.44,142.49 299.66,142.49 arc(290.2,144.37) 282.19,149.73 251.96,179.96 arc(251.71,180.13) 251.42,180.19 241.23,180.19 arc(240.94,180.24) 240.69,180.41 240.6,180.5 arc(240.35,180.66) 240.06,180.72 214.11,180.72 arc(213.82,180.66) 213.58,180.5 212.24,179.16 arc(212,179) 211.71,178.94 208.05,178.94 arc(207.76,178.88) 207.51,178.72 206.3,177.5 205.09,176.29 arc(204.92,176.04) 204.86,175.75 204.86,173.81
FC63_TDP2: length 274.6
  TOP w0.147: U1.CA27 204.05,166.9 arc(204.08,167.07) 204.18,167.21 204.24,167.27 arc(204.31,167.32) 204.4,167.34 v4(204.5,167.34)
  SIG4 w0.112: 203.24,172.97 203.15,172.88 203.15,168.18 arc(203.17,168.1) 203.21,168.04 arc(203.28,167.99) 203.35,167.98 203.79,167.98 arc(203.92,167.95) 204.04,167.87 204.05,167.86 arc(204.12,167.75) 204.15,167.63 204.15,167.47 arc(204.18,167.38) 204.27,167.34 v4(204.5,167.34)
  SIG4 w0.16: YJ35.D5 367.55,53.97 arc(367.44,54.13) 367.41,54.32 367.41,54.64 arc(367.47,54.8) 367.63,54.86 368.58,54.86 arc(368.87,54.92) 369.12,55.08 369.16,55.13 369.21,55.18 arc(369.46,55.35) 369.75,55.41 379.26,55.41 arc(379.41,55.44) 379.53,55.52 379.89,55.88 379.89,56.24 380.25,56.6 380.61,56.6 380.97,56.96 380.97,57.29 381.35,57.67 381.69,57.67 382.05,58.03 382.05,58.37 382.43,58.75 382.76,58.75 383.12,59.11 383.12,59.44 383.51,59.83 383.84,59.83 384.38,60.37 arc(384.46,60.49) 384.49,60.64 384.49,61.15 384.24,61.4 384.24,61.91 384.49,62.16 384.49,62.67 384.24,62.92 384.24,63.43 384.49,63.69 384.49,64.19 384.26,64.42 384.26,64.98 384.49,65.21 384.49,68.87 arc(384.46,69.02) 384.38,69.14 313.6,139.92 arc(308.78,143.14) 303.11,144.27 300.04,144.27 arc(290.86,146.09) 283.08,151.29 247.88,186.49 arc(245.42,188.14) 242.51,188.72 241.58,188.72 arc(237.41,187.89) 233.88,185.53 233.42,185.07 arc(231.41,183.73) 229.04,183.26 214.09,183.26 arc(213.94,183.23) 213.82,183.15 211.73,181.05 arc(211.36,180.81) 210.92,180.72 207.21,180.72 arc(207.06,180.69) 206.94,180.61 203.35,177.02 arc(203.27,176.89) 203.24,176.75 203.24,172.97
FC63_TDP3: length 256.8
  TOP w0.147: v4(205.6,172.34) 205.55,172.34 U1.CF26
  SIG5 w0.112: 204.86,173.71 204.86,173.68 204.95,173.59 204.95,173.18 arc(204.98,173.03) 205.06,172.9 arc(205.19,172.81) 205.35,172.78 205.79,172.78 arc(205.85,172.77) 205.9,172.73 205.91,172.72 arc(205.94,172.68) 205.95,172.63 205.95,172.47 arc(205.91,172.38) 205.82,172.34 v4(205.6,172.34)
  SIG5 w0.16: YJ35.D36 366.1,56.72 arc(366.16,57.01) 366.32,57.26 366.81,57.75 arc(366.88,57.85) 366.91,57.97 366.91,58.57 arc(366.91,58.6) 366.91,58.64 arc(366.91,58.65) 366.92,58.66 arc(366.96,58.76) 367.03,58.86 367.08,58.91 arc(367.21,59) 367.35,59.03 378.88,59.03 arc(379.17,59.08) 379.42,59.25 382.16,61.99 arc(382.33,62.24) 382.38,62.53 382.38,67.85 arc(382.3,68.29) 382.05,68.66 310.71,140 arc(310.34,140.25) 309.9,140.33 291.88,140.33 arc(291.58,140.39) 291.34,140.56 254.01,177.88 arc(253.77,178.04) 253.47,178.1 239.27,178.1 arc(238.98,178.16) 238.73,178.33 236.56,180.5 arc(236.32,180.66) 236.02,180.72 209.74,180.72 arc(209.48,180.67) 209.25,180.52 208.85,180.11 205.13,176.39 arc(205.09,176.34) 205.05,176.29 arc(204.91,175.98) 204.86,175.64 204.86,173.71
FC_PLL0_REFCLK_N: length 241.7
  TOP w0.107: v1(135.23,191.13) 135.04,191.13 134.77,190.87 134.77,160.94 140.2,155.52 153.87,155.52 154.44,154.95 154.44,153.88 154.61,153.72 154.93,153.72 155.03,153.82 C2721.1
  SIG4 w0.14: v1(135.23,191.13) 135.09,190.99 135.09,190.55 135.7,189.94 142.63,189.94 143.83,191.13 155.3,191.13 161.39,197.23 190.65,197.23 192.86,195.02 210.17,195.02 214.26,190.93 230.15,190.93 236.58,197.36 281.66,197.36 282.43,198.12 304.74,198.12 305.24,197.61 305.24,195.58 304.79,195.12 303.03,195.12 302.55,195.6 302.55,196.12 v1(302.45,196.22)
  BOTTOM w0.107: v1(302.45,196.22) 302.74,196.52 302.74,196.87 302.64,196.97 R3142.2
FC_PLL0_REFCLK_P: length 241.7
  TOP w0.107: v1(134.32,191.13) 134.44,191.01 134.44,160.81 140.06,155.19 153.73,155.19 154.11,154.81 154.11,153.74 154.47,153.39 154.8,153.39 C2928.1
  SIG4 w0.14: v1(303.37,196.22) 303.07,196.22 302.88,196.03 302.88,195.74 303.17,195.45 304.65,195.45 304.91,195.71 304.91,197.47 304.6,197.79 303.3,197.79 303.17,197.66 302.76,197.66 302.63,197.79 302.21,197.79 302.08,197.66 301.66,197.66 301.54,197.79 301.12,197.79 300.99,197.66 300.57,197.66 300.44,197.79 300.03,197.79 299.9,197.66 299.48,197.66 299.35,197.79 298.93,197.79 298.81,197.66 298.39,197.66 298.26,197.79 282.56,197.79 281.8,197.03 236.72,197.03 230.29,190.6 214.13,190.6 210.04,194.69 192.72,194.69 190.51,196.9 161.53,196.9 155.44,190.8 143.96,190.8 142.77,189.61 135.56,189.61 134.76,190.41 134.76,190.95 134.58,191.13 v1(134.32,191.13)
  BOTTOM w0.107: v1(303.37,196.22) 303.07,196.52 303.07,196.86 303.19,196.97 R3138.2
FC_PLL1_REFCLK_N: length 269.6
  TOP w0.107: C17.1 154.8,128.5 154.27,128.5 154.01,128.75 147.32,128.75 145.79,127.23 139.2,127.23 129.06,137.36 129.06,190.98 v1(128.91,191.13)
  SIG4 w0.14: v1(128.91,191.13) 129.04,190.99 129.04,190.42 131.89,187.58 145.22,187.58 146.93,189.28 156.16,189.28 161.62,194.74 189.75,194.74 192.85,191.64 202.03,191.64 204.57,189.1 231.54,189.1 237.82,195.37 268.91,195.37 270.82,193.47 298.56,193.47 300.06,194.97 v1(300.06,196.22)
  BOTTOM w0.107: R3144.2 299.89,196.97 299.77,196.86 299.77,196.52 v1(300.06,196.22)
FC_PLL1_REFCLK_P: length 269.6
  TOP w0.107: C18.1 155.03,129.02 154.84,128.83 154.4,128.83 154.15,129.08 147.18,129.08 145.66,127.56 139.33,127.56 129.39,137.5 129.39,191.01 129.51,191.13 v1(129.82,191.13)
  SIG4 w0.14: v1(129.82,191.13) 129.55,191.13 129.38,190.95 129.38,190.56 129.75,190.18 129.93,190.18 130.23,189.89 130.23,189.71 130.52,189.41 130.7,189.41 131,189.11 131,188.93 132.03,187.91 132.52,187.91 132.65,188.03 133.06,188.03 133.19,187.91 133.61,187.91 133.74,188.03 134.16,188.03 134.28,187.91 145.09,187.91 146.79,189.61 156.02,189.61 161.48,195.07 189.89,195.07 192.99,191.97 202.17,191.97 204.71,189.43 231.41,189.43 237.68,195.7 269.05,195.7 270.95,193.8 298.43,193.8 299.73,195.1 299.73,195.86 299.37,196.22 v1(299.15,196.22)
  BOTTOM w0.107: v1(299.15,196.22) 299.44,196.52 299.44,196.87 299.34,196.97 R3145.2
FC_PLL2_REFCLK_N: length 98.2
  TOP w0.107: C19.1 247.62,143.99 247.47,144.14 247.47,147.84 249.82,150.19 249.82,175.71 251.27,177.16 251.27,186.05 260.59,195.37 278.18,195.37 280.39,193.16 283.01,193.16 283.15,193.03 283.15,192.43 283.05,192.33 v1(282.85,192.33)
  BOTTOM w0.107: R3146.2 296,196.97 296.15,196.82 296.15,195.76 293.64,193.24 283.48,193.24 283.15,192.91 283.15,192.4 283.08,192.33 v1(282.85,192.33)
FC_PLL2_REFCLK_P: length 99.1
  TOP w0.107: C20.1 247.05,143.99 247.14,144.08 247.14,147.98 249.49,150.32 249.49,175.85 250.94,177.3 250.94,186.19 260.45,195.7 278.32,195.7 280.53,193.49 283.15,193.49 283.48,193.16 283.48,192.63 v1(283.77,192.33)
  BOTTOM w0.107: v1(283.77,192.33) 283.6,192.33 283.48,192.45 283.48,192.77 283.61,192.91 293.77,192.91 296.48,195.62 296.48,196.85 296.61,196.97 R3147.2
FC_PLL3_REFCLK_N: length 88.3
  TOP w0.107: C3108.1 245.81,153.64 245.96,153.79 245.96,175.37 249.03,178.44 249.03,187.12 259.65,197.74 281.24,197.74 283.5,195.48 283.5,194.85 v1(283.77,194.58)
  BOTTOM w0.107: R3153.2 293.55,196.97 293.42,196.85 293.42,196.2 293.05,195.83 283.86,195.83 283.48,195.45 283.48,194.88 v1(283.77,194.58)
FC_PLL3_REFCLK_P: length 87.2
  TOP w0.107: v1(282.85,194.58) 283.17,194.9 283.17,195.34 281.1,197.41 259.79,197.41 249.36,186.98 249.36,178.31 246.29,175.23 246.29,153.82 246.47,153.64 C3142.1
  BOTTOM w0.107: v1(282.85,194.58) 283.15,194.88 283.15,195.59 283.72,196.16 292.92,196.16 293.09,196.34 293.09,196.85 292.96,196.97 R3154.2
FC_TRVDD0P8_0: length 149.6
  TOP w0.229: v1(170.56,155.37) 170.56,155.35 170.55,155.34 U1.BJ60 ; U1.BY65 165.57,166.32 v1(165.55,166.32) ; U1.BM58 v1(172.55,158.34) ; U1.CE62 168.55,171.34 v1(168.52,171.34) ; U1.BP47 v1(183.55,160.34) ; U1.AT65 166,141.84 v1(165.55,142.29) ; U1.BC65 165.55,149.34 v1(165.55,149.37) ; U1.BF56 v1(174.55,152.34) ; U1.BV44 186.55,164.34 v1(186.55,164.29) ; U1.BT65 166,161.84 165.55,162.29 v1(165.5,162.29) ; U1.CF52 v1(178.55,172.34) ; v1(185.52,171.34) 185.55,171.34 U1.CE45 ; U1.CF62 v1(168.55,172.34) ; v1(190.6,168.39) 190.6,168.34 191.01,167.93 arc(191.04,167.89) U1.CB40 ; v1(174.56,155.37) 174.56,155.35 174.55,155.34 U1.BJ56 ; U1.AY59 v1(171.55,146.34) ; U1.BW38 192.55,165.34 192.56,165.36 v1(192.56,165.37) ; U1.BT51 v1(179.55,162.34) ; v1(170.55,152.32) 170.55,152.34 U1.BF60 ; U1.BC58 v1(172.55,149.34) ; v1(168.55,148.29) 169,147.84 U1.BB62 ; v1(191.5,168.39) 191.5,168.37 191.52,168.34 191.55,168.34 U1.CB39 ; U1.CA57 v1(173.55,167.34) ; U1.BR58 v1(172.55,161.34) ; v1(168.55,160.29) 168.55,160.34 U1.BP62 ; U1.AU60 v1(170.55,143.34) ; U1.BD65 165.95,149.84 v1(165.5,150.29) ; U1.BP44 v1(186.55,160.34) ; U1.BV47 v1(183.55,164.34) ; U1.BJ54 176.54,155.35 v1(176.56,155.35) ; U1.BJ62 168.55,155.34 v1(168.55,155.37) ; U1.CF56 v1(174.55,172.34) ; U1.BV35 v1(195.55,164.34) ; U1.BT47 v1(183.55,162.34) ; U1.CB48 182.55,168.34 182.57,168.34 v1(182.6,168.32) ; U1.AY54 v1(176.5,146.39) ; U1.BW65 165.55,165.34 v1(165.55,165.37) ; U1.CB47 183.55,168.34 v1(183.55,168.32) ; U1.BP38 v1(192.55,159.34) ; v1(189.55,160.37) 189.55,160.34 U1.BP41 ; U1.BV51 v1(179.55,164.34) ; U1.CF58 v1(172.55,172.34) ; U1.AU54 v1(176.55,143.34) ; U1.AY56 v1(174.55,146.34) ; v1(180.57,166.34) 180.55,166.34 U1.BY50 ; v1(168.5,147.37) 168.52,147.37 U1.BA62 ; U1.BF54 v1(176.55,152.34) ; U1.BY44 186.55,166.34 v1(186.55,166.34) ; U1.BY51 v1(179.55,166.34) ; U1.CA54 v1(176.55,167.34) ; U1.CB36 195.05,167.89 v1(194.6,168.34) ; U1.BG65 165.55,153.34 v1(165.55,153.4) ; U1.BR56 v1(174.55,161.34) ; v1(189.5,171.37) 189.52,171.34 189.55,171.34 U1.CE41 ; U1.AV62 v1(168.55,144.34) ; v1(176.5,161.39) 176.5,161.37 176.52,161.34 176.55,161.34 U1.BR54 ; U1.CF55 v1(175.55,172.34) ; U1.BW54 v1(176.55,165.34) ; U1.BV50 v1(180.55,164.34) ; U1.CF59 v1(171.55,172.34) ; v1(165.52,141.39) 165.55,141.37 165.55,141.34 U1.AR65 ; U1.BV54 v1(176.55,164.34) ; U1.BT38 v1(192.55,162.34) ; U1.CB35 v1(195.55,168.34) ; v1(188.6,171.34) 189.05,170.89 U1.CE42 ; v1(168.55,159.39) 168.55,159.34 U1.BN62 ; U1.AP56 v1(174.55,140.34) ; U1.BR60 v1(170.55,161.34) ; U1.BT50 v1(180.55,162.34) ; U1.BK62 168.57,156.32 v1(168.52,156.32) ; v1(168.55,167.37) 168.55,167.34 U1.CA62 ; U1.BC56 v1(174.55,149.34) ; U1.BR65 v1(165.55,161.34) ; v1(165.52,154.32) 165.57,154.32 U1.BH65 ; U1.AU56 v1(174.55,143.34) ; U1.AU58 v1(172.55,143.34) ; U1.BC59 v1(171.55,149.34) ; U1.BW41 v1(189.55,165.34) ; v1(168.55,168.32) 168.55,168.34 U1.CB62 ; U1.CC57 v1(173.55,169.34) ; U1.CC54 v1(176.55,169.34) ; U1.AP54 v1(176.55,140.34) ; U1.BJ58 172.55,155.34 172.56,155.35 v1(172.56,155.37) ; v1(189.55,164.37) 189.55,164.34 U1.BV41 ; v1(172.55,152.32) 172.55,152.34 U1.BF58 ; U1.AU62 v1(168.55,143.34) ; U1.BM56 v1(174.55,158.34) ; v1(184.57,171.37) 184.57,171.32 U1.CE46 ; U1.BT41 v1(189.55,162.34) ; U1.BM60 v1(170.55,158.34) ; U1.AY58 v1(172.55,146.34) ; U1.BW57 v1(173.55,165.34) ; U1.BT44 v1(186.55,162.34) ; U1.BM54 v1(176.55,158.34) ; U1.BC54 v1(176.55,149.34) ; U1.BY47 v1(183.55,166.34) ; U1.BV38 v1(192.55,164.34) ; U1.CF53 v1(177.55,172.34)
  BOTTOM w0.381: C391.1 168.55,160.33 v1(168.55,160.29) ; C438.1 192.55,165.38 192.55,165.37 192.56,165.35 v1(192.56,165.37) ; v1(174.55,146.34) 174.55,146.29 C3145.1 ; C435.1 192.55,162.38 v1(192.55,162.34) ; v1(175.55,172.34) 176.03,171.86 C455.1 ; v1(180.55,162.34) 180.06,161.85 C426.1 ; C411.1 189.08,160.83 v1(189.55,160.37) ; v1(194.6,168.34) 194.54,168.34 C446.1 ; v1(172.55,152.32) 173.02,151.85 C2980.1 ; C429.1 179.05,161.84 v1(179.55,162.34) ; C3046.1 171.55,149.32 v1(171.55,149.34) ; C434.1 176.55,164.36 v1(176.55,164.34) ; v1(168.55,172.34) 168.05,171.84 C454.1 ; v1(183.55,160.34) 183.09,160.8 C407.1 ; C421.1 165.58,162.34 165.57,162.34 165.52,162.29 v1(165.5,162.29) ; v1(186.55,160.34) 187.04,160.83 C410.1 ; C2979.1 165.55,161.32 v1(165.55,161.34) ; v1(170.55,161.34) 170.55,161.34 C3192.1 ; C389.1 170.55,158.34 v1(170.55,158.34) 170.55,158.34 C399.1 ; C403.1 171.04,151.82 v1(170.55,152.32) ; C3023.1 174.58,149.34 v1(174.55,149.34) ; v1(168.52,156.32) 168.52,156.34 169,156.82 C393.1 ; v1(171.55,172.34) 171.06,171.85 C464.1 ; C3154.1 174.57,143.34 v1(174.55,143.34) ; v1(176.55,152.34) 176.56,152.34 C3027.1 ; v1(165.55,166.32) 165.55,166.34 166.06,166.86 C420.1 ; C431.1 179.55,166.35 v1(179.55,166.34) ; v1(183.55,162.34) 183.05,161.84 C424.1 ; C398.1 172.55,158.34 v1(172.55,158.34) ; v1(176.55,158.34) 176.55,158.29 C396.1 ; C466.1 173.55,169.29 v1(173.55,169.34) ; C444.1 173.55,167.36 v1(173.55,167.34) ; v1(189.5,171.37) 189.5,171.34 190.03,170.81 C451.1 ; C2827.1 175.07,154.86 v1(174.56,155.37) ; v1(184.57,171.37) 184.57,171.34 184.07,171.84 C443.1 ; v1(176.55,169.34) 176.55,169.29 C456.1 ; v1(176.5,161.39) 176.5,161.37 176.55,161.32 176.55,161.29 C413.1 ; v1(168.55,168.32) 168.08,168.79 C450.1 ; v1(182.6,168.32) 182.05,168.86 C461.1 ; v1(192.55,164.34) 192.55,164.39 C439.1 ; C3013.1 165.05,140.9 165.55,141.39 v1(165.52,141.39) ; v1(172.55,146.34) 172.55,146.3 C2973.1 ; v1(172.55,149.34) 172.55,149.34 C2972.1 ; C3085.1 174.58,152.34 v1(174.55,152.34) ; C423.1 183.51,164.34 v1(183.55,164.34) ; v1(192.55,159.34) 192.08,159.81 C412.1 ; C3125.1 165.05,142.81 165.55,142.32 v1(165.55,142.29) ; C432.1 176.55,165.38 v1(176.55,165.34) ; v1(186.55,162.34) 186.54,162.34 C416.1 ; C3120.1 170.53,143.34 v1(170.55,143.34) ; v1(168.55,159.39) 168.04,158.89 C395.1 ; 168.08,148.85 168.08,148.76 v1(168.55,148.29) ; v1(165.55,153.4) 165.55,153.33 C408.1 ; v1(165.5,150.29) 165.55,150.29 166.08,150.82 C3073.1 ; v1(191.5,168.39) 191.07,167.97 C448.1 ; C400.1 174.55,161.34 v1(174.55,161.34) ; C3016.1 174.55,140.13 v1(174.55,140.34) ; v1(176.55,143.34) 176.56,143.34 C3090.1 ; v1(176.55,140.34) 176.55,140.13 C3187.1 ; v1(172.55,143.34) 172.55,143.36 C2968.1 ; C419.1 190.06,164.83 v1(189.55,165.34) ; v1(176.5,146.39) 176.5,146.37 176.55,146.32 176.55,146.31 C3140.1 ; v1(165.55,149.37) 165.55,149.32 C3113.1 ; C449.1 186.06,171.88 v1(185.52,171.34) ; C409.1 172.1,154.91 v1(172.56,155.37) ; C427.1 v1(180.55,164.34) ; v1(168.55,155.37) 168.08,154.9 168.08,154.84 ; C467.1 188.55,171.34 v1(188.6,171.34) ; C417.1 186.07,163.81 v1(186.55,164.29) ; C436.1 195.57,164.34 v1(195.55,164.34) ; v1(176.56,155.35) 177.06,154.85 C397.1 ; C3007.1 168.03,146.91 v1(168.5,147.37) ; v1(172.55,161.34) 172.55,161.34 C401.1 ; C460.1 176.55,167.36 v1(176.55,167.34) ; v1(174.55,172.34) 174.55,172.29 C459.1 ; C3100.1 v1(171.55,146.34) ; C430.1 179.05,163.85 v1(179.55,164.34) ; v1(180.57,166.34) 180.55,166.37 180.55,166.37 C428.1 ; v1(189.55,164.37) 189.08,163.9 C440.1 ; v1(165.55,165.37) 165.55,165.33 C422.1 ; C433.1 173.55,165.29 v1(173.55,165.34) ; C437.1 189.06,161.86 v1(189.55,162.34) ; v1(183.55,166.34) 183.55,166.32 C425.1 ; C3103.1 168.55,143.31 v1(168.55,143.34) ; v1(186.55,166.34) 186.58,166.34 C418.1 ; v1(172.55,172.34) 172.06,171.86 C465.1 ; v1(168.55,144.34) 168.05,143.84 C2884.1 ; v1(168.52,171.34) 168.52,171.31 168.07,170.86 C452.1 ; v1(174.55,158.34) 174.55,158.34 C405.1 ; v1(183.55,168.32) 184.07,168.84 C462.1 ; v1(177.55,172.34) 177.55,172.31 C457.1 ; v1(176.55,149.34) 176.59,149.34 C3081.1 ; v1(170.56,155.37) 170.09,154.9 C406.1 ; v1(168.55,167.37) 169.08,166.84 C453.1 ; v1(190.6,168.39) 190.6,168.38 C463.1 ; C402.1 166.06,154.86 v1(165.52,154.32) ; C458.1 178.55,172.41 v1(178.55,172.34) ; C445.1 195.05,167.84 v1(195.55,168.34) C447.1
  BOTTOM w0.508: C3015.1 151.3,145.97 v1(151.45,146.12) ; C3015.1 150.41,146.78 ; C3015.1 149.62,145.97 ; C415.1 154.24,156.84 ; C415.1 153.56,157.53 ; C415.1 154.24,158.24 ; 153.35,154.81 153.38,154.79 C2693.1 154.24,153.92
  vias: v1(148.37,161.24) v1(148.53,152.27) v1(148.63,149.41) v1(148.65,146.43) v1(149.01,161.87) v1(149.29,156.08) v1(149.42,153.16) v1(149.42,147.19) v1(149.52,150.29) v1(149.7,159.56) v1(150.05,156.84) v1(150.05,147.83) v1(150.3,151.08) v1(150.51,160.37) v1(150.91,157.86) v1(151.57,158.49) v1(152.03,146.83) v1(152.9,147.7) v1(153.23,160.14) v1(153.81,146.81) v2(154.75,161.54)
FC_TRVDD0P8_1: length 146.6
  TOP w0.229: v1(165.5,125.29) U1.Y65 ; v1(171.56,112.37) 171.56,112.35 U1.G59 ; U1.AP60 v1(170.55,140.34) ; U1.G47 v1(183.55,112.34) ; v1(165.5,113.27) 166.05,113.82 U1.H65 ; U1.AE62 168.55,130.34 v1(168.55,130.37) ; U1.F62 168.55,111.34 v1(168.55,111.29) ; U1.B62 168.58,107.37 v1(168.58,107.31) ; v1(165.55,128.4) 165.99,128.84 U1.AC65 ; v1(178.55,106.34) 178.55,106.34 U1.A52 ; U1.V62 168.55,123.34 v1(168.55,123.29) ; U1.E40 191.05,110.79 190.6,110.34 190.6,110.32 190.59,110.32 190.59,110.32 190.56,110.3 v1(190.56,110.31) ; v1(184.6,107.34) 184.55,107.34 U1.B46 ; U1.AH54 176.6,133.39 v1(176.5,133.39) ; U1.W54 v1(176.55,124.34) ; U1.W58 v1(172.55,124.34) ; v1(189.52,114.34) 189.55,114.34 U1.J41 ; U1.P62 168.55,119.34 v1(168.55,119.32) ; U1.D56 v1(174.55,109.34) ; v1(176.52,109.37) 176.55,109.34 U1.D54 ; U1.AB60 170.56,127.35 170.56,127.32 170.55,127.32 v1(170.55,127.32) ; U1.T56 v1(174.55,121.34) ; U1.E62 169,110.84 v1(168.55,110.39) ; v1(174.56,112.37) 174.57,112.37 U1.G56 ; v1(168.5,122.39) 168.6,122.39 U1.U62 ; v1(170.55,118.37) 170.55,118.34 U1.N60 ; U1.E48 v1(182.55,110.34) ; U1.B41 189.52,107.31 v1(189.52,107.31) ; v1(189.5,113.32) 189.52,113.34 189.55,113.34 U1.H41 ; U1.N38 v1(192.55,118.34) ; v1(165.55,136.37) 165.57,136.37 U1.AL65 ; U1.D59 v1(171.55,109.34) ; U1.K58 172.55,115.34 v1(172.55,115.32) ; U1.AB58 172.55,127.34 v1(172.55,127.32) ; v1(165.55,112.37) 165.55,112.34 U1.G65 ; v1(183.5,110.34) 183.55,110.34 U1.E47 ; U1.L41 189.55,116.34 189.54,116.34 v1(189.52,116.35) ; U1.G54 v1(176.55,112.34) ; v1(168.55,118.37) 168.55,118.34 U1.N62 ; v1(168.5,134.39) 168.55,134.39 168.96,134.81 arc(169,134.83) U1.AJ62 ; U1.AL59 v1(171.55,136.34) ; U1.L38 v1(192.55,116.34) ; U1.AP58 v1(172.55,140.34) ; U1.W65 v1(165.55,124.34) ; U1.N56 v1(174.55,118.34) ; v1(188.57,107.34) 188.57,107.37 U1.B42 ; U1.N54 v1(176.55,118.34) ; U1.W56 v1(174.55,124.34) ; U1.T58 v1(172.55,121.34) ; U1.N44 v1(186.55,118.34) ; U1.K60 170.55,115.34 v1(170.55,115.32) ; U1.G58 172.56,112.35 v1(172.56,112.37) ; U1.AE54 v1(176.55,130.34) ; v1(176.58,106.36) 176.87,106.65 176.87,106.66 U1.A54 ; U1.T54 176.55,121.34 v1(176.5,121.34) ; U1.N47 v1(183.55,118.34) ; U1.AL58 v1(172.55,136.34) ; U1.M65 165.55,117.34 v1(165.55,117.32) ; U1.AL56 v1(174.55,136.34) ; U1.J38 v1(192.55,114.34) ; U1.A59 v1(171.55,106.34) ; U1.AK62 168.55,135.34 v1(168.55,135.29) ; U1.E36 194.57,110.37 v1(194.57,110.34) ; U1.D52 v1(178.55,109.34) ; U1.AB54 v1(176.55,127.34) ; U1.AF62 168.55,131.34 v1(168.55,131.32) ; U1.E35 v1(195.55,110.34) ; U1.K54 v1(176.55,115.34) ; U1.L47 v1(183.55,116.34) ; U1.AH59 v1(171.55,133.34) ; U1.AH56 v1(174.55,133.34) ; v1(165.52,116.34) 165.55,116.34 U1.L65 ; U1.J47 v1(183.55,114.34) ; U1.AE60 v1(170.55,130.34) ; U1.W59 v1(171.55,124.34) ; U1.N58 v1(172.55,118.34) ; v1(165.5,137.29) U1.AM65 ; U1.G44 v1(186.55,112.34) ; U1.B45 185.53,107.32 v1(185.53,107.3) ; U1.L44 v1(186.55,116.34) ; U1.N41 v1(189.55,118.34) ; U1.A62 168.57,106.37 168.57,106.35 v1(168.56,106.34) ; U1.J44 v1(186.55,114.34) ; U1.AH58 v1(172.55,133.34) ; U1.AD65 v1(165.52,129.32) ; U1.H38 v1(192.55,113.34) ; U1.AE58 v1(172.55,130.34) ; U1.N35 v1(195.55,118.34) ; U1.AE56 v1(174.55,130.34) ; U1.E39 v1(191.54,110.33) ; U1.L35 v1(195.55,116.34) ; U1.T59 v1(171.55,121.34) ; U1.K56 v1(174.55,115.34) ; U1.AL54 v1(176.55,136.34) ; U1.A56 v1(174.55,106.34) ; U1.AB56 v1(174.55,127.34)
  TOP w0.381: 149.71,132.36 C523.1 ; C523.1 150.3,131.72 ; C523.1 150.9,132.36 ; C469.1 148.62,118.97 ; C469.1 147.42,118.97 ; C469.1 148.02,119.61 ; C496.1 150.94,119.61 ; C496.1 150.34,118.97 ; C496.1 151.54,118.97
  BOTTOM w0.381: v1(171.55,124.34) 171.55,124.34 C546.1 ; C569.1 172.59,136.34 v1(172.55,136.34) ; C500.1 183.07,114.82 v1(183.55,114.34) ; v1(174.55,130.34) 174.55,130.34 C574.1 ; C476.1 189.05,106.86 189.5,107.31 v1(189.52,107.31) ; v1(174.55,106.34) 174.55,106.17 C472.1 ; C557.1 171.57,136.34 v1(171.55,136.34) ; v1(176.55,124.34) 176.55,124.32 C545.1 ; C570.1 174.55,133.31 v1(174.55,133.34) 174.08,133.81 C559.1 ; v1(165.55,136.37) 165.55,136.31 C564.1 ; C531.1 168.03,123.81 v1(168.55,123.29) ; v1(176.55,136.34) 176.59,136.34 C555.1 ; v1(186.55,118.34) 187.06,117.83 C548.1 ; C513.1 176.55,115.29 v1(176.55,115.34) ; C509.1 186.05,113.85 v1(186.55,114.34) ; C517.1 192.06,115.86 v1(192.55,116.34) ; C533.1 168.08,117.9 v1(168.55,118.37) ; C488.1 176.55,109.32 176.52,109.35 v1(176.52,109.37) ; C493.1 174.55,109.32 v1(174.55,109.34) ; v1(168.55,135.29) 168.55,135.38 C565.1 ; v1(165.55,124.34) 165.55,124.33 C534.1 ; C532.1 165.5,125.42 v1(165.5,125.29) ; v1(168.5,134.39) 168.55,134.34 168.55,134.32 C566.1 ; C494.1 171.55,109.3 v1(171.55,109.34) ; v1(172.55,133.34) 172.55,133.34 C571.1 ; C502.1 165.55,117.4 v1(165.55,117.32) ; v1(176.55,118.34) 176.55,118.29 C536.1 ; v1(176.55,127.34) 176.58,127.34 C535.1 ; v1(168.58,107.31) 168.58,107.41 C483.1 ; C521.1 190.02,114.84 v1(189.52,114.34) ; C477.1 189.05,107.84 188.57,107.37 v1(188.57,107.34) ; C484.1 185.07,106.84 v1(185.53,107.3) ; C526.1 171.06,117.86 v1(170.55,118.37) ; C539.1 183.07,117.86 v1(183.55,118.34) ; C491.1 195.06,109.86 v1(194.57,110.34) ; v1(171.55,133.34) 171.55,133.38 C572.1 ; 168.08,129.84 168.55,130.31 v1(168.55,130.37) ; C528.1 168.5,122.34 v1(168.5,122.39) ; C487.1 176.55,112.29 v1(176.55,112.34) ; C567.1 172.55,140.39 v1(172.55,140.34) 172.55,140.2 C562.1 ; v1(192.55,118.34) 192.06,117.86 C543.1 ; C475.1 191.05,109.85 v1(191.54,110.33) ; v1(174.55,136.34) 174.59,136.34 C554.1 ; v1(184.6,107.34) 185.05,107.79 C479.1 ; C516.1 190.03,113.85 v1(189.5,113.32) 189.99,112.83 C518.1 ; v1(168.55,111.29) 168.55,111.4 C482.1 ; C541.1 174.55,127.31 v1(174.55,127.34) ; v1(170.55,130.34) 171.05,129.84 C561.1 ; v1(170.55,115.32) 170.55,115.3 C497.1 ; C486.1 184.02,110.86 v1(183.5,110.34) ; C520.1 187.06,115.83 v1(186.55,116.34) ; v1(183.55,116.34) 183.07,115.86 C501.1 ; v1(171.55,106.34) 171.55,106.17 C473.1 ; C507.1 165.55,112.32 v1(165.55,112.37) ; C542.1 190.03,117.86 v1(189.55,118.34) ; C537.1 v1(171.55,121.34) ; v1(172.55,121.34) 172.55,121.33 C525.1 ; C568.1 170.55,140.38 v1(170.55,140.34) ; C556.1 168.55,131.35 v1(168.55,131.32) ; v1(172.56,112.37) 172.1,111.91 C511.1 ; C529.1 172.08,126.85 v1(172.55,127.32) ; C558.1 170.07,126.84 v1(170.55,127.32) ; v1(176.5,133.39) 176.5,133.37 176.55,133.32 176.55,133.3 C575.1 ; C498.1 172.08,114.84 v1(172.55,115.32) ; v1(195.55,118.34) 195.08,118.81 C505.1 ; C492.1 191.05,110.8 v1(190.56,110.31) ; C499.1 165.04,115.86 v1(165.52,116.34) 165.55,116.34 166.07,115.82 C515.1 ; C470.1 178.58,106.34 v1(178.55,106.34) ; C508.1 165.5,113.41 v1(165.5,113.27) ; v1(192.55,113.34) 192.03,112.83 C506.1 ; v1(176.55,130.34) 176.55,130.33 C573.1 ; v1(172.55,130.34) 172.55,130.35 C560.1 ; v1(165.55,128.4) 166.08,127.87 C551.1 ; C490.1 195.55,110.35 v1(195.55,110.34) ; v1(195.55,116.34) 195.08,116.81 C504.1 ; C544.1 v1(174.55,124.34) ; C503.1 190.01,115.86 v1(189.52,116.35) ; v1(174.55,121.34) 174.55,121.32 C524.1 ; C563.1 165.5,137.38 v1(165.5,137.29) ; C514.1 174.1,111.91 v1(174.56,112.37) ; v1(182.55,110.34) 183.03,109.86 C485.1 ; C519.1 192.06,113.86 v1(192.55,114.34) ; v1(176.58,106.36) 176.58,106.2 C471.1 ; v1(165.52,129.32) 165.52,129.41 C552.1 ; C512.1 174.09,114.88 v1(174.55,115.34) ; v1(186.55,112.34) 186.03,112.86 C478.1 ; v1(172.55,118.34) 173.06,117.83 C540.1 ; v1(168.56,106.34) 168.57,106.34 168.59,106.32 C481.1 ; v1(178.55,109.34) 179.04,109.84 C489.1 ; C474.1 184.02,111.87 v1(183.55,112.34) ; v1(172.55,124.34) 172.55,124.3 C547.1 ; v1(174.55,118.34) 174.55,118.32 C538.1 ; C480.1 169.07,109.87 v1(168.55,110.39) ; C530.1 168.55,119.38 v1(168.55,119.32) ; v1(176.5,121.34) 176.55,121.34 177.07,120.83 C527.1 ; C510.1 171.06,111.87 v1(171.56,112.37)
  vias: v1(146.39,122.68) v1(146.44,121.66) v1(146.44,120.55) v1(147.54,122.68) v1(147.56,121.66) v1(147.71,130.6) v1(148.45,131.34) v1(148.65,122.68) v1(149.16,132.08) v1(149.19,120.27) v1(149.17,119.36) v1(150.25,130.12) v1(151.19,121.79) v1(152.77,119.2) v1(153.35,123.06) v1(153.35,119.96) v2(156.4,124.08)
FC_TRVDD0P8_2: length 149.4
  TOP w0.229: U1.H29 202.52,113.37 v1(202.52,113.28) ; U1.A8 v1(223.55,106.34) ; v1(207.57,110.32) 207.57,110.34 207.07,110.84 U1.E24 ; v1(205.57,116.34) 205.55,116.34 U1.L26 ; U1.AB7 v1(224.55,127.34) ; U1.J20 v1(211.55,114.34) ; U1.A5 226.55,106.34 v1(226.49,106.34) ; U1.M2 229.05,117.95 v1(228.61,118.39) ; U1.AL8 223.1,136.84 223.55,136.39 v1(223.61,136.39) ; v1(226.55,122.37) 226.55,122.34 U1.U5 ; U1.AF5 226.55,131.34 v1(226.55,131.32) ; U1.AJ5 v1(226.54,134.35) ; U1.N23 v1(208.55,118.34) ; U1.AD2 229.55,129.34 v1(229.55,129.29) ; v1(226.55,118.39) 226.1,118.84 U1.N5 ; U1.B18 213.55,107.34 v1(213.57,107.34) ; U1.G20 v1(211.55,112.34) ; v1(210.5,107.28) 210.5,107.39 U1.B21 ; v1(199.55,116.34) U1.L32 ; U1.T9 v1(222.55,121.34) ; U1.H2 229.6,113.29 v1(229.61,113.29) ; U1.AB13 v1(218.55,127.34) ; U1.K11 v1(220.55,115.34) ; v1(199.55,118.34) U1.N32 ; U1.L23 v1(208.55,116.34) ; v1(199.55,114.34) U1.J32 ; v1(204.52,110.34) 204.55,110.34 U1.E27 ; v1(202.53,107.3) 202.53,107.31 202.53,107.31 202.05,107.79 U1.B29 ; U1.W2 229.5,124.39 v1(229.55,124.39) ; U1.G23 v1(208.55,112.34) ; U1.B17 214.5,107.39 v1(214.5,107.28) ; v1(222.54,136.35) U1.AL9 ; U1.B5 226.55,107.34 v1(226.49,107.34) ; U1.W9 222.55,124.34 v1(222.55,124.37) ; U1.N8 v1(223.55,118.34) ; U1.T13 v1(218.55,121.34) ; U1.AE9 v1(222.55,130.34) ; U1.AH13 v1(218.55,133.34) ; U1.D8 223.55,109.34 v1(223.55,109.32) ; v1(223.61,112.39) 223.56,112.39 223.46,112.43 U1.G8 ; U1.K9 v1(222.55,115.34) ; U1.B34 v1(196.55,107.34) ; U1.N11 v1(220.55,118.34) ; U1.G13 v1(218.55,112.34) ; U1.T8 v1(223.55,121.34) ; v1(201.57,107.34) 201.55,107.34 U1.B30 ; v1(220.55,112.37) 220.55,112.34 U1.G11 ; v1(226.55,110.37) 226.55,110.34 U1.E5 ; v1(229.61,116.39) 229.5,116.39 U1.L2 ; U1.J35 v1(195.55,114.34) ; U1.AE13 v1(218.55,130.34) ; v1(218.52,106.34) 218.55,106.34 U1.A13 ; v1(202.54,114.34) 202.55,114.34 U1.J29 ; U1.N13 v1(218.55,118.34) ; U1.T11 v1(220.55,121.34) ; U1.N9 v1(222.55,118.34) ; U1.E23 208.05,110.79 v1(208.5,110.34) ; v1(202.55,118.34) U1.N29 ; U1.G35 v1(195.55,112.34) ; U1.AK5 226.06,135.84 226.6,135.3 v1(226.6,135.28) ; U1.B22 209.55,107.34 v1(209.6,107.34) ; U1.AH11 v1(220.55,133.34) ; v1(198.5,107.28) 198.05,107.73 U1.B33 ; U1.J26 v1(205.55,114.34) ; U1.A15 v1(216.55,106.34) ; U1.AE7 v1(224.55,130.34) ; U1.AB9 v1(222.55,127.34) ; U1.N20 v1(211.55,118.34) ; U1.W13 v1(218.55,124.34) ; v1(203.6,110.28) 203.6,110.29 U1.E28 ; v1(220.49,106.34) 220.55,106.34 U1.A11 ; v1(205.57,118.34) 205.55,118.34 U1.N26 ; U1.D13 v1(218.55,109.34) ; U1.H26 v1(205.55,113.34) ; U1.K13 v1(218.55,115.34) ; U1.AB11 v1(220.55,127.34) ; U1.F5 226.55,111.34 226.55,111.3 226.56,111.29 v1(226.58,111.29) ; v1(226.55,119.32) 226.55,119.34 U1.P5 ; v1(229.61,125.29) 229.6,125.29 U1.Y2 ; U1.AC2 229.14,128.84 v1(229.59,128.39) ; U1.J23 v1(208.55,114.34) ; v1(223.61,124.39) 223.55,124.39 223.14,124.81 arc(223.1,124.83) U1.W8 ; U1.AH9 v1(222.55,133.34) ; v1(220.54,124.36) 220.07,124.84 U1.W11 ; U1.G2 229.5,112.39 v1(229.55,112.39) ; U1.AE11 v1(220.55,130.34) ; U1.AH8 v1(223.55,133.34) ; U1.AE5 226.1,130.84 v1(226.55,130.39) ; U1.V5 226.22,123.67 226.55,123.34 226.55,123.3 226.56,123.29 v1(226.58,123.29) ; v1(222.55,112.37) 222.55,112.34 U1.G9 ; U1.K7 v1(224.55,115.34) ; v1(199.55,112.34) U1.G32 ; v1(202.54,116.34) 202.55,116.34 U1.L29 ; U1.L20 v1(211.55,116.34) ; U1.D15 v1(216.55,109.34) ; U1.D11 v1(220.55,109.34)
  TOP w0.381: C604.1 240.91,106.22 ; C604.1 240.91,105.02 ; C604.1 240.27,105.62 ; 240.27,107.13 C631.1 ; C631.1 240.91,106.54 ; C631.1 240.91,107.73
  SIG7 w0.254: 229.04,111.63 229.55,112.13 v1(229.55,112.39)
  BOTTOM w0.381: C634.1 212.04,118.84 v1(211.55,118.34) ; v1(201.57,107.34) 202.05,106.87 C590.1 ; v1(223.55,109.32) 223.52,109.34 223.5,109.34 C592.1 ; v1(226.54,134.35) 227.06,133.83 C672.1 ; C588.1 203.07,110.86 203.6,110.33 v1(203.6,110.28) ; C636.1 199.08,116.81 v1(199.55,116.34) ; v1(229.61,113.29) 229.59,113.29 C618.1 ; C674.1 223.55,133.38 v1(223.55,133.34) 223.55,133.32 C663.1 ; C641.1 223.6,121.34 v1(223.55,121.34) ; C610.1 202.08,114.8 v1(202.54,114.34) ; C667.1 218.05,127.84 v1(218.55,127.34) ; v1(226.55,110.37) 226.55,110.32 C597.1 ; C620.1 209.05,113.84 v1(208.55,114.34) 209.04,114.84 C626.1 ; v1(222.55,118.34) 222.55,118.37 C654.1 ; C627.1 218.55,115.4 v1(218.55,115.34) ; v1(224.55,115.34) 224.55,115.32 C629.1 ; v1(218.55,109.34) 218.55,109.32 C600.1 ; v1(220.55,127.34) 221.04,126.85 C668.1 ; v1(205.57,118.34) 206.05,118.82 C648.1 ; v1(202.54,116.34) 202.55,116.34 202.08,116.81 C649.1 ; C642.1 218.06,120.85 v1(218.55,121.34) ; v1(211.55,114.34) 212.04,114.84 C607.1 ; C623.1 205.08,113.81 v1(205.55,113.34) ; v1(208.55,118.34) 209.04,118.84 C647.1 ; v1(229.55,129.29) 229.55,129.39 C670.1 ; v1(218.55,112.34) 218.55,112.32 C615.1 ; C606.1 199.08,114.81 v1(199.55,114.34) ; C651.1 226.55,119.36 v1(226.55,119.32) ; v1(222.54,136.35) 222.03,135.85 C673.1 ; v1(226.58,111.29) 226.56,111.29 226.55,111.3 226.55,111.36 C599.1 ; C578.1 209.55,107.3 209.55,107.32 209.57,107.34 v1(209.6,107.34) ; C671.1 223.06,135.9 223.56,136.39 v1(223.61,136.39) ; C677.1 v1(226.6,135.28) 227.09,135.77 C682.1 ; v1(223.61,124.39) 224.05,123.95 C645.1 ; v1(220.49,106.34) 220.08,105.93 C593.1 ; v1(195.55,114.34) 195.08,114.81 C608.1 ; C579.1 196.04,107.85 v1(196.55,107.34) ; C683.1 v1(220.54,124.36) ; C581.1 213.51,107.34 v1(213.57,107.34) ; v1(208.5,110.34) 208.05,109.89 C584.1 ; C639.1 202.08,118.81 v1(202.55,118.34) ; C624.1 212.04,112.84 v1(211.55,112.34) ; C633.1 199.08,118.81 v1(199.55,118.34) ; v1(220.55,130.34) 220.55,130.34 C678.1 ; v1(211.55,116.34) 212.04,116.84 C625.1 ; C635.1 209.04,116.84 v1(208.55,116.34) ; C653.1 222.55,121.31 v1(222.55,121.34) ; v1(218.55,118.34) 218.03,117.83 C638.1 ; C612.1 224.07,111.93 v1(223.61,112.39) 223.61,112.42 C617.1 ; C602.1 230.06,111.88 v1(229.55,112.39) ; C614.1 230.09,115.91 v1(229.61,116.39) 229.05,115.84 C619.1 ; v1(218.55,124.34) 219.06,123.83 C681.1 ; v1(226.58,123.29) 226.56,123.29 226.55,123.3 226.55,123.36 226.23,123.68 C644.1 ; v1(210.5,107.28) 210.53,107.28 C582.1 ; v1(226.55,122.37) 226.55,122.29 C650.1 ; C679.1 218.55,130.34 v1(218.55,130.34) ; C659.1 230.09,125.77 v1(229.61,125.29) 229.05,125.85 C666.1 ; C656.1 223.06,124.88 v1(222.55,124.37) ; v1(226.49,107.34) 226.49,107.37 C596.1 ; v1(216.55,109.34) 216.55,109.34 C601.1 ; C652.1 220.54,121.34 v1(220.55,121.34) ; v1(220.55,109.34) 220.55,109.31 C598.1 ; v1(220.55,112.37) 220.07,112.85 C611.1 ; v1(222.55,112.37) 222.55,112.3 C613.1 ; v1(224.55,130.34) 224.04,130.85 C676.1 ; C594.1 218.52,106.34 v1(218.52,106.34) ; C643.1 223.54,118.34 v1(223.55,118.34) ; v1(218.55,133.34) 218.06,132.85 C664.1 ; C660.1 227.07,129.87 v1(226.55,130.39) ; v1(224.55,127.34) 225.04,126.85 C680.1 ; C585.1 226.15,106 v1(226.49,106.34) ; C595.1 216.55,106.35 v1(216.55,106.34) ; v1(199.55,112.34) 199.08,112.81 C605.1 ; C632.1 229.08,117.91 228.6,118.39 v1(228.61,118.39) ; v1(220.55,133.34) 220.06,132.85 C665.1 ; v1(226.55,118.39) 226.55,118.37 226.52,118.34 226.51,118.34 C640.1 ; C587.1 204.06,110.83 204.55,110.34 v1(204.52,110.34) ; C661.1 227.03,131.82 226.55,131.34 v1(226.55,131.32) ; v1(198.5,107.28) 198.52,107.28 C583.1 ; v1(222.55,133.34) 222.54,133.34 C662.1 ; C591.1 223.18,105.97 v1(223.55,106.34) ; v1(222.55,115.34) 222.55,115.38 C616.1 ; C622.1 206.04,114.84 v1(205.55,114.34) ; v1(220.55,118.34) 220.54,118.34 C655.1 ; v1(220.55,115.34) 220.55,115.3 C628.1 ; C580.1 214.6,107.28 v1(214.5,107.28) ; v1(205.57,116.34) 205.55,116.34 206.04,116.84 C637.1 ; v1(195.55,112.34) 195.08,112.81 C621.1 ; v1(237.27,106.93) 237.3,106.96 C577.1 238.18,107.96 238.19,107.95 ; v1(202.52,113.28) 202.06,112.82 C609.1 ; v1(229.55,124.39) 229.55,124.37 229.57,124.34 229.59,124.34 C646.1 ; C589.1 202.05,107.79 v1(202.53,107.3) ; v1(229.59,128.39) 229.58,128.39 C675.1 ; C669.1 223.04,126.85 v1(222.55,127.34) ; C586.1 208.03,110.79 207.57,110.34 v1(207.57,110.32)
  vias: v1(232.35,122.68) v1(232.35,114.81) v1(232.47,126.87) v1(232.47,120.77) v1(233.49,114.81) v1(233.62,120.77) v1(237.17,105.99) v1(237.17,105.08) v1(237.17,104.16) v1(238.06,105.99) v1(238.06,105.08) v1(238.06,104.16) v1(238.16,106.93) v1(238.95,105.99) v1(238.95,105.08) v1(238.95,104.16) v1(239.92,106.02) v1(239.92,105.1) v1(239.92,104.19) v2(235.52,118.11)
FC_TRVDD0P8_3: length 148.2
  TOP w0.229: v1(208.54,166.34) 208.55,166.34 U1.BY23 ; v1(226.58,168.32) 226.52,168.32 U1.CB5 ; v1(222.55,149.37) 222.55,149.34 U1.BC9 ; U1.CF12 v1(219.55,172.34) ; v1(229.62,161.4) 229.37,161.15 229.36,161.15 U1.BR2 ; U1.CF15 v1(216.55,172.34) ; U1.BF13 v1(218.55,152.34) ; U1.CE18 213.55,171.34 v1(213.6,171.34) ; U1.BP20 v1(211.55,160.34) ; U1.AY11 220.07,145.84 v1(220.56,146.32) ; U1.BF9 v1(222.55,152.34) ; U1.BR13 v1(218.55,161.34) ; v1(220.55,149.37) 220.55,149.34 U1.BC11 ; v1(229.59,150.32) 229.52,150.32 U1.BD2 ; U1.BC2 229.55,149.34 v1(229.55,149.39) ; U1.CC10 v1(221.55,169.34) ; U1.CC13 v1(218.55,169.34) ; U1.AU9 v1(222.55,143.34) ; v1(229.55,142.29) 229.1,141.84 U1.AT2 ; U1.AP11 v1(220.55,140.34) ; U1.BP5 226.07,159.84 v1(226.56,160.32) ; U1.BV13 v1(218.55,164.34) ; U1.BJ5 226.55,155.34 v1(226.55,155.39) ; v1(226.55,159.37) 226.55,159.34 U1.BN5 ; U1.AU5 226.55,143.34 v1(226.55,143.39) ; U1.BM7 v1(224.55,158.34) ; v1(229.58,166.29) 229.55,166.29 229.1,165.84 U1.BY2 ; U1.CA10 v1(221.55,167.34) ; v1(223.61,149.39) 223.55,149.39 arc(223.54,149.35) 223.51,149.31 U1.BC8 ; U1.CF14 v1(217.55,172.34) ; U1.BW2 229.55,165.34 v1(229.55,165.39) ; v1(203.57,168.37) 203.57,168.37 U1.CB28 ; U1.AL2 229.5,136.39 v1(229.55,136.39) ; U1.CB27 v1(204.55,168.34) ; U1.BV23 208.52,164.32 v1(208.52,164.34) ; U1.BA5 226.55,147.34 v1(226.55,147.37) ; v1(209.57,171.4) 209.57,171.37 U1.CE22 ; U1.BT20 211.55,162.34 v1(211.55,162.34) ; v1(229.61,141.39) 229.6,141.39 U1.AR2 ; v1(210.5,171.34) 210.5,171.29 U1.CE21 ; v1(229.55,162.29) 229.1,161.84 U1.BT2 ; v1(215.55,164.34) U1.BV16 ; v1(226.61,148.29) 226.5,148.29 U1.BB5 ; U1.CE17 214.5,171.29 v1(214.5,171.4) ; U1.CB23 208.55,168.34 v1(208.52,168.34) ; U1.BC13 v1(218.55,149.34) ; U1.AL11 v1(220.54,136.35) ; U1.BW26 v1(205.55,165.34) ; U1.CF8 v1(223.55,172.34) ; U1.BP23 v1(208.55,160.34) ; U1.BW13 v1(218.55,165.34) ; U1.AP7 v1(224.55,140.34) ; U1.BJ9 v1(222.55,155.34) ; U1.AP13 v1(218.55,140.34) ; v1(226.56,167.37) 226.56,167.35 U1.CA5 ; v1(214.55,164.34) U1.BV17 ; U1.BJ7 v1(224.55,155.34) ; U1.AL13 v1(218.55,136.34) ; U1.BT26 v1(205.55,162.34) ; U1.BY20 v1(211.55,166.34) ; U1.CF5 226.07,171.84 226.57,172.34 v1(226.58,172.34) ; U1.BJ13 v1(218.55,155.34) ; U1.BJ11 v1(220.55,155.34) ; U1.BM9 v1(222.55,158.34) ; U1.BV20 v1(211.55,164.34) ; U1.BV29 202.55,164.34 v1(202.52,164.34) ; U1.BR9 v1(222.55,161.34) ; U1.BV26 v1(205.55,164.34) ; U1.BK5 v1(226.54,156.33) ; U1.BT23 v1(208.55,162.34) ; v1(215.55,162.34) U1.BT16 ; v1(229.61,153.39) 229.6,153.39 U1.BG2 ; U1.AY8 v1(223.55,146.34) ; U1.BM13 v1(218.55,158.34) ; U1.BF11 v1(220.55,152.34) ; U1.CF11 v1(220.55,172.34) ; U1.AM2 229.55,137.34 229.55,137.3 229.56,137.29 v1(229.61,137.29) ; U1.AU7 v1(224.55,143.34) ; U1.AY9 v1(222.55,146.34) ; U1.AY13 v1(218.55,146.34) ; U1.BR7 v1(224.55,161.34) ; U1.AV5 v1(226.55,144.34) ; U1.BW10 v1(221.55,165.34) ; v1(214.55,162.34) U1.BT17 ; v1(215.55,166.34) U1.BY16 ; U1.CE5 v1(226.55,171.34) ; U1.AP9 v1(222.55,140.34) ; v1(207.57,168.34) 207.55,168.34 U1.CB24 ; U1.BF7 v1(224.55,152.34) ; U1.AU11 v1(220.55,143.34) ; U1.AU13 v1(218.55,143.34) ; U1.BH2 229.1,153.84 v1(229.55,154.29) ; U1.BP26 v1(205.55,160.34) ; U1.CF9 v1(222.55,172.34) ; v1(214.55,166.34) U1.BY17 ; U1.BR11 v1(220.55,161.34) ; U1.CA13 v1(218.55,167.34) ; U1.BM11 v1(220.55,158.34)
  BOTTOM w0.33: v1(215.55,162.34) 216.01,161.88 C741.1 ; v1(218.55,158.34) 219.04,157.85 C734.1 ; v1(224.55,158.34) 224.05,158.84 C722.1 ; C698.1 223.54,146.34 v1(223.55,146.34) ; v1(220.55,155.34) 221.05,154.84 C736.1 ; v1(218.55,161.34) 218.06,160.85 C2793.1 ; C733.1 221.04,157.85 v1(220.55,158.34) ; C2967.1 220.06,160.85 v1(220.55,161.34) ; C3082.1 222.06,160.85 v1(222.55,161.34) ; C724.1 224.06,154.85 v1(224.55,155.34) ; C723.1 v1(226.56,160.32) ; C732.1 223.05,157.84 v1(222.55,158.34) ; C745.1 208.06,161.85 v1(208.55,162.34) ; v1(218.55,155.34) 219.05,154.84 C727.1 ; v1(222.55,155.34) 222.06,155.83 C725.1 ; C703.1 224.05,143.84 v1(224.55,143.34) ; C3094.1 224.06,160.85 v1(224.55,161.34) ; v1(222.55,146.34) 223.06,145.83 C697.1
  BOTTOM w0.381: v1(218.55,143.34) 218.06,143.83 C706.1 ; C2839.1 205.54,165.34 v1(205.55,165.34) ; v1(213.6,171.34) 213.5,171.34 C2869.1 ; v1(222.55,152.34) 223.05,151.84 C737.1 ; C728.1 229.55,154.39 v1(229.55,154.29) ; C2704.1 221.55,167.35 v1(221.55,167.34) ; C3194.1 205.05,167.84 v1(204.55,168.34) ; v1(222.55,149.37) 222.55,149.34 222.05,148.84 C699.1 ; C685.1 243.46,138.55 ; C685.1 242.86,139.19 ; C685.1 242.26,138.55 ; C2744.1 223.04,171.85 v1(222.55,172.34) ; C705.1 220.03,135.85 v1(220.54,136.35) ; C3147.1 218.55,165.39 v1(218.55,165.34) ; v1(229.61,153.39) 230.09,152.91 C726.1 ; v1(226.55,143.39) 226.08,143.86 C709.1 ; C700.1 229.55,142.34 v1(229.55,142.29) ; v1(220.55,143.34) 220.06,143.83 C702.1 ; v1(229.61,137.29) 229.61,137.33 C694.1 ; v1(218.55,146.34) 219.04,145.86 C708.1 ; C2938.1 211.03,165.83 v1(211.55,166.34) ; C719.1 229.11,150.8 v1(229.59,150.32) 230.06,150.79 C714.1 ; v1(224.55,140.34) 224.03,139.82 C690.1 ; C707.1 226.04,144.85 v1(226.55,144.34) ; C701.1 229.58,141.36 229.58,141.37 v1(229.61,141.39) ; v1(211.55,164.34) 212.05,164.85 C747.1 ; v1(226.58,172.34) 226.89,172.65 C3076.1 ; C742.1 v1(214.55,164.34) ; v1(226.55,171.34) 227.04,171.83 C3115.1 ; C696.1 221.04,145.85 v1(220.56,146.32) ; C2737.1 219.05,172.84 v1(219.55,172.34) ; v1(226.61,148.29) 227.01,148.7 C710.1 ; v1(229.55,162.29) 230.02,162.76 C2783.1 ; v1(207.57,168.34) 207.55,168.34 207.05,167.84 C2692.1 ; v1(221.55,165.34) 221.55,165.31 C2935.1 ; C2902.1 218.05,163.84 v1(218.55,164.34) ; v1(226.55,155.39) 226.55,155.37 226.57,155.34 226.59,155.34 C731.1 ; 244.31,149.69 C712.1 243.67,149.1 ; v1(226.55,159.37) 226.55,159.3 C721.1 ; C743.1 205.55,164.3 v1(205.55,164.34) ; v1(226.54,156.33) 227.04,156.83 C735.1 ; v1(218.55,167.34) 218.55,167.35 C2751.1 ; v1(220.55,140.34) 220.02,139.81 C689.1 ; v1(214.55,166.34) 214.55,166.38 C2681.1 ; C2818.1 208.55,166.34 v1(208.54,166.34) ; C2901.1 223.05,172.84 v1(223.55,172.34) ; C2824.1 211.08,161.87 v1(211.55,162.34) ; v1(229.55,149.39) 230.06,148.88 C687.1 ; v1(215.55,164.34) 216.06,164.85 C740.1 ; C2688.1 216.04,171.83 v1(216.55,172.34) ; v1(229.62,161.4) 230.06,160.96 C2880.1 ; C3040.1 230.01,164.93 v1(229.55,165.39) ; C691.1 222.02,139.82 v1(222.55,140.34) ; C718.1 219.05,151.84 v1(218.55,152.34) ; C3050.1 215.02,170.87 214.52,171.37 214.52,171.38 v1(214.5,171.4) ; C2962.1 210.99,170.85 v1(210.5,171.34) ; C739.1 245.26,162.91 ; C739.1 244.07,162.91 ; C739.1 244.67,163.55 ; C2782.1 218.55,169.32 v1(218.55,169.34) ; v1(208.55,160.34) 208.06,159.85 C715.1 ; v1(217.55,172.34) 218.06,171.83 C2904.1 ; C717.1 211.07,160.82 v1(211.55,160.34) ; C688.1 223.58,149.34 223.58,149.37 v1(223.61,149.39) ; C2956.1 220.1,172.79 v1(220.55,172.34) ; v1(218.55,136.34) 218.03,135.82 C704.1 ; C2995.1 226.06,168.83 226.56,168.33 226.56,168.32 v1(226.58,168.32) ; C3183.1 221.55,169.32 v1(221.55,169.34) ; v1(224.55,152.34) 225.05,151.84 C713.1 ; v1(208.52,164.34) 208.52,164.33 C746.1 ; v1(226.55,147.37) 226.57,147.37 C695.1 ; C729.1 221.05,151.84 v1(220.55,152.34) ; C3176.1 214.05,161.84 v1(214.55,162.34) ; v1(229.58,166.29) 230.05,166.76 C2931.1 ; C2883.1 203.05,163.84 202.55,164.34 v1(202.52,164.34) ; C730.1 220.05,148.84 220.55,149.34 v1(220.55,149.37) ; v1(229.55,136.39) 229.09,135.93 C693.1 ; C3153.1 203.55,168.29 203.55,168.32 203.57,168.35 v1(203.57,168.37) ; v1(215.55,166.34) 215.55,166.37 C3132.1 ; C3144.1 208.58,168.34 v1(208.52,168.34) ; v1(209.57,171.4) 209.57,171.37 209.07,170.86 C3018.1 ; C720.1 218.05,148.84 v1(218.55,149.34) ; C716.1 206.03,159.87 v1(205.55,160.34) ; v1(222.55,143.34) 222.03,143.86 C692.1 ; v1(205.55,162.34) 205.05,161.84 C744.1 ; C3175.1 226.62,167.37 v1(226.56,167.37) 226.49,167.37 C2863.1 ; C686.1 218.02,139.81 v1(218.55,140.34)
  vias: v1(235.14,160.4) v1(236.16,164.21) v1(236.16,163.32) v1(236.16,160.4) v1(236.66,144.02) v1(236.77,146.12) v1(237.4,138.63) v1(237.43,139.7) v1(237.55,144.02) v1(237.66,146.12) v1(238.29,138.63) v1(238.32,139.7) v1(241.74,163.83) v1(241.74,162.94) v1(242,152.07) v1(242.25,150.57) v1(242.89,152.07) v1(243.14,150.57) v1(243.78,163.83) v1(243.78,162.94) v1(243.9,139.7) v1(243.9,138.81) v1(244.79,139.7) v1(244.79,138.81) v2(235.65,165.99)
