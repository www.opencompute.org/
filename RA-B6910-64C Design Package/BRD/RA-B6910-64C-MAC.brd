# Allegro board RA-B6910-64C-MAC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FC18_TDP2: length 103.9
  TOP w0.147: v4(168.55,133.29) 168.55,133.34 U1.AH62
  SIG4 w0.112: 163.26,134.04 163.28,134.04 163.38,133.95 167.71,133.95 arc(167.84,133.92) 167.94,133.85 168.02,133.77 arc(168.09,133.66) 168.12,133.54 168.12,133.07 arc(168.16,132.98) 168.25,132.94 168.42,132.94 arc(168.51,132.98) 168.55,133.07 v4(168.55,133.29)
  SIG4 w0.16: 163.26,134.04 162.66,134.04 arc(162.23,133.95) 161.86,133.7 161.3,133.14 arc(161.22,133.08) 161.13,133.04 161.13,133.04 arc(161.08,133.03) 161.03,133.03 151.83,133.03 arc(151.53,132.99) 151.26,132.88 arc(151.21,132.85) 151.17,132.82 arc(151.09,132.76) 151.02,132.7 144.67,126.35 138.32,120 arc(138.07,119.63) 137.99,119.19 137.99,108.36 arc(137.96,108.22) 137.87,108.1 118.56,88.78 arc(118.31,88.41) 118.22,87.97 118.22,72.94 arc(118.17,72.64) 118,72.4 112.69,67.08 arc(112.44,66.92) 112.15,66.86 111.32,66.86 arc(111.1,66.77) 111.01,66.55 111.01,66.32 arc(111.04,66.13) 111.15,65.97 YJ25.A37
FC18_TDP3: length 100.1
  TOP w0.147: U1.AG64 167,132.84 arc(166.68,132.71) v4(166.55,132.39)
  SIG5 w0.112: v4(166.55,132.39) 166.55,132.62 arc(166.51,132.71) 166.42,132.74 166.25,132.74 arc(166.16,132.71) 166.12,132.62 166.12,132.14 arc(166.1,132.02) 166.03,131.91 165.96,131.85 arc(165.85,131.78) 165.73,131.75 163.38,131.75 163.28,131.66 163.26,131.66
  SIG5 w0.16: YJ25.A33 114.5,64.84 arc(114.53,65.01) 114.63,65.16 arc(114.63,65.17) 114.64,65.17 115.14,65.67 arc(115.26,65.86) 115.31,66.08 115.31,69.05 arc(115.34,69.2) 115.42,69.32 115.96,69.86 116.26,69.86 116.71,70.32 116.71,70.62 118.27,72.18 arc(118.52,72.55) 118.61,72.99 118.61,73.75 118.78,73.93 118.78,74.64 118.61,74.81 118.61,88.13 arc(118.63,88.28) 118.72,88.4 138.03,107.71 arc(138.28,108.09) 138.37,108.52 138.37,119.21 arc(138.42,119.51) 138.59,119.75 149.6,130.76 arc(149.85,130.93) 150.14,130.99 161.72,130.99 arc(162.16,131.07) 162.53,131.32 162.79,131.58 arc(162.88,131.64) 162.99,131.66 163.26,131.66
FC19_RDN0: length 115.3
  TOP w0.147: v4(176.55,128.39) 176.55,128.46 arc(176.56,128.52) 176.6,128.57 176.79,128.77 arc(176.87,128.82) 176.97,128.84 U1.AC54
  SIG2 w0.112: 163.26,125.64 163.28,125.64 163.38,125.73 168.82,125.73 arc(169.05,125.82) 169.14,126.05 169.14,126.45 arc(169.15,126.5) 169.18,126.54 169.31,126.67 arc(169.35,126.7) 169.4,126.71 175.63,126.71 arc(175.75,126.73) 175.86,126.8 176.02,126.97 arc(176.09,127.07) 176.12,127.2 176.12,128.62 arc(176.16,128.71) 176.25,128.74 176.42,128.74 arc(176.51,128.71) 176.55,128.62 v4(176.55,128.39)
  SIG2 w0.16: 163.26,125.64 161.41,125.64 arc(160.97,125.72) 160.6,125.97 159.94,126.63 arc(159.82,126.71) 159.67,126.74 154.81,126.74 arc(154.52,126.69) 154.27,126.52 152.69,124.93 arc(152.52,124.69) 152.46,124.4 152.46,120.87 arc(152.38,120.43) 152.13,120.06 148.38,116.31 arc(148.3,116.19) 148.27,116.04 148.27,104.79 arc(148.19,104.35) 147.94,103.98 131.89,87.93 arc(131.8,87.8) 131.77,87.66 131.77,70.17 arc(131.72,69.88) 131.55,69.64 128.94,67.03 arc(128.78,66.78) 128.72,66.49 128.72,58.92 arc(128.63,58.48) 128.39,58.11 127.79,57.52 127.79,57.21 127.38,56.8 127.07,56.8 126.72,56.44 126.72,56.1 126.33,55.72 126,55.72 125.64,55.36 arc(125.27,55.11) 124.83,55.03 122.95,55.03 arc(122.86,55.01) 122.78,54.98 arc(122.73,54.95) 122.68,54.91 122.63,54.86 arc(122.54,54.72) 122.51,54.57 122.51,54.08 arc(122.46,53.86) 122.34,53.67 121.92,53.26 arc(121.76,53.01) 121.7,52.72 YJ25.B15
FC19_RDN1: length 108.6
  TOP w0.147: U1.AD58 172.55,129.34 v4(172.55,129.29)
  SIG3 w0.112: v4(172.55,129.29) 172.55,129.07 arc(172.51,128.98) 172.42,128.94 172.25,128.94 arc(172.02,128.85) 171.92,128.62 171.92,128.15 arc(171.91,128.1) 171.89,128.06 171.78,127.96 arc(171.74,127.93) 171.69,127.92 170.34,127.92 arc(170.22,127.89) 170.11,127.82 170.04,127.75 arc(169.97,127.65) 169.95,127.52 169.95,127.11 arc(169.94,127.07) 169.91,127.02 169.84,126.95 arc(169.8,126.93) 169.75,126.92 169.34,126.92 arc(169.21,126.89) 169.11,126.82 169.05,126.76 arc(168.98,126.66) 168.95,126.53 168.95,126.2 arc(168.94,126.16) 168.92,126.11 168.8,126 arc(168.76,125.97) 168.71,125.96 163.38,125.96 163.28,126.05 163.26,126.05
  SIG3 w0.16: 163.26,126.05 161.34,126.05 arc(161.2,126.08) 161.07,126.16 160.45,126.79 arc(160.08,127.04) 159.64,127.12 154.81,127.12 arc(154.37,127.04) 154,126.79 152.42,125.2 arc(152.17,124.83) 152.08,124.4 152.08,120.71 arc(152.05,120.56) 151.97,120.44 148.23,116.7 arc(147.98,116.32) 147.89,115.89 147.89,104.63 arc(147.86,104.49) 147.78,104.36 131.73,88.31 arc(131.48,87.94) 131.39,87.5 131.39,68.93 arc(131.36,68.78) 131.28,68.66 128.66,66.04 arc(128.42,65.67) 128.33,65.23 128.33,59.01 arc(128.27,58.72) 128.11,58.47 124.72,55.08 arc(124.65,55.02) 124.57,54.97 arc(124.38,54.89) 124.18,54.86 123.33,54.86 arc(123.1,54.77) 123.01,54.54 123.01,54.32 arc(123.04,54.13) 123.15,53.97 YJ25.B17
FC19_RDN2: length 110.5
  TOP w0.147: U1.AC56 174.96,128.84 arc(174.86,128.82) 174.78,128.77 174.6,128.58 arc(174.56,128.53) 174.55,128.46 v4(174.55,128.39)
  SIG2 w0.112: 163.26,127.65 163.28,127.65 163.38,127.74 173.78,127.74 arc(173.83,127.75) 173.87,127.78 174.02,127.93 arc(174.09,128.03) 174.12,128.16 174.12,128.62 arc(174.16,128.71) 174.25,128.74 174.42,128.74 arc(174.51,128.71) 174.55,128.62 v4(174.55,128.39)
  SIG2 w0.16: 163.26,127.65 162.07,127.65 arc(161.63,127.73) 161.26,127.98 160.45,128.79 arc(160.33,128.87) 160.18,128.9 154.02,128.9 arc(153.73,128.84) 153.49,128.68 150.6,125.8 arc(150.44,125.55) 150.38,125.26 150.38,125.26 150.38,123.12 arc(150.29,122.68) 150.05,122.31 144.7,116.97 arc(144.62,116.85) 144.59,116.7 144.59,104.91 arc(144.53,104.62) 144.37,104.37 129.93,89.94 arc(129.77,89.69) 129.71,89.4 129.71,74.33 129.94,74.1 129.94,73.55 129.71,73.32 129.71,72.81 129.91,72.61 129.91,72 129.71,71.79 129.71,71.28 arc(129.65,70.99) 129.49,70.75 127.6,68.86 arc(127.44,68.61) 127.38,68.32 127.38,61.21 arc(127.29,60.77) 127.04,60.4 126.01,59.36 arc(125.63,59.11) 125.2,59.03 122.95,59.03 arc(122.86,59.01) 122.78,58.98 arc(122.73,58.95) 122.68,58.91 122.63,58.86 arc(122.56,58.77) 122.52,58.66 arc(122.51,58.61) 122.51,58.57 122.51,58.08 arc(122.46,57.86) 122.34,57.67 121.88,57.21 arc(121.75,57.02) 121.7,56.79 YJ25.B24
FC19_RDN3: length 103.9
  TOP w0.147: U1.AD60 170.55,129.34 v4(170.55,129.29)
  SIG3 w0.112: 163.26,128.01 163.28,128.01 163.38,127.92 168.75,127.92 arc(168.8,127.93) 168.84,127.96 168.94,128.06 arc(168.97,128.1) 168.98,128.15 168.98,128.62 arc(169.07,128.85) 169.3,128.94 170.42,128.94 arc(170.51,128.98) 170.55,129.07 v4(170.55,129.29)
  SIG3 w0.16: YJ25.B22 123.15,57.97 arc(123.04,58.13) 123.01,58.32 123.01,58.52 arc(123.11,58.76) 123.35,58.86 124.18,58.86 arc(124.4,58.9) 124.61,59 arc(124.66,59.04) 124.72,59.08 124.76,59.13 124.81,59.18 arc(124.84,59.21) 124.86,59.23 126.52,60.89 arc(126.87,61.41) 127,62.04 127,65.79 arc(127.08,66.22) 127.33,66.6 129.22,68.48 arc(129.3,68.6) 129.33,68.75 129.33,89.4 arc(129.42,89.84) 129.66,90.21 144.1,104.64 arc(144.18,104.76) 144.21,104.91 144.21,116.52 arc(144.3,116.96) 144.54,117.33 149.89,122.67 arc(149.97,122.8) 150,122.94 150,125.26 arc(150.09,125.7) 150.33,126.07 153.22,128.95 arc(153.59,129.2) 154.02,129.28 159.92,129.28 arc(160.36,129.2) 160.73,128.95 161.56,128.12 arc(161.68,128.04) 161.82,128.01 163.26,128.01
FC19_RDP0: length 115.3
  TOP w0.147: U1.AD54 176.55,129.34 v4(176.55,129.29)
  SIG2 w0.112: v4(176.55,129.29) 176.55,129.07 arc(176.51,128.98) 176.42,128.94 176.25,128.94 arc(176.02,128.85) 175.92,128.62 175.92,127.2 arc(175.91,127.15) 175.89,127.11 175.72,126.94 arc(175.68,126.91) 175.63,126.91 169.4,126.91 arc(169.28,126.88) 169.17,126.81 169.04,126.68 arc(168.97,126.58) 168.95,126.45 168.95,126.05 arc(168.91,125.96) 168.82,125.92 163.38,125.92 163.28,126.02 163.26,126.02
  SIG2 w0.16: YJ25.B14 120.75,53.97 arc(120.64,54.13) 120.61,54.32 120.61,54.53 arc(120.7,54.77) 120.94,54.86 121.78,54.86 arc(122.07,54.92) 122.31,55.08 122.36,55.13 122.41,55.18 arc(122.5,55.26) 122.6,55.32 arc(122.77,55.38) 122.95,55.41 124.83,55.41 arc(125.12,55.46) 125.37,55.63 128.12,58.38 arc(128.28,58.63) 128.34,58.92 128.34,66.49 arc(128.43,66.93) 128.68,67.3 131.28,69.91 arc(131.36,70.03) 131.39,70.17 131.39,87.66 arc(131.45,87.95) 131.62,88.2 147.67,104.25 arc(147.83,104.5) 147.89,104.79 147.89,116.04 arc(147.95,116.34) 148.12,116.58 151.86,120.33 arc(152.02,120.58) 152.08,120.87 152.08,124.4 arc(152.17,124.83) 152.42,125.2 154,126.79 arc(154.37,127.04) 154.81,127.12 159.67,127.12 arc(159.96,127.07) 160.21,126.9 160.87,126.24 arc(161.12,126.07) 161.41,126.02 163.26,126.02
FC19_RDP1: length 108.6
  TOP w0.147: U1.AC58 173,128.84 arc(172.83,128.81) 172.68,128.71 172.61,128.64 arc(172.57,128.57) 172.55,128.48 v4(172.55,128.39)
  SIG3 w0.112: 163.26,125.67 163.28,125.67 163.38,125.76 168.71,125.76 arc(168.83,125.79) 168.94,125.86 169.06,125.98 arc(169.13,126.08) 169.15,126.2 169.15,126.53 arc(169.16,126.58) 169.19,126.62 169.25,126.68 arc(169.29,126.71) 169.34,126.72 169.75,126.72 arc(169.88,126.75) 169.98,126.82 170.05,126.88 arc(170.12,126.99) 170.14,127.11 170.14,127.52 arc(170.15,127.57) 170.18,127.61 170.25,127.68 arc(170.29,127.71) 170.34,127.72 171.69,127.72 arc(171.82,127.75) 171.92,127.82 172.02,127.92 arc(172.09,128.03) 172.12,128.15 172.12,128.62 arc(172.16,128.71) 172.25,128.74 172.42,128.74 arc(172.51,128.71) 172.55,128.62 v4(172.55,128.39)
  SIG3 w0.16: 163.26,125.67 161.34,125.67 arc(161.05,125.73) 160.81,125.9 160.18,126.52 arc(159.93,126.69) 159.64,126.74 154.81,126.74 arc(154.52,126.69) 154.27,126.52 152.69,124.93 arc(152.52,124.69) 152.46,124.4 152.46,120.71 arc(152.41,120.42) 152.24,120.17 148.5,116.43 arc(148.33,116.18) 148.27,115.89 148.27,104.63 arc(148.21,104.34) 148.05,104.09 132,88.04 arc(131.83,87.79) 131.77,87.5 131.77,68.93 arc(131.72,68.64) 131.55,68.39 128.93,65.77 arc(128.77,65.53) 128.71,65.23 128.71,59.01 arc(128.62,58.58) 128.37,58.21 127.23,57.06 127.23,56.73 126.85,56.34 126.51,56.34 126.1,55.93 126.1,55.6 125.72,55.22 125.39,55.22 125.13,54.96 125.13,54.96 arc(124.96,54.71) 124.91,54.43 124.91,54.08 arc(124.86,53.86) 124.74,53.67 124.3,53.24 arc(124.15,53.01) 124.1,52.75 YJ25.B18
FC19_RDP2: length 110.5
  TOP w0.147: v4(174.55,129.29) 174.55,129.34 U1.AD56
  SIG2 w0.112: v4(174.55,129.29) 174.55,129.07 arc(174.51,128.98) 174.42,128.94 174.25,128.94 arc(174.02,128.85) 173.92,128.62 173.92,128.16 arc(173.91,128.11) 173.89,128.07 173.79,127.97 arc(173.75,127.95) 173.7,127.94 163.38,127.94 163.28,128.03 163.26,128.03
  SIG2 w0.16: 163.26,128.03 162.07,128.03 arc(161.78,128.09) 161.53,128.25 160.72,129.06 arc(160.47,129.23) 160.18,129.28 154.02,129.28 arc(153.59,129.2) 153.22,128.95 150.33,126.07 arc(150.09,125.7) 150,125.26 150,123.12 arc(149.94,122.83) 149.78,122.58 144.43,117.24 arc(144.27,116.99) 144.21,116.7 144.21,104.91 arc(144.18,104.76) 144.1,104.64 129.66,90.21 arc(129.42,89.84) 129.33,89.4 129.33,71.28 arc(129.3,71.14) 129.22,71.02 127.33,69.13 arc(127.08,68.76) 127,68.32 127,61.21 arc(126.94,60.91) 126.77,60.67 125.74,59.63 arc(125.49,59.46) 125.2,59.41 122.95,59.41 arc(122.77,59.38) 122.6,59.32 arc(122.5,59.26) 122.41,59.18 122.36,59.13 arc(122.06,58.93) 121.72,58.86 120.93,58.86 arc(120.7,58.77) 120.61,58.54 120.61,58.32 arc(120.64,58.13) 120.75,57.97 YJ25.B25
FC19_RDP3: length 103.9
  TOP w0.147: U1.AC60 171,128.84 arc(170.83,128.81) 170.68,128.71 170.61,128.64 arc(170.57,128.57) 170.55,128.48 v4(170.55,128.39)
  SIG3 w0.112: 163.26,127.63 163.28,127.63 163.38,127.72 168.75,127.72 arc(168.87,127.75) 168.98,127.82 169.08,127.92 arc(169.15,128.03) 169.18,128.15 169.18,128.62 arc(169.21,128.71) 169.3,128.74 170.42,128.74 arc(170.51,128.71) 170.55,128.62 v4(170.55,128.39)
  SIG3 w0.16: 163.26,127.63 161.82,127.63 arc(161.53,127.69) 161.29,127.85 160.46,128.68 arc(160.21,128.84) 159.92,128.9 154.02,128.9 arc(153.73,128.84) 153.49,128.68 150.6,125.8 arc(150.44,125.55) 150.38,125.26 150.38,122.94 arc(150.32,122.65) 150.16,122.41 144.81,117.06 arc(144.65,116.81) 144.59,116.52 144.59,104.91 arc(144.53,104.62) 144.37,104.37 129.93,89.94 arc(129.77,89.69) 129.71,89.4 129.71,71.8 129.94,71.57 129.94,71.01 129.71,70.78 129.71,70.27 129.94,70.05 129.94,69.49 129.71,69.26 129.71,68.75 arc(129.65,68.46) 129.49,68.21 127.6,66.33 arc(127.44,66.08) 127.38,65.79 127.38,62.04 arc(127.23,61.27) 126.79,60.62 125.26,59.09 125.02,58.85 arc(124.94,58.72) 124.91,58.57 124.91,58.08 arc(124.86,57.86) 124.74,57.67 124.3,57.24 arc(124.15,57.01) 124.1,56.75 YJ25.B21
FC19_TDN0: length 105.9
  TOP w0.147: v4(164.55,129.29) 164.55,129.34 U1.AD66
  SIG5 w0.112: 163.18,128.04 163.21,128.04 163.3,127.95 163.75,127.95 arc(163.8,127.96) 163.84,127.99 163.89,128.03 arc(163.92,128.07) 163.92,128.12 163.92,128.62 arc(164.02,128.85) 164.25,128.94 164.42,128.94 arc(164.51,128.98) 164.55,129.07 v4(164.55,129.29)
  SIG5 w0.16: YJ25.B34 113.55,57.97 arc(113.44,58.13) 113.41,58.32 113.41,58.53 arc(113.5,58.76) 113.74,58.86 114.58,58.86 arc(114.87,58.92) 115.12,59.08 115.16,59.13 115.21,59.18 arc(115.46,59.35) 115.75,59.41 126.62,59.41 arc(126.89,59.52) 127.01,59.79 127.01,67.99 arc(126.95,68.11) 126.94,68.24 126.94,91.03 arc(126.99,91.32) 127.16,91.56 143.6,108.01 arc(143.77,108.26) 143.83,108.55 143.83,116.14 arc(143.91,116.58) 144.16,116.95 153.49,126.28 arc(153.87,126.53) 154.3,126.62 159.64,126.62 arc(159.93,126.67) 160.18,126.84 161.16,127.82 arc(161.4,127.98) 161.7,128.04 163.18,128.04
FC19_TDN1: length 111.9
  TOP w0.147: U1.AC64 167,128.84 arc(166.83,128.81) 166.68,128.71 166.61,128.64 arc(166.56,128.57) 166.55,128.49 v4(166.55,128.4)
  SIG4 w0.112: v4(166.55,128.4) 166.55,128.62 arc(166.51,128.71) 166.42,128.74 166.25,128.74 arc(166.02,128.84) 165.92,129.07 165.92,129.54 arc(165.91,129.58) 165.89,129.63 165.8,129.71 arc(165.76,129.73) 165.71,129.74 163.38,129.74 163.29,129.65 163.27,129.65
  SIG4 w0.16: 163.27,129.65 162.99,129.65 arc(162.73,129.6) 162.52,129.46 162.19,129.13 arc(161.94,128.96) 161.65,128.9 154.02,128.9 arc(153.73,128.84) 153.49,128.68 150.62,125.81 arc(150.45,125.56) 150.39,125.27 150.39,122.98 arc(150.34,122.69) 150.17,122.44 144.43,116.71 arc(144.27,116.46) 144.21,116.17 144.21,108.42 arc(144.15,108.12) 143.99,107.88 127.52,91.41 arc(127.36,91.17) 127.3,90.88 127.3,73.33 127.55,73.07 127.55,72.56 127.3,72.31 127.3,71.8 127.57,71.53 127.57,67.94 127.38,67.75 127.38,61.57 arc(127.32,61.28) 127.15,61.03 126.45,60.33 126.45,60.02 126.04,59.61 125.73,59.61 125.37,59.25 arc(125.12,59.08) 124.83,59.03 113.35,59.03 arc(113.21,59) 113.08,58.91 113.03,58.86 arc(112.94,58.72) 112.91,58.57 112.91,58.08 arc(112.86,57.86) 112.74,57.67 112.25,57.18 arc(112.14,57.02) 112.1,56.83 YJ25.B36
FC19_TDN2: length 115.4
  TOP w0.147: U1.AD62 168.55,129.34 v4(168.55,129.29)
  SIG4 w0.112: v4(168.55,129.29) 168.55,129.07 arc(168.51,128.98) 168.42,128.94 168.25,128.94 arc(168.02,128.85) 167.92,128.62 167.92,128.14 arc(167.91,128.09) 167.89,128.05 167.8,127.97 arc(167.76,127.95) 167.71,127.94 164.57,127.94 arc(164.3,127.88) 164.07,127.73 163.44,127.1 arc(163.41,127.08) 163.39,127.06 arc(163.33,127.04) 163.28,127.03 163,127.03 162.9,127.12 162.88,127.12
  SIG4 w0.16: 162.88,127.12 154.79,127.12 arc(154.35,127.04) 153.98,126.79 152.43,125.24 arc(152.18,124.87) 152.09,124.43 152.09,120.74 arc(152.06,120.6) 151.98,120.48 146.78,115.27 arc(146.53,114.9) 146.44,114.46 146.44,107.15 arc(146.41,107) 146.33,106.88 129.66,90.21 arc(129.42,89.84) 129.33,89.4 129.33,67.88 arc(129.3,67.73) 129.22,67.61 128.65,67.04 arc(128.4,66.67) 128.32,66.23 128.32,58.33 arc(128.29,58.19) 128.2,58.06 125.66,55.52 arc(125.53,55.44) 125.39,55.41 113.35,55.41 arc(113.06,55.35) 112.81,55.18 112.76,55.13 112.72,55.08 arc(112.47,54.92) 112.18,54.86 111.32,54.86 arc(111.1,54.77) 111.01,54.55 111.01,54.32 arc(111.04,54.13) 111.15,53.97 YJ25.B2
FC19_TDN3: length 108.2
  TOP w0.147: U1.AA65 166,126.84 arc(165.68,126.71) v4(165.55,126.39)
  SIG5 w0.112: v4(165.55,126.39) 165.55,126.62 arc(165.51,126.71) 165.42,126.74 165.25,126.74 arc(165.16,126.71) 165.12,126.62 165.12,126.14 arc(165.1,126.02) 165.03,125.91 164.96,125.85 arc(164.85,125.78) 164.73,125.75 163.38,125.75 163.28,125.66 163.26,125.66
  SIG5 w0.16: 163.26,125.66 162.49,125.66 arc(162.34,125.63) 162.22,125.55 161.68,125.01 161.68,124.79 161.14,124.25 160.93,124.25 160.07,123.4 arc(159.7,123.15) 159.26,123.06 158.5,123.06 158.35,122.91 157.58,122.91 157.43,123.06 155.45,123.06 arc(155.15,123) 154.91,122.84 152.33,120.26 152.33,120.05 151.79,119.51 151.58,119.51 147.05,114.98 arc(146.88,114.73) 146.82,114.44 146.82,107.15 arc(146.77,106.85) 146.6,106.61 129.93,89.94 arc(129.77,89.69) 129.71,89.4 129.71,70.65 arc(129.65,70.36) 129.49,70.11 128.93,69.55 arc(128.76,69.31) 128.7,69.01 128.7,55.79 arc(128.48,55.25) 127.94,55.03 115.75,55.03 arc(115.61,55) 115.48,54.91 115.43,54.86 arc(115.34,54.72) 115.31,54.57 115.31,54.08 arc(115.26,53.86) 115.14,53.67 114.69,53.23 arc(114.68,53.21) 114.67,53.2 arc(114.54,52.99) 114.5,52.76 YJ25.B6
FC19_TDP0: length 105.9
  TOP w0.147: U1.AC66 164.99,128.84 arc(164.68,128.71) v4(164.55,128.4)
  SIG5 w0.112: 163.18,127.66 163.21,127.66 163.3,127.75 163.75,127.75 arc(163.87,127.78) 163.98,127.85 164.03,127.89 arc(164.1,128) 164.12,128.12 164.12,128.62 arc(164.16,128.71) 164.25,128.74 164.42,128.74 arc(164.51,128.71) 164.55,128.62 v4(164.55,128.4)
  SIG5 w0.16: 163.18,127.66 161.7,127.66 arc(161.55,127.63) 161.43,127.55 160.45,126.57 arc(160.08,126.32) 159.64,126.24 154.3,126.24 arc(154.01,126.18) 153.76,126.01 152.71,124.96 152.71,124.75 152.17,124.21 151.96,124.21 151.42,123.67 151.42,123.45 150.88,122.91 150.67,122.91 150.13,122.38 150.13,122.16 149.59,121.62 149.37,121.62 144.43,116.68 arc(144.27,116.43) 144.21,116.14 144.21,108.55 arc(144.12,108.11) 143.87,107.74 127.43,91.3 arc(127.35,91.17) 127.32,91.03 127.32,68.24 arc(127.32,68.21) 127.33,68.19 arc(127.34,68.17) 127.35,68.16 arc(127.38,68.12) 127.39,68.08 127.39,59.79 arc(127.16,59.25) 126.62,59.03 115.75,59.03 arc(115.61,59) 115.48,58.91 115.43,58.86 arc(115.34,58.72) 115.31,58.57 115.31,58.08 arc(115.26,57.86) 115.14,57.67 114.67,57.2 arc(114.67,57.2) 114.67,57.2 arc(114.54,57.01) 114.5,56.79 YJ25.B33
FC19_TDP1: length 111.9
  TOP w0.147: U1.AD64 166.55,129.34 v4(166.55,129.29)
  SIG4 w0.112: v4(166.55,129.29) 166.55,129.07 arc(166.51,128.98) 166.42,128.94 166.25,128.94 arc(166.16,128.98) 166.12,129.07 166.12,129.54 arc(166.09,129.66) 166.02,129.76 165.94,129.85 arc(165.84,129.92) 165.71,129.94 163.38,129.94 163.29,130.03 163.27,130.03
  SIG4 w0.16: 163.27,130.03 162.99,130.03 arc(162.59,129.95) 162.25,129.73 161.92,129.4 arc(161.79,129.31) 161.65,129.28 154.02,129.28 arc(153.59,129.2) 153.22,128.95 150.35,126.08 arc(150.1,125.71) 150.01,125.27 150.01,122.98 arc(149.98,122.84) 149.9,122.71 144.16,116.97 arc(143.91,116.6) 143.83,116.17 143.83,108.42 arc(143.8,108.27) 143.72,108.15 127.25,91.68 arc(127.01,91.31) 126.92,90.88 126.92,71.64 127.19,71.37 127.19,68.1 127,67.91 127,61.57 arc(126.97,61.43) 126.89,61.3 125.1,59.52 arc(124.98,59.44) 124.83,59.41 113.35,59.41 arc(113.06,59.35) 112.81,59.18 112.76,59.13 112.72,59.08 arc(112.47,58.92) 112.18,58.86 111.32,58.86 arc(111.1,58.77) 111.01,58.55 111.01,58.32 arc(111.04,58.13) 111.15,57.97 YJ25.B37
FC19_TDP2: length 115.4
  TOP w0.147: v4(168.55,128.39) 168.55,128.47 arc(168.56,128.54) 168.6,128.59 168.71,128.7 arc(168.86,128.81) U1.AC62
  SIG4 w0.112: 162.88,126.74 162.9,126.74 163,126.84 163.28,126.84 arc(163.33,126.84) 163.39,126.85 arc(163.49,126.89) 163.57,126.96 164.21,127.59 arc(164.37,127.7) 164.57,127.74 167.71,127.74 arc(167.84,127.76) 167.94,127.83 168.02,127.91 arc(168.09,128.02) 168.12,128.14 168.12,128.62 arc(168.16,128.71) 168.25,128.74 168.42,128.74 arc(168.51,128.71) 168.55,128.62 v4(168.55,128.39)
  SIG4 w0.16: YJ25.B3 112.1,52.81 arc(112.14,53.02) 112.26,53.19 112.74,53.67 arc(112.86,53.86) 112.91,54.08 112.91,54.57 arc(112.94,54.72) 113.03,54.86 113.08,54.91 arc(113.21,55) 113.35,55.03 125.39,55.03 arc(125.68,55.08) 125.93,55.25 126.29,55.61 126.62,55.61 127,55.99 127,56.33 127.36,56.69 127.67,56.69 128.08,57.1 128.08,57.4 128.47,57.79 arc(128.64,58.04) 128.7,58.33 128.7,66.23 arc(128.75,66.52) 128.92,66.77 129.49,67.34 arc(129.65,67.59) 129.71,67.88 129.71,89.4 arc(129.77,89.69) 129.93,89.94 146.6,106.61 arc(146.77,106.85) 146.82,107.15 146.82,114.46 arc(146.88,114.76) 147.05,115 152.25,120.21 arc(152.42,120.45) 152.47,120.74 152.47,124.43 arc(152.53,124.72) 152.7,124.97 154.25,126.52 arc(154.49,126.69) 154.79,126.74 162.88,126.74
FC19_TDP3: length 108.2
  TOP w0.147: v4(165.55,127.29) 165.55,127.34 U1.AB65
  SIG5 w0.112: v4(165.55,127.29) 165.55,127.07 arc(165.51,126.98) 165.42,126.94 165.25,126.94 arc(165.02,126.85) 164.92,126.62 164.92,126.14 arc(164.92,126.09) 164.89,126.05 164.82,125.99 arc(164.78,125.96) 164.73,125.95 163.38,125.95 163.28,126.04 163.26,126.04
  SIG5 w0.16: YJ25.B5 113.55,53.97 arc(113.44,54.13) 113.41,54.32 113.41,54.52 arc(113.51,54.76) 113.75,54.86 114.58,54.86 arc(114.87,54.92) 115.12,55.08 115.16,55.13 115.21,55.18 arc(115.46,55.35) 115.75,55.41 127.94,55.41 arc(128.21,55.52) 128.32,55.79 128.32,69.01 arc(128.41,69.45) 128.66,69.82 129.22,70.38 arc(129.3,70.5) 129.33,70.65 129.33,89.4 arc(129.42,89.84) 129.66,90.21 146.33,106.88 arc(146.41,107) 146.44,107.15 146.44,114.44 arc(146.53,114.88) 146.78,115.25 154.64,123.11 arc(155.01,123.35) 155.45,123.44 159.26,123.44 arc(159.55,123.5) 159.8,123.66 161.95,125.82 arc(162.2,125.98) 162.49,126.04 163.26,126.04
FC20_21_PVDD0P8: length 5.6
  TOP w0.229: U1.AG49 v1(181.55,132.34) ; U1.AE49 v1(181.55,130.34)
  TOP w0.381: C3137.1 154.88,120.65 ; C3137.1 154.27,119.86 ; C3137.1 155.49,119.86
  BOTTOM w0.13: v1(155.38,121.03) v2(155.38,121.79)
  BOTTOM w0.381: v1(181.55,132.34) 181.55,132.36 C3092.1 ; C3341.1 181.06,130.83 v1(181.55,130.34)
  vias: v1(154.37,121.03)
FC20_RDN0: length 105.1
  TOP w0.147: U1.AA54 176.55,126.34 v4(176.55,126.29)
  SIG8 w0.112: v4(176.55,126.29) 176.55,126.04 arc(176.52,125.97) 176.45,125.94 176.22,125.94 arc(176.01,125.85) 175.92,125.64 175.92,124.14 arc(175.91,124.09) 175.89,124.05 175.8,123.96 arc(175.76,123.93) 175.71,123.92 163.4,123.92 163.31,124.02 163.28,124.02
  SIG8 w0.16: 163.28,124.02 160.42,124.02 arc(159.98,123.93) 159.61,123.68 159.48,123.55 arc(159.36,123.47) 159.21,123.44 155.45,123.44 arc(155.01,123.35) 154.64,123.11 146.83,115.3 arc(146.58,114.93) 146.49,114.49 146.49,103.37 arc(146.44,103.07) 146.27,102.83 129.55,86.11 arc(129.39,85.86) 129.33,85.57 129.33,78.65 arc(129.27,78.36) 129.1,78.11 127.95,76.95 arc(127.78,76.71) 127.72,76.42 127.72,68.99 arc(127.7,68.85) 127.61,68.73 127.29,68.4 arc(127.04,68.03) 126.95,67.59 126.95,59.96 arc(127.23,59.29) 127.9,59.01 128.99,59.01 arc(129.14,58.98) 129.26,58.9 129.35,58.82 arc(129.42,58.73) 129.47,58.63 arc(129.5,58.53) 129.51,58.42 129.51,58.15 arc(129.57,57.85) 129.74,57.59 130,57.34 arc(130.22,57) 130.3,56.61 YJ26.B21
FC20_RDN1: length 112.1
  TOP w0.147: U1.Y58 172.95,125.84 arc(172.86,125.82) 172.78,125.77 172.65,125.64 arc(172.58,125.53) v4(172.55,125.39)
  SIG9 w0.112: 163.13,127.64 163.24,127.75 171.54,127.75 arc(171.69,127.72) 171.81,127.63 arc(171.9,127.51) 171.93,127.36 171.93,126.04 arc(172.01,125.83) 172.22,125.74 172.42,125.74 arc(172.46,125.73) 172.51,125.71 172.51,125.7 arc(172.54,125.66) 172.55,125.61 v4(172.55,125.39)
  SIG9 w0.16: 163.13,127.64 161.39,127.64 arc(161.24,127.61) 161.12,127.52 160.43,126.84 arc(160.33,126.75) 160.21,126.69 arc(160.06,126.63) 159.9,126.62 154.53,126.62 arc(154.38,126.59) 154.26,126.5 149.29,121.54 144.32,116.57 arc(144.24,116.44) 144.21,116.3 144.21,104.63 arc(144.12,104.19) 143.87,103.82 137.68,97.63 131.49,91.44 arc(131.41,91.32) 131.38,91.17 131.38,90.86 arc(131.29,90.43) 131.05,90.06 129.24,88.25 127.43,86.44 arc(127.35,86.31) 127.32,86.17 127.32,79.23 arc(127.23,78.79) 126.98,78.42 126.17,77.61 125.36,76.8 arc(125.28,76.67) 125.25,76.53 125.25,66.74 arc(125.3,66.45) 125.47,66.2 125.85,65.83 arc(126.01,65.58) 126.07,65.29 126.07,60.81 126.4,60.48 126.4,60.05 126.07,59.72 126.07,59.29 arc(126.1,59.14) 126.18,59.02 126.7,58.49 127.11,58.49 127.47,58.13 127.47,57.72 127.83,57.36 128.24,57.36 128.55,57.06 128.55,56.65 129.69,55.51 arc(129.81,55.42) 129.96,55.39 131.39,55.39 arc(131.68,55.34) 131.93,55.17 132.02,55.08 arc(132.2,54.95) 132.42,54.87 arc(132.49,54.86) 132.56,54.86 133.46,54.86 arc(133.7,54.76) 133.8,54.52 133.8,54.34 arc(133.76,54.14) 133.65,53.97 YJ26.B14
FC20_RDN2: length 112.2
  TOP w0.147: v4(174.55,126.29) 174.55,126.34 U1.AA56
  SIG8 w0.112: 163.26,126.04 163.28,126.04 163.38,125.95 168.68,125.95 arc(168.72,125.95) 168.76,125.98 168.92,126.13 arc(168.94,126.17) 168.95,126.22 168.95,126.46 arc(168.98,126.59) 169.05,126.69 169.17,126.82 arc(169.28,126.89) 169.4,126.91 173.73,126.91 arc(173.85,126.89) 173.96,126.82 174.05,126.72 arc(174.12,126.62) 174.14,126.5 174.14,126.04 arc(174.17,125.97) 174.25,125.94 174.45,125.94 arc(174.52,125.97) 174.55,126.04 v4(174.55,126.29)
  SIG8 w0.16: YJ26.B18 130.3,52.78 arc(130.25,53.01) 130.12,53.21 129.71,53.63 arc(129.56,53.84) 129.51,54.1 129.51,54.31 arc(129.45,54.63) 129.27,54.89 129.26,54.9 arc(129.14,54.98) 128.99,55.01 127.12,55.01 arc(126.08,55.45) 125.65,56.49 125.65,77.29 arc(125.71,77.58) 125.87,77.83 126.71,78.67 arc(126.88,78.92) 126.94,79.21 126.94,85.99 arc(127.02,86.43) 127.27,86.8 130.89,90.42 arc(130.97,90.54) 131,90.69 131,91.2 arc(131.06,91.49) 131.22,91.74 143.6,104.12 arc(143.77,104.36) 143.83,104.66 143.83,116.14 arc(143.91,116.58) 144.16,116.95 153.53,126.32 arc(153.9,126.56) 154.34,126.65 159.76,126.65 arc(160,126.61) 160.21,126.5 arc(160.26,126.47) 160.3,126.43 160.47,126.26 arc(160.71,126.1) 161,126.04 163.26,126.04
FC20_RDN3: length 99.8
  TOP w0.147: U1.Y60 170.95,125.84 arc(170.86,125.82) 170.78,125.77 170.65,125.64 arc(170.58,125.53) v4(170.55,125.39)
  SIG9 w0.112: 163.11,125.67 163.2,125.75 168.91,125.75 168.96,125.7 170.03,125.7 arc(170.22,125.66) 170.39,125.55 v4(170.55,125.39)
  SIG9 w0.16: 163.11,125.67 162.21,125.67 arc(162.07,125.64) 161.94,125.55 159.78,123.4 arc(159.41,123.15) 158.98,123.06 155.29,123.06 arc(155.14,123.03) 155.02,122.95 151,118.93 146.99,114.92 arc(146.9,114.79) 146.88,114.65 146.88,103.37 arc(146.79,102.93) 146.54,102.56 138.18,94.2 129.82,85.84 arc(129.74,85.71) 129.71,85.57 129.71,78.68 arc(129.62,78.24) 129.37,77.87 128.41,76.91 127.92,76.42 127.68,76.18 127.42,75.92 arc(127.34,75.8) 127.31,75.65 127.31,72.97 127.54,72.74 127.54,72.18 127.31,71.95 127.31,71.45 127.54,71.22 127.54,70.66 127.31,70.43 127.31,69.92 arc(127.25,69.61) 127.08,69.35 126.95,69.23 arc(126.79,68.98) 126.73,68.69 126.73,66.94 arc(126.79,66.65) 126.95,66.4 127.17,66.18 arc(127.33,65.94) 127.39,65.64 127.39,63.33 127.62,63.1 127.62,62.54 127.39,62.31 127.39,61.81 arc(127.45,61.51) 127.61,61.27 127.92,60.96 128.28,60.96 128.64,60.6 128.64,60.24 129.26,59.62 arc(129.31,59.57) 129.37,59.53 arc(129.58,59.43) 129.8,59.39 131.39,59.39 arc(131.68,59.34) 131.93,59.17 132.09,59.01 arc(132.26,58.9) 132.45,58.86 133.46,58.86 arc(133.7,58.76) 133.8,58.52 133.8,58.34 arc(133.76,58.14) 133.65,57.97 YJ26.B25
FC20_RDP0: length 105.1
  TOP w0.147: U1.Y54 177.01,125.84 arc(176.84,125.81) 176.68,125.71 176.61,125.63 arc(176.57,125.56) 176.55,125.48 v4(176.55,125.39)
  SIG8 w0.112: v4(176.55,125.39) 176.55,125.64 arc(176.52,125.71) 176.45,125.74 176.22,125.74 arc(176.15,125.71) 176.12,125.64 176.12,124.14 arc(176.09,124.01) 176.02,123.91 175.94,123.82 arc(175.83,123.75) 175.71,123.73 163.4,123.73 163.31,123.64 163.28,123.64
  SIG8 w0.16: 163.28,123.64 160.42,123.64 arc(160.12,123.58) 159.88,123.41 159.75,123.28 arc(159.5,123.12) 159.21,123.06 155.45,123.06 arc(155.15,123) 154.91,122.84 147.1,115.03 arc(146.93,114.78) 146.88,114.49 146.88,103.37 arc(146.79,102.93) 146.54,102.56 129.82,85.84 arc(129.74,85.71) 129.71,85.57 129.71,78.65 arc(129.62,78.21) 129.37,77.84 128.22,76.68 arc(128.13,76.56) 128.11,76.42 128.11,75.09 128.33,74.86 128.33,74.3 128.11,74.07 128.11,73.57 128.33,73.34 128.33,72.78 128.11,72.55 128.11,72.04 128.33,71.81 128.33,71.26 128.11,71.03 128.11,70.52 128.33,70.29 128.33,69.73 128.11,69.5 128.11,68.99 arc(128.05,68.7) 127.88,68.46 127.56,68.13 arc(127.39,67.88) 127.33,67.59 127.33,59.96 arc(127.5,59.56) 127.9,59.39 128.99,59.39 arc(129.28,59.34) 129.53,59.17 129.71,58.99 arc(129.82,58.91) 129.95,58.87 arc(129.99,58.86) 130.02,58.86 130.9,58.86 arc(131.13,58.82) 131.32,58.69 arc(131.4,58.57) 131.43,58.43 131.43,58.39 arc(131.38,58.17) 131.25,57.97 YJ26.B22
FC20_RDP1: length 112.1
  TOP w0.147: v4(172.55,126.29) 172.55,126.34 U1.AA58
  SIG9 w0.112: 163.13,128.02 163.21,127.94 171.54,127.94 arc(171.76,127.9) 171.95,127.77 arc(172.08,127.58) 172.12,127.36 172.12,126.04 arc(172.15,125.97) 172.22,125.94 172.42,125.94 arc(172.46,125.95) 172.49,125.97 172.52,125.99 arc(172.54,126.03) 172.55,126.07 v4(172.55,126.29)
  SIG9 w0.16: YJ26.B15 132.7,52.75 arc(132.65,53.01) 132.5,53.24 132.15,53.58 arc(131.97,53.85) 131.91,54.16 131.91,54.48 arc(131.91,54.54) 131.89,54.6 arc(131.85,54.69) 131.79,54.77 131.75,54.82 131.66,54.9 arc(131.54,54.98) 131.39,55.01 129.96,55.01 arc(129.67,55.07) 129.42,55.24 127.92,56.74 126.94,57.72 125.91,58.75 arc(125.75,58.99) 125.69,59.29 125.69,65.29 arc(125.66,65.44) 125.58,65.56 125.2,65.93 arc(124.95,66.3) 124.87,66.74 124.87,76.53 arc(124.92,76.82) 125.09,77.07 125.9,77.88 126.71,78.69 arc(126.88,78.94) 126.94,79.23 126.94,86.17 arc(126.99,86.46) 127.16,86.71 130.78,90.33 arc(130.94,90.57) 131,90.86 131,91.17 arc(131.06,91.46) 131.22,91.71 143.6,104.09 arc(143.77,104.34) 143.83,104.63 143.83,116.3 arc(143.89,116.59) 144.05,116.84 153.99,126.77 arc(154.23,126.94) 154.53,127 159.89,127 arc(159.98,127.01) 160.05,127.03 160.16,127.11 160.16,127.11 160.85,127.79 arc(161.1,127.96) 161.39,128.02 163.13,128.02
FC20_RDP2: length 112.2
  TOP w0.147: U1.Y56 175.01,125.84 arc(174.84,125.81) 174.68,125.71 174.61,125.63 arc(174.57,125.56) 174.55,125.48 v4(174.55,125.39)
  SIG8 w0.112: 163.26,125.66 163.28,125.66 163.38,125.75 168.68,125.75 arc(168.8,125.77) 168.9,125.84 169.06,125.99 arc(169.13,126.1) 169.15,126.22 169.15,126.46 arc(169.16,126.51) 169.19,126.55 169.31,126.68 arc(169.35,126.7) 169.4,126.71 173.73,126.71 arc(173.78,126.7) 173.82,126.68 173.91,126.59 arc(173.94,126.54) 173.95,126.5 173.95,126.04 arc(174.03,125.83) 174.25,125.74 174.45,125.74 arc(174.52,125.71) 174.55,125.64 v4(174.55,125.39)
  SIG8 w0.16: YJ26.B17 131.25,53.97 arc(131.36,54.14) 131.4,54.34 131.4,54.45 arc(131.37,54.61) 131.28,54.75 131.28,54.75 arc(131.15,54.83) 131,54.86 129.92,54.86 arc(129.87,54.87) 129.83,54.89 arc(129.83,54.89) 129.82,54.89 arc(129.8,54.9) 129.78,54.92 129.61,55.09 129.53,55.17 arc(129.28,55.34) 128.99,55.39 127.12,55.39 arc(126.35,55.71) 126.03,56.49 126.03,70.15 126.26,70.38 126.26,70.94 126.03,71.17 126.03,71.68 126.26,71.9 126.26,72.46 126.03,72.69 126.03,73.2 126.26,73.43 126.26,73.99 126.03,74.22 126.03,74.72 126.26,74.95 126.26,75.51 126.03,75.74 126.03,77.29 arc(126.06,77.44) 126.14,77.56 126.98,78.4 arc(127.23,78.77) 127.32,79.21 127.32,85.99 arc(127.38,86.28) 127.54,86.53 131.16,90.15 arc(131.32,90.39) 131.38,90.69 131.38,91.2 arc(131.41,91.34) 131.49,91.47 143.87,103.85 arc(144.12,104.22) 144.21,104.66 144.21,116.14 144.21,116.14 arc(144.27,116.43) 144.43,116.68 153.8,126.05 arc(154.05,126.21) 154.34,126.27 159.76,126.27 arc(159.88,126.25) 159.98,126.2 arc(160.01,126.18) 160.03,126.16 160.2,125.99 arc(160.57,125.74) 161,125.66 163.26,125.66
FC20_RDP3: length 99.8
  TOP w0.147: U1.AA60 170.55,126.34 v4(170.55,126.29)
  SIG9 w0.112: v4(170.55,126.29) 170.51,126.25 arc(170.12,125.99) 169.66,125.9 169.04,125.9 168.99,125.95 163.21,125.95 163.11,126.05
  SIG9 w0.16: YJ26.B24 132.7,56.78 arc(132.65,57.01) 132.52,57.21 132.05,57.68 arc(131.95,57.84) 131.91,58.03 131.91,58.48 arc(131.91,58.53) 131.9,58.59 arc(131.89,58.6) 131.89,58.61 arc(131.85,58.7) 131.79,58.77 131.75,58.82 131.66,58.9 arc(131.54,58.98) 131.39,59.01 129.8,59.01 arc(129.46,59.07) 129.15,59.21 arc(129.07,59.28) 128.99,59.35 127.34,61 arc(127.1,61.37) 127.01,61.81 127.01,65.64 arc(126.98,65.79) 126.9,65.91 126.68,66.13 arc(126.43,66.5) 126.35,66.94 126.35,68.69 arc(126.43,69.13) 126.68,69.5 126.81,69.62 arc(126.9,69.76) 126.93,69.92 126.93,75.65 arc(126.99,75.95) 127.15,76.19 127.41,76.45 127.65,76.69 129.1,78.14 arc(129.27,78.39) 129.33,78.68 129.33,85.57 arc(129.39,85.86) 129.55,86.11 146.27,102.83 arc(146.44,103.07) 146.49,103.37 146.49,114.65 arc(146.55,114.94) 146.72,115.19 154.75,123.22 arc(155,123.38) 155.29,123.44 158.98,123.44 arc(159.27,123.5) 159.51,123.66 161.67,125.82 arc(161.92,125.99) 162.21,126.05 163.11,126.05
FC20_TDN0: length 105.6
  TOP w0.147: U1.W62 169,124.84 arc(168.68,124.71) v4(168.55,124.39)
  SIG6 w0.112: v4(168.55,124.39) 168.55,124.62 arc(168.51,124.71) 168.42,124.74 168.25,124.74 arc(168.02,124.84) 167.92,125.07 167.92,125.56 arc(167.91,125.61) 167.89,125.65 167.83,125.7 arc(167.79,125.73) 167.74,125.74 163.39,125.74 163.29,125.65 163.27,125.65
  SIG6 w0.16: 163.27,125.65 162.1,125.65 arc(161.81,125.59) 161.56,125.42 160.93,124.79 arc(160.62,124.57) 160.26,124.47 arc(160.19,124.46) 160.12,124.46 159.13,124.46 arc(158.98,124.43) 158.86,124.35 157.91,123.4 arc(157.54,123.15) 157.1,123.06 155.47,123.06 arc(155.18,123) 154.93,122.84 148.5,116.4 arc(148.33,116.15) 148.27,115.86 148.27,104.63 arc(148.21,104.34) 148.05,104.09 132,88.04 arc(131.83,87.79) 131.77,87.5 131.77,75.52 132.02,75.27 132.02,74.84 131.77,74.59 131.77,73.35 arc(131.72,73.06) 131.55,72.81 130.6,71.86 130.6,71.55 130.26,71.21 129.95,71.21 129.61,70.87 129.61,70.56 129.27,70.22 128.96,70.22 128.62,69.88 128.62,69.57 128.28,69.23 127.97,69.23 127.63,68.89 arc(127.46,68.64) 127.4,68.35 127.4,61.44 arc(127.46,61.14) 127.63,60.9 128.91,59.62 arc(129.15,59.45) 129.44,59.39 138.59,59.39 arc(138.88,59.34) 139.13,59.17 139.34,58.96 arc(139.38,58.93) 139.42,58.9 arc(139.5,58.87) 139.58,58.86 140.6,58.86 arc(140.89,58.74) 141,58.46 141,58.34 arc(140.96,58.14) 140.85,57.97 YJ26.B34
FC20_TDN1: length 114.1
  TOP w0.147: U1.Y64 166.55,125.34 v4(166.55,125.29)
  SIG7 w0.112: v4(166.55,125.29) 166.55,125.1 arc(166.54,125.04) 166.51,125 166.49,124.98 arc(166.44,124.95) 166.39,124.94 166.26,124.94 arc(166.16,124.98) 166.12,125.08 166.12,125.5 arc(166.09,125.65) 166,125.77 165.98,125.79 arc(165.86,125.88) 165.71,125.91 164.47,125.91 arc(164.41,125.92) 164.35,125.96 164.29,126.01 arc(164.17,126.09) 164.03,126.12 163.73,126.12 163.64,126.21 163.61,126.21
  SIG7 w0.16: 163.61,126.21 162.62,126.21 arc(162.53,126.23) 162.46,126.28 162.34,126.4 arc(162.14,126.54) 161.91,126.58 154.11,126.58 arc(153.82,126.52) 153.57,126.36 144.05,116.84 arc(143.89,116.59) 143.83,116.3 143.83,104.48 arc(143.8,104.33) 143.72,104.21 129.55,90.04 arc(129.39,89.8) 129.33,89.51 129.33,74.08 arc(129.27,73.79) 129.11,73.55 126.07,70.51 arc(125.8,70.1) 125.7,69.62 125.7,58.74 arc(125.76,58.45) 125.93,58.2 126.94,57.19 128.89,55.24 arc(129.14,55.07) 129.43,55.01 140.99,55.01 arc(141.14,54.98) 141.26,54.9 141.35,54.82 141.39,54.77 arc(141.45,54.7) 141.49,54.61 arc(141.49,54.6) 141.49,54.59 arc(141.51,54.54) 141.51,54.48 141.51,54.16 arc(141.57,53.85) 141.75,53.58 142.02,53.31 142.18,53.16 arc(142.27,53.02) 142.3,52.86 YJ26.B3
FC20_TDN2: length 103
  TOP w0.147: U1.W66 165,124.84 arc(164.68,124.71) v4(164.55,124.39)
  SIG7 w0.112: 163.17,123.71 163.2,123.71 163.29,123.8 163.54,123.8 arc(163.75,123.84) 163.93,123.96 163.95,123.98 arc(164.07,124.16) 164.11,124.37 164.11,124.55 arc(164.17,124.69) 164.3,124.74 164.38,124.74 arc(164.5,124.7) 164.55,124.58 v4(164.55,124.39)
  SIG7 w0.16: YJ26.B37 143.25,57.97 arc(143.36,58.14) 143.4,58.34 143.4,58.52 arc(143.3,58.76) 143.06,58.86 142.16,58.86 arc(141.86,58.92) 141.62,59.08 141.53,59.17 arc(141.28,59.34) 140.99,59.39 129.62,59.39 arc(129.48,59.42) 129.35,59.51 127.51,61.35 arc(127.43,61.47) 127.4,61.62 127.4,67.62 arc(127.43,67.76) 127.51,67.89 131.55,71.92 arc(131.72,72.17) 131.77,72.46 131.77,74.44 131.86,74.53 131.94,74.61 131.94,75.08 131.86,75.16 131.77,75.24 131.77,75.71 131.86,75.79 131.94,75.87 131.94,76.34 131.86,76.42 131.77,76.5 131.77,76.97 131.86,77.05 131.94,77.13 131.94,77.6 131.86,77.68 131.77,77.77 131.77,78.23 131.86,78.31 131.94,78.4 131.94,78.86 131.86,78.94 131.77,79.03 131.77,79.49 131.92,79.63 131.92,80.15 131.77,80.29 131.77,80.75 131.89,80.87 131.89,81.44 131.77,81.55 131.77,87.63 arc(131.8,87.78) 131.89,87.9 146.65,102.67 arc(146.82,102.92) 146.88,103.21 146.88,114.65 arc(146.9,114.79) 146.99,114.92 155.02,122.95 arc(155.14,123.03) 155.29,123.06 159.01,123.06 arc(159.3,123.12) 159.55,123.28 159.86,123.6 arc(159.98,123.68) 160.13,123.71 163.17,123.71
FC20_TDN3: length 113.1
  TOP w0.147: v4(167.55,127.29) 167.55,127.34 U1.AB63
  SIG6 w0.112: 163.28,128.03 163.31,128.03 163.4,127.94 166.74,127.94 arc(166.87,127.91) 166.97,127.84 167.02,127.79 arc(167.09,127.69) 167.12,127.56 167.12,127.07 arc(167.16,126.98) 167.25,126.94 167.42,126.94 arc(167.51,126.98) 167.55,127.07 v4(167.55,127.29)
  SIG6 w0.16: 163.28,128.03 161.58,128.03 arc(161.15,127.94) 160.78,127.7 160.22,127.14 arc(160.15,127.09) 160.08,127.05 arc(160.02,127.03) 159.95,127.03 154.72,127.03 arc(154.28,126.94) 153.91,126.69 144.16,116.95 arc(143.91,116.57) 143.83,116.14 143.83,104.53 arc(143.8,104.38) 143.72,104.26 129.66,90.21 arc(129.42,89.84) 129.33,89.4 129.33,74.91 arc(129.3,74.76) 129.22,74.64 126.04,71.46 arc(125.79,71.09) 125.7,70.65 125.7,58.82 arc(125.79,58.38) 126.04,58.01 128.7,55.35 arc(129.07,55.1) 129.51,55.01 138.59,55.01 arc(138.74,54.98) 138.86,54.9 138.95,54.82 138.99,54.77 arc(139.05,54.69) 139.09,54.6 arc(139.09,54.6) 139.1,54.59 arc(139.11,54.54) 139.11,54.48 139.11,54.16 arc(139.17,53.85) 139.35,53.58 139.76,53.17 arc(139.86,53.02) 139.9,52.84 YJ26.B6
FC20_TDP0: length 105.6
  TOP w0.147: v4(168.55,125.29) 168.55,125.34 U1.Y62
  SIG6 w0.112: v4(168.55,125.29) 168.55,125.07 arc(168.51,124.98) 168.42,124.94 168.25,124.94 arc(168.16,124.98) 168.12,125.07 168.12,125.56 arc(168.09,125.68) 168.02,125.79 167.97,125.84 arc(167.87,125.91) 167.74,125.94 163.39,125.94 163.29,126.03 163.27,126.03
  SIG6 w0.16: 163.27,126.03 162.1,126.03 arc(161.66,125.94) 161.29,125.69 160.66,125.06 arc(160.45,124.92) 160.21,124.84 arc(160.16,124.84) 160.12,124.84 159.13,124.84 arc(158.84,124.78) 158.59,124.62 157.64,123.66 arc(157.39,123.5) 157.1,123.44 155.47,123.44 arc(155.03,123.35) 154.66,123.11 148.23,116.67 arc(147.98,116.3) 147.89,115.86 147.89,104.63 arc(147.86,104.49) 147.78,104.36 131.73,88.31 arc(131.48,87.94) 131.39,87.5 131.39,73.35 arc(131.36,73.2) 131.28,73.08 127.36,69.16 arc(127.11,68.78) 127.02,68.35 127.02,61.44 arc(127.11,61) 127.36,60.63 128.64,59.35 arc(129.01,59.1) 129.44,59.01 138.59,59.01 arc(138.74,58.98) 138.86,58.9 138.87,58.89 arc(139.05,58.63) 139.11,58.31 139.11,58.16 arc(139.17,57.85) 139.35,57.58 139.52,57.41 139.72,57.21 arc(139.85,57.01) 139.9,56.78 YJ26.B33
FC20_TDP1: length 114.1
  TOP w0.147: U1.W64 167,124.84 arc(166.68,124.71) v4(166.55,124.39)
  SIG7 w0.112: 163.61,125.83 163.64,125.83 163.73,125.93 164.03,125.93 arc(164.1,125.91) 164.15,125.88 164.21,125.82 arc(164.33,125.74) 164.47,125.71 165.71,125.71 arc(165.78,125.7) 165.85,125.65 165.86,125.63 arc(165.91,125.57) 165.92,125.5 165.92,125.08 arc(166.02,124.84) 166.26,124.74 166.38,124.74 arc(166.5,124.7) 166.55,124.58 v4(166.55,124.39)
  SIG7 w0.16: YJ26.B2 143.25,53.97 arc(143.36,54.14) 143.4,54.34 143.4,54.52 arc(143.3,54.76) 143.06,54.86 142.28,54.86 arc(141.87,54.94) 141.53,55.17 arc(141.28,55.34) 140.99,55.39 129.43,55.39 arc(129.29,55.42) 129.16,55.51 128.75,55.92 128.75,56.14 128.42,56.47 128.2,56.47 127.87,56.8 127.87,57.03 127.54,57.36 127.31,57.36 126.98,57.69 126.98,57.91 126.65,58.24 126.43,58.24 126.2,58.47 arc(126.11,58.6) 126.08,58.74 126.08,69.62 arc(126.15,69.96) 126.34,70.24 126.81,70.71 127.04,70.71 127.37,71.04 127.37,71.27 127.7,71.6 127.93,71.6 128.26,71.93 128.26,72.16 128.58,72.49 128.79,72.49 129.14,72.84 129.14,73.04 129.38,73.28 arc(129.62,73.65) 129.71,74.08 129.71,89.51 arc(129.74,89.65) 129.82,89.78 143.99,103.94 arc(144.15,104.19) 144.21,104.48 144.21,116.3 arc(144.24,116.44) 144.32,116.57 153.84,126.09 arc(153.96,126.17) 154.11,126.2 161.91,126.2 arc(162,126.18) 162.07,126.14 162.19,126.01 arc(162.39,125.88) 162.62,125.83 163.61,125.83
FC20_TDP2: length 103
  TOP w0.147: U1.Y66 164.55,125.34 v4(164.55,125.29)
  SIG7 w0.112: 163.17,124.09 163.2,124.09 163.29,124 163.54,124 arc(163.68,124.03) 163.79,124.1 163.81,124.12 arc(163.89,124.24) 163.92,124.37 163.92,124.55 arc(164.03,124.83) 164.3,124.94 164.38,124.94 arc(164.5,124.99) 164.55,125.1 v4(164.55,125.29)
  SIG7 w0.16: 163.17,124.09 160.13,124.09 arc(159.84,124.03) 159.59,123.87 159.28,123.55 arc(159.15,123.47) 159.01,123.44 155.29,123.44 arc(155,123.38) 154.75,123.22 146.72,115.19 arc(146.55,114.94) 146.49,114.65 146.49,103.21 arc(146.47,103.06) 146.38,102.94 131.62,88.17 arc(131.45,87.93) 131.39,87.63 131.39,72.46 arc(131.36,72.31) 131.28,72.19 127.25,68.16 arc(127.08,67.91) 127.02,67.62 127.02,61.62 arc(127.08,61.32) 127.25,61.08 129.08,59.24 arc(129.33,59.07) 129.62,59.01 140.99,59.01 arc(141.14,58.98) 141.26,58.9 141.35,58.82 141.39,58.77 arc(141.45,58.69) 141.5,58.59 arc(141.51,58.54) 141.51,58.48 141.51,58.16 arc(141.57,57.85) 141.75,57.58 142.14,57.19 arc(142.26,57.02) 142.3,56.81 YJ26.B36
FC20_TDP3: length 113.1
  TOP w0.147: U1.AA63 168,126.84 arc(167.68,126.71) v4(167.55,126.39)
  SIG6 w0.112: v4(167.55,126.39) 167.55,126.62 arc(167.51,126.71) 167.42,126.74 167.25,126.74 arc(167.02,126.84) 166.92,127.07 166.92,127.56 arc(166.91,127.61) 166.89,127.65 166.83,127.7 arc(166.79,127.73) 166.74,127.74 163.4,127.74 163.31,127.65 163.28,127.65
  SIG6 w0.16: 163.28,127.65 161.58,127.65 arc(161.29,127.59) 161.05,127.43 160.49,126.87 160.21,126.69 arc(160.08,126.66) 159.95,126.64 154.72,126.64 arc(154.42,126.59) 154.18,126.42 144.43,116.68 arc(144.27,116.43) 144.21,116.14 144.21,104.53 arc(144.15,104.24) 143.99,103.99 129.93,89.94 arc(129.77,89.69) 129.71,89.4 129.71,74.91 arc(129.65,74.61) 129.49,74.37 128.29,73.17 128.29,72.83 127.98,72.52 127.64,72.52 127.3,72.18 127.3,71.84 126.99,71.53 126.65,71.53 126.31,71.19 arc(126.14,70.94) 126.08,70.65 126.08,58.82 arc(126.14,58.53) 126.31,58.28 126.99,57.6 127.32,57.6 127.64,57.29 127.64,56.95 127.98,56.61 128.32,56.61 128.63,56.3 128.63,55.96 128.97,55.62 arc(129.22,55.45) 129.51,55.39 138.59,55.39 arc(138.88,55.34) 139.13,55.17 arc(139.47,54.94) 139.88,54.86 140.66,54.86 arc(140.9,54.76) 141,54.52 141,54.34 arc(140.96,54.14) 140.85,53.97 YJ26.B5
FC21_RDN0: length 89.1
  TOP w0.147: U1.U53 178.01,122.84 arc(177.84,122.81) 177.68,122.71 177.61,122.63 arc(177.57,122.56) 177.55,122.48 v4(177.55,122.39)
  SIG8 w0.112: 163.26,119.65 163.28,119.65 163.38,119.74 168.82,119.74 arc(169.07,119.79) 169.28,119.93 169.51,120.17 169.92,120.58 arc(170.11,120.7) 170.32,120.74 176.68,120.74 arc(176.85,120.77) 176.99,120.87 arc(177.09,121.01) 177.12,121.18 177.12,122.64 arc(177.15,122.71) 177.22,122.74 177.45,122.74 arc(177.52,122.71) 177.55,122.64 v4(177.55,122.39)
  SIG8 w0.16: 163.26,119.65 162.93,119.65 arc(162.79,119.62) 162.66,119.54 161.1,117.97 arc(160.73,117.72) 160.29,117.64 159.78,117.64 arc(159.49,117.58) 159.24,117.41 153.32,111.5 arc(153.16,111.25) 153.1,110.96 153.1,103.6 arc(153.01,103.16) 152.76,102.79 143.81,93.84 arc(143.73,93.71) 143.7,93.57 143.7,89.52 arc(143.61,89.08) 143.37,88.71 142.49,87.84 arc(142.12,87.59) 141.68,87.5 140.1,87.5 arc(139.81,87.44) 139.57,87.28 136.58,84.29 arc(136.34,84.13) 136.04,84.07 135.41,84.07 arc(135.11,84.01) 134.87,83.85 134.06,83.04 arc(133.9,82.8) 133.84,82.5 133.84,80.95 134.04,80.74 134.04,80.13 133.84,79.93 133.84,78.92 134.04,78.71 134.04,78.1 133.84,77.9 133.84,76.94 arc(133.75,76.5) 133.5,76.13 132.4,75.03 arc(132.32,74.91) 132.29,74.76 132.29,71.71 132.55,71.45 132.55,70.95 132.29,70.69 132.29,70.18 132.55,69.93 132.55,69.42 132.29,69.17 132.29,68.66 132.55,68.41 132.55,67.9 132.29,67.64 132.29,67.1 arc(132.32,66.98) 132.41,66.9 arc(132.46,66.87) 132.53,66.86 133.3,66.86 arc(133.5,66.82) 133.66,66.71 133.72,66.65 arc(133.78,66.56) 133.8,66.45 133.8,66.34 arc(133.76,66.14) 133.65,65.97 YJ26.A25
FC21_RDN1: length 94.9
  TOP w0.147: v4(173.55,123.29) 173.55,123.34 U1.V57
  SIG9 w0.112: v4(173.55,123.29) 173.55,123.07 arc(173.54,123.03) 173.52,122.99 173.49,122.97 arc(173.46,122.95) 173.42,122.94 173.25,122.94 arc(173.18,122.97) 173.15,123.04 173.15,123.48 arc(173.12,123.61) 173.05,123.71 172.94,123.83 arc(172.83,123.9) 172.71,123.92 163.36,123.92 arc(163.3,123.94) 163.25,123.97 arc(163.2,124) 163.14,124.02 163.11,124.02
  SIG9 w0.16: 163.11,124.02 162.63,124.02 arc(162.33,123.96) 162.09,123.79 160.26,121.97 arc(160.17,121.85) 160.09,121.72 159.96,121.39 arc(159.91,121.13) 159.76,120.91 159.26,120.41 arc(159.01,120.25) 158.72,120.19 155.85,120.19 arc(155.56,120.13) 155.31,119.97 148.8,113.46 arc(148.64,113.21) 148.58,112.92 148.58,102.5 arc(148.52,102.21) 148.35,101.96 140.24,93.85 arc(140.08,93.6) 140.02,93.31 140.02,91.4 arc(139.96,91.11) 139.79,90.86 137.67,88.74 arc(137.42,88.57) 137.13,88.52 135.22,88.52 arc(134.93,88.46) 134.68,88.29 132.38,85.99 131.62,85.23 arc(131.45,84.98) 131.39,84.69 131.39,77.64 arc(131.36,77.5) 131.28,77.37 129.45,75.54 arc(129.28,75.29) 129.22,75 129.22,70.45 arc(129.17,70.16) 129,69.91 128,68.91 arc(127.75,68.54) 127.67,68.1 127.67,67.29 arc(127.76,66.86) 128,66.48 128.12,66.37 arc(128.2,66.25) 128.23,66.1 128.23,64.41 arc(128.31,63.97) 128.56,63.6 129.35,62.82 129.39,62.77 arc(129.45,62.69) 129.49,62.6 arc(129.5,62.59) 129.5,62.58 arc(129.51,62.53) 129.51,62.48 129.51,62.35 129.51,62.35 129.51,62.04 arc(129.55,61.84) 129.66,61.67 130.16,61.17 arc(130.26,61.02) 130.3,60.84 YJ26.A18
FC21_RDN2: length 97.6
  TOP w0.147: v4(175.55,122.39) 175.55,122.48 arc(175.57,122.56) 175.61,122.63 175.68,122.71 arc(175.84,122.81) 176.01,122.84 U1.U55
  SIG8 w0.112: v4(175.55,122.39) 175.55,122.64 arc(175.52,122.71) 175.45,122.74 175.22,122.74 arc(175.15,122.71) 175.12,122.64 175.12,122.05 arc(175.03,121.84) 174.82,121.75 163.38,121.75 163.28,121.66 163.26,121.66
  SIG8 w0.16: 163.26,121.66 161.26,121.66 arc(161.11,121.63) 160.99,121.55 159.59,120.14 arc(159.21,119.9) 158.78,119.81 156.08,119.81 arc(155.79,119.75) 155.54,119.59 149.18,113.23 arc(149.02,112.98) 148.96,112.69 148.96,112.69 148.96,102.5 arc(148.87,102.07) 148.62,101.69 140.51,93.58 arc(140.43,93.46) 140.4,93.31 140.4,91.37 arc(140.31,90.93) 140.06,90.56 137.97,88.47 arc(137.6,88.22) 137.16,88.14 135.43,88.14 arc(135.14,88.08) 134.89,87.91 132,85.02 arc(131.83,84.77) 131.77,84.48 131.77,77.79 arc(131.69,77.36) 131.44,76.99 130.33,75.87 arc(130.24,75.75) 130.21,75.6 130.21,74.55 130.44,74.32 130.44,73.76 130.21,73.53 130.21,73.02 130.44,72.79 130.44,72.24 130.21,72.01 130.21,71.5 130.44,71.27 130.44,70.71 130.21,70.48 130.21,69.97 130.44,69.75 130.44,69.19 130.21,68.96 130.21,68.08 arc(130.16,67.79) 129.99,67.54 128.86,66.41 arc(128.69,66.16) 128.63,65.87 128.63,64.57 arc(128.69,64.28) 128.86,64.04 129.28,63.62 arc(129.52,63.45) 129.82,63.39 131.39,63.39 arc(131.68,63.34) 131.93,63.17 132.08,63.03 arc(132.26,62.9) 132.47,62.86 133.44,62.86 arc(133.59,62.83) 133.72,62.74 arc(133.78,62.65) 133.8,62.54 133.8,62.35 arc(133.76,62.14) 133.65,61.97 YJ26.A14
FC21_RDN3: length 84.5
  TOP w0.147: U1.V59 171.55,123.34 v4(171.55,123.29)
  SIG9 w0.112: v4(171.55,123.29) 171.55,123.07 arc(171.54,123.02) 171.51,122.98 171.51,122.98 arc(171.46,122.95) 171.42,122.94 171.25,122.94 arc(171.04,122.85) 170.95,122.64 170.95,122.16 arc(170.94,122.07) 170.89,122 arc(170.82,121.95) 170.73,121.94 163.19,121.94 arc(163.13,121.95) 163.08,121.98 163.03,122.03
  SIG9 w0.16: 163.03,122.03 162.82,122.03 arc(162.48,121.96) 162.19,121.77 162.16,121.74 arc(162.11,121.68) 162.07,121.63 162.07,121.63 arc(161.91,121.34) 161.86,121.02 161.86,120.73 arc(161.83,120.59) 161.75,120.47 153.18,111.89 arc(152.93,111.52) 152.84,111.09 152.84,103.56 arc(152.82,103.42) 152.73,103.29 143.65,94.22 arc(143.41,93.85) 143.32,93.41 143.32,89.21 arc(143.29,89.07) 143.21,88.94 142.26,87.99 arc(142.13,87.91) 141.99,87.88 140.36,87.88 arc(139.93,87.79) 139.56,87.55 138.06,86.06 136.57,84.56 arc(136.45,84.48) 136.3,84.45 135.51,84.45 arc(135.07,84.37) 134.7,84.12 133.79,83.21 arc(133.55,82.84) 133.46,82.4 133.46,76.78 arc(133.43,76.63) 133.35,76.51 131.82,74.99 arc(131.66,74.74) 131.6,74.45 131.6,70.9 arc(131.54,70.61) 131.37,70.36 129.24,68.22 arc(129.05,67.95) 128.99,67.62 128.99,67.43 arc(129.04,67.19) 129.17,66.99 129.35,66.82 129.39,66.77 arc(129.46,66.69) 129.5,66.59 arc(129.51,66.53) 129.51,66.48 129.51,66.29 129.51,66 arc(129.54,65.84) 129.64,65.7 130.13,65.2 arc(130.26,65.02) 130.3,64.8 YJ26.A21
FC21_RDP0: length 89.1
  TOP w0.147: U1.V53 177.55,123.34 v4(177.55,123.29)
  SIG8 w0.112: v4(177.55,123.29) 177.55,123.04 arc(177.52,122.97) 177.45,122.94 177.22,122.94 arc(177.01,122.85) 176.92,122.64 176.92,121.18 arc(176.9,121.09) 176.85,121.01 arc(176.77,120.96) 176.68,120.94 170.32,120.94 arc(170.03,120.88) 169.79,120.72 169.37,120.31 169.14,120.07 arc(168.99,119.97) 168.82,119.94 163.38,119.94 163.28,120.03 163.26,120.03
  SIG8 w0.16: 163.26,120.03 162.93,120.03 arc(162.64,119.97) 162.39,119.81 160.83,118.24 arc(160.58,118.08) 160.29,118.02 159.78,118.02 arc(159.34,117.93) 158.97,117.68 153.05,111.77 arc(152.8,111.4) 152.72,110.96 152.72,103.6 arc(152.66,103.3) 152.49,103.06 143.54,94.1 arc(143.38,93.86) 143.32,93.57 143.32,89.52 arc(143.26,89.23) 143.1,88.98 142.22,88.1 arc(141.97,87.94) 141.68,87.88 140.1,87.88 arc(139.67,87.79) 139.3,87.55 136.31,84.56 arc(136.19,84.48) 136.04,84.45 135.41,84.45 arc(134.97,84.37) 134.6,84.12 133.79,83.31 arc(133.55,82.94) 133.46,82.5 133.46,76.94 arc(133.4,76.65) 133.23,76.4 132.13,75.3 arc(131.97,75.05) 131.91,74.76 131.91,66.42 131.91,66.29 131.91,66.09 arc(131.96,65.84) 132.1,65.64 132.55,65.18 arc(132.66,65.02) 132.7,64.83 YJ26.A24
FC21_RDP1: length 94.9
  TOP w0.147: U1.U57 173.95,122.84 arc(173.86,122.82) 173.78,122.77 173.65,122.64 arc(173.58,122.53) v4(173.55,122.39)
  SIG9 w0.112: 163.11,123.64 163.14,123.64 arc(163.2,123.65) 163.25,123.68 163.27,123.69 arc(163.3,123.72) 163.35,123.73 172.71,123.73 arc(172.76,123.72) 172.8,123.69 172.91,123.57 arc(172.94,123.53) 172.95,123.48 172.95,123.04 arc(173.04,122.83) 173.25,122.74 173.42,122.74 arc(173.46,122.73) 173.51,122.71 173.51,122.7 arc(173.54,122.66) 173.55,122.61 v4(173.55,122.39)
  SIG9 w0.16: 163.11,123.64 162.63,123.64 arc(162.48,123.61) 162.36,123.52 161.5,122.66 160.53,121.7 arc(160.48,121.64) 160.45,121.57 160.33,121.3 arc(160.24,120.95) 160.03,120.64 159.53,120.14 arc(159.16,119.9) 158.72,119.81 155.85,119.81 arc(155.7,119.78) 155.58,119.7 152.32,116.44 149.07,113.19 arc(148.99,113.07) 148.96,112.92 148.96,102.5 arc(148.87,102.07) 148.62,101.69 140.51,93.58 arc(140.43,93.46) 140.4,93.31 140.4,91.4 arc(140.31,90.97) 140.06,90.59 137.94,88.47 arc(137.57,88.22) 137.13,88.14 135.22,88.14 arc(135.08,88.11) 134.95,88.02 133.42,86.49 131.89,84.96 arc(131.8,84.83) 131.77,84.69 131.77,77.64 arc(131.72,77.35) 131.55,77.1 129.72,75.27 arc(129.63,75.15) 129.61,75 129.61,74.67 129.91,74.36 129.91,73.96 129.61,73.65 129.61,73.21 129.92,72.9 129.92,72.54 129.61,72.23 129.61,71.76 129.92,71.45 129.92,71.07 129.72,70.88 129.61,70.76 129.61,70.45 arc(129.52,70.01) 129.27,69.64 128.27,68.64 arc(128.11,68.4) 128.05,68.1 128.05,67.29 arc(128.11,67) 128.27,66.75 128.38,66.64 arc(128.55,66.39) 128.61,66.1 128.61,64.41 arc(128.67,64.12) 128.83,63.87 129.49,63.21 129.71,62.99 arc(129.85,62.89) 130.02,62.86 131.06,62.86 arc(131.3,62.76) 131.4,62.52 131.4,62.34 arc(131.36,62.14) 131.25,61.97 YJ26.A17
