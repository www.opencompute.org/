# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Library data of the parts (continued)
R3051 = R: signal model: DEFAULT_RESISTOR_16000OHM_2_1
R3052 = R: signal model: DEFAULT_RESISTOR_16900OHM_2_1
R3101 R3103 = R: signal model: DEFAULT_RESISTOR_470.000000OHM_2_1
R3102 R3104 = R: signal model: DEFAULT_RESISTOR_56.000000OHM_2_1
R3228 = R: signal model: DEFAULT_RESISTOR_1690OHM_2_1
R3238 R3239 = R: signal model: DEFAULT_RESISTOR_3000OHM_2_1
R3437 = R: signal model: DEFAULT_RESISTOR_412.000000OHM_2_1
R4294-R4305 = R: signal model: R_R0402_DISCRETE_CS00002JB38_1/_0
SW4 = SW4P_PS022N12AAK1
SW5 = SW3P_SC12PACQR
SW6 = SW_PUSHBUTTON4P_NDT010-J1A-AEAT
TP1-TP64 = TP: alternate symbols: (TOP:TP26D10;BOTTOM:TP30D10)
TP65-TP67 = TP: alternate symbols: (TOP:TP30;BOTTOM:TP26)
U2 = INA230AIRGTR
U6 = M24128
U7 U8 = TMP75AIDGKR
U19-U24 U28-U33 = NCP45750IMN24TWG
U25 U26 U50 = 74LVC08
U34 = PM8535BFEI
U47 = 9ZXL1231EKILF1KW
U54 = SN74LVC2G34
U56 = M24128BRMN6TP
U58 = AT24C32
U61 = ZL30281LDF1
U62 = NL17SZ00DFT2G
U63 = SN74LVC1G125DBVR
U66 = TXS0102DCUR
U71 U72 U102-U105 = 74LVC07
U73-U84 = INA231AIYFFR
U86 = LM4FB15P9ZADHIN
U88-U93 U108 = PCA9846PW
U94 = LCMXO21200UHC4FTG256C
U95-U100 = SN74LVC2G32DCUR
U101 = PCA9555AHF
U107 = SN74LVC1G07
X1-X8 = TP_TDR_4P_FTS: User Part Number: TP15
Y2 = X_4S_CX3225SB25000D0FPLCC

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
BGA12_0-4_1-388X1-6445
  round 0.229 smd: A1(-0.4,0.6) A2(0,0.6) A3(0.4,0.6) B1(-0.4,0.2) B2(0,0.2) B3(0.4,0.2) C1(-0.4,-0.2) C2(0,-0.2) C3(0.4,-0.2) D1(-0.4,-0.6) D2(0,-0.6) D3(0.4,-0.6)
BGA212
  round 0.292 smd: A1(-4.5,4.5) A2(-4,4.5) A4(-3,4.5) A5(-2.5,4.5) A7(-1.5,4.5) A8(-1,4.5) A10(0,4.5) A11(0.5,4.5) A13(1.5,4.5) A14(2,4.5) A16(3,4.5) A17(3.5,4.5) A18(4,4.5) A19(4.5,4.5) B1(-4.5,4) B2(-4,4) B3(-3.5,4) B4(-3,4) B5(-2.5,4) B6(-2,4) B7(-1.5,4) B8(-1,4) B9(-0.5,4) B10(0,4) B11(0.5,4) B12(1,4) B13(1.5,4) B14(2,4) B15(2.5,4) B16(3,4) B17(3.5,4) B18(4,4) B19(4.5,4) C1(-4.5,3.5) C2(-4,3.5) C5(-2.5,3.5) C6(-2,3.5) C8(-1,3.5) C10(0,3.5) C12(1,3.5) C14(2,3.5) C15(2.5,3.5) C18(4,3.5) D1(-4.5,3) D2(-4,3) D6(-2,3) D7(-1.5,3) D8(-1,3) D12(1,3) D13(1.5,3) D14(2,3) D18(4,3) D19(4.5,3) E2(-4,2.5) E3(-3.5,2.5) E7(-1.5,2.5) E10(0,2.5) E13(1.5,2.5) E17(3.5,2.5) E18(4,2.5) E19(4.5,2.5) F1(-4.5,2) F2(-4,2) F3(-3.5,2) F4(-3,2) F10(0,2) F16(3,2) F17(3.5,2) F18(4,2) G1(-4.5,1.5) G2(-4,1.5) G4(-3,1.5) G5(-2.5,1.5) G10(0,1.5) G15(2.5,1.5) G16(3,1.5) G18(4,1.5) G19(4.5,1.5) H2(-4,1) H3(-3.5,1) H4(-3,1) H9(-0.5,1) H10(0,1) H11(0.5,1) H12(1,1) H16(3,1) H17(3.5,1) H18(4,1) H19(4.5,1) J1(-4.5,0.5) J2(-4,0.5) J8(-1,0.5) J9(-0.5,0.5) J10(0,0.5) J11(0.5,0.5) J12(1,0.5) J18(4,0.5) K1(-4.5,0) K2(-4,0) K3(-3.5,0) K5(-2.5,0) K6(-2,0) K7(-1.5,0) K8(-1,0) K9(-0.5,0) K10(0,0) K11(0.5,0) K12(1,0) K13(1.5,0) K14(2,0) K15(2.5,0) K17(3.5,0) K18(4,0) K19(4.5,0) L2(-4,-0.5) L8(-1,-0.5) L9(-0.5,-0.5) L10(0,-0.5) L11(0.5,-0.5) L12(1,-0.5) L18(4,-0.5) L19(4.5,-0.5) M1(-4.5,-1) M2(-4,-1) M3(-3.5,-1) M4(-3,-1) M8(-1,-1) M9(-0.5,-1) M10(0,-1) M11(0.5,-1) M12(1,-1) M16(3,-1) M17(3.5,-1) M18(4,-1) N1(-4.5,-1.5) N2(-4,-1.5) N4(-3,-1.5) N5(-2.5,-1.5) N10(0,-1.5) N15(2.5,-1.5) N16(3,-1.5) N18(4,-1.5) N19(4.5,-1.5) P2(-4,-2) P3(-3.5,-2) P4(-3,-2) P10(0,-2) P16(3,-2) P17(3.5,-2) P18(4,-2) P19(4.5,-2) R1(-4.5,-2.5) R2(-4,-2.5) R3(-3.5,-2.5) R7(-1.5,-2.5) R10(0,-2.5) R13(1.5,-2.5) R17(3.5,-2.5) R18(4,-2.5) T1(-4.5,-3) T2(-4,-3) T6(-2,-3) T7(-1.5,-3) T8(-1,-3) T12(1,-3) T13(1.5,-3) T14(2,-3) T18(4,-3) T19(4.5,-3) U2(-4,-3.5) U5(-2.5,-3.5) U6(-2,-3.5) U8(-1,-3.5) U10(0,-3.5) U12(1,-3.5) U14(2,-3.5) U15(2.5,-3.5) U18(4,-3.5) U19(4.5,-3.5) V1(-4.5,-4) V2(-4,-4) V3(-3.5,-4) V4(-3,-4) V5(-2.5,-4) V6(-2,-4) V7(-1.5,-4) V8(-1,-4) V9(-0.5,-4) V10(0,-4) V11(0.5,-4) V12(1,-4) V13(1.5,-4) V14(2,-4) V15(2.5,-4) V16(3,-4) V17(3.5,-4) V18(4,-4) V19(4.5,-4) W1(-4.5,-4.5) W2(-4,-4.5) W3(-3.5,-4.5) W4(-3,-4.5) W6(-2,-4.5) W7(-1.5,-4.5) W9(-0.5,-4.5) W10(0,-4.5) W12(1,-4.5) W13(1.5,-4.5) W15(2.5,-4.5) W16(3,-4.5) W18(4,-4.5) W19(4.5,-4.5)
BGA256D
  round 0.49 smd: A1(-7.5,7.5) A2(-6.5,7.5) A3(-5.5,7.5) A4(-4.5,7.5) A5(-3.5,7.5) A6(-2.5,7.5) A7(-1.5,7.5) A8(-0.5,7.5) A9(0.5,7.5) A10(1.5,7.5) A11(2.5,7.5) A12(3.5,7.5) A13(4.5,7.5) A14(5.5,7.5) A15(6.5,7.5) A16(7.5,7.5) B1(-7.5,6.5) B2(-6.5,6.5) B3(-5.5,6.5) B4(-4.5,6.5) B5(-3.5,6.5) B6(-2.5,6.5) B7(-1.5,6.5) B8(-0.5,6.5) B9(0.5,6.5) B10(1.5,6.5) B11(2.5,6.5) B12(3.5,6.5) B13(4.5,6.5) B14(5.5,6.5) B15(6.5,6.5) B16(7.5,6.5) C1(-7.5,5.5) C2(-6.5,5.5) C3(-5.5,5.5) C4(-4.5,5.5) C5(-3.5,5.5) C6(-2.5,5.5) C7(-1.5,5.5) C8(-0.5,5.5) C9(0.5,5.5) C10(1.5,5.5) C11(2.5,5.5) C12(3.5,5.5) C13(4.5,5.5) C14(5.5,5.5) C15(6.5,5.5) C16(7.5,5.5) D1(-7.5,4.5) D2(-6.5,4.5) D3(-5.5,4.5) D4(-4.5,4.5) D5(-3.5,4.5) D6(-2.5,4.5) D7(-1.5,4.5) D8(-0.5,4.5) D9(0.5,4.5) D10(1.5,4.5) D11(2.5,4.5) D12(3.5,4.5) D13(4.5,4.5) D14(5.5,4.5) D15(6.5,4.5) D16(7.5,4.5) E1(-7.5,3.5) E2(-6.5,3.5) E3(-5.5,3.5) E4(-4.5,3.5) E5(-3.5,3.5) E6(-2.5,3.5) E7(-1.5,3.5) E8(-0.5,3.5) E9(0.5,3.5) E10(1.5,3.5) E11(2.5,3.5) E12(3.5,3.5) E13(4.5,3.5) E14(5.5,3.5) E15(6.5,3.5) E16(7.5,3.5) F1(-7.5,2.5) F2(-6.5,2.5) F3(-5.5,2.5) F4(-4.5,2.5) F5(-3.5,2.5) F6(-2.5,2.5) F7(-1.5,2.5) F8(-0.5,2.5) F9(0.5,2.5) F10(1.5,2.5) F11(2.5,2.5) F12(3.5,2.5) F13(4.5,2.5) F14(5.5,2.5) F15(6.5,2.5) F16(7.5,2.5) G1(-7.5,1.5) G2(-6.5,1.5) G3(-5.5,1.5) G4(-4.5,1.5) G5(-3.5,1.5) G6(-2.5,1.5) G7(-1.5,1.5) G8(-0.5,1.5) G9(0.5,1.5) G10(1.5,1.5) G11(2.5,1.5) G12(3.5,1.5) G13(4.5,1.5) G14(5.5,1.5) G15(6.5,1.5) G16(7.5,1.5) H1(-7.5,0.5) H2(-6.5,0.5) H3(-5.5,0.5) H4(-4.5,0.5) H5(-3.5,0.5) H6(-2.5,0.5) H7(-1.5,0.5) H8(-0.5,0.5) H9(0.5,0.5) H10(1.5,0.5) H11(2.5,0.5) H12(3.5,0.5) H13(4.5,0.5) H14(5.5,0.5) H15(6.5,0.5) H16(7.5,0.5) J1(-7.5,-0.5) J2(-6.5,-0.5) J3(-5.5,-0.5) J4(-4.5,-0.5) J5(-3.5,-0.5) J6(-2.5,-0.5) J7(-1.5,-0.5) J8(-0.5,-0.5) J9(0.5,-0.5) J10(1.5,-0.5) J11(2.5,-0.5) J12(3.5,-0.5) J13(4.5,-0.5) J14(5.5,-0.5) J15(6.5,-0.5) J16(7.5,-0.5) K1(-7.5,-1.5) K2(-6.5,-1.5) K3(-5.5,-1.5) K4(-4.5,-1.5) K5(-3.5,-1.5) K6(-2.5,-1.5) K7(-1.5,-1.5) K8(-0.5,-1.5) K9(0.5,-1.5) K10(1.5,-1.5) K11(2.5,-1.5) K12(3.5,-1.5) K13(4.5,-1.5) K14(5.5,-1.5) K15(6.5,-1.5) K16(7.5,-1.5) L1(-7.5,-2.5) L2(-6.5,-2.5) L3(-5.5,-2.5) L4(-4.5,-2.5) L5(-3.5,-2.5) L6(-2.5,-2.5) L7(-1.5,-2.5) L8(-0.5,-2.5) L9(0.5,-2.5) L10(1.5,-2.5) L11(2.5,-2.5) L12(3.5,-2.5) L13(4.5,-2.5) L14(5.5,-2.5) L15(6.5,-2.5) L16(7.5,-2.5) M1(-7.5,-3.5) M2(-6.5,-3.5) M3(-5.5,-3.5) M4(-4.5,-3.5) M5(-3.5,-3.5) M6(-2.5,-3.5) M7(-1.5,-3.5) M8(-0.5,-3.5) M9(0.5,-3.5) M10(1.5,-3.5) M11(2.5,-3.5) M12(3.5,-3.5) M13(4.5,-3.5) M14(5.5,-3.5) M15(6.5,-3.5) M16(7.5,-3.5) N1(-7.5,-4.5) N2(-6.5,-4.5) N3(-5.5,-4.5) N4(-4.5,-4.5) N5(-3.5,-4.5) N6(-2.5,-4.5) N7(-1.5,-4.5) N8(-0.5,-4.5) N9(0.5,-4.5) N10(1.5,-4.5) N11(2.5,-4.5) N12(3.5,-4.5) N13(4.5,-4.5) N14(5.5,-4.5) N15(6.5,-4.5) N16(7.5,-4.5) P1(-7.5,-5.5) P2(-6.5,-5.5) P3(-5.5,-5.5) P4(-4.5,-5.5) P5(-3.5,-5.5) P6(-2.5,-5.5) P7(-1.5,-5.5) P8(-0.5,-5.5) P9(0.5,-5.5) P10(1.5,-5.5) P11(2.5,-5.5) P12(3.5,-5.5) P13(4.5,-5.5) P14(5.5,-5.5) P15(6.5,-5.5) P16(7.5,-5.5) R1(-7.5,-6.5) R2(-6.5,-6.5) R3(-5.5,-6.5) R4(-4.5,-6.5) R5(-3.5,-6.5) R6(-2.5,-6.5) R7(-1.5,-6.5) R8(-0.5,-6.5) R9(0.5,-6.5) R10(1.5,-6.5) R11(2.5,-6.5) R12(3.5,-6.5) R13(4.5,-6.5) R14(5.5,-6.5) R15(6.5,-6.5) R16(7.5,-6.5) T1(-7.5,-7.5) T2(-6.5,-7.5) T3(-5.5,-7.5) T4(-4.5,-7.5) T5(-3.5,-7.5) T6(-2.5,-7.5) T7(-1.5,-7.5) T8(-0.5,-7.5) T9(0.5,-7.5) T10(1.5,-7.5) T11(2.5,-7.5) T12(3.5,-7.5) T13(4.5,-7.5) T14(5.5,-7.5) T15(6.5,-7.5) T16(7.5,-7.5)
BGA1311_1_37-5X37-5
  round 0.49 smd: A2(-17,18) A3(-16,18) A4(-15,18) A5(-14,18) A6(-13,18) A7(-12,18) A9(-10,18) A11(-8,18) A13(-6,18) A15(-4,18) A16(-3,18) A18(-1,18) A20(1,18) A22(3,18) A24(5,18) A25(6,18) A27(8,18) A29(10,18) A31(12,18) A33(14,18) A34(15,18) A35(16,18) A36(17,18) AA1(-18,-2) AA2(-17,-2) AA3(-16,-2) AA4(-15,-2) AA5(-14,-2) AA6(-13,-2) AA7(-12,-2) AA8(-11,-2) AA9(-10,-2) AA10(-9,-2) AA11(-8,-2) AA12(-7,-2) AA13(-6,-2) AA14(-5,-2) AA15(-4,-2) AA16(-3,-2) AA17(-2,-2) AA18(-1,-2) AA19(0,-2) AA20(1,-2) AA21(2,-2) AA22(3,-2) AA23(4,-2) AA24(5,-2) AA25(6,-2) AA26(7,-2) AA27(8,-2) AA28(9,-2) AA29(10,-2) AA30(11,-2) AA31(12,-2) AA32(13,-2) AA33(14,-2) AA34(15,-2) AA35(16,-2) AA36(17,-2) AA37(18,-2) AB2(-17,-3) AB3(-16,-3) AB4(-15,-3) AB5(-14,-3) AB6(-13,-3) AB7(-12,-3) AB8(-11,-3) AB9(-10,-3) AB10(-9,-3) AB11(-8,-3) AB12(-7,-3) AB13(-6,-3) AB14(-5,-3) AB15(-4,-3) AB16(-3,-3) AB17(-2,-3) AB18(-1,-3) AB19(0,-3) AB20(1,-3) AB21(2,-3) AB22(3,-3) AB23(4,-3) AB24(5,-3) AB25(6,-3) AB26(7,-3) AB27(8,-3) AB28(9,-3) AB29(10,-3) AB30(11,-3) AB31(12,-3) AB32(13,-3) AB33(14,-3) AB34(15,-3) AB35(16,-3) AB36(17,-3) AC1(-18,-4) AC2(-17,-4) AC3(-16,-4) AC4(-15,-4) AC5(-14,-4) AC6(-13,-4) AC7(-12,-4) AC8(-11,-4) AC9(-10,-4) AC10(-9,-4) AC11(-8,-4) AC12(-7,-4) AC13(-6,-4) AC14(-5,-4) AC15(-4,-4) AC16(-3,-4) AC17(-2,-4) AC18(-1,-4) AC19(0,-4) AC20(1,-4) AC21(2,-4) AC22(3,-4) AC23(4,-4) AC24(5,-4) AC25(6,-4) AC26(7,-4) AC27(8,-4) AC28(9,-4) AC29(10,-4) AC30(11,-4) AC31(12,-4) AC32(13,-4) AC33(14,-4) AC34(15,-4) AC35(16,-4) AC36(17,-4) AC37(18,-4) AD2(-17,-5) AD3(-16,-5) AD4(-15,-5) AD5(-14,-5) AD6(-13,-5) AD7(-12,-5) AD8(-11,-5) AD9(-10,-5) AD10(-9,-5) AD11(-8,-5) AD12(-7,-5) AD13(-6,-5) AD14(-5,-5) AD15(-4,-5) AD16(-3,-5) AD17(-2,-5) AD18(-1,-5) AD19(0,-5) AD20(1,-5) AD21(2,-5) AD22(3,-5) AD23(4,-5) AD24(5,-5) AD25(6,-5) AD26(7,-5) AD27(8,-5) AD28(9,-5) AD29(10,-5) AD30(11,-5) AD31(12,-5) AD32(13,-5) AD33(14,-5) AD34(15,-5) AD35(16,-5) AD36(17,-5) AE1(-18,-6) AE2(-17,-6) AE3(-16,-6) AE4(-15,-6) AE5(-14,-6) AE6(-13,-6) AE7(-12,-6) AE8(-11,-6) AE9(-10,-6) AE10(-9,-6) AE11(-8,-6) AE12(-7,-6) AE13(-6,-6) AE14(-5,-6) AE15(-4,-6) AE16(-3,-6) AE17(-2,-6) AE18(-1,-6) AE19(0,-6) AE20(1,-6) AE21(2,-6) AE22(3,-6) AE23(4,-6) AE24(5,-6) AE25(6,-6) AE26(7,-6) AE27(8,-6) AE28(9,-6) AE29(10,-6) AE30(11,-6) AE31(12,-6) AE32(13,-6) AE33(14,-6) AE34(15,-6) AE35(16,-6) AE36(17,-6) AE37(18,-6) AF2(-17,-7) AF3(-16,-7) AF4(-15,-7) AF5(-14,-7) AF6(-13,-7) AF7(-12,-7) AF8(-11,-7) AF9(-10,-7) AF10(-9,-7) AF11(-8,-7) AF12(-7,-7) AF13(-6,-7) AF14(-5,-7) AF15(-4,-7) AF16(-3,-7) AF17(-2,-7) AF18(-1,-7) AF19(0,-7) AF20(1,-7) AF21(2,-7) AF22(3,-7) AF23(4,-7) AF24(5,-7) AF25(6,-7) AF26(7,-7) AF27(8,-7) AF28(9,-7) AF29(10,-7) AF30(11,-7) AF31(12,-7) AF32(13,-7) AF33(14,-7) AF34(15,-7) AF35(16,-7) AF36(17,-7) AG1(-18,-8) AG2(-17,-8) AG3(-16,-8) AG4(-15,-8) AG5(-14,-8) AG6(-13,-8) AG7(-12,-8) AG8(-11,-8) AG9(-10,-8) AG10(-9,-8) AG11(-8,-8) AG12(-7,-8) AG13(-6,-8) AG14(-5,-8) AG15(-4,-8) AG16(-3,-8) AG17(-2,-8) AG18(-1,-8) AG19(0,-8) AG20(1,-8) AG21(2,-8) AG22(3,-8) AG23(4,-8) AG24(5,-8) AG25(6,-8) AG26(7,-8) AG27(8,-8) AG28(9,-8) AG29(10,-8) AG30(11,-8) AG31(12,-8) AG32(13,-8) AG33(14,-8) AG34(15,-8) AG35(16,-8) AG36(17,-8) AG37(18,-8) AH1(-18,-9) AH2(-17,-9) AH3(-16,-9) AH4(-15,-9) AH5(-14,-9) AH6(-13,-9) AH7(-12,-9) AH8(-11,-9) AH9(-10,-9) AH10(-9,-9) AH11(-8,-9) AH12(-7,-9) AH13(-6,-9) AH14(-5,-9) AH15(-4,-9) AH16(-3,-9) AH17(-2,-9) AH18(-1,-9) AH19(0,-9) AH20(1,-9) AH21(2,-9) AH22(3,-9) AH23(4,-9) AH24(5,-9) AH25(6,-9) AH26(7,-9) AH27(8,-9) AH28(9,-9) AH29(10,-9) AH30(11,-9) AH31(12,-9) AH32(13,-9) AH33(14,-9) AH34(15,-9) AH35(16,-9) AH36(17,-9) AJ2(-17,-10) AJ3(-16,-10) AJ4(-15,-10) AJ5(-14,-10) AJ6(-13,-10) AJ7(-12,-10) AJ8(-11,-10) AJ9(-10,-10) AJ10(-9,-10) AJ11(-8,-10) AJ12(-7,-10) AJ13(-6,-10) AJ14(-5,-10) AJ15(-4,-10) AJ16(-3,-10) AJ17(-2,-10) AJ18(-1,-10) AJ19(0,-10) AJ20(1,-10) AJ21(2,-10) AJ22(3,-10) AJ23(4,-10) AJ24(5,-10) AJ25(6,-10) AJ26(7,-10) AJ27(8,-10) AJ28(9,-10) AJ29(10,-10) AJ30(11,-10) AJ31(12,-10) AJ32(13,-10) AJ33(14,-10) AJ34(15,-10) AJ35(16,-10) AJ36(17,-10) AJ37(18,-10) AK1(-18,-11) AK2(-17,-11) AK3(-16,-11) AK4(-15,-11) AK5(-14,-11) AK6(-13,-11) AK7(-12,-11) AK8(-11,-11) AK9(-10,-11) AK10(-9,-11) AK11(-8,-11) AK12(-7,-11) AK13(-6,-11) AK14(-5,-11) AK15(-4,-11) AK16(-3,-11) AK17(-2,-11) AK18(-1,-11) AK19(0,-11) AK20(1,-11) AK21(2,-11) AK22(3,-11) AK23(4,-11) AK24(5,-11) AK25(6,-11) AK26(7,-11) AK27(8,-11) AK28(9,-11) AK29(10,-11) AK30(11,-11) AK31(12,-11) AK32(13,-11) AK33(14,-11) AK34(15,-11) AK35(16,-11) AK36(17,-11) AK37(18,-11) AL2(-17,-12) AL3(-16,-12) AL4(-15,-12) AL5(-14,-12) AL6(-13,-12) AL7(-12,-12) AL8(-11,-12) AL9(-10,-12) AL10(-9,-12) AL11(-8,-12) AL12(-7,-12) AL13(-6,-12) AL14(-5,-12) AL15(-4,-12) AL16(-3,-12) AL17(-2,-12) AL18(-1,-12) AL19(0,-12) AL20(1,-12) AL21(2,-12) AL22(3,-12) AL23(4,-12) AL24(5,-12) AL25(6,-12) AL26(7,-12) AL27(8,-12) AL28(9,-12) AL29(10,-12) AL30(11,-12) AL31(12,-12) AL32(13,-12) AL33(14,-12) AL34(15,-12) AL35(16,-12) AL36(17,-12) AM1(-18,-13) AM2(-17,-13) AM3(-16,-13) AM4(-15,-13) AM5(-14,-13) AM6(-13,-13) AM7(-12,-13) AM8(-11,-13) AM9(-10,-13) AM10(-9,-13) AM11(-8,-13) AM12(-7,-13) AM13(-6,-13) AM14(-5,-13) AM15(-4,-13) AM16(-3,-13) AM17(-2,-13) AM18(-1,-13) AM19(0,-13) AM20(1,-13) AM21(2,-13) AM22(3,-13) AM23(4,-13) AM24(5,-13) AM25(6,-13) AM26(7,-13) AM27(8,-13) AM28(9,-13) AM29(10,-13) AM30(11,-13) AM31(12,-13) AM32(13,-13) AM33(14,-13) AM34(15,-13) AM35(16,-13) AM36(17,-13) AM37(18,-13) AN2(-17,-14) AN3(-16,-14) AN4(-15,-14) AN5(-14,-14) AN6(-13,-14) AN7(-12,-14) AN8(-11,-14) AN9(-10,-14) AN10(-9,-14) AN11(-8,-14) AN12(-7,-14) AN13(-6,-14) AN14(-5,-14) AN15(-4,-14) AN16(-3,-14) AN17(-2,-14) AN18(-1,-14) AN19(0,-14) AN20(1,-14) AN21(2,-14) AN22(3,-14) AN23(4,-14) AN24(5,-14) AN25(6,-14) AN26(7,-14) AN27(8,-14) AN28(9,-14) AN29(10,-14) AN30(11,-14) AN31(12,-14) AN32(13,-14) AN33(14,-14) AN34(15,-14) AN35(16,-14) AN36(17,-14) AP1(-18,-15) AP2(-17,-15) AP3(-16,-15) AP4(-15,-15) AP5(-14,-15) AP6(-13,-15) AP7(-12,-15) AP8(-11,-15) AP9(-10,-15) AP10(-9,-15) AP11(-8,-15) AP12(-7,-15) AP13(-6,-15) AP14(-5,-15) AP15(-4,-15) AP16(-3,-15) AP17(-2,-15) AP18(-1,-15) AP19(0,-15) AP20(1,-15) AP21(2,-15) AP22(3,-15) AP23(4,-15) AP24(5,-15) AP25(6,-15) AP26(7,-15) AP27(8,-15) AP28(9,-15) AP29(10,-15) AP30(11,-15) AP31(12,-15) AP32(13,-15) AP33(14,-15) AP34(15,-15) AP35(16,-15) AP36(17,-15) AP37(18,-15) AR2(-17,-16) AR3(-16,-16) AR4(-15,-16) AR5(-14,-16) AR6(-13,-16) AR7(-12,-16) AR8(-11,-16) AR9(-10,-16) AR10(-9,-16) AR11(-8,-16) AR12(-7,-16) AR13(-6,-16) AR14(-5,-16) AR15(-4,-16) AR16(-3,-16) AR17(-2,-16) AR18(-1,-16) AR19(0,-16) AR20(1,-16) AR21(2,-16) AR22(3,-16) AR23(4,-16) AR24(5,-16) AR25(6,-16) AR26(7,-16) AR27(8,-16) AR28(9,-16) AR29(10,-16) AR30(11,-16) AR31(12,-16) AR32(13,-16) AR33(14,-16) AR34(15,-16) AR35(16,-16) AR36(17,-16) AT1(-18,-17) AT2(-17,-17) AT3(-16,-17) AT4(-15,-17) AT5(-14,-17) AT6(-13,-17) AT7(-12,-17) AT8(-11,-17) AT9(-10,-17) AT10(-9,-17) AT11(-8,-17) AT12(-7,-17) AT13(-6,-17) AT14(-5,-17) AT15(-4,-17) AT16(-3,-17) AT17(-2,-17) AT18(-1,-17) AT19(0,-17) AT20(1,-17) AT21(2,-17) AT22(3,-17) AT23(4,-17) AT24(5,-17) AT25(6,-17) AT26(7,-17) AT27(8,-17) AT28(9,-17) AT29(10,-17) AT30(11,-17) AT31(12,-17) AT32(13,-17) AT33(14,-17) AT34(15,-17) AT35(16,-17) AT36(17,-17) AT37(18,-17) AU2(-17,-18) AU3(-16,-18) AU4(-15,-18) AU5(-14,-18) AU6(-13,-18) AU7(-12,-18) AU9(-10,-18) AU11(-8,-18) AU13(-6,-18) AU15(-4,-18) AU16(-3,-18) AU18(-1,-18) AU20(1,-18) AU22(3,-18) AU24(5,-18) AU25(6,-18) AU27(8,-18) AU29(10,-18) AU31(12,-18) AU33(14,-18) AU34(15,-18) AU35(16,-18) AU36(17,-18) B1(-18,17) B2(-17,17) B3(-16,17) B4(-15,17) B5(-14,17) B6(-13,17) B7(-12,17) B8(-11,17) B9(-10,17) B10(-9,17) B11(-8,17) B12(-7,17) B13(-6,17) B14(-5,17) B15(-4,17) B16(-3,17) B17(-2,17) B18(-1,17) B19(0,17) B20(1,17) B21(2,17) B22(3,17) B23(4,17) B24(5,17) B25(6,17) B26(7,17) B27(8,17) B28(9,17) B29(10,17) B30(11,17) B31(12,17) B32(13,17) B33(14,17) B34(15,17) B35(16,17) B36(17,17) B37(18,17) C2(-17,16) C3(-16,16) C4(-15,16) C5(-14,16) C6(-13,16) C7(-12,16) C8(-11,16) C9(-10,16) C10(-9,16) C11(-8,16) C12(-7,16) C13(-6,16) C14(-5,16) C15(-4,16) C16(-3,16) C17(-2,16) C18(-1,16) C19(0,16) C20(1,16) C21(2,16) C22(3,16) C23(4,16) C24(5,16) C25(6,16) C26(7,16) C27(8,16) C28(9,16) C29(10,16) C30(11,16) C31(12,16) C32(13,16) C33(14,16) C34(15,16) C35(16,16) C36(17,16) D1(-18,15) D2(-17,15) D3(-16,15) D4(-15,15) D5(-14,15) D6(-13,15) D7(-12,15) D8(-11,15) D9(-10,15) D10(-9,15) D11(-8,15) D12(-7,15) D13(-6,15) D14(-5,15) D15(-4,15) D16(-3,15) D17(-2,15) D18(-1,15) D19(0,15) D20(1,15) D21(2,15) D22(3,15) D23(4,15) D24(5,15) D25(6,15) D26(7,15) D27(8,15) D28(9,15) D29(10,15) D30(11,15) D31(12,15) D32(13,15) D33(14,15) D34(15,15) D35(16,15) D36(17,15) D37(18,15) E2(-17,14) E3(-16,14) E4(-15,14) E5(-14,14) E6(-13,14) E7(-12,14) E8(-11,14) E9(-10,14) E10(-9,14) E11(-8,14) E12(-7,14) E13(-6,14) E14(-5,14) E15(-4,14) E16(-3,14) E17(-2,14) E18(-1,14) E19(0,14) E20(1,14) E21(2,14) E22(3,14) E23(4,14) E24(5,14) E25(6,14) E26(7,14) E27(8,14) E28(9,14) E29(10,14) E30(11,14) E31(12,14) E32(13,14) E33(14,14) E34(15,14) E35(16,14) E36(17,14) F1(-18,13) F2(-17,13) F3(-16,13) F4(-15,13) F5(-14,13) F6(-13,13) F7(-12,13) F8(-11,13) F9(-10,13) F10(-9,13) F11(-8,13) F12(-7,13) F13(-6,13) F14(-5,13) F15(-4,13) F16(-3,13) F17(-2,13) F18(-1,13) F19(0,13) F20(1,13) F21(2,13) F22(3,13) F23(4,13) F24(5,13) F25(6,13) F26(7,13) F27(8,13) F28(9,13) F29(10,13) F30(11,13) F31(12,13) F32(13,13) F33(14,13) F34(15,13) F35(16,13) F36(17,13) F37(18,13) G2(-17,12) G3(-16,12) G4(-15,12) G5(-14,12) G6(-13,12) G7(-12,12) G8(-11,12) G9(-10,12) G10(-9,12) G11(-8,12) G12(-7,12) G13(-6,12) G14(-5,12) G15(-4,12) G16(-3,12) G17(-2,12) G18(-1,12) G19(0,12) G20(1,12) G21(2,12) G22(3,12) G23(4,12) G24(5,12) G25(6,12) G26(7,12) G27(8,12) G28(9,12) G29(10,12) G30(11,12) G31(12,12) G32(13,12) G33(14,12) G34(15,12) G35(16,12) G36(17,12) H1(-18,11) H2(-17,11) H3(-16,11) H4(-15,11) H5(-14,11) H6(-13,11) H7(-12,11) H8(-11,11) H9(-10,11) H10(-9,11) H11(-8,11) H12(-7,11) H13(-6,11) H14(-5,11) H15(-4,11) H16(-3,11) H17(-2,11) H18(-1,11) H19(0,11) H20(1,11) H21(2,11) H22(3,11) H23(4,11) H24(5,11) H25(6,11) H26(7,11) H27(8,11) H28(9,11) H29(10,11) H30(11,11) H31(12,11) H32(13,11) H33(14,11) H34(15,11) H35(16,11) H36(17,11) H37(18,11) J2(-17,10) J3(-16,10) J4(-15,10) J5(-14,10) J6(-13,10) J7(-12,10) J8(-11,10) J9(-10,10) J10(-9,10) J11(-8,10) J12(-7,10) J13(-6,10) J14(-5,10) J15(-4,10) J16(-3,10) J17(-2,10) J18(-1,10) J19(0,10) J20(1,10) J21(2,10) J22(3,10) J23(4,10) J24(5,10) J25(6,10) J26(7,10) J27(8,10) J28(9,10) J29(10,10) J30(11,10) J31(12,10) J32(13,10) J33(14,10) J34(15,10) J35(16,10) J36(17,10) J37(18,10) K1(-18,9) K2(-17,9) K3(-16,9) K4(-15,9) K5(-14,9) K6(-13,9) K7(-12,9) K8(-11,9) K9(-10,9) K10(-9,9) K11(-8,9) K12(-7,9) K13(-6,9) K14(-5,9) K15(-4,9) K16(-3,9) K17(-2,9) K18(-1,9) K19(0,9) K20(1,9) K21(2,9) K22(3,9) K23(4,9) K24(5,9) K25(6,9) K26(7,9) K27(8,9) K28(9,9) K29(10,9) K30(11,9) K31(12,9) K32(13,9) K33(14,9) K34(15,9) K35(16,9) K36(17,9) L1(-18,8) L2(-17,8) L3(-16,8) L4(-15,8) L5(-14,8) L6(-13,8) L7(-12,8) L8(-11,8) L9(-10,8) L10(-9,8) L11(-8,8) L12(-7,8) L13(-6,8) L14(-5,8) L15(-4,8) L16(-3,8) L17(-2,8) L18(-1,8) L19(0,8) L20(1,8) L21(2,8) L22(3,8) L23(4,8) L24(5,8) L25(6,8) L26(7,8) L27(8,8) L28(9,8) L29(10,8) L30(11,8) L31(12,8) L32(13,8) L33(14,8) L34(15,8) L35(16,8) L36(17,8) L37(18,8) M2(-17,7) M3(-16,7) M4(-15,7) M5(-14,7) M6(-13,7) M7(-12,7) M8(-11,7) M9(-10,7) M10(-9,7) M11(-8,7) M12(-7,7) M13(-6,7) M14(-5,7) M15(-4,7) M16(-3,7) M17(-2,7) M18(-1,7) M19(0,7) M20(1,7) M21(2,7) M22(3,7) M23(4,7) M24(5,7) M25(6,7) M26(7,7) M27(8,7) M28(9,7) M29(10,7) M30(11,7) M31(12,7) M32(13,7) M33(14,7) M34(15,7) M35(16,7) M36(17,7) N1(-18,6) N2(-17,6) N3(-16,6) N4(-15,6) N5(-14,6) N6(-13,6) N7(-12,6) N8(-11,6) N9(-10,6) N10(-9,6) N11(-8,6) N12(-7,6) N13(-6,6) N14(-5,6) N15(-4,6) N16(-3,6) N17(-2,6) N18(-1,6) N19(0,6) N20(1,6) N21(2,6) N22(3,6) N23(4,6) N24(5,6) N25(6,6) N26(7,6) N27(8,6) N28(9,6) N29(10,6) N30(11,6) N31(12,6) N32(13,6) N33(14,6) N34(15,6) N35(16,6) N36(17,6) N37(18,6) P2(-17,5) P3(-16,5) P4(-15,5) P5(-14,5) P6(-13,5) P7(-12,5) P8(-11,5) P9(-10,5) P10(-9,5) P11(-8,5) P12(-7,5) P13(-6,5) P14(-5,5) P15(-4,5) P16(-3,5) P17(-2,5) P18(-1,5) P19(0,5) P20(1,5) P21(2,5) P22(3,5) P23(4,5) P24(5,5) P25(6,5) P26(7,5) P27(8,5) P28(9,5) P29(10,5) P30(11,5) P31(12,5) P32(13,5) P33(14,5) P34(15,5) P35(16,5) P36(17,5) R1(-18,4) R2(-17,4) R3(-16,4) R4(-15,4) R5(-14,4) R6(-13,4) R7(-12,4) R8(-11,4) R9(-10,4) R10(-9,4) R11(-8,4) R12(-7,4) R13(-6,4) R14(-5,4) R15(-4,4) R16(-3,4) R17(-2,4) R18(-1,4) R19(0,4) R20(1,4) R21(2,4) R22(3,4) R23(4,4) R24(5,4) R25(6,4) R26(7,4) R27(8,4) R28(9,4) R29(10,4) R30(11,4) R31(12,4) R32(13,4) R33(14,4) R34(15,4) R35(16,4) R36(17,4) R37(18,4) T2(-17,3) T3(-16,3) T4(-15,3) T5(-14,3) T6(-13,3) T7(-12,3) T8(-11,3) T9(-10,3) T10(-9,3) T11(-8,3) T12(-7,3) T13(-6,3) T14(-5,3) T15(-4,3) T16(-3,3) T17(-2,3) T18(-1,3) T19(0,3) T20(1,3) T21(2,3) T22(3,3) T23(4,3) T24(5,3) T25(6,3) T26(7,3) T27(8,3) T28(9,3) T29(10,3) T30(11,3) T31(12,3) T32(13,3) T33(14,3) T34(15,3) T35(16,3) T36(17,3) U1(-18,2) U2(-17,2) U3(-16,2) U4(-15,2) U5(-14,2) U6(-13,2) U7(-12,2) U8(-11,2) U9(-10,2) U10(-9,2) U11(-8,2) U12(-7,2) U13(-6,2) U14(-5,2) U15(-4,2) U16(-3,2) U17(-2,2) U18(-1,2) U19(0,2) U20(1,2) U21(2,2) U22(3,2) U23(4,2) U24(5,2) U25(6,2) U26(7,2) U27(8,2) U28(9,2) U29(10,2) U30(11,2) U31(12,2) U32(13,2) U33(14,2) U34(15,2) U35(16,2) U36(17,2) U37(18,2) V2(-17,1) V3(-16,1) V4(-15,1) V5(-14,1) V6(-13,1) V7(-12,1) V8(-11,1) V9(-10,1) V10(-9,1) V11(-8,1) V12(-7,1) V13(-6,1) V14(-5,1) V15(-4,1) V16(-3,1) V17(-2,1) V18(-1,1) V19(0,1) V20(1,1) V21(2,1) V22(3,1) V23(4,1) V24(5,1) V25(6,1) V26(7,1) V27(8,1) V28(9,1) V29(10,1) V30(11,1) V31(12,1) V32(13,1) V33(14,1) V34(15,1) V35(16,1) V36(17,1) V37(18,1) W1(-18,0) W2(-17,0) W3(-16,0) W4(-15,0) W5(-14,0) W6(-13,0) W7(-12,0) W8(-11,0) W9(-10,0) W10(-9,0) W11(-8,0) W12(-7,0) W13(-6,0) W14(-5,0) W15(-4,0) W16(-3,0) W17(-2,0) W18(-1,0) W19(0,0) W20(1,0) W21(2,0) W22(3,0) W23(4,0) W24(5,0) W25(6,0) W26(7,0) W27(8,0) W28(9,0) W29(10,0) W30(11,0) W31(12,0) W32(13,0) W33(14,0) W34(15,0) W35(16,0) W36(17,0) W37(18,0) Y2(-17,-1) Y3(-16,-1) Y4(-15,-1) Y5(-14,-1) Y6(-13,-1) Y7(-12,-1) Y8(-11,-1) Y9(-10,-1) Y10(-9,-1) Y11(-8,-1) Y12(-7,-1) Y13(-6,-1) Y14(-5,-1) Y15(-4,-1) Y16(-3,-1) Y17(-2,-1) Y18(-1,-1) Y19(0,-1) Y20(1,-1) Y21(2,-1) Y22(3,-1) Y23(4,-1) Y24(5,-1) Y25(6,-1) Y26(7,-1) Y27(8,-1) Y28(9,-1) Y29(10,-1) Y30(11,-1) Y31(12,-1) Y32(13,-1) Y33(14,-1) Y34(15,-1) Y35(16,-1) Y36(17,-1) Y37(18,-1)
C0201
  rect 0.305x0.381 smd: 1(-0.267,0) 2(0.267,0)
C0402
  rect 0.457x0.508 smd: 1(-0.4,0) 2(0.4,0)
C0603
  rect 0.813x0.711 smd: 1(-0.737,0) 2(0.737,0)
C0805_H57
  rect 1.118x1.372 smd: 1(-0.95,0) 2(0.95,0)
C0805_H61
  rect 1.118x1.372 smd: 1(-0.95,0) 2(0.95,0)
CON_4S1H2S_P1XA_F09
  rect 1.549x0.61 smd: 1(-1.775,1.5) 2(-1.775,0.5) 3(-1.775,-0.5) 4(-1.775,-1.5)
  rect 1.803x1.219 smd: G1(0.75,2.8) G2(0.75,-2.8)
CON_8S1H2S_P0-5XC
  rect 0.864x0.279 smd: 1(2.575,1.75) 2(2.575,1.25) 3(2.575,0.75) 4(2.575,0.25) 5(2.575,-0.25) 6(2.575,-0.75) 7(2.575,-1.25) 8(2.575,-1.75)
  rect 2.007x0.838 smd: G1(-0.6,3.45) G2(-0.6,-3.45)
CON_8S1H2S_P1XD_CAP_F09
  rect 1.549x0.61 smd: 1(-1.775,3.5) 2(-1.775,2.5) 3(-1.775,1.5) 4(-1.775,0.5) 5(-1.775,-0.5) 6(-1.775,-1.5) 7(-1.775,-2.5) 8(-1.775,-3.5)
  rect 1.803x1.219 smd: G1(0.75,-4.8) G2(0.75,4.8)
CON_120S2H2D_P0-8W4-4_LUV_H237
  round 1.245 hole 1.245 unplated: (0,-26.1)
  round 0.838 hole 0.838 unplated: (0,26.1)
  rect 2.057x0.533 smd: 1(2.2,23.6) 2(-2.2,23.6) 3(2.2,22.8) 4(-2.2,22.8) 5(2.2,22) 6(-2.2,22) 7(2.2,21.2) 8(-2.2,21.2) 9(2.2,20.4) 10(-2.2,20.4) 11(2.2,19.6) 12(-2.2,19.6) 13(2.2,18.8) 14(-2.2,18.8) 15(2.2,18) 16(-2.2,18) 17(2.2,17.2) 18(-2.2,17.2) 19(2.2,16.4) 20(-2.2,16.4) 21(2.2,15.6) 22(-2.2,15.6) 23(2.2,14.8) 24(-2.2,14.8) 25(2.2,14) 26(-2.2,14) 27(2.2,13.2) 28(-2.2,13.2) 29(2.2,12.4) 30(-2.2,12.4) 31(2.2,11.6) 32(-2.2,11.6) 33(2.2,10.8) 34(-2.2,10.8) 35(2.2,10) 36(-2.2,10) 37(2.2,9.2) 38(-2.2,9.2) 39(2.2,8.4) 40(-2.2,8.4) 41(2.2,7.6) 42(-2.2,7.6) 43(2.2,6.8) 44(-2.2,6.8) 45(2.2,6) 46(-2.2,6) 47(2.2,5.2) 48(-2.2,5.2) 49(2.2,4.4) 50(-2.2,4.4) 51(2.2,3.6) 52(-2.2,3.6) 53(2.2,2.8) 54(-2.2,2.8) 55(2.2,2) 56(-2.2,2) 57(2.2,1.2) 58(-2.2,1.2) 59(2.2,0.4) 60(-2.2,0.4) 61(2.2,-0.4) 62(-2.2,-0.4) 63(2.2,-1.2) 64(-2.2,-1.2) 65(2.2,-2) 66(-2.2,-2) 67(2.2,-2.8) 68(-2.2,-2.8) 69(2.2,-3.6) 70(-2.2,-3.6) 71(2.2,-4.4) 72(-2.2,-4.4) 73(2.2,-5.2) 74(-2.2,-5.2) 75(2.2,-6) 76(-2.2,-6) 77(2.2,-6.8) 78(-2.2,-6.8) 79(2.2,-7.6) 80(-2.2,-7.6) 81(2.2,-8.4) 82(-2.2,-8.4) 83(2.2,-9.2) 84(-2.2,-9.2) 85(2.2,-10) 86(-2.2,-10) 87(2.2,-10.8) 88(-2.2,-10.8) 89(2.2,-11.6) 90(-2.2,-11.6) 91(2.2,-12.4) 92(-2.2,-12.4) 93(2.2,-13.2) 94(-2.2,-13.2) 95(2.2,-14) 96(-2.2,-14) 97(2.2,-14.8) 98(-2.2,-14.8) 99(2.2,-15.6) 100(-2.2,-15.6) 101(2.2,-16.4) 102(-2.2,-16.4) 103(2.2,-17.2) 104(-2.2,-17.2) 105(2.2,-18) 106(-2.2,-18) 107(2.2,-18.8) 108(-2.2,-18.8) 109(2.2,-19.6) 110(-2.2,-19.6) 111(2.2,-20.4) 112(-2.2,-20.4) 113(2.2,-21.2) 114(-2.2,-21.2) 115(2.2,-22) 116(-2.2,-22) 117(2.2,-22.8) 118(-2.2,-22.8) 119(2.2,-23.6) 120(-2.2,-23.6)
CON_F134S2H4D4S_P0-5W7-55_LUVXA
  round 1.168 hole 1.168 unplated: (-1.48,22) (-1.48,-2)
  round 1.651 hole 1.651 unplated: (-1.48,2) (-1.48,-22)
  rect 1.6x0.279 smd: A1(3.795,-2.75) A2(-3.755,-3) A3(3.795,-3.25) A4(-3.755,-3.5) A5(3.795,-3.75) A6(-3.755,-4) A7(3.795,-4.25) A8(-3.755,-4.5) A9(3.795,-4.75) A10(-3.755,-5) A11(3.795,-5.25) A12(-3.755,-5.5) A13(3.795,-5.75) A14(-3.755,-6) A15(3.795,-6.25) A16(-3.755,-6.5) A17(3.795,-6.75) A18(-3.755,-7) A19(3.795,-7.25) A20(-3.755,-7.5) A21(3.795,-7.75) A22(-3.755,-8) A23(3.795,-8.25) A24(-3.755,-8.5) A25(3.795,-8.75) A26(-3.755,-9) A27(3.795,-9.25) A28(-3.755,-9.5) A29(3.795,-9.75) A30(-3.755,-10) A31(3.795,-10.25) A32(-3.755,-10.5) A33(3.795,-10.75) A34(-3.755,-11) A35(3.795,-11.25) A36(-3.755,-11.5) A37(3.795,-11.75) A38(-3.755,-12) A39(3.795,-12.25) A40(-3.755,-12.5) A41(3.795,-12.75) A42(-3.755,-13) A43(3.795,-13.25) A44(-3.755,-13.5) A45(3.795,-13.75) A46(-3.755,-14) A47(3.795,-14.25) A48(-3.755,-14.5) A49(3.795,-14.75) A50(-3.755,-15) A51(3.795,-15.25) A52(-3.755,-15.5) A53(3.795,-15.75) A54(-3.755,-16) A55(3.795,-16.25) A56(-3.755,-16.5) A57(3.795,-16.75) A58(-3.755,-17) A67(3.795,-19.25) A68(-3.755,-19.5) A69(3.795,-19.75) A70(-3.755,-20) A71(3.795,-20.25) A72(-3.755,-20.5) A73(3.795,-20.75) A74(-3.755,-21) A75(3.795,-21.25) B1(3.795,21.25) B2(-3.755,21) B3(3.795,20.75) B4(-3.755,20.5) B5(3.795,20.25) B6(-3.755,20) B7(3.795,19.75) B8(-3.755,19.5) B9(3.795,19.25) B10(-3.755,19) B11(3.795,18.75) B12(-3.755,18.5) B13(3.795,18.25) B14(-3.755,18) B15(3.795,17.75) B16(-3.755,17.5) B17(3.795,17.25) B18(-3.755,17) B19(3.795,16.75) B20(-3.755,16.5) B21(3.795,16.25) B22(-3.755,16) B23(3.795,15.75) B24(-3.755,15.5) B25(3.795,15.25) B26(-3.755,15) B27(3.795,14.75) B28(-3.755,14.5) B29(3.795,14.25) B30(-3.755,14) B31(3.795,13.75) B32(-3.755,13.5) B33(3.795,13.25) B34(-3.755,13) B35(3.795,12.75) B36(-3.755,12.5) B37(3.795,12.25) B38(-3.755,12) B39(3.795,11.75) B40(-3.755,11.5) B41(3.795,11.25) B42(-3.755,11) B43(3.795,10.75) B44(-3.755,10.5) B45(3.795,10.25) B46(-3.755,10) B47(3.795,9.75) B48(-3.755,9.5) B49(3.795,9.25) B50(-3.755,9) B51(3.795,8.75) B52(-3.755,8.5) B53(3.795,8.25) B54(-3.755,8) B55(3.795,7.75) B56(-3.755,7.5) B57(3.795,7.25) B58(-3.755,7) B67(3.795,4.75) B68(-3.755,4.5) B69(3.795,4.25) B70(-3.755,4) B71(3.795,3.75) B72(-3.755,3.5) B73(3.795,3.25) B74(-3.755,3) B75(3.795,2.75)
  rect 2.794x1.245 smd: G1(3.02,22.35) G2(3.02,1.65) G3(3.02,-1.65) G4(3.02,-22.35)
CON_M160S2H2D_P0-8W4-4_LUV
  round 1.245 hole 1.245 unplated: (0,-34.1)
  round 0.838 hole 0.838 unplated: (0,34.1)
  rect 2.057x0.533 smd: 1(2.2,31.6) 2(-2.2,31.6) 3(2.2,30.8) 4(-2.2,30.8) 5(2.2,30) 6(-2.2,30) 7(2.2,29.2) 8(-2.2,29.2) 9(2.2,28.4) 10(-2.2,28.4) 11(2.2,27.6) 12(-2.2,27.6) 13(2.2,26.8) 14(-2.2,26.8) 15(2.2,26) 16(-2.2,26) 17(2.2,25.2) 18(-2.2,25.2) 19(2.2,24.4) 20(-2.2,24.4) 21(2.2,23.6) 22(-2.2,23.6) 23(2.2,22.8) 24(-2.2,22.8) 25(2.2,22) 26(-2.2,22) 27(2.2,21.2) 28(-2.2,21.2) 29(2.2,20.4) 30(-2.2,20.4) 31(2.2,19.6) 32(-2.2,19.6) 33(2.2,18.8) 34(-2.2,18.8) 35(2.2,18) 36(-2.2,18) 37(2.2,17.2) 38(-2.2,17.2) 39(2.2,16.4) 40(-2.2,16.4) 41(2.2,15.6) 42(-2.2,15.6) 43(2.2,14.8) 44(-2.2,14.8) 45(2.2,14) 46(-2.2,14) 47(2.2,13.2) 48(-2.2,13.2) 49(2.2,12.4) 50(-2.2,12.4) 51(2.2,11.6) 52(-2.2,11.6) 53(2.2,10.8) 54(-2.2,10.8) 55(2.2,10) 56(-2.2,10) 57(2.2,9.2) 58(-2.2,9.2) 59(2.2,8.4) 60(-2.2,8.4) 61(2.2,7.6) 62(-2.2,7.6) 63(2.2,6.8) 64(-2.2,6.8) 65(2.2,6) 66(-2.2,6) 67(2.2,5.2) 68(-2.2,5.2) 69(2.2,4.4) 70(-2.2,4.4) 71(2.2,3.6) 72(-2.2,3.6) 73(2.2,2.8) 74(-2.2,2.8) 75(2.2,2) 76(-2.2,2) 77(2.2,1.2) 78(-2.2,1.2) 79(2.2,0.4) 80(-2.2,0.4) 81(2.2,-0.4) 82(-2.2,-0.4) 83(2.2,-1.2) 84(-2.2,-1.2) 85(2.2,-2) 86(-2.2,-2) 87(2.2,-2.8) 88(-2.2,-2.8) 89(2.2,-3.6) 90(-2.2,-3.6) 91(2.2,-4.4) 92(-2.2,-4.4) 93(2.2,-5.2) 94(-2.2,-5.2) 95(2.2,-6) 96(-2.2,-6) 97(2.2,-6.8) 98(-2.2,-6.8) 99(2.2,-7.6) 100(-2.2,-7.6) 101(2.2,-8.4) 102(-2.2,-8.4) 103(2.2,-9.2) 104(-2.2,-9.2) 105(2.2,-10) 106(-2.2,-10) 107(2.2,-10.8) 108(-2.2,-10.8) 109(2.2,-11.6) 110(-2.2,-11.6) 111(2.2,-12.4) 112(-2.2,-12.4) 113(2.2,-13.2) 114(-2.2,-13.2) 115(2.2,-14) 116(-2.2,-14) 117(2.2,-14.8) 118(-2.2,-14.8) 119(2.2,-15.6) 120(-2.2,-15.6) 121(2.2,-16.4) 122(-2.2,-16.4) 123(2.2,-17.2) 124(-2.2,-17.2) 125(2.2,-18) 126(-2.2,-18) 127(2.2,-18.8) 128(-2.2,-18.8) 129(2.2,-19.6) 130(-2.2,-19.6) 131(2.2,-20.4) 132(-2.2,-20.4) 133(2.2,-21.2) 134(-2.2,-21.2) 135(2.2,-22) 136(-2.2,-22) 137(2.2,-22.8) 138(-2.2,-22.8) 139(2.2,-23.6) 140(-2.2,-23.6) 141(2.2,-24.4) 142(-2.2,-24.4) 143(2.2,-25.2) 144(-2.2,-25.2) 145(2.2,-26) 146(-2.2,-26) 147(2.2,-26.8) 148(-2.2,-26.8) 149(2.2,-27.6) 150(-2.2,-27.6) 151(2.2,-28.4) 152(-2.2,-28.4) 153(2.2,-29.2) 154(-2.2,-29.2) 155(2.2,-30) 156(-2.2,-30) 157(2.2,-30.8) 158(-2.2,-30.8) 159(2.2,-31.6) 160(-2.2,-31.6)
DFN12_TH_0-5_3X3XA
  rect 0.457x0.279 smd: 1(-1.425,1.25) 2(-1.425,0.75) 3(-1.425,0.25) 4(-1.425,-0.25) 5(-1.425,-0.75) 6(-1.425,-1.25) 7(1.425,-1.25) 8(1.425,-0.75) 9(1.425,-0.25) 10(1.425,0.25) 11(1.425,0.75) 12(1.425,1.25)
  rect 1.981x2.921 smd: 13(0,0)
EC56_197_229S
  oval 3.023x1.6 smd: 1(-2.2,0) 2(2.2,0)
EC83_248_390S
  rect 3.505x1.6 smd: 1(-2.8,0) 2(2.8,0)
GND_C10D4B10
  round 4.013 hole 4.013 unplated: (0,0)
  round 0.762 hole 0.559: 2(0,3.5) 3(-2.5,2.5) 4(-3.5,0) 5(-2.5,-2.5) 6(0,-3.5) 7(2.5,-2.5) 8(3.5,0) 9(2.5,2.5)
HEADER1X2XJ_H339
  rect 1.549x1.549 hole 1.041: 1(0,0)
  round 1.549 hole 1.041: 2(0,-2.54)
HOLE_C7D2-7B3_NPB
  round 7.01 hole 2.718: 1(0,0)
HOLE_D2-15N_PLTB3
  round 2.159 hole 2.159 unplated: (0,0)
HOLE_D3-1N
  round 3.099 hole 3.099 unplated: (0,0)
HOLE_OB6X7-6OBD3-2X4-8BN_NPM
  oval 3.2x4.801 hole 3.2x4.801 unplated: (0,0)
HOLE_OB6X7-6OBD3-2X4-8TN_NPM
  oval 3.2x4.801 hole 3.2x4.801 unplated: (0,0)
HWQFN24_0-5_4X4
  rect 0.914x0.254 smd: 1(-2.05,1.25) 2(-2.05,0.75) 3(-2.05,0.25) 4(-2.05,-0.25) 5(-2.05,-0.75) 6(-2.05,-1.25) 13(2.05,-1.25) 14(2.05,-0.75) 15(2.05,-0.25) 16(2.05,0.25) 17(2.05,0.75) 18(2.05,1.25)
  rect 0.254x0.914 smd: 7(-1.25,-2.05) 8(-0.75,-2.05) 9(-0.25,-2.05) 10(0.25,-2.05) 11(0.75,-2.05) 12(1.25,-2.05) 19(1.25,2.05) 20(0.75,2.05) 21(0.25,2.05) 22(-0.25,2.05) 23(-0.75,2.05) 24(-1.25,2.05)
  rect 2.108x2.108 smd: TH(0,0)
L0402
  rect 0.457x0.508 smd: 1(-0.4,0) 2(0.4,0)
L0603
  rect 0.813x0.711 smd: 1(-0.737,0) 2(0.737,0)
L0805
  rect 1.118x1.372 smd: 1(-0.95,0) 2(0.95,0)
L1007
  rect 0.914x2.007 smd: 1(-1.1,0) 2(1.1,0)
L_CMLE053T_4-85X4-7
  rect 2.007x2.515 smd: 1(-2.5,0) 2(2.5,0)
L_HCBS5265_5-2X5-2
  rect 1.168x2.515 smd: 1(-2.175,0) 2(2.175,0)
L_HCUVD8095D-102KBQL_8X8
  rect 1.753x3.404 smd: 1(-3.125,2.2) 2(3.125,-2.2)
L_HCUVE966490D-121
  rect 3.2x3.099 smd: 1(-3.35,0) 2(3.35,0)
L_MLV-YT12N_2-5X2
  rect 0.813x2.007 smd: 1(-1,0) 2(1,0)
LED_1921
  rect 0.813x0.813 smd: A(-0.75,0) C(0.75,0)
LED_16213XA
  rect 0.61x0.711 smd: A(-0.55,0) C(0.55,0)
LED_LTSTS270KSKT
  rect 0.914x0.914 smd: 1(-0.9,0) 2(0.9,0)
MPKT4_H025P0200
  round 1.003 hole 0.25: 1(0,0) 4(0,-2.54)
  round 1.994 hole 0.25: 2(2.54,0) 3(2.54,-2.54)
MSOP8
  rect 1.422x0.356 smd: 1(-2.232,0.975) 2(-2.232,0.325) 3(-2.232,-0.325) 4(-2.232,-0.975) 5(2.232,-0.975) 6(2.232,-0.325) 7(2.232,0.325) 8(2.232,0.975)
OSC4_FJ2500009
  rect 1.016x1.219 smd: 1(-0.65,0.85) 2(-0.65,-0.85) 3(0.65,-0.85) 4(0.65,0.85)
QFN16_THXI
  rect 0.838x0.254 smd: 1(-1.475,0.75) 2(-1.475,0.25) 3(-1.475,-0.25) 4(-1.475,-0.75) 9(1.475,-0.75) 10(1.475,-0.25) 11(1.475,0.25) 12(1.475,0.75)
  rect 0.254x0.838 smd: 5(-0.75,-1.475) 6(-0.25,-1.475) 7(0.25,-1.475) 8(0.75,-1.475) 13(0.75,1.475) 14(0.25,1.475) 15(-0.25,1.475) 16(-0.75,1.475)
  rect 1.702x1.702 smd: TH(0,0)
QFN32_TH_0-5_5X5XL
  rect 0.914x0.279 smd: 1(-2.55,1.75) 2(-2.55,1.25) 3(-2.55,0.75) 4(-2.55,0.25) 5(-2.55,-0.25) 6(-2.55,-0.75) 7(-2.55,-1.25) 8(-2.55,-1.75) 17(2.55,-1.75) 18(2.55,-1.25) 19(2.55,-0.75) 20(2.55,-0.25) 21(2.55,0.25) 22(2.55,0.75) 23(2.55,1.25) 24(2.55,1.75)
  rect 0.279x0.914 smd: 9(-1.75,-2.55) 10(-1.25,-2.55) 11(-0.75,-2.55) 12(-0.25,-2.55) 13(0.25,-2.55) 14(0.75,-2.55) 15(1.25,-2.55) 16(1.75,-2.55) 25(1.75,2.55) 26(1.25,2.55) 27(0.75,2.55) 28(0.25,2.55) 29(-0.25,2.55) 30(-0.75,2.55) 31(-1.25,2.55) 32(-1.75,2.55)
  rect 3.607x3.607 smd: TH(0,0)
R0201
  rect 0.305x0.381 smd: 1(-0.267,0) 2(0.267,0)
R0402
  rect 0.457x0.508 smd: 1(-0.4,0) 2(0.4,0)
R0603
  rect 0.813x0.711 smd: 1(-0.737,0) 2(0.737,0)
R1206XA
  rect 1.6x2.184 smd: 1(-1.3,0) 2(1.3,0)
R1206XK
  rect 1.702x1.803 smd: 1(-1.65,0) 2(1.65,0)
R2512_4PXF
  rect 2.819x3.505 smd: 1A(-2.4,0) 2A(2.4,0)
  rect 0.254x0.254 smd: 1B(-1.117,0) 2B(1.117,0)
SC70-5XA
  rect 0.508x0.406 smd: 1(-0.95,0.65) 2(-0.95,0) 3(-0.95,-0.65) 4(0.95,-0.65) 5(0.95,0.65)
SC70-5XB
  rect 0.914x0.406 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0.65)
SHORT_R0603
  custom 0.178x0.178 smd: 1(-0.749,0)
  rect 0.813x0.711 smd: 2(0.749,0)
SO8_1-27_4-9X3-9XA
  rect 1.422x0.61 smd: 1(-2.65,1.905) 2(-2.65,0.635) 3(-2.65,-0.635) 4(-2.65,-1.905) 5(2.65,-1.905) 6(2.65,-0.635) 7(2.65,0.635) 8(2.65,1.905)
SOCKET8SXD
  rect 0.508x1.499 smd: 1(1.905,4) 2(0.635,4) 3(-0.635,4) 4(-1.905,4) 5(-1.905,-4) 6(-0.635,-4) 7(0.635,-4) 8(1.905,-4)
SOD323
  rect 0.813x0.864 smd: 1(-1.092,0) 2(1.092,0)
SOIC8XH
  rect 1.27x0.889 smd: 1(-2.6,1.905) 2(-2.6,0.635) 3(-2.6,-0.635) 4(-2.6,-1.905) 5(2.6,-1.905) 6(2.6,-0.635) 7(2.6,0.635) 8(2.6,1.905)
SOP8
  rect 1.194x0.254 smd: 1(-1.463,0.75) 2(-1.463,0.25) 3(-1.463,-0.25) 4(-1.463,-0.75) 5(1.463,-0.75) 6(1.463,-0.25) 7(1.463,0.25) 8(1.463,0.75)
SOT23-5XE
  rect 1.067x0.61 smd: 1(-1.35,0.95) 2(-1.35,0) 3(-1.35,-0.95) 4(1.35,-0.95) 5(1.35,0.95)
SOT23-6
  rect 1.499x0.483 smd: 1(-1.275,0.95) 2(-1.275,0) 3(-1.275,-0.95) 4(1.275,-0.95) 5(1.275,0) 6(1.275,0.95)
SOT23_GDSXC
  rect 0.914x0.813 smd: D(1,0) G(-1,0.95) S(-1,-0.95)
SOT323_GDS_2-15X1-3
  rect 0.914x0.711 smd: D(0.95,0) G(-0.95,0.65) S(-0.95,-0.65)
SOT363XD
  rect 0.508x0.432 smd: 1(-0.95,0.65) 2(-0.95,0) 3(-0.95,-0.65) 4(0.95,-0.65) 5(0.95,0) 6(0.95,0.65)
SOT563-6_0-5_1-6X1-2XB
  rect 0.61x0.254 smd: 1(-0.7,0.5) 2(-0.7,0) 3(-0.7,-0.5) 4(0.7,-0.5) 5(0.7,0) 6(0.7,0.5)
SOT563-6XA
  rect 0.508x0.279 smd: 1(-0.85,0.5) 2(-0.85,0) 3(-0.85,-0.5) 4(0.85,-0.5) 5(0.85,0) 6(0.85,0.5)
SW4P_PS022-N12AAK-1
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(-7.62,0) 3(0,-2.54) 4(-7.62,-2.54)
SW4S_NDTQ010-G1A-AEAT
  round 0.965 hole 0.965 unplated: (0,1.6)
  oval 0.965x1.372 hole 0.965x1.372 unplated: (0,-1.4)
  rect 1.219x1.016 smd: 1(-2.1,2.05) 2(2.1,2.05)
  rect 1.219x1.321 smd: 3(2.1,-0.9) 4(-2.1,-0.9)
SW_RD15P4P
  round 1.422 hole 1.422 unplated: (-2.35,2) (-2.35,-6)
  rect 1.524x1.524 hole 1.016: A(0,0)
  round 1.524 hole 1.016: B(0,-2) C(0,-4)
TAJ_D2E
  rect 2.007x2.997 smd: 1(-3,0) 2(3,0)
TAJ_DXC
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
TDR_3P_C85P67_141_100M_Q
  round 2.159 hole 1.702: 1(0,0) 2(-1.27,3.349) 3(1.27,3.349)
TP26D10
  round 0.508 hole 0.254: 1(0,0)
TP30
  round 0.762 smd: 1(0,0)
TP30_FOR_BOM
  round 0.762 smd: 1(0,0)
TQFN25_5X4
  rect 2.108x0.406 smd: 1(-1.25,1.2) 2(-1.25,0.55) 3(-1.25,-0.55) 4(-1.25,-1.2) 14(1.25,-1.2) 15(1.25,0) 16(1.25,1.2)
  rect 0.305x0.914 smd: 5(-1.7,-2.35) 13(1.7,-2.35) 17(1.7,2.35) 25(-1.7,2.35)
  rect 0.178x0.914 smd: 6(-1.2,-2.35) 7(-0.8,-2.35) 8(-0.4,-2.35) 9(0,-2.35) 10(0.4,-2.35) 11(0.8,-2.35) 12(1.2,-2.35) 18(1.2,2.35) 19(0.8,2.35) 20(0.4,2.35) 21(0,2.35) 22(-0.4,2.35) 23(-0.8,2.35) 24(-1.2,2.35)
TRIANG_LAUNCH_3PXA
  round 0.254 hole 0.991 unplated: (-1.274,3.852) (-1.274,-2.498) (-0.004,-5.038) (1.266,3.852) (1.266,-2.498)
  round 0.66 smd: 1(-0.512,1.301) 2(0.504,1.301)
  rect 0.991x1.499 smd: 3(-0.004,-0.148)
TSSOP8_3
  rect 1.499x0.356 smd: 1(-2.235,0.975) 2(-2.235,0.325) 3(-2.235,-0.325) 4(-2.235,-0.975) 5(2.235,-0.975) 6(2.235,-0.325) 7(2.235,0.325) 8(2.235,0.975)
TSSOP14
  rect 1.499x0.356 smd: 1(-2.921,1.95) 2(-2.921,1.3) 3(-2.921,0.65) 4(-2.921,0) 5(-2.921,-0.65) 6(-2.921,-1.3) 7(-2.921,-1.95) 8(2.921,-1.95) 9(2.921,-1.3) 10(2.921,-0.65) 11(2.921,0) 12(2.921,0.65) 13(2.921,1.3) 14(2.921,1.95)
TSSOP16XD
  rect 1.372x0.61 smd: 1(-2.925,2.375) 8(-2.925,-2.375) 9(2.925,-2.375) 16(2.925,2.375)
  rect 1.372x0.406 smd: 2(-2.925,1.625) 3(-2.925,0.975) 4(-2.925,0.325) 5(-2.925,-0.325) 6(-2.925,-0.975) 7(-2.925,-1.625) 10(2.925,-1.625) 11(2.925,-0.975) 12(2.925,-0.325) 13(2.925,0.325) 14(2.925,0.975) 15(2.925,1.625)
unnamed#2
  round 1.016 smd: (0,0)
USB1XAY
  rect 0.432x1.499 smd: 1(-1.3,0.89) 2(-0.65,0.89) 3(0,0.89) 4(0.65,0.89) 5(1.3,0.89)
  oval 1.803x1.118 hole 1.219x0.508: G1(-2.8,1.14) G2(2.8,1.14)
  oval 2.21x1.118 hole 1.6x0.508: G3(0,-1.01)
USB1XBD
  rect 1.372x0.356 smd: 1(-2.525,1.3) 5(-2.525,-1.3)
  rect 1.372x0.406 smd: 2(-2.525,0.65) 3(-2.525,0) 4(-2.525,-0.65)
  oval 1.27x1.067 hole 0.864x0.66: G1(-2.85,2.225) G2(-2.85,-2.225)
  custom 0.35x0.35 hole 1.499x0.838: G3(0.15,4.09) G5(0.15,-4.09)
  rect 1.905x2.921 smd: G4(0.15,0)
VFQFPN64_TH_0-5_9X9XA
  rect 0.787x0.279 smd: 1(-4.488,3.75) 16(-4.488,-3.75) 33(4.488,-3.75) 48(4.488,3.75)
  rect 0.864x0.279 smd: 2(-4.45,3.25) 3(-4.45,2.75) 4(-4.45,2.25) 5(-4.45,1.75) 6(-4.45,1.25) 7(-4.45,0.75) 8(-4.45,0.25) 9(-4.45,-0.25) 10(-4.45,-0.75) 11(-4.45,-1.25) 12(-4.45,-1.75) 13(-4.45,-2.25) 14(-4.45,-2.75) 15(-4.45,-3.25) 34(4.45,-3.25) 35(4.45,-2.75) 36(4.45,-2.25) 37(4.45,-1.75) 38(4.45,-1.25) 39(4.45,-0.75) 40(4.45,-0.25) 41(4.45,0.25) 42(4.45,0.75) 43(4.45,1.25) 44(4.45,1.75) 45(4.45,2.25) 46(4.45,2.75) 47(4.45,3.25)
  rect 0.279x0.787 smd: 17(-3.75,-4.488) 32(3.75,-4.488) 49(3.75,4.488) 64(-3.75,4.488)
  rect 0.279x0.864 smd: 18(-3.25,-4.45) 19(-2.75,-4.45) 20(-2.25,-4.45) 21(-1.75,-4.45) 22(-1.25,-4.45) 23(-0.75,-4.45) 24(-0.25,-4.45) 25(0.25,-4.45) 26(0.75,-4.45) 27(1.25,-4.45) 28(1.75,-4.45) 29(2.25,-4.45) 30(2.75,-4.45) 31(3.25,-4.45) 50(3.25,4.45) 51(2.75,4.45) 52(2.25,4.45) 53(1.75,4.45) 54(1.25,4.45) 55(0.75,4.45) 56(0.25,4.45) 57(-0.25,4.45) 58(-0.75,4.45) 59(-1.25,4.45) 60(-1.75,4.45) 61(-2.25,4.45) 62(-2.75,4.45) 63(-3.25,4.45)
  rect 6.248x6.248 smd: 65(0,0)
VSSOP8XB
  rect 0.813x0.279 smd: 1(-1.55,0.75) 2(-1.55,0.25) 3(-1.55,-0.25) 4(-1.55,-0.75) 5(1.55,-0.75) 6(1.55,-0.25) 7(1.55,0.25) 8(1.55,0.75)
X_4S_7M25000083_3-2X2-5
  rect 1.219x1.422 smd: 1(-0.85,1.1) 2(-0.85,-1.1) 3(0.85,-1.1) 4(0.85,1.1)

## Nets
