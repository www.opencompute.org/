# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P0V9_ADDR1: length 2.3
  TOP w0.178: PU301.18 205.89,33.61 206.16,33.34 206.16,32.19 PR305.2
P0V9_CTRL: length 6.8
  TOP w0.112: PU301.9 200.16,34.81 199.85,34.69 199.54,34.37 v2(198.18,34.37) 198.18,34.09 198.08,33.98 198.08,33.48 197.84,33.24 197.84,33.04 197.6,32.8 C1231.1 197.39,33.17 197.5,33.29 R3552.2 R3551.2
P0V9_IREF1: length 2.4
  TOP w0.178: PU301.20 206.12,34.41 206.55,33.99 206.55,33.2 PR301.2
P0V9_TAKE1: length 6.1
  TOP w0.112: PU301.11 200.46,34.01 200.3,33.95 199.95,33.6 199.6,32.76 199.6,32.1 199.42,31.92 PR308.2 199.82,31.59 199.92,31.69 199.92,32.84 200.14,33.35 200.4,33.61 PU301.12
P0V9_VCC: length 26.2
  TOP w0.178: PU301.24 206.51,36.01 207.27,36.78 207.27,37.4 207.46,37.59
  TOP w0.254: PR308.1 198.36,31.84 PR307.1 198.57,33.04 v2(198.74,33.21)
  IN1 w0.254: v2(208.6,37.9) 207.21,36.51 207.21,36.15 206.9,35.83 206.9,31.74 205.86,30.7 205.86,29.81 205.4,29.34 200.56,29.34 200,29.91 200,33.82 199.75,34.07 199.21,34.07 198.74,33.6 v2(198.74,33.21)
P0V9_VOSNS+: length 4.5
  TOP w0.178: PU301.22 206.65,35.21 206.89,34.97 PC309.1
  TOP w0.254: PR320.1 PC309.1 207.64,35.1 208.08,35.53 PR321.2
P0V92: length 354.7
  TOP w0.254: v2(200.71,98.6) 200.9,98.6 201.53,99.23 201.53,100.47 201.21,100.79 PJ1.2 ; v2(54.62,47.04) 54.63,47.04 54.51,46.92 R3906.1
  TOP w0.457: U34.N20 v6(184.59,87.02) ; U34.N20 U34.P19 ; U34.N20 U34.M19 v6(182.59,88.02) ; U34.W16 v6(179.59,80.02) U34.Y15 v6(178.59,79.02) U34.AA14 v6(177.59,78.02) U34.AB13 v6(176.59,77.02) ; U34.W16 U34.V17 ; U34.W16 U34.V15 ; U34.V19 v6(182.59,82.02) U34.U18 v6(181.59,83.02) U34.T17 v6(180.59,84.02) U34.R16 v6(179.59,85.02) U34.P15 v6(178.59,86.02) U34.N14 v6(177.59,87.02) ; U34.V19 U34.U20 ; U34.V19 U34.W20 ; U34.V19 U34.W18 ; v6(189.59,88.02) U34.M25 v6(188.59,87.02) U34.N24 v6(187.59,86.02) U34.P23 v6(186.59,85.02) U34.R22 v6(185.59,84.02) U34.T21 v6(184.59,83.02) U34.U20 ; U34.AE20 v6(184.59,74.02) ; U34.AE20 U34.AD19 ; U34.AE20 U34.AF19 v6(182.59,73.02) ; U34.AA20 U34.Y19 ; U34.AA20 v6(184.59,78.02) U34.AB21 v6(185.59,77.02) U34.AC22 v6(186.59,76.02) U34.AD23 v6(187.59,75.02) U34.AE24 v6(188.59,74.02) U34.AF25 v6(189.59,73.02) ; U34.AA20 U34.AB19 ; U34.Y19 v6(182.59,79.02) U34.AA18 v6(181.59,78.02) U34.AB17 v6(180.59,77.02) U34.AC16 v6(179.59,76.02) U34.AD15 v6(178.59,75.02) U34.AE14 v6(177.59,74.02) ; U34.Y19 U34.W20 ; v6(190.59,74.02) U34.AE26 v6(189.59,75.02) U34.AD25 v6(188.59,76.02) U34.AC24 v6(187.59,77.02) U34.AB23 v6(186.59,78.02) U34.AA22 v6(185.59,79.02) U34.Y21 v6(184.59,80.02) U34.W20 ; U34.W22 v6(186.59,80.02) U34.Y23 v6(187.59,79.02) U34.AA24 v6(188.59,78.02) U34.AB25 ; U34.W22 U34.V21 ; U34.W22 U34.V23 ; U34.V17 U34.W18 ; U34.V17 v6(180.59,82.02) U34.U16 v6(179.59,83.02) U34.T15 v6(178.59,84.02) U34.R14 v6(177.59,85.02) U34.P13 v6(176.59,86.02) ; U34.W14 U34.V15 ; U34.W14 v6(177.59,80.02) U34.Y13 v6(176.59,79.02) ; U34.W14 U34.V13 v6(176.59,82.02) ; U34.V15 v6(178.59,82.02) U34.U14 v6(177.59,83.02) U34.T13 v6(176.59,84.02) ; U34.AC20 U34.AB19 ; U34.AC20 v6(184.59,76.02) U34.AD21 v6(185.59,75.02) U34.AE22 v6(186.59,74.02) U34.AF23 v6(187.59,73.02) ; U34.AC20 U34.AD19 ; U34.AB19 v6(182.59,77.02) U34.AC18 v6(181.59,76.02) U34.AD17 v6(180.59,75.02) U34.AE16 v6(179.59,74.02) U34.AF15 v6(178.59,73.02) ; U34.W18 v6(181.59,80.02) U34.Y17 v6(180.59,79.02) U34.AA16 v6(179.59,78.02) U34.AB15 v6(178.59,77.02) U34.AC14 v6(177.59,76.02) U34.AD13 v6(176.59,75.02) ; U34.U20 U34.T19 ; U34.V21 U34.W20 ; U34.V21 v6(185.59,82.02) U34.U22 v6(186.59,83.02) U34.T23 v6(187.59,84.02) U34.R24 v6(188.59,85.02) U34.P25 v6(189.59,86.02) ; U34.AD19 v6(182.59,75.02) U34.AE18 v6(181.59,74.02) U34.AF17 v6(180.59,73.02) ; U34.T19 U34.R20 ; U34.T19 v6(182.59,84.02) U34.R18 v6(181.59,85.02) U34.P17 v6(180.59,86.02) U34.N16 v6(179.59,87.02) U34.M15 v6(178.59,88.02) ; U34.R20 v6(184.59,85.02) U34.P21 v6(185.59,86.02) U34.N22 v6(186.59,87.02) U34.M23 v6(187.59,88.02) ; U34.R20 U34.P19 ; U34.V23 U34.W24 v6(188.59,80.02) U34.Y25 v6(189.59,79.02) ; U34.V23 v6(187.59,82.02) U34.U24 v6(188.59,83.02) U34.T25 v6(189.59,84.02) ; v6(180.59,88.02) U34.M17 v6(181.59,87.02) U34.N18 v6(182.59,86.02) U34.P19
  IN2 w0.254: v2(95.28,33.22) 99.16,33.22 99.7,33.77 101.86,33.77 104.35,31.28 104.35,23.81 103.6,23.06 103.6,9.77 105.78,7.59 155.22,7.59 156.21,8.58 156.21,10.85 155.4,11.66 155.4,13.89 156.19,14.68 156.19,29.56 159.3,32.67 159.3,36.1 163.38,40.19 174.69,40.19 176.23,41.73 176.23,42.92 176.75,43.44 180.27,43.44 181.65,44.82 v2(185.08,44.82)
  BOTTOM w0.254: v2(95.28,33.22) 92.83,35.67 79.61,35.67 74.35,30.4 66.81,30.4 65.89,31.32 65.89,33.24 62.28,36.86 62.28,40.55 61.83,41 61.83,42.38 57.54,46.67 55.01,46.67 54.63,47.04 v2(54.62,47.04)
  BOTTOM w0.381: v6(189.59,86.02) 189.2,85.63 C540.1
  vias: v2(185.09,45.56) v2(185.77,45.56) v2(185.78,44.82) v2(186.45,44.85) v2(186.47,45.57) v2(187.12,47.88) v2(187.12,47.02) v2(187.16,46.33) v2(187.2,45.61) v2(187.18,44.9) v2(187.94,44.91) v2(187.98,46.34) v2(187.96,45.57) v2(190.24,46.06) v2(190.24,45.42) v2(192.5,46.09) v2(192.49,45.44) v2(193.7,44.66) v2(193.68,43.9) v2(193.68,43.22) v2(194.33,43.5) v2(194.33,42.82) v2(194.35,44.27) v2(195.1,45.64) v2(197.44,46.68) v2(197.47,46.03) v2(197.89,45.4) v2(198.11,46.03) v2(198.28,46.67) v2(198.6,45.4) v2(198.83,46.03) v2(199.13,48.66) v2(199.09,47.99) v2(199.11,47.35) v2(199.12,46.69) v2(199.42,42.56) v2(199.51,45.18) v2(199.53,44.52) v2(199.53,43.85) v2(199.49,43.21) v2(199.63,98.97) v2(199.55,46.03) v2(199.83,47.99) v2(199.85,47.35) v2(199.85,46.66) v2(199.86,48.63) v2(200.26,46.02) v2(200.52,48.62) v2(200.49,47.98) v2(200.51,47.34) v2(200.51,46.66) v2(200.61,97.05) v2(200.71,99.25) v2(200.68,94.32) v2(200.81,94.95) v2(200.88,45.48) v2(201.34,94.32) v2(201.49,94.95) v2(201.64,45.48) v2(202.49,45.49) v3(198.48,49.28) v3(201.51,47.65)
P0V92_BIC_SCALED: length 9.6
  TOP w0.112: 46.63,44.73 46.33,44.73 46.18,44.58 45.59,44.58 U86.H2
  TOP w0.254: R3906.2 C1159.1 51.99,47.72 50.14,45.87 v1(50.14,45.72) 49.86,45.44 49.33,45.44 48.62,44.73 46.63,44.73
P0V92_SENSE+: length 11.2
  TOP w0.254: v2(206.15,106.24) 205.66,106.24 203.78,104.37 203.38,104.37 202.7,103.7 PJ1.1 ; PC309.2 PR320.2 208.59,33.8 208.59,32.94 208.36,32.7 208.36,31.75 208.54,31.57 PC310.1 208.54,30.96 v2(208.29,30.71)
P1V8: length 482.8
  TOP w0.254: PU7.6 21.78,19.66 21.92,19.81 21.92,21.84 21.65,22.12 21.65,23.51 21.81,23.67 21.81,26.23 21.7,26.34 21.19,26.34 v2(21.12,26.26) ; U66.3 183.89,132.02 v2(183.95,131.96)
  TOP w0.279: U61.29 v2(123.44,38.68) ; U61.18 v2(118.69,34.97)
  TOP w0.381: R4242.1 122.31,121.58 v2(123.2,121.58) ; R78.1 v2(34.75,75.15) ; R3071.1 v2(28.09,94.41) ; v2(51.59,122.66) 50.87,121.93 R4236.1 ; R4238.1 74.81,121.97 74.71,122.06 v2(74.21,122.06) ; 97.51,107.65 91.59,107.65 90.37,108.86 87.68,108.86 84.3,105.49 82.58,105.49 82.26,105.81 82.26,108.65 R4314.1 82.11,109.18 v2(82.88,109.96) 82.6,110.24 79.71,110.24 78.19,108.72 75.54,108.72 73.73,106.91 67.14,106.91 65.23,108.82 61.46,108.82 60.25,110.03 59.68,110.03 v2(59.39,109.74) 59,109.35 58.69,109.35 R4313.1 58.48,109.02 57.84,108.39 56.04,108.39 55.75,108.67 53.88,108.67 52.92,109.07 52.86,109.04 ; 97.51,107.65 98.31,108.45 R4318.1 101.99,108.67 102.54,109.22 103.62,109.22 v2(103.87,108.97) ; 97.51,107.65 97.51,105.71 98.59,104.63 99.63,104.63 99.65,104.63 100.34,104.92 102.12,104.92 102.3,104.74 110.67,104.74 112.09,103.33 113.97,103.33 114.65,104.01 114.65,106.62 115.09,107.05 116.68,107.05 118.06,108.44 119.68,108.44 120.13,108.88 120.13,109.36 120.72,109.95 121.88,109.95 122.5,109.33 126.19,109.33 126.72,109.86 R4319.1 127.51,108.98 127.27,108.75 127.27,108.26 126.88,107.86 v2(126.88,107.79) ; U105.14 v2(34.12,88.52) ; U104.14 v2(97.49,61.13) ; 52.17,109.04 52.1,109.04 51.35,108.3 48.14,108.3 47.63,108.81 43.79,108.81 42.11,110.49 v2(41.94,110.49) ; v2(180.76,124.16) 180.8,124.13 U71.14 ; R72.1 v2(29.72,75.2) ; v2(189.97,119.3) 189.69,119.58 U103.14 ; R73.1 v2(26.29,75.2) ; R3066.1 v2(21.23,37.82) ; v2(35.36,110.61) 35.6,110.61 36.23,109.97 R4312.1 ; R69.1 v2(17.7,79.1) ; R3067.1 v2(43.48,75.18) ; R75.1 v2(35.89,75.15) ; R4244.1 v2(146.34,120.94) ; R4320.1 162.15,131 164.49,131 166.27,129.22 v2(166.27,127.93) ; R74.1 v2(27.43,75.2) ; R3065.1 v2(19.47,38.44) ; L13.1 114.63,36.47 v2(114.57,36.41) ; R67.1 v2(19.96,79.1) ; R3068.1 v2(44.63,75.18) ; R3271.1 v2(10.9,104.2) ; R3074.1 v2(26.95,94.41) ; R71.1 v2(28.57,75.2) ; R3069.1 v2(41.2,75.18) ; R3072.1 v2(29.24,94.41) ; R3064.1 v2(23.44,37.8) ; R77.1 v2(33.61,75.15) ; R3063.1 v2(22.35,37.8) ; R3073.1 v2(25.81,94.41) ; R70.1 v2(18.85,79.1) ; R68.1 v2(21.11,79.1) ; R76.1 v2(37.04,75.15) ; R3070.1 v2(42.34,75.18)
  TOP w0.457: U34.R34 v6(198.59,85.02) ; U34.U26 v6(190.59,83.02) ; U34.AA26 v6(190.59,78.02) ; U34.U31 v6(195.59,83.02) ; U34.AD28 v6(192.59,75.02) ; U34.AJ34 v6(198.59,70.02) ; U34.AG34 v6(198.59,72.02) ; U34.N34 v6(198.59,87.02) ; U34.AC34 v6(198.59,76.02) ; U34.L31 v6(195.59,89.02) ; U34.P28 v6(192.59,86.02) ; U34.AE34 v6(198.59,74.02) ; U34.U34 v6(198.59,83.02) ; U34.R26 v6(190.59,85.02) ; U34.L34 v6(198.59,89.02)
  TOP w0.508: U56.8 182.65,118.19 182.93,118.47 C951.1 C950.1 v2(183.52,120.22) ; R3264.1 v2(8.66,100.97) ; R3127.1 v2(171.6,116.03) ; R3147.2 208.11,66.73 208.41,66.44 208.41,59.01 R3259.2 208.22,58.82 v2(208.22,56.99) ; U89.16 v2(30.9,67.38) ; R3278.1 179.72,135.54 v2(179.66,135.6) 179.66,137.49 180.45,138.27 R3279.1 ; R3125.1 v2(186.57,116.87) ; U90.16 38.22,67.33 v2(38.21,67.34) ; U63.5 v2(88.51,34.78) ; U34.AG31 v6(195.59,73.02) ; R3126.1 v2(171.6,115.01) ; v2(9.93,107.04) 10.24,106.73 R3268.1 ; U91.16 v2(24.47,30.43) ; R3148.2 78.1,32.12 v2(77.98,32) ; U88.16 v2(22.69,71.12) ; U93.16 v2(30.42,86.56) ; U92.16 45.81,67.32 v2(45.79,67.34) ; 52.86,109.04 52.17,109.04 ; R3277.1 v2(179.95,131.06) ; R3128.1 v2(171.6,119.08)
  IN1 w0.508: v2(123.44,38.68) 122.28,37.52 122.28,36.71 121.61,36.04 119.21,36.04 118.69,35.51 v2(118.69,34.97) ; v2(45.42,28.24) 45.42,28.04 45.92,27.53 46.71,27.53 47.19,28.02 v2(47.19,28.27) 48.11,29.18 54.81,29.18 56.39,27.61 v2(56.68,27.61)
  BOTTOM w0.254: v2(77.98,32) 75.31,29.34 66.36,29.34 63.47,32.23 63.47,33.97 61.21,36.23 61.21,40.11 60.76,40.56 60.76,41.89 57.59,45.06 56.08,45.06 55.2,45.94 R3909.1 ; v6(195.59,83.02) 194.92,82.36 C607.1 ; v6(198.59,83.02) 198.58,83.01 C592.1 ; v6(198.59,76.02) 198.05,76.56 C603.1 ; v6(198.59,89.02) 198.51,89.09 C595.1 197.51,89.09 197.17,88.76 C597.1 ; v6(195.59,73.02) 195.62,72.99 C601.1 ; R3575.2 193.01,89.13 R3573.2 193.44,87.66 R3576.2
  BOTTOM w0.279: C613.1 199.2,87.63 v6(198.59,87.02) ; C617.1 199.2,86.41 v6(198.59,87.02) ; R3571.2 195.98,90.12 195.58,89.72 195.58,89.03 v6(195.59,89.02) 195.85,88.76 C604.1 C597.1 ; C615.1 199.2,89.63 v6(198.59,89.02) ; C596.1 190.77,83.2 v6(190.59,83.02) ; v6(198.59,85.02) 198.59,84.98 C616.1 ; v6(198.59,87.02) 198.48,87.12 C594.1 ; R3573.2 193.01,87.85 192.44,87.28 C605.1 192.44,86.17 v6(192.59,86.02)
  BOTTOM w0.305: C599.1 198.57,74.04 v6(198.59,74.02) ; C598.1 197.98,72.63 v6(198.59,72.02) ; C602.1 198.61,70 v6(198.59,70.02) ; C606.1 190.36,78.25 v6(190.59,78.02)
  BOTTOM w0.381: v2(103.87,108.97) 104.09,109.19 109.22,109.19 R4323.1 ; v2(24.21,97.54) C1083.1 24.08,96.72 U72.14 ; U102.14 194.03,116.31 193.95,116.39 C1203.1 ; R4248.1 v2(149.58,145.06) ; v2(21.83,138.06) 21.98,137.91 R4234.1 ; R4315.1 84.87,108.67 83.59,109.96 v2(82.88,109.96) ; v2(126.88,107.79) 126.88,107.79 126.98,107.89 127.74,107.89 127.93,108.08 127.93,108.22 127.53,108.62 127.53,111 127.97,111.43 130.18,111.43 131.49,110.12 132.63,110.12 133.6,109.15 134.66,109.15 135.9,109.67 136.91,109.67 137.16,109.41 R4322.1 137.26,108.99 138.32,108.99 138.81,109.47 142.8,109.47 143.43,110.11 146.76,110.11 147.4,109.47 147.4,107.87 151.19,104.08 158.14,104.08 158.96,104.42 159.97,105.25 160.91,106.65 160.91,107.65 R4321.1 158.79,111.25 159.88,112.33 160.65,112.33 161.35,111.63 164.19,111.63 164.89,112.33 165.61,112.33 165.98,112.18 169.04,112.18 169.95,113.09 v2(169.95,113.24) ; v2(111.84,125.14) 112,125.14 112.43,125.57 R4250.1 ; C1205.1 34.16,88.56 v2(34.12,88.52) ; R3123.1 v2(207.03,12.01) ; D4.1 138.9,42.96 C1079.1 ; R4252.1 v2(88.97,124.87) ; R4246.1 160.95,124.78 v2(161.19,124.54) ; C600.1 v6(192.59,75.02) ; C1082.1 180.89,124.04 v2(180.76,124.16) ; C593.1 190.25,84.68 v6(190.59,85.02) ; v2(97.49,61.13) 97.51,61.11 C1204.1 ; v2(41.94,110.49) 41.51,110.49 40.78,109.76 40.78,109.53 40.31,109.06 39.65,109.06 R4317.1 39.28,109.02 39.28,108.76 38.83,108.32 35.44,108.32 35.26,108.5 35.26,110.51 v2(35.36,110.61) ; Q46.D v2(2.79,31.14) ; R4256.1 v2(33.86,145.61) ; v2(78.4,145.28) R4254.1 77.75,145.27 R4240.1
  BOTTOM w0.457: C961.1 118.17,35.49 v2(118.69,34.97) ; C953.2 123.01,38.25 v2(123.44,38.68) 122.82,39.3 C959.1 ; R4316.1 58.55,108.08 58.55,108.91 v2(59.39,109.74)
  BOTTOM w0.508: v2(24.47,30.43) 24.52,30.47 C1148.1 ; C1139.1 38.21,66.65 v2(38.21,67.34) ; R3754.2 57.51,29.11 57.87,28.76 57.87,28.06 57.42,27.61 v2(56.68,27.61) 55.98,27.61 54.74,28.85 R3753.1 ; v2(71.86,32.06) R4065.1 ; C1074.2 183.97,131.99 v2(183.95,131.96) ; C1202.1 190.2,119.07 v2(189.97,119.3) ; C1204.1 98.13,48.26 94.89,45.02 v2(94.89,44.78) ; R3337.2 R3336.2 148.36,44.65 v2(148.62,44.91) ; v2(24.81,24.22) 26.04,24.22 26.95,25.14 33.12,25.14 34.71,23.54 38.99,23.54 39.59,24.14 41.31,24.14 v2(45.42,28.24) 45.42,28.74 R3749.1 ; R4386.1 8.62,2.49 v2(7.99,3.12) ; C960.1 119.22,35.61 118.69,35.09 v2(118.69,34.97) ; v2(68.71,30.99) 68.71,31.42 67.79,32.33 R4069.1 ; R3430.2 v2(178.44,120.35) ; v2(30.9,67.38) 30.89,67.37 C1136.1 ; v2(22.69,71.12) 22.75,71.06 C1142.1 ; R4066.2 74.9,32.23 v2(74.75,32.08) ; R4070.2 70.84,32 v2(71.19,31.65) ; v2(179.65,120.29) R3431.2 ; C1145.1 30.51,86.47 v2(30.42,86.56) ; R3746.2 R3745.1 50.37,28.5 49.43,27.56 47.7,27.56 47.19,28.07 v2(47.19,28.27) 47.88,28.96 R3750.2 ; v2(208.22,56.99) 208.22,56.99 204.05,52.82 v2(203.72,52.82) ; C1203.1 v2(193.95,117.27) ; C1079.1 v2(138.94,43.64) ; R3432.2 v2(180.47,120.14) ; v2(45.79,67.34) C70.1
  vias: v2(2.18,40.06) v2(2.16,39.42) v2(3.46,31.13) v2(18.39,26.14) v2(18.39,25.38) v2(19.93,25.71) v2(20.43,25.29) v2(21.11,25.61) v2(21.18,24.91) v2(66.95,2.57) v2(68.1,2.55) v2(122.96,41.16) v2(191.83,2.84) v2(192.23,2.29) v2(203.98,79) v2(204.67,78.95) v2(206.81,101.73) v2(206.85,101.1) v3(204.7,78.21) v6(191.62,74.09)
P1V8_BIC_SCALED: length 10.7
  TOP w0.112: U86.H3 44.89,44.44 44.58,44.75 44.49,44.75 v6(44.32,44.92)
  BOTTOM w0.254: v6(44.32,44.92) 44.32,45 44.77,45.46 47.76,45.46 48.23,44.98 v3(49.96,44.98) 51.43,44.98 C1158.1 R3910.1 R3909.2
P1V8_DISCHARGE_EN: length 6.7
  BOTTOM w0.508: Q52.G 9.35,6.23 9.49,6.37 R4385.2 8.62,6.81 7.85,7.58 v3(7.85,9.28) Q53.D
P1V8_DISCHARGE_EN_D: length 4.4
  BOTTOM w0.508: R4386.2 v3(11.79,2.01) 11.79,3.01 11.32,3.48 Q52.D
P1V8_EN: length 22.7
  TOP w0.112: R3474.2 R3618.2 22.66,18.2 22.66,17.12 22.26,16.72 19.57,16.72 v4(19.49,16.8) 18.91,17.38 C1230.1 18.91,19 19.19,19.28 PU7.4
  BOTTOM w0.112: v4(19.49,16.8) 19.37,16.68 19.37,12.17 17.43,10.23 Q53.G
P1V8_JTAG: length 3.8
  TOP w0.254: J47.1 v2(7.06,105.14) 7.12,105.14 8.28,106.31 R3268.2
P3V3: length 313.6
  TOP w0.508: R2923.1 v2(182.98,126.89) ; v2(22.17,91.02) 22.62,90.58 23.11,90.58 26.35,87.34 v2(26.89,87.34) ; v2(194.02,106.59) 196.47,109.03 v2(196.47,109.75) ; R2927.1 v2(186.72,122.38) ; R2926.1 v2(171.6,121.23) ; v2(172.68,125.93) 172.9,126.16 174.74,126.16 177.02,128.43 v2(178.48,128.43) ; R2929.1 189.15,125.55 v2(189.77,124.93) 189.26,124.41 R2928.1 ; v2(22.91,99.87) 21.92,98.88 20.37,98.88 19.99,99.26 19.99,99.82 v2(19.86,99.95) 19.29,99.95 18.49,99.15 17.73,99.15 17.37,99.51 v2(17.37,99.82) ; v2(164.78,142.96) 166.16,141.58 173.36,141.58 v2(174.05,142.27)
  IN1 w0.508: v2(164.78,142.96) 148.09,142.96 146.07,144.98 144.32,144.98 143.7,144.36 142.98,144.36 v2(141.76,145.59) ; v2(178.48,128.43) 178.48,127.75 179.33,126.89 v2(182.98,126.89) ; v2(29.57,146.48) 82.43,146.48 v2(83.27,145.64) ; v2(188.6,118.77) 187.68,119.68 ; 187.68,119.68 187.2,119.2 186.74,119.2 185.44,120.51 185.44,126.4 184.94,126.89 183.07,126.89 ; 187.68,119.68 187.68,121.37 186.72,122.34 v2(186.72,122.38) 187.03,122.69 188.36,122.69 188.87,123.2 188.87,124.02 v2(189.77,124.93) 190.61,124.93 191.38,124.16 v2(191.8,124.16) ; v2(172.68,125.93) 172.04,125.3 170.84,125.3 170.33,124.79 170.33,123.38 170.94,121.89 v2(171.6,121.23) ; v2(181.38,124.84) 181.38,125.29 v2(182.98,126.89) ; v2(174.05,142.27) 174.51,141.82 182.74,141.82 183.18,141.38 185.78,141.38 186.07,141.67 187.09,141.67 187.83,140.93 v2(187.83,139.87) 187.83,138.61 186.16,136.94 186.16,135.44 v2(185.31,134.59) 185.57,134.59 186.01,134.15 186.01,131.29 185.09,130.38 v2(183.44,130.38) 183.52,130.3 183.52,128.31 183.71,128.13 183.71,127.53 183.07,126.89 ; v2(21.01,84.71) 21.01,84.13 20.47,83.59 19.28,83.59 18.85,84.02 18.13,84.02 17.63,84.52 v2(17.63,84.71) ; v2(182.98,126.89) 183.07,126.89
  IN2 w0.508: v2(196.47,109.75) 196.62,109.91 196.62,110.66 194.83,112.45 194.83,117.48 194.32,117.98 193.66,117.98 189.77,121.87 v2(189.77,124.93) ; v2(19.86,99.95) 20.14,99.67 20.14,93.06 v2(22.17,91.02) 21.6,90.45 21.6,87.23 21.01,86.64 v2(21.01,84.71) ; v2(17.37,99.82) v2(15.03,99.82)
  BOTTOM w0.381: R2838.1 v2(22.91,99.87) ; R2836.1 16.81,99.39 17.25,99.82 v2(17.37,99.82) ; R4193.2 188.09,140.13 v2(187.83,139.87) ; R4184.2 v2(190.47,140.59) ; R4191.2 189.28,140.23 v2(189.38,140.13) ; R2837.1 v2(19.86,99.95) ; v2(191.62,140.61) R4185.2
  BOTTOM w0.508: v2(186.72,122.38) 186.53,122.56 R4188.2 ; v2(183.44,130.38) 183.9,129.92 R4182.2 ; R4183.2 191.9,124.26 v2(191.8,124.16) ; R4190.2 189.2,119.38 v2(188.6,118.77) 188.16,119.2 R4189.2 ; R4186.2 181.21,125.01 v2(181.38,124.84) ; R4192.2 193.69,106.25 v2(194.02,106.59) ; 8.02,106.41 9.97,104.45 9.97,102.85 13,99.82 v2(15.03,99.82) ; v2(21.01,84.71) 20.73,84.99 R2834.1 ; v2(29.57,146.48) 21.1,146.48 18.05,143.43 18.05,134.28 18.46,133.87 18.46,130.43 20.16,128.73 20.16,127.44 18.27,125.56 18.27,124.21 13.53,119.46 13.53,113.69 7.94,108.09 7.94,107.66 ; R2833.1 26.16,85.35 26.66,85.85 26.66,87.11 v2(26.89,87.34) ; R2835.1 v2(17.63,84.71) ; R2925.1 v2(172.68,125.93) ; R4187.2 v2(185.31,134.59)
P3V3_DB1200: length 10
  TOP w0.254: v2(63.91,55.4) 63.71,55.6 U47.40 ; U47.32 58.77,57.53 v2(58.67,57.43) ; U47.57 68.98,61.53 v2(69.27,61.24) 69.05,61.03 U47.56 ; U47.25 58.89,61.03 v2(58.67,61.24) 58.96,61.53 U47.24 ; v2(69.22,57.18) 68.86,57.53 U47.49
  TOP w0.381: R2967.1 R2968.1 v2(65.99,72.85) ; R2963.1 v2(61.77,70.69) ; R2970.1 v2(56.62,70.69)
P3V3_DB1200_VDDA: length 0.9
  TOP w0.254: U47.1 67.71,66.5 v2(67.59,66.62)
  vias: v3(67.3,67.39)
P3V3_DB1200_VDDR: length 1.2
  TOP w0.305: v2(64.24,66.93) 64.21,66.89 U47.8
P3V3_M2A: length 13.3
  TOP w0.203: U73.D1 35.33,115.49 v1(33.26,117.56) 33.13,117.43 31.32,117.43 31.14,117.6 30.68,117.6 v2(30.63,117.65) ; R3625.1 29.97,115.9 28.17,115.9 27.91,115.64 R3623.2
  IN1 w0.203: v2(30.77,114.57) 30.63,114.71 v2(30.63,117.65)
  vias: v1(26.5,111.72)
P3V3_M2A_EN: length 103.6
  TOP w0.112: U95.1 6.02,82.42 5.65,82.05 v2(5.65,81.14) ; v2(13.12,91.99) R2864.2 ; U86.M1 46.12,46.61 47.42,46.61 48.16,47.35 48.81,47.35 50.01,48.55 50.94,50.79 51.62,51.47 54.75,51.47 v2(54.98,51.25)
  IN1 w0.122: v2(4.62,64.75) 10.11,59.25 17.63,59.25 19.26,57.62 21.11,57.62 22.27,56.47 30.24,56.47 31.7,55.01 45.8,55.01 46.34,55.55 47.17,55.55 48.47,54.26 48.47,53.9 51.12,51.25 v2(54.98,51.25)
  IN2 w0.122: v2(13.12,91.99) 12.79,91.66 12.13,91.66 9.04,88.58 9.04,86.18 8.61,85.75 8.19,85.75 7.36,84.92 7.36,83.13 5.65,81.41 v2(5.65,81.14) 6.09,80.69 6.09,77.52 5.79,77.21 5.79,65.96 4.66,64.82 4.66,64.77 4.64,64.75 v2(4.62,64.75)
P3V3_M2A_EN_R: length 1.9
  TOP w0.112: U25.3 v2(14.39,90.5) 14.4,90.51 R2864.1
P3V3_M2A_L: length 4
  TOP w0.203: R3623.1 27.91,116.36 28.01,116.26 30,116.26 R3626.1
  vias: v1(21.54,121.08) v1(31.25,119.28)
P3V3_M2A_SR: length 3.8
  TOP w0.112: U19.7 26.06,118.02 v2(26.11,118.07)
  BOTTOM w0.112: v2(26.11,118.07) 26.11,119.25 v3(25.96,119.4) 25.34,120.02 C104.1
P3V3_M2B: length 14
  TOP w0.203: U74.D1 59.61,115.34 57.52,117.42 v2(54.93,117.42) ; R3631.2 52.65,115.71 53.01,116.08 54.69,116.08 R3632.1
  IN2 w0.203: v2(54.93,117.42) 55.22,117.13 55.22,114.88 54.68,114.33 v2(54.68,113.93)
P3V3_M2B_EN: length 110.8
  TOP w0.112: R2865.2 12.13,92 11.02,90.9 11.02,89.84 v1(9.85,88.67) 9.42,88.24 9.42,86.38 8.23,85.19 7.37,85.19 6.68,84.51 4.76,84.51 4.18,83.92 U95.5 2.23,83.92 1.41,83.1 1.41,65.26 2.71,63.97 3.83,63.97 v2(4.12,64.26) ; U86.K3 v5(44.95,45.94)
  IN1 w0.122: v2(56.75,49.45) 56.49,49.45 55.34,50.6 51.16,50.6 48.02,53.74 48.02,54.1 46.99,55.13 46.55,55.13 46,54.58 31.52,54.58 30.06,56.04 21.79,56.04 21.16,56.67 19.6,56.67 17.44,58.83 9.94,58.83 4.5,64.26 v2(4.12,64.26)
  BOTTOM w0.112: v2(56.75,49.45) 56.36,49.45 54.35,47.44 48.81,47.44 47.48,46.11 v3(46.16,46.11) 45.99,45.94 v5(44.95,45.94)
P3V3_M2B_EN_R: length 1.9
  TOP w0.112: R2865.1 12.44,90.48 v2(12.44,90.47) U25.6
P3V3_M2B_L: length 32
  TOP w0.203: R3633.1 54.63,116.43 52.98,116.43 52.65,116.76 R3631.1
  TOP w0.381: v2(51.97,145.04) v2(53.87,145.04) 53.87,144.84 55.51,143.2 55.51,141.51 54.67,140.67 54.67,137.4 56.74,135.32 57.95,135.32 58.62,134.65 58.62,127.73 59.39,126.96 59.39,125.13 60.19,124.33 60.19,123.97
  BOTTOM w0.254: R4102.1 v2(51.97,145.04) ; R4103.1 v2(53.87,145.04)
  vias: v1(51.02,120.2) v1(56.43,119.78) v1(58.7,120.28)
P3V3_M2B_SR: length 11.2
  TOP w0.112: C123.1 45.03,118.72 44.04,119.71 v2(43.89,119.71) ; U20.7 50.77,117.17 51.1,117.5 51.1,118.2 50.88,118.43 v2(50.57,118.43)
  BOTTOM w0.112: v2(43.89,119.71) 44.11,119.71 45.05,118.77 v3(47.83,118.77) 49.99,118.77 50.33,118.43 v2(50.57,118.43)
P3V3_M2C: length 14
  TOP w0.203: v2(79.56,116.56) 82.7,116.56 83.33,115.92 U75.D1 ; R3638.2 77.53,114.97 77.72,115.15 79.43,115.15 R3639.1
  IN2 w0.254: v2(79.56,116.56) v2(79.56,112.75)
P3V3_M2C_EN: length 71.9
  TOP w0.112: v6(42.95,48.94) U86.V6 ; v2(7.25,78.64) 6.59,78.64 4.92,80.31 4.56,80.31 4.32,80.07 U96.1 ; R2866.2 11.33,79.46 v2(11.62,79.17)
  IN1 w0.122: v2(10.07,63.29) 11.35,63.29 11.72,62.92 24.45,62.92 24.76,62.61 33.99,62.61 35.33,61.28 38.2,61.28 39.39,60.09 40.15,60.09 v2(41.44,58.8)
  IN2 w0.122: v2(10.07,63.29) 10.35,63.58 10.35,70.65 11.95,72.24 11.95,75.39 12.18,75.62 12.18,78.61 v2(11.62,79.17)
  BOTTOM w0.112: v2(7.25,78.64) 7.72,78.64 8.2,79.11 11.56,79.11 v2(11.62,79.17) ; v6(42.95,48.94) 42.95,50.18 43.56,50.78 43.56,52.7 42.65,53.61 42.65,56.01 42.47,56.19 42.47,56.81 42.03,57.24 42.03,58.64 41.87,58.8 v2(41.44,58.8)
P3V3_M2C_EN_R: length 3.1
  TOP w0.112: R2866.1 v2(11.33,81.32) 11.33,81.51 11.79,81.97 U25.8
P3V3_M2C_L: length 38.3
  TOP w0.203: R3640.1 79.41,115.51 77.71,115.51 77.53,115.69 R3638.1
  TOP w0.381: 67.24,125.89 66.83,125.89 66.43,125.49 65.19,125.49 65.08,125.6 65.08,128.26 63.52,129.83 61.58,129.83 60.73,128.98 60.06,128.98 59.16,129.87 59.16,134.86 58.06,135.96 57.3,135.96 55.54,137.73 55.54,139.72 60.91,145.09 v2(61.11,145.09) v2(63.02,145.09)
  BOTTOM w0.254: R4107.1 v2(61.11,145.09) ; R4106.1 v2(63.02,145.09)
  vias: v1(71.21,119.39) v1(80.69,120.09) v1(82.65,121.15)
P3V3_M2C_SR: length 7.8
  TOP w0.112: U21.7 75.68,116.95 v2(75.51,117.13) ; C126.1 70.34,117.49 v2(70.73,117.88)
  BOTTOM w0.112: v2(75.51,117.13) 75.51,117.64 75.04,118.11 74.31,118.11 v3(74.11,118.31) 73.91,118.11 70.96,118.11 v2(70.73,117.88)
P3V3_M2D: length 14.5
  TOP w0.203: v2(104.93,116.79) 104.99,116.72 108.4,116.72 110.26,114.86 U76.D1 ; R3646.1 104.65,115.27 103.19,115.27 102.94,115.03 R3645.2
  IN2 w0.203: v2(105.54,112.27) 105.08,112.73 105.08,116.64 v2(104.93,116.79)
P3V3_M2D_EN: length 72.8
  TOP w0.112: v2(7.28,77.98) 3.84,77.98 2.82,76.97 U96.5 ; R2867.2 13.15,79.52 13.15,79.25 12.31,78.41 v2(11.73,78.41) ; U86.W7 42.95,50.18 43.19,50.74 43.19,52.26 43.01,52.7 43.01,54.86 43.35,55.2 43.35,57.16 42.45,58.06 v2(41.45,58.06)
  IN1 w0.122: v2(9.49,62.83) 9.82,62.49 24.27,62.49 24.58,62.18 32.58,62.18 34,60.76 34,60.52 34.39,60.13 38.11,60.13 39.85,58.38 41.14,58.38 v2(41.45,58.06)
  IN2 w0.122: v2(9.49,62.83) 9.49,63.45 9.92,63.89 9.92,70.84 11.52,72.44 11.52,75.62 11.73,75.84 v2(11.73,78.41)
  BOTTOM w0.112: v2(7.28,77.98) 7.88,77.98 8.37,78.48 11.67,78.48 v2(11.73,78.41)
P3V3_M2D_EN_R: length 3
  TOP w0.112: U25.11 13.74,82.09 v1(13.43,81.78) 13.41,81.76 R2867.1
P3V3_M2D_L: length 41.9
  TOP w0.203: R3645.1 102.94,116.12 103.43,115.63 104.68,115.63 R3647.1
  TOP w0.381: 91.7,124.75 91.7,124.75 90.84,124.75 88.7,126.89 88.7,129.37 87.87,130.2 85.29,130.2 84.87,130.61 84.87,131.58 84.54,131.91 83.92,131.91 83.33,132.51 83.33,134.03 82.3,135.05 v2(79.99,135.05)
  IN2 w0.381: v2(69.19,145.01) 69.58,145.4 70.5,145.4 v2(70.84,145.06) 70.27,144.49 70.27,142.58 73.94,138.91 73.94,138.45 74.89,137.5 77.52,137.5 78.21,136.8 79.01,136.8 79.99,135.82 v2(79.99,135.05)
  BOTTOM w0.254: R4110.1 v2(70.84,145.06) ; R4111.1 v2(69.19,145.01)
  vias: v1(93.79,119.41) v1(106.87,121.43) v1(107.04,118.84)
P3V3_M2D_SR: length 8
  TOP w0.112: v2(96.26,117.86) 96.05,117.65 C129.1 ; U22.7 101.08,117.79 v2(100.9,117.97)
  BOTTOM w0.112: v2(100.9,117.97) 100.58,118.29 100.58,118.45 100.17,118.86 v3(99.47,118.86) 97.26,118.86 v2(96.26,117.86)
P3V3_M2E: length 12.9
  TOP w0.203: R3653.1 128.56,115.4 127.06,115.4 126.87,115.22 R3652.2 ; v2(129.06,116.87) 132.39,116.87 134.26,114.99 U77.D1
  IN2 w0.203: v2(128.42,113.65) 129.06,114.29 v2(129.06,116.87)
P3V3_M2E_EN: length 94.3
  TOP w0.112: U86.U8 v5(41.95,48.94) ; U97.1 8.7,88.93 10.21,90.45 v2(10.21,92.05) ; v2(11.97,94.93) 13.27,94.93 14.26,95.92 R2868.2
  IN1 w0.122: v2(10.21,92.05) 10.21,93.45 11.69,94.93 v2(11.97,94.93) ; v2(40.26,56.81) 39.49,56.81 38.61,57.69 33.36,57.69 30.17,60.88 27.06,60.88 26.34,60.16 24.85,60.16 24.23,60.78 19.45,60.78 18.88,61.34 9.26,61.34 8.22,62.39 8.22,62.73 5.75,65.2 4.31,65.2 v2(4,64.89)
  IN2 w0.122: v2(10.21,92.05) 9.5,92.05 9.08,91.63 8.48,91.63 7.65,90.8 7.65,89.43 6.4,88.19 6.4,87.19 5.37,86.16 5.02,86.16 4.33,85.47 4.33,81.35 4.62,81.06 4.62,80.07 4.23,79.69 4.23,71.28 4.73,70.78 4.73,68.49 5.12,68.11 5.12,65.96 4.04,64.89 v2(4,64.89)
  BOTTOM w0.112: v5(41.95,48.94) 41.95,51.57 42,51.62 42,52.11 41.86,52.26 41.86,53.6 41.18,54.28 41.18,55.89 v2(40.26,56.81)
P3V3_M2E_EN_R: length 3.6
  TOP w0.112: R2868.1 14.26,98.06 14.18,98.14 v1(14.18,99.16) U26.3
P3V3_M2E_L: length 31.6
  TOP w0.203: R4115.1 130.13,143.08 v2(130.14,143.07) ; R3652.1 126.87,116.32 127.43,115.76 128.58,115.76 R3654.1
  TOP w0.254: R4114.1 v2(130.55,145.69)
  TOP w0.381: 131.77,123.38 131.77,124.15 131.29,124.62 131.29,135.09 v2(130.68,135.7)
  BOTTOM w0.381: v2(130.68,135.7) 129.4,135.7 128.34,136.76 127.99,137.61 127.99,139.23 127.65,139.57 127.65,140.27 128.27,140.89 128.27,142.28 129.02,143.02 130.1,143.02 v2(130.14,143.07) 130.79,143.71 130.79,145.45 v2(130.55,145.69)
  vias: v1(122.13,119.62) v1(130.16,121.07)
P3V3_M2E_SR: length 8.3
  TOP w0.112: v2(124.18,118.77) 124.44,118.77 125.03,118.18 U23.7 ; v2(120.61,118.42) C132.1
  BOTTOM w0.112: v2(124.18,118.77) 124.05,118.89 v3(122.42,118.89) 121.09,118.89 v2(120.61,118.42)
P3V3_M2F: length 14.8
  TOP w0.203: R3660.1 157,115.8 154.82,115.8 154.55,115.53 R3659.2 ; U78.D1 162.85,119.81 162.65,119.61 161.68,119.61 160.38,119.07 158.75,117.45 v2(157.47,117.45)
  IN1 w0.279: v2(156.94,113.49) 156.94,114.32 157.47,114.85 v2(157.47,117.45)
P3V3_M2F_EN: length 87.7
  TOP w0.112: U97.5 4.58,90.43 4.69,90.54 4.69,91.03 5.36,91.69 8.38,91.69 9.42,92.74 9.42,93.29 10.49,94.36 13.9,94.36 15.94,96.4 R2869.2 16.48,96.4 16.78,96.09 16.78,94.12 19.13,91.77 19.13,84.45 18.75,84.07 17.72,84.07 17.11,83.46 17.11,80.8 16.58,80.27 16.58,79.71 15.98,79.11 15.98,69.41 15.29,67.75 15.29,64.38 15.93,63.74 18.93,63.74 19.7,62.97 19.7,61.01 v2(20.43,60.28) ; v6(39.45,47.88) U86.T14
  IN1 w0.122: v2(20.43,60.28) 23.06,60.28 24.38,58.96 30.44,58.96 32.68,56.72 37.42,56.72 v2(37.49,56.79)
  BOTTOM w0.112: v6(39.45,47.88) 39.45,50.22 39.51,50.27 39.51,51.98 38.96,52.52 38.96,54.13 37.49,55.59 v2(37.49,56.79)
P3V3_M2F_EN_R: length 3.8
  TOP w0.112: R2869.1 v1(16.13,98.87) 16.13,100.96 U26.6
P3V3_M2F_L: length 44
  TOP w0.203: R3661.1 156.97,116.16 154.81,116.16 154.55,116.42 R3659.1
  TOP w0.381: 155.74,123.74 155.74,124.48 155.34,124.88 155.34,127.89 154.46,128.76 154.46,134.8 154.11,135.16 153.12,135.16 152.46,135.82 152.46,143 153.12,143.67 153.12,145.78 152.51,146.39 145.56,146.39 144.61,145.45 144.61,144.42 v2(144.75,144.28) 141.38,144.28 v2(141.32,144.34)
  BOTTOM w0.254: R4118.1 144.47,144.56 v2(144.75,144.28) ; v2(141.32,144.34) 141.55,144.58 R4119.1
  vias: v1(142.94,118.95) v1(145.79,119.85) v1(154.25,120.67)
P3V3_M2F_SR: length 12.8
  TOP w0.112: C135.1 145.68,117.75 145.95,118.03 146.51,118.03 146.87,118.38 148.37,118.38 148.67,118.68 v1(152.34,118.68) 152.97,118.05 152.97,116.78 152.62,116.43 U24.7
P3V3_M2G: length 17.1
  IN1 w0.279: v2(157.71,113.94) 158.01,114.24 158.01,117.84 157.23,118.62 v2(157.23,119.28)
  BOTTOM w0.203: R3723.2 158.82,117.72 158.6,117.94 157.06,117.94 R3724.1 ; U84.D1 150.12,118.27 151.14,119.28 v3(153.61,119.28) v2(157.23,119.28)
P3V3_M2G_EN: length 143.2
  TOP w0.112: v2(54.99,54.65) 57.69,51.95 57.69,49.14 59.3,45.26 59.3,42.02 58.88,41.61 58.69,41.61 58.12,41.04 57.45,41.04 56.17,40.51 55.41,40.51 54.39,39.49 53.23,39.01 53.11,38.89 50.68,37.88 48.57,37.88 47.95,38.5 46.18,38.5 45.69,38.98 45.69,39.2 U86.A5 ; v2(5.56,92.51) 5.98,92.09 U98.1 ; v2(16.24,110.1) R2949.2
  IN1 w0.122: v2(54.99,54.65) 53.44,54.65 52.89,54.1 51.89,54.1 51.2,54.78 51.2,54.79 51.12,54.87 51.12,55.3 49.55,56.88 49.55,58.24 48.19,59.6 45.93,59.6 44.4,61.13 42.29,61.13 41.71,61.71 35.51,61.71 34.17,63.04 24.94,63.04 24.63,63.36 11.98,63.36 11.51,63.82 9.51,63.82 6.23,67.1 v2(4.59,67.1)
  IN2 w0.122: v2(4.59,67.1) 4.68,67.19 4.68,67.93 4.49,68.12 3.43,68.12 2.87,68.69 2.87,75.54 2.25,76.15 2.25,78.94 2.87,79.55 2.87,85.9 3.58,86.61 3.58,89.7 4.22,90.34 4.22,91.9 4.83,92.51 v2(5.56,92.51) 6.4,93.34 6.4,93.73 7.16,94.49 7.16,95.22 8.38,96.44 8.38,98.25 10.43,100.3 10.43,104.53 10.64,104.75 11.13,104.75 12.72,106.34 12.72,106.93 13.41,107.62 13.41,108.53 14.56,109.68 15.82,109.68 v2(16.24,110.1)
P3V3_M2G_EN_R: length 3.2
  TOP w0.112: U26.8 16.78,107.5 16.19,108.1 15.86,108.1 v2(15.54,108.41) R2949.1
P3V3_M2G_L: length 12.2
  BOTTOM w0.203: R3723.1 158.82,118.53 158.59,118.3 157.06,118.3 R3725.1
  BOTTOM w0.254: R4122.1 172.27,126.61 171.9,126.23 171.52,126.61 R4123.1
  BOTTOM w0.381: 171.9,126.23 171.3,125.63 171.01,125.63 170.45,125.07 170.45,122.75 170.17,122.47 167.67,122.47
  vias: v3(153.7,122.59) v3(164,122.63)
P3V3_M2G_SR: length 9.3
  BOTTOM w0.112: U33.7 161,119.31 160.57,119.74 160.57,121.23 v3(160.86,121.53) 161.08,121.74 162.94,121.74 164.04,120.64 164.95,120.64 165.61,121.31 C279.1
P3V3_M2H: length 16.8
  IN2 w0.203: v2(129.43,112.59) 129.43,112.98 129.56,113.11 129.56,117.26 129.25,117.57 v2(129.17,117.57)
  BOTTOM w0.203: U83.D1 122.48,115.51 123.22,116.26 125.65,116.26 v3(126.47,117.07) 126.96,117.57 v2(129.17,117.57) ; R3717.1 129.48,114.78 131.09,114.78 131.4,114.46 R3716.2
P3V3_M2H_EN: length 120.5
  TOP w0.112: U98.5 4.61,93.59 4.72,93.7 4.72,93.73 4.83,93.83 4.83,94.97 5.71,95.86 v2(5.71,95.89) ; R2950.2 v2(13.5,110.1) ; v2(52.28,54.54) 50.86,54.54 48.44,52.13 48.44,49.01 47.87,48.44 47.85,48.44 47.05,47.64 45.76,47.64 U86.R2
  IN1 w0.122: v2(52.28,54.54) 52.05,54.54 51.55,55.05 51.55,57.04 50.74,57.85 50.74,57.85 50.54,58.05 50.54,58.49 48.93,60.11 46.33,60.11 44.73,61.71 42.33,61.71 41.89,62.14 35.68,62.14 34.35,63.47 25.12,63.47 24.8,63.79 12.21,63.79 11.74,64.25 9.69,64.25 6.28,67.66 v2(4.24,67.66)
  IN2 w0.122: v2(4.24,67.66) 3.28,67.66 1.92,69.02 1.92,72.8 2.35,73.23 2.35,75.44 1.83,75.96 1.83,79.47 2.35,80 2.35,86.02 3.15,86.81 3.15,90.86 3.61,91.32 3.61,93.78 v2(5.71,95.89) 6.02,96.19 6.02,100.02 6.69,100.69 6.69,102.69 8.75,104.75 8.75,105.16 11.75,108.17 11.75,109.3 12.56,110.1 v2(13.5,110.1)
P3V3_M2H_EN_R: length 2.7
  TOP w0.112: U26.11 14.83,107.95 14.25,108.53 v2(14.25,108.59) R2950.1
P3V3_M2H_L: length 30.5
  TOP w0.381: v2(146.73,139.44) 146.73,139.91 147.72,140.9 147.72,144.71 v2(148.24,145.22) 146.34,145.22 v2(145.43,144.31)
  BOTTOM w0.203: R3716.1 131.4,115.54 131.01,115.14 129.47,115.14 R3718.1
  BOTTOM w0.254: R4127.1 v2(148.24,145.22) ; v2(145.43,144.31) 145.73,144.61 R4126.1
  BOTTOM w0.381: 143.55,126.5 145.05,126.5 145.39,126.84 145.39,130.04 145.88,130.53 146.49,130.53 146.83,130.88 146.83,134.28 146.73,134.39 v2(146.73,139.44)
  vias: v3(129.09,120.39) v3(136.16,121.39)
P3V3_M2H_SR: length 9.6
  BOTTOM w0.112: U32.7 133.26,116.42 132.87,116.82 132.87,118.48 134.45,120.07 136.47,120.07 v3(136.83,119.71) 137.96,118.58 C276.1
P3V3_M2I: length 15.5
  IN2 w0.203: v2(104.95,117.55) 105.59,116.91 v2(105.59,112.93)
  BOTTOM w0.203: U82.D1 98.71,114.78 99.47,115.54 101.66,115.54 v3(102.51,116.39) 103.67,117.55 v2(104.95,117.55) ; R3708.2 107.58,113.87 107.48,113.97 R3709.1
P3V3_M2I_EN: length 328.9
  TOP w0.112: v2(160.15,111.68) 162.84,112.8 164.05,112.8 165.74,113.5 167.08,114.85 167.08,119.91 169.3,122.13 169.3,124.6 168.79,125.11 168.79,126.33 171.51,129.05 172.33,129.05 175.36,132.08 175.36,139.9 R2951.2 ; v2(10.78,92.49) 10.95,92.32 10.95,91.67 10.62,91.34 10.62,90.23 9.02,88.63 9.02,86.54 8.07,85.59 U99.1 ; U86.R1 46.82,47.94 48.05,49.17 48.05,52.29 50.75,54.99 v2(53.1,54.99)
  IN1 w0.122: v2(53.1,54.99) 52.22,54.99 51.98,55.23 51.98,57.22 50.96,58.23 50.96,59.13 50.8,59.3 50.34,59.3 49.1,60.54 46.51,60.54 44.91,62.14 42.5,62.14 42.07,62.57 35.86,62.57 34.53,63.91 25.33,63.91 24.51,64.72 9.98,64.72 6.53,68.18 4.58,68.18 v2(4.18,68.58) ; v2(10.78,92.49) 10.78,93.08 13,95.3 13,98.97 16.17,102.13 16.17,103.28 16.94,104.05 v2(16.94,104.34)
  IN2 w0.122: v2(10.78,92.49) 10.47,92.8 9.59,92.8 8.85,92.06 8.3,92.06 7.21,90.97 7.21,89.64 5.97,88.39 5.97,87.36 5.34,86.74 4.99,86.74 3.82,85.56 3.82,81.1 3.73,81.01 3.73,80.65 3.8,80.58 3.8,71.11 4.24,70.67 4.24,68.65 v2(4.18,68.58)
  BOTTOM w0.112: v2(16.94,104.34) 16.98,104.3 29.47,104.3 30.28,103.49 49.03,103.49 52.41,100.12 52.83,100.12 53.53,99.42 57.86,99.42 59.13,100.68 72.18,100.68 74.95,97.92 78.34,97.92 79.83,99.4 89.85,99.4 90.18,99.74 97.42,99.74 98.62,100.94 114.29,100.94 117.62,104.27 123.66,104.27 125.3,105.91 127.62,105.91 130.16,108.45 132.45,108.45 133.37,107.53 136.26,107.53 136.53,107.26 142.2,107.26 143.31,107.72 143.59,108 143.59,109.28 143.81,109.5 146.02,109.5 146.51,109.01 146.51,108.02 150.97,103.56 158.45,103.56 159.78,104.11 161.44,105.77 161.44,108.61 160.74,109.32 160.74,111.1 v2(160.15,111.68)
P3V3_M2I_EN_R: length 2.6
  TOP w0.112: U50.3 181.66,143.34 v2(181.32,143.69) 180.84,144.17 R2951.1
P3V3_M2I_L: length 28.7
  TOP w0.254: R4131.1 v2(129.5,145.68) ; R4130.1 v2(127.6,145.67)
  IN1 w0.381: v2(123.31,136.58) 123.25,136.64 121.48,136.64 121.21,136.9 v2(118.33,136.9)
  BOTTOM w0.203: R3708.1 107.58,115.13 107.46,115.01 R3710.1
  BOTTOM w0.381: v2(129.5,145.68) 129.49,145.67 v2(127.6,145.67) 126.64,145.67 125.47,144.5 123.45,144.5 122.52,143.57 122.52,140.08 121.87,139.43 121.87,138.27 123.31,136.84 v2(123.31,136.58) ; 119.13,134.21 119.13,134.35 118.86,134.63 118.86,136.37 v2(118.33,136.9)
  vias: v3(103.95,126.22) v3(112.67,121.54)
P3V3_M2I_SR: length 10.2
  BOTTOM w0.112: U31.7 109.41,116.08 109.15,116.35 109.15,117.87 110.17,118.89 111.56,118.89 112.03,119.37 112.68,119.37 v3(113.31,118.74) 113.31,117.93 113.59,117.66 C274.1
P3V3_M2J: length 17.5
  IN2 w0.254: v2(79.58,112.06) 79.91,112.06 80.17,112.32 80.17,116.73 v2(79.61,117.29)
  BOTTOM w0.203: R3702.1 80.33,114.32 81.67,114.32 81.93,114.06 R3701.2 ; U81.D1 73.3,114.59 74.34,115.63 75.66,115.63 76.69,116.66 v3(76.69,117.39) 79.51,117.39 v2(79.61,117.29)
P3V3_M2J_EN: length 311.1
  TOP w0.112: U86.T1 46.17,48.23 46.68,48.23 47.66,49.21 47.66,52.69 50.41,55.43 v2(52.52,55.43) ; R2952.2 177.75,139.96 176.43,138.65 176.43,132.6 172.32,128.49 171.5,128.49 169.99,126.98 169.99,121.65 167.47,119.13 167.47,114.68 165.89,113.1 164.24,112.42 162.06,111.98 160.43,111.31 160.04,110.91 154.86,110.91 153.61,109.66 149.58,109.66 149.21,109.51 148.75,109.04 146.59,109.04 145.81,109.82 143.88,109.82 143.31,109.25 143.31,108.54 142.96,108.19 142.96,107.78 142.45,107.27 138.37,107.27 137.35,106.25 133.86,106.25 133.49,106.1 132.77,105.38 131.98,105.05 129.29,105.05 128.24,106.1 123.24,106.1 123,106.34 119.87,106.34 119.48,105.95 115.86,105.95 v2(115.74,106.07) ; v2(7.06,88.19) 6.56,87.69 4.95,87.69 4.35,87.09 U99.5
  IN1 w0.122: v2(52.52,55.43) 52.52,58.66 51.46,59.72 50.52,59.72 49.27,60.97 46.83,60.97 45.22,62.57 42.68,62.57 42.25,63 36.04,63 34.71,64.34 25.51,64.34 24.69,65.15 10.16,65.15 6.64,68.68 v2(5.18,68.68)
  IN2 w0.122: v2(16.91,108.22) 14.39,105.7 14.39,104.99 12.44,103.04 12.44,101.63 13.11,100.97 13.11,94.06 9.07,90.03 8.49,90.03 8.08,89.61 8.08,89.2 v2(7.06,88.19) 6.83,87.96 6.83,86.24 6.35,85.76 6.35,85.04 6.03,84.71 5.3,84.71 4.75,84.17 4.75,81.53 5.05,81.23 5.05,79.69 4.95,79.58 4.95,78.35 5.2,78.09 5.2,76.77 4.7,76.27 4.7,73.69 5.36,73.03 5.36,68.86 v2(5.18,68.68)
  BOTTOM w0.112: v2(115.74,106.07) 114.19,104.51 108.07,104.51 107.23,103.67 97.8,103.67 96.92,102.8 89.51,102.8 88.82,102.11 74.71,102.11 73.61,103.2 58.32,103.2 56.89,101.76 54.51,101.76 53.02,103.25 52.59,103.25 50.01,105.84 31.25,105.84 30.45,106.64 23.06,106.64 22.33,107.38 19.66,107.38 18.83,108.22 v2(16.91,108.22)
P3V3_M2J_EN_R: length 2.3
  TOP w0.112: R2952.1 181.26,140.76 v2(181.5,141) 181.89,141.39 U50.6
P3V3_M2J_L: length 21
  IN2 w0.381: v2(74.76,139.43) 74.76,140.88 71.87,143.77 71.87,144.44 v2(72.52,145.09) v2(74.19,145.09)
  BOTTOM w0.203: R3703.1 80.24,114.68 81.63,114.68 81.93,114.98 R3701.1
  BOTTOM w0.254: R4134.1 v2(72.52,145.09) ; R4135.1 v2(74.19,145.09)
  BOTTOM w0.381: 76.83,133.54 75.72,133.54 74.76,134.51 v2(74.76,139.43)
  vias: v3(84.56,122.93) v3(92.8,123.93)
P3V3_M2J_SR: length 8.8
  BOTTOM w0.112: U30.7 83.77,118.07 84.51,118.81 86.61,118.81 v3(86.95,118.46) 87.23,118.18 88.81,118.18 88.94,118.05 C271.1
P3V3_M2K: length 14.3
  IN2 w0.203: v2(54.88,113.24) 54.53,113.24 54.19,113.58 54.19,116.82 v2(54.07,116.94)
  BOTTOM w0.203: U80.D1 48.66,115.68 49.58,116.6 53.74,116.6 v2(54.07,116.94) ; R3695.1 55.67,115.08 57.61,115.08 57.8,114.88 R3694.2
  vias: v3(54.83,110.8)
P3V3_M2K_EN: length 316.7
  TOP w0.112: U100.1 8.78,95.25 v2(9.36,95.83) ; R2953.2 179.08,138.96 176.94,136.83 176.94,131.69 172.45,127.2 171.19,127.2 170.38,126.39 170.38,120.81 168.47,118.9 168.42,118.9 167.86,118.34 167.86,114.52 166.11,112.77 163.31,111.61 162.18,111.61 160.75,111.01 160.25,110.52 155.02,110.52 153.77,109.27 149.69,109.27 149.42,109.16 148.91,108.65 146.42,108.65 145.65,109.43 144.04,109.43 143.7,109.09 143.7,108.38 143.35,108.03 143.35,107.62 142.61,106.88 138.53,106.88 137.51,105.86 133.97,105.86 133.75,105.77 133.02,105.04 132.11,104.66 129.07,104.66 128.04,105.69 123.07,105.69 122.81,105.95 120.07,105.95 119.47,105.34 v2(115.75,105.34) ; v5(43.93,47.88) 44.03,47.98 44.71,47.98 44.75,47.94 U86.R3
  IN1 w0.122: v2(3.8,69.48) 3.83,69.48 3.9,69.54 6.99,69.54 7.05,69.48 7.08,69.48 10.54,66.02 25.05,66.02 25.87,65.2 35.07,65.2 36.4,63.87 42.61,63.87 43.04,63.44 45.58,63.44 47.18,61.83 50.74,61.83 v2(51.25,61.32)
  IN2 w0.122: v2(13.92,107.93) 13.92,107.02 13.23,106.33 13.23,105.18 11.37,103.32 11.37,99.8 11.85,99.31 11.85,96.63 11.73,96.5 10.7,96.5 10.03,95.83 v2(9.36,95.83) 6.99,93.45 6.99,92.04 6.35,91.41 6.35,90.27 5.36,89.28 5.27,89.28 4.04,88.05 4.04,86.39 3.39,85.74 3.31,85.13 3.31,79.63 3.37,79.56 3.37,69.91 v2(3.8,69.48)
  BOTTOM w0.112: v2(13.92,107.93) 14.05,107.8 16.59,107.8 17.04,107.35 18.82,107.35 19.18,106.99 22.16,106.99 22.9,106.25 30.29,106.25 31.09,105.45 49.84,105.45 52.43,102.86 52.86,102.86 54.35,101.37 57.05,101.37 58.49,102.81 72.82,102.81 75.76,99.87 77.41,99.87 78.9,101.36 89.04,101.36 89.92,102.23 96.92,102.23 97.67,102.99 113.39,102.99 v2(115.75,105.34) ; v2(51.25,61.32) 50.52,60.58 50.52,54.53 47.59,51.61 47.59,49.81 45.74,47.95 44,47.95 v5(43.93,47.88)
P3V3_M2K_EN_R: length 6.2
  TOP w0.112: R2953.1 183.64,138.99 183.99,139.34 184.05,139.34 v2(184.86,140.15) 186.1,141.39 186.77,141.39 187.43,140.74 U50.8
P3V3_M2K_L: length 38.2
  IN1 w0.381: v2(67.54,144.17) 67.51,144.14 v2(65.93,144.14) 64.63,144.14 62.8,142.31 59.72,142.31 59.08,142.96 50.73,142.96 v2(50.41,143.28)
  BOTTOM w0.203: R3694.1 57.8,115.64 57.6,115.43 55.47,115.43 R3696.1
  BOTTOM w0.254: R4139.1 67.16,144.99 67.54,144.61 v2(67.54,144.17) ; v2(65.93,144.14) 65.93,144.4 R4138.1
  BOTTOM w0.381: v2(50.41,143.28) 49.76,142.63 49.76,134.25 50.79,133.22 J6.B74
  vias: v3(56.74,121.45) v3(67.93,120.12)
P3V3_M2K_SR: length 10.3
  BOTTOM w0.112: C269.1 65.87,117.68 63.87,117.68 62.64,118.91 60.36,118.91 v3(59.85,118.4) 59.34,117.88 59.34,116.34 59.58,116.09 U29.7
P3V3_M2L: length 16.4
  IN1 w0.203: v2(31.22,118.14) 31.22,114.94 v2(31.52,114.63)
  BOTTOM w0.203: v2(31.22,118.14) 31.09,118.26 29.42,118.26 v3(28.76,117.61) 27.81,117.61 25.71,115.51 U79.D1 ; R3670.1 32.28,116.46 34.42,116.46 34.62,116.26 R3669.2 34.62,114.89
  vias: v3(32.35,114.09)
P3V3_M2L_EN: length 343
  TOP w0.112: U100.5 4.59,96.75 4.7,96.86 4.7,99.31 v2(5.04,99.65) ; v2(53.03,55.89) 50.27,55.89 47.27,52.89 47.27,49.18 46.67,48.57 46.31,48.57 46.14,48.75 45.76,48.75 U86.T2 ; v2(118.6,107.46) 118.29,107.15 118.29,106.69 118.64,106.34 119.24,106.34 119.63,106.73 123.16,106.73 123.4,106.49 128.59,106.49 129.64,105.44 131.88,105.44 132.55,105.72 133.28,106.45 133.74,106.64 136.81,106.64 140.38,110.21 146.33,110.21 147.11,109.43 148.54,109.43 148.95,109.84 149.46,110.05 153.45,110.05 154.7,111.3 159.07,111.3 160.07,112.31 162.35,113.25 163.74,114.64 163.74,114.87 166.69,117.83 166.69,120.08 168.07,121.46 168.07,127.36 173.08,132.36 173.08,139.56 179.65,146.13 191.27,146.13 191.9,145.5 191.9,144.07 191.43,143.6 R2954.2
  IN1 w0.122: v2(4.02,66.84) 3.73,67.12 3.73,68.77 4.09,69.12 6.81,69.12 10.34,65.58 24.87,65.58 25.69,64.77 34.89,64.77 36.22,63.44 42.43,63.44 42.86,63 45.4,63 47,61.4 49.44,61.4 50.67,60.18 51.61,60.18 53.03,58.76 v2(53.03,55.89)
  IN2 w0.122: v2(4.02,66.84) 3.5,66.84 1.4,68.94 1.4,86.03 2.71,87.35 2.71,91.52 3.1,91.9 3.1,97.64 5.04,99.58 v2(5.04,99.65) 5.04,100.52 5.76,101.23 5.76,103.08 7.58,104.9 7.58,106 9.93,108.35 v2(10.66,108.35)
  BOTTOM w0.112: v2(118.6,107.46) 118.59,107.46 113.73,102.59 97.83,102.59 96.89,101.65 89.89,101.65 89.2,100.97 79.06,100.97 77.57,99.48 75.6,99.48 72.66,102.42 58.65,102.42 57.21,100.98 54.18,100.98 52.69,102.47 52.27,102.47 49.68,105.05 30.93,105.05 30.12,105.86 22.74,105.86 22.47,106.13 17.64,106.13 16.48,107.29 12.79,107.29 11.73,108.35 v2(10.66,108.35)
P3V3_M2L_EN_R: length 4.2
  TOP w0.112: U50.11 189.85,142.69 190.38,142.16 v1(190.81,142.16) 190.81,143.03 R2954.1
P3V3_M2L_L: length 4.2
  BOTTOM w0.203: 34.62,118.33 R3669.1 34.62,117.04 34.42,116.84 32.18,116.84 R3671.1
  vias: v3(40.67,121.28) v3(46.17,121.86)
P3V3_M2L_SR: length 7.2
  TOP w0.112: v2(37.27,119.78) 37.37,119.89 38.45,119.89 38.8,119.53 v1(39.23,119.53) 39.69,119.53 40.18,120.02 v2(41.71,120.02)
  BOTTOM w0.112: v2(37.27,119.78) 36.99,119.51 U28.7 ; C266.1 v2(41.71,120.02)
P3V3_OR_M2A_EN: length 46.7
  TOP w0.112: U19.11 24.06,117.79 23.84,118.01 22,118.01 v2(21.89,118.12)
  IN1 w0.122: v2(12.53,92.73) 14.06,94.26 14.06,97.04 16.22,99.2 16.22,100.02 21.56,105.36 21.56,110.03 21.64,110.11 21.64,112.48 22.81,113.65 22.81,114.65 21.87,115.59 21.87,116.35 22.16,116.63 22.16,117.49 v2(21.89,118.12)
  IN2 w0.122: v2(12.53,92.73) 8.56,88.76 8.56,87.53 7.26,86.23 7.26,85.88 6.86,85.47 6.86,84.87 v2(5.23,83.24)
  BOTTOM w0.112: v2(5.23,83.24) 4.73,83.24 4.57,83.07 R4077.2
P3V3_OR_M2A_EN_R: length 3.4
  TOP w0.112: U95.7 v2(1.85,82.92)
  BOTTOM w0.112: v2(1.85,82.92) 2,83.07 R4077.1
P3V3_OR_M2B_EN: length 76.2
  TOP w0.112: U20.11 48.77,117.4 48.52,117.64 46.59,117.64 46.44,117.79 v2(46.29,117.79)
  IN1 w0.122: v2(46.29,117.79) 46.44,117.79 47.2,117.03 47.2,116.33 47.8,115.73 48.2,114.75 48.2,112.74 47.83,111.83 47.11,111.11 47.11,104.38 47.13,104.36 v2(47.13,101.73) ; v2(16.66,103.1) 16.68,103.08 16.68,101.26 15.79,100.37 15.79,99.43 13.52,97.17 13.52,95.1 v2(11.32,92.9)
  BOTTOM w0.112: v2(11.32,92.9) 11.32,92.19 10.22,91.09 10.22,88.71 9.39,87.88 9.39,86.27 8.5,85.38 8.5,83.59 8.17,83.26 7.54,83.26 R4078.2 ; v2(47.13,101.73) 45.7,101.73 44.72,102.71 29.96,102.71 29.16,103.51 17.07,103.51 v2(16.66,103.1)
P3V3_OR_M2B_EN_R: length 3.6
  TOP w0.112: v2(5.21,82.48) 6.15,83.42 U95.3
  BOTTOM w0.112: v2(5.21,82.48) R4078.1
P3V3_OR_M2C_EN: length 101.6
  TOP w0.112: v2(71.25,116.58) 71.27,116.56 73.46,116.56 73.68,116.34 U21.11
  IN1 w0.122: v2(63.78,86.73) 63.78,87.71 66.1,90.03 66.1,91.12 71.28,96.31 71.28,105.26 71.53,105.85 71.53,110.43 71.18,111.26 71.18,115.12 70.78,115.52 70.78,116.1 v2(71.25,116.58)
  BOTTOM w0.112: R4079.2 5.11,75.46 7.29,75.46 8.6,76.77 9.82,76.77 10.08,76.51 12.76,76.51 13.6,75.67 16.06,75.67 16.42,76.02 16.42,76.41 17.1,77.1 17.45,77.1 17.81,77.45 19.77,77.45 20.85,78.54 31.07,78.54 v3(32.06,79.53) 32.41,79.88 43.23,79.88 48.45,85.1 57.04,85.1 57.38,85.44 62.49,85.44 v2(63.78,86.73)
P3V3_OR_M2C_EN_R: length 5.4
  TOP w0.112: v2(4.86,72.87) 3.82,73.91 U96.7
  BOTTOM w0.112: R4079.1 4.86,73.79 v2(4.86,72.87)
P3V3_OR_M2D_EN: length 140.4
  TOP w0.112: v2(97.24,117.4) 97.26,117.37 98.87,117.37 99.08,117.17 U22.11 ; v2(7.31,79.33) 7.85,78.79 7.85,77.86 7.54,77.54 v2(4.67,77.54)
  IN1 w0.122: v2(80.88,82.78) 93.62,95.52 96.49,95.52 98.67,97.7 98.67,101.35 98.22,101.8 98.22,104.53 97.96,105.84 97.96,108.28 98.08,108.4 98.08,114.59 97.57,115.1 97.57,117.07 v2(97.24,117.4)
  BOTTOM w0.112: R4080.2 1.96,77.65 2.33,77.27 3.34,77.27 3.61,77.54 v2(4.67,77.54) ; v2(7.31,79.33) 7.52,79.53 10.36,79.53 11.93,81.1 11.93,81.42 13.29,82.79 15.38,82.79 15.95,82.22 16.58,82.22 17.34,81.46 27.12,81.46 29.21,83.56 32.69,83.56 34.4,85.26 35.86,85.26 37.85,87.25 39.24,87.25 41.2,89.21 42.81,89.21 43.1,89.49 46.17,89.49 47.98,87.68 61.3,87.68 63.15,89.52 67.84,89.52 69.23,88.13 77.99,88.13 80.88,85.24 v2(80.88,82.78)
P3V3_OR_M2D_EN_R: length 4.9
  TOP w0.112: v2(1.87,81.07) 2.73,81.07 3.32,80.48 U96.3
  BOTTOM w0.112: v2(1.87,81.07) 1.4,80.6 1.4,79.95 R4080.1
P3V3_OR_M2E_EN: length 170
  TOP w0.112: U23.11 123.03,117.2 122.98,117.33 122.81,117.49 121.72,117.49 121.54,117.31 120.42,117.31 119.88,116.78 117.75,116.78 117.36,116.38 115.82,116.38 115.53,116.09 v2(115.53,107.63)
  IN1 w0.122: v2(5.19,89.74) 7.97,89.74 8.25,90.02 13.19,90.02 16.53,93.36 19.25,93.36 24.94,99.05 v2(25.2,99.05) ; v2(91.47,75.9) 95.63,80.06 103.37,80.06 116,92.69 116,104.53 116.19,104.72 116.19,106.29 115.71,107.44 v2(115.53,107.63)
  BOTTOM w0.112: v2(25.2,99.05) 35.92,99.05 38.68,96.28 59.44,96.28 60.71,97.55 69.6,97.55 73.03,94.12 80.62,94.12 91.47,83.28 v2(91.47,75.9) ; v2(5.19,89.74) 4.75,89.74 4.59,89.58 R4081.2
P3V3_OR_M2E_EN_R: length 3.5
  TOP w0.112: U97.7 3.18,89.43 2.49,90.12 v2(2.06,90.12)
  BOTTOM w0.112: R4081.1 3,89.58 2.46,90.12 v2(2.06,90.12)
P3V3_OR_M2F_EN: length 207.2
  TOP w0.112: v2(13.34,92.86) 12.65,93.55 R4082.2 ; U24.11 150.62,116.71 150.44,116.88 148.62,116.88 148.47,117.03 v2(147.28,117.03)
  IN1 w0.122: v2(147.28,117.03) 147.76,117.03 148.13,116.66 148.13,110.84 147.74,110.45 147.74,105.21 108.23,65.69 102.02,65.69 98.57,62.24 98.34,62.24 97.68,61.57 96.91,61.57 94.13,58.8 v2(94.1,58.8) ; v2(25.2,99.82) 25.08,99.82 19.07,93.8 16.13,93.8 15.19,92.86 v2(13.34,92.86)
  BOTTOM w0.112: v2(94.1,58.8) 94.1,81.2 80.79,94.52 73.19,94.52 69.76,97.95 60.55,97.95 59.28,96.67 47.18,96.67 43.26,100.59 34.85,100.59 33.79,99.53 25.49,99.53 v2(25.2,99.82)
P3V3_OR_M2F_EN_R: length 6.3
  TOP w0.112: U97.3 8.12,89.93 v1(8.96,90.77) 9.14,90.96 9.14,91.85 9.86,92.56 9.86,93.09 10.31,93.55 R4082.1
P3V3_OR_M2G_EN: length 191.6
  TOP w0.112: v2(165.51,119.53) 166.17,118.87 166.17,117.88 163.34,115.05 163.34,114.79 162.13,113.58 159.85,112.64 158.91,111.69 154.54,111.69 153.29,110.44 149.35,110.44 148.75,110.19 148.38,109.82 147.27,109.82 146.49,110.6 140.22,110.6 136.65,107.04 133.55,107.04 132.99,106.8 132.31,106.12 132.04,106.01 129.71,106.01 128.82,106.91 125.45,106.91 125.32,107.04 123.41,107.04 123.32,107.12 119.17,107.12 v2(118.82,106.78)
  IN2 w0.122: v2(12.17,107.08) 12.17,106.49 11.39,105.71 10.62,105.71 9.73,104.81 9.73,100.26 7.59,98.13 7.59,97.23 6.68,96.32 6.68,95.68 5.88,94.88 5.88,94.32 5.52,93.96 v2(5.52,93.19)
  BOTTOM w0.112: v2(118.82,106.78) 118.47,106.78 113.89,102.2 97.99,102.2 96.94,101.15 89.94,101.15 89.36,100.58 79.27,100.58 77.78,99.09 75.43,99.09 72.5,102.03 58.81,102.03 57.37,100.59 54.02,100.59 52.53,102.08 52.1,102.08 49.52,104.66 30.77,104.66 29.96,105.47 22.58,105.47 22.31,105.74 17.43,105.74 16.28,106.89 12.36,106.89 v2(12.17,107.08) ; v2(5.52,93.19) 5.07,92.74 R4083.2 ; v2(165.51,119.53) 165.12,119.91 163.22,119.91 163,119.7 U33.11
P3V3_OR_M2G_EN_R: length 3.2
  TOP w0.112: v2(2.03,92.74) 2.18,92.74 2.33,92.59 U98.7
  BOTTOM w0.112: v2(2.03,92.74) R4083.1
P3V3_OR_M2H_EN: length 165.8
  TOP w0.112: v2(121.13,108.99) 121.37,108.99 122.75,107.61 123.84,107.61 124.03,107.43 126.12,107.43 126.23,107.32 127.56,107.32 127.67,107.43 129.41,107.43 129.74,107.1 132.65,107.1 133.43,107.43 136.35,107.43 139.34,110.42 139.34,116.03 139.8,116.48 140.89,116.48 v2(141.06,116.66)
  IN2 w0.122: v2(9.83,96.42) 9.17,97.08 9.17,98.37 10.87,100.08 10.87,103.48 12.65,105.26 v2(12.65,105.4)
  BOTTOM w0.112: v2(12.65,105.4) 13.4,104.65 14.09,104.65 14.49,105.05 14.49,105.57 14.92,106 15.37,106 16.55,104.82 v3(18.73,104.82) 22.13,104.82 22.25,104.69 29.64,104.69 30.44,103.88 49.2,103.88 52.52,100.55 52.95,100.55 53.7,99.81 57.7,99.81 59.13,101.25 72.17,101.25 75.11,98.31 78.18,98.31 79.66,99.79 89.69,99.79 90.09,100.2 97.09,100.2 98.32,101.42 114.21,101.42 118.75,105.95 119.17,105.95 121.13,107.91 v2(121.13,108.99) ; v2(141.06,116.66) 140.89,116.48 139.54,116.48 139.1,116.92 135.4,116.92 135.26,116.79 U32.11 ; v2(9.83,96.42) 9.14,96.42 R4084.2
P3V3_OR_M2H_EN_R: length 4.8
  TOP w0.112: U98.3 6.23,93.09 5.99,93.32 5.99,94.01 v2(6.6,94.61)
  BOTTOM w0.112: v2(6.6,94.61) 6.6,95.48 7.04,95.91 R4084.1
