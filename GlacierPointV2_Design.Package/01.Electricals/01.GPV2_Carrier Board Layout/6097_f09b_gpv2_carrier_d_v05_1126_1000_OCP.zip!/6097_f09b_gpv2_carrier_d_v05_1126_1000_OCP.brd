# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
JTAG_PESW_TDO: length 260.9
  TOP w0.112: U34.AG33 v6(197.59,72.02) ; v2(10.88,99.28) 11.09,99.49 11.09,100.7 10.83,100.97 R3264.2 R3266.1
  IN2 w0.122: v6(197.59,72.02) 197.17,72.44 194.42,72.44 194.11,72.13 194.11,70.79 193.8,70.48 193.17,70.48 192.2,69.52 191.44,69.52 191.06,69.14 191.06,61.86 190.23,61.03 182.8,61.03 178.94,57.17 173.46,54.9 170.53,51.97 168.44,51.11 164.57,51.11 163.47,50.01 104.75,50.01 93.94,45.53 93.55,45.14 93.55,44.68 92.96,44.09 92.18,44.09 v2(90.58,42.49)
  BOTTOM w0.112: v2(90.58,42.49) 89.57,43.5 89.57,46.99 90.3,47.72 90.3,58.24 92.14,60.08 92.14,72 88.2,75.93 88.2,84 80.01,92.18 72.42,92.18 68.85,95.75 61.46,95.75 60.19,94.48 37.71,94.48 35.76,96.43 32.08,96.43 31.77,96.11 31.46,96.11 29.87,94.52 29.87,94.43 27.97,92.53 16.35,92.53 13.91,94.98 13.91,96.25 v2(10.88,99.28)
JTAG_PESW_TDO_R: length 4
  TOP w0.112: J47.4 7.67,103.64 v2(8.68,102.63) 9.28,102.03 R3266.2
JTAG_PESW_TMS: length 258.1
  TOP w0.112: U34.AG27 v6(191.59,72.02) ; J47.5 7.58,103.14 8.03,102.69 8.03,101.15 v2(7.34,100.47)
  IN2 w0.122: v2(90.01,44.78) 90.01,45.5 90.59,46.09 103.17,51.3 158.69,51.3 159.85,52.46 167.93,52.46 169.48,53.1 172.13,55.75 177.54,58 182.16,62.61 184.09,62.61 185.12,63.65 185.12,68.17 185.56,68.6 187.72,68.6 188.09,68.97 188.09,71.34 188.29,71.55 191.12,71.55 v6(191.59,72.02)
  BOTTOM w0.112: v6(191.59,72.02) 191.74,72.02 192.35,72.63 R3272.2 ; v2(7.34,100.47) 8.33,101.45 9.43,101.45 14.27,96.61 14.27,95.09 16.08,93.29 v3(16.34,93.29) 16.76,92.87 27.17,92.87 28.63,94.33 28.63,94.42 30.68,96.47 31.59,96.47 31.89,96.77 35.9,96.77 37.85,94.82 60.05,94.82 61.32,96.09 68.99,96.09 72.42,92.66 80.02,92.66 88.64,84.04 88.64,76 92.48,72.16 92.48,59.92 90.65,58.09 90.65,45.43 v2(90.01,44.78)
JTAG_PESW_TRSTB: length 261.9
  TOP w0.112: J47.2 7.8,104.64 8.4,105.24 R3265.1 9.43,104.93 9.63,104.72 10.99,104.72 11.9,103.82 11.9,98.3 11.71,98.1 11.71,97.45 v2(11.24,96.98) ; U34.AG28 v6(192.59,72.02)
  IN2 w0.122: v2(88.31,44.42) 88.66,44.07 89.99,44.07 90.48,44.56 90.48,45.26 90.88,45.67 103.44,50.87 162.78,50.87 163.92,52.01 168.17,52.01 169.81,52.68 172.61,55.48 177.83,57.64 182.2,62.02 185.63,62.02 186.14,62.53 186.14,67.34 186.32,67.52 188.73,67.52 189.14,67.93 189.14,70.27 189.44,70.56 190.01,70.56 190.41,70.96 191.53,70.96 v6(192.59,72.02)
  BOTTOM w0.112: v2(11.24,96.98) 12.97,95.24 12.97,94.95 16.07,91.85 29.45,91.85 33.35,95.75 35.48,95.75 37.43,93.8 60.47,93.8 61.74,95.07 68.57,95.07 72.14,91.5 79.73,91.5 87.19,84.05 87.19,75.96 91.46,71.69 91.46,60.42 89.33,58.29 89.33,47.83 88.31,46.81 v2(88.31,44.42)
JTAG_TI_TCK: length 6.9
  TOP w0.112: J56.4 6.5,31.27 6.63,31.14 8.08,31.14 8.5,31.57 R3882.2 9.8,31.8 v1(9.85,31.76) 9.91,31.7 R3878.2
JTAG_TI_TCK_R: length 37.5
  TOP w0.089: U86.B15 38.95,41.34 38.94,41.33 38.94,39.88 38.67,39.61
  TOP w0.112: v2(36.44,38.17) 37.22,38.94 38,38.94 38.67,39.61 ; R3878.1 10.71,31.13 11.38,31.8 14.33,31.8 v2(14.94,31.19)
  BOTTOM w0.112: v2(14.94,31.19) 15.39,30.73 17.36,30.73 18.26,29.84 28.12,29.84 29.21,30.29 29.44,30.52 32.2,30.52 35.22,33.55 35.22,34.96 35.67,35.41 35.67,35.96 35.76,36.04 35.76,37.48 v2(36.44,38.17)
JTAG_TI_TDI: length 7.3
  TOP w0.112: R3879.2 9.88,29.6 9,30.48 R3883.2 8.53,29.54 v1(8.23,29.24) 6.58,29.24 5.55,30.27 J56.3
JTAG_TI_TDI_R: length 44.7
  TOP w0.112: v2(12.04,26.01) 11.2,26.85 11.2,28.04 10.68,28.57 R3879.1 ; U86.D14 39.64,42.63 39.64,43.11 39.97,43.43 v6(40.1,43.43)
  BOTTOM w0.112: v6(40.1,43.43) 40.1,43.08 39.45,42.44 39.45,39.8 38.63,38.97 38.63,36.21 37.54,35.12 37.54,34.89 36.93,34.28 36.93,33.81 31.63,28.51 29.46,28.51 29.12,28.37 28.3,27.56 27.26,27.56 26.66,28.15 17.16,28.15 15.02,26.01 v2(12.04,26.01)
JTAG_TI_TDO: length 40.4
  TOP w0.112: v2(6.07,28.6) 6.07,28.68 5.48,29.27 J56.2
  BOTTOM w0.112: R3880.2 38.12,36.37 37.27,35.51 36.92,35.51 36.55,35.13 36.55,33.91 31.49,28.86 29.35,28.86 28.49,28.5 17.03,28.5 15.18,26.65 6.89,26.65 6.01,27.53 6.01,28.54 v2(6.07,28.6)
JTAG_TI_TDO_R: length 6.9
  TOP w0.112: v6(39.23,42.89) 39.11,42.77 39.11,42.28 U86.C14
  BOTTOM w0.112: v6(39.23,42.89) 39.2,42.85 39.2,41.97 39.03,41.81 39.03,40.2 v3(38.34,39.5) 38.12,39.29 R3880.1
JTAG_TI_TMS: length 6.3
  TOP w0.112: R3881.2 R3884.2 7.72,27.1 v2(5.56,27.1) 5.56,27.79 5.08,28.27 J56.1
JTAG_TI_TMS_R: length 39.1
  TOP w0.112: v2(10.64,27.25) 10.64,27.28 10.53,27.39 R3881.1 ; v6(38.63,42.34) 38.74,42.24 38.74,42.16 U86.C15
  BOTTOM w0.112: v6(38.63,42.34) 38.63,40.59 37.55,39.51 37.55,36.81 35.56,34.82 35.56,33.41 31.35,29.2 29.28,29.2 28.41,28.84 16.85,28.84 15,26.99 11.57,26.99 11.3,27.25 v2(10.64,27.25)
LATCH_DETECT: length 21.3
  TOP w0.112: R3054.1 66.45,24.53 64.79,22.87 64.79,17.86 v1(63.37,16.44) 59.2,12.27 v2(59.2,11.09)
  BOTTOM w0.112: v2(59.2,11.09) 58.9,10.78 J41.53
LATCH_DETECT_BUFFER: length 4.3
  TOP w0.112: U54.6 72.34,26.06 72.46,26.17 v2(72.46,27.45) 72.46,27.83 72.59,27.96 U54.3
LATCH_DETECT_R: length 4.9
  TOP w0.112: R3054.2 67.25,27.65 67.81,28.21 v1(68.56,28.21) 68.81,27.96 U54.4
LATCH_DETECT_SW: length 202.1
  TOP w0.112: U54.1 76.23,26.06 C806.1 R3055.2 76.26,31.67 78.67,34.08 80.35,34.78 v2(83.57,38) ; v2(148.18,110.26) 148.5,110.58 149.12,110.84 153.12,110.84 154.37,112.09 158.74,112.09 159.63,112.97 161.91,113.91 162.95,114.95 162.95,115.23 164.31,116.59 164.31,117.81 165.06,118.56 165.06,120.38 167.61,122.94 167.61,128.21 168.42,129.01 v2(168.42,131.06) 168.42,133.16 169.63,134.38 169.63,139.16 168.22,140.56 165.31,140.56 164.16,141.72 164.16,144.96 165.9,146.7 SW6.1
  IN1 w0.122: SW4.4 170.84,133.49 v2(168.42,131.06) ; v2(148.18,110.26) 148.2,110.24 148.2,105.06 108.41,65.27 102.85,65.27 98.27,60.69 96.93,60.69 96.45,60.49 94.29,58.32 94.24,58.3 91.04,58.3 90.41,57.67 80.94,57.67 72.98,49.71 v2(72.13,49.71)
  BOTTOM w0.112: v2(72.13,49.71) 72.13,45.11 79.21,38.03 83.54,38.03 v2(83.57,38)
LED_FM_BIC_DEBUG_EN: length 10.3
  TOP w0.112: v2(104.36,145.78) 106.28,143.85 108.56,143.85 108.71,144 109.7,144 109.83,143.87 Q24.6 109.83,143.21 110.44,142.6 v1(110.44,141.96)
  BOTTOM w0.112: D5.2 105.13,146.04 104.87,145.78 v2(104.36,145.78)
LED_FM_BIC_DEBUG_EN_R: length 14.9
  TOP w0.112: v1(106.09,141.28) 105.29,142.09 105.29,144.14 103.6,145.83 v2(103.54,145.83) 102.56,144.85 100.24,144.85 99.63,144.24 97.27,144.24 97.03,144.49 R3437.1
  BOTTOM w0.112: D5.1 103.33,146.04 v2(103.54,145.83)
LED_HB: length 1.8
  TOP w0.112: D3.A 207.81,109.1 v2(207.25,109.1) 206.73,108.58 R3269.2
LED_P12V: length 7.4
  TOP w0.508: v2(93.52,146.46) 93.62,146.36 R2875.1
  BOTTOM w0.508: v2(93.52,146.46) 94.01,146.94 D1.1
LED_PM_HB_D: length 2.8
  TOP w0.112: Q10.6 207.35,107.1 v2(207.28,107.17) 207.42,107.3 D3.C
M2A_LED: length 2.9
  TOP w0.112: R2840.2 21.68,124.35 J4.B10
M2A_VIO_CFG: length 5.8
  TOP w0.112: J4.B73 37.43,134.26 37.79,134.63 37.79,135.8 R4235.2 37.43,136.73 37.35,136.8 v1(35.2,136.8)
M2B_LED: length 2.8
  TOP w0.112: R2839.2 45.18,123.49 v2(45.18,124.06) 45.18,124.43 45.68,124.94 J4.A10
M2B_VIO_CFG: length 2.4
  TOP w0.112: J4.A73 R4237.2
M2C_LED: length 2.7
  TOP w0.112: J36.B10 69.68,124.51 v2(69.62,124.45) 69.25,124.08 R2895.2
M2C_VIO_CFG: length 12.4
  TOP w0.112: J36.B73 85.43,134.36 85.88,134.81 85.88,135.24 85.53,135.59 80.48,135.59 R4239.2 80.02,136.22 78.58,137.65 77.88,137.65 77.29,138.24 v1(77.29,138.81)
M2D_LED: length 2.7
  TOP w0.112: J36.A10 93.68,123.84 R2892.2
M2D_VIO_CFG: length 5.1
  TOP w0.112: J36.A73 109.43,134.48 109.56,134.61 109.56,135.96 R4241.2 110.69,137.09 v1(111.7,137.09)
M2E_LED: length 2.6
  TOP w0.112: R2901.2 v2(117.37,124.21) 117.68,124.51 J38.B10
M2E_VIO_CFG: length 2.8
  TOP w0.112: J38.B73 133.43,134.8 134.17,135.54 R4243.2
M2F_LED: length 3.1
  TOP w0.112: R2898.2 140.81,123.85 v2(140.81,124.24) 140.81,124.29 141.68,125.16 141.68,125.97 J38.A10
M2F_VIO_CFG: length 5.1
  TOP w0.112: R4245.2 157.2,136.9 v1(157.59,136.9) 157.59,135.56 157.43,135.4 J38.A73
M2G_LED: length 11.7
  BOTTOM w0.112: R2844.2 169.46,128.14 v3(169.83,128.51) 169.83,131.36 169.43,131.75 169.43,133.58 168.81,134.21 165.69,134.21 165.42,133.93 J8.B10
M2G_VIO_CFG: length 3.2
  BOTTOM w0.112: J8.B73 149.67,140.78 149.67,142.56 R4247.2
M2H_LED: length 16.9
  BOTTOM w0.112: J8.A10 141.42,135.18 141.54,135.3 142.1,135.3 142.1,135.36 143.51,136.77 145.77,136.77 145.97,136.57 145.97,132.81 146.44,132.35 146.44,131.04 146.32,130.93 145.71,130.93 144.97,130.19 144.97,128.75 144.86,128.64 R2843.2
M2H_VIO_CFG: length 6.7
  BOTTOM w0.112: J8.A73 125.67,144.07 125.81,144.21 126.45,144.21 v3(126.53,144.29) 126.78,144.04 127.65,144.04 128.11,144.51 R4249.2
M2I_LED: length 18.7
  BOTTOM w0.112: R2889.2 121.62,130.32 122.6,131.3 122.6,133.69 122.05,134.24 120.18,134.24 119.27,135.15 119.27,137.25 118.58,137.94 118.27,138.07 117.31,138.07 116.96,137.72 116.96,135.53 117.42,135.07 J34.B10
M2I_VIO_CFG: length 13.7
  TOP w0.112: v1(95.59,141.96) R4251.2 96.53,143.22 v2(96.56,143.18)
  BOTTOM w0.112: v2(96.56,143.18) 97,142.74 98.42,142.74 99.1,142.07 99.1,138.47 99.28,138.28 101.22,138.28 101.67,138.74 J34.B73
M2J_LED: length 20.2
  BOTTOM w0.112: J34.A10 93.42,134.1 92.82,134.69 92.82,135.07 93.51,135.76 94.54,135.76 95.97,134.33 98.12,134.33 98.49,133.96 98.49,131.47 97.46,130.44 97.46,129.5 98.01,128.95 v3(98.67,128.95) 98.91,128.71 98.91,126.89 97.38,125.36 R2886.2
M2J_VIO_CFG: length 2.8
  BOTTOM w0.112: J34.A73 77.67,141.85 76.95,142.57 R4253.2
M2K_LED: length 24.5
  BOTTOM w0.112: J6.B10 69.42,134.26 69.73,134.57 69.73,135.41 70.14,135.82 70.59,135.82 70.94,135.47 70.94,135.03 71.54,134.44 71.73,134.36 73.5,134.36 74.03,133.83 74.03,133.23 74.43,132.63 74.43,131.73 73.34,129.08 73.34,127.64 75.16,123.24 75.16,120.98 v3(74.29,120.11) 74.08,119.91 R2842.2
M2K_VIO_CFG: length 2.8
  BOTTOM w0.112: R4255.2 53.67,142.61 J6.B73
M2L_LED: length 3
  BOTTOM w0.112: J6.A10 45.42,132.26 46.36,131.33 R2841.2
M2L_VIO_CFG: length 8.7
  BOTTOM w0.112: J6.A73 29.67,142.42 29.43,142.66 29.43,143.69 R4257.2 28.05,142.73 26,142.73 v3(24.79,141.52)
Net_247: length 0.7
  TOP w0.112: v6(197.59,76.02) 197.09,76.52
Net_248: length 0.7
  TOP w0.112: v6(196.59,76.02) 196.09,76.52
Net_300: length 0.7
  BOTTOM w0.112: 21.45,48.65 v2(21.95,48.15)
Net_303: length 0.7
  BOTTOM w0.112: 21.45,47.65 v2(21.95,47.15)
Net_309: length 0.7
  BOTTOM w0.112: 9.45,50.65 v2(8.95,50.15)
Net_353: length 0.7
  TOP w0.112: 191.09,69.52 v6(191.59,69.02)
Net_354: length 0.7
  TOP w0.112: 192.09,69.52 v6(192.59,69.02)
Net_355: length 0.7
  TOP w0.112: 193.09,69.52 v6(193.59,69.02)
Net_356: length 0.7
  TOP w0.112: 194.09,69.52 v6(194.59,69.02)
Net_357: length 0.7
  TOP w0.112: 195.09,69.52 v6(195.59,69.02)
Net_358: length 0.7
  TOP w0.112: 196.09,69.52 v6(196.59,69.02)
Net_359: length 0.7
  TOP w0.112: 197.09,69.52 v6(197.59,69.02)
Net_361: length 0.7
  TOP w0.112: 195.09,81.52 v6(195.59,82.02)
Net_363: length 0.7
  TOP w0.112: 197.09,81.52 v6(197.59,82.02)
Net_364: length 0.7
  TOP w0.112: 197.09,82.52 v6(197.59,83.02)
Net_1190: length 0.7
  TOP w0.124: 188.09,63.52 v6(188.59,63.02)
Net_1191: length 0.7
  TOP w0.124: 188.09,62.52 v6(188.59,62.02)
Net_1192: length 0.7
  TOP w0.124: 187.09,64.52 v6(187.59,64.02)
Net_1193: length 0.7
  TOP w0.124: 187.09,63.52 v6(187.59,63.02)
Net_1194: length 0.7
  TOP w0.124: 186.09,63.52 v6(186.59,63.02)
Net_1195: length 0.7
  TOP w0.124: 186.09,62.52 v6(186.59,62.02)
Net_1196: length 0.7
  TOP w0.124: 185.09,64.52 v6(185.59,64.02)
Net_1197: length 0.7
  TOP w0.124: 185.09,63.52 v6(185.59,63.02)
Net_1206: length 0.7
  TOP w0.124: 188.09,66.52 v6(188.59,66.02)
Net_1207: length 0.7
  TOP w0.124: 188.09,65.52 v6(188.59,65.02)
Net_1208: length 0.7
  TOP w0.124: 187.09,67.52 v6(187.59,67.02)
Net_1209: length 0.7
  TOP w0.124: 187.09,66.52 v6(187.59,66.02)
Net_1210: length 0.7
  TOP w0.124: 186.09,66.52 v6(186.59,66.02)
Net_1211: length 0.7
  TOP w0.124: 186.09,65.52 v6(186.59,65.02)
Net_1212: length 0.7
  TOP w0.124: 185.09,67.52 v6(185.59,67.02)
Net_1213: length 0.7
  TOP w0.124: 185.09,66.52 v6(185.59,66.02)
Net_1214: length 0.7
  TOP w0.124: 184.09,66.52 v6(184.59,66.02)
Net_1215: length 0.7
  TOP w0.124: 184.09,65.52 v6(184.59,65.02)
Net_1216: length 0.7
  TOP w0.124: 183.09,67.52 v6(182.59,67.02)
Net_1217: length 0.7
  TOP w0.124: 183.09,66.52 v6(182.59,66.02)
Net_1218: length 0.7
  TOP w0.124: 182.09,66.52 v6(181.59,66.02)
Net_1219: length 0.7
  TOP w0.124: 182.09,65.52 v6(181.59,65.02)
Net_1220: length 0.7
  TOP w0.124: 181.09,67.52 v6(180.59,67.02)
Net_1221: length 0.7
  TOP w0.124: 181.09,66.52 v6(180.59,66.02)
OSC1_VDD: length 3.9
  TOP w0.112: OSC1.4 30.71,37.17 R3766.1 29.69,35.91 L14.1
OSC1_VDD_R:
  vias: v1(27.99,40.8)
P3E_1_PESW_RX0_C_DN: length 161.9
  TOP w0.124: C1070.2 178.83,55 178.83,54.67 178.09,53.93 177.91,53.93 177.65,53.67 177.65,53.49 177.39,53.23 177.21,53.23 176.94,52.96 176.94,52.78 176.4,52.24 166.39,48.09 161.98,47.22 153.9,43.87 148.36,46.17 143.9,45.28 140.67,45.92 137.49,45.29 134.32,45.92 129.55,44.97 121.61,46.56 105.01,44.32 97.25,44.32 95.28,43.51 86.78,43.51 86.12,43.24 79.08,36.19 68.7,31.9 63.08,31.9 61.3,31.54 57.42,29.93 50.27,22.79 49.77,21.58 49.77,20.17 49.5,18.81 48.53,16.47 48.37,16.4 47.9,16.59 47.5,16.43 47.16,15.6 47.32,15.21 47.79,15.01 47.86,14.84 44.72,7.26 44.72,6.88 v2(44.36,6.51)
  BOTTOM w0.124: v2(44.36,6.51) 44.71,6.15 44.71,5.98 44.74,5.75 44.74,5.6 44.5,5.35 J41.90
P3E_1_PESW_RX0_C_DP: length 161.9
  TOP w0.124: C1071.2 179.14,55 179.14,54.55 176.57,51.98 166.48,47.8 162.06,46.92 153.9,43.54 148.33,45.85 143.9,44.96 140.67,45.61 137.49,44.98 134.32,45.61 129.55,44.66 121.6,46.25 105.03,44.02 97.31,44.02 95.34,43.21 86.84,43.21 86.29,42.98 79.25,35.93 68.77,31.59 63.11,31.59 61.39,31.25 57.59,29.68 50.53,22.62 50.07,21.52 50.07,20.14 49.79,18.72 48.76,16.23 48.37,16.07 47.9,16.26 47.74,16.19 47.49,15.6 47.56,15.44 48.03,15.25 48.19,14.84 46.13,9.85 46.2,9.67 46.05,9.33 45.88,9.26 45.74,8.91 45.81,8.74 45.67,8.39 45.49,8.32 45.03,7.2 45.03,6.92 v2(45.37,6.51)
  BOTTOM w0.124: v2(45.37,6.51) 45.02,6.16 45.02,6 45.05,5.77 45.05,5.59 45.3,5.34 J41.88
P3E_1_PESW_RX0_DN: length 8.5
  TOP w0.099: 180,58.9 180,58.93 180.05,58.98 180.05,59.61 179.95,59.71 179.95,59.91 180.05,60.01 180.05,60.21 179.95,60.31 179.95,60.51 180.05,60.61 180.05,60.81 179.95,61.07 179.81,61.12 179.74,61.3 179.79,61.44 179.72,61.62 179.58,61.68 179.51,61.86 179.56,61.99 179.49,62.17 179.49,62.82 179.39,62.92 179.19,62.92 179.09,62.82 U34.AU15
  TOP w0.124: 180,58.9 180,58.62 179.06,57.67 178.83,57.13 178.83,56.51 C1070.1
P3E_1_PESW_RX0_DP: length 8.5
  TOP w0.099: U34.AT15 179.09,63.22 179.19,63.12 179.47,63.12 179.69,62.9 179.69,62.22 180.26,60.85 180.26,58.98 180.31,58.93 180.31,58.9
  TOP w0.124: 180.31,58.9 180.31,58.49 179.31,57.5 179.14,57.07 179.14,56.51 C1071.1
P3E_1_PESW_RX1_C_DN: length 161.3
  TOP w0.124: C1068.2 176.72,55 176.72,54.81 175.67,53.23 166.63,49.48 162.18,48.6 153.93,45.18 148.51,47.43 143.88,46.5 140.67,47.14 137.49,46.51 134.32,47.14 129.67,46.21 121.78,47.79 107.17,45.86 89.33,45.86 85.44,44.25 78.42,37.23 73.44,35.17 68.47,33.11 63,33.11 61,32.71 56.07,30.66 45.13,19.73 44.89,19.15 44.76,18.47 44.76,14.84 43.1,10.84 42.53,9.99 41.56,7.65 41.56,6.91 v2(41.18,6.53)
  BOTTOM w0.124: v2(41.18,6.53) 41.54,6.17 41.54,5.58 41.3,5.34 J41.98
P3E_1_PESW_RX1_C_DP: length 161.3
  TOP w0.124: v2(42.2,6.53) 41.87,6.87 41.87,7.58 42.8,9.84 43.37,10.7 45.06,14.78 45.06,18.44 45.19,19.06 45.39,19.56 56.24,30.41 61.09,32.41 63.03,32.8 68.53,32.8 78.59,36.97 85.61,43.99 89.4,45.56 107.19,45.56 121.77,47.48 129.67,45.9 134.32,46.83 137.49,46.2 140.67,46.83 143.88,46.19 148.48,47.11 153.93,44.85 162.26,48.3 166.72,49.19 175.87,52.98 177.03,54.72 177.03,55 C1069.2
  BOTTOM w0.124: J41.96 42.1,5.36 41.85,5.61 41.85,6.19 v2(42.2,6.53)
P3E_1_PESW_RX1_DN: length 9.5
  TOP w0.099: U34.AT14 178.09,63.82 178.19,63.92 178.39,63.92 178.49,63.82 178.49,61.48 178.39,61.38 178.39,61.18 178.49,61.08 178.49,60.89 178.39,60.78 178.39,60.59 178.49,60.48 178.49,60.29 178.39,60.18 178.39,59.99 178.49,59.88 178.49,59.09 178.24,58.84 178.17,58.84 178.15,58.82
  TOP w0.124: 178.15,58.82 177.03,57.7 176.73,56.96 176.73,56.51 C1068.1
P3E_1_PESW_RX1_DP: length 9.6
  TOP w0.099: U34.AR14 178.09,64.22 178.19,64.12 178.47,64.12 178.69,63.9 178.69,59 178.38,58.69 178.38,58.62 178.37,58.6
  TOP w0.124: 178.37,58.6 177.29,57.53 177.03,56.9 177.03,56.51 C1069.1
P3E_1_PESW_RX2_C_DN: length 162.2
  TOP w0.124: v2(37.98,6.48) 38.35,6.85 38.35,7.57 38.65,8.29 41.04,11.87 41.53,13.05 41.96,15.21 42.39,16.26 42.79,16.43 43.13,16.29 43.29,16.35 43.54,16.95 43.47,17.11 43.13,17.25 42.97,17.64 44.13,20.46 50.11,26.44 55.4,31.73 60.46,33.82 62.85,34.3 68.2,34.3 72.98,36.28 77.77,38.26 84.77,45.26 89.1,47.05 107.07,47.05 121.98,49.12 130.04,47.51 134.32,48.36 137.49,47.73 140.67,48.36 143.84,47.73 149.92,48.94 154.86,46.9 161.74,49.75 166.31,50.66 173.9,53.8 174.52,54.73 174.52,55 C1066.2
  BOTTOM w0.124: J41.106 38.1,5.32 38.34,5.57 38.34,6.12 v2(37.98,6.48)
P3E_1_PESW_RX2_C_DP: length 162.2
  TOP w0.124: C1067.2 174.82,55 174.82,54.63 174.1,53.56 166.4,50.37 161.83,49.46 154.86,46.57 149.89,48.63 143.84,47.42 140.67,48.05 137.49,47.42 134.32,48.05 130.04,47.2 121.97,48.81 107.09,46.75 89.16,46.75 84.94,45 77.94,38 68.26,33.99 62.88,33.99 60.55,33.53 55.57,31.47 50.33,26.22 50.32,26.22 44.39,20.29 43.3,17.64 43.36,17.48 43.7,17.34 43.87,16.95 43.53,16.12 43.13,15.96 42.79,16.1 42.63,16.03 42.25,15.12 41.82,12.96 41.31,11.72 38.92,8.14 38.66,7.51 38.66,6.82 v2(39,6.48)
  BOTTOM w0.124: J41.104 38.9,5.35 38.65,5.6 38.65,6.13 v2(39,6.48)
P3E_1_PESW_RX2_DN: length 9.1
  TOP w0.099: U34.AU13 177.09,62.82 177.19,62.92 177.39,62.92 177.49,62.82 177.49,62.31 177.39,62.21 177.39,62.01 177.49,61.91 177.49,61.71 177.39,61.61 177.39,61.41 177.49,61.31 177.49,61.11 177.39,61.01 177.39,60.81 177.49,60.71 177.49,59.91 177.13,59.56 177.06,59.56 177.04,59.54
  TOP w0.124: 177.04,59.54 174.52,57.02 174.52,56.52 C1066.1
P3E_1_PESW_RX2_DP: length 9.1
  TOP w0.099: U34.AT13 177.09,63.22 177.19,63.12 177.47,63.12 177.69,62.9 177.69,59.83 177.27,59.41 177.27,59.34 177.26,59.32
  TOP w0.124: 177.26,59.32 174.83,56.9 174.83,56.5 C1067.1
P3E_1_PESW_RX3_C_DN: length 161.3
  TOP w0.124: v2(34.78,7.19) 35.15,7.56 35.15,8.04 35.3,8.47 37.62,11.52 39.22,14.34 39.56,14.76 41.97,18.37 43.14,21.19 54.69,32.75 60.03,34.96 62.7,35.49 67.93,35.49 77.12,39.29 84.09,46.27 89.7,48.59 107.74,48.59 122.83,50.61 131.14,48.95 134.32,49.59 137.49,48.95 140.67,49.59 143.84,48.95 150.06,50.19 150.15,50.16 154.85,48.21 161.44,50.95 165.91,51.83 172.11,54.4 172.38,54.8 172.38,55 C1064.2
  BOTTOM w0.124: v2(34.78,7.19) 35.14,6.83 35.14,5.62 34.9,5.38 J41.114
P3E_1_PESW_RX3_C_DP: length 161.3
  TOP w0.124: C1065.2 172.69,55 172.69,54.71 172.32,54.16 166,51.54 161.53,50.65 154.85,47.88 150.03,49.88 143.84,48.64 140.67,49.27 137.49,48.64 134.32,49.27 131.14,48.64 122.82,50.3 107.76,48.29 89.76,48.29 84.26,46.01 77.29,39.04 67.99,35.18 62.73,35.18 60.12,34.67 54.87,32.49 43.4,21.02 42.82,19.62 42.24,18.22 39.8,14.58 39.47,14.17 37.88,11.36 35.57,8.33 35.46,7.99 35.46,7.54 v2(35.8,7.19)
  BOTTOM w0.124: v2(35.8,7.19) 35.45,6.85 35.45,5.65 35.7,5.4 J41.112
P3E_1_PESW_RX3_DN: length 10.7
  TOP w0.099: U34.AT12 176.09,63.82 176.19,63.92 176.39,63.92 176.49,63.82 176.49,63.15 176.39,63.05 176.39,62.85 176.49,62.75 176.49,62.55 176.39,62.45 176.39,62.25 176.49,62.15 176.49,61.95 176.39,61.85 176.39,61.65 176.49,61.55 176.49,60.64 175.79,59.95 175.72,59.95 175.7,59.93
  TOP w0.124: 175.7,59.93 173.28,57.51 172.71,57.27 172.38,56.94 172.38,56.51 C1064.1
P3E_1_PESW_RX3_DP: length 10.7
  TOP w0.099: 175.92,59.72 175.94,59.73 175.94,59.8 176.69,60.56 176.69,63.9 176.47,64.12 176.19,64.12 176.09,64.22 U34.AR12
  TOP w0.124: 175.92,59.72 173.45,57.25 172.88,57.01 172.69,56.82 172.69,56.51 C1065.1
P3E_1_PESW_TX0_DN: length 165.8
  TOP w0.124: U34.AP15 v6(178.59,65.02)
  IN2 w0.099: v6(178.59,65.02) 178.59,65.32 178.69,65.42 178.89,65.42 178.99,65.32 178.99,63.52 178.95,63.49 178.95,63.46
  IN2 w0.136: v2(42.82,14.94) 43.19,15.31 43.19,16.29 44.58,19.66 47.3,22.38 52.64,25.94 55.62,28.93 82.6,40.1 87.09,44.58 87.5,45.59 90.31,48.4 102.07,53.27 114.27,55.51 122.52,53.12 132.16,55.47 143.25,53.76 153.58,56.51 155.68,56.63 155.99,56.35 156.03,55.62 156.16,55.5 156.8,55.53 156.92,55.67 156.87,56.4 157.15,56.71 161.71,56.97 162.92,56.97 166.36,58.39 172.88,58.39 173.26,58.55 173.33,58.73 173.71,58.89 173.89,58.81 174.27,58.97 174.34,59.15 174.72,59.31 174.9,59.23 175.28,59.39 175.36,59.57 175.73,59.73 175.91,59.65 176.43,59.86 178.57,62 178.95,62.91 178.95,63.46
  BOTTOM w0.124: J41.93 42.9,9.79 43.15,10.03 43.15,12.58 43.17,13.86 43.17,14.59 v2(42.82,14.94)
P3E_1_PESW_TX0_DP: length 165.8
  TOP w0.124: U34.AN15 v6(178.59,66.02)
  IN2 w0.099: v6(178.59,66.02) 178.59,65.72 178.69,65.62 178.97,65.62 179.19,65.4 179.19,63.52 179.23,63.49 179.23,63.46
  IN2 w0.136: v2(43.83,14.94) 43.46,15.31 43.46,16.23 44.82,19.5 47.48,22.16 52.82,25.73 55.78,28.69 82.76,39.86 87.32,44.43 87.74,45.43 90.47,48.16 102.15,53 114.26,55.22 122.51,52.83 132.17,55.19 143.27,53.48 153.62,56.23 155.58,56.34 155.71,56.22 155.76,55.48 156.06,55.21 156.93,55.26 157.2,55.57 157.16,56.3 157.28,56.44 161.72,56.69 162.98,56.69 166.42,58.11 172.94,58.11 176.59,59.63 178.81,61.85 179.23,62.86 179.23,63.46
  BOTTOM w0.124: v2(43.83,14.94) 43.48,14.59 43.48,13.85 43.45,12.57 43.45,10.02 43.7,9.77 J41.91
P3E_1_PESW_TX1_DN: length 165.8
  TOP w0.124: U34.AN14 v6(177.59,66.02)
  IN2 w0.099: v6(177.59,66.02) 177.59,66.32 177.69,66.42 177.89,66.42 177.99,66.32 177.99,63.51 177.95,63.47 177.95,63.44
  IN2 w0.136: v2(39.59,13.01) 39.96,13.38 39.96,13.94 41.21,16.97 42.79,19.33 46.35,22.89 52,26.67 55.1,29.77 82.16,40.97 86.21,45.02 86.73,46.29 89.73,49.28 101.4,54.12 114.6,56.53 122.76,54.16 132.35,56.5 143.44,54.79 153.78,57.54 163.06,58.07 166.15,59.35 172.2,59.35 172.63,59.52 172.7,59.7 173.08,59.86 173.26,59.78 173.64,59.94 173.71,60.12 174.09,60.28 174.27,60.2 174.65,60.36 174.72,60.54 175.1,60.7 175.28,60.62 176.3,61.04 177.7,62.44 177.95,63.04 177.95,63.44
  BOTTOM w0.124: v2(39.59,13.01) 39.95,12.66 39.95,9.96 39.7,9.71 J41.101
P3E_1_PESW_TX1_DP: length 165.8
  TOP w0.124: U34.AM14 v6(177.59,67.02)
  IN2 w0.099: 178.23,63.44 178.23,63.47 178.19,63.51 178.19,66.4 177.97,66.62 177.69,66.62 177.59,66.72 v6(177.59,67.02)
  IN2 w0.136: v2(40.61,13.01) 40.24,13.38 40.24,13.89 41.46,16.83 43.01,19.15 46.53,22.67 52.18,26.45 55.26,29.53 82.32,40.74 86.44,44.86 86.97,46.13 89.89,49.05 101.48,53.85 114.58,56.24 122.75,53.87 132.36,56.22 143.45,54.51 153.82,57.26 163.12,57.79 166.2,59.07 172.26,59.07 176.46,60.81 177.94,62.29 178.23,62.98 178.23,63.44
  BOTTOM w0.124: v2(40.61,13.01) 40.25,12.66 40.25,9.94 40.5,9.69 J41.99
P3E_1_PESW_TX2_DN: length 168.6
  TOP w0.124: U34.AP13 v6(176.59,65.02)
  IN2 w0.099: v6(176.59,65.02) 176.59,65.32 176.69,65.42 176.89,65.42 176.99,65.32 176.99,63.54 176.95,63.5 176.95,63.48
  IN2 w0.136: 176.95,63.48 176.95,63.21 176.8,62.84 176.8,62.84 176.04,62.09 174.93,61.63 174.75,61.7 174.37,61.55 174.29,61.36 173.92,61.21 173.73,61.28 173.36,61.13 173.28,60.94 172.9,60.79 172.72,60.86 172.35,60.71 172.27,60.52 171.8,60.33 165.96,60.33 162.86,59.05 153.78,58.53 143.37,55.76 132.26,57.47 122.78,55.16 114.61,57.53 100.87,55.03 89.21,50.19 85.91,46.9 85.31,45.46 81.62,41.76 54.24,30.42 51.57,27.75 45.21,23.5 42.24,20.53 40.22,18.51 38.38,16.26 38.43,15.75 39.26,15.07 39.28,14.9 38.87,14.4 38.69,14.39 37.87,15.07 37.46,15.03 37.02,14.5 36.79,13.84 36.79,13.46 v2(36.42,13.09)
  BOTTOM w0.124: v2(36.42,13.09) 36.76,12.75 36.76,9.98 36.5,9.72 J41.109
P3E_1_PESW_TX2_DP: length 168.6
  TOP w0.124: U34.AN13 v6(176.59,66.02)
  IN2 w0.099: v6(176.59,66.02) 176.59,65.72 176.69,65.62 176.97,65.62 177.19,65.4 177.19,63.54 177.23,63.5 177.23,63.48
  IN2 w0.136: v2(37.43,13.09) 37.06,13.46 37.06,13.79 37.27,14.36 37.6,14.76 37.78,14.78 38.61,14.1 39.01,14.14 39.57,14.81 39.52,15.22 38.7,15.9 38.67,16.18 40.43,18.32 42.36,20.25 45.39,23.28 51.75,27.53 54.4,30.18 81.77,41.52 85.55,45.3 86.15,46.74 89.36,49.96 100.95,54.76 114.59,57.24 122.77,54.87 132.28,57.19 143.38,55.48 153.82,58.25 162.92,58.77 166.02,60.05 171.86,60.05 176.2,61.85 177.03,62.68 177.05,62.73 177.23,63.16 177.23,63.48
  BOTTOM w0.124: J41.107 37.3,9.71 37.06,9.94 37.06,12.72 v2(37.43,13.09)
P3E_1_PESW_TX3_DN: length 168.1
  TOP w0.124: U34.AN12 v6(175.59,66.02)
  IN2 w0.099: v6(175.59,66.02) 175.59,66.33 175.69,66.43 175.89,66.43 175.99,66.33 175.99,63.75 175.95,63.71 175.95,63.68
  IN2 w0.136: 175.95,63.68 175.95,63.4 175.87,63.21 174.69,62.72 174.51,62.79 174.13,62.64 174.06,62.45 173.68,62.3 173.5,62.37 173.12,62.22 173.04,62.04 172.67,61.88 172.49,61.95 172.11,61.8 172.03,61.62 171.4,61.35 165.82,61.35 162.7,60.06 153.38,59.53 143.08,56.79 131.94,58.51 122.67,56.25 114.73,58.55 100.66,55.98 88.65,51 85.06,47.41 84.45,45.92 81.15,42.63 53.68,31.25 50.71,28.29 43.94,23.77 35.97,15.79 33.84,13.2 33.55,12.49 33.55,12.04 v2(33.18,11.67)
  BOTTOM w0.124: v2(33.18,11.67) 33.54,11.31 33.54,9.93 33.3,9.69 J41.117
P3E_1_PESW_TX3_DP: length 168.1
  TOP w0.124: U34.AM12 v6(175.59,67.02)
  IN2 w0.099: v6(175.59,67.02) 175.59,66.73 175.69,66.63 175.97,66.63 176.19,66.41 176.19,63.75 176.23,63.71 176.23,63.68
  IN2 w0.136: 176.23,63.68 176.23,63.34 176.08,62.99 171.45,61.07 165.88,61.07 162.76,59.78 153.42,59.25 143.1,56.51 131.95,58.22 122.67,55.96 114.71,58.26 100.74,55.71 88.81,50.76 85.3,47.25 84.68,45.77 81.31,42.4 53.83,31.02 50.89,28.07 44.12,23.55 36.17,15.6 34.09,13.06 33.83,12.44 33.83,12.04 v2(34.2,11.67)
  BOTTOM w0.124: v2(34.2,11.67) 33.85,11.32 33.85,9.93 34.1,9.68 J41.115
P3E_2_PESW_RX0_C_DN: length 184.5
  TOP w0.124: C1062.2 163.16,54.57 163.16,54.43 163.07,54.23 159.93,51.66 154.83,49.55 150.23,51.45 143.85,50.17 143.84,50.17 140.67,50.81 137.49,50.17 134.32,50.81 131.14,50.17 122.88,51.82 107.1,49.78 89.46,49.78 82.21,46.78 75.25,39.82 71.46,38.25 67.67,36.68 62.35,36.68 56.98,35.61 54.97,34.78 50.68,30.48 47.68,29.24 45.31,29.24 44.79,29.02 44.47,28.55 44.47,27.64 43.77,25.95 43.93,25.55 44.37,25.37 44.44,25.21 44.19,24.62 44.03,24.55 43.59,24.73 43.2,24.57 40.86,18.92 40.85,18.9 40.85,18.89 40.81,18.79 35.81,13.79 35.6,13.48 34.66,11.22 34.25,10.6 33.63,9.11 33.63,6.67 33.84,6.18 34.14,5.88 34.91,5.56 52.34,5.56 56.23,3.95 57.54,2.64 57.54,1.87 57.42,1.75 v2(57.19,1.75)
  BOTTOM w0.124: v2(57.19,1.75) 57.42,1.75 57.55,1.87 57.55,3.29 57.3,3.54 J41.58
P3E_2_PESW_RX0_C_DP: length 184.5
  TOP w0.124: C1063.2 163.47,54.57 163.47,54.36 163.31,54.04 160.09,51.39 154.83,49.22 150.2,51.13 143.91,49.88 143.84,49.86 140.67,50.5 137.49,49.86 134.32,50.5 131.14,49.86 122.87,51.52 107.12,49.48 89.52,49.48 82.38,46.52 75.42,39.56 67.73,36.38 62.38,36.38 57.07,35.32 55.15,34.52 50.85,30.23 47.74,28.94 45.37,28.94 44.99,28.78 44.78,28.46 44.78,27.58 44.1,25.95 44.17,25.78 44.6,25.6 44.77,25.21 44.43,24.38 44.03,24.22 43.59,24.4 43.43,24.33 41.06,18.61 36.04,13.59 35.87,13.34 34.94,11.08 34.52,10.45 33.94,9.05 33.94,6.74 34.1,6.35 34.31,6.14 34.97,5.87 52.4,5.87 56.41,4.21 57.85,2.77 57.85,1.89 57.99,1.75 v2(58.21,1.75)
  BOTTOM w0.124: v2(58.21,1.75) 57.98,1.75 57.85,1.87 57.85,3.27 58.1,3.52 J41.56
P3E_2_PESW_RX0_DN: length 17.7
  TOP w0.099: 166.3,59.08 166.33,59.08 166.38,59.03 173.13,59.03 174.12,60.02 174.12,60.16 174.26,60.3 174.4,60.3 174.54,60.44 174.54,60.58 174.68,60.72 174.83,60.72 175.49,61.38 175.49,62.82 175.39,62.92 175.19,62.92 175.09,62.82 U34.AU11
  TOP w0.124: 166.3,59.08 166,59.08 165.98,59.05 165.33,58.78 163.17,56.63 163.17,56.09 C1062.1
P3E_2_PESW_RX0_DP: length 17.7
  TOP w0.099: U34.AT11 175.09,63.22 175.19,63.12 175.47,63.12 175.69,62.9 175.69,61.3 173.21,58.82 166.38,58.82 166.33,58.77 166.3,58.77
  TOP w0.124: C1063.1 163.47,56.07 163.47,56.5 165.5,58.53 166.09,58.77 166.3,58.77
P3E_2_PESW_RX1_C_DN: length 183.3
  TOP w0.124: C1060.2 161.03,54.54 161.03,54.34 160.79,53.99 159.16,52.65 154.86,50.87 150.4,52.71 143.84,51.4 140.67,52.04 137.49,51.4 134.32,52.04 131.14,51.4 122.85,53.06 106.11,50.98 88.13,50.98 80.47,47.81 72.76,40.09 67.69,37.99 62.83,37.99 56.53,36.74 54.31,35.82 50.08,31.58 47.35,30.45 43.56,30.45 43.04,30.24 42.72,29.76 42.72,26.59 40.21,20.52 39.95,19.9 31.9,11.86 31.47,10.66 31.47,7.08 31.76,6.39 32.05,5.7 32.68,5.07 34.37,4.37 50.7,4.37 53.77,3.1 54.37,2.49 54.37,1.92 54.2,1.75 v2(53.99,1.75)
  BOTTOM w0.124: J41.66 54.1,3.5 54.35,3.25 54.35,1.87 54.22,1.75 v2(53.99,1.75)
P3E_2_PESW_RX1_C_DP: length 183.3
  TOP w0.124: v2(55.01,1.75) 54.8,1.75 54.68,1.87 54.68,2.62 53.94,3.36 50.76,4.67 34.43,4.67 32.85,5.33 32.3,5.87 31.78,7.15 31.78,10.6 32.17,11.69 40.21,19.73 43.03,26.53 43.03,29.67 43.25,29.99 43.62,30.15 47.41,30.15 50.25,31.33 54.49,35.56 56.62,36.44 62.86,37.69 67.75,37.69 72.93,39.83 80.65,47.55 88.19,50.67 106.13,50.67 122.84,52.75 131.14,51.09 134.32,51.73 137.49,51.09 137.55,51.1 140.67,51.73 143.84,51.09 150.37,52.4 154.86,50.54 159.31,52.38 161.02,53.79 161.33,54.25 161.33,54.54 C1061.2
  BOTTOM w0.124: J41.64 54.9,3.52 54.65,3.27 54.65,1.87 54.78,1.75 v2(55.01,1.75)
P3E_2_PESW_RX1_DN: length 19.6
  TOP w0.099: 164.11,59.21 164.13,59.23 164.2,59.23 164.75,59.79 172.53,59.79 172.73,59.99 172.73,60.14 172.87,60.28 173.02,60.28 173.16,60.42 173.16,60.56 173.3,60.7 173.44,60.7 173.58,60.84 173.58,60.99 173.72,61.13 173.87,61.13 174.49,61.75 174.49,63.82 174.39,63.92 174.19,63.92 174.09,63.82 U34.AT10
  TOP w0.124: C1060.1 161.05,56.07 161.05,56.45 163.36,58.77 163.88,58.99 164.11,59.21
P3E_2_PESW_RX1_DP: length 19.6
  TOP w0.099: 164.32,59 164.34,59.01 164.34,59.08 164.84,59.58 172.61,59.58 174.69,61.66 174.69,63.9 174.47,64.12 174.19,64.12 174.09,64.22 U34.AR10
  TOP w0.124: 164.32,59 164.06,58.73 163.53,58.51 161.35,56.33 161.35,56.04 C1061.1
P3E_2_PESW_RX2_C_DN: length 192.1
  TOP w0.124: v2(50.79,1.75) 51.02,1.75 51.16,1.89 51.16,2.31 50.89,2.59 49.47,3.17 31.01,3.17 29.11,3.96 28.42,4.65 27.93,5.83 27.93,7.16 28.27,8.26 28.81,9.08 28.78,9.25 28.46,9.46 28.38,9.88 28.88,10.62 29.3,10.71 29.61,10.5 29.74,10.52 29.78,10.53 30.37,11.41 30.84,12.54 31.73,13.44 31.73,13.61 31.34,14 31.34,14.43 31.97,15.06 32.4,15.06 32.79,14.67 32.97,14.67 36.34,18.05 36.34,23.37 34.8,24.92 34.8,29.01 35.24,30.08 36.26,31.09 37.36,31.55 39.6,32 47.59,32 49.37,32.73 53.35,36.71 56.18,37.88 56.59,37.96 56.62,37.98 62.87,39.22 62.9,39.22 63.08,39.26 63.13,39.22 66.71,39.22 72.51,41.62 79.64,48.75 87.96,52.2 104.73,52.2 122.92,54.27 131.14,52.62 134.32,53.26 137.49,52.62 140.67,53.26 143.84,52.62 150.72,54 155.01,52.22 158.41,53.63 158.87,54.32 158.87,54.6 C1058.2
  BOTTOM w0.124: v2(50.79,1.75) 51.02,1.75 51.15,1.87 51.15,2.92 50.9,3.17 J41.74
P3E_2_PESW_RX2_C_DP: length 192.1
  TOP w0.124: v2(51.81,1.75) 51.59,1.75 51.47,1.87 51.47,2.44 51.06,2.85 49.53,3.48 31.07,3.48 29.28,4.22 28.68,4.83 28.24,5.89 28.24,7.12 28.55,8.13 29.13,9.01 29.05,9.43 28.74,9.64 28.7,9.81 29.06,10.35 29.23,10.38 29.54,10.17 29.76,10.22 29.97,10.26 30.64,11.26 31.1,12.37 32.04,13.31 32.04,13.74 31.65,14.13 31.65,14.3 32.1,14.76 32.27,14.76 32.66,14.37 33.09,14.37 36.65,17.92 36.65,23.5 35.11,25.04 35.11,28.95 35.5,29.9 36.43,30.83 37.45,31.26 39.63,31.69 47.66,31.69 49.54,32.47 53.52,36.45 56.27,37.59 56.68,37.67 56.71,37.68 62.9,38.92 62.93,38.92 63.01,38.93 63.04,38.92 66.77,38.92 72.68,41.36 79.81,48.49 88.02,51.89 104.75,51.89 122.91,53.96 131.14,52.31 134.32,52.95 137.49,52.31 140.67,52.95 143.84,52.31 150.69,53.68 155.01,51.89 158.61,53.38 159.17,54.23 159.17,54.6 C1059.2
  BOTTOM w0.124: v2(51.81,1.75) 51.58,1.75 51.45,1.87 51.45,2.92 51.7,3.17 J41.72
P3E_2_PESW_RX2_DN: length 19.5
  TOP w0.099: U34.AU9 173.09,62.82 173.19,62.92 173.39,62.92 173.49,62.82 173.49,62.08 173.16,61.75 173.02,61.75 172.88,61.61 172.88,61.47 172.74,61.33 172.59,61.33 172.45,61.19 172.45,61.05 172.05,60.64 171.85,60.64 171.75,60.74 171.55,60.74 171.45,60.64 163.47,60.64 162.92,60.09 162.84,60.09 162.83,60.07
  TOP w0.124: C1058.1 158.87,56.11 158.87,56.36 160.35,57.84 160.78,58.02 162.83,60.07
P3E_2_PESW_RX2_DP: length 19.5
  TOP w0.099: 163.04,59.85 163.06,59.87 163.06,59.94 163.56,60.44 172.13,60.44 173.69,62 173.69,62.9 173.47,63.12 173.19,63.12 173.09,63.22 U34.AT9
  TOP w0.124: 163.04,59.85 160.95,57.76 160.52,57.58 159.17,56.24 159.17,56.11 C1059.1
P3E_2_PESW_RX3_C_DN: length 191.8
  TOP w0.124: v2(47.59,1.41) 47.81,1.41 47.94,1.54 47.94,1.81 47.77,1.98 46.46,1.98 46.41,1.93 46.04,1.93 45.99,1.98 30.71,1.98 28.45,2.92 27.37,4 26.72,5.57 26.72,11.39 26.43,12.85 26.43,14.91 26.48,14.99 27.19,16.05 28.52,16.6 33.16,16.6 35.13,18.57 35.13,22.87 33.61,24.39 33.61,29.51 34.05,30.58 35.59,32.12 37.08,32.74 40.07,33.33 40.2,33.42 41.1,33.6 41.33,33.6 42.32,33.19 44.71,33.19 48.56,33.95 48.79,34.05 52.35,37.61 56.22,39.21 60.08,40.81 60.14,40.78 61.54,40.78 62.35,40.45 66.55,40.45 71.84,42.64 79.43,50.23 79.92,51.4 80.51,51.65 86.09,52.76 87.62,53.39 103.03,53.39 122.97,55.48 131.14,53.84 134.32,54.48 137.49,53.84 140.67,54.48 143.84,53.84 147.32,54.54 150.94,55.26 155.04,53.56 156.54,54.18 156.71,54.43 156.71,54.6 C1072.2
  BOTTOM w0.124: J41.82 47.7,3.52 47.95,3.28 47.95,1.54 47.82,1.41 v2(47.59,1.41)
P3E_2_PESW_RX3_C_DP: length 191.8
  TOP w0.124: v2(48.61,1.41) 48.38,1.41 48.24,1.55 48.24,1.94 47.9,2.29 30.78,2.29 28.62,3.18 27.63,4.17 27.03,5.63 27.03,11.42 26.73,12.88 26.73,14.82 27.39,15.8 28.58,16.3 33.28,16.3 35.43,18.45 35.43,23 33.91,24.52 33.91,29.45 34.31,30.41 35.77,31.87 37.17,32.45 40.19,33.04 40.32,33.13 41.13,33.29 41.26,33.29 42.26,32.88 44.74,32.88 48.65,33.66 48.96,33.79 52.52,37.35 60.08,40.48 61.48,40.48 62.29,40.14 66.61,40.14 72.02,42.38 79.69,50.06 79.92,50.61 80.15,51.17 80.59,51.35 86.18,52.47 87.68,53.09 103.05,53.09 122.95,55.17 131.14,53.53 134.32,54.17 137.49,53.53 140.67,54.17 143.84,53.53 150.91,54.95 155.04,53.23 156.75,53.93 157.01,54.33 157.01,54.6 C1073.2
  BOTTOM w0.124: J41.80 48.5,3.52 48.25,3.27 48.25,1.54 48.38,1.41 v2(48.61,1.41)
P3E_2_PESW_RX3_DN: length 20.9
  TOP w0.099: 164.24,61.53 164.26,61.53 164.31,61.48 170.98,61.48 171.44,61.94 171.44,62.09 171.58,62.23 171.72,62.23 171.86,62.37 171.86,62.51 172,62.65 172.15,62.65 172.49,62.99 172.49,63.82 172.39,63.92 172.19,63.92 172.09,63.82 U34.AT8
  TOP w0.124: C1072.1 156.71,56.11 156.71,56.33 156.91,56.63 157.74,56.97 161.8,61.04 163,61.53 164.24,61.53
P3E_2_PESW_RX3_DP: length 21
  TOP w0.099: 164.24,61.23 164.26,61.23 164.31,61.28 171.07,61.28 172.69,62.91 172.69,63.9 172.47,64.12 172.19,64.12 172.09,64.22 U34.AR8
  TOP w0.124: 164.24,61.23 163.06,61.23 161.97,60.78 160.83,59.64 157.91,56.72 157.11,56.39 157.01,56.24 157.01,56.11 C1073.1
P3E_2_PESW_TX0_DN: length 145.3
  TOP w0.124: U34.AP11 v6(174.59,65.02)
  IN1 w0.099: v6(174.59,65.02) 174.59,65.34 174.69,65.44 174.89,65.44 174.99,65.33 174.99,63.32 174.95,63.28 174.95,63.26
  IN1 w0.136: 174.95,63.26 174.95,62.66 174.43,61.88 174.05,61.72 173.89,61.79 173.51,61.63 173.44,61.47 173.06,61.31 172.9,61.38 172.52,61.22 172.45,61.06 172.07,60.9 171.91,60.97 171.53,60.81 171.46,60.65 170.82,60.38 164.72,60.38 160.26,58.54 155.26,53.54 133.51,44.53 129.64,44.53 125.67,43.74 122.04,43.74 115.79,44.98 113.14,44.72 105.76,41.67 103.44,39.35 100.23,38.01 98.01,38.01 95.86,37.13 93.88,35.15 89.27,32.06 87.57,31.36 86.12,31.36 85.06,30.92 82.34,28.2 81.81,26.94 80.31,25.43 77.97,24.46 71.42,24.46 69.66,23.74 67.53,21.6 66.91,20.1 63.58,16.77 62.21,15.85 62.13,15.45 62.51,14.87 62.48,14.7 61.95,14.34 61.77,14.38 61.53,14.75 61.15,14.86 58.45,13.74 56.28,11.96 55.96,11.48 55.96,11.08 v2(55.59,10.71)
  BOTTOM w0.124: v2(55.59,10.71) 55.95,10.36 55.95,9.96 55.7,9.71 J41.61
P3E_2_PESW_TX0_DP: length 145.3
  TOP w0.124: U34.AN11 v6(174.59,66.02)
  IN1 w0.099: v6(174.59,66.02) 174.59,65.74 174.69,65.64 174.97,65.64 175.19,65.42 175.19,63.32 175.23,63.28 175.23,63.26
  IN1 w0.136: 175.23,63.26 175.23,62.57 174.61,61.65 170.88,60.11 164.77,60.11 160.42,58.3 155.42,53.3 133.57,44.25 129.66,44.25 125.7,43.46 122.01,43.46 115.78,44.7 113.21,44.45 105.92,41.43 103.6,39.11 100.28,37.74 98.06,37.74 96.02,36.89 94.06,34.93 89.4,31.82 87.63,31.08 86.18,31.08 85.21,30.68 82.57,28.04 82.05,26.78 80.46,25.19 78.02,24.18 71.47,24.18 69.82,23.5 67.77,21.44 67.14,19.94 63.76,16.55 62.46,15.68 62.42,15.51 62.81,14.93 62.73,14.53 62.63,14.46 62.01,14.05 61.6,14.13 61.35,14.51 61.16,14.56 58.59,13.5 56.49,11.77 56.24,11.4 56.24,11.08 v2(56.61,10.71)
  BOTTOM w0.124: v2(56.61,10.71) 56.25,10.36 56.25,9.95 56.5,9.7 J41.59
P3E_2_PESW_TX1_DN: length 145.2
  TOP w0.124: U34.AN10 v6(173.59,66.02)
  IN1 w0.099: v6(173.59,66.02) 173.59,66.34 173.69,66.44 173.89,66.44 173.99,66.34 173.99,63.38 173.95,63.34 173.95,63.32
  IN1 w0.136: v2(52.35,10.61) 52.71,10.97 52.71,11.35 53.19,12.07 56.86,14.65 58.15,15.19 58.67,15.71 64.12,18.62 65.96,20.46 66.65,22.14 69.07,24.56 71.27,25.47 74.92,26.19 76.38,26.8 76.95,27.37 82.38,29.62 84.43,31.67 86.06,32.35 87.47,32.35 88.88,32.93 93.07,35.73 95.19,37.85 97.97,39 100.09,39 102.84,40.14 105.24,42.53 114.11,46.21 123.11,46.21 126.6,45.51 133.35,45.51 154.75,54.38 159.7,59.32 164.5,61.31 168.74,61.31 168.86,61.44 169.27,61.44 169.4,61.31 170.09,61.31 171.72,61.99 171.79,62.16 172.17,62.31 172.33,62.24 172.71,62.4 172.78,62.57 173.16,62.72 173.32,62.65 173.7,62.81 173.95,63.19 173.95,63.32
  BOTTOM w0.124: J41.69 52.5,9.75 52.73,9.98 52.73,10.23 v2(52.35,10.61)
P3E_2_PESW_TX1_DP: length 145.2
  TOP w0.124: U34.AM10 v6(173.59,67.02)
  IN1 w0.099: 174.23,63.32 174.23,63.34 174.19,63.38 174.19,66.42 173.97,66.64 173.69,66.64 173.59,66.74 v6(173.59,67.02)
  IN1 w0.136: 174.23,63.32 174.23,63.1 173.88,62.58 170.14,61.03 164.56,61.03 159.86,59.09 154.91,54.14 133.41,45.23 126.57,45.23 123.08,45.93 114.17,45.93 105.4,42.3 103,39.9 100.14,38.72 98.02,38.72 95.35,37.61 93.25,35.51 89.02,32.68 87.53,32.07 86.11,32.07 84.59,31.44 82.54,29.38 77.11,27.14 76.54,26.56 75,25.92 71.35,25.2 69.23,24.32 66.89,21.98 66.19,20.3 64.29,18.39 58.84,15.48 58.31,14.95 56.99,14.41 53.39,11.87 52.99,11.27 52.99,10.99 v2(53.37,10.61)
  BOTTOM w0.124: J41.67 53.3,9.68 53.03,9.95 53.03,10.28 v2(53.37,10.61)
P3E_2_PESW_TX2_DN: length 154.1
  TOP w0.124: U34.AP9 v6(172.59,65.02)
  IN1 w0.099: v6(172.59,65.02) 172.59,65.34 172.69,65.44 172.89,65.44 172.99,65.33 172.99,64.61 172.84,64.25 172.45,63.86 171.87,63.62 166.16,63.62 165.76,63.46 165.39,63.09 165.31,63.01 164.84,63.01 164.8,63.05 164.78,63.05
  IN1 w0.136: 164.78,63.05 164.15,63.05 162.39,62.32 159.15,60.16 156.11,57.11 155.95,57.11 155.66,56.82 155.66,56.66 155.37,56.37 155.21,56.37 154.92,56.09 154.92,55.92 154.14,55.15 133.38,46.55 126.53,46.55 123.2,47.21 113.71,47.21 104.97,43.59 102.41,41.03 99.84,39.96 97.87,39.96 93.37,38.1 91.56,36.29 90.43,35.82 88.37,35.82 86.4,35.01 81.84,30.45 77.06,28.47 71.08,28.47 70.64,28.29 70.48,27.91 70.89,26.92 70.82,26.76 70.23,26.51 70.07,26.58 70.07,26.58 69.66,27.57 69.28,27.72 67.89,27.15 66.18,24.59 65.06,20.89 63.62,19.45 59.94,17.92 56.88,17.31 56.65,16.97 56.87,15.85 56.77,15.7 56.15,15.58 56,15.67 55.77,16.8 55.43,17.03 52.26,16.39 50.65,15.73 49.56,14.1 49.56,11.03 v2(49.19,10.66)
  BOTTOM w0.124: v2(49.19,10.66) 49.55,10.3 49.55,10.03 49.3,9.79 J41.77
P3E_2_PESW_TX2_DP: length 154.1
  TOP w0.124: U34.AN9 v6(172.59,66.02)
  IN1 w0.099: v6(172.59,66.02) 172.59,65.74 172.69,65.64 172.97,65.64 173.19,65.42 173.19,64.57 173.01,64.14 172.73,63.85 172.56,63.69 171.91,63.42 166.2,63.42 165.88,63.29 165.53,62.94 165.39,62.81 164.84,62.81 164.8,62.77 164.78,62.77
  IN1 w0.136: 164.78,62.77 164.21,62.77 162.52,62.07 159.33,59.94 154.3,54.91 133.43,46.27 126.51,46.27 123.17,46.93 113.77,46.93 105.13,43.36 102.57,40.79 99.89,39.68 97.92,39.68 93.53,37.86 91.72,36.06 90.49,35.54 88.42,35.54 86.56,34.77 82,30.21 77.12,28.19 71.13,28.19 70.85,28.07 70.78,27.91 71.19,26.92 71.03,26.54 70.23,26.21 69.85,26.37 69.44,27.35 69.28,27.42 68.08,26.92 66.44,24.47 65.31,20.74 63.78,19.21 60.03,17.65 57.04,17.06 56.94,16.91 57.17,15.79 56.94,15.45 56.09,15.28 55.75,15.51 55.52,16.63 55.37,16.73 52.34,16.13 50.84,15.5 49.84,14.01 49.84,11.03 v2(50.21,10.66)
  BOTTOM w0.124: J41.75 50.1,9.77 49.85,10.02 49.85,10.3 v2(50.21,10.66)
P3E_2_PESW_TX3_DN: length 154.9
  TOP w0.124: U34.AN8 v6(171.59,66.02)
  IN1 w0.099: 165.72,64.66 165.75,64.66 165.78,64.62 171.77,64.62 171.99,64.84 171.99,66.33 171.89,66.43 171.69,66.43 171.59,66.33 v6(171.59,66.02)
  IN1 w0.136: v2(45.97,18.5) 46.34,18.87 46.34,19.58 47.92,21.95 51.68,23.51 63.74,23.51 64.54,23.94 67.28,28.04 70.57,29.4 76.85,29.4 81.34,31.26 85.88,35.8 88.41,36.85 90.43,36.85 90.94,37.06 92.73,38.85 97.79,40.94 99.75,40.94 101.77,41.78 104.4,44.41 113.62,48.22 123,48.22 126.47,47.53 133.31,47.53 134.71,48.11 134.78,48.28 135.16,48.44 135.33,48.37 135.71,48.53 135.78,48.7 136.16,48.85 136.33,48.78 152.69,55.56 158.05,60.92 162.15,63.66 164.56,64.66 165.72,64.66
  BOTTOM w0.124: J41.85 46.1,9.71 46.33,9.95 46.33,18.14 v2(45.97,18.5)
P3E_2_PESW_TX3_DP: length 154.9
  TOP w0.124: U34.AM8 v6(171.59,67.02)
  IN1 w0.099: 165.72,64.38 165.75,64.38 165.78,64.42 171.86,64.42 172.19,64.75 172.19,66.41 171.97,66.63 171.69,66.63 171.59,66.73 v6(171.59,67.02)
  IN1 w0.136: 165.72,64.38 164.61,64.38 162.28,63.41 158.23,60.71 152.85,55.33 133.37,47.25 126.45,47.25 122.97,47.94 113.67,47.94 104.56,44.17 101.93,41.54 99.81,40.66 97.84,40.66 92.89,38.61 91.1,36.82 90.49,36.57 88.47,36.57 86.03,35.56 81.5,31.03 76.9,29.12 70.63,29.12 67.46,27.81 64.73,23.73 63.81,23.23 51.74,23.23 48.1,21.73 46.61,19.5 46.61,18.87 v2(46.98,18.5)
  BOTTOM w0.124: v2(46.98,18.5) 46.64,18.16 46.64,9.95 46.9,9.69 J41.83
P3E_3_PESW_RX0_C_DN: length 92.8
  TOP w0.124: v2(140.61,6.42) 140.25,6.77 140.25,10.55 140.64,12.49 147.95,30.15 157.69,39.89 162.66,41.95 167.08,42.82 184.67,50.11 194.84,50.11 197.32,51.13 199.12,52.34 201.11,54.33 202.38,54.86 203.07,55.55 204.07,55.96 204.28,56.27 204.28,56.55 C397.2
  BOTTOM w0.124: v2(140.61,6.42) 140.25,6.06 140.25,5.42 140.5,5.18 J49.68
P3E_3_PESW_RX0_C_DP: length 92.8
  TOP w0.124: v2(139.59,6.42) 139.95,6.77 139.95,10.58 140.34,12.58 147.69,30.32 157.52,40.15 162.57,42.24 166.99,43.12 184.61,50.42 194.78,50.42 197.17,51.4 198.92,52.58 200.94,54.59 202.2,55.11 202.9,55.81 203.87,56.21 203.97,56.36 203.97,56.55 C398.2
  BOTTOM w0.124: v2(139.59,6.42) 139.95,6.06 139.95,5.39 139.7,5.14 J49.70
P3E_3_PESW_RX0_DN: length 10.7
  TOP w0.099: U34.AP37 200.79,65.52 200.69,65.42 200.69,65.22 200.79,65.12 202.39,65.12 204.23,63.29 204.23,62.44 204.28,62.39 204.28,62.37
  TOP w0.124: C397.1 204.28,58.06 204.28,62.37
P3E_3_PESW_RX0_DP: length 10.7
  TOP w0.099: U34.AP36 200.39,65.52 200.49,65.42 200.49,65.14 200.71,64.92 202.31,64.92 204.02,63.2 204.02,62.44 203.97,62.39 203.97,62.37
  TOP w0.124: C398.1 203.97,58.06 203.97,62.37
P3E_3_PESW_RX1_C_DN: length 93
  TOP w0.124: C395.2 201.91,56.53 201.91,56.26 201.63,55.84 200.4,55.33 198.32,53.26 196.74,52.2 194.76,51.38 184.54,51.38 166.65,43.97 162.29,43.1 156.98,40.9 146.5,30.42 141.87,19.25 137.73,13.06 137.05,11.41 137.05,6.77 v2(137.41,6.42)
  BOTTOM w0.124: v2(137.41,6.42) 137.05,6.06 137.05,5.46 137.3,5.21 J49.76
P3E_3_PESW_RX1_C_DP: length 93
  TOP w0.124: v2(136.39,6.42) 136.75,6.77 136.75,11.48 137.46,13.2 141.6,19.4 146.24,30.59 156.81,41.16 162.2,43.4 166.56,44.26 184.48,51.69 194.7,51.69 196.6,52.47 198.13,53.49 200.23,55.59 201.43,56.09 201.61,56.36 201.61,56.53 C396.2
  BOTTOM w0.124: J49.78 136.5,5.19 136.75,5.44 136.75,6.06 v2(136.39,6.42)
P3E_3_PESW_RX1_DN: length 10
  TOP w0.099: 202.95,62.28 202.95,62.3 202.9,62.35 202.9,63 201.78,64.12 199.79,64.12 199.69,64.22 199.69,64.42 199.79,64.52 U34.AR36
  TOP w0.124: C395.1 201.91,58.04 201.91,58.67 202.95,61.17 202.95,62.28
P3E_3_PESW_RX1_DP: length 10
  TOP w0.099: U34.AR35 199.39,64.52 199.49,64.42 199.49,64.14 199.71,63.92 201.7,63.92 202.7,62.92 202.7,62.35 202.65,62.3 202.65,62.28
  TOP w0.124: C396.1 201.61,58.04 201.61,58.73 202.65,61.24 202.65,62.28
P3E_3_PESW_RX2_C_DN: length 93.1
  TOP w0.124: v2(134.23,6.39) 133.88,6.75 133.88,10.87 134.99,13.56 139.92,20.93 143.24,28.94 152.23,37.93 156.18,41.88 162.38,44.45 166.83,45.33 184.49,52.65 194.54,52.65 196.05,53.27 197.83,54.46 199.43,56.06 199.53,56.29 199.53,56.53 C393.2
  BOTTOM w0.124: v2(134.23,6.39) 133.87,6.03 133.87,5.41 134.1,5.18 J49.84
P3E_3_PESW_RX2_C_DP: length 93.1
  TOP w0.124: v2(133.22,6.39) 133.57,6.75 133.57,10.93 134.72,13.7 139.65,21.08 142.98,29.11 156.01,42.14 162.3,44.74 166.74,45.63 184.42,52.95 194.48,52.95 195.91,53.54 197.64,54.7 199.17,56.24 199.22,56.35 199.22,56.53 C394.2
  BOTTOM w0.124: J49.86 133.3,5.16 133.56,5.42 133.56,6.05 v2(133.22,6.39)
P3E_3_PESW_RX2_DN: length 7
  TOP w0.124: C393.1 199.51,58.06 199.51,58.5 199.62,58.75 200.92,60.06 201.37,61.14 201.37,61.97 201.12,62.59 200.74,62.96 200.74,63.17 U34.AT37
P3E_3_PESW_RX2_DP: length 7
  TOP w0.124: C394.1 199.21,58.03 199.21,58.56 199.36,58.92 200.66,60.23 201.07,61.2 201.07,61.91 200.86,62.41 200.44,62.84 200.44,63.17 U34.AT36
P3E_3_PESW_RX3_C_DN: length 93.6
  TOP w0.124: C391.2 197.19,56.55 197.19,56.08 195.44,54.32 194.28,53.84 184.26,53.84 166.89,46.65 162.42,45.76 155.44,42.87 141.63,29.06 138.89,22.43 135.29,17.06 131.8,13.56 130.68,10.86 130.68,6.75 v2(131.03,6.39)
  BOTTOM w0.124: v2(131.03,6.39) 130.66,6.02 130.66,5.41 130.9,5.17 J49.92
P3E_3_PESW_RX3_C_DP: length 93.6
  TOP w0.124: v2(130.02,6.39) 130.37,6.75 130.37,10.92 131.54,13.74 135.05,17.25 138.61,22.58 141.37,29.23 155.27,43.13 162.33,46.06 166.81,46.95 184.2,54.15 194.22,54.15 195.26,54.58 196.88,56.2 196.88,56.55 C392.2
  BOTTOM w0.124: J49.94 130.1,5.16 130.36,5.42 130.36,6.05 v2(130.02,6.39)
P3E_3_PESW_RX3_DN: length 6.1
  TOP w0.124: U34.AU36 199.74,62.17 199.74,61.65 199.47,60.98 197.34,58.86 197.19,58.49 197.19,58.06 C391.1
P3E_3_PESW_RX3_DP: length 6.1
  TOP w0.124: C392.1 196.88,58.06 196.88,58.55 197.08,59.03 199.21,61.16 199.44,61.71 199.44,62.17 U34.AU35
P3E_3_PESW_TX0_DN: length 107
  TOP w0.124: U34.AE37 v6(201.59,74.02)
  IN2 w0.099: 204.71,72.01 204.71,72.04 204.68,72.08 204.68,72.54 204.54,72.78 204.3,73.02 204,73.14 202.99,73.14 202.2,73.47 201.46,73.47 201.19,73.74 201.19,73.92 201.29,74.02 v6(201.59,74.02)
  IN2 w0.136: 204.71,72.01 204.71,66.61 202.05,60.18 200.4,58.52 195.86,56.64 187.28,56.64 184.34,55.43 183.26,54.34 176.82,51.67 173.94,48.8 166.02,45.51 162.98,45.51 157.12,43.09 151.34,37.3 146.57,30.17 143.54,22.84 142.25,16.36 141.87,12.48 141.87,11.16 v2(142.23,10.79)
  BOTTOM w0.124: v2(142.23,10.79) 141.86,10.42 141.86,10.03 142.1,9.79 J49.63
P3E_3_PESW_TX0_DP: length 107
  TOP w0.124: U34.AE36 v6(200.59,74.02)
  IN2 w0.099: 204.43,72.01 204.43,72.04 204.47,72.08 204.47,72.49 204.37,72.65 204.18,72.85 203.96,72.94 202.95,72.94 202.16,73.27 201.37,73.27 200.99,73.65 200.99,73.92 200.89,74.02 v6(200.59,74.02)
  IN2 w0.136: v2(141.22,10.79) 141.59,11.16 141.59,12.49 141.97,16.4 143.27,22.93 146.33,30.3 151.12,37.48 156.96,43.32 162.92,45.79 165.96,45.79 173.79,49.03 176.66,51.91 183.1,54.58 184.18,55.66 187.22,56.92 195.8,56.92 200.24,58.76 201.81,60.33 204.43,66.66 204.43,72.01
  BOTTOM w0.124: v2(141.22,10.79) 141.56,10.45 141.56,10.06 141.3,9.8 J49.65
P3E_3_PESW_TX1_DN: length 105.9
  TOP w0.124: U34.AF36 v6(200.59,73.02)
  IN2 w0.099: 203.27,67.81 203.27,67.84 203.23,67.88 203.23,68.39 202.94,68.95 202.94,71.2 202.57,72.12 202.25,72.43 201.79,72.62 200.3,72.62 200.19,72.74 200.19,72.92 200.29,73.02 v6(200.59,73.02)
  IN2 w0.136: 203.27,67.81 203.27,65.53 201.29,60.76 199.91,59.38 195.93,57.73 187.45,57.73 183.83,56.23 182.77,55.17 176.35,52.51 173.42,49.58 165.89,46.46 162.85,46.46 156.55,43.85 150.68,37.98 145.71,30.54 139.26,14.97 138.67,11.98 138.67,11.16 v2(139.03,10.79)
  BOTTOM w0.124: v2(139.03,10.79) 138.66,10.42 138.66,10.03 138.9,9.79 J49.71
P3E_3_PESW_TX1_DP: length 105.9
  TOP w0.124: U34.AF35 v6(199.59,73.02)
  IN2 w0.099: v6(199.59,73.02) 199.89,73.02 199.99,72.92 199.99,72.65 200.22,72.42 201.75,72.42 202.14,72.26 202.39,72 202.74,71.16 202.74,68.9 203.03,68.34 203.03,67.88 202.99,67.84 202.99,67.81
  IN2 w0.136: v2(138.02,10.79) 138.39,11.16 138.39,12.01 138.99,15.05 145.46,30.68 150.47,38.16 156.39,44.09 162.79,46.74 165.83,46.74 173.27,49.82 176.2,52.75 182.61,55.41 183.67,56.47 187.39,58.01 195.87,58.01 199.75,59.61 201.06,60.92 202.99,65.59 202.99,67.81
  BOTTOM w0.124: v2(138.02,10.79) 138.36,10.45 138.36,10.06 138.1,9.81 J49.73
P3E_3_PESW_TX2_DN: length 104.1
  TOP w0.124: U34.AG37 v6(201.59,72.02)
  IN2 w0.099: v6(201.59,72.02) 201.29,72.02 201.19,71.92 201.19,71.57 201.3,71.31 202.03,70.57 202.29,69.94 202.29,67.9 202.33,67.86 202.33,67.83
  IN2 w0.136: 202.33,67.83 202.33,65.68 200.52,61.31 199.44,60.23 195.66,58.66 187.26,58.66 183.22,56.99 182.19,55.96 175.83,53.33 172.9,50.39 165.71,47.41 162.58,47.41 156.05,44.71 149.93,38.59 144.94,31.12 141,21.62 137.08,15.74 135.47,11.86 135.47,11.16 v2(135.83,10.79)
  BOTTOM w0.124: v2(135.83,10.79) 135.46,10.42 135.46,10.03 135.7,9.79 J49.79
P3E_3_PESW_TX2_DP: length 104.1
  TOP w0.124: U34.AG36 v6(200.59,72.02)
  IN2 w0.099: 202.05,67.83 202.05,67.86 202.09,67.9 202.09,69.9 201.86,70.46 201.13,71.19 200.99,71.53 200.99,71.92 200.89,72.02 v6(200.59,72.02)
  IN2 w0.136: v2(134.82,10.79) 135.19,11.16 135.19,11.91 136.83,15.88 140.76,21.76 144.69,31.25 149.71,38.76 155.89,44.95 162.52,47.69 165.65,47.69 172.74,50.63 175.68,53.56 182.04,56.2 183.06,57.22 187.21,58.94 195.6,58.94 199.28,60.47 200.28,61.46 202.05,65.74 202.05,67.83
  BOTTOM w0.124: J49.81 134.9,9.8 135.16,10.06 135.16,10.45 v2(134.82,10.79)
P3E_3_PESW_TX3_DN: length 103.9
  TOP w0.124: U34.AH36 v6(200.59,71.02)
  IN2 w0.099: v6(200.59,71.02) 200.29,71.02 200.19,70.92 200.19,70.37 199.19,69.37 199.19,62.91 199.35,62.53 199.35,61.98 199.39,61.94 199.39,61.92
  IN2 w0.136: 199.39,61.92 199.39,61.69 199.27,61.4 198.86,60.99 195.48,59.59 187.06,59.59 182.4,57.66 181.48,56.74 175.28,54.17 172.25,51.14 165.51,48.35 162.24,48.35 155.52,45.57 149.19,39.23 144.1,31.62 140.35,22.56 133.81,14.6 132.79,13.06 132.27,11.8 132.27,11.16 v2(132.63,10.79)
  BOTTOM w0.124: v2(132.63,10.79) 132.26,10.42 132.26,10.03 132.5,9.79 J49.87
