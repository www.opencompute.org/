# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FM_COM_SEL_2: length 10.8
  TOP w0.112: v2(26.35,47.95) 27.05,47.24 v1(27.74,47.24) R4009.1
  BOTTOM w0.112: U94.A15 22.81,44.65 23.74,43.71 24.65,43.71 25.47,44.53 25.47,47.07 v2(26.35,47.95)
FM_COM_SEL_2_R: length 8.5
  TOP w0.112: U86.J18 37.31,45.09 36.73,45.09 36.56,45.25 34.93,45.25 34.32,45.86 32.89,45.86 v1(31.75,47) 31.18,47.56 30.48,47.56 R4009.2
FM_COM_SEL_3: length 16.1
  TOP w0.112: v2(27.1,48.05) 28.37,49.33 R4010.1
  BOTTOM w0.112: U94.A13 20.45,44.22 20.99,43.68 22.61,43.68 23.88,42.4 25.35,42.4 26.31,43.36 26.31,47.27 v2(27.1,48.05)
FM_COM_SEL_3_R: length 7.5
  TOP w0.112: R4010.2 31.56,49.33 v1(32.72,48.17) 33.02,47.87 33.25,47.87 35.33,45.79 36.8,45.79 U86.L19
FM_JTAG_EN_N: length 17.5
  TOP w0.112: R4011.1 28.14,48.31 v2(27.84,48)
  BOTTOM w0.112: v2(27.84,48) 27.31,47.47 v3(27.31,45.62) 27.31,43.74 25.69,42.13 23.52,42.13 22.81,42.83 21.06,42.83 19.96,43.94 19.16,43.94 U94.A11
FM_JTAG_EN_N_R: length 7.2
  TOP w0.112: U86.K19 36.87,45.52 35.09,45.52 34.09,46.51 v1(33.65,46.51) 32.93,47.23 32.82,47.23 31.74,48.31 R4011.2
FM_JTAG_SEL_0: length 14
  IN1 w0.122: v2(30.58,45.71) 30.52,45.65 21.68,45.65 21.19,46.15 v2(18.95,46.15)
  BOTTOM w0.112: v2(30.58,45.71) 30.8,45.71 31.14,46.05 R4012.1 ; U94.C11 v2(18.95,46.15)
FM_JTAG_SEL_0_R: length 6.1
  TOP w0.112: U86.K18 37.47,45.44 v6(37.96,45.94)
  BOTTOM w0.112: R4012.2 32.76,45.98 36.34,45.98 v3(36.47,46.11) 37.78,46.11 v6(37.96,45.94)
FM_JTAG_SEL_1: length 17.6
  TOP w0.112: v2(17.95,48.14) 18.46,47.63 18.46,46.88 18.72,46.62 19.14,46.62 19.45,46.31 19.45,44.98 20.83,43.6 24.2,43.6 25.02,44.42 v1(25.02,44.83) 26.82,44.83 28.25,43.4 28.36,43.4 28.62,43.14 R4013.1
  BOTTOM w0.112: U94.F10 17.95,49.15 v2(17.95,48.14)
FM_JTAG_SEL_1_R: length 7.3
  TOP w0.112: R4013.2 30.42,43.41 30.8,43.41 31.09,43.7 v1(31.6,43.7) 32.02,43.7 32.36,44.04 33.28,44.04 33.5,43.83 36.21,43.83 36.32,43.94 U86.G19
FM_JTAG_SEL_2: length 12.6
  TOP w0.112: v2(18.95,47.15) 19.26,47.15 19.73,46.68 19.73,46.04 20.1,45.66 22.16,45.66 22.91,46.41 v1(23.22,46.41) 23.53,46.72 24.39,46.72 24.7,46.41 29.03,46.41 R4014.1
  BOTTOM w0.112: U94.D11 v2(18.95,47.15)
FM_JTAG_SEL_2_R: length 8.2
  TOP w0.112: R4014.2 32.06,46.22 33.21,45.07 v1(33.89,45.07) 33.98,44.99 36.32,44.99 36.51,44.79 37.1,44.79 37.45,44.44 U86.H18
FM_JTAG_SEL_3: length 13.6
  TOP w0.112: v2(18.95,45.15) 18.95,44.87 21.01,42.81 v1(22.57,42.81) 22.84,43.09 24.35,43.09 25.4,44.14 27.06,44.14 29.09,42.12 R4015.1
  BOTTOM w0.112: U94.B11 v2(18.95,45.15)
FM_JTAG_SEL_3_R: length 8.1
  TOP w0.089: 34.77,43.53 34.82,43.58 36.33,43.58 36.39,43.64 37.16,43.64 U86.G18
  TOP w0.112: R4015.2 31.11,43.09 32.71,43.09 v1(33.05,43.43) 34.67,43.43 34.77,43.53
FM_LED_PM_HB: length 31.3
  TOP w0.112: R3258.1 207.85,102.27 v2(207.34,102.77) 207.37,102.77 207.85,103.25 Q10.2 ; U34.R30 v6(194.59,85.02)
  IN2 w0.102: 200.65,85.09 200.41,84.85 200.41,84.75 200.07,84.42 195.19,84.42 v6(194.59,85.02)
  IN2 w0.122: 200.65,85.09 202.23,86.67 203.17,86.67 204.86,88.36 205.99,88.36 206.51,88.88 206.51,94.26 207.16,94.91 207.16,100.1 207.72,100.66 207.72,102.4 v2(207.34,102.77)
FM_M2A_OCP_ADJ: length 8
  TOP w0.112: v2(21.16,118.45) R4388.1 20.02,118.96 19.57,118.96 v1(18.79,119.74) ; U19.9 v2(25.06,118.03)
  BOTTOM w0.112: v2(21.16,118.45) 21.34,118.64 22.15,118.64 23.04,117.75 24.77,117.75 v2(25.06,118.03)
FM_M2B_OCP_ADJ: length 6.9
  TOP w0.112: U20.9 49.77,118.13 v1(49.56,118.34) 49.18,118.72 46.35,118.72 45.04,117.41 R4389.1
FM_M2C_OCP_ADJ: length 7.3
  TOP w0.112: v2(71.07,117.3) 70.78,117.01 70.78,116.57 R4390.1 ; U21.9 74.68,116.8 74.93,117.05 v2(74.93,117.48)
  BOTTOM w0.112: v2(71.07,117.3) 71.32,117.56 v3(72.47,117.56) 72.68,117.76 74.66,117.76 v2(74.93,117.48)
FM_M2D_OCP_ADJ: length 7.1
  TOP w0.112: R4391.1 95.79,116.59 v2(96.45,117.25) ; U22.9 100.08,117.66 v2(100.02,117.73)
  BOTTOM w0.112: v2(96.45,117.25) 96.72,117.51 96.72,117.75 97.41,118.44 97.99,118.44 v3(98.5,117.93) 98.7,117.73 v2(100.02,117.73)
FM_M2E_OCP_ADJ: length 6.4
  TOP w0.112: U23.9 v2(124.03,117.5) ; v2(120.64,117.75) 120.29,117.75 119.94,117.41 v1(119.71,117.41) 119.65,117.35 R4392.1
  BOTTOM w0.112: v2(124.03,117.5) 120.9,117.5 v2(120.64,117.75)
FM_M2F_OCP_ADJ: length 11.9
  TOP w0.112: R4393.1 142.7,117.1 142.87,117.28 143.59,117.28 143.77,117.46 v1(146.26,117.46) 146.4,117.46 146.42,117.48 148.59,117.48 149.01,117.9 151.67,117.9 151.96,117.78 152.1,117.64 152.1,117.11 151.62,116.62 U24.9
FM_M2G_OCP_ADJ: length 8.6
  BOTTOM w0.112: U33.9 162,119.56 161.02,120.54 161.02,120.93 161.56,121.47 162.82,121.47 163.93,120.37 165.42,120.37 v3(165.48,120.31) 165.54,120.24 R4394.1
FM_M2H_OCP_ADJ: length 7.8
  BOTTOM w0.112: U32.9 134.26,116.61 133.8,117.07 133.8,118.26 134.11,118.57 135.43,118.57 136.37,117.63 v3(137.08,117.63) 138.82,117.63 R4395.1
FM_M2I_OCP_ADJ: length 8.1
  BOTTOM w0.112: R4396.1 114.87,117.07 v3(113.79,117.07) 112.49,117.07 111.49,118.07 110.54,118.07 110,117.53 110,116.65 110.41,116.24 U31.9
FM_M2J_OCP_ADJ: length 7.6
  BOTTOM w0.112: R4397.1 v3(88.34,116.96) 87.12,116.96 86.07,118.01 84.92,118.01 84.57,117.66 84.57,116.4 84.77,116.2 U30.9
FM_M2K_OCP_ADJ: length 8.9
  BOTTOM w0.112: U29.9 60.58,116.24 60.24,116.59 60.24,117.49 60.83,118.09 61.92,118.09 63.11,116.9 v3(63.87,116.9) 64.55,116.22 R4398.1
FM_M2L_OCP_ADJ: length 7.2
  TOP w0.112: v2(41.73,119.38) 42.07,119.04 42.07,118.44 41.59,117.97 v1(40.33,117.97) 38.73,117.97 v2(37.89,118.81)
  BOTTOM w0.112: v2(37.89,118.81) 37.99,118.71 U28.9 ; R4399.1 42.11,119 v2(41.73,119.38)
FM_OE_RST_N: length 10.2
  TOP w0.112: U63.1 85.42,34.78 85.2,35 v1(85.2,35.96) 85.2,36.36 86.54,37.7 U62.4 88.12,37.7 88.36,37.47 R3219.2 89.5,36.77 90.6,36.77 Q36.G
FM_PLD_VCCIO_1_5_P1V8: length 94.4
  TOP w0.112: R4228.1 53.74,48.95 55.5,47.19 v2(55.53,47.19)
  IN1 w0.122: v2(66.99,30.94) 66.83,30.77 60.88,30.77 59.49,29.39 59.49,26.62 58.07,25.2 41.04,25.2 39.52,23.68 36.72,23.68 35.11,25.28 35.11,27.41 34.32,28.2 32.79,28.2 v2(31.01,29.98)
  BOTTOM w0.112: R4222.2 R4218.2 R4230.1 9.58,27.62 9.73,27.77 11.27,27.77 11.71,27.33 14.86,27.33 16.71,29.18 28.29,29.18 29.16,29.54 30.58,29.54 31.01,29.97 v2(31.01,29.98) ; v2(66.99,30.94) 66.55,31.38 66.55,33.12 62.65,37.02 62.65,40.66 62.47,40.83 62.47,42.24 57.51,47.19 v2(55.53,47.19)
FM_PLD_VCCIO_1_5_P1V8_R: length 8.8
  TOP w0.112: U86.K1 47.79,45.44 48.38,46.03 49.64,46.03 51.99,48.39 52.63,48.39 52.94,48.7 R4228.2
FM_PLD_VCCIO_1_5_P3V3SB: length 94.8
  TOP w0.112: R4229.1 53.99,50.17 55.04,49.11 55.04,48.38 55.6,47.82 55.6,47.82 v2(55.6,47.82)
  IN1 w0.122: v2(30.02,30.05) 30.39,30.42 31.2,30.42 32.57,29.05 32.57,29.02 33.03,28.56 34.47,28.56 35.78,27.26 35.78,25.2 37.03,23.95 39,23.95 40.52,25.47 57.8,25.47 58.89,26.57 58.89,29.18 60.77,31.05 66.48,31.05 66.81,31.38 67.45,31.38 v2(67.84,30.99)
  BOTTOM w0.112: v2(30.02,30.05) 29.77,29.8 29.01,29.8 28.14,29.44 15.74,29.44 15.37,29.08 15.37,28.47 14.65,27.74 R4231.1 R4225.2 R4226.2 ; v2(55.6,47.82) 60.87,47.82 63.9,44.79 63.9,44.17 63.03,43.3 63.03,41.61 63.32,41.32 63.6,40.65 63.6,36.45 66.82,33.23 66.82,32.01 v2(67.84,30.99)
FM_PLD_VCCIO_1_5_P3V3SB_R: length 9.8
  TOP w0.089: 46.46,45.75 45.76,45.75 U86.K2
  TOP w0.112: 46.46,45.75 47.73,45.75 48.29,46.31 49.54,46.31 51.36,48.13 v1(51.67,48.9) 51.98,49.63 52.51,50.17 R4229.2
FM_PLD_VCCIO_PMOS_1_G: length 8.9
  BOTTOM w0.112: Q44.G 3.64,34.5 3.56,34.42 R4221.1 ; R4220.2 R4221.1 ; R4221.1 3.56,33.45 4.14,32.87 4.14,30.38 Q46.G 3.62,29.99 v3(2.13,28.49)
FM_PLD_VCCIO_PMOS_2_G: length 10.7
  BOTTOM w0.112: R4224.1 7.64,33.39 9.7,33.39 10.79,32.3 10.79,30.53 Q47.G ; R4224.1 7.19,35.14 Q48.G v3(8.66,35.2) ; R4224.1 R4223.2
FM_PLD_VCCIO_Q45_D: length 2.9
  BOTTOM w0.112: Q45.D 5.5,31.91 v3(4.82,32.6) 4.36,33.05 R4221.2
FM_PLD_VCCIO_Q45_G: length 4.8
  BOTTOM w0.112: R4222.1 7.01,28.65 7.01,29.72 Q45.G 5.05,28.35 v3(4.45,28.35)
FM_PLD_VCCIO_Q49_D: length 5.6
  BOTTOM w0.112: Q49.D 11.83,31.84 10.79,32.88 10.79,33.45 v3(10.41,33.83) R4224.2
FM_PLD_VCCIO_Q49_G: length 3.4
  BOTTOM w0.112: R4225.1 13.46,28.54 14.43,29.52 v3(14.43,29.67) 14.16,29.94 Q49.G
FM_POWER_EN: length 366
  TOP w0.112: v2(25.01,16.49) 24.33,17.17 24.33,17.97 R3618.1 ; v2(57.62,5.82) 57.62,6.56 58.55,7.49 58.55,10.35 58.05,10.85 v2(57.77,10.85) 57.77,18.49 58.81,19.53 R3053.2 ; v2(38.52,56.86) 38.52,56.34 39.4,55.46 39.4,53.71 39.65,53.46 39.65,52.88 41.4,51.13 41.4,50 U86.W10 ; v2(196.78,32.78) 196.7,32.85 R3552.1 ; R4288.1 17.33,92.03 17.44,91.93 17.44,87.99 v2(17.16,87.71)
  IN1 w0.122: v2(28.7,59.99) 30.36,59.99 33.09,57.25 38.13,57.25 v2(38.52,56.86) ; v2(27.85,87.46) 27.52,87.8 17.24,87.8 v2(17.16,87.71) ; v2(196.78,32.78) 197.82,31.73 197.82,27.16 200.6,24.38 206.03,24.38 207.98,22.43 207.98,12.01 207.11,11.14 207.11,9.97 207.37,9.71 207.37,3.54 205.61,1.79 94.7,1.79 94.3,2.18 82.08,2.18 79.76,4.51 66.47,4.51 65.92,5.06 58.58,5.06 57.82,5.82 v2(57.62,5.82) 56.89,5.82 56.83,5.76 37.51,5.76 36.71,6.56 36.71,7.3 36.01,8.01 27.62,8.01 24.14,11.49 24.14,15.61 v2(25.01,16.49)
  IN2 w0.122: v2(27.85,87.46) 27.93,87.39 27.93,86.23 29.74,84.42 29.74,79.7 29.07,79.03 29.07,76.43 28.07,75.42 28.07,74.22 29.09,73.2 29.09,61.14 28.7,60.75 v2(28.7,59.99) 28.7,59.28 28.48,59.06 28.48,55.65 27.4,54.57 27.4,49.72 25.9,48.23 25.9,47.43 26.94,46.4 26.94,37.64 25.96,36.66 25.96,35.5 25.37,34.1 25.37,32.37 26.21,31.54 26.21,28.14 26.22,28.13 26.22,26.84 26.93,26.13 26.93,23.52 25.46,22.05 25.46,18.11 25.01,17.66 v2(25.01,16.49)
  BOTTOM w0.112: v3(56.43,12.41) 57.12,11.71 R4357.2 57.7,10.93 v2(57.77,10.85)
FM_POWER_EN_R: length 18.6
  TOP w0.112: R3053.1 v4(59.72,15.06)
  BOTTOM w0.112: J41.51 59.7,10.22 61.18,11.7 61.18,13.59 v4(59.72,15.06) 64.21,15.06 64.51,14.76 R4356.1
FM_POWER_EN_R1: length 382
  TOP w0.112: U26.12 14.18,105.84 14.6,105.42 14.6,105.03 v2(15.23,104.4) 15.34,104.4 16.13,105.19 U26.9 ; 184.29,143.5 184.29,144.05 183.7,144.64 U50.1 ; 184.29,143.5 183.47,142.69 U50.4 v2(181.57,142.69) ; 184.29,143.5 185.1,142.69 186.08,142.69 ; 186.08,142.69 186.73,143.34 U50.12 ; 186.08,142.69 187.38,141.39 U50.9 ; v2(12.88,102.18) U26.1 12.84,100.93 12.84,98.53 12.22,97.9 R4289.2 12.49,97.43 12.81,97.1 12.81,96.15 12.25,95.58 v2(11.89,95.58) ; U26.4 14.83,102.06 v2(14.58,102.31) ; 15.01,87.72 14.61,87.72 13.74,88.59 U25.4 13.74,91.2 v2(13.73,91.2) ; 15.01,87.72 14.43,87.14 13.15,87.14 12.65,86.64 12.65,84.55 12.44,84.34 U25.9 12.44,81.99 12.07,81.61 12.07,80.89 R2847.1 ; 15.01,87.72 15.32,87.42 15.32,85.37 14.39,84.45 U25.12 14.39,82.06 14.21,81.88 14.21,80.85 R2848.2 ; 15.01,87.72 15.56,87.72 15.69,87.85 U25.1 15.69,91.19 R4288.2 16.22,91.23 16.54,91.56 C1229.1
  IN1 w0.122: v2(15.23,104.4) 14.58,103.75 v2(14.58,102.31) ; v2(165.95,111.38) 165.95,107.52 157.83,99.41 157.83,87.88 154.16,84.21 152.64,84.21 152.33,84.51 146.88,84.51 116.67,54.31 112.32,54.31 95.54,47.36 92.4,47.36 91.59,46.55 87.62,46.55 75.3,34.23 70.71,34.23 70.07,33.59 66,33.59 65.59,33.18 59.88,33.18 56.93,30.23 43.78,30.23 43.74,30.2 43.72,30.2 43.2,29.67 43.2,28.13 v2(43.62,27.71) ; v2(16.38,34.11) 11.11,39.38 6.5,39.38 5.34,40.54 5.34,43.36 3.8,44.9 3.8,61.18 v2(2.11,62.87)
  IN2 w0.122: v2(16.38,34.11) 16.38,32.6 15.95,32.17 15.95,30.24 16.81,29.37 23.22,29.37 24.09,28.5 24.09,26.25 v2(24.64,25.7)
  BOTTOM w0.112: v2(24.64,25.7) 24.95,25.39 26.46,25.39 27.11,26.04 33.33,26.04 37.51,30.21 41.11,30.21 v2(43.62,27.71) ; v2(181.57,142.69) 175.36,136.48 175.36,123.61 173.01,121.26 173.01,117.26 172.29,116.54 171.03,116.54 170.49,116.01 170.49,112.82 169.53,111.86 168.38,111.38 v2(165.95,111.38) ; v2(2.11,62.87) 1.93,63.05 1.93,73.91 4.42,76.41 4.82,76.41 6.4,77.99 6.4,79.69 7.12,80.41 9.12,80.41 10.75,82.04 10.75,82.72 10.24,83.23 10.24,84.26 12.72,86.74 12.72,88.58 13.73,89.59 v2(13.73,91.2) 14.25,91.71 14.25,92.86 12.62,94.49 12.62,95.01 12.05,95.58 v2(11.89,95.58) ; v2(14.58,102.31) 13.02,102.31 v2(12.88,102.18)
FM_POWER_EN_R2: length 8.2
  BOTTOM w0.112: R4357.1 R4358.2 59.05,12.78 59.84,11.99 U107.4 60.6,11.67 60.87,11.94 60.87,13.46 60.22,14.11 59.58,14.11 v3(58.89,14.8)
FM_POWER_EN_R3: length 2.9
  BOTTOM w0.112: U107.2 63.71,12.32 R4356.2 v3(63.71,13.54)
FRU_ADDR0: length 3.5
  TOP w0.112: U6.1 12.29,28.65 12.06,28.42 v1(12.06,28.19) 12.06,27.71 R16.2
FRU_ADDR1: length 3.2
  TOP w0.112: R17.1 13.89,27.86 13.66,28.09 v1(13.66,28.35) 13.66,29.91 U6.2
FRU_ADDR2: length 3.5
  TOP w0.112: U6.3 14.83,29.54 15.37,29.01 v1(15.37,28.22) 14.93,27.79 R18.1
I2C_GPIO_INT_N: length 3.1
  BOTTOM w0.112: R4163.1 78.84,47.69 v3(79.32,48.17) 79.32,48.52 79.54,48.74 U101.22
I2C_PESW_M2A_EN: length 284
  TOP w0.112: U34.P30 v6(194.59,86.02) ; R3565.1 205.24,93.09 v2(204.81,92.66)
  IN1 w0.122: v2(204.81,92.66) 204.81,93.44 201.82,96.43 200.63,96.43 200.05,97.01 199.19,97.01 198.66,97.53 196.95,97.53 193.35,101.13 192.2,101.61 165.79,101.61 163.95,99.76 163.95,98.44 163.88,98.38 163.71,98.2 163.71,98.2 160.92,95.41 160.92,95.41 160.87,95.36 160.87,95.3 160.87,95.3 160.87,84.03 158.09,81.25 158.09,74.01 154.05,69.98 152.96,69.98 151.95,68.96 136.25,68.96 118.33,51.04 112.34,51.04 98.24,45.2 96.13,43.79 89.65,43.79 v2(88.36,42.49)
  IN2 w0.102: 196.45,86.62 198.77,86.62 198.99,86.84 198.99,87.28 199.63,87.92 200.57,87.92
  IN2 w0.122: v6(194.59,86.02) 194.59,85.78 194.85,85.52 195.99,85.52 196.1,85.63 196.1,86.27 196.45,86.62 ; 200.57,87.92 203.93,91.28 203.93,91.56 204.34,91.97 204.34,92.34 204.66,92.66 v2(204.81,92.66)
  BOTTOM w0.112: R3529.1 29.26,88.52 29.01,88.78 29.01,90.97 29.36,91.33 29.48,91.33 33.51,95.36 35.32,95.36 37.27,93.41 60.63,93.41 61.9,94.68 68.41,94.68 71.98,91.11 79.57,91.11 86.71,83.97 86.71,75.88 91.07,71.52 91.07,60.59 88.93,58.45 88.93,48.01 87.8,46.88 87.8,43.05 v2(88.36,42.49)
I2C_PESW_M2A_EN_LVC: length 22.3
  TOP w0.112: U25.2 15.04,92.84 15.21,93 17.16,93 17.89,92.27 17.89,86.5 v1(17.66,86.27) 18.22,85.71 18.22,84.91 v2(18.43,84.7)
  IN1 w0.122: v2(24.06,84.66) 23.41,85.31 20.59,85.31 20.2,84.92 20.2,84.47 19.98,84.24 19.51,84.24 19.06,84.7 v2(18.43,84.7)
  BOTTOM w0.112: R3511.2 23.83,84.89 v2(24.06,84.66)
I2C_PESW_M2A_EN_LVC_R: length 7.2
  BOTTOM w0.112: R3511.1 R91.1 R2833.2 25.91,87.33 25.5,87.73 v3(25.34,87.73) 24.12,87.73 23.43,88.42 U72.2
I2C_PESW_M2A_EN_R: length 5.5
  BOTTOM w0.112: U72.1 24.08,88.51 24.33,88.27 v3(27.2,88.27) 27.46,88.52 R3529.2
I2C_PESW_M2B_EN: length 291
  TOP w0.112: R3566.1 205.36,94.18 204.89,94.65 v2(204.89,94.72) ; U34.P29 v6(193.59,86.02)
  IN1 w0.122: v2(204.89,94.72) 202.07,97.54 199.5,97.54 199.12,97.91 199.12,98.07 198.38,98.81 196.6,98.81 194.13,101.28 192.3,102.03 165.61,102.03 163.52,99.94 163.52,98.62 160.49,95.59 160.45,95.55 160.44,95.54 160.44,95.48 160.44,95.47 160.44,95.18 160.43,95.17 160.43,84.41 157.58,81.56 157.58,74.11 154.16,70.69 152.85,70.69 152.55,71 137.37,71 117.85,51.47 112.25,51.47 98.06,45.59 96,44.22 89.46,44.22 87.71,42.47 v2(87.63,42.47)
  IN2 w0.102: v6(193.59,86.02) 193.99,86.42 195.88,86.42 196.33,86.88 197.71,86.88 198.25,87.42 198.84,87.42 199.57,88.15 200.17,88.15 200.22,88.2
  IN2 w0.122: 200.22,88.2 200.25,88.2 203.5,91.45 203.5,91.83 203.91,92.24 203.91,92.85 204.66,93.6 204.66,94.49 v2(204.89,94.72)
  BOTTOM w0.112: v2(87.63,42.47) 87.41,42.69 87.41,47.05 88.52,48.16 88.52,58.6 90.68,60.75 90.68,71.35 86.31,75.72 86.31,83.82 79.41,90.72 71.81,90.72 68.25,94.29 62.07,94.29 60.59,92.81 38.64,92.81 v3(38.02,92.2) 32.46,92.2 31.88,91.62 31.88,90.14 28.15,86.41 28.14,86.41 25.75,84.01 24.07,84.01 R3530.1
I2C_PESW_M2B_EN_LVC: length 13.8
  TOP w0.112: U25.5 13.09,88.57 12.11,87.59 v2(12.11,84.79)
  IN1 w0.122: v2(19.68,84.7) 19.23,85.16 16.13,85.16 15.33,84.35 12.76,84.35 12.33,84.79 v2(12.11,84.79)
  BOTTOM w0.112: R3512.2 v2(19.68,84.7)
I2C_PESW_M2B_EN_LVC_R: length 5.8
  BOTTOM w0.112: R3512.1 R2834.2 R92.1 21.74,86.61 21.38,86.97 v3(21.38,87.46) 21.38,87.78 22.13,88.53 U72.4
I2C_PESW_M2B_EN_R: length 3.7
  BOTTOM w0.112: R3530.2 22.76,86.58 23.31,87.13 v3(23.31,87.48) 23.31,87.91 22.78,88.44 U72.3
I2C_PESW_M2C_EN: length 290.5
  TOP w0.112: U34.P32 v6(196.59,86.02) ; R3567.1 v2(204.78,92.02)
  IN1 w0.122: v2(204.78,92.02) 204.29,92.51 204.29,93.35 201.74,95.91 200.38,95.91 199.78,96.51 197.33,96.51 193.07,100.78 192.09,101.18 165.97,101.18 164.33,99.55 164.33,98.22 164.06,97.95 164.06,97.95 163.88,97.78 161.34,95.24 161.34,95.24 161.3,95.19 161.3,95.19 161.3,83.52 158.55,80.77 158.55,72.37 154.16,67.99 152.64,67.99 152.34,68.29 136.19,68.29 118.51,50.61 112.42,50.61 98.42,44.81 96.26,43.36 90.04,43.36 88.71,42.03 87.23,42.03 v2(86.82,42.44)
  IN2 w0.102: v6(196.59,86.02) 196.99,86.42 198.85,86.42 199.19,86.76 199.19,87.2 199.62,87.63 200.88,87.63
  IN2 w0.122: v2(204.78,92.02) 204.78,91.72 204.35,91.29 204.35,91.1 200.88,87.63
  BOTTOM w0.112: v2(86.82,42.44) 86.82,47.02 88.03,48.23 88.03,58.69 88.65,59.31 88.65,59.67 87.47,60.85 87.47,74 85.9,75.57 85.9,83.67 79.24,90.33 71.65,90.33 68.08,93.9 62.23,93.9 60.75,92.42 39.24,92.42 38.13,91.31 33.61,91.31 25.91,83.62 23.86,83.62 23.18,84.3 22.05,84.3 22.02,84.27 19.5,84.27 19.13,84.64 19.13,84.86 R3531.1
I2C_PESW_M2C_EN_LVC: length 5.4
  TOP w0.112: v2(13.09,86.08) U25.10
  BOTTOM w0.112: v2(13.09,86.08) 13.16,86.14 14.75,86.14 R3513.2
I2C_PESW_M2C_EN_LVC_R: length 8
  BOTTOM w0.112: R3513.1 R93.1 R2835.2 17.63,87.57 v3(18.07,88.01) 18.12,88.06 20.37,88.06 20.83,88.53 U72.6
I2C_PESW_M2C_EN_R: length 4.9
  BOTTOM w0.112: R3531.2 18.67,86.51 v3(19.43,87.27) 19.74,87.58 20.53,87.58 21.48,88.53 U72.5
I2C_PESW_M2D_EN: length 296.5
  TOP w0.112: R3568.1 v2(204.78,90.98) ; U34.P33 v6(197.59,86.02)
  IN1 w0.122: v2(204.78,90.98) 203.86,91.9 203.86,93.17 201.58,95.45 197.74,95.45 192.76,100.43 191.98,100.75 166.14,100.75 164.7,99.31 164.7,97.99 164.06,97.35 164.06,97.35 161.77,95.06 161.77,95.06 161.73,95.02 161.73,83.19 159.21,80.67 159.21,72.42 153.97,67.18 153.11,67.18 152.27,66.34 135.11,66.34 118.94,50.18 112.51,50.18 98.6,44.41 96.39,42.94 90.39,42.94 89.69,42.23 v2(89.69,42.19)
  IN2 w0.102: v6(197.59,86.02) 197.99,85.62 198.78,85.62 199.87,86.71 200.73,86.71
  IN2 w0.122: 200.73,86.71 204.78,90.76 v2(204.78,90.98)
  BOTTOM w0.112: v2(89.69,42.19) 89.82,42.06 90.76,42.06 91.08,42.38 91.08,42.6 91.43,42.95 91.89,42.95 93.6,44.66 93.6,55.48 95.48,57.36 95.48,59.14 95.32,59.3 95.32,81.64 80.92,96.05 74.59,96.05 71.52,99.12 60.06,99.12 58.8,97.85 52.81,97.85 52.19,98.46 50.33,98.46 49.21,99.58 45.48,99.58 43.53,101.53 24.1,101.53 23.21,101.16 22.55,101.16 22.41,101.3 19.94,101.3 18.85,100.21 R3532.1
I2C_PESW_M2D_EN_LVC: length 22.4
  TOP w0.112: U25.13 15.04,84.4 16.38,85.73 v2(16.38,87.51)
  IN2 w0.122: v2(18.37,100.6) 18.58,100.4 18.58,98.34 17.06,96.82 17.04,96.82 16.55,96.33 16.55,91.89 17.23,91.21 17.23,88.71 16.38,87.85 v2(16.38,87.51)
  BOTTOM w0.112: R3514.2 16.88,100.36 18.13,100.36 v2(18.37,100.6)
I2C_PESW_M2D_EN_LVC_R: length 7.1
  BOTTOM w0.112: U72.8 20.18,95.98 19.63,96.53 18.25,96.53 v3(17.94,96.84) 17.83,96.95 R94.1 R2836.2 R3514.1
I2C_PESW_M2D_EN_R: length 4.4
  BOTTOM w0.112: R3532.2 18.85,97.46 19,97.3 v3(19.13,97.3) 19.56,97.3 20.83,96.03 U72.9
I2C_PESW_M2E_EN: length 292.8
  TOP w0.112: U34.R27 v6(191.59,85.02) ; R3569.1 205.09,97.66 v2(204.52,97.66)
  IN1 w0.122: v2(93.02,44.81) 93.43,45.22 96.03,45.22 112.35,51.98 117.75,51.98 137.5,71.73 152.01,71.73 152.93,72.64 154.02,72.64 157.07,75.7 157.07,81.79 160,84.72 160,95.58 160.01,95.59 160.01,95.74 163.09,98.82 163.09,100.12 165.44,102.46 186.97,102.46 188.11,103.59 193.89,103.59 196.93,100.56 199.44,100.56 199.56,100.68 201.09,100.68 204.12,97.66 v2(204.52,97.66)
  IN2 w0.089: 198.02,90.62 198.89,90.62 198.98,90.71 198.98,91.66 ; 193.12,87.64 193.14,87.62 194.77,87.62 194.98,87.83 194.98,88.74
  IN2 w0.122: 198.98,91.66 199.06,91.74 199.06,92.33 199.46,92.72 199.74,92.72 200.51,93.49 201.97,93.49 202.78,94.31 202.78,95.92 v2(204.52,97.66) ; 198.02,90.62 196.94,89.54 195.27,89.54 195.04,89.31 195.04,88.79 194.98,88.74 ; 193.12,87.64 192.87,87.64 192.11,86.88 192.11,85.54 v6(191.59,85.02)
  BOTTOM w0.112: R3533.1 21.48,99.68 21.48,100.58 21.8,100.91 22.23,100.91 22.39,100.76 25,100.76 25.61,100.15 33.6,100.15 34.43,100.98 43.42,100.98 47.34,97.07 59.12,97.07 60.39,98.34 69.92,98.34 73.35,94.91 80.95,94.91 94.54,81.32 94.54,58.54 93.19,57.19 93.19,46.81 93.02,46.63 v2(93.02,44.81)
I2C_PESW_M2E_EN_LVC: length 8.3
  TOP w0.112: U26.2 13.53,102.47 14.71,103.65 v1(18.34,103.65) 19.29,103.65 R3516.2
I2C_PESW_M2E_EN_LVC_R: length 11.1
  TOP w0.112: R3516.1 21.11,102.63 21.11,101.16 v2(20.69,100.75)
  BOTTOM w0.112: U72.10 21.48,96.11 20.88,96.72 R95.1 R2837.2 19.63,98.46 19.3,98.78 19.3,100.1 19.95,100.75 v2(20.69,100.75)
I2C_PESW_M2E_EN_R: length 3.4
  BOTTOM w0.112: U72.11 22.13,96.2 21.85,96.48 v3(21.85,97.32) 21.85,97.78 21.89,97.82 R3533.2
I2C_PESW_M2F_EN: length 283.8
  TOP w0.112: R3570.1 204.43,98.45 v2(204.23,98.25) ; U34.R28 v6(192.59,85.02)
  IN1 w0.122: v2(204.23,98.25) 200.93,101.55 196.63,101.55 194.11,104.07 166.44,104.07 162.67,100.29 162.67,99 159.57,95.9 159.57,85 156.41,81.84 156.41,75.64 154.16,73.39 152.85,73.39 152.55,73.7 138.83,73.7 117.6,52.46 112.38,52.46 95.94,45.65 93.1,45.65 v2(92.26,44.81)
  IN2 w0.089: 195.77,88.52 195.72,88.48 195.4,88.48 195.18,88.25 195.18,87.62 194.97,87.42 194.37,87.42 194.11,87.16 ; 197.87,90.05 198.23,90.42 199.08,90.42 199.18,90.52 199.18,91.35 199.31,91.48
  IN2 w0.122: 194.11,87.16 194.11,86.89 193.76,86.54 193.33,86.54 193.17,86.38 193.17,85.6 v6(192.59,85.02) ; v2(204.23,98.25) 204.61,98.25 204.98,97.89 204.98,97.41 203.35,95.78 203.35,94.27 201.77,92.69 201.77,92.1 201.15,91.48 199.31,91.48 ; 197.87,90.05 196.9,89.08 196.33,89.08 195.77,88.52
  BOTTOM w0.112: R3534.1 28.01,97.66 30.76,97.66 v3(31.5,98.4) 35.79,98.4 38.3,95.89 59.6,95.89 60.87,97.16 69.44,97.16 72.87,93.73 80.46,93.73 89.99,84.21 89.99,76.23 93.55,72.67 93.55,59.42 92.74,58.6 92.74,47.22 92.26,46.75 v2(92.26,44.81)
I2C_PESW_M2F_EN_LVC: length 5.8
  TOP w0.112: U26.5 15.48,101.95 16.18,102.65 17.72,102.65 v1(18.34,102.03) 18.91,102.03 19.12,102.24 R3520.2
I2C_PESW_M2F_EN_LVC_R: length 12
  TOP w0.112: R3520.1 20.17,101.93 20.17,100.51 20.58,100.1 20.58,99.8 20.88,99.5 21.56,99.5 22.01,99.96 v2(22.01,100.39)
  BOTTOM w0.112: v2(22.01,100.39) 22.38,100.03 22.38,98.81 22.73,98.46 R2838.2 R96.1 23.93,97.95 22.78,96.81 U72.12
I2C_PESW_M2F_EN_R: length 5.8
  BOTTOM w0.112: U72.13 23.43,94.42 23.8,94.06 24.76,94.06 v3(25.99,95.28) 26.42,95.71 R3534.2
I2C_PESW_M2G_EN: length 54.7
  TOP w0.112: U34.M26 v6(190.59,88.02) ; R3523.1 v2(182.83,129.39)
  IN2 w0.122: v6(190.59,88.02) 190.59,89.97 191.27,90.65 191.27,92.03 190.8,92.5 190.37,92.5 190.18,92.69 190.18,93.41 190.79,94.02 190.79,94.27 191.68,95.16 191.68,95.7 192.63,96.66 192.63,101.36 193.11,101.84 193.11,103.33 192.22,104.22 190.92,104.22 190.45,104.69 190.45,105.19 191.76,106.5 191.76,109.86 187.28,114.35 187.28,122.63 186.63,123.28 186.63,128.25 185.48,129.39 v2(182.83,129.39)
  BOTTOM w0.112: R3575.1 191.75,89.18 v6(190.59,88.02)
I2C_PESW_M2G_EN_LVC: length 207.5
  TOP w0.112: U26.10 15.48,105.84 v2(15.13,105.49) ; v2(161.24,110.74) 161.25,110.77 162.33,111.22 163.38,111.22 167.92,113.1 168.94,113.1 169.52,113.67 170.39,113.67 170.77,114.06 170.77,126.23 171.33,126.79 173.44,126.79 177.08,130.42 182.63,130.42 183.42,129.64 183.42,129.16 183.18,128.93 R3515.2
  BOTTOM w0.112: v2(15.13,105.49) 16.73,103.9 29.32,103.9 30.12,103.1 48.87,103.1 52.25,99.72 52.68,99.72 53.37,99.03 58.02,99.03 59.29,100.29 72.02,100.29 74.78,97.53 78.5,97.53 79.99,99.01 90.01,99.01 90.34,99.34 97.58,99.34 98.78,100.55 114.45,100.55 117.72,103.82 125.9,103.82 127.11,102.61 128.22,102.61 129.3,103.69 129.3,107.02 130.34,108.06 132.29,108.06 133.2,107.14 136.09,107.14 136.36,106.87 142.28,106.87 143.54,107.4 145.74,107.4 149.98,103.16 158.58,103.16 159.97,103.74 161.86,105.63 161.86,108.85 161.24,109.47 v2(161.24,110.74)
I2C_PESW_M2G_EN_LVC_R: length 8.9
  TOP w0.112: R3515.1 R2918.1 R2923.2 181.01,126.89 v2(178.8,124.68) 177.6,123.48 U71.2
I2C_PESW_M2G_EN_R: length 8.8
  TOP w0.112: U71.1 177.36,124.13 177.86,124.64 177.86,125.49 v2(178.77,126.39) 180.57,128.19 180.57,129.03 R3523.2
I2C_PESW_M2H_EN: length 62.3
  TOP w0.112: R3524.1 182.28,125.85 181.72,125.29 181.09,125.29 179.65,123.85 v2(179.65,121.18) ; U34.L30 v6(194.59,89.02)
  IN1 w0.122: v2(203.63,105.28) 203.02,105.28 202.74,105.56 202.74,106.31 200.7,108.35 195.72,108.35 190.72,113.36 187.48,113.36 181.17,119.67 181.17,120.27 180.26,121.18 v2(179.65,121.18)
  IN2 w0.089: 193.18,94.27 193.18,92.28 192.99,92.09 192.99,90.7 193.27,90.42 193.86,90.42 194.13,90.14
  IN2 w0.122: 193.18,94.27 194.04,95.13 194.36,95.13 195.09,95.86 195.09,96.39 196.18,97.49 197.69,97.49 198.11,97.9 198.11,98.31 199.29,99.49 199.76,99.49 202.31,102.04 202.31,103.12 203.63,104.45 v2(203.63,105.28) ; v6(194.59,89.02) 194.13,89.47 194.13,90.14
  BOTTOM w0.112: R3576.1 194.49,88.46 194.59,88.56 v6(194.59,89.02)
I2C_PESW_M2H_EN_LVC: length 196.1
  TOP w0.112: v2(161.77,110.39) 162.06,110.68 162.41,110.82 163.46,110.82 168,112.7 170.5,112.7 171.17,113.37 171.17,124.86 171.6,125.3 R3517.2 ; U26.13 13.53,105.75 13.38,105.6 13.38,104.1 13.53,103.95 13.53,103.31 v2(13.14,102.92)
  BOTTOM w0.112: v2(161.77,110.39) 162.33,109.83 162.33,105.55 160.11,103.33 158.76,102.77 149.63,102.77 145.39,107.01 143.62,107.01 142.36,106.48 136.2,106.48 135.93,106.75 133.04,106.75 132.12,107.67 130.51,107.67 129.69,106.85 129.69,103.53 128.38,102.22 126.88,102.22 125.67,103.43 117.88,103.43 114.61,100.16 99.88,100.16 98.55,98.83 90.38,98.83 90.17,98.62 80.15,98.62 78.67,97.13 74.62,97.13 71.86,99.9 59.45,99.9 58.18,98.63 53.21,98.63 52.54,99.31 50.71,99.31 49.65,100.37 46.11,100.37 44.16,102.32 29.8,102.32 29.1,103.01 17.19,103.01 16.84,102.66 16.23,102.66 15.58,103.32 13.55,103.32 v2(13.14,102.92)
I2C_PESW_M2H_EN_LVC_R: length 8.3
  TOP w0.112: R2919.1 R3517.1 173.67,125.3 174.54,124.43 v2(174.54,123.89) 174.54,122.66 175.02,122.18 U71.4
  BOTTOM w0.112: v2(174.54,123.89) 174.54,124.43 173.8,125.17 R2925.2
I2C_PESW_M2H_EN_R: length 6.7
  TOP w0.112: R3524.2 181.07,125.88 v2(178.03,122.83) U71.3
I2C_PESW_M2I_EN: length 65.4
  TOP w0.112: U34.L29 v6(193.59,89.02) ; R3525.1 v2(171.6,123.27)
  IN1 w0.122: v2(171.6,123.27) 174.04,123.27 182.85,114.46 185.46,114.46 187.09,112.83 190.64,112.83 195.54,107.92 200.52,107.92 202.29,106.16 202.29,105.3 202.82,104.78 v2(203.05,104.78)
  IN2 w0.089: 192.82,93.43 192.98,93.27 192.98,92.67 192.88,92.57
  IN2 w0.122: v2(203.05,104.78) 201.78,103.51 201.78,102.29 199.53,100.05 198.85,100.05 196.95,98.15 195.99,98.15 194.05,96.21 194.05,95.55 192.82,94.32 192.82,93.43 ; v6(193.59,89.02) 192.86,89.74 192.86,90.13 192.17,90.82 192.17,91.52 192.52,91.87 192.52,92.21 192.88,92.57
  BOTTOM w0.112: R3571.1 195.18,89.77 194.97,89.56 194.13,89.56 v6(193.59,89.02)
I2C_PESW_M2I_EN_LVC: length 31
  TOP w0.112: U50.2 181.78,143.99 180.95,144.82 179.17,144.82 174.55,140.2 174.55,132.69 v2(174.7,132.54) ; R3518.2 v2(171.6,122.25)
  IN1 w0.122: v2(174.7,132.54) 173.88,131.72 173.88,125.86 171.78,123.76 171.33,123.76 171.06,123.49 171.06,123.28 171.4,122.45 v2(171.6,122.25)
I2C_PESW_M2I_EN_LVC_R: length 5.4
  TOP w0.112: U71.6 174.91,120.88 v1(174.24,120.22) R2920.1 R2926.2 R3518.1
I2C_PESW_M2I_EN_R: length 4.2
  TOP w0.112: U71.5 174.59,121.53 v1(174.28,121.84) 173.87,122.25 173.87,122.94 173.55,123.27 R3525.2
I2C_PESW_M2J_EN: length 55
  TOP w0.112: R3572.1 205.02,95.28 v2(204.67,95.63) ; U34.M32 v6(196.59,88.02) ; R3526.1 v2(187.87,123.39)
  IN2 w0.122: v6(196.59,88.02) 196.94,88.02 197.47,88.55 198.82,88.55 199.09,88.82 199.09,89.18 199.56,89.65 200.49,89.65 202.65,91.81 202.65,92.36 204.22,93.93 204.22,95.18 v2(204.67,95.63) 205.04,95.63 205.86,96.45 205.86,98.63 205.72,98.76 205.72,103.24 204.95,104.01 204.95,106.04 203.07,107.92 195.86,107.92 191.79,112 191.79,115.31 189.13,117.98 189.13,118.87 188.24,119.77 188.24,123.03 v2(187.87,123.39)
I2C_PESW_M2J_EN_LVC: length 29.5
  TOP w0.112: R3519.2 v2(186.72,120.35) ; U50.5 v2(183.91,142.04)
  IN1 w0.122: v2(186.72,120.35) 186.09,120.97 186.09,123.31 186.66,123.88 186.66,133.07 187.31,133.72 187.31,136.6 188.45,137.74 188.45,141.3 187.31,142.44 186.55,142.44 186.16,142.84 184.7,142.84 v2(183.91,142.04)
I2C_PESW_M2J_EN_LVC_R: length 6.3
  TOP w0.112: R2927.2 185.3,122.35 ; 185.3,122.35 184.94,121.99 184.92,121.99 v1(184.07,121.15) 183.67,120.75 183.42,120.75 182.9,120.23 U71.8 ; 185.3,122.35 R2921.1 R3519.1
I2C_PESW_M2J_EN_R: length 6
  TOP w0.112: R3526.2 185.29,123.39 v1(185.06,123.62) 184.76,123.31 184.76,122.68 182.96,120.88 U71.9
I2C_PESW_M2K_EN: length 64.1
  TOP w0.112: v2(184.65,126.1) 185.41,126.1 185.59,125.93 186.62,125.93 R3527.1 ; U34.M27 v6(191.59,88.02)
  IN1 w0.122: v2(184.65,126.1) 182.83,124.28 182.83,118.8 187.74,113.89 190.8,113.89 195.9,108.79 200.9,108.79 203.2,106.48 v2(203.2,105.87)
  IN2 w0.122: v2(203.2,105.87) 202.64,105.87 201.35,104.57 201.35,102.66 200.38,101.7 197.5,101.7 193.04,97.24 193.04,95.54 192.47,94.97 191.88,94.97 191.17,94.27 191.17,92.74 191.61,92.3 191.61,90.66 192.2,90.07 192.2,89.43 191.59,88.81 v6(191.59,88.02)
  BOTTOM w0.112: R3573.1 191.66,88.09 v6(191.59,88.02)
I2C_PESW_M2K_EN_LVC: length 23.8
  TOP w0.112: v2(189.81,125.91) 190.18,125.54 191.07,125.54 191.18,125.43 R3521.2 ; v2(187,142.9) 187.86,142.04 U50.10
  IN1 w0.122: v2(187,142.9) 187.48,142.9 188.92,141.47 188.92,137.44 187.84,136.36 187.84,134.53 188.22,134.14 188.22,128.54 188.48,128.28 188.48,127.23 v2(189.81,125.91)
I2C_PESW_M2K_EN_LVC_R: length 11.5
  TOP w0.112: U71.10 182.97,121.53 183.92,122.49 v1(183.92,122.72) 184.32,123.12 184.32,123.69 185.04,124.41 R2922.1 186.89,123.83 187.54,123.83 188.12,124.41 R2928.2 189.12,123.64 190.07,123.64 190.38,123.95 R3521.1
I2C_PESW_M2K_EN_R: length 6.3
  TOP w0.112: R3527.2 v1(185.06,125.43) 185.06,125.1 183.83,123.87 183.83,123.48 183.01,122.66 183.01,122.47 182.73,122.18 U71.11
I2C_PESW_M2L_EN: length 59.2
  TOP w0.112: U34.M31 v6(195.59,88.02) ; R3528.1 v2(187.77,127.46) ; R3574.1 v2(204.68,96.32)
  IN2 w0.122: v6(195.59,88.02) 195.9,88.02 196.45,88.56 196.88,88.56 197.91,89.59 198.86,89.59 199.81,90.54 200.78,90.54 202.22,91.98 202.22,92.54 203.79,94.1 203.79,95.43 v2(204.68,96.32) 204.68,96.32 205.41,97.05 205.41,98.47 205.29,98.59 205.29,103.04 204.52,103.81 204.52,105.86 202.92,107.47 195.71,107.47 190.49,112.69 190.49,115.66 187.73,118.42 187.73,122.86 187.1,123.49 187.1,126.78 v2(187.77,127.46)
I2C_PESW_M2L_EN_LVC: length 22.9
  TOP w0.112: U50.13 187.36,143.99 187.21,143.84 v2(186.81,143.84) ; R3522.2 191.18,127.41 190.43,128.16 v2(189.77,128.16)
  IN1 w0.122: v2(189.77,128.16) 190.55,128.93 190.55,131.36 189.68,132.23 189.68,134.83 190.57,135.72 190.57,138.69 189.08,142.29 187.53,143.84 v2(186.81,143.84)
I2C_PESW_M2L_EN_LVC_R: length 12.8
  TOP w0.112: R3522.1 190.38,127.27 190.25,127.4 189.3,127.4 R2929.2 187.78,127.01 186.88,127.01 R2924.1 186.2,126.56 184.42,126.56 v1(183.86,125.99) 183.29,125.43 183.29,123.63 182.49,122.83 U71.12
I2C_PESW_M2L_EN_R: length 7.2
  TOP w0.112: U71.13 182.49,123.48 182.85,123.85 182.85,125.88 184.18,127.2 v1(185.06,127.2) 185.32,127.46 R3528.2
I2C_PESW_MULTI_CONFIG_ADD0: length 4
  BOTTOM w0.112: Q38.D 55.07,35.98 v3(55.07,36.96) R3747.2 R3748.2
I2C_PESW_MULTI_CONFIG_ADD0_L: length 263.8
  TOP w0.112: U34.R33 v6(197.59,85.02)
  IN1 w0.102: 200.38,83.21 200.03,83.21 199.81,83.42 196.5,83.42 196.12,83.8 196.12,84.27 196.36,84.51 196.76,84.51 197.27,85.02 v6(197.59,85.02)
  IN1 w0.122: 200.38,83.21 200.46,83.28 204.74,83.28 205.03,83.58 205.22,83.58 205.97,84.33 205.97,86.35 206.63,87.01 206.63,97.39 204.91,99.12 204.57,99.12 201.21,102.47 196.91,102.47 193.45,105.94 193.45,107.87 190.55,110.77 v2(189.18,110.77) 189.18,110.35 190.07,109.46 191.4,109.46 193.17,107.69 193.17,106.82 191.52,105.17 189.58,105.17 188.91,104.49 166.26,104.49 162.24,100.47 162.24,99.18 159.14,96.08 159.14,85.31 155.2,81.36 155.2,77.12 154.13,76.05 152.69,76.05 152.33,76.4 140.78,76.4 117.3,52.92 112.36,52.92 95.84,46.08 92.93,46.08 92.12,45.27 88.15,45.27 75.83,32.95 71.24,32.95 70.6,32.31 66.53,32.31 66.13,31.9 60.41,31.9 58.04,29.53 58.04,27.74 56.74,26.44 55.92,26.44 54.17,28.19 v2(48.11,28.19)
  BOTTOM w0.112: R3430.1 178.43,118.77 R3433.1 179.04,116.73 179.04,114.72 C1249.1 184.38,114.68 184.7,115 184.85,115 v3(184.85,115) 189.08,110.77 v2(189.18,110.77) ; R3757.1 49.03,29.11 v2(48.11,28.19)
I2C_PESW_MULTI_CONFIG_ADD0_L_R: length 7.6
  BOTTOM w0.112: R3757.2 R3745.2 v3(50.37,31.23) 50.92,31.79 53,31.79 Q38.S
I2C_PESW_MULTI_CONFIG_ADD0_R: length 26.2
  TOP w0.089: 46.27,46.3 46.1,46.13 45.76,46.13 U86.M2
  TOP w0.112: 46.27,46.3 47.47,46.3 48.13,46.96 49.02,46.96 50.35,48.29 51.19,50.32 51.91,51.04 54.32,51.04 56.15,49.21 56.15,48.77 57.59,47.32 58.08,46.16 58.08,43.22 57.79,42.93 v2(57.79,42.87)
  BOTTOM w0.112: v2(57.79,42.87) 57.73,42.81 57.19,42.81 56.76,42.39 56.76,41.07 v3(56.51,40.82) 56.16,40.47 R3748.1
I2C_PESW_MULTI_CONFIG_ADD1: length 4.2
  BOTTOM w0.112: Q39.D 52.53,36.16 v3(52.53,36.88) R3751.2 R3752.2
I2C_PESW_MULTI_CONFIG_ADD1_L: length 264.6
  TOP w0.112: U34.T30 v6(194.59,84.02)
  IN1 w0.102: v6(194.59,84.02) 195.07,83.54 195.07,81.7 195.22,81.54 201.78,81.54 202.66,82.42
  IN1 w0.122: v2(43.64,29.49) 43.95,29.81 57.11,29.81 60.06,32.76 65.77,32.76 66.18,33.16 70.25,33.16 70.89,33.8 75.48,33.8 87.8,46.13 91.77,46.13 92.57,46.93 95.64,46.93 112.41,53.87 116.89,53.87 145.3,82.28 153.93,82.28 158.26,86.62 158.26,99.18 164.73,105.65 186.84,105.65 187.26,106.07 190.72,106.07 191.35,106.71 191.35,107.57 190.33,108.59 189.73,108.59 188.31,110.01 188.31,111.78 v2(188.62,112.09) 189.41,112.09 189.81,111.68 191.17,111.68 195.36,107.49 200.12,107.49 201.84,105.77 201.84,103.06 204.23,100.66 204.95,100.66 207.51,98.1 207.51,84.58 205.35,82.42 202.66,82.42
  BOTTOM w0.112: R3431.1 R3434.1 180.01,117.34 180.35,116.99 180.35,116.05 180.89,115.51 C1250.1 181.74,115.31 181.98,115.54 182.85,115.54 183.26,115.95 v3(183.64,115.95) 184.66,115.95 188.52,112.09 v2(188.62,112.09) ; v2(43.64,29.49) 44.01,29.11 R3758.1
I2C_PESW_MULTI_CONFIG_ADD1_L_R: length 8.1
  BOTTOM w0.112: Q39.S v3(49.11,33.44) 48.38,33.44 46.53,31.6 46.53,30.66 R3749.2 R3758.2
I2C_PESW_MULTI_CONFIG_ADD1_R: length 25.8
  TOP w0.089: 46.36,46.03 46.27,45.94 U86.L2
  TOP w0.112: v2(57.21,43.35) 57.47,43.61 57.47,46.59 57.31,46.97 55.71,48.58 55.71,49 54.11,50.6 52.4,50.6 51.27,49.48 50.7,48.08 49.19,46.58 48.21,46.58 47.65,46.03 46.36,46.03
  BOTTOM w0.112: R3752.1 53.7,39.52 54.89,40.72 55.25,40.72 56.24,41.7 56.24,42.49 57.03,43.28 57.15,43.28 v2(57.21,43.35)
I2C_PESW_MULTI_CONFIG_ADD2: length 4.9
  BOTTOM w0.112: R3756.2 58.37,38.16 R3755.2 57.23,37.68 v3(58.1,36.81) Q40.D
I2C_PESW_MULTI_CONFIG_ADD2_L: length 253.3
  TOP w0.112: U34.T31 v6(195.59,84.02)
  IN1 w0.102: v6(195.59,84.02) 196.08,83.53 196.08,82.87 196.39,82.56 200.07,82.56 200.36,82.84
  IN1 w0.122: v2(56.32,26.88) 56.58,26.88 57.61,27.92 57.61,29.71 60.24,32.33 65.95,32.33 66.36,32.74 70.43,32.74 71.07,33.38 75.65,33.38 87.98,45.7 91.94,45.7 92.75,46.5 95.74,46.5 112.44,53.42 117.05,53.42 142.73,79.11 152.33,79.11 152.64,78.8 154.16,78.8 154.56,79.19 154.56,81.4 158.72,85.56 158.72,96.26 161.81,99.35 161.81,100.65 166.09,104.92 187.27,104.92 187.95,105.61 190.86,105.61 191.78,106.53 191.78,107.74 190.49,109.03 189.89,109.03 188.74,110.19 188.74,111.17 v2(189.1,111.53) 189.39,111.24 191,111.24 195.18,107.06 199.93,107.06 201.34,105.65 201.34,102.95 204.06,100.23 204.75,100.23 207.08,97.9 207.08,86.86 206.4,86.17 206.4,84.12 205.12,82.84 200.36,82.84
  BOTTOM w0.112: v2(189.1,111.53) 189.1,112.5 184.53,117.07 C1251.1 183.16,117.85 182.81,118.2 v3(182.23,118.2) 181.36,117.32 R3435.1 R3432.1 ; R3759.1 53.72,28.55 55.39,26.88 v2(56.32,26.88)
I2C_PESW_MULTI_CONFIG_ADD2_L_R: length 6.7
  BOTTOM w0.112: R3759.2 R3753.2 56.54,31.72 v3(57.49,31.72) 58.51,32.74 Q40.S
I2C_PESW_MULTI_CONFIG_ADD2_R: length 21.2
  TOP w0.112: v5(43.92,48.42) 43.45,48.89 U86.U6
  IN1 w0.122: v2(57.36,42.36) 56.27,43.45 55.46,43.45 54.72,44.19 54.07,44.19 53.93,44.33 53.56,44.33 53.41,44.18 50.56,44.18 49.83,43.45 49.41,43.45 48.65,44.21 48.4,44.21 45.15,47.47 44.87,47.47 v5(43.92,48.42)
  BOTTOM w0.112: R3756.1 58.42,41.03 v3(58.06,41.39) 57.36,42.09 v2(57.36,42.36)
I2C_PESW_MULTI_CONFIG_ADD3: length 7.9
  BOTTOM w0.112: Q42.D 72.44,39.89 v3(71.98,39.89) R4063.2 R4067.2
I2C_PESW_MULTI_CONFIG_ADD3_L: length 295.8
  TOP w0.112: v2(202.82,83.95) 202.82,83.98 203.82,84.98 203.82,87.18 204.8,88.16 205.79,88.16 206.32,88.69 R4075.1 R4073.1 ; U34.T33 v6(197.59,84.02)
  IN1 w0.102: v6(197.59,84.02) 197.99,83.62 200.07,83.62 200.14,83.55 200.68,83.55
  IN1 w0.122: v2(73.1,31.98) 73.44,31.64 75.93,31.64 79.11,32.96 79.38,33.22 79.38,34.43 83.42,38.47 83.72,38.6 86.19,38.6 87.23,39.03 88.46,40.27 90.04,40.27 92.01,42.24 v2(93.13,42.24) ; 200.68,83.55 200.86,83.73 202.6,83.73 v2(202.82,83.95)
  IN2 w0.122: v2(202.82,83.95) 203.42,84.56 205.25,84.56 208.17,87.48 208.17,99.48 208.58,99.89 208.58,106.6 208.21,106.97 208.21,109.08 207.41,109.87 206.67,109.87 205.93,110.6 199.66,110.6 197.11,113.15 197.11,118.99 193.17,122.93 192.33,122.93 190.92,124.34 190.92,128.79 190.1,129.6 189.31,129.6 188.62,130.28 188.62,133.7 186.25,136.07 186.25,137.05 185.76,137.55 185.33,137.55 184.92,137.96 184.92,138.66 184.25,139.32 182.85,139.32 v2(182.36,139.81)
  BOTTOM w0.112: R4068.1 72.87,32.21 v2(73.1,31.98) ; v2(93.13,42.24) 98.88,47.99 98.88,60 99.89,61 99.89,80.98 96.12,84.75 96.12,92.82 103.07,99.77 114.77,99.77 118.05,103.04 121.85,103.04 124.07,100.82 127.54,100.82 130.14,103.43 130.14,106.75 130.67,107.28 131.96,107.28 132.88,106.36 135.77,106.36 136.04,106.09 142.45,106.09 142.45,106.09 142.78,106.09 146.48,102.38 158.97,102.38 161.23,103.32 167.57,109.66 168.84,110.51 176.77,118.44 176.77,136.87 179.71,139.81 v2(182.36,139.81)
I2C_PESW_MULTI_CONFIG_ADD3_L_R: length 3.6
  BOTTOM w0.112: Q42.S v3(72.85,35.08) 72.85,33.98 R4068.2 R4065.2
I2C_PESW_MULTI_CONFIG_ADD3_R: length 43.2
  TOP w0.089: U86.V7 42.65,49.74 42.65,50.21 42.8,50.98
  TOP w0.102: 42.8,50.98 42.8,51.97 v2(42.73,52.04)
  IN1 w0.122: v2(71.31,47.47) 71.25,47.52 65.74,47.52 65.66,47.6 56.57,47.6 55.72,46.75 55.35,46.75 55.09,47.01 55.09,47.2 54.27,48.02 49.65,48.02 47.75,49.91 47.75,50.64 46.6,51.79 45.75,52.14 44.67,52.14 44.57,52.04 v2(42.73,52.04)
  BOTTOM w0.112: R4063.1 67.05,41.21 67.05,42.41 67.52,42.89 67.52,43.68 v2(71.31,47.47)
I2C_PESW_MULTI_CONFIG_ADD4: length 7
  BOTTOM w0.112: Q43.D v3(66.75,38.53) 65.95,38.53 65.39,39.09 R4064.2 R4071.2
I2C_PESW_MULTI_CONFIG_ADD4_L: length 298.5
  TOP w0.112: U34.T32 v6(196.59,84.02) ; R4074.1 R4076.1 205.71,90.38 204.83,90.38 203.43,88.98 203.43,85.83 v2(202.86,85.26)
  IN1 w0.122: v2(93.77,42.22) 93.19,41.64 92.25,41.64 91.15,40.55 91.15,40.05 90.42,39.32 89.04,39.32 86.28,38.17 84.69,38.17 84.2,37.97 80.67,34.44 80.37,34.44 79.88,33.95 79.88,33.19 79.76,32.9 78.65,31.79 76.65,30.96 69.71,30.96 v2(69.47,31.2) ; v6(196.59,84.02) 196.77,84.02 197.26,84.51 200.03,84.51 200.5,84.98 201.84,84.98 202.12,85.26 v2(202.86,85.26)
  IN2 w0.122: v2(202.86,85.26) 203.1,85.02 205.05,85.02 207.64,87.61 207.64,99.78 208.15,100.29 208.15,105.27 207.75,105.67 207.64,105.92 207.64,106.65 207.73,106.74 207.73,107.35 204.94,110.14 199.51,110.14 196.6,113.05 196.6,118.81 193.11,122.31 191.42,122.31 191.14,122.58 191.14,123.32 190.41,124.05 190.41,128.15 189.47,129.09 189.21,129.09 188.12,130.18 188.12,132.45 185.75,134.82 185.75,135.97 185.49,136.23 184.84,136.23 184.74,136.33 184.74,137.38 184.37,137.75 182.84,137.75 v2(182.18,138.41)
  BOTTOM w0.112: v2(93.77,42.22) 99.31,47.77 99.31,59.72 100.28,60.68 100.28,81.15 96.52,84.91 96.52,92.66 102.82,98.96 114.59,98.96 117.54,101.92 119.27,101.92 120.75,100.43 127.7,100.43 130.54,103.27 130.54,106.6 130.83,106.89 131.64,106.89 132.56,105.97 135.61,105.97 135.88,105.7 142.61,105.7 146.32,101.99 159.06,101.99 161.45,102.98 167.78,109.31 169.03,110.15 177.17,118.29 177.17,136.71 178.87,138.41 v2(182.18,138.41) ; v2(69.47,31.2) 69.47,31.57 68.81,32.23 R4072.1
I2C_PESW_MULTI_CONFIG_ADD4_L_R: length 3.8
  BOTTOM w0.112: Q43.S 68.81,36.04 v3(68.81,35.1) R4072.2 R4069.2
I2C_PESW_MULTI_CONFIG_ADD4_R: length 33.8
  TOP w0.112: U86.N15 v6(38.95,47.49)
  IN1 w0.122: v6(38.95,47.49) 38.95,47.08 40.58,45.45 45.71,45.45 49.27,41.88 49.95,41.88 50.13,42.06 50.36,42.61 51.06,43.32 53.06,43.32 53.16,43.21 53.16,42.73 53.49,42.4 54.79,42.4 55.34,41.86 55.34,41.68 55.61,41.41 58.79,41.41 59.03,41.17 61.47,41.17 62.5,40.14 65.01,40.14 65.39,40.52 v2(65.39,41.43)
  BOTTOM w0.112: v2(65.39,41.43) R4064.1
JTAG_BIC_M2_TCK: length 34.4
  TOP w0.112: R3990.1 37.54,54.96 37.41,54.83 37.41,52.75 v2(37.88,52.28)
  IN1 w0.122: v2(37.88,52.28) 37.57,51.97 31.3,51.97 30.11,53.16 29.39,53.16 27.12,50.89 22.13,50.89 21.86,50.63 16.81,50.63 15.5,49.33 15.5,48.13 15.4,48.03 15.03,48.03 14.44,47.45 14.44,47 14.05,46.61 12.42,46.61 v4(11.95,46.15)
  BOTTOM w0.112: U94.C5 v4(11.95,46.15)
JTAG_BIC_M2_TCK_R: length 6.2
  TOP w0.089: 40,50.8 40,50.56 40.18,50.38 40.21,50.38 40.34,50.24 40.65,50.24 40.75,50.14 40.75,49.7 40.49,49.44 U86.V12
  TOP w0.112: 40,50.8 40,51.34 38.57,52.77 v1(38.57,52.97) 37.9,53.65 R3990.2
JTAG_BIC_M2_TDI: length 26
  IN1 w0.122: v2(32.74,46.78) 31.91,47.62 29.59,47.62 29.47,47.5 22.93,47.5 22.84,47.59 16.15,47.59 14.21,45.66 11.44,45.66 v2(10.95,46.15)
  BOTTOM w0.112: R3991.1 32.72,47.7 v3(32.6,47.58) 32.6,46.93 v2(32.74,46.78) ; U94.C4 v2(10.95,46.15)
JTAG_BIC_M2_TDI_R: length 7.1
  TOP w0.112: v6(38.59,45.89) 38.58,45.89 38.45,46.02 U86.M16
  BOTTOM w0.112: v3(34.4,48.93) 34.57,48.76 R3991.2 34.57,47.17 35.23,46.51 35.77,46.51 35.86,46.6 37.2,46.6 37.37,46.43 38.05,46.43 v6(38.59,45.89)
JTAG_BIC_M2_TDO: length 29.7
  TOP w0.112: R3938.2 13.55,43.41 v4(13.63,43.49) ; v6(38.99,46.38) 39.06,46.31 39.06,45.55 U86.K15
  IN1 w0.122: v6(38.99,46.38) 37.3,46.38 36.56,45.64 31.36,45.64 30.93,45.2 23.78,45.2 23.28,44.7 21.19,44.7 20.31,45.59 15.52,45.59 13.63,43.7 v4(13.63,43.49)
JTAG_BIC_M2_TDO_R: length 3.9
  TOP w0.112: R3938.1 11.95,43.04 v1(11.95,43.75) v2(11.95,45.15)
  BOTTOM w0.112: U94.B5 v2(11.95,45.15)
JTAG_BIC_M2_TMS: length 26.9
  IN1 w0.122: v2(30.74,44.45) 30.62,44.57 27.03,44.57 26.83,44.78 23.95,44.78 23.28,44.1 19.36,44.1 18.37,45.09 15.63,45.09 14.4,43.86 14.4,43.35 14.07,43.02 12.08,43.02 v2(9.95,45.15)
  BOTTOM w0.112: v2(30.74,44.45) 30.69,44.5 30.69,44.97 31.24,45.53 31.75,45.53 32.01,45.26 R3992.1 ; U94.B3 v2(9.95,45.15)
JTAG_BIC_M2_TMS_R: length 6.4
  TOP w0.112: U86.K17 38.2,45.44 38.37,45.27 v6(38.49,45.27)
  BOTTOM w0.112: R3992.2 33.56,45.03 33.95,45.43 v3(34.24,45.43) 34.36,45.43 34.47,45.53 37.78,45.53 37.85,45.47 38.18,45.47 38.37,45.27 v6(38.49,45.27)
JTAG_BIC_M2_TRST: length 39
  TOP w0.112: R3803.1 10.97,44.29 v2(10.97,45.12)
  IN1 w0.122: v2(10.97,45.12) 11.4,44.7 13.94,44.7 15.82,46.59 24.54,46.59 24.66,46.47 30.5,46.47 v2(30.73,46.71)
  BOTTOM w0.112: v2(30.73,46.71) 31.24,47.21 31.44,47.21 34.27,50.05 34.27,54.36 34.62,54.71 v3(35.53,54.71) 37.68,54.71 38.36,54.03 R3993.1 ; U94.A4 v2(10.97,45.12)
JTAG_BIC_M2_TRST_R: length 3.4
  TOP w0.112: v6(38.96,48.44) U86.U14
  BOTTOM w0.112: v6(38.96,48.44) 38.96,49.5 v3(38.79,49.67) 38.36,50.1 R3993.2
JTAG_CPLD_M2A_TCK: length 69.7
  TOP w0.112: v2(27.81,121.67) 27.97,121.84 27.97,123.36 26.18,125.15 J4.B28
  IN1 w0.122: v2(17.41,95.97) 20.3,98.86 20.3,100.31 20.25,100.36 20.25,100.93 23.16,103.84 24.34,103.84 28.8,108.3 28.8,111.05 29.18,111.42 29.18,118.74 28,121.59 v2(27.81,121.67)
  IN2 w0.122: v2(19.6,66.98) 20.13,67.51 20.13,69.3 19.78,69.65 19.78,72.75 20.42,73.39 20.42,77.1 20.54,77.21 20.54,79.86 20.48,79.91 20.48,84.36 20.39,84.45 20.39,86.9 20.48,86.99 20.48,89.68 17.41,92.75 v2(17.41,95.97)
  BOTTOM w0.112: v2(19.6,66.98) 18.42,66.98 18.24,66.8 R3975.2
JTAG_CPLD_M2A_TCK_R: length 8.6
  BOTTOM w0.112: U94.R8 14.93,59.17 14.93,60.07 v3(17.9,63.04) 17.9,63.55 17.73,63.72 17.73,65.06 R3975.1
JTAG_CPLD_M2A_TDI: length 94
  TOP w0.112: v2(26.98,123.23) 26.98,123.39 25.18,125.19 J4.B24
  IN1 w0.122: v2(14.84,96.01) 14.84,96.76 16.79,98.71 16.79,99.87 22.43,105.51 23.9,105.51 27.52,109.14 27.52,111.58 27.76,111.82 27.76,118.58 27.35,119.58 26.28,120.64 26.28,122.53 v2(26.98,123.23)
  IN2 w0.122: v2(1.57,47.92) 3.57,49.92 3.57,60.64 7.95,65.02 7.95,70.06 8.17,70.28 8.17,71.54 8.96,72.33 8.96,75.57 9.41,76.02 9.41,80.71 9.68,80.98 9.68,82.33 11.13,83.78 11.13,84.88 10.54,85.47 10.54,86.59 10.88,86.93 10.88,87.48 11.3,87.89 12.47,87.89 14.84,90.26 v2(14.84,96.01)
  BOTTOM w0.112: R3939.1 v2(1.57,47.92)
JTAG_CPLD_M2A_TDI_R: length 5.6
  BOTTOM w0.112: R3939.2 4.13,49.01 4.21,49.1 v3(4.98,49.1) 5.66,49.1 7.12,47.65 U94.D1
JTAG_CPLD_M2A_TDO: length 92.3
  TOP w0.112: v2(27.15,122.36) 27.6,122.81 27.6,123.25 25.68,125.17 J4.B26
  IN1 w0.122: v2(15.4,94.84) 15.4,96.54 18.88,100.02 18.88,101.07 22.59,104.77 23.87,104.77 27.95,108.85 27.95,111.4 28.32,111.78 28.32,118.34 27.71,119.83 26.71,120.83 26.71,121.92 v2(27.15,122.36)
  IN2 w0.122: v2(9.95,50.15) 9.89,50.15 9.25,49.5 7.91,49.5 6.64,50.77 6.64,60.08 8.36,61.8 9.88,61.8 12.05,63.97 12.05,69.09 12.4,69.44 12.4,70.86 13.44,71.9 13.44,80.4 13.67,80.63 13.67,85.46 14.53,86.33 14.53,89.04 15.4,89.91 v2(15.4,94.84)
  BOTTOM w0.112: U94.G3 v2(9.95,50.15)
JTAG_CPLD_M2A_TMS: length 117.6
  TOP w0.112: J4.B67 35.93,134.41 35.83,134.51 30.24,134.51 29.89,134.85 29.89,136.71 27.91,138.69 21.19,138.69 v2(19.31,136.81)
  IN2 w0.122: v2(1.53,53.92) 1.53,61.04 6.22,65.73 6.22,75.97 6.67,76.42 6.67,81.81 8.39,83.53 8.39,84.89 9.48,85.98 9.48,87.76 11.56,89.84 12.44,89.84 12.91,90.32 12.91,91.03 13.89,92.01 13.89,103.69 15.25,105.05 15.32,105.05 15.58,105.31 15.58,106.25 17.35,108.03 17.35,108.7 16.71,109.35 16.71,110.29 16.15,110.85 16.15,111.81 15.03,112.93 15.03,119.45 v2(15.35,119.77)
  BOTTOM w0.112: v2(19.31,136.81) 18.68,136.18 18.68,135.08 19.1,134.66 19.1,130.7 20.77,129.02 20.77,124.46 16.09,119.77 v2(15.35,119.77) ; v2(1.53,53.92) 2.31,53.92 2.46,54.07 R3951.1
JTAG_CPLD_M2A_TMS_R: length 6.2
  BOTTOM w0.112: R3951.2 4.25,53.65 v3(5.03,53.65) 6.23,53.65 6.68,54.1 9,54.1 U94.K2
JTAG_CPLD_M2A_TRST: length 69.2
  TOP w0.112: v2(27.25,120.97) 26.55,121.67 26.55,123.29 24.99,124.85 24.61,124.85 24.18,125.28 J4.B20
  IN1 w0.122: v2(16.87,97.26) 19.32,99.7 19.32,100.86 22.8,104.34 24.05,104.34 28.38,108.67 28.38,111.23 28.75,111.6 28.75,118.42 27.79,120.74 v2(27.25,120.97)
  IN2 w0.122: v2(16.87,97.26) 16.03,96.42 16.03,88.14 15.47,87.57 15.47,81.24 14.92,80.69 14.92,78.13 14.37,77.59 14.37,70.95 13.39,69.96 v2(13.39,69.93)
  BOTTOM w0.112: R3963.2 12.52,67.01 13.52,68.01 13.52,68.86 13.39,69.18 v2(13.39,69.93)
JTAG_CPLD_M2A_TRST_R: length 6.5
  BOTTOM w0.112: R3963.1 v3(12.52,64.34) 12.52,62.74 11.31,61.53 11.31,59.78 U94.T4
JTAG_CPLD_M2B_TCK: length 106.1
  TOP w0.112: v2(11.06,85.81) 11.06,84.45 11.16,84.34 11.16,83.87 10.7,83.4 10.7,82.64 10.81,82.52 10.81,82.17 10.55,81.91 10.55,77.66 11.73,76.48 11.73,72.18 12.57,71.34 12.57,63.71 13.36,62.92 R3976.2 ; v2(51.32,124.45) 50.91,124.45 50.18,125.18 J4.A28
  IN1 w0.122: v2(11.06,85.81) 12.52,85.81 12.69,85.63 13.55,85.63 14.07,86.16 25.92,86.16 27.24,84.84 37.16,84.84 38.04,85.72 38.67,85.72 39.25,86.31 39.25,86.48 53.75,100.99 55.68,100.99 57.75,103.05 57.75,105.13 57.39,105.49 57.39,105.95 56.13,107.21 55.42,108.93 55.42,118.85 55.07,119.2 54.58,120.37 53.1,121.86 53.1,122.35 52.45,123 52.45,123.33 51.34,124.45 v2(51.32,124.45)
JTAG_CPLD_M2B_TCK_R: length 6.8
  TOP w0.112: R3976.1 13.78,61.23 13.78,59.95 13.41,59.57 v1(13.41,59.06) 13.49,58.98 13.49,56.72 12.95,56.18 v2(12.95,56.15)
  BOTTOM w0.112: U94.M6 v2(12.95,56.15)
JTAG_CPLD_M2B_TDI: length 129.9
  TOP w0.112: v2(52.46,121.74) 52.16,122.04 52.16,122.74 51.7,123.21 51.17,123.21 49.18,125.2 J4.A24
  IN1 w0.122: v2(11.57,86.53) 11.62,86.59 26.17,86.59 27.49,85.27 36.98,85.27 37.93,86.22 38.56,86.22 38.82,86.48 38.82,86.66 53.61,101.44 55.53,101.44 57.32,103.23 57.32,104.96 56.97,105.31 56.97,105.68 55.68,106.96 55.08,108.4 54.16,109.33 54.16,110.03 54.23,110.11 54.23,115.72 54.52,116.01 54.52,117.19 54.36,117.35 54.36,119.55 54.15,120.06 v2(52.46,121.74)
  IN2 w0.122: v2(11.57,86.53) 11.57,84.43 11.9,84.11 11.9,82.92 10.74,81.76 10.74,81.12 9.92,80.31 9.92,76.94 10.5,76.37 10.5,75.56 9.39,74.45 9.39,72.15 8.6,71.36 8.6,70.06 8.38,69.84 8.38,64.84 4.02,60.48 4.02,44.84 2.29,43.1 v2(2.29,42.93)
  BOTTOM w0.112: R3940.1 2.67,43.31 v2(2.29,42.93)
JTAG_CPLD_M2B_TDI_R: length 5.7
  BOTTOM w0.112: U94.B1 6.82,44.02 v3(4.98,44.02) R3940.2
JTAG_CPLD_M2B_TDO: length 125.7
  TOP w0.112: J4.A26 49.68,125.18 51.21,123.65 v2(51.51,123.65)
  IN1 w0.122: v2(13.61,87.76) 14.08,88.22 28.1,88.22 30.21,86.12 36.06,86.12 37.73,87.79 38.64,87.79 53.59,102.74 55.62,102.74 56.47,103.58 56.47,104.6 56.11,104.96 56.11,105.09 56.01,105.33 54.95,106.4 54.79,106.77 53.86,107.7 53.3,109.05 53.3,109.47 53.17,109.79 53.17,119.52 51.13,121.56 51.13,123.26 v2(51.51,123.65)
  IN2 w0.122: v2(11.95,49.15) 11.51,48.7 8.1,48.7 6.21,50.59 6.21,60.26 8.17,62.23 9.63,62.23 11.45,64.05 11.45,69.14 11.93,69.62 11.93,71 12.98,72.06 12.98,81.18 13.21,81.41 13.21,85.2 12.52,85.89 12.52,86.66 v2(13.61,87.76)
  BOTTOM w0.112: U94.F5 v2(11.95,49.15)
JTAG_CPLD_M2B_TMS: length 133.3
  TOP w0.112: v2(60.31,130.36) 60.31,130.69 59.93,131.07 J4.A67 ; R3952.1 4.49,53.42 4.18,53.73 4.18,54.32 3.16,55.34 3.16,59.53 7.37,63.74 7.37,71.37 8.34,72.34 8.34,76.44 9.27,77.38 9.27,84.42 v2(9.61,84.76)
  IN1 w0.122: v2(9.61,84.76) 10.08,85.23 12.49,85.23 12.51,85.21 13.75,85.21 14.27,85.73 25.69,85.73 27.01,84.41 37.99,84.41 39.68,86.1 39.68,86.3 53.93,100.55 55.85,100.55 58.17,102.87 58.17,105.31 57.82,105.66 57.82,106.13 56.5,107.45 55.85,109.03 55.85,119.03 55.44,119.44 54.94,120.65 53.66,121.93 v2(53.66,122.36)
  IN2 w0.122: v2(53.66,122.36) 53.66,124.88 52.32,126.22 52.32,130.08 52.84,130.59 60.08,130.59 v2(60.31,130.36)
JTAG_CPLD_M2B_TMS_R: length 7.5
  TOP w0.112: R3952.2 6.85,53.42 v1(6.99,53.28) 7.66,52.6 11.41,52.6 v2(11.95,53.15)
  BOTTOM w0.112: U94.J5 v2(11.95,53.15)
