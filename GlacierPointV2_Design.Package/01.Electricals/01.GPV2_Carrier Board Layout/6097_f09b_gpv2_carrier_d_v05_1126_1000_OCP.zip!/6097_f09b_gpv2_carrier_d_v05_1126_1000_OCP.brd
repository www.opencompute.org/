# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
JTAG_CPLD_M2B_TRST: length 104.6
  TOP w0.112: v2(51.57,121.75) 51.13,121.31 50.52,121.31 50.14,121.68 50.14,123.26 48.88,124.52 48.51,124.52 48.18,124.85 48.18,125.97 J4.A20
  IN1 w0.122: v2(51.57,121.75) 51.72,121.75 53.61,119.86 53.61,109.95 53.73,109.66 53.73,109.14 53.78,109.01 53.99,108.8 54.34,107.97 55.19,106.97 55.32,106.65 56.54,105.44 56.54,105.13 56.89,104.78 56.89,103.41 55.69,102.21 53.66,102.21 38.82,87.36 38.42,87.36 36.76,85.69 27.71,85.69 26.35,87.05 12.01,87.05 v2(11.65,87.41)
  IN2 w0.122: v2(9.37,68.78) 9.37,69.61 9.47,69.7 9.47,71 10.93,72.46 10.93,77.27 10.79,77.41 10.79,79.75 11.98,80.93 11.98,81.79 12.76,82.57 12.76,84.9 12.04,85.61 12.04,87.02 v2(11.65,87.41)
  BOTTOM w0.112: R3964.2 7.95,67.67 9.06,68.78 v2(9.37,68.78)
JTAG_CPLD_M2B_TRST_R: length 6.7
  BOTTOM w0.112: U94.T2 9.45,60.24 8.26,61.43 8.26,63.95 v3(7.8,64.41) 7.8,65.41 R3964.1
JTAG_CPLD_M2C_TCK: length 122.1
  TOP w0.112: v2(12.39,74.63) 14.21,72.82 14.21,70.23 13.84,69.86 13.84,69.59 13.51,69.25 13.51,68.01 13.04,67.54 13.04,64.19 14.38,62.86 R3977.2 ; J36.B28 74.18,125.25 74.82,124.61 74.82,123.77 v2(74.46,123.41)
  IN1 w0.122: v2(67.3,85.11) 67.3,87.01 68.66,88.38 68.66,90.06 74.22,95.63 74.22,95.85 78.32,99.94 78.32,103.39 75.92,105.78 75.72,106.25 75.72,107.8 76.6,109.92 76.6,116.92 74.69,121.53 74.69,123.17 v2(74.46,123.41)
  BOTTOM w0.112: v2(12.39,74.63) 12.63,74.4 16.9,74.4 17.69,75.19 20.16,75.19 21.69,76.72 39.86,76.72 41.28,78.13 42.5,78.13 43.96,78.13 44.57,78.74 47.48,78.74 48.43,79.69 48.43,80.17 49.44,81.18 49.44,82.22 50.02,82.8 57.77,82.8 58.27,83.3 65.97,83.3 67.3,84.62 v2(67.3,85.11)
JTAG_CPLD_M2C_TCK_R: length 8.2
  TOP w0.112: v2(14.95,55.15) 14.95,55.35 14,56.31 14,59.24 14.5,59.74 v1(14.5,60.4) 14.85,60.75 14.85,61.18 R3977.1
  BOTTOM w0.112: U94.L8 v2(14.95,55.15)
JTAG_CPLD_M2C_TDI: length 151.4
  TOP w0.112: J36.B24 73.18,125.08 v2(73.5,124.76)
  IN1 w0.122: v2(68.27,85.05) 68.27,86.08 69.55,87.35 69.55,89.74 75.33,95.52 75.33,95.75 79.17,99.59 79.17,103.74 76.64,106.27 76.58,106.43 76.58,107.61 77.46,109.73 77.46,117.19 75.59,121.71 75.59,123.51 74.34,124.76 v2(73.5,124.76)
  IN2 w0.122: v2(10.34,74.27) 10.34,72.48 9.03,71.18 9.03,69.88 8.93,69.78 8.93,64.78 4.53,60.38 4.53,44.51 2.64,42.62 2.64,42.29 v2(2.44,42.09)
  BOTTOM w0.112: v2(68.27,85.05) 68.27,84.64 66.21,82.57 63.02,82.57 60.73,80.28 60.51,80.07 53.62,80.07 53.32,79.77 49.47,79.77 47.15,77.45 41.69,77.45 40.24,76.01 24.36,76.01 23.32,74.96 23.32,74.78 22.77,74.23 19.73,74.23 19.55,74.06 10.55,74.06 v2(10.34,74.27) ; v2(2.44,42.09) 2.26,42.09 1.4,42.95 1.4,44.6 1.83,45.03 R3941.1
JTAG_CPLD_M2C_TDI_R: length 6.6
  BOTTOM w0.112: U94.C2 8.96,46.15 8.19,46.15 7.32,45.29 v3(4.98,45.29) 4.72,45.03 R3941.2
JTAG_CPLD_M2C_TDO: length 128.7
  TOP w0.112: J36.B26 73.68,125.25 74.17,124.75 v2(74.17,124.27)
  IN1 w0.122: v2(67.83,85.83) 67.83,86.31 69.09,87.57 69.09,89.89 74.9,95.7 74.9,95.92 78.74,99.76 78.74,103.56 76.28,106.02 76.15,106.34 76.15,107.71 77.03,109.83 77.03,117.07 75.14,121.63 75.14,123.35 74.22,124.27 v2(74.17,124.27)
  IN2 w0.122: v2(19.06,74.6) 18.55,74.09 18.55,73.33 18.5,73.28 18.5,71.56 18.08,71.14 18.08,69.88 15.74,67.55 15.74,60.97 13.4,58.63 13.4,51.59 v2(12.95,51.15)
  BOTTOM w0.112: v2(19.06,74.6) 20.08,74.6 21.84,76.36 40.06,76.36 41.49,77.79 47.01,77.79 49.46,80.24 49.46,80.72 49.78,81.04 49.78,81.11 50.18,81.51 50.69,81.51 51.52,80.68 56.24,80.68 58.48,82.92 66.08,82.92 67.83,84.67 v2(67.83,85.83) ; U94.H6 v2(12.95,51.15)
JTAG_CPLD_M2C_TMS: length 156.2
  TOP w0.112: v2(83.49,134.81) 83.93,134.36 J36.B67 ; R3953.1 4.48,52.4 3.82,53.06 3.82,54.2 2.82,55.19 2.82,59.67 6.97,63.82 6.97,70.19 6.39,70.78 6.39,72.38 7.06,73.05 v2(7.06,74.36)
  IN1 w0.122: v2(74.3,121.08) 74.44,121.02 76.18,116.83 76.18,113.86 75.38,113.06 75.38,112.22 76.18,111.42 76.18,110.07 75.3,107.94 75.3,106.17 75.56,105.54 77.89,103.21 77.89,100.12 73.8,96.03 73.8,95.8 68.23,90.24 68.23,88.61 66.84,87.21 66.84,85.83 v2(66.61,85.6)
  IN2 w0.122: v2(83.49,134.81) 83.49,133.29 81.46,131.26 75.82,128.92 74.07,128.92 73.06,127.91 73.06,124.53 73.74,123.85 73.74,121.63 v2(74.3,121.08)
  BOTTOM w0.112: v2(7.06,74.36) 7.06,74.44 7.77,75.15 13.06,75.15 13.27,74.94 16.96,74.94 17.6,75.59 20.05,75.59 21.55,77.09 39.67,77.09 41.06,78.47 42.65,78.47 42.65,78.47 43.82,78.47 44.43,79.08 47.34,79.08 48.09,79.83 48.09,80.31 49.1,81.32 49.1,82.36 49.87,83.14 57.63,83.14 58.13,83.64 65.63,83.64 66.61,84.61 v2(66.61,85.6)
JTAG_CPLD_M2C_TMS_R: length 9.7
  TOP w0.112: v2(12.95,54.15) 12.47,53.67 12.47,52.89 11.49,51.91 7.27,51.91 v1(6.98,51.62) 6.2,52.4 R3953.2
  BOTTOM w0.112: U94.K6 v2(12.95,54.15)
JTAG_CPLD_M2C_TRST: length 120.1
  TOP w0.112: J36.B20 72.18,124.97 73.66,123.49 73.66,121.88 74.01,121.54 74.6,121.54 74.98,121.16 v2(76.38,121.16)
  IN1 w0.122: v2(76.38,121.16) 76.38,120.92 77.88,117.29 77.88,109.62 77,107.5 77,106.51 77,106.51 79.6,103.92 79.6,99.41 75.76,95.57 75.76,95.35 70.05,89.64 70.05,87.24 68.79,85.98 v2(68.79,85.71)
  IN2 w0.122: v2(12.54,73.51) 12.54,72.22 10.8,70.49 10.8,68.16 v2(10.97,67.99)
  BOTTOM w0.112: v2(10.97,67.99) 10.5,67.99 9.09,66.58 R3965.2 ; v2(68.79,85.71) 68.79,84.68 66.35,82.23 63.31,82.23 60.81,79.72 53.76,79.72 53.46,79.43 49.61,79.43 47.29,77.11 41.83,77.11 39.29,74.57 25.23,74.57 24.74,74.09 24.23,74.09 24.21,74.11 23.17,74.11 22.95,73.89 19.86,73.89 19.69,73.72 12.75,73.72 v2(12.54,73.51)
JTAG_CPLD_M2C_TRST_R: length 7.7
  BOTTOM w0.112: R3965.1 8.79,65.26 v3(8.79,63.39) 8.79,61.67 9.93,60.53 9.93,59.17 U94.R3
JTAG_CPLD_M2D_TCK: length 161.9
  TOP w0.112: R3978.2 15.96,62.9 15.7,62.9 14.55,64.04 14.55,68.05 15.1,69.37 15.1,74.39 10.89,78.6 10.89,81.74 11.23,82.08 v2(11.23,83.25) ; J36.A28 98.18,125.28 98.81,124.65 98.81,123.91 v2(98.45,123.56)
  IN1 w0.122: v2(82.57,81.72) 82.99,82.14 83.28,82.14 93.71,92.57 95.95,92.57 100.37,97 100.37,105.95 99.84,106.49 99.84,111.21 98.99,112.06 98.99,115.47 98.5,115.96 98.5,123.51 v2(98.45,123.56)
  BOTTOM w0.112: v2(82.57,81.72) 83.02,82.17 83.02,85.04 78.82,89.24 69.7,89.24 69.69,89.23 68.85,90.07 68.81,90.07 68.19,90.69 62.8,90.69 60.87,88.76 54.83,88.76 52.24,91.35 42.85,91.35 41.86,90.36 41.85,90.36 41.81,90.4 38.76,90.4 35.01,86.64 34.11,86.64 32.1,84.63 28.67,84.63 26.57,82.54 17.85,82.54 16.84,83.55 15.93,83.55 15.81,83.66 11.65,83.66 v2(11.23,83.25)
JTAG_CPLD_M2D_TCK_R: length 5.7
  TOP w0.112: v2(14.95,58.15) 14.95,58.73 v1(15.12,58.9) 15.87,58.9 16.92,59.94 16.92,61.15 R3978.1
  BOTTOM w0.112: U94.P8 v2(14.95,58.15)
JTAG_CPLD_M2D_TDI: length 185.1
  TOP w0.112: J36.A24 97.18,125.97 97.18,125.09 v2(97.47,124.8)
  IN1 w0.122: v2(97.47,124.8) 97.68,125.02 98.89,125.02 99.39,124.51 99.39,116.56 99.99,115.96 99.99,112.64 100.71,111.93 100.71,106.88 101.66,105.93 101.66,93.16 100.21,91.7 94.5,91.7 v2(84.38,81.58)
  IN2 w0.122: v2(10.68,84.08) 10.31,83.71 9.97,83.71 8.36,82.09 8.36,75.63 8.34,75.61 8.34,72.32 7.74,71.72 7.74,70.46 7.52,70.24 7.52,65.2 3.14,60.82 3.14,50.35 v2(1.54,48.75)
  BOTTOM w0.112: v2(10.68,84.08) 12.01,85.41 14.71,85.41 15.46,84.66 15.93,84.66 16.34,84.25 18.89,84.25 19.27,83.87 22.22,83.87 22.25,83.9 23.02,83.9 23.7,83.23 26.1,83.23 33.73,90.86 38.23,90.86 39.4,92.03 60.92,92.03 62.39,93.51 67.92,93.51 71.49,89.94 79.08,89.94 84.38,84.64 v2(84.38,81.58) ; v2(1.54,48.75) 2.66,49.87 R3942.1
JTAG_CPLD_M2D_TDI_R: length 7.2
  BOTTOM w0.112: R3942.2 4.64,50.03 v3(4.98,50.37) 5.72,50.37 7.94,48.15 8.96,48.15 U94.E2
JTAG_CPLD_M2D_TDO: length 177.7
  TOP w0.112: J36.A26 97.68,125.23 98.36,124.55 v2(98.36,124.46)
  IN1 w0.122: v2(83.44,81.7) 93.89,92.15 99.53,92.15 101.2,93.82 101.2,105.73 100.27,106.66 100.27,111.58 99.5,112.35 99.5,115.74 98.94,116.3 98.94,124.25 98.72,124.46 v2(98.36,124.46)
  IN2 w0.122: v2(14.21,84.9) 14.21,80.05 13.87,79.71 13.87,71.72 12.9,70.76 12.9,69.29 12.56,68.95 12.56,63.87 10.05,61.36 8.54,61.36 7.07,59.9 7.07,51.02 v2(7.95,50.15)
  BOTTOM w0.112: U94.G1 v2(7.95,50.15) ; v2(14.21,84.9) 14.93,84.18 15.88,84.18 16.17,83.89 18.76,83.89 19.12,83.53 22.4,83.53 22.44,83.56 22.88,83.56 23.57,82.88 26.43,82.88 28.53,84.97 31.93,84.97 34.03,87.08 34.93,87.08 39.55,91.69 52.38,91.69 54.97,89.1 60.66,89.1 62.59,91.03 68.4,91.03 69.83,89.6 78.94,89.6 83.44,85.1 v2(83.44,81.7)
JTAG_CPLD_M2D_TMS: length 192
  TOP w0.112: J36.A67 107.93,132.56 110.08,130.4 111.33,130.4 112.27,129.47 112.27,127.15 112.75,126.67 112.75,119.59 113.46,118.89 113.46,115.91 114.3,115.07 114.3,109.59 112.38,107.67 110.52,107.67 108.3,105.44 103.25,105.44 103.05,105.23 102.49,105.23 102.29,105.44 99.06,105.44 v2(98.83,105.2)
  IN1 w0.122: v2(98.83,105.2) 98.83,102.48 99.09,102.21 99.09,97.53 96.58,95.02 93.88,95.02 81.69,82.83 v2(81.69,82.38)
  BOTTOM w0.112: R3954.1 1.58,57.27 1.58,60.87 3.26,62.55 3.26,74.77 4.4,75.91 6.15,75.91 6.4,76.16 6.4,77.38 6.78,77.76 6.78,79.59 7.18,79.99 10.27,79.99 10.8,80.52 10.8,81.59 12.39,83.18 15.61,83.18 16.16,82.63 16.74,82.63 17.51,81.86 26.95,81.86 29.05,83.95 32.53,83.95 34.35,85.77 35.65,85.77 37.59,87.71 39.04,87.71 41,89.66 42.48,89.66 43.43,90.62 45.64,90.62 48.19,88.07 61.14,88.07 63.08,90.01 67.91,90.01 68.53,89.39 68.57,89.39 69.43,88.52 78.57,88.52 81.69,85.41 v2(81.69,82.38)
JTAG_CPLD_M2D_TMS_R: length 5.1
  BOTTOM w0.112: R3954.2 3.85,55.82 4.72,54.95 v3(5.04,54.95) 5.35,54.65 U94.L1
JTAG_CPLD_M2D_TRST: length 148.4
  TOP w0.112: v2(98.04,121.01) 98.04,122.31 97.66,122.69 97.66,123.69 97.33,124.02 97.1,124.02 96.18,124.93 96.18,125.97 J36.A20
  IN1 w0.122: v2(82.5,82.8) 83.34,82.8 93.54,93 93.57,93 93.6,93.03 95.8,93.03 99.95,97.17 99.95,105.74 99.42,106.27 99.42,110.96 98.51,111.86 98.51,114.92 98.04,115.4 v2(98.04,121.01)
  IN2 w0.122: v2(16.41,83.09) 15.92,82.6 15.92,81.04 15.39,80.52 15.39,77.94 14.8,77.35 14.8,70.76 13.88,69.84 13.88,68.93 v2(13.96,68.86)
  BOTTOM w0.112: R3966.2 13.49,66.54 13.49,67.41 13.96,67.88 v2(13.96,68.86) ; v2(82.5,82.8) 82.5,85.07 78.72,88.86 69.58,88.86 68.71,89.73 68.67,89.73 68.05,90.35 62.94,90.35 61,88.41 54.7,88.41 52.1,91.01 43,91.01 42,90.02 38.96,90.02 35.07,86.12 34.22,86.12 32.39,84.29 28.91,84.29 26.81,82.2 17.69,82.2 16.79,83.09 v2(16.41,83.09)
JTAG_CPLD_M2D_TRST_R: length 8.4
  BOTTOM w0.112: R3966.1 13.31,65.21 13.31,63.65 v3(13.67,63.3) 13.67,62.89 11.66,60.89 11.66,60.04 11.93,59.77 11.93,59.17 U94.R5
JTAG_CPLD_M2E_TCK: length 150.6
  TOP w0.112: J38.B28 122.18,125.28 123.65,123.81 123.65,122.97 v2(123.05,122.38)
  IN1 w0.122: v2(22.9,67.44) 23.86,67.44 23.96,67.55 25.05,67.55 26.53,66.07 35.42,66.07 36.76,64.73 42.97,64.73 43.36,64.34 55.24,64.34 56.57,65.66 63.6,65.66 63.96,65.3 65.8,65.3 66.56,66.05 72.59,66.05 73.52,66.98 75.45,66.98 78.86,70.38 89.29,70.38 96.78,77.87 104.24,77.87 123.5,97.13 123.5,102.69 123.79,102.99 123.79,107.35 123.38,108.84 123.28,109.83 123.28,116.04 122.71,116.61 122.71,119.76 122.24,120.23 122.24,121 122.4,121.16 122.8,122.13 v2(123.05,122.38)
  BOTTOM w0.112: v2(22.9,67.44) 22.2,67.44 22.04,67.61 20.93,67.61 20.16,66.84 20.16,66.77 19.75,66.36 R3979.2
JTAG_CPLD_M2E_TCK_R: length 8.8
  BOTTOM w0.112: U94.T8 15.45,60.08 17.14,61.76 17.58,61.76 18.95,63.13 v3(19.92,63.13) 19.92,63.62 19.38,64.16 R3979.1
JTAG_CPLD_M2E_TDI: length 194.1
  TOP w0.112: R3943.1 4.39,47.32 2.29,49.42 2.29,53.8 1.46,54.63 1.46,60.31 5.61,64.46 5.61,69.63 4.9,70.34 v2(4.9,71.99) ; v2(121.94,123.69) 121.94,124.52 121.18,125.28 J38.B24
  IN1 w0.122: v2(4.9,71.99) 6.5,70.39 9.22,70.39 11.78,67.82 14.97,67.82 16.48,69.33 20.55,69.33 21.06,68.82 25.15,68.82 27.03,66.94 35.78,66.94 37.12,65.6 43.33,65.6 43.73,65.19 47.07,65.19 47.54,65.66 49.53,65.66 50.95,67.08 63.41,67.08 64.33,66.15 65.08,66.15 66.46,67.54 70.18,67.54 70.71,68.07 75.32,68.07 78.5,71.25 88.93,71.25 96.41,78.73 103.89,78.73 122.63,97.47 122.63,103.42 122.94,103.73 122.94,107.03 122.54,108.46 122.27,111.22 122.27,115.81 121.8,116.28 121.8,119.29 121.29,119.81 121.29,121.29 121.65,121.65 121.82,122.06 121.82,123.57 v2(121.94,123.69)
JTAG_CPLD_M2E_TDI_R: length 5.2
  TOP w0.112: R3943.2 v1(8.97,47.32) 9.13,47.32 v2(9.95,48.15)
  BOTTOM w0.112: U94.E3 v2(9.95,48.15)
JTAG_CPLD_M2E_TDO: length 175.2
  TOP w0.112: v2(122.46,122.96) 122.9,123.4 122.9,124.06 121.68,125.28 J38.B26
  IN1 w0.122: v2(14,67.19) 15.13,67.19 16.84,68.91 20.19,68.91 20.72,68.38 24.91,68.38 26.78,66.5 35.6,66.5 36.94,65.16 43.15,65.16 43.55,64.76 49.27,64.76 51.15,66.65 63.22,66.65 64.15,65.72 65.38,65.72 66.74,67.08 70.49,67.08 70.94,67.54 75.4,67.54 78.68,70.82 89.11,70.82 96.6,78.3 104.07,78.3 123.07,97.31 123.07,103.06 123.37,103.36 123.37,107.18 122.95,108.68 122.86,109.65 122.86,115.85 122.26,116.45 122.26,119.53 121.77,120.02 121.77,121.16 122.01,121.4 122.25,121.97 122.25,122.75 v2(122.46,122.96)
  IN2 w0.122: v2(14,67.19) 14,63.48 8.46,57.94 8.46,51.64 v4(8.95,51.15)
  BOTTOM w0.112: U94.H2 v4(8.95,51.15)
JTAG_CPLD_M2E_TMS: length 196.5
  TOP w0.112: J38.B67 131.93,131.33 v2(132.24,131.02) ; v2(9.42,67.79) 8.66,67.03 8.66,62.49 6.42,60.25 5.41,60.25 4.18,59.03 4.18,57.24 R3955.1
  IN1 w0.122: v2(9.42,67.79) 10.67,66.53 25.33,66.53 26.23,65.64 35.24,65.64 36.58,64.3 42.79,64.3 43.18,63.91 55.43,63.91 56.75,65.24 63.29,65.24 63.65,64.87 65.99,64.87 66.74,65.62 72.85,65.62 73.77,66.54 75.63,66.54 79.04,69.95 89.47,69.95 96.96,77.45 104.42,77.45 123.92,96.95 123.92,102.36 124.22,102.66 124.22,107.46 123.82,108.9 123.71,110.02 123.71,116.25 123.15,116.81 123.15,120.37 v2(122.71,120.81)
  IN2 w0.122: v2(132.24,131.02) 129.87,131.02 127.98,129.13 119.13,129.13 118.27,128.27 118.27,126.47 118.87,125.87 118.87,125.72 120.34,124.25 121.24,124.25 121.46,124.03 121.46,122.69 122.71,121.43 v2(122.71,120.81)
JTAG_CPLD_M2E_TMS_R: length 5.8
  TOP w0.112: v2(9.95,55.15) 9.54,54.74 v1(9.01,54.74) 8.82,54.74 7.09,56.46 R3955.2
  BOTTOM w0.112: U94.L3 v2(9.95,55.15)
JTAG_CPLD_M2E_TRST: length 171.8
  TOP w0.112: J38.B20 120.18,125.08 v2(120.57,124.7) ; v2(9.87,73.49) 10.31,73.06 10.31,69.87 11.48,68.7 11.48,64.01 10.31,62.84 R3967.2
  IN1 w0.122: v2(120.57,124.7) 120.13,124.27 120.13,112.34 120.72,110.91 121.38,110.25 121.44,110.12 121.59,109.33 121.59,108.66 121.68,107.77 121.86,107.06 122.09,106.51 122.09,104.35 121.64,103.9 121.64,97.73 103.49,79.58 95.85,79.58 88.64,72.37 v2(83.5,72.37)
  BOTTOM w0.112: v2(83.5,72.37) 74.8,81.07 63.79,81.07 61.29,78.57 54.24,78.57 52.98,77.31 50.14,77.31 48.77,75.94 43.62,75.94 42.92,75.24 42.92,75.15 41.82,74.04 40.97,74.04 39.67,72.74 28.4,72.74 28.33,72.67 25.32,72.67 25,72.99 24.19,72.99 23.91,72.71 22.19,72.71 22.08,72.82 20.67,72.82 19.97,73.52 19.83,73.38 13.27,73.38 12.96,73.08 10.29,73.08 v2(9.87,73.49)
JTAG_CPLD_M2E_TRST_R: length 4.9
  TOP w0.112: R3967.1 10.31,59.78 v1(11.01,59.09) v2(11.95,58.15)
  BOTTOM w0.112: U94.P5 v2(11.95,58.15)
JTAG_CPLD_M2F_TCK: length 181.7
  TOP w0.112: v2(17.95,60.03) 17.95,62.21 17.71,62.45 R3980.2 ; v2(146.61,123.26) 146.88,123.53 146.88,124.53 146.18,125.23 J38.A28
  IN1 w0.122: v2(146.61,123.26) 147.21,122.66 147.21,120.27 146.06,119.12 146.06,116.66 146.54,116.18 146.54,115.14 145.84,114.45 145.84,111.18 146.53,110.49 146.89,109.63 146.89,105.56 107.88,66.55 101.67,66.55 98.37,63.25 97.32,63.25 93.25,59.18 90.55,59.18 89.9,58.53 80.6,58.53 74.01,51.94 72.81,51.94 71.64,50.77 56.5,50.77 55.5,51.77 51.2,51.77 48.89,54.07 48.89,54.43 47.3,56.02 46.13,56.02 46.08,56.07 44.47,56.07 44.1,55.7 42.46,55.7 42.16,55.99 41.31,55.99 40.75,55.44 31.88,55.44 30.3,57.02 22.42,57.02 21.25,58.18 19.71,58.18 17.95,59.94 v2(17.95,60.03)
JTAG_CPLD_M2F_TCK_R: length 6.2
  TOP w0.112: R3980.1 17.42,59.89 14.95,57.42 v4(14.95,57.15)
  BOTTOM w0.112: U94.N8 v4(14.95,57.15)
JTAG_CPLD_M2F_TDI: length 201.2
  TOP w0.112: J38.A24 145.18,125.1 v2(145.59,124.69)
  IN1 w0.122: v4(6.98,46.52) 7.81,47.36 7.81,47.63 9.82,49.64 15.07,49.64 16.18,50.75 16.18,51 16.88,51.7 22.67,51.7 25.07,54.1 30.1,54.1 31.57,52.62 37.35,52.62 37.45,52.73 38.07,52.73 38.17,52.63 40.79,52.63 41.15,53 45.95,53 47.06,52.53 48.69,50.9 48.69,50.18 49.97,48.9 52.51,48.9 53.03,49.41 55.27,49.41 56.15,48.53 67.57,48.53 67.71,48.39 72.94,48.39 80.9,56.35 90.64,56.35 91.74,57.45 96.48,57.45 96.61,57.5 103.52,64.41 108.76,64.41 149.05,104.71 149.05,116.97 148.27,117.75 148.27,123.19 146.78,124.69 v2(145.59,124.69)
  BOTTOM w0.112: R3944.1 2.67,46.66 3.11,47.1 5.84,47.1 6.41,46.52 v4(6.98,46.52)
JTAG_CPLD_M2F_TDI_R: length 5.9
  BOTTOM w0.112: U94.C1 7.99,46.65 7.14,45.8 5.74,45.8 v3(4.98,46.56) 3.98,46.56 R3944.2
JTAG_CPLD_M2F_TDO: length 189.4
  TOP w0.112: v2(146.25,124.17) 146.25,124.66 145.68,125.23 J38.A26
  IN1 w0.122: v2(146.25,124.17) 146.69,124.17 147.73,123.13 147.73,117.68 148.63,116.78 148.63,104.88 108.58,64.84 103.35,64.84 97.13,58.63 95.32,57.88 91.28,57.88 90.64,57.24 81.19,57.24 72.76,48.82 68.2,48.82 67.02,50 58.34,50 57.35,49.01 56.33,49.01 55.21,50.13 50.62,50.13 50.28,50.47 49.89,50.47 49.56,50.8 49.56,51.58 47,54.14 46.98,54.14 31.28,54.14 30.46,54.95 21.3,54.95 20.02,53.67 16.23,53.67 14.51,51.95 11.75,51.95 v4(10.95,51.15)
  BOTTOM w0.112: U94.H4 v4(10.95,51.15)
JTAG_CPLD_M2F_TMS: length 220.3
  TOP w0.112: R3956.1 3.84,56.57 3.84,59.17 5.27,60.59 6.18,60.59 7.62,62.03 v4(7.62,62.7) ; J38.A67 155.93,134.5 154.67,135.76 v2(153.48,135.76)
  IN1 w0.122: v2(153.48,135.76) 153.87,135.37 153.87,131.81 153.47,131.4 153.18,131.4 151.19,129.42 151.19,129.37 150.48,128.65 147.52,128.65 146.6,127.74 146.6,126.55 144.64,124.59 144.64,119.81 144.96,119.04 144.96,110.66 145.77,109.85 146.03,109.21 146.03,105.91 107.52,67.4 100.28,67.4 97.41,64.53 97.41,64.48 97.03,64.1 96.96,64.1 92.91,60.05 80.01,60.05 77.88,57.91 73.75,57.91 73.05,57.22 73.05,53.53 71.15,51.63 57.02,51.63 56.02,52.63 51.54,52.63 49.83,54.35 49.83,54.79 48.27,56.35 48.27,57.49 47.63,58.12 45.63,58.12 44.82,57.32 42.99,57.32 42.65,56.98 41.06,56.98 40.37,56.29 32.5,56.29 30.78,58.01 24.71,58.01 23.08,59.65 19.91,59.65 18.64,60.91 9.09,60.91 7.62,62.39 v4(7.62,62.7)
JTAG_CPLD_M2F_TMS_R: length 6.4
  TOP w0.112: v2(10.95,54.15) 8.43,54.15 7.13,55.45 v1(6.96,55.45) R3956.2
  BOTTOM w0.112: U94.K4 v2(10.95,54.15)
JTAG_CPLD_M2F_TRST: length 193.8
  TOP w0.112: v2(146.16,122) 145.8,122.36 145.8,123.34 144.18,124.96 J38.A20
  IN1 w0.122: v2(146.16,122) 146.79,121.37 146.79,120.48 145.5,119.2 145.5,116.51 146.11,115.9 146.11,115.4 145.42,114.71 145.42,110.92 146.13,110.21 146.46,109.4 146.46,105.74 107.7,66.97 101.49,66.97 98.19,63.67 97.14,63.67 93.08,59.61 90.35,59.61 89.7,58.97 79.6,58.97 77.52,56.89 77.05,56.89 71.36,51.2 56.76,51.2 55.76,52.2 51.37,52.2 49.32,54.25 49.32,54.69 48.09,55.92 47.84,56.17 47.84,57.31 47.46,57.69 46.94,57.69 45.82,56.58 44.37,56.58 43.92,56.12 42.65,56.12 42.35,56.42 41.13,56.42 40.57,55.87 32.07,55.87 30.37,57.56 23.78,57.56 22.64,58.7 19.8,58.7 19.02,59.48 19.02,59.59 18.13,60.48 12.4,60.48 v2(12.17,60.25)
  BOTTOM w0.112: R3968.2 14.31,66.36 14.19,66.25 14.19,62.27 v2(12.17,60.25)
JTAG_CPLD_M2F_TRST_R: length 7.2
  BOTTOM w0.112: R3968.1 v3(14.81,64.39) 14.81,61.68 13.7,60.58 13.23,60.58 12.45,59.79 U94.T5
JTAG_CPLD_M2G_TCK: length 233.6
  TOP w0.112: R3981.2 18.78,57.95 v2(17.99,57.15)
  IN1 w0.122: v2(18.36,36.09) 19.38,35.07 25.6,35.07 26.54,34.12 28.41,34.12 29.25,33.29 32.55,33.29 33.44,32.4 35.21,32.4 35.87,33.05 40.99,33.05 41.07,32.97 43.47,32.97 43.71,33.21 55.37,33.21 58.19,36.02 64.82,36.02 64.94,36.15 69.01,36.15 69.65,36.79 72.94,36.79 81.71,45.57 83.02,45.57 86.56,49.11 89.71,49.11 90.51,49.92 95.03,49.92 111.94,56.92 114.37,56.92 150.83,93.37 152.26,93.37 153.15,94.26 154.01,94.26 155.27,95.53 155.27,100.74 163.1,108.57 163.1,111.24 161.6,112.73 161.6,117.75 159.62,119.73 159.62,120.94 158.32,122.25 v2(158.32,124.42)
  IN2 w0.122: v2(18.36,36.09) 18.36,36.77 19.02,37.43 19.02,38.83 17.94,39.91 17.94,41.74 19.09,42.88 19.09,44.31 18.46,44.94 18.46,56.69 v2(17.99,57.15)
  BOTTOM w0.112: v2(158.32,124.42) 158.32,125.7 157.14,126.87 157.14,129.33 157.66,129.85 159.68,129.85 160.17,130.34 160.17,131.62 160.92,132.37 160.92,133.22 J8.B28
JTAG_CPLD_M2G_TCK_R: length 5.5
  TOP w0.112: R3981.1 17.48,57.86 17.48,56.89 17.16,56.57 16.75,56.57 v1(16.23,56.05) 16.23,55.39 16.48,55.15 v2(16.95,55.15)
  BOTTOM w0.112: U94.L9 v2(16.95,55.15)
JTAG_CPLD_M2G_TDI: length 238
  IN1 w0.122: v2(1.47,46) 1.47,42.37 2.01,41.83 2.01,41.29 8.42,34.87 9.73,34.87 10.21,34.39 11.87,34.39 13.99,32.27 14.83,32.27 15.07,32.51 28.19,32.51 28.86,31.84 32.18,31.84 32.91,31.12 35.74,31.12 35.93,31.31 41.98,31.31 42.29,31.61 43.93,31.61 44.24,31.93 56.82,31.93 58.23,33.35 58.42,33.53 59.35,34.46 59.7,34.46 65.06,34.46 65.47,34.87 69.54,34.87 70.18,35.51 74.77,35.51 87.09,47.83 90.24,47.83 91.04,48.64 95.29,48.64 112.19,55.64 115.03,55.64 149.3,89.92 152.55,89.92 152.86,89.61 154.16,89.61 156.55,92 156.55,99.94 164.38,107.77 164.38,111.77 162.9,113.25 162.9,118.29 163.52,118.92 163.52,121.25 161.89,122.89 161.89,123.01 160.39,124.51 160.39,124.73 v2(159.95,125.17)
  BOTTOM w0.112: v2(159.95,125.17) 159.85,125.27 159.85,126.73 160.97,127.84 160.97,129.68 160.92,129.73 160.92,131.31 161.92,132.31 161.92,133.22 J8.B24 ; v2(1.47,46) 1.47,46.67 R3945.1
JTAG_CPLD_M2G_TDI_R: length 6.5
  BOTTOM w0.112: U94.D2 8.96,47.15 6.74,47.15 6.07,47.83 v3(4.98,47.83) 4.36,47.83 4.32,47.86 R3945.2
JTAG_CPLD_M2G_TDO: length 234.6
  IN1 w0.122: v2(14.17,32.72) 14.49,33.03 28.29,33.03 29.04,32.27 32.36,32.27 33.08,31.54 35.57,31.54 35.76,31.74 41.81,31.74 42.11,32.04 43.75,32.04 44.07,32.36 56.64,32.36 57.93,33.65 58.12,33.83 59.17,34.89 59.88,34.89 64.89,34.89 65.3,35.3 69.37,35.3 70.01,35.94 74.59,35.94 86.92,48.26 90.06,48.26 90.86,49.06 95.2,49.06 112.11,56.07 114.77,56.07 150.32,91.62 154.07,91.62 156.13,93.68 156.13,100.39 163.96,108.22 163.96,111.59 162.47,113.08 162.47,119.23 162.63,119.39 162.63,121.45 161.45,122.63 161.45,122.8 159.91,124.34 159.91,124.58 159.42,125.08 v2(159.42,126.17)
  IN2 w0.122: v2(14.17,32.72) 13.6,33.29 13.6,42.48 12.49,43.59 12.49,52.69 v2(12.95,53.15)
  BOTTOM w0.112: v2(159.42,126.17) 159.42,126.78 160.03,127.4 160.03,129.09 160.53,129.59 160.53,131.47 161.42,132.36 161.42,133.22 J8.B26 ; U94.J6 v2(12.95,53.15)
JTAG_CPLD_M2G_TMS: length 253.3
  TOP w0.112: v2(155.07,130.96) 155.85,130.96 156.83,129.98 156.83,128.03 158.13,126.72 158.13,125.22 158.72,124.64 v2(159.18,124.64) ; R3957.1 4.96,58.62 5.38,59.04 v2(5.38,59.1)
  IN1 w0.122: v2(5.38,59.1) 4.71,58.43 4.71,45.27 7.17,42.8 7.17,42.79 9.45,40.51 12.86,40.51 18.76,34.62 25.36,34.62 26.29,33.69 28.23,33.69 29.07,32.86 32.37,32.86 33.26,31.97 35.39,31.97 35.58,32.16 41.63,32.16 41.93,32.46 43.57,32.46 43.89,32.78 55.55,32.78 58.37,35.6 64.99,35.6 65.12,35.72 69.19,35.72 69.83,36.36 74.42,36.36 86.74,48.69 89.88,48.69 90.69,49.49 95.12,49.49 112.02,56.49 114.58,56.49 150.71,92.62 152.55,92.62 152.86,92.32 154.16,92.32 155.7,93.85 155.7,100.57 163.53,108.39 163.53,111.41 162.04,112.91 162.04,119.52 160.92,120.64 160.92,122.65 159.18,124.39 v2(159.18,124.64)
  BOTTOM w0.112: J8.B67 151.17,139.3 150.34,138.47 150.34,136.07 152.76,133.66 152.76,131.77 153,131.53 154.49,131.53 v2(155.07,130.96)
JTAG_CPLD_M2G_TMS_R: length 8.8
  TOP w0.112: R3957.2 v1(6.95,58.5) 7.03,58.5 8.24,57.28 8.24,56.43 8.62,56.04 10.24,56.04 10.58,55.7 11.4,55.7 v2(11.95,55.15)
  BOTTOM w0.112: U94.L5 v2(11.95,55.15)
JTAG_CPLD_M2G_TRST: length 250.3
  IN1 w0.122: v2(18.16,31.39) 18.66,31.89 28.21,31.89 28.68,31.42 32,31.42 32.73,30.69 35.92,30.69 36.11,30.88 41.97,30.88 42.27,30.58 43.5,30.58 44.42,31.5 56.99,31.5 59.53,34.04 65.24,34.04 65.65,34.44 69.72,34.44 70.36,35.08 74.95,35.08 87.27,47.41 90.41,47.41 91.22,48.21 95.37,48.21 112.28,55.21 115.51,55.21 148.19,87.88 151.95,87.88 152.89,88.82 153.98,88.82 156.98,91.83 156.98,99.76 164.81,107.59 164.81,112.64 163.39,114.06 163.39,118.12 163.95,118.68 163.95,121.52 163.39,122.07 163.39,124.72 161.36,126.75 v2(161.36,126.99)
  IN2 w0.122: v2(18.16,31.39) 17.91,31.64 17.91,37.07 18.4,37.55 18.4,38.65 17.09,39.96 17.09,45.76 16.49,46.35 16.49,59.6 17.51,60.61 17.51,66.54 v2(17.05,67)
  BOTTOM w0.112: v2(161.36,126.99) 161.99,126.99 162.29,127.28 162.29,128.24 162.37,128.33 162.37,129.31 161.72,129.97 161.72,130.95 162.92,132.15 162.92,133.22 J8.B20 ; v2(17.05,67) 16.59,67 R3969.2
JTAG_CPLD_M2G_TRST_R: length 8.9
  BOTTOM w0.112: R3969.1 15.65,65.26 15.65,63.68 v3(15.95,63.37) 15.95,62.3 13.76,60.1 13.26,60.1 12.93,59.78 12.93,59.17 U94.R6
JTAG_CPLD_M2H_TCK: length 186.8
  IN1 w0.122: v2(82.14,62.46) 82.7,61.9 91.77,61.9 98.98,69.11 106.78,69.11 138.84,101.17 138.84,110.5 138.91,110.56 138.91,122.92 138.58,123.7 v2(137.54,124.74)
  IN2 w0.122: v2(47.85,62.28) 47.48,62.64 47.48,64.97 v2(47.72,65.21)
  BOTTOM w0.112: R3982.2 21.85,66.36 22.28,66.8 23.14,66.8 23.89,67.55 24.44,67.55 29.26,62.73 33.07,62.73 33.07,62.73 45,62.73 45.34,62.38 45.35,62.38 45.45,62.28 v2(47.85,62.28) ; J8.A28 136.92,133.22 136.92,130.21 136.27,129.57 136.27,127.66 135.72,127.11 135.72,125.91 136.56,125.07 137.21,125.07 v2(137.54,124.74) ; v2(47.72,65.21) 56.55,74.04 63.16,74.04 65.47,76.35 72.57,76.35 77.23,71.69 77.23,67.78 82.14,62.87 v2(82.14,62.46)
JTAG_CPLD_M2H_TCK_R: length 9.9
  BOTTOM w0.112: U94.T9 16.45,59.81 17.68,61.04 18.27,61.04 19.19,61.95 20.83,61.95 22.32,63.44 v3(22.32,64.27) 22.32,64.91 R3982.1
JTAG_CPLD_M2H_TDI: length 227.1
  IN1 w0.122: v2(82.19,61.42) 91.89,61.42 99.16,68.68 106.96,68.68 139.27,100.99 139.27,110.31 139.33,110.38 139.33,123.04 138.96,123.95 137.37,125.54 v2(136.72,125.54) ; v2(7.73,72.5) 8.44,71.79 12.28,71.79 13.06,72.57 16.27,72.57 v2(16.57,72.27)
  IN2 w0.122: v2(1.4,49.87) 2.71,51.18 2.71,61 7.09,65.38 7.09,70.42 7.31,70.64 7.31,72.08 v2(7.73,72.5)
  BOTTOM w0.112: v2(16.57,72.27) 16.57,71.37 17.06,70.87 20,70.87 21.29,69.58 25.43,69.58 29.96,65.05 47.27,65.05 47.54,64.78 47.9,64.78 48.86,65.73 48.86,65.87 56.69,73.7 63.3,73.7 65.61,76.01 72.43,76.01 76.89,71.55 76.89,67.64 81.71,62.82 81.71,61.9 v2(82.19,61.42) ; R3946.1 2.58,51.05 v2(1.4,49.87) ; J8.A24 137.92,133.22 137.92,131.45 137.72,131.25 137.72,129.92 137,129.2 137,127.01 136.72,126.73 v2(136.72,125.54)
JTAG_CPLD_M2H_TDI_R: length 6.5
  BOTTOM w0.112: U94.E1 7.97,48.65 v3(4.98,51.64) 4.06,51.64 R3946.2
JTAG_CPLD_M2H_TDO: length 209.3
  IN1 w0.122: v2(82.33,64.05) 83.63,62.75 91.42,62.75 98.63,69.96 106.43,69.96 137.99,101.52 137.99,110.84 138.05,110.91 138.05,119.78 137.21,121.82 137.21,123.28 136.21,124.28 v2(136.21,126.23)
  IN2 w0.122: v2(9.95,51.15) 10.45,51.64 10.45,57.27 11.79,58.61 12.38,58.61 15.31,61.54 15.31,67.72 17.65,70.06 17.65,71.62 v2(17.79,71.76)
  BOTTOM w0.112: U94.H3 v2(9.95,51.15) ; v2(17.79,71.76) 20.7,71.76 20.87,71.6 23,71.6 23.45,71.15 24.49,71.15 25.2,70.44 25.73,70.44 30.44,65.73 46.84,65.73 55.83,74.72 62.88,74.72 65.19,77.03 72.85,77.03 77.91,71.97 77.91,68.17 82.03,64.05 v2(82.33,64.05) ; v2(136.21,126.23) 136.21,127.01 136.63,127.44 136.63,129.35 137.27,129.99 137.27,131.57 137.42,131.72 J8.A26
JTAG_CPLD_M2H_TMS: length 232.8
  IN1 w0.122: v2(7.52,73.28) 8.54,73.28 9.6,72.22 12.09,72.22 12.87,73 16.8,73 17.21,72.59 v2(17.55,72.59) ; v2(83.06,62.43) 83.16,62.33 91.59,62.33 98.8,69.54 106.61,69.54 138.42,101.34 138.42,110.67 138.48,110.73 138.48,119.96 137.64,121.99 137.64,123.64 v2(136.65,124.63)
  IN2 w0.122: v2(136.65,124.63) 134.72,126.57 133.64,126.57 132.79,127.42 132.79,131.27 128.76,135.3 v2(126.65,135.3)
  BOTTOM w0.112: R3958.1 1.92,57.94 1.92,60.69 2.58,61.34 3.57,61.34 5.66,63.43 5.66,71.97 6.97,73.28 v2(7.52,73.28) ; v2(83.06,62.43) 77.57,67.92 77.57,71.83 72.71,76.69 65.33,76.69 63.02,74.38 55.97,74.38 46.98,65.39 30.1,65.39 25.56,69.94 21.56,69.94 20.27,71.23 17.65,71.23 17.19,71.69 17.19,72.23 v2(17.55,72.59) ; J8.A67 127.17,139.71 126.49,139.03 125.69,139.03 125.45,138.79 125.45,136.91 126.65,135.71 v2(126.65,135.3)
JTAG_CPLD_M2H_TMS_R: length 6.5
  BOTTOM w0.112: R3958.2 4.41,56.26 v3(5.03,56.26) 6.42,56.26 7.54,55.14 8.95,55.14 U94.L2
JTAG_CPLD_M2H_TRST: length 201.3
  TOP w0.112: v2(10.86,67.07) 10.37,67.56 10.37,69.33 9.86,69.84 v2(9.86,72.66)
  IN1 w0.122: v2(137.31,126.17) 136.94,126.53 136.62,126.67 136.02,126.67 135.76,126.41 135.76,124.09 136.75,123.1 136.75,121.7 137.63,119.59 137.63,111.08 137.56,111.01 137.56,101.69 106.26,70.39 98.45,70.39 91.24,63.18 84.11,63.18 v2(83.69,63.6)
  BOTTOM w0.112: v2(9.86,72.66) 13.17,72.66 13.54,73.02 19.92,73.02 21.01,71.94 23.18,71.94 23.59,71.54 24.66,71.54 25.27,70.92 25.76,70.92 30.6,66.09 46.71,66.09 55.69,75.06 62.74,75.06 65.05,77.37 72.99,77.37 78.25,72.12 78.25,68.31 81.81,64.74 82.55,64.74 v2(83.69,63.6) ; R3970.2 10.24,66.45 v2(10.86,67.07) ; v2(137.31,126.17) 137.36,126.21 137.36,128.94 138.08,129.66 138.08,131.1 138.92,131.94 138.92,133.22 J8.A20
JTAG_CPLD_M2H_TRST_R: length 6.2
  BOTTOM w0.112: U94.T3 10.45,62.25 10.73,62.54 10.73,63.74 v3(10.24,64.24) R3970.1
JTAG_CPLD_M2I_TCK: length 152.4
  IN1 w0.122: v2(24.09,70.62) 26.14,70.62 27.24,69.52 32.11,69.52 32.67,68.96 36.2,68.96 37.16,68 43.42,68 44.52,66.9 46.33,66.9 47.04,67.61 48.07,67.61 49.42,68.96 63.8,68.96 64.81,69.97 69.35,69.97 69.38,69.94 72.26,69.94 74.3,70.79 77.81,74.29 87.33,74.29 94.82,81.78 102.67,81.78 113.24,92.35 113.24,100.87 114.29,101.92 114.29,104.37 113.96,105.18 113.96,106.66 113.9,106.79 113.03,108.9 112.76,109.17 112.76,114.1 112.6,114.25 112.6,115.12 113.32,115.83 113.32,120.07 112.39,121 112.39,122.79 112.24,123.16 110.82,124.58 v2(110.82,125.96)
  IN2 w0.122: v2(24.09,70.62) 24.18,70.53 24.18,67.14 v2(24.15,67.11)
  BOTTOM w0.112: v2(110.82,125.96) 110.31,125.96 109.21,127.06 109.21,129.15 110.13,130.07 111.13,130.07 111.45,130.38 111.45,130.88 112.92,132.35 112.92,133.22 J34.B28 ; R3983.2 23.15,66.31 23.95,67.11 v2(24.15,67.11)
JTAG_CPLD_M2I_TCK_R: length 12.5
  BOTTOM w0.112: U94.P9 16.45,57.65 16.92,58.12 16.92,59.77 17.82,60.67 18.57,60.67 19.29,61.39 21.2,61.39 22.81,62.99 v3(22.81,63.02) 23.33,63.54 23.33,64.99 R3983.1
JTAG_CPLD_M2I_TDI: length 187.1
  IN1 w0.122: v2(111.93,126.28) 111.93,126.28 113.22,124.99 113.22,124.08 113.69,123.62 113.69,121.75 114.6,120.83 114.6,108.53 115.26,106.94 115.26,105.37 115.57,104.62 115.57,101.39 114.52,100.34 114.52,91.81 103.19,80.49 95.36,80.49 87.87,73 78.38,73 75.1,69.71 72.3,68.55 70.43,68.55 69.85,67.97 65.91,67.97 65.5,67.56 49.83,67.56 48.6,66.32 47.57,66.32 46.86,65.62 43.97,65.62 43.56,66.03 37.3,66.03 35.8,67.52 32.26,67.52 31.74,68.04 26.66,68.04 25.43,69.27 21.34,69.27 20.73,69.88 16.37,69.88 14.73,68.25 12.09,68.25 9.51,70.84 7.15,70.84 v2(6.82,71.17)
  IN2 w0.122: v2(1.63,53) 2.28,53.65 2.28,60.98 2.28,60.98 2.28,61.17 6.65,65.55 6.65,71 v2(6.82,71.17)
  BOTTOM w0.112: v2(1.63,53) 1.61,52.99 R3947.1 ; J34.B24 113.92,133.22 113.92,132.31 112.63,131.02 112.63,126.98 v2(111.93,126.28)
JTAG_CPLD_M2I_TDI_R: length 8.7
  BOTTOM w0.112: R3947.2 2.98,52.19 3.23,52.45 v3(3.57,52.45) 4.9,52.45 8.19,49.15 8.96,49.15 U94.F2
JTAG_CPLD_M2I_TDO: length 179.7
  IN1 w0.122: v2(111.21,126.75) 111.21,126.31 111.87,125.64 111.96,125.64 112.77,124.84 112.77,123.89 113,123.66 113.26,123.04 113.26,121.56 114.18,120.64 114.18,108.42 114.73,107.07 114.75,107.06 114.81,106.92 114.81,105.35 115.14,104.53 115.14,101.56 114.09,100.51 114.09,91.99 103.02,80.92 95.18,80.92 87.69,73.43 78.2,73.43 74.85,70.08 72.44,69.08 68.74,69.08 68.7,69.12 66.37,69.12 65.28,68.03 49.69,68.03 48.42,66.75 47.39,66.75 46.68,66.04 44.15,66.04 43.74,66.46 37.48,66.46 35.84,68.1 32.31,68.1 31.78,68.62 26.79,68.62 25.7,69.71 21.68,69.71 21.08,70.31 14.4,70.31 13.87,69.78 13.87,69.55 v2(13.01,68.69)
  IN2 w0.122: v2(13.01,68.69) 13.13,68.57 13.13,63.83 10.23,60.93 9.42,60.93 7.51,59.02 7.51,51.59 v2(7.95,51.15)
  BOTTOM w0.112: v2(111.21,126.75) 111.59,126.75 112.27,127.44 112.27,131.16 113.42,132.31 113.42,133.22 J34.B26 ; U94.H1 v2(7.95,51.15)
JTAG_CPLD_M2I_TMS: length 195.5
  TOP w0.112: v2(104.36,135.42) 105.3,136.36 106.59,136.36 107.35,137.13 108.03,137.13 108.54,136.62 108.54,135.64 108,135.1 107.5,135.1 106.81,134.41 106.81,128.58 108.24,127.15 109.56,127.15 110.07,126.94 v2(110.33,126.69)
  IN1 w0.122: v2(6.84,72.15) 7.63,71.36 12.62,71.36 13.02,71.76 15.33,71.76 15.77,71.32 20.93,71.32 21.18,71.57 22.96,71.57 23.23,71.29 26.11,71.29 27.43,69.98 32.26,69.98 32.85,69.39 36.38,69.39 36.56,69.22 43.66,69.22 44.84,68.03 47.89,68.03 50.29,70.43 53.49,70.43 54.98,71.92 68.95,71.92 70.06,70.8 72.08,70.8 73.63,71.44 77.34,75.16 86.97,75.16 94.46,82.65 102.31,82.65 112.39,92.72 112.39,101.22 113.44,102.27 113.44,104.18 113.09,105.02 113.09,106.47 112.5,107.89 111.74,108.65 111.29,109.75 111.29,117.6 110.33,119.92 v2(110.33,126.69)
  BOTTOM w0.112: v2(104.36,135.42) 104.22,135.42 103.69,135.95 103.69,138.61 103.17,139.13 J34.B67 ; v2(6.84,72.15) 6.1,71.41 6.1,62.42 3.93,60.24 v3(2.46,60.24) 2.46,58.42 R3959.1
JTAG_CPLD_M2I_TMS_R: length 5.5
  BOTTOM w0.112: R3959.2 4.1,57.58 v3(5.03,57.58) 5.82,57.58 7.76,55.65 U94.M1
JTAG_CPLD_M2I_TRST: length 163.9
  IN1 w0.122: v2(112.03,124.33) 112.03,123.98 112.64,123.38 112.83,122.92 112.83,121.2 113.75,120.27 113.75,108.27 114.38,106.74 114.38,105.26 114.72,104.45 114.72,101.74 113.67,100.69 113.67,92.17 102.85,81.35 95,81.35 87.51,73.86 77.99,73.86 74.55,70.42 72.34,69.51 69.1,69.51 69.07,69.54 65.17,69.54 64.12,68.49 49.56,68.49 48.24,67.18 47.21,67.18 46.5,66.47 44.34,66.47 43.92,66.89 37.65,66.89 36.02,68.53 32.49,68.53 31.96,69.05 27.05,69.05 25.94,70.17 22.13,70.17 21.51,70.79 15.58,70.79 15.02,71.34 13.19,71.34 12.18,70.32 v2(11.37,70.32)
  BOTTOM w0.112: J34.B20 114.92,133.22 114.92,132.07 113.41,130.56 113.41,127.85 113.83,126.83 113.83,125.28 112.89,124.33 v2(112.03,124.33) ; R3971.2 11.82,66.8 11.82,69.33 11.37,69.79 v2(11.37,70.32)
JTAG_CPLD_M2I_TRST_R: length 7.3
  BOTTOM w0.112: U94.R4 10.93,59.17 10.93,62.05 11.38,62.5 v3(11.38,63.04) R3971.1
JTAG_CPLD_M2J_TCK: length 151.1
  TOP w0.112: R3984.2 13.57,64.28 13.57,67.52 14.21,68.17 14.76,69.5 14.76,74.09 v2(11.24,77.62)
  IN1 w0.122: v2(16.67,77.61) 16.17,77.61 16.16,77.62 v2(11.24,77.62) ; v2(78.87,84.58) 78.87,84.86 91.49,97.48 91.49,104.77 91.02,105.89 91.02,107.95 90.58,109.02 90.58,115.57 90.1,116.04 90.1,119.9 88.9,121.11 88.9,123.2 87.96,124.14 87.96,124.69 87.16,125.49 v2(87.16,125.82)
  BOTTOM w0.112: J34.A28 88.92,133.22 88.92,132.09 87.69,130.86 87.69,130.58 87.04,129.93 86.08,129.93 85,128.85 85,127.52 86.1,126.43 86.94,126.08 87.16,125.86 v2(87.16,125.82) ; v2(16.67,77.61) 17.1,77.61 18.2,78.7 18.2,79.06 19.5,80.37 27.93,80.37 29.2,81.64 32.38,81.64 34.66,83.92 37.92,83.92 39.93,85.93 41.81,85.93 42.41,86.53 56.82,86.53 56.9,86.6 61.84,86.6 63.69,88.45 67.39,88.45 68.79,87.06 77.51,87.06 78.87,85.7 v2(78.87,84.58)
JTAG_CPLD_M2J_TCK_R: length 7.4
  TOP w0.112: R3984.1 15.9,61.14 v1(15.9,60.35) 15.27,59.73 15.11,59.73 14.38,58.99 14.38,56.85 14.95,56.27 v2(14.95,56.15)
  BOTTOM w0.112: U94.M8 v2(14.95,56.15)
JTAG_CPLD_M2J_TDI: length 164
  TOP w0.112: R3948.1 4.39,48.34 2.67,50.06 2.67,53.9 1.8,54.77 1.8,60.09 5.95,64.25 5.95,69.77 5.36,70.36 5.36,72.93 5.72,73.28 5.72,75.55 v2(7.21,77.04)
  IN1 w0.122: v2(87.83,126.41) 86.32,126.41 85.88,125.97 85.88,125.01 85.91,124.95 85.91,121.83 86.55,121.19 86.55,119.27 87.38,118.44 87.38,112.03 88.7,110.72 88.7,108.77 89.11,107.76 89.11,104.76 88.98,104.62 88.98,98.42 78.13,87.57 77.39,87.57 76.17,86.36 76.17,85.46 71.23,80.51 63.95,80.51 62.46,79.02 52.98,79.02 52.24,79.76 49.46,79.76 46.77,77.08 28.67,77.08 28.12,77.63 19.59,77.63 19.42,77.46 17.39,77.46 17.1,77.17 7.34,77.17 v2(7.21,77.04)
  BOTTOM w0.112: v2(87.83,126.41) 88.67,127.24 88.67,130.88 89.92,132.13 89.92,133.22 J34.A24
JTAG_CPLD_M2J_TDI_R: length 6.8
  TOP w0.112: v4(10.95,49.15) 10.4,48.59 8.79,48.59 7.9,47.7 6.39,47.7 R3948.2
  BOTTOM w0.112: U94.F4 v4(10.95,49.15)
JTAG_CPLD_M2J_TDO: length 160.1
  IN1 w0.122: v2(87.9,125.4) 88.46,124.85 88.46,124.29 89.33,123.41 89.33,121.46 90.53,120.26 90.53,116.22 91.01,115.75 91.01,109.19 91.45,108.12 91.45,106.01 91.92,104.87 91.92,97.15 v2(79.71,84.94)
  IN2 w0.122: v2(15.96,80.16) 15.96,77.49 16.39,77.06 17.17,77.06 17.36,76.88 17.36,75.55 15.7,73.89 15.7,69.95 13.56,67.81 13.56,63.65 10.41,60.5 9.67,60.5 7.95,58.78 v2(7.95,53.15)
  BOTTOM w0.112: v2(87.9,125.4) 87.63,125.67 87.63,125.97 87.38,126.22 87.38,126.63 88.31,127.56 88.31,131 89.42,132.11 J34.A26 ; v2(79.71,84.94) 79.71,85.37 77.68,87.4 68.93,87.4 67.53,88.79 63.51,88.79 61.66,86.94 47.38,86.94 v3(47.09,87.24) 45.57,88.76 43.49,88.76 42.77,88.04 41.5,88.04 39.01,85.55 37.77,85.55 36.6,84.38 34.56,84.38 32.28,82.09 29.06,82.09 27.69,80.72 19.22,80.72 18.13,79.63 16.48,79.63 v2(15.96,80.16) ; U94.J1 v2(7.95,53.15)
JTAG_CPLD_M2J_TMS: length 167
  TOP w0.112: v2(8.93,76.25) 8.72,76.05 8.72,72.24 7.71,71.23 7.71,63.6 3.5,59.39 3.5,55.89 R3960.1
  IN1 w0.122: v2(86.32,125.78) 86.37,125.74 86.37,121.98 87.15,121.2 87.15,119.53 87.82,118.85 87.82,112.2 89.13,110.9 89.13,108.95 89.54,107.95 89.54,104.58 89.41,104.44 89.41,98.25 78.31,87.15 77.56,87.15 76.6,86.19 76.6,85.28 71.4,80.08 64.13,80.08 62.64,78.59 52.74,78.59 52.01,79.33 49.67,79.33 46.98,76.65 28.26,76.65 27.71,77.2 19.77,77.2 19.14,76.57 17.75,76.57 17.61,76.71 9.38,76.71 v2(8.93,76.25)
  IN2 w0.122: v2(78.17,138.47) 80.99,135.66 83.4,135.66 83.99,135.07 83.99,134.44 88.39,130.03 88.39,127.63 87.2,126.44 86.65,126.44 86.32,126.11 v2(86.32,125.78)
  BOTTOM w0.112: v2(78.17,138.47) 79.17,139.47 J34.A67
JTAG_CPLD_M2J_TMS_R: length 7.5
  TOP w0.112: R3960.2 7.59,54.43 8.41,53.62 11.42,53.62 v4(11.95,54.15)
  BOTTOM w0.112: U94.K5 v4(11.95,54.15)
JTAG_CPLD_M2J_TRST: length 155.5
  TOP w0.112: v2(10.24,82.26) 10.12,82.14 10.12,77.31 11.35,76.09 11.35,72.03 12.16,71.22 12.16,63.06 12.34,62.88 R3972.2
  IN1 w0.122: v2(17.1,80.11) 16.67,80.11 15.78,81 14.65,81 13.76,81.89 11.83,81.89 11.46,82.26 v2(10.24,82.26) ; v2(80.44,84.27) 92.41,96.24 92.41,103.89 92.35,103.94 92.35,104.99 91.88,106.12 91.88,108.21 91.44,109.28 91.44,115.93 90.96,116.4 90.96,120.57 89.76,121.77 v2(89.76,124.06)
  BOTTOM w0.112: J34.A20 90.92,133.22 90.92,132 89.43,130.51 89.43,126.83 90.12,126.14 90.12,124.41 v2(89.76,124.06) ; v2(17.1,80.11) 18.06,81.07 27.43,81.07 29.53,83.17 32.86,83.17 34.52,84.83 36.32,84.83 37.54,86.06 38.84,86.06 41.38,88.6 42.8,88.6 43.3,89.1 46,89.1 47.82,87.28 61.48,87.28 63.33,89.13 67.68,89.13 69.07,87.74 77.82,87.74 80.44,85.12 v2(80.44,84.27)
JTAG_CPLD_M2J_TRST_R: length 4.7
  TOP w0.112: R3972.1 12.34,61.17 v1(13.15,60.36) 13.15,59.86 12.84,59.56 12.84,58.51 12.95,58.4 v2(12.95,58.15)
  BOTTOM w0.112: U94.P6 v2(12.95,58.15)
JTAG_CPLD_M2K_TCK: length 115.9
  TOP w0.112: R3985.2 18.44,62.89 18.02,63.31 15.78,63.31 14.9,64.2 14.9,67.94 15.57,69.57 15.57,76.17 15.03,76.71 v1(15.03,77.86) 15.03,80.94 15.23,81.14 15.23,81.87 14.94,82.16 v2(14.94,82.35)
  IN1 w0.122: v2(14.94,82.35) 17.32,82.35 17.88,81.79 23.35,81.79 23.53,81.98 35.98,81.98 36.51,82.51 42.53,82.51 43.76,83.74 45.29,83.74 48.6,87.05 50.52,87.05 51.03,87.27 52.42,88.66 52.67,89.26 53.27,90.7 63.34,100.76 63.5,100.93 63.5,106.17 64.42,107.09 64.42,112.28 63.58,113.13 63.58,114.77 63.94,115.13 63.94,117.83 62.11,119.66 62.11,125.17 62.24,125.3 v2(62.24,126.62)
  BOTTOM w0.112: v2(62.24,126.62) 62.94,126.62 64.3,127.97 64.3,131.55 64.92,132.18 J6.B28
JTAG_CPLD_M2K_TCK_R: length 6.5
  TOP w0.112: v2(16.95,57.15) 16.8,57.3 v1(16.8,58.33) 17.53,59.06 18.36,59.06 18.56,59.27 18.56,61.53 R3985.1
  BOTTOM w0.112: U94.N9 v2(16.95,57.15)
JTAG_CPLD_M2K_TDI: length 134.1
  TOP w0.112: R3949.1 4.39,50.37 3.37,51.39 3.37,54.16 2.48,55.05 2.48,59.81 6.63,63.97 6.63,70.05 6.05,70.64 6.05,72.53 6.5,72.99 6.5,75.12 8.8,77.42 v2(8.8,77.85)
  IN1 w0.122: v2(8.8,77.85) 10.62,79.67 21.9,79.67 23.78,81.55 38.74,81.55 39.18,82 42.65,82 43.94,83.29 45.47,83.29 48.81,86.63 50.6,86.63 50.81,86.71 51.28,86.9 52.78,88.4 52.81,88.48 53.04,89.02 53.63,90.45 63.84,100.67 63.93,100.75 63.93,105.97 64.85,106.89 64.85,112.39 64.8,112.52 64.03,113.29 64.03,114.6 64.4,114.96 64.4,118.02 62.54,119.88 62.54,123.11 63.06,123.63 63.42,123.63 63.72,123.93 63.72,125.46 v2(63.18,126)
  BOTTOM w0.112: J6.B24 65.92,132.08 64.98,131.13 64.98,126.5 64.31,125.83 63.35,125.83 v2(63.18,126)
JTAG_CPLD_M2K_TDI_R: length 8.4
  TOP w0.112: R3949.2 6.53,50.37 v1(6.95,49.95) 7.29,49.61 10.22,49.61 10.76,50.15 v2(12.95,50.15)
  BOTTOM w0.112: U94.G6 v2(12.95,50.15)
JTAG_CPLD_M2K_TDO: length 136.8
  IN1 w0.122: v2(64.7,86.33) 64.87,86.33 65.23,86.69 65.23,87.52 66.95,89.25 66.95,90.77 72.15,95.97 72.15,105.02 72.48,105.82 v2(72.48,107.59)
  IN2 w0.122: v2(9.95,53.15) 9.95,53.27 9.45,53.77 9.45,56.98 11.62,59.14 12.31,59.14 14.88,61.71 14.88,67.9 16.36,69.39 16.36,69.39 16.44,69.47 16.44,69.48 16.55,69.6 16.55,71.38 17.01,71.84 17.01,73.15 18.46,74.6 18.46,76.79 v2(18.23,77.02) ; v2(63.91,126.4) 64.35,126.84 66.2,126.84 66.36,126.68 66.36,125.83 64.92,124.39 64.92,122.67 70.27,117.33 70.27,115.96 71.26,114.97 71.26,108.81 v2(72.48,107.59)
  BOTTOM w0.112: J6.B26 65.42,132.11 64.64,131.32 64.64,127.83 64.51,127.71 64.51,127 v2(63.91,126.4) ; v2(64.7,86.33) 63.03,84.66 57.7,84.66 57.25,84.2 49.1,84.2 46,81.1 45,81.1 43.39,79.49 39.31,79.49 37.95,78.13 21.03,78.13 19.92,77.02 v2(18.23,77.02) ; U94.J3 v2(9.95,53.15)
JTAG_CPLD_M2K_TMS: length 154.8
  TOP w0.112: v2(10.05,76.05) 9.42,75.41 9.42,69.69 10,69.11 10,64.61 9.04,63.65 9.04,62.37 6.59,59.91 5.55,59.91 4.52,58.88 4.52,57.92 R3961.1
  IN1 w0.122: v2(73.1,104.03) 73.02,103.95 73.02,95.63 67.81,90.42 67.81,88.86 66.28,87.33 v2(66.28,86.55)
  IN2 w0.122: v2(73.1,104.03) 72.59,104.03 69.25,107.37 69.25,114.87 66.01,118.1 66.01,119.02 64.06,120.97 64.06,124.45 63.95,124.57 63.52,124.57 63.34,124.75 63.34,125.03 63.31,125.03 62.58,125.76 62.58,126.18 64,127.6 64,130.21 62.02,132.19 58.61,132.19 v2(57.59,131.17)
  BOTTOM w0.112: v2(66.28,86.55) 66.28,86.04 64.22,83.98 57.99,83.98 57.49,83.48 49.73,83.48 48.76,82.5 48.76,81.47 47.75,80.46 47.75,79.97 47.2,79.42 44.29,79.42 43.68,78.81 39.8,78.81 38.42,77.43 21.37,77.43 19.88,75.94 17.37,75.94 16.71,75.28 13.43,75.28 12.66,76.05 v2(10.05,76.05) ; v2(57.59,131.17) 56.68,132.08 56.68,134.71 55.17,136.22 J6.B67
JTAG_CPLD_M2K_TMS_R: length 7.2
  TOP w0.112: v2(10.95,55.15) 10.58,55.15 10.13,55.59 8.48,55.59 7.84,56.24 7.84,56.87 v1(7.59,57.12) 7.23,57.48 R3961.2
  BOTTOM w0.112: U94.L4 v2(10.95,55.15)
JTAG_CPLD_M2K_TRST: length 122
  IN1 w0.122: v2(65.51,86.08) 65.68,86.24 65.68,87.36 67.38,89.06 67.38,90.59 72.59,95.8 72.59,104.5 72.6,104.51 v2(72.6,104.91)
  IN2 w0.122: v2(65.69,126.21) 65.1,126.21 64.49,125.6 64.49,122.49 69.78,117.2 69.78,112.93 70.35,112.36 70.35,106.87 72.37,104.86 72.55,104.86 v2(72.6,104.91) ; v2(14.33,69.61) 15.27,70.55 15.27,74.64 v2(16.89,76.26)
  BOTTOM w0.112: v2(16.89,76.26) 16.95,76.32 19.75,76.32 21.22,77.79 38.11,77.79 39.48,79.15 43.53,79.15 44.15,79.76 47.06,79.76 47.41,80.11 47.41,81.63 49.59,83.82 57.35,83.82 57.84,84.32 63.76,84.32 v2(65.51,86.08) ; R3973.2 17.49,66.76 17.49,67.44 17.3,67.63 16.23,67.63 14.4,69.46 14.4,69.53 v2(14.33,69.61) ; J6.B20 66.92,131.91 65.32,130.31 65.32,126.58 v2(65.69,126.21)
JTAG_CPLD_M2K_TRST_R: length 7.6
  BOTTOM w0.112: R3973.1 v3(17.09,64.39) 17.09,63.98 16.51,63.4 16.51,62.33 13.83,59.65 U94.T6
JTAG_CPLD_M2L_TCK: length 92.2
  IN1 w0.122: v4(24.39,90.66) 25.05,91.32 30.59,91.32 32.25,89.66 36.4,89.66 44.33,97.59 44.33,107.19 44.15,107.37 43.02,110.1 43.02,110.19 44.38,111.56 44.38,121.71 43.37,122.72 43.37,124.08 43.06,124.4 40.95,124.4 v2(40.93,124.42)
  IN2 w0.122: v4(24.39,90.66) 24.39,86.88 23.39,85.89 23.39,76.53 22.98,76.11 22.98,74.46 22.14,73.62 22.13,73.62 22.13,72.14 21.5,71.52 21.5,70.78 21.86,70.42 v2(21.86,67.17)
  BOTTOM w0.112: J6.A28 40.92,132.03 40.53,131.09 40.32,130.88 40.32,127.79 38.78,126.25 38.78,125.86 39.78,124.86 40.49,124.86 v2(40.93,124.42) ; R3986.2 20.52,66.72 20.98,67.17 v2(21.86,67.17)
JTAG_CPLD_M2L_TCK_R: length 11
  BOTTOM w0.112: R3986.1 21.42,64.67 21.42,63.31 v3(21.28,63.18) 20.61,62.5 19.11,62.5 18.02,61.42 17.42,61.42 15.93,59.92 15.93,59.17 U94.R9
JTAG_CPLD_M2L_TDI: length 123.1
  TOP w0.112: v2(10.38,87.22) 9.86,86.69 9.86,86.03 8.61,84.78 8.61,82.99 8.26,82.64 8.26,81.05 8.83,80.49 8.83,78.55 8.26,77.99 8.26,77.4 6.07,75.21 6.07,73.08 5.71,72.71 5.71,70.5 6.29,69.91 6.29,64.11 2.14,59.95 2.14,54.91 3.01,54.04 3.01,50.73 4.39,49.35 R3950.1
  IN1 w0.122: v2(10.38,87.22) 11.08,87.92 11.62,87.92 12.36,88.65 30.21,88.65 31.37,87.48 36.05,87.48 45.62,97.06 45.62,108.2 45.51,108.32 45.51,110.45 46.18,111.13 46.18,115.19 46.26,115.27 46.26,116.61 45.79,117.08 45.79,122.58 44.72,123.66 44.72,124.98 42.74,126.96 42.49,126.96 41.63,127.81 41.63,129.29 41.64,129.3 41.64,130.05 v2(41.16,130.53)
  BOTTOM w0.112: v2(41.16,130.53) 41.48,130.84 41.48,131.38 41.92,131.83 J6.A24
JTAG_CPLD_M2L_TDI_R: length 5.7
  TOP w0.112: v2(9.95,49.15) 8.81,49.15 7.99,48.32 v1(7.25,48.32) 6.79,48.32 R3950.2
  BOTTOM w0.112: U94.F3 v2(9.95,49.15)
JTAG_CPLD_M2L_TDO: length 114.4
  IN1 w0.122: v2(18.63,90.01) 24.62,90.01 25.39,90.78 30.47,90.78 32.02,89.23 36.58,89.23 44.76,97.41 44.76,107.43 44.64,107.56 44.64,110.85 44.83,111.04 44.83,122.04 43.82,123.05 43.82,124.47 43.31,124.97 42.24,124.97 41.92,125.3 v2(39.98,125.3)
  IN2 w0.122: v2(8.95,53.15) 8.95,57.82 14.45,63.31 14.45,68.08 16.01,69.65 16.01,69.66 16.13,69.77 16.13,73.71 17.79,75.37 17.79,78.53 18.2,78.94 18.2,81.68 18.15,81.68 17.05,82.79 17.05,84.52 17.05,84.53 17.05,84.89 17.05,84.9 19.14,86.99 19.14,89.51 v2(18.63,90.01)
  BOTTOM w0.112: v2(39.98,125.3) 39.85,125.3 39.29,125.86 39.29,126.27 40.7,127.68 40.7,130.75 41.14,131.19 41.14,131.56 41.42,131.85 J6.A26 ; U94.J2 v2(8.95,53.15)
JTAG_CPLD_M2L_TMS: length 108.1
  IN2 w0.122: v2(7.9,74.02) 7.9,82.37 8.82,83.29 8.82,84.66 9.94,85.78 9.94,87.62 11.55,89.23 12.43,89.23 14.38,91.18 14.38,100.9 16,102.53 16,106.06 17.78,107.84 17.78,108.9 17.13,109.54 17.13,110.47 16.87,110.73 16.87,112.16 v2(15.48,113.55)
  BOTTOM w0.112: v2(7.9,74.02) 8.16,73.75 8.16,71.6 6.76,70.2 6.76,62.59 3.04,58.87 R3962.1 ; v2(15.48,113.55) 16.22,113.55 17.63,114.96 18.93,114.96 19.77,115.81 19.77,118.69 22.67,121.58 22.67,129.81 20.99,131.48 20.99,134.17 21.4,134.57 21.4,139.05 26.72,144.37 30.29,144.37 31.17,143.49 J6.A67
JTAG_CPLD_M2L_TMS_R: length 8.1
  BOTTOM w0.112: U94.M3 10.44,55.65 9.91,56.18 8.31,56.18 7.21,57.29 7.21,57.47 7.02,57.47 6.86,57.63 6.25,57.63 5.74,58.15 5,58.15 4.27,58.87 R3962.2
JTAG_CPLD_M2L_TRST: length 105.4
  TOP w0.112: R3974.2 11.33,63.21 11.82,63.7 11.82,71.01 11.01,71.82 11.01,75.8 9.73,77.08 9.73,82.36 10.21,82.84 10.21,86.33 10.88,87 10.88,87.93 v2(11.3,88.36)
  IN1 w0.122: v2(11.3,88.36) 12.4,89.46 14.51,89.46 14.89,89.84 17.2,89.84 17.65,89.38 30.88,89.38 31.49,88.77 32.82,88.77 33.68,87.91 35.87,87.91 45.2,97.23 45.2,107.62 45.07,107.74 45.07,110.66 45.35,110.94 45.35,119.29 45.32,119.32 45.32,122.23 44.26,123.29 44.26,124.81 v2(42.6,126.47)
  BOTTOM w0.112: J6.A20 42.92,131.77 42.16,131.01 42.16,129.85 41.23,128.92 41.23,127.84 v2(42.6,126.47)
JTAG_CPLD_M2L_TRST_R: length 6.2
  TOP w0.112: R3974.1 11.33,60.79 v1(10.97,60.43) 10.97,60.03 11.71,59.29 11.71,59.03 12.47,58.27 12.47,57.61 12.93,57.15 v2(12.95,57.15)
  BOTTOM w0.112: U94.N6 v2(12.95,57.15)
JTAG_CPLD_TCK: length 15.1
  TOP w0.112: J58.8 7.05,43.45 R3916.1 7.5,42.36 7.7,42.16 11.43,42.16 14.22,39.37 v2(14.22,37.57)
  BOTTOM w0.112: R3920.2 13.89,37.89 v2(14.22,37.57)
JTAG_CPLD_TCK_R: length 5.1
  BOTTOM w0.112: U94.A7 14.45,43.51 13.8,42.85 13.8,41.74 13.61,41.55 v3(13.61,41.2) 13.84,40.97 13.84,40.05 R3920.1
JTAG_CPLD_TDI: length 10.7
  TOP w0.112: v2(10.05,37.52) 9.93,37.64 9.93,38.9 9.46,39.37 8.19,39.37 R3913.2 6.27,38.56 6.17,38.45 J58.3
  BOTTOM w0.112: v2(10.05,37.52) 10.71,37.52 11.47,38.28 11.99,38.28 R3918.2
JTAG_CPLD_TDI_R: length 5.4
  BOTTOM w0.112: U94.A6 13.45,44.49 12.34,43.38 v3(12.34,41.2) 12.34,40.76 12.88,40.22 R3918.1
JTAG_CPLD_TDO: length 9.2
  TOP w0.112: J58.2 6.69,37.45 6.78,37.54 R3915.2 7.93,36.98 10.31,36.98 10.62,37.29 v2(10.62,38.79)
  BOTTOM w0.112: v2(10.62,38.79) 10.8,38.79 10.9,38.89 11.55,38.89 R3917.2
JTAG_CPLD_TDO_R: length 8
  BOTTOM w0.112: U94.C6 12.98,46.17 12.98,44.56 11.84,43.41 11.84,41.97 v3(11.07,41.2) 11.84,40.43 R3917.1
JTAG_CPLD_TMS: length 19.4
  TOP w0.112: v2(11.4,35.69) 11.15,35.94 11.15,37.72 11.58,38.15 11.58,41.15 10.91,41.82 8.48,41.82 R3914.2 7.24,40.97 6.76,41.45 J58.6
  BOTTOM w0.112: R3919.2 14.94,37.53 13.1,35.69 v2(11.4,35.69)
JTAG_CPLD_TMS_R: length 6.3
  BOTTOM w0.112: U94.B8 15.92,45.17 15.92,43.79 14.92,42.78 14.92,41.15 14.94,41.14 R3919.1
JTAG_PESE_TDI_R: length 4.4
  TOP w0.112: J47.3 v2(8.8,104.14) 8.85,104.2 R3271.2 R3270.2
JTAG_PESW_RSTB: length 255
  TOP w0.112: U34.AG29 v6(193.59,72.02) ; J47.7 v2(7.21,102.14)
  IN2 w0.122: v2(91.38,44.83) 92.05,45.5 103.97,50.44 163.09,50.44 164.21,51.56 168.23,51.56 170.3,52.42 173.11,55.22 178.27,57.36 182.43,61.52 189.78,61.52 190.08,61.82 190.08,68.85 191.11,69.88 191.11,70.26 191.33,70.48 192.04,70.48 v6(193.59,72.02)
  BOTTOM w0.112: v6(193.59,72.02) 193.65,72.08 R3284.2 ; v2(91.38,44.83) 91.38,46.75 92.25,47.62 92.25,58.67 93.16,59.58 93.16,72.51 89.54,76.12 89.54,84.1 80.3,93.34 72.71,93.34 69.28,96.77 61.04,96.77 59.76,95.5 38.13,95.5 36.19,97.45 31.41,97.45 31.17,97.21 29.13,97.21 26.37,94.45 26.37,94.35 25.57,93.55 18.49,93.55 8.89,103.15 8.21,103.15 v2(7.21,102.14)
JTAG_PESW_TCK: length 250.6
  TOP w0.112: J47.6 7.56,102.64 7.68,102.52 7.68,101.68 v2(7.32,101.32) ; U34.AF26 v6(190.59,73.02)
  IN2 w0.122: v6(190.59,73.02) 190.18,73.43 186.33,73.43 186.11,73.21 186.11,69.82 185.8,69.5 183.67,69.5 183.45,69.29 183.45,65.17 182.27,63.98 181.16,63.53 180.34,63.53 179.76,62.94 179.76,61.87 176.3,58.41 171.45,56.41 169.06,54.01 167.52,53.38 166.8,53.38 166.79,53.37 158.95,53.37 157.75,52.17 102.31,52.17 v2(91.46,47.67)
  BOTTOM w0.112: R3273.2 191.14,73.02 v6(190.59,73.02) ; v2(91.46,47.67) 91.09,48.03 91.09,58.02 92.82,59.75 92.82,72.33 89.11,76.04 89.11,84.05 80.16,93 72.57,93 69.14,96.43 61.18,96.43 59.91,95.16 37.99,95.16 36.04,97.11 31.66,97.11 31.38,96.83 29.89,96.83 27.46,94.4 27.46,94.3 26.37,93.21 18.26,93.21 9.68,101.79 7.8,101.79 v2(7.32,101.32)
JTAG_PESW_TDI: length 251
  TOP w0.112: v2(11.24,97.87) 11.24,98.22 11.55,98.53 11.55,101.81 R3270.1 ; U34.AG26 v6(190.59,72.02)
  IN2 w0.122: v2(89.13,44.76) 89.13,45.32 90.27,46.46 103.01,51.73 158.24,51.73 159.41,52.91 167.74,52.91 169.18,53.51 171.73,56.06 176.79,58.15 181.66,63.02 182.2,63.24 184,65.04 184,68.4 184.12,68.53 184.72,68.53 185.29,69.09 186.82,69.09 187.09,69.36 187.09,72.18 187.34,72.43 190.18,72.43 v6(190.59,72.02)
  BOTTOM w0.112: v2(11.24,97.87) 13.49,95.63 13.49,94.92 16.21,92.19 28.78,92.19 30.86,94.28 30.86,94.5 32.45,96.09 35.62,96.09 37.57,94.14 60.33,94.14 61.6,95.41 68.71,95.41 72.28,91.84 79.87,91.84 87.72,84 87.72,75.91 91.8,71.83 91.8,60.25 89.94,58.39 89.94,47.88 89.13,47.07 v2(89.13,44.76)
