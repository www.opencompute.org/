# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P3E_PESW_M2H_TX2_C_DN: length 88.9
  IN1 w0.136: v2(141.05,103.23) 140.68,103.59 140.68,104 140.19,105.19 140.19,109.93 140.32,110.25 140.32,123.04 139.62,125.34 138.86,126.48 138.26,126.72 137.43,127.56 137.16,128.31 137.57,132.42 138.06,134.9 138.06,135.73 v2(138.43,136.1)
  BOTTOM w0.124: v2(138.43,136.1) 138.07,136.45 138.07,139.86 138.17,139.96 J8.A23 ; C890.2 181.12,103.61 181.12,106.52 179.93,107.71 169.26,107.71 162.63,101.09 158.89,99.54 144.55,99.54 142.09,100.42 140.69,102.52 140.69,102.87 v2(141.05,103.23)
P3E_PESW_M2H_TX2_C_DP: length 88.9
  IN1 w0.136: v2(140.03,103.23) 140.4,103.59 140.4,103.95 139.91,105.14 139.91,109.99 140.04,110.3 140.04,123 139.36,125.22 138.67,126.25 138.1,126.49 137.03,127.56 137.03,127.84 136.88,128.28 137.29,132.46 137.78,134.93 137.78,135.73 v2(137.41,136.1)
  BOTTOM w0.124: J8.A25 137.67,139.97 137.77,139.87 137.77,136.45 v2(137.41,136.1) ; C891.2 180.81,103.59 180.81,106.39 179.8,107.41 169.38,107.41 162.81,100.83 158.95,99.23 144.5,99.23 141.89,100.17 140.38,102.42 140.38,102.87 v2(140.03,103.23)
P3E_PESW_M2H_TX2_DN: length 7.2
  TOP w0.124: U34.B19 v6(182.59,98.02)
  BOTTOM w0.099: v6(182.59,98.02) 182.59,97.72 182.49,97.62 182.29,97.62 182.19,97.72 182.19,98.24 182.29,98.35 182.29,98.54 182.19,98.65 182.19,98.84 182.29,98.94 182.29,99.14 182.19,99.24 182.19,99.44 181.96,99.67 181.96,99.82 181.82,99.96 181.68,99.96 181.54,100.1 181.54,100.24 181.4,100.38 181.25,100.38 181.08,100.55 181.08,100.95 181.13,101 181.13,101.03
  BOTTOM w0.124: C890.1 181.13,102.09 181.13,101.03
P3E_PESW_M2H_TX2_DP: length 7.2
  TOP w0.124: U34.C19 v6(182.59,97.02)
  BOTTOM w0.099: v6(182.59,97.02) 182.59,97.32 182.49,97.42 182.21,97.42 181.99,97.64 181.99,99.36 180.88,100.47 180.88,100.95 180.83,101 180.83,101.03
  BOTTOM w0.124: C891.1 180.83,102.09 180.83,101.03
P3E_PESW_M2H_TX3_C_DN: length 91.1
  IN1 w0.136: v2(141.4,136.87) 141.03,136.5 141.03,136.1 140.65,135.18 139.57,134.1 138.9,132.48 139.46,129.68 140.36,128.78 141.85,125.17 141.85,119.06 142.12,117.72 142.12,116.45 141.5,114.95 141.5,110.7 141.11,109.76 141.11,108.56 141.11,108.56 141.11,107.58 141.9,105.68 141.9,104.94 v2(142.27,104.57)
  BOTTOM w0.124: v2(142.27,104.57) 141.91,104.22 141.91,104.04 141.97,103.91 143.98,101.89 146.71,100.76 158.54,100.76 161.97,102.18 168.48,108.68 169.14,108.96 181.78,108.96 183.62,107.12 183.62,102.3 C888.2 ; v2(141.4,136.87) 141.06,137.21 141.06,139.85 141.17,139.96 J8.A11
P3E_PESW_M2H_TX3_C_DP: length 91.1
  IN1 w0.136: v2(140.39,136.87) 140.75,136.5 140.75,136.16 140.41,135.34 139.33,134.26 138.61,132.51 139.2,129.54 140.12,128.62 141.57,125.11 141.57,119.04 141.84,117.69 141.84,116.5 141.22,115 141.22,110.75 140.83,109.81 140.83,108.68 140.83,108.68 140.83,107.53 141.62,105.62 141.62,104.94 v2(141.25,104.57)
  BOTTOM w0.124: J8.A13 140.67,139.96 140.76,139.88 140.76,137.24 v2(140.39,136.87) ; C889.2 183.32,102.3 183.32,106.99 181.66,108.65 169.2,108.65 168.65,108.43 162.15,101.92 158.6,100.46 146.65,100.46 143.81,101.63 141.71,103.73 141.6,103.98 141.6,104.22 v2(141.25,104.57)
P3E_PESW_M2H_TX3_DN: length 4.9
  TOP w0.124: U34.A20 v6(184.59,99.02)
  BOTTOM w0.124: C888.1 183.56,100.73 183.56,100.26 183.72,100.1 183.72,99.69 183.56,99.52 183.56,98.87 183.91,98.51 184.46,98.51 184.59,98.64 v6(184.59,99.02)
P3E_PESW_M2H_TX3_DP: length 4.9
  TOP w0.124: U34.B20 v6(184.59,98.02)
  BOTTOM w0.124: v6(184.59,98.02) 184.59,98.08 184.46,98.21 183.78,98.21 183.25,98.74 183.25,100.86 C889.1
P3E_PESW_M2I_RX0_DN: length 100.8
  TOP w0.124: U34.E5 v6(168.59,95.02)
  IN2 w0.099: 165.57,94.66 165.6,94.66 165.64,94.62 168.9,94.62 169,94.72 169,94.92 168.9,95.02 v6(168.59,95.02)
  IN2 w0.136: v2(107.74,135.71) 107.36,135.33 107.36,134.67 109.68,132.35 110.72,132.35 111.38,131.69 111.38,130.52 111.05,130.2 109.86,129.7 109.33,129.17 109.33,124.26 109.64,123.54 109.65,123.54 110.09,122.47 110.95,121.19 117.13,118.62 117.61,118.15 117.98,117.26 117.98,110.21 118.46,109.03 119.52,107.97 119.92,107 119.92,106.79 119.58,105.96 119.58,104.93 119.78,104.45 119.92,104.3 120.05,104.25 121.27,104.25 121.96,103.97 123.02,102.91 124.1,100.88 124.61,100.54 128.39,98.97 140.41,96.58 149.24,95.71 149.39,95.83 149.79,95.79 149.91,95.65 150.32,95.61 150.46,95.72 150.87,95.68 150.98,95.54 151.39,95.5 151.53,95.62 151.94,95.58 152.06,95.43 152.46,95.39 152.61,95.51 153.01,95.47 153.13,95.33 153.54,95.29 153.68,95.41 154.09,95.37 154.21,95.22 154.61,95.18 154.76,95.3 155.16,95.26 155.28,95.12 155.69,95.08 155.83,95.19 156.24,95.16 156.36,95.01 159.92,94.66 165.57,94.66
  BOTTOM w0.124: J34.B41 109.67,140.06 109.57,139.96 109.57,138.8 108.95,137.87 107.59,137.31 107.33,137.05 107.33,136.11 v2(107.74,135.71)
P3E_PESW_M2I_RX0_DP: length 100.8
  TOP w0.124: U34.E6 v6(169.59,95.02)
  IN2 w0.099: 165.57,94.38 165.6,94.38 165.64,94.42 168.98,94.42 169.2,94.64 169.2,94.92 169.3,95.02 v6(169.59,95.02)
  IN2 w0.136: 165.57,94.38 159.91,94.38 140.37,96.3 128.31,98.7 124.48,100.29 123.89,100.68 122.79,102.74 121.8,103.73 121.21,103.97 119.99,103.97 119.77,104.07 119.54,104.29 119.3,104.87 119.3,106.01 119.64,106.84 119.64,106.95 119.29,107.81 118.23,108.87 117.7,110.15 117.7,117.21 117.37,117.99 116.97,118.39 110.76,120.96 109.85,122.34 109.43,123.33 109.42,123.33 109.05,124.2 109.05,129.29 109.7,129.94 110.9,130.43 111.1,130.64 111.1,131.58 110.61,132.07 109.56,132.07 107.08,134.56 107.08,135.35 v2(106.72,135.71)
  BOTTOM w0.124: J34.B43 109.17,140.07 109.27,139.97 109.27,138.89 108.75,138.12 107.42,137.57 107.03,137.17 107.03,135.89 106.84,135.71 v2(106.72,135.71)
P3E_PESW_M2I_RX1_DN: length 99.6
  TOP w0.124: U34.D4 v6(167.59,96.02)
  IN2 w0.099: 165.54,95.66 165.57,95.66 165.61,95.62 167.9,95.62 168,95.72 168,95.92 167.9,96.02 v6(167.59,96.02)
  IN2 w0.136: v2(112.94,136.06) 112.57,135.69 112.57,134.16 112.27,133.86 111.58,133.86 111.44,133.73 111.44,133.1 111.58,132.97 112.27,132.97 112.57,132.67 112.57,132.29 112.47,132.05 112.47,127.68 113.21,125.89 113.21,124.01 112.88,123.67 112.88,122.68 113.45,121.82 114.99,120.55 117.7,119.43 118.39,118.75 118.91,117.48 118.91,112.24 119.67,110.42 120.18,109.9 120.31,109.56 120.31,108.85 120.76,108.18 122.25,107.56 122.81,107 123.58,106.16 123.56,105.75 122.58,104.86 122.57,104.72 123.03,104.21 123.18,104.2 124.15,105.09 124.57,105.07 125.07,104.51 125.15,104.42 125.13,104.01 124.47,103.42 124.46,103.24 124.89,102.77 125.07,102.76 125.72,103.35 126.14,103.33 127.17,102.19 127.63,101.87 128.83,101.37 128.99,100.98 128.65,100.17 128.72,99.99 129.3,99.75 129.48,99.83 129.82,100.64 130.21,100.8 131.52,100.26 131.69,99.86 131.58,99.6 131.65,99.42 132.23,99.18 132.41,99.25 132.52,99.52 132.91,99.68 134.56,99 134.56,99 142.33,97.45 148.74,96.82 148.88,96.94 149.29,96.9 149.41,96.76 149.82,96.72 149.96,96.83 150.37,96.8 150.48,96.65 150.89,96.61 151.03,96.73 151.44,96.69 151.56,96.54 151.96,96.5 152.11,96.62 152.51,96.58 152.63,96.44 153.04,96.4 153.18,96.52 153.59,96.48 153.71,96.33 154.11,96.29 154.26,96.41 154.66,96.37 154.78,96.23 155.19,96.19 155.33,96.31 155.74,96.27 155.86,96.12 160.55,95.66 165.54,95.66
  BOTTOM w0.124: v2(112.94,136.06) 112.58,136.42 112.58,139.97 112.67,140.06 J34.B29
P3E_PESW_M2I_RX1_DP: length 99.6
  TOP w0.124: U34.D5 v6(168.59,96.02)
  IN2 w0.099: 165.54,95.38 165.57,95.38 165.61,95.42 167.98,95.42 168.2,95.64 168.2,95.92 168.3,96.02 v6(168.59,96.02)
  IN2 w0.136: v2(111.92,136.06) 112.29,135.69 112.29,134.28 112.15,134.14 111.46,134.14 111.17,133.84 111.17,132.99 111.46,132.69 112.15,132.69 112.29,132.55 112.29,132.34 112.19,132.11 112.19,127.63 112.94,125.84 112.94,124.12 112.6,123.79 112.6,122.59 113.24,121.63 114.85,120.31 117.55,119.19 118.15,118.59 118.63,117.42 118.63,112.19 119.43,110.26 119.94,109.75 120.03,109.51 120.04,109.51 120.04,108.77 120.58,107.95 122.09,107.33 122.61,106.81 123.29,106.05 123.28,105.88 122.31,104.99 122.29,104.61 122.9,103.93 123.28,103.92 124.26,104.8 124.44,104.79 124.86,104.32 124.85,104.14 124.2,103.55 124.18,103.14 124.76,102.49 125.17,102.47 125.83,103.07 126.01,103.06 126.98,101.98 127.5,101.62 128.61,101.16 128.69,100.98 128.35,100.17 128.51,99.78 129.3,99.45 129.69,99.61 130.03,100.42 130.21,100.5 131.31,100.04 131.38,99.86 131.27,99.6 131.43,99.21 132.23,98.88 132.62,99.04 132.73,99.31 132.91,99.38 134.48,98.73 142.28,97.18 160.53,95.38 165.54,95.38
  BOTTOM w0.124: J34.B31 112.17,140.56 112.17,140.56 112.17,140.03 112.27,139.93 112.27,136.41 v2(111.92,136.06)
P3E_PESW_M2I_RX2_DN: length 91
  TOP w0.124: U34.C5 v6(168.59,97.02)
  IN2 w0.099: 165.7,96.66 165.72,96.66 165.76,96.62 168.9,96.62 169,96.72 169,96.92 168.9,97.02 v6(168.59,97.02)
  IN2 w0.136: 165.7,96.66 161.17,96.66 156.21,97.15 156.09,97.29 155.68,97.33 155.54,97.21 155.13,97.25 155.01,97.4 154.61,97.44 154.46,97.32 154.06,97.36 153.94,97.5 153.53,97.54 153.39,97.43 152.98,97.47 152.86,97.61 152.46,97.65 152.31,97.53 151.91,97.57 151.79,97.72 151.38,97.76 151.24,97.64 150.83,97.68 150.71,97.82 150.31,97.86 150.16,97.74 149.76,97.78 149.64,97.93 149.23,97.97 149.09,97.85 141.44,98.6 135.63,99.76 131.75,101.37 130.46,102.66 129.55,104.84 128.84,105.55 127.71,106.02 126.28,106.02 124.74,106.66 124.17,107.23 124.17,108.34 123.82,109.17 122.71,110.29 122.1,110.54 120.86,110.54 120.5,110.9 119.86,112.45 119.86,117.71 118.95,119.9 117.67,121.18 117.3,121.18 117,120.88 116.68,120.88 116.23,121.33 116.23,121.51 116.58,121.86 116.58,122.27 116.09,122.77 114.84,124.63 114.84,126.23 113.72,127.36 113.47,127.96 113.47,131.3 115.56,133.39 115.56,135.08 v2(115.95,135.47)
  BOTTOM w0.124: J34.B17 115.67,140.06 115.56,139.96 115.56,137.76 115.6,136.73 115.6,135.82 v2(115.95,135.47)
P3E_PESW_M2I_RX2_DP: length 91
  TOP w0.124: U34.C6 v6(169.59,97.02)
  IN2 w0.099: 165.7,96.38 165.72,96.38 165.76,96.42 168.98,96.42 169.2,96.64 169.2,96.92 169.3,97.02 v6(169.59,97.02)
  IN2 w0.136: v2(114.94,135.47) 115.28,135.13 115.28,133.5 113.19,131.41 113.19,127.9 113.48,127.2 114.57,126.12 114.57,124.54 115.87,122.59 116.3,122.16 116.3,121.98 115.95,121.63 115.95,121.22 116.57,120.6 117.11,120.6 117.41,120.9 117.56,120.9 118.72,119.74 119.58,117.66 119.58,112.39 120.26,110.75 120.75,110.26 122.05,110.26 122.56,110.05 123.59,109.02 123.89,108.28 123.89,107.12 124.59,106.42 126.22,105.74 127.65,105.74 128.68,105.32 129.32,104.68 130.22,102.5 131.59,101.13 135.55,99.49 141.4,98.33 161.15,96.38 165.7,96.38
  BOTTOM w0.124: J34.B19 115.17,140.04 115.26,139.96 115.26,137.75 115.3,136.71 115.3,135.83 v2(114.94,135.47)
P3E_PESW_M2I_RX3_DN: length 91.4
  TOP w0.124: U34.B4 v6(167.59,98.02)
  IN2 w0.099: 165.67,97.66 165.69,97.66 165.73,97.62 167.9,97.62 168,97.72 168,97.92 167.9,98.02 v6(167.59,98.02)
  IN2 w0.136: 165.67,97.66 162.47,97.66 160.55,97.85 160.43,97.99 160.02,98.03 159.88,97.91 159.47,97.95 159.36,98.1 158.95,98.14 158.8,98.02 158.4,98.06 158.28,98.21 157.87,98.25 157.73,98.13 157.32,98.17 157.21,98.31 156.8,98.35 156.66,98.23 156.2,98.28 156.08,98.42 155.67,98.46 155.53,98.34 155.12,98.38 155,98.53 154.6,98.57 154.45,98.45 154.05,98.49 153.93,98.63 153.52,98.67 153.38,98.56 140.04,99.87 136.13,100.65 132.43,102.18 131.5,103.1 130.67,105.13 129.5,106.3 127.86,106.97 126.64,106.97 126.5,107.07 125.16,108.7 123.46,112.8 123.34,113.4 122.55,115.7 121.94,117.89 121.91,118.34 121.7,118.8 116.84,123.66 116.27,124.51 116.27,128.36 115.85,129.38 115.53,129.69 115.37,130.1 115.37,131.21 115.69,131.53 115.88,131.53 116.17,131.82 116.17,132.02 117.03,132.88 121.58,132.88 122.43,133.72 122.43,134.95 v2(122.79,135.31)
  BOTTOM w0.124: v2(122.79,135.31) 122.45,135.65 122.45,136.03 121.62,136.86 121.51,136.86 120.23,138.02 118.67,139.58 J34.B5
P3E_PESW_M2I_RX3_DP: length 91.4
  TOP w0.124: U34.B5 v6(168.59,98.02)
  IN2 w0.099: v6(168.59,98.02) 168.3,98.02 168.2,97.92 168.2,97.64 167.98,97.42 165.73,97.42 165.69,97.38 165.67,97.38
  IN2 w0.136: v2(121.77,135.31) 122.15,134.93 122.15,133.84 121.47,133.16 116.91,133.16 115.09,131.33 115.09,130.04 115.3,129.53 115.61,129.22 115.99,128.3 115.99,124.43 116.62,123.48 121.47,118.64 121.64,118.27 121.67,117.84 122.28,115.62 123.07,113.33 123.19,112.71 124.91,108.56 126.31,106.86 126.55,106.69 127.81,106.69 129.34,106.06 130.43,104.97 130.83,104.01 131.27,102.94 132.27,101.94 136.05,100.38 140,99.59 162.46,97.38 165.67,97.38
  BOTTOM w0.124: v2(121.77,135.31) 122.14,135.68 122.14,135.9 121.49,136.55 121.39,136.55 120.02,137.8 118.37,139.45 118.37,139.74 118.17,139.93 J34.B7
P3E_PESW_M2I_TX0_C_DN: length 85.2
  TOP w0.124: v2(110.29,103.91) 109.95,103.57 109.95,103.44 110.94,102.46 111.11,102.46 111.39,102.18 111.39,102 111.65,101.74 111.91,101.74 112.17,101.47 112.17,101.22 113.09,100.3 113.09,99.84 113.36,99.58 113.61,99.58 113.87,99.32 113.87,99.06 117.09,95.85 120.8,94.31 126.33,94.31 127.27,94.5 131.14,93.72 134.32,94.36 137.49,93.72 140.67,94.36 143.84,93.72 147.74,94.5 148.88,94.5 149.03,94.65 149.4,94.65 149.55,94.5 150.06,94.5 150.43,94.65 150.92,94.65 C413.2
  IN1 w0.136: v2(108.43,138.95) 108.06,138.58 108.06,138.05 108.75,136.39 108.75,135.34 108.65,135.1 107.69,134.14 106.85,132.11 106.85,131.38 107.13,129.99 107.13,127.69 108,123.29 108,121.77 109.56,113.94 109.56,112.97 109.44,110.64 109.44,106.31 109.94,105.12 109.94,104.26 v2(110.29,103.91)
  BOTTOM w0.124: J34.B47 108.17,140.04 108.07,139.95 108.07,139.31 v2(108.43,138.95)
P3E_PESW_M2I_TX0_C_DP: length 85.2
  TOP w0.124: v2(109.27,103.91) 109.65,103.53 109.65,103.32 112.79,100.17 112.79,99.72 116.92,95.59 120.74,94.01 126.36,94.01 127.27,94.19 131.14,93.41 134.32,94.05 137.49,93.41 140.67,94.05 143.84,93.41 147.77,94.2 150.12,94.2 150.49,94.35 150.92,94.35 C414.2
  IN1 w0.136: v2(107.41,138.95) 107.78,138.58 107.78,137.99 108.47,136.34 108.47,135.39 108.41,135.26 107.45,134.3 107.43,134.25 106.57,132.17 106.57,131.35 106.85,129.96 106.85,127.66 107.72,123.27 107.72,121.75 109.28,113.92 109.28,112.98 109.16,110.65 109.16,106.25 109.66,105.06 109.66,104.29 v2(109.27,103.91)
  BOTTOM w0.124: v2(107.41,138.95) 107.77,139.31 107.77,139.93 107.67,140.03 J34.B49
P3E_PESW_M2I_TX0_DN: length 15.7
  TOP w0.099: U34.E2 166.39,94.52 166.49,94.42 166.49,94.22 166.39,94.12 165.58,94.12 165.48,94.22 165.28,94.22 165.18,94.12 164.98,94.12 164.88,94.22 164.68,94.22 164.58,94.12 164.28,94.12 164.09,94.18 164.02,94.3 163.83,94.36 163.71,94.29 163.52,94.35 163.45,94.48 163.26,94.53 163.13,94.46 162.67,94.6 162.06,94.6 162.01,94.65 161.98,94.65
  TOP w0.124: C413.1 152.43,94.65 161.98,94.65
P3E_PESW_M2I_TX0_DP: length 15.7
  TOP w0.099: 161.98,94.35 162.01,94.35 162.06,94.4 162.64,94.4 164.25,93.92 166.47,93.92 166.69,94.14 166.69,94.42 166.79,94.52 U34.E3
  TOP w0.124: C414.1 152.43,94.35 161.98,94.35
P3E_PESW_M2I_TX1_C_DN: length 86.2
  TOP w0.124: C411.2 152.75,95.99 149.02,95.99 143.84,94.96 140.67,95.59 137.49,94.96 134.32,95.59 131.14,94.96 127.28,95.73 126.29,95.53 124.38,95.53 124.2,95.71 123.83,95.71 123.65,95.53 123.28,95.53 123.1,95.71 122.73,95.71 122.55,95.53 122.18,95.53 121.06,95.99 120.96,96.23 120.62,96.37 120.38,96.27 120.04,96.42 119.96,96.62 119.64,96.75 119.44,96.66 118.74,96.95 118.66,97.03 118.66,97.24 118.73,97.4 v2(119.02,97.69)
  IN1 w0.136: v2(119.02,97.69) 119.02,97.73 118.67,98.08 118.67,98.74 116.95,100.46 116.95,102.39 117.35,103.37 117.35,105.17 117.07,106.59 116.4,108.21 116.19,108.42 115.79,109.37 115.79,110.33 116.19,111.3 116.19,112.51 115.9,112.81 115.7,112.81 115.56,112.95 115.56,113.58 115.7,113.71 115.9,113.71 116.19,114.01 116.19,114.87 115.9,115.17 115.7,115.17 115.56,115.3 115.56,115.93 115.7,116.07 115.9,116.07 116.19,116.37 116.19,117.22 115.9,117.52 115.7,117.52 115.56,117.66 115.56,118.29 115.7,118.42 115.9,118.42 116.19,118.72 116.19,120.52 116.13,120.69 116.06,120.86 114.95,121.97 114.95,123.87 114.42,125.15 113.12,126.45 112.36,128.29 112.36,129.42 111.71,130.98 110.04,132.65 110.04,136.72 110.29,137.33 110.87,137.91 111.06,138.37 111.06,138.58 v2(111.43,138.95)
  BOTTOM w0.124: J34.B35 111.17,140.05 111.07,139.95 111.07,139.31 v2(111.43,138.95)
P3E_PESW_M2I_TX1_C_DP: length 86.2
  TOP w0.124: C412.2 152.75,95.69 149.05,95.69 143.84,94.65 140.67,95.28 137.49,94.65 134.32,95.28 131.14,94.65 127.28,95.42 126.32,95.23 122.12,95.23 118.57,96.7 118.36,96.91 118.36,97.34 v2(118,97.69)
  IN1 w0.136: v2(118,97.69) 118.39,98.08 118.39,98.62 116.67,100.34 116.67,102.45 117.07,103.42 117.07,105.14 116.8,106.5 116.16,108.05 115.95,108.26 115.52,109.31 115.52,110.39 115.92,111.36 115.92,112.4 115.78,112.53 115.58,112.53 115.28,112.83 115.28,113.69 115.58,113.99 115.78,113.99 115.92,114.13 115.92,114.75 115.78,114.89 115.58,114.89 115.28,115.19 115.28,116.05 115.58,116.35 115.78,116.35 115.92,116.48 115.92,117.11 115.78,117.24 115.58,117.24 115.28,117.54 115.28,118.4 115.58,118.7 115.78,118.7 115.92,118.84 115.92,120.47 115.82,120.7 114.67,121.85 114.67,123.81 114.18,124.99 112.88,126.29 112.08,128.23 112.08,129.37 111.48,130.82 109.76,132.53 109.76,136.78 110.05,137.49 110.63,138.07 110.78,138.42 110.78,138.58 v2(110.41,138.95)
  BOTTOM w0.124: v2(110.41,138.95) 110.77,139.31 110.77,139.94 110.67,140.04 J34.B37
P3E_PESW_M2I_TX1_DN: length 12.9
  TOP w0.099: 161.97,95.99 161.99,95.99 162.05,95.94 162.34,95.94 162.52,95.87 162.66,95.92 162.84,95.85 162.9,95.71 163.08,95.64 163.21,95.69 163.39,95.62 163.45,95.48 164.33,95.12 165.39,95.12 165.49,95.22 165.49,95.42 165.39,95.52 U34.D1
  TOP w0.124: C411.1 154.27,95.99 157.88,95.99 157.97,96.08 158.34,96.08 158.43,95.99 158.8,95.99 158.89,96.08 159.27,96.08 159.36,95.99 161.97,95.99
P3E_PESW_M2I_TX1_DP: length 12.9
  TOP w0.099: 161.97,95.69 161.99,95.69 162.05,95.74 162.3,95.74 164.28,94.92 165.47,94.92 165.69,95.14 165.69,95.42 165.79,95.52 U34.D2
  TOP w0.124: C412.1 154.27,95.69 161.97,95.69
P3E_PESW_M2I_TX2_C_DN: length 79.7
  TOP w0.124: v2(119.25,100.63) 118.91,100.29 118.91,99.91 119.89,98.92 124.98,96.82 126.63,96.82 127.33,96.95 131.14,96.19 134.32,96.83 137.49,96.19 140.67,96.83 143.84,96.19 144.82,96.39 144.93,96.56 145.3,96.63 145.47,96.52 145.84,96.59 145.95,96.76 146.32,96.84 146.49,96.72 146.86,96.79 146.98,96.97 147.34,97.04 147.52,96.93 147.88,97 148,97.17 148.36,97.25 148.54,97.13 149.67,97.36 150.92,97.36 C409.2
  IN1 w0.136: v2(114.43,138.95) 114.06,138.58 114.06,138.26 113.68,137.69 111.63,136.85 111.29,136.51 111.16,136.19 111.16,135.71 111.81,132.42 112.86,131.38 113.31,130.28 113.31,128.59 113.71,127.64 115.37,125.97 117.56,120.7 117.56,111.86 116.73,109.87 116.73,109.64 117.02,108.94 117.22,108.65 118.01,106.75 118.64,103.56 118.89,100.99 v2(119.25,100.63)
  BOTTOM w0.124: J34.B23 114.17,140.07 114.07,139.97 114.07,139.31 v2(114.43,138.95)
P3E_PESW_M2I_TX2_C_DP: length 79.8
  TOP w0.124: C410.2 150.92,97.05 149.7,97.05 143.84,95.88 140.67,96.51 137.49,95.88 134.32,96.51 131.14,95.88 127.33,96.64 126.66,96.51 124.92,96.51 119.72,98.67 118.6,99.78 118.6,100.27 v2(118.23,100.63)
  IN1 w0.136: v2(113.41,138.95) 113.78,138.58 113.78,138.35 113.78,138.35 113.49,137.92 111.47,137.08 111.05,136.67 110.88,136.25 110.88,135.68 110.89,135.66 111.56,132.28 112.62,131.22 113.04,130.22 113.04,128.53 113.47,127.48 115.14,125.82 117.28,120.65 117.28,111.92 116.89,110.97 116.45,109.93 116.45,109.58 116.77,108.81 116.97,108.52 117.74,106.67 118.36,103.52 118.61,101.01 v2(118.23,100.63)
  BOTTOM w0.124: v2(113.41,138.95) 113.77,139.31 113.77,139.94 113.67,140.03 J34.B25
P3E_PESW_M2I_TX2_DN: length 15.9
  TOP w0.099: 161.92,97.36 161.94,97.36 161.99,97.31 162.24,97.31 162.68,97.04 162.82,97.07 162.99,96.97 163.03,96.83 163.2,96.73 163.34,96.77 163.51,96.67 163.55,96.53 163.72,96.43 163.85,96.46 164.03,96.36 164.06,96.22 164.23,96.12 166.44,96.12 166.54,96.22 166.54,96.42 166.44,96.52 U34.C2
  TOP w0.124: C409.1 152.43,97.36 161.92,97.36
P3E_PESW_M2I_TX2_DP: length 15.9
  TOP w0.099: U34.C3 166.85,96.52 166.74,96.41 166.74,96.14 166.52,95.92 164.17,95.92 164.04,96 164.04,96 162.18,97.1 161.99,97.1 161.94,97.05 161.92,97.05
  TOP w0.124: 161.92,97.05 152.43,97.05 C410.1
P3E_PESW_M2I_TX3_C_DN: length 81.3
  TOP w0.124: C439.2 152.75,98.7 149.32,98.7 143.37,97.51 140.67,98.05 137.53,97.42 134.36,98.05 131.16,97.41 127.26,98.19 126.46,98.03 125.28,98.03 122.47,99.19 122.38,99.42 122.03,99.57 121.8,99.47 121.45,99.61 120.94,100.13 120.83,100.38 120.89,100.51 120.74,100.88 120.6,100.93 120.39,101.45 120.39,102.11 120.59,102.31 v2(120.85,102.31)
  IN1 w0.136: v2(117.43,138.95) 117.06,138.58 117.06,138.17 116.71,137.65 114.9,136.9 114.23,136.35 113.77,134.04 113.82,133.81 114.15,133.01 114.33,132.94 115.27,133.33 115.66,133.17 115.9,132.59 115.74,132.2 114.8,131.8 114.72,131.63 115.58,129.55 116.15,128.99 117.61,125.46 118.26,124.81 118.54,124.12 118.54,111.79 118.29,111.19 118.29,109.44 118.45,109.06 119.42,108.09 119.65,107.65 119.83,106.93 119.83,106.3 119.51,105.53 119.51,104.99 119.99,103.83 120.35,103.47 120.47,103.2 120.47,102.69 v2(120.85,102.31)
  BOTTOM w0.124: v2(117.43,138.95) 117.07,139.31 117.07,139.99 117.17,140.09 J34.B11
P3E_PESW_M2I_TX3_C_DP: length 81.3
  TOP w0.124: C440.2 152.75,98.39 149.35,98.39 143.37,97.2 140.67,97.74 137.53,97.11 134.36,97.74 131.16,97.1 127.26,97.88 126.49,97.72 125.22,97.72 121.68,99.19 121.24,99.4 120.68,99.96 120.09,101.39 120.09,102.06 v2(119.83,102.31)
  IN1 w0.136: v2(116.41,138.95) 116.78,138.58 116.78,138.25 116.53,137.87 114.75,137.14 113.98,136.51 113.49,134.04 113.55,133.72 113.93,132.8 114.33,132.64 115.27,133.03 115.45,132.95 115.6,132.59 115.53,132.41 114.58,132.02 114.42,131.63 115.34,129.4 115.91,128.83 117.37,125.3 118.02,124.65 118.26,124.07 118.26,111.85 118.01,111.24 118.01,109.38 118.21,108.9 119.19,107.92 119.39,107.55 119.55,106.89 119.55,106.36 119.23,105.59 119.23,104.93 119.76,103.67 120.12,103.31 120.19,103.14 120.19,102.66 v2(119.83,102.31)
  BOTTOM w0.124: J34.B13 116.67,140.08 116.77,139.98 116.77,139.31 v2(116.41,138.95)
P3E_PESW_M2I_TX3_DN: length 13.2
  TOP w0.099: U34.B1 165.39,97.52 165.49,97.42 165.49,97.22 165.38,97.11 164.9,97.11 164.66,97.26 164.62,97.4 164.45,97.5 164.31,97.46 164.14,97.56 164.1,97.7 163.93,97.8 163.79,97.77 163.62,97.87 163.59,98.01 163.42,98.11 163.28,98.07 163.11,98.18 163.07,98.31 162.9,98.42 162.76,98.38 162.32,98.65 162.04,98.65 161.99,98.7 161.96,98.7
  TOP w0.124: 161.96,98.7 154.27,98.7 C439.1
P3E_PESW_M2I_TX3_DP: length 13.2
  TOP w0.099: 161.96,98.39 161.99,98.39 162.04,98.44 162.26,98.44 164.84,96.91 165.46,96.91 165.69,97.14 165.69,97.42 165.79,97.52 U34.B2
  TOP w0.124: 161.96,98.39 154.27,98.39 C440.1
P3E_PESW_M2J_RX0_DN: length 120.4
  TOP w0.124: U34.J5 v6(168.59,91.02)
  IN2 w0.099: v6(168.59,91.02) 168.9,91.02 169,90.92 169,90.72 168.9,90.62 165.29,90.62 165.25,90.66 165.23,90.66
  IN2 w0.136: v2(85.92,137.73) 85.55,137.36 85.55,137.01 86.28,135.26 87.19,134.35 90.34,133.04 99.06,133.04 99.23,133.12 101.29,133.12 101.83,132.58 101.83,129.62 103.03,128.42 103.24,127.91 103.24,121.13 102.18,118.57 101.82,116.75 101.82,112.42 102.76,109.3 103.24,108.58 103.54,108.25 105.4,104.31 107.77,102.73 115.03,99.72 116.82,99.37 117.18,99.27 117.7,99.03 118.2,98.91 118.31,98.92 119.5,98.62 120.81,98.08 121.42,97.67 124.21,96.52 124.21,96.52 127,95.36 143.87,92 149.5,91.44 149.65,91.56 150.05,91.52 150.17,91.37 150.58,91.33 150.72,91.45 151.13,91.41 151.25,91.27 151.65,91.23 151.8,91.35 152.2,91.31 152.32,91.16 152.73,91.12 152.87,91.24 153.28,91.2 153.39,91.06 153.8,91.02 153.94,91.13 154.35,91.09 154.47,90.95 154.87,90.91 155.02,91.03 155.42,90.99 155.54,90.84 155.95,90.8 156.09,90.92 156.5,90.88 156.62,90.74 157.41,90.66 165.23,90.66
  BOTTOM w0.124: v2(85.92,137.73) 85.57,138.08 85.57,139.85 85.67,139.95 J34.A41
P3E_PESW_M2J_RX0_DP: length 120.4
  TOP w0.124: U34.J6 v6(169.59,91.02)
  IN2 w0.099: 165.23,90.38 165.25,90.38 165.29,90.42 168.98,90.42 169.2,90.64 169.2,90.92 169.3,91.02 v6(169.59,91.02)
  IN2 w0.136: 165.23,90.38 157.39,90.38 143.83,91.72 126.92,95.09 121.29,97.43 120.68,97.83 119.41,98.36 118.3,98.64 118.19,98.62 117.6,98.77 117.09,99.01 116.76,99.09 114.95,99.45 107.64,102.48 105.18,104.12 103.31,108.09 103.02,108.41 102.5,109.18 101.54,112.38 101.54,116.78 101.91,118.65 102.96,121.18 102.96,127.86 102.79,128.26 101.55,129.5 101.55,132.46 101.17,132.84 99.29,132.84 99.11,132.76 90.29,132.76 87.03,134.11 86.04,135.1 85.3,136.9 85.28,136.92 85.28,137.36 v2(84.91,137.73)
  BOTTOM w0.124: v2(84.91,137.73) 85.27,138.09 85.27,139.86 85.17,139.95 J34.A43
P3E_PESW_M2J_RX1_DN: length 119.7
  TOP w0.124: U34.H4 v6(167.59,92.02)
  IN2 w0.099: v6(167.59,92.02) 167.9,92.02 168,91.92 168,91.72 167.9,91.62 165.44,91.62 165.4,91.66 165.38,91.66
  IN2 w0.136: 165.38,91.66 158.03,91.66 156.2,91.84 156.08,91.98 155.68,92.02 155.53,91.91 155.13,91.95 155.01,92.09 154.6,92.13 154.46,92.01 154.05,92.05 153.94,92.2 153.53,92.24 153.39,92.12 152.98,92.16 152.86,92.3 152.46,92.34 152.31,92.22 151.91,92.26 151.79,92.41 151.38,92.45 151.24,92.33 150.83,92.37 150.71,92.52 150.31,92.56 150.16,92.44 149.76,92.48 149.64,92.62 149.23,92.66 149.09,92.54 143.16,93.13 137.04,94.35 127.5,96.25 122.33,98.39 121.82,98.74 119.78,99.58 118.01,99.93 115.71,100.88 114.45,102.14 114.21,102.24 110.91,102.9 109.77,102.9 108.61,103.38 107.43,104.56 107.43,105.74 106.19,108.73 106.19,108.98 104.95,110.22 104.08,110.8 103.09,113.19 103.09,118.18 104.24,120.94 104.24,127.74 104.37,127.88 105.45,127.88 106.21,128.63 106.21,129.96 104.8,131.37 104.8,132.55 103.3,134.05 98.6,134.05 98.52,133.97 90.76,133.97 89.2,135.01 88.56,136.57 88.56,137.05 v2(88.92,137.42)
  BOTTOM w0.124: v2(88.92,137.42) 88.57,137.77 88.57,139.85 88.67,139.94 J34.A29
P3E_PESW_M2J_RX1_DP: length 119.7
  TOP w0.124: U34.H5 v6(168.59,92.02)
  IN2 w0.099: v6(168.59,92.02) 168.3,92.02 168.2,91.92 168.2,91.64 167.98,91.42 165.44,91.42 165.4,91.38 165.38,91.38
  IN2 w0.136: v2(87.91,137.42) 88.28,137.05 88.28,136.48 88.3,136.46 88.97,134.83 90.67,133.69 98.64,133.69 98.71,133.77 103.19,133.77 104.52,132.44 104.52,131.25 105.93,129.85 105.93,128.75 105.34,128.16 104.26,128.16 103.96,127.86 103.96,121 102.81,118.23 102.81,113.14 103.86,110.62 104.77,110 105.91,108.86 105.91,108.68 107.15,105.69 107.15,104.45 108.46,103.14 109.72,102.62 110.88,102.62 114.13,101.97 114.29,101.91 115.55,100.65 117.93,99.66 119.7,99.31 121.69,98.49 122.2,98.15 127.42,95.98 143.12,92.85 158.01,91.38 165.38,91.38
  BOTTOM w0.124: v2(87.91,137.42) 88.27,137.78 88.27,139.85 88.17,139.94 J34.A31
P3E_PESW_M2J_RX2_DN: length 117.9
  TOP w0.124: U34.G5 v6(168.59,93.02)
  IN2 w0.099: v6(168.59,93.02) 168.9,93.02 169,92.92 169,92.72 168.9,92.62 165.46,92.62 165.42,92.66 165.4,92.66
  IN2 w0.136: v2(91.93,137.76) 91.56,137.39 91.56,136.35 91.79,136 92.37,135.76 93.63,135.76 94.5,136.13 95.62,137.25 96.67,137.68 102.27,137.68 103.39,136.56 103.39,135.35 105.84,132.9 105.84,131.76 107.18,130.41 107.18,128.15 105.18,126.15 105.18,120.66 104.09,118.03 104.09,113.33 104.81,111.6 105.65,111.25 108.49,108.41 109.3,106.45 109.63,106.12 110.28,105.68 111.26,105.28 111.86,104.68 112.55,104.4 116.5,104.4 119.13,101.77 119.32,101.66 119.78,101.57 121.95,100.13 122.19,99.76 123.41,98.95 127.64,97.19 142.36,94.27 149.19,93.59 149.34,93.71 149.74,93.67 149.86,93.53 150.27,93.49 150.41,93.61 150.82,93.57 150.94,93.42 151.34,93.38 151.49,93.5 151.89,93.46 152.01,93.32 152.42,93.28 152.56,93.39 152.97,93.35 153.09,93.21 153.49,93.17 153.64,93.29 154.04,93.25 154.16,93.1 154.57,93.06 154.71,93.18 155.12,93.14 155.23,93 155.64,92.96 155.78,93.08 156.19,93.04 156.31,92.89 158.67,92.66 165.4,92.66
  BOTTOM w0.124: J34.A17 91.67,139.95 91.57,139.85 91.57,138.11 v2(91.93,137.76)
P3E_PESW_M2J_RX2_DP: length 117.9
  TOP w0.124: U34.G6 v6(169.59,93.02)
  IN2 w0.099: 165.4,92.38 165.42,92.38 165.46,92.42 168.98,92.42 169.2,92.64 169.2,92.92 169.3,93.02 v6(169.59,93.02)
  IN2 w0.136: v2(90.91,137.76) 91.28,137.39 91.28,136.27 91.61,135.78 92.31,135.48 93.68,135.48 94.66,135.89 95.78,137.01 96.73,137.4 102.15,137.4 103.11,136.44 103.11,135.23 105.56,132.79 105.56,131.64 106.9,130.3 106.9,128.26 104.9,126.26 104.9,120.71 103.81,118.09 103.81,113.27 104.59,111.39 105.49,111.01 108.26,108.25 109.07,106.29 109.46,105.9 110.15,105.44 111.11,105.04 111.7,104.44 112.49,104.12 116.38,104.12 118.96,101.54 119.19,101.42 119.23,101.4 119.68,101.31 121.75,99.93 121.99,99.56 123.27,98.7 127.56,96.93 142.32,93.99 145.75,93.65 158.66,92.38 165.4,92.38
  BOTTOM w0.124: J34.A19 91.17,139.94 91.27,139.85 91.27,138.11 v2(90.91,137.76)
P3E_PESW_M2J_RX3_DN: length 116.9
  TOP w0.124: U34.F4 v6(167.59,94.02)
  IN2 w0.099: v6(167.59,94.02) 167.9,94.02 168,93.92 168,93.72 167.9,93.62 165.57,93.62 165.53,93.66 165.51,93.66
  IN2 w0.136: v2(94.93,138.95) 94.57,138.58 94.57,138.4 94.76,138.21 95.16,138.21 96.2,138.64 98.87,138.64 99.01,138.78 99.01,140.93 99.31,141.23 100.17,141.23 100.47,140.93 100.47,138.78 100.6,138.64 103.37,138.64 105.7,136.31 105.7,135.48 106.06,134.61 108.62,132.05 108.62,131.26 108.16,130.14 108.16,126.7 107.86,126.4 107.27,126.4 107.14,126.26 107.14,125.64 107.27,125.5 107.86,125.5 108.16,125.2 108.16,124.62 110.44,119.1 111.96,118.09 113.34,118.09 113.95,118.7 114.38,118.7 114.99,118.1 114.99,117.67 113.8,116.49 113.8,116.3 114.03,116.07 114.26,114.92 115.21,112.27 115.03,111.88 114.42,111.67 114.33,111.49 114.55,110.9 114.72,110.82 115.33,111.04 115.71,110.86 116.37,109.02 117.4,107.09 118.72,103.92 119.19,103.45 119.48,103.33 121.05,103.33 121.44,103.17 122.23,102.37 123.4,100.18 124.2,99.65 127.87,98.13 141.56,95.41 149.1,94.66 149.25,94.78 149.66,94.74 149.77,94.6 150.18,94.56 150.32,94.68 150.73,94.64 150.85,94.49 151.25,94.45 151.4,94.57 151.8,94.53 151.92,94.39 152.53,94.33 152.68,94.44 153.08,94.4 153.2,94.26 153.69,94.21 153.84,94.33 154.24,94.29 154.36,94.15 154.86,94.1 155,94.22 155.41,94.18 155.53,94.03 155.93,93.99 156.08,94.11 156.48,94.07 156.6,93.93 159.3,93.66 165.51,93.66
  BOTTOM w0.124: v2(94.93,138.95) 94.57,139.31 94.57,139.85 94.67,139.95 J34.A5
P3E_PESW_M2J_RX3_DP: length 116.9
  TOP w0.124: U34.F5 v6(168.59,94.02)
  IN2 w0.099: 165.51,93.38 165.53,93.38 165.57,93.42 167.98,93.42 168.2,93.64 168.2,93.92 168.3,94.02 v6(168.59,94.02)
  IN2 w0.136: 165.51,93.38 159.28,93.38 141.52,95.13 127.79,97.86 124.07,99.4 123.19,99.99 122.01,102.2 121.28,102.93 121,103.05 119.43,103.05 119.03,103.21 118.48,103.76 117.15,106.97 116.11,108.91 115.49,110.65 115.32,110.74 114.7,110.52 114.32,110.7 114.03,111.51 114.21,111.89 114.82,112.11 114.91,112.28 113.99,114.84 113.77,115.93 113.52,116.18 113.52,116.61 114.71,117.79 114.71,117.98 114.26,118.42 114.07,118.42 113.45,117.81 111.88,117.81 110.22,118.91 107.88,124.56 107.88,125.08 107.74,125.22 107.16,125.22 106.86,125.52 106.86,126.38 107.16,126.68 107.74,126.68 107.88,126.81 107.88,130.2 108.34,131.32 108.34,131.94 105.83,134.45 105.42,135.42 105.42,136.19 103.26,138.36 100.49,138.36 100.19,138.66 100.19,140.82 100.05,140.95 99.42,140.95 99.29,140.82 99.29,138.66 98.99,138.36 96.25,138.36 95.22,137.93 94.64,137.93 94.29,138.29 94.29,138.58 v2(93.92,138.95)
  BOTTOM w0.124: v2(93.92,138.95) 94.27,139.3 94.27,139.85 94.17,139.94 J34.A7
P3E_PESW_M2J_TX0_C_DN: length 110.6
  TOP w0.124: v2(87.99,103.96) 87.88,103.96 87.57,103.65 87.57,103.04 87.83,102.41 88.21,102.03 88.42,102.03 88.69,101.77 88.69,101.56 89.11,101.13 89.65,100.91 89.85,100.99 90.19,100.85 90.27,100.65 90.62,100.51 90.81,100.59 91.16,100.45 91.24,100.25 92.18,99.86 96.16,99.86 97.99,99.5 101.14,100.13 105.22,99.31 107.26,99.31 108.11,98.46 108.11,96.88 112.95,92.05 117.47,89.95 122.97,88.56 126.28,89.22 130.98,88.28 134.13,88.91 137.02,88.34 140.31,88.99 144.08,88.24 148.27,89.08 150.25,89.08 150.65,89.25 150.92,89.25 C421.2
  IN1 w0.136: v2(84.43,138.95) 84.06,138.58 84.06,137.03 84.56,135.81 84.56,134.6 83.31,131.58 83.31,129.26 84.03,127.52 84.03,123.23 84.09,122.94 84.09,116.7 85.61,113.03 85.61,111.98 86.54,109.73 86.54,106.92 86.71,106.51 87.49,105.73 87.7,105.22 87.7,104.78 87.64,104.62 87.62,104.53 87.62,104.33 v2(87.99,103.96)
  BOTTOM w0.124: J34.A47 84.17,139.95 84.07,139.85 84.07,139.31 v2(84.43,138.95)
P3E_PESW_M2J_TX0_C_DP: length 110.6
  TOP w0.124: v2(86.97,103.96) 87.27,103.67 87.27,102.98 87.57,102.24 88.94,100.87 92.12,99.56 96.13,99.56 97.99,99.18 101.14,99.82 105.19,99.01 107.13,99.01 107.81,98.33 107.81,96.75 112.77,91.79 117.36,89.67 117.39,89.66 122.96,88.25 126.28,88.91 130.98,87.97 134.13,88.6 137.02,88.02 140.31,88.68 144.08,87.93 148.3,88.77 150.31,88.77 150.72,88.94 150.92,88.94 C422.2
  IN1 w0.136: v2(86.97,103.96) 87.34,104.33 87.34,104.56 87.37,104.7 87.42,104.83 87.42,105.16 87.25,105.58 86.47,106.35 86.26,106.86 86.26,109.67 85.33,111.92 85.33,112.97 83.81,116.64 83.81,122.92 83.75,123.2 83.75,127.47 83.04,129.2 83.04,131.64 84.29,134.66 84.29,135.75 83.78,136.97 83.78,138.58 v2(83.41,138.95)
  BOTTOM w0.124: v2(83.41,138.95) 83.77,139.31 83.77,139.86 83.67,139.95 J34.A49
P3E_PESW_M2J_TX0_DN: length 15.8
  TOP w0.099: 162.05,89.25 162.07,89.25 162.12,89.2 162.57,89.2 162.75,89.27 162.81,89.4 162.99,89.48 163.12,89.43 163.3,89.5 163.36,89.63 163.54,89.71 163.68,89.66 163.86,89.73 163.91,89.86 164.1,89.94 164.23,89.89 164.8,90.12 165,90.12 165.1,90.22 165.3,90.22 165.4,90.12 166.39,90.12 166.49,90.22 166.49,90.42 166.39,90.52 U34.J2
  TOP w0.124: 162.05,89.25 152.43,89.25 C421.1
P3E_PESW_M2J_TX0_DP: length 15.8
  TOP w0.099: U34.J3 166.79,90.52 166.69,90.42 166.69,90.14 166.47,89.92 164.84,89.92 162.61,88.99 162.12,88.99 162.07,88.94 162.05,88.94
  TOP w0.124: C422.1 152.43,88.94 162.05,88.94
P3E_PESW_M2J_TX1_C_DN: length 112.6
  TOP w0.124: v2(88.39,106.88) 88.04,106.53 88.04,106.25 88.2,105.86 88.53,105.52 89.08,104.2 89.08,103.3 89.18,103.05 89.79,102.44 90.76,102.04 90.76,102.04 91.1,101.9 91.29,101.98 91.64,101.83 91.72,101.64 92.06,101.5 92.26,101.58 92.6,101.43 92.68,101.24 93.13,101.06 93.5,101.06 93.65,101.2 94.02,101.2 94.17,101.06 96.64,101.06 97.99,100.79 101.16,101.42 105.38,100.58 107.74,100.58 109.33,98.98 109.33,97.52 113,93.85 117.82,91.11 122.7,89.88 126.54,90.65 131.14,89.73 134.32,90.37 137.49,89.73 140.67,90.37 143.84,89.73 147.36,90.43 148.73,90.43 148.89,90.6 149.27,90.6 149.43,90.43 150.19,90.43 150.56,90.59 152.75,90.59 C419.2
  IN1 w0.136: v2(88.39,106.88) 88.02,107.25 88.02,108.58 86.68,111.84 86.68,117.6 86.41,118.25 85.46,119.2 85.25,119.69 85.25,121.85 84.96,123.3 84.96,128.67 85.24,129.35 85.24,132.36 85.55,133.11 85.72,133.17 86.68,132.78 87.06,132.93 87.39,133.73 87.23,134.11 86.27,134.51 86.2,134.68 86.64,135.73 87.06,137.85 87.06,138.58 v2(87.43,138.95)
  BOTTOM w0.124: v2(87.43,138.95) 87.07,139.31 87.07,139.85 87.17,139.95 J34.A35
P3E_PESW_M2J_TX1_C_DP: length 112.5
  TOP w0.124: v2(87.38,106.88) 87.73,106.53 87.73,106.19 87.94,105.68 88.28,105.35 88.78,104.14 88.78,103.24 88.92,102.88 89.62,102.18 93.07,100.75 96.6,100.75 97.99,100.48 101.16,101.11 105.35,100.27 107.61,100.27 109.03,98.86 109.03,97.39 112.81,93.61 117.71,90.83 122.7,89.57 126.54,90.34 131.14,89.42 134.32,90.06 137.49,89.42 140.67,90.06 143.84,89.42 147.39,90.13 150.25,90.13 150.62,90.28 152.75,90.28 C420.2
  IN1 w0.136: v2(86.41,138.95) 86.78,138.58 86.78,137.88 86.37,135.81 85.9,134.68 86.06,134.3 87.02,133.9 87.09,133.73 86.85,133.15 86.68,133.08 85.72,133.48 85.34,133.32 84.97,132.42 84.97,129.4 84.69,128.73 84.69,123.27 84.97,121.82 84.97,119.64 85.22,119.04 86.17,118.09 86.4,117.55 86.4,111.78 87.74,108.53 87.74,107.25 v2(87.38,106.88)
  BOTTOM w0.124: v2(86.41,138.95) 86.77,139.31 86.77,139.86 86.67,139.95 J34.A37
P3E_PESW_M2J_TX1_DN: length 12.9
  TOP w0.099: 162.18,90.59 162.21,90.59 162.26,90.54 162.5,90.54 162.8,90.66 162.86,90.8 163.04,90.87 163.17,90.82 163.36,90.89 163.41,91.02 163.59,91.1 163.73,91.05 163.91,91.12 164.48,91.12 164.58,91.22 164.78,91.22 164.88,91.12 165.39,91.12 165.49,91.22 165.49,91.42 165.39,91.52 U34.H1
  TOP w0.124: 162.18,90.59 159.54,90.59 159.46,90.66 159.09,90.66 159.01,90.59 154.27,90.59 C419.1
P3E_PESW_M2J_TX1_DP: length 12.9
  TOP w0.099: U34.H2 165.79,91.52 165.69,91.42 165.69,91.14 165.47,90.92 163.95,90.92 162.54,90.33 162.26,90.33 162.21,90.28 162.18,90.28
  TOP w0.124: C420.1 154.27,90.28 162.18,90.28
P3E_PESW_M2J_TX2_C_DN: length 103.9
  TOP w0.124: v2(93.62,106.27) 93.45,106.27 93.13,105.95 93.13,105.58 93.31,105.4 93.31,105.03 93.13,104.85 93.13,104.02 93.47,103.21 93.82,103.07 94.05,103.16 94.39,103.02 94.49,102.79 95.71,102.28 96.81,102.28 98.04,102.03 101.17,102.66 103.31,102.23 103.58,102.21 107.8,102.21 110.54,99.47 110.54,98.02 113.68,94.88 118.2,92.3 122.79,91.12 126.96,91.96 131.14,91.12 134.32,91.76 137.49,91.12 140.67,91.76 143.84,91.12 147.99,91.95 150.92,91.95 C417.2
  IN1 w0.136: v2(90.43,138.95) 90.06,138.58 90.06,137.85 89.81,136.6 88.48,133.39 88.48,127.6 89.04,126.24 90.92,124.37 92.37,120.86 92.37,109.55 93.26,107.4 93.26,106.63 v2(93.62,106.27)
  BOTTOM w0.124: J34.A23 90.17,139.95 90.07,139.85 90.07,139.31 v2(90.43,138.95)
P3E_PESW_M2J_TX2_C_DP: length 103.8
  TOP w0.124: C418.2 150.92,91.65 148.02,91.65 143.84,90.81 140.67,91.44 137.49,90.81 134.32,91.44 131.14,90.81 126.96,91.65 122.79,90.81 118.09,92.02 113.49,94.64 110.24,97.89 110.24,99.34 107.67,101.91 103.56,101.91 103.26,101.93 101.17,102.35 98.04,101.72 96.78,101.98 95.65,101.98 93.7,102.78 93.24,102.98 92.83,103.96 92.83,106.05 v2(92.61,106.27)
  IN1 w0.136: v2(89.41,138.95) 89.78,138.58 89.78,137.88 89.54,136.68 88.2,133.45 88.2,127.54 88.81,126.08 90.68,124.21 92.09,120.8 92.09,109.5 92.98,107.35 92.98,106.64 v2(92.61,106.27)
  BOTTOM w0.124: v2(89.41,138.95) 89.77,139.31 89.77,139.85 89.67,139.95 J34.A25
P3E_PESW_M2J_TX2_DN: length 15.6
  TOP w0.099: U34.G2 166.39,92.52 166.49,92.42 166.49,92.22 166.39,92.12 165.62,92.12 165.52,92.22 165.32,92.22 165.22,92.12 165.02,92.12 164.92,92.22 164.72,92.22 164.62,92.12 164.42,92.12 164.32,92.22 164.12,92.22 164.02,92.12 162.96,92.12 162.43,91.9 162.15,91.9 162.1,91.95 162.08,91.95
  TOP w0.124: 162.08,91.95 159.23,91.95 159.15,92.03 158.77,92.03 158.69,91.95 152.43,91.95 C417.1
P3E_PESW_M2J_TX2_DP: length 15.6
  TOP w0.099: 162.08,91.65 162.1,91.65 162.15,91.7 162.47,91.7 163,91.92 166.47,91.92 166.69,92.14 166.69,92.42 166.79,92.52 U34.G3
  TOP w0.124: 162.08,91.65 152.43,91.65 C418.1
P3E_PESW_M2J_TX3_C_DN: length 105.5
  TOP w0.124: C415.2 152.75,93.29 147.86,93.29 143.84,92.49 140.67,93.12 137.49,92.49 134.32,93.12 131.14,92.49 127.31,93.25 125.88,92.97 125.7,93.09 125.33,93.02 125.21,92.84 124.84,92.76 124.67,92.88 124.3,92.81 124.18,92.63 123.05,92.4 118.91,93.37 114.44,95.85 111.82,98.47 111.82,99.88 108.27,103.43 103.57,103.43 101.18,103.91 98.26,103.32 97.61,103.45 97.5,103.63 97.16,103.69 96.98,103.58 96.53,103.67 96.08,103.67 95.85,103.76 95.77,103.96 95.49,104.07 95.29,103.99 94.84,104.18 94.72,104.36 94.72,104.55 v2(95.07,104.9)
  IN1 w0.136: v2(95.07,104.9) 94.7,105.27 94.7,106.61 94.35,107.47 93.64,111.03 93.64,120.28 91.69,124.98 89.84,126.83 89.41,127.88 89.41,133.15 90.16,134.98 90.59,135.26 92.2,135.26 92.78,135.5 93.06,135.92 93.06,136.2 v2(93.43,136.56)
  BOTTOM w0.124: v2(93.43,136.56) 93.07,136.92 93.07,139.85 93.17,139.95 J34.A11
P3E_PESW_M2J_TX3_C_DP: length 105.5
  TOP w0.124: C416.2 152.75,92.99 147.89,92.99 143.84,92.18 140.67,92.81 137.49,92.18 134.32,92.81 131.14,92.18 127.31,92.94 123.05,92.09 118.8,93.08 114.26,95.6 111.52,98.34 111.52,99.75 108.14,103.12 103.54,103.12 101.18,103.6 98.26,103.01 96.5,103.36 96.02,103.36 94.63,103.93 94.41,104.27 94.41,104.55 v2(94.06,104.9)
  IN1 w0.136: v2(94.06,104.9) 94.42,105.27 94.42,106.56 94.08,107.39 93.36,111 93.36,120.22 91.45,124.83 89.6,126.67 89.13,127.82 89.13,133.2 89.94,135.16 90.51,135.54 92.14,135.54 92.6,135.73 92.78,136 92.78,136.2 v2(92.41,136.56)
  BOTTOM w0.124: v2(92.41,136.56) 92.77,136.92 92.77,139.85 92.67,139.95 J34.A13
P3E_PESW_M2J_TX3_DN: length 12.7
  TOP w0.099: U34.F1 165.39,93.52 165.49,93.42 165.49,93.22 165.39,93.12 164.72,93.12 164.62,93.22 164.42,93.22 164.32,93.12 164.12,93.12 164.02,93.22 163.82,93.22 163.72,93.12 163.44,93.12 162.62,93.24 162.09,93.24 162.04,93.29 162.01,93.29
  TOP w0.124: 162.01,93.29 161.05,93.29 160.88,93.46 160.51,93.46 160.34,93.29 154.27,93.29 C415.1
P3E_PESW_M2J_TX3_DP: length 12.8
  TOP w0.099: 162.01,92.99 162.04,92.99 162.09,93.04 162.61,93.04 163.43,92.92 165.48,92.92 165.69,93.14 165.69,93.42 165.79,93.52 U34.F2
  TOP w0.124: C416.1 154.27,92.99 162.01,92.99
P3E_PESW_M2K_RX0_DN: length 220.2
  TOP w0.124: U34.AM4 v6(167.59,67.02)
  IN2 w0.099: v6(167.59,67.02) 167.9,67.02 168,66.92 168,66.72 167.9,66.62 165.72,66.62 165.68,66.66 165.66,66.66
  IN2 w0.136: 165.66,66.66 163.43,66.66 160.4,67.26 160.3,67.42 159.9,67.5 159.74,67.39 159.35,67.47 159.24,67.63 158.84,67.71 158.69,67.6 158.29,67.68 158.18,67.84 157.78,67.92 157.63,67.81 157.23,67.89 157.12,68.05 156.72,68.13 156.57,68.03 156.17,68.11 156.06,68.26 155.66,68.34 155.51,68.24 155.11,68.32 155.01,68.47 154.61,68.55 154.45,68.45 154.05,68.53 153.95,68.68 153.55,68.76 153.39,68.66 125.07,74.29 110.5,78.71 101.91,80.42 89.31,84.24 84.09,86.4 78.85,88.57 73.7,89.6 67.23,89.6 66.15,90.04 64.06,90.04 61.26,88.88 59.18,88.88 54.1,90.99 51.89,93.2 49.05,93.2 45.86,94.52 44.44,95.95 42.65,100.26 39.07,102.65 34.82,106.9 34,108.88 33.04,113.7 32.48,115.06 31.92,115.74 30.46,116.72 26.64,120.54 26.52,120.76 26.24,122.15 26.24,124.91 28.45,127.12 28.45,129.78 26.91,131.33 26.91,132.62 27.58,133.29 28.57,133.71 29.81,133.71 30.3,133.91 37.67,133.91 38.77,135.01 41.01,135.93 43.88,135.93 44.96,136.38 48.32,139.74 49.62,140.28 50.92,140.82 53.35,140.82 57.72,136.45 61.08,136.45 61.58,136.95 61.58,137.65 v2(61.92,137.99)
  BOTTOM w0.124: J6.B41 61.67,139.95 61.57,139.85 61.57,138.34 v2(61.92,137.99)
P3E_PESW_M2K_RX0_DP: length 220.2
  TOP w0.124: U34.AM5 v6(168.59,67.02)
  IN2 w0.099: v6(168.59,67.02) 168.3,67.02 168.2,66.92 168.2,66.64 167.98,66.42 165.72,66.42 165.68,66.38 165.66,66.38
  IN2 w0.136: 165.66,66.38 163.4,66.38 153.45,68.36 153.45,68.36 153.39,68.37 153.34,68.38 125,74.02 110.43,78.44 101.85,80.15 89.21,83.98 78.77,88.3 73.67,89.32 67.18,89.32 66.1,89.77 64.11,89.77 61.31,88.61 59.13,88.61 53.94,90.75 51.77,92.92 49,92.92 45.71,94.29 44.2,95.79 42.43,100.07 38.89,102.43 34.58,106.74 33.73,108.8 32.77,113.62 32.23,114.92 31.73,115.53 30.28,116.5 26.41,120.37 26.25,120.66 25.96,122.12 25.96,125.03 28.17,127.24 28.17,129.67 26.63,131.21 26.63,132.74 27.42,133.53 28.52,133.99 29.75,133.99 30.24,134.19 37.56,134.19 38.61,135.24 40.96,136.21 43.83,136.21 44.8,136.62 48.16,139.98 50.86,141.1 53.47,141.1 57.83,136.73 60.97,136.73 61.3,137.07 61.3,137.59 v2(60.9,137.99)
  BOTTOM w0.124: J6.B43 61.17,139.95 61.27,139.85 61.27,138.35 v2(60.9,137.99)
P3E_PESW_M2K_RX1_DN: length 219.4
  TOP w0.124: U34.AL5 v6(168.59,68.02)
  IN2 w0.099: v6(168.59,68.02) 168.9,68.02 169,67.92 169,67.73 168.9,67.62 165.78,67.62 165.74,67.66 165.71,67.66
  IN2 w0.136: 165.71,67.66 163.91,67.66 124.32,75.54 111.24,79.51 102.14,81.31 99.64,82.07 99.56,82.24 99.16,82.35 99,82.27 98.61,82.39 98.52,82.55 98.13,82.67 97.97,82.58 97.58,82.7 97.49,82.86 97.1,82.98 96.93,82.89 96.54,83.01 96.46,83.18 96.07,83.29 95.9,83.21 95.51,83.33 95.42,83.49 95.03,83.61 94.87,83.52 94.48,83.64 94.39,83.8 94,83.92 93.83,83.83 93.44,83.95 93.36,84.12 92.97,84.24 92.8,84.15 90.46,84.86 79.51,89.39 71.55,90.98 63.85,90.98 61.07,89.83 59.44,89.83 54.99,91.67 52.46,94.2 49.11,94.2 46.35,95.34 45.25,96.44 43.42,100.88 40.01,103.16 35.53,107.64 34.89,109.19 34.37,111.76 34.49,111.93 35.04,112.04 35.27,112.39 35.1,113.23 34.75,113.47 34.2,113.36 34.04,113.46 33.86,114.4 31.68,119.64 31.59,119.74 29.63,120.55 28.92,121.61 28.42,123.28 28.53,123.72 29.78,124.97 29.78,132.26 30.11,132.59 36.99,132.59 42.81,135 44.57,135 45.74,135.79 48.92,138.97 51.1,139.87 52.97,139.87 57.42,135.43 63.26,135.43 64.56,136.73 64.56,137.41 v2(64.93,137.78)
  BOTTOM w0.124: J6.B29 64.67,139.96 64.57,139.86 64.57,138.13 v2(64.93,137.78)
P3E_PESW_M2K_RX1_DP: length 219.4
  TOP w0.124: U34.AL6 v6(169.59,68.02)
  IN2 w0.099: 165.71,67.38 165.74,67.38 165.78,67.42 168.98,67.42 169.2,67.64 169.2,67.92 169.3,68.02 v6(169.59,68.02)
  IN2 w0.136: 165.71,67.38 163.88,67.38 124.26,75.26 111.17,79.23 102.07,81.04 90.37,84.59 79.43,89.13 71.53,90.7 63.9,90.7 61.13,89.55 59.39,89.55 54.83,91.44 52.34,93.92 49.05,93.92 46.2,95.11 45.02,96.29 43.19,100.69 39.83,102.94 35.29,107.48 34.62,109.11 34.08,111.82 34.32,112.18 34.87,112.29 34.98,112.45 34.85,113.06 34.69,113.17 34.14,113.06 33.79,113.3 33.59,114.32 31.45,119.49 31.43,119.5 29.45,120.32 28.67,121.49 28.13,123.27 28.27,123.86 28.33,123.92 29.01,124.59 29.5,125.09 29.5,132.37 30,132.87 36.94,132.87 42.75,135.28 44.48,135.28 45.56,136 48.76,139.21 51.05,140.15 53.09,140.15 57.53,135.71 63.14,135.71 64.28,136.85 64.28,137.41 v2(63.91,137.78)
  BOTTOM w0.124: J6.B31 64.17,139.94 64.27,139.85 64.27,138.13 v2(63.91,137.78)
P3E_PESW_M2K_RX2_DN: length 212.7
  TOP w0.124: U34.AK4 v6(167.59,69.02)
  IN2 w0.099: v6(167.59,69.02) 167.9,69.02 168,68.92 168,68.72 167.9,68.62 165.75,68.62 165.72,68.66 165.69,68.66
  IN2 w0.136: 165.69,68.66 163.95,68.66 161.22,69.2 161.12,69.36 160.72,69.44 160.56,69.33 160.16,69.41 160.06,69.57 159.66,69.65 159.5,69.54 159.1,69.62 159,69.78 158.6,69.86 158.44,69.75 158.04,69.83 157.94,69.99 157.54,70.07 157.39,69.97 156.99,70.04 156.88,70.2 156.48,70.28 156.33,70.18 155.93,70.26 155.82,70.41 155.42,70.49 155.27,70.39 154.87,70.47 154.76,70.62 154.36,70.7 154.21,70.6 126.02,76.2 113,80.16 103.12,82.12 89.83,86.15 79.87,90.28 69.45,92.35 67.19,93.56 66.36,93.9 64.81,94.21 60.1,94.21 55.48,95.13 49.41,95.13 46.83,96.2 46.03,97 44.15,101.53 40.89,103.72 38.34,106.26 36.31,112.98 35.47,114.54 33.54,119.19 31.91,121.63 31.2,123.35 31.2,127.67 31.64,128.72 32.45,129.54 34.98,130.58 37.62,130.58 39.68,132.64 42.05,133.62 46.1,133.62 46.87,134.38 46.87,135.51 47.87,136.52 48.48,136.77 49.28,136.77 49.7,136.94 51.45,138.69 52.79,138.69 57.66,133.82 64.72,133.82 67.58,136.68 67.58,137.43 v2(67.93,137.78)
  BOTTOM w0.124: J6.B17 67.67,139.96 67.57,139.86 67.57,138.13 v2(67.93,137.78)
P3E_PESW_M2K_RX2_DP: length 212.7
  TOP w0.124: U34.AK5 v6(168.59,69.02)
  IN2 w0.099: v6(168.59,69.02) 168.3,69.02 168.2,68.92 168.2,68.64 167.98,68.42 165.75,68.42 165.72,68.38 165.69,68.38
  IN2 w0.136: v2(66.91,137.78) 67.3,137.39 67.3,136.8 64.6,134.1 57.78,134.1 52.91,138.97 51.33,138.97 49.54,137.18 49.22,137.05 48.42,137.05 47.71,136.76 46.59,135.63 46.59,134.5 45.99,133.9 41.99,133.9 39.52,132.88 37.51,130.86 34.92,130.86 32.29,129.77 31.4,128.88 30.92,127.73 30.92,123.29 31.67,121.5 33.3,119.06 35.22,114.42 36.05,112.87 38.1,106.11 40.71,103.5 43.93,101.35 45.8,96.84 46.67,95.96 49.36,94.85 55.45,94.85 60.07,93.93 64.78,93.93 66.28,93.63 67.07,93.3 69.35,92.08 79.79,90.01 89.73,85.89 103.05,81.85 112.93,79.88 125.96,75.93 163.92,68.38 165.69,68.38
  BOTTOM w0.124: J6.B19 67.17,139.97 67.27,139.87 67.27,138.13 v2(66.91,137.78)
P3E_PESW_M2K_RX3_DN: length 212.5
  TOP w0.124: U34.AJ5 v6(168.59,70.02)
  IN2 w0.099: v6(168.59,70.02) 168.9,70.02 169,69.92 169,69.72 168.9,69.62 165.67,69.62 165.63,69.66 165.6,69.66
  IN2 w0.136: 165.6,69.66 164.65,69.66 162.02,70.18 161.92,70.34 161.52,70.42 161.36,70.31 160.96,70.39 160.86,70.55 160.46,70.63 160.3,70.52 159.9,70.6 159.8,70.76 159.4,70.84 159.24,70.73 158.84,70.81 158.74,70.97 158.34,71.05 158.19,70.95 157.79,71.03 157.68,71.18 157.28,71.26 157.13,71.16 156.73,71.24 156.62,71.39 156.22,71.47 156.07,71.37 155.67,71.45 155.56,71.6 155.16,71.68 155.01,71.58 125.96,77.35 101.77,84.69 98.65,85.99 95.9,86.53 95.09,86.53 88.79,87.79 81,91.01 73.52,92.5 71.01,93.26 68.96,94.11 64.32,95.52 61.51,96.07 49.57,96.07 47.43,96.96 46.83,97.55 44.86,102.33 41.32,104.69 39.14,106.87 36.86,114.39 36.23,115.57 34.24,122.15 33.14,124.8 33.04,125.12 32.5,126.42 32.5,128.08 32.89,128.46 35.58,129.58 39.18,129.58 41.1,131.5 43.93,132.67 48.25,132.67 49.93,134.36 49.93,135.6 51.15,136.82 53.27,136.82 57.21,132.88 64.87,132.88 68.04,134.2 70.55,136.7 70.55,137.17 v2(70.9,137.52)
  BOTTOM w0.124: J6.B5 70.67,139.94 70.55,139.82 70.55,137.87 v2(70.9,137.52)
P3E_PESW_M2K_RX3_DP: length 212.5
  TOP w0.124: U34.AJ6 v6(169.59,70.02)
  IN2 w0.099: 165.6,69.38 165.63,69.38 165.67,69.42 168.98,69.42 169.2,69.64 169.2,69.92 169.3,70.02 v6(169.59,70.02)
  IN2 w0.136: v2(69.89,137.52) 70.27,137.14 70.27,136.82 67.88,134.44 64.81,133.16 57.32,133.16 53.39,137.1 51.03,137.1 49.65,135.72 49.65,134.47 48.13,132.95 43.88,132.95 40.95,131.74 39.07,129.86 35.52,129.86 32.73,128.7 32.22,128.2 32.22,126.36 32.78,125.02 32.87,124.72 32.87,124.71 33.97,122.05 35.97,115.46 36.6,114.28 38.9,106.72 41.14,104.47 44.63,102.14 46.6,97.4 47.27,96.72 49.51,95.8 61.48,95.8 64.25,95.24 68.87,93.84 70.91,93 73.45,92.23 80.92,90.74 88.7,87.52 95.06,86.25 95.87,86.25 98.57,85.72 101.68,84.43 125.89,77.08 164.62,69.38 165.6,69.38
  BOTTOM w0.124: J6.B7 70.17,139.94 70.25,139.86 70.25,137.89 v2(69.89,137.52)
P3E_PESW_M2K_TX0_C_DN: length 157.7
  TOP w0.124: C1037.2 150.91,62.2 148.74,62.2 142.77,61.01 140.67,61.43 137.49,60.8 134.32,61.43 131.14,60.8 124.04,62.22 123.56,62.26 122.14,62.13 110.49,64.46 89.13,73.31 78.54,78.97 74.85,82 73.95,82.37 71.19,85.14 70.92,85.79 70.57,86.21 70.31,86.39 70.07,86.46 69.85,86.46 68.98,86.82 68.88,87.06 68.54,87.2 68.31,87.1 67.96,87.25 67.87,87.48 67.52,87.62 67.29,87.53 66.94,87.67 66.85,87.9 66.5,88.04 66.27,87.95 65.92,88.09 61.97,88.09 59.91,90.15 59.91,90.4 v2(60.31,90.8)
  IN1 w0.136: v2(60.31,90.8) 59.94,91.17 59.94,92.33 67.14,99.53 67.14,102.5 67.83,104.16 67.83,107.32 67.08,108.08 67.08,109.95 66.88,110.43 66.69,110.62 66.33,111.49 66.33,111.54 66.32,111.55 66.32,112.35 65.94,113.27 65.94,113.59 66.11,113.75 66.11,117.58 64.93,120.41 64.93,126.73 64.5,127.78 64.37,128.44 64.37,130.91 61.76,133.51 61.38,134.43 61.45,134.61 61.69,134.71 61.85,135.1 61.61,135.68 61.22,135.84 60.98,135.75 60.81,135.82 60.06,137.62 60.06,138.6 v2(60.43,138.97)
  BOTTOM w0.124: v2(60.43,138.97) 60.07,139.33 60.07,139.85 60.17,139.95 J6.B47
P3E_PESW_M2K_TX0_C_DP: length 157.7
  TOP w0.124: v2(59.29,90.8) 59.61,90.48 59.61,90.03 61.85,87.79 65.86,87.79 69.79,86.16 70.02,86.16 70.18,86.11 70.36,85.99 70.65,85.64 70.93,84.97 73.78,82.11 74.69,81.74 78.37,78.71 89,73.03 110.4,64.17 122.12,61.82 123.56,61.96 124.01,61.91 124.01,61.91 131.14,60.48 134.32,61.12 137.49,60.48 140.67,61.12 142.77,60.7 148.77,61.9 150.93,61.9 C1038.2
  IN1 w0.136: v2(59.29,90.8) 59.66,91.17 59.66,92.44 66.86,99.65 66.86,102.56 67.55,104.22 67.55,107.21 66.8,107.96 66.8,109.89 66.64,110.27 66.45,110.46 66.05,111.44 66.05,111.48 66.04,111.5 66.04,112.3 65.67,113.21 65.67,113.7 65.83,113.86 65.83,117.52 64.65,120.36 64.65,126.67 64.23,127.69 64.09,128.42 64.09,130.79 61.52,133.36 61.08,134.43 61.24,134.82 61.48,134.92 61.55,135.1 61.4,135.47 61.22,135.54 60.98,135.44 60.59,135.61 59.78,137.57 59.78,138.6 v2(59.41,138.97)
  BOTTOM w0.124: v2(59.41,138.97) 59.77,139.33 59.77,139.85 59.67,139.95 J6.B49
