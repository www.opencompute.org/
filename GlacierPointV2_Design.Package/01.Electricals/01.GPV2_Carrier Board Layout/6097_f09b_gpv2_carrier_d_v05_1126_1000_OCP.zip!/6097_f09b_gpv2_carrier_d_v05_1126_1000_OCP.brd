# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Nets (continued)
SMB_M2A_P1V8_DAT: J4.B42(NC15) R3621.2 R3810.2
SMB_M2A_P1V8_DAT_R2: R68.2 R3810.1 U88.4(SD0)
SMB_M2AB_3V3SB_CLK: R3771.1 R3804.1
SMB_M2AB_3V3SB_CLK_R1: R3804.2 U88.14(SCL)
SMB_M2AB_3V3SB_CLK_R2: R3771.2 R3790.2 U86.B12(PP5|I2C2SCL)
SMB_M2AB_3V3SB_DAT: R3772.1 R3805.1
SMB_M2AB_3V3SB_DAT_R1: R3805.2 U88.15(SDA)
SMB_M2AB_3V3SB_DAT_R2: R3772.2 R3791.2 U86.B8(PP6|I2C2SDA)
SMB_M2B_ALERT_LVC_N: R4195.2 U86.W6(PF2|RMII0-EN0MDC)
SMB_M2B_ALERT_LVC_N_R: R4195.1 R4211.1 U105.4(OUT)
SMB_M2B_ALERT_N: J4.A44(ALERT#) R4313.2 U105.3(IN)
SMB_M2B_INA231_ALRT_N: R4017.2 U86.B2(PD7|AIN4)
SMB_M2B_INA231_ALRT_N_R: R3900.1 R4017.1 U74.A3(ALERT)
SMB_M2B_INA231_CLK_R1: R3628.1 U74.A1(SCL)
SMB_M2B_INA231_DAT_R1: R3629.1 U74.A2(SDA)
SMB_M2B_P1V8_CLK: J4.A40(SMB_CLK) R3628.2 R3811.2
SMB_M2B_P1V8_CLK_R2: R69.2 R3811.1 U88.7(SC1)
SMB_M2B_P1V8_DAT: J4.A42(SMB_DATA) R3629.2 R3812.2
SMB_M2B_P1V8_DAT_R2: R70.2 R3812.1 U88.6(SD1)
SMB_M2C_ALERT_LVC_N: R4196.2 U86.T7(PF3|RMII0-EN0MDIO)
SMB_M2C_ALERT_LVC_N_R: R4196.1 R4206.1 U105.6(OUT)
SMB_M2C_ALERT_N: J36.B44(NC16) R4314.2 U105.5(IN)
SMB_M2C_INA231_ALRT_N: R4018.2 U86.B3(PD6|AIN5)
SMB_M2C_INA231_ALRT_N_R: R3901.1 R4018.1 U75.A3(ALERT)
SMB_M2C_INA231_CLK_R1: R3635.1 U75.A1(SCL)
SMB_M2C_INA231_DAT_R1: R3636.1 U75.A2(SDA)
SMB_M2C_P1V8_CLK: J36.B40(NC14) R3635.2 R3813.2
SMB_M2C_P1V8_CLK_R2: R71.2 R3813.1 U89.5(SC0)
SMB_M2C_P1V8_DAT: J36.B42(NC15) R3636.2 R3814.2
SMB_M2C_P1V8_DAT_R2: R72.2 R3814.1 U89.4(SD0)
SMB_M2CD_3V3SB_CLK: R3773.1 R3817.1
SMB_M2CD_3V3SB_CLK_R1: R3817.2 U89.14(SCL)
SMB_M2CD_3V3SB_CLK_R2: R3773.2 R3792.2 U86.U19(PK4|I2C3SCL)
SMB_M2CD_3V3SB_DAT: R3774.1 R3818.1
SMB_M2CD_3V3SB_DAT_R1: R3818.2 U89.15(SDA)
SMB_M2CD_3V3SB_DAT_R2: R3774.2 R3793.2 U86.V17(PK5|I2C3SDA)
SMB_M2D_ALERT_LVC_N: R4197.2 U86.V5(PA6|EN0RXCK)
SMB_M2D_ALERT_LVC_N_R: R4197.1 R4207.1 U104.2(OUT)
SMB_M2D_ALERT_N: J36.A44(ALERT#) R4318.2 U104.1(IN)
SMB_M2D_INA231_ALRT_N: R4019.2 U86.B4(PD5|AIN6)
SMB_M2D_INA231_ALRT_N_R: R3902.1 R4019.1 U76.A3(ALERT)
SMB_M2D_INA231_CLK_R1: R3642.1 U76.A1(SCL)
SMB_M2D_INA231_DAT_R1: R3643.1 U76.A2(SDA)
SMB_M2D_P1V8_CLK: J36.A40(SMB_CLK) R3642.2 R3815.2
SMB_M2D_P1V8_CLK_R2: R73.2 R3815.1 U89.7(SC1)
SMB_M2D_P1V8_DAT: J36.A42(SMB_DATA) R3643.2 R3816.2
SMB_M2D_P1V8_DAT_R2: R74.2 R3816.1 U89.6(SD1)
SMB_M2E_ALERT_LVC_N: R4199.2 U86.V11(PG2|EN0TXCK)
SMB_M2E_ALERT_LVC_N_R: R4199.1 R4208.1 U104.4(OUT)
SMB_M2E_ALERT_N: J38.B44(NC16) R4319.2 U104.3(IN)
SMB_M2E_INA231_ALRT_N: R4020.2 U86.A4(PD4|AIN7)
SMB_M2E_INA231_ALRT_N_R: R3887.1 R4020.1 U77.A3(ALERT)
SMB_M2E_INA231_CLK_R1: R3649.1 U77.A1(SCL)
SMB_M2E_INA231_DAT_R1: R3650.1 U77.A2(SDA)
SMB_M2E_P1V8_CLK: J38.B40(NC14) R3649.2 R3826.2
SMB_M2E_P1V8_CLK_R2: R75.2 R3826.1 U90.5(SC0)
SMB_M2E_P1V8_DAT: J38.B42(NC15) R3650.2 R3827.2
SMB_M2E_P1V8_DAT_R2: R76.2 R3827.1 U90.4(SD0)
SMB_M2EF_3V3SB_CLK: R3775.1 R3830.1
SMB_M2EF_3V3SB_CLK_R1: R3830.2 U90.14(SCL)
SMB_M2EF_3V3SB_CLK_R2: R3775.2 R3794.2 U86.V16(PK6|I2C4SCL)
SMB_M2EF_3V3SB_DAT: R3776.1 R3831.1
SMB_M2EF_3V3SB_DAT_R1: R3831.2 U90.15(SDA)
SMB_M2EF_3V3SB_DAT_R2: R3776.2 R3795.2 U86.W16(PK7|I2C4SDA)
SMB_M2F_ALERT_LVC_N: R4203.2 U86.T12(PN6|EN0TXER)
SMB_M2F_ALERT_LVC_N_R: R4203.1 R4209.1 U104.6(OUT)
SMB_M2F_ALERT_N: J38.A44(ALERT#) R4320.2 U104.5(IN)
SMB_M2F_INA231_ALRT_N: R4021.2 U86.W12(PQ5|RMII0-EN0RXD0)
SMB_M2F_INA231_ALRT_N_R: R3888.1 R4021.1 U78.A3(ALERT)
SMB_M2F_INA231_CLK_R1: R3656.1 U78.A1(SCL)
SMB_M2F_INA231_DAT_R1: R3657.1 U78.A2(SDA)
SMB_M2F_P1V8_CLK: J38.A40(SMB_CLK) R3656.2 R3828.2
SMB_M2F_P1V8_CLK_R2: R77.2 R3828.1 U90.7(SC1)
SMB_M2F_P1V8_DAT: J38.A42(SMB_DATA) R3657.2 R3829.2
SMB_M2F_P1V8_DAT_R2: R78.2 R3829.1 U90.6(SD1)
SMB_M2G_ALERT_LVC_N: R4198.2 U86.N18(PM7|EN0COL)
SMB_M2G_ALERT_LVC_N_R: R4198.1 R4216.1 U104.8(OUT)
SMB_M2G_ALERT_N: J8.B44(NC16) R4321.2 U104.9(IN)
SMB_M2G_INA231_ALRT_N: R4027.2 U86.U15(PQ6|RMII0-EN0RXD1)
SMB_M2G_INA231_ALRT_N_R: R3894.1 R4027.1 U84.A3(ALERT)
SMB_M2G_INA231_CLK_R1: R3721.1 U84.A1(SCL)
SMB_M2G_INA231_DAT_R1: R3722.1 U84.A2(SDA)
SMB_M2G_P1V8_CLK: J8.B40(NC14) R3721.2 R3839.2
SMB_M2G_P1V8_CLK_R2: R3063.2 R3839.1 U91.5(SC0)
SMB_M2G_P1V8_DAT: J8.B42(NC15) R3722.2 R3840.2
SMB_M2G_P1V8_DAT_R2: R3064.2 R3840.1 U91.4(SD0)
SMB_M2GH_3V3SB_CLK: R3777.1 R3843.1
SMB_M2GH_3V3SB_CLK_R1: R3843.2 U91.14(SCL)
SMB_M2GH_3V3SB_CLK_R2: R3777.2 R3796.2 U86.C6(PB4|I2C5SCL)
SMB_M2GH_3V3SB_DAT: R3778.1 R3844.1
SMB_M2GH_3V3SB_DAT_R1: R3844.2 U91.15(SDA)
SMB_M2GH_3V3SB_DAT_R2: R3778.2 R3797.2 U86.B6(PB5|I2C5SDA)
SMB_M2H_ALERT_LVC_N: R4200.2 U86.N19(PM6|EN0CRS)
SMB_M2H_ALERT_LVC_N_R: R4200.1 R4217.1 U104.10(OUT)
SMB_M2H_ALERT_N: J8.A44(ALERT#) R4322.2 U104.11(IN)
SMB_M2H_INA231_ALRT_N: R4026.2 U86.P4(PH0|LPC0COMXRTS)
SMB_M2H_INA231_ALRT_N_R: R3893.1 R4026.1 U83.A3(ALERT)
SMB_M2H_INA231_CLK_R1: R3714.1 U83.A1(SCL)
SMB_M2H_INA231_DAT_R1: R3715.1 U83.A2(SDA)
SMB_M2H_P1V8_CLK: J8.A40(SMB_CLK) R3714.2 R3841.2
SMB_M2H_P1V8_CLK_R2: R3065.2 R3841.1 U91.7(SC1)
SMB_M2H_P1V8_DAT: J8.A42(SMB_DATA) R3715.2 R3842.2
SMB_M2H_P1V8_DAT_R2: R3066.2 R3842.1 U91.6(SD1)
SMB_M2I_ALERT_LVC_N: R4201.2 U86.T6(PA2|SSI0CLK)
SMB_M2I_ALERT_LVC_N_R: R4201.1 R4212.1 U104.12(OUT)
SMB_M2I_ALERT_N: J34.B44(NC16) R4323.2 U104.13(IN)
SMB_M2I_INA231_ALRT_N: R4025.2 U86.E3(PQ0|SSI3CLK)
SMB_M2I_INA231_ALRT_N_R: R3892.1 R4025.1 U82.A3(ALERT)
SMB_M2I_INA231_CLK_R1: R3706.1 U82.A1(SCL)
SMB_M2I_INA231_DAT_R1: R3707.1 U82.A2(SDA)
SMB_M2I_P1V8_CLK: J34.B40(NC14) R3706.2 R3852.2
SMB_M2I_P1V8_CLK_R2: R3067.2 R3852.1 U92.5(SC0)
SMB_M2I_P1V8_DAT: J34.B42(NC15) R3707.2 R3853.2
SMB_M2I_P1V8_DAT_R2: R3068.2 R3853.1 U92.4(SD0)
SMB_M2IJ_3V3SB_CLK: R3779.1 R3856.1
SMB_M2IJ_3V3SB_CLK_R1: R3856.2 U92.14(SCL)
SMB_M2IJ_3V3SB_CLK_R2: R3779.2 R3798.2 U86.F2(PB6|I2C6SCL)
SMB_M2IJ_3V3SB_DAT: R3780.1 R3857.1
SMB_M2IJ_3V3SB_DAT_R1: R3857.2 U92.15(SDA)
SMB_M2IJ_3V3SB_DAT_R2: R3780.2 R3799.2 U86.F1(PB7|I2C6SDA)
SMB_M2J_ALERT_LVC_N: R4202.2 U86.U5(PA3|SSI0FSS)
SMB_M2J_ALERT_LVC_N_R: R4202.1 R4213.1 U105.8(OUT)
SMB_M2J_ALERT_N: J34.A44(ALERT#) R4315.2 U105.9(IN)
SMB_M2J_INA231_ALRT_N: R4024.2 U86.E2(PQ1|SSI3FSS)
SMB_M2J_INA231_ALRT_N_R: R3891.1 R4024.1 U81.A3(ALERT)
SMB_M2J_INA231_CLK_R1: R3699.1 U81.A1(SCL)
SMB_M2J_INA231_DAT_R1: R3700.1 U81.A2(SDA)
SMB_M2J_P1V8_CLK: J34.A40(SMB_CLK) R3699.2 R3854.2
SMB_M2J_P1V8_CLK_R2: R3069.2 R3854.1 U92.7(SC1)
SMB_M2J_P1V8_DAT: J34.A42(SMB_DATA) R3700.2 R3855.2
SMB_M2J_P1V8_DAT_R2: R3070.2 R3855.1 U92.6(SD1)
SMB_M2K_ALERT_LVC_N: R4204.2 U86.V4(PA4|SSI0XDAT0)
SMB_M2K_ALERT_LVC_N_R: R4204.1 R4214.1 U105.10(OUT)
SMB_M2K_ALERT_N: J6.B44(NC16) R4316.2 U105.11(IN)
SMB_M2K_INA231_ALRT_N: R4023.2 U86.H4(PQ2|SSI3XDAT0)
SMB_M2K_INA231_ALRT_N_R: R3890.1 R4023.1 U80.A3(ALERT)
SMB_M2K_INA231_CLK_R1: R3692.1 U80.A1(SCL)
SMB_M2K_INA231_DAT_R1: R3693.1 U80.A2(SDA)
SMB_M2K_P1V8_CLK: J6.B40(NC14) R3692.2 R3865.2
SMB_M2K_P1V8_CLK_R2: R3071.2 R3865.1 U93.5(SC0)
SMB_M2K_P1V8_DAT: J6.B42(NC15) R3693.2 R3866.2
SMB_M2K_P1V8_DAT_R2: R3072.2 R3866.1 U93.4(SD0)
SMB_M2KL_3V3SB_CLK: R3781.1 R3869.1
SMB_M2KL_3V3SB_CLK_R1: R3869.2 U93.14(SCL)
SMB_M2KL_3V3SB_CLK_R2: R3781.2 R3800.2 U86.C2(PD0|I2C7SCL)
SMB_M2KL_3V3SB_DAT: R3782.1 R3870.1
SMB_M2KL_3V3SB_DAT_R1: R3870.2 U93.15(SDA)
SMB_M2KL_3V3SB_DAT_R2: R3782.2 R3801.2 U86.C1(PD1|I2C7SDA)
SMB_M2L_ALERT_LVC_N: R4205.2 U86.W4(PA5|SSI0XDAT1)
SMB_M2L_ALERT_LVC_N_R: R4205.1 R4215.1 U105.12(OUT)
SMB_M2L_ALERT_N: J6.A44(ALERT#) R4317.2 U105.13(IN)
SMB_M2L_INA231_ALRT_N: R4022.2 U86.M4(PQ3|SSI3XDAT1)
SMB_M2L_INA231_ALRT_N_R: R3889.1 R4022.1 U79.A3(ALERT)
SMB_M2L_INA231_CLK_R1: R3666.1 U79.A1(SCL)
SMB_M2L_INA231_DAT_R1: R3667.1 U79.A2(SDA)
SMB_M2L_P1V8_CLK: J6.A40(SMB_CLK) R3666.2 R3867.2
SMB_M2L_P1V8_CLK_R2: R3073.2 R3867.1 U93.7(SC1)
SMB_M2L_P1V8_DAT: J6.A42(SMB_DATA) R3667.2 R3868.2
SMB_M2L_P1V8_DAT_R2: R3074.2 R3868.1 U93.6(SD1)
SMB_MUX_VR_CLK: PR104.1 PR304.1 PU101.6(SCL) PU201.6(SCL) PU301.6(SCL) PU601.6(SCL) R4374.2 TP65.1
SMB_MUX_VR_CLK_R: R4374.1 R4380.2 U108.10(SC2)
SMB_MUX_VR_DAT: PR103.1 PR303.1 PU101.7(SDA) PU201.7(SDA) PU301.7(SDA) PU601.7(SDA) R4375.2 TP67.1
SMB_MUX_VR_DAT_R: R4375.1 R4381.2 U108.9(SD2)
SMB_PESW_3V3SB_CLK: R3334.2 R3767.1
SMB_PESW_3V3SB_CLK_R1: D4.7(SCLB) R3334.1
SMB_PESW_3V3SB_CLK_R2: R3767.2 R3786.2 U86.A17(PB2|I2C0SCL)
SMB_PESW_3V3SB_DAT: R3335.2 R3768.1
SMB_PESW_3V3SB_DAT_R1: D4.6(SDAB) R3335.1
SMB_PESW_3V3SB_DAT_R2: R3768.2 R3787.2 U86.B17(PB3|I2C0SDA)
SMB_PESW_P1V8_CLK: R3332.1 R4049.1
SMB_PESW_P1V8_CLK_R1: D4.2(SCLA) R3332.2
SMB_PESW_P1V8_CLK_R2: R3336.1 R4049.2 U34.K27(TWI_SCL_1)
SMB_PESW_P1V8_DAT: R3333.1 R4050.1
SMB_PESW_P1V8_DAT_R1: D4.3(SDAA) R3333.2
SMB_PESW_P1V8_DAT_R2: R3337.1 R4050.2 U34.K30(TWI_SDA_1)
SMB_SENSOR_3V3SB_CLK: R42.2 R47.1 R2959.1 R3769.1 R4331.1
SMB_SENSOR_3V3SB_CLK_R1: R9.2 R44.2 R4160.1 R4326.2 R4331.2
SMB_SENSOR_3V3SB_CLK_R2: R3769.2 R3788.2 U86.N5(PR0|I2C1SCL)
SMB_SENSOR_3V3SB_CLK_R3: R4326.1 U106.7(SCLB)
SMB_SENSOR_3V3SB_DAT: R41.2 R48.1 R2958.1 R3770.1 R4330.1
SMB_SENSOR_3V3SB_DAT_R1: R10.2 R43.2 R4159.1 R4327.2 R4330.2
SMB_SENSOR_3V3SB_DAT_R2: R3770.2 R3789.2 U86.N4(PR1|I2C1SDA)
SMB_SENSOR_3V3SB_DAT_R3: R4327.1 U106.6(SDAB)
SMB_SENSOR_DB1200_CLK_R1: R2959.2 U47.13(SMBCLK)
SMB_SENSOR_DB1200_DAT_R1: R2958.2 U47.12(SMBDAT)
SMB_SENSOR_FRU_CLK_R1: R47.2 U6.6(SCL)
SMB_SENSOR_FRU_DAT_R1: R48.2 U6.5(SDA)
SMB_SENSOR_I2C_GPIO_CLK_R1: R4160.2 U101.19(SCL)
SMB_SENSOR_I2C_GPIO_DAT_R1: R4159.2 U101.20(SDA)
SMB_SENSOR_INA230_CLK_R1: R9.1 U2.5(SCL)
SMB_SENSOR_INA230_DAT_R1: R10.1 U2.4(SDA)
SMB_SENSOR_TMP75_CLK_0_R1: R42.1 U7.2(SCL)
SMB_SENSOR_TMP75_CLK_1_R1: R44.1 U8.2(SCL)
SMB_SENSOR_TMP75_DAT_0_R1: R41.1 U7.1(SDA)
SMB_SENSOR_TMP75_DAT_1_R1: R43.1 U8.1(SDA)
SMB_SENSOR_ZL30281_CLK: R4324.1 U61.31(SCL||SCLK)
SMB_SENSOR_ZL30281_CLK_R1: R3239.2 R4324.2 U106.2(SCLA)
SMB_SENSOR_ZL30281_DAT: R4325.1 U61.2(SDA||MOSI)
SMB_SENSOR_ZL30281_DAT_R1: R3238.2 R4325.2 U106.3(SDAA)
SPI_PESW_FLASH_CLK: R3124.1 R3250.2 U58.6(SCL)
SPI_PESW_FLASH_CLK_R: R3250.1 U34.AJ31(QSPI_CLK)
SPI_PESW_FLASH_CSB_0: R3123.2 R3251.2 U58.1(A0)
SPI_PESW_FLASH_CSB_0_R: R3251.1 U34.AJ27(QSPI_CSB_0)
SPI_PESW_FLASH_DAT_0: R3252.2 R4259.2
SPI_PESW_FLASH_DAT_0_R1: R3252.1 U34.AJ29(QSPI_DATA_0)
SPI_PESW_FLASH_DAT_0_R2: R4259.1 U58.5(SDA)
SPI_PESW_FLASH_DAT_1: R3253.2 R4260.1
SPI_PESW_FLASH_DAT_1_R1: R3253.1 U34.AJ30(QSPI_DATA_1)
SPI_PESW_FLASH_DAT_1_R2: R4260.2 U58.2(A1)
SPI_PESW_FLASH_DAT_2: R3254.2 R4261.1
SPI_PESW_FLASH_DAT_2_R1: R3254.1 U34.AJ32(QSPI_DATA_2)
SPI_PESW_FLASH_DAT_2_R2: R4261.2 U58.3(A2)
SPI_PESW_FLASH_DAT_3: R3255.2 R4258.2
SPI_PESW_FLASH_DAT_3_R1: R3255.1 U34.AJ33(QSPI_DATA_3)
SPI_PESW_FLASH_DAT_3_R2: R4258.1 U58.7(WP)
SW_P0V9_1: PC308.2 PL301.1 PU301.2(SW1) PU301.3(SW2)
SW_P0V9_BT_1: PR306.2 PU301.25(BST)
SW_P1V8: PL702.1 PU7.2(SW)
SW_P1V8_FLT: PC701.1 PC702.1 PL701.2 PU7.3(VIN)
SW_P3V3_STBY_1: PC108.2 PL101.1 PU101.2(SW1) PU101.3(SW2)
SW_P3V3_STBY_2: PC207.2 PL201.1 PU201.2(SW1) PU201.3(SW2)
SW_P3V3_STBY_3: PC607.2 PL601.1 PU601.2(SW1) PU601.3(SW2)
SW_P3V3_STBY_BT_1: PR124.2 PU101.25(BST)
SW_P3V3_STBY_BT_2: PR206.2 PU201.25(BST)
SW_P3V3_STBY_BT_3: PR606.2 PU601.25(BST)
SW_P12V_FLT: PC101.1 PC102.1 PC103.1 PC104.1 PC105.1 PC117.1 PC118.1 PC201.1 PC202.1 PC203.1 PC204.1 PC215.1 PC216.1 PC301.1 PC302.1 PC304.1 PC305.1 PC317.1 PC322.1 PC601.1 PC602.1 PC603.1 PC604.1 PC615.1 PL102.2 PU101.1(IN1) PU101.16(IN2) PU201.1(IN1) PU201.16(IN2) PU301.1(IN1) PU301.16(IN2) PU601.1(IN1) PU601.16(IN2)
TDR_DIFF_85_BOT_DN: X5.4(S2) X6.1(S1)
TDR_DIFF_85_BOT_DP: X5.1(S1) X6.4(S2)
TDR_DIFF_85_IN1_DN: X3.4(S2) X4.1(S1)
TDR_DIFF_85_IN1_DP: X3.1(S1) X4.4(S2)
TDR_DIFF_85_IN2_DN: X7.4(S2) X8.1(S1)
TDR_DIFF_85_IN2_DP: X7.1(S1) X8.4(S2)
TDR_DIFF_85_TOP_DN: X1.4(S2) X2.1(S1)
TDR_DIFF_85_TOP_DP: X1.1(S1) X2.4(S2)
TDR_GND: J24.1(GND) J25.1(GND) J26.1(GND) J50.1(GND) X1.2(P1) X1.3(P2) X2.2(P1) X2.3(P2) X3.2(P1) X3.3(P2) X4.2(P1) X4.3(P2) X5.2(P1) X5.3(P2) X6.2(P1) X6.3(P2) X7.2(P1) X7.3(P2) X8.2(P1) X8.3(P2)
TDR_SE_50_OHM_BOT: J50.2(IO1) J50.3(IO2)
TDR_SE_50_OHM_IN1: J25.2(IO1) J25.3(IO2)
TDR_SE_50_OHM_IN2: J26.2(IO1) J26.3(IO2)
TDR_SE_50_OHM_TOP: J24.2(IO1) J24.3(IO2)
TGND: J9.3 J10.3 J11.3 J12.3 J13.3 J14.3 J15.3 J16.3 J17.3 J18.3 J19.3 J20.3 J51.3 J52.3 J53.3 J54.3
TMP_A0_0: R19.2 U7.7(A0)
TMP_A0_1: R22.2 U8.7(A0)
TMP_A1_0: R20.2 U7.6(A1)
TMP_A1_1: R23.2 U8.6(A1)
TMP_A2_0: R21.2 U7.5(A2)
TMP_A2_1: R24.2 U8.5(A2)
TMP_ALERT_U7_N: R4053.2 U86.N2(PR2|GPIOPR2)
TMP_ALERT_U7_N_R: R4053.1 R4055.2 U7.3(ALERT)
TMP_ALERT_U8_N: R4054.2 U86.V8(PR3|GPIOPR3)
TMP_ALERT_U8_N_R: R4054.1 R4056.2 U8.3(ALERT)
TP_JTAG_CONN_5: J58.5 TP64.1
TP_JTAG_PCH_LAN_TRST_N: J58.4 TP63.1
TP_M2A_MFG_CLK: J4.B58(NC23) TP4.1
TP_M2A_MFG_DAT: J4.B56(NC22) TP3.1
TP_M2B_MFG_CLK: J4.A58(MFG_CLK) TP2.1
TP_M2B_MFG_DAT: J4.A56(MFG_DATA) TP1.1
TP_M2C_MFG_CLK: J36.B58(NC23) TP20.1
TP_M2C_MFG_DAT: J36.B56(NC22) TP19.1
TP_M2D_MFG_CLK: J36.A58(MFG_CLK) TP18.1
TP_M2D_MFG_DAT: J36.A56(MFG_DATA) TP17.1
TP_M2E_MFG_CLK: J38.B58(NC23) TP24.1
TP_M2E_MFG_DAT: J38.B56(NC22) TP23.1
TP_M2F_MFG_CLK: J38.A58(MFG_CLK) TP22.1
TP_M2F_MFG_DAT: J38.A56(MFG_DATA) TP21.1
TP_M2G_MFG_CLK: J8.B58(NC23) TP12.1
TP_M2G_MFG_DAT: J8.B56(NC22) TP11.1
TP_M2H_MFG_CLK: J8.A58(MFG_CLK) TP10.1
TP_M2H_MFG_DAT: J8.A56(MFG_DATA) TP9.1
TP_M2I_MFG_CLK: J34.B58(NC23) TP16.1
TP_M2I_MFG_DAT: J34.B56(NC22) TP15.1
TP_M2J_MFG_CLK: J34.A58(MFG_CLK) TP14.1
TP_M2J_MFG_DAT: J34.A56(MFG_DATA) TP13.1
TP_M2J_PLA_S3_N: J34.A30(PLA_S3#) R4271.1
TP_M2K_MFG_CLK: J6.B58(NC23) TP8.1
TP_M2K_MFG_DAT: J6.B56(NC22) TP7.1
TP_M2L_MFG_CLK: J6.A58(MFG_CLK) TP6.1
TP_M2L_MFG_DAT: J6.A56(MFG_DATA) TP5.1
TP_PEWAKE_M2A: J4.B54(NC21) TP49.1
TP_PEWAKE_M2B: J4.A54(PEWAKE#) TP50.1
TP_PEWAKE_M2C: J36.B54(NC21) TP51.1
TP_PEWAKE_M2D: J36.A54(PEWAKE#) TP52.1
TP_PEWAKE_M2E: J38.B54(NC21) TP53.1
TP_PEWAKE_M2F: J38.A54(PEWAKE#) TP54.1
TP_PEWAKE_M2G: J8.B54(NC21) TP60.1
TP_PEWAKE_M2H: J8.A54(PEWAKE#) TP59.1
TP_PEWAKE_M2I: J34.B54(NC21) TP58.1
TP_PEWAKE_M2J: J34.A54(PEWAKE#) TP57.1
TP_PEWAKE_M2K: J6.B54(NC21) TP56.1
TP_PEWAKE_M2L: J6.A54(PEWAKE#) TP55.1
TP_RESERVED_USB+: J49.25 TP61.1
TP_RESERVED_USB-: J49.27 TP62.1
TP_USB2_M2A_DN: J4.B36(NC12) TP26.1
TP_USB2_M2A_DP: J4.B34(NC11) TP25.1
TP_USB2_M2B_DN: J4.A36(USB_D-) TP27.1
TP_USB2_M2B_DP: J4.A34(USB_D+) TP28.1
TP_USB2_M2C_DN: J36.B36(NC12) TP29.1
TP_USB2_M2C_DP: J36.B34(NC11) TP30.1
TP_USB2_M2D_DN: J36.A36(USB_D-) TP31.1
TP_USB2_M2D_DP: J36.A34(USB_D+) TP32.1
TP_USB2_M2E_DN: J38.B36(NC12) TP33.1
TP_USB2_M2E_DP: J38.B34(NC11) TP34.1
TP_USB2_M2F_DN: J38.A34(USB_D+) TP35.1
TP_USB2_M2F_DP: J38.A36(USB_D-) TP36.1
TP_USB2_M2G_DN: J8.B36(NC12) TP48.1
TP_USB2_M2G_DP: J8.B34(NC11) TP47.1
TP_USB2_M2H_DN: J8.A36(USB_D-) TP46.1
TP_USB2_M2H_DP: J8.A34(USB_D+) TP45.1
TP_USB2_M2I_DN: J34.B36(NC12) TP44.1
TP_USB2_M2I_DP: J34.B34(NC11) TP43.1
TP_USB2_M2J_DN: J34.A36(USB_D-) TP42.1
TP_USB2_M2J_DP: J34.A34(USB_D+) TP41.1
TP_USB2_M2K_DN: J6.B36(NC12) TP40.1
TP_USB2_M2K_DP: J6.B34(NC11) TP39.1
TP_USB2_M2L_DN: J6.A36(USB_D-) TP37.1
TP_USB2_M2L_DP: J6.A34(USB_D+) TP38.1
TWI_PESW_EEPROM_CLK_0: R3260.1 U34.J31(TWI_SCL_0) U56.6(SCL)
TWI_PESW_EEPROM_DAT_0: R3261.1 U34.J32(TWI_SDA_0) U56.5(SDA)
UART_BIC_RXD: R3937.2 U86.J1(PK0|U4RX)
UART_BIC_RXD_R: R3937.1 U94.C7(PT13B)
UART_BIC_RXD_REMOTE: R4096.2 U86.P2(PR5|U1RX)
UART_BIC_RXD_REMOTE_R: R4096.1 U94.D7(PT13D)
UART_BIC_TXD: R3885.2 U94.B7(PT13A)
UART_BIC_TXD_R: R3885.1 U86.J2(PK1|U4TX)
UART_BIC_TXD_REMOTE: R4095.2 U94.E6(PT13C)
UART_BIC_TXD_REMOTE_R: R4095.1 U86.W9(PR6|U1TX)
UART_PESW_CPLD_USIN: R4362.2 R4384.2
UART_PESW_CPLD_USIN_R: R4362.1 U94.A8(PT17B|PCLKC0_1)
UART_PESW_CPLD_USOUT: R4361.2 R4383.2
UART_PESW_CPLD_USOUT_R: R4361.1 U94.C8(PT17A|PCLKT0_1)
UART_PESW_USIN: R3279.2 U34.R32(UART_USIN) U66.5(A1)
UART_PESW_USIN_3V3SB: R3274.1 U66.8(B1)
UART_PESW_USIN_3V3SB_R: J60.3(D+) R3274.2 R3276.2 R4384.1
UART_PESW_USOUT: R3277.2 U34.R31(UART_USOUT) U66.4(A2)
UART_PESW_USOUT_3V3SB: R3280.1 U66.1(B2)
UART_PESW_USOUT_3V3SB_R: J60.2(D-) R3275.2 R3280.2 R4383.1
VSENSE_P3V3_M2A_INA231_INN: C1086.2 R3626.2 U73.D2(IN-)
VSENSE_P3V3_M2A_INA231_INP: C1086.1 R3625.2 U73.D3(IN+)
VSENSE_P3V3_M2B_INA231_INN: C1088.2 R3633.2 U74.D2(IN-)
VSENSE_P3V3_M2B_INA231_INP: C1088.1 R3632.2 U74.D3(IN+)
VSENSE_P3V3_M2C_INA231_INN: C1090.2 R3640.2 U75.D2(IN-)
VSENSE_P3V3_M2C_INA231_INP: C1090.1 R3639.2 U75.D3(IN+)
VSENSE_P3V3_M2D_INA231_INN: C1092.2 R3647.2 U76.D2(IN-)
VSENSE_P3V3_M2D_INA231_INP: C1092.1 R3646.2 U76.D3(IN+)
VSENSE_P3V3_M2E_INA231_INN: C1094.2 R3654.2 U77.D2(IN-)
VSENSE_P3V3_M2E_INA231_INP: C1094.1 R3653.2 U77.D3(IN+)
VSENSE_P3V3_M2F_INA231_INN: C1096.2 R3661.2 U78.D2(IN-)
VSENSE_P3V3_M2F_INA231_INP: C1096.1 R3660.2 U78.D3(IN+)
VSENSE_P3V3_M2G_INA231_INN: C1108.2 R3725.2 U84.D2(IN-)
VSENSE_P3V3_M2G_INA231_INP: C1108.1 R3724.2 U84.D3(IN+)
VSENSE_P3V3_M2H_INA231_INN: C1106.2 R3718.2 U83.D2(IN-)
VSENSE_P3V3_M2H_INA231_INP: C1106.1 R3717.2 U83.D3(IN+)
VSENSE_P3V3_M2I_INA231_INN: C1104.2 R3710.2 U82.D2(IN-)
VSENSE_P3V3_M2I_INA231_INP: C1104.1 R3709.2 U82.D3(IN+)
VSENSE_P3V3_M2J_INA231_INN: C1102.2 R3703.2 U81.D2(IN-)
VSENSE_P3V3_M2J_INA231_INP: C1102.1 R3702.2 U81.D3(IN+)
VSENSE_P3V3_M2K_INA231_INN: C1100.2 R3696.2 U80.D2(IN-)
VSENSE_P3V3_M2K_INA231_INP: C1100.1 R3695.2 U80.D3(IN+)
VSENSE_P3V3_M2L_INA231_INN: C1098.2 R3671.2 U79.D2(IN-)
VSENSE_P3V3_M2L_INA231_INP: C1098.1 R3670.2 U79.D3(IN+)
VSENSE_P12V_INA230_INN: C2.2 R8.2 U2.12(IN-)
VSENSE_P12V_INA230_INP: C2.1 R7.2 U2.13(IN+)
VSENSE_P12V_INA230_R_INN: R6.1B R8.1
VSENSE_P12V_INA230_R_INP: R6.2B R7.1
XTAL_25M_ZL30281_XA: C954.1 R3227.1 U61.10(XA) Y2.1(X1)
XTAL_25M_ZL30281_XB: C955.1 R3228.1 Y2.3(X2)
XTAL_25M_ZL30281_XB_R: R3227.2 R3228.2 U61.11(XB)
N13628460: PC109.2 PC120.1 PR120.2 PR125.2 PR126.2

Pads without a net: DM10 1; J4 A68 A69 B68 B69; J6 A68 A69 B68 B69; J8 A68 A69 B68 B69; J34 A68 A69 B68 B69; J36 A68 A69 B68 B69; J38 A68 A69 B68 B69; J41 19 20 42 43 45 120; J49 13 14 30 159; J55 4; J60 4; PU101 8; PU201 8; PU301 8 13 19; PU601 8; Q10 3; Q24 3; U2 6 7 8 14 15 16; U34 A27 A29 A31 A33 A35 A36 AB29 AB30 AB32 AB33 AC29 AC30 AC32 AC33 AD32 AD33 AE27 AE28 AE30 AF27 AF28 AF29 AF30 AF31 AF32 AF33 AH26 AH27 AH28 AH30 AJ28 AK27 AK28 AK29 AK30 AK31 AK32 AK33 AM17 AM19 AM21 AM23 AN17 AN18 AN19 AN20 AN21 AN22 AN23 AN24 AP18 AP20 AP22 AP24 AR17 AR19 AR21 AR23 AT17 AT18 AT19 AT20 AT21 AT22 AT23 AT24 AU18 AU20 AU22 AU24 B26 B27 B28 B29 B30 B31 B32 B33 B36 B37 C26 C28 C30 C32 C35 C36 D27 D29 D31 D33 D36 D37 E26 E27 E28 E29 E30 E31 E32 E33 E35 E36 F26 F28 F30 F32 F36 F37 G35 G36 H27 H28 H29 H30 H32 H33 H36 H37 J27 J33 K26 K28 K31 K33 K35 K36 L26 L27 L28 L32 L36 L37 M29 M33 M35 M36 N27 N32 N33 N36 N37 P35 P36 R36 R37 T28 T35 T36 U27 U28 U29 U32 U33 U36 U37 V27 V29 V30 V31 V33 W29 W30 W32 W33 Y32 Y33; U47 3 15 16; U61 5 6 7 8 14 15 20 21; U73 B2 C2; U74 B2 C2; U75 B2 C2; U76 B2 C2; U77 B2 C2; U78 B2 C2; U79 B2 C2; U80 B2 C2; U81 B2 C2; U82 B2 C2; U83 B2 C2; U84 B2 C2; U86 B7 B18 C5 C12 C18 D19 E13 L18 M17 T18 T19 U18 V13 V14 V15 V18 V19 W13 W15 W18 W19; U94 A2 A3 A10 A12 A14 B4 B9 B13 B16 C13 C15 C16 D3 D6 D8 D10 D14 D15 D16 E7 E8 E9 E10 E11 E14 E15 F1 F7 F9 G2 G4 G5 G16 H5 H13 H15 J4 J12 K1 K3 K11 K12 K13 L7 L10 L13 L14 L15 L16 M2 M7 M9 M10 M11 M14 M15 M16 N1 N2 N3 N7 N10 N11 N14 N15 N16 P1 P2 P4 P7 P10 P11 P12 P13 P15 P16 R1 R7 R10 R11 R13 R14 R16 T7 T10 T11 T12 T13 T14 T15; U101 14 15 16 17; U107 1

## Via types
v1: diameter 0.762, hole 0.381, TOP to BOTTOM, 290 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 5036 vias
v3: diameter 0.66, hole 0.33, TOP to BOTTOM, 362 vias
v4: diameter 0.762, hole 0.254, TOP to BOTTOM, 36 vias
v5: diameter 0.406, hole 0.203, TOP to BOTTOM, 25 vias
v6: diameter 0.49, hole 0.254, TOP to BOTTOM, 1044 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
GND: length 1997.5
  TOP w0.178: 206.83,34.48 206.5,34.81 PU301.21 ; PU301.17 205.47,32.33 v2(205.26,32.11) ; PU601.21 194.64,32.81 194.74,32.72 ; v2(171.26,18.29) 171.18,18.36 PU201.21 ; PU301.23 206.91,35.61 PR321.1 ; PC605.2 194.75,33.76 194.6,33.61 PU601.23
  TOP w0.203: v6(36.45,40.53) 36.54,40.53 U86.A19 ; 36.34,116.51 U73.C1 ; U86.W1 46.07,49.94 v2(46.36,50.23) ; v2(45.7,50.41) 45.45,50.17 U86.W2 ; v2(85.9,117.55) 85.82,117.47 U75.C1 ; U86.A18 37.31,40.8 v6(37.31,40.43) ; U86.B19 36.69,41.44 36.58,41.33 v6(36.41,41.33) ; U86.V1 46.31,49.44 v2(46.45,49.58) ; U76.C1 111.07,114.9 111.07,116.09 111.91,116.93 v2(111.91,117.02) ; U74.C1 61.03,116.63 61.46,117.06 v2(62.22,117.06)
  TOP w0.254: PR127.1 186.59,16.09 v2(186.04,15.54) ; v2(153.43,131.99) 153.43,133.52 J38.A57 ; v6(199.59,98.02) 200.84,98.02 201.94,99.12 201.94,100.66 202.13,100.86 203.09,100.86 203.4,101.17 203.4,102.11 203.12,102.39 203.12,103.53 203.56,103.96 204.01,103.96 205.58,105.53 v2(205.85,105.53) ; U86.B1 v6(46.5,41.44) ; U78.C1 162.47,120.6 v2(162.04,121.03) ; v2(45.22,134.77) 45.33,134.77 45.43,134.67 J4.A9 ; v2(195.15,32.43) 195.02,32.43 194.74,32.72 ; v2(69.25,134.72) 69.43,134.55 J36.B9 ; J4.A21 48.43,132.33 v2(48.57,132.18) ; PR128.1 183.22,14.9 v2(183.57,15.25) ; v2(121.93,132.24) J38.B27 ; U86.K10 U86.K9 U86.L9 ; v2(1.86,80.18) 2.57,80.18 2.82,79.92 U96.4 ; J38.A33 147.43,133.52 v2(147.43,132.17) ; U66.2 183.39,132.1 v2(183.26,131.97) ; PR208.1 171.67,17.88 v2(171.26,18.29) ; v2(85.93,131.47) J36.B75 ; C1156.2 51.38,45.94 v2(50.98,45.54) ; v2(151.93,132.03) 151.93,133.52 J38.A51 ; J38.A1 139.43,134.79 v2(139.29,134.93) ; v6(45.89,40.44) 45.45,40.87 U86.A2 ; J47.8 v2(5.29,101.64) ; v2(21.43,132.24) J4.B9 ; v2(47.38,134.73) 47.3,134.73 46.93,134.35 J4.A15 ; v2(75.57,132.31) 75.43,132.45 J36.B33 ; J38.B57 129.43,132.14 v2(129.33,132.04) ; v2(37.14,131.37) 37.93,132.17 J4.B75 ; U86.L8 U86.M8 ; U86.L8 43,45.94 v5(43.04,45.9) 43.45,45.49 U86.K6 ; U86.L8 U86.L9 ; v2(150.83,134.73) 150.43,134.34 J38.A45 ; v2(123.43,132.25) J38.B33 ; v2(43.93,132.01) J4.A3 ; v2(148.79,132.21) 148.93,132.35 J38.A39 ; v2(103.93,132.24) J36.A51 ; v2(64.24,55.96) 64.21,55.99 U47.41 ; PR321.1 207.28,36.18 207.96,36.86 PC306.2 ; R4133.2 127.6,144.19 v2(127.2,144.58) ; U97.4 7.91,90.43 v2(8.18,90.7) ; v5(42.39,46.98) 41.95,46.55 U86.M9 ; U86.L9 U86.M9 ; J36.A15 94.93,132.05 v2(94.78,131.9) ; v2(127.93,132.05) J38.B51 ; v2(145.93,132.24) 145.93,133.52 J38.A27 ; J4.A39 52.93,132.42 v2(52.85,132.34) ; U86.F10 41.39,43.44 40.95,43.88 v6(40.95,43.92) U86.H11 ; U86.H10 U86.H11 ; U86.H11 U86.H12 ; U86.H11 U86.J11 U86.J12 ; v2(68,56.01) 67.71,56.3 U47.48 ; J4.B32 27.18,125.15 27.53,124.79 v2(27.72,124.79) ; Q24.1 v2(109.83,145.77) ; J36.B15 70.93,132.08 v2(70.78,131.93) ; U86.K14 U86.K13 39.95,45.35 40.32,44.98 40.32,44.94 U86.J12 ; v2(76.78,132.3) 76.93,132.45 J36.B39 ; 206.83,34.48 207.13,34.18 207.13,33.56 207.62,33.07 PR301.1 207.62,32.39 207.74,32.27 PC310.2 207.74,31.18 v2(207.28,30.72) ; J4.B38 28.68,124.99 v2(28.46,124.77) ; v2(72.43,132.24) J36.B21 ; J38.B9 117.43,131.86 v2(117.56,131.73) ; U77.C1 134.93,116.56 v2(135.83,117.46) ; J38.B45 126.43,132.07 v2(126.54,131.96) ; v2(57.43,132.03) J4.A57 ; U86.J12 U86.H12 ; J4.B71 36.93,134.43 v2(37.2,134.7) ; v6(43.43,44.02) 43.51,43.94 U86.G5 U86.G4 ; J36.B1 67.43,134.92 v2(67.17,135.18) ; J4.A51 v2(55.93,132.03) ; v2(102.58,132.02) 102.43,132.16 J36.A45 ; U98.4 v2(7.87,93.59) ; v2(195.99,33.53) 195.75,33.76 PC605.2 ; U86.H12 40.45,44.35 v6(40.15,44.05) ; v2(96.43,132.24) J36.A21 ; U86.M9 U86.M10 U86.N10 41.53,46.94 v5(41.96,47.37) ; v2(50.07,132.31) 49.93,132.45 J4.A27 ; U86.R18 U86.R17 v6(37.95,48.49) ; v2(114.75,134.75) 114.76,134.76 115.25,134.76 115.43,134.58 J38.B1 ; R4116.2 v2(127.59,142.47) ; J4.A45 v2(54.43,134.72) ; v2(99.43,132.27) J36.A33 ; v2(141.43,132) 141.43,133.52 J38.A9 ; v2(7.95,87.55) 7.49,87.09 U99.4 ; v2(24.43,132.24) J4.B21 ; v2(139.93,132) 139.93,133.52 J38.A3 ; J4.A75 61.93,132.15 61.67,131.89 v2(61.67,131.75) ; v6(37.95,42.44) U86.D18 ; v2(79.93,132.05) J36.B51 ; v2(120.43,132.24) J38.B21 ; v2(81.43,132.03) J36.B57 ; J36.A9 v2(93.43,132) ; J38.A15 142.93,133.52 v2(142.93,132) ; v2(100.8,132.31) 100.93,132.45 J36.A39 ; v2(7.87,96.57) 7.81,96.57 7.63,96.75 U100.4 ; J36.A57 105.43,134.41 v2(105.09,134.74) ; v2(78.58,132.02) 78.43,132.17 J36.B45 ; Q24.4 v2(108.83,142.72) ; v2(97.93,132.24) J36.A27 ; J38.A21 144.43,133.52 v2(144.43,132.24) ; J36.A75 109.93,134.54 110.11,134.72 110.52,134.72 v2(110.54,134.7) ; J38.B15 118.93,131.92 v2(118.77,131.76) ; J4.B39 28.93,132.37 v2(28.81,132.25) ; v2(67.93,132.04) J36.B3 ; v2(22.93,132.24) J4.B15 ; v2(110.9,37.48) 111.4,37.99 111.4,38.41 111.91,38.91 v2(112.55,38.91) 112.78,38.91 113.64,39.77 114.72,39.77 v2(114.86,39.62) ; v2(27.43,132.28) J4.B33 ; J36.A1 91.43,134.4 v2(91.74,134.7) 91.93,134.51 J36.A3 ; J4.B45 30.43,132.12 v2(30.56,131.99) ; v2(124.93,132.24) J38.B39 ; v2(51.43,132.33) J4.A33 ; J4.B51 31.93,132.11 v2(32.25,131.8) ; J4.A1 43.43,134.45 43.25,134.63 43.06,134.63 v2(42.95,134.53) ; J4.B57 33.43,132.79 33.99,132.23 v2(33.99,131.98) ; R4132.2 v2(130.02,144.56) 130.54,144.04 R4117.2 ; U95.4 7.76,83.92 v2(7.87,83.81) ; v2(73.93,132.24) J36.B27 ; v6(46.47,40.81) 46.34,40.94 U86.A1 ; v2(207.57,104.24) 207.35,104.02 Q10.1 ; v2(25.93,132.24) J4.B27 ; Q10.5 207.85,106.12 v2(208.09,106.36) 208.09,106.36 208.35,106.1 Q10.4 ; J38.B71 132.93,132.47 v2(133.4,132) 133.93,132.53 J38.B75 ; v2(60.53,131.18) 60.76,131.41 60.76,132.28 60.93,132.45 J4.A71 ; U86.P16 v6(38.45,47.96) ; U47.23 v2(58.6,62.03)
  TOP w0.279: J4.B1 19.43,135.02 v2(19.12,135.34) ; U24.6 152.71,113.35 153.07,113.35 153.26,113.54 v2(153.26,114.63) ; v2(19.45,135.88) 19.93,135.4 J4.B3 ; U23.6 125.03,113.56 v2(125.23,113.36) ; U20.6 v2(50.77,113.54) ; v2(85.33,134.91) 84.93,134.51 J36.B71 ; v2(109.01,134.72) 109.01,134.53 108.93,134.46 J36.A71 ; v2(116.17,134.86) 115.93,134.62 J38.B3 ; U21.6 75.68,112.69 v2(75.89,112.48) ; U19.6 26.48,114.57 26.7,114.79 v2(26.7,115.72) ; U22.6 v2(101.08,113.29)
  TOP w0.305: J4.A38 52.68,128.46 v2(53.04,128.82) ; v2(64.89,66.59) 64.71,66.41 U47.7 ; v2(38.02,85.07) U105.7 ; J38.A75 157.93,134.47 158.1,134.64 v2(158.1,135.07) ; J38.B38 124.68,127.02 124.57,127.13 124.57,127.56 v2(124.78,127.77) ; v2(100.93,127.22) 100.68,126.97 J36.A38 ; J4.A32 51.18,127.12 v2(51.37,127.31) ; v2(75.32,127.18) 75.18,127.04 J36.B32 ; U47.2 67.21,66.24 v2(66.89,66.56) ; U47.33 60.21,56.45 v2(59.82,56.06) ; J38.A38 148.68,127.02 v2(148.83,127.17) ; v2(156.73,135.1) 156.93,134.9 J38.A71 ; J38.A32 147.18,126.83 v2(147.52,127.17) ; v2(99.54,127.36) 99.18,127 J36.A32 ; U50.7 v2(183.99,140.74) ; U47.58 v2(69.27,62.03) ; v2(65.47,69.03) R2966.2 ; v2(76.9,127.79) 76.59,127.47 76.59,127.04 76.68,126.95 J36.B38 ; J38.B32 123.18,127 v2(123.38,127.19) ; v2(121.19,118.12) 121.32,117.99 C1241.2
  TOP w0.33: v2(84.73,37.24) 85.2,37.7 U62.3 ; R3220.2 93.16,33.72 v2(93.72,33.72) ; C973.2 v2(116.48,32.5) ; R3233.2 v2(129.36,36.4) ; R3231.2 v2(129.36,37.41) ; C968.2 v2(119.95,45.18) ; Q36.S v2(93.1,36.54) ; R3218.2 118.92,44.87 v2(119.23,45.18) ; C974.2 v2(117.5,32.5) ; R3240.2 v2(129.36,35.38) ; R3237.2 v2(123.13,45.18)
  TOP w0.356: v2(11.57,90.47) 11.79,90.25 U25.7
  TOP w0.381: C132.2 117.53,118.42 v2(116.77,117.66) ; R4338.2 35.58,34.18 v2(36,34.6) 36.09,34.69 R4339.2 ; v2(135.24,38.49) 135.24,37 134.7,36.46 U106.4 ; R3904.2 52.6,46.89 C1159.2 v2(51.92,46.92) ; v2(22.01,119.07) 22.01,118.94 22.39,118.56 C1237.2 ; v2(118.55,142.81) 118.3,143.07 J55.5 ; PR305.1 206.88,31.12 v2(207.28,30.72) ; C1231.2 197.64,31.96 v2(197.28,31.61) 197.03,31.35 PR601.1 ; C1134.2 v2(22.25,79.1) ; R4075.2 205.43,88.69 v2(204.88,89.23) ; R3819.2 v2(31.88,75.2) ; C1175.2 185.93,131.46 C1174.2 ; v2(47.73,75.02) 47.7,75.02 47.8,75.12 R3858.2 ; C1240.2 98.27,117.95 v2(97.57,117.95) ; v2(140.98,118.24) 141.41,118.24 C135.2 ; C145.2 149.26,117.41 v2(149.21,117.46) ; R4235.1 36.63,135.28 v2(37.2,134.7) ; R2964.2 67.01,68.87 v2(66.81,68.67) ; C1226.2 140.9,39.74 139.63,41.01 v2(138.29,41.01) ; R3265.2 v2(10.88,105.24) ; v2(116.82,116.83) 117.34,117.35 R4392.2 ; v2(8.95,45.15) 8.52,45.58 C1167.2 ; v2(2.36,72.03) 2.44,72.03 R4278.1 ; C1238.2 46.81,118.17 v2(46.7,118.28) ; R17.2 v2(13.89,25.4) ; v2(42.95,134.53) 42.58,134.53 42.33,134.28 J4.G3 ; R3871.2 v2(31.39,94.41) ; R4340.2 40.62,57.47 v2(40.31,57.47) ; v2(2.21,88.87) 2,88.67 R4284.1 ; R4233.2 v2(108.11,146.41) ; U34.J34 v6(198.59,90.02) ; v2(63.75,134.75) 62.53,135.97 R4237.1 ; v2(34.32,21.51) 34.52,21.7 C1234.2 ; U108.8 27.82,34.77 v2(27.58,35) ; v2(70.36,31.44) 70.78,31.02 C1228.2 ; R4245.1 155.48,136.01 v2(154.99,136.51) ; U26.7 16.78,101.74 v2(17.12,102.08) ; R4393.2 141.9,116.77 141.31,117.35 v2(140.91,117.35) ; v2(111.71,135.41) 110.99,136.13 R4241.1 ; v2(130.73,38.25) 131.33,38.25 C1227.2 ; v2(132.63,136.23) 133.17,136.23 R4243.1 ; C1236.2 185.22,100.8 186.27,99.76 189.07,99.76 189.59,99.24 v6(189.59,99.02) ; R3049.1 v2(69.76,20.04) ; v2(197.24,30.59) 197.24,30.58 196.88,30.58 PR602.1 ; C1229.2 v2(16.79,90.29) ; v2(24.06,79.93) 24.06,80.13 23.68,80.51 R3806.2 ; C1239.2 72.9,117.1 v2(71.72,117.1) ; v2(22.44,20.16) 22.44,20.22 R4370.2 ; C122.2 v2(12.42,109.34) ; v2(34.16,34.98) 34.18,34.98 34.18,34.97 34.13,34.97 33.87,34.7 C1233.2 ; R3832.2 v2(39.19,75.15) ; v2(109.61,142.73) 109.33,143.01 Q24.5 ; PR202.1 173.16,15.84 v2(173.67,16.34) 173.65,16.34 PR201.1 ; TP66.1 156.78,15.04 v2(155.12,15.04) ; R4239.1 v2(79.22,135.39) ; R3803.2 9.84,43.09 v2(9.55,43.37) ; v2(72.97,110.05) 72.96,110.05 C128.2 ; v2(94.23,142.77) 94.67,143.22 R4251.1 ; U71.7 175.6,120.23 v2(175.1,119.74) ; v2(55.78,43.89) C1157.2 R3905.2 ; C1230.2 v2(19.44,17.72) ; C1137.2 v2(30.86,75.2) ; v2(193.22,112.93) 193.22,113.46 193.59,113.84 U103.7 ; v2(102.18,136.27) 102.42,136.27 102.94,136.28 R4287.2 ; v2(115.21,36.5) 115.21,36.63 115.65,37.06 C972.2 ; v2(25.23,111.27) 25.16,111.27 24.64,110.75 C49.2 ; v2(60.76,70.99) R2969.2 ; U104.7 92.21,57.23 91.75,56.77 v2(91.75,56.01) ; C1146.2 v2(45.77,75.18) ; C1149.2 v2(30.38,94.41) ; R18.2 v2(14.93,25.48) ; R3052.2 v2(67.68,20.02) ; R3845.2 v2(25.55,41.66) ; C1143.2 v2(24.54,41.66) ; C1140.2 v2(38.18,75.15)
  TOP w0.457: U34.AF4 v6(167.59,73.02) ; U34.A6 v6(169.59,99.02) ; U34.R6 v6(169.59,85.02) ; U34.AP30 v6(194.59,65.02) ; U34.K24 v6(188.59,90.02) ; U34.AE8 v6(172.59,75.02) U34.AD9 ; U34.K14 v6(177.59,90.02) ; J38.G3 138.33,134.3 v2(138.56,134.53) ; U34.AH17 v6(180.59,71.02) ; U34.J23 v6(187.59,91.02) U34.H23 ; U34.M24 v6(187.59,87.02) U34.N23 U34.P22 v6(185.59,85.02) U34.R21 v6(184.59,84.02) U34.T20 ; U34.AR25 v6(189.59,64.02) ; U34.AP17 v6(180.59,65.02) ; U34.P7 U34.N6 v6(169.59,87.02) ; U34.AU16 180.59,63.02 v6(180.59,63.02) U34.AT16 ; U34.AK18 v6(182.59,70.02) U34.AJ19 ; U34.AD11 v6(175.59,76.02) U34.AC12 ; U34.AH5 v6(168.59,71.02) ; U34.AJ14 v6(177.59,70.02) U34.AK13 ; U34.J16 v6(179.59,91.02) ; U34.AT35 v6(199.59,63.02) ; U34.Y11 v6(174.59,79.02) ; U34.K1 v6(165.59,89.02) U34.K2 ; U34.P20 v6(184.59,86.02) U34.N21 U34.M22 v6(186.59,88.02) ; U34.AH23 v6(187.59,71.02) ; R2921.2 v2(186.72,121.36) ; U34.F31 v6(195.59,94.02) ; U34.AR16 180.59,64.02 v6(180.59,64.02) ; U34.C16 v6(179.59,97.02) ; U34.AF20 v6(184.59,73.02) U34.AG21 ; U34.AK9 v6(173.59,70.02) U34.AJ10 ; U34.N3 v6(166.59,86.02) ; U34.AE3 v6(166.59,74.02) ; U34.K23 v6(187.59,90.02) ; v6(190.65,85.98) 190.55,85.98 U34.P26 U34.R25 v6(188.59,84.02) U34.T24 v6(187.59,83.02) U34.U23 v6(186.59,82.02) U34.V22 ; U34.AH22 v6(186.59,71.02) ; Q9.1 80.56,28.84 v2(81.46,27.95) ; U34.T12 v6(175.59,84.02) ; U34.AD26 v6(190.59,75.02) ; U34.AR20 v6(184.59,64.02) ; C137.2 147.82,111.48 v2(147.67,111.33) ; U34.AF18 v6(181.59,73.02) ; U34.AU34 v6(198.59,62.02) ; U34.W10 v6(173.59,80.02) ; U34.AT34 v6(198.59,63.02) ; U34.AH8 v6(172.59,72.02) U34.AG9 ; v6(179.59,64.02) 179.59,64.02 U34.AR15 ; U34.AA8 v6(172.59,79.02) U34.Y9 ; v2(187.67,125.96) 187.18,126.44 R2924.2 ; U34.J15 v6(178.59,91.02) U34.H14 ; U34.K19 v6(182.59,90.02) ; U34.C18 v6(181.59,97.02) ; U34.D14 v6(177.59,96.02) ; v6(178.59,72.02) U34.AG15 U34.AF16 v6(180.59,74.02) U34.AE17 U34.AD18 v6(182.59,76.02) U34.AC19 ; U34.AM34 v6(198.59,68.02) U34.AL34 ; U34.AK24 v6(188.59,70.02) U34.AJ24 ; U34.V36 200.09,81.52 v6(199.59,82.02) U34.V35 ; U34.F15 v6(178.59,94.02) ; U34.AR27 v6(191.59,64.02) ; U34.M8 v6(172.59,87.02) U34.N8 ; U34.V20 v6(184.59,82.02) U34.U21 v6(185.59,83.02) U34.T22 U34.R23 v6(187.59,85.02) U34.P24 U34.N25 v6(189.59,87.02) ; U34.C11 v6(174.59,97.02) ; U34.AB31 v6(195.59,77.02) ; U34.D16 v6(179.59,96.02) ; U34.AH21 v6(185.59,71.02) ; U34.L8 v6(172.59,88.02) U34.M9 ; U34.AC35 v6(199.59,76.02) ; U34.D26 v6(190.59,96.02) ; U34.W23 v6(187.59,80.02) U34.Y24 v6(188.59,79.02) U34.AA25 U34.AB26 v6(190.59,77.02) ; U34.W8 v6(171.59,80.02) ; v6(189.59,72.02) U34.AG25 v6(188.59,73.02) U34.AF24 v6(187.59,74.02) U34.AE23 v6(186.59,75.02) U34.AD22 U34.AC21 v6(184.59,77.02) U34.AB20 ; U34.C27 v6(191.59,97.02) ; U34.AF10 v6(173.59,73.02) ; U34.K5 v6(168.59,90.02) ; U34.AA6 v6(169.59,78.02) ; J4.G1 18.33,130.03 v2(18.11,129.81) ; U34.L17 v6(180.59,89.02) ; U34.K8 v6(172.59,89.02) U34.L9 ; U34.AA19 v6(182.59,78.02) U34.AB18 U34.AC17 v6(180.59,76.02) U34.AD16 U34.AE15 v6(178.59,74.02) U34.AF14 ; U34.C22 v6(186.59,97.02) ; U34.D12 v6(175.59,96.02) ; U34.J13 v6(176.59,91.02) U34.H12 ; U34.AP25 v6(189.59,65.02) ; U34.AB9 v6(172.59,77.02) U34.AC8 ; U34.M20 v6(184.59,88.02) ; U34.AF12 v6(175.59,73.02) ; U34.Y36 v6(200.59,79.02) ; U34.F6 v6(169.59,94.02) ; U34.H22 v6(186.59,91.02) U34.J22 ; v6(176.59,74.02) U34.AE13 U34.AD14 v6(178.59,76.02) U34.AC15 U34.AB16 v6(180.59,78.02) U34.AA17 U34.Y18 v6(182.59,80.02) U34.W19 ; U34.W15 v6(178.59,80.02) U34.Y14 v6(177.59,79.02) U34.AA13 v6(176.59,78.02) U34.AB12 v6(175.59,77.02) ; U34.L18 v6(181.59,89.02) ; U34.W4 v6(167.59,80.02) ; U34.F34 v6(198.59,94.02) ; U34.T29 v6(193.59,84.02) ; U34.AD4 v6(167.59,75.02) ; U34.AC25 v6(189.59,76.02) ; U34.U17 v6(180.59,83.02) ; U34.N13 v6(177.59,86.02) U34.P14 U34.R15 v6(179.59,84.02) U34.T16 ; U34.AE25 v6(188.59,75.02) U34.AD24 U34.AC23 v6(186.59,77.02) U34.AB22 U34.AA21 v6(184.59,79.02) U34.Y20 ; U34.Y37 v6(201.59,79.02) ; U34.AH1 v6(164.59,71.02) ; U34.AG19 v6(182.59,72.02) ; U34.B6 v6(169.59,98.02) ; U34.N29 v6(193.59,87.02) ; U34.AP10 v6(173.59,65.02) ; U34.G34 v6(198.59,93.02) ; U34.AH13 v6(177.59,72.02) U34.AG14 ; v2(20.95,47.15) 20.96,47.13 C1162.2 ; U34.AD20 v6(184.59,75.02) U34.AE21 ; U34.D28 v6(192.59,96.02) ; U34.AG3 v6(166.59,72.02) ; U34.AM24 v6(188.59,67.02) ; U34.AU7 v6(170.59,62.02) ; U34.E4 v6(167.59,95.02) ; U34.A4 v6(167.59,99.02) ; U34.A34 v6(197.63,98.06) 198.09,97.59 U34.B34 ; U34.AT7 v6(170.59,63.02) ; U34.P9 v6(173.59,85.02) U34.R10 ; U34.AH10 v6(173.59,71.02) ; U34.AJ4 v6(167.59,70.02) ; U34.AH19 v6(182.59,71.02) ; U34.AK11 v6(175.59,70.02) U34.AJ12 ; v6(175.59,64.02) 175.59,64.02 U34.AR11 ; U34.V12 v6(175.59,82.02) ; U34.P31 v6(195.59,86.02) ; U34.AF11 v6(174.59,73.02) ; U34.D35 v6(199.59,96.02) ; U34.AB34 v6(198.59,77.02) ; C806.2 v2(77.06,25.43) ; U34.AK6 v6(169.59,69.02) ; U34.V11 v6(174.59,82.02) ; U34.U10 v6(173.59,83.02) U34.T9 ; U34.AM22 v6(186.59,67.02) ; U34.V24 v6(188.59,82.02) U34.U25 ; U34.AH12 v6(175.59,71.02) ; U34.AN7 v6(170.59,66.02) ; U34.AU4 v6(167.59,62.02) ; U34.AL4 v6(167.59,68.02) ; U34.AP32 v6(196.59,65.02) ; U34.N11 v6(174.59,87.02) ; U34.C31 195.09,96.47 v6(195.58,95.98) ; U34.AP8 v6(171.59,65.02) ; U34.AP35 v6(199.59,65.02) ; U34.J9 v6(173.59,90.02) U34.K10 ; U34.R13 v6(177.59,84.02) U34.T14 U34.U15 v6(179.59,82.02) U34.V16 ; U34.AH34 v6(198.59,71.02) U34.AJ35 ; U34.J18 v6(181.59,91.02) U34.H17 ; U34.V37 v6(201.59,82.02) ; U34.AE10 v6(173.59,74.02) ; U34.AF22 v6(186.59,73.02) ; U34.AG16 v6(179.59,72.02) ; U34.AN4 v6(167.59,66.02) ; U34.AA35 v6(199.59,78.02) ; J36.G4 111.03,134.21 110.54,134.7 v2(110.54,134.7) ; U34.H34 v6(198.59,92.02) ; U34.AE35 v6(199.59,74.02) ; U34.AU2 v6(165.59,62.02) ; U34.AP34 v6(198.59,65.02) ; C227.2 66.72,122.5 v2(66.32,122.1) ; U34.AK8 v6(172.59,70.02) U34.AJ9 ; U34.B35 v6(199.59,98.02) ; U34.AA12 v6(175.59,78.02) U34.AB11 ; U34.C9 v6(172.59,97.02) ; U34.Y7 v6(170.59,79.02) ; U34.K22 v6(185.59,89.02) U34.L21 ; U34.B7 v6(170.59,98.02) ; U34.AP3 v6(166.59,65.02) ; U34.AE9 v6(172.59,74.02) U34.AF8 ; U34.D10 v6(173.59,96.02) ; U34.AG22 v6(186.59,72.02) ; U34.AK34 v6(198.59,69.02) ; U34.F22 v6(186.59,94.02) ; U34.L10 v6(173.59,89.02) ; U34.AU3 v6(166.59,62.02) ; U34.W21 v6(185.59,80.02) U34.Y22 v6(186.59,79.02) U34.AA23 U34.AB24 v6(188.59,77.02) ; U34.AR18 v6(182.59,65.02) U34.AP19 ; U34.AK16 v6(180.59,70.02) U34.AJ17 ; v2(66.52,134.9) 66.33,134.71 J36.G1 ; U34.AH15 v6(178.59,71.02) ; U34.AP21 v6(185.59,65.02) ; U34.AP16 v6(179.59,65.02) ; U34.Y35 v6(199.59,79.02) ; U34.AJ15 v6(178.59,70.02) U34.AK14 ; U34.AK21 v6(185.59,70.02) U34.AJ21 ; U34.AJ36 v6(200.59,70.02) ; U34.AK3 v6(166.59,69.02) ; C1168.2 8.45,58.65 v2(8.95,59.15) ; U34.V14 v6(177.59,82.02) U34.U13 v6(176.59,83.02) ; U34.L14 v6(177.59,89.02) U34.K13 ; U34.AJ18 v6(181.59,70.02) U34.AK17 ; U34.F35 v6(199.59,94.02) ; U34.U19 v6(182.59,83.02) U34.T18 U34.R17 v6(180.59,85.02) U34.P16 U34.N15 v6(178.59,87.02) U34.M14 ; U34.AM35 v6(199.59,67.02) ; U34.U8 v6(171.59,83.02) U34.T7 ; U34.K12 v6(175.59,90.02) ; U34.AH24 v6(188.59,71.02) ; U34.W12 v6(175.59,80.02) ; U34.AM6 v6(169.59,67.02) ; U34.AM13 v6(176.59,67.02) ; U34.L3 v6(166.59,88.02) ; U34.W25 v6(189.59,80.02) ; U34.AH9 v6(172.59,71.02) U34.AJ8 ; U34.AT25 v6(189.59,63.02) ; U34.AA28 v6(192.59,78.02) ; U34.G15 v6(178.59,93.02) ; U34.C25 v6(189.59,97.02) ; U34.J11 v6(174.59,91.02) U34.H10 ; U34.AE11 v6(174.59,74.02) ; U34.AC6 v6(169.59,76.02) ; U34.T34 v6(198.59,84.02) ; U34.R19 v6(182.59,85.02) U34.P18 v6(181.59,86.02) U34.N17 v6(180.59,87.02) U34.M16 v6(179.59,88.02) ; U34.D3 v6(166.59,95.02) ; U34.AG12 v6(175.59,72.02) ; C765.2 v2(191.02,145.48) ; U34.Y12 v6(175.59,79.02) ; U34.AH14 v6(177.59,71.02) ; U34.AH4 v6(167.59,71.02) ; U34.AM3 v6(166.59,67.02) ; U34.K20 v6(184.59,90.02) ; U34.AC3 v6(166.59,76.02) ; U34.AE19 v6(182.59,74.02) ; U34.F9 v6(172.59,94.02) ; U34.T4 v6(167.59,84.02) ; R2922.2 v2(187.72,125.01) ; U34.H16 v6(180.59,91.02) U34.J17 ; U34.C24 v6(188.59,97.02) ; U34.K32 v6(196.59,90.02) ; U34.AR9 v6(173.59,64.02) ; U34.U35 v6(199.59,83.02) ; U34.F3 v6(166.59,93.02) ; U34.J37 201.09,90.52 v6(200.59,91.02) U34.J36 ; v6(177.59,64.02) 177.59,64.02 U34.AR13 ; U34.AK22 v6(186.59,70.02) U34.AJ22 ; U34.B25 v6(189.59,98.02) ; U34.AP7 v6(170.59,65.02) ; U34.D25 v6(189.59,96.02) ; U34.AJ37 v6(201.59,70.02) ; U34.AJ13 v6(176.59,70.02) U34.AK12 ; U34.K11 v6(174.59,90.02) ; U34.AH25 v6(189.59,71.02) ; U34.D23 v6(187.59,96.02) ; U34.AH18 v6(181.59,71.02) ; U34.AR22 v6(186.59,64.02) ; U34.H35 v6(199.59,92.02) ; U34.AA10 v6(173.59,78.02) ; U34.AG35 v6(199.59,72.02) ; U34.V9 v6(172.59,82.02) ; U34.J10 v6(173.59,91.02) U34.H9 ; U34.AJ16 v6(179.59,70.02) ; U34.F20 v6(184.59,94.02) ; U34.AE12 v6(175.59,74.02) ; J36.G3 90.33,134.41 v2(90.62,134.69) ; U34.AA3 v6(166.59,78.02) ; U34.AR34 v6(198.59,64.02) ; U34.K4 v6(167.59,90.02) ; U34.AT3 v6(166.59,63.02) ; U34.W3 v6(166.59,80.02) ; U34.AD34 v6(198.59,75.02) ; U34.AJ23 v6(187.59,70.02) U34.AK23 ; U34.K6 v6(169.59,90.02) ; U34.V18 v6(181.59,82.02) ; U34.T11 v6(175.59,83.02) U34.U12 ; U34.J35 v6(199.59,91.02) ; U34.AE29 v6(193.59,74.02) ; U34.L35 v6(199.59,89.02) ; U34.AK26 v6(190.59,70.02) U34.AJ26 ; U34.R12 v6(175.59,85.02) ; U34.AG11 v6(174.59,72.02) ; U34.K15 v6(178.59,90.02) ; U34.AU6 v6(169.59,62.02) ; U34.M34 v6(198.59,88.02) ; U34.AP14 v6(177.59,65.02) ; U34.K25 v6(189.59,90.02) ; U34.AG6 v6(169.59,72.02) ; U34.H11 v6(175.59,91.02) U34.J12 ; U34.J4 v6(167.59,91.02) ; U34.E34 v6(198.59,95.02) ; U34.AG8 v6(172.59,73.02) U34.AF9 ; U34.L19 v6(182.59,89.02) ; U34.C4 v6(167.59,97.02) ; U34.AN16 v6(179.59,66.02) ; U34.V32 v6(196.59,82.02) ; U34.V4 v6(167.59,82.02) ; U34.C29 v6(193.59,97.02) ; U34.AP26 v6(190.59,65.02) ; U34.AP12 v6(175.59,65.02) ; U34.A16 v6(179.59,99.02) ; U34.W1 v6(164.59,80.02) ; U34.U3 v6(166.59,82.02) ; C228.2 66.28,120.72 v2(65.94,120.39) ; v6(196.58,95.98) 196.12,95.52 U34.D32 ; U34.AG23 v6(187.59,72.02) ; U34.AM9 v6(172.59,67.02) ; U34.L24 v6(188.59,89.02) 189.09,88.52 U34.L25 ; U34.AH32 v6(196.59,71.02) ; U34.H3 v6(166.59,91.02) ; U34.F18 v6(181.59,94.02) ; U34.F11 v6(174.59,94.02) ; U34.AU5 v6(168.59,62.02) ; U34.AG10 v6(173.59,72.02) ; U34.C7 v6(170.59,97.02) ; U34.J19 v6(182.59,91.02) U34.H18 ; U34.K18 v6(181.59,90.02) ; U34.W17 v6(180.59,80.02) U34.Y16 U34.AA15 v6(178.59,78.02) U34.AB14 U34.AC13 v6(176.59,76.02) U34.AD12 v6(175.59,75.02) ; U34.AM31 v6(195.59,67.02) ; U34.L23 v6(187.59,89.02) ; U34.W13 v6(176.59,80.02) ; U34.AR7 v6(170.59,64.02) ; U34.AK15 v6(178.59,69.02) ; U34.AG18 v6(181.59,72.02) ; U34.AP6 v6(169.59,65.02) ; U34.AE6 v6(169.59,74.02) ; Q9.4 v2(78.85,26.29) ; U34.H15 v6(178.59,92.02) ; U34.AU25 v6(189.59,62.02) ; U34.C33 v6(197.59,97.02) ; U34.E16 v6(179.59,95.02) ; U34.A7 v6(170.59,99.02) ; U34.AL15 v6(178.59,68.02) ; U34.N12 v6(175.59,87.02) ; v2(135.41,130.88) 135.41,131.52 135.03,131.89 J38.G2 ; U34.AR4 v6(167.59,64.02) ; U34.D21 v6(185.59,96.02) ; U34.AH2 v6(165.59,71.02) ; U34.N19 v6(182.59,87.02) U34.M18 v6(181.59,88.02) ; U34.AK10 v6(174.59,70.02) U34.AJ11 ; U34.K17 v6(180.59,90.02) ; U34.AN25 v6(189.59,66.02) ; U34.AM27 v6(191.59,67.02) ; U34.K3 v6(166.59,89.02) ; U34.P11 v6(174.59,86.02) ; U34.K16 v6(179.59,90.02) ; U34.B3 v6(166.59,97.02) ; U34.M10 v6(173.59,88.02) ; U34.F24 v6(188.59,94.02) ; U34.C34 v6(198.59,97.02) ; U34.H24 v6(188.59,91.02) U34.J24 ; U34.G4 v6(167.59,93.02) ; U34.C20 v6(184.59,97.02) ; U34.J21 v6(185.59,91.02) U34.H21 ; U34.AH11 v6(174.59,71.02) ; U34.E7 v6(170.59,95.02) ; U34.AH6 v6(169.59,71.02) ; U34.AB7 v6(170.59,77.02) ; U34.V26 v6(190.59,82.02) ; U34.AK35 v6(199.59,69.02) ; U34.H6 v6(169.59,92.02) ; U34.V7 v6(170.59,82.02) ; U34.H13 v6(177.59,91.02) U34.J14 ; U34.K21 v6(185.59,90.02) ; U34.T26 v6(190.59,84.02) ; U34.AM29 v6(193.59,67.02) ; U34.AG17 v6(180.59,72.02) ; U34.AB4 v6(167.59,77.02) ; U34.J8 v6(172.59,90.02) U34.K9 ; U34.H8 v6(172.59,91.02) ; U34.U6 v6(169.59,83.02) ; U34.L16 v6(179.59,89.02) ; U34.K29 v6(193.59,90.02) ; U34.R8 v6(171.59,85.02) ; U34.W6 v6(169.59,80.02) ; U34.E25 v6(189.59,95.02) ; U34.AP28 v6(192.59,65.02) ; U34.W5 v6(168.59,80.02) ; U34.AF34 v6(198.59,73.02) ; U34.AG24 v6(188.59,72.02) ; U34.A25 v6(189.59,99.02) ; U34.D30 v6(194.59,96.02) ; U34.AC10 v6(173.59,76.02) ; U34.D6 v6(169.59,96.02) ; U34.A2 v6(165.59,99.02) ; U34.C15 v6(178.59,97.02) ; U34.AN34 v6(198.59,66.02) ; U34.C13 v6(176.59,97.02) ; U34.L6 v6(169.59,89.02) ; U34.M4 v6(167.59,88.02) ; C952.1 v2(89.6,39.79) ; U34.AR29 v6(193.59,64.02) ; U34.AM20 v6(184.59,67.02) ; U34.AT6 v6(169.59,63.02) ; U34.P34 v6(198.59,86.02) ; U34.M12 v6(175.59,88.02) ; U34.L15 v6(178.59,89.02) ; U34.Y31 v6(195.59,79.02) ; U34.P12 v6(175.59,86.02) ; U34.F27 v6(191.59,94.02) ; U34.H19 v6(182.59,92.02) ; U34.B16 v6(179.59,98.02) ; U34.N10 v6(173.59,87.02) U34.N9 ; U34.AH20 v6(184.59,71.02) ; U34.F13 v6(176.59,94.02) ; U34.Y4 v6(167.59,79.02) ; U34.AR31 v6(195.59,64.02) ; U34.AD7 v6(170.59,75.02) ; U34.D34 v6(198.59,96.02) ; U34.N35 v6(199.59,87.02) ; U34.A3 v6(166.59,99.02) ; U34.D7 v6(170.59,96.02) ; U34.F29 v6(193.59,94.02) ; U34.AH16 v6(179.59,71.02) ; U34.R3 v6(166.59,84.02) ; U34.W2 v6(165.59,80.02) ; U34.A5 v6(168.59,99.02) ; U34.K34 v6(198.59,90.02) ; U34.AH3 v6(166.59,71.02) ; U34.R35 v6(199.59,85.02) ; U34.M11 v6(174.59,88.02) ; U34.L11 v6(174.59,89.02) ; U34.Y26 v6(190.59,79.02) ; U34.AP23 v6(187.59,65.02) ; U34.AR24 v6(188.59,64.02) ; U34.AR33 v6(197.59,64.02) ; U34.L12 v6(175.59,89.02) ; U34.D19 v6(182.59,96.02)
  TOP w0.508: R3585.2 58.35,49.39 v2(58.19,49.23) ; v2(10.95,57.15) 10.55,57.55 C1201.2 ; C224.2 66.87,123.52 v2(66.33,122.98) ; v2(161.6,17.68) 161.69,17.77 PR122.1 ; R3599.2 v2(77.37,64.45) ; U34.AM15 v6(178.59,67.02) ; R2920.2 v2(171.6,120.22) ; v2(9.95,46.15) 10.31,46.5 C1189.2 ; C163.2 39.46,121.89 v2(39.84,121.89) ; v2(29.16,79.82) 28.8,80.17 R3872.2 ; R3598.2 v2(77.34,62.92) ; v2(36.2,117.64) 35.88,117.96 C1085.2 ; C1093.2 134.93,119.49 v2(134.99,119.55) ; v2(125.09,110.6) C134.2 ; C1195.2 9.32,57.51 v2(9.95,58.15) ; U34.AK19 v6(182.59,70.02) ; v2(22.95,45.15) 22.53,44.72 C1169.2 ; Y2.4 v2(110.9,37.48) ; R3281.1 R3282.1 206.19,104.42 v2(206.5,104.73) ; R3859.2 44.2,60.63 v2(44.1,60.54) ; R3916.2 v2(8.97,43) ; J58.G2 2.39,35.15 3.25,36.02 v2(3.25,36.25) ; v2(20.82,64.27) 20.65,64.44 R3807.2 ; R3158.1 205.43,82.31 v2(204.93,81.81) 204.93,81.8 205.44,81.29 R3153.1 R3156.1 R3150.1 ; v2(204.88,89.23) 204.88,89.26 205.39,89.77 R4076.2 ; C951.2 C950.2 v2(184.32,120.22) ; 204.96,84.06 204.96,83.98 205.55,83.39 R3159.1 ; 204.96,84.06 v2(204.91,84.06) ; 204.96,84.06 205.36,84.45 R3157.1 ; J4.G2 39.03,131.29 v2(38.55,130.81) ; v2(49.73,109.78) 49.51,110 C125.2 ; C1089.2 v2(88.2,119.89) ; C131.2 98.97,110.28 v2(98.68,109.99) ; SW6.4 168.59,143.75 v2(168.74,143.9) ; U34.H26 v6(190.59,92.02) ; v2(42.25,123.82) 42.55,123.52 C156.2 ; R3130.2 v2(171.6,114) ; v2(15.85,28.93) 16.1,29.19 U6.4 ; v2(16.55,80.93) 16.13,80.93 16.13,80.93 C121.2 ; v2(114.75,134.75) 114.33,134.33 J38.G1 ; U34.AM11 v6(174.59,67.02) ; R3582.2 51.83,59.15 v2(51.41,59.15) ; v2(9.14,35.97) 8.76,36.35 C1170.2 ; R3820.2 29.29,60.53 v2(29.2,60.43) ; R3579.2 v2(51.39,63.41) ; C1180.2 v2(5.22,74.1) ; J38.G4 159.03,130.83 v2(158.86,130.66) ; PC110.2 185.29,13.76 v2(185.58,13.48) ; U92.8 v2(41.06,70.9) ; C1166.2 19.49,54.61 v2(18.95,55.15) 18.5,55.6 C1192.2 ; U34.J26 v6(190.59,91.02) ; U56.4 175.29,114.38 v2(174.9,114) ; C1161.2 13.31,49.51 v2(12.95,49.15) ; R3152.1 205.33,78.13 204.82,77.61 v2(204.82,77.42) 205.17,77.06 R3151.1 ; U34.AM18 v6(181.59,67.02) ; v2(22.95,59.15) 22.54,59.56 C1165.2 ; v2(3.45,41.99) 3.92,42.45 J58.7 ; J36.G2 87.03,131.19 v2(86.72,130.88) ; v2(19.95,56.15) 19.84,56.26 C1197.2 ; v2(12.85,38.46) 13.22,38.82 R15.1 ; C44.1 v2(11.66,37.53) ; C1174.2 185.57,131.46 185.24,131.79 v2(185.24,131.86) ; U34.D17 v6(180.59,96.02) ; J4.G4 63.03,134.03 v2(63.75,134.75) ; OSC1.2 33.07,39.23 v2(33.35,39.51) ; v2(33.12,70.96) 33.47,71.31 U90.8 ; v2(1.53,107.38) 2.06,106.84 J47.G1 ; C1191.2 19.43,48.67 v2(18.95,49.15) 18.63,49.47 C1163.2 ; v2(12.95,55.15) 13.46,55.65 C1160.2 ; R3593.2 v2(77.34,56.06) ; C1196.2 20.97,57.17 v2(20.95,57.15) ; v2(42.31,122.92) 42.72,122.5 C6.2 ; v2(36.34,116.99) 36.34,116.51 ; v2(11.95,51.15) 12.4,51.6 C1193.2 ; R2960.1 64.57,72.18 64.06,71.67 v2(64.06,71.48) ; v2(1.92,43.68) 2.2,43.95 J58.G1 ; U54.2 v2(75.05,27.01) ; U93.8 v2(25.67,90.13) ; J56.G2 v2(3.58,32.57) ; R3600.2 v2(77.37,65.72) ; U63.3 87.44,32.88 v2(87.78,33.22) ; v2(172.91,146.45) 172.66,146.7 SW6.2 ; R3589.2 v2(64.32,49.26) ; R3129.2 v2(186.59,115.85) ; R3581.2 v2(51.39,60.62) ; R3577.2 v2(51.39,66.21) ; R2847.2 v2(12.4,79.15) ; R3597.2 v2(77.34,61.65) ; R3591.2 v2(67.12,49.26) ; R3592.2 v2(68.39,49.26) ; v2(188.49,134.57) 188.85,134.93 J60.5 ; R3580.2 51.65,62.14 51.52,62.01 v2(51.35,62.01) ; R3588.2 v2(62.67,49.26) ; R3583.2 v2(51.5,58.35) ; R3590.2 v2(65.59,49.26) ; U91.8 v2(19.72,36.26) ; C157.2 v2(41.76,121.26) ; v2(161.09,126.15) 161.25,126.32 C1095.2 ; C162.2 38.69,123.39 v2(39.29,122.79) 38.83,122.33 C15.2 ; v2(51.03,56.8) 51.28,56.55 R3584.2 ; U34.AH29 v6(193.59,71.02) ; v2(204.73,74.29) 205.04,73.97 C1222.2 ; C1171.2 v2(8.89,34.37) ; J47.G2 2.24,99.94 v2(1.6,100.58) ; R2918.2 v2(182.96,127.91) ; R3235.2 126.52,42.49 v2(126.9,42.11) ; C1198.2 20.19,51.91 v2(20.95,51.15) ; R2919.2 v2(171.6,124.28) ; v2(68.3,26.24) 68.26,26.28 C975.1 ; R3048.2 v2(82.62,17.78) ; R3160.1 v2(204.84,87.56) ; R3149.1 207.63,62.95 v2(207.63,59.67) ; R3578.2 v2(51.39,64.94) ; J56.G1 v2(3.48,26.97) ; U34.D8 v6(171.59,96.02) ; R3586.2 v2(59.62,49.26) ; R3131.2 172.16,117.04 v2(171.66,117.55) 172.17,118.06 R3132.2 ; R3833.2 v2(36.6,60.57) ; U34.AE32 v6(196.59,74.02) ; U88.8 v2(17.95,74.75) ; SW6.3 v2(172.9,143.75) ; C1091.2 v2(111.03,119.39) ; R3155.1 v2(204.8,86.53) ; U34.W28 v6(192.59,80.02) ; C1087.2 v2(64.17,120) ; R2971.2 v2(57.63,70.89) ; R3595.2 v2(77.34,58.86) ; U89.8 26.15,72.88 v2(25.84,73.18) ; C964.2 v2(114.97,41.86) ; R3594.2 v2(77.34,57.33) ; v2(204.91,85.51) R3154.1 ; R3596.2 v2(77.34,60.13) ; R3587.2 v2(61.4,49.26) ; U34.P4 v6(167.59,86.02)
  IN2 w0.254: v2(66.41,113.35) 65.44,112.38 65.44,109.57 71.49,103.52 73.37,103.52 74.51,104.66 76.5,104.66 78.56,103.81 80.84,101.52 88.38,98.4 91.86,98.4 93.38,96.88 99.14,96.88 v2(100.31,95.71) ; v2(183.57,15.25) 184.38,14.45 184.38,12.55 179.05,7.22 173.88,7.22 172.07,5.41 172.07,4.54 172.37,4.24 172.72,4.24 v2(172.84,4.37) ; v2(181.76,33.53) 182.27,33.02 182.27,32.37 182.27,32.37 182.27,28.65 181.58,27.95 181.58,24.48 187.22,18.85 187.22,15.98 186.65,15.42 186.15,15.42 v2(186.04,15.54)
  BOTTOM w0.203: 98.09,114.85 98.09,114.38 98.33,114.14 U82.C1 ; 149.75,117.72 149.9,117.57 U84.C1 ; v2(25.2,113.39) 25.66,113.39 U79.C1 ; v2(47.33,114.44) 47.9,115.01 U80.C1 ; v2(120.59,116.22) 121.78,116.22 122.1,115.91 122.1,114.68 122.33,114.46 U83.C1
  BOTTOM w0.254: v2(172.16,129.5) 172.44,129.22 R4125.2 ; R4113.2 v2(70.89,144.01) ; C1251.2 182.63,116.29 v2(182.66,116.25) ; C603.2 198.52,77.09 v6(198.59,77.02) ; v2(131.17,139.57) J8.A51 ; v2(100.31,95.71) 100.31,95.32 106,89.63 106,49.27 105.11,48.37 105.11,35.58 107.84,32.85 107.84,17.22 100.04,9.43 100.04,6.07 104.3,1.81 170.29,1.81 v2(172.84,4.37) ; v2(36.67,139.59) 36.67,139.59 J6.A45 ; v2(35.94,44.55) C1125.2 ; v2(143.17,139.57) J8.A3 ; J8.A57 129.67,139.69 v2(129.79,139.57) ; v2(167.07,139.55) 167.17,139.66 J8.B3 ; J34.B51 v2(107.17,139.57) ; v2(158.23,130.89) 158.42,131.08 158.42,133.22 J8.B38 ; J6.B9 69.67,139.59 v2(69.67,139.59) ; v2(105.28,139.66) 105.67,140.05 J34.B57 ; v2(90.8,139.47) 90.67,139.6 J34.A21 ; v2(54.36,142.02) 54.17,141.83 J6.B71 ; v2(63.67,139.59) 63.67,139.59 J6.B33 ; J6.A51 v2(35.17,139.59) ; v6(193.59,84.02) 193.78,83.83 193.78,82.75 194.23,82.3 C607.2 ; v2(179.55,115.68) 179.92,115.31 C1250.2 ; J34.B21 114.67,140.57 v2(114.67,139.57) ; v2(93.67,139.54) J34.A9 ; v6(190.65,85.98) 190.95,86.27 R3004.1 ; v2(140.17,139.57) J8.A15 ; R4112.2 v2(69.19,143.96) ; J34.B9 v2(117.67,139.57) ; J34.A33 87.67,139.61 v2(87.81,139.46) ; J6.A27 41.17,140.77 v2(41.17,139.59) ; J6.A71 v2(30.17,142.47) ; J6.A33 39.67,140.77 v2(39.67,139.59) ; v2(84.67,139.57) J34.A45 ; J8.B21 v2(162.67,139.57) ; J6.A15 44.17,140.77 v2(44.17,139.59) ; R4100.2 22.64,132.52 v2(22.93,132.24) ; v2(47.33,142.14) 47.67,141.81 J6.A1 ; v2(45.67,139.59) 45.67,140.77 J6.A9 ; J6.A38 38.42,134.62 38.57,134.77 39.43,134.77 v2(39.47,134.8) 39.92,134.35 J6.A32 ; v2(125.17,139.58) J8.A75 ; J6.B51 v2(59.17,139.59) ; R4120.2 v2(141.33,143.61) ; R3846.2 v2(23.04,34.04) ; J6.B1 71.67,142.01 v2(71.67,142.01) ; v2(83.17,139.57) J34.A51 ; v2(132.67,139.57) J8.A45 ; J8.B27 v2(161.17,139.57) ; U81.C1 72.27,113.73 v2(72.1,113.56) ; J6.B39 v2(62.17,139.59) ; v2(92.17,139.57) J34.A15 ; v2(99.96,32.46) 103.48,32.46 104.7,31.23 104.7,21.77 105.61,20.87 v2(106.69,20.87) ; v6(195.59,79.02) 195.78,79.21 C609.2 ; C592.2 199.23,82.38 v6(199.59,82.02) ; R4124.2 v2(171.38,129.49) ; J34.B3 119.17,139.81 v2(119.43,139.56) 119.67,139.8 J34.B1 ; C1249.2 178.41,114.68 178.09,115 v2(178.09,115.28) ; R4128.2 v2(148.85,143.62) ; v2(126.33,139.59) 126.17,139.75 J8.A71 ; J8.B39 v2(158.17,139.57) ; v2(89.04,139.47) 89.17,139.6 J34.A27 ; U101.9 79.54,54.3 77.78,56.06 v2(77.34,56.06) ; R4129.2 v2(145.41,143.64) ; v2(95.17,139.57) J34.A3 ; R3005.1 194.12,71.02 v6(193.59,71.02) ; J6.B45 60.67,139.59 v2(60.67,139.59) ; R4108.2 v2(61.11,144.04) ; v2(141.67,139.57) J8.A9 ; J34.B27 v2(113.17,139.57) ; J8.B33 v2(159.67,139.57) ; v6(178.59,69.02) 178.65,69.08 C688.2 ; J6.A3 47.17,141.58 46.61,142.14 v2(46.32,142.14) ; J8.B45 v2(156.67,139.57) ; v2(33.45,139.57) 33.67,139.79 J6.A57 ; C1126.2 36.2,43.36 v2(35.92,43.08) ; J8.B57 v2(153.67,139.57) ; v2(28.73,142.23) 29.17,141.79 J6.A75 ; J6.B15 v2(68.17,139.59) ; J34.B33 v2(111.67,139.57) ; R4109.2 v2(63.02,144.04) ; J34.B75 v2(101.17,139.57) ; J8.B51 v2(155.17,139.57) ; R4104.2 v2(53.87,143.99) ; v2(138.67,139.57) J8.A21 ; v2(77.17,139.57) J34.A75 ; R4141.2 v2(65.35,143.33) ; J34.A1 95.67,139.69 95.75,139.61 v2(95.75,139.21) ; J8.B15 v2(164.17,139.57) ; J8.B71 v2(150.17,139.57) ; v6(196.59,71.02) 195.74,71.87 C601.2 ; v2(135.67,139.57) J8.A33 ; v2(81.67,139.57) J34.A57 ; J34.B15 v2(116.17,139.57) ; R4105.2 v2(51.97,143.99) ; J34.A39 86.17,139.6 v2(86.03,139.46) ; J8.B75 v2(149.17,139.57) ; J6.A39 38.17,140.77 v2(38.17,139.59) ; J8.B9 v2(165.67,139.57) ; J6.B75 53.17,141.63 v2(52.8,142) ; R4121.2 v2(144.72,143.58) ; J6.A21 42.67,140.77 v2(42.67,139.59) ; J6.B3 v2(71.17,139.59) ; v2(78.17,139.57) J34.A71 ; C612.2 197.38,79.33 v2(197.61,79.1) ; R4140.2 v2(67,143.32) ; v2(171.26,18.29) 171.47,18.08 171.47,17.89 172.32,17.03 172.32,16.47 171.6,15.75 171.6,15.18 170.86,14.43 170.86,12.02 174.65,8.23 179.33,8.23 185.42,14.32 185.42,15.69 185.96,16.24 185.96,23.06 187.48,24.57 191.16,24.57 194.31,27.72 194.31,32.28 194.63,32.59 194.99,32.59 v2(195.15,32.43) ; v2(137.17,139.57) J8.A27 ; v2(134.17,139.57) J8.A39 ; R4137.2 v2(72.52,144.04) ; R4101.2 24.64,132.44 v2(24.43,132.24) ; R4136.2 v2(74.19,144.04) ; J6.B21 66.67,139.59 v2(66.67,139.59) ; v2(57.67,139.59) 57.67,139.59 J6.B57 ; J34.B39 v2(110.17,139.57) ; J34.B45 v2(108.67,139.57) ; J6.B27 v2(65.17,139.59)
  BOTTOM w0.279: v6(193.59,87.02) 193.2,87.02 C605.2 ; v2(83.11,114.28) 83.11,112.94 83.3,112.76 83.59,112.76 U30.6 ; C617.2 200,86.61 v6(199.59,87.02) ; v6(199.59,85.02) 199.95,84.66 C616.2 ; R3256.1 192.2,83.17 191.7,82.67 C596.2 191.24,82.67 v6(190.59,82.02) 190.06,82.55 C556.2 ; v2(98.48,42.19) 98.15,41.87 R3.2 ; C604.2 196.11,89.54 v6(196.59,90.02) 197.03,89.58 C597.2 ; U32.6 133.12,113.33 132.76,113.33 132.62,113.47 v2(132.62,114.73) ; C594.2 197.3,86.7 197.42,86.58 198.03,86.58 v6(198.59,86.02) ; v2(58.63,112.52) 59.39,112.52 59.58,112.71 U29.6 ; v6(198.59,88.02) 198.4,88.21 198.31,88.21 C595.2 ; C676.2 193.22,91.68 C666.2 193.42,91.68 C721.2 ; U31.6 109.27,112.84 108.96,112.84 108.8,113 108.8,114.24 v2(108.69,114.36) ; v2(167.75,139.53) 167.66,139.63 167.66,140.76 J8.B1 ; v2(159.99,117.76) 160.19,117.57 160.19,116.43 160.41,116.2 160.88,116.2 U33.6 ; C1247.2 62.03,116.88 v2(62.22,117.06) ; U2.10 v2(98.62,34.17) ; C613.2 200,88.61 v6(199.59,89.02) ; v6(199.59,91.02) 199.59,90.53 200,90.12 C615.2
  BOTTOM w0.305: v6(188.59,70.02) 188.42,69.85 C689.2 ; v6(172.59,87.02) 172.13,87.48 C730.2 ; C694.2 180.21,69.4 v6(179.59,70.02) ; C685.2 171.88,69.31 v6(172.59,70.02) 172.46,70.15 C664.2 ; C621.2 171.04,83.56 v6(171.59,83.02) 172.16,83.59 C625.2 ; v6(172.59,79.02) 172.06,78.49 C639.2 ; v6(189.59,95.02) 190,94.61 C674.2 ; C662.2 172.55,71.98 v6(172.59,72.02) ; C557.2 179.2,73.41 v6(178.59,74.02) 179.25,74.68 C567.2 ; C634.2 171.99,85.42 v6(171.59,85.02) ; C680.2 186.06,71.55 v6(186.59,71.02) ; C578.2 182.04,84.48 v6(182.59,85.02) 183.15,84.46 C577.2 ; v2(159.8,134.52) 159.92,134.4 J8.B32 ; v2(87.78,134.63) 87.92,134.48 J34.A32 ; C693.2 181.24,69.37 v6(180.59,70.02) ; C632.2 172.97,86.4 v6(173.59,87.02) ; C630.2 173.15,81.46 v6(172.59,82.02) ; v6(188.59,75.02) 188.04,75.56 C562.2 ; v6(178.59,80.02) 178.01,80.6 C584.2 ; v6(190.59,70.02) 190.32,69.75 C687.2 ; C575.2 182.96,80.39 v6(182.59,80.02) 182.07,80.54 C580.2 ; C723.2 174.22,69.65 v6(174.59,70.02) ; C626.2 172.13,80.56 v6(171.59,80.02) ; C656.2 177.04,89.56 v6(177.59,89.02) ; v6(184.59,73.02) 184.26,73.35 C549.2 ; v6(171.59,85.02) 171.06,84.49 C631.2 ; v6(171.59,85.02) 171.04,85.56 C635.2 C628.2 ; C623.2 C629.2 171.12,81.49 v6(170.59,82.02) ; C724.2 173.15,69.58 v6(173.59,70.02) ; C548.2 183.98,81.41 v6(184.59,82.02) 184.18,82.43 C537.2 ; J6.B32 63.92,134.16 v2(64.41,134.65) ; v6(182.59,71.02) 182.82,71.25 C658.2 ; v6(191.59,94.02) 192.18,94.61 C671.2 ; C574.2 184.23,79.38 v6(184.59,79.02) 185.35,78.26 C569.2 ; v6(172.59,75.02) 172.04,75.56 C633.2 ; C558.2 182.91,74.34 v6(182.59,74.02) ; v6(177.59,90.02) 177.12,90.49 C659.2 ; C644.2 172.04,77.56 v6(172.59,77.02) 172.06,76.49 C627.2 ; C568.2 181.25,74.68 v6(180.59,74.02) ; v6(172.59,73.02) 172.46,72.89 C682.2 ; v6(188.59,77.02) 188.59,77.25 188.27,77.56 C554.2 ; C637.2 174.17,80.6 v6(173.59,80.02) ; v6(177.59,82.02) 177.58,82.02 C585.2 ; v6(182.59,72.02) 182.76,72.19 C651.2 ; J34.B38 110.42,133.22 110.42,131.9 110.6,131.72 v2(110.6,130.93) ; C720.2 176.33,69.76 v6(176.59,70.02) ; v6(189.59,90.02) 189.81,89.8 C732.2 ; v6(186.59,70.02) 186.54,69.97 C691.2 ; J34.B71 102.17,139.77 v2(102.42,139.51) ; C599.2 196.61,74.04 v6(196.59,74.02) ; v6(175.59,82.02) 175.16,81.59 C642.2 ; C663.2 172.54,71.07 v6(172.59,71.02) ; v6(192.59,80.02) 192.61,80.05 C611.2 ; J34.A38 86.42,131.96 v2(85.93,131.47) ; C668.2 183.07,91.54 v6(182.59,92.02) ; v6(172.59,74.02) 172.38,73.81 C684.2 ; C669.2 183.11,90.5 v6(182.59,91.02) ; v6(178.59,87.02) 178.04,87.56 C681.2 ; C638.2 175.04,74.57 v6(175.59,74.02) ; C541.2 185.55,80.06 v6(185.59,80.02) ; C665.2 188.04,91.47 v6(187.59,91.02) ; v6(181.59,70.02) 182.29,69.32 C686.2 ; v6(173.59,85.02) 173.08,84.51 C620.2 ; C641.2 175.12,77.49 v6(175.59,77.02) ; v6(175.59,85.02) 175.06,84.49 C636.2 ; v6(193.59,67.02) 193.12,67.49 C717.2 ; v6(187.59,70.02) 187.48,69.91 C690.2 ; C622.2 C624.2 ; C624.2 167.27,81.27 C640.2 167.27,81.34 v6(166.59,82.02) ; C624.2 168.22,81.39 v6(167.59,82.02) ; C728.2 171.9,89.71 v6(172.59,89.02) ; C678.2 177.66,72.09 v6(177.59,72.02) ; J6.B38 62.42,132.38 62.65,132.16 v2(62.65,130.94) ; C722.2 175.29,69.72 v6(175.59,70.02) ; v6(180.59,85.02) 180.04,85.56 C539.2 ; C538.2 187.58,80.03 v6(187.59,80.02) ; C676.2 190.93,91.68 v6(190.59,92.02) ; v6(193.59,94.02) 194.18,94.61 C672.2 ; R2910.2 193.41,90.2 v6(193.59,90.02) ; v6(182.59,76.02) 182.9,76.33 C571.2 ; C550.2 179.27,78.7 v6(178.59,78.02) ; C581.2 181.06,81.49 v6(181.59,82.02) ; v6(172.59,88.02) 172.04,88.57 C729.2 ; C602.2 200.57,70 v6(200.59,70.02) ; C598.2 198.45,73.16 v6(198.59,73.02) ; v6(182.59,83.02) 183.01,83.44 C576.2 ; v6(190.59,82.02) 191.05,81.56 C610.2 ; C551.2 181.28,76.71 v6(180.59,76.02) ; C560.2 186.04,74.48 v6(186.59,75.02) 186.04,75.56 C553.2 ; C543.2 v6(186.59,82.02) ; C555.2 183.16,86.45 v6(182.59,87.02) ; C752.2 186.97,91.4 v6(186.59,91.02) ; C564.2 177.23,76.67 v6(176.59,76.02) ; C692.2 185.6,70.01 v6(185.59,70.02) ; J8.A1 143.67,141.57 v2(144.08,141.97) ; v6(179.59,84.02) 179.04,84.56 C547.2 ; C572.2 184.26,77.35 v6(184.59,77.02) ; C566.2 177.23,74.67 v6(176.59,74.02) ; v6(177.59,71.02) 177.12,71.49 C654.2 ; C677.2 171.85,90.75 v6(172.59,90.02) ; v6(180.59,78.02) 181.3,78.73 C563.2 ; C546.2 175.94,86.66 v6(175.59,87.02) ; C542.2 184.04,85.47 v6(184.59,86.02) ; C583.2 179.03,81.46 v6(179.59,82.02) 179.04,82.56 C579.2 ; C582.2 180.04,80.57 v6(180.59,80.02) ; v2(134.61,130.95) 134.42,131.14 J8.A38 ; C661.2 189.81,80.25 v6(189.59,80.02) 188.87,80.73 C652.2 ; C565.2 179.27,76.7 v6(178.59,76.02) ; C573.2 183.04,78.02 v6(182.59,78.02) ; C545.2 176.19,85.42 v6(175.59,86.02) ; C619.2 175.04,76.56 v6(175.59,76.02) ; v6(175.59,84.02) 175.13,83.56 C618.2 ; v6(175.59,75.02) 175.12,75.49 C643.2 ; v6(195.59,94.02) 196.15,94.59 C670.2 ; v6(184.59,67.02) 184.36,67.25 C679.2 ; v6(186.59,72.02) 186.13,72.48 C675.2 ; C715.2 183.3,69.93 C683.2 182.66,69.95 v6(182.59,70.02) ; C716.2 196.05,67.48 v6(195.59,67.02) 195.14,67.47 C718.2 ; C660.2 177.04,70.57 v6(177.59,70.02) 177.34,69.77 C719.2 ; C667.2 184.58,94.02 v6(184.59,94.02) ; v6(190.59,77.02) 189.9,77.71 C606.2 ; J34.B32 111.92,134.12 112.88,135.09 v2(113.18,135.38) ; C552.2 189.89,74.32 v6(190.59,75.02) ; v6(184.59,75.02) 184.28,75.33 C561.2 ; J8.A32 v2(135.92,134.46)
  BOTTOM w0.381: v2(197.25,9.4) 196.68,9.4 R3124.2 ; v2(48.68,145.32) 48.19,145.32 R4145.2 ; R4280.1 8,92.56 8.38,92.94 v2(8.38,93.12) ; Q49.S v2(11.8,31.07) ; v6(185.59,85.02) 186.17,84.43 C570.2 ; C1245.2 111.3,117.02 v2(111.91,117.02) ; v6(200.59,82.02) 200.59,82.59 201.15,83.16 R3257.1 ; v2(40.54,119.45) 39.82,119.45 39.69,119.33 C1248.2 ; C657.2 183.06,88.55 v6(182.59,89.02) ; v2(36.34,116.99) 36.34,115.43 36.47,115.31 U28.6 ; v2(33.53,88.77) 33.53,89.61 33.88,89.96 C1205.2 ; v5(42.39,46.98) 41.99,46.58 C1123.2 ; R4144.2 48.65,144.12 v2(48.77,144.25) ; C18.2 v2(42.64,129.68) ; v2(18.14,99.92) 18.14,99.56 R94.2 ; C559.2 186.9,86.33 v6(187.59,87.02) ; C1232.1 v2(55.67,14.76) ; v2(5.69,85.17) 6.55,86.03 R4283.1 ; v6(187.59,85.02) 188.2,85.63 C540.2 ; v2(61.72,11.06) 62.04,11.38 U107.3 ; v2(34.12,33.27) 34.12,33.27 34.12,33.29 33.61,32.78 R4369.2 C1235.2 ; U72.7 v2(20.18,90.6) ; R3904.2 C1156.2 51.38,45.94 v2(50.98,45.54) ; R4257.1 v2(30.02,143.21) ; C276.2 140.63,118.58 v2(140.98,118.24) ; C1116.2 37.79,48.33 v6(37.95,48.49) ; v2(116.82,116.83) 116.55,116.56 R4396.2 ; C104.2 22.95,120.02 v2(22.01,119.07) ; C1244.2 v2(135.83,117.46) ; R96.2 23.93,99.6 24.19,99.86 v2(24.28,99.86) ; v2(13.67,70.89) 13.86,71.08 U7.4 ; v2(68.85,116.07) 68.7,116.22 R4398.2 ; v2(140.91,117.35) 140.73,117.53 R4395.2 ; C1252.2 24.08,3.2 v2(23.82,3.46) ; R4253.1 77.9,143.24 v2(78.42,143.76) ; v2(5.89,91.19) 6.22,91.52 R4279.1 ; C593.2 189.25,84.68 v6(188.59,84.02) ; v2(184.28,137.22) 184.05,136.98 C1075.1 184.05,136.54 184.04,136.54 C1223.2 ; v2(7.09,97.43) 7.26,97.26 R4285.1 ; v2(11.33,28.59) 11.49,28.59 11.54,28.54 R4226.1 ; C1115.2 41.13,44.1 v6(40.95,43.92) ; v2(5.99,30.81) 5.42,30.24 Q45.S ; C267.2 39.22,112.97 v2(39.22,112.46) ; R4282.1 v2(2.64,93.78) ; C269.2 68.41,117.28 v2(68.83,116.85) ; C1224.1 v2(1.61,101.8) ; C1107.2 v2(147.49,112.03) ; U58.4 v2(182.68,8.28) ; C274.2 v2(116.77,117.66) ; R4276.1 v2(7.82,84.73) ; v6(198.59,92.02) 198.12,91.55 C673.2 ; v2(43.75,118.88) 43.63,119 R4399.2 43.14,119 C266.2 ; R4218.1 8.91,29.05 v2(9.22,29.05) ; v2(162.04,121.03) 162.69,121.03 163.06,120.66 C1243.2 ; C1083.2 v2(25.01,97.5) ; C1246.2 v2(85.9,117.55) ; C1128.2 44.12,39.42 v2(44.12,39.17) ; C1220.2 v2(5.94,40.57) ; R4275.1 8.99,82.04 v2(8.81,81.86) ; R4281.1 v2(10.43,95.56) ; v2(182.24,124.79) C1082.2 ; D4.4 v2(138.29,41.01) ; C1204.2 98.93,61.4 v2(98.53,61.8) ; Q51.S v2(2.98,101.96) ; C1225.2 v2(2.8,107.94) ; v2(2.67,97.76) 3.11,97.76 R4286.1 ; v2(135.44,110.86) 135.09,110.51 C277.2 ; C92.2 v2(42.68,125.47) ; v2(54.89,142.39) 54.89,142.73 55.17,143.01 R4255.1 ; C1219.1 v2(1.55,41.45) ; v2(6.6,40.56) 6.99,40.18 C1221.1 ; v2(96.56,116.05) 97.06,115.55 98.09,115.55 98.09,114.85 ; v2(149.21,117.46) 149.46,117.72 149.75,117.72 ; R4247.1 v2(150.67,145.07) ; v2(146.11,127.2) 146.11,126.21 145.25,125.35 C177.2 ; U102.7 v2(190.13,110.03) ; v2(74.64,46.59) 75.28,45.95 R4162.1 ; C1218.2 v2(3.12,41.4) ; R4277.1 2.97,77.85 v2(2.92,77.8) ; C172.2 v2(51.46,128.68) ; C653.2 183.12,89.49 v6(182.59,90.02) ; v2(21.03,99.99) 20.88,99.84 R95.2 ; C600.2 v6(193.59,74.02)
  BOTTOM w0.457: C184.2 162.65,130.46 v2(162.26,130.06) ; J34.G1 v2(120.77,138.13) ; U94.N13 v2(20.95,57.15) ; J8.G1 168.77,138.52 v2(169.09,138.2) ; U94.L11 v2(18.95,55.15) ; J8.G2 v2(148.07,138.13) ; U94.H8 v2(14.95,51.15) ; J6.G3 48.77,141.55 v2(48.14,142.17) ; v2(34.61,6.56) 34.1,6.05 J41.116 ; v2(100.62,142.01) 100.07,141.46 J34.G2 ; U94.C14 v2(21.95,46.15) ; C174.2 65.97,124.82 v2(65.97,124.78) ; v2(76.07,138.13) J34.G4 ; U94.E12 v2(18.95,49.15) U94.F11 ; U94.D4 v2(10.95,47.15) ; C198.2 v2(90.65,130.08) ; C94.2 51.79,130.72 v2(51.35,131.15) 50.76,130.56 C168.2 ; U94.H9 v2(16.95,51.15) ; J8.G4 124.07,138.32 v2(124.3,138.09) ; C21.2 50.36,132.02 v2(50.07,132.31) ; U94.P3 v2(9.95,58.15) ; v2(52.07,138.13) J6.G2 ; v2(90.67,126.77) 90.67,125.41 C202.2 ; v2(66.04,130.33) 66.49,130.33 66.67,130.51 C27.2 ; C1.2 v2(99.96,32.46) ; J6.G4 v2(28.07,141.79) ; v2(36.03,6.54) 36.5,6.07 J41.110 ; v2(75.32,127.18) 75.32,126.08 C199.2 ; U94.P14 v2(21.95,58.15) ; U94.L6 v2(12.95,55.15) ; U94.C3 v2(9.95,46.15) ; U94.E5 v2(11.95,48.15) ; U94.J9 v2(16.95,53.15) ; U94.F6 v2(12.95,49.15) ; U94.M5 v2(11.95,56.15) ; v2(144.77,138.13) J8.G3 ; J34.G3 96.77,137.9 97.12,137.55 v2(97.12,136.95) ; U94.B2 v2(8.95,45.15) ; R4249.1 129.39,144.56 v2(130.02,144.56) ; U94.N4 v2(10.95,57.15) ; U94.B15 v2(22.95,45.15) ; U94.M12 v2(19.95,56.15) ; U94.R15 v2(22.95,59.15) ; U94.D13 v2(20.95,47.15) ; U94.J8 v2(14.95,53.15) ; U94.R2 v2(8.95,59.15)
  BOTTOM w0.508: v2(97.26,127.31) 97.12,127.17 C201.2 ; C1119.2 v2(36.22,50.16) ; U8.4 154.07,54.3 153.71,54.66 153.71,55.44 v2(153.96,55.68) ; v2(4.9,91.87) 4.75,91.72 C1185.2 ; J49.45 v2(149.3,10.19) ; J41.38 v2(65.3,5.79) ; v2(119.55,109.11) 119.69,108.96 C1105.2 ; J49.64 v2(142.1,5.77) ; v2(168.99,127.47) 169.12,127.33 C185.2 ; v2(70.84,64.44) 71.24,64.84 R2936.2 ; v2(135.94,5.82) 135.7,5.58 J49.80 ; J41.39 v2(64.5,10.19) ; v2(107.39,10.19) 107.7,9.88 J49.149 ; v2(139.09,5.89) 138.9,5.7 J49.72 ; J49.120 119.7,5.58 v2(119.96,5.84) ; C586.2 184.1,87.53 v6(184.59,88.02) ; C1181.2 4.45,88.56 v2(4.81,88.2) ; R4158.1 v2(85.36,48.6) ; R22.1 163.21,52.04 v2(162.88,51.7) ; v2(70.91,10.84) 71.39,10.84 71.7,10.53 J41.21 ; v2(123.22,5.84) 122.9,5.53 J49.112 ; J49.48 v2(148.5,5.79) ; C39.2 v2(169.23,125.35) ; v2(125.02,5.82) 125.3,5.54 J49.106 ; R3104.2 R3102.2 205.19,74.74 v2(204.73,74.29) ; J49.59 143.7,9.89 v2(144.04,10.24) ; J41.71 v2(51.7,10.19) ; C103.2 v2(44.91,70.86) ; J49.96 129.3,5.58 v2(129.57,5.84) ; C273.2 85.03,109.85 v2(84.79,109.6) ; R2852.2 60,52.81 v2(60.27,53.09) ; C770.2 v2(68.71,68.45) ; v2(16.98,79.08) C45.2 ; v2(109.04,5.87) 109.3,5.61 J49.146 ; v2(100.48,145.95) 101.16,146.63 D1.2 ; v2(110.59,10.24) 110.9,9.93 J49.141 ; J49.28 v2(156.5,5.79) ; J49.66 141.3,5.44 v2(140.97,5.77) ; J41.81 v2(47.7,10.19) ; C1145.2 v2(31.31,86.57) ; R20.1 14.27,81.04 v2(14.78,81.55) ; v2(120.35,128.41) 120.2,128.56 C211.2 ; J41.70 v2(52.5,6.37) ; v2(99.51,130.85) 100.07,130.85 C209.2 ; v2(46.13,28.27) 46.85,29 C1112.2 ; R2939.2 v2(71.55,57.56) 71.53,57.53 R2940.2 ; v2(24.75,84.71) 24.89,84.85 R91.2 ; J41.24 v2(70.9,5.79) ; C178.2 138.66,125.44 v2(138.15,125.96) ; J41.46 v2(62.1,5.79) ; J41.49 v2(60.5,10.19) ; J49.82 134.9,5.49 v2(134.62,5.77) ; v2(160.62,13.5) 160.5,13.38 R3121.2 ; v2(72.77,138.15) 72.77,138.15 J6.G1 ; J41.108 v2(37.3,6.6) ; J41.119 v2(32.5,10.2) ; C171.2 72.8,126.9 v2(72.53,127.18) ; C1141.2 v2(38.98,70.87) ; J41.76 v2(50.1,6.42) ; v2(110.36,5.87) 110.1,5.6 J49.144 ; J41.62 v2(55.7,6.4) ; R2938.2 71.55,61.49 v2(71.5,61.54) R2937.2 ; v2(112.22,5.82) 112.5,5.53 J49.138 ; v2(134.42,10.21) 134.1,9.89 J49.83 ; v2(178.09,115.28) 178.43,115.62 R3433.2 ; v2(113.71,124.35) 114.69,125.33 C214.2 ; C36.2 162.65,126.74 v2(163.12,127.2) ; v2(117.04,10.16) 117.3,9.9 J49.125 ; v2(104.04,5.82) 103.7,5.48 J49.160 ; v2(132.79,5.82) 132.5,5.53 J49.88 ; C203.2 97.07,121.26 v2(97.45,121.63) ; J49.50 v2(147.7,5.79) ; J41.27 v2(69.3,10.19) ; v2(147.52,127.17) 147.76,126.93 C183.2 ; J49.34 v2(154.1,5.79) ; J41.95 v2(42.1,10.42) ; v2(72.86,108.57) 73.11,108.32 C1101.2 ; v2(140.84,10.26) 140.5,9.92 J49.67 ; C210.2 99.53,125.18 v2(100.1,124.62) ; J41.73 v2(50.9,10.19) ; v2(113.99,130.16) 114.6,130.76 C213.2 ; v2(4.85,84.99) 4.77,85.07 4.21,85.07 4.06,85.22 C1183.2 ; J49.154 106.1,5.53 v2(105.79,5.84) ; J41.79 v2(48.5,10.19) ; v2(79.46,45.19) 79.95,45.68 C1186.2 C1187.2 ; J49.152 106.9,5.58 v2(107.19,5.87) ; v2(128.24,5.79) 128.5,5.54 J49.98 ; R4.2 95.11,35.57 v2(95.22,35.46) ; C1103.2 v2(96.47,108.64) ; C1202.2 v2(190,118.27) ; J49.155 105.3,9.9 v2(105.59,10.19) ; v2(57.07,28.37) 56.31,28.37 55.78,28.91 C1113.2 ; C1148.2 v2(25.32,30.43) ; C1135.2 v2(31.72,70.89) ; v2(179.55,115.68) 179.65,115.78 R3434.2 ; v2(39.01,67.36) 39.01,66.65 C1139.2 ; v2(182.66,116.25) 181.28,116.25 R3435.2 ; v2(70.36,31.44) 70.36,31.55 69.82,32.08 C1179.2 ; J41.113 v2(34.9,10.19) ; J49.23 158.1,9.94 v2(157.85,10.19) ; v2(21.16,110.24) 21.16,110.57 21.03,110.7 C1097.2 ; J49.104 126.1,5.58 v2(126.39,5.87) ; C270.2 61.85,110.18 60.91,109.24 v2(59.84,109.24) ; C173.2 51.41,127.27 v2(51.37,127.31) ; C207.2 v2(99.57,128.95) ; J41.118 v2(33.3,5.79) ; J41.54 v2(58.9,5.79) ; J41.22 v2(71.7,5.79) ; C1078.2 v2(130.08,43.52) ; v2(120.5,127.19) 120.5,125.78 C212.2 ; R93.2 v2(16.61,84.71) ; J49.122 118.9,5.61 v2(118.62,5.89) ; C182.2 v2(147.58,130.76) ; J49.26 v2(157.3,5.79) ; R92.2 v2(21.74,84.71) ; v2(131.45,5.82) 131.7,5.56 J49.90 ; v2(91.48,116.96) R4397.2 ; J49.29 v2(155.7,10.19) ; C1138.2 23.96,37.07 23.62,36.74 v2(23.62,36.45) ; C1129.2 C1130.2 47.38,44.39 v2(48.41,43.36) ; J41.89 v2(44.5,10.19) ; J41.52 v2(59.7,5.79) ; J41.111 v2(35.7,10.19) ; J41.23 v2(70.9,10.19) ; J49.128 116.5,5.63 v2(116.74,5.87) ; R2849.2 v2(66.45,54.13) ; v2(73.91,32.08) 73.89,32.11 C1178.2 ; v2(68.67,10.25) 68.5,10.08 J41.29 ; R2851.2 v2(66.42,52.07) ; C1142.2 v2(21.95,71.13) ; v2(115.42,5.77) 115.7,5.48 J49.130 ; J41.87 v2(45.3,10.19) ; R2941.2 v2(71.5,53.57) ; J49.157 104.5,9.9 v2(104.24,10.16) ; J49.85 133.3,9.96 v2(133.05,10.21) ; J49.136 113.3,5.6 v2(113.56,5.87) ; J49.74 138.1,5.56 v2(137.85,5.82) ; J41.65 v2(54.1,10.19) ; R2853.2 65.61,49.28 v2(65.59,49.26) ; J41.60 v2(56.5,6.4) ; J41.102 v2(39.7,6.4) ; C70.2 v2(44.99,67.36) ; v2(161.87,51.61) 161.47,51.21 C46.2 ; J49.123 118.1,9.9 v2(118.42,10.21) ; J41.92 v2(43.7,6.35) ; J49.93 130.1,9.88 v2(129.77,10.21) ; J49.75 137.3,10 v2(137.59,10.29) ; C1203.2 v2(193.15,117.27) ; C170.2 72.21,128.99 v2(72.71,129.5) ; J41.63 v2(54.9,10.19) ; C204.2 96.52,128.38 v2(96.33,128.57) ; J41.36 v2(66.1,5.79) ; C1154.2 46.2,41.74 v6(46.5,41.44) 46.79,41.74 C1155.2 ; v2(72.85,130.3) 72.4,130.76 C24.2 ; C1074.1 183.17,132.07 v2(183.26,131.97) ; C30.2 v2(144.43,130.33) ; v2(136.22,10.26) 136.5,9.98 J49.77 ; J41.55 v2(58.1,10.19) ; J49.43 v2(150.1,10.19) ; J49.58 v2(144.5,5.79) ; J41.57 v2(57.3,10.19) ; J49.101 v2(126.9,10.16) ; J49.114 122.1,5.59 v2(121.84,5.84) ; J49.133 114.1,9.9 v2(113.84,10.16) ; v2(5.03,95.83) C1184.2 ; J49.117 v2(120.5,10.19) ; J49.115 v2(121.3,10.19) ; C271.2 v2(91.43,118.05) ; v2(139.4,10.26) 139.7,9.96 J49.69 ; C275.2 111.12,110.05 v2(111.73,110.66) ; J49.61 142.9,9.93 v2(142.6,10.24) ; J49.35 v2(153.3,10.19) ; J49.139 111.7,9.95 v2(112.01,10.26) ; C100.2 148.02,128.66 147.58,129.1 v2(147.32,129.1) ; v2(59.62,49.26) 59.62,49.62 59.29,49.96 R2854.2 ; J49.53 v2(146.1,10.19) ; R2850.2 v2(66.37,53.09) ; Q53.S v2(11.49,7.43) ; J41.105 v2(38.1,10.19) ; v2(55.04,26.34) 52.52,28.86 C1111.2 ; J41.103 v2(38.9,10.19) ; J49.40 v2(151.7,5.79) ; C1144.2 v2(21.75,74.75) ; C186.2 v2(169.23,129.22) ; C1136.2 v2(31.69,67.41) ; v2(115.21,10.21) 114.9,9.9 J49.131 ; C280.2 162.96,113.02 v2(163.36,113.42) ; J41.47 v2(61.3,10.19) ; J41.44 v2(62.9,5.79) ; Q52.S v2(12.15,5.48) ; C97.2 v2(138.65,129.94) ; J49.107 v2(124.5,10.19) ; J41.78 v2(49.3,6.42) ; J41.86 v2(46.1,6.5) ; v2(5.21,81.74) 4.73,81.74 4.42,82.05 C1182.2 ; J49.51 v2(146.9,10.19) ; J41.84 v2(46.9,6.5) ; J49.109 v2(123.7,10.19) ; C1147.2 v2(29.62,90.06) ; J49.99 v2(127.7,10.16) ; C1121.2 v2(35.16,50.18) ; J49.32 v2(154.9,5.79) ; J49.91 130.9,9.89 v2(131.17,10.16) ; J41.100 v2(40.5,6.4) ; J49.42 v2(150.9,5.79) ; C1127.2 v2(42.44,39.6) ; C1099.2 v2(46,109.56) ; J49.37 v2(152.5,10.19) ; J41.94 v2(42.9,6.35) ; C187.2 v2(168.86,124.41) ; J49.147 108.5,9.9 v2(108.84,10.24) ; J41.26 v2(70.1,5.79) ; J41.25 v2(70.1,10.19) ; C1079.2 v2(139.74,43.66) ; J41.68 v2(53.3,6.37) ; J41.97 v2(41.3,10.42) ; C197.2 v2(96.43,130.97) ; J41.31 v2(67.7,10.19) ; R4162.1 R4161.1 ; J49.56 v2(145.3,5.79) ; J41.41 v2(63.7,10.19)
  vias: v2(0.76,121.49) v2(0.76,120.22) v2(0.76,118.95) v2(0.76,117.68) v2(0.76,116.41) v2(0.76,115.09) v2(0.76,113.87) v2(0.76,112.6) v2(0.76,111.33) v2(0.76,110.06) v2(0.76,108.79) v2(0.76,107.52) v2(0.76,106.25) v2(0.76,104.98) v2(0.76,102.44) v2(0.76,97.36) v2(0.76,94.82) v2(0.76,93.55) v2(0.76,92.28) v2(0.76,91.01) v2(0.76,89.74) v2(0.76,88.47) v2(0.76,87.2) v2(0.76,85.93) v2(0.76,84.66) v2(0.76,83.39) v2(0.76,82.12) v2(0.76,80.85) v2(0.76,79.58) v2(0.76,78.31) v2(0.76,77.04) v2(0.76,75.77) v2(0.76,74.5) v2(0.76,73.23) v2(0.76,71.96) v2(0.76,70.69) v2(0.76,69.42) v2(0.76,68.15) v2(0.76,66.88) v2(0.76,65.61) v2(0.76,64.34) v2(0.76,63.07) v2(0.76,61.8) v2(0.76,60.53) v2(0.76,59.26) v2(0.76,57.99) v2(0.76,56.72) v2(0.76,55.45) v2(0.76,54.18) v2(0.76,52.91) v2(0.76,51.64) v2(0.76,50.37) v2(0.76,49.1) v2(0.76,47.83) v2(0.76,46.56) v2(0.76,45.29) v2(0.76,44.02) v2(0.76,42.75) v2(0.76,41.48) v2(0.76,40.21) v2(0.76,38.94) v2(0.76,37.67) v2(0.76,36.4) v2(0.76,35.13) v2(0.76,33.86) v2(0.76,32.59) v2(0.76,31.32) v2(0.76,30.05) v2(0.76,28.78) v2(0.76,27.51) v2(0.76,26.19) v2(0.76,24.97) v2(0.76,23.7) v2(0.76,22.43) v2(0.76,21.16) v2(0.76,19.89) v2(0.76,18.62) v2(0.76,17.35) v2(0.76,16.08) v2(0.76,14.81) v2(0.76,13.54) v2(0.76,12.27) v2(0.76,11) v2(0.76,9.73) v2(0.76,8.46) v2(0.76,7.19) v2(0.76,5.92) v2(0.76,4.65) v2(0.76,3.38) v2(0.76,2.11) v2(2.1,122.74) v2(2.15,0.76) v2(3.37,122.74) v2(3.42,0.76) v2(4.64,122.74) v2(4.69,0.76) v2(5.91,122.74) v2(5.96,0.76) v2(7.18,122.74) v2(7.23,0.76) v2(8.45,122.74) v2(8.5,0.76) v2(9.72,122.74) v2(9.77,0.76) v2(10.99,122.74) v2(11.04,0.76) v2(12.26,122.74) v2(12.31,0.76) v2(13.53,122.74) v2(13.58,0.76) v2(15.76,123.04) v2(15.78,41.96) v2(16.17,22.12) v2(16.16,21.48) v2(16.17,20.83) v2(17.06,124.46) v2(17.26,145.96) v2(17.26,144.69) v2(17.26,143.42) v2(17.26,142.15) v2(17.26,140.88) v2(17.26,139.61) v2(17.26,138.34) v2(17.26,137.07) v2(17.26,135.8) v2(17.26,134.53) v2(17.26,133.26) v2(17.26,131.99) v2(17.26,130.72) v2(17.26,129.45) v2(17.26,128.18) v2(17.26,126.91) v2(17.26,125.64) v2(17.77,114) v2(17.77,113.21) v2(17.78,112.38) v2(17.81,111.61) v2(18,122.47) v2(18.09,110.31) v2(18.26,123.07) v2(18.31,68.47) v2(18.58,147.24) v2(18.66,0.76) v2(18.92,116.28) v2(18.87,95.6) v2(19.02,118.54) v2(19,117.45) v2(19.76,110.55) v2(19.85,147.24) v2(19.94,27.68) v2(19.93,0.76) v2(20.62,27.68) v2(20.62,20.51) v2(20.7,21.23) v2(21.12,147.24) v2(21.12,27.14) v2(21.2,0.76) v2(21.35,20.51) v2(21.37,21.28) v2(22.17,108.84) v2(22.39,147.24) v2(22.47,93.99) v2(22.47,0.76) v2(23.1,25.38) v2(23.48,108.49) v2(23.66,147.24) v2(23.74,0.76) v2(24,109.58) v2(24.93,147.24) v2(25.01,0.76) v2(25.45,123.26) v2(25.52,136.61) v2(25.5,122.61) v2(25.53,121.93) v2(25.5,121.25) v2(25.53,109.45) v2(25.59,138.08) v2(25.66,107.9) v2(26.2,147.24) v2(26.28,0.76) v2(26.74,130.34) v2(26.84,109.45) v2(26.91,128.36) v2(27.25,129.89) v2(27.47,147.24) v2(27.55,0.76) v2(28.15,101.01) v2(28.42,35) v2(28.74,147.24) v2(28.82,0.76) v2(29.05,138.28) v2(29.27,34.56) v2(30.01,147.24) v2(30.09,0.76) v2(30.18,38.55) v2(30.39,139.58) v2(30.4,27.55) v2(30.96,100.93) v2(31.28,147.24) v2(31.36,0.76) v2(32.23,130.87) v2(32.55,147.24) v2(32.63,0.76) v2(32.71,11.14) v2(33.05,138.94) v2(33.22,127.88) v2(33.82,147.24) v2(33.9,0.76) v2(34.19,124.87) v2(34.26,94.92) v2(34.34,79.27) v2(34.37,12.32) v2(34.75,138.99) v2(35.09,147.24) v2(35.1,138.35) v2(35.08,128.75) v2(35.17,0.76) v2(35.28,92.86) v2(35.51,124.89) v2(35.52,49.24) v2(35.71,144.05) v2(36.3,12.4) v2(36.36,147.24) v2(36.44,0.76) v2(36.6,100.15) v2(36.74,144.14) v2(37.55,12.41) v2(37.63,147.24) v2(37.71,0.76) v2(38,100.15) v2(38.9,147.24) v2(38.98,0.76) v2(39.22,98.35) v2(39.47,12.27) v2(39.73,126.07) v2(40.25,0.76) v2(40.49,98.32) v2(40.69,99.62) v2(40.74,12.34) v2(41.52,0.76) v2(42,125.91) v2(41.96,99.69) v2(42.32,84.33) v2(42.71,147.24) v2(42.7,14.25) v2(42.79,0.76) v2(42.96,136.68) v2(43.1,114.78) v2(43.6,116.98) v2(43.6,116.29) v2(43.56,109.96) v2(43.67,117.7) v2(43.98,147.24) v2(44,14.27) v2(44.06,130.79) v2(44.15,110.26) v2(44.12,109.63) v2(44.12,87.02) v2(44.06,0.76) v2(44.29,138.21) v2(45.25,147.24) v2(45.33,0.76) v2(45.44,129.51) v2(45.43,86.99) v2(45.52,127.96) v2(45.82,19.13) v2(45.98,68.48) v2(46.17,80.47) v2(46.52,147.24) v2(46.6,0.76) v2(46.84,1.47) v2(46.92,127.94) v2(46.99,129.54) v2(47.07,19.15) v2(47.19,97.97) v2(47.79,147.24) v2(47.93,101.8) v2(47.87,0.76) v2(48.33,127.18) v2(48.41,128.32) v2(49.06,147.24) v2(49.1,98.93) v2(49.14,0.76) v2(49.23,90.13) v2(49.27,89.02) v2(49.45,122.5) v2(49.43,1.45) v2(49.47,123.16) v2(49.46,121.83) v2(49.47,121.11) v2(49.83,101.04) v2(49.94,127.15) v2(49.9,80.36) v2(50,129.29) v2(50.22,2.21) v2(50.33,147.24) v2(50.41,0.76) v2(50.65,82.03) v2(50.78,73.09) v2(51.43,129.33) v2(51.6,147.24) v2(51.68,0.76) v2(52.12,106.66) v2(52.17,108) v2(52.27,2.29) v2(52.87,147.24) v2(52.93,74.22) v2(52.95,0.76) v2(53.42,106.6) v2(53.42,105.25) v2(53.4,81.98) v2(53.56,2.26) v2(54.14,147.24) v2(54.22,0.76) v2(54.33,130.1) v2(54.43,127.23) v2(54.81,105.23) v2(55.41,147.24) v2(55.47,2.23) v2(55.49,0.76) v2(56.02,103.77) v2(56.08,129.74) v2(56.23,127.45) v2(56.41,1.68) v2(56.68,147.24) v2(56.79,55.78) v2(56.76,0.76) v2(57.35,129.74) v2(57.81,137.49) v2(57.95,147.24) v2(58.03,0.76) v2(58.55,90.83) v2(58.93,1.73) v2(59.06,137.52) v2(59.22,147.24) v2(59.3,0.76) v2(59.63,107.05) v2(60.39,91.53) v2(60.49,147.24) v2(60.57,0.76) v2(60.71,82.2) v2(60.71,80.88) v2(60.76,137.34) v2(60.8,90.31) v2(61.11,64.08) v2(61.09,58.42) v2(61.17,61.16) v2(61.47,43.89) v2(61.76,147.24) v2(61.84,0.76) v2(62.15,137.31) v2(62.37,92.08) v2(62.79,71.45) v2(62.92,91.53) v2(63.03,147.24) v2(62.98,122.92) v2(63.04,122.12) v2(63.11,0.76) v2(63.53,121.49) v2(63.47,44.61) v2(63.51,43.02) v2(63.63,137.16) v2(63.76,64.19) v2(64.04,58.39) v2(64.3,147.24) v2(64.38,0.76) v2(65.02,93.05) v2(65,91.61) v2(65.08,137.01) v2(65.57,147.24) v2(65.65,0.76) v2(66.3,43.11) v2(66.44,93.07) v2(66.7,137.06) v2(66.84,147.24) v2(66.78,64.11) v2(66.8,61.24) v2(66.8,58.42) v2(66.92,0.76) v2(67.81,113.88) v2(67.83,113.24) v2(67.78,112.33) v2(67.77,111.66) v2(67.97,109.47) v2(67.97,108.8) v2(67.98,108.12) v2(68.11,147.24) v2(68.13,137.01) v2(68.09,130.74) v2(68.19,0.76) v2(69.34,130.74) v2(69.38,147.24) v2(69.46,0.76) v2(69.58,128.08) v2(69.75,138.15) v2(70.65,147.24) v2(70.73,0.76) v2(70.8,129.48) v2(70.84,128.12) v2(71.05,138.18) v2(71.92,147.24) v2(72,0.76) v2(72.23,75.09) v2(72.16,73.66) v2(73.04,123.3) v2(73.03,122.65) v2(73.07,122) v2(73.19,147.24) v2(73.27,0.76) v2(73.46,121.21) v2(74.04,127.17) v2(74.46,147.24) v2(74.54,0.76) v2(75.12,103.75) v2(75.5,130.66) v2(75.51,130.01) v2(75.6,100.77) v2(75.73,147.24) v2(75.81,0.76) v2(77,147.24) v2(77.08,0.76) v2(77.19,103.19) v2(77.44,101.05) v2(77.54,107.46) v2(78.27,147.24) v2(78.34,127.89) v2(78.35,0.76) v2(78.82,122.57) v2(78.9,106.17) v2(78.98,52.4) v2(78.99,50.8) v2(79.54,147.24) v2(79.62,0.76) v2(79.88,108.76) v2(80.04,128.3) v2(80.59,52.39) v2(80.59,50.8) v2(80.81,147.24) v2(80.89,0.76) v2(81.09,108.76) v2(81.29,128.3) v2(81.63,138.46) v2(82.08,147.24) v2(82.16,0.76) v2(83.06,138.42) v2(83.35,147.24) v2(83.43,0.76) v2(84.62,147.24) v2(84.7,0.76) v2(84.78,138.41) v2(84.96,39.73) v2(85.89,147.24) v2(85.97,0.76) v2(86.1,138.38) v2(86.24,67.07) v2(86.25,65.5) v2(86.81,103.34) v2(87.03,123.17) v2(87.03,122.53) v2(87.08,121.89) v2(87.16,147.24) v2(87.17,107.54) v2(87.77,138.13) v2(87.97,67.04) v2(88.19,103.19) v2(88.62,107.59) v2(89.06,138.08) v2(90.25,123.38) v2(90.24,122.64) v2(90.24,121.99) v2(90.24,66.45) v2(90.79,138.43) v2(91.05,0.76) v2(91.91,129.52) v2(92.09,138.43) v2(92.32,137.24) v2(92.32,0.76) v2(92.54,147.23) v2(92.48,107.01) v2(92.85,114.56) v2(92.84,113.18) v2(92.84,110.34) v2(92.88,117.87) v2(92.89,117.21) v2(92.88,116.45) v2(92.87,115.22) v2(92.86,112.47) v2(92.86,111.71) v2(92.86,109.65) v2(93.01,98.22) v2(93.32,129.45) v2(93.35,127.2) v2(93.52,137.22) v2(93.59,0.76) v2(93.83,105.54) v2(93.95,104.24) v2(94.84,127.16) v2(94.86,0.76) v2(94.99,129.89) v2(95.22,105.56) v2(95.53,98.25) v2(95.45,4.38) v2(95.55,97.46) v2(96.13,0.76) v2(96.49,9.99) v2(97.03,122.81) v2(97.03,122.17) v2(97.05,123.47) v2(97.4,0.76) v2(97.51,4.9) v2(97.8,98.21) v2(97.78,37.12) v2(97.78,35.9) v2(97.82,8.35) v2(98.03,129.57) v2(98.67,0.76) v2(98.96,37.12) v2(98.96,35.9) v2(99.94,0.76) v2(101.21,0.76) v2(102.36,127.19) v2(102.48,0.76) v2(103.75,0.76) v2(104.05,128.73) v2(104.17,11.3) v2(105.02,0.76) v2(105.13,137.62) v2(105.27,128.73) v2(105.72,98.42) v2(105.72,11.35) v2(105.77,94.97) v2(106.29,0.76) v2(106.41,39.18) v2(106.46,135.13) v2(106.74,138.93) v2(106.69,23.74) v2(106.81,36.12) v2(107.14,93.6) v2(107.15,97.01) v2(107.39,11.91) v2(107.49,147.22) v2(107.56,0.76) v2(107.94,136.38) v2(107.95,40.8) v2(108.57,104.08) v2(108.79,11.89) v2(108.83,0.76) v2(109.6,40.8) v2(110.1,0.76) v2(110.21,36.12) v2(110.62,11.79) v2(110.83,103.51) v2(110.92,122.87) v2(110.93,122.15) v2(111.15,40.83) v2(111.37,0.76) v2(111.51,122.53) v2(111.51,121.74) v2(112.04,11.81) v2(112.07,34.93) v2(112.07,34.26) v2(112.09,33.3) v2(112.09,32.66) v2(112.64,0.76) v2(112.97,36.36) v2(113.06,40.83) v2(113.27,42.99) v2(113.77,37.85) v2(113.87,11.86) v2(113.91,0.76) v2(114.14,123.33) v2(114.17,122.68) v2(114.18,122.03) v2(114.8,136.1) v2(115.19,11.89) v2(115.18,0.76) v2(115.39,38.66) v2(116.07,130.82) v2(116.45,0.76) v2(116.79,115.39) v2(116.76,114.76) v2(116.81,113.49) v2(116.81,112.85) v2(116.81,112.17) v2(117.22,109.73) v2(117.47,129.47) v2(117.52,109.04) v2(117.45,98.01) v2(117.56,100.63) v2(117.72,0.76) v2(118.41,30.66) v2(118.54,39.82) v2(118.55,38.44) v2(118.55,37.04) v2(118.64,12.83) v2(118.84,127.16) v2(118.99,0.76) v2(119.24,102.6) v2(119.45,30.68) v2(119.7,97.37) v2(119.87,100.45) v2(119.94,39.83) v2(119.94,12.83) v2(119.98,37.03) v2(120.23,104.71) v2(120.26,0.76) v2(120.9,122.48) v2(120.9,13.74) v2(120.97,123.76) v2(120.96,123.13) v2(121.07,101.56) v2(121.28,121.94) v2(121.33,39.83) v2(121.33,38.43) v2(121.33,37.03) v2(121.48,134.74) v2(121.51,104.73) v2(121.53,0.76) v2(122,127.18) v2(122.25,13.72) v2(122.8,0.76) v2(123.05,134.72) v2(123.27,145.85) v2(123.29,130.69) v2(123.29,129.93) v2(124.07,0.76) v2(124.16,145.82) v2(124.52,102.05) v2(124.88,146.56) v2(124.88,145.89) v2(125.34,0.76) v2(125.88,104.34) v2(126.16,101.96) v2(126.32,127.89) v2(126.26,35.14) v2(126.26,34.25) v2(126.53,147.24) v2(126.61,0.76) v2(127.03,15.04) v2(127.38,104.36) v2(127.35,103.05) v2(127.73,48.68) v2(127.8,147.24) v2(127.88,0.76) v2(128.02,128.45) v2(128.52,146.41) v2(128.6,104.47) v2(128.6,14.94) v2(129.07,147.24) v2(129.15,0.76) v2(129.31,128.45) v2(129.69,14.55) v2(129.78,138.37) v2(130.34,147.24) v2(130.42,0.76) v2(131.04,14.55) v2(131.05,138.38) v2(131.61,147.24) v2(131.69,0.76) v2(132.78,138.42) v2(132.88,147.24) v2(132.96,0.76) v2(133.22,103.15) v2(134.05,138.41) v2(133.99,104.65) v2(134.15,147.24) v2(134.23,0.76) v2(134.75,120.51) v2(134.77,103.15) v2(135.26,123.27) v2(135.26,122.62) v2(135.28,104.67) v2(135.42,147.24) v2(135.5,0.76) v2(135.78,138.38) v2(136.77,0.76) v2(137.05,138.5) v2(137.21,136.7) v2(137.96,147.24) v2(138.04,0.76) v2(138.15,122.15) v2(138.16,123.49) v2(138.16,122.8) v2(138.59,136.76) v2(139.23,147.24) v2(139.31,0.76) v2(139.9,102.49) v2(140.08,130.94) v2(140.27,137.52) v2(140.5,147.24) v2(140.58,0.76) v2(141,105.21) v2(141.15,103.89) v2(141.35,129.17) v2(141.56,137.56) v2(141.77,147.24) v2(141.85,0.76) v2(142.34,112.57) v2(142.34,111.73) v2(142.34,111.06) v2(142.4,115.46) v2(142.39,114.77) v2(142.4,114.05) v2(142.38,113.37) v2(143.04,147.24) v2(142.95,104.7) v2(143.06,127.19) v2(143.12,0.76) v2(143.38,106.4) v2(144.15,12.47) v2(144.17,108.93) v2(144.31,147.24) v2(144.39,0.76) v2(144.52,127.17) v2(145.15,123.24) v2(145.08,122.59) v2(145.22,121.97) v2(145.31,105.82) v2(145.49,121.25) v2(145.47,108.99) v2(145.52,12.5) v2(145.58,147.24) v2(145.66,0.76) v2(146.07,129.09) v2(146.85,147.24) v2(146.93,0.76) v2(147.45,11.3) v2(147.82,26.48) v2(148.12,147.24) v2(148.07,61.06) v2(148.2,0.76) v2(148.72,11.35) v2(148.93,130.03) v2(149.39,147.24) v2(149.47,0.76) v2(149.71,107.95) v2(149.71,26.5) v2(149.99,30.02) v2(150.28,130.08) v2(150.51,127.17) v2(150.66,147.24) v2(150.7,12.42) v2(150.74,0.76) v2(150.95,108.03) v2(151.39,30.01) v2(151.84,128.47) v2(151.93,147.24) v2(152.05,12.4) v2(152.01,0.76) v2(152.08,129.68) v2(153.2,147.24) v2(153.17,137.1) v2(153.17,32.96) v2(153.28,0.76) v2(153.42,129.62) v2(153.88,14.99) v2(154.47,147.24) v2(154.54,32.94) v2(154.55,0.76) v2(154.58,108.66) v2(155.74,147.24) v2(155.82,0.76) v2(155.98,110.08) v2(156.09,11.99) v2(156.73,137.41) v2(156.9,6.42) v2(157.01,147.24) v2(157.09,0.76) v2(157.33,11.96) v2(157.7,6.42) v2(158.28,147.24) v2(158.26,137.4) v2(158.36,0.76) v2(158.84,122.81) v2(159.07,123.74) v2(159.54,122.84) v2(159.55,147.24) v2(159.63,0.76) v2(159.73,137.36) v2(160.63,80.34) v2(160.6,79.71) v2(160.82,147.24) v2(160.9,0.76) v2(161.07,137.35) v2(161.42,80.34) v2(161.37,79.71) v2(162.09,147.24) v2(162.1,80.37) v2(162.08,79.73) v2(162.17,0.76) v2(162.78,137.4) v2(162.84,23.75) v2(162.82,23.04) v2(163.21,37.96) v2(163.21,37.24) v2(163.22,36.5) v2(163.36,147.24) v2(163.44,0.76) v2(164.09,137.38) v2(164.63,147.24) v2(164.7,23.75) v2(164.67,23.04) v2(164.71,0.76) v2(165,20.77) v2(165.56,21.29) v2(165.77,137.46) v2(165.81,37.92) v2(165.84,37.21) v2(165.81,36.53) v2(165.87,15.3) v2(165.87,14.05) v2(165.98,0.76) v2(166.09,20.95) v2(166.09,16) v2(166.4,14.83) v2(166.53,14.03) v2(166.53,13.33) v2(166.54,12.02) v2(166.56,12.7) v2(166.56,11.38) v2(166.73,22.63) v2(166.7,21.92) v2(166.71,21.13) v2(166.7,15.57) v2(167.04,137.46) v2(167.06,14.57) v2(167.25,0.76) v2(167.37,17.93) v2(167.36,17.28) v2(167.38,16.62) v2(167.4,15.93) v2(167.39,15.19) v2(167.7,14.57) v2(168.3,118.16) v2(168.47,119.52) v2(168.52,0.76) v2(169.01,118.16) v2(169.06,117.5) v2(169.06,116.79) v2(169.33,37.82) v2(169.3,37.01) v2(169.32,36.2) v2(169.55,114.96) v2(169.55,114.27) v2(169.57,116.33) v2(169.57,115.65) v2(169.79,0.76) v2(171.06,0.76) v2(171.47,21.39) v2(171.71,38.1) v2(171.68,13.76) v2(171.7,13.1) v2(171.75,37.22) v2(171.77,36.52) v2(172.33,0.76) v2(172.92,37.29) v2(173.25,18.95) v2(173.52,147.24) v2(173.6,0.76) v2(173.84,13.61) v2(173.84,12.86) v2(173.98,37.26) v2(174.79,147.24) v2(174.87,0.76) v2(175.32,37.4) v2(175.32,36.72) v2(175.32,36.06) v2(175.52,23.83) v2(175.52,23.16) v2(175.52,22.43) v2(175.52,21.77) v2(176.06,147.24) v2(176.23,20.93) v2(176.58,23.85) v2(176.56,23.14) v2(176.61,22.45) v2(176.58,21.77) v2(176.72,12.58) v2(176.89,20.96) v2(177.05,13.32) v2(177.21,11.94) v2(177.33,147.24) v2(177.39,12.56) v2(177.6,41.35) v2(177.57,40.67) v2(177.75,24.89) v2(177.8,24.16) v2(177.85,12.01) v2(177.86,37.34) v2(177.86,36.6) v2(177.86,35.84) v2(177.88,14.33) v2(177.87,13.65) v2(177.86,12.99) v2(177.88,11.27) v2(178.13,15.67) v2(178.05,14.99) v2(178.33,40.69) v2(178.36,41.33) v2(178.5,37.34) v2(178.52,36.63) v2(178.52,35.84) v2(178.6,147.24) v2(178.57,17.82) v2(178.56,17.05) v2(178.56,16.29) v2(178.69,14.99) v2(178.82,15.64) v2(179.04,40.67) v2(179.07,41.33) v2(179.3,37.31) v2(179.71,41.35) v2(179.71,40.69) v2(179.87,147.24) v2(179.95,0.76) v2(180.64,38.35) v2(180.65,39.06) v2(180.81,36.98) v2(180.81,36.35) v2(180.75,34.31) v2(180.86,33.58) v2(181.14,147.24) v2(181.22,0.76) v2(182.05,22.06) v2(182.41,147.24) v2(182.49,0.76) v2(183.68,147.24) v2(183.76,0.76) v2(183.92,110.19) v2(184.09,106.82) v2(184.12,19.74) v2(184.21,128.67) v2(184.55,108.27) v2(184.94,128.65) v2(184.95,147.24) v2(185.03,0.76) v2(186.22,147.24) v2(186.33,110.21) v2(186.35,106.14) v2(186.3,0.76) v2(186.47,3.78) v2(186.47,3.1) v2(186.5,2.46) v2(186.64,107.71) v2(187.21,3.81) v2(187.21,3.12) v2(187.24,2.49) v2(187.49,147.24) v2(187.7,22.9) v2(187.78,20.39) v2(187.99,48.09) v2(188,47.44) v2(188.33,22.9) v2(188.41,20.39) v2(188.66,41.35) v2(188.66,40.64) v2(188.76,147.24) v2(188.86,107.09) v2(189.05,37.65) v2(189.05,36.99) v2(189.05,36.3) v2(189.07,38.31) v2(189.45,41.34) v2(189.36,28.63) v2(189.37,27.95) v2(189.39,27.3) v2(189.39,26.66) v2(189.39,26.03) v2(189.45,40.63) v2(189.82,3.78) v2(189.82,3.1) v2(189.84,2.46) v2(189.9,38.68) v2(189.91,37.96) v2(189.88,37.3) v2(189.88,36.57) v2(190.03,147.24) v2(190,28.68) v2(190.02,27.98) v2(190.02,27.3) v2(190.02,26.66) v2(190.02,26.03) v2(190.08,29.33) v2(190.11,0.76) v2(190.2,48.11) v2(190.2,47.45) v2(190.47,29.89) v2(190.53,2.43) v2(190.56,3.78) v2(190.56,3.09) v2(190.91,107.38) v2(190.91,32.26) v2(190.91,31.57) v2(190.91,30.84) v2(190.94,29.22) v2(191.04,30.19) v2(191.3,147.24) v2(191.38,0.76) v2(191.84,102.5) v2(192.48,48.08) v2(192.48,47.42) v2(192.49,15.5) v2(192.57,13.07) v2(192.74,145.81) v2(192.74,144.54) v2(192.74,143.27) v2(192.74,142) v2(192.74,140.73) v2(192.74,139.46) v2(192.74,138.19) v2(192.74,136.92) v2(192.74,135.65) v2(192.74,134.38) v2(192.74,133.11) v2(192.74,131.84) v2(192.74,130.57) v2(192.74,129.3) v2(192.74,128.03) v2(192.74,126.76) v2(192.74,125.49) v2(193.12,15.5) v2(193.2,13.07) v2(193.16,0.76) v2(193.58,123.51) v2(193.59,41.25) v2(193.61,40.61) v2(193.81,37.11) v2(193.81,15.5) v2(193.89,13.07) v2(194.3,41.27) v2(194.32,40.63) v2(194.45,15.53) v2(194.43,0.76) v2(194.67,47.7) v2(194.68,4.55) v2(195.58,122.74) v2(196.44,39.12) v2(196.64,41.25) v2(196.67,40.62) v2(196.85,122.74) v2(197.24,39.14) v2(197.19,4.36) v2(197.19,3.69) v2(197.18,3.03) v2(197.18,2.35) v2(197.73,0.76) v2(197.89,39.01) v2(197.9,4.38) v2(197.91,3.71) v2(197.9,3.05) v2(197.9,2.36) v2(198.12,122.74) v2(198.39,39.48) v2(198.48,38.01) v2(198.74,101.01) v2(198.96,38.62) v2(199,0.76) v2(199.09,40.71) v2(199.09,40.08) v2(199.09,39.3) v2(199.39,122.74) v2(199.64,38.66) v2(199.73,41.55) v2(199.73,40.69) v2(199.77,51.99) v2(199.77,39.99) v2(199.91,39.27) v2(199.97,42.15) v2(200.27,0.76) v2(200.43,41.37) v2(200.43,40.68) v2(200.43,39.74) v2(200.52,32.38) v2(200.66,122.74) v2(200.85,31.44) v2(201.07,30.6) v2(201.05,29.92) v2(201.32,32.01) v2(201.47,31.23) v2(201.54,0.76) v2(201.71,30.6) v2(201.69,29.89) v2(201.93,122.74) v2(201.97,32.09) v2(202.16,31.35) v2(202.51,34.25) v2(202.52,33.58) v2(202.54,32.94) v2(202.65,32.15) v2(202.82,31.35) v2(202.81,0.76) v2(203.2,122.74) v2(203.19,53.69) v2(203.79,76.71) v2(204.01,74.34) v2(204.08,0.76) v2(204.47,122.74) v2(205.35,0.76) v2(205.5,49.54) v2(205.5,48.88) v2(205.5,48.19) v2(205.5,47.36) v2(205.74,122.74) v2(205.96,37.54) v2(206.62,0.76) v2(207.01,122.74) v2(207.84,26.56) v2(207.89,0.76) v2(208.54,49.54) v2(208.5,28.44) v2(208.5,27.74) v2(208.5,27.03) v2(208.57,122.59) v2(209.24,121.48) v2(209.24,120.21) v2(209.24,118.94) v2(209.24,117.67) v2(209.24,116.4) v2(209.24,115.13) v2(209.24,113.86) v2(209.24,112.59) v2(209.24,111.32) v2(209.24,110.05) v2(209.24,108.78) v2(209.24,107.51) v2(209.24,106.24) v2(209.24,104.97) v2(209.24,103.7) v2(209.24,102.43) v2(209.24,101.16) v2(209.24,99.89) v2(209.24,98.62) v2(209.24,97.35) v2(209.24,96.08) v2(209.24,94.81) v2(209.24,93.54) v2(209.24,92.27) v2(209.24,91) v2(209.24,89.73) v2(209.24,88.46) v2(209.24,87.19) v2(209.24,85.92) v2(209.24,84.65) v2(209.24,83.38) v2(209.24,82.11) v2(209.24,80.84) v2(209.24,79.57) v2(209.24,78.3) v2(209.24,77.03) v2(209.24,75.76) v2(209.24,74.49) v2(209.24,73.22) v2(209.24,71.95) v2(209.24,70.68) v2(209.24,69.41) v2(209.24,68.14) v2(209.24,66.87) v2(209.24,65.6) v2(209.24,64.33) v2(209.24,63.06) v2(209.24,61.79) v2(209.24,60.52) v2(209.24,59.25) v2(209.24,57.98) v2(209.24,56.71) v2(209.24,55.44) v2(209.24,54.17) v2(209.24,52.9) v2(209.24,51.63) v2(209.24,50.36) v2(209.24,49.09) v2(209.24,47.82) v2(209.24,46.55) v2(209.24,45.28) v2(209.24,44.01) v2(209.24,42.74) v2(209.24,41.47) v2(209.24,40.2) v2(209.24,38.93) v2(209.24,37.66) v2(209.24,36.39) v2(209.24,35.12) v2(209.24,33.85) v2(209.24,32.58) v2(209.24,31.31) v2(209.24,30.04) v2(209.24,28.77) v2(209.24,27.5) v2(209.24,26.23) v2(209.24,24.96) v2(209.24,23.69) v2(209.24,21.15) v2(209.24,19.88) v2(209.24,18.61) v2(209.24,17.34) v2(209.24,16.07) v2(209.24,14.8) v2(209.24,13.53) v2(209.24,12.26) v2(209.24,10.99) v2(209.24,9.72) v2(209.24,8.45) v2(209.24,7.18) v2(209.24,5.91) v2(209.24,4.64) v2(209.24,3.37) v2(209.24,2.1) v3(161.89,35.79) v3(163.91,39.04) v3(166.68,19.06) v3(167.64,35.13) v3(168.23,23.56) v3(189.5,32.03) v3(189.82,15.71) v3(189.85,20.68) v3(192.32,30.82) v3(193.47,23.02) v3(194.48,25.35) v3(197.15,27.71) v6(186.44,55.37) v6(188.72,55.55) v6(188.72,54.86) v6(191.06,55.47) v6(191.06,54.81) v6(193.48,55.27) v6(193.51,54.63) v6(195.53,56.15) v6(200.59,87.16) v6(200.59,86.07)
