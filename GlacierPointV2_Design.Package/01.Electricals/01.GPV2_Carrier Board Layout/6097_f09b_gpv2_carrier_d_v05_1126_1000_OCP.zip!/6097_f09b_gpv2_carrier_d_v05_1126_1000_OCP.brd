# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P3E_PESW_M2A_TX2_C_DP: length 168.4
  TOP w0.124: J4.B25 25.43,132.72 25.33,132.62 25.33,131.91 v2(25.69,131.56) ; v2(23.37,109.52) 23.01,109.16 23.01,107.75 23.3,107.05 24.01,106.34 28.16,104.62 47.45,104.62 48.86,104.19 54.22,100.61 70.13,94.02 88.19,81.96 92.08,79.88 115.53,70.16 122.09,68.85 124.23,69.01 124.71,68.96 124.71,68.96 131.14,67.68 134.32,68.31 137.49,67.68 140.67,68.31 143.84,67.68 145.37,67.98 145.48,68.16 145.85,68.23 146.02,68.11 146.39,68.19 146.5,68.36 146.87,68.43 147.04,68.32 147.41,68.39 147.52,68.56 147.89,68.64 148.06,68.52 148.43,68.59 148.54,68.77 148.91,68.84 149.08,68.73 150.27,68.96 152.75,68.96 C1027.2
  IN1 w0.136: v2(25.69,131.56) 25.32,131.19 25.32,130.83 24.42,128.66 24,128.04 23.75,127.42 22.95,123.42 22.95,118.29 23.12,117.42 23.36,116.84 23.66,116.55 24.12,115.43 24.12,114.43 23.72,113.44 23.72,112.01 23,110.28 23,109.89 v2(23.37,109.52)
P3E_PESW_M2A_TX2_DN: length 14.9
  TOP w0.099: 163.05,72.87 163.08,72.87 163.13,72.92 166.47,72.92 166.69,73.14 166.69,73.42 166.79,73.52 U34.AF3
  TOP w0.124: C1028.1 154.27,68.66 154.66,68.66 157.59,69.87 159.39,71.07 160.22,71.9 162.54,72.87 163.05,72.87
P3E_PESW_M2A_TX2_DP: length 14.9
  TOP w0.099: 163.05,73.17 163.08,73.17 163.13,73.12 163.69,73.12 163.79,73.22 163.99,73.22 164.09,73.12 164.29,73.12 164.39,73.22 164.58,73.22 164.69,73.12 164.88,73.12 164.99,73.22 165.18,73.22 165.29,73.12 165.48,73.12 165.59,73.22 165.78,73.22 165.89,73.12 166.39,73.12 166.49,73.22 166.49,73.42 166.39,73.52 U34.AF2
  TOP w0.124: 163.05,73.17 162.48,73.17 160.05,72.16 159.19,71.31 157.45,70.14 154.6,68.96 154.27,68.96 C1027.1
P3E_PESW_M2A_TX3_C_DN: length 169.1
  TOP w0.124: v2(21.68,131.62) 22.03,131.98 22.03,132.6 21.93,132.7 J4.B11 ; v2(18.59,109.88) 18.96,109.51 18.96,109.2 19.1,108.86 22.83,105.14 27.94,103.02 45.94,103.02 49.53,101.94 53.85,99.05 69.7,92.48 87.35,80.69 91.54,78.45 115.68,68.45 122.18,67.15 124.56,67.32 131.14,66 134.32,66.63 137.49,66 140.67,66.63 143.84,66 150.5,67.33 150.91,67.33 C1030.2
  IN1 w0.136: v2(21.68,131.62) 22.06,131.24 22.06,129.44 21.78,126.57 20.68,121.08 20.31,120.52 19.67,117.29 19.71,115.47 18.96,111.7 18.96,110.25 v2(18.59,109.88)
P3E_PESW_M2A_TX3_C_DP: length 169.1
  TOP w0.124: C1029.2 150.94,67.63 150.47,67.63 143.84,66.31 140.67,66.94 137.49,66.31 134.32,66.94 131.14,66.31 124.58,67.62 122.2,67.46 115.76,68.74 91.67,78.73 87.51,80.95 69.85,92.75 54,99.32 49.66,102.21 49.3,102.32 49.2,102.51 48.84,102.62 48.65,102.52 48.3,102.63 48.19,102.82 47.84,102.93 47.65,102.83 47,103.02 46.9,103.21 46.54,103.32 46.35,103.22 45.99,103.33 28,103.33 23,105.4 21.07,107.32 21.07,107.54 20.81,107.8 20.59,107.8 19.36,109.04 19.27,109.26 19.27,109.54 v2(19.61,109.88) ; v2(22.69,131.62) 22.33,131.98 22.33,132.61 22.43,132.7 J4.B13
  IN1 w0.136: v2(22.69,131.62) 22.34,131.27 22.34,129.43 22.05,126.53 20.95,120.97 20.57,120.41 19.95,117.26 19.99,115.45 19.24,111.67 19.24,110.25 v2(19.61,109.88)
P3E_PESW_M2A_TX3_DN: length 15.7
  TOP w0.099: U34.AG2 165.84,72.52 165.74,72.42 165.74,72.14 165.52,71.92 164.72,71.92 162.52,71.16 162.28,71.16 162.23,71.11 162.21,71.11
  TOP w0.124: 162.21,71.11 161.92,71.11 160.51,70.53 157.3,68.38 154.73,67.32 152.43,67.32 C1030.1
P3E_PESW_M2A_TX3_DP: length 15.7
  TOP w0.099: 162.21,71.42 162.23,71.42 162.28,71.37 162.49,71.37 162.98,71.54 163.04,71.66 163.23,71.73 163.36,71.67 163.55,71.73 163.61,71.86 163.8,71.92 163.93,71.86 164.12,71.93 164.18,72.06 164.37,72.12 164.5,72.06 164.68,72.12 165.44,72.12 165.54,72.22 165.54,72.42 165.44,72.52 U34.AG1
  TOP w0.124: C1029.1 152.43,67.62 154.67,67.62 157.15,68.65 160.36,70.8 161.86,71.42 162.21,71.42
P3E_PESW_M2B_RX0_DN: length 146.8
  TOP w0.124: U34.Y6 v6(169.59,79.02) ; v2(53.18,129.45) 53.53,129.79 53.53,132.61 53.43,132.71 J4.A41
  IN2 w0.099: 165.52,78.38 165.55,78.38 165.58,78.42 168.98,78.42 169.2,78.64 169.2,78.92 169.3,79.02 v6(169.59,79.02)
  IN2 w0.136: v2(53.18,129.45) 53.55,129.08 53.55,127.24 53.9,126.4 55.09,124.61 55.2,124.07 56.65,120.56 57.4,119.44 57.72,118.66 58.1,118.5 59.01,118.88 59.18,118.81 59.42,118.22 59.35,118.06 58.44,117.68 58.28,117.3 58.57,116.6 58.62,116.5 59,116.34 59.36,116.49 59.53,116.42 59.77,115.84 59.7,115.67 59.34,115.52 59.12,114.99 61.56,109.11 61.56,107.02 61.74,106.56 64.06,104.25 75.29,99.6 77.19,99.22 80.45,99.87 81.12,99.8 83.5,98.82 86.93,96.52 98.13,94.29 104.07,91.84 120.42,86.88 152.29,80.54 152.29,80.54 163.11,78.39 163.11,78.38 165.52,78.38
P3E_PESW_M2B_RX0_DP: length 146.8
  TOP w0.124: U34.Y5 v6(168.59,79.02) ; v2(54.2,129.45) 53.83,129.81 53.83,132.6 53.93,132.7 J4.A43
  IN2 w0.099: v6(168.59,79.02) 168.9,79.02 169,78.92 169,78.72 168.9,78.62 165.58,78.62 165.55,78.66 165.52,78.66
  IN2 w0.136: 165.52,78.66 163.16,78.66 159.24,79.44 159.14,79.59 158.74,79.67 158.59,79.57 158.19,79.65 158.08,79.8 157.68,79.88 157.53,79.78 157.13,79.86 157.02,80.02 156.62,80.09 156.47,79.99 156.07,80.07 155.96,80.23 155.56,80.31 155.41,80.2 155.01,80.28 154.91,80.44 154.51,80.52 154.35,80.41 153.95,80.49 153.85,80.65 153.45,80.73 153.29,80.62 152.89,80.7 152.79,80.86 152.39,80.94 152.23,80.83 120.48,87.15 104.16,92.1 98.21,94.56 87.04,96.79 83.63,99.06 81.19,100.08 80.43,100.15 77.19,99.5 75.37,99.86 64.22,104.48 61.98,106.72 61.84,107.07 61.84,109.2 61.81,109.22 59.42,114.99 59.55,115.3 59.92,115.46 60.08,115.84 59.74,116.64 59.36,116.8 59,116.64 58.83,116.71 58.59,117.3 58.66,117.46 59.57,117.84 59.72,118.22 59.39,119.02 59.01,119.18 58.1,118.8 57.94,118.87 57.64,119.58 56.9,120.69 55.47,124.15 55.35,124.72 54.15,126.53 53.83,127.29 53.83,129.08 v2(54.2,129.45)
P3E_PESW_M2B_RX1_DN: length 146.9
  TOP w0.124: J4.A29 50.43,132.7 50.53,132.61 50.53,130.27 v2(50.17,129.92) ; U34.AA5 v6(168.59,78.02)
  IN2 w0.099: 165.43,77.38 165.45,77.38 165.49,77.42 167.98,77.42 168.2,77.64 168.2,77.92 168.3,78.02 v6(168.59,78.02)
  IN2 w0.136: 165.43,77.38 162.37,77.38 162.36,77.39 152.07,79.43 122.17,85.38 103.55,91.03 97.86,93.38 86.69,95.61 86.34,95.75 83.07,97.94 80.78,98.89 80.35,98.89 77.24,98.27 74.87,98.74 63.43,103.48 60.9,106.01 60.36,107.3 60.36,109.56 56.83,118.08 55.33,119.44 51.9,120.48 50.92,120.88 50.11,122.1 50.11,125.2 50.54,127.38 50.54,129.55 v2(50.17,129.92)
P3E_PESW_M2B_RX1_DP: length 146.9
  TOP w0.124: U34.AA4 v6(167.59,78.02) ; v2(51.19,129.92) 50.83,130.27 50.83,132.6 50.93,132.7 J4.A31
  IN2 w0.099: 165.43,77.66 165.45,77.66 165.49,77.62 167.9,77.62 168,77.72 168,77.92 167.9,78.02 v6(167.59,78.02)
  IN2 w0.136: v2(51.19,129.92) 50.82,129.55 50.82,127.35 50.39,125.18 50.39,122.18 51.1,121.11 51.99,120.74 55.47,119.69 57.06,118.24 60.64,109.61 60.64,107.36 61.13,106.16 63.58,103.71 74.95,99.01 77.24,98.55 80.32,99.17 80.83,99.17 83.2,98.18 86.47,96 86.77,95.87 97.92,93.66 97.94,93.65 103.65,91.29 122.24,85.65 152.01,79.73 152.17,79.83 152.57,79.75 152.67,79.6 153.07,79.52 153.23,79.62 153.63,79.54 153.73,79.39 154.13,79.31 154.29,79.41 154.69,79.33 154.79,79.18 155.19,79.1 155.35,79.2 155.75,79.12 155.85,78.97 156.25,78.89 156.41,78.99 156.81,78.91 156.91,78.75 157.31,78.68 157.46,78.78 157.86,78.7 157.97,78.54 158.37,78.46 158.52,78.57 158.92,78.49 159.03,78.33 162.41,77.66 165.43,77.66
P3E_PESW_M2B_RX2_DN: length 150.2
  TOP w0.124: U34.AB6 v6(169.59,77.02) ; v2(47.16,128.92) 47.53,129.28 47.53,132.59 47.43,132.69 J4.A17
  IN2 w0.099: v6(169.59,77.02) 169.3,77.02 169.2,76.92 169.2,76.64 168.98,76.42 165.62,76.42 165.58,76.38 165.56,76.38
  IN2 w0.136: 165.56,76.38 162.51,76.38 120.2,84.8 104.64,89.52 97.49,92.48 86.55,94.65 83.32,95.99 75.11,97.63 62.07,103.03 59.36,105.74 58.65,106.79 58.38,107.45 58.38,109.13 57.33,114.43 56.09,117.42 54.81,118.58 51.02,119.15 48.86,120.59 48.16,122.27 47.87,123.76 47.53,127.14 47.53,128.55 v2(47.16,128.92)
P3E_PESW_M2B_RX2_DP: length 150.2
  TOP w0.124: J4.A19 47.93,132.7 47.83,132.6 47.83,129.27 v2(48.18,128.92) ; U34.AB5 v6(168.59,77.02)
  IN2 w0.099: 165.56,76.66 165.58,76.66 165.62,76.62 168.9,76.62 169,76.72 169,76.92 168.9,77.02 v6(168.59,77.02)
  IN2 w0.136: 165.56,76.66 162.54,76.66 120.26,85.07 115.12,86.63 115.03,86.79 114.64,86.91 114.48,86.82 114.09,86.94 114,87.11 113.61,87.22 113.45,87.14 113.06,87.26 112.97,87.42 112.58,87.54 112.41,87.45 112.02,87.57 111.93,87.73 111.54,87.85 111.38,87.76 110.99,87.88 110.9,88.05 110.51,88.17 110.35,88.08 109.96,88.2 109.87,88.36 109.48,88.48 109.31,88.39 108.92,88.51 108.83,88.67 108.44,88.79 108.28,88.7 104.73,89.78 97.57,92.75 86.64,94.92 83.4,96.26 75.19,97.9 62.23,103.26 59.58,105.92 58.9,106.93 58.66,107.51 58.66,109.16 57.6,114.51 56.32,117.59 54.93,118.85 51.12,119.41 49.08,120.78 48.43,122.35 48.14,123.8 47.81,127.15 47.81,128.55 v2(48.18,128.92)
P3E_PESW_M2B_RX3_DN: length 150.2
  TOP w0.124: v2(44.17,130.11) 44.53,130.47 44.53,132.6 44.43,132.69 J4.A5 ; U34.AC5 v6(168.59,76.02)
  IN2 w0.099: 165.58,75.38 165.6,75.38 165.64,75.42 167.98,75.42 168.2,75.64 168.2,75.92 168.3,76.02 v6(168.59,76.02)
  IN2 w0.136: v2(44.17,130.11) 44.54,129.74 44.54,127.35 45.28,125.55 46.08,124.36 47.48,120.97 48.11,120.02 49.56,118.58 49.56,117.09 52.25,114.39 53.95,111.56 55.25,110.26 55.39,109.94 55.39,107.67 55.77,107.03 55.99,106.77 56.39,106.55 57.84,104.78 58.55,104.2 59.94,103.46 61.74,102.12 74.71,96.75 82.97,95.11 86.3,93.73 97.28,91.55 104.24,88.67 121.3,83.49 152.95,77.2 162.05,75.39 162.05,75.38 165.58,75.38
P3E_PESW_M2B_RX3_DP: length 150.2
  TOP w0.124: v2(45.18,130.11) 44.83,130.46 44.83,132.6 44.93,132.7 J4.A7 ; U34.AC4 v6(167.59,76.02)
  IN2 w0.099: 165.58,75.66 165.6,75.66 165.64,75.62 167.9,75.62 168,75.72 168,75.92 167.9,76.02 v6(167.59,76.02)
  IN2 w0.136: 165.58,75.66 162.1,75.66 162.1,75.66 159.9,76.1 159.79,76.25 159.39,76.33 159.24,76.23 158.84,76.31 158.74,76.46 158.34,76.54 158.18,76.44 157.78,76.52 157.68,76.67 157.28,76.75 157.12,76.65 156.72,76.73 156.62,76.89 156.22,76.97 156.06,76.86 155.66,76.94 155.56,77.1 155.16,77.18 155,77.07 154.6,77.15 154.5,77.31 154.1,77.39 153.95,77.28 153.55,77.36 153.44,77.52 153.04,77.6 152.89,77.49 121.36,83.76 104.33,88.93 97.36,91.81 86.38,94 83.05,95.38 74.79,97.02 61.88,102.37 60.09,103.69 58.71,104.43 58.04,104.98 56.57,106.77 56.17,106.99 56,107.19 55.67,107.75 55.67,109.99 55.49,110.42 54.17,111.74 52.48,114.57 49.84,117.2 49.84,118.69 48.33,120.2 47.73,121.1 46.32,124.49 45.53,125.68 44.81,127.41 44.81,129.74 v2(45.18,130.11)
P3E_PESW_M2B_TX0_C_DN: length 137
  TOP w0.124: C1016.2 152.69,76.75 149.42,76.75 143.84,75.64 140.67,76.27 137.49,75.64 134.32,76.27 131.14,75.64 124.56,76.95 121.39,76.32 118.66,76.95 100.52,84.47 95,87.42 92.26,87.69 92.04,87.8 73.37,100.28 73.31,100.57 73.29,100.7 73.71,101.33 73.67,101.5 73.14,101.85 72.97,101.82 72.55,101.19 72.13,101.11 71.38,101.6 71.3,102.02 72.14,103.28 72.1,103.45 71.57,103.81 71.4,103.77 70.56,102.52 70.14,102.44 69.84,102.63 69.18,102.77 68.95,103.12 69.02,103.49 68.92,103.63 68.29,103.76 68.15,103.66 68.07,103.3 67.72,103.06 66.65,103.27 64.96,103.97 64.75,104.1 59.96,108.03 59.71,108.03 59.4,107.72 v2(59.4,107.66) ; v2(54.67,127.86) 55.03,128.22 55.03,132.63 54.93,132.72 J4.A47
  IN1 w0.136: v2(59.4,107.66) 59.03,108.03 58.82,108.03 58.52,108.33 58.35,108.73 58.35,109.97 57.81,112.69 57.81,119.96 55.41,123.55 55.23,124.15 55.04,125.44 55.04,127.5 v2(54.67,127.86)
P3E_PESW_M2B_TX0_C_DP: length 137
  TOP w0.124: v2(55.69,127.86) 55.33,128.22 55.33,132.6 55.43,132.7 J4.A49 ; v2(59.4,108.67) 59.74,108.33 60.07,108.33 64.93,104.34 65.1,104.24 66.74,103.56 67.2,103.47 67.65,103.38 67.8,103.48 67.87,103.85 68.23,104.08 69.11,103.91 69.34,103.55 69.27,103.19 69.37,103.04 69.96,102.92 70.21,102.76 70.38,102.79 71.21,104.05 71.63,104.13 72.38,103.63 72.46,103.21 71.62,101.96 71.66,101.79 72.19,101.43 72.36,101.47 72.78,102.09 73.2,102.18 73.95,101.68 74.03,101.26 73.61,100.63 73.65,100.46 92.2,88.07 92.35,87.98 95.09,87.71 100.65,84.74 118.75,77.24 121.39,76.63 124.56,77.26 131.14,75.95 134.32,76.58 137.49,75.95 140.67,76.58 143.84,75.95 149.39,77.06 152.74,77.06 C1015.2
  IN1 w0.136: v2(59.4,108.67) 59.03,108.31 58.94,108.31 58.75,108.49 58.63,108.79 58.63,110 58.58,110.26 58.53,110.5 58.64,110.67 58.56,111.07 58.39,111.18 58.31,111.58 58.42,111.74 58.35,112.14 58.18,112.25 58.09,112.72 58.09,113.13 58.23,113.27 58.23,113.67 58.09,113.81 58.09,114.22 58.23,114.36 58.23,114.77 58.09,114.91 58.09,120.05 55.67,123.67 55.5,124.21 55.32,125.46 55.32,127.5 v2(55.69,127.86)
P3E_PESW_M2B_TX0_DN: length 14.2
  TOP w0.099: U34.Y3 166.82,79.52 166.73,79.43 166.73,79.14 166.51,78.92 162.64,78.92 162.59,78.87 162.57,78.87
  TOP w0.124: C1016.1 154.28,76.77 154.87,76.77 159.94,78.87 162.57,78.87
P3E_PESW_M2B_TX0_DP: length 14.3
  TOP w0.099: U34.Y2 166.42,79.52 166.52,79.42 166.52,79.22 166.42,79.12 165.04,79.12 164.94,79.22 164.74,79.22 164.64,79.12 164.44,79.12 164.34,79.22 164.14,79.22 164.04,79.12 163.84,79.12 163.74,79.22 163.54,79.22 163.44,79.12 163.24,79.12 163.14,79.22 162.94,79.22 162.84,79.12 162.64,79.12 162.59,79.17 162.57,79.17
  TOP w0.124: 162.57,79.17 159.88,79.17 154.81,77.07 154.27,77.07 C1015.1
P3E_PESW_M2B_TX1_C_DN: length 137.3
  TOP w0.124: C1018.2 150.92,75.43 149.63,75.43 143.84,74.27 140.67,74.9 137.49,74.27 134.32,74.9 131.14,74.27 124.42,75.61 121.54,75.04 115.84,76.33 93.79,85.46 91.69,86.58 69.34,101.51 66.23,102.13 64.4,102.89 59.32,106.29 55.41,107.07 54.92,107.07 54.74,107.14 53.14,107.14 v2(52.78,106.78) ; J4.A35 51.93,132.7 52.03,132.6 52.03,132.08 v2(51.67,131.72)
  IN1 w0.136: v2(52.78,106.78) 52.42,107.15 51.76,107.15 51.23,107.59 51.04,108.52 52.25,111.43 52.25,119.12 50.31,121.06 50.03,121.74 50.03,123.96 50.76,125.73 50.78,125.78 51.62,126.62 52.04,127.62 52.04,131.35 v2(51.67,131.72)
P3E_PESW_M2B_TX1_C_DP: length 137.3
  TOP w0.124: C1017.2 150.92,75.73 149.6,75.73 143.84,74.58 140.67,75.21 137.49,74.58 134.32,75.21 131.14,74.58 124.42,75.92 121.55,75.35 115.94,76.62 93.92,85.74 91.85,86.84 69.46,101.8 66.32,102.43 64.55,103.16 59.44,106.57 55.44,107.37 54.98,107.37 54.8,107.44 53.14,107.44 v2(52.78,107.8) ; v2(52.68,131.72) 52.33,132.07 52.33,132.6 52.43,132.69 J4.A37
  IN1 w0.136: v2(52.78,107.8) 52.42,107.43 51.86,107.43 51.48,107.74 51.33,108.49 51.49,108.86 51.67,108.94 51.83,109.32 51.75,109.5 52.53,111.38 52.53,119.24 50.54,121.22 50.31,121.8 50.31,122.81 50.44,122.94 50.44,123.37 50.31,123.5 50.31,123.9 51.02,125.63 51.86,126.46 52.31,127.57 52.31,128.23 52.45,128.37 52.45,128.78 52.31,128.91 52.31,130.25 52.45,130.39 52.45,130.8 52.31,130.94 52.31,131.35 v2(52.68,131.72)
P3E_PESW_M2B_TX1_DN: length 15.1
  TOP w0.099: U34.AA2 165.84,78.52 165.74,78.42 165.74,78.08 165.52,77.86 162.65,77.86 162.6,77.81 162.57,77.81
  TOP w0.124: C1018.1 152.43,75.43 154.77,75.43 160.52,77.81 162.57,77.81
P3E_PESW_M2B_TX1_DP: length 15.1
  TOP w0.099: 162.57,78.11 162.6,78.11 162.65,78.06 162.85,78.06 162.95,78.16 163.15,78.16 163.25,78.06 163.45,78.06 163.55,78.16 163.75,78.16 163.85,78.06 164.05,78.06 164.15,78.16 164.34,78.16 164.45,78.06 165.44,78.06 165.54,78.16 165.54,78.42 165.44,78.52 U34.AA1
  TOP w0.124: 162.57,78.11 160.46,78.11 154.71,75.73 152.43,75.73 C1017.1
P3E_PESW_M2B_TX2_C_DN: length 141.8
  TOP w0.124: v2(54.14,105.39) 54.5,105.74 55.91,105.74 56.74,105.4 57.01,105.13 59.3,104.18 59.78,104.38 60.35,104.14 63.83,101.81 65.96,100.93 66.93,100.74 67.32,100.15 68.27,99.96 68.68,100.24 69.22,100.13 91.04,85.55 93.41,84.28 115.73,75.03 121.49,73.63 124.43,74.22 131.14,72.88 134.32,73.51 137.49,72.88 140.67,73.51 143.84,72.88 149.77,74.06 152.75,74.06 C1020.2 ; v2(48.67,127.74) 49.03,128.09 49.03,132.6 48.93,132.7 J4.A23
  IN1 w0.136: v2(54.14,105.39) 53.77,105.75 51.15,105.75 50.12,106.59 49.77,108.36 51.32,112.11 51.32,118.73 50.12,119.94 49.19,120.32 48.77,120.75 48.6,121.16 48.6,123.82 49.05,126.09 49.05,127.36 v2(48.67,127.74)
P3E_PESW_M2B_TX2_C_DP: length 141.8
  TOP w0.124: C1019.2 152.75,74.37 149.74,74.37 143.84,73.19 140.67,73.83 137.49,73.19 134.32,73.83 131.14,73.19 124.43,74.53 121.49,73.94 115.83,75.32 93.54,84.56 91.19,85.81 69.34,100.42 68.62,100.56 68.21,100.29 67.5,100.43 67.11,101.01 66.05,101.22 63.98,102.08 60.49,104.41 59.78,104.71 59.3,104.51 57.18,105.38 56.91,105.65 55.97,106.05 54.5,106.05 v2(54.14,106.4) ; J4.A25 49.43,132.7 49.33,132.6 49.33,128.09 v2(49.69,127.74)
  IN1 w0.136: v2(49.69,127.74) 49.33,127.38 49.33,126.06 48.88,123.79 48.88,121.21 49,120.91 49.35,120.56 50.27,120.18 51.6,118.85 51.6,112.06 50.9,110.35 50.97,110.17 50.82,109.79 50.63,109.72 50.48,109.34 50.55,109.16 50.4,108.78 50.21,108.71 50.06,108.33 50.15,107.89 50.31,107.78 50.39,107.38 50.28,107.22 50.37,106.75 51.25,106.03 51.65,106.03 51.79,106.17 52.2,106.17 52.34,106.03 53.77,106.03 v2(54.14,106.4)
P3E_PESW_M2B_TX2_DN: length 14.3
  TOP w0.099: 162.61,76.87 162.64,76.87 162.69,76.92 166.47,76.92 166.69,77.14 166.69,77.42 166.79,77.52 U34.AB3
  TOP w0.124: C1020.1 154.27,74.06 154.63,74.06 161.4,76.87 162.61,76.87
P3E_PESW_M2B_TX2_DP: length 14.3
  TOP w0.099: 162.61,77.17 162.64,77.17 162.69,77.12 162.88,77.12 162.99,77.22 163.18,77.22 163.29,77.12 163.48,77.12 163.59,77.22 163.78,77.22 163.88,77.12 164.08,77.12 164.18,77.22 164.38,77.22 164.48,77.12 164.68,77.12 164.78,77.22 164.98,77.22 165.08,77.12 166.39,77.12 166.49,77.22 166.49,77.42 166.39,77.52 U34.AB2
  TOP w0.124: 162.61,77.17 161.33,77.17 154.57,74.37 154.27,74.37 C1019.1
P3E_PESW_M2B_TX3_C_DN: length 141
  TOP w0.124: J4.A11 45.93,132.7 46.03,132.6 46.03,127.7 v2(45.66,127.33) ; v2(55.39,103.92) 55.75,104.27 55.96,104.27 58.86,103.07 65.14,99.71 71.71,96.99 90.14,84.68 92.91,83.19 115.67,73.77 121.32,72.34 124.15,72.91 131.14,71.51 134.32,72.15 137.49,71.51 140.67,72.15 143.84,71.51 149.9,72.72 150.92,72.72 C1022.2
  IN1 w0.136: v2(55.39,103.92) 55.02,104.29 50.78,104.29 49.1,105.67 48.7,107.65 48.93,109.97 49.8,112.06 49.8,115.64 49.55,116.88 49.55,118.62 47.93,120.24 47.64,120.94 47.64,122.58 46.05,126.43 46.05,126.94 v2(45.66,127.33)
P3E_PESW_M2B_TX3_C_DP: length 141
  TOP w0.124: v2(46.68,127.33) 46.33,127.68 46.33,132.6 46.43,132.7 J4.A13 ; C1021.2 150.92,73.03 149.87,73.03 143.84,71.82 140.67,72.46 137.49,71.82 134.32,72.46 131.14,71.82 124.15,73.22 121.33,72.66 115.77,74.06 93.05,83.47 90.3,84.94 71.86,97.26 65.27,99.99 58.99,103.35 56.02,104.58 55.75,104.58 v2(55.39,104.93)
  IN1 w0.136: v2(55.39,104.93) 55.02,104.57 53.26,104.57 53.12,104.7 52.71,104.7 52.57,104.57 52.17,104.57 52.03,104.7 51.62,104.7 51.48,104.57 50.88,104.57 50.57,104.82 50.55,105.02 50.23,105.28 50.04,105.26 49.35,105.82 49.27,106.22 49.38,106.38 49.3,106.78 49.14,106.89 48.99,107.66 49.21,109.9 50.08,112 50.08,115.67 49.83,116.91 49.83,118.73 48.17,120.4 47.92,120.99 47.92,122.64 46.33,126.49 46.33,126.98 v2(46.68,127.33)
P3E_PESW_M2B_TX3_DN: length 15.2
  TOP w0.099: U34.AC2 165.84,76.52 165.74,76.42 165.74,76.14 165.52,75.92 162.69,75.92 162.64,75.87 162.61,75.87
  TOP w0.124: 162.61,75.87 162.22,75.87 154.63,72.72 152.43,72.72 C1022.1
P3E_PESW_M2B_TX3_DP: length 15.2
  TOP w0.099: U34.AC1 165.44,76.52 165.54,76.42 165.54,76.22 165.44,76.12 164.49,76.12 164.38,76.22 164.19,76.22 164.09,76.12 163.89,76.12 163.79,76.22 163.59,76.22 163.49,76.12 163.29,76.12 163.19,76.22 162.99,76.22 162.89,76.12 162.69,76.12 162.64,76.17 162.61,76.17
  TOP w0.124: C1021.1 152.43,73.03 154.57,73.03 162.16,76.17 162.61,76.17
P3E_PESW_M2C_RX0_DN: length 124.2
  TOP w0.124: U34.R5 v6(168.59,85.02) ; v2(77.17,127.2) 77.53,127.56 77.53,132.6 77.43,132.69 J36.B41
  IN2 w0.099: v6(168.59,85.02) 168.3,85.02 168.2,84.92 168.2,84.64 167.98,84.42 166,84.42 165.96,84.38 165.94,84.38
  IN2 w0.136: 165.94,84.38 163.63,84.38 143.16,86.4 120.66,90.87 113.34,93.9 113.19,94.28 113.41,94.82 113.34,94.98 112.75,95.23 112.59,95.16 112.59,95.16 112.36,94.62 111.99,94.47 110.3,95.16 106.76,96.24 104.05,97.36 100.85,100.56 100,101.13 97.22,102.28 87.45,102.28 83.82,103.78 82.03,105.57 81.82,106.59 81.91,106.73 81.73,107.65 81.73,109.7 81.63,109.93 81.23,110.33 80.64,110.58 79.93,110.58 78.99,110.97 78.43,111.8 77.54,123.89 77.54,126.83 v2(77.17,127.2)
P3E_PESW_M2C_RX0_DP: length 124.2
  TOP w0.124: J36.B43 77.93,132.7 77.83,132.6 77.83,127.55 v2(78.18,127.2) ; U34.R4 v6(167.59,85.02)
  IN2 w0.099: 165.94,84.66 165.96,84.66 166,84.62 167.9,84.62 168,84.72 168,84.92 167.9,85.02 v6(167.59,85.02)
  IN2 w0.136: v2(78.18,127.2) 77.82,126.83 77.82,123.9 78.7,111.9 79.17,111.19 79.99,110.86 80.69,110.86 81.39,110.57 81.87,110.09 82.01,109.75 82.01,107.68 82.21,106.67 82.12,106.53 82.28,105.71 83.97,104.02 87.51,102.56 97.28,102.56 100.13,101.37 101.03,100.77 104.21,97.6 106.86,96.5 110.4,95.43 111.99,94.77 112.15,94.84 112.37,95.37 112.75,95.53 113.55,95.2 113.71,94.82 113.49,94.28 113.56,94.12 120.75,91.14 133.02,88.7 133.18,88.8 133.58,88.72 133.68,88.57 134.08,88.49 134.24,88.59 134.64,88.51 134.74,88.36 135.14,88.28 135.3,88.38 135.7,88.3 135.8,88.15 136.2,88.07 136.35,88.17 136.75,88.09 136.86,87.93 137.26,87.86 137.41,87.96 137.81,87.88 137.92,87.72 138.32,87.64 138.47,87.75 138.87,87.67 138.98,87.51 139.38,87.43 139.53,87.54 139.93,87.46 140.03,87.3 143.2,86.67 163.64,84.66 165.94,84.66
P3E_PESW_M2C_RX1_DN: length 124.5
  TOP w0.124: J36.B29 74.43,132.7 74.53,132.6 74.53,128.17 v2(74.17,127.81) ; U34.T6 v6(169.59,84.02)
  IN2 w0.099: v6(169.59,84.02) 169.3,84.02 169.2,83.92 169.2,83.64 168.98,83.42 166.04,83.42 166,83.38 165.98,83.38
  IN2 w0.136: v2(74.17,127.81) 74.54,127.44 74.54,126.86 75.27,123.18 75.27,122.02 75.39,120.8 75.7,119.25 76.23,117.96 76.82,115.02 77.09,112.22 77.71,110.2 77.72,110.16 80.97,105.3 83.28,102.99 87.26,101.34 97.01,101.34 99.6,100.27 103.15,96.72 118.51,90.36 144.56,85.18 155.19,84.13 155.19,84.13 162.8,83.38 165.98,83.38
P3E_PESW_M2C_RX1_DP: length 124.5
  TOP w0.124: v2(75.19,127.81) 74.83,128.17 74.83,132.6 74.93,132.7 J36.B31 ; U34.T5 v6(168.59,84.02)
  IN2 w0.099: v6(168.59,84.02) 168.9,84.02 169,83.92 169,83.72 168.9,83.62 166.04,83.62 166,83.66 165.98,83.66
  IN2 w0.136: 165.98,83.66 162.81,83.66 162.22,83.72 162.1,83.86 161.7,83.9 161.55,83.78 161.15,83.82 161.03,83.97 160.62,84.01 160.48,83.89 160.07,83.93 159.95,84.07 159.55,84.11 159.4,84 159,84.04 158.88,84.18 158.47,84.22 158.33,84.1 157.92,84.14 157.8,84.29 157.4,84.33 157.25,84.21 156.85,84.25 156.73,84.39 156.32,84.43 156.18,84.31 155.77,84.35 155.65,84.5 155.25,84.54 155.1,84.42 144.6,85.45 118.59,90.63 103.3,96.96 99.76,100.5 97.06,101.62 87.31,101.62 83.43,103.23 81.18,105.48 77.98,110.28 77.37,112.28 77.09,115.06 76.5,118.04 75.97,119.33 75.67,120.84 75.55,122.03 75.55,123.21 74.82,126.88 74.82,127.44 v2(75.19,127.81)
P3E_PESW_M2C_RX2_DN: length 129.6
  TOP w0.124: U34.U5 v6(168.59,83.02) ; J36.B17 71.43,132.7 71.53,132.6 71.53,130.4 v2(71.18,130.04)
  IN2 w0.099: 165.92,82.38 165.95,82.38 165.99,82.42 167.98,82.42 168.2,82.64 168.2,82.92 168.3,83.02 v6(168.59,83.02)
  IN2 w0.136: v2(71.18,130.04) 71.55,129.68 71.55,127.03 71.61,126.36 71.5,126.22 70.37,126.11 70.11,125.79 70.19,124.93 70.51,124.67 71.64,124.78 71.78,124.66 72.09,121.52 72.43,119.82 74.37,113.4 75.36,111.02 75.56,109 76.27,107.03 76.28,107 76.91,106.05 80.25,104.67 82.68,102.23 87.14,100.39 96.75,100.39 99.08,99.42 104.93,93.57 104.93,93.57 104.97,93.53 105.32,93.39 118.22,89.47 145.81,83.99 162.11,82.38 165.92,82.38
P3E_PESW_M2C_RX2_DP: length 129.6
  TOP w0.124: v2(72.19,130.04) 71.84,130.4 71.84,132.61 71.93,132.7 J36.B19 ; U34.U4 v6(167.59,83.02)
  IN2 w0.099: v6(167.59,83.02) 167.9,83.02 168,82.92 168,82.72 167.9,82.62 165.99,82.62 165.95,82.66 165.92,82.66
  IN2 w0.136: v2(72.19,130.04) 71.83,129.68 71.83,127.04 71.9,126.27 71.64,125.95 70.51,125.84 70.4,125.7 70.46,125.07 70.6,124.96 71.73,125.07 72.05,124.81 72.37,121.56 72.7,119.89 74.64,113.5 75.64,111.09 75.84,109.06 76.53,107.12 77.1,106.28 77.1,106.27 80.41,104.9 82.84,102.47 87.19,100.67 96.8,100.67 99.24,99.66 105.13,93.77 105.41,93.65 118.28,89.75 145.85,84.26 153.84,83.48 153.99,83.59 154.39,83.55 154.51,83.41 154.92,83.37 155.06,83.49 155.47,83.45 155.59,83.3 155.99,83.26 156.14,83.38 156.54,83.34 156.66,83.2 157.07,83.16 157.21,83.28 157.62,83.24 157.74,83.09 158.14,83.05 158.29,83.17 158.69,83.13 158.81,82.99 159.22,82.95 159.36,83.06 159.77,83.02 159.89,82.88 160.29,82.84 160.44,82.96 160.84,82.92 160.96,82.77 162.13,82.66 165.92,82.66
P3E_PESW_M2C_RX3_DN: length 130.6
  TOP w0.124: v2(68.2,130.07) 68.55,130.42 68.55,130.85 68.53,132.2 68.53,132.59 68.43,132.7 J36.B5 ; U34.V6 v6(169.59,82.02)
  IN2 w0.136: v2(68.2,130.07) 68.57,129.71 68.57,124.27 69.35,122.37 70.14,121.19 70.85,119.48 71.96,117.82 72.34,116.91 72.73,114.96 74.4,110.93 74.6,108.84 75.44,106.5 76.19,105.38 76.19,105.38 76.23,105.31 79.73,103.86 82.16,101.43 87.38,99.27 96.71,99.27 98.68,98.45 104.41,92.72 104.6,92.64 118.09,88.55 148.17,82.56 153.31,82.06 153.31,82.06 164.84,80.92 168.93,80.92 169.24,81.23 169.24,81.67 v6(169.59,82.02)
P3E_PESW_M2C_RX3_DP: length 130.6
  TOP w0.124: U34.V5 v6(168.59,82.02) ; J36.B7 68.93,132.7 68.84,132.61 68.84,132.2 68.86,130.86 68.86,130.43 v2(69.22,130.07)
  IN2 w0.136: v2(69.22,130.07) 68.85,129.7 68.85,124.33 69.6,122.51 70.39,121.33 71.1,119.61 72.21,117.95 72.61,116.99 73,115.04 74.67,111 74.88,108.9 75.28,107.76 75.69,106.62 76.42,105.54 79.89,104.1 82.32,101.67 87.44,99.55 96.77,99.55 98.83,98.69 104.57,92.95 104.69,92.9 118.15,88.82 148.21,82.84 153.22,82.35 153.37,82.47 153.77,82.43 153.89,82.28 154.3,82.24 154.44,82.36 154.85,82.32 154.97,82.18 155.37,82.14 155.52,82.26 155.92,82.22 156.04,82.07 156.45,82.03 156.59,82.15 157,82.11 157.12,81.96 157.52,81.92 157.67,82.04 158.07,82 158.19,81.86 158.6,81.82 158.74,81.94 159.15,81.9 159.26,81.75 159.67,81.71 159.81,81.83 160.22,81.79 160.34,81.65 160.74,81.61 160.89,81.73 161.3,81.69 161.42,81.54 164.86,81.2 168.81,81.2 168.96,81.35 168.96,81.65 v6(168.59,82.02)
P3E_PESW_M2C_TX0_C_DN: length 113
  TOP w0.124: v2(79.98,109.47) 80.34,109.11 80.34,108.15 80.18,107.76 80.18,106.72 80.75,105.34 81.31,104.78 82.19,103.71 82.61,103.67 83.19,104.14 83.74,104.09 83.83,103.98 83.81,103.71 83.78,103.45 83.19,102.97 83.14,102.42 83.42,102.08 85.16,100.92 85.58,101 85.77,101.28 85.94,101.32 86.47,100.96 86.5,100.79 86.32,100.51 86.4,100.09 104.29,88.13 117.75,82.56 121.86,81.61 125.36,82.31 131.14,81.15 134.32,81.78 137.49,81.15 140.67,81.78 143.84,81.15 148.96,82.17 152.75,82.17 C432.2 ; v2(78.66,131.39) 79.02,131.75 79.02,132.61 78.93,132.7 J36.B47
  IN1 w0.136: v2(79.98,109.47) 80.35,109.84 80.35,117.42 79.85,118.63 78.75,119.73 78.08,121.37 78.08,124.67 79.03,126.96 79.03,131.02 v2(78.66,131.39)
P3E_PESW_M2C_TX0_C_DP: length 113
  TOP w0.124: v2(79.68,131.39) 79.33,131.74 79.33,132.6 79.43,132.7 J36.B49 ; v2(81,109.47) 80.64,109.11 80.64,108.09 80.48,107.7 80.48,106.78 81.01,105.52 81.54,104.98 82.34,104.01 82.52,103.99 83.09,104.46 83.9,104.38 84.15,104.07 84.07,103.3 83.48,102.81 83.46,102.52 83.63,102.3 85.22,101.24 85.39,101.27 85.58,101.56 86,101.64 86.74,101.14 86.83,100.72 86.64,100.44 86.67,100.27 91.02,97.36 91.23,97.4 91.54,97.2 91.58,96.99 91.91,96.77 92.11,96.81 92.42,96.6 92.47,96.4 92.78,96.19 92.98,96.23 93.29,96.03 93.33,95.82 93.64,95.61 93.84,95.66 94.16,95.45 94.2,95.24 104.44,88.4 117.84,82.85 121.86,81.92 125.36,82.62 131.14,81.46 134.32,82.1 137.49,81.46 140.67,82.1 143.84,81.46 148.93,82.48 152.75,82.48 C431.2
  IN1 w0.136: v2(81,109.47) 80.63,109.84 80.63,117.48 80.09,118.79 78.99,119.89 78.35,121.42 78.35,124.61 79.31,126.91 79.31,131.02 v2(79.68,131.39)
P3E_PESW_M2C_TX0_DN: length 13.1
  TOP w0.099: U34.R2 165.79,84.52 165.69,84.42 165.69,84.14 165.47,83.92 162.46,83.92 162.21,83.81 162,83.81 161.95,83.76 161.93,83.76
  TOP w0.124: 161.93,83.76 159.18,83.76 155.34,82.17 154.27,82.17 C432.1
P3E_PESW_M2C_TX0_DP: length 13.1
  TOP w0.099: U34.R1 165.39,84.52 165.49,84.42 165.49,84.22 165.39,84.12 164.82,84.12 164.72,84.22 164.52,84.22 164.42,84.12 164.22,84.12 164.12,84.22 163.92,84.22 163.82,84.12 163.62,84.12 163.52,84.22 163.32,84.22 163.22,84.12 163.02,84.12 162.92,84.22 162.72,84.22 162.62,84.12 162.42,84.12 162.17,84.02 162,84.02 161.95,84.07 161.93,84.07
  TOP w0.124: C431.1 154.27,82.48 155.28,82.48 159.12,84.07 161.93,84.07
P3E_PESW_M2C_TX1_C_DN: length 110.5
  TOP w0.124: J36.B35 75.93,132.7 76.03,132.6 76.03,131.99 v2(75.67,131.63) ; v2(77.72,106.81) 78.07,106.46 78.07,105.84 78.24,105.36 81.16,101.81 102.4,87.61 118.07,81.12 121.6,80.31 125.1,81.01 131.14,79.8 134.32,80.43 137.49,79.8 140.67,80.43 143.84,79.8 149.09,80.85 150.91,80.85 C434.2
  IN1 w0.136: v2(75.67,131.63) 76.04,131.26 76.04,126.53 77.14,123.86 77.14,120.96 78.53,117.61 78.53,109.14 78.09,108.08 78.09,107.18 v2(77.72,106.81)
P3E_PESW_M2C_TX1_C_DP: length 110.5
  TOP w0.124: C433.2 150.94,81.15 149.06,81.15 143.84,80.11 140.67,80.74 137.49,80.11 134.32,80.74 131.14,80.11 125.1,81.32 121.61,80.62 118.17,81.41 102.55,87.88 82.23,101.46 82.19,101.66 81.88,101.87 81.68,101.83 81.37,102.04 80.71,102.84 80.73,103.04 80.49,103.33 80.28,103.35 80.05,103.64 80.07,103.85 79.83,104.14 79.62,104.16 79.39,104.45 79.41,104.65 79.17,104.94 78.96,104.96 78.51,105.51 78.38,105.89 78.38,106.45 v2(78.74,106.81) ; v2(76.68,131.63) 76.33,131.98 76.33,132.6 76.43,132.7 J36.B37
  IN1 w0.136: v2(78.74,106.81) 78.37,107.18 78.37,108.03 78.81,109.08 78.81,117.66 77.42,121.02 77.42,123.92 76.32,126.58 76.32,131.26 v2(76.68,131.63)
P3E_PESW_M2C_TX1_DN: length 16
  TOP w0.099: U34.T3 166.79,83.52 166.69,83.42 166.69,83.14 166.47,82.92 162.27,82.92 162.22,82.87 162.19,82.87
  TOP w0.124: C434.1 152.43,80.83 154.87,80.83 159.78,82.87 162.19,82.87
P3E_PESW_M2C_TX1_DP: length 16
  TOP w0.099: 162.19,83.17 162.22,83.17 162.27,83.12 162.47,83.12 162.57,83.22 162.77,83.22 162.87,83.12 163.07,83.12 163.17,83.22 163.37,83.22 163.47,83.12 163.67,83.12 163.77,83.22 163.97,83.22 164.07,83.12 164.27,83.12 164.37,83.22 164.57,83.22 164.67,83.12 166.39,83.12 166.49,83.22 166.49,83.42 166.39,83.52 U34.T2
  TOP w0.124: 162.19,83.17 159.72,83.17 154.81,81.14 152.43,81.14 C433.1
P3E_PESW_M2C_TX2_C_DN: length 121
  TOP w0.124: v2(75.49,103.2) 75.87,102.81 75.87,102.66 76.15,102.38 78.25,102.38 80.91,99.72 81.78,99.14 81.78,99.14 83.87,97.74 83.91,97.52 83.8,97.36 83.8,96.58 84.44,96.16 84.86,96.24 85.18,96.72 85.35,96.75 85.88,96.4 85.92,96.22 85.6,95.74 85.68,95.32 86.42,94.83 86.84,94.91 87.16,95.39 88.25,95.61 101.77,86.57 118.64,79.58 121.47,78.93 124.97,79.63 124.97,79.63 125.85,79.45 131.14,78.39 134.32,79.03 137.49,78.39 140.67,79.03 143.84,78.39 149.23,79.47 152.75,79.47 C436.2 ; v2(72.64,131.56) 73,131.92 73,132.12 73.03,132.5 73.03,132.61 72.93,132.7 J36.B23
  IN1 w0.136: v2(72.64,131.56) 73.01,131.19 73.01,131 73.15,130.66 73.36,130.45 73.48,129.88 73.09,128.95 72,127.86 71.74,127.24 71.74,122.93 72.97,119.97 72.97,118.76 73.71,115.03 74.18,113.89 74.18,112 74.83,110.43 74.83,109.23 74.25,107.83 74.25,106.14 74.74,104.94 75.77,103.91 75.86,103.7 75.86,103.56 v2(75.49,103.2)
P3E_PESW_M2C_TX2_C_DP: length 121
  TOP w0.124: v2(73.66,131.56) 73.31,131.91 73.31,132.11 73.33,132.49 73.33,132.6 73.43,132.7 J36.B25 ; C435.2 152.75,79.78 149.2,79.78 143.84,78.7 140.67,79.34 137.49,78.7 134.32,79.34 131.14,78.7 124.97,79.94 121.47,79.24 118.74,79.87 101.92,86.84 88.31,95.93 86.98,95.66 86.66,95.19 86.49,95.15 85.96,95.51 85.92,95.68 86.24,96.16 86.16,96.58 85.41,97.08 84.99,96.99 84.67,96.51 84.5,96.48 84.11,96.74 84.11,97.27 84.24,97.46 84.14,97.92 83.46,98.38 83.42,98.63 83.1,98.83 82.86,98.78 82.06,99.32 82.01,99.57 81.7,99.77 81.45,99.72 81.1,99.96 80.22,100.84 80.22,101.07 80,101.29 79.77,101.29 79.31,101.75 79.31,101.94 79.04,102.2 78.86,102.2 78.38,102.68 76.28,102.68 76.18,102.79 76.18,102.86 76.18,102.87 v2(76.5,103.2)
  IN1 w0.136: v2(73.66,131.56) 73.29,131.19 73.29,131.06 73.39,130.82 73.62,130.59 73.77,129.85 73.33,128.79 72.24,127.7 72.02,127.18 72.02,122.99 73.25,120.03 73.25,118.79 73.98,115.11 74.46,113.95 74.46,112.05 75.11,110.48 75.11,109.18 74.53,107.78 74.53,106.19 74.98,105.1 76.01,104.07 76.14,103.75 76.14,103.56 v2(76.5,103.2)
P3E_PESW_M2C_TX2_DN: length 13.2
  TOP w0.099: U34.U2 165.79,82.52 165.69,82.42 165.69,82.14 165.47,81.92 162.34,81.92 162.29,81.87 162.26,81.87
  TOP w0.124: 162.26,81.87 160.74,81.87 154.95,79.47 154.27,79.47 C436.1
P3E_PESW_M2C_TX2_DP: length 13.2
  TOP w0.099: 162.26,82.17 162.29,82.17 162.34,82.12 162.54,82.12 162.64,82.22 162.84,82.22 162.94,82.12 163.14,82.12 163.24,82.22 163.44,82.22 163.54,82.12 163.74,82.12 163.84,82.22 164.04,82.22 164.14,82.12 164.34,82.12 164.44,82.22 164.64,82.22 164.74,82.12 165.39,82.12 165.49,82.22 165.49,82.42 165.39,82.52 U34.U1
  TOP w0.124: 162.26,82.17 160.68,82.17 154.89,79.78 154.27,79.78 C435.1
P3E_PESW_M2C_TX3_C_DN: length 117.6
  TOP w0.124: C438.2 150.92,78.13 149.36,78.13 143.84,77.03 140.67,77.66 137.49,77.03 134.32,77.66 131.14,77.03 124.83,78.29 121.33,77.59 118.95,78.14 101.05,85.56 94.73,88.94 92.51,89.16 90.86,90.03 76.65,99.53 76.51,99.8 76.51,100.1 v2(76.15,100.46) ; v2(69.68,127.44) 70.04,127.8 70.04,128.43 70.02,129.33 70.02,132.61 69.93,132.71 J36.B11
  IN1 w0.136: v2(69.68,127.44) 70.05,127.07 70.05,125.46 70.47,124.44 70.81,122.72 71.94,120 71.94,119.14 72.81,114.74 73.24,113.7 73.24,111.4 73.8,110.05 73.8,109.23 73.3,108.01 73.3,105.83 73.91,104.37 73.91,103.71 74.97,102.12 76.32,101.56 76.52,101.26 76.52,100.83 v2(76.15,100.46)
P3E_PESW_M2C_TX3_C_DP: length 117.6
  TOP w0.124: C437.2 150.92,78.43 149.33,78.43 143.84,77.34 140.67,77.97 137.49,77.34 134.32,77.97 131.14,77.34 124.83,78.6 121.34,77.9 119.04,78.43 101.18,85.83 94.82,89.23 92.6,89.45 91.02,90.3 83.22,95.51 83.17,95.75 82.86,95.96 82.62,95.91 82.31,96.12 82.26,96.36 81.95,96.57 81.7,96.52 81.39,96.73 81.34,96.98 81.03,97.18 80.78,97.13 76.88,99.74 76.81,99.87 76.81,100.17 77.09,100.46 v2(77.17,100.46) ; J36.B13 70.43,132.7 70.33,132.6 70.33,129.33 70.34,128.43 70.34,127.79 v2(70.69,127.44)
  IN1 w0.136: v2(70.69,127.44) 70.33,127.07 70.33,125.51 70.74,124.52 71.08,122.81 72.22,120.06 72.22,119.17 73.08,114.82 73.52,113.76 73.52,111.46 74.08,110.1 74.08,109.17 73.58,107.96 73.58,105.89 74.19,104.42 74.19,103.79 75.15,102.34 76.51,101.78 76.8,101.35 76.8,100.83 v2(77.17,100.46)
P3E_PESW_M2C_TX3_DN: length 16.3
  TOP w0.099: 162.45,80.87 162.47,80.87 162.52,80.92 166.47,80.92 166.69,81.14 166.69,81.42 166.79,81.52 U34.V3
  TOP w0.124: 162.45,80.87 160.78,80.87 160.21,80.63 159.65,80.07 154.96,78.13 152.43,78.13 C438.1
P3E_PESW_M2C_TX3_DP: length 16.3
  TOP w0.099: 162.45,81.17 162.47,81.17 162.52,81.12 162.75,81.12 162.85,81.22 163.05,81.22 163.15,81.12 163.35,81.12 163.45,81.22 163.65,81.22 163.75,81.12 163.95,81.12 164.05,81.22 164.25,81.22 164.35,81.12 164.55,81.12 164.65,81.22 164.85,81.22 164.95,81.12 166.39,81.12 166.49,81.22 166.49,81.42 166.39,81.52 U34.V2
  TOP w0.124: C437.1 152.43,78.43 154.9,78.43 159.48,80.33 160.04,80.89 160.72,81.17 162.45,81.17
P3E_PESW_M2D_RX0_DN: length 104.8
  TOP w0.124: U34.L5 v6(168.59,89.02) ; v2(101.16,127.82) 101.51,128.18 101.51,128.87 101.82,129.17 102.94,129.17 103.06,129.29 103.06,129.93 102.94,130.06 101.82,130.06 101.51,130.36 101.51,132.61 101.43,132.69 J36.A41
  IN2 w0.099: v6(168.59,89.02) 168.3,89.02 168.2,88.92 168.2,88.64 167.98,88.42 165.18,88.42 165.14,88.38 165.12,88.38
  IN2 w0.136: v2(101.16,127.82) 101.53,127.46 101.53,126.67 100.92,126.06 99.8,126.06 99.19,125.44 99.19,120.21 99,119.24 99,117.26 100.13,114.53 100.13,111.77 100.52,110.82 100.52,110.82 100.52,107.66 100.75,106.51 101.08,105.7 101.47,105.31 106.53,101.93 115.55,98.2 116.43,97.32 117.84,96.28 119.87,95.37 145.37,90.29 145.38,90.29 156.09,89.23 164.7,88.38 165.12,88.38
P3E_PESW_M2D_RX0_DP: length 104.9
  TOP w0.124: J36.A43 101.93,132.7 101.82,132.59 101.82,130.49 101.94,130.36 103.06,130.36 103.37,130.06 103.37,129.17 103.06,128.86 101.94,128.86 101.82,128.74 101.82,128.18 v2(102.18,127.82) ; U34.L4 v6(167.59,89.02)
  IN2 w0.099: v6(167.59,89.02) 167.9,89.02 168,88.92 168,88.72 167.9,88.62 165.18,88.62 165.14,88.66 165.12,88.66
  IN2 w0.136: 165.12,88.66 164.71,88.66 163.12,88.82 163,88.96 162.59,89 162.45,88.88 162.04,88.92 161.92,89.07 161.52,89.11 161.37,88.99 160.97,89.03 160.85,89.17 160.44,89.21 160.3,89.1 159.89,89.14 159.77,89.28 159.37,89.32 159.22,89.2 158.82,89.24 158.7,89.39 158.29,89.43 158.15,89.31 157.74,89.35 157.63,89.49 157.22,89.53 157.08,89.41 156.67,89.45 156.55,89.6 156.15,89.64 156,89.52 145.42,90.57 119.96,95.64 117.98,96.52 116.61,97.53 115.71,98.43 106.66,102.18 101.65,105.53 101.32,105.86 101.02,106.59 100.8,107.69 100.8,110.87 100.41,111.82 100.41,114.59 99.28,117.31 99.28,119.21 99.47,120.18 99.47,125.33 99.92,125.78 101.03,125.78 101.81,126.55 101.81,127.46 v2(102.18,127.82)
P3E_PESW_M2D_RX1_DN: length 105.2
  TOP w0.124: v2(98.18,130.22) 98.53,130.57 98.53,132.6 98.43,132.7 J36.A29 ; U34.M6 v6(169.59,88.02)
  IN2 w0.099: v6(169.59,88.02) 169.3,88.02 169.2,87.92 169.2,87.64 168.98,87.42 165.91,87.42 165.87,87.38 165.85,87.38
  IN2 w0.136: 165.85,87.38 164.03,87.38 156.24,88.15 156.12,88.16 156.12,88.16 146.3,89.13 119.41,94.48 118.79,94.7 116.39,95.98 114.97,97.4 104.9,101.58 102.75,103.35 101.25,104.15 100.23,104.99 99.78,105.82 99.46,106.88 99.46,110.81 99.46,110.81 98.98,111.96 98.98,114.56 98.06,116.8 98.06,118.09 97.91,118.69 96.47,121.37 96.07,122.35 96.07,125.22 97.02,126.17 97.54,126.17 98.77,127.4 98.77,128.16 98.54,129.31 98.54,129.85 v2(98.18,130.22)
P3E_PESW_M2D_RX1_DP: length 105.3
  TOP w0.124: U34.M5 v6(168.59,88.02) ; v2(99.19,130.22) 98.83,130.58 98.83,132.6 98.93,132.7 J36.A31
  IN2 w0.099: v6(168.59,88.02) 168.9,88.02 169,87.92 169,87.72 168.9,87.62 165.91,87.62 165.87,87.66 165.85,87.66
  IN2 w0.136: v2(99.19,130.22) 98.82,129.85 98.82,129.33 99.05,128.19 99.05,127.28 97.66,125.89 97.14,125.89 96.35,125.11 96.35,122.41 96.73,121.49 98.17,118.79 98.34,118.13 98.34,116.85 99.26,114.61 99.26,112.02 99.74,110.86 99.74,106.92 100.04,105.93 100.45,105.17 101.41,104.38 102.91,103.58 105.05,101.82 115.13,97.64 116.56,96.21 118.9,94.95 119.49,94.75 146.34,89.4 156.15,88.44 156.15,88.44 156.29,88.56 156.7,88.52 156.82,88.37 157.22,88.33 157.37,88.45 157.77,88.41 157.89,88.27 158.3,88.23 158.44,88.34 158.85,88.3 158.97,88.16 159.37,88.12 159.52,88.24 159.92,88.2 160.04,88.05 160.45,88.01 160.59,88.13 161,88.09 161.12,87.95 161.52,87.91 161.67,88.03 162.07,87.99 162.19,87.84 162.6,87.8 162.74,87.92 163.15,87.88 163.27,87.74 164.05,87.66 165.85,87.66
P3E_PESW_M2D_RX2_DN: length 106.1
  TOP w0.124: J36.A17 95.43,132.7 95.53,132.6 95.53,131.31 95.51,130.21 95.51,129.56 v2(95.15,129.21) ; U34.N5 v6(168.59,87.02)
  IN2 w0.099: 165.93,86.38 165.96,86.38 165.99,86.42 167.98,86.42 168.2,86.64 168.2,86.92 168.3,87.02 v6(168.59,87.02)
  IN2 w0.136: v2(95.15,129.21) 95.52,128.84 95.52,126.43 94.77,124.61 94.77,122.68 95.36,116.67 95.8,115.73 96.92,114.61 97.73,114.07 97.93,113.6 97.93,108.24 97.37,106.88 97.37,105.85 97.83,104.73 98.24,104.32 101.26,103.07 103.76,101.02 114.45,96.59 116.36,94.68 118.95,93.61 147.54,87.92 155.29,87.15 155.41,87.14 163.15,86.38 165.93,86.38
P3E_PESW_M2D_RX2_DP: length 106.1
  TOP w0.124: J36.A19 95.93,132.7 95.83,132.6 95.83,131.31 95.81,130.21 95.81,129.57 v2(96.17,129.21) ; U34.N4 v6(167.59,87.02)
  IN2 w0.099: 165.93,86.66 165.96,86.66 165.99,86.62 167.9,86.62 168,86.72 168,86.92 167.9,87.02 v6(167.59,87.02)
  IN2 w0.136: v2(96.17,129.21) 95.8,128.84 95.8,126.38 95.05,124.55 95.05,122.69 95.63,116.75 96.04,115.89 97.1,114.83 97.96,114.25 98.21,113.66 98.21,108.18 97.64,106.83 97.64,105.91 98.07,104.89 98.4,104.55 101.41,103.31 103.9,101.26 114.61,96.82 116.52,94.91 119.03,93.87 147.58,88.19 155.32,87.43 155.32,87.43 155.47,87.55 155.87,87.51 155.99,87.37 156.4,87.33 156.54,87.44 156.95,87.4 157.06,87.26 157.47,87.22 157.61,87.34 158.02,87.3 158.14,87.15 158.54,87.11 158.69,87.23 159.09,87.19 159.21,87.05 159.62,87.01 159.76,87.13 160.17,87.09 160.29,86.94 160.69,86.9 160.84,87.02 161.24,86.98 161.36,86.84 161.77,86.8 161.91,86.92 162.32,86.88 162.44,86.73 163.16,86.66 165.93,86.66
P3E_PESW_M2D_RX3_DN: length 108.5
  TOP w0.124: U34.P6 v6(169.59,86.02) ; v2(92.19,130.12) 92.55,130.48 92.55,131.22 92.53,132.26 92.53,132.6 92.43,132.7 J36.A5
  IN2 w0.099: 165.97,85.38 165.99,85.38 166.03,85.42 168.98,85.42 169.2,85.64 169.2,85.92 169.3,86.02 v6(169.59,86.02)
  IN2 w0.136: v2(92.19,130.12) 92.56,129.76 92.56,125.2 94.97,108.97 97.04,103.97 97.24,103.67 98.12,103.08 99.12,102.88 103.68,99.84 107.57,98.23 108.15,97.36 108.57,96.93 109.45,96.93 110.27,97.27 113.93,95.76 115.78,93.91 120.18,92.09 133.46,89.45 144.18,87.32 163.82,85.38 165.97,85.38
P3E_PESW_M2D_RX3_DP: length 108.5
  TOP w0.124: v2(93.21,130.12) 92.86,130.48 92.86,131.22 92.83,132.27 92.83,132.6 92.93,132.7 J36.A7 ; U34.P5 v6(168.59,86.02)
  IN2 w0.099: 165.97,85.66 165.99,85.66 166.03,85.62 168.9,85.62 169,85.72 169,85.92 168.9,86.02 v6(168.59,86.02)
  IN2 w0.136: 165.97,85.66 163.84,85.66 144.22,87.59 140.41,88.35 140.31,88.5 139.91,88.58 139.76,88.48 139.35,88.56 139.25,88.71 138.85,88.79 138.7,88.69 138.3,88.77 138.19,88.92 137.79,89 137.64,88.9 137.24,88.98 137.13,89.14 136.73,89.22 136.58,89.11 136.18,89.19 136.08,89.35 135.68,89.43 135.52,89.32 135.12,89.4 135.02,89.56 134.62,89.64 134.46,89.53 134.06,89.61 133.96,89.77 133.56,89.85 133.4,89.74 120.26,92.36 115.93,94.15 114.09,95.99 110.27,97.57 109.4,97.21 108.69,97.21 108.37,97.53 107.75,98.45 103.81,100.08 99.23,103.15 98.23,103.35 97.83,103.61 97.83,103.61 97.44,103.87 97.29,104.1 95.24,109.04 92.84,125.22 92.84,129.76 v2(93.21,130.12)
P3E_PESW_M2D_TX0_C_DN: length 93.5
  TOP w0.124: v2(102.69,131.38) 103.04,131.72 103.04,132.6 102.93,132.71 J36.A47 ; v2(105.94,97.68) 106.29,97.33 106.29,96.38 111.52,91.15 112.12,90.73 117.08,88.38 122.8,86.93 126.3,87.63 131.14,86.67 134.32,87.3 137.49,86.67 140.67,87.3 143.84,86.67 148.42,87.58 152.75,87.58 C424.2
  IN1 w0.136: v2(105.94,97.68) 106.31,98.05 106.31,99.19 105.6,102.74 105.6,109.17 104.47,111.91 104.47,112.92 105.69,115.87 105.69,117.68 105.47,118.8 103.6,123.31 103.41,125.24 103.27,125.35 102.22,125.25 101.91,125.51 101.82,126.37 102.08,126.69 102.85,126.76 103.06,127 103.06,128.67 102.92,128.8 102.08,128.8 101.79,129.1 101.79,129.96 102.08,130.26 102.92,130.26 103.06,130.4 103.06,131.01 v2(102.69,131.38)
P3E_PESW_M2D_TX0_C_DP: length 93.5
  TOP w0.124: J36.A49 103.43,132.7 103.34,132.61 103.34,131.74 v2(103.7,131.38) ; C423.2 152.76,87.89 148.39,87.89 143.84,86.98 140.67,87.61 137.49,86.98 134.32,87.61 131.14,86.98 126.3,87.95 122.8,87.25 117.18,88.66 112.27,90.99 111.72,91.38 110.08,93.02 110.08,93.22 109.82,93.49 109.61,93.49 109.35,93.75 109.35,93.96 109.08,94.23 108.87,94.23 108.61,94.49 108.61,94.7 108.34,94.96 108.13,94.96 107.87,95.23 107.87,95.44 107.61,95.7 107.4,95.7 106.59,96.51 106.59,97.32 v2(106.95,97.68)
  IN1 w0.136: v2(103.7,131.38) 103.33,131.01 103.33,130.28 103.04,129.98 102.2,129.98 102.06,129.85 102.06,129.22 102.2,129.08 103.04,129.08 103.33,128.78 103.33,126.9 102.99,126.5 102.22,126.42 102.11,126.28 102.17,125.65 102.31,125.54 103.36,125.64 103.68,125.38 103.88,123.38 105.74,118.88 105.97,117.71 105.97,115.81 104.75,112.87 104.75,111.96 105.88,109.23 105.88,102.77 106.59,99.22 106.59,98.05 v2(106.95,97.68)
P3E_PESW_M2D_TX0_DN: length 12.8
  TOP w0.099: U34.L2 165.79,88.52 165.69,88.42 165.69,88.14 165.47,87.92 163.04,87.92 162.48,87.69 162.21,87.69 162.16,87.64 162.14,87.64
  TOP w0.124: 162.14,87.64 154.32,87.64 C424.1
P3E_PESW_M2D_TX0_DP: length 12.8
  TOP w0.099: U34.L1 165.39,88.52 165.49,88.42 165.49,88.22 165.39,88.12 164.8,88.12 164.7,88.22 164.5,88.22 164.4,88.12 164.2,88.12 164.1,88.22 163.9,88.22 163.8,88.12 163.6,88.12 163.5,88.22 163.3,88.22 163.2,88.12 163,88.12 162.44,87.89 162.21,87.89 162.16,87.94 162.14,87.94
  TOP w0.124: C423.1 154.21,87.94 158.35,87.94 158.49,88.08 158.86,88.08 159,87.94 162.14,87.94
P3E_PESW_M2D_TX1_C_DN: length 90.4
  TOP w0.124: v2(105.92,94.26) 106.27,93.9 106.27,93.36 106.89,92.74 113.61,88.25 116.36,87.06 122.49,85.64 125.95,86.33 131.14,85.3 134.32,85.93 137.49,85.3 140.67,85.93 143.84,85.3 148.56,86.24 150.92,86.24 C426.2 ; J36.A35 99.93,132.69 100.03,132.6 100.03,132.03 v2(99.66,131.66)
  IN1 w0.136: v2(99.66,131.66) 100.03,131.29 100.03,127.65 100.61,125.76 102.86,122.38 103.89,119.89 103.89,114.02 103.51,113.09 103.51,111.76 104.67,108.96 104.67,97.42 104.91,96.84 106.18,95.57 106.29,95.31 106.29,94.63 v2(105.92,94.26)
P3E_PESW_M2D_TX1_C_DP: length 90.4
  TOP w0.124: J36.A37 100.43,132.69 100.33,132.6 100.33,132.01 v2(100.68,131.66) ; C425.2 150.92,86.54 148.53,86.54 143.84,85.61 140.67,86.24 137.49,85.61 134.32,86.24 131.14,85.61 125.95,86.64 122.49,85.95 116.46,87.35 113.76,88.52 113.3,88.82 113.26,89.03 112.95,89.24 112.74,89.2 109.82,91.15 109.78,91.35 109.47,91.56 109.26,91.52 108.95,91.73 108.91,91.94 108.6,92.14 108.39,92.1 108.08,92.31 108.04,92.52 107.73,92.72 107.52,92.68 107.08,92.98 106.58,93.48 106.58,93.9 v2(106.93,94.26)
  IN1 w0.136: v2(100.68,131.66) 100.31,131.29 100.31,127.69 100.86,125.88 103.11,122.52 104.17,119.95 104.17,113.96 103.79,113.03 103.79,111.82 104.95,109.02 104.95,97.47 105.14,97 106.42,95.73 106.57,95.37 106.57,94.63 v2(106.93,94.26)
P3E_PESW_M2D_TX1_DN: length 15.7
  TOP w0.099: 162.15,86.77 162.17,86.77 162.22,86.82 162.76,86.82 163,86.92 166.47,86.92 166.69,87.14 166.69,87.42 166.79,87.52 U34.M3
  TOP w0.124: 162.15,86.77 157.3,86.77 156.03,86.24 152.43,86.24 C426.1
P3E_PESW_M2D_TX1_DP: length 15.7
  TOP w0.099: 162.15,87.07 162.17,87.07 162.22,87.02 162.72,87.02 162.96,87.12 163.16,87.12 163.26,87.22 163.46,87.22 163.56,87.12 163.76,87.12 163.86,87.22 164.06,87.22 164.16,87.12 164.36,87.12 164.46,87.22 164.66,87.22 164.76,87.12 164.96,87.12 165.06,87.22 165.26,87.22 165.36,87.12 166.39,87.12 166.49,87.22 166.49,87.42 166.39,87.52 U34.M2
  TOP w0.124: 162.15,87.07 157.24,87.07 155.96,86.54 152.43,86.54 C425.1
P3E_PESW_M2D_TX2_C_DN: length 101.5
  TOP w0.124: J36.A23 96.93,132.7 97.03,132.6 97.03,131.94 v2(96.67,131.58) ; C428.2 152.75,84.88 148.69,84.88 143.84,83.91 140.67,84.54 137.49,83.91 134.32,84.54 131.14,83.91 125.69,85 122.57,84.38 116.03,85.89 111.46,87.78 102.21,93.97 101.42,94.75 101.2,95.3 101.77,96.68 101.65,96.99 99.71,97.79 99.55,97.72 98.97,96.32 98.57,96.15 96.77,96.9 96.55,97.24 96.55,97.51 v2(96.19,97.87)
  IN1 w0.136: v2(96.67,131.58) 97.04,131.21 97.04,129.04 96.62,128.02 95.78,123.82 95.22,118.16 95.22,111.14 95.82,108.12 96.29,107 96.49,106.35 96.88,104.37 96.88,103.75 96.56,100.49 96.56,98.23 v2(96.19,97.87)
P3E_PESW_M2D_TX2_C_DP: length 101.5
  TOP w0.124: v2(97.69,131.58) 97.33,131.94 97.33,132.6 97.43,132.7 J36.A25 ; C427.2 152.75,85.18 148.66,85.18 143.84,84.22 140.67,84.85 137.49,84.22 134.32,84.85 131.14,84.22 125.69,85.31 122.58,84.69 116.12,86.18 111.61,88.05 106.05,91.76 106.01,91.97 105.7,92.17 105.49,92.13 105.18,92.34 105.14,92.55 104.83,92.75 104.63,92.71 104.32,92.92 104.28,93.12 103.97,93.33 103.76,93.29 103.45,93.5 103.41,93.7 103.1,93.91 102.9,93.87 102.4,94.2 101.68,94.92 101.53,95.3 102.1,96.68 101.88,97.22 99.71,98.12 99.32,97.96 98.74,96.55 98.57,96.48 96.98,97.15 96.85,97.33 96.85,97.51 v2(97.21,97.87)
  IN1 w0.136: v2(97.69,131.58) 97.32,131.21 97.32,128.99 96.89,127.94 96.06,123.78 95.5,118.15 95.5,111.16 96.09,108.21 96.55,107.1 96.76,106.41 97.16,104.4 97.16,103.74 96.84,100.48 96.84,98.23 v2(97.21,97.87)
P3E_PESW_M2D_TX2_DN: length 13
  TOP w0.099: 162.19,85.87 162.21,85.87 162.26,85.92 165.47,85.92 165.69,86.14 165.69,86.42 165.79,86.52 U34.N2
  TOP w0.124: C428.1 154.27,84.88 155.9,84.88 158.29,85.87 162.19,85.87
P3E_PESW_M2D_TX2_DP: length 13
  TOP w0.099: U34.N1 165.39,86.52 165.49,86.42 165.49,86.22 165.39,86.12 164.76,86.12 164.66,86.22 164.46,86.22 164.36,86.12 164.16,86.12 164.06,86.22 163.86,86.22 163.76,86.12 163.56,86.12 163.46,86.22 163.26,86.22 163.16,86.12 162.96,86.12 162.86,86.22 162.66,86.22 162.56,86.12 162.26,86.12 162.21,86.17 162.19,86.17
  TOP w0.124: 162.19,86.17 158.23,86.17 155.84,85.18 154.27,85.18 C427.1
P3E_PESW_M2D_TX3_C_DN: length 99.2
  TOP w0.124: v2(93.75,98.25) 94.1,97.9 94.1,97.3 95.47,95.93 97.28,95.38 100.94,92.93 109.23,87.4 117.44,84 121.93,82.96 125.49,83.67 131.14,82.54 134.32,83.17 137.49,82.54 140.67,83.17 143.84,82.54 148.83,83.54 150.92,83.54 C430.2 ; J36.A11 93.93,132.7 94.03,132.61 94.03,128.14 v2(93.67,127.79)
  IN1 w0.136: v2(93.75,98.25) 94.12,98.62 94.12,100.22 95.9,104.52 95.57,106.16 95.47,106.49 94.96,107.73 94.29,111.07 94.29,120.31 94.04,125.48 94.04,127.42 v2(93.67,127.79)
P3E_PESW_M2D_TX3_C_DP: length 99.2
  TOP w0.124: J36.A13 94.43,132.7 94.33,132.6 94.33,128.14 v2(94.69,127.79) ; v2(94.77,98.25) 94.41,97.89 94.41,97.43 95.63,96.2 97.41,95.66 97.91,95.32 98.12,95.36 98.43,95.16 98.47,94.95 98.84,94.7 99.05,94.74 99.36,94.54 99.4,94.33 99.8,94.07 100,94.11 100.31,93.9 100.35,93.7 100.66,93.49 100.87,93.53 101.18,93.32 101.22,93.12 109.37,87.67 117.53,84.29 121.94,83.27 125.49,83.98 131.14,82.85 134.32,83.49 137.49,82.85 140.67,83.49 143.84,82.85 148.79,83.84 150.92,83.84 C429.2
  IN1 w0.136: v2(94.77,98.25) 94.4,98.62 94.4,100.17 96.19,104.49 95.84,106.22 95.74,106.58 95.23,107.81 94.57,111.09 94.57,120.31 94.32,125.48 94.32,127.42 v2(94.69,127.79)
P3E_PESW_M2D_TX3_DN: length 15.9
  TOP w0.099: U34.P3 166.79,85.52 166.69,85.42 166.69,85.14 166.47,84.92 162.37,84.92 162.32,84.87 162.3,84.87
  TOP w0.124: 162.3,84.87 158.83,84.87 155.62,83.54 152.43,83.54 C430.1
P3E_PESW_M2D_TX3_DP: length 15.9
  TOP w0.099: 162.3,85.17 162.32,85.17 162.37,85.12 162.59,85.12 162.7,85.22 162.89,85.22 163,85.12 163.19,85.12 163.3,85.22 163.49,85.22 163.6,85.12 163.79,85.12 163.9,85.22 164.09,85.22 164.19,85.12 164.39,85.12 164.49,85.22 164.69,85.22 164.79,85.12 166.39,85.12 166.49,85.22 166.49,85.42 166.39,85.52 U34.P2
  TOP w0.124: C429.1 152.43,83.84 155.56,83.84 158.77,85.17 162.3,85.17
P3E_PESW_M2E_RX0_DN: length 78.6
  TOP w0.124: J38.B41 125.43,132.7 125.53,132.6 125.53,127.61 v2(125.17,127.25) ; U34.E11 v6(174.59,95.02)
  IN2 w0.099: 173.95,98.64 173.95,98.61 173.99,98.57 173.99,95.63 174.21,95.41 174.49,95.41 174.59,95.31 v6(174.59,95.02)
  IN2 w0.136: v2(125.17,127.25) 125.54,126.89 125.54,125.93 125.96,124.91 125.96,121.21 126.32,120.68 127.12,120.35 130.81,120.35 137.5,117.57 138.28,116.8 138.89,115.32 138.89,110.49 139.6,108.79 141.32,107.07 141.73,106.9 143,106.9 143.27,107.16 145.31,107.16 146.02,106.87 146.49,106.67 147.02,106.46 147.02,106.45 147.31,106.34 148.7,105.76 151.16,105.27 151.5,105.5 151.6,105.97 151.75,106.07 152.37,105.95 152.47,105.8 152.38,105.32 152.6,104.98 156.25,104.26 169.77,102.92 172.24,101.76 173.42,100.57 173.95,99.29 173.95,98.64
