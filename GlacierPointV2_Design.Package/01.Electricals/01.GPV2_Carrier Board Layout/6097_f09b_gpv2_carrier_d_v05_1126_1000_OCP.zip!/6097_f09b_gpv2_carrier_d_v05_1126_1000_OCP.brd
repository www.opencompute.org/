# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TDR_SE_50_OHM_IN1: length 152.5
  IN2 w0.122: J25.3 113.9,-168.85 39.23,-168.85 39.01,-168.62 39.01,-167.74 39.29,-167.45 113.9,-167.45 J25.2
TDR_SE_50_OHM_IN2: length 152.5
  IN1 w0.122: J26.2 29.18,-167.59 103.82,-167.59 104.07,-167.84 104.07,-168.73 103.81,-168.99 29.18,-168.99 J26.3
TDR_SE_50_OHM_TOP: length 152.5
  TOP w0.112: J24.3 113.89,-162.2 39.3,-162.2 39,-161.9 39,-161.08 39.27,-160.82 113.9,-160.82 J24.2
TGND: length 14.4
  TOP w0.508: J11.3 v2(305.4,158.6) ; J20.3 v2(191.42,158.45) ; J12.3 v2(161.14,158.45) ; J18.3 v2(19.63,157.82) ; J15.3 v2(81.37,157.82) ; J17.3 v2(246.57,158.45) ; J9.3 v2(123.51,158.45) ; J14.3 v2(265.63,158.61)
  BOTTOM w0.508: J13.3 v2(305.4,156.06) ; J53.3 v2(81.37,155.28) ; J10.3 v2(265.63,156.07) ; J19.3 v2(191.42,155.91) ; J52.3 v2(161.14,155.91) ; J51.3 v2(123.51,155.91) ; J54.3 v2(19.63,155.28) ; J16.3 v2(246.57,155.91)
  vias: v2(10.29,160.03) v2(10.29,154.95) v2(12.35,162.72) v2(12.48,151.04) v2(17.43,162.72) v2(17.56,151.04) v2(19.91,158.47) v2(19.91,157.17) v2(19.91,155.93) v2(19.91,154.63) v2(21.13,158.47) v2(21.13,157.17) v2(21.13,155.93) v2(21.13,154.63) v2(22.51,162.72) v2(22.64,151.04) v2(27.59,162.72) v2(27.72,151.04) v2(32.67,162.72) v2(32.8,151.04) v2(37.75,162.72) v2(37.88,151.04) v2(42.83,162.72) v2(42.96,151.04) v2(47.91,162.72) v2(48.04,151.04) v2(52.99,162.72) v2(53.12,151.04) v2(58.07,162.72) v2(58.2,151.04) v2(63.15,162.72) v2(63.28,151.04) v2(68.23,162.72) v2(68.36,151.04) v2(73.31,162.72) v2(73.44,151.04) v2(78.39,162.72) v2(78.52,151.04) v2(79.87,158.47) v2(79.87,157.17) v2(79.87,155.93) v2(79.87,154.63) v2(81.09,158.47) v2(81.09,157.17) v2(81.09,155.93) v2(81.09,154.63) v2(83.47,162.72) v2(83.6,151.04) v2(88.55,162.72) v2(88.68,151.04) v2(93.63,162.72) v2(93.76,151.04) v2(94.77,154.02) v2(98.71,162.72) v2(98.76,154.94) v2(103.79,162.72) v2(103.84,154.94) v2(108.87,162.72) v2(108.92,154.94) v2(111.29,153.71) v2(113.7,152.71) v2(113.95,162.72) v2(118.78,152.71) v2(119.03,162.72) v2(123.79,159.1) v2(123.79,157.81) v2(123.79,156.56) v2(123.79,155.27) v2(124.11,162.72) v2(124.24,151.04) v2(125.01,159.1) v2(125.01,157.81) v2(125.01,156.56) v2(125.01,155.27) v2(129.19,162.72) v2(129.32,151.04) v2(134.29,162.69) v2(134.4,151.04) v2(139.37,162.69) v2(139.49,151.01) v2(144.45,162.69) v2(144.57,151.01) v2(149.53,162.69) v2(149.65,151.01) v2(154.61,162.69) v2(154.73,151.01) v2(159.64,159.1) v2(159.64,157.81) v2(159.64,156.56) v2(159.64,155.27) v2(159.69,162.69) v2(159.81,151.01) v2(160.86,159.1) v2(160.86,157.81) v2(160.86,156.56) v2(160.86,155.27) v2(164.77,162.69) v2(164.89,151.01) v2(166.29,153.03) v2(169.85,162.69) v2(170.98,156.34) v2(174.93,162.69) v2(176.06,156.34) v2(180.01,162.69) v2(181.6,152.97) v2(185.09,162.69) v2(185.21,151.01) v2(190.17,162.69) v2(190.29,151.01) v2(191.69,159.1) v2(191.69,157.81) v2(191.69,156.56) v2(191.69,155.27) v2(192.91,159.1) v2(192.91,157.81) v2(192.91,156.56) v2(192.91,155.27) v2(195,159.73) v2(195,157.19) v2(195,154.65) v2(195.25,162.69) v2(195.37,151.01) v2(200.33,162.69) v2(200.45,151.01) v2(205.41,162.69) v2(205.53,151.01) v2(210.49,162.69) v2(210.61,151.01) v2(215.57,162.69) v2(215.69,151.01) v2(220.65,162.69) v2(220.77,151.01) v2(225.73,162.69) v2(225.85,151.01) v2(230.81,162.69) v2(230.93,151.01) v2(235.89,162.69) v2(236.06,150.94) v2(240.97,162.69) v2(241.09,151.01) v2(242.99,159.72) v2(242.99,157.18) v2(242.99,154.64) v2(245.07,159.1) v2(245.07,157.8) v2(245.07,156.56) v2(245.07,155.26) v2(246.05,162.69) v2(246.17,151.01) v2(246.29,159.1) v2(246.29,157.8) v2(246.29,156.56) v2(246.29,155.26) v2(251.13,162.69) v2(251.25,151.01) v2(256.21,162.69) v2(256.33,151.01) v2(261.29,162.69) v2(261.41,151.01) v2(265.91,159.25) v2(265.91,157.96) v2(265.91,156.71) v2(265.91,155.42) v2(266.37,162.69) v2(266.49,151.01) v2(267.13,159.25) v2(267.13,157.96) v2(267.13,156.71) v2(267.13,155.42) v2(269.22,159.88) v2(269.22,157.34) v2(269.22,154.8) v2(271.45,162.69) v2(271.57,151.01) v2(276.53,162.69) v2(276.65,151.01) v2(281.61,162.69) v2(281.73,151.01) v2(286.69,162.69) v2(286.81,151.01) v2(291.77,162.69) v2(291.89,151.01) v2(296.85,162.69) v2(296.97,151.01) v2(301.81,159.87) v2(301.81,157.33) v2(301.81,154.79) v2(301.93,162.69) v2(302.05,151.01) v2(303.9,159.25) v2(303.9,157.96) v2(303.9,156.71) v2(303.9,155.42) v2(305.12,159.25) v2(305.12,157.96) v2(305.12,156.71) v2(305.12,155.42) v2(305.37,153.31) v2(307.01,162.69) v2(312.09,162.69) v2(313.22,155.08) v2(317.17,162.69) v2(318.3,155.08) v2(322.25,162.69) v2(323.38,155.08) v2(327.33,162.69) v2(328.46,155.08) v2(332.41,162.69) v2(333.54,155.08) v2(337.49,162.69) v2(337.61,151.01) v2(342.57,162.69) v2(342.69,151.01) v2(347.65,162.69) v2(347.77,151.01) v2(352.73,162.69) v2(352.85,151.01) v2(357.81,162.69) v2(357.93,151.01) v2(362.89,162.69) v2(363.01,151.01) v2(366.67,162.66) v2(366.67,160) v2(366.67,154.92) v2(366.8,150.98)
TMP_A0_0: length 3.6
  BOTTOM w0.112: U7.7 15.16,78.89 v3(15.14,78.9) 15.29,79.05 R19.2
TMP_A0_1: length 3.3
  BOTTOM w0.112: U8.7 161.09,53 v3(161.22,53.14) 161.63,53.14 R22.2
TMP_A1_0: length 4.1
  BOTTOM w0.112: U7.6 14.51,77.59 13.72,78.37 v3(13.72,78.93) 13.97,79.18 13.97,79.84 R20.2
TMP_A1_1: length 5.9
  BOTTOM w0.112: U8.6 160.47,53.65 v3(161.22,54.41) 161.22,55.67 159.77,57.12 R23.2
TMP_A2_0: length 4.6
  BOTTOM w0.112: U7.5 13.86,77.32 13.66,77.52 13.13,77.52 v3(12.76,77.89) 12.76,78.73 13.26,79.23 R21.2
TMP_A2_1: length 3.3
  BOTTOM w0.112: U8.5 159.85,54.3 160.45,54.91 v3(160.45,55.7) 160.15,56.01 R24.2
TMP_ALERT_U7_N: length 7.2
  TOP w0.112: U86.N2 v6(44.96,46.94)
  BOTTOM w0.112: R4053.2 48.64,48.97 v3(47.08,47.41) 46.71,47.04 45.06,47.04 v6(44.96,46.94)
TMP_ALERT_U7_N_R: length 78.8
  IN1 w0.122: v2(52.33,49.34) 50.14,49.34 49.13,50.35 49.13,51.07 47.3,52.9 46.03,53.42 40.98,53.42 40.61,53.05 38.63,53.05 38.53,53.15 37.25,53.15 37.15,53.05 31.76,53.05 30.28,54.53 24.41,54.53 22.17,52.28 16.77,52.28 15.18,50.7 7.77,50.7 7.51,50.96 7.51,60.42 v2(6.36,61.57)
  BOTTOM w0.112: U7.3 14.51,71.11 13.84,70.45 13.21,70.45 12.46,71.2 10.91,71.2 v3(10.04,70.33) 7.16,67.45 7.16,62.38 v2(6.36,61.57) ; R4053.1 51.98,49.34 v2(52.33,49.34) 52.6,49.34 R4055.2
TMP_ALERT_U8_N: length 4.8
  TOP w0.089: U86.V8 42.45,50.25 42.35,50.5 42.35,51.11
  TOP w0.112: 42.35,51.11 42.35,51.81 42.29,51.86 v1(42.29,52.91) 42.29,54.08 R4054.2
TMP_ALERT_U8_N_R: length 171.2
  TOP w0.112: R4054.1 R4056.2 41.86,55.99 41.61,56.24 41.61,57.34 41.7,57.43 v2(42.47,57.43)
  IN1 w0.122: v2(42.47,57.43) 42.79,57.75 44.65,57.75 45.45,58.55 47.81,58.55 48.7,57.66 48.7,56.52 50.27,54.95 50.27,54.51 51.53,53.24 53.3,53.24 53.71,53.65 68.59,53.65 72.09,57.15 72.09,57.67 72.76,58.34 77.45,58.34 79.71,60.6 v2(79.71,61.24)
  IN2 w0.122: v2(104.96,33.85) 106.92,31.89 126.75,31.89 133.45,38.58 v2(133.45,40.03)
  BOTTOM w0.112: v2(104.96,33.85) 103.92,34.89 103.92,43.7 102.48,45.13 97.3,45.13 95.19,43.03 95.19,41.74 93.77,40.31 92.71,40.31 92.19,39.79 90.47,39.79 88.86,41.41 87.14,41.41 86.31,41.75 86.12,41.94 85.58,43.25 85.58,46.74 87.23,48.4 87.23,51.98 84.95,57.49 81.2,61.24 v2(79.71,61.24) ; v2(133.45,40.03) 140.71,40.03 142.49,41.8 147.39,41.8 149.58,44 149.58,45.41 148.97,46.03 148.97,52.14 v3(149.82,53) 150.81,53.98 153.55,53.98 153.88,53.65 U8.3
TP_JTAG_CONN_5: length 6.2
  TOP w0.112: J58.5 5.24,40.45 5.57,40.13 6.83,40.13 7.12,40.42 10.16,40.42 TP64.1
TP_JTAG_PCH_LAN_TRST_N: length 4.6
  TOP w0.112: TP63.1 7.16,39.98 6.64,39.45 J58.4
TP_M2A_MFG_CLK: length 2.1
  TOP w0.112: J4.B58 33.68,124.6 TP4.1
TP_M2A_MFG_DAT: length 4
  TOP w0.112: J4.B56 33.18,125.97 33.18,124.72 33.72,124.18 33.72,123.93 34.46,123.2 TP3.1
TP_M2B_MFG_CLK: length 1.9
  TOP w0.112: J4.A58 57.68,125.25 57.99,124.94 TP2.1
TP_M2B_MFG_DAT: length 2.2
  TOP w0.112: J4.A56 57.18,126.87 57.34,127.03 57.92,127.03 TP1.1
TP_M2C_MFG_CLK: length 1.5
  TOP w0.112: TP20.1 81.79,126.72 81.68,126.61 J36.B58
TP_M2C_MFG_DAT: length 2.5
  TOP w0.112: J36.B56 81.18,125.97 81.18,125.03 81.35,124.86 81.98,124.86 TP19.1
TP_M2D_MFG_CLK: length 1.8
  TOP w0.112: TP18.1 106.04,124.97 105.78,124.97 105.68,125.07 J36.A58
TP_M2D_MFG_DAT: length 2.7
  TOP w0.112: J36.A56 105.18,124.82 TP17.1
TP_M2E_MFG_CLK: length 2.4
  TOP w0.112: J38.B58 129.68,125.01 129.8,124.89 130.29,124.89 130.44,125.04 TP24.1
TP_M2E_MFG_DAT: length 2.7
  TOP w0.112: TP23.1 130.11,124.04 129.18,124.97 129.18,125.97 J38.B56
TP_M2F_MFG_CLK: length 2.1
  TOP w0.112: TP22.1 154.1,124.95 153.79,124.95 153.68,125.07 153.68,125.97 J38.A58
TP_M2F_MFG_DAT: length 3.2
  TOP w0.112: TP21.1 153.96,124.11 153.18,124.89 153.18,125.97 J38.A56
TP_M2G_MFG_CLK: length 12.9
  BOTTOM w0.112: J8.B58 153.42,134.18 153.29,134.32 152.75,134.32 150.87,136.2 150.87,138.23 151.55,138.91 151.55,142.94 152.44,143.83 TP12.1
TP_M2G_MFG_DAT: length 14
  BOTTOM w0.112: J8.B56 153.92,134.21 153.52,134.61 152.9,134.61 151.13,136.38 151.13,137.98 151.84,138.68 151.84,142.58 TP11.1
TP_M2H_MFG_CLK: length 7.1
  BOTTOM w0.112: TP10.1 125.95,136.9 127.38,135.48 127.9,135.48 129.42,133.96 J8.A58
TP_M2H_MFG_DAT: length 6.7
  BOTTOM w0.112: J8.A56 129.92,133.92 127.93,135.91 127.53,135.91 126.77,136.67 126.77,137.6 TP9.1
TP_M2I_MFG_CLK: length 20.9
  BOTTOM w0.112: TP16.1 92.88,143.13 93.87,142.15 98.02,142.15 98.55,141.62 98.55,137.9 98.91,137.53 102.26,137.53 102.98,136.8 102.98,135.4 104.53,133.85 105.32,133.85 105.42,133.75 J34.B58
TP_M2I_MFG_DAT: length 22.1
  BOTTOM w0.112: TP15.1 93.6,144.42 93.6,143.92 94.25,143.26 95.55,143.26 96.39,142.42 98.24,142.42 98.82,141.83 98.82,138.3 99.29,137.84 102.41,137.84 103.29,136.96 103.29,135.47 104.54,134.22 105.71,134.22 105.92,134.01 J34.B56
TP_M2J_MFG_CLK: length 11.7
  BOTTOM w0.112: TP14.1 79.18,142.33 79.51,142 79.51,136.32 81.42,134.41 J34.A58
TP_M2J_MFG_DAT: length 12
  BOTTOM w0.112: J34.A56 81.92,134.36 79.77,136.51 79.77,142.24 80.46,142.93 TP13.1
TP_M2J_PLA_S3_N: length 13.7
  BOTTOM w0.112: R4271.1 87.97,124.61 87.31,125.27 86.89,125.44 86.6,125.44 86.37,125.21 v3(85.44,125.21) 85.44,126.53 84.65,127.32 84.65,129.08 85.89,130.32 86.85,130.32 87.28,130.75 87.28,131.04 88.42,132.18 J34.A30
TP_M2K_MFG_CLK: length 12.4
  BOTTOM w0.112: TP8.1 55.67,143.98 55.67,136.35 57.42,134.6 J6.B58
TP_M2K_MFG_DAT: length 12.5
  BOTTOM w0.112: TP7.1 56.04,144.14 56.04,136.58 57.92,134.7 J6.B56
TP_M2L_MFG_CLK: length 15.8
  BOTTOM w0.112: TP6.1 24.51,138.35 24.51,134.65 25.21,133.94 28.64,133.94 28.95,134.07 29.24,134.36 29.55,134.49 31.08,134.49 31.36,134.2 33.04,134.2 33.42,133.82 J6.A58
TP_M2L_MFG_DAT: length 15.6
  TOP w0.112: v2(30.35,135.47) 30.35,137.59 30.98,138.22 30.98,145.11 31.12,145.25 TP5.1
  BOTTOM w0.112: J6.A56 33.92,133.93 33.35,134.5 31.52,134.5 31.24,134.78 30.84,134.78 30.35,135.27 v2(30.35,135.47)
TP_PEWAKE_M2A: length 5
  TOP w0.112: J4.B54 32.68,125.07 32.86,124.89 32.86,124.67 33.46,124.07 33.46,123.82 34.19,123.1 34.19,122.63 TP49.1
TP_PEWAKE_M2B: length 3.9
  TOP w0.112: J4.A54 56.68,125.27 56.98,124.97 57.25,124.97 57.98,124.25 58.68,124.25 TP50.1
TP_PEWAKE_M2C: length 3.8
  TOP w0.112: TP51.1 82.37,124.44 81.24,124.44 80.68,125 J36.B54
TP_PEWAKE_M2D: length 3.3
  TOP w0.112: J36.A54 104.68,127.05 105.02,127.4 105.64,127.4 106.26,126.78 TP52.1
TP_PEWAKE_M2E: length 4.1
  TOP w0.112: TP53.1 130.65,123.1 128.68,125.07 J38.B54
TP_PEWAKE_M2F: length 2.8
  TOP w0.112: J38.A54 152.68,126.9 152.92,127.15 154,127.15 TP54.1
TP_PEWAKE_M2G: length 15.1
  BOTTOM w0.112: TP60.1 154.31,143.53 153.39,143.53 152.13,142.28 152.13,138.55 151.54,137.96 151.54,136.51 153.13,134.92 154.16,134.92 154.42,134.66 J8.B54
TP_PEWAKE_M2H: length 4.9
  BOTTOM w0.112: TP59.1 127.55,136.84 130.42,133.97 J8.A54
TP_PEWAKE_M2I: length 16.4
  BOTTOM w0.112: TP58.1 98.24,141.06 98.24,137.8 98.82,137.22 101.43,137.22 101.74,136.91 101.74,135.76 104.65,132.85 104.65,132.47 105.21,131.92 106.1,131.92 106.42,132.24 106.42,133.22 J34.B54
TP_PEWAKE_M2J: length 13.4
  BOTTOM w0.112: J34.A54 82.42,134.31 80.04,136.69 80.04,142 81.03,142.98 TP57.1
TP_PEWAKE_M2K: length 12.7
  BOTTOM w0.112: J6.B54 58.42,135.06 56.6,136.89 56.6,143.39 TP56.1
TP_PEWAKE_M2L: length 13.7
  TOP w0.112: TP55.1 31.8,143.61 31.8,137.67 31.62,137.49 31.62,135.12 v2(31.67,135.07)
  BOTTOM w0.112: J6.A54 34.42,133.95 33.53,134.84 31.91,134.84 v2(31.67,135.07)
TP_RESERVED_USB+: length 7.9
  BOTTOM w0.112: J49.25 157.3,10.44 159.13,12.27 159.13,14.57 TP61.1
TP_RESERVED_USB-: length 9.3
  BOTTOM w0.112: J49.27 156.5,10.2 158.47,12.16 158.47,15.81 TP62.1
TP_USB2_M2A_DN: length 3.8
  TOP w0.112: J4.B36 28.18,127.13 27.97,127.44 26.47,128.06 TP26.1
TP_USB2_M2A_DP: length 5.7
  TOP w0.112: J4.B34 27.68,126.93 27.49,127.12 24.95,128.17 TP25.1
TP_USB2_M2B_DN: length 3.4
  TOP w0.112: TP27.1 53.03,123.21 53.03,124.34 52.18,125.19 J4.A36
TP_USB2_M2B_DP: length 2.2
  TOP w0.112: TP28.1 52.52,124.35 51.68,125.19 J4.A34
TP_USB2_M2C_DN: length 2.8
  TOP w0.112: J36.B36 76.18,125.25 76.55,124.88 76.55,123.51 TP29.1
TP_USB2_M2C_DP: length 1.5
  TOP w0.112: J36.B34 75.68,125.06 TP30.1
TP_USB2_M2D_DN: length 2.2
  TOP w0.112: TP31.1 100.53,124.1 100.53,124.9 100.18,125.25 J36.A36
TP_USB2_M2D_DP: length 34.1
  TOP w0.112: J36.A34 99.68,126.81 99.99,127.12 99.99,127.66 99.31,128.33 v2(97.88,128.33)
  IN2 w0.122: v2(97.88,128.33) 97.25,128.96 97.25,129.85 96.76,130.34 96.11,130.34 93.45,131.44 88.05,131.44 84.88,134.61 84.88,135.26 83.16,136.99 81.74,136.99 79.46,139.28 79.46,140.41 79.94,140.89 79.94,144.98 TP32.1
TP_USB2_M2E_DN: length 1.3
  TOP w0.112: TP33.1 124.18,125.03 124.18,125.97 J38.B36
TP_USB2_M2E_DP: length 2.8
  TOP w0.112: TP34.1 124.42,123.98 123.68,124.72 J38.B34
TP_USB2_M2F_DN: length 2.9
  TOP w0.112: TP35.1 148.1,124 148.1,124.36 147.68,124.78 147.68,125.97 J38.A34
TP_USB2_M2F_DP: length 1.6
  TOP w0.112: J38.A36 148.18,125.97 148.18,124.88 148.29,124.77 TP36.1
TP_USB2_M2G_DN: length 19.2
  BOTTOM w0.112: TP48.1 155.76,142.62 153.7,142.62 152.95,141.87 152.95,138.11 152.39,137.55 152.39,136.82 152.96,136.25 153.88,136.25 154.41,135.72 154.89,135.72 156.32,134.29 158.77,134.29 158.92,134.14 J8.B36
TP_USB2_M2G_DP: length 20.7
  BOTTOM w0.112: J8.B34 159.42,134.17 158.99,134.6 156.49,134.6 155.07,136.02 154.6,136.02 154.1,136.53 153.07,136.53 152.66,136.93 152.66,137.43 153.22,137.99 153.22,141.75 153.74,142.27 157.07,142.27 TP47.1
TP_USB2_M2H_DN: length 11.8
  BOTTOM w0.112: TP46.1 128.92,139.72 128.92,137.85 129.17,137.25 129.74,136.68 134.2,136.68 134.92,135.97 J8.A36
TP_USB2_M2H_DP: length 16.5
  BOTTOM w0.112: J8.A34 135.42,136.18 134.51,137.09 129.7,137.09 129.39,137.4 129.23,137.78 129.23,141.59 129.67,142.03 131.62,142.03 TP45.1
TP_USB2_M2I_DN: length 30.5
  BOTTOM w0.112: TP44.1 96.41,144.04 97.27,143.18 98.22,143.18 99.59,144.55 104.77,144.55 105.37,143.94 105.37,142.39 104.22,141.23 104.22,136.46 105.63,135.05 105.63,134.92 106.13,134.42 108,134.42 109.45,135.87 110.03,135.87 111.11,134.79 111.11,134.4 110.92,134.21 J34.B36
TP_USB2_M2I_DP: length 31.1
  BOTTOM w0.112: J34.B34 111.42,134.89 110.17,136.14 109.31,136.14 107.85,134.69 106.26,134.69 105.92,135.02 105.92,135.13 104.49,136.56 104.49,141 105.68,142.19 105.68,144.17 105.02,144.84 99.33,144.84 98.64,144.15 97.78,144.15 96.46,145.47 TP43.1
TP_USB2_M2J_DN: length 15.8
  BOTTOM w0.112: J34.A36 86.92,134.2 85.7,135.42 82.48,135.42 80.82,137.08 80.82,141.62 82.05,142.85 TP42.1
TP_USB2_M2J_DP: length 16.4
  BOTTOM w0.112: TP41.1 83.44,143.8 81.09,141.45 81.09,137.19 82.59,135.69 85.87,135.69 87.42,134.14 J34.A34
TP_USB2_M2K_DN: length 20.7
  BOTTOM w0.112: TP40.1 74.97,143.03 73.7,141.76 73.7,138.17 73.13,137.6 71.88,137.6 71.19,136.9 69.2,136.9 68.66,136.35 63.52,136.35 62.92,135.76 J6.B36
TP_USB2_M2K_DP: length 22.1
  BOTTOM w0.112: J6.B34 63.42,134.23 63.24,134.41 63.24,135.56 63.72,136.04 68.79,136.04 69.33,136.59 71.32,136.59 72.01,137.29 73.26,137.29 74.02,138.04 74.02,141.63 75.52,143.14 75.52,145.08 TP39.1
TP_USB2_M2L_DN: length 12.2
  BOTTOM w0.112: TP37.1 39.76,124.23 38.89,124.23 37.71,125.41 37.71,126.27 36.71,127.27 36.71,129.67 38.92,131.88 J6.A36
TP_USB2_M2L_DP: length 22.6
  TOP w0.112: TP38.1 33.24,144.25 32.13,143.14 32.13,137.83 32.56,137.4 38,137.4 38.84,136.56 38.84,134.65 39.14,134.35 39.87,134.35 40.04,134.18 v2(40.04,131.96)
  BOTTOM w0.112: J6.A34 39.42,132.13 39.6,131.96 v2(40.04,131.96)
TWI_PESW_EEPROM_CLK_0: length 49.4
  TOP w0.112: v2(204.42,101.14) 204.42,101.1 204.85,100.66 R3260.1 ; U56.6 183.41,115.65 183.87,115.19 v2(187.91,115.19) ; U34.J31 v6(195.59,91.02)
  IN1 w0.122: v2(204.42,101.14) 203.12,102.43 203.12,103.76 204.09,104.72 204.09,106.35 201.22,109.22 196.08,109.22 190.11,115.19 v2(187.91,115.19)
  IN2 w0.122: v6(195.59,91.02) 196.36,91.79 197.26,91.79 198.08,92.61 198.08,93.21 198.4,93.53 198.79,93.53 199.09,93.83 199.09,94.26 202.09,97.26 202.79,97.26 203.28,97.74 203.28,100 v2(204.42,101.14)
TWI_PESW_EEPROM_DAT_0: length 47.8
  TOP w0.112: U56.5 188.16,114.38 v2(188.24,114.45) ; R3261.1 204.75,99.57 v2(204.58,99.74) ; U34.J32 v6(196.59,91.02)
  IN2 w0.122: v6(196.59,91.02) 196.93,91.02 198.38,92.48 198.73,92.48 200.07,93.82 201.81,93.82 202.1,94.11 202.1,95.88 203.76,97.54 203.76,98.92 v2(204.58,99.74) 204.86,100.02 204.86,102.84 204.09,103.61 204.09,105.69 202.74,107.04 195.44,107.04 188.24,114.24 v2(188.24,114.45)
UART_BIC_RXD: length 40.6
  TOP w0.112: v2(16.95,48.15) 16.51,47.71 16.51,46.78 R3937.2 ; v2(48.59,45.57) 48.18,45.16 46.17,45.16 U86.J1
  IN1 w0.122: v2(16.95,48.15) 17.5,48.7 24.44,48.7 24.85,49.1 28.86,49.1 29.17,48.79 37.03,48.79 38.28,50.04 40.78,50.04 41.01,50.26 45.02,50.26 48.59,46.7 v2(48.59,45.57)
UART_BIC_RXD_R: length 2
  TOP w0.112: R3937.1 14.06,46.25 v4(13.95,46.15)
  BOTTOM w0.112: U94.C7 v4(13.95,46.15)
UART_BIC_RXD_REMOTE: length 73.9
  TOP w0.112: U86.P2 45.47,47.42 47.41,47.42 48.84,48.85 48.84,51.85 50.56,53.57 54.44,53.57 57.23,50.78 57.23,49.23 58.47,46.24 58.47,43.09 58.23,42.51 57.56,41.85 57.21,41.85 55.91,41.31 55.1,41.31 54.1,40.3 52.8,39.77 51.94,39.77 51.86,39.85 v2(51.75,39.85) ; R4096.2 15.1,42.87 16.62,42.87 17.69,41.8 v4(19.3,41.8)
  IN1 w0.122: v2(51.75,39.85) 50.77,38.86 49.88,38.86 49.18,38.17 47.33,38.17 46.48,37.31 41.14,37.31 40.36,38.1 37.12,38.1 36.75,37.73 35.86,37.73 32.77,40.81 29.69,40.81 29.66,40.79 20.31,40.79 v4(19.3,41.8)
UART_BIC_RXD_REMOTE_R: length 5.3
  TOP w0.112: v2(13.95,47.15) 13.39,46.58 13.39,44.93 v1(13.47,44.85) 13.56,44.76 14.44,44.76 14.83,44.36 R4096.1
  BOTTOM w0.112: U94.D7 v2(13.95,47.15)
UART_BIC_TXD: length 51.8
  IN1 w0.122: v2(51.61,40.96) 51.61,40.36 50.56,39.3 49.13,39.3 48.42,38.6 47.16,38.6 46.3,37.74 42.44,37.74 41.09,39.09 38.74,39.09 38.41,38.75 35.48,38.75 32.38,41.85 30.03,41.85 29.39,41.21 20.82,41.21 19.8,42.24 19.11,42.24 16.72,39.85 15.1,39.85 v4(14.4,40.55)
  BOTTOM w0.112: R3885.2 51.27,42.78 51.11,42.62 51.11,41.47 v2(51.61,40.96) ; U94.B7 14.45,45.6 15.02,45.03 15.02,43.52 14.46,42.97 14.46,41.96 14.33,41.83 14.33,40.62 v4(14.4,40.55)
UART_BIC_TXD_R: length 8.6
  TOP w0.112: U86.J2 44.97,44.94 v6(44.96,44.95)
  BOTTOM w0.112: v6(44.96,44.95) 45.33,44.95 45.37,44.99 47.57,44.99 48.17,44.38 50.12,44.38 v3(50.92,43.58) R3885.1
UART_BIC_TXD_REMOTE: length 2
  TOP w0.112: R4095.2 13.13,48.32 v4(12.95,48.15)
  BOTTOM w0.112: U94.E6 v4(12.95,48.15)
UART_BIC_TXD_REMOTE_R: length 31
  TOP w0.112: U86.W9 41.65,50.24 41.65,51.54 41.48,51.72 v2(41.48,51.88) ; R4095.1 15.41,48.74 15.41,49.49 15.57,49.65 16.42,49.65 v2(16.93,49.13)
  IN1 w0.122: v2(41.48,51.88) 41.26,51.66 38.95,51.66 38.35,51.06 33.78,51.06 33.76,51.04 28.68,51.04 27.24,49.59 17.4,49.59 v2(16.93,49.13)
UART_PESW_CPLD_USIN: length 290.5
  TOP w0.112: R4384.2 185.67,138.72 v2(185.26,139.13) ; R4362.2 16.24,43.48 v2(16.09,43.33)
  IN1 w0.122: v2(76.07,145.3) 77.24,144.13 77.24,143.38 77.56,143.06 81.98,143.06 82.36,143.44 82.36,143.44 84.96,143.44 87.25,145.73 90.27,145.73 90.9,145.1 90.9,144.68 92.15,143.43 94.41,143.43 96,141.85 98.54,141.85 99.77,140.62 102.64,140.62 103.06,141.04 104.94,141.04 105.77,141.38 168.02,141.38 170.53,138.87 182.87,138.87 183.19,139.2 185.2,139.2 v2(185.26,139.13) ; v2(16.09,43.33) 15.66,42.9 15.18,42.9 14.45,42.17 11.55,42.17 9.55,44.17 9.29,44.17 7.98,45.48 6.79,45.48 6.11,46.16 6.11,56.36 6.8,57.05 6.8,59.82 6.65,59.96 5.16,61.46 5.16,61.85 2.88,64.13 2.88,69.85 3.97,70.93 3.97,76.17 4.06,76.26 4.06,79.74 4.75,80.43 4.75,81.82 4.28,82.29 4.28,84.19 3.89,84.58 3.89,106.58 15.54,118.24 15.54,118.73 19.38,122.57 20.16,126.5 20.16,129.92 19.38,130.7 19.38,134.83 v4(27.9,143.36)
  IN2 w0.122: v4(27.9,143.36) 29.49,144.95 34.31,144.95 35.33,145.97 75.85,145.97 76.07,145.75 v2(76.07,145.3)
UART_PESW_CPLD_USIN_R: length 1.6
  TOP w0.112: R4362.1 15.44,44.05 v2(15.48,44.01)
  BOTTOM w0.112: U94.A8 15.45,44.04 v2(15.48,44.01)
UART_PESW_CPLD_USOUT: length 289.9
  TOP w0.112: R4361.2 16.06,48.29 16.36,48.59 17.13,48.59 17.49,48.23 17.49,47.61 v2(17.95,47.15) ; v2(185.3,133.74) 185.3,133.82 185.96,134.48 R4383.2
  IN1 w0.122: v2(185.3,133.74) 184.84,133.74 184.74,133.84 184.74,137.09 185.17,137.52 185.55,137.52 186.43,138.4 186.43,138.96 185.75,139.65 183.01,139.65 182.69,139.32 170.71,139.32 168.13,141.91 145.14,141.91 144.58,142.47 143.72,142.47 143.2,141.95 141.26,141.95 137.81,145.4 135.14,145.4 132.96,143.22 131.61,143.22 130.24,141.85 105.56,141.85 104.74,141.51 102.79,141.51 102.38,141.09 100.02,141.09 98.82,142.29 96.18,142.29 95.49,142.98 95.49,143.75 94.75,144.49 92.15,144.49 90.47,146.17 86.97,146.17 85.45,144.65 81.66,144.65 81.58,144.58 79.18,144.58 v2(78.99,144.76) ; v4(26.63,143.23) 25.11,143.23 18.68,136.8 18.68,129.84 19.73,128.78 19.73,127.81 18.93,127.02 v2(18.04,127.02)
  IN2 w0.122: v2(17.95,47.15) 17.51,47.59 17.51,58.49 18.39,59.38 18.39,61.74 18.3,61.83 18.3,67.19 18.93,67.82 18.93,73.1 19.5,73.68 19.5,76.54 18.23,77.81 18.23,78.17 18.49,78.43 18.81,78.43 19.29,78.91 19.29,79.28 19.24,79.32 19.24,85.35 19.56,85.67 19.56,89.99 16.97,92.58 16.97,96.15 17.23,96.41 17.25,96.41 19,98.16 19,102.96 17.72,104.24 17.72,107.17 18.21,107.65 18.21,109.07 17.63,109.65 17.63,111 17.33,111.3 17.33,120.58 18.7,121.95 18.7,126.35 v2(18.04,127.02) ; v4(26.63,143.23) 29.25,145.85 29.74,145.85 30.29,146.4 78.26,146.4 78.99,145.67 v2(78.99,144.76)
UART_PESW_CPLD_USOUT_R: length 1.9
  TOP w0.112: v2(14.95,47.15) 15.06,47.26 R4361.1
  BOTTOM w0.112: U94.C8 v2(14.95,47.15)
UART_PESW_USIN: length 75.8
  TOP w0.112: v2(184.12,134.89) 184.39,135.16 U66.5 184.39,136.42 v1(183.39,137.42) 182.92,137.89 181.92,137.89 R3279.2 ; U34.R32 v6(196.59,85.02)
  IN2 w0.102: 200.94,86.5 200.68,86.5 200.67,86.51 200.03,86.51 198.94,85.42 196.99,85.42 v6(196.59,85.02)
  IN2 w0.122: 200.94,86.5 202.02,87.58 202.55,87.58 205.53,90.56 205.53,94.83 206.29,95.6 206.29,98.81 206.16,98.94 206.16,103.92 205.38,104.7 205.38,106.22 203.25,108.36 196.04,108.36 192.22,112.18 192.22,116.36 190.88,117.7 190.88,118.16 190.32,118.72 189.87,118.72 189.51,119.08 189.51,120.29 188.68,121.12 188.68,127.6 188.14,128.14 187.77,128.14 184.6,131.31 184.6,134.41 v2(184.12,134.89)
UART_PESW_USIN_3V3SB: length 8.6
  TOP w0.112: R3274.1 185.49,137.69 184.82,137.02 184.82,134.74 184.47,134.4 182.36,134.4 v2(181.96,134.79) 181.96,135.15 182.29,135.48 182.29,135.75 182.45,135.9 U66.8
UART_PESW_USIN_3V3SB_R: length 9.6
  TOP w0.112: J60.3 188.79,133.63 187.97,134.45 187.24,135.81 187.24,136.18 R3276.2 R3274.2 R4384.1 186.98,138.72 187.23,138.97 187.23,140.29 v2(186.6,140.92)
UART_PESW_USOUT: length 76.7
  TOP w0.112: R3277.2 184.13,131.06 184.39,131.32 U66.4 185.2,132.8 185.24,132.76 v2(185.31,132.76) ; U34.R31 v6(195.59,85.02)
  IN2 w0.102: 201.2,86.11 200.04,84.95 200.04,84.81 199.85,84.62 195.99,84.62 v6(195.59,85.02)
  IN2 w0.122: v2(185.31,132.76) 185.96,132.76 186.23,132.5 186.23,130.7 189.13,127.79 189.13,121.38 192.65,117.86 192.65,112.55 196.42,108.79 203.66,108.79 205,107.44 205.66,107.44 207.16,105.94 207.32,105.58 207.32,104.67 206.8,104.16 206.8,102.49 207.3,101.99 207.3,100.84 206.73,100.27 206.73,95.27 206.06,94.6 206.06,89.04 205.81,88.79 204.68,88.79 203.01,87.12 202.07,87.12 201.2,86.25 201.2,86.11
UART_PESW_USOUT_3V3SB: length 4.6
  TOP w0.112: U66.1 182.89,132.81 v2(182.89,133.88) 182.92,133.91 184.19,133.91 184.85,133.26 185.68,133.26 185.96,133.54 R3280.1
UART_PESW_USOUT_3V3SB_R: length 5.7
  TOP w0.112: R3275.2 R4383.1 186.76,134.55 ; 186.76,134.55 v2(187.78,133.53) 188.33,132.98 J60.2 ; 186.76,134.55 R3280.2
VSENSE_P3V3_M2A_INA231_INN: length 5.6
  TOP w0.203: R3626.2 31.48,116.23 31.9,116.23 C1086.2 32.37,116.26 33.65,116.26 34.82,115.09 U73.D2
VSENSE_P3V3_M2A_INA231_INP: length 5.6
  TOP w0.203: R3625.2 31.46,115.87 31.95,115.87 C1086.1 32.37,115.9 33.49,115.9 34.71,114.69 U73.D3
VSENSE_P3V3_M2B_INA231_INN: length 5.8
  TOP w0.203: U74.D2 59.3,114.94 57.83,116.41 57.06,116.41 C1088.2 56.59,116.43 56.15,116.43 R3633.2
VSENSE_P3V3_M2B_INA231_INP: length 5.7
  TOP w0.203: U74.D3 59.19,114.53 57.68,116.05 57.01,116.05 C1088.1 56.62,116.05 56.07,116.05 R3632.2
VSENSE_P3V3_M2C_INA231_INN: length 5
  TOP w0.203: U75.D2 81.79,115.52 C1090.2 80.71,115.75 R3640.2
VSENSE_P3V3_M2C_INA231_INP: length 5
  TOP w0.203: R3639.2 80.71,114.95 C1090.1 81.79,115.16 85.38,115.16 U75.D3
VSENSE_P3V3_M2D_INA231_INN: length 5.6
  TOP w0.203: U76.D2 110.01,114.46 108.84,115.63 107.05,115.63 C1092.2 106.58,115.6 106.17,115.6 R3647.2
VSENSE_P3V3_M2D_INA231_INP: length 5.6
  TOP w0.203: R3646.2 106.14,115.25 106.64,115.25 C1092.1 107.05,115.27 108.69,115.27 109.9,114.06 U76.D3
VSENSE_P3V3_M2E_INA231_INN: length 5.6
  TOP w0.203: R3654.2 130.07,115.73 130.49,115.73 C1094.2 130.96,115.76 132.86,115.76 134.03,114.59 U77.D2
VSENSE_P3V3_M2E_INA231_INP: length 5.6
  TOP w0.203: R3653.2 130.04,115.38 130.54,115.38 C1094.1 130.96,115.4 132.71,115.4 133.92,114.19 U77.D3
VSENSE_P3V3_M2F_INA231_INN: length 7.8
  TOP w0.203: U78.D2 163.25,119.71 162.79,119.26 161.8,119.26 160.74,118.2 160,116.41 159.79,116.21 159.43,116.21 C1096.2 159.06,116.18 158.51,116.18 R3661.2
VSENSE_P3V3_M2F_INA231_INP: length 8.5
  TOP w0.203: R3660.2 158.54,115.83 159.01,115.83 C1096.1 159.5,115.83 159.93,115.83 160.29,116.2 161.04,117.99 161.94,118.9 162.94,118.9 163.65,119.61 U78.D3
VSENSE_P3V3_M2G_INA231_INN: length 6.4
  BOTTOM w0.203: R3725.2 155.58,118.31 155.12,118.31 C1108.2 154.66,118.3 153.55,118.3 153,118.85 151.3,118.85 150.52,118.07 U84.D2
VSENSE_P3V3_M2G_INA231_INP: length 5.8
  BOTTOM w0.203: U84.D3 151.45,118.49 152.83,118.49 153.38,117.94 154.68,117.94 C1108.1 155.1,117.94 155.57,117.94 R3724.2
VSENSE_P3V3_M2H_INA231_INN: length 6.6
  BOTTOM w0.203: R3718.2 128,115.14 127.54,115.14 C1106.2 127.06,115.11 125.87,115.11 125.26,115.71 123.37,115.71 122.88,115.23 U83.D2
VSENSE_P3V3_M2H_INA231_INP: length 6
  BOTTOM w0.203: U83.D3 123.28,115.12 123.52,115.36 125.11,115.36 125.72,114.75 127.12,114.75 C1106.1 127.53,114.78 127.99,114.78 R3717.2
VSENSE_P3V3_M2I_INA231_INN: length 5.9
  BOTTOM w0.203: R3710.2 104.38,114.9 C1104.2 103.25,114.68 102.24,114.68 101.93,115 99.44,115 99.11,114.66 U82.D2
VSENSE_P3V3_M2I_INA231_INP: length 5.3
  BOTTOM w0.203: R3709.2 104.35,114.1 C1104.1 103.24,114.32 102.07,114.32 101.76,114.64 99.6,114.64 U82.D3
VSENSE_P3V3_M2J_INA231_INN: length 6.5
  BOTTOM w0.203: U81.D2 73.7,114.47 74.32,115.09 75.62,115.09 76.05,114.66 77.92,114.66 C1102.2 78.35,114.64 78.81,114.64 R3703.2
VSENSE_P3V3_M2J_INA231_INP: length 5.9
  BOTTOM w0.203: U81.D3 74.1,114.35 74.47,114.72 75.48,114.72 75.9,114.3 77.89,114.3 C1102.1 78.32,114.27 78.81,114.27 R3702.2
VSENSE_P3V3_M2K_INA231_INN: length 6.2
  BOTTOM w0.203: U80.D2 49.06,115.57 49.58,116.09 51.06,116.09 51.77,115.38 53.21,115.38 C1100.2 54.32,115.57 R3696.2
VSENSE_P3V3_M2K_INA231_INP: length 5.6
  BOTTOM w0.203: R3695.2 54.29,114.77 C1100.1 53.19,114.98 51.67,114.98 50.9,115.74 49.79,115.74 U80.D3
VSENSE_P3V3_M2L_INA231_INN: length 6.9
  BOTTOM w0.203: R3671.2 30.76,116.76 30.27,116.76 C1098.2 29.85,116.78 28.67,116.78 26.11,114.23 U79.D2
VSENSE_P3V3_M2L_INA231_INP: length 6.2
  BOTTOM w0.203: U79.D3 26.51,114.12 28.81,116.41 29.83,116.41 C1098.1 30.25,116.38 30.81,116.38 R3670.2
VSENSE_P12V_INA230_INN: length 3.3
  BOTTOM w0.254: U2.12 97.62,34.79 97.3,34.47 97.3,34 97.76,33.54 C2.2 97.63,33.17 97.63,32.69 R8.2
VSENSE_P12V_INA230_INP: length 4.3
  BOTTOM w0.254: U2.13 96.63,35.74 96.38,35.49 96.38,35.12 96.85,34.64 96.85,33.41 C2.1 97.22,33.05 97.22,32.46 R7.2
VSENSE_P12V_INA230_R_INN: length 3.6
  BOTTOM w0.279: R8.1 97.83,31.26 97.83,29.01 98.12,28.72 R6.1B
VSENSE_P12V_INA230_R_INP: length 3.6
  BOTTOM w0.279: R6.2B 97.06,28.72 97.34,29 97.34,31.16 R7.1
XTAL_25M_ZL30281_XA: length 10.1
  TOP w0.112: U61.10 116.17,39.68 115.75,40.1 R3227.1 113.46,40.1 113.39,40.03 C954.1 v2(111.58,40.03) 111.28,40.34 109.17,40.34 109,40.17 109,39.91 Y2.1
XTAL_25M_ZL30281_XB: length 6.2
  TOP w0.112: R3228.1 112.32,38.16 C955.1 111.82,37.15 110.42,36.58 109.09,36.58 v2(108.66,36.75) 107.98,37.04 Y2.3
XTAL_25M_ZL30281_XB_R: length 4.7
  TOP w0.112: R3228.2 113.91,38.98 v1(114.26,39.13) 114.37,39.18 115.37,39.18 R3227.2 115.78,39.18 U61.11
N13628460: length 4.3
  TOP w0.254: PR126.2 184.54,16.01 PC120.1 184.77,16.95 PR125.2 PR120.2 PC109.2

## Copper pours and planes (outline as drawn)
GND on TOP (solid shape): 19.08,123.84 19.08,120.82 19.01,120.75 17.82,120.75 17.82,123.01 18.66,123.85 19.06,123.85
GND on TOP (solid shape): 121.76,37.61 121.79,37.59 121.79,36.58 118.1,36.58 118.09,36.6 118.09,40.28 121.76,40.28
GND on TOP (solid shape): 21.37,27.93 21.37,26.91 21.25,26.79 18.59,26.79 18.39,26.99 18.39,28.09 18.59,28.29 21.01,28.29
GND on TOP (solid shape): 21.54,20.21 20.19,20.21 20.05,20.35 20.05,20.63 20.07,20.65 20.07,21.48 20.14,21.55 21.54,21.55
GND on TOP (solid shape): 49.8,123.16 49.8,120.98 49.67,120.85 48.3,120.85 48.17,120.98 48.17,123.77 48.22,123.82 49.13,123.82
GND on TOP (solid shape): 63.95,123.55 63.95,120.88 63.63,120.56 62.18,120.56 62.07,120.68 62.07,123.64 62.13,123.7 63.8,123.7
GND on TOP (solid shape): 111.77,123.39 111.77,121.32 110.9,120.45 110.21,120.45 110.07,120.58 110.07,123.79 110.26,123.98 111.18,123.98
GND on TOP (solid shape): 113.91,35.55 113.91,32.14 113.87,32.11 112.24,32.11 111.51,32.84 111.51,35.28 111.86,35.64 113.82,35.64
GND on TOP (solid shape): 126.62,35.2 126.62,33.83 126.36,33.57 124.8,33.57 124.66,33.71 124.66,35.05 125.04,35.43 126.39,35.43
GND on TOP (solid shape): 196.33,48.69 196.33,47.24 196.24,47.15 187.92,47.15 187.74,47.34 187.74,48.87 187.82,48.95 196.07,48.95
GND on TOP (solid shape): 120.04,32.08 120.04,30.68 119.84,30.49 119.67,30.41 118.12,30.41 117.89,30.64 117.89,32.06 118.03,32.2 119.91,32.2
GND on TOP (solid shape): 17.1,22.21 17.1,21.68 17.1,21.68 17.1,19.56 17.08,19.54 15.8,19.54 15.58,19.76 15.58,22.24 15.73,22.4 16.91,22.4
GND on TOP (solid shape): 73.35,123.36 73.35,121.75 73.8,121.31 73.8,120.98 73.67,120.85 72.3,120.85 72.17,120.98 72.17,123.77 72.32,123.93 72.78,123.93
GND on TOP (solid shape): 115.08,123.84 115.08,120.82 115.01,120.75 113.33,120.75 113.18,120.9 113.18,123.33 113.56,123.33 114.08,123.85 115.06,123.85
GND on TOP (solid shape): 121.15,124.01 121.15,123.22 121.64,122.73 121.64,121.18 121.3,120.84 120.21,120.84 120.06,121 120.06,123.92 120.16,124.03 121.13,124.03
GND on TOP (solid shape): 139.11,123.96 139.11,120.28 138.99,120.17 134.52,120.17 134.15,120.53 134.15,123.87 134.31,124.03 135.99,124.03 139.04,124.03
GND on TOP (solid shape): 25.8,123.42 25.8,120.98 25.71,120.89 24.26,120.89 24.23,120.92 24.23,121.66 24.49,121.92 24.49,123.79 25.42,123.79
GND on TOP (solid shape): 143.97,116.77 143.97,111.04 143.9,110.96 140.2,110.96 140.2,111.32 140.18,111.33 140.18,113.88 142.31,116.01 142.88,116.01 143.08,116.21 143.08,116.77 143.14,116.83 143.91,116.83
GND on TOP (solid shape): 195.11,15.94 195.32,15.46 195.57,15 195.58,14.98 195.58,13 195.43,12.85 192.43,12.85 191.86,13.41 191.86,15.33 192.48,15.94
GND on TOP (solid shape): 145.49,123.19 145.49,122.49 145.48,122.48 145.48,121.72 145.8,121.41 145.8,120.98 145.67,120.85 144.3,120.85 144.07,121.08 144.07,123.72 144.13,123.79 144.9,123.79
GND on TOP (solid shape): 184.37,19.9 184.37,19.55 184.31,19.49 183.07,19.49 182.65,19.08 181.07,19.08 181.05,19.1 181.05,19.24 181.07,19.26 181.89,19.26 181.89,19.26 182.39,19.26 183.14,20.01 184.26,20.01
GND on TOP (solid shape): 208.66,30.3 208.66,28.69 208.73,28.62 208.73,26.28 208.56,26.11 206.96,26.11 206.83,26.24 206.83,28.47 207.52,29.16 207.52,30.29 207.56,30.33 208.64,30.33
GND on TOP (solid shape): 28.85,36.55 28.85,35.51 29.01,35.36 29.92,35.36 29.95,35.33 29.95,34.9 29.54,34.49 29.54,33.38 29.46,33.3 27.46,33.3 27.19,33.57 27.19,36.64 27.28,36.73 28.68,36.73
GND on TOP (solid shape): 17.28,53.25 17.28,51.01 17.12,50.85 14.84,50.85 14.67,51.02 14.67,51.15 14.71,51.19 14.71,52.03 14.7,52.13 14.68,52.22 14.67,52.24 14.67,53.3 14.8,53.43 17.11,53.43
GND on TOP (solid shape): 172.32,19.26 173.4,19.26 173.5,19.16 173.5,18.82 173.35,18.66 173.17,18.66 173.05,18.78 172.17,18.78 171.88,19.08 169.86,19.08 169.86,19.26 169.88,19.28 172.31,19.28
GND on TOP (solid shape): 69.79,117.45 69.79,115.92 69.79,115.91 69.79,115.81 69.72,115.74 69.38,115.74 69.37,115.73 69.35,115.73 69.08,115.45 69.08,112.02 69.46,111.63 69.46,108.07 69,107.61 67.28,107.61 67.04,107.85 67.04,117.17 67.36,117.48 69.76,117.48
GND on TOP (solid shape): 94.57,118.07 94.57,109.23 94.36,109.02 92.2,109.02 91.9,109.32 91.9,118.02 92.02,118.15 94.5,118.15
GND on TOP (solid shape): 159.87,123.88 159.87,120.9 159.59,120.62 158.23,120.62 158.09,120.76 158.09,124.02 158.15,124.07 158.19,124.06 158.4,124.05 158.58,124.14 159.6,124.14
GND on TOP (solid shape): 96.97,123.71 97.2,123.71 97.35,123.56 97.35,122.56 97.73,122.18 97.73,121.23 97.71,121.21 97.66,121.09 97.66,120.96 97.66,120.92 97.61,120.87 96.24,120.87 96.15,120.96 96.15,123.77 96.23,123.85 96.82,123.85
GND on TOP (solid shape): 44.46,118.84 44.46,113.36 44.47,113.36 44.47,109.44 44.38,109.35 43.9,109.35 43.08,110.18 43.08,110.4 42.46,111.02 42.46,119.05 42.6,119.2 44.1,119.2
GND on TOP (solid shape): 118.36,115.93 118.36,109.23 118.09,108.95 117.8,108.95 117.69,108.84 116.51,108.84 116.21,109.14 116.21,115.89 116.29,115.97 118.33,115.97
GND on TOP (solid shape): 180.8,43.36 180.8,40.2 181.16,39.83 182.32,39.83 182.36,39.79 182.36,33.43 182.25,33.32 179.96,33.32 178.81,34.46 161.02,34.46 160.86,34.62 160.86,39.99 161.18,40.32 176.07,40.32 176.48,40.72 176.48,43.43 176.71,43.66 180.49,43.66
GND on TOP (solid shape): 185.22,130.48 185.22,128.56 184.95,128.29 184.02,128.29 183.72,128.58 183.72,128.85 183.85,128.98 183.85,129.82 183.72,129.95 183.72,130.12 183.8,130.25 183.82,130.39 183.86,130.5 183.97,130.55 185.16,130.55
GND on TOP (solid shape): 89.39,123.97 89.76,123.68 90.13,123.97 90.15,124.03 91.02,124.03 91.12,123.92 91.12,120.76 90.89,120.52 86.29,120.52 86.18,120.63 86.18,123.85 86.35,124.03 89.38,124.03
GND on TOP (solid shape): 178.2,25.65 178.2,18.4 178.42,18.19 179.54,18.19 179.6,18.13 179.6,11.13 179.45,10.97 177.11,10.97 175.82,12.27 172.18,12.27 171.42,13.03 171.42,14.32 171.49,14.4 174.42,14.4 174.66,14.33 174.89,14.4 175.79,14.4 177.74,16.35 177.74,20.43 177.56,20.61 175.18,20.61 175.14,20.65 175.14,21.22 174.96,21.41 173.37,21.41 173.17,21.61 173.17,25.61 173.29,25.72 178.13,25.72
GND on TOP (solid shape): 166.97,25.63 166.97,18.19 168.2,18.19 168.31,18.08 168.31,14.81 168.3,14.81 168.3,10.19 168.19,10.08 161.52,10.08 161.3,10.29 161.3,13.88 161.43,14 164.62,14 164.99,14.37 164.99,15.9 165.26,16.17 166.17,16.17 166.5,16.5 166.5,20.47 166.47,20.5 163.89,20.5 163.82,20.58 163.45,20.58 162.84,21.18 161.39,21.18 161.24,21.34 161.24,24.77 162.19,25.71 166.89,25.71
GND on TOP (solid shape): 17.98,118.91 18.21,118.84 18.44,118.92 19.17,118.92 19.45,118.65 19.89,118.65 20.02,118.52 20.02,116.03 19.47,115.47 19.47,115.44 19.43,115.39 19.43,110.97 19.47,110.92 19.47,110.79 19.45,110.77 19.4,110.65 19.38,110.52 19.38,110.52 18.41,110.52 18.14,110.68 17.84,110.59 17.73,110.55 17.63,110.59 17.51,110.7 17.44,110.94 17.44,118.53 17.83,118.92 17.96,118.92
GND on TOP (solid shape): 115.21,42.04 115.21,41 114.81,40.59 109.04,40.59 108.31,39.85 108.31,38.63 108.23,38.56 106.5,38.56 106.35,38.41 106.35,37.06 107.04,36.37 108.63,36.37 108.69,36.37 110.46,36.37 110.5,36.41 111.02,36.63 112.22,36.63 112.39,36.8 112.7,36.8 112.7,37.39 113.11,37.8 113.46,37.8 113.46,38.15 114,38.69 114.05,38.67 114.44,38.65 114.73,38.92 114.75,38.96 115.11,38.96 115.11,38.94 115.79,38.94 115.88,38.86 115.88,38.74 115.82,38.74 115.52,38.43 114.27,38.43 114.05,38.21 114.05,37.69 113.41,37.06 113.41,36.42 112.98,35.99 111.76,35.99 110.9,35.13 107.31,35.13 107.24,35.21 105.56,35.21 105.4,35.37 105.4,36.36 105.38,36.37 105.38,40.03 106.48,41.12 113.95,41.12 114.96,42.14 115.11,42.14
GND on TOP (solid shape): 200.69,41.47 200.69,39 200.87,38.82 201.91,38.82 202.11,38.62 202.11,34.72 202.21,34.62 203.34,34.62 203.45,34.51 203.45,32.17 203.68,31.94 203.68,29.69 203.47,29.48 198.62,29.48 198.44,29.66 198.44,31 198.57,31.14 200.18,31.14 200.24,31.21 200.24,32.45 200.36,32.57 201.47,32.57 201.7,32.79 201.7,37.25 201.36,37.58 196.09,37.58 195.84,37.84 195.84,38.48 195.49,38.82 194.6,38.82 194.44,38.99 194.44,39.95 194.23,40.16 190.8,40.16 190.53,39.88 190.53,32.89 190.78,32.64 191.7,32.64 191.77,32.56 191.77,25.58 191.49,25.3 189.56,25.3 188.81,24.55 188.81,20.25 188.69,20.14 185.41,20.14 185.1,20.45 185.1,24.55 185.78,25.23 185.78,26.88 186.24,27.34 186.24,29.66 186.4,29.81 189.58,29.81 190.1,30.33 190.1,34.9 189.99,35 189.99,35 189.79,35.2 186.39,35.2 186.24,35.35 186.24,38.18 188.14,40.08 188.14,41.52 188.31,41.69 200.47,41.69
GND on TOP (solid shape): outline of 234 points within 35.43,23.45 41.43,31.05
GND on TOP (solid shape): outline of 234 points within 59.43,23.45 65.43,31.05
GND on TOP (solid shape): outline of 234 points within 83.43,23.45 89.43,31.05
GND on TOP (solid shape): outline of 234 points within 107.43,23.45 113.43,31.05
GND on TOP (solid shape): outline of 234 points within 131.43,23.45 137.43,31.05
GND on TOP (solid shape): outline of 234 points within 155.43,23.45 161.43,31.05
GND on TOP (solid shape): outline of 271 points within 2.5,111 12.5,121
GND on TOP (solid shape): outline of 271 points within 2.5,14 12.5,24
GND on TOP (solid shape): outline of 271 points within 85.5,3.5 95.5,13.5
GND on TOP (solid shape): outline of 271 points within 197.5,111 207.5,121
GND on TOP (solid shape): outline of 271 points within 197.5,14 207.5,24
GND on TOP (solid shape): outline of 489 points within 0.51,0.51 209.49,147.49
GND on BOTTOM (solid shape): 99.29,35.58 97.46,35.58 97.46,37.41 99.29,37.41
GND on BOTTOM (solid shape): 76.65,130.94 76.65,129.37 74.83,129.37 74.7,129.5 74.7,130.76 74.9,130.97 76.63,130.97
GND on BOTTOM (solid shape): 163.09,76.15 162.69,75.74 160.99,75.74 160.32,76.4 160.32,83.46 160.63,83.77 163.09,83.77
GND on BOTTOM (solid shape): 49.8,125.09 49.8,120.98 49.67,120.85 48.3,120.85 48.17,120.98 48.17,125.18 48.29,125.3 49.59,125.3
GND on BOTTOM (solid shape): 93.56,115.43 93.56,109.01 93.39,108.84 91.14,108.84 90.98,109 90.98,115.29 91.21,115.53 93.46,115.53
GND on BOTTOM (solid shape): 37.84,50.83 37.84,49.35 37.29,48.8 35.04,48.8 34.86,48.99 34.85,49 34.85,51.06 34.91,51.11 37.56,51.11
GND on BOTTOM (solid shape): 73.65,123.53 73.65,121.54 73.8,121.4 73.8,120.98 73.67,120.85 72.3,120.85 72.21,120.95 72.21,123.81 72.32,123.93 73.26,123.93
GND on BOTTOM (solid shape): 195.53,49.36 195.53,47.46 195.29,47.21 187.94,47.21 187.73,47.42 187.73,47.65 187.72,47.66 187.72,49.35 187.94,49.57 195.32,49.57
GND on BOTTOM (solid shape): 197.87,98.68 197.87,96.49 197.15,95.77 194.45,95.77 192.75,97.47 189.53,97.47 189.2,97.79 189.2,99.15 189.37,99.32 197.23,99.32
GND on BOTTOM (solid shape): 199.42,5.1 199.42,2.32 199.17,2.06 194.15,2.06 194.03,2.18 194.03,4.32 193.73,4.62 193.73,5.21 193.85,5.33 199.19,5.33
GND on BOTTOM (solid shape): 142.81,115.66 142.81,110.4 142.34,109.93 140.74,109.93 140.69,109.98 140.69,115.62 140.85,115.79 142.68,115.79
GND on BOTTOM (solid shape): 66.49,65.15 68.08,65.15 68.15,65.08 68.15,64.5 67.82,64.17 67.82,57.43 67.69,57.3 60.35,57.3 60.12,57.53 60.12,64.95 60.35,65.18 66.47,65.18
GND on BOTTOM (solid shape): 161.56,10.14 161.56,7.86 161.56,7.86 161.56,3.27 161.55,3.26 156.31,3.26 156.2,3.37 156.2,6.09 157.83,7.71 157.83,9.79 157.61,10 157.61,10.31 157.85,10.55 161.15,10.55
GND on BOTTOM (solid shape): 205.26,87.43 205.26,86.57 205.23,86.55 205.23,81.76 205.13,81.66 204.2,81.66 204.01,81.86 204.01,83.73 204.18,83.9 204.18,86.01 204.22,86.06 204.22,87.61 204.38,87.76 204.93,87.76
GND on BOTTOM (solid shape): 28.22,127.72 28.07,127.57 26.49,127.57 26.44,127.62 26.44,128.38 26.44,128.39 26.46,128.53 26.44,128.66 26.44,128.67 26.44,130.9 26.53,130.99 28.22,130.99
GND on BOTTOM (solid shape): 202.12,87.31 202.12,86.17 201.73,85.78 201.66,85.78 201.66,85.79 201.56,85.8 201.47,85.79 201.46,85.78 200.5,85.78 200.41,85.87 200.41,87.33 200.57,87.48 201.94,87.48
GND on BOTTOM (solid shape): 118.09,115.36 118.09,108.44 117.93,108.28 115.42,108.28 115.3,108.4 115.3,115.35 115.6,115.65 117.81,115.65
GND on BOTTOM (solid shape): 124.65,130.94 124.65,129.38 124.32,129.05 124.32,129.04 124.17,128.88 124.17,128.2 124.16,128.18 123.28,128.18 123.23,128.19 123.18,128.19 122.96,128.19 122.7,128.45 122.7,130.76 122.9,130.97 124.63,130.97
GND on BOTTOM (solid shape): 122.28,40.08 122.28,36.7 121.72,36.14 119.46,36.14 119.44,36.14 119.22,36.2 118.99,36.14 118.97,36.14 117.57,36.14 117.19,36.52 117.19,40.16 117.71,40.68 121.69,40.68
GND on BOTTOM (solid shape): 170.02,121.4 170.02,114.15 169.22,113.35 169.22,112.99 168.86,112.62 167.79,112.62 167.74,112.67 167.74,117.32 167.26,117.8 167.26,121.66 167.35,121.75 169.67,121.75
GND on BOTTOM (solid shape): 145.8,123.54 145.8,122.28 145.7,122 145.8,121.72 145.8,120.98 145.67,120.85 144.3,120.85 144.26,120.89 144.26,123.74 144.32,123.8 145.54,123.8
GND on BOTTOM (solid shape): 121.62,124.1 121.62,124.02 121.6,124 121.48,123.67 121.62,123.35 121.62,120.92 121.5,120.79 120.12,120.79 120.05,120.86 120.05,123.77 120.56,124.28 121.44,124.28
GND on BOTTOM (solid shape): 45.43,117.84 45.43,116.94 45.54,116.83 45.54,116.69 45.52,116.67 45.44,116.42 45.52,116.18 45.54,116.16 45.54,116.05 45.52,116.03 45.44,115.77 45.54,115.52 45.54,111.55 45.15,111.16 42.67,111.16 42.67,111.16 42.67,112.64 42.69,112.65 42.69,117.9 42.77,117.98 45.29,117.98
GND on BOTTOM (solid shape): 33.58,39.34 33.52,39.29 33.4,38.94 33.58,38.62 33.58,36.55 30.33,36.55 30.33,38.2 30.37,38.22 30.56,38.55 30.37,38.88 30.33,38.9 30.33,40.02 30.42,40.08 33.58,40.08
GND on BOTTOM (solid shape): 42.32,47.53 42.36,47.52 42.4,47.32 42.56,47.18 42.6,47.14 42.61,47.09 42.6,46.93 42.67,46.79 42.69,46.76 42.69,46.69 42.67,46.67 42.59,46.51 42.61,46.34 42.62,46.29 42.48,46.15 41.84,46.15 41.73,46.26 41.73,47.47 41.81,47.55 42.27,47.55
GND on BOTTOM (solid shape): 68.71,114.45 68.71,107.66 68.57,107.51 65.94,107.51 65.8,107.65 65.8,108.03 65.81,108.03 65.81,109.24 65.86,109.35 65.97,109.39 66.36,109.78 65.96,110.15 65.85,110.2 65.8,110.31 65.8,114.58 65.93,114.71 68.45,114.71
GND on BOTTOM (solid shape): 49.58,42.14 49.58,41.63 48.92,40.97 48.42,40.97 48.31,41.01 48.26,41.11 47.88,41.45 47.51,41.11 47.46,41.01 47.35,40.97 47.27,40.97 47.13,40.83 46.9,40.83 46.32,40.26 45.78,40.26 45.5,40.54 45.5,41.99 48.82,41.99 48.84,42.01 48.92,42.01 49.1,42.19 49.53,42.19
GND on BOTTOM (solid shape): 22.54,27.48 22.54,23.33 22.54,23.32 22.53,23.28 22.51,23.25 22.49,23.22 22.46,23.2 22.42,23.19 22.39,23.18 22.34,23.19 22.29,23.19 22.23,23.18 22.18,23.16 22.13,23.14 22.08,23.11 22.04,23.08 22.01,23.03 21.98,22.99 21.96,22.94 21.94,22.89 21.93,22.83 21.93,22.78 21.94,22.72 21.96,22.67 21.98,22.62 22.01,22.58 22.04,22.54 22.08,22.5 22.13,22.47 22.18,22.45 22.23,22.43 22.29,22.42 22.34,22.42 22.39,22.43 22.42,22.43 22.46,22.41 22.49,22.39 22.51,22.36 22.53,22.33 22.54,22.3 22.54,22.28 22.54,19.93 22.15,19.54 15.8,19.54 15.58,19.76 15.58,25.83 16.2,26.45 17.66,26.45 17.66,24.56 17.99,24.23 21.38,24.23 21.67,24.52 21.67,26.46 21.41,26.72 17.94,26.72 17.66,26.45 16.2,26.45 17.59,27.84 22.18,27.84
GND on BOTTOM (solid shape): 41.15,45.67 41.15,45.49 41.35,45.29 41.35,43.94 41.07,43.66 40.91,43.66 40.9,43.67 40.74,43.71 40.58,43.67 40.56,43.66 40.39,43.66 40.29,43.75 40.17,43.8 40.14,43.8 39.87,44.08 39.87,44.11 39.84,44.23 39.78,44.33 39.76,44.39 39.78,44.44 39.83,44.93 39.34,45.03 39.24,45.01 39.16,45.05 39.11,45.09 39.06,45.12 39.01,45.14 39.01,45.66 39.14,45.78 41.03,45.78
GND on BOTTOM (solid shape): 182.98,91.92 183.04,91.92 183.1,91.86 183.36,91.86 183.49,91.72 183.49,90.14 183.5,90.13 183.5,89.67 183.5,89.66 183.46,89.51 183.48,89.36 183.49,89.32 182.84,88.67 177.34,88.67 177,89.02 177,89.05 176.96,89.19 176.88,89.31 176.73,89.45 176.73,90.7 176.48,90.95 175.87,90.95 175.83,90.92 175.83,86.99 175.73,86.88 175.66,86.88 175.6,86.94 172.01,86.94 171.7,87.25 171.7,89.6 171.7,89.61 171.72,89.71 171.7,89.81 171.7,89.82 171.7,90.56 171.72,90.57 171.72,90.75 171.71,90.8 171.7,90.86 171.7,90.93 172.7,91.92 178.23,91.92 178.25,91.88 178.59,91.65 178.93,91.88 178.95,91.92 182.27,91.92 182.53,92.18 182.71,92.18
GND on BOTTOM (solid shape): outline of 86 points within 108.44,142.6 165.08,147.49
GND on BOTTOM (solid shape): outline of 97 points within 106.27,36.11 110.95,40.63
GND on BOTTOM (solid shape): 179.91,25.64 179.91,17.99 179.72,17.81 179.72,11.83 178.92,11.03 176.16,11.03 175.41,11.79 175.41,14.55 175.53,14.67 175.56,14.67 175.84,14.8 175.94,15.08 175.94,15.16 175.95,15.16 175.95,15.61 176.17,16.01 175.95,16.41 175.95,17.91 176.08,18.11 176.06,18.36 176.06,18.41 176.1,18.45 176.33,18.76 176.18,19.12 176.15,19.17 176.16,19.22 176.14,19.7 175.67,19.78 175.62,19.76 175.18,20.19 175.18,20.2 174.61,20.78 174.6,20.78 174.19,21.18 172.54,21.18 171.7,20.35 170.51,20.35 169.27,19.1 169.27,11.8 168.7,11.23 165.65,11.23 165.3,11.58 165.3,15.69 165.3,15.7 165.3,18.8 162.54,21.56 162.54,25.61 162.72,25.8 179.75,25.8
GND on BOTTOM (solid shape): outline of 234 points within 25.68,16.2 31.68,23.8
GND on BOTTOM (solid shape): outline of 234 points within 49.68,16.2 55.68,23.8
GND on BOTTOM (solid shape): outline of 234 points within 73.68,16.2 79.68,23.8
GND on BOTTOM (solid shape): outline of 234 points within 97.68,16.2 103.68,23.8
GND on BOTTOM (solid shape): outline of 234 points within 121.68,16.2 127.68,23.8
GND on BOTTOM (solid shape): outline of 234 points within 145.68,16.2 151.68,23.8
GND on BOTTOM (solid shape): outline of 271 points within 2.5,111 12.5,121
GND on BOTTOM (solid shape): outline of 271 points within 2.5,14 12.5,24
GND on BOTTOM (solid shape): outline of 271 points within 85.5,3.5 95.5,13.5
GND on BOTTOM (solid shape): outline of 271 points within 197.5,111 207.5,121
GND on BOTTOM (solid shape): outline of 271 points within 197.5,14 207.5,24
GND on BOTTOM (solid shape): 93.35,147.39 93.35,147.12 93.21,146.98 18.5,146.98 17.8,146.7 17.52,146 17.52,125.5 16.63,123.37 14.5,122.48 2,122.48 1.3,122.2 1.02,121.5 1.02,2 1.3,1.3 2,1.02 208,1.02 208.7,1.3 208.98,2 208.98,31.74 208.98,36.08 208.98,73.76 209.17,74.15 209.06,74.58 209.15,74.9 209.06,75.23 209.17,75.58 209.06,75.93 209.23,76.39 209.04,76.83 209.04,77.74 209.09,77.79 209.09,104.56 208.98,104.82 208.98,105.21 209.17,105.69 208.98,106.17 208.98,121.5 208.7,122.2 208,122.48 195.5,122.48 193.37,123.37 192.48,125.5 192.48,146 192.2,146.7 191.5,146.98 170.45,146.98 170.45,147.49 191.5,147.49 192.55,147.05 192.99,146 192.99,125.5 193.73,123.73 195.5,122.99 208,122.99 209.06,122.55 209.49,121.5 209.49,2 209.06,0.94 208,0.51 2,0.51 0.94,0.94 0.51,2 0.51,121.5 0.94,122.55 2,122.99 14.5,122.99 16.27,123.73 17.01,125.5 17.01,146 17.45,147.05 18.5,147.49 93.25,147.49
GND on BOTTOM (solid shape): outline of 756 points within 160.86,1.34 204.91,41.92
GND on GND (solid shape): outline of 29171 points within 0.51,0.51 209.49,147.49
GND on IN1 (solid shape): 121.76,37.61 121.78,37.6 121.78,36.92 121.4,36.54 119,36.54 118.89,36.43 118.25,36.43 118.04,36.64 118.04,40.33 118.14,40.43 121.76,40.43
GND on IN1 (solid shape): 167.26,146.98 162.54,146.98 162.43,147.09 132.2,147.09 132.1,146.98 128.31,146.98 128.31,146.98 126.37,146.98 124.89,145.5 121.76,145.5 121.76,145.51 121.28,145.51 121.23,145.56 120.4,145.56 120.31,145.65 120.31,147.49 167.26,147.49
GND on IN1 (solid shape): 201.98,32.75 201.79,32.57 200.97,32.57 200.9,32.5 200.9,31.84 201.15,31.59 202.9,31.59 203.06,31.75 203.06,34.63 205.98,34.63 206.28,34.33 206.28,34.33 206.47,34.14 206.47,31.85 205.48,30.86 205.48,29.96 205.24,29.72 200.72,29.72 200.38,30.06 200.38,33.84 200.64,33.84 201.22,34.42 201.23,34.42 201.36,34.55 201.36,34.55 201.43,34.63 201.98,34.63
GND on IN1 (solid shape): 33.58,39.56 33.58,39.26 33.45,38.98 33.58,38.69 33.58,36.95 33.5,36.87 32.99,36.87 32.78,36.67 30.33,36.67 30.33,38.2 30.37,38.22 30.56,38.55 30.37,38.88 30.33,38.9 30.33,40.02 30.42,40.08 33.05,40.08
GND on IN1 (solid shape): outline of 86 points within 106.03,36.11 110.95,40.63
GND on IN1 (solid shape): 208.36,34.69 208.46,34.66 208.56,34.65 208.67,34.61 208.72,34.5 208.72,31.17 208.64,31.04 208.49,31.04 207.91,30.71 208.49,30.39 208.64,30.39 208.72,30.26 208.72,25.02 208.36,24.66 207.04,24.66 206.45,25.25 205.22,25.25 204.71,25.77 201.25,25.77 199.58,27.44 199.58,29.42 199.67,29.56 199.84,29.53 200.4,28.96 205.55,28.96 206.24,29.65 206.24,30.55 207.28,31.59 207.28,34.2 207.79,34.7 208.35,34.7
GND on IN1 (solid shape): outline of 289 points within 15.58,19.54 22.54,27.85
