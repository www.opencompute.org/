# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RST_PESW_M2I_LVC_N_R: length 18.4
  BOTTOM w0.112: R4171.1 R4188.1 186.57,123.36 187.27,122.66 187.27,120.04 186.92,119.69 186.92,117.17 v3(187.37,116.72) 188.72,115.37 188.72,113.49 189.71,112.5 189.71,111.48 190.78,110.42 U102.6
RST_PESW_M2I_N: length 52.9
  BOTTOM w0.112: R3295.2 206.12,73.38 206.12,76.76 205.6,77.28 205.6,86.4 206.29,87.09 206.29,98.58 205.6,99.27 205.6,102.25 204.07,103.78 204.07,105.76 201.96,107.87 197.59,107.87 193.95,104.24 192.71,104.24 191.43,105.53 v3(191.43,106.2) U102.5
RST_PESW_M2I_N_R: length 11
  TOP w0.112: U34.AD31 v6(195.59,75.02)
  BOTTOM w0.112: v6(195.59,75.02) 196.52,75.02 197.02,74.52 201.93,74.52 202.66,73.79 v3(203.05,73.79) 204.45,73.79 R3295.1
RST_PESW_M2J_LVC_N: length 145.5
  IN1 w0.122: v2(91.72,145.99) 91.72,145.56 92.35,144.93 94.93,144.93 96.11,143.75 96.11,142.98 96.36,142.73 99.04,142.73 100.21,141.55 102.03,141.55 102.67,142.19 104.85,142.19 105.29,142.63 107.43,142.63 107.98,143.18 112.11,143.18 112.99,142.3 119.74,142.3 120.96,143.52 122.01,143.52 122.49,144 125.23,144 125.54,143.69 132.63,143.69 134.77,145.83 137.99,145.83 140.66,143.16 142.02,143.16 142.15,143.29 144.05,143.29 144.2,143.14 145.43,143.14 145.59,143.2 146.82,143.2 147.69,142.34 168.31,142.34 170.34,140.3 184.28,140.3 184.57,140.59 185.49,140.59 v2(186.44,139.64)
  BOTTOM w0.112: R4172.2 187.76,122.52 187.76,122.76 187.14,123.38 187.14,133.65 187.6,134.12 187.6,138.5 187.5,138.6 187.33,138.6 186.44,139.49 v2(186.44,139.64) ; J34.A50 83.42,133.93 80.43,136.92 80.43,141.79 81.42,142.78 81.42,144.23 81.82,144.64 85.78,144.64 87.22,146.08 91.08,146.08 91.17,145.99 v2(91.72,145.99)
RST_PESW_M2J_LVC_N_R: length 8
  BOTTOM w0.112: R4172.1 R4189.1 187.5,119.55 187.5,118.42 v3(188.11,117.81) 190.13,115.8 U102.8
RST_PESW_M2J_N: length 53.8
  BOTTOM w0.112: R3296.2 206.56,72.81 206.56,73.41 206.51,73.46 206.51,77 205.99,77.52 205.99,86.1 206.68,86.8 206.68,98.74 205.99,99.44 205.99,102.45 204.46,103.97 204.46,105.93 202.08,108.31 195.99,108.31 v3(195.48,108.81) 195.48,109.35 194.59,110.24 194.03,110.24 190.78,113.49 U102.9
RST_PESW_M2J_N_R: length 12.9
  TOP w0.112: U34.AD30 v6(194.59,75.02)
  BOTTOM w0.112: R3296.1 204.05,73.17 201.45,73.17 v3(201.18,73.44) 201.06,73.56 196.46,73.56 196.07,73.95 196.07,74.43 195.91,74.59 194.69,74.59 194.59,74.69 v6(194.59,75.02)
RST_PESW_M2K_LVC_N: length 171.6
  IN1 w0.122: v2(163.25,145.53) 162.1,146.69 132.43,146.69 130.75,145.01 127.4,145.01 127.39,145.02 127.02,145.02 127.01,145.01 120.44,145.01 120.05,145.4 113.94,145.4 113.15,144.6 107.36,144.6 106.95,144.19 105.93,144.19 104.82,145.31 99.88,145.31 98.85,144.27 97.04,144.27 95.68,145.64 v2(95.68,146.15) ; v2(185.36,143.78) 183.44,145.69 v2(179.83,145.69)
  BOTTOM w0.112: v2(179.83,145.69) 179.12,146.41 174.21,146.41 173.06,145.26 163.53,145.26 v2(163.25,145.53) ; R4174.2 188.39,122.93 188.39,132.97 188.93,133.51 188.93,135.05 188.36,135.63 188.36,138.59 187.95,139 187.49,139 186.99,139.5 186.99,140.01 186.69,140.31 186.22,140.31 186.05,140.48 186.05,143.09 v2(185.36,143.78) ; J6.B50 59.42,134.97 57.19,137.2 57.19,143.17 59.87,145.85 82.14,145.85 82.95,145.03 85.49,145.03 87.08,146.62 92.31,146.62 93.24,145.69 93.85,145.69 94.48,146.33 95.5,146.33 v2(95.68,146.15)
RST_PESW_M2K_LVC_N_R: length 8.5
  BOTTOM w0.112: R4174.1 R4190.1 v3(190.72,120.24) 191.43,119.53 U102.10
RST_PESW_M2K_N: length 54.1
  BOTTOM w0.112: U102.11 192.08,113.31 196.55,108.83 v3(197.31,108.83) 202.11,108.83 204.85,106.09 204.85,104.14 206.38,102.61 206.38,99.6 207.07,98.91 207.07,86.53 206.38,85.84 206.38,77.83 206.9,77.31 206.9,73.89 207.18,73.61 207.18,72.41 R3297.2
RST_PESW_M2K_N_R: length 14.7
  TOP w0.112: U34.AD29 v6(193.59,75.02)
  BOTTOM w0.112: v6(193.59,75.02) 193.61,75.02 194.26,74.37 195.26,74.37 197.07,72.55 197.07,71.79 197.34,71.53 202.17,71.53 v3(202.24,71.45) 202.59,71.45 203.08,71.94 204.27,71.94 R3297.1
RST_PESW_M2L_LVC_N: length 184.5
  TOP w0.112: v2(33.12,145.63) 31.4,143.91 31.4,137.96 31,137.55 v2(31,135.26)
  IN1 w0.122: v2(176.48,144.03) 175.93,144.57 161.31,144.57 160.89,144.99 151.97,144.99 151.59,144.62 147.5,144.62 146.53,145.6 143.85,145.6 143.65,145.39 142.89,145.39 142.03,146.26 132.91,146.26 130.77,144.12 126.42,144.12 126.11,144.43 122.08,144.43 121.61,143.96 120.17,143.96 119.59,144.54 114.3,144.54 113.51,143.75 107.9,143.75 107.41,143.26 105.6,143.26 104.57,144.29 100.08,144.29 99,143.21 97.27,143.21 94.51,145.98 92.83,145.98 92.2,146.61 86.72,146.61 85.27,145.16 82.79,145.16 82.15,145.8 45.58,145.8 41.59,141.8 36.01,141.8 33.12,144.69 v2(33.12,145.63)
  BOTTOM w0.112: J6.A50 35.42,133.93 34.06,135.29 32.13,135.29 31.88,135.54 31.28,135.54 v2(31,135.26) ; R4175.2 188.18,145.01 183.87,145.01 183.23,144.37 176.82,144.37 v2(176.48,144.03)
RST_PESW_M2L_LVC_N_R: length 32
  BOTTOM w0.112: U102.12 192.73,115.52 192.25,115.99 192.25,117.27 192.73,117.74 192.73,120.11 189.2,123.63 189.2,128.47 190.3,129.57 190.31,129.57 190.31,131.73 190.16,131.87 190.16,135.66 190.28,135.78 190.28,138.19 v3(188.77,139.7) 188.67,139.8 188.67,141.68 189.02,142.03 R4191.1 R4175.1
RST_PESW_M2L_N: length 56.7
  BOTTOM w0.112: U102.13 193.38,113.46 195.3,111.53 196.29,111.53 198.21,109.61 202.61,109.61 205.11,107.12 206.02,107.12 207.02,106.12 207.32,105.4 207.32,104.95 206.98,104.62 206.98,103.86 207.87,102.98 207.87,78.6 207.68,78.42 207.68,74.41 207.96,74.13 207.96,70.74 v3(207.07,69.85) 206.31,69.09 R3298.2
RST_PESW_M2L_N_R: length 21.9
  TOP w0.112: U34.AD27 v6(191.59,75.02)
  BOTTOM w0.112: v6(191.59,75.02) 191.01,74.44 191.01,73.72 190.83,73.54 190.27,73.54 190.11,73.38 190.11,72.73 190.34,72.5 190.88,72.5 191.11,72.26 191.11,71.81 191.4,71.52 195.66,71.52 196.04,71.14 196.04,69.7 196.24,69.51 201.63,69.51 201.72,69.6 v3(202.23,69.6) 202.49,69.6 202.81,69.92 204.25,69.92 R3298.1
SMB_BIC_3V3SB_READY_N: length 118
  IN1 w0.122: v2(63.82,2.65) 61.2,2.65 59.26,4.58 57.12,4.58 56.55,5.16 28.01,5.16 v2(26.3,3.45)
  IN2 w0.122: v2(35.09,58.63) 35.3,58.42 35.3,52.06 29.94,46.7 29.94,43.81 30.49,43.26 30.49,41.55 28.96,40.02 28.96,35.15 28.86,35.06 28.86,34.82 28.84,34.79 28.84,34.75 28.83,34.74 28.83,34.38 28.84,34.37 28.84,24.8 26.23,22.2 26.23,15.21 25.25,14.24 25.25,4.5 v2(26.3,3.45)
  BOTTOM w0.112: J41.32 67.7,3.03 67.39,2.71 67.39,2.19 67.06,1.86 64.6,1.86 v2(63.82,2.65) ; v2(26.3,3.45) 25.58,2.72 C1252.1 ; R4035.2 42.21,55.89 42.08,56.03 42.08,56.6 39.31,59.37 37.06,59.37 36.32,58.63 v2(35.09,58.63)
SMB_BIC_3V3SB_READY_N_R: length 7.3
  TOP w0.112: v5(42.01,48.29) 42.16,48.44 U86.T8
  BOTTOM w0.112: v5(42.01,48.29) 42.01,48.33 42.49,48.82 42.49,50.88 v3(42.75,51.13) 43.17,51.55 43.17,52.26 42.25,53.18 42.25,53.77 42.21,53.8 R4035.1
SMB_BIC_CPLD_0_CLK: length 23.2
  BOTTOM w0.112: R3989.2 15.98,39.22 15.37,38.62 15.37,35.88 16.71,34.54 23.15,34.54 23.51,34.18 23.51,33.73 v3(24.89,32.35) 26.74,30.5 28.61,30.5 28.83,30.72 28.83,31.19 28.13,31.89 28.13,32.81 R4363.2
SMB_BIC_CPLD_0_CLK_R1: length 10.9
  IN2 w0.122: v4(16.12,41.26) 15.27,41.26 14.64,41.89 14.64,46.77 14.42,46.98 14.42,47.46 14.64,47.68 14.64,48.83 v2(14.95,49.15)
  BOTTOM w0.112: U94.F8 v2(14.95,49.15) ; v4(16.12,41.26) 15.98,41.12 R3989.1
SMB_BIC_CPLD_0_CLK_R2: length 4.2
  TOP w0.112: v2(29.7,30.98) 29.87,31.14 U108.5
  BOTTOM w0.112: R4363.1 28.67,32.01 v2(29.7,30.98) R4376.2
SMB_BIC_CPLD_0_DAT: length 24
  BOTTOM w0.112: R3988.2 18.59,38.79 17.29,38.79 16.78,38.28 16.78,37.9 17.73,36.96 18.3,36.96 19.51,35.75 20.92,35.75 v3(21.23,36.06) 22.84,37.67 22.84,37.92 23.23,38.31 24.94,38.31 25.3,37.95 27.95,37.95 30.04,35.85 31.3,35.85 31.4,35.75 31.4,33.74 30.73,33.07 R4364.2
SMB_BIC_CPLD_0_DAT_R1: length 10.6
  TOP w0.112: v2(16.95,47.15) 16.95,46.64 16.63,46.32 16.63,45.43 16.73,45.33 16.73,43.45 17.24,42.94 v2(17.77,42.94)
  BOTTOM w0.112: v2(17.77,42.94) 17.82,42.89 18.86,42.89 19.96,41.79 v3(19.96,41.2) 19.02,40.27 R3988.1 ; U94.D9 v2(16.95,47.15)
SMB_BIC_CPLD_0_DAT_R2: length 5
  TOP w0.112: U108.4 30.52,31.05 v2(30.44,30.98)
  BOTTOM w0.112: v2(30.44,30.98) 30.73,31.26 R4364.1 30.5,31.98 30.28,32.2 30.28,33.5 R4377.2
SMB_BIC_CPLD_1_CLK: length 18.1
  BOTTOM w0.112: R4365.2 26.75,35.87 26.75,35.84 24.53,33.62 24.17,33.62 23.91,33.88 23.91,34.37 23.33,34.95 17.14,34.95 v3(16.44,35.65) 15.82,36.27 15.82,38.47 R3987.2
SMB_BIC_CPLD_1_CLK_R1: length 4.4
  BOTTOM w0.112: R3987.1 16.99,42.44 16.54,42.89 16.54,44.56 U94.A9
SMB_BIC_CPLD_1_CLK_R2: length 8
  TOP w0.112: v2(28.23,31.02) 28.57,31.36 U108.7
  BOTTOM w0.112: R4365.1 R4378.2 28.91,35.33 28.91,34.84 27.54,33.47 27.54,31.71 v2(28.23,31.02)
SMB_BIC_CPLD_1_DAT: length 14.8
  TOP w0.112: v2(24.35,34.06) 24.53,34.06 25.47,33.12 R4366.2
  BOTTOM w0.112: v2(24.35,34.06) 24.35,34.82 23.82,35.35 17.83,35.35 16.37,36.81 v3(16.37,37.4) 16.37,38.45 17.12,39.19 17.72,39.19 R3921.2
SMB_BIC_CPLD_1_DAT_R1: length 7
  BOTTOM w0.112: U94.C9 16.94,46.16 16.94,43.09 18.01,42.02 R3921.1
SMB_BIC_CPLD_1_DAT_R2: length 6.9
  TOP w0.112: U108.6 29.22,30.56 29.12,30.45 26.99,30.45 26.59,30.85 R4379.2 R4366.1
SMB_BIC_VR_CLK: length 86.5
  TOP w0.112: R4367.1 33.87,18.8 v2(33.87,18.59)
  IN1 w0.122: v2(33.87,18.59) 33.87,20.41 35.02,21.57 35.02,23.41 32.06,26.36 27.05,26.36 24.57,28.85 18.82,28.85 16.48,31.18 v2(16.45,31.18)
  IN2 w0.122: v2(17.22,38.1) 16.95,37.84 16.95,32.05 16.45,31.55 v2(16.45,31.18)
  BOTTOM w0.112: R3911.2 46.15,57.95 45.99,58.11 45.99,59.53 44.36,61.15 34.32,61.15 34.06,60.89 34.06,59.9 32.19,58.03 32.19,50 29.15,46.96 29.15,42.46 26.69,39.99 23.66,39.99 v3(23.46,39.79) 22.37,39.79 20.76,38.18 20.76,37.29 20.44,36.98 19.64,36.98 19.19,37.43 v3(18.65,37.43) 17.9,37.43 v2(17.22,38.1)
SMB_BIC_VR_CLK_R1: length 8.2
  TOP w0.112: R4367.2 33.03,19.48 v1(32.49,20.02) 31.17,21.34 U108.14
SMB_BIC_VR_CLK_R2: length 8.8
  TOP w0.112: U86.V3 44.95,49.4 44.67,49.12 v5(44.67,49)
  BOTTOM w0.112: v5(44.67,49) 45.19,49.52 45.19,52.58 v3(45.31,52.7) 45.31,53.17 44.87,53.62 44.87,54.27 R4051.2 45.42,54.9 45.8,55.28 46,55.28 46.15,55.43 R3911.1
SMB_BIC_VR_DAT: length 85.2
  TOP w0.112: v2(33.6,21.36) 33.68,21.36 R4368.1
  IN1 w0.122: v2(17.01,29.96) 18.69,28.28 24.49,28.28 26.96,25.81 31.99,25.81 34,23.8 34,22.57 33.6,22.17 v2(33.6,21.36)
  IN2 w0.122: v2(17.95,38.02) 17.4,37.46 17.4,31.44 17.01,31.06 v2(17.01,29.96)
  BOTTOM w0.112: R3912.2 49.48,56.78 49.04,57.22 47.79,57.22 46.6,58.41 46.6,59.47 44.51,61.55 32.58,61.55 31.77,60.74 31.77,50.14 28.74,47.1 28.74,42.63 26.49,40.39 22.23,40.39 19.81,37.97 18,37.97 v2(17.95,38.02)
SMB_BIC_VR_DAT_R1: length 6.8
  TOP w0.112: U108.15 31.82,23.54 v1(32.14,23.22) 32.22,23.14 32.22,21.49 33.22,20.49 R4368.2
SMB_BIC_VR_DAT_R2: length 9.5
  TOP w0.112: U86.W3 45.06,50.04 45.38,50.83 45.38,51.45 v2(45.63,51.7)
  BOTTOM w0.112: R3912.1 R4052.2 48.22,55.27 46.78,55.27 46.37,54.87 46.37,54.5 46.66,54.22 46.67,54.22 47.04,53.85 47.04,53.12 v3(46.99,53.06) 46.99,52.88 45.82,51.72 45.6,51.72 45.58,51.7 45.58,51.7 v2(45.63,51.7)
SMB_BMC_3V3SB_CLK: length 37.2
  TOP w0.112: v2(51.68,42) 51.64,41.97 51.08,41.97 R3783.1 ; R3044.1 71.92,21.65 v2(71.92,22.18)
  BOTTOM w0.112: v2(51.68,42) 52.01,42.34 54.25,42.34 55.27,43.36 55.87,43.36 56.22,43.71 56.22,43.92 56.63,44.34 57.64,44.34 60.25,41.72 60.25,36.53 62.89,33.89 62.89,31.82 67.29,27.43 67.29,26.23 68.89,24.63 70,24.63 v3(70.49,24.14) 71.92,22.71 v2(71.92,22.18)
SMB_BMC_3V3SB_CLK_R1: length 18.6
  TOP w0.112: v4(69.3,5.83) 69.3,6.59 72.01,9.3 72.01,11.5 72.72,12.21 72.72,19.15 72.43,19.44 R3043.2 R3044.2
  BOTTOM w0.112: J41.28 v4(69.3,5.83)
SMB_BMC_3V3SB_CLK_R2: length 6.8
  TOP w0.089: U86.D2 45.76,42.74 46.24,42.74 46.33,42.66 46.65,42.66
  TOP w0.112: R3783.2 49.51,41.86 48.28,40.63 47.76,40.63 47.63,40.68 47.43,40.89 47.43,41.88 46.65,42.66
SMB_BMC_3V3SB_DAT: length 33.5
  TOP w0.112: R3784.1 v2(53.75,41.86) ; R3045.1 71.09,21.84 v2(71.09,22.22)
  BOTTOM w0.112: v2(71.09,22.22) 69.13,24.17 68.79,24.17 66.81,26.16 66.81,27.27 62.42,31.66 62.42,33.61 59.12,36.91 59.12,41.34 58.27,42.19 58.27,43.13 57.54,43.86 57,43.86 55,41.86 v2(53.75,41.86)
SMB_BMC_3V3SB_DAT_R1: length 18.5
  TOP w0.112: R3045.2 R3047.2 70.6,19.44 70.26,19.1 70.26,15.64 71.47,14.43 v1(71.47,13.34) 71.47,9.55 v2(68.5,6.59)
  BOTTOM w0.112: J41.30 v2(68.5,6.59)
SMB_BMC_3V3SB_DAT_R2: length 8.4
  TOP w0.112: R3784.2 51.97,41.5 51.41,41.5 51.28,41.38 49.37,41.38 48.4,40.41 47.66,40.41 47.36,40.54 47.16,40.74 47.16,41.81 46.53,42.44 U86.D1
SMB_INA230_ALERT_N: length 67.2
  TOP w0.112: U86.B5 43.93,41.44 43.64,41.15 43.64,40.82 44.15,40.31 44.19,40.31 45.24,39.26 45.24,38.86 46.01,38.08 47.47,38.08 v2(47.86,37.7)
  IN1 w0.122: v2(47.86,37.7) 56.24,37.7 56.88,38.34 57.13,38.59 63.76,38.59 63.88,38.71 65.69,38.71 67.5,40.52 v2(67.5,41.48)
  BOTTOM w0.112: v2(67.5,41.48) 67.56,41.55 75.13,41.55 79.45,37.22 v3(81.37,37.22) 82.23,36.36 91.96,36.36 92.65,37.05 93.97,37.05 97.64,40.73 97.64,42.04 98.27,42.67 99.47,42.67 100.23,41.91 R4034.2
SMB_INA230_ALERT_N_R: length 4.3
  BOTTOM w0.112: U2.3 98.62,38.64 v3(99.42,39.44) 99.47,39.48 99.47,39.93 99.19,40.21 R3046.2 R4034.1
SMB_M2A_ALERT_LVC_N: length 52.6
  TOP w0.112: R4194.2 31.92,87.05 29.97,87.05 29.77,86.84 v2(27.48,86.84) ; v2(28.05,59.4) 31.15,56.31 31.15,50.59 35.54,46.2 36.76,46.2 36.81,46.25 37.26,46.25 U86.M18
  IN2 w0.122: v2(27.48,86.84) 27.48,85.99 28.31,85.16 28.31,79.65 28.03,79.38 28.03,76.51 26.88,75.35 26.88,74.53 28.62,72.79 28.62,61.59 28.26,61.23 28.26,59.7 28.05,59.49 v2(28.05,59.4)
SMB_M2A_ALERT_LVC_N_R: length 6.7
  TOP w0.112: U105.2 34.77,83.23 v2(34.25,82.72) 33.88,82.35 33.5,82.35 33.05,82.8 33.05,84.57 32.71,84.91 R4210.1 R4194.1
SMB_M2A_ALERT_N: length 59.4
  TOP w0.112: U105.1 34.12,86.38 33.25,87.25 32.36,87.25 32.16,87.45 29.9,87.45 v2(27.41,89.94) ; R4312.2 35.44,109.17 35.25,108.99 32.84,108.99 31.8,110.03 31.8,110.11 v2(31.74,110.17) ; J4.B44 30.18,125.97 30.18,122.05 29.95,121.81 v2(29.69,121.81)
  IN1 w0.122: v2(29.69,121.81) 30.68,119.41 31.7,118.39 31.7,115.12 32.06,114.76 32.06,110.95 v2(31.74,110.17) 31.7,110.13 30.57,107.41 23.48,100.32 v2(23.37,100.32)
  IN2 w0.122: v2(23.37,100.32) 23.26,100.43 22.85,100.43 22.47,100.06 22.47,98.65 24.52,96.61 24.68,96.61 25.33,95.95 25.33,92.01 v2(27.41,89.94)
SMB_M2A_INA231_ALRT_N: length 106.8
  TOP w0.112: U86.U10 41.45,48.46 v5(41.48,48.43) ; R4016.2 37.74,109.2 37.3,109.2 36.82,109.68 36.82,110.21 35.73,111.3 35.13,111.3 34.89,111.07 34.89,109.57 34.79,109.47 32.92,109.47 32.24,110.15 32,110.72 32,111.54 31.33,112.21 30.4,112.21 29.69,111.5 v1(28.77,111.5) 28.05,110.78 25.44,110.78 24.83,110.18 v2(23.78,110.18)
  IN2 w0.122: v5(41.48,48.43) 41.58,48.53 41.58,50.25 42.06,50.73 42.06,56.33 43.59,57.86 44.26,57.86 45.63,59.23 45.87,59.8 45.87,61.21 45.5,61.58 45.5,66.38 47.24,68.13 47.24,70.06 44.88,72.42 44.88,73.72 45.07,73.9 45.07,75.37 41.73,78.71 41.73,80.22 41.03,80.91 40.53,80.91 38.81,82.63 37.73,82.63 32.88,87.48 31.56,87.48 29.18,89.85 29.18,92.3 29.68,92.79 29.68,95.19 27.12,97.74 27.12,98.32 25.79,99.66 25.65,99.99 25.08,100.56 25.08,101.55 23.49,103.14 21.47,103.14 18.15,106.46 18.15,106.92 19.11,107.87 19.11,108.34 20.35,109.58 20.35,110.05 22.12,111.82 22.54,111.82 23.78,110.58 v2(23.78,110.18)
SMB_M2A_INA231_ALRT_N_R: length 6.2
  TOP w0.112: R4016.1 R3899.1 36.86,110.77 36.2,111.42 v1(36.2,111.84) 37.14,112.78 U73.A3
SMB_M2A_INA231_CLK_R1: length 4.9
  TOP w0.112: R3620.1 40.29,113.66 v1(40.01,113.94) 38.46,115.49 U73.A1
SMB_M2A_INA231_DAT_R1: length 6.9
  TOP w0.112: U73.A2 37.3,115.09 37.94,114.45 38.59,114.45 39.93,113.11 39.93,112.34 v1(40.08,112.19) 40.92,111.36 40.92,110.83 R3621.1
SMB_M2A_P1V8_CLK: length 34.9
  TOP w0.112: R3620.2 41.43,112.73 41.43,110.17 39.63,108.37 36.97,108.37 36.77,108.18 v1(31.93,108.18) 30.27,108.18 30.08,108.38 30.08,108.84 30.28,109.04 30.28,109.68 R3809.2 30.47,110.81 v2(31.08,110.81) ; J4.B40 v2(29.18,123.33)
  IN1 w0.122: v2(31.08,110.81) 30.8,110.81 29.63,111.98 29.63,119.31 28.7,121.55 28.7,122.85 v2(29.18,123.33)
SMB_M2A_P1V8_CLK_R2: length 43.9
  TOP w0.112: U88.5 19.99,76.84 20.52,77.37 v1(20.52,78.51) 20.52,79.95 R67.2 19.96,81.77 20.12,81.92 20.12,89.59 19.55,90.17 19.55,92.16 18.19,93.51 v2(18.19,95.59) ; R3809.1 29.61,109.35 29.29,109.67 v2(29.29,110.91)
  IN1 w0.122: v2(18.19,95.59) 21.6,99 21.6,100.12 21.38,100.34 21.38,101.42 23.18,103.22 24.57,103.22 29.23,107.89 29.23,110.83 29.29,110.89 v2(29.29,110.91)
SMB_M2A_P1V8_DAT: length 28.2
  TOP w0.112: J4.B42 29.68,122.92 v2(29.53,122.77) ; R3621.2 39.14,109.85 39.14,109.07 38.87,108.79 36.74,108.79 36.55,108.59 32.48,108.59 31.52,109 31.36,109.23 31.36,109.6 R3810.2 31.07,110.32 31.23,110.32 31.57,110.66 31.57,111.16 31.17,111.57 v4(30.91,111.57)
  IN1 w0.122: v2(29.53,122.77) 29.27,122.51 29.24,122.37 29.24,121.51 30.07,119.51 30.07,112.41 v4(30.91,111.57)
SMB_M2A_P1V8_DAT_R2: length 42.2
  TOP w0.112: v2(18.7,94.77) 21.27,92.2 21.27,86.08 22.18,85.17 22.18,83.64 21.11,82.57 R68.2 21.64,79.98 21.64,77.67 v1(21.49,77.52) 20.65,76.68 U88.4 ; R3810.1 30.86,108.94 v2(30.55,108.63)
  IN1 w0.122: v2(30.55,108.63) 30.3,108.03 25.04,102.77 23.37,102.77 22.24,101.64 22.24,101.16 22.57,100.83 22.57,100.21 22.31,99.95 22.31,98.38 v2(18.7,94.77)
SMB_M2AB_3V3SB_CLK: length 67.7
  TOP w0.112: R3771.1 39.17,35.61 v2(38.96,35.41) ; R3804.1 21.67,64.4 22.14,63.93 23.5,63.93 25.03,65.45 25.03,67.53 25.91,68.4 37.78,68.4 v2(39.54,70.17)
  IN2 w0.122: v2(38.96,35.41) 38.26,35.41 37.77,35.89 37.77,36.07 38.25,36.54 38.25,36.69 37.85,37.08 37.71,37.08 37.24,36.61 36.06,36.61 35.37,37.3 35.37,38.84 33.28,40.93 33.28,46.44 35.37,48.53 35.57,48.53 37.6,50.56 37.6,51.04 38.46,51.9 38.46,53.6 39.32,54.45 39.32,55.19 39.19,55.31 38.63,55.31 38.5,55.43 38.5,56.07 38.63,56.2 39.19,56.2 39.32,56.32 39.32,58.86 38.82,59.35 38.82,64.29 40.13,65.6 40.13,69.57 v2(39.54,70.17)
SMB_M2AB_3V3SB_CLK_R1: length 4.7
  TOP w0.112: U88.14 21.3,69.1 21.67,68.73 v1(21.67,68.35) 21.31,68 21.31,66.08 R3804.2
SMB_M2AB_3V3SB_CLK_R2: length 5.9
  TOP w0.112: U86.B12 40.28,41.27 40.28,40.84 40.08,40.64 40.08,37.56 40.21,37.42 R3790.2 R3771.2
SMB_M2AB_3V3SB_DAT: length 71.4
  TOP w0.112: v2(38.27,34.16) 38.33,34.22 39.48,34.22 40.96,34.51 41.93,34.51 42.09,34.35 43.12,34.35 43.34,34.13 44.15,34.13 44.99,34.97 44.99,35.63 R3772.1 ; v2(38.23,70.1) 36.96,68.83 25.72,68.83 24.61,67.72 24.61,65.7 23.84,64.93 R3805.1
  IN2 w0.122: v2(38.23,70.1) 38.82,70.1 39.68,69.24 39.68,66.47 38.39,65.18 38.39,59.76 36.88,58.25 36.88,54.23 37.32,53.78 37.32,52.45 35.67,50.79 35.67,50.02 33.92,48.28 33.16,48.28 32.25,47.37 32.25,46.2 32.4,46.04 32.4,41.19 34.81,38.79 34.81,36.92 36.07,35.66 37.27,35.66 38.27,34.66 v2(38.27,34.16)
SMB_M2AB_3V3SB_DAT_R1: length 5.3
  TOP w0.112: R3805.2 23.48,67.66 v1(23.48,68.2) 23.36,68.33 22.88,68.33 21.95,69.27 U88.15
SMB_M2AB_3V3SB_DAT_R2: length 7.5
  TOP w0.112: R3772.2 R3791.2 44.4,37.3 43.99,37.71 42.81,37.71 42.52,38 42.52,38.21 42.03,38.7 42.03,40.5 42.11,40.58 42.11,41.1 U86.B8
SMB_M2B_ALERT_LVC_N: length 37.8
  TOP w0.112: R4195.2 v2(34.98,80.67) ; U86.W6 43.53,50.02 43.53,50.53 43.65,50.81 43.65,52.48 43.53,52.75 43.53,54.81 43.98,55.26 43.98,57.18 41.39,59.77 v2(41.2,59.77)
  IN2 w0.122: v2(34.98,80.67) 35.39,80.26 35.79,80.26 36.4,79.65 36.4,77.55 37.59,76.35 39.13,76.35 39.73,75.75 39.73,74.51 40.46,73.78 41.08,73.78 41.43,73.43 41.43,71.96 41.65,71.74 41.65,64.48 40.64,63.47 40.64,60.33 v2(41.2,59.77)
SMB_M2B_ALERT_LVC_N_R: length 3.8
  TOP w0.112: U105.4 36.07,82.73 36.75,82.04 v2(36.76,82.04) R4211.1 R4195.1
SMB_M2B_ALERT_N: length 61.2
  TOP w0.112: U105.3 v2(35.42,82.73) ; R4313.2 58.47,109.94 v2(57.59,109.05) ; v2(55.1,122.4) 55.1,124.05 54.18,124.97 J4.A44
  IN1 w0.122: v2(55.1,122.4) 56.01,121.49 56.44,120.45 57.14,119.74 57.14,111.38 57.59,110.31 v2(57.59,109.05) 57.59,108.82 57.73,108.35 58.17,107.69 58.7,107.16 58.78,107.16 59.88,106.06 59.88,102.17 55.81,98.1 53.75,97.25 52.6,96.77 44.19,88.36 43.85,88.36 43.4,87.9 43.4,86.75 41.1,84.46 40.37,84.46 38.88,82.97 35.66,82.97 v2(35.42,82.73)
SMB_M2B_INA231_ALRT_N: length 152.7
  TOP w0.089: U86.B2 45.16,41.15 45.16,40.61 45.73,40.04 46.53,40.04
  TOP w0.112: v2(54.6,109.84) 54.81,110.05 v1(54.81,110.77) 55.86,110.77 R4017.2 ; 46.53,40.04 47.31,40.04 47.76,39.85 48.57,39.85 48.64,39.78 50.52,39.78 50.92,39.38 53.03,39.38 54.22,39.87 55.24,40.9 56,40.9 57.3,41.44 57.73,41.44 58.69,42.4 v2(58.77,42.4) ; v2(82.89,97.16) 82.46,97.58 81.57,97.95 80.78,98.75 78.49,100.28 77.98,100.78 77.98,101.2 77.69,101.5 77.13,101.5 76.97,101.34 75.79,101.34 75.78,101.33 75.76,101.34 75.7,101.34 74.09,102.94 74.09,104.03 72.78,105.35 71.74,105.35 71.5,105.11 66.63,105.11 66.01,105.73 v2(66.01,105.78)
  IN1 w0.122: v2(62.95,41.04) 61.49,42.5 58.87,42.5 v2(58.77,42.4)
  IN2 w0.122: v2(62.95,41.04) 63.05,41.14 63.05,42.01 63.56,42.52 66.42,42.52 67.46,43.56 68.63,43.56 76.12,51.05 76.12,51.46 87.46,62.8 v2(97.5,62.8)
  BOTTOM w0.112: v2(97.5,62.8) 97.63,62.8 99.11,64.28 99.11,80.66 92.8,86.97 92.8,89.83 85.11,97.52 83.25,97.52 v2(82.89,97.16) ; v2(54.6,109.84) 54.6,107.63 55.61,106.62 58.66,106.62 59.12,106.16 59.91,106.16 60.58,106.82 60.58,107.41 61.92,108.75 63.12,108.75 64.44,107.43 64.44,106.57 64.03,106.16 64.03,105.69 65.12,104.59 65.77,104.59 66.07,104.9 66.07,105.67 66.01,105.73 v2(66.01,105.78)
SMB_M2B_INA231_ALRT_N_R: length 7.7
  TOP w0.112: R4017.1 R3900.1 56.92,111.76 58.59,111.76 v1(58.71,111.64) 58.83,111.76 59.56,111.76 61.83,114.04 U74.A3
SMB_M2B_INA231_CLK_R1: length 5.4
  TOP w0.112: U74.A1 62.03,115.34 62.65,114.72 62.65,112.31 v1(63.14,111.81) 63.14,110.62 R3628.1
SMB_M2B_INA231_DAT_R1: length 4.9
  TOP w0.112: R3629.1 62.09,111.34 v1(61.65,111.79) 61.65,113.27 62.23,113.85 62.23,114.58 61.88,114.94 U74.A2
SMB_M2B_P1V8_CLK: length 28.5
  TOP w0.112: R3628.2 63.14,109.46 63.03,109.36 61.73,109.36 60.53,110.57 58.23,110.57 57.25,109.58 v2(57.05,109.58) ; J4.A40 53.18,125.97 53.18,124.84 53.78,124.24 53.78,123.99 v2(54.52,123.25)
  IN1 w0.122: v2(57.05,109.58) 57.05,110.43 56.71,110.77 56.71,119.39 56.19,119.91 55.67,121.16 54.58,122.25 54.58,123.18 v2(54.52,123.25)
  BOTTOM w0.112: v2(57.05,109.58) 57.05,108.9 56.74,108.58 R3811.2 55.97,107.86 v3(55.53,107.42)
SMB_M2B_P1V8_CLK_R2: length 66.7
  TOP w0.112: U88.7 18.69,77.17 18.29,77.58 17.95,77.58 17.71,77.82 v1(17.71,78.12) 17.71,78.42 18.26,78.97 18.26,79.95 R69.2 17.7,82.94 v2(17.95,83.19)
  IN1 w0.122: v2(57.45,107.81) 58.52,106.73 58.6,106.73 59.45,105.88 59.45,102.34 55.58,98.47 54.15,97.88 53.52,97.62 53.51,97.61 52.36,97.13 44.01,88.78 43.68,88.78 42.97,88.08 42.97,86.93 40.93,84.89 40.19,84.89 38.7,83.4 24.34,83.4 23.2,82.26 18.88,82.26 v2(17.95,83.19)
  BOTTOM w0.112: R3811.1 57.15,107.06 57.45,107.36 v2(57.45,107.81)
SMB_M2B_P1V8_DAT: length 25.3
  TOP w0.112: v2(54.4,124.09) 54.4,124.19 53.68,124.9 J4.A42 ; v2(56.4,109.65) 56.88,110.13 57.17,110.13 58.06,111.02 60.63,111.02 61.84,109.81 R3629.2
  IN1 w0.122: v2(54.4,124.09) 53.92,123.61 53.92,123.12 54.15,122.89 54.15,122.08 55.31,120.92 55.83,119.67 56.28,119.21 56.28,109.76 v2(56.4,109.65)
  BOTTOM w0.112: v2(56.4,109.65) 56.18,109.43 R3812.2
SMB_M2B_P1V8_DAT_R2: length 65.4
  TOP w0.112: v2(18.68,83.25) 18.68,80.68 R70.2 19.43,79.93 v1(19.43,77.52) 19.43,77.32 19.34,77.23 U88.6
  IN1 w0.122: v2(56.52,108.98) 56.93,107.64 58.26,106.31 58.43,106.31 59.03,105.71 59.03,102.52 55.34,98.83 53.18,97.94 52.13,97.5 43.83,89.21 43.47,89.21 42,87.74 42,86.56 40.76,85.32 40.01,85.32 38.52,83.83 24.13,83.83 22.98,82.69 19.24,82.69 v2(18.68,83.25)
  BOTTOM w0.112: v2(56.52,108.98) 56.17,108.63 R3812.1
SMB_M2C_ALERT_LVC_N: length 38.2
  TOP w0.112: U86.T7 42.93,48.44 v5(42.44,47.95) ; R4196.2 40.74,80.9 40.33,80.9 v2(40.07,80.64)
  IN2 w0.122: v2(40.07,80.64) 40.07,78.45 41.81,76.71 41.81,75.1 42.86,74.04 43.19,74.04 43.59,73.63 43.59,71.6 43.09,71.09 43.09,61.46 43.62,60.93 43.62,59.35 v2(43.09,58.81)
  BOTTOM w0.112: v5(42.44,47.95) 42.54,47.95 43.4,48.82 43.4,50.09 43.95,50.64 43.95,52.86 43.35,53.46 43.35,56.75 43.09,57.01 v2(43.09,58.81)
SMB_M2C_ALERT_LVC_N_R: length 5.3
  TOP w0.112: U105.6 37.37,82.97 37.47,82.87 39.11,82.87 v1(39.28,82.71) 39.36,82.62 R4206.1 R4196.1
SMB_M2C_ALERT_N: length 89.7
  TOP w0.112: J36.B44 78.18,125.97 78.18,123.93 78.55,123.56 79.4,123.56 79.7,123.26 79.7,121.6 79.47,121.37 v2(79.21,121.37) ; U105.5 36.72,85 37.31,85.6 38.23,85.6 38.51,85.32 38.51,84.35 40.82,82.04 41.45,82.04 42.49,81 47.57,81 v2(48.24,81.68) ; v2(82.86,107.51) 82.86,108.75 R4314.2
  IN1 w0.122: v2(48.24,81.68) 50.29,83.72 52.19,84.51 57.38,84.51 57.44,84.57 69.57,84.57 71.66,86.66 71.66,87.9 81.86,98.09 81.86,106.29 82.18,106.61 82.18,106.83 v2(82.86,107.51)
  IN2 w0.122: v2(82.86,107.51) 82.65,108.02 82.65,109.07 83.32,109.75 83.32,110.17 81.23,112.26 81.23,119.35 v2(79.21,121.37)
SMB_M2C_INA231_ALRT_N: length 123.2
  TOP w0.089: 46.3,39.81 45.69,39.81 44.95,40.55 U86.B3
  TOP w0.112: v2(83.53,108.6) 83.64,108.71 v1(85.12,108.71) 85.19,108.71 85.58,109.1 R4018.2 ; 46.3,39.81 47.19,39.81 47.69,39.6 48.16,39.6 48.52,39.24 49.59,39.24 v2(50.46,38.37)
  IN1 w0.122: v2(50.46,38.37) 50.71,38.13 55.99,38.13 56.87,39.01 60.42,39.01 60.69,39.28 v2(60.69,39.81) ; v2(81,97.86) 81,98.29 81.4,98.69 81.4,106.47 81.7,106.77 81.7,107.43 82.36,108.08 83.01,108.08 v2(83.53,108.6)
  IN2 w0.122: v2(60.69,39.81) 62.06,41.18 62.06,42.6 63.01,43.55 63.81,43.55 64.25,43.99 68.45,43.99 75.69,51.23 75.69,51.64 88.1,64.05 97.55,64.05 v2(97.85,64.34)
  BOTTOM w0.112: v2(97.85,64.34) 98,64.34 98.32,64.67 98.32,80.3 81,97.63 v2(81,97.86)
SMB_M2C_INA231_ALRT_N_R: length 5.9
  TOP w0.112: U75.A3 86.62,114.41 85.67,113.47 v1(85.67,112.25) 86.38,111.54 R3901.1 R4018.1
SMB_M2C_INA231_CLK_R1: length 9.1
  TOP w0.112: U75.A1 87.73,115.92 88.02,116.21 88.55,116.21 89.97,114.79 v1(89.97,111.28) 89.69,111 R3635.1
SMB_M2C_INA231_DAT_R1: length 5.2
  TOP w0.112: U75.A2 86.84,115.52 87.2,115.17 87.2,114.2 86.98,113.98 86.98,112.59 v1(87.18,112.4) 87.18,111.84 87.49,111.52 R3636.1
SMB_M2C_P1V8_CLK: length 29.3
  TOP w0.112: v2(79.2,122.04) 78.22,122.04 77.18,123.09 J36.B40 ; R3635.2 88.25,110.2 85.31,107.26 v1(84.64,107.26) v2(83.67,107.26)
  IN2 w0.122: v2(83.67,107.26) 83.67,107.26 83.3,107.63 83.07,108.17 83.07,108.9 83.75,109.57 83.75,110.36 81.79,112.32 81.79,119.45 v2(79.2,122.04)
  BOTTOM w0.112: R3813.2 83.77,106.58 83.77,107.16 v2(83.67,107.26)
SMB_M2C_P1V8_CLK_R2: length 80.5
  TOP w0.112: v2(28.57,79.02) R71.2 27.99,76.03 v1(27.99,74.63) 27.99,73.37 28.2,73.17 U89.5
  IN1 w0.122: v2(28.57,79.02) 30.09,77.5 37.95,77.5 38.56,78.11 46,78.11 50.97,83.08 52.07,83.54 57.7,83.54 57.86,83.7 69.93,83.7 72.52,86.29 72.52,87.54 82.75,97.78 82.75,105.89 v2(82.96,106.1)
  BOTTOM w0.112: v2(82.96,106.1) 83.3,105.76 R3813.1
SMB_M2C_P1V8_DAT: length 27.3
  TOP w0.112: v2(79.17,123.11) 78.35,123.11 77.68,123.77 J36.B42 ; R3636.2 87.49,110.12 85.47,108.1 83.98,108.1 v2(83.83,107.95)
  IN2 w0.122: v2(83.83,107.95) 83.82,107.95 83.82,107.98 83.81,107.98 83.81,107.99 84.19,108.37 84.19,110.57 82.26,112.5 82.26,120.02 v2(79.17,123.11)
  BOTTOM w0.112: R3814.2 82.99,108.26 83.3,107.95 v2(83.83,107.95)
SMB_M2C_P1V8_DAT_R2: length 80.8
  TOP w0.112: v2(29.72,79.01) R72.2 29.13,76.03 29.13,73.86 v1(29,73.72) 28.85,73.57 U89.4
  IN1 w0.122: v2(83.04,106.86) 82.32,106.15 82.32,97.95 72.09,87.72 72.09,86.48 69.75,84.13 57.68,84.13 57.61,84.07 52.24,84.07 50.66,83.41 45.78,78.54 38.35,78.54 37.76,77.94 30.79,77.94 v2(29.72,79.01)
  BOTTOM w0.112: R3814.1 81.86,107.27 82.26,106.86 v2(83.04,106.86)
SMB_M2CD_3V3SB_CLK: length 6.2
  TOP w0.112: R3773.1 31.08,59.48 v2(30.24,59.48) 30.24,60.12 30.3,60.19 R3817.1
SMB_M2CD_3V3SB_CLK_R1: length 4.5
  TOP w0.112: R3817.2 30.3,63.95 v1(29.72,64.53) 29.5,64.75 U89.14
SMB_M2CD_3V3SB_CLK_R2: length 10.3
  TOP w0.112: U86.U19 36.71,48.94 35.95,49.71 34.88,49.71 34.54,50.05 v1(33.98,50.05) 33.98,51.85 32.86,52.97 32.86,54.24 R3792.2 R3773.2
SMB_M2CD_3V3SB_DAT: length 5.6
  TOP w0.112: R3818.1 31.32,60.71 v2(32.52,59.51) 34.67,57.36 R3774.1
SMB_M2CD_3V3SB_DAT_R1: length 4.7
  TOP w0.112: R3818.2 31.32,64 v1(31.28,64.04) 30.15,65.17 U89.15
SMB_M2CD_3V3SB_DAT_R2: length 8.8
  TOP w0.112: U86.V17 37.82,49.57 37.82,50.06 35.18,52.71 34.76,52.71 34.14,53.32 34.14,54.43 R3793.2 R3774.2
SMB_M2D_ALERT_LVC_N: length 96.9
  TOP w0.112: U86.V5 43.94,49.46 43.94,50.48 44.08,50.82 44.08,52.51 43.95,52.83 43.95,54.59 44.38,55.02 44.38,57.91 43.67,58.61 43.5,59.02 43.27,59.26 42.72,59.26 v2(42.17,59.81) ; v2(87.58,59.44) 87.35,59.66 87.35,59.82 88.32,60.78 R4197.2
  IN1 w0.122: v2(85.42,80.7) 84.92,80.19 74.95,80.19 72.68,77.92 65.02,77.92 63.48,76.38 50.95,76.38 46.77,72.2 43.64,72.2 v2(42.72,73.12)
  IN2 w0.122: v2(42.17,59.81) 41.64,60.33 41.64,63.29 42.09,63.74 42.09,72.49 v2(42.72,73.12)
  BOTTOM w0.112: v2(87.58,59.44) 87.08,59.93 87.08,72.84 85.42,74.5 v2(85.42,80.7)
SMB_M2D_ALERT_LVC_N_R: length 4.8
  TOP w0.112: R4197.1 R4207.1 90.09,59.49 v1(90.85,60.24) 91.09,60.48 U104.2
SMB_M2D_ALERT_N: length 82.3
  TOP w0.112: U104.1 95.31,61.13 96.22,60.22 v2(97.08,60.22) ; J36.A44 102.18,124.52 101.85,124.19 101.85,122.66 v2(100.86,121.67) ; v2(102.55,107.81) 102.55,107.81 102.55,107.81 102.79,108.05 R4318.2
  IN1 w0.122: 102.55,107.81 102.55,107.94 102,108.49 102,113.6 102.38,114.52 102.38,119.38 100.86,120.9 v2(100.86,121.67) ; 102.55,107.81 102.55,107.81 103.15,107.22 103.15,92.83 100.54,90.22 v2(95.1,90.22) ; 102.55,107.81 v2(102.55,107.81)
  BOTTOM w0.112: v2(97.08,60.22) 96.98,60.32 96.98,61.33 99.5,63.85 99.5,80.82 95.1,85.22 v2(95.1,90.22)
SMB_M2D_INA231_ALRT_N: length 135.9
  TOP w0.112: U86.B4 44.45,41.76 v6(44.61,41.91) ; R4019.2 106.15,109.44 105.82,109.77 v1(105.68,109.77) 103.28,107.37 102.32,107.37 101.88,107.8 100.48,107.8 100.05,107.37 99.64,107.37 v2(98.4,106.13)
  IN1 w0.122: v2(98.4,106.13) 98.95,106.13 99.52,105.56 99.52,97.35 96.13,93.96 93.69,93.96 v2(90.87,91.14)
  IN2 w0.122: v2(58.54,34.99) 63.35,39.81 72.07,39.81 87.47,55.21 93.01,55.21 v2(97.11,59.3)
  BOTTOM w0.112: v6(44.61,41.91) 44.61,40.57 45.61,39.58 46.56,39.58 46.74,39.76 47.97,39.76 50.51,37.22 50.51,35.57 51.28,34.79 58.43,34.79 58.54,34.89 v2(58.54,34.99) ; v2(90.87,91.14) 90.87,88.3 98.72,80.46 98.72,64.45 97.92,63.65 97.72,63.65 96.59,62.51 96.59,59.82 v2(97.11,59.3)
SMB_M2D_INA231_ALRT_N_R: length 10.1
  TOP w0.112: R4019.1 R3902.1 108.03,108.15 108.31,107.87 108.99,107.87 109.8,108.68 v1(109.8,111.28) 110.1,111.28 111.83,113.01 U76.A3
SMB_M2D_INA231_CLK_R1: length 6.4
  TOP w0.112: R3642.1 111.87,109.92 112.54,110.59 v1(112.54,111.03) 112.61,111.1 112.61,114.42 112.17,114.86 U76.A1
SMB_M2D_INA231_DAT_R1: length 6.1
  TOP w0.112: U76.A2 111.9,114.46 111.91,114.45 111.99,114.45 112.22,114.22 112.22,112.33 v1(111.18,111.3) 110.64,110.75 R3643.1
SMB_M2D_P1V8_CLK: length 33.3
  TOP w0.112: v2(100.97,123.32) 100.97,124.53 101.18,124.75 101.18,125.97 J36.A40 ; v2(102.7,106.39) v1(105.11,106.39) 108.64,106.39 110.32,108.07 111.45,108.07 R3642.2
  IN1 w0.122: v2(100.97,123.32) 101.15,123.14 101.15,122.42 100.85,122.12 100.69,122.12 100.42,121.86 100.42,120.73 101.95,119.21 101.95,114.61 101.57,113.71 101.57,108.15 102.62,107.11 102.62,106.47 v2(102.7,106.39)
  BOTTOM w0.112: v2(102.7,106.39) 102.7,106.34 102.25,105.89 101.65,105.89 101.27,105.5 R3815.2
SMB_M2D_P1V8_CLK_R2: length 110.1
  TOP w0.112: U89.7 26.9,72.96 25.65,74.21 v1(25.65,74.6) 25.65,75.98 R73.2 25.55,76.62 25.25,76.32 25.25,75.39 v2(24.46,74.6)
  IN1 w0.122: v2(102.71,105.72) 102.71,93 100.47,90.77 94.8,90.77 84.68,80.64 74.78,80.64 72.49,78.35 64.84,78.35 63.3,76.81 50.77,76.81 46.6,72.64 44.24,72.64 43.2,73.69 40.23,73.69 39.57,73.02 26.9,73.02 26.24,73.69 25.38,73.69 v2(24.46,74.6)
  BOTTOM w0.112: R3815.1 102.46,105.42 102.71,105.67 v2(102.71,105.72)
SMB_M2D_P1V8_DAT: length 32.1
  TOP w0.112: J36.A42 101.68,124.62 101.41,124.35 101.41,123.07 100.95,122.61 v2(100.71,122.61) ; v2(102,107.02) 102.06,106.97 108.64,106.97 110.15,108.48 R3643.2
  IN1 w0.122: v2(102,107.02) 102,107.04 101.99,107.04 101.14,107.89 101.14,112.15 100.43,112.85 100.43,115.31 101.51,116.39 101.51,119.03 99.95,120.59 99.95,122.17 100.39,122.61 v2(100.71,122.61)
  BOTTOM w0.112: R3816.2 101.17,107.02 v2(102,107.02)
SMB_M2D_P1V8_DAT_R2: length 112.4
  TOP w0.112: U89.6 27.55,73.23 v1(27.07,73.71) 26.85,73.93 26.85,76.03 R74.2 26.95,77.11 25.48,77.11 24.46,76.09 v2(24.46,75.49)
  IN1 w0.122: v2(24.46,75.49) 25.68,74.27 26.44,74.27 27.25,73.46 39.19,73.46 39.85,74.11 43.63,74.11 44.65,73.09 46.44,73.09 50.59,77.24 63.12,77.24 64.66,78.78 72.01,78.78 74.31,81.08 84.5,81.08 94.7,91.27 100.38,91.27 102.15,93.04 102.15,106.25 v2(102.05,106.35)
  BOTTOM w0.112: v2(102.05,106.35) 100.43,106.35 100.23,106.55 R3816.1
SMB_M2E_ALERT_LVC_N: length 91.6
  TOP w0.089: U86.V11 40.95,50.32 40.55,50.73 v2(40.45,50.73)
  TOP w0.112: v2(86.51,59.41) 87.55,58.37 R4199.2
  IN2 w0.122: v2(40.45,50.73) 40.45,53.05 40.62,53.22 40.62,56.54 40.75,56.67 40.75,59.44 40.35,59.84 40.24,59.84 39.69,60.4 39.69,63.16 40.99,64.46 40.99,70.27 40.34,70.92 v2(40.34,71.32)
  BOTTOM w0.112: v2(86.51,59.41) 86.68,59.58 86.68,67.24 85.93,67.99 82.16,67.99 80.58,69.57 80.58,73.44 74.12,79.9 64.28,79.9 61.77,77.39 54.72,77.39 53.47,76.14 50.64,76.14 46.7,72.19 43.85,72.19 43.31,71.65 40.67,71.65 v2(40.34,71.32)
SMB_M2E_ALERT_LVC_N_R: length 4.9
  TOP w0.112: U104.4 92,59.18 v1(91,58.18) 90.14,57.33 R4208.1 R4199.1
SMB_M2E_ALERT_N: length 92.4
  TOP w0.112: v2(129.24,110.69) 128.63,111.29 128.14,111.29 R4319.2 ; U104.3 95.89,59.83 v2(96.34,59.38) ; v2(127.65,122.22) 127.65,122.34 126.18,123.81 126.18,125.97 J38.B44
  IN1 w0.122: v2(97.02,75.32) 104.1,75.32 130.08,101.3 130.08,104.17 129.97,104.42 129.97,104.9 129.63,105.74 129.63,108.47 129.24,110.44 v2(129.24,110.69) 128.84,111.09 128.84,112.77 129.39,113.32 129.39,113.95 129.12,114.62 128.61,115.12 128.61,119.89 v2(127.65,122.22)
  BOTTOM w0.112: v2(97.02,75.32) 96.2,74.5 96.2,59.53 v2(96.34,59.38)
SMB_M2E_INA231_ALRT_N: length 176.6
  TOP w0.112: v2(130.8,109.84) 131.25,109.39 R4020.2 ; U86.A4 44.45,40.76 45.66,39.56 47.23,39.56 47.77,39.33 v2(48,39.11) ; v2(83.22,23.39) 82.81,23.81 82.81,29.55 85.2,31.95 93.9,31.95 94.69,32.74 98.13,32.74 99.52,34.12 104.34,34.12 104.98,34.77 107.05,34.77 v2(107.27,34.55)
  IN1 w0.122: v2(130.8,109.84) 130.8,109.46 130.96,108.67 130.96,106.51 v2(131.01,106.45)
  BOTTOM w0.112: v2(107.27,34.55) 106.83,34.55 105.57,35.82 105.57,41.33 106.08,41.84 106.08,46.13 131.01,71.06 v2(131.01,106.45) ; v2(48,39.11) 49.81,37.3 v3(49.81,36.67) 49.81,35.69 51.33,34.17 60.81,34.17 61,33.98 61,30.73 60.27,30 60.27,25.55 61.58,24.24 67.81,24.24 70.34,21.71 72.73,21.71 75.54,24.52 79.83,24.52 81.27,23.08 82.91,23.08 v2(83.22,23.39)
SMB_M2E_INA231_ALRT_N_R: length 6.4
  TOP w0.112: R4020.1 132.99,109.39 R3887.1 133.63,110.57 v1(134.45,111.39) 134.45,111.59 135.73,112.87 U77.A3
SMB_M2E_INA231_CLK_R1: length 6.9
  TOP w0.112: U77.A1 136.23,114.99 136.53,114.69 136.53,113.99 136.7,113.82 137.82,113.82 138.08,113.56 v1(138.08,111.45) 138.08,110.69 R3649.1
SMB_M2E_INA231_DAT_R1: length 4.8
  TOP w0.112: U77.A2 135.89,114.59 136.12,114.36 136.12,111.68 v1(136.38,111.43) 136.38,110.87 136.53,110.72 R3650.1
SMB_M2E_P1V8_CLK: length 28.8
  TOP w0.112: J38.B40 125.18,123.31 v2(126.98,121.5) ; R3649.2 136.12,107.93 133.58,107.93 132.64,107.54 130.62,107.54 v1(130.17,107.99) 129.04,107.99 R3826.2 128.91,108.12 128.91,108.79 128.77,109.13 128.4,109.49 v2(128.31,109.49)
  IN1 w0.122: v2(128.31,109.49) 128.22,109.49 127.95,109.76 127.72,110.33 127.72,119.72 v2(126.98,121.5)
SMB_M2E_P1V8_CLK_R2: length 138
  TOP w0.112: U90.5 35.52,73.14 35.33,73.32 v1(35.33,74.6) 35.33,76.04 R75.2 36.89,77.59 36.89,79.03 37.71,79.85 38.52,79.85 40.21,78.15 40.21,73.81 v2(40.8,73.23) ; v2(128.42,108.77) 128.17,108.52 R3826.1
  IN1 w0.122: v2(83.37,68.52) 84.33,69.47 89.6,69.47 97.15,77.02 104.6,77.02 129.23,101.65 129.23,103.98 129.12,104.24 129.12,104.73 128.77,105.57 128.77,107.15 128.47,108.68 v2(128.42,108.77)
  BOTTOM w0.112: v2(83.37,68.52) 83.37,71.75 74.44,80.68 63.96,80.68 61.45,78.18 54.4,78.18 53.14,76.92 50.32,76.92 50.09,76.69 46.37,72.98 43.3,72.98 42.93,72.61 41.42,72.61 v2(40.8,73.23)
SMB_M2E_P1V8_DAT: length 26.8
  TOP w0.112: v2(127,122.34) 125.68,123.67 J38.B42 ; R3650.2 136.53,108.91 135.98,108.37 135.31,108.37 135.11,108.56 v1(134.89,108.56) 134.4,108.56 134.21,108.37 133.47,108.37 132.78,108.08 130.97,108.08 129.72,109.33 129.72,109.48 129.65,109.65 R3827.2 129.18,110.02 v2(128.36,110.84)
  IN1 w0.122: v2(128.36,110.84) 128.36,112.9 128.88,113.42 128.88,113.81 128.62,114.42 128.18,114.86 128.18,119.79 127.33,121.85 127,122.17 v2(127,122.34)
SMB_M2E_P1V8_DAT_R2: length 140.6
  TOP w0.112: v2(128.36,110.16) 128.36,110.1 129.23,109.22 R3827.1 ; v2(40.25,72.66) 39.77,73.14 39.77,78.04 38.36,79.46 37.89,79.46 37.34,78.91 37.34,76.9 R76.2 36.45,76.01 36.45,73.86 v1(36.29,73.69) 36.17,73.57 U90.4
  IN1 w0.122: v2(82.36,68.52) 82.8,68.08 84.18,68.08 85.15,69.04 89.78,69.04 96.58,75.84 104.02,75.84 129.65,101.47 129.65,104.07 129.55,104.32 129.55,104.82 129.2,105.66 129.2,108.25 128.94,109.58 v2(128.36,110.16)
  BOTTOM w0.112: v2(40.25,72.66) 40.69,72.22 43.09,72.22 43.46,72.58 46.53,72.58 50.48,76.53 53.31,76.53 54.56,77.78 61.61,77.78 64.12,80.29 74.28,80.29 82.36,72.21 v2(82.36,68.52)
SMB_M2EF_3V3SB_CLK: length 5
  TOP w0.112: R3775.1 35.76,58.25 v1(37.54,60.02) 37.62,60.11 R3830.1
SMB_M2EF_3V3SB_CLK_R1: length 4.5
  TOP w0.112: R3830.2 37.62,63.95 v1(37.05,64.53) 36.82,64.76 U90.14
SMB_M2EF_3V3SB_CLK_R2: length 8.5
  TOP w0.112: R3775.2 R3794.2 35.45,54.96 35.22,54.73 35.22,53.25 38.13,50.35 38.13,49.77 U86.V16
SMB_M2EF_3V3SB_DAT: length 5.3
  TOP w0.112: R3776.1 36.45,57.4 36.45,58.05 v1(37.18,58.77) 38.64,60.23 R3831.1
SMB_M2EF_3V3SB_DAT_R1: length 4.7
  TOP w0.112: R3831.2 v1(38.64,63.2) 38.64,63.8 37.47,64.97 U90.15
SMB_M2EF_3V3SB_DAT_R2: length 7.5
  TOP w0.112: U86.W16 38.45,50.72 36.33,52.85 36.33,54.7 36.59,54.96 R3795.2 R3776.2
SMB_M2F_ALERT_LVC_N: length 69
  TOP w0.112: U86.T12 40.45,48.15 v5(40.9,47.7) ; v2(84.2,54.79) 88.45,54.79 R4203.2
  IN1 w0.122: v2(84.2,54.79) 82,54.79 79.16,51.95 78.31,51.95 72.71,46.35 69.78,46.35 69.46,46.67 63.89,46.67 v2(63.83,46.73) ; v2(63.75,41.49) 62.28,42.95 59.81,42.95 58.44,44.32 56.46,44.32 56.16,44.62 54.25,44.62 54.11,44.76 51.68,44.76 51.54,44.62 48.31,44.62 46.09,46.84 46.09,48.1 44.82,49.37 40.85,49.37 40.55,49.06 40.55,48.06 v5(40.9,47.7)
  BOTTOM w0.112: v2(63.75,41.49) 63.71,41.53 63.71,42 63.94,42.23 66.23,42.23 66.98,42.98 66.98,45.34 65.58,46.73 v2(63.83,46.73)
SMB_M2F_ALERT_LVC_N_R: length 5.3
  TOP w0.112: U104.6 91.69,57.88 90.86,57.05 v1(90.86,56.36) 90.78,56.29 R4209.1 R4203.1
SMB_M2F_ALERT_N: length 119.2
  TOP w0.112: R4320.2 160.49,128.54 v2(160.47,128.54) ; v2(101.5,60.5) 100.47,61.53 98.6,62.31 97.82,62.31 97.03,61.52 97.03,60.94 97.67,60.3 97.67,58.63 96.57,57.54 94.42,57.54 93.42,58.53 U104.5 ; v2(150.85,122.21) 150.73,122.21 150.63,122.31 150.63,124.48 150.18,124.93 150.18,125.97 J38.A44
  IN1 w0.122: v2(150.85,122.21) 150.85,121.8 151.49,121.16 151.82,120.35 151.82,118.71 152.13,118.41 152.13,117.19 151.69,116.76 151.69,111.04 152.4,109.33 152.4,107.6 150.65,105.85 150.65,104.49 109.29,63.13 104.13,63.13 v2(101.5,60.5)
  IN2 w0.122: v2(150.85,122.21) 150.97,122.21 151.5,122.74 154.36,122.74 158.29,126.67 159.43,126.67 160.47,127.71 v2(160.47,128.54)
SMB_M2F_INA231_ALRT_N: length 206.2
  TOP w0.089: U86.W12 40.37,49.94 40.12,50.19 40,50.24 39.85,50.24 39.73,50.37
  TOP w0.112: v2(39.04,50.93) 39.6,50.37 39.73,50.37 ; v2(158.2,112.57) 158.6,112.57 159.3,113.27 161.65,114.24 162.54,115.13 162.54,115.41 163.87,116.73 163.87,118.11 164.65,118.89 164.65,120.61 167.17,123.13 167.17,125.89 165.4,127.67 165.4,129.1 165.18,129.31 163.55,129.31 163.4,129.17 R4021.2
  IN1 w0.122: v2(158.2,112.57) 158.2,112.44 158.82,111.81 158.82,108.4 157.49,107.06 157.1,106.8 156.53,106.56 154.62,104.65 154.62,103.41 148.35,97.13 148.35,94.75 148.22,94.62 148.13,94.62 112.62,59.12 111.54,59.12 94.46,52.05 89.1,52.05 88.41,51.36 84.81,51.36 81.69,48.24 80.57,48.24 71.57,39.23 v2(69.12,39.23)
  IN2 w0.122: v2(40.8,32.61) 40.8,33.6 40.51,33.9 40.51,35.63 34.72,41.42 34.72,43.26 35.2,43.73 36.06,43.73 36.43,44.1 36.43,45.68 37.31,46.57 37.31,48.42 39.04,50.15 v2(39.04,50.93) ; v2(42.93,31.02) 44.3,29.65 50.81,29.65 54.69,33.53 56.46,33.53 59.35,34.73 63.85,39.23 v2(69.12,39.23)
  BOTTOM w0.112: v2(40.8,32.61) 41.69,31.72 42.23,31.72 v2(42.93,31.02)
SMB_M2F_INA231_ALRT_N_R: length 8.5
  TOP w0.112: R4021.1 164.2,126.98 164.41,126.77 164.41,125.81 164.71,125.52 R3888.1 165.55,124.99 v1(165.55,124.29) 163.65,122.39 U78.A3
SMB_M2F_INA231_CLK_R1: length 4.5
  TOP w0.112: U78.A1 162.85,123.48 162.68,123.64 v1(162.68,124.14) 163.12,124.57 163.12,125.31 R3656.1
SMB_M2F_INA231_DAT_R1: length 4.5
  TOP w0.112: R3657.1 163.93,125.13 164.09,124.97 v1(164.09,124.14) 164.09,123.56 163.25,122.72 U78.A2
SMB_M2F_P1V8_CLK: length 25.1
  TOP w0.112: v2(150.14,121.59) 149.69,122.04 149.69,124.28 149.18,124.79 J38.A40 ; v2(158.81,125.45) 159.58,125.45 160.02,125.9 160.02,126.3 161.16,127.44 161.78,127.44 R3656.2
  IN2 w0.122: v2(150.14,121.59) 150.67,121.06 154.17,121.06 155.01,121.91 155.18,121.91 155.85,121.23 156.03,121.23 156.48,121.69 156.48,121.86 155.81,122.53 155.81,122.7 158.59,125.49 158.77,125.49 v2(158.81,125.45)
  BOTTOM w0.112: v2(150.14,121.59) 150.14,121.39 150.04,121.29 149.95,121.29 149.27,120.61 R3828.2
SMB_M2F_P1V8_CLK_R2: length 199.9
  TOP w0.112: v2(33.61,79.27) R77.2 33.07,76.06 33.07,74.65 v1(33.25,74.47) 33.25,73.79 34.22,72.82 U90.7
  IN1 w0.122: v2(32.7,51.49) 38.04,51.49 38.71,52.15 41.05,52.15 41.46,52.57 45.83,52.57 46.84,52.15 48.18,50.81 48.18,50.09 49.82,48.45 55.63,48.45 55.97,48.1 66.49,48.1 66.63,47.96 73.12,47.96 81.07,55.92 91.02,55.92 92.12,57.02 96.57,57.02 96.85,57.14 103.7,63.99 108.94,63.99 149.73,104.78 149.73,106.15 151.54,107.96 151.54,108.95 150.64,111.13 150.64,120.41 v2(150.18,120.88)
  IN2 w0.122: v2(32.7,51.49) 32.7,54.47 34.17,55.94 34.17,59.26 35.13,60.22 35.13,65.82 35.28,65.97 35.28,73.72 34.11,74.89 34.11,75.86 33.61,76.37 v2(33.61,79.27)
  BOTTOM w0.112: v2(150.18,120.88) 150.18,120.58 149.41,119.81 R3828.1
SMB_M2F_P1V8_DAT: length 26.2
  TOP w0.112: v2(150.16,122.31) 150.16,124.38 149.68,124.87 149.68,125.97 J38.A42 ; R3657.2 163.6,126.66 163.6,127.37 163.29,127.68 162.12,127.68 161.93,127.87 161.01,127.87 159.77,126.63 159.19,126.63 v2(158.61,126.05)
  IN2 w0.122: v2(158.61,126.05) 158.5,126.05 153.98,121.53 150.88,121.53 150.16,122.25 v2(150.16,122.31)
  BOTTOM w0.112: v2(150.16,122.31) 150.1,122.31 149.16,121.36 148.4,121.36 R3829.2 146.9,120.61 v3(146.5,120.21)
SMB_M2F_P1V8_DAT_R2: length 203.9
  TOP w0.112: v2(35.22,79.26) 34.75,78.79 R78.2 34.17,76.01 34.17,73.88 v1(34.35,73.7) 34.87,73.18 U90.6
  IN1 w0.122: v2(32.68,50.59) 34.83,50.59 34.86,50.62 38.46,50.62 38.57,50.51 39.59,50.51 40.31,51.23 41.43,51.23 41.46,51.26 46.53,51.26 47.32,50.47 47.32,50.11 47.32,49.77 49.5,47.59 53.44,47.59 54.43,46.6 54.9,46.6 55.17,46.32 55.9,46.32 56.74,47.17 64.87,47.17 64.95,47.09 69.64,47.09 69.83,46.9 72.66,46.9 81.25,55.49 92.17,55.49 93.24,56.56 93.32,56.6 96.66,56.6 97.09,56.78 103.88,63.56 109.11,63.56 150.19,104.63 150.19,105.99 151.97,107.78 151.97,109.2 151.14,111.22 151.14,119.97 v2(151.3,120.13)
  IN2 w0.122: v2(32.68,50.59) 33.16,51.08 33.16,54.32 34.6,55.76 34.6,58.94 36.11,60.45 36.11,62.66 35.72,63.05 35.72,74.19 35.22,74.69 v2(35.22,79.26)
  BOTTOM w0.112: R3829.1 148.34,119.11 150.28,119.11 v2(151.3,120.13)
SMB_M2G_ALERT_LVC_N: length 78
  TOP w0.112: U86.N18 37.05,46.53 36.69,46.53 36.01,46.67 35.47,46.89 v2(35.41,46.95) ; v2(69.75,42.5) 69.75,42.82 78.66,51.73 78.94,51.73 81.49,54.28 91.7,54.28 R4198.2
  IN1 w0.122: v2(69.75,42.5) 69.75,42.01 66.03,38.28 64.06,38.28 63.93,38.16 57.31,38.16 56.04,36.89 40.06,36.89 39.8,37.15 39.37,37.15 39.2,37.32 v2(37.1,37.32)
  IN2 w0.122: v2(35.41,46.95) 35.41,46.91 33.76,45.26 33.76,41.09 35.97,38.88 35.97,37.97 36.26,37.68 36.74,37.68 v2(37.1,37.32)
SMB_M2G_ALERT_LVC_N_R: length 7.8
  TOP w0.112: R4198.1 R4216.1 94.47,54.71 94.64,54.53 96.19,54.53 96.57,54.92 v1(96.57,55.6) 96.57,56.54 97.26,57.23 U104.8
SMB_M2G_ALERT_N: length 111.2
  TOP w0.112: v2(108.22,58.23) 106.09,56.11 101.3,56.11 99.52,57.88 U104.9
  IN1 w0.122: v2(156.92,131.99) 155.95,131.02 155.95,130.64 155.21,129.9 155.21,126.61 155.61,126.21 155.61,121.92 156.43,119.93 156.43,112.97 158.14,111.27 158.14,108.54 v2(158.1,108.51) 158.1,108.4 156.87,107.17 156.24,106.91 154.11,104.77 154.11,103.5 147.52,96.91 147.52,95.14 113.1,60.73 108.45,58.8 v2(108.22,58.23)
  BOTTOM w0.112: J8.B44 156.92,133.22 v2(156.92,131.99) ; R4321.2 158.11,109.65 158.11,108.51 v2(158.1,108.51)
SMB_M2G_INA231_ALRT_N: length 148.2
  TOP w0.112: v6(38.44,48.94) 38.44,48.94 U86.U15
  IN1 w0.122: v2(154.16,108.1) 154.16,107.51 152.01,105.35 152.01,104.04 109.33,61.37 105.74,59.88 104.06,59.88 101.17,56.99 93.93,53.99 85.44,53.99 84.93,53.49 83.9,53.49 80.53,50.12 79.66,50.12 74.57,45.03 69.19,45.03 68.94,45.28 61.28,45.28 60.75,44.75 56.64,44.75 56.34,45.04 54.43,45.04 54.28,45.19 53.45,45.19 53.23,45.41 51.58,45.41 51.22,45.05 49.22,45.05 49.05,44.88 48.37,44.88 47.57,45.68 47.57,45.87 47.57,46.93 44.91,49.59 39.08,49.59 v6(38.44,48.94)
  BOTTOM w0.112: v3(155.13,108.1) v2(154.16,108.1) 154.16,108.09 153.56,107.49 R4027.2
SMB_M2G_INA231_ALRT_N_R: length 10.4
  BOTTOM w0.112: U84.A3 150.92,115.99 151.37,115.54 v3(151.37,114.09) 151,113.71 151,111.31 R3894.1 R4027.1
SMB_M2G_INA231_CLK_R1: length 4.6
  BOTTOM w0.112: R3721.1 149.23,113.65 v3(148.81,114.07) 150.12,115.38 U84.A1
SMB_M2G_INA231_DAT_R1: length 4.2
  BOTTOM w0.112: U84.A2 150.52,115.01 150.08,114.57 v3(150.08,114.13) 150.08,113.03 R3722.1
SMB_M2G_P1V8_CLK: length 46.8
  IN1 w0.122: v2(158.22,105.27) 158.75,105.79 158.75,106.44 162.21,109.91 162.21,110.92 159.43,113.7 159.43,118.4 158.62,119.21 158.62,120.7 156.92,122.41 156.92,127.28 156.56,127.63 156.56,130.08 v2(157.05,130.57)
  BOTTOM w0.112: v2(157.05,130.57) 157.92,131.44 J8.B40 ; R3721.2 149.23,111.48 151.54,109.17 151.54,106.43 152.12,105.85 154.56,105.85 R3839.2 155.63,105.93 157.64,105.93 158.22,105.36 v2(158.22,105.27)
SMB_M2G_P1V8_CLK_R2: length 182.1
  TOP w0.112: v2(26.62,36.42) 26.74,36.54 26.74,41.65 25.85,42.55 24.11,42.55 22.35,40.79 R3063.2 22.07,39.21 21.77,38.92 v2(21.77,37.34) U91.5
  IN1 w0.122: v2(157.3,105.28) 157.3,103.97 154.41,101.08 154.41,97.97 153.45,97.01 153.03,97.01 151.71,95.68 151.38,95.68 150.91,95.21 150.91,94.81 113.88,57.77 111.77,57.77 94.86,50.77 90.16,50.77 89.35,49.97 85.49,49.97 84.49,48.96 84.49,48.24 82.66,46.42 81.36,46.42 72.58,37.64 69.3,37.64 68.66,37 64.59,37 64.46,36.88 57.84,36.88 55.1,34.14 43.73,34.14 43.55,34.32 39.77,34.32 39.48,34.61 39.48,35.52 39.15,35.85 34.8,35.85 34.09,35.56 33.78,35.24 32.48,35.24 32.25,35.47 29.19,35.47 28.24,36.42 v2(26.62,36.42)
  BOTTOM w0.112: v2(157.3,105.28) 157.22,105.36 R3839.1
SMB_M2G_P1V8_DAT: length 45.5
  IN1 w0.122: v2(156.99,131.32) 157.57,130.74 157.57,130.09 156.99,129.51 156.99,127.82 157.35,127.46 157.35,122.59 159.06,120.87 159.06,119.64 160.98,117.73 160.98,112.76 162.68,111.06 162.68,108.85 160.75,106.93 v2(160.26,106.93)
  BOTTOM w0.112: R3722.2 150.27,111.22 152.11,109.38 152.11,106.73 152.37,106.47 R3840.2 156.77,106.87 156.95,107.05 160.14,107.05 v2(160.26,106.93) ; v2(156.99,131.32) 157.42,131.76 157.42,133.22 J8.B42
SMB_M2G_P1V8_DAT_R2: length 184.8
  TOP w0.112: U91.4 v1(22.42,36.78) 22.42,37.05 22.91,37.54 22.91,38.96 23.16,39.21 R3064.2 23.44,41.31 24.23,42.09 25.73,42.09 26.21,41.62 26.21,36.79 26.19,36.77 26.19,35.15 v2(26.62,34.72)
  IN1 w0.122: v2(26.62,34.72) 26.78,34.56 28.59,34.56 29.43,33.71 32.72,33.71 33.61,32.82 35.04,32.82 35.69,33.48 41.16,33.48 41.25,33.39 43.29,33.39 43.54,33.64 55.2,33.64 58.01,36.45 64.64,36.45 64.77,36.58 68.84,36.58 69.47,37.22 72.76,37.22 81.54,45.99 82.84,45.99 84.92,48.07 84.92,48.79 85.67,49.54 89.53,49.54 90.33,50.34 94.94,50.34 111.85,57.35 114.05,57.35 151.21,94.51 152.51,94.51 152.8,94.79 153.94,94.79 154.85,95.7 154.85,100.92 159.04,105.11 v2(159.04,105.35)
  BOTTOM w0.112: R3840.1 158.49,106.47 159.04,105.92 v2(159.04,105.35)
SMB_M2GH_3V3SB_CLK: length 27.5
  TOP w0.112: R3843.1 26.96,26.67 27.4,27.1 30.93,27.1 v2(31.17,27.34)
  BOTTOM w0.112: R3777.1 47.45,34.44 45.9,32.89 41.8,32.89 41.2,33.48 40.38,33.48 39.77,32.87 39.77,32.2 39.22,31.66 37.84,31.66 33.28,27.09 31.42,27.09 v2(31.17,27.34)
SMB_M2GH_3V3SB_CLK_R1: length 3.6
  TOP w0.112: R3843.2 24.68,26.67 24.27,27.08 24.27,27.55 23.07,28.75 U91.14
SMB_M2GH_3V3SB_CLK_R2: length 10.3
  TOP w0.112: U86.C6 v6(42.95,41.94)
  IN1 w0.122: v6(42.95,41.94) 42.95,39.85 43.02,39.78 43.02,38.79 43.12,38.69 46.05,38.69 v2(46.34,38.98)
  BOTTOM w0.112: R3777.2 R3796.2 v3(46.43,37.99) 46.43,38.88 v2(46.34,38.98)
SMB_M2GH_3V3SB_DAT: length 28.7
  TOP w0.112: v2(47.91,35.16) 48.22,35.47 48.22,35.8 R3778.1 ; R3844.1 27.12,27.68 27.3,27.5 29.56,27.5 v2(29.66,27.6)
  BOTTOM w0.112: v2(47.91,35.16) 47.91,34.09 46.26,32.44 41.69,32.44 41.08,33.05 40.53,33.05 40.19,32.71 40.19,32.05 39.41,31.27 38.01,31.27 33.41,26.67 30.59,26.67 v2(29.66,27.6)
SMB_M2GH_3V3SB_DAT_R1: length 2.3
  TOP w0.112: U91.15 23.72,28.75 24.79,27.68 R3844.2
SMB_M2GH_3V3SB_DAT_R2: length 8.1
  TOP w0.112: R3778.2 R3797.2 47.45,37.11 46.88,37.67 45.83,37.67 44.94,38.56 44.94,39.25 44.2,40 43.9,40 43.34,40.56 43.34,41.33 U86.B6
SMB_M2H_ALERT_LVC_N: length 141.5
  TOP w0.112: v2(38.9,68.77) 38.9,68.8 38.06,67.97 26.07,67.97 25.43,67.33 25.43,65.2 24.37,64.15 24.37,60.53 25.07,59.84 28.23,59.84 29.07,59 30.55,59 31.55,58 31.55,51.04 35.2,47.39 35.77,47.39 36.02,47.14 36.49,46.94 U86.N19 ; v2(104.7,59.44) 104.7,57.85 103.79,56.95 R4200.2
  IN1 w0.122: v2(84.73,66.07) 84.73,65.53 85.37,64.9 90.47,64.9 97.73,72.15 v2(103.58,72.15)
  BOTTOM w0.112: v2(103.58,72.15) 104.7,71.03 v2(104.7,59.44) ; v2(38.9,68.77) 40.54,68.77 41.28,69.51 47.92,69.51 49.76,71.36 49.76,73.61 51.12,74.97 53.95,74.97 55.21,76.22 62.26,76.22 64.57,78.53 73.48,78.53 79.41,72.6 79.41,68.84 81.83,66.42 84.38,66.42 v2(84.73,66.07)
