# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Nets (continued)
GND: C1.2 C6.2 C9.2 C12.2 C15.2 C18.2 C21.2 C24.2 C27.2 C30.2 C33.2 C36.2 C39.2 C44.1 C45.2 C46.2 C49.2 C70.2 C87.2 C89.2 C92.2 C94.2 C97.2 C100.2 C103.2 C104.2 C121.2 C122.2 C123.2 C125.2 C126.2 C128.2 C129.2 C131.2 C132.2 C134.2 C135.2 C137.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.2 C193.2 C197.2 C198.2 C199.2 C200.2 C201.2 C202.2 C203.2 C204.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C225.2 C226.2 C227.2 C228.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C537.2 C538.2 C539.2 C540.2 C541.2 C542.2 C543.2 C545.2 C546.2 C547.2 C548.2 C549.2 C550.2 C551.2 C552.2 C553.2 C554.2 C555.2 C556.2 C557.2 C558.2 C559.2 C560.2 C561.2 C562.2 C563.2 C564.2 C565.2 C566.2 C567.2 C568.2 C569.2 C570.2 C571.2 C572.2 C573.2 C574.2 C575.2 C576.2 C577.2 C578.2 C579.2 C580.2 C581.2 C582.2 C583.2 C584.2 C585.2 C586.2 C587.2 C588.2 C589.2 C590.2 C591.2 C592.2 C593.2 C594.2 C595.2 C596.2 C597.2 C598.2 C599.2 C600.2 C601.2 C602.2 C603.2 C604.2 C605.2 C606.2 C607.2 C609.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C617.2 C618.2 C619.2 C620.2 C621.2 C622.2 C623.2 C624.2 C625.2 C626.2 C627.2 C628.2 C629.2 C630.2 C631.2 C632.2 C633.2 C634.2 C635.2 C636.2 C637.2 C638.2 C639.2 C640.2 C641.2 C642.2 C643.2 C644.2 C645.2 C646.2 C647.2 C648.2 C649.2 C650.2 C651.2 C652.2 C653.2 C654.2 C655.2 C656.2 C657.2 C658.2 C659.2 C660.2 C661.2 C662.2 C663.2 C664.2 C665.2 C666.2 C667.2 C668.2 C669.2 C670.2 C671.2 C672.2 C673.2 C674.2 C675.2 C676.2 C677.2 C678.2 C679.2 C680.2 C681.2 C682.2 C683.2 C684.2 C685.2 C686.2 C687.2 C688.2 C689.2 C690.2 C691.2 C692.2 C693.2 C694.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C728.2 C729.2 C730.2 C732.2 C733.2 C734.2 C749.2 C750.2 C751.2 C752.2 C759.2 C760.2 C761.2 C762.2 C765.2 C769.2 C770.2 C771.2 C772.2 C773.2 C774.2 C775.2 C776.2 C806.2 C948.2 C949.2 C950.2 C951.2 C952.1 C953.1 C954.2 C955.2 C959.2 C960.2 C961.2 C964.2 C965.2 C966.2 C967.2 C968.2 C969.2 C972.2 C973.2 C974.2 C975.1 C1074.1 C1075.1 C1078.2 C1079.2 C1082.2 C1083.2 C1085.2 C1087.2 C1089.2 C1091.2 C1093.2 C1095.2 C1097.2 C1099.2 C1101.2 C1103.2 C1105.2 C1107.2 C1111.2 C1112.2 C1113.2 C1114.2 C1115.2 C1116.2 C1117.2 C1118.2 C1119.2 C1120.2 C1121.2 C1122.2 C1123.2 C1124.2 C1125.2 C1126.2 C1127.2 C1128.2 C1129.2 C1130.2 C1131.2 C1132.2 C1133.2 C1134.2 C1135.2 C1136.2 C1137.2 C1138.2 C1139.2 C1140.2 C1141.2 C1142.2 C1143.2 C1144.2 C1145.2 C1146.2 C1147.2 C1148.2 C1149.2 C1151.2 C1152.2 C1153.2 C1154.2 C1155.2 C1156.2 C1157.2 C1158.2 C1159.2 C1160.2 C1161.2 C1162.2 C1163.2 C1164.2 C1165.2 C1166.2 C1167.2 C1168.2 C1169.2 C1170.2 C1171.2 C1172.2 C1173.2 C1174.2 C1175.2 C1176.2 C1177.2 C1178.2 C1179.2 C1180.2 C1181.2 C1182.2 C1183.2 C1184.2 C1185.2 C1186.2 C1187.2 C1189.2 C1191.2 C1192.2 C1193.2 C1194.2 C1195.2 C1196.2 C1197.2 C1198.2 C1199.2 C1200.2 C1201.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.2 C1209.2 C1210.2 C1211.2 C1212.2 C1213.2 C1214.2 C1215.2 C1216.2 C1217.2 C1218.2 C1219.1 C1220.2 C1221.1 C1222.2 C1223.2 C1224.1 C1225.2 C1226.2 C1227.2 C1228.2 C1229.2 C1230.2 C1231.2 C1232.1 C1233.2 C1234.2 C1235.2 C1236.2 C1237.2 C1238.2 C1239.2 C1240.2 C1241.2 C1242.2 C1243.2 C1244.2 C1245.2 C1246.2 C1247.2 C1248.2 C1249.2 C1250.2 C1251.2 C1252.2 D1.2 D4.4(GND) H3.2(GND2) H3.3(GND3) H3.4(GND4) H3.5(GND5) H3.6(GND6) H3.7(GND7) H3.8(GND8) H3.9(GND9) H4.2(GND2) H4.3(GND3) H4.4(GND4) H4.5(GND5) H4.6(GND6) H4.7(GND7) H4.8(GND8) H4.9(GND9) H5.2(GND2) H5.3(GND3) H5.4(GND4) H5.5(GND5) H5.6(GND6) H5.7(GND7) H5.8(GND8) H5.9(GND9) H6.2(GND2) H6.3(GND3) H6.4(GND4) H6.5(GND5) H6.6(GND6) H6.7(GND7) H6.8(GND8) H6.9(GND9) H31.2(GND2) H31.3(GND3) H31.4(GND4) H31.5(GND5) H31.6(GND6) H31.7(GND7) H31.8(GND8) H31.9(GND9) H32.1(GND) H33.1(GND) H34.1(GND) H35.1(GND) H36.1(GND) J4.A1(GND3) J4.A3(GND4) J4.A9(GND5) J4.A15(GND6) J4.A21(GND7) J4.A27(GND8) J4.A32(GND1) J4.A33(GND9) J4.A38(GND2) J4.A39(GND10) J4.A45(GND11) J4.A51(GND12) J4.A57(GND13) J4.A71(GND14) J4.A75(GND15) J4.B1(GND18) J4.B3(GND19) J4.B9(GND20) J4.B15(GND21) J4.B21(GND22) J4.B27(GND23) J4.B32(NC10) J4.B33(GND24) J4.B38(NC13) J4.B39(GND25) J4.B45(GND26) J4.B51(GND27) J4.B57(GND28) J4.B71(GND29) J4.B75(GND31) J4.G1 J4.G2 J4.G3 J4.G4 J6.A1(GND3) J6.A3(GND4) J6.A9(GND5) J6.A15(GND6) J6.A21(GND7) J6.A27(GND8) J6.A32(GND1) J6.A33(GND9) J6.A38(GND2) J6.A39(GND10) J6.A45(GND11) J6.A51(GND12) J6.A57(GND13) J6.A71(GND14) J6.A75(GND15) J6.B1(GND18) J6.B3(GND19) J6.B9(GND20) J6.B15(GND21) J6.B21(GND22) J6.B27(GND23) J6.B32(NC10) J6.B33(GND24) J6.B38(NC13) J6.B39(GND25) J6.B45(GND26) J6.B51(GND27) J6.B57(GND28) J6.B71(GND29) J6.B75(GND31) J6.G1 J6.G2 J6.G3 J6.G4 J8.A1(GND3) J8.A3(GND4) J8.A9(GND5) J8.A15(GND6) J8.A21(GND7) J8.A27(GND8) J8.A32(GND1) J8.A33(GND9) J8.A38(GND2) J8.A39(GND10) J8.A45(GND11) J8.A51(GND12) J8.A57(GND13) J8.A71(GND14) J8.A75(GND15) J8.B1(GND18) J8.B3(GND19) J8.B9(GND20) J8.B15(GND21) J8.B21(GND22) J8.B27(GND23) J8.B32(NC10) J8.B33(GND24) J8.B38(NC13) J8.B39(GND25) J8.B45(GND26) J8.B51(GND27) J8.B57(GND28) J8.B71(GND29) J8.B75(GND31) J8.G1 J8.G2 J8.G3 J8.G4 J34.A1(GND3) J34.A3(GND4) J34.A9(GND5) J34.A15(GND6) J34.A21(GND7) J34.A27(GND8) J34.A32(GND1) J34.A33(GND9) J34.A38(GND2) J34.A39(GND10) J34.A45(GND11) J34.A51(GND12) J34.A57(GND13) J34.A71(GND14) J34.A75(GND15) J34.B1(GND18) J34.B3(GND19) J34.B9(GND20) J34.B15(GND21) J34.B21(GND22) J34.B27(GND23) J34.B32(NC10) J34.B33(GND24) J34.B38(NC13) J34.B39(GND25) J34.B45(GND26) J34.B51(GND27) J34.B57(GND28) J34.B71(GND29) J34.B75(GND31) J34.G1 J34.G2 J34.G3 J34.G4 J36.A1(GND3) J36.A3(GND4) J36.A9(GND5) J36.A15(GND6) J36.A21(GND7) J36.A27(GND8) J36.A32(GND1) J36.A33(GND9) J36.A38(GND2) J36.A39(GND10) J36.A45(GND11) J36.A51(GND12) J36.A57(GND13) J36.A71(GND14) J36.A75(GND15) J36.B1(GND18) J36.B3(GND19) J36.B9(GND20) J36.B15(GND21) J36.B21(GND22) J36.B27(GND23) J36.B32(NC10) J36.B33(GND24) J36.B38(NC13) J36.B39(GND25) J36.B45(GND26) J36.B51(GND27) J36.B57(GND28) J36.B71(GND29) J36.B75(GND31) J36.G1 J36.G2 J36.G3 J36.G4 J38.A1(GND3) J38.A3(GND4) J38.A9(GND5) J38.A15(GND6) J38.A21(GND7) J38.A27(GND8) J38.A32(GND1) J38.A33(GND9) J38.A38(GND2) J38.A39(GND10) J38.A45(GND11) J38.A51(GND12) J38.A57(GND13) J38.A71(GND14) J38.A75(GND15) J38.B1(GND18) J38.B3(GND19) J38.B9(GND20) J38.B15(GND21) J38.B21(GND22) J38.B27(GND23) J38.B32(NC10) J38.B33(GND24) J38.B38(NC13) J38.B39(GND25) J38.B45(GND26) J38.B51(GND27) J38.B57(GND28) J38.B71(GND29) J38.B75(GND31) J38.G1 J38.G2 J38.G3 J38.G4 J41.21 J41.22 J41.23 J41.24 J41.25 J41.26 J41.27 J41.29 J41.31 J41.36 J41.38 J41.39 J41.41 J41.44 J41.46 J41.47 J41.49 J41.52 J41.54 J41.55 J41.57 J41.60 J41.62 J41.63 J41.65 J41.68 J41.70 J41.71 J41.73 J41.76 J41.78 J41.79 J41.81 J41.84 J41.86 J41.87 J41.89 J41.92 J41.94 J41.95 J41.97 J41.100 J41.102 J41.103 J41.105 J41.108 J41.110 J41.111 J41.113 J41.116 J41.118 J41.119 J46.2 J47.8 J47.G1 J47.G2 J49.15 J49.16 J49.17 J49.18 J49.19 J49.20 J49.21 J49.22 J49.23 J49.24 J49.26 J49.28 J49.29 J49.32 J49.34 J49.35 J49.37 J49.40 J49.42 J49.43 J49.45 J49.48 J49.50 J49.51 J49.53 J49.56 J49.58 J49.59 J49.61 J49.64 J49.66 J49.67 J49.69 J49.72 J49.74 J49.75 J49.77 J49.80 J49.82 J49.83 J49.85 J49.88 J49.90 J49.91 J49.93 J49.96 J49.98 J49.99 J49.101 J49.104 J49.106 J49.107 J49.109 J49.112 J49.114 J49.115 J49.117 J49.120 J49.122 J49.123 J49.125 J49.128 J49.130 J49.131 J49.133 J49.136 J49.138 J49.139 J49.141 J49.144 J49.146 J49.147 J49.149 J49.152 J49.154 J49.155 J49.157 J49.160 J55.5(GND) J55.G1 J55.G2 J55.G3 J55.G4 J55.G5 J56.G1 J56.G2 J58.7 J58.G1 J58.G2 J59.1 J60.5(GND) J60.G1 J60.G2 J60.G3 OSC1.2(GND) PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC110.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC201.2 PC202.2 PC203.2 PC204.2 PC205.2 PC206.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC301.2 PC302.2 PC304.2 PC305.2 PC306.2 PC307.2 PC310.2 PC311.2 PC312.2 PC313.2 PC314.2 PC315.2 PC316.2 PC317.2 PC318.2 PC319.2 PC320.2 PC321.2 PC322.2 PC601.2 PC602.2 PC603.2 PC604.2 PC605.2 PC606.2 PC610.2 PC611.2 PC612.2 PC615.2 PC701.2 PC702.2 PC703.2 PC704.2 PR101.1 PR105.1 PR122.1 PR127.1 PR128.1 PR201.1 PR202.1 PR208.1 PR301.1 PR305.1 PR321.1 PR601.1 PR602.1 PU7.1(GND) PU101.4(PGND1) PU101.14(PGND2) PU101.15(PGND3) PU101.23(AGND) PU201.4(PGND1) PU201.14(PGND2) PU201.15(PGND3) PU201.21(VOSNS-) PU201.23(AGND) PU301.4(PGND1) PU301.14(PGND2) PU301.15(PGND3) PU301.17(PS#) PU301.21(VOSNS-) PU301.23(AGND) PU601.4(PGND1) PU601.14(PGND2) PU601.15(PGND3) PU601.21(VOSNS-) PU601.23(AGND) Q9.1(S1) Q9.4(S2) Q10.1(S1) Q10.4(S2) Q10.5(G2) Q24.1(S1) Q24.4(S2) Q24.5(G2) Q36.S(SOURCE) Q45.S Q49.S Q51.S Q52.S(SOURCE) Q53.S(SOURCE) R3.2 R4.2 R15.1 R17.2 R18.2 R20.1 R22.1 R91.2 R92.2 R93.2 R94.2 R95.2 R96.2 R2847.2 R2849.2 R2850.2 R2851.2 R2852.2 R2853.2 R2854.2 R2910.2 R2918.2 R2919.2 R2920.2 R2921.2 R2922.2 R2924.2 R2936.2 R2937.2 R2938.2 R2939.2 R2940.2 R2941.2 R2960.1 R2964.2 R2966.2 R2969.2 R2971.2 R3004.1 R3005.1 R3048.2 R3049.1 R3052.2 R3102.2 R3104.2 R3121.2 R3124.2 R3129.2 R3130.2 R3131.2 R3132.2 R3149.1 R3150.1 R3151.1 R3152.1 R3153.1 R3154.1 R3155.1 R3156.1 R3157.1 R3158.1 R3159.1 R3160.1 R3218.2 R3220.2 R3231.2 R3233.2 R3235.2 R3237.2 R3240.2 R3256.1 R3257.1 R3265.2 R3281.1 R3282.1 R3433.2 R3434.2 R3435.2 R3577.2 R3578.2 R3579.2 R3580.2 R3581.2 R3582.2 R3583.2 R3584.2 R3585.2 R3586.2 R3587.2 R3588.2 R3589.2 R3590.2 R3591.2 R3592.2 R3593.2 R3594.2 R3595.2 R3596.2 R3597.2 R3598.2 R3599.2 R3600.2 R3803.2 R3806.2 R3807.2 R3819.2 R3820.2 R3832.2 R3833.2 R3845.2 R3846.2 R3858.2 R3859.2 R3871.2 R3872.2 R3904.2 R3905.2 R3910.2 R3916.2 R4075.2 R4076.2 R4100.2 R4101.2 R4104.2 R4105.2 R4108.2 R4109.2 R4112.2 R4113.2 R4116.2 R4117.2 R4120.2 R4121.2 R4124.2 R4125.2 R4128.2 R4129.2 R4132.2 R4133.2 R4136.2 R4137.2 R4140.2 R4141.2 R4144.2 R4145.2 R4158.1 R4161.1 R4162.1 R4218.1 R4226.1 R4233.2 R4235.1 R4237.1 R4239.1 R4241.1 R4243.1 R4245.1 R4247.1 R4249.1 R4251.1 R4253.1 R4255.1 R4257.1 R4275.1 R4276.1 R4277.1 R4278.1 R4279.1 R4280.1 R4281.1 R4282.1 R4283.1 R4284.1 R4285.1 R4286.1 R4287.2 R4338.2 R4339.2 R4340.2 R4369.2 R4370.2 R4388.2 R4389.2 R4390.2 R4391.2 R4392.2 R4393.2 R4394.2 R4395.2 R4396.2 R4397.2 R4398.2 R4399.2 SW4.1 SW4.2 SW4.3 SW5.C SW6.2 SW6.3 SW6.4 TP66.1 U2.10(GND) U2.TH U6.4(VSS) U7.4(GND) U8.4(GND) U19.6(VSS) U20.6(VSS) U21.6(VSS) U22.6(VSS) U23.6(VSS) U24.6(VSS) U25.7(GND) U26.7(GND) U28.6(VSS) U29.6(VSS) U30.6(VSS) U31.6(VSS) U32.6(VSS) U33.6(VSS) U34.A2(VSS_A2) U34.A3(VSS_A3) U34.A4(VSS_A4) U34.A5(VSS_A5) U34.A6(VSS_A6) U34.A7(VSS_A7) U34.A16(VSS_A16) U34.A25(VSS_A25) U34.A34(VSS_A34) U34.AA3(VSS_AA3) U34.AA6(VSS_AA6) U34.AA8(VSS_AA8) U34.AA10(VSS_AA10) U34.AA12(VSS_AA12) U34.AA13(VSS_AA13) U34.AA15(VSS_AA15) U34.AA17(VSS_AA17) U34.AA19(VSS_AA19) U34.AA21(VSS_AA21) U34.AA23(VSS_AA23) U34.AA25(VSS_AA25) U34.AA28(VSS_AA28) U34.AA35(VSS_AA35) U34.AB4(VSS_AB4) U34.AB7(VSS_AB7) U34.AB9(VSS_AB9) U34.AB11(VSS_AB11) U34.AB12(VSS_AB12) U34.AB14(VSS_AB14) U34.AB16(VSS_AB16) U34.AB18(VSS_AB18) U34.AB20(VSS_AB20) U34.AB22(VSS_AB22) U34.AB24(VSS_AB24) U34.AB26(VSS_AB26) U34.AB31(VSS_AB31) U34.AB34(VSS_AB34) U34.AC3(VSS_AC3) U34.AC6(VSS_AC6) U34.AC8(VSS_AC8) U34.AC10(VSS_AC10) U34.AC12(VSS_AC12) U34.AC13(VSS_AC13) U34.AC15(VSS_AC15) U34.AC17(VSS_AC17) U34.AC19(VSS_AC19) U34.AC21(VSS_AC21) U34.AC23(VSS_AC23) U34.AC25(VSS_AC25) U34.AC35(VSS_AC35) U34.AD4(VSS_AD4) U34.AD7(VSS_AD7) U34.AD9(VSS_AD9) U34.AD11(VSS_AD11) U34.AD12(VSS_AD12) U34.AD14(VSS_AD14) U34.AD16(VSS_AD16) U34.AD18(VSS_AD18) U34.AD20(VSS_AD20) U34.AD22(VSS_AD22) U34.AD24(VSS_AD24) U34.AD26(VSS_AD26) U34.AD34(VSS_AD34) U34.AE3(VSS_AE3) U34.AE6(VSS_AE6) U34.AE8(VSS_AE8) U34.AE9(VSS_AE9) U34.AE10(VSS_AE10) U34.AE11(VSS_AE11) U34.AE12(VSS_AE12) U34.AE13(VSS_AE13) U34.AE15(VSS_AE15) U34.AE17(VSS_AE17) U34.AE19(VSS_AE19) U34.AE21(VSS_AE21) U34.AE23(VSS_AE23) U34.AE25(VSS_AE25) U34.AE29(VSS_AE29) U34.AE32(VSS_AE32) U34.AE35(VSS_AE35) U34.AF4(VSS_AF4) U34.AF8(VSS_AF8) U34.AF9(VSS_AF9) U34.AF10(VSS_AF10) U34.AF11(VSS_AF11) U34.AF12(VSS_AF12) U34.AF14(VSS_AF14) U34.AF16(VSS_AF16) U34.AF18(VSS_AF18) U34.AF20(VSS_AF20) U34.AF22(VSS_AF22) U34.AF24(VSS_AF24) U34.AF34(VSS_AF34) U34.AG3(VSS_AG3) U34.AG6(VSS_AG6) U34.AG8(VSS_AG8) U34.AG9(VSS_AG9) U34.AG10(VSS_AG10) U34.AG11(VSS_AG11) U34.AG12(VSS_AG12) U34.AG14(VSS_AG14) U34.AG15(VSS_AG15) U34.AG16(VSS_AG16) U34.AG17(VSS_AG17) U34.AG18(VSS_AG18) U34.AG19(VSS_AG19) U34.AG21(VSS_AG21) U34.AG22(VSS_AG22) U34.AG23(VSS_AG23) U34.AG24(VSS_AG24) U34.AG25(VSS_AG25) U34.AG35(VSS_AG35) U34.AH1(VSS_AH1) U34.AH2(VSS_AH2) U34.AH3(VSS_AH3) U34.AH4(VSS_AH4) U34.AH5(VSS_AH5) U34.AH6(VSS_AH6) U34.AH8(VSS_AH8) U34.AH9(VSS_AH9) U34.AH10(VSS_AH10) U34.AH11(VSS_AH11) U34.AH12(VSS_AH12) U34.AH13(VSS_AH13) U34.AH14(VSS_AH14) U34.AH15(VSS_AH15) U34.AH16(VSS_AH16) U34.AH17(VSS_AH17) U34.AH18(VSS_AH18) U34.AH19(VSS_AH19) U34.AH20(VSS_AH20) U34.AH21(VSS_AH21) U34.AH22(VSS_AH22) U34.AH23(VSS_AH23) U34.AH24(VSS_AH24) U34.AH25(VSS_AH25) U34.AH29(VSS_AH29) U34.AH32(VSS_AH32) U34.AH34(VSS_AH34) U34.AJ4(VSS_AJ4) U34.AJ8(VSS_AJ8) U34.AJ9(VSS_AJ9) U34.AJ10(VSS_AJ10) U34.AJ11(VSS_AJ11) U34.AJ12(VSS_AJ12) U34.AJ13(VSS_AJ13) U34.AJ14(VSS_AJ14) U34.AJ15(VSS_AJ15) U34.AJ16(VSS_AJ16) U34.AJ17(VSS_AJ17) U34.AJ18(VSS_AJ18) U34.AJ19(VSS_AJ19) U34.AJ21(VSS_AJ21) U34.AJ22(VSS_AJ22) U34.AJ23(VSS_AJ23) U34.AJ24(VSS_AJ24) U34.AJ26(VSS_AJ26) U34.AJ35(VSS_AJ35) U34.AJ36(VSS_AJ36) U34.AJ37(VSS_AJ37) U34.AK3(VSS_AK3) U34.AK6(VSS_AK6) U34.AK8(VSS_AK8) U34.AK9(VSS_AK9) U34.AK10(VSS_AK10) U34.AK11(VSS_AK11) U34.AK12(VSS_AK12) U34.AK13(VSS_AK13) U34.AK14(VSS_AK14) U34.AK15(VSS_AK15) U34.AK16(VSS_AK16) U34.AK17(VSS_AK17) U34.AK18(VSS_AK18) U34.AK19(VSS_AK19) U34.AK21(VSS_AK21) U34.AK22(VSS_AK22) U34.AK23(VSS_AK23) U34.AK24(VSS_AK24) U34.AK26(VSS_AK26) U34.AK34(VSS_AK34) U34.AK35(VSS_AK35) U34.AL4(VSS_AL4) U34.AL15(VSS_AL15) U34.AL34(VSS_AL34) U34.AM3(VSS_AM3) U34.AM6(VSS_AM6) U34.AM9(VSS_AM9) U34.AM11(VSS_AM11) U34.AM13(VSS_AM13) U34.AM15(VSS_AM15) U34.AM18(VSS_AM18) U34.AM20(VSS_AM20) U34.AM22(VSS_AM22) U34.AM24(VSS_AM24) U34.AM27(VSS_AM27) U34.AM29(VSS_AM29) U34.AM31(VSS_AM31) U34.AM34(VSS_AM34) U34.AM35(VSS_AM35) U34.AN4(VSS_AN4) U34.AN7(VSS_AN7) U34.AN16(VSS_AN16) U34.AN25(VSS_AN25) U34.AN34(VSS_AN34) U34.AP3(VSS_AP3) U34.AP6(VSS_AP6) U34.AP7(VSS_AP7) U34.AP8(VSS_AP8) U34.AP10(VSS_AP10) U34.AP12(VSS_AP12) U34.AP14(VSS_AP14) U34.AP16(VSS_AP16) U34.AP17(VSS_AP17) U34.AP19(VSS_AP19) U34.AP21(VSS_AP21) U34.AP23(VSS_AP23) U34.AP25(VSS_AP25) U34.AP26(VSS_AP26) U34.AP28(VSS_AP28) U34.AP30(VSS_AP30) U34.AP32(VSS_AP32) U34.AP34(VSS_AP34) U34.AP35(VSS_AP35) U34.AR4(VSS_AR4) U34.AR7(VSS_AR7) U34.AR9(VSS_AR9) U34.AR11(VSS_AR11) U34.AR13(VSS_AR13) U34.AR15(VSS_AR15) U34.AR16(VSS_AR16) U34.AR18(VSS_AR18) U34.AR20(VSS_AR20) U34.AR22(VSS_AR22) U34.AR24(VSS_AR24) U34.AR25(VSS_AR25) U34.AR27(VSS_AR27) U34.AR29(VSS_AR29) U34.AR31(VSS_AR31) U34.AR33(VSS_AR33) U34.AR34(VSS_AR34) U34.AT3(VSS_AT3) U34.AT6(VSS_AT6) U34.AT7(VSS_AT7) U34.AT16(VSS_AT16) U34.AT25(VSS_AT25) U34.AT34(VSS_AT34) U34.AT35(VSS_AT35) U34.AU2(VSS_AU2) U34.AU3(VSS_AU3) U34.AU4(VSS_AU4) U34.AU5(VSS_AU5) U34.AU6(VSS_AU6) U34.AU7(VSS_AU7) U34.AU16(VSS_AU16) U34.AU25(VSS_AU25) U34.AU34(VSS_AU34) U34.B3(VSS_B3) U34.B6(VSS_B6) U34.B7(VSS_B7) U34.B16(VSS_B16) U34.B25(VSS_B25) U34.B34(VSS_B34) U34.B35(VSS_B35) U34.C4(VSS_C4) U34.C7(VSS_C7) U34.C9(VSS_C9) U34.C11(VSS_C11) U34.C13(VSS_C13) U34.C15(VSS_C15) U34.C16(VSS_C16) U34.C18(VSS_C18) U34.C20(VSS_C20) U34.C22(VSS_C22) U34.C24(VSS_C24) U34.C25(VSS_C25) U34.C27(VSS_C27) U34.C29(VSS_C29) U34.C31(VSS_C31) U34.C33(VSS_C33) U34.C34(VSS_C34) U34.D3(VSS_D3) U34.D6(VSS_D6) U34.D7(VSS_D7) U34.D8(VSS_D8) U34.D10(VSS_D10) U34.D12(VSS_D12) U34.D14(VSS_D14) U34.D16(VSS_D16) U34.D17(VSS_D17) U34.D19(VSS_D19) U34.D21(VSS_D21) U34.D23(VSS_D23) U34.D25(VSS_D25) U34.D26(VSS_D26) U34.D28(VSS_D28) U34.D30(VSS_D30) U34.D32(VSS_D32) U34.D34(VSS_D34) U34.D35(VSS_D35) U34.E4(VSS_E4) U34.E7(VSS_E7) U34.E16(VSS_E16) U34.E25(VSS_E25) U34.E34(VSS_E34) U34.F3(VSS_F3) U34.F6(VSS_F6) U34.F9(VSS_F9) U34.F11(VSS_F11) U34.F13(VSS_F13) U34.F15(VSS_F15) U34.F18(VSS_F18) U34.F20(VSS_F20) U34.F22(VSS_F22) U34.F24(VSS_F24) U34.F27(VSS_F27) U34.F29(VSS_F29) U34.F31(VSS_F31) U34.F34(VSS_F34) U34.F35(VSS_F35) U34.G4(VSS_G4) U34.G15(VSS_G15) U34.G34(VSS_G34) U34.H3(VSS_H3) U34.H6(VSS_H6) U34.H8(VSS_H8) U34.H9(VSS_H9) U34.H10(VSS_H10) U34.H11(VSS_H11) U34.H12(VSS_H12) U34.H13(VSS_H13) U34.H14(VSS_H14) U34.H15(VSS_H15) U34.H16(VSS_H16) U34.H17(VSS_H17) U34.H18(VSS_H18) U34.H19(VSS_H19) U34.H21(VSS_H21) U34.H22(VSS_H22) U34.H23(VSS_H23) U34.H24(VSS_H24) U34.H26(VSS_H26) U34.H34(VSS_H34) U34.H35(VSS_H35) U34.J4(VSS_J4) U34.J8(VSS_J8) U34.J9(VSS_J9) U34.J10(VSS_J10) U34.J11(VSS_J11) U34.J12(VSS_J12) U34.J13(VSS_J13) U34.J14(VSS_J14) U34.J15(VSS_J15) U34.J16(VSS_J16) U34.J17(VSS_J17) U34.J18(VSS_J18) U34.J19(VSS_J19) U34.J21(VSS_J21) U34.J22(VSS_J22) U34.J23(VSS_J23) U34.J24(VSS_J24) U34.J26(VSS_J26) U34.J34(VSS_J34) U34.J35(VSS_J35) U34.J36(VSS_J36) U34.J37(VSS_J37) U34.K1(VSS_K1) U34.K2(VSS_K2) U34.K3(VSS_K3) U34.K4(VSS_K4) U34.K5(VSS_K5) U34.K6(VSS_K6) U34.K8(VSS_K8) U34.K9(VSS_K9) U34.K10(VSS_K10) U34.K11(VSS_K11) U34.K12(VSS_K12) U34.K13(VSS_K13) U34.K14(VSS_K14) U34.K15(VSS_K15) U34.K16(VSS_K16) U34.K17(VSS_K17) U34.K18(VSS_K18) U34.K19(VSS_K19) U34.K20(VSS_K20) U34.K21(VSS_K21) U34.K22(VSS_K22) U34.K23(VSS_K23) U34.K24(VSS_K24) U34.K25(VSS_K25) U34.K29(VSS_K29) U34.K32(VSS_K32) U34.K34(VSS_K34) U34.L3(VSS_L3) U34.L6(VSS_L6) U34.L8(VSS_L8) U34.L9(VSS_L9) U34.L10(VSS_L10) U34.L11(VSS_L11) U34.L12(VSS_L12) U34.L14(VSS_L14) U34.L15(VSS_L15) U34.L16(VSS_L16) U34.L17(VSS_L17) U34.L18(VSS_L18) U34.L19(VSS_L19) U34.L21(VSS_L21) U34.L23(VSS_L23) U34.L24(VSS_L24) U34.L25(VSS_L25) U34.L35(VSS_L35) U34.M4(VSS_M4) U34.M8(VSS_M8) U34.M9(VSS_M9) U34.M10(VSS_M10) U34.M11(VSS_M11) U34.M12(VSS_M12) U34.M14(VSS_M14) U34.M16(VSS_M16) U34.M18(VSS_M18) U34.M20(VSS_M20) U34.M22(VSS_M22) U34.M24(VSS_M24) U34.M34(VSS_M34) U34.N3(VSS_N3) U34.N6(VSS_N6) U34.N8(VSS_N8) U34.N9(VSS_N9) U34.N10(VSS_N10) U34.N11(VSS_N11) U34.N12(VSS_N12) U34.N13(VSS_N13) U34.N15(VSS_N15) U34.N17(VSS_N17) U34.N19(VSS_N19) U34.N21(VSS_N21) U34.N23(VSS_N23) U34.N25(VSS_N25) U34.N29(VSS_N29) U34.N35(VSS_N35) U34.P4(VSS_P4) U34.P7(VSS_P7) U34.P9(VSS_P9) U34.P11(VSS_P11) U34.P12(VSS_P12) U34.P14(VSS_P14) U34.P16(VSS_P16) U34.P18(VSS_P18) U34.P20(VSS_P20) U34.P22(VSS_P22) U34.P24(VSS_P24) U34.P26(VSS_P26) U34.P31(VSS_P31) U34.P34(VSS_P34) U34.R3(VSS_R3) U34.R6(VSS_R6) U34.R8(VSS_R8) U34.R10(VSS_R10) U34.R12(VSS_R12) U34.R13(VSS_R13) U34.R15(VSS_R15) U34.R17(VSS_R17) U34.R19(VSS_R19) U34.R21(VSS_R21) U34.R23(VSS_R23) U34.R25(VSS_R25) U34.R35(VSS_R35) U34.T4(VSS_T4) U34.T7(VSS_T7) U34.T9(VSS_T9) U34.T11(VSS_T11) U34.T12(VSS_T12) U34.T14(VSS_T14) U34.T16(VSS_T16) U34.T18(VSS_T18) U34.T20(VSS_T20) U34.T22(VSS_T22) U34.T24(VSS_T24) U34.T26(VSS_T26) U34.T29(VSS_T29) U34.T34(VSS_T34) U34.U3(VSS_U3) U34.U6(VSS_U6) U34.U8(VSS_U8) U34.U10(VSS_U10) U34.U12(VSS_U12) U34.U13(VSS_U13) U34.U15(VSS_U15) U34.U17(VSS_U17) U34.U19(VSS_U19) U34.U21(VSS_U21) U34.U23(VSS_U23) U34.U25(VSS_U25) U34.U35(VSS_U35) U34.V4(VSS_V4) U34.V7(VSS_V7) U34.V9(VSS_V9) U34.V11(VSS_V11) U34.V12(VSS_V12) U34.V14(VSS_V14) U34.V16(VSS_V16) U34.V18(VSS_V18) U34.V20(VSS_V20) U34.V22(VSS_V22) U34.V24(VSS_V24) U34.V26(VSS_V26) U34.V32(VSS_V32) U34.V35(VSS_V35) U34.V36(VSS_V36) U34.V37(VSS_V37) U34.W1(VSS_W1) U34.W2(VSS_W2) U34.W3(VSS_W3) U34.W4(VSS_W4) U34.W5(VSS_W5) U34.W6(VSS_W6) U34.W8(VSS_W8) U34.W10(VSS_W10) U34.W12(VSS_W12) U34.W13(VSS_W13) U34.W15(VSS_W15) U34.W17(VSS_W17) U34.W19(VSS_W19) U34.W21(VSS_W21) U34.W23(VSS_W23) U34.W25(VSS_W25) U34.W28(VSS_W28) U34.Y4(VSS_Y4) U34.Y7(VSS_Y7) U34.Y9(VSS_Y9) U34.Y11(VSS_Y11) U34.Y12(VSS_Y12) U34.Y14(VSS_Y14) U34.Y16(VSS_Y16) U34.Y18(VSS_Y18) U34.Y20(VSS_Y20) U34.Y22(VSS_Y22) U34.Y24(VSS_Y24) U34.Y26(VSS_Y26) U34.Y31(VSS_Y31) U34.Y35(VSS_Y35) U34.Y36(VSS_Y36) U34.Y37(VSS_Y37) U47.2(GNDA) U47.7(GND0) U47.23(GND1) U47.33(GND2) U47.41(GND3) U47.48(GND4) U47.58(GND5) U47.65(EPAD) U50.7(GND) U54.2(GND) U56.4(VSS) U58.4(GND) U61.TH(GND_TH) U62.3(GND) U63.3(GND) U66.2(GND) U71.7(GND) U72.7(GND) U73.C1(GND) U74.C1(GND) U75.C1(GND) U76.C1(GND) U77.C1(GND) U78.C1(GND) U79.C1(GND) U80.C1(GND) U81.C1(GND) U82.C1(GND) U83.C1(GND) U84.C1(GND) U86.A1(GND21) U86.A2(GND24) U86.A18(GND22) U86.A19(GND23) U86.B1(GND25) U86.B19(GND26) U86.D18(GNDX2) U86.F10(GND15) U86.G4(GNDA) U86.G5(VREFA-) U86.H10(GND18) U86.H11(GND19) U86.H12(GND20) U86.J11(GND16) U86.J12(GND17) U86.K6(GND13) U86.K9(GND14) U86.K10(GND10) U86.K13(GND11) U86.K14(GND12) U86.L8(GND1) U86.L9(GND2) U86.M8(GND3) U86.M9(GND4) U86.M10(GND9) U86.N10(GND5) U86.P16(GND27) U86.R17(GND28) U86.R18(GNDX) U86.V1(GND6) U86.W1(GND7) U86.W2(GND8) U88.8(VSS) U89.8(VSS) U90.8(VSS) U91.8(VSS) U92.8(VSS) U93.8(VSS) U94.B2(GND0) U94.B15(GND1) U94.C3(GND2) U94.C14(GND3) U94.D4(GND4) U94.D13(GND5) U94.E5(GND6) U94.E12(GND7) U94.F6(GND8) U94.F11(GND9) U94.H8(GND10) U94.H9(GND11) U94.J8(GND12) U94.J9(GND13) U94.L6(GND14) U94.L11(GND15) U94.M5(GND16) U94.M12(GND17) U94.N4(GND18) U94.N13(GND19) U94.P3(GND20) U94.P14(GND21) U94.R2(GND22) U94.R15(GND23) U95.4(GND) U96.4(GND) U97.4(GND) U98.4(GND) U99.4(GND) U100.4(GND) U101.9(VSS) U101.TH U102.7(GND) U103.7(GND) U104.7(GND) U105.7(GND) U106.4(GND) U107.3(GND) U108.8(VSS) Y2.2(G1) Y2.4(G2)
P0V9_ADDR1: PR305.2 PU301.18(ADDR)
P0V9_BOOTC: PC308.1 PR306.1
P0V9_CTRL: C1231.1 PU301.9(CTRL) R3551.2 R3552.2
P0V9_IREF1: PR301.2 PU301.20(IREF)
P0V9_TAKE1: PR308.2 PU301.11(PASS) PU301.12(TAKE)
P0V9_VCC: PC306.1 PR307.1 PR308.1 PU301.24(VCC)
P0V9_VDRV1: PC307.1 PR303.2 PR304.2 PR309.2 PU301.5(VDRV)
P0V9_VOSNS+: PC309.1 PR320.1 PR321.2 PU301.22(VOSNS+)
P0V92: C537.1 C538.1 C539.1 C540.1 C541.1 C542.1 C543.1 C545.1 C546.1 C547.1 C548.1 C549.1 C550.1 C551.1 C552.1 C553.1 C554.1 C555.1 C556.1 C557.1 C558.1 C559.1 C560.1 C561.1 C562.1 C563.1 C564.1 C565.1 C566.1 C567.1 C568.1 C569.1 C570.1 C571.1 C572.1 C573.1 C574.1 C575.1 C576.1 C577.1 C578.1 C579.1 C580.1 C581.1 C582.1 C583.1 C584.1 C585.1 C586.1 C587.1 C588.1 C589.1 C590.1 C591.1 L8.1 PC311.1 PC312.1 PC313.1 PC314.1 PC315.1 PC316.1 PC318.1 PC319.1 PC320.1 PC321.1 PJ1.2 PL301.2 R3161.1 R3906.1 R4308.2 R4309.2 R4311.2 U34.AA14(VDD_0V9_AA14) U34.AA16(VDD_0V9_AA16) U34.AA18(VDD_0V9_AA18) U34.AA20(VDD_0V9_AA20) U34.AA22(VDD_0V9_AA22) U34.AA24(VDD_0V9_AA24) U34.AB13(VDD_0V9_AB13) U34.AB15(VDD_0V9_AB15) U34.AB17(VDD_0V9_AB17) U34.AB19(VDD_0V9_AB19) U34.AB21(VDD_0V9_AB21) U34.AB23(VDD_0V9_AB23) U34.AB25(VDD_0V9_AB25) U34.AC14(VDD_0V9_AC14) U34.AC16(VDD_0V9_AC16) U34.AC18(VDD_0V9_AC18) U34.AC20(VDD_0V9_AC20) U34.AC22(VDD_0V9_AC22) U34.AC24(VDD_0V9_AC24) U34.AD13(VDD_0V9_AD13) U34.AD15(VDD_0V9_AD15) U34.AD17(VDD_0V9_AD17) U34.AD19(VDD_0V9_AD19) U34.AD21(VDD_0V9_AD21) U34.AD23(VDD_0V9_AD23) U34.AD25(VDD_0V9_AD25) U34.AE14(VDD_0V9_AE14) U34.AE16(VDD_0V9_AE16) U34.AE18(VDD_0V9_AE18) U34.AE20(VDD_0V9_AE20) U34.AE22(VDD_0V9_AE22) U34.AE24(VDD_0V9_AE24) U34.AE26(VDD_0V9_AE26) U34.AF15(VDD_0V9_AF15) U34.AF17(VDD_0V9_AF17) U34.AF19(VDD_0V9_AF19) U34.AF23(VDD_0V9_AF23) U34.AF25(VDD_0V9_AF25) U34.M15(VDD_0V9_M15) U34.M17(VDD_0V9_M17) U34.M19(VDD_0V9_M19) U34.M23(VDD_0V9_M23) U34.M25(VDD_0V9_M25) U34.N14(VDD_0V9_N14) U34.N16(VDD_0V9_N16) U34.N18(VDD_0V9_N18) U34.N20(VDD_0V9_N20) U34.N22(VDD_0V9_N22) U34.N24(VDD_0V9_N24) U34.P13(VDD_0V9_P13) U34.P15(VDD_0V9_P15) U34.P17(VDD_0V9_P17) U34.P19(VDD_0V9_P19) U34.P21(VDD_0V9_P21) U34.P23(VDD_0V9_P23) U34.P25(VDD_0V9_P25) U34.R14(VDD_0V9_R14) U34.R16(VDD_0V9_R16) U34.R18(VDD_0V9_R18) U34.R20(VDD_0V9_R20) U34.R22(VDD_0V9_R22) U34.R24(VDD_0V9_R24) U34.T13(VDD_0V9_T13) U34.T15(VDD_0V9_T15) U34.T17(VDD_0V9_T17) U34.T19(VDD_0V9_T19) U34.T21(VDD_0V9_T21) U34.T23(VDD_0V9_T23) U34.T25(VDD_0V9_T25) U34.U14(VDD_0V9_U14) U34.U16(VDD_0V9_U16) U34.U18(VDD_0V9_U18) U34.U20(VDD_0V9_U20) U34.U22(VDD_0V9_U22) U34.U24(VDD_0V9_U24) U34.V13(VDD_0V9_V13) U34.V15(VDD_0V9_V15) U34.V17(VDD_0V9_V17) U34.V19(VDD_0V9_V19) U34.V21(VDD_0V9_V21) U34.V23(VDD_0V9_V23) U34.W14(VDD_0V9_W14) U34.W16(VDD_0V9_W16) U34.W18(VDD_0V9_W18) U34.W20(VDD_0V9_W20) U34.W22(VDD_0V9_W22) U34.W24(VDD_0V9_W24) U34.Y13(VDD_0V9_Y13) U34.Y15(VDD_0V9_Y15) U34.Y17(VDD_0V9_Y17) U34.Y19(VDD_0V9_Y19) U34.Y21(VDD_0V9_Y21) U34.Y23(VDD_0V9_Y23) U34.Y25(VDD_0V9_Y25)
P0V92_BIC_SCALED: C1159.1 R3906.2 U86.H2(PE1|AIN2)
P0V92_SENSE+: PC309.2 PC310.1 PJ1.1 PR320.2
P1V8: C70.1 C592.1 C593.1 C594.1 C595.1 C596.1 C597.1 C598.1 C599.1 C600.1 C601.1 C602.1 C603.1 C604.1 C605.1 C606.1 C607.1 C613.1 C615.1 C616.1 C617.1 C948.1 C949.1 C950.1 C951.1 C953.2 C959.1 C960.1 C961.1 C1074.2 C1079.1 C1082.1 C1083.1 C1136.1 C1139.1 C1142.1 C1145.1 C1148.1 C1202.1 C1203.1 C1204.1 C1205.1 C1219.2 D4.1(VCCA) L7.1 L13.1 PC703.1 PC704.1 PL702.2 PU7.6(OUT) Q46.D R67.1 R68.1 R69.1 R70.1 R71.1 R72.1 R73.1 R74.1 R75.1 R76.1 R77.1 R78.1 R3063.1 R3064.1 R3065.1 R3066.1 R3067.1 R3068.1 R3069.1 R3070.1 R3071.1 R3072.1 R3073.1 R3074.1 R3123.1 R3125.1 R3126.1 R3127.1 R3128.1 R3136.2 R3137.2 R3138.2 R3139.2 R3140.2 R3141.2 R3142.2 R3143.2 R3144.2 R3145.2 R3146.2 R3147.2 R3148.2 R3162.1 R3258.2 R3259.2 R3260.2 R3261.2 R3264.1 R3268.1 R3271.1 R3272.1 R3273.1 R3277.1 R3278.1 R3279.1 R3284.1 R3285.2 R3336.2 R3337.2 R3430.2 R3431.2 R3432.2 R3565.2 R3566.2 R3567.2 R3568.2 R3569.2 R3570.2 R3571.2 R3572.2 R3573.2 R3574.2 R3575.2 R3576.2 R3745.1 R3746.2 R3749.1 R3750.2 R3753.1 R3754.2 R3909.1 R4065.1 R4066.2 R4069.1 R4070.2 R4073.2 R4074.2 R4219.1 R4234.1 R4236.1 R4238.1 R4240.1 R4242.1 R4244.1 R4246.1 R4248.1 R4250.1 R4252.1 R4254.1 R4256.1 R4312.1 R4313.1 R4314.1 R4315.1 R4316.1 R4317.1 R4318.1 R4319.1 R4320.1 R4321.1 R4322.1 R4323.1 R4386.1 U34.AA26(VDDO_1V8_AA26) U34.AC34(VDDO_1V8_AC34) U34.AD28(VDDO_1V8_AD28) U34.AE34(VDDO_1V8_AE34) U34.AG31(VDDO_1V8_AG31) U34.AG34(VDDO_1V8_AG34) U34.AJ34(VDDO_1V8_AJ34) U34.L31(VDDO_1V8_L31) U34.L34(VDDO_1V8_L34) U34.N34(VDDO_1V8_N34) U34.P28(VDDO_1V8_P28) U34.R26(VDDO_1V8_R26) U34.R34(VDDO_1V8_R34) U34.U26(VDDO_1V8_U26) U34.U31(VDDO_1V8_U31) U34.U34(VDDO_1V8_U34) U56.8(VCC) U58.8(VCC) U61.18(AVDD18_18) U61.29(DVDD18) U63.5(VCC) U66.3(VCCA) U71.14(VCC) U72.14(VCC) U88.16(VDD2) U89.16(VDD2) U90.16(VDD2) U91.16(VDD2) U92.16(VDD2) U93.16(VDD2) U102.14(VCC) U103.14(VCC) U104.14(VCC) U105.14(VCC)
P1V8_BIC_SCALED: C1158.1 R3909.2 R3910.1 U86.H3(PE0|AIN3)
P1V8_DISCHARGE_EN: Q52.G(GATE) Q53.D(DRAIN) R4385.2
P1V8_DISCHARGE_EN_D: Q52.D(DRAIN) R4386.2
P1V8_EN: C1230.1 PU7.4(EN) Q53.G(GATE) R3474.2 R3618.2
P1V8_JTAG: J47.1 R3268.2
P3V3: C1225.1 Q50.D R2833.1 R2834.1 R2835.1 R2836.1 R2837.1 R2838.1 R2923.1 R2925.1 R2926.1 R2927.1 R2928.1 R2929.1 R4182.2 R4183.2 R4184.2 R4185.2 R4186.2 R4187.2 R4188.2 R4189.2 R4190.2 R4191.2 R4192.2 R4193.2 R4293.2
P3V3_BOOTC_1: PC108.1 PR124.1
P3V3_BOOTC_2: PC207.1 PR206.1
P3V3_BOOTC_3: PC607.1 PR606.1
P3V3_DB1200: C769.1 C770.1 C771.1 C772.1 C773.1 C774.1 C775.1 C776.1 L6.2 R2916.1 R2917.1 R2963.1 R2967.1 R2968.1 R2970.1 U47.24(VDD0) U47.25(VDDIO1) U47.32(VDDIO2) U47.40(VDD1) U47.49(VDDIO3) U47.56(VDDIO4) U47.57(VDD2)
P3V3_DB1200_VDDA: C759.1 C760.1 R2916.2 U47.1(VDDA)
P3V3_DB1200_VDDR: C761.1 C762.1 R2917.2 U47.8(VDDR)
P3V3_M2A: C49.1 R3623.2 R3625.1 U19.1(VOUT1) U19.2(VOUT2) U19.3(VOUT3) U19.4(VOUT4) U19.5(VOUT5) U73.D1(BUS)
P3V3_M2A_EN: R2864.2 U86.M1(PC5|FAN0TACH0) U95.1(1A)
P3V3_M2A_EN_R: R2864.1 U25.3(Y)
P3V3_M2A_L: C12.1 C15.1 C89.1 C158.1 C159.1 C160.1 C161.1 C162.1 C163.1 J4.B2(3.3V_10) J4.B4(3.3V_11) J4.B12(3.3V_12) J4.B14(3.3V_13) J4.B16(3.3V_14) J4.B18(3.3V_15) J4.B70(3.3V_16) J4.B72(3.3V_17) J4.B74(3.3V_18) R2777.2 R2840.1 R3623.1 R3626.1 R4098.1 R4099.1 R4262.2
P3V3_M2A_SR: C104.1 U19.7(SR)
P3V3_M2B: C125.1 R3631.2 R3632.1 U20.1(VOUT1) U20.2(VOUT2) U20.3(VOUT3) U20.4(VOUT4) U20.5(VOUT5) U74.D1(BUS)
P3V3_M2B_EN: R2865.2 U86.K3(PC7|FAN0TACH1) U95.5(2A)
P3V3_M2B_EN_R: R2865.1 U25.6(Y)
P3V3_M2B_L: C6.1 C9.1 C87.1 C152.1 C153.1 C154.1 C155.1 C156.1 C157.1 J4.A2(3.3V_1) J4.A4(3.3V_2) J4.A12(3.3V_3) J4.A14(3.3V_4) J4.A16(3.3V_5) J4.A18(3.3V_6) J4.A70(3.3V_7) J4.A72(3.3V_8) J4.A74(3.3V_9) R2774.2 R2839.1 R3631.1 R3633.1 R4102.1 R4103.1 R4263.2
P3V3_M2B_SR: C123.1 U20.7(SR)
P3V3_M2C: C128.1 R3638.2 R3639.1 U21.1(VOUT1) U21.2(VOUT2) U21.3(VOUT3) U21.4(VOUT4) U21.5(VOUT5) U75.D1(BUS)
P3V3_M2C_EN: R2866.2 U86.V6(PF1|FAN0TACH2) U96.1(1A)
P3V3_M2C_EN_R: R2866.1 U25.8(Y)
P3V3_M2C_L: C224.1 C225.1 C226.1 C227.1 C228.1 C229.1 C230.1 C231.1 C232.1 J36.B2(3.3V_10) J36.B4(3.3V_11) J36.B12(3.3V_12) J36.B14(3.3V_13) J36.B16(3.3V_14) J36.B18(3.3V_15) J36.B70(3.3V_16) J36.B72(3.3V_17) J36.B74(3.3V_18) R2894.2 R2895.1 R3638.1 R3640.1 R4106.1 R4107.1 R4264.2
P3V3_M2C_SR: C126.1 U21.7(SR)
P3V3_M2D: C131.1 R3645.2 R3646.1 U22.1(VOUT1) U22.2(VOUT2) U22.3(VOUT3) U22.4(VOUT4) U22.5(VOUT5) U76.D1(BUS)
P3V3_M2D_EN: R2867.2 U86.W7(PF5|FAN0TACH4) U96.5(2A)
P3V3_M2D_EN_R: R2867.1 U25.11(Y)
P3V3_M2D_L: C215.1 C216.1 C217.1 C218.1 C219.1 C220.1 C221.1 C222.1 C223.1 J36.A2(3.3V_1) J36.A4(3.3V_2) J36.A12(3.3V_3) J36.A14(3.3V_4) J36.A16(3.3V_5) J36.A18(3.3V_6) J36.A70(3.3V_7) J36.A72(3.3V_8) J36.A74(3.3V_9) R2891.2 R2892.1 R3645.1 R3647.1 R4110.1 R4111.1 R4265.2
P3V3_M2D_SR: C129.1 U22.7(SR)
P3V3_M2E: C134.1 R3652.2 R3653.1 U23.1(VOUT1) U23.2(VOUT2) U23.3(VOUT3) U23.4(VOUT4) U23.5(VOUT5) U77.D1(BUS)
P3V3_M2E_EN: R2868.2 U86.U8(PF7|FAN0TACH5) U97.1(1A)
P3V3_M2E_EN_R: R2868.1 U26.3(Y)
P3V3_M2E_L: C242.1 C243.1 C244.1 C245.1 C246.1 C247.1 C248.1 C249.1 C250.1 J38.B2(3.3V_10) J38.B4(3.3V_11) J38.B12(3.3V_12) J38.B14(3.3V_13) J38.B16(3.3V_14) J38.B18(3.3V_15) J38.B70(3.3V_16) J38.B72(3.3V_17) J38.B74(3.3V_18) R2900.2 R2901.1 R3652.1 R3654.1 R4114.1 R4115.1 R4266.2
P3V3_M2E_SR: C132.1 U23.7(SR)
P3V3_M2F: C137.1 R3659.2 R3660.1 U24.1(VOUT1) U24.2(VOUT2) U24.3(VOUT3) U24.4(VOUT4) U24.5(VOUT5) U78.D1(BUS)
P3V3_M2F_EN: R2869.2 U86.T14(PG1|FAN0TACH6) U97.5(2A)
P3V3_M2F_EN_R: R2869.1 U26.6(Y)
P3V3_M2F_L: C233.1 C234.1 C235.1 C236.1 C237.1 C238.1 C239.1 C240.1 C241.1 J38.A2(3.3V_1) J38.A4(3.3V_2) J38.A12(3.3V_3) J38.A14(3.3V_4) J38.A16(3.3V_5) J38.A18(3.3V_6) J38.A70(3.3V_7) J38.A72(3.3V_8) J38.A74(3.3V_9) R2897.2 R2898.1 R3659.1 R3661.1 R4118.1 R4119.1 R4267.2
P3V3_M2F_SR: C135.1 U24.7(SR)
P3V3_M2G: C280.1 R3723.2 R3724.1 U33.1(VOUT1) U33.2(VOUT2) U33.3(VOUT3) U33.4(VOUT4) U33.5(VOUT5) U84.D1(BUS)
P3V3_M2G_EN: R2949.2 U86.A5(PE4|FAN0TACH7) U98.1(1A)
P3V3_M2G_EN_R: R2949.1 U26.8(Y)
P3V3_M2G_L: C36.1 C39.1 C100.1 C182.1 C183.1 C184.1 C185.1 C186.1 C187.1 J8.B2(3.3V_10) J8.B4(3.3V_11) J8.B12(3.3V_12) J8.B14(3.3V_13) J8.B16(3.3V_14) J8.B18(3.3V_15) J8.B70(3.3V_16) J8.B72(3.3V_17) J8.B74(3.3V_18) R2789.2 R2844.1 R3723.1 R3725.1 R4122.1 R4123.1 R4268.2
P3V3_M2G_SR: C279.1 U33.7(SR)
P3V3_M2H: C277.1 R3716.2 R3717.1 U32.1(VOUT1) U32.2(VOUT2) U32.3(VOUT3) U32.4(VOUT4) U32.5(VOUT5) U83.D1(BUS)
P3V3_M2H_EN: R2950.2 U86.R2(PH1|LPC0COMXCTS) U98.5(2A)
P3V3_M2H_EN_R: R2950.1 U26.11(Y)
P3V3_M2H_L: C30.1 C33.1 C97.1 C176.1 C177.1 C178.1 C179.1 C180.1 C181.1 J8.A2(3.3V_1) J8.A4(3.3V_2) J8.A12(3.3V_3) J8.A14(3.3V_4) J8.A16(3.3V_5) J8.A18(3.3V_6) J8.A70(3.3V_7) J8.A72(3.3V_8) J8.A74(3.3V_9) R2786.2 R2843.1 R3716.1 R3718.1 R4126.1 R4127.1 R4269.2
P3V3_M2H_SR: C276.1 U32.7(SR)
P3V3_M2I: C275.1 R3708.2 R3709.1 U31.1(VOUT1) U31.2(VOUT2) U31.3(VOUT3) U31.4(VOUT4) U31.5(VOUT5) U82.D1(BUS)
P3V3_M2I_EN: R2951.2 U86.R1(PH2|LPC0COMXDCD) U99.1(1A)
P3V3_M2I_EN_R: R2951.1 U50.3(Y)
P3V3_M2I_L: C206.1 C207.1 C208.1 C209.1 C210.1 C211.1 C212.1 C213.1 C214.1 J34.B2(3.3V_10) J34.B4(3.3V_11) J34.B12(3.3V_12) J34.B14(3.3V_13) J34.B16(3.3V_14) J34.B18(3.3V_15) J34.B70(3.3V_16) J34.B72(3.3V_17) J34.B74(3.3V_18) R2888.2 R2889.1 R3708.1 R3710.1 R4130.1 R4131.1 R4270.2
P3V3_M2I_SR: C274.1 U31.7(SR)
P3V3_M2J: C273.1 R3701.2 R3702.1 U30.1(VOUT1) U30.2(VOUT2) U30.3(VOUT3) U30.4(VOUT4) U30.5(VOUT5) U81.D1(BUS)
P3V3_M2J_EN: R2952.2 U86.T1(PH3|LPC0COMXDSR) U99.5(2A)
P3V3_M2J_EN_R: R2952.1 U50.6(Y)
P3V3_M2J_L: C197.1 C198.1 C199.1 C200.1 C201.1 C202.1 C203.1 C204.1 C205.1 J34.A2(3.3V_1) J34.A4(3.3V_2) J34.A12(3.3V_3) J34.A14(3.3V_4) J34.A16(3.3V_5) J34.A18(3.3V_6) J34.A70(3.3V_7) J34.A72(3.3V_8) J34.A74(3.3V_9) R2885.2 R2886.1 R3701.1 R3703.1 R4134.1 R4135.1 R4271.2
P3V3_M2J_SR: C271.1 U30.7(SR)
P3V3_M2K: C270.1 R3694.2 R3695.1 U29.1(VOUT1) U29.2(VOUT2) U29.3(VOUT3) U29.4(VOUT4) U29.5(VOUT5) U80.D1(BUS)
P3V3_M2K_EN: R2953.2 U86.R3(PH4|LPC0COMXDTR) U100.1(1A)
P3V3_M2K_EN_R: R2953.1 U50.8(Y)
P3V3_M2K_L: C24.1 C27.1 C94.1 C170.1 C171.1 C172.1 C173.1 C174.1 C175.1 J6.B2(3.3V_10) J6.B4(3.3V_11) J6.B12(3.3V_12) J6.B14(3.3V_13) J6.B16(3.3V_14) J6.B18(3.3V_15) J6.B70(3.3V_16) J6.B72(3.3V_17) J6.B74(3.3V_18) R2783.2 R2842.1 R3694.1 R3696.1 R4138.1 R4139.1 R4272.2
P3V3_M2K_SR: C269.1 U29.7(SR)
P3V3_M2L: C267.1 R3669.2 R3670.1 U28.1(VOUT1) U28.2(VOUT2) U28.3(VOUT3) U28.4(VOUT4) U28.5(VOUT5) U79.D1(BUS)
P3V3_M2L_EN: R2954.2 U86.T2(PH5|LPC0COMXRI) U100.5(2A)
P3V3_M2L_EN_R: R2954.1 U50.11(Y)
P3V3_M2L_L: C18.1 C21.1 C92.1 C164.1 C165.1 C166.1 C167.1 C168.1 C169.1 J6.A2(3.3V_1) J6.A4(3.3V_2) J6.A12(3.3V_3) J6.A14(3.3V_4) J6.A16(3.3V_5) J6.A18(3.3V_6) J6.A70(3.3V_7) J6.A72(3.3V_8) J6.A74(3.3V_9) R2780.2 R2841.1 R3669.1 R3671.1 R4142.1 R4143.1 R4273.2
P3V3_M2L_SR: C266.1 U28.7(SR)
P3V3_OR_M2A_EN: R4077.2 U19.11(EN)
P3V3_OR_M2A_EN_R: R4077.1 U95.7(1Y)
P3V3_OR_M2B_EN: R4078.2 U20.11(EN)
P3V3_OR_M2B_EN_R: R4078.1 U95.3(2Y)
P3V3_OR_M2C_EN: R4079.2 U21.11(EN)
P3V3_OR_M2C_EN_R: R4079.1 U96.7(1Y)
P3V3_OR_M2D_EN: R4080.2 U22.11(EN)
P3V3_OR_M2D_EN_R: R4080.1 U96.3(2Y)
P3V3_OR_M2E_EN: R4081.2 U23.11(EN)
P3V3_OR_M2E_EN_R: R4081.1 U97.7(1Y)
P3V3_OR_M2F_EN: R4082.2 U24.11(EN)
P3V3_OR_M2F_EN_R: R4082.1 U97.3(2Y)
P3V3_OR_M2G_EN: R4083.2 U33.11(EN)
P3V3_OR_M2G_EN_R: R4083.1 U98.7(1Y)
P3V3_OR_M2H_EN: R4084.2 U32.11(EN)
P3V3_OR_M2H_EN_R: R4084.1 U98.3(2Y)
P3V3_OR_M2I_EN: R4085.2 U31.11(EN)
P3V3_OR_M2I_EN_R: R4085.1 U99.7(1Y)
P3V3_OR_M2J_EN: R4086.2 U30.11(EN)
P3V3_OR_M2J_EN_R: R4086.1 U99.3(2Y)
P3V3_OR_M2K_EN: R4087.2 U29.11(EN)
P3V3_OR_M2K_EN_R: R4087.1 U100.7(1Y)
P3V3_OR_M2L_EN: R4088.2 U28.11(EN)
P3V3_OR_M2L_EN_R: R4088.1 U100.3(2Y)
P3V3_STBY: C1.1 C44.2 C45.1 C46.1 C103.1 C121.1 C122.1 C140.1 C141.1 C142.1 C143.1 C144.1 C145.1 C146.1 C147.1 C148.1 C149.1 C150.1 C151.1 C188.1 C189.1 C190.1 C191.1 C192.1 C193.1 C251.1 C252.1 C253.1 C254.1 C255.1 C256.1 C257.1 C258.1 C259.1 C260.1 C261.1 C262.1 C263.1 C264.1 C265.1 C268.1 C272.1 C278.1 C765.1 C952.2 C968.1 C975.2 C1075.2 C1078.1 C1085.1 C1087.1 C1089.1 C1091.1 C1093.1 C1095.1 C1097.1 C1099.1 C1101.1 C1103.1 C1105.1 C1107.1 C1115.1 C1116.1 C1117.1 C1118.1 C1119.1 C1120.1 C1121.1 C1122.1 C1123.1 C1124.1 C1129.1 C1130.1 C1133.1 C1135.1 C1138.1 C1141.1 C1144.1 C1147.1 C1151.1 C1152.1 C1153.1 C1154.1 C1155.1 C1160.1 C1161.1 C1162.1 C1163.1 C1164.1 C1165.1 C1166.1 C1167.1 C1168.1 C1169.1 C1174.1 C1175.1 C1176.1 C1177.1 C1180.1 C1181.1 C1182.1 C1183.1 C1184.1 C1185.1 C1186.1 C1187.1 C1206.1 C1207.1 C1208.1 C1209.1 C1210.1 C1211.1 C1212.1 C1213.1 C1214.1 C1215.1 C1216.1 C1217.1 C1221.2 C1222.1 C1223.1 C1224.2 C1226.1 C1227.1 C1232.2 C1233.1 C1234.1 C1237.1 C1238.1 C1239.1 C1240.1 C1241.1 C1242.1 C1243.1 C1244.1 C1245.1 C1246.1 C1247.1 C1248.1 D4.8(VCCB) D17.A D18.1 J55.1(VBUS) J60.1(VBUS) L6.1 L11.1 L14.2 PC110.1 PC112.1 PC113.1 PC114.1 PC115.1 PC116.1 PC119.1 PC210.1 PC211.1 PC212.1 PC213.1 PC214.1 PC610.1 PC611.1 PC612.1 PL101.2 PL201.2 PL601.2 PL701.1 PR125.1 PR126.1 PR207.2 PR309.1 PR701.1 Q47.D Q50.S R16.1 R19.1 R21.1 R23.1 R24.1 R2791.1 R2792.1 R2793.1 R2794.1 R2795.1 R2796.1 R2799.1 R2800.1 R2848.1 R2930.1 R2931.1 R2932.1 R2933.1 R2934.1 R2935.1 R3043.1 R3046.1 R3047.1 R3051.1 R3055.1 R3101.1 R3103.1 R3216.1 R3217.1 R3219.1 R3230.1 R3232.1 R3234.1 R3236.1 R3238.1 R3239.1 R3269.1 R3275.1 R3276.1 R3301.1 R3302.1 R3437.2 R3535.2 R3536.2 R3537.2 R3538.2 R3539.2 R3540.2 R3541.2 R3542.2 R3543.2 R3544.2 R3545.2 R3546.2 R3601.2 R3619.1 R3622.1 R3630.1 R3634.1 R3651.1 R3658.1 R3678.1 R3691.1 R3697.1 R3698.1 R3704.1 R3705.1 R3711.1 R3712.1 R3713.1 R3719.1 R3720.1 R3726.1 R3727.1 R3728.1 R3729.1 R3730.1 R3731.1 R3732.1 R3747.1 R3751.1 R3755.1 R3765.1 R3786.1 R3787.1 R3788.1 R3789.1 R3790.1 R3791.1 R3792.1 R3793.1 R3794.1 R3795.1 R3796.1 R3797.1 R3798.1 R3799.1 R3800.1 R3801.1 R3808.1 R3821.1 R3822.1 R3823.1 R3824.1 R3825.1 R3834.1 R3835.1 R3836.1 R3837.1 R3838.1 R3847.1 R3848.1 R3849.1 R3850.1 R3851.1 R3860.1 R3861.1 R3862.1 R3863.1 R3864.1 R3873.1 R3874.1 R3875.1 R3876.1 R3877.1 R3882.1 R3883.1 R3884.1 R3887.2 R3888.2 R3889.2 R3890.2 R3891.2 R3892.2 R3893.2 R3894.2 R3899.2 R3900.2 R3901.2 R3902.2 R3908.1 R3913.1 R3914.1 R3915.1 R3923.2 R4048.1 R4051.1 R4052.1 R4055.1 R4056.1 R4067.1 R4071.1 R4097.1 R4163.2 R4206.2 R4207.2 R4208.2 R4209.2 R4210.2 R4211.2 R4212.2 R4213.2 R4214.2 R4215.2 R4216.2 R4217.2 R4227.1 R4230.2 R4231.2 R4274.2 R4290.1 R4293.1 R4328.1 R4341.1 R4342.1 R4343.1 R4358.1 R4371.1 R4372.1 R4373.1 R4376.1 R4377.1 R4378.1 R4379.1 R4380.1 R4381.1 R4385.1 U2.9(VS) U6.8(VCC) U7.8(V+) U8.8(V+) U19.10(VCC) U19.12(VIN2) U19.13(VIN1) U20.10(VCC) U20.12(VIN2) U20.13(VIN1) U21.10(VCC) U21.12(VIN2) U21.13(VIN1) U22.10(VCC) U22.12(VIN2) U22.13(VIN1) U23.10(VCC) U23.12(VIN2) U23.13(VIN1) U24.10(VCC) U24.12(VIN2) U24.13(VIN1) U25.14(VCC) U26.14(VCC) U28.10(VCC) U28.12(VIN2) U28.13(VIN1) U29.10(VCC) U29.12(VIN2) U29.13(VIN1) U30.10(VCC) U30.12(VIN2) U30.13(VIN1) U31.10(VCC) U31.12(VIN2) U31.13(VIN1) U32.10(VCC) U32.12(VIN2) U32.13(VIN1) U33.10(VCC) U33.12(VIN2) U33.13(VIN1) U50.14(VCC) U54.5(VCC) U61.3(DVDD33) U62.5(VCC) U66.7(VCCB) U73.B1(VS) U74.B1(VS) U75.B1(VS) U76.B1(VS) U77.B1(VS) U78.B1(VS) U79.B1(VS) U80.B1(VS) U81.B1(VS) U82.B1(VS) U83.B1(VS) U84.B1(VS) U86.F3(VDDA) U86.F4(VREFA+) U86.G10(VDD13) U86.H9(VDD14) U86.J8(VDD3) U86.J9(VDD4) U86.J10(VDD15) U86.K7(VDD11) U86.K8(VDD12) U86.K11(VDD9) U86.K12(VDD10) U86.L10(VDD1) U86.L11(VDD2) U86.L12(VDD5) U86.M11(VDD6) U86.M12(VDD7) U86.N16(VDD17) U86.P10(VDD8) U86.P17(VDD16) U86.P19(VBAT) U88.1(VDD1) U89.1(VDD1) U90.1(VDD1) U91.1(VDD1) U92.1(VDD1) U93.1(VDD1) U94.A1(VCC0) U94.A16(VCC1) U94.D5(VCCIO0_3) U94.D12(VCCIO0_1) U94.G7(VCC4) U94.G8(VCCIO0_0) U94.G9(VCCIO0_2) U94.G10(VCC5) U94.K7(VCC6) U94.K10(VCC7) U94.T1(VCC2) U94.T16(VCC3) U95.8(VCC) U96.8(VCC) U97.8(VCC) U98.8(VCC) U99.8(VCC) U100.8(VCC) U101.21(VDD) U106.1(VCCA) U106.8(VCCB) U107.5(VCC) U108.1(VDD1) U108.16(VDD2)
P3V3_STBY_ADDR1: PR105.2 PU101.18(ADDR)
P3V3_STBY_ADDR2: PR202.2 PU201.18(ADDR)
P3V3_STBY_ADDR3: PR602.2 PU601.18(ADDR)
P3V3_STBY_BIC_SCALED: C1157.1 R3905.1 R3908.2 U86.G1(PE2|AIN1)
P3V3_STBY_CPLD_JTAG: C1170.1 C1171.1 D18.2 J58.1
P3V3_STBY_CTRL: PR122.2 PR123.2 PU101.9(CTRL) PU201.9(CTRL) PU601.9(CTRL)
P3V3_STBY_IREF1: PR101.2 PU101.20(IREF)
P3V3_STBY_IREF2: PR201.2 PU201.20(IREF)
P3V3_STBY_IREF3: PR601.2 PU601.20(IREF)
P3V3_STBY_ISUM1: PU101.19(ISUM) PU201.19(ISUM) PU601.19(ISUM)
P3V3_STBY_PS#1: PR106.2 PU101.17(PS#)
P3V3_STBY_PS#2: PR203.2 PU201.17(PS#)
P3V3_STBY_PS#3: PR603.2 PU601.17(PS#)
P3V3_STBY_SET: PU101.13(SET) PU201.13(SET) PU601.13(SET)
P3V3_STBY_TAKE1: PR108.2 PU101.12(TAKE) PU601.11(PASS)
P3V3_STBY_TAKE2: PU101.11(PASS) PU201.12(TAKE)
P3V3_STBY_TAKE3: PU201.11(PASS) PU601.12(TAKE)
P3V3_STBY_VCC: PC106.1 PC205.1 PC605.1 PR106.1 PR107.1 PR108.1 PR109.2 PR203.1 PR204.2 PR603.1 PR604.2 PU101.24(VCC) PU201.24(VCC) PU601.24(VCC)
P3V3_STBY_VDRV1: PC107.1 PR103.2 PR104.2 PR109.1 PR205.2 PR605.2 PU101.5(VDRV)
P3V3_STBY_VDRV2: PC206.1 PR204.1 PR205.1 PU201.5(VDRV)
P3V3_STBY_VDRV3: PC606.1 PR604.1 PR605.1 PU601.5(VDRV)
P3V3_STBY_VOSNS2+: PR207.1 PR208.2 PU201.22(VOSNS+) PU601.22(VOSNS+)
P3V3_STBY_VOSNS+: PC109.1 PR120.1 PR121.2 PU101.22(VOSNS+)
P3V3_STBY_VOSNS-: PC120.2 PR121.1 PR127.2 PR128.2 PU101.21(VOSNS-)
P12V_BIC_SCALED: C1156.1 R3903.2 R3904.1 U86.G2(PE3|AIN0)
P12V_CONN: J41.2 J41.3 J41.4 J41.5 J41.6 J41.7 J41.8 J41.9 J41.10 J41.11 J41.12 J41.13 J41.14 J41.15 J41.16 J41.17 J41.18 J49.2 J49.3 J49.4 J49.5 J49.6 J49.7 J49.8 J49.9 J49.10 J49.11 J49.12 R6.2A U2.11(BUS)
P12V_STBY: PL102.1 PR123.1 R6.1A R2875.2 R3903.1
VCCIO_PLD_1_5: C1189.1 C1191.1 C1192.1 C1193.1 C1194.1 C1195.1 C1196.1 C1197.1 C1198.1 C1199.1 C1200.1 C1201.1 C1218.1 C1220.1 Q44.D Q48.D R3922.2 R4219.2 R4227.2 U94.E4(VCCIO5) U94.E13(VCCIO1_0) U94.H7(VCCIO4_1) U94.H10(VCCIO1_1) U94.J7(VCCIO4_0) U94.J10(VCCIO1_2) U94.K8(VCCIO2_2) U94.K9(VCCIO2_0) U94.M4(VCCIO3) U94.M13(VCCIO1_3) U94.N5(VCCIO2_3) U94.N12(VCCIO2_1)
VCCIO_PMOS_1_S: Q44.S Q46.S R4220.1
VCCIO_PMOS_2_S: Q47.S Q48.S R4223.1
VDD_P1V8_ZL30281: C972.1 C973.1 C974.1 L13.2 U61.12(AVDD18_12) U61.13(AVDD18_13) U61.17(AVDD18_17)
VDD_P3V3_ZL30281: C964.1 C965.1 C966.1 C967.1 C969.1 C1114.1 C1172.1 C1173.1 L11.2 U61.9(VDDXO33) U61.16(VDDO3) U61.19(VDDO2) U61.22(AVDD33) U61.25(VDDO1)
VDDC_OUTPUT: C1125.1 C1126.1 C1127.1 C1128.1 U86.E10(VDDC2) U86.H16(VDDC1)
VDDO_1V8: C609.1 C610.1 C611.1 C612.1 C614.1 L7.2 R3162.2 U34.AA31(VDDO_1V8_REF_AA31) U34.AA34(VDDO_1V8_REF_AA34) U34.N26(VDDA_DTM_ESD) U34.V28(VDDO_1V8_REF_V28) U34.W26(VDDO_1V8_REF_W26)
AVD_PCIE: C662.1 C663.1 C664.1 C665.1 C666.1 C667.1 C668.1 C669.1 C670.1 C671.1 C672.1 C673.1 C674.1 C675.1 C676.1 C677.1 C678.1 C679.1 C680.1 C681.1 C682.1 C683.1 C684.1 C685.1 C686.1 C687.1 C688.1 C689.1 C690.1 C691.1 C692.1 C693.1 C694.1 C715.1 C716.1 C717.1 C718.1 C719.1 C720.1 C721.1 C722.1 C723.1 C724.1 C728.1 C729.1 C730.1 C732.1 C733.1 C734.1 C749.1 C750.1 C751.1 C752.1 R4309.1 R4311.1 U34.AC26(AVD_PCIE_AC26) U34.AE7(AVD_PCIE_AE7) U34.AF7(AVD_PCIE_AF7) U34.AF13(AVD_PCIE_AF13) U34.AF21(AVD_PCIE_AF21) U34.AG7(AVD_PCIE_AG7) U34.AH7(AVD_PCIE_AH7) U34.AJ7(AVD_PCIE_AJ7) U34.AJ20(AVD_PCIE_AJ20) U34.AJ25(AVD_PCIE_AJ25) U34.AK7(AVD_PCIE_AK7) U34.AK20(AVD_PCIE_AK20) U34.AK25(AVD_PCIE_AK25) U34.AL7(AVD_PCIE_AL7) U34.AL8(AVD_PCIE_AL8) U34.AL9(AVD_PCIE_AL9) U34.AL10(AVD_PCIE_AL10) U34.AL11(AVD_PCIE_AL11) U34.AL12(AVD_PCIE_AL12) U34.AL13(AVD_PCIE_AL13) U34.AL14(AVD_PCIE_AL14) U34.AL16(AVD_PCIE_AL16) U34.AL17(AVD_PCIE_AL17) U34.AL18(AVD_PCIE_AL18) U34.AL19(AVD_PCIE_AL19) U34.AL20(AVD_PCIE_AL20) U34.AL21(AVD_PCIE_AL21) U34.AL22(AVD_PCIE_AL22) U34.AL23(AVD_PCIE_AL23) U34.AL24(AVD_PCIE_AL24) U34.AL25(AVD_PCIE_AL25) U34.AL26(AVD_PCIE_AL26) U34.AL27(AVD_PCIE_AL27) U34.AL28(AVD_PCIE_AL28) U34.AL29(AVD_PCIE_AL29) U34.AL30(AVD_PCIE_AL30) U34.AL31(AVD_PCIE_AL31) U34.AL32(AVD_PCIE_AL32) U34.AL33(AVD_PCIE_AL33) U34.AM7(AVD_PCIE_AM7) U34.AM16(AVD_PCIE_AM16) U34.AM25(AVD_PCIE_AM25) U34.AM33(AVD_PCIE_AM33) U34.F7(AVD_PCIE_F7) U34.F16(AVD_PCIE_F16) U34.F25(AVD_PCIE_F25) U34.F33(AVD_PCIE_F33) U34.G7(AVD_PCIE_G7) U34.G8(AVD_PCIE_G8) U34.G9(AVD_PCIE_G9) U34.G10(AVD_PCIE_G10) U34.G11(AVD_PCIE_G11) U34.G12(AVD_PCIE_G12) U34.G13(AVD_PCIE_G13) U34.G14(AVD_PCIE_G14) U34.G16(AVD_PCIE_G16) U34.G17(AVD_PCIE_G17) U34.G18(AVD_PCIE_G18) U34.G19(AVD_PCIE_G19) U34.G20(AVD_PCIE_G20) U34.G21(AVD_PCIE_G21) U34.G22(AVD_PCIE_G22) U34.G23(AVD_PCIE_G23) U34.G24(AVD_PCIE_G24) U34.G25(AVD_PCIE_G25) U34.G26(AVD_PCIE_G26) U34.G27(AVD_PCIE_G27) U34.G28(AVD_PCIE_G28) U34.G29(AVD_PCIE_G29) U34.G30(AVD_PCIE_G30) U34.G31(AVD_PCIE_G31) U34.G32(AVD_PCIE_G32) U34.G33(AVD_PCIE_G33) U34.H7(AVD_PCIE_H7) U34.H20(AVD_PCIE_H20) U34.H25(AVD_PCIE_H25) U34.J7(AVD_PCIE_J7) U34.J20(AVD_PCIE_J20) U34.J25(AVD_PCIE_J25) U34.K7(AVD_PCIE_K7) U34.L7(AVD_PCIE_L7) U34.L22(AVD_PCIE_L22) U34.M7(AVD_PCIE_M7) U34.M13(AVD_PCIE_M13) U34.M21(AVD_PCIE_M21) U34.N7(AVD_PCIE_N7)
AVD_PCIE_Q: C651.1 C652.1 C653.1 C654.1 C655.1 C656.1 C657.1 C658.1 C659.1 C660.1 C661.1 L8.2 R3161.2 U34.AG13(AVD_PCIE_Q_AG13) U34.AG20(AVD_PCIE_Q_AG20) U34.L13(AVD_PCIE_Q_L13) U34.L20(AVD_PCIE_Q_L20) U34.V25(AVD_PCIE_Q_V25)
AVD_PCIE_TX: C618.1 C619.1 C620.1 C621.1 C622.1 C623.1 C624.1 C625.1 C626.1 C627.1 C628.1 C629.1 C630.1 C631.1 C632.1 C633.1 C634.1 C635.1 C636.1 C637.1 C638.1 C639.1 C640.1 C641.1 C642.1 C643.1 C644.1 C645.1 C646.1 C647.1 C648.1 C649.1 C650.1 R4308.1 U34.AA7(AVD_PCIE_TX_AA7) U34.AA9(AVD_PCIE_TX_AA9) U34.AA11(AVD_PCIE_TX_AA11) U34.AB8(AVD_PCIE_TX_AB8) U34.AB10(AVD_PCIE_TX_AB10) U34.AC7(AVD_PCIE_TX_AC7) U34.AC9(AVD_PCIE_TX_AC9) U34.AC11(AVD_PCIE_TX_AC11) U34.AD8(AVD_PCIE_TX_AD8) U34.AD10(AVD_PCIE_TX_AD10) U34.P8(AVD_PCIE_TX_P8) U34.P10(AVD_PCIE_TX_P10) U34.R7(AVD_PCIE_TX_R7) U34.R9(AVD_PCIE_TX_R9) U34.R11(AVD_PCIE_TX_R11) U34.T8(AVD_PCIE_TX_T8) U34.T10(AVD_PCIE_TX_T10) U34.U7(AVD_PCIE_TX_U7) U34.U9(AVD_PCIE_TX_U9) U34.U11(AVD_PCIE_TX_U11) U34.V8(AVD_PCIE_TX_V8) U34.V10(AVD_PCIE_TX_V10) U34.W7(AVD_PCIE_TX_W7) U34.W9(AVD_PCIE_TX_W9) U34.W11(AVD_PCIE_TX_W11) U34.Y8(AVD_PCIE_TX_Y8) U34.Y10(AVD_PCIE_TX_Y10)
BIC_BOARD_ID_0: R4338.1 R4341.2 U86.B14(PS2|GPIOPS2)
BIC_BOARD_ID_1: R4339.1 R4342.2 U86.A14(PS3|GPIOPS3)
BIC_BOARD_ID_2: R4340.1 R4343.2 U86.V9(PS4|GPIOPS4)
BIC_REMOTE_DEBUG_SELECT_N: R4287.1 SW5.B(COM) U86.U2(PH6|GPIOPH6)
BMC_BYPASS_SELECT_N: J59.2 R4048.2 U86.P18(RESET_N)
BMC_HARTBEAT_LED_R_N: R3802.2 U86.T13(PS5|GPIOPS5)
BMC_HEARTBEAT_LED_N: D17.C R3802.1
BOOT_RECOVERYB: J46.1 R3259.1 U34.AH33(BOOT_RECOVERYB)
CARD_TYPE_DETECTION: J41.33 R3051.2 R3052.1
CLK_25M_MINIBMC_CLKIN: OSC1.3(OUT) R3764.1
CLK_25M_MINIBMC_CLKIN_R: R3764.2 U86.E19(OSC0)
CLK_100M_DB1200_M2A_DN: R3188.1 U47.18(DIF0#)
CLK_100M_DB1200_M2A_DP: R3187.1 U47.17(DIF0)
CLK_100M_DB1200_M2A_R_DN: J4.B53(NC25) R3188.2 R3578.1
CLK_100M_DB1200_M2A_R_DP: J4.B55(NC26) R3187.2 R3577.1
CLK_100M_DB1200_M2B_DN: R3190.1 U47.22(DIF1#)
CLK_100M_DB1200_M2B_DP: R3189.1 U47.21(DIF1)
CLK_100M_DB1200_M2B_R_DN: J4.A53(REFCLKN) R3190.2 R3580.1
CLK_100M_DB1200_M2B_R_DP: J4.A55(REFCLKP) R3189.2 R3579.1
CLK_100M_DB1200_M2C_DN: R3192.1 U47.27(DIF2#)
CLK_100M_DB1200_M2C_DP: R3191.1 U47.26(DIF2)
CLK_100M_DB1200_M2C_R_DN: J36.B53(NC25) R3192.2 R3582.1
CLK_100M_DB1200_M2C_R_DP: J36.B55(NC26) R3191.2 R3581.1
CLK_100M_DB1200_M2D_DN: R3194.1 U47.31(DIF3#)
CLK_100M_DB1200_M2D_DP: R3193.1 U47.30(DIF3)
CLK_100M_DB1200_M2D_R_DN: J36.A53(REFCLKN) R3194.2 R3584.1
CLK_100M_DB1200_M2D_R_DP: J36.A55(REFCLKP) R3193.2 R3583.1
CLK_100M_DB1200_M2E_DN: R3196.1 U47.35(DIF4#)
CLK_100M_DB1200_M2E_DP: R3195.1 U47.34(DIF4)
CLK_100M_DB1200_M2E_R_DN: J38.B53(NC25) R3196.2 R3586.1
CLK_100M_DB1200_M2E_R_DP: J38.B55(NC26) R3195.2 R3585.1
CLK_100M_DB1200_M2F_DN: R3198.1 U47.39(DIF5#)
CLK_100M_DB1200_M2F_DP: R3197.1 U47.38(DIF5)
CLK_100M_DB1200_M2F_R_DN: J38.A53(REFCLKN) R3198.2 R3588.1
CLK_100M_DB1200_M2F_R_DP: J38.A55(REFCLKP) R3197.2 R3587.1
CLK_100M_DB1200_M2G_DN: R3200.1 U47.43(DIF6#)
CLK_100M_DB1200_M2G_DP: R3199.1 U47.42(DIF6)
CLK_100M_DB1200_M2G_R_DN: J8.B53(NC25) R3200.2 R3590.1
CLK_100M_DB1200_M2G_R_DP: J8.B55(NC26) R3199.2 R3589.1
CLK_100M_DB1200_M2H_DN: R3202.1 U47.47(DIF7#)
CLK_100M_DB1200_M2H_DP: R3201.1 U47.46(DIF7)
CLK_100M_DB1200_M2H_R_DN: J8.A53(REFCLKN) R3202.2 R3592.1
CLK_100M_DB1200_M2H_R_DP: J8.A55(REFCLKP) R3201.2 R3591.1
CLK_100M_DB1200_M2I_DN: R3204.1 U47.51(DIF8#)
CLK_100M_DB1200_M2I_DP: R3203.1 U47.50(DIF8)
CLK_100M_DB1200_M2I_R_DN: J34.B53(NC25) R3204.2 R3594.1
CLK_100M_DB1200_M2I_R_DP: J34.B55(NC26) R3203.2 R3593.1
CLK_100M_DB1200_M2J_DN: R3206.1 U47.55(DIF9#)
CLK_100M_DB1200_M2J_DP: R3205.1 U47.54(DIF9)
CLK_100M_DB1200_M2J_R_DN: J34.A53(REFCLKN) R3206.2 R3596.1
CLK_100M_DB1200_M2J_R_DP: J34.A55(REFCLKP) R3205.2 R3595.1
CLK_100M_DB1200_M2K_DN: R3208.1 U47.60(DIF10#)
CLK_100M_DB1200_M2K_DP: R3207.1 U47.59(DIF10)
CLK_100M_DB1200_M2K_R_DN: J6.B53(NC25) R3208.2 R3598.1
CLK_100M_DB1200_M2K_R_DP: J6.B55(NC26) R3207.2 R3597.1
CLK_100M_DB1200_M2L_DN: R3210.1 U47.64(DIF11#)
CLK_100M_DB1200_M2L_DP: R3209.1 U47.63(DIF11)
CLK_100M_DB1200_M2L_R_DN: J6.A53(REFCLKN) R3210.2 R3600.1
CLK_100M_DB1200_M2L_R_DP: J6.A55(REFCLKP) R3209.2 R3599.1
CLK_100M_PE_DN: J41.50 R3099.1
CLK_100M_PE_DP: J41.48 R3100.1
CLK_100M_PESW_D_C_DN: C971.2 R3241.2 U34.Y30(PCIE_REFCLK_D_RXI_N)
CLK_100M_PESW_D_C_DP: C970.2 R3241.1 U34.Y29(PCIE_REFCLK_D_RXI_P)
CLK_100M_PESW_D_DN: C971.1 U61.23(OC1N)
CLK_100M_PESW_D_DP: C970.1 U61.24(OC1P)
CLK_100M_PESW_H2_R_C_DN: C909.2 R3098.2 U34.AA30(PCIE_REFCLK_H2_RXI_N)
CLK_100M_PESW_H2_R_C_DP: C910.2 R3098.1 U34.AA29(PCIE_REFCLK_H2_RXI_P)
CLK_100M_PESW_H2_R_DN: C909.1 R3099.2
CLK_100M_PESW_H2_R_DP: C910.1 R3100.2
CLK_100M_PESW_S3_DB1200_C_DN: C912.2 R3101.2 R3104.1 U47.10(DIF_IN#)
CLK_100M_PESW_S3_DB1200_C_DP: C913.2 R3102.1 R3103.2 U47.9(DIF_IN)
CLK_100M_PESW_S3_DB1200_DN: C912.1 U34.AA33(PCIE_REFCLK_S3_TXO_N)
CLK_100M_PESW_S3_DB1200_DP: C913.1 U34.AA32(PCIE_REFCLK_S3_TXO_P)
CLKBUF_M2A_OE_N: R2796.2 R2854.1 R4146.2 U47.19(VOE0#)
CLKBUF_M2A_OE_N_R: R4146.1 U101.1(P00)
CLKBUF_M2B_OE_N: R2795.2 R2853.1 R4147.2 U47.20(VOE1#)
CLKBUF_M2B_OE_N_R: R4147.1 U101.2(P01)
CLKBUF_M2C_OE_N: R2794.2 R2852.1 R4148.2 U47.28(VOE2#)
CLKBUF_M2C_OE_N_R: R4148.1 U101.3(P02)
CLKBUF_M2D_OE_N: R2793.2 R2851.1 R4149.2 U47.29(VOE3#)
CLKBUF_M2D_OE_N_R: R4149.1 U101.4(P03)
CLKBUF_M2E_OE_N: R2792.2 R2850.1 R4150.2 U47.36(VOE4#)
CLKBUF_M2E_OE_N_R: R4150.1 U101.5(P04)
CLKBUF_M2F_OE_N: R2791.2 R2849.1 R4151.2 U47.37(VOE5#)
CLKBUF_M2F_OE_N_R: R4151.1 U101.6(P05)
CLKBUF_M2G_OE_N: R2935.2 R2941.1 R4152.2 U47.44(VOE6#)
CLKBUF_M2G_OE_N_R: R4152.1 U101.7(P06)
CLKBUF_M2H_OE_N: R2934.2 R2940.1 R4153.2 U47.45(VOE7#)
CLKBUF_M2H_OE_N_R: R4153.1 U101.8(P07)
CLKBUF_M2I_OE_N: R2933.2 R2939.1 R4154.2 U47.52(VOE8#)
CLKBUF_M2I_OE_N_R: R4154.1 U101.10(P10)
CLKBUF_M2J_OE_N: R2932.2 R2938.1 R4155.2 U47.53(VOE9#)
CLKBUF_M2J_OE_N_R: R4155.1 U101.11(P11)
CLKBUF_M2K_OE_N: R2931.2 R2937.1 R4156.2 U47.61(VOE10#)
CLKBUF_M2K_OE_N_R: R4156.1 U101.12(P12)
CLKBUF_M2L_OE_N: R2930.2 R2936.1 R4157.2 U47.62(VOE11#)
CLKBUF_M2L_OE_N_R: R4157.1 U101.13(P13)
COM_CPLD_M2A_RX: J4.B46(NC17) R3924.1
COM_CPLD_M2A_RX_R: R3924.2 U94.H14(PR7A|PCLKT1_0)
COM_CPLD_M2A_TX: R4294.1 U94.E16(PR3A)
COM_CPLD_M2A_TX_R: J4.B48(NC18) R4294.2
COM_CPLD_M2B_RX: J4.A46(UART_RX) R3925.1
