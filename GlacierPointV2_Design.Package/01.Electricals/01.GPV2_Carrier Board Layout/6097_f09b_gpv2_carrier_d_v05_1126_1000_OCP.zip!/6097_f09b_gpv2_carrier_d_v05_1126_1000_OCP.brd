# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Nets (continued)
COM_CPLD_M2B_RX_R: R3925.2 U94.H16(PR7B|PCLKC1_0)
COM_CPLD_M2B_TX: R4295.1 U94.F15(PR3B)
COM_CPLD_M2B_TX_R: J4.A48(UART_TX) R4295.2
COM_CPLD_M2C_RX: J36.B46(NC17) R3926.1
COM_CPLD_M2C_RX_R: R3926.2 U94.J16(PR7C)
COM_CPLD_M2C_TX: R4296.1 U94.F13(PR3C)
COM_CPLD_M2C_TX_R: J36.B48(NC18) R4296.2
COM_CPLD_M2D_RX: J36.A46(UART_RX) R3927.1
COM_CPLD_M2D_RX_R: R3927.2 U94.J14(PR7D)
COM_CPLD_M2D_TX: R4297.1 U94.G12(PR3D)
COM_CPLD_M2D_TX_R: J36.A48(UART_TX) R4297.2
COM_CPLD_M2E_RX: J38.B46(NC17) R3928.1
COM_CPLD_M2E_RX_R: R3928.2 U94.J15(PR9A)
COM_CPLD_M2E_TX: R4298.1 U94.F14(PR4A)
COM_CPLD_M2E_TX_R: J38.B48(NC18) R4298.2
COM_CPLD_M2F_RX: J38.A46(UART_RX) R3929.1
COM_CPLD_M2F_RX_R: R3929.2 U94.K16(PR9B)
COM_CPLD_M2F_TX: R4299.1 U94.F16(PR4B)
COM_CPLD_M2F_TX_R: J38.A48(UART_TX) R4299.2
COM_CPLD_M2G_RX: J8.B46(NC17) R3930.1
COM_CPLD_M2G_RX_R: R3930.2 U94.H11(PR9C)
COM_CPLD_M2G_TX: R4300.1 U94.F12(PR4C)
COM_CPLD_M2G_TX_R: J8.B48(NC18) R4300.2
COM_CPLD_M2H_RX: J8.A46(UART_RX) R3931.1
COM_CPLD_M2H_RX_R: R3931.2 U94.J13(PR9D)
COM_CPLD_M2H_TX: R4301.1 U94.G13(PR4D)
COM_CPLD_M2H_TX_R: J8.A48(UART_TX) R4301.2
COM_CPLD_M2I_RX: J34.B46(NC17) R3932.1
COM_CPLD_M2I_RX_R: R3932.2 U94.K14(PR10A)
COM_CPLD_M2I_TX: R4302.1 U94.G15(PR5A)
COM_CPLD_M2I_TX_R: J34.B48(NC18) R4302.2
COM_CPLD_M2J_RX: J34.A46(UART_RX) R3933.1
COM_CPLD_M2J_RX_R: R3933.2 U94.K15(PR10B)
COM_CPLD_M2J_TX: R4303.1 U94.G14(PR5B)
COM_CPLD_M2J_TX_R: J34.A48(UART_TX) R4303.2
COM_CPLD_M2K_RX: J6.B46(NC17) R3934.1
COM_CPLD_M2K_RX_R: R3934.2 U94.J11(PR10C)
COM_CPLD_M2K_TX: R4304.1 U94.G11(PR5C)
COM_CPLD_M2K_TX_R: J6.B48(NC18) R4304.2
COM_CPLD_M2L_RX: J6.A46(UART_RX) R3935.1
COM_CPLD_M2L_RX_R: R3935.2 U94.L12(PR10D)
COM_CPLD_M2L_TX: R4305.1 U94.H12(PR5D)
COM_CPLD_M2L_TX_R: J6.A48(UART_TX) R4305.2
COM_GP_RX: J41.37 J55.3(D+) U94.B6(PT11B)
COM_GP_TX: J41.35 J55.2(D-) R3936.2
COM_GP_TX_R: R3936.1 U94.A5(PT11A)
DELTA_L_85_5IN_BOT_DN: J51.1 J52.2
DELTA_L_85_5IN_BOT_DP: J51.2 J52.1
DELTA_L_85_5IN_IN1_DN: J10.1 J13.2
DELTA_L_85_5IN_IN1_DP: J10.2 J13.1
DELTA_L_85_5IN_IN2_DN: J11.1 J14.2
DELTA_L_85_5IN_IN2_DP: J11.2 J14.1
DELTA_L_85_5IN_TOP_DN: J9.1 J12.2
DELTA_L_85_5IN_TOP_DP: J9.2 J12.1
DELTA_L_85_10IN_BOT_DN: J53.1 J54.2
DELTA_L_85_10IN_BOT_DP: J53.2 J54.1
DELTA_L_85_10IN_IN1_DN: J16.1 J19.2
DELTA_L_85_10IN_IN1_DP: J16.2 J19.1
DELTA_L_85_10IN_IN2_DN: J17.1 J20.2
DELTA_L_85_10IN_IN2_DP: J17.2 J20.1
DELTA_L_85_10IN_TOP_DN: J15.1 J18.2
DELTA_L_85_10IN_TOP_DP: J15.2 J18.1
FLASHCARD_B_PRSNT_N: J49.1 R3121.1
FLASHCARD_PRSNT_N: J41.1 R3048.1
FM_BIC_DEBUG_EN: Q24.2(G1) R4232.2 R4233.1
FM_BIC_DEBUG_EN_R: R4232.1 U86.B11(PN1|U1CTS)
FM_BIC_M2A_EN: R4057.2 R4275.2 U95.2(1B)
FM_BIC_M2A_EN_R: R4057.1 U86.B13(PP2|USB0NXT)
FM_BIC_M2B_EN: R4058.2 R4276.2 U95.6(2B)
FM_BIC_M2B_EN_R: R4058.1 U86.A16(PB0|USB0ID)
FM_BIC_M2C_EN: R4059.2 R4277.2 U96.2(1B)
FM_BIC_M2C_EN_R: R4059.1 U86.R7(PA7|USB0EPEN)
FM_BIC_M2D_EN: R4060.2 R4278.2 U96.6(2B)
FM_BIC_M2D_EN_R: R4060.1 U86.R13(PS7|GPIOPS7)
FM_BIC_M2E_EN: R4061.2 R4279.2 U97.2(1B)
FM_BIC_M2E_EN_R: R4061.1 U86.U12(PN7|GPIOPN7)
FM_BIC_M2F_EN: R4062.2 R4280.2 U97.6(2B)
FM_BIC_M2F_EN_R: R4062.1 U86.B16(PB1|USB0VBUS)
FM_BIC_M2G_EN: R4089.2 R4281.2 U98.2(1B)
FM_BIC_M2G_EN_R: R4089.1 U86.D8(PP4|GPIOPP4)
FM_BIC_M2H_EN: R4090.2 R4282.2 U98.6(2B)
FM_BIC_M2H_EN_R: R4090.1 U86.A8(PP7|GPIOPP7)
FM_BIC_M2I_EN: R4091.2 R4283.2 U99.2(1B)
FM_BIC_M2I_EN_R: R4091.1 U86.M3(PQ7|GPIOPQ7)
FM_BIC_M2J_EN: R4092.2 R4284.2 U99.6(2B)
FM_BIC_M2J_EN_R: R4092.1 U86.P3(PR4|GPIOPR4)
FM_BIC_M2K_EN: R4093.2 R4285.2 U100.2(1B)
FM_BIC_M2K_EN_R: R4093.1 U86.R10(PR7|GPIOPR7)
FM_BIC_M2L_EN: R4094.2 R4286.2 U100.6(2B)
FM_BIC_M2L_EN_R: R4094.1 U86.D12(PS0|GPIOPS0)
FM_CLKBUF_DB1200_EN: Q36.D(DRAIN) R2960.2 R2961.2 R3601.1 R4387.1
FM_CLKBUF_DB1200_EN_R: R2961.1 U47.6(^CKPWRGD_PD#)
FM_COM_EN_N: R4006.1 U94.C12(PT23A)
FM_COM_EN_N_R: R4006.2 U86.D13(PS1|LPC0RESET_N)
FM_COM_SEL_0: R4007.1 U94.B12(PT23B)
FM_COM_SEL_0_R: R4007.2 U86.H19(PL1|LPC0CLK)
FM_COM_SEL_1: R4008.1 U94.B14(PT24A)
FM_COM_SEL_1_R: R4008.2 U86.G16(PL0|LPC0FRAME_N)
FM_COM_SEL_2: R4009.1 U94.A15(PT24B)
FM_COM_SEL_2_R: R4009.2 U86.J18(PL3|LPC0SERIRQ)
FM_COM_SEL_3: R4010.1 U94.A13(PT24C|INITN)
FM_COM_SEL_3_R: R4010.2 U86.L19(PM3|LPC0AD0)
FM_JTAG_EN_N: R4011.1 U94.A11(PT21A)
FM_JTAG_EN_N_R: R4011.2 U86.K19(PM1|LPC0AD2)
FM_JTAG_SEL_0: R4012.1 U94.C11(PT21B)
FM_JTAG_SEL_0_R: R4012.2 U86.K18(PM0|LPC0AD3)
FM_JTAG_SEL_1: R4013.1 U94.F10(PT21C)
FM_JTAG_SEL_1_R: R4013.2 U86.G19(PL5|LPC0PD_N)
FM_JTAG_SEL_2: R4014.1 U94.D11(PT21D)
FM_JTAG_SEL_2_R: R4014.2 U86.H18(PL4|LPC0SCI_N)
FM_JTAG_SEL_3: R4015.1 U94.B11(PT22A)
FM_JTAG_SEL_3_R: R4015.2 U86.G18(PL2|LPC0CLKRUN_N)
FM_LED_PM_HB: Q10.2(G1) R3258.1 U34.R30(TPOUT)
FM_M2A_OCP_ADJ: R4388.1 U19.9(OCP)
FM_M2B_OCP_ADJ: R4389.1 U20.9(OCP)
FM_M2C_OCP_ADJ: R4390.1 U21.9(OCP)
FM_M2D_OCP_ADJ: R4391.1 U22.9(OCP)
FM_M2E_OCP_ADJ: R4392.1 U23.9(OCP)
FM_M2F_OCP_ADJ: R4393.1 U24.9(OCP)
FM_M2G_OCP_ADJ: R4394.1 U33.9(OCP)
FM_M2H_OCP_ADJ: R4395.1 U32.9(OCP)
FM_M2I_OCP_ADJ: R4396.1 U31.9(OCP)
FM_M2J_OCP_ADJ: R4397.1 U30.9(OCP)
FM_M2K_OCP_ADJ: R4398.1 U29.9(OCP)
FM_M2L_OCP_ADJ: R4399.1 U28.9(OCP)
FM_OE_RST_N: Q36.G(GATE) R3219.2 U62.4(OUT_Y) U63.1(OE_N)
FM_PLD_VCCIO_1_5_P1V8: R4218.2 R4222.2 R4228.1 R4230.1
FM_PLD_VCCIO_1_5_P1V8_R: R4228.2 U86.K1(PK2|GPIOPK2)
FM_PLD_VCCIO_1_5_P3V3SB: R4225.2 R4226.2 R4229.1 R4231.1
FM_PLD_VCCIO_1_5_P3V3SB_R: R4229.2 U86.K2(PK3|GPIOPK3)
FM_PLD_VCCIO_PMOS_1_G: Q44.G Q46.G R4220.2 R4221.1
FM_PLD_VCCIO_PMOS_2_G: Q47.G Q48.G R4223.2 R4224.1
FM_PLD_VCCIO_Q45_D: Q45.D R4221.2
FM_PLD_VCCIO_Q45_G: Q45.G R4222.1
FM_PLD_VCCIO_Q49_D: Q49.D R4224.2
FM_PLD_VCCIO_Q49_G: Q49.G R4225.1
FM_POWER_EN: R3053.2 R3552.1 R3618.1 R4288.1 R4357.2 U86.W10(PT0|GPIOPT0)
FM_POWER_EN_R: J41.51 R3053.1 R4356.1
FM_POWER_EN_R1: C1229.1 R2847.1 R2848.2 R4288.2 R4289.2 U25.1(A) U25.4(A) U25.9(A) U25.12(A) U26.1(A) U26.4(A) U26.9(A) U26.12(A) U50.1(A) U50.4(A) U50.9(A) U50.12(A)
FM_POWER_EN_R2: R4357.1 R4358.2 U107.4(Y)
FM_POWER_EN_R3: R4356.2 U107.2(A)
FRU_ADDR0: R16.2 U6.1(E0)
FRU_ADDR1: R17.1 U6.2(E1)
FRU_ADDR2: R18.1 U6.3(E2)
I2C_GPIO_INT_N: R4163.1 U101.22(INT#)
I2C_PESW_M2A_EN: R3529.1 R3565.1 U34.P30(TWI_SRSTB_3)
I2C_PESW_M2A_EN_LVC: R3511.2 U25.2(B)
I2C_PESW_M2A_EN_LVC_R: R91.1 R2833.2 R3511.1 U72.2(OUT)
I2C_PESW_M2A_EN_R: R3529.2 U72.1(IN)
I2C_PESW_M2B_EN: R3530.1 R3566.1 U34.P29(TWI_SCL_3)
I2C_PESW_M2B_EN_LVC: R3512.2 U25.5(B)
I2C_PESW_M2B_EN_LVC_R: R92.1 R2834.2 R3512.1 U72.4(OUT)
I2C_PESW_M2B_EN_R: R3530.2 U72.3(IN)
I2C_PESW_M2C_EN: R3531.1 R3567.1 U34.P32(TWI_SDA_3)
I2C_PESW_M2C_EN_LVC: R3513.2 U25.10(B)
I2C_PESW_M2C_EN_LVC_R: R93.1 R2835.2 R3513.1 U72.6(OUT)
I2C_PESW_M2C_EN_R: R3531.2 U72.5(IN)
I2C_PESW_M2D_EN: R3532.1 R3568.1 U34.P33(TWI_SRSTB_4)
I2C_PESW_M2D_EN_LVC: R3514.2 U25.13(B)
I2C_PESW_M2D_EN_LVC_R: R94.1 R2836.2 R3514.1 U72.8(OUT)
I2C_PESW_M2D_EN_R: R3532.2 U72.9(IN)
I2C_PESW_M2E_EN: R3533.1 R3569.1 U34.R27(TWI_SCL_4)
I2C_PESW_M2E_EN_LVC: R3516.2 U26.2(B)
I2C_PESW_M2E_EN_LVC_R: R95.1 R2837.2 R3516.1 U72.10(OUT)
I2C_PESW_M2E_EN_R: R3533.2 U72.11(IN)
I2C_PESW_M2F_EN: R3534.1 R3570.1 U34.R28(TWI_SDA_4)
I2C_PESW_M2F_EN_LVC: R3520.2 U26.5(B)
I2C_PESW_M2F_EN_LVC_R: R96.1 R2838.2 R3520.1 U72.12(OUT)
I2C_PESW_M2F_EN_R: R3534.2 U72.13(IN)
I2C_PESW_M2G_EN: R3523.1 R3575.1 U34.M26(TWI_SRSTB_5)
I2C_PESW_M2G_EN_LVC: R3515.2 U26.10(B)
I2C_PESW_M2G_EN_LVC_R: R2918.1 R2923.2 R3515.1 U71.2(OUT)
I2C_PESW_M2G_EN_R: R3523.2 U71.1(IN)
I2C_PESW_M2H_EN: R3524.1 R3576.1 U34.L30(TWI_SCL_5)
I2C_PESW_M2H_EN_LVC: R3517.2 U26.13(B)
I2C_PESW_M2H_EN_LVC_R: R2919.1 R2925.2 R3517.1 U71.4(OUT)
I2C_PESW_M2H_EN_R: R3524.2 U71.3(IN)
I2C_PESW_M2I_EN: R3525.1 R3571.1 U34.L29(TWI_SDA_5)
I2C_PESW_M2I_EN_LVC: R3518.2 U50.2(B)
I2C_PESW_M2I_EN_LVC_R: R2920.1 R2926.2 R3518.1 U71.6(OUT)
I2C_PESW_M2I_EN_R: R3525.2 U71.5(IN)
I2C_PESW_M2J_EN: R3526.1 R3572.1 U34.M32(TWI_SRSTB_6)
I2C_PESW_M2J_EN_LVC: R3519.2 U50.5(B)
I2C_PESW_M2J_EN_LVC_R: R2921.1 R2927.2 R3519.1 U71.8(OUT)
I2C_PESW_M2J_EN_R: R3526.2 U71.9(IN)
I2C_PESW_M2K_EN: R3527.1 R3573.1 U34.M27(TWI_SCL_6)
I2C_PESW_M2K_EN_LVC: R3521.2 U50.10(B)
I2C_PESW_M2K_EN_LVC_R: R2922.1 R2928.2 R3521.1 U71.10(OUT)
I2C_PESW_M2K_EN_R: R3527.2 U71.11(IN)
I2C_PESW_M2L_EN: R3528.1 R3574.1 U34.M31(TWI_SDA_6)
I2C_PESW_M2L_EN_LVC: R3522.2 U50.13(B)
I2C_PESW_M2L_EN_LVC_R: R2924.1 R2929.2 R3522.1 U71.12(OUT)
I2C_PESW_M2L_EN_R: R3528.2 U71.13(IN)
I2C_PESW_MULTI_CONFIG_ADD0: Q38.D(DRAIN) R3747.2 R3748.2
I2C_PESW_MULTI_CONFIG_ADD0_L: C1249.1 R3430.1 R3433.1 R3757.1 U34.R33(GPIO_60)
I2C_PESW_MULTI_CONFIG_ADD0_L_R: Q38.S(SOURCE) R3745.2 R3757.2
I2C_PESW_MULTI_CONFIG_ADD0_R: R3748.1 U86.M2(PC4|FAN0PWM0)
I2C_PESW_MULTI_CONFIG_ADD1: Q39.D(DRAIN) R3751.2 R3752.2
I2C_PESW_MULTI_CONFIG_ADD1_L: C1250.1 R3431.1 R3434.1 R3758.1 U34.T30(GPIO_61)
I2C_PESW_MULTI_CONFIG_ADD1_L_R: Q39.S(SOURCE) R3749.2 R3758.2
I2C_PESW_MULTI_CONFIG_ADD1_R: R3752.1 U86.L2(PC6|FAN0PWM1)
I2C_PESW_MULTI_CONFIG_ADD2: Q40.D(DRAIN) R3755.2 R3756.2
I2C_PESW_MULTI_CONFIG_ADD2_L: C1251.1 R3432.1 R3435.1 R3759.1 U34.T31(GPIO_62)
I2C_PESW_MULTI_CONFIG_ADD2_L_R: Q40.S(SOURCE) R3753.2 R3759.2
I2C_PESW_MULTI_CONFIG_ADD2_R: R3756.1 U86.U6(PF0|FAN0PWM2)
I2C_PESW_MULTI_CONFIG_ADD3: Q42.D(DRAIN) R4063.2 R4067.2
I2C_PESW_MULTI_CONFIG_ADD3_L: R4068.1 R4073.1 R4075.1 U34.T33(GPIO_63)
I2C_PESW_MULTI_CONFIG_ADD3_L_R: Q42.S(SOURCE) R4065.2 R4068.2
I2C_PESW_MULTI_CONFIG_ADD3_R: R4063.1 U86.V7(PF4|FAN0PWM4)
I2C_PESW_MULTI_CONFIG_ADD4: Q43.D(DRAIN) R4064.2 R4071.2
I2C_PESW_MULTI_CONFIG_ADD4_L: R4072.1 R4074.1 R4076.1 U34.T32(GPIO_64)
I2C_PESW_MULTI_CONFIG_ADD4_L_R: Q43.S(SOURCE) R4069.2 R4072.2
I2C_PESW_MULTI_CONFIG_ADD4_R: R4064.1 U86.N15(PG0|FAN0PWM6)
JTAG_BIC_M2_TCK: R3990.1 U94.C5(PT10B)
JTAG_BIC_M2_TCK_R: R3990.2 U86.V12(PG6|RMII0-EN0RXER)
JTAG_BIC_M2_TDI: R3991.1 U94.C4(PT9A)
JTAG_BIC_M2_TDI_R: R3991.2 U86.M16(PG3|RMII0-EN0TXEN)
JTAG_BIC_M2_TDO: R3938.2 U86.K15(PG5|RMII0-EN0TXD1)
JTAG_BIC_M2_TDO_R: R3938.1 U94.B5(PT9B)
JTAG_BIC_M2_TMS: R3992.1 U94.B3(PT9C)
JTAG_BIC_M2_TMS_R: R3992.2 U86.K17(PG4|RMII0-EN0TXD0)
JTAG_BIC_M2_TRST: R3803.1 R3993.1 U94.A4(PT10A)
JTAG_BIC_M2_TRST_R: R3993.2 U86.U14(PG7|RMII0-EN0RXDV)
JTAG_CPLD_M2A_TCK: J4.B28(GND17) R3975.2
JTAG_CPLD_M2A_TCK_R: R3975.1 U94.R8(PB11B|PCLKC2_0)
JTAG_CPLD_M2A_TDI: J4.B24(NC7) R3939.1
JTAG_CPLD_M2A_TDI_R: R3939.2 U94.D1(PL1B|L_GPLLC_FB)
JTAG_CPLD_M2A_TDO: J4.B26(NC8) U94.G3(PL5B)
JTAG_CPLD_M2A_TMS: J4.B67(NC27) R3951.1
JTAG_CPLD_M2A_TMS_R: R3951.2 U94.K2(PL10B)
JTAG_CPLD_M2A_TRST: J4.B20(NC6) R3963.2
JTAG_CPLD_M2A_TRST_R: R3963.1 U94.T4(PB3B)
JTAG_CPLD_M2B_TCK: J4.A28(TCK) R3976.2
JTAG_CPLD_M2B_TCK_R: R3976.1 U94.M6(PB11C)
JTAG_CPLD_M2B_TDI: J4.A24(TDI) R3940.1
JTAG_CPLD_M2B_TDI_R: R3940.2 U94.B1(PL1C)
JTAG_CPLD_M2B_TDO: J4.A26(TDO) U94.F5(PL5C)
JTAG_CPLD_M2B_TMS: J4.A67(TMS) R3952.1
JTAG_CPLD_M2B_TMS_R: R3952.2 U94.J5(PL10C)
JTAG_CPLD_M2B_TRST: J4.A20(TRST) R3964.2
JTAG_CPLD_M2B_TRST_R: R3964.1 U94.T2(PB3C)
JTAG_CPLD_M2C_TCK: J36.B28(GND17) R3977.2
JTAG_CPLD_M2C_TCK_R: R3977.1 U94.L8(PB11D)
JTAG_CPLD_M2C_TDI: J36.B24(NC7) R3941.1
JTAG_CPLD_M2C_TDI_R: R3941.2 U94.C2(PL1D)
JTAG_CPLD_M2C_TDO: J36.B26(NC8) U94.H6(PL5D)
JTAG_CPLD_M2C_TMS: J36.B67(NC27) R3953.1
JTAG_CPLD_M2C_TMS_R: R3953.2 U94.K6(PL10D)
JTAG_CPLD_M2C_TRST: J36.B20(NC6) R3965.2
JTAG_CPLD_M2C_TRST_R: R3965.1 U94.R3(PB3D)
JTAG_CPLD_M2D_TCK: J36.A28(TCK) R3978.2
JTAG_CPLD_M2D_TCK_R: R3978.1 U94.P8(PB12A)
JTAG_CPLD_M2D_TDI: J36.A24(TDI) R3942.1
JTAG_CPLD_M2D_TDI_R: R3942.2 U94.E2(PL2A|L_GPLLT_IN)
JTAG_CPLD_M2D_TDO: J36.A26(TDO) U94.G1(PL6A)
JTAG_CPLD_M2D_TMS: J36.A67(TMS) R3954.1
JTAG_CPLD_M2D_TMS_R: R3954.2 U94.L1(PL11A)
JTAG_CPLD_M2D_TRST: J36.A20(TRST) R3966.2
JTAG_CPLD_M2D_TRST_R: R3966.1 U94.R5(PB5A|CSSPIN)
JTAG_CPLD_M2E_TCK: J38.B28(GND17) R3979.2
JTAG_CPLD_M2E_TCK_R: R3979.1 U94.T8(PB12B)
JTAG_CPLD_M2E_TDI: J38.B24(NC7) R3943.1
JTAG_CPLD_M2E_TDI_R: R3943.2 U94.E3(PL2B|L_GPLLC_IN)
JTAG_CPLD_M2E_TDO: J38.B26(NC8) U94.H2(PL6B)
JTAG_CPLD_M2E_TMS: J38.B67(NC27) R3955.1
JTAG_CPLD_M2E_TMS_R: R3955.2 U94.L3(PL11B)
JTAG_CPLD_M2E_TRST: J38.B20(NC6) R3967.2
JTAG_CPLD_M2E_TRST_R: R3967.1 U94.P5(PB5B)
JTAG_CPLD_M2F_TCK: J38.A28(TCK) R3980.2
JTAG_CPLD_M2F_TCK_R: R3980.1 U94.N8(PB12C)
JTAG_CPLD_M2F_TDI: J38.A24(TDI) R3944.1
JTAG_CPLD_M2F_TDI_R: R3944.2 U94.C1(PL2C)
JTAG_CPLD_M2F_TDO: J38.A26(TDO) U94.H4(PL6C)
JTAG_CPLD_M2F_TMS: J38.A67(TMS) R3956.1
JTAG_CPLD_M2F_TMS_R: R3956.2 U94.K4(PL11C)
JTAG_CPLD_M2F_TRST: J38.A20(TRST) R3968.2
JTAG_CPLD_M2F_TRST_R: R3968.1 U94.T5(PB6A)
JTAG_CPLD_M2G_TCK: J8.B28(GND17) R3981.2
JTAG_CPLD_M2G_TCK_R: R3981.1 U94.L9(PB12D)
JTAG_CPLD_M2G_TDI: J8.B24(NC7) R3945.1
JTAG_CPLD_M2G_TDI_R: R3945.2 U94.D2(PL2D)
JTAG_CPLD_M2G_TDO: J8.B26(NC8) U94.J6(PL6D)
JTAG_CPLD_M2G_TMS: J8.B67(NC27) R3957.1
JTAG_CPLD_M2G_TMS_R: R3957.2 U94.L5(PL11D)
JTAG_CPLD_M2G_TRST: J8.B20(NC6) R3969.2
JTAG_CPLD_M2G_TRST_R: R3969.1 U94.R6(PB6B)
JTAG_CPLD_M2H_TCK: J8.A28(TCK) R3982.2
JTAG_CPLD_M2H_TCK_R: R3982.1 U94.T9(PB16A|PCLKT2_1)
JTAG_CPLD_M2H_TDI: J8.A24(TDI) R3946.1
JTAG_CPLD_M2H_TDI_R: R3946.2 U94.E1(PL3A|PCLKT5_0)
JTAG_CPLD_M2H_TDO: J8.A26(TDO) U94.H3(PL7A)
JTAG_CPLD_M2H_TMS: J8.A67(TMS) R3958.1
JTAG_CPLD_M2H_TMS_R: R3958.2 U94.L2(PL12A|PCLKT3_0)
JTAG_CPLD_M2H_TRST: J8.A20(TRST) R3970.2
JTAG_CPLD_M2H_TRST_R: R3970.1 U94.T3(PB6C)
JTAG_CPLD_M2I_TCK: J34.B28(GND17) R3983.2
JTAG_CPLD_M2I_TCK_R: R3983.1 U94.P9(PB16B|PCLKC2_1)
JTAG_CPLD_M2I_TDI: J34.B24(NC7) R3947.1
JTAG_CPLD_M2I_TDI_R: R3947.2 U94.F2(PL3B|PCLKC5_0)
JTAG_CPLD_M2I_TDO: J34.B26(NC8) U94.H1(PL7B)
JTAG_CPLD_M2I_TMS: J34.B67(NC27) R3959.1
JTAG_CPLD_M2I_TMS_R: R3959.2 U94.M1(PL12B|PCLKC3_0)
JTAG_CPLD_M2I_TRST: J34.B20(NC6) R3971.2
JTAG_CPLD_M2I_TRST_R: R3971.1 U94.R4(PB6D)
JTAG_CPLD_M2J_TCK: J34.A28(TCK) R3984.2
JTAG_CPLD_M2J_TCK_R: R3984.1 U94.M8(PB16C)
JTAG_CPLD_M2J_TDI: J34.A24(TDI) R3948.1
JTAG_CPLD_M2J_TDI_R: R3948.2 U94.F4(PL3C)
JTAG_CPLD_M2J_TDO: J34.A26(TDO) U94.J1(PL7C|PCLKT4_0)
JTAG_CPLD_M2J_TMS: J34.A67(TMS) R3960.1
JTAG_CPLD_M2J_TMS_R: R3960.2 U94.K5(PL12C)
JTAG_CPLD_M2J_TRST: J34.A20(TRST) R3972.2
JTAG_CPLD_M2J_TRST_R: R3972.1 U94.P6(PB8A|MCLK_CCLK)
JTAG_CPLD_M2K_TCK: J6.B28(GND17) R3985.2
JTAG_CPLD_M2K_TCK_R: R3985.1 U94.N9(PB16D)
JTAG_CPLD_M2K_TDI: J6.B24(NC7) R3949.1
JTAG_CPLD_M2K_TDI_R: R3949.2 U94.G6(PL3D)
JTAG_CPLD_M2K_TDO: J6.B26(NC8) U94.J3(PL7D|PCLKC4_0)
JTAG_CPLD_M2K_TMS: J6.B67(NC27) R3961.1
JTAG_CPLD_M2K_TMS_R: R3961.2 U94.L4(PL12D)
JTAG_CPLD_M2K_TRST: J6.B20(NC6) R3973.2
JTAG_CPLD_M2K_TRST_R: R3973.1 U94.T6(PB8B|SO_SPISO)
JTAG_CPLD_M2L_TCK: J6.A28(TCK) R3986.2
JTAG_CPLD_M2L_TCK_R: R3986.1 U94.R9(PB18A)
JTAG_CPLD_M2L_TDI: J6.A24(TDI) R3950.1
JTAG_CPLD_M2L_TDI_R: R3950.2 U94.F3(PL4A)
JTAG_CPLD_M2L_TDO: J6.A26(TDO) U94.J2(PL9A)
JTAG_CPLD_M2L_TMS: J6.A67(TMS) R3962.1
JTAG_CPLD_M2L_TMS_R: R3962.2 U94.M3(PL13A)
JTAG_CPLD_M2L_TRST: J6.A20(TRST) R3974.2
JTAG_CPLD_M2L_TRST_R: R3974.1 U94.N6(PB8C)
JTAG_CPLD_TCK: J58.8 R3916.1 R3920.2
JTAG_CPLD_TCK_R: R3920.1 U94.A7(PT16C|TCK)
JTAG_CPLD_TDI: J58.3 R3913.2 R3918.2
JTAG_CPLD_TDI_R: R3918.1 U94.A6(PT12D|TDI)
JTAG_CPLD_TDO: J58.2 R3915.2 R3917.2
JTAG_CPLD_TDO_R: R3917.1 U94.C6(PT12C|TDO)
JTAG_CPLD_TMS: J58.6 R3914.2 R3919.2
JTAG_CPLD_TMS_R: R3919.1 U94.B8(PT16D|TMS)
JTAG_PESE_TDI_R: J47.3 R3270.2 R3271.2
JTAG_PESW_RSTB: J47.7 R3284.2 U34.AG29(EJ_RSTB)
JTAG_PESW_TCK: J47.6 R3273.2 U34.AF26(TCK)
JTAG_PESW_TDI: R3270.1 U34.AG26(TDI)
JTAG_PESW_TDO: R3264.2 R3266.1 U34.AG33(TDO)
JTAG_PESW_TDO_R: J47.4 R3266.2
JTAG_PESW_TMS: J47.5 R3272.2 U34.AG27(TMS)
JTAG_PESW_TRSTB: J47.2 R3265.1 U34.AG28(TRSTB)
JTAG_TI_TCK: J56.4 R3878.2 R3882.2
JTAG_TI_TCK_R: R3878.1 U86.B15(PC0|TCK|SWDCLK)
JTAG_TI_TDI: J56.3 R3879.2 R3883.2
JTAG_TI_TDI_R: R3879.1 U86.D14(PC2|TDI)
JTAG_TI_TDO: J56.2 R3880.2
JTAG_TI_TDO_R: R3880.1 U86.C14(PC3|TDO|SWO)
JTAG_TI_TMS: J56.1 R3881.2 R3884.2
JTAG_TI_TMS_R: R3881.1 U86.C15(PC1|TMS|SWDIO)
LATCH_DETECT: J41.53 R3054.1
LATCH_DETECT_BUFFER: U54.3(2A) U54.6(1Y)
LATCH_DETECT_R: R3054.2 U54.4(2Y)
LATCH_DETECT_SW: C806.1 R3055.2 SW4.4 SW6.1 U54.1(1A)
LED_FM_BIC_DEBUG_EN: D5.2 Q24.6(D1)
LED_FM_BIC_DEBUG_EN_R: D5.1 R3437.1
LED_HB: D3.A R3269.2
LED_P12V: D1.1 R2875.1
LED_PM_HB_D: D3.C Q10.6(D1)
M2A_LED: J4.B10(NC5) R2840.2
M2A_VIO_CFG: J4.B73(GND30) R4235.2
M2B_LED: J4.A10(LED_1#) R2839.2
M2B_VIO_CFG: J4.A73(VIO_CFG_GND) R4237.2
M2C_LED: J36.B10(NC5) R2895.2
M2C_VIO_CFG: J36.B73(GND30) R4239.2
M2D_LED: J36.A10(LED_1#) R2892.2
M2D_VIO_CFG: J36.A73(VIO_CFG_GND) R4241.2
M2E_LED: J38.B10(NC5) R2901.2
M2E_VIO_CFG: J38.B73(GND30) R4243.2
M2F_LED: J38.A10(LED_1#) R2898.2
M2F_VIO_CFG: J38.A73(VIO_CFG_GND) R4245.2
M2G_LED: J8.B10(NC5) R2844.2
M2G_VIO_CFG: J8.B73(GND30) R4247.2
M2H_LED: J8.A10(LED_1#) R2843.2
M2H_VIO_CFG: J8.A73(VIO_CFG_GND) R4249.2
M2I_LED: J34.B10(NC5) R2889.2
M2I_VIO_CFG: J34.B73(GND30) R4251.2
M2J_LED: J34.A10(LED_1#) R2886.2
M2J_VIO_CFG: J34.A73(VIO_CFG_GND) R4253.2
M2K_LED: J6.B10(NC5) R2842.2
M2K_VIO_CFG: J6.B73(GND30) R4255.2
M2L_LED: J6.A10(LED_1#) R2841.2
M2L_VIO_CFG: J6.A73(VIO_CFG_GND) R4257.2
OSC1_VDD: C1131.1 L14.1 OSC1.4(VDD) R3766.1
OSC1_VDD_R: C1132.1 R3766.2
P3E_1_PESW_RX0_C_DN: C1070.2 J41.90
P3E_1_PESW_RX0_C_DP: C1071.2 J41.88
P3E_1_PESW_RX0_DN: C1070.1 U34.AU15(TX55_N)
P3E_1_PESW_RX0_DP: C1071.1 U34.AT15(TX55_P)
P3E_1_PESW_RX1_C_DN: C1068.2 J41.98
P3E_1_PESW_RX1_C_DP: C1069.2 J41.96
P3E_1_PESW_RX1_DN: C1068.1 U34.AT14(TX54_N)
P3E_1_PESW_RX1_DP: C1069.1 U34.AR14(TX54_P)
P3E_1_PESW_RX2_C_DN: C1066.2 J41.106
P3E_1_PESW_RX2_C_DP: C1067.2 J41.104
P3E_1_PESW_RX2_DN: C1066.1 U34.AU13(TX53_N)
P3E_1_PESW_RX2_DP: C1067.1 U34.AT13(TX53_P)
P3E_1_PESW_RX3_C_DN: C1064.2 J41.114
P3E_1_PESW_RX3_C_DP: C1065.2 J41.112
P3E_1_PESW_RX3_DN: C1064.1 U34.AT12(TX52_N)
P3E_1_PESW_RX3_DP: C1065.1 U34.AR12(TX52_P)
P3E_1_PESW_TX0_DN: J41.93 U34.AP15(RX55_N)
P3E_1_PESW_TX0_DP: J41.91 U34.AN15(RX55_P)
P3E_1_PESW_TX1_DN: J41.101 U34.AN14(RX54_N)
P3E_1_PESW_TX1_DP: J41.99 U34.AM14(RX54_P)
P3E_1_PESW_TX2_DN: J41.109 U34.AP13(RX53_N)
P3E_1_PESW_TX2_DP: J41.107 U34.AN13(RX53_P)
P3E_1_PESW_TX3_DN: J41.117 U34.AN12(RX52_N)
P3E_1_PESW_TX3_DP: J41.115 U34.AM12(RX52_P)
P3E_2_PESW_RX0_C_DN: C1062.2 J41.58
P3E_2_PESW_RX0_C_DP: C1063.2 J41.56
P3E_2_PESW_RX0_DN: C1062.1 U34.AU11(TX51_N)
P3E_2_PESW_RX0_DP: C1063.1 U34.AT11(TX51_P)
P3E_2_PESW_RX1_C_DN: C1060.2 J41.66
P3E_2_PESW_RX1_C_DP: C1061.2 J41.64
P3E_2_PESW_RX1_DN: C1060.1 U34.AT10(TX50_N)
P3E_2_PESW_RX1_DP: C1061.1 U34.AR10(TX50_P)
P3E_2_PESW_RX2_C_DN: C1058.2 J41.74
P3E_2_PESW_RX2_C_DP: C1059.2 J41.72
P3E_2_PESW_RX2_DN: C1058.1 U34.AU9(TX49_N)
P3E_2_PESW_RX2_DP: C1059.1 U34.AT9(TX49_P)
P3E_2_PESW_RX3_C_DN: C1072.2 J41.82
P3E_2_PESW_RX3_C_DP: C1073.2 J41.80
P3E_2_PESW_RX3_DN: C1072.1 U34.AT8(TX48_N)
P3E_2_PESW_RX3_DP: C1073.1 U34.AR8(TX48_P)
P3E_2_PESW_TX0_DN: J41.61 U34.AP11(RX51_N)
P3E_2_PESW_TX0_DP: J41.59 U34.AN11(RX51_P)
P3E_2_PESW_TX1_DN: J41.69 U34.AN10(RX50_N)
P3E_2_PESW_TX1_DP: J41.67 U34.AM10(RX50_P)
P3E_2_PESW_TX2_DN: J41.77 U34.AP9(RX49_N)
P3E_2_PESW_TX2_DP: J41.75 U34.AN9(RX49_P)
P3E_2_PESW_TX3_DN: J41.85 U34.AN8(RX48_N)
P3E_2_PESW_TX3_DP: J41.83 U34.AM8(RX48_P)
P3E_3_PESW_RX0_C_DN: C397.2 J49.68
P3E_3_PESW_RX0_C_DP: C398.2 J49.70
P3E_3_PESW_RX0_DN: C397.1 U34.AP37(TX75_N)
P3E_3_PESW_RX0_DP: C398.1 U34.AP36(TX75_P)
P3E_3_PESW_RX1_C_DN: C395.2 J49.76
P3E_3_PESW_RX1_C_DP: C396.2 J49.78
P3E_3_PESW_RX1_DN: C395.1 U34.AR36(TX74_N)
P3E_3_PESW_RX1_DP: C396.1 U34.AR35(TX74_P)
P3E_3_PESW_RX2_C_DN: C393.2 J49.84
P3E_3_PESW_RX2_C_DP: C394.2 J49.86
P3E_3_PESW_RX2_DN: C393.1 U34.AT37(TX73_N)
P3E_3_PESW_RX2_DP: C394.1 U34.AT36(TX73_P)
P3E_3_PESW_RX3_C_DN: C391.2 J49.92
P3E_3_PESW_RX3_C_DP: C392.2 J49.94
P3E_3_PESW_RX3_DN: C391.1 U34.AU36(TX72_N)
P3E_3_PESW_RX3_DP: C392.1 U34.AU35(TX72_P)
P3E_3_PESW_TX0_DN: J49.63 U34.AE37(RX75_N)
P3E_3_PESW_TX0_DP: J49.65 U34.AE36(RX75_P)
P3E_3_PESW_TX1_DN: J49.71 U34.AF36(RX74_N)
P3E_3_PESW_TX1_DP: J49.73 U34.AF35(RX74_P)
P3E_3_PESW_TX2_DN: J49.79 U34.AG37(RX73_N)
P3E_3_PESW_TX2_DP: J49.81 U34.AG36(RX73_P)
P3E_3_PESW_TX3_DN: J49.87 U34.AH36(RX72_N)
P3E_3_PESW_TX3_DP: J49.89 U34.AH35(RX72_P)
P3E_4_PESW_RX0_C_DN: C389.2 J49.102
P3E_4_PESW_RX0_C_DP: C390.2 J49.100
P3E_4_PESW_RX0_DN: C389.1 U34.AU33(TX71_N)
P3E_4_PESW_RX0_DP: C390.1 U34.AT33(TX71_P)
P3E_4_PESW_RX1_C_DN: C387.2 J49.110
P3E_4_PESW_RX1_C_DP: C388.2 J49.108
P3E_4_PESW_RX1_DN: C387.1 U34.AT32(TX70_N)
P3E_4_PESW_RX1_DP: C388.1 U34.AR32(TX70_P)
P3E_4_PESW_RX2_C_DN: C385.2 J49.118
P3E_4_PESW_RX2_C_DP: C386.2 J49.116
P3E_4_PESW_RX2_DN: C385.1 U34.AU31(TX69_N)
P3E_4_PESW_RX2_DP: C386.1 U34.AT31(TX69_P)
P3E_4_PESW_RX3_C_DN: C383.2 J49.126
P3E_4_PESW_RX3_C_DP: C384.2 J49.124
P3E_4_PESW_RX3_DN: C383.1 U34.AT30(TX68_N)
P3E_4_PESW_RX3_DP: C384.1 U34.AR30(TX68_P)
P3E_4_PESW_TX0_DN: J49.95 U34.AP33(RX71_N)
P3E_4_PESW_TX0_DP: J49.97 U34.AN33(RX71_P)
P3E_4_PESW_TX1_DN: J49.103 U34.AN32(RX70_N)
P3E_4_PESW_TX1_DP: J49.105 U34.AM32(RX70_P)
P3E_4_PESW_TX2_DN: J49.111 U34.AP31(RX69_N)
P3E_4_PESW_TX2_DP: J49.113 U34.AN31(RX69_P)
P3E_4_PESW_TX3_DN: J49.119 U34.AN30(RX68_N)
P3E_4_PESW_TX3_DP: J49.121 U34.AM30(RX68_P)
P3E_5_PESW_RX0_C_DN: C381.2 J49.132
P3E_5_PESW_RX0_C_DP: C382.2 J49.134
P3E_5_PESW_RX0_DN: C381.1 U34.AU29(TX67_N)
P3E_5_PESW_RX0_DP: C382.1 U34.AT29(TX67_P)
P3E_5_PESW_RX1_C_DN: C379.2 J49.140
P3E_5_PESW_RX1_C_DP: C380.2 J49.142
P3E_5_PESW_RX1_DN: C379.1 U34.AT28(TX66_N)
P3E_5_PESW_RX1_DP: C380.1 U34.AR28(TX66_P)
P3E_5_PESW_RX2_C_DN: C377.2 J49.148
P3E_5_PESW_RX2_C_DP: C378.2 J49.150
P3E_5_PESW_RX2_DN: C377.1 U34.AU27(TX65_N)
P3E_5_PESW_RX2_DP: C378.1 U34.AT27(TX65_P)
P3E_5_PESW_RX3_C_DN: C407.2 J49.156
P3E_5_PESW_RX3_C_DP: C408.2 J49.158
P3E_5_PESW_RX3_DN: C407.1 U34.AT26(TX64_N)
P3E_5_PESW_RX3_DP: C408.1 U34.AR26(TX64_P)
P3E_5_PESW_TX0_DN: J49.127 U34.AP29(RX67_N)
P3E_5_PESW_TX0_DP: J49.129 U34.AN29(RX67_P)
P3E_5_PESW_TX1_DN: J49.135 U34.AN28(RX66_N)
P3E_5_PESW_TX1_DP: J49.137 U34.AM28(RX66_P)
P3E_5_PESW_TX2_DN: J49.143 U34.AP27(RX65_N)
P3E_5_PESW_TX2_DP: J49.145 U34.AN27(RX65_P)
P3E_5_PESW_TX3_DN: J49.151 U34.AN26(RX64_N)
P3E_5_PESW_TX3_DP: J49.153 U34.AM26(RX64_P)
P3E_6_PESW_RX0_C_DN: C405.2 J49.36
P3E_6_PESW_RX0_C_DP: C406.2 J49.38
P3E_6_PESW_RX0_DN: C405.1 U34.AK37(TX79_N)
P3E_6_PESW_RX0_DP: C406.1 U34.AK36(TX79_P)
P3E_6_PESW_RX1_C_DN: C403.2 J49.44
P3E_6_PESW_RX1_C_DP: C404.2 J49.46
P3E_6_PESW_RX1_DN: C403.1 U34.AL36(TX78_N)
P3E_6_PESW_RX1_DP: C404.1 U34.AL35(TX78_P)
P3E_6_PESW_RX2_C_DN: C401.2 J49.52
P3E_6_PESW_RX2_C_DP: C402.2 J49.54
P3E_6_PESW_RX2_DN: C401.1 U34.AM37(TX77_N)
P3E_6_PESW_RX2_DP: C402.1 U34.AM36(TX77_P)
P3E_6_PESW_RX3_C_DN: C399.2 J49.60
P3E_6_PESW_RX3_C_DP: C400.2 J49.62
P3E_6_PESW_RX3_DN: C399.1 U34.AN36(TX76_N)
P3E_6_PESW_RX3_DP: C400.1 U34.AN35(TX76_P)
P3E_6_PESW_TX0_DN: J49.31 U34.AA37(RX79_N)
P3E_6_PESW_TX0_DP: J49.33 U34.AA36(RX79_P)
P3E_6_PESW_TX1_DN: J49.39 U34.AB36(RX78_N)
P3E_6_PESW_TX1_DP: J49.41 U34.AB35(RX78_P)
P3E_6_PESW_TX2_DN: J49.47 U34.AC37(RX77_N)
P3E_6_PESW_TX2_DP: J49.49 U34.AC36(RX77_P)
P3E_6_PESW_TX3_DN: J49.55 U34.AD36(RX76_N)
P3E_6_PESW_TX3_DP: J49.57 U34.AD35(RX76_P)
P3E_PESW_M2A_RX0_DN: J4.B41(PERN4) U34.AD6(RX36_P)
P3E_PESW_M2A_RX0_DP: J4.B43(PERP4) U34.AD5(RX36_N)
P3E_PESW_M2A_RX1_DN: J4.B29(PERN5) U34.AE5(RX37_P)
P3E_PESW_M2A_RX1_DP: J4.B31(PERP5) U34.AE4(RX37_N)
P3E_PESW_M2A_RX2_DN: J4.B17(PERN6) U34.AF6(RX38_P)
P3E_PESW_M2A_RX2_DP: J4.B19(PERP6) U34.AF5(RX38_N)
P3E_PESW_M2A_RX3_DN: J4.B5(PERN7) U34.AG5(RX39_P)
P3E_PESW_M2A_RX3_DP: J4.B7(PERP7) U34.AG4(RX39_N)
P3E_PESW_M2A_TX0_C_DN: C1024.2 J4.B47(PETN4)
P3E_PESW_M2A_TX0_C_DP: C1023.2 J4.B49(PETP4)
P3E_PESW_M2A_TX0_DN: C1024.1 U34.AD3(TX36_P)
P3E_PESW_M2A_TX0_DP: C1023.1 U34.AD2(TX36_N)
P3E_PESW_M2A_TX1_C_DN: C1026.2 J4.B35(PETN5)
P3E_PESW_M2A_TX1_C_DP: C1025.2 J4.B37(PETP5)
P3E_PESW_M2A_TX1_DN: C1026.1 U34.AE2(TX37_P)
P3E_PESW_M2A_TX1_DP: C1025.1 U34.AE1(TX37_N)
P3E_PESW_M2A_TX2_C_DN: C1028.2 J4.B23(PETN6)
P3E_PESW_M2A_TX2_C_DP: C1027.2 J4.B25(PETP6)
P3E_PESW_M2A_TX2_DN: C1028.1 U34.AF3(TX38_P)
P3E_PESW_M2A_TX2_DP: C1027.1 U34.AF2(TX38_N)
P3E_PESW_M2A_TX3_C_DN: C1030.2 J4.B11(PETN7)
P3E_PESW_M2A_TX3_C_DP: C1029.2 J4.B13(PETP7)
P3E_PESW_M2A_TX3_DN: C1030.1 U34.AG2(TX39_P)
P3E_PESW_M2A_TX3_DP: C1029.1 U34.AG1(TX39_N)
P3E_PESW_M2B_RX0_DN: J4.A41(PERN0) U34.Y6(RX32_P)
P3E_PESW_M2B_RX0_DP: J4.A43(PERP0) U34.Y5(RX32_N)
P3E_PESW_M2B_RX1_DN: J4.A29(PERN1) U34.AA5(RX33_P)
P3E_PESW_M2B_RX1_DP: J4.A31(PERP1) U34.AA4(RX33_N)
P3E_PESW_M2B_RX2_DN: J4.A17(PERN2) U34.AB6(RX34_P)
P3E_PESW_M2B_RX2_DP: J4.A19(PERP2) U34.AB5(RX34_N)
P3E_PESW_M2B_RX3_DN: J4.A5(PERN3) U34.AC5(RX35_P)
P3E_PESW_M2B_RX3_DP: J4.A7(PERP3) U34.AC4(RX35_N)
P3E_PESW_M2B_TX0_C_DN: C1016.2 J4.A47(PETN0)
P3E_PESW_M2B_TX0_C_DP: C1015.2 J4.A49(PETP0)
P3E_PESW_M2B_TX0_DN: C1016.1 U34.Y3(TX32_P)
P3E_PESW_M2B_TX0_DP: C1015.1 U34.Y2(TX32_N)
P3E_PESW_M2B_TX1_C_DN: C1018.2 J4.A35(PETN1)
P3E_PESW_M2B_TX1_C_DP: C1017.2 J4.A37(PETP1)
P3E_PESW_M2B_TX1_DN: C1018.1 U34.AA2(TX33_P)
P3E_PESW_M2B_TX1_DP: C1017.1 U34.AA1(TX33_N)
P3E_PESW_M2B_TX2_C_DN: C1020.2 J4.A23(PETN2)
P3E_PESW_M2B_TX2_C_DP: C1019.2 J4.A25(PETP2)
P3E_PESW_M2B_TX2_DN: C1020.1 U34.AB3(TX34_P)
P3E_PESW_M2B_TX2_DP: C1019.1 U34.AB2(TX34_N)
P3E_PESW_M2B_TX3_C_DN: C1022.2 J4.A11(PETN3)
P3E_PESW_M2B_TX3_C_DP: C1021.2 J4.A13(PETP3)
P3E_PESW_M2B_TX3_DN: C1022.1 U34.AC2(TX35_P)
P3E_PESW_M2B_TX3_DP: C1021.1 U34.AC1(TX35_N)
P3E_PESW_M2C_RX0_DN: J36.B41(PERN4) U34.R5(RX28_P)
P3E_PESW_M2C_RX0_DP: J36.B43(PERP4) U34.R4(RX28_N)
P3E_PESW_M2C_RX1_DN: J36.B29(PERN5) U34.T6(RX29_P)
P3E_PESW_M2C_RX1_DP: J36.B31(PERP5) U34.T5(RX29_N)
P3E_PESW_M2C_RX2_DN: J36.B17(PERN6) U34.U5(RX30_P)
P3E_PESW_M2C_RX2_DP: J36.B19(PERP6) U34.U4(RX30_N)
P3E_PESW_M2C_RX3_DN: J36.B5(PERN7) U34.V6(RX31_P)
P3E_PESW_M2C_RX3_DP: J36.B7(PERP7) U34.V5(RX31_N)
P3E_PESW_M2C_TX0_C_DN: C432.2 J36.B47(PETN4)
P3E_PESW_M2C_TX0_C_DP: C431.2 J36.B49(PETP4)
P3E_PESW_M2C_TX0_DN: C432.1 U34.R2(TX28_P)
P3E_PESW_M2C_TX0_DP: C431.1 U34.R1(TX28_N)
P3E_PESW_M2C_TX1_C_DN: C434.2 J36.B35(PETN5)
P3E_PESW_M2C_TX1_C_DP: C433.2 J36.B37(PETP5)
P3E_PESW_M2C_TX1_DN: C434.1 U34.T3(TX29_P)
P3E_PESW_M2C_TX1_DP: C433.1 U34.T2(TX29_N)
P3E_PESW_M2C_TX2_C_DN: C436.2 J36.B23(PETN6)
P3E_PESW_M2C_TX2_C_DP: C435.2 J36.B25(PETP6)
P3E_PESW_M2C_TX2_DN: C436.1 U34.U2(TX30_P)
P3E_PESW_M2C_TX2_DP: C435.1 U34.U1(TX30_N)
P3E_PESW_M2C_TX3_C_DN: C438.2 J36.B11(PETN7)
P3E_PESW_M2C_TX3_C_DP: C437.2 J36.B13(PETP7)
P3E_PESW_M2C_TX3_DN: C438.1 U34.V3(TX31_P)
P3E_PESW_M2C_TX3_DP: C437.1 U34.V2(TX31_N)
P3E_PESW_M2D_RX0_DN: J36.A41(PERN0) U34.L5(RX24_P)
P3E_PESW_M2D_RX0_DP: J36.A43(PERP0) U34.L4(RX24_N)
P3E_PESW_M2D_RX1_DN: J36.A29(PERN1) U34.M6(RX25_P)
P3E_PESW_M2D_RX1_DP: J36.A31(PERP1) U34.M5(RX25_N)
P3E_PESW_M2D_RX2_DN: J36.A17(PERN2) U34.N5(RX26_P)
P3E_PESW_M2D_RX2_DP: J36.A19(PERP2) U34.N4(RX26_N)
P3E_PESW_M2D_RX3_DN: J36.A5(PERN3) U34.P6(RX27_P)
P3E_PESW_M2D_RX3_DP: J36.A7(PERP3) U34.P5(RX27_N)
P3E_PESW_M2D_TX0_C_DN: C424.2 J36.A47(PETN0)
P3E_PESW_M2D_TX0_C_DP: C423.2 J36.A49(PETP0)
P3E_PESW_M2D_TX0_DN: C424.1 U34.L2(TX24_P)
P3E_PESW_M2D_TX0_DP: C423.1 U34.L1(TX24_N)
P3E_PESW_M2D_TX1_C_DN: C426.2 J36.A35(PETN1)
P3E_PESW_M2D_TX1_C_DP: C425.2 J36.A37(PETP1)
P3E_PESW_M2D_TX1_DN: C426.1 U34.M3(TX25_P)
P3E_PESW_M2D_TX1_DP: C425.1 U34.M2(TX25_N)
P3E_PESW_M2D_TX2_C_DN: C428.2 J36.A23(PETN2)
P3E_PESW_M2D_TX2_C_DP: C427.2 J36.A25(PETP2)
P3E_PESW_M2D_TX2_DN: C428.1 U34.N2(TX26_P)
P3E_PESW_M2D_TX2_DP: C427.1 U34.N1(TX26_N)
P3E_PESW_M2D_TX3_C_DN: C430.2 J36.A11(PETN3)
P3E_PESW_M2D_TX3_C_DP: C429.2 J36.A13(PETP3)
P3E_PESW_M2D_TX3_DN: C430.1 U34.P3(TX27_P)
P3E_PESW_M2D_TX3_DP: C429.1 U34.P2(TX27_N)
P3E_PESW_M2E_RX0_DN: J38.B41(PERN4) U34.E11(RX12_P)
P3E_PESW_M2E_RX0_DP: J38.B43(PERP4) U34.D11(RX12_N)
P3E_PESW_M2E_RX1_DN: J38.B29(PERN5) U34.F10(RX13_P)
P3E_PESW_M2E_RX1_DP: J38.B31(PERP5) U34.E10(RX13_N)
P3E_PESW_M2E_RX2_DN: J38.B17(PERN6) U34.E9(RX14_P)
P3E_PESW_M2E_RX2_DP: J38.B19(PERP6) U34.D9(RX14_N)
P3E_PESW_M2E_RX3_DN: J38.B5(PERN7) U34.F8(RX15_P)
P3E_PESW_M2E_RX3_DP: J38.B7(PERP7) U34.E8(RX15_N)
P3E_PESW_M2E_TX0_C_DN: C905.2 J38.B47(PETN4)
P3E_PESW_M2E_TX0_C_DP: C904.2 J38.B49(PETP4)
P3E_PESW_M2E_TX0_DN: C905.1 U34.B11(TX12_P)
P3E_PESW_M2E_TX0_DP: C904.1 U34.A11(TX12_N)
P3E_PESW_M2E_TX1_C_DN: C875.2 J38.B35(PETN5)
P3E_PESW_M2E_TX1_C_DP: C906.2 J38.B37(PETP5)
P3E_PESW_M2E_TX1_DN: C875.1 U34.C10(TX13_P)
P3E_PESW_M2E_TX1_DP: C906.1 U34.B10(TX13_N)
P3E_PESW_M2E_TX2_C_DN: C877.2 J38.B23(PETN6)
P3E_PESW_M2E_TX2_C_DP: C876.2 J38.B25(PETP6)
P3E_PESW_M2E_TX2_DN: C877.1 U34.B9(TX14_P)
P3E_PESW_M2E_TX2_DP: C876.1 U34.A9(TX14_N)
P3E_PESW_M2E_TX3_C_DN: C879.2 J38.B11(PETN7)
P3E_PESW_M2E_TX3_C_DP: C878.2 J38.B13(PETP7)
P3E_PESW_M2E_TX3_DN: C879.1 U34.C8(TX15_P)
P3E_PESW_M2E_TX3_DP: C878.1 U34.B8(TX15_N)
P3E_PESW_M2F_RX0_DN: J38.A41(PERN0) U34.E15(RX8_P)
P3E_PESW_M2F_RX0_DP: J38.A43(PERP0) U34.D15(RX8_N)
P3E_PESW_M2F_RX1_DN: J38.A29(PERN1) U34.F14(RX9_P)
P3E_PESW_M2F_RX1_DP: J38.A31(PERP1) U34.E14(RX9_N)
P3E_PESW_M2F_RX2_DN: J38.A17(PERN2) U34.E13(RX10_P)
P3E_PESW_M2F_RX2_DP: J38.A19(PERP2) U34.D13(RX10_N)
P3E_PESW_M2F_RX3_DN: J38.A5(PERN3) U34.F12(RX11_P)
P3E_PESW_M2F_RX3_DP: J38.A7(PERP3) U34.E12(RX11_N)
P3E_PESW_M2F_TX0_C_DN: C897.2 J38.A47(PETN0)
P3E_PESW_M2F_TX0_C_DP: C896.2 J38.A49(PETP0)
P3E_PESW_M2F_TX0_DN: C897.1 U34.B15(TX8_P)
P3E_PESW_M2F_TX0_DP: C896.1 U34.A15(TX8_N)
P3E_PESW_M2F_TX1_C_DN: C899.2 J38.A35(PETN1)
P3E_PESW_M2F_TX1_C_DP: C898.2 J38.A37(PETP1)
P3E_PESW_M2F_TX1_DN: C899.1 U34.C14(TX9_P)
P3E_PESW_M2F_TX1_DP: C898.1 U34.B14(TX9_N)
P3E_PESW_M2F_TX2_C_DN: C901.2 J38.A23(PETN2)
P3E_PESW_M2F_TX2_C_DP: C900.2 J38.A25(PETP2)
P3E_PESW_M2F_TX2_DN: C901.1 U34.B13(TX10_P)
P3E_PESW_M2F_TX2_DP: C900.1 U34.A13(TX10_N)
P3E_PESW_M2F_TX3_C_DN: C903.2 J38.A11(PETN3)
P3E_PESW_M2F_TX3_C_DP: C902.2 J38.A13(PETP3)
P3E_PESW_M2F_TX3_DN: C903.1 U34.C12(TX11_P)
P3E_PESW_M2F_TX3_DP: C902.1 U34.B12(TX11_N)
P3E_PESW_M2G_RX0_DN: J8.B41(PERN4) U34.E21(RX3_N)
P3E_PESW_M2G_RX0_DP: J8.B43(PERP4) U34.F21(RX3_P)
P3E_PESW_M2G_RX1_DN: J8.B29(PERN5) U34.D22(RX2_N)
P3E_PESW_M2G_RX1_DP: J8.B31(PERP5) U34.E22(RX2_P)
P3E_PESW_M2G_RX2_DN: J8.B17(PERN6) U34.E23(RX1_N)
P3E_PESW_M2G_RX2_DP: J8.B19(PERP6) U34.F23(RX1_P)
P3E_PESW_M2G_RX3_DN: J8.B5(PERN7) U34.D24(RX0_N)
P3E_PESW_M2G_RX3_DP: J8.B7(PERP7) U34.E24(RX0_P)
P3E_PESW_M2G_TX0_C_DN: C886.2 J8.B47(PETN4)
P3E_PESW_M2G_TX0_C_DP: C887.2 J8.B49(PETP4)
P3E_PESW_M2G_TX0_DN: C886.1 U34.B21(TX3_N)
P3E_PESW_M2G_TX0_DP: C887.1 U34.C21(TX3_P)
P3E_PESW_M2G_TX1_C_DN: C884.2 J8.B35(PETN5)
P3E_PESW_M2G_TX1_C_DP: C885.2 J8.B37(PETP5)
P3E_PESW_M2G_TX1_DN: C884.1 U34.A22(TX2_N)
P3E_PESW_M2G_TX1_DP: C885.1 U34.B22(TX2_P)
P3E_PESW_M2G_TX2_C_DN: C882.2 J8.B23(PETN6)
P3E_PESW_M2G_TX2_C_DP: C883.2 J8.B25(PETP6)
P3E_PESW_M2G_TX2_DN: C882.1 U34.B23(TX1_N)
P3E_PESW_M2G_TX2_DP: C883.1 U34.C23(TX1_P)
P3E_PESW_M2G_TX3_C_DN: C880.2 J8.B11(PETN7)
P3E_PESW_M2G_TX3_C_DP: C881.2 J8.B13(PETP7)
P3E_PESW_M2G_TX3_DN: C880.1 U34.A24(TX0_N)
P3E_PESW_M2G_TX3_DP: C881.1 U34.B24(TX0_P)
P3E_PESW_M2H_RX0_DN: J8.A41(PERN0) U34.E17(RX7_N)
P3E_PESW_M2H_RX0_DP: J8.A43(PERP0) U34.F17(RX7_P)
P3E_PESW_M2H_RX1_DN: J8.A29(PERN1) U34.D18(RX6_N)
P3E_PESW_M2H_RX1_DP: J8.A31(PERP1) U34.E18(RX6_P)
P3E_PESW_M2H_RX2_DN: J8.A17(PERN2) U34.E19(RX5_N)
P3E_PESW_M2H_RX2_DP: J8.A19(PERP2) U34.F19(RX5_P)
P3E_PESW_M2H_RX3_DN: J8.A5(PERN3) U34.D20(RX4_N)
P3E_PESW_M2H_RX3_DP: J8.A7(PERP3) U34.E20(RX4_P)
P3E_PESW_M2H_TX0_C_DN: C894.2 J8.A47(PETN0)
P3E_PESW_M2H_TX0_C_DP: C895.2 J8.A49(PETP0)
P3E_PESW_M2H_TX0_DN: C894.1 U34.B17(TX7_N)
P3E_PESW_M2H_TX0_DP: C895.1 U34.C17(TX7_P)
P3E_PESW_M2H_TX1_C_DN: C892.2 J8.A35(PETN1)
P3E_PESW_M2H_TX1_C_DP: C893.2 J8.A37(PETP1)
P3E_PESW_M2H_TX1_DN: C892.1 U34.A18(TX6_N)
P3E_PESW_M2H_TX1_DP: C893.1 U34.B18(TX6_P)
P3E_PESW_M2H_TX2_C_DN: C890.2 J8.A23(PETN2)
P3E_PESW_M2H_TX2_C_DP: C891.2 J8.A25(PETP2)
P3E_PESW_M2H_TX2_DN: C890.1 U34.B19(TX5_N)
P3E_PESW_M2H_TX2_DP: C891.1 U34.C19(TX5_P)
P3E_PESW_M2H_TX3_C_DN: C888.2 J8.A11(PETN3)
P3E_PESW_M2H_TX3_C_DP: C889.2 J8.A13(PETP3)
P3E_PESW_M2H_TX3_DN: C888.1 U34.A20(TX4_N)
P3E_PESW_M2H_TX3_DP: C889.1 U34.B20(TX4_P)
P3E_PESW_M2I_RX0_DN: J34.B41(PERN4) U34.E5(RX19_N)
P3E_PESW_M2I_RX0_DP: J34.B43(PERP4) U34.E6(RX19_P)
P3E_PESW_M2I_RX1_DN: J34.B29(PERN5) U34.D4(RX18_N)
P3E_PESW_M2I_RX1_DP: J34.B31(PERP5) U34.D5(RX18_P)
P3E_PESW_M2I_RX2_DN: J34.B17(PERN6) U34.C5(RX17_N)
P3E_PESW_M2I_RX2_DP: J34.B19(PERP6) U34.C6(RX17_P)
P3E_PESW_M2I_RX3_DN: J34.B5(PERN7) U34.B4(RX16_N)
P3E_PESW_M2I_RX3_DP: J34.B7(PERP7) U34.B5(RX16_P)
P3E_PESW_M2I_TX0_C_DN: C413.2 J34.B47(PETN4)
P3E_PESW_M2I_TX0_C_DP: C414.2 J34.B49(PETP4)
P3E_PESW_M2I_TX0_DN: C413.1 U34.E2(TX19_N)
P3E_PESW_M2I_TX0_DP: C414.1 U34.E3(TX19_P)
P3E_PESW_M2I_TX1_C_DN: C411.2 J34.B35(PETN5)
P3E_PESW_M2I_TX1_C_DP: C412.2 J34.B37(PETP5)
P3E_PESW_M2I_TX1_DN: C411.1 U34.D1(TX18_N)
P3E_PESW_M2I_TX1_DP: C412.1 U34.D2(TX18_P)
P3E_PESW_M2I_TX2_C_DN: C409.2 J34.B23(PETN6)
P3E_PESW_M2I_TX2_C_DP: C410.2 J34.B25(PETP6)
P3E_PESW_M2I_TX2_DN: C409.1 U34.C2(TX17_N)
P3E_PESW_M2I_TX2_DP: C410.1 U34.C3(TX17_P)
P3E_PESW_M2I_TX3_C_DN: C439.2 J34.B11(PETN7)
P3E_PESW_M2I_TX3_C_DP: C440.2 J34.B13(PETP7)
P3E_PESW_M2I_TX3_DN: C439.1 U34.B1(TX16_N)
P3E_PESW_M2I_TX3_DP: C440.1 U34.B2(TX16_P)
P3E_PESW_M2J_RX0_DN: J34.A41(PERN0) U34.J5(RX23_N)
P3E_PESW_M2J_RX0_DP: J34.A43(PERP0) U34.J6(RX23_P)
P3E_PESW_M2J_RX1_DN: J34.A29(PERN1) U34.H4(RX22_N)
P3E_PESW_M2J_RX1_DP: J34.A31(PERP1) U34.H5(RX22_P)
P3E_PESW_M2J_RX2_DN: J34.A17(PERN2) U34.G5(RX21_N)
P3E_PESW_M2J_RX2_DP: J34.A19(PERP2) U34.G6(RX21_P)
P3E_PESW_M2J_RX3_DN: J34.A5(PERN3) U34.F4(RX20_N)
P3E_PESW_M2J_RX3_DP: J34.A7(PERP3) U34.F5(RX20_P)
P3E_PESW_M2J_TX0_C_DN: C421.2 J34.A47(PETN0)
P3E_PESW_M2J_TX0_C_DP: C422.2 J34.A49(PETP0)
P3E_PESW_M2J_TX0_DN: C421.1 U34.J2(TX23_N)
P3E_PESW_M2J_TX0_DP: C422.1 U34.J3(TX23_P)
P3E_PESW_M2J_TX1_C_DN: C419.2 J34.A35(PETN1)
P3E_PESW_M2J_TX1_C_DP: C420.2 J34.A37(PETP1)
P3E_PESW_M2J_TX1_DN: C419.1 U34.H1(TX22_N)
P3E_PESW_M2J_TX1_DP: C420.1 U34.H2(TX22_P)
P3E_PESW_M2J_TX2_C_DN: C417.2 J34.A23(PETN2)
P3E_PESW_M2J_TX2_C_DP: C418.2 J34.A25(PETP2)
P3E_PESW_M2J_TX2_DN: C417.1 U34.G2(TX21_N)
P3E_PESW_M2J_TX2_DP: C418.1 U34.G3(TX21_P)
P3E_PESW_M2J_TX3_C_DN: C415.2 J34.A11(PETN3)
P3E_PESW_M2J_TX3_C_DP: C416.2 J34.A13(PETP3)
P3E_PESW_M2J_TX3_DN: C415.1 U34.F1(TX20_N)
P3E_PESW_M2J_TX3_DP: C416.1 U34.F2(TX20_P)
P3E_PESW_M2K_RX0_DN: J6.B41(PERN4) U34.AM4(RX43_N)
P3E_PESW_M2K_RX0_DP: J6.B43(PERP4) U34.AM5(RX43_P)
P3E_PESW_M2K_RX1_DN: J6.B29(PERN5) U34.AL5(RX42_N)
P3E_PESW_M2K_RX1_DP: J6.B31(PERP5) U34.AL6(RX42_P)
P3E_PESW_M2K_RX2_DN: J6.B17(PERN6) U34.AK4(RX41_N)
P3E_PESW_M2K_RX2_DP: J6.B19(PERP6) U34.AK5(RX41_P)
P3E_PESW_M2K_RX3_DN: J6.B5(PERN7) U34.AJ5(RX40_N)
P3E_PESW_M2K_RX3_DP: J6.B7(PERP7) U34.AJ6(RX40_P)
P3E_PESW_M2K_TX0_C_DN: C1037.2 J6.B47(PETN4)
P3E_PESW_M2K_TX0_C_DP: C1038.2 J6.B49(PETP4)
P3E_PESW_M2K_TX0_DN: C1037.1 U34.AM1(TX43_N)
P3E_PESW_M2K_TX0_DP: C1038.1 U34.AM2(TX43_P)
P3E_PESW_M2K_TX1_C_DN: C1035.2 J6.B35(PETN5)
P3E_PESW_M2K_TX1_C_DP: C1036.2 J6.B37(PETP5)
P3E_PESW_M2K_TX1_DN: C1035.1 U34.AL2(TX42_N)
P3E_PESW_M2K_TX1_DP: C1036.1 U34.AL3(TX42_P)
P3E_PESW_M2K_TX2_C_DN: C1033.2 J6.B23(PETN6)
P3E_PESW_M2K_TX2_C_DP: C1034.2 J6.B25(PETP6)
P3E_PESW_M2K_TX2_DN: C1033.1 U34.AK1(TX41_N)
P3E_PESW_M2K_TX2_DP: C1034.1 U34.AK2(TX41_P)
P3E_PESW_M2K_TX3_C_DN: C1031.2 J6.B11(PETN7)
P3E_PESW_M2K_TX3_C_DP: C1032.2 J6.B13(PETP7)
P3E_PESW_M2K_TX3_DN: C1031.1 U34.AJ2(TX40_N)
P3E_PESW_M2K_TX3_DP: C1032.1 U34.AJ3(TX40_P)
P3E_PESW_M2L_RX0_DN: J6.A41(PERN0) U34.AT4(RX47_N)
P3E_PESW_M2L_RX0_DP: J6.A43(PERP0) U34.AT5(RX47_P)
P3E_PESW_M2L_RX1_DN: J6.A29(PERN1) U34.AR5(RX46_N)
P3E_PESW_M2L_RX1_DP: J6.A31(PERP1) U34.AR6(RX46_P)
P3E_PESW_M2L_RX2_DN: J6.A17(PERN2) U34.AP4(RX45_N)
P3E_PESW_M2L_RX2_DP: J6.A19(PERP2) U34.AP5(RX45_P)
P3E_PESW_M2L_RX3_DN: J6.A5(PERN3) U34.AN5(RX44_N)
P3E_PESW_M2L_RX3_DP: J6.A7(PERP3) U34.AN6(RX44_P)
P3E_PESW_M2L_TX0_C_DN: C1013.2 J6.A47(PETN0)
P3E_PESW_M2L_TX0_C_DP: C1014.2 J6.A49(PETP0)
P3E_PESW_M2L_TX0_DN: C1013.1 U34.AT1(TX47_N)
P3E_PESW_M2L_TX0_DP: C1014.1 U34.AT2(TX47_P)
P3E_PESW_M2L_TX1_C_DN: C1011.2 J6.A35(PETN1)
P3E_PESW_M2L_TX1_C_DP: C1012.2 J6.A37(PETP1)
P3E_PESW_M2L_TX1_DN: C1011.1 U34.AR2(TX46_N)
P3E_PESW_M2L_TX1_DP: C1012.1 U34.AR3(TX46_P)
P3E_PESW_M2L_TX2_C_DN: C1041.2 J6.A23(PETN2)
P3E_PESW_M2L_TX2_C_DP: C1010.2 J6.A25(PETP2)
P3E_PESW_M2L_TX2_DN: C1041.1 U34.AP1(TX45_N)
P3E_PESW_M2L_TX2_DP: C1010.1 U34.AP2(TX45_P)
P3E_PESW_M2L_TX3_C_DN: C1039.2 J6.A11(PETN3)
P3E_PESW_M2L_TX3_C_DP: C1040.2 J6.A13(PETP3)
P3E_PESW_M2L_TX3_DN: C1039.1 U34.AN2(TX44_N)
P3E_PESW_M2L_TX3_DP: C1040.1 U34.AN3(TX44_P)
PD_BOOTSTRAP_1: R3136.1 R3159.2 U34.W35(GPIO_97)
PD_BOOTSTRAP_2: R3137.1 R3158.2 U34.W34(GPIO_98)
PD_BOOTSTRAP_4: R3139.1 R3156.2 U34.Y34(GPIO_100)
PD_BOOTSTRAP_5: R3140.1 R3155.2 U34.W36(GPIO_101)
PD_BOOTSTRAP_6: R3142.1 R3154.2 U34.W27(GPIO_102)
PD_BOOTSTRAP_7: R3143.1 R3153.2 U34.W31(GPIO_103)
PD_BOOTSTRAP_8: R3144.1 R3152.2 U34.Y28(GPIO_104)
PD_BOOTSTRAP_9: R3145.1 R3151.2 U34.Y27(GPIO_105)
PD_DB1200_SMB_SA0: R2963.2 R2969.1 U47.11(VSADR0_TRI)
PD_DB1200_SMB_SA1: R2970.2 R2971.1 U47.14(VSADR1_TRI)
PD_EEPROM_A0: R3128.2 R3132.1 U56.1(E0)
PD_EEPROM_A1: R3127.2 R3131.1 U56.2(E1)
PD_EEPROM_A2: R3126.2 R3130.1 U56.3(E2)
PD_EEPROM_WC_N: R3125.2 R3129.1 U56.7(WC_N)
PD_FRU_WC_N: R15.2 U6.7(W\C\)
PD_I2C_GPIO_A0: R4158.2 U101.18(A0)
PD_I2C_GPIO_A1: R4161.2 U101.23(A1)
PD_I2C_GPIO_A2: R4162.2 U101.24(A2)
PD_I2C_MUX1_A0: R3806.1 U88.2(A0)
PD_I2C_MUX1_A1: R3807.1 U88.13(A1)
PD_I2C_MUX2_A0: R3819.1 U89.2(A0)
PD_I2C_MUX2_A1: R3820.1 U89.13(A1)
PD_I2C_MUX3_A0: R3832.1 U90.2(A0)
PD_I2C_MUX3_A1: R3833.1 U90.13(A1)
PD_I2C_MUX4_A0: R3845.1 U91.2(A0)
PD_I2C_MUX4_A1: R3846.1 U91.13(A1)
PD_I2C_MUX5_A0: R3858.1 U92.2(A0)
PD_I2C_MUX5_A1: R3859.1 U92.13(A1)
PD_I2C_MUX6_A0: R3871.1 U93.2(A0)
PD_I2C_MUX6_A1: R3872.1 U93.13(A1)
PD_I2C_MUX7_A0: R4369.1 U108.2(A0)
PD_I2C_MUX7_A1: R4370.1 U108.13(A1)
PD_INA230_A0: R3.1 U2.2(A0)
PD_INA230_A1: R4.1 U2.1(A1)
PD_M2A_PWRDIS: J4.B6(NC3) R4099.2 R4100.1
PD_M2B_PWRDIS: J4.A6(PWRDIS) R4103.2 R4104.1
PD_M2C_PWRDIS: J36.B6(NC3) R4107.2 R4108.1
PD_M2D_PWRDIS: J36.A6(PWRDIS) R4111.2 R4112.1
PD_M2E_PWRDIS: J38.B6(NC3) R4115.2 R4116.1
PD_M2F_PWRDIS: J38.A6(PWRDIS) R4119.2 R4120.1
PD_M2G_PWRDIS: J8.B6(NC3) R4123.2 R4124.1
PD_M2H_PWRDIS: J8.A6(PWRDIS) R4127.2 R4128.1
PD_M2I_PWRDIS: J34.B6(NC3) R4131.2 R4132.1
PD_M2J_PWRDIS: J34.A6(PWRDIS) R4135.2 R4136.1
PD_M2K_PWRDIS: J6.B6(NC3) R4139.2 R4140.1
PD_M2L_PWRDIS: J6.A6(PWRDIS) R4143.2 R4144.1
PD_PESW_THERM_BASS: R3282.2 U34.J29(THERM_BASE)
PD_PESW_THERM_EMIT: R3281.2 U34.J30(THERM_EMIT)
PD_PESW_VSS_AH31: R3005.2 U34.AH31(VSS_AH31)
PD_PESW_VSS_J28: R2910.1 U34.J28(VSS_J28)
PD_PESW_VSS_P27: R3004.2 U34.P27(VSS_P27)
PD_TPIN: R3257.2 U34.R29(TPIN)
PD_UART_PESW_UCTSB: R3256.2 U34.T27(UART_UCTSB)
PD_ZL30281_AC0: R3230.2 R3231.1 U61.28(AC0)
PD_ZL30281_AC1: R3232.2 R3233.1 U61.27(AC1)
PD_ZL30281_IF1: R3236.2 R3237.1 U61.1(IF1||MISO)
PD_ZL30281_TEST: R3240.1 U61.26(TEST)
PU_25M_BMC_CLK_EN_R: OSC1.1(OE) R3765.2
PU_BOOTSTRAP_0: R3141.1 R3160.2 U34.V34(GPIO_96)
PU_BOOTSTRAP_3: R3138.1 R3157.2 U34.W37(GPIO_99)
PU_BOOTSTRAP_10: R3146.1 R3150.2 U34.AA27(GPIO_106)
PU_CPLD_JTAGENB: R4274.1 U94.C10(PT20C|JTAGENB)
PU_CPLD_PROGRAMN: R3923.1 U94.B10(PT20D|PROGRAMN)
PU_CPLD_SN: R3922.1 U94.R12(PB25A|SN)
PU_DB1200_100M: R2964.1 R2967.2 U47.4(^100M_133M#)
PU_DB1200_HI_BW: R2966.1 R2968.2 U47.5(^HIBW_BYPM_LOBW#)
PU_I2C_MUX1_SC2: R3301.2 U88.10(SC2)
PU_I2C_MUX1_SC3: R2799.2 U88.12(SC3)
PU_I2C_MUX1_SD2: R3302.2 U88.9(SD2)
PU_I2C_MUX1_SD3: R2800.2 U88.11(SD3)
PU_I2C_MUX2_SC2: R3825.2 U89.10(SC2)
PU_I2C_MUX2_SC3: R3822.2 U89.12(SC3)
PU_I2C_MUX2_SD2: R3824.2 U89.9(SD2)
PU_I2C_MUX2_SD3: R3823.2 U89.11(SD3)
PU_I2C_MUX3_SC2: R3838.2 U90.10(SC2)
PU_I2C_MUX3_SC3: R3835.2 U90.12(SC3)
PU_I2C_MUX3_SD2: R3837.2 U90.9(SD2)
PU_I2C_MUX3_SD3: R3836.2 U90.11(SD3)
PU_I2C_MUX4_SC2: R3851.2 U91.10(SC2)
PU_I2C_MUX4_SC3: R3848.2 U91.12(SC3)
PU_I2C_MUX4_SD2: R3850.2 U91.9(SD2)
PU_I2C_MUX4_SD3: R3849.2 U91.11(SD3)
PU_I2C_MUX5_SC2: R3864.2 U92.10(SC2)
PU_I2C_MUX5_SC3: R3861.2 U92.12(SC3)
PU_I2C_MUX5_SD2: R3863.2 U92.9(SD2)
PU_I2C_MUX5_SD3: R3862.2 U92.11(SD3)
PU_I2C_MUX6_SC2: R3877.2 U93.10(SC2)
PU_I2C_MUX6_SC3: R3874.2 U93.12(SC3)
PU_I2C_MUX6_SD2: R3876.2 U93.9(SD2)
PU_I2C_MUX6_SD3: R3875.2 U93.11(SD3)
PU_I2C_MUX7_SC3: R4372.2 U108.12(SC3)
PU_I2C_MUX7_SD3: R4373.2 U108.11(SD3)
PU_INA231_M2A_A0: R3619.2 U73.B3(A0)
PU_INA231_M2A_A1: R3622.2 U73.C3(A1)
PU_INA231_M2B_A0: R3713.2 U74.B3(A0)
PU_INA231_M2B_A1: R3630.2 U74.C3(A1)
PU_INA231_M2C_A0: R3634.2 U75.B3(A0)
PU_INA231_M2C_A1: R3728.2 U75.C3(A1)
PU_INA231_M2D_A0: R3730.2 U76.B3(A0)
PU_INA231_M2D_A1: R3729.2 U76.C3(A1)
PU_INA231_M2E_A0: R3731.2 U77.B3(A0)
PU_INA231_M2E_A1: R3651.2 U77.C3(A1)
PU_INA231_M2F_A0: R3732.2 U78.B3(A0)
PU_INA231_M2F_A1: R3658.2 U78.C3(A1)
PU_INA231_M2G_A0: R3726.2 U84.B3(A0)
PU_INA231_M2G_A1: R3727.2 U84.C3(A1)
PU_INA231_M2H_A0: R3719.2 U83.B3(A0)
PU_INA231_M2H_A1: R3720.2 U83.C3(A1)
PU_INA231_M2I_A0: R3711.2 U82.B3(A0)
PU_INA231_M2I_A1: R3712.2 U82.C3(A1)
PU_INA231_M2J_A0: R3704.2 U81.B3(A0)
PU_INA231_M2J_A1: R3705.2 U81.C3(A1)
PU_INA231_M2K_A0: R3697.2 U80.B3(A0)
PU_INA231_M2K_A1: R3698.2 U80.C3(A1)
PU_INA231_M2L_A0: R3678.2 U79.B3(A0)
PU_INA231_M2L_A1: R3691.2 U79.C3(A1)
PU_M2A_CLKREQ_N: J4.B52(NC20) R2777.1
PU_M2A_PLA_S3_N: J4.B30(NC9) R4262.1
PU_M2A_VIO_1V8: J4.B22(GND16) R4234.2
PU_M2B_CLKREQ_N: J4.A52(CLKREQ#) R2774.1
PU_M2B_PLA_S3_N: J4.A30(PLA_S3#) R4263.1
PU_M2B_VIO_1V8: J4.A22(VIO_1V8) R4236.2
PU_M2C_CLKREQ_N: J36.B52(NC20) R2894.1
PU_M2C_PLA_S3_N: J36.B30(NC9) R4264.1
PU_M2C_VIO_1V8: J36.B22(GND16) R4238.2
PU_M2D_CLKREQ_N: J36.A52(CLKREQ#) R2891.1
PU_M2D_PLA_S3_N: J36.A30(PLA_S3#) R4265.1
PU_M2D_VIO_1V8: J36.A22(VIO_1V8) R4240.2
PU_M2E_CLKREQ_N: J38.B52(NC20) R2900.1
PU_M2E_PLA_S3_N: J38.B30(NC9) R4266.1
PU_M2E_VIO_1V8: J38.B22(GND16) R4242.2
PU_M2F_CLKREQ_N: J38.A52(CLKREQ#) R2897.1
PU_M2F_PLA_S3_N: J38.A30(PLA_S3#) R4267.1
PU_M2F_VIO_1V8: J38.A22(VIO_1V8) R4244.2
PU_M2G_CLKREQ_N: J8.B52(NC20) R2789.1
PU_M2G_PLA_S3_N: J8.B30(NC9) R4268.1
PU_M2G_VIO_1V8: J8.B22(GND16) R4246.2
PU_M2H_CLKREQ_N: J8.A52(CLKREQ#) R2786.1
PU_M2H_PLA_S3_N: J8.A30(PLA_S3#) R4269.1
PU_M2H_VIO_1V8: J8.A22(VIO_1V8) R4248.2
PU_M2I_CLKREQ_N: J34.B52(NC20) R2888.1
PU_M2I_PLA_S3_N: J34.B30(NC9) R4270.1
PU_M2I_VIO_1V8: J34.B22(GND16) R4250.2
PU_M2J_CLKREQ_N: J34.A52(CLKREQ#) R2885.1
PU_M2J_VIO_1V8: J34.A22(VIO_1V8) R4252.2
PU_M2K_CLKREQ_N: J6.B52(NC20) R2783.1
PU_M2K_PLA_S3_N: J6.B30(NC9) R4272.1
PU_M2K_VIO_1V8: J6.B22(GND16) R4254.2
PU_M2L_CLKREQ_N: J6.A52(CLKREQ#) R2780.1
PU_M2L_PLA_S3_N: J6.A30(PLA_S3#) R4273.1
PU_M2L_VIO_1V8: J6.A22(VIO_1V8) R4256.2
PU_P3V3_STBY_Q50_G: Q50.G Q51.D R4290.2
PU_PESW_AVS_ENB: R3285.1 U34.H31(AVS_ENB)
PU_PESW_MULTI_CONFIG_ADD0: C1111.1 Q38.G(GATE) R3746.1
PU_PESW_MULTI_CONFIG_ADD1: C1112.1 Q39.G(GATE) R3750.1
PU_PESW_MULTI_CONFIG_ADD2: C1113.1 Q40.G(GATE) R3754.1
PU_PESW_MULTI_CONFIG_ADD3: C1178.1 Q42.G(GATE) R4066.1
PU_PESW_MULTI_CONFIG_ADD4: C1179.1 Q43.G(GATE) R4070.1
PU_REMOTE_DEBUG_SELECT: R4097.2 SW5.A
PU_TAP_SEL: R3147.1 R3149.2 U34.AG30(TAP_SEL)
PU_TXS_OE: R3278.2 U66.6(OE)
PU_ZL30281_IF0: R3234.2 R3235.1 U61.32(IF0||CSN)
PWRGD_CLK_ZL30281: R3218.1 U61.4(READY) U62.2(IN_B)
PWRGD_GPV2_SYS: R4387.2 U86.A13(PQ4|DIVSCLK)
PWRGD_P0V92: C1228.1 PR307.2 PU301.10(PG) U62.1(IN_A)
PWRGD_P1V8: D4.5(ENABLE) PR701.2 PU7.5(PG) R4289.1 R4292.2 U61.30(RSTN) U106.5(ENABLE)
PWRGD_P1V8_R: Q51.G R4292.1
PWRGD_P3V3_M2A: R3994.2 U86.A11(PN2|U1DCD)
PWRGD_P3V3_M2A_R: R3535.1 R3994.1 U19.8(PG)
PWRGD_P3V3_M2B: R3995.2 U86.B10(PN3|U1DSR)
PWRGD_P3V3_M2B_R: R3536.1 R3995.1 U20.8(PG)
PWRGD_P3V3_M2C: R3996.2 U86.A10(PN4|U1DTR)
PWRGD_P3V3_M2C_R: R3537.1 R3996.1 U21.8(PG)
PWRGD_P3V3_M2D: R3997.2 U86.B9(PN5|U1RI)
PWRGD_P3V3_M2D_R: R3538.1 R3997.1 U22.8(PG)
PWRGD_P3V3_M2E: R3998.2 U86.C10(PN0|U1RTS)
PWRGD_P3V3_M2E_R: R3539.1 R3998.1 U23.8(PG)
PWRGD_P3V3_M2F: R3999.2 U86.C8(PJ0|PECIVTT)
PWRGD_P3V3_M2F_R: R3540.1 R3999.1 U24.8(PG)
PWRGD_P3V3_M2G: R4005.2 U86.E7(PJ1|PECI0SD)
PWRGD_P3V3_M2G_R: R3546.1 R4005.1 U33.8(PG)
PWRGD_P3V3_M2H: R4004.2 U86.D6(PP0|SGPMCLK)
PWRGD_P3V3_M2H_R: R3545.1 R4004.1 U32.8(PG)
PWRGD_P3V3_M2I: R4003.2 U86.D7(PP1|SGPMLD)
PWRGD_P3V3_M2I_R: R3544.1 R4003.1 U31.8(PG)
PWRGD_P3V3_M2J: R4002.2 U86.A7(PE6|SGPMO)
PWRGD_P3V3_M2J_R: R3543.1 R4002.1 U30.8(PG)
PWRGD_P3V3_M2K: R4001.2 U86.G15(PM5|SGPMI)
PWRGD_P3V3_M2K_R: R3542.1 R4001.1 U29.8(PG)
PWRGD_P3V3_M2L: R4000.2 U86.V10(PT1|GPIOPT1)
PWRGD_P3V3_M2L_R: R3541.1 R4000.1 U28.8(PG)
PWRGD_P3V3_STBY: PR107.2 PU101.10(PG) PU201.10(PG) PU601.10(PG) R3474.1 R3551.1
RESERVED_M2A_PLN_N: J4.B8(NC4) R4098.2 R4101.1
RESERVED_M2B_PLN_N: J4.A8(PLN#) R4102.2 R4105.1
RESERVED_M2C_PLN_N: J36.B8(NC4) R4106.2 R4109.1
RESERVED_M2D_PLN_N: J36.A8(PLN#) R4110.2 R4113.1
RESERVED_M2E_PLN_N: J38.B8(NC4) R4114.2 R4117.1
RESERVED_M2F_PLN_N: J38.A8(PLN#) R4118.2 R4121.1
RESERVED_M2G_PLN_N: J8.B8(NC4) R4122.2 R4125.1
RESERVED_M2H_PLN_N: J8.A8(PLN#) R4126.2 R4129.1
RESERVED_M2I_PLN_N: J34.B8(NC4) R4130.2 R4133.1
RESERVED_M2J_PLN_N: J34.A8(PLN#) R4134.2 R4137.1
RESERVED_M2K_PLN_N: J6.B8(NC4) R4138.2 R4141.1
RESERVED_M2L_PLN_N: J6.A8(PLN#) R4142.2 R4145.1
RST_I2C_MUX1_N: C1134.1 R3808.2 R4028.1 U88.3(RESET#)
RST_I2C_MUX1_N_R: R4028.2 U86.H17(PJ2|GPIOPJ2)
RST_I2C_MUX2_N: C1137.1 R3821.2 R4029.1 U89.3(RESET#)
RST_I2C_MUX2_N_R: R4029.2 U86.F16(PJ3|GPIOPJ3)
RST_I2C_MUX3_N: C1140.1 R3834.2 R4030.1 U90.3(RESET#)
RST_I2C_MUX3_N_R: R4030.2 U86.F18(PJ4|GPIOPJ4)
RST_I2C_MUX4_N: C1143.1 R3847.2 R4031.1 U91.3(RESET#)
RST_I2C_MUX4_N_R: R4031.2 U86.E17(PJ5|GPIOPJ5)
RST_I2C_MUX5_N: C1146.1 R3860.2 R4032.1 U92.3(RESET#)
RST_I2C_MUX5_N_R: R4032.2 U86.N1(PJ6|GPIOPJ6)
RST_I2C_MUX6_N: C1149.1 R3873.2 R4033.1 U93.3(RESET#)
RST_I2C_MUX6_N_R: R4033.2 U86.K5(PJ7|GPIOPJ7)
RST_I2C_MUX7_N: C1235.1 R4371.2 R4382.1 U108.3(RESET#)
RST_I2C_MUX7_N_R: R4382.2 U86.V2(PH7|GPIOPH7)
RST_PE_BUF_N_R2: R3212.2 R4328.2 U63.2(A)
RST_PE_MOS_G: Q9.5(G2) Q9.6(D1) R3216.2
RST_PE_MOS_N_R2: Q9.2(G1) R3213.2 R3217.2
RST_PE_N: R3050.1 R3212.1 R3213.1 R3242.1 U86.E18(PT2|GPIOPT2)
RST_PE_N_R1: J41.34 R3049.2 R3050.2
RST_PE_PESW_GPIO15_N: R3215.2 U34.N30(TWI_SRSTB_7)
RST_PE_PESW_GPIO28_N: R4336.2 U34.L33(TWI_SCL_8)
RST_PE_PESW_GPIO29_N: R4335.2 U34.M28(TWI_SDA_8)
RST_PE_PESW_GPIO30_N: R4334.2 U34.M30(TWI_SRSTB_8)
RST_PE_PESW_GPIO31_N: R4333.2 U34.N28(TWI_SCL_7)
RST_PE_PESW_GPIO35_N: R4332.2 U34.N31(TWI_SDA_7)
RST_PE_PESW_GPIO_N_R: C1236.1 Q9.3(D2) R3148.1 R3215.1 R3242.2 R4332.1 R4333.1 R4334.1 R4335.1 R4336.1
RST_PE_PESW_RSTB_N: R3214.2 U34.AG32(RSTB)
RST_PE_PESW_RSTB_N_R: R3214.1 R3220.1 U63.4(Y)
RST_PE_SLOT1_1_RESET_N: J41.40 R4337.1
RST_PE_SLOT1_1_RESET_N_R: R4337.2 U86.F17(PT3|GPIOPT3)
RST_PESW_M2A_LVC_N: J4.B50(NC19) R4164.2
RST_PESW_M2A_LVC_N_R: R4164.1 R4186.1 U103.2(OUT)
RST_PESW_M2A_N: R3287.2 U103.1(IN)
RST_PESW_M2A_N_R: R3287.1 U34.AE33(GPIO_92)
RST_PESW_M2B_LVC_N: J4.A50(PERST#) R4165.2
RST_PESW_M2B_LVC_N_R: R4165.1 R4187.1 U103.4(OUT)
RST_PESW_M2B_N: R3288.2 U103.3(IN)
RST_PESW_M2B_N_R: R3288.1 U34.AE31(GPIO_93)
RST_PESW_M2C_LVC_N: J36.B50(NC19) R4166.2
RST_PESW_M2C_LVC_N_R: R4166.1 R4182.1 U103.6(OUT)
RST_PESW_M2C_N: R3289.2 U103.5(IN)
RST_PESW_M2C_N_R: R3289.1 U34.U30(GPIO_82)
RST_PESW_M2D_LVC_N: J36.A50(PERST#) R4167.2
RST_PESW_M2D_LVC_N_R: R4167.1 R4183.1 U103.8(OUT)
RST_PESW_M2D_N: R3290.2 U103.9(IN)
RST_PESW_M2D_N_R: R3290.1 U34.AB28(GPIO_83)
RST_PESW_M2E_LVC_N: J38.B50(NC19) R4169.2
RST_PESW_M2E_LVC_N_R: R4169.1 R4184.1 U103.10(OUT)
RST_PESW_M2E_N: R3291.2 U103.11(IN)
RST_PESW_M2E_N_R: R3291.1 U34.AB27(GPIO_84)
RST_PESW_M2F_LVC_N: J38.A50(PERST#) R4173.2
RST_PESW_M2F_LVC_N_R: R4173.1 R4185.1 U103.12(OUT)
RST_PESW_M2F_N: R3292.2 U103.13(IN)
RST_PESW_M2F_N_R: R3292.1 U34.AC31(GPIO_85)
RST_PESW_M2G_LVC_N: J8.B50(NC19) R4168.2
RST_PESW_M2G_LVC_N_R: R4168.1 R4192.1 U102.2(OUT)
RST_PESW_M2G_N: R3293.2 U102.1(IN)
RST_PESW_M2G_N_R: R3293.1 U34.AC28(GPIO_86)
RST_PESW_M2H_LVC_N: J8.A50(PERST#) R4170.2
RST_PESW_M2H_LVC_N_R: R4170.1 R4193.1 U102.4(OUT)
RST_PESW_M2H_N: R3294.2 U102.3(IN)
RST_PESW_M2H_N_R: R3294.1 U34.AC27(GPIO_87)
RST_PESW_M2I_LVC_N: J34.B50(NC19) R4171.2
RST_PESW_M2I_LVC_N_R: R4171.1 R4188.1 U102.6(OUT)
RST_PESW_M2I_N: R3295.2 U102.5(IN)
RST_PESW_M2I_N_R: R3295.1 U34.AD31(GPIO_88)
RST_PESW_M2J_LVC_N: J34.A50(PERST#) R4172.2
RST_PESW_M2J_LVC_N_R: R4172.1 R4189.1 U102.8(OUT)
RST_PESW_M2J_N: R3296.2 U102.9(IN)
RST_PESW_M2J_N_R: R3296.1 U34.AD30(GPIO_89)
RST_PESW_M2K_LVC_N: J6.B50(NC19) R4174.2
RST_PESW_M2K_LVC_N_R: R4174.1 R4190.1 U102.10(OUT)
RST_PESW_M2K_N: R3297.2 U102.11(IN)
RST_PESW_M2K_N_R: R3297.1 U34.AD29(GPIO_90)
RST_PESW_M2L_LVC_N: J6.A50(PERST#) R4175.2
RST_PESW_M2L_LVC_N_R: R4175.1 R4191.1 U102.12(OUT)
RST_PESW_M2L_N: R3298.2 U102.13(IN)
RST_PESW_M2L_N_R: R3298.1 U34.AD27(GPIO_91)
SMB_BIC_3V3SB_READY_N: C1252.1 J41.32 R4035.2
SMB_BIC_3V3SB_READY_N_R: R4035.1 U86.T8(PF6|FAN0PWM5)
SMB_BIC_CPLD_0_CLK: R3989.2 R4363.2
SMB_BIC_CPLD_0_CLK_R1: R3989.1 U94.F8(PT18A)
SMB_BIC_CPLD_0_CLK_R2: R4363.1 R4376.2 U108.5(SC0)
SMB_BIC_CPLD_0_DAT: R3988.2 R4364.2
SMB_BIC_CPLD_0_DAT_R1: R3988.1 U94.D9(PT18B)
SMB_BIC_CPLD_0_DAT_R2: R4364.1 R4377.2 U108.4(SD0)
SMB_BIC_CPLD_1_CLK: R3987.2 R4365.2
SMB_BIC_CPLD_1_CLK_R1: R3987.1 U94.A9(PT18C|SCL_PCLKT0_0)
SMB_BIC_CPLD_1_CLK_R2: R4365.1 R4378.2 U108.7(SC1)
SMB_BIC_CPLD_1_DAT: R3921.2 R4366.2
SMB_BIC_CPLD_1_DAT_R1: R3921.1 U94.C9(PT18D|SDA_PCLKC0_0)
SMB_BIC_CPLD_1_DAT_R2: R4366.1 R4379.2 U108.6(SD1)
SMB_BIC_VR_CLK: R3911.2 R4367.1
SMB_BIC_VR_CLK_R1: R4367.2 U108.14(SCL)
SMB_BIC_VR_CLK_R2: R3911.1 R4051.2 U86.V3(PA0|U0RX)
SMB_BIC_VR_DAT: R3912.2 R4368.1
SMB_BIC_VR_DAT_R1: R4368.2 U108.15(SDA)
SMB_BIC_VR_DAT_R2: R3912.1 R4052.2 U86.W3(PA1|U0TX)
SMB_BMC_3V3SB_CLK: R3044.1 R3783.1
SMB_BMC_3V3SB_CLK_R1: J41.28 R3043.2 R3044.2
SMB_BMC_3V3SB_CLK_R2: R3783.2 U86.D2(PD2|I2C8SCL)
SMB_BMC_3V3SB_DAT: R3045.1 R3784.1
SMB_BMC_3V3SB_DAT_R1: J41.30 R3045.2 R3047.2
SMB_BMC_3V3SB_DAT_R2: R3784.2 U86.D1(PD3|I2C8SDA)
SMB_INA230_ALERT_N: R4034.2 U86.B5(PE5|FAN0PWM7|GPIO)
SMB_INA230_ALERT_N_R: R3046.2 R4034.1 U2.3(ALERT)
SMB_M2A_ALERT_LVC_N: R4194.2 U86.M18(PM4|RMII0-EN0RREF_CLK)
SMB_M2A_ALERT_LVC_N_R: R4194.1 R4210.1 U105.2(OUT)
SMB_M2A_ALERT_N: J4.B44(NC16) R4312.2 U105.1(IN)
SMB_M2A_INA231_ALRT_N: R4016.2 U86.U10(PS6|GPIOPS6)
SMB_M2A_INA231_ALRT_N_R: R3899.1 R4016.1 U73.A3(ALERT)
SMB_M2A_INA231_CLK_R1: R3620.1 U73.A1(SCL)
SMB_M2A_INA231_DAT_R1: R3621.1 U73.A2(SDA)
SMB_M2A_P1V8_CLK: J4.B40(NC14) R3620.2 R3809.2
SMB_M2A_P1V8_CLK_R2: R67.2 R3809.1 U88.5(SC0)
