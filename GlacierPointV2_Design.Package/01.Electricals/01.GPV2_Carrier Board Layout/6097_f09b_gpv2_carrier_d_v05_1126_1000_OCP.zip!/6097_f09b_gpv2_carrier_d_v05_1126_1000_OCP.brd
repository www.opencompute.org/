# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P3E_3_PESW_TX3_DP: length 103.9
  TOP w0.124: U34.AH35 v6(199.59,71.02)
  IN2 w0.099: 199.11,61.92 199.11,61.94 199.15,61.98 199.15,62.49 198.99,62.87 198.99,69.46 199.99,70.46 199.99,70.92 199.89,71.02 v6(199.59,71.02)
  IN2 w0.136: v2(131.62,10.79) 131.99,11.16 131.99,11.86 132.54,13.19 133.59,14.76 140.11,22.71 143.85,31.75 148.97,39.41 155.37,45.8 162.19,48.63 165.45,48.63 172.09,51.38 175.12,54.41 181.32,56.98 182.24,57.9 187,59.87 195.42,59.87 198.7,61.23 199.03,61.56 199.11,61.74 199.11,61.92
  BOTTOM w0.124: v2(131.62,10.79) 131.96,10.45 131.96,10.06 131.7,9.81 J49.89
P3E_4_PESW_RX0_C_DN: length 98.2
  TOP w0.124: v6(194.23,55.58) 194.58,55.93 194.58,56.6 C389.2
  IN1 w0.136: v6(194.23,55.58) 194.6,55.21 194.6,54.55 194.14,53.86 188.82,51.65 181.36,51.65 179.95,51.07 172.26,45.93 169.92,44.96 165.29,44.96 160.14,42.83 154.92,37.61 149.15,30.58 141.85,19.66 141.45,17.66 141.68,17.32 142.35,17.19 142.45,17.04 142.33,16.42 142.18,16.32 141.51,16.45 141.17,16.22 139.95,10.1 139.32,9.58 139.32,9.58 135.17,8.1 128.74,8.1 127.47,7.58 127.19,7.15 127.19,6.76 v2(126.82,6.39)
  BOTTOM w0.124: J49.102 126.9,5.27 127.16,5.53 127.16,6.05 v2(126.82,6.39)
P3E_4_PESW_RX0_C_DP: length 98.2
  TOP w0.124: v6(195.25,55.58) 194.89,55.94 194.89,56.59 C390.2
  IN1 w0.136: v6(195.25,55.58) 194.88,55.21 194.88,54.47 194.32,53.63 188.88,51.38 181.42,51.38 180.08,50.82 172.39,45.68 169.98,44.68 165.34,44.68 160.3,42.59 155.12,37.42 149.37,30.42 142.11,19.55 141.75,17.72 141.85,17.58 142.52,17.44 142.75,17.1 142.58,16.25 142.24,16.02 141.57,16.15 141.42,16.05 140.2,9.94 139.46,9.34 135.22,7.82 128.8,7.82 127.66,7.35 127.47,7.06 127.47,6.76 v2(127.83,6.39)
  BOTTOM w0.124: J49.100 127.7,5.31 127.47,5.54 127.47,6.03 v2(127.83,6.39)
P3E_4_PESW_RX0_DN: length 7.5
  TOP w0.099: 194.59,58.27 194.59,58.3 194.64,58.35 194.64,58.68 195.08,59.12 195.08,59.26 195.22,59.4 195.36,59.4 195.5,59.54 195.5,59.69 195.64,59.83 195.79,59.83 195.93,59.97 195.93,60.11 196.07,60.25 196.21,60.25 196.35,60.39 196.35,60.54 196.49,60.68 196.64,60.68 197.1,61.14 197.49,62.07 197.49,62.82 197.39,62.92 197.19,62.92 197.09,62.82 U34.AU33
  TOP w0.124: 194.59,58.27 194.59,58.1 C389.1
P3E_4_PESW_RX0_DP: length 7.4
  TOP w0.099: 194.89,58.27 194.89,58.3 194.84,58.35 194.84,58.59 196.78,60.53 197.28,61.03 197.69,62.03 197.69,62.9 197.47,63.12 197.19,63.12 197.09,63.22 U34.AT33
  TOP w0.124: C390.1 194.89,58.1 194.89,58.27
P3E_4_PESW_RX1_C_DN: length 96.4
  TOP w0.124: C387.2 192.18,56.59 192.18,55.32 v6(191.83,54.97)
  IN1 w0.136: v6(191.83,54.97) 192.19,54.6 192.19,54.36 191.95,54 188.55,52.59 181.14,52.59 179.28,51.81 171.65,46.72 169.65,45.89 165.08,45.89 159.59,43.61 154.28,38.3 148.14,30.83 139.14,17.35 138.16,14.98 136.61,9.87 136.22,9.58 134.93,9.16 127.55,9.16 124.41,7.86 123.96,7.19 123.96,6.76 v2(123.59,6.39)
  BOTTOM w0.124: J49.110 123.7,5.38 123.95,5.63 123.95,6.04 v2(123.59,6.39)
P3E_4_PESW_RX1_C_DP: length 96.4
  TOP w0.124: C388.2 192.49,56.59 192.49,55.32 v6(192.84,54.97)
  IN1 w0.136: v2(124.61,6.39) 124.24,6.76 124.24,7.1 124.59,7.63 127.6,8.88 134.98,8.88 136.35,9.33 136.85,9.7 138.42,14.89 139.39,17.22 148.37,30.66 151.43,34.38 154.48,38.11 159.75,43.38 165.13,45.61 169.7,45.61 171.78,46.47 179.41,51.57 181.2,52.31 188.6,52.31 192.14,53.77 192.47,54.27 192.47,54.6 v6(192.84,54.97)
  BOTTOM w0.124: J49.108 124.5,5.35 124.25,5.6 124.25,6.04 v2(124.61,6.39)
P3E_4_PESW_RX1_DN: length 9.5
  TOP w0.099: U34.AT32 196.09,63.82 196.19,63.92 196.39,63.92 196.49,63.82 196.49,63.03 196.39,62.93 196.39,62.73 196.49,62.63 196.49,62.43 196.39,62.33 196.39,62.13 196.49,62.03 196.49,61.85 196.4,61.64 195.86,61.1 195.72,61.1 195.58,60.96 195.58,60.82 194.82,60.06 193.09,59.35 192.66,58.92 192.59,58.92 192.57,58.9
  TOP w0.124: C387.1 192.18,58.1 192.18,58.51 192.57,58.9
P3E_4_PESW_RX1_DP: length 9.5
  TOP w0.099: 192.79,58.68 192.81,58.7 192.81,58.77 193.21,59.17 194.94,59.89 196.57,61.53 196.69,61.81 196.69,63.9 196.47,64.12 196.19,64.12 196.09,64.22 U34.AR32
  TOP w0.124: C388.1 192.49,58.1 192.49,58.38 192.79,58.68
P3E_4_PESW_RX2_C_DN: length 96.7
  TOP w0.124: v6(189.38,55.27) 189.73,55.63 189.73,56.61 C385.2
  IN1 w0.136: v6(189.38,55.27) 189.75,54.9 189.75,54.62 189.51,54.27 187.7,53.52 180.97,53.52 178.62,52.55 171.07,47.5 169.54,46.87 165.04,46.87 159.05,44.39 153.47,38.81 150.41,35.08 147.34,31.34 137.85,17.13 135.74,15.73 135.66,15.32 136.3,14.37 136.26,14.2 135.73,13.84 135.56,13.88 134.92,14.83 134.52,14.91 130.71,12.37 130.34,12.29 129.22,12.07 126.73,11.04 123.81,9.09 121.29,8.04 120.76,7.24 120.76,6.76 v2(120.39,6.39)
  BOTTOM w0.124: J49.118 120.5,5.4 120.75,5.65 120.75,6.04 v2(120.39,6.39)
P3E_4_PESW_RX2_C_DP: length 96.7
  TOP w0.124: v6(190.39,55.27) 190.04,55.63 190.04,56.61 C386.2
  IN1 w0.136: v2(121.41,6.39) 121.04,6.76 121.04,7.16 121.48,7.82 123.94,8.84 126.86,10.79 129.31,11.8 130.82,12.1 134.58,14.61 134.75,14.58 135.39,13.63 135.79,13.54 136.51,14.03 136.59,14.43 135.96,15.38 135.99,15.56 138.05,16.93 147.57,31.17 153.68,38.62 159.21,44.15 165.09,46.59 169.59,46.59 171.2,47.26 178.75,52.3 181.03,53.25 187.76,53.25 189.7,54.05 190.03,54.54 190.03,54.9 v6(190.39,55.27)
  BOTTOM w0.124: v2(121.41,6.39) 121.05,6.04 121.05,5.67 121.3,5.42 J49.116
P3E_4_PESW_RX2_DN: length 10.2
  TOP w0.099: 190.27,59.63 190.29,59.65 190.36,59.65 190.93,60.22 191.75,60.55 192.25,60.55 192.35,60.66 192.55,60.66 192.65,60.55 193.6,60.55 194.42,60.89 194.64,61.11 194.64,61.26 194.78,61.4 194.92,61.4 195.06,61.54 195.06,61.68 195.2,61.82 195.35,61.82 195.49,61.96 195.49,62.82 195.39,62.92 195.19,62.92 195.09,62.82 U34.AU31
  TOP w0.124: C385.1 189.73,58.13 189.73,59.09 190.27,59.63
P3E_4_PESW_RX2_DP: length 10.2
  TOP w0.099: U34.AT31 195.09,63.22 195.19,63.12 195.47,63.12 195.69,62.9 195.69,61.88 194.54,60.72 193.64,60.35 191.79,60.35 191.05,60.04 190.51,59.5 190.51,59.43 190.49,59.41
  TOP w0.124: 190.49,59.41 190.04,58.96 190.04,58.13 C386.1
P3E_4_PESW_RX3_C_DN: length 95.5
  TOP w0.124: C383.2 187.43,56.61 187.43,55.7 v6(187.08,55.35)
  IN1 w0.136: v6(187.08,55.35) 187.45,54.98 187.45,54.76 187.16,54.47 180.81,54.47 178.1,53.35 170.5,48.27 169.4,47.82 164.85,47.82 158.41,45.15 153,39.74 146.19,31.44 137,17.69 133.67,15.47 130.34,13.24 128.41,12.86 127.07,12.3 120.16,10.93 119.61,10.56 117.56,7.5 117.56,6.79 v2(117.19,6.42)
  BOTTOM w0.124: J49.126 117.3,5.41 117.55,5.66 117.55,6.06 v2(117.19,6.42)
P3E_4_PESW_RX3_C_DP: length 95.5
  TOP w0.124: C384.2 187.74,56.61 187.74,55.7 v6(188.1,55.35)
  IN1 w0.136: v6(188.1,55.35) 187.73,54.98 187.73,54.65 187.27,54.19 180.86,54.19 178.23,53.1 170.63,48.02 169.46,47.54 164.9,47.54 158.57,44.91 153.21,39.55 146.41,31.27 137.2,17.49 130.45,12.98 128.49,12.59 127.15,12.03 120.27,10.67 119.81,10.35 117.84,7.41 117.84,6.79 v2(118.21,6.42)
  BOTTOM w0.124: J49.124 118.1,5.41 117.85,5.66 117.85,6.06 v2(118.21,6.42)
P3E_4_PESW_RX3_DN: length 12.1
  TOP w0.099: 190.1,61.38 190.12,61.4 190.19,61.4 190.35,61.57 190.62,61.57 190.72,61.67 190.92,61.67 191.02,61.57 191.93,61.57 192.04,61.67 192.23,61.67 192.34,61.57 192.53,61.57 192.64,61.67 192.83,61.67 192.93,61.57 193.7,61.57 193.98,61.76 194.49,62.98 194.49,63.82 194.39,63.92 194.19,63.92 194.09,63.82 U34.AT30
  TOP w0.124: C383.1 187.43,58.13 187.43,58.72 190.1,61.38
P3E_4_PESW_RX3_DP: length 12.1
  TOP w0.099: 190.31,61.17 190.33,61.19 190.33,61.26 190.44,61.36 193.76,61.36 194.15,61.62 194.69,62.94 194.69,63.9 194.47,64.12 194.19,64.12 194.09,64.22 U34.AR30
  TOP w0.124: 190.31,61.17 187.74,58.59 187.74,58.13 C384.1
P3E_4_PESW_TX0_DN: length 101.3
  TOP w0.124: U34.AP33 v6(197.59,65.02)
  IN1 w0.099: v6(197.59,65.02) 197.59,65.34 197.49,65.44 197.29,65.44 197.19,65.33 197.19,63.49 197.23,63.46 197.23,63.43
  IN1 w0.136: 197.23,63.43 197.23,59.94 197.18,59.9 196.84,59.39 196.88,59.2 197.3,58.91 197.39,58.5 196.91,57.79 196.49,57.7 196.07,57.99 195.88,57.95 195.32,57.11 192.91,56.11 185.61,56.11 180.71,55.14 177.63,53.86 170.12,48.84 169.69,48.66 169.23,48.48 164.66,48.48 158.08,45.75 152.2,39.87 145.4,31.58 136.88,18.82 135.44,17.81 134.6,17.6 134.51,17.46 134.12,17.36 133.98,17.45 133.39,17.3 132.61,16.98 132.55,16.83 132.17,16.67 132.02,16.74 131.65,16.58 131.58,16.43 131.21,16.27 131.06,16.34 130.68,16.18 130.52,15.93 130.52,15.61 v2(130.89,15.24)
  BOTTOM w0.124: v2(130.89,15.24) 130.53,14.88 130.53,14.19 129.05,10.62 129.05,10.04 129.3,9.79 J49.95
P3E_4_PESW_TX0_DP: length 101.3
  TOP w0.124: U34.AN33 v6(197.59,66.02)
  IN1 w0.099: 196.95,63.43 196.95,63.46 196.99,63.49 196.99,65.42 197.21,65.64 197.49,65.64 197.59,65.74 v6(197.59,66.02)
  IN1 w0.136: v2(129.87,15.24) 130.24,15.61 130.24,16.02 130.5,16.41 133.3,17.56 135.32,18.07 136.67,19.02 145.17,31.75 151.99,40.05 157.92,45.99 164.61,48.76 169.18,48.76 169.99,49.09 177.5,54.11 180.63,55.41 185.58,56.39 192.86,56.39 195.14,57.34 195.71,58.2 196.13,58.28 196.55,58 196.74,58.04 197.09,58.56 197.05,58.75 196.63,59.03 196.54,59.45 196.95,60.05 196.95,63.43
  BOTTOM w0.124: J49.97 128.5,9.81 128.75,10.05 128.75,10.69 130.23,14.25 130.23,14.88 v2(129.87,15.24)
P3E_4_PESW_TX1_DN: length 102.2
  TOP w0.124: U34.AN32 v6(196.59,66.02)
  IN1 w0.099: v6(196.59,66.02) 196.59,66.34 196.49,66.44 196.29,66.44 196.19,66.33 196.19,63.4 196.23,63.36 196.23,63.33
  IN1 w0.136: 196.23,63.33 196.23,60.25 194.67,57.91 192.71,57.1 185.66,57.1 180.55,56.08 177.06,54.64 169.68,49.7 169.33,49.56 168.97,49.41 164.44,49.41 157.55,46.55 151.46,40.47 144.69,32.21 136.2,19.52 135.36,18.92 133.6,18.48 133.51,18.34 133.12,18.24 132.98,18.33 132.14,18.12 131.59,17.89 131.53,17.74 131.15,17.58 131,17.65 130.63,17.49 130.57,17.34 130.19,17.18 130.04,17.25 129.56,17.05 128.57,16.24 127.88,15.2 127.88,14.85 127.88,14.67 v2(128.24,14.3)
  BOTTOM w0.124: J49.103 126.1,9.82 125.85,10.06 125.85,10.47 127.89,13.52 127.89,13.94 v2(128.24,14.3)
P3E_4_PESW_TX1_DP: length 102.2
  TOP w0.124: U34.AM32 v6(196.59,67.02)
  IN1 w0.099: v6(196.59,67.02) 196.59,66.74 196.49,66.64 196.21,66.64 195.99,66.42 195.99,63.4 195.95,63.36 195.95,63.33
  IN1 w0.136: v2(127.23,14.3) 127.6,14.67 127.6,14.85 127.6,15.28 128.36,16.43 129.41,17.29 132.05,18.38 135.24,19.18 136,19.71 144.46,32.38 151.26,40.66 157.39,46.79 160.89,48.24 164.39,49.69 168.91,49.69 169.54,49.95 176.93,54.88 180.47,56.35 185.63,57.38 192.65,57.38 194.48,58.13 195.95,60.33 195.95,63.33
  BOTTOM w0.124: J49.105 125.3,9.81 125.55,10.05 125.55,10.57 127.58,13.61 127.58,13.94 v2(127.23,14.3)
P3E_4_PESW_TX2_DN: length 105.8
  TOP w0.124: U34.AP31 v6(195.59,65.02)
  IN1 w0.099: v6(195.59,65.02) 195.59,65.34 195.49,65.44 195.29,65.44 195.19,65.33 195.19,63.32 195.23,63.29 195.23,63.26
  IN1 w0.136: 195.23,63.26 195.23,60.44 194.1,58.75 192.37,58.03 185.59,58.03 180.28,56.97 176.5,55.41 169.48,50.71 168.56,50.33 164.21,50.33 157.04,47.36 151.08,41.4 146.9,39.67 124.32,24.58 122.46,22.32 121.73,20.55 121.73,18.44 121.86,18.31 121.86,17.9 121.73,17.78 121.73,17.37 121.86,17.24 121.86,16.83 121.73,16.71 121.73,16.3 121.86,16.17 121.86,15.76 121.73,15.64 121.73,14.73 v2(122.1,14.36)
  BOTTOM w0.124: J49.111 122.9,9.82 122.65,10.06 122.65,10.72 121.74,12.91 121.74,14.01 v2(122.1,14.36)
P3E_4_PESW_TX2_DP: length 105.8
  TOP w0.124: U34.AN31 v6(195.59,66.02)
  IN1 w0.099: v6(195.59,66.02) 195.59,65.74 195.49,65.64 195.21,65.64 194.99,65.42 194.99,63.32 194.95,63.29 194.95,63.26
  IN1 w0.136: v2(121.08,14.36) 121.45,14.73 121.45,20.61 122.22,22.46 124.13,24.79 146.76,39.91 148.84,40.77 150.92,41.64 156.88,47.6 164.16,50.61 168.5,50.61 169.34,50.96 176.37,55.66 180.2,57.24 185.56,58.31 192.31,58.31 193.91,58.97 194.95,60.52 194.95,63.26
  BOTTOM w0.124: v2(121.08,14.36) 121.44,14.01 121.44,12.85 122.35,10.66 122.35,10.05 122.1,9.81 J49.113
P3E_4_PESW_TX3_DN: length 106.6
  TOP w0.124: U34.AN30 v6(194.59,66.02)
  IN1 w0.099: v6(194.59,66.02) 194.59,66.34 194.49,66.44 194.29,66.44 194.19,66.33 194.19,61.46 194.23,61.42 194.23,61.39
  IN1 w0.136: v2(119.81,12.19) 119.45,12.55 119.45,14.07 119.6,14.84 119.75,14.94 119.83,15.34 119.73,15.48 119.81,15.88 119.96,15.98 120.04,16.38 119.94,16.53 120.02,16.93 120.17,17.03 120.25,17.43 120.15,17.58 120.8,20.86 121.57,22.71 123.69,25.3 146.52,40.55 150.59,42.24 156.49,48.13 164.02,51.26 168.35,51.26 168.69,51.4 168.69,51.4 169.01,51.53 176.12,56.28 180.04,57.91 185.58,59.01 192.03,59.01 193.41,59.58 194.23,60.8 194.23,61.39
  BOTTOM w0.124: v2(119.81,12.19) 119.45,11.84 119.45,10.06 119.7,9.82 J49.119
P3E_4_PESW_TX3_DP: length 106.6
  TOP w0.124: U34.AM30 v6(194.59,67.02)
  IN1 w0.099: 193.95,61.39 193.95,61.42 193.99,61.46 193.99,66.42 194.21,66.64 194.49,66.64 194.59,66.74 v6(194.59,67.02)
  IN1 w0.136: 193.95,61.39 193.95,60.89 193.22,59.8 191.97,59.29 185.55,59.29 179.96,58.18 175.99,56.53 168.88,51.78 168.29,51.53 163.97,51.53 156.33,48.37 150.43,42.47 146.39,40.8 123.5,25.51 121.33,22.85 120.93,21.89 120.53,20.94 119.18,14.12 119.17,14.12 119.17,12.57 v2(118.79,12.19)
  BOTTOM w0.124: J49.121 118.9,9.81 119.15,10.05 119.15,11.84 v2(118.79,12.19)
P3E_5_PESW_RX0_C_DN: length 103.6
  TOP w0.124: v2(115.01,6.42) 114.65,6.77 114.65,12.17 v2(115.01,12.52)
  BOTTOM w0.124: C381.2 192.42,56.29 191.92,56.29 191.25,56.01 181.91,56.01 174.38,52.89 171.38,49.9 158.33,44.49 150.07,36.22 141.3,32.59 134.83,31.3 125.52,27.45 125.1,27.03 125.1,26.78 124.83,26.51 124.58,26.51 124.32,26.25 124.32,26 124.06,25.73 123.8,25.73 123.54,25.47 123.54,25.22 123.28,24.95 123.02,24.95 119.8,21.73 115.19,14.82 114.65,13.54 114.65,12.88 v2(115.01,12.52) ; J49.132 114.9,5.42 114.65,5.67 114.65,6.06 v2(115.01,6.42)
P3E_5_PESW_RX0_C_DP: length 103.6
  TOP w0.124: v2(113.99,6.42) 114.35,6.77 114.35,12.17 v2(113.99,12.52)
  BOTTOM w0.124: v2(113.99,6.42) 114.35,6.06 114.35,5.66 114.1,5.41 J49.134 ; v2(113.99,12.52) 114.35,12.88 114.35,13.6 114.92,14.97 119.57,21.93 125.35,27.71 134.74,31.6 141.21,32.89 149.89,36.48 158.16,44.75 171.21,50.16 174.2,53.15 181.85,56.31 191.19,56.31 191.86,56.59 192.46,56.59 C382.2
P3E_5_PESW_RX0_DN: length 9.4
  TOP w0.124: U34.AU29 v6(193.59,62.02)
  BOTTOM w0.099: 193.24,61.39 193.24,61.42 193.19,61.47 193.19,62.32 193.29,62.42 193.49,62.42 193.59,62.32 v6(193.59,62.02)
  BOTTOM w0.124: C381.1 193.95,56.27 194.56,56.27 195.07,56.78 195.07,57.44 193.9,60.27 193.24,60.93 193.24,61.39
P3E_5_PESW_RX0_DP: length 9.4
  TOP w0.124: U34.AT29 v6(193.59,63.02)
  BOTTOM w0.099: v6(193.59,63.02) 193.59,62.72 193.49,62.62 193.21,62.62 192.99,62.4 192.99,61.47 192.94,61.42 192.94,61.39
  BOTTOM w0.124: 192.94,61.39 192.94,60.8 193.64,60.1 194.24,58.66 194.15,58.44 194.31,58.06 194.52,57.97 194.69,57.55 194.77,57.37 194.77,56.9 194.44,56.57 193.95,56.57 C382.1
P3E_5_PESW_RX1_C_DN: length 103.8
  TOP w0.124: v2(111.81,6.42) 111.45,6.77 111.45,12.09 v2(111.81,12.45)
  BOTTOM w0.124: C379.2 189.51,57.61 189.14,57.61 188.18,57.21 181.23,57.21 174.03,54.23 170.71,50.91 157.53,45.45 149.39,37.31 140.9,33.79 134.59,32.54 124.8,28.48 118.48,22.16 116.33,18.95 114.62,17.23 114.62,16.98 114.35,16.72 114.1,16.72 113.84,16.46 113.84,16.2 113.57,15.94 113.32,15.94 113.06,15.68 113.06,15.42 112.8,15.16 112.54,15.16 112.13,14.75 111.45,13.11 111.45,12.8 v2(111.81,12.45) ; v2(111.81,6.42) 111.45,6.06 111.45,5.66 111.7,5.41 J49.140
P3E_5_PESW_RX1_C_DP: length 103.8
  TOP w0.124: v2(110.79,6.42) 111.15,6.77 111.15,12.09 v2(110.79,12.45)
  BOTTOM w0.124: v2(110.79,12.45) 111.15,12.8 111.15,13.17 111.87,14.92 116.09,19.14 118.24,22.36 124.62,28.74 134.5,32.83 140.81,34.09 149.22,37.57 157.36,45.71 170.54,51.17 173.86,54.49 181.17,57.52 188.12,57.52 189.08,57.91 189.58,57.91 C380.2 ; J49.142 110.9,5.41 111.15,5.66 111.15,6.06 v2(110.79,6.42)
P3E_5_PESW_RX1_DN: length 8.4
  TOP w0.124: U34.AT28 v6(192.59,63.02)
  BOTTOM w0.099: v6(192.59,63.02) 192.59,63.32 192.49,63.42 192.29,63.42 192.19,63.32 192.19,61.47 192.24,61.42 192.24,61.39
  BOTTOM w0.124: C379.1 191.06,57.58 191.49,57.58 191.92,58.01 192.24,58.79 192.24,61.39
P3E_5_PESW_RX1_DP: length 8.4
  TOP w0.124: U34.AR28 v6(192.59,64.02)
  BOTTOM w0.099: v6(192.59,64.02) 192.59,63.72 192.49,63.63 192.21,63.63 191.99,63.41 191.99,61.47 191.94,61.42 191.94,61.39
  BOTTOM w0.124: C380.1 191.05,57.89 191.36,57.89 191.66,58.18 191.94,58.85 191.94,59.23 191.76,59.4 191.76,59.78 191.94,59.96 191.94,61.39
P3E_5_PESW_RX2_C_DN: length 106.5
  TOP w0.124: v2(108.61,12.6) 108.25,12.24 108.25,6.77 v2(108.61,6.41)
  BOTTOM w0.124: v2(108.61,12.6) 108.25,12.95 108.25,13.54 109.2,14.96 109.66,15.34 109.84,15.32 110.1,15 110.52,14.96 111.23,15.54 111.27,15.97 111.01,16.29 111.03,16.46 115.82,20.39 118.02,23.69 123.7,29.37 134.82,33.97 140.93,35.19 148.73,38.42 156.74,46.43 170.06,51.94 174.05,55.93 177.48,57.35 177.68,57.27 178.02,57.42 178.1,57.61 178.45,57.75 178.64,57.67 178.98,57.81 179.06,58.01 179.41,58.15 179.6,58.07 179.95,58.21 180.02,58.41 180.37,58.55 180.56,58.47 180.91,58.61 180.99,58.8 181.61,59.06 187.57,59.06 C377.2 ; J49.148 108.5,5.22 108.25,5.47 108.25,6.06 v2(108.61,6.41)
P3E_5_PESW_RX2_C_DP: length 106.5
  TOP w0.124: v2(107.59,6.41) 107.95,6.77 107.95,12.24 v2(107.59,12.6)
  BOTTOM w0.124: v2(107.59,12.6) 107.95,12.95 107.95,13.63 108.98,15.17 109.57,15.65 109.99,15.61 110.25,15.29 110.43,15.28 110.94,15.7 110.96,15.87 110.7,16.19 110.74,16.62 115.59,20.6 117.79,23.88 123.53,29.62 134.73,34.26 140.84,35.48 148.56,38.68 156.57,46.68 169.89,52.2 173.87,56.19 181.55,59.37 187.51,59.37 C378.2 ; v2(107.59,6.41) 107.95,6.06 107.95,5.48 107.7,5.23 J49.150
P3E_5_PESW_RX2_DN: length 6.4
  TOP w0.124: U34.AU27 v6(191.59,62.02)
  BOTTOM w0.099: v6(191.59,62.02) 191.59,62.32 191.49,62.42 191.29,62.42 191.19,62.32 191.19,61.47 191.24,61.42 191.24,61.39
  BOTTOM w0.124: C377.1 189.05,59.08 189.48,59.08 191.24,60.84 191.24,61.39
P3E_5_PESW_RX2_DP: length 6.4
  TOP w0.124: U34.AT27 v6(191.59,63.02)
  BOTTOM w0.099: 190.94,61.39 190.94,61.42 190.99,61.47 190.99,62.4 191.21,62.62 191.49,62.62 191.59,62.72 v6(191.59,63.02)
  BOTTOM w0.124: 190.94,61.39 190.94,60.97 190.14,60.16 189.88,60.16 189.62,59.9 189.62,59.65 189.36,59.39 189.06,59.39 C378.1
P3E_5_PESW_RX3_C_DN: length 106.5
  TOP w0.124: v2(105.41,11.91) 105.05,11.56 105.05,6.77 v2(105.41,6.41)
  BOTTOM w0.124: v2(105.41,6.41) 105.05,6.06 105.05,5.5 105.3,5.25 J49.156 ; v2(105.41,11.91) 105.05,12.27 105.05,12.69 105.66,13.6 114.8,21.1 117.05,24.47 123.16,30.57 134.76,35.38 141.16,36.66 148.17,39.56 156.03,47.43 169.22,52.89 173.51,57.18 176.5,58.42 176.72,58.33 177.06,58.47 177.15,58.69 177.49,58.83 177.67,58.75 178.02,58.9 178.09,59.08 178.44,59.22 178.62,59.15 178.96,59.29 179.04,59.47 179.38,59.61 179.56,59.54 179.91,59.68 179.98,59.86 181.72,60.58 185.56,60.58 C407.2
P3E_5_PESW_RX3_C_DP: length 106.5
  TOP w0.124: v2(104.39,6.41) 104.75,6.77 104.75,11.56 v2(104.39,11.91)
  BOTTOM w0.124: v2(104.39,11.91) 104.75,12.27 104.75,12.78 105.44,13.81 114.57,21.31 116.81,24.66 122.98,30.83 134.68,35.68 141.08,36.95 147.99,39.81 155.86,47.68 169.05,53.14 173.34,57.44 181.6,60.86 181.62,60.88 185.56,60.88 C408.2 ; v2(104.39,6.41) 104.75,6.06 104.75,5.51 104.5,5.26 J49.158
P3E_5_PESW_RX3_DN: length 7.1
  TOP w0.124: U34.AT26 v6(190.59,63.02)
  BOTTOM w0.099: 189.26,61.21 189.28,61.21 189.33,61.26 189.74,61.26 190.19,61.71 190.19,63.32 190.29,63.42 190.49,63.42 190.59,63.32 v6(190.59,63.02)
  BOTTOM w0.124: C407.1 187.07,60.58 187.47,60.58 189,61.21 189.26,61.21
P3E_5_PESW_RX3_DP: length 7.1
  TOP w0.124: U34.AR26 v6(190.59,64.02)
  BOTTOM w0.099: 189.26,61.52 189.28,61.52 189.33,61.47 189.66,61.47 189.99,61.8 189.99,63.4 190.21,63.62 190.49,63.62 190.59,63.72 v6(190.59,64.02)
  BOTTOM w0.124: 189.26,61.52 188.94,61.52 187.41,60.88 187.07,60.88 C408.1
P3E_5_PESW_TX0_DN: length 107.7
  TOP w0.124: U34.AP29 v6(193.59,65.02)
  IN1 w0.099: v6(193.59,65.02) 193.59,65.35 193.49,65.45 193.29,65.45 193.19,65.35 193.19,61.56 193.23,61.53 193.23,61.5
  IN1 w0.136: 193.23,61.5 193.23,61.08 192.69,60.28 191.86,59.94 184.85,59.94 180.23,59.02 175.77,57.17 168.72,52.46 168.09,52.2 161.83,52.2 160.24,51.54 158.81,50.11 155.19,48.61 149.54,42.96 146.69,41.78 122.92,25.89 120.83,23.35 119.23,19.49 118.85,19.33 118.42,19.51 118.25,19.44 118.01,18.86 118.08,18.69 118.51,18.51 118.67,18.13 117.2,14.59 117.28,14.41 117.12,14.03 116.94,13.96 116.79,13.58 116.86,13.4 116.71,13.02 116.52,12.94 116.25,12.29 116.25,11.17 v2(116.63,10.79)
  BOTTOM w0.124: J49.127 116.5,9.79 116.26,10.03 116.26,10.42 v2(116.63,10.79)
P3E_5_PESW_TX0_DP: length 107.7
  TOP w0.124: U34.AN29 v6(193.59,66.02)
  IN1 w0.099: 192.95,61.5 192.95,61.53 192.99,61.56 192.99,65.44 193.21,65.66 193.49,65.66 193.59,65.76 v6(193.59,66.02)
  IN1 w0.136: 192.95,61.5 192.95,61.17 192.51,60.51 191.81,60.22 184.82,60.22 180.15,59.29 175.64,57.42 168.59,52.71 168.04,52.48 161.77,52.48 160.09,51.78 160.05,51.74 158.65,50.34 155.03,48.85 149.38,43.19 146.56,42.02 122.73,26.1 120.59,23.5 119.02,19.7 118.85,19.63 118.42,19.81 118.04,19.66 117.71,18.86 117.86,18.48 118.3,18.3 118.37,18.13 116.31,13.16 115.97,12.35 115.97,11.15 v2(115.62,10.79)
  BOTTOM w0.124: J49.129 115.7,9.81 115.96,10.06 115.96,10.45 v2(115.62,10.79)
P3E_5_PESW_TX1_DN: length 108.5
  TOP w0.124: U34.AN28 v6(192.59,66.02)
  IN1 w0.099: 192.23,61.59 192.23,61.61 192.19,61.65 192.19,66.32 192.29,66.42 192.49,66.42 192.59,66.32 v6(192.59,66.02)
  IN1 w0.136: v2(113.43,10.79) 113.08,11.15 113.08,12.48 114.47,15.85 114.81,16.36 114.99,16.39 115.22,16.73 115.18,16.92 115.41,17.26 115.59,17.29 115.82,17.63 115.78,17.81 116.01,18.15 116.19,18.19 116.42,18.53 116.38,18.71 120.34,24.64 122.55,26.85 146.58,42.9 149.08,43.94 154.64,49.49 158.05,50.9 159.44,52.3 161.44,53.12 167.83,53.12 168.38,53.35 175.37,58.02 180.15,60 184.48,60.86 191.66,60.86 192.06,61.03 192.23,61.28 192.23,61.59
  BOTTOM w0.124: v2(113.43,10.79) 113.06,10.42 113.06,10.03 113.3,9.79 J49.135
P3E_5_PESW_TX1_DP: length 108.5
  TOP w0.124: U34.AM28 v6(192.59,67.02)
  IN1 w0.099: 191.95,61.59 191.95,61.61 191.99,61.65 191.99,66.41 192.21,66.63 192.49,66.63 192.59,66.73 v6(192.59,67.02)
  IN1 w0.136: 191.95,61.59 191.95,61.37 191.87,61.25 191.6,61.14 184.45,61.14 180.07,60.27 175.24,58.27 168.24,53.6 167.78,53.4 161.38,53.4 159.28,52.53 157.89,51.14 154.48,49.73 148.92,44.17 146.44,43.15 122.37,27.06 120.12,24.82 114.23,15.99 112.8,12.54 112.8,11.17 v2(112.42,10.79)
  BOTTOM w0.124: J49.137 112.5,9.8 112.76,10.06 112.76,10.45 v2(112.42,10.79)
P3E_5_PESW_TX2_DN: length 108.8
  TOP w0.124: U34.AP27 v6(191.59,65.02)
  IN1 w0.099: 183.67,63.46 183.69,63.47 183.69,63.53 184.11,63.94 184.11,65.16 184.37,65.42 191.49,65.42 191.59,65.32 v6(191.59,65.02)
  IN1 w0.136: v2(110.23,10.79) 109.85,11.17 109.85,12.34 110.7,14.39 110.96,14.71 111.16,14.73 111.42,15.04 111.4,15.24 111.66,15.56 111.85,15.58 112.11,15.89 112.09,16.09 112.35,16.4 112.55,16.42 112.81,16.74 112.79,16.93 113.37,17.64 113.62,17.67 113.9,17.44 114.31,17.48 114.86,18.15 114.82,18.56 114.5,18.82 114.48,19 120.33,26.12 121.97,27.61 146.7,44.13 152.27,49.71 156.28,51.37 161.63,56.72 165.27,58.23 172.57,58.23 182.6,62.38 183.67,63.46
  BOTTOM w0.124: v2(110.23,10.79) 109.86,10.42 109.86,10.03 110.1,9.79 J49.143
P3E_5_PESW_TX2_DP: length 108.8
  TOP w0.124: U34.AN27 v6(191.59,66.02)
  IN1 w0.099: 183.48,63.65 183.49,63.67 183.55,63.67 183.9,64.03 183.9,65.24 184.28,65.62 191.47,65.62 191.59,65.74 v6(191.59,66.02)
  IN1 w0.136: 183.48,63.65 182.44,62.61 172.52,58.51 165.21,58.51 161.47,56.96 156.12,51.6 152.11,49.94 146.52,44.35 121.8,27.83 120.13,26.32 114.19,19.09 114.23,18.68 114.55,18.41 114.57,18.24 114.17,17.74 113.99,17.73 113.71,17.96 113.23,17.91 110.46,14.54 109.57,12.4 109.57,11.15 v2(109.22,10.79)
  BOTTOM w0.124: v2(109.22,10.79) 109.56,10.45 109.56,10.06 109.3,9.81 J49.145
P3E_5_PESW_TX3_DN: length 109.8
  TOP w0.124: U34.AN26 v6(190.59,66.02)
  IN1 w0.099: 180.15,63.38 180.17,63.38 180.21,63.42 180.79,63.42 182.8,64.25 183.25,64.7 183.25,65.72 183.95,66.42 190.49,66.42 190.59,66.32 v6(190.59,66.02)
  IN1 w0.136: 180.15,63.38 179.97,63.38 179.76,63.24 179.59,62.83 178.4,61.65 172.44,59.18 164.97,59.18 161.04,57.55 155.61,52.12 151.72,50.51 146.02,44.81 121.32,28.3 119.64,26.86 111.13,17.46 110.23,16.57 110.23,16.37 109.94,16.08 109.75,16.08 109.46,15.79 109.46,15.6 109.17,15.31 108.98,15.31 108.69,15.02 108.69,14.83 108.4,14.54 108.21,14.54 107.92,14.25 107.92,14.06 107.63,13.77 107.44,13.77 107.1,13.44 106.67,12.38 106.67,11.16 v2(107.03,10.79)
  BOTTOM w0.124: J49.151 106.9,9.79 106.66,10.03 106.66,10.42 v2(107.03,10.79)
P3E_5_PESW_TX3_DP: length 109.8
  TOP w0.124: U34.AM26 v6(190.59,67.02)
  IN1 w0.099: 180.15,63.66 180.17,63.66 180.21,63.62 180.75,63.62 182.69,64.43 183.05,64.79 183.05,65.8 183.87,66.62 190.49,66.62 190.59,66.72 v6(190.59,67.02)
  IN1 w0.136: 180.15,63.66 179.88,63.66 179.53,63.43 179.35,62.99 178.25,61.88 172.38,59.46 164.91,59.46 160.89,57.79 155.45,52.36 151.57,50.75 145.84,45.02 121.15,28.52 119.45,27.06 110.92,17.65 106.87,13.6 106.39,12.44 106.39,11.16 v2(106.02,10.79)
  BOTTOM w0.124: J49.153 106.1,9.8 106.36,10.06 106.36,10.45 v2(106.02,10.79)
P3E_6_PESW_RX0_C_DN: length 97.3
  IN1 w0.136: v2(157.2,12.65) 156.83,12.28 156.83,10.31 155.63,8.5 153.52,7.63 153.04,6.91 153.04,6.57 v2(153.41,6.2)
  BOTTOM w0.124: C405.2 205.01,65.1 205.01,59.59 204.03,57.25 202.15,55.36 200.83,54.82 197.55,51.53 194.48,50.26 180.91,50.26 176.91,48.61 174.13,45.83 161.08,40.42 158.7,38.04 154.96,29 154.96,20.45 156.84,15.9 156.84,13.01 v2(157.2,12.65) ; v2(153.41,6.2) 153.05,5.84 153.05,5.66 153.3,5.41 J49.36
P3E_6_PESW_RX0_C_DP: length 97.4
  IN1 w0.136: v2(152.39,6.2) 152.76,6.57 152.76,7 153.33,7.86 155.44,8.73 156.56,10.4 156.56,12.28 v2(156.19,12.65)
  BOTTOM w0.124: C406.2 204.7,65.08 204.7,59.65 203.77,57.42 201.98,55.62 200.66,55.08 197.38,51.79 194.42,50.57 180.85,50.57 176.74,48.86 173.96,46.08 160.91,40.68 158.45,38.21 154.65,29.06 154.65,20.39 156.54,15.84 156.54,13 v2(156.19,12.65) ; J49.38 152.5,5.39 152.75,5.64 152.75,5.84 v2(152.39,6.2)
P3E_6_PESW_RX0_DN: length 6.9
  TOP w0.124: U34.AK37 v6(201.59,69.02)
  BOTTOM w0.099: v6(201.59,69.02) 201.29,69.02 201.19,68.92 201.19,68.72 201.29,68.62 202.67,68.62 203.68,67.61 204.59,67.61 204.95,67.25 204.95,66.65 C405.1
P3E_6_PESW_RX0_DP: length 6.9
  TOP w0.124: U34.AK36 v6(200.59,69.02)
  BOTTOM w0.099: C406.1 204.74,66.66 204.74,67.17 204.5,67.41 203.59,67.41 202.58,68.42 201.21,68.42 200.99,68.64 200.99,68.92 200.89,69.02 v6(200.59,69.02)
P3E_6_PESW_RX1_C_DN: length 96.4
  IN1 w0.136: v2(150.21,6.23) 149.84,6.6 149.84,6.88 150.28,7.55 153.06,8.7 154.15,9.6 154.56,11.66 152.91,15.65 152.91,28.63 154.01,31.28 154.01,31.8 v2(154.38,32.17)
  BOTTOM w0.124: J49.44 150.1,5.17 149.85,5.41 149.85,5.88 v2(150.21,6.23) ; v2(154.38,32.17) 154.02,32.52 154.02,33.13 154.08,33.31 157.69,38.72 160.41,41.44 173.42,46.83 176.19,49.6 180.67,51.46 194.13,51.46 196.95,52.62 200.17,55.84 201.49,56.39 203.02,57.92 203.41,58.84 203.41,63.14 C403.2
P3E_6_PESW_RX1_C_DP: length 96.4
  IN1 w0.136: v2(149.19,6.23) 149.56,6.6 149.56,6.97 150.1,7.77 152.91,8.94 153.9,9.75 154.27,11.64 152.63,15.6 152.63,28.68 153.73,31.34 153.73,31.8 v2(153.36,32.17)
  BOTTOM w0.124: J49.46 149.3,5.16 149.55,5.41 149.55,5.88 v2(149.19,6.23) ; v2(153.36,32.17) 153.72,32.52 153.72,33.18 153.8,33.44 157.45,38.92 160.24,41.7 173.25,47.09 176.02,49.86 180.61,51.76 194.07,51.76 196.77,52.88 200,56.1 201.32,56.65 202.77,58.1 203.1,58.91 203.1,63.14 C404.2
P3E_6_PESW_RX1_DN: length 7
  TOP w0.124: U34.AL36 v6(200.59,68.02)
  BOTTOM w0.099: 202.2,67.44 202.19,67.45 202.11,67.45 201.94,67.62 200.33,67.62 200.23,67.72 200.23,67.92 200.33,68.02 v6(200.59,68.02)
  BOTTOM w0.124: C403.1 203.41,64.65 203.41,65.1 203.29,65.68 202.82,66.82 202.2,67.44
P3E_6_PESW_RX1_DP: length 7
  TOP w0.124: U34.AL35 v6(199.59,68.02)
  BOTTOM w0.099: 201.98,67.23 201.96,67.24 201.96,67.31 201.86,67.42 200.25,67.42 200.03,67.64 200.03,67.88 199.89,68.02 v6(199.59,68.02)
  BOTTOM w0.124: 201.98,67.23 202.56,66.65 203,65.59 203.1,65.07 203.1,64.65 C404.1
P3E_6_PESW_RX2_C_DN: length 92.6
  IN1 w0.136: v2(151.21,29.39) 150.84,29.03 150.84,28.21 151.89,22.93 151.89,15.51 153.13,12.53 152.9,11.38 151.39,9.87 147.5,8.26 146.64,6.97 146.64,6.53 v2(147.01,6.17)
  BOTTOM w0.124: v2(147.01,6.17) 146.65,5.81 146.65,5.45 146.9,5.2 J49.52 ; C401.2 201.21,58.31 201.21,57.96 200.89,57.47 199.55,56.92 196.28,53.65 193.89,52.66 180.39,52.66 175.49,50.63 172.74,47.87 159.77,42.5 156.78,39.51 155.33,37.75 151.4,31.86 150.87,30.58 150.87,29.74 v2(151.21,29.39)
P3E_6_PESW_RX2_C_DP: length 92.6
  IN1 w0.136: v2(150.2,29.39) 150.56,29.03 150.56,28.18 151.61,22.9 151.61,15.46 152.84,12.5 152.65,11.52 151.23,10.1 147.31,8.48 146.36,7.06 146.36,6.53 v2(145.99,6.17)
  BOTTOM w0.124: C402.2 200.9,58.31 200.9,58.05 200.68,57.72 199.38,57.18 196.11,53.91 193.82,52.96 180.33,52.96 175.32,50.89 172.56,48.13 159.59,42.75 156.55,39.71 155.09,37.93 151.13,32 150.57,30.64 150.57,29.76 v2(150.2,29.39) ; J49.54 146.1,5.19 146.34,5.43 146.34,5.81 v2(145.99,6.17)
P3E_6_PESW_RX2_DN: length 8.7
  TOP w0.124: U34.AM37 v6(201.59,67.02)
  BOTTOM w0.124: C401.1 201.21,59.82 201.21,60.93 201.58,61.81 201.58,65.71 201.24,66.52 201.24,66.67 v6(201.59,67.02)
P3E_6_PESW_RX2_DP: length 8.7
  TOP w0.124: U34.AM36 v6(200.59,67.02)
  BOTTOM w0.124: C402.1 200.91,59.83 200.91,60.99 201.27,61.87 201.27,65.65 200.94,66.46 200.94,66.67 v6(200.59,67.02)
P3E_6_PESW_RX3_C_DN: length 92.8
  IN1 w0.136: v2(149.28,26.97) 148.91,26.61 148.91,26.27 148.48,25.24 146.61,23.36 145,19.49 144.69,17.94 144.79,17.79 145.49,17.65 145.72,17.31 145.55,16.46 145.21,16.23 144.51,16.37 144.36,16.27 144.24,15.64 144.34,15.49 145.03,15.36 145.26,15.01 145.09,14.16 144.75,13.93 144.05,14.07 143.91,13.97 143.44,11.63 143.44,6.51 v2(143.81,6.14)
  BOTTOM w0.124: J49.60 143.7,5.25 143.45,5.5 143.45,5.78 v2(143.81,6.14) ; v2(149.28,26.97) 148.93,27.32 148.93,28.65 149.24,30.17 150.31,32.76 150.37,32.89 152.96,36.77 155.81,40.24 159.08,43.51 172.05,48.88 175.05,51.88 179.81,53.85 193.59,53.85 195.64,54.7 198.19,57.25 198.5,58 198.5,58.31 C399.2
P3E_6_PESW_RX3_C_DP: length 92.8
  IN1 w0.136: v2(142.79,6.14) 143.16,6.51 143.16,11.68 143.17,11.68 143.65,14.14 144,14.37 144.69,14.23 144.84,14.33 144.97,14.95 144.87,15.1 144.17,15.24 143.94,15.58 144.11,16.43 144.45,16.66 145.15,16.52 145.3,16.62 145.42,17.25 145.32,17.4 144.63,17.54 144.4,17.88 144.73,19.57 146.37,23.52 148.24,25.39 148.63,26.33 148.63,26.61 v2(148.26,26.97)
  BOTTOM w0.124: v2(148.26,26.97) 148.63,27.34 148.63,28.68 148.94,30.26 150.03,32.89 150.11,33.05 152.72,36.95 155.58,40.44 158.9,43.76 171.88,49.14 174.88,52.14 179.75,54.15 193.53,54.15 195.47,54.96 197.94,57.42 198.2,58.06 198.2,58.31 C400.2 ; J49.62 142.9,5.25 143.15,5.5 143.15,5.78 v2(142.79,6.14)
P3E_6_PESW_RX3_DN: length 8.2
  TOP w0.124: U34.AN36 v6(200.59,66.02)
  BOTTOM w0.124: C399.1 198.5,59.82 198.5,60.25 198.7,60.72 199.99,62.02 200.36,62.9 200.36,65.05 200.24,65.33 200.24,65.67 v6(200.59,66.02)
P3E_6_PESW_RX3_DP: length 8.2
  TOP w0.124: U34.AN35 v6(199.59,66.02)
  BOTTOM w0.124: v6(199.59,66.02) 199.94,65.67 199.94,65.27 200.05,64.99 200.05,62.96 199.74,62.19 198.44,60.89 198.2,60.31 198.2,59.82 C400.1
P3E_6_PESW_TX0_DN: length 112.4
  TOP w0.124: U34.AA37 v6(201.59,78.02)
  IN2 w0.099: v6(201.59,78.02) 201.29,78.02 201.19,77.92 201.19,77.74 201.31,77.62 202.19,77.62 203.64,78.22 205.3,78.22 205.34,78.26 205.36,78.26
  IN2 w0.136: 205.36,78.26 206.4,78.26 206.88,78.06 207.68,77.26 207.9,76.72 207.9,74.6 208.51,73.15 208.51,65.34 205.63,58.39 200.83,53.6 193.47,50.55 184.2,50.55 178.8,48.31 175.9,45.42 171.34,43.53 166.79,41.64 164,41.64 159.14,39.63 157.16,36.67 157.16,33.71 155.86,30.57 155.18,29.89 154.64,28.58 154.64,16.07 v2(155.01,15.7)
  BOTTOM w0.124: J49.31 154.9,9.59 154.65,9.84 154.65,15.34 v2(155.01,15.7)
P3E_6_PESW_TX0_DP: length 112.4
  TOP w0.124: U34.AA36 v6(200.59,78.02)
  IN2 w0.099: 205.36,77.98 205.34,77.98 205.3,78.02 203.68,78.02 202.23,77.42 201.22,77.42 200.99,77.65 200.99,77.92 200.89,78.02 v6(200.59,78.02)
  IN2 w0.136: v2(153.99,15.7) 154.36,16.06 154.36,28.63 154.94,30.05 155.63,30.73 156.88,33.77 156.88,36.75 158.96,39.85 163.95,41.92 166.73,41.92 175.74,45.65 178.64,48.55 184.14,50.83 193.42,50.83 200.67,53.83 205.39,58.55 207.34,63.24 207.26,63.43 207.42,63.8 207.6,63.88 208.23,65.4 208.23,73.09 207.62,74.55 207.62,76.67 207.44,77.1 206.72,77.83 206.35,77.98 205.36,77.98
  BOTTOM w0.124: J49.33 154.1,9.58 154.35,9.83 154.35,15.34 v2(153.99,15.7)
P3E_6_PESW_TX1_DN: length 111.7
  TOP w0.124: U34.AB36 v6(200.59,77.02)
  IN2 w0.099: 205.46,76.82 205.43,76.82 205.4,76.78 205.09,76.78 204.63,76.97 204.34,77.26 204.13,77.35 204.03,77.39 203.73,77.39 203.48,77.28 202.94,76.74 202.65,76.62 200.35,76.62 200.19,76.78 200.19,76.92 200.29,77.02 v6(200.59,77.02)
  IN2 w0.136: 205.46,76.82 205.97,76.82 206.29,76.69 206.77,76.21 206.97,75.72 206.97,74.35 207.57,72.89 207.57,65.91 204.62,58.77 200.46,54.61 193.07,51.55 184.19,51.55 178.26,49.09 175.36,46.2 175.31,46.17 166.71,42.61 163.67,42.61 158.61,40.51 156.18,36.87 156.18,33.78 155.09,31.15 154.36,30.42 153.71,28.85 153.71,24.06 151.49,12.89 151.49,12.15 v2(151.86,11.79)
  BOTTOM w0.124: J49.39 151.7,9.6 151.47,9.82 151.47,10.6 151.48,10.99 151.48,11.41 v2(151.86,11.79)
P3E_6_PESW_TX1_DP: length 111.7
  TOP w0.124: U34.AB35 v6(199.59,77.02)
  IN2 w0.099: v6(199.59,77.02) 199.89,77.02 199.99,76.92 199.99,76.7 200.26,76.42 202.69,76.42 203.05,76.57 203.59,77.11 203.77,77.18 203.99,77.18 204.23,77.08 204.52,76.79 205.05,76.58 205.4,76.58 205.43,76.54 205.46,76.54
  IN2 w0.136: 205.46,76.54 205.92,76.54 206.13,76.45 206.53,76.05 206.69,75.66 206.69,74.29 207.29,72.83 207.29,65.96 206.97,65.17 206.78,65.09 206.63,64.72 206.7,64.53 204.38,58.93 200.3,54.85 193.01,51.83 184.13,51.83 178.1,49.33 175.2,46.43 166.65,42.89 163.61,42.89 158.43,40.74 155.9,36.96 155.9,33.83 154.85,31.31 154.12,30.58 153.43,28.91 153.43,24.09 151.21,12.92 151.21,12.15 v2(150.84,11.79)
  BOTTOM w0.124: J49.41 150.9,9.58 151.17,9.85 151.17,10.61 151.18,11 151.18,11.45 v2(150.84,11.79)
P3E_6_PESW_TX2_DN: length 111.3
  TOP w0.124: U34.AC37 v6(201.59,76.02)
  IN2 w0.099: 206,74.81 206,74.83 205.96,74.87 205.96,75.16 205.71,75.48 205.44,75.61 201.36,75.61 201.19,75.78 201.19,75.92 201.29,76.02 v6(201.59,76.02)
  IN2 w0.136: v2(148.61,10.67) 148.24,11.03 148.24,11.32 148.08,11.72 147.09,12.71 146.37,14.06 145.48,18.53 145.48,20.88 146.14,24.2 148.19,29.15 152.79,36.04 158.05,41.3 163.46,43.54 166.47,43.54 174.77,46.98 177.64,49.85 184.14,52.54 193,52.54 199.95,55.42 203.59,59.05 206.6,66.34 206.6,72.75 206,74.21 206,74.81
  BOTTOM w0.124: J49.47 148.5,9.58 148.25,9.83 148.25,10.31 v2(148.61,10.67)
P3E_6_PESW_TX2_DP: length 111.3
  TOP w0.124: U34.AC36 v6(200.59,76.02)
  IN2 w0.099: 205.72,74.81 205.72,74.83 205.76,74.87 205.76,75.09 205.58,75.31 205.39,75.4 201.28,75.4 200.99,75.7 200.99,75.92 200.89,76.02 v6(200.59,76.02)
  IN2 w0.136: v2(147.59,10.67) 147.96,11.03 147.96,11.27 147.84,11.56 146.86,12.54 146.1,13.96 145.2,18.5 145.2,20.9 145.87,24.29 147.94,29.28 152.57,36.22 157.89,41.54 163.4,43.82 166.41,43.82 174.61,47.22 177.48,50.08 184.09,52.82 192.95,52.82 199.79,55.66 203.35,59.21 206.32,66.39 206.32,72.7 205.72,74.15 205.72,74.81
  BOTTOM w0.124: v2(147.59,10.67) 147.95,10.31 147.95,9.84 147.7,9.59 J49.49
P3E_6_PESW_TX3_DN: length 110.8
  TOP w0.124: U34.AD36 v6(200.59,75.02)
  IN2 w0.099: v6(200.59,75.02) 200.29,75.02 200.19,74.92 200.19,74.74 200.3,74.62 202.17,74.62 203.94,73.89 204.12,73.89 204.79,73.61 205.51,72.89 205.65,72.55 205.65,72.24 205.69,72.2 205.69,72.18
  IN2 w0.136: 205.69,72.18 205.69,66.54 202.83,59.64 199.4,56.21 192.9,53.52 183.95,53.52 177.16,50.71 174.46,48.01 166.06,44.53 163.12,44.53 157.64,42.26 152.14,36.76 147.38,29.63 145.23,24.44 144.47,20.6 144.47,18.8 144.79,15.51 144.53,15.19 143.9,15.13 143.79,14.99 143.85,14.36 143.99,14.24 144.62,14.3 144.93,14.04 145.01,13.24 145.01,12.2 v2(145.38,11.84)
  BOTTOM w0.124: v2(145.38,11.84) 145.03,11.48 145.03,10.84 145.05,10.39 145.05,9.84 145.3,9.59 J49.55
P3E_6_PESW_TX3_DP: length 110.8
  TOP w0.124: U34.AD35 v6(199.59,75.02)
  IN2 w0.099: v6(199.59,75.02) 199.89,75.02 199.99,74.92 199.99,74.65 200.22,74.42 202.13,74.42 203.9,73.69 204.08,73.69 204.68,73.44 205.33,72.78 205.45,72.51 205.45,72.24 205.41,72.2 205.41,72.18
  IN2 w0.136: 205.41,72.18 205.41,66.6 202.59,59.8 199.24,56.44 192.85,53.8 183.89,53.8 177,50.94 174.3,48.24 166,44.81 163.06,44.81 157.48,42.5 151.93,36.94 147.13,29.76 144.96,24.52 144.19,20.63 144.19,18.79 144.5,15.59 144.39,15.46 143.76,15.39 143.5,15.08 143.59,14.21 143.9,13.95 144.53,14.01 144.67,13.9 144.73,13.22 144.73,12.2 v2(144.37,11.84)
  BOTTOM w0.124: J49.57 144.5,9.58 144.75,9.82 144.75,10.38 144.72,10.83 144.72,11.48 v2(144.37,11.84)
P3E_PESW_M2A_RX0_DN: length 168.3
  TOP w0.124: v2(40.39,126.2) 40.74,126.56 40.74,128.09 40.51,128.64 39.53,129.62 38.56,130.02 30.88,130.02 29.96,130.4 29.52,131.07 29.52,132.6 29.43,132.68 J4.B41 ; U34.AD6 v6(169.59,75.02)
  IN2 w0.099: 165.62,74.38 165.64,74.38 165.68,74.42 168.98,74.42 169.2,74.64 169.2,74.92 169.3,75.02 v6(169.59,75.02)
  IN2 w0.136: v2(40.39,126.2) 40.75,125.83 40.75,125.57 41.02,125.18 42.25,124.67 43.36,123.84 44.24,122.76 44.23,122.59 43.63,122.09 43.59,121.68 44.14,121.01 44.55,120.97 45.15,121.47 45.33,121.45 45.73,120.96 45.71,120.78 45.11,120.29 45.05,119.69 45.42,119.25 45.82,119.21 46.28,119.35 46.66,119.66 46.81,119.64 47.26,119.09 47.48,118.55 47.48,116.95 48.79,115.64 50.34,115 50.99,114.35 53.5,110.16 53.74,108.57 54.99,106.48 55.64,105.7 55.97,105.52 56.66,104.69 56.77,104.34 57.58,103.35 57.61,103.32 59.42,101.97 73.95,95.96 82.37,94.28 85.5,92.99 85.86,92.91 86.03,92.84 96.99,90.66 104.46,87.57 113.26,84.9 122.07,82.23 161.52,74.38 165.62,74.38
P3E_PESW_M2A_RX0_DP: length 168.3
  TOP w0.124: U34.AD5 v6(168.59,75.02) ; J4.B43 29.93,132.69 29.82,132.58 29.82,131.16 30.17,130.65 30.55,130.49 30.94,130.33 38.62,130.33 39.7,129.88 40.77,128.81 41.05,128.15 41.05,126.56 v2(41.4,126.2)
  IN2 w0.099: 165.62,74.66 165.64,74.66 165.68,74.62 168.9,74.62 169,74.72 169,74.92 168.9,75.02 v6(168.59,75.02)
  IN2 w0.136: 165.62,74.66 161.55,74.66 159.49,75.07 159.39,75.22 158.99,75.3 158.83,75.2 158.43,75.28 158.33,75.43 157.93,75.51 157.77,75.41 157.37,75.49 157.27,75.65 156.87,75.73 156.71,75.62 156.31,75.7 156.21,75.86 155.81,75.94 155.66,75.83 155.26,75.91 155.15,76.07 154.75,76.15 154.6,76.04 154.2,76.12 154.09,76.28 153.69,76.36 153.54,76.25 153.14,76.33 153.03,76.49 152.63,76.57 152.48,76.46 122.14,82.5 104.55,87.83 97.07,90.93 86.11,93.11 85.94,93.18 85.58,93.25 82.45,94.55 74.03,96.23 59.56,102.22 57.8,103.53 57.02,104.47 56.91,104.83 56.15,105.74 55.82,105.92 55.22,106.65 54,108.67 53.77,110.26 51.21,114.52 50.5,115.24 48.95,115.88 47.76,117.06 47.76,118.61 47.5,119.24 46.95,119.91 46.58,119.95 46.15,119.6 45.79,119.49 45.56,119.51 45.34,119.78 45.38,120.14 45.98,120.64 46.02,121.05 45.47,121.72 45.06,121.76 44.46,121.26 44.28,121.28 43.88,121.77 43.89,121.95 44.49,122.44 44.53,122.85 43.56,124.04 42.39,124.91 41.2,125.4 41.03,125.66 41.03,125.83 v2(41.4,126.2)
P3E_PESW_M2A_RX1_DN: length 168.5
  TOP w0.124: U34.AE5 v6(168.59,74.02) ; v2(33.93,127.97) 34.29,128.33 34.29,128.53 34.16,128.73 33.97,128.8 30.67,128.8 28.14,129.85 26.75,131 26.53,131.32 26.53,132.59 26.43,132.69 J4.B29
  IN2 w0.099: v6(168.59,74.02) 168.3,74.02 168.2,73.92 168.2,73.64 167.98,73.42 165.66,73.42 165.62,73.38 165.59,73.38
  IN2 w0.136: 165.59,73.38 161.81,73.38 121.46,81.41 104.49,86.56 100.45,88.23 95.66,89.18 95.12,89.18 89.62,90.27 82.12,93.38 73.72,95.05 53.34,102.34 41.38,107.3 40.71,108.3 40.71,108.99 40.92,109.51 40.92,110.72 41.11,111.16 41.11,111.66 41.11,111.66 40.43,113.29 39.68,114.69 38.71,117.03 38.71,120.96 36.97,125.17 36.12,126.01 34.68,126.61 34.3,127.17 34.3,127.6 v2(33.93,127.97)
P3E_PESW_M2A_RX1_DP: length 168.5
  TOP w0.124: U34.AE4 v6(167.59,74.02) ; J4.B31 26.93,132.7 26.84,132.61 26.84,131.41 26.98,131.2 28.3,130.12 30.73,129.11 34.03,129.11 34.36,128.97 34.59,128.62 34.59,128.33 v2(34.95,127.97)
  IN2 w0.099: v6(167.59,74.02) 167.9,74.02 168,73.92 168,73.72 167.9,73.62 165.66,73.62 165.62,73.66 165.59,73.66
  IN2 w0.136: 165.59,73.66 161.84,73.66 121.53,81.68 104.58,86.82 100.53,88.5 95.69,89.46 95.15,89.46 89.7,90.54 82.2,93.65 73.79,95.32 69.64,96.81 69.56,96.98 69.18,97.11 69.01,97.03 68.63,97.17 68.55,97.34 68.16,97.48 67.99,97.4 67.61,97.53 67.53,97.7 67.15,97.84 66.98,97.76 66.59,97.9 66.51,98.07 66.13,98.2 65.96,98.12 65.58,98.26 65.5,98.43 65.11,98.57 64.94,98.49 64.56,98.63 64.48,98.79 64.1,98.93 63.93,98.85 63.54,98.99 63.46,99.16 63.08,99.3 62.91,99.22 53.44,102.6 41.57,107.52 40.99,108.39 40.99,108.94 41.2,109.46 41.2,110.66 41.39,111.11 41.39,111.71 40.68,113.41 39.93,114.81 38.99,117.09 38.99,121.02 37.21,125.32 36.28,126.25 34.86,126.84 34.58,127.26 34.58,127.6 v2(34.95,127.97)
P3E_PESW_M2A_RX2_DN: length 186.1
  TOP w0.124: J4.B17 23.43,132.7 23.53,132.61 23.53,131.4 23.9,130.84 27.4,128.74 29.78,127.75 33.2,127.07 33.73,127.07 34.31,126.83 34.65,126.33 34.65,125.92 v2(34.29,125.56) ; U34.AF6 v6(169.59,73.02)
  IN2 w0.099: v6(169.59,73.02) 169.3,73.02 169.2,72.92 169.2,72.64 168.98,72.42 165.86,72.42 165.82,72.38 165.79,72.38
  IN2 w0.136: 165.79,72.38 161.4,72.38 122.46,80.12 103.37,85.92 99.73,87.42 95.68,88.23 95.11,88.23 89.32,89.38 81.87,92.47 73.61,94.11 55,100.77 54.87,100.71 54.43,99.65 54.43,99.65 53.9,98.38 53.38,98.16 52.57,98.5 52.42,98.88 53.27,100.93 53.09,101.35 52.57,101.57 52.31,101.46 51.4,99.25 51.02,99.09 50.21,99.42 50.01,99.91 50.95,102.19 50.93,102.24 47.54,103.65 47.37,103.58 46.96,102.57 46.58,102.41 45.77,102.75 45.62,103.12 46.04,104.13 45.97,104.3 45.38,104.54 45.21,104.47 44.94,103.82 44.56,103.66 43.76,104 43.61,104.38 43.88,105.03 43.84,105.11 43.81,105.19 40.52,106.56 40.12,106.96 39.89,107.88 38.95,109.87 37.68,114.94 37.28,116.05 36.85,117.75 36.26,119.01 35.64,121.46 35.64,123.13 35.44,123.62 34.92,124.14 34.66,124.77 34.66,125.19 v2(34.29,125.56)
P3E_PESW_M2A_RX2_DP: length 186.1
  TOP w0.124: v2(35.31,125.56) 34.95,125.92 34.95,126.42 34.51,127.08 33.79,127.38 33.23,127.38 29.87,128.04 27.54,129.01 24.12,131.06 23.83,131.49 23.83,132.59 23.93,132.69 J4.B19 ; U34.AF5 v6(168.59,73.02)
  IN2 w0.099: v6(168.59,73.02) 168.9,73.02 169,72.92 169,72.72 168.9,72.62 165.86,72.62 165.82,72.66 165.79,72.66
  IN2 w0.136: v2(35.31,125.56) 34.94,125.19 34.94,124.83 35.16,124.29 35.67,123.78 35.92,123.18 35.92,121.5 36.52,119.1 37.12,117.84 37.54,116.13 37.94,115.02 39.21,109.96 40.15,107.98 40.37,107.11 40.68,106.79 44.02,105.41 44.18,105.03 43.91,104.38 43.98,104.21 44.56,103.97 44.73,104.04 45,104.69 45.38,104.85 46.18,104.51 46.34,104.13 45.92,103.12 45.99,102.96 46.58,102.72 46.74,102.78 47.16,103.79 47.54,103.95 51.14,102.46 51.26,102.19 50.31,99.91 50.43,99.64 51.02,99.39 51.18,99.46 52.1,101.68 52.57,101.87 53.3,101.56 53.57,100.93 52.72,98.88 52.79,98.71 53.38,98.47 53.69,98.6 54.65,100.92 54.99,101.07 73.69,94.38 81.96,92.73 89.4,89.65 95.14,88.51 95.71,88.51 99.81,87.69 103.46,86.18 122.53,80.4 152.64,74.41 152.79,74.51 153.19,74.43 153.3,74.28 153.7,74.2 153.85,74.3 154.25,74.22 154.36,74.07 154.76,73.99 154.91,74.09 155.31,74.01 155.41,73.86 155.81,73.78 155.97,73.88 156.37,73.8 156.47,73.65 156.87,73.57 157.03,73.67 157.43,73.59 157.53,73.43 157.93,73.36 158.09,73.46 158.49,73.38 158.59,73.22 158.99,73.14 159.15,73.25 159.55,73.17 159.65,73.01 161.43,72.66 165.79,72.66
P3E_PESW_M2A_RX3_DN: length 187
  TOP w0.124: U34.AG5 v6(168.59,72.02) ; J4.B5 20.43,132.68 20.53,132.59 20.53,129.36 19.9,127.84 18.67,126.61 17.44,123.64 17.17,123.37 16.48,121.71 16.48,111.78 17.15,109.59 18.22,108 22.5,103.71 27.18,101.78 42.57,101.78 47.21,99.85 47.78,99.29 47.78,98.97 v2(47.41,98.61)
  IN2 w0.099: 164.25,71.38 164.27,71.38 164.31,71.42 167.98,71.42 168.2,71.64 168.2,71.92 168.3,72.02 v6(168.59,72.02)
  IN2 w0.136: v2(47.41,98.61) 47.78,98.24 47.78,97.86 48.09,97.4 49.7,96.73 61.49,96.73 66.08,95.82 73.32,93.23 73.63,93.14 81.49,91.57 89.14,88.41 95.19,87.2 96.04,87.2 99.37,86.54 102.89,85.08 123.31,78.88 161.02,71.38 164.25,71.38
P3E_PESW_M2A_RX3_DP: length 187
  TOP w0.124: J4.B7 20.93,132.69 20.83,132.6 20.83,129.3 20.15,127.66 18.93,126.44 17.7,123.46 17.43,123.2 16.79,121.65 16.79,111.83 17.43,109.73 18.45,108.19 22.67,103.97 27.24,102.08 42.63,102.08 47.39,100.11 48.08,99.42 48.08,98.95 v2(48.43,98.61) ; U34.AG4 v6(167.59,72.02)
  IN2 w0.099: 164.25,71.66 164.27,71.66 164.31,71.62 167.9,71.62 168,71.72 168,71.92 167.9,72.02 v6(167.59,72.02)
  IN2 w0.136: 164.25,71.66 161.05,71.66 159.23,72.02 159.13,72.17 158.73,72.25 158.57,72.15 158.17,72.23 158.07,72.39 157.67,72.46 157.52,72.36 157.12,72.44 157.01,72.6 156.61,72.68 156.46,72.57 156.06,72.65 155.95,72.81 155.55,72.89 155.4,72.78 155,72.86 154.89,73.02 154.49,73.1 154.34,72.99 153.94,73.07 153.84,73.23 153.44,73.31 153.28,73.2 152.88,73.28 152.78,73.44 152.38,73.52 152.22,73.41 123.38,79.15 102.99,85.34 99.45,86.81 96.07,87.48 95.22,87.48 92.22,88.08 89.22,88.67 81.57,91.84 73.7,93.41 73.41,93.5 66.15,96.09 61.52,97.01 49.75,97.01 48.27,97.63 48.06,97.95 48.06,98.24 v2(48.43,98.61)
P3E_PESW_M2A_TX0_C_DN: length 167
  TOP w0.124: v2(25.63,110.14) 25.99,109.78 25.99,109.42 26.31,108.66 26.8,108.17 26.85,108.15 27.57,107.85 27.97,108.02 28.01,108.13 28.19,108.55 28.32,108.6 28.7,108.45 28.79,108.23 28.79,107.71 28.97,107.27 29.92,106.88 35.67,106.88 35.91,106.78 47.77,106.78 49.58,106.23 55.03,102.59 71.13,95.92 89.47,83.67 92.76,81.91 116.42,72.11 121.25,71.14 124.96,71.36 131.14,70.12 134.32,70.76 137.49,70.12 140.67,70.76 143.84,70.12 150.04,71.36 152.75,71.36 C1024.2 ; J4.B47 30.93,132.7 31.02,132.6 31.02,131.67 v2(30.67,131.32)
  IN1 w0.136: v2(25.63,110.14) 26,110.51 26,111.3 25.84,112.11 25.84,115.82 26.05,116.33 26.28,116.56 26.84,117.92 26.84,118.4 26.57,119.06 24.89,120.74 24.6,121.44 24.6,123.14 24.83,123.7 28.65,127.52 30.88,130.23 31.04,130.61 31.04,130.95 v2(30.67,131.32)
P3E_PESW_M2A_TX0_C_DP: length 167
  TOP w0.124: C1023.2 152.75,71.67 150,71.67 143.84,70.43 140.67,71.07 137.49,70.43 134.32,71.07 131.14,70.43 124.98,71.67 121.27,71.45 116.51,72.4 92.89,82.18 89.63,83.93 71.28,96.19 55.18,102.86 49.71,106.51 47.81,107.09 40.34,107.09 40.19,107.24 39.82,107.24 39.67,107.09 39.29,107.09 39.14,107.24 38.77,107.24 38.62,107.09 38.24,107.09 38.09,107.24 37.72,107.24 37.57,107.09 37.19,107.09 37.04,107.24 36.67,107.24 36.52,107.09 35.97,107.09 35.73,107.19 29.98,107.19 29.21,107.51 29.1,107.77 29.1,108.29 28.93,108.68 28.32,108.93 27.95,108.78 27.73,108.25 27.57,108.18 26.97,108.43 26.57,108.84 26.3,109.48 26.3,109.8 v2(26.64,110.14) ; J4.B49 31.43,132.7 31.33,132.6 31.33,131.67 v2(31.68,131.32)
  IN1 w0.136: v2(31.68,131.32) 31.32,130.95 31.32,130.56 31.12,130.08 28.86,127.33 25.07,123.54 24.88,123.08 24.88,121.49 25.13,120.9 26.81,119.21 27.12,118.45 27.12,117.87 26.51,116.4 26.28,116.17 26.12,115.76 26.12,112.14 26.28,111.33 26.28,110.51 v2(26.64,110.14)
P3E_PESW_M2A_TX0_DN: length 14.5
  TOP w0.099: U34.AD3 166.79,75.52 166.69,75.42 166.69,75.14 166.47,74.92 162.92,74.92 162.86,74.87 162.84,74.87
  TOP w0.124: C1024.1 154.27,71.36 154.62,71.36 157.59,72.59 158.62,73.28 162.46,74.87 162.84,74.87
P3E_PESW_M2A_TX0_DP: length 14.5
  TOP w0.099: 162.84,75.17 162.86,75.17 162.92,75.12 163.2,75.12 163.3,75.22 163.5,75.22 163.6,75.12 163.8,75.12 163.9,75.22 164.1,75.22 164.2,75.12 164.4,75.12 164.5,75.22 164.7,75.22 164.8,75.12 165,75.12 165.1,75.22 165.3,75.22 165.4,75.12 166.39,75.12 166.49,75.22 166.49,75.42 166.39,75.52 U34.AD2
  TOP w0.124: C1023.1 154.27,71.67 154.56,71.67 157.45,72.86 158.48,73.55 162.4,75.17 162.84,75.17
P3E_PESW_M2A_TX1_C_DN: length 165.6
  TOP w0.124: J4.B35 27.93,132.71 28.03,132.61 28.03,132.47 28.05,132.12 28.05,131.95 v2(27.68,131.59) ; C1026.2 150.92,70.02 150.17,70.02 143.84,68.76 140.67,69.39 137.49,68.76 134.32,69.39 131.14,68.76 124.82,70.02 121.75,69.83 115.89,71 92.35,80.75 88.66,82.72 70.49,94.86 54.56,101.46 49.12,105.09 47.75,105.51 28.34,105.51 24.53,107.09 24.29,107.33 24.29,107.65 v2(23.98,107.96)
  IN1 w0.136: v2(23.98,107.96) 24.32,108.3 24.32,108.66 24.62,109.38 24.62,110.21 24.42,110.67 24.42,113.45 24.89,114.57 24.89,115.48 24.32,116.85 23.9,117.26 23.73,117.68 23.67,118 23.67,123.65 24.07,124.62 26.92,127.47 27.45,128.27 28.05,129.71 28.05,131.22 v2(27.68,131.59)
P3E_PESW_M2A_TX1_C_DP: length 165.6
  TOP w0.124: J4.B37 28.43,132.71 28.33,132.61 28.33,132.48 28.35,132.14 28.35,132.12 28.35,131.94 v2(28.7,131.59) ; v2(24.99,107.96) 24.76,107.96 24.59,107.79 24.59,107.45 24.7,107.35 28.4,105.82 30.74,105.82 30.92,105.99 31.3,105.99 31.47,105.82 31.85,105.82 32.02,105.99 32.4,105.99 32.58,105.82 47.8,105.82 49.26,105.37 54.71,101.73 70.63,95.13 88.82,82.98 92.48,81.03 115.98,71.29 121.77,70.13 124.84,70.33 131.14,69.07 134.32,69.7 137.49,69.07 140.67,69.7 143.84,69.07 150.14,70.33 150.92,70.33 C1025.2
  IN1 w0.136: v2(24.99,107.96) 24.6,108.35 24.6,108.6 24.72,108.91 24.9,109.32 24.9,110.26 24.7,110.73 24.7,113.39 25.17,114.52 25.17,115.53 24.56,117.01 24.14,117.42 24,117.76 23.95,118.03 23.95,123.59 24.31,124.46 27.14,127.3 27.7,128.14 28.33,129.66 28.33,131.22 v2(28.7,131.59)
P3E_PESW_M2A_TX1_DN: length 15.5
  TOP w0.099: 162.96,73.87 162.99,73.87 163.04,73.92 165.52,73.92 165.74,74.14 165.74,74.43 165.83,74.52 U34.AE2
  TOP w0.124: 162.96,73.87 162.63,73.87 159.51,72.58 157.53,71.25 156.06,70.64 154.56,70.02 152.43,70.02 C1026.1
P3E_PESW_M2A_TX1_DP: length 15.5
  TOP w0.099: U34.AE1 165.44,74.52 165.54,74.42 165.54,74.22 165.44,74.12 164.84,74.12 164.73,74.22 164.54,74.22 164.43,74.12 164.24,74.12 164.13,74.22 163.94,74.22 163.84,74.12 163.64,74.12 163.54,74.22 163.34,74.22 163.24,74.12 163.04,74.12 162.99,74.17 162.96,74.17
  TOP w0.124: C1025.1 152.43,70.33 154.5,70.33 157.38,71.52 159.37,72.85 162.57,74.17 162.96,74.17
P3E_PESW_M2A_TX2_C_DN: length 168.4
  TOP w0.124: J4.B23 24.93,132.72 25.03,132.62 25.03,131.91 v2(24.67,131.56) ; C1028.2 152.75,68.66 150.3,68.66 143.84,67.37 140.67,68 137.49,67.37 134.32,68 131.14,67.37 124.68,68.66 124.68,68.66 124.23,68.7 122.07,68.55 115.44,69.87 91.94,79.6 88.03,81.7 69.98,93.75 54.08,100.34 48.73,103.91 47.4,104.32 28.1,104.32 23.84,106.08 23.04,106.88 22.71,107.69 22.71,109.16 v2(22.35,109.52)
  IN1 w0.136: v2(24.67,131.56) 25.04,131.19 25.04,130.89 25.04,130.89 24.17,128.79 23.75,128.17 23.48,127.5 22.67,123.44 22.67,118.26 22.85,117.34 23.12,116.69 23.42,116.39 23.85,115.37 23.85,114.48 23.44,113.5 23.44,112.06 23.1,111.25 22.72,110.34 22.72,109.89 v2(22.35,109.52)
