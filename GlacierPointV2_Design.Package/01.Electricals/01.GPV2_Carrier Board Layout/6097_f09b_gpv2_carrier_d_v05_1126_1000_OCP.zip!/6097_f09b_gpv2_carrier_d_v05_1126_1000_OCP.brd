# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P3E_PESW_M2K_TX0_DN: length 16.2
  TOP w0.099: U34.AM1 165.43,67.52 165.53,67.42 165.53,67.22 165.43,67.12 164.84,67.12 164.74,67.22 164.54,67.22 164.44,67.12 164.24,67.12 164.14,67.22 163.94,67.22 163.84,67.12 163.64,67.12 163.54,67.22 163.34,67.22 163.24,67.12 163.04,67.12 162.99,67.17 162.96,67.17
  TOP w0.124: 162.96,67.17 162.53,67.17 160.35,66.27 157.53,63.44 154.56,62.22 152.43,62.22 C1037.1
P3E_PESW_M2K_TX0_DP: length 16.2
  TOP w0.099: 162.96,66.87 162.99,66.87 163.04,66.92 165.52,66.92 165.74,67.14 165.74,67.42 165.84,67.52 U34.AM2
  TOP w0.124: C1038.1 152.43,61.91 154.62,61.91 157.7,63.18 160.52,66.01 162.59,66.87 162.96,66.87
P3E_PESW_M2K_TX1_C_DN: length 157.4
  TOP w0.124: C1035.2 152.78,63.59 149.44,63.59 143.08,62.32 140.67,62.8 137.49,62.16 134.32,62.8 131.14,62.16 124.17,63.56 124.17,63.56 123.69,63.6 122.1,63.46 110.33,65.82 89.94,74.26 79.7,79.74 72.87,85.32 71.44,87.04 71.03,87.38 69.05,88.43 68.34,89.02 67.62,89.31 64.75,89.31 64.57,89.49 64.19,89.49 64.02,89.31 63.64,89.31 63.47,89.49 63.09,89.49 62.91,89.31 62.54,89.31 61.61,90.25 61.61,91.2 61.84,91.43 v2(62.05,91.43)
  IN1 w0.136: v2(62.05,91.43) 61.66,91.82 61.66,92.53 68.77,99.64 68.77,109.46 68.5,110.12 67.47,111.14 67.25,111.68 67.25,114.26 67.11,114.41 67.11,123.66 66.87,124.23 66.87,125.99 66.53,126.81 65.53,127.81 65.39,128.14 65.39,131.27 63.06,133.61 63.06,135.14 63.16,135.24 63.71,135.24 64.08,135.62 64.08,136.29 63.67,136.71 63.16,136.71 63.06,136.81 63.06,138.6 v2(63.43,138.97)
  BOTTOM w0.124: v2(63.43,138.97) 63.07,139.33 63.07,139.86 63.17,139.95 J6.B35
P3E_PESW_M2K_TX1_C_DP: length 157.4
  TOP w0.124: C1036.2 152.72,63.28 149.47,63.28 143.08,62.01 140.67,62.49 137.49,61.85 134.32,62.49 131.14,61.85 124.14,63.25 124.14,63.25 123.69,63.3 122.09,63.16 110.24,65.52 89.81,73.99 79.53,79.48 72.65,85.1 71.23,86.83 70.86,87.13 68.88,88.18 68.18,88.75 67.56,89.01 62.41,89.01 61.3,90.12 61.3,91.16 v2(61.03,91.43)
  IN1 w0.136: v2(62.41,138.97) 62.78,138.6 62.78,136.69 63.04,136.43 63.55,136.43 63.8,136.18 63.8,135.73 63.59,135.52 63.04,135.52 62.78,135.25 62.78,133.49 65.11,131.16 65.11,128.09 65.3,127.65 66.3,126.65 66.59,125.93 66.59,124.18 66.83,123.61 66.83,114.29 66.97,114.15 66.97,111.62 67.24,110.98 68.26,109.96 68.49,109.41 68.49,99.76 61.38,92.65 61.38,91.78 v2(61.03,91.43)
  BOTTOM w0.124: v2(62.41,138.97) 62.77,139.33 62.77,139.85 62.67,139.95 J6.B37
P3E_PESW_M2K_TX1_DN: length 15.2
  TOP w0.099: 163.08,68.17 163.11,68.17 163.16,68.12 163.36,68.12 163.46,68.22 163.66,68.22 163.76,68.12 163.96,68.12 164.06,68.22 164.26,68.22 164.36,68.12 164.56,68.12 164.66,68.22 164.86,68.22 164.96,68.12 165.16,68.12 165.26,68.22 165.46,68.22 165.56,68.12 166.39,68.12 166.49,68.22 166.49,68.42 166.39,68.52 U34.AL2
  TOP w0.124: C1035.1 154.27,63.56 154.65,63.56 157.67,64.81 160.06,67.19 162.42,68.17 163.08,68.17
P3E_PESW_M2K_TX1_DP: length 15.2
  TOP w0.099: 163.08,67.87 163.11,67.87 163.16,67.92 166.47,67.92 166.69,68.14 166.69,68.42 166.79,68.52 U34.AL3
  TOP w0.124: C1036.1 154.27,63.25 154.71,63.25 157.85,64.55 160.23,66.94 162.48,67.87 163.08,67.87
P3E_PESW_M2K_TX2_C_DN: length 148.8
  TOP w0.124: v2(64.44,92.02) 64.36,92.02 63.99,91.65 63.99,91.19 64.21,90.97 64.48,90.86 64.62,90.92 64.95,90.78 65,90.64 65.29,90.52 67.89,90.52 69.56,89.83 71.99,88.21 75.19,85.01 80.3,80.82 87.31,77.07 87.55,77.14 87.88,76.97 87.95,76.73 88.3,76.54 88.54,76.61 88.87,76.44 88.94,76.2 89.72,75.78 90.63,75.35 110.4,67.16 122.36,64.77 124.31,64.92 131.14,63.55 134.32,64.19 137.49,63.55 140.67,64.19 143.49,63.62 150.11,64.95 150.95,64.95 C1033.2
  IN1 w0.136: v2(66.43,138.97) 66.06,138.6 66.06,137.74 65.62,133.26 66.47,131.21 67.24,130.45 68.05,128.48 68.05,127.88 67.8,127.27 67.8,125.11 68.06,123.76 68.06,118 68.22,116.44 69,112.48 69.25,112.12 69.85,109.07 69.85,106.11 69.7,105.75 69.7,99.03 64.07,93.4 64.07,92.39 v2(64.44,92.02)
  BOTTOM w0.124: v2(66.43,138.97) 66.07,139.33 66.07,139.86 66.17,139.96 J6.B23
P3E_PESW_M2K_TX2_C_DP: length 148.8
  TOP w0.124: v2(63.42,92.02) 63.69,91.76 63.69,91.06 64.03,90.72 64.37,90.58 64.37,90.58 65.23,90.22 67.83,90.22 69.42,89.56 71.8,87.97 74.99,84.78 80.13,80.56 89.58,75.51 90.51,75.07 110.31,66.87 122.34,64.46 124.29,64.61 131.14,63.24 134.32,63.88 137.49,63.24 140.67,63.88 143.49,63.31 150.14,64.64 150.89,64.64 C1034.2
  IN1 w0.136: v2(63.42,92.02) 63.79,92.39 63.79,93.51 69.42,99.14 69.42,105.81 69.57,106.17 69.57,109.05 68.98,112.01 68.74,112.37 67.94,116.39 67.78,117.98 67.78,123.73 67.52,125.08 67.52,127.32 67.77,127.93 67.77,128.42 67,130.29 66.23,131.05 65.34,133.22 65.78,137.75 65.78,138.6 v2(65.41,138.97)
  BOTTOM w0.124: v2(65.41,138.97) 65.77,139.33 65.77,139.87 65.67,139.97 J6.B25
P3E_PESW_M2K_TX2_DN: length 15.9
  TOP w0.099: 162.82,69.17 162.84,69.17 162.89,69.12 163.09,69.12 163.19,69.22 163.39,69.22 163.49,69.12 163.69,69.12 163.79,69.22 163.99,69.22 164.09,69.12 164.29,69.12 164.39,69.22 164.59,69.22 164.69,69.12 165.44,69.12 165.54,69.22 165.54,69.42 165.44,69.52 U34.AK1
  TOP w0.124: C1033.1 152.43,64.92 154.54,64.92 157.74,66.24 159.59,68.1 162.19,69.17 162.82,69.17
P3E_PESW_M2K_TX2_DP: length 15.8
  TOP w0.099: 162.82,68.87 162.84,68.87 162.89,68.92 165.52,68.92 165.74,69.14 165.74,69.42 165.84,69.52 U34.AK2
  TOP w0.124: C1034.1 152.43,64.61 154.6,64.61 156.25,65.3 157.05,65.63 157.91,65.99 159.76,67.84 162.25,68.87 162.82,68.87
P3E_PESW_M2K_TX3_C_DN: length 149.9
  TOP w0.124: v2(66.27,92.36) 65.9,91.99 65.9,91.89 66,91.79 68.23,91.79 69.12,91.52 71.16,90.44 76.61,85.96 77.09,85.07 81.12,81.76 82.97,80.77 84.35,80.2 84.54,80.29 84.88,80.14 84.96,79.95 85.31,79.81 85.5,79.89 85.85,79.74 85.93,79.55 86.27,79.41 86.47,79.49 86.81,79.34 86.89,79.15 87.24,79.01 87.43,79.09 87.78,78.94 87.86,78.75 90.9,77.49 98.51,73.42 110.65,68.39 122.14,66.09 124.44,66.26 131.14,64.92 134.32,65.56 137.49,64.92 140.67,65.56 143.84,64.92 150.66,66.28 152.78,66.28 C1031.2
  IN1 w0.136: v2(69.43,138.97) 69.01,138.55 69.01,137.67 68.84,136.82 67.48,133.54 67.48,131.85 67.83,131.5 69.6,131.5 70.23,130.88 70.23,129.87 69.89,129.05 69.09,128.25 68.98,127.98 68.98,127.7 68.89,127.49 68.89,124.38 69.67,120.43 69.67,113.9 69.78,113.38 70.29,112.14 70.87,109.23 70.87,108.4 70.87,105.94 70.64,105.38 70.64,98.64 65.94,93.94 65.94,92.69 v2(66.27,92.36)
  BOTTOM w0.124: v2(69.43,138.97) 69.07,139.33 69.07,139.86 69.17,139.96 J6.B11
P3E_PESW_M2K_TX3_C_DP: length 149.9
  TOP w0.124: v2(65.25,92.36) 65.59,92.02 65.59,91.77 65.87,91.49 68.19,91.49 69.01,91.24 70.99,90.18 76.37,85.76 76.85,84.87 80.95,81.51 82.84,80.5 90.77,77.21 98.38,73.15 110.56,68.1 122.13,65.79 124.42,65.95 131.14,64.61 134.32,65.24 137.49,64.61 140.67,65.24 143.84,64.61 150.69,65.98 152.73,65.98 C1032.2
  IN1 w0.136: v2(68.41,138.97) 68.73,138.65 68.73,137.7 68.57,136.91 68.27,136.19 67.2,133.6 67.2,131.74 67.72,131.22 69.49,131.22 69.95,130.76 69.95,129.92 69.65,129.21 68.85,128.4 68.7,128.03 68.7,127.76 68.61,127.54 68.61,124.35 69.39,120.4 69.39,113.87 69.51,113.3 70.02,112.06 70.59,109.2 70.59,109.18 70.59,108.4 70.59,105.99 70.59,105.99 70.36,105.43 70.36,98.76 65.66,94.06 65.66,92.76 v2(65.25,92.36)
  BOTTOM w0.124: v2(68.41,138.97) 68.77,139.33 68.77,139.87 68.67,139.97 J6.B13
P3E_PESW_M2K_TX3_DN: length 14.8
  TOP w0.099: U34.AJ2 166.39,70.52 166.49,70.42 166.49,70.22 166.39,70.12 165.24,70.12 165.14,70.22 164.94,70.22 164.84,70.12 164.64,70.12 164.54,70.22 164.34,70.22 164.24,70.12 164.04,70.12 163.94,70.22 163.74,70.22 163.64,70.12 163.44,70.12 163.34,70.22 163.14,70.22 163.04,70.12 162.84,70.12 162.79,70.17 162.76,70.17
  TOP w0.124: 162.76,70.17 162,70.17 159.78,69.25 158.09,68.13 157.35,67.38 154.64,66.26 154.27,66.26 C1031.1
P3E_PESW_M2K_TX3_DP: length 14.8
  TOP w0.099: 162.76,69.87 162.79,69.87 162.84,69.92 166.47,69.92 166.69,70.14 166.69,70.42 166.79,70.52 U34.AJ3
  TOP w0.124: 162.76,69.87 162.06,69.87 159.92,68.98 158.29,67.89 157.52,67.13 154.7,65.96 154.27,65.96 C1032.1
P3E_PESW_M2L_RX0_DN: length 213.6
  TOP w0.124: U34.AT4 v6(167.59,63.02)
  IN2 w0.099: v6(167.59,63.02) 167.9,63.02 168,62.92 168,62.73 167.9,62.62 165.15,62.62 165.11,62.66 165.09,62.66
  IN2 w0.136: v2(36.42,143.43) 36.07,143.08 36.07,142.53 35.44,141.9 33.69,141.9 31.56,141.01 25.28,141.01 20.5,139.03 18.2,136.73 18.2,133.18 20.15,128.46 20.15,124.18 20.41,123.54 20.41,115.68 21.02,115.07 23.9,115.07 26.32,114.07 26.4,113.99 26.89,113.26 27.25,112.38 27.64,110.41 27.66,110.26 27.66,108.56 28.6,106.29 30.6,104.28 33.69,96.84 42.01,91.28 48.8,87.65 51.59,86.49 75.48,81.74 84.97,78.86 87.24,78.41 87.4,78.52 87.8,78.44 87.9,78.28 88.3,78.2 88.45,78.31 88.86,78.23 88.96,78.07 89.36,77.99 89.51,78.1 89.91,78.02 90.02,77.86 90.42,77.78 90.57,77.88 90.97,77.81 91.08,77.65 91.48,77.57 91.63,77.67 92.03,77.59 92.13,77.44 92.53,77.36 92.69,77.46 93.09,77.38 93.19,77.23 93.59,77.15 93.75,77.25 94.15,77.17 94.25,77.02 113.12,73.27 113.12,73.27 126.27,69.97 163.04,62.66 165.09,62.66
  BOTTOM w0.124: v2(36.42,143.43) 36.07,143.08 36.07,142.6 36.17,142.5 37.18,142.5 37.57,142.11 37.57,141.58 37.67,141.49 J6.A41
P3E_PESW_M2L_RX0_DP: length 213.7
  TOP w0.124: U34.AT5 v6(168.59,63.02)
  IN2 w0.099: 165.09,62.38 165.11,62.38 165.15,62.42 167.98,62.42 168.21,62.64 168.21,62.92 168.3,63.02 v6(168.59,63.02)
  IN2 w0.136: v2(35.4,143.43) 35.79,143.04 35.79,142.65 35.32,142.18 33.64,142.18 31.5,141.29 25.23,141.29 20.34,139.27 17.92,136.85 17.92,133.12 19.87,128.41 19.87,124.12 20.13,123.49 20.13,115.56 20.91,114.79 23.85,114.79 26.16,113.83 26.18,113.81 26.64,113.13 26.98,112.3 27.37,110.37 27.38,110.24 27.38,108.51 28.36,106.13 30.37,104.13 33.46,96.65 41.86,91.04 48.68,87.4 51.51,86.22 75.42,81.47 84.9,78.59 87.19,78.14 87.19,78.14 113.07,72.99 113.07,72.99 126.21,69.7 163.01,62.38 165.09,62.38
  BOTTOM w0.124: v2(35.4,143.43) 35.76,143.07 35.76,142.47 36.04,142.19 37.06,142.19 37.27,141.98 37.27,141.59 37.17,141.5 J6.A43
P3E_PESW_M2L_RX1_DN: length 212.2
  TOP w0.124: U34.AR5 v6(168.59,64.02)
  IN2 w0.099: 165.68,63.66 165.7,63.66 165.74,63.62 168.9,63.62 169.01,63.74 169.01,63.91 168.9,64.02 v6(168.59,64.02)
  IN2 w0.136: 165.68,63.66 163.29,63.66 124.66,71.34 109.06,75.25 94.48,78.15 94.38,78.3 93.98,78.38 93.83,78.28 93.42,78.36 93.32,78.52 92.92,78.6 92.77,78.49 92.37,78.57 92.26,78.73 91.86,78.81 91.71,78.7 91.31,78.78 91.2,78.94 90.8,79.02 90.65,78.91 90.25,78.99 90.14,79.15 89.74,79.23 89.59,79.12 89.19,79.2 89.09,79.36 88.69,79.44 88.53,79.33 88.13,79.41 88.03,79.57 87.63,79.65 87.47,79.55 83.74,80.29 76.28,82.55 73.47,83.11 73.36,83.28 73.45,83.75 73.22,84.1 72.37,84.27 72.02,84.04 71.93,83.57 71.77,83.46 51.76,87.44 49.43,88.41 43.9,91.36 34.58,97.59 31.35,105.38 31.31,105.42 29.18,107.55 28.77,108.54 28.65,109.15 28.54,111.4 28.6,112.02 28.04,113.38 28.02,113.41 26.87,115.13 23.37,116.58 22.9,117.05 22.9,118.87 22,123.41 21.12,125.54 21.12,128.6 20.29,130.61 19.45,132.62 19.45,134.11 24.07,138.72 24.22,138.79 24.62,138.79 24.76,138.65 25.17,138.65 25.31,138.79 25.72,138.79 25.86,138.65 26.27,138.65 26.41,138.79 26.81,138.79 26.95,138.65 27.36,138.65 27.5,138.79 27.91,138.79 28.05,138.65 28.46,138.65 28.6,138.79 29.44,138.79 29.69,138.54 v2(29.69,138.46)
  BOTTOM w0.124: J6.A29 40.67,139.79 40.57,139.7 40.57,138.43 39.96,137.82 36.56,137.82 35.45,137.36 33.09,137.36 31.64,138.81 30.05,138.81 v2(29.69,138.46)
P3E_PESW_M2L_RX1_DP: length 212.2
  TOP w0.124: U34.AR6 v6(169.59,64.02)
  IN2 w0.099: 165.68,63.38 165.7,63.38 165.74,63.42 168.98,63.42 169.22,63.65 169.22,63.92 169.31,64.02 v6(169.59,64.02)
  IN2 w0.136: 165.68,63.38 163.26,63.38 124.6,71.07 109.01,74.98 83.67,80.02 76.21,82.28 73.31,82.86 73.06,83.22 73.15,83.69 73.05,83.85 72.43,83.98 72.27,83.87 72.18,83.4 71.83,83.17 51.68,87.17 49.31,88.16 43.76,91.12 34.35,97.4 31.11,105.23 28.94,107.4 28.5,108.46 28.37,109.11 28.26,111.4 28.32,111.98 27.78,113.27 27.78,113.27 26.69,114.9 23.21,116.34 22.62,116.93 22.62,118.84 21.73,123.33 20.86,125.43 20.81,125.54 20.84,125.59 20.84,128.55 19.17,132.56 19.17,134.23 23.91,138.96 24.16,139.07 29.28,139.07 v2(29.69,139.47)
  BOTTOM w0.124: J6.A31 40.17,139.79 40.27,139.7 40.27,138.56 39.83,138.13 38.11,138.13 37.94,138.3 37.56,138.3 37.38,138.13 36.5,138.13 35.39,137.66 33.22,137.66 32.54,138.34 32.54,138.59 32.28,138.85 32.03,138.85 31.76,139.12 31.39,139.12 31.21,139.3 30.84,139.3 30.66,139.12 29.9,139.12 29.69,139.33 v2(29.69,139.47)
P3E_PESW_M2L_RX2_DN: length 210.4
  TOP w0.124: U34.AP4 v6(167.59,65.02)
  IN2 w0.099: 165.59,64.66 165.62,64.66 165.66,64.62 167.9,64.62 168.01,64.73 168.01,64.91 167.9,65.02 v6(167.59,65.02)
  IN2 w0.136: v2(26.31,136.88) 25.98,137.21 25.29,137.21 24.82,137.02 24.21,136.4 24.21,136.2 23.92,135.91 23.72,135.91 23.43,135.63 23.43,135.43 23.14,135.14 22.95,135.14 22.66,134.85 22.66,134.65 22.37,134.37 22.17,134.37 21.16,133.35 20.95,132.85 20.95,131.43 21.29,130.61 21.47,130.53 21.63,130.16 21.55,129.97 22.45,127.81 23.85,120.78 23.85,117.61 24.05,117.41 24.23,117.34 24.82,117.1 26.5,117.1 27.86,115.74 29.27,113.63 30.31,111.12 30.31,110.02 29.8,108.8 29.8,108.51 29.95,108.16 32.11,106 35.3,98.28 41.45,94.18 48.34,91.32 50.68,91.32 52.39,89.61 55.48,88.33 58.58,87.05 58.83,87 61.59,87 64.44,88.18 65.23,88.18 68.17,86.96 77.39,86.96 78.08,86.83 78.11,86.82 89.4,82.15 100.31,78.84 108.28,77.25 123.98,72.49 152.13,66.89 152.29,66.99 152.69,66.91 152.79,66.76 153.19,66.68 153.35,66.78 153.75,66.7 153.85,66.55 154.25,66.47 154.41,66.57 154.81,66.49 154.91,66.34 155.31,66.26 155.46,66.36 155.86,66.28 155.97,66.13 156.37,66.05 156.52,66.15 156.92,66.07 157.03,65.92 157.43,65.84 157.58,65.94 157.98,65.86 158.09,65.7 158.49,65.62 158.64,65.73 159.04,65.65 159.14,65.49 163.34,64.66 165.59,64.66
  BOTTOM w0.124: v2(26.31,136.88) 26.61,137.18 31.57,137.18 32.58,136.17 35.76,136.17 36.14,136.33 36.3,136.33 36.41,136.44 41.32,136.44 43.57,138.7 43.57,139.7 43.67,139.79 J6.A17
P3E_PESW_M2L_RX2_DP: length 210.4
  TOP w0.124: U34.AP5 v6(168.59,65.02)
  IN2 w0.099: v6(168.59,65.02) 168.31,65.02 168.21,64.92 168.21,64.65 167.98,64.42 165.66,64.42 165.62,64.38 165.59,64.38
  IN2 w0.136: v2(26.31,137.9) 25.9,137.49 25.24,137.49 24.67,137.25 20.92,133.51 20.67,132.9 20.67,131.38 22.18,127.73 23.57,120.75 23.57,117.5 23.9,117.17 24.13,117.08 24.76,116.82 26.39,116.82 27.64,115.56 29.02,113.5 30.03,111.07 30.03,110.08 29.52,108.86 29.52,108.46 29.71,108 31.87,105.84 35.08,98.1 41.32,93.93 48.29,91.04 50.56,91.04 52.23,89.38 58.5,86.78 58.8,86.72 61.64,86.72 64.5,87.9 65.18,87.9 68.11,86.69 77.36,86.69 78.03,86.55 78.03,86.55 89.3,81.88 100.24,78.56 108.21,76.98 123.91,72.22 152.19,66.59 163.31,64.38 165.59,64.38
  BOTTOM w0.124: v2(26.31,137.9) 26.31,137.78 26.6,137.49 31.69,137.49 32.71,136.47 35.7,136.47 36.35,136.74 38.98,136.74 39.16,136.92 39.54,136.92 39.71,136.74 40.09,136.74 40.26,136.92 40.64,136.92 40.82,136.74 41.19,136.74 41.71,137.26 41.71,137.51 41.97,137.78 42.22,137.78 43.27,138.82 43.27,139.7 43.17,139.79 J6.A19
P3E_PESW_M2L_RX3_DN: length 207.8
  TOP w0.124: U34.AN5 v6(168.59,66.02)
  IN2 w0.099: 165.65,65.66 165.67,65.66 165.71,65.62 168.86,65.62 168.97,65.73 168.97,65.92 168.87,66.02 v6(168.59,66.02)
  IN2 w0.136: 165.65,65.66 163.73,65.66 123.49,73.66 108.93,78.08 100.37,79.78 98.02,80.5 97.93,80.66 97.54,80.78 97.37,80.69 96.98,80.81 96.9,80.97 96.51,81.09 96.34,81 95.95,81.12 95.86,81.29 95.47,81.41 95.31,81.32 94.92,81.44 94.83,81.6 94.44,81.72 94.27,81.63 93.88,81.75 93.8,81.92 93.41,82.03 93.24,81.95 92.85,82.06 92.76,82.23 92.37,82.35 92.21,82.26 91.82,82.38 91.73,82.54 91.34,82.66 91.18,82.57 90.1,82.9 78.52,87.7 76.32,88.13 67.94,88.13 65.58,89.11 64.26,89.11 61.43,87.94 59.01,87.94 53.27,90.32 51.31,92.27 48.55,92.27 41.98,94.99 36.22,98.84 33.95,104.34 32.7,110.61 32.18,111.86 30.68,113.36 27,118.87 25.11,120.76 24.51,122.23 24.51,124.48 25.54,126.99 25.54,127.53 23.92,131.45 23.92,132.95 27.86,136.9 37.59,136.9 37.76,136.72 38.14,136.72 38.31,136.9 38.69,136.9 38.87,136.72 39.24,136.72 39.42,136.9 39.94,136.9 41.23,137.43 41.64,137.43 41.78,137.29 42.19,137.29 42.33,137.43 43.06,137.43 43.28,137.34 v2(43.68,136.95)
  BOTTOM w0.124: v2(43.68,136.95) 44.13,137.13 46.11,137.13 46.57,137.59 46.57,139.7 46.67,139.79 J6.A5
P3E_PESW_M2L_RX3_DP: length 207.8
  TOP w0.124: U34.AN6 v6(169.59,66.02)
  IN2 w0.099: 165.65,65.38 165.67,65.38 165.71,65.42 168.95,65.42 169.17,65.64 169.17,65.92 169.27,66.02 v6(169.59,66.02)
  IN2 w0.136: v2(43.68,137.96) 43.42,137.71 41.14,137.71 41.12,137.69 39.89,137.18 27.75,137.18 23.64,133.07 23.64,131.4 25.26,127.48 25.26,127.04 24.23,124.53 24.23,122.17 24.88,120.6 26.78,118.69 30.47,113.18 31.94,111.7 32.43,110.53 33.67,104.28 33.68,104.25 36,98.65 41.85,94.74 48.49,91.99 51.2,91.99 53.11,90.08 58.96,87.66 61.49,87.66 64.32,88.83 65.52,88.83 67.88,87.85 76.3,87.85 78.44,87.43 90.01,82.64 100.3,79.51 108.86,77.81 123.43,73.39 163.7,65.38 165.65,65.38
  BOTTOM w0.124: v2(43.68,137.96) 44.2,137.44 44.57,137.44 44.75,137.62 45.12,137.62 45.3,137.44 45.99,137.44 46.27,137.72 46.27,138.09 46.09,138.27 46.09,138.64 46.27,138.82 46.27,139.7 46.17,139.79 J6.A7
P3E_PESW_M2L_TX0_C_DN: length 174.1
  TOP w0.124: v2(37.8,99.44) 37.74,99.44 37.44,99.14 37.44,98.71 37.62,98.53 37.62,98.16 37.44,97.98 37.44,97.61 37.62,97.43 37.62,97.06 37.44,96.88 37.44,96.41 37.79,96.05 38.05,96.05 38.31,95.79 38.31,95.54 38.92,94.92 40.72,94.92 49.01,91.49 49.99,91.49 51.43,90.89 51.95,90.38 52.34,89.43 52.34,87.78 52.74,87.38 53.97,87.38 56.91,86.17 58.49,83.79 59.32,83.35 60.37,83.09 61.35,83.09 63,82.4 65.57,79.84 70.88,77.64 83.5,70.07 94.42,65.55 95.17,64.8 98.1,63.59 98.97,63.59 109.87,59.07 121.93,56.66 123.5,56.82 131.14,55.29 134.32,55.93 137.49,55.29 140.67,55.93 143.84,55.29 149.77,56.48 150.59,56.82 150.93,56.82 C1013.2
  IN1 w0.136: v2(36.43,139) 36.06,138.63 36.06,135.83 36.6,133.13 36.6,130.56 36,129.13 36,126.91 36.35,126.08 36.35,124.75 35.93,124.12 34.92,123.71 34.69,123.47 34.48,122.96 34.48,121.63 35.02,120.33 35.02,116.72 35.38,115.84 35.38,113.99 36.38,111.57 36.38,109.88 35.81,108.49 35.81,104.45 37.41,100.58 37.41,99.83 v2(37.8,99.44)
  BOTTOM w0.124: J6.A47 36.17,139.95 36.07,139.86 36.07,139.35 v2(36.43,139)
P3E_PESW_M2L_TX0_C_DP: length 174.1
  TOP w0.124: C1014.2 150.93,56.51 150.65,56.51 149.86,56.19 143.84,54.98 140.67,55.62 137.49,54.98 134.32,55.62 131.14,54.98 123.49,56.51 121.91,56.35 109.78,58.78 98.91,63.28 98.04,63.28 95,64.54 94.25,65.29 83.36,69.8 70.74,77.37 65.4,79.58 62.83,82.15 61.29,82.79 60.33,82.79 59.21,83.07 58.28,83.56 56.71,85.92 53.91,87.08 52.61,87.08 52.04,87.66 52.04,89.37 51.69,90.2 51.26,90.63 49.92,91.19 48.95,91.19 40.66,94.62 38.8,94.62 37.14,96.28 37.14,99.09 v2(36.78,99.44)
  IN1 w0.136: v2(36.78,99.44) 37.13,99.79 37.13,100.52 35.53,104.39 35.53,108.55 36.1,109.93 36.1,111.52 35.1,113.94 35.1,115.79 34.74,116.66 34.74,120.28 34.2,121.57 34.2,123.02 34.45,123.63 34.77,123.94 35.74,124.35 36.07,124.83 36.07,126.02 35.72,126.85 35.72,129.18 36.32,130.61 36.32,133.11 35.78,135.8 35.78,138.63 v2(35.41,139)
  BOTTOM w0.124: J6.A49 35.67,139.95 35.77,139.85 35.77,139.35 v2(35.41,139)
P3E_PESW_M2L_TX0_DN: length 17.1
  TOP w0.099: 162.83,62.63 162.85,62.63 162.9,62.58 163.1,62.58 163.2,62.68 163.4,62.68 163.5,62.58 163.7,62.58 163.8,62.68 164,62.68 164.1,62.58 164.3,62.58 164.4,62.68 164.6,62.68 164.7,62.58 165.17,62.58 165.54,62.94 165.54,63.42 165.44,63.52 U34.AT1
  TOP w0.124: C1013.1 152.44,56.82 154.47,56.82 157.4,58.04 161.65,62.29 162.48,62.63 162.83,62.63
P3E_PESW_M2L_TX0_DP: length 17
  TOP w0.099: U34.AT2 165.86,63.52 165.74,63.4 165.74,62.86 165.26,62.38 162.9,62.38 162.85,62.33 162.83,62.33
  TOP w0.124: C1014.1 152.44,56.52 154.53,56.52 157.57,57.78 161.83,62.03 162.54,62.33 162.83,62.33
P3E_PESW_M2L_TX1_C_DN: length 176
  TOP w0.124: C1011.2 152.74,58.14 150.58,58.14 143.5,56.72 143.5,56.72 141.5,57.12 139.83,57.12 137.49,56.65 135.15,57.12 133.49,57.12 131.14,56.65 131.14,56.65 123.74,58.13 122.51,58.13 108.64,60.9 96.27,66.03 95.94,66.35 83.37,71.56 74.87,76.65 74.88,76.65 73.2,77.65 70.56,79.24 67.81,80.22 65.67,81.51 65.54,81.58 65.49,81.61 63.68,83.41 61.51,84.31 60.63,84.31 60.38,84.38 59.33,84.93 58.98,85.29 57.75,87.12 53.81,88.76 53.58,89.09 53.58,89.66 53.04,90.97 52.11,91.9 50.17,92.71 49.28,92.71 43.48,95.11 43.38,95.34 43.04,95.48 42.81,95.39 42.46,95.53 42.37,95.76 42.02,95.91 41.79,95.81 41.44,95.95 41.35,96.18 41,96.33 40.77,96.23 40.4,96.38 40.01,96.97 40.01,97.31 v2(40.36,97.66)
  IN1 w0.136: v2(40.36,97.66) 39.97,98.05 39.97,102.06 39.67,102.35 39.2,102.35 39.06,102.49 39.06,103.12 39.2,103.25 39.67,103.25 39.97,103.55 39.97,104.44 39.55,105.47 39.15,105.64 38.49,105.36 38.31,105.44 38.07,106.01 38.15,106.19 38.81,106.47 38.97,106.86 38.39,108.27 38.39,113.84 37.86,115.12 37.86,116.08 38.91,118.62 38.91,119.88 37.86,122.42 37.86,125.49 36.93,127.73 36.93,128.81 37.98,131.33 37.98,135.01 38.22,135.61 37.93,136.31 37.21,136.61 37.14,136.78 37.38,137.36 37.56,137.44 38.28,137.14 38.67,137.3 39.06,138.24 39.06,138.6 v2(39.43,138.97)
  BOTTOM w0.124: J6.A35 39.17,139.96 39.07,139.86 39.07,139.33 v2(39.43,138.97)
P3E_PESW_M2L_TX1_C_DP: length 176
  TOP w0.124: C1012.2 152.77,57.83 150.61,57.83 143.53,56.41 143.47,56.41 141.47,56.81 139.87,56.81 137.52,56.34 137.46,56.34 135.12,56.81 133.52,56.81 131.17,56.34 131.11,56.34 123.71,57.83 122.48,57.83 108.55,60.61 96.09,65.77 95.77,66.09 83.24,71.28 73.04,77.39 72.1,77.96 70.43,78.96 67.68,79.94 65.4,81.31 65.31,81.35 63.51,83.16 61.45,84.01 60.59,84.01 60.27,84.09 59.71,84.38 59.71,84.39 59.15,84.69 58.74,85.1 57.55,86.87 53.6,88.51 53.28,89 53.28,89.6 52.78,90.8 51.93,91.64 50.11,92.4 49.22,92.4 40.2,96.14 39.7,96.88 39.7,97.31 v2(39.35,97.66)
  IN1 w0.136: v2(38.41,138.97) 38.78,138.6 38.78,138.3 38.46,137.51 38.28,137.44 37.56,137.74 37.17,137.58 36.84,136.78 37,136.39 37.72,136.09 37.92,135.61 37.7,135.06 37.7,131.38 36.65,128.86 36.65,127.67 37.58,125.44 37.58,122.36 38.63,119.82 38.63,118.68 37.58,116.13 37.58,115.07 38.11,113.79 38.11,108.21 38.67,106.86 38.6,106.68 37.93,106.41 37.77,106.01 38.1,105.22 38.49,105.06 39.15,105.33 39.33,105.26 39.69,104.39 39.69,103.67 39.56,103.53 39.08,103.53 38.78,103.23 38.78,102.37 39.08,102.08 39.56,102.08 39.69,101.94 39.69,98.01 v2(39.35,97.66)
  BOTTOM w0.124: v2(38.41,138.97) 38.77,139.33 38.77,139.87 38.67,139.97 J6.A37
P3E_PESW_M2L_TX1_DN: length 15.9
  TOP w0.099: U34.AR2 166.43,64.52 166.53,64.42 166.53,64.22 166.43,64.12 165.52,64.12 165.42,64.22 165.22,64.22 165.12,64.12 164.92,64.12 164.67,64.02 164.53,64.07 164.35,64 164.29,63.86 164.01,63.74 163.75,63.74 163.65,63.85 163.45,63.85 163.35,63.74 162.73,63.74 162.68,63.79 162.66,63.79
  TOP w0.124: C1011.1 154.27,58.15 154.53,58.15 157.38,59.33 161.47,63.42 162.36,63.79 162.66,63.79
P3E_PESW_M2L_TX1_DP: length 15.8
  TOP w0.099: U34.AR3 166.85,64.52 166.74,64.41 166.74,64.14 166.52,63.92 164.96,63.92 164.05,63.54 162.73,63.54 162.68,63.49 162.66,63.49
  TOP w0.124: C1012.1 154.27,57.85 154.59,57.85 157.55,59.07 161.64,63.17 162.42,63.49 162.66,63.49
P3E_PESW_M2L_TX2_C_DN: length 168.3
  TOP w0.124: v2(41.83,98.96) 41.48,98.6 41.48,98.27 42.45,97.29 52.92,92.96 54.04,91.84 54.87,89.82 55.13,89.56 58.5,88.17 59.75,86.31 60.2,85.86 61.04,85.51 61.76,85.51 64.9,84.21 66.74,82.36 67.65,81.76 71.06,80.34 77.6,76.43 89.16,70.61 110.08,61.94 122.71,59.42 123.77,59.51 131.14,58.04 134.32,58.67 137.49,58.04 140.67,58.67 143.84,58.04 145.53,58.38 145.64,58.54 146,58.62 146.17,58.5 146.54,58.58 146.65,58.75 147.02,58.82 147.18,58.71 147.55,58.78 147.66,58.95 148.03,59.02 148.2,58.91 148.56,58.98 148.67,59.15 149.04,59.22 149.21,59.11 149.84,59.24 150.43,59.48 150.89,59.48 C1041.2
  IN1 w0.136: v2(42.43,138.97) 42.06,138.6 42.06,138.26 41.77,137.71 40.02,136.54 39.2,135.55 38.94,134.92 38.94,133.61 39.29,131.86 40.68,128.48 40.68,127.81 40.5,127.37 39.73,126.6 39.24,126.39 38.8,125.74 38.8,122.56 39.85,120.04 39.85,118.46 39.35,117.05 39.35,114.99 40.05,113.28 40.05,112.52 39.34,110.8 39.34,109.04 40.68,105.8 41.11,104.08 41.11,101.7 41.48,101.33 41.48,99.31 v2(41.83,98.96)
  BOTTOM w0.124: J6.A23 42.17,139.96 42.07,139.86 42.07,139.33 v2(42.43,138.97)
P3E_PESW_M2L_TX2_C_DP: length 168.3
  TOP w0.124: v2(40.82,98.96) 41.17,98.6 41.17,98.14 42.28,97.03 52.75,92.7 53.78,91.67 54.62,89.65 54.96,89.31 58.3,87.92 59.51,86.11 60.03,85.6 60.98,85.2 61.7,85.2 63.21,84.58 64.72,83.95 66.55,82.13 67.5,81.49 70.93,80.07 77.45,76.16 89.03,70.33 109.99,61.65 122.7,59.11 123.75,59.21 131.14,57.73 134.32,58.36 137.49,57.73 140.67,58.36 143.84,57.73 149.93,58.95 150.49,59.18 150.95,59.18 C1010.2
  IN1 w0.136: v2(40.82,98.96) 41.2,99.34 41.2,101.21 40.83,101.58 40.83,104.04 40.42,105.72 39.06,108.99 39.06,110.85 39.77,112.57 39.77,113.22 39.07,114.93 39.07,117.1 39.57,118.5 39.57,119.98 38.52,122.51 38.52,125.82 39.01,126.55 39.05,126.62 39.57,126.83 40.27,127.53 40.41,127.87 40.41,128.43 39.02,131.78 38.66,133.58 38.66,134.98 38.96,135.69 39.83,136.75 41.55,137.9 41.78,138.33 41.78,138.6 v2(41.41,138.97)
  BOTTOM w0.124: v2(41.41,138.97) 41.77,139.33 41.77,139.87 41.67,139.97 J6.A25
P3E_PESW_M2L_TX2_DN: length 16.7
  TOP w0.099: U34.AP1 165.45,65.52 165.54,65.42 165.54,65.04 165.43,64.92 164.86,64.92 164.76,65.02 164.56,65.02 164.46,64.92 164.26,64.92 164.16,65.02 163.96,65.02 163.86,64.92 163.66,64.92 163.56,65.02 163.36,65.02 163.26,64.92 163.06,64.92 163.01,64.97 162.99,64.97
  TOP w0.124: 162.99,64.97 162.42,64.97 161.14,64.44 157.41,60.71 154.52,59.51 152.43,59.51 C1041.1
P3E_PESW_M2L_TX2_DP: length 16.7
  TOP w0.099: 162.99,64.66 163.01,64.66 163.06,64.72 165.51,64.72 165.75,64.95 165.75,65.44 165.83,65.52 U34.AP2
  TOP w0.124: C1010.1 152.43,59.21 154.58,59.21 156.08,59.83 156.8,60.13 157.58,60.45 161.31,64.18 162.48,64.66 162.99,64.66
P3E_PESW_M2L_TX3_C_DN: length 168
  TOP w0.124: C1039.2 152.74,60.84 150.58,60.84 143.63,59.45 140.67,60.04 137.49,59.41 134.32,60.04 131.14,59.41 123.9,60.85 122.63,60.74 110.33,63.2 88.87,72.09 78.26,77.43 71.35,81.57 68.07,82.93 65.9,85.1 60.83,87.2 60.13,87.91 59.89,88.48 59.07,89.29 57.7,89.86 54.39,93.18 54.39,93.35 54.97,93.94 54.97,94.37 54.34,95 53.91,95 53.33,94.41 53.15,94.41 51.09,96.48 51.09,96.73 50.82,96.99 50.57,96.99 50.31,97.26 50.31,97.94 50.48,98.12 50.48,98.49 50.31,98.67 50.31,99.05 49.58,99.78 49.58,100.03 49.31,100.29 49.06,100.29 48.72,100.63 48.72,100.77 v2(49.12,101.17)
  IN1 w0.136: v2(49.12,101.17) 48.76,101.54 48.76,102.97 48.68,103.34 48.79,103.5 49.09,103.56 49.32,103.91 49.16,104.75 48.8,104.99 48.5,104.93 48.34,105.04 48.02,106.66 48.02,109.49 49.13,112.16 49.13,114.94 47.77,118.22 47.77,118.88 46.96,120.84 46.96,122.53 45.73,125.51 45.2,126.03 44.79,127.04 44.79,127.88 44.38,128.86 43.34,129.9 42.72,131.39 42.54,132.32 42.19,132.55 41.17,132.35 41.01,132.46 40.89,133.07 41,133.23 42.01,133.43 42.25,133.79 42.14,134.32 42.36,134.99 42.6,135.21 44.66,136.06 45.01,136.59 45.06,136.66 45.06,138.6 v2(45.43,138.97)
  BOTTOM w0.124: v2(45.43,138.97) 45.07,139.33 45.07,139.86 45.17,139.96 J6.A11
P3E_PESW_M2L_TX3_C_DP: length 168
  TOP w0.124: v2(48.11,101.17) 48.42,100.86 48.42,100.5 50,98.92 50,97.13 53.03,94.11 53.45,94.11 54.04,94.69 54.21,94.69 54.66,94.24 54.66,94.06 54.08,93.48 54.08,93.05 57.53,89.6 58.9,89.04 59.63,88.31 59.87,87.74 60.66,86.94 65.72,84.85 67.9,82.67 71.22,81.3 78.11,77.16 88.74,71.82 110.24,62.91 122.61,60.44 123.89,60.55 131.14,59.1 134.32,59.73 137.49,59.1 140.67,59.73 143.63,59.14 150.61,60.53 152.77,60.53 C1040.2
  IN1 w0.136: v2(44.41,138.97) 44.78,138.6 44.78,136.75 44.47,136.29 42.44,135.45 42.12,135.15 41.85,134.34 41.95,133.85 41.84,133.69 40.83,133.48 40.59,133.13 40.76,132.29 41.11,132.06 42.13,132.26 42.29,132.15 42.45,131.31 43.1,129.74 44.14,128.7 44.51,127.82 44.51,126.99 44.97,125.88 45.49,125.35 46.68,122.47 46.68,120.78 47.49,118.83 47.49,118.16 48.85,114.88 48.85,112.22 47.74,109.54 47.74,106.63 48.09,104.87 48.45,104.63 48.75,104.69 48.9,104.59 49.03,103.97 48.92,103.81 48.62,103.75 48.38,103.4 48.48,102.94 48.48,101.54 v2(48.11,101.17)
  BOTTOM w0.124: v2(44.41,138.97) 44.77,139.33 44.77,139.87 44.67,139.96 J6.A13
P3E_PESW_M2L_TX3_DN: length 15.6
  TOP w0.099: U34.AN2 166.39,66.52 166.49,66.42 166.49,66.22 166.39,66.12 165.62,66.12 165.52,66.22 165.32,66.22 165.22,66.12 165.02,66.12 164.92,66.22 164.72,66.22 164.62,66.12 164.42,66.12 164.32,66.22 164.12,66.22 164.02,66.12 163.82,66.12 163.72,66.22 163.52,66.22 163.42,66.12 163.22,66.12 163.17,66.17 163.15,66.17
  TOP w0.124: 163.15,66.17 162.56,66.17 160.83,65.46 157.38,62 154.61,60.85 154.27,60.85 C1039.1
P3E_PESW_M2L_TX3_DP: length 15.6
  TOP w0.099: U34.AN3 166.79,66.52 166.69,66.42 166.69,66.14 166.47,65.92 163.22,65.92 163.17,65.87 163.15,65.87
  TOP w0.124: C1040.1 154.27,60.55 154.67,60.55 157.55,61.74 161.01,65.2 162.62,65.87 163.15,65.87
PD_BOOTSTRAP_1: length 10.1
  TOP w0.112: U34.W35 199.6,80.01 202.08,80.01 204.88,82.8 205.77,82.8 R3159.2 R3136.1
PD_BOOTSTRAP_2: length 11.3
  TOP w0.112: R3137.1 v2(206.95,82.31) R3158.2 ; U34.W34 v6(198.59,80.02)
  IN2 w0.122: v2(206.95,82.31) 206.14,82.31 204.51,80.68 199.25,80.68 v6(198.59,80.02)
PD_BOOTSTRAP_4: length 10.9
  TOP w0.112: R3139.1 v2(206.95,80.25) R3156.2 ; U34.Y34 v6(198.59,79.02)
  IN2 w0.122: v2(206.95,80.25) 206.59,79.89 199.64,79.89 198.77,79.02 v6(198.59,79.02)
PD_BOOTSTRAP_5: length 11.5
  TOP w0.102: U34.W36 200.49,80.92 202.17,80.92 202.17,80.92
  TOP w0.112: 202.17,80.92 204.21,82.96 204.21,84.45 204.48,84.71 204.48,85.7 204.78,86 205.79,86 R3155.2 R3140.1
PD_BOOTSTRAP_6: length 20.2
  TOP w0.112: U34.W27 v6(191.59,80.02) ; R3142.1 206.98,85.51 v2(206.96,85.52) 206.95,85.51 R3154.2
  IN2 w0.122: v6(191.59,80.02) 192.13,80.56 197.93,80.56 198.41,81.05 203.32,81.05 206.96,84.69 v2(206.96,85.52)
PD_BOOTSTRAP_7: length 14.3
  TOP w0.112: U34.W31 v6(195.59,80.02) ; R3143.1 v2(206.95,81.29) R3153.2
  IN2 w0.122: v6(195.59,80.02) 196.08,79.53 198.89,79.53 199.63,80.27 205.93,80.27 v2(206.95,81.29)
PD_BOOTSTRAP_8: length 17.9
  TOP w0.112: R3144.1 R3152.2 205.86,78.61 204.96,78.61 204.07,77.72 202.62,77.72 v6(201.92,77.02) ; U34.Y28 v6(192.59,79.02)
  IN1 w0.122: v6(192.59,79.02) 193.1,78.51 193.1,77.79 193.39,77.5 201.43,77.5 201.91,77.03 201.91,77.03 v6(201.92,77.02)
PD_BOOTSTRAP_9: length 19.5
  TOP w0.112: R3145.1 R3151.2 205.85,76.58 204.92,76.58 204.21,77.3 202.82,77.3 v6(202.55,77.02) ; U34.Y27 v6(191.59,79.02)
  IN1 w0.122: v6(202.55,77.02) 202.05,76.52 198.37,76.52 197.83,77.06 196.44,77.06 195.85,76.48 195.29,76.48 194.56,77.2 193.36,77.2 193.07,77.5 192.33,77.5 192.05,77.77 192.05,78.56 v6(191.59,79.02)
PD_DB1200_SMB_SA0: length 6.1
  TOP w0.112: R2963.2 61.77,69.5 R2969.1 60.76,68.91 61.09,68.58 61.86,68.58 v1(62.11,68.33) 62.11,67.32 62.71,66.73 U47.11
PD_DB1200_SMB_SA1: length 7.8
  TOP w0.112: U47.14 61.21,66.3 61.02,66.49 58.44,66.49 v1(58.25,66.68) 57.63,67.3 R2971.1 56.65,69.48 R2970.2
PD_EEPROM_A0: length 4.8
  TOP w0.112: U56.1 174.9,118.19 v1(174.27,118.82) 173.51,118.06 R3132.1 R3128.2
PD_EEPROM_A1: length 4.2
  TOP w0.112: U56.2 v1(174.27,116.92) 173.76,116.92 173.63,117.04 R3131.1 R3127.2
PD_EEPROM_A2: length 4.5
  TOP w0.112: U56.3 175.16,115.65 174.52,115.01 v1(174.27,115.01) R3126.2 R3130.1
PD_EEPROM_WC_N: length 4.7
  TOP w0.112: R3129.1 R3125.2 v1(183.67,116.87) 183.34,116.87 183.29,116.92 U56.7
PD_FRU_WC_N: length 2.9
  TOP w0.112: U6.7 13.56,36.73 v1(13.49,36.8) 13.49,37.92 R15.2
PD_I2C_GPIO_A0: length 2.6
  BOTTOM w0.112: U101.18 v3(83.21,50.34) R4158.2
PD_I2C_GPIO_A1: length 3.3
  BOTTOM w0.112: U101.23 79.04,48.89 v3(78.05,47.9) 77.8,47.65 R4161.2
PD_I2C_GPIO_A2: length 4
  BOTTOM w0.112: U101.24 78.54,48.84 78.32,48.61 77.48,48.61 v3(76.76,47.89) R4162.2
PD_I2C_MUX1_A0: length 4.5
  TOP w0.112: U88.2 21.95,76.5 23.42,77.98 v1(23.42,78.38) R3806.1
PD_I2C_MUX1_A1: length 4.3
  TOP w0.112: R3807.1 20.65,65.73 v1(20.65,66.9) U88.13
PD_I2C_MUX2_A0: length 6.9
  TOP w0.112: U89.2 30.15,73.12 30.47,73.45 v1(32.19,73.45) 32.58,73.84 32.58,75.92 R3819.1
PD_I2C_MUX2_A1: length 4.3
  TOP w0.112: R3820.1 v1(29.29,63.25) 29.29,63.75 28.85,64.18 U89.13
PD_I2C_MUX3_A0: length 6.1
  TOP w0.112: R3832.1 38.71,76.11 38.71,74.17 v1(39.06,73.82) 39.02,73.78 38.15,73.78 37.47,73.1 U90.2
PD_I2C_MUX3_A1: length 4.3
  TOP w0.112: R3833.1 v1(36.6,63.22) 36.6,63.72 36.17,64.16 U90.13
PD_I2C_MUX4_A0: length 7
  TOP w0.112: R3845.1 25.82,39.97 25.82,39.49 25.01,38.67 25.01,37.96 25.58,37.39 v1(25.58,37.06) 25.27,36.75 24.56,36.75 23.72,35.92 U91.2
PD_I2C_MUX4_A1: length 3.6
  TOP w0.112: U91.13 22.42,30.68 23.04,31.29 v2(23.04,31.45)
  BOTTOM w0.112: R3846.1 v2(23.04,31.45)
PD_I2C_MUX5_A0: length 6.6
  TOP w0.112: R3858.1 47.29,76.09 v1(47.29,73.67) 46.7,73.08 45.19,73.08 45.06,72.95 U92.2
PD_I2C_MUX5_A1: length 4.3
  TOP w0.112: R3859.1 v1(44.2,63.22) 44.2,63.73 43.76,64.17 U92.13
PD_I2C_MUX6_A0: length 5.9
  TOP w0.112: R3871.1 30.94,95.37 30.94,93.38 v1(31.26,93.06) 30.56,92.36 29.92,92.36 29.67,92.11 U93.2
PD_I2C_MUX6_A1: length 4.3
  TOP w0.112: R3872.1 v1(28.8,82.45) 28.8,82.96 28.37,83.39 U93.13
PD_I2C_MUX7_A0: length 2.6
  TOP w0.112: U108.2 v2(31.82,30.98)
  BOTTOM w0.112: R4369.1 31.91,30.98 v2(31.82,30.98)
PD_I2C_MUX7_A1: length 10.3
  TOP w0.112: R4370.1 24.93,20.76 27.85,23.68 30.18,23.68 v1(30.52,24.02) U108.13
PD_INA230_A0: length 2.8
  BOTTOM w0.112: R3.1 v3(98.15,39.44) 98.12,39.41 U2.2
PD_INA230_A1: length 4.3
  BOTTOM w0.112: R4.1 95.11,37.47 v3(96.57,38.93) 97.2,38.93 97.62,38.51 U2.1
PD_M2A_PWRDIS: length 10.9
  TOP w0.112: v2(23.1,130.51) 21.83,129.25 21.83,128.05 20.68,126.89 J4.B6 20.68,123.59 R4099.2
  BOTTOM w0.112: v2(23.1,130.51) 23.1,131.09 23.43,131.42 23.43,132.41 23.18,132.66 R4100.1
PD_M2B_PWRDIS: length 33.3
  TOP w0.112: v2(43.3,127.08) 44.34,127.08 44.68,126.74 J4.A6
  IN2 w0.122: v2(50.93,135.53) 50.93,135.39 50.59,135.06 50.59,134.03 49.42,132.86 49.42,131.42 48.76,130.77 46.32,130.77 45.54,131.55 43.45,131.55 42.1,130.2 42.1,129.74 41.24,128.89 41.24,127.79 42.09,126.94 43.16,126.94 v2(43.3,127.08)
  BOTTOM w0.112: v2(50.93,135.53) 50.93,141.31 52.8,143.19 R4104.1 R4103.2 52.8,145.56 52.94,145.69 54.42,145.69 v3(54.47,145.74)
PD_M2C_PWRDIS: length 30.6
  TOP w0.112: J36.B6 68.68,126.85 68.44,127.09 66.13,127.09 65.53,127.69 65.53,129.05 64.89,129.69 64.89,134.79 63.38,136.3 63.19,136.3 63.08,136.42 57.44,136.42 56.24,137.62 v1(56.24,138.18) 56.24,139.61 v2(60.04,143.41)
  BOTTOM w0.112: R4107.2 R4108.1 v2(60.04,143.41)
PD_M2D_PWRDIS: length 41.7
  TOP w0.112: J36.A6 92.68,126.79 92.25,127.22 91.53,127.22 91.13,126.82 91.13,126.52 90.88,126.27 89.98,126.27 89.29,126.96 89.29,129.96 88.34,130.9 88.34,135.24 87.93,135.65 86.6,135.65 86.39,135.86 81.07,135.86 78.66,138.26 v1(78.66,140.54) 78.66,141.6 77.78,142.49 68.99,142.49 68.9,142.58 v2(68.02,142.58)
  BOTTOM w0.112: v2(68.02,142.58) 68.12,142.68 R4112.1 R4111.2
PD_M2E_PWRDIS: length 35.9
  TOP w0.112: R4116.1 128.12,143.08 R4115.2 128.96,141.84 v1(128.69,141.57) 128.69,141.28 126.74,139.34 126.74,138.33 125.83,137.42 120.04,137.42 118.67,136.05 117.32,136.05 116.2,137.17 114.37,137.17 113.78,136.59 113.78,135.23 112.65,134.1 112.65,127.59 113.55,126.69 115.18,126.69 115.46,126.97 116.41,126.97 116.68,126.7 J38.B6
PD_M2F_PWRDIS: length 24.7
  TOP w0.112: v2(142.44,142.85) v1(141.69,142.1) 140.72,141.13 140.72,138.84 140.22,138.34 139.8,138.34 139.2,137.73 139.2,136.04 138.6,135.44 138.21,135.44 137.04,134.27 137.04,127.88 138.04,126.88 139.13,126.88 139.4,127.16 140.52,127.16 140.68,127 J38.A6
  BOTTOM w0.112: R4119.2 R4120.1 v2(142.44,142.85)
PD_M2G_PWRDIS: length 10.5
  IN1 w0.122: v4(166.08,131.32) 166.76,131.32 168.28,129.8 169.93,129.8 171.35,128.38 171.35,127.78 v2(171.38,127.75)
  BOTTOM w0.112: R4123.2 171.37,127.74 v2(171.38,127.75) R4124.1 ; v4(166.08,131.32) 166.42,131.66 166.42,133.22 J8.B6
PD_M2H_PWRDIS: length 13.9
  TOP w0.112: v2(142.62,134.82) 142.62,134.98 142.89,135.25 142.89,137 146.71,140.82 146.71,142.68 v4(146.7,142.69)
  BOTTOM w0.112: v4(146.7,142.69) 147.08,143.08 147.59,143.08 147.7,143.19 R4128.1 R4127.2 ; J8.A6 142.42,134.62 v2(142.62,134.82)
PD_M2I_PWRDIS: length 25.1
  TOP w0.112: R4131.2 R4132.1 128.97,143.8 129.23,143.54 130.37,143.54 130.74,143.17 130.74,141.52 v1(130.37,141.15) 129.91,140.69 128.59,140.69 127.31,139.4 v2(127.31,139.02)
  IN1 w0.122: v2(127.31,139.02) 125.66,137.38 122.87,137.38 121.59,138.65 120.03,138.65 118.93,137.55 v2(118.3,137.55)
  BOTTOM w0.112: J34.B6 118.42,135.32 117.78,135.97 117.78,137.03 v2(118.3,137.55)
PD_M2J_PWRDIS: length 31.2
  TOP w0.112: v2(94.78,134.76) 93.97,135.57 91.99,135.57 91.11,136.44 87.36,136.44 87.15,136.65 81.4,136.65 80.7,137.35 80.7,141.88 v1(80.05,142.53) 79.3,143.28 73.31,143.28 v2(73.12,143.46)
  BOTTOM w0.112: J34.A6 94.42,134.41 v2(94.78,134.76) ; R4135.2 R4136.1 v2(73.12,143.46)
PD_M2K_PWRDIS: length 17.6
  TOP w0.112: v2(66.51,142.62) 67.11,142.62 67.67,142.06 70.21,142.06 v1(73.3,138.96) 73.3,138.02 70.86,135.58 70.86,134.99 v2(70.6,134.73)
  BOTTOM w0.112: v2(66.51,142.62) 66.47,142.66 R4140.1 R4139.2 ; v2(70.6,134.73) 70.42,134.55 J6.B6
PD_M2L_PWRDIS: length 23.7
  TOP w0.112: v2(49,137.91) 49.54,137.91 50.56,138.93 50.56,141.53 47.78,144.31 v2(46.87,144.31)
  IN1 w0.122: v2(46.93,131.88) 47.65,131.88 48.06,131.48 48.77,131.48 49.41,132.13 49.41,132.37 49.99,132.94 49.99,136.92 v2(49,137.91)
  BOTTOM w0.112: R4144.1 47.06,144.12 v2(46.87,144.31) v3(46.07,144.31) ; R4143.2 47.84,130.98 v2(46.93,131.88) 46.79,131.88 46.42,132.26 J6.A6
PD_PESW_THERM_BASS: length 20.2
  TOP w0.112: R3282.2 204.96,103.33 v2(203.73,103.33) ; U34.J29 v6(193.59,91.02)
  IN2 w0.122: v2(203.73,103.33) 203.42,103.02 203.42,102.55 200.13,99.26 200.13,97.86 198.74,96.48 198.16,96.48 196.49,94.81 195.27,94.81 195.07,94.61 195.07,92.84 194.64,92.4 194.48,92.4 194.16,92.08 194.16,91.97 193.59,91.4 v6(193.59,91.02)
PD_PESW_THERM_EMIT: length 19.1
  TOP w0.112: v2(204.24,102.82) 205.31,102.82 R3281.2 ; U34.J30 v6(194.59,91.02)
  IN2 w0.122: v2(204.24,102.82) 203.74,102.32 203.74,101.7 201.27,99.23 201.27,97.79 201.02,97.54 200.34,97.54 199.06,96.25 199.06,95.85 198.7,95.5 198.1,95.5 197.47,94.87 197.05,94.87 196.12,93.94 196.12,92.69 196.03,92.6 195.26,92.6 195.09,92.43 195.09,91.52 v6(194.59,91.02)
PD_PESW_VSS_AH31: length 1.6
  TOP w0.112: U34.AH31 v6(195.59,71.02)
  BOTTOM w0.112: R3005.2 194.92,71.02 v6(195.59,71.02)
PD_PESW_VSS_J28: length 1.6
  TOP w0.381: U34.J28 v6(192.59,91.02)
  BOTTOM w0.279: R2910.1 192.44,90.87 v6(192.59,91.02)
PD_PESW_VSS_P27: length 1.3
  TOP w0.457: v6(191.62,85.96) 191.52,85.96 U34.P27
  BOTTOM w0.254: v6(191.62,85.96) 191.48,86.09 R3004.2
PD_TPIN: length 8.6
  TOP w0.112: U34.R29 v6(193.59,85.02)
  BOTTOM w0.112: v6(193.59,85.02) 194.07,84.54 194.07,83.85 194.32,83.6 200.06,83.6 R3257.2
PD_UART_PESW_UCTSB: length 1.6
  TOP w0.112: U34.T27 v6(191.59,84.02)
  BOTTOM w0.112: v6(191.59,84.02) 191.64,83.97 R3256.2
PD_ZL30281_AC0: length 6.6
  TOP w0.112: U61.28 123.37,38.18 v2(123.95,37.61) 124.14,37.41 R3230.2 125.51,37.82 125.62,37.93 127.74,37.93 127.92,37.75 R3231.1
PD_ZL30281_AC1: length 6.8
  TOP w0.112: R3233.1 127.92,36.73 127.74,36.91 125.62,36.91 125.51,36.8 R3232.2 v2(124.82,36.4) 124.5,36.4 123.22,37.68 U61.27
PD_ZL30281_IF1: length 4.4
  TOP w0.112: R3236.2 R3237.1 123.13,42.92 v2(122.71,42.49) 121.69,41.48 U61.1
PD_ZL30281_TEST: length 6.2
  TOP w0.112: R3240.1 v2(127.2,35.38) 126.93,35.38 126.47,35.85 124.65,35.85 123.32,37.18 U61.26
PU_25M_BMC_CLK_EN_R: length 1.6
  TOP w0.112: R3765.2 32.36,36.51 32.37,36.53 OSC1.1
PU_BOOTSTRAP_0: length 14.2
  TOP w0.102: U34.V34 198.49,81.12 201.56,81.12 201.63,81.19
  TOP w0.112: 201.63,81.19 201.82,81.19 203.94,83.31 203.94,84.56 204.21,84.82 204.21,86.65 204.63,87.07 205.86,87.07 206.32,87.54 R3160.2 R3141.1
PU_BOOTSTRAP_3: length 9.5
  TOP w0.112: R3138.1 R3157.2 205.81,84.99 205.12,84.99 204.48,84.34 204.48,82.85 202.14,80.52 U34.W37
PU_BOOTSTRAP_10: length 18.2
  TOP w0.112: R3146.1 v2(207,79.18) R3150.2 ; U34.AA27 v6(191.59,78.02)
  IN2 w0.122: v6(191.59,78.02) 191.61,78.02 192.14,78.54 201.77,78.54 202.75,79.52 205.96,79.52 206.31,79.18 v2(207,79.18)
PU_CPLD_JTAGENB: length 2.2
  TOP w0.112: v4(17.95,46.15) 17.36,45.56 R4274.1
  BOTTOM w0.112: U94.C10 v4(17.95,46.15)
PU_CPLD_PROGRAMN: length 7.6
  BOTTOM w0.112: U94.B10 17.91,45.19 17.91,44.52 v3(21.23,41.2) 20.07,40.05 R3923.1
PU_CPLD_SN: length 5.3
  TOP w0.112: R3922.1 21.73,59.16 v4(19.96,59.16)
  BOTTOM w0.112: v4(19.96,59.16) U94.R12
PU_DB1200_100M: length 6.6
  TOP w0.112: R2967.2 R2964.1 67.54,69.82 67.54,68.76 67.2,68.42 v1(67.2,67.76) 66.89,67.76 66.21,67.08 U47.4
PU_DB1200_HI_BW: length 6.2
  TOP w0.112: U47.5 65.71,67.18 65.91,67.38 v1(65.91,67.78) 65.91,68.7 66.5,69.29 66.5,69.84 R2966.1 R2968.2
PU_I2C_MUX1_SC2: length 4.7
  TOP w0.112: U88.10 18.69,69.48 17.6,68.39 R3301.2
PU_I2C_MUX1_SC3: length 4.5
  TOP w0.112: U88.12 19.99,68.43 20.06,68.37 v1(20.06,68.27) 20.06,66.15 R2799.2
PU_I2C_MUX1_SD2: length 5.8
  TOP w0.112: U88.9 17.95,69.2 17.66,68.91 16.56,68.91 16.24,68.59 v1(16.24,67.94) 16.59,67.59 R3302.2
PU_I2C_MUX1_SD3: length 5
  TOP w0.112: U88.11 19.34,69.21 19.47,69.09 19.47,67.93 18.6,67.06 v1(18.39,67.06) 18.39,66.38 18.62,66.15 R2800.2
PU_I2C_MUX2_SC2: length 4.4
  TOP w0.112: U89.10 v1(26.9,64.54) 26.9,64.08 26.24,63.42 R3825.2
PU_I2C_MUX2_SC3: length 4.2
  TOP w0.112: U89.12 v1(28.2,64.52) 28.2,63.34 28.27,63.26 R3822.2
PU_I2C_MUX2_SD2: length 4.6
  TOP w0.112: U89.9 26.15,64.52 25.22,63.59 v1(25.22,63.27) R3824.2
PU_I2C_MUX2_SD3: length 4.3
  TOP w0.112: R3823.2 v1(27.25,63.25) 27.25,63.54 27.55,63.84 U89.11
PU_I2C_MUX3_SC2: length 4.4
  TOP w0.112: R3838.2 33.56,63.39 34.22,64.05 v1(34.22,64.52) U90.10
PU_I2C_MUX3_SC3: length 4.2
  TOP w0.112: U90.12 v1(35.52,64.52) 35.52,63.31 35.59,63.24 R3835.2
PU_I2C_MUX3_SD2: length 4.6
  TOP w0.112: U90.9 33.47,64.81 32.54,63.88 v1(32.54,63.2) R3837.2
PU_I2C_MUX3_SD3: length 4.3
  TOP w0.112: U90.11 34.87,63.82 34.57,63.52 v1(34.57,63.2) R3836.2
PU_I2C_MUX4_SC2: length 3.5
  TOP w0.112: U91.10 20.47,30.17 v2(20.29,30.35)
  BOTTOM w0.112: v2(20.29,30.35) 20.29,32.29 R3851.2
PU_I2C_MUX4_SC3: length 3.4
  TOP w0.112: U91.12 v2(21.77,30.35)
  BOTTOM w0.112: v2(21.77,30.35) 21.77,32.35 R3848.2
PU_I2C_MUX4_SD2: length 3.6
  TOP w0.112: v2(19.45,31.39) 19.72,31.12 U91.9
  BOTTOM w0.112: R3850.2 18.97,31.87 v2(19.45,31.39)
PU_I2C_MUX4_SD3: length 3.4
  TOP w0.112: U91.11 21.12,31.35 v2(21.03,31.45)
  BOTTOM w0.112: R3849.2 21.03,32.57 v2(21.03,31.45)
PU_I2C_MUX5_SC2: length 4.4
  TOP w0.112: U92.10 v1(41.81,64.52) 41.81,64.06 41.15,63.4 R3864.2
PU_I2C_MUX5_SC3: length 4.2
  TOP w0.112: R3861.2 43.18,63.25 43.11,63.32 v1(43.11,64.52) U92.12
PU_I2C_MUX5_SD2: length 4.6
  TOP w0.112: R3863.2 40.13,63.02 v1(40.32,63.2) 41.06,63.94 U92.9
PU_I2C_MUX5_SD3: length 4.3
  TOP w0.112: U92.11 42.46,63.82 42.16,63.53 v1(42.16,63.2) R3862.2
PU_I2C_MUX6_SC2: length 4.4
  TOP w0.112: U93.10 v1(26.42,83.75) 25.76,83.09 R3877.2
PU_I2C_MUX6_SC3: length 4.2
  TOP w0.112: U93.12 v1(27.72,83.75) 27.72,82.54 27.79,82.47 R3874.2
PU_I2C_MUX6_SD2: length 4.8
  TOP w0.112: U93.9 25.67,84.88 25.99,84.56 25.99,84.35 25.67,84.03 25.67,83.62 24.74,82.69 v1(24.74,82.43) R3876.2
PU_I2C_MUX6_SD3: length 4.3
  TOP w0.112: U93.11 27.07,83.05 26.77,82.75 v1(26.77,82.43) R3875.2
PU_I2C_MUX7_SC3: length 8.8
  TOP w0.112: R4372.2 25.07,21.79 v1(25.2,21.92) 27.28,24 29.19,24 29.87,24.68 U108.12
PU_I2C_MUX7_SD3: length 7.9
  TOP w0.112: R4373.2 25.59,22.81 25.97,23.19 25.97,23.71 v1(26.7,24.43) 28.61,24.43 29.22,25.04 U108.11
PU_INA231_M2A_A0: length 7.1
  TOP w0.112: U73.B3 36.74,114.39 36.08,113.73 33.99,113.73 v1(33.18,112.92) 33.18,112.45 34.42,111.22 R3619.2
PU_INA231_M2A_A1: length 8
  TOP w0.112: R3622.2 33.1,111.04 33.1,111.99 32.5,112.58 32.5,113.85 v1(33.27,114.62) 33.99,114.62 34.39,114.22 36.04,114.22 36.34,114.52 U73.C3
PU_INA231_M2B_A0: length 5.7
  TOP w0.112: R3713.2 57.4,112.78 v1(57.94,113.32) 60.56,113.32 61.43,114.19 U74.B3
PU_INA231_M2B_A1: length 5.1
  TOP w0.112: U74.C3 61.03,114.4 60.78,114.14 58.76,114.14 58.32,114.59 v1(57.94,114.59) 57.19,113.84 R3630.2
PU_INA231_M2C_A0: length 7.1
  TOP w0.112: U75.B3 86.22,114.58 84.94,113.31 84.94,112.6 83.98,111.64 v1(83.11,111.64) 82.01,111.64 R3634.2
PU_INA231_M2C_A1: length 5.4
  TOP w0.112: R3728.2 v1(82.68,113.26) 84.45,113.26 85.82,114.63 U75.C3
PU_INA231_M2D_A0: length 6.5
  TOP w0.112: U76.B3 111.43,113.2 110.08,111.86 108.48,111.86 v1(108.05,111.43) 108.05,111.04 108.55,110.55 R3730.2
PU_INA231_M2D_A1: length 5.8
  TOP w0.112: R3729.2 106.76,112.68 107.09,113.02 v1(107.97,113.02) 110.39,113.02 111.03,113.66 U76.C3
PU_INA231_M2E_A0: length 6.2
  TOP w0.112: U77.B3 135.33,113.94 133.06,111.68 v1(131.86,111.68) 131.86,111.22 132.48,110.6 R3731.2
PU_INA231_M2E_A1: length 5.8
  TOP w0.112: U77.C3 134.93,114 134.58,113.66 132.36,113.66 v1(131.84,113.13) 130.8,112.1 R3651.2
PU_INA231_M2F_A0: length 5.9
  TOP w0.112: U78.B3 163.8,121 164.25,120.55 164.25,119.15 163.38,118.28 163.38,117.83 v1(163.08,117.54) 162.4,116.85 162.4,116.75 R3732.2
PU_INA231_M2F_A1: length 6.1
  TOP w0.112: R3658.2 161.53,116.9 v1(161.53,117.53) 162.06,118.06 162.08,118.06 162.58,118.56 163.26,118.56 163.96,119.26 163.96,120.4 163.75,120.6 U78.C3
PU_INA231_M2G_A0: length 6.2
  BOTTOM w0.112: R3726.2 154,112.83 v3(152.74,114.09) 152.49,114.34 152.49,115.82 151.15,117.17 U84.B3
PU_INA231_M2G_A1: length 7.6
  BOTTOM w0.112: R3727.2 155.53,113.61 v3(154.02,115.12) 153.76,115.38 153.76,115.99 151.89,117.86 151.33,117.86 151.04,117.57 U84.C3
PU_INA231_M2H_A0: length 6.5
  BOTTOM w0.112: U83.B3 123.53,114.06 123.68,113.91 123.68,112.12 124.75,111.04 v3(125.68,111.04) 125.68,110.47 124.97,109.76 R3719.2
PU_INA231_M2H_A1: length 7.1
  BOTTOM w0.112: U83.C3 123.5,114.46 124.07,113.89 124.07,112.89 124.5,112.46 v3(125.99,112.46) 126.24,112.22 126.24,110.19 125.81,109.76 R3720.2
PU_INA231_M2I_A0: length 5.9
  BOTTOM w0.112: R3711.2 102.06,110.15 v3(102.06,110.62) 102.06,111.55 99.87,113.74 U82.B3
PU_INA231_M2I_A1: length 7
  BOTTOM w0.112: R3712.2 102.68,109.71 102.68,111.82 v3(102.18,112.32) 102.18,113 101.03,114.14 U82.C3
PU_INA231_M2J_A0: length 6.7
  BOTTOM w0.112: R3704.2 78.28,109.39 v3(78.28,110.27) 76.93,111.62 76.03,111.62 74.33,113.33 U81.B3
PU_INA231_M2J_A1: length 7.6
  BOTTOM w0.112: R3705.2 79.13,110.25 v3(77,112.38) 75.65,113.73 U81.C3
PU_INA231_M2K_A0: length 5.9
  BOTTOM w0.112: R3697.2 51.92,111.34 v3(51.92,111.58) 51.77,111.58 49.98,113.37 49.98,114.37 49.74,114.61 U80.B3
PU_INA231_M2K_A1: length 7
  BOTTOM w0.112: U80.C3 49.94,115.01 51.81,113.14 v3(52.29,113.14) 52.86,112.57 52.86,111.19 R3698.2
PU_INA231_M2L_A0: length 12.7
  BOTTOM w0.112: R3678.2 37.86,110.77 37.56,111.07 36.94,111.07 36.16,111.85 32.23,111.85 31.5,112.57 v3(29.31,112.57) 27.37,112.57 27.01,112.93 U79.B3
PU_INA231_M2L_A1: length 12.9
  BOTTOM w0.112: U79.C3 28.35,113.33 v3(29.3,114.28) 30.29,113.29 31.2,113.29 32.37,112.12 36.29,112.12 36.59,111.81 R3691.2
PU_M2A_CLKREQ_N: length 5
  TOP w0.112: R2777.1 v1(33.55,122.68) 33.55,123.37 33.2,123.71 33.2,123.96 32.56,124.59 32.56,124.79 32.18,125.18 J4.B52
PU_M2A_PLA_S3_N: length 7.4
  TOP w0.112: R4262.1 30.38,121.18 29.32,121.18 28.66,121.83 v1(28.66,122.6) 28.66,123.16 26.68,125.13 J4.B30
PU_M2A_VIO_1V8: length 13.6
  TOP w0.112: J4.B22 24.68,127.03 v2(24.47,127.23)
  BOTTOM w0.112: v2(24.47,127.23) 24.47,129.48 26.56,131.56 26.56,133.09 26.4,133.25 25.38,133.25 24.63,134 23.46,134 R4234.2
PU_M2B_CLKREQ_N: length 3.8
  TOP w0.112: J4.A52 56.18,125.2 56.51,124.88 56.87,124.72 57.32,124.28 v2(57.32,124) 57.8,123.52 R2774.1
PU_M2B_PLA_S3_N: length 5.6
  TOP w0.112: J4.A30 50.68,125.21 50.98,124.9 51.53,124.9 51.91,124.52 51.91,123.98 52.58,123.31 52.58,122.44 R4263.1
PU_M2B_VIO_1V8: length 4.1
  TOP w0.112: J4.A22 48.68,125.09 48.86,124.91 48.99,124.91 50.67,123.23 R4236.2
PU_M2C_CLKREQ_N: length 3.7
  TOP w0.112: R2894.1 80.96,124.02 80.92,124.02 80.19,124.74 v2(80,124.74) 80,124.96 80.18,125.15 J36.B52
PU_M2C_PLA_S3_N: length 6
  TOP w0.112: J36.B30 74.68,125.26 75.24,124.71 75.24,123.55 v1(76.4,122.39) 77.5,121.29 R4264.1
PU_M2C_VIO_1V8: length 4.7
  TOP w0.112: R4238.2 74.4,122.77 74.01,123.16 74.01,123.64 72.68,124.96 J36.B22
PU_M2D_CLKREQ_N: length 4.5
  TOP w0.112: R2891.1 v1(104.18,122.68) 104.18,122.68 J36.A52
PU_M2D_PLA_S3_N: length 4.7
  TOP w0.112: J36.A30 98.68,125.27 99.15,124.8 v1(99.15,122.68) 99.15,121.66 R4265.1
PU_M2D_VIO_1V8: length 34.2
  TOP w0.112: v2(97.92,127.65) 97.73,127.83 97.09,127.83 96.68,127.42 J36.A22
  IN2 w0.122: v2(76.3,143.79) 76.79,143.79 79.11,141.48 79.11,139.23 81.63,136.7 83.05,136.7 84.56,135.2 84.56,134.54 87.99,131.11 93.27,131.11 95.9,130.03 96.65,130.03 96.98,129.7 96.98,128.59 v2(97.92,127.65)
  BOTTOM w0.112: v2(76.3,143.79) 76.76,144.25 R4240.2
PU_M2E_CLKREQ_N: length 3.4
  TOP w0.112: R2900.1 129.72,123.25 v2(128.18,124.79) 128.18,125.97 J38.B52
PU_M2E_PLA_S3_N: length 6
  TOP w0.112: R4266.1 125.37,121.66 v1(124.65,122.38) 123.99,123.04 123.99,123.96 122.68,125.26 J38.B30
PU_M2E_VIO_1V8: length 4.3
  TOP w0.112: R4242.2 122.22,122.59 121.46,123.34 121.46,124.5 120.68,125.28 J38.B22
PU_M2F_CLKREQ_N: length 3.3
  TOP w0.112: R2897.1 153,123.98 152.63,123.98 v2(152.25,124.36) 152.18,124.42 152.18,125.97 J38.A52
PU_M2F_PLA_S3_N: length 5.8
  TOP w0.112: R4267.1 148.52,122.31 v1(148.37,122.46) 147.76,123.07 147.76,124.14 146.68,125.22 J38.A30
PU_M2F_VIO_1V8: length 5.2
  TOP w0.112: J38.A22 144.68,125.97 144.68,124.95 146.15,123.48 146.15,122.87 147.02,122 R4244.2
PU_M2G_CLKREQ_N: length 5.2
  BOTTOM w0.112: J8.B52 154.92,132.46 155.53,131.85 155.53,130.73 155.19,130.39 154.95,130.39 154.63,130.07 v3(154.63,129.98) 154.63,128.92 R2789.1
PU_M2G_PLA_S3_N: length 11.6
  BOTTOM w0.112: J8.B30 160.42,133.22 160.42,132.39 159.8,131.77 159.8,130.5 159.52,130.22 157.51,130.22 156.69,129.4 156.69,126.05 v3(156.45,125.81) 156.45,124.89 R4268.1
PU_M2G_VIO_1V8: length 8.9
  BOTTOM w0.112: J8.B22 162.42,133.22 162.42,132.23 161.31,131.12 161.31,129.89 161.72,129.47 161.72,129.05 v3(161.83,128.94) 161.83,128.12 160.54,126.84 R4246.2
