# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
COM_CPLD_M2I_RX_R: length 2.7
  TOP w0.112: v4(21.95,54.15) 23.01,54.15 R3932.2
  BOTTOM w0.112: U94.K14 v4(21.95,54.15)
COM_CPLD_M2I_TX: length 164.9
  IN1 w0.122: v2(111.06,107.18) 111.31,106.93 111.31,105.79 112.16,103.74 112.16,102.8 111.11,101.75 111.11,93.28 101.77,83.95 101.42,83.95 101.42,83.95 93.92,83.95 86.43,76.45 76.81,76.45 72.89,72.54 71.81,72.09 70.61,72.09 68.44,74.26 65.5,74.26 64.7,73.46 54.2,73.46 52.52,71.78 49.56,71.78 47.22,69.45 44.15,69.45 43.96,69.64 36.74,69.64 36.56,69.82 33.03,69.82 32.4,70.44 28.06,70.44 27.67,70.83 27.67,71.26 27.13,71.81 24.21,71.81 23.86,72.15 v2(23.86,73.28)
  IN2 w0.122: v2(23.86,73.28) 23.86,71.96 24.69,71.12 24.69,66.98 22.92,65.21 22.92,59.82 23.4,59.34 23.4,50.59 v2(22.95,50.15) ; v2(106.23,124.57) 107.85,122.94 107.85,112.34 110.16,110.03 110.16,108.99 111.32,107.84 111.32,107.43 v2(111.06,107.18)
  BOTTOM w0.112: v2(106.23,124.57) 106.4,124.57 107.23,125.4 107.23,127.99 R4302.1 ; U94.G15 v2(22.95,50.15)
COM_CPLD_M2I_TX_R: length 5
  BOTTOM w0.112: R4302.2 106.93,129.09 106.93,130.35 108.03,131.44 108.03,131.83 107.92,131.93 J34.B48
COM_CPLD_M2J_RX: length 132.6
  IN1 w0.122: v2(86.83,124.98) 86.83,124.03 87.58,123.28 87.58,119.82 89.08,118.32 89.08,115.79 89.66,115.21 89.66,108.94 90.16,107.74 90.16,105.59 90.41,104.99 90.41,98.04 78.45,86.09 77.73,86.09 v2(77.47,85.83)
  IN2 w0.122: v2(30.25,58.51) 30.77,59.03 30.77,66.46 30.42,66.81 30.42,68.9 31.21,69.69 31.21,71.5 30.74,71.97 30.74,74.1 31.37,74.74 31.37,75.63 31.97,76.23 31.97,80.35 v2(31.72,80.59)
  BOTTOM w0.112: v2(30.25,58.51) 29.82,58.51 R3933.1 ; J34.A46 84.42,132.4 83.03,131.01 83.03,129.77 84.24,128.56 84.24,127.16 84.66,126.74 84.66,125.12 85.19,124.59 86.44,124.59 v2(86.83,124.98) ; v2(31.72,80.59) 32.51,80.59 33.59,81.67 35.04,81.67 36.42,83.06 38.28,83.06 40.04,84.82 41.84,84.82 42.56,85.55 43.47,85.55 43.88,85.14 47.77,85.14 48.22,85.58 56.96,85.58 57.22,85.83 62.24,85.83 64.01,87.6 67.02,87.6 68.36,86.26 77.04,86.26 v2(77.47,85.83)
COM_CPLD_M2J_RX_R: length 8.9
  BOTTOM w0.112: U94.K15 22.63,53.65 23.16,54.18 23.9,54.18 24.77,55.04 24.77,56.21 v3(27.05,58.5) 27.99,58.5 R3933.2
COM_CPLD_M2J_TX: length 143
  IN1 w0.122: v2(78.26,85.46) 78.86,85.46 91.06,97.65 91.06,104.59 90.59,105.72 90.59,107.85 90.15,108.92 90.15,115.39 89.59,115.94 89.59,119.55 88.06,121.08 88.06,123.42 87.41,124.07 v2(87.41,124.46)
  IN2 w0.122: v2(24.25,79.07) 24.43,78.88 24.43,76.83 23.5,75.9 23.5,74.22 23.42,74.13 23.42,71.78 23.61,71.59 23.61,66.58 22.33,65.3 22.33,59.14 22.83,58.63 22.83,51.02 v2(21.95,50.15)
  BOTTOM w0.112: R4303.1 83.65,126.18 83.82,126 83.82,125.34 85.02,124.15 87.1,124.15 v2(87.41,124.46) ; U94.G14 v2(21.95,50.15) ; v2(24.25,79.07) 27.79,79.07 28.26,79.53 28.26,79.99 29.37,81.1 32.41,81.1 33.5,82.19 34.57,82.19 34.85,82.47 34.85,82.91 35.43,83.49 38.13,83.49 40.01,85.37 41.83,85.37 42.61,86.14 43.68,86.14 44.3,85.52 47.56,85.52 48.01,85.97 56.81,85.97 57.06,86.22 62.08,86.22 63.93,88.07 67.11,88.07 68.52,86.66 77.37,86.66 78.26,85.76 v2(78.26,85.46)
COM_CPLD_M2J_TX_R: length 6.7
  BOTTOM w0.112: R4303.2 83.65,128.57 82.6,129.62 82.6,131.16 83.92,132.48 J34.A48
COM_CPLD_M2K_RX: length 118.2
  TOP w0.112: v2(25.72,51.67) 25.26,51.67 25.03,51.43 R3934.1
  IN1 w0.122: v2(65.02,117.13) 65.02,113.11 65.3,112.42 65.3,107.76 66.48,106.58 66.48,104.84 65.66,102.86 65.66,100.06 55.11,89.51 55.05,89.36 55.05,89.36 54.27,87.48 52.24,85.46 49.75,84.42 46.75,81.42 44.97,81.42 43.45,79.9 37.79,79.9 36.71,78.82 32.32,78.82 30.46,80.69 27.69,80.69 v2(26.74,79.74)
  IN2 w0.122: v2(65.02,117.13) 64.9,117.13 61.83,120.2 61.83,123.88 v2(62.74,124.79) ; v2(25.72,51.67) 25.2,52.18 25.2,53.57 25.55,53.92 25.55,60 25.93,60.38 25.93,61.68 26.63,62.37 26.63,71.35 26.77,71.5 26.77,72.95 25.37,74.35 25.37,75.61 26.74,76.98 v2(26.74,79.74)
  BOTTOM w0.112: J6.B46 60.42,132.4 59.48,131.47 59.48,129.97 59.79,129.66 59.79,128.99 60.67,128.11 60.67,126.38 62.26,124.79 v2(62.74,124.79)
COM_CPLD_M2K_RX_R: length 6.2
  TOP w0.112: v4(18.95,53.15) 19.57,52.53 21.94,52.53 23.03,51.43 R3934.2
  BOTTOM w0.112: U94.J11 v4(18.95,53.15)
COM_CPLD_M2K_TX: length 121.6
  IN1 w0.122: v2(18.68,77.99) 19.18,78.49 27.18,78.49 28.95,80.26 30.27,80.26 32.17,78.37 36.89,78.37 37.99,79.46 43.67,79.46 45.2,80.99 46.93,80.99 50.01,84.07 50.05,84.09 52.48,85.09 54.63,87.24 55.45,89.21 66.16,99.93 66.16,102.79 66.91,104.59 66.91,106.78 65.98,107.7 v2(65.98,109.77)
  IN2 w0.122: v2(65.98,109.77) 66.05,109.77 66.05,109.88 67.05,110.88 67.05,116.36 64.37,119.04 63.62,119.04 62.26,120.41 62.26,123.09 v2(63.28,124.12) ; v2(18.68,77.99) 20,76.67 20,73.57 19.35,72.93 19.35,69.46 19.71,69.1 19.71,67.71 19.54,67.55 19.54,67.52 19.44,67.42 19.42,67.42 19.16,67.17 19.16,67.11 18.72,66.67 18.72,62.58 19.39,61.91 19.39,50.59 v2(18.95,50.15)
  BOTTOM w0.112: U94.G11 v2(18.95,50.15) ; R4304.1 59.96,126.51 62.35,124.12 v2(63.28,124.12)
COM_CPLD_M2K_TX_R: length 6.2
  BOTTOM w0.112: J6.B48 59.92,132.46 59.07,131.61 59.07,129.75 59.31,129.51 59.31,128.89 59.96,128.23 R4304.2
COM_CPLD_M2L_RX: length 104.7
  TOP w0.112: v2(26.71,55.52) 25.79,55.52 24.74,54.48 R3935.1
  IN1 w0.122: v2(24.76,95.18) 31.33,95.18 34.17,92.34 35.39,92.34 37.69,94.65 37.69,98.25 38.53,99.09 38.53,100.08 36.58,104.79 36.58,108.68 37.02,109.74 37.02,112.33 36.41,113.79 36.41,116.17 35.69,116.89 35.69,122.79 36.7,123.8 v2(36.7,123.83)
  IN2 w0.122: v2(26.71,55.52) 26.92,55.73 26.92,61.29 27.55,61.92 27.55,72.91 25.84,74.61 25.84,75.4 27.18,76.74 27.18,85.44 26.31,86.31 26.31,90.37 24.76,91.92 v2(24.76,95.18)
  BOTTOM w0.112: J6.A46 36.42,132.43 35.22,131.23 35.22,130.59 34.11,129.49 34.11,128.7 33.99,128.58 33.2,128.58 32.77,128.14 32.77,127.48 33.52,126.72 v3(34.12,126.72) 34.97,126.72 35.99,125.7 35.99,124.54 v2(36.7,123.83)
COM_CPLD_M2L_RX_R: length 4.7
  TOP w0.112: R3935.2 23.09,55.08 v1(20.79,55.08) 20.02,55.08 v2(19.95,55.15)
  BOTTOM w0.112: U94.L12 v2(19.95,55.15)
COM_CPLD_M2L_TX: length 103.9
  IN1 w0.122: v2(36.71,122.93) 36.14,122.36 36.14,118.58 36.68,118.04 36.91,117.49 36.91,114.13 37.44,112.83 37.44,109.36 37.11,108.56 37.11,104.62 38.96,100.15 38.96,98.91 38.58,98.53 38.58,94.92 35.57,91.91 33.9,91.91 32.74,93.07 25.79,93.07 23.82,95.03 21.83,95.03 v2(20.86,94.06)
  IN2 w0.122: v2(19.95,51.15) 19.95,54.38 20.41,54.84 20.41,59.59 19.93,60.07 19.93,61.98 19.15,62.75 19.15,65.07 20.56,66.48 20.56,69.5 20.21,69.85 20.21,72.55 20.88,73.21 20.88,75.04 21.77,75.93 21.77,83.52 22.76,84.52 22.76,91.65 20.86,93.56 v2(20.86,94.06)
  BOTTOM w0.112: U94.H12 v2(19.95,51.15) ; R4305.1 33.21,126.19 33.54,125.87 33.54,123.84 33.91,123.47 34.49,123.47 34.77,123.75 35.89,123.75 v2(36.71,122.93)
COM_CPLD_M2L_TX_R: length 7.9
  BOTTOM w0.112: J6.A48 35.92,132.49 34.82,131.39 34.82,130.79 33.56,129.52 v3(33.56,129.15) 33.42,129.02 33.06,129.02 32.34,128.31 R4305.2
COM_GP_RX: length 333
  TOP w0.112: J55.3 117,144.65 117.11,144.76 120.37,144.76 v2(120.57,144.57)
  IN1 w0.122: v2(120.57,144.57) 120.2,144.57 119.8,144.97 114.12,144.97 113.33,144.17 107.57,144.17 107.09,143.7 105.79,143.7 104.75,144.73 99.92,144.73 98.89,143.71 v2(97.4,143.71) ; v2(65.3,10.41) 65.3,9.97 65.02,9.7 47.57,9.7 46.96,10.3 46.96,13.45 42.1,18.31 37.95,18.31 36.63,19.63 36.63,23.14 31.47,28.31 27.86,28.31 v2(27.54,27.99) 27.04,27.99 25.17,29.86 19.04,29.86 16.82,32.08 15.75,32.08 15.34,31.67 13.34,31.67 12.62,32.39 v2(12.62,32.77)
  IN2 w0.122: v2(84.24,145.6) 85.13,146.49 92.46,146.49 94.18,144.78 96.33,144.78 v2(97.4,143.71) ; v2(23.86,102.15) 24.43,101.57 24.43,100.49 24.75,100.17 24.75,98.61 24.85,98.5 25.41,98.5 26.17,97.75 26.17,97.28 27.46,95.98 27.46,91.54 28.29,90.71 28.29,88.9 29.86,87.34 29.86,86.43 31.14,85.15 31.14,79.6 31.3,79.44 31.3,76.34 30.28,75.32 30.28,74.81 29.99,74.52 29.99,66.48 30.33,66.15 30.33,60.21 29.74,59.61 29.74,58.81 29.37,58.45 29.37,55.13 29,54.76 29,49.56 29.34,49.21 29.34,42.74 28.36,41.76 28.36,36.5 27.14,35.27 27.14,30.16 27.54,29.76 v2(27.54,27.99)
  BOTTOM w0.112: v2(12.62,32.77) 12.62,33.68 10.87,35.43 10.87,35.94 11.17,36.24 11.89,36.24 13.11,37.46 13.11,38 13.38,38.27 13.38,40.68 13.09,40.97 13.09,43.59 13.88,44.37 13.88,45.22 U94.B6 ; v2(84.24,145.6) 83.58,146.26 30.97,146.26 30.2,145.5 24.81,145.5 v3(24.28,144.96) 24.28,143.86 20.27,139.86 20.27,135.33 19.87,134.93 19.87,131.02 21.55,129.34 21.55,124.14 14.56,117.15 14.56,113.1 10.15,108.7 10.15,108.18 12.21,106.12 12.21,102.14 13.2,101.15 17.71,101.15 18.19,101.63 18.97,101.63 19.55,102.2 23.81,102.2 v2(23.86,102.15) ; J41.37 v2(65.3,10.41)
COM_GP_TX: length 320.2
  TOP w0.112: J55.2 116.35,144.72 116.23,144.84 114.56,144.84 113.87,144.15 113.87,142.42 111.59,140.15 98,140.15 v2(97.78,140.37)
  IN1 w0.122: v2(66.1,10.39) 66.1,9.95 65.42,9.27 47.39,9.27 46.43,10.23 46.43,13.36 42.02,17.78 37.88,17.78 36.19,19.47 36.19,22.84 32.21,26.82 27.29,26.82 v2(26.89,27.22) 24.68,29.43 18.84,29.43 16.63,31.64 16.21,31.64 15.27,30.7 13.07,30.7 11.86,31.9 v2(11.86,32.72)
  IN2 w0.122: v2(85.06,145.77) 90.43,145.77 92.77,143.44 94.71,143.44 v2(97.78,140.37) ; v2(23.09,101.67) 23.34,101.67 23.85,101.17 23.85,100.3 23.47,99.4 23.47,98.74 24.15,98.07 25.15,98.07 25.73,97.49 25.73,96.49 26.28,95.94 26.28,91.92 27.87,90.34 27.87,88.68 29.22,87.32 29.22,86.42 30.28,85.36 30.28,76.45 29.16,75.33 29.16,74.07 29.54,73.68 29.54,65.93 29.91,65.56 29.91,60.39 29.3,59.79 29.3,59.04 28.94,58.68 28.94,55.42 28.33,54.81 28.33,49.42 28.92,48.83 28.92,42.99 27.93,42 27.93,36.79 26.31,35.17 25.8,33.95 25.8,32.71 26.63,31.88 26.63,28.32 26.89,28.06 v2(26.89,27.22)
  BOTTOM w0.112: R3936.2 10.56,35.19 11.86,33.88 v2(11.86,32.72) ; v2(85.06,145.77) 84.17,146.66 30.82,146.66 30.04,145.88 23.99,145.88 23.4,145.29 23.4,143.52 19.89,140.02 19.89,135.49 19.48,135.09 19.48,130.86 21.16,129.18 21.16,124.3 14.17,117.31 14.17,113.26 9.74,108.83 9.74,108.03 11.8,105.97 11.8,101.98 13.02,100.76 17.88,100.76 18.22,101.09 19.15,101.09 19.76,101.7 23.07,101.7 v2(23.09,101.67) ; J41.35 v2(66.1,10.39)
COM_GP_TX_R: length 11.3
  BOTTOM w0.112: U94.A5 12.06,44.65 9.91,42.5 9.91,38.23 v3(8.74,37.06) 8.74,36.76 8.85,36.65 9.53,36.65 9.91,36.27 R3936.1
DELTA_L_85_5IN_BOT_DN: length 135.5
  BOTTOM w0.124: J51.1 126.22,155.76 129.94,155.76 130.07,155.63 129.64,153.24 129.89,152.89 130.89,152.71 131.24,152.96 132.25,158.66 132.4,158.76 133.15,158.63 133.25,158.48 132.33,153.25 132.57,152.9 133.57,152.72 133.92,152.97 134.93,158.67 135.08,158.77 135.83,158.64 135.93,158.5 135,153.24 135.25,152.89 136.25,152.71 136.6,152.96 137.61,158.67 137.76,158.77 138.51,158.64 138.61,158.49 137.69,153.27 137.93,152.92 138.93,152.74 139.28,152.99 140.29,158.66 140.43,158.76 141.19,158.63 141.29,158.48 140.36,153.25 140.61,152.9 141.61,152.73 141.96,152.97 142.48,155.91 142.97,158.68 143.11,158.78 143.87,158.65 143.97,158.5 143.04,153.27 143.29,152.92 144.29,152.74 144.64,152.99 145.65,158.66 145.79,158.76 146.54,158.63 146.65,158.48 145.72,153.26 145.97,152.91 146.97,152.73 147.32,152.98 148.33,158.69 148.47,158.79 149.23,158.66 149.33,158.52 148.4,153.26 148.64,152.91 149.65,152.73 150,152.98 151.01,158.68 151.15,158.78 151.91,158.65 152.01,158.5 151.09,153.34 151.34,152.99 152.34,152.81 152.69,153.06 153.69,158.69 153.83,158.79 154.59,158.66 154.69,158.51 154.26,156.09 154.59,155.76 158.44,155.76 J52.2
DELTA_L_85_5IN_BOT_DP: length 135.5
  BOTTOM w0.124: J52.1 158.44,156.07 154.71,156.07 154.59,156.19 155.01,158.58 154.76,158.93 153.76,159.11 153.41,158.87 152.41,153.24 152.27,153.14 151.52,153.27 151.41,153.41 152.33,158.57 152.08,158.93 151.2,159.08 151.08,159.1 150.73,158.86 149.72,153.15 149.57,153.05 148.82,153.18 148.72,153.33 149.65,158.59 149.41,158.94 148.4,159.12 148.05,158.87 147.04,153.16 146.9,153.05 146.14,153.19 146.04,153.33 146.97,158.56 146.72,158.91 145.72,159.08 145.37,158.84 144.36,153.16 144.22,153.06 143.47,153.2 143.37,153.34 144.29,158.57 144.05,158.92 143.04,159.1 142.69,158.86 142.17,155.91 141.68,153.15 141.54,153.05 140.78,153.18 140.68,153.33 141.61,158.56 141.36,158.91 140.36,159.08 140.01,158.84 139.01,153.16 138.86,153.06 138.11,153.2 138.01,153.34 138.93,158.56 138.69,158.92 137.69,159.09 137.33,158.85 136.32,153.13 136.18,153.03 135.42,153.17 135.32,153.31 136.25,158.57 136.01,158.92 135.01,159.1 134.66,158.85 133.65,153.15 133.5,153.05 132.75,153.18 132.65,153.32 133.57,158.55 133.33,158.91 132.33,159.08 131.97,158.84 130.97,153.14 130.82,153.04 130.07,153.17 129.97,153.31 130.4,155.74 130.07,156.07 126.22,156.07 J51.2
DELTA_L_85_5IN_IN1_DN: length 127
  IN1 w0.136: v2(268.71,155.69) 268.94,155.93 273.01,155.93 273.57,156.49 273.27,158.19 273.45,158.44 274.12,158.56 274.35,158.41 275.15,153.86 275.49,153.62 276.36,153.77 276.59,154.11 275.85,158.28 275.96,158.43 276.59,158.54 276.74,158.44 277.56,153.82 277.9,153.58 278.76,153.73 279,154.07 278.25,158.3 278.35,158.45 278.99,158.56 279.14,158.46 279.96,153.82 280.3,153.58 281.16,153.73 281.4,154.07 280.65,158.3 280.75,158.45 281.39,158.56 281.54,158.46 282.36,153.83 282.69,153.6 283.56,153.75 283.8,154.09 283.05,158.28 283.16,158.43 283.8,158.54 283.94,158.44 284.76,153.83 285.09,153.59 285.96,153.74 286.2,154.08 285.46,158.28 285.56,158.42 286.2,158.54 286.34,158.43 287.16,153.84 287.49,153.6 288.36,153.76 288.6,154.09 287.86,158.28 287.96,158.43 288.6,158.54 288.74,158.44 289.56,153.83 289.89,153.6 290.76,153.75 291,154.09 290.26,158.27 290.36,158.42 291,158.53 291.15,158.42 291.96,153.81 292.3,153.58 293.17,153.73 293.4,154.07 292.67,158.23 292.77,158.37 293.41,158.49 293.55,158.38 294.36,153.8 294.7,153.57 295.57,153.72 295.8,154.06 295.07,158.23 295.17,158.37 295.83,158.49 295.98,158.39 296.77,153.86 297.16,153.59 298.01,153.74 298.25,154.08 297.96,155.7 298.19,155.92 302.09,155.92 v2(302.32,155.69)
  BOTTOM w0.124: J10.1 v2(268.71,155.69) ; J13.2 v2(302.32,155.69)
DELTA_L_85_5IN_IN1_DP: length 127
  IN1 w0.136: v2(302.32,156.44) 302.08,156.2 298.08,156.2 297.66,155.79 297.96,154.14 297.85,153.99 297.23,153.88 297.03,154.02 296.23,158.55 295.89,158.79 295.01,158.63 294.77,158.29 295.51,154.12 295.41,153.97 294.77,153.86 294.62,153.96 293.81,158.55 293.47,158.78 292.61,158.63 292.37,158.29 293.11,154.13 293,153.99 292.36,153.87 292.22,153.98 291.4,158.59 291.06,158.82 290.2,158.67 289.96,158.33 290.7,154.15 290.6,154.01 289.96,153.89 289.81,154 289,158.6 288.66,158.84 287.8,158.68 287.56,158.35 288.3,154.16 288.2,154.01 287.56,153.9 287.41,154 286.6,158.6 286.26,158.83 285.4,158.68 285.16,158.34 285.9,154.15 285.8,154 285.16,153.89 285.01,153.99 284.2,158.6 283.86,158.84 282.99,158.68 282.76,158.35 283.5,154.15 283.4,154.01 282.76,153.89 282.61,154 281.79,158.62 281.46,158.85 280.59,158.7 280.36,158.36 281.1,154.14 281,153.99 280.36,153.88 280.21,153.98 279.39,158.62 279.06,158.85 278.19,158.7 277.96,158.36 278.7,154.13 278.6,153.99 277.96,153.87 277.81,153.98 277,158.6 276.66,158.83 275.79,158.68 275.56,158.34 276.3,154.18 276.19,154.03 275.55,153.92 275.41,154.02 274.6,158.57 274.19,158.86 273.28,158.7 272.98,158.26 273.27,156.58 272.9,156.21 268.94,156.21 v2(268.71,156.44)
  BOTTOM w0.124: J13.1 v2(302.32,156.44) ; J10.2 v2(268.71,156.44)
DELTA_L_85_5IN_IN2_DN: length 127
  TOP w0.124: J14.2 v2(268.71,158.23) ; J11.1 v2(302.32,158.23)
  IN2 w0.136: v2(268.71,158.23) 268.94,158.46 272.85,158.46 273.07,158.25 272.78,156.62 273.02,156.28 273.89,156.12 274.25,156.38 275.05,160.9 275.23,161.03 275.86,160.92 275.96,160.77 275.23,156.6 275.46,156.26 276.33,156.11 276.67,156.34 277.48,160.93 277.62,161.03 278.26,160.92 278.36,160.77 277.63,156.61 277.87,156.27 278.73,156.12 279.07,156.35 279.88,160.97 280.03,161.07 280.67,160.96 280.77,160.81 280.03,156.63 280.27,156.29 281.14,156.14 281.47,156.37 282.29,160.98 282.43,161.08 283.07,160.97 283.18,160.82 282.43,156.63 282.67,156.3 283.54,156.14 283.87,156.38 284.69,160.98 284.83,161.08 285.47,160.97 285.57,160.82 284.83,156.62 285.07,156.28 285.94,156.13 286.27,156.37 287.09,160.98 287.24,161.08 287.87,160.97 287.98,160.82 287.23,156.63 287.47,156.29 288.34,156.14 288.67,156.37 289.49,161 289.64,161.1 290.28,160.99 290.38,160.84 289.63,156.61 289.87,156.28 290.74,156.12 291.07,156.36 291.89,161 292.04,161.1 292.68,160.99 292.78,160.84 292.03,156.61 292.27,156.27 293.14,156.12 293.47,156.36 294.29,160.98 294.44,161.08 295.07,160.97 295.18,160.82 294.44,156.65 294.68,156.31 295.54,156.16 295.88,156.4 296.68,160.95 296.91,161.11 297.58,160.99 297.76,160.74 297.46,159.03 298.02,158.47 302.08,158.47 v2(302.32,158.23)
DELTA_L_85_5IN_IN2_DP: length 127
  TOP w0.124: J14.1 v2(268.71,158.98) ; J11.2 v2(302.32,158.98)
  IN2 w0.136: v2(302.32,158.98) 302.09,158.75 298.13,158.75 297.76,159.12 298.05,160.8 297.75,161.24 296.84,161.4 296.43,161.11 295.62,156.56 295.48,156.46 294.84,156.57 294.74,156.72 295.47,160.88 295.24,161.22 294.37,161.37 294.03,161.14 293.22,156.52 293.07,156.42 292.43,156.53 292.33,156.68 293.08,160.9 292.84,161.24 291.97,161.39 291.64,161.16 290.82,156.52 290.67,156.42 290.03,156.53 289.93,156.68 290.68,160.91 290.44,161.24 289.57,161.4 289.24,161.16 288.42,156.54 288.27,156.43 287.63,156.55 287.53,156.69 288.27,160.89 288.04,161.22 287.17,161.38 286.83,161.14 286.02,156.53 285.87,156.43 285.23,156.54 285.13,156.69 285.87,160.88 285.63,161.22 284.77,161.37 284.43,161.14 283.62,156.54 283.47,156.44 282.83,156.55 282.73,156.7 283.47,160.89 283.24,161.22 282.37,161.38 282.03,161.14 281.22,156.54 281.07,156.43 280.43,156.55 280.33,156.69 281.07,160.87 280.83,161.21 279.97,161.36 279.63,161.13 278.81,156.52 278.67,156.41 278.03,156.53 277.93,156.67 278.66,160.83 278.42,161.17 277.56,161.32 277.22,161.09 276.41,156.5 276.27,156.4 275.63,156.52 275.52,156.66 276.26,160.83 276.14,161 276.02,161.17 275.16,161.32 274.8,161.07 274,156.54 273.83,156.42 273.18,156.53 273.08,156.68 273.37,158.34 272.97,158.74 268.95,158.74 v2(268.71,158.98)
DELTA_L_85_5IN_TOP_DN: length 135.6
  TOP w0.124: J9.1 126.22,158.61 130.07,158.61 130.4,158.28 129.97,155.85 130.07,155.71 130.82,155.58 130.97,155.68 131.97,161.38 132.33,161.62 133.33,161.45 133.57,161.09 132.65,155.86 132.75,155.72 133.5,155.59 133.65,155.69 134.66,161.39 135.01,161.64 136.01,161.46 136.25,161.11 135.32,155.85 135.42,155.71 136.18,155.57 136.32,155.67 137.33,161.39 137.69,161.63 138.69,161.46 138.93,161.1 138.01,155.88 138.11,155.74 138.86,155.6 139.01,155.7 140.01,161.38 140.36,161.62 141.36,161.45 141.61,161.1 140.68,155.87 140.78,155.72 141.54,155.59 141.68,155.69 142.17,158.45 142.69,161.4 143.04,161.64 144.05,161.46 144.29,161.11 143.37,155.88 143.47,155.74 144.22,155.6 144.36,155.7 145.37,161.38 145.72,161.62 146.72,161.45 146.97,161.1 146.04,155.87 146.14,155.73 146.9,155.59 147.04,155.7 148.05,161.41 148.4,161.66 149.41,161.48 149.65,161.13 148.72,155.87 148.82,155.72 149.57,155.59 149.72,155.69 150.73,161.4 151.08,161.64 152.08,161.47 152.33,161.11 151.4,155.88 151.5,155.74 152.26,155.61 152.4,155.71 153.4,161.38 153.79,161.65 154.73,161.49 155,161.1 154.59,158.73 154.71,158.61 158.44,158.61 J12.2
DELTA_L_85_5IN_TOP_DP: length 135.6
  TOP w0.124: J9.2 126.22,158.3 129.94,158.3 130.07,158.17 129.64,155.78 129.89,155.43 130.89,155.25 131.24,155.5 132.25,161.2 132.4,161.3 133.15,161.17 133.25,161.02 132.33,155.79 132.57,155.44 133.57,155.26 133.92,155.51 134.93,161.21 135.08,161.31 135.83,161.18 135.93,161.04 135,155.78 135.25,155.43 136.25,155.25 136.6,155.5 137.61,161.21 137.76,161.31 138.51,161.18 138.61,161.03 137.69,155.81 137.93,155.46 138.93,155.28 139.28,155.53 140.29,161.2 140.43,161.3 141.19,161.17 141.29,161.02 140.36,155.79 140.61,155.44 141.61,155.27 141.96,155.51 142.48,158.45 142.97,161.22 143.11,161.32 143.87,161.19 143.97,161.04 143.04,155.81 143.29,155.46 144.29,155.28 144.64,155.53 145.65,161.2 145.79,161.3 146.54,161.17 146.65,161.02 145.72,155.8 145.97,155.45 146.97,155.27 147.32,155.52 148.33,161.23 148.47,161.33 149.23,161.2 149.33,161.06 148.4,155.8 148.64,155.45 149.65,155.27 150,155.52 151.01,161.22 151.15,161.32 151.91,161.19 152.01,161.04 151.08,155.81 151.33,155.46 152.33,155.28 152.68,155.53 153.68,161.2 153.86,161.33 154.55,161.21 154.68,161.03 154.26,158.63 154.59,158.3 158.44,158.3 J12.1
DELTA_L_85_10IN_BOT_DN: length 262.7
  BOTTOM w0.124: J53.1 78.66,155.43 74.94,155.43 74.81,155.56 75.24,157.95 74.99,158.3 73.99,158.48 73.64,158.23 72.63,152.53 72.48,152.43 71.73,152.56 71.63,152.71 72.56,157.94 72.31,158.29 71.31,158.47 70.96,158.22 69.95,152.52 69.8,152.42 69.05,152.55 68.95,152.69 69.88,157.95 69.63,158.3 68.63,158.48 68.28,158.24 67.27,152.52 67.12,152.42 66.37,152.55 66.27,152.7 67.19,157.92 66.95,158.27 65.95,158.45 65.6,158.2 64.59,152.53 64.45,152.43 63.69,152.56 63.59,152.71 64.52,157.94 64.27,158.29 63.27,158.47 62.92,158.22 62.42,155.39 61.91,152.52 61.77,152.42 61.01,152.56 60.91,152.7 61.84,157.95 61.6,158.3 60.59,158.48 60.24,158.23 59.23,152.53 59.09,152.43 58.34,152.56 58.24,152.7 59.16,157.95 58.92,158.3 57.92,158.48 57.57,158.24 56.55,152.52 56.41,152.42 55.66,152.56 55.56,152.7 56.49,157.96 56.24,158.31 55.24,158.48 54.89,158.24 53.87,152.51 53.73,152.41 52.98,152.55 52.88,152.69 53.81,157.95 53.56,158.3 52.56,158.47 52.21,158.23 51.19,152.52 51.05,152.42 50.3,152.55 50.2,152.69 51.13,157.95 50.88,158.3 49.88,158.48 49.53,158.23 48.52,152.53 48.37,152.43 47.62,152.56 47.52,152.71 48.45,157.94 48.2,158.29 47.2,158.47 46.85,158.22 45.84,152.52 45.69,152.42 44.94,152.55 44.84,152.69 45.77,157.95 45.52,158.3 44.52,158.48 44.17,158.24 43.16,152.52 43.02,152.42 42.26,152.55 42.16,152.7 43.09,157.92 42.84,158.27 41.84,158.45 41.49,158.2 40.48,152.53 40.34,152.43 39.58,152.56 39.48,152.71 40.41,157.94 40.16,158.29 39.16,158.47 38.81,158.22 38.31,155.38 37.8,152.51 37.66,152.41 36.9,152.55 36.8,152.69 37.73,157.92 37.48,158.27 36.48,158.45 36.13,158.2 35.12,152.53 34.98,152.43 34.23,152.56 34.13,152.71 35.05,157.93 34.81,158.28 33.8,158.46 33.45,158.21 32.44,152.5 32.3,152.4 31.54,152.53 31.44,152.68 32.37,157.93 32.13,158.29 31.13,158.46 30.77,158.22 29.76,152.51 29.62,152.41 28.87,152.55 28.77,152.69 29.69,157.92 29.45,158.27 28.44,158.45 28.09,158.2 27.08,152.5 26.94,152.4 26.19,152.54 26.09,152.68 26.51,155.1 26.18,155.43 22.34,155.43 J54.2
DELTA_L_85_10IN_BOT_DP: length 262.7
  BOTTOM w0.124: J54.1 22.34,155.13 26.06,155.13 26.19,155 25.76,152.61 26.01,152.26 27.01,152.08 27.36,152.33 28.37,158.03 28.52,158.13 29.27,157.99 29.37,157.85 28.44,152.62 28.69,152.27 29.69,152.09 30.04,152.33 31.05,158.04 31.2,158.14 31.95,158.01 32.05,157.86 31.12,152.6 31.37,152.25 32.37,152.08 32.72,152.32 33.73,158.04 33.87,158.14 34.63,158 34.73,157.86 33.8,152.64 34.05,152.28 35.05,152.11 35.4,152.35 36.41,158.03 36.55,158.13 37.31,157.99 37.41,157.85 36.48,152.62 36.73,152.27 37.73,152.09 38.08,152.34 38.62,155.38 39.09,158.04 39.23,158.14 39.99,158.01 40.09,157.87 39.16,152.64 39.41,152.28 40.41,152.11 40.76,152.35 41.77,158.03 41.91,158.13 42.66,157.99 42.76,157.85 41.84,152.63 42.08,152.28 43.09,152.1 43.44,152.34 44.45,158.06 44.59,158.16 45.35,158.03 45.45,157.88 44.52,152.62 44.76,152.27 45.76,152.09 46.12,152.34 47.13,158.05 47.27,158.15 48.02,158.01 48.12,157.87 47.2,152.64 47.44,152.29 48.45,152.11 48.8,152.35 49.81,158.05 49.95,158.15 50.7,158.02 50.8,157.88 49.87,152.62 50.12,152.27 51.12,152.09 51.47,152.34 52.48,158.05 52.63,158.15 53.38,158.02 53.48,157.87 52.55,152.62 52.8,152.27 53.8,152.09 54.15,152.34 55.16,158.06 55.31,158.16 56.06,158.03 56.16,157.88 55.23,152.63 55.48,152.28 56.48,152.1 56.83,152.35 57.84,158.03 57.99,158.16 58.74,158.03 58.84,157.88 57.91,152.63 58.16,152.28 59.16,152.1 59.51,152.35 60.52,158.06 60.66,158.16 61.42,158.02 61.52,157.88 60.59,152.63 60.84,152.28 61.84,152.1 62.19,152.35 62.73,155.39 63.2,158.04 63.34,158.14 64.1,158.01 64.2,157.87 63.27,152.64 63.52,152.28 64.52,152.11 64.87,152.35 65.87,158.03 66.02,158.13 66.77,157.99 66.87,157.85 65.95,152.63 66.19,152.28 67.2,152.1 67.55,152.34 68.56,158.06 68.7,158.16 69.46,158.03 69.56,157.88 68.63,152.62 68.87,152.27 69.87,152.09 70.22,152.34 71.24,158.05 71.38,158.15 72.13,158.01 72.23,157.87 71.31,152.64 71.55,152.29 72.56,152.11 72.91,152.35 73.92,158.05 74.06,158.15 74.81,158.02 74.91,157.88 74.48,155.46 74.82,155.13 78.66,155.13 J53.2
DELTA_L_85_10IN_IN1_DN: length 254
  IN1 w0.136: v2(243.5,156.29) 243.27,156.06 240.69,156.06 238.84,157.36 238.54,159.08 238.15,159.35 237.15,159.17 236.91,158.83 237.93,153.12 237.82,152.97 237.18,152.86 237.04,152.96 235.94,159.14 235.61,159.37 234.74,159.22 234.51,158.88 235.53,153.1 235.43,152.96 234.79,152.84 234.64,152.95 233.54,159.15 233.21,159.38 232.34,159.23 232.1,158.89 233.13,153.11 233.02,152.96 232.39,152.85 232.24,152.95 231.14,159.14 230.81,159.38 229.94,159.22 229.7,158.89 230.72,153.12 230.62,152.97 229.98,152.86 229.84,152.96 228.74,159.16 228.4,159.39 227.54,159.24 227.3,158.9 228.32,153.12 228.22,152.98 227.58,152.86 227.44,152.96 226.34,159.15 226,159.39 225.14,159.23 224.9,158.9 225.92,153.12 225.82,152.98 225.18,152.86 225.03,152.97 223.94,159.14 223.6,159.38 222.74,159.22 222.5,158.89 223.52,153.11 223.42,152.97 222.78,152.85 222.64,152.96 221.55,159.11 221.21,159.35 220.34,159.2 220.11,158.86 221.12,153.12 221.02,152.97 220.38,152.86 220.23,152.96 219.15,159.11 218.81,159.35 217.94,159.19 217.71,158.86 218.72,153.13 218.62,152.98 217.98,152.87 217.83,152.97 216.74,159.15 216.4,159.39 215.54,159.24 215.3,158.9 216.32,153.11 216.22,152.97 215.58,152.85 215.43,152.96 214.34,159.15 214,159.38 213.14,159.23 212.9,158.89 213.92,153.12 213.82,152.98 213.18,152.86 213.03,152.97 211.94,159.12 211.61,159.36 210.74,159.21 210.5,158.87 211.52,153.12 211.42,152.98 210.78,152.86 210.63,152.96 209.54,159.12 209.21,159.36 208.34,159.2 208.1,158.87 209.12,153.12 209.02,152.98 208.38,152.86 208.23,152.97 207.13,159.16 206.8,159.4 205.93,159.25 205.7,158.91 206.72,153.11 206.62,152.97 205.98,152.85 205.83,152.96 204.74,159.16 204.4,159.39 203.53,159.24 203.3,158.9 204.32,153.12 204.22,152.98 203.58,152.86 203.43,152.97 202.33,159.16 202,159.4 201.13,159.24 200.9,158.91 201.92,153.12 201.82,152.98 201.18,152.86 201.03,152.96 199.94,159.12 199.6,159.36 198.64,159.19 198.41,158.85 198.59,157.82 198.29,156.87 197.18,156.05 194.72,156.05 v2(194.49,156.29)
  BOTTOM w0.124: J19.2 v2(194.49,156.29) ; J16.1 v2(243.5,156.29)
DELTA_L_85_10IN_IN1_DP: length 254
  IN1 w0.136: v2(194.49,155.54) 194.73,155.77 197.27,155.77 198.53,156.7 198.88,157.8 198.7,158.79 198.81,158.94 198.8,158.94 199.54,159.06 199.69,158.96 200.78,152.8 201.11,152.57 201.98,152.72 202.22,153.06 201.19,158.84 201.29,158.99 201.93,159.1 202.08,159 203.18,152.8 203.51,152.57 204.38,152.72 204.62,153.06 203.59,158.84 203.7,158.98 204.33,159.1 204.48,158.99 205.58,152.79 205.91,152.56 206.78,152.71 207.02,153.05 205.99,158.84 206.09,158.99 206.73,159.1 206.88,159 207.98,152.8 208.31,152.57 209.18,152.72 209.42,153.06 208.4,158.8 208.5,158.95 209.14,159.06 209.29,158.96 210.38,152.8 210.71,152.57 211.58,152.72 211.82,153.06 210.8,158.8 210.9,158.95 211.54,159.06 211.69,158.96 212.78,152.8 213.11,152.57 213.98,152.72 214.22,153.06 213.2,158.83 213.3,158.98 213.94,159.09 214.08,158.99 215.18,152.79 215.52,152.56 216.38,152.71 216.62,153.05 215.6,158.83 215.7,158.98 216.34,159.09 216.48,158.99 217.58,152.81 217.91,152.57 218.19,152.62 218.35,152.65 218.78,152.73 219.02,153.06 218,158.79 218.11,158.94 218.74,159.05 218.89,158.95 219.98,152.8 220.32,152.57 221.18,152.72 221.42,153.06 220.4,158.79 220.51,158.94 221.14,159.05 221.29,158.95 222.38,152.79 222.72,152.56 223.58,152.71 223.82,153.05 222.8,158.82 222.9,158.97 223.54,159.08 223.69,158.98 224.78,152.8 225.12,152.57 225.98,152.72 226.22,153.06 225.2,158.83 225.3,158.98 225.94,159.09 226.09,158.99 227.18,152.8 227.52,152.57 228.38,152.72 228.62,153.06 227.6,158.84 227.7,158.98 228.34,159.1 228.48,158.99 229.58,152.8 229.92,152.57 230.78,152.72 231.02,153.06 230,158.82 230.1,158.97 230.74,159.08 230.89,158.98 231.98,152.79 232.32,152.55 233.19,152.7 233.42,153.04 232.4,158.83 232.5,158.97 233.14,159.09 233.29,158.98 234.38,152.78 234.72,152.55 235.59,152.7 235.82,153.04 234.8,158.82 234.9,158.97 235.54,159.08 235.69,158.98 236.78,152.8 237.12,152.56 237.99,152.71 238.22,153.05 237.21,158.77 237.31,158.91 238.09,159.05 238.29,158.91 238.59,157.19 240.6,155.78 243.26,155.78 v2(243.5,155.54)
  BOTTOM w0.124: J16.2 v2(243.5,155.54) ; J19.1 v2(194.49,155.54)
DELTA_L_85_10IN_IN2_DN: length 254
  TOP w0.124: J20.2 v2(194.49,158.08) ; J17.1 v2(243.5,158.08)
  IN2 w0.136: v2(243.5,158.08) 243.26,158.31 240.74,158.31 239.45,159.26 239.11,160.34 239.29,161.33 239.18,161.47 238.45,161.6 238.3,161.5 237.21,155.34 236.88,155.11 236.01,155.26 235.77,155.6 236.8,161.38 236.69,161.53 236.06,161.64 235.91,161.54 234.81,155.34 234.48,155.11 233.61,155.26 233.37,155.6 234.4,161.38 234.29,161.52 233.66,161.64 233.51,161.53 232.41,155.33 232.07,155.1 231.21,155.25 230.97,155.59 232,161.38 231.89,161.53 231.26,161.64 231.11,161.54 230.01,155.34 229.68,155.11 228.81,155.26 228.57,155.6 229.59,161.34 229.49,161.49 228.85,161.6 228.7,161.5 227.61,155.34 227.28,155.11 226.41,155.26 226.17,155.6 227.19,161.34 227.09,161.49 226.45,161.6 226.3,161.5 225.21,155.34 224.87,155.11 224.01,155.26 223.77,155.6 224.79,161.37 224.69,161.52 224.05,161.63 223.91,161.52 222.81,155.33 222.47,155.1 221.61,155.25 221.37,155.59 222.39,161.37 222.29,161.52 221.65,161.63 221.51,161.53 220.41,155.35 220.07,155.11 219.8,155.16 219.8,155.16 219.64,155.19 219.21,155.26 218.97,155.6 219.99,161.33 219.88,161.48 219.25,161.59 219.1,161.49 218.01,155.34 217.67,155.1 216.81,155.26 216.57,155.59 217.59,161.33 217.48,161.48 216.85,161.59 216.7,161.49 215.61,155.33 215.27,155.1 214.4,155.25 214.17,155.59 215.19,161.36 215.09,161.51 214.45,161.62 214.3,161.52 213.21,155.34 212.87,155.11 212.01,155.26 211.77,155.6 212.79,161.37 212.69,161.52 212.05,161.63 211.9,161.53 210.81,155.34 210.47,155.11 209.6,155.26 209.37,155.6 210.39,161.38 210.29,161.52 209.65,161.64 209.5,161.53 208.41,155.34 208.07,155.1 207.2,155.26 206.97,155.59 207.99,161.36 207.89,161.51 207.25,161.62 207.1,161.52 206.01,155.32 205.67,155.09 204.8,155.24 204.57,155.58 205.59,161.36 205.49,161.51 204.85,161.62 204.7,161.52 203.6,155.32 203.27,155.09 202.4,155.24 202.16,155.58 203.19,161.36 203.09,161.51 202.45,161.62 202.3,161.52 201.21,155.34 200.87,155.1 200,155.25 199.77,155.59 200.78,161.31 200.68,161.45 200.34,161.51 200,161.57 199.77,161.42 199.47,159.69 197.51,158.32 194.73,158.32 v2(194.49,158.08)
DELTA_L_85_10IN_IN2_DP: length 254
  TOP w0.124: J17.2 v2(243.5,158.83) ; J20.1 v2(194.49,158.83)
  IN2 w0.136: v2(243.5,158.83) 243.26,158.59 240.83,158.59 239.69,159.43 239.4,160.36 239.58,161.39 239.35,161.73 238.38,161.9 238.05,161.66 236.96,155.5 236.81,155.4 236.17,155.51 236.07,155.66 237.09,161.45 236.86,161.78 235.99,161.94 235.65,161.7 234.56,155.51 234.41,155.4 233.77,155.52 233.67,155.66 234.69,161.44 234.46,161.78 233.59,161.93 233.25,161.7 232.16,155.5 232.01,155.39 231.37,155.51 231.27,155.65 232.29,161.45 232.06,161.79 231.19,161.94 230.85,161.7 229.76,155.51 229.61,155.4 228.97,155.52 228.87,155.66 229.88,161.4 229.65,161.74 228.78,161.9 228.45,161.66 227.36,155.5 227.21,155.4 226.57,155.51 226.47,155.66 227.48,161.41 227.25,161.74 226.38,161.9 226.05,161.66 224.96,155.5 224.81,155.4 224.17,155.52 224.07,155.66 225.09,161.43 224.85,161.77 223.99,161.92 223.65,161.69 222.55,155.49 222.41,155.39 221.77,155.51 221.67,155.65 222.69,161.44 222.45,161.77 221.59,161.93 221.25,161.69 220.16,155.51 220.01,155.41 219.37,155.52 219.27,155.67 220.28,161.4 220.05,161.73 219.18,161.89 218.84,161.65 217.75,155.5 217.61,155.4 216.97,155.51 216.87,155.66 217.88,161.4 217.65,161.74 216.78,161.89 216.44,161.65 215.35,155.5 215.21,155.39 214.57,155.51 214.46,155.65 215.49,161.43 215.25,161.76 214.38,161.92 214.05,161.68 212.95,155.51 212.81,155.4 212.17,155.52 212.07,155.66 213.09,161.44 212.85,161.77 211.99,161.93 211.65,161.69 210.55,155.5 210.41,155.4 209.77,155.51 209.66,155.66 210.69,161.44 210.45,161.78 209.59,161.93 209.25,161.7 208.15,155.5 208.01,155.4 207.37,155.51 207.26,155.66 208.28,161.43 208.05,161.76 207.18,161.92 206.85,161.68 205.75,155.49 205.6,155.38 204.96,155.5 204.86,155.64 205.89,161.43 205.65,161.77 204.78,161.92 204.45,161.68 203.35,155.49 203.2,155.38 202.56,155.5 202.46,155.64 203.48,161.42 203.25,161.76 202.38,161.91 202.04,161.68 200.95,155.5 200.8,155.4 200.17,155.51 200.06,155.66 201.07,161.37 200.84,161.71 199.93,161.87 199.52,161.58 199.22,159.85 197.42,158.6 194.72,158.6 194.49,158.83 v2(194.49,158.83)
DELTA_L_85_10IN_TOP_DN: length 262.7
  TOP w0.124: J15.1 78.66,157.67 74.82,157.67 74.48,158 74.91,160.42 74.81,160.56 74.06,160.69 73.92,160.59 72.91,154.89 72.56,154.65 71.55,154.83 71.31,155.18 72.23,160.41 72.13,160.55 71.38,160.69 71.24,160.59 70.22,154.88 69.87,154.63 68.87,154.81 68.63,155.16 69.56,160.42 69.46,160.57 68.7,160.7 68.56,160.6 67.55,154.88 67.2,154.64 66.19,154.82 65.95,155.17 66.87,160.39 66.77,160.53 66.02,160.67 65.87,160.57 64.87,154.89 64.52,154.65 63.52,154.82 63.27,155.18 64.2,160.41 64.1,160.55 63.34,160.68 63.2,160.58 62.69,157.72 62.19,154.88 61.84,154.63 60.83,154.81 60.59,155.16 61.52,160.39 61.41,160.53 60.66,160.67 60.52,160.57 59.51,154.89 59.16,154.65 58.16,154.82 57.91,155.18 58.84,160.4 58.74,160.54 57.98,160.68 57.84,160.58 56.83,154.86 56.48,154.62 55.47,154.79 55.23,155.14 56.16,160.4 56.06,160.55 55.31,160.68 55.16,160.58 54.15,154.87 53.8,154.63 52.8,154.81 52.55,155.16 53.48,160.39 53.38,160.53 52.62,160.67 52.48,160.57 51.47,154.87 51.12,154.62 50.12,154.8 49.87,155.15 50.8,160.4 50.7,160.55 49.95,160.68 49.8,160.58 48.79,154.87 48.44,154.62 47.44,154.8 47.19,155.15 48.12,160.41 48.02,160.55 47.27,160.68 47.13,160.58 46.11,154.86 45.76,154.61 44.76,154.79 44.51,155.14 45.44,160.4 45.34,160.54 44.59,160.67 44.45,160.57 43.43,154.86 43.08,154.62 42.08,154.79 41.83,155.14 42.76,160.39 42.66,160.54 41.91,160.67 41.77,160.57 40.76,154.86 40.41,154.62 39.4,154.8 39.16,155.15 40.09,160.4 39.99,160.54 39.23,160.68 39.09,160.57 38.58,157.71 38.08,154.88 37.73,154.63 36.73,154.81 36.48,155.16 37.41,160.39 37.31,160.53 36.55,160.67 36.41,160.57 35.4,154.89 35.05,154.65 34.05,154.82 33.8,155.18 34.73,160.4 34.63,160.54 33.87,160.68 33.73,160.58 32.72,154.86 32.37,154.62 31.37,154.79 31.12,155.14 32.05,160.4 31.95,160.55 31.2,160.68 31.05,160.58 30.04,154.87 29.69,154.63 28.69,154.81 28.44,155.16 29.37,160.39 29.27,160.53 28.52,160.67 28.37,160.57 27.36,154.87 27.01,154.62 26.01,154.8 25.76,155.15 26.19,157.54 26.06,157.67 22.34,157.67 J18.2
DELTA_L_85_10IN_TOP_DP: length 262.7
  TOP w0.124: J15.2 78.66,157.97 74.94,157.97 74.81,158.1 75.24,160.49 74.99,160.84 73.99,161.02 73.64,160.77 72.63,155.07 72.48,154.97 71.73,155.1 71.63,155.25 72.56,160.48 72.31,160.83 71.31,161.01 70.96,160.76 69.95,155.06 69.8,154.96 69.05,155.09 68.95,155.23 69.88,160.49 69.63,160.84 68.63,161.02 68.28,160.78 67.27,155.06 67.12,154.96 66.37,155.09 66.27,155.24 67.19,160.46 66.95,160.81 65.95,160.99 65.6,160.74 64.59,155.07 64.45,154.97 63.69,155.1 63.59,155.25 64.52,160.48 64.27,160.83 63.27,161.01 62.92,160.76 62.38,157.72 61.91,155.05 61.77,154.95 61.01,155.09 60.91,155.23 61.84,160.46 61.59,160.81 60.59,160.99 60.24,160.74 59.23,155.07 59.09,154.97 58.34,155.1 58.24,155.25 59.16,160.47 58.91,160.82 57.91,161 57.56,160.75 56.55,155.04 56.41,154.94 55.65,155.07 55.55,155.22 56.48,160.47 56.24,160.83 55.23,161 54.88,160.76 53.87,155.05 53.73,154.95 52.98,155.09 52.88,155.23 53.8,160.46 53.56,160.81 52.55,160.99 52.2,160.74 51.19,155.04 51.05,154.94 50.3,155.08 50.19,155.22 51.12,160.47 50.88,160.83 49.88,161 49.53,160.76 48.52,155.05 48.37,154.94 47.62,155.08 47.52,155.22 48.45,160.48 48.2,160.83 47.2,161.01 46.85,160.76 45.83,155.04 45.69,154.94 44.94,155.07 44.84,155.21 45.77,160.47 45.52,160.82 44.52,161 44.17,160.75 43.16,155.06 43.01,154.94 42.26,155.07 42.16,155.22 43.09,160.47 42.84,160.82 41.84,160.99 41.49,160.75 40.48,155.04 40.33,154.94 39.58,155.07 39.48,155.22 40.41,160.47 40.16,160.82 39.16,161 38.81,160.75 38.27,157.71 37.8,155.05 37.66,154.95 36.9,155.09 36.8,155.23 37.73,160.46 37.48,160.81 36.48,160.99 36.13,160.74 35.12,155.07 34.98,154.97 34.23,155.1 34.13,155.25 35.05,160.47 34.81,160.82 33.8,161 33.45,160.75 32.44,155.04 32.3,154.94 31.54,155.07 31.44,155.22 32.37,160.47 32.13,160.83 31.13,161 30.77,160.76 29.76,155.05 29.62,154.95 28.87,155.09 28.77,155.23 29.69,160.46 29.45,160.81 28.44,160.99 28.09,160.74 27.08,155.04 26.94,154.94 26.19,155.08 26.09,155.22 26.51,157.64 26.18,157.97 22.34,157.97 J18.1
FLASHCARD_B_PRSNT_N: length 8
  BOTTOM w0.112: R3121.1 161.9,12.82 v3(162.46,12.26) 164.63,10.09 166.76,10.09 166.9,9.96 J49.1
FLASHCARD_PRSNT_N: length 11.4
  TOP w0.112: R3048.1 v1(80.49,18.54) 79.7,17.75 v2(79.7,10.69)
  BOTTOM w0.112: J41.1 v2(79.7,10.69)
FM_BIC_DEBUG_EN: length 4.8
  TOP w0.112: R4232.2 111.16,145.76 v1(111.03,145.89) 110.51,146.41 R4233.1 109.33,146.1 Q24.2
FM_BIC_DEBUG_EN_R: length 445.2
  TOP w0.112: v2(78.87,33.33) 78.2,33.06 77.51,32.37 77.51,27.85 78.08,27.28 78.08,25.54 78.72,24.91 79.76,24.91 81.77,22.89 84.8,22.89 84.98,23.07 87.68,23.07 98.38,12.36 v2(98.38,11.08) ; U86.B11 40.52,41.01 40.52,38.04 40.73,37.82 40.73,35.64 40.95,35.43 v2(40.97,35.43) ; v2(83.04,142.52) 82.76,142.24 82.76,141.91 81.18,140.33 81.18,137.46 81.6,137.04 87.33,137.04 87.54,136.83 91.28,136.83 92.14,135.97 93.88,135.97 96.74,138.83 96.74,141.86 97.17,142.29 98.6,142.29 100.19,140.7 110.33,140.7 111.06,141.42 111.06,143.33 R4232.1
  IN1 w0.122: v2(26.08,25.92) 26.64,25.36 28.5,25.36 32.22,21.64 32.22,19.61 34.71,17.12 38.99,17.12 45.96,10.16 45.96,10.1 47.21,8.84 80,8.84 85.98,14.82 94.65,14.82 v2(98.38,11.08) ; v2(91.57,42.47) 89.81,40.71 88.19,40.71 86.83,39.35 86.08,39.04 83.63,39.04 83.2,38.86 78.87,34.53 v2(78.87,33.33) ; v2(15.16,102.81) 15.16,103.68 15.67,104.19 15.67,106.95 15.1,107.51 15.1,109.86 15.97,110.73 15.97,118.56 19.79,122.38 20.59,126.38 20.59,131.09 19.8,131.88 19.8,134.53 26.19,140.91 41.53,140.91 45.37,144.75 49.8,144.75 51,143.55 59.35,143.55 59.65,143.85 60.41,143.85 61.24,143.02 62.64,143.02 64.32,144.7 67.74,144.7 68.18,144.26 68.18,143.26 69.16,142.28 71.22,142.28 71.39,142.45 76.35,142.45 76.61,142.2 82.72,142.2 v2(83.04,142.52)
  BOTTOM w0.112: v2(26.08,25.92) 26.51,26.35 26.64,26.35 27.26,26.97 28.27,26.97 29.33,28.03 29.53,28.11 32.61,28.11 32.73,28.23 33.26,28.23 37.59,32.56 38.33,32.56 40.05,34.28 40.62,34.28 40.97,34.64 v2(40.97,35.43) ; v2(15.16,102.81) 16.4,101.57 17.38,101.57 18.4,102.59 28.97,102.59 29.63,101.92 43.89,101.92 45.84,99.97 49.39,99.97 50.47,98.89 52.4,98.89 53.05,98.24 58.34,98.24 59.61,99.51 71.68,99.51 74.76,96.44 81.08,96.44 95.71,81.8 95.71,59.46 95.87,59.3 95.87,47.81 94.03,45.96 94.03,44.5 92,42.47 v2(91.57,42.47)
FM_BIC_M2A_EN: length 5.2
  TOP w0.112: v2(7.31,81.41) 7.81,81.91 7.81,82.73 7.61,82.92 U95.2
  BOTTOM w0.112: v2(7.31,81.41) 8.19,82.29 R4275.2 8.18,82.6 R4057.2
FM_BIC_M2A_EN_R: length 79.4
  TOP w0.112: U86.B13 v6(39.95,41.94)
  IN1 w0.122: v6(39.95,41.94) 39.53,41.94 37.59,40 36.16,40 32.48,43.68 27.12,43.68 26.46,44.34 24.86,44.34 24.2,43.67 19.1,43.67 18.62,44.16 16.27,44.16 15.63,43.51 15.16,43.51 14.24,42.6 11.88,42.6 9.42,45.05 9.42,45.3 8.79,45.93 6.94,45.93 6.53,46.34 6.53,53.21 7.23,53.9 7.23,59.99 6.92,60.29 5.82,61.4 5.82,61.94 3.31,64.45 3.31,69.61 4.39,70.69 4.39,75.99 5.41,77.01 5.41,77.52 4.67,78.25 4.67,79.14 4.68,79.16 4.68,79.46 v2(5.55,80.33)
  BOTTOM w0.112: v2(5.55,80.33) 5.58,80.33 6.37,81.11 R4057.1
FM_BIC_M2B_EN: length 4.3
  TOP w0.112: v2(5.2,83.98) 4.64,83.42 U95.6
  BOTTOM w0.112: R4058.2 5.03,84.15 v2(5.2,83.98) 5.95,84.73 R4276.2
FM_BIC_M2B_EN_R: length 94.8
  TOP w0.112: U86.A16 38.45,40.28 37.78,39.6 35.35,39.6 33.76,38.02 33.76,36 34.6,35.16 34.6,32.86 31.28,29.54 27.25,29.54 24.31,32.49 16.02,32.49 v2(14.56,33.94)
  IN1 w0.122: v2(14.56,33.94) 13.27,35.23 10.82,35.23 9.32,36.73 7.81,36.73 3.94,40.6 3.94,42.75 2.64,44.05 2.64,58.09 1.6,59.13 1.6,79.2 2.31,79.91 2.31,83.68 v2(1.84,84.16)
  BOTTOM w0.112: R4058.1 1.84,84.15 v2(1.84,84.16)
FM_BIC_M2C_EN: length 5.1
  TOP w0.112: U96.2 3.82,80.2 4.18,80.55 v2(4.18,80.83)
  BOTTOM w0.112: v2(4.18,80.83) 3.21,80.83 2.97,80.59 R4277.2 R4059.2
FM_BIC_M2C_EN_R: length 77.5
  TOP w0.112: v5(42.69,47.48) 42.95,47.74 U86.R7
  IN1 w0.122: v2(5.39,78.82) 6.18,78.03 6.18,76.33 6.2,76.31 6.2,76.3 7.45,75.04 10.67,75.04 10.98,75.36 16.01,75.36 17.22,74.15 19.24,74.15 21.3,76.21 25.12,76.21 25.69,75.65 44.79,75.65 45.11,75.33 45.11,73.72 45.31,73.52 45.36,73.52 45.36,73.53 v2(45.33,73.53)
  IN2 w0.122: v5(42.69,47.48) 42.9,47.69 42.9,48.11 43.43,48.64 43.43,56.43 44.43,57.43 44.44,57.43 45.99,58.99 46,59 46.03,59.03 46.29,59.67 46.29,61.38 45.93,61.75 45.93,65.93 47.67,67.67 47.67,70.23 45.33,72.58 v2(45.33,73.53)
  BOTTOM w0.112: v2(5.39,78.82) 5.17,78.59 R4059.1
FM_BIC_M2D_EN: length 3.9
  TOP w0.112: U96.6 3.32,75 v1(3.2,74.88) 3.3,74.78 R4278.2 2.22,73.68 R4060.2
FM_BIC_M2D_EN_R: length 60.2
  TOP w0.112: R4060.1 1.84,72.5 1.84,66.23 2.43,65.64 v4(4.17,65.64) ; v5(40.29,47.56) 39.95,47.89 U86.R13
  IN1 w0.122: v4(4.17,65.64) 6.33,65.64 8.7,63.26 8.7,62.51 9.44,61.77 19.06,61.77 19.52,61.31 30.65,61.31 31.9,60.06 32.86,60.06 33.33,59.6 33.33,58.87 34.02,58.18 v2(37.73,58.18)
  BOTTOM w0.112: v2(37.73,58.18) 38.4,57.51 38.66,57.51 39.33,56.84 39.33,55.93 40.23,55.03 40.23,54.13 40.83,53.53 40.83,52.71 40.46,52.34 40.46,51.35 41.01,50.8 41.01,49.85 40.53,49.37 40.53,48.62 40.29,48.38 v5(40.29,47.56)
FM_BIC_M2E_EN: length 5.9
  TOP w0.112: v2(8.66,89.57) 8.52,89.43 U97.2
  BOTTOM w0.112: R4061.2 R4279.2 8.48,91.52 8.66,91.34 v2(8.66,89.57)
FM_BIC_M2E_EN_R: length 81.3
  TOP w0.112: v2(2.36,71.39) 2.36,71.39 2.36,67 2.98,66.38 v2(4.67,66.38) ; U86.U12 v5(40.95,48.94)
  IN1 w0.122: v2(4.67,66.38) 5.98,66.38 9.02,63.34 9.02,62.58 9.55,62.05 19.22,62.05 19.68,61.59 31.22,61.59 31.48,61.33 32.66,61.33 33.06,60.92 33.06,60.33 33.86,59.53 35.75,59.53 36.19,59.09 37.9,59.09 v2(38.22,58.76) ; v2(1.85,89.43) 1.77,89.35 1.77,87.91 2.35,87.32 2.35,84.03 2.59,83.8 2.59,79.8 2.35,79.56 2.35,79.01 1.88,78.54 1.88,71.87 v2(2.36,71.39)
  BOTTOM w0.112: R4061.1 6.74,90.38 5.44,89.08 2.9,89.08 2.54,89.43 v2(1.85,89.43) ; v5(40.95,48.94) 40.95,49.09 41.44,49.58 41.44,50.87 40.82,51.49 40.82,52.2 41.2,52.58 41.2,53.67 40.65,54.22 40.65,55.5 39.73,56.43 39.73,57.08 38.97,57.83 38.69,57.83 38.22,58.3 v2(38.22,58.76)
FM_BIC_M2F_EN: length 5.7
  TOP w0.112: U97.6 4.67,89.93 5.21,90.47 v2(5.21,90.91)
  BOTTOM w0.112: R4062.2 4.96,90.66 v2(5.21,90.91) 5.21,91.36 6.4,92.56 R4280.2
FM_BIC_M2F_EN_R: length 101.5
  TOP w0.089: 38.33,39.76 38.74,40.18 38.74,41.15 U86.B16
  TOP w0.112: v2(13.06,34) 13.75,34 15.56,32.19 24.19,32.19 27.1,29.28 31.39,29.28 34.88,32.76 34.88,37.22 36.96,39.3 37.87,39.3 38.33,39.76
  IN1 w0.122: v2(13.06,34) 12.24,34.82 10.54,34.82 9.93,35.43 8.46,35.43 2.68,41.22 2.68,41.64 2.88,41.85 2.88,43.22 2.36,43.74 2.36,57.98 1.33,59.01 1.33,90.26 1.42,90.35 v2(1.42,90.63)
  BOTTOM w0.112: v2(1.42,90.63) 1.7,90.63 1.74,90.66 R4062.1
FM_BIC_M2G_EN: length 5.5
  TOP w0.112: v2(8.95,93.69) 8.95,92.87 8.67,92.59 U98.2
  BOTTOM w0.112: v2(8.95,93.69) 9.63,94.37 R4281.2 R4089.2
FM_BIC_M2G_EN_R: length 103.3
  TOP w0.112: v6(42.45,43.2) 42.5,43.15 42.5,42.49 U86.D8
  IN1 w0.122: v6(42.45,43.2) 42.45,41.86 41.18,40.58 39.08,40.58 37.95,39.45 35.83,39.45 32.2,43.08 30.72,43.08 30.25,42.61 22.48,42.61 22.15,42.94 18.81,42.94 16.42,40.55 15.82,40.55 15.09,41.28 10.38,41.28 9.53,42.14 8.82,42.14 8.24,42.71 8.24,42.78 5.41,45.61 5.41,57.32 6.1,58.01 6.1,59.41 4.35,61.15 4.35,61.67 2.15,63.87 2.15,70.12 3.1,71.07 3.1,76.99 2.48,77.62 2.48,77.98 2.99,78.49 2.99,79.42 3.14,79.57 3.14,84.02 2.99,84.17 2.99,90.38 v2(1.96,91.41)
  BOTTOM w0.112: R4089.1 7.65,94.89 6.71,93.95 5.26,93.95 4.57,93.27 1.73,93.27 1.37,92.91 1.37,92 v2(1.96,91.41)
FM_BIC_M2H_EN: length 5.1
  TOP w0.112: v2(5.33,94.59) 5.31,94.56 5.31,93.7 4.7,93.09 U98.6
  BOTTOM w0.112: R4090.2 R4282.2 4.52,93.78 v2(5.33,94.59)
FM_BIC_M2H_EN_R: length 99.6
  TOP w0.112: v2(42.51,38.87) 42.86,39.22 42.86,39.85 42.45,40.26 U86.A8
  IN1 w0.122: v2(1.7,94.59) 1.51,94.4 1.51,91.23 1.98,90.77 2.03,90.77 2.71,90.09 2.71,84.06 2.86,83.91 2.86,79.68 2.63,79.45 2.63,78.9 2.15,78.42 2.15,76.96 2.82,76.28 2.82,71.18 1.88,70.24 1.88,63.76 4.08,61.56 4.08,61.04 5.82,59.3 5.82,58.43 5.13,57.74 5.13,45.5 7.97,42.66 7.97,42.6 8.82,41.74 9.54,41.74 10.27,41.01 14.97,41.01 15.71,40.27 16.53,40.27 18.92,42.66 21.16,42.66 21.49,42.34 30.37,42.34 30.84,42.81 32.08,42.81 35.71,39.18 38.23,39.18 38.56,39.51 41.87,39.51 v2(42.51,38.87)
  BOTTOM w0.112: v2(1.7,94.59) 1.91,94.79 R4090.1
FM_BIC_M2I_EN: length 4.6
  TOP w0.112: v2(8.53,86.85) 7.77,86.09 U99.2
  BOTTOM w0.112: R4091.2 R4283.2 7.71,86.03 v2(8.53,86.85)
FM_BIC_M2I_EN_R: length 91
  TOP w0.112: U86.M3 44.89,46.44 44.38,45.93 v5(44.38,45.89)
  IN1 w0.122: v2(7.8,88.19) 7.06,87.45 7.06,86.49 6.75,86.18 6.75,76.6 7.75,75.6 10.24,75.6 10.55,75.92 16.61,75.92 16.71,75.82 19.05,75.82 20,76.77 25.39,76.77 25.95,76.21 46.39,76.21 47.23,75.37 47.23,74.59 47.08,74.44 v2(46.82,74.44)
  IN2 w0.122: v2(46.82,74.44) 46.82,72.78 48.8,70.8 48.8,66.92 47.05,65.17 47.05,62.39 47.42,62.02 47.42,59.22 47.18,58.63 47.1,58.44 45.04,56.38 45.04,53.63 46.87,51.8 46.87,48.28 45.04,46.44 44.94,46.44 v5(44.38,45.89)
  BOTTOM w0.112: v2(7.8,88.19) 7.29,87.68 6.96,87.68 6.58,87.31 R4091.1
FM_BIC_M2J_EN: length 4.4
  TOP w0.112: U99.6 2.62,86.59 2.03,87.17 v2(1.88,87.17) 1.55,87.5 R4284.2
  BOTTOM w0.112: R4092.2 2.02,87.32 v2(1.88,87.17)
FM_BIC_M2J_EN_R: length 88.6
  TOP w0.112: U86.P3 44.88,47.44 44.58,47.75 44.33,47.75 44.04,47.46 v5(43.29,47.46)
  IN1 w0.122: v2(5.18,87.2) 6.2,86.18 6.2,83.42 6.45,83.17 6.45,76.44 7.57,75.32 10.35,75.32 10.67,75.64 16.49,75.64 16.59,75.54 19.32,75.54 20.28,76.49 25.27,76.49 25.83,75.93 45.66,75.93 46.22,75.37 46.22,74.69 v2(45.77,74.25)
  IN2 w0.122: v5(43.29,47.46) 44.58,47.46 45.36,48.24 45.36,49.12 44.19,50.3 44.19,56.79 46.22,58.83 46.23,58.84 46.26,58.87 46.57,59.62 46.57,61.59 46.2,61.96 46.2,65.81 47.95,67.56 47.95,70.45 45.77,72.62 v2(45.77,74.25)
  BOTTOM w0.112: v2(5.18,87.2) 5.06,87.32 R4092.1
FM_BIC_M2K_EN: length 6
  TOP w0.112: v2(9.93,97.26) 8.43,95.75 U100.2
  BOTTOM w0.112: R4093.2 R4285.2 v2(9.93,97.26)
FM_BIC_M2K_EN_R: length 99.7
  TOP w0.112: v5(40.91,48.32) 41.3,47.94 U86.R10
  IN1 w0.122: v2(6.68,98.27) 6.42,98.02 6.42,95.45 5.89,94.92 5.89,94.01 6.42,93.48 6.42,91.08 5.77,90.42 4.77,90.42 4.32,89.97 4.32,84.84 4.65,84.51 5.46,84.51 5.69,84.28 5.69,83.19 6.09,82.79 6.09,80.18 4.95,79.03 4.95,78.58 5.86,77.67 5.86,76.22 7.31,74.76 10.99,74.76 11.31,75.08 15.25,75.08 16.45,73.87 19.51,73.87 21.57,75.93 24.83,75.93 26.06,74.7 26.7,74.7 27.03,74.37 39.42,74.37 39.7,74.65 43.71,74.65 43.9,74.46 v2(44.59,74.46)
  IN2 w0.122: v5(40.91,48.32) 40.91,48.39 41.31,48.79 41.31,51.43 41.04,51.7 41.04,52.7 41.17,52.83 41.17,56.49 41.18,56.5 41.18,56.76 42.79,58.37 44.14,58.37 45.22,59.45 45.44,59.98 45.44,61.03 44.55,61.92 44.55,68.79 45.36,69.6 45.36,71.04 44.46,71.94 44.46,74.33 v2(44.59,74.46)
  BOTTOM w0.112: R4093.1 v2(6.68,98.27)
FM_BIC_M2L_EN: length 5
  TOP w0.112: v2(5.46,97.64) 5.11,97.28 5.11,96.66 4.69,96.25 U100.6
  BOTTOM w0.112: R4094.2 R4286.2 5.13,97.97 v2(5.46,97.64)
FM_BIC_M2L_EN_R: length 100.3
  TOP w0.112: U86.D12 40.6,42.44 v6(40.89,42.73)
  IN1 w0.122: v6(40.89,42.73) 40.36,42.2 40.36,41.77 40.12,41.53 39.6,41.53 37.8,39.73 35.95,39.73 32.27,43.4 27,43.4 26.34,44.06 24.98,44.06 24.25,43.33 18.82,43.33 16.3,40.82 15.94,40.82 15.2,41.56 10.63,41.56 9.78,42.41 8.93,42.41 8.52,42.82 8.52,42.89 5.68,45.73 5.68,57.21 6.37,57.9 6.37,59.64 4.63,61.38 4.63,61.79 2.43,63.98 2.43,70.01 3.43,71.01 3.43,76.39 3.37,76.44 3.37,77.11 3.36,77.12 3.36,77.98 3.26,78.08 3.26,79.31 3.41,79.46 3.41,84.14 3.26,84.29 3.26,90.21 3.4,90.35 3.4,97.88 2.5,98.78 v2(2.06,98.78)
  BOTTOM w0.112: R4094.1 2.26,98.98 v2(2.06,98.78)
FM_CLKBUF_DB1200_EN: length 60.9
  TOP w0.112: Q36.D R3601.1 91.14,40.74 v2(90.67,40.27) 90.35,40.59 R4387.1 ; v2(66.19,75.13) 65.46,74.4 65.46,71.63 65.21,71.38 R2960.2 R2961.2
  BOTTOM w0.112: v2(66.19,75.13) 66.73,75.67 72.29,75.67 76.55,71.41 76.55,67.5 81.22,62.82 81.22,61.61 85.23,57.6 87.5,52.13 87.5,48.26 86.02,46.77 86.02,42.94 86.36,42.12 86.47,42 87.12,41.73 89.21,41.73 v2(90.67,40.27)
FM_CLKBUF_DB1200_EN_R: length 4.6
  TOP w0.112: U47.6 65.21,66.27 65.38,66.45 65.38,66.76 64.51,67.63 v1(64.51,67.91) 64.33,68.09 64.33,68.93 R2961.1
FM_COM_EN_N: length 31.3
  IN1 w0.122: v2(25.38,35.74) 28.32,35.74 29.01,35.04 32.08,35.04 32.78,34.34 34.35,34.34 34.53,34.16 36.18,34.16 36.2,34.18 v2(37.55,34.18)
  IN2 w0.122: v2(25.16,43.05) 24.98,42.87 24.98,40.1 24.71,39.83 24.71,38.43 25.38,37.76 v2(25.38,35.74)
  BOTTOM w0.112: U94.C12 19.95,46.15 20.71,46.15 20.93,45.93 20.93,44.46 21.44,43.94 22.73,43.94 23.62,43.05 v2(25.16,43.05) ; v2(37.55,34.18) 37.55,34.42 37.88,34.75 37.88,34.98 39.03,36.13 R4006.1
FM_COM_EN_N_R: length 8.4
  TOP w0.112: v6(40.74,43.33) 40.28,42.87 40.28,42.76 U86.D13
  BOTTOM w0.112: v6(40.74,43.33) 40.39,42.99 40.39,41.4 v3(40.34,41.35) 39.68,40.68 39.68,38.47 38.99,37.78 38.99,37.08 R4006.2
FM_COM_SEL_0: length 11.5
  TOP w0.112: v2(19.95,45.15) 22.19,45.15 22.73,45.68 23.5,45.68 23.75,45.44 v1(27.94,45.44) 27.94,44.39 28.17,44.15 R4007.1
  BOTTOM w0.112: U94.B12 v2(19.95,45.15)
FM_COM_SEL_0_R: length 7.7
  TOP w0.112: U86.H19 36.46,44.44 36.12,44.09 33.7,44.09 33.02,44.78 v1(32.5,44.78) 32.24,44.52 31.61,44.52 31.09,44 30.25,44 R4007.2
FM_COM_SEL_1: length 13.6
  TOP w0.112: v2(25.52,43.62) 25.61,43.53 v1(26.52,43.53) 27.98,42.07 27.98,41.71 28.16,41.53 30.33,41.53 31.03,42.23 v2(31.03,42.36)
  BOTTOM w0.112: R4008.1 31.64,42.98 v2(31.03,42.36) ; v2(25.52,43.62) 25.08,43.62 24.84,43.38 23.68,43.38 22.84,44.22 22.27,44.22 21.95,44.53 21.95,45.15 U94.B14
FM_COM_SEL_1_R: length 9.6
  TOP w0.112: U86.G16 38.46,43.94 38.85,44.33 39.09,44.33 39.47,44.71 v6(39.53,44.71)
  IN1 w0.122: v2(35.2,44.55) 35.68,44.08 36.68,44.08 36.96,44.36 39.18,44.36 v6(39.53,44.71)
  BOTTOM w0.112: v2(35.2,44.55) 35.2,44.17 34.01,42.98 R4008.2
