# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P3V3_OR_M2I_EN: length 157
  IN2 w0.122: v2(13.87,105.16) 11.82,103.11 11.82,101.43 12.68,100.58 12.68,94.82 12.21,94.35 10.31,94.35 8.62,92.67 8.23,92.67 6.78,91.23 6.78,89.94 5.51,88.67 v2(5.51,88.24)
  BOTTOM w0.112: R4085.2 4.38,86.62 5.4,86.62 5.71,86.93 5.71,88.04 v2(5.51,88.24) ; v2(13.87,105.16) 13.87,105.67 14.6,106.4 15.9,106.4 16.94,105.35 22.14,105.35 22.42,105.08 29.8,105.08 30.61,104.27 49.36,104.27 51.94,101.69 52.37,101.69 53.86,100.2 57.53,100.2 58.97,101.64 72.33,101.64 75.27,98.7 78.02,98.7 79.5,100.18 89.52,100.18 90.1,100.76 97.1,100.76 98.15,101.81 114.05,101.81 118.58,106.34 119.01,106.34 119.26,106.6 119.26,108.56 118.49,109.33 118.49,115.61 118.07,116.03 114.99,116.03 114.56,116.47 111.53,116.47 111.41,116.35 U31.11
P3V3_OR_M2I_EN_R: length 3.5
  TOP w0.112: v2(1.89,85.9) 2.08,86.09 U99.7
  BOTTOM w0.112: v2(1.89,85.9) 2.23,86.24 R4085.1
P3V3_OR_M2J_EN: length 127.2
  IN1 w0.122: v2(9.68,91.49) 9.35,91.82 9.35,93.32 9.43,93.41 9.43,95.24 10.42,96.23 10.42,99.78 11.94,101.3 14.72,101.3 15.71,102.29 15.71,103.56 16.22,104.07 16.22,108.62 v2(16.34,108.73)
  BOTTOM w0.112: v2(9.68,91.49) 9.68,89.97 9.22,89.51 9.22,89.33 8.76,88.87 R4086.2 ; U30.11 85.77,116.27 85.94,116.44 88.51,116.44 89.01,115.93 94.07,115.93 v3(94.62,115.38) 94.62,109.56 92.99,107.93 92.79,107.93 88.82,103.97 88.82,103.19 88.12,102.5 74.87,102.5 73.77,103.59 58.16,103.59 56.72,102.15 54.67,102.15 53.18,103.64 52.75,103.64 50.17,106.23 31.42,106.23 30.61,107.04 23.23,107.04 22.49,107.77 19.83,107.77 18.87,108.73 v2(16.34,108.73)
P3V3_OR_M2J_EN_R: length 5.9
  TOP w0.112: U99.3 6.08,86.59 v2(5.16,85.67)
  BOTTOM w0.112: v2(5.16,85.67) 6.15,86.66 6.15,88.28 R4086.1
P3V3_OR_M2K_EN: length 101.9
  IN2 w0.122: v2(5.56,96.75) 4.78,97.53 4.78,97.71 5.5,98.44 5.5,100.21 6.21,100.92 6.21,102.83 8.02,104.64 8.02,105.77 9.83,107.58 10.54,107.58 11.2,108.25 11.2,109.71 12.59,111.1 14.06,111.1 v2(15.11,112.15)
  BOTTOM w0.112: U29.11 61.58,116.29 61.69,116.4 63.59,116.4 64.21,115.78 65.4,115.78 65.81,115.38 68.29,115.38 69.07,114.6 69.07,107.51 67.64,106.08 67.64,105.01 66.61,103.99 58,103.99 56.56,102.55 54.83,102.55 53.34,104.03 52.92,104.03 50.33,106.62 31.58,106.62 30.77,107.43 26.78,107.43 25.63,108.58 24.81,108.58 24.47,108.93 23.12,108.93 22.4,108.21 19.95,108.21 18.88,109.27 15.57,109.27 14.41,110.43 14.41,111.45 v2(15.11,112.15) ; v2(5.56,96.75) 4.31,96.75 R4087.2
P3V3_OR_M2K_EN_R: length 4.1
  TOP w0.112: U100.7 3.23,95.75 2.26,96.72 v2(1.8,96.72)
  BOTTOM w0.112: v2(1.8,96.72) 2.01,96.93 R4087.1
P3V3_OR_M2L_EN: length 66.5
  IN2 w0.122: v2(14.92,110.65) 12.94,108.67 12.94,108.41 12.63,108.09 12.37,108.09 9.25,104.97 9.25,100.6 v2(8.65,99.99)
  BOTTOM w0.112: U28.11 38.99,118.55 39.2,118.76 40.2,118.76 40.36,118.92 41.57,118.92 41.97,118.51 42.49,118.51 42.66,118.34 45.44,118.34 45.79,117.99 45.79,117.09 46.31,116.57 46.31,115.25 46.03,114.96 46.03,111.25 45.06,110.29 45.06,108.18 43.89,107.01 31.74,107.01 30.8,107.95 27.21,107.95 26.17,109 25.29,109 24.97,109.32 24.97,109.91 24.17,110.71 23.26,110.71 22.71,110.16 21.92,110.16 21.38,109.63 20.92,109.63 20.4,110.14 20.4,110.76 20.1,111.07 15.34,111.07 v2(14.92,110.65) ; R4088.2 8.63,99.98 v2(8.65,99.99)
P3V3_OR_M2L_EN_R: length 5.2
  TOP w0.112: v2(6.58,99.26) 6.05,98.73 6.05,96.47 6.26,96.25 U100.3
  BOTTOM w0.112: v2(6.58,99.26) 6.92,99.26 6.96,99.31 R4088.1
P3V3_STBY: length 1050.8
  TOP w0.203: U73.B1 36.74,115.9 36.97,116.12 ; U77.B1 135.33,115.24 135.73,115.64 ; U74.B1 61.43,115.87 61.97,116.41 ; 161.98,121.78 162.76,121 U78.B1 ; U75.B1 86.22,116.15 86.65,116.59 ; U76.B1 111.43,115.05 111.73,115.36 111.73,115.7 112.57,116.53
  TOP w0.254: v2(2.62,95.63) 2.99,95.25 U100.8 ; U86.L12 40.49,45.98 40.49,46.41 U86.M12 ; U86.L12 40.09,45.94 39.65,46.38 v6(39.65,46.96) ; U86.L12 U86.L11 ; U86.L12 U86.K12 U86.K11 U86.L11 ; U86.G10 41.58,43.94 v6(41.94,43.59) ; C1180.1 4.32,75.13 U96.8 ; U97.8 3.28,88.93 2.46,88.11 v2(2.24,88.11) ; U66.7 183.36,135.87 v2(183.36,134.89) ; v2(185.79,27.67) 185.54,27.93 185.54,32.65 183.68,34.51 183.68,34.65 ; v6(42.44,44.02) 42.02,44.44 U86.H9 U86.J9 ; U86.L11 U86.L10 ; U86.L11 U86.M11 ; v2(1.86,82.04) 2.24,82.42 U95.8 ; v6(43.31,44.96) 42.95,45.31 U86.K7 U86.K8 U86.J8 ; U98.8 v2(2.66,92.09) ; PR126.1 184.04,14.9 v2(183.61,14.47) ; U19.10 24.56,117.8 24.46,118.05 24.03,118.48 C1237.1 ; v6(42.82,44.53) 42.45,44.9 U86.J8 ; U99.8 2.75,85.59 2.17,85.01 v2(1.89,85.01) ; PR125.1 185.08,15.66 185.08,15.1 PC110.1 v2(185.94,14.89) ; U86.N16 v6(37.95,46.94) 37.95,46.95 U86.P17 ; U86.M12 40.29,46.6 v6(40.29,46.91) ; U86.M12 U86.M11 ; v6(43.93,43.44) U86.F4 U86.F3 ; U86.P10 41.4,47.44 v6(40.95,46.99) U86.M11 ; U86.J9 U86.J10 ; U86.J9 U86.J8 ; U86.P19 36.44,47.44 v6(36.36,47.52)
  TOP w0.279: U21.10 74.18,116.52 73.72,116.98 C1239.1 ; U61.3 120.69,41.69 120.42,41.96 ; C145.1 151.12,117.33 U24.10 ; C1241.1 123.38,117.63 123.53,117.26 U23.10
  TOP w0.305: U22.10 99.58,117.4 99.16,117.83 C1240.1 ; U20.10 49.27,117.67 v2(48.81,118.13)
  TOP w0.33: R3236.1 v2(124.87,44.55) ; R3601.2 v2(92.95,39.74) ; R3230.1 v2(126.94,37.41) ; R3232.1 v2(126.94,36.4) ; 189.61,144.64 U50.14
  TOP w0.381: R4097.1 R3437.2 96.21,145.81 v2(96.42,146.02) ; v2(123.59,118.44) 123.14,117.99 C1241.1 ; R4328.1 83.19,34.57 83.78,35.16 v2(83.94,35.16) ; U62.5 C952.2 ; R3899.2 38.9,110.77 39.42,111.3 v2(40.36,111.3) ; R4379.1 26.59,33.83 25.29,35.13 U91.1 ; v2(41.61,55.55) 41.1,55.04 R4343.1 ; v2(130.7,37.15) R3239.1 R3238.1 ; 48.3,110.12 49.33,109.09 50.5,109.09 51.18,109.77 v2(52.7,109.77) 54.42,111.49 55.85,111.49 R3900.2 56.04,112.23 55.9,112.36 R3713.1 R3630.1 ; R3634.1 80.7,112.02 81.89,110.82 85.43,110.82 R3901.2 ; R3634.1 80.5,112.15 77.64,109.29 v2(72.96,109.29) ; R3634.1 R3728.1 ; R16.1 12.85,25.76 v2(13.18,25.43) ; v2(33.63,53.54) 33.57,53.59 R3792.1 ; v2(100.02,118.37) 99.67,118.37 C1240.1 ; R3799.1 50.14,43.92 49.59,43.92 v2(49.56,43.89) ; R3795.1 v2(36.86,53.49) ; 36.97,116.12 36.97,117.79 36.59,118.17 36.59,119.3 C1085.1 ; v2(37.62,120.33) 37.59,120.36 37.04,120.36 36.68,120 C1085.1 ; R4373.1 v2(22.31,22.81) ; R4373.1 R4380.1 ; R4373.1 R4372.1 ; 160.98,115.55 160.98,115.55 R3732.1 ; 160.98,115.55 R3658.1 ; 160.98,115.55 160.98,114.94 160.68,114.63 159.51,114.63 158.06,113.17 v2(157.74,113.17) ; v2(34.16,33.9) C1233.1 32.57,32.96 U108.1 ; R3801.1 v2(49.56,40.84) ; v2(12.44,108.54) C122.1 13.08,107.97 12.88,107.78 U26.14 ; U106.8 139.86,38.41 C1226.1 140.1,39.34 139.26,40.19 136.31,40.19 v2(135.54,40.96) ; R4381.1 v2(22.98,27.69) ; v2(49.46,42.88) 49.49,42.85 50.14,42.85 R3798.1 ; R3790.1 40.21,35.55 v2(40.05,35.4) ; R4342.1 v2(37.1,35.07) 37.1,34.65 36.6,34.15 R4341.1 ; v2(121.16,111.3) 121.69,111.3 123.13,109.87 125.63,109.87 127.6,111.84 129.35,111.84 129.89,111.3 R3651.1 131.2,111.3 131.68,110.82 R3731.1 130.35,110.44 130.19,110.29 130.19,109.79 130.33,109.47 131.17,108.62 132.62,108.62 133.88,109.14 134.43,109.69 R3887.2 ; R3043.1 v2(71.81,17.98) ; v2(48.81,118.13) 48.77,118.17 C1238.1 ; v2(70.8,17.98) R3047.1 ; C1085.1 36.84,119.39 37.19,119.04 37.19,118.63 38.69,117.13 v2(40.17,117.13) ; C1167.1 8.21,44.4 v2(7.95,44.15) ; R4056.1 42.7,56.79 v2(42.92,56.57) ; v2(31.42,113.67) 31.42,112.92 32.55,111.79 32.55,110.9 32.77,110.36 33.02,110.11 R3622.1 R3619.1 ; C145.1 v2(151.66,117.41) ; U108.16 32.57,23.95 33.72,22.8 C1234.1 v2(32.97,22.26) ; R3051.1 v2(68.7,20.02) ; v2(22.21,18.28) 22.01,18.48 PR701.1 ; R4274.2 18.16,44.15 v2(17.73,43.72) ; PR309.1 196.32,35.36 v2(196.07,35.36) ; R3808.1 22.25,82.68 v2(22.7,83.13) ; R3902.2 108.83,108.72 107.75,109.8 R3730.1 ; v2(185.29,135.64) 185.94,135.64 R3275.1 R3276.1 ; C1239.1 73.86,117.22 v2(74.33,117.22) ; C1237.1 24.68,118.56 v2(24.68,118.56) ; R3729.1 106.45,111.17 105.82,110.54 102.88,110.54 101.57,109.22 97.69,109.22 v2(96.8,110.11) ; R3847.1 v2(24.54,37.8) ; v2(132.19,39.73) C1227.1 132.5,38.19 132.72,38.41 U106.1 ; R3908.1 v2(55.78,41.86) ; v2(35.76,53.54) R3794.1 ; R3793.1 34.67,53.62 v2(34.74,53.55) ; R3888.2 165.84,126.32 166.49,125.67 166.49,123.67 164.41,121.59 v2(164.41,121.08) ; 15.69,82.43 U25.14 ; R3860.1 v2(46.79,75.18)
  TOP w0.457: 189.61,144.64 190.18,144.64 C765.1 v2(190.22,145.47) ; C1168.1 8.15,59.95 v2(7.95,60.15) ; R3055.1 v2(77.61,26.55) ; C1162.1 20.16,46.93 v2(19.95,47.15) ; v2(90.3,37.58) 90.19,37.47 R3219.1 ; R3216.1 v2(78.64,25.6) ; 120.42,41.96 119.95,42.44 v2(119.95,43.1) C968.1 ; C952.2 v2(88.8,39.79)
  TOP w0.508: v2(69.06,26.22) C975.2 69.1,27.01 U54.5 ; v2(161.19,125.37) 161.33,125.52 C1095.1 162.22,125.15 162.22,124.77 161.85,124.39 161.85,122.3 161.98,122.17 161.98,121.78 ; v2(9.35,41.3) 9.02,40.97 R3914.1 ; v2(24.74,79.81) R3876.1 R3877.1 R3875.1 R3874.1 v2(27.79,79.81) ; v2(30.71,70.9) 30.9,71.09 U89.1 ; v2(46.76,35.36) 47.45,36.04 R3797.1 ; v2(103.86,59.06) R4212.2 103.09,59.03 R4217.2 ; v2(27.81,60.28) 27.81,60.55 28.27,61.01 R3822.1 R3823.1 R3825.1 R3824.1 v2(25.22,60.6) ; R3835.1 v2(35.59,60.57) ; R3101.1 R3103.1 205.73,75 206.24,74.49 C1222.1 206.24,73.26 205.8,72.82 205.02,72.82 204.5,73.34 203.22,73.34 202.71,72.82 202.71,66.44 205.05,64.1 205.71,62.51 205.71,57.95 v2(208,55.66) ; v2(135.73,119.52) C1093.1 136.52,118.1 136.52,116.99 135.73,116.2 135.73,115.64 ; R3864.1 v2(41.15,60.58) ; v2(41.22,86.41) 41.1,86.54 40.71,86.54 R4214.2 ; v2(86.01,119.89) C1089.1 86.65,116.59 ; R3217.1 81.92,32.74 v2(81.69,32.97) ; v2(6.45,27.71) 6.65,27.91 R3884.1 ; C1165.1 23.74,59.93 v2(23.95,60.15) ; U93.1 v2(30.42,90.09) ; C1160.1 13.76,54.33 v2(13.95,54.15) ; v2(16.21,64.24) 16.59,64.62 R3302.1 R3301.1 R2800.1 R2799.1 19.63,64.62 v2(20.02,64.23) ; R3765.1 v2(31.84,34.59) ; C1180.1 v2(5.19,74.9) ; v2(23.95,44.15) 23.73,44.36 C1169.1 ; R3791.1 v2(44.4,35.41) ; R4210.2 32.23,83.06 v2(31.78,82.6) ; R3915.1 8.51,37.54 v2(8.86,37.9) ; v2(17.95,54.15) 18.45,54.15 C1166.1 ; R3234.1 126.41,41.35 v2(127.15,41.35) ; R3883.1 7.47,30.22 v2(7.47,29.83) ; v2(31.72,87.94) 31.93,88.14 R4215.2 ; R3861.1 v2(43.18,60.58) ; U88.1 22.69,74.92 v2(22.49,74.72) ; R3913.1 8.53,38.56 v2(8.81,38.84) ; 15.69,82.43 15.77,82.35 C121.1 15.8,81.71 16.32,81.71 16.4,81.63 v2(16.49,81.63) ; v2(40.25,59.31) 40.71,58.85 D17.A ; R3836.1 v2(34.57,60.57) ; R3729.1 107.75,110.17 R3730.1 ; v2(11.63,36.73) C44.2 U6.8 ; R4216.2 v2(95.27,56.06) ; R4206.2 38.54,81.33 R4211.2 v2(37.56,82.07) ; R4208.2 R4209.2 87.86,56.29 v2(87.35,56.79) ; R3862.1 v2(42.16,60.58) ; R2848.1 v2(14.45,79.17) ; v2(17.95,50.15) 17.54,49.74 C1163.1 ; R3837.1 v2(32.54,60.57) ; C1161.1 14.35,49.75 v2(13.95,50.15) ; v2(206.04,108.08) 206.45,107.68 R3269.1 ; R3838.1 v2(33.56,60.57) ; v2(24.71,36.22) 24.47,35.98 U91.1 ; R3834.1 v2(38.18,79.02) ; R4048.1 v2(2.96,9.09) ; R4207.2 v2(88.21,59.49) ; R3873.1 v2(30.38,98.22) ; v2(42.44,87.55) 41.05,88.95 R4213.2 ; 61.97,116.41 62.83,116.41 63.37,116.95 C1087.1 v2(63.37,119.98) ; v2(14.95,50.15) 15.1,50.29 C1164.1 ; 112.57,116.53 112.57,117.29 111.83,118.02 C1091.1 111.83,119.62 v2(111.65,119.8) ; U90.1 v2(38.22,70.86) ; R3882.1 v2(7.01,31.8) ; U92.1 v2(45.81,70.87) ; R3863.1 v2(40.13,60.58) ; R3821.1 v2(30.86,79.04)
  IN2 w0.254: v2(183.35,33.51) 182.68,32.83 182.68,28.47 182.01,27.8 182.01,24.64 187.62,19.03 187.62,15.81 186.82,15.01 186.06,15.01 v2(185.94,14.89) ; v2(172.83,3.57) 172.57,3.84 172.2,3.84 171.66,4.37 171.66,5.58 173.71,7.63 178.88,7.63 183.97,12.72 183.97,14.11 v2(183.61,14.47) ; v2(64.55,113.4) 65.01,112.94 65.01,109.43 71.32,103.12 73.54,103.12 74.68,104.26 76.17,104.26 78.28,103.38 80.49,101.17 88.17,97.99 91.69,97.99 93.21,96.47 98.37,96.47 v2(99.66,95.18)
  IN2 w0.381: v2(164.94,117.72) 164.22,118.44 164.22,120.89 v2(164.41,121.08) ; v2(185.79,27.67) 185.77,27.67 184.26,26.16 184.26,25.24 185.06,24.44 193.78,24.44 197.86,28.51 197.86,32.56 197.08,33.34 197.08,34.35 v2(196.07,35.36)
  IN2 w0.508: v2(208,55.66) 206.08,53.74 206.08,50.14 206.47,49.74 206.47,38.99 206.79,38.67 206.79,32.22 205,30.44 205,29.59 196.7,21.29 196.7,16.89 200.27,13.32 203.45,13.32 207.5,9.28 207.5,2.85 206.26,1.61 171.89,1.61 170.82,2.68 170.82,6.86 169.91,7.78 163.37,7.78 158.32,12.83 158.32,18.3 160.79,20.78 160.79,29.48 v2(163.25,31.94) ; v2(190.49,123.01) 190.49,122.27 194.07,118.68 194.75,118.68 195.73,117.7 195.73,112.54 198.81,109.46 204.45,109.46 205.83,108.08 v2(206.04,108.08)
  BOTTOM w0.203: U81.B1 73.07,113.33 72.69,112.95 ; U80.B1 48.52,114.61 48.01,114.1 ; U84.B1 149.74,117.17 149.58,117.02 ; U83.B1 122.12,114.06 121.87,113.8 ; U82.B1 98.23,113.74 98.03,113.54 ; 25.13,112.73 25.31,112.73 25.51,112.93 U79.B1
  BOTTOM w0.254: v2(99.66,95.18) 99.86,95.18 105.6,89.45 105.6,49.43 104.7,48.54 104.7,35.41 107.43,32.68 107.43,17.39 99.64,9.59 99.64,5.9 104.13,1.41 170.67,1.41 v2(172.83,3.57) ; v2(185.79,27.67) 185.79,26.93 186.23,26.49 186.23,24.84 185.15,23.76 185.15,16.64 184.32,15.81 184.32,14.45 179.65,9.77 175.14,9.77 172.65,12.26 172.65,15.58 173.15,16.08 173.15,17.7 173.62,18.17 PR207.2 ; U101.21 80.04,48.52 79.95,48.42 79.95,47.67
  BOTTOM w0.279: U30.10 85.27,116.35 85.1,116.53 C1246.1 ; U33.10 162.5,119.73 162.26,119.97 C1243.1 ; 99.32,34.15 99.32,34.34 99.12,34.53 U2.9 ; U32.10 134.76,116.76 134.39,117.13 C1244.1 ; C1248.1 38.62,118.92 38.49,118.61 U28.10 ; v2(61.05,117.62) 60.73,117.31 C1247.1 60.73,116.62 61.08,116.27 U29.10 ; C1245.1 110.47,116.8 110.91,116.36 U31.10
  BOTTOM w0.381: 25.13,112.73 22.56,112.73 21.83,112 C1097.1 ; v2(31.42,113.67) 32.57,112.52 36.56,112.52 36.68,112.4 38.47,112.4 38.75,112.12 R3691.1 ; R4055.1 v2(54.46,48.97) ; D4.8 131.56,42.96 131.47,42.88 C1078.1 ; R4051.1 45.62,54.02 45.97,53.67 v2(46.6,53.67) ; C1244.1 134.39,117.99 v2(134.27,118.11) ; R3893.2 124.9,108.39 124.76,108.53 R3719.1 ; R3712.1 102.55,108.64 103.85,107.34 R3892.2 104.4,107.63 103.21,108.82 103.21,109.56 103.47,109.82 109.66,109.82 110.38,109.1 112.94,109.1 v2(113.31,109.47) ; R4231.2 14.62,28.54 v2(14.91,28.83) ; R4371.1 32.18,34.93 v2(31.84,34.59) ; U107.5 59.68,12.97 58.69,13.96 C1232.2 57.41,13.96 v2(56.87,13.43) 57.09,13.21 57.28,13.21 R4358.1 ; v2(34.16,33.9) 34.74,34.48 34.74,35.61 R3787.1 ; R3890.2 53.59,109.33 53.16,109.77 v2(52.7,109.77) 52.23,109.77 R3698.1 R3697.1 ; R4230.2 9.77,28.42 v2(9.99,28.64) ; R4377.1 30.72,34.97 v2(30.33,34.57) 29.7,33.94 R4376.1 ; C1075.2 183.25,135.54 C1223.1 183.21,135.5 183.21,135.04 v2(183.36,134.89) ; C1245.1 110.47,117.35 110.74,117.62 v2(110.77,117.62) ; R3891.2 78.96,105.3 79.55,105.89 v2(79.55,106.07) 79.55,107.38 79.13,107.8 R3705.1 ; v2(34.2,37.84) 34.41,38.05 R3786.1 ; v2(137.19,111.25) 136.42,110.48 134.95,109.88 133.68,109.88 132.9,110.66 131.74,110.66 130.38,112.01 127.63,112.01 126.78,111.16 126.78,109.61 126.13,108.96 R3720.1 ; C1116.1 37.36,47.53 v6(37.95,46.94) ; v2(164.86,113.94) 164.86,113.46 163.65,112.25 161.94,112.25 161.31,112.88 158.73,112.88 158.44,113.17 v2(157.74,113.17) 156.59,112.03 R3727.1 R3726.1 154.44,111.06 153.56,110.17 R3894.2 ; U7.8 15.81,77.79 C45.1 16.39,78.37 v2(16.96,78.37) ; U94.A1 v2(7.95,44.15) ; v2(50,50.98) 50.1,51.08 R3788.1 ; C1246.1 v2(85.1,117.55) ; 149.58,117.02 149.34,116.77 149.34,115.68 148.16,114.51 C1107.1 ; v2(161.46,120.75) 161.84,120.37 C1243.1 ; v6(42.44,44.02) 41.94,44.53 C1115.1 ; R3678.1 39.07,110.49 38.68,110.1 37.5,110.1 R3889.2 ; C1248.1 38.62,119.47 38.15,119.94 37.91,120.05 v2(37.62,120.33) ; C1123.1 42.54,45.57 43.15,44.96 v6(43.31,44.96) ; R3923.2 20.21,39.25 v2(20.71,39.74) ; C1138.1 25.71,37.36 27.68,37.36 R4378.1 ; R4290.1 v2(4.87,102.39) ; R4052.1 47.62,56.24 v2(47.39,56.47) ; R3789.1 v2(50.11,49.99)
  BOTTOM w0.457: U94.G9 v2(16.95,50.15) ; U94.A16 v2(23.95,44.15) ; U94.K10 v2(17.95,54.15) ; U94.D12 v2(19.95,47.15) ; U94.T1 v2(7.95,60.15) ; U94.G8 v2(14.95,50.15) ; U94.G7 v2(13.95,50.15) ; U94.K7 v2(13.95,54.15) ; U94.G10 v2(17.95,50.15) ; U94.T16 v2(23.95,60.15) ; v2(99.96,33.26) C1.1 99.32,33.27 99.32,34.15 ; U94.D5 v2(11.95,47.15)
  BOTTOM w0.508: R3796.1 46.76,35.72 v2(46.76,35.36) ; R3850.1 v2(18.97,34.04) ; v2(51.5,38.74) 51.71,38.96 R3751.1 ; R4385.1 v2(11.14,6.81) ; 98.03,113.54 98.03,111.53 97.54,111.04 97.54,109.85 C1103.1 96.8,109.78 v2(96.8,110.11) ; v2(2.62,95.63) 3.13,95.63 C1184.1 ; R2931.1 v2(72.54,61.49) 72.62,61.42 R2932.1 ; v2(2.66,92.09) 3.03,91.72 C1185.1 ; R3801.1 v2(49.56,40.84) ; C1144.1 22.55,74.78 v2(22.49,74.72) ; v2(81.64,47.32) 81.51,47.32 80.98,46.79 C1187.1 C1186.1 79.95,47.67 ; R2935.1 v2(72.54,53.65) ; C103.1 45.71,70.96 v2(45.81,70.87) ; C1147.1 30.42,90.1 v2(30.42,90.09) ; C1097.1 21.83,111.91 v2(22.35,111.38) ; R3719.1 R3720.1 ; v2(2.24,88.11) 2.79,88.11 C1181.1 ; R2934.1 72.54,57.51 v2(72.59,57.56) R2933.1 ; R2796.1 62.69,50.44 63.42,49.71 v2(63.42,49.56) ; v2(147.39,112.68) 148.02,112.68 C1107.1 ; v2(70.64,52.1) 70.61,52.07 R2793.1 ; v2(150.89,47.17) 150.89,47.67 153.79,50.57 156.36,50.57 157.02,51.23 ; R21.1 12.97,80.94 v2(12.51,81.39) ; C1138.1 25.42,36.81 24.83,36.22 v2(24.71,36.22) ; 157.02,51.23 157.02,53.76 158.48,55.22 R24.1 R23.1 ; 157.02,51.23 160.01,51.23 160.79,52.01 C46.1 160.81,52.35 U8.8 ; R3849.1 v2(21.01,34.04) ; R2792.1 70.13,53.09 v2(70.46,52.76) ; R3848.1 v2(22.02,34.04) ; v2(63.5,52.2) R2794.1 ; R3704.1 R3705.1 ; R3712.1 R3711.1 ; R2791.1 v2(70.38,54.13) ; v2(45.95,110.26) 46.05,110.36 C1099.1 46.68,111.16 48.01,112.49 48.01,114.1 ; C1141.1 38.18,70.9 v2(38.22,70.86) ; C1135.1 30.92,71.11 v2(30.71,70.9) ; R2795.1 68.5,50.42 69.11,49.81 v2(69.11,49.48) ; 121.87,113.8 121.87,110.4 121.77,110.3 121.02,110.3 120.49,109.76 C1105.1 119.29,109.76 v2(119.06,109.54) ; R3851.1 v2(19.99,34.04) ; C1182.1 3.08,82.18 1.99,82.18 v2(1.86,82.04) ; v2(64.4,41.31) 64.4,40.8 R4071.1 ; R19.1 15.29,81.01 15.9,81.63 v2(16.49,81.63) ; v2(55.56,40.04) 55.56,39.45 R3747.1 ; R3755.1 57.23,40.01 v2(57.75,40.54) ; R3046.1 v2(99.19,42.16) ; C1078.1 v2(130.88,43.51) ; R4067.1 v2(66.46,41.43) ; v2(78.84,44.66) 78.81,44.69 78.81,45.92 R4163.2 ; 72.69,112.95 72.69,111.61 73.75,110.56 C1101.1 73.44,109.12 73.27,109.29 v2(72.96,109.29) ; v2(1.89,85.01) 2.17,85.01 2.38,85.22 C1183.1 ; R2930.1 v2(72.54,66.68)
  vias: v2(1.74,104.06) v2(2.42,104.05) v2(9.15,31.08) v2(9.35,38.43) v2(9.26,32.8) v2(11.22,33.86) v2(11.23,33.17) v2(15.95,17.63) v2(15.96,16.96) v2(16.61,16.96) v2(16.65,17.63) v2(21.26,116.69) v2(21.31,115.94) v2(21.67,114.05) v2(21.74,113.33) v2(22.1,110.74) v2(22.28,113.79) v2(22.43,115.85) v2(40.12,116.46) v2(40.61,115.12) v2(41.2,115.42) v2(41.22,114.73) v2(41.5,117.25) v2(41.53,116.6) v2(41.94,114.73) v2(42.04,117.75) v2(45.82,116.42) v2(45.82,115.79) v2(46.67,114.16) v2(46.69,113.16) v2(46.79,112.27) v2(47.2,113.54) v2(47.2,112.77) v2(63.12,114.29) v2(63.13,113.53) v2(63.92,112.08) v2(63.93,111.38) v2(63.93,110.75) v2(63.93,110.11) v2(64.56,114.17) v2(67.74,70.84) v2(67.87,68.43) v2(70.45,115.04) v2(70.46,114.36) v2(70.46,113.67) v2(72.03,112.9) v2(72.03,112.24) v2(72.03,110.82) v2(72.06,111.53) v2(88.34,115.01) v2(88.34,114.38) v2(88.3,113.65) v2(88.39,112.83) v2(88.77,112.27) v2(89.02,115.01) v2(89.08,114.38) v2(89.05,112.85) v2(96.47,113.56) v2(96.48,112.91) v2(97.14,113.58) v2(97.16,112.9) v2(97.18,112.26) v2(97.18,111.6) v2(110.62,32.33) v2(111.25,32.36) v2(113.05,114.93) v2(113.27,114.21) v2(113.31,113.31) v2(113.28,112.67) v2(113.26,112.01) v2(113.26,111.38) v2(113.28,110.74) v2(113.31,110.11) v2(121.16,113.87) v2(121.16,113.23) v2(121.16,112.6) v2(121.18,111.96) v2(121.54,115.42) v2(121.59,114.72) v2(123.32,143.25) v2(124.19,143.56) v2(124.86,143.33) v2(124.86,142.61) v2(136.93,112.73) v2(136.93,111.99) v2(137.05,114.34) v2(136.98,113.36) v2(137.08,114.98) v2(145.67,115.67) v2(146.72,113.98) v2(146.71,113.33) v2(146.72,112.62) v2(146.74,111.93) v2(147.39,114.02) v2(147.39,113.35) v2(162.62,29.7) v2(162.6,28.85) v2(162.62,28.06) v2(162.63,27.16) v2(163.2,33.51) v2(163.21,32.74) v2(164.2,114.58) v2(164.22,113.93) v2(164.88,115.22) v2(164.92,114.58) v2(165.28,29.66) v2(165.25,28.81) v2(165.27,28.02) v2(165.28,27.12) v2(165.53,115.2) v2(165.54,113.92) v2(165.59,114.56) v2(165.69,33.65) v2(165.73,32.79) v2(165.75,31.99) v2(165.88,29.26) v2(165.86,28.41) v2(165.88,27.62) v2(165.89,26.72) v2(166.42,29.69) v2(166.41,28.81) v2(166.43,28) v2(166.44,27.1) v2(167.34,33.41) v2(167.34,32.72) v2(169.23,31.78) v2(169.27,33.99) v2(169.29,33.34) v2(169.25,32.58) v2(170.52,29.7) v2(170.5,28.85) v2(170.52,28.06) v2(170.52,27.16) v2(171.12,29.3) v2(171.1,28.45) v2(171.12,27.66) v2(171.13,26.76) v2(171.65,28.85) v2(171.7,33.93) v2(171.66,31.24) v2(171.66,30.48) v2(171.66,29.73) v2(171.67,28.05) v2(171.68,27.15) v2(175.41,33.65) v2(175.41,32.88) v2(175.41,32.15) v2(175.41,31.44) v2(175.54,29.81) v2(175.51,28.96) v2(175.53,28.17) v2(175.54,27.27) v2(176.14,29.41) v2(176.12,28.56) v2(176.14,27.77) v2(176.15,26.87) v2(176.68,29.84) v2(176.67,28.96) v2(176.69,28.16) v2(176.7,27.26) v2(177.47,30.83) v2(178.54,30.84) v2(179.59,30.87) v2(180.39,31.85) v2(180.39,29.84) v2(180.39,29.13) v2(180.39,28.37) v2(181.09,29.84) v2(181.09,29.13) v2(181.09,28.37) v2(181.66,41.3) v2(181.7,40.66) v2(181.74,31.39) v2(182.33,41.33) v2(182.36,40.69) v2(182.97,41.32) v2(183,40.68) v2(183.69,41.32) v2(183.73,40.68) v2(184.05,33.48) v2(184.39,41.37) v2(184.43,40.73) v2(184.65,39.34) v2(184.66,38.69) v2(184.67,38.04) v2(184.69,37.39) v2(184.67,36.73) v2(184.7,36.08) v2(184.71,35.44) v2(184.71,34.75) v2(184.72,34.09) v2(185.2,39.02) v2(185.22,38.37) v2(185.25,37.07) v2(185.26,37.74) v2(185.26,36.43) v2(185.26,35.77) v2(185.27,35.12) v2(185.28,34.43) v2(185.28,33.77) v2(187.58,132.23) v2(187.59,131.48) v2(187.57,130.73) v2(187.57,130.06) v3(182.09,32.39) v3(182.11,29.52) v3(182.59,27.27) v3(184.05,28.9) v3(184.34,31.86)
P3V3_STBY_ADDR1: length 3.4
  TOP w0.152: PU101.18 181.93,17.16 182.42,16.67 v2(182.42,16.64)
  BOTTOM w0.178: v2(182.42,16.64) 182.3,16.76 180.57,16.76 PR105.2
P3V3_STBY_ADDR2: length 2.6
  TOP w0.178: PU201.18 170.74,17.16 171.28,16.62 171.28,16.53 171.97,15.84 PR202.2
P3V3_STBY_ADDR3: length 2.6
  TOP w0.178: 194.59,31.34 194.32,31.61 PU601.18
  TOP w0.203: PR602.2 195.43,30.33 194.59,31.17 194.59,31.34
P3V3_STBY_BIC_SCALED: length 13.1
  TOP w0.112: v1(55.98,45.1) 55.43,45.1 54.36,44.04
  TOP w0.254: U86.G1 46,43.89 48.8,43.89 49.43,44.53 53.87,44.53 54.36,44.04 C1157.1 R3905.1 R3908.2
P3V3_STBY_CTRL: length 71.5
  TOP w0.112: PR123.2 PR122.2 163.82,17.77 v2(163.9,17.68) 164.02,17.68 164.21,17.88 164.65,18.17 165.12,18.36 PU201.9 ; PU601.9 188.38,32.81 187.48,31.91 v2(187.43,31.91) ; PU101.9 176.08,18.36 v2(175.71,18.21)
  IN1 w0.122: v2(175.71,18.21) 175.71,17.37 176.59,16.48 176.59,14.8 175.25,13.46 175.25,11.4 176.3,10.35 176.89,10.35 176.9,10.34 176.92,10.34 177.3,9.95 181.28,9.95 181.37,10.04 181.75,10.04 185.13,13.43 185.13,14.99 185.43,15.29 185.43,17.65 185.91,18.12 185.91,25.9 187.08,27.08 187.08,30.52 186.85,30.75 186.85,31.25 187.43,31.83 v2(187.43,31.91)
  IN2 w0.122: v2(163.9,17.68) 163.9,11.71 165.86,9.74 170.78,9.74 172.77,11.73 172.77,17.13 173.85,18.21 v2(175.71,18.21)
P3V3_STBY_IREF1: length 3.2
  TOP w0.178: v2(182.42,17.83) 182.28,17.96 PU101.20
  BOTTOM w0.178: PR101.2 182.08,17.48 v2(182.42,17.83)
P3V3_STBY_IREF2: length 2.5
  TOP w0.178: PR201.2 172.34,16.96 172,17.3 171.57,17.3 170.91,17.96 PU201.20
P3V3_STBY_IREF3: length 2.5
  TOP w0.178: 195.21,31.92 194.98,31.92 194.49,32.41 PU601.20
  TOP w0.203: 195.21,31.92 195.5,31.92 195.83,31.59 PR601.2
P3V3_STBY_ISUM1: length 54.5
  TOP w0.152: v2(182.96,16.98) 182.64,17.29 182.25,17.29 181.98,17.56 PU101.19
  TOP w0.178: v2(195.2,31.27) 195.16,31.27 194.41,32.01 PU601.19 ; v2(171.73,16.8) 171.66,16.87 171.53,16.87 170.83,17.56 PU201.19
  IN1 w0.254: v2(171.73,16.8) 171.73,16 172.74,14.99 172.74,11.53 175.49,8.78 v2(176.24,8.78)
  IN2 w0.254: v2(184.83,25.48) 185.33,24.98 193.66,24.98 196.9,28.23 196.9,29.56 v2(195.2,31.27) ; v2(176.24,8.78) 178.75,8.78 182.6,12.63 182.6,15.8 182.96,16.15 v2(182.96,16.98)
  BOTTOM w0.254: v2(184.83,25.48) 183.2,23.85 183.2,18.52 183.06,18.37 183.06,17.46 182.96,17.36 v2(182.96,16.98)
P3V3_STBY_PS#1: length 2
  TOP w0.254: v2(181.82,15.87) 181.91,15.96 181.91,16.41 181.65,16.66 PU101.17
  BOTTOM w0.254: v2(181.82,15.87) 181.85,15.84 PR106.2
P3V3_STBY_PS#2: length 3.1
  TOP w0.254: PR203.2 171.67,14.8 170.9,15.57 v2(170.9,15.83) 170.9,16.35 170.59,16.66 PU201.17
P3V3_STBY_PS#3: length 3
  TOP w0.178: PU601.17 194.13,31.11 194.31,30.94 194.31,30.38 194.92,29.76 v2(194.96,29.76)
  TOP w0.203: v2(194.96,29.76) 195.41,29.31 PR603.2
P3V3_STBY_SET: length 71.8
  TOP w0.112: v2(188.61,30.27) 189.06,30.27 189.16,30.37 PU601.13 ; PU101.13 176.65,16.66 176.54,16.55 176.54,15.63 175.97,15.06 v2(175.56,15.06) ; PU201.13 165.28,16.66 165.03,16.56 164.65,16.18 164.65,15.27 163.8,14.42 160.72,14.42 v2(160.53,14.23)
  IN1 w0.122: v2(175.56,15.06) 175.56,14.98 174.32,13.74 174.32,11.13 175.95,9.5 176.53,9.5 176.55,9.48 176.56,9.48 177.04,9 182.52,9 187.21,13.69 187.21,18.55 186.84,18.92 186.84,25.53 188.13,26.81 188.13,29.45 188.61,29.93 v2(188.61,30.27)
  IN2 w0.122: v2(175.56,15.06) 175.56,14.54 175.29,14.27 175.29,10.74 172.85,8.29 165.01,8.29 160.17,13.13 160.17,13.87 v2(160.53,14.23)
P3V3_STBY_TAKE1: length 46.5
  TOP w0.112: PU101.12 176.45,17.16 176.17,16.89 176.17,15.71 176.03,15.57 175.47,15.57 PR108.2 174.66,15.57 v2(174.66,14.77) ; v2(187.96,31.18) 187.96,31.24 188.73,32.01 PU601.11
  IN1 w0.122: v2(174.66,14.77) 173.94,14.05 173.65,14.05 173.38,13.77 173.38,11.68 175.83,9.23 176.42,9.23 176.44,9.21 176.45,9.21 176.93,8.73 182.63,8.73 187.48,13.58 187.48,19.04 187.25,19.26 187.25,25.32 188.4,26.47 188.4,28.79 189.05,29.44 189.05,30.45 188.32,31.18 v2(187.96,31.18)
P3V3_STBY_TAKE2: length 32.8
  TOP w0.112: PU101.11 176.33,17.56 175.61,16.84 175.61,16.12 v2(175.72,16.01) ; PU201.12 165.27,17.16 164.55,16.57 164.36,16.3 164.36,15.62 163.45,14.7 160.8,14.7 v2(160.55,14.96)
  IN2 w0.122: v2(160.55,14.96) 161.08,14.43 161.08,12.73 165.23,8.58 171.65,8.58 174.7,11.63 174.7,14.14 175.1,14.54 175.1,15.39 v2(175.72,16.01)
P3V3_STBY_TAKE3: length 84.5
  TOP w0.112: PU201.11 165.33,17.56 165,17.43 164.07,16.5 164.07,15.72 163.31,14.97 161.71,14.97 160.45,16.22 v2(159.9,16.22) ; PU601.12 188.76,31.61 188.56,31.42 188.48,31.23 188.48,30.78 187.99,30.29 v2(186.17,30.29)
  IN2 w0.122: v2(159.9,16.22) 160.45,16.22 161.35,15.32 161.35,12.85 165.34,8.86 171.54,8.86 174.38,11.69 174.38,13.89 173.66,14.61 173.66,15.46 175.21,17.02 176.03,17.02 176.2,16.85 176.2,14.38 175.64,13.82 175.64,8.52 175.84,8.31 178.88,8.31 183.06,12.5 183.06,15.64 183.16,15.74 184.11,15.74 185.48,14.37 186.92,14.37 188.07,15.52 188.07,19.26 182.77,24.56 182.77,26.8 186.17,30.2 v2(186.17,30.29)
P3V3_STBY_VCC: length 112.5
  TOP w0.178: PU201.24 172.09,19.56 172.35,19.82 PC205.1 ; PC605.1 195.07,34.56 194.52,34.01 PU601.24 ; PU101.24 182.16,19.56 183.16,20.56 PC106.1
  TOP w0.254: v2(197.28,29.92) 197.28,29.75 196.84,29.31 PR603.1 ; PR107.1 PR108.1 174.19,15.9 v2(174.19,15.32) 173.68,14.8 PR203.1 ; PC106.1 v2(184.14,20.56) ; v2(185.96,33.04) PR604.2 ; PC605.1 195.55,34.34 v2(196.09,34.34)
  IN2 w0.254: v2(197.28,29.92) 197.19,29.92 196.2,30.91 196.2,32.97 196.49,33.26 196.49,33.94 v2(196.09,34.34)
  BOTTOM w0.254: v2(162.36,20.59) 163.2,19.76 163.2,16.61 164.52,15.29 164.52,11.82 165.49,10.85 168.86,10.85 169.88,11.87 169.88,18.85 170.61,19.58 172.31,19.58 172.72,19.99 173.22,19.99 v2(173.36,20.13) 173.63,20.4 174.45,20.4 174.8,20.04 174.8,16.17 174.19,15.56 v2(174.19,15.32) 173.87,14.99 173.87,14.31 174.89,13.3 174.89,11.25 175.48,10.65 179.08,10.65 181.85,13.42 PR106.1 182.2,14.17 182.48,14.45 182.48,15.75 183.48,16.75 183.94,16.75 184.34,17.14 184.34,18.68 183.61,19.41 183.61,20.04 v2(184.14,20.56) 184.14,24.06 185.35,25.28 185.35,25.92 184.79,26.49 184.79,28.03 185.13,28.37 185.13,30.89 185.96,31.72 v2(185.96,33.04) 187.48,33.04 188.51,32.02 188.51,31.14 188.33,30.71 187.36,29.74 187.36,25.85 187.83,25.39 190.82,25.39 193.49,28.05 193.49,32.88 194.95,34.34 v2(196.09,34.34)
P3V3_STBY_VDRV1: length 68.7
  TOP w0.254: v2(161.55,18.65) 161.75,18.85 PR205.2 ; v2(186.79,31.9) 186.49,32.2 PR605.2
  BOTTOM w0.254: v2(186.79,31.9) 185.54,30.65 185.54,28.17 185.2,27.83 185.2,26.77 185.76,26.21 185.76,25.11 184.74,24.09 184.74,16.95 184.11,16.32 183.64,16.32 182.92,15.6 182.92,13.76 179.38,10.21 175.28,10.21 173.26,12.23 173.26,15.21 174.27,16.22 v2(174.27,19.75) 174.05,19.53 172.92,19.53 172.57,19.18 170.82,19.18 170.28,18.64 170.28,11.7 169.02,10.44 165.32,10.44 164.11,11.65 164.11,15.08 162.76,16.43 162.76,17.44 v2(161.55,18.65)
P3V3_STBY_VDRV3:
  vias: v2(186.59,34.6)
P3V3_STBY_VOSNS2+: length 54.5
  TOP w0.178: v2(171.85,18.52) 171.6,18.76 PU201.22 ; 194.72,33.21 PU601.22
  TOP w0.254: 194.72,33.21 195.28,33.21 v2(195.38,33.12) ; PR208.2 173.14,18.02 172.77,18.39 171.98,18.39 v2(171.85,18.52)
  BOTTOM w0.254: PR207.1 172.55,18.52 v2(171.85,18.52) 171.87,18.5 171.87,18.06 172.73,17.2 172.73,16.26 172.22,15.75 172.22,12.12 174.98,9.36 179.88,9.36 185.01,14.49 185.01,15.86 185.56,16.41 185.56,23.29 187.24,24.98 190.99,24.98 193.9,27.89 193.9,32.44 194.47,33.01 195.27,33.01 v2(195.38,33.12)
P3V3_STBY_VOSNS+: length 4
  TOP w0.178: 182.95,18.76 PU101.22
  TOP w0.254: 182.95,18.76 182.96,18.77 PR121.2 PC109.1 PR120.1
P3V3_STBY_VOSNS-: length 8.6
  TOP w0.178: 182.78,18.36 PU101.21
  TOP w0.254: 182.78,18.36 183.17,17.97 PR121.1 183.47,17.72 v2(183.83,17.36) 183.74,17.27 PC120.2 183.74,16.51 PR128.2 ; v2(186.66,17.61) 186.66,17.59 186.67,17.58 186.67,16.98 PR127.2
  IN2 w0.254: v2(186.66,17.61) 186.65,17.62 184.09,17.62 v2(183.83,17.36)
P12V_BIC_SCALED: length 8.7
  TOP w0.112: 46.38,44.27 45.78,44.27 U86.G2
  TOP w0.254: 46.38,44.27 48.67,44.27 49.43,45.03 51.48,45.03 C1156.1 R3904.1 R3903.2
P12V_CONN: length 30.7
  IN1 w0.508: v2(97.95,34.22) 97.95,33.32 95.13,30.5 v2(93.35,30.5)
  BOTTOM w0.279: v2(97.95,34.22) 98.12,34.39 U2.11
  BOTTOM w0.508: J41.3 v2(78.9,7.09) ; J41.15 v2(74.1,7.09) ; J41.5 v2(78.1,7.09) ; J41.14 v2(74.9,6) ; J41.12 v2(75.7,6) ; J41.13 v2(74.9,7.09) ; J41.2 v2(79.7,6) ; J41.4 v2(78.9,6) ; J41.11 v2(75.7,7.09) ; J41.7 v2(77.3,7.09) ; J41.6 v2(78.1,6) ; J41.10 v2(76.5,6) ; J41.9 v2(76.5,7.09) ; J41.8 v2(77.3,6)
  vias: v2(72.48,7.09) v2(72.6,10.23) v2(73.29,7.09) v2(73.4,10.23) v2(73.38,6) v2(73.39,2.9) v2(74.13,10.23) v2(74.18,6) v2(74.19,2.9) v2(74.93,10.23) v2(74.94,2.9) v2(75.73,10.23) v2(75.74,2.9) v2(76.53,10.23) v2(76.54,2.9) v2(77.33,10.23) v2(77.35,2.9) v2(78.13,10.23) v2(78.14,2.9) v2(78.93,10.23) v2(78.94,2.9) v2(79.74,2.9) v2(91.77,30.49) v2(91.77,29.69) v2(91.77,28.89) v2(91.77,28.09) v2(91.77,27.29) v2(91.77,26.49) v2(91.79,25.71) v2(92.58,30.5) v2(92.58,29.7) v2(92.58,28.9) v2(92.58,28.1) v2(92.58,27.3) v2(92.59,26.47) v2(92.62,25.7) v2(93.35,29.7) v2(93.35,28.9) v2(93.35,28.1) v2(93.35,27.3) v2(93.43,26.48) v2(93.45,25.7) v2(94.19,26.48) v2(94.21,25.7) v2(95.02,26.44) v2(95.04,25.66) v2(95.78,26.44) v2(95.81,25.66) v2(162.99,2.89) v2(163.55,6.57) v2(163.61,5.8) v2(163.7,2.89) v2(164.35,6.57) v2(164.41,5.8) v2(164.5,2.89) v2(165.3,6.49) v2(165.3,5.8) v2(165.27,2.89) v2(166.1,6.49) v2(166.1,5.8) v2(166.12,2.89) v2(166.9,6.49) v2(166.9,5.8) v2(166.99,2.89) v2(167.59,6.49) v2(167.59,5.8) v3(84.13,13.49) v3(92.09,19.97)
P12V_STBY: length 270.9
  TOP w0.254: R3903.1 56.67,45.94 v2(57,45.61)
  TOP w0.381: PR123.1 162.39,15.84 v2(162.06,15.51)
  TOP w0.508: v2(33.22,142.97) 34.15,142.04 36.33,142.04 37.3,141.07 37.3,140.1 37.36,140.04 37.36,138.69 37.86,138.18 42.78,138.18 43.47,138.87 43.47,140.28 44.84,141.65 v2(44.84,143.6) ; v2(92.47,141.95) 93.62,143.1 R2875.2
  IN1 w0.508: v2(92.47,141.95) 91.5,140.98 51.56,140.98 48.94,143.6 v2(44.84,143.6)
  IN2 w0.508: v2(18.2,119.22) 18.2,115.98 21.7,112.48 23.44,112.48 24.26,111.66 24.26,111.13 24.7,110.69 24.7,109.57 24.93,109.01 24.96,108.99 26.14,108.5 27.52,105.18 27.52,100.75 28.39,99.87 29.63,99.87 31.11,98.39 31.11,97.81 33.6,95.33 33.6,92.71 34.61,91.69 36.87,91.69 39.79,90.48 41.66,89.24 43.23,87.66 43.23,87.01 43.97,86.27 47.48,86.27 49.84,83.91 52.38,83.91 56.69,79.59 56.69,71.88 55.98,71.17 55.98,70.18 59.31,66.85 59.31,56.92 58.95,56.57 58.95,47.57 v2(57,45.61) ; v2(94.95,32.16) 98.88,32.16 100.77,30.27 v2(101.88,30.27)
  BOTTOM w0.508: v2(94.95,32.16) v3(82.54,32.16) 78.84,32.16 78.35,32.64 77.6,32.64 74.83,29.87 66.58,29.87 64.42,32.03 64.42,33.95 61.74,36.63 61.74,40.33 61.3,40.78 61.3,42.15 57.83,45.61 v2(57,45.61) ; v2(33.22,142.97) 32.46,142.97 30.51,144.91 26.31,144.91 20.86,139.46 20.86,134.82 20.45,134.42 20.45,131.26 22.13,129.58 22.13,123.15 v2(18.2,119.22)
  vias: v2(100,26.37) v2(99.98,25.65) v2(100.63,26.34) v2(100.62,25.63) v2(101.3,26.38) v2(101.29,25.67) v2(101.36,31.06) v2(101.88,29.47) v2(101.88,28.67) v2(101.86,27.9) v2(101.86,27.19) v2(101.99,31.03) v2(102.02,26.39) v2(102,25.68) v2(102.64,30.27) v2(102.64,29.47) v2(102.64,28.67) v2(102.63,27.9) v2(102.63,27.19) v2(102.66,31.08) v2(102.78,26.39) v2(102.76,25.68) v2(103.38,31.08) v2(103.48,30.3) v2(103.5,29.59) v2(103.53,28.85) v2(103.53,28.05) v2(103.51,27.27) v2(103.51,26.47) v2(103.49,25.76) v2(203.21,8.86) v2(203.21,8.22) v2(203.21,7.59) v2(203.21,6.95) v2(203.21,6.32) v2(203.21,5.68) v2(203.21,5.05) v2(203.21,4.41) v2(203.2,3.75) v2(203.2,3.12) v2(203.85,8.86) v2(203.85,8.22) v2(203.85,7.59) v2(203.85,6.95) v2(203.85,6.32) v2(203.85,5.68) v2(203.85,5.05) v2(203.85,4.41) v2(203.83,3.75) v2(203.83,3.12) v2(204.52,8.89) v2(204.52,8.22) v2(204.53,4.67) v2(204.51,3.79) v2(204.51,3.15) v2(205.14,3.79) v2(205.14,3.15) v2(205.16,8.89) v2(205.16,8.22) v2(205.16,4.67) v2(205.87,8.85) v2(205.87,8.21) v2(205.87,7.58) v2(205.87,6.94) v2(205.87,6.31) v2(205.87,5.67) v2(205.87,5.04) v2(205.87,4.4) v2(205.85,3.74) v2(205.85,3.1)
VCCIO_PLD_1_5: length 24.8
  TOP w0.112: v2(19.95,57.15) 20.47,57.67 v1(20.47,57.83) ; R3922.2 v1(24.96,56.37)
  TOP w0.508: C1198.1 18.8,52.06 17.95,52.91 v2(17.95,53.15) ; C1193.1 13.2,52.4 v2(13.95,53.15) ; R3922.2 21.74,56.37 C1196.1 21.17,56.37 v2(20.95,56.15) ; C1192.1 17.59,54.79 v2(16.95,54.15) ; v2(14.95,54.15) 15.16,53.94 C1200.1 ; C1201.1 11.35,57.75 v2(11.95,57.15) ; C1199.1 14.2,51.4 v2(13.95,51.15) ; C1194.1 17.81,51.29 v2(17.95,51.15) ; v2(20.95,48.15) 20.95,48.15 C1191.1 ; C1189.1 10.35,47.55 v2(10.95,48.15) ; C1197.1 19.86,57.06 v2(19.95,57.15) ; v2(10.95,56.15) 10.39,56.71 C1195.1
  BOTTOM w0.457: U94.N5 v2(11.95,57.15) ; U94.H10 v2(17.95,51.15) ; U94.J7 v2(13.95,53.15) ; U94.M13 v2(20.95,56.15) ; U94.E4 v2(10.95,48.15) ; U94.E13 v2(20.95,48.15) ; U94.M4 v2(10.95,56.15) ; U94.K8 v2(14.95,54.15) ; U94.J10 v2(17.95,53.15) ; U94.H7 v2(13.95,51.15) ; U94.K9 v2(16.95,54.15) ; U94.N12 v2(19.95,57.15)
  vias: v2(6.1,42.93) v2(6.1,42.24) v2(6.73,42.62) v2(6.78,41.91)
VCCIO_PMOS_1_S:
  vias: v3(1.5,32.56)
VCCIO_PMOS_2_S:
  vias: v3(7.46,32.57)
VDD_P1V8_ZL30281: length 11.4
  TOP w0.254: v2(116.44,38.31) 116.81,38.68 U61.12
  TOP w0.279: U61.13 116.56,38.18 v2(116.44,38.31) 116.36,38.31 115.92,37.87 C972.1 ; U61.17 118.19,35.38 v2(117.5,34.69) C974.1 C973.1
  TOP w0.381: C972.1 114.63,37.87 L13.2
  IN1 w0.381: v2(116.44,38.31) 117.5,37.25 v2(117.5,34.69)
VDD_P3V3_ZL30281: length 7.7
  TOP w0.254: U61.9 117.05,40.18 116,41.22 C964.1 ; U61.16 116.72,36.68 v2(116.23,36.2)
  TOP w0.279: v2(120.53,35.02) 120.69,35.18 U61.22 ; U61.19 119.19,35.34 v2(119.52,35)
  TOP w0.508: C964.1 v2(115.77,41.91)
  BOTTOM w0.457: v2(123.33,36.36) 122.82,36.86 C965.1 ; C967.1 120.54,35.04 v2(120.53,35.02)
  vias: v2(116.28,35.38) v2(120.01,34.45) v2(123.38,35.57)
VDDC_OUTPUT: length 2.6
  TOP w0.254: v6(42.04,42.71) 41.81,42.94 U86.E10 ; v6(38.89,44.79) 38.8,44.79 U86.H16
  BOTTOM w0.112: v3(37.09,42.17) 37.41,42.49 C1126.1
VDDO_1V8: length 3.5
  TOP w0.457: U34.W26 v6(190.59,80.02) ; U34.N26 v6(190.59,87.02) ; U34.AA31 v6(195.59,78.02) ; U34.AA34 v6(198.59,78.02)
  TOP w0.508: U34.V28 v6(192.59,82.02)
  vias: v3(196.12,76.56) v3(200.53,80.91)
AVD_PCIE: length 144
  TOP w0.457: v6(179.59,93.02) U34.G16 v6(180.59,93.02) ; U34.AF21 v6(185.59,73.02) ; v6(196.59,93.02) U34.F33 v6(197.59,94.02) ; v6(196.59,93.02) 196.59,93.02 U34.G33 ; v6(196.59,93.02) U34.G32 195.59,93.02 v6(195.59,93.02) U34.G31 194.59,93.02 v6(194.59,93.02) U34.G30 194.09,92.52 v6(193.59,93.02) U34.G29 193.09,92.52 v6(192.59,93.02) U34.G28 192.09,92.52 v6(191.59,93.02) U34.G27 191.09,92.52 v6(190.59,93.02) U34.G26 v6(189.59,92.02) ; U34.G20 v6(184.59,93.02) ; v6(189.59,67.02) U34.AM25 v6(188.59,68.02) U34.AL24 188.09,68.52 v6(187.59,68.02) U34.AL23 187.09,68.52 v6(186.59,68.02) U34.AL22 186.09,68.52 v6(185.59,68.02) U34.AL21 v6(184.59,69.02) U34.AK20 ; U34.J20 v6(184.59,91.02) ; U34.AL29 v6(192.59,68.02) U34.AL28 192.09,68.52 v6(191.59,68.02) U34.AL27 191.09,68.52 v6(190.59,68.02) U34.AL26 ; U34.AL7 v6(170.59,68.02) ; U34.AL7 v6(170.59,69.02) U34.AK7 v6(170.59,70.02) U34.AJ7 v6(170.59,71.02) U34.AH7 v6(170.59,72.02) U34.AG7 v6(170.59,73.02) U34.AF7 v6(170.59,74.02) U34.AE7 ; U34.AL7 v6(171.59,68.02) ; v6(171.59,93.02) U34.F7 v6(170.59,94.02) ; v6(171.59,93.02) U34.G7 ; v6(171.59,93.02) U34.G8 v6(172.59,93.02) U34.G9 v6(173.59,93.02) U34.G10 v6(174.59,93.02) U34.G11 v6(175.59,93.02) U34.G12 v6(176.59,93.02) U34.G13 v6(177.59,93.02) U34.G14 ; U34.AL32 v6(196.59,68.02) U34.AM33 v6(197.59,68.02) U34.AL33 ; U34.AL18 v6(182.59,68.02) ; U34.AL25 v6(189.59,68.02) 189.59,68.02 U34.AL26 ; U34.AL20 v6(184.59,68.02) ; v6(179.59,94.02) U34.F16 v6(180.59,93.02) ; v6(181.59,68.02) U34.AL17 v6(180.59,68.02) U34.AL16 v6(179.59,68.02) U34.AM16 v6(179.59,67.02) ; v6(170.59,67.02) U34.AM7 v6(171.59,68.02) ; U34.AL30 v6(194.59,68.02) U34.AL31 ; U34.G19 v6(182.59,93.02) U34.G18 v6(181.59,93.02) U34.G17 v6(180.59,93.02) ; U34.G25 v6(189.59,93.02) U34.F25 v6(189.59,94.02) ; U34.G25 188.59,93.02 v6(188.59,93.02) U34.G24 187.59,93.02 v6(187.59,93.02) U34.G23 186.59,93.02 v6(186.59,93.02) U34.G22 185.59,93.02 v6(185.59,93.02) U34.G21 v6(184.59,92.02) U34.H20 ; U34.G25 v6(189.59,92.02) ; v6(189.59,92.02) U34.H25 v6(189.59,91.02) U34.J25 ; v6(186.59,89.02) U34.L22 v6(185.59,88.02) U34.M21 ; U34.G7 v6(170.59,92.02) U34.H7 v6(170.59,91.02) U34.J7 v6(170.59,90.02) U34.K7 v6(170.59,89.02) U34.L7 v6(170.59,88.02) U34.M7 v6(170.59,87.02) U34.N7 ; U34.G7 v6(170.59,93.02) ; U34.AL26 v6(189.59,69.02) U34.AK25 ; v6(171.59,68.02) U34.AL8 v6(172.59,68.02) U34.AL9 v6(173.59,68.02) U34.AL10 174.59,68.02 v6(174.59,68.02) U34.AL11 175.59,68.02 v6(175.59,68.02) U34.AL12 176.59,68.02 v6(176.59,68.02) U34.AL13 177.59,68.02 v6(177.59,68.02) U34.AL14 ; U34.AJ25 v6(189.59,70.02) ; U34.AF13 v6(176.59,73.02) ; U34.AJ20 v6(184.59,70.02) ; U34.AC26 v6(190.59,76.02) ; U34.M13 v6(176.59,88.02)
  TOP w0.508: U34.AL19 v6(182.59,68.02) ; U34.AL18 v6(181.59,68.02)
  BOTTOM w0.305: v6(186.59,68.02) 186.54,68.07 C691.1 ; v6(170.59,87.02) 171.05,87.48 C730.1 ; C674.1 190.6,93.03 v6(190.59,93.02) ; v6(184.59,70.02) 184.52,69.95 C683.1 ; v6(192.59,93.02) 192.59,93.75 C671.1 ; v6(174.59,93.02) 175.13,92.48 C749.1 ; v6(176.59,73.02) 176.84,72.77 C678.1 ; v6(191.59,93.02) 191.27,92.7 C676.1 ; C665.1 188.04,92.47 v6(188.59,93.02) ; C682.1 170.71,72.89 v6(170.59,73.02) ; v6(170.59,90.02) 171.31,90.74 C677.1 ; C728.1 171.28,89.71 v6(170.59,89.02) ; C724.1 173.15,68.46 v6(173.59,68.02) ; v6(176.59,88.02) 177.04,87.56 C681.1 ; v6(184.59,92.02) 184.11,91.54 C668.1 ; v6(190.59,68.02) 190.32,68.29 C687.1 ; v6(194.59,93.02) 194.59,93.02 C672.1 ; C717.1 192.83,68.26 v6(192.59,68.02) ; C666.1 193.32,92.75 v6(193.59,93.02) ; C680.1 C675.1 185.32,72.75 v6(185.59,73.02) ; C670.1 196.68,93.11 v6(196.59,93.02) ; C669.1 184.07,90.5 v6(184.59,91.02) ; C667.1 184.38,93.22 v6(184.59,93.02) ; C684.1 170.8,73.81 v6(170.59,74.02) ; v6(170.59,72.02) 170.63,71.98 C662.1 ; C664.1 170.72,70.15 v6(170.59,70.02) ; C722.1 175.29,68.32 v6(175.59,68.02) ; C690.1 187.48,68.13 v6(187.59,68.02) ; C752.1 186.97,92.64 v6(186.59,93.02) ; v6(188.59,68.02) 188.42,68.19 C689.1 ; C720.1 176.33,68.28 v6(176.59,68.02) ; C679.1 184.35,67.78 v6(184.59,68.02) ; C719.1 177.34,68.27 v6(177.59,68.02) ; C732.1 190.25,90.36 v6(189.59,91.02) ; v6(170.59,71.02) 170.64,71.07 C663.1 ; C718.1 194.75,68.18 v6(194.59,68.02) ; C723.1 174.22,68.39 v6(174.59,68.02) ; C751.1 177.11,92.54 v6(177.59,93.02) ; C685.1 170.81,69.24 v6(170.59,69.02) ; C715.1 184.58,69.01 v6(184.59,69.02) ; v6(195.59,93.02) 194.95,92.38 C721.1 ; v6(170.59,88.02) 171.14,88.57 C729.1 ; C750.1 173.02,92.58 v6(172.59,93.02) ; v6(185.59,68.02) 185.6,68.03 C692.1 ; C716.1 196.4,68.21 v6(196.59,68.02)
  BOTTOM w0.381: v6(196.59,93.02) 197.26,92.35 C673.1
  vias: v2(177.88,45.43) v2(178.44,45.08) v2(178.51,45.71) v2(179.15,45.69) v2(179.12,45.05) v2(179.85,45.67) v2(179.8,45.03) v2(179.88,46.95) v2(179.86,46.31) v2(180.5,47.36) v2(180.52,46.71) v2(180.5,46.07) v2(180.49,45.17) v2(180.96,45.63) v2(181.11,47.62) v2(181.15,46.97) v2(181.16,46.33) v2(181.73,47.82) v2(181.76,47.16) v2(181.78,46.52) v3(153.85,89.08) v3(155.93,71.93) v3(172.17,63.17) v3(177.3,62.66) v3(182.9,62.88)
AVD_PCIE_Q: length 13.8
  TOP w0.457: U34.L13 v6(176.59,89.02) ; U34.V25 v6(189.59,82.02) ; U34.AG20 v6(184.59,72.02) ; U34.L20 v6(184.59,89.02) ; U34.AG13 v6(176.59,72.02)
  BOTTOM w0.112: v3(175.09,72.52) 176.09,72.52 v6(176.59,72.02)
  BOTTOM w0.279: C661.1 189.81,81.79 v6(189.59,82.02) 188.99,81.42 C652.1 ; C658.1 183.88,71.31 v6(184.59,72.02) 184.42,72.19 C651.1
  BOTTOM w0.305: C657.1 184.12,88.55 v6(184.59,89.02) 184.12,89.49 C653.1 ; v6(176.59,89.02) 176.32,89.29 C656.1 C659.1 ; C660.1 C654.1 176.32,71.75 v6(176.59,72.02)
  vias: v2(200.51,91.98) v2(200.67,92.69) v2(201.15,92.12) v2(201.3,92.74)
AVD_PCIE_TX: length 41.7
  TOP w0.457: U34.U7 v6(170.59,83.02) ; U34.AA11 v6(174.59,78.02) ; U34.R7 v6(170.59,85.02) ; U34.AB8 v6(171.59,77.02) ; U34.AD10 v6(173.59,75.02) ; U34.V10 v6(173.59,82.02) ; U34.T10 v6(173.59,84.02) U34.R9 ; U34.AC9 v6(172.59,76.02) ; U34.Y8 v6(171.59,79.02) ; U34.V8 v6(171.59,82.02) ; U34.AC11 v6(174.59,76.02) ; U34.W11 v6(174.59,80.02) ; U34.AB10 v6(173.59,77.02) ; U34.P10 v6(173.59,86.02) ; U34.W9 v6(172.59,80.02) ; U34.AA9 v6(172.59,78.02) ; U34.AA7 v6(170.59,78.02) ; U34.AC7 v6(170.59,76.02) ; U34.U9 v6(172.59,83.02) ; U34.T8 v6(171.59,84.02) ; U34.W7 v6(170.59,80.02) ; U34.AD8 v6(171.59,75.02) ; U34.Y10 v6(173.59,79.02) ; U34.U11 v6(174.59,83.02) ; U34.P8 v6(171.59,86.02) ; U34.R11 v6(174.59,85.02)
  BOTTOM w0.305: C633.1 171.32,75.29 v6(171.59,75.02) ; C642.1 175.16,80.59 v6(174.59,80.02) ; C620.1 172.08,84.51 v6(171.59,84.02) ; C619.1 174.04,76.56 v6(173.59,77.02) ; C644.1 171.32,77.29 v6(171.59,77.02) ; C636.1 174.32,84.75 v6(174.59,85.02) ; C638.1 174.04,74.57 v6(173.59,75.02) ; C626.1 172.13,81.48 v6(171.59,82.02) ; C630.1 173.15,80.58 v6(172.59,80.02) ; v6(173.59,86.02) 172.99,85.42 C634.1 ; C639.1 171.32,78.75 v6(171.59,79.02) ; C632.1 171.93,86.36 v6(171.59,86.02) ; C627.1 171.06,76.49 v6(170.59,76.02) ; C618.1 174.04,83.56 v6(173.59,84.02) ; C631.1 170.32,84.75 v6(170.59,85.02) 170.32,85.29 C635.1 C628.1 ; v6(174.59,78.02) 174.32,77.75 C641.1 ; v6(174.59,76.02) 174.32,75.75 C643.1 ; C621.1 170.32,83.29 v6(170.59,83.02) ; v6(173.59,82.02) 174.17,81.44 C637.1 ; C625.1 172.93,83.36 v6(172.59,83.02) ; C629.1 171.12,80.55 v6(170.59,80.02) 170.16,80.45 C623.1 C622.1 C624.1 167.27,80.74 C640.1
  vias: v2(173,41.76) v2(173.64,42.4) v2(173.64,41.76) v2(174.19,43.05) v2(174.27,42.4) v2(174.27,41.76) v2(174.85,43.1) v2(174.91,42.4) v2(174.91,41.76) v2(175.54,43.03) v2(175.54,42.4) v2(175.54,41.76) v3(165.29,78.29) v3(165.42,83.58) v3(165.42,75.09)
BIC_BOARD_ID_0: length 12.2
  TOP w0.089: U86.B14 39.14,41.13 39.14,39.7
  TOP w0.112: R4341.2 36.29,33.54 35.9,33.54 R4338.1 35.28,33.23 35.14,33.36 35.14,36.43 35.91,37.2 v2(36.38,37.2) 36.38,37.4 37.56,38.58 38.11,38.58 39.14,39.61 39.14,39.7
BIC_BOARD_ID_1: length 6.4
  TOP w0.112: R4339.1 R4342.2 37.63,37.08 37.63,37.47 v1(38.12,37.96) 38.4,38.24 38.4,38.46 39.45,39.51 U86.A14
BIC_BOARD_ID_2: length 8.4
  TOP w0.089: 41.99,51.81 42.05,51.75 42.05,50.25 42.24,50.06 42.24,49.73 U86.V9
  TOP w0.112: R4340.1 40.5,55.59 40.5,54.33 40.67,54.16 R4343.2 41.1,53.52 40.95,53.38 v1(40.95,52.93) 41.19,52.93 41.99,52.13 41.99,51.81
BIC_REMOTE_DEBUG_SELECT_N: length 203.2
  TOP w0.112: v2(103.63,139.52) 103.63,137.97 103.81,137.79 R4287.1 ; v2(47.09,57.09) 46.17,56.17 46.17,52.59 46.86,51.89 46.86,49.41 46.46,49 45.51,49 U86.U2
  IN1 w0.122: v2(103.63,139.52) 103.63,138.97 102.97,138.31 97.31,138.31 95.59,140.03 92.14,140.03 91.66,140.51 51.29,140.51 48.76,143.04 44.85,143.04 42.29,140.48 26.36,140.48 20.23,134.35 20.23,132.05 21.01,131.27 21.01,126.14 20.22,122.18 17.33,119.29 17.33,109.93 18.59,108.67 v2(18.59,106.65)
  IN2 w0.122: v2(47.09,57.09) 48.04,57.09 48.14,57.19 48.14,58.39 49.1,59.36 49.1,64.17 49.65,64.72 49.65,71.16 48.59,72.22 48.59,74.89 43.61,79.88 43.61,80.15 41.36,82.4 40.94,82.4 39.01,84.32 38.14,84.32 37.06,85.41 37.06,86.81 33.49,90.37 33.06,90.37 32.05,91.38 32.05,94.4 28.44,98.02 28.44,98.33 26.47,100.29 26.47,100.77 20.59,106.65 v2(18.59,106.65)
  BOTTOM w0.112: SW5.B 102.33,142.91 103.63,141.61 v2(103.63,139.52)
BMC_BYPASS_SELECT_N: length 72.2
  TOP w0.112: v2(23.72,17.48) 23.72,17.16 15.65,9.09 R4048.2 4.49,7.46 J59.2 ; v2(35.42,47.84) 35.61,48.03 36.86,48.03 U86.P18
  IN1 w0.122: v2(24.92,46.92) 29.75,46.92 30,47.17 31.7,47.17 32.79,46.09 33.21,46.09 34.97,47.84 v2(35.42,47.84)
  IN2 w0.122: v2(23.72,17.48) 24.06,17.82 24.06,22.02 25.45,23.41 25.45,24.6 25.16,24.89 25.16,29.02 23.66,30.51 23.66,34.53 22.85,35.34 22.85,38.64 23.24,39.03 23.24,44.25 23.72,44.74 23.72,46.58 24.07,46.92 v2(24.92,46.92)
BMC_HARTBEAT_LED_R_N: length 5.9
  TOP w0.112: v2(40.18,53.5) 40.03,53.64 R3802.2 ; U86.T13 v6(39.95,48.95)
  BOTTOM w0.112: v2(40.18,53.5) 40.01,53.33 v3(40.01,52.72) 39.95,52.66 v6(39.95,48.95)
BMC_HEARTBEAT_LED_N: length 5
  TOP w0.112: v1(39.44,59.75) 39.61,59.58 D17.C 39.61,55.97 40.03,55.55 R3802.1
BOOT_RECOVERYB: length 24.7
  TOP w0.112: J46.1 208.51,54.51 208.51,55.84 207.52,56.83 R3259.1 206.18,60.27 206.18,62.81 205.4,64.68 203.81,66.27 v2(203.81,68.3) ; U34.AH33 v2(197.59,71.02)
  IN1 w0.122: v2(197.59,71.02) 197.59,70.92 197.99,70.52 201.75,70.52 202.34,69.93 202.34,69.46 203.5,68.3 v2(203.81,68.3)
CARD_TYPE_DETECTION: length 11.2
  TOP w0.112: R3051.2 R3052.1 67.68,11.68 v4(66.9,10.9)
  BOTTOM w0.112: v4(66.9,10.9) J41.33
CLK_25M_MINIBMC_CLKIN: length 2.7
  TOP w0.112: OSC1.3 30.57,39.74 30.57,40.04 30.92,40.39 31.4,40.39 R3764.1
CLK_25M_MINIBMC_CLKIN_R: length 5.2
  TOP w0.112: R3764.2 33.24,40.87 33.32,40.8 v1(33.91,40.8) 34.14,40.8 35.18,41.84 35.92,41.84 36.95,42.87 U86.E19
CLK_100M_DB1200_M2A_DN: length 4.9
  TOP w0.124: U47.18 59.05,64.53 58.95,64.62 58.21,64.62 56.29,65.42 55.47,65.42 R3188.1
CLK_100M_DB1200_M2A_DP: length 4.9
  TOP w0.124: R3187.1 55.47,65.72 56.35,65.72 58.27,64.93 58.95,64.93 59.05,65.03 U47.17
CLK_100M_DB1200_M2A_R_DN: length 96.6
  TOP w0.124: v2(28.88,100.84) 29.24,100.84 29.36,100.71 29.36,100.34 29.58,100.02 29.95,99.86 31.17,99.86 31.85,99.41 33.35,95.79 33.35,92.8 34.12,92.02 40.17,92.02 42.89,90.9 45.7,89.02 46.21,88.51 46.21,85.93 48.37,83.77 53.55,83.77 54.24,83.49 54.68,83.05 55.16,82.33 55.16,75.73 55.58,74.71 55.58,72.65 55.38,72.15 55.16,71.94 55.16,71.72 50.8,67.36 50.52,66.69 50.52,65.88 50.98,65.42 52.35,65.42 R3578.1 53.31,65.42 53.7,65.42 R3188.2 ; v2(32.77,131.33) 33.12,131.68 33.12,131.78 32.54,132.37 32.54,132.63 32.43,132.74 J4.B53
  IN1 w0.136: v2(32.77,131.33) 33.13,130.96 33.13,130.74 31.3,128.9 30.48,126.94 30.48,122.67 32.14,118.67 32.14,115.31 32.49,114.97 32.49,109.03 29.38,101.5 29.38,100.97 29.25,100.84 v2(28.88,100.84)
CLK_100M_DB1200_M2A_R_DP: length 96.6
  TOP w0.124: J4.B55 32.93,132.73 32.84,132.64 32.84,132.5 33.43,131.91 33.43,131.68 v2(33.78,131.33) ; v2(30.15,100.84) 29.79,100.84 29.67,100.71 29.67,100.43 29.78,100.26 30.01,100.16 31.27,100.16 32.1,99.61 33.66,95.85 33.66,92.92 34.25,92.33 40.23,92.33 43.04,91.17 45.9,89.26 46.51,88.64 46.51,86.06 48.5,84.08 53.61,84.08 54.41,83.75 54.92,83.24 55.47,82.42 55.47,75.79 55.89,74.77 55.89,72.58 55.64,71.98 55.47,71.81 55.47,71.6 54.59,70.72 54.59,70.5 54.33,70.23 54.1,70.23 53.84,69.97 53.84,69.74 53.58,69.48 53.35,69.48 53.08,69.21 53.08,68.99 52.82,68.72 52.59,68.72 52.33,68.46 52.33,68.23 52.07,67.97 51.84,67.97 51.06,67.18 50.83,66.63 50.83,66.01 51.11,65.72 52.35,65.72 R3577.1 53.31,65.72 53.7,65.72 R3187.2
  IN1 w0.136: v2(30.15,100.84) 29.78,100.84 29.65,100.97 29.65,101.45 32.77,108.97 32.77,115.08 32.42,115.43 32.42,118.72 30.76,122.73 30.76,126.89 31.53,128.74 33.41,130.62 33.41,130.96 v2(33.78,131.33)
CLK_100M_DB1200_M2B_DN: length 4.8
  TOP w0.124: R3190.1 55.47,62.62 58.96,62.62 59.05,62.53 U47.22
CLK_100M_DB1200_M2B_DP: length 4.8
  TOP w0.124: U47.21 59.04,63.03 58.95,62.93 55.47,62.93 R3189.1
CLK_100M_DB1200_M2B_R_DN: length 93.9
  TOP w0.124: v2(56.2,129.11) 56.55,129.47 56.55,130.64 56.53,131.21 56.53,132.6 56.43,132.7 J4.A53 ; R3190.2 53.7,62.62 53.31,62.62 R3580.1 52.35,62.62 51.05,62.62 50.65,62.89 49.5,65.66 49.5,66.88 50.04,68.18 54.56,72.7 54.62,72.84 54.62,74.52 54.12,75.72 54.12,81.95 53.64,82.67 53.44,82.76 47.32,82.76 44.59,85.49 44.59,87.61 44.47,87.74 v2(44.11,87.74)
  IN1 w0.136: v2(44.11,87.74) 44.4,87.74 44.52,87.86 44.52,88.08 52.84,96.4 56.57,97.94 60.34,101.71 60.34,110.25 58.74,115.5 58.74,122.24 57.19,125.98 57,126.97 56.57,128.01 56.57,128.74 v2(56.2,129.11)
CLK_100M_DB1200_M2B_R_DP: length 94.1
  TOP w0.124: J4.A55 56.93,132.7 56.83,132.6 56.83,131.22 56.86,130.65 56.86,129.46 v2(57.21,129.11) ; v2(45.38,87.74) 45.05,87.74 44.9,87.58 44.9,86.73 45.07,86.56 45.07,86.18 44.9,86 44.9,85.61 45.16,85.35 45.41,85.35 45.68,85.08 45.68,84.83 45.94,84.57 46.19,84.57 46.46,84.3 46.46,84.05 47.44,83.06 53.5,83.06 53.84,82.92 54.43,82.04 54.43,75.78 54.93,74.58 54.93,72.78 54.82,72.53 50.3,68 49.81,66.82 49.81,65.72 50.9,63.09 51.14,62.93 52.35,62.93 R3579.1 53.31,62.93 53.7,62.93 R3189.2
  IN1 w0.136: v2(57.21,129.11) 56.85,128.74 56.85,128.07 57.27,127.05 57.46,126.06 57.46,126.06 59.02,122.3 59.02,115.54 60.61,110.29 60.61,101.59 56.72,97.7 53,96.16 44.8,87.96 44.8,87.8 44.87,87.74 v2(45.38,87.74)
CLK_100M_DB1200_M2C_DN: length 4.9
  TOP w0.124: R3192.1 55.47,59.83 56.43,59.83 56.71,60.12 58.96,60.12 59.05,60.03 U47.27
