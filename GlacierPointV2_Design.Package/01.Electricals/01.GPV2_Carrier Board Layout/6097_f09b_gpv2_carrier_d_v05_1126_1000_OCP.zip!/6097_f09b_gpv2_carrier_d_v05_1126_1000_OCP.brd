# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P3E_PESW_M2E_RX0_DP: length 78.6
  TOP w0.124: v2(126.19,127.25) 125.83,127.61 125.83,132.6 125.93,132.7 J38.B43 ; U34.D11 v6(174.59,96.02)
  IN2 w0.099: 174.23,98.64 174.23,98.61 174.19,98.57 174.19,95.71 174.29,95.61 174.49,95.61 174.59,95.71 v6(174.59,96.02)
  IN2 w0.136: 174.23,98.64 174.23,99.35 173.66,100.73 172.4,101.99 169.84,103.2 156.29,104.53 152.77,105.23 152.67,105.38 152.77,105.86 152.54,106.2 151.69,106.37 151.35,106.14 151.25,105.66 151.1,105.56 148.78,106.03 147.41,106.59 147.22,106.67 146.6,106.93 146.22,107.09 146.22,107.09 145.36,107.44 143.15,107.44 142.89,107.18 141.78,107.18 141.48,107.3 139.83,108.95 139.17,110.55 139.17,115.38 138.52,116.95 137.66,117.81 133.08,119.71 133,119.89 132.62,120.05 132.44,119.97 132.07,120.13 131.99,120.31 131.61,120.47 131.43,120.39 130.87,120.62 129.52,120.62 129.38,120.76 128.98,120.76 128.84,120.62 127.17,120.62 126.5,120.9 126.24,121.29 126.24,124.97 125.82,125.99 125.82,126.89 v2(126.19,127.25)
P3E_PESW_M2E_RX1_DN: length 80.6
  TOP w0.124: J38.B29 122.43,132.7 122.53,132.6 122.53,128.17 v2(122.17,127.81) ; U34.F10 v6(173.59,94.02)
  IN2 w0.099: 172.95,98.68 172.95,98.66 172.99,98.62 172.99,94.63 173.21,94.41 173.49,94.41 173.59,94.31 v6(173.59,94.02)
  IN2 w0.136: 172.95,98.68 172.95,99.19 172.56,100.13 171.73,100.96 169.92,101.81 150.81,103.69 143.3,105.19 140.71,106.26 138.83,108.15 137.94,110.28 137.94,115.16 137.48,116.27 136.98,116.77 136.73,116.88 136.43,116.88 135.45,116.47 135.08,116.1 133.43,116.1 132.92,116.44 132.04,118.57 130.12,119.36 127.03,119.36 125.6,119.95 124.98,120.88 124.98,124.71 124.78,125.19 122.87,126.47 122.54,127.09 122.54,127.44 v2(122.17,127.81)
P3E_PESW_M2E_RX1_DP: length 80.6
  TOP w0.124: J38.B31 122.93,132.7 122.83,132.6 122.83,128.17 v2(123.19,127.81) ; U34.E10 v6(173.59,95.02)
  IN2 w0.099: 173.23,98.68 173.23,98.66 173.19,98.62 173.19,94.71 173.29,94.61 173.49,94.61 173.59,94.71 v6(173.59,95.02)
  IN2 w0.136: v2(123.19,127.81) 122.82,127.44 122.82,127.16 123.09,126.66 125,125.38 125.26,124.77 125.26,120.97 125.78,120.18 127.08,119.64 130.18,119.64 132.25,118.78 133.15,116.63 133.51,116.38 134.97,116.38 135.29,116.71 136.38,117.16 136.78,117.16 137.14,117.01 137.72,116.43 138.22,115.21 138.22,110.33 139.06,108.3 140.87,106.5 143.39,105.45 145.77,104.98 145.92,105.08 146.32,105.01 146.43,104.85 146.83,104.77 146.98,104.87 147.38,104.79 147.49,104.64 147.89,104.56 148.04,104.66 148.44,104.58 148.55,104.43 150.85,103.97 170,102.08 171.89,101.19 172.8,100.29 173.23,99.24 173.23,98.68
P3E_PESW_M2E_RX2_DN: length 81.3
  TOP w0.124: v2(119.17,127.76) 119.53,128.12 119.53,132.61 119.43,132.7 J38.B17 ; U34.E9 v6(172.59,95.02)
  IN2 w0.099: 171.95,98.61 171.95,98.58 171.99,98.55 171.99,95.63 172.21,95.41 172.49,95.41 172.59,95.31 v6(172.59,95.02)
  IN2 w0.136: 171.95,98.61 171.95,99.18 171.77,99.6 171.19,100.18 170.36,100.53 159.77,101.73 149.19,100.8 146.89,100.96 146.62,101.27 146.67,102.07 146.56,102.2 145.92,102.25 145.79,102.13 145.73,101.33 145.42,101.06 140.54,101.4 139.62,101.72 138.99,102.14 138.15,103.16 137.1,105.69 135.43,107.73 130.67,110.91 128.53,111.79 127.7,112.63 127.05,114.21 127.05,115.19 125.69,118.46 124.33,119.82 123.97,120.69 123.97,122.12 123.21,123.95 122.04,125.12 120.27,125.86 119.55,126.94 119.55,127.39 v2(119.17,127.76)
P3E_PESW_M2E_RX2_DP: length 81.3
  TOP w0.124: J38.B19 119.93,132.7 119.83,132.6 119.83,128.12 v2(120.19,127.76) ; U34.D9 v6(172.59,96.02)
  IN2 w0.099: v6(172.59,96.02) 172.59,95.71 172.49,95.61 172.29,95.61 172.19,95.71 172.19,98.55 172.23,98.58 172.23,98.61
  IN2 w0.136: 172.23,98.61 172.23,99.24 172.01,99.76 171.35,100.42 170.43,100.8 159.78,102.01 153.79,101.49 153.65,101.61 153.25,101.57 153.12,101.43 152.72,101.39 152.58,101.51 152.17,101.48 152.05,101.33 151.64,101.3 151.5,101.42 151.09,101.38 150.97,101.24 149.19,101.08 147.02,101.23 146.91,101.37 146.96,102.16 146.69,102.47 145.83,102.53 145.52,102.26 145.46,101.47 145.33,101.35 140.6,101.68 139.74,101.97 139.18,102.35 138.39,103.3 137.34,105.84 135.62,107.94 130.81,111.16 128.69,112.03 127.94,112.79 127.32,114.27 127.32,115.24 125.93,118.62 124.57,119.98 124.25,120.75 124.25,122.17 123.45,124.11 122.2,125.36 120.46,126.08 119.83,127.03 119.83,127.4 v2(120.19,127.76)
P3E_PESW_M2E_RX3_DN: length 82.2
  TOP w0.124: v2(116.16,130.13) 116.53,130.5 116.53,132.6 116.43,132.7 J38.B5 ; U34.F8 v6(171.59,94.02)
  IN2 w0.099: 169.75,99.58 169.78,99.58 169.82,99.62 170.35,99.62 170.74,99.46 170.99,99.21 170.99,94.63 171.21,94.41 171.49,94.41 171.59,94.31 v6(171.59,94.02)
  IN2 w0.136: 169.75,99.58 168.73,99.58 158.8,100.71 149.07,99.86 140.3,100.49 139.08,100.91 138.39,101.37 137.1,102.94 136.06,105.45 135.78,105.76 134.95,106.21 134.62,106.32 134.3,106.44 133.65,106.67 127.89,107.82 127.73,107.98 127.6,108.11 126.38,111.06 124.67,112.77 122.78,117.34 122.51,118.69 121.55,120.47 119.69,122.34 117.3,125.91 117.3,127.56 116.54,129.4 116.54,129.75 v2(116.16,130.13)
P3E_PESW_M2E_RX3_DP: length 82.2
  TOP w0.124: v2(117.17,130.13) 116.83,130.48 116.83,132.6 116.93,132.7 J38.B7 ; U34.E8 v6(171.59,95.02)
  IN2 w0.099: v6(171.59,95.02) 171.59,94.71 171.49,94.61 171.29,94.61 171.19,94.71 171.19,99.3 170.85,99.63 170.39,99.82 169.82,99.82 169.78,99.86 169.75,99.86
  IN2 w0.136: 169.75,99.86 168.74,99.86 165.81,100.19 165.69,100.34 165.29,100.39 165.14,100.27 164.74,100.32 164.62,100.46 164.22,100.51 164.07,100.39 163.66,100.44 163.55,100.58 163.14,100.63 163,100.51 162.59,100.56 162.48,100.71 162.07,100.75 161.92,100.63 158.81,100.99 149.07,100.14 140.36,100.77 139.21,101.16 138.58,101.58 137.34,103.09 136.3,105.6 135.96,105.98 135.06,106.46 133.72,106.94 128.03,108.08 127.93,108.17 127.93,108.17 127.83,108.27 127.83,108.27 126.61,111.22 124.9,112.93 123.04,117.42 122.77,118.79 121.78,120.64 119.91,122.51 117.58,126 117.58,127.62 116.82,129.46 116.82,129.78 v2(117.17,130.13)
P3E_PESW_M2E_TX0_C_DN: length 82.6
  TOP w0.124: v2(126.67,131.3) 127.03,131.65 127.03,132.6 126.93,132.7 J38.B47 ; v2(127.49,103.72) 127.86,103.35 127.86,103.03 128.22,102.67 130.42,102.67 133.05,103.76 135.35,103.76 135.81,103.85 140.04,105.6 140.17,105.63 141.54,105.69 142.37,105.61 142.91,105.39 144.23,104.07 146.43,103.16 160.89,103.16 169.58,106.75 171.88,106.75 172.06,106.68 173.77,105.54 174.68,104.63 174.79,104.37 174.79,104.03 C905.2
  IN1 w0.136: v2(127.49,103.72) 127.86,104.09 127.86,106.69 127.64,107.8 127.4,108.59 126.79,110.06 126.79,119.33 125.94,121.37 125.94,124.61 127.04,127.27 127.04,130.93 v2(126.67,131.3)
P3E_PESW_M2E_TX0_C_DP: length 82.6
  TOP w0.124: C904.2 175.09,104.09 175.09,104.43 174.94,104.8 173.97,105.77 172.2,106.95 171.94,107.06 169.52,107.06 160.83,103.46 146.5,103.46 144.4,104.33 143.08,105.64 142.44,105.91 141.54,106 140.13,105.93 139.95,105.89 135.72,104.14 135.32,104.06 132.99,104.06 130.36,102.98 128.35,102.98 128.16,103.16 128.16,103.38 v2(128.5,103.72) ; v2(127.69,131.3) 127.33,131.66 127.33,132.6 127.43,132.7 J38.B49
  IN1 w0.136: v2(127.69,131.3) 127.32,130.93 127.32,127.21 126.22,124.55 126.22,121.43 127.07,119.38 127.07,110.12 127.66,108.69 127.91,107.87 128.14,106.72 128.14,104.09 v2(128.5,103.72)
P3E_PESW_M2E_TX0_DN: length 6.1
  TOP w0.099: U34.B11 175.09,97.78 175,97.87 174.71,97.87 174.49,98.08 174.49,100.54 174.87,101.46 174.87,101.71 174.82,101.76 174.82,101.79
  TOP w0.124: 174.82,101.79 174.82,102.55 C905.1
P3E_PESW_M2E_TX0_DP: length 6.1
  TOP w0.099: 175.12,101.79 175.12,101.76 175.07,101.71 175.07,101.42 174.94,101.1 175,100.97 174.92,100.78 174.79,100.73 174.69,100.5 174.69,99.86 174.79,99.76 174.79,99.56 174.69,99.46 174.69,99.26 174.79,99.16 174.79,98.96 174.69,98.86 174.69,98.17 174.79,98.07 174.99,98.07 175.09,98.17 U34.A11
  TOP w0.124: C904.1 175.12,102.55 175.12,101.79
P3E_PESW_M2E_TX1_C_DN: length 81.3
  TOP w0.124: J38.B35 123.93,132.7 124.04,132.59 124.04,131.78 v2(123.69,131.44) ; C875.2 172.74,104.04 172.74,104.4 172.65,104.6 171.96,105.29 171.31,105.56 169.82,105.56 161.13,101.97 147.43,101.97 142.67,101.01 140.67,101.42 137.49,100.78 134.26,101.43 131.08,100.79 127.52,101.51 126.43,102.84 126.43,104.64 v2(126.07,105)
  IN1 w0.136: v2(123.69,131.44) 124.06,131.07 124.06,129.04 124.01,128.92 123.94,128.74 123.94,127.31 124.99,124.77 124.99,121.23 125.86,119.13 125.86,109.84 125.64,109.29 125.64,108.46 125.69,108.1 126.44,105.62 126.44,105.37 v2(126.07,105)
P3E_PESW_M2E_TX1_C_DP: length 81.3
  TOP w0.124: J38.B37 124.43,132.7 124.34,132.61 124.34,131.8 v2(124.71,131.44) ; C906.2 173.04,104.04 173.04,104.46 172.91,104.78 172.13,105.55 171.37,105.87 169.76,105.87 161.07,102.27 147.4,102.27 142.67,101.33 140.67,101.73 137.49,101.09 134.26,101.74 131.08,101.1 127.69,101.78 126.73,102.95 126.73,104.64 v2(127.09,105)
  IN1 w0.136: v2(124.71,131.44) 124.34,131.07 124.34,128.98 124.22,128.68 124.22,127.37 125.27,124.83 125.27,121.28 126.14,119.18 126.14,109.78 125.92,109.24 125.92,108.48 125.96,108.16 126.72,105.66 126.72,105.37 v2(127.09,105)
P3E_PESW_M2E_TX1_DN: length 7.1
  TOP w0.099: U34.C10 174.09,96.82 173.99,96.92 173.71,96.92 173.49,97.14 173.49,99.69 172.79,101.38 172.79,101.73 172.74,101.78 172.74,101.8
  TOP w0.124: C875.1 172.74,102.53 172.74,101.8
P3E_PESW_M2E_TX1_DP: length 7.1
  TOP w0.099: U34.B10 174.09,97.22 173.99,97.12 173.79,97.12 173.69,97.22 173.69,97.87 173.79,97.97 173.79,98.17 173.69,98.27 173.69,98.47 173.79,98.57 173.79,98.77 173.69,98.87 173.69,99.74 173.61,99.92 173.67,100.05 173.59,100.23 173.46,100.29 173.39,100.47 173.44,100.6 173.36,100.79 173.23,100.84 172.99,101.42 172.99,101.73 173.04,101.78 173.04,101.8
  TOP w0.124: 173.04,101.8 173.04,102.53 C906.1
P3E_PESW_M2E_TX2_C_DN: length 82.4
  TOP w0.124: C877.2 170.67,104.05 170.67,104.27 170.56,104.37 170.06,104.37 161.37,100.77 148.12,100.77 142.95,99.74 140.67,100.2 137.49,99.56 134.32,100.2 131.14,99.56 127.34,100.32 126.61,100.18 125.83,100.18 125.31,100.4 124.99,100.72 124.99,101.07 v2(124.65,101.41) ; v2(120.65,131.62) 121.02,131.99 121.02,132.61 120.93,132.7 J38.B23
  IN1 w0.136: v2(124.65,101.41) 125.03,101.79 125.03,106.7 124.35,110.12 124.35,114.68 124.93,117.61 124.93,118.91 123.94,121.3 123.94,122.46 121.36,126.32 121.01,127.16 121.01,131.25 v2(120.65,131.62)
P3E_PESW_M2E_TX2_C_DP: length 82.4
  TOP w0.124: C876.2 170.97,104.01 170.97,104.4 170.69,104.68 169.99,104.68 161.31,101.08 148.08,101.08 142.95,100.05 140.67,100.51 137.49,99.87 134.32,100.51 131.14,99.87 127.34,100.64 126.58,100.48 125.89,100.48 125.48,100.66 125.29,100.84 125.29,101.04 v2(125.66,101.41) ; v2(121.66,131.62) 121.32,131.96 121.32,132.59 121.43,132.7 J38.B25
  IN1 w0.136: v2(121.66,131.62) 121.29,131.25 121.29,127.21 121.61,126.45 124.22,122.55 124.22,121.35 125.21,118.96 125.21,117.58 124.63,114.65 124.63,110.15 125.3,106.73 125.3,101.77 v2(125.66,101.41)
P3E_PESW_M2E_TX2_DN: length 6.6
  TOP w0.099: 170.64,102.19 170.64,102.16 170.69,102.11 170.69,101.54 172.17,100.06 172.49,99.3 172.49,98.14 172.71,97.92 172.99,97.92 173.09,97.82 U34.B9
  TOP w0.124: 170.64,102.19 170.64,102.52 C877.1
P3E_PESW_M2E_TX2_DP: length 6.6
  TOP w0.099: 170.95,102.19 170.95,102.16 170.9,102.11 170.9,101.62 171.07,101.45 171.22,101.45 171.36,101.31 171.36,101.16 171.5,101.02 171.64,101.02 171.78,100.88 171.78,100.74 171.92,100.6 172.07,100.6 172.21,100.46 172.21,100.32 172.35,100.18 172.44,99.94 172.57,99.89 172.65,99.7 172.6,99.57 172.69,99.34 172.69,98.22 172.79,98.12 172.99,98.12 173.09,98.22 U34.A9
  TOP w0.124: C876.1 170.95,102.52 170.95,102.19
P3E_PESW_M2E_TX3_C_DN: length 73
  TOP w0.124: v2(117.65,131.09) 118.02,131.46 118.02,132.61 117.93,132.69 J38.B11 ; C879.2 159.54,99.58 149.18,99.58 143.38,98.42 140.67,98.97 137.51,98.33 134.33,98.97 131.14,98.33 127.29,99.1 126.41,98.93 125.54,99.01 123.35,99.92 122,101.26 121.22,103.16 120.69,104.43 120.69,105.02 v2(120.35,105.36)
  IN1 w0.136: v2(120.35,105.36) 120.7,105.71 120.7,106.14 120.3,108.16 120.15,108.59 119.97,109.48 119.85,110.43 119.85,110.44 119.78,110.76 119.21,112.14 119.21,125.27 119.05,125.43 119.02,125.43 118.44,126.02 118.01,127.03 118.01,130.72 v2(117.65,131.09)
P3E_PESW_M2E_TX3_C_DP: length 73
  TOP w0.124: v2(118.66,131.09) 118.32,131.43 118.32,132.59 118.43,132.7 J38.B13 ; v2(121.36,105.36) 121,104.99 121,104.49 121.5,103.28 121.68,103.2 121.82,102.86 121.75,102.68 122.26,101.44 123.52,100.18 125.62,99.31 126.4,99.23 127.29,99.41 131.14,98.64 134.33,99.28 137.51,98.64 139.03,98.95 139.03,98.95 140.67,99.28 143.38,98.73 145.2,99.1 145.57,99.17 145.67,99.33 146.04,99.4 146.19,99.3 146.56,99.37 146.66,99.52 147.03,99.6 147.18,99.5 147.55,99.57 147.68,99.78 148.05,99.85 148.26,99.71 149.15,99.89 159.54,99.89 C878.2
  IN1 w0.136: v2(118.66,131.09) 118.29,130.72 118.29,127.09 118.67,126.18 119.14,125.71 119.16,125.71 119.49,125.39 119.49,112.2 120.05,110.84 120.12,110.49 120.12,110.47 120.25,109.52 120.42,108.66 120.57,108.24 120.98,106.17 120.98,105.74 v2(121.36,105.36)
P3E_PESW_M2E_TX3_DN: length 15.3
  TOP w0.099: 170.64,99.76 170.67,99.76 170.72,99.81 170.92,99.81 171.3,99.42 171.49,98.98 171.49,97.14 171.71,96.92 171.99,96.92 172.09,96.82 U34.C8
  TOP w0.124: C879.1 161.05,99.58 164.53,99.58 164.94,99.76 166.67,99.76 166.97,100.06 166.97,100.35 167.1,100.47 167.73,100.47 167.86,100.35 167.86,100.06 168.16,99.76 170.64,99.76
P3E_PESW_M2E_TX3_DP: length 15.2
  TOP w0.099: U34.B8 172.09,97.22 171.99,97.12 171.79,97.12 171.69,97.22 171.69,99.02 171.47,99.54 171,100.01 170.72,100.01 170.67,100.06 170.64,100.06
  TOP w0.124: C878.1 161.05,99.89 164.46,99.89 164.88,100.06 166.54,100.06 166.67,100.19 166.67,100.47 166.97,100.78 167.86,100.78 168.16,100.47 168.16,100.19 168.29,100.06 170.64,100.06
P3E_PESW_M2F_RX0_DN: length 55.8
  TOP w0.124: v2(149.18,129.4) 149.54,129.75 149.54,132.6 149.43,132.71 149.43,133.52 J38.A41 ; U34.E15 v6(178.59,95.02)
  IN2 w0.099: 177.95,98.61 177.95,98.58 177.99,98.54 177.99,95.63 178.21,95.41 178.49,95.41 178.59,95.31 v6(178.59,95.02)
  IN2 w0.136: 177.95,98.61 177.95,99.58 176.73,102.51 174.26,104.99 167.62,109.43 164.6,110.68 163.19,111.62 161.05,113.76 156.28,116.95 149.49,119.76 148.98,120.52 148.98,122.49 149.55,123.87 149.55,129.03 v2(149.18,129.4)
P3E_PESW_M2F_RX0_DP: length 55.8
  TOP w0.124: v2(150.2,129.4) 149.84,129.75 149.84,132.62 149.93,132.71 J38.A43 ; U34.D15 v6(178.59,96.02)
  IN2 w0.099: v6(178.59,96.02) 178.59,95.71 178.49,95.61 178.29,95.61 178.19,95.71 178.19,98.54 178.23,98.58 178.23,98.61
  IN2 w0.136: v2(150.2,129.4) 149.83,129.03 149.83,123.82 149.26,122.44 149.26,120.6 149.67,119.99 156.41,117.2 161.23,113.98 163.37,111.83 164.73,110.93 165.25,110.71 165.42,110.78 165.8,110.63 165.87,110.45 166.25,110.3 166.42,110.37 166.8,110.21 166.87,110.04 167.75,109.68 168.11,109.43 168.29,109.47 168.63,109.24 168.67,109.06 174.43,105.21 176.97,102.67 178.23,99.64 178.23,98.61
P3E_PESW_M2F_RX1_DN: length 57.8
  TOP w0.124: U34.F14 v6(177.59,94.02) ; J38.A29 146.43,132.7 146.53,132.6 146.53,130.17 v2(146.18,129.81)
  IN2 w0.099: v6(177.59,94.02) 177.59,94.31 177.49,94.41 177.21,94.41 176.99,94.63 176.99,98.57 176.95,98.61 176.95,98.63
  IN2 w0.136: 176.95,98.63 176.95,99.49 175.9,102.03 173.98,103.95 167.71,108.14 164.74,109.37 162.56,110.82 160.21,113.18 159.19,113.86 158.16,114.55 156.74,115.13 155.82,116.06 155.05,116.37 151.45,116.37 150.81,116.72 149.5,118.67 149.04,118.86 148.65,119.19 147.6,120.75 147.6,123.67 146.76,125.7 146.76,126.94 146.54,128.29 146.54,129.45 v2(146.18,129.81)
P3E_PESW_M2F_RX1_DP: length 57.8
  TOP w0.124: J38.A31 146.93,132.72 146.83,132.62 146.83,130.17 v2(147.19,129.81) ; U34.E14 v6(177.59,95.02)
  IN2 w0.099: 177.23,98.63 177.23,98.61 177.19,98.57 177.19,94.71 177.29,94.61 177.49,94.61 177.59,94.71 v6(177.59,95.02)
  IN2 w0.136: v2(147.19,129.81) 146.82,129.44 146.82,128.31 147.04,126.96 147.04,125.76 147.27,125.21 147.44,125.14 147.6,124.76 147.53,124.59 147.88,123.73 147.88,120.84 148.85,119.38 149.19,119.11 149.68,118.9 151,116.93 151.52,116.65 155.11,116.65 155.98,116.29 156.9,115.37 158.29,114.79 160.39,113.39 162.74,111.04 164.87,109.62 165.25,109.46 165.42,109.53 165.8,109.38 165.87,109.21 166.24,109.05 166.42,109.12 166.79,108.97 166.87,108.79 167.84,108.39 174.16,104.17 176.14,102.19 177.23,99.55 177.23,98.63
P3E_PESW_M2F_RX2_DN: length 59.8
  TOP w0.124: J38.A17 143.43,132.7 143.53,132.6 143.53,128.17 v2(143.17,127.81) ; U34.E13 v6(176.59,95.02)
  IN2 w0.099: 175.95,98.64 175.95,98.61 175.99,98.57 175.99,95.63 176.21,95.41 176.49,95.41 176.59,95.31 v6(176.59,95.02)
  IN2 w0.136: v2(143.17,127.81) 143.55,127.43 143.55,123.04 144.58,120.55 145.58,119.55 147.31,118.83 147.71,118.44 148.27,117.07 148.46,116.89 149.5,116.45 151.87,114.09 153.67,113.34 153.94,113.45 154.05,113.5 154.31,114.14 154.48,114.21 155.07,113.96 155.14,113.8 154.87,113.16 155.03,112.78 158.28,111.43 161.04,109.59 168.51,106.5 173.36,103.26 175.1,101.51 175.95,99.46 175.95,98.64
P3E_PESW_M2F_RX2_DP: length 59.8
  TOP w0.124: U34.D13 v6(176.59,96.02) ; v2(144.19,127.81) 143.83,128.17 143.83,132.6 143.93,132.7 J38.A19
  IN2 w0.099: 176.23,98.64 176.23,98.61 176.19,98.57 176.19,95.71 176.29,95.61 176.49,95.61 176.59,95.71 v6(176.59,96.02)
  IN2 w0.136: 176.23,98.64 176.23,99.51 175.33,101.67 173.53,103.47 168.64,106.75 164.47,108.47 164.4,108.64 164.03,108.8 163.85,108.73 163.48,108.88 163.41,109.06 163.03,109.21 162.86,109.14 162.48,109.3 162.41,109.47 162.03,109.62 161.86,109.55 161.17,109.84 158.41,111.68 155.24,112.99 155.17,113.16 155.44,113.8 155.28,114.18 154.48,114.51 154.1,114.35 153.84,113.71 153.67,113.64 152.03,114.33 149.66,116.69 149.61,116.71 148.62,117.12 148.51,117.23 147.94,118.6 147.47,119.07 145.74,119.79 144.82,120.71 143.83,123.09 143.83,127.46 v2(144.19,127.81)
P3E_PESW_M2F_RX3_DN: length 59.4
  TOP w0.124: U34.F12 v6(175.59,94.02) ; J38.A5 140.43,132.7 140.53,132.6 140.53,131.14 140.52,130.83 140.52,130.51 140.52,130.35 v2(140.17,130)
  IN2 w0.099: v6(175.59,94.02) 175.59,94.31 175.49,94.41 175.21,94.41 174.99,94.63 174.99,98.54 174.95,98.58 174.95,98.6
  IN2 w0.136: 174.95,98.6 174.95,99.35 174.24,101.06 172.79,102.51 169.58,104.66 160.78,108.3 158.51,109.81 155.97,110.87 153.3,111.68 151.94,112.24 151.38,112.8 146.66,115.95 145.97,116.64 143.66,120.11 142.18,123.67 140.69,128.58 140.55,129.29 140.55,129.62 v2(140.17,130)
P3E_PESW_M2F_RX3_DP: length 59.4
  TOP w0.124: J38.A7 140.93,132.72 140.84,132.63 140.84,131.13 140.82,130.5 140.82,130.36 v2(141.18,130) ; U34.E12 v6(175.59,95.02)
  IN2 w0.099: 175.23,98.6 175.23,98.58 175.19,98.54 175.19,94.71 175.29,94.61 175.49,94.61 175.59,94.71 v6(175.59,95.02)
  IN2 w0.136: v2(141.18,130) 140.83,129.64 140.83,129.32 140.96,128.65 142.44,123.76 143.9,120.24 146.19,116.82 146.84,116.17 150.07,114.01 151.56,113.02 152.09,112.48 153.39,111.94 156.07,111.13 158.65,110.06 160.91,108.55 162.03,108.08 162.21,108.16 162.58,108 162.65,107.83 163.03,107.67 163.2,107.74 163.58,107.59 163.65,107.41 164.03,107.26 164.2,107.33 164.58,107.17 164.65,107 169.71,104.91 172.97,102.73 174.48,101.22 175.23,99.4 175.23,98.6
P3E_PESW_M2F_TX0_C_DN: length 62.4
  TOP w0.124: J38.A47 150.93,132.7 151.03,132.6 151.03,128.14 v2(150.67,127.79) ; C897.2 183.56,104.13 183.56,104.54 183.41,104.88 182.97,105.32 182.72,105.32 182.46,105.59 182.46,105.84 181.83,106.46 181.2,107.98 179.83,109.36 178.56,109.95 178.42,110.36 178.93,111.44 178.87,111.6 178.29,111.88 178.12,111.82 177.61,110.74 177.21,110.59 176.12,111.11 174.29,111.52 168.63,111.52 163.13,109.25 161.49,109.25 161.35,109.11 160.98,109.11 160.84,109.25 160.47,109.25 160.33,109.11 159.96,109.11 159.82,109.25 159.44,109.25 159.31,109.11 158.93,109.11 158.8,109.25 155.68,109.25 v2(155.32,108.89)
  IN1 w0.136: v2(155.32,108.89) 154.95,109.26 154.67,109.26 154.28,109.52 153.83,110.61 153.83,119.62 152.65,122.46 151.36,123.75 151.04,124.53 151.04,127.42 v2(150.67,127.79)
P3E_PESW_M2F_TX0_C_DP: length 62.4
  TOP w0.124: v2(151.69,127.79) 151.33,128.14 151.33,132.6 151.43,132.7 151.43,133.52 J38.A49 ; v2(155.32,109.91) 155.68,109.55 163.07,109.55 168.56,111.82 174.33,111.82 176.22,111.4 177.23,110.92 177.39,110.98 177.9,112.06 178.3,112.21 179.11,111.82 179.26,111.42 178.75,110.34 178.81,110.18 180.01,109.61 181.46,108.15 182.09,106.64 183.67,105.06 183.86,104.6 183.86,104.14 C896.2
  IN1 w0.136: v2(151.69,127.79) 151.32,127.42 151.32,126.77 151.46,126.63 151.46,126.22 151.32,126.08 151.32,125.68 151.46,125.54 151.46,125.13 151.32,124.99 151.32,124.58 151.6,123.91 152,123.5 152.2,123.5 152.49,123.22 152.49,123.02 152.89,122.62 154.11,119.68 154.11,111.76 154.25,111.63 154.25,111.22 154.11,111.08 154.11,110.67 154.51,109.7 154.75,109.54 154.95,109.54 v2(155.32,109.91)
P3E_PESW_M2F_TX0_DN: length 9.8
  TOP w0.099: U34.B15 179.09,97.82 178.99,97.92 178.71,97.92 178.49,98.14 178.49,98.83 179.41,99.76 181.06,99.76 181.11,99.81 181.14,99.81
  TOP w0.124: 181.14,99.81 182.08,99.81 182.89,100.14 183.47,100.72 183.56,100.94 183.56,102.62 C897.1
P3E_PESW_M2F_TX0_DP: length 9.8
  TOP w0.099: 181.14,99.5 181.11,99.5 181.06,99.55 180.86,99.55 180.76,99.45 180.56,99.45 180.46,99.55 180.26,99.55 180.16,99.45 179.97,99.45 179.86,99.55 179.49,99.55 178.69,98.75 178.69,98.22 178.79,98.12 178.99,98.12 179.09,98.22 U34.A15
  TOP w0.124: 181.14,99.5 182.14,99.5 183.06,99.88 183.73,100.55 183.87,100.88 183.87,102.62 C896.1
P3E_PESW_M2F_TX1_C_DN: length 62.8
  TOP w0.124: v2(149.81,108.67) 150.17,108.3 150.17,107.63 150.33,107.25 150.68,106.91 150.88,106.82 151.32,106.78 153.12,107.14 156.52,107.14 157.58,107.58 162.22,107.58 168.86,110.33 174.05,110.33 174.67,110.2 179.06,108.39 180.15,107.3 181.34,104.43 181.34,104.1 C899.2 ; J38.A35 147.93,133.52 147.93,132.7 148.03,132.6 148.03,128.14 v2(147.67,127.79)
  IN1 w0.136: v2(147.67,127.79) 148.04,127.42 148.04,126.83 148.46,125.81 148.83,125.44 149.09,124.83 149.09,120.15 149.72,118.61 149.72,110.62 150.17,109.52 150.17,109.03 v2(149.81,108.67)
P3E_PESW_M2F_TX1_C_DP: length 62.8
  TOP w0.124: v2(148.69,127.79) 148.33,128.14 148.33,132.62 148.43,132.72 J38.A37 ; C898.2 181.64,104.13 181.64,104.49 180.41,107.47 179.23,108.65 174.76,110.5 174.08,110.63 168.8,110.63 162.16,107.88 157.52,107.88 156.46,107.44 153.09,107.44 151.3,107.09 150.96,107.12 150.85,107.16 150.59,107.42 150.48,107.69 150.48,108.32 v2(150.82,108.67)
  IN1 w0.136: v2(148.69,127.79) 148.32,127.42 148.32,126.89 148.7,125.97 149.07,125.6 149.37,124.89 149.37,120.2 150,118.67 150,110.67 150.45,109.58 150.45,109.03 v2(150.82,108.67)
P3E_PESW_M2F_TX1_DN: length 9.5
  TOP w0.099: 180.54,101.09 180.52,101.09 180.47,101.04 179.6,101.04 178.87,100.74 177.65,99.52 177.49,99.13 177.49,97.14 177.71,96.92 177.99,96.92 178.09,96.82 U34.C14
  TOP w0.124: 180.54,101.09 180.92,101.09 180.95,101.13 181,101.13 181.07,101.16 181.27,101.35 181.36,101.57 181.36,102.6 C899.1
P3E_PESW_M2F_TX1_DP: length 9.5
  TOP w0.099: 180.54,100.79 180.52,100.79 180.47,100.84 179.64,100.84 178.99,100.57 177.82,99.4 177.69,99.09 177.69,98.8 177.79,98.7 177.79,98.5 177.69,98.4 177.69,98.2 177.79,98.1 177.79,97.9 177.69,97.8 177.69,97.22 177.79,97.12 177.99,97.12 178.09,97.22 U34.B14
  TOP w0.124: C898.1 181.66,102.6 181.66,101.51 181.52,101.18 181.25,100.9 180.98,100.79 180.54,100.79
P3E_PESW_M2F_TX2_C_DN: length 65.8
  TOP w0.124: v2(144.68,131.65) 145.03,132 145.03,132.6 144.93,132.7 144.93,133.52 J38.A23 ; v2(144.3,108.3) 144.65,107.95 144.65,107.63 144.85,107.33 149.16,105.54 152.3,105.54 154.32,105.94 161.39,105.94 169.1,109.14 173.15,109.14 174.44,108.88 175.94,108.26 178.79,105.41 179.18,104.48 179.18,104.19 C901.2
  IN1 w0.136: v2(144.3,108.3) 144.61,108.62 144.61,109.06 144.03,110.48 144.03,116.55 143.52,119.11 143.52,124.77 143.76,125.35 144.75,126.35 145.06,127.09 145.06,131.27 v2(144.68,131.65)
P3E_PESW_M2F_TX2_C_DP: length 65.7
  TOP w0.124: J38.A25 145.43,132.71 145.34,132.62 145.34,132 v2(145.7,131.65) ; v2(145.31,108.3) 144.95,107.94 144.95,107.72 145.05,107.57 149.22,105.85 152.27,105.85 154.29,106.25 161.33,106.25 169.04,109.44 173.18,109.44 174.53,109.18 176.11,108.52 179.05,105.58 179.48,104.54 179.48,104.08 C900.2
  IN1 w0.136: v2(145.31,108.3) 144.89,108.72 144.89,109.11 144.58,109.88 144.58,109.88 144.31,110.54 144.31,116.58 143.8,119.14 143.8,124.72 143.89,124.95 143.99,125.19 143.99,125.19 144.99,126.19 145.34,127.04 145.34,131.29 v2(145.7,131.65)
P3E_PESW_M2F_TX2_DN: length 7.1
  TOP w0.099: U34.B13 177.09,97.82 176.99,97.92 176.71,97.92 176.49,98.14 176.49,99.24 176.78,99.93 178.98,102.14 178.98,102.21 179,102.23
  TOP w0.124: C901.1 179.13,102.62 179.13,102.36 179,102.23
P3E_PESW_M2F_TX2_DP: length 7.1
  TOP w0.099: 179.21,102.01 179.2,101.99 179.12,101.99 178.34,101.21 178.34,101.07 178.2,100.93 178.06,100.93 177.92,100.79 177.92,100.64 177.78,100.5 177.63,100.5 177.49,100.36 177.49,100.22 177.35,100.08 177.21,100.08 176.95,99.82 176.69,99.2 176.69,98.22 176.79,98.12 176.99,98.12 177.09,98.22 U34.A13
  TOP w0.124: 179.21,102.01 179.43,102.23 179.43,102.63 C900.1
P3E_PESW_M2F_TX3_C_DN: length 65.5
  TOP w0.124: v2(144.04,106.42) 144.4,106.07 144.4,105.82 144.87,105.11 146.71,104.35 160.65,104.35 169.34,107.95 173.02,107.95 173.63,107.82 175.41,107.09 176.21,106.29 176.89,104.65 176.89,104.08 C903.2 ; v2(141.67,131.4) 142.03,131.75 142.03,132.6 141.93,132.7 J38.A11
  IN1 w0.136: v2(144.04,106.42) 144.41,106.79 144.41,107.02 144.22,107.21 143.92,107.21 143.36,107.76 143.24,108.06 143.24,109.4 143.05,109.86 143.05,116.59 142.51,119.26 142.51,125.3 142.04,127.68 142.04,131.03 v2(141.67,131.4)
P3E_PESW_M2F_TX3_C_DP: length 65.5
  TOP w0.124: v2(142.69,131.4) 142.33,131.75 142.33,132.59 142.43,132.69 J38.A13 ; v2(145.06,106.42) 144.7,106.07 144.7,105.91 145.07,105.36 145.92,105.01 146.78,104.65 160.59,104.65 169.28,108.25 173.05,108.25 173.72,108.12 175.58,107.35 176.47,106.46 177.19,104.71 177.19,104.1 C902.2
  IN1 w0.136: v2(145.06,106.42) 144.69,106.79 144.69,107.13 144.34,107.48 144.03,107.48 143.6,107.92 143.52,108.12 143.52,109.45 143.32,109.92 143.32,116.62 142.79,119.29 142.79,125.32 142.32,127.7 142.32,131.03 v2(142.69,131.4)
P3E_PESW_M2F_TX3_DN: length 7.7
  TOP w0.099: 176.02,101.43 176.02,101.4 176.08,101.35 176.08,101.04 175.49,99.62 175.49,97.14 175.71,96.92 175.99,96.92 176.09,96.82 U34.C12
  TOP w0.124: 176.02,101.43 176.02,101.85 176.4,102.22 176.77,102.22 176.89,102.35 176.89,102.58 C903.1
P3E_PESW_M2F_TX3_DP: length 7.7
  TOP w0.099: 176.33,101.43 176.33,101.4 176.28,101.35 176.28,101 176.16,100.71 176.21,100.58 176.14,100.39 176,100.34 175.93,100.16 175.98,100.02 175.91,99.84 175.78,99.78 175.69,99.58 175.69,98.92 175.79,98.82 175.79,98.62 175.69,98.52 175.69,98.32 175.79,98.22 175.79,98.02 175.69,97.92 175.69,97.22 175.79,97.12 175.99,97.12 176.09,97.22 U34.B12
  TOP w0.124: C902.1 177.2,102.58 177.2,102.22 176.89,101.92 176.53,101.92 176.33,101.72 176.33,101.43
P3E_PESW_M2G_RX0_DN: length 62.6
  TOP w0.124: U34.E21 v6(185.59,95.02)
  IN2 w0.099: v6(185.59,95.02) 185.59,94.71 185.49,94.61 185.29,94.61 185.19,94.71 185.19,99.51 185.23,99.55 185.23,99.57
  IN2 w0.136: 185.23,99.57 185.23,99.81 180.79,110.52 176.67,114.64 174.61,119.61 174.49,120.24 174.59,120.39 174.51,120.79 174.35,120.9 174.27,121.3 174.38,121.45 174.3,121.85 174.14,121.96 174.06,122.36 174.17,122.51 174.09,122.91 173.93,123.02 173.76,123.88 173.76,126.89 173.5,128.21 172.84,128.86 170.65,128.86 169.76,128.5 169.01,128.5 167.94,129.57 166.79,132.32 165.7,133.41 162.41,134.78 161.24,134.78 159.23,136.79 158.02,136.79 157.58,137.22 157.58,137.73 v2(157.95,138.09)
  BOTTOM w0.124: J8.B41 157.67,140.05 157.57,139.95 157.57,138.47 v2(157.95,138.09)
P3E_PESW_M2G_RX0_DP: length 62.6
  TOP w0.124: U34.F21 v6(185.59,94.02)
  IN2 w0.099: v6(185.59,94.02) 185.59,94.31 185.49,94.41 185.21,94.41 184.99,94.63 184.99,99.51 184.95,99.55 184.95,99.57
  IN2 w0.136: 184.95,99.57 184.95,99.75 180.56,110.36 176.43,114.49 175.38,117.02 174.34,119.53 173.48,123.85 173.48,126.86 173.24,128.07 172.73,128.58 170.7,128.58 169.82,128.22 168.89,128.22 167.7,129.41 166.56,132.16 165.54,133.18 162.35,134.5 161.13,134.5 159.12,136.51 157.9,136.51 157.3,137.11 157.3,137.73 v2(156.94,138.09)
  BOTTOM w0.124: J8.B43 157.17,140.06 157.27,139.96 157.27,138.42 v2(156.94,138.09)
P3E_PESW_M2G_RX1_DN: length 62.2
  TOP w0.124: U34.D22 v6(186.59,96.02)
  IN2 w0.099: 186.23,99.57 186.23,99.55 186.19,99.51 186.19,95.71 186.29,95.61 186.49,95.61 186.59,95.71 v6(186.59,96.02)
  IN2 w0.136: v2(160.86,138.1) 160.49,137.73 160.49,136.98 161.62,135.84 162.33,135.84 166.38,134.16 168.23,132.32 168.85,132.06 169.18,131.73 172.19,130.49 174.02,130.49 174.31,130.25 175.82,122.68 175.97,122.58 176.05,122.18 175.95,122.03 176.03,121.63 176.19,121.52 176.26,121.12 176.16,120.97 176.24,120.57 176.4,120.46 176.48,120.06 176.37,119.91 176.61,118.69 176.76,118.59 177.26,118.68 177.6,118.46 177.77,117.61 177.54,117.26 177.05,117.16 176.95,117.02 177.06,116.47 177.69,114.94 179.42,113.21 179.61,113.21 179.99,113.6 180.42,113.6 181.02,112.99 181.02,112.56 180.64,112.18 180.64,111.99 181.65,110.98 186.23,99.92 186.23,99.57
  BOTTOM w0.124: J8.B29 160.67,140.07 160.57,139.97 160.57,139.57 160.49,139.38 160.49,138.47 v2(160.86,138.1)
P3E_PESW_M2G_RX1_DP: length 62.2
  TOP w0.124: U34.E22 v6(186.59,95.02)
  IN2 w0.099: v6(186.59,95.02) 186.59,95.31 186.49,95.41 186.21,95.41 185.99,95.63 185.99,99.51 185.95,99.55 185.95,99.57
  IN2 w0.136: v2(159.84,138.1) 160.21,137.73 160.21,136.86 161.51,135.56 162.28,135.56 166.22,133.93 168.07,132.08 168.7,131.82 169.02,131.49 172.13,130.21 173.92,130.21 174.06,130.1 175.57,122.52 176.36,118.52 176.7,118.29 177.2,118.39 177.35,118.29 177.47,117.66 177.37,117.52 176.88,117.42 176.65,117.07 176.79,116.39 177.45,114.78 179.3,112.93 179.72,112.93 180.11,113.32 180.3,113.32 180.74,112.87 180.74,112.68 180.36,112.3 180.36,111.87 181.41,110.82 185.95,99.86 185.95,99.57
  BOTTOM w0.124: J8.B31 160.17,140.05 160.26,139.96 160.26,139.63 160.18,139.45 160.18,138.44 v2(159.84,138.1)
P3E_PESW_M2G_RX2_DN: length 61.1
  TOP w0.124: U34.E23 v6(187.59,95.02)
  IN2 w0.099: 187.23,99.57 187.23,99.55 187.19,99.51 187.19,94.71 187.29,94.61 187.49,94.61 187.59,94.71 v6(187.59,95.02)
  IN2 w0.136: v2(163.95,138.13) 163.59,137.77 163.59,137.06 164.02,136.63 166.71,135.51 169.44,132.78 171.55,131.91 174.31,131.91 175.05,131.17 176.68,127.24 176.68,125.15 177.04,123.32 177.2,123.22 177.28,122.82 177.17,122.67 177.25,122.27 177.41,122.16 177.49,121.76 177.38,121.61 177.46,121.21 177.62,121.1 177.7,120.7 177.59,120.55 177.72,119.91 182.87,113.64 184.42,112.09 186.14,112.09 187.46,110.76 187.46,105.32 187.23,105.09 187.23,99.57
  BOTTOM w0.124: v2(163.95,138.13) 163.58,138.5 163.58,139.96 163.67,140.05 J8.B17
P3E_PESW_M2G_RX2_DP: length 61.1
  TOP w0.124: U34.F23 v6(187.59,94.02)
  IN2 w0.099: 186.95,99.57 186.95,99.55 186.99,99.51 186.99,94.63 187.21,94.41 187.49,94.41 187.59,94.31 v6(187.59,94.02)
  IN2 w0.136: v2(162.94,138.13) 163.31,137.77 163.31,136.94 163.86,136.39 166.55,135.27 169.28,132.55 171.5,131.63 174.2,131.63 174.82,131.01 176.4,127.19 176.4,125.12 177.46,119.79 182.66,113.45 184.3,111.81 186.02,111.81 187.18,110.65 187.18,105.44 186.95,105.2 186.95,99.57
  BOTTOM w0.124: J8.B19 163.17,140.05 163.28,139.94 163.28,138.47 v2(162.94,138.13)
P3E_PESW_M2G_RX3_DN: length 60.1
  TOP w0.124: U34.D24 v6(188.59,96.02)
  IN2 w0.099: v6(188.59,96.02) 188.59,95.71 188.49,95.61 188.29,95.61 188.19,95.71 188.19,99.51 188.23,99.55 188.23,99.57
  IN2 w0.136: 188.23,99.57 188.23,104.16 188.39,104.32 188.39,111.04 186.04,114.55 184.43,115.22 183.99,115.66 183.67,116.44 183.74,116.62 183.59,117 183.41,117.07 183.25,117.45 183.32,117.63 183.17,118.01 182.99,118.08 182.64,118.92 182.34,119.37 182.38,119.56 182.15,119.9 181.96,119.94 180.92,121.5 178.18,124.24 177.65,125.52 177.65,128.16 176.54,130.84 176.54,131.81 174.53,136.65 174.08,137.1 171.76,138.06 170.49,138.06 167.71,136.91 166.81,136.91 166.54,137.18 166.54,137.79 v2(166.91,138.16)
  BOTTOM w0.124: J8.B5 166.67,140.06 166.57,139.96 166.57,138.5 v2(166.91,138.16)
P3E_PESW_M2G_RX3_DP: length 60.1
  TOP w0.124: U34.E24 v6(188.59,95.02)
  IN2 w0.099: v6(188.59,95.02) 188.59,95.31 188.49,95.41 188.21,95.41 187.99,95.63 187.99,99.51 187.95,99.55 187.95,99.57
  IN2 w0.136: v2(165.89,138.16) 166.26,137.79 166.26,137.06 166.7,136.63 167.76,136.63 170.54,137.78 171.71,137.78 173.92,136.87 174.3,136.49 176.26,131.76 176.26,130.78 177.37,128.1 177.37,125.47 177.94,124.08 180.7,121.32 182.39,118.79 183.75,115.5 184.27,114.98 185.86,114.33 188.11,110.95 188.11,104.43 187.95,104.27 187.95,99.57
  BOTTOM w0.124: v2(165.89,138.16) 166.27,138.54 166.27,139.95 166.17,140.05 J8.B7
P3E_PESW_M2G_TX0_C_DN: length 52.7
  IN1 w0.136: v2(156.43,138.95) 156.06,138.58 156.06,135.54 156.64,134.14 159.74,131.04 161.68,128.68 161.92,128.1 162.88,126.66 164.14,125.39 165.83,121.33 166.04,121.01 166.43,120.08 166.62,119.22 166.79,117.88 167.73,113.11 169.03,111.82 174.13,109.71 185.1,107.52 185.4,107.22 185.4,106.92 v2(185.77,106.55)
  BOTTOM w0.124: v2(156.43,138.95) 156.07,139.31 156.07,139.96 156.17,140.06 J8.B47 ; v2(185.77,106.55) 185.41,106.19 185.41,105.86 C886.2
P3E_PESW_M2G_TX0_C_DP: length 52.7
  IN1 w0.136: v2(184.75,106.55) 185.12,106.92 185.12,107.11 184.96,107.27 174.05,109.44 168.87,111.58 167.48,112.98 166.51,117.84 166.34,119.17 166.16,119.99 165.79,120.88 165.58,121.2 163.91,125.24 162.68,126.46 162.66,126.48 161.67,127.97 161.43,128.53 159.53,130.85 156.4,133.98 155.78,135.49 155.78,138.58 v2(155.41,138.95)
  BOTTOM w0.124: J8.B49 155.67,140.08 155.77,139.98 155.77,139.31 v2(155.41,138.95) ; v2(184.75,106.55) 185.11,106.19 185.11,105.87 C887.2
P3E_PESW_M2G_TX0_DN: length 9
  TOP w0.124: U34.B21 v6(185.59,98.02)
  BOTTOM w0.099: 185.24,101.64 185.24,101.61 185.19,101.56 185.19,100.5 185.29,100.4 185.29,100.2 185.19,100.1 185.19,99.9 185.29,99.8 185.29,99.6 185.19,99.5 185.19,99.3 185.29,99.2 185.29,99 185.19,98.9 185.19,98.7 185.29,98.6 185.29,98.4 185.19,98.3 185.19,97.72 185.29,97.62 185.49,97.62 185.59,97.72 v6(185.59,98.02)
  BOTTOM w0.124: 185.24,101.64 185.24,103.17 185.41,104.03 185.41,104.36 C886.1
P3E_PESW_M2G_TX0_DP: length 9
  TOP w0.124: U34.C21 v6(185.59,97.02)
  BOTTOM w0.099: v6(185.59,97.02) 185.59,97.32 185.49,97.42 185.21,97.42 184.99,97.64 184.99,101.56 184.94,101.61 184.94,101.64
  BOTTOM w0.124: C887.1 185.11,104.34 185.11,104.06 184.94,103.2 184.94,101.64
P3E_PESW_M2G_TX1_C_DN: length 54.7
  IN1 w0.136: v2(159.43,138.95) 159.06,138.58 159.06,135.13 159.47,134.14 162.99,130.62 166.5,122.15 166.74,121.79 167.37,120.27 167.62,118.99 167.73,117.94 168.6,113.56 169.55,112.61 170.91,112.04 184.61,109.32 185.66,109.32 185.96,109.02 185.96,108.71 v2(186.32,108.34)
  BOTTOM w0.124: C884.2 187.16,103.9 187.16,106.47 185.97,107.66 185.97,107.99 v2(186.32,108.34) ; J8.B35 159.17,140.06 159.07,139.96 159.07,139.31 v2(159.43,138.95)
P3E_PESW_M2G_TX1_C_DP: length 54.7
  IN1 w0.136: v2(185.31,108.34) 185.68,108.71 185.68,108.9 185.54,109.04 184.58,109.04 170.83,111.77 169.39,112.37 168.34,113.42 167.45,117.9 167.35,118.95 167.1,120.19 166.49,121.66 166.25,122.02 162.76,130.46 159.24,133.98 158.78,135.08 158.78,138.58 v2(158.41,138.95)
  BOTTOM w0.124: v2(158.41,138.95) 158.77,139.31 158.77,139.95 158.67,140.05 J8.B37 ; C885.2 186.86,103.97 186.86,106.34 185.66,107.53 185.66,107.99 v2(185.31,108.34)
P3E_PESW_M2G_TX1_DN: length 6.4
  TOP w0.124: U34.A22 v6(186.59,99.02)
  BOTTOM w0.099: v6(186.59,99.02) 186.59,98.67 186.49,98.57 186.29,98.57 186.19,98.67 186.19,99.34 186.29,99.45 186.29,99.64 186.19,99.75 186.19,99.94 186.29,100.05 186.29,100.24 186.19,100.35 186.19,100.63 186.43,100.87 186.57,100.87 186.71,101.01 186.71,101.15 187.08,101.51 187.08,102 187.13,102.05 187.13,102.08
  BOTTOM w0.124: 187.13,102.08 187.13,102.42 C884.1
P3E_PESW_M2G_TX1_DP: length 6.4
  TOP w0.124: U34.B22 v6(186.59,98.02)
  BOTTOM w0.099: 186.82,102.08 186.82,102.05 186.87,102 186.87,101.6 185.99,100.71 185.99,98.58 186.21,98.36 186.5,98.36 186.59,98.27 v6(186.59,98.02)
  BOTTOM w0.124: 186.82,102.08 186.82,102.42 C885.1
P3E_PESW_M2G_TX2_C_DN: length 52.4
  IN1 w0.136: v2(162.43,138.95) 162.06,138.58 162.06,134.67 162.66,133.21 163.97,130.76 164.95,128.4 167.88,122.91 168.96,121.3 169.46,120.08 170.01,117.36 170.31,116.62 170.31,115.15 170.75,114.09 171.35,113.49 172.27,113.11 179.89,111.59 184.72,111.59 185.26,111.05 185.26,110.56 v2(185.63,110.19)
  BOTTOM w0.124: C882.2 188.77,105.9 188.77,106.17 188.62,106.54 188.23,107.12 187.87,107.48 187.87,108.46 186.75,109.58 185.38,109.58 185.27,109.68 185.27,109.83 v2(185.63,110.19) ; J8.B23 162.17,140.07 162.07,139.97 162.07,139.31 v2(162.43,138.95)
P3E_PESW_M2G_TX2_C_DP: length 52.4
  IN1 w0.136: v2(184.61,110.19) 184.98,110.56 184.98,110.94 184.6,111.31 179.87,111.31 172.19,112.84 171.19,113.25 170.52,113.93 170.03,115.09 170.03,116.56 169.74,117.28 169.2,120 168.71,121.17 167.64,122.77 164.7,128.28 163.72,130.64 162.41,133.09 161.78,134.61 161.78,138.58 v2(161.41,138.95)
  BOTTOM w0.124: C883.2 188.47,105.88 188.47,106.11 188.35,106.39 187.99,106.93 187.57,107.35 187.57,108.33 186.62,109.28 185.25,109.28 184.97,109.56 184.97,109.83 v2(184.61,110.19) ; v2(161.41,138.95) 161.77,139.31 161.77,139.95 161.67,140.05 J8.B25
P3E_PESW_M2G_TX2_DN: length 9.6
  TOP w0.124: U34.B23 v6(187.59,98.02)
  BOTTOM w0.099: 188.32,100.97 188.3,100.96 188.23,100.96 188.03,100.75 188.03,100.61 187.89,100.47 187.74,100.47 187.19,99.91 187.19,99.72 187.29,99.61 187.29,99.42 187.19,99.31 187.19,99.12 187.29,99.02 187.29,98.82 187.19,98.72 187.19,97.72 187.29,97.62 187.49,97.62 187.59,97.72 v6(187.59,98.02)
  BOTTOM w0.124: C882.1 188.79,104.38 188.79,101.68 188.62,101.27 188.32,100.97
P3E_PESW_M2G_TX2_DP: length 9.6
  TOP w0.124: U34.C23 v6(187.59,97.02)
  BOTTOM w0.099: 188.11,101.19 188.09,101.17 188.09,101.1 186.99,100 186.99,97.64 187.21,97.42 187.49,97.42 187.59,97.32 v6(187.59,97.02)
  BOTTOM w0.124: C883.1 188.48,104.38 188.48,101.74 188.36,101.44 188.11,101.19
P3E_PESW_M2G_TX3_C_DN: length 55.6
  IN1 w0.136: v2(190.5,106.87) 190.1,107.27 190.1,107.56 189.81,107.86 188.31,107.86 187.32,108.85 187.32,111.34 186.03,112.63 180.22,112.63 177.49,114.27 177.09,114.17 176.72,113.56 176.55,113.51 176,113.84 175.96,114.02 176.33,114.63 176.23,115.03 174.98,115.78 172.16,116.94 171.44,117.09 171.11,117.31 170.85,117.93 170.36,120.41 169.84,121.68 168.76,123.28 167.91,125.33 167.37,128.06 166.78,129.49 165.07,131.2 164.74,132 164.74,133.74 165.07,135.43 165.07,138.6 v2(165.43,138.95)
  BOTTOM w0.124: v2(190.5,106.87) 190.12,106.49 190.12,106.3 190.37,106.05 190.37,103.89 C880.2 ; J8.B11 165.17,140.06 165.07,139.97 165.07,139.31 v2(165.43,138.95)
P3E_PESW_M2G_TX3_C_DP: length 55.6
  IN1 w0.136: v2(164.41,138.95) 164.8,138.57 164.8,135.46 164.46,133.77 164.46,131.94 164.65,131.49 164.65,131.22 166.54,129.33 167.1,127.98 167.65,125.25 168.52,123.15 169.59,121.54 170.09,120.33 170.59,117.85 170.89,117.12 171.33,116.82 172.08,116.68 174.85,115.53 175.99,114.85 176.03,114.67 175.66,114.06 175.76,113.66 176.51,113.22 176.9,113.31 177.27,113.93 177.45,113.97 180.15,112.35 185.92,112.35 187.04,111.23 187.04,108.73 188.2,107.58 189.69,107.58 189.82,107.45 189.82,107.21 v2(189.48,106.87)
  BOTTOM w0.124: C881.2 190.06,103.88 190.06,105.92 189.82,106.17 189.82,106.54 v2(189.48,106.87) ; v2(164.41,138.95) 164.77,139.31 164.77,139.96 164.67,140.06 J8.B13
P3E_PESW_M2G_TX3_DN: length 6.8
  TOP w0.124: U34.A24 v6(188.59,99.02)
  BOTTOM w0.099: v6(188.59,99.02) 188.59,98.72 188.49,98.62 188.29,98.62 188.19,98.72 188.19,99.26 188.44,99.5 188.58,99.5 188.72,99.64 188.72,99.79 188.86,99.93 189,99.93 189.14,100.07 189.14,100.21 189.28,100.35 189.43,100.35 189.57,100.49 189.57,100.64 189.71,100.78 189.78,100.78 189.8,100.79
  BOTTOM w0.124: 189.8,100.79 190.37,101.37 190.37,102.37 C880.1
P3E_PESW_M2G_TX3_DP: length 6.8
  TOP w0.124: U34.B24 v6(188.59,98.02)
  BOTTOM w0.099: 189.58,101.01 189.56,100.99 189.56,100.92 187.99,99.34 187.99,98.64 188.21,98.42 188.49,98.42 188.59,98.32 v6(188.59,98.02)
  BOTTOM w0.124: C881.1 190.07,102.38 190.07,101.5 189.58,101.01
P3E_PESW_M2H_RX0_DN: length 80.2
  TOP w0.124: U34.E17 v6(180.59,95.02)
  IN2 w0.099: v6(180.59,95.02) 180.59,94.71 180.49,94.61 180.29,94.61 180.19,94.71 180.19,99.34 180.23,99.37 180.23,99.4
  IN2 w0.136: 180.23,99.4 180.23,100 179.16,102.57 176.33,106.82 175.96,107.19 168.81,111.96 168.46,112.39 167.35,115.07 166.75,118.13 166.57,119.29 166.51,119.7 166.43,119.96 166.06,120.66 165.55,121.28 164.46,123.32 164.46,123.32 164.51,123.5 164.32,123.86 164.14,123.91 163.95,124.27 164,124.45 163.81,124.81 163.63,124.87 163.44,125.23 163.49,125.4 163.3,125.76 163.12,125.82 162.31,127.34 161.51,129.27 160.93,129.85 157.57,129.85 156.36,128.64 155.38,128.64 155.24,128.78 155.24,128.94 153.62,130.56 151.03,130.56 149.97,131.63 149.97,132.35 149.31,133.01 137.73,133.01 135.65,133.86 134.3,135.22 133.57,136.98 133.57,137.4 v2(133.93,137.76)
  BOTTOM w0.124: v2(133.93,137.76) 133.57,138.11 133.57,139.95 133.67,140.05 J8.A41
P3E_PESW_M2H_RX0_DP: length 80.2
  TOP w0.124: U34.F17 v6(180.59,94.02)
  IN2 w0.099: 179.95,99.4 179.95,99.37 179.99,99.34 179.99,94.63 180.21,94.41 180.49,94.41 180.59,94.31 v6(180.59,94.02)
  IN2 w0.136: v2(132.91,137.76) 133.29,137.38 133.29,136.9 133.31,136.88 134.06,135.06 135.5,133.63 137.67,132.73 149.2,132.73 149.69,132.24 149.69,131.51 150.91,130.29 153.5,130.29 154.96,128.83 154.96,128.66 155.26,128.36 156.48,128.36 157.69,129.57 160.82,129.57 161.27,129.11 162.06,127.22 162.93,125.58 165.31,121.13 165.82,120.51 166.18,119.85 166.24,119.64 166.47,118.08 167.08,114.99 168.22,112.24 168.62,111.75 175.78,106.97 176.11,106.64 176.11,106.64 178.92,102.44 179.95,99.95 179.95,99.4
  BOTTOM w0.124: J8.A43 133.17,140.06 133.27,139.96 133.27,138.11 v2(132.91,137.76)
P3E_PESW_M2H_RX1_DN: length 80.1
  TOP w0.124: U34.D18 v6(181.59,96.02)
  IN2 w0.099: 181.23,99.45 181.23,99.43 181.19,99.39 181.19,95.71 181.29,95.61 181.49,95.61 181.59,95.71 v6(181.59,96.02)
  IN2 w0.136: v2(136.93,137.76) 136.57,137.4 136.57,136 137.03,134.89 138.41,133.97 149.95,133.97 151.11,132.82 151.11,131.86 151.44,131.52 154.11,131.52 155.62,133.03 157.21,133.03 162.58,130.8 163.46,129.92 167.3,120.64 168.45,114.87 169.26,112.92 169.46,112.68 172.47,110.67 172.66,110.71 173,110.48 173.04,110.29 173.38,110.06 173.57,110.1 173.91,109.87 173.95,109.68 174.29,109.45 174.48,109.49 174.82,109.26 174.86,109.07 176.49,107.98 177.42,107.05 178.1,106.03 178.27,106 178.84,106.37 179.24,106.29 179.72,105.57 179.64,105.17 179.08,104.79 179.04,104.62 179.9,103.33 181.23,100.13 181.23,99.45
  BOTTOM w0.124: v2(136.93,137.76) 136.57,138.11 136.57,139.86 136.67,139.96 J8.A29
P3E_PESW_M2H_RX1_DP: length 80
  TOP w0.124: U34.E18 v6(181.59,95.02)
  IN2 w0.099: v6(181.59,95.02) 181.59,95.31 181.49,95.41 181.21,95.41 180.99,95.63 180.99,99.39 180.95,99.43 180.95,99.45
  IN2 w0.136: v2(135.91,137.76) 136.29,137.37 136.29,135.94 136.81,134.71 138.33,133.69 149.83,133.69 150.83,132.7 150.83,131.74 151.33,131.24 154.23,131.24 155.74,132.75 157.15,132.75 162.42,130.57 163.22,129.77 167.04,120.56 168.18,114.79 169.02,112.77 169.27,112.47 176.31,107.76 177.2,106.87 177.93,105.78 178.22,105.72 178.33,105.7 178.89,106.08 179.07,106.04 179.42,105.51 179.39,105.34 178.83,104.96 178.75,104.56 179.65,103.2 180.95,100.07 180.95,99.45
  BOTTOM w0.124: v2(135.91,137.76) 136.27,138.11 136.27,139.85 136.17,139.95 J8.A31
P3E_PESW_M2H_RX2_DN: length 76.6
  TOP w0.124: U34.E19 v6(182.59,95.02)
  IN2 w0.099: v6(182.59,95.02) 182.59,94.71 182.49,94.61 182.29,94.61 182.19,94.71 182.19,99.34 182.23,99.38 182.23,99.41
  IN2 w0.136: v2(139.93,138.98) 139.56,138.61 139.56,136.7 139.89,136.21 140.45,135.98 141.27,135.98 144.16,137.17 149.01,137.17 150.43,136.59 152.58,134.44 153.53,134.04 157.31,134.04 163.17,131.61 165.43,129.36 165.43,128.05 166.68,125.04 166.97,124.6 167.15,124.56 167.38,124.22 167.34,124.04 167.57,123.7 167.75,123.66 167.98,123.33 167.94,123.14 168.17,122.8 168.35,122.77 168.58,122.43 168.54,122.24 168.88,121.74 170.51,117.81 170.51,115.91 170.77,114.6 171.14,113.71 171.68,113.16 177.27,110.84 179.59,108.53 181.87,103.03 182.23,101.2 182.23,99.41
  BOTTOM w0.124: J8.A17 139.67,139.94 139.57,139.84 139.57,139.33 v2(139.93,138.98)
P3E_PESW_M2H_RX2_DP: length 76.6
  TOP w0.124: U34.F19 v6(182.59,94.02)
  IN2 w0.099: v6(182.59,94.02) 182.59,94.31 182.49,94.41 182.21,94.41 181.99,94.63 181.99,99.34 181.95,99.38 181.95,99.41
  IN2 w0.136: v2(138.91,138.98) 139.28,138.61 139.28,136.62 139.7,135.98 140.39,135.7 141.33,135.7 144.22,136.9 148.96,136.9 150.27,136.35 152.42,134.2 153.47,133.76 157.25,133.76 163.01,131.38 165.15,129.24 165.15,127.99 166.43,124.9 168.63,121.61 170.23,117.76 170.23,115.88 170.5,114.52 170.9,113.55 171.52,112.92 177.11,110.61 179.35,108.37 181.6,102.95 181.95,101.18 181.95,99.41
  BOTTOM w0.124: v2(138.91,138.98) 139.27,139.33 139.27,139.85 139.17,139.95 J8.A19
P3E_PESW_M2H_RX3_DN: length 75.6
  TOP w0.124: U34.D20 v6(184.59,96.02)
  IN2 w0.136: v6(184.59,96.02) 184.29,95.72 184.07,95.93 184.07,100.11 180.37,109.06 176.74,112.69 175.27,114.89 174.78,116.18 174.39,116.35 173.63,116.06 173.46,116.13 173.23,116.72 173.31,116.89 174.07,117.19 174.24,117.57 173.67,119.03 172.71,124.21 170.7,126.22 168.6,127.09 166.82,128.87 166.41,129.86 162.56,133.71 160.58,133.71 159.33,134.22 158.97,134.58 158.97,135.37 158.48,135.86 157.31,135.86 156.01,137.16 156.01,137.5 155.35,138.16 154.21,138.16 154.07,138.3 153.66,138.3 153.52,138.16 153.11,138.16 152.97,138.3 152.57,138.3 152.42,138.16 152.02,138.16 151.88,138.3 151.47,138.3 151.33,138.16 150.92,138.16 150.78,138.3 150.37,138.3 150.23,138.16 149.76,138.16 149.06,138.86 147.42,138.86 147.27,138.71 146.18,138.71 146,138.9 144.25,138.9 143.36,138.01 142.84,138.01 142.51,138.33 142.51,138.53 v2(142.93,138.95)
  BOTTOM w0.124: J8.A5 142.67,139.95 142.57,139.85 142.57,139.31 v2(142.93,138.95)
P3E_PESW_M2H_RX3_DP: length 75.6
  TOP w0.124: U34.E20 v6(184.59,95.02)
  IN2 w0.136: v6(184.59,95.02) 183.79,95.81 183.79,100.06 180.13,108.9 176.52,112.51 175.02,114.76 174.56,115.97 174.38,116.05 173.62,115.75 173.24,115.92 172.93,116.73 173.1,117.11 173.86,117.4 173.93,117.58 173.4,118.96 172.45,124.07 170.54,125.98 168.44,126.85 166.58,128.71 166.17,129.7 162.44,133.43 160.52,133.43 159.17,133.98 158.69,134.46 158.69,135.25 158.37,135.58 157.19,135.58 155.73,137.04 155.73,137.38 155.23,137.88 149.65,137.88 148.95,138.58 147.53,138.58 147.38,138.43 146.07,138.43 145.88,138.62 144.36,138.62 143.48,137.73 142.72,137.73 142.23,138.22 142.23,138.63 v2(141.91,138.95)
  BOTTOM w0.124: v2(141.91,138.95) 142.27,139.31 142.27,139.85 142.17,139.95 J8.A7
P3E_PESW_M2H_TX0_C_DN: length 86.5
  IN1 w0.136: v2(134.5,102.57) 134.13,102.93 134.13,103.5 133.97,103.89 133.66,104.2 133.36,104.93 133.36,105.42 133.61,106.04 133.61,108.19 133.36,108.82 133.36,115.09 132.76,116.52 132.46,118.04 132.46,125.42 131.45,127.87 131.45,133.78 132.06,136.87 132.06,138.58 v2(132.43,138.95)
  BOTTOM w0.124: C894.2 174.83,104.47 174.83,104.97 174.55,105.25 170.43,105.25 164.33,99.16 159.2,97.03 142.92,97.03 135.72,100.01 134.18,101.55 134.18,102.25 v2(134.5,102.57) ; v2(132.43,138.95) 132.07,139.31 132.07,139.85 132.17,139.95 J8.A47
P3E_PESW_M2H_TX0_C_DP: length 86.5
  IN1 w0.136: v2(133.48,102.57) 133.85,102.93 133.85,103.45 133.73,103.73 133.42,104.05 133.08,104.88 133.08,105.47 133.34,106.1 133.34,108.14 133.08,108.76 133.08,115.03 132.49,116.44 132.18,118.01 132.18,125.37 131.17,127.82 131.17,133.81 131.78,136.89 131.78,138.58 v2(131.41,138.95)
  BOTTOM w0.124: v2(133.48,102.57) 133.88,102.17 133.88,101.42 135.55,99.75 142.86,96.73 159.27,96.73 164.51,98.9 170.56,104.95 174.42,104.95 174.52,104.85 174.52,104.47 C895.2 ; J8.A49 131.67,139.95 131.77,139.85 131.77,139.31 v2(131.41,138.95)
P3E_PESW_M2H_TX0_DN: length 11.3
  TOP w0.124: U34.B17 v6(180.59,98.02)
  BOTTOM w0.099: v6(180.59,98.02) 180.59,97.72 180.49,97.62 177.79,97.62 177.73,97.67 177.71,97.67
  BOTTOM w0.124: C894.1 174.83,102.96 174.83,102.65 175.01,102.22 175.21,102.14 175.35,101.79 175.27,101.59 175.41,101.25 175.61,101.16 175.75,100.82 175.67,100.62 175.81,100.28 176.01,100.19 176.15,99.85 176.07,99.65 176.22,99.3 176.41,99.22 176.56,98.88 176.47,98.68 176.7,98.13 177.38,97.67 177.71,97.67
P3E_PESW_M2H_TX0_DP: length 11.3
  TOP w0.124: U34.C17 v6(180.59,97.02)
  BOTTOM w0.099: v6(180.59,97.02) 180.59,97.32 180.49,97.42 177.79,97.42 177.73,97.37 177.71,97.37
  BOTTOM w0.124: C895.1 174.52,102.96 174.52,102.59 176.46,97.92 177.29,97.37 177.71,97.37
P3E_PESW_M2H_TX1_C_DN: length 88
  IN1 w0.136: v2(135.43,138.95) 135.06,138.58 135.06,133.85 134.04,131.4 133.25,130.6 132.67,129.2 132.67,127.54 133.45,125.66 133.45,118.04 134.36,115.84 134.36,109.33 134.74,107.41 134.74,105.65 v2(135.11,105.28)
  BOTTOM w0.124: v2(135.11,105.28) 134.75,104.92 134.75,104.67 134.92,104.25 137.27,101.9 142.08,98.68 143.02,98.29 158.99,98.29 163.42,100.13 169.78,106.48 178.3,106.48 178.58,106.2 178.58,105.78 C892.2 ; J8.A35 135.17,139.97 135.07,139.87 135.07,139.31 v2(135.43,138.95)
P3E_PESW_M2H_TX1_C_DP: length 88
  IN1 w0.136: v2(134.09,105.28) 134.46,105.65 134.46,107.39 134.08,109.3 134.08,115.79 133.17,117.98 133.17,125.6 132.39,127.49 132.39,129.69 132.7,130.01 133.01,130.76 133.81,131.56 134.78,133.91 134.78,138.58 v2(134.41,138.95)
  BOTTOM w0.124: v2(134.41,138.95) 134.77,139.31 134.77,139.88 134.67,139.97 J8.A37 ; C893.2 178.28,105.7 178.28,106.07 178.17,106.17 169.9,106.17 163.6,99.87 159.05,97.99 142.96,97.99 141.96,98.4 141.93,98.41 137.07,101.66 134.66,104.07 134.44,104.6 134.44,104.92 v2(134.09,105.28)
P3E_PESW_M2H_TX1_DN: length 8.9
  TOP w0.124: U34.A18 v6(181.59,99.02)
  BOTTOM w0.124: C892.1 178.62,104.23 178.62,103.86 178.77,103.7 178.77,103.33 178.62,103.18 178.62,102.8 178.77,102.65 178.77,102.28 178.62,102.13 178.62,101.45 178.91,100.74 179.17,100.47 179.39,100.47 179.65,100.21 179.65,99.99 179.92,99.73 180.13,99.73 180.4,99.46 180.4,99.25 180.97,98.67 181.24,98.67 v6(181.59,99.02)
P3E_PESW_M2H_TX1_DP: length 8.9
  TOP w0.124: U34.B18 v6(181.59,98.02)
  BOTTOM w0.124: C893.1 178.31,104.23 178.31,101.39 178.65,100.56 180.85,98.37 181.24,98.37 v6(181.59,98.02)
