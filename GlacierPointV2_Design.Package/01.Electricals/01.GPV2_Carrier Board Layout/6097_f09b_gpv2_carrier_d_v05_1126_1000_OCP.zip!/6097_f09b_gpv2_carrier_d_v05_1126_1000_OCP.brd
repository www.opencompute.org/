# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PU_M2H_CLKREQ_N: length 5.1
  BOTTOM w0.112: J8.A52 130.92,132.08 130.35,131.52 v3(130.35,129.98) 130.35,129.39 130.77,128.98 R2786.1
PU_M2H_PLA_S3_N: length 12.4
  BOTTOM w0.112: J8.A30 136.42,131.16 135.67,130.41 134.24,130.41 133.13,129.31 133.13,127.35 133.83,126.65 134.49,126.65 135.1,126.05 135.1,125.73 135.92,124.92 R4269.1
PU_M2H_VIO_1V8: length 18.6
  BOTTOM w0.112: J8.A22 138.42,134.02 137.93,134.51 137.93,134.81 138.23,135.11 138.75,135.11 139.67,136.03 142.01,136.03 143.44,137.46 145.14,137.46 146.11,138.42 146.11,141.04 147.07,142 147.99,142 R4248.2
PU_M2I_CLKREQ_N: length 4.7
  BOTTOM w0.112: J34.B52 106.92,132.26 106.15,131.49 v3(106.15,129.98) R2888.1
PU_M2I_PLA_S3_N: length 12.5
  BOTTOM w0.112: R4270.1 110.05,124.56 v3(109.53,125.09) 108.78,125.84 108.78,129.28 109.97,130.48 110.89,130.48 111.09,130.68 111.09,131.07 112.42,132.4 112.42,133.22 J34.B30
PU_M2I_VIO_1V8: length 8.3
  BOTTOM w0.112: J34.B22 114.42,133.22 114.42,132.27 113.01,130.86 113.01,126.51 113.24,126.28 R4250.2
PU_M2J_CLKREQ_N: length 5.1
  BOTTOM w0.112: J34.A52 82.92,132.09 82.02,131.2 v3(82.02,129.98) 82.02,129.56 82.63,128.95 R2885.1
PU_M2J_VIO_1V8: length 8.4
  BOTTOM w0.112: R4252.2 89.07,126.23 89.07,130.79 90.42,132.15 J34.A22
PU_M2K_CLKREQ_N: length 4.8
  BOTTOM w0.112: R2783.1 58.68,129.75 v3(58.49,129.95) 58.49,131.67 58.92,132.1 J6.B52
PU_M2K_PLA_S3_N: length 13.1
  BOTTOM w0.112: R4272.1 64.28,125.02 v3(64.02,125.28) 63.89,125.42 62.26,125.42 61.11,126.56 61.11,129.11 62.06,130.05 62.63,130.05 63.93,131.35 63.93,131.82 64.42,132.31 J6.B30
PU_M2K_VIO_1V8: length 19
  BOTTOM w0.112: J6.B22 66.42,134.16 66.82,134.56 67.88,134.56 69.48,136.16 71.32,136.16 72.15,136.98 73.39,136.98 74.32,137.92 74.32,141.51 75.81,143 75.81,144.39 76,144.58 76.26,144.58 R4254.2
PU_M2L_CLKREQ_N: length 6.1
  BOTTOM w0.112: R2780.1 32.1,129.59 v3(32.48,129.98) 33.41,129.98 34.43,131 34.43,131.93 34.92,132.41 J6.A52
PU_M2L_PLA_S3_N: length 14.1
  BOTTOM w0.112: J6.A30 40.42,132.28 40.5,132.2 40.5,131.9 40.36,131.56 39.06,130.26 38.43,130.26 37.03,128.86 37.03,127.41 38.14,126.3 38.14,125.76 v3(38.94,124.95) 39.38,124.51 40.21,124.51 40.76,123.97 41.16,123.97 R4273.1
PU_M2L_VIO_1V8: length 30.9
  TOP w0.112: v2(41.2,129.71) 41.13,129.71 40.46,130.38 40.46,131.43 40.73,131.69 40.73,133.59 41.72,134.59 41.72,136.68 40.7,137.7 33.15,137.7 32.6,138.25 32.6,143.14 33.07,143.61 34.51,143.61 35.29,144.39 v4(35.29,144.95)
  BOTTOM w0.112: v2(41.2,129.71) 41.82,130.33 41.82,131.2 42.42,131.81 J6.A22 ; R4256.2 v4(35.29,144.95)
PU_P3V3_STBY_Q50_G: length 3.5
  BOTTOM w0.112: Q50.G 5.56,104.39 R4290.2 5.38,103.01 Q51.D
PU_PESW_AVS_ENB: length 17.1
  TOP w0.112: R3285.1 205.01,102.08 v2(204.23,102.08) ; U34.H31 v6(195.59,92.02)
  IN2 w0.122: v2(204.23,102.08) 204.23,101.72 201.65,99.14 201.65,97.44 198.75,94.54 197.39,94.54 197.14,94.29 197.14,92.51 196.9,92.28 196.19,92.28 195.93,92.02 v6(195.59,92.02)
PU_PESW_MULTI_CONFIG_ADD0: length 6.8
  BOTTOM w0.112: R3746.1 C1111.1 52.52,30.3 v3(53.79,31.57) 54.68,31.57 Q38.G
PU_PESW_MULTI_CONFIG_ADD1: length 8.1
  BOTTOM w0.112: Q39.G 52.04,32.72 49.46,32.72 v3(47.88,31.14) R3750.1 C1112.1
PU_PESW_MULTI_CONFIG_ADD2: length 6.6
  BOTTOM w0.112: Q40.G 60.41,32.58 v3(59.61,31.78) 58.77,30.94 57.82,30.94 R3754.1 C1113.1
PU_PESW_MULTI_CONFIG_ADD3: length 3.7
  BOTTOM w0.112: C1178.1 R4066.1 v3(74.9,35.1) 74.9,35.76 74.75,35.92 Q42.G
PU_PESW_MULTI_CONFIG_ADD4: length 3.7
  BOTTOM w0.112: Q43.G 70.84,36.17 v3(70.84,35.08) R4070.1 C1179.1
PU_REMOTE_DEBUG_SELECT: length 11.8
  TOP w0.112: SW5.A 104.33,142.23 103.38,141.28 v1(102.26,141.28) 100.38,141.28 98.57,143.09 97.3,143.09 96.44,143.95 95.68,143.95 R4097.2
PU_TAP_SEL: length 17.5
  TOP w0.112: v2(203.42,69.04) 203.49,68.97 204.1,68.97 205.15,67.92 v1(205.15,67.44) 205.15,66.24 205.46,65.93 R3147.1 R3149.2 ; U34.AG30 v6(194.59,72.02)
  IN1 w0.122: v2(203.42,69.04) 202.75,69.71 202.75,70.43 201.7,71.47 195.89,71.47 195.34,72.02 v6(194.59,72.02)
PU_TXS_OE: length 3.3
  TOP w0.112: R3278.2 v2(182.08,136.94) 183.01,136.94 183.13,136.82 183.4,136.82 183.89,136.33 U66.6
PU_ZL30281_IF0: length 4.5
  TOP w0.112: R3235.1 R3234.2 v2(124.42,41.48) 124.28,41.48 122.98,40.18 U61.32
PWRGD_CLK_ZL30281: length 39
  TOP w0.112: U61.4 120.19,41.34 118.92,42.61 R3218.1 116.06,43.75 113.8,41.49 104.19,41.49 102.35,39.64 v1(102.21,39.64) 97.48,39.64 96.19,38.35 U62.2
PWRGD_GPV2_SYS: length 81.1
  TOP w0.112: U86.A13 39.67,40.66 39.67,37.84 v2(39.49,37.66) ; R4387.2 87.25,40.59 v2(86.56,39.9)
  IN1 w0.122: v2(86.56,39.9) 86.25,40.22 83.7,40.22 76.01,32.52 71.42,32.52 70.78,31.88 66.71,31.88 66.3,31.47 60.59,31.47 58.47,29.35 58.47,27.56 58.22,27.31 56.8,25.9 44.11,25.9 39.55,30.45 36.29,30.45 35.04,29.21 v2(33.02,29.21)
  BOTTOM w0.112: v2(39.49,37.66) 39.58,37.57 39.58,35.67 39.46,35.56 39.46,34.44 38.08,33.06 37.19,33.06 v3(35.49,31.36) 33.34,29.21 v2(33.02,29.21)
PWRGD_P0V92: length 244.6
  TOP w0.112: v2(60.05,2.68) 58.29,4.44 58.29,6.17 59.03,6.9 59.03,10.54 58.45,11.12 58.45,12.41 64.4,18.36 64.4,23.04 65.94,24.58 65.94,27.4 67.32,28.78 71.83,28.78 72.78,29.73 C1228.1 74.01,31.02 v1(74.04,30.99) 75.02,30.99 78.64,34.6 80.17,35.24 83.94,39 U62.1 ; PU301.10 200.37,34.41 200.1,34.3 199.41,33.61 v2(199.41,33.55) 199.41,33.4 199.16,32.81 PR307.2
  IN1 w0.122: v2(60.05,2.68) 60.62,2.11 81.05,2.11 81.44,1.73 94.03,1.73 94.49,1.26 207.34,1.26 208.56,2.49 208.56,22.63 206.3,24.89 200.76,24.89 199.21,26.43 199.21,32.78 199.41,33.26 v2(199.41,33.55)
PWRGD_P1V8: length 286.5
  TOP w0.112: v4(22.02,17.28) 21.12,17.28 20.59,17.81 PR701.2 20.28,18.48 19.69,19.06 PU7.5 ; U61.30 124.21,39.18 124.94,38.44 127.01,38.44 128.28,39.72 v2(130.29,39.72) 130.9,40.33 132.35,40.33 133.16,39.52 135.14,39.52 136.07,38.58 136.07,36.87 136.48,36.46 U106.5 ; v2(11.25,96) 11.88,96.63 R4289.1
  IN1 w0.122: v2(15.56,33.99) 13.41,36.14 10.79,36.14 9.75,37.18 7.96,37.18 4.85,40.29 4.85,43.16 3.31,44.7 3.31,61 v2(2.07,62.24)
  IN2 w0.122: v2(130.29,39.72) 130.29,39.57 128.11,37.4 128.11,35.47 126.04,33.4 113.16,33.4 112.77,33.79 106.34,33.79 105.44,34.69 97.03,34.69 96.79,34.45 92.94,34.45 90.01,31.52 85.9,31.52 78.57,24.19 76.21,24.19 73.39,21.37 73.39,15.57 71.88,14.06 71.88,6.61 72.14,6.34 72.14,4.98 69,1.83 59.89,1.83 58.99,2.73 25.82,2.73 22.52,6.03 22.52,16.78 v4(22.02,17.28) 23.62,18.88 23.62,28.17 22.97,28.82 16.74,28.82 15.47,30.09 15.47,32.93 15.56,33.03 v2(15.56,33.99)
  BOTTOM w0.112: v2(2.07,62.24) 1.41,62.9 1.41,74.83 3.39,76.8 4.65,76.8 6.01,78.15 6.01,79.94 6.75,80.69 6.87,80.8 8.78,80.8 9.65,81.67 9.65,82.82 9.02,83.45 9.02,85.34 9.81,86.12 9.81,87.74 10.78,88.71 10.78,90.63 11.98,91.83 11.98,93.75 11.25,94.48 v2(11.25,96) 10.62,96.63 10.62,97.8 10.09,98.33 10.09,100.01 9.66,100.44 8.16,100.44 7.7,99.97 6.87,99.97 R4292.2 ; v2(130.29,39.72) 130.43,39.72 131.72,41.01 D4.5
PWRGD_P1V8_R: length 4
  BOTTOM w0.112: Q51.G 5.5,101.11 5.7,101.31 R4292.1 6.33,102.06 6.78,102.51 v3(6.78,102.99)
PWRGD_P3V3_M2A: length 4.3
  TOP w0.112: U86.A11 40.84,40.83 40.84,38.3 40.87,38.28 40.87,38.27 41.27,37.86 R3994.2
PWRGD_P3V3_M2A_R: length 108.2
  TOP w0.112: U19.8 v2(25.56,118.46) ; v2(21.66,117.32) 21.74,117.41 R3535.1 ; R3994.1 41.93,35.39 v2(42.01,35.39)
  IN1 w0.122: v2(21.66,117.32) 21.05,117.32 20.77,117.04 20.77,114.23 20.95,114.05 20.95,112.64 20.43,112.11 20.43,110.3 20.83,109.9 20.83,109.15 v2(20.54,108.85)
  IN2 w0.122: v2(20.54,108.85) 26.89,102.49 26.89,100.49 28.91,98.48 28.91,98.14 32.5,94.55 32.5,92.31 37.82,87 37.82,86.12 41.09,82.84 43.43,82.84 44.61,81.67 44.61,81.22 44.59,81.2 44.59,79.5 49.02,75.07 49.02,72.39 50.08,71.33 50.08,64.54 49.63,64.09 49.63,62.13 49.53,62.03 49.53,59.15 48.57,58.19 48.57,56.64 47.84,55.91 47.84,48.71 48.04,48.51 48.04,48.19 48.19,48.04 48.19,48 45.98,45.79 45.98,42.33 44.89,41.23 44.89,38.5 42.01,35.62 v2(42.01,35.39)
  BOTTOM w0.112: v2(21.66,117.32) 25.29,117.32 25.56,117.59 v2(25.56,118.46)
PWRGD_P3V3_M2B: length 5.5
  TOP w0.112: U86.B10 41.45,41.45 v6(40.96,41.95)
  BOTTOM w0.112: R3995.2 40.07,37.75 40.07,39.24 40.47,39.65 v3(40.47,40.06) 40.84,40.43 40.84,41.83 v6(40.96,41.95)
PWRGD_P3V3_M2B_R: length 107.5
  TOP w0.112: v2(46.47,117.11) R3536.1 ; v2(50.59,117.75) 50.27,117.44 U20.8
  IN1 w0.122: v2(32.97,86.77) 35.94,86.77 46.14,96.97 46.14,108.55 46.63,109.04 46.63,111.25 47.39,112 47.77,112.94 47.77,114.58 47.4,115.48 46.77,116.11 46.77,116.81 v2(46.47,117.11)
  IN2 w0.122: v2(32.97,86.77) 33.55,86.18 33.55,81.95 34.4,81.1 34.4,80.62 35.22,79.81 35.3,79.81 35.83,79.28 35.83,77.1 37.51,75.41 37.51,73.13 40.56,70.08 40.56,64.74 39.26,63.44 39.26,59.62 39.74,59.14 39.74,54.05 39.02,53.33 39.02,51.84 38.38,51.19 38.38,50.8 36.83,49.26 36.83,47.25 34.29,44.71 34.29,41.24 39.47,36.06 39.47,35.24 v2(39.95,34.76)
  BOTTOM w0.112: v2(39.95,34.76) 39.96,34.76 39.96,34.75 40.02,34.75 40.49,35.22 40.49,35.92 40.21,36.2 R3995.1 ; v2(46.47,117.11) 46.52,117.07 49.9,117.07 v2(50.59,117.75)
PWRGD_P3V3_M2C: length 4.6
  TOP w0.112: U86.A10 41.23,40.72 41.23,38.47 41.68,38.02 41.68,37.49 R3996.2
PWRGD_P3V3_M2C_R: length 113.4
  TOP w0.112: R3537.1 v2(71.31,115.94) ; R3996.1 42.54,35.83 v2(42.54,34.89) ; U21.8 v2(75.18,116.56)
  IN1 w0.122: v2(64.64,87.17) 64.64,87.7 66.53,89.59 66.53,90.95 71.71,96.13 71.71,105.13 71.96,105.73 71.96,109.98 72.58,110.6 72.58,113.62 72.44,113.96 71.67,114.73 71.67,115.58 v2(71.31,115.94)
  IN2 w0.122: v2(42.54,34.89) 42.54,35.55 45.31,38.32 45.31,40.95 46.73,42.36 46.73,45.68 48.54,47.48 48.54,47.7 48.47,47.77 48.47,48.08 48.26,48.28 48.26,55.66 49,56.39 49,58.01 49.96,58.97 49.96,61.86 50.05,61.95 50.05,63.91 50.51,64.36 50.51,71.51 49.45,72.57 49.45,75.25 45.02,79.68 45.02,80.93 v2(46.51,82.42)
  BOTTOM w0.112: v2(75.18,116.56) 74.56,116.56 74.11,116.11 71.49,116.11 v2(71.31,115.94) ; v2(46.51,82.42) 48.76,84.67 57.16,84.67 57.54,85.05 62.72,85.05 64.64,86.97 v2(64.64,87.17)
PWRGD_P3V3_M2D: length 5.5
  TOP w0.112: U86.B9 41.82,41.31 41.82,38.43 42.07,38.17 42.07,37.9 42.71,37.26 42.99,37.26 43.36,36.89 R3997.2
PWRGD_P3V3_M2D_R: length 129.9
  TOP w0.112: v2(96.74,116.66) 96.82,116.74 R3538.1 ; U22.8 v2(100.58,117.41) ; R3997.1 v2(43.36,35.43)
  IN1 w0.122: v2(96.74,116.66) 97.13,116.28 97.13,114.87 97.65,114.34 97.65,108.65 97.3,108.3 97.3,106.96 97.8,104.48 97.8,101.35 98.24,100.9 98.24,97.88 96.32,95.96 93.16,95.96 78.83,81.63 74.25,81.63 71.83,79.21 64.49,79.21 62.94,77.67 49.23,77.67 v2(48.44,76.88)
  IN2 w0.122: v2(43.36,35.43) 43.36,35.76 45.88,38.29 45.88,39.43 47.2,40.74 47.2,45.45 48.76,47.01 48.76,47.79 48.69,47.86 48.69,55.42 49.42,56.15 49.42,57.83 50.38,58.79 50.38,61.68 50.48,61.78 50.48,63.73 50.93,64.19 50.93,71.69 49.87,72.75 49.87,75.45 v2(48.44,76.88)
  BOTTOM w0.112: v2(100.58,117.41) 99.84,116.66 v2(96.74,116.66)
PWRGD_P3V3_M2E: length 6.2
  TOP w0.112: v6(41.45,42.44) U86.C10
  BOTTOM w0.112: R3998.2 41.27,38.58 41.08,38.77 v3(40.61,38.77) 40.6,38.77 41.27,39.45 41.27,41.57 41.45,41.75 v6(41.45,42.44)
PWRGD_P3V3_M2E_R: length 152.2
  TOP w0.112: U23.8 124.53,117.77 v2(124.18,118.12) ; v2(120.6,116.87) R3539.1
  IN1 w0.122: v2(120.6,116.87) 121.1,116.36 121.1,114.58 121.8,113.88 121.8,113.1 121.8,111.58 122.15,108.1 122.51,106.77 122.51,103.98 122.2,103.67 122.2,97.65 103.71,79.15 96.23,79.15 88.75,71.68 78.32,71.68 75.32,68.68 v2(73.86,68.68)
  IN2 w0.122: v2(42.55,33.83) 42.55,32.45 44.9,30.09 49.69,30.09 60.5,40.9 60.5,44.59 61.26,45.35 64.95,45.35 65.03,45.44 66.51,45.44 73.86,52.79 v2(73.86,68.68)
  BOTTOM w0.112: v2(124.18,118.12) 124.59,117.71 124.59,117.38 124.08,116.87 v2(120.6,116.87) ; v2(42.55,33.83) 42.29,33.83 41.55,34.58 41.55,36.57 R3998.1
PWRGD_P3V3_M2F: length 5.1
  TOP w0.112: v6(41.96,41.94) U86.C8
  BOTTOM w0.112: R3999.2 42.32,37.84 41.83,38.33 v3(41.83,39.21) 41.83,41.81 v6(41.96,41.94)
PWRGD_P3V3_M2F_R: length 166.5
  TOP w0.112: v2(147.12,117.94) 148.49,117.94 148.84,118.29 151.77,118.29 152.3,118.07 152.51,117.87 152.51,116.95 152.12,116.56 U24.8 ; R3540.1 147.85,116.32 v2(147.66,116.5)
  IN1 w0.122: v2(69.95,49.5) 71.03,49.5 73.04,51.52 74.18,51.52 80.77,58.1 90.11,58.1 90.75,58.75 93.16,58.75 93.17,58.76 93.43,58.76 96.67,62 97.5,62 98.17,62.67 98.39,62.67 101.85,66.12 108.05,66.12 147.31,105.38 147.31,109.94 147.02,110.65 146.27,111.4 146.27,114.19 147.66,115.58 v2(147.66,116.5) 147.65,116.51 147.09,116.51 146.57,117.03 146.57,117.39 v2(147.12,117.94)
  IN2 w0.122: v2(43.84,34.65) 43.84,31.76 45.07,30.54 49.51,30.54 59.73,40.75 59.73,44.58 61.02,45.86 66.31,45.86 v2(69.95,49.5)
  BOTTOM w0.112: R3999.1 42.32,36.71 42.91,36.11 42.91,35.15 43.41,34.65 v2(43.84,34.65)
PWRGD_P3V3_M2G: length 7.9
  TOP w0.112: v6(43.03,43.54) 43.03,43.02 U86.E7
  IN1 w0.122: v6(43.03,43.54) 43.03,42.46 43.48,42.01 v2(43.48,39.11)
  BOTTOM w0.112: R4005.2 44.4,37.45 v3(43.8,38.04) 43.51,38.33 43.51,39.08 v2(43.48,39.11)
PWRGD_P3V3_M2G_R: length 182.9
  IN1 w0.122: v2(45.27,31.06) 57.16,31.06 59.7,33.61 65.42,33.61 65.83,34.02 69.9,34.02 70.54,34.66 75.12,34.66 87.45,46.98 91.41,46.98 92.22,47.78 95.46,47.78 112.36,54.79 115.74,54.79 148.17,87.21 152.55,87.21 152.86,86.91 154.16,86.91 157.41,90.15 157.41,99.59 165.44,107.62 165.44,112.27 166.03,112.87 166.03,115.69 165.55,116.18 v2(165.55,118.86)
  IN2 w0.122: v2(45.33,34.65) 45.33,31.12 v2(45.27,31.06) ; v2(165.55,118.86) 165.55,117.47 165.17,117.09 163.39,117.09 161.47,119.01 161.47,119.46 v2(161.03,119.9)
  BOTTOM w0.112: R4005.1 44.8,36.05 44.9,35.95 44.9,35.08 v2(45.33,34.65) ; U33.8 161.5,119.43 v2(161.03,119.9) ; R3546.1 165.25,119.16 v2(165.55,118.86)
PWRGD_P3V3_M2H: length 6.7
  TOP w0.112: U86.D6 v6(43.98,42.44)
  BOTTOM w0.112: v6(43.98,42.44) 43.98,42.02 44.17,41.83 44.17,40.18 v3(45.23,39.12) 45.41,38.94 R4004.2
PWRGD_P3V3_M2H_R: length 154.5
  TOP w0.112: v2(136.78,118.99) 137.12,118.65 137.12,116.44 v2(136.69,116)
  IN1 w0.122: v2(136.69,116) 136.39,115.7 136.39,112.02 137.06,110.38 137.12,110.33 137.12,101.86 106.08,70.82 98.27,70.82 91.06,63.61 84.37,63.61 83.49,64.49 79.93,64.49 79.07,63.63 72.96,63.63 69.88,60.54 69.88,56.77 v2(69.44,56.34)
  IN2 w0.122: v2(69.44,56.34) 69.44,51.59 67.61,49.76 67.61,48.1 66.96,47.44 66.2,47.44 66.11,47.35 61.73,47.35 59.28,44.89 59.28,40.9 52.59,34.22 46.85,34.22 v2(46.39,34.68)
  BOTTOM w0.112: U32.8 133.76,116.51 133.33,116.94 133.33,118.36 133.96,118.99 v2(136.78,118.99) ; R3545.1 137.1,116.41 v2(136.69,116) ; v2(46.39,34.68) 45.96,34.68 45.41,35.23 R4004.1
PWRGD_P3V3_M2I: length 10.1
  TOP w0.112: v6(43.5,42.94) 42.99,42.44 U86.D7
  IN1 w0.122: v2(47.07,39.1) 47.07,39.52 46.87,39.71 45.07,39.71 44.16,40.63 44.16,41.66 43.5,42.33 v6(43.5,42.94)
  BOTTOM w0.112: v2(47.07,39.1) 47.26,39.1 48.46,37.9 R4003.2
PWRGD_P3V3_M2I_R: length 145.1
  IN1 w0.122: v2(112.57,118.83) 112.57,116 v2(112.71,115.86) 112.18,115.33 112.18,109.23 112.22,109.19 112.78,108.36 113.47,106.68 113.48,106.67 113.53,106.56 113.53,105.09 113.86,104.28 113.86,102.09 112.81,101.04 112.81,92.54 102.49,82.21 94.64,82.21 87.15,74.72 77.63,74.72 74.06,71.15 72.17,70.37 69.69,70.37 68.78,71.28 65.42,71.28 63.57,69.44 v2(55.12,69.44)
  IN2 w0.122: v2(48.53,34.75) 52.45,34.75 56.66,38.97 56.66,44.86 55.06,46.47 55.06,50.46 56.06,51.46 56.06,55.19 55.35,55.9 55.35,57.36 54.92,57.78 54.92,69.24 v2(55.12,69.44)
  BOTTOM w0.112: v2(48.53,34.75) 48.46,34.82 R4003.1 ; R3544.1 v2(112.71,115.86) ; U31.8 109.91,116.16 109.59,116.49 109.59,117.72 110.34,118.48 112.21,118.48 v2(112.57,118.83)
PWRGD_P3V3_M2J: length 6.4
  TOP w0.112: R4002.2 46.43,37.17 46.33,37.27 45.46,37.27 44.55,38.17 44.55,39.33 44.25,39.63 43.66,39.63 42.95,40.34 U86.A7
PWRGD_P3V3_M2J_R: length 135.8
  TOP w0.112: v2(45.86,35.47) R4002.1
  IN1 w0.122: v2(89.96,103.9) 89.96,98.2 78.48,86.72 77.74,86.72 77.03,86.01 77.03,85.11 71.57,79.65 64.31,79.65 62.83,78.17 49.93,78.17 v2(49.56,78.54)
  IN2 w0.122: v2(89.96,103.9) 90.19,104.12 90.19,108.36 87.42,111.13 87.42,115.13 88.07,115.77 v2(88.37,115.77) 88.37,117.7 v2(88.4,117.73) ; v2(45.86,35.47) 46.85,36.47 53.08,36.47 56.23,39.62 56.23,44.07 53.79,46.51 53.79,53.62 54.02,53.84 54.02,56.64 53.42,57.23 53.42,71.62 54.67,72.86 54.67,75.95 52.16,78.45 49.64,78.45 v2(49.56,78.54)
  BOTTOM w0.112: U30.8 84.27,116.15 84.18,116.24 84.18,117.86 84.73,118.41 86.27,118.41 86.95,117.73 v2(88.4,117.73) ; R3543.1 v2(88.37,115.77)
PWRGD_P3V3_M2K: length 17.1
  TOP w0.112: U86.G15 39.07,43.94 39.22,44.09 v6(39.49,44.09) ; R4001.2 38.13,37.02 39.22,38.11 v2(39.22,38.65)
  IN2 w0.122: v2(39.22,38.65) 39.22,39.43 36.76,41.9 36.76,45.31 37.97,46.52 38.3,46.52 38.57,46.79 39.16,46.79 39.94,46.01 39.94,44.54 v6(39.49,44.09)
PWRGD_P3V3_M2K_R: length 126.3
  TOP w0.112: v2(39.03,34.65) 38.71,34.65 38.13,35.23 R4001.1
  IN1 w0.122: v2(42.92,85.04) 43.41,85.52 44.65,85.52 47.46,88.33 50.26,88.33 50.31,88.35 51.34,89.38 52.18,91.42 61.64,100.87 61.64,100.88 61.88,101.12 61.88,110.89 61.64,111.69 61.64,112.02 61.68,112.06 61.68,115.51 61.88,115.71 v2(62.65,115.71)
  IN2 w0.122: v2(62.65,115.71) 62.77,115.83 62.77,117.96 v2(62.6,118.13) ; v2(39.03,34.65) 39.03,33.76 40.62,32.17 40.99,32.17 41.66,32.85 41.66,33.57 42.54,34.45 43,34.45 43.83,35.28 43.83,35.46 45.46,37.09 51.33,37.09 55.19,40.95 55.19,44.3 53.36,46.12 53.36,53.87 53.54,54.05 53.54,56.5 53,57.05 53,71.8 54.07,72.87 54.07,75.94 51.99,78.02 49.45,78.02 47.54,79.93 47.54,82.02 44.89,84.66 43.3,84.66 v2(42.92,85.04)
  BOTTOM w0.112: v2(62.6,118.13) 62.24,118.49 60.67,118.49 59.83,117.65 59.83,116.41 60.08,116.16 U29.8 ; v2(62.65,115.71) R3542.1
PWRGD_P3V3_M2L: length 5.7
  TOP w0.089: U86.V10 41.15,49.75 41.15,50.81
  TOP w0.112: 41.15,50.81 39.21,52.75 39.21,53.27 38.96,53.52 R4000.2
PWRGD_P3V3_M2L_R: length 113.6
  TOP w0.112: R4000.1 38.96,55.32 38.04,56.24 38.04,57.19 38.33,57.48 38.33,57.83 v2(38.83,58.34) ; v2(41.32,118.48) 41.12,118.67 38.79,118.67 38.01,119.45 v2(37.84,119.45)
  IN1 w0.122: v2(39.19,89.31) 46.58,96.7 v2(46.58,108.23) ; v2(55.49,55.05) 55.49,54.52 55.09,54.12 53.57,54.12 53.13,53.67 51.71,53.67 50.7,54.68 50.7,55.13 49.12,56.7 49.12,57.84 47.98,58.98 45.28,58.98 44.47,58.17 42.41,58.17 41.86,57.62 41.18,57.62 40.86,57.94 39.23,57.94 v2(38.83,58.34)
  IN2 w0.122: v2(41.32,118.48) 41.19,118.48 40.65,117.94 40.65,116.69 41.3,116.04 42.7,116.04 43.32,115.42 43.63,114.67 43.63,113.7 45.41,109.4 v2(46.58,108.23) ; v2(39.19,89.31) 39.01,89.13 39.01,87.81 41.33,85.5 43.13,85.5 43.53,85.1 46.11,85.1 48.76,82.46 48.76,79.68 49.05,79.38 52.44,79.38 55.52,76.3 55.52,72.36 54.49,71.33 54.49,57.6 54.91,57.18 54.91,55.63 v2(55.49,55.05)
  BOTTOM w0.112: R3541.1 v2(41.32,118.48) ; v2(37.84,119.45) 37.81,119.45 37.39,119.03 37.39,118.6 37.49,118.5 U28.8
PWRGD_P3V3_STBY: length 261.1
  TOP w0.112: v2(173.66,17.37) 173.73,17.44 174.62,17.44 PR107.2 175.37,17.29 175.42,17.29 176,17.87 176.23,17.96 PU101.10 ; PU601.10 188.57,32.41 187.31,31.16 v2(187.31,31.07) ; v2(25.74,17.24) 25.74,17.73 R3474.1 ; R3551.1 196.63,34.82 195.91,34.82 195.56,35.17 v2(195.56,35.74) ; v2(162.84,15.42) 163.08,15.42 163.62,15.97 163.62,16.62 164.8,17.79 165.22,17.96 PU201.10
  IN1 w0.122: v2(25.74,17.24) 25.74,13.17 29.69,9.21 37.22,9.21 38.25,8.19 45.73,8.19 46.41,7.51 65.22,7.51 67.6,5.13 80.12,5.13 82.57,2.68 94.48,2.68 94.93,2.23 159.44,2.23 160.65,3.44 162.13,7.01 162.13,14.88 162.67,15.42 v2(162.84,15.42) ; v2(173.66,17.37) 173.74,17.29 175.12,17.29 176.16,16.25 176.16,14.98 174.76,13.57 174.76,11.29 176.12,9.93 176.71,9.93 176.73,9.91 176.74,9.91 177.16,9.49 182.33,9.49 186.48,13.64 186.48,16.52 186.19,16.81 186.19,17.77 186.59,18.17 186.59,18.48 186.34,18.73 186.34,25.69 187.65,27 187.65,30.73 v2(187.31,31.07)
  IN2 w0.122: v2(162.84,15.42) 162.84,12.02 165.56,9.3 171.26,9.3 173.21,11.24 173.21,16.56 173.7,17.06 173.7,17.33 v2(173.66,17.37) ; v2(195.56,35.74) 195.44,35.62 195.44,33.91 194.46,32.93 194.46,31.2 196.17,29.49 196.17,28.22 193.47,25.52 186.7,25.52 186.37,25.85 186.37,27.7 187.6,28.92 187.6,30.79 v2(187.31,31.07)
RESERVED_M2A_PLN_N: length 11
  TOP w0.112: R4098.2 21.18,123.91 J4.B8 21.18,126.87 22.34,128.03 22.34,128.85 23.32,129.83 v2(23.36,129.83)
  BOTTOM w0.112: v2(23.36,129.83) 23.95,130.42 v3(23.95,131.48) 23.95,132.54 24.1,132.69 R4101.1
RESERVED_M2B_PLN_N: length 30.1
  TOP w0.112: J4.A8 45.18,126.95 44.58,127.55 v2(43.78,127.55)
  IN2 w0.122: v2(43.78,127.55) 43.85,127.62 43.85,128.97 43.35,129.47 43.35,130.87 43.72,131.24 45.2,131.24 46.09,130.35 49.35,130.35 50.67,131.67 50.67,133.26 51.04,133.64 v2(51.04,134.79)
  BOTTOM w0.112: v2(51.04,134.79) 50.57,134.79 50.44,134.92 50.44,141.54 50.9,141.99 R4105.1 ; v3(49.73,144.33) 50.07,143.99 R4105.1 ; R4105.1 R4102.2
RESERVED_M2C_PLN_N: length 31.5
  TOP w0.112: v2(61.95,143.46) 61.28,142.8 59.9,142.8 57.05,139.94 57.05,137.62 57.68,136.98 v1(58.44,136.98) 58.57,136.85 63.05,136.85 63.26,136.64 64.12,136.64 65.23,135.53 65.23,130.01 65.62,129.62 67.28,129.62 68.73,128.17 68.73,127.55 69.18,127.1 J36.B8
  BOTTOM w0.112: v2(61.95,143.46) R4109.1 R4106.2
RESERVED_M2D_PLN_N: length 38.4
  TOP w0.112: v2(69.39,143.31) 69.64,143.31 70.2,142.75 78.23,142.75 79.32,141.66 v1(79.32,138.58) 79.32,137.98 81.18,136.12 86.79,136.12 87,135.91 88.21,135.91 88.72,135.4 88.72,131.16 90.27,129.62 91.09,129.62 92.38,128.33 92.38,127.54 93.18,126.74 J36.A8
  BOTTOM w0.112: v2(69.39,143.31) 69.77,143.69 R4113.1 R4110.2
RESERVED_M2E_PLN_N: length 40.9
  TOP w0.112: R4114.2 R4117.1 132.11,144.04 v1(132.25,143.9) 132.42,143.73 132.42,141.51 129.82,138.92 129.47,138.92 128,137.44 126.86,137.44 126.54,137.11 120.21,137.11 118.83,135.73 117.21,135.73 116.07,136.87 114.49,136.87 114.08,136.46 114.08,135.1 112.95,133.97 112.95,127.76 113.71,127.01 115.07,127.01 115.31,127.25 116.74,127.25 117.18,126.8 J38.B8
RESERVED_M2F_PLN_N: length 23.7
  TOP w0.112: v2(143.34,142.84) 143.34,142.37 v1(141.4,140.42) 141.02,140.05 141.02,138.72 140.34,138.04 139.93,138.04 139.5,137.61 139.5,135.91 138.73,135.14 138.33,135.14 137.34,134.15 137.34,131.2 138.14,130.41 138.84,130.41 141.18,128.07 J38.A8
  BOTTOM w0.112: v2(143.34,142.84) 143.63,143.13 R4121.1 R4118.2
RESERVED_M2G_PLN_N: length 13.9
  IN1 w0.122: v2(165.61,132.03) 166.79,132.03 168.56,130.25 172.1,130.25 172.79,129.57 172.79,128.16 v2(172.44,127.8)
  BOTTOM w0.112: R4125.1 v2(172.44,127.8) 172.43,127.8 R4122.2 v3(173.6,127.14) ; J8.B8 165.92,133.22 165.92,132.34 v2(165.61,132.03)
RESERVED_M2H_PLN_N: length 13.3
  TOP w0.112: v2(145.73,142.76) 145.73,140.73 v1(144.9,139.9) 142.44,137.44 142.44,135.44 142.3,135.3 141.92,134.92 v2(141.92,134.86)
  BOTTOM w0.112: J8.A8 v2(141.92,134.86) ; R4126.2 R4129.1 146.51,143.54 v2(145.73,142.76)
RESERVED_M2I_PLN_N: length 22
  TOP w0.112: R4130.2 R4133.1 128.13,143.82 127.89,143.59 127.26,143.59 127.14,143.47 127.14,141.59 v1(126.8,141.24) 125.71,140.16 125.71,139.4 124.93,138.62 v2(124.93,138.16)
  IN1 w0.122: v2(117.63,137.63) 117.7,137.63 118.8,138.73 119.57,138.73 120.34,139.5 123.6,139.5 v2(124.93,138.16)
  BOTTOM w0.112: J34.B8 117.92,135.11 117.41,135.62 117.41,137.41 v2(117.63,137.63)
RESERVED_M2J_PLN_N: length 32.6
  TOP w0.112: v2(70.96,143.37) 71.32,143.01 78.73,143.01 80.09,141.66 v1(80.09,140.06) 80.09,137.59 81.29,136.39 87.04,136.39 87.25,136.18 90.75,136.18 91.72,135.21 93.65,135.21 v2(94.08,134.78)
  BOTTOM w0.112: J34.A8 93.92,134.67 94.03,134.78 v2(94.08,134.78) ; R4134.2 R4137.1 71.45,143.85 v2(70.96,143.37)
RESERVED_M2K_PLN_N: length 17.9
  TOP w0.112: v2(70.36,135.35) 70.36,136.09 71.62,137.36 v1(71.62,138.71) 71.62,139.89 69.82,141.68 66.5,141.68 65.88,142.3 v2(64.82,142.3)
  BOTTOM w0.112: R4138.2 R4141.1 v2(64.82,142.3) ; v2(70.36,135.35) 70.09,135.08 70.09,134.44 69.92,134.28 J6.B8
RESERVED_M2L_PLN_N: length 23.6
  TOP w0.112: v2(46.69,145.36) 45.52,144.19 v2(45.52,142.16)
  IN1 w0.122: v2(45.52,142.16) 46.51,141.17 46.51,137.48 46.02,136.99 46.02,134.76 45.45,134.18 45.45,132.31 46.51,131.25 v2(46.93,131.25)
  BOTTOM w0.112: R4145.1 47.37,145.35 46.7,145.35 v2(46.69,145.36) v3(44.73,145.36) ; R4142.2 47.81,129.65 47.41,130.05 47.41,130.77 v2(46.93,131.25) 45.92,132.26 J6.A8
RST_I2C_MUX1_N: length 59.7
  TOP w0.112: R3808.2 C1134.1 22.51,80.51 22.86,80.16 22.86,78.94 22.25,78.33 22.25,77.42 21.3,76.46 U88.3 21.3,74.07 26.08,69.28 35.98,69.28 v2(36.88,70.18)
  IN2 w0.122: v2(35.54,59.08) 36.37,59.08 37.53,60.24 37.53,62.93 36.88,63.57 v2(36.88,70.18)
  BOTTOM w0.112: v2(35.54,59.08) 34.7,59.08 33.08,57.46 33.08,53.37 33.64,52.81 33.64,50.34 29.96,46.67 29.96,44.24 30.44,43.76 31.63,43.76 R4028.1
RST_I2C_MUX1_N_R: length 6.4
  TOP w0.112: U86.H17 v6(37.95,44.95)
  BOTTOM w0.112: R4028.2 32.71,43.99 v3(34.04,43.99) 34.04,44.24 34.86,45.05 37.85,45.05 v6(37.95,44.95)
RST_I2C_MUX2_N: length 50.5
  TOP w0.112: R3821.2 C1137.1 30.63,76.62 30.25,76.24 v1(30.25,74.63) 30.25,73.88 29.5,73.13 U89.3 29.5,71.04 30.83,69.71 35.22,69.71 v2(36.19,70.68)
  IN2 w0.122: v2(36.26,59.67) 36.35,59.67 37.06,60.38 37.06,62.41 36.19,63.28 v2(36.19,70.68)
  BOTTOM w0.112: v2(36.26,59.67) 34.46,59.67 32.61,57.82 32.61,53.12 33.23,52.5 33.23,50.49 29.57,46.83 29.57,43.03 30.71,41.88 31.83,41.88 R4029.1
RST_I2C_MUX2_N_R: length 8.4
  TOP w0.112: U86.F16 39.19,43.44 v6(39.26,43.51)
  IN1 w0.122: v2(35.14,43.08) 35.32,43.08 35.74,42.66 36.48,42.66 37.32,43.51 v6(39.26,43.51)
  BOTTOM w0.112: v2(35.14,43.08) 33.99,41.94 R4029.2
RST_I2C_MUX3_N: length 41.4
  TOP w0.112: v2(37.54,70.71) 36.82,71.43 U90.3 36.82,73.11 37.59,73.88 v1(37.59,74.6) 37.59,76.24 37.94,76.6 C1140.1 38.18,77.58 R3834.2 ; v2(31.01,41.41) 31.54,41.94 R4030.1
  IN2 w0.122: v2(37.54,70.71) 37.54,63.68 37.95,63.27 37.95,60 36.24,58.29 36.24,52.33 31.82,47.91 31.82,45.64 31.94,45.53 31.94,42.33 v2(31.01,41.41)
RST_I2C_MUX3_N_R: length 5.5
  TOP w0.089: 36.08,42.67 36.36,42.95 36.36,43.21 36.6,43.44 U86.F18
  TOP w0.112: R4030.2 33.23,41.94 33.36,42.07 v1(33.91,42.07) 33.94,42.07 34.28,42.41 34.49,42.49 35.29,42.65 35.3,42.68 35.49,42.71 35.68,42.71 35.72,42.67 36.08,42.67
RST_I2C_MUX4_N: length 14.2
  TOP w0.112: U91.3 23.07,36.61 23.68,37.22 v1(23.96,37.22) 24,37.26 24,38.91 24.3,39.21 R3847.2 24.54,40.23 ; 24.54,40.23 v2(25.22,39.55) ; 24.54,40.23 C1143.1
  BOTTOM w0.112: v2(25.22,39.55) 28.57,39.55 29.89,40.87 R4031.1
RST_I2C_MUX4_N_R: length 7.4
  TOP w0.112: U86.E17 37.96,42.94 38.55,42.94 v6(38.56,42.96)
  IN1 w0.122: v2(35.41,41.4) 35.92,41.91 36.32,41.91 37.35,42.94 38.54,42.94 v6(38.56,42.96)
  BOTTOM w0.112: v2(35.41,41.4) 34.87,40.87 R4031.2
RST_I2C_MUX5_N: length 42.3
  TOP w0.112: U92.3 44.41,72.92 44.79,73.29 44.79,73.64 45.19,74.05 45.19,76.42 45.37,76.6 C1146.1 R3860.2 46.79,77.29 47.15,77.65 49.35,77.65 50.21,78.51 v2(50.21,78.89) ; v2(54.25,53.14) 54.1,52.98 R4032.1
  IN2 w0.122: v2(50.21,78.89) 52.33,78.89 55.09,76.12 55.09,72.68 53.91,71.5 53.91,57.46 54.46,56.91 54.46,53.34 v2(54.25,53.14)
RST_I2C_MUX5_N_R: length 10.9
  TOP w0.112: U86.N1 46.03,47.02 47.42,47.02 48.06,47.65 48.54,47.65 49.53,48.64 v1(49.53,49.33) 49.53,51.99 50.52,52.98 R4032.2
RST_I2C_MUX6_N: length 78.1
  TOP w0.112: U93.3 29.02,92.05 29.82,92.85 29.82,95.5 30.14,95.83 C1149.1 R3873.2 30.38,96.82 29.74,97.46 29.74,97.94 v2(29.39,98.29)
  IN2 w0.122: v2(29.39,98.29) 29.65,98.29 32.97,94.97 32.97,92.46 34.44,90.98 36.68,90.98 39.89,89.65 41.76,87.78 41.76,87.38 42.28,86.86 42.41,86.86 43.69,85.57 46.56,85.57 49.22,82.91 49.22,80.07 49.47,79.82 52.6,79.82 56.07,76.35 56.07,72.3 55.23,71.46 55.23,69.97 55.84,69.36 55.84,64.94 55.49,64.6 55.49,58.3 55.84,57.95 55.84,56.06 56.42,55.48 56.42,55.44 56.49,55.37 56.49,51.28 56.42,51.21 56.42,50.1 v2(56.47,50.1)
  BOTTOM w0.112: R4033.1 54.28,47.96 56.38,50.05 56.42,50.05 56.42,50.1 v2(56.47,50.1)
RST_I2C_MUX6_N_R: length 12.7
  TOP w0.112: U86.K5 43.77,45.26 v6(43.77,44.54)
  BOTTOM w0.112: R4033.2 52.51,48.41 v3(49.52,48.41) 49.09,48.41 47.32,46.63 45.58,46.63 45.48,46.53 44.49,46.53 43.77,45.81 v6(43.77,44.54)
RST_I2C_MUX7_N: length 49.2
  TOP w0.112: U108.3 v2(31.17,30.98)
  IN2 w0.122: v2(42.95,38.18) 43.72,38.18 44.54,39 44.54,41.2 45.67,42.33 45.67,46.1 47.14,47.58 47.14,54.35 v2(46.81,54.68) ; v2(31.17,30.98) 31.69,30.45 31.69,28.22 32.23,27.68 v2(32.92,27.68)
  BOTTOM w0.112: R4382.1 48.16,54.28 47.21,54.28 v2(46.81,54.68) ; R4371.2 32.36,34.13 31.32,33.09 31.32,32.27 31.61,31.98 C1235.1 31.77,31.58 v2(31.17,30.98) ; v2(32.92,27.68) 33.29,27.68 37.74,32.13 38.46,32.13 40.2,33.88 41.52,33.88 42,33.4 43.2,33.4 44.28,34.47 44.28,34.91 43.87,35.31 43.87,36.15 42.95,37.07 v2(42.95,38.18)
RST_I2C_MUX7_N_R: length 8.3
  TOP w0.112: U86.V2 45.15,49.14 45.15,48.54 v5(45,48.39)
  BOTTOM w0.112: v5(45,48.39) 45,48.71 45.24,48.96 46.44,48.96 46.98,49.49 v3(46.98,50.76) 46.98,52.03 R4382.2
RST_PE_BUF_N_R2: length 4.4
  TOP w0.112: U63.2 v1(85.24,33.83) 84.54,33.14 R3212.2 84,34.42 R4328.2
RST_PE_MOS_G: length 4.4
  TOP w0.112: Q9.5 Q9.6 81.32,26.94 81.43,26.83 v1(81.43,26.11) 81.43,25.73 81.31,25.6 R3216.2
RST_PE_MOS_N_R2: length 4.5
  TOP w0.112: Q9.2 79.5,29.31 79.98,29.79 80.67,29.79 80.9,30.02 v1(80.9,30.05) R3213.2 R3217.2
RST_PE_N: length 103.8
  TOP w0.089: U86.E18 37.45,42.96 37.17,43.24 36.81,43.24 36.56,42.99 36.56,42.79 36.03,42.26 35.05,42.26 34.27,41.48 31.68,41.48 31.64,41.44 31.64,41.39 31.25,40.99 31.25,40.98 31.14,40.88 30.68,40.88 v2(30.17,40.37)
  TOP w0.112: v2(68.98,21.26) 69.36,21.26 R3050.1 ; v2(82.32,23.7) 82.32,30.12 83.19,30.99 83.19,33.13 R3212.1 83.2,33.42 82.68,33.94 R3242.1 81.63,33.45 81.45,33.45 80.9,32.9 R3213.1
  IN1 w0.122: v2(68.98,21.26) 69.36,21.26 71.54,23.44 82.07,23.44 v2(82.32,23.7)
  IN2 w0.122: v2(30.17,40.37) 29.53,39.73 29.53,35.47 29.75,35.25 29.75,34 32.26,31.49 32.26,29.33 33.37,28.23 33.37,25.27 32.41,24.32 32.41,18.14 v2(32.73,17.82)
  BOTTOM w0.112: v2(32.73,17.82) 34.7,17.82 35.28,18.41 40.35,18.41 46.81,24.87 56.21,24.87 57.77,23.3 67.49,23.3 68.98,21.82 v2(68.98,21.26)
RST_PE_N_R1: length 18.1
  TOP w0.112: v4(66.9,6.59) 66.9,10.05 69.76,12.91 R3049.2 69.24,19.16 69.24,20.34 R3050.2
  BOTTOM w0.112: J41.34 v4(66.9,6.59)
RST_PE_PESW_GPIO15_N: length 181.2
  TOP w0.112: R3215.2 79.76,32.27 79.34,32.69 79.34,33.44 79.76,33.86 v2(80.42,33.86) ; U34.N30 v6(194.59,87.02)
  IN1 w0.122: v2(80.42,33.86) 80.72,33.86 84.48,37.62 84.73,37.72 86.32,37.72 89.14,38.89 90.59,38.89 91.65,39.94 91.65,40.36 92.45,41.17 93.71,41.17 95.8,42.03 98.78,44.02 112.6,49.74 119.14,49.74 134.99,65.59 152.33,65.59 152.64,65.28 154.25,65.28 160.07,71.1 160.07,80.59 162.2,82.72 162.2,94.88 165.07,97.76 165.07,99.08 166.32,100.33 191.84,100.33 196.05,96.11 196.05,95.93 197.41,94.58 199.7,94.58 200.42,93.86 202.33,93.86 203.34,92.86 v2(203.34,92.43)
  IN2 w0.089: 196.22,87.08 195.76,86.62 195,86.62 194.6,87.02
  IN2 w0.102: 196.22,87.08 197.46,87.08 198,87.62 198.75,87.62 199.68,88.55 ; 194.6,87.02 v6(194.59,87.02)
  IN2 w0.122: 199.68,88.55 199.99,88.55 203.07,91.63 203.07,92.1 203.34,92.37 v2(203.34,92.43)
RST_PE_PESW_GPIO28_N: length 21.2
  TOP w0.089: v6(197.59,93.02) 197.49,92.92 197.49,88.83 197.18,88.52 U34.L33
  TOP w0.112: R4336.2 v1(187.39,101.7) 187.39,101.4 187.86,100.94 189.5,100.94 v2(190.56,99.88)
  IN1 w0.122: v2(190.56,99.88) 190.87,99.57 192.28,99.57 195.04,96.81 195.04,95.65 195.42,95.27 196.09,95.27 196.48,94.88 196.71,94.88 196.89,94.71 196.89,93.93 197.59,93.23 v6(197.59,93.02)
RST_PE_PESW_GPIO29_N: length 24
  TOP w0.112: R4335.2 191.07,102.89 191.28,103.1 v2(192.27,103.1) ; v6(191.66,87.09) U34.M28
  IN2 w0.122: v6(191.66,87.09) 191.61,87.09 191.21,87.49 190.3,87.49 190.04,87.74 190.04,88.31 189.9,88.45 189.33,88.45 189.12,88.65 189.12,89.12 188.77,89.47 188.34,89.47 188.12,89.69 188.12,93.3 188.34,93.51 188.94,93.51 189.15,93.73 189.15,94.33 189.25,94.43 189.77,94.43 191.09,95.75 191.09,103.02 191.27,103.21 192.17,103.21 v2(192.27,103.1)
RST_PE_PESW_GPIO30_N: length 29.5
  TOP w0.112: U34.M30 v6(194.59,88.02) ; R4334.2 188.52,101.59 188.73,101.38 190.69,101.38 191.05,101.02 194.79,101.02 195.79,102.01 v1(196.48,102.01) 197.03,102.01 v2(198.04,101)
  IN2 w0.122: v6(194.59,88.02) 194.01,88.02 192.57,89.47 192.57,90.04 191.95,90.66 191.95,92.6 192.05,92.71 192.05,93.95 193.54,95.45 193.54,96.31 198.04,100.81 v2(198.04,101)
RST_PE_PESW_GPIO31_N: length 24.9
  TOP w0.112: U34.N28 192.49,86.92 192.49,88.69 192.16,89.02 v6(189.59,89.02) ; v2(192.66,102.43) 192.66,102.16 192.22,101.73 v1(191.93,101.73) 191.85,101.81 190.2,101.81 189.62,102.38 R4333.2
  IN2 w0.122: v2(192.66,102.43) 192.1,101.87 192.1,96.8 191.4,96.1 191.4,95.52 190.14,94.26 190.14,93.75 189.89,93.5 189.5,93.5 189.18,93.19 189.18,89.43 v6(189.59,89.02)
RST_PE_PESW_GPIO35_N: length 39.1
  TOP w0.089: 197.85,90.92 197.68,90.75 197.68,88.62
  TOP w0.112: v6(198.59,98.02) 198.59,98.59 197.8,99.38 190.25,99.38 189.09,100.54 187.12,100.54 v1(185.95,101.71) 185.89,101.77 185.89,102.5 R4332.2 ; 197.68,88.62 197.58,88.52 197.58,87.14 197.39,86.94 195.34,86.94 195.09,86.69 U34.N31 ; 197.85,90.92 197.95,91.02 v6(198.59,91.02)
  IN2 w0.089: 194.23,90.61 193.44,90.61 193.2,90.86 193.2,91.71 193.42,91.93
  IN2 w0.122: 193.42,91.93 194.1,92.61 194.1,93.95 195.66,95.52 195.7,95.52 196.09,95.91 196.09,96.06 196.64,96.61 197.76,96.61 198.16,97.01 198.16,97.59 v6(198.59,98.02) ; 194.23,90.61 194.23,90.61 197.13,90.61 197.54,91.02 v6(198.59,91.02)
RST_PE_PESW_GPIO_N_R: length 168.7
  TOP w0.112: v2(182.77,98.92) 183.59,98.92 184.76,100.09 184.76,103.42 184.9,103.56 C1236.1 185.36,103.69 R4332.1 R4336.1 R4334.1 R4333.1 R4335.1 ; v2(80.76,27.51) 80.62,27.65 79.26,27.65 78.85,28.06 Q9.3 78.85,29.14 78.69,29.3 v1(78.69,30.05) R3148.1 78.71,31.3 R3215.1 80.15,31.3 80.26,31.4 80.26,32.87 R3242.2
  IN2 w0.122: v2(108.04,34.55) 107.47,35.12 96.16,35.12 95.95,34.91 91.76,34.91 88.83,31.98 84.79,31.98 80.76,27.95 v2(80.76,27.51)
  BOTTOM w0.112: v2(182.77,98.92) 182.77,98.62 183.35,98.04 183.35,96.95 182.9,96.5 161.11,96.5 160.34,95.73 151.22,95.73 145.12,89.63 145.12,79.39 105.96,40.23 105.96,36.35 107.01,35.3 107.28,35.3 v2(108.04,34.55)
RST_PE_PESW_RSTB_N: length 129
  TOP w0.112: U34.AG32 v6(196.59,72.02) ; R3214.2 v2(93.88,32.88)
  IN2 w0.122: v6(196.59,72.02) 197.13,71.48 197.13,69.89 197.54,69.48 197.7,69.48 198,69.19 198,63.85 194.66,60.51 182.97,60.51 179.31,56.86 173.82,54.59 170.76,51.52 168.21,50.47 164.66,50.47 163.5,49.3 153.9,49.3 136.06,31.46 106.39,31.46 103.59,34.26 99.43,34.26 98.89,33.72 94.72,33.72 v2(93.88,32.88)
RST_PE_PESW_RSTB_N_R: length 3.7
  TOP w0.112: U63.4 v1(91.01,32.88) R3214.1 R3220.1
RST_PE_SLOT1_1_RESET_N: length 86.4
  TOP w0.112: R4337.1 29.11,45.17 28.26,46.02 24.54,46.02 24.44,46.12 v2(24.28,46.12)
  IN1 w0.122: v2(64.5,6.18) 63.63,7.05 45.94,7.05 45.51,7.48 37.78,7.48 36.65,8.62 27.63,8.62 v2(24.58,11.67)
  IN2 w0.122: v2(24.28,46.12) 24.28,45.51 24.7,45.09 24.7,43.58 23.67,42.54 23.67,38.2 23.89,37.98 23.89,37.61 23.67,37.39 23.67,37.03 24.07,36.63 24.07,35.34 24.9,34.51 24.9,31.7 25.78,30.82 25.78,26.81 25.58,26.61 25.58,25.41 25.89,25.1 25.89,23.51 25.88,23.49 25.88,23.24 24.48,21.84 24.48,11.77 v2(24.58,11.67)
  BOTTOM w0.112: J41.40 v2(64.5,6.18)
RST_PE_SLOT1_1_RESET_N_R: length 9.4
  TOP w0.112: v6(37.95,43.94) 37.95,43.93 U86.F17 ; R4337.2 31.35,45.17 v2(31.49,45.03)
  IN1 w0.122: v2(31.49,45.03) 31.49,44.57 31.87,44.19 33.08,44.19 33.6,43.66 36.77,43.66 37.05,43.94 v6(37.95,43.94)
RST_PESW_M2A_LVC_N: length 180.6
  TOP w0.112: v2(32,124.6) 31.99,124.6 31.68,124.91 J4.B50
  IN1 w0.122: v2(32,124.6) 31.89,124.72 31.89,128.08 32.09,128.56 34.37,130.84 34.43,130.98 34.43,132.39 33.39,133.42 33.39,134.43 32.6,135.21 32.6,139.35 33.29,140.03 42.47,140.03 45.05,142.61 48.54,142.61 51.1,140.05 85.42,140.05 85.51,139.96 91.32,139.96 91.47,139.82 91.47,139.38 91.9,138.95 92.47,138.95 93.55,137.88 103.37,137.88 104.39,138.9 104.39,138.94 104.64,139.19 105.89,139.19 106.8,140.1 127.64,140.1 128.29,139.45 128.88,139.45 129.52,140.1 130.05,140.1 130.11,140.04 135.99,140.04 136.93,139.11 137.4,139.11 138.18,139.88 138.36,139.88 138.49,140.01 138.85,140.01 138.98,139.88 139.86,139.88 139.99,140.01 140.35,140.01 140.48,139.88 141.36,139.88 141.49,140.01 141.85,140.01 141.98,139.88 142.86,139.88 142.99,140.01 143.35,140.01 143.48,139.88 146.55,139.88 146.55,139.88 146.91,139.88 146.91,139.88 148.86,139.88 148.99,140.01 149.35,140.01 149.48,139.88 149.86,139.88 149.99,140.01 150.35,140.01 150.48,139.88 153.36,139.88 153.49,140.01 153.85,140.01 153.98,139.88 154.86,139.88 154.99,140.01 155.35,140.01 155.48,139.88 156.36,139.88 156.49,140.01 156.85,140.01 156.98,139.88 157.86,139.88 157.99,140.01 158.35,140.01 158.48,139.88 159.36,139.88 159.49,140.01 159.85,140.01 159.98,139.88 160.86,139.88 160.99,140.01 161.35,140.01 161.48,139.88 162.36,139.88 162.49,140.01 162.85,140.01 162.98,139.88 163.86,139.88 163.99,140.01 164.35,140.01 164.48,139.88 165.36,139.88 165.49,140.01 165.85,140.01 165.98,139.88 166.34,139.88 166.44,139.78 166.44,139.31 166.74,139.01 167.56,139.01 169.56,137.02 169.56,136.16 170.76,134.95 173.45,134.95 v2(179.65,128.75)
  BOTTOM w0.112: R4164.2 179.65,128.23 v2(179.65,128.75)
RST_PESW_M2A_LVC_N_R: length 17.7
  TOP w0.112: U103.2 190.34,116.62 189.33,117.63 v2(185.75,117.63)
  BOTTOM w0.112: R4164.1 R4186.1 182.5,125.58 183.06,125.02 183.06,122.53 185.17,120.42 185.17,118.21 v2(185.75,117.63)
RST_PESW_M2A_N: length 48.1
  TOP w0.112: v2(194.09,101.97) 191.82,104.25 188.98,104.25 187.99,105.23 187.99,108.87 189.69,110.57 U103.1
  IN1 w0.122: v2(200.53,83.99) 201.12,84.58 202.04,84.58 202.28,84.82 203.19,84.82 203.93,85.57 203.93,87.51 204.62,88.2 204.93,88.2 205.35,88.62 205.35,96.46 205.02,96.79 203.78,96.79 200.74,99.83 199.92,99.83 199.46,99.37 196.74,99.37 194.14,101.97 v2(194.09,101.97)
  BOTTOM w0.112: R3287.2 200.95,84.41 v2(200.53,83.99)
RST_PESW_M2A_N_R: length 26.9
  TOP w0.112: v2(197.56,74.97) 197.11,74.52 U34.AE33
  IN1 w0.122: v6(193.59,82.02) 193.59,80.44 192.68,79.54 191.32,79.54 191.09,79.3 191.09,77.79 191.33,77.54 191.75,77.54 192.09,77.2 192.09,76.74 192.31,76.52 193.87,76.52 195.09,75.3 195.09,74.79 195.41,74.47 196.09,74.47 196.58,74.97 v2(197.56,74.97)
  BOTTOM w0.112: R3287.1 200.37,85.32 200.18,85.52 v3(195.09,85.52) 193.27,85.52 193.01,85.26 193.01,84.81 193.1,84.71 193.1,82.5 v6(193.59,82.02)
RST_PESW_M2B_LVC_N: length 171.8
  TOP w0.112: v2(50.13,145.17) 51.08,144.22 51.08,142.02 54.14,138.96 54.14,137.07 56.45,134.76 57.7,134.76 58.08,134.37 58.08,128.47 56.59,126.98 55.79,126.98 55.68,126.87 J4.A50
  IN1 w0.122: v2(185.37,138.15) 185.16,138.15 184.59,138.72 183.58,138.72 182.82,137.97 170.81,137.97 167.82,140.96 105.89,140.96 104.91,140.55 103.36,140.55 102.98,140.18 100.91,140.18 99.96,139.23 97.8,139.23 96.11,140.92 94.23,140.92 93.77,141.38 93.77,142.08 92.91,142.93 91.62,142.93 90.4,144.15 90.4,144.98 90.1,145.29 87.45,145.29 85.16,143 82.69,143 82.32,142.62 76.94,142.62 76.6,142.97 71.27,142.97 71.01,142.71 69.33,142.71 68.65,143.39 68.65,144.7 68.23,145.13 64.08,145.13 63.45,144.51 59.27,144.51 58.82,144.06 54.67,144.06 54.28,144.45 50.85,144.45 v2(50.13,145.17)
  BOTTOM w0.112: R4165.2 185.98,136.32 v3(185.98,137.54) v2(185.37,138.15)
RST_PESW_M2B_LVC_N_R: length 27.9
  TOP w0.112: v2(185.71,118.48) 187.69,118.48 188.09,118.08 189.49,118.08 191.64,115.93 U103.4
  BOTTOM w0.112: v2(185.71,118.48) 186.41,119.18 186.41,119.63 186.13,119.91 186.13,120.88 184.63,122.38 184.63,125.07 186.13,126.57 v3(186.13,127.38) 186.13,133.89 186.76,134.52 R4187.1 R4165.1
RST_PESW_M2B_N: length 47.9
  TOP w0.112: U103.3 190.99,109.38 190.15,108.54 188.77,108.54 188.4,108.16 188.4,105.75 189.45,104.7 v2(191.17,104.7)
  IN1 w0.122: v2(191.17,104.7) 194.08,104.7 196.8,101.98 201.1,101.98 204.39,98.69 204.65,98.69 206.21,97.14 206.21,87.19 205.54,86.53 205.54,84.99 205.19,84.64 204.31,84.64 v2(203.51,83.84)
  BOTTOM w0.112: v2(203.51,83.84) 203.65,83.98 R3288.2
RST_PESW_M2B_N_R: length 30.9
  TOP w0.112: U34.AE31 194.61,74.04 v6(194.61,73.06)
  IN1 w0.122: v6(194.61,73.06) 191.97,73.06 191.06,73.96 191.06,77.27 190.82,77.5 190.32,77.5 190.1,77.72 190.1,79.23 190.38,79.52 190.81,79.52 191.06,79.77 191.06,80.28 191.38,80.6 192.95,80.6 193.08,80.72 193.08,84.33 193.27,84.53 195.84,84.53 196.11,84.8 196.11,85.31 196.32,85.52 200.79,85.52 201.2,85.93 v2(202.46,85.93)
  BOTTOM w0.112: R3288.1 203.19,85.7 202.69,85.7 v2(202.46,85.93)
RST_PESW_M2C_LVC_N: length 148.3
  TOP w0.112: v2(75.7,142) 76.53,141.17 76.53,138.33 78.27,136.59 78.27,134.94 78.69,134.53 81.77,134.53 82.76,133.54 82.76,128.29 81.45,126.97 79.79,126.97 79.68,126.86 J36.B50
  IN1 w0.122: v2(184.4,138.27) 183.62,137.5 170.64,137.5 167.6,140.53 106.14,140.53 104.78,139.97 103.42,139.97 103.03,139.58 103.03,138.97 102.79,138.74 97.59,138.74 95.85,140.47 93.95,140.47 93.17,141.26 93.17,142.06 92.74,142.49 91.91,142.49 91.12,141.71 87.72,141.71 87.67,141.66 76.05,141.66 v2(75.7,142)
  BOTTOM w0.112: v2(184.4,138.27) 184.4,138.14 184.24,137.99 183.01,137.99 182.67,137.65 182.67,136.47 181.34,135.14 181.34,132.12 182.47,130.99 R4166.2
RST_PESW_M2C_LVC_N_R: length 23.5
  TOP w0.112: U103.6 192.94,116.16 190.38,118.72 189.54,118.72 188.98,119.28 v2(185.7,119.28)
  BOTTOM w0.112: v2(185.7,119.28) 185.7,120.62 183.62,122.71 183.62,126.34 185.63,128.36 185.63,128.82 185.08,129.37 R4182.1 R4166.1
RST_PESW_M2C_N: length 44.3
  TOP w0.112: v2(193.57,103.15) 191.66,105.06 191.66,113.15 192.29,113.78 U103.5
  IN1 w0.122: v2(193.57,103.15) 196.85,99.87 199.36,99.87 199.74,100.26 200.92,100.26 203.96,97.22 205.32,97.22 205.78,96.76 205.78,87.37 205.39,86.98 204.62,86.98 204.36,86.72 204.36,85.39 203.36,84.39 202.5,84.39 202.33,84.22 201.64,84.22 v2(201.56,84.15)
  BOTTOM w0.112: R3289.2 201.78,84.37 v2(201.56,84.15)
RST_PESW_M2C_N_R: length 10.1
  TOP w0.112: U34.U30 v6(194.59,83.02)
  IN2 w0.122: v2(201.56,85.42) 201.52,85.42 201.02,84.92 201.02,83.74 200.78,83.5 195.07,83.5 v6(194.59,83.02)
  BOTTOM w0.112: R3289.1 201.92,85.42 v2(201.56,85.42)
RST_PESW_M2D_LVC_N: length 130
  TOP w0.112: v2(123.48,137.91) 123.43,137.96 123.43,138.7 123.11,139.02 118.35,139.02 117.68,138.35 107.52,138.35 106.56,137.4 105.6,137.4 103.75,135.55 103.75,135.24 104.12,134.87 104.57,134.87 105.16,135.46 105.3,135.46 105.98,134.78 105.98,128.76 105.41,128.19 104.53,128.19 103.68,127.34 J36.A50
  IN1 w0.122: v2(143.4,145.84) 143.71,146.14 161.76,146.14 162.9,145.01 172.2,145.01 173.79,146.6 191.13,146.6 192.08,145.65 192.08,135.8 190.85,134.58 190.85,132.55 191.53,131.87 191.53,128.61 v2(191.9,128.24)
  IN2 w0.122: v2(123.48,137.91) 123.48,140.71 124.39,141.62 125.73,141.62 127.63,143.52 131.44,143.52 134.03,146.1 143.13,146.1 v2(143.4,145.84)
  BOTTOM w0.112: R4167.2 v2(191.9,128.24)
RST_PESW_M2D_LVC_N_R: length 8
  TOP w0.112: U103.8 193.59,122.6 v2(192.59,123.6)
  BOTTOM w0.112: v2(192.59,123.6) 191.7,123.6 191.29,124.01 191.29,125.5 191.59,125.8 R4183.1 R4167.1
RST_PESW_M2D_N: length 60.5
  TOP w0.112: v2(208.53,75.59) 207.48,74.54 207.48,71.56 R3290.2 ; U103.9 v2(192.94,121.84)
  IN1 w0.122: v2(208.53,75.59) 208.31,75.81 208.15,76.18 208.15,79.27 208.4,79.52 208.4,98.61 205.58,101.43 205.58,102.95 204.95,103.58 204.95,107.21 201.74,110.43 199.79,110.43 194.94,115.28 194.94,117.81 192.89,119.86 192.89,121.79 v2(192.94,121.84)
RST_PESW_M2D_N_R: length 17.9
  TOP w0.112: v2(203.81,71.45) 205.08,71.45 205.55,70.98 R3290.1 ; U34.AB28 v6(192.59,77.02)
  IN1 w0.122: v2(203.81,71.45) 203.38,71.89 203.38,73.36 202.2,74.54 198.23,74.54 198.01,74.76 198.01,75.28 197.77,75.53 195.31,75.53 193.87,76.96 193.22,76.96 193.16,77.02 v6(192.59,77.02)
RST_PESW_M2E_LVC_N: length 84.7
  TOP w0.112: v2(141.04,145.12) 140.66,144.74 140.66,141.8 138.92,140.06 138.51,140.06 137.73,139.28 137.73,137.62 137.28,137.17 131.89,137.17 131.44,136.72 130.69,136.72 130.09,136.13 130.09,135.49 130.75,134.83 130.75,127.76 130.12,127.13 127.84,127.13 127.68,126.97 J38.B50
  BOTTOM w0.112: v2(141.04,145.12) 144.9,145.12 145.84,146.07 150.67,146.07 151.62,145.12 152.08,145.12 152.76,145.8 160.75,145.8 162.63,143.93 165.35,143.93 167.48,141.8 172.42,141.8 175.38,144.77 181.87,144.77 182.55,145.44 v3(183.31,145.44) 188.94,145.44 R4169.2
RST_PESW_M2E_LVC_N_R: length 24.5
  TOP w0.112: v2(192.15,121.79) 192.32,121.63 192.32,120.68 U103.10
  BOTTOM w0.112: R4169.1 R4184.1 190.16,142.06 189.87,141.76 189.87,140.39 190.67,138.44 190.67,135.47 190.55,135.36 190.55,132.04 190.72,131.88 190.72,128.89 190.25,128.42 v3(190.25,127.48) 190.37,127.36 190.37,123.75 191.04,123.08 191.04,122.36 191.61,121.79 v2(192.15,121.79)
RST_PESW_M2E_N: length 64.6
  TOP w0.112: v2(208.54,74.21) 208.54,69.61 207.88,68.95 R3291.2 ; U103.11 191.64,119.59 191.88,119.35 193.93,119.35 v2(194.16,119.58)
  BOTTOM w0.112: v2(208.54,74.21) 208.07,74.68 208.07,77.98 208.26,78.17 208.26,104.3 207.44,106.27 206.2,107.52 205.26,107.52 202.78,110 198.56,110 194.55,114.01 194.55,119.19 v2(194.16,119.58)
RST_PESW_M2E_N_R: length 21
  TOP w0.112: R3291.1 205.34,68.95 v1(204.72,69.57) 204,69.57 v2(203.9,69.47) ; U34.AB27 v6(191.59,77.02)
  IN1 w0.122: v2(203.9,69.47) 203.21,70.16 203.21,70.6 202.23,71.58 202.23,72.24 201.95,72.52 195.37,72.52 195.1,72.8 195.1,73.83 194.72,74.2 194.11,74.2 193.85,74.46 192.2,74.46 192.07,74.6 192.07,76.3 191.59,76.78 v6(191.59,77.02)
RST_PESW_M2F_LVC_N: length 65.4
  TOP w0.112: v2(151.72,145.7) 151.72,135.17 152.28,134.6 153.8,134.6 153.91,134.49 153.91,128.04 153.51,127.64 152.42,127.64 151.68,126.89 J38.A50
  BOTTOM w0.112: v2(151.72,145.7) 152.24,146.21 161,146.21 162.77,144.45 173.77,144.45 174.55,145.22 180.83,145.22 v3(181.23,145.62) 181.61,146 189,146 190.12,144.88 190.65,144.88 R4173.2
RST_PESW_M2F_LVC_N_R: length 23.8
  TOP w0.112: U103.12 190.99,122.15 v2(191.59,122.75)
  BOTTOM w0.112: R4173.1 R4185.1 191.06,141.5 191.06,140.39 191.54,139.23 191.54,135.69 190.95,135.09 190.95,132.31 191.11,132.14 191.11,128.55 190.86,128.3 190.86,123.85 191.59,123.11 v2(191.59,122.75)
RST_PESW_M2F_N: length 63.8
  TOP w0.112: U103.13 190.34,119.82 191.21,118.95 194.28,118.95 v2(194.95,119.61) ; R3292.2 206.9,74.74 208.52,76.37 v2(208.6,76.37)
  BOTTOM w0.112: v2(208.6,76.37) 208.6,77.92 208.65,77.97 208.65,104.48 208.46,104.94 v3(208.46,105.69) 208.53,105.77 208.53,106.93 206.65,108.81 204.52,108.81 202.94,110.4 198.77,110.4 194.95,114.22 v2(194.95,119.61)
RST_PESW_M2F_N_R: length 14.5
  TOP w0.112: v2(203.86,72.5) 204.36,72 R3292.1 ; U34.AC31 v6(195.59,76.02)
  IN1 w0.122: v6(195.59,76.02) 195.85,76.02 196.47,76.65 197.84,76.65 198.07,76.42 198.07,75.75 198.33,75.49 202.1,75.49 203.86,73.74 v2(203.86,72.5)
RST_PESW_M2G_LVC_N: length 100.5
  IN1 w0.122: v2(160.47,144.18) 160.86,143.79 167.48,143.79 169.41,141.85 170.82,141.85 171.92,142.96 176.2,142.96 179.39,146.15 187.08,146.15 191.07,142.15 191.07,135.5 190.36,134.78 190.36,132.42 191.1,131.69 191.1,126.16 191.87,125.39 192.25,124.47 192.25,123.96 192.09,123.57 192.09,122.42 191.1,121.43 191.1,118.22 189.59,116.71 v2(188.37,116.71)
  BOTTOM w0.112: v2(188.37,116.71) 189.2,115.88 189.2,113.82 190.17,112.85 190.17,111.79 192.15,109.8 194.44,109.8 194.56,109.69 194.56,105.66 R4168.2 ; v2(160.47,144.18) 159.86,144.79 157.1,144.79 155.35,143.04 153.54,143.04 152.53,142.03 152.53,138.33 151.97,137.77 151.97,136.63 153.29,135.31 154.64,135.31 155.42,134.53 J8.B50
RST_PESW_M2G_LVC_N_R: length 4.2
  BOTTOM w0.112: U102.2 v3(193.38,107.09) 192.89,106.61 R4192.1 R4168.1
RST_PESW_M2G_N: length 54.4
  TOP w0.112: v2(194.03,107.59) 194.03,108.48 v2(195.89,110.34) ; R3293.2 207.54,69.96 208.1,70.53 208.1,74.49 v2(208.51,74.9)
  IN1 w0.122: v2(208.51,74.9) 208.01,75.4 207.73,76.07 207.73,79.45 207.97,79.69 207.97,98.44 205.15,101.26 205.15,102.67 204.52,103.3 204.52,106.68 201.21,110 199.61,110 199.27,110.34 v2(195.89,110.34)
  BOTTOM w0.112: U102.1 v2(194.03,107.59)
RST_PESW_M2G_N_R: length 18
  TOP w0.112: v2(203.81,70.45) 203.94,70.58 204.92,70.58 205.54,69.96 R3293.1 ; U34.AC28 v6(192.59,76.02)
  IN1 w0.122: v2(203.81,70.45) 203.81,70.73 202.88,71.66 202.88,72.43 201.78,73.53 196.02,73.53 195.1,74.45 194.38,74.45 194.08,74.74 194.08,75.65 193.71,76.02 v6(192.59,76.02)
RST_PESW_M2H_LVC_N: length 74.3
  IN2 w0.122: v2(185.78,144.4) 179.15,144.4 177.72,145.82 174.57,145.82 v2(174.55,145.85)
  BOTTOM w0.112: R4170.2 187.6,144.4 v2(185.78,144.4) ; J8.A50 131.42,136 131.14,136.28 129.59,136.28 128.83,137.03 128.53,137.77 128.53,139.48 128.2,139.8 128.2,140.06 128.81,140.67 128.81,141.89 129.36,142.44 130.53,142.44 134.73,146.64 161.27,146.64 163.05,144.86 173.56,144.86 v2(174.55,145.85)
RST_PESW_M2H_LVC_N_R: length 43.5
  TOP w0.112: v2(192,117.78) 194.34,115.44 194.34,114.22 194.01,113.42 194.01,112.42 192.08,110.49 192.08,107.02 v2(192.41,106.69)
  BOTTOM w0.112: U102.4 192.08,107.02 v2(192.41,106.69) ; R4170.1 R4193.1 187.38,141.32 187.38,139.71 187.7,139.39 188.12,139.39 188.75,138.77 188.75,135.79 189.32,135.21 189.32,133.11 188.8,132.59 188.8,123.42 192,120.22 v2(192,117.78)
RST_PESW_M2H_N: length 55.6
  TOP w0.112: v2(195.25,110.87) 192.73,108.35 v2(192.73,107.51)
  BOTTOM w0.112: U102.3 v2(192.73,107.51) ; v2(195.25,110.87) 196.09,110.87 197.74,109.22 202.27,109.22 205.24,106.25 205.24,104.35 206.77,102.82 206.77,102.45 207.46,101.76 207.46,85.75 207.48,85.73 207.48,85.31 207.46,85.29 207.46,80.47 207.47,80.46 207.47,80.04 207.46,80.03 207.46,78.99 207.29,78.82 207.29,74.18 207.57,73.9 207.57,71.79 v3(207.38,71.59) 205.89,70.1 R3294.2
RST_PESW_M2H_N_R: length 18.6
  TOP w0.112: U34.AC27 v6(191.59,76.02)
  BOTTOM w0.112: R3294.1 204.2,70.99 202.89,70.99 202.77,70.87 201.44,70.87 v3(201.15,70.59) 201.07,70.51 197.33,70.51 197.04,70.8 197.04,71.23 196.71,71.55 196.46,71.55 196.1,71.91 196.1,73.16 195.76,73.49 194.34,73.49 194.01,73.82 194.01,74.23 193.73,74.51 193.5,74.51 193.12,74.88 193.12,75.33 192.85,75.6 191.89,75.6 191.59,75.9 v6(191.59,76.02)
RST_PESW_M2I_LVC_N: length 112
  TOP w0.112: v2(122.91,138.21) 122.51,138.61 119.74,138.61 119.5,138.37 119.5,137.44 118.52,136.45 117.52,136.45 116.04,137.94 109.92,137.94 109.12,137.13 109.12,135.6 108.09,134.57 107.69,134.57 107.31,134.19 107.31,131.89 v2(107.58,131.63)
  IN2 w0.122: v2(122.91,138.21) 122.91,140.97 124.01,142.06 125.29,142.06 127.3,144.07 131.16,144.07 133.68,146.59 165.1,146.59 165.73,145.96 167.83,145.96 168.81,144.97 177.33,144.97 179.12,143.18 183.87,143.18 v2(184.96,142.09)
  BOTTOM w0.112: v2(107.58,131.63) 107.42,131.79 107.42,133.22 J34.B50 ; v2(184.96,142.09) 185.65,141.4 185.65,139.71 187.21,138.15 187.21,134.29 186.74,133.82 186.74,126.08 R4171.2
