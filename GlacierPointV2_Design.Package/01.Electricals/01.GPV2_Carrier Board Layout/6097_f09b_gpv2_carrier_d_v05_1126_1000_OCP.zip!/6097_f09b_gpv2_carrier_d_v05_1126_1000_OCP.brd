# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_100M_DB1200_M2C_DP: length 4.9
  TOP w0.124: U47.26 59.04,60.53 58.93,60.42 56.59,60.42 56.3,60.14 55.47,60.14 R3191.1
CLK_100M_DB1200_M2C_R_DN: length 106.6
  TOP w0.124: v2(80.17,127.66) 80.53,128.02 80.53,128.23 80.37,129 80.37,129.78 80.53,131.33 80.53,132.6 80.43,132.7 J36.B53 ; R3192.2 53.7,59.83 53.31,59.83 R3582.1 52.35,59.83 51.05,59.83 50.58,60.14 48.49,65.19 48.49,67.17 49.24,68.97 53.23,72.96 53.48,73.58 53.48,74.75 51.86,78.67 51.86,81.91 51.74,82.03 v2(51.38,82.03)
  IN1 w0.136: v2(51.38,82.03) 51.85,82.5 51.85,82.66 52.29,83.1 57.9,83.1 58.06,83.26 70.12,83.26 73.46,86.61 73.46,87.49 77.6,91.62 78.34,91.62 83.61,96.9 83.61,97.69 83.2,98.67 83.2,105.01 83.65,106.1 84.54,106.99 84.57,107.05 84.57,108.18 84.56,108.18 84.4,108.59 84.08,108.9 82.15,113.56 82.15,121.23 80.54,125.13 80.54,127.29 v2(80.17,127.66)
CLK_100M_DB1200_M2C_R_DP: length 106.7
  TOP w0.124: v2(52.65,82.03) 52.29,82.03 52.17,81.91 52.17,78.73 52.31,78.39 52.54,78.29 52.68,77.94 52.59,77.71 52.73,77.37 52.96,77.27 53.11,76.93 53.01,76.69 53.79,74.82 53.79,73.52 53.49,72.79 49.49,68.8 48.79,67.11 48.79,65.25 50.83,60.34 51.14,60.14 52.35,60.14 R3581.1 53.31,60.14 53.7,60.14 R3191.2 ; J36.B55 80.93,132.7 80.83,132.6 80.83,131.32 80.68,129.77 80.68,129.03 80.83,128.26 80.83,128.02 v2(81.19,127.66)
  IN1 w0.136: v2(52.65,82.03) 52.21,82.03 52.13,82.11 52.13,82.55 52.4,82.82 58.01,82.82 58.17,82.98 70.23,82.98 73.74,86.49 73.74,87.37 77.71,91.34 78.45,91.34 83.89,96.78 83.89,97.75 83.48,98.73 83.48,104.96 83.89,105.95 84.78,106.83 84.84,106.99 84.84,108.24 84.63,108.75 84.32,109.06 82.43,113.62 82.43,121.28 80.82,125.18 80.82,127.29 v2(81.19,127.66)
CLK_100M_DB1200_M2D_DN: length 5.2
  TOP w0.124: U47.31 59.06,58.03 58.96,58.13 58.28,58.13 57.19,57.04 55.47,57.04 R3194.1
CLK_100M_DB1200_M2D_DP: length 5.2
  TOP w0.124: U47.30 59.05,58.53 58.95,58.43 58.15,58.43 57.06,57.34 55.47,57.34 R3193.1
CLK_100M_DB1200_M2D_R_DN: length 129.7
  TOP w0.124: v2(50.99,73.77) 51.35,73.77 51.47,73.64 51.47,73.13 47.71,69.37 47.56,69.02 47.56,68.46 46.69,66.35 46.69,65.03 47.19,63.82 48.47,62.54 49.99,58.85 51.2,57.39 51.23,57.35 51.69,57.04 52.35,57.04 R3584.1 53.31,57.04 53.7,57.04 R3194.2 ; v2(104.17,129.37) 104.52,129.73 104.52,132.61 104.43,132.69 J36.A53
  IN1 w0.136: v2(50.99,73.77) 51.36,73.77 51.49,73.9 51.49,74.53 52,75.05 64,75.05 65.5,76.55 73.36,76.55 75.65,78.83 85.46,78.83 94.47,87.85 102.03,87.85 107.76,93.57 107.76,98.83 106.64,104.45 106.64,117.71 106.33,119.27 104.54,123.59 104.54,129.01 v2(104.17,129.37)
CLK_100M_DB1200_M2D_R_DP: length 129.8
  TOP w0.124: R3193.2 53.7,57.34 53.31,57.34 R3583.1 52.35,57.34 51.79,57.34 51.43,57.58 50.26,59.01 48.72,62.72 47.45,63.99 46.99,65.09 46.99,66.29 47.87,68.4 47.87,68.96 47.96,69.19 48.24,69.47 48.46,69.47 48.73,69.73 48.73,69.96 48.99,70.22 49.22,70.22 49.48,70.49 49.48,70.71 49.75,70.98 49.97,70.98 50.24,71.24 50.24,71.47 50.5,71.73 50.73,71.73 50.99,71.99 50.99,72.22 51.78,73.01 51.78,73.65 51.9,73.77 v2(52.26,73.77) ; v2(105.18,129.37) 104.82,129.74 104.82,132.59 104.93,132.7 J36.A55
  IN1 w0.136: v2(52.26,73.77) 51.89,73.77 51.76,73.9 51.76,74.42 52.12,74.77 64.11,74.77 65.61,76.27 73.48,76.27 75.77,78.55 85.58,78.55 94.59,87.57 102.15,87.57 108.04,93.46 108.04,98.86 106.92,104.48 106.92,117.73 106.6,119.35 104.81,123.65 104.81,129.01 v2(105.18,129.37)
CLK_100M_DB1200_M2E_DN: length 5
  TOP w0.124: R3196.1 59.14,53.34 59.14,53.85 61.11,55.82 61.11,56.27 61.21,56.37 U47.35
CLK_100M_DB1200_M2E_DP: length 5
  TOP w0.124: U47.34 60.71,56.36 60.8,56.26 60.8,55.94 58.84,53.97 58.84,53.34 R3195.1
CLK_100M_DB1200_M2E_R_DN: length 141.7
  TOP w0.124: v2(88.16,66.32) 88.52,66.32 88.65,66.2 88.65,65.84 86.74,61.24 75.24,49.73 74.99,49.73 74.72,49.47 74.72,49.22 74.46,48.96 74.21,48.96 73.94,48.69 73.94,48.44 73.68,48.18 73.43,48.18 73.16,47.91 73.16,47.66 72.9,47.4 72.65,47.4 72.38,47.13 72.38,46.88 72.25,46.75 71.89,46.75 69.54,44.4 67.13,42.79 66.25,42.42 63.55,42.42 62.98,42.66 62.4,42.9 61.26,43.37 60.79,43.84 60.52,44.5 60.52,45.84 60.24,46.5 60.34,46.73 60.2,47.07 59.96,47.17 59.78,47.62 59.88,47.85 59.73,48.2 59.5,48.29 59.14,49.16 59.14,50.22 R3586.1 59.14,51.18 59.14,51.57 R3196.2 ; J38.B53 128.43,132.71 128.53,132.61 128.53,131.61 128.48,130.64 128.5,129.36 128.53,128.93 128.53,128.16 v2(128.17,127.81)
  IN1 w0.136: v2(88.16,66.32) 88.53,66.32 88.66,66.45 88.66,67.21 88.98,67.53 90.83,67.53 97.12,73.82 104.74,73.82 131.75,100.82 131.75,103.79 131.43,104.55 131.43,105.81 131.65,106.34 131.65,107.06 131.43,107.58 131.43,110.52 130.82,112 130.82,116.31 129.13,124.79 128.54,125.89 128.54,127.44 v2(128.17,127.81)
CLK_100M_DB1200_M2E_R_DP: length 141.8
  TOP w0.124: v2(89.43,66.32) 89.08,66.32 88.95,66.2 88.95,65.78 87,61.07 72.38,46.44 72.02,46.44 69.74,44.16 67.28,42.52 66.31,42.12 63.49,42.12 61.08,43.12 60.53,43.67 60.21,44.44 60.21,45.78 58.84,49.1 58.84,50.22 R3585.1 58.84,51.18 58.84,51.57 R3195.2 ; J38.B55 128.93,132.69 128.83,132.6 128.83,131.6 128.79,130.64 128.8,129.37 128.83,128.94 128.83,128.16 v2(129.19,127.81)
  IN1 w0.136: v2(89.43,66.32) 89.07,66.32 88.94,66.45 88.94,67.1 89.09,67.25 90.95,67.25 97.24,73.54 104.86,73.54 132.03,100.71 132.03,103.84 131.71,104.6 131.71,105.76 131.93,106.28 131.93,107.11 131.71,107.64 131.71,110.57 131.1,112.06 131.1,116.34 129.4,124.88 128.82,125.96 128.82,127.44 v2(129.19,127.81)
CLK_100M_DB1200_M2F_DN: length 4.6
  TOP w0.124: R3198.1 62.19,53.34 62.19,53.76 63.11,54.68 63.11,56.27 63.21,56.37 U47.39
CLK_100M_DB1200_M2F_DP: length 4.6
  TOP w0.124: U47.38 62.71,56.36 62.8,56.27 62.8,54.81 61.88,53.88 61.88,53.34 R3197.1
CLK_100M_DB1200_M2F_R_DN: length 157.7
  TOP w0.124: v2(152.2,129.01) 152.53,129.34 152.53,132.6 152.43,132.7 J38.A53 ; v2(62.76,44.61) 62.41,44.61 62.28,44.73 62.28,46.91 62.19,47.39 62.19,50.22 R3588.1 62.19,51.18 62.19,51.57 R3198.2
  IN1 w0.136: v2(62.76,44.61) 62.39,44.61 62.21,44.42 62.21,44.15 62.5,43.86 63.54,43.86 63.84,44.16 64.15,44.47 65.02,44.83 68.77,44.83 69.03,44.57 74.81,44.57 79.93,49.68 80.71,49.68 84.01,52.99 85.05,52.99 85.61,53.55 94.01,53.55 106.25,58.63 107.92,60.3 111.63,61.83 111.92,62.12 111.92,62.32 112.2,62.61 112.4,62.61 142.2,92.41 142.2,92.61 142.49,92.9 142.69,92.9 142.98,93.18 142.98,93.38 143.27,93.67 143.47,93.67 143.75,93.96 143.75,94.16 144.04,94.45 144.24,94.45 144.53,94.74 144.53,94.93 144.82,95.22 145.02,95.22 145.31,95.51 145.31,95.71 145.6,96 145.79,96 146.08,96.29 146.08,97.5 152.46,103.88 152.46,105.2 155.4,108.13 155.89,108.34 156.35,108.8 156.55,109.27 156.55,110.47 156.38,110.87 155.96,111.29 155.76,111.29 155.47,111.58 155.47,111.78 155.17,112.08 154.8,112.98 154.8,119.94 152.57,125.33 152.57,128.64 v2(152.2,129.01)
CLK_100M_DB1200_M2F_R_DP: length 157.7
  TOP w0.124: v2(153.21,129.01) 152.83,129.39 152.83,132.61 152.93,132.71 152.93,133.52 J38.A55 ; v2(61.49,44.61) 61.84,44.61 61.98,44.74 61.98,46.88 61.88,47.36 61.88,50.22 R3587.1 61.88,51.18 61.88,51.57 R3197.2
  IN1 w0.136: v2(153.21,129.01) 152.85,128.64 152.85,125.39 155.08,119.99 155.08,113.03 155.41,112.24 156.62,111.02 156.83,110.52 156.83,109.22 156.59,108.64 156.05,108.1 155.56,107.89 152.74,105.08 152.74,103.76 146.36,97.39 146.36,96.17 111.79,61.6 108.08,60.06 106.41,58.39 94.06,53.27 85.73,53.27 85.16,52.71 84.13,52.71 80.82,49.4 80.04,49.4 74.92,44.29 68.92,44.29 68.65,44.55 65.08,44.55 64.31,44.23 63.65,43.58 62.38,43.58 61.93,44.03 61.93,44.5 61.83,44.61 v2(61.49,44.61)
CLK_100M_DB1200_M2G_DN: length 4.2
  TOP w0.124: U47.43 65.21,56.36 65.11,56.27 65.11,53.34 R3200.1
CLK_100M_DB1200_M2G_DP: length 4.2
  TOP w0.124: U47.42 64.71,56.36 64.8,56.27 64.8,53.34 R3199.1
CLK_100M_DB1200_M2G_R_DN: length 164.6
  TOP w0.124: R3200.2 65.11,51.57 65.11,51.18 R3590.1 65.11,50.22 65.11,43.27 65.23,43.14 v2(65.58,43.14)
  IN1 w0.136: v2(65.58,43.14) 65.21,43.14 65.09,43.27 65.09,43.6 65.29,43.8 67.78,43.8 68.05,43.53 75.2,43.53 80.33,48.67 81.11,48.67 84.43,51.99 85.46,51.99 86.02,52.55 94.2,52.55 106.76,57.76 106.76,57.76 106.82,57.78 108.42,59.38 113.02,61.29 113.07,61.31 147.08,95.32 147.08,97.09 153.58,103.59 153.58,104.9 155.94,107.26 156.43,107.46 157.24,108.27 157.59,109.12 157.59,110.59 157.18,111.58 157.16,111.63 155.94,112.85 155.8,113.19 155.8,120.21 153.61,125.5 153.61,126.5 154.17,127.86 154.17,130.52 154.5,131.31 154.8,131.61 155.07,132.26 155.07,134.35 154.54,135.63 154.54,136.76 v2(154.93,137.15)
  BOTTOM w0.124: v2(154.93,137.15) 154.57,137.51 154.57,139.94 154.67,140.04 J8.B53
CLK_100M_DB1200_M2G_R_DP: length 164.6
  TOP w0.124: R3199.2 64.8,51.57 64.8,51.18 R3589.1 64.8,50.22 64.8,43.28 64.67,43.14 v2(64.31,43.14)
  IN1 w0.136: v2(64.31,43.14) 64.68,43.14 64.81,43.27 64.81,43.72 65.17,44.08 67.9,44.08 68.16,43.81 75.08,43.81 80.22,48.95 80.99,48.95 84.31,52.27 85.34,52.27 85.91,52.83 94.15,52.83 106.66,58.02 108.26,59.62 112.91,61.55 146.8,95.44 146.8,97.2 153.3,103.7 153.3,105.02 155.78,107.49 156.27,107.7 157,108.43 157.31,109.17 157.31,110.54 156.92,111.48 155.7,112.7 155.52,113.13 155.52,120.15 153.33,125.44 153.33,126.56 153.89,127.92 153.89,130.58 154.26,131.47 154.56,131.77 154.79,132.31 154.79,134.29 154.26,135.58 154.26,136.81 v2(153.91,137.15)
  BOTTOM w0.124: J8.B55 154.17,140.04 154.27,139.94 154.27,137.51 v2(153.91,137.15)
CLK_100M_DB1200_M2H_DN: length 4.5
  TOP w0.124: U47.47 67.21,56.35 67.11,56.26 67.11,55.67 67.9,54.88 67.9,53.34 R3202.1
CLK_100M_DB1200_M2H_DP: length 4.5
  TOP w0.124: U47.46 66.71,56.36 66.8,56.26 66.8,55.55 67.6,54.75 67.6,53.34 R3201.1
CLK_100M_DB1200_M2H_R_DN: length 138.5
  TOP w0.124: v2(85.55,65.63) 85.55,65.99 85.67,66.12 86.42,66.12 86.78,65.82 86.88,65.31 85.39,61.71 83.21,59.53 82.99,59.53 82.72,59.27 82.72,59.04 82.46,58.78 82.23,58.78 81.97,58.51 81.97,58.29 81.7,58.02 81.48,58.02 81.21,57.76 81.21,57.53 80.95,57.27 80.72,57.27 80.46,57 80.46,56.78 80.19,56.51 79.97,56.51 79.7,56.25 79.7,56.02 79.44,55.76 79.21,55.76 78.95,55.5 78.95,55.27 78.69,55.01 78.46,55.01 78.2,54.74 78.2,54.51 77.93,54.25 77.7,54.25 77.44,53.99 77.44,53.76 77.18,53.5 76.95,53.5 76.69,53.23 76.69,53.01 76.42,52.74 76.2,52.74 75.93,52.48 75.93,52.25 75.67,51.99 75.44,51.99 75.18,51.72 75.18,51.5 73.13,49.45 70.73,48.45 68.2,48.45 67.9,48.75 67.9,50.22 R3592.1 67.9,51.18 67.9,51.57 R3202.2
  IN1 w0.136: v2(85.55,65.63) 85.55,66 85.67,66.13 86.48,66.13 87.25,65.36 90.21,65.36 97.65,72.8 105.63,72.8 132.75,99.92 132.75,103.99 132.43,104.75 132.43,105.61 132.68,106.2 132.68,108.02 132.43,108.61 132.43,110.94 131.82,112.42 131.82,116.45 131.5,118.04 131.5,125.32 130.51,127.73 130.51,132.76 130.04,135.1 130.04,135.82 130.56,137.07 130.56,137.38 v2(130.93,137.75)
  BOTTOM w0.124: v2(130.93,137.75) 130.57,138.11 130.57,139.86 130.67,139.96 J8.A53
CLK_100M_DB1200_M2H_R_DP: length 138.4
  TOP w0.124: v2(85.55,66.9) 85.55,66.55 85.67,66.42 86.53,66.42 87.06,65.99 87.2,65.28 85.65,61.54 73.3,49.19 70.79,48.15 68.07,48.15 67.6,48.62 67.6,50.22 R3591.1 67.6,51.18 67.6,51.57 R3201.2
  IN1 w0.136: v2(85.55,66.9) 85.55,66.54 85.67,66.41 86.6,66.41 87.36,65.64 90.09,65.64 97.53,73.08 105.52,73.08 132.47,100.03 132.47,103.93 132.15,104.69 132.15,105.66 132.4,106.25 132.4,107.97 132.15,108.56 132.15,110.88 131.54,112.36 131.54,116.42 131.22,118.02 131.22,125.27 130.23,127.67 130.23,129.17 130.09,129.31 130.09,129.72 130.23,129.86 130.23,130.27 130.09,130.41 130.09,130.82 130.23,130.96 130.23,131.36 130.09,131.5 130.09,131.91 130.23,132.05 130.23,132.73 129.76,135.07 129.76,135.87 130.28,137.12 130.28,137.38 v2(129.91,137.75)
  BOTTOM w0.124: J8.A55 130.17,139.96 130.27,139.86 130.27,138.11 v2(129.91,137.75)
CLK_100M_DB1200_M2I_DN: length 6.2
  TOP w0.124: U47.51 68.87,58.53 68.97,58.43 69.38,58.43 70.96,56.85 73.26,56.85 R3204.1
CLK_100M_DB1200_M2I_DP: length 6.2
  TOP w0.124: R3203.1 73.26,56.55 70.83,56.55 69.26,58.13 68.97,58.13 68.87,58.03 U47.50
CLK_100M_DB1200_M2I_R_DN: length 123.6
  TOP w0.124: R3204.2 75.02,56.85 75.41,56.85 R3594.1 76.38,56.85 77.65,56.85 78.13,57.17 78.17,57.39 78.48,57.6 78.7,57.56 79.06,57.8 79.21,58.14 79.12,58.35 79.26,58.7 79.47,58.78 79.61,59.13 79.53,59.34 79.67,59.68 79.88,59.77 80.02,60.11 79.94,60.32 80.08,60.67 80.29,60.75 80.43,61.1 80.34,61.31 80.49,61.65 80.7,61.74 80.9,62.23 80.9,66.15 80.1,68.09 76.84,71.34 76.62,71.34 76.35,71.61 76.35,71.83 76.09,72.1 75.86,72.1 75.6,72.36 75.6,72.59 75.33,72.85 75.11,72.85 74.84,73.11 74.84,73.34 74.56,73.62 73.3,74.14 71.57,74.14 71.45,74.02 v2(71.45,73.66)
  IN1 w0.136: v2(106.24,138.47) 105.88,138.1 105.88,131.19 106.13,129.89 106.13,128.09 105.57,126.73 105.57,123.87 107.28,119.76 107.76,117.35 107.76,110.47 108.52,108.63 108.52,107.31 107.76,105.47 107.76,104.13 108.79,98.95 108.79,92.97 102.33,86.51 94.63,86.51 85.92,77.8 76.32,77.8 72.67,74.16 71.58,74.16 71.45,74.03 v2(71.45,73.66)
  BOTTOM w0.124: J34.B53 106.67,140.09 106.57,139.99 106.57,139.62 105.93,138.98 105.93,138.78 v2(106.24,138.47)
CLK_100M_DB1200_M2I_R_DP: length 123.6
  TOP w0.124: R3203.2 75.02,56.55 75.41,56.55 R3593.1 76.38,56.55 77.74,56.55 79.31,57.59 81.2,62.17 81.2,66.21 80.35,68.26 74.73,73.88 73.37,74.45 71.57,74.45 71.45,74.57 v2(71.45,74.93)
  IN1 w0.136: v2(105.23,138.47) 105.6,138.1 105.6,136.1 105.46,135.96 105.46,135.55 105.6,135.41 105.6,134.44 105.46,134.3 105.46,133.9 105.6,133.76 105.6,133.35 105.46,133.21 105.46,132.8 105.6,132.66 105.6,132.25 105.46,132.11 105.46,131.71 105.6,131.57 105.6,131.16 105.86,129.86 105.86,128.14 105.3,126.79 105.3,123.82 107.01,119.68 107.48,117.32 107.48,110.41 108.24,108.58 108.24,107.36 107.48,105.52 107.48,104.1 108.51,98.93 108.51,93.09 102.21,86.79 94.51,86.79 85.8,78.08 76.2,78.08 72.56,74.43 71.58,74.43 71.45,74.56 v2(71.45,74.93)
  BOTTOM w0.124: v2(105.23,138.47) 105.63,138.87 105.63,139.11 106.27,139.75 106.27,139.99 106.17,140.08 J34.B55
CLK_100M_DB1200_M2J_DN: length 5.9
  TOP w0.124: R3206.1 73.26,59.65 71.65,59.65 70.87,60.43 68.96,60.43 68.86,60.53 U47.55
CLK_100M_DB1200_M2J_DP: length 5.9
  TOP w0.124: U47.54 68.87,60.03 68.97,60.12 70.74,60.12 71.52,59.34 73.26,59.34 R3205.1
CLK_100M_DB1200_M2J_R_DN: length 117
  TOP w0.124: v2(59.98,80.92) 59.98,81.28 60.11,81.4 61.47,81.4 62.08,81.15 62.4,80.83 62.72,80.51 62.72,80.28 62.98,80.02 63.21,80.02 63.47,79.76 63.47,79.53 63.74,79.27 63.96,79.27 64.23,79 64.23,78.78 64.49,78.51 64.72,78.51 65.17,78.06 65.92,77.75 66.67,77.75 67.94,77.22 69.12,76.05 70.49,72.74 70.62,72.61 71.64,72.19 71.73,71.98 72.07,71.84 72.28,71.92 72.63,71.78 72.71,71.57 73.06,71.43 73.27,71.52 73.61,71.37 73.7,71.16 74.04,71.02 74.25,71.11 74.6,70.96 74.68,70.76 75.03,70.61 75.24,70.7 75.58,70.56 75.67,70.35 76.02,70.2 76.22,70.29 76.69,70.1 79.29,67.49 79.91,66.01 79.91,64.26 78.15,60.01 77.61,59.65 76.38,59.65 R3596.1 75.41,59.65 75.02,59.65 R3206.2
  IN1 w0.136: v2(59.98,80.92) 59.98,81.29 60.11,81.42 62.19,81.42 63.01,82.24 70.53,82.24 74.46,86.17 74.46,87.07 77.45,90.07 78.2,90.07 84.74,96.61 84.74,98.03 84.21,99.31 84.21,104.82 84.44,105.38 85.56,106.49 85.61,106.62 85.61,109.53 84.61,111.93 84.61,112.96 83.17,116.46 83.17,121.62 81.65,125.28 81.65,126.21 82.22,127.6 82.22,135.48 82.56,136.3 82.56,137.33 v2(82.93,137.7)
  BOTTOM w0.124: v2(82.93,137.7) 82.57,138.05 82.57,139.85 82.67,139.95 J34.A53
CLK_100M_DB1200_M2J_R_DP: length 116.9
  TOP w0.124: R3205.2 75.02,59.34 75.41,59.34 R3595.1 76.38,59.34 77.7,59.34 78.39,59.8 80.21,64.2 80.21,66.07 79.55,67.67 76.86,70.36 70.79,72.87 70.75,72.92 69.38,76.22 68.11,77.48 66.74,78.05 65.98,78.05 65.34,78.32 62.62,81.05 62.25,81.41 61.53,81.71 60.11,81.71 59.98,81.83 v2(59.98,82.19)
  IN1 w0.136: v2(59.98,82.19) 59.98,81.82 60.11,81.69 62.07,81.69 62.9,82.52 70.42,82.52 74.18,86.28 74.18,87.19 74.69,87.7 77.34,90.35 78.08,90.35 84.46,96.73 84.46,97.98 83.93,99.26 83.93,104.88 84.21,105.54 85.32,106.65 85.33,106.67 85.33,109.48 84.33,111.88 84.33,112.91 82.89,116.4 82.89,121.56 81.37,125.22 81.37,126.27 81.94,127.66 81.94,128.95 81.8,129.09 81.8,129.5 81.94,129.64 81.94,130.04 81.8,130.18 81.8,130.59 81.94,130.73 81.94,131.14 81.8,131.28 81.8,131.69 81.94,131.83 81.94,132.48 81.8,132.62 81.8,133.03 81.94,133.17 81.94,135.54 82.28,136.35 82.28,137.33 v2(81.91,137.7)
  BOTTOM w0.124: v2(81.91,137.7) 82.27,138.05 82.27,139.85 82.17,139.95 J34.A55
CLK_100M_DB1200_M2K_DN: length 5.8
  TOP w0.124: U47.60 68.88,63.03 68.98,62.93 69.81,62.93 70.3,62.44 73.26,62.44 R3208.1
CLK_100M_DB1200_M2K_DP: length 5.8
  TOP w0.124: R3207.1 73.26,62.13 70.18,62.13 69.69,62.63 68.97,62.63 68.87,62.53 U47.59
CLK_100M_DB1200_M2K_R_DN: length 110
  TOP w0.124: v2(50.03,88.95) 50.03,89.31 50.16,89.44 50.44,89.44 50.65,89.23 50.65,86.44 51.25,85.84 53.7,85.84 55.93,84.91 57.34,82.81 57.34,77.78 58.38,76.73 66.55,76.73 67.24,76.45 68.31,75.38 69.62,72.21 70.7,71.14 71.19,70.93 71.27,70.72 71.62,70.58 71.83,70.67 72.17,70.53 72.26,70.32 72.6,70.17 72.81,70.26 73.16,70.12 73.25,69.91 73.59,69.76 73.8,69.85 74.14,69.71 74.23,69.5 74.58,69.36 74.79,69.44 75.13,69.3 75.22,69.09 75.56,68.95 75.77,69.03 76.68,68.66 78.48,66.85 78.94,65.75 78.94,64.46 78.8,64.11 78.59,64.02 78.45,63.68 78.53,63.47 78.28,62.86 77.66,62.44 76.38,62.44 R3598.1 75.41,62.44 75.02,62.44 R3208.2
  IN1 w0.136: v2(50.03,88.95) 50.03,89.32 50.16,89.45 50.46,89.45 50.95,89.78 51.75,91.71 61.37,101.33 61.37,110.81 59.87,115.77 59.87,118.03 60.18,119.62 60.19,119.65 60.19,124.4 59.11,127.02 58.57,129.7 58.57,137.77 v2(58.94,138.14)
  BOTTOM w0.124: v2(58.94,138.14) 58.57,138.51 58.57,139.98 58.67,140.08 J6.B53
CLK_100M_DB1200_M2K_R_DP: length 110
  TOP w0.124: v2(50.03,90.22) 50.03,89.86 50.16,89.74 50.57,89.74 50.95,89.36 50.95,86.57 51.38,86.14 53.76,86.14 56.14,85.16 57.64,82.9 57.64,77.9 58.51,77.04 66.61,77.04 67.41,76.71 68.57,75.55 69.88,72.39 70.87,71.4 75.89,69.32 76.85,68.92 78.74,67.03 79.25,65.81 79.25,64.39 78.53,62.66 77.75,62.14 76.38,62.14 R3597.1 75.41,62.13 75.02,62.13 R3207.2
  IN1 w0.136: v2(57.92,138.14) 58.29,137.77 58.29,129.67 58.84,126.93 59.91,124.34 59.91,119.68 59.59,118.05 59.59,115.73 61.09,110.77 61.09,101.44 54.48,94.83 54.29,94.83 54,94.55 54,94.36 53.72,94.07 53.53,94.07 53.24,93.78 53.24,93.6 52.95,93.31 52.77,93.31 52.48,93.02 52.48,92.83 51.51,91.87 50.72,89.96 50.37,89.73 50.16,89.73 50.03,89.85 v2(50.03,90.22)
  BOTTOM w0.124: v2(57.92,138.14) 58.27,138.48 58.27,139.97 58.17,140.07 J6.B55
CLK_100M_DB1200_M2L_DN: length 5.7
  TOP w0.124: U47.64 68.8,65.03 68.9,64.93 69.29,64.93 69.59,65.23 73.26,65.23 R3210.1
CLK_100M_DB1200_M2L_DP: length 5.7
  TOP w0.124: R3209.1 73.26,64.93 69.72,64.93 69.41,64.63 68.97,64.63 68.87,64.53 U47.63
CLK_100M_DB1200_M2L_R_DN: length 116.6
  TOP w0.124: R3210.2 75.02,65.23 75.41,65.23 R3600.1 76.38,65.23 77.54,65.23 77.78,65.43 77.86,65.82 77.73,66.14 77.03,66.83 76.81,66.83 76.54,67.1 76.54,67.32 76.15,67.72 75.78,67.72 75.62,67.56 75.24,67.56 75.08,67.72 74.71,67.72 74.55,67.56 74.18,67.56 74.02,67.72 73.38,67.72 72.3,68.16 68.78,71.69 67.53,74.69 66.55,75.67 66.31,75.77 57.82,75.77 56.35,77.24 56.35,82.53 55.71,83.49 55.32,83.88 55.32,83.88 54.93,84.27 53.75,84.76 48.74,84.76 47.58,85.93 47.58,88.51 45.82,90.28 45.59,90.28 45.33,90.54 45.33,90.77 45.06,91.03 44.84,91.03 44.57,91.29 44.57,91.52 44.31,91.78 43.38,92.17 43.17,92.08 42.82,92.23 42.74,92.44 42.39,92.58 42.18,92.49 41.84,92.64 41.75,92.84 41.4,92.99 41.2,92.9 40.85,93.04 40.76,93.25 40.42,93.4 34.63,93.4 34.49,93.26 v2(34.49,92.96)
  IN1 w0.136: v2(34.47,138.36) 34.1,137.99 34.1,135.61 35.49,132.25 35.49,131.45 35.03,130.33 32.84,128.14 32.68,127.75 32.68,125.77 33.4,124.03 33.4,121.79 34.09,120.14 34.09,116.52 34.43,115.69 34.43,102.97 35.77,96.26 35.77,93.88 35.35,93.46 34.62,93.46 34.49,93.33 v2(34.49,92.96)
  BOTTOM w0.124: J6.A53 34.67,139.95 34.57,139.86 34.57,139.45 34.11,138.99 34.11,138.72 v2(34.47,138.36)
CLK_100M_DB1200_M2L_R_DP: length 116.6
  TOP w0.124: 56.6,82.7 56.66,82.62 56.66,77.37 57.95,76.08 66.37,76.08 66.73,75.93 67.79,74.86 69.03,71.86 72.47,68.42 73.44,68.02 76.28,68.02 77.98,66.31 78.18,65.85 78.06,65.26 77.65,64.93 76.38,64.93 R3599.1 75.41,64.93 75.02,64.93 R3209.2 ; 56.6,82.7 55.94,83.69 55.1,84.53 53.81,85.07 48.87,85.07 47.88,86.05 47.88,88.64 44.48,92.04 40.48,93.7 34.67,93.7 34.49,93.88 v2(34.49,94.23) ; 56.6,82.7 56.6,82.7 56.6,82.7
  IN1 w0.136: v2(34.49,94.23) 34.49,93.87 34.62,93.74 35.23,93.74 35.49,93.99 35.49,96.24 35.39,96.72 35.23,96.83 35.15,97.23 35.26,97.39 35.18,97.79 35.01,97.9 34.93,98.3 35.04,98.47 34.96,98.86 34.8,98.97 34.72,99.37 34.83,99.54 34.75,99.94 34.59,100.05 34.51,100.45 34.62,100.61 34.15,102.95 34.15,115.63 33.81,116.47 33.81,120.09 33.12,121.74 33.12,123.97 32.4,125.72 32.4,127.8 32.6,128.3 34.79,130.49 35.21,131.5 35.21,132.19 33.82,135.55 33.82,137.99 v2(33.45,138.36)
  BOTTOM w0.124: J6.A55 34.17,139.95 34.27,139.85 34.27,139.57 33.81,139.11 33.81,138.72 v2(33.45,138.36)
CLK_100M_PE_DN: length 16.3
  TOP w0.124: v2(60.39,6.17) 60.62,6.17 60.75,6.29 60.75,7.11 62.27,10.78 64.05,13.46 65.85,17.8 65.85,18.25 R3099.1
  BOTTOM w0.124: J41.50 60.5,5.18 60.75,5.43 60.75,6.04 60.62,6.17 v2(60.39,6.17)
CLK_100M_PE_DP: length 16.3
  TOP w0.124: v2(61.41,6.17) 61.18,6.17 61.05,6.29 61.05,7.05 62.54,10.64 64.32,13.31 66.16,17.74 66.16,18.25 R3100.1
  BOTTOM w0.124: J41.48 61.3,5.19 61.05,5.44 61.05,6.04 61.18,6.17 v2(61.41,6.17)
CLK_100M_PESW_D_C_DN: length 239.8
  TOP w0.124: C971.2 121.29,32.78 121.29,31.74 121.01,31.09 120.14,30.21 118.44,29.51 114.85,25.92 112.72,20.77 111.47,19.52 109.54,18.72 106.39,18.72 105.55,18.16 105.47,17.95 105.3,17.56 105.09,17.47 104.94,17.09 105.02,16.88 104.87,16.5 104.66,16.42 104.5,16.04 104.59,15.83 104.43,15.45 104.22,15.36 104.06,14.98 104.15,14.77 103.99,14.39 103.78,14.3 103.63,13.92 103.71,13.71 103.55,13.33 103.35,13.25 103.19,12.87 103.27,12.66 103.03,12.07 102.74,11.78 102.52,11.78 102.22,11.49 102.22,11.27 101.93,10.98 101.71,10.98 101.42,10.68 101.42,10.46 99.76,8.8 98.04,4.65 97.31,4.16 96.63,4.22 96.38,4.5 96.38,5.09 96.5,5.21 v2(96.86,5.21) ; U34.Y30 v6(194.59,79.02)
  IN1 w0.136: v2(96.86,5.21) 96.49,5.21 96.37,5.09 96.37,4.27 96.79,3.85 97.38,3.85 97.52,3.99 97.93,3.99 98.07,3.85 98.48,3.85 98.62,3.99 99.03,3.99 99.17,3.85 99.57,3.85 99.71,3.99 100.12,3.99 100.26,3.85 158.29,3.85 159.29,4.84 160.37,7.45 160.37,7.86 160.23,8 160.23,8.41 160.37,8.55 160.37,8.96 160.23,9.1 160.23,9.5 160.37,9.64 160.37,10.05 160.23,10.19 160.23,10.6 160.37,10.74 160.37,11.97 158.64,16.15 156.63,19.17 156.19,20.22 155.44,24 155.44,28.54 159.81,39.09 161.54,40.83 165.19,42.34 169.99,42.34 173.14,43.64 180.67,48.68 182.07,49.26 189.8,49.26 191.43,49.93 203.21,49.93 205.58,51.52 206.55,53.84 206.47,54.02 206.63,54.4 206.81,54.48 207.1,55.18 206.53,59.85 207.33,66.19 206.9,76.85 206.61,77.56 206.42,77.63 206.27,78.01 206.34,78.19 206.18,78.58 205.54,79.22 205.35,79.22 205.06,79.51 205.06,79.71 204.77,79.99 204.1,80.27 203.92,80.19 203.54,80.35 203.47,80.53 202.87,80.78 201.38,80.78 201.24,80.64 200.84,80.64 200.7,80.78 200.29,80.78 200.15,80.64 199.74,80.64 199.6,80.78 199.19,80.78 199.06,80.64 198.65,80.64 198.51,80.78 198.1,80.78 197.96,80.64 197.55,80.64 197.41,80.78 197.01,80.78 196.87,80.64 196.46,80.64 196.32,80.78 195.64,80.78 194.51,80.31 194.2,79.84 194.2,79.41 v6(194.59,79.02)
  BOTTOM w0.124: v6(194.59,79.02) 194.45,79.02 194.26,79.2 194.26,79.79 R3241.2
CLK_100M_PESW_D_C_DP: length 239.9
  TOP w0.124: U34.Y29 v6(193.59,79.02) ; C970.2 121.59,32.78 121.59,31.68 121.27,30.92 120.31,29.95 118.62,29.25 115.11,25.75 112.98,20.6 111.64,19.26 109.6,18.42 106.48,18.42 105.8,17.96 105.54,17.33 105.54,17.33 103.29,11.9 100.02,8.63 98.29,4.44 97.39,3.84 96.49,3.93 96.07,4.39 96.07,5.09 95.95,5.21 v2(95.59,5.21)
  IN1 w0.136: v2(95.59,5.21) 95.96,5.21 96.09,5.09 96.09,4.15 96.67,3.57 158.41,3.57 159.52,4.68 160.09,6.04 160.65,7.4 160.65,12.03 158.88,16.29 156.87,19.3 156.46,20.3 155.72,24.02 155.72,28.49 160.04,38.93 161.7,40.59 165.25,42.06 170.04,42.06 173.27,43.4 180.8,48.43 182.13,48.98 189.86,48.98 191.49,49.65 203.3,49.65 205.81,51.33 206.94,54.05 207.39,55.15 206.81,59.85 207.61,66.18 207.18,76.91 206.42,78.74 204.91,80.25 204.88,80.25 202.92,81.06 195.58,81.06 194.33,80.54 193.92,79.93 193.92,79.35 v6(193.59,79.02)
  BOTTOM w0.124: v6(193.59,79.02) 193.77,79.02 193.96,79.2 193.96,79.79 R3241.1
CLK_100M_PESW_D_DN: length 2.1
  TOP w0.124: C971.1 121.29,34.29 121.29,35.4 121.19,35.5 U61.23
CLK_100M_PESW_D_DP: length 2.1
  TOP w0.124: U61.24 121.69,35.48 121.59,35.38 121.59,34.29 C970.1
CLK_100M_PESW_H2_R_C_DN: length 232.9
  TOP w0.124: C909.2 65.85,21.75 65.85,22.88 67.13,24.16 79.5,24.16 83.37,20.28 91.4,16.96 97.21,11.15 97.31,10.39 97.31,9.2 97.41,9.1 v2(97.77,9.1) ; U34.AA30 v6(194.59,78.02)
  IN1 w0.099: v6(194.59,78.02) 194.27,78.02 194.17,78.12 194.17,78.32 194.28,78.42 202.07,78.42 202.11,78.38 202.13,78.38
  IN1 w0.136: 202.13,78.38 202.88,78.38 203.76,78.01 204.7,78.01 205.23,77.79 205.64,77.38 206.21,76 206.23,75.47 206.1,75.32 206.12,74.91 206.26,74.78 206.28,74.37 206.14,74.23 206.16,73.82 206.31,73.68 206.32,73.28 206.19,73.13 206.2,72.72 206.35,72.59 206.37,72.18 206.23,72.04 206.25,71.63 206.39,71.5 206.41,71.09 206.28,70.94 206.29,70.54 206.44,70.4 206.45,69.99 206.32,69.85 206.34,69.44 206.48,69.31 206.5,68.9 206.36,68.76 206.38,68.35 206.53,68.21 206.6,66.47 205.78,59.99 206.32,55.55 204.82,51.91 202.94,50.66 191.05,50.66 189.47,50 181.87,50 180.47,49.42 172.98,44.42 169.72,43.07 165.05,43.07 161.15,41.45 159.03,39.34 154.71,28.9 154.71,23.76 155.47,19.91 155.96,18.74 157.88,15.87 159.47,12.03 159.47,10.64 159.33,10.5 159.33,10.09 159.47,9.95 159.47,9.54 159.33,9.4 159.33,9 159.47,8.86 159.47,8.45 159.33,8.31 159.33,7.9 159.47,7.76 159.47,7.35 158.55,5.13 157.99,4.57 103.4,4.57 103.26,4.71 102.86,4.71 102.72,4.57 102.31,4.57 102.17,4.71 101.76,4.71 101.62,4.57 101.21,4.57 99.19,5.41 98.55,5.83 98.02,6.63 98.06,6.83 97.83,7.17 97.64,7.21 97.41,7.55 97.23,8.47 97.23,8.93 97.4,9.1 v2(97.77,9.1)
  BOTTOM w0.124: v6(194.59,78.02) 194.4,78.02 194.27,77.9 194.27,77.36 R3098.2
CLK_100M_PESW_H2_R_C_DP: length 233
  TOP w0.124: U34.AA29 v6(193.59,78.02) ; v2(96.5,9.1) 96.76,9.1 97,9.35 97,10.37 96.92,11.01 91.23,16.7 83.2,20.02 81.03,22.2 80.8,22.2 80.54,22.46 80.54,22.69 80.27,22.95 80.05,22.95 79.78,23.22 79.78,23.44 79.38,23.85 74.24,23.85 74.08,23.69 73.7,23.69 73.54,23.85 73.17,23.85 73.01,23.69 72.64,23.69 72.48,23.85 72.1,23.85 71.94,23.69 71.57,23.69 71.41,23.85 71.03,23.85 70.87,23.69 70.5,23.69 70.34,23.85 69.97,23.85 69.81,23.69 69.43,23.69 69.27,23.85 68.9,23.85 68.74,23.69 68.37,23.69 68.21,23.85 67.26,23.85 66.16,22.75 66.16,21.75 C910.2
  IN1 w0.099: v6(193.59,78.02) 193.87,78.02 193.97,78.12 193.97,78.4 194.19,78.62 202.07,78.62 202.11,78.66 202.13,78.66
  IN1 w0.136: 202.13,78.66 202.93,78.66 203.82,78.29 204.75,78.29 205.39,78.03 205.88,77.54 206.49,76.06 206.88,66.46 206.06,59.99 206.61,55.51 205.04,51.73 203.03,50.38 191.11,50.38 189.52,49.72 181.93,49.72 180.6,49.17 173.11,44.17 169.77,42.79 165.11,42.79 161.3,41.21 159.27,39.18 154.99,28.84 154.99,23.79 155.74,19.99 156.21,18.88 158.13,16 159.75,12.08 159.75,7.3 158.79,4.97 158.11,4.29 101.16,4.29 99.06,5.16 98.35,5.63 97.15,7.44 96.95,8.44 96.95,9 96.85,9.1 v2(96.5,9.1)
  BOTTOM w0.124: v6(193.59,78.02) 193.84,78.02 193.97,77.9 193.97,77.33 R3098.1
CLK_100M_PESW_H2_R_DN: length 1.5
  TOP w0.124: C909.1 65.85,20.24 65.85,19.77 R3099.2
CLK_100M_PESW_H2_R_DP: length 1.5
  TOP w0.124: R3100.2 66.16,19.77 66.16,20.24 C910.1
CLK_100M_PESW_S3_DB1200_C_DN: length 286.8
  TOP w0.124: U47.10 63.21,66.18 63.3,66.28 63.3,70.45 v2(62.95,70.81) ; R3101.2 v2(203.74,76.02)
  IN1 w0.136: v2(203.74,76.02) 204.1,75.66 204.72,75.66 205.25,75.44 205.6,74.91 205.94,66.49 205.19,60.51 205.81,55.49 204.45,52.21 202.84,51.14 191.02,51.14 189.36,50.45 181.76,50.45 180.26,49.82 172.77,44.82 169.82,43.6 165.15,43.6 160.9,41.84 158.51,39.45 154.15,28.91 154.15,23.78 154.93,19.86 155.6,18.24 157.26,15.75 158.12,13.69 158.82,11.99 158.82,7.06 158.8,7.04 158.08,5.31 157.79,5.02 103.8,5.02 103.28,5.43 102.89,7.26 102.88,7.26 102.2,10.38 104,19.32 105.05,21.85 105.94,22.45 106.55,22.45 106.67,22.57 v2(106.67,22.94)
  BOTTOM w0.124: C912.2 v2(203.74,76.02) R3101.2 ; v2(62.95,70.81) 63.3,71.16 63.3,71.94 63.36,72.02 64.34,73.5 65.84,74.12 69.36,74.12 70.41,73.68 74.68,69.41 76.84,64.21 77.17,63.87 77.74,63.64 78.05,63.33 78.98,61.07 79.44,60.62 81.87,59.61 84.43,57.05 86.36,52.38 86.36,48.46 84.93,47.02 84.93,42.97 85.52,41.53 85.79,41.26 87.01,40.76 87.53,40.76 88.14,40.15 88.14,39.41 88.51,39.04 93.48,39.04 95.87,41.42 95.87,42.78 97.54,44.45 101.52,44.45 102.91,43.52 103.14,43.1 103.14,34.34 105.56,31.91 105.56,22.72 105.82,22.45 106.54,22.45 106.67,22.58 v2(106.67,22.94)
CLK_100M_PESW_S3_DB1200_C_DP: length 286.7
  TOP w0.124: R3103.2 v2(203.74,75) ; U47.9 63.71,66.19 63.61,66.29 63.61,70.45 v2(63.96,70.81)
  IN1 w0.136: v2(106.67,21.67) 106.67,22.04 106.55,22.17 106.03,22.17 105.27,21.66 105.04,21.11 105.12,20.93 104.96,20.55 104.78,20.47 104.27,19.23 104.17,18.73 104.28,18.57 104.2,18.17 104.03,18.06 103.95,17.66 104.06,17.49 103.98,17.09 103.81,16.98 103.73,16.58 103.84,16.42 103.76,16.02 103.6,15.91 103.52,15.51 103.63,15.35 103.55,14.95 103.38,14.84 103.3,14.44 103.41,14.27 103.33,13.87 103.17,13.76 102.49,10.38 102.63,9.72 102.8,9.61 102.89,9.21 102.78,9.05 103.54,5.58 103.9,5.3 155.3,5.3 155.44,5.44 155.85,5.44 155.99,5.3 157.67,5.3 157.85,5.47 158.54,7.14 158.54,7.55 158.4,7.69 158.4,8.1 158.54,8.24 158.54,8.65 158.4,8.79 158.4,9.19 158.54,9.33 158.54,10.67 158.4,10.81 158.4,11.22 158.54,11.36 158.54,11.93 157.86,13.58 157.86,13.58 157.01,15.62 155.35,18.11 154.66,19.78 153.87,23.76 153.87,28.97 158.28,39.61 160.74,42.07 165.1,43.88 169.77,43.88 172.64,45.06 180.13,50.07 181.71,50.72 189.3,50.72 190.97,51.42 191.5,51.42 191.64,51.56 192.04,51.56 192.18,51.42 192.59,51.42 192.73,51.56 193.14,51.56 193.28,51.42 193.69,51.42 193.83,51.56 194.24,51.56 194.38,51.42 194.78,51.42 194.92,51.56 195.33,51.56 195.47,51.42 202.75,51.42 204.23,52.4 205.52,55.52 204.91,60.51 205.66,66.5 205.33,74.82 205.06,75.22 204.67,75.38 204.12,75.38 v2(203.74,75)
  BOTTOM w0.124: v2(63.96,70.81) 63.61,71.16 63.61,71.85 64.55,73.25 65.9,73.81 69.3,73.81 70.24,73.42 70.75,72.91 70.75,72.68 71.01,72.42 71.24,72.42 71.5,72.16 71.5,71.93 71.77,71.67 71.99,71.67 72.26,71.4 72.26,71.18 72.52,70.91 72.75,70.91 73.01,70.65 73.01,70.42 73.28,70.16 73.5,70.16 74.42,69.24 76.58,64.04 77,63.62 77.06,63.59 77.56,63.38 77.79,63.16 78.72,60.9 79.27,60.36 81.69,59.35 84.17,56.88 86.06,52.32 86.06,48.58 84.62,47.15 84.62,42.91 85.26,41.36 85.62,41 86.95,40.45 87.41,40.45 87.83,40.03 87.83,39.28 88.38,38.73 93.61,38.73 96.17,41.3 96.17,42.65 97.66,44.15 101.43,44.15 102.68,43.31 102.83,43.02 102.83,34.21 105.26,31.79 105.26,22.59 105.7,22.15 106.55,22.15 106.67,22.02 v2(106.67,21.67) ; R3103.2 v2(203.74,75) C913.2
CLK_100M_PESW_S3_DB1200_DN: length 8.9
  TOP w0.124: U34.AA33 v6(197.59,78.02)
  BOTTOM w0.099: C912.1 201.92,75.62 200.33,75.62 200.23,75.72 200.03,75.72 199.93,75.62 199.29,75.62 199.18,75.72 198.99,75.72 198.88,75.62 198.22,75.62 198.12,75.72 197.92,75.72 197.82,75.62 197.39,75.62 197.19,75.82 197.19,77.92 197.29,78.02 v6(197.59,78.02)
CLK_100M_PESW_S3_DB1200_DP: length 9
  TOP w0.124: U34.AA32 v6(196.59,78.02)
  BOTTOM w0.099: C913.1 201.9,75.42 197.3,75.42 196.99,75.73 196.99,77.92 196.89,78.02 v6(196.59,78.02)
CLKBUF_M2A_OE_N: length 35.4
  TOP w0.112: U47.19 59.05,64.03 58.93,63.91 57.46,63.91 57.23,64.14 56.54,64.14 v2(56.11,63.7)
  IN2 w0.122: v2(56.11,63.7) 56.11,60.42 57.32,59.21 57.32,56.61 58.05,55.88 58.05,54.8 v2(57.35,54.1)
  BOTTOM w0.112: v2(57.35,54.1) 57.35,53.18 R2854.1 R2796.2 61.83,51.18 63.02,51.18 64.85,49.35 64.85,48.95 65.25,48.54 70.28,48.54 71.98,50.24 72.69,50.24 R4146.2
CLKBUF_M2A_OE_N_R: length 4
  BOTTOM w0.112: R4146.1 v3(75.53,49.33) 76.41,49.33 76.9,49.82 76.9,50.16 77.09,50.34 U101.1
CLKBUF_M2B_OE_N: length 31.8
  TOP w0.112: U47.20 59.05,63.53 58.95,63.63 v2(56.94,63.63)
  IN2 w0.122: v2(56.94,63.63) 56.94,60.32 57.8,59.45 57.8,56.76 58.47,56.1 58.47,54.58 v2(58.22,54.33)
  BOTTOM w0.112: v2(58.22,54.33) 58.22,53.08 59.69,51.61 63.49,51.61 64.12,50.99 65.85,50.99 R2853.1 R2795.2 67.46,50.43 67.46,50.75 67.82,51.11 68.5,51.11 69.55,50.06 71.35,50.06 72.14,50.85 73.11,50.85 R4147.2
CLKBUF_M2B_OE_N_R: length 3.5
  BOTTOM w0.112: U101.2 77.06,50.84 76.57,50.36 v3(76.38,50.36) R4147.1
CLKBUF_M2C_OE_N: length 26.2
  TOP w0.112: U47.28 59.05,59.53 58.96,59.44 57.05,59.44 56.39,58.78 56.31,58.78 v2(56.03,58.5)
  BOTTOM w0.112: R4148.2 72.14,51.38 71.53,50.77 v3(70.03,50.77) 69.34,50.77 68.73,51.38 64.97,51.38 63.65,52.71 62.34,52.71 R2794.2 R2852.1 60.8,53.73 v2(56.03,58.5)
CLKBUF_M2C_OE_N_R: length 3.4
  BOTTOM w0.112: R4148.1 v3(75.54,51.38) 75.58,51.34 U101.3
CLKBUF_M2D_OE_N: length 23.4
  TOP w0.112: v2(56.79,58.52) 57.4,59.13 58.95,59.13 59.05,59.03 U47.29
  BOTTOM w0.112: v2(56.79,58.52) 56.79,58.16 61.85,53.11 64.01,53.11 64.54,52.58 67.38,52.58 R2851.1 R2793.2 69.7,51.33 71.53,51.33 v3(72.14,51.94) 72.57,51.94 73.03,52.41 R4149.2
CLKBUF_M2D_OE_N_R: length 3.6
  BOTTOM w0.112: U101.4 76.87,51.84 v3(76.31,52.41) R4149.1
CLKBUF_M2E_OE_N: length 16.3
  TOP w0.112: U47.36 v2(61.71,55.91)
  BOTTOM w0.112: R4150.2 72.82,52.68 71.25,52.68 70.31,53.62 69.5,53.62 R2792.2 R2850.1 67.4,53.55 v3(65,53.55) 62.36,53.55 61.23,54.67 61.23,55.43 v2(61.71,55.91)
CLKBUF_M2E_OE_N_R: length 3.8
  BOTTOM w0.112: U101.5 77.11,52.34 76,53.45 v3(75.53,53.45) R4150.1
CLKBUF_M2F_OE_N: length 16.8
  TOP w0.112: U47.37 62.21,55.68 61.77,55.24 v2(61.77,55.01)
  BOTTOM w0.112: R4151.2 73.1,54.02 73.1,53.44 72.77,53.11 71.32,53.11 70.87,53.57 70.87,54.46 70.64,54.69 69.5,54.69 R2791.2 R2849.1 67.2,54.79 66.45,54.79 66.14,54.48 62.3,54.48 v2(61.77,55.01)
CLKBUF_M2F_OE_N_R: length 4.7
  BOTTOM w0.112: U101.6 77.09,52.84 76.73,53.2 v3(76.73,54.38) 76.61,54.5 R4151.1
CLKBUF_M2G_OE_N: length 12.2
  TOP w0.112: v2(65.89,55) 65.89,55.35 65.71,55.53 U47.44
  BOTTOM w0.112: v2(65.89,55) 65.97,55.09 R2941.1 R2935.2 72.59,55.09 R4152.2
CLKBUF_M2G_OE_N_R: length 6.3
  BOTTOM w0.112: U101.7 78.54,54.34 77.81,55.08 75.35,55.08 v3(74.78,55.65) 74.78,56.48 R4152.1
CLKBUF_M2H_OE_N: length 12.4
  TOP w0.112: U47.45 66.21,55.81 v2(66.14,55.74)
  BOTTOM w0.112: R4153.2 75.72,58 74.56,58 v3(73.74,57.18) 72.63,56.06 R2934.2 R2940.1 69.92,56.06 69.4,55.55 66.34,55.55 v2(66.14,55.74)
CLKBUF_M2H_OE_N_R: length 5.3
  BOTTOM w0.112: R4153.1 v3(76.13,55.64) 76.34,55.43 77.91,55.43 79.04,54.3 U101.8
CLKBUF_M2I_OE_N: length 12.7
  TOP w0.112: U47.52 v2(69.37,59.03)
  BOTTOM w0.112: v2(69.37,59.03) 69.96,58.44 70.6,58.44 71.14,58.97 R2939.1 R2933.2 v3(74.42,58.97) 75.67,58.97 76.68,57.96 77.45,57.96 78.36,57.05 R4154.2
CLKBUF_M2I_OE_N_R: length 2.9
  BOTTOM w0.112: U101.10 80.04,54.63 v3(79.63,55.04) 79.63,55.99 R4154.1
CLKBUF_M2J_OE_N: length 14.4
  TOP w0.112: v2(70.36,58.96) 69.79,59.53 U47.53
  BOTTOM w0.112: R4155.2 80.4,57.54 78.42,57.54 77.67,58.29 76.9,58.29 75.22,59.98 R2932.2 R2938.1 71.37,59.98 v2(70.36,58.96)
CLKBUF_M2J_OE_N_R: length 2.8
  BOTTOM w0.112: U101.11 80.54,54.69 v3(80.9,55.04) R4155.1
CLKBUF_M2K_OE_N: length 16.3
  TOP w0.112: U47.61 v2(69.29,63.53)
  BOTTOM w0.112: R4156.2 81.93,57.28 81.11,58.1 78.88,58.1 77.57,59.41 76.63,59.41 v3(74.08,61.95) 73.03,63.01 R2931.2 R2937.1 70.77,63.01 70.59,63.19 69.63,63.19 v2(69.29,63.53)
CLKBUF_M2K_OE_N_R: length 3.4
  BOTTOM w0.112: U101.12 81.04,54.35 81.32,54.63 81.75,54.63 v3(82.17,55.04) 82.17,55.58 81.93,55.82 R4156.1
CLKBUF_M2L_OE_N: length 18.9
  TOP w0.112: U47.62 69.97,64.03 v2(70.26,63.74)
  BOTTOM w0.112: v2(70.26,63.74) 71.2,63.74 R2936.1 R2930.2 74.04,64.04 76.99,61.09 77.12,61.09 79.63,58.58 81.55,58.58 83.35,56.78 R4157.2
CLKBUF_M2L_OE_N_R: length 3.5
  BOTTOM w0.112: U101.13 82.71,52.84 83.35,53.48 v3(83.35,54.08) R4157.1
COM_CPLD_M2A_RX: length 88.8
  TOP w0.112: v2(32.13,123.72) 31.6,123.72 30.68,124.64 J4.B46
  IN1 w0.122: v2(26.44,98.33) 27.9,99.8 30.45,99.8 33.2,102.55 33.2,115.28 32.88,115.61 32.88,119.16 31.82,121.72 31.82,123.4 v2(32.13,123.72)
  IN2 w0.122: v2(26.44,98.33) 26.67,98.09 26.67,97.48 28.59,95.56 28.59,92.71 28.72,92.58 28.72,89.13 30.83,87.02 31.63,87.02 33.07,85.57 33.07,81.69 33.83,80.92 33.83,80.44 32.96,79.57 32.96,74.72 34.81,72.87 34.81,66.47 34.02,65.68 34.02,59.78 33.49,59.25 33.49,56.24 31.6,54.35 31.6,52.74 v2(29.44,50.58)
  BOTTOM w0.112: v2(29.44,50.58) 28.91,50.05 R3924.1
COM_CPLD_M2A_RX_R: length 7.4
  BOTTOM w0.112: R3924.2 28.02,49.87 v3(26.82,49.87) 24.96,49.87 23.69,51.13 21.97,51.13 U94.H14
COM_CPLD_M2A_TX: length 84.9
  TOP w0.112: v2(32.47,122.25) 32.37,122.14 R4294.1
  IN1 w0.122: v2(32.47,122.25) 32.47,121.98 33.31,119.96 33.31,115.79 33.69,115.4 33.69,101.61 31.45,99.36 29.29,99.36 25.88,95.95 v2(24.72,95.95)
  IN2 w0.122: v2(24.72,95.95) 24.26,95.49 24.26,91.59 24.83,91.02 24.83,86.94 26.24,85.54 26.24,77.18 24.93,75.88 24.93,73.35 26.17,72.11 26.17,65.76 24.76,64.35 24.76,60.52 24.82,60.37 25.12,60.07 25.12,54.09 24.7,53.67 24.7,48.72 v2(24.09,48.11)
  BOTTOM w0.112: U94.E16 23.55,48.65 v2(24.09,48.11)
COM_CPLD_M2A_TX_R: length 4.8
  TOP w0.112: R4294.2 32.26,122.94 32.81,123.49 32.81,123.78 32.44,124.15 31.73,124.15 31.18,124.7 31.18,125.97 J4.B48
COM_CPLD_M2B_RX: length 103.4
  TOP w0.112: J4.A46 54.68,125.04 55.73,123.99 v2(56.34,123.99)
  IN1 w0.122: v2(64.54,105.9) 64.36,105.71 64.36,100.58 59.09,95.31 53.99,90.21 53.15,88.17 51.52,86.54 50.69,86.2 49.01,86.2 45.64,82.83 44.17,82.83 42.89,81.55 39.39,81.55 38.96,81.11 37.6,81.11 36.69,80.2 33.89,80.2 v2(33.38,80.72)
  IN2 w0.122: v2(33.38,80.72) 32.46,79.8 32.46,74.61 34.32,72.75 34.32,66.8 33.02,65.5 33.02,56.42 31.17,54.56 31.17,53.18 v2(29.91,51.93) ; v2(56.34,123.99) 56.93,123.4 56.93,122.54 60.56,118.91 60.56,116.89 60.72,116.73 60.72,115.61 61.64,114.69 61.64,113.37 62.84,112.17 62.84,109.42 64.92,107.34 64.92,106.28 v2(64.54,105.9)
  BOTTOM w0.112: v2(29.91,51.93) 29.19,51.21 R3925.1
COM_CPLD_M2B_RX_R: length 4.9
  BOTTOM w0.112: R3925.2 27.44,51.21 27.38,51.15 v3(26.83,51.15) 24.54,51.15 24.04,51.65 U94.H16
COM_CPLD_M2B_TX: length 110.9
  TOP w0.112: v2(57.41,122.7) 57.17,122.46 R4295.1
  IN1 w0.122: v2(25.58,79.75) 26.96,81.13 31.82,81.13 33.22,79.73 36.98,79.73 37.85,80.59 39.07,80.59 39.59,81.12 43.14,81.12 44.35,82.32 45.77,82.32 49.05,85.61 50.37,85.61 51.76,86.18 53.54,87.97 53.96,88.97 54.26,89.69 54.26,89.69 54.39,90 54.39,90 61.67,97.29 64.78,100.4 64.78,105.31 65.1,105.62 65.1,106.21 v2(65.64,106.75)
  IN2 w0.122: v2(65.64,106.75) 65.35,107.04 65.35,107.54 63.32,109.57 63.32,112.52 62.1,113.74 62.1,115.88 61.76,116.23 61.76,118.35 v2(57.41,122.7) ; v2(22.95,49.15) 23.28,49.15 24.27,50.13 24.27,53.85 24.69,54.27 24.69,59.88 24.45,60.12 24.28,60.52 24.28,64.62 25.69,66.02 25.69,71.96 24.49,73.16 24.49,73.64 23.97,74.15 23.97,75.66 25.58,77.26 v2(25.58,79.75)
  BOTTOM w0.112: U94.F15 v2(22.95,49.15)
COM_CPLD_M2B_TX_R: length 4
  TOP w0.112: R4295.2 56.83,123.81 56.83,124.11 56.67,124.35 56.36,124.48 55.78,124.48 55.18,125.08 J4.A48
COM_CPLD_M2C_RX: length 112.7
  TOP w0.112: v2(79.32,124.03) 79.05,124.03 78.68,124.39 J36.B46
  IN1 w0.122: v2(69.33,85.06) 69.33,85.81 70.55,87.03 70.55,89.53 76.18,95.17 76.18,95.39 80.03,99.24 80.03,107.03 81.72,108.72 81.72,109.63 81.29,110.68 81.29,119.27 80.91,120.17 79.87,121.21 79.87,123.47 v2(79.32,124.03)
  IN2 w0.122: v2(29.91,53.66) 30.3,54.05 30.3,55.19 31.63,56.52 31.63,65.53 32.68,66.58 32.68,72.61 v2(31.39,73.9)
  BOTTOM w0.112: R3926.1 29.62,53.95 v2(29.91,53.66) ; v2(69.33,85.06) 69.33,84.66 66.51,81.84 63.47,81.84 60.97,79.34 53.92,79.34 52.66,78.08 48.81,78.08 47.45,76.72 42.1,76.72 39.28,73.9 v2(31.39,73.9)
COM_CPLD_M2C_RX_R: length 5.6
  BOTTOM w0.112: R3926.2 27.6,53.95 v3(27.32,53.67) 26.67,53.02 25.29,53.02 24.92,52.65 U94.J16
COM_CPLD_M2C_TX: length 123.5
  TOP w0.112: R4296.1 80.87,122.4 v2(80.97,122.3)
  IN1 w0.122: v2(80.97,122.3) 81.72,120.5 81.72,110.8 82.2,109.63 82.2,108.59 80.45,106.85 80.45,99.06 76.61,95.22 76.61,94.99 71.03,89.41 71.03,86.65 v2(69.92,85.55)
  IN2 w0.122: v2(22.92,73.23) 22.92,71.6 23.18,71.34 23.18,70.32 22.34,69.48 22.34,66.35 21.85,65.85 21.85,58.9 22.4,58.35 22.4,51.29 21.46,50.36 21.46,49.81 20.95,49.3 v2(20.95,49.15)
  BOTTOM w0.112: U94.F13 v2(20.95,49.15) ; v2(69.92,85.55) 69.92,83.43 67.95,81.46 63.63,81.46 61.13,78.95 54.08,78.95 52.82,77.7 49.98,77.7 48.61,76.33 42.31,76.33 41.67,75.69 41.67,75.04 41.28,74.65 40.95,74.65 39.46,73.17 30.32,73.17 29.43,74.05 25.36,74.05 25,73.7 24.05,73.7 24.03,73.72 23.42,73.72 v2(22.92,73.23)
COM_CPLD_M2C_TX_R: length 3.2
  TOP w0.112: R4296.2 80.32,123.76 79.18,124.9 79.18,125.97 J36.B48
COM_CPLD_M2D_RX: length 134.8
  TOP w0.112: v2(102.11,122.1) 102.25,122.24 102.25,123.96 102.68,124.39 J36.A46
  IN1 w0.122: v2(102.11,122.1) 102.11,120.88 103.25,119.74 103.25,114.31 102.86,113.39 102.86,108.89 103.81,107.95 104.01,107.45 104.01,92.47 100.82,89.28 95.27,89.28 85.32,79.33 75.31,79.33 73.04,77.06 65.38,77.06 63.84,75.51 51.31,75.51 47.1,71.31 41.24,71.31 40.79,71.76 39.91,71.76 39.57,72.1 35.27,72.1 v2(33.88,70.7)
  IN2 w0.122: v2(29.92,52.72) 30.73,53.53 30.73,54.91 32.08,56.25 32.08,65.23 33.88,67.03 v2(33.88,70.7)
  BOTTOM w0.112: v2(29.92,52.72) 29.92,52.72 R3927.1
COM_CPLD_M2D_RX_R: length 7.5
  BOTTOM w0.112: R3927.2 27.71,52.72 v3(27.35,52.36) 27.14,52.15 22,52.15 21.5,52.65 U94.J14
COM_CPLD_M2D_TX: length 150
  TOP w0.112: R4297.1 102.56,121.39 v2(101.57,121.39)
  IN1 w0.122: v2(21.33,73.35) 21.71,73.73 24.36,73.73 25.85,72.24 27.41,72.24 27.84,71.81 32.52,71.81 33.28,72.57 39.71,72.57 40.09,72.19 40.97,72.19 41.42,71.74 46.92,71.74 51.13,75.95 63.66,75.95 65.2,77.49 72.86,77.49 75.13,79.76 85.14,79.76 95.09,89.71 100.64,89.71 103.58,92.65 103.58,107.31 103.41,107.71 102.43,108.69 102.43,113.48 102.81,114.4 102.81,119.56 101.57,120.8 v2(101.57,121.39)
  IN2 w0.122: v2(21.33,73.35) 21.33,73.05 20.64,72.36 20.64,70.15 20.99,69.81 20.99,66.3 19.58,64.89 19.58,62.93 20.89,61.62 20.89,57.92 21.4,57.41 21.4,55.88 20.88,55.36 20.88,54.62 20.41,54.16 20.41,50.92 19.95,50.46 v2(19.95,50.15)
  BOTTOM w0.112: U94.G12 v2(19.95,50.15)
COM_CPLD_M2D_TX_R: length 3.6
  TOP w0.112: R4297.2 102.85,123.44 103.18,123.77 J36.A48
COM_CPLD_M2E_RX: length 170.3
  TOP w0.112: v2(127.23,124.57) 126.68,125.12 J38.B46
  IN1 w0.122: v2(127.23,124.57) 127.23,123.93 128.65,122.51 129.92,116.1 129.92,110.48 129.86,110.41 129.86,109.58 130.05,108.6 130.05,105.83 130.4,104.99 130.4,104.52 130.51,104.26 130.51,101.12 104.14,74.76 96.14,74.76 90,68.61 85.62,68.61 84.09,67.08 v2(82.98,67.08)
  IN2 w0.122: v2(29.91,55.55) 31.2,56.84 31.2,65.74 32.25,66.79 32.25,71.9 v2(31.86,72.29)
  BOTTOM w0.112: v2(31.86,72.29) 39.1,72.29 39.75,71.63 39.75,71.29 40.69,70.35 47.22,70.35 v3(48.38,71.51) 48.38,73.33 50.8,75.75 53.63,75.75 54.89,77 61.94,77 64.44,79.51 73.76,79.51 80.19,73.08 80.19,69.41 82.52,67.08 v2(82.98,67.08) ; R3928.1 29.86,55.5 v2(29.91,55.55)
COM_CPLD_M2E_RX_R: length 7.2
  BOTTOM w0.112: U94.J15 22.89,53.09 24.66,53.09 26.54,54.96 v3(27.34,54.96) 27.88,55.5 R3928.2
COM_CPLD_M2E_TX: length 185.8
  TOP w0.112: v2(128.14,123.94) 128.6,123.48 R4298.1
  IN1 w0.122: v2(81.76,67.11) 82.32,66.55 84.28,66.55 85.88,68.15 90.15,68.15 96.33,74.33 103.97,74.33 104.32,74.33 130.93,100.94 130.93,104.35 130.83,104.6 130.83,105.07 130.48,105.91 130.48,108.68 130.28,109.67 130.28,110.18 130.38,110.27 130.38,116.2 129.01,123.06 v2(128.14,123.94)
  IN2 w0.122: v2(21.95,49.15) 22.41,49.61 23.06,49.61 23.83,50.37 23.83,59.63 23.41,60.05 23.41,64.65 25.21,66.45 25.21,71.73 24.46,72.48 v2(24.4,72.48)
  BOTTOM w0.112: v2(24.4,72.48) 24.94,72.48 25.57,71.85 28.99,71.85 31.27,69.57 40.47,69.57 40.87,69.96 47.82,69.96 49.09,71.23 49.09,73.49 50.96,75.36 53.79,75.36 55.05,76.62 62.1,76.62 64.6,79.12 73.6,79.12 79.8,72.92 79.8,69.07 v2(81.76,67.11) ; U94.F14 v2(21.95,49.15)
COM_CPLD_M2E_TX_R: length 3.1
  TOP w0.112: R4298.2 127.69,123.29 127.69,124.76 127.18,125.27 J38.B48
COM_CPLD_M2F_RX: length 178.5
  TOP w0.112: v2(151.07,122.99) 151.07,124.62 150.68,125.01 150.68,125.97 J38.A46
  IN1 w0.122: v2(151.07,122.99) 151.33,122.73 151.33,121.95 151.84,121.44 152.76,119.22 152.76,117 152.13,116.37 152.13,111.44 152.82,109.77 152.82,107.41 151.11,105.7 151.11,104.35 109.47,62.71 105.4,62.71 100.34,57.65 95.45,55.62 93.74,54.92 84.95,54.92 84.38,54.35 83.3,54.35 80.9,51.94 80.5,51.94 79.8,51.25 78.21,51.25 72.88,45.92 69.59,45.92 69.36,46.13 56.3,46.13 56.07,45.9 55,45.9 54.72,46.18 54.26,46.18 54.01,46.42 50.19,46.42 46.89,49.72 46.89,50.29 46.35,50.83 41.64,50.83 41.61,50.8 41.23,50.8 40.69,50.26 37.9,50.26 37.36,49.72 31.07,49.72 v2(30.29,50.5)
  BOTTOM w0.112: v2(30.29,50.5) 30.29,51.23 30.36,51.3 30.36,56.65 30.03,56.98 R3929.1
COM_CPLD_M2F_RX_R: length 6.4
  BOTTOM w0.112: U94.K16 24.21,53.65 v3(27.05,56.49) 27.54,56.98 R3929.2
COM_CPLD_M2F_TX: length 177.5
  TOP w0.112: v2(151.89,122.17) 152.4,122.68 R4299.1
  IN1 w0.122: v2(24.94,48.16) 25.46,48.68 28.24,48.68 28.62,48.29 37.1,48.29 38.62,49.81 45.16,49.81 47.79,47.18 47.79,45.77 48.47,45.1 48.96,45.1 49.84,45.98 53.38,45.98 53.75,45.61 54.46,45.61 54.6,45.47 56.52,45.47 56.81,45.17 59.86,45.17 60.39,45.7 69.13,45.7 69.34,45.49 74.43,45.49 79.48,50.54 79.7,50.54 80.41,51.25 80.8,51.25 83.48,53.92 84.76,53.92 85.33,54.49 93.92,54.49 95.17,55.01 100.52,57.22 104.52,61.23 104.97,61.41 108.13,61.41 109.24,61.87 151.55,104.18 151.55,105.5 153.57,107.52 153.57,109.53 153.19,110.45 153.19,113.01 152.69,113.5 152.69,116.26 153.19,116.76 153.19,119.39 152.17,121.84 151.89,122.13 v2(151.89,122.17)
  BOTTOM w0.112: U94.F16 v2(24.94,48.16)
COM_CPLD_M2F_TX_R: length 3.3
  TOP w0.112: R4299.2 151.97,123.48 151.66,123.79 151.66,124.69 151.18,125.17 J38.A48
COM_CPLD_M2G_RX: length 206.1
  TOP w0.112: R3930.1 v4(25.8,50.34)
  IN1 w0.122: v2(156.1,129.73) 155.72,129.35 155.72,126.79 156.05,126.45 156.05,122.06 157.74,120.38 157.74,118.85 158.52,118.06 158.52,113.4 159.25,112.67 159.25,108.17 157.68,106.6 156.72,106.12 155.08,104.48 155.08,103.07 149.92,97.92 149.92,95.72 112.83,58.63 111.59,58.63 94.69,51.62 89.8,51.62 89,50.82 85.14,50.82 82.08,47.76 80.72,47.76 71.46,38.5 68.94,38.5 68.31,37.86 64.24,37.86 64.11,37.73 57.48,37.73 56.21,36.46 39.89,36.46 39.62,36.73 34.68,36.73 34.27,36.55 33.12,36.55 32.91,36.35 29.54,36.35 27.45,38.44 v2(25.55,38.44)
  IN2 w0.122: v4(25.8,50.34) 25.4,49.94 25.4,45.4 26.51,44.29 26.51,39.4 25.55,38.44 v2(25.55,38.44)
  BOTTOM w0.112: J8.B46 156.42,133.22 156.42,130.27 156.1,129.95 v2(156.1,129.73)
COM_CPLD_M2G_RX_R: length 6.1
  TOP w0.112: v2(18.95,51.15) 19.41,50.68 21.47,50.68 v1(21.92,51.13) 22.37,50.68 23.21,50.68 23.55,50.34 R3930.2
  BOTTOM w0.112: U94.H11 v2(18.95,51.15)
COM_CPLD_M2G_TX: length 208.6
  IN1 w0.122: v2(20.22,37.65) 21.22,36.64 22.32,36.64 22.91,37.23 28.04,37.23 29.37,35.9 32.49,35.9 32.73,35.67 33.55,35.67 33.81,35.92 33.89,35.96 33.95,35.96 34.77,36.3 39.44,36.3 39.78,35.96 50.16,35.96 51.55,34.57 54.92,34.57 57.66,37.3 64.29,37.3 64.41,37.43 68.48,37.43 69.12,38.07 71.63,38.07 80.41,46.85 82.49,46.85 84.06,48.42 84.06,49.14 85.31,50.39 89.18,50.39 89.98,51.2 94.77,51.2 111.68,58.2 113.7,58.2 150.46,94.97 150.46,97.75 155.54,102.83 155.54,104.34 156.97,105.77 157.8,106.11 160.59,108.91 160.59,111.93 158.97,113.56 158.97,118.24 158.19,119.03 158.19,120.53 156.48,122.23 156.48,127.08 v2(156.16,127.41)
  IN2 w0.122: v2(19.95,49.15) 19.51,48.7 19.51,44.66 20.22,43.95 v2(20.22,37.65)
  BOTTOM w0.112: U94.F12 v2(19.95,49.15) ; R4300.1 155.72,127.85 v2(156.16,127.41)
COM_CPLD_M2G_TX_R: length 4.6
  BOTTOM w0.112: R4300.2 155.51,129.06 155.51,130.12 155.92,130.53 J8.B48
COM_CPLD_M2H_RX: length 194.1
  TOP w0.112: R3931.1 25.59,52.45 v2(25.73,52.58)
  IN1 w0.122: v2(82.17,65.84) 83.82,65.84 85.18,64.47 90.68,64.47 97.89,71.68 105.72,71.68 136.25,102.21 136.25,110.07 135.51,111.86 135.51,116.17 136.36,117.02 136.36,117.91 135.9,118.37 135.44,118.37 134.53,119.28 134.53,119.75 134.83,120.04 135.09,120.04 135.42,120.38 135.42,120.99 134.75,121.67 v2(134.75,125.42)
  IN2 w0.122: v2(25.73,52.58) 25.73,53.48 26.06,53.81 26.06,55.5 26.41,55.85 26.41,61.52 27.11,62.21 v2(27.11,70.98)
  BOTTOM w0.112: J8.A46 132.42,131.84 131.38,130.79 131.38,129.52 131.62,129.28 132.03,129.28 132.31,129 132.31,126.92 133.81,125.42 v2(134.75,125.42) ; v2(27.11,70.98) 29.16,68.93 32.83,68.93 33.5,68.26 43.09,68.26 43.92,69.09 48.62,69.09 55.37,75.83 62.42,75.83 64.73,78.14 73.31,78.14 79.02,72.44 79.02,68.68 81.86,65.84 v2(82.17,65.84)
COM_CPLD_M2H_RX_R: length 3.7
  TOP w0.112: v4(20.95,53.15) 22.24,53.15 22.94,52.45 R3931.2
  BOTTOM w0.112: U94.J13 v4(20.95,53.15)
COM_CPLD_M2H_TX: length 197.7
  IN1 w0.122: v2(83.81,65.08) 84.86,64.03 90.88,64.03 98.09,71.25 105.91,71.25 136.69,102.03 136.69,110.15 135.94,111.97 135.94,115.99 136.81,116.86 136.81,118.23 136.2,118.84 136.2,123.02 135.23,123.98 v2(135.23,124.74)
  IN2 w0.122: v2(20.95,50.15) 20.95,50.48 21.4,50.93 21.4,55.27 21.83,55.7 21.83,57.61 21.38,58.05 21.38,62.12 21.41,62.15 21.41,70.1 21.07,70.45 21.07,71.95 21.5,72.38 v2(21.57,72.38)
  BOTTOM w0.112: v2(135.23,124.74) 133.81,124.74 131.79,126.76 R4301.1 ; v2(83.81,65.08) 83.67,65.23 81.88,65.23 78.63,68.47 78.63,72.28 73.15,77.75 64.89,77.75 62.58,75.45 55.53,75.45 47.96,67.87 32.66,67.87 32.35,68.19 29.08,68.19 25.91,71.35 25.44,71.35 24.86,71.94 23.75,71.94 23.36,72.33 21.62,72.33 v2(21.57,72.38) ; U94.G13 v2(20.95,50.15)
COM_CPLD_M2H_TX_R: length 5.4
  BOTTOM w0.112: J8.A48 131.92,132.2 130.97,131.25 130.97,129.35 R4301.2
COM_CPLD_M2I_RX: length 159.6
  TOP w0.112: R3932.1 v2(26.43,53.47)
  IN1 w0.122: v2(28.14,70.99) 28.49,71.34 32.12,71.34 33.21,70.26 34.25,70.26 35.31,71.31 39.71,71.31 40.57,70.46 43.74,70.46 44.31,69.89 47.01,69.89 49.33,72.21 52.34,72.21 54.02,73.89 64.52,73.89 65.31,74.68 68.63,74.68 70.78,72.53 71.74,72.53 72.65,72.91 76.63,76.89 86.25,76.89 93.74,84.37 101.6,84.37 110.68,93.46 110.68,101.93 111.73,102.98 111.73,103.65 110.83,105.82 v2(110.83,106.25)
  IN2 w0.122: v2(26.43,53.47) 26.6,53.64 26.6,54.56 27.35,55.32 27.35,60.98 28.14,61.77 v2(28.14,70.99) ; v2(106.61,123.08) 107,123.08 107.41,122.67 107.41,122.09 107.01,121.69 107.01,112.54 109.7,109.84 109.7,108.76 110.58,107.89 110.58,106.89 110.83,106.63 v2(110.83,106.25)
  BOTTOM w0.112: v2(106.61,123.08) 107.39,123.87 107.39,124.61 107.76,124.98 107.76,129.33 107.39,129.7 107.39,130.25 108.42,131.28 108.42,133.22 J34.B46
