# Allegro board 6097_f09b_gpv2_carrier_d_v05_1126_1000_OCP.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SMB_M2H_ALERT_LVC_N_R: length 5.3
  TOP w0.112: R4200.1 R4217.1 101.24,58.04 v1(100.81,57.61) 99.89,58.53 U104.10
SMB_M2H_ALERT_N: length 98.8
  TOP w0.112: U104.11 v2(100.13,59.18)
  IN1 w0.122: v2(134.35,126.07) 134.09,125.82 134.09,119.07 135.33,117.84 135.33,116.61 134.99,116.28 134.99,109.93 135.74,109.18 v2(135.74,108.87) 135.74,107.46 135.83,107.37 135.83,102.38 105.6,72.16 v2(104.26,72.16)
  BOTTOM w0.112: v2(135.74,108.87) 135.96,109.09 R4322.2 ; J8.A44 132.92,133.22 132.92,130.99 v3(131.9,129.97) 132.71,129.17 132.71,127.11 133.74,126.07 v2(134.35,126.07) ; v2(100.13,59.18) 100.69,58.62 104.5,58.62 105.14,59.26 105.14,71.28 v2(104.26,72.16)
SMB_M2H_INA231_ALRT_N: length 146.2
  TOP w0.112: U86.P4 44.26,47.24 43.8,47.24 43.64,47.09 43.01,47.09 v5(42.93,47) ; v2(126.66,108.48) 126.45,108.48 126.04,108.07 122.91,108.07 121.56,109.43 120.94,109.43 120.68,109.16 120.68,107.94 120.44,107.7 119.45,107.7 119.26,107.89 118.32,107.89 116.95,106.52 115.41,106.52 115.18,106.3 115.18,99.7 115.54,99.34 115.84,99.34 v2(116.88,98.29)
  IN1 w0.122: v2(70.74,42.89) 69.99,42.89 69.94,42.94 66.81,42.94 66.54,42.67 65.62,42.29 64.9,41.57 64.9,40.98 64.5,40.58 62.71,40.58 61.37,41.91 56.35,41.91 54.81,43.45 53.56,43.45 53.27,43.74 50.77,43.74 50.06,43.03 49.8,42.4 49.73,42.33 49.33,42.33 49,42.66 49,43.35 48.37,43.99 48.31,43.99 45.77,46.53 44.79,46.53 44.24,47.08 43.01,47.08 v5(42.93,47)
  IN2 w0.122: v2(70.74,42.89) 71.58,42.89 77.5,48.82 77.5,51.54 86.62,60.66 99.23,60.66 100.12,61.55 107.64,61.55 v2(107.95,61.86)
  BOTTOM w0.112: R4026.2 126.15,107.97 v2(126.66,108.48) ; v2(116.88,98.29) 116.88,88.55 107.98,79.65 107.98,61.94 107.95,61.91 v2(107.95,61.86)
SMB_M2H_INA231_ALRT_N_R: length 8.4
  BOTTOM w0.112: U83.A3 123.28,111.44 v3(123.68,111.05) 123.68,108.05 124.56,107.17 R3893.1 R4026.1
SMB_M2H_INA231_CLK_R1: length 9.2
  BOTTOM w0.112: U83.A1 122.48,109.09 122.29,108.91 122.29,106.88 v3(121.74,106.32) 122.41,105.66 R3714.1
SMB_M2H_INA231_DAT_R1: length 7
  BOTTOM w0.112: U83.A2 v3(122.88,108.36) 122.88,106.87 R3715.1
SMB_M2H_P1V8_CLK: length 56.2
  TOP w0.112: R3841.2 141.63,108.34 141.72,108.43 142.08,108.43 142.11,108.46 142.11,108.46 142.48,108.83 v2(142.48,108.89)
  IN2 w0.122: v2(142.48,108.89) 142.45,108.89 142.45,108.94 141,110.39 141,114.43 140.02,116.79 140.02,125.42 137.1,128.34 137.1,130.41 133.72,133.79 133.72,134.43 v2(132.58,135.56)
  BOTTOM w0.112: R3714.2 124.5,106.3 127.45,106.3 129.99,108.84 132.61,108.84 133.44,108.01 140.41,108.01 v3(140.58,108.18) 140.82,108.43 142.03,108.43 142.45,108.85 142.45,108.89 v2(142.48,108.89) ; J8.A40 133.92,133.22 133.92,134.92 133.28,135.56 v2(132.58,135.56)
SMB_M2H_P1V8_CLK_R2: length 183.6
  TOP w0.112: v2(21,42.1) 20.12,41.21 R3065.2 19.45,39.24 19.02,38.81 19.02,37.62 v1(19.44,37.2) 19.59,37.2 20.47,36.31 U91.7 ; v2(141.87,107.95) 141.61,107.69 140.44,107.69 140.26,107.87 R3841.1
  IN1 w0.122: v2(141.87,107.95) 141.87,107.47 142.52,105.89 143.39,105.02 143.39,104.51 107.14,68.25 99.33,68.25 92.05,60.98 81.9,60.98 80.77,62.11 78.9,62.11 77.9,61.11 73.55,61.11 70.36,57.92 70.36,56.63 69.63,55.9 69.26,55.9 67.83,57.33 59.97,57.33 58.4,55.75 v2(57.53,55.75)
  BOTTOM w0.112: v2(57.53,55.75) 57.03,56.25 57.03,56.49 54.86,58.66 54.86,60.99 52.98,62.87 50.09,62.87 48.8,61.58 45.59,61.58 45.19,61.99 45.18,61.99 45.14,62.03 44.84,62.33 32.91,62.33 32.9,62.33 32.26,62.33 30.99,61.07 30.99,59.88 30.96,59.85 30.96,50.43 27.89,47.37 27.89,43.21 25.89,41.2 23.16,41.2 22.2,42.16 21.07,42.16 v2(21,42.1)
SMB_M2H_P1V8_DAT: length 52.4
  TOP w0.112: R3842.2 141.7,109.01 v2(141.84,108.87)
  IN2 w0.122: v2(141.84,108.87) 141.7,108.87 140.39,110.18 140.39,114.74 139.37,117.19 139.37,125.36 136.67,128.06 136.67,130.24 133.21,133.7 133.21,134.16 v2(132.6,134.78)
  BOTTOM w0.112: J8.A42 133.42,134.58 133.22,134.78 v2(132.6,134.78) ; v2(141.84,108.87) 139.93,108.87 139.5,108.43 133.57,108.43 132.77,109.24 132.1,109.24 v3(131.9,109.44) 131.7,109.24 129.83,109.24 127.29,106.7 R3715.2
SMB_M2H_P1V8_DAT_R2: length 181.5
  TOP w0.112: R3842.1 142.92,109.23 142.92,108.71 142.5,108.29 v2(142.5,107.94) ; v2(21.82,41.7) 21.47,41.35 21.47,39.47 R3066.2 20.68,38.68 20.68,37.67 21.12,37.22 v1(21.12,36.78) U91.6
  IN1 w0.122: v2(142.5,107.94) 142.5,107.2 142.97,106.08 143.82,105.23 143.82,104.33 107.31,67.83 99.51,67.83 92.23,60.55 81.49,60.55 80.36,61.68 79.18,61.68 78.18,60.68 73.72,60.68 70.82,57.77 70.82,56.48 68.91,54.58 66.09,54.58 66.07,54.56 59.64,54.56 59.08,55.12 56.83,55.12 56.35,55.6 56.35,56.28 v2(56.42,56.35)
  BOTTOM w0.112: v2(56.42,56.35) 56.22,56.54 56.22,56.74 54.19,58.78 54.19,60.85 52.59,62.45 50.36,62.45 49.1,61.19 45.43,61.19 44.98,61.64 44.68,61.94 32.74,61.94 32.74,61.94 32.42,61.94 31.38,60.9 31.38,50.3 28.32,47.24 28.32,42.85 26.26,40.79 22.73,40.79 v2(21.82,41.7)
SMB_M2I_ALERT_LVC_N: length 113.6
  TOP w0.112: U86.T6 43.41,48.4 v5(43.41,47.99) ; R4201.2 102.67,60.52 v2(102.67,60.83)
  IN1 w0.122: v2(96.95,85.29) 94.05,85.29 86.07,77.32 76.45,77.32 72.5,73.37 72.4,73.27 71.64,72.96 70.97,72.96 68.26,75.67 65.68,75.67 64.34,74.32 53.84,74.32 52.17,72.64 49.05,72.64 46.72,70.32 44.64,70.32 v2(44.17,70.79)
  IN2 w0.122: v2(44.17,70.79) 44.12,70.74 44.12,61.75 44.99,60.88 44.99,60.06 44.84,59.71 v2(44.39,59.26)
  BOTTOM w0.112: v2(44.39,59.26) 44.02,58.89 44.02,53.36 44.34,53.04 44.34,50.59 43.71,49.96 43.71,48.79 43.41,48.49 v5(43.41,47.99) ; v2(102.67,60.83) 102.67,79.32 96.95,85.04 v2(96.95,85.29)
SMB_M2I_ALERT_LVC_N_R: length 5
  TOP w0.112: R4201.1 R4212.1 101.04,59.06 v1(100.9,59.2) 100.26,59.83 U104.12
SMB_M2I_ALERT_N: length 93.1
  TOP w0.112: v2(100.94,59.97) 100.43,60.48 U104.13
  IN1 w0.122: v2(97.79,84.91) 101.53,84.91 110.25,93.63 110.25,102.1 111.3,103.15 111.3,103.57 110.17,106.3 v2(110.17,106.64)
  IN2 w0.122: v2(110.17,106.64) 109.95,106.86 109.95,107.8 109.19,108.56 109.19,109.63 106.37,112.46 106.37,121.82 v2(106.94,122.39)
  BOTTOM w0.112: v2(97.79,84.91) 103.1,79.6 103.1,60.65 102.42,59.97 v2(100.94,59.97) ; v2(110.17,106.64) 110.17,107.88 109.66,108.4 R4323.2 ; J34.B44 108.92,131.63 108.92,131.62 108.92,131.55 108.89,131.52 108.89,131.14 107.94,130.19 v3(107.94,129.99) 107.94,129.76 108.23,129.47 108.23,123.62 107,122.39 v2(106.94,122.39)
SMB_M2I_INA231_ALRT_N: length 136.8
  TOP w0.112: U86.E3 44.93,42.92 v6(44.42,42.92)
  IN1 w0.122: v2(69.08,42.28) 68.68,41.89 68.04,41.89 68.01,41.92 67.31,41.92 67.06,41.66 67.06,40.95 65.37,39.26 61.95,39.26 60.96,40.25 59.41,40.25 59.16,39.99 56.41,39.99 56.02,39.6 54.35,39.6 53.35,40.6 53.35,40.97 51.86,42.45 51.48,42.45 51.28,42.26 51.17,41.99 51.17,41.84 50.45,41.12 50.45,40.63 50.17,40.34 49.08,40.34 48.64,40.78 48.64,41.78 47.5,42.92 v6(44.42,42.92)
  IN2 w0.122: v2(69.08,42.28) 69.09,42.28 69.09,42.53 77.03,50.47 77.03,51.76 87.5,62.24 101.25,62.24 101.46,62.03 107.01,62.03 107.14,62.16 v2(107.2,62.16) ; v2(117.72,101.48) 117.14,101.48 115.15,103.46 112.3,103.46 111.38,103.85 110.71,104.51 109.34,105.08 108.06,106.36 107.61,107.45 v2(107.61,107.74)
  BOTTOM w0.112: R4025.2 107.21,107.34 v2(107.61,107.74) ; v2(107.2,62.16) 107.2,62.21 107.23,62.25 107.23,80.66 115.95,89.38 v3(115.95,98.99) 115.95,99.7 v2(117.72,101.48)
SMB_M2I_INA231_ALRT_N_R: length 12
  BOTTOM w0.112: R4025.1 R3892.1 104.52,106.66 103.61,106.66 102.9,107.37 102.45,107.37 102.11,107.51 101.77,107.85 101.26,107.85 100.66,108.46 100.66,109.82 100.79,109.94 v3(100.79,110.62) 100.79,112.06 U82.A3
SMB_M2I_INA231_CLK_R1: length 4.1
  BOTTOM w0.112: R3706.1 98.17,110.54 v3(98.25,110.62) 98.71,111.07 U82.A1
SMB_M2I_INA231_DAT_R1: length 4.2
  BOTTOM w0.112: U82.A2 99.11,111.03 v3(99.52,110.62) 99.52,109.75 R3707.1
SMB_M2I_P1V8_CLK: length 48.4
  TOP w0.112: v2(111.95,106.19) 112.75,106.99 R3852.2
  IN1 w0.122: v2(109.92,131.24) 109.92,130.25 109.39,129.71 109.39,127.27 109.42,127.19 109.69,125.85 109.69,118.84 110.79,113.28 110.79,109.78 111.38,108.37 111.96,107.79 112.35,106.85 112.35,106.59 v2(111.95,106.19)
  BOTTOM w0.112: J34.B40 v2(109.92,131.24) ; v2(111.95,106.19) 111.95,106.05 110.99,105.09 107.87,105.09 107.29,104.51 v3(106.75,104.51) 98.27,104.51 97.64,105.13 97.64,108.12 R3706.2
SMB_M2I_P1V8_CLK_R2: length 119
  TOP w0.112: U92.5 43.11,72.83 43.3,73.03 43.3,73.79 42.93,74.17 v1(42.93,74.6) 42.93,76.04 R3067.2 45.74,78.86 47.54,78.86 48.44,79.76 50.87,79.76 51.13,79.49 51.13,77.9 49.07,75.83 49.07,72.56 46.8,70.29 v2(46.8,68.48) ; R3852.1 113.77,106.95 112.77,105.95 v2(112.56,105.95)
  IN1 w0.122: v2(112.56,105.95) 112.65,105.86 112.65,104.83 113.01,103.97 113.01,102.45 111.96,101.4 111.96,92.9 102.13,83.08 94.28,83.08 86.79,75.59 77.16,75.59 73.38,71.81 72,71.24 70.24,71.24 68.19,73.29 65.8,73.29 65.02,72.52 54.74,72.52 53.09,70.87 50.04,70.87 47.65,68.48 v2(46.8,68.48)
SMB_M2I_P1V8_DAT: length 47.5
  TOP w0.112: R3853.2 112.07,104.32 111.46,104.94 111.46,106.44 v2(111.85,106.84)
  IN1 w0.122: v2(111.85,106.84) 111.86,106.84 111.57,107.52 111.02,108.08 110.36,109.66 110.36,113.22 108.95,120.31 108.95,127.01 108.87,127.39 108.71,127.78 108.71,129.66 109.3,130.25 v2(109.3,130.56)
  BOTTOM w0.112: v2(111.85,106.84) 111.38,106.37 111.38,106.08 110.96,105.66 v3(108.68,105.66) 106.47,105.66 105.75,104.94 99.89,104.94 99.21,105.62 R3707.2 ; J34.B42 109.42,131.57 109.3,131.45 v2(109.3,130.56)
SMB_M2I_P1V8_DAT_R2: length 117.8
  TOP w0.112: v2(45.14,68.48) 45.14,69.19 48.68,72.72 48.68,76.15 50.65,78.12 50.65,79.07 50.39,79.33 48.64,79.33 47.69,78.38 46.41,78.38 R3068.2 44.04,76.02 44.04,73.76 v1(43.99,73.71) 43.76,73.48 U92.4 ; v2(112.21,105.37) 112.75,105.37 113.27,104.84 R3853.1
  IN1 w0.122: v2(112.21,105.37) 112.21,104.73 112.58,103.82 112.58,102.62 111.53,101.57 111.53,93.1 101.94,83.51 94.1,83.51 86.61,76.02 76.98,76.02 73.14,72.17 71.91,71.67 70.42,71.67 68.37,73.72 65.57,73.72 64.88,73.03 54.38,73.03 52.7,71.35 49.84,71.35 47.45,68.96 45.63,68.96 v2(45.14,68.48)
SMB_M2IJ_3V3SB_CLK: length 24.7
  TOP w0.112: R3856.1 49.45,56.98 v2(50.08,56.98) ; R3779.1 v2(53.75,42.88)
  IN2 w0.122: v2(50.08,56.98) 50.08,56.03 49.12,55.06 49.12,45.78 51.36,43.54 53.09,43.54 v2(53.75,42.88)
SMB_M2IJ_3V3SB_CLK_R1: length 4.5
  TOP w0.112: R3856.2 45.21,63.98 v1(44.68,64.52) 44.41,64.79 U92.14
SMB_M2IJ_3V3SB_CLK_R2: length 8
  TOP w0.089: 47.4,43.13 47.38,43.15 45.75,43.15 U86.F2
  TOP w0.112: 47.4,43.13 47.56,43.13 48.38,42.32 v1(48.93,42.32) 50.65,42.32 50.97,42.64 R3798.2 51.36,43.26 51.94,43.26 R3779.2
SMB_M2IJ_3V3SB_DAT: length 21.7
  TOP w0.112: v2(50,57.69) 49.46,57.69 46.23,60.92 R3857.1 ; R3780.1 v2(53.75,43.89)
  IN2 w0.122: v2(53.75,43.89) 53.51,44.13 53.05,44.13 50.56,46.61 50.56,57.14 v2(50,57.69)
SMB_M2IJ_3V3SB_DAT_R1: length 4.7
  TOP w0.112: R3857.2 v1(46.23,63.25) 46.23,63.98 45.06,65.15 U92.15
SMB_M2IJ_3V3SB_DAT_R2: length 7.1
  TOP w0.112: U86.F1 47.67,43.44 48.21,42.9 48.67,42.9 49.15,43.39 50.7,43.39 50.97,43.66 R3799.2 R3780.2
SMB_M2J_ALERT_LVC_N: length 44.7
  TOP w0.112: R4202.2 41.25,87.91 42.29,86.87 42.29,85.85 41.43,84.99 41.43,83.97 41.76,83.64 v2(41.76,83.29) ; U86.U5 44.01,48.94 v5(44.45,48.51)
  IN2 w0.122: v2(44.45,60) 44.45,60.08 44.55,60.19 44.55,60.72 43.69,61.57 43.69,71 44.02,71.33 44.02,75.29 40.87,78.43 v2(40.87,80.45)
  BOTTOM w0.112: v2(44.45,60) 44.9,59.55 44.9,58.45 44.48,58.03 44.48,53.46 44.73,53.2 44.73,50.59 44.31,50.16 44.31,48.64 v5(44.45,48.51) ; v2(41.76,83.29) 41.43,82.96 41.43,80.7 41.18,80.45 v2(40.87,80.45)
SMB_M2J_ALERT_LVC_N_R: length 4.4
  TOP w0.112: U105.8 38.02,88.55 v2(38.28,88.29) 38.91,88.29 39.57,88.95 R4213.1 R4202.1
SMB_M2J_ALERT_N: length 113
  TOP w0.112: U105.9 37.37,88.41 38.48,87.3 41.2,87.3 41.78,86.72 41.78,85.99 41.02,85.23 41.02,83.59 v2(41.12,83.49)
  IN1 w0.122: v2(84.94,104.91) 84.94,104.67 84.75,104.48 84.75,99.43 85.18,98.37 85.18,96.44 78.02,89.27 77.27,89.27 74.89,86.89 74.89,85.99 70.71,81.81 63.41,81.81 61.9,80.3 53.72,80.3 52.64,81.38 50.9,81.38 50.84,81.43 49.96,81.43 46.07,77.55 v2(39.22,77.55)
  IN2 w0.122: v2(84.94,104.91) 84.81,105.05 84.81,107.42 85.29,107.9 85.29,112.3 84.07,113.52 v2(84.07,129.44) ; v2(38.46,82.06) 38.46,80.57 39.22,79.81 v2(39.22,77.55)
  BOTTOM w0.112: v2(84.07,129.44) 84.07,129.48 v3(83.57,129.98) 83.57,130.95 84.92,132.3 J34.A44 ; R4315.2 84.87,104.98 v2(84.94,104.91) ; v2(38.46,82.06) 38.98,82.59 40.22,82.59 v2(41.12,83.49)
SMB_M2J_INA231_ALRT_N: length 118.9
  TOP w0.089: 46.84,42.94 U86.E2
  TOP w0.112: 46.84,42.94 46.96,42.94 47.88,42.02 v2(47.88,41.07)
  IN1 w0.122: v2(80.43,98.15) 80.43,98.43 80.88,98.88 80.88,106.6 v2(81.14,106.86) ; v2(47.88,41.07) 47.88,40.52 48.36,40.04 48.56,40.04 48.83,39.76 50.33,39.76 51.14,40.57 51.14,41.16 51.4,41.42 52.22,41.42 52.54,41.1 52.54,40.82 54.18,39.17 56.4,39.17 56.78,39.55 v2(59.78,39.55)
  IN2 w0.122: v2(59.78,39.55) 61.35,41.12 61.35,42.49 62.84,43.98 63.59,43.98 64.05,44.45 67.66,44.45 87.91,64.69 v2(97,64.69)
  BOTTOM w0.112: v2(80.43,98.15) 80.43,97.64 96.1,81.96 96.1,81.92 96.97,81.06 v3(96.97,78.96) 96.97,75.99 97.46,75.5 97.46,75.14 96.97,74.65 96.97,66.07 97,66.04 v2(97,64.69) ; v2(81.14,106.86) 81.56,106.45 81.56,105.2 R4024.2
SMB_M2J_INA231_ALRT_N_R: length 13.2
  BOTTOM w0.112: R4024.1 R3891.1 79.76,104.76 79.47,104.47 78.54,104.47 77.01,106 v3(77.01,110.27) 76.39,110.89 76.13,110.89 U81.A3
SMB_M2J_INA231_CLK_R1: length 4.4
  BOTTOM w0.112: U81.A1 73.3,111.88 74.47,110.71 v3(74.47,110.27) 74.81,109.93 R3699.1
SMB_M2J_INA231_DAT_R1: length 4.7
  BOTTOM w0.112: U81.A2 73.7,112.32 v3(75.74,110.27) 75.85,110.16 R3700.1
SMB_M2J_P1V8_CLK: length 46.6
  TOP w0.112: R3854.2 86.71,105.1 v2(86.66,105.05)
  IN2 w0.122: v2(85.97,130.78) 85.39,130.19 85.39,119.64 86.97,118.06 86.97,108.64 86.65,108.32 86.65,105.05 v2(86.66,105.05)
  BOTTOM w0.112: J34.A40 85.92,133.22 85.92,132.16 85.44,131.68 85.44,131.31 v2(85.97,130.78) ; v2(86.66,105.05) 86.38,104.37 85.11,103.1 78.29,103.1 v3(76.5,104.9) 75.11,106.28 75.11,108.02 R3699.2
SMB_M2J_P1V8_CLK_R2: length 71.5
  TOP w0.112: v2(50.55,80.3) 50.86,80.61 50.86,81.14 50.57,81.43 49,81.43 47.21,79.64 44.24,79.64 R3069.2 40.65,76.05 40.65,74.62 v1(40.81,74.46) 41.3,73.97 41.3,73.18 41.81,72.67 U92.7 ; v2(85.87,105.11) 85.91,105.15 R3854.1
  IN1 w0.122: v2(50.55,80.3) 52.46,80.3 53.31,79.45 62.27,79.45 63.77,80.94 71.05,80.94 75.75,85.64 75.75,86.54 77.31,88.11 78.06,88.11 86.24,96.29 86.24,104.13 86.27,104.15 86.27,104.72 v2(85.87,105.11)
SMB_M2J_P1V8_DAT: length 45.4
  TOP w0.112: v2(85.2,104.3) 85.2,103.46 R3855.2
  IN2 w0.122: v2(85.2,104.3) 85.2,104.51 85.41,104.72 85.41,105.36 85.78,105.73 85.78,108.26 86.49,108.97 86.49,117.76 84.57,119.69 84.57,130.25 v2(84.07,130.74)
  BOTTOM w0.112: v2(84.07,130.74) 84.07,130.88 85.42,132.23 J34.A42 ; R3700.2 75.55,108.02 75.55,106.8 v3(75.85,106.49) 78.84,103.5 84.85,103.5 85.2,103.85 v2(85.2,104.3)
SMB_M2J_P1V8_DAT_R2: length 67.5
  TOP w0.112: v2(50.39,80.99) 49.12,80.99 47.38,79.25 44.99,79.25 R3070.2 41.76,76.02 41.76,73.89 v1(41.94,73.7) 41.94,73.27 42.46,72.75 U92.6 ; R3855.1 85.94,103.39 85.94,104.33 v2(85.82,104.44)
  IN1 w0.122: v2(85.82,104.44) 85.74,104.36 85.74,96.39 77.95,88.6 77.2,88.6 75.32,86.72 75.32,85.81 70.88,81.37 63.59,81.37 62.09,79.87 53.53,79.87 52.57,80.84 50.54,80.84 v2(50.39,80.99)
SMB_M2K_ALERT_LVC_N: length 45.6
  TOP w0.112: v2(40.55,84.01) 40.58,84.04 R4204.2 ; v2(43.07,59.82) 43.33,59.82 43.84,59.31 44.04,58.83 44.77,58.1 44.77,54.82 44.34,54.39 44.34,52.93 44.47,52.61 44.47,50.72 44.28,50.25 44.21,50.18 44.15,50.04 44.15,49.74 U86.V4
  IN2 w0.122: v2(43.07,59.82) 42.62,60.27 42.62,71.36 43.17,71.9 43.17,73.46 43.05,73.57 42.08,73.57 41.43,74.22 40.77,74.22 40.21,74.79 40.21,75.88 39,77.09 38,77.09 37.07,78.02 37.07,79.69 v2(36.12,80.65)
  BOTTOM w0.112: v2(40.55,84.01) 39.52,82.98 38.81,82.98 38.46,82.63 36.6,82.63 36.12,82.14 v2(36.12,80.65)
SMB_M2K_ALERT_LVC_N_R: length 6.5
  TOP w0.112: U105.10 36.72,87.77 37.82,86.67 v2(38.38,86.67) R4214.1 R4204.1
SMB_M2K_ALERT_N: length 90.9
  TOP w0.112: U105.11 36.07,87.43 37.45,86.06 38.43,86.06 38.94,85.55 38.94,84.59 40.9,82.63 41.55,82.63 42.7,81.48 v2(44.17,81.48)
  IN1 w0.122: v2(65.55,105.11) 65.21,104.28 65.21,100.22 64.96,99.97 64.96,99.97 54.75,89.76 53.91,87.72 52,85.82 49.5,84.78 46.57,81.85 44.54,81.85 v2(44.17,81.48)
  IN2 w0.122: v2(65.55,105.11) 65.55,105.99 66.34,106.77 66.34,107.18 64.49,109.02 64.49,112.23 63.78,112.94 63.78,117.63 60.29,121.11 v2(60.29,129.55)
  BOTTOM w0.112: J6.B44 60.92,132.35 60.81,132.08 59.87,131.15 59.87,130.14 60.29,129.72 v2(60.29,129.55) ; v2(65.55,105.11) 65.55,105.96 64.84,106.67 64.84,107.58 64.2,108.22 64.2,108.76 63.43,109.53 62.05,109.53 60.07,107.56 60.07,106.87 59.75,106.55 59.28,106.55 R4316.2
SMB_M2K_INA231_ALRT_N: length 152.3
  TOP w0.112: v6(44.95,43.94) 44.45,44.44 U86.H4
  IN1 w0.122: v2(51.76,97.77) 51.84,97.85 55.1,99.19 58.6,102.7 58.6,105.51 v2(58.37,105.74) ; v6(44.95,43.94) 46.83,43.94 49.32,41.45 50.14,41.45 50.61,41.92 50.82,42.44 51.27,42.89 52.4,42.89 53.19,42.1 53.19,41.74 53.6,41.33 55.08,41.33 55.62,40.78 55.81,40.78 55.98,40.61 56.61,40.61 56.98,40.98 58.18,40.98 58.42,40.74 61.23,40.74 62.28,39.69 65.19,39.69 66.02,40.52 66.02,41.61 66.52,42.12 66.64,42.17 67.08,42.35 68.4,42.35 v2(68.42,42.33)
  IN2 w0.122: v2(95.05,58.43) 94.73,58.12 89.71,58.12 73.32,41.73 69.02,41.73 68.91,41.84 68.89,41.84 68.64,42.1 68.64,42.11 v2(68.42,42.33)
  BOTTOM w0.112: v2(58.37,105.74) 58.01,105.74 57.59,105.32 v3(57.22,105.32) 56.05,105.32 55.95,105.42 R4023.2 ; v2(51.76,97.77) 52.07,97.46 58.95,97.46 60.23,98.73 70.25,98.73 73.68,95.3 81.11,95.3 94.93,81.48 94.93,58.55 v2(95.05,58.43)
SMB_M2K_INA231_ALRT_N_R: length 12.2
  BOTTOM w0.112: R4023.1 54.78,106.44 54.78,106.66 53.59,107.85 R3890.1 53.44,108.08 53.07,108.45 50.74,108.45 50.32,108.87 50.32,110.8 50.65,111.14 v3(50.65,111.58) 50.65,112.13 49.46,113.33 U80.A3
SMB_M2K_INA231_CLK_R1: length 4.2
  BOTTOM w0.112: U80.A1 48.66,112.12 v3(48.11,111.58) 47.74,111.2 R3692.1
SMB_M2K_INA231_DAT_R1: length 4.2
  BOTTOM w0.112: R3693.1 49.38,110.97 v3(49.38,111.58) 49.06,111.9 U80.A2
SMB_M2K_P1V8_CLK: length 49.4
  IN1 w0.122: v2(63.42,107.72) 63.42,111.14 63.1,111.9 62.68,112.32 62.68,114.48 63.52,115.32 63.52,116.52 61.39,118.65 61.39,129.18 61.59,129.38 v2(61.59,130.59)
  BOTTOM w0.112: R3692.2 47.94,109.56 v3(49.96,107.54) 53.08,104.43 53.51,104.43 54.99,102.94 56.4,102.94 58.37,104.91 61.34,104.91 61.81,105.37 62.25,105.37 R3865.2 63.07,105.75 64.05,106.73 64.05,107.27 63.6,107.72 v2(63.42,107.72) ; J6.B40 61.92,132.14 62.15,131.91 62.15,131.15 v2(61.59,130.59)
SMB_M2K_P1V8_CLK_R2: length 68.2
  TOP w0.112: v2(42.98,84.28) 43.49,84.79 43.49,88.08 41.38,90.18 40.24,90.18 39.14,91.29 33.94,91.29 32.65,92.58 32.65,95.76 31.45,98.66 30.91,99.2 28.93,99.2 28.09,98.36 R3071.2 27.53,95.27 v1(27.53,93.83) 27.53,93.19 27.72,93.01 U93.5
  IN1 w0.122: v2(42.98,84.28) 43.41,84.71 44.96,84.71 48.16,87.91 50.35,87.91 50.55,87.99 51.7,89.14 52.54,91.18 62.65,101.28 62.65,107.18 v2(62.63,107.2)
  BOTTOM w0.112: v2(62.63,107.2) 62.63,107.2 R3865.1
SMB_M2K_P1V8_DAT: length 47.9
  IN1 w0.122: v2(61.26,131.17) 60.94,130.86 60.94,118.45 61.51,117.88 61.51,116.41 61.74,116.18 62.8,116.18 63.09,115.89 63.09,115.53 62.25,114.69 62.25,112.15 62.68,111.72 62.68,108.45 v2(62.89,108.24)
  BOTTOM w0.112: J6.B42 61.42,132.3 61.3,132.18 61.19,131.91 61.19,131.24 v2(61.26,131.17) ; R3693.2 48.96,109.56 51.69,106.84 51.69,106.37 53.24,104.82 53.67,104.82 55.16,103.33 56.24,103.33 58.21,105.3 61.01,105.3 61.59,105.88 R3866.2 61.56,106.33 61.15,106.73 61.15,107.43 61.96,108.24 v2(62.89,108.24)
SMB_M2K_P1V8_DAT_R2: length 71.5
  TOP w0.112: U93.4 28.37,92.81 v1(28.49,92.93) 28.65,93.09 28.65,95.24 R3072.2 28.69,96.37 28.69,98.38 29.12,98.81 30.67,98.81 31.16,98.31 32.11,96.04 32.11,92.57 33.82,90.86 38.87,90.86 40.11,89.61 41.29,89.61 43.03,87.87 43.03,85.9 41.83,84.71 41.83,84.13 42.37,83.59 v2(42.44,83.59)
  IN1 w0.122: v2(42.44,83.59) 42.98,83.59 43.59,84.2 45.11,84.2 48.39,87.48 50.43,87.48 50.79,87.63 52.06,88.9 52.91,90.94 53.42,91.45 63.08,101.11 63.08,106.34 63.59,106.86 v2(63.59,106.92)
  BOTTOM w0.112: R3866.1 61.59,107.32 62,107.73 62.79,107.73 v2(63.59,106.92)
SMB_M2KL_3V3SB_CLK: length 65.5
  TOP w0.112: v2(46.86,80.29) 46.6,80.03 42.04,80.03 41.53,79.52 39.66,79.52 38.86,80.32 37.14,80.32 36.55,79.73 30.54,79.73 R3869.1
  IN2 w0.122: v2(53.82,40.76) 54.39,40.76 54.76,41.13 54.76,44.11 52.89,45.98 52.89,47.5 51.56,48.83 51.56,55.22 52.08,55.73 52.08,63.52 52.57,64 52.57,71.97 53.64,73.05 53.64,75.24 51.29,77.59 49.16,77.59 46.86,79.9 v2(46.86,80.29)
  BOTTOM w0.112: v2(53.82,40.76) 53.74,40.84 R3781.1
SMB_M2KL_3V3SB_CLK_R1: length 4.5
  TOP w0.112: U93.14 29.02,83.99 v1(29.25,83.76) 29.82,83.19 R3869.2
SMB_M2KL_3V3SB_CLK_R2: length 11.8
  TOP w0.112: v6(44.94,42.44) 45.45,41.94 U86.C2
  BOTTOM w0.112: v6(44.94,42.44) 45.19,42.2 45.19,40.41 45.65,39.95 46.45,39.95 47.03,40.52 48.57,40.52 v3(48.91,40.19) 49.21,39.89 50.53,39.89 50.97,40.33 R3800.2 51.41,40.41 51.9,40.41 R3781.2
SMB_M2KL_3V3SB_DAT: length 63.7
  TOP w0.112: v2(52.44,40.2) 52.54,40.2 53.13,40.8 R3782.1 ; v2(45.46,80.54) 41.92,80.54 41.31,79.93 39.83,79.93 39.04,80.72 36.86,80.72 36.28,80.15 31.14,80.15 R3870.1
  IN2 w0.122: v2(45.46,80.54) 48.84,77.17 49.8,77.17 50.3,76.67 50.3,72.92 51.9,71.32 51.9,63.94 51.81,63.85 51.2,63.85 50.91,63.56 50.91,61.6 50.81,61.5 50.81,58.42 51.65,57.58 51.65,55.92 51.06,55.33 51.06,48.62 52.39,47.29 52.39,45.88 54.19,44.08 54.19,42.69 53.9,42.4 53.66,42.4 52.44,41.18 v2(52.44,40.2)
SMB_M2KL_3V3SB_DAT_R1: length 4.7
  TOP w0.112: R3870.2 v1(30.84,82.43) 30.84,83.21 29.67,84.38 U93.15
SMB_M2KL_3V3SB_DAT_R2: length 8.3
  TOP w0.112: R3782.2 51.91,40.42 51.4,40.42 R3801.2 50.3,40.18 47.65,40.18 47.23,40.35 46.92,40.66 46.92,41.7 46.74,41.88 46.01,41.88 U86.C1
SMB_M2L_ALERT_LVC_N: length 53.5
  TOP w0.112: v2(45.53,55.63) 45.2,55.29 45.2,54.68 44.73,54.21 44.73,53.07 44.89,52.68 44.89,50.7 44.66,50.15 U86.W4 ; R4205.2 31.93,91.88 v2(31.61,92.2)
  IN2 w0.122: v2(31.61,92.2) 31.61,91.22 33.09,89.74 33.52,89.74 36.35,86.91 36.35,85.51 38.18,83.68 39.02,83.68 40.81,81.89 41.26,81.89 42.65,80.51 42.65,79.95 47.23,75.37 47.23,74.82 48.17,73.88 48.17,72.04 49.23,70.98 49.23,64.89 48.68,64.35 48.68,59.55 47.56,58.43 47.46,58.2 45.53,56.27 v2(45.53,55.63)
SMB_M2L_ALERT_LVC_N_R: length 7.7
  TOP w0.112: R4205.1 R4215.1 32.43,89.63 32.54,89.52 32.54,88.37 v2(32.72,88.19) 33.25,87.66 34.77,87.66 35.42,88.3 U105.12
SMB_M2L_ALERT_N: length 62
  TOP w0.112: U105.13 34.77,88.29 34.54,88.06 33.5,88.06 32.99,88.57 32.99,90.42 32.61,90.81 v2(32.61,91.44)
  IN1 w0.122: v2(40.4,122.24) 41.21,121.43 41.21,119.06 40.8,118.64 40.8,117.76 40.68,117.64 40.68,116.3 40.17,115.78 40.17,114.88 40.8,114.25 40.8,110.84 40.13,110.17 v2(40.13,109.73) 40.15,109.71 40.15,109.15 40.51,108.79 40.51,108.06 42.57,105.99 42.57,98.27 35.78,91.48 32.65,91.48 v2(32.61,91.44)
  BOTTOM w0.112: J6.A44 36.92,132.37 35.63,131.08 35.63,130.43 35.33,130.13 35.33,129.7 v3(35.33,129.7) 35.53,129.5 35.53,126.77 36.41,125.89 36.41,124.88 38.25,123.04 38.41,123.04 39.04,122.42 39.23,122.34 40.3,122.34 v2(40.4,122.24) ; v2(40.13,109.73) 39.99,109.87 39.22,109.87 38.68,109.33 R4317.2
SMB_M2L_INA231_ALRT_N: length 90.3
  TOP w0.112: U86.M4 44.4,46.44 43.91,45.95 43.51,45.95 43.01,46.45 v5(42.92,46.45)
  IN1 w0.122: v2(31.85,109.33) 31.85,108.65 31.12,106.89 26.14,101.91 26.14,101.34 25.63,100.83 v2(25.56,100.83)
  IN2 w0.122: v2(25.56,100.83) 25.93,100.47 26.15,99.94 27.99,98.1 27.99,97.57 30.83,94.73 30.83,90.76 35.72,85.87 35.72,85.54 38.14,83.12 38.93,83.12 40.71,81.35 41.2,81.35 42.16,80.39 42.16,79.42 46.25,75.33 46.25,72.75 48.37,70.63 48.37,67.09 46.63,65.35 46.63,62.18 47,61.81 47,59.3 46.74,58.69 44.61,56.56 44.61,50.49 45.59,49.52 45.59,48.15 44.55,47.11 44.55,46.61 43.94,45.99 43.53,45.99 43.08,46.45 v5(42.92,46.45)
  BOTTOM w0.112: v2(31.85,109.33) v3(33.37,110.85) 33.57,111.05 35.71,111.05 35.81,110.95 35.81,109.22 36.04,108.99 37.08,108.99 R4022.2
SMB_M2L_INA231_ALRT_N_R: length 12.6
  BOTTOM w0.112: R4022.1 R3889.1 36.28,111.15 35.98,111.45 31.91,111.45 31.28,112.09 30.41,112.09 30.09,111.77 v3(30.09,111.54) 27.5,111.54 U79.A3
SMB_M2L_INA231_CLK_R1: length 9.8
  BOTTOM w0.112: U79.A1 25.71,111.9 27.52,110.1 v3(27.52,108.66) 29.83,108.66 30.27,109.1 30.83,109.1 31.85,108.07 R3666.1
SMB_M2L_INA231_DAT_R1: length 5.3
  BOTTOM w0.112: U79.A2 26.11,112.24 v3(28.65,109.7) 28.7,109.66 R3667.1
SMB_M2L_P1V8_CLK: length 42.7
  TOP w0.112: v2(43.09,108.71) 43.15,108.71 43.76,108.1 R3867.2
  IN1 w0.122: v2(40.89,123.47) 41.11,123.47 43.13,121.46 43.13,115.85 43.64,115.34 43.64,111.89 42.52,110.77 42.52,109.28 v2(43.09,108.71)
  BOTTOM w0.112: v2(43.09,108.71) 42.51,108.13 42.51,107.55 42.36,107.4 34.49,107.4 33.81,108.07 R3666.2 ; v2(40.89,123.47) 40.74,123.32 39.93,123.32 39.43,123.82 38.69,123.82 37.22,125.29 37.22,126.2 36.32,127.1 36.32,129.84 37.92,131.44 J6.A40
SMB_M2L_P1V8_CLK_R2: length 50
  TOP w0.112: U93.7 26.42,91.9 25.47,92.85 25.47,93.69 v1(25.45,93.71) 25.23,93.93 25.23,95.25 R3073.2 25.81,97.45 25.16,98.09 23.95,98.09 23.7,97.84 23.7,94.53 v2(23.16,93.99) ; R3867.1 42.21,107.98 v2(42.06,108.14)
  IN1 w0.122: v2(42.06,108.14) 42.77,107.42 42.77,107.24 43.47,106.55 43.47,97.95 36.05,90.53 32.04,90.53 30.74,91.82 25.33,91.82 v2(23.16,93.99)
SMB_M2L_P1V8_DAT: length 44.6
  TOP w0.112: R3868.2 40.39,108.56 41.48,109.65 v2(42,109.65)
  IN1 w0.122: v2(40.38,122.88) 40.97,122.88 42.62,121.23 42.62,112.05 41.13,110.55 41.13,110.31 41.78,109.65 v2(42,109.65)
  BOTTOM w0.112: J6.A42 37.42,132.31 36.2,131.09 36.2,130.44 35.93,130.17 35.93,126.93 36.81,126.04 36.81,125.11 38.5,123.42 39.27,123.42 39.81,122.88 v2(40.38,122.88) ; v2(42,109.65) 41.69,109.65 39.83,107.79 35.01,107.79 v3(34.49,108.31) 34.04,108.76 32.08,108.76 31.49,109.01 R3667.2
SMB_M2L_P1V8_DAT_R2: length 54.1
  TOP w0.112: R3868.1 41.19,108.32 41.75,108.88 v2(41.8,108.88) ; v2(21.67,94) 23.27,95.6 23.27,97.97 23.83,98.53 25.29,98.53 26.95,96.87 R3074.2 26.37,95.24 26.37,93.12 v1(26.55,92.93) 27.07,92.42 U93.6
  IN1 w0.122: v2(41.8,108.88) 41.62,108.7 41.62,107.63 43,106.25 43,98.09 35.87,90.96 32.22,90.96 30.87,92.3 25.85,92.3 23.57,94.58 22.24,94.58 v2(21.67,94)
SMB_MUX_VR_CLK: length 122.6
  TOP w0.112: PU301.6 200.02,36.01 v2(199.92,35.92) 199.82,36.02 PR304.1 ; TP65.1 158.49,19.29 160.13,19.29 160.85,18.56 R4374.2 160.98,18.42 v2(160.98,17.45) ; v2(164.16,19.13) 164.47,19.13 164.9,19.56 PU201.6 ; PU601.6 188.17,34.01 v2(188.06,33.91) ; PR104.1 175.25,19.02 175.67,19.45 v2(175.85,19.45) 175.97,19.56 PU101.6
  IN1 w0.122: v2(164.16,19.13) 162.28,17.24 161.25,17.24 161.05,17.45 v2(160.98,17.45) ; v2(175.85,19.45) 176.19,19.45 176.63,19 176.63,17.74 177.36,17.01 177.37,17.01 177.6,16.79 177.6,14.83 177.36,14.25 176.2,13.1 176.2,11.66 176.65,11.21 177.24,11.21 177.26,11.19 177.27,11.19 177.65,10.81 180.92,10.81 184.27,14.15 184.27,17.82 185,18.55 185,24.43 184.32,25.1 184.32,25.79 185.19,26.66 185.19,27.9 185.65,28.37 185.65,29.47 185.19,29.93 185.19,31.57 187.53,33.91 v2(188.06,33.91)
  IN2 w0.122: v2(199.92,35.92) 200.37,35.47 200.37,33.55 198.89,32.07 198.89,28.1 194.22,23.43 184.67,23.43 183.26,24.85 183.26,26.62 186.61,29.98 186.61,30.49 185.88,31.22 185.88,32.27 187.53,33.91 v2(188.06,33.91) ; v2(164.16,19.13) 164.4,19.36 164.86,19.36 164.86,19.22 165.03,19.05 165.03,11.88 166.19,10.72 170.06,10.72 171.12,11.78 171.12,14.56 171.35,14.8 171.35,16.36 171.24,16.47 171.24,17.14 172.7,18.59 172.7,19.19 173.01,19.5 173.67,19.5 173.91,19.26 175.67,19.26 v2(175.85,19.45)
SMB_MUX_VR_CLK_R: length 179.9
  TOP w0.112: U108.10 28.57,25.59 28.13,25.15 26.53,25.15 26.29,25.05 25.44,24.19 25.44,23.75 v1(25.13,23.44) 24.19,23.44 R4380.2 23.78,24.58 23.68,24.68 v2(23.18,24.68) ; R4374.1 160.85,19.91 v2(160.99,20.05)
  IN1 w0.122: v2(23.18,24.68) 23.18,20.55 27.47,16.26 31.05,16.26 32.06,15.25 32.06,15.07 31.34,14.35 31.34,14.18 31.8,13.73 31.97,13.73 32.69,14.45 32.86,14.45 33.31,14 33.31,13.82 32.59,13.1 32.59,12.93 33.05,12.48 33.22,12.48 33.94,13.2 34.11,13.2 38.65,8.66 46.01,8.66 46.68,7.99 78.95,7.99 83.8,3.14 95.12,3.14 95.58,2.69 158.83,2.69 160.55,4.4 161.56,6.86 161.56,16.03 160.03,17.57 160.03,19.09 v2(160.99,20.05)
SMB_MUX_VR_DAT: length 122.8
  TOP w0.112: v2(188.11,33.2) 188.53,33.61 PU601.7 ; v2(164.09,18.41) 164.3,18.41 165.06,19.16 PU201.7 ; PR103.1 175.07,18.2 175.57,18.7 175.85,18.7 v2(175.96,18.81) 176.31,19.16 PU101.7 ; v2(160.48,17.91) R4375.2 159.72,18.45 159.72,17.52 159.47,17.27 158.93,17.27 158.7,17.04 158.7,14.42 TP67.1 ; PR303.1 199.53,35.22 v2(199.92,35.22) 200.31,35.61 PU301.7
  IN1 w0.122: v2(164.09,18.41) 164.6,18.93 164.6,19.31 164.35,19.57 163.98,19.57 162.58,18.17 160.74,18.17 v2(160.48,17.91) ; v2(188.11,33.2) 187.45,33.2 185.63,31.38 185.63,30.13 186.58,29.18 186.58,27.45 185.46,26.32 185.46,18.34 184.7,17.59 184.7,13.79 181.4,10.49 181.21,10.49 181.1,10.38 177.48,10.38 177.09,10.76 177.08,10.76 177.06,10.78 176.48,10.78 175.77,11.49 175.77,13.31 176.91,14.45 177.05,14.78 177.05,16.68 176.2,17.53 176.2,18.57 v2(175.96,18.81)
  IN2 w0.122: v2(199.92,35.22) 198.22,33.53 198.22,33 198.43,32.79 198.43,28.25 194.07,23.88 184.83,23.88 183.7,25.01 183.7,26.43 187.04,29.76 187.04,30.67 186.35,31.36 186.35,32.13 187.42,33.2 v2(188.11,33.2) ; v2(175.96,18.81) 173.83,18.81 172.21,17.19 172.21,12.03 170.42,10.24 166.01,10.24 164.36,11.9 164.36,18.14 v2(164.09,18.41)
SMB_MUX_VR_DAT_R: length 182.7
  TOP w0.112: v2(23.13,26.22) 23.13,26.35 R4381.2 24,26.78 24,25.43 24.33,25.1 v1(25.15,25.1) 25.29,25.1 26.37,25.55 27.05,26.23 U108.9 ; v2(159.2,17.75) 159.03,17.92 R4375.1
  IN1 w0.122: v2(159.2,17.75) 161.08,15.87 161.08,6.98 160.09,4.59 158.61,3.11 96.06,3.11 94.94,4.23 94.94,5.51 95.87,6.43 95.87,11.93 93.64,14.15 87.1,14.15 81.37,8.42 46.89,8.42 46.06,9.25 41.42,9.25 39.56,11.11 36.84,11.11 31.25,16.7 27.63,16.7 23.84,20.49 23.84,25.52 v2(23.13,26.22)
SMB_PESW_3V3SB_CLK: length 127.1
  IN1 w0.122: v2(40.35,22.47) 42.08,24.2 63.57,24.2 64.63,25.26 65.86,28.23 70.3,30.07 76.76,30.07 79.14,31.06 79.71,31.63 80.53,31.63 81.22,32.32 81.22,33.14 83.82,35.73 89.36,38.02 90.99,38.02 92.51,39.54 92.51,40 92.78,40.27 93.96,40.27 97.31,41.66 99.7,41.66 102.79,44.75 112.77,48.88 126.1,48.88 126.75,48.23 128.37,48.23 v2(128.59,48.46)
  IN2 w0.122: v2(40.35,22.47) 40.35,23.33 39.67,24.01 36.04,24.01 34.64,25.41 34.64,36.05 33.72,36.97 33.72,38.87 v2(33.83,38.98)
  BOTTOM w0.112: v2(128.59,48.46) 128.02,47.89 R3334.2 ; v2(33.83,38.98) 34.38,39.53 R3767.1
SMB_PESW_3V3SB_CLK_R1: length 4.5
  BOTTOM w0.112: R3334.1 129.06,42.62 129.95,41.73 v3(130.96,41.73) 131.09,41.73 131.67,42.31 D4.7
SMB_PESW_3V3SB_CLK_R2: length 6
  TOP w0.112: U86.A17 37.95,40.47 37.49,40.01 36.34,40.01 35.92,40.43 v2(35.92,40.87)
  BOTTOM w0.112: v2(35.92,40.87) 35.21,40.16 R3767.2 R3786.2
SMB_PESW_3V3SB_DAT: length 126.3
  IN1 w0.122: v2(39.85,23.22) 41.4,24.77 58.25,24.77 59.92,26.44 59.92,29.21 61.06,30.35 67.29,30.35 67.44,30.49 76.66,30.49 76.69,30.51 78.9,31.42 79.54,32.06 80.25,32.06 80.76,32.57 80.76,33.28 83.61,36.13 89.22,38.46 90.81,38.46 92.08,39.72 92.08,40.19 92.59,40.71 93.81,40.71 95.96,41.6 99.08,43.68 112.68,49.31 126.38,49.31 v2(126.88,48.82)
  IN2 w0.122: v2(39.85,23.22) 35.09,23.22 34.06,24.25 34.06,31.5 32.29,33.28 32.29,35.1 v2(33.3,36.11)
  BOTTOM w0.112: v2(126.88,48.82) 127.57,48.13 127.57,42.08 128.02,41.62 R3335.2 ; v2(33.3,36.11) 33.41,36 R3768.1
SMB_PESW_3V3SB_DAT_R1: length 4.3
  BOTTOM w0.112: R3335.1 129.18,41.1 129.44,40.84 v3(129.95,40.84) 130.96,40.84 131.78,41.66 D4.6
SMB_PESW_3V3SB_DAT_R2: length 8
  TOP w0.112: v6(38.22,41.88) 37.95,41.61 U86.B17
  BOTTOM w0.112: v6(38.22,41.88) 38.22,40.74 37.74,40.26 37.74,40.26 37.49,40.01 37.49,40.01 v3(36.64,39.16) 35.13,37.65 R3787.2 R3768.2
SMB_PESW_P1V8_CLK: length 3.4
  BOTTOM w0.112: R4049.1 144.79,45.66 144.63,45.82 v3(144.17,45.82) 143.67,45.82 143.55,45.71 R3332.1
SMB_PESW_P1V8_CLK_R1: length 6.6
  BOTTOM w0.112: D4.2 140.25,42.31 v3(140.88,42.95) 142.59,44.65 R3332.2
SMB_PESW_P1V8_CLK_R2: length 109
  TOP w0.112: U34.K27 v6(191.59,90.02)
  IN1 w0.122: v2(147.27,60.86) 147.61,60.53 152.15,60.53 152.58,60.96 152.58,61.7 152.7,61.82 154.89,61.82 163.23,70.17 163.23,94.67 167.18,98.62 167.18,99.19 167.42,99.43 167.98,99.43 167.98,99.43 189.67,99.43 190.32,99.16 192.54,96.94 192.54,96.65 194.71,94.48 195.82,94.48 196.14,94.16 196.14,90.88 195.83,90.57 192.14,90.57 v6(191.59,90.02)
  BOTTOM w0.112: v2(147.27,60.86) 147.27,45.21 146.71,44.65 R3336.1 R4049.2
SMB_PESW_P1V8_DAT: length 3.4
  BOTTOM w0.112: R3333.1 143.55,42.49 143.7,42.34 v3(144.19,42.34) 144.67,42.34 144.79,42.45 R4050.1
SMB_PESW_P1V8_DAT_R1: length 6.4
  BOTTOM w0.112: D4.3 v3(139.22,41.66) 140.91,41.66 R3333.2
SMB_PESW_P1V8_DAT_R2: length 110.5
  TOP w0.112: U34.K30 v6(194.59,90.02)
  IN1 w0.122: v6(194.59,90.02) 195.87,90.02 196.33,90.47 196.78,90.47 197.06,90.75 197.06,93.24 196.5,93.8 196.5,94.24 195.95,94.79 195.23,94.79 190.74,99.28 189.23,99.9 166.63,99.9 166,99.26 166,98.08 162.62,94.71 162.62,70.4 154.69,62.46 152.76,62.46 152.08,63.14 150.74,63.14 v2(148.82,61.23)
  BOTTOM w0.112: v2(148.82,61.23) 148.53,60.94 148.53,45.76 149.19,45.1 149.19,44.34 147.73,42.88 147.09,42.88 146.69,43.28 R3337.1 R4050.2
SMB_SENSOR_3V3SB_CLK: length 153.1
  TOP w0.112: v2(58.67,70.92) R2959.1
  IN2 w0.122: v2(58.67,70.92) 58.67,70.21 60.1,68.78 60.1,56.57 60.4,56.26 60.4,55.19 59.69,54.48 59.69,51.92 60.3,51.31 v2(60.3,49.5) 60.26,49.47 60.26,48.35 60.82,47.79 65.91,47.79 66.62,48.5 66.62,50.3 67.46,51.14 67.46,57.05 68.29,57.89 68.29,63.74 73.68,69.12 101.59,69.12 108.42,62.29 108.42,61.64 106.97,60.18 103.16,60.18 101.55,58.57 97.05,58.57 92.91,54.43 87.99,54.43 77.8,44.23 77.8,43.8 78.84,42.75 v2(79.52,42.75)
  BOTTOM w0.112: R4331.1 79.65,42.62 v2(79.52,42.75) ; R3769.1 54.02,50.8 55.28,50.8 55.76,51.28 57.12,51.28 v3(57.49,50.91) 58.75,49.65 58.75,49.33 59.26,48.82 59.82,48.82 60.3,49.3 v2(60.3,49.5) ; R42.2 58.73,70.98 v2(58.67,70.92) 58.67,71.02 57.85,71.84 56.49,71.84 54.48,69.83 54.48,69.03 R47.1
SMB_SENSOR_3V3SB_CLK_R1: length 71.4
  TOP w0.112: v2(134.8,41.31) 135.27,41.78 R4326.2 ; v2(84.31,39.72) 86.22,41.64 101.26,41.64 101.94,42.32 111.39,42.32 112.71,43.64 v2(113.51,43.64)
  BOTTOM w0.112: v2(134.8,41.31) 134.36,41.31 133.88,41.79 133.88,43.9 128.45,49.33 v3(122.88,49.33) 119.21,49.33 113.66,43.79 ; v4(82.02,45.11) 82.02,44.05 82.23,43.84 R4331.2 ; v4(82.02,45.11) 82.86,45.95 R4160.1 ; v4(82.02,45.11) 82.56,45.11 83.38,44.29 R9.2 82.86,42.9 82.86,41.79 84.31,40.33 v2(84.31,39.72) ; 113.66,43.79 R44.2 ; 113.66,43.79 v2(113.51,43.64)
SMB_SENSOR_3V3SB_CLK_R2: length 14.4
  TOP w0.112: v5(43.38,46.72) 43.54,46.87 43.88,46.87 U86.N5
  BOTTOM w0.112: R3769.2 R3788.2 51.61,51.47 50.62,52.45 50.13,52.45 v3(49.5,51.82) 48.52,51.82 48,51.29 48,49.61 46.07,47.68 44.75,47.68 43.95,46.87 43.53,46.87 v5(43.38,46.72)
SMB_SENSOR_3V3SB_CLK_R3: length 11.6
  TOP w0.112: R4326.1 139.96,41.78 v1(141.08,40.66) 141.77,39.97 141.77,38.36 141.17,37.76 U106.7
SMB_SENSOR_3V3SB_DAT: length 149.3
  TOP w0.112: R2958.1 v2(59.69,70.99)
  IN2 w0.122: v2(78.24,43.98) 79.79,43.98 89.26,53.45 92.2,53.45 95.18,54.68 105.08,58.78 106.37,58.78 109.06,61.48 109.06,62.36 101.59,69.84 72.49,69.84 67.82,65.17 67.82,58.09 66.98,57.25 66.98,51.34 66.14,50.49 66.14,49.18 65.51,48.55 61.15,48.55 v2(60.71,49) 60.95,49.24 60.95,56.52 60.58,56.9 60.58,69.04 59.69,69.93 v2(59.69,70.99)
  BOTTOM w0.112: R48.1 55.63,69.02 55.63,70.43 56.65,71.45 57.69,71.45 58.14,71 58.14,70.83 58.49,70.48 59.18,70.48 v2(59.69,70.99) 60.01,71.31 R41.2 ; v2(60.71,49) 60.71,48.54 60.49,48.32 58.24,48.32 57.33,49.23 57.33,50.26 56.99,50.61 56.21,50.61 55.59,49.99 v3(55.06,49.99) R3770.1 ; R4330.1 79.32,43.98 v2(78.24,43.98)
SMB_SENSOR_3V3SB_DAT_R1: length 79.3
  TOP w0.112: v2(85.62,39.75) 85.62,40.48 86.34,41.2 94.45,41.2 95.11,40.55 100.78,40.55 102.12,41.88 112.79,41.88 v2(113.99,43.09) ; v2(134.45,42.04) 135.3,42.89 R4327.2
  BOTTOM w0.112: v4(81.06,44.09) 80.4,44.09 R4330.2 ; v4(81.06,44.09) 81.06,44.9 R4159.1 ; v4(81.06,44.09) 81.06,43.87 80.61,43.42 79.18,43.42 R10.2 78.84,42.12 81.92,39.04 84.9,39.04 v2(85.62,39.75) ; R43.2 114.35,42.73 v2(113.99,43.09) 113.46,42.55 113.09,42.55 112.83,42.81 112.83,43.58 119.15,49.9 128.69,49.9 v3(131.58,47.01) 134.45,44.14 v2(134.45,42.04)
SMB_SENSOR_3V3SB_DAT_R2: length 12.1
  TOP w0.112: U86.N4 44.45,46.9 43.91,46.36 v5(43.79,46.36)
  BOTTOM w0.112: R3770.2 R3789.2 51.61,50.15 51.23,50.52 49.66,50.52 v3(49.14,50) 48.97,50 46.36,47.4 44.82,47.4 v5(43.79,46.36)
SMB_SENSOR_3V3SB_DAT_R3: length 13.7
  TOP w0.112: R4327.1 v1(138,42.89) 139.97,42.89 142.25,40.62 142.25,38.28 141.09,37.11 U106.6
SMB_SENSOR_DB1200_CLK_R1: length 5.9
  TOP w0.112: R2959.2 v1(58.67,68.27) 58.67,68 59.68,66.99 61.15,66.99 61.71,66.44 U47.13
SMB_SENSOR_DB1200_DAT_R1: length 5.4
  TOP w0.112: U47.12 62.21,66.6 61.27,67.54 60.36,67.54 ; 60.36,67.54 v1(60.36,67.55) ; 60.36,67.54 59.69,68.21 R2958.2
SMB_SENSOR_FRU_CLK_R1: length 76.2
  TOP w0.112: v2(15.36,42.43) 15.29,42.37 15.29,37.65 14.83,37.19 v1(14.83,36.8) U6.6
  IN2 w0.122: v2(17.16,68.26) 16.77,67.87 16.69,67.87 16.68,67.86 16.67,67.86 16.17,67.37 16.17,65.64 16.65,65.17 16.65,61.07 15.46,59.88 15.46,44.65 15.93,44.19 15.93,43.8 15.36,43.23 v2(15.36,42.43)
  BOTTOM w0.112: R47.2 53.77,66.95 52.21,65.39 51.04,65.39 48.86,63.21 45.62,63.21 45.32,63.51 29.58,63.51 24.7,68.39 19.67,68.39 19.16,68.9 18.13,68.9 17.49,68.26 v2(17.16,68.26)
SMB_SENSOR_FRU_DAT_R1: length 76.4
  TOP w0.112: v2(16.48,42.16) 16.76,41.89 16.76,40.92 16.1,40.26 v1(16.1,36.8) U6.5
  IN2 w0.122: v2(18.1,67.87) 18.1,67.87 18.1,67.88 17.65,67.43 17.51,67.43 17.49,67.44 16.87,67.44 16.61,67.18 16.61,65.91 17.08,65.44 17.08,60.79 15.89,59.6 15.89,45.21 16.54,44.57 16.54,42.21 v2(16.48,42.16)
  BOTTOM w0.112: v2(18.1,67.87) 18.1,67.87 18.1,67.89 18.13,67.86 20.63,67.86 20.77,68 22.2,68 22.37,67.83 22.56,67.83 22.68,67.96 23.11,67.96 23.24,67.83 23.62,67.83 23.72,67.94 24.6,67.94 29.42,63.12 45.16,63.12 45.46,62.82 49.02,62.82 50.37,64.16 51.58,64.16 R48.2
SMB_SENSOR_I2C_GPIO_CLK_R1: length 4.3
  BOTTOM w0.112: U101.19 81.04,48.79 81.17,48.67 82.21,48.67 v3(82.79,48.09) 83.13,47.75 R4160.2
SMB_SENSOR_I2C_GPIO_DAT_R1: length 4.1
  BOTTOM w0.112: R4159.2 82.11,47.84 81.78,48.17 v3(80.72,48.17) 80.54,48.34 U101.20
SMB_SENSOR_INA230_CLK_R1: length 31.8
  BOTTOM w0.112: U2.5 101.33,37.24 v3(101.85,37.76) 101.85,41.82 100.2,43.47 97.96,43.47 96.84,42.35 96.84,41.04 93.63,37.83 92.29,37.83 91.6,37.14 87.97,37.14 86.09,39.02 86.09,39.91 85.86,40.14 85.2,40.41 83.43,42.18 83.43,42.57 R9.1
SMB_SENSOR_INA230_DAT_R1: length 35.6
  BOTTOM w0.112: U2.4 99.12,38.27 99.8,38.94 100.69,38.94 v3(101.14,39.4) 101.24,39.5 101.24,41.87 100.04,43.08 98.12,43.08 97.23,42.18 97.23,40.86 93.8,37.44 92.48,37.44 91.79,36.75 87.61,36.75 85.8,38.57 81.58,38.57 78.04,42.11 R10.1
SMB_SENSOR_TMP75_CLK_0_R1: length 52.4
  BOTTOM w0.112: U7.2 15.16,70.92 v3(14.67,70.43) 15.65,69.45 20.03,69.45 20.7,68.78 24.86,68.78 29.72,63.93 48.16,63.93 49.93,65.7 49.93,65.83 56.83,72.73 R42.1
SMB_SENSOR_TMP75_CLK_1_R1: length 51.3
  BOTTOM w0.112: R44.1 116.07,44.19 123.51,44.19 127.32,40.37 128.98,40.37 130.07,39.28 133.85,39.28 134.05,39.49 141.29,39.49 143.2,41.39 147.54,41.39 149.98,43.83 149.98,45.63 149.91,45.69 149.91,50.65 v3(152.26,53) U8.2
SMB_SENSOR_TMP75_DAT_0_R1: length 52.5
  BOTTOM w0.112: R41.1 59.43,73.3 56.85,73.3 49.52,65.98 49.52,65.84 48.07,64.39 47.38,64.39 47.2,64.57 46.87,64.57 46.62,64.32 29.88,64.32 25,69.19 20.91,69.19 19.68,70.42 v3(15.98,70.42) 15.98,70.53 15.81,70.7 U7.1
SMB_SENSOR_TMP75_DAT_1_R1: length 50.5
  BOTTOM w0.112: R43.1 117.64,42.73 118.44,43.53 123.09,43.53 126.72,39.9 128.82,39.9 129.84,38.89 134.73,38.89 134.77,38.92 141.74,38.92 143.79,40.97 147.67,40.97 150.37,43.67 150.37,45.79 150.3,45.86 150.3,49.12 v3(153.2,52.02) 153.78,52.02 154.12,52.35 U8.1
SMB_SENSOR_ZL30281_CLK: length 8.3
  TOP w0.112: v2(128.36,38.34) 128.61,38.58 R4324.1 ; U61.31 v2(123.44,39.68)
  BOTTOM w0.112: v2(128.36,38.34) 128.36,38.34 124.83,38.34 124.49,38.67 124.49,39.91 124.26,40.14 123.9,40.14 v2(123.44,39.68)
SMB_SENSOR_ZL30281_CLK_R1: length 7
  TOP w0.112: U106.2 132.81,37.76 R3239.2 132.19,37.39 131.9,37.69 129.94,37.69 129.79,37.84 R4324.2 130.21,38.58 v1(131.02,39.39)
SMB_SENSOR_ZL30281_DAT: length 14.9
  TOP w0.112: U61.2 v2(121.19,42) ; R4325.1 131.39,35.11 v2(130.23,36.27)
  BOTTOM w0.112: v2(130.23,36.27) 129.95,36.56 129.95,37.98 128.83,39.09 125.96,39.09 123.17,41.89 122,41.89 121.9,42 v2(121.19,42)
SMB_SENSOR_ZL30281_DAT_R1: length 5
  TOP w0.112: U106.3 133.19,37.11 R3238.2 132.39,35.93 132.76,35.93 133.43,35.26 v1(133.43,35.1) R4325.2
SPI_PESW_FLASH_CLK: length 65.2
  TOP w0.112: v2(208.4,50.32) 207.79,50.32 206.46,51.65 205.73,53.42 R3250.2
  IN2 w0.122: v2(208.06,10.86) 208.56,11.37 208.56,23.16 208.45,23.7 207.16,26.82 207.16,28.94 207.79,29.56 207.79,30.92 208.15,31.8 208.15,46.18 207.89,46.83 207.89,49.81 v2(208.4,50.32)
  BOTTOM w0.112: v2(208.06,10.86) 207.92,10.73 200.21,10.73 199.75,10.28 196.46,10.28 R3124.1 194.96,9.54 192.42,7.01 U58.6
SPI_PESW_FLASH_CLK_R: length 23.6
  TOP w0.112: v2(203.31,54.6) 203.89,54.02 R3250.1 ; U34.AJ31 v2(195.59,70.02)
  IN1 w0.102: v2(195.59,70.02) 195.75,69.85 196.17,68.84 196.25,68.72 196.44,68.62 198.66,68.62 198.93,68.36
  IN1 w0.122: 198.93,68.36 199.05,68.24 199.05,67.75 199.26,67.54 201.74,67.54 202.02,67.26 203.07,59.47 v2(203.31,54.6)
SPI_PESW_FLASH_CSB_0: length 65.8
  BOTTOM w0.112: U58.1 184.4,4.47 189.02,9.08 192.78,9.08 R3123.2 196.93,14.96 196.93,20.11 197.62,21.76 198.16,22.58 201.15,25.56 203.12,26.38 v3(205.59,28.85) 206.78,30.04 206.78,31.02 207.59,31.82 207.59,49.52 206.06,51.05 204.57,51.05 204.06,50.53 203.4,50.53 R3251.2
SPI_PESW_FLASH_CSB_0_R: length 24.5
  TOP w0.112: U34.AJ27 v2(191.59,70.02)
  IN1 w0.102: 197.33,67.13 197.05,67.42 194.94,67.42 194.2,67.73 193.23,68.7 193,69.25 192.68,69.57 v2(191.59,70.02)
  IN1 w0.122: 197.33,67.13 198.12,66.35 198.12,65.84 198.45,65.51 198.76,65.51 199.09,65.18 199.09,63.27 201.35,54.22 v2(201.64,53.28)
  BOTTOM w0.112: R3251.1 202.69,52.25 202.45,52.82 202.24,53.03 v2(201.64,53.28)
SPI_PESW_FLASH_DAT_0: length 52.4
  BOTTOM w0.112: R3252.2 203.98,51.27 204.41,51.7 206.12,51.7 208.09,49.73 208.09,31.4 207.75,31.06 207.75,29.82 206.98,29.04 206.98,26.34 208.02,23.8 208.02,19.77 208.07,19.55 208.07,18.45 207.48,15.51 v3(207.48,13.22) 207.48,11.75 207.1,11.37 199.92,11.37 R4259.2
SPI_PESW_FLASH_DAT_0_R1: length 23.5
  TOP w0.112: U34.AJ29 v2(193.59,70.02)
  IN1 w0.102: v2(193.59,70.02) 193.71,69.9 194.12,68.91 194.35,68.68 196.05,67.77 196.42,67.62 197.64,67.62 197.78,67.48
  IN1 w0.122: 197.78,67.48 199.08,66.18 199.08,65.89 199.44,65.53 199.8,65.53 200.02,65.31 200.13,64.21 201.66,55.95 v2(202.23,53.92)
  BOTTOM w0.112: R3252.1 203.57,52.07 203.27,52.37 202.91,53.23 v2(202.23,53.92)
SPI_PESW_FLASH_DAT_0_R2: length 10.3
  BOTTOM w0.112: R4259.1 v3(197.49,10.92) 195.33,10.92 192.69,8.28 U58.5
SPI_PESW_FLASH_DAT_1: length 43.8
  BOTTOM w0.112: R3253.2 202.05,49.99 204.25,49.99 204.76,50.5 205.91,50.5 206.84,49.57 206.84,39.37 207.09,39.12 207.09,32.12 206,31.03 v3(206,30.85) 206,30.11 202.75,26.86 201.04,26.15 197.75,22.86 197.2,22.03 196.28,19.83 R4260.1
SPI_PESW_FLASH_DAT_1_R1: length 25.2
  TOP w0.112: U34.AJ30 v2(194.59,70.02)
  IN1 w0.102: 198.24,67.48 198.16,67.56 198.16,68.29 198.02,68.42 195.92,68.42 195.4,68.63 195.17,68.86 194.77,69.84 v2(194.59,70.02)
  IN1 w0.122: v2(201.27,52.51) 201.34,52.58 201.89,52.81 202.66,53.57 202.75,53.85 201.07,66.2 200.77,66.5 199.21,66.5 198.24,67.48
  BOTTOM w0.112: R3253.1 201.27,51.96 v2(201.27,52.51)
SPI_PESW_FLASH_DAT_1_R2: length 22
  BOTTOM w0.112: R4260.2 195.07,16.77 v3(195.43,16.41) 195.85,15.4 195.85,14.52 195.02,12.52 192.12,9.62 188.83,9.62 184.95,5.74 U58.2
SPI_PESW_FLASH_DAT_2: length 44.4
  BOTTOM w0.112: R4261.1 196.05,20.66 196.66,22.13 197.35,23.16 200.98,26.79 202.48,27.41 v3(203.42,28.35) 204.05,28.98 204.05,30.13 206.44,32.51 206.44,38.54 206.28,38.7 206.28,49.41 205.68,50 204.96,50 204.44,49.48 201.5,49.48 R3254.2
SPI_PESW_FLASH_DAT_2_R1: length 26.8
  TOP w0.112: U34.AJ32 v2(196.59,70.02)
  IN1 w0.102: 199.04,69.17 198.79,69.42 197.95,69.42 197.31,69.68 197.25,69.75 v2(196.59,70.02)
  IN1 w0.122: 199.04,69.17 199.11,69.1 199.11,68.86 199.47,68.51 201.68,68.51 202.54,67.65 202.79,67.04 203.72,59.5 203.98,54.34 203.59,53.41 202.71,52.53 201.39,51.98 200.82,51.98 v2(200.47,52.33)
  BOTTOM w0.112: v2(200.47,52.33) R3254.1
SPI_PESW_FLASH_DAT_2_R2: length 20.9
  BOTTOM w0.112: R4261.2 193.64,16.09 194.69,16.09 194.99,15.79 195.13,15.46 v3(195.13,14.35) 195.13,14.29 194.57,12.95 191.85,10.23 188.49,10.23 185.27,7.01 U58.3
SPI_PESW_FLASH_DAT_3: length 56.7
  TOP w0.112: R3255.2 207.36,52.72 v2(207.35,52.7)
  IN2 w0.122: v2(207.7,10.1) 207.48,10.32 207.48,15.87 207.88,16.84 207.88,23.08 207.82,23.4 206.46,26.68 206.46,30.87 207.51,31.93 207.51,45.92 207.2,46.68 207.2,50.12 206.82,50.5 206.82,52 206.93,52.28 v2(207.35,52.7)
  BOTTOM w0.112: R4258.2 200.47,10.1 v3(206.27,10.1) v2(207.7,10.1)
SPI_PESW_FLASH_DAT_3_R1: length 20.8
  TOP w0.112: R3255.1 v2(204.44,55.18) ; U34.AJ33 v2(197.59,70.02)
  IN1 w0.102: v2(197.59,70.02) 198,70.02 198.4,69.62 201.67,69.62 201.96,69.33 202.17,68.83
  IN1 w0.122: v2(204.44,55.18) 204.17,60.74 203.24,67.56 203.11,67.89 202.17,68.83
SPI_PESW_FLASH_DAT_3_R2: length 9.8
  BOTTOM w0.112: R4258.1 198.33,6.47 197.81,5.95 v3(197.54,5.95) 190.7,5.95 190.49,5.74 U58.7
TDR_DIFF_85_BOT_DN: length 152.5
  BOTTOM w0.124: X6.1 409.87,-155.28 409.75,-155.41 340.78,-155.41 arc(337.27,-155.75) 333.89,-156.78 331.2,-157.89 arc(329.87,-158.3) 328.48,-158.43 299.16,-158.43 arc(297.95,-158.31) 296.8,-157.96 292.77,-156.3 arc(290.58,-155.63) 288.31,-155.41 260.56,-155.41 260.44,-155.28 X5.4
TDR_DIFF_85_BOT_DP: length 152.5
  BOTTOM w0.124: X6.4 409.87,-155.84 409.75,-155.71 340.78,-155.71 arc(337.33,-156.05) 334.01,-157.06 331.32,-158.17 arc(329.93,-158.59) 328.48,-158.74 299.16,-158.74 arc(297.9,-158.61) 296.68,-158.24 292.65,-156.58 arc(290.52,-155.93) 288.31,-155.71 260.56,-155.71 260.44,-155.84 X5.1
TDR_DIFF_85_IN1_DN: length 152.5
  IN1 w0.136: X3.4 260.44,-165.49 260.57,-165.35 410.66,-165.35 410.82,-165.5 X4.1
TDR_DIFF_85_IN1_DP: length 152.4
  IN1 w0.136: X3.1 260.44,-164.94 260.57,-165.07 410.64,-165.07 410.82,-164.89 X4.4
TDR_DIFF_85_IN2_DN: length 152.5
  IN2 w0.136: X8.1 260.44,-170.3 260.56,-170.18 410.68,-170.18 410.82,-170.31 X7.4
TDR_DIFF_85_IN2_DP: length 152.5
  IN2 w0.136: X8.4 260.44,-169.78 260.56,-169.9 410.68,-169.9 410.82,-169.76 X7.1
TDR_DIFF_85_TOP_DN: length 152.4
  TOP w0.124: X1.4 410.75,-160.11 410.63,-160.23 260.56,-160.23 260.44,-160.11 X2.1
TDR_DIFF_85_TOP_DP: length 152.4
  TOP w0.124: X2.4 260.44,-160.66 260.56,-160.54 410.63,-160.54 410.75,-160.66 X1.1
TDR_GND:
  vias: v2(20.98,-158.49) v2(20.98,-163.57) v2(20.98,-168.65) v2(23.25,-171.74) v2(26.03,-158.24) v2(28.33,-171.74) v2(30.47,-158.21) v2(33.41,-171.74) v2(35.26,-158.39) v2(38.43,-171.74) v2(40.22,-158.35) v2(43.51,-171.74) v2(43.75,-155.19) v2(48.52,-153.41) v2(48.59,-171.74) v2(53.6,-153.41) v2(53.67,-171.74) v2(58.68,-153.41) v2(58.68,-171.74) v2(63.76,-153.41) v2(63.76,-171.74) v2(68.84,-153.41) v2(68.84,-171.74) v2(73.92,-153.41) v2(73.92,-171.74) v2(79,-153.41) v2(79,-171.74) v2(84.08,-153.41) v2(84.08,-171.74) v2(88.91,-156.81) v2(89.16,-171.74) v2(93.99,-156.81) v2(94.24,-171.74) v2(99.07,-156.81) v2(99.32,-171.74) v2(104.15,-156.81) v2(104.4,-171.74) v2(109.23,-156.81) v2(109.48,-171.74) v2(114.31,-156.81) v2(114.56,-171.74) v2(119.64,-152.78) v2(119.64,-171.74) v2(124.72,-152.78) v2(124.72,-171.74) v2(129.8,-152.78) v2(129.8,-171.74) v2(134.88,-152.78) v2(134.88,-171.74) v2(139.96,-152.78) v2(139.96,-171.74) v2(144.98,-152.78) v2(145.04,-171.74) v2(150.06,-152.78) v2(150.12,-171.74) v2(155.14,-152.78) v2(155.14,-171.74) v2(160.22,-152.78) v2(160.22,-171.74) v2(165.3,-152.78) v2(165.3,-171.74) v2(170.38,-152.78) v2(170.38,-171.74) v2(175.46,-152.78) v2(175.46,-171.74) v2(180.54,-152.78) v2(180.54,-171.74) v2(185.62,-152.78) v2(185.62,-171.74) v2(190.7,-152.78) v2(190.7,-171.74) v2(195.78,-152.78) v2(195.78,-171.74) v2(200.86,-152.78) v2(200.86,-171.74) v2(205.94,-152.78) v2(205.94,-171.74) v2(211.02,-152.78) v2(211.02,-171.74) v2(216.1,-152.78) v2(216.1,-171.74) v2(221.18,-152.78) v2(221.18,-171.74) v2(226.26,-152.78) v2(226.26,-171.74) v2(231.34,-152.78) v2(231.34,-171.74) v2(236.42,-152.78) v2(236.42,-171.74) v2(240.57,-155.2) v2(241.5,-171.74) v2(242.82,-158.28) v2(246.58,-171.74) v2(247.16,-158.29) v2(251.66,-171.74) v2(252.06,-158.28) v2(255.02,-157.29) v2(255.68,-154.8) v2(261.82,-153.41) v2(261.82,-171.74) v2(266.9,-153.41) v2(266.9,-171.74) v2(271.98,-153.41) v2(271.98,-171.74) v2(277.06,-153.41) v2(277.06,-171.74) v2(282.14,-153.41) v2(282.14,-171.74) v2(287.22,-153.41) v2(287.22,-171.74) v2(292.3,-153.41) v2(292.3,-171.74) v2(297.38,-153.41) v2(297.38,-171.74) v2(302.46,-156.15) v2(302.46,-171.74) v2(307.54,-156.15) v2(307.54,-171.74) v2(312.62,-156.15) v2(312.62,-171.74) v2(317.7,-156.15) v2(317.7,-171.74) v2(322.78,-156.15) v2(322.78,-171.74) v2(327.86,-156.15) v2(327.86,-171.74) v2(332.94,-153.41) v2(332.94,-171.74) v2(338.02,-153.41) v2(338.02,-171.74) v2(343.1,-153.41) v2(343.1,-171.74) v2(348.18,-153.41) v2(348.18,-171.74) v2(353.26,-153.41) v2(353.26,-171.74) v2(358.34,-153.41) v2(358.34,-171.74) v2(363.42,-153.41) v2(363.42,-171.74) v2(368.5,-153.41) v2(368.5,-171.74) v2(373.58,-153.41) v2(373.58,-171.74) v2(378.66,-153.41) v2(378.66,-171.74) v2(383.74,-153.41) v2(383.74,-171.74) v2(388.82,-153.41) v2(388.82,-171.74) v2(393.9,-153.41) v2(393.9,-171.74) v2(398.98,-153.41) v2(398.98,-171.74) v2(404.06,-153.41) v2(404.09,-171.71) v2(408.52,-153.41) v2(409.15,-171.66) v2(414.98,-153.41) v2(414.98,-158.49) v2(414.98,-163.57) v2(414.98,-171.74)
TDR_SE_50_OHM_BOT: length 152.5
  BOTTOM w0.112: J50.3 29.18,-162.26 103.82,-162.26 104.08,-162 104.08,-161.18 103.78,-160.88 29.2,-160.88 J50.2
