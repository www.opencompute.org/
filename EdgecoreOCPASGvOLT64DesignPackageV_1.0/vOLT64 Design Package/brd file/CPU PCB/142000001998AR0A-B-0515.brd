# Allegro board 142000001998AR0A-B-0515.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VR_PWREN_PVDDR: length 190.3
  TOP w0.114: U12.N11 v3(199.09,49.61) ; v2(54.48,5.61) 54.62,5.75 U29.17
  S3 w0.102: v2(102.13,13.87) 99.06,10.79 88.76,10.79 81.45,3.48 73.43,3.48 72.06,2.11 61.88,2.11 59.98,4.01 56.23,4.01 54.63,5.61 v2(54.48,5.61)
  S8 w0.102: v3(199.09,49.61) 199.52,49.18 199.52,45.32 199.09,44.88 199.09,43.88 198.84,43.64 197.84,43.64 197.63,43.43 196.15,43.43 196.05,43.33 195.19,43.33 194.91,43.05 194.91,42.43 194.91,41.95 190.17,37.21 190.17,27.34 187.88,25.04 179.34,25.04 177.41,23.11 177.41,21.84 176.77,21.2 176.77,20.2 176.5,19.93 174.29,19.93 173.75,19.39 173,19.39 172.21,18.6 172.21,16.97 167.3,12.06 160.27,12.06 156.1,7.9 139.29,7.9 138.23,8.97 138.23,10.15 137.96,10.41 135.94,10.41 131.6,14.75 120.05,14.75 119.29,15.52 105.97,15.52 105.64,15.19 103.45,15.19 v2(102.13,13.87)
  BOTTOM w0.114: R755.1 54.41,5.54 v2(54.48,5.61) ; v1(199.94,47.38) 199.92,47.38 199.58,47.72 199.58,49.12 v3(199.09,49.61)
VTT_REFIN: length 5
  BOTTOM w0.254: v1(38.5,25.58) C588.2 R700.1 R699.2 39.31,28.56 39.75,29 U37.1
VTT_REFOUT: length 2.4
  TOP w0.114: v2(44.37,31.67) 43.81,31.11 C155.2
  BOTTOM w0.114: U37.6 43.7,31 v2(44.37,31.67)
WAKEL_DIR: length 4.6
  TOP w0.114: R802.2 R982.2 168.28,106.32 v2(167.4,107.2) U38.5
WATCHDOG_IND: length 150.8
  TOP w0.114: v2(99.06,98.3) 98.48,98.3 98.09,97.91 98.09,95.76 99.55,94.3 99.55,94.26 99.75,94.07 99.75,91.74 99.49,91.49 99.49,91.06 99.69,90.86 99.69,90.58 99.34,90.22 U9.AM4 ; v2(203.53,71.33) 203.71,71.15 R885.1 R155.1 R153.2
  S3 w0.102: v2(99.06,98.3) 99.75,98.98 101.47,98.98 102.03,99.54 102.03,100.61 102.39,100.97 105.02,100.97 105.22,100.76 111.61,100.76 114.35,98.02 114.55,98.02 114.88,97.69 114.88,96.49 121.48,89.9 123.13,89.9 124.66,88.37 124.66,86.72 126.7,84.68 130.23,84.68 136.17,78.74 150.94,78.74 153.56,76.12 156.57,76.12 v2(156.82,76.38)
  S8 w0.102: v2(203.53,71.33) 201.5,73.36 179.7,73.36 175.53,77.53 173.49,77.53 171.98,79.04 171.98,85.17 170.92,86.23 168.76,86.23 166.9,84.38 166.9,79.12 164.16,76.38 v2(156.82,76.38)
  BOTTOM w0.114: v1(97.16,99.09) 98.27,99.09 v2(99.06,98.3)
XDP_CPU_MBP<2>: length 131.3
  TOP w0.114: U9.N78 107.26,54.49 v2(107.63,54.11) ; v2(26.75,2.11) 26.89,2.25 CONN11.9
  S5 w0.102: v2(26.75,2.11) 34.57,9.93 34.57,11.59 36.34,13.36 55.4,13.36 57.15,15.11 66.96,15.11 69.14,17.3 73.56,17.3 74.19,16.66 78.67,16.66 79.97,17.96 86.7,17.96 88.35,19.61 88.98,19.61 90.07,20.69 90.07,23.59 92.35,25.88 92.35,30.99 93.14,31.78 93.14,47.17 93.85,47.88 94.61,47.88 95.43,48.69 95.43,49.87 96.53,50.98 97.17,50.98 99.43,53.24 106.76,53.24 v2(107.63,54.11)
  BOTTOM w0.114: R773.1 26,2.86 v2(26.75,2.11) 26,1.36 22.9,1.36 20.8,3.45 v1(20.8,4.51)
XDP_CPU_MBP<3>: length 137.7
  TOP w0.102: 107.96,55.27 107.96,56.22 108.09,56.35 108.09,56.7 107.75,57.04 U9.M75
  TOP w0.114: v2(27.58,2.13) 27.39,2.33 CONN11.11 ; v2(108.79,49.15) 109.37,49.73 109.37,53.86 107.96,55.27
  S5 w0.102: v2(108.79,49.15) 107.16,47.52 107.16,45.42 104.9,43.15 104.9,42.01 99.65,36.76 98.9,36.76 98.42,36.28 98.42,28.97 93.85,24.4 93.85,14.5 91.46,12.11 77.69,12.11 76.15,10.57 71.5,10.57 69.01,13.06 61.47,13.06 57.12,8.71 55.39,8.71 54.88,9.22 54.23,9.22 53.85,8.84 50.88,8.84 48.23,6.2 48.23,5.92 48.18,5.87 v2(48.18,5.82)
  S10 w0.102: v2(27.58,2.13) 29.51,4.06 40.8,4.06 43.09,6.35 45.41,6.35 45.66,6.1 47.9,6.1 v2(48.18,5.82)
  BOTTOM w0.114: v1(19.69,3.87) 19.69,3.52 22.1,1.12 26.57,1.12 v2(27.58,2.13) 26.91,2.81 R774.1
XDP_CPU_MBP<4>: length 147.2
  TOP w0.102: U9.J78 111.21,53.85
  TOP w0.114: CONN11.15 v2(28.39,2.16) ; 111.21,53.85 111.21,48.83 110.41,48.03 109.25,48.03 v2(108.81,47.6)
  S5 w0.102: v2(49.99,5.51) 49.99,7.06 51.31,8.38 53.89,8.38 54.22,8.05 54.79,8.05 55,8.26 57.31,8.26 61.66,12.6 68.53,12.6 72.64,8.48 72.67,8.48 74.05,7.1 77.54,7.1 77.76,7.32 80.12,7.32 81.02,8.21 81.65,8.21 82.2,8.76 82.95,8.76 83.49,8.23 85.41,8.23 88.74,11.55 91.55,11.55 94.31,14.31 94.31,24.21 99.77,29.67 99.77,36.01 99.77,36.01 99.77,36.23 102.31,38.77 104.58,38.77 105.78,39.98 106.59,39.98 106.93,40.33 106.93,43.48 107.62,44.16 107.62,46.41 v2(108.81,47.6)
  S10 w0.102: v2(49.99,5.51) 48.21,7.29 43.05,7.29 40.51,4.75 25.3,4.75 23.75,3.2 23.75,2.06 24.23,1.57 27.8,1.57 v2(28.39,2.16)
  BOTTOM w0.114: v1(27.86,6.12) 27.86,4.88 27.51,4.52 27.51,3.17 27.73,2.95 R766.1 28.07,2.49 v2(28.39,2.16)
XDP_CPU_MBP<5>: length 137.6
  TOP w0.102: U9.H75 109.73,57 109.58,56.85 109.58,56.33 111.7,54.21
  TOP w0.114: CONN11.17 28.89,2.45 v2(29.18,2.16) ; v2(110.21,46.84) 111.7,48.32 111.7,54.21
  S5 w0.102: v2(43.16,5.76) 43.16,4.46 43.81,3.81 51.15,3.81 52.14,4.8 55.97,4.8 56.49,4.28 59.63,4.28 61.75,6.4 61.91,6.4 62.69,7.18 66.43,7.18 67.82,5.79 69.43,5.79 70.52,6.88 72.97,6.88 73.69,6.17 76.94,6.17 77.67,5.44 79.24,5.44 79.43,5.24 79.68,5.24 80.08,5.64 80.66,5.64 81.63,6.61 81.92,6.61 82.26,6.94 82.64,6.94 82.97,6.61 85.09,6.61 89.11,10.64 92.59,10.64 95.27,13.31 95.27,23.87 100.69,29.29 100.69,35.63 100.69,35.64 100.69,35.85 102.69,37.86 104.96,37.86 106.16,39.07 108.51,39.07 109.47,40.03 109.47,44.01 110.64,45.18 110.64,46.41 v2(110.21,46.84)
  S10 w0.102: v2(29.18,2.16) 30.86,3.84 41.24,3.84 v2(43.16,5.76)
  BOTTOM w0.114: v2(29.18,2.16) 28.96,2.39 R767.1 29.31,2.95 29.62,3.25 29.62,5.94 v1(29.49,6.07)
XDP_CPU_MBP<6>: length 140.1
  TOP w0.102: 110.97,53.75 109.35,55.37 109.25,55.37 108.95,55.66 108.95,56.07 109.09,56.21 109.09,56.69 108.74,57.04 U9.K75
  TOP w0.114: v2(110.21,48.51) 110.97,49.28 110.97,53.75 ; CONN11.21 v2(29.89,2.16)
  S5 w0.102: v2(45.44,5.61) 46.79,4.27 50.96,4.27 52.02,5.33 52.02,7.04 52.85,7.87 53.76,7.87 54.03,7.59 55.02,7.59 56.43,6.19 56.43,4.99 56.68,4.74 59.44,4.74 61.56,6.86 61.72,6.86 62.53,7.67 66.59,7.67 68.01,6.25 69.24,6.25 70.33,7.34 73.16,7.34 73.87,6.63 77.13,6.63 77.86,5.89 79.69,5.89 79.89,6.1 80.47,6.1 81.44,7.06 81.74,7.06 82.12,7.45 82.12,8.04 82.39,8.31 82.76,8.31 83.88,7.19 85.02,7.19 88.92,11.09 92.4,11.09 94.78,13.48 94.78,24.03 100.23,29.48 100.23,35.82 100.23,35.82 100.23,36.04 102.5,38.32 104.77,38.32 105.97,39.52 107.57,39.52 108.08,40.03 108.08,46.13 108.46,46.51 108.85,46.51 109.65,47.31 109.65,47.75 110.21,48.31 v2(110.21,48.51)
  S10 w0.102: v2(45.44,5.61) 43.71,5.61 41.71,3.61 31.34,3.61 v2(29.89,2.16)
  BOTTOM w0.114: v2(29.89,2.16) 30.51,2.78 R768.1 30.27,2.95 29.97,3.25 29.97,4.62 30.3,4.95 30.3,6.02 v1(30.86,6.58)
XDP_CPU_MBP<7>: length 131.8
  TOP w0.102: 111.46,54.1 109.37,56.19 109.37,56.92 U9.J76
  TOP w0.114: 111.46,54.1 111.46,48.62 110.39,47.55 v2(110.21,47.55) ; CONN11.23 30.39,2.6 v2(30.86,2.13)
  S5 w0.102: v2(110.21,47.55) 109.7,47.04 109.7,46.12 108.31,44.72 108.31,39.94 107.66,39.29 106.07,39.29 104.86,38.09 102.6,38.09 100.46,35.95 100.46,35.73 100.46,35.73 100.46,29.39 95.04,23.97 95.04,13.41 92.5,10.86 89.02,10.86 84.99,6.84 83.07,6.84 82.73,7.17 82.16,7.17 81.83,6.84 81.54,6.84 80.57,5.87 79.99,5.87 79.78,5.66 77.77,5.66 77.03,6.4 73.78,6.4 73.07,7.11 70.43,7.11 69.34,6.02 67.91,6.02 66.49,7.44 62.63,7.44 61.82,6.63 61.65,6.63 59.53,4.51 56.58,4.51 56.2,4.9 56.2,5.87 55.57,6.49 53.51,6.49 51.05,4.04 45.35,4.04 44.52,4.87 v2(44.52,5.12)
  S10 w0.102: v2(30.86,2.13) 32.11,3.38 43.48,3.38 44.52,4.42 v2(44.52,5.12)
  BOTTOM w0.114: R769.1 31.45,2.72 v2(30.86,2.13)
XDP_CPU_PRDY_N: length 135.3
  TOP w0.102: U9.L78 108.25,55.35
  TOP w0.114: v2(25.59,2.08) 25.89,2.39 CONN11.5 ; v2(108.79,48.31) 109.61,49.14 109.61,53.99 108.25,55.35
  S5 w0.102: v2(108.79,48.31) 107.39,46.91 107.39,44.73 105.97,43.31 105.97,40.49 104.48,39 102.22,39 99.54,36.33 99.54,36.11 99.54,36.11 99.54,29.76 94.08,24.3 94.08,14.4 91.56,11.88 77.79,11.88 76.24,10.34 71.41,10.34 68.92,12.83 61.56,12.83 57.22,8.48 54.9,8.48 54.7,8.28 54.32,8.28 53.99,8.61 51.09,8.61 49.05,6.57 v2(49.05,5.66)
  S10 w0.102: v2(25.59,2.08) 27.8,4.29 40.71,4.29 43,6.58 45.51,6.58 45.77,6.32 48.39,6.32 v2(49.05,5.66)
  BOTTOM w0.114: R772.1 25.06,2.61 v2(25.59,2.08) 25.1,1.6 23.06,1.6 22.03,2.63 v1(22.03,3.85)
XDP_CPU_PREQ_N: length 142.4
  TOP w0.102: U9.K77 108.74,56.55 108.74,55.58 110.72,53.6
  TOP w0.114: v2(110.19,49.2) 110.72,49.73 110.72,53.6 ; CONN11.3 25.39,2.76 v2(24.74,2.11)
  S5 w0.102: v2(110.19,49.2) 109.42,48.44 109.42,47.41 108.75,46.74 108.36,46.74 107.85,46.22 107.85,44.07 107.16,43.38 107.16,40.23 106.68,39.75 105.88,39.75 104.67,38.54 102.41,38.54 100,36.14 100,35.92 100,35.92 100,29.58 94.54,24.11 94.54,14.22 91.65,11.32 88.83,11.32 85.49,7.99 83.41,7.99 82.86,8.53 82.29,8.53 81.74,7.99 81.11,7.99 80.21,7.09 77.85,7.09 77.62,6.86 74.68,6.86 74.66,6.87 73.96,6.87 72.57,8.25 72.55,8.25 68.43,12.37 61.75,12.37 57.41,8.03 55.09,8.03 54.89,7.82 54.13,7.82 53.8,8.15 52.81,8.15 51.79,7.14 51.79,5.42 50.86,4.5 46.96,4.5 46.02,5.44 v2(46.02,6.78)
  S10 w0.102: v2(46.02,6.78) 46,6.81 42.9,6.81 40.61,4.52 25.39,4.52 24.74,3.87 v2(24.74,2.11)
  BOTTOM w0.114: v1(23.04,4.68) 23.04,3.32 23.43,2.94 R771.1 24.12,2.73 v2(24.74,2.11)
XDP_CPU_PRESENT_N: length 125
  TOP w0.102: U9.M77 107.75,55.09
  TOP w0.114: v2(40.34,7.92) 40.03,7.92 39.39,8.56 CONN11.60 ; 107.75,55.09 108.76,54.08 v2(108.76,53.72)
  S5 w0.102: v2(40.34,7.92) 39.42,7.92 38.99,7.49 38.99,7.16 38.63,6.81 37.31,6.81 35.92,8.2 35.92,12.38 36.38,12.85 38.25,12.85 38.8,12.29 48.01,12.29 48.44,12.73 55.09,12.73 57.24,14.88 69.49,14.88 70.3,15.7 72.43,15.7 73.78,14.35 76.68,14.35 80.06,17.73 86.8,17.73 88.45,19.38 89.08,19.38 90.3,20.6 90.3,23.5 92.58,25.78 92.58,30.89 93.37,31.68 93.37,46.28 93.7,46.61 94.19,46.61 95.66,48.08 95.66,49.78 96.58,50.7 97.22,50.7 98.44,51.93 104.55,51.93 104.83,52.21 104.83,52.58 105.28,53.04 108.08,53.04 v2(108.76,53.72)
  BOTTOM w0.114: v1(41.61,10.77) 41.25,10.41 41.25,9.3 40.92,8.97 R730.1 v2(40.34,7.92)
XDP_CPU_PWRBTN_N: length 16.6
  TOP w0.114: v2(34.54,2.11) 34.89,2.46 CONN11.41
  S3 w0.102: v2(25.29,7.02) 25.29,6.26 27.55,4 32.65,4 v2(34.54,2.11)
  BOTTOM w0.114: v2(34.54,2.11) 34.8,2.36 R759.1 ; v1(26.99,7.93) 26.21,7.93 v2(25.29,7.02)
XDP_CPU_SDA: length 10.4
  TOP w0.114: CONN4.51 20.32,121.54 v2(20.12,121.74)
  BOTTOM w0.114: v1(15.67,119.59) 15.67,121.41 16.65,122.39 19.47,122.39 v2(20.12,121.74) 20.12,121.08 20.57,120.62 R426.1
XDP_CPU_TCK0: length 110.5
  TOP w0.114: v2(39.39,2.08) 38.89,2.58 CONN11.57 ; v2(106.53,38.25) 108.03,39.75 108.85,39.75 109.42,40.32 109.42,46.3 109.06,46.67 108.39,46.67 108.2,46.86 108.18,46.86 108.18,47.37 R255.2
  S5 w0.102: v2(39.39,2.08) 40.18,2.87 52.65,2.87 53.12,3.34 57.04,3.34 57.95,2.43 60.22,2.43 60.88,3.1 60.88,4.05 61.15,4.32 62.71,4.32 63.14,4.75 65.66,4.75 66.45,3.96 67.17,3.96 67.63,4.42 72.48,4.42 72.79,4.11 77.66,4.11 77.71,4.06 83.51,4.06 88.78,9.33 94.11,9.33 94.64,9.86 94.64,12.03 95.72,13.12 95.72,23.66 101.12,29.06 101.12,29.08 101.14,29.1 101.14,35.44 101.14,35.45 101.14,35.66 102.88,37.4 105.68,37.4 v2(106.53,38.25)
  BOTTOM w0.114: R764.1 v2(39.39,2.08)
XDP_CPU_TDI: length 113.5
  TOP w0.114: R248.2 v2(105.46,49.94) ; v2(39.75,7.39) 39.5,7.39 38.39,8.5 CONN11.56
  S5 w0.102: v2(105.46,49.94) 104.8,50.6 99.69,50.6 99.42,50.32 99.42,49.2 97.49,47.27 96.57,47.27 95.33,46.02 95.33,41.66 94.51,40.84 94.51,31.21 93.73,30.42 93.73,25.24 93.17,24.68 93.17,14.83 91.14,12.8 77.68,12.8 77.28,13.21 73.3,13.21 71.96,14.55 70.78,14.55 69.97,13.74 60.33,13.74 59,12.42 56.4,12.42 55.56,11.58 53.85,11.58 51.79,9.53 45.47,9.53 42.42,6.48 41.75,6.48 40.84,7.39 v2(39.75,7.39)
  BOTTOM w0.114: R739.1 39.17,7.98 v2(39.75,7.39) 40.74,7.39 41.78,8.43 43.56,8.43 v1(43.76,8.64)
XDP_CPU_TDO: length 117.6
  TOP w0.114: v2(107.61,49.91) 107.62,49.91 107.49,50.04 R243.1 ; CONN11.52 37.39,8.21 v2(38.24,7.37)
  S5 w0.102: v2(107.61,49.91) 107.62,49.91 106.48,51.05 98.54,51.05 98.04,50.56 98.04,48.79 97.01,47.75 96.3,47.75 94.87,46.32 94.87,41.85 94.06,41.03 94.06,31.4 93.64,30.98 93.27,30.61 93.27,25.5 91.03,23.27 91.03,18.92 90.14,18.03 90.14,17.46 85.94,13.26 82.97,13.26 80.66,15.57 79.32,15.57 77.42,13.67 73.49,13.67 72.15,15.01 70.59,15.01 69.78,14.2 57.53,14.2 55.37,12.04 48.87,12.04 48.39,11.56 41.4,11.56 39.41,9.56 39.41,8.53 v2(38.24,7.37)
  BOTTOM w0.114: v1(43.43,6.99) 42.7,7.72 41.55,7.72 40.72,6.88 38.72,6.88 v2(38.24,7.37) R738.1
XDP_CPU_TMS: length 109.2
  TOP w0.114: R242.2 v2(108.79,49.89) ; CONN11.58 v2(38.89,11.3)
  S5 w0.102: v2(38.89,11.3) 39.15,11.05 40.51,11.05 41.27,11.81 48.26,11.81 48.72,12.27 55.28,12.27 57.43,14.43 69.68,14.43 70.49,15.24 72.24,15.24 73.59,13.89 77.32,13.89 79.23,15.8 80.85,15.8 83.16,13.49 85.85,13.49 89.92,17.56 89.92,18.13 90.81,19.02 90.81,23.36 93.04,25.6 93.04,30.7 93.47,31.14 93.83,31.49 93.83,41.13 94.64,41.94 94.64,46.42 96.11,47.89 96.11,49.59 96.77,50.24 97.41,50.24 98.45,51.28 107.4,51.28 v2(108.79,49.89)
  BOTTOM w0.114: R726.1 38.89,11.84 v2(38.89,11.3)
XDP_CPU_TRST_N: length 116.9
  TOP w0.114: CONN11.54 37.89,8.39 39.52,6.76 41.86,6.76 v2(42.16,7.06) ; v2(106.45,49.91) 106.32,50.04 R246.1
  S5 w0.102: v2(42.16,7.06) 46.41,11.3 48.51,11.3 49.02,11.81 55.46,11.81 57.62,13.97 69.87,13.97 70.68,14.78 72.05,14.78 73.4,13.44 78.21,13.44 79.32,14.55 81.36,14.55 82.88,13.03 91.03,13.03 92.94,14.94 92.94,24.85 93.5,25.41 93.5,30.51 93.8,30.81 94.28,31.3 94.28,40.94 95.1,41.75 95.1,46.23 96.39,47.52 97.1,47.52 98.27,48.69 98.27,50.46 98.64,50.83 105.54,50.83 v2(106.45,49.91)
  BOTTOM w0.114: v2(42.16,7.06) 41.71,6.6 38.33,6.6 37.72,7.21 37.72,8.32 R737.1
XDP_NOA0_PCH: length 63.8
  TOP w0.114: R79.1 83.01,108.66 v2(82.63,109.04) ; v2(32.38,116.71) 32.38,117.53 30.82,119.09 CONN4.9
  S5 w0.102: v2(32.38,116.71) 32.77,116.33 34.77,116.33 35.51,115.6 45.87,115.6 46.38,116.1 68.05,116.1 68.17,115.98 70.26,115.98 70.82,116.54 73.84,116.54 74.29,116.08 76.78,116.08 78.96,113.89 79.8,113.89 81.08,112.61 81.08,111.91 82.21,110.78 82.21,109.46 v2(82.63,109.04)
  BOTTOM w0.114: v1(33.17,118.26) 32.92,118.01 32.92,117.65 32.56,117.29 32.56,116.78 32.49,116.71 v2(32.38,116.71)
XDP_NOA1_PCH: length 91.6
  TOP w0.114: CONN4.11 30.32,118.48 v2(31.09,117.7)
  S5 w0.102: v2(90.42,106.05) 90.88,105.59 90.88,103.3 90.35,102.77 90.35,102.11 90.47,101.98 90.47,101.28 89.17,99.97 87.52,99.97 87.25,100.24 87.25,103.96 87.86,104.57 87.86,107.29 88.44,107.87 88.44,113.65 85.15,116.94 78.86,116.94 78.79,117.02 76.02,117.02 76,116.99 74.67,116.99 74.22,117.45 70.44,117.45 70.01,117.02 44.79,117.02 44.28,116.51 36.4,116.51 34.87,118.03 31.92,118.03 31.59,117.7 v2(31.09,117.7)
  BOTTOM w0.114: v2(90.42,106.05) 90.25,106.05 89.64,105.43 R480.1 ; v1(31.57,118.85) 31.57,118.19 v2(31.09,117.7) 30.33,118.46 R416.1
XDP_NOA2_PCH: length 74.6
  TOP w0.114: CONN4.15 29.32,117.62 v2(29.44,117.5) ; R83.1 86.51,107.37 v2(86.33,107.54)
  S5 w0.102: v2(29.44,117.5) 29.92,117.02 30.63,117.02 30.75,116.89 31.43,116.89 31.55,117.02 32.07,117.53 34.73,117.53 36.21,116.06 44.47,116.06 44.97,116.56 70.19,116.56 70.63,116.99 74.03,116.99 74.48,116.54 76.19,116.54 76.21,116.56 78.6,116.56 78.67,116.48 84.96,116.48 87.12,114.32 87.12,109.86 87.58,109.41 87.58,108.33 86.79,107.54 v2(86.33,107.54)
  BOTTOM w0.114: v1(28.7,116.59) 28.7,116.76 v2(29.44,117.5) 29.39,117.55 R415.1
XDP_NOA3_PCH: length 72.8
  TOP w0.114: R102.1 85.45,104.62 v2(84.99,105.08) ; v2(28.68,117.5) 28.82,117.64 CONN4.17
  S5 w0.102: v2(28.68,117.5) 29.39,116.79 30.53,116.79 30.66,116.66 31.52,116.66 31.65,116.79 32.16,117.3 34.63,117.3 36.11,115.83 44.56,115.83 45.07,116.33 70.29,116.33 70.72,116.76 73.93,116.76 74.39,116.31 76.87,116.31 79.03,114.15 80.42,114.15 81.97,112.6 83.2,112.6 84.51,111.29 84.51,105.56 v2(84.99,105.08)
  BOTTOM w0.114: R414.1 28.48,117.7 v2(28.68,117.5) 27.89,117.5 v1(27.69,117.7)
XDP_NOA4_PCH: length 83.9
  TOP w0.114: v2(88.57,105.84) 89,105.41 89,104.36 R111.1 ; CONN4.27 26.32,117.93 v2(26.49,117.75)
  S5 w0.102: v2(88.57,105.84) 88.98,106.25 88.98,114.94 86.75,117.17 78.96,117.17 78.88,117.25 75.93,117.25 75.9,117.22 74.77,117.22 74.31,117.68 70.34,117.68 69.91,117.25 44.69,117.25 44.19,116.74 36.92,116.74 35.37,118.29 30.85,118.29 30.75,118.19 26.92,118.19 v2(26.49,117.75)
  BOTTOM w0.114: R421.1 27.21,118.47 v2(26.49,117.75) 25.83,117.09 25.48,117.09 24.47,116.08 v1(24.47,115.52)
XDP_NOA4_PCH_R: length 22.2
  TOP w0.102: 92.55,91.07 92.55,91.38 92.69,91.52 92.69,92.44 93.07,92.81
  TOP w0.114: 92.55,91.07 92.9,90.72 U9.BE4 ; R111.2 88.65,102.59 v2(88.9,102.34) 89.03,102.21 89.03,99.14 93.07,95.1 93.07,92.81
  BOTTOM w0.114: R111.2 88.65,102.59 v2(88.9,102.34) 89.53,101.7 89.53,98.7 90.6,97.64 v1(91.47,97.64)
XDP_NOA5_PCH: length 84.2
  TOP w0.114: v2(87.38,106.98) 87.86,106.5 87.86,104.55 R104.1 ; v2(25.65,117.75) 25.82,117.92 CONN4.29
  S5 w0.102: v2(25.65,117.75) 26.11,117.3 27.3,117.3 27.97,117.96 29.94,117.96 30.65,117.25 30.72,117.25 30.85,117.12 31.33,117.12 31.46,117.25 31.97,117.76 34.82,117.76 36.3,116.28 44.37,116.28 44.88,116.79 70.1,116.79 70.53,117.22 74.12,117.22 74.58,116.76 76.09,116.76 76.12,116.79 78.69,116.79 78.77,116.71 85.06,116.71 87.35,114.42 87.35,109.96 87.8,109.5 87.8,107.9 87.38,107.47 v2(87.38,106.98)
  BOTTOM w0.114: v1(23.85,114.4) 23.85,115.95 v2(25.65,117.75) 26.27,118.37 R420.1
XDP_NOA6_PCH: length 88.8
  TOP w0.114: v2(24.94,117.75) 24.82,117.88 CONN4.33
  S5 w0.102: v2(24.94,117.75) 25.6,118.41 30.65,118.41 30.75,118.52 35.69,118.52 36.4,117.81 38.42,117.81 38.92,117.3 44.42,117.3 44.6,117.47 69.82,117.47 70.25,117.91 74.41,117.91 74.86,117.45 75.81,117.45 75.84,117.47 78.98,117.47 79.05,117.4 86.84,117.4 89.2,115.04 89.2,103.84 88.39,103.02 88.39,102.46 v2(87.78,101.85)
  BOTTOM w0.114: R489.1 88.55,101.37 88.06,101.85 v2(87.78,101.85) ; R419.1 25.33,118.14 v2(24.94,117.75) 24.1,116.92 24.03,116.92 23.2,116.08 v1(23.2,115.52)
XDP_NOA7_PCH: length 92.2
  TOP w0.114: CONN4.35 24.32,117.86 v2(24.18,117.73)
  S5 w0.102: v2(24.18,117.73) 24.25,117.73 25.22,118.69 30.61,118.69 30.66,118.75 35.79,118.75 36.5,118.03 38.51,118.03 39.02,117.53 44.32,117.53 45.01,118.21 51.32,118.21 51.9,118.8 65.36,118.8 65.52,118.72 66.43,117.81 69.82,117.81 70.15,118.14 74.5,118.14 74.96,117.68 75.72,117.68 75.74,117.7 79.07,117.7 79.15,117.63 87.97,117.63 90.25,115.35 90.25,108.38 89.94,108.08 89.94,101.55 v2(90.02,101.47)
  BOTTOM w0.114: R418.1 24.41,117.96 v2(24.18,117.73) 22.58,116.13 v1(22.58,114.4) ; v2(90.02,101.47) 90.17,101.32 R490.1
XDP_NOA8_PCH: length 22.2
  TOP w0.114: R98.1 77.4,98.85 81.49,98.85 83.44,96.9 84.96,96.9 87.12,94.74 87.12,93.7 87.86,92.96 87.86,91.31 U9.BR2
XDP_NOA8_PCH_R: length 54.1
  TOP w0.114: CONN4.10 v2(30.82,110.36) ; R98.2 v2(72.54,107.19)
  S10 w0.102: v2(30.82,110.36) 31.25,109.93 45.95,109.93 49.7,113.68 56,113.68 58.27,111.4 60.25,111.4 61.14,110.52 66.62,110.52 67.67,109.47 70.34,109.47 70.61,109.19 71.08,109.19 72.01,108.27 72.01,107.72 v2(72.54,107.19)
  BOTTOM w0.114: v1(29.77,110.36) v2(30.82,110.36)
XDP_NOA9_PCH: length 76.3
  TOP w0.114: v4(87.45,91.36) 87.46,91.36 U9.BT3
  S5 w0.102: v2(41.83,112.65) 41.35,112.17 34.29,112.17 v2(30.48,115.98)
  BOTTOM w0.114: R441.1 30.66,114.33 R433.1 30.66,115.79 v2(30.48,115.98) ; v4(87.45,91.36) 87.81,91.72 87.81,96.27 85.78,98.3 80.64,98.3 80.01,98.93 71.58,98.93 70.03,100.49 70.03,101.3 69.11,102.21 69.11,104.06 66.34,106.83 59.28,106.83 58.42,107.7 57.02,107.7 55.5,106.17 48.31,106.17 v1(43.15,111.33) v2(41.83,112.65)
XDP_NOA9_PCH_R: length 3.9
  TOP w0.114: CONN4.12 v2(30.32,112.42)
  BOTTOM w0.114: R441.2 30.53,112.63 v2(30.32,112.42) 30.14,112.24 v1(30.14,111.58)
XDP_NOA10_PCH: length 60.9
  TOP w0.114: v2(29.59,116.33) 29.32,116.06 CONN4.16 ; R38.1 v2(80.72,111.43)
  S10 w0.102: v2(29.59,116.33) 29.59,116.22 30.29,115.52 32.89,115.52 33.94,116.57 36.26,116.57 36.44,116.4 36.56,116.35 36.65,116.28 37.67,116.28 37.82,116.43 38.04,116.66 38.51,116.66 38.59,116.74 51.71,116.74 52.22,117.25 73.97,117.25 74.96,116.26 76.29,116.26 77.39,115.15 77.39,113.68 79.64,111.43 v2(80.72,111.43)
  BOTTOM w0.114: v1(30.23,116.97) 29.81,116.97 29.59,116.74 v2(29.59,116.33) 29.54,116.28 R437.1
XDP_NOA11_PCH: length 66.5
  TOP w0.114: R115.1 81.03,103.86 v2(80.34,104.55) ; CONN4.18 28.82,115.51 28.3,116.03 v2(27.91,116.03)
  S10 w0.102: v2(80.34,104.55) 78.79,106.1 78.79,108.49 77.24,110.04 77.24,110.79 76.6,111.43 76.33,111.43 75.51,112.24 75.51,112.84 72.02,116.33 52.6,116.33 52.09,115.82 38.97,115.82 38.89,115.75 38.42,115.75 38.19,115.52 38.04,115.37 36.35,115.37 36.29,115.42 36.12,115.54 35.93,115.61 35.92,115.62 35.89,115.65 35.02,115.65 34.2,114.83 29.11,114.83 v2(27.91,116.03)
  BOTTOM w0.114: v1(27.59,115.06) R436.1 28.63,115.32 v2(27.91,116.03)
XDP_NOA14_PCH: length 55.6
  TOP w0.114: CONN4.34 24.82,112.9 v2(24.89,112.83)
  S10 w0.102: v2(72.26,112.88) 71.93,113.21 71.93,113.35 70.37,114.91 65,114.91 64.49,114.4 62.32,114.4 61.47,113.55 61.47,113.53 60.87,112.93 58.7,112.93 56.58,115.05 49.13,115.05 48.48,114.4 36.96,114.4 34.47,111.91 27.76,111.91 27.3,112.37 25.35,112.37 v2(24.89,112.83)
  BOTTOM w0.114: R444.1 v2(72.26,112.88) ; v1(23.8,111.89) 23.95,111.89 v2(24.89,112.83)
XDP_PCH_CPU_PWRGD: length 359.1
  TOP w0.114: R56.1 v2(23.14,111.18) 21.82,112.5 CONN4.46 ; U12.M6 v3(193.09,50.61)
  S3 w0.102: v3(193.09,50.61) 192.63,51.06 192.63,51.64 192.26,52.02 189.28,52.02 185.47,48.21 185.47,37.17 171.4,23.09 171.4,11.15 166.76,6.51 166.76,4.09 165.16,2.49 161.93,2.49 161.58,2.84 159.6,2.84 158.54,1.78 128.63,1.78 127.57,2.84 125.82,2.84 125.77,2.79 124.06,2.79 123.84,3.01 123.46,3.01 123.18,2.73 122.58,2.73 120.66,4.65 103.91,4.65 103.48,4.22 97.9,4.22 92.87,9.24 88.18,9.24 80.84,1.91 75.49,1.91 74.65,2.74 73.02,2.74 72.15,1.88 61.79,1.88 59.88,3.78 56.14,3.78 55.12,4.8 51.92,4.8 49.23,7.49 48.41,7.49 47.98,7.92 41.64,7.92 40.73,8.84 31.14,8.84 30.83,8.53 20.7,8.53 17.98,11.25 11.26,11.25 3.94,18.57 3.94,22.43 3.46,22.91 3.46,107.71 7.95,112.21 22.11,112.21 v2(23.14,111.18)
  BOTTOM w0.114: v1(22.05,109.91) 22.05,110.08 v2(23.14,111.18)
XDP_PCH_PWRBTN_N: length 18.3
  TOP w0.114: v2(22.56,121.89) 22.58,121.89 22.82,121.66 CONN4.41
  S5 w0.102: v2(10.43,119.79) 12.96,122.31 22.14,122.31 v2(22.56,121.89)
  BOTTOM w0.114: R423.1 22.48,121.82 v2(22.56,121.89) ; v2(10.43,119.79) 10.53,119.69 v1(11.72,119.69)
XDP_PCH_PWRGD: length 361.3
  TOP w0.114: U12.N5 v3(192.09,49.61)
  S3 w0.102: v3(192.09,49.61) 191.66,50.04 187.95,50.04 185.93,48.02 185.93,36.98 171.86,22.9 171.86,10.96 167.29,6.39 167.29,3 166.33,2.03 161.74,2.03 161.39,2.38 159.79,2.38 158.73,1.32 128.44,1.32 127.38,2.38 126.01,2.38 124.97,1.34 109.57,1.34 106.72,4.19 104.1,4.19 103.67,3.76 97.71,3.76 92.68,8.78 88.37,8.78 81.01,1.42 58.96,1.42 57.05,3.33 55.95,3.33 54.93,4.34 50.51,4.34 49.53,5.32 49.53,5.83 48.32,7.04 48.22,7.04 47.99,7.26 43.03,7.26 42.37,6.6 41.97,6.6 41.71,6.87 41.71,7.2 40.52,8.38 31.33,8.38 31.02,8.07 20.51,8.07 17.79,10.79 11.07,10.79 3.48,18.38 3.48,22.24 3,22.72 3,111.52 v2(10.32,118.83) 13.89,122.4 22.96,122.4 v2(23.19,122.17)
  BOTTOM w0.114: R424.2 23.42,121.95 v2(23.19,122.17)
XDP_PCH_PWRGD_R: length 6.9
  TOP w0.114: CONN4.39 23.32,117.88 v2(23.47,117.73)
  BOTTOM w0.114: v1(21.93,115.52) 21.93,116.19 v2(23.47,117.73) 23.42,117.78 R424.1
XDP_PCH_RSMRST: length 360.5
  TOP w0.114: CONN4.47 21.32,117.47 v2(21.52,117.27) ; v3(193.05,49.54) 193.05,49.54 193.59,50.08 U12.N6
  S3 w0.102: v3(193.05,49.54) 192.66,49.94 192.66,50.58 192.25,50.99 188.58,50.99 185.7,48.11 185.7,37.07 171.63,23 171.63,11.06 166.99,6.42 166.99,3.99 165.26,2.26 161.84,2.26 161.48,2.61 159.7,2.61 158.64,1.55 128.54,1.55 127.47,2.61 125.92,2.61 124.88,1.57 109.67,1.57 106.82,4.42 104,4.42 103.57,3.99 97.8,3.99 92.78,9.01 88.27,9.01 80.91,1.65 61.69,1.65 59.79,3.56 56.04,3.56 55.03,4.57 51.82,4.57 49.13,7.26 48.31,7.26 47.88,7.7 41.55,7.7 40.63,8.61 31.24,8.61 30.92,8.3 20.61,8.3 17.88,11.02 11.16,11.02 3.71,18.48 3.71,22.33 3.23,22.81 3.23,107.81 13.13,117.7 21.08,117.7 v2(21.52,117.27)
  BOTTOM w0.114: R422.1 v2(21.52,117.27) 20.8,116.56 20.8,115.66 v1(20.66,115.52)
XDP_PCH_SCL: length 26.7
  TOP w0.114: v2(38.4,2.08) 37.89,2.6 CONN11.53
  S3 w0.102: v2(38.4,2.08) 37.67,1.35 24.45,1.35 23.36,2.44 23.36,6.54 v2(22.93,6.97)
  BOTTOM w0.114: R763.1 38.46,2.13 v2(38.4,2.08) ; v1(25.99,6.21) 23.69,6.21 v2(22.93,6.97)
XDP_PCH_SDA: length 23.5
  TOP w0.114: CONN11.51 37.39,2.26 v2(37.57,2.08)
  S3 w0.102: v2(37.57,2.08) 37.06,1.58 24.55,1.58 23.59,2.53 23.59,6.47 v2(24.14,7.02)
  BOTTOM w0.114: R762.1 37.54,2.11 v2(37.57,2.08) ; v2(24.14,7.02) 25.15,8.03 v1(25.2,8.03)
XDP_PCH_SYSRST_N: length 357.3
  TOP w0.114: CONN11.48 36.39,10.93 35.38,11.94 28.75,11.94 v2(28.63,11.81) ; CONN4.48 21.31,114.41 21.31,111.84 v2(22.07,111.07) R55.1 ; U12.M11 v3(199.09,50.61)
  S3 w0.102: v2(100.91,14.07) 98.09,11.25 88.57,11.25 81.28,3.96 66.25,3.96 65.75,4.47 56.62,4.47 55.47,5.62 55.47,5.86 54.96,6.38 53.84,6.38 52.11,8.11 49.27,8.11 48.88,7.72 48.5,7.72 48.07,8.15 41.74,8.15 40.16,9.73 31.37,9.73 30.12,10.97 30.12,11.09 29.4,11.81 v2(28.63,11.81)
  S8 w0.102: v2(100.91,14.07) 102.51,15.67 105.48,15.67 105.78,15.98 125.5,15.98 125.8,15.67 141.88,15.67 143.61,13.94 147.48,13.94 153.2,19.66 162.74,19.66 163.68,20.6 168.94,20.6 169.36,21.02 172.16,21.02 172.58,20.6 174.25,20.6 179.18,25.53 183.19,25.53 188.87,31.21 188.87,36.7 194.45,42.28 194.45,43.24 195,43.79 195.86,43.79 195.96,43.88 197.44,43.88 197.82,44.26 197.82,44.74 197.64,44.92 197.64,47.67 197.95,47.99 198.08,47.99 198.63,48.54 198.63,50.15 v3(199.09,50.61)
  S10 w0.102: v2(28.63,11.81) 28.5,11.94 17.83,11.94 10.39,19.38 10.39,39.24 20.62,49.48 20.62,51.05 21.77,52.2 25.53,52.2 28.63,55.3 28.63,56.73 30.18,58.28 30.18,60.33 29.41,61.09 28.03,61.09 26.65,62.47 26.65,62.85 26.67,62.87 26.67,65.14 26.34,65.47 26.34,66.61 26.8,67.07 27.05,67.07 27.33,67.35 27.33,67.46 27.81,67.94 29.72,67.94 31.11,69.34 31.11,80.36 31.29,80.54 31.29,81.26 31.11,81.43 31.11,88.93 30.91,89.14 30.91,89.59 19.89,100.61 19.89,101.2 19.39,101.7 18.79,101.7 16.92,103.57 16.92,109.86 18.14,111.07 v2(22.07,111.07)
XDP_PCH_TCK0: length 80.2
  TOP w0.114: CONN4.57 18.82,117.64 v2(18.25,117.07)
  S10 w0.102: v2(78.79,104.14) 77.8,104.14 76.96,104.97 76.96,105.61 75.84,106.72 75.84,109.38 74.57,110.65 74.57,111.35 73.5,112.42 72.07,112.42 71.68,112.82 71.68,113.28 70.98,113.98 67.09,113.98 67.08,113.97 64.9,113.97 64.7,114.17 63.45,114.17 62.59,113.31 61.67,113.31 61.06,112.7 58.6,112.7 56.48,114.82 49.23,114.82 48.58,114.17 37.05,114.17 34.56,111.68 27.67,111.68 27.21,112.14 20.86,112.14 18.25,114.75 v2(18.25,117.07)
  BOTTOM w0.114: R476.1 v2(78.79,104.14) ; R417.1 v1(18.71,117.93) 18.71,117.88 18.25,117.42 v2(18.25,117.07)
XDP_PCH_TDI: length 75.6
  TOP w0.114: R116.2 v2(76.63,103.35) ; R60.1 19.46,111.49 v2(19.32,111.63) CONN4.56
  S10 w0.102: v2(19.32,111.63) 24.87,111.63 25.27,111.23 34.77,111.23 37.26,113.72 48.77,113.72 49.42,114.37 56.29,114.37 58.52,112.14 60.86,112.14 60.99,112.01 62.23,112.01 63.22,113 64.64,113 65.56,112.09 67.44,112.09 67.46,112.11 71.05,112.11 72.69,110.46 73.95,110.46 75.39,109.03 75.39,106.22 75.34,106.17 75.34,103.54 75.6,103.28 76.56,103.28 v2(76.63,103.35)
  BOTTOM w0.114: v1(20.04,114.4) 19.32,113.68 v2(19.32,111.63)
XDP_PCH_TDO: length 79.7
  TOP w0.114: v2(21.36,116.46) 21.06,116.46 20.32,115.72 CONN4.52 20.32,110.92 R58.1 ; R88.1 v2(82.04,105.16)
  S10 w0.102: v2(21.36,116.46) 21.62,116.71 28.24,116.71 29.67,115.29 33.02,115.29 34.07,116.34 36.17,116.34 36.31,116.2 36.45,116.14 36.58,116.06 37.76,116.06 37.91,116.21 38.1,116.4 38.14,116.43 38.61,116.43 38.68,116.51 51.8,116.51 52.31,117.02 73.87,117.02 74.87,116.03 75.15,116.03 76.32,114.86 76.67,114.86 77.17,114.36 77.17,113.39 79.6,110.95 79.6,109.77 81.46,107.92 81.46,105.74 v2(82.04,105.16)
  BOTTOM w0.114: v1(21.31,114.4) 21.31,116.41 v2(21.36,116.46)
XDP_PCH_TMS: length 82.6
  TOP w0.114: v2(20.27,116.48) 19.36,116.48 18.82,115.94 CONN4.58 18.82,112.34 17.75,111.28 R59.1 ; v2(83.06,103.71) 83.49,104.14 R106.2
  S10 w0.102: v2(83.06,103.71) 82.13,103.71 81,104.84 81,106.6 77.47,110.13 77.47,110.89 76.7,111.66 76.42,111.66 75.76,112.32 75.76,112.93 74.07,114.63 74.07,115.78 73.29,116.56 52.5,116.56 51.99,116.05 38.87,116.05 38.8,115.98 38.33,115.98 38.28,115.92 38.15,115.8 37.95,115.6 36.44,115.6 36.23,115.74 36.05,115.81 35.98,115.88 34.92,115.88 34.1,115.06 29.57,115.06 28.14,116.48 22.83,116.48 22.35,116 20.75,116 v2(20.27,116.48)
  BOTTOM w0.114: v1(19.39,115.52) 19.39,115.61 v2(20.27,116.48)
XDP_PCU_SCL: length 8.5
  TOP w0.114: CONN4.53 19.81,120.15 19.81,121.21 19.75,121.27 19.75,121.41 19.57,121.6 19.53,121.6 19.33,121.79 v2(19.25,121.79)
  BOTTOM w0.114: R425.1 19.66,120.78 19.25,121.18 v2(19.25,121.79) 18.95,122.09 17.5,122.09 16.99,121.59 v1(16.99,119.42)
XDP_SC_PWRGD_R: length 6.6
  TOP w0.114: v2(33.83,5.56) 34.39,5 CONN11.39
  BOTTOM w0.114: v1(31.72,8.38) 31.72,7.99 33.83,5.88 v2(33.83,5.56) 33.83,4.68 R754.1
N20732468: length 5.7
  TOP w0.114: U17.6 170.79,20.54 v2(170.78,20.53)
  BOTTOM w0.114: 171.89,20.75 R955.2 ; 171.89,20.75 171.1,20.75 170.87,20.53 v2(170.78,20.53) ; 171.89,20.75 171.42,21.22 171.42,22 v1(170.87,22.56) 170.89,22.58 R249.2
N21811685: length 4.9
  TOP w0.114: v2(131.14,81.03) 131.15,81.04 LED18.C
  BOTTOM w0.114: R868.2 131.22,83.44 130.99,83.44 130.66,83.11 130.66,82.02 v1(130.71,81.97) 130.8,81.88 130.8,81.37 v2(131.14,81.03)

## Copper pours and planes (outline as drawn)
AGND_V3P3 on S8: 147.07,32.28 147.6,31.75 157.45,31.75 157.68,31.98 157.68,39.17 157.25,39.6 147.55,39.6 147.07,39.12
AGND_VDDQ on S10: 50.72,16.31 58.39,16.31 59.87,14.83 59.87,4.52 59.4,4.05 50.68,4.05 50.29,4.44 50.29,5.13 50.7,5.54 51.65,5.54 52.06,5.95 52.06,8.03 51.7,8.39 51.21,8.39 50.22,9.38 50.22,15.8
GND on TOP (solid shape): 57.88,22.41 56.88,22.41 56.88,21.57 54.3,21.57 54.3,23.01 57.88,23.01
GND on TOP (solid shape): 73.09,21.7 72.09,21.7 72.09,20.85 67.58,20.85 67.58,22.3 73.09,22.3
GND on TOP (solid shape): 87.46,21.9 86.47,21.9 86.47,21.06 81.96,21.06 81.96,22.5 87.46,22.5
GND on TOP (solid shape): 47.98,14.38 47.98,12.65 47.47,12.14 41.53,12.14 41.1,12.57 41.1,14.55 41.5,14.96 47.4,14.96
GND on TOP (solid shape): 207.58,91.31 207.58,87.03 207.3,86.75 205.04,86.75 204.82,86.97 204.82,91.2 205.3,91.68 207.2,91.68
GND on TOP (solid shape): 102.11,25.78 104.65,25.78 104.9,25.53 106.55,25.53 106.81,25.27 109.09,25.27 109.6,24.77 109.6,23.5 110.36,22.73 113.92,22.73 114.43,22.23 114.43,21.07 114.85,20.64 120.36,20.64 120.36,20.04 119.36,20.04 119.36,19.2 103.99,19.2 101.41,21.78 99.83,21.78 98.91,22.7 98.14,22.7 96.04,24.8 96.04,26.42 96.65,27.03 100.86,27.03
GND on TOP (solid shape): outline of 171 points within 0.28,0.28 209.73,123.22
GND on BOTTOM (solid shape): 82.93,22.99 86.79,22.99 86.94,22.83 86.94,21.87 85.98,20.9 83.21,20.9 82.55,21.56 80.72,21.56 80.64,21.64 80.64,23.09 80.82,23.27 82.65,23.27
GND on BOTTOM (solid shape): 185.67,123.22 209.68,123.22 209.73,123.16 209.73,0.36 209.65,0.28 0.33,0.28 0.3,0.29 0.29,0.3 0.28,0.33 0.28,0.91 126.04,0.91 126.54,0.41 127.29,0.41 127.74,0.86 159.98,0.86 160.44,0.41 161.18,0.41 161.68,0.91 185.09,0.91 207.85,0.91 208.33,1.4 208.33,69.42 208.87,69.96 208.87,72.23 208.33,72.77 208.33,106.64 209.32,107.64 209.32,109.37 209.32,109.37 209.32,109.65 206.09,112.88 206.09,115.85 206.27,116.03 207.5,116.03 208.33,116.86 208.33,122.02 207.77,122.58 188.15,122.58 188.03,122.46 188.03,122.08 187.93,121.98 187.55,121.98 187.47,122.05 187.47,122.47 187.36,122.58 185.09,122.58 185.09,122.59 180.87,122.59 180.76,122.48 180.76,122.02 180.74,121.99 180.34,121.99 180.29,122.04 180.29,122.44 180.14,122.59 0.91,122.59 0.91,0.91 0.28,0.91 0.28,123.17 0.29,123.2 0.3,123.21 0.33,123.22 185.67,123.22
GND on S3 (solid shape): outline of 84 points within 0.28,0.28 209.73,123.22
GND on S5 (solid shape): outline of 84 points within 0.28,0.28 209.73,123.22
GND on S8 (solid shape): outline of 84 points within 0.28,0.28 209.73,123.22
GND on S10 (solid shape): outline of 84 points within 0.28,0.28 209.73,123.22
GND on TOP: 111.02,56.31 111.02,56.59 111.12,56.69 111.89,56.69 112.57,57.38 112.9,57.38 112.93,57.35 112.93,57.07 113.13,56.87 113.87,56.87 114.38,56.36 114.38,53.54 114,53.16 113.13,53.16 112.52,53.77 112.52,55.19 112.22,55.5 112.09,55.62 110.54,55.62 110.41,55.75 110.41,56.06 110.46,56.11 110.82,56.11
GND on TOP: outline of 184 points within 78.41,55.6 94.23,77.28
GND on TOP: 38.9,109.32 43.21,109.32 43.56,108.97 43.56,106.5 43.05,105.99 38.65,105.99 38.34,106.3 38.34,108.76
GND on TOP: 31.67,23.37 31.67,20.57 31.52,20.42 28.98,20.42 28.75,20.65 28.75,22.53 28.4,22.89 26.82,22.89 26.72,22.99 26.72,26.77 26.97,27.03 33.83,27.03 34.16,26.7 34.16,24.97 33.66,24.46 32.77,24.46
GND on TOP: 57.94,23.04 57.94,22.38 57.86,22.3 57.18,22.3 57.02,22.15 57.02,21.51 56.95,21.44 54.23,21.44 53.8,21.87 52.45,21.87 52.17,21.59 48.62,21.59 48.44,21.77 48.44,23.04 48.82,23.42 55.3,23.42 55.65,23.06 57.91,23.06
GND on TOP: 126.7,65.94 129.95,65.94 130.81,65.07 130.81,63.68 130.58,63.45 128.27,63.45 127.91,63.8 126.36,63.8 126.31,63.86 126.31,65.56
GND on TOP: 143.26,57.33 142.49,56.57 142.49,49.23 141.94,48.67 138.89,48.67 138.51,49.05 138.51,58.88 139.7,60.07 167.23,60.07 168.88,58.42 168.88,52.86 168.28,52.25 166.12,52.25 165.46,52.91 165.46,56.39 164.52,57.33
GND on TOP: 76.62,56.58 76.63,56.59 76.63,56.96 77.11,57.44 77.4,57.44 77.58,57.26 77.58,57.05 77.81,56.82 78.08,56.82 78.36,57.1 78.36,58.32 79.35,59.31 79.73,59.31 79.98,59.05 79.98,58.17 79.86,58.04 79.48,58.04 79.25,57.81 79.25,57.1 79.71,56.64 79.71,55.75 79.5,55.55 76.83,55.55 76.62,55.76
GND on TOP: 154.68,42.11 154.68,37.67 154.18,37.16 145.19,37.16 144.6,37.74 144.6,39.7 144.86,39.95 147.93,39.95 148.16,39.73 149.15,39.73 149.25,39.83 152.91,39.83 153.29,40.21 153.29,42.11 153.41,42.24 154.56,42.24
GND on TOP: 44.88,27.53 53.95,27.53 54.46,27.03 54.46,25.35 52.73,23.62 48.74,23.62 48.26,23.14 48.26,22.15 47.73,21.62 44.63,21.62 43.97,22.28 43.97,26.62
GND on TOP: 172.87,51.31 172.87,53.29 173.05,53.47 177.83,53.47 177.98,53.31 177.98,50.55 177.65,50.22 177.09,50.22 177.04,50.27 177.04,51.08 176.89,51.23 172.95,51.23
GND on TOP: 22.25,106.1 27.66,106.1 28.09,105.66 28.09,101.57 27.53,101.02 22.2,101.02 21.69,101.52 21.69,105.54
GND on TOP: 138.58,91.31 142.01,91.31 142.54,90.78 142.54,87.17 142.34,86.97 138.96,86.97 138.15,87.78 138.15,90.88
GND on TOP: 126.82,108.15 124.31,108.15 124.03,108.44 124.03,111.31 123.63,111.7 122.03,111.7 121.97,111.76 121.97,114.53 122.73,115.29 126.7,115.29 127.33,114.66 127.33,113.9 127.49,113.74 130.39,113.74 130.51,113.63 130.51,113.18 130.31,112.99 127.36,112.99 127.09,112.72 127.09,108.43
GND on TOP: 172.95,65.13 178.08,65.13 178.33,64.87 178.33,62.26 177.88,61.8 177.09,61.8 176.99,61.9 176.99,62.69 176.83,62.84 173.02,62.84 172.82,63.04 172.82,65
GND on TOP: 204.97,78.88 205.27,78.58 205.27,76.88 205.13,76.74 203.91,76.74 203.52,77.13 203.52,78.66 203.75,78.88
GND on TOP: 165.02,34.85 165.02,36.42 165.18,36.58 165.18,42.24 165.61,42.67 166.07,42.67 166.37,42.98 166.37,46.94 165.61,47.7 165.61,50.11 166.12,50.62 169.34,50.62 170.51,49.45 170.51,33.05 169.95,32.49 167.28,32.49 167.08,32.69 167.08,34.26 166.62,34.72 165.15,34.72
GND on TOP: 157.33,68.68 157.33,76.25 158.17,77.09 163.63,77.09 163.83,76.89 163.83,75.64 163.65,75.46 160.6,75.46 160.05,74.9 160.05,69.44 160.17,69.32 162.28,69.32 162.36,69.24 162.36,65.68 162.03,65.35 151.87,65.35 151.41,65.81 151.41,67.06 151.79,67.44 156.08,67.44
GND on TOP: 32.16,34.21 38.56,34.21 39.37,33.4 39.37,31.06 39.09,30.78 35.15,30.78 33.45,32.49 32.13,32.49 31.7,32.92 31.7,33.76
GND on TOP: outline of 86 points within 74.98,75.46 92.3,96.17
GND on TOP: 172.11,99.19 173.56,99.19 173.74,99.01 173.74,94.87 173.1,94.23 171.55,94.23 170.74,95.05 170.74,98.12 170.87,98.25 171.86,98.25 171.96,98.35 171.96,99.03
GND on TOP: 73.58,10.62 77.24,10.62 77.29,10.57 77.29,8.41 77.47,8.23 78.31,8.23 78.33,8.2 78.33,7.62 78.31,7.59 77.42,7.59 77.32,7.49 77.32,6.86 77.27,6.81 73.56,6.81 73.51,6.86 73.51,10.54
GND on TOP: 172.9,72.4 178.03,72.4 178.28,72.14 178.28,69.53 177.83,69.07 177.04,69.07 176.96,69.14 176.96,70.03 176.88,70.11 172.97,70.11 172.77,70.31 172.77,72.27
GND on TOP: 57.94,18.52 57.94,17.07 57.84,16.97 57.2,16.97 57.05,17.12 57.05,18.54 57.12,18.62 57.84,18.62
GND on TOP: 115.52,41.81 115.67,41.96 116.56,41.96 116.89,42.29 116.89,43.76 117.02,43.89 118.24,43.89 118.87,43.26 118.87,42.01 118.24,41.38 116.92,41.38 116.76,41.22 116.76,38.63 116.61,38.48 115.6,38.48 115.52,38.56
GND on TOP: 22.86,38.73 28.14,38.73 28.75,38.13 28.75,33.32 28.42,32.99 23.19,32.99 22.63,33.55 22.63,38.51
GND on TOP: 114.68,13.54 114.68,9.68 114.35,9.35 110.72,9.35 110.49,9.58 110.49,14.94 110.66,15.1 114.41,15.1 114.55,14.96 114.55,14.71 114.43,14.58 113.97,14.58 113.84,14.45 113.89,14.4 113.89,13.74 113.97,13.67 114.55,13.67
GND on TOP: 98.73,74.17 98.74,74.18 98.74,79.22 98.9,79.38 99,79.38 99.42,78.97 99.42,78.61 99.29,78.49 99.29,78.28 99.67,77.9 99.67,77.65 99.85,77.47 100.28,77.47 100.43,77.62 100.43,77.9 100.05,78.28 100.05,78.59 100.13,78.67 100.73,78.67 100.99,78.41 100.99,77.27 101.83,76.43 101.83,69.57 101.6,69.34 100.86,69.34 100.51,69.7 98.93,69.7 98.73,69.9
GND on TOP: 177.47,104.57 180.04,104.57 180.34,104.27 180.34,100.15 179.81,99.62 178.03,99.62 177.85,99.8 177.85,100.63 177.67,100.81 176.96,100.81 176.83,100.94 176.83,103.17 177.06,103.4 177.06,104.17
GND on TOP: 67.54,16.71 64.82,16.71 64.57,16.46 64.57,13.61 64.87,13.31 66.65,13.31 66.85,13.51 66.85,15.52 67.13,15.8 67.69,15.8 67.69,16.56
GND on TOP: 162.66,14.61 166.93,14.61 167.97,13.56 167.97,8.2 167.74,7.98 162.71,7.98 162.36,8.33 162.36,14.3
GND on TOP: 59.54,19.2 59.54,18.19 59.39,18.03 58.85,18.03 58.62,18.26 58.62,18.44 58.45,18.62 58.32,18.62 58.22,18.72 58.22,19.56 58.32,19.66 59.08,19.66
GND on TOP: 74.88,47.73 87.71,47.73 88.8,46.63 88.8,41.25 87.93,40.39 79.83,40.39 78.36,38.91 73.79,38.91 72.64,37.77 70.38,37.77 69.34,38.81 69.34,44.27 67.34,46.28 67.34,47.4 66.19,48.54 66.19,51.64 67.18,52.63 72.69,52.63 73.23,52.1 73.23,49.38
GND on TOP: 59.99,8.18 59.99,4.55 59.84,4.39 58.17,4.39 58.04,4.27 58.04,3.43 57.96,3.35 56.57,3.35 56.49,3.43 56.49,4.22 56.34,4.37 56.21,4.37 56.11,4.47 56.11,8.2 56.21,8.31 59.87,8.31
GND on TOP: 187.19,116.76 189.69,116.76 190.15,116.3 190.15,112.83 189.69,112.38 187.61,112.38 186.82,113.17 186.82,116.39
GND on TOP: 114.43,105.03 119.46,105.03 119.86,104.62 119.86,103.05 119.13,102.31 114.66,102.31 114.27,102.69 114.27,104.88
GND on BOTTOM: 90.47,52.63 91.82,52.63 92.15,52.3 92.15,48.9 92.02,48.77 91.39,48.77 90.83,49.33 89.66,49.33 89.08,48.74 89.08,46.91 88.62,46.46 88.06,46.46 87.68,46.84 87.68,49.83
GND on BOTTOM: 72.77,22.4 66.47,22.4 65.86,21.79 64.57,21.79 64.41,21.64 64.41,20.88 64.52,20.78 72.8,20.78 72.9,20.88 72.9,22.28
GND on BOTTOM: 166.12,29.34 166.12,31.5 167.08,32.46 167.08,34.29 167.59,34.8 170.66,34.8 170.94,34.52 170.94,31.85 171.65,31.14 172.36,31.14 173.05,30.45 173.05,29.69 172.29,28.93 166.52,28.93
GND on BOTTOM: 157.58,16.15 165.71,16.15 166.32,15.54 166.32,13.59 165.51,12.78 163.09,12.78 161.82,14.05 159.44,14.05 159.28,13.89 159.28,13.36 159.16,13.23 157.56,13.23 157.4,13.39 157.4,15.98
GND on BOTTOM: 79.27,62.2 82.55,62.2 84.28,60.48 84.28,56.21 83.44,55.37 79.55,55.37 79.17,55.75 79.17,62.1
GND on BOTTOM: 41.5,14.96 47.4,14.96 47.98,14.38 47.98,12.65 46.84,11.51 42.16,11.51 41.1,12.57 41.1,14.55
GND on BOTTOM: 96.39,51.99 97.59,51.99 97.92,51.66 97.92,50.34 97.56,49.99 96.6,49.99 96.29,50.29 96.29,51.89
GND on BOTTOM: 44.88,27.53 55.78,27.53 56.79,28.55 56.79,33.45 57.18,33.83 57.18,36.04 57.19,36.06 57.19,37.4 57.4,37.62 58.55,37.62 58.83,37.34 58.83,23.9 56.52,21.59 55.65,21.59 55.52,21.72 55.52,24.21 56.36,25.04 56.36,25.45 56.03,25.78 55.58,25.78 54.58,24.79 53.85,24.79 52.68,23.62 48.74,23.62 48.26,23.14 48.26,22.15 47.73,21.62 44.63,21.62 43.97,22.28 43.97,25.58 44.36,25.97 44.36,27.01
GND on BOTTOM: 164.77,35.81 164.77,42.82 165.28,43.33 165.28,45.69 165.48,45.9 166.29,45.9 166.47,46.08 166.47,48.59 165.71,49.35 165.71,50.6 165.99,50.88 168.73,50.88 170.51,49.1 170.51,44.3 168.61,42.39 166.62,42.39 166.27,42.04 166.27,35.97 165.89,35.59 165,35.59
GND on BOTTOM: 77.83,44.25 78.05,44.02 78.05,42.65 84.1,36.6 84.1,35.79 84.02,35.71 73.2,35.71 72.95,35.46 72.95,34.8 72.85,34.7 69.01,34.7 68.3,33.99 65.94,33.99 65.79,34.14 65.79,35.62 69.29,39.13 69.29,43.74 69.8,44.25
GND on BOTTOM: 162.69,10.19 166.78,10.19 167.06,9.91 167.06,5.13 166.7,4.78 163.32,4.78 162.41,5.69 162.41,9.91
GND on BOTTOM: 26.04,25.02 30.61,25.02 31.5,24.13 31.5,23.37 30.99,22.86 29.46,22.86 29.08,22.48 29.08,21.84 28.7,21.46 25.78,21.46 25.4,21.84 25.4,24.38
GND on BOTTOM: 7.03,91.27 7.03,95.54 8.34,96.86 14.9,96.86 15.72,96.03 15.72,91.08 13.54,88.9 9.41,88.9
GND on BOTTOM: 111.56,71.68 110.92,71.68 110.87,71.73 110.87,74.02 111.05,74.19 113.49,74.19 113.77,74.47 113.77,77.17 113.06,77.88 113.06,79.38 112.8,79.63 110.67,79.63 110.54,79.76 110.54,80.06 110.69,80.21 116.03,80.21 116.54,79.71 116.54,73.08 120.32,69.29 120.32,68.43 119.46,67.56 115.32,67.56 114.76,68.12 114.76,72.11 114.02,72.85 112.73,72.85
GND on BOTTOM: 187.74,116.66 189.69,116.66 190.01,116.34 190.01,112.81 189.76,112.56 187.12,112.56 186.84,112.84 186.84,115.76
GND on BOTTOM: 175.03,83.19 175.03,82.37 174.9,82.25 174.19,82.25 173.74,82.7 172.82,82.7 172.72,82.8 172.72,86.51 173,86.79 175.06,86.79 175.29,86.56 175.29,85.85 174.96,85.52 174.19,85.52 173.96,85.29 173.96,83.44 174.17,83.24 174.98,83.24
GND on BOTTOM: 71.4,25.48 71.07,25.81 71.07,27.25 71.27,27.46 83.41,27.46 83.59,27.28 83.59,25.43 82.73,24.56 73.15,24.56 72.24,25.48
GND on BOTTOM: 1.68,16.66 7.39,16.66 7.92,16.13 7.92,11.28 7.34,10.69 2.36,10.69 1.47,11.58 1.47,16.46
GND on G2: 0.26,0.26 0.26,123.24 209.7,123.24 209.73,123.22 209.73,0.3 209.68,0.26
GND on G4, G9: 0.26,0.26 0.26,123.24 209.7,123.24 209.73,123.22 209.73,0.3 209.68,0.26
GND on S5: 101.28,75.76 101.28,74.65 101,74.37 97.69,74.37 97.13,73.81 97.13,72.19 97.51,71.81 101.96,71.81 102.11,71.65 102.11,71.4 101.57,70.87 101.57,69.47 101.32,69.22 100.71,69.22 99.95,68.45 99.95,64.47 99.62,64.13 96.52,64.13 96.47,64.14 86.49,64.14 84.71,62.36 84.71,58.55 83.95,57.78 80.14,57.78 79.38,58.55 79.38,77.22 80.52,78.36 85.47,78.36 86.11,78.99 86.11,82.68 86.23,82.8 93.22,82.8 93.47,82.55 93.47,80.9 94.49,79.88 99.82,79.88 100.33,79.38 100.33,76.71
GND on V6: 55.65,37.19 54.05,37.19 53.3,37.93 38.76,37.93 38.08,38.61 32.59,38.61 30.84,40.36 30.84,52.45 30.2,53.09 2.06,53.09 0.69,51.71 0.38,51.71 0.3,51.79 0.3,86.44 2.79,83.95 27,83.95 28.91,85.85 28.91,107.85 32.41,111.35 55.52,111.35 61.09,105.79 65.66,105.79 68.71,102.74 68.71,100.84 70.87,98.68 93.73,98.68 95.15,97.26 95.15,93.7 96.27,92.58 96.27,88.27 93.85,85.85 93.85,85.8 93.22,85.17 93.22,73.28 92.84,72.9 88.9,72.9 88.39,72.39 88.39,71.45 88.9,70.94 88.9,70.79 88.39,70.28 88.39,68.28 88.9,67.77 88.9,67.41 88.39,66.9 88.39,66.42 90.55,64.26 92.28,64.26 92.89,63.65 92.89,63.02 92.71,62.84 92.71,62.28 92.89,62.1 92.89,61.62 92.69,61.43 92.69,60.33 93.14,59.88 93.14,51.1 77.09,35.05 57.78,35.05
GND on V6: 0.33,0.28 0.29,0.29 0.28,0.33 0.28,123.17 0.29,123.21 0.33,123.22 141.94,123.22 141.94,122.59 0.91,122.59 0.91,0.91 126.16,0.91 126.59,0.48 127.23,0.48 127.66,0.91 160.05,0.91 160.48,0.48 161.14,0.48 161.57,0.91 185.09,0.91 207.85,0.91 208.33,1.4 208.33,122.02 207.77,122.59 151.51,122.59 151.51,123.22 209.67,123.22 209.73,123.16 209.73,0.33 209.68,0.28
GND on V6, V7: 141.17,122.59 142.39,122.59 143.46,121.51 151.58,121.51 152.65,122.59 152.78,122.59 152.78,123.22 141.17,123.22
GND on V7: 34.11,57.14 35.36,57.14 35.83,56.67 38.14,56.67 38.61,57.14 70.47,57.14 71.34,58.01 77.3,58.01 77.49,57.82 77.49,57.44 66.01,45.96 63.26,45.96 60.37,43.07 60.37,40.51 59.14,39.28 34.9,39.28 32.92,41.26 32.92,55.95
GND on V7: 6.35,122.43 6.86,121.92 6.86,109.6 11.94,104.52 12.45,104.52 12.57,104.65 51.56,104.65 51.82,104.9 56.39,104.9 59.44,107.95 60.07,107.95 62.1,109.98 70.74,109.98 71.5,109.22 71.5,107.19 74.42,104.27 79.25,104.27 93.85,89.66 93.85,85.98 94.49,85.34 97.16,85.34 97.54,84.96 97.54,84.2 95,81.66 93.47,81.66 92.96,81.15 92.96,74.3 92.58,73.91 86.36,73.91 85.98,74.3 85.98,76.33 84.71,77.6 84.71,78.87 83.82,79.76 78.87,79.76 76.33,77.22 76.33,75.69 75.82,75.18 72.77,75.18 72.26,74.68 69.09,74.68 68.71,74.3 63.75,74.3 62.87,75.18 49.78,75.18 48.9,76.07 42.93,76.07 41.78,77.22 27.94,77.22 27.56,77.6 22.73,77.6 19.81,74.68 19.81,59.82 20.19,59.44 19.81,59.05 19.81,58.04 20.19,57.66 19.81,57.28 19.81,40.01 19.43,39.62 10.54,39.62 8.64,41.53 8.64,105.41 6.22,107.82 1.14,107.82 1.04,107.92 1.04,121.95 1.52,122.43 ; 1 cut-out
GND on V7: 0.33,0.28 0.29,0.29 0.28,0.33 0.28,123.17 0.29,123.21 0.33,123.22 141.91,123.22 141.91,122.59 0.91,122.59 0.91,0.91 126.16,0.91 126.59,0.48 127.23,0.48 127.66,0.91 160.05,0.91 160.48,0.48 161.14,0.48 161.57,0.91 185.09,0.91 207.85,0.91 208.33,1.4 208.33,122.02 207.77,122.58 185.09,122.58 185.09,122.59 151.54,122.59 151.54,123.22 185.67,123.22 185.67,123.22 209.68,123.22 209.73,123.16 209.73,0.36 209.65,0.28
GND on G11: 185.74,0.26 0.26,0.26 0.26,123.24 185.74,123.24 185.74,123.24 209.7,123.24 209.73,123.22 209.73,0.3 209.68,0.25 185.75,0.25
GND_SCREW1 on TOP (solid shape): outline of 235 points within 6.1,1.5 13.1,8.5
GND_SCREW1 on BOTTOM (solid shape): outline of 235 points within 6.1,1.5 13.1,8.5
GND_SCREW2 on TOP (solid shape): outline of 235 points within 172.9,106.62 179.9,113.63
GND_SCREW2 on BOTTOM (solid shape): outline of 235 points within 172.9,106.62 179.9,113.63
GND_SCREW3 on TOP (solid shape): outline of 235 points within 172.9,1.5 179.9,8.5
GND_SCREW3 on BOTTOM (solid shape): outline of 235 points within 172.9,1.5 179.9,8.5
GND_SCREW4 on TOP (solid shape): outline of 235 points within 50.02,106.62 57.03,113.63
GND_SCREW4 on BOTTOM (solid shape): outline of 235 points within 50.02,106.62 57.03,113.63
GND_SCREW5 on TOP (solid shape): outline of 235 points within 87.2,1.5 94.2,8.5
GND_SCREW5 on BOTTOM (solid shape): outline of 235 points within 87.2,1.5 94.2,8.5
P0V6_VTT on BOTTOM: 38.91,31.09 39.14,31.32 40.61,31.32 40.82,31.11 40.82,30.86 40.77,30.81 39.83,30.81 39.78,30.76 39.78,30.25 39.8,30.23 40.74,30.23 40.82,30.15 40.82,29.9 40.72,29.79 39.45,29.79 39.22,30.02 35.94,30.02 35.18,29.26 34.59,29.26 33.96,29.9 33.96,30.94 34.11,31.09
P0V6_VTT on V6: 55.27,28.85 56.67,30.25 56.67,35.66 55.37,36.96 53.59,36.96 52.68,37.87 34.85,37.87 33.86,36.88 33.86,29.84 34.85,28.85
P0V9_A_L_I210 on BOTTOM: 135.13,84.84 136.65,84.84 136.91,84.58 136.91,82.8 136.65,82.55 135.38,82.55 134.87,83.06 134.87,84.58
P0V9_A_L_I210 on S5: 135.71,80.72 134.57,81.86 134.57,93.85 135,94.28 135,96.55 135.53,97.08 153.52,97.08 156.01,94.59 156.01,83.31 153.42,80.72
P1V2_VDDQ on TOP: 79.35,73.2 79.35,74.98 79.48,75.11 79.6,75.11 79.86,74.85 79.86,72.82 80.11,72.57 80.49,72.57 80.49,72.19 80.37,72.06 80.11,72.06 79.86,71.8 79.86,71.17 79.98,71.04 80.24,71.04 80.49,70.79 80.49,70.53 80.37,70.41 80.11,70.41 79.98,70.28 79.98,69.65 80.49,69.14 80.49,68.76 80.37,68.63 80.11,68.63 79.98,68.5 79.98,67.87 80.37,67.49 80.49,67.49 80.49,67.11 80.37,66.98 79.98,66.98 79.86,66.85 79.86,66.42 80.31,65.96 81.1,65.96 81.56,65.51 81.56,65.15 81.94,64.77 81.94,64.51 81.84,64.41 81.46,64.41 80.62,65.25 80.19,65.25 79.86,64.92 79.86,64.13 79.6,63.88 79.4,63.88 79.35,63.93 79.35,68.5 79.1,68.76 79.1,69.01 79.35,69.26 79.35,71.8 78.97,72.19 78.97,72.82
P1V2_VDDQ on TOP: 45.09,28.55 44.63,29.01 44.63,32.05 48.16,35.59 54.18,35.59 54.66,36.07 54.66,43.38 55.4,44.12 55.4,49.81 63.02,57.43 74.98,57.43 75.49,56.92 75.49,55.58 73.74,53.82 65.18,53.82 60.35,49 60.35,44.42 59.28,43.36 59.28,37.39 60.83,35.84 60.83,30.78 60.45,30.4 55.93,30.4 54.08,28.55
P1V2_VDDQ on BOTTOM: 74.14,55.65 78.21,55.65 78.54,55.98 78.54,63.42 78.26,63.7 76.97,63.7 76.1,62.82 76.1,59.69 73.96,57.56 73.96,55.83
P1V2_VDDQ on BOTTOM: 45.52,32.87 53.87,32.87 54.76,33.76 54.76,38.02 55.02,38.28 55.88,38.28 56.13,38.02 56.13,29.87 54.81,28.55 45.09,28.55 44.63,29.01 44.63,29.59 45.02,29.98 45.02,32.37
P1V2_VDDQ on G2: 84.45,64.49 84.09,64.13 81.24,64.13 81.2,64.09 80.22,64.09 79.45,63.32 79.45,61.23 78.3,60.07 76.96,60.07 76.18,60.85 74.35,60.85 73.84,61.37 73.36,61.37 73.2,61.52 73.2,62 72.97,62.23 66.7,62.23 63.91,59.44 57.73,59.44 57.02,60.15 54.46,60.15 53.75,59.44 48.51,59.44 48.39,59.31 47.43,59.31 47.4,59.28 32.16,59.28 30.73,60.71 30.73,75.82 31.51,76.6 44.57,76.6 45.39,77.42 46.74,77.42 46.89,77.57 51.77,77.57 52.27,78.08 53.98,78.08 54.58,77.47 55.73,77.47 56.34,78.08 64.06,78.08 65.3,76.83 66.12,76.83 67.82,75.13 73.47,75.13 73.93,75.59 74.16,75.59 74.62,75.13 77.44,75.13 78.26,74.32 79.63,74.32 79.83,74.52 79.83,77.9 81.43,79.5 83.62,79.5 84.45,78.66 84.45,74.5 85.01,73.94 85.01,70.51 84.45,69.95
P1V2_VDDQ on G4: 84.45,72.85 83.97,72.36 83.97,70.56 84.45,70.08 84.45,64.49 84.09,64.13 81.24,64.13 81.2,64.09 80.22,64.09 76.58,60.45 75.06,60.45 74.55,59.94 68.83,59.94 67.41,58.52 63.81,58.52 63.56,58.27 55.39,58.27 54.23,59.44 48.51,59.44 48.39,59.31 47.43,59.31 47.4,59.28 32.16,59.28 30.73,60.71 30.73,75.82 31.51,76.6 38.12,76.6 41.85,80.33 52.31,80.33 53.26,81.28 65.01,81.28 65.67,80.61 67.98,80.61 70.36,78.23 80.14,78.23 80.39,77.98 84.07,77.98 84.45,77.6
P1V2_VDDQ on S5: 35.79,37.49 55.17,37.49 56.72,35.94 56.72,27.94 58.65,26.01 60.76,26.01 61.16,25.6 61.16,15.75 60.86,15.44 59.08,15.44 58.78,15.75 58.78,17.78 51.97,24.59 23.7,24.59 20.6,27.69 20.6,77.8 22.73,79.93 43.87,79.93 44.32,79.48 44.32,70.13 43.64,69.44 43.64,67.72 43.99,67.36 43.99,67.03 43.64,66.67 43.64,62.64 44.15,62.13 44.15,51.71 40.69,48.26 34.98,48.26 32.82,46.1 32.82,40.46
P1V2_VDDQ on V7: 84.45,76.3 85.45,75.31 85.45,74.27 84.45,73.28 84.45,64.49 84.09,64.13 84.09,63.98 78.44,58.32 69.62,58.32 68.83,57.53 32.99,57.53 31.72,56.26 31.72,40.56 30.33,39.17 22.07,39.17 20.5,40.74 20.5,74.22 22.88,76.6 38.12,76.6 38.13,76.61 41.33,76.61 42.32,75.62 48.56,75.62 49.4,74.78 62.76,74.78 63.45,74.09 68.86,74.09 69.19,74.42 72.34,74.42 72.64,74.73 76.45,74.73 76.86,75.13 76.86,76.83 79.15,79.12 83.69,79.12 84.45,78.36
