# Allegro board 142000001998AR0A-B-0515.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_BATLOW: length 17.8
  TOP w0.114: U9.BB4 94.39,90.22 94.74,90.57 94.74,90.87 94.08,91.53 94.08,95.18 90.75,98.5 90.75,102.46 v2(90.81,102.51)
  BOTTOM w0.114: v2(90.81,102.51) 91.4,103.11 R478.1 v1(93.8,103.11)
PCH_CPU2PCH_R_THROT: length 6.1
  TOP w0.114: R186.1 v2(192.53,63.71) ; U12.C6 v3(193.09,60.61)
  S3 w0.102: v3(193.09,60.61) 192.79,60.91 192.79,61.37 192.71,61.45 192.71,61.77 192.79,61.85 192.79,62.99 192.53,63.25 v2(192.53,63.71)
PCH_CPU2PCH_THROT: length 140.4
  TOP w0.114: R186.2 192.53,66.67 v2(191.77,67.44) ; R65.1 v2(89.69,109.7)
  S3 w0.102: v2(89.69,109.7) 90.65,110.66 90.65,114.49 92.65,116.48 93.15,116.48 95.18,114.44 102.89,114.44 107.83,109.5 110.98,109.5 114.79,105.69 120.83,105.69 122.53,107.39 133.81,107.39 135.18,108.76 139.9,108.76 140.44,108.23 146.84,108.23 147.38,108.76 147.86,108.76 149.28,107.34 150.51,107.34 153.91,103.94 161.95,103.94 163.12,102.77 166.3,102.77 172.06,97.01 172.06,87.85 183.14,76.76 184.81,76.76 191.77,69.81 v2(191.77,67.44)
  BOTTOM w0.114: v1(191.91,66.22) 191.91,67.29 v2(191.77,67.44)
PCH_CPU2PCH_THROT_R: length 31.9
  TOP w0.114: v2(89.74,108.74) 89.79,108.79 R65.2 ; v4(90.67,81.76) 90.39,82.04 U9.BL22
  S10 w0.102: v2(89.74,108.74) 89.48,108.48 89.48,102.86 89.59,102.76 89.59,102.04 89.33,101.78 89.33,98.82 92.09,96.06 92.09,88.48 91.57,87.96 91.57,87.55 91.28,87.27 91.28,86.57 91.55,86.3 91.55,85.83 91.06,85.34 91.06,84.91 90.58,84.43 90.58,84 90.29,83.71 90.29,83.17 90.67,82.78 v4(90.67,81.76)
  BOTTOM w0.114: v2(89.74,108.74) 89.5,108.98 v1(88.85,108.98)
PCH_DPWROK: length 23.8
  TOP w0.114: v2(94.03,106.86) 93.59,107.3 R71.2 ; v4(96.9,89.42) 96.9,89.69 96.37,90.22 U9.AV4
  S10 w0.102: v4(96.9,89.42) 96.9,94.71 97.64,95.45 97.64,102.66 94.03,106.26 v2(94.03,106.86)
  BOTTOM w0.114: v1(94.46,105.87) 94.03,106.3 v2(94.03,106.86) 93.59,107.3 R71.2
PCH_PLTRST_N: length 370
  TOP w0.114: R228.1 v2(191.67,42.65) ; v2(62.84,109.19) 62.97,109.07 R66.1
  S3 w0.102: v2(97.98,13.88) 96.49,12.4 88.1,12.4 86.47,10.77 82.3,10.77 79.02,7.49 77.26,7.49 76.77,7.01 70.51,7.01 69.29,5.79 66.86,5.79 66.48,5.41 63.03,5.41 62.14,6.3 61.39,6.3 59.49,8.19 54.93,8.19 54.79,8.05 54.22,8.05 53.18,9.09 44.01,9.09 42.69,10.41 32.51,10.41 31.83,11.1 31.83,12.03 30.95,12.9 26.16,12.9 25.48,12.22 11.26,12.22 4.62,18.86 4.62,22.71 4.27,23.07 4.27,89.39 22.07,107.18 30.63,107.18 36.9,113.45 36.9,115.68 36.42,116.16 36.42,117.48 39,120.07 57.33,120.07 61.26,116.13 61.26,110.77 v2(62.84,109.19)
  S8 w0.102: v2(97.98,13.88) 97.98,14.03 100.63,16.68 100.76,16.81 105,16.81 105.31,17.12 111.79,17.12 115.47,20.8 147.91,20.8 150.65,23.54 169.24,23.54 170.89,25.2 176.68,25.2 178.43,26.95 182.21,26.95 187.73,32.47 187.73,38.68 191.67,42.62 v2(191.67,42.65)
  BOTTOM w0.114: v2(191.67,42.65) 191.67,43.18 191.11,43.74 v1(190.98,43.74)
PCH_PLTRST_N_R: length 49
  TOP w0.114: U9.BE24 92.96,80.88 v4(93.24,80.88) ; R66.2 65.55,109.17 v2(66.24,109.17)
  S3 w0.102: v2(66.24,109.17) 66.65,108.76 66.65,108.05 67.64,107.06 68.12,107.06 76.09,99.09 79.93,99.09 82.27,96.74 84.81,96.74 88.6,92.96 88.6,91.36 87.5,90.27 87.5,89.18 87.3,88.98 87.3,88.32 87.81,87.81 87.81,87.6 88.29,87.12 88.29,86.74 88.7,86.33 88.7,85.9 89.08,85.52 89.08,84.9 88.73,84.56 88.73,84.17 89.28,83.62 89.28,83.24 89.69,82.83 89.69,82.4 90.09,81.99 90.09,81.79 90.55,81.33 92.53,81.33 92.98,80.88 v4(93.24,80.88)
  BOTTOM w0.114: v1(65.23,109.86) 65.91,109.17 v2(66.24,109.17)
PCH_PLTRST_R_N: length 10.7
  TOP w0.114: R228.2 192.79,44.45 v2(192.81,44.48) ; U12.M10 v3(198.09,50.61)
  S8 w0.102: v3(198.09,50.61) 197.64,50.16 196.34,50.16 195.96,49.78 195.96,48.47 194.26,46.77 194.26,46.1 193.7,45.54 193.7,45.31 193.16,44.77 193.11,44.77 v2(192.81,44.48)
PCH_PM_SYNC: length 40.7
  TOP w0.114: U9.BT9 v4(88.2,87.77) ; R47.2 v2(66.14,110.03)
  S3 w0.102: v4(88.2,87.77) 88.2,88.13 88.09,88.24 88.09,88.95 88.32,89.18 88.32,89.81 88.67,90.17 88.67,90.78 88.8,90.91 88.8,93.08 84.91,96.97 82.36,96.97 80.02,99.31 76.19,99.31 68.21,107.29 67.73,107.29 66.88,108.14 66.88,109.29 v2(66.14,110.03)
  BOTTOM w0.114: v1(67.56,107.14) 66.9,107.8 66.9,109.27 v2(66.14,110.03)
PCH_PM_SYNC_R: length 88.8
  TOP w0.114: U9.H77 110.49,56.56 v4(110.59,56.46) ; R47.1 v2(63.22,110.03)
  S3 w0.102: v4(110.59,56.46) 111.02,56.89 111.02,58.83 109.98,59.87 109.98,60.2 108.92,61.26 104.73,61.26 103.56,62.44 103.56,63.93 101.97,65.52 101.97,67.42 101.8,67.59 101.8,70.59 101.27,71.12 101.27,72.54 100.41,73.41 99.12,73.41 98.09,74.44 97.5,75.03 87.12,75.03 86.79,75.36 86.79,75.95 86.61,76.13 79.95,76.13 79.5,76.58 79.5,90.12 70,99.62 70,101.68 69.38,102.3 69.38,103.34 63.75,108.97 63.75,109.5 v2(63.22,110.03)
PCH_PME_N: length 136.6
  TOP w0.114: v2(97.38,108.74) 98.18,109.53 R50.1 ; U9.BE16 92.96,84.62 v4(93.19,84.39)
  S5 w0.102: v4(93.19,84.39) 93.56,84.39 93.95,84 96.91,84 97.14,84.24 97.14,84.53 97.42,84.8 97.71,84.8 98.12,85.21 98.12,87.58 98.66,88.12 98.66,88.61 98.46,88.81 98.46,89.64 97.19,90.91 95.24,90.91 92.99,93.16 92.99,100.13 93.83,100.97 93.83,102.84 96.77,105.79 96.77,108.13 v2(97.38,108.74)
  S8 w0.102: v2(28.09,85.6) 28.09,102.48 39.1,113.49 47.76,113.49 47.76,113.49 47.95,113.49 51.71,117.25 67.01,117.25 67.19,117.42 67.22,117.45 75.81,117.45 76.17,117.81 78.32,117.81 78.94,117.19 78.96,117.17 88.43,117.17 90.96,114.64 90.96,113.88 94.32,110.52 95.61,110.52 v2(97.38,108.74)
  BOTTOM w0.114: R540.1 26.72,84.2 28.09,85.58 v2(28.09,85.6)
PCH_PWRBTN_N: length 414.5
  TOP w0.102: 95.48,90.82 95.48,91.4 95.08,91.8 95.08,95.4 95.08,95.4 95.08,95.65 93.41,97.32
  TOP w0.114: R109.1 93.32,102.72 v2(92.91,102.31) 92.81,102.31 92.41,101.9 92.41,98.32 93.41,97.32 ; U9.AW3 95.48,90.82 ; U12.C5 v3(192.09,60.61)
  S3 w0.102: v2(92.91,102.31) 92.91,103.76 92.38,104.29 92.38,107.92 93.07,108.61 93.07,110.71 93.52,111.16 93.52,111.74 94.83,113.05 98.56,113.05 99.28,113.77 102.92,113.77 107.64,109.04 110.79,109.04 114.6,105.23 121.02,105.23 122.72,106.93 138.56,106.93 139.14,107.52 148.39,107.52 149.02,106.88 150.22,106.88 153.63,103.48 161.76,103.48 162.95,102.29 166.13,102.29 171.6,96.82 171.6,87.57 190.45,68.72 190.45,66.5 190.25,66.29 190.25,64.34 191.77,62.81 191.77,61.83 191.71,61.77 191.71,61.45 192.09,61.07 v3(192.09,60.61)
  S10 w0.102: v2(92.91,102.31) 91.19,104.04 91.19,108.2 90.98,108.41 90.98,114.73 91.87,115.62 91.87,116.24 91.6,116.51 91.25,116.51 91.2,116.56 78.83,116.56 77.91,115.65 77.53,115.65 76.7,116.48 75.05,116.48 74.06,117.47 52.12,117.47 51.61,116.97 38.49,116.97 38.42,116.89 37.95,116.89 37.72,116.66 37.57,116.51 36.72,116.51 36.67,116.55 36.57,116.59 36.36,116.8 33.74,116.8 33.2,116.26 31.83,116.26 31.11,116.97 23.04,116.97 v2(22.2,117.81) 19.26,117.81 19.09,117.98 16.41,117.98 14.27,115.85 14.27,103.76 29.82,88.21 29.82,81.58 29.51,81.28 29.51,80.52 29.82,80.22 29.82,75.67 29.84,75.64 29.84,75.26 29.82,75.24 29.82,71.37 29.13,70.69 26.55,70.69 25.43,69.56 25.43,68.47 24.61,67.66 24.61,64.22 25.38,63.46 25.38,61.72 25.55,61.55 25.55,58.78 25.15,58.37 25.15,57.82 24.61,57.28 24.61,55.57 22.28,53.24 21.34,53.24 19.58,51.49 19.58,50.54 9.35,40.3 9.35,18.9 19.75,8.49 27.95,8.49 28.68,9.22 34.8,9.22 35.96,8.05 35.96,6.42 35.84,6.3 35.23,6.3 34.59,5.66 v2(34.59,5.56)
  BOTTOM w0.114: R759.2 34.8,5.36 v2(34.59,5.56) 34.59,5.89 34.01,6.48 33.58,6.48 32.89,7.16 v1(32.89,9.04) ; v2(22.2,117.81) 22.48,118.08 R423.2 ; v3(192.09,60.61) 191.65,61.05 191.65,62.48 v1(191.26,62.87)
PCH_PWROK: length 111.4
  TOP w0.114: R189.1 186.03,68.91 v2(186.39,69.27) ; U9.AN1 98.3,92 98.3,92.32 98.27,92.35 98.27,92.71 98.3,92.74 98.3,93.47 97.97,93.8 97.97,93.98 v3(97.92,94.03)
  S3 w0.102: v2(118.29,95.81) 118.67,96.19 119.58,96.19 120.6,95.17 125.91,95.17 126.36,94.72 126.36,90.3 131.57,85.09 133.63,85.09 134,84.72 134.86,84.72 135.64,83.95 144.4,83.95 145.29,83.06 146.56,83.06 147.83,81.79 148.97,81.79 152.37,78.38 168.53,78.38 170.03,76.89 174.22,76.89 175.06,76.05 180.15,76.05 186.39,69.81 v2(186.39,69.27)
  S5 w0.102: v3(97.92,94.03) 97.99,94.03 98.35,93.67 100.56,93.67 101.24,92.99 104.46,92.99 105.71,94.23 110.52,94.23 110.84,94.56 110.84,94.84 114.02,98.02 115.39,98.02 117.6,95.81 v2(118.29,95.81)
PCH_RSMRST_N: length 138.9
  TOP w0.114: R64.1 94.54,108.46 R72.2 95.2,108.51 v2(95.43,108.28) ; U12.C4 v3(191.09,60.61)
  S3 w0.102: v3(191.09,60.61) 190.7,60.99 190.7,63.2 189.15,64.75 189.15,69.69 171.37,87.47 171.37,96.72 166.04,102.06 162.86,102.06 161.66,103.25 149.81,103.25 146.94,106.12 138.84,106.12 138.28,106.68 122.79,106.68 121.12,105 114.5,105 110.69,108.81 107.55,108.81 103.69,112.67 97.02,112.67 94.95,110.6 94.95,108.76 v2(95.43,108.28)
  BOTTOM w0.114: v2(95.43,108.28) 95.2,108.51 R464.2 92.99,108.51 92.57,108.09 92.57,107.72 92.53,107.69 v1(92.53,107)
PCH_RSMRST_N_R: length 23.3
  TOP w0.114: v2(94.79,106.88) 94.59,107.09 R72.1 ; U9.AR7 97.4,88.91 v4(97.61,88.7)
  S10 w0.102: v4(97.61,88.7) 97.46,88.85 97.46,91.01 97.74,91.29 97.74,93.47 97.36,93.85 97.36,94.84 97.87,95.35 97.87,102.81 94.77,105.91 94.77,106.86 v2(94.79,106.88)
  BOTTOM w0.114: v1(96.6,106.68) 96.39,106.88 v2(94.79,106.88)
PCH_SERIRQ: length 328.3
  TOP w0.114: U9.BU14 v4(87.7,85.19) ; R28.1 83.33,111.82 v2(83.39,111.76)
  TOP w0.127: v2(175.16,23.14) U17.27
  S3 w0.102: v4(87.7,85.19) 87.7,84.18 88.08,83.8 88.08,83.17 87.81,82.9 87.81,82.31 88.19,81.94 88.19,81.51 88.78,80.92 88.78,80.61 89.07,80.32 89.07,79.74 88.81,79.48 88.81,78.97 89.07,78.71 89.07,78.07 88.59,77.59 88.59,77.09 88.11,76.61 88.11,76.33 87.81,76.03 87.81,75.59 88.17,75.23 97.71,75.23 99.16,73.79 100.31,73.79 102.14,71.96 102.14,71.18 102.11,71.15 102.11,69.57 102.79,68.88 102.79,68.38 102.74,68.33 102.74,65.1 104.11,63.74 104.11,63.2 104.48,62.83 104.48,62.6 104.95,62.13 110.06,62.13 111.67,60.52 111.67,59.98 112.95,58.7 112.95,52.3 v2(112.42,51.77) ; v2(126.88,17.61) 126.88,22.39 129.1,24.6 129.1,46.76 125.06,50.8 v2(124.16,50.8)
  S5 w0.102: v2(124.16,50.8) 124.16,51.26 120.55,54.86 117.5,54.86 114.4,51.77 v2(112.42,51.77)
  S8 w0.102: v2(126.88,17.61) 127.78,18.52 139.4,18.52 141.15,16.77 148.77,16.77 153.21,21.21 161.85,21.21 163.7,23.06 175.08,23.06 v2(175.16,23.14) ; v2(83.39,111.76) 83.39,110.56 85.82,108.13 88.44,108.13 89,107.57 91.41,107.57 92.58,108.74 95.68,108.74 96.14,108.28 97.57,108.28 97.84,108.55 97.84,109.88 96.72,111 96.72,112.79 93,116.51 91.25,116.51 90.36,117.4 79.06,117.4 79.03,117.43 79.02,117.43 78.42,118.03 76.07,118.03 75.72,117.68 67.12,117.68 66.92,117.47 51.61,117.47 47.85,113.72 37.83,113.72 28.74,104.63 28.17,104.63 15.65,92.11 15.65,80.33 v2(11.89,76.58)
  S10 w0.102: v2(83.39,111.76) 83.89,111.26 83.89,108.58 83.29,107.98 83.29,104.77 83.97,104.09 83.97,103.42 84.63,102.76 84.63,98.99 87.83,95.78 87.83,90.6 87.54,90.31 87.54,89.29 87.83,89 87.86,89 88.08,88.78 88.08,88.44 87.81,88.17 87.81,87.47 88.08,87.2 88.08,86.71 87.81,86.44 87.81,85.3 v4(87.7,85.19)
  BOTTOM w0.114: CONN14.8 v2(11.89,76.58) ; Q10.4 112.65,51.54 v2(112.42,51.77)
PCH_SLP_S3_N: length 304.4
  TOP w0.114: v2(183.49,51.18) 183.87,50.8 R221.1 ; R125.1 91.57,101.35 v2(91.54,101.37)
  S3 w0.102: v2(91.54,101.37) 90.98,101.37 87.93,104.42 87.49,104.42 86.89,105.02 86.89,105.19 86.09,105.99 84.93,105.99 83.52,107.4 83.52,108.79 83.89,109.17 83.89,110.19 82.88,111.2 82.88,112.25 82.4,112.74 82.27,112.74 80.62,114.38 80.62,115.27 78.59,117.3 69.76,117.3 68.76,118.3 68.76,118.68 70.52,120.45 106.02,120.45 106.73,119.74 108.12,119.74 108.18,119.68 113.58,119.68 114.39,120.5 139.91,120.5 145.27,115.14 149.48,115.14 150.2,114.43 160.85,114.43 164.07,111.21 164.08,111.22 165.17,111.22 165.57,110.83 167.99,110.83 169.67,109.14 170.69,109.14 v2(171.09,108.74)
  S5 w0.102: v2(171.09,108.74) 171.09,103.05 174.96,99.19 174.96,94.95 181.05,88.86 181.05,85.7 182.15,84.61 183.49,84.61 185.27,82.83 185.27,78.46 184.4,77.6 184.4,52.1 v2(183.49,51.18)
  S8 w0.102: v2(183.49,51.18) 184.18,50.5 184.18,49.53 179.35,44.7 170.87,44.7 166.67,40.51 137.67,40.51 132.14,34.98 124.21,34.98 123.7,34.47 100.89,34.47 99.9,35.46 v2(98.96,35.46)
  BOTTOM w0.114: R667.2 99.01,35.41 v2(98.96,35.46)
PCH_SLP_S3_N_R: length 9.9
  TOP w0.102: R125.2 91.57,98.37 94.67,95.27 94.67,91.43 U9.AY2
PCH_SLP_S3_R_N: length 6.4
  TOP w0.114: v2(183.49,49.89) R221.2 187.17,49.89 187.5,49.56 189.14,49.56 U12.P2
PCH_SLP_S4_N: length 142.3
  TOP w0.114: v2(191.13,68.07) 191.13,67.18 191.64,66.67 R182.1 ; R126.1 v2(92.91,101.6)
  S3 w0.102: v2(92.91,101.6) 92.46,102.06 92.46,103.9 92.16,104.2 92.16,108.02 92.84,108.7 92.84,110.8 93.29,111.26 93.29,111.83 94.74,113.28 98.46,113.28 99.18,114 103.01,114 107.74,109.27 110.88,109.27 114.69,105.46 120.93,105.46 122.63,107.16 133.96,107.16 135.33,108.53 139.65,108.53 140.18,108 146.94,108 147.47,108.53 147.76,108.53 149.19,107.11 150.32,107.11 153.72,103.71 161.85,103.71 163.02,102.54 166.2,102.54 171.83,96.91 171.83,87.75 183.16,76.43 184.83,76.43 191.13,70.12 v2(191.13,68.07)
  BOTTOM w0.114: v1(190.82,66.93) 190.82,67.76 v2(191.13,68.07)
PCH_SLP_S4_N_R: length 11.2
  TOP w0.114: R126.2 92.91,98.78 93.68,98.02 v2(95,98.02) 95.36,98.02 95.76,97.62 95.76,97.39 95.76,97.39 95.76,97 95.76,97 95.76,94.85 95.37,94.47 95.37,93.37 95.38,93.36 U9.AW1
  BOTTOM w0.114: v2(95,98.02) 94.56,98.02 v1(94.03,98.55)
PCH_SLP_S4_R_N: length 7.4
  TOP w0.114: R182.2 v2(191.64,64.64) ; U12.D6 v3(193.09,59.61)
  S3 w0.102: v3(193.09,59.61) 192.53,60.17 192.53,60.84 192.47,60.91 192.47,62.79 191.64,63.62 v2(191.64,64.64)
PCH_SYS_PWROK: length 173
  TOP w0.114: U12.E5 v3(192.09,58.61) ; v2(190.7,64.66) 190.75,64.71 R218.2 ; R18.2 v2(82.4,113.59) 81.62,113.59 80.91,114.3 80.91,117.81 84.25,121.15 112.67,121.15 114.25,119.56 114.74,119.56 114.74,119.55 119.06,119.55 119.07,119.56 119.81,119.56 v2(120.27,120.02)
  S10 w0.102: v2(120.27,120.02) 120.27,121.21 120.9,121.84 139.14,121.84 143.06,117.93 143.08,117.93 143.58,117.42 150.43,117.42 153.27,114.59 153.33,114.53 163.68,114.53 164.82,115.67 167.85,115.67 167.98,115.54 171.3,115.54 172.09,114.76 172.09,100.64 175.01,97.72 175.01,94.03 180.26,88.78 180.26,85.72 186.89,79.09 186.89,75.74 190.68,71.96 190.68,64.94 190.7,64.91 v2(190.7,64.66) 190.7,64.59 191.62,63.68 191.62,59.11 192.09,58.64 v3(192.09,58.61)
  BOTTOM w0.114: v1(119.63,119.13) 119.63,119.38 v2(120.27,120.02) ; v2(82.4,113.59) R18.2
PCH_SYS_PWROK_R: length 29.5
  TOP w0.114: v4(87.92,89.45) 88.17,89.45 U9.BP5 ; v2(84.23,114.05) 83.9,114.38 R18.1
  S10 w0.102: v4(87.92,89.45) 87.92,89.95 88.04,90.07 88.04,95.91 84.86,99.08 84.86,102.86 84.43,103.29 84.43,105.19 83.52,106.11 83.52,107.87 84.23,108.58 v2(84.23,114.05)
  BOTTOM w0.114: v1(84.39,113.13) 84.39,113.89 v2(84.23,114.05)
PCH_SYSRESET_N: length 200
  TOP w0.114: v2(80.27,105.57) R85.1 R105.2 ; R195.1 v2(203.58,67.44)
  S3 w0.102: v2(203.58,67.44) 203.58,67.8 202.05,69.33 202.05,78.37 201.39,79.04 200.55,79.87 200.55,87.36 199.55,88.36 199.55,98.89 195.3,103.14 176.66,103.14 172.59,107.2 172.59,108.94 169.88,111.66 165.71,111.66 165.35,112.01 164.25,112.01 161.15,115.11 150.48,115.11 149.77,115.82 145.55,115.82 140.19,121.18 69.23,121.18 67.94,119.9 67.94,118.03 71.18,114.79 71.18,114.48 71.67,114 72.19,114 72.52,114.33 73.95,114.33 75.54,112.74 75.54,112.3 76.23,111.61 76.43,111.61 78.87,109.17 78.87,106.97 v2(80.27,105.57)
PCH_SYSRESET_N_R: length 5.3
  TOP w0.114: U12.B16 204.59,62.12 204.59,62.87 203.58,63.89 v2(203.58,64.64) R195.2
PCH_SYSRESET_R_N: length 20.1
  TOP w0.102: 89.93,90.72 89.58,91.07 89.58,91.34 89.93,91.69 89.93,92.5 89.8,92.62
  TOP w0.114: 89.8,92.62 89.8,93.38 89.53,93.65 89.53,94.49 89.4,94.63 89.4,95.31 85.49,99.21 84.24,99.21 82.1,101.35 80.7,101.35 v2(79.55,102.49) R105.1 ; U9.BL4 89.93,90.72
  BOTTOM w0.114: v2(79.55,102.49) 79.55,101.7 v1(79.65,101.6)
PCH_THERMTRIP_N: length 160.6
  TOP w0.114: v2(68.25,108.36) 68.38,108.23 R69.2 ; v2(171.15,78.88) 179.16,78.88 181.86,76.18 181.86,67.19 181.75,67.09 181.19,67.09 180.55,66.45 176.96,66.45 176.7,66.19 U13.15
  S3 w0.102: v2(117.42,97.54) 117.97,96.99 120.59,96.99 121.85,95.73 129.9,95.73 130.74,94.89 133.35,94.89 134.81,96.35 156.1,96.35 157.23,97.49 161.77,97.49 162.71,96.55 165.94,96.55 168.58,93.9 168.58,88.98 166.7,87.1 166.7,81.41 169.23,78.88 v2(171.15,78.88)
  BOTTOM w0.114: v2(117.42,97.54) 115.57,97.54 114.15,96.11 112.8,96.11 109.25,92.56 106.2,92.56 105.79,92.15 105.08,92.15 103.89,93.34 102.49,93.34 101.98,92.84 100.46,92.84 100.25,93.05 100.25,93.13 99.81,93.57 99.1,93.57 98.93,93.4 97.66,93.4 97.21,93.85 97.21,94.09 96.17,95.14 91.21,95.14 86.36,99.99 76.59,99.99 69.09,107.49 R69.2 68.38,108.23 v2(68.25,108.36)
PCH_THERMTRIP_N_R: length 40.2
  TOP w0.114: R69.1 70.74,108.23 v2(71.09,107.87) ; U9.BJ16 v4(91.17,84.33)
  S3 w0.102: v2(71.09,107.87) 71.09,106.39 76.77,100.71 80.56,100.71 82.93,98.34 85.48,98.34 85.68,98.14 85.87,97.95 86.57,97.26 86.89,96.93 89.62,94.21 90.6,94.21 91.59,93.22 91.59,90.12 91.06,89.59 91.06,88.27 90.78,87.99 90.78,87.6 91.06,87.33 91.06,86.56 90.78,86.28 90.78,85.67 91.06,85.39 91.06,84.44 v4(91.17,84.33)
  BOTTOM w0.114: v2(71.09,107.87) 71.63,107.34 v1(71.63,106.76)
PCH_WAKE_N: length 147.9
  TOP w0.114: v2(90.45,106.76) 91.49,105.71 R110.2 ; Q2.D 60.65,109.92 v2(60.65,110.16)
  S10 w0.102: v2(167.33,112.65) 167.31,112.65 166.85,113.11 164.72,113.11 163.25,111.63 151.79,111.63 150.04,113.39 133.17,113.39 v2(133.15,113.36)
  BOTTOM w0.114: v2(133.15,113.36) 132.66,112.88 128.65,112.88 127.13,111.35 127.13,108.64 125.68,107.19 122.68,107.19 117.47,101.98 111.82,101.98 110.87,101.03 108.65,101.03 107.88,100.26 107.88,99.61 106.74,98.47 104.33,98.47 104.27,98.42 103.58,98.42 103.09,98.91 102.61,98.91 102.03,99.49 102.03,103.78 100.91,104.9 98.68,104.9 98.4,105.18 97.05,105.18 96.62,104.75 94.51,104.75 93.17,106.1 91.11,106.1 v2(90.45,106.76) 90.07,106.76 88.82,108.01 86,108.01 85.79,108.22 81.31,108.22 80.58,107.49 80.07,107.49 78.99,108.56 78.38,108.56 77.72,109.22 77.72,111.12 77.34,111.51 76.4,111.51 76.15,111.76 76.15,112.63 76.42,112.9 76.78,112.9 77.07,113.2 77.07,113.58 77.06,113.6 77.06,115.42 77.22,115.58 v1(77.22,118.02) 73.05,118.02 71.96,119.11 69.04,119.11 67.36,117.44 65.96,117.44 65.51,116.98 65.51,115.58 64.13,114.21 63.82,114.21 62.87,113.26 62.87,111.05 61.98,110.16 v2(60.65,110.16) 60.65,110.16 R447.2 ; R803.2 v2(167.33,112.65)
PCH_WAKE_N_R: length 14.7
  TOP w0.114: U9.BA1 94.39,95.21 91,98.6 91,101.84 v2(91.49,102.34) R110.1
  BOTTOM w0.114: v1(92.25,100.69) 92.25,101.57 v2(91.49,102.34)
PCH_WAKE_R_N: length 2.8
  TOP w0.114: U38.3 166.45,112.19 v2(165.99,112.65)
  BOTTOM w0.114: R803.1 166.42,112.21 v2(165.99,112.65)
PCH_XDP_NCLK1: length 61.3
  TOP w0.114: v2(82.04,104.44) 82.3,104.19 R114.1 ; v2(33.93,115.54) 33.63,115.85 32.72,115.85 32.32,115.44 CONN4.4
  S10 w0.102: v2(82.04,104.44) 81.23,105.26 81.23,107.76 77.1,111.89 76.52,111.89 75.99,112.41 75.99,113.06 74.4,114.66 74.4,115.78 73.39,116.79 52.41,116.79 51.9,116.28 38.78,116.28 38.7,116.2 38.23,116.2 38.01,115.98 37.86,115.83 36.51,115.83 36.34,115.94 36.18,116.01 36.08,116.11 34.5,116.11 v2(33.93,115.54)
  BOTTOM w0.114: v1(34.19,116.43) 34.19,115.8 v2(33.93,115.54)
PCIE2_MGMT_MAC_C_TX0_N: length 13.4
  TOP w0.127: C57.1 120.93,88.67 v3(120.9,88.64) ; v4(109.98,87.78) 109.76,87.78 U9.J9
  BOTTOM w0.127: v3(120.9,88.64) 120.4,88.14 120.09,88.14 119.16,88.36 118.28,88.73 114.2,89.71 112.11,89.21 110.76,88.38 110.16,87.78 v4(109.98,87.78)
PCIE2_MGMT_MAC_C_TX0_P: length 13.4
  TOP w0.127: v3(120.9,87.37) 120.92,87.35 C60.1 ; U9.F9 110.39,87.96 110.39,87.65 v4(110.64,87.4)
  BOTTOM w0.127: v4(110.64,87.4) 110.53,87.52 110.53,87.77 110.92,88.17 112.21,88.96 114.2,89.44 118.17,88.48 119.08,88.11 120.06,87.87 120.4,87.87 v3(120.9,87.37)
PCIE2_MGMT_MAC_RX0_N: length 23.5
  TOP w0.127: U9.D15 112.22,85.27 112.56,85.62 113.14,85.62 113.4,85.36 114.92,85.36 116.69,87.12 118.63,88.31 119.3,89.41 119.96,89.81 121.36,90.15 122.98,89.76 129.33,91.29 131.45,90.78 132.08,90.78 C644.2
PCIE2_MGMT_MAC_RX0_N_R: length 3.1
  TOP w0.127: C644.1 134.06,90.83 134.82,90.83 134.9,90.91 135.99,90.91 136.11,91.02 U6.20
PCIE2_MGMT_MAC_RX0_P: length 23.5
  TOP w0.127: C643.2 132.15,90.51 131.42,90.51 129.33,91.01 122.98,89.49 121.36,89.88 120.07,89.56 119.5,89.21 118.82,88.12 116.85,86.91 116.48,86.54 116.48,86.36 116.54,86.31 116.54,86.18 116.31,85.95 116.2,85.95 116.13,86.03 115.97,86.03 115.66,85.71 115.66,85.61 115.73,85.54 115.73,85.36 115.52,85.14 115.39,85.14 115.32,85.22 115.16,85.22 115.03,85.09 114.63,85.09 114.5,84.96 114.5,84.86 114.41,84.77 114.01,84.77 113.92,84.86 113.92,84.94 113.77,85.09 113.29,85.09 113.02,85.35 112.78,85.35 U9.B15
PCIE2_MGMT_MAC_RX0_P_R: length 3.1
  TOP w0.127: U6.21 136.05,90.52 135.93,90.64 135.01,90.64 134.93,90.56 134.1,90.56 C643.1
PCIE2_MGMT_MAC_TX0_N: length 15.2
  TOP w0.127: U6.23 136.18,89.52 136.08,89.42 135.96,89.42 v3(135.37,90.02) ; v3(125.45,88.64) 124.95,88.14 123.28,88.14 C57.2
  S10 w0.102: v3(125.45,88.64) 125.93,88.16 126.33,88.16 128.14,89.27 129.89,89.69 131.22,89.38 132.45,89.08 134.24,89.51 134.86,89.51 v3(135.37,90.02)
PCIE2_MGMT_MAC_TX0_P: length 15.2
  TOP w0.127: C60.2 123.28,87.88 124.95,87.88 v3(125.45,87.37) ; v3(135.37,88.75) 135.77,89.15 135.97,89.15 136.1,89.02 U6.24
  S10 w0.102: v3(135.37,88.75) 134.81,89.31 134.27,89.31 132.45,88.87 129.89,89.49 129.05,89.28 128.22,89.08 126.38,87.96 126.04,87.96 v3(125.45,87.37)
PCIE3_100G_C_TX_DN_0: length 98.2
  TOP w0.127: U9.D30 112.2,78.34 112.85,78.99 113.03,78.99 113.28,79.25 117.48,79.25 v3(117.98,79.75)
  S3 w0.102: v3(146.99,14.99) 146.56,14.99 146.45,14.88 146.45,14.37 146.21,14.12 145.28,14.12 135.38,24.02 135.38,62.96 129.46,68.88 125.04,68.88 123.87,70.05 121.84,70.05 119,72.9 116.86,72.9 115.19,74.57 115.19,77.85 116.55,79.22 117.88,79.22 117.98,79.32 v3(117.98,79.75)
  BOTTOM w0.127: v3(146.99,14.99) 146.49,14.48 146.49,11.75 C620.1
PCIE3_100G_C_TX_DN_1: length 101.5
  TOP w0.127: v3(119.76,77.97) 119.26,77.47 114.55,77.47 113.79,78.23 113.28,78.23 113.03,77.98 112.34,77.98 U9.C31
  S3 w0.102: v3(119.76,77.97) 119.76,77.54 119.86,77.44 120.53,77.44 121.23,76.73 121.23,73.84 123.01,72.06 124.64,72.06 125.4,71.3 132.92,71.3 137.11,67.11 137.11,26.4 140.55,22.96 147.85,22.96 150.04,20.78 150.04,12.29 149.07,11.33 148.56,11.33 148.25,11.63 148.25,12.04 v3(147.72,12.57)
  BOTTOM w0.127: C621.1 148.22,11.75 148.22,12.07 v3(147.72,12.57)
PCIE3_100G_C_TX_DN_2: length 94
  TOP w0.127: U9.D32 112.2,77.35 112.57,77.72 113.04,77.72 113.28,77.48 113.67,77.48 115.34,75.82 115.7,75.82 v3(116.2,76.32)
  S3 w0.102: v3(148.2,17.32) 147.67,17.86 147.67,20.5 146.66,21.51 140.46,21.51 136.35,25.63 136.35,66.12 132,70.46 124.83,70.46 123.99,71.3 123.16,71.3 122.7,71.3 120,73.99 119.67,73.99 119.15,73.99 117.36,75.79 116.31,75.79 116.2,75.89 v3(116.2,76.32)
  BOTTOM w0.127: C247.1 151.64,14.8 151.64,15.21 151.2,15.65 148.59,15.65 147.7,16.54 147.7,16.82 v3(148.2,17.32)
PCIE3_100G_C_TX_DN_3: length 98.8
  TOP w0.127: U9.C34 112.73,76.86 112.96,76.63 113.18,76.63 113.25,76.56 116.19,73.62 122.39,73.62 122.81,73.2 v3(122.81,73.14)
  S3 w0.102: v3(153.72,12.7) 154.15,12.7 154.25,12.8 154.25,17.55 148.02,23.77 140.53,23.77 137.67,26.64 137.67,68.72 133.82,72.57 125.03,72.57 123.91,73.69 123.35,73.69 123.25,73.58 123.25,73.58 v3(122.81,73.14)
  BOTTOM w0.127: v3(153.72,12.7) 154.22,12.2 154.22,11.88 C623.1
PCIE3_100G_C_TX_DP_0: length 98.3
  TOP w0.127: U9.B30 112.85,78.48 113.58,78.48 114.08,78.98 117.48,78.98 v3(117.98,78.48)
  S3 w0.102: v3(145.72,14.99) 146.15,14.99 146.25,14.88 146.25,14.45 146.13,14.33 145.36,14.33 144.85,14.84 144.85,15.1 144.68,15.26 144.43,15.26 144.27,15.42 144.27,15.68 144.11,15.84 143.85,15.84 143.69,16 143.69,16.25 143.53,16.41 143.28,16.41 143.11,16.58 143.11,16.83 142.95,16.99 142.7,16.99 142.54,17.15 142.54,17.41 142.38,17.57 142.12,17.57 141.96,17.73 141.96,17.98 141.8,18.15 141.54,18.15 141.38,18.31 141.38,18.56 141.22,18.72 140.97,18.72 140.81,18.88 140.81,19.14 140.64,19.3 140.39,19.3 140.23,19.46 140.23,19.71 140.07,19.88 139.81,19.88 139.65,20.04 139.65,20.29 139.49,20.45 139.24,20.45 139.07,20.62 139.07,20.87 138.91,21.03 138.66,21.03 138.08,21.61 138.08,21.75 138.08,21.89 137.92,22.05 137.78,22.05 137.64,22.05 137.48,22.21 137.48,22.35 137.48,22.35 137.48,22.49 137.32,22.65 137.18,22.65 137.04,22.65 136.87,22.82 136.87,22.95 136.87,22.96 136.87,23.09 136.71,23.26 136.57,23.26 136.43,23.26 135.59,24.1 135.59,63.04 129.54,69.09 125.12,69.09 123.95,70.26 121.93,70.26 119.08,73.1 116.94,73.1 115.39,74.65 115.39,77.77 116.64,79.01 117.88,79.01 117.98,78.91 v3(117.98,78.48)
  BOTTOM w0.127: v3(145.72,14.99) 146.22,14.48 146.22,11.75 C619.1
PCIE3_100G_C_TX_DP_1: length 101.6
  TOP w0.127: U9.A31 113.8,77.85 114.44,77.2 119.26,77.2 v3(119.76,76.7)
  S3 w0.102: v3(119.76,76.7) 119.76,77.13 119.86,77.23 120.45,77.23 121.03,76.65 121.03,73.75 122.93,71.86 124.55,71.86 125.32,71.09 132.83,71.09 136.91,67.02 136.91,26.32 140.47,22.76 140.78,22.76 140.98,22.56 141.21,22.56 141.41,22.76 141.64,22.76 141.84,22.56 142.07,22.56 142.27,22.76 142.5,22.76 142.71,22.56 142.94,22.56 143.14,22.76 143.37,22.76 143.57,22.56 143.8,22.56 144,22.76 144.23,22.76 144.43,22.56 144.66,22.56 144.87,22.76 145.09,22.76 145.3,22.56 145.53,22.56 145.73,22.76 145.96,22.76 146.16,22.56 146.39,22.56 146.59,22.76 146.82,22.76 147.02,22.56 147.25,22.56 147.46,22.76 147.77,22.76 149.83,20.69 149.83,20.22 149.66,20.04 149.66,19.81 149.83,19.64 149.83,19.41 149.66,19.23 149.66,19 149.83,18.82 149.83,18.59 149.66,18.42 149.66,18.19 149.83,18.01 149.83,17.78 149.66,17.6 149.66,17.38 149.83,17.2 149.83,16.97 149.66,16.79 149.66,16.56 149.83,16.38 149.83,16.16 149.66,15.98 149.66,15.75 149.83,15.57 149.83,15.34 149.66,15.17 149.66,14.94 149.83,14.76 149.83,14.53 149.66,14.35 149.66,14.12 149.83,13.95 149.83,12.38 148.99,11.53 148.64,11.53 148.45,11.72 148.45,12.04 v3(148.99,12.57)
  BOTTOM w0.127: v3(148.99,12.57) 148.49,12.07 148.49,11.75 C622.1
PCIE3_100G_C_TX_DP_2: length 94
  TOP w0.127: U9.B32 113.02,77.35 113.16,77.21 113.56,77.21 115.23,75.55 115.7,75.55 v3(116.2,75.05)
  S3 w0.102: v3(116.2,75.05) 116.2,75.48 116.31,75.58 117.27,75.58 119.07,73.79 119.75,73.79 119.75,73.79 119.92,73.79 122.61,71.09 123.24,71.09 123.91,71.09 124.75,70.26 131.92,70.26 136.14,66.03 136.14,25.54 140.38,21.31 140.69,21.31 140.86,21.13 141.09,21.13 141.27,21.31 141.5,21.31 141.68,21.13 141.91,21.13 142.08,21.31 142.31,21.31 142.49,21.13 142.72,21.13 142.9,21.31 143.12,21.31 143.3,21.13 143.53,21.13 143.71,21.31 143.94,21.31 144.12,21.13 144.34,21.13 144.52,21.31 144.75,21.31 144.93,21.13 145.16,21.13 145.33,21.31 145.56,21.31 145.74,21.13 145.97,21.13 146.15,21.31 146.58,21.31 146.81,21.07 146.81,20.88 146.97,20.72 147.17,20.72 147.47,20.42 147.47,20.1 147.32,19.96 147.32,19.73 147.47,19.58 147.47,19.36 147.32,19.21 147.32,18.98 147.47,18.83 147.47,18.61 147.32,18.46 147.32,18.23 147.47,18.09 147.47,17.86 v3(146.93,17.32)
  BOTTOM w0.127: v3(146.93,17.32) 147.43,16.82 147.43,16.42 148.48,15.38 151.09,15.38 151.38,15.09 151.38,14.8 C246.1
PCIE3_100G_C_TX_DP_3: length 98.8
  TOP w0.127: U9.A34 113.44,76.75 116.3,73.89 122.3,73.89 122.81,74.4 v3(122.81,74.41)
  S3 w0.102: v3(122.81,74.41) 123.34,73.89 124,73.89 125.11,72.77 133.91,72.77 137.87,68.81 137.87,26.72 140.61,23.98 148.11,23.98 153.25,18.83 153.43,18.83 153.59,18.67 153.59,18.49 153.76,18.33 153.93,18.33 154.09,18.17 154.09,17.99 154.45,17.63 154.45,17.24 154.64,17.06 154.64,16.83 154.45,16.65 154.45,16.42 154.64,16.24 154.64,16.01 154.45,15.83 154.45,15.6 154.64,15.42 154.64,15.19 154.45,15.01 154.45,14.78 154.64,14.6 154.64,14.37 154.45,14.19 154.45,13.96 154.64,13.78 154.64,13.55 154.45,13.37 154.45,12.8 154.56,12.7 v3(154.99,12.7)
  BOTTOM w0.127: v3(154.99,12.7) 154.49,12.2 154.49,11.88 C624.1
PCIE3_100G_RX_DN_0: length 101.8
  TOP w0.127: U9.J24 v4(109,80.9)
  S3 w0.102: v4(109,80.9) 109.39,81.29 109.39,81.63 109.75,81.99 113.53,81.99 114.64,80.88 114.64,73.7 116.2,72.14 117.96,72.14 120.98,69.11 123.45,69.11 134.82,57.74 134.82,23.52 146.48,11.86 146.48,10.22 146.95,9.75 150.03,9.75 150.24,9.96 150.24,10.29 150.11,10.41 v3(149.72,10.41)
  BOTTOM w0.127: v3(149.72,10.41) 150.22,9.91 150.22,8.92 150.1,8.8 CONN16.35
PCIE3_100G_RX_DN_1: length 104.2
  TOP w0.127: U9.K26 v4(108.5,80.04)
  S3 w0.102: v3(151.72,9.65) 152.25,9.12 152.25,8.88 151.93,8.56 142.6,8.56 140.03,11.13 140.03,16.26 134.06,22.23 134.06,57.2 123.32,67.94 120.45,67.94 117.58,70.82 116.18,70.82 113.41,73.58 113.41,78.36 111.38,80.39 110.21,80.39 110.16,80.45 109.32,80.45 108.92,80.04 v4(108.5,80.04)
  BOTTOM w0.127: v3(151.72,9.65) 152.22,9.15 152.22,8.92 152.1,8.8 CONN16.27
PCIE3_100G_RX_DN_2: length 120.6
  TOP w0.127: v4(109,79.18) 109.28,79.47 U9.J28
  S3 w0.102: v4(109,79.18) 109.39,79.18 109.8,78.77 111.7,78.77 112.32,78.15 112.32,73.22 116.3,69.24 117.72,69.24 121.01,65.96 121.01,63.02 122.43,61.59 125.37,61.59 133.1,53.87 133.1,20.64 138.3,15.44 138.3,9.01 140.12,7.19 156.16,7.19 157.45,5.89 157.45,3.8 156.2,2.54 153.85,2.54 152.45,3.93 152.45,4.7 v3(153.08,5.33)
  BOTTOM w0.127: CONN16.26 152.6,3.37 152.49,3.49 152.49,4.73 v3(153.08,5.33)
PCIE3_100G_RX_DN_3: length 114.6
  TOP w0.127: U9.K30 v4(108.5,78.32)
  S3 w0.102: v4(108.5,78.32) 108.82,78.32 109.22,77.93 110.89,77.93 111.38,77.44 111.38,72.99 116.73,67.64 117.62,67.64 119.99,65.27 119.99,62.15 123.05,59.08 126.59,59.08 132.33,53.34 132.33,19.45 137.11,14.67 137.11,8.59 139.7,5.99 155.67,5.99 156.64,5.02 156.64,4.06 155.88,3.3 154.77,3.3 154.45,3.62 154.45,4.16 v3(154.99,4.69)
  BOTTOM w0.127: v3(154.99,4.69) 154.49,4.19 154.49,3.49 154.6,3.37 CONN16.18
PCIE3_100G_RX_DP_0: length 101.9
  TOP w0.127: U9.F24 v4(109.99,80.9)
  S3 w0.102: v3(150.99,10.41) 150.52,10.41 150.44,10.34 150.44,9.88 150.11,9.55 146.86,9.55 146.28,10.13 146.28,11.78 134.62,23.44 134.62,57.66 123.37,68.91 120.9,68.91 117.87,71.93 116.12,71.93 114.44,73.61 114.44,80.8 113.45,81.79 109.84,81.79 109.59,81.55 109.59,81.29 v4(109.99,80.9)
  BOTTOM w0.127: v3(150.99,10.41) 150.49,9.91 150.49,8.92 150.6,8.8 CONN16.33
PCIE3_100G_RX_DP_1: length 104.2
  TOP w0.127: U9.H26 v4(109.49,80.04)
  S3 w0.102: v3(152.99,9.65) 152.45,9.12 152.45,8.79 152.02,8.36 151.25,8.36 151.12,8.23 150.89,8.23 150.76,8.36 150.53,8.36 150.41,8.23 150.18,8.23 150.05,8.36 149.82,8.36 149.7,8.23 149.47,8.23 149.34,8.36 149.11,8.36 148.99,8.23 148.76,8.23 148.63,8.36 148.4,8.36 148.27,8.23 148.05,8.23 147.92,8.36 147.69,8.36 147.56,8.23 147.33,8.23 147.21,8.36 146.98,8.36 146.85,8.23 146.62,8.23 146.5,8.36 146.27,8.36 146.14,8.23 145.91,8.23 145.78,8.36 142.51,8.36 139.83,11.04 139.83,16.17 133.86,22.14 133.86,57.12 123.23,67.74 120.36,67.74 117.49,70.61 116.09,70.61 113.21,73.5 113.21,78.27 111.29,80.19 110.36,80.19 110.22,80.04 v4(109.49,80.04)
  BOTTOM w0.127: v3(152.99,9.65) 152.49,9.15 152.49,8.92 152.6,8.8 CONN16.25
PCIE3_100G_RX_DP_2: length 120.6
  TOP w0.127: v4(109.99,79.18) 110.28,79.47 U9.F28
  S3 w0.102: v3(151.72,5.33) 152.25,4.79 152.25,3.85 152.52,3.58 152.52,3.39 152.68,3.23 152.87,3.23 153.76,2.34 156.28,2.34 157.66,3.71 157.66,5.98 156.24,7.39 140.21,7.39 138.51,9.09 138.51,15.52 133.3,20.73 133.3,53.95 125.45,61.8 122.51,61.8 121.21,63.1 121.21,66.04 117.81,69.44 116.38,69.44 112.52,73.3 112.52,78.23 111.79,78.97 110.2,78.97 v4(109.99,79.18)
  BOTTOM w0.127: CONN16.28 152.1,3.37 152.22,3.49 152.22,4.83 v3(151.72,5.33)
PCIE3_100G_RX_DP_3: length 114.6
  TOP w0.127: U9.H30 v4(109.49,78.32)
  S3 w0.102: v3(153.72,4.69) 154.25,4.16 154.25,3.53 154.69,3.1 155.96,3.1 156.84,3.98 156.84,5.11 155.75,6.2 139.78,6.2 137.31,8.67 137.31,14.76 132.54,19.53 132.54,53.42 126.68,59.28 123.14,59.28 120.19,62.23 120.19,65.35 117.7,67.84 116.81,67.84 111.58,73.08 111.58,77.52 110.97,78.13 109.69,78.13 v4(109.49,78.32)
  BOTTOM w0.127: v3(153.72,4.69) 154.22,4.19 154.22,3.49 154.1,3.37 CONN16.20
PCIE3_100G_TX_DN_0: length 3.2
  BOTTOM w0.127: CONN16.49 146.6,8.8 146.49,8.92 146.49,10.09 C620.2
PCIE3_100G_TX_DN_1: length 3.2
  BOTTOM w0.127: C621.2 148.22,10.09 148.22,8.92 148.1,8.8 CONN16.43
PCIE3_100G_TX_DN_2: length 16.5
  TOP w0.127: v3(150.99,4.7) 150.49,5.2 150.49,9.43 150.09,9.83 149.17,9.83 148.79,10.21 148.79,10.82 149.11,11.14 151.24,11.14 151.56,11.46 151.56,11.91 151.71,12.06 v3(152.15,12.06)
  BOTTOM w0.127: C247.2 151.65,13.15 151.65,12.31 151.89,12.06 v3(152.15,12.06) ; CONN16.34 150.6,3.37 150.49,3.49 150.49,4.2 v3(150.99,4.7)
PCIE3_100G_TX_DN_3: length 3.3
  BOTTOM w0.127: CONN16.19 154.1,8.8 154.22,8.92 154.22,9.97 C623.2
PCIE3_100G_TX_DP_0: length 3.2
  BOTTOM w0.127: CONN16.51 146.1,8.8 146.22,8.92 146.22,10.09 C619.2
PCIE3_100G_TX_DP_1: length 3.2
  BOTTOM w0.127: CONN16.41 148.6,8.8 148.49,8.92 148.49,10.09 C622.2
PCIE3_100G_TX_DP_2: length 16.4
  TOP w0.127: v3(149.72,4.7) 150.22,5.2 150.22,9.32 149.98,9.56 149.06,9.56 148.53,10.1 148.53,10.93 149,11.4 150.08,11.4 150.24,11.56 150.49,11.56 150.64,11.4 151.13,11.4 151.3,11.57 151.3,11.87 151.1,12.06 v3(150.88,12.06)
  BOTTOM w0.127: C246.2 151.38,13.13 151.38,12.32 151.13,12.06 v3(150.88,12.06) ; CONN16.36 150.1,3.37 150.22,3.49 150.22,4.2 v3(149.72,4.7)
PCIE3_100G_TX_DP_3: length 3.3
  BOTTOM w0.127: CONN16.17 154.6,8.8 154.49,8.92 154.49,9.97 C624.2
PCIE_BMM_RX_N: length 190.7
  TOP w0.127: v3(115.49,90.95) 115.99,90.45 115.99,90.2 115.33,89.55 114.57,89.55 112.77,87.75 U9.C9
  S10 w0.102: v3(115.49,90.95) 115.92,90.95 116.02,91.05 116.02,91.82 115.43,92.41 114.02,92.41 113.36,93.07 113.36,102.18 114.02,102.84 114.02,109.12 113.59,109.55 112.75,109.55 111.25,111.05 108.53,111.05 103.99,115.6 103.99,118.71 100.75,121.95 38.35,121.95 37.31,120.9 13.69,120.9 10.26,117.47 10.26,90.83 20.22,80.87 24.46,80.87 24.92,80.42 24.92,78.27 24.29,77.65 23.65,77.65 23.57,77.57 23.47,77.57 v3(23.34,77.44)
  BOTTOM w0.127: CONN14.5 23.31,77.48 v3(23.34,77.44)
PCIE_BMM_RX_P: length 190.7
  TOP w0.127: U9.A9 113.31,87.88 113.31,87.91 114.68,89.28 115.44,89.28 116.26,90.09 116.26,90.45 v3(116.76,90.95)
  S10 w0.102: v3(23.34,78.13) 23.47,78 23.57,78 23.73,77.85 24.21,77.85 24.71,78.36 24.71,78.59 24.59,78.72 24.59,78.94 24.71,79.07 24.71,79.3 24.59,79.43 24.59,79.65 24.71,79.78 24.71,80.33 24.38,80.67 20.14,80.67 10.06,90.75 10.06,117.56 13.61,121.11 37.23,121.11 38.27,122.15 100.84,122.15 104.19,118.8 104.19,115.68 108.62,111.25 111.34,111.25 112.83,109.75 113.67,109.75 114.22,109.2 114.22,102.76 113.56,102.1 113.56,93.15 114.1,92.61 115.52,92.61 116.22,91.9 116.22,91.05 116.33,90.95 v3(116.76,90.95)
  BOTTOM w0.127: CONN14.3 23.29,78.08 v3(23.34,78.13)
PCIE_BMM_TX_C_N: length 208.4
  TOP w0.127: U9.R16 v4(107.02,84.33)
  S10 w0.102: v3(26.4,75.35) 26.4,75.78 26.3,75.88 25.66,75.88 25.25,76.29 25.25,77.12 26.21,78.09 26.21,81.55 25.67,82.09 19.75,82.09 11.05,90.8 11.05,117.14 14.22,120.32 38.43,120.32 39.57,121.46 98.86,121.46 103.02,117.3 103.02,114.73 107.9,109.86 110.24,109.86 111.81,108.28 111.81,106.02 111.25,105.46 111.25,102.32 112.19,101.38 112.19,95.5 111.35,94.67 111.35,90.63 110.67,89.94 108.46,89.94 107.44,90.96 107.44,92.27 106.57,93.14 102.42,93.14 102.01,92.73 102.01,91.08 102.39,90.7 103.45,90.7 108.94,85.22 108.94,84.2 108.69,83.95 107.4,83.95 v4(107.02,84.33)
  BOTTOM w0.127: C354.1 v3(26.4,75.35)
PCIE_BMM_TX_C_P: length 208.4
  TOP w0.114: U9.N16 v4(108.01,84.33)
  S10 w0.102: v4(108.01,84.33) 108.19,84.15 108.6,84.15 108.74,84.29 108.74,85.13 103.37,90.5 102.3,90.5 101.8,91 101.8,92.81 102.34,93.34 106.65,93.34 107.65,92.35 107.65,91.04 108.54,90.14 110.58,90.14 111.15,90.71 111.15,94.75 111.99,95.59 111.99,101.3 111.05,102.23 111.05,105.55 111.61,106.1 111.61,108.2 110.15,109.65 107.81,109.65 102.82,114.65 102.82,117.21 98.77,121.26 39.66,121.26 38.51,120.12 14.31,120.12 11.25,117.06 11.25,90.88 16.36,85.77 16.59,85.77 16.75,85.61 16.75,85.38 16.92,85.22 17.14,85.22 17.31,85.06 17.31,84.83 17.47,84.67 17.7,84.67 17.86,84.5 17.86,84.28 18.02,84.12 18.25,84.12 18.41,83.95 18.41,83.73 18.57,83.56 18.8,83.56 18.96,83.4 18.96,83.17 19.12,83.01 19.35,83.01 19.51,82.85 19.51,82.62 19.84,82.3 20.21,82.3 20.44,82.52 20.67,82.52 20.9,82.3 21.13,82.3 21.36,82.52 21.58,82.52 21.81,82.3 22.04,82.3 22.27,82.52 22.5,82.52 22.73,82.3 22.96,82.3 23.18,82.52 23.41,82.52 23.64,82.3 23.87,82.3 24.1,82.52 24.33,82.52 24.56,82.3 24.78,82.3 25.01,82.52 25.24,82.52 25.47,82.3 25.76,82.3 26.42,81.64 26.42,81.05 26.57,80.9 26.57,80.67 26.42,80.52 26.42,80.29 26.57,80.14 26.57,79.91 26.42,79.76 26.42,79.53 26.57,79.38 26.57,79.15 26.42,78.99 26.42,78.77 26.57,78.61 26.57,78.38 26.42,78.23 26.42,78 25.45,77.04 25.45,76.38 25.75,76.08 26.3,76.08 26.4,76.18 v3(26.4,76.62)
  BOTTOM w0.127: C340.1 v3(26.4,76.62)
PCIE_BMM_TX_N: length 3.4
  BOTTOM w0.127: C354.2 24.24,75.85 22.99,75.85 22.82,75.68 CONN14.11
PCIE_BMM_TX_P: length 3.4
  BOTTOM w0.127: CONN14.9 22.82,76.28 22.99,76.11 24.24,76.11 C340.2
PCIE_CLK_BMM_N: length 177.6
  TOP w0.127: R144.1 v3(106.76,96.78)
  S10 w0.102: v3(106.76,96.78) 107.14,97.15 107.14,98.05 107.34,98.25 107.34,98.39 107.28,98.45 107.28,98.6 107.57,98.88 107.72,98.88 107.77,98.83 107.92,98.83 108.18,99.09 108.18,106.25 104.67,109.75 103.91,109.75 102.9,110.77 102.9,111.53 98.65,115.77 98.65,116.84 95.61,119.89 52.88,119.89 51.54,118.54 15.85,118.54 13.06,115.74 13.06,91.73 20.02,84.76 27.24,84.76 28.88,83.12 28.88,72.94 27.97,72.03 27.56,72.03 27.46,71.93 v3(27.46,71.49)
  BOTTOM w0.127: CONN14.17 22.82,73.88 22.99,74.05 23.77,74.05 25.82,72 26.96,72 v3(27.46,71.49)
PCIE_CLK_BMM_P: length 177.6
  TOP w0.127: R145.1 v3(107.72,96.78)
  S10 w0.102: v3(27.46,72.76) 27.46,72.33 27.56,72.23 27.88,72.23 28.68,73.03 28.68,83.03 27.15,84.56 19.94,84.56 12.85,91.64 12.85,115.83 15.77,118.75 51.45,118.75 52.8,120.09 95.69,120.09 98.86,116.92 98.86,115.86 103.1,111.62 103.1,110.85 104,109.96 104.76,109.96 108.38,106.33 108.38,99 107.34,97.96 107.34,97.15 v3(107.72,96.78)
  BOTTOM w0.127: CONN14.15 22.82,74.48 22.99,74.31 23.88,74.31 25.93,72.26 26.96,72.26 v3(27.46,72.76)
PCIE_CLK_MAC_N: length 21
  TOP w0.127: v3(131.06,88.33) 130.61,87.88 130.61,87.7 130.87,87.44 132.07,87.44 C704.2
  BOTTOM w0.127: R509.1 117.76,94.13 118.17,94.13 118.38,94.08 120.04,91.38 124.08,90.41 124.37,90.29 126.12,89.87 127,89.33 128.16,87.44 128.72,87.1 130.2,87.1 130.57,87.46 130.57,87.84 v3(131.06,88.33)
PCIE_CLK_MAC_N_R: length 3.4
  TOP w0.127: C704.1 134.07,87.49 134.71,87.49 135.56,88.33 135.7,88.33 135.89,88.52 U6.25
PCIE_CLK_MAC_P: length 21
  TOP w0.127: v3(129.79,88.33) 130.3,87.81 130.3,87.63 130.76,87.17 132.16,87.17 C703.2
  BOTTOM w0.127: R508.1 117.76,94.4 118.2,94.4 118.55,94.31 120.21,91.62 124.17,90.67 124.45,90.55 126.22,90.12 127.19,89.53 128.35,87.64 128.8,87.36 130.09,87.36 130.3,87.58 130.3,87.81 v3(129.79,88.33)
PCIE_CLK_MAC_P_R: length 3.4
  TOP w0.127: C703.1 134.08,87.22 134.82,87.22 135.67,88.07 135.85,88.07 135.89,88.02 U6.26
PCIE_CLK_R_BMM_N: length 6.8
  TOP w0.127: U9.Y1 104.51,92.17 104.51,92.98 104.94,93.41 105.44,93.41 105.57,93.54 105.57,94.11 105.7,94.23 106.08,94.23 106.21,94.11 106.21,93.54 106.33,93.41 106.64,93.41 107.11,93.88 107.11,94.72 R144.2
PCIE_CLK_R_BMM_P: length 6.8
  TOP w0.127: R145.2 107.37,94.72 107.37,93.77 106.75,93.14 105.05,93.14 104.78,92.87 104.78,91.82 104.42,91.47 104.42,90.85 U9.Y3
PCIE_CLK_R_MAC_N: length 14.1
  TOP w0.127: U9.U2 105.91,91.35 105.91,92.19 106.12,92.41 107.75,92.41 109.47,94.13 111.19,94.13 111.32,94.01 111.32,93.7 111.44,93.57 111.83,93.57 111.95,93.7 111.95,94.01 112.08,94.13 112.46,94.13 112.59,94.01 112.59,93.7 112.71,93.57 113.1,93.57 113.22,93.7 113.22,94.01 113.35,94.13 114.76,94.13 v3(115.27,93.63)
  BOTTOM w0.127: R509.2 115.29,93.61 v3(115.27,93.63)
PCIE_CLK_R_MAC_P: length 14.1
  TOP w0.127: v3(115.27,94.9) 114.76,94.4 109.36,94.4 107.64,92.67 106.01,92.67 105.64,92.3 105.64,91.82 105.41,91.59 105.41,91.08 105.77,90.72 U9.U4
  BOTTOM w0.127: R508.2 115.29,94.93 v3(115.27,94.9)
PCIE_OOB_RX_N: length 104.9
  TOP w0.127: v3(114.43,86.87) 114.24,87.05 112.99,87.05 112.85,86.91 112.56,86.91 112.22,87.25 U9.D10
  S10 w0.102: v3(144.98,11.25) 144.55,11.25 144.45,11.35 144.45,13.26 134.54,23.16 134.54,67.49 133.07,68.96 127.36,68.96 124.74,71.58 124.74,81.87 120.68,85.93 114.25,85.93 113.44,86.74 113.44,87.1 113.74,87.4 114.33,87.4 114.43,87.3 v3(114.43,86.87)
  BOTTOM w0.127: v3(144.98,11.25) 144.49,10.75 144.49,8.92 144.6,8.8 CONN16.57
PCIE_OOB_RX_P: length 105
  TOP w0.127: U9.B10 112.81,87.25 112.88,87.32 113.99,87.32 114.43,87.76 v3(114.43,88.14)
  S10 w0.102: v3(114.43,88.14) 114.43,87.71 114.33,87.6 113.66,87.6 113.23,87.18 113.23,86.66 114.16,85.72 120.6,85.72 124.54,81.79 124.54,71.49 127.27,68.76 132.99,68.76 134.34,67.4 134.34,23.08 142.39,15.03 142.39,14.81 142.55,14.65 142.77,14.65 142.93,14.49 142.93,14.27 143.1,14.1 143.32,14.1 143.48,13.94 143.48,13.72 143.64,13.56 143.86,13.56 144.25,13.17 144.25,11.35 144.15,11.25 v3(143.71,11.25)
  BOTTOM w0.127: CONN16.59 144.1,8.8 144.22,8.92 144.22,10.75 v3(143.71,11.25)
PCIE_OOB_TX_C_N: length 101.2
  TOP w0.127: U9.T18 v4(106.52,83.47)
  S10 w0.102: v4(106.52,83.47) 106.96,83.03 112.41,83.03 113.56,81.89 120.31,81.89 120.9,81.3 120.9,73.45 126.59,67.77 130.71,67.77 133.63,64.85 133.63,21.35 139.88,15.1 139.88,11.86 140.67,11.07 141.43,11.07 141.91,11.55 141.91,12.4 142.01,12.5 v3(142.44,12.5)
  BOTTOM w0.127: C245.1 141.95,11.8 141.95,12.23 142.21,12.5 v3(142.44,12.5)
PCIE_OOB_TX_C_P: length 101.2
  TOP w0.114: U9.P18 v4(107.51,83.47)
  S10 w0.102: v3(141.17,12.5) 141.6,12.5 141.7,12.4 141.7,11.64 141.34,11.28 140.75,11.28 140.08,11.95 140.08,15.19 139.9,15.37 139.9,15.68 139.73,15.84 139.43,15.84 139.27,16 139.27,16.31 139.11,16.47 138.8,16.47 138.64,16.63 138.64,16.94 138.48,17.1 138.17,17.1 138.01,17.26 138.01,17.56 137.85,17.73 137.54,17.73 137.38,17.89 137.38,18.19 137.22,18.35 136.92,18.35 136.75,18.52 136.75,18.82 136.59,18.98 136.29,18.98 136.13,19.14 136.13,19.45 135.96,19.61 135.66,19.61 135.5,19.77 135.5,20.08 135.34,20.24 135.03,20.24 133.83,21.44 133.83,64.93 130.79,67.97 126.67,67.97 121.11,73.53 121.11,81.38 120.4,82.09 113.64,82.09 112.5,83.24 107.75,83.24 v4(107.51,83.47)
  BOTTOM w0.127: v3(141.17,12.5) 141.38,12.5 141.68,12.19 141.68,11.83 C244.1
PCIE_OOB_TX_N: length 3.2
  BOTTOM w0.127: C245.2 141.99,10.09 141.99,8.92 142.1,8.8 CONN16.67
PCIE_OOB_TX_P: length 3.3
  BOTTOM w0.127: CONN16.69 141.6,8.8 141.72,8.92 141.72,9.97 C244.2
PCIE_RST_N: length 386.1
  TOP w0.114: v2(165.89,86.87) 166.3,86.45 Q5.G ; v2(140.6,4.68) 140.6,6.62 140.28,6.93 138.13,6.93 137.19,7.87 137.19,9.71 137.18,9.71 137.18,10.2 137.19,10.21 137.19,10.89 137.19,10.9 137.19,11.56 137.19,12.93 138.84,14.58 v2(138.84,21.82) ; U12.P4 v3(191.09,48.61)
  S3 w0.102: v2(20.12,72.68) 19.17,71.73 16.82,71.73 16.77,71.68 7.72,71.68 4.95,68.91 4.95,24.14 5.26,23.84 5.26,23.84 5.87,23.23 5.87,20.04 9.78,16.13 14.97,16.13 14.97,16.12 15.35,16.12 15.61,16.38 17.3,16.38 18.09,15.6 19.67,15.6 20.88,14.38 25.03,14.38 25.47,14.83 32.29,14.83 33.78,13.34 47.57,13.34 47.87,13.03 49.66,13.03 51.26,11.43 51.9,11.43 52.16,11.18 57.09,11.18 58.08,10.19 58.95,10.19 59.61,9.53 60.25,9.53 60.4,9.37 61.77,9.37 62.86,8.29 70.12,8.29 70.12,8.28 70.5,8.28 71.64,9.42 72.12,9.42 73.65,10.95 78.8,10.95 79.36,11.51 86.24,11.51 87.82,13.08 93.88,13.08 96.33,15.53 98.16,15.53 v2(98.16,15.54) ; v3(191.09,48.61) 190.57,49.12 189.99,49.12 189.56,48.69 189.56,43.46 188.49,42.39 188.49,35.76 179.64,26.91 v2(177.03,26.91)
  S5 w0.102: v2(165.89,86.87) 171.86,86.87 181.53,77.19 181.53,67.77 181.86,67.44 181.86,66.28 180.99,65.41 180.77,65.41 178.97,63.6 178.97,59.16 180.29,57.84 180.29,40.92 182.93,38.28 182.93,32.81 v2(177.03,26.91)
  S8 w0.102: v2(98.16,15.54) 98.5,15.54 100.46,17.5 104.72,17.5 105.02,17.81 108.64,17.81 111.86,21.03 114.53,21.03 115.01,21.51 121.62,21.51 121.93,21.82 v2(138.84,21.82) 147.95,21.82 150.36,24.23 168.84,24.23 170.49,25.88 176.01,25.88 177.03,26.9 v2(177.03,26.91)
  BOTTOM w0.114: v2(20.12,72.68) CONN14.21 22.87,72.68 23.42,72.14 v1(24.51,72.14) ; CONN16.74 v2(140.6,4.68)
PD_BDX_SPARE1: length 25.6
  TOP w0.108: U9.AC64 102.93,63.16 102.62,63.47 v4(102.62,63.52)
  TOP w0.114: R263.2 101.06,44 v2(100.83,43.78) 100.83,42.46 R289.1
  S10 w0.102: v4(102.62,63.52) 102.28,63.52 101.14,62.38 101.14,59.77 101.5,59.41 101.5,55.7 101.83,55.37 101.83,54.23 102.03,54.03 102.03,53.15 101.68,52.79 101.68,50.83 101.65,50.8 101.65,45.47 100.83,44.65 v2(100.83,43.78)
  BOTTOM w0.114: v2(100.83,43.78) 100.59,44.02 v1(99.75,44.02)
PD_BDX_SPARE2: length 14.5
  TOP w0.114: U9.AN78 98.35,55.35 98.09,55.09 98.09,53.98 98.22,53.85 98.22,52.27 97.63,51.69 97.63,49.53 97.95,49.21 97.95,46.64 97.79,46.48 v2(96.57,46.48) 96.57,46.48 R258.1
  BOTTOM w0.114: v1(95.45,48.34) 95.45,47.98 96.14,47.3 R616.2 v2(96.57,46.48)
PD_BDX_SPARE3: length 22.8
  TOP w0.108: v4(100.58,61.73) 100.86,61.44 U9.AG67
  TOP w0.114: R264.2 v2(102.21,43.73)
  S8 w0.102: v2(102.21,43.73) 100.46,45.49 100.46,53.29 100.97,53.8 100.97,55.55 100.43,56.08 100.43,58.8 100.63,59 100.63,59.39 100.18,59.84 100.18,60.3 100.58,60.7 v4(100.58,61.73)
  BOTTOM w0.114: v2(102.21,43.73) R264.2 101.45,44.45 v1(101.14,44.75)
PD_BDX_SPARE4: length 23.8
  TOP w0.108: U9.AJ67 99.87,61.44 v4(99.59,61.73)
  TOP w0.114: R266.1 v2(104.37,46.08)
  S8 w0.102: v4(99.59,61.73) 100.14,62.28 100.81,62.28 101.04,62.05 101.04,61.21 102.03,60.22 102.03,59.74 101.68,59.39 101.68,57 102.77,55.91 102.77,52.69 102.74,52.67 102.74,52.57 102.62,52.44 102.62,49.44 102.67,49.39 102.67,48.56 103.84,47.4 103.84,46.62 v2(104.37,46.08)
  BOTTOM w0.114: v2(104.37,46.08) R266.1 105.03,45.36 105.31,45.09 v1(106.5,45.09)
PD_CPU_TSTCLK_DN: length 31.6
  TOP w0.108: v4(109.98,67.75) 110.28,67.45 U9.F54
  TOP w0.114: R274.1 114.71,45.82 114.71,46.23 v2(114.68,46.25)
  S10 w0.102: v4(109.98,67.75) 109.98,67.61 108.03,65.65 108.03,64.91 108.41,64.53 108.41,62.36 109.04,61.72 110.85,61.72 112.5,60.07 113.49,60.07 114.45,59.11 114.45,54.03 115.09,53.39 115.09,52.3 114.2,51.41 114.2,50.14 115.09,49.25 115.09,46.89 114.68,46.48 v2(114.68,46.25)
  BOTTOM w0.114: v1(115.06,48.01) 115.32,47.75 115.32,47.12 114.68,46.48 v2(114.68,46.25)
PD_CPU_TSTCLK_DP: length 30.4
  TOP w0.108: U9.J54 v4(109,67.16)
  S10 w0.102: v2(114,46.28) 114,47.05 113.13,47.91 113.13,50.7 114.81,52.37 114.81,53.24 114.15,53.9 114.15,59.08 113.38,59.84 112.39,59.84 110.74,61.49 108.81,61.49 108.66,61.34 108.34,61.34 107.95,61.74 107.95,62.1 107.57,62.48 107.57,65.73 v4(109,67.16)
  BOTTOM w0.114: v2(114,46.28) 114,45.61 R627.1 v1(115.34,45.36)
PD_CPU_TSTSTRAP0: length 5.9
  TOP w0.089: U9.E55 111.71,66.96 112.06,67.31 112.35,67.31 112.63,67.03 112.99,67.03
  TOP w0.109: 112.99,67.03 113.39,67.44 v2(113.87,67.44)
  TOP w0.114: R202.1 113.95,67.52 v2(113.87,67.44)
PD_FIVR_CLKREF: length 10.7
  TOP w0.114: R259.1 96.52,48.26 95.98,48.8 95.98,49.29 97.14,50.45 97.14,52.36 97.72,52.94 97.72,54.49 97.84,54.61 97.84,55.27 98.02,55.45 98.02,56.03 98.25,56.26 98.25,56.66 97.85,57.05 U9.AP75
PD_GPIO53: length 23.5
  TOP w0.114: U9.BT20 v4(88.2,82.62)
  BOTTOM w0.114: v1(79.85,87.05) 80.4,86.5 86.42,86.5 86.71,86.21 86.71,85.89 87.19,85.4 87.19,85.08 87.7,84.58 87.7,84.16 88.2,83.66 v4(88.2,82.62) 87.92,82.62 87.5,82.19 85.47,82.19 85.24,81.97 85.24,81.7 84.75,81.2 84.75,80.75 84.31,80.3 84.31,79.8 84.78,79.33 84.78,78.93 85.22,78.49 85.22,78.18 84.81,77.77 84.81,77.15 85.19,76.77 85.19,76.47 85.75,75.91 R554.1
PD_LAN_NCSI_CLKIN: length 6.1
  TOP w0.114: v4(103.15,60.24) 103.55,59.84 U9.AA72
  BOTTOM w0.114: v4(103.15,60.24) 101.9,60.24 v1(101.2,60.94) 100.85,61.29 100.28,61.29 100.05,61.52 R578.2
PD_N1_BB_DCMI_FRU_A0: length 3.4
  TOP w0.114: U19.1 v2(189.38,19.08)
  BOTTOM w0.114: v2(189.38,19.08) 188.87,19.58 R677.2 R687.1
PD_N1_BB_DCMI_FRU_A1: length 3.3
  TOP w0.114: v2(189.41,20.4) 189.35,20.35 U19.2
  BOTTOM w0.114: v2(189.41,20.4) 189.28,20.52 R672.2 R660.1
PD_N1_BB_DCMI_FRU_WP: length 4.4
  TOP w0.114: U19.7 v2(181.59,20.35)
  BOTTOM w0.114: v2(181.59,20.35) 181.95,19.99 R673.2 R663.1 182.35,21.47 v1(182.83,21.94)
PD_NCSI_RXD1: length 21.2
  TOP w0.108: v4(105.03,59.16) 104.74,58.86 U9.W72
  TOP w0.114: R293.1 v2(107.62,43) R268.2
  S10 w0.102: v2(107.62,43) 107.16,43.47 107.16,54.46 105.18,56.44 105.18,59 v4(105.03,59.16)
  BOTTOM w0.114: v2(107.62,43) 107.62,43.69 v1(107.31,43.99)
PD_TD_IREF: length 4.4
  TOP w0.114: U9.P11 107.06,87.15 v4(107.06,86.03)
  BOTTOM w0.114: v1(108.41,85.75) 107.26,86.89 R535.2 107.06,87 v4(107.06,86.03)
PD_TSTCLK_SC_DN: length 7.1
  TOP w0.114: R213.1 117.14,61.34 v2(117.12,61.37) 117.12,61.14 114.65,58.67 U9.A73
  BOTTOM w0.114: v1(115.96,61.44) 117.02,61.44 117.09,61.37 v2(117.12,61.37)
PD_TSTCLK_SC_DP: length 8.6
  TOP w0.114: R216.1 117.32,60.4 116.88,59.96 v2(116.85,59.96) 116.85,59.93 114.88,57.96 U9.A74
  BOTTOM w0.114: v2(116.85,59.96) 116.85,60.31 116.33,60.83 114.81,60.83 v1(114.65,60.67)
PE_WAKE_R_N: length 11.9
  TOP w0.102: 102.59,55.6 102.59,56.01 102.45,56.14
  TOP w0.114: 102.59,55.6 102.58,55.59 102.58,55.23 102.97,54.84 102.97,53.34 102.97,53.34 102.97,52.9 102.74,52.67 102.74,50.67 102.34,50.27 101.83,50.27 101.43,49.87 101.43,49.58 v2(101.06,49.21) R256.1 ; 102.45,56.14 102.45,56.91 U9.AD76
  BOTTOM w0.114: v2(101.06,49.21) 102.11,50.25 v1(102.11,50.67)
PE_WAKELAN_N: length 97.7
  TOP w0.114: Q4.G 70.47,99.4 69.49,100.38 v2(69.49,101.14) ; R256.2 v2(101.06,46.77)
  BOTTOM w0.114: v2(101.06,46.77) R256.2 102.66,47.55 103.36,48.25 103.36,49 102.61,49.75 102.61,50.13 102.74,50.26 102.74,51.69 102.19,52.24 101.92,52.24 101.68,52.47 101.68,53.3 101.89,53.51 101.89,53.85 101.65,54.09 101.31,54.09 100.25,53.04 99.39,53.04 98.93,53.49 98.93,54 99.52,54.58 99.52,55.83 100.25,56.57 100.25,58.52 100.03,58.75 97.92,58.75 97.59,59.08 97.59,59.31 97.1,59.79 97.1,60.17 96.6,60.68 96.6,62.2 96.39,62.41 94.61,62.41 94.13,61.93 94.13,61.54 93.88,61.29 84.53,61.29 84.2,61.62 84.2,61.93 84,62.13 83.01,62.13 82.75,62.38 82.75,62.76 82.47,63.04 81.48,63.04 81.2,63.32 81.2,64.67 81.71,65.18 81.71,65.63 81.28,66.07 81.28,66.57 80.8,67.06 80.8,67.34 79.86,68.28 79.86,68.91 79.58,69.19 78.16,69.19 77.77,69.57 77.77,70.46 76.91,71.32 76.91,72.14 76.25,72.8 69.82,72.8 69.12,73.5 v1(67.83,73.5) 67.06,74.27 67.06,89.74 69.49,92.18 v2(69.49,101.14)
