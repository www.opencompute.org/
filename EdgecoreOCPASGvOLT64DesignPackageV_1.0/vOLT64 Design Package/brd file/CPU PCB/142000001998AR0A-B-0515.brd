# Allegro board 142000001998AR0A-B-0515.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RP_DDR4_DIMM2_DQ52: length 61
  TOP w0.102: v3(84.6,52.88) 84.6,53.8 85.19,54.38 85.19,54.99 85.76,55.57 85.76,56.35 U9.BY77
  TOP w0.114: v2(46.61,48.6) 46.46,48.45 CONN8.211
  S3 w0.102: v2(46.61,48.6) 46.61,47.95 45.52,46.86 44.81,46.86 44.7,46.96 44.7,47.29 44.6,47.4 44.2,47.4 44.09,47.29 44.09,46.96 43.99,46.86 43.51,46.86 43.31,47.07 43.31,48.03 43.51,48.23 45.26,48.23 46.22,49.19 55.41,49.19 56.06,49.83 65.53,49.83 68.73,53.04 79.07,53.04 79.34,52.76 81.03,52.76 83.73,55.46 84.77,55.46 86.1,54.13 86.1,53.6 85.36,52.86 84.91,52.86 84.89,52.88 v3(84.6,52.88)
RP_DDR4_DIMM2_DQ53: length 61
  TOP w0.102: U9.BY75 85.97,57.05 86.31,56.71 86.31,56.41 85.97,56.06 85.97,55.48 85.39,54.91 85.39,54.3 85.13,54.05 v3(85.13,53.42)
  TOP w0.114: v2(52.02,48.5) 52.14,48.5 52.44,48.2 CONN8.212
  S3 w0.102: v3(85.13,53.42) 84.98,53.57 84.44,53.57 83.92,53.05 83.5,53.05 83.21,52.76 83.21,52.34 82.8,51.93 81.04,51.93 77.93,48.82 77.4,48.82 77.3,48.92 77.3,49.86 77.2,49.96 76.79,49.96 76.69,49.86 76.69,48.92 76.59,48.82 76.18,48.82 76.08,48.92 76.08,49.86 75.98,49.96 75.57,49.96 75.47,49.86 75.47,48.92 75.37,48.82 74.86,48.82 74.76,48.92 74.76,50.06 74.66,50.16 74.25,50.16 74.15,50.06 74.15,48.92 74.05,48.82 73.64,48.82 73.54,48.92 73.54,50.06 73.44,50.16 73.03,50.16 72.93,50.06 72.93,48.92 72.83,48.82 72.42,48.82 72.32,48.92 72.32,50.06 72.22,50.16 71.81,50.16 71.71,50.06 71.71,48.92 71.61,48.82 71.2,48.82 71.1,48.92 71.1,50.06 71,50.16 70.59,50.16 70.49,50.06 70.49,48.92 70.39,48.82 69.98,48.82 69.88,48.92 69.88,50.06 69.78,50.16 69.37,50.16 69.27,50.06 69.27,48.92 69.17,48.82 68.76,48.82 68.66,48.92 68.66,50.06 68.56,50.16 68.15,50.16 68.05,50.06 68.05,48.92 67.95,48.82 67.46,48.82 67.36,48.92 67.36,49.02 67.26,49.12 66.85,49.12 66.75,49.02 66.75,48.92 66.65,48.82 57.91,48.82 57.6,48.5 52.02,48.5 v2(52.02,48.5)
RP_DDR4_DIMM2_DQ54: length 61.3
  TOP w0.102: 87.93,55.33 87.71,55.1 87.71,54.34 v3(87.3,53.93)
  TOP w0.114: v2(51.59,44.79) 52,45.2 CONN8.224 ; U9.BR77 87.96,56.55 87.96,55.35 87.93,55.33
  S3 w0.102: v2(51.59,44.79) 51.59,44.73 51.9,44.42 52.67,44.42 54.42,42.67 55.32,42.67 61.65,36.35 69.49,36.35 69.6,36.45 69.6,38.43 69.7,38.53 70.1,38.53 70.21,38.43 70.21,36.45 70.31,36.35 70.71,36.35 70.82,36.45 70.82,38.43 70.92,38.53 71.32,38.53 71.42,38.43 71.42,36.45 71.53,36.35 72.01,36.35 83.64,47.98 83.64,48.64 85.77,50.76 85.77,51.23 85.39,51.6 85.39,52.02 v3(87.3,53.93)
RP_DDR4_DIMM2_DQ55: length 61.1
  TOP w0.102: v3(87.3,53.17) 87.91,53.78 87.91,55 88.17,55.25 88.17,55.98 88.28,56.1 88.28,56.73 87.95,57.06 U9.BR75
  TOP w0.114: v2(47.05,44.79) 46.89,44.95 CONN8.225
  S3 w0.102: v3(87.3,53.17) 87.25,53.12 87.25,51.81 87.7,51.37 87.7,50.11 72.77,35.18 60.53,35.18 54.91,40.79 52.03,40.79 48.8,44.02 47.47,44.02 47.05,44.44 v2(47.05,44.79)
RP_DDR4_DIMM2_DQ56: length 60.5
  TOP w0.102: v3(86.68,51.03) 86.8,50.91 87.54,50.91 89.96,53.33 89.96,55.17 90.13,55.34 90.13,56.17 90.12,56.18 90.12,56.37 U9.BL77
  TOP w0.114: v2(48.82,43.26) 47.97,42.4 47.62,42.4 47.17,41.95 CONN8.237
  S10 w0.102: v3(86.68,51.03) 85.82,51.03 85.82,51.04 85.79,51.04 85.36,51.47 84.98,51.47 84.1,50.59 84,50.59 80.63,47.22 73.14,47.22 73.04,47.32 73.04,47.42 72.93,47.52 72.53,47.52 72.43,47.42 72.43,47.32 72.33,47.22 71.84,47.22 71.74,47.32 71.74,47.5 71.64,47.6 71.23,47.6 71.13,47.5 71.13,47.32 71.03,47.22 70.55,47.22 70.45,47.32 70.45,47.52 70.34,47.62 69.94,47.62 69.84,47.52 69.84,47.32 69.73,47.22 69.33,47.22 69.23,47.32 69.23,47.52 69.12,47.62 68.72,47.62 68.62,47.52 68.62,47.32 68.52,47.22 68.11,47.22 68.01,47.32 68.01,47.52 67.91,47.62 67.5,47.62 67.4,47.52 67.4,47.32 67.3,47.22 66.89,47.22 66.79,47.32 66.79,47.52 66.69,47.62 66.28,47.62 66.18,47.52 66.18,47.32 66.08,47.22 65.67,47.22 65.57,47.32 65.57,47.52 65.47,47.62 65.06,47.62 64.96,47.52 64.96,47.32 64.86,47.22 64.45,47.22 64.35,47.32 64.35,47.52 64.25,47.62 63.84,47.62 63.74,47.52 63.74,47.32 63.64,47.22 63.23,47.22 63.13,47.32 63.13,47.52 63.03,47.62 62.62,47.62 62.52,47.52 62.52,47.32 62.42,47.22 62.01,47.22 61.91,47.32 61.91,47.52 61.81,47.62 61.4,47.62 61.3,47.52 61.3,47.32 61.2,47.22 60.79,47.22 60.69,47.32 60.69,47.52 60.59,47.62 60.18,47.62 60.08,47.52 60.08,47.32 59.98,47.22 59.56,47.22 54.4,42.06 51,42.06 50.74,42.32 50.24,42.32 49.81,42.75 49.22,42.75 48.82,43.15 v2(48.82,43.26)
RP_DDR4_DIMM2_DQ57: length 60.4
  TOP w0.102: v3(87.74,52.09) 88.44,52.09 89.75,53.41 89.75,55.25 89.93,55.42 89.93,56.08 89.56,56.45 89.56,56.67 89.93,57.05 U9.BL75
  TOP w0.114: CONN8.236 51.31,42.2 50.34,43.18 v2(50.34,43.34)
  S10 w0.102: v3(87.74,52.09) 86.88,52.09 86.42,51.63 86.04,51.63 85.6,52.06 84.73,52.06 83.5,50.84 83.36,50.84 80.66,48.13 79.97,48.13 79.87,48.03 79.87,47.85 79.77,47.75 79.36,47.75 79.26,47.85 79.26,48.03 79.16,48.13 78.75,48.13 78.65,48.03 78.65,47.85 78.55,47.75 78.14,47.75 78.04,47.85 78.04,48.03 77.94,48.13 77.53,48.13 77.43,48.03 77.43,47.85 77.33,47.75 76.92,47.75 76.82,47.85 76.82,48.03 76.72,48.13 76.31,48.13 76.21,48.03 76.21,47.85 76.11,47.75 75.7,47.75 75.6,47.85 75.6,48.03 75.5,48.13 75.09,48.13 74.99,48.03 74.99,47.85 74.89,47.75 74.48,47.75 74.38,47.85 74.38,48.03 74.28,48.13 59.79,48.13 58.91,47.25 58.77,47.25 58.23,47.8 58.08,47.8 57.8,47.51 57.8,47.36 58.34,46.82 58.34,46.68 58.05,46.39 57.9,46.39 57.36,46.93 57.22,46.93 56.93,46.65 56.93,46.5 57.47,45.96 57.47,45.82 57.19,45.53 57.04,45.53 56.5,46.07 56.36,46.07 56.07,45.78 56.07,45.64 56.61,45.1 56.61,44.95 54.37,42.71 51.19,42.71 51.1,42.81 50.74,42.81 50.34,43.21 v2(50.34,43.34)
RP_DDR4_DIMM2_DQ58: length 60.5
  TOP w0.102: U9.BG77 91.92,56.55 91.92,54.77 91.58,54.43 91.58,52.82 90.59,51.83 v3(90,51.83)
  TOP w0.114: CONN8.249 48.29,38.95 48.82,39.48 v2(48.82,39.7)
  S10 w0.102: v3(90,51.83) 90,50.98 74.3,35.28 58.27,35.28 56.08,37.47 51.69,37.47 50.9,38.25 49.94,38.25 48.82,39.36 v2(48.82,39.7)
RP_DDR4_DIMM2_DQ59: length 60.3
  TOP w0.102: U9.BG75 91.91,57.03 92.24,56.7 92.24,56.1 92.13,55.98 92.13,52.59 90.24,50.7 v3(88.88,50.7)
  TOP w0.114: CONN8.250 50.63,38.7 49.71,39.62 v2(49.71,39.7)
  S10 w0.102: v3(88.88,50.7) 73.96,35.79 58.51,35.79 55.36,38.94 50.34,38.94 49.71,39.57 v2(49.71,39.7)
RP_DDR4_DIMM2_DQ60: length 60.5
  TOP w0.102: v3(88.81,53.17) 89.55,53.91 89.55,55.5 89.44,55.62 U9.BM78
  TOP w0.114: v2(51.96,43.33) 52.09,43.2 CONN8.232
  S10 w0.102: v3(88.81,53.17) 88.58,53.17 87.77,53.99 87.77,54.89 87.53,55.12 86.19,55.12 80.47,49.4 78.32,49.4 78.21,49.3 78.21,49 78.11,48.9 77.71,48.9 77.61,49 77.61,49.3 77.5,49.4 77.1,49.4 77,49.3 77,49 76.89,48.9 76.49,48.9 76.39,49 76.39,49.3 76.28,49.4 75.88,49.4 75.78,49.3 75.78,49 75.67,48.9 75.27,48.9 75.17,49 75.17,49.3 75.07,49.4 74.66,49.4 74.56,49.3 74.56,49 74.46,48.9 72.96,48.9 72.86,49 72.86,49.33 72.76,49.43 72.35,49.43 72.25,49.33 72.25,49 72.15,48.9 71.74,48.9 71.64,49 71.64,49.33 71.54,49.43 71.13,49.43 71.03,49.33 71.03,49 70.93,48.9 70.44,48.9 70.34,49 70.34,49.35 70.24,49.45 69.83,49.45 69.73,49.35 69.73,49 69.63,48.9 69.22,48.9 69.12,49 69.12,49.35 69.02,49.45 68.62,49.45 68.51,49.35 68.51,49 68.41,48.9 68.01,48.9 67.9,49 67.9,49.35 67.8,49.45 67.4,49.45 67.29,49.35 67.29,49 67.19,48.9 66.79,48.9 66.68,49 66.68,49.35 66.58,49.45 66.18,49.45 66.08,49.35 66.08,49 65.97,48.9 65.57,48.9 65.47,49 65.47,49.35 65.36,49.45 64.96,49.45 64.86,49.35 64.86,49 64.75,48.9 64.35,48.9 64.25,49 64.25,49.35 64.14,49.45 63.74,49.45 63.64,49.35 63.64,49 63.54,48.9 63.13,48.9 63.03,49 63.03,49.35 62.93,49.45 62.52,49.45 62.42,49.35 62.42,49 62.32,48.9 61.91,48.9 61.81,49 61.81,49.35 61.71,49.45 61.3,49.45 61.2,49.35 61.2,49 61.1,48.9 60.69,48.9 60.59,49 60.59,49.35 60.49,49.45 60.08,49.45 59.98,49.35 59.98,49 59.88,48.9 59.47,48.9 59.37,49 59.37,49.35 59.27,49.45 58.86,49.45 58.76,49.35 58.76,49 58.66,48.9 57.91,48.9 52.35,43.33 v2(51.96,43.33)
RP_DDR4_DIMM2_DQ61: length 60.3
  TOP w0.102: v3(88.94,53.93) 89.35,54.34 89.35,55.42 89.16,55.61 89.16,55.98 89.34,56.16 89.34,56.75 89.44,56.85 U9.BM76
  TOP w0.114: CONN8.233 46.74,42.95 v2(47.05,43.26)
  S10 w0.102: v2(47.05,43.26) 46.43,43.26 46.08,43.61 46.08,45.12 46.33,45.37 47.45,45.37 47.55,45.47 47.55,45.85 47.65,45.95 48.06,45.95 48.16,45.85 48.16,45.47 48.26,45.37 48.67,45.37 48.77,45.47 48.77,45.85 48.87,45.95 49.28,45.95 49.38,45.85 49.38,45.47 49.48,45.37 49.89,45.37 49.99,45.47 49.99,45.85 50.09,45.95 50.5,45.95 50.6,45.85 50.6,45.47 50.7,45.37 51.11,45.37 51.21,45.47 51.21,45.85 51.31,45.95 51.72,45.95 51.82,45.85 51.82,45.47 51.92,45.37 52.87,45.37 57.68,50.19 73.81,50.19 74.09,49.91 80.13,49.91 85.94,55.72 87.78,55.72 88.36,55.14 88.36,54.51 v3(88.94,53.93)
RP_DDR4_DIMM2_DQ62: length 60.4
  TOP w0.102: v3(90.77,53.93) 91.18,54.34 91.18,55.49 91.42,55.73 U9.BH78
  TOP w0.114: CONN8.245 46.82,39.95 v2(47.05,39.72)
  S10 w0.102: v3(90.77,53.93) 90.42,53.93 74.23,37.74 67.89,37.74 66.92,36.77 59.09,36.77 55.56,40.3 47.58,40.3 47.04,40.84 45.82,40.84 45.64,40.67 45.64,39.9 45.82,39.72 v2(47.05,39.72)
RP_DDR4_DIMM2_DQ63: length 60.7
  TOP w0.102: v3(90.77,53.17) 91.38,53.78 91.38,55.3 91.7,55.62 91.7,56.31 91.58,56.42 91.58,56.89 U9.BH76
  TOP w0.114: CONN8.246 v2(51.51,39.7)
  S10 w0.102: v2(51.51,39.7) 55.43,39.7 58.85,36.28 68.58,36.28 68.69,36.38 68.69,37.11 68.79,37.21 69.19,37.21 69.3,37.11 69.3,36.38 69.4,36.28 69.88,36.28 69.98,36.38 69.98,37.16 70.08,37.26 70.49,37.26 70.59,37.16 70.59,36.38 70.69,36.28 71.1,36.28 71.2,36.38 71.2,37.16 71.3,37.26 71.71,37.26 71.81,37.16 71.81,36.38 71.91,36.28 72.32,36.28 72.42,36.38 72.42,37.16 72.52,37.26 72.93,37.26 73.03,37.16 73.03,36.38 73.13,36.28 73.61,36.28 90.5,53.17 v3(90.77,53.17)
RP_DDR4_DIMM2_DQS0_N: length 52.2
  TOP w0.102: CONN8.11 46.22,100.45 46.33,100.34 48.83,100.34 48.92,100.43 48.92,100.57 v2(48.65,100.84) ; U9.CJ1 81.52,92.5 76.98,97.04 76.28,97.04 76.04,96.8 v3(76.04,96.46)
  S8 w0.089: v2(48.65,100.84) 48.96,100.53 48.96,100.25 49.17,100.04 53.44,100.04 53.58,99.89 53.61,99.89
  S8 w0.102: 53.61,99.89 54.06,99.89 54.16,99.79 54.16,99.42 54.26,99.31 54.66,99.31 54.77,99.42 54.77,99.79 54.87,99.89 55.27,99.89 55.38,99.79 55.38,99.42 55.48,99.31 55.88,99.31 55.99,99.42 55.99,99.79 56.09,99.89 56.55,99.89 60.17,96.27 69.53,96.27 69.91,96.65 69.91,98.42 70.01,98.53 70.42,98.53 70.52,98.42 70.52,96.65 70.91,96.27 71.71,96.27 72.1,96.65 72.1,98.42 72.2,98.53 72.6,98.53 72.71,98.42 72.71,96.65 73.09,96.27 73.97,96.27 74.33,95.91 75.29,95.91 75.84,96.46 v3(76.04,96.46)
RP_DDR4_DIMM2_DQS0_P: length 52.2
  TOP w0.102: U9.CJ3 81.52,91.27 81.8,91.55 81.8,92.62 77.09,97.32 76.17,97.32 75.84,97 v3(75.5,97) ; v2(49.46,100.84) 49.19,100.57 49.19,100.26 49,100.06 46.33,100.06 46.22,99.95 CONN8.13
  S8 w0.089: 53.61,100.37 53.58,100.37 53.44,100.23 49.25,100.23 49.15,100.33 49.15,100.53 v2(49.46,100.84)
  S8 w0.102: v3(75.5,97) 75.5,96.8 75.09,96.39 74.53,96.39 74.17,96.75 73.29,96.75 73.19,96.85 73.19,98.63 72.8,99.01 72,99.01 71.61,98.63 71.61,96.85 71.51,96.75 71.11,96.75 71,96.85 71,98.63 70.62,99.01 69.81,99.01 69.43,98.63 69.43,96.85 69.33,96.75 60.37,96.75 56.75,100.37 53.61,100.37
RP_DDR4_DIMM2_DQS1_N: length 41
  TOP w0.092: 76.08,88.05 76.66,87.46 76.67,87.46
  TOP w0.102: v2(49.33,95.94) 49.07,95.67 49.07,95.37 49.35,95.09 52.24,95.09 52.35,95.2 CONN8.32 ; U9.CU10 77.87,87.25 77.66,87.46 76.67,87.46 ; v3(71.14,89.51) 70.9,89.27 70.9,88.79 71.32,88.37 75.76,88.37 76.08,88.05
  S3 w0.102: v2(49.33,95.94) 49.17,95.77 49.17,95.67 49.35,95.49 57.59,95.49 58.7,94.39 66.74,94.39 67.45,93.68 67.6,93.68 67.72,93.8 67.87,93.8 68.16,93.52 68.16,93.37 68.03,93.24 68.03,93.1 68.31,92.81 68.46,92.81 68.59,92.94 68.73,92.94 69.02,92.65 69.02,92.51 68.89,92.38 68.89,92.24 69.18,91.95 69.32,91.95 69.45,92.08 69.59,92.08 69.88,91.79 69.88,91.65 69.75,91.52 69.75,91.37 70.04,91.09 70.18,91.09 70.31,91.22 70.46,91.22 70.74,90.93 70.74,90.78 70.61,90.66 70.61,90.51 71,90.12 71,89.65 v3(71.14,89.51)
RP_DDR4_DIMM2_DQS1_P: length 41
  TOP w0.092: 76.67,87.26 76.65,87.26 76.65,87.27 76.59,87.27 76.47,87.38 76.06,87.79
  TOP w0.102: v2(48.52,95.94) 48.79,95.67 48.79,95.25 49.23,94.81 52.24,94.81 52.35,94.7 CONN8.34 ; 76.67,87.26 77.58,87.26 77.92,86.92 78.2,86.92 78.53,87.25 U9.CR10 ; 76.06,87.79 75.77,88.09 71.21,88.09 70.62,88.67 70.62,89.27 v3(70.38,89.51)
  S3 w0.102: v2(48.52,95.94) 48.69,95.77 48.69,95.47 49.15,95.01 57.39,95.01 58.5,93.9 66.54,93.9 70.52,89.92 70.52,89.65 v3(70.38,89.51)
RP_DDR4_DIMM2_DQS2_N: length 38.2
  TOP w0.102: CONN8.53 46.22,89.95 46.33,89.84 48.2,89.84 48.44,90.09 48.44,90.3 v2(48.18,90.56) ; U9.CV18 77.23,83.87 77.05,83.87 76.71,83.53 75.44,83.53 v3(74.87,84.1)
  S8 w0.089: 53,89.65 52.98,89.65 52.83,89.79 48.69,89.79 48.49,90 48.49,90.25 v2(48.18,90.56)
  S8 w0.102: 53,89.65 55.39,89.65 55.49,89.55 55.49,89.28 55.59,89.17 56,89.17 56.1,89.28 56.1,89.55 56.2,89.65 56.61,89.65 56.71,89.55 56.71,89.28 56.81,89.17 57.22,89.17 57.32,89.28 57.32,89.55 57.42,89.65 57.99,89.65 59.02,88.61 64.37,88.61 68.15,84.84 73.2,84.84 73.32,84.72 74.8,84.72 75.01,84.51 75.01,84.23 v3(74.87,84.1)
RP_DDR4_DIMM2_DQS2_P: length 38.2
  TOP w0.102: U9.CT18 78.39,83.95 77.89,83.95 77.76,84.07 76.97,84.07 76.63,83.73 76,83.73 v3(75.63,84.1) ; v2(48.99,90.56) 48.72,90.3 48.72,89.97 48.31,89.56 46.33,89.56 46.22,89.45 CONN8.55
  S8 w0.089: v2(48.99,90.56) 48.68,90.25 48.68,90.08 48.77,89.98 52.83,89.98 52.98,90.13 53,90.13
  S8 w0.102: 53,90.13 58.19,90.13 59.22,89.1 64.57,89.1 68.35,85.32 73.4,85.32 73.52,85.2 75,85.2 75.5,84.71 75.5,84.23 v3(75.63,84.1)
RP_DDR4_DIMM2_DQS3_N: length 43.8
  TOP w0.102: U9.CU26 78.04,80.33 76.39,80.33 75.82,80.9 74.46,80.9 74.37,80.82 74.37,80.74 v3(74.62,80.49) ; v2(49.88,85.29) 49.62,85.02 49.62,84.77 49.79,84.59 52.24,84.59 52.35,84.7 CONN8.74
  S3 w0.102: v2(49.88,85.29) 49.72,85.12 49.72,84.95 49.92,84.74 52.66,84.74 52.76,84.84 52.76,85.14 53.14,85.52 53.95,85.52 54.33,85.14 54.33,84.84 54.43,84.74 54.84,84.74 54.94,84.84 54.94,85.14 55.33,85.52 56.13,85.52 56.52,85.14 56.52,84.84 56.62,84.74 57.02,84.74 57.13,84.84 57.13,85.14 57.51,85.52 58.32,85.52 58.7,85.14 58.7,84.84 58.8,84.74 59.21,84.74 59.31,84.84 59.31,85.14 59.69,85.52 60.5,85.52 60.89,85.14 60.89,84.84 60.99,84.74 61.39,84.74 61.5,84.84 61.5,85.14 61.88,85.52 62.69,85.52 63.07,85.14 63.07,84.84 63.17,84.74 63.81,84.74 64.29,84.26 64.29,83.76 64.59,83.47 64.73,83.47 65.05,83.78 65.19,83.78 65.48,83.49 65.48,83.35 65.16,83.03 65.16,82.89 65.45,82.6 65.59,82.6 65.91,82.92 66.05,82.92 66.34,82.63 66.34,82.49 66.03,82.17 66.03,82.03 66.27,81.79 73.98,81.79 74.48,81.29 74.48,80.63 v3(74.62,80.49)
RP_DDR4_DIMM2_DQS3_P: length 43.7
  TOP w0.102: U9.CR26 78.57,80.32 78.21,80.68 77.89,80.68 77.74,80.54 76.47,80.54 75.91,81.1 74.37,81.1 74.17,80.9 74.17,80.79 v3(73.86,80.49) ; CONN8.76 52.35,84.2 52.24,84.31 49.67,84.31 49.34,84.65 49.34,85.02 v2(49.07,85.29)
  S3 w0.102: v2(49.07,85.29) 49.23,85.12 49.23,84.75 49.72,84.26 52.86,84.26 53.24,84.64 53.24,84.94 53.34,85.04 53.75,85.04 53.85,84.94 53.85,84.64 54.23,84.26 55.04,84.26 55.42,84.64 55.42,84.94 55.53,85.04 55.93,85.04 56.03,84.94 56.03,84.64 56.42,84.26 57.22,84.26 57.61,84.64 57.61,84.94 57.71,85.04 58.12,85.04 58.22,84.94 58.22,84.64 58.6,84.26 59.41,84.26 59.79,84.64 59.79,84.94 59.89,85.04 60.3,85.04 60.4,84.94 60.4,84.64 60.79,84.26 61.59,84.26 61.98,84.64 61.98,84.94 62.08,85.04 62.49,85.04 62.59,84.94 62.59,84.64 62.97,84.26 63.61,84.26 63.81,84.06 63.81,83.56 66.07,81.31 73.78,81.31 74,81.09 74,80.63 v3(73.86,80.49)
RP_DDR4_DIMM2_DQS4_N: length 43.3
  TOP w0.102: CONN8.177 46.22,56.95 46.33,56.84 46.87,56.84 47.35,56.36 48.36,56.36 48.51,56.51 48.51,56.74 v2(48.24,57) ; U9.CM76 80.33,56.97 80.33,56.14 80.52,55.95 80.52,55.7 79.7,54.88 76.3,54.88 v2(75.11,53.69)
  S5 w0.089: v2(48.24,57) 48.55,56.69 48.55,56.4 48.83,56.12 52.5,56.12 52.75,55.87 52.75,55.78 52.7,55.73 52.7,55.71 52.71,55.7
  S5 w0.102: v2(75.11,53.69) 75.27,53.85 75.27,54.46 74.85,54.88 72.24,54.88 72.14,54.78 72.14,54.67 71.76,54.28 70.95,54.28 70.57,54.67 70.57,54.78 70.46,54.88 69.4,54.88 69.29,54.78 69.29,54.62 69.19,54.52 68.79,54.52 68.68,54.62 68.68,54.78 68.58,54.88 68.18,54.88 68.08,54.78 68.08,54.62 67.97,54.52 67.57,54.52 67.47,54.62 67.47,54.78 67.36,54.88 66.96,54.88 66.86,54.78 66.86,54.62 66.75,54.52 66.35,54.52 66.25,54.62 66.25,54.78 66.14,54.88 53.53,54.88 52.71,55.7
RP_DDR4_DIMM2_DQS4_P: length 43.3
  TOP w0.102: v2(49.06,57) 48.79,56.74 48.79,56.39 48.48,56.08 47.23,56.08 46.75,56.56 46.33,56.56 46.22,56.45 CONN8.179 ; v2(75.92,53.69) 75.92,54.06 76.54,54.68 79.78,54.68 80.72,55.61 80.72,56.03 80.53,56.22 80.53,56.92 80.55,56.94 80.55,57.2 80.2,57.55 U9.CN75
  S5 w0.089: v2(49.06,57) 48.74,56.69 48.74,56.48 48.91,56.31 52.58,56.31 52.83,56.06 53.04,56.06 53.05,56.05
  S5 w0.102: 53.05,56.05 53.73,55.37 70.66,55.37 71.05,54.98 71.05,54.87 71.15,54.76 71.56,54.76 71.66,54.87 71.66,54.98 72.04,55.37 75.05,55.37 75.76,54.66 75.76,53.85 v2(75.92,53.69)
RP_DDR4_DIMM2_DQS5_N: length 47.6
  TOP w0.102: CONN8.198 52.35,51.7 52.24,51.59 49.11,51.59 48.97,51.73 48.97,51.9 v2(49.23,52.17) ; U9.CD77 84,56.55 84,55.59 83.17,54.76 83.17,54.37 80.41,51.6 77.92,51.6 77.89,51.63 77.43,51.63 77.24,51.43 77.24,51.32 77.35,51.21 v3(77.59,51.21)
  S8 w0.102: v2(49.23,52.17) 49.15,52.08 49.15,51.92 49.36,51.71 50.81,51.71 50.91,51.81 50.91,52.01 51.01,52.11 51.42,52.11 51.52,52.01 51.52,51.81 51.62,51.71 52.03,51.71 52.13,51.81 52.13,52.01 52.23,52.11 52.64,52.11 52.74,52.01 52.74,51.81 52.84,51.71 53.25,51.71 53.35,51.81 53.35,52.01 53.45,52.11 53.86,52.11 53.96,52.01 53.96,51.81 54.06,51.71 55.13,51.71 56.41,53 73.66,53 73.89,52.77 76.87,52.77 77.45,52.18 77.45,51.35 v3(77.59,51.21)
RP_DDR4_DIMM2_DQS5_P: length 47.5
  TOP w0.102: v2(48.42,52.17) 48.69,51.9 48.69,51.62 48.99,51.31 52.24,51.31 52.35,51.2 CONN8.200 ; v3(76.83,51.21) 77.03,51.41 77.03,51.52 77.35,51.84 77.97,51.84 78,51.81 80.33,51.81 82.97,54.45 82.97,54.85 83.8,55.68 83.8,56.18 83.64,56.33 83.64,56.7 83.83,56.88 83.83,57.39 U9.CD75
  S8 w0.102: v3(76.83,51.21) 76.97,51.35 76.97,51.98 76.67,52.29 73.69,52.29 73.46,52.51 56.61,52.51 55.33,51.23 48.98,51.23 48.59,51.62 48.59,52 v2(48.42,52.17)
RP_DDR4_DIMM2_DQS6_N: length 60.7
  TOP w0.102: CONN8.219 46.22,46.45 46.33,46.34 47.28,46.34 47.62,46 48.68,46 48.92,46.24 48.92,46.41 v2(48.65,46.68) ; v3(81.38,49.66) 81.38,49.24 81.49,49.14 82.12,49.14 86.67,53.68 86.67,54.95 87.46,55.74 U9.BT78
  S3 w0.089: 52.14,45.91 52.12,45.91 51.97,46.06 51.14,46.06 50.98,45.9 49.21,45.9 48.96,46.15 48.96,46.37 v2(48.65,46.68)
  S3 w0.102: 52.14,45.91 57.87,45.91 58.22,46.25 58.99,46.25 59.09,46.15 59.09,46.02 59.19,45.92 59.6,45.92 59.7,46.02 59.7,46.15 59.8,46.25 60.21,46.25 60.31,46.15 60.31,46.02 60.41,45.92 60.82,45.92 60.92,46.02 60.92,46.15 61.02,46.25 68.92,46.25 69.02,46.15 69.02,45.22 69.4,44.83 70.21,44.83 70.59,45.22 70.59,46.15 70.7,46.25 71.1,46.25 71.2,46.15 71.2,45.22 71.59,44.83 72.39,44.83 72.78,45.22 72.78,46.15 72.88,46.25 73.29,46.25 73.39,46.15 73.39,45.22 73.77,44.83 74.58,44.83 74.96,45.22 74.96,46.15 75.06,46.25 75.47,46.25 75.57,46.15 75.57,45.22 75.96,44.83 76.76,44.83 77.15,45.22 77.15,46.15 77.25,46.25 79.58,46.25 81.74,48.42 81.74,49.1 81.38,49.46 v3(81.38,49.66)
RP_DDR4_DIMM2_DQS6_P: length 60.7
  TOP w0.102: v2(49.46,46.68) 49.19,46.41 49.19,46.12 48.79,45.72 47.51,45.72 47.17,46.06 46.33,46.06 46.22,45.95 CONN8.221 ; v3(80.84,49.12) 81.21,49.12 81.4,48.93 82.2,48.93 86.87,53.6 86.87,54.87 87.43,55.43 87.52,55.43 87.74,55.64 87.74,56.03 87.46,56.31 U9.BT76
  S3 w0.089: v2(49.46,46.68) 49.15,46.37 49.15,46.23 49.29,46.09 50.9,46.09 51.06,46.25 51.97,46.25 52.12,46.39 52.14,46.39
  S3 w0.102: 52.14,46.39 57.67,46.39 58.02,46.74 69.12,46.74 69.5,46.35 69.5,45.42 69.6,45.31 70.01,45.31 70.11,45.42 70.11,46.35 70.5,46.74 71.3,46.74 71.69,46.35 71.69,45.42 71.79,45.31 72.19,45.31 72.3,45.42 72.3,46.35 72.68,46.74 73.49,46.74 73.87,46.35 73.87,45.42 73.97,45.31 74.38,45.31 74.48,45.42 74.48,46.35 74.86,46.74 75.67,46.74 76.06,46.35 76.06,45.42 76.16,45.31 76.56,45.31 76.67,45.42 76.67,46.35 77.05,46.74 79.38,46.74 81.26,48.62 81.26,48.9 81.04,49.12 v3(80.84,49.12)
RP_DDR4_DIMM2_DQS7_N: length 61.8
  TOP w0.102: CONN8.240 52.35,41.2 52.24,41.09 49.32,41.09 49.19,41.22 49.19,41.35 v2(49.46,41.61) ; U9.BJ77 90.92,56.09 90.72,55.9 90.72,55.65 90.16,55.08 90.16,53.02 86.32,49.18 86.06,49.18 85.6,49.64 v3(85.6,49.96)
  S10 w0.089: 55.59,41.65 55.57,41.63 55.57,41.43 55.17,41.02 49.27,41.02 49.15,41.14 49.15,41.3 v2(49.46,41.61) ; 83.45,49.21 83.47,49.22 83.67,49.22 84.24,49.79 84.51,49.79 84.79,50.08 85.08,50.08 85.19,49.96 v3(85.6,49.96)
  S10 w0.102: 83.45,49.21 80.88,46.63 73.22,46.63 72.84,46.25 72.84,45.69 72.73,45.59 72.33,45.59 72.23,45.69 72.23,46.25 71.84,46.63 71.04,46.63 70.65,46.25 70.65,45.69 70.55,45.59 70.14,45.59 70.04,45.69 70.04,46.25 69.66,46.63 60.57,46.63 58.61,44.67 58.47,44.67 58.24,44.9 58.1,44.9 57.81,44.61 57.81,44.47 58.04,44.24 58.04,44.1 57.75,43.81 57.61,43.81 57.38,44.03 57.24,44.03 56.95,43.75 56.95,43.6 57.17,43.38 57.17,43.24 56.89,42.95 56.74,42.95 56.52,43.17 56.38,43.17 56.09,42.88 56.09,42.74 56.31,42.52 56.31,42.37 55.59,41.65
RP_DDR4_DIMM2_DQS7_P: length 61.7
  TOP w0.102: U9.BJ75 90.92,57.03 91.25,56.7 91.25,56.13 91.13,56.01 91.12,56.01 90.93,55.81 90.93,55.56 90.36,55 90.36,52.94 86.4,48.98 85.98,48.98 85.54,49.41 85.52,49.41 85.52,49.42 v3(85.06,49.42) ; v2(48.65,41.61) 48.92,41.35 48.92,41.1 49.2,40.81 52.24,40.81 52.35,40.7 CONN8.242
  S10 w0.089: v3(85.06,49.42) 85.06,49.82 85,49.88 84.87,49.88 84.58,49.6 84.32,49.6 83.81,49.09 83.81,48.88 83.79,48.87 ; v2(48.65,41.61) 48.96,41.3 48.96,41.06 49.19,40.83 55.25,40.83 55.71,41.29 55.91,41.29 55.93,41.31
  S10 w0.102: 55.93,41.31 60.77,46.15 69.46,46.15 69.56,46.05 69.56,45.49 69.94,45.11 70.75,45.11 71.13,45.49 71.13,46.05 71.24,46.15 71.64,46.15 71.74,46.05 71.74,45.49 72.13,45.11 72.93,45.11 73.32,45.49 73.32,46.05 73.42,46.15 81.08,46.15 83.79,48.87
RP_DDR4_DIMM2_DQS8_N: length 44.4
  TOP w0.102: U9.CV34 77.31,76.86 77.31,77.08 77.24,77.16 76.36,77.16 75.97,77.54 74.81,77.54 74.71,77.45 74.71,77.35 v3(74.96,77.11) ; CONN8.95 46.22,79.45 46.33,79.34 46.75,79.34 47.09,79.68 48.27,79.68 48.6,80.01 48.6,80.45 v2(48.34,80.71)
  S8 w0.102: v3(74.96,77.11) 74.82,77.25 74.82,77.99 74.22,78.59 70.15,78.59 69.17,79.57 66.93,79.57 64.71,81.79 62.79,81.79 62.69,81.89 62.69,82.72 62.31,83.11 61.5,83.11 61.12,82.72 61.12,81.89 61.02,81.79 60.61,81.79 60.51,81.89 60.51,82.72 60.12,83.11 59.32,83.11 58.93,82.72 58.93,81.89 58.83,81.79 58.42,81.79 58.32,81.89 58.32,82.72 57.94,83.11 57.13,83.11 56.75,82.72 56.75,81.89 56.65,81.79 53.5,81.79 53.4,81.89 53.4,82.02 53.3,82.12 52.9,82.12 52.79,82.02 52.79,81.89 52.69,81.79 48.99,81.79 48.5,81.3 48.5,80.88 v2(48.34,80.71)
RP_DDR4_DIMM2_DQS8_P: length 44.4
  TOP w0.102: CONN8.97 46.22,78.95 46.33,79.06 46.87,79.06 47.21,79.4 48.39,79.4 48.88,79.9 48.88,80.45 v2(49.15,80.71) ; U9.CT34 78.02,76.86 77.65,77.22 77.65,77.22 77.51,77.36 76.44,77.36 76.06,77.75 74.73,77.75 74.51,77.53 74.51,77.43 v3(74.2,77.11)
  S8 w0.102: v3(74.2,77.11) 74.34,77.25 74.34,77.79 74.02,78.1 69.95,78.1 68.97,79.08 66.73,79.08 64.51,81.31 62.59,81.31 62.21,81.69 62.21,82.52 62.11,82.63 61.7,82.63 61.6,82.52 61.6,81.69 61.22,81.31 60.41,81.31 60.02,81.69 60.02,82.52 59.92,82.63 59.52,82.63 59.41,82.52 59.41,81.69 59.03,81.31 58.22,81.31 57.84,81.69 57.84,82.52 57.74,82.63 57.33,82.63 57.23,82.52 57.23,81.69 56.85,81.31 49.19,81.31 48.98,81.1 48.98,80.88 v2(49.15,80.71)
RP_DDR4_DIMM2_ECC0: length 44.2
  TOP w0.102: v2(71.88,77.19) 71.65,77.42 71.65,78.02 71.87,78.23 76.32,78.23 76.71,77.85 U9.CV31
  TOP w0.114: CONN8.92 52.04,80.2 51.88,80.37 v2(51.88,80.68)
  S8 w0.102: v2(51.88,80.68) 51.88,80.08 52.01,79.94 52.46,79.94 52.57,80.04 52.57,80.7 52.67,80.8 53.07,80.8 53.17,80.7 53.17,80.04 53.28,79.94 53.76,79.94 53.86,80.04 53.86,80.54 53.96,80.64 54.37,80.64 54.47,80.54 54.47,80.04 54.57,79.94 56.22,79.94 56.32,80.04 56.32,80.66 56.43,80.76 56.83,80.76 56.93,80.66 56.93,80.04 57.04,79.94 57.44,79.94 57.54,80.04 57.54,80.66 57.64,80.76 58.05,80.76 58.15,80.66 58.15,80.04 58.25,79.94 58.66,79.94 58.76,80.04 58.76,80.66 58.86,80.76 59.27,80.76 59.37,80.66 59.37,80.04 59.47,79.94 59.88,79.94 59.98,80.04 59.98,80.66 60.08,80.76 60.49,80.76 60.59,80.66 60.59,80.04 60.69,79.94 61.1,79.94 61.2,80.04 61.2,80.66 61.3,80.76 61.71,80.76 61.81,80.66 61.81,80.04 61.91,79.94 62.32,79.94 62.42,80.04 62.42,80.66 62.52,80.76 62.93,80.76 63.03,80.66 63.03,80.04 63.13,79.94 63.54,79.94 63.64,80.04 63.64,80.66 63.74,80.76 64.15,80.76 64.25,80.66 64.25,80.04 64.35,79.94 64.71,79.94 66.78,77.88 67.41,77.88 67.51,77.98 67.51,78.49 67.61,78.59 68.02,78.59 68.12,78.49 68.12,77.98 68.22,77.88 69.36,77.88 69.64,77.6 71.47,77.6 v2(71.88,77.19)
RP_DDR4_DIMM2_ECC1: length 44
  TOP w0.102: U9.CT31 78.38,77.68 77.69,77.68 77.58,77.57 77.15,77.57 77.15,77.57 76.69,77.57 76.27,78 73.51,78 v3(72.67,77.15)
  TOP w0.114: CONN8.91 46.48,80.45 v2(46.74,80.71)
  S8 w0.102: v2(46.74,80.71) 46.74,81.31 46.56,81.48 45.01,81.48 44.79,81.27 44.79,79.72 45.07,79.44 45.55,79.44 45.66,79.54 45.66,79.93 45.76,80.04 46.16,80.04 46.27,79.93 46.27,79.54 46.37,79.44 46.77,79.44 46.87,79.54 46.87,79.93 46.98,80.04 47.38,80.04 47.48,79.93 47.48,79.54 47.59,79.44 64.25,79.44 66.29,77.39 69.15,77.39 69.78,76.76 70.79,76.76 71.09,76.46 72.26,76.46 72.67,76.87 v3(72.67,77.15)
RP_DDR4_DIMM2_ECC2: length 43.9
  TOP w0.114: v3(71.04,75.37) 71.04,75.71 71.43,76.1 76.73,76.1 76.96,75.87 U9.CV36 ; v2(49.28,77.97) 49.28,78.55 49.11,78.72 47.31,78.72 46.55,77.95 CONN8.101
  S8 w0.102: v2(49.28,77.97) 49.28,78.23 49.1,78.41 48.92,78.41 48.74,78.59 48.74,78.79 48.91,78.96 51.01,78.96 51.12,78.86 51.12,78.82 51.22,78.72 51.62,78.72 51.72,78.82 51.72,78.86 51.83,78.96 52.23,78.96 52.33,78.86 52.33,78.82 52.44,78.72 52.84,78.72 52.94,78.82 52.94,78.86 53.05,78.96 53.45,78.96 53.55,78.86 53.55,78.82 53.66,78.72 54.06,78.72 54.16,78.82 54.16,78.86 54.26,78.96 54.67,78.96 54.77,78.86 54.77,78.82 54.87,78.72 55.28,78.72 55.38,78.82 55.38,78.86 55.48,78.96 55.89,78.96 55.99,78.86 55.99,78.82 56.09,78.72 56.5,78.72 56.6,78.82 56.6,78.86 56.7,78.96 57.11,78.96 57.21,78.86 57.21,78.82 57.31,78.72 57.72,78.72 57.82,78.82 57.82,78.86 57.92,78.96 58.33,78.96 58.43,78.86 58.43,78.82 58.53,78.72 58.94,78.72 59.04,78.82 59.04,78.86 59.14,78.96 59.55,78.96 59.65,78.86 59.65,78.82 59.75,78.72 60.48,78.72 60.58,78.61 60.58,77.88 60.68,77.77 61.09,77.77 61.19,77.88 61.19,78.61 61.29,78.72 61.7,78.72 61.8,78.61 61.8,77.88 61.9,77.77 62.31,77.77 62.41,77.88 62.41,78.61 62.51,78.72 62.92,78.72 63.02,78.61 63.02,77.88 63.12,77.77 63.53,77.77 63.63,77.88 63.63,78.61 63.73,78.72 64.21,78.72 66.02,76.91 68.92,76.91 69.8,76.03 70.8,76.03 71.12,75.72 71.12,75.45 v3(71.04,75.37)
RP_DDR4_DIMM2_ECC3: length 44.2
  TOP w0.114: v2(47.62,77.97) 46.61,76.95 CONN8.105 ; v3(72.52,75.37) 72.99,75.84 76.58,75.84 76.84,75.58 77.67,75.58 77.84,75.76 78.43,75.76 U9.CT36
  S8 w0.102: v3(72.52,75.37) 71.94,74.8 69.03,74.8 68.68,74.45 63.8,74.45 62.69,75.56 57.16,75.56 56.94,75.78 51.26,75.78 49.8,77.24 46.56,77.24 46.45,77.14 46.45,76.38 46.35,76.28 45.95,76.28 45.85,76.38 45.85,77.14 45.74,77.24 45.26,77.24 45.05,77.45 45.05,78.36 45.24,78.55 47.5,78.55 47.62,78.42 v2(47.62,77.97)
RP_DDR4_DIMM2_ECC4: length 44.1
  TOP w0.102: v3(72.26,79.19) 72.96,78.49 76.45,78.49 76.59,78.35 78.05,78.35 U9.CU30
  TOP w0.114: v2(49.53,82.74) 49.53,81.95 50.03,81.45 52.02,81.45 52.27,81.2 CONN8.88
  S8 w0.102: v2(49.53,82.74) 49.53,83.18 50.1,83.74 50.58,83.74 50.68,83.64 50.68,83.34 50.78,83.24 51.19,83.24 51.29,83.34 51.29,83.64 51.39,83.74 51.8,83.74 51.9,83.64 51.9,83.34 52,83.24 52.41,83.24 52.51,83.34 52.51,83.64 52.61,83.74 53.2,83.74 53.3,83.64 53.3,82.75 53.4,82.65 53.81,82.65 53.91,82.75 53.91,83.64 54.01,83.74 54.53,83.74 54.63,83.64 54.63,83.44 54.73,83.34 55.14,83.34 55.24,83.44 55.24,83.64 55.34,83.74 55.74,83.74 55.85,83.64 55.85,83.44 55.95,83.34 56.35,83.34 56.46,83.44 56.46,83.64 56.56,83.74 63.97,83.74 67.65,80.07 68.13,80.07 68.23,80.17 68.23,80.53 68.33,80.63 68.74,80.63 68.84,80.53 68.84,80.17 68.94,80.07 69.35,80.07 69.45,80.17 69.45,80.53 69.55,80.63 69.96,80.63 70.06,80.53 70.06,80.17 70.16,80.07 72.61,80.07 72.77,79.91 72.77,79.76 72.64,79.63 72.44,79.63 72.26,79.45 v3(72.26,79.19)
RP_DDR4_DIMM2_ECC5: length 44.3
  TOP w0.089: v3(74.55,79.18) 75.02,78.71 76.59,78.71
  TOP w0.102: 76.59,78.71 76.75,78.55 77.79,78.55 77.92,78.68 78.23,78.68 78.44,78.48 78.91,78.48 U9.CR30
  TOP w0.114: v2(47.91,82.72) 46.64,81.45 CONN8.87
  S8 w0.102: v3(74.55,79.18) 75.28,79.92 76.76,79.92 77,80.16 77,80.79 76.68,81.12 67.3,81.12 64.11,84.3 47.9,84.3 47.47,83.87 47.47,83.01 47.76,82.72 v2(47.91,82.72)
RP_DDR4_DIMM2_ECC6: length 44.1
  TOP w0.114: U9.CU35 77.88,76.53 77.09,76.53 77.01,76.6 70.87,76.6 70.44,77.03 67.76,77.03 67.65,76.92 67.65,76.33 v3(68.61,75.37) ; v2(50.09,77.97) 50.09,78.21 50.62,78.74 52.04,78.74 52.58,78.2 CONN8.100
  S8 w0.102: v2(50.09,77.97) 51.54,76.53 52.02,76.53 52.12,76.42 52.12,76.37 52.22,76.27 52.63,76.27 52.73,76.37 52.73,76.42 52.83,76.53 53.24,76.53 53.34,76.42 53.34,76.37 53.44,76.27 53.85,76.27 53.95,76.37 53.95,76.42 54.05,76.53 54.46,76.53 54.56,76.42 54.56,76.37 54.66,76.27 55.07,76.27 55.17,76.37 55.17,76.42 55.27,76.53 55.68,76.53 55.78,76.42 55.78,76.37 55.88,76.27 56.29,76.27 56.39,76.37 56.39,76.42 56.49,76.53 56.9,76.53 57,76.42 57,76.37 57.1,76.27 57.51,76.27 57.61,76.37 57.61,76.42 57.71,76.53 58.46,76.53 58.56,76.42 58.56,76.15 58.67,76.05 59.18,76.05 59.28,76.15 59.28,76.63 59.39,76.73 59.79,76.73 59.89,76.63 59.89,76.15 59.99,76.05 60.4,76.05 60.5,76.15 60.5,76.63 60.6,76.73 61.01,76.73 61.11,76.63 61.11,76.15 61.21,76.05 61.62,76.05 61.72,76.15 61.72,76.63 61.82,76.73 62.23,76.73 62.33,76.63 62.33,76.15 62.43,76.05 62.92,76.05 64.03,74.93 64.52,74.93 64.62,75.03 64.62,75.62 64.72,75.72 65.13,75.72 65.23,75.62 65.23,75.03 65.33,74.93 66.34,74.93 66.44,75.03 66.44,75.46 66.54,75.56 66.95,75.56 67.05,75.46 67.05,75.03 67.15,74.93 68.38,74.93 68.61,75.16 v3(68.61,75.37)
RP_DDR4_DIMM2_ECC7: length 44.1
  TOP w0.114: CONN8.104 52.52,77.2 v2(51.73,77.99) ; v3(69.37,75.37) 69.37,75.67 69.03,76.01 69.03,76.35 69.19,76.51 70.4,76.51 70.56,76.35 76.86,76.35 77.01,76.2 77.65,76.2 77.83,76.02 78.21,76.02 78.55,76.37 79.04,76.37 U9.CR35
  S8 w0.102: v3(69.37,75.37) 69.37,75.7 68.97,76.1 65.85,76.1 64.7,77.25 64.21,77.25 64.11,77.14 64.11,76.48 64.01,76.38 63.6,76.38 63.5,76.48 63.5,77.14 63.4,77.25 59.4,77.25 59.22,77.43 59.22,77.97 59.12,78.07 58.71,78.07 58.61,77.97 58.61,77.13 58.51,77.03 58.1,77.03 58,77.13 58,77.97 57.9,78.07 57.49,78.07 57.39,77.97 57.39,77.13 57.29,77.03 56.88,77.03 56.78,77.13 56.78,77.97 56.68,78.07 56.27,78.07 56.17,77.97 56.17,77.13 56.07,77.03 54.42,77.03 54.32,77.13 54.32,78.13 54.22,78.23 53.81,78.23 53.71,78.13 53.71,77.13 53.61,77.03 53.21,77.03 53.1,77.13 53.1,78.13 53,78.23 52.6,78.23 52.49,78.13 52.49,77.13 52.39,77.03 51.91,77.03 51.73,77.2 v2(51.73,77.99)
RP_DDR4_DIMM2_I2C_SCL: length 5.4
  TOP w0.114: CONN8.253 48.63,37.95 v2(48.67,37.91)
  BOTTOM w0.114: R656.1 48.72,37.86 v2(48.67,37.91) 48.32,38.26 v1(47.77,38.26)
RP_DDR4_DIMM2_I2C_SDA: length 5.5
  TOP w0.114: v2(50.9,37.33) 51.12,37.54 52.27,37.54 52.43,37.7 CONN8.254
  BOTTOM w0.114: v2(50.9,37.33) 51.03,37.45 R649.1 51.66,38.76 v1(52.76,38.76)
RP_DDR4_DIMM2_MA0: length 44.4
  TOP w0.102: v3(70.96,66.77) 71.8,65.93 72.78,65.93 73.11,65.59 76.37,65.59 76.99,64.98 U9.CV60
  TOP w0.178: CONN8.144 52.74,67.2 51.85,66.31 50.95,66.31 50.4,65.76 v2(50.4,65.69)
  S3 w0.152: v3(70.96,66.77) 70.96,66.54 70.47,66.05 67.83,66.05 66.94,65.15 66.48,65.15 66.4,65.23 66.4,66.08 66.27,66.2 65.57,66.2 65.44,66.08 65.44,65.28 65.31,65.15 64.61,65.15 64.48,65.28 64.48,66.08 64.36,66.2 63.66,66.2 63.53,66.08 63.53,63.4 63.37,63.24 60.35,63.24 60.22,63.37 60.22,64.07 60.35,64.2 62.56,64.2 62.68,64.32 62.68,65.02 62.55,65.15 50.94,65.15 v2(50.4,65.69)
RP_DDR4_DIMM2_MA1: length 39.9
  TOP w0.102: v3(71.04,70.08) 71.87,69.25 76.9,69.25 77.08,69.43 U9.CU50
  TOP w0.178: CONN8.133 47.03,69.95 47.33,69.66 48.08,69.66 48.82,70.4 v2(48.82,70.41)
  S3 w0.152: v2(48.82,70.41) 49.82,69.41 52.1,69.41 52.25,69.56 52.25,70.31 52.4,70.46 52.76,70.46 52.91,70.31 52.91,69.56 53.06,69.41 53.42,69.41 53.57,69.56 53.57,70.31 53.72,70.46 54.08,70.46 54.23,70.31 54.23,69.56 54.38,69.41 55.31,69.41 56.64,70.73 58.59,70.73 58.74,70.58 58.74,70.33 58.9,70.18 59.25,70.18 59.41,70.33 59.41,70.58 59.56,70.73 60.28,70.73 60.78,70.23 67.55,70.23 68.28,69.49 70.84,69.49 71.04,69.7 v3(71.04,70.08)
RP_DDR4_DIMM2_MA2: length 41.1
  TOP w0.102: U9.CR50 78.54,69.43 78.21,69.1 77.71,69.1 77.58,69.23 77.16,69.23 76.99,69.05 71.08,69.05 70.28,69.85 v3(70.28,70.08)
  TOP w0.178: v2(51.49,70.41) 51.69,70.2 CONN8.132
  S5 w0.152: v3(70.28,70.08) 69.77,69.57 67.82,69.57 67.26,70.13 64.02,70.13 63.4,70.75 63.4,71.96 63.24,72.12 62.6,72.12 62.44,71.96 62.44,70.92 62.28,70.77 61.63,70.77 61.48,70.92 61.48,71.99 61.32,72.15 60.68,72.15 60.52,71.99 60.52,70.94 60.34,70.77 59.67,70.77 59.56,70.88 59.56,71.87 59.28,72.15 58.73,72.15 58.5,71.92 58.5,70.76 58.37,70.64 57.61,70.64 57.46,70.79 57.46,71.51 57.29,71.68 56.65,71.68 56.49,71.51 56.49,70.06 56.22,69.79 51.98,69.79 51.49,70.28 v2(51.49,70.41)
RP_DDR4_DIMM2_MA3: length 42.8
  TOP w0.102: U9.CT49 78.38,69.76 77.67,69.76 77.56,69.65 77.47,69.65 77.01,69.65 76.82,69.46 73.14,69.46 v3(72.52,70.08)
  TOP w0.178: CONN8.131 47.89,70.45 v2(47.94,70.41)
  S5 w0.152: v2(47.94,70.41) 47.06,70.41 46.37,71.09 45.01,71.09 44.7,70.79 44.7,69.55 44.95,69.3 56.59,69.3 56.77,69.49 67.19,69.49 67.72,68.96 70.46,68.96 70.85,69.36 71.79,69.36 v3(72.52,70.08)
RP_DDR4_DIMM2_MA4: length 43.6
  TOP w0.102: U9.CV49 76.92,69.93 76.67,69.67 74.45,69.67 v3(74.04,70.08)
  TOP w0.178: CONN8.128 52.36,71.2 52.18,71.03 50.34,71.03 v2(49.71,70.41)
  S5 w0.152: v2(49.71,70.41) 49.71,70.59 50.14,71.02 53.22,71.02 53.38,71.18 53.38,72.07 53.5,72.2 54.21,72.2 54.34,72.07 54.34,71.18 54.49,71.02 55.14,71.02 55.29,71.18 55.29,72.07 55.42,72.2 57.91,72.2 58.38,72.67 59.37,72.67 59.52,72.83 59.52,73.76 59.68,73.91 60.03,73.91 60.18,73.76 60.18,72.83 60.34,72.67 60.69,72.67 60.85,72.83 60.85,73.76 61,73.91 61.35,73.91 61.51,73.76 61.51,72.83 61.66,72.67 62.01,72.67 62.17,72.83 62.17,73.76 62.32,73.91 62.67,73.91 62.83,73.76 62.83,72.83 62.98,72.67 63.48,72.67 63.89,72.26 63.89,71.01 64.12,70.79 73.33,70.79 v3(74.04,70.08)
RP_DDR4_DIMM2_MA5: length 43.1
  TOP w0.102: U9.CR48 78.93,70.32 78.44,70.32 78.19,70.07 77.61,70.07 77.47,70.21 76.45,70.21 v3(76.33,70.08)
  TOP w0.178: v2(49.71,72.23) 50.34,71.61 51.94,71.61 52.04,71.71 53.38,71.71 CONN8.126
  S5 w0.152: v3(76.33,70.08) 76.74,70.08 77.08,70.42 77.08,71.03 76.91,71.21 73.9,71.21 73.66,71.45 64.72,71.45 64.45,71.72 64.45,72.59 64.03,73 64.03,74.52 63.02,75.54 62.16,75.54 62.01,75.39 62.01,75.29 61.86,75.13 61.5,75.13 61.35,75.29 61.35,75.39 61.2,75.54 60.84,75.54 60.69,75.39 60.69,75.29 60.54,75.13 60.18,75.13 60.03,75.29 60.03,75.39 59.88,75.54 59.36,75.54 58.84,75.02 58.84,73.39 58.65,73.2 58.15,73.2 57.63,72.69 53.3,72.69 52.17,71.56 49.98,71.56 49.71,71.83 v2(49.71,72.23)
RP_DDR4_DIMM2_MA6: length 43.6
  TOP w0.089: U9.CT47 78.38,70.75 77.91,70.75 77.8,70.64 76.85,70.64 76.59,70.89 72.82,70.89 v3(71.8,71.91)
  TOP w0.178: CONN8.127 48.04,71.45 v2(48.82,72.23)
  S3 w0.152: v2(48.82,72.23) 49.31,71.75 52.8,71.75 52.95,71.9 52.95,72.48 53.1,72.63 53.46,72.63 53.61,72.48 53.61,71.9 53.76,71.75 54.12,71.75 54.27,71.9 54.27,72.48 54.43,72.63 54.78,72.63 54.93,72.48 54.93,71.9 55.09,71.75 55.44,71.75 55.59,71.9 55.59,72.48 55.75,72.63 56.1,72.63 56.25,72.48 56.25,71.9 56.41,71.75 56.76,71.75 56.91,71.9 56.91,72.48 57.07,72.63 57.42,72.63 57.57,72.48 57.57,71.9 57.73,71.75 58.08,71.75 58.24,71.9 58.24,72.48 58.39,72.63 58.74,72.63 58.9,72.48 58.9,71.9 59.05,71.75 60.75,71.75 61.25,71.25 62.37,71.25 62.52,71.4 62.52,71.53 62.67,71.68 63.03,71.68 63.18,71.53 63.18,71.4 63.33,71.25 63.69,71.25 63.84,71.4 63.84,71.53 64,71.68 64.35,71.68 64.5,71.53 64.5,71.4 64.66,71.25 65.01,71.25 65.16,71.4 65.16,71.53 65.32,71.68 65.67,71.68 65.82,71.53 65.82,71.4 65.98,71.25 71.15,71.25 v3(71.8,71.91)
RP_DDR4_DIMM2_MA7: length 44.3
  TOP w0.089: U9.CR46 78.91,71.28 78.41,71.28 78.16,71.03 77.64,71.03 77.47,71.2 76.86,71.2 76.76,71.3 74.65,71.3 v3(74.04,71.91)
  TOP w0.178: v2(51.49,72.23) 51.55,72.29 51.95,72.29 52.36,72.7 CONN8.122
  S5 w0.152: v2(51.49,72.23) 52.04,72.23 53.01,73.2 54.27,73.2 54.42,73.36 54.42,74.59 54.58,74.75 55.22,74.75 55.38,74.59 55.38,73.36 55.54,73.2 56.14,73.2 56.34,73.4 56.34,74.49 56.52,74.68 57.12,74.68 57.3,74.5 57.3,73.88 57.47,73.7 58.16,73.7 58.34,73.88 58.34,75.43 58.11,75.67 57.64,75.67 57.42,75.88 57.42,76.49 57.63,76.7 59.47,76.7 59.62,76.54 59.62,76.25 59.78,76.1 60.13,76.1 60.28,76.25 60.28,76.54 60.44,76.7 60.79,76.7 60.94,76.54 60.94,76.25 61.1,76.1 61.45,76.1 61.6,76.25 61.6,76.54 61.76,76.7 62.6,76.7 64.62,74.68 64.62,73.2 65.35,72.47 73.71,72.47 74.04,72.14 v3(74.04,71.91)
RP_DDR4_DIMM2_MA8: length 43.3
  TOP w0.089: U9.CV47 76.85,70.92 76.68,71.09 73.35,71.09 v3(72.54,71.9)
  TOP w0.178: CONN8.125 46.2,71.95 46.21,71.96 46.22,71.96 46.42,72.16 46.42,72.17 46.48,72.23 v2(47.05,72.23)
  S3 w0.152: v3(72.54,71.9) 72.54,71.39 71.89,70.75 61.06,70.75 60.55,71.26 51.92,71.26 51.67,71.02 47.42,71.02 46.71,70.31 44.88,70.31 44.52,70.67 44.52,71.49 44.67,71.64 45.16,71.64 45.31,71.8 45.31,72.15 45.16,72.3 44.67,72.3 44.52,72.46 44.52,72.94 44.85,73.27 46.01,73.27 47.04,72.23 v2(47.05,72.23)
RP_DDR4_DIMM2_MA9: length 45
  TOP w0.102: U9.CT44 78.45,72.01 77.65,72.01 77.24,72.41 77,72.41 76.89,72.53 68.91,72.53 68.68,72.3 v3(68.68,71.91)
  TOP w0.178: CONN8.121 48.04,72.95 v2(48.82,73.74)
  S3 w0.152: v3(68.68,71.91) 68.22,72.37 64.61,72.37 63.27,73.7 62.03,73.7 61.88,73.55 61.88,72.39 61.72,72.24 61.37,72.24 61.22,72.39 61.22,73.55 61.06,73.7 60.71,73.7 60.56,73.55 60.56,72.39 60.4,72.24 60.05,72.24 59.9,72.39 59.9,73.55 59.74,73.7 59.26,73.7 59.11,73.55 59.11,73.33 58.96,73.18 58.6,73.18 58.45,73.33 58.45,73.55 58.3,73.7 57.94,73.7 57.79,73.55 57.79,73.33 57.63,73.18 57.28,73.18 57.13,73.33 57.13,73.55 56.97,73.7 56.49,73.7 56.34,73.55 56.34,73.38 56.19,73.23 55.83,73.23 55.68,73.38 55.68,73.55 55.53,73.7 55.17,73.7 55.02,73.55 55.02,73.38 54.87,73.23 54.51,73.23 54.36,73.38 54.36,73.55 54.21,73.7 53.85,73.7 53.7,73.55 53.7,73.38 53.55,73.23 53.19,73.23 53.04,73.38 53.04,73.55 52.88,73.7 52.32,73.7 51.55,72.92 48.69,72.92 48.51,73.1 48.51,73.5 48.75,73.74 v2(48.82,73.74)
RP_DDR4_DIMM2_MA10: length 43.8
  TOP w0.102: U9.CU61 76.78,64.48 76.69,64.57 75.21,64.57 v3(74.8,64.98)
  TOP w0.178: v2(52.02,65.64) 52.02,65.19 52.51,64.7 CONN8.146
  S5 w0.152: v3(74.8,64.98) 74.8,64.19 75.21,63.78 76.5,63.78 76.66,63.93 76.66,65.3 76.81,65.46 77.16,65.46 77.32,65.3 77.32,63.93 77.47,63.78 78.46,63.78 78.84,64.16 78.84,66.38 78.11,67.11 77.42,67.11 77.08,66.77 77.08,66.39 76.77,66.08 73.15,66.08 72.86,65.79 52.17,65.79 v2(52.02,65.64)
RP_DDR4_DIMM2_MA11: length 44.1
  TOP w0.089: v3(74.8,71.91) 75.21,71.5 76.85,71.5 76.95,71.4 78.04,71.4 U9.CU46
  TOP w0.178: v2(49.71,73.74) 50.57,72.88 51.67,72.88 52,73.2 CONN8.120
  S5 w0.152: v3(74.8,71.91) 74.8,72.47 74.31,72.96 69.07,72.96 68.92,73.11 68.92,73.46 68.77,73.61 68.41,73.61 68.26,73.46 68.26,73.11 68.11,72.96 67.75,72.96 67.6,73.11 67.6,73.46 67.45,73.61 67.09,73.61 66.94,73.46 66.94,73.11 66.79,72.96 65.68,72.96 65.23,73.41 65.23,77.14 64.19,78.18 62.48,78.18 62.33,78.03 62.33,77.9 62.17,77.75 61.82,77.75 61.67,77.9 61.67,78.03 61.51,78.18 61.16,78.18 61,78.03 61,77.9 60.85,77.75 60.5,77.75 60.34,77.9 60.34,78.03 60.19,78.18 59.84,78.18 59.68,78.03 59.68,77.9 59.53,77.75 59.18,77.75 59.02,77.9 59.02,78.03 58.87,78.18 58.52,78.18 58.36,78.03 58.36,77.9 58.21,77.75 57.86,77.75 57.7,77.9 57.7,78.03 57.55,78.18 56.82,78.18 51.74,73.1 50.35,73.1 v2(49.71,73.74)
RP_DDR4_DIMM2_MA12: length 34.9
  TOP w0.102: v3(70.28,71.91) 70.7,72.32 76.81,72.32 77.22,71.91 U9.CV44
  TOP w0.178: v2(47.05,73.74) 46.76,73.45 CONN8.119
  S3 w0.152: v3(70.28,71.91) 69.77,72.42 69.01,72.42 68.58,72.85 64.81,72.85 63.43,74.23 49.32,74.23 48.95,74.6 47,74.6 46.7,74.31 46.7,74.02 46.99,73.74 v2(47.05,73.74)
RP_DDR4_DIMM2_MA13: length 45.6
  TOP w0.102: v3(74.02,61.51) 74.48,61.98 76.61,61.98 76.87,61.73 77.75,61.73 78.03,62.01 U9.CT66
  TOP w0.178: v2(51.49,61.21) 51.99,61.7 CONN8.158
  S5 w0.152: v2(51.49,61.21) 52.09,60.6 55.47,60.6 55.62,60.76 55.62,61.04 55.77,61.19 56.13,61.19 56.28,61.04 56.28,60.76 56.43,60.6 58.25,60.6 58.43,60.42 58.43,59.41 58.58,59.26 59.22,59.26 59.38,59.42 59.38,60.62 59.54,60.78 60.18,60.78 60.34,60.62 60.34,59.42 60.5,59.26 61.14,59.26 61.3,59.42 61.3,60.72 61.46,60.88 62.1,60.88 62.26,60.72 62.26,59.42 62.42,59.26 63.06,59.26 63.22,59.42 63.22,60.97 63.36,61.12 64.01,61.12 64.17,60.95 64.17,59.42 64.33,59.26 64.97,59.26 65.13,59.42 65.13,60.99 65.28,61.14 65.92,61.14 66.09,60.97 66.09,59.42 66.25,59.26 66.93,59.26 67.05,59.37 67.05,60.48 67.3,60.74 67.86,60.74 68.12,61.01 73.51,61.01 v3(74.02,61.51)
RP_DDR4_DIMM2_MA14: length 43.4
  TOP w0.102: v3(68.99,64.99) 69.42,65.42 72.26,65.42 73.52,64.16 76.52,64.16 76.67,64.01 77.29,64.01 U9.CV62
  TOP w0.178: v2(47.05,63.51) 46.99,63.45 CONN8.151
  S5 w0.152: v3(68.99,64.99) 68.99,64.8 68.63,64.44 67.87,64.44 67.33,64.98 49.56,64.98 49.33,64.75 49.33,64.23 49.17,64.07 48.53,64.07 48.37,64.23 48.37,64.87 48.21,65.03 46.22,65.03 46,65.24 46,65.85 45.84,66.02 45.2,66.02 45.04,65.86 45.04,65.24 44.83,65.03 44.26,65.03 44.14,64.9 44.14,64.2 44.26,64.07 46.54,64.07 47.05,63.57 v2(47.05,63.51)
RP_DDR4_DIMM2_MA15: length 44.3
  TOP w0.102: v3(74.8,63.15) 75.21,62.74 76.96,62.74 77.06,62.64 77.72,62.64 77.91,62.83 78.38,62.83 U9.CT64
  TOP w0.178: v2(49.71,61.21) 50.71,62.2 CONN8.156
  S3 w0.152: v3(74.8,63.15) 74.8,63.62 74.39,64.03 67.88,64.03 67.54,63.7 65.89,63.7 63.98,61.78 55.75,61.78 55.6,61.94 55.6,62.69 55.44,62.84 55.09,62.84 54.94,62.69 54.94,61.94 54.78,61.78 54.43,61.78 54.27,61.94 54.27,62.69 54.12,62.84 53.77,62.84 53.61,62.69 53.61,61.94 53.46,61.78 52.77,61.78 52.62,61.94 52.62,62.9 52.49,63.03 51.79,63.03 51.66,62.9 51.66,61.94 51.5,61.78 50.85,61.78 50.73,61.91 50.73,62.51 50.46,62.77 48.95,62.77 48.82,62.64 48.82,61.94 48.94,61.82 49.38,61.82 49.71,61.49 v2(49.71,61.21)
RP_DDR4_DIMM2_MA16: length 42.3
  TOP w0.102: v3(72.1,65) 72.1,64.31 72.45,63.96 76.44,63.96 76.59,63.81 76.93,63.81 76.96,63.78 77.03,63.71 77.47,63.71 77.71,63.94 78.5,63.94 U9.CT62
  TOP w0.178: CONN8.152 52.04,63.2 v2(51.73,63.51)
  S5 w0.152: v2(51.73,63.51) 52.23,64.01 56.21,64.01 56.73,63.48 58.28,63.48 58.43,63.64 58.43,64.34 58.59,64.49 58.94,64.49 59.09,64.34 59.09,63.64 59.25,63.48 59.6,63.48 59.75,63.64 59.75,64.34 59.91,64.49 60.26,64.49 60.41,64.34 60.41,63.64 60.57,63.48 60.92,63.48 61.08,63.64 61.08,64.34 61.23,64.49 61.58,64.49 61.74,64.34 61.74,63.64 61.89,63.48 62.24,63.48 62.4,63.64 62.4,64.34 62.55,64.49 62.9,64.49 63.06,64.34 63.06,63.64 63.21,63.48 63.56,63.48 63.72,63.64 63.72,64.34 63.87,64.49 64.22,64.49 64.38,64.34 64.38,63.64 64.53,63.48 64.89,63.48 65.04,63.64 65.04,64.34 65.19,64.49 65.55,64.49 65.7,64.34 65.7,63.64 65.85,63.48 66.21,63.48 66.36,63.64 66.36,64.34 66.51,64.49 66.87,64.49 67.02,64.34 67.02,63.64 67.17,63.48 70.58,63.48 v3(72.1,65)
RP_DDR4_DIMM2_ODT0: length 43.2
  TOP w0.102: v3(69.77,64.98) 69.77,64.59 70.81,63.55 76.18,63.55 76.74,63 U9.CV64
  TOP w0.178: v2(48.82,63.51) 47.85,62.54 46.29,62.54 46.21,62.45 CONN8.155
  S3 w0.152: v3(69.77,64.98) 69.29,64.49 67.65,64.49 67.34,64.18 65.69,64.18 63.78,62.27 56.64,62.27 56.26,62.65 56.26,63.99 56.07,64.18 49.85,64.18 49.54,64.49 46.71,64.49 46.3,64.08 46.3,63.02 46.61,62.71 48.03,62.71 v2(48.82,63.51)
RP_DDR4_DIMM2_ODT1: length 40.8
  TOP w0.102: U9.CR69 78.54,60.52 78.2,60.19 77.78,60.19 77.61,60.36 76.97,60.36 76.28,61.06 75.26,61.06 v3(74.8,61.51)
  TOP w0.178: v2(47.05,61.21) 46.79,60.95 CONN8.161
  S5 w0.152: v3(74.8,61.51) 74.8,60.93 74.32,60.45 68.37,60.45 67.55,59.63 67.55,59.11 67.22,58.77 58.2,58.77 56.82,60.14 54.37,60.14 54.1,59.87 52.6,59.87 52.32,60.14 45.95,60.14 45.66,60.44 45.66,61 45.86,61.21 v2(47.05,61.21)
RP_DDR4_DIMM2_R_EVENT_L: length 6.2
  TOP w0.114: CONN8.134 54.69,69.7 55.55,68.84 v2(55.55,67.23)
  BOTTOM w0.114: v2(55.55,67.23) 55.55,66.62 R574.1 55.39,66.27 v1(56.4,66.27)
RP_DDR4_DIMM2_R_RST_L: length 6.1
  TOP w0.114: v2(56.22,75.31) 56.22,75.81 55.84,76.2 CONN8.108
  BOTTOM w0.114: v2(56.22,75.31) 56.34,75.44 R546.1 v1(57.28,76.96)
RP_DDR4_DIMM2_SA0: length 7
  TOP w0.114: CONN8.256 51.75,37.2 v2(51.18,36.63)
  BOTTOM w0.114: v2(51.18,36.63) 50.97,36.42 R678.1 ; R678.1 50.72,35.1 50.14,34.52 50.14,34.11 v1(49.76,33.73) ; R678.1 R679.1
RP_DDR4_DIMM2_SA1: length 9.7
  TOP w0.114: CONN8.260 52.42,36.2 v2(52.07,35.85)
  BOTTOM w0.114: v2(52.07,35.85) 52.82,35.1 R880.1 R681.1 54.56,35.48 54.56,38.46 54.94,38.84 v1(54.94,39.55) R680.1
RP_DDR4_DIMM2_SA2: length 63.1
  TOP w0.114: v2(51.59,59.64) 51.65,59.7 CONN8.166
  S3 w0.102: v2(51.59,59.64) 50.88,60.35 37.92,60.35 37.64,60.63 31.86,60.63 30.45,59.23 30.45,36.84 32.47,34.82 34.4,34.82 34.99,34.24 43.1,34.24 v2(44.07,35.2)
  BOTTOM w0.114: R688.1 R689.1 v2(44.07,35.2)
RP_DDR4_DMIM2_PAR: length 44.9
  TOP w0.102: v3(72.52,66.61) 72.55,66.61 73.37,65.8 76.7,65.8 77.01,65.48 77.24,65.48 77.61,65.12 78.2,65.12 78.39,65.32 78.88,65.32 U9.CR59
  TOP w0.178: v2(46.61,67.25) 46.15,67.25 45.94,67.45 CONN8.143
  S5 w0.152: v3(72.52,66.61) 72.15,66.25 48.78,66.25 48.53,66.5 47.84,66.5 47.56,66.78 47.56,67.98 46.72,68.83 46.08,68.83 45.93,68.68 45.93,68.03 45.77,67.87 45.42,67.87 45.27,68.01 45.27,68.68 45.12,68.83 44.64,68.83 44.3,68.49 44.3,66.98 44.66,66.61 45.97,66.61 v2(46.61,67.25)
RP_DDR4_I2C_SCL: length 101.2
  S10 w0.102: v2(36.71,37.35) 37.3,36.75 39.78,36.75 41.61,38.58 44.09,38.58 46.41,36.27 v2(47.04,36.27) 47.04,35.92 45.03,33.91 45.03,33.12 44.24,32.33 43.75,32.33 43.19,31.78 43.19,29.08 45.15,27.13 52.83,27.13 54.18,25.78 54.18,22.26 55.28,21.16 56.36,21.16 56.79,21.59 60.15,21.59 60.87,20.88 62.59,20.88 67.26,25.55 72.26,25.55 73.4,26.7 83.06,26.7 84.15,25.6 89.2,25.6 90.65,27.05 90.65,35.59 93.17,38.1 93.17,39.37 v2(91.98,40.56)
  BOTTOM w0.114: R877.2 90.14,39.55 91.15,40.56 v2(91.98,40.56) U36.7 91.98,37.81 R657.2 ; R647.2 36.86,37.5 v2(36.71,37.35) ; R656.2 47.81,37.04 v2(47.04,36.27)
RP_DDR4_I2C_SDA: length 102.3
  S10 w0.102: v2(37.71,37.33) 39.42,39.04 44.4,39.04 45.14,38.3 46.66,38.3 48.08,36.88 v2(49.76,36.88) 48.31,35.43 47.27,35.43 45.26,33.43 45.26,33.03 44.96,32.72 44.96,31.42 44.56,31.02 43.85,31.02 43.42,30.59 43.42,29.18 45.24,27.36 52.93,27.36 54.41,25.88 54.41,22.35 55.37,21.39 56.26,21.39 56.69,21.82 60.25,21.82 60.96,21.11 62.49,21.11 67.16,25.78 72.16,25.78 73.3,26.92 83.15,26.92 84.24,25.83 89.08,25.83 90.42,27.18 90.42,36.1 v2(92.63,38.3)
  BOTTOM w0.114: R649.2 50.12,37.24 v2(49.76,36.88) ; R878.2 90.12,41.05 92.33,41.05 92.63,40.75 U36.6 v2(92.63,38.3) 92.63,38.14 93.16,37.61 R658.2 ; R648.2 37.76,37.38 v2(37.71,37.33)
RP_DDR4_R_0_I2C_SCL: length 2.9
  TOP w0.114: CONN7.253 v2(35.05,37.95)
  BOTTOM w0.114: R647.1 35.28,38.18 v2(35.05,37.95)
RP_DDR4_R_0_I2C_SDA: length 3.2
  TOP w0.114: CONN7.254 40.42,37.7 40.13,37.41 v2(39.43,37.41)
  BOTTOM w0.114: v2(39.43,37.41) 38.67,38.18 R648.1
RP_DDR_I2C_EN: length 3.3
  BOTTOM w0.114: R879.2 R659.2 94.03,37.53 v1(94.03,38.43) 93.28,39.18 U36.5
RP_DDR_I2C_SCL: length 8.7
  BOTTOM w0.114: 91.87,42.61 v1(89.65,42.61) ; 91.87,42.61 92.54,42.61 93.89,41.25 R638.2 ; 91.87,42.61 91.98,42.71 U36.2 91.98,45.64 R621.2
RP_DDR_I2C_SDA: length 6.1
  BOTTOM w0.114: v1(94.87,43.33) 94.69,43.16 R633.2 94.34,42.67 93.17,42.67 92.63,43.21 U36.3 92.63,45.36 R622.2
RP_DDR_R_I2C_SCL: length 29.6
  TOP w0.114: U9.CD58 v4(84.23,65.45)
  S10 w0.102: v2(93.95,48.54) 92.89,49.61 92.89,56.96 92.29,57.56 92.29,58.43 91.55,59.18 91.55,59.31 91.08,59.77 91.08,61.96 91.55,62.43 91.55,62.74 91.08,63.21 91.08,64.03 88.39,66.73 84.81,66.73 84.23,66.15 v4(84.23,65.45)
  BOTTOM w0.114: R621.1 91.97,47 v1(92.72,47.75) 93.51,48.54 v2(93.95,48.54)
RP_DDR_R_I2C_SDA: length 29.2
  TOP w0.114: U9.CC60 v4(84.73,64.59)
  S10 w0.102: v4(84.73,64.59) 84.73,66.16 85.04,66.47 88.09,66.47 90.29,64.27 90.29,63.28 90.63,62.95 90.63,62.22 90.29,61.88 90.29,61.57 90.63,61.23 90.63,60.5 90.29,60.17 90.29,59.85 90.63,59.51 90.63,59.11 91.3,58.43 91.3,58.05 92.41,56.95 92.41,48.79 v2(93.95,47.24)
  BOTTOM w0.114: R622.1 93.27,46.56 v2(93.95,47.24)
RP_JTAG_R_CPU_TCK: length 12
  TOP w0.102: U9.T76 106.4,56.92 106.4,56.18
  TOP w0.114: 106.4,56.18 107.04,55.55 107.04,53.74 107.73,53.04 107.86,53.04 108.21,52.7 108.21,52.21 108.2,52.2 108.2,49.66 107.86,49.32 107.72,49.32 107.62,49.23 ; 107.62,49.23 v2(107.61,49.23) ; 107.62,49.23 107.98,48.87 R255.1
  BOTTOM w0.114: v2(107.61,49.23) 107.62,49.22 107.96,49.22 108.2,49.46 v1(108.2,50.8)
RP_JTAG_R_CPU_TDI: length 5.3
  TOP w0.114: R248.1 v2(105.46,52.48) 105.46,52.93 105.23,53.16 105.23,54.43 105.28,54.48 U9.V78
  BOTTOM w0.114: v1(105.92,53.21) 105.92,52.93 v2(105.46,52.48)
RP_JTAG_R_CPU_TDO: length 5.7
  TOP w0.114: U9.T78 106.78,55.31 106.78,53.29 v2(107.62,52.45) 107.49,52.32 R243.2
  BOTTOM w0.114: v2(107.62,52.45) 107.95,52.78 v1(107.95,53.21)
RP_JTAG_R_CPU_TMS: length 7.7
  TOP w0.102: 107.54,54.94 107.54,56 107.11,56.43 107.11,56.71 106.91,56.91 106.91,57.41 U9.R75
  TOP w0.114: R242.1 v2(108.79,52.53) 108.79,53.07 108.15,53.71 108.15,54.33 107.54,54.94
  BOTTOM w0.114: v1(109.12,51.77) 109.12,52.2 v2(108.79,52.53)
RP_JTAG_R_CPU_TRST_L: length 8
  TOP w0.102: 105.56,54.43 105.56,56.13 105.38,56.31 105.38,56.67 105.64,56.93 105.64,57.42 U9.U75
  TOP w0.114: 105.56,54.43 105.49,54.36 105.49,53.42 v2(106.45,52.45) 106.32,52.32 R246.2
  BOTTOM w0.114: v2(106.45,52.45) 106.45,52.12 107.1,51.47 v1(107.1,51.43)
RP_JTAG_TCK_PCH: length 21.8
  TOP w0.102: 89.31,90.85 89.31,91.38 89.72,91.79 89.72,92.33 89.55,92.5
  TOP w0.114: U9.BM3 89.31,90.85 ; 89.55,92.5 89.55,93.28 88.9,93.93 88.9,95.38 85.67,98.6 84.14,98.6 82.05,100.7 80.34,100.7 78.76,102.28 v2(78.76,103.23)
  BOTTOM w0.114: R476.2 v2(78.76,103.23) 78.36,102.83 v1(78.36,101.57)
