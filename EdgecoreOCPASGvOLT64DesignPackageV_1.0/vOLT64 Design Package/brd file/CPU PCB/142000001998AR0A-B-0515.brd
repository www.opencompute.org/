# Allegro board 142000001998AR0A-B-0515.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
C105_CPU_PCH_PLTRST_N_R: length 4.2
  TOP w0.114: v2(171.12,84.43) 170.6,84.95 R169.2
  BOTTOM w0.114: U34.5 171.5,84.05 v2(171.12,84.43) 170.6,84.95 R169.2 v1(170.23,85.9)
C105_PCHHOT_N: length 99.7
  TOP w0.114: R238.2 v2(99.98,49.96) ; v2(178.1,65.81) 178.03,65.74 U13.14
  S3 w0.102: v2(99.98,49.96) 100.53,49.41 100.53,48.62 99.44,47.52 99.44,47.32 99.54,47.22 100.17,47.22 100.44,46.95 100.44,46.33 100.61,46.16 100.61,45.86 100.87,45.6 102.86,45.6 103.02,45.44 103.6,45.44 103.93,45.11 115.46,45.11 116.52,46.18 117.72,46.18 117.83,46.29 119.46,46.29 120.31,47.14 v2(122.76,47.14)
  S8 w0.102: v2(122.76,47.14) 122.76,47.7 123.76,48.7 123.76,49.37 130.01,55.62 154.96,55.62 155.44,55.14 165.59,55.14 170.54,60.09 170.54,65.79 170.99,66.24 177.86,66.24 178.1,66 v2(178.1,65.81)
  BOTTOM w0.114: R572.2 v2(178.1,65.81)
C105_PCHHOT_N_R: length 5.9
  TOP w0.114: U9.AL76 99.34,56.49 99.77,56.06 99.77,54.46 100.23,54 100.23,51.91 R238.1
CI_KGI_SELECT: length 16.3
  TOP w0.114: v2(57.2,118.21) 56.99,118 CONN2.2 55.68,121.21 54.53,122.35 46.61,122.35 45.76,121.5 CONN3.3
CLK_33M_BMM: length 203.4
  TOP w0.114: v2(114.53,98.6) 114.45,98.52 R128.1
  S5 w0.102: v2(16.23,76.06) 16.55,75.73 16.55,71.94 15.83,71.21 12.01,71.21 10.21,73.01 10.21,114.95 16.36,121.11 23.06,121.11 24.28,122.33 110.69,122.33 112.85,120.17 112.85,114.48 114.02,113.32 114.02,99.11 v2(114.53,98.6)
  BOTTOM w0.114: CONN14.10 14.65,75.98 14.73,76.06 v2(16.23,76.06) 16.23,80.75 17.39,81.9 22.25,81.9 23.96,83.61 27.15,83.61 v1(27.41,83.87)
CLK_33M_BMM_R: length 18.1
  TOP w0.114: v4(104.06,86.66) 104.04,86.68 U9.Y11 ; R128.2 114.09,97.62 v2(114.38,97.33)
  S5 w0.102: v2(114.38,97.33) 114.37,97.34 114.02,97.34 110.52,93.83 109.25,93.83 107.14,91.72 107.14,88.57 105.23,86.66 v4(104.06,86.66)
CLK_33M_CPLD: length 215.6
  TOP w0.114: v2(204.9,57.53) 204.56,57.19 204.39,57.19 204.31,57.11 U12.F16 ; v2(114.71,100.39) 114.33,100.39 113.21,101.51 110.33,101.51 109.3,102.54 108.58,102.54 107.27,101.23 105.36,101.23 R123.1
  S3 w0.102: v2(198.5,15.62) 199.69,16.81 199.69,22.32 207.21,29.84 207.21,55.22 v2(204.9,57.53)
  S10 w0.102: v2(204.9,57.53) 204.9,67.18 198.86,73.23 196.93,73.23 189.08,81.08 186.51,81.08 184.74,82.84 183.91,82.84 180.75,86.01 180.75,88.98 175.64,94.08 175.64,97.76 172.57,100.84 172.57,115.71 171.56,116.71 170.1,116.71 169.75,116.36 167.06,116.36 166.68,116.73 154.49,116.73 152.28,118.95 142.72,118.95 139.34,122.33 120.56,122.33 119.51,121.27 119.51,118.62 118.5,117.61 116.33,117.61 114.71,115.99 v2(114.71,100.39)
  BOTTOM w0.114: R641.2 v2(198.5,15.62)
CLK_33M_LPC: length 46.3
  TOP w0.108: U9.AC67 102.85,61.44 v4(102.56,61.73)
  TOP w0.114: R141.1 v2(105.61,96.83)
  S8 w0.102: v4(102.56,61.73) 102.68,61.73 103.4,62.45 103.4,62.89 104.39,63.88 105,63.88 106.41,65.29 106.41,67.07 106.81,67.47 106.81,71.93 105.54,73.2 105.54,73.55 105.92,73.93 105.92,74.25 105.17,74.99 105.17,75.89 105.54,76.25 105.54,79.5 105.03,80.01 105.03,84.71 105.8,85.48 105.8,88.15 101.07,92.89 101.07,94.18 101.68,94.79 103.58,94.79 105.61,96.82 v2(105.61,96.83)
  BOTTOM w0.114: R507.1 v2(105.61,96.83)
CLK_33M_LPC_PORT80: length 5.1
  BOTTOM w0.114: R641.1 198.5,13.21 198.78,12.93 v1(199.82,12.93) 200.38,12.37 CONN15.3
CLK_33M_LPC_R: length 2.3
  BOTTOM w0.114: R507.2 105.73,94.86 R906.1 v1(107.89,94.86)
CLK_33M_LPC_TPM: length 172.1
  TOP w0.114: v2(117.53,99.21) 116.93,99.8 114.1,99.8 112.9,101 111.45,101 111.45,101.01 108.87,101.01 108.59,100.73 106.32,100.73 105.94,100.35 105.94,99.01 105.45,98.52 103.74,98.52 103,99.27 v2(103,99.5)
  TOP w0.127: U17.21 175.96,19.23 175.05,20.15 175.05,22.19 174.27,22.96 174.27,23.67 v2(175.06,24.46)
  S5 w0.102: v2(166.55,93.57) 166.55,93.2 182.12,77.63 182.12,67.87 182.78,67.21 182.78,65.02 180.77,63.02 180.77,41.55 183.41,38.91 183.41,32.12 179.46,28.17 179.41,28.17 177.55,26.31 177.55,26.25 175.75,24.46 v2(175.06,24.46)
  S10 w0.102: v2(166.55,93.57) 166.55,94.11 164.82,95.83 161.95,95.83 157.02,100.76 152.22,100.76 143.13,109.86 132.61,109.86 130.3,107.54 120.83,107.54 118.41,105.13 118.41,101.98 117.53,101.09 v2(117.53,99.21)
  BOTTOM w0.114: v2(103,99.5) 103.04,99.5 103.72,100.19 R486.1
CLK_33M_R_CPLD: length 19
  TOP w0.109: v4(105.05,87.76) 105.05,87.57 105.04,87.56 U9.V11
  TOP w0.114: R123.2 104.98,99.44 v2(105.26,99.16)
  S8 w0.102: v2(105.26,99.16) 102.36,96.27 100.05,96.27 99.39,95.61 99.39,94.03 105.05,88.37 v4(105.05,87.76)
CLK_33M_R_LPC: length 5.8
  TOP w0.109: U9.AA4 103.79,90.72 104.17,91.09 104.17,91.46 103.91,91.72 103.91,92.23 104.06,92.38 104.06,93.29 104.65,93.88 v3(104.65,93.98)
  TOP w0.114: v3(104.65,93.98) 105.61,94.95 R141.2
CLK_33M_R_TPM: length 18.1
  TOP w0.109: v4(103.08,88.33) 103.08,88.35 103.42,88.7 103.83,88.7 U9.Y7
  TOP w0.114: R122.2 v2(103.99,99.11)
  S8 w0.102: v4(103.08,88.33) 103.08,89.78 98.91,93.95 98.91,95.94 100.08,97.1 102.52,97.1 103.99,98.57 v2(103.99,99.11)
CLK_33M_TPM: length 3
  TOP w0.114: R122.1 103.13,100.85 102.82,100.53 v2(102.82,100.41)
  BOTTOM w0.114: v2(102.82,100.41) 102.82,100.53 103.39,101.1 R486.2
CLK_50M: length 6.3
  TOP w0.114: C22.2 163.07,120.2 R78.2 ; C22.2 162,120.27 U5.5 ; C22.2 162.36,120.9 v2(161.34,120.9)
  BOTTOM w0.114: v1(161.23,119.71) 161.34,119.82 v2(161.34,120.9)
CLK_50M_R: length 3.4
  TOP w0.114: R853.1 R78.1 v2(164.08,118.16) 164.12,118.2 OSC1.3
CLK_100M_XDPCPU_N: length 278.4
  TOP w0.127: R130.1 v3(110.79,99.16) ; CONN11.42 34.89,8.34 v3(35.28,7.95)
  S10 w0.102: v3(110.79,99.16) 110.36,99.16 110.26,99.26 110.26,101.5 109.63,102.13 109.63,106.91 101.55,114.99 101.55,115.52 96.29,120.78 52.08,120.78 51.57,120.27 39.78,120.27 39.12,119.61 15.18,119.61 11.86,116.29 11.86,91.61 19.91,83.57 26.74,83.57 27.69,82.62 27.69,78.75 27.69,78.75 27.69,78.37 27.69,78.37 27.69,74.57 27.43,74.32 25.87,74.32 24.71,73.16 24.71,69.04 24.36,68.68 13.72,68.68 6.35,61.32 6.35,14.76 14.83,6.27 34.15,6.27 34.74,6.87 34.74,7.85 34.85,7.95 v3(35.28,7.95)
CLK_100M_XDPCPU_P: length 278.4
  TOP w0.127: v3(34.01,7.95) 34.39,8.34 CONN11.40 ; R129.1 v3(109.52,99.16)
  S10 w0.102: v3(34.01,7.95) 34.44,7.95 34.54,7.85 34.54,6.96 34.06,6.48 14.92,6.48 6.55,14.84 6.55,61.23 13.8,68.48 24.44,68.48 24.92,68.95 24.92,73.08 25.96,74.12 27.52,74.12 27.89,74.49 27.89,78.28 27.89,78.29 27.89,78.83 27.89,78.84 27.89,82.71 26.83,83.77 19.99,83.77 12.06,91.69 12.06,116.2 15.27,119.41 39.2,119.41 39.87,120.07 51.66,120.07 52.17,120.57 96.21,120.57 101.35,115.44 101.35,114.9 109.42,106.82 109.42,104.58 109.32,104.48 109.07,104.48 108.97,104.38 108.97,103.97 109.07,103.87 109.32,103.87 109.42,103.77 109.42,103.36 109.32,103.26 109.07,103.26 108.97,103.16 108.97,102.75 109.07,102.65 109.32,102.65 109.42,102.55 109.42,102.05 110.06,101.41 110.06,99.26 109.96,99.16 v3(109.52,99.16)
CLK_100M_XDPCPU_R_N: length 9.1
  TOP w0.127: v4(109.37,91.26) 109.42,91.21 U9.H2 ; R130.2 v3(110.79,96.67)
  S10 w0.102: v3(110.79,96.67) 110.36,96.67 110.26,96.57 110.26,95.57 109.19,94.51 109.19,94.06 109.3,93.96 109.52,93.96 109.63,93.86 109.63,93.45 109.52,93.35 109.3,93.35 109.19,93.25 109.19,92.84 109.3,92.74 109.52,92.74 109.63,92.64 109.63,92.23 109.52,92.13 109.3,92.13 109.19,92.03 109.19,91.44 v4(109.37,91.26)
CLK_100M_XDPCPU_R_P: length 9.1
  TOP w0.127: v4(109.98,90.7) 109.73,90.45 U9.H4 ; R129.2 v3(109.52,96.67)
  S10 w0.102: v3(109.52,96.67) 109.96,96.67 110.06,96.57 110.06,95.66 108.99,94.59 108.99,91.06 109.35,90.7 v4(109.98,90.7)
CLK_BUF_50M_BMM: length 188.9
  TOP w0.114: v2(160.91,112.52) 160.04,111.65 v2(149.48,111.65) ; v3(29.21,84.33) 29.21,82.27 24.11,77.17 24.11,65.03 v2(24.11,65.03)
  BOTTOM w0.114: v2(160.91,112.52) 160.91,113.59 C41.1 R119.1 ; v2(149.48,111.65) 149.46,111.63 147.59,111.63 139.53,119.7 128.18,119.7 126.76,118.27 116.8,118.27 116.56,118.52 114.08,118.52 113.63,118.07 113.04,118.07 112.74,117.77 112.58,117.77 112.37,117.57 111.95,117.57 111.8,117.42 107.88,117.42 107.47,117.42 106.98,116.93 105.8,116.93 105.41,117.32 105.41,117.32 105.31,117.42 104.79,117.42 104.55,117.66 101.41,117.66 98.94,120.13 61.66,120.13 56.55,115.02 51.1,115.02 49.44,113.36 41.54,113.36 30.41,102.22 30.41,85.53 v1(30.16,85.28) v3(29.21,84.33) ; v2(24.11,65.03) 23.14,65.03 23,64.88 CONN14.47
CLK_BUF_50M_BMM_R: length 2.6
  TOP w0.114: U5.3 v2(160.07,115.82)
  BOTTOM w0.114: v2(160.07,115.82) 160.02,115.77 R119.2
CLK_BUF_EN: length 8.3
  TOP w0.114: U5.8 v2(157.53,121.01)
  S3 w0.102: v2(152.12,119.67) 153.45,121.01 v2(157.53,121.01)
  BOTTOM w0.114: R465.1 157.53,120.9 157.53,120.91 v2(157.53,121.01)
CLK_BUF_Q2_RSV: length 14.5
  TOP w0.114: U5.6 v2(160.07,120.98)
  S3 w0.102: v2(149.15,119.71) 151.33,121.88 159.17,121.88 v2(160.07,120.98)
  BOTTOM w0.114: R1045.2 160.02,120.93 v2(160.07,120.98)
CLK_BUF_Q3_RSV: length 11.5
  TOP w0.114: U5.7 v2(158.8,120.98)
  S3 w0.102: v2(150.73,119.68) 152.7,121.65 158.13,121.65 v2(158.8,120.98)
  BOTTOM w0.114: v2(158.8,120.98) 158.8,120.08 R468.2
CLK_M2_SUSCLK: length 28
  TOP w0.114: v2(92.13,109.91) 91.43,110.6 R41.2 ; v4(93.63,87.48) 93.43,87.48 U9.BD11
  S10 w0.102: v4(93.63,87.48) 93.63,88.57 94.26,89.2 94.26,102.54 92.35,104.44 92.35,109.68 v2(92.13,109.91)
  BOTTOM w0.114: v2(92.13,109.91) 92.35,109.68 93.92,109.68 v1(94.57,110.32)
CLR CMOS: length 4.1
  TOP w0.114: CONN17.3 135.89,117.22 136.53,116.59 v2(137.16,116.59)
  BOTTOM w0.114: R800.1 136.6,117.15 v2(137.16,116.59)
CONN12_GND: length 2.8
  TOP w0.114: CONN12.1 v2(118.19,4.17)
  BOTTOM w0.114: CONN12.1 v2(118.19,4.17)
CPLD23_INT_CPU: length 256.8
  TOP w0.114: U12.K6 v3(193.09,52.61) ; v2(139.04,10.46) 138.63,10.06 138.63,8.76 139.04,8.36 145.31,8.36 147.4,6.27 147.4,3.2 147.89,2.71 158.3,2.71 158.99,3.39 160.32,3.39 162,5.07 162.95,5.07 v2(163.93,4.09) ; R48.1 v2(101.06,111.13)
  S3 w0.102: v2(101.06,111.13) 102.01,110.19 103.86,110.19 104.17,109.88 104.17,108.86 105.29,107.74 107.99,107.74 108.33,107.4 110.92,107.4 114.68,103.64 114.68,102.74 115.57,101.85 117.02,101.85 122.23,96.65 130.63,96.65 131.01,97.03 133.99,97.03 134.39,97.43 155.74,97.43 157.09,98.78 160.68,98.78 163.27,101.37 165.75,101.37 170.36,96.77 170.36,82.41 175.81,76.96 180.53,76.96 188.16,69.33 v2(188.16,67.06)
  S10 w0.102: v2(188.16,67.06) 188.14,67.06 187.2,66.12 187.2,56.41 188.65,54.97 191.85,54.97 192.56,54.25 192.56,53.31 193.09,52.78 v3(193.09,52.61) 193.09,52.15 192.71,51.77 192.71,51.45 192.41,51.16 191.92,51.16 191.47,50.71 191.47,50.45 191.05,50.04 186.23,50.04 185.7,49.5 185.7,41.31 187.83,39.17 187.83,33.96 187.78,33.91 187.78,16.61 185.2,14.02 184.79,14.02 184.23,13.46 169.09,13.46 168.76,13.13 168.76,8.92 v2(163.93,4.09)
  BOTTOM w0.114: v1(185.34,67.11) 185.64,66.8 187.91,66.8 v2(188.16,67.06)
  BOTTOM w0.127: CONN16.91 136.1,8.56 135.99,8.67 135.99,9.3 137.36,10.67 138.84,10.67 v2(139.04,10.46)
CPLD23_INT_CPU_R: length 43.1
  TOP w0.114: R48.2 101.06,109.04 101.09,109.01 101.09,108.89 v2(101.22,108.76) ; U9.BA21 94.75,82.39 v4(95.16,81.98)
  S5 w0.102: v4(95.16,81.98) 95.53,81.61 98.51,81.61 99.9,83 99.9,84.62 101.12,85.84 101.12,87.66 101.43,87.97 101.43,88.77 100.91,89.28 100.91,89.33 98.5,91.74 95.77,91.74 94.18,93.33 94.18,99.09 100.33,105.24 100.33,106.22 100.76,106.65 100.76,108.31 v2(101.22,108.76)
  BOTTOM w0.114: R48.2 101.06,109.04 101.09,109.01 101.09,108.89 v2(101.22,108.76) 101.06,108.61 101.06,108.3 v1(101.7,107.66)
CPLD_ADR_STATUS_RD: length 176.7
  TOP w0.114: v2(81.64,112.24) 81.64,113.23 80.67,114.2 80.67,117.91 84.15,121.39 112.77,121.39 114.14,120.02 v2(114.94,120.02) ; U12.D11 v3(199.09,59.61)
  S3 w0.102: v2(114.94,120.02) 116.41,118.54 134.32,118.54 139.63,113.23 158.93,113.23 159.61,112.55 159.61,111.25 162.86,108 169.47,108 176.26,101.21 192.32,101.21 195.48,98.04 195.48,82.68 200.45,77.71 200.45,68.16 199.18,66.88 199.18,65.23 198.63,64.68 198.63,60.1 199.09,59.64 v3(199.09,59.61)
  BOTTOM w0.114: v1(115.37,119.27) 115.37,119.45 114.94,119.89 v2(114.94,120.02) ; R450.1 81.46,112.06 v2(81.64,112.24)
CPLD_BDX_CPU_RSMRST: length 24.4
  TOP w0.114: v2(174.57,60.88) 174.7,61.01 U13.6 ; U12.J3 v3(190.09,53.61)
  S3 w0.102: v2(174.57,60.88) 175.69,62 177.37,62 184.99,54.38 189.32,54.38 v3(190.09,53.61)
  BOTTOM w0.114: v2(174.57,60.88) 174.57,61.8 174.98,62.21 v1(175.03,62.21) ; v1(189.28,54.61) 190.09,53.8 v3(190.09,53.61)
CPLD_BDX_PWRGOOD_CPU: length 39.4
  TOP w0.114: U12.F7 v3(194.09,57.61)
  BOTTOM w0.114: v3(194.09,57.61) 193.61,58.09 187.83,58.09 181.97,63.96 181.97,75.41 177.65,79.73 177.65,82.52 176.94,83.24 v1(176.28,83.24) 176.25,83.21 175.87,83.21 175.53,83.55 U34.13
CPLD_CLK_25M: length 14.3
  TOP w0.114: R172.1 v2(197.36,44.45) ; U12.J12 v3(200.09,53.61)
  BOTTOM w0.114: v1(197.36,43.29) v2(197.36,44.45) 198.07,44.45 198.33,44.71 198.48,44.71 198.91,45.14 198.91,45.26 199.16,45.52 199.16,46.25 199.64,46.74 200.28,46.74 200.61,47.07 200.61,53.09 v3(200.09,53.61)
CPLD_CLK_25M_R: length 3.2
  TOP w0.114: OSC4.3 196.99,41.63 v2(197.4,42.04) 197.4,42.68 R172.2
  BOTTOM w0.114: v1(197.4,41.13) v2(197.4,42.04)
CPLD_CONFIG_CLK: length 171.2
  TOP w0.114: R82.1 v2(85.55,107.52) ; U12.D9 v3(197.09,59.61)
  S3 w0.102: v2(85.55,107.52) 84.18,108.89 84.18,111.62 82.66,113.13 82.21,113.13 81.94,113.4 81.94,114.21 85.36,117.63 88.87,117.63 89.76,118.52 94.77,118.52 95.25,118.03 99.67,118.03 99.83,118.2 101.03,118.2 101.85,117.37 104.13,117.37 105.23,116.27 105.23,115.46 106.37,114.32 110.61,114.32 111.23,114.94 114.99,114.94 115.47,115.42 115.47,116.92 116.2,117.65 125.68,117.65 126.75,116.59 126.75,113.96 127.97,112.73 132.69,112.73 133.1,112.32 134.06,112.32 135.89,110.49 148.25,110.49 149.9,108.84 151.13,108.84 154.33,105.64 169.25,105.64 175.35,99.53 175.35,94.23 180.57,89.01 185.01,89.01 194.55,79.48 194.55,68.73 196.66,66.63 196.66,60.04 v3(197.09,59.61)
  BOTTOM w0.114: v1(196.13,59.61) 197.08,59.61 v3(197.09,59.61)
CPLD_CONFIG_CLK_R: length 24.6
  TOP w0.102: 91.92,93.01 91.71,92.8 91.71,91.78 91.56,91.63 91.56,91.07
  TOP w0.114: 91.92,93.01 91.92,94.86 84.79,102 84.79,104.62 84.45,104.95 84.45,105.28 85.07,105.89 R82.2 R83.2 87.3,105.89 v2(87.35,105.95) ; U9.BG4 91.91,90.72 91.56,91.07
  BOTTOM w0.114: R470.1 v2(87.35,105.95) 87.84,106.43 89.16,106.43 v1(89.28,106.55)
CPLD_CONFIG_DATA: length 209.4
  TOP w0.114: R103.1 v2(86.41,105.03) ; U12.C13 v3(201.09,60.61)
  S3 w0.102: v3(201.09,60.61) 201.09,63.2 201.81,63.92 201.81,68.24 201.6,68.44 201.6,78.18 201.2,78.58 200.09,79.68 200.09,82.94 196.63,86.4 196.63,98.64 192.62,102.65 176.5,102.65 172.14,107.01 172.14,108.34 169.35,111.13 165.59,111.13 165.24,111.48 164.13,111.48 160.96,114.66 150.29,114.66 149.58,115.37 145.36,115.37 140,120.73 114.25,120.73 113.43,119.91 108.27,119.91 108.22,119.97 106.83,119.97 106.12,120.68 70.43,120.68 68.53,118.78 68.53,118.21 69.67,117.07 78.5,117.07 80.39,115.18 80.39,112.62 82.07,110.95 82.07,108.53 84.83,105.77 85.67,105.77 v2(86.41,105.03)
  BOTTOM w0.114: v3(201.09,60.61) 201.09,61.06 v1(201.57,61.54)
CPLD_CONFIG_DATA_R: length 19.2
  TOP w0.102: 92.18,92.91 91.91,92.65 U9.BG2
  TOP w0.114: R102.2 R103.2 86.41,102.62 v2(85.62,101.83) 85.62,101.5 92.18,94.95 92.18,92.91
  BOTTOM w0.114: R103.2 86.41,102.62 v2(85.62,101.83) 85.9,101.55 v1(86.72,101.55)
CPLD_CPU2PCH_THROT: length 30.4
  TOP w0.114: U12.G4 v3(191.09,56.61) ; v2(177.16,73.96) 176.65,73.45 U10.15
  S3 w0.102: v2(177.16,73.96) 177.97,73.96 185.45,66.49 185.45,60.94 189.31,57.07 190.62,57.07 v3(191.09,56.61)
  BOTTOM w0.114: v1(188.26,55.58) 189.2,55.58 189.76,56.13 190.6,56.13 191.08,56.61 v3(191.09,56.61) ; v1(178.03,73.96) v2(177.16,73.96)
CPLD_CPU_CATERR_N: length 16.3
  TOP w0.114: U12.K2 189.11,52.63 182.45,52.63 179.41,55.66 177.89,55.66 v2(177.47,55.24) 176.7,54.48 U14.15
  BOTTOM w0.114: v2(177.47,55.24) 177.47,55.91 v1(177.83,56.26)
CPLD_CPU_ERROR_0: length 19.2
  TOP w0.114: U12.H2 189.59,55.09 189.1,54.61 182.63,54.61 180.61,56.63 175.78,56.63 v2(174.42,55.27) 174.7,54.99 U14.19
  BOTTOM w0.114: v1(174.42,54.08) v2(174.42,55.27)
CPLD_CPU_ERROR_1: length 16.9
  TOP w0.114: U12.J1 182.49,54.11 180.21,56.39 176.34,56.39 v2(175.2,55.25) U14.18
  BOTTOM w0.114: v1(175.29,56.26) 175.2,56.18 v2(175.2,55.25)
CPLD_CPU_ERROR_2: length 17.6
  TOP w0.114: U14.17 175.7,55 v2(175.97,55.27) 176.85,56.15 180.07,56.15 182.55,53.67 189.18,53.67 189.59,54.08 U12.J2
  BOTTOM w0.114: v1(175.97,54.1) v2(175.97,55.27)
CPLD_CPU_PCH_PLTRST_N: length 39.5
  TOP w0.114: U12.E7 v3(194.09,58.61)
  BOTTOM w0.114: U34.12 177.11,84.05 177.52,83.64 177.75,83.64 178.23,83.16 178.23,80.95 183.21,75.97 183.21,63.37 187.45,59.13 v1(188.87,59.13) 193.57,59.13 v3(194.09,58.61)
CPLD_CPU_PROCHOT_N: length 239.8
  TOP w0.114: U12.L1 188.34,52.36 180.43,52.36 178.64,54.15 v2(178.59,54.15) U14.14
  S3 w0.102: v3(19.28,69.47) 21.55,67.2 21.55,61.47 25.88,57.14 25.88,56.08 26.82,55.14 26.82,53.26 29.36,50.72 29.36,39.54 29.34,39.52 29.34,35.3 33.32,31.32 35.58,31.32 39.39,27.51 43.75,27.51 45.12,26.14 61.82,26.14 64.94,23.01 68.93,23.01 69.03,23.11 72.63,23.11 72.73,23.01 93.99,23.01 99.06,28.08 99.06,31.38 101.39,33.71 116.48,33.71 v2(119.68,36.91)
  S8 w0.102: v2(119.68,36.91) 119.68,43.25 122.89,46.46 123.04,46.46 124.22,47.64 124.22,49.01 130.15,54.94 154.98,54.94 155.23,54.69 172.06,54.69 172.6,54.15 v2(178.59,54.15)
  BOTTOM w0.114: R567.2 170.59,55.8 171.61,56.83 178.06,56.83 178.56,56.32 178.56,54.17 v2(178.59,54.15) ; CONN14.29 20.09,70.28 v3(19.28,69.47)
CPLD_CPU_THERMTRIP_N: length 227.9
  TOP w0.114: U12.K1 182.6,53.11 179.81,55.91 177.32,55.91 v2(176.68,55.27) 176.2,54.79 U14.16
  S3 w0.102: v3(19.99,69.39) 21.79,67.59 21.79,64.26 26.14,59.92 26.14,56.15 27.05,55.23 27.05,53.35 29.59,50.81 29.59,39.45 29.57,39.43 29.57,35.54 30.75,34.37 34.21,34.37 38.48,30.1 39.41,30.1 41.78,27.74 43.84,27.74 45.22,26.37 61.91,26.37 65.04,23.24 68.83,23.24 68.93,23.34 72.72,23.34 72.82,23.24 93.9,23.24 98.83,28.17 98.83,31.47 101.29,33.93 115.82,33.93 v2(118.72,36.83)
  S8 w0.102: v2(176.68,55.27) 176.21,54.79 172.34,54.79 171.84,55.29 166.96,55.29 166.59,54.91 155.34,54.91 154.87,55.38 130.11,55.38 123.99,49.26 123.99,47.72 122.95,46.69 122.78,46.69 119.08,42.99 119.08,37.19 v2(118.72,36.83)
  BOTTOM w0.114: CONN14.31 20.28,69.68 v3(19.99,69.39) ; v2(176.68,55.27) 176.68,56.13 v1(176.56,56.26)
CPLD_DDR01_MEMHOT: length 26.8
  TOP w0.114: U12.G3 v3(190.09,56.61) ; U10.16 v2(176.15,73.84)
  S3 w0.102: v3(190.09,56.61) 189.45,56.61 185.22,60.85 185.22,66.4 178.26,73.36 176.64,73.36 v2(176.15,73.84)
  BOTTOM w0.114: v2(176.15,73.84) 176.17,73.82 v1(176.17,72.92)
CPLD_DDR_EVENT_N: length 270.3
  TOP w0.114: U12.N8 v3(195.09,49.61)
  S3 w0.102: v2(98.29,16.51) 96.6,16.51 93.62,13.54 87.63,13.54 86.05,11.96 79.47,11.96 79.09,12.35 77.7,12.35 76.95,11.61 73.14,11.61 72.23,10.7 70.92,10.7 70.33,10.11 64.25,10.11 63.38,10.97 58.4,10.97 57.26,12.12 52.33,12.12 52.23,12.22 51.58,12.22 50.54,13.26 47.97,13.26 46.72,14.5 43.63,14.5 42.83,15.31 40.87,17.27 35.49,17.27 34.83,16.61 31.16,16.61 30.16,15.61 25.15,15.61 24.7,15.17 21.21,15.17 20,16.38 18.42,16.38 17.02,17.78 15.18,17.78 14.34,18.62 9.19,18.62 6.65,21.16 6.65,23.55 6.05,24.16 6.05,24.17 5.74,24.47 5.74,45.31 8.81,48.39 24.38,48.39 v2(25.65,49.66)
  S8 w0.102: v3(195.09,49.61) 194.52,49.04 194.52,48.43 194.27,48.18 193.94,48.18 192.96,47.19 191.94,47.19 191.44,46.69 191.44,45.68 185.78,40.01 185.78,33.54 185.91,33.41 186.04,33.27 186.18,33.14 186.18,32.21 181.83,27.86 176.22,27.86 174.69,26.34 170.3,26.34 168.65,24.69 150.17,24.69 148.25,22.76 122.22,22.76 121.44,21.97 114.82,21.97 114.34,21.49 111.58,21.49 108.36,18.26 104.83,18.26 104.53,17.96 100.27,17.96 100,17.69 100,17.69 98.82,16.51 v2(98.29,16.51)
  BOTTOM w0.114: v2(25.65,49.66) 25.86,49.45 Q11.D 29.72,49.45 v1(30.15,49.89) 30.4,50.14 R607.2
CPLD_FIVR_FAULT: length 18.6
  TOP w0.114: U12.H1 182.47,55.11 180.71,56.87 175.26,56.87 173.7,55.31 v2(173.7,55.25) U14.21
  BOTTOM w0.114: v2(173.7,55.25) 173.7,55.95 v1(174.02,56.26)
CPLD_INTERRUPT_R: length 25.4
  BOTTOM w0.114: R937.2 24.03,82.98 22.45,81.41 19.53,81.41 18.77,80.64 18.77,79.65 17.07,77.95 17.07,75.82 17.66,75.22 17.66,68.05 16.97,67.35 16.22,67.35 15.39,68.18 CONN14.36
CPLD_JTAG_TCK: length 2.3
  TOP w0.127: v2(195.5,20.62) 195.61,20.51 U21.4
  BOTTOM w0.114: v2(195.5,20.62) 195.66,20.47 R664.2
CPLD_JTAG_TDI: length 39.5
  TOP w0.114: 195.61,15.21 193.78,17.04 193.32,17.04 191.8,18.57 191.8,23.5 v2(188.47,26.82)
  TOP w0.127: U21.13 195.61,15.21
  S10 w0.102: v2(188.47,26.82) 188.47,38.86 186.41,40.92 186.41,46.89 v2(186.74,47.22)
  BOTTOM w0.114: R843.2 186.77,47.2 v2(186.74,47.22) 186.36,46.84 v1(185.45,46.84)
CPLD_JTAG_TDO: length 2.2
  TOP w0.127: U21.7 v2(193.71,20.65)
  BOTTOM w0.114: R695.2 v2(193.71,20.65)
CPLD_JTAG_TMS: length 3.1
  TOP w0.127: U21.10 v2(193.71,12.82)
  BOTTOM w0.114: v1(194.04,11.9) 194.04,12.48 v2(193.71,12.82)
  BOTTOM w0.127: R696.2 193.65,12.88 v2(193.71,12.82)
CPLD_LED1_DEBUG: length 5.3
  TOP w0.114: TP5.1 206.57,52.83 205.92,52.83 205.16,53.59 v2(204.85,53.59) 203.1,53.59 U12.J15
CPLD_LED2_DEBUG: length 36.6
  TOP w0.114: LED19.C2 v2(199.58,75.13) ; U12.K16 205.08,53.11 v2(206.12,52.07)
  S8 w0.102: v2(199.58,75.13) 200.5,74.21 204.65,74.21 205.12,74.69 206.52,74.69 207.22,73.98 207.22,69.17 205.58,67.53 205.58,56.1 206.7,54.98 206.7,52.64 v2(206.12,52.07)
  BOTTOM w0.114: v1(205.1,52.07) v2(206.12,52.07)
CPLD_LED2_DEBUG_R: length 3
  TOP w0.114: R883.2 v2(196.07,75.06) 196.15,75.13 LED19.A2
  BOTTOM w0.114: v1(194.94,75.06) v2(196.07,75.06)
CPLD_LED3_DEBUG: length 8.7
  TOP w0.114: U12.K15 203.07,52.63 204.8,52.63 206.76,50.67 v2(206.76,49.53) 206.76,48.94 TP7.1
  BOTTOM w0.114: v2(206.76,49.53) 206.44,49.21 v1(205.72,49.21)
CPLD_LED4_DEBUG: length 37.8
  TOP w0.114: U12.L16 204.89,52.11 205.69,51.31 v2(205.69,50.8) ; LED19.C1 v2(199.58,75.98)
  S8 w0.102: v2(199.58,75.98) 201.12,74.44 204.55,74.44 205.03,74.91 206.61,74.91 207.45,74.08 207.45,68.98 205.81,67.34 205.81,56.19 206.92,55.07 206.92,52.03 v2(205.69,50.8)
CPLD_LED4_DEBUG_R: length 2.9
  TOP w0.114: R875.2 v2(196.07,76.05) 196.15,75.98 LED19.A1
  BOTTOM w0.114: v1(196.07,77.08) v2(196.07,76.05)
CPLD_PCH_APWROK: length 11.7
  TOP w0.114: v2(186.69,62.92) 186.69,63.75 187.22,64.29 187.22,65.38 R184.1 ; U12.F4 v3(191.09,57.61)
  S3 w0.102: v3(191.09,57.61) 191.08,57.61 190.53,58.17 189.13,58.17 186.69,60.6 v2(186.69,62.92)
CPLD_PCH_PWROK: length 11.4
  TOP w0.114: R189.2 186.03,65.25 v2(186.64,64.64) ; U12.F3 v3(190.09,57.61)
  S3 w0.102: v3(190.09,57.61) 189.1,57.61 186.08,60.63 186.08,64.08 v2(186.64,64.64)
CPLD_PCH_THERMTRIP_N: length 23.3
  TOP w0.114: R212.1 176.25,60.53 v2(176.25,61.19) 176.2,61.24 U13.9 ; U12.K4 v3(191.09,52.61)
  S3 w0.102: v3(191.09,52.61) 190.61,53.09 185.93,53.09 177.29,61.72 176.78,61.72 v2(176.25,61.19)
  BOTTOM w0.114: v1(177.39,62.23) 176.94,62.23 176.25,61.54 v2(176.25,61.19)
CPLD_PCHHOT_N: length 20.6
  TOP w0.114: v2(177.09,61.26) 176.7,61.65 U13.10 ; U12.K3 v3(190.09,52.61)
  S3 w0.102: v2(177.09,61.26) 177.14,61.26 185.79,52.61 v3(190.09,52.61)
  BOTTOM w0.114: v1(188.34,53.7) 189,53.7 v3(190.09,52.61)
CPLD_SC_PWRGOOD: length 25.4
  TOP w0.114: U12.J4 v3(191.09,53.61) ; v2(173.76,61.21) 174.2,61.65 U13.5
  S3 w0.102: v2(173.76,61.21) 174.78,62.23 177.46,62.23 185.08,54.61 190.09,54.61 v3(191.09,53.61)
  BOTTOM w0.114: v1(190.58,54.61) 191.09,54.1 v3(191.09,53.61) ; v1(173.76,62.13) v2(173.76,61.21)
CPU_DDR_PWRGD: length 86.6
  TOP w0.102: v3(76.33,75.37) 76.4,75.3 77.52,75.3 78.09,74.73 78.22,74.73 78.41,74.55 78.88,74.55 U9.CR39
  S3 w0.102: v2(93.95,45.97) 95.89,47.9 95.89,49.07 98.6,51.79 98.6,58.03 98.45,58.18 98.45,58.42 98.12,58.75 97.84,58.75 97.61,58.98 97.61,59.26 97.1,59.77 97.1,60.27 96.67,60.71 96.67,61.11 96.88,61.32 100.81,61.32 101.09,61.59 101.09,62.36 102.06,63.32 102.06,63.78 101.21,64.63 101.21,67.78 101.47,68.05 101.47,68.88 100.84,69.52 100.1,69.52 99.77,69.85 99.77,72.42 97.38,74.8 85.55,74.8 85.22,74.47 80.16,74.47 79.73,74.04 79.73,73.25 77.61,71.13 76.16,71.13 76.02,71.27 76.02,72.52 76.33,72.82 v3(76.33,75.37)
  BOTTOM w0.114: R613.1 102.75,47.3 102.02,47.3 101.75,47.03 101.75,45.84 101.4,45.49 100.76,45.49 100.51,45.75 100.51,47.35 99.97,47.88 99.47,47.88 97.74,49.61 95.71,49.61 94.64,48.54 94.64,46.66 v2(93.95,45.97)
CPU_JTAG_RST: length 253.6
  TOP w0.114: v2(142.02,5.3) 141.6,4.89 141.6,3.79 143.17,2.22 158.5,2.22 159.19,2.91 161.46,2.91 162.15,2.22 164.25,2.22 v2(164.97,2.95) ; R49.1 v2(100.08,111.18) ; U12.L12 v3(200.09,51.61)
  S3 w0.102: v2(188.09,65.91) 188.09,65.94 187.6,66.42 187.6,69.56 180.43,76.73 175.71,76.73 170.13,82.31 170.13,96.67 165.71,101.09 163.35,101.09 160.81,98.55 157.18,98.55 155.75,97.12 134.4,97.12 134.09,96.8 131.1,96.8 130.72,96.42 122.13,96.42 116.93,101.63 115.48,101.63 114.45,102.65 114.45,103.54 110.82,107.18 108.23,107.18 107.89,107.52 105.19,107.52 103.94,108.77 103.94,109.79 103.77,109.96 101.3,109.96 v2(100.08,111.18)
  S10 w0.102: v2(188.09,65.91) 187.53,65.35 187.53,58.93 188.29,58.17 199.26,58.17 199.57,57.86 199.57,52.15 200.09,51.63 v3(200.09,51.61) 200.1,51.61 200.61,51.1 200.61,45.59 200.33,45.31 200.33,44.25 199.31,43.23 197.78,43.23 194.61,40.06 194.61,38.52 191.2,35.11 191.2,35.09 191.15,35.04 191.15,18.12 185.43,12.4 184.6,12.4 182.74,10.54 172.57,10.54 v2(164.97,2.95)
  BOTTOM w0.114: v2(188.09,65.91) 185.92,65.91 v1(185.29,65.28)
  BOTTOM w0.127: CONN16.70 141.6,4.89 v2(142.02,5.3)
CPU_JTAG_RST_R: length 40.4
  TOP w0.114: v2(100.54,108.82) 100.54,108.89 100.08,109.35 R49.2 ; U9.BA19 94.76,83.19 v4(95.16,82.79)
  S5 w0.102: v4(95.16,82.79) 95.56,82.39 97.38,82.39 98.17,83.18 99.27,83.18 99.53,83.44 99.53,86.12 100.17,86.76 100.17,89.06 100.16,89.07 100.16,89.6 98.25,91.52 95.71,91.52 93.96,93.27 93.96,99.19 100.1,105.33 100.1,106.32 100.54,106.75 v2(100.54,108.82)
  BOTTOM w0.114: v1(100.43,107.66) 100.08,108.02 100.08,108.28 100.54,108.74 v2(100.54,108.82)
CPU_PWR_DEBUG_N: length 142.3
  TOP w0.102: 105.77,56.55 105.77,55.47 105.92,55.32
  TOP w0.114: v2(35.99,2.13) 35.89,2.23 CONN11.45 ; U9.U77 105.77,56.55 ; 105.92,55.32 v3(105.92,54.15)
  S5 w0.102: v2(35.99,2.13) 37.44,3.58 51.24,3.58 52.23,4.57 55.87,4.57 56.39,4.05 59.72,4.05 60.62,4.95 61.61,4.95 62.52,5.87 67.42,5.87 67.72,5.56 69.52,5.56 70.62,6.65 72.88,6.65 73.59,5.94 75.6,5.94 76.87,4.67 79.68,4.67 79.91,4.9 79.91,5.14 80.18,5.41 80.76,5.41 81.22,5.87 84.67,5.87 89.21,10.41 92.68,10.41 95.49,13.22 95.49,23.78 100.91,29.2 100.91,35.54 100.92,35.54 100.92,35.76 102.79,37.63 105.05,37.63 106.26,38.84 108.66,38.84 109.7,39.88 109.7,43.92 111.1,45.31 111.1,47.37 111.84,48.11 112.52,48.11 112.83,48.41 112.83,49.66 111.33,51.16 111.33,53.34 109.83,54.84 106.6,54.84 v3(105.92,54.15)
  BOTTOM w0.114: v1(46.63,3.93) 46.63,3.52 46.06,2.95 C639.2 45.31,2.02 44.41,1.12 36.58,1.12 35.99,1.7 v2(35.99,2.13) 35.71,2.41 R760.1
CPU_PWRGD_CPU: length 10.9
  TOP w0.114: U9.V76 105.12,56.9 105.12,56.42 104.99,56.29 104.99,49.75 105.41,49.33 v2(105.41,49.17) 106.1,48.49 R252.1
  BOTTOM w0.114: v1(106.4,47.78) 106.4,48.19 v2(105.41,49.17)
CPU_SV: length 32.3
  TOP w0.114: U9.BP16 88.9,84.62 v4(89.19,84.33) ; R63.2 v2(87.12,108.81)
  S10 w0.102: v4(89.19,84.33) 89.28,84.43 89.28,85.55 89.57,85.83 89.57,86.25 89.3,86.52 89.3,87.24 89.57,87.51 89.57,87.98 89.3,88.25 89.3,88.89 89.52,89.11 89.52,90.14 89.38,90.27 89.38,95.87 86.33,98.92 86.33,104.36 85.9,104.79 85.9,105.46 85.09,106.27 85.09,107.71 85.74,108.36 86.66,108.36 v2(87.12,108.81)
  BOTTOM w0.114: v1(88.82,110.26) 88.06,109.5 R63.2 v2(87.12,108.81)
CPU_XDP_HOOK0: length 208.2
  TOP w0.114: U12.N3 v3(190.09,49.61)
  S3 w0.102: v2(33.12,5.46) 33.48,5.11 39.39,5.11 43.3,1.19 81.1,1.19 88.46,8.56 92.59,8.56 97.61,3.53 103.76,3.53 104.19,3.96 106.63,3.96 109.48,1.12 125.19,1.12 126.23,2.15 127.28,2.15 128.35,1.09 158.83,1.09 159.89,2.15 161.29,2.15 161.65,1.8 166.76,1.8 172.09,7.13 172.09,22.81 186.16,36.88 186.16,45.68 v3(190.09,49.61)
  BOTTOM w0.114: v1(30.4,7.82) 31.14,7.82 33.12,5.84 v2(33.12,5.46) 32.92,5.26 R754.2 32.89,4.64 R775.1 R776.1
CPU_XDP_SYSPWROK: length 210.2
  TOP w0.114: v3(201.09,48.61) U12.P13 ; CONN11.47 36.39,2.52 v2(36.83,2.08)
  S3 w0.102: v2(104.66,14.02) 104.66,14 100.71,10.06 94.13,10.06 v2(93.94,9.87)
  S5 w0.102: v2(36.83,2.08) 38.1,3.35 51.34,3.35 52.33,4.34 55.78,4.34 56.3,3.82 59.82,3.82 60.72,4.72 61.7,4.72 62.62,5.64 67.32,5.64 67.63,5.33 69.62,5.33 70.71,6.43 72.78,6.43 73.5,5.71 75.51,5.71 76.88,4.34 77.75,4.34 77.8,4.29 83.42,4.29 88.99,9.87 v2(93.94,9.87)
  S8 w0.102: v3(201.09,48.61) 201.09,46.82 201.15,46.76 201.15,45.95 200.54,45.35 200.54,44.36 199.13,42.95 198.12,42.95 197.91,42.74 196.88,42.74 195.65,41.51 195.65,39.37 190.86,34.58 190.86,27.05 188.11,24.31 179.67,24.31 178.16,22.79 178.16,21.62 177.46,20.92 177.46,19.91 176.79,19.24 176.32,19.24 175,17.93 175,16.15 170.23,11.38 160.55,11.38 156.39,7.21 138.09,7.21 131.29,14.02 119.65,14.02 118.84,14.83 106.26,14.83 105.92,14.5 105.15,14.5 v2(104.66,14.02)
  BOTTOM w0.114: v2(93.94,9.87) 93.94,10.82 92.1,12.66 v1(92.1,13.24) ; v2(36.83,2.08) 36.63,2.29 R761.1
CSN1_VDDQ_CH01: length 25.3
  TOP w0.254: R333.2 v2(62.04,24.53) ; v2(63.17,9.38) 63.16,9.37 R368.2
  S8 w0.254: v2(63.17,9.38) 63.36,9.19 63.36,8.43 63.91,7.87 64.83,7.87 65.68,8.73 65.68,10.19 63.58,12.29 63.58,23.7 62.96,24.31 62.26,24.31 v2(62.04,24.53)
  BOTTOM w0.254: v1(63.14,10.33) 63.14,9.41 v2(63.17,9.38) 63.16,9.37 C630.1
CSN1_VDDQ_CH01_R: length 1.8
  TOP w0.203: v2(61.53,8.45) 61.24,8.15 U29.40
  TOP w0.254: R368.1 v2(61.53,8.45)
CSP1_VDDQ_CH01: length 22.1
  TOP w0.254: R365.2 64.69,8.75 v2(64.06,9.38) ; R335.2 v2(62.04,23.59)
  S8 w0.254: v2(64.06,9.38) 63.87,9.19 63.87,8.64 64.12,8.38 64.62,8.38 65.18,8.94 65.18,9.97 63.07,12.08 63.07,23.49 62.75,23.81 62.26,23.81 v2(62.04,23.59)
  BOTTOM w0.254: v1(65.07,9.39) 64.07,9.39 v2(64.06,9.38)
CSP1_VDDQ_CH01_C: length 3.9
  TOP w0.114: v2(63.16,6.72) R373.2 63.26,7.58 R372.1
  BOTTOM w0.114: v1(64.28,7.54) 63.19,7.54 C630.2 v2(63.16,6.72)
CSP1_VDDQ_CH01_R: length 2.7
  TOP w0.203: v2(61.53,7.48) 61.26,7.75 U29.39
  TOP w0.254: R373.1 v2(61.53,7.48)
  BOTTOM w0.254: v1(60.63,7.48) v2(61.53,7.48)
CSP1_VDDQ_CH01_R_R: length 2.1
  TOP w0.114: v2(65.88,6.6) R372.2 R365.1
DA/DSS: length 3.5
  TOP w0.114: CONN6.49 180.95,90.29 v2(180.62,90.61) 180.95,90.94 180.95,92.19 R97.2
DCPSUSBYP_C: length 15
  TOP w0.254: U9.AW21 v4(95.95,81.99)
  TOP w0.305: v4(95.95,81.99) U9.AU21
  BOTTOM w0.114: C382.2 90.17,73.21 90.17,75.13 90.58,75.54 90.58,76.07 90.2,76.45 90.2,76.81 90.68,77.29 90.68,77.65 91.19,78.16 91.19,78.61 91.34,78.77 92.38,78.77 92.56,78.94 92.56,79.35 93.37,80.16 93.5,80.16 94.16,80.82 95.3,80.82 95.56,81.08 95.56,81.38 95.95,81.77 v4(95.95,81.99)
DDR0_CLK_DN_1: length 1.6
  TOP w0.114: U9.CM45 v4(80.77,71.45)
  BOTTOM w0.114: R559.2 80.52,71.71 v4(80.77,71.45)
DDR0_CLK_DN_3: length 2.1
  TOP w0.114: U9.CL43 v4(81.26,72.31)
  BOTTOM w0.114: v4(81.26,72.31) 80.85,72.72 80.47,72.72 R557.2
DDR0_CLK_DP_1: length 4
  TOP w0.114: U9.CK45 v4(81.76,71.45)
  BOTTOM w0.114: v4(81.76,71.45) 81.44,71.45 80.95,70.97 80.64,70.97 80.37,71.25 79.22,71.25 78.92,71.55 R559.1
DDR0_CLK_DP_3: length 4.8
  TOP w0.114: U9.CJ43 v4(82.25,72.31)
  BOTTOM w0.114: R557.1 79.15,73.36 79.5,73.71 80.9,73.71 81.23,73.38 81.23,73.03 81.94,72.31 v4(82.25,72.31)
DDR1_CLK_DN_1: length 4.1
  TOP w0.102: U9.CR54 v4(78.54,67.45)
  BOTTOM w0.114: v4(78.54,67.45) 78.24,67.15 75.67,67.15 R571.2
DDR1_CLK_DN_3: length 2.5
  TOP w0.102: U9.CT53 v4(79.04,67.95)
  BOTTOM w0.114: R566.2 77.74,67.59 77.77,67.56 78.1,67.56 78.49,67.95 v4(79.04,67.95)
DDR1_CLK_DP_1: length 5.1
  TOP w0.102: v3(74.29,68.52) 74.29,68.51 74.96,67.84 75.92,67.84 76.12,67.64 77.7,67.64 77.89,67.45 U9.CU54
  BOTTOM w0.114: R571.1 74.29,67.62 v3(74.29,68.52)
DDR1_CLK_DP_3: length 3.1
  TOP w0.102: U9.CV53 76.67,67.95 76.57,67.84 76.21,67.84 75.74,68.31 v3(75.74,68.49)
  BOTTOM w0.114: v3(75.74,68.49) 76.04,68.19 76.04,68.13 76.3,67.87 R566.1
DDR01_CPU_VREFCA: length 8.9
  TOP w0.102: v4(77.93,67.95) 78.05,68.07 78.18,68.07 78.41,68.3 78.74,68.3 78.88,68.44 U9.CR52
  BOTTOM w0.114: v4(77.93,67.95) 77.82,68.06 77.82,69.12 77.47,69.47 77.47,69.85 76.25,71.07 74.37,71.07 v1(74.37,71.07) 74.37,71.07 R562.1
DDR01_VREFCA: length 157.7
  TOP w0.305: CONN8.164 49.41,60.2 v2(48.84,59.64) ; CONN7.164 37.42,60.2 v2(36.84,59.63)
  TOP w0.381: v2(69.52,71.91) 69.52,71.42 69.03,70.94 R200.1 C98.1 ; v2(31.68,95.42) 31.68,95.33 30.76,94.41 30.76,81.41 31.03,81.15 31.03,80.65 30.76,80.38 30.76,78.56 28.22,76.02 28.22,70.82 30.12,68.91 30.12,60.73 v2(31.6,59.26)
  S3 w0.381: v2(31.6,59.26) 31.8,59.26 31.91,59.15 35.57,59.15 35.69,59.03 36.18,59.03 36.29,59.14 36.35,59.14 v2(36.84,59.63)
  BOTTOM w0.381: 44.32,60.22 46.2,62.1 51.82,62.1 52.73,61.19 R580.2 ; 44.32,60.22 44.78,59.77 45.72,59.77 46.41,60.45 47.32,60.45 47.98,59.79 48.69,59.79 v2(48.84,59.64) 48.57,59.36 C489.2 ; 44.32,60.22 40.18,60.22 40.03,60.38 37.59,60.38 v2(36.84,59.63) 37.44,59.03 C490.2 ; v2(31.68,95.42) v1(31.68,96.32) 34.06,98.7 40.92,98.7 41.55,99.34 41.55,103.66 43.61,105.71 56.74,105.71 59.02,103.44 59.02,97.9 66.42,90.5 66.42,73.92 67.69,72.64 68.96,72.64 69.52,72.09 v2(69.52,71.91) 69.52,71.71 70.15,71.07 70.36,71.07 R562.2
DDR4_EVENT_MOS: length 12.2
  BOTTOM w0.114: Q8.D 29.3,53.59 R603.2 30.79,53.59 31.24,53.14 31.24,49.07 v1(30.35,48.18) 30,47.83 27.33,47.83 Q11.G
DDR4_VPP: length 115.3
  TOP w0.381: C170.2 v2(32.79,28.6) ; C169.1 v2(31.83,28.6) ; R345.1 37.95,18.39 v2(38.1,18.54) ; C171.2 v2(33.76,28.6)
  S3 w0.508: v2(52.86,33.38) 52.86,33.71 52.2,34.37 50.22,34.37 49.1,33.25 47.42,33.25 45.87,34.8 v2(45.87,35.86) 45.87,37.68 46.93,38.73 55.27,38.73 59.87,34.14 62.31,34.14 63.22,33.22 63.22,28.04 65.71,25.55 70.08,25.55 70.46,25.93 83.08,25.93 84.05,24.97 87.22,24.97 87.27,24.92 94.32,24.92 96.11,26.71 96.11,32.77 95.04,33.84 v2(95.04,35.67)
  S10 w0.508: v2(95.04,35.67) 93.78,36.93 93.78,40.64 92.86,41.55 89.1,41.55 v2(87.53,39.98)
  BOTTOM w0.381: v2(87.53,39.98) 88.09,40.54 R878.1 R877.1 ; v2(45.19,35.86) 45.05,35.73 C541.1 C542.1 ; R652.1 33.64,36.09 v2(33.39,35.84) 33.39,34.81 C552.1 C551.1 ; C542.1 45.99,35.74 v2(45.87,35.86) 45.87,36.51 R655.1 ; C542.1 C543.1 ; v2(52.86,33.38) 53.23,33.75 R880.2 ; R879.1 v2(95.04,35.67) R676.1 ; v2(32.7,35.84) 32.29,35.42 C551.1 ; C550.1 C551.1 ; R606.1 v2(25.38,50.5)
  vias: v1(30.68,30.76) v2(31.85,30.56) v2(31.85,29.54) v2(32.82,30.56) v2(32.82,29.54) v2(33.78,29.54)
DDR4_VPP_AGND: length 5.2
  TOP w0.381: R344.2 37.82,19.31 v2(37.97,19.46) ; C176.2 34.8,22.17 v2(34.67,22.05) 34.26,22.46 U23.5
  BOTTOM w0.381: R709.1 v2(29.79,18.77)
DDR4_VPP_SS: length 5.8
  TOP w0.114: v2(38.1,21.69) 37.19,20.78 35.61,20.78 35.38,21 R339.1 35.15,21.51 34.42,21.51 34.12,21.81 U23.4
DDR4_VPP_SS_C: length 2
  TOP w0.114: v2(37.21,22.68) 36.7,22.17 C176.1 R339.2
DDR4_VPP_SW: length 10.8
  TOP w0.381: C178.1 22.58,23.33 L18.1
  BOTTOM w0.381: v2(24.03,25.32) 23.77,25.06 23.77,20.88 25.42,19.23 v1(27.1,19.23)
DDR4_VPP_VBST: length 7.3
  TOP w0.381: C178.2 v2(24.54,21.46) 24.71,21.46 25.02,21.16 U23.12
  BOTTOM w0.114: v1(27.36,20.5) 25.5,20.5 v2(24.54,21.46)
DDR4_VPP_VO: length 5.5
  TOP w0.114: U23.1 33.97,19.86 v2(34.52,19.31) C189.1 R345.2
  BOTTOM w0.114: v1(33.6,18.82) 34.09,19.31 v2(34.52,19.31) 34.75,19.08 R711.1
DDR4_VPP_VO_R: length 2.8
  BOTTOM w0.114: R711.2 R708.1 v1(38.35,20.42)
DDR4_VPP_VREG: length 4.3
  TOP w0.114: U23.3 34.27,21.16 v2(34.42,21.01)
  BOTTOM w0.114: v2(34.42,21.01) 34.01,21.01 v1(33.5,21.51) 33.32,21.69 R701.2 C596.1
DDR_EVENT_1V2_N: length 47.7
  BOTTOM w0.114: R606.2 26.74,52.09 Q8.G 27.91,53.22 27.91,53.52 28.63,54.23 30.81,54.23 31.07,54.49 31.07,55.12 31.44,55.49 31.94,55.49 32.21,55.76 32.21,57.15 32.22,57.16 32.22,58.65 32.18,58.69 32.18,59.64 34.39,61.85 40.54,61.85 41.66,60.73 44.07,60.73 44.5,61.16 44.5,65 43.21,66.29 42.21,66.29 41.74,66.77 R570.2 41.97,67.35 42.7,66.62 v1(45.45,66.62) 54.13,66.62 R574.2
DEV_OFF_N: length 116.6
  TOP w0.114: R973.1 130.18,80.75 136.4,74.52 136.4,65.66 137.92,64.14 142.24,64.14 v2(144.65,61.72) ; v2(201.04,45.09) 201.04,47.66 U12.R13
  BOTTOM w0.114: v2(144.65,61.72) 145.4,60.97 148.58,60.97 150.13,59.42 150.13,59.21 150.85,58.48 159.49,58.48 160.42,57.55 178.36,57.55 180.77,55.14 180.77,42.97 183.13,40.61 188.8,40.61 192.25,37.16 193.7,37.16 194.23,37.69 194.82,37.69 195.38,37.13 v1(197.38,37.13) 198.33,37.13 202.6,41.4 202.6,42.85 201.04,44.41 v2(201.04,45.09)
DEV_OFF_N_R: length 8.2
  TOP w0.114: R973.2 130.2,85.54 R961.2 131.24,85.54 131.7,85.09 133.12,85.09 133.55,85.52 R960.2 134.04,85.6 134.44,86 v2(134.44,86.08) 134.82,86.08 135.77,87.02 U6.28
  BOTTOM w0.114: v2(134.44,86.08) 134.67,86.08 v1(135.2,86.61)
DIFF_XCLK_BIASREF: length 20.6
  TOP w0.108: v4(104.01,84.38) 103.63,83.99 U9.AA18
  S10 w0.102: v2(106.53,99.24) 106.1,99.24 103.89,97.03 103.89,96.16 102.16,94.44 101.65,94.44 101.04,93.83 101.04,89.03 101.52,88.54 101.52,88.21 102.18,87.55 102.18,87.34 104.01,85.52 v4(104.01,84.38)
  BOTTOM w0.114: v2(106.53,99.24) 106.32,99.44 R487.2
DIMM1_SPD: length 6.1
  TOP w0.305: v2(31.76,37.45) CONN7.255
  BOTTOM w0.114: v1(32.74,39.53) R646.2
  BOTTOM w0.381: C527.1 C528.1 v2(31.76,37.45) 32.58,37.45 R652.2 R646.2
DIMM2_SPD: length 7.1
  TOP w0.305: CONN8.255 v2(46.58,37.45)
  BOTTOM w0.114: v1(45.64,40.69) 45.64,39.52 C518.1
  BOTTOM w0.381: C518.1 C519.1 45.95,38.58 46.58,37.95 v2(46.58,37.45) 46.43,37.6 R655.2 R654.2
ENTER/EXIT_SLEEP: length 3.9
  TOP w0.114: CONN6.44 v2(182.95,79.18)
  BOTTOM w0.114: v2(182.95,79.18) 183.19,79.42 R156.1 R157.2
EXT_UART1_CTS: length 7.6
  TOP w0.114: TP11.1 139.98,10.45 v2(139.1,9.58)
  BOTTOM w0.114: CONN16.79 v2(139.1,9.58) 139.6,10.07 139.6,13.03 v1(139.27,13.36)
EXT_UART1_RTS: length 3.7
  TOP w0.114: v2(140.1,4.03) 140.1,5.39 TP12.1
  BOTTOM w0.127: CONN16.76 v2(140.1,4.03)
FAULT_LED_OUT_N: length 36.5
  TOP w0.114: R336.2 v2(11.06,23.31)
  BOTTOM w0.114: v1(28.37,8) 27.55,8.83 24.04,8.83 23.22,8 21.09,8 16.67,12.42 9.96,12.42 9.43,12.95 9.41,12.95 9.02,13.35 9.02,19.77 10.54,21.3 10.54,22.79 v2(11.06,23.31) 11.53,23.78 CONN14.176
FB_V1P8A: length 4.7
  BOTTOM w0.381: 170.42,38.75 v1(171.22,37.94) ; 170.42,38.75 U35.4 ; 170.42,38.75 R612.2 R611.2
FM_BIOS_RCRV_BOOT_N: length 34.8
  TOP w0.114: v4(87.7,81.76) 87.41,82.04 U9.BU22 ; R43.1 83.44,110.44 v2(83.44,109.7)
  S10 w0.102: v4(87.7,81.76) 87.7,82.68 87.32,83.06 87.32,83.76 87.59,84.03 87.59,84.65 87.32,84.92 87.32,85.49 87.59,85.76 87.59,86.23 87.32,86.49 87.32,87.14 87.59,87.41 87.59,88.06 87.22,88.42 87.22,88.65 86.82,89.05 86.81,89.05 86.58,89.28 86.58,91.23 87.43,92.08 87.43,95.87 84.4,98.89 84.4,102.67 83.74,103.33 83.74,103.99 83.06,104.68 83.06,108.43 83.44,108.81 v2(83.44,109.7)
  BOTTOM w0.114: v1(84.4,110.54) R43.1 83.33,109.8 v2(83.44,109.7)
FM_CPLD_P0V6_VTT_DIMM_EN: length 187.4
  TOP w0.114: U12.L4 v3(191.09,51.61) ; v2(42.21,23.14) 42.09,23.27 42.09,28.13 42.63,28.67 R325.2
  S3 w0.102: v2(97.36,20.74) 95.45,20.74 93.58,18.87 90.56,18.87 89.87,18.19 87.49,18.19 86.46,17.16 86.46,17.13 85.86,16.54 77.03,16.54 76.29,17.27 72.33,17.27 71.85,16.79 71.21,16.79 70.52,16.1 67.91,16.1 67.13,15.32 48.82,15.32 47.37,16.76 46.27,16.76 44.45,18.58 44.45,20.9 v2(42.21,23.14)
  S8 w0.102: v2(97.36,20.74) 97.37,20.75 106.5,20.75 110.57,24.82 146.91,24.82 149.33,27.23 159.73,27.23 162,29.5 162.14,29.63 162.14,29.63 162.81,30.3 180.36,30.3 183.72,33.66 183.72,39.29 182.88,40.13 182.88,42.34 184.1,43.56 184.1,47.3 184.23,47.44 184.23,47.44 184.37,47.57 184.5,47.7 188.87,52.07 190.63,52.07 191.09,51.61 v3(191.09,51.61)
  BOTTOM w0.114: v3(191.09,51.61) 190.6,52.1 189.56,52.1 v1(189.08,52.58)
FM_CPLD_P0V9_LAN1_EN: length 5.3
  TOP w0.114: U12.A12 199.69,62.21 R185.1 199.69,66.22 v2(199.9,66.42)
  BOTTOM w0.114: v2(199.9,66.42) v1(199.9,65.53)
FM_CPLD_P0V9_LAN_EN: length 9.6
  TOP w0.114: R223.1 207.11,45.34 205.84,46.61 v2(205.84,47.07) 205.84,48.97 204.81,50.01 204.47,50.01 204.27,50.2 204.27,50.39 204.21,50.45 204.21,50.6 203.7,51.11 U12.M16
  BOTTOM w0.114: v2(205.84,47.07) v1(205.84,46.07)
FM_CPLD_P1V8_LAN1_EN: length 4.1
  TOP w0.114: U12.T11 v2(198.59,46.1) 199.14,45.55 199.14,44.91 199.12,44.9 199.12,43.95 198.68,43.51 R224.2
FM_CPLD_P1V8_LAN_EN: length 6.4
  TOP w0.114: U12.R5 193.08,47.62 193.08,46.81 192.78,46.51 v2(192.78,45.68) 192.78,45.41 191.49,44.12 R225.2
  BOTTOM w0.114: v1(191.74,45.64) 191.77,45.67 192.77,45.67 v2(192.78,45.68)
FM_CPLD_V3P3_PCH_EN: length 141.5
  TOP w0.114: v2(105.77,14.02) 100.46,8.71 R367.2 96.85,7.34 Q6.G ; U12.N13 v3(201.09,49.61)
  S8 w0.102: v2(105.77,14.02) 106.35,14.61 118.74,14.61 119.56,13.79 131.19,13.79 138,6.99 156.48,6.99 160.65,11.15 170.32,11.15 175.23,16.06 175.23,17.83 176.41,19.01 176.88,19.01 177.68,19.82 177.68,20.82 178.45,21.59 178.45,22.76 179.7,24.01 188.13,24.01 191.08,26.96 191.08,34.48 195.88,39.27 195.88,41.41 196.98,42.51 198.01,42.51 198.22,42.72 199.57,42.72 201.55,44.7 201.55,46.05 201.37,46.23 201.37,48.21 201.55,48.39 201.55,49.15 v3(201.09,49.61)
FM_CPU_PROCHOT_PCH_N: length 62.6
  TOP w0.114: v2(25.63,112.83) 25.82,113.02 CONN4.30 ; R86.1 v2(77.78,107.26)
  S10 w0.102: v2(25.63,112.83) 26.6,113.8 36.03,113.8 37.02,114.79 38.11,114.79 38.43,115.11 38.55,115.23 38.61,115.29 39.08,115.29 39.11,115.32 57.45,115.32 58.19,114.58 61.98,114.58 62.03,114.63 64.14,114.63 64.69,115.19 66.48,115.19 67.15,115.85 70.84,115.85 71.75,114.94 72.03,114.94 72.44,114.52 72.44,113.6 73.39,112.65 73.6,112.65 74.8,111.44 74.8,111.05 76.5,109.35 76.82,109.35 77.78,108.39 v2(77.78,107.26)
  BOTTOM w0.114: v1(25.17,111.86) 25.17,112.37 v2(25.63,112.83)
FM_DDR4_VPP_CPLD_EN: length 190.5
  TOP w0.114: v2(35.38,25.04) R334.1 35.05,23.76 U23.7 ; U12.L3 v3(190.09,51.61)
  S3 w0.102: v2(35.38,25.04) 35.38,23.76 38.14,21.01 41.82,21.01 44.22,18.6 44.22,18.49 46.17,16.54 47.28,16.54 48.72,15.09 67.22,15.09 67.83,15.7 71.77,15.7 72.03,15.96 72.03,16.5 72.58,17.04 76.2,17.04 76.96,16.28 80.69,16.28 81.41,15.57 87.58,15.57 90.66,18.65 93.68,18.65 95.31,20.28 v2(98.17,20.28)
  S8 w0.102: v2(98.17,20.28) 106.35,20.28 110.66,24.59 147.01,24.59 149.42,27 159.83,27 162.23,29.4 162.37,29.54 162.9,30.07 180.46,30.07 183.95,33.56 183.95,40.77 184.33,41.15 184.33,47.21 184.46,47.34 184.6,47.47 188.94,51.82 189.88,51.82 v3(190.09,51.61)
  BOTTOM w0.114: v3(190.09,51.61) 188.27,51.61 v1(187.96,51.92)
FM_ME_RCRV_N: length 41.8
  TOP w0.114: v2(66.22,112.55) R30.2 ; U9.BP9 v4(89.19,87.77)
  S3 w0.102: v4(89.19,87.77) 89.19,88.08 89.08,88.19 89.08,88.95 89.33,89.2 89.33,93.2 87.52,95.01 85.1,97.43 82.55,97.43 80.2,99.78 76.38,99.78 68.41,107.75 67.92,107.75 67.34,108.33 67.34,111.43 v2(66.22,112.55)
  BOTTOM w0.114: R30.2 v2(66.22,112.55) 66.83,113.16 v1(67.16,113.16)
FM_NMI_EVENT_CPLD_N: length 190.2
  TOP w0.114: U12.D12 v3(200.09,59.61) ; v2(118.87,120.02) 116.54,122.35 81.31,122.35 75.63,116.68 75.63,115.31 75.54,115.22 75.54,107.26 v2(74.93,106.65)
  S3 w0.102: v2(118.87,120.02) 119.43,119.46 140.61,119.46 145.16,114.91 149.39,114.91 150.1,114.2 160.75,114.2 164.01,110.95 165.13,110.95 165.53,110.54 167.84,110.54 169.47,108.92 169.9,108.92 171.16,107.65 176.49,102.32 192.62,102.32 196.4,98.55 196.4,86.31 199.86,82.84 199.86,79.59 201.1,78.35 201.1,78.35 201.37,78.08 201.37,67.7 201.58,67.49 201.58,64.02 200.76,63.2 200.76,60.96 200.58,60.78 200.58,60.11 v3(200.09,59.61)
  BOTTOM w0.114: v1(118.37,118.97) 118.37,118.98 118.36,118.99 118.36,119.51 v2(118.87,120.02) ; v2(74.93,106.65) 74.93,105.27 74.1,104.44 R474.1
FM_NMI_EVENT_PCH_N: length 57.9
  TOP w0.114: R101.1 v2(74.1,105.46) ; CONN4.6 v2(31.82,110.39)
  S10 w0.102: v2(74.1,105.46) 73.73,105.82 73.73,107.51 72.63,108.61 72.3,108.61 71.7,109.21 71.7,109.54 70.62,110.62 67.34,110.62 66.52,111.43 65.38,111.43 65.23,111.28 64.21,111.28 63.93,111.56 60.48,111.56 60.4,111.63 58.37,111.63 56.09,113.91 49.61,113.91 48.07,112.37 46.57,112.37 45.84,113.11 37.3,113.11 34.58,110.39 v2(31.82,110.39)
  BOTTOM w0.114: v2(31.82,110.39) v1(31.82,111.43) 31.82,113.17 R442.1
FM_PROCHOT_N: length 182.9
  TOP w0.114: U12.C11 v3(199.09,60.61) ; v2(115.87,120.04) 114.29,121.63 84.05,121.63 80.43,118.01 80.43,113.35 79.78,112.7 79.78,109.16 79.97,108.98 79.97,108.49 79.02,107.54 78.21,107.54 77.98,107.77 77.42,107.77 76.63,106.98 v2(76.63,106.78)
  S3 w0.102: v2(115.87,120.04) 117.14,118.77 135.62,118.77 140.93,113.46 159.03,113.46 162.2,110.29 163.22,110.29 165.28,108.23 169.56,108.23 176.36,101.43 192.41,101.43 195.71,98.14 195.71,82.77 200.68,77.8 200.68,68.06 199.47,66.85 199.47,66.64 199.44,66.61 199.44,66.23 199.47,66.21 199.47,61.77 199.47,61.77 199.47,61.45 199.47,61.45 199.47,60.99 v3(199.09,60.61)
  BOTTOM w0.114: R469.1 76.94,106.47 v2(76.63,106.78)
FM_SMI_ACTIVE_CPLD_N: length 221.6
  TOP w0.114: R75.1 v2(74.19,106.29) ; U12.E12 v3(200.09,58.61)
  S3 w0.102: v3(200.09,58.61) 200.61,59.13 202.36,59.13 202.62,59.39 202.62,62.23 204.77,64.39 204.77,64.42 204.8,64.45 204.8,67.6 202.74,69.66 202.74,78.65 201.67,79.72 201.24,80.16 201.24,92.66 201.6,93.03 201.6,98.45 196.17,103.87 191.05,103.87 186.09,108.84 186.09,113.96 183.45,116.6 176.07,116.6 171.36,121.31 164.55,121.31 163.16,119.91 159.13,119.91 157.63,118.41 152.85,118.41 152.21,117.78 144.68,117.78 140.59,121.87 68.95,121.87 68.28,121.2 67.26,120.18 67.26,119.42 67.26,119.42 67.26,117.75 67.66,117.35 70.05,114.95 70.05,113.46 70.46,113.06 71.1,113.06 71.81,112.35 71.81,111.73 72.31,111.23 73.28,111.23 73.76,110.74 74.44,110.74 74.96,110.23 74.96,107.33 74.19,106.56 v2(74.19,106.29)
  BOTTOM w0.114: v3(200.09,58.61) 199.96,58.61 199.47,59.11 198.78,59.11 198.6,59.28 v1(198.6,62.51) ; v2(74.19,106.29) 74.12,106.29 R466.1
FM_SMI_ACTIVE_PCH_N: length 59.3
  TOP w0.114: CONN4.36 v2(24.32,111.12) ; R73.1 v2(74.19,108.74)
  S10 w0.102: v2(24.32,111.12) 24.44,111 34.87,111 37.36,113.49 48.86,113.49 49.51,114.14 56.2,114.14 58.42,111.91 60.45,111.91 60.58,111.79 63.73,111.79 64.14,112.19 65.05,112.19 65.56,111.68 67.04,111.68 67.54,111.19 71.01,111.19 72.24,109.96 72.97,109.96 v2(74.19,108.74)
  BOTTOM w0.114: v2(24.32,111.12) 23.5,110.3 v1(23.5,109.91)
FM_THROTTLE_N: length 188.4
  TOP w0.114: v2(117.86,120.04) 115.79,122.11 81.41,122.11 75.88,116.58 75.88,115.21 75.78,115.11 75.78,106.69 76.66,105.81 76.66,104.34 76.96,104.04 R107.1 ; U12.C12 v3(200.09,60.61)
  S3 w0.102: v3(200.09,60.61) 200.53,61.05 200.53,64.93 200.65,65.05 200.65,67.38 201.14,67.87 201.14,77.99 201.01,78.12 199.64,79.49 199.64,82.75 196.17,86.21 196.17,98.46 192.73,101.89 176.6,101.89 172.27,106.23 169.81,108.69 166.95,108.69 165.28,110.36 164.27,110.36 160.71,113.92 145.83,113.92 140.52,119.23 118.67,119.23 v2(117.86,120.04)
  BOTTOM w0.114: v2(117.86,120.04) 117.22,119.41 117.22,119.25 v1(117.12,119.14)
FM_THROTTLE_PCH_N: length 65.2
  TOP w0.114: CONN4.28 v2(26.32,111.68)
  S10 w0.102: v2(75.95,104.78) 76.35,105.18 76.35,105.9 75.62,106.63 75.62,109.12 74.04,110.69 72.89,110.69 71.4,112.18 71.4,112.64 70.98,113.06 67.69,113.06 67.66,113.03 65.21,113.03 64.29,113.94 63.55,113.94 62.59,112.98 61.7,112.98 61.19,112.47 58.51,112.47 56.39,114.59 49.32,114.59 48.67,113.94 37.17,113.94 34.68,111.46 26.55,111.46 v2(26.32,111.68)
  BOTTOM w0.114: v1(26.77,112.67) 26.32,112.22 v2(26.32,111.68) ; v2(75.95,104.78) R473.1 76.91,104.78 R477.1
FORCE_MEMPROCHOT: length 124.6
  TOP w0.114: U12.K5 v3(192.09,52.61)
  S8 w0.102: v3(192.09,52.61) 192.09,52.64 191.62,53.11 188.92,53.11 180.06,44.25 171.06,44.25 166.83,40.02 166.77,40.02 166.74,40.06 137.86,40.06 132.33,34.52 124.4,34.52 123.43,33.55 122.95,33.55 122.26,34.24 99.14,34.24 v2(99.03,34.14)
  BOTTOM w0.114: v2(99.03,34.14) 98.18,34.14 98.18,34.14 97.97,34.14 97.51,34.6 97.51,35.32 95.91,36.92 95.91,38.02 94.97,38.96 94.97,39.4 92.35,42.01 87.99,42.01 87.45,42.55 86.11,42.55 Q13.G 85.09,43.61 Q12.G v1(83.64,45.11)
FP_LED9_N: length 43
  TOP w0.114: LED17.C v2(190.6,16.31) ; U12.M14 v3(202.09,50.61)
  S8 w0.102: v2(190.6,16.31) 190.6,19.57 194.92,23.89 194.92,33.12 196.5,34.7 197.68,34.7 200.36,37.37 200.36,38.55 203.47,41.67 203.47,48.39 203.56,48.48 203.56,48.82 203.47,48.91 203.47,49.4 203.07,49.79 203.07,49.86 203.07,50.17 202.63,50.61 v3(202.09,50.61)
FP_LED9_N_R: length 1.9
  TOP w0.114: v2(190.6,12.9) LED17.A
  BOTTOM w0.114: LED17.A v2(190.6,12.9)
FP_LED10_N: length 45.2
  TOP w0.114: LED16.C v2(188.82,16.46) ; U12.M12 v3(200.09,50.61)
  S8 w0.102: v3(200.09,50.61) 200.53,50.16 202.44,50.16 202.75,49.85 202.75,48.13 202.56,47.95 202.56,47.32 203.24,46.64 203.24,41.76 200.13,38.65 200.13,37.47 197.59,34.92 196.4,34.92 194.69,33.21 194.69,24.09 189.84,19.23 189.84,17.48 v2(188.82,16.46)
FP_LED10_N_R: length 1.9
  TOP w0.114: v2(188.82,12.88) LED16.A
  BOTTOM w0.114: LED16.A v2(188.82,12.88)
GPIO33: length 6.8
  TOP w0.114: U9.AN11 98.32,87.19 v4(98.61,87.48)
  BOTTOM w0.114: v4(98.61,87.48) 98.23,87.48 97.14,88.57 97.14,88.99 97.34,89.18 97.34,89.79 97.72,90.17 v1(97.72,90.61) 97.72,90.68 97.66,90.73 R523.2 R520.1
GPIO61_JTAG_EN_R: length 13.3
  TOP w0.114: U9.BB18 94.3,84.35 94.34,84.38 v4(94.34,84.38)
  BOTTOM w0.114: v4(94.34,84.38) 94.34,84.65 93.41,85.58 91.08,85.58 90.56,86.09 90.56,86.36 90.22,86.71 90.22,87.17 90.05,87.35 88.89,87.35 88.71,87.53 88.71,88.09 89.08,88.46 89.08,89.11 89.32,89.35 89.32,90.55 v1(88.71,91.16) 88.39,91.48 R131.2
HS1_PIN1: length 4
  TOP w0.381: C25.2 59.56,105.97 v2(61.97,103.56)
  vias: v2(61.24,101.37) v2(62.19,99.23) v2(64.4,98.31) v2(66.66,99.21) v2(66.77,103.71) v2(67.7,101.44)
HS1_PIN2: length 4.1
  TOP w0.381: v2(127.7,101.44) 131.33,101.44 C42.2
  vias: v2(121.24,101.37) v2(121.97,103.56) v2(122.19,99.23) v2(124.4,98.31) v2(126.66,99.21) v2(126.77,103.71)
HS1_PIN3: length 4
  TOP w0.381: C124.2 HS1.3
  vias: v2(61.24,41.37) v2(61.97,43.56) v2(62.19,39.23) v2(64.4,38.31) v2(66.66,39.22) v2(66.77,43.71) v2(67.7,41.44)
HS1_PIN4: length 3.9
  TOP w0.381: C138.2 v2(124.4,38.31)
  vias: v2(121.24,41.37) v2(121.97,43.56) v2(122.19,39.23) v2(126.66,39.22) v2(126.77,43.71) v2(127.7,41.44)
HW_BMC_PRESENT: length 14.3
  S3 w0.102: v2(23.44,69.22) 22.48,70.18 18.41,70.18 17.17,68.94 15.93,68.94 v2(15.54,69.32)
  BOTTOM w0.114: CONN14.32 15.48,69.38 v2(15.54,69.32) ; R914.1 R913.2 24.38,68.86 v1(23.98,68.45) 23.44,68.99 v2(23.44,69.22)
