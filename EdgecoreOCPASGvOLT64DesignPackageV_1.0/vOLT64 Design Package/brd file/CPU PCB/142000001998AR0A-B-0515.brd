# Allegro board 142000001998AR0A-B-0515.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
P1V2_VDDQ on S8: 38.51,39.6 54.05,39.6 56.72,36.93 56.72,31.37 55.3,29.95 44.04,29.95 41.58,27.48 28.96,27.48 27.56,28.88 27.56,53.59 30.86,56.9 30.86,76.02 31.37,76.53 33.55,76.53 34.06,76.02 34.06,63.6 36.55,61.11 36.55,55.07 32.82,51.33 32.82,45.29
P1V2_VDDQ on G9: 84.45,76.05 85.29,75.21 85.29,74.42 84.45,73.58 84.45,72.87 85.09,72.24 85.09,70.56 84.45,69.93 84.45,64.49 84.17,64.05 80.06,59.94 66.76,59.94 66.25,59.44 57.33,59.44 56.85,59.92 54.71,59.92 54.23,59.44 48.51,59.44 48.39,59.31 47.43,59.31 47.4,59.28 32.16,59.28 30.73,60.71 30.73,75.82 31.31,76.39 41.24,76.39 41.63,76 46.94,76 47.36,75.58 48.68,75.58 49.56,74.7 62.64,74.7 63.22,74.12 68.81,74.12 69.24,74.55 76.38,74.55 76.86,75.03 76.86,78 78.46,79.6 83.21,79.6 84.45,78.36
P1V2_VDDQ on G11: 84.45,76.94 84.45,74.47 85.01,73.91 85.01,70.46 84.45,69.9 84.45,64.49 84.09,64.13 81.24,64.13 81.2,64.09 80.22,64.09 77.52,61.39 73.1,61.39 73.03,61.47 70.13,61.47 69.8,61.14 65.66,61.14 63.96,59.44 57.76,59.44 57.28,59.92 54.51,59.92 54.03,59.44 48.51,59.44 48.39,59.31 47.43,59.31 47.4,59.28 32.16,59.28 30.99,60.45 30.99,75.79 31.39,76.2 46.53,76.2 47.22,75.51 57.51,75.51 59.08,77.09 70.76,77.09 70.99,76.86 75.72,76.86 75.73,76.87 75.96,76.87 76.15,77.06 76.15,77.29 77.15,78.3 80.28,78.3 80.47,78.11 81.97,78.11 82.07,78.21 82.45,78.21 82.6,78.05 83.34,78.05
P1V05 on TOP: 127.76,81.28 127.76,79.96 127.25,79.45 126.31,79.45 124.99,78.13 124.99,75.64 124.56,75.21 122.43,75.21 122.17,75.46 122.17,79.5 122.43,79.76 123.57,79.76 123.95,80.14 123.95,81.15 124.17,81.37 125.39,81.37 125.77,81.75 127.29,81.75
P1V05 on TOP: 132.77,63.88 134.49,63.88 134.72,63.65 134.72,59.61 134.14,59.03 132.94,59.03 132.59,59.39 132.59,63.7
P1V05 on TOP, BOTTOM: 106.93,33.5 102.74,33.5 102.25,33.01 101.59,33.01 101.22,32.64 101.22,27.43 102.11,26.54 114.05,26.54 114.3,26.8 114.3,28.57 114.55,28.83 120.52,28.83 120.9,29.21 120.9,34.29 120.52,34.67 115.19,34.67 113.79,33.27 107.16,33.27
P1V05 on BOTTOM: 120.9,79.17 125.09,79.17 125.55,78.71 125.55,76.4 124.16,75.01 122.48,75.01 120.93,73.46 119.13,73.46 118.54,74.04 117.6,74.04 117.37,74.27 117.37,75.92 117.63,76.17 119.96,76.17 120.42,76.63 120.42,78.69
P1V05 on S5: 71.25,109.22 71.63,108.84 71.63,107.31 71.12,106.81 61.59,106.81 59.94,105.16 20.7,105.16 19.05,106.81 19.05,108.97 19.43,109.35 47.75,109.35 50.55,106.55 56.52,106.55 59.18,109.22
P1V05 on S5: 104.01,73.25 120.17,73.25 122.4,71.02 122.4,69.72 122.05,69.37 120.02,69.37 119.51,69.88 110.06,69.88 109.7,69.52 102.54,69.52 102.11,69.95 102.11,70.87 102.37,71.13 102.37,71.62
P1V05 on V6: 121.03,69.34 120.78,69.6 120.78,78.99 121.67,79.88 124.51,79.88 126.42,81.79 132.79,81.79 145.75,68.83 169.24,68.83 169.98,69.57 169.98,78.21 170.21,78.44 172.82,78.44 173.05,78.21 173.05,68.86 173.66,68.25 178.05,68.25 178.64,67.67 178.64,46.89 177.93,46.18 170.87,46.18 170.18,46.86 170.18,59.39 169.49,60.07 141.3,60.07 132.03,69.34
P1V05 on V7: outline of 104 points within 7.42,5.33 178.61,122.22
P1V5_A_L_I210 on S5: 144.96,88.42 145.68,89.15 148.67,89.15 149.05,88.77 149.05,85.01 148.5,84.47 139.78,84.47 139.26,85 139.26,86.04 139.23,86.07 139.23,87.59 140.06,88.42
P1V5_PCH on TOP: 130.05,74.55 130.05,73.15 129.79,72.9 125.86,72.9 125.48,73.28 125.48,75.92 125.65,76.1 128.32,76.1 128.47,75.95 128.47,75.41 129.21,74.68 129.92,74.68
P1V05_PCH on TOP: 120.85,83.24 121.03,83.41 121.03,83.97 121.31,84.25 124.89,84.25 125.22,83.92 125.22,82.35 124.92,82.04 114.25,82.04 113.87,82.42 113.87,82.88 114.22,83.24
P1V5_PCH on S3: 128.63,73.99 127.79,73.15 125.76,73.15 118.59,80.31 117.07,80.31 114.25,83.13 109.96,83.13 107.7,80.87 107.7,76.2 107.06,75.56 95.07,75.56 94.77,75.87 94.77,77.55 95.73,78.51 98.42,78.51 99.95,80.04 99.95,89.53 101.6,91.19 103.5,91.19 104.27,91.95 104.27,99.97 104.7,100.41 111.35,100.41 122.03,89.73 122.85,89.73 123.9,88.67 123.9,87.86 126.39,85.37 126.39,84.73 126.85,84.28 127.48,84.28 128.63,83.13
P1V05_PCH on S5: 107.95,82.04 107.31,81.41 104.62,81.41 104.14,80.92 100.79,80.92 100.51,81.2 100.51,84.48 101.37,85.34 101.98,85.34 102.87,86.23 111.89,86.23 112.37,86.71 123.47,86.71 123.52,86.66 123.52,82.4 123.16,82.04
P1V05_PCH on V7: 109.92,85 109.98,85 111.7,86.72 113.15,86.72 114.21,87.77 114.88,87.77 115.94,86.72 123.16,86.72 123.5,86.37 123.5,82.17 121.64,80.31 121.27,80.31 120.12,79.16 111.06,79.16 111.02,79.12 101.42,79.12 98.93,81.61 98.93,83.82 98.3,84.45 98.3,85.47 98.42,85.6 99.44,85.6 99.69,85.34 99.69,84.96 100.71,83.95 108.87,83.95
P1V05_PCH on S10: 102.55,82.52 103.63,81.44 103.63,80.64 101.37,78.38 101.37,70.74 100.69,70.05 100.13,70.05 99.59,70.59 99.59,76.25 98.42,77.42 98.42,78.77 97.97,79.22 97.33,79.22 97.32,79.21 96.69,79.21 96.39,79.5 96.39,80.01 96.86,80.48 96.86,82.54 97.39,83.07 98.52,84.2 98.52,84.9 99.38,85.76 102.43,85.76 102.55,85.64
P1V05_VCC_PCH on TOP: 119.48,81.71 123.39,81.71 123.7,81.41 123.7,80.59 123.47,80.37 121.84,80.37 121.13,79.65 119.63,79.65 119.25,80.04 119.25,81.48
P1V05_VCC_PCH on V6: 123.94,86.62 125.35,85.22 125.35,81.46 124.28,80.39 121.69,80.39 120.93,79.63 119.68,79.63 119,80.31 117.65,80.31 116.54,79.2 101.09,79.2 100.37,79.92 98.49,79.92 98.11,80.3 98.11,81.25 98.7,81.85 98.7,84.09 98.35,84.45 98.35,87.43 100.2,89.28 113.16,89.28 115.82,86.61 121.54,86.61 121.79,86.62
P1V05_VCCGBE on TOP: 106.17,68.88 106.17,68.05 106.05,67.92 104.27,67.92 103.17,69.01 103.17,69.54 103.3,69.67 104.33,69.67 104.47,69.53 104.81,69.53 105.03,69.32 105.33,69.32 105.44,69.42 105.64,69.42 105.74,69.32 106.12,69.32 106.25,69.44 106.38,69.44 106.43,69.39 106.43,68.91 106.4,68.88
P1V05_VCCGBE on TOP: 125.76,62.76 131.78,62.76 131.98,62.56 131.98,59.33 131.7,59.05 123.29,59.05 122.83,59.51 122.83,62.03 123.01,62.2 125.2,62.2
P1V05_VCCGBE on TOP: 103.35,65.51 103.66,65.2 106.48,65.2 106.76,65.48 106.76,65.89 106.63,66.01 105.41,66.01 105.33,66.09 105.33,66.98 105.31,67 105.03,67 104.85,67.18 104.62,67.18 104.47,67.03 104.19,67.03 104.06,67.16 103.84,67.16 103.68,67 103.68,66.75 103.81,66.62 103.81,66.24 103.43,65.86 103.38,65.86 103.35,65.84
P1V05_VCCGBE on V6: 131.42,63.32 131.42,60.93 130.48,59.99 108.26,59.99 102.93,65.32 102.93,68.64 103.89,69.6 118.24,69.6 118.87,68.96 128.02,68.96 129.2,67.78 129.2,65.54
P1V05_VCCGBE on V7: 130.76,64.67 130.76,60.76 129.88,59.87 125.22,59.87 118.4,66.69 109.46,66.69 108.13,65.35 108.13,61.49 108.79,60.83 113.13,60.83 113.45,60.51 113.45,55.37 113.11,55.03 107.73,55.03 105.15,57.61 105.15,59.48 103.9,60.73 103.9,62.12 102.93,63.09 102.93,68.64 103.89,69.6 119.11,69.6 119.75,68.96 126.47,68.96
P1V05_VCCGBE on S8: 105.28,67.6 105.41,67.73 105.41,68.07 105.79,68.45 105.79,69.76 104.52,71.03 104.52,73.76 104.46,73.82 102.87,73.82 102.81,73.76 102.81,65.98 103.02,65.76 104.49,65.76 105.28,66.55
P1V05_VCCGBE on S10: 103.23,65.41 104.01,64.62 106.43,64.62 107.01,65.2 107.01,68.05 107.59,68.63 112.37,68.63 121.67,59.33 131.24,59.33 131.67,59.77 131.67,65.46 130.33,66.8 126.36,66.8 119.39,73.77 119.39,76.77 117.98,78.18 110.24,78.18 109.78,78.64 108.18,78.64 108.18,78.26 108.1,78.18 104.09,78.18 103.23,77.32
P1V05_VCCION on TOP: 120.47,77.39 121.28,77.39 121.49,77.19 121.49,75.01 121.02,74.54 119.01,74.54 118.69,74.85 118.69,75.77 118.97,76.05 119.84,76.05 120.42,76.63 120.42,77.34
P1V05_VCCION on V6: 97.79,81.15 97.79,79.92 98.04,79.67 99.57,79.67 99.57,79.63 99.95,79.63 100.97,78.61 110.36,78.61 111.12,77.85 119.76,77.85 120.02,77.6 120.02,76.83 120.14,76.71 120.14,74.73 119.96,74.55 103.63,74.55 102.68,73.6 102.68,67.28 102.55,67.16 99.12,67.16 94.95,71.33 94.95,72.56 93.42,74.09 93.42,82.37 93.94,82.89 96.98,82.89 98.02,83.92 98.48,83.92 98.6,83.79 98.6,81.97
P1V05_VCCION on V7: 98.54,79.67 99.57,79.67 99.57,79.63 99.95,79.63 100.59,78.99 118.63,78.99 120.02,77.6 120.02,76.83 120.14,76.71 120.14,74.75 119.94,74.55 103.63,74.55 102.68,73.6 102.68,63.16 102.93,62.91 102.93,61.67 102.86,61.6 102.41,61.6 101.4,62.61 99.83,62.61 99.54,62.9 99.54,65.78 98.63,66.68 98.63,67.65 94.95,71.33 94.95,72.56 93.34,74.17 93.34,80.52 93.85,81.03 95.12,81.03 98.17,84.07 98.55,84.07 98.81,83.82 98.81,82.17 98.17,81.53 98.17,80.04
P1V05_VCCION on S8: 101.85,69.44 99.69,69.44 98.97,68.72 98.97,67.56 99.31,67.22 102.23,67.22 102.55,67.54 102.55,68.74
P1V05_VCCSCSUS on TOP: 104.65,69.9 104.89,69.9 104.89,69.9 104.97,69.9 105.01,69.86 105.01,69.59 105.04,69.55 105.24,69.55 105.59,69.9 105.74,69.9 105.8,69.84 105.8,69.68 105.87,69.61 106.02,69.61 106.08,69.67 106.08,69.84 106.15,69.9 106.45,69.9 106.71,69.64 106.8,69.64 106.93,69.77 106.93,70.79 106.55,71.18 104.52,71.18 104.47,71.13 104.47,70.08
P1V05_VCCSCSUS on BOTTOM: 109.25,73.99 110.16,73.99 110.24,73.91 110.24,71.86 109.02,70.64 107.09,70.64 106.78,70.33 106.78,70.13 106.53,69.88 104.27,69.88 104.09,70.05 104.09,70.99 104.55,71.45 105.84,71.45 106.38,71.98 107.42,71.98 107.89,72.45 108.37,72.45 108.97,73.05 108.97,73.71
P1V05_VCCSCSUS on BOTTOM: 117.55,73.46 118.87,73.46 119.1,73.23 120.88,73.23 121.18,72.92 121.18,70.51 120.85,70.18 119.76,70.18 117.45,72.49 117.45,73.36
P1V05_VCCSCSUS on V6: 119.89,69.85 103.38,69.85 102.93,70.29 102.93,73.15 104.08,74.3 119.13,74.3 120.57,72.85 120.57,70.54
P1V05_VCCSCSUS on V7: 119.74,69.7 103.53,69.7 102.93,70.29 102.93,73.15 104.08,74.3 119.13,74.3 120.27,73.15 120.27,70.23
P1V7_SW on TOP: 168.2,67.54 164.49,67.54 162.53,69.49 160.91,69.49 160.83,69.57 160.83,70.54 160.91,70.61 168.1,70.61 168.38,70.33 168.38,67.72
P3V3 on TOP (solid shape): 160.53,107.31 160.53,106.68 160.27,106.43 157.86,106.43 157.61,106.68 157.61,107.31 157.86,107.57 160.27,107.57
P3V3 on TOP: 144.78,56.13 144.4,55.75 144.4,49.4 145.03,48.77 157.71,48.77 162.36,53.42 162.36,55.83 162.05,56.13
P3V3 on TOP: 203.54,74.43 205.37,74.43 205.53,74.59 205.53,76.17 205.32,76.38 203.38,76.38 203.1,76.1 203.1,74.87
P3V3 on BOTTOM: 98.55,73.99 97.46,73.99 97.13,74.32 96.14,74.32 96.04,74.22 96.04,73.53 96.22,73.36 97.16,73.36 97.38,73.13 97.38,72.72 97.46,72.64 98.63,72.64 98.76,72.77 98.76,73.79
P3V3 on S3: 20.73,122.33 31.75,122.33 32.26,121.82 32.26,109.7 30.48,107.92 21.89,107.92 21.39,108.43 21.39,119.89 20.45,120.83 20.45,122.05
P3V3 on S5: 126.97,84.15 126.97,79.3 121.11,73.43 103.86,73.43 102.49,72.06 97.56,72.06 97.38,72.24 97.38,73.66 97.69,73.96 101.88,73.96 102.39,74.47 102.39,76.3 103,76.91 118.9,76.91 120.29,78.31 120.29,79.72 121.5,80.93 122.91,80.93 123.9,81.92 123.9,84.3 124.18,84.58 126.54,84.58
P3V3 on V6: outline of 131 points within 1.5,1.14 208.08,122.68 ; 1 cut-out
P3V3_A on TOP: 158.85,39.52 158.85,48.18 162.15,51.49 163.91,51.49 164.62,50.77 164.62,39.78 163.98,39.14 159.23,39.14
P3V3_A on TOP: 174.47,98.76 179.58,98.76 179.96,98.37 179.96,96.01 177.93,93.98 176.15,93.98 174.22,95.91 174.22,98.5
P3V3_A on BOTTOM: 163.91,51.49 164.62,50.77 164.62,43.28 163.65,42.32 160.05,42.32 159.18,43.18 159.18,48.51 162.15,51.49
P3V3_A on V7: 177.04,122.1 175.77,120.83 175.77,78.84 179.24,75.37 179.24,46.58 178.14,45.49 139.19,45.49 137.79,44.09 137.79,26.19 136.53,24.92 96.55,24.92 87.6,15.98 57.66,15.98 46.74,5.05 23.34,5.05 22.23,6.17 22.23,13.67 23.83,15.27 42.37,15.27 53.67,26.57 87.96,26.57 93.68,32.28 93.68,36.45 93.31,36.82 91.17,36.82 90.63,36.27 90.63,33.27 86.39,29.03 64.65,29.03 63.72,29.95 63.72,36.7 63.41,37.01 62.21,37.01 60.26,38.96 10.31,38.96 8.08,41.2 8.08,105.11 6.05,107.14 2.39,107.14 1.09,105.84 1.09,1.93 2.03,0.99 80.16,0.99 80.37,1.19 207.57,1.19 207.95,1.57 207.95,121.84 207.7,122.1 ; 1 cut-out
P3V3_A_L_I210 on TOP: 176.28,102.36 176.28,100.2 176.15,100.08 171.95,100.08 171.86,100.16 169.33,100.16 167.51,101.98 167.51,103.12 167.77,103.38 175.26,103.38
P3V3_A_L_I210 on V7: 173.46,76.76 132.56,76.76 131.85,77.47 131.85,102.26 132.8,103.21 132.8,104.18 134.21,105.59 134.21,111.09 136.13,113.02 136.13,116.84 135.62,117.35 133.35,117.35 132.97,117.73 132.97,120.65 134.54,122.22 141.15,122.22 142.49,120.88 151.82,120.88 153.03,122.1 173.53,122.1 175.16,120.47 175.16,78.46
P3V3_BATT on S8: 94.01,84.45 92.08,86.39 92.08,90.93 93.73,92.58 93.73,92.61 95,93.88 95.81,93.88 96.14,93.55 96.14,92.68 95.86,92.41 95.86,91.72 96.75,90.83 96.75,85.14 96.06,84.45
P3V3_L_PCH on TOP: 106.71,7.39 106.71,6.02 106.2,5.51 103.73,5.51 103.68,5.56 103.68,6.6 104.8,7.72 104.8,10.31 105,10.52 107.87,10.52 108.1,10.29 108.1,8.79
P3V3_PCH on TOP: 108.86,4.72 107.39,4.72 107.04,4.37 107.04,3.99 106.83,3.78 103.91,3.78 103.68,3.56 103.68,3.02 103.89,2.82 104.27,2.82 104.44,2.64 104.44,1.55 104.62,1.37 108.1,1.37 108.33,1.6 108.33,3.1 108.46,3.23 108.79,3.23 108.99,3.43 108.99,4.6
P3V3_PCH on V7: 94.23,86.49 94.93,85.79 100.65,85.79 101.47,84.96 104.78,84.96 105,84.73 108.71,84.73 110.85,86.87 112.88,86.87 114.08,88.08 114.86,88.08 116.07,86.87 122.91,86.87 123.34,87.31 123.34,90.57 112.72,101.19 109.6,101.19 105.93,104.86 105.93,111.45 104.53,112.84 86.16,112.84 83.11,115.9 78.41,115.9 77.9,116.41 77.52,116.41 77.01,115.9 63.37,115.9 62.32,114.85 62.32,111.65 63.37,110.59 71.3,110.59 72.16,109.73 72.16,106.93 74.19,104.9 79.22,104.9 82.87,101.01 94.23,89.65 ; 1 cut-out
P3V3_PCH on S8: 98.79,76.31 98.93,76.17 103.38,76.17 104.14,76.94 104.14,86.69 103.76,87.07 98.76,87.07 98.16,86.47 98.16,84.57 98.16,84.57 98.16,83.27 97.42,82.54 96.25,82.54 94.61,80.9 94.61,80.04 94.84,79.81 95.4,79.81 96.09,79.12 97.74,79.12 98.79,78.07
P3V3_PCH on S8: 114.94,48.56 114.27,49.23 114.27,53.29 118.25,57.26 118.25,58.56 119.13,59.44 120.42,59.44 123.57,62.59 123.57,70.56 122.43,71.7 113.97,71.7 113.41,72.26 113.41,93.47 114.1,94.16 116.79,94.16 116.81,94.18 129.84,94.18 130.81,93.22 130.81,79.1 131.32,78.59 138.56,78.59 139.73,77.42 139.73,70.33 117.96,48.56 ; 1 cut-out
P3V3_PCH on S10: 114.78,51.77 114.78,50.16 115.67,49.28 115.67,45.92 109.89,40.14 109.89,18.35 102.01,10.46 102.01,3.02 102.95,2.08 108.88,2.08 109.14,2.34 109.14,6.88 110.26,8 112.19,8 115.39,11.2 115.39,31.72 117.97,34.3 117.97,51.02 116.87,52.12 115.14,52.12
P3V3_PCH on S10: 137.87,73.69 137.87,69.14 138.1,68.91 167.06,68.91 168.28,67.69 168.28,51.1 168.94,50.44 173.43,50.44 174.02,51.03 174.02,71.35 172.09,73.28 171.32,73.28 171.07,73.53 171.07,77.93 170.43,78.56 143.97,78.56 143.38,77.98 143.38,77.6 142.95,77.17 141.35,77.17
P3V3_PCH_L on TOP: 107.09,6.07 106.25,5.23 104.57,5.23 104.52,5.18 104.52,4.27 104.67,4.11 106.43,4.11 107.7,5.38 109.88,5.38 110.16,5.66 110.16,6.83 109.96,7.04 107.44,7.04 107.09,6.68
P3V3_STBY on BOTTOM: 10.34,16.26 19.28,16.26 20.19,17.17 22.83,17.17 23.01,16.99 23.01,15.27 22.3,14.55 12.29,14.55 11.53,13.79 10.21,13.79 9.96,14.05 9.96,15.88
P5V on TOP (solid shape): 163.83,109.6 163.83,108.2 163.58,107.95 162.56,107.95 162.31,107.7 162.31,106.68 162.05,106.43 161.16,106.43 160.78,106.81 160.78,107.7 160.91,107.82 160.91,109.47 161.29,109.86 163.58,109.86
P5V on TOP: 168.02,75.41 164.49,75.41 164.31,75.59 164.31,77.22 164.57,77.47 169.52,77.47 169.83,77.16 169.83,73.57 169.57,73.3 168.68,73.3 168.28,73.71 168.28,75.16
P5V on TOP: 122.15,119.35 131.7,119.35 131.9,119.15 131.9,115.32 131.46,114.88 130.61,114.88 130.43,115.06 130.43,115.47 130.38,115.53 127.65,115.53 126.77,116.41 122.63,116.41 120.85,114.63 115.95,114.63 115.67,114.91 115.67,117.96 115.87,118.16 120.95,118.16
P5V on TOP: 127.74,33.39 127.28,33.85 126.38,33.85 125.47,32.93 123.89,32.93 123.29,32.34 123.29,13.44 123.83,12.9 126.87,12.9 127.74,13.77
P5V on TOP: 60.22,19.33 61.7,19.33 61.85,19.48 62.2,19.48 62.38,19.3 62.38,18.26 62.13,18.01 60.2,18.01 60.02,18.19 60.02,19.13
P5V on TOP: 78.94,23.16 80.52,23.16 80.75,22.94 80.75,21.16 80.47,20.88 78.94,20.88 78.64,21.18 78.64,22.86
P5V on BOTTOM: 124.56,15.85 126.85,15.85 127.13,15.57 127.13,13.64 126.42,12.93 124.59,12.93 124,13.51 124,13.82 124.38,14.2 124.38,15.67
P5V on S5: 122.74,118.44 122.28,117.97 122.28,97.13 122.29,97.12 122.29,95.75 127.46,90.58 127.46,73.39 132.36,68.49 156.51,68.49 157.23,67.77 157.23,34.9 157.2,34.9 156.24,33.93 125.27,33.93 123.71,32.37 123.77,32.31 123.77,13.39 124.46,12.7 129.16,12.7 129.92,13.46 129.92,23.09 131.14,24.31 165,24.31 169.77,29.08 169.77,76.58 164.39,81.97 164.39,112.85 164.92,113.39 170.36,113.39 172.52,115.54 178.92,115.54 180.77,113.69 183.69,113.69 185.22,112.17 185.85,112.17 186.28,112.6 186.28,115.87 185.7,116.46 181.2,116.46 179.68,117.98 171.07,117.98 170.13,117.04 132.38,117.04 130.99,118.44
P5V on V6: 57.51,26.21 57.51,19.79 58.55,18.75 61.11,18.75 61.75,18.11 62.53,18.11 63.17,18.75 85.78,18.75 95.1,28.07 126.97,28.07 127.61,28.7 127.61,34.19 127,34.8 91.69,34.8 83.97,27.08 58.37,27.08
P5V on V7: 117.2,122.22 133.65,122.22 133.67,122.21 135.47,122.21 135.76,121.92 135.76,113.33 134.11,111.68 134.11,105.77 132.49,104.15 120.95,104.15 116.31,108.79 116.31,121.34
P5V_A on TOP: 87.76,19.08 88.98,19.08 89.15,18.9 89.15,18.44 88.95,18.24 87.78,18.24 87.68,18.34 87.68,19
P5V_A on TOP: 73.38,18.87 77.29,18.87 78.31,19.89 80.57,19.89 80.85,19.61 80.85,18.11 80.49,17.75 73.69,17.75 73.3,18.14 73.3,18.8
P5V_B on TOP: 120.57,17.17 120.57,16.46 120.68,16.36 120.9,16.36 121.06,16.21 121.06,13.84 121.13,13.77 121.54,13.77 121.74,13.97 121.74,16.99 121.51,17.22 120.62,17.22
P5V_CONN on BOTTOM: 157.48,6.17 159.51,6.17 159.69,6.35 159.69,10.44 159.99,10.74 166.85,10.74 166.95,10.85 166.95,12.29 166.9,12.34 157.56,12.34 157.38,12.17 157.38,6.27
P5V_STBY on TOP: 160.57,27.13 164.33,27.13 164.52,26.93 164.52,25.2 164.31,24.99 160.41,24.99 160.26,25.15 160.26,26.81
P5V_STBY on BOTTOM: 170.46,6.87 170.46,4.62 170.1,4.27 168.22,4.27 167.87,4.62 167.87,10.52 167.64,10.74 167.64,13.65 168.42,14.43 168.42,16.14 160.42,24.14 160.42,25.55 160.98,26.11 166.06,26.11 171.19,20.98 171.19,18.13 172.49,16.83 172.49,8.9
V1P8A on S10: 198.25,56.39 193.93,56.39 193.55,56.01 193.55,44.2 193.8,43.94 197.36,43.94 198.63,45.21 198.63,56.01
V3P3_SW on TOP: 155.57,46.74 155.96,46.35 155.96,43.56 155.7,43.31 153.29,43.31 153.11,43.13 153.11,40.59 153.03,40.51 152.1,40.51 151.97,40.64 151.97,43.1 151.76,43.31 149.35,43.31 149.1,43.56 149.1,46.35 149.48,46.74
V3P3A_SW on TOP: 166.6,34.52 166.6,33.48 166.5,33.38 158.8,33.38 158.47,33.71 158.47,35.59 158.9,36.02 163.58,36.02 165,34.59 166.52,34.59
V5A_PM_P1V7 on TOP: 165.33,71.42 160.81,71.42 160.63,71.6 160.63,74.19 160.96,74.52 165.81,74.52 166.04,74.3 166.04,72.14
V5A_SW on TOP: 119.94,112.39 120.8,111.53 123.47,111.53 123.52,111.48 123.52,110.52 123.44,110.44 121.56,110.44 119.84,108.71 116.11,108.71 115.72,109.1 115.72,112.22 115.9,112.39
V12A_CONN on TOP: 158.17,17.58 161.34,17.58 161.52,17.4 161.52,8.59 161.98,8.13 161.98,6.07 160.1,4.19 157.71,4.19 156.11,5.79 156.11,13.87 157.68,15.44 157.68,17.09
V12A_CONN on BOTTOM: 156.46,1.14 156.46,9.7 156.08,10.08 156.08,13.46 156.34,13.72 156.97,13.72 157.23,13.46 157.23,6.17 157.56,5.84 159.84,5.84 160.02,6.02 160.83,6.02 161.37,5.49 161.37,3.23 159.16,1.02 156.59,1.02
V12A_CONN_R on TOP: 167.39,22.94 167.87,22.45 167.87,16.22 167.02,15.37 162.59,15.37 162.28,15.67 162.28,17.58 162.81,18.11 164.1,18.11 164.34,18.35 164.34,22.61 164.67,22.94
V12A_DDR on TOP (solid shape): 55.77,19.21 54.3,19.21 54.3,20.84 55.77,20.84
V12A_DDR on BOTTOM (solid shape): 47.73,18.59 47.73,17.14 47.09,16.51 41.45,16.51 41.12,16.84 41.12,19.3 41.43,19.61 46.71,19.61
V12A_DDR on TOP: 41.96,15.9 40.03,13.97 38.99,13.97 38.61,14.35 38.61,18.08 41.15,20.62 52.07,20.62 52.27,20.42 52.27,19.35 48.82,15.9
V12A_DDR on TOP: 55.85,20.78 55.85,19.1 55.58,18.82 55.17,18.82 54.13,17.78 49.78,17.78 48.62,18.95 48.62,20.5 48.74,20.62 52.32,20.62 52.58,20.88 55.75,20.88
V12A_DDR on BOTTOM: 48.54,20.65 52.02,20.65 52.22,20.45 52.22,18.92 51.89,18.59 48.74,18.59 48.44,18.9 48.44,20.55
V12A_PM_V3P3A on TOP: 169.98,28.88 169.98,30.91 169.77,31.11 167.41,31.11 166.8,31.72 166.8,32.56 166.73,32.64 165.1,32.64 164.26,31.8 164.26,29.83 164.05,29.62 162.72,29.62 162.59,29.49 162.59,28.04 162.76,27.87 165.21,27.87 166.15,28.8 169.9,28.8
V12A_V3P3 on TOP: 151.16,42.21 151.16,40.67 151.05,40.56 149.53,40.56 149.33,40.77 146.41,40.77 145.92,40.28 144.75,40.28 144.55,40.49 144.55,43.28 144.78,43.51 147.57,43.51 148.51,42.57 150.8,42.57
V12A_V5A on TOP: 117.81,107.95 118.06,107.7 119.84,107.7 119.9,107.76 120.82,107.76 121.46,108.4 121.46,109.1 121.94,109.59 123.54,109.59 123.65,109.48 123.65,107.28 122.69,106.32 119.56,106.32 119.08,105.84 115.65,105.84 115.4,105.59 114.22,105.59 114.1,105.71 114.1,107.74 114.3,107.95
VCC12A on TOP: 111.76,107.57 113.08,107.57 113.36,107.29 113.36,103.73 113.46,103.63 113.69,103.63 113.87,103.45 113.87,103.15 113.56,102.84 111.91,102.84 111.33,103.43 111.33,107.14
VCC12A on TOP: 92.11,17.13 92.28,16.97 92.28,14.27 91.95,13.94 88.16,13.94 87.86,14.25 87.86,16.13 88.86,17.13
VCC12A on TOP: 168.25,26.19 168.25,27.84 168.5,28.09 172.01,28.09 172.72,28.8 174.17,28.8 174.42,28.55 174.42,27.08 173.41,26.06 168.38,26.06
VCC12A on TOP: 161.29,18.85 149.68,18.85 149.1,19.43 149.1,22.48 149.86,23.24 161.16,23.24 161.67,22.73 161.67,19.23
VCC12A on TOP: 119.68,10.26 120.09,10.67 120.78,10.67 121.34,11.23 121.34,12.67 121.44,12.78 123.75,12.78 123.95,12.57 126.36,12.57 126.62,12.32 126.62,8.86 126.31,8.56 120.07,8.56 119.68,8.94
VCC12A on TOP: 18.24,18.49 23.04,18.49 23.24,18.29 23.24,16.23 22.71,15.7 19.23,15.7 17.96,16.97 17.96,18.21
VCC12A on TOP: 143.59,43.59 141,43.59 140.59,43.18 140.59,37.59 140.97,37.21 143.31,37.21 143.84,37.74 143.84,43.33
VCC12A on TOP: 36.25,17.86 36.96,17.14 36.96,14.3 36.42,13.77 35.18,13.77 34.77,14.17 34.77,15.14 34.49,15.42 31.42,15.42 31.14,15.7 31.14,17.55 31.45,17.86
VCC12A on BOTTOM: 159.29,18.8 149.73,18.8 149.1,19.43 149.1,22.48 149.86,23.24 159.21,23.24 159.73,22.73 159.73,19.23
VCC12A on S5: 144.55,44.55 133.81,44.55 126.82,37.57 118.9,37.57 96.66,15.33 96.66,2.94 97.27,2.32 104.08,2.32 109.78,8.03 122.12,8.03 122.67,8.58 130.43,8.58 131.46,9.61 132.75,9.61 142.06,18.92 168.55,18.92 174.29,24.66 174.29,28.83 173.96,29.16 170.89,29.16 165.33,23.6 131.7,23.6 130.48,22.38 130.48,13.31 129.26,12.09 124.1,12.09 123.44,12.75 123.44,32.92 124.92,34.39 144.75,34.39 145.39,35.03 145.39,43.71
VCC12A on V6: 51.23,6.12 50.5,6.86 50.5,10.59 47.14,13.94 20.52,13.94 17.68,16.79 17.68,18.64 17.93,18.9 49.56,18.9 50.14,18.31 61.11,18.31 61.57,17.86 62.66,17.86 63.12,18.31 86.61,18.31 95.96,27.66 128.93,27.66 129.92,28.65 129.92,43.54 130.75,44.36 159.55,44.36 162.51,41.4 185.93,41.4 186.61,42.09 186.61,66.88 176.56,76.94 176.56,80.44 154.99,102.01 129.95,102.01 125.95,106 122.69,106 118.69,102.01 111.28,102.01 110.64,102.64 110.64,106.68 111.35,107.39 118.92,107.39 121.7,110.18 128.88,110.18 131.67,107.39 155.75,107.39 157.2,105.94 163.88,105.94 179.04,90.78 179.04,81.76 193.22,67.59 193.22,27.94 191.36,26.09 165.1,26.09 164.72,25.7 164.72,20.32 160.76,16.36 112.06,16.36 109,19.42 105.26,19.42 104.32,18.47 104.32,17.78 99.06,12.52 89.23,12.52 86.35,9.65 72.59,9.65 69.06,6.12
VCC12A on S8: 40.18,2.34 22.63,2.34 17.96,7.01 17.96,18.21 18.47,18.72 23.93,18.72 28.4,14.25 37.52,14.25 40.88,10.88 40.88,3.04
VCC12A_PM_DDR4_VPP on TOP: 28.02,20.83 28.22,20.62 28.22,19.71 27.84,19.33 21.69,19.33 21.56,19.46 21.56,20.55 21.84,20.83
VCC_EUSB on TOP (solid shape): 164.59,105.66 164.59,104.27 164.21,103.89 163.19,103.89 162.69,103.38 162.69,100.08 161.8,99.19 158.75,99.19 158.19,99.75 158.19,105.31 158.67,105.79 164.47,105.79
VCCIN on TOP: outline of 91 points within 65.91,26.44 100.66,76.14
VCCIN on BOTTOM: 92.89,52.37 93.6,52.37 94.16,51.82 95.45,51.82 95.63,51.64 95.63,49.99 94.69,49.05 93.85,49.05 93.57,48.77 92.94,48.77 92.79,48.92 92.79,52.27
VCCIN on BOTTOM: 89.84,67.82 95.94,67.82 96.04,67.72 96.04,66.8 96.37,66.47 96.37,65.15 96.52,65 96.85,65 97,64.85 97,63.88 96.85,63.73 96.6,63.73 96.11,63.25 95.48,63.25 95.3,63.42 95.3,63.88 95.12,64.06 93.19,64.06 92.86,63.73 91.39,63.73 91.14,63.98 91.14,65.33 90.93,65.53 90.93,66.29 90.78,66.45 90.2,66.45 89.76,66.88 89.76,67.74
VCCIN on BOTTOM: 90.47,73.76 95.05,73.76 95.71,73.1 96.6,73.1 96.77,72.92 96.77,72.11 96.62,71.96 90.35,71.96 90.25,72.06 90.25,72.97 90.37,73.1 90.37,73.66
VCCIN on BOTTOM: 72.69,33.45 72.8,33.55 72.8,33.96 73.15,34.32 73.15,34.85 73.33,35.03 86.59,35.03 88.98,32.64 88.98,31.37 88.62,31.01 85.37,31.01 84.61,30.25 83.69,30.25 83.44,30 83.44,28.85 83.29,28.7 70.66,28.7 70.13,29.24 70.13,30.35 69.49,30.99 66.55,30.99 65.91,31.62 65.91,33.15 66.09,33.32 68.45,33.32 68.58,33.45
VCCIN on G2: 99.82,72.39 99.82,71.01 101.03,69.8 101.03,62.58 98.81,60.36 98.55,60.36 98.23,60.04 98.23,59.79 97.22,58.77 97.22,56.36 96.96,56.11 96.96,51.24 96.9,51.18 95.38,51.18 94.36,50.16 93.85,50.16 93.6,50.42 93.6,57.5 93.41,57.7 93.41,57.82 93.41,58.84 93.41,58.84 93.41,59.41 93.03,59.79 93.03,61.69 93.47,62.14 93.47,63.28 92.96,63.79 92.2,63.79 91.38,64.62 91.38,65.7 91.44,65.76 91.44,66.27 91.38,66.33 91.38,69.11 91.95,69.68 91.95,70.14 91.38,70.71 91.38,73.67 91.57,73.86 95.38,73.86 96.22,73.03 99.19,73.03
VCCIN on S3: 98.11,59.66 98.11,51.63 89.76,43.28 89.76,31.32 88.39,29.95 66.95,29.95 65.46,31.45 65.46,33.68 66.12,34.34 73.28,34.34 90.73,51.79 90.73,59.49 85.92,64.3 85.92,74.61 86.23,74.93 97.38,74.93 99.36,72.95 99.36,69.72 100.03,69.06 100.97,69.06 101.35,68.68 101.35,62.9 ; 1 cut-out
VCCIN on S5: 93.45,63.6 95.71,63.6 96.06,63.25 96.06,50.88 92.66,47.47 92.66,33.02 89.74,30.1 66.19,30.1 65.74,30.56 65.74,33.05 66.67,33.99 74.88,33.99 93.09,52.2 93.09,63.25
VCCIN on V6: 88.67,66.56 88.67,66.85 89.13,67.31 89.13,67.77 88.52,68.38 88.52,72.26 89.03,72.77 94.23,72.77 94.49,72.52 94.49,71.35 106.71,59.13 106.71,36.04 106.05,35.38 91.47,35.38 84.38,28.3 66.14,28.3 65.58,28.85 65.58,33.78 66.24,34.44 77.44,34.44 93.47,50.47 93.47,59.79 92.89,60.38 92.89,61.06 93.34,61.52 93.34,63.75 92.56,64.54 90.69,64.54
VCCIN on V7: 99.26,64.91 99.26,59.47 98.91,59.12 98.91,58.14 99.26,57.78 99.26,54.48 98.8,54.02 98.8,53.08 96.9,51.18 95.38,51.18 94.36,50.16 90.88,50.16 89.84,49.12 89.84,33.58 85.6,29.34 66.47,29.34 65.3,30.51 65.3,44.86 84.79,64.34 84.79,71.86 85.7,72.77 94.23,72.77 94.49,72.52 94.49,71.35 98.34,67.5 98.34,65.83
VCCIN on S8: 101.35,63.73 101.35,62.9 99.07,60.62 99.07,60.6 98.7,60.24 98.7,59.79 98.72,59.78 98.72,44.67 97.38,43.33 97.38,39.73 95.61,37.95 95.61,32.79 92.43,29.62 70.99,29.62 69.65,30.96 66.07,30.96 65.71,31.32 65.71,34.37 66.29,34.95 81.2,34.95 93.85,47.6 93.85,50.16 93.6,50.42 93.6,57.5 93.41,57.7 93.41,59.41 93.03,59.79 93.03,60.36 92.65,60.74 89.47,60.74 85.92,64.3 85.92,71.4 87.86,73.34 87.86,73.79 88.65,74.57 97.75,74.57 98.11,74.22 98.11,66.97
VCCIN on G9: 99.82,72.36 99.82,71.07 101.03,69.86 101.03,62.58 98.81,60.36 98.55,60.36 98.23,60.04 98.23,59.79 97.22,58.77 97.22,56.36 96.29,55.43 96.29,51.44 96.04,51.18 95.38,51.18 94.36,50.16 94,50.16 93.89,50.28 93.89,56.66 94.56,57.34 94.56,58.67 93.43,59.8 93.43,60.23 93.03,60.63 93.03,61.69 93.47,62.14 93.47,63.28 92.96,63.79 92.2,63.79 91.38,64.62 91.38,65.7 91.44,65.76 91.44,66.27 91.38,66.33 91.38,69.13 91.95,69.7 91.95,70.14 91.38,70.71 91.38,73.67 91.57,73.86 95.38,73.86 96.19,73.05 99.14,73.05
VCCIN on S10: 101.35,68.38 101.35,65.41 100.58,64.64 98.55,64.64 96.01,62.1 96.01,58.93 94.51,57.43 94.51,50.32 94.36,50.16 93.85,50.16 93.6,50.42 93.6,57.5 92.89,58.22 92.89,63.2 91.19,64.9 91.19,71.91 90.4,72.69 90.4,73.56 90.7,73.86 95.38,73.86 96.22,73.03 98.7,73.03 99.39,72.34 99.39,70.33
VCCIN on G11: 99.82,71.04 101.03,69.84 101.03,62.58 98.81,60.36 98.55,60.36 98.23,60.04 98.23,59.79 97.22,58.77 97.22,56.36 96.96,56.11 96.96,51.24 96.9,51.18 95.38,51.18 94.36,50.16 93.85,50.16 93.6,50.42 93.6,57.5 93.41,57.7 93.41,57.82 93.41,58.84 93.41,58.84 93.41,59.41 93.03,59.79 93.03,61.69 93.47,62.14 93.47,63.28 92.96,63.79 92.2,63.79 91.38,64.62 91.38,65.7 91.44,65.76 91.44,66.27 91.38,66.33 91.38,69.18 91.92,69.72 91.92,70.04 91.38,70.59 91.38,74.56 91.74,74.93 97.38,74.93 99.82,72.49
VCCIN_P1V05_VCC on TOP: 79.4,10.87 81.64,10.87 83.13,9.37 83.13,7.85 82.8,7.52 82.37,7.52 81.99,7.9 81.13,7.9 80.85,7.62 79.48,7.62 79.22,7.87 79.22,10.69
VCCKRHV on TOP: 140.79,69.42 142.32,69.42 142.44,69.29 142.44,65.48 142.06,65.1 139.75,65.1 139.14,65.71 139.14,67.61 139.47,67.94 140.34,67.94 140.67,68.28 140.67,69.29
VCCKRHV on BOTTOM: 121.11,69.16 120.83,68.88 120.83,65.3 121.26,64.87 141.25,64.87 141.73,65.35 141.73,68.55 141.12,69.16
VCCKRHV on S8: 122.28,70.1 108.2,70.1 107.16,69.06 107.16,65.71 107.49,65.38 122.35,65.38 123.01,66.04 123.01,69.34 122.28,70.08
VCCSCFUSESUS on TOP: 130.43,70.74 130.43,69.85 129.67,69.09 129.67,68.07 129.54,67.94 128.52,67.94 128.27,68.2 128.27,70.48 128.65,70.87 130.3,70.87
VCCSCFUSESUS on TOP: 144.73,69.55 145.62,69.55 146.38,68.78 147.4,68.78 147.52,68.66 147.52,66.57 146.96,66.01 145.19,66.01 144.96,66.24 144.96,67.41 144.6,67.77 144.6,69.42
VCCSCFUSESUS on TOP: 152.2,61.34 151.38,62.15 151.38,63.8 151.79,64.21 168.4,64.21 168.78,63.83 168.78,61.87 168.25,61.34
VCCSCFUSESUS on S5: 107.42,69.06 101.96,69.06 101.73,68.83 101.73,64.19 102.29,63.63 114.07,63.63 115.83,61.87 118.87,61.87 120.63,63.63 145.39,63.63 148.18,60.83 155.68,60.83 156.26,61.42 156.26,67.49 155.85,67.89 132,67.89 129.82,70.08 124.1,70.08 123.01,68.99 107.49,68.99
VCCSUS3_3 on S8: 93.47,75.87 92.13,77.22 92.13,84 92.48,84.35 96.27,84.35 96.27,84.4 96.93,85.06 96.93,86.92 97.16,87.15 97.97,87.15 98.04,87.07 98.04,83.57 97.26,82.78 96.29,82.78 96.28,82.79 94.41,80.92 94.41,79.65 95.05,79.02 97.71,79.02 97.82,78.92 97.82,76.3 97.38,75.87
VCCSUS3_3 on S10: 98.3,86.11 98.22,86.19 95.28,86.19 93.47,84.38 93.47,76.33 93.95,75.84 97.38,75.84 97.82,76.28 97.82,78.89 97.71,78.99 96.52,78.99 96.22,79.3 96.22,80.7 96.69,81.17 96.69,82.84 98.3,84.45
DDR4_VPP on TOP: 32.3,37.11 34.23,37.11 34.43,36.91 34.43,35.64 34.28,35.48 32.5,35.48 32.2,35.79 32.2,37.01
DDR4_VPP on TOP: 44.3,37.11 46.23,37.11 46.43,36.91 46.43,35.64 46.28,35.48 44.5,35.48 44.2,35.79 44.2,37.01
DDR4_VPP on TOP: 20.95,31.34 32.66,31.34 34.29,29.72 34.29,28.52 33.99,28.22 20.95,28.22 20.7,28.47 20.7,31.09
DDR4_VPP on BOTTOM: 25.78,31.24 32.38,31.24 34.04,29.59 34.04,28.57 33.4,27.94 25.53,27.94 25.27,28.19 25.27,30.73
DDR4_VPP on S10: 32.23,36.47 46,36.47 46.23,36.25 46.23,35.46 42.55,31.78 40.74,31.78 38.61,29.64 38.61,18.52 38.2,18.11 29.36,18.11 27.15,20.32 27.15,32.89 24.99,35.05 24.99,50.55 25.37,50.93 29.21,50.93 29.95,50.19 29.95,38.76
DDR4_VPP_AGND on S8: 31.98,22.45 35.69,22.45 38.4,19.74 38.4,19.1 37.31,18.01 30.02,18.01 29.41,18.62 29.41,19.89
DDR4_VPP_SW on TOP: 21.51,25.93 24.38,25.93 25.12,25.2 25.12,24.28 26.67,22.73 28.19,22.73 28.32,22.61 28.32,21.67 28.17,21.51 25.45,21.51 24.94,22.02 20.7,22.02 20.45,22.28 20.45,24.87
HS1_PIN1 on TOP (solid shape): outline of 268 points within 60.03,97.06 68.92,105.95
HS1_PIN1 on BOTTOM (solid shape): outline of 268 points within 60.03,97.06 68.92,105.95
HS1_PIN2 on TOP (solid shape): outline of 268 points within 120.03,97.06 128.92,105.95
HS1_PIN2 on BOTTOM (solid shape): outline of 268 points within 120.03,97.06 128.92,105.95
HS1_PIN3 on TOP (solid shape): outline of 268 points within 60.03,37.06 68.92,45.95
HS1_PIN3 on BOTTOM (solid shape): outline of 268 points within 60.03,37.06 68.92,45.95
HS1_PIN4 on TOP (solid shape): outline of 268 points within 120.03,37.06 128.92,45.95
HS1_PIN4 on BOTTOM (solid shape): outline of 268 points within 120.03,37.06 128.92,45.95
NUT1_GND on TOP (solid shape): outline of 258 points within 186.65,90.75 195.15,99.25
PS_12V_LVIN1 on TOP (solid shape): 70.98,18.49 67.58,18.49 67.58,20.12 70.98,20.12
PS_12V_LVIN1 on BOTTOM (solid shape): 85.52,20.09 85.52,18.67 85.34,18.49 80.62,18.49 80.59,18.52 80.59,20.19 80.72,20.32 85.29,20.32
PS_12V_LVIN1 on TOP: 82.02,20.52 85.27,20.52 85.5,20.29 85.5,18.75 85.19,18.44 84.63,18.44 84.48,18.29 84.48,16.74 84.79,16.43 86.28,16.43 86.51,16.21 86.51,11.45 86.21,11.14 84.79,11.14 84.61,11.33 84.61,13.49 84.28,13.49 84.1,13.67 82.73,13.67 82.37,14.02 82.37,17.7 81.81,18.26 81.81,20.32
PS_12V_LVIN1 on TOP: 67.21,20.19 70.97,20.19 71.04,20.12 71.04,18.52 70.94,18.41 70.36,18.41 70.05,18.11 70.05,13.84 69.75,13.54 68.28,13.54 68.02,13.79 68.02,16.64 67.56,17.09 64.82,17.09 64.44,17.48 64.44,19.48 64.69,19.74 66.75,19.74
PS_12V_LVIN1 on BOTTOM: 70.84,20.14 68.68,20.14 68.12,19.58 65.99,19.58 65.79,19.79 64.44,19.79 64.24,19.58 64.24,17.81 64.54,17.5 70.76,17.5 71.04,17.78 71.04,19.94
PS_12V_LVIN1 on S10: 85.37,20.45 68.81,20.45 68.25,19.89 68.25,19.2 70.03,17.42 84.07,17.42 85.7,19.05 85.7,20.12
PS_12V_LVIN3 on TOP: 119.94,12.73 119.94,11.25 118.01,9.32 115.8,9.32 115.57,9.55 115.57,14.53 114,16.1 110.36,16.1 110.11,16.36 110.11,18.21 110.41,18.52 118.24,18.52 118.31,18.44 118.31,16.87 117.98,16.54 117.5,16.54 117.3,16.33 117.3,13.49 117.75,13.03 119.63,13.03
RP_1.05V_REG_PHASE on TOP: 120.55,20.9 120.37,21.08 115.7,21.08 115.44,21.34 115.44,26.42 115.95,26.92 122.05,26.92 122.43,26.54 122.43,22.12 121.21,20.9
RP_1.8V_REG_PHASE1 on TOP: 91.03,30.45 94.49,30.45 94.77,30.18 94.77,22.2 94.26,21.69 89.56,21.69 88.32,22.94 83.01,22.94 82.73,23.22 82.73,23.98 84.79,26.04 89.76,26.04 90.27,26.54 90.27,29.69
RP_1.8V_REG_PHASE1 on BOTTOM, S5: 86,27.84 88.85,27.84 89.31,27.38 89.31,25.32 87.38,23.39 84.3,23.39 84.02,23.67 84.02,24.74 85.6,26.31 85.6,27.43
RP_1.8V_REG_PHASE2 on TOP: 66.34,30.2 69.34,30.2 69.7,29.84 69.7,25.91 70.54,25.07 75.79,25.07 77.77,23.09 77.77,21.89 77.62,21.74 76.33,21.74 75.31,22.76 67.41,22.76 65.96,24.21 65.96,29.82
RP_1.8V_REG_PHASE2 on BOTTOM: 66.17,27.58 68.99,27.58 69.24,27.33 69.24,25.91 70.61,24.54 71.86,24.54 72.29,24.1 72.29,23.04 72.09,22.83 67.44,22.83 65.99,24.28 65.99,27.41
RP_1.8V_REG_V18A on S10: 86.94,16.66 88.32,18.03 89.31,18.03 89.61,17.73 89.61,14.66 88.52,13.56 82.22,13.56 77.85,9.19 77.85,6.53 76.78,5.46 71.07,5.46 70.66,5.87 70.66,7.54 71.2,8.08 71.2,14.88 72.97,16.66
RP_3.3V_LVCC on TOP: 205.61,80.34 205.61,78.14 205.96,77.79 205.96,74.52 206.1,74.38 207.62,74.38 207.81,74.57 207.81,80.45 207.68,80.58 205.85,80.58
RP_3.3V_LVCC on BOTTOM: 208.03,108.99 208.28,108.74 208.28,106.83 207.9,106.45 206.6,106.45 206.35,106.71 206.35,108.74 206.6,108.99
RP_3.3V_LVCC on BOTTOM: 188.81,109.03 189.99,109.03 190.24,108.78 190.24,106.75 190.14,106.65 188.59,106.65 188.26,106.98 188.26,108.49
RP_3.3V_LVCC on V7: 189.38,109.61 207.18,109.61 207.98,108.82 207.98,79.47 207.29,78.79 205.69,78.79 204.93,79.56 204.93,105.1 203.95,106.08 188.85,106.08 188,106.93 188,108.23
RP_BAT_3.3V on BOTTOM: 7.61,104.2 6.89,104.92 6.89,110.94 7.67,111.72 14.64,111.72 15.49,110.87 15.49,105.18 14.52,104.2
SW_VDDQ_CH01 on TOP (solid shape): 57.75,23.57 55.5,23.57 55.5,24.55 57.75,24.55
SW_VDDQ_CH01 on TOP: 59.08,23.6 58.95,23.47 55.55,23.47 55.07,23.95 55.07,26.04 57.68,28.65 60.73,28.65 61.24,28.14 61.24,25.98 60.67,25.41 60.21,25.41 59.08,24.28

Small or netless copper shapes (teardrops, artwork): 115 on TOP

## Text on the board
Ref Des/Silkscreen Top: SYS | P5V | P3V3 | P1V7 | P1V3 | P1V05 | DDR4_VPP | VDDQ | VTT | P1V5 | VCCIN | P/N:142000001998A REV.0A
PAGE_OUTLINE: 05/15/2018
User.9: TOP (COMPONENT_SIDE)                       1
User.10: G2 (GND_LAYER_2)                           2
User.11: G5 (GND_LAYER_5)                           5
User.12: BOT (SOLDER_SIDE)                         12
User.13: SST (SILKSCREEN_TOP)                      13
User.14: SSB (SILKSCREEN_BOTTOM)                   14
User.15: SMT (SOLDER_MASK_TOP)                     15
User.16: SMB (SOLDER_MASK_BOTTOM)                  16
User.17: DRILL(FINISH HOLE SIZE LIST)                  20
User.18: PMT (PASTE_MASK_TOP)                     17
User.19: PMB (PASTE_MASK_BOTTOM)                  18
User.20: DIM (BOARD_DIMENSION)                    19
User.21: S3 (SIGNAL_LAYER_3)                       3
User.22: S4 (SIGNAL_LAYER_4 )                      4
User.23: V6 (VCC_LAYER_6)                           6
User.24: V7 (VCC_LAYER_7)                           7
User.25: G8 (GND_LAYER_8)                           8
User.26: S9 (SIGNAL_LAYER_9)                       9
User.27: S10 (SIGNAL)LAYER_10)                     10
User.28: G11 (GND_LAYER_11)                         11
User.29: S8 (SIGNAL_LAYER_8)                       8
User.30: S5 (SIGNAL_LAYER_5)                       5
User.31: G4 (GND_LAYER_4)                           4
User.32: G9 (GND_LAYER_9)                           9
User.37: FIGURE | SIZE | 8.0 | 10.0 | 12.0 | 16.0 | 28.0 | 43.0 | 134.0 | 30.0 | 35.0 | 40.0 | 44.0 | 45.0 | 48.0 | 59.0 | 63.0 | 71.0 | 125.0 | 138.0 | 166.0 | 177.0 | 44.0x28.0 | 189.0x126.0 | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | +3.0/-0.0 | ALL UNITS ARE IN MILS | PLATED | NON-PLATED | QTY | 2 | 1558 | 3612 | 86 | 4 | 1 | 3 | 5 | 8 | DRILL CHART: TOP to BOTTOM
User.39: U31 | HSB1 | CONN16 | C272 | C273 | R791 | R792 | R786 | R788 | C637 | CONN14 | Q8 | Q11 | C271 | C267 | C269 | C439 | C423 | R938 | R940 | R937 | C408 | C353 | C371 | C383 | C395 | R540 | R709 | C483 | R917 | C467 | C459 | C473 | R914 | R915 | R916 | R913 | R912 | R939 | R941 | C354 | C340 | C613 | R646 | R652 | R952 | R754 | R953 | U41 | R433 | C574 | C575 | C908 | C442 | C450 | C403 | C410 | C369 | C376 | R647 | C339 | R711 | R708 | U40 | C588 | R700 | R918 | C490 | R648 | R726 | C564 | R585 | R581 | R576 | C589 | C592 | R943 | R579 | L36 | R564 | R565 | R568 | R560 | C382 | C602 | C638 | C460 | C448 | C518 | C519 | C603 | C312 | C335 | R656 | C306 | C484 | C489 | C293 | R742 | C625 | C336 | C614 | C260 | C326 | C365 | R649 | C416 | C430 | C397 | C404 | C386 | C463 | R756 | R574 | C415 | R580 | C373 | C389 | C405 | C420 | C323 | C362 | C310 | C330 | C458 | C370 | C317 | C301 | C305 | C322 | C338 | C441 | C406 | C139 | C419 | C525 | R543 | C325 | R743 | R758 | R729 | C530 | C539 | C549 | C565 | R693 | C572 | R780 | R460 | R447 | C595 | C597 | R429 | R723 | U32 | R70 | R445 | R451 | C635 | C633 | R463 | R444 | C454 | C431 | R562 | R430 | R474 | R724 | R744 | R740 | R459 | R571 | C476 | C485 | C488 | C494 | C498 | C377 | TP23 | TP24 | R566 | R777 | R438 | R521 | R462 | C400 | C407 | R559 | R431 | C345 | R557 | C360 | C606 | R741 | R733 | C466 | R488 | R454 | C446 | C401 | Q12 | C429 | C421 | C378 | C387 | C510 | C511 | C512 | R516 | C465 | R481 | R471 | R467 | R470 | Q13 | R878 | R877 | R458 | R443 | R449 | R432 | TP35 | C526 | C529 | C522 | C481 | C501 | U36 | R790 | C504 | C506 | TP37 | C493 | C496 | R439 | R448 | R483 | R485 | R518 | R452 | C292 | TP16 | C289 | R605 | R604 | R600 | R599 | TP15 | C503 | C449 | R638 | R633 | Q14 | C461 | R456 | R624 | C497 | R578 | R499 | R635 | TP20 | R506 | R625 | TP31 | R642 | R634 | D1 | R615 | R785 | R639 | C911 | R613 | C457 | R632 | C417 | C379 | C456 | C372 | C384 | TP32 | R502 | TP30 | C342 | R586 | R617 | C509 | Q1 | R508 | R509 | Q10 | L30 | C388 | Q9 | R630 | C327 | L35 | R753 | C593 | C472 | C462 | C440 | C455 | C515 | R640 | R628 | C291 | TP36 | R715 | TP34 | C508 | R868 | R881 | R583 | R587 | R589 | R590 | R597 | R561 | C402 | C936 | C937 | C934 | C930 | R555 | C154 | C944 | C961 | R748 | C636 | C939 | C938 | C942 | C585 | C608 | R727 | C591 | C571 | R694 | C115 | C117 | C116 | C120 | C119 | R608 | C502 | C500 | R803 | C647 | C505 | C629 | C631 | C634 | R611 | C507 | C648 | R536 | R541 | R542 | C464 | R577 | C627 | L37 | C318 | U34 | C517 | C913 | C396 | R563 | C319 | R673 | C544 | R663 | C604 | R721 | C61 | C277 | C276 | R722 | C605 | R644 | R651 | R660 | R156 | R672 | R677 | R687 | R157 | R152 | 75 | 74 | C58 | C398 | C452 | C590 | C570 | C567 | R132 | R135 | C399 | C453 | H* | R147 | C54 | 20 | 21 | 10 | 11 | R707 | 2 | R908 | R150 | R848 | C308 | C309 | BA1 | R495 | R417 | R496 | R425 | R493 | R426 | R494 | R422 | R491 | R423 | R492 | R424 | R771 | R418 | R497 | R772 | R606 | C550 | R419 | R773 | C551 | R420 | R774 | R498 | R421 | R766 | R436 | R414 | C552 | R529 | U33 | R767 | R437 | R415 | R948 | R690 | C278 | R530 | C527 | R416 | R691 | C167 | R946 | R768 | R531 | R942 | C528 | R532 | R603 | R769 | R607 | R947 | R533 | C568 | R775 | R534 | R441 | C569 | R525 | R776 | R442 | C596 | C566 | R526 | R759 | R701 | R699 | R725 | R527 | R760 | R528 | R761 | R762 | R736 | R682 | R737 | C350 | R763 | R683 | C909 | R738 | R684 | R764 | U37 | R739 | R685 | R765 | C347 | R730 | C520 | C348 | R570 | C521 | C424 | R547 | R654 | C390 | R551 | C425 | C349 | C329 | R655 | C391 | R688 | C352 | C639 | C426 | C324 | C359 | R689 | C392 | C491 | L31 | C307 | C297 | C331 | C427 | C541 | C393 | C321 | C361 | C542 | C302 | C337 | C428 | C394 | C543 | C334 | C598 | C341 | C303 | R678 | C486 | C333 | C295 | C599 | R679 | C320 | C351 | C447 | C296 | C304 | L34 | C346 | R549 | C523 | R880 | C294 | C380 | C432 | R548 | C487 | C524 | R680 | R681 | C381 | C343 | C422 | TP27 | C385 | C344 | C582 | R710 | R755 | C583 | C594 | L33 | C584 | R544 | R592 | C474 | R546 | C374 | TP33 | C586 | C262 | R545 | C475 | R593 | C587 | R728 | C563 | C561 | C562 | C630 | C553 | C600 | C554 | C701 | R461 | R734 | R735 | R453 | R466 | C531 | C468 | C470 | C532 | R750 | C471 | R473 | C533 | R477 | R757 | R469 | C534 | C628 | R446 | C444 | C328 | C535 | R476 | C615 | C536 | R450 | R482 | C537 | C538 | R746 | R500 | R747 | C540 | C363 | C576 | C632 | R517 | R554 | R621 | C577 | C285 | C364 | R622 | C578 | R475 | R623 | C579 | C366 | R719 | R489 | C495 | C580 | C367 | R720 | C581 | C368 | R131 | R490 | C607 | TP19 | R553 | TP21 | TP14 | TP25 | R657 | TP26 | R675 | R658 | R659 | R676 | TP22 | C482 | R440 | R464 | R879 | R479 | R480 | R520 | R478 | R645 | C492 | R505 | R523 | R643 | R616 | R636 | R778 | C274 | R609 | R614 | R779 | R667 | R610 | R752 | C547 | R787 | R594 | R595 | R596 | C556 | R626 | R584 | R501 | R507 | R486 | R457 | R933 | C263 | R923 | R487 | R906 | C557 | R929 | R569 | R535 | TP18 | R936 | R930 | R924 | C409 | R795 | R515 | R935 | R582 | R925 | C418 | C299 | C286 | C433 | R637 | R927 | R749 | R926 | R598 | TP17 | C300 | C434 | R928 | C313 | R783 | C314 | TP29 | R784 | R519 | C279 | C315 | C28 | C499 | TP28 | C548 | R932 | C316 | Q16 | R522 | C546 | C311 | R934 | C555 | R751 | R627 | L32 | R427 | C558 | C29 | R435 | C559 | R745 | R1049 | C560 | R1050 | R455 | R558 | R619 | R618 | R601 | R602 | C935 | R800 | C959 | C931 | C941 | C945 | C244 | C928 | C960 | C933 | R999 | C943 | C245 | R1001 | C926 | R550 | C929 | C619 | C332 | C620 | C925 | C927 | C621 | C622 | C573 | C246 | C247 | C623 | R465 | R468 | R697 | C624 | C626 | R732 | C275 | R731 | C612 | R120 | C609 | R119 | C610 | C611 | C41 | R1045 | U35 | R567 | C445 | R537 | R575 | R249 | R955 | C443 | R538 | R631 | C375 | R573 | R612 | R620 | R954 | R556 | C513 | C290 | C514 | C516 | R629 | C298 | C915 | C914 | R572 | C355 | R716 | C357 | R158 | R843 | R159 | C479 | R717 | C477 | R718 | R404 | C435 | C411 | R405 | C412 | C436 | R696 | R406 | R695 | R702 | R664 | C281 | R149 | R703 | R665 | R230 | C282 | R704 | R869 | R133 | R407 | R641 | R910 | R650 | R705 | R408 | R653 | R706 | C437 | C413 | R666 | C438 | C414 | R409 | R674 | R909 | R151 | R410 | R686 | C358 | R911 | R661 | R411 | R668 | C478 | R669 | R412 | C356 | C480 | R670 | C64 | R413 | C65 | R671 | CONN15 | CONN13 | 160 | 100 | 110 | 120 | 130 | 140 | 150 | 170 | 180 | 190 | 204 | 30 | 40 | 50 | 60 | 70 | 80 | 90 | 155 | 105 | 115 | 185 | 125 | 135 | 145 | 195 | 203 | 73 | 55 | 85 | 95 | 65 | 35 | 175 | 15 | 25 | 45 | 71 | 165 | 5 | 119 | Q7
