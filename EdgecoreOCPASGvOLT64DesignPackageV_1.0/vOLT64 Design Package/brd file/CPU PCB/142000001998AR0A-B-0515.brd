# Allegro board 142000001998AR0A-B-0515.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RP_DDR4_DIMM1_DQ50: length 85.2
  TOP w0.114: v4(92.16,59.15) 91.87,58.86 U9.BG72 ; CONN7.228 39.04,44.2 38.34,44.9 v2(38.34,45.14)
  S8 w0.102: v2(38.34,45.14) 38.34,45.03 38.97,44.39 40.6,44.39 42.78,42.21 44.34,42.21 44.44,42.11 44.44,41.71 44.54,41.61 44.95,41.61 45.05,41.71 45.05,42.11 45.15,42.21 45.56,42.21 45.66,42.11 45.66,41.71 45.76,41.61 46.17,41.61 46.27,41.71 46.27,42.11 46.37,42.21 50.91,42.21 51.01,42.11 51.01,41.67 51.11,41.57 51.52,41.57 51.62,41.67 51.62,42.11 51.72,42.21 52.13,42.21 52.23,42.11 52.23,41.67 52.33,41.57 52.74,41.57 52.84,41.67 52.84,42.11 52.94,42.21 53.35,42.21 53.45,42.11 53.45,41.67 53.55,41.57 53.96,41.57 54.06,41.67 54.06,42.11 54.16,42.21 54.68,42.21 55.63,41.26 55.63,41.11 55.48,40.96 55.48,40.82 55.76,40.53 55.91,40.53 56.06,40.68 56.2,40.68 56.49,40.39 56.49,40.25 56.34,40.1 56.34,39.95 56.63,39.66 56.77,39.66 56.92,39.82 57.07,39.82 57.35,39.53 57.35,39.39 57.2,39.23 57.2,39.09 57.49,38.8 57.63,38.8 57.79,38.96 57.93,38.96 58.22,38.67 58.22,38.52 58.06,38.37 58.06,38.23 58.35,37.94 58.5,37.94 58.65,38.09 58.79,38.09 59.08,37.81 59.08,37.66 58.93,37.51 58.93,37.36 59.21,37.08 59.36,37.08 59.51,37.23 59.66,37.23 60.56,36.32 78.69,36.32 92.68,50.32 92.68,57.01 92.33,57.36 92.33,58.49 92.16,58.66 v4(92.16,59.15)
RP_DDR4_DIMM1_DQ51: length 85.2
  TOP w0.114: U9.BH71 v4(91.66,60.01) ; CONN7.229 34.23,43.95 34.25,43.94 35.61,43.94 36.23,44.56 v2(36.23,44.72)
  S8 w0.102: v2(36.23,44.72) 37.16,43.79 40.44,43.79 40.92,43.3 40.92,43.16 40.32,42.55 40.32,42.41 40.61,42.12 40.75,42.12 41.35,42.73 41.5,42.73 41.79,42.44 41.79,42.3 41.18,41.69 41.18,41.55 41.47,41.26 41.61,41.26 42.22,41.87 42.36,41.87 43.14,41.09 54.18,41.09 59.44,35.83 78.91,35.83 93.17,50.09 93.17,57.58 93.34,57.75 93.34,58.46 92.74,59.06 92.74,59.24 91.97,60.01 v4(91.66,60.01)
RP_DDR4_DIMM1_DQ52: length 85.2
  TOP w0.114: U9.BV72 v4(87.2,59.15) ; CONN7.211 35.22,48.45 36.21,49.44 v2(36.21,49.75)
  S8 w0.102: v2(36.21,49.75) 35.38,48.93 35.38,47.68 35.2,47.5 34.67,47.5 34.57,47.6 34.57,48.84 34.47,48.95 34.06,48.95 33.96,48.84 33.96,47.6 33.86,47.5 33.38,47.5 33.2,47.68 33.2,50.9 33.94,51.65 34.77,51.65 34.87,51.54 34.87,51.1 34.97,51 35.38,51 35.48,51.1 35.48,51.54 35.58,51.65 35.99,51.65 36.09,51.54 36.09,51.1 36.19,51 36.6,51 36.7,51.1 36.7,51.54 36.8,51.65 37.21,51.65 37.31,51.54 37.31,51.1 37.41,51 37.82,51 37.92,51.1 37.92,51.54 38.02,51.65 38.42,51.65 38.53,51.54 38.53,51.1 38.63,51 39.03,51 39.14,51.1 39.14,51.54 39.24,51.65 39.64,51.65 39.75,51.54 39.75,51.1 39.85,51 40.25,51 40.36,51.1 40.36,51.54 40.46,51.65 40.86,51.65 40.96,51.54 40.96,51.1 41.07,51 41.47,51 41.57,51.1 41.57,51.54 41.68,51.65 42.16,51.65 45.93,47.88 56.62,47.88 57.53,48.79 68.22,48.79 69.14,47.88 80.35,47.88 86.19,53.72 86.19,57.87 86.47,58.15 86.47,58.41 v4(87.2,59.15)
RP_DDR4_DIMM1_DQ53: length 85.1
  TOP w0.114: v4(86.71,60.01) 86.36,59.81 U9.BW71 ; v2(37.72,48) 37.72,48.34 37.86,48.48 39.74,48.48 40.01,48.2 CONN7.212
  S8 w0.102: v2(37.72,48) 37.72,48.06 38.28,48.62 38.83,48.62 38.93,48.72 38.93,49.92 39.03,50.03 39.44,50.03 39.54,49.92 39.54,48.72 39.64,48.62 40.05,48.62 40.15,48.72 40.15,49.92 40.25,50.03 40.66,50.03 40.76,49.92 40.76,48.72 40.86,48.62 41.27,48.62 41.37,48.72 41.37,49.92 41.47,50.03 41.88,50.03 41.98,49.92 41.98,48.72 42.08,48.62 42.58,48.62 42.68,48.72 42.68,49.07 42.78,49.17 43.19,49.17 43.29,49.07 43.29,48.72 43.39,48.62 44.3,48.62 45.57,47.35 46.21,47.35 46.31,47.25 46.31,46.69 46.41,46.59 46.82,46.59 46.92,46.69 46.92,47.25 47.02,47.35 50.75,47.35 50.85,47.25 50.85,46.56 50.95,46.46 51.35,46.46 51.46,46.56 51.46,47.25 51.56,47.35 51.96,47.35 52.07,47.25 52.07,46.56 52.17,46.46 52.57,46.46 52.68,46.56 52.68,47.25 52.78,47.35 53.18,47.35 53.29,47.25 53.29,46.56 53.39,46.46 53.79,46.46 53.89,46.56 53.89,47.25 54,47.35 54.4,47.35 54.5,47.25 54.5,46.56 54.61,46.46 55.01,46.46 55.11,46.56 55.11,47.25 55.22,47.35 55.62,47.35 55.72,47.25 55.72,46.56 55.83,46.46 56.23,46.46 56.33,46.56 56.33,47.25 56.43,47.35 56.92,47.35 57.88,48.31 68,48.31 68.96,47.35 70.8,47.35 70.9,47.25 70.9,47.19 71,47.09 71.41,47.09 71.51,47.19 71.51,47.25 71.61,47.35 72.02,47.35 72.12,47.25 72.12,47.19 72.22,47.09 72.63,47.09 72.73,47.19 72.73,47.25 72.83,47.35 73.24,47.35 73.34,47.25 73.34,47.19 73.44,47.09 73.85,47.09 73.95,47.19 73.95,47.25 74.05,47.35 74.46,47.35 74.56,47.25 74.56,47.19 74.66,47.09 75.07,47.09 75.17,47.19 75.17,47.25 75.27,47.35 75.68,47.35 75.78,47.25 75.78,47.19 75.88,47.09 76.29,47.09 76.39,47.19 76.39,47.25 76.49,47.35 76.89,47.35 77,47.25 77,47.19 77.1,47.09 77.5,47.09 77.61,47.19 77.61,47.25 77.71,47.35 78.11,47.35 78.22,47.25 78.22,47.19 78.32,47.09 78.72,47.09 78.83,47.19 78.83,47.25 78.93,47.35 80.88,47.35 86.77,53.24 86.77,55.22 86.72,55.28 86.72,56.43 87.43,57.15 87.43,58.67 87.61,58.85 87.61,59.41 87.34,59.69 87.03,59.69 v4(86.71,60.01)
RP_DDR4_DIMM1_DQ54: length 85
  TOP w0.114: CONN7.224 40.01,45.2 v2(39.96,45.15) ; U9.BJ72 v4(91.17,59.15)
  S8 w0.102: v4(91.17,59.15) 91.17,58.62 91.5,58.28 91.5,57.21 92.2,56.51 92.2,51.75 80.48,40.03 75.69,40.03 72.48,36.81 71.91,36.81 71.81,36.92 71.81,37.59 71.71,37.69 71.3,37.69 71.2,37.59 71.2,36.92 71.1,36.81 70.69,36.81 70.59,36.92 70.59,37.59 70.49,37.69 70.08,37.69 69.98,37.59 69.98,36.92 69.88,36.81 69.47,36.81 69.37,36.92 69.37,37.59 69.27,37.69 68.86,37.69 68.76,37.59 68.76,36.92 68.66,36.81 60.92,36.81 59.66,38.08 59.66,38.22 60.13,38.68 60.13,38.83 59.84,39.12 59.7,39.12 59.23,38.65 59.09,38.65 58.71,39.03 58.71,39.18 59.36,39.83 59.36,39.98 59.08,40.26 58.93,40.26 58.28,39.61 58.13,39.61 57.84,39.9 57.84,40.04 58.5,40.7 58.5,40.84 58.21,41.13 58.07,41.13 57.41,40.47 57.27,40.47 56.98,40.76 56.98,40.9 57.64,41.56 57.64,41.7 57.35,41.99 57.21,41.99 56.55,41.33 56.41,41.33 55.9,41.84 55.9,41.98 56.25,42.33 56.25,42.48 55.97,42.76 55.82,42.76 55.47,42.41 55.33,42.41 54.99,42.75 43.4,42.75 41,45.15 v2(39.96,45.15)
RP_DDR4_DIMM1_DQ55: length 85
  TOP w0.114: U9.BL71 v4(90.67,60.01) ; CONN7.225 34.34,44.95 v2(34.61,44.69)
  S8 w0.102: v2(34.61,44.69) 36.14,43.15 36.14,43.08 36.8,42.42 38.38,42.42 38.83,41.97 39.11,41.97 39.4,41.68 39.4,41.4 40.23,40.57 53.99,40.57 59.22,35.34 79.11,35.34 93.65,49.89 93.65,56.84 94.28,57.48 94.28,58.5 94.02,58.77 93.94,58.77 93.46,59.25 93.46,59.33 93.21,59.58 93.21,60.05 92.85,60.4 91.06,60.4 v4(90.67,60.01)
RP_DDR4_DIMM1_DQ56: length 78.6
  TOP w0.114: v2(37.52,43.25) 37.03,42.76 36.12,42.76 35.32,41.95 CONN7.237 ; U9.BU67 v4(87.7,61.73)
  S5 w0.089: 87.58,60.64 87.58,61.18 87.7,61.3 v4(87.7,61.73)
  S5 w0.102: 87.58,60.64 87.22,60.29 87.22,59.87 86.67,59.31 86.67,58.87 86.43,58.63 86.43,58.16 86.13,57.87 86.01,57.87 82.53,54.4 82.53,54.03 77.85,49.35 68.78,49.35 67.85,50.28 67.37,50.28 67.27,50.18 67.27,49.79 67.17,49.69 66.76,49.69 66.66,49.79 66.66,50.18 66.56,50.28 66.15,50.28 66.05,50.18 66.05,49.79 65.95,49.69 65.54,49.69 65.44,49.79 65.44,50.18 65.34,50.28 64.93,50.28 64.83,50.18 64.83,49.79 64.73,49.69 64.32,49.69 64.22,49.79 64.22,50.18 64.12,50.28 63.71,50.28 63.61,50.18 63.61,49.79 63.51,49.69 63.1,49.69 63,49.79 63,50.18 62.9,50.28 62.49,50.28 62.39,50.18 62.39,49.79 62.29,49.69 61.88,49.69 61.78,49.79 61.78,50.18 61.68,50.28 61.28,50.28 61.17,50.18 61.17,49.79 61.07,49.69 60.67,49.69 60.56,49.79 60.56,50.18 60.46,50.28 60.06,50.28 59.95,50.18 59.95,49.79 59.85,49.69 59.45,49.69 59.34,49.79 59.34,50.18 59.24,50.28 58.84,50.28 58.74,50.18 58.74,49.79 58.63,49.69 58.23,49.69 58.13,49.79 58.13,50.18 58.02,50.28 57.62,50.28 57.52,50.18 57.52,49.79 57.41,49.69 57.01,49.69 56.91,49.79 56.91,50.18 56.8,50.28 56.4,50.28 56.3,50.18 56.3,49.79 56.2,49.69 55.79,49.69 55.69,49.79 55.69,50.18 55.59,50.28 54.5,50.28 53.89,49.67 53.89,48.38 51.63,46.12 47.46,46.12 46.69,46.89 46.18,46.89 46.08,46.79 46.08,46.51 45.97,46.41 45.57,46.41 45.47,46.51 45.47,46.79 45.36,46.89 44.96,46.89 44.86,46.79 44.86,46.51 44.75,46.41 44.35,46.41 44.25,46.51 44.25,46.79 44.15,46.89 43.74,46.89 43.64,46.79 43.64,46.51 43.54,46.41 43.13,46.41 43.03,46.51 43.03,46.79 42.93,46.89 42.44,46.89 40.17,44.61 38.82,44.61 37.52,43.31 v2(37.52,43.25)
RP_DDR4_DIMM1_DQ57: length 78.3
  TOP w0.114: CONN7.236 38.53,42.2 38.34,42.4 v2(38.34,43.23) ; U9.BT66 v4(88.2,62.58)
  S5 w0.089: 88.08,59.66 88.08,60.18 87.82,60.44 87.82,61.15 88.07,61.41 88.07,62.13 88.2,62.25 v4(88.2,62.58)
  S5 w0.102: 88.08,59.66 87.72,59.3 87.72,59.09 87.54,58.91 87.54,58.27 84.94,55.67 84.94,54.9 81.99,51.95 81.84,51.95 81.57,52.23 81.42,52.23 81.13,51.94 81.13,51.8 81.41,51.52 81.41,51.37 81.13,51.09 80.98,51.09 80.7,51.36 80.56,51.36 80.27,51.08 80.27,50.93 80.55,50.65 80.55,50.51 80.26,50.22 80.12,50.22 79.84,50.5 79.7,50.5 79.41,50.21 79.41,50.07 79.69,49.79 79.69,49.65 78.67,48.63 68.27,48.63 68.17,48.73 68.17,48.93 68.06,49.03 67.66,49.03 67.56,48.93 67.56,48.73 67.45,48.63 66.93,48.63 66.83,48.73 66.83,49.11 66.73,49.21 66.32,49.21 66.22,49.11 66.22,48.73 66.12,48.63 65.71,48.63 65.61,48.73 65.61,49.11 65.51,49.21 65.1,49.21 65,49.11 65,48.73 64.9,48.63 64.49,48.63 64.39,48.73 64.39,49.11 64.29,49.21 63.88,49.21 63.78,49.11 63.78,48.73 63.68,48.63 63.27,48.63 63.17,48.73 63.17,49.11 63.07,49.21 62.66,49.21 62.56,49.11 62.56,48.73 62.46,48.63 62.05,48.63 61.95,48.73 61.95,49.11 61.85,49.21 61.44,49.21 61.34,49.11 61.34,48.73 61.24,48.63 60.83,48.63 60.73,48.73 60.73,49.11 60.63,49.21 60.22,49.21 60.12,49.11 60.12,48.73 60.02,48.63 59.61,48.63 59.51,48.73 59.51,49.11 59.41,49.21 59,49.21 58.9,49.11 58.9,48.73 58.8,48.63 58.4,48.63 58.29,48.73 58.29,49.11 58.19,49.21 57.79,49.21 57.68,49.11 57.68,48.73 57.58,48.63 57.18,48.63 57.07,48.73 57.07,49.11 56.97,49.21 56.57,49.21 56.46,49.11 56.46,48.73 56.36,48.63 55.16,48.63 51.93,45.39 45.12,45.39 45.02,45.49 45.02,45.75 44.92,45.85 44.51,45.85 44.41,45.75 44.41,45.49 44.31,45.39 43.9,45.39 43.8,45.49 43.8,45.75 43.7,45.85 43.29,45.85 43.19,45.75 43.19,45.49 43.09,45.39 42.11,45.39 40.73,44.01 39.11,44.01 v2(38.34,43.23)
RP_DDR4_DIMM1_DQ58: length 78.4
  TOP w0.114: v2(36.22,39.73) 35.45,38.95 CONN7.249 ; U9.BH67 v4(91.66,61.73)
  S5 w0.089: 90.54,58.04 90.54,58.71 90.74,58.92 90.74,59.38 90.36,59.76 90.3,59.83 90.3,60.19 90.79,60.68 90.79,61.02 91.5,61.73 v4(91.66,61.73)
  S5 w0.102: v2(36.22,39.73) 36.22,39.91 36.61,40.3 39.08,40.3 39.17,40.39 44.38,40.39 44.48,40.29 44.48,39.88 44.58,39.78 44.99,39.78 45.09,39.88 45.09,40.29 45.19,40.39 45.6,40.39 45.7,40.29 45.7,39.88 45.8,39.78 46.21,39.78 46.31,39.88 46.31,40.29 46.41,40.39 56.08,40.39 60.17,36.3 72.61,36.3 89.39,53.07 89.39,55.64 90.84,57.1 90.84,57.74 90.54,58.04
RP_DDR4_DIMM1_DQ59: length 78.5
  TOP w0.114: v2(37.78,39.41) 37.79,39.4 37.79,39.32 38.4,38.7 CONN7.250 ; U9.BG66 v4(92.16,62.58)
  S5 w0.102: v4(92.16,62.58) 92.25,62.49 92.25,60.33 92.23,60.31 92.23,59.74 92.59,59.39 92.59,58.62 92.48,58.51 92.48,53.64 74.06,35.23 59.79,35.23 56.42,38.6 41.84,38.6 41.74,38.5 41.74,38.23 41.64,38.13 41.23,38.13 41.13,38.23 41.13,38.5 41.03,38.6 38.61,38.6 37.8,39.41 v2(37.78,39.41)
RP_DDR4_DIMM1_DQ60: length 78.6
  TOP w0.114: v4(86.71,61.73) 86.36,61.52 U9.BW67 ; v2(39.96,43.2) CONN7.232
  S5 w0.089: v4(86.71,61.73) 86.71,62.72 86.98,62.99 88.39,62.99 88.64,62.74 88.64,62.24 88.3,61.89 88.3,61.44 88.64,61.09 88.64,60.61 88.31,60.28 88.31,59.82
  S5 w0.102: v2(39.96,43.2) 40.04,43.28 42.5,43.28 43.12,43.91 43.7,43.91 43.8,44.01 43.8,44.65 43.9,44.75 44.31,44.75 44.41,44.65 44.41,44.01 44.51,43.91 45.47,43.91 45.57,44.01 45.57,44.68 45.67,44.78 46.08,44.78 46.18,44.68 46.18,44.01 46.28,43.91 51.46,43.91 51.82,44.26 51.96,44.26 52.63,43.6 52.77,43.6 53.06,43.89 53.06,44.03 52.39,44.69 52.39,44.84 52.68,45.12 52.83,45.12 53.49,44.46 53.63,44.46 53.92,44.75 53.92,44.89 53.26,45.56 53.26,45.7 53.54,45.99 53.69,45.99 54.35,45.33 54.49,45.33 54.78,45.61 54.78,45.76 54.12,46.42 54.12,46.56 54.41,46.85 54.55,46.85 55.21,46.19 55.36,46.19 55.64,46.48 55.64,46.62 54.98,47.28 54.98,47.42 55.46,47.9 55.94,47.9 56.04,47.8 56.04,47.37 56.15,47.27 56.55,47.27 56.65,47.37 56.65,47.8 56.76,47.9 57.16,47.9 57.26,47.8 57.26,47.37 57.37,47.27 57.77,47.27 57.87,47.37 57.87,47.8 57.97,47.9 78.76,47.9 85.43,54.57 85.43,55.24 88.45,58.26 88.45,58.57 88.64,58.77 88.64,59.48 88.31,59.82
RP_DDR4_DIMM1_DQ61: length 78.6
  TOP w0.114: CONN7.233 34.54,42.95 v2(34.61,43.02) ; U9.BV66 v4(87.2,62.58)
  S5 w0.102: v4(87.2,62.58) 87.2,61.56 86.62,60.97 86.62,60.59 86.17,60.14 86.17,59.77 85.79,59.39 85.79,59.04 85.45,58.7 85.45,58.16 85.17,57.88 84.99,57.88 83.12,56.01 82,56.01 81.54,55.55 81.54,53.74 77.88,50.07 68.87,50.07 68.14,50.8 53.58,50.8 52.82,50.04 52.82,48.46 51.77,47.41 49.83,47.41 49.72,47.51 49.72,47.65 49.62,47.75 49.22,47.75 49.11,47.65 49.11,47.51 49.01,47.41 48.61,47.41 48.51,47.51 48.51,47.65 48.4,47.75 48,47.75 47.9,47.65 47.9,47.51 47.79,47.41 47.39,47.41 47.29,47.51 47.29,47.65 47.18,47.75 46.78,47.75 46.68,47.65 46.68,47.51 46.57,47.41 45.37,47.41 45.27,47.51 45.27,47.92 45.17,48.03 44.76,48.03 44.66,47.92 44.66,47.51 44.56,47.41 44.15,47.41 44.05,47.51 44.05,47.92 43.95,48.03 43.54,48.03 43.44,47.92 43.44,47.51 43.34,47.41 41.95,47.41 40.7,46.16 38.5,46.16 37.61,45.27 37.13,45.27 37.03,45.37 37.03,46.07 36.93,46.17 36.52,46.17 36.42,46.07 36.42,45.37 36.32,45.27 35.91,45.27 35.81,45.37 35.81,46.07 35.71,46.17 35.3,46.17 35.2,46.07 35.2,45.37 35.1,45.27 34.69,45.27 34.59,45.37 34.59,46.07 34.49,46.17 34.08,46.17 33.98,46.07 33.98,45.37 33.88,45.27 33.46,45.27 33.28,45.09 33.28,43.26 33.52,43.02 v2(34.61,43.02)
RP_DDR4_DIMM1_DQ62: length 78.8
  TOP w0.114: v2(34.6,39.7) 34.35,39.95 CONN7.245 ; U9.BL67 v4(90.67,61.73)
  S5 w0.089: v4(90.67,61.73) 90.55,61.6 90.55,60.71 90.06,60.22 90.06,59.8 90.55,59.31 90.55,58.99 90.31,58.75 90.31,58.02
  S5 w0.102: 90.31,58.02 90.12,57.83 90.12,56.92 88.25,55.06 88.25,53.48 71.55,36.78 71.07,36.78 70.97,36.88 70.97,37.69 70.87,37.8 70.46,37.8 70.36,37.69 70.36,36.88 70.26,36.78 69.85,36.78 69.75,36.88 69.75,37.69 69.65,37.8 69.24,37.8 69.14,37.69 69.14,36.88 69.04,36.78 60.43,36.78 56.09,41.12 38.87,41.12 38.78,41.02 35.1,41.02 34.6,40.52 v2(34.6,39.7)
RP_DDR4_DIMM1_DQ63: length 78.3
  TOP w0.114: v2(39.51,39.65) 39.56,39.7 CONN7.246 ; U9.BJ66 v4(91.17,62.58)
  S5 w0.102: v4(91.17,62.58) 91.44,62.58 92.05,61.97 92.05,61.5 91.62,61.07 91.62,60.67 91.22,60.27 91.22,59.72 91.58,59.36 91.58,58.81 91.35,58.58 91.35,58.29 91.56,58.08 91.56,56.8 90.16,55.39 90.16,52.77 86.96,49.57 86.96,49.45 87.2,49.21 87.2,49.08 86.94,48.82 86.81,48.82 86.57,49.06 86.44,49.06 86.18,48.8 86.18,48.67 86.42,48.43 86.42,48.31 86.16,48.05 86.04,48.05 85.8,48.29 85.67,48.29 85.41,48.03 85.41,47.9 85.65,47.66 85.65,47.53 85.39,47.27 85.26,47.27 85.02,47.52 84.9,47.52 84.64,47.25 84.64,47.13 84.88,46.89 84.88,46.76 84.62,46.5 84.49,46.5 84.25,46.74 84.13,46.74 83.86,46.48 83.86,46.36 84.11,46.11 84.11,45.99 83.84,45.73 83.72,45.73 83.48,45.97 83.35,45.97 73.15,35.76 59.99,35.76 56.53,39.23 41.23,39.23 41.13,39.33 41.13,39.65 41.03,39.75 40.62,39.75 40.52,39.65 40.52,39.33 40.42,39.23 39.94,39.23 v2(39.51,39.65)
RP_DDR4_DIMM1_DQS0_N: length 68
  TOP w0.102: v2(35.89,101.01) 36.14,101.01 36.39,100.77 36.39,100.52 36.21,100.34 34.33,100.34 34.22,100.45 CONN7.11 ; U9.CB4 85.11,90.35 85.11,90.83 85.31,91.03 85.31,91.39 85.17,91.52 85.17,92.45 85.07,92.55 85.07,94.15 81.13,98.09 80.65,98.09 80.37,97.81 v3(79.99,97.81)
  S10 w0.089: 41.35,99.82 41.33,99.84 41.33,100.04 41.08,100.29 36.69,100.29 36.43,100.55 36.43,100.92 36.34,101.01 v2(35.89,101.01)
  S10 w0.102: 41.35,99.82 41.87,99.3 45.51,99.3 45.75,99.54 58.96,99.54 60.43,98.07 60.43,97.44 61.6,96.27 68.89,96.27 69.28,96.65 69.28,98.15 69.38,98.25 69.78,98.25 69.89,98.15 69.89,96.65 70.27,96.27 71.17,96.27 73.89,98.98 79.53,98.98 80.37,98.14 80.37,97.98 80.19,97.81 v3(79.99,97.81)
RP_DDR4_DIMM1_DQS0_P: length 67.9
  TOP w0.102: v2(37.16,101.01) 36.91,101.01 36.67,100.77 36.67,100.4 36.32,100.06 34.33,100.06 34.22,99.95 CONN7.13 ; U9.CB2 84.97,91.22 84.97,92.36 84.87,92.47 84.87,94.07 81.05,97.89 80.73,97.89 80.55,97.7 80.55,97.29 v3(80.53,97.27)
  S10 w0.089: 41.69,100.16 41.68,100.18 41.47,100.18 41.16,100.48 36.77,100.48 36.62,100.63 36.62,100.92 36.71,101.01 v2(37.16,101.01)
  S10 w0.102: 41.69,100.16 42.07,99.78 43.51,99.78 43.61,99.88 43.61,100.08 43.71,100.18 44.12,100.18 44.22,100.08 44.22,99.88 44.32,99.78 45.31,99.78 45.55,100.02 59.16,100.02 60.91,98.27 60.91,97.64 61.8,96.75 68.69,96.75 68.79,96.85 68.79,98.35 69.18,98.73 69.98,98.73 70.37,98.35 70.37,96.85 70.47,96.75 70.97,96.75 73.69,99.46 79.73,99.46 80.85,98.34 80.85,97.78 80.53,97.47 v3(80.53,97.27)
RP_DDR4_DIMM1_DQS1_N: length 64.6
  TOP w0.102: v2(38.6,96.01) 38.34,95.75 38.34,95.66 38.91,95.09 40.24,95.09 40.35,95.2 CONN7.32
  TOP w0.114: U9.CH7 v4(82.75,88.63)
  S5 w0.102: v2(38.6,96.01) 38.3,95.71 38.3,95.49 38.53,95.27 40.64,95.27 41,95.62 41.96,95.62 42.1,95.76 43.12,95.76 43.53,95.36 44.15,95.36 44.25,95.46 44.25,95.84 44.36,95.95 44.76,95.95 44.86,95.84 44.86,95.46 44.97,95.36 45.37,95.36 45.47,95.46 45.47,95.84 45.57,95.95 45.98,95.95 46.08,95.84 46.08,95.46 46.18,95.36 49.67,95.36 50.08,94.95 51.09,94.95 51.19,95.05 51.19,95.48 51.57,95.86 52.38,95.86 52.76,95.48 52.76,95.05 52.87,94.95 55.75,94.95 57.39,93.31 58.54,93.31 58.65,93.41 58.65,93.88 59.03,94.27 59.84,94.27 60.22,93.88 60.22,93.41 60.32,93.31 60.73,93.31 60.83,93.41 60.83,93.88 61.21,94.27 62.02,94.27 62.41,93.88 62.41,93.41 62.51,93.31 62.91,93.31 63.01,93.41 63.01,93.88 63.4,94.27 64.21,94.27 64.59,93.88 64.59,93.41 64.69,93.31 65.1,93.31 65.2,93.41 65.2,93.88 65.58,94.27 66.39,94.27 66.77,93.88 66.77,93.41 66.88,93.31 67.28,93.31 67.38,93.41 67.38,93.88 67.77,94.27 68.57,94.27 68.96,93.88 68.96,93.41 69.06,93.31 69.47,93.31 69.57,93.41 69.57,93.88 69.95,94.27 70.76,94.27 71.14,93.88 71.14,93.41 71.24,93.31 76.03,93.31 77.53,91.81 80.8,91.81 81.76,90.85 81.76,90.65 82.75,89.67 v4(82.75,88.63)
RP_DDR4_DIMM1_DQS1_P: length 64.5
  TOP w0.102: CONN7.34 40.35,94.7 40.24,94.81 38.79,94.81 38.06,95.55 38.06,95.75 v2(37.79,96.01)
  TOP w0.114: U9.CG9 v4(83.24,87.77)
  S5 w0.102: v2(37.79,96.01) 38.1,95.71 38.1,95.41 38.44,95.06 40.72,95.06 41.08,95.42 41.96,95.42 42.1,95.28 42.92,95.28 43.33,94.88 49.47,94.88 49.88,94.47 51.29,94.47 51.67,94.85 51.67,95.28 51.77,95.38 52.18,95.38 52.28,95.28 52.28,94.85 52.67,94.47 55.55,94.47 57.19,92.83 58.74,92.83 59.13,93.21 59.13,93.68 59.23,93.78 59.64,93.78 59.74,93.68 59.74,93.21 60.12,92.83 60.93,92.83 61.31,93.21 61.31,93.68 61.41,93.78 61.82,93.78 61.92,93.68 61.92,93.21 62.31,92.83 63.11,92.83 63.5,93.21 63.5,93.68 63.6,93.78 64.01,93.78 64.11,93.68 64.11,93.21 64.49,92.83 65.3,92.83 65.68,93.21 65.68,93.68 65.78,93.78 66.19,93.78 66.29,93.68 66.29,93.21 66.68,92.83 67.48,92.83 67.87,93.21 67.87,93.68 67.97,93.78 68.37,93.78 68.48,93.68 68.48,93.21 68.86,92.83 69.67,92.83 70.05,93.21 70.05,93.68 70.15,93.78 70.56,93.78 70.66,93.68 70.66,93.21 71.04,92.83 75.83,92.83 77.33,91.33 80.6,91.33 81.42,90.51 81.62,90.51 82.54,89.58 82.54,89.03 82.35,88.83 82.35,88.31 82.89,87.77 v4(83.24,87.77)
RP_DDR4_DIMM1_DQS2_N: length 59.4
  TOP w0.102: v2(36.62,90.55) 36.35,90.29 35.92,90.29 35.47,89.84 34.33,89.84 34.22,89.95 CONN7.53
  TOP w0.114: U9.CG13 v4(83.24,86.05)
  S10 w0.089: 80.34,87.98 80.35,87.97 80.35,87.76 80.6,87.51 80.98,87.51 81.34,87.14 81.34,86.78 81.62,86.5 81.89,86.5 82.01,86.62 82.49,86.62 82.67,86.45 82.72,86.39 83.01,86.1 83.06,86.05 v4(83.24,86.05) ; v2(36.62,90.55) 36.93,90.24 37.42,90.24 37.59,90.07 39.9,90.07 40.12,89.86 40.41,89.86 40.55,90 40.58,90
  S10 w0.102: 40.58,90 44.02,90 44.17,90.16 44.63,90.16 44.78,90 50.3,90 50.89,90.59 61.1,90.59 61.49,90.21 61.49,89.52 61.59,89.42 61.99,89.42 62.1,89.52 62.1,90.21 62.48,90.59 63.29,90.59 63.67,90.21 63.67,89.52 63.77,89.42 64.18,89.42 64.28,89.52 64.28,90.21 64.66,90.59 65.47,90.59 65.86,90.21 65.86,89.52 65.96,89.42 66.36,89.42 66.47,89.52 66.47,90.21 66.85,90.59 75.51,90.59 77.64,88.46 79.86,88.46 80.34,87.98
RP_DDR4_DIMM1_DQS2_P: length 59.4
  TOP w0.102: CONN7.55 34.22,89.45 34.33,89.56 35.59,89.56 36.03,90.01 36.35,90.01 v2(36.62,89.74)
  TOP w0.114: U9.CH14 v4(82.75,85.19)
  S10 w0.089: v2(36.62,89.74) 36.93,90.05 37.34,90.05 37.51,89.88 39.82,89.88 40.04,89.67 40.41,89.67 40.55,89.52 40.58,89.52 ; 80,87.64 80.01,87.62 80.22,87.62 80.53,87.32 80.9,87.32 81.15,87.06 81.15,86.7 81.54,86.31 81.97,86.31 82.09,86.43 82.41,86.43 82.53,86.31 82.82,86.02 82.82,85.26 v4(82.75,85.19)
  S10 w0.102: 80,87.64 79.66,87.98 77.44,87.98 75.31,90.11 67.05,90.11 66.95,90.01 66.95,89.32 66.56,88.93 65.76,88.93 65.37,89.32 65.37,90.01 65.27,90.11 64.86,90.11 64.76,90.01 64.76,89.32 64.38,88.93 63.57,88.93 63.19,89.32 63.19,90.01 63.09,90.11 62.68,90.11 62.58,90.01 62.58,89.32 62.19,88.93 61.39,88.93 61,89.32 61,90.01 60.9,90.11 51.09,90.11 50.5,89.52 40.58,89.52
RP_DDR4_DIMM1_DQS3_N: length 57.2
  TOP w0.102: v2(38.66,85.26) 38.39,85 38.39,84.69 38.48,84.59 40.24,84.59 40.35,84.7 CONN7.74
  TOP w0.114: U9.CD24 v4(84.23,80.9)
  S5 w0.089: 79.7,82.71 79.73,82.71 79.87,82.57 80.42,82.57 80.63,82.36 80.98,82.36 81.37,81.96 81.37,81.6 81.61,81.36 81.91,81.36 82.06,81.51 82.45,81.51 82.66,81.3 82.84,81.3 83.01,81.47 83.47,81.47 84.05,80.9 v4(84.23,80.9) ; v2(38.66,85.26) 38.34,84.95 38.34,84.74 38.43,84.66 43.3,84.66 43.44,84.8 43.46,84.8
  S5 w0.102: 43.46,84.8 44.01,84.8 44.11,84.9 44.11,84.99 44.49,85.37 45.3,85.37 45.69,84.99 45.69,84.9 45.79,84.8 52.59,84.8 52.81,85.03 53.39,85.03 53.49,85.13 53.49,85.26 53.59,85.36 53.99,85.36 54.1,85.26 54.1,85.13 54.2,85.03 54.6,85.03 54.71,85.13 54.71,85.26 54.81,85.36 55.21,85.36 55.32,85.26 55.32,85.13 55.42,85.03 55.82,85.03 55.93,85.13 55.93,85.26 56.03,85.36 56.43,85.36 56.53,85.26 56.53,85.13 56.64,85.03 57.04,85.03 57.14,85.13 57.14,85.26 57.25,85.36 57.65,85.36 57.75,85.26 57.75,85.13 57.86,85.03 58.26,85.03 58.36,85.13 58.36,85.26 58.47,85.36 58.87,85.36 58.97,85.26 58.97,85.13 59.07,85.03 64.96,85.03 65.06,85.13 65.06,85.57 65.44,85.95 66.25,85.95 66.64,85.57 66.64,85.13 66.74,85.03 76.82,85.03 79.14,82.71 79.7,82.71
RP_DDR4_DIMM1_DQS3_P: length 57.2
  TOP w0.102: CONN7.76 40.35,84.2 40.24,84.31 38.37,84.31 38.11,84.57 38.11,85 v2(37.84,85.26)
  TOP w0.114: U9.CB24 v4(85.22,80.9)
  S5 w0.089: v2(37.84,85.26) 38.15,84.95 38.15,84.66 38.35,84.47 43.3,84.47 43.44,84.32 43.46,84.32 ; v4(85.22,80.9) 84.77,80.9 84.35,80.47 84.08,80.47 83.8,80.75 83.8,80.88 83.64,81.04 83.4,81.28 83.09,81.28 82.92,81.11 82.58,81.11 82.37,81.32 82.14,81.32 81.99,81.17 81.53,81.17 81.18,81.52 81.18,81.88 80.9,82.17 80.55,82.17 80.35,82.38 79.87,82.38 79.73,82.23 79.7,82.23
  S5 w0.102: 43.46,84.32 44.21,84.32 44.59,84.7 44.59,84.79 44.69,84.89 45.1,84.89 45.2,84.79 45.2,84.7 45.59,84.32 52.79,84.32 53.01,84.54 65.16,84.54 65.54,84.93 65.54,85.37 65.65,85.47 66.05,85.47 66.15,85.37 66.15,84.93 66.54,84.54 76.62,84.54 78.94,82.23 79.7,82.23
RP_DDR4_DIMM1_DQS4_N: length 58.6
  TOP w0.102: v2(36.73,56.93) 36.92,56.93 37.22,56.63 37.22,56.28 37.1,56.16 36.55,56.16 35.87,56.84 34.33,56.84 34.22,56.95 CONN7.177
  TOP w0.114: U9.CD69 v4(84.23,60.87)
  S10 w0.089: v2(36.73,56.93) 37.18,56.93 37.26,56.84 37.26,56.45 37.51,56.21 39.09,56.21 39.24,56.06 39.26,56.06 ; v4(84.23,60.87) 84.23,61.08 84.15,61.16 83.92,61.16 83.83,61.07 83.83,60.63 83.48,60.28 83,60.28 82.91,60.38 82.58,60.38 82.46,60.27 82.04,60.27 81.9,60.42 81.62,60.42 81.37,60.17 81.37,59.81 80.92,59.35 80.18,59.35 80.03,59.21 80.01,59.21
  S10 w0.102: 80.01,59.21 79.63,59.21 78.03,57.61 72.31,57.61 71.1,56.4 55.79,56.4 54.91,55.51 45.76,55.51 45.66,55.41 45.66,55.22 45.55,55.12 45.15,55.12 45.05,55.22 45.05,55.41 44.95,55.51 44.54,55.51 44.44,55.41 44.44,55.22 44.34,55.12 43.93,55.12 43.83,55.22 43.83,55.41 43.73,55.51 41.55,55.51 41,56.06 39.26,56.06
RP_DDR4_DIMM1_DQS4_P: length 58.7
  TOP w0.102: v2(38,56.93) 37.74,56.93 37.5,56.69 37.5,56.17 37.21,55.88 36.43,55.88 35.75,56.56 34.33,56.56 34.22,56.45 CONN7.179
  TOP w0.114: U9.CB69 v4(85.22,60.87)
  S10 w0.089: 39.26,56.54 39.24,56.54 39.09,56.4 37.59,56.4 37.46,56.53 37.46,56.84 37.54,56.93 v2(38,56.93) ; v4(85.22,60.87) 84.87,61.22 84.36,61.22 84.23,61.35 83.84,61.35 83.64,61.15 83.64,60.71 83.4,60.47 83.08,60.47 82.98,60.57 82.5,60.57 82.38,60.46 82.12,60.46 81.98,60.61 81.54,60.61 81.18,60.25 81.18,59.89 80.84,59.55 80.18,59.55 80.03,59.69 80.01,59.69
  S10 w0.102: 39.26,56.54 41.2,56.54 41.75,56 54.71,56 55.59,56.88 70.9,56.88 72.11,58.09 77.83,58.09 79.43,59.69 80.01,59.69
RP_DDR4_DIMM1_DQS5_N: length 57.7
  TOP w0.102: v2(38.96,52.17) 38.66,52.17 38.47,51.98 38.47,51.79 38.67,51.59 40.24,51.59 40.35,51.7 CONN7.198
  TOP w0.114: U9.CL69 v4(81.26,60.87)
  S3 w0.089: 79.48,60.28 79.5,60.3 79.5,60.5 80.05,61.05 81.07,61.05 v4(81.26,60.87) ; v2(38.96,52.17) 38.51,52.17 38.42,52.26 38.42,52.51 38.77,52.85 40.52,52.85 40.67,52.71 40.69,52.71
  S3 w0.102: 40.69,52.71 41.05,52.71 42.38,54.05 43.89,54.05 43.99,53.94 43.99,53.59 44.09,53.49 44.5,53.49 44.6,53.59 44.6,53.94 44.7,54.05 45.1,54.05 45.21,53.94 45.21,53.59 45.31,53.49 45.71,53.49 45.82,53.59 45.82,53.94 45.92,54.05 52.7,54.05 53.09,54.43 57.98,54.43 58.08,54.33 58.08,53.85 58.46,53.47 59.27,53.47 59.65,53.85 59.65,54.33 59.75,54.43 60.16,54.43 60.26,54.33 60.26,53.85 60.65,53.47 61.45,53.47 61.84,53.85 61.84,54.33 61.94,54.43 62.34,54.43 62.45,54.33 62.45,53.85 62.83,53.47 63.64,53.47 64.02,53.85 64.02,54.33 64.12,54.43 65.76,54.43 70.01,58.69 76.35,58.69 76.91,59.25 78.45,59.25 79.48,60.28
RP_DDR4_DIMM1_DQS5_P: length 57.6
  TOP w0.102: v2(37.69,52.17) 38,52.17 38.19,51.98 38.19,51.68 38.55,51.31 40.24,51.31 40.35,51.2 CONN7.200
  TOP w0.114: U9.CJ69 v4(82.25,60.87)
  S3 w0.089: 40.69,53.19 40.67,53.19 40.52,53.05 38.69,53.05 38.23,52.59 38.23,52.26 38.14,52.17 v2(37.69,52.17) ; 79.14,60.62 79.16,60.64 79.36,60.64 79.97,61.24 81.15,61.24 81.18,61.27 81.85,61.27 v4(82.25,60.87)
  S3 w0.102: 79.14,60.62 78.25,59.73 76.71,59.73 76.15,59.17 69.81,59.17 65.55,54.92 63.92,54.92 63.54,54.53 63.54,54.05 63.44,53.95 63.03,53.95 62.93,54.05 62.93,54.53 62.54,54.92 61.74,54.92 61.35,54.53 61.35,54.05 61.25,53.95 60.85,53.95 60.74,54.05 60.74,54.53 60.36,54.92 59.55,54.92 59.17,54.53 59.17,54.05 59.07,53.95 58.66,53.95 58.56,54.05 58.56,54.53 58.18,54.92 52.89,54.92 52.5,54.53 42.18,54.53 40.84,53.19 40.69,53.19
RP_DDR4_DIMM1_DQS6_N: length 86.2
  TOP w0.102: CONN7.219 34.22,46.45 34.33,46.34 35.28,46.34 36.01,45.62 36.69,45.62 36.92,45.85 36.92,46.41 v2(36.65,46.68)
  TOP w0.114: U9.BM72 v4(90.18,59.15)
  S8 w0.102: v4(90.18,59.15) 90.38,58.95 90.38,58.14 90.07,57.83 90.07,57.13 91.7,55.5 91.7,52.21 80.16,40.67 78.8,40.67 78.42,41.05 78.42,41.61 78.32,41.71 77.91,41.71 77.81,41.61 77.81,41.05 77.43,40.67 76.62,40.67 76.24,41.05 76.24,41.61 76.13,41.71 75.73,41.71 75.63,41.61 75.63,41.05 75.24,40.67 74.44,40.67 74.05,41.05 74.05,41.61 73.95,41.71 73.54,41.71 73.44,41.61 73.44,41.05 73.06,40.67 72.25,40.67 71.87,41.05 71.87,41.61 71.77,41.71 71.36,41.71 71.26,41.61 71.26,41.05 70.87,40.67 69.82,40.67 69.16,41.33 69.16,43.49 66.35,46.3 62.61,46.3 59.84,43.54 58.5,43.54 58.12,43.92 58.12,43.99 58.02,44.09 57.61,44.09 57.51,43.99 57.51,43.92 57.13,43.54 52.51,43.54 52.26,43.79 45.42,43.79 43.47,45.74 37.28,45.74 36.81,46.2 36.81,46.51 v2(36.65,46.68)
RP_DDR4_DIMM1_DQS6_P: length 86.1
  TOP w0.102: CONN7.221 34.22,45.95 34.33,46.06 35.17,46.06 35.89,45.34 36.8,45.34 37.19,45.73 37.19,46.41 v2(37.46,46.68) ; U9.BN71 v4(89.68,60.01)
  S8 w0.102: v2(37.46,46.68) 37.3,46.51 37.3,46.4 37.48,46.22 43.67,46.22 44.29,45.61 44.43,45.61 44.46,45.63 44.6,45.63 44.89,45.35 44.89,45.2 44.86,45.17 44.86,45.03 45.62,44.28 52.46,44.28 52.71,44.02 56.93,44.02 57.03,44.12 57.03,44.19 57.41,44.58 58.22,44.58 58.6,44.19 58.6,44.12 58.7,44.02 59.64,44.02 62.41,46.79 66.55,46.79 69.65,43.69 69.65,41.53 70.02,41.15 70.67,41.15 70.78,41.25 70.78,41.81 71.16,42.19 71.97,42.19 72.35,41.81 72.35,41.25 72.45,41.15 72.86,41.15 72.96,41.25 72.96,41.81 73.34,42.19 74.15,42.19 74.53,41.81 74.53,41.25 74.64,41.15 75.04,41.15 75.14,41.25 75.14,41.81 75.53,42.19 76.33,42.19 76.72,41.81 76.72,41.25 76.82,41.15 77.23,41.15 77.33,41.25 77.33,41.81 77.71,42.19 78.52,42.19 78.9,41.81 78.9,41.25 79,41.15 79.96,41.15 91.22,52.41 91.22,55.3 89.59,56.93 89.59,57.83 89.45,57.97 89.45,58.98 89.68,59.22 v4(89.68,60.01)
RP_DDR4_DIMM1_DQS7_N: length 78.4
  TOP w0.102: CONN7.240 40.35,41.2 40.24,41.09 37.31,41.09 37.19,41.2 37.19,41.35 v2(37.46,41.61) ; U9.BN67 v4(89.68,61.73)
  S5 w0.089: 40.26,41.85 40.24,41.85 40.1,41.99 39.38,41.99 39.16,42.21 37.27,42.21 37.15,42.09 37.15,41.93 v2(37.46,41.61) ; 89.03,57.2 89.04,57.22 89.04,57.43 89.54,57.92 89.54,59.47 89.29,59.72 89.29,60.17 89.77,60.64 89.77,61.15 89.68,61.24 v4(89.68,61.73)
  S5 w0.102: 40.26,41.85 41.1,41.85 41.42,42.17 42.99,42.17 43.09,42.07 43.09,41.73 43.2,41.63 43.6,41.63 43.7,41.73 43.7,42.07 43.81,42.17 44.21,42.17 44.31,42.07 44.31,41.73 44.42,41.63 44.82,41.63 44.92,41.73 44.92,42.07 45.03,42.17 54.51,42.17 56.82,44.48 56.97,44.48 57.29,44.16 57.83,44.16 58.4,44.74 58.4,45.28 58.08,45.6 58.08,45.74 59.04,46.7 68.49,46.7 68.59,46.6 68.59,46.29 68.98,45.91 69.78,45.91 70.17,46.29 70.17,46.6 70.27,46.7 70.68,46.7 70.78,46.6 70.78,46.29 71.16,45.91 71.97,45.91 72.35,46.29 72.35,46.6 72.45,46.7 72.86,46.7 72.96,46.6 72.96,46.29 73.35,45.91 74.15,45.91 74.54,46.29 74.54,46.6 74.64,46.7 75.05,46.7 75.15,46.6 75.15,46.29 75.53,45.91 76.34,45.91 76.72,46.29 76.72,46.6 76.82,46.7 77.23,46.7 77.33,46.6 77.33,46.29 77.72,45.91 78.52,45.91 78.91,46.29 78.91,46.6 79.01,46.7 80,46.7 86.68,53.38 86.68,54.85 89.03,57.2
RP_DDR4_DIMM1_DQS7_P: length 78.4
  TOP w0.102: CONN7.242 40.35,40.7 40.24,40.81 37.19,40.81 36.92,41.09 36.92,41.35 v2(36.65,41.61) ; U9.BM66 v4(90.18,62.58)
  S5 w0.089: 40.26,42.33 40.24,42.33 40.1,42.18 39.46,42.18 39.24,42.4 37.19,42.4 36.96,42.17 36.96,41.93 v2(36.65,41.61) ; v4(90.18,62.58) 89.95,62.58 89.29,61.93 89.29,61.36 89.58,61.07 89.58,60.72 89.1,60.25 89.1,59.64 89.35,59.39 89.35,58 88.91,57.56 88.7,57.56 88.69,57.54
  S5 w0.102: 40.26,42.33 40.9,42.33 41.22,42.65 54.31,42.65 56.62,44.97 57.17,44.97 57.49,44.65 57.63,44.65 57.92,44.94 57.92,45.08 57.6,45.4 57.6,45.94 58.84,47.18 68.69,47.18 69.08,46.8 69.08,46.49 69.18,46.39 69.58,46.39 69.69,46.49 69.69,46.8 70.07,47.18 70.88,47.18 71.26,46.8 71.26,46.49 71.36,46.39 71.77,46.39 71.87,46.49 71.87,46.8 72.25,47.18 73.06,47.18 73.44,46.8 73.44,46.49 73.55,46.39 73.95,46.39 74.05,46.49 74.05,46.8 74.44,47.18 75.25,47.18 75.63,46.8 75.63,46.49 75.73,46.39 76.14,46.39 76.24,46.49 76.24,46.8 76.62,47.18 77.43,47.18 77.81,46.8 77.81,46.49 77.92,46.39 78.32,46.39 78.42,46.49 78.42,46.8 78.81,47.18 79.8,47.18 86.2,53.58 86.2,55.05 88.69,57.54
RP_DDR4_DIMM1_DQS8_N: length 53.9
  TOP w0.102: CONN7.95 34.22,79.45 34.33,79.34 36.97,79.34 37.14,79.52 37.14,79.97 36.9,80.21 v2(36.65,80.21)
  TOP w0.114: U9.CL24 v4(81.26,80.9)
  S10 w0.089: 80.19,80.96 80.21,80.96 80.36,81.11 81.05,81.11 v4(81.26,80.9)
  S10 w0.102: v2(36.65,80.21) 37.04,79.82 37.04,79.52 37.48,79.08 40.96,79.08 41.51,79.64 57.23,79.64 59.09,81.5 60.18,81.5 60.28,81.39 60.28,81.29 60.38,81.19 60.79,81.19 60.89,81.29 60.89,81.39 60.99,81.5 61.4,81.5 61.5,81.39 61.5,81.29 61.6,81.19 62.01,81.19 62.11,81.29 62.11,81.39 62.21,81.5 63.7,81.5 64.09,81.88 64.09,81.9 64.19,82 64.6,82 64.7,81.9 64.7,81.88 65.08,81.5 65.89,81.5 66.27,81.88 66.27,81.9 66.37,82 66.78,82 66.88,81.9 66.88,81.88 67.27,81.5 77.76,81.5 78.29,80.96 80.19,80.96
RP_DDR4_DIMM1_DQS8_P: length 53.9
  TOP w0.102: CONN7.97 34.22,78.95 34.33,79.06 37.08,79.06 37.42,79.4 37.42,79.97 37.67,80.21 v2(37.92,80.21)
  TOP w0.114: U9.CJ24 v4(82.25,80.9)
  S10 w0.089: 80.19,81.45 80.21,81.45 80.36,81.3 81.66,81.3 81.67,81.3 81.85,81.3 v4(82.25,80.9)
  S10 w0.102: 80.19,81.45 78.49,81.45 77.96,81.98 67.47,81.98 67.37,82.08 67.37,82.1 66.98,82.48 66.17,82.48 65.79,82.1 65.79,82.08 65.69,81.98 65.28,81.98 65.18,82.08 65.18,82.1 64.8,82.48 63.99,82.48 63.61,82.1 63.61,82.08 63.5,81.98 58.89,81.98 57.03,80.12 41.31,80.12 40.76,79.57 37.68,79.57 37.53,79.72 37.53,79.82 v2(37.92,80.21)
RP_DDR4_DIMM1_ECC0: length 53.6
  TOP w0.114: U9.CL20 v4(81.26,82.62) ; CONN7.92 v2(39.94,80.2)
  S10 w0.102: v4(81.26,82.62) 80.89,82.25 78.85,82.25 78.05,83.05 59.04,83.05 57.48,81.49 57.3,81.49 57.09,81.7 57.09,81.87 57.83,82.61 57.83,82.79 57.62,83 57.44,83 56.03,81.58 54.09,81.58 54,81.49 54,80.86 53.91,80.77 53.54,80.77 53.46,80.86 53.46,81.49 53.37,81.58 53,81.58 52.91,81.49 52.91,80.86 52.82,80.77 52.45,80.77 52.36,80.86 52.36,81.49 52.17,81.69 50.71,81.69 50.61,81.58 50.61,81.52 50.51,81.42 50.1,81.42 50,81.52 50,81.58 49.9,81.69 49.49,81.69 49.39,81.58 49.39,81.52 49.29,81.42 48.88,81.42 48.78,81.52 48.78,81.58 48.68,81.69 48.27,81.69 48.17,81.58 48.17,81.52 48.07,81.42 47.67,81.42 47.56,81.52 47.56,81.58 47.46,81.69 47.06,81.69 46.95,81.58 46.95,81.52 46.85,81.42 46.45,81.42 46.34,81.52 46.34,81.58 46.24,81.69 45.09,81.69 44.99,81.58 44.99,80.89 44.89,80.79 44.49,80.79 44.38,80.89 44.38,81.58 44.28,81.69 42.14,81.69 40.6,80.15 40,80.15 v2(39.94,80.2)
RP_DDR4_DIMM1_ECC1: length 53.6
  TOP w0.114: v2(35.85,81.67) 34.64,80.45 CONN7.91 ; U9.CJ20 v4(82.25,82.62)
  S10 w0.102: v2(35.85,81.67) 35.65,81.46 35.65,81.2 35.83,81.02 40.63,81.02 41.79,82.18 53.34,82.18 53.42,82.27 53.42,82.67 53.51,82.76 53.88,82.76 53.97,82.67 53.97,82.27 54.06,82.18 55.78,82.18 57.25,83.64 78.61,83.64 79.36,82.89 80.87,82.89 81.02,83.03 81.53,83.03 81.95,82.62 v4(82.25,82.62)
RP_DDR4_DIMM1_ECC2: length 53.5
  TOP w0.114: CONN7.101 34.11,77.95 34.37,78.21 35.57,78.21 v2(36.31,77.47) ; U9.CL28 v4(81.26,79.18)
  S10 w0.102: v2(36.31,77.47) 36.48,77.3 44.07,77.3 44.17,77.4 44.17,77.57 44.27,77.68 44.68,77.68 44.78,77.57 44.78,77.4 44.88,77.3 52.87,77.3 53.34,76.83 57.1,76.83 59.49,79.22 67.54,79.22 67.63,79.14 67.63,78.78 67.72,78.69 68.08,78.69 68.17,78.78 68.17,79.14 68.26,79.22 68.63,79.22 68.72,79.14 68.72,78.78 68.81,78.69 69.18,78.69 69.27,78.78 69.27,79.14 69.35,79.22 69.72,79.22 69.81,79.14 69.81,78.78 69.9,78.69 76.4,78.69 77.22,79.51 79.39,79.51 79.72,79.18 v4(81.26,79.18)
RP_DDR4_DIMM1_ECC3: length 53.5
  TOP w0.114: CONN7.105 34.17,76.95 v2(34.68,77.46) ; U9.CJ28 v4(82.25,79.18)
  S10 w0.102: v2(34.68,77.46) 34.68,77.2 35.19,76.7 47.14,76.7 47.97,75.87 50.24,75.87 50.59,76.21 51.08,76.21 51.18,76.32 51.18,76.45 51.28,76.55 51.69,76.55 51.79,76.45 51.79,76.32 51.89,76.21 57.29,76.21 59.08,78 66.01,78 66.1,78.09 66.1,78.48 66.22,78.6 66.86,78.6 66.99,78.48 66.99,78.09 67.08,78 76.14,78 77.07,78.93 80.85,78.93 80.99,78.79 81.78,78.79 82.18,79.18 v4(82.25,79.18)
RP_DDR4_DIMM1_ECC4: length 53.5
  TOP w0.114: U9.CM18 v4(80.77,83.47) ; v2(37.48,81.69) 39.8,81.69 40.29,81.2 CONN7.88
  S10 w0.102: v2(37.48,81.69) 40.45,81.69 40.68,81.92 40.68,82.04 40.41,82.32 40.41,82.44 40.67,82.7 40.79,82.7 41.07,82.43 41.19,82.43 41.45,82.69 41.45,82.82 41.18,83.09 41.18,83.22 41.44,83.48 41.57,83.48 41.84,83.2 41.97,83.2 42.12,83.35 43.59,83.35 44.16,82.78 44.48,82.78 44.57,82.87 44.57,83.27 44.66,83.35 45.03,83.35 45.12,83.27 45.12,82.87 45.21,82.78 45.57,82.78 45.66,82.87 45.66,83.27 45.75,83.35 56.11,83.35 57.4,84.64 78.27,84.64 79.79,83.13 80.42,83.13 v4(80.77,83.47)
RP_DDR4_DIMM1_ECC5: length 53.6
  TOP w0.114: v2(36.16,83.04) 35.13,82.01 34.8,82.01 34.25,81.45 CONN7.87 ; U9.CK18 v4(81.76,83.47)
  S10 w0.102: v2(36.16,83.04) 37.25,84.13 37.78,84.13 37.87,84.04 37.87,83.75 37.96,83.66 38.33,83.66 38.42,83.75 38.42,84.04 38.51,84.13 38.88,84.13 38.97,84.04 38.97,83.75 39.05,83.66 39.42,83.66 39.51,83.75 39.51,84.04 39.6,84.13 39.97,84.13 40.06,84.04 40.06,83.75 40.15,83.66 40.51,83.66 40.6,83.75 40.6,84.04 40.69,84.13 56.04,84.13 57.15,85.24 78.44,85.24 79.77,83.91 81.32,83.91 v4(81.76,83.47)
RP_DDR4_DIMM1_ECC6: length 53.5
  TOP w0.114: U9.CM26 v4(80.77,80.04) ; CONN7.100 40.58,78.2 40,78.78 37.97,78.78 v2(37.56,78.37)
  S10 w0.102: v4(80.77,80.04) 80.77,80.3 80.58,80.49 77.48,80.49 77.19,80.79 75.92,80.79 75.74,80.97 64.01,80.97 63.35,80.31 62.85,80.31 62.75,80.41 62.75,80.58 62.65,80.69 62.24,80.69 62.14,80.58 62.14,80.41 62.04,80.31 61.63,80.31 61.53,80.41 61.53,80.58 61.43,80.69 61.02,80.69 60.92,80.58 60.92,80.41 60.82,80.31 60.41,80.31 60.31,80.41 60.31,80.58 60.21,80.69 59.8,80.69 59.7,80.58 59.7,80.41 59.6,80.31 58.89,80.31 57.15,78.57 56.36,78.57 56.26,78.67 56.26,79.05 56.16,79.15 55.75,79.15 55.65,79.05 55.65,78.67 55.55,78.57 55.14,78.57 55.04,78.67 55.04,79.05 54.94,79.15 54.53,79.15 54.43,79.05 54.43,78.67 54.33,78.57 53.85,78.57 53.36,79.06 42.21,79.06 41.64,78.49 37.68,78.49 v2(37.56,78.37)
RP_DDR4_DIMM1_ECC7: length 53.5
  TOP w0.114: v2(39.58,77.89) 39.83,77.89 40.21,77.51 40.22,77.51 40.53,77.2 CONN7.104 ; U9.CK26 v4(81.76,80.04)
  S10 w0.102: v2(39.58,77.89) 41.89,77.89 42.46,78.46 43.92,78.46 44.02,78.36 44.02,78.28 44.12,78.18 44.53,78.18 44.63,78.28 44.63,78.36 44.73,78.46 46.01,78.46 46.11,78.36 46.11,78.03 46.21,77.93 46.61,77.93 46.72,78.03 46.72,78.36 46.82,78.46 52.89,78.46 54.03,77.33 56.75,77.33 59.25,79.82 64.37,79.82 64.46,79.91 64.46,80.28 64.55,80.37 64.91,80.37 65,80.28 65,79.91 65.09,79.82 65.46,79.82 65.55,79.91 65.55,80.28 65.64,80.37 66.01,80.37 66.1,80.28 66.1,79.91 66.18,79.82 66.55,79.82 66.64,79.91 66.64,80.28 66.73,80.37 67.1,80.37 67.19,80.28 67.19,79.91 67.28,79.82 67.64,79.82 67.73,79.91 67.73,80.28 67.82,80.37 68.19,80.37 68.28,80.28 68.28,79.91 68.37,79.82 68.74,79.82 68.83,79.91 68.83,80.28 68.91,80.37 69.28,80.37 69.37,80.28 69.37,79.91 69.46,79.82 69.83,79.82 69.92,79.91 69.92,80.28 70.01,80.37 70.38,80.37 70.46,80.28 70.46,79.91 70.55,79.82 75.86,79.82 75.95,79.92 80.22,79.92 80.55,79.58 80.93,79.58 81.39,80.04 v4(81.76,80.04)
RP_DDR4_DIMM1_MA0: length 63
  TOP w0.178: U9.CK49 v4(81.76,69.74) ; CONN7.144 40.71,67.2 39.92,66.42 v2(39.92,65.82)
  S8 w0.152: v2(39.92,65.82) 39.92,65.61 40.33,65.21 44.28,65.21 44.41,65.08 44.41,64.4 44.28,64.28 42.42,64.28 42.23,64.08 42.23,63.34 42.63,62.94 44.63,62.94 44.79,63.1 44.79,63.76 44.95,63.91 45.59,63.91 45.75,63.76 45.75,63.1 45.9,62.94 53.29,62.94 54.49,64.15 56.65,64.15 56.8,63.99 56.8,63.12 56.95,62.97 57.59,62.97 57.76,63.14 57.76,64.09 58.03,64.36 59.09,64.36 60.51,62.94 68.04,62.94 68.16,63.07 68.16,64.39 68.29,64.52 69.94,64.52 70.07,64.39 70.07,63.1 70.22,62.94 70.84,62.94 71,63.11 71,64.22 71.3,64.52 76.99,64.52 80.31,67.84 80.31,68.18 80.77,68.64 80.77,69.09 81.05,69.37 81.56,69.37 81.76,69.56 v4(81.76,69.74)
RP_DDR4_DIMM1_MA1: length 58.3
  TOP w0.178: v2(35.05,70.3) 34.7,69.95 CONN7.133 ; U9.CK41 81.5,73.32 v4(81.76,73.17)
  S8 w0.089: 77.73,67.21 78.51,68 78.51,69.65 79.87,71.01 80.46,71.01 80.59,70.88 80.85,70.88 81.05,71.08 81.49,71.08 81.64,70.94 81.89,70.94 82.26,71.3 82.26,71.69 82.74,72.17 82.74,72.5 82.07,73.17 v4(81.76,73.17)
  S8 w0.152: v2(35.05,70.3) 34.84,70.3 34.61,70.07 34.61,69.8 34.84,69.56 37.63,69.56 37.99,69.2 40.92,69.2 42.4,67.72 45.03,67.72 46.17,66.58 66.61,66.58 67.41,67.38 72.2,67.38 72.36,67.21 77.73,67.21
RP_DDR4_DIMM1_MA2: length 58.1
  TOP w0.178: v4(80.77,73.17) U9.CM41 ; CONN7.132 40.03,70.2 v2(39.94,70.3)
  S8 w0.152: v2(39.94,70.3) 39.99,70.36 41.48,70.36 42.4,69.44 53.19,69.44 54.37,68.26 55.05,68.26 55.44,68.65 55.98,68.65 56.13,68.5 56.13,68.12 56.29,67.97 56.64,67.97 56.8,68.12 56.8,68.5 56.95,68.65 57.3,68.65 57.46,68.5 57.46,68.12 57.61,67.97 57.96,67.97 58.12,68.12 58.12,68.5 58.27,68.65 58.75,68.65 58.9,68.5 58.9,67.8 59.06,67.65 59.41,67.65 59.56,67.8 59.56,68.5 59.72,68.65 60.07,68.65 60.22,68.5 60.22,67.8 60.38,67.65 60.73,67.65 60.88,67.8 60.88,68.5 61.04,68.65 61.39,68.65 61.54,68.5 61.54,67.8 61.7,67.65 62.05,67.65 62.21,67.8 62.21,68.5 62.36,68.65 62.71,68.65 62.87,68.5 62.87,67.8 63.02,67.65 63.37,67.65 63.53,67.8 63.53,68.5 63.68,68.65 64.03,68.65 64.19,68.5 64.19,67.8 64.34,67.65 64.69,67.65 64.85,67.8 64.85,68.5 65,68.65 65.35,68.65 65.51,68.5 65.51,67.8 65.66,67.65 66.02,67.65 66.17,67.8 66.17,68.5 66.32,68.65 69.38,68.65 69.73,68.99 76.58,68.99 78.69,71.1 78.69,71.71 80.16,73.17 v4(80.77,73.17)
RP_DDR4_DIMM1_MA3: length 59.8
  TOP w0.178: v2(36.67,70.28) 36.67,70.37 36.12,70.92 34.62,70.92 34.15,70.45 CONN7.131 ; U9.CF41 v4(83.74,73.17)
  S10 w0.152: v2(36.67,70.28) 36.4,70.01 36.4,69.65 36.59,69.45 41.21,69.45 42.92,67.74 57.73,67.74 60.52,70.54 63.95,70.54 64.11,70.7 64.11,71.29 64.26,71.44 64.91,71.44 65.07,71.29 65.07,70.7 65.22,70.54 65.87,70.54 66.02,70.7 66.02,71.31 66.15,71.44 66.86,71.44 66.98,71.31 66.98,70.7 67.14,70.54 67.99,70.54 68.28,70.83 68.65,70.83 68.94,70.54 69.31,70.54 69.6,70.83 69.97,70.83 70.26,70.54 70.63,70.54 70.92,70.83 72.61,70.83 72.9,70.54 73.27,70.54 73.56,70.83 73.93,70.83 74.22,70.54 74.59,70.54 74.88,70.83 75.25,70.83 75.54,70.54 76.64,70.54 78.86,72.76 83.33,72.76 v4(83.74,73.17)
RP_DDR4_DIMM1_MA4: length 59.5
  TOP w0.178: U9.CL39 v4(81.26,74.03) ; CONN7.128 40.29,71.2 40.22,71.13 38.96,71.13 38.31,70.49 v2(38.31,70.28)
  S8 w0.152: v4(81.26,74.03) 81.31,73.98 81.31,73.05 80.8,72.54 80.8,72.15 80.28,71.63 79.79,71.63 76.94,68.77 76.94,67.82 76.76,67.64 76.35,67.64 76.01,67.98 67.33,67.98 66.41,67.07 56.45,67.07 55.75,67.77 52.97,67.77 52.82,67.92 52.82,68.83 52.67,68.98 52.31,68.98 52.16,68.83 52.16,67.92 52.01,67.77 51.65,67.77 51.5,67.92 51.5,68.83 51.35,68.98 50.99,68.98 50.84,68.83 50.84,67.92 50.69,67.77 49.13,67.77 48.62,68.28 46.73,68.28 46.58,68.43 46.58,68.83 46.43,68.98 46.07,68.98 45.92,68.83 45.92,68.43 45.77,68.28 45.41,68.28 45.26,68.43 45.26,68.83 45.11,68.98 44.75,68.98 44.6,68.83 44.6,68.43 44.44,68.28 42.64,68.28 42.44,68.48 42.44,68.79 42.23,69 41.8,69 41.11,69.69 38.74,69.69 38.31,70.12 v2(38.31,70.28)
RP_DDR4_DIMM1_MA5: length 60.2
  TOP w0.178: CONN7.126 41.38,71.71 39.96,71.71 39.92,71.67 38.8,71.67 38.34,72.13 v2(38.34,72.34) ; U9.CG39 v4(83.24,74.03)
  S8 w0.089: v4(83.24,74.03) 82.87,74.03 82.25,74.65 82.25,74.95 81.83,75.37 80.52,75.37
  S8 w0.152: v2(38.34,72.34) 39.27,71.4 41.89,71.4 42.4,70.89 46.81,70.89 47.18,71.26 51.66,71.26 52.15,70.78 53.86,70.78 54.06,70.58 54.06,70.08 54.22,69.92 55.23,69.92 55.34,70.04 55.94,70.04 56.68,70.78 63.31,70.78 63.5,70.97 63.98,70.97 64.13,70.82 64.13,69.82 64.28,69.67 64.64,69.67 64.79,69.82 64.79,70.82 64.94,70.97 65.3,70.97 65.45,70.82 65.45,69.82 65.6,69.67 65.96,69.67 66.11,69.82 66.11,70.82 66.26,70.97 66.75,70.97 66.9,70.82 66.9,70.1 67.05,69.95 67.41,69.95 67.56,70.1 67.56,70.82 67.71,70.97 76.96,70.97 77.8,71.8 77.8,72.27 79.84,74.31 79.84,74.7 80.52,75.37
RP_DDR4_DIMM1_MA6: length 60.1
  TOP w0.178: U9.CK37 v4(81.76,74.89) ; v2(37.09,72.39) 37.09,72.27 36.27,71.45 CONN7.127
  S8 w0.152: v4(81.76,74.89) 81.45,74.89 80.86,74.3 80.47,74.3 80.22,74.06 80.22,73.98 79.48,73.23 79.48,73.1 78.2,71.82 78.2,71.22 76.55,69.57 68.02,69.57 67.58,69.13 63.71,69.13 63.6,69.25 63.3,69.25 63.3,69.25 62.77,69.25 62.62,69.4 62.62,69.95 62.46,70.1 62.11,70.1 61.96,69.95 61.96,69.4 61.8,69.25 61.45,69.25 61.3,69.4 61.3,69.95 61.14,70.1 60.79,70.1 60.64,69.95 60.64,69.4 60.48,69.25 60.13,69.25 59.97,69.4 59.97,69.95 59.82,70.1 59.47,70.1 59.31,69.95 59.31,69.4 59.16,69.25 58.81,69.25 58.65,69.4 58.65,69.95 58.5,70.1 58.15,70.1 57.99,69.95 57.99,69.4 57.84,69.25 57.22,69.25 56.92,69.55 55.52,69.55 55.22,69.25 54.2,69.25 53.53,69.92 42.61,69.92 41.61,70.91 37.4,70.91 37.09,71.22 v2(37.09,72.39)
RP_DDR4_DIMM1_MA7: length 61.7
  TOP w0.178: CONN7.122 40.5,72.7 40.14,72.35 v2(39.96,72.35) ; U9.CD39 v4(84.23,74.03)
  S8 w0.089: v4(84.23,74.03) 84.75,74.03 85.17,74.45 85.17,75.11 84.9,75.37 82.1,75.37 81.79,75.68
  S8 w0.152: v2(39.96,72.35) 39.96,72.1 40.17,71.89 40.9,71.89 41.05,72.05 41.05,72.33 41.2,72.48 41.56,72.48 41.71,72.33 41.71,72.05 41.86,71.89 42.32,71.89 42.7,71.51 43.18,71.51 43.33,71.67 43.33,72.04 43.48,72.19 43.84,72.19 43.99,72.04 43.99,71.67 44.15,71.51 46.46,71.51 46.69,71.75 52.03,71.75 52.56,72.28 53.52,72.28 53.64,72.15 53.64,71.42 53.8,71.26 54.44,71.26 54.6,71.42 54.6,72.15 54.73,72.28 55.43,72.28 55.56,72.15 55.56,71.42 55.71,71.26 56.36,71.26 56.51,71.42 56.51,72.15 56.64,72.28 57.34,72.28 57.47,72.15 57.47,71.42 57.62,71.26 58.27,71.26 58.42,71.42 58.42,72.15 58.55,72.28 59.25,72.28 59.38,72.15 59.38,71.42 59.53,71.26 61.02,71.26 61.46,71.7 61.87,71.7 62.15,71.42 76.71,71.42 77.28,72 77.28,72.35 79.01,74.08 79.01,75.24 80.06,76.3 80.46,76.3 80.67,76.09 80.92,76.09 81.06,76.23 81.54,76.23 81.79,75.99 81.79,75.68
RP_DDR4_DIMM1_MA8: length 60.2
  TOP w0.178: CONN7.125 34.2,71.95 34.59,72.34 v2(35.46,72.34) ; U9.CM37 v4(80.77,74.89)
  S10 w0.152: v4(80.77,74.89) 80.06,74.18 78.84,74.18 77.07,72.42 60.25,72.42 59.8,71.97 59.59,71.97 59.12,72.44 58.9,72.44 58.65,72.18 58.65,71.97 59.12,71.5 59.12,71.28 58.87,71.03 58.65,71.03 58.18,71.5 57.97,71.5 57.72,71.25 57.72,71.04 58.19,70.56 58.19,70.35 57.56,69.72 56.61,69.72 56.46,69.58 56.46,68.96 56.3,68.8 55.66,68.8 55.5,68.96 55.5,69.58 55.34,69.73 54.41,69.73 54.25,69.58 54.25,68.94 54.09,68.77 53.6,68.77 53.45,68.92 53.45,69.49 53.3,69.64 52.94,69.64 52.79,69.49 52.79,68.92 52.64,68.77 51.16,68.77 50.65,69.28 46.69,69.28 46.54,69.13 46.54,68.99 46.38,68.83 46.03,68.83 45.88,68.99 45.88,69.13 45.72,69.28 45.37,69.28 45.22,69.13 45.22,68.99 45.06,68.83 44.71,68.83 44.55,68.99 44.55,69.13 44.4,69.28 42.76,69.28 40.66,71.38 35.78,71.38 35.46,71.7 v2(35.46,72.34)
RP_DDR4_DIMM1_MA9: length 58.4
  TOP w0.178: v2(36.32,73.52) 35.76,72.96 34.48,72.96 34.47,72.95 CONN7.121 ; U9.CJ35 v4(82.25,75.75)
  S8 w0.152: v4(82.25,75.75) 82.25,76.75 81.91,77.09 81.52,77.09 81.39,76.95 81.14,76.95 81,77.09 80.51,77.09 80.24,76.81 79.74,76.81 78.52,75.59 78.52,74.27 76.76,72.5 66.81,72.5 66.66,72.35 66.66,72.14 66.5,71.98 66.15,71.98 66,72.14 66,72.35 65.84,72.5 65.49,72.5 65.34,72.35 65.34,72.14 65.18,71.98 64.83,71.98 64.68,72.14 64.68,72.35 64.52,72.5 64.17,72.5 64.02,72.35 64.02,72.14 63.86,71.98 63.51,71.98 63.35,72.14 63.35,72.35 63.2,72.5 61.19,72.5 60.95,72.26 60.95,71.88 60.82,71.75 60.12,71.75 59.99,71.88 59.99,72.61 59.84,72.77 46.1,72.77 45.94,72.61 45.94,72.36 45.82,72.24 45.11,72.24 44.99,72.36 44.99,72.61 44.83,72.77 42.31,72.77 41.99,73.09 36.56,73.09 36.32,73.33 v2(36.32,73.52)
RP_DDR4_DIMM1_MA10: length 62
  TOP w0.178: v2(38.14,65.82) 38.14,64.93 38.37,64.7 CONN7.146 ; U9.CJ51 v4(82.25,68.88)
  S10 w0.089: 76.63,67.58 76.99,67.94 76.99,68.71 77.19,68.91 78.46,68.91 78.71,69.16 78.71,69.29 78.24,69.76 78.24,69.88 78.54,70.18 78.66,70.18 79.14,69.71 79.26,69.71 79.63,70.08 80.35,70.08 80.53,70.26 80.98,70.26 81.07,70.18 81.48,70.18 81.61,70.31 81.92,70.31 82.25,69.98 v4(82.25,68.88)
  S10 w0.152: v2(38.14,65.82) 38.14,65.36 38.4,65.1 40.54,65.1 40.69,65.25 40.69,65.56 40.84,65.71 41.2,65.71 41.35,65.56 41.35,65.25 41.5,65.1 53.04,65.1 53.19,65.25 53.19,65.36 53.34,65.51 53.7,65.51 53.85,65.36 53.85,65.25 54,65.1 54.98,65.1 55.29,65.42 59.17,65.42 59.59,65.83 60.34,65.83 60.49,65.99 60.49,66.27 60.64,66.42 61,66.42 61.15,66.27 61.15,65.99 61.3,65.83 61.78,65.83 61.94,65.99 61.94,67.23 62.09,67.39 62.44,67.39 62.6,67.23 62.6,65.99 62.75,65.83 63.23,65.83 64.53,67.13 66.77,67.13 66.92,67.28 66.92,67.69 67.07,67.84 67.43,67.84 67.58,67.69 67.58,67.28 67.73,67.13 68.21,67.13 68.75,67.66 68.75,68.27 68.87,68.4 69.58,68.4 69.71,68.27 69.71,67.92 69.87,67.77 74.17,67.77 74.36,67.58 76.63,67.58
RP_DDR4_DIMM1_MA11: length 57.7
  TOP w0.178: v2(38.34,73.6) 38.34,73.53 38.9,72.97 40.1,72.97 40.34,73.2 CONN7.120 ; U9.CG35 v4(83.24,75.75)
  S10 w0.152: v4(83.24,75.75) 83.24,75.57 83,75.33 79.1,75.33 78.73,74.96 77.58,73.81 76.73,72.96 60.18,72.96 59.62,73.52 59.22,73.52 56.59,70.89 56.29,70.89 56.13,71.05 56.13,71.51 55.97,71.67 55.33,71.67 55.17,71.51 55.17,71.05 55.01,70.89 54.37,70.89 54.21,71.05 54.21,71.51 54.05,71.67 53.41,71.67 53.25,71.51 53.25,70.73 52.44,69.92 44.44,69.92 44.31,70.06 44.31,70.73 44.14,70.89 42.1,70.89 40.12,72.88 37.92,72.88 37.77,73.03 37.77,73.3 38.06,73.6 v2(38.34,73.6)
RP_DDR4_DIMM1_MA12: length 60.1
  TOP w0.178: U9.CF37 v4(83.74,74.89) ; v2(34.65,73.58) 34.37,73.58 34.24,73.45 CONN7.119
  S10 w0.152: v2(34.65,73.58) 34.44,73.58 34.26,73.41 34.26,71.07 34.44,70.89 40.46,70.89 43.07,68.28 57.57,68.28 61.22,71.93 62.17,71.93 62.33,71.77 62.33,71.19 62.49,71.03 63.13,71.03 63.29,71.19 63.29,71.77 63.45,71.93 67.06,71.93 67.54,71.45 76.73,71.45 79.06,73.78 80.37,73.78 81.07,74.48 83.33,74.48 v4(83.74,74.89)
RP_DDR4_DIMM1_MA13: length 61.2
  TOP w0.178: v2(39.49,61.21) 39.99,61.7 CONN7.158 ; v4(81.76,66.3) U9.CK56
  S8 w0.152: v2(39.49,61.21) 39.29,61.21 38.9,60.81 38.9,60.31 39.08,60.13 40.06,60.13 40.26,60.33 40.26,60.86 40.42,61.02 40.98,61.02 41.22,60.78 41.22,59.61 41.36,59.47 42.11,59.47 42.28,59.63 42.28,60.08 42.43,60.23 43.21,60.23 43.36,60.08 43.36,59.63 43.52,59.48 44.16,59.48 44.32,59.63 44.32,60.08 44.48,60.23 45.12,60.23 45.28,60.08 45.28,59.63 45.43,59.48 46.08,59.48 46.23,59.63 46.23,60.08 46.39,60.23 64.87,60.23 65.03,60.08 65.03,59.79 65.18,59.64 65.53,59.64 65.69,59.79 65.69,60.08 65.84,60.23 67.5,60.23 67.65,60.39 67.65,60.78 67.81,60.94 68.45,60.94 68.61,60.78 68.61,60.39 68.76,60.23 69.41,60.23 69.56,60.39 69.56,60.78 69.72,60.94 70.36,60.94 70.52,60.78 70.52,60.39 70.68,60.23 71.91,60.23 72.06,60.39 72.06,60.58 72.21,60.73 72.57,60.73 72.72,60.58 72.72,60.39 72.87,60.23 73.23,60.23 73.38,60.39 73.38,60.58 73.53,60.73 73.89,60.73 74.04,60.58 74.04,60.39 74.19,60.23 77.31,60.23 78.58,61.51 79.53,61.51 80.23,62.2 81,62.2 81.15,62.05 81.43,62.05 81.79,62.41 81.79,62.74 82.19,63.14 82.19,64.85 81.76,65.28 v4(81.76,66.3)
RP_DDR4_DIMM1_MA14: length 60.6
  TOP w0.178: v2(35.05,63.51) 34.99,63.45 CONN7.151 ; U9.CM52 v4(80.77,68.02)
  S10 w0.152: v2(35.05,63.51) 34.73,63.83 33.63,63.83 33.33,63.53 33.33,61.5 33.21,61.39 32.51,61.39 32.37,61.53 32.37,64.34 32.5,64.46 36.27,64.46 36.61,64.12 55.39,64.12 55.7,64.44 59.58,64.44 60,64.86 63.64,64.86 64.93,66.15 77.11,66.15 77.93,66.98 78.79,66.98 79.88,68.07 80.72,68.07 v4(80.77,68.02)
RP_DDR4_DIMM1_MA15: length 62
  TOP w0.178: CONN7.156 38.71,62.2 v2(37.71,61.21) ; U9.CJ54 v4(82.25,67.16)
  S10 w0.152: v4(82.25,67.16) 82.6,66.82 82.92,66.82 83.22,66.52 83.22,66.11 82.73,65.61 82.73,65.24 82.5,65.02 80.29,65.02 77.83,62.56 65.62,62.56 63.78,60.72 60.38,60.72 60.23,60.87 60.23,61.29 60.08,61.44 59.72,61.44 59.57,61.29 59.57,60.87 59.42,60.72 59.06,60.72 58.91,60.87 58.91,61.29 58.76,61.44 58.4,61.44 58.25,61.29 58.25,60.87 58.09,60.72 57.74,60.72 57.59,60.87 57.59,61.29 57.43,61.44 57.08,61.44 56.93,61.29 56.93,60.87 56.77,60.72 56.42,60.72 56.27,60.87 56.27,61.29 56.11,61.44 55.76,61.44 55.61,61.29 55.61,60.87 55.45,60.72 53.58,60.72 53.43,60.87 53.43,61.39 53.28,61.54 52.92,61.54 52.77,61.39 52.77,60.87 52.62,60.72 46.24,60.72 46.09,60.87 46.09,61.22 45.93,61.37 45.58,61.37 45.43,61.22 45.43,60.87 45.27,60.72 44.92,60.72 44.77,60.87 44.77,61.22 44.61,61.37 44.26,61.37 44.11,61.22 44.11,60.87 43.95,60.72 38.2,60.72 v2(37.71,61.21)
