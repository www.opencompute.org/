# Allegro board 142000001998AR0A-B-0515.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RP_JTAG_TDI_PCH: length 20.2
  TOP w0.114: U9.BM5 89.44,90.23 88.59,91.07 88.59,91.51 88.82,91.74 88.82,93.01 87.88,93.95 87.88,95.12 85.38,97.62 83.74,97.62 81.67,99.69 78.67,99.69 R116.1
RP_JTAG_TDO_PCH: length 22.4
  TOP w0.102: 90.72,93.37 90.72,91.78 90.35,91.41 90.35,90.8
  TOP w0.114: 90.72,93.37 90.91,93.55 90.91,94.51 85.66,99.76 84.37,99.76 81.53,102.6 81.53,104.14 81.13,104.54 R88.2 80.62,106.43 v2(80.29,106.43) ; U9.BK3 90.35,90.8
  BOTTOM w0.114: v2(80.29,106.43) 80.86,106.99 v1(81.13,106.99)
RP_JTAG_TMS_PCH: length 15.3
  TOP w0.102: 91.41,93.24 91.14,92.96 91.14,91.43 U9.BJ2
  TOP w0.114: R106.1 83.87,102.55 v2(83.95,102.48) 83.95,102.15 91.41,94.69 91.41,93.24
RP_LAN_MDIO_DIR_CTL_0: length 9.9
  TOP w0.114: U9.E75 111.11,57.47 v4(111.51,57.07) ; R232.1 v2(116.08,56.64)
  S8 w0.102: v4(111.51,57.07) 115.65,57.07 v2(116.08,56.64)
  BOTTOM w0.114: v1(115.44,57.28) 115.53,57.28 116.08,56.73 v2(116.08,56.64) R597.1
RP_LAN_MDIO_DIR_CTL_1: length 22.6
  TOP w0.114: U9.N72 v4(107.51,60.02) ; R296.1 v2(111.15,42.95)
  S10 w0.102: v4(107.51,60.02) 107.59,59.94 107.59,59.03 108.15,58.47 108.15,57.94 110.67,55.42 110.67,43.43 v2(111.15,42.95)
  BOTTOM w0.114: v2(111.15,42.95) R296.1 110.77,42.24 v1(110.01,41.48)
RP_LAN_NCSI_ARB_OUT: length 11.5
  TOP w0.114: U9.AB78 103.31,55.82 103.64,55.5 103.64,53.54 103.91,53.27 103.91,50.23 103.82,50.14 103.82,49.47 104.11,49.17 v2(104.37,49.17) 104.47,49.08 R251.1 R245.1
  BOTTOM w0.114: v1(105.96,50.87) 105.94,50.85 105.59,50.85 104.98,50.24 104.98,49.78 v2(104.37,49.17)
RP_LAN_NCSI_TX0: length 6.1
  TOP w0.114: v3(104.27,54.58) 104.44,54.58 104.72,54.86 104.72,56.5 U9.W77
  BOTTOM w0.114: v1(106.38,56.03) 105.84,56.57 R596.1 105.21,55.4 104.39,54.58 v3(104.27,54.58)
RP_LAN_NCSI_TX1: length 2.9
  TOP w0.114: U9.Y78 v3(104.29,55.22)
  BOTTOM w0.114: v1(103.38,55.12) 104.19,55.12 v3(104.29,55.22) 104.27,55.24 R595.1
RP_LAN_NCSI_TX_EN: length 6
  TOP w0.114: v4(102.78,58.31) 102.78,58.07 103.31,57.55 U9.AA75
  BOTTOM w0.114: v4(102.78,58.31) 102.29,57.81 102.29,55.74 v1(102.26,55.72) 102.98,55.72 103.33,56.06 R594.1
RP_LAN_XTAL_I: length 12.6
  TOP w0.114: R207.1 120.04,64.57 119.68,64.92 119.23,64.92 118.54,65.61 R205.1 118.11,66.19 114.48,66.19 113.96,65.67 113,65.67 112.85,65.82 112.56,65.82 112.55,65.81 112.36,65.62 112.06,65.62 111.86,65.82 111.57,65.82 111.36,65.61 111.08,65.61 110.84,65.85 110.84,65.88 110.63,66.09 110.14,66.09 109.78,65.73 U9.J58
RP_LAN_XTAL_O: length 15.6
  TOP w0.114: C108.1 122.35,63.77 OSC5.3 121.11,63.42 118.82,63.42 118.52,63.73 R207.2 117.83,63.5 115.47,63.5 113.66,65.3 113.26,65.3 113.06,65.1 112.58,65.1 112.35,65.33 112.07,65.33 111.86,65.12 111.57,65.12 111.34,65.35 110.86,65.35 U9.F58
RP_LAN_XTAL_R_I: length 10.2
  TOP w0.114: v2(126.73,67) 125.63,65.89 C103.1 124.96,65.82 OSC5.1 124.03,66.19 122.65,67.57 121.31,67.57 120.07,66.33 R205.2
RP_LPC_LAD0: length 379.7
  TOP w0.114: v2(118.14,98.4) 118.14,99.44 116.2,101.37 114.05,101.37 113.42,102 110.68,102 108.47,104.21 108.47,105.26 107.08,106.65 102.62,106.65 102.21,106.23 102.21,98.56 v2(101.42,97.76) R138.1 ; U12.D2 189.15,58.67 188.17,58.67 186.06,60.78 v2(182.3,60.78)
  TOP w0.127: U17.26 v2(179.2,22.49)
  S3 w0.102: v2(201.19,8.33) 200.43,9.09 183.25,9.09 175.9,16.45 175.9,19.18 v2(179.2,22.49)
  S5 w0.102: v2(101.42,97.76) 101.42,99.69 101.98,100.25 101.98,106.32 103.78,108.12 103.78,109.22 103.07,109.93 103.07,116.36 98.04,121.39 84.7,121.39 84.48,121.16 84.46,121.16 34.77,121.16 34.44,120.83 28.73,120.83 28.69,120.8 24.38,120.8 23.75,120.17 16.94,120.17 16.75,120.17 11.15,114.56 11.15,79.62 11.42,79.35 15.08,75.68 v2(15.08,74.78)
  S10 w0.102: v2(179.2,22.49) 179.2,24.52 181.97,27.29 181.97,60.45 v2(182.3,60.78) 182.55,61.04 182.55,75.82 165.89,92.48 165.89,93.48 164.96,94.41 162.69,94.41 158.3,98.81 153.21,98.81 142.75,109.27 132.71,109.27 130.5,107.06 122.85,107.06 118.92,103.13 118.92,99.19 v2(118.14,98.4)
  BOTTOM w0.114: CONN15.7 201.23,8.37 v2(201.19,8.33) v1(201.19,6.5) ; CONN14.14 v2(15.08,74.78)
RP_LPC_LAD1: length 384.5
  TOP w0.114: v2(182.08,61.49) 185.9,61.49 188.29,59.11 U12.D1 ; v2(119.15,98.73) 119.15,98.76 116.3,101.61 114.15,101.61 113.51,102.25 110.77,102.25 108.71,104.31 108.71,105.36 107.18,106.89 102.52,106.89 101.97,106.33 101.97,98.99 101.25,98.27 100.99,98.27 v2(100.48,97.76) R137.1
  TOP w0.127: U17.23 178.4,20.54 178.87,20.07 v2(179.07,20.07)
  S3 w0.102: v2(201.24,9.37) 200.61,10.01 198.44,10.01 198.26,9.83 184.37,9.83 178.49,15.71 178.49,19.74 178.82,20.07 v2(179.07,20.07)
  S5 w0.102: v2(11.89,74.18) 11.44,73.72 11.44,72.79 12.3,71.92 15.54,71.92 15.8,72.19 15.8,75.29 11.51,79.58 11.51,79.58 11.38,79.71 11.38,114.47 16.85,119.94 23.84,119.94 24.47,120.57 28.79,120.57 28.82,120.6 40.93,120.6 41.26,120.93 84.57,120.93 84.8,121.16 97.95,121.16 102.84,116.26 102.84,109.83 103.56,109.12 103.56,108.22 101.75,106.41 101.75,100.36 100.48,99.08 v2(100.48,97.76)
  S10 w0.102: v2(119.15,98.73) 119.15,103.04 122.87,106.76 132.98,106.76 134.99,108.76 139.48,108.76 142.82,105.41 142.82,104.4 145.92,101.3 145.92,100.2 146.35,99.77 150.55,99.77 156.54,93.78 163.54,93.78 182.32,74.99 182.32,61.73 v2(182.08,61.49) 181.71,61.13 181.71,27.36 178.74,24.39 178.74,20.27 178.94,20.07 v2(179.07,20.07)
  BOTTOM w0.114: CONN14.16 v2(11.89,74.18) ; v1(199.62,8.38) 200.26,8.38 v2(201.24,9.37) CONN15.6
RP_LPC_LAD2: length 377.9
  TOP w0.114: v2(116.97,98.42) 116.1,99.29 112.47,99.29 111.24,100.51 109.08,100.51 107.21,98.65 106.28,98.65 105.66,98.02 103.32,98.02 v2(102.9,98.45) ; v2(182.42,59.87) 186.51,59.87 188.27,58.11 U12.E1
  TOP w0.127: U17.20 178.6,18.58 179.07,19.05 v2(179.07,19.3)
  S3 w0.102: v2(201.24,10.79) 183.72,10.79 178.71,15.8 178.71,18.69 179.07,19.05 v2(179.07,19.3)
  S5 w0.102: v2(102.9,98.45) 103.97,98.45 104.44,98.92 104.44,112.4 103.53,113.32 103.53,116.54 98.23,121.84 34.81,121.84 34.25,121.28 28.54,121.28 28.5,121.25 24.19,121.25 23.56,120.62 16.56,120.62 10.69,114.75 10.69,78.33 11.78,77.24 11.88,77.24 14.2,74.92 14.2,74.46 v2(15.08,73.58)
  S10 w0.102: v2(116.97,98.42) 115.62,99.77 115.62,107.58 116.98,108.94 130.86,108.94 132.26,110.34 143.41,110.34 146.81,106.93 152.15,106.93 153.24,105.84 158.96,105.84 168.53,96.28 168.53,90.35 182.78,76.1 182.78,60.22 v2(182.42,59.87) 182.42,26.05 181.13,24.76 181.13,20.52 179.92,19.3 v2(179.07,19.3)
  BOTTOM w0.114: CONN14.18 v2(15.08,73.58) ; v1(199.77,9.91) 200.66,10.79 v2(201.24,10.79) 201.24,10.74 201.62,10.37 CONN15.5 ; R506.1 99.47,97.16 99.64,97.16 100.02,97.53 100.02,97.96 100.51,98.45 v2(102.9,98.45)
RP_LPC_LAD3: length 384.3
  TOP w0.114: R139.1 v2(102.36,97.79) 103.25,97.79 103.26,97.78 105.87,97.78 106.1,98.01 108.29,98.01 108.69,97.61 108.69,95.71 109.08,95.32 113.21,95.32 116.03,98.14 v2(116.03,98.7) ; v2(183.01,59.21) 186.64,59.21 188.17,57.67 189.15,57.67 U12.E2
  TOP w0.127: U17.17 v2(176.35,16.63)
  S3 w0.102: v2(176.35,16.63) 183.44,9.55 v2(198.63,9.55)
  S5 w0.102: v2(11.89,72.98) 15.13,72.98 15.54,73.39 15.54,73.77 15.12,74.19 15.02,74.19 14.43,74.79 14.43,76.02 10.92,79.52 10.92,114.66 16.66,120.4 17.04,120.4 23.65,120.4 24.28,121.03 28.6,121.03 28.63,121.06 34.34,121.06 34.67,121.39 64.63,121.39 64.64,121.4 64.65,121.41 64.86,121.62 98.14,121.62 103.3,116.45 103.3,110.02 104.01,109.31 104.01,108.03 102.21,106.22 102.21,100.13 102.03,99.95 102.03,98.11 v2(102.36,97.79)
  S10 w0.102: v2(176.35,16.63) 176.53,16.46 179.62,16.46 183.01,19.85 v2(183.01,59.21) 183.01,76.46 168.8,90.67 168.8,96.33 158.86,106.27 153.44,106.27 152.27,107.44 149.43,107.44 146.3,110.57 131.9,110.57 130.58,109.24 116.96,109.24 115.39,107.68 115.39,99.34 v2(116.03,98.7)
  BOTTOM w0.114: CONN14.20 v2(11.89,72.98) ; CONN15.4 199.35,11.37 v1(199.31,11.4) 198.63,10.72 v2(198.63,9.55)
RP_LPC_LCLK: length 4.2
  TOP w0.109: v4(103.56,89.18) 103.32,89.18 U9.AC7
  BOTTOM w0.114: v1(106.6,90.22) 104.63,90.22 R522.1 104.11,89.86 103.56,89.31 v4(103.56,89.18)
RP_LPC_R_LAD0: length 9.3
  TOP w0.114: R138.2 v2(101.42,95.32) 100.97,94.87 100.97,91.74 101.32,91.39 U9.AF3
  BOTTOM w0.114: v2(101.42,95.32) 101.49,95.32 102.18,96.01 102.18,96.39 103.58,97.79 v1(103.78,97.79)
RP_LPC_R_LAD1: length 7.7
  TOP w0.114: U9.AG4 100.68,90.36 100.68,90.86 100.46,91.08 100.46,91.51 100.66,91.71 100.66,95.33 v2(100.69,95.35) 100.48,95.56 R137.2
  BOTTOM w0.114: v2(100.69,95.35) 101.52,96.19 v1(101.52,96.52)
RP_LPC_R_LAD2: length 7.4
  TOP w0.114: v2(98.48,94.34) 99.26,93.55 99.26,92.41 98.99,92.13 98.99,91.74 99.21,91.52 99.21,90.84 U9.AL3
  BOTTOM w0.114: v2(98.48,94.34) 98.42,94.39 98.42,95.2 R506.2 100.13,96.07 v1(100.28,96.22)
RP_LPC_R_LAD3: length 5.7
  TOP w0.114: R139.2 v2(102.36,95.32) 101.22,94.18 101.22,92.4 101.32,92.31 U9.AF1
  BOTTOM w0.114: v1(102.95,96.16) 102.95,95.91 v2(102.36,95.32)
RP_LPC_R_LCLK: length 2.7
  TOP w0.108: U9.AA9 103.81,88.31 v4(104.05,88.31)
  BOTTOM w0.114: v1(105.46,88.54) 105.05,88.95 R522.2 104.27,88.54 v4(104.05,88.31)
RP_MS_INT1_R_L: length 30.8
  TOP w0.114: R13.1 v2(87.96,115.26) ; v4(91.66,88.63) 91.45,88.63 U9.BH7
  S10 w0.102: v4(91.66,88.63) 91.29,89 91.29,96.54 89.1,98.72 89.1,101.88 89.36,102.13 89.36,102.67 89.26,102.77 89.26,109.49 89.23,109.51 89.23,113.99 v2(87.96,115.26)
  BOTTOM w0.114: v1(88.7,115.91) 88.61,115.91 v2(87.96,115.26)
RP_PROCHOT_L: length 17.9
  TOP w0.108: U9.AG71 v4(100.58,60.01)
  TOP w0.114: R265.1 v2(103.31,46.12)
  S8 w0.102: v2(103.31,46.12) 102.69,46.74 102.69,47.45 101.73,48.41 101.73,53.01 102.08,53.37 102.08,56.01 101.47,56.62 101.47,59.44 100.9,60.01 v4(100.58,60.01)
  BOTTOM w0.114: v1(103.31,45.09) v2(103.31,46.12)
RP_PWR_ADDR_POT: length 4.1
  TOP w0.114: C255.2 77.25,4.95 v2(77.06,5.13) 76.76,5.13 76.41,5.48 U28.18
  BOTTOM w0.114: v2(77.06,5.13) 77.25,4.95 C255.2 v1(78.23,4.41)
RP_REFCLK14IN: length 6.5
  TOP w0.108: U9.W9 104.17,87.68 103.76,87.68 v4(103.56,87.48)
  BOTTOM w0.114: R519.1 103.07,89.79 103.07,89 103.56,88.52 v4(103.56,87.48) 104.42,87.48 104.7,87.2 v1(105.92,87.2)
RP_RSMRST_CPU_R_L: length 13.1
  TOP w0.102: U9.R77 106.76,56.74 106.62,56.88 106.62,57.18 106.4,57.4 106.12,57.4 105.93,57.21 105.93,56.91 106.12,56.72 106.12,56.34 105.98,56.2 105.98,55.65 106.48,55.16
  TOP w0.114: 106.48,55.16 106.48,53.08 106.91,52.64 106.91,49.64 v2(106.45,49.17) 106.96,48.67 R253.1
  BOTTOM w0.114: v2(106.45,49.17) 107.52,48.11 v1(107.87,48.11)
RP_RTC_X1: length 16.8
  TOP w0.114: U9.AT2 96.93,91.28 96.93,92.84 97.19,93.1 97.19,93.56 97.07,93.68 97.07,94.38 97.11,94.42 97.11,94.95 97.33,95.17 97.33,99.37 X1.1 96.88,100.68 96.34,101.22 C39.1 96.55,101.68 96.88,102.01 96.88,103.15 R100.2 96.85,103.76 v2(97.76,104.67)
  BOTTOM w0.114: v1(97.87,103.68) 97.76,103.78 v2(97.76,104.67)
RP_RTC_X2: length 7.3
  TOP w0.114: R146.1 96.65,96.65 v2(96.27,96.27) 96.67,95.87 96.67,91.54 96.51,91.39 96.51,91.07 96.86,90.72 U9.AT4
RP_RTC_X2_R: length 8.7
  TOP w0.114: R146.2 96.17,97.86 v2(95.76,98.27) 95.73,98.27 94.38,99.62 X1.2 94.38,101.16 C38.1 94.71,101.68 94.27,102.12 94.27,103.29 R100.1
  BOTTOM w0.114: v2(95.76,98.27) 95.63,98.4 v1(95.63,99.06)
RP_SPI_IO2: length 2.1
  TOP w0.114: v4(92.63,83.5) 92.37,83.76 U9.BF18
  BOTTOM w0.114: TP21.1 92.61,84.94 92.61,83.52 v4(92.63,83.5)
RP_SPI_IO3: length 4.6
  TOP w0.114: v4(93.24,82.66) 92.89,82.66 U9.BE20
  BOTTOM w0.114: v4(93.24,82.66) 93.24,82.88 93.03,83.08 93.03,83.41 93.34,83.72 93.93,83.72 94.2,84 94.5,84 94.73,84.22 94.73,84.76 TP22.1
RP_SPI_LAN_HOLD: length 6.5
  TOP w0.114: R235.1 v2(122.79,53.54) 122.79,53.13 124.54,51.38 U16.7
RP_SPI_LAN_WP: length 6.4
  TOP w0.114: U16.3 v2(120.93,50.11) 120.93,50.8 122.07,51.94 122.07,53.49 121.87,53.69 R234.1
RP_SSD_LED_A: length 110.9
  S5 w0.102: v2(207.21,104.79) 207.81,104.2 207.81,45.2 204.85,42.24 204.85,39.78 206.07,38.56 206.07,27.38 203.28,24.59 195.78,24.59 v2(195.53,24.33)
  BOTTOM w0.114: R716.2 187.37,14.42 188.01,15.06 188.01,16.64 189.15,17.78 v1(189.71,17.78) 190.25,18.31 190.25,19.33 190.33,19.33 190.45,19.44 190.45,21.39 193.4,24.33 v2(195.53,24.33) ; CONN13.10 205.05,105.48 v1(205.74,104.79) v2(207.21,104.79)
RP_SSD_LED_C: length 2.4
  TOP w0.114: LED15.C v2(187.04,16.51)
  BOTTOM w0.114: v2(187.04,16.51) LED15.C
RP_STBY_1.05V_R: length 4
  TOP w0.114: CONN11.44 v2(35.39,11.14)
  BOTTOM w0.114: v2(35.39,11.14) R725.2 34.44,12.07 C613.2
RP_STBY_R_1.05V: length 11.5
  TOP w0.114: CONN11.43 35.39,2.22 v2(35.26,2.08)
  S10 w0.102: v2(40.34,2.08) 39.73,2.69 35.86,2.69 v2(35.26,2.08)
  BOTTOM w0.114: v1(41.3,4.9) 41.3,3.81 C638.2 41.28,2.97 R765.1 v2(40.34,2.08)
RP_SVID_R_ALERT: length 21.6
  TOP w0.108: U9.AK72 99.38,58.86 v4(99.09,59.15)
  TOP w0.114: R286.2 v2(98.8,43.18)
  S10 w0.102: v2(98.8,43.18) 97.94,44.04 97.94,51.66 98.2,51.92 98.2,52.63 97.69,53.14 97.69,56.52 99.21,58.04 99.21,59.03 v4(99.09,59.15)
  BOTTOM w0.114: v1(96.52,44.83) 97.16,44.2 97.79,44.2 v2(98.8,43.18)
RP_SVID_R_CLK: length 23.5
  TOP w0.108: U9.AH72 100.37,58.86 v4(100.08,59.15)
  S8 w0.102: v2(102.21,43) 101.47,42.27 99.67,42.27 99.26,42.67 99.26,54.1 99.62,54.46 99.62,55.96 99.44,56.13 99.44,58.51 v4(100.08,59.15)
  BOTTOM w0.114: v1(103.25,41.2) 103.14,41.31 R634.2 103.14,42.53 102.67,43 v2(102.21,43)
RP_SVID_R_DATA: length 24.1
  TOP w0.108: v4(99.59,60.01) 99.96,60.01 100.08,59.88 U9.AJ71
  TOP w0.114: R304.2 v2(98.8,40.08)
  S10 w0.102: v4(99.59,60.01) 99.69,59.9 99.69,58.95 100.23,58.42 100.23,58.06 98.25,56.08 98.25,53.26 99.26,52.25 99.26,40.54 v2(98.8,40.08)
  BOTTOM w0.114: v1(97.86,40.02) 97.92,40.08 v2(98.8,40.08)
RP_TACH6: length 41.5
  TOP w0.114: R11.1 v2(79.6,115.32) ; v4(95.94,86) 96.34,85.59 U9.AU14
  S5 w0.102: v2(79.6,115.32) 80.54,115.32 81,114.86 82.66,114.86 84.96,112.56 84.96,107.21 85.75,106.43 85.75,105.04 86.85,103.94 86.85,100.32 92.08,95.09 92.08,92.38 94.49,89.97 95.05,89.97 95.31,89.7 95.31,88.75 96.1,87.97 96.1,87.13 95.94,86.97 v4(95.94,86)
  BOTTOM w0.114: v2(79.6,115.32) 79.6,115.8 v1(78.87,116.54)
RP_TACH7: length 23.2
  TOP w0.114: U9.AM2 98.84,90.71 98.48,90.35 98.48,90.09 98.84,89.73 v3(98.84,89.46) ; R89.1 95.12,105.87 v2(95.45,106.2)
  S10 w0.102: v3(98.84,89.46) 99.52,90.13 99.52,96.7 100,97.18 100,101.65 v2(95.45,106.2)
  BOTTOM w0.114: v2(95.45,106.2) 96.06,105.59 v1(96.06,105.36)
RP_USB_RBIAS: length 4.1
  TOP w0.114: U9.AG11 100.8,87.47 v4(100.59,87.47) 100.35,87.47 U9.AJ11
  BOTTOM w0.114: v4(100.59,87.47) 100.08,87.98 100.08,89.56 R515.1
RP_XTAL_I: length 20.6
  TOP w0.114: U9.K2 108.74,92.16 109.42,92.84 115.72,92.84 117.32,94.44 R148.2 v2(119.28,95.61) 119.81,96.14 121.84,96.14 122.81,95.17 122.81,94.75 OSC2.1 125.03,94.37 C51.1
RP_XTAL_O: length 13.4
  TOP w0.114: R154.1 119.3,92.89 R148.1 116.38,92.91 115.8,92.33 113.26,92.33 v2(113.03,92.1) 112.78,92.35 109.64,92.35 U9.J1
  BOTTOM w0.114: v1(112.09,91.85) 112.78,91.85 v2(113.03,92.1)
RP_XTAL_R_O: length 5.1
  TOP w0.114: OSC2.3 120.83,92.54 R154.2 120.92,91.16 C52.1 122.23,91.79 v2(122.17,91.85)
  BOTTOM w0.114: v2(122.17,91.85) 122.91,92.59 v1(123.19,92.59)
RST_BTN_IN_BMC_N: length 254.5
  S5 w0.102: v2(123.65,2.55) 124.06,2.14 125.5,2.14 126.31,2.96 127.65,2.96 128.14,2.47 147.13,2.47 147.48,2.83 147.57,2.92 159.57,2.92 162.15,5.49 163.81,5.49 167.09,8.78 170.49,8.78 174.6,12.88 178.34,12.88 180.14,14.68 180.14,20.42 180.92,21.21 180.92,23.78 188.11,30.96 192.82,30.96 200.05,38.19 200.05,38.53 204.44,42.93 204.44,43.54 204.8,43.89 204.8,45.65 204.77,45.68 v3(204.77,50.44)
  S8 w0.102: v2(123.65,2.55) 123.85,2.36 123.85,1.85 123.31,1.32 120.13,1.32 120.08,1.37 97.41,1.37 95.57,3.21 95.57,5.73 92.64,8.66 88.44,8.66 86.91,7.12 86.91,3.87 86.34,3.31 v2(86.34,3)
  S10 w0.102: v2(19.93,25.88) 21.83,25.88 23.08,24.64 23.08,15.5 24.11,14.47 31.99,14.47 32.16,14.63 32.92,14.63 33.08,14.47 46.26,14.47 50.17,18.38 53.44,18.38 53.7,18.64 57.95,18.64 58.99,17.6 62.12,17.6 65.13,14.59 65.13,6.81 65.43,6.51 65.43,6.14 65.13,5.84 65.13,5.51 67.64,3.01 70.89,3.01 71.41,2.48 72.29,2.48 73.28,3.48 74.88,3.48 74.93,3.43 82.05,3.43 82.64,4.02 85.12,4.02 86.14,3 v2(86.34,3)
  BOTTOM w0.114: R909.2 202.97,50.9 v1(203.58,50.29) 204.62,50.29 v3(204.77,50.44) ; CONN14.169 20.12,25.88 20.12,25.88 v2(19.93,25.88)
RST_BTN_IN_BMC_N_R: length 3.4
  TOP w0.114: U12.J13 v3(201.09,53.61)
  BOTTOM w0.114: R909.1 202.97,52.79 202.64,53.13 201.57,53.13 v3(201.09,53.61)
RST_BTN_OUT_BMC_N: length 35.5
  TOP w0.114: R329.2 v2(11.06,27.12)
  BOTTOM w0.114: v1(19.98,5.53) 19.98,8.08 16.37,11.7 9.66,11.7 9.13,12.23 9.11,12.23 8.29,13.05 8.29,20.07 9.82,21.6 9.82,25.87 v2(11.06,27.12) 11.06,26.99 12.47,25.58 CONN14.170
RSVD_97: length 0.6
  TOP w0.109: v4(96.62,59.99) 96.89,59.72 U9.AR71
RSVD_98: length 1.6
  TOP w0.114: v4(88.19,64.31) 88,64.31 U9.BT62
  BOTTOM w0.114: v1(88.19,65.28) v4(88.19,64.31)
SAFE_MODE_BOOT: length 21.8
  TOP w0.108: U9.AF69 101.78,60.58 102.03,60.83 v4(102.06,60.83)
  S10 w0.102: v4(102.06,60.83) 102.06,59.82 101.7,59.46 101.7,55.83 102.08,55.45 102.08,54.69 102.69,54.08 102.69,52.52 102.62,52.44 102.62,49.49 102.77,49.33 102.77,45.95 101.4,44.58 v2(101.4,43.13)
  BOTTOM w0.114: v2(101.4,43.13) 101.06,42.8 R635.2 101.06,41.43 v1(101.41,41.08)
SATA3_C_RX0_N: length 42
  TOP w0.127: C32.2 v3(103.58,104.57) ; U9.CA33 v4(85.72,76.61)
  S8 w0.089: 91.42,93.09 91.42,93.07 91.41,93.06 91.41,92.02 90.32,90.93 90.32,90.53 89.53,89.74 89.53,89.03 89.31,88.8 89.31,88.47 89.76,88.01 89.76,87.53 89.31,87.07 89.31,86.74 89.76,86.28 89.76,85.83 89.31,85.37 89.31,85.01 89.79,84.53 89.79,84.12 89.31,83.64 89.31,83.31 89.79,82.83 89.79,82.4 89.31,81.92 89.31,81.58 89.79,81.1 89.79,80.7 89.28,80.19 89.28,79.81 88.8,79.32 88.8,78.96 88.42,78.58 87.97,78.58 87.85,78.7 87.54,78.7 87.29,78.45 87.29,78.09 86.79,77.6 86.35,76.87 86.08,76.61 v4(85.72,76.61)
  S8 w0.102: 91.42,93.09 91.42,95.48 101.04,105.11 103.48,105.11 103.58,105 v3(103.58,104.57)
SATA3_C_RX0_P: length 42
  TOP w0.127: C26.2 v3(103.58,105.84) ; U9.BY32 v4(86.21,77.46)
  S8 w0.089: 91.22,93.09 91.22,93.07 91.22,93.06 91.22,92.1 90.13,91.01 90.13,90.6 89.34,89.82 89.34,89.11 89.12,88.88 89.12,88.39 89.57,87.93 89.57,87.61 89.12,87.15 89.12,86.66 89.57,86.2 89.57,85.91 89.12,85.45 89.12,84.93 89.6,84.45 89.6,84.2 89.12,83.72 89.12,83.23 89.6,82.75 89.6,82.48 89.12,81.99 89.12,81.51 89.6,81.02 89.6,80.77 89.09,80.27 89.09,79.89 88.61,79.4 88.61,79.04 88.34,78.77 88.05,78.77 87.93,78.89 87.46,78.89 87.1,78.52 87.1,78.17 86.39,77.46 v4(86.21,77.46)
  S8 w0.102: v3(103.58,105.84) 103.58,105.41 103.48,105.31 100.96,105.31 94.45,98.8 94.34,98.8 94.34,98.8 94.23,98.8 94.08,98.66 94.08,98.55 94.08,98.44 93.94,98.29 93.83,98.29 93.72,98.29 93.58,98.15 93.58,98.04 93.58,97.93 93.43,97.78 93.32,97.78 93.21,97.78 93.07,97.64 93.07,97.53 93.07,97.42 92.92,97.28 92.82,97.28 92.81,97.28 92.7,97.28 92.56,97.13 92.56,97.02 92.56,97.02 92.56,96.91 92.42,96.77 92.31,96.77 92.31,96.77 92.2,96.77 92.05,96.63 92.05,96.52 92.05,96.41 91.91,96.26 91.8,96.26 91.69,96.26 91.55,96.12 91.55,96.01 91.55,95.9 91.22,95.57 91.22,93.09
SATA3_C_RX1_N: length 41.6
  TOP w0.127: U9.BW33 86.36,76.81 v4(86.71,76.61) ; C40.2 v3(103.58,102.03)
  S8 w0.089: v4(86.71,76.61) 87.07,76.61 87.78,77.32 87.78,77.6 87.94,77.75 88.07,77.89 88.31,77.89 88.47,77.74 88.93,77.74 89.29,78.1 89.29,78.47 89.79,78.97 89.79,79.32 90.27,79.81 90.27,80.19 90.78,80.7 90.78,81.1 90.3,81.58 90.3,81.92 90.78,82.4 90.78,82.83 90.3,83.31 90.3,83.64 90.78,84.12 90.78,84.53 90.3,85.01 90.3,85.37 90.75,85.83 90.75,86.28 90.3,86.74 90.3,87.07 90.75,87.53 90.75,88.01 90.3,88.47 90.3,88.8 90.53,89.03 90.53,89.74 91.31,90.53 91.31,90.93 92.25,91.87 92.25,92.93 92.26,92.94 92.26,92.96
  S8 w0.102: 92.26,92.96 92.26,94.26 92.79,94.79 95.76,94.79 97.16,96.19 97.16,99.9 99.82,102.57 103.48,102.57 103.58,102.46 v3(103.58,102.03)
SATA3_C_RX1_P: length 41.6
  TOP w0.127: C37.2 v3(103.58,103.3) ; U9.BV32 v4(87.2,77.46)
  S8 w0.089: 92.06,92.96 92.06,92.94 92.06,92.93 92.06,91.95 91.12,91.01 91.12,90.6 90.34,89.82 90.34,89.11 90.11,88.88 90.11,88.39 90.56,87.93 90.56,87.61 90.11,87.15 90.11,86.66 90.56,86.2 90.56,85.91 90.11,85.45 90.11,84.93 90.59,84.45 90.59,84.2 90.11,83.72 90.11,83.23 90.59,82.75 90.59,82.48 90.11,81.99 90.11,81.51 90.59,81.02 90.59,80.77 90.08,80.27 90.08,79.89 89.6,79.4 89.6,79.05 89.1,78.55 89.1,78.18 88.85,77.93 88.54,77.93 88.39,78.08 88,78.08 87.8,77.88 87.38,77.46 v4(87.2,77.46)
  S8 w0.102: 92.06,92.96 92.06,94.34 92.71,95 93.03,95 93.13,95.1 93.13,95.2 93.23,95.3 93.64,95.3 93.74,95.2 93.74,95.1 93.84,95 94.49,95 94.6,95.1 94.6,95.28 94.7,95.38 95.1,95.38 95.21,95.28 95.21,95.1 95.31,95 95.67,95 96.95,96.27 96.95,99.98 99.74,102.77 103.48,102.77 103.58,102.87 v3(103.58,103.3)
SATA3_C_TX0_N: length 152.3
  TOP w0.127: U9.BV28 v4(87.2,79.18)
  S8 w0.089: 88.54,93.16 88.54,93.14 88.53,93.14 88.53,90.78 87.54,89.79 87.54,89.04 87.31,88.81 87.31,88.47 87.8,87.99 87.8,87.55 87.31,87.07 87.31,86.74 87.8,86.26 87.8,85.82 87.31,85.34 87.31,85.04 87.8,84.56 87.8,84.12 87.31,83.64 87.31,83.31 87.82,82.81 87.82,82.42 87.31,81.91 87.31,81.61 87.82,81.1 87.82,80.71 87.33,80.21 87.2,80.09 v4(87.2,79.18)
  S8 w0.102: 88.54,93.16 88.54,95.9 93.98,101.35 93.98,103.24 95.03,104.29 96.37,104.29 97.24,105.17 99.08,105.17 99.67,105.76 99.67,106.4 99.42,106.65 99.42,107.28 99.88,107.75 105.62,107.75 107.5,109.63 111.44,109.63 112.28,110.46 112.66,110.46 114.88,112.69 114.88,116.81 116.57,118.49 125.61,118.49 128.86,121.74 139.74,121.74 143.91,117.58 160.53,117.58 164.08,114.02 164.08,102.25 180.23,86.11 182.44,86.11 v3(182.91,85.64)
  BOTTOM w0.127: C277.1 v3(182.91,85.64)
SATA3_C_TX0_P: length 152.4
  TOP w0.127: v4(86.71,80.04) 86.36,80.24 U9.BW26
  S8 w0.089: 88.33,93.16 88.33,93.14 88.34,93.14 88.34,90.86 87.35,89.87 87.35,89.12 87.12,88.89 87.12,88.39 87.6,87.91 87.6,87.63 87.12,87.15 87.12,86.66 87.6,86.18 87.6,85.9 87.12,85.42 87.12,84.96 87.6,84.48 87.6,84.2 87.12,83.72 87.12,83.24 87.63,82.73 87.63,82.5 87.12,81.99 87.12,81.53 87.63,81.03 87.63,80.79 86.88,80.04 v4(86.71,80.04)
  S8 w0.102: v3(182.91,86.91) 182.31,86.31 182.05,86.31 181.88,86.49 181.65,86.49 181.47,86.31 181.24,86.31 181.06,86.49 180.83,86.49 180.66,86.31 180.31,86.31 164.29,102.34 164.29,114.1 160.61,117.78 143.99,117.78 139.83,121.95 128.78,121.95 125.53,118.69 116.48,118.69 114.68,116.89 114.68,112.77 112.57,110.67 112.19,110.67 111.35,109.83 107.42,109.83 105.54,107.95 99.8,107.95 99.21,107.37 99.21,106.57 99.47,106.32 99.47,105.84 99,105.37 97.16,105.37 96.28,104.5 94.95,104.5 93.78,103.33 93.78,101.43 88.33,95.99 88.33,93.16
  BOTTOM w0.127: C276.1 v3(182.91,86.91)
SATA3_C_TX1_N: length 191.2
  TOP w0.127: U9.BT28 v4(88.2,79.18)
  S8 w0.089: v4(88.2,79.18) 88.2,80.09 88.32,80.21 88.81,80.71 88.81,81.1 88.3,81.61 88.3,81.91 88.81,82.42 88.81,82.81 88.3,83.31 88.3,83.64 88.79,84.12 88.79,84.56 88.3,85.04 88.3,85.34 88.79,85.82 88.79,86.26 88.3,86.74 88.3,87.07 88.79,87.55 88.79,87.99 88.3,88.47 88.3,88.77 88.56,89.02 88.56,89.81 89.52,90.78 89.52,93.14 89.53,93.14 89.53,93.16
  S8 w0.102: v3(196.19,119.92) 195.66,119.39 195.66,115.72 191.47,111.54 191.47,107.36 185.82,101.71 185.82,92.42 187.46,90.78 187.46,85.4 186.7,84.63 180.66,84.63 161.8,103.5 161.8,110.25 157.14,114.91 144.67,114.91 138.88,120.7 128.99,120.7 123.22,114.93 123.22,111.48 120.75,109.01 116.16,109.01 114.38,107.24 109.43,107.24 109.43,107.24 108.42,107.24 107.78,106.6 101.02,106.6 100.76,106.34 100.76,105.88 98.06,103.17 95.41,103.17 94.82,102.58 94.82,100.89 89.53,95.6 89.53,93.16
  BOTTOM w0.127: C282.1 v3(196.19,119.92)
SATA3_C_TX1_P: length 191.1
  TOP w0.127: U9.BU26 v4(87.7,80.04)
  S8 w0.089: v4(87.7,80.04) 87.87,80.04 88.62,80.79 88.62,81.03 88.11,81.53 88.11,81.99 88.62,82.5 88.62,82.73 88.11,83.24 88.11,83.72 88.6,84.2 88.6,84.48 88.11,84.96 88.11,85.42 88.6,85.9 88.6,86.18 88.11,86.66 88.11,87.15 88.6,87.63 88.6,87.91 88.11,88.39 88.11,88.85 88.37,89.1 88.37,89.89 89.33,90.86 89.33,93.14 89.33,93.14 89.33,93.16
  S8 w0.102: 89.33,93.16 89.33,95.68 89.88,96.24 89.88,96.49 90.03,96.63 90.27,96.63 90.42,96.77 90.42,97.02 90.56,97.16 90.81,97.16 90.95,97.31 90.95,97.55 91.09,97.7 91.34,97.7 91.48,97.84 91.48,98.08 91.62,98.23 91.87,98.23 94.61,100.97 94.61,102.67 95.33,103.38 97.97,103.38 100.56,105.96 100.56,106.43 100.94,106.81 107.7,106.81 108.33,107.44 109.52,107.44 114.3,107.44 116.08,109.22 120.66,109.22 123.01,111.56 123.01,115.01 128.91,120.9 138.96,120.9 144.75,115.11 157.23,115.11 162,110.34 162,103.58 180.75,84.84 186.61,84.84 187.26,85.48 187.26,90.69 185.62,92.34 185.62,101.79 191.27,107.45 191.27,111.63 195.45,115.81 195.45,119.38 v3(194.92,119.92)
  BOTTOM w0.127: C281.1 v3(194.92,119.92)
SATA3_RX0_N: length 129.9
  TOP w0.127: v3(190.31,86.52) 190.82,87.02 190.82,87.56 190.55,87.83 CONN6.25 ; C32.1 v3(106.12,104.57)
  S8 w0.102: v3(106.12,104.57) 106.12,105 106.22,105.11 113.33,105.11 114.76,106.53 120.01,106.53 124.34,110.86 124.34,114.71 129.27,119.63 138.68,119.63 144.67,113.64 155.57,113.64 157.58,111.63 157.58,105.68 160.86,102.4 160.86,98.19 162.98,96.06 168.15,96.06 177.11,87.1 177.11,84.62 178.44,83.29 191.79,83.29 193.45,84.96 193.45,87.49 192.75,88.19 191.2,88.19 190.83,87.82 190.83,87.04 v3(190.31,86.52)
SATA3_RX0_P: length 129.9
  TOP w0.127: C26.1 v3(106.12,105.84) ; v3(191.58,86.52) 191.08,87.02 191.08,87.56 191.35,87.83 CONN6.23
  S8 w0.102: v3(191.58,86.52) 191.03,87.07 191.03,87.73 191.29,87.99 192.67,87.99 193.25,87.41 193.25,86.99 193.15,86.89 192.98,86.89 192.88,86.78 192.88,86.58 192.98,86.48 193.15,86.48 193.25,86.38 193.25,86.17 193.15,86.07 192.98,86.07 192.88,85.97 192.88,85.77 192.98,85.67 193.15,85.67 193.25,85.56 193.25,85.04 191.7,83.5 178.53,83.5 177.32,84.71 177.32,87.18 168.23,96.27 163.07,96.27 161.06,98.27 161.06,102.49 157.78,105.77 157.78,111.72 155.66,113.84 144.75,113.84 138.76,119.84 129.18,119.84 124.14,114.79 124.14,110.95 119.92,106.73 114.67,106.73 113.25,105.31 106.22,105.31 106.12,105.41 v3(106.12,105.84)
SATA3_RX1_N: length 165.5
  TOP w0.127: C40.1 v3(106.12,102.03)
  S8 w0.102: v3(106.12,102.03) 106.12,102.46 106.22,102.57 107.45,102.57 108.95,104.06 118.92,104.06 122.58,107.72 126.44,107.72 127.3,108.58 127.3,116.17 129.88,118.75 137.2,118.75 142.99,112.95 155.22,112.95 156.67,111.51 156.67,105.17 159.89,101.95 159.89,96.97 162.68,94.18 168.77,94.18 176.15,86.81 176.15,83.52 178.44,81.23 193.6,81.23 196.27,83.89 196.27,98.92 194.07,101.11 194.07,111.62 194.18,111.72 194.26,111.72 194.37,111.82 194.37,112.02 194.26,112.12 194.18,112.12 194.07,112.23 194.07,112.62 195.86,114.41 196.55,114.41 196.95,114.01 196.95,113.03 196.85,112.93 v3(196.41,112.93)
  BOTTOM w0.127: v3(196.41,112.93) 196.92,113.43 196.92,114.01 196.8,114.12 CONN13.43
SATA3_RX1_P: length 165.5
  TOP w0.127: C37.1 v3(106.12,103.3)
  S8 w0.102: v3(106.12,103.3) 106.12,102.87 106.22,102.77 107.37,102.77 108.86,104.27 118.84,104.27 122.5,107.92 126.36,107.92 127.1,108.67 127.1,116.26 129.79,118.95 137.29,118.95 143.08,113.16 155.3,113.16 156.87,111.59 156.87,105.26 160.1,102.03 160.1,97.05 162.76,94.39 168.86,94.39 176.35,86.89 176.35,83.6 178.52,81.43 193.52,81.43 196.07,83.98 196.07,98.83 193.87,101.03 193.87,112.71 195.78,114.61 196.63,114.61 197.15,114.09 197.15,113.03 197.25,112.93 v3(197.68,112.93)
  BOTTOM w0.127: CONN13.41 197.3,114.12 197.18,114.01 197.18,113.43 v3(197.68,112.93)
SATA3_TX0_N: length 6.3
  TOP w0.127: CONN6.31 188.15,87.83 187.88,87.56 187.88,86.51 187.51,86.14 185.83,86.14 v3(185.33,85.64)
  BOTTOM w0.127: C277.2 v3(185.33,85.64)
SATA3_TX0_P: length 6.2
  TOP w0.127: v3(185.33,86.91) 185.33,86.62 185.55,86.4 186.14,86.4 186.42,86.69 186.68,86.69 186.96,86.4 187.4,86.4 187.62,86.62 187.62,87.56 187.35,87.83 CONN6.33
  BOTTOM w0.127: C276.2 v3(185.33,86.91)
SATA3_TX1_N: length 3
  BOTTOM w0.127: C282.2 195.68,117.25 195.68,116.09 195.8,115.97 CONN13.47
SATA3_TX1_P: length 3
  BOTTOM w0.127: C281.2 195.42,117.25 195.42,116.09 195.3,115.97 CONN13.49
SF100_IO3: length 95.2
  TOP w0.114: CONN3.8 v2(48.3,114.86)
  S8 w0.102: v2(112.39,114.43) 107.82,114.43 107.62,114.23 107.49,114.09 102.2,114.09 100.6,112.5 99.3,112.5 98.4,113.39 98.4,113.94 97.99,114.35 96.24,114.35 91.74,118.85 86.73,118.85 85.97,118.08 80.77,118.08 79.65,119.2 52.64,119.2 v2(48.3,114.86)
  BOTTOM w0.114: v1(41.65,114.22) 41.94,113.93 47.36,113.93 v2(48.3,114.86) ; Q1.G 114.12,105.61 115.06,106.55 115.06,110.87 114.3,111.63 R934.2 114.61,113.08 114.76,113.24 114.76,114.34 114.35,114.76 112.72,114.76 v2(112.39,114.43)
SMB_10GBE_ALERT: length 23.3
  TOP w0.108: v4(98.1,59.15) 98.1,59.72 U9.AN71
  TOP w0.114: R285.1 v2(96.57,40.69)
  S10 w0.102: v4(98.1,59.15) 98.1,58.7 98.25,58.55 98.25,58.12 95.71,55.58 95.71,45.36 96.34,44.73 96.34,43.94 96.09,43.69 96.09,42.8 96.57,42.32 v2(96.57,40.69)
  BOTTOM w0.114: v1(96.65,42.42) 96.65,40.77 v2(96.57,40.69)
SMB_10GBE_CLK: length 6.5
  TOP w0.114: U9.AM75 98.84,57.05 98.49,56.71 98.49,56.4 98.73,56.17 98.73,55.35 98.35,54.97 98.35,54.23 98.8,53.78 R237.1
SMB_10GBE_DATA: length 11.9
  TOP w0.114: v2(98.8,47.24) R250.1 99.08,48 99.51,48.44 99.51,53.41 99.33,53.59 99.33,53.84 98.65,54.53 98.65,54.91 99.03,55.29 99.03,56.37 U9.AM77
  BOTTOM w0.114: v2(98.8,47.24) 98.48,47.24 v1(97.64,48.08)
SMB_9548_I_SCL: length 3.6
  BOTTOM w0.114: U33.22 R497.2 v1(26.11,99.11)
SMB_9548_I_SDA: length 3.9
  BOTTOM w0.114: R498.2 v1(27.56,98.12) 26.59,98.12 25.76,97.29 U33.23
SMB_9548_SCL0: length 225.4
  S8 w0.102: v2(146.6,3.78) 146.6,3.04 144.91,1.35 128.09,1.35 127.27,2.16 124.84,2.16 123.86,3.14 123.64,3.14 122.27,4.51 119.38,4.51 119.14,4.27 119.14,3.94 118.81,3.61 113.05,3.61 111.43,5.23 111.09,5.23 101.7,5.23 100.2,6.73 97.33,6.73 95.03,9.03 95.03,10.32 94.39,10.96 93.49,10.96 93.14,10.61 88.83,10.61 87.63,10.61 87.03,10.01 85.69,10.01 85.42,9.74 85.42,8.4 84.95,7.93 84.95,5.89 82.24,3.17 78.49,3.17 77.6,2.29 76.14,2.29 75.87,2.55 75.87,2.93 75.37,3.43 69.4,3.43 69,3.02 65.05,3.02 64.85,3.22 64.47,3.22 64.37,3.13 64.16,3.34 58.33,3.34 58.32,3.35 56.41,3.35 55.67,4.09 52.63,4.09 50.83,5.89 50.83,7.09 50.19,7.72 48.43,7.72 46.77,9.38 v2(46.77,10.21) 45.22,11.76 42.37,11.76 38.63,15.49 31.08,15.49 30.36,15.49 26.57,19.29 26.57,19.29 26.31,19.55 25.93,19.92 25.93,48.64 22,52.58 22,82.96 24.43,85.39 24.43,86.09 24.39,86.14 24.39,86.51 24.43,86.56 24.43,86.74 24.18,87 22.58,87 v2(21.64,86.06)
  BOTTOM w0.114: R531.2 21.21,86.48 v2(21.64,86.06) 21.17,85.58 19.12,85.58 18.98,85.72 18.98,85.72 16.97,87.74 R786.2 ; v2(46.77,10.21) 47.77,10.21 v1(47.87,10.31)
  BOTTOM w0.127: CONN16.50 v2(146.6,3.78)
SMB_9548_SCL1: length 227.7
  S5 w0.102: v2(132.99,5.82) 130,5.82 129.3,5.12 126.44,5.12 126.02,5.53 126.02,5.53 124.63,5.53 124.62,5.53 124.55,5.46 124.47,5.38 123.74,5.38 122.25,5.38 120.51,3.64 v2(120.51,2.23)
  S8 w0.102: v2(120.51,2.23) 120.46,2.29 106.79,2.29 106.13,2.95 105.65,2.95 105.03,2.34 102.66,2.34 101.94,3.05 100.7,3.05 100.18,2.53 99.88,2.53 99.23,3.18 97.56,3.18 96.48,4.25 96.48,6.11 93.02,9.57 88.06,9.57 85.99,7.5 85.99,5.8 85.99,5.46 82.1,1.57 81.73,1.19 75,1.19 74.9,1.09 73.79,1.09 73.69,1.19 46.52,1.19 41.15,6.57 41.15,11.42 38.14,14.43 30.48,14.43 30.48,14.43 30.3,14.43 29.96,14.43 26.14,18.24 25.87,18.51 24.89,19.49 24.89,19.49 20.95,23.43 20.95,23.77 20.95,23.77 20.95,35.82 21.23,36.1 21.23,37.51 20.95,37.79 20.95,83.34 18.19,86.11 v2(18.19,88.04)
  BOTTOM w0.114: 19.96,101.77 R493.2 ; 19.96,101.77 17.34,101.77 16.13,100.56 16.13,91.21 16.69,90.65 R791.2 17.12,89.61 18.19,88.54 v2(18.19,88.04) ; 19.96,101.77 v1(19.96,101.78) ; v2(132.99,5.82) 134.66,5.82 134.88,6.04 136.85,6.04 137.1,6.29 CONN16.87
SMB_9548_SDA0: length 226.2
  S5 w0.102: v2(122.18,2.34) 122.27,2.42 122.27,3.51 122.53,3.77 123.76,3.77 124.65,4.66 124.89,4.9 125.76,4.9 126.47,4.19 127.24,4.19 128.26,3.17 145.57,3.17 146.14,3.75 146.14,3.97 146.41,4.24 146.52,4.24 v2(146.74,4.46)
  S8 w0.102: v2(122.18,2.34) 121.4,3.12 112.96,3.12 111.26,4.83 104.95,4.83 104.06,3.94 97.7,3.94 97.12,4.52 97.12,6.37 94.63,8.86 94.63,10.15 94.22,10.55 93.66,10.55 93.31,10.21 87.8,10.21 85.36,7.76 85.36,5.72 81.46,1.83 74.74,1.83 74.63,1.73 74.06,1.73 73.96,1.83 73.32,1.83 73.3,1.85 53,1.85 50.77,4.09 49.24,4.09 48.56,4.76 48.56,4.79 46.79,6.56 46.79,6.72 45.06,8.45 v2(45.06,11.04) 44.87,11.23 42.28,11.23 38.45,15.06 30.22,15.06 26.4,18.88 26.14,19.15 25.53,19.76 25.53,48.47 21.59,52.41 21.59,83.5 v2(23.72,85.64)
  BOTTOM w0.114: v2(45.06,11.04) 45.78,10.33 v1(45.78,9.86) ; R534.2 23.93,85.84 v2(23.72,85.64) 23.15,85.06 19.05,85.06 18.92,85.19 17.27,86.85 R788.2 ; v2(146.74,4.46) 146.74,4.44 147.1,4.08 CONN16.48
SMB_9548_SDA1: length 214.2
  S5 w0.102: v2(134.62,5.18) 134.47,5.33 130.15,5.33 129.44,4.62 126.36,4.62 125.86,5.13 125.85,5.13 124.79,5.13 124.79,5.13 124.64,4.97 122.42,4.97 121.38,3.93 v2(121.38,2.26)
  S8 w0.102: v2(121.38,2.26) 120.74,2.89 112.87,2.89 111.39,4.37 104.82,4.37 104.16,3.71 97.61,3.71 96.89,4.42 96.89,6.28 94.13,9.04 94.13,9.41 94.4,9.68 94.4,10.06 94.13,10.33 93.75,10.33 93.4,9.98 87.9,9.98 85.59,7.67 85.59,5.63 81.56,1.6 74.83,1.6 74.73,1.5 73.96,1.5 73.86,1.6 49.95,1.6 45.9,5.65 45.9,6.11 45.39,6.62 45.39,7.8 44.25,8.94 v2(44.25,10.62) 42.56,10.62 38.35,14.83 30.32,14.83 30.13,14.83 26.31,18.65 26.04,18.92 25.3,19.66 21.36,23.6 21.36,35.65 21.64,35.93 21.64,37.68 21.36,37.95 21.36,83.51 19.36,85.51 v2(19.36,86.15)
  BOTTOM w0.114: CONN16.81 138.6,6.06 138.36,5.82 137.22,5.82 137.02,5.62 135.06,5.62 v2(134.62,5.18) ; v2(44.25,10.62) 44.25,9.67 v1(45.48,8.44) ; R792.2 16.89,88.68 18.44,87.12 R529.2 v2(19.36,86.15)
SMB_CLK_CPLD: length 6.7
  TOP w0.114: R900.2 v2(195.61,64.59) ; U12.C10 v3(198.09,60.61)
  BOTTOM w0.114: v2(195.61,64.59) 195.61,64.57 196.47,63.7 v1(196.49,63.7) 197.54,62.66 197.54,61.16 v3(198.09,60.61)
SMB_DATA_CPLD: length 155.6
  TOP w0.114: U12.C9 v3(197.09,60.61)
  S3 w0.102: v2(83.26,118.54) 84.71,119.99 105.83,119.99 106.54,119.28 107.93,119.28 108.01,119.2 112.39,119.2 113.54,118.06 134.01,118.06 139.34,112.73 155.83,112.73 162.1,106.45 170.19,106.45 175.58,101.06 175.58,94.33 180.67,89.24 185.21,89.24 194.78,79.67 194.78,68.83 197.33,66.27 197.33,61.9 197.47,61.77 197.47,60.99 v3(197.09,60.61)
  BOTTOM w0.114: v1(196.29,60.96) 196.74,60.96 v3(197.09,60.61) ; R488.2 v2(83.26,118.54)
SMB_FRU_PCU_CLK_P3V3: length 18.4
  TOP w0.114: U19.6 v2(184.25,21.62)
  S5 w0.102: v2(198.45,20.95) 198.32,20.95 197.52,20.15 191.08,20.15 189.94,21.29 187.31,21.29 186.98,20.95 184.91,20.95 v2(184.25,21.62)
  BOTTOM w0.114: v2(198.45,20.95) 198.45,19.96 R650.2
SMB_FRU_PCU_DATA_P3V3: length 30.9
  TOP w0.114: U19.5 v2(181.61,22.89)
  S5 w0.102: v2(206.35,22.4) 195.86,22.4 193.62,24.64 183.36,24.64 v2(181.61,22.89)
  BOTTOM w0.114: v2(206.35,22.4) 207.14,21.62 R671.2
SMB_LM75BD_CLK_P3V3: length 152.5
  TOP w0.114: v2(138.18,107.95) 138.62,107.5 139.15,107.5 140.21,108.56 140.21,111.25 139.83,111.63 R297.2
  S8 w0.102: v2(138.18,107.95) 137.41,107.95 135.13,105.66 135.13,104.27 133.43,102.57 133.43,80.77 135.69,78.51 139.7,78.51 140.36,77.85 140.36,69.06 139.98,68.67 139.98,63.16 141.35,61.79 v2(141.35,61.47)
  BOTTOM w0.114: v2(141.35,61.47) 141.73,61.09 142.28,61.09 143.54,59.83 144.93,59.83 147.47,57.29 158.78,57.29 159.68,56.39 167.68,56.39 168.97,55.09 168.97,50.85 170.75,49.07 170.75,48.03 171.17,47.61 178.06,47.61 178.84,46.83 178.84,43.36 182.6,39.6 187.3,39.6 189.13,37.77 189.13,33.95 194.44,28.64 196.58,28.64 201.04,24.18 R674.1 R666.2 ; v2(138.18,107.95) 138.1,108.03 v1(138.1,108.89)
SMB_LM75BD_DATA_P3V3: length 153.1
  TOP w0.114: v2(137.67,107.44) 138.3,107.44 138.48,107.26 139.25,107.26 140.45,108.46 140.45,111.77 139.32,112.9 U20.1
  S8 w0.102: v2(137.67,107.44) 137.23,107.44 135.36,105.57 135.36,104.17 133.65,102.47 133.65,80.87 135.78,78.74 139.83,78.74 140.59,77.98 140.59,68.96 140.21,68.58 140.21,63.26 141.87,61.59 v2(142.11,61.59)
  BOTTOM w0.114: v1(136.83,107.08) 137.2,107.44 v2(137.67,107.44) ; R668.1 R669.2 205.1,20.46 196.68,28.88 194.54,28.88 189.37,34.05 189.37,37.87 187.4,39.84 182.7,39.84 179.08,43.46 179.08,46.93 178.16,47.85 171.27,47.85 170.99,48.13 170.99,49.17 169.21,50.95 169.21,55.19 167.77,56.64 159.77,56.64 158.88,57.53 147.57,57.53 145.03,60.07 143.64,60.07 v2(142.11,61.59)
SMB_LVC3_ALERT: length 169.7
  TOP w0.114: R13.2 v2(85.54,115.26)
  S3 w0.102: v2(193.98,44.22) 193.72,44.49 193.72,45.13 194.23,45.64 194.23,47.06 194.56,47.4 194.56,66 193.67,66.89 v2(193.67,67.36) 193.5,67.53 193.5,72.23 173.74,91.99 173.74,100.5 169.08,105.16 154.17,105.16 150.94,108.38 149.71,108.38 148.19,109.91 132.72,109.91 131.75,108.94 122.61,108.94 120.4,106.73 116.09,106.73 114.66,108.17 114.66,109.96 113.52,111.1 108.53,111.1 102.74,116.89 98.35,116.89 97.92,116.46 94.97,116.46 93.37,118.06 90.78,118.06 89.25,116.53 86.82,116.53 v2(85.54,115.26)
  BOTTOM w0.114: R13.2 v2(85.54,115.26) ; R230.2 194.28,66.75 v2(193.67,67.36) ; v1(193.93,43.31) 193.93,44.17 v2(193.98,44.22)
SMB_LVC3_ALERT_R: length 6.9
  TOP w0.114: U12.D8 v3(195.09,59.61)
  BOTTOM w0.114: v3(195.09,59.61) 194.61,60.08 194.61,62.79 194.44,62.97 v1(194.44,63.88) 194.28,64.03 R230.1
SMB_PCU_CLK_P3V3: length 459.8
  TOP w0.114: v2(198.04,23.16) 198.04,25.43 193.19,30.28 189.46,30.28 187.3,32.44 187.3,38.23 186.18,39.35 186.18,41.63 185.2,42.61 178.2,42.61 175.01,39.42 v2(175.01,38.2) ; v2(195.2,67.35) 195.61,66.94 R900.1
  S3 w0.102: v2(50.8,17.22) 51.05,17.22 54.53,20.7 56.01,20.7 56.9,21.59 60.71,21.59 61.7,20.6 65.93,20.6 66.28,20.95 67.26,20.95 68.68,22.38 69.19,22.38 69.29,22.48 72.37,22.48 72.47,22.38 77.86,22.38 78.87,21.36 83.23,21.36 83.64,21.77 87.05,21.77 87.6,22.32 88.51,22.32 89.08,21.74 89.74,21.74 90.12,22.12 94,22.12 99.69,27.82 99.69,31.11 101.65,33.07 121.56,33.07 v2(122.8,31.84) ; v2(188.85,82.42) 188.85,81.58 194.14,76.29 194.14,69.09 194.14,68.41 v2(195.2,67.35) 195.61,66.94 195.61,66.4 195.71,66.3 195.71,65.67 196.22,65.16 196.22,63.08 196.32,62.98 196.32,46.78 195.13,45.59 194.82,45.59 194.49,45.26 194.49,44.15 194.97,43.66 194.97,42.06 195.62,41.41 195.62,26.85 198.04,24.43 v2(198.04,23.16)
  S5 w0.102: v2(17.12,116.46) 16.54,115.88 16.54,115.62 16.54,115.3 16.72,115.12 16.72,114.11 16.54,113.92 16.54,108.48 21.23,103.78 22.17,103.78 v2(25.93,100.02)
  S8 w0.102: v2(175.01,38.2) 173.76,36.96 173.2,36.96 172.95,37.21 171.6,37.21 170.79,36.4 164.8,36.4 159.21,30.81 135.79,30.81 132.72,33.88 124.66,33.88 122.8,32.02 v2(122.8,31.84)
  S10 w0.102: v2(17.12,116.46) 16.51,115.85 16.51,115.33 16.72,115.12 16.72,114.11 16.51,113.89 16.51,103.06 18.28,101.3 19.22,101.3 19.49,101.03 19.49,99.99 30.71,88.76 30.71,81.27 30.89,81.09 30.89,80.71 30.71,80.53 30.71,70.7 28.96,68.95 26.79,68.95 26.29,68.45 26.29,67.13 25.93,66.78 25.93,65.3 26.24,64.99 26.24,62.08 26.64,61.68 26.64,60.48 27.56,59.56 27.79,59.56 v2(28.9,58.45) 28.01,57.57 28.01,57.34 28.02,57.34 28.02,56.33 27.66,55.97 27.66,55.59 27.69,55.56 27.69,55.04 25.25,52.6 21.6,52.6 20.22,51.22 20.22,50.04 9.98,39.8 9.98,19.16 18.53,10.62 34.99,10.62 37.69,7.92 37.69,6.73 38.54,5.89 v2(38.54,5.62) 38.99,6.07 40.11,6.07 41.86,7.82 46.48,7.82 48.56,9.91 48.56,15.42 50.37,17.22 v2(50.8,17.22)
  BOTTOM w0.114: v2(17.12,116.46) 18.54,116.46 19.66,117.58 R425.2 ; R763.2 38.46,5.53 v2(38.54,5.62) ; v2(28.9,58.45) 29.54,58.45 29.65,58.34 U40.4 ; v1(198.37,24.13) 198.37,23.5 v2(198.04,23.16) 198.04,21.56 197.61,21.13 197.61,20.18 197.35,19.92 197.35,18.88 197.63,18.6 R650.1 R653.1 R666.1 ; R497.1 v2(25.93,100.02) ; R159.1 v2(188.85,82.42)
SMB_PCU_CLK_P3V3_SWITCH: length 120
  TOP w0.114: R45.2 v2(85.5,110.44)
  S8 w0.102: v2(28.7,57.58) 29.36,58.24 29.36,70.89 28.85,71.39 28.85,76.14 29.67,76.95 30.02,77.3 30.02,79.53 29.74,79.81 29.74,83.93 29.87,84.05 29.87,102.97 37.85,110.95 47.52,110.95 52.91,116.33 67.39,116.33 67.44,116.38 67.45,116.38 67.58,116.51 67.6,116.54 76.28,116.54 76.58,116.84 78,116.84 78.43,116.4 78.58,116.26 84.31,116.26 84.73,115.84 84.73,111.2 v2(85.5,110.44)
  BOTTOM w0.114: v2(85.5,110.44) 84.58,109.52 v1(84.58,109.09) ; R942.2 28.77,59.36 28.37,58.96 28.37,57.91 v2(28.7,57.58) 28.7,57.12 28.47,56.88 U40.1
SMB_PCU_CLK_P3V3_SWITCH_R: length 28.5
  TOP w0.114: U9.BN11 89.48,87.02 v4(89.68,86.91) ; R45.1 v2(87.86,110.44)
  S10 w0.102: v4(89.68,86.91) 89.79,87.02 89.79,88.09 90.07,88.37 90.07,89.05 90.31,89.3 90.31,89.85 89.64,90.53 89.64,96.19 86.84,98.99 86.84,104.32 86.9,104.37 86.9,107.34 87.86,108.31 v2(87.86,110.44)
  BOTTOM w0.114: v2(87.86,110.44) 87.86,110.49 v1(88.9,111.53)
SMB_PCU_DATA_P3V3: length 523.1
  TOP w0.114: v2(187.58,82.42) 188.54,83.39 198.1,83.39 v2(198.93,82.55) ; v2(116.84,120.02) 116.51,120.34 116.51,120.47 115.11,121.87 81.51,121.87 79.48,119.84 79.48,118.59 v2(79.5,118.57)
  S3 w0.102: v2(116.84,120.02) 116.84,119.56 117.4,119 140.42,119 145.74,113.69 160.45,113.69 165.68,108.46 169.66,108.46 176.45,101.66 192.51,101.66 195.94,98.23 195.94,86 198.93,83.01 v2(198.93,82.55) 198.93,79.87 200.91,77.89 200.91,67.96 200.42,67.47 200.42,65.23 199.69,64.51 199.69,61.87 199.7,61.86 199.7,61.36 199.69,61.35 199.69,60.89 199.62,60.82 199.62,47.98 201.12,46.48 201.12,45.72 201.55,45.29 201.55,44.83 201.12,44.4 201.12,25.03 197.94,21.86 197.94,16.74 197.26,16.05 197.26,15.32 196.22,14.28 185.49,14.28 184.3,15.47 184.3,17.23 v2(184.63,17.56)
  S5 w0.102: v2(20.57,117.25) 19.52,117.25 18.16,115.89 18.16,114.05 17.04,112.93 17.04,108.55 21.4,104.19 23.36,104.19 26.8,100.76 v2(26.8,100) ; v2(184.63,17.56) 187.31,17.56 187.91,16.97 205.44,16.97 v2(206.12,17.65)
  S8 w0.102: v2(20.57,117.25) 21.69,118.36 36.07,118.36 37.11,117.32 v2(37.11,117.2)
  S10 w0.102: v2(79.5,118.57) 78.79,119.28 52.96,119.28 51.74,118.06 37.97,118.06 v2(37.11,117.2) ; v2(20.57,117.25) 20.24,117.58 19.17,117.58 18.99,117.75 16.69,117.75 14.5,115.57 14.5,103.95 30.05,88.4 30.05,81.49 29.74,81.18 29.74,80.61 30.05,80.31 30.05,75.76 30.07,75.74 30.07,75.17 30.05,75.14 30.05,71.28 29.23,70.46 28.17,70.46 27.94,70.23 26.42,70.23 25.65,69.47 25.65,68.19 25.65,67.4 25.3,67.04 25.3,65.04 25.61,64.73 25.61,61.82 25.78,61.65 25.78,58.36 v2(25.6,58.18) 25.6,57.95 24.84,57.19 24.84,55.83 25.02,55.65 25.02,53.9 24.13,53.01 21.43,53.01 19.81,51.39 19.81,50.21 9.58,39.97 9.58,18.99 18.36,10.21 34.13,10.21 36.45,7.89 36.45,7.21 37.69,5.97 v2(37.69,5.63)
  BOTTOM w0.114: R158.1 v2(187.58,82.42) ; v2(79.5,118.57) 80.34,117.73 R488.1 ; R762.2 37.54,5.48 v2(37.69,5.63) ; R670.1 R671.1 ; R670.1 v2(206.12,17.65) v1(206.72,17.06) ; R670.1 R669.1 ; R426.2 v2(20.57,117.25) ; U41.4 v2(25.6,58.18) ; R498.1 v2(26.8,100)
SMB_PCU_DATA_P3V3_SWITCH: length 139.7
  TOP w0.114: R40.2 v2(76.65,110.74)
  S10 w0.102: v2(25.43,56.95) 26.06,57.58 26.06,61.69 25.84,61.91 25.84,64.82 25.53,65.13 25.53,66.95 25.88,67.3 25.88,69.21 26.63,69.96 29.05,69.96 30.3,71.21 30.3,80.38 29.97,80.71 29.97,81.09 30.28,81.39 30.28,88.62 16.1,102.79 16.1,114.06 16.32,114.28 16.32,114.95 16.1,115.16 16.1,116.09 17.54,117.53 18.52,117.53 21.44,114.6 34.29,114.6 35.02,115.33 35.24,115.33 35.39,115.39 35.55,115.42 35.71,115.42 35.87,115.39 36.01,115.33 36.15,115.24 36.25,115.14 38.14,115.14 38.29,115.29 38.52,115.52 38.99,115.52 39.06,115.59 52.18,115.59 52.69,116.1 71.92,116.1 73.56,114.47 73.56,113.37 76.19,110.74 v2(76.65,110.74)
  BOTTOM w0.114: R943.2 25.22,58.46 25.1,58.33 25.1,57.27 v2(25.43,56.95) 25.36,56.88 U41.1
SMB_PCU_DATA_P3V3_SWITCH_R: length 34.5
  TOP w0.114: U9.BJ13 90.88,86.34 v4(91.17,86.05) ; R40.1 v2(79.12,110.74)
  S5 w0.102: v4(91.17,86.05) 91.54,86.05 92.2,86.72 92.2,87 92.56,87.35 92.56,88.01 92.38,88.19 92.38,90.63 90.93,92.08 90.93,93.87 90.59,94.21 89.9,94.21 86.02,98.08 85.25,98.86 84.2,98.86 82.6,100.46 82.6,103.9 82.65,103.95 82.65,105.54 82.04,106.15 81.78,106.15 81.13,106.8 81.13,107.91 79.12,109.91 v2(79.12,110.74)
  BOTTOM w0.114: v1(79.38,111.51) 79.12,111.25 v2(79.12,110.74)
SMB_PWR_ALERT_N: length 189.6
  TOP w0.114: R194.1 v2(202.31,67.44) ; R31.2 v2(76.61,112.44)
  S3 w0.102: v2(202.31,67.44) 202.31,68.72 201.83,69.2 201.83,78.27 201.29,78.81 200.32,79.78 200.32,87.26 199.32,88.26 199.32,98.8 195.24,102.88 176.59,102.88 172.36,107.11 172.36,108.85 169.78,111.43 165.61,111.43 165.3,111.74 164.19,111.74 161.05,114.88 150.38,114.88 149.67,115.6 145.46,115.6 140.1,120.95 69.33,120.95 68.17,119.8 68.17,118.13 71.37,114.94 74.07,114.94 74.75,114.25 75.28,114.25 76,113.53 76,113.06 v2(76.61,112.44)
  BOTTOM w0.114: R31.2 v2(76.61,112.44)
SMB_PWR_ALERT_N_R: length 34.5
  TOP w0.114: R31.1 v2(79.28,112.44) ; v4(93.12,87.78) 93.39,88.05 U9.BC9
  S5 w0.102: v2(79.28,112.44) 79.63,112.09 79.63,110.5 81.61,108.52 81.61,106.64 81.88,106.38 82.14,106.38 82.88,105.63 82.88,104.8 85.17,102.52 85.17,100.54 91.16,94.55 91.16,92.13 93.18,90.11 93.18,88.99 92.75,88.56 92.75,88.16 v4(93.12,87.78)
  BOTTOM w0.114: v1(77.88,113.74) 77.98,113.74 v2(79.28,112.44)
SMB_PWR_ALERT_R_N: length 3.6
  TOP w0.114: R194.2 v2(202.31,64.64) 202.59,64.37 U12.A15
SMB_VR_P1V2_SCL: length 19.2
  TOP w0.114: v2(49.13,11.1) 46.73,8.7 46.73,6.48 46.12,5.88 46.12,4.49 47.62,2.99 R770.1 R403.1 51.81,2.99 52.26,2.54 53.09,2.54 53.52,2.98 54.42,2.98 55.54,4.09 U29.20
SMB_VR_P1V2_SDA: length 3.1
  TOP w0.114: U29.19 54.99,4.95 54.83,4.79 54.61,4.79 54.5,4.69 53.89,4.69 R398.1 53.11,4.52 R392.1
SMB_VR_SCL: length 167.4
  TOP w0.114: v2(51.56,2.29) 51.36,2.09 R403.2 ; R397.2 79.4,2.44 v2(79.48,2.36)
  S5 w0.102: v2(199.01,20.19) 197.26,18.44 187.67,18.44 187.03,19.08 185.29,19.08 184.13,17.91 184.13,15.85 180.43,12.16 179.41,12.16 178.87,11.61 176.05,11.61 174.86,10.42 173.93,10.42 172.03,8.52 172.03,6.21 169.66,3.84 166.83,3.84 165.21,2.21 147.83,2.21 147.41,1.79 127.85,1.79 127.43,2.21 126.53,2.21 125.42,1.09 80.75,1.09 v2(79.48,2.36)
  BOTTOM w0.114: R653.2 v2(199.01,20.19) ; v1(82.25,3.96) 82.25,3.24 80.85,1.84 80,1.84 v2(79.48,2.36) 78.36,1.24 60.77,1.24 60.68,1.16 57.68,1.16 57.6,1.24 57.02,1.24 56.64,1.63 52.82,1.63 52.16,2.29 v2(51.56,2.29)
SMB_VR_SDA: length 191.8
  TOP w0.114: v2(78.71,2.39) 78.46,2.64 R396.2 ; R398.2 52.71,3.61 v2(52.43,3.33)
  S3 w0.102: v2(40.85,6.07) 41.25,5.67 41.25,4.48 42.4,3.33 v2(52.43,3.33)
  S5 w0.102: v2(206.12,20.22) 204.37,21.97 195.61,21.97 194.19,23.38 183.89,23.38 183.39,22.89 183.39,19.07 183.9,18.56 183.9,15.95 180.34,12.39 179.32,12.39 178.77,11.84 175.96,11.84 174.76,10.65 173.84,10.65 171.81,8.62 171.81,6.3 169.62,4.11 166.79,4.11 165.11,2.44 147.74,2.44 147.32,2.02 127.95,2.02 127.53,2.44 126.44,2.44 125.35,1.35 82.92,1.35 81.45,2.82 79.15,2.82 v2(78.71,2.39)
  BOTTOM w0.114: v1(42.25,5.76) 41.16,5.76 v2(40.85,6.07) ; R670.2 v2(206.12,20.22) ; v2(52.43,3.33) 52.43,2.36 52.5,2.3 52.67,2.12 52.89,1.91 55.5,1.91 55.88,2.29 56.9,2.29 57.78,1.4 60.58,1.4 60.86,1.68 74.1,1.68 74.15,1.62 74.54,1.62 74.59,1.68 75.08,1.68 75.24,1.84 78.16,1.84 v2(78.71,2.39)
SML0_ALERT_N_R: length 10.2
  TOP w0.114: U9.BL7 v4(90.67,88.63)
  BOTTOM w0.114: v4(90.67,88.63) 90.37,88.92 90.37,90.35 89.41,91.31 89.41,91.95 v1(91.57,94.11) 91.82,94.36 R485.2
SML0_CLK: length 104.4
  TOP w0.114: R8.1 73.13,115.39 v2(73.13,116.08)
  S3 w0.102: v2(27.1,61.37) 28.6,61.37 29.46,62.23 29.46,64.31 32.28,67.13 32.28,81.2 31.6,81.89 30.38,81.89 28.7,83.57 28.7,84.07 v2(28.19,84.58)
  S5 w0.102: v2(28.19,84.58) 29.97,86.36 29.97,100.2 31.27,101.5 57.75,101.5 62.46,106.2 71.47,106.2 72.03,106.76 72.03,108.37 72.75,109.08 72.75,110.57 71.49,111.83 71.49,113.27 73.13,114.91 v2(73.13,116.08)
  BOTTOM w0.114: R8.1 73.13,115.39 v2(73.13,116.08) v1(73.13,117.22) ; v2(27.1,61.37) 26.69,60.95 26.53,60.95 26.13,61.35 R581.2
SML0_CLK_R: length 39
  TOP w0.114: v2(74.96,115.57) 74.78,115.39 R8.2 ; v4(88.69,88.63) 88.4,88.91 U9.BR7
  S5 w0.102: v4(88.69,88.63) 88.78,88.63 89.33,89.18 89.33,89.74 88.29,90.78 88.29,93.76 84.59,97.46 83.4,97.46 81.85,99 80.27,100.58 79.81,100.58 78.43,101.96 77.46,101.96 77.19,102.23 77.19,107.69 76.19,108.68 76.19,111.49 75.36,112.32 75.36,113.1 74.99,113.46 74.63,113.46 74.17,113.92 74.17,114.81 74.93,115.57 v2(74.96,115.57)
  BOTTOM w0.114: v1(73.84,114.3) 74.96,115.42 v2(74.96,115.57)
SML0_DATA: length 112.8
  TOP w0.114: R25.1 v2(85.47,113.31)
  S8 w0.102: v2(85.47,113.31) 86,113.84 86,115.45 84.96,116.48 78.68,116.48 78.49,116.67 78.09,117.07 76.49,117.07 76.18,116.76 67.51,116.76 67.48,116.74 67.48,116.74 67.3,116.56 52.56,116.56 47.35,111.35 37.93,111.35 29.64,103.06 29.64,84.15 29.51,84.02 29.51,79.72 29.79,79.44 29.79,77.65 29.44,77.29 28.63,76.48 28.63,71.05 28.88,70.79 28.88,61.16 v2(27.78,60.07)
  BOTTOM w0.114: R585.2 26.92,60.37 27.22,60.07 v2(27.78,60.07) ; R25.1 v2(85.47,113.31)
SML0_DATA_R: length 34.9
  TOP w0.114: U9.BN18 89.39,83.76 v4(89.68,83.47) ; R25.2 v2(87.99,113.31)
  S10 w0.102: v4(89.68,83.47) 89.68,84.55 90.14,85.01 90.14,85.39 90.58,85.83 90.58,86.23 91.05,86.71 91.05,87.1 90.79,87.37 90.79,88.07 91.05,88.34 91.05,96.45 88.44,99.06 88.44,103.99 89.03,104.57 89.03,109.39 89,109.42 89,112.29 v2(87.99,113.31)
  BOTTOM w0.114: v2(87.99,113.31) 88.7,114.02 v1(88.7,114.07)
SML1_ALERT: length 7.2
  TOP w0.114: v4(91.71,89.25) 92.05,88.91 U9.BF7
  BOTTOM w0.114: R483.2 94.03,93.6 v1(92.96,93.6) 92.71,93.34 92.08,93.34 91.57,92.84 91.57,91.62 91.71,91.48 v4(91.71,89.25)
SML1_CLK: length 113
  S8 w0.102: v2(27.13,64.1) 27.67,64.65 27.67,69.63 28.22,70.18 28.22,83.95 29.16,84.89 29.16,102.9 37.85,111.6 47.04,111.6 52.23,116.79 67.2,116.79 67.38,116.97 67.39,116.97 67.41,116.99 76,116.99 76.36,117.35 78.13,117.35 78.77,116.71 85.06,116.71 86.44,115.33 86.44,113.76 v2(89.74,110.46)
  BOTTOM w0.114: R576.2 26.68,63.65 v2(27.13,64.1) ; v2(89.74,110.46) 89.97,110.69 R452.1 90.5,110.67 R790.2
SML1_CLK_R: length 24.9
  TOP w0.114: U9.BG9 91.81,88.05 92.25,88.49 92.99,88.49 v4(93.13,88.35)
  S10 w0.102: v4(93.13,88.35) 93.13,88.76 93.18,88.81 93.18,94.27 93.01,94.44 93.01,99.25 90.22,102.05 90.22,102.82 89.94,103.1 89.94,107.39 v2(90.58,108.03)
  BOTTOM w0.114: v1(91.62,108.09) 91.56,108.03 v2(90.58,108.03) 90.5,108.1 R790.1
SML1_DATA: length 115.9
  TOP w0.114: R789.2 90.27,111.66 v2(89.79,112.14)
  S8 w0.102: v2(27.11,62.66) 26.68,63.09 26.68,64.89 27.44,65.66 27.44,69.63 26.14,70.94 26.14,73.43 27.74,75.03 27.74,84.77 28,85.04 28.18,85.04 28.7,85.56 28.7,102.77 38.07,112.14 46.94,112.14 51.82,117.02 67.11,117.02 67.29,117.2 67.29,117.2 67.32,117.22 75.9,117.22 76.26,117.58 78.23,117.58 78.86,116.94 86.98,116.94 88.9,115.02 88.9,113.03 v2(89.79,112.14)
  BOTTOM w0.114: v2(27.11,62.66) 26.44,62.66 R579.2 ; v2(89.79,112.14) 90.27,111.66 R789.2
