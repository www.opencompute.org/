# Allegro board 142000001998AR0A-B-0515.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BDX_PECI_PCH_3V3_R: length 4
  BOTTOM w0.114: CONN14.35 22.92,68.48 23.58,67.82 24.11,67.82 R915.1
BDX_PECID0: length 12.9
  TOP w0.114: U9.L72 108.29,58.86 108.03,59.13 v4(108.03,59.16)
  BOTTOM w0.114: v4(108.03,59.16) 108.46,59.59 110.24,59.59 110.34,59.49 111.15,59.49 R586.1 111.25,59.06 v1(110.69,58.5) 110.2,58.01 110.2,53.75 110.64,53.31 110.64,52.26 110.18,51.8 R749.2
BDX_PWRGOOD_CPU: length 157.1
  TOP w0.114: U10.4 173.65,68.32 173.08,67.74 171.4,67.74 170.47,68.67 170.47,78.03 167.93,80.57 167.93,82.59 v2(168.38,83.04) ; R32.1 v2(72.26,111.96)
  S3 w0.102: v2(168.38,83.04) 168.37,83.04 166.93,84.48 166.93,87 168.81,88.88 168.81,94 165.32,97.49 162.1,97.49 161.87,97.71 157.13,97.71 156,96.58 134.71,96.58 133.28,95.15 130.81,95.15 130,95.96 121.94,95.96 120.68,97.23 118.87,97.23 v2(118.6,97.51)
  BOTTOM w0.114: R537.1 v2(168.38,83.04) ; v2(118.6,97.51) 118.51,97.51 117.88,96.88 115.32,96.88 114.3,95.86 112.89,95.86 109.35,92.32 106.3,92.32 105.89,91.91 105.02,91.91 103.82,93.1 102.59,93.1 102.04,92.56 100.43,92.56 100.03,92.96 100.03,93.04 99.72,93.35 99.19,93.35 98.93,93.09 97.66,93.09 97.47,93.29 97,93.76 97,93.96 96.07,94.89 91.11,94.89 86.26,99.75 76.49,99.75 68.44,107.8 67.82,107.8 67.67,107.95 67.67,110.21 68.45,111 R453.2 72.09,111.79 v2(72.26,111.96)
BDX_PWRGOOD_CPU_R: length 34.8
  TOP w0.114: R32.2 v2(74.01,111.27) ; U9.BU11 v4(87.7,86.91)
  S5 w0.102: v2(74.01,111.27) 75.48,109.79 75.48,106.25 75.11,105.87 75.11,103.3 77.16,101.25 78.14,101.25 79.52,99.87 79.98,99.87 81.35,98.5 83.1,96.74 84.3,96.74 87.83,93.21 87.83,90.14 88.32,89.66 88.32,89.11 88.09,88.89 88.09,88.34 87.81,88.06 87.81,87.3 87.7,87.19 v4(87.7,86.91)
  BOTTOM w0.114: v2(74.01,111.27) 73.25,110.52 v1(73.23,110.52)
BDX_RTCRST_N: length 91.6
  TOP w0.114: U9.AP9 97.35,88.05 v4(97.08,87.78) ; CONN17.2 v2(138.43,118.49) ; v2(101.19,101.63) 100.36,101.63 R118.2
  S3 w0.102: v2(101.19,101.63) 101.83,102.26 101.83,105.26 v2(101.24,105.84)
  S10 w0.102: v4(97.08,87.78) 97.08,86.67 97.37,86.39 99.29,86.39 100.05,87.14 100.05,87.86 99.97,87.93 99.97,89.53 100.18,89.74 100.18,93.8 101.19,94.82 101.2,94.82 101.25,94.87 101.61,94.87 101.88,95.13 101.88,95.49 104.47,98.09 104.47,100.2 103.43,101.24 101.57,101.24 v2(101.19,101.63)
  BOTTOM w0.114: v2(138.43,118.49) 137.96,118.96 130,118.96 127.85,116.8 123.42,116.8 121.85,115.23 121.85,109.82 121.27,109.24 116.1,109.24 115.57,108.71 115.57,103.89 114.3,102.62 112.12,102.62 110.77,101.27 108.45,101.27 107.95,101.77 107.95,106.17 107.44,106.68 102.08,106.68 v2(101.24,105.84) ; v2(101.19,101.63) 100.58,101.02 99.42,101.02 98.81,101.63 v1(98.17,101.63)
BDX_SATA1_ACTIVITY_LED1: length 45.6
  TOP w0.114: LED14.C v2(185.26,16.51) ; U12.N14 v3(202.09,49.61)
  S8 w0.102: v3(202.09,49.61) 202.52,49.18 202.52,48.92 202.52,48.91 202.52,48.79 202.52,48.79 202.52,48.43 202.32,48.23 202.32,47.24 203.01,46.55 203.01,41.86 199.9,38.74 199.9,37.59 197.46,35.15 196.31,35.15 194.46,33.31 194.46,24.18 190.14,19.86 189.15,19.86 185.8,16.51 v2(185.26,16.51)
  BOTTOM w0.114: LED14.C v2(185.26,16.51)
BDX_SATA2_ACTIVITY_LED2: length 47.8
  TOP w0.114: LED13.C v2(182.47,16.51) ; U12.P14 v3(202.09,48.61)
  S8 w0.102: v3(202.09,48.61) 202.09,47.15 202.78,46.45 202.78,41.95 199.67,38.84 199.67,37.69 197.36,35.38 196.22,35.38 194.23,33.4 194.23,24.28 190.89,20.93 185.38,20.93 184.66,20.21 184.66,20.21 184.39,19.94 182.47,18.02 v2(182.47,16.51)
  BOTTOM w0.114: LED13.C v2(182.47,16.51)
BDX_SC_PWRGOOD: length 209.9
  TOP w0.114: v2(100.97,49.89) 101.06,49.98 R239.2 ; U13.19 174.7,66.27 v2(174.19,66.78)
  S3 w0.102: v2(100.97,49.89) 100.2,50.65 99.77,50.65 99.47,50.34 99.47,48.82 98.22,47.57 98.22,45.9 99.24,44.88 115.24,44.88 115.44,44.68 116.54,44.68 117.93,46.06 119.55,46.06 120.17,46.69 v2(122.02,46.69)
  S5 w0.102: v2(100.97,49.89) 100.97,49.82 100.51,49.36 100.51,44.78 99.31,43.59 99.31,38.99 97.66,37.34 97.66,37.33 97.18,36.85 97.18,36.64 97.18,36.64 97.18,34.18 97.18,34.18 97.18,33.8 97.18,33.8 97.18,28.37 93.4,24.59 93.4,14.73 91.24,12.57 77.59,12.57 77.18,12.98 72.85,12.98 72.31,13.51 60.42,13.51 59.1,12.19 57.56,12.19 56.54,11.18 56.18,11.18 56.01,11.35 53.94,11.35 51.89,9.3 48.03,9.3 46.71,7.98 v2(46.71,5.49)
  S8 w0.102: v2(122.02,46.69) 122.02,47.28 123.53,48.79 123.53,49.46 129.91,55.85 155.05,55.85 155.53,55.37 165.49,55.37 170.31,60.19 170.31,65.88 170.9,66.47 173.89,66.47 v2(174.19,66.78)
  S10 w0.102: v2(46.71,5.49) 46.71,5.2 44.66,3.15 33.45,3.15 v2(32.41,2.11)
  BOTTOM w0.114: v1(174.19,65.99) v2(174.19,66.78) ; R775.2 32.89,2.59 v2(32.41,2.11) ; R609.1 101.04,50.75 R239.2 101.06,49.98 v2(100.97,49.89)
BDX_SCLOCK: length 155.1
  TOP w0.114: R37.2 v2(85.47,111.4) ; U12.C8 v3(195.09,60.61)
  S3 w0.102: v2(85.47,111.4) 85.01,111.86 85.01,115.38 86.45,116.81 89.21,116.81 90.68,118.29 94.67,118.29 95.16,117.81 99.85,117.81 100.01,117.97 100.39,117.97 101.24,117.12 102.83,117.12 108.62,111.33 114.11,111.33 117.41,108.03 121.37,108.03 122.59,109.25 131.74,109.25 132.63,110.13 148.28,110.13 149.81,108.61 151.04,108.61 154.24,105.41 169.15,105.41 173.97,100.6 173.97,92.09 193.73,72.33 193.73,68.15 195.15,66.73 195.15,64.4 195.47,64.08 195.47,60.99 v3(195.09,60.61)
  BOTTOM w0.114: v2(85.47,111.4) 85.2,111.4 84.71,111.89 v1(84.66,111.89)
BDX_SDATAOUT0: length 210.4
  TOP w0.114: v2(72.29,109.27) 73.13,110.11 R44.1 ; U12.E14 v3(202.09,58.61)
  S3 w0.102: v2(72.29,109.27) 72.29,109.49 69.32,112.46 69.32,115.37 67.03,117.65 67.03,120.28 68.85,122.1 140.8,122.1 144.09,118.81 156.13,118.81 156.27,118.67 157.28,118.67 158.75,120.14 163.06,120.14 164.46,121.54 171.45,121.54 176.16,116.82 183.55,116.82 186.32,114.05 186.32,108.93 191.15,104.1 196.27,104.1 201.83,98.54 201.83,92.93 201.46,92.57 201.46,80.25 201.76,79.95 202.97,78.75 202.97,69.76 205.03,67.7 205.03,64.11 203.48,62.56 203.48,59.39 202.7,58.61 v3(202.09,58.61)
  BOTTOM w0.114: v3(202.09,58.61) v1(203.23,58.61)
BDX_SDATAOUT1: length 208.3
  TOP w0.114: R67.1 v2(76.68,108.84) ; U12.C14 v3(202.09,60.61)
  S3 w0.102: v3(202.09,60.61) 202.09,62.06 204.57,64.54 204.57,67.51 202.51,69.57 202.51,78.56 201.57,79.49 201.01,80.06 201.01,92.76 201.37,93.12 201.37,98.35 196.08,103.64 190.96,103.64 185.86,108.74 185.86,113.86 183.36,116.37 175.83,116.37 175.05,117.14 170.31,117.14 169.58,116.41 166.76,116.41 166.2,116.96 158.09,116.96 156.86,118.19 152.94,118.19 152.28,117.53 144.63,117.53 144.6,117.55 144.58,117.55 140.49,121.64 69.04,121.64 68.51,121.11 67.49,120.09 67.49,119.52 67.49,117.84 67.76,117.57 70.28,115.05 70.28,114.71 71.56,113.42 72.56,113.42 72.97,113 73.25,113 75.77,110.48 75.77,109.75 v2(76.68,108.84)
  BOTTOM w0.114: v1(204.09,59.72) 203.19,60.61 v3(202.09,60.61)
BDX_SERIRQ_DATA: length 22.5
  TOP w0.114: U9.AE75 101.81,57.04 102.21,56.64 102.21,56.36 101.98,56.13 101.98,55.66 102.11,55.53 102.11,54.31 v3(101.48,53.68)
  S5 w0.102: v3(101.48,53.68) 106.33,53.68 107.24,54.58 109.52,54.58 111.05,53.06 111.05,50.27 112.29,49.02 v2(112.37,49.02)
  BOTTOM w0.114: Q10.3 113.14,49.44 112.75,49.05 112.39,49.05 v2(112.37,49.02) 112.09,49.02 v1(111.17,49.94)
BDX_SERIRQ_DIR: length 27.4
  TOP w0.114: U9.AD74 102.1,58.26 v4(102.1,58.53) ; R794.2 116.71,52.45 116.12,53.04 114.16,53.04 113.67,52.55 v2(113.61,52.55)
  S8 w0.102: v2(113.61,52.55) 111.66,52.55 111.1,53.11 105.94,53.11 104.95,54.1 104.95,55.65 104.27,56.34 104.27,58.55 104.09,58.72 103.86,58.72 103.58,59 103.58,59.49 103.3,59.77 102.77,59.77 102.54,59.54 102.54,58.98 v4(102.1,58.53)
  BOTTOM w0.114: Q10.5 113.79,52.37 v2(113.61,52.55) 112.04,52.55 v1(111.51,53.09) 110.87,53.72 R795.1
BDX_SLOAD: length 383.2
  TOP w0.114: U12.N10 v3(198.09,49.61)
  S3 w0.102: v2(99.71,14.69) 99.71,14.36 97.28,11.94 88.29,11.94 86.66,10.31 85.67,10.31 85.19,9.83 85.19,8.9 83.55,7.26 77.35,7.26 76.82,6.73 70.55,6.73 69.39,5.56 66.96,5.56 66.58,5.18 62.94,5.18 62.05,6.07 61.29,6.07 59.4,7.96 55.03,7.96 54.89,7.82 54.13,7.82 53.09,8.86 43.92,8.86 42.6,10.19 32.41,10.19 31.6,11 31.6,11.12 30.93,11.79 30.63,11.79 29.91,12.5 26.08,12.5 25.58,11.99 11.16,11.99 4.39,18.76 4.39,22.62 4.04,22.97 4.04,89.48 22.01,107.45 30.57,107.45 36.67,113.55 36.67,115.59 36.19,116.07 36.19,117.58 38.91,120.29 57.43,120.29 61.49,116.23 61.49,113.87 63.75,111.61 v2(63.75,110.97)
  S8 w0.102: v2(99.71,14.69) 99.71,15.11 100.95,16.36 105.19,16.36 105.5,16.66 111.97,16.66 114.18,18.87 114.37,18.87 123.95,18.87 126.47,16.36 148.68,16.36 152.67,20.35 162.46,20.35 164.67,22.56 171.11,22.56 171.38,22.83 174.53,22.83 174.8,22.56 175.23,22.56 178.6,25.93 178.89,26.21 182.91,26.21 188.19,31.5 188.19,38.12 193.52,43.45 193.52,44.42 194.84,45.75 195.08,45.75 195.97,46.63 195.97,47.14 196.47,47.64 196.47,48.64 196.98,49.15 197.63,49.15 v3(198.09,49.61)
  BOTTOM w0.114: v1(196.52,47.73) 196.9,47.73 197.58,48.4 197.58,49.1 v3(198.09,49.61) ; R451.2 v2(63.75,110.97)
BDX_SLP_S3_CPU_N: length 26.4
  TOP w0.108: v4(103.05,59.13) U9.AC71
  TOP w0.114: v2(101.29,39.85) 101.29,39.32 R303.2
  S8 w0.102: v2(101.29,39.85) 102.08,39.85 103.38,41.15 103.38,42.97 102.84,43.51 102.84,44.32 103.63,45.11 104.39,45.11 104.93,45.64 104.93,46.96 103.83,48.06 103.83,50.1 103.89,50.16 103.89,53.85 103.3,54.43 103.3,58.88 v4(103.05,59.13)
  BOTTOM w0.114: v1(102.59,39.07) R303.2 101.29,39.32 v2(101.29,39.85)
BDX_SLP_S3_CPU_N_R: length 3.9
  TOP w0.114: R307.1 100.1,38.15 v2(99.92,38.15) 99.92,38.35 R303.1
  BOTTOM w0.114: R667.1 99.97,38.1 v2(99.92,38.15)
BDX_SPI_MUX_SEL: length 192.5
  TOP w0.114: R931.2 110.98,109.09 110.74,108.85 U44.6 109.91,108.84 109.47,108.84 109.35,108.97 109.35,109.47 108.97,109.86 108.33,109.86 107.74,110.44 U43.1 v2(107.74,113.03)
  S8 w0.102: v2(33.06,116.85) 33.02,116.81 33.02,116.2 32.13,115.32 19.81,115.32 14.99,110.49 14.99,105.16 9.91,100.08 9.91,87.38 7.49,84.96 7.49,51.82 17.27,42.04 v2(17.27,39.75)
  S10 w0.102: v2(33.06,116.85) 33.38,117.17 36.49,117.17 36.92,116.74 37.3,116.74 37.77,117.21 37.77,117.54 38.06,117.83 51.83,117.83 53.05,119.05 75.77,119.05 76.73,118.08 85.32,118.08 v2(85.85,118.62)
  BOTTOM w0.114: CONN14.119 19.93,40.88 18.8,39.75 v2(17.27,39.75) ; v2(107.74,113.03) 107.31,113.46 R933.2 106.75,113.85 105.28,115.32 104.78,115.32 104.39,115.7 102.72,115.7 102.23,115.21 101.96,115.21 100.84,116.33 97.54,116.33 96.9,115.7 95.63,115.7 92.46,118.87 90.04,118.87 v1(89.66,118.49) 88.65,117.47 87,117.47 v2(85.85,118.62)
BDX_SPKR: length 39.2
  TOP w0.114: R9.2 83.74,115.77 v2(84.15,115.77) ; v4(89.19,82.62) 88.9,82.9 U9.BP20
  S10 w0.102: v4(89.19,82.62) 89.19,83.69 88.81,84.07 88.81,84.61 89.07,84.88 89.07,85.38 88.81,85.64 88.81,86.34 89.07,86.61 89.07,87.1 88.81,87.37 88.81,88.12 89.08,88.39 89.08,89.05 89.32,89.29 89.32,90.03 89.15,90.2 89.15,95.78 86.11,98.82 86.11,104.26 85.67,104.7 85.67,105.36 84.86,106.18 84.86,108.57 84.91,108.62 84.91,115.01 v2(84.15,115.77)
  BOTTOM w0.114: v2(84.15,115.77) 84.64,116.26 v1(85.38,116.26)
BDX_SRTCRST_N: length 18.6
  TOP w0.114: U9.AP4 97.85,90.72 97.5,91.07 97.5,91.58 97.79,91.87 97.79,93.27 97.29,93.77 97.29,94.29 97.35,94.35 97.35,94.85 97.59,95.08 97.59,98.09 97.67,98.18 97.67,101.4 98.81,102.54 R117.2 R118.1 100.36,102.59 101.22,103.45 v2(101.22,103.48)
  BOTTOM w0.114: v2(101.22,103.48) 101.22,102.39 100.46,101.63 C274.1
BDX_TCK_SCLK: length 157.5
  S8 w0.102: v2(198.88,17.5) 198.2,16.81 193.73,16.81 190.86,13.94 173.83,13.94 170.55,10.67 162.36,10.67 157.81,6.12 144.95,6.12 143.1,4.27 v2(143.1,4.03)
  S10 w0.102: v2(198.88,17.5) 200.15,18.77 205.54,18.77 207.82,21.06 207.82,69.81 205.44,72.2 205.44,78.22 201.6,82.06 201.6,87.01 204.08,89.49 204.08,91.92 203.03,92.97 v2(203.03,94.21)
  BOTTOM w0.114: v2(203.03,94.21) 202.51,94.73 v1(202.51,96.43) 202.51,96.93 200.92,98.52 R132.1
  BOTTOM w0.127: CONN16.64 v2(143.1,4.03)
BDX_TCK_SCLK_R: length 3.8
  TOP w0.114: U7.2 197.91,98.31 v2(197.7,98.52)
  BOTTOM w0.114: v2(197.7,98.52) R132.2 v1(198.73,99.69)
BDX_TDI_MOSI: length 131.6
  S5 w0.102: v2(200.53,93.32) 198.49,91.28 197.61,91.28 190.1,83.77 186.97,83.77 186.21,83.01 186.21,77.95 185.32,77.06 185.32,52.2 184.15,51.03 184.15,40.79 184.53,40.41 184.53,31.56 180.02,27.05 179.87,27.05 178.66,25.85 178.66,25.69 176.56,23.58 176.56,23.11 174.12,20.68 173.29,20.68 172.33,19.71 172.01,19.71 170.21,17.91 151.21,17.91 147.42,14.12 142.06,14.12 v2(141.66,14.53)
  BOTTOM w0.114: R147.1 v2(200.53,93.32) ; v2(141.66,14.53) 140.41,14.53 139.9,14.02 139.9,9.45 139.6,9.14 CONN16.77
BDX_TDI_MOSI_R: length 8.2
  TOP w0.114: v2(203.76,93.32) 205.89,93.32 206.55,93.98 206.55,95.22 206.06,95.71 U7.11
  BOTTOM w0.114: R147.2 v2(203.76,93.32) v1(204.9,93.32)
BDX_TDO_MISO: length 143.8
  S5 w0.102: v2(206.22,92.27) 206.66,91.82 206.66,89.47 206.21,89.01 206.21,84.74 207.58,83.37 207.58,58.3 203.55,54.26 203.55,44.25 201.24,41.95 201.24,40.7 199.36,38.82 199.36,38.48 195.35,34.47 191.78,34.47 188.73,31.42 187.92,31.42 180.11,23.61 179.35,23.61 178.51,22.77 178.51,15.6 176.95,14.04 173.58,14.04 169.65,10.12 162.04,10.12 157.84,5.91 143.66,5.91 v2(142.99,5.24)
  BOTTOM w0.114: v1(204.77,92.04) 206,92.04 v2(206.22,92.27) 206.98,93.03 R150.1
  BOTTOM w0.127: CONN16.66 142.6,4.86 v2(142.99,5.24)
BDX_TDO_MISO_R: length 3.8
  TOP w0.114: U7.14 v2(206.3,97.66)
  BOTTOM w0.114: v2(206.3,97.66) 206.07,97.89 R150.2 204.97,98.49 v1(204.62,98.15)
BDX_TMS_CS_N: length 151.7
  TOP w0.114: R134.1 v2(203.24,91.4)
  S8 w0.102: v2(141.1,5.31) 141.1,5.82 141.86,6.58 157.62,6.58 161.94,10.9 170.46,10.9 173.74,14.17 189.87,14.17 190.25,14.55 190.25,14.55 191.52,15.82 191.52,20.16 193.58,22.23 v2(194.41,22.23)
  S10 w0.102: v2(203.24,91.4) 203.24,91.03 201.68,89.46 201.68,88.56 200.56,87.44 200.56,81.22 201.85,79.92 201.85,78.85 204.39,76.31 204.39,68.99 205.89,67.5 205.89,61.63 206.76,60.77 206.76,56.81 204.37,54.42 204.37,50.11 204.47,50.01 204.71,50.01 206.88,47.84 206.88,32.08 201.78,26.97 196.62,26.97 194.41,24.77 v2(194.41,22.23)
  BOTTOM w0.114: v2(203.24,91.4) 202.86,91.78 v1(202.08,91.78)
  BOTTOM w0.127: CONN16.72 v2(141.1,5.31)
BDX_TMS_CS_N_R: length 11.1
  TOP w0.114: U7.5 198.02,96.36 197.36,95.71 v2(197.36,94.43) 197.36,93 198.11,92.26 R134.2
  BOTTOM w0.114: v1(197.36,93.41) v2(197.36,94.43)
BIOS_CPU_SPI2_CS_TPM: length 4.7
  TOP w0.114: v4(91.17,87.77) 90.88,88.05 U9.BJ9
  BOTTOM w0.114: v1(90.32,91.53) 91.06,90.79 TP19.1 91.17,89.66 v4(91.17,87.77)
BIOS_SPI1_CS: length 70.3
  TOP w0.114: v3(109.35,110.36) 109.69,110.71 U43.4 ; CONN2.1 v2(53.14,118.21) ; v2(103.96,111.12) 103.99,111.1 103.99,110.59 104.32,110.26 R949.2
  TOP w0.127: U1.1 103.55,111.54 v2(103.96,111.12)
  S8 w0.102: v2(53.14,118.21) 53.9,118.97 73.04,118.97 73.88,118.14 75.53,118.14 75.55,118.16 75.88,118.49 78.61,118.49 79.21,117.89 79.22,117.89 79.25,117.86 92.41,117.86 96.86,113.4 98.07,113.4 99.2,112.27 100.7,112.27 102.82,112.27 v2(103.96,111.12)
  BOTTOM w0.114: v2(103.96,111.12) 104.14,110.95 104.14,108.95 104.71,108.38 105.96,108.38 107.95,110.36 v3(109.35,110.36)
BIOS_SPI2_CS: length 67.7
  TOP w0.114: CONN2.3 v2(58.22,118.21)
  S8 w0.102: v2(97.66,111.96) 97.66,112.17 92.21,117.63 79.16,117.63 79.13,117.66 79.12,117.66 78.51,118.26 75.98,118.26 75.62,117.91 66.85,117.91 66.67,117.73 58.7,117.73 v2(58.22,118.21)
  BOTTOM w0.114: R936.2 109.47,104.85 109.47,106.2 Q1.S 110.78,108.67 v1(108.08,108.67) 106.6,108.67 106.06,108.13 104.61,108.13 103.9,108.85 103.9,110.19 102.25,111.84 98.89,111.84 98.8,111.75 97.87,111.75 v2(97.66,111.96)
  BOTTOM w0.127: v2(97.66,111.96) 97.04,112.59 U31.1
BIOS_SPI2_CS_SWITCH: length 7.8
  TOP w0.114: v3(110.74,106.56) 109.92,107.38 U44.4
  BOTTOM w0.114: Q1.D v3(110.74,106.56) 110.27,106.56 109.73,106.02 R935.2 109.78,104.14 v1(110.74,104.14)
BIOS_SPI_C_CLK: length 79.2
  TOP w0.114: CONN3.4 v2(45.76,114.86) ; U43.7 111.64,110.12 111.32,109.8 110.76,109.8 110.24,110.33 v3(110.24,110.36)
  TOP w0.127: U1.6 v2(97.82,115.13)
  S8 w0.102: v2(97.82,115.13) 97.36,115.13 95.78,116.71 95.78,117.15 93.25,119.68 52.29,119.68 47.7,115.09 47.7,114.71 47.27,114.28 46.34,114.28 v2(45.76,114.86)
  BOTTOM w0.114: U31.6 104.13,114.55 105.28,114.55 106.86,112.98 106.86,111.46 107.31,111 109.6,111 v3(110.24,110.36)
  BOTTOM w0.127: U31.6 102.89,115.13 102.46,114.71 98.24,114.71 v2(97.82,115.13)
BIOS_SPI_C_MISO: length 75.9
  TOP w0.114: CONN3.5 47.03,119.77 47.55,119.26 49.23,119.26 v2(49.56,119.58) ; v2(99.47,113.31) 100.02,113.86 102.58,113.86 ; U43.12 110.34,116.31 109.66,115.63 108.78,115.63 107.56,114.41 107.11,114.41 106.61,113.92 106.08,113.92 106.03,113.97 105.56,113.97
  TOP w0.127: 105.56,113.97 105.45,113.86 U1.2 102.58,113.86
  S8 w0.102: v2(49.56,119.58) 50.37,120.4 94.75,120.4 100.12,115.03 100.12,113.96 v2(99.47,113.31)
  BOTTOM w0.127: U31.2 96.73,113.86 97.41,113.18 99.34,113.18 v2(99.47,113.31)
BIOS_SPI_C_MOSI: length 89.4
  TOP w0.114: CONN3.6 v2(47.03,114.86) ; v3(111.76,116.2) 112.29,116.74 U43.9
  TOP w0.127: U1.5 97.02,116.4 v2(97.54,116.92)
  S8 w0.102: v3(111.76,116.2) 111.94,116.03 111.94,115.26 111.38,114.71 107.78,114.71 107.4,114.32 102.11,114.32 100.51,112.73 99.39,112.73 98.63,113.49 98.63,115.82 v2(97.54,116.92) 95.83,118.62 95.83,118.81 94.47,120.17 52.09,120.17 47.03,115.1 v2(47.03,114.86)
  BOTTOM w0.114: v2(47.03,114.86) 46.34,114.17 43.5,114.17 v1(43.02,114.65)
  BOTTOM w0.127: v2(97.54,116.92) 97.87,116.58 100.94,116.58 101.12,116.4 U31.5
BIOS_SPI_CI_N: length 55.3
  TOP w0.114: U2.1 v2(61.84,112.47)
  BOTTOM w0.114: R924.1 109.47,115.82 108.71,116.59 107.8,116.59 107.31,116.1 105.59,116.1 105.11,116.59 104.58,116.59 104.24,116.92 99.49,116.92 98.25,118.15 95.18,118.15 93.98,119.35 68.35,119.35 v1(67.99,119) 66.67,117.68 65.86,117.68 65.25,117.07 65.25,115.69 64.02,114.45 63.7,114.45 62.43,113.18 U32.3 v2(61.84,112.47)
BIOS_SPI_CI_N_R: length 3.4
  TOP w0.114: v2(109.35,113.03) 109.22,113.03 109.04,112.85 U43.3
  BOTTOM w0.114: R924.2 109.47,113.62 109.35,113.49 v2(109.35,113.03) 109.09,112.78 v1(109.09,112.14)
BIOS_SPI_CLK: length 17.5
  TOP w0.114: R52.2 99.11,111.05 99.83,111.77 100.86,111.77 102.33,113.23 106.63,113.23 107.31,113.92 109.98,113.92 v3(111.51,115.44)
  BOTTOM w0.114: R926.1 v3(111.51,115.44) R427.2 112.65,115.64 112.65,116.36 v1(112.68,116.39)
BIOS_SPI_CLK_R: length 45.7
  TOP w0.114: R52.1 99.44,109.2 v2(99.44,108.84) ; U9.BG13 v4(92.16,86.05)
  S5 w0.102: v2(99.44,108.84) 99.44,108.2 99.31,108.07 99.31,106.74 99.52,106.54 99.52,105.43 99.19,105.11 98.73,105.11 98.6,105.23 97.18,105.23 94.5,102.56 94.5,100.96 93.47,99.93 93.47,96.32 93.47,96.32 93.47,92.96 95.33,91.11 98.37,91.11 99.87,89.61 99.87,89.42 99.93,89.36 99.93,88.82 99.97,88.78 99.97,88.46 99.87,88.37 99.87,88.34 99.03,87.5 99.03,86.56 98.76,86.28 98.76,84.91 97.05,83.2 94.14,83.2 93.45,83.9 92.06,83.9 91.78,84.17 91.78,84.64 92.16,85.02 v4(92.16,86.05)
  BOTTOM w0.114: v2(99.44,108.84) 99.44,107.93 v1(99.16,107.66)
BIOS_SPI_CS0_N: length 17.9
  TOP w0.114: U2.4 60.64,114.48 61.37,115.21 R6.2 62.03,115.93 v2(64.39,118.29) 65.15,119.05 67.11,119.05 68.35,117.81 69.93,117.81 71.82,115.91 72.15,115.91 72.52,115.54 72.52,114.71 72.8,114.43 R15.1
BIOS_SPI_CS0_N_R: length 36.4
  TOP w0.114: R15.2 74.73,114.43 v2(75.01,114.71) ; v4(89.68,88.63) U9.BN7
  S5 w0.102: v2(75.01,114.71) 75.84,113.87 75.84,112.52 77.87,110.49 77.87,107.89 78.3,107.46 78.3,103.04 78.87,102.48 78.87,102.2 80.01,101.06 80.47,101.06 82.19,99.34 83.6,97.94 84.79,97.94 88.75,93.98 88.75,91.33 90.32,89.76 90.32,89.27 v4(89.68,88.63)
  BOTTOM w0.114: v1(75.21,113.69) 75.01,113.89 v2(75.01,114.71)
BIOS_SPI_CS1_N: length 9.9
  BOTTOM w0.114: U32.4 59.51,113.18 59.08,112.75 59.08,110.26 R460.2 60.05,109.67 61.62,108.1 v1(62.51,108.1) 62.97,108.1 63.37,108.51 R70.1
BIOS_SPI_CS1_N_R: length 39.3
  TOP w0.114: v4(88.2,86.05) 87.91,86.34 U9.BT13
  S3 w0.102: v2(66.17,108.33) 66.17,108.1 67.44,106.83 68.02,106.83 76,98.86 79.83,98.86 82.17,96.52 84.61,96.52 87.66,93.47 87.66,92.51 86.51,91.36 86.51,89.28 86.74,89.05 86.92,89.05 87.1,88.87 87.1,88.47 86.74,88.11 86.74,87.68 87.22,87.2 87.22,86.66 87.84,86.05 v4(88.2,86.05)
  BOTTOM w0.114: v1(66.17,107.52) v2(66.17,108.33) 65.99,108.51 R70.2
BIOS_SPI_HOLD_N: length 11.1
  TOP w0.114: R21.2 94.76,114.41 95.31,113.86 U1.7
  TOP w0.127: U1.7 v2(97.82,113.86)
  BOTTOM w0.114: v1(105.16,113.54) 104.83,113.86 U31.7
  BOTTOM w0.127: U31.7 v2(97.82,113.86)
BIOS_SPI_KGI_N: length 67.8
  TOP w0.114: U44.1 106.95,108.85 106.17,108.08 97.28,108.08 96.01,106.81 95.38,106.81 94.87,106.3 93.73,106.3 92.84,107.19 92.84,114.05 95.38,116.59 v2(95.38,118.62) ; U2.3 61.84,114.52 v2(62.48,115.16)
  BOTTOM w0.114: U32.1 61.84,114.52 v2(62.48,115.16) 62.87,114.78 64.01,114.78 64.57,115.34 v1(64.57,116.33) 64.57,117.65 66.55,119.63 94.36,119.63 v2(95.38,118.62)
BIOS_SPI_MISO: length 69.2
  TOP w0.114: R4.2 90.53,116.94 v2(91.41,116.05) ; v4(91.17,82.62) 91.15,82.63 U9.BJ20
  S3 w0.102: v3(100.71,115.32) 99.89,115.32 99.51,115.7 98.63,115.7 98.27,115.34 98.27,114.94 98,114.67 95.28,114.67 92.99,116.97 92.33,116.97 v2(91.41,116.05)
  S8 w0.102: v3(100.71,115.32) 105.41,115.32 106.05,115.95 107.19,115.95 108.2,114.94 110.62,114.94 111,115.32 111,117.86 v3(110.11,118.75)
  S10 w0.102: v4(91.17,82.62) 91.17,83.7 91.67,84.2 91.67,84.58 92.04,84.96 92.04,85.4 91.78,85.67 91.78,86.39 92.05,86.66 92.05,87.02 92.54,87.51 92.54,88.84 92.41,88.98 92.41,96.07 89.56,98.91 89.56,101.68 89.81,101.93 89.81,102.86 89.71,102.96 89.71,107.95 90.35,108.58 90.35,114.99 v2(91.41,116.05)
  BOTTOM w0.114: v3(110.11,118.75) 110.11,119.81 109.48,120.44 R930.1 ; v1(91.63,117.94) 91.92,117.64 91.92,116.56 v2(91.41,116.05)
BIOS_SPI_MOSI: length 54.1
  S5 w0.102: v2(108.84,106.3) 108.84,107.94 108.77,108.01 108.77,111.8 109.8,112.84 109.8,114.83 108.84,115.8 108.84,117.55 109.68,118.39 109.68,118.92 111.22,120.47 v3(111.76,120.47)
  S10 w0.102: v3(111.76,120.47) 113.16,119.07 113.16,116.86 v2(113.61,116.41)
  BOTTOM w0.114: R462.1 82.08,108.8 82.42,108.46 85.91,108.46 86.12,108.25 89.24,108.25 90.17,107.31 91.82,107.31 92.33,107.82 92.33,108.46 92.96,109.09 95.13,109.09 95.21,109.01 95.46,109.01 97.28,107.19 98.65,107.19 99.54,106.3 101.05,106.3 101.68,106.93 108.2,106.93 v2(108.84,106.3) ; R435.2 v2(113.61,116.41) ; R928.1 v3(111.76,120.47)
BIOS_SPI_MOSI_R: length 29.7
  TOP w0.114: U9.BL11 v4(90.67,86.91)
  S5 w0.102: v4(90.67,86.91) 90.92,86.91 91.57,87.55 91.57,87.99 91.26,88.29 91.26,91.46 90.73,91.99 90.73,92.93 90.02,93.63 90.02,93.76 85.15,98.63 83.88,98.63 81.58,100.93 81.58,106.03 80.9,106.71 80.9,107.44 v2(80.39,107.95)
  BOTTOM w0.114: v2(80.39,107.95) 80.59,108.15 R462.2 80.31,109.08 v1(80.31,109.96)
BIOS_SPI_WP_N: length 11
  TOP w0.114: v2(100.05,115.8) 100.85,115.8 101.52,115.13 U1.3
  BOTTOM w0.114: v1(94.43,115.47) R440.2 94.64,114.41 95.37,115.13 U31.3
  BOTTOM w0.127: U31.3 96.74,115.13 97.41,115.8 v2(100.05,115.8)
BIST_ENABLE: length 30.8
  TOP w0.108: U9.AM69 98.4,60.58 98.11,60.87 v4(98.1,60.87)
  TOP w0.114: R308.2 v2(96.72,36.83)
  S10 w0.102: v2(96.72,36.83) 96.34,36.83 95.86,37.31 95.86,39.04 95.07,39.83 95.07,45.26 95.22,45.42 95.22,56.11 97.28,58.17 97.28,58.72 97.51,58.95 97.51,59.36 97.23,59.64 97.23,60.3 97.8,60.87 v4(98.1,60.87)
  BOTTOM w0.114: v1(98.12,35.1) 98.11,35.11 98.09,35.11 96.72,36.47 v2(96.72,36.83)
BMC_BTN_LOCKED_N: length 32
  TOP w0.114: R341.2 v2(11.06,20.77)
  BOTTOM w0.114: CONN14.184 11.67,21.38 v2(11.06,20.77) 9.5,19.21 9.5,13.55 9.61,13.44 9.63,13.44 10.16,12.9 16.87,12.9 21.26,8.51 22.83,8.51 23.97,9.65 v1(27.53,9.65)
BMC_FAULT_LED: length 215.3
  TOP w0.114: U12.P6 v3(193.09,48.61) ; R513.1 v2(8.28,23.31) R336.1
  S3 w0.102: v2(97.37,17.92) 96.97,17.92 93.27,14.22 87.34,14.22 85.95,12.83 79.91,12.83 79.49,13.25 76.76,13.25 75.54,14.46 70.38,14.46 69.86,13.94 55.86,13.94 55.05,13.13 51.64,13.13 50.83,13.94 48.25,13.94 47.01,15.19 43.92,15.19 41.1,18.01 31.04,18.01 30.66,17.63 22.67,17.63 20.99,19.3 10.91,19.3 8.81,21.4 8.81,22.77 v2(8.28,23.31)
  S8 w0.102: v2(97.37,17.92) 99.26,17.92 99.98,18.64 104.24,18.64 104.55,18.95 106.65,18.95 111.15,23.44 147.48,23.44 149.9,25.86 160.3,25.86 163.37,28.93 180.93,28.93 185.09,33.09 185.09,40.3 185.5,40.7 185.5,40.74 190.75,46 190.75,46.98 191.65,47.88 192.63,47.88 193.09,48.33 v3(193.09,48.61)
  BOTTOM w0.114: v3(193.09,48.61) 193.09,48.13 v1(192.28,47.32)
BMC_ID_BTN: length 221.5
  TOP w0.114: R327.2 v2(8.28,28.39) ; U12.M4 v3(191.09,50.61)
  S3 w0.102: v2(8.28,28.39) 9.73,26.94 9.73,22.72 11.09,21.36 11.61,21.36 12.7,20.27 31.98,20.27 33.17,21.46 34.9,21.46 35.59,20.78 39.62,20.78 44.3,16.1 47.38,16.1 48.63,14.86 67.32,14.86 67.93,15.47 71.86,15.47 72.52,16.13 72.96,16.13 73.21,16.38 76.54,16.38 76.87,16.05 80.6,16.05 82.91,13.74 85.57,13.74 86.96,15.14 87.48,15.14 90.76,18.42 93.77,18.42 95.17,19.81 v2(97.34,19.81)
  S8 w0.102: v3(191.09,50.61) 191.07,50.61 190.63,51.05 188.5,51.05 184.69,47.25 184.56,47.11 184.56,41.06 184.18,40.68 184.18,33.47 180.55,29.84 163,29.84 162.59,29.44 162.46,29.31 159.92,26.77 149.52,26.77 147.1,24.36 110.76,24.36 106.26,19.86 104.17,19.86 104.13,19.82 97.35,19.82 v2(97.34,19.81)
  BOTTOM w0.114: v1(188.87,49.2) 189.76,50.09 190.57,50.09 v3(191.09,50.61)
BMC_ID_LED: length 216.1
  TOP w0.114: R514.1 v2(8.28,22.04) R338.1 ; U12.N7 v3(194.09,49.61)
  S3 w0.102: v2(98.22,17.45) 96.82,17.45 93.36,14 87.44,14 86.04,12.6 79.69,12.6 79.34,12.95 76.73,12.95 76.14,13.55 71.34,13.55 71.25,13.64 55.88,13.64 55.14,12.9 51.54,12.9 50.73,13.72 48.16,13.72 46.91,14.96 43.82,14.96 41,17.78 31.14,17.78 30.76,17.4 22.57,17.4 20.9,19.08 10.78,19.08 8.28,21.58 v2(8.28,22.04)
  S8 w0.102: v2(98.22,17.45) 99.11,17.45 99.54,17.88 100.08,18.41 104.34,18.41 104.64,18.72 106.75,18.72 110,21.97 110.19,21.97 114.18,21.97 114.63,22.43 121.25,22.43 122.03,23.22 147.58,23.22 149.58,25.22 160.06,25.22 163.54,28.7 181.03,28.7 185.32,32.99 185.32,40.2 185.72,40.61 185.72,40.64 190.98,45.9 190.98,46.88 191.75,47.65 192.74,47.65 193.26,48.18 193.27,48.18 193.52,48.43 193.52,48.44 193.55,48.46 193.55,48.79 194.09,49.33 v3(194.09,49.61)
  BOTTOM w0.114: v1(195.99,49.28) 195.83,49.12 195.71,49.12 195.66,49.07 194.63,49.07 v3(194.09,49.61)
BMC_LOCK_BTN: length 217.4
  TOP w0.114: R341.1 v2(8.28,20.77) R512.1 ; U12.P7 v3(194.09,48.61)
  S3 w0.102: v2(8.28,20.77) 10.2,18.85 19.19,18.85 21.73,16.31 24.71,16.31 25.17,15.84 30.07,15.84 31.06,16.84 34.73,16.84 35.39,17.5 40.96,17.5 43.73,14.73 46.82,14.73 48.06,13.49 50.64,13.49 51.63,12.5 57.01,12.5 57.09,12.42 68.99,12.42 69.13,12.57 71.72,12.57 71.83,12.67 79.22,12.67 79.52,12.37 86.13,12.37 87.53,13.77 93.46,13.77 96.68,16.99 v2(97.37,16.99)
  S8 w0.102: v3(194.09,48.61) 194.05,48.61 192.86,47.42 191.84,47.42 191.21,46.79 191.21,45.77 185.55,40.11 185.55,33.45 185.81,33.18 185.95,33.04 185.95,32.31 181.74,28.09 176.12,28.09 174.6,26.57 170.21,26.57 168.55,24.91 150.08,24.91 148.15,22.99 122.13,22.99 121.34,22.2 114.73,22.2 114.27,21.74 110.1,21.74 106.84,18.49 104.74,18.49 104.43,18.19 100.17,18.19 99.77,17.78 98.98,16.99 v2(97.37,16.99)
  BOTTOM w0.114: v3(194.09,48.61) 194.36,48.34 194.36,46.58 194.03,46.25 v1(194.03,45.59)
BMC_NMI_BTN: length 220.8
  TOP w0.114: R332.1 v2(8.28,24.58) R511.1 ; U12.M8 v3(195.09,50.61)
  S3 w0.102: v2(8.28,24.58) 9.04,23.81 9.04,21.49 11,19.53 21.09,19.53 22.76,17.86 30.55,17.86 30.96,18.26 35.43,18.26 37.08,19.91 39.52,19.91 44.01,15.42 47.1,15.42 48.35,14.17 51.46,14.17 52.27,13.36 54.95,13.36 55.77,14.17 69.77,14.17 70.38,14.78 73.56,14.78 74.06,15.29 76.66,15.29 77.47,14.48 81.2,14.48 82.63,13.06 85.85,13.06 87.25,14.45 93.09,14.45 97.03,18.39 v2(98.2,18.39)
  S8 w0.102: v2(98.2,18.39) 99.41,18.39 99.89,18.87 104.15,18.87 104.45,19.18 106.54,19.18 111.04,23.67 147.39,23.67 149.8,26.09 160.21,26.09 163.15,29.03 163.28,29.16 180.84,29.16 184.86,33.18 184.86,40.39 185.27,40.8 185.27,40.8 185.27,40.84 190.53,46.1 190.53,47.07 191.61,48.16 192.55,48.16 192.66,48.26 192.66,48.79 193.02,49.15 193.55,49.15 193.66,49.26 193.66,49.79 193.98,50.11 194.59,50.11 v3(195.09,50.61)
  BOTTOM w0.114: v1(195.96,50.99) 195.58,50.61 v3(195.09,50.61)
BMC_PRESENT_BDX_GPIO17: length 301.3
  TOP w0.114: v2(98.73,92.53) 98.73,91.69 98.35,91.31 U9.AN3 ; v2(191.04,74) 191.67,73.38 191.67,71.22 194.68,68.21 194.68,63.02 U12.A8
  S3 w0.102: v2(22.83,80.06) 22.83,76.66 26.14,73.36 26.14,71.06 26.39,70.81 26.75,70.81 27.53,70.02 27.53,68.94 v2(26.87,68.28) ; v2(98.73,92.53) 97.13,94.13 97.13,96.94 96.8,97.27 96.8,105.66 v3(97.71,106.58) 98.49,107.35 101.35,107.35 102.11,106.59 102.11,101.47 102.33,101.25 105.06,101.25 105.32,100.99 111.89,100.99 112.39,100.48 113.3,100.48 115.19,98.59 115.19,96.51 121.34,90.36 125.66,90.36 130,86.02 130,85.24 133.24,81.99 135.5,81.99 136.4,81.1 148.91,81.1 153.12,76.89 v2(156.06,76.89)
  S5 w0.102: v2(22.83,80.06) 22.83,85.55 23.5,86.22 23.5,97.01 16.13,104.38 16.13,114.09 16.32,114.28 16.32,114.95 16.13,115.14 16.13,116.46 17.93,118.26 24.46,118.26 25.14,118.93 30.52,118.93 30.56,118.97 35.88,118.97 36.02,118.84 36.47,118.39 36.74,118.26 38.61,118.26 39.11,117.75 44.23,117.75 44.91,118.44 51.22,118.44 51.83,119.05 74.26,119.05 74.88,118.43 74.88,118.4 75.15,118.14 75.53,118.14 75.55,118.16 79.26,118.16 79.34,118.08 87.1,118.08 87.86,118.85 90.66,118.85 95.76,113.75 95.76,111.01 97.84,108.93 97.84,108.25 97.71,108.13 v3(97.71,106.58)
  S8 w0.102: v2(191.04,74) 183.33,74 173.86,83.47 173.86,83.61 171.01,86.46 168.66,86.46 165.63,83.43 165.63,81.11 161.41,76.89 v2(156.06,76.89)
  BOTTOM w0.114: v1(99.49,92.81) 99.21,92.53 v2(98.73,92.53) ; v2(26.87,68.28) 26.87,68.37 26.38,68.86 R913.1
BMC_PWR_BTN: length 217.5
  TOP w0.114: R331.1 v2(8.28,25.85) R510.1 ; U12.P5 v3(192.09,48.61)
  S3 w0.102: v2(8.28,25.85) 9.27,24.86 9.27,21.59 11.09,19.76 21.18,19.76 22.86,18.08 30.45,18.08 30.86,18.49 35.34,18.49 36.99,20.14 39.61,20.14 44.11,15.65 47.2,15.65 48.44,14.4 69.67,14.4 70.28,15.01 73.46,15.01 74,15.54 80.46,15.54 82.72,13.28 85.76,13.28 87.15,14.68 92.33,14.68 96.49,18.85 v2(97.37,18.85)
  S8 w0.102: v2(97.37,18.85) 99.47,18.85 99.73,19.1 104.05,19.1 104.36,19.41 106.45,19.41 110.95,23.9 147.29,23.9 149.71,26.31 160.11,26.31 162.92,29.12 163.05,29.25 163.18,29.39 180.74,29.39 184.63,33.28 184.63,40.49 185.04,40.89 185.04,40.97 189.59,45.52 189.59,46.89 190.74,48.04 191.17,48.04 191.74,48.61 v3(192.09,48.61)
  BOTTOM w0.114: v1(190.83,47.5) 191.94,48.61 v3(192.09,48.61)
BMC_READY_CPU_ENABLE: length 273.5
  TOP w0.114: U12.R11 198.6,48.11 v3(199.09,47.62) ; v3(23.47,32.13) 23.77,32.44 28.73,32.44 29.26,32.97 29.26,38.38 29.9,39.01 29.9,45.16 30.66,45.92 v2(31.32,45.92)
  S10 w0.102: v3(91.74,19.89) 88.44,19.89 87.5,20.83 81.86,20.83 81.08,21.62 76.43,21.62 75.11,22.94 68.45,22.94 66.34,20.83 64.29,20.83 63.47,20.02 60.31,20.02 59.78,19.48 55.88,19.48 55.14,20.22 42.32,20.22 38.56,16.46 28.63,16.46 25.81,19.28 25.81,29.79 v3(23.47,32.13)
  BOTTOM w0.114: R952.1 30.3,45.97 R953.1 v2(31.32,45.92) 31.45,46.05 v1(31.45,46.81) ; v3(91.74,19.89) 93.98,19.89 95.12,21.03 95.12,26.87 101.27,33.02 101.27,35.92 102.57,37.21 108.51,37.21 109.19,37.9 112.94,37.9 113.53,37.31 113.67,37.31 114.91,36.07 130.05,36.07 135.2,41.22 135.2,57.05 140.45,62.29 149.16,62.29 151.01,60.44 158.75,60.44 160.92,58.27 176.26,58.27 177.52,59.54 179.96,59.54 181.52,57.98 181.52,43.66 182.15,43.02 189.25,43.02 190.85,41.43 193.68,41.43 194.87,42.62 194.87,43.76 194.48,44.15 194.48,45.13 194.94,45.59 195.25,45.59 197.76,48.11 198.73,48.11 199.09,47.75 v3(199.09,47.62)
BMC_READY_CPU_ENABLE_R: length 31.5
  S3 w0.102: v2(28.45,47.12) 27.81,47.75 27.81,50.8 24.38,54.23 22.61,54.23 18.92,57.91 18.92,64.01 17.15,65.78 v2(15.87,65.78)
  BOTTOM w0.114: v2(28.45,47.12) 28.37,47.19 v1(27.43,47.19) 27.99,46.63 29.03,46.63 R952.2 ; CONN14.44 v2(15.87,65.78)
BMC_RST_BTN: length 219.5
  TOP w0.114: U12.M3 v3(190.09,50.61) ; R329.1 v2(8.28,27.12) R504.1
  S3 w0.102: v2(8.28,27.12) 9.5,25.9 9.5,21.68 11.19,19.99 21.28,19.99 22.95,18.31 30.36,18.31 30.77,18.72 35.24,18.72 36.89,20.37 39.71,20.37 44.2,15.88 47.29,15.88 48.53,14.63 67.41,14.63 68.02,15.24 73.37,15.24 73.9,15.77 80.56,15.77 82.82,13.51 85.66,13.51 87.06,14.91 87.57,14.91 90.85,18.19 93.87,18.19 95.03,19.35 v2(98.15,19.35)
  S8 w0.102: v2(98.15,19.35) 98.17,19.33 103.96,19.33 104.27,19.63 106.35,19.63 110.85,24.13 147.2,24.13 149.61,26.54 160.02,26.54 162.69,29.21 162.69,29.22 162.82,29.35 163.09,29.62 180.65,29.62 184.4,33.37 184.4,40.58 184.78,40.96 184.78,47.02 188.38,50.61 v3(190.09,50.61)
  BOTTOM w0.114: v3(190.09,50.61) 189.97,50.5 v1(188.87,50.5)
BMC_SPI_CLK: length 178.4
  S8 w0.102: v2(110.49,115.7) 110.36,115.57 109.6,115.57 108.46,116.71 102.36,116.71 100.53,118.54 98.63,118.54 96.32,120.85 49.25,120.85 43.69,115.29 37.46,115.29 29.48,107.31 22.2,107.31 11.14,96.25 11.14,49.65 19.68,41.1 v2(19.68,36.08)
  BOTTOM w0.114: CONN14.135 v2(19.68,36.08) ; R925.1 v2(110.49,115.7)
BMC_SPI_CLK_R: length 3.9
  TOP w0.114: U43.5 110.34,113.01 v2(110.36,113.03)
  BOTTOM w0.114: R925.2 110.49,113.16 v2(110.36,113.03) 110.24,112.9 v1(110.24,111.38)
BMC_SPI_CS0: length 6.6
  TOP w0.114: U42.1 103.97,118.1 104.8,117.27 104.8,116.99 105.51,116.28 106.07,116.28 R951.2 107.79,116.26 v2(108.21,115.83)
  BOTTOM w0.114: v2(108.21,115.83) 108.33,115.72 R923.1
BMC_SPI_CS0_R: length 3.5
  TOP w0.114: v2(108.46,113.03) 108.39,112.97 U43.2
  BOTTOM w0.114: v1(107.82,112.01) 107.82,112.39 v2(108.46,113.03) 108.46,113.49 108.33,113.62 R923.2
BMC_SPI_CS1: length 17.7
  TOP w0.114: U42.3 v3(104.5,119.4) ; U44.3 108.44,107.55 108.71,107.82 108.71,109.22 108.46,109.47 105.92,109.47 v2(105.79,109.6) 105.94,109.75 R950.2
  S5 w0.102: v3(104.5,119.4) 104.01,118.91 104.01,113.16 105.03,112.14 105.03,110.36 v2(105.79,109.6)
BMC_SPI_CS_N: length 176.4
  TOP w0.114: U42.4 v3(102.6,119.4)
  S8 w0.102: v3(102.6,119.4) 101.6,120.4 99.36,120.4 98.21,121.54 42.49,121.54 39.88,118.93 39.88,118.35 37.64,116.11 35.48,116.11 35.19,116.05 35.07,116 33.14,116 31.95,114.81 21.2,114.81 15.75,109.36 15.75,105.09 10.45,99.79 10.45,49.37 18.03,41.78 v2(18.03,36.68)
  BOTTOM w0.114: v1(101.73,119.63) 102.36,119.63 v3(102.6,119.4) ; CONN14.133 v2(18.03,36.68)
BMC_SPI_DI: length 188.9
  S8 w0.102: v2(19.39,34.88) 19.04,35.23 18.61,35.23 18.21,35.62 18.21,36.21 18.49,36.49 18.49,41.65 10.68,49.46 10.68,99.7 16,105.02 16,109.29 21.27,114.55 33.59,114.55 34.79,115.75 35.06,115.75 35.26,115.83 35.5,115.88 37.73,115.88 40.11,118.26 40.11,118.83 42.58,121.31 98.12,121.31 99.41,120.02 100.33,120.02 102.18,118.16 105.34,118.16 106.93,119.75 v3(106.93,120.47)
  BOTTOM w0.114: v2(19.39,34.88) CONN14.139 26.22,34.88 v1(27.15,35.81) ; R929.1 v3(106.93,120.47)
BMC_SPI_DI_R: length 2.4
  TOP w0.114: v3(108.46,118.75) 108.84,118.36 108.93,118.36 109.04,118.25 U43.14
  BOTTOM w0.114: v3(108.46,118.75) 108.46,118.81 108.13,119.14 R929.2
BMC_SPI_DO: length 190.3
  S8 w0.102: v3(110.24,120.34) 108.62,120.34 106.21,117.93 101.52,117.93 99.95,119.51 99.27,119.51 97.7,121.08 43.9,121.08 38.34,115.52 34.88,115.52 33.41,114.05 21.08,114.05 16.51,109.47 16.51,105.2 10.91,99.6 10.91,49.56 18.72,41.74 18.72,36.4 18.67,36.35 v2(18.67,35.81)
  BOTTOM w0.114: v2(18.67,35.81) 19,35.48 CONN14.137 25.07,35.48 v1(27.1,37.52) ; R927.1 v3(110.24,120.34)
BMC_SPI_DO_R: length 1.9
  TOP w0.114: v3(110.92,118.75) 110.99,118.67 U43.11
  BOTTOM w0.114: R927.2 111,118.83 v3(110.92,118.75)
BMC_SPI_OUT_SEL: length 179.1
  TOP w0.114: v3(102.11,115.82) 101.92,116.01 U42.6 100.92,118.1 R922.2
  S8 w0.102: v2(20.04,34.28) 20.14,34.38 20.14,40.97 11.36,49.75 11.36,96.16 22.27,107.06 29.94,107.06 37.94,115.07 43.82,115.07 49.38,120.62 96.04,120.62 100.84,115.82 v3(102.11,115.82)
  BOTTOM w0.114: v1(27.08,34.39) 26.96,34.28 CONN14.141 v2(20.04,34.28)
BMC_UART0_DIR_SEL: length 297.2
  TOP w0.114: v2(183.58,44.76) 181.98,46.36 181.98,51.11 182.98,52.12 186.85,52.12 187.3,51.67 189.15,51.67 U12.L2
  S3 w0.102: v2(26.82,69.5) 26.56,69.5 24.56,71.5 16.92,71.5 14.76,69.34 14.76,67.54 v2(15.11,67.18)
  S5 w0.102: v2(15.11,67.18) 10.72,62.79 10.72,34.9 14.46,31.16 14.46,15 21.84,7.63 21.84,3.67 23.88,1.62 59.92,1.62 61.53,3.23 61.66,3.37 62.08,3.37 63.23,4.52 65.57,4.52 66.36,3.73 67.26,3.73 67.72,4.19 72.39,4.19 72.69,3.89 77.56,3.89 77.61,3.84 83.61,3.84 88.88,9.1 94.2,9.1 94.86,9.76 94.86,11.94 95.95,13.03 95.95,20.77 97.44,22.26 v2(98.7,22.26)
  S8 w0.102: v2(98.7,22.26) 98.7,24.08 99.75,25.14 99.89,25.27 146.72,25.27 149.14,27.69 157.79,27.69 161.27,31.16 164.43,31.16 165.03,31.75 166.37,31.75 166.93,31.19 170.42,31.19 171.3,32.07 171.3,34.64 171.94,35.29 173.82,35.29 175.51,36.98 176.07,37.54 176.07,41.71 177.93,43.57 182.39,43.57 v2(183.58,44.76)
  BOTTOM w0.114: v2(183.58,44.76) v1(184.58,44.76) R152.2 ; v2(26.82,69.5) 26.49,69.82 R912.1
BMC_UART0_DIR_SEL_R: length 12.4
  S3 w0.102: v2(16.74,69.55) 17.2,70 17.91,70 18.32,70.41 22.57,70.41 22.98,70 v2(23.52,70)
  BOTTOM w0.114: v2(16.74,69.55) 16.3,69.98 CONN14.30 ; v2(23.52,70) 24.87,70 R912.2
BMC_UART0_RX: length 24.6
  TOP w0.114: R315.2 v2(11.06,30.93)
  S10 w0.102: v2(11.06,30.93) 13.87,28.12 18.03,28.12 v2(19.07,27.08)
  BOTTOM w0.114: v1(29.57,31.93) 29.36,31.72 25.1,31.72 24.31,30.94 24.31,28.28 23.1,27.08 CONN14.165 v2(19.07,27.08)
BMC_UART0_TX: length 22
  TOP w0.114: R321.2 v2(11.06,29.66)
  S10 w0.102: v2(11.06,29.66) 13.67,27.05 v2(18.24,27.05)
  BOTTOM w0.114: v2(18.24,27.05) 18.87,27.68 CONN14.163 23.1,27.68 23.83,28.4 23.83,31.52 24.64,32.33 v1(27.1,32.33)
BMC_UART1_RX: length 39.8
  TOP w0.114: R539.1 v2(11.06,32.2)
  S5 w0.102: v2(16.66,9.32) 13.78,12.2 13.78,25.87 11.76,27.88 8.02,27.88 7.6,28.3 7.6,31.29 7.93,31.63 9.02,31.63 9.59,32.2 v2(11.06,32.2)
  BOTTOM w0.114: CONN14.166 12.15,26.78 11.59,27.34 11.59,31.67 v2(11.06,32.2)
BMC_UART1_TX: length 44.1
  TOP w0.114: R378.1 v2(11.06,33.47)
  S5 w0.102: v2(17.72,8.32) 16.9,8.32 13.55,11.67 13.55,25.17 12.19,26.53 7.83,26.53 7.13,27.23 7.13,31.9 8.09,32.86 10.46,32.86 v2(11.06,33.47)
  BOTTOM w0.114: v2(11.06,33.47) 11.99,32.54 11.99,27.86 12.47,27.38 CONN14.164
BMCINIT: length 21.9
  TOP w0.108: v4(103.05,60.86) 102.77,60.58 U9.AD69
  TOP w0.114: R291.1 v2(105.46,43)
  S10 w0.102: v2(105.46,43) 104.95,43.51 104.95,52.68 103.4,54.23 103.4,58.83 103.45,58.88 103.45,59.92 103.66,60.12 103.66,60.48 103.28,60.86 v4(103.05,60.86)
  BOTTOM w0.114: v2(105.46,43) 106.1,42.37 v1(106.1,41.91)
BMM_MB_ID0: length 23.9
  TOP w0.114: R317.2 v2(16.88,30.59) R318.1
  BOTTOM w0.114: v2(16.88,30.59) 17.14,30.85 17.14,33.66 16.27,34.53 16.27,39.98 17.76,41.47 17.96,41.47 19.69,41.47 20.3,42.08 CONN14.115 22.9,42.08 23.11,42.29 26.49,42.29 v1(27.41,41.38)
BMM_MB_ID1: length 24.7
  TOP w0.114: R323.1 v2(16.86,29.57) R322.2
  BOTTOM w0.114: v1(27.41,39.95) 26.06,41.3 22.86,41.3 22.68,41.48 CONN14.117 20.18,41.48 19.93,41.23 17.86,41.23 16.51,39.88 16.51,34.63 17.39,33.76 17.39,30.44 17.02,30.07 17.02,29.74 v2(16.86,29.57)
BMM_SCL1: length 3.9
  BOTTOM w0.114: CONN14.61 23.57,60.68 v1(24.16,61.26) 24.25,61.36 R581.1
BMM_SCL2: length 12.9
  S10 w0.102: v2(15.11,61.19) 21.29,61.19 22.86,62.76 23.43,62.76 23.91,63.25 v2(24.38,63.25)
  BOTTOM w0.114: R576.1 24.79,63.65 v2(24.38,63.25) ; v2(15.11,61.19) 14.9,60.98 CONN14.60
BMM_SCL3: length 7.8
  BOTTOM w0.114: CONN14.67 23.47,58.88 v1(24.13,59.54) 24.21,59.61 24.43,59.61 24.69,59.87 27.05,59.87 27.37,59.55 27.37,58.51 27.69,58.18 U40.3
BMM_SCL4: length 62.1
  S5 w0.102: v2(15.67,59.18) 18.03,61.54 18.03,76.34 11.84,82.54 11.84,87.24 12.43,87.83 13.28,87.83 14,87.12 v2(14,85.8)
  BOTTOM w0.114: R786.1 14.76,87.74 14,86.97 v2(14,85.8) ; CONN14.66 v2(15.67,59.18) 16.69,59.18 19,56.87 19.32,56.87 19.36,56.83 22.15,56.83 24.6,54.38 24.6,48.94 24.8,48.74 24.8,48.09 27.38,45.52 v1(27.38,45.49)
BMM_SCL5: length 42.9
  S5 w0.102: v2(12.62,86.94) 13.23,86.33 13.23,82.11 18.72,76.62 18.72,61.26 18.52,61.05 18.52,56.49 v2(20.12,54.89)
  BOTTOM w0.114: R791.1 14.66,89.61 13.34,88.29 v1(12.01,88.29) 12.01,87.55 v2(12.62,86.94) ; CONN14.73 20.33,54.68 v2(20.12,54.89)
BMM_SDA1: length 3.7
  BOTTOM w0.114: CONN14.63 23.37,60.08 23.49,60.2 24.6,60.2 24.77,60.37 R585.1
BMM_SDA2: length 12.8
  S10 w0.102: v2(24.34,62.38) 22.98,62.38 20.75,60.15 v2(15.14,60.15)
  BOTTOM w0.114: v2(15.14,60.15) 14.91,60.38 CONN14.62 ; R579.1 v2(24.34,62.38)
BMM_SDA3: length 2.8
  BOTTOM w0.114: CONN14.69 24.36,58.28 U41.3
BMM_SDA4: length 64.7
  S5 w0.102: v2(14.96,84.84) 13.79,84.84 13.46,85.17 13.46,87.33 13.18,87.6 12.52,87.6 12.06,87.15 12.06,82.63 18.26,76.44 18.26,61.45 18.06,61.24 18.06,60.4 v2(15.65,57.99)
  BOTTOM w0.114: v2(14.96,84.84) 14.96,86.02 R788.1 ; v1(27.38,44.15) 26.16,45.36 26.16,46.39 24.56,47.99 24.56,48.64 24.36,48.84 24.36,54.28 22.05,56.59 19.26,56.59 19.23,56.62 18.75,56.62 17.37,57.99 v2(15.65,57.99) 15.05,58.58 CONN14.68
BMM_SDA5: length 56.5
  S5 w0.102: v2(20.12,53.8) 18.29,55.63 18.29,61.15 18.49,61.35 18.49,76.53 12.73,82.3 v2(12.73,85.65)
  BOTTOM w0.114: R792.1 14.79,88.68 13.31,87.2 13.31,86.23 v2(12.73,85.65) ; v1(27.36,42.85) 25.15,45.06 25.15,46.99 24.3,47.83 24.3,48.56 24.12,48.74 24.12,53.89 23.92,54.08 CONN14.75 20.4,54.08 v2(20.12,53.8)
C33_BDX_PWRGOOD_CPU: length 30.3
  TOP w0.114: U12.H4 v3(191.09,55.61) ; U10.20 174.15,73.75 v2(174.35,73.94)
  S3 w0.102: v2(174.35,73.94) 175.84,72.44 178.85,72.44 184.99,66.3 184.99,60.75 189.66,56.08 190.61,56.08 v3(191.09,55.61)
  BOTTOM w0.114: v1(174.35,72.92) v2(174.35,73.94)
C33_P1V05_PCH_EN: length 164.8
  TOP w0.114: R387.2 v2(67.69,4.88) ; U12.P10 v3(198.09,48.61)
  S3 w0.102: v2(67.69,4.88) 68.38,4.19 81.19,4.19 88.48,11.48 97.61,11.48 101.36,15.24 v2(101.36,15.55)
  S8 w0.102: v2(101.36,15.55) 101.7,15.9 105.38,15.9 105.69,16.21 112.16,16.21 112.24,16.28 125.51,16.28 125.9,15.9 141.98,15.9 143.7,14.17 147.39,14.17 153.1,19.89 162.65,19.89 163.59,20.83 168.68,20.83 169.1,21.25 172.25,21.25 172.68,20.83 174.15,20.83 179.08,25.76 183.1,25.76 188.65,31.31 188.65,36.83 194.23,42.41 194.23,43.34 194.91,44.02 195.77,44.02 196.22,44.47 196.63,44.47 197.41,45.25 197.41,47.93 v3(198.09,48.61)
  BOTTOM w0.114: v2(67.69,4.88) v1(67.69,5.82) 67.69,7.19 68.66,8.16 R734.1 R735.1
C33_P1V5_PCH_EN: length 67.4
  TOP w0.114: U12.G1 186.81,56.11 185.56,57.36 171.88,57.36 168.65,60.58 140.82,60.58 135.81,65.58 135.81,69.77 135.16,70.43 v2(134.52,70.43)
  TOP w0.127: U11.5 v2(134.52,70.43)
  BOTTOM w0.114: C402.1 v2(134.52,70.43)
  BOTTOM w0.127: C402.1 R561.2
C33_PVCCKRHV_EN: length 64.3
  TOP w0.114: U12.H3 v3(190.09,55.61)
  TOP w0.127: U8.5 v2(145.04,71.51)
  S3 w0.102: v3(190.09,55.61) 189.04,55.61 184.76,59.89 184.76,66.21 180.99,69.98 170.92,69.98 169.04,71.86 166.92,71.86 165.09,73.69 162.49,73.69 161.98,73.17 161.98,70.28 161.16,69.47 158.51,69.47 158.12,69.09 157.62,69.09 156.63,70.08 146.47,70.08 v2(145.04,71.51)
  BOTTOM w0.127: v2(145.04,71.51) 144.74,71.21 R550.2 C332.1
C33_PVCCSCFUSESUS_EN: length 51.6
  TOP w0.114: U22.7 155.22,68.45 154.58,67.82 R692.1 153.41,68.15 153.28,68.28 151.64,68.28 v2(150.29,66.93) 150.29,62.64 151.82,61.11 168.88,61.11 172.1,57.89 187.14,57.89 187.92,57.11 U12.F1
C33_UART_BDX_B2B_RX0: length 185.4
  TOP w0.114: v2(173.78,59.46) 174.79,58.46 R842.2 ; v2(202.16,102.05) 203.89,102.05 205.05,103.22 CONN18.3 ; R871.1 v2(206.52,73.61)
  S3 w0.102: v2(206.52,73.61) 205.35,74.77 205.35,82.03 202.57,84.81 202.57,88.78 204.72,90.93 204.72,99.19 202.16,101.75 v2(202.16,102.05)
  S8 w0.102: v2(206.52,73.61) 203.76,70.85 202.41,70.85 200.25,73.01 179.53,73.01 175.55,76.99 171.45,76.99 170.62,76.16 170.62,72.19 173.64,69.17 175.22,69.17 177.89,66.5 178.07,66.5 178.56,66 178.56,61.72 177.03,60.2 174.52,60.2 v2(173.78,59.46)
  S10 w0.102: v2(173.78,59.46) 173.84,59.46 174.88,58.42 176.78,58.42 178.31,56.9 178.31,55.54 179.34,54.51 179.34,48.99 178.58,48.23 178.58,42.9 175.03,39.35 170.34,39.35 164.75,33.76 159.03,33.76 147.97,22.7 147.97,19.67 v2(148.46,19.18)
  BOTTOM w0.114: v2(148.46,19.18) 146.94,19.18 146.24,18.48 146.24,17.34 143.78,14.87 v1(143.78,14.07) 143.78,13.27 143.02,12.52 143.02,9.94 143.1,9.86 CONN16.63
C33_UART_BDX_B2B_TX0: length 185.9
  TOP w0.114: v2(171.4,73.83) 170.95,74.27 R844.2 ; R872.1 v2(206.53,72.59) ; CONN18.2 202.55,107.67 200.32,105.44 200.32,103.94 v2(201.31,102.95)
  S3 w0.102: v2(206.53,72.59) 205.12,74 205.12,81.93 202.29,84.77 202.29,88.82 204.5,91.03 204.5,99.03 201.31,102.22 v2(201.31,102.95)
  S8 w0.102: v2(171.4,73.83) 171.4,76.05 172.03,76.68 175.39,76.68 179.45,72.62 200.17,72.62 203.33,69.46 204.7,69.46 206.53,71.29 v2(206.53,72.59)
  S10 w0.102: v2(171.4,73.83) 172.17,73.83 173.23,72.77 177.04,72.77 178.54,71.27 178.54,66.76 178.31,66.54 178.31,66.26 178.56,66 178.56,65.62 178.31,65.37 178.31,58.88 178.54,58.65 178.54,55.64 179.58,54.61 179.58,48.9 178.82,48.13 178.82,42.8 175.13,39.12 170.43,39.12 164.85,33.53 159.13,33.53 148.21,22.61 148.21,20.45 v2(148.72,19.94)
  BOTTOM w0.114: v1(170.43,73.53) 171.11,73.53 v2(171.4,73.83) ; CONN16.75 140.1,8.66 140.59,9.14 140.59,13.09 140.48,13.2 140.48,13.57 140.88,13.97 141.42,13.97 141.42,13.96 142.49,13.96 145.87,17.34 145.87,18.52 147.29,19.94 v2(148.72,19.94)
C33_UART_BDX_CPLD_RX0: length 17
  TOP w0.114: U12.B1 187.95,61.75 186.71,61.75 185.1,63.36 181.73,63.36 180.95,62.58 180.95,59.69 179.72,58.46 v2(178.09,58.46) R662.2
  BOTTOM w0.114: v1(179.02,58.46) v2(178.09,58.46)
C33_UART_BDX_CPLD_TX0: length 27.4
  TOP w0.114: R870.2 173.48,76.71 v2(174.23,75.95) ; U12.A2 187.57,64.13 187.57,67.83 187.05,68.35 v3(186.53,68.35)
  S3 w0.102: v2(174.23,75.95) 174.51,75.68 178.41,75.68 185.73,68.35 v3(186.53,68.35)
  BOTTOM w0.114: v3(186.53,68.35) 186.85,68.67 v1(187.97,68.67)
C33_UART_BDX_RX0: length 6
  TOP w0.114: U13.7 175.2,61.54 175.04,61.38 v2(175.04,59.46) 175.13,59.36 R842.1 R662.1
  BOTTOM w0.114: v1(175.92,59.59) 175.79,59.46 v2(175.04,59.46)
C33_UART_BDX_RX1: length 323
  TOP w0.114: v2(175.58,61.03) 175.62,61.06 175.62,61.14 175.7,61.23 U13.8 ; R378.2 v2(8.35,33.47)
  BOTTOM w0.114: v2(175.58,61.03) 175.58,61.26 179.25,64.92 179.25,73.76 177.57,75.44 172.12,75.44 166.66,80.9 166.66,90.18 170.31,93.83 170.31,112.67 169.71,113.27 169.71,119.53 167.41,121.83 156.72,121.83 151.17,116.28 146.17,116.28 140.32,122.13 57.22,122.13 55.08,119.99 55.08,118.04 54.16,117.12 39.71,117.12 32.58,109.98 v1(32.58,109.41) 30.37,107.2 18.49,107.2 14.83,103.54 8.38,103.54 4.76,99.93 4.76,88.35 10.03,83.08 10.03,79.51 10.03,35.15 v2(8.35,33.47)
C33_UART_BDX_TX0: length 7.7
  TOP w0.114: R844.1 R870.1 v2(171.98,74.83) 174.8,74.83 175.15,74.48 U10.18
  BOTTOM w0.114: v1(171.05,74.83) v2(171.98,74.83)
C33_UART_BDX_TX1: length 307.7
  TOP w0.114: v2(171.88,77.67) 175.85,77.67 177.39,76.13 R552.1 ; R539.2 v2(8.35,32.2)
  BOTTOM w0.114: v2(171.88,77.67) 170.24,77.67 166.9,81 166.9,90.07 170.55,93.71 170.55,112.77 169.95,113.37 169.95,119.63 167.51,122.07 156.62,122.07 151.07,116.52 146.29,116.52 140.44,122.38 57.12,122.38 54.84,120.09 54.84,118.16 54.05,117.37 39.62,117.37 v1(30.82,108.57) 29.69,107.44 18.39,107.44 14.73,103.78 8.28,103.78 4.52,100.03 4.52,87.43 9.78,82.17 9.78,35.9 7.8,33.93 7.8,32.75 v2(8.35,32.2)
C33_UART_BDX_TX1_R: length 3.4
  TOP w0.114: U10.17 v2(175.65,74.49) 175.99,74.83 R552.2
  BOTTOM w0.114: v2(175.65,74.49) 175.87,74.7 v1(176.56,74.7)
C105_BDX_PWRGOOD_CPU: length 211.2
  TOP w0.114: v2(105.41,47.58) R252.2
  S5 w0.102: v2(47.65,5.05) 47.65,5.49 46.99,6.15 46.99,7.87 48.18,9.07 51.98,9.07 53.15,10.24 54.7,10.24 55.4,10.95 56.64,10.95 57.65,11.96 59.19,11.96 60.51,13.28 70.36,13.28 71.12,12.52 72.62,12.52 72.82,12.73 77.11,12.73 77.5,12.34 91.34,12.34 93.62,14.63 93.62,24.49 97.41,28.28 97.41,33.7 97.41,33.7 97.41,34.27 97.41,34.27 97.41,36.4 98.12,37.11 99.68,37.11 103.84,41.26 103.84,44.37 104.98,45.52 104.98,47.12 105.44,47.58 v2(105.41,47.58)
  S8 w0.102: v2(105.41,47.58) 105.41,47.58 105.92,48.08 105.92,50.13 106.31,50.52 110.13,50.52 110.18,50.47 110.37,50.47 110.64,50.2 110.64,50.09 112.92,47.8 115.87,47.8 116.41,47.27 117.81,47.27 119.84,49.3 121.69,49.3 122.38,49.99 122.38,50.64 123.68,51.94 124.33,51.94 128.67,56.29 129.06,56.29 129.54,56.76 155.43,56.76 155.91,56.29 165.11,56.29 169.39,60.57 169.39,82.93 v2(168.38,83.95)
  S10 w0.102: v2(47.65,5.05) 47.65,4.42 46.15,2.92 34.11,2.92 v2(33.27,2.08)
  BOTTOM w0.114: v2(33.27,2.08) 33.81,2.62 R776.2 ; R613.2 R615.1 105.33,47.5 v2(105.41,47.58) ; v2(168.38,83.95) R537.2 R538.1
C105_BDX_PWRGOOD_CPU_R: length 6.6
  TOP w0.114: v2(171.09,83.44) 170.69,83.04 R173.2
  BOTTOM w0.114: v1(167.47,83.19) 167.49,83.17 167.49,83.13 168.07,82.55 170.03,82.55 170.17,82.69 R173.2 170.69,83.04 v2(171.09,83.44) 171.2,83.55 U34.4
C105_CPU_PCH__R_PLTRST_N: length 87.5
  TOP w0.102: U9.L76 108.33,56.97 108.33,56.21 108.53,56 108.53,55.47 110.18,53.83
  TOP w0.114: 110.18,53.83 v2(110.18,52.45) R240.1
  BOTTOM w0.114: R517.1 81.7,91.25 v1(81.5,91.05) 78.97,88.52 78.97,81.2 79.71,80.47 83.06,80.47 83.29,80.24 83.29,79.81 83.64,79.45 83.64,79 83.27,78.63 83.27,78.2 83.71,77.77 83.71,77.27 83.33,76.89 83.33,76.3 83.77,75.86 83.77,75.56 83.24,75.03 83.24,74.75 82.8,74.32 82.8,73.89 82.3,73.38 82.3,73 82.75,72.54 82.75,72.11 82.27,71.63 82.27,71.35 82.75,70.87 82.75,70.48 82.3,70.03 82.3,69.6 82.75,69.14 82.75,68.71 82.27,68.22 82.27,67.87 82.73,67.41 82.73,66.88 82.25,66.4 82.25,66.14 82.73,65.66 82.73,65.38 83.13,64.97 83.44,64.97 83.54,65.07 83.95,65.07 84,65.02 85.12,65.02 85.39,64.74 85.6,64.74 85.78,64.57 85.78,64.11 86.28,63.6 86.28,63.14 86.64,62.79 86.64,62.48 86.94,62.18 93.42,62.18 93.62,62.38 93.62,62.74 93.88,62.99 94.61,62.99 94.84,62.76 96.6,62.76 96.89,63.06 97.41,63.06 97.59,62.88 97.59,60.68 98.09,60.17 98.09,59.82 98.32,59.59 100.3,59.59 100.61,59.28 100.61,58.83 100.48,58.7 100.48,56.29 99.77,55.58 99.77,54.51 99.26,54 99.26,53.62 99.59,53.29 100.13,53.29 101.3,54.46 103.81,54.46 104.1,54.17 104.44,54.17 104.83,54.56 108.88,54.56 110.18,53.27 v2(110.18,52.45)
C105_CPU_PCH_PLTRST_N: length 206.1
  TOP w0.114: R240.2 v2(110.18,50.01)
  S5 w0.102: v2(36.45,12.01) 37.06,12.62 38.15,12.62 38.71,12.06 48.11,12.06 48.54,12.5 55.18,12.5 57.34,14.66 69.59,14.66 70.4,15.47 72.34,15.47 73.68,14.12 77.23,14.12 79.13,16.03 80.47,16.03 80.85,16.03 80.85,16.03 80.94,16.03 83.25,13.72 85.75,13.72 89.69,17.65 89.69,18.22 90.58,19.11 90.58,23.45 92.81,25.69 92.81,30.8 93.31,31.3 93.6,31.59 93.6,41.22 94.41,42.03 94.41,46.51 95.89,47.99 95.89,49.68 96.67,50.47 97.31,50.47 98.35,51.51 108.68,51.51 v2(110.18,50.01)
  S8 w0.102: v2(110.18,50.01) 110.39,50.01 112.83,47.57 115.72,47.57 116.74,46.56 119.27,46.56 122.61,49.9 122.61,50.54 123.78,51.71 124.42,51.71 128.77,56.06 129.15,56.06 129.63,56.54 155.34,56.54 155.82,56.06 165.21,56.06 169.62,60.47 169.62,85.45 v2(169.32,85.75)
  BOTTOM w0.114: R536.1 v2(169.32,85.75) ; R736.1 36.37,11.94 v2(36.45,12.01)
