# Allegro board 142000001998AR0A-B-0515.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SML1_DATA_R: length 30.6
  TOP w0.114: U9.BB11 93.76,86.82 v4(93.56,86.82) ; R789.1 v2(92.33,111.66)
  S10 w0.102: v2(92.33,111.66) 92.89,111.1 92.89,106.09 96.72,102.25 96.72,96.08 96.46,95.81 96.43,95.81 94.55,93.93 94.55,88.24 94.03,87.71 94.03,87.29 v4(93.56,86.82)
  BOTTOM w0.114: v1(93.17,111.26) 92.78,111.66 v2(92.33,111.66)
SMP_TESTDDR01_VIEWDIG0: length 12.8
  TOP w0.114: U9.CU76 77.82,57.25 77.47,57.6 77.02,57.6 76.63,57.99 76.12,57.99 75.77,58.34 70.86,58.34 v3(69.52,59.68) 69.52,60.99 69.01,61.49 R211.1
  BOTTOM w0.114: v1(69.8,60.55) 69.52,60.27 v3(69.52,59.68)
SMP_TESTDDR01_VIEWDIG1: length 16.1
  TOP w0.114: U9.CM78 79.55,55.22 ; v3(68.76,59.68) 68.73,59.71 R215.1
  TOP w0.127: v3(68.76,59.68) 70.45,57.99 75.13,57.99 76.02,57.1 76.02,55.8 76.61,55.22 79.55,55.22
  BOTTOM w0.114: v1(68.53,60.55) 68.76,60.33 v3(68.76,59.68)
SOC_FPGA_CLK: length 126.1
  TOP w0.114: R51.2 v2(102.03,111.18) ; U12.C3 v3(190.09,60.61)
  S3 w0.102: v3(190.09,60.61) 189.64,61.06 189.64,63.62 188.62,64.64 188.62,69.29 170.89,87.02 170.89,96.56 165.85,101.6 163.09,101.6 160.5,99.01 156.99,99.01 155.7,97.71 134.19,97.71 133.78,97.31 130.94,97.31 130.51,96.88 122.32,96.88 117.12,102.08 116.47,102.08 115.06,103.49 115.06,103.58 111.01,107.63 108.42,107.63 107.47,108.58 107.45,108.58 105.6,110.44 102.77,110.44 v2(102.03,111.18)
  BOTTOM w0.114: v2(102.03,111.18) R51.2 102.8,110.44 103.01,110.23 v1(103.06,110.23)
SOC_FPGA_CLK_R: length 45.8
  TOP w0.114: R51.1 v2(102.03,108.81)
  TOP w0.254: v4(94.35,81.21) 94.35,81.22 94.36,81.23 94.36,81.24 94.71,81.59 U9.BA23
  S5 w0.102: v2(102.03,108.81) 101.7,108.48 101.7,107.27 100.56,106.13 100.56,105.56 100.58,105.53 100.58,104.58 94.41,98.41 94.41,93.39 95.83,91.97 99.33,91.97 101.95,89.36 101.95,88.94 101.68,88.67 101.68,88.11 101.95,87.84 101.95,85.86 101.69,85.6 101.41,85.6 100.3,84.49 100.3,82.91 99.57,82.17 99.57,81.07 99.31,80.81 94.75,80.81 v4(94.35,81.21)
  BOTTOM w0.114: v1(102.97,107.66) 102.03,108.6 v2(102.03,108.81)
SOC_FPGA_DIN: length 137.9
  TOP w0.114: U12.E3 v3(190.09,58.61) ; R54.2 v2(96.24,111.25)
  S3 w0.102: v2(96.24,111.25) 97.76,109.73 102.62,109.73 103.05,109.3 103.06,109.3 103.33,109.03 103.33,108.64 104.68,107.29 107.8,107.29 108.28,106.8 109.48,106.8 109.8,106.48 109.8,105.28 111.46,103.63 111.46,103.1 113.16,101.4 116.48,101.4 118.62,99.26 118.62,98.2 119.35,97.46 120.77,97.46 122.04,96.19 130.18,96.19 130.76,95.61 133.23,95.61 134.51,96.89 155.84,96.89 157.28,98.32 160.93,98.32 162.71,100.1 166.38,100.1 169.9,96.58 169.9,82.22 175.62,76.5 180.34,76.5 187.38,69.47 187.38,60.28 189.05,58.61 v3(190.09,58.61)
  BOTTOM w0.114: v2(96.24,111.25) 97.08,110.41 R456.1
SOC_FPGA_DIN_R: length 34.7
  TOP w0.114: v2(95.4,109.47) 95.43,109.5 R54.1 ; U9.BB16 93.74,85 v4(93.44,85)
  S5 w0.102: v2(95.4,109.47) 95.4,109.07 96.22,108.25 96.22,106.26 92.46,102.5 92.46,101.41 92.53,101.33 92.53,92.79 94.83,90.5 96.35,90.5 97.28,89.58 97.28,89.26 97.13,89.11 97.13,88.27 97.03,88.16 96.92,88.16 96.7,87.94 96.7,87.81 96.3,87.41 96.3,86.4 96.32,86.39 96.32,85.84 96.08,85.6 95.76,85.6 94.99,84.83 93.6,84.83 v4(93.44,85)
  BOTTOM w0.114: v1(96.28,109.8) 95.73,109.8 v2(95.4,109.47)
SOC_FPGA_DOUT: length 218.2
  TOP w0.114: R61.2 68.89,109.98 v2(68.33,109.98) ; U12.E13 v3(201.09,58.61)
  S3 w0.102: v3(201.09,58.61) 201.63,58.06 203.12,58.06 205.26,60.2 205.26,67.79 204.52,68.53 204.52,81.37 201.69,84.2 201.69,92.47 202.06,92.84 202.06,98.64 196.36,104.33 191.24,104.33 186.55,109.03 186.55,114.15 183.64,117.05 176.26,117.05 171.54,121.77 164.36,121.77 162.97,120.37 157.34,120.37 156.7,119.74 155.83,119.74 155.14,119.04 144.18,119.04 140.89,122.33 140.67,122.33 140.66,122.33 140.29,122.33 68.76,122.33 65.84,119.41 65.84,115.46 66.18,115.11 66.7,115.11 67.81,114 68.55,114 68.83,113.71 68.83,110.49 v2(68.33,109.98)
  BOTTOM w0.114: v1(199.59,63.96) 199.59,59.46 199.95,59.11 200.59,59.11 v3(201.09,58.61) ; R461.1 68.3,109.96 v2(68.33,109.98)
SOC_FPGA_DOUT_R: length 46.2
  TOP w0.114: U9.BB23 93.97,81.59 94.35,81.97 v4(94.35,81.99) ; R61.1 v2(70.82,109.78)
  S3 w0.102: v2(70.82,109.78) 71.58,109.02 71.58,106.23 76.84,100.97 80.63,100.97 83.03,98.57 85.57,98.57 85.84,98.31 85.96,98.18 86.1,98.05 86.29,97.86 87.05,97.09 89.4,94.74 90.58,94.74 91.85,93.47 91.85,90.04 91.26,89.46 91.26,88.42 91.57,88.11 91.57,87.5 91.26,87.2 91.26,86.54 91.57,86.23 91.57,85.72 91.26,85.42 91.26,84.84 91.67,84.43 91.67,84.07 92.18,83.57 92.18,83.36 92.74,82.8 92.74,82.58 93.17,82.14 94.19,82.14 v4(94.35,81.99)
  BOTTOM w0.114: v1(69.75,110.24) 70.36,110.24 v2(70.82,109.78)
SPI_10GBE_1T45_DIR: length 3.5
  BOTTOM w0.114: Q9.5 117.26,53.66 R601.2 R602.2 v1(119.28,53.7)
SPI_10GBE_CLK: length 14.4
  TOP w0.114: R273.2 v2(113.08,43.69) ; R1053.1 117.7,38.17 118.61,39.09 R1052.2 118.84,39.5 118.41,39.5 v2(118.21,39.7) 117.87,40.04 U18.11
  S5 w0.102: v2(118.21,39.7) 115.62,39.7 114.81,40.51 113.64,40.51 113.08,41.07 v2(113.08,43.69)
SPI_10GBE_CLK_LVC3V3: length 21
  TOP w0.127: U16.6 v2(123.52,50.11)
  S5 w0.102: v2(123.52,50.11) 123.52,49.04 119.76,45.27 119.76,39.01 119,38.25 117.55,38.25 117.47,38.18 v2(116.89,38.18)
  BOTTOM w0.114: v2(116.89,38.18) 116.57,38.18 116.33,38.42 R640.1
SPI_10GBE_CLK_LVC3V3_R: length 4.6
  TOP w0.114: U18.6 114.33,40.04 113.82,39.52 v2(113.82,38.81)
  BOTTOM w0.114: R640.2 114.81,38.81 v2(113.82,38.81) v1(113.82,38)
SPI_10GBE_CLK_R: length 25
  TOP w0.114: v4(107.51,61.73) 107.8,61.44 U9.M67 ; R273.1 v2(113.08,46.23)
  S10 w0.102: v2(113.08,46.23) 113.08,47.27 112.73,47.62 112.73,47.64 111.91,48.45 111.91,54.99 112.78,55.85 112.78,58.45 112.47,58.75 112.22,58.75 111.61,58.14 110.95,58.14 110.77,58.32 110.77,58.98 109.93,59.82 109.93,60.17 109.63,60.48 107.82,60.48 107.49,60.81 107.49,61.71 v4(107.51,61.73)
  BOTTOM w0.114: v2(113.08,46.23) 112.52,45.66 111.44,45.66 v1(111.2,45.9)
SPI_10GBE_CS_N: length 47.5
  TOP w0.109: v4(107.04,62.59) 107.02,62.56 U9.P67
  TOP w0.114: U18.13 118.31,41.04 119.15,41.88 119.15,43.89 v2(118.75,44.3) 118.75,44.6 R1051.2 117.19,46.36 115.71,47.84 115.71,48.25 116.54,49.07 116.54,49.78 116.79,50.04 117.31,50.04 117.6,50.33 117.6,54.1 116.91,54.79 116.91,55.59 117.2,55.88 120.55,55.88 122.3,57.63 122.3,60.22 120.29,62.23 115.29,62.23 v2(115.16,62.1)
  S5 w0.102: v2(115.16,62.1) 114.88,62.1 113.94,63.04 107.5,63.04 v4(107.04,62.59)
  BOTTOM w0.114: v2(118.75,44.3) 118.75,44.42 v1(118.14,45.03) 117.78,45.03 R628.1
SPI_10GBE_CS_N_LVC3V3: length 26.9
  TOP w0.114: R301.1 R300.2 v2(111.55,37.31) ; U16.1 v2(121.28,52.65)
  S5 w0.102: v2(121.28,52.65) 118.06,49.43 118.06,42.79 118.33,42.52 118.82,42.52 119.02,42.32 119.02,39.43 118.61,39.01 115.44,39.01 114.73,38.3 112.54,38.3 v2(111.55,37.31)
SPI_10GBE_CS_N_LVC3V3_R: length 6.1
  TOP w0.114: U18.4 113.89,41.04 v2(113.84,40.99) 113.26,40.99 111.81,39.55 111.07,39.55 110.65,39.12 R301.2
  BOTTOM w0.114: v2(113.84,40.99) 113.95,41.1 v1(114.78,41.1)
SPI_10GBE_DIR_1: length 9.4
  TOP w0.114: U18.2 114.58,42.04 v2(113.74,42.88) 112.93,42.06 112.93,41.68 111.3,40.06 109.86,40.06 R283.1
  BOTTOM w0.114: v2(113.74,42.88) 113.74,42.88 112.68,42.88 v1(112.6,42.8)
SPI_10GBE_DIR_2: length 7.7
  TOP w0.114: R287.1 110.54,39.8 111.63,39.8 v2(113.77,41.94) 114.16,41.54 U18.3
  BOTTOM w0.114: v1(112.85,41.4) 113.23,41.4 v2(113.77,41.94)
SPI_10GBE_MISO: length 13.5
  TOP w0.114: U9.D74 111.82,58.27 v4(112.32,58.27) ; v2(116.71,58.29) 116.94,58.52 R220.1 118.13,58.92 118.21,59 120.25,59 R1048.2
  S8 w0.102: v4(112.32,58.27) 116.69,58.27 v2(116.71,58.29)
  BOTTOM w0.114: R589.2 116.94,58.52 v2(116.71,58.29) 116.71,58.42 115.82,59.31 v1(114.43,59.31)
SPI_10GBE_MISO_LVC3V3: length 8
  BOTTOM w0.114: Q9.3 116.61,49.09 115.82,48.29 115.82,46.72 116.31,46.23 R619.2 117.5,46.23 R618.2 v1(119.43,46.28)
SPI_10GBE_MISO_LVC3V3_R: length 6.6
  TOP w0.114: v2(116.38,48.06) 117.42,48.06 117.96,48.59 117.96,50.37 118.97,51.38 U16.2
  BOTTOM w0.114: R619.1 v2(116.38,48.06)
SPI_10GBE_MISO_R: length 12.9
  BOTTOM w0.114: R589.1 118.81,58.8 120.14,58.8 120.93,58.01 120.93,56.24 120.19,55.5 v1(119.68,55.5) 119.02,55.5 118.57,55.96 116.99,55.96 116.61,55.58 Q9.4
SPI_10GBE_MOSI: length 19.7
  TOP w0.114: v2(118.57,40.62) 118.41,40.62 118.33,40.54 U18.12 ; R236.2 v2(112.47,50.82)
  S5 w0.102: v2(112.47,50.82) 113.75,50.82 115.42,49.15 115.42,47.62 115.85,47.19 115.85,44.63 116.43,44.04 116.43,42.7 118.51,40.62 v2(118.57,40.62)
  BOTTOM w0.114: v2(118.57,40.62) 118.56,40.62 118.54,40.64 v1(117.35,40.64) 117.6,40.89 R1050.2 116.46,40.57 R1049.1
SPI_10GBE_MOSI_LVC3V3: length 25.1
  TOP w0.114: R302.1 v2(112.55,37.26)
  TOP w0.127: v2(122.28,48.83) 122.39,48.83 122.4,48.84 U16.5
  S5 w0.102: v2(112.55,37.26) 113.36,38.07 114.82,38.07 115.53,38.79 118.85,38.79 119.27,39.21 119.27,46.43 121.68,48.83 v2(122.28,48.83)
  BOTTOM w0.114: v1(122.15,49.68) 122.28,49.56 v2(122.28,48.83)
SPI_10GBE_MOSI_LVC3V3_R: length 4.4
  TOP w0.114: U18.5 113.94,40.54 113.79,40.39 113.31,40.39 v2(112.95,40.03) 112.55,39.62 R302.2
  BOTTOM w0.114: v2(112.95,40.03) 112.85,39.93 v1(111.89,39.93)
SPI_10GBE_MOSI_R: length 12.1
  TOP w0.114: v2(112.5,53.06) 113.17,52.39 R236.1 ; v4(111.56,58.65) 111.66,58.75 U9.C73
  S10 w0.102: v2(112.5,53.06) 112.5,54.97 113.16,55.63 113.16,58.62 112.6,59.18 112.09,59.18 v4(111.56,58.65)
  BOTTOM w0.114: v1(113.26,58.37) 112.9,58.72 111.63,58.72 v4(111.56,58.65)
SPI_CS_SELECT: length 380.6
  TOP w0.114: 60.65,113.36 60.48,113.18 U2.6 ; 60.65,113.36 v2(60.68,113.39) ; 60.65,113.36 R33.2 ; U12.M9 v3(197.09,50.61)
  S3 w0.102: v2(97.17,14.34) 95.46,12.62 88.01,12.62 86.43,11.05 79.67,11.05 79.04,10.41 73.89,10.41 72.44,8.97 71.92,8.97 70.05,7.1 70.05,6.88 69.19,6.02 66.77,6.02 66.39,5.64 63.13,5.64 62.24,6.53 61.48,6.53 59.59,8.42 54.84,8.42 54.7,8.28 54.32,8.28 53.28,9.32 44.27,9.32 42.95,10.64 33.67,10.64 31.18,13.13 25.85,13.13 25.17,12.45 11.35,12.45 4.85,18.95 4.85,22.81 4.5,23.16 4.5,89.29 22.16,106.96 30.73,106.96 37.13,113.36 37.13,115.78 36.65,116.26 36.65,117.39 37.93,118.67 58.41,118.67 60.68,116.4 v2(60.68,113.39)
  S8 w0.102: v3(197.09,50.61) 196.15,50.61 195.58,50.04 195.58,48.47 193.98,46.87 193.98,46.14 193.47,45.63 193.47,45.4 193.07,45 192.5,45 192.36,45.14 191.92,45.14 187.88,41.1 187.88,39.15 187.5,38.77 187.5,32.56 182.12,27.18 178.34,27.18 176.59,25.43 170.68,25.43 169.03,23.77 150.55,23.77 147.81,21.03 115.18,21.03 111.49,17.35 105.21,17.35 104.91,17.04 100.65,17.04 98.03,14.42 97.25,14.42 v2(97.17,14.34)
  BOTTOM w0.114: R429.2 60.18,115.86 59.94,115.62 U32.6 60.42,114.48 60.68,114.23 v2(60.68,113.39) ; v1(195.06,47.3) 195.07,47.31 195.07,47.46 195.47,47.85 195.71,47.85 196.57,48.71 196.57,50.09 v3(197.09,50.61)
SPI_MUX_OE_N: length 14.1
  TOP w0.114: U43.15 108.39,116.64 108.71,116.33 v3(109.73,116.33)
  S5 w0.102: v3(111,110.36) 110.82,110.54 110.82,114.45 109.73,115.54 v3(109.73,116.33)
  BOTTOM w0.114: v1(110.87,109.47) 110.87,110.24 v3(111,110.36) 111.25,110.62 Q16.D 113.28,111.63 R932.2
SPI_NIC1_NVM_CS: length 19.5
  TOP w0.114: v2(135.23,98.2) 135.25,98.17 R811.2 ; v2(146.81,102.31) 147.32,102.31 R816.1 U39.1
  S3 w0.102: v2(146.81,102.31) 146.53,102.59 140.16,102.59 138.33,100.76 138.33,99.97 136.55,98.2 v2(135.23,98.2)
  BOTTOM w0.114: v2(135.23,98.2) 134.7,98.2 v1(134.32,98.58)
SPI_NIC1_NVM_CS_R_N: length 5.3
  TOP w0.114: U6.15 137.59,93.62 v2(135.74,95.48) 135.25,95.96 R811.1
  BOTTOM w0.114: v1(135.71,96.47) 135.74,96.44 v2(135.74,95.48)
SPI_NIC1_NVM_SCK: length 12.5
  TOP w0.114: R812.2 137.29,98.15 v2(137.41,98.27) ; v2(137.03,104.75) 136.62,104.75 R815.1 136.22,105.41 U39.6
  S8 w0.102: v2(137.03,104.75) 137.36,104.75 138.05,104.06 138.05,98.91 v2(137.41,98.27)
  BOTTOM w0.114: v2(137.03,104.75) 136.32,104.75 v1(136.14,104.56)
SPI_NIC1_NVM_SCK_R: length 4.9
  TOP w0.114: R812.1 137.29,95.86 v2(137.78,95.36) 138.59,94.55 U6.13
  BOTTOM w0.114: v2(137.78,95.36) 137.78,96.1 v1(137.57,96.32)
SPI_NIC1_NVM_SI: length 14.5
  TOP w0.114: U39.5 136.73,106.68 R1046.1 R813.1 136.7,106.3 v2(137.01,105.99) ; R809.2 138.3,98.22 v2(138.28,98.25)
  S8 w0.102: v2(137.01,105.99) 137.01,105.42 138.28,104.15 v2(138.28,98.25)
  BOTTOM w0.114: v1(137.87,105.69) 137.57,105.99 v2(137.01,105.99)
SPI_NIC1_NVM_SI_R: length 4.7
  TOP w0.114: U6.12 139.09,94.97 v2(139.06,95) 139.06,95.02 138.3,95.78 R809.1
  BOTTOM w0.114: v1(138.23,94.41) 138.81,95 v2(139.06,95)
SPI_NIC1_NVM_SO: length 20.2
  TOP w0.114: U39.2 146.87,104.14 R1047.1 R814.1 147.6,104.14 v2(146.94,103.48) ; R989.2 v2(136.27,98.65)
  S3 w0.102: v2(146.94,103.48) 146.28,102.82 140.03,102.82 138.1,100.89 138.1,100.48 v2(136.27,98.65)
  BOTTOM w0.114: v2(136.27,98.65) 136.58,98.35 v1(136.58,97.69)
SPI_NIC1_NVM_SO_R: length 5.1
  TOP w0.114: U6.14 138.09,94.04 v2(136.89,95.24) 136.27,95.86 R989.1
  BOTTOM w0.114: v1(136.14,94.56) 136.82,95.24 v2(136.89,95.24)
SRDS_SIG_DET: length 114.3
  TOP w0.114: v2(202.06,45.69) 202.08,45.72 202.18,45.72 202.35,45.88 202.35,46.7 202.03,47.02 202.03,47.67 U12.R14 ; R972.1 149.86,85.85 v2(149.99,85.72)
  S8 w0.102: v2(149.99,85.72) 149.73,85.72 148.34,84.33 148.34,81.79 147.83,81.28 147.83,66.17 143.89,62.23 v2(143.89,61.72)
  BOTTOM w0.114: v2(143.89,61.72) 144.88,60.73 148.44,60.73 149.89,59.28 149.89,59.11 150.75,58.24 159.39,58.24 160.32,57.31 178.26,57.31 180.53,55.04 180.53,42.87 183.03,40.37 188.13,40.37 v1(188.85,39.65) 192.26,36.24 197.78,36.24 202.84,41.3 202.84,44.91 v2(202.06,45.69)
SRDS_SIG_DET_R: length 9.9
  TOP w0.114: U6.54 145.69,87.52 146.18,88.01 147.7,88.01 148.34,87.38 R972.2 148.95,87.48 v2(151,87.48) 151.46,87.48 R970.1 R920.1
  BOTTOM w0.114: v1(150.01,87.45) 150.04,87.48 v2(151,87.48)
SUSCLK_32K_CPLD: length 157.3
  TOP w0.114: R41.1 90.19,111.02 89.92,111.02 v2(89.75,111.19) ; U12.H5 v3(192.09,55.61)
  S3 w0.102: v3(192.09,55.61) 192.47,55.99 193.01,55.99 193.52,56.5 193.52,61.26 193.47,61.31 193.47,62.9 193.29,63.08 193.29,64.32 192.71,64.9 192.71,69.44 184.86,77.29 183.62,77.29 177.32,83.6 177.32,86.86 173.1,91.08 173.1,100.24 169,104.34 154.08,104.34 150.68,107.75 149.45,107.75 147.93,109.27 132.98,109.27 131.89,108.18 122.75,108.18 120.66,106.1 115.83,106.1 113.92,108.01 113.92,108.98 112.99,109.91 108,109.91 102.51,115.39 101.93,115.39 101.07,116.26 98.61,116.26 98.18,115.82 94.7,115.82 93.1,117.42 91.17,117.42 89.23,115.49 89.23,111.71 v2(89.75,111.19)
  BOTTOM w0.114: v1(192.15,54.61) 192.15,55.55 v3(192.09,55.61)
SVID_ALERT: length 87.7
  TOP w0.114: R369.2 50.8,8.23 51.38,7.65 v2(51.59,7.65) 51.78,7.85 R370.2 ; R401.2 v2(71.65,2.97) ; R286.1 v2(98.8,40.77)
  S10 w0.102: v2(71.65,2.97) 72.39,3.71 74.22,3.71 74.24,3.73 74.98,3.73 75,3.71 81.53,3.71 88.74,10.92 92.1,10.92 95.25,14.07 95.25,21.59 99.06,25.4 99.06,31.14 98.4,31.8 98.4,36.53 97.79,37.14 97.79,38.19 98.48,38.88 98.48,39.67 98.34,39.81 98.34,40.31 v2(98.8,40.77)
  BOTTOM w0.114: v2(71.65,2.97) 70.78,3.84 v1(70.53,3.84) 69.71,3.02 65.07,3.02 64.85,3.23 64.47,3.23 64.05,2.81 59.7,2.81 59.07,2.17 57.84,2.17 57.3,2.71 57.3,3.41 55.91,4.8 55.91,7.03 54.8,8.13 52.06,8.13 v2(51.59,7.65) ; R286.1 v2(98.8,40.77)
SVID_ALERT_DDR_R: length 2.5
  TOP w0.114: R370.1 54.53,7.85 55.03,7.35 U29.13
SVID_ALERT_VCORE: length 4
  TOP w0.114: R401.1 72.59,4.01 v2(73.66,5.09) 74.41,5.84 U28.13
  BOTTOM w0.114: v2(73.66,5.09) v1(73.66,5.97)
SVID_CLK: length 117
  TOP w0.114: R376.2 v2(51.28,6.91) 50.9,7.29 R374.1 ; R399.1 v2(73.51,2.29)
  S10 w0.102: v2(102.23,41.48) 102.04,41.48 100.36,39.8 99.84,39.8 99.06,39.03 99.06,38.78 98.5,38.22 98.5,37.38 98.84,37.04 99.23,37.04 99.54,36.73 99.54,25 95.94,21.39 95.94,13.42 92.92,10.41 89.18,10.41 86.38,7.62 86.38,3.8 87.04,3.13 87.04,2.67 86.64,2.27 84.79,2.27 84.51,2.55 84.4,2.55 83.91,3.03 83.83,3.11 82.86,3.11 82.3,2.55 81.22,2.55 81.03,2.36 81.03,2.17 80.76,1.91 78.55,1.91 78.32,2.14 75.21,2.14 74.94,2.41 74.94,2.43 74.93,2.43 74.93,2.45 74.61,2.77 74.1,2.77 73.95,2.62 73.84,2.62 v2(73.51,2.29) 73.11,2.29 72.59,1.76 71.11,1.76 70.59,2.28 65,2.28 64.9,2.18 64.42,2.18 64.32,2.28 64.09,2.28 62.38,3.99 62.38,15.01 60.79,16.6 58.58,16.6 58.24,16.94 52.85,16.94 52.65,16.74 51.14,16.74 51.04,16.64 50.47,16.64 49.71,15.88 49.71,8.48 v2(51.28,6.91)
  BOTTOM w0.114: v1(50.67,7.62) 50.67,7.52 v2(51.28,6.91) ; R634.1 v2(102.23,41.48) 102.23,40.33 R639.2
SVID_CLK_DDR_R: length 2.7
  TOP w0.114: U29.14 54.6,6.95 v2(54.43,7.11) 54.33,7.01 53.06,7.01 R376.1
SVID_CLK_VCORE: length 6
  TOP w0.114: R399.2 73.51,4.25 v2(74.38,5.12) 74.81,5.55 U28.14
  BOTTOM w0.114: v2(74.38,5.12) 74.38,4.91 73.83,4.36 72.19,4.36 v1(71.81,3.99)
SVID_DATA: length 92.8
  TOP w0.114: v2(99.09,37.62) 98.8,37.91 R304.1 ; v2(74.35,2.18) 74.44,2.27 74.44,2.97 R400.2 ; R379.1 51.01,6.35 v2(51.33,6.03) R385.2
  S10 w0.102: v2(99.09,37.62) 99.19,37.52 99.43,37.52 100.03,36.93 100.03,24.8 96.67,21.44 96.67,13.48 92.59,9.39 88.92,9.39 87.03,7.5 87.03,3.83 87.53,3.33 87.53,2.47 86.84,1.79 84.58,1.79 84.48,1.79 84.2,2.07 84.19,2.07 83.63,2.63 83.06,2.63 82.5,2.07 82.04,2.07 81.62,1.65 81.19,1.65 80.96,1.42 78.35,1.42 78.12,1.65 74.72,1.65 74.35,2.03 v2(74.35,2.18)
  BOTTOM w0.114: R304.1 98.8,37.91 v2(99.09,37.62) ; v2(51.33,6.03) 53.19,7.89 54.7,7.89 55.65,6.94 55.65,4.72 57.02,3.34 57.02,2.54 57.66,1.91 59.82,1.91 60.07,2.16 72.12,2.16 73.69,3.73 v1(74.28,3.73) 74.35,3.67 v2(74.35,2.18)
SVID_DATA_CORE: length 3.6
  TOP w0.114: U28.15 75.21,5.21 75.16,5.16 75.16,5.13 v2(75.15,5.12) 74.44,4.42 R400.1
  BOTTOM w0.114: v1(75.46,4.25) 75.15,4.56 v2(75.15,5.12)
SVID_DATA_DDR_R: length 2.7
  TOP w0.114: R385.1 53.2,6.03 53.57,6.4 54.76,6.4 54.91,6.55 U29.15
SW1_OE_N: length 4
  TOP w0.114: v2(203.83,98.81) 204.33,98.31 U7.15
  BOTTOM w0.114: R848.2 v1(204.86,99.48) 204.5,99.48 v2(203.83,98.81)
SW1_SYS_RESET_N: length 4
  TOP w0.114: R714.2 v2(184.66,7.49) 183.99,6.82 SW1.4 SW1.3
SW2_SYS_RESET_N: length 3.8
  TOP w0.114: SW2.3 SW2.4 188.34,6.56 v2(188.34,7.49) R389.2
SW_VDDQ_CH01: length 3.9
  TOP w0.249: QFN1.6 R335.1
  BOTTOM w0.381: v2(55.8,25.27) 54.46,23.93 C594.1
SYS_CPLD_INT_CPU: length 360.1
  TOP w0.114: v2(195.88,45.52) 195.88,45.76 196.59,46.47 U12.T9 ; R19.1 v2(76.53,114.35)
  S5 w0.102: v2(144.22,3.71) 143.4,4.53 143.05,4.53 142.53,5.05 142.53,5.43 143.29,6.19 157.73,6.19 161.89,10.35 169.51,10.35 173.48,14.31 176.72,14.31 178.28,15.87 178.28,22.86 180.26,24.85 180.26,25.18 180.53,25.45 181.62,25.45 187.82,31.65 188.12,31.65 196.15,39.68 196.15,44.79 195.88,45.06 v2(195.88,45.52)
  S8 w0.102: v2(144.22,3.71) 143.46,2.95 128.34,2.95 126.16,5.13 122.87,5.13 122.62,5.37 115.58,5.37 110.12,10.83 95.74,10.83 94.75,11.82 93.13,11.82 92.78,11.48 89.19,11.48 87.27,11.48 86.67,10.87 85.33,10.87 84.75,10.29 84.18,10.29 81.99,8.1 81.99,4.87 81.16,4.04 77.91,4.04 77.86,3.99 76.59,3.99 76.29,4.29 70.89,4.29 70.79,4.39 67.86,4.39 67.42,3.96 66.79,3.96 65.4,5.35 62.59,5.35 62.08,5.87 60.89,5.87 59.53,4.51 56.58,4.51 56.2,4.9 56.2,6 54.6,7.59 54.03,7.59 52.79,8.84 49.64,8.84 47.83,10.65 47.83,12.65 45.14,15.34 41.8,15.34 40.78,16.36 30.78,16.36 26.93,20.21 26.93,53.95 28.8,55.82 28.8,56.2 30.3,57.7 30.3,76.36 30.71,76.77 30.71,80.37 30.89,80.54 30.89,103.01 37.83,109.96 47.76,109.96 51.48,113.68 56.6,113.68 57.07,113.21 59.79,113.21 60.99,114.4 65.62,114.4 66.05,113.97 66.43,113.97 66.47,114 68.52,114 69.43,114.91 73.55,114.91 74.22,114.25 76.43,114.25 v2(76.53,114.35)
  BOTTOM w0.114: v2(76.53,114.35) 75.79,115.09 v1(75.79,116.03) ; 145.1,3.16 144.55,3.71 v2(144.22,3.71)
  BOTTOM w0.127: 145.1,3.16 CONN16.56
SYS_CPLD_INT_CPU_R: length 44.7
  TOP w0.114: R19.2 79.58,114.35 v2(79.86,114.63) 79.86,114.91 80.07,115.12 80.07,115.51 78.74,116.84 R905.2 ; U9.BB14 94.33,85.22 v4(94.36,85.22)
  S5 w0.102: v2(79.86,114.63) 80.26,114.63 82.07,112.83 83.69,112.83 84.73,111.79 84.73,107.12 85.52,106.33 85.52,104.95 86.62,103.85 86.62,100.22 91.85,95 91.85,92.31 94.49,89.67 94.49,89.66 94.55,89.6 94.55,89.23 95.43,88.35 95.43,87.89 95.21,87.66 95.21,87.35 95.55,87 95.55,85.85 94.92,85.22 v4(94.36,85.22)
  BOTTOM w0.114: v2(79.86,114.63) 79.76,114.73 v1(78.82,114.73)
SYS_PWRBTN_N: length 62.2
  TOP w0.114: R390.2 C252.1 R389.1 v2(188.34,10.29) ; U12.K14 v3(202.09,52.61)
  S8 w0.102: v2(188.34,10.29) 198.91,10.29 201.6,12.98 201.6,17.77 202.21,18.38 202.21,24.89 206.86,29.54 206.86,47.66 205,49.52 204.39,49.52 204.03,49.88 203.76,50.15 203.76,50.76 202.09,52.43 v3(202.09,52.61)
SYSLED: length 3.6
  TOP w0.114: Q5.D 165.35,83.18 164.59,82.42 v2(164.59,82.3) R164.1 R163.2
SYSLED_R: length 1.7
  TOP w0.114: R163.1 v2(165.99,79.88) 165.98,79.87 LED11.C
TEST_NET1: length 13.7
  TOP w0.114: TP60.1 v3(195.47,70.8) 195.94,70.33 195.94,67.89 197.36,66.47 197.36,62.34 U12.A10
  BOTTOM w0.114: v1(193.52,71.32) 194.94,71.32 v3(195.47,70.8)
TEST_NET2: length 11.8
  TOP w0.114: TP61.1 194.84,70.23 195.48,69.6 v3(195.48,69.34) 195.48,67.98 196.95,66.51 196.95,62.47 U12.A9
  BOTTOM w0.114: v3(195.48,69.34) 195.22,69.6 v1(193.75,69.6)
TEST_NOA_COMP: length 21.1
  TOP w0.114: v4(104.03,62.58) 103.75,62.3 U9.AA66 ; R260.2 v2(105.46,46.89)
  S10 w0.102: v4(104.03,62.58) 104.27,62.81 104.41,62.81 104.55,62.67 104.55,60.68 104.06,60.2 104.06,60.1 103.66,59.69 103.66,58.95 103.84,58.78 104.01,58.78 104.19,58.6 104.19,57.66 103.68,57.15 103.68,54.53 104.57,53.64 105.11,53.64 105.94,52.81 105.94,47.37 v2(105.46,46.89)
  BOTTOM w0.114: v1(105.54,45.95) 105.54,46.81 v2(105.46,46.89)
TEST_RCIN_N: length 55
  TOP w0.114: v4(95.16,79.58) 95.15,79.58 94.75,79.98 U9.BA27 ; R14.1 v2(71.86,114.46)
  S3 w0.102: v2(71.86,114.46) 72.06,114.66 73.96,114.66 74.63,114 75.21,114 75.77,113.44 75.77,112.39 76.23,111.94 76.61,111.94 78.98,109.58 79.43,109.58 81.08,107.92 81.08,106.35 81.29,106.13 81.29,101.92 83.5,99.72 86.17,99.72 89.13,96.75 90.78,96.75 93.4,94.13 93.4,92.3 95.33,90.37 95.33,89.1 95.16,88.93 95.16,87.17 95.41,86.92 95.76,86.92 96.37,86.31 96.37,80.24 95.71,79.58 v4(95.16,79.58)
  BOTTOM w0.114: v2(71.86,114.46) 70.92,115.39 v1(70.76,115.39)
TGND_VDDQ_CH01: length 2.5
  BOTTOM w0.114: v3(57.11,20.59) 57.58,21.07 TP33.1 v1(58.8,21.72)
TP_ADR_COMPLETE: length 3.2
  TOP w0.114: v4(102.08,62.6) 101.77,62.3 U9.AF66
  BOTTOM w0.114: v1(103.52,63.3) 103.05,63.3 102.36,62.6 v4(102.08,62.6) 102.04,62.64 TP31.1
TP_BDX_CPU_RESET_N: length 5
  TOP w0.114: U9.BU7 v4(87.7,88.63)
  BOTTOM w0.114: v4(87.7,88.63) 87.3,89.03 86.46,89.03 85.83,89.66 R517.2 84.5,90.34 v1(84.45,90.39)
TP_BDX_GP50: length 9.3
  TOP w0.114: U9.BV20 86.92,82.9 v4(87.2,82.62)
  BOTTOM w0.114: v1(79.78,81.5) 79.78,82.21 TP24.1 80.59,83.03 86.79,83.03 v4(87.2,82.62)
TP_DDR_VREFDQ_0: length 10.4
  TOP w0.114: v3(76.45,68.49) 76.69,68.73 77.11,68.73 U9.CV51
  BOTTOM w0.114: v3(76.45,68.49) 76.02,68.93 71.15,68.93 70.74,68.52 70.74,68.2 70.96,67.98 72.02,67.98 72.26,67.74 C431.1 73.23,67.54 v1(73.28,67.59)
TP_DDR_VREFDQ_1: length 7.1
  TOP w0.114: v4(77.37,68.44) 77.54,68.44 77.93,68.83 78.44,68.83 U9.CT51
  BOTTOM w0.114: v4(77.37,68.44) 77.37,68.81 v1(76.83,69.34) 76.51,69.67 72.71,69.67 C454.1
TP_GPIO54: length 8.9
  TOP w0.114: v4(86.7,83.45) 86.39,83.76 U9.BW18
  BOTTOM w0.114: v4(86.7,83.45) 86.25,83.9 80.37,83.9 TP23.1 79.72,84.54 v1(79.72,85.41)
TP_HDA_SYNC: length 1.4
  TOP w0.114: v4(98.08,88.37) 98.1,88.39 U9.AN7
  BOTTOM w0.114: v4(98.08,88.37) 98.38,88.67 TP20.1
TP_KR_EPHY_DFTDIG_1: length 6.3
  TOP w0.114: U9.F69 110.28,60.58 v4(109.98,60.88)
  BOTTOM w0.114: TP32.1 109.91,60.81 v4(109.98,60.88) 110.15,61.05 110.15,61.49 111.02,62.36 112.99,62.36 v1(113.68,61.66)
TP_LDRQ0_N: length 2.2
  TOP w0.114: v4(99.55,89.2) 99.83,89.49 U9.AK4
  BOTTOM w0.114: v4(99.55,89.2) 99.31,89.44 TP18.1
TP_PE_HSCLK_DN: length 4.7
  TOP w0.114: U9.C49 112.75,69.93 113.17,70.34 R196.2
TP_PE_HSCLK_DP: length 3.5
  TOP w0.114: U9.A49 116.18,69.93 R199.2
TP_PMTEST_RST: length 5.6
  TOP w0.114: U9.BD7 93.52,88.54 93.96,88.54 v4(94.14,88.37)
  BOTTOM w0.114: v1(93.55,92.41) 93.51,92.38 TP16.1 93.4,90.41 93.4,89.11 v4(94.14,88.37)
TP_SATA_PLLOBS0: length 6.8
  TOP w0.114: v4(93.37,78.03) 93.37,77.72 93.04,77.39 92.71,77.39 92.21,76.89 U9.BF33
  BOTTOM w0.114: TP26.1 92.99,75.54 92.2,76.33 92.2,76.73 91.74,77.19 91.74,77.77 91.95,77.98 92.28,77.98 92.41,77.85 92.81,77.85 92.99,78.03 v4(93.37,78.03)
TP_SATA_PLLOBS1: length 1.4
  TOP w0.114: U9.BE32 92.65,78.31 v4(92.65,78.32)
  BOTTOM w0.114: TP25.1 93.2,78.87 v4(92.65,78.32)
TP_SLP_A_N: length 5
  TOP w0.114: v4(92.8,89.35) 93.27,89.35 93.71,88.91 U9.BB7
  BOTTOM w0.114: v1(92.18,92.57) 92.33,92.41 TP14.1 92.33,89.82 v4(92.8,89.35)
TP_SLP_SUS_N: length 3.5
  TOP w0.108: U9.AY7 95.13,89.23 v4(94.93,89.43)
  BOTTOM w0.114: v1(94.82,92.19) 94.82,90.69 TP15.1 94.71,89.65 v4(94.93,89.43)
TP_TEST_PE_AMONI: length 5.3
  TOP w0.114: U9.N43 107.51,73.03 v4(107.21,73.33)
  BOTTOM w0.114: TP29.1 110.64,75.03 109.6,75.03 107.9,73.33 v4(107.21,73.33)
TP_TEST_PE_AMONV: length 5.1
  TOP w0.114: U9.N47 107.51,70.15 v4(107.37,70)
  BOTTOM w0.114: v4(107.37,70) 108.74,70 109.64,70.91 v1(109.98,70.91) TP30.1
TP_TEST_PE_DFX_DN: length 2.4
  TOP w0.114: v4(105.54,74.09) 105.56,74.12 106.35,74.12 106.75,74.52 U9.R39
  BOTTOM w0.114: v4(105.54,74.09) 105.54,74.74 TP27.1
TP_TEST_PE_DFX_DP: length 6.7
  TOP w0.114: U9.N39 107.72,74.32 v4(108.01,74.03)
  BOTTOM w0.114: v4(108.01,74.03) 108.14,74.03 109.65,75.54 111.32,75.54 TP28.1 112.12,74.96 v1(113.16,74.96)
TP_USB2_PLLMON_DN: length 1.5
  TOP w0.114: v4(102.06,88.37) 102.37,88.05 U9.AD9
  BOTTOM w0.114: v4(102.06,88.37) 102.49,88.8 TP17.1
TP_USB2_PLLMON_DP: length 0.6
  TOP w0.114: v4(102.57,87.5) 102.87,87.19 U9.AC11
TP_VCCRTCEXT: length 16.6
  TOP w0.254: U9.AW16 v4(95.94,84.41)
  BOTTOM w0.114: v4(95.94,84.41) 95.84,84.41 94.61,83.18 94.19,83.18 93.85,82.84 93.85,82.73 93.4,82.28 93.08,82.28 92.32,83.03 90.93,83.03 90.65,82.75 90.65,82.45 90.22,82.02 90.22,81.69 89.71,81.18 89.71,80.77 89.23,80.29 89.23,79.98 88.77,79.53 88.77,79.1 88.27,78.59 88.27,78.23 87.78,77.75 87.78,77.25 87.31,76.78 87.31,76.26 87.71,75.87 87.71,75.13 C366.2
TP_VCCSST: length 13.3
  TOP w0.254: v4(95.95,82.77) 95.95,82.79 U9.AW19
  BOTTOM w0.114: v4(95.95,82.77) 95.95,82.54 95.56,82.15 95.56,81.83 95.32,81.59 95,81.59 94.99,81.6 94.12,81.6 93.65,81.13 93.65,80.7 93.42,80.47 91.36,80.47 91.14,80.24 91.14,79.86 90.63,79.35 90.63,78.97 90.17,78.51 90.17,78.18 89.74,77.75 89.74,77.29 89.18,76.73 89.18,76.4 89.64,75.94 89.64,75 C368.2
TP_VCCSUS_1P05: length 16.4
  TOP w0.254: v4(96.76,84.39) 96.75,84.39 U9.AU16
  BOTTOM w0.114: v4(96.76,84.39) 96.36,84 96.14,84 96.12,83.98 95.79,83.98 95.55,83.74 95.55,82.63 95.29,82.37 94.19,82.37 93.71,81.9 93.06,81.9 92.83,82.13 92.51,82.13 92.28,81.9 92.28,81.58 91.98,81.29 91.01,81.29 90.78,81.06 90.78,80.77 90.2,80.19 90.2,79.96 89.71,79.48 89.71,79.02 89.2,78.51 89.2,78.16 88.7,77.65 88.7,77.32 88.24,76.86 88.24,76.4 88.72,75.92 88.72,75.03 C367.2
TP_VCCUSB3SUS: length 2.2
  TOP w0.305: U9.AP30 97.95,78.49 98.12,78.66 98.12,79.02 U9.AP28
  TOP w0.33: U9.AP30 v4(98.35,77.99)
  BOTTOM w0.114: C337.2 98.35,77.44 v4(98.35,77.99)
TPM_DET_N: length 275.6
  TOP w0.114: U12.F10 v3(198.09,57.61)
  S3 w0.102: v2(122.81,27.69) 123.62,26.87 123.62,25.75 122.87,25 98.18,25 94.43,21.26 90.47,21.26 89.03,19.81 88.39,19.81 86.64,18.06 72.47,18.06 71.68,17.27 57.9,17.27 56.55,15.93 50.8,15.93 43.81,22.92 43.81,24.92 42.19,26.54 35.6,26.54 34.97,27.17 31.96,27.17 26.34,32.79 26.34,50.52 24.41,52.45 20.17,52.45 16.65,55.97 16.65,62.34 v2(16.13,62.87)
  S5 w0.102: v2(186.72,37.21) 185.7,38.23 185.7,50.41 189.9,54.61 196.63,54.61 197.71,55.69 197.71,57.23 v3(198.09,57.61)
  BOTTOM w0.114: v2(186.72,37.21) 186.33,37.21 v1(185.34,36.22) 184.53,35.41 184.53,32.1 180.89,28.45 176.06,28.45 173.65,26.04 170.01,26.04 169,27.06 136.57,27.06 134.66,25.15 130.07,25.15 127.79,27.44 123.06,27.44 v2(122.81,27.69) ; R948.2 27.94,73.42 28.13,73.23 28.13,71.16 27.43,70.45 23.73,70.45 23.71,70.47 23.22,70.47 22.98,70.22 22.98,69.21 22.85,69.08 CONN14.33 20.57,69.08 16.43,64.94 16.43,63.16 v2(16.13,62.87)
TPM_RESET_N: length 40.8
  TOP w0.114: R229.2 v2(200.66,41.78)
  TOP w0.127: U17.16 v2(179.18,15.98)
  S8 w0.102: v2(200.66,41.78) 200.66,40.39 199.44,39.17 199.44,37.82 197.23,35.61 195.88,35.61 193.52,33.25 193.52,28.24 187.15,21.87 185.81,21.87 185.11,21.16 181.37,21.16 180.24,20.03 180.24,17.04 v2(179.18,15.98)
TPM_RESET_R_N: length 4.9
  TOP w0.114: U12.R12 200.08,47.62 v2(200.08,46.1) 200.08,44.91 200.66,44.32 R229.1
U10_DIR: length 2.3
  TOP w0.114: U10.2 v2(172.65,68.35)
  BOTTOM w0.114: v2(172.65,68.35) 173,68.7 R563.1
U10_OE_N: length 2.4
  TOP w0.114: U10.22 173.15,73.97 v2(172.9,74.22)
  BOTTOM w0.114: v2(172.9,74.22) 173.13,73.99 R556.2
U13_DIR: length 2
  TOP w0.114: v2(172.69,61.11) 172.69,61.31 172.7,61.32 U13.2
  BOTTOM w0.114: v2(172.69,61.11) R577.1
U13_OE_N: length 2.2
  TOP w0.114: U13.22 v2(173.2,66.93)
  BOTTOM w0.114: v2(173.2,66.93) 173.13,66.85 R573.2
U14_DIR: length 2.6
  TOP w0.114: R203.1 171.91,49.02 171.91,50.45 v2(172.11,50.65) U14.2
U14_OE_N: length 3.2
  TOP w0.114: v2(172.87,55.27) 173.2,54.94 U14.22
  BOTTOM w0.114: v1(172.75,56.26) 172.75,55.4 v2(172.87,55.27) 173.18,54.96 R575.2
U17_PP: length 5.3
  TOP w0.114: v2(173.35,20.09) 173.35,20.07 173.17,19.89 U17.7
  BOTTOM w0.114: v2(173.35,20.09) v1(174.32,20.09) 173.73,19.5 R954.1 R631.1
UART_BDX_RX0: length 117.7
  TOP w0.114: U9.AG77 100.55,56.56 100.03,56.03 100.03,55.41 v3(100.2,55.23) ; U13.17 175.7,67.22 v2(175.67,67.25)
  S3 w0.102: v2(120.85,45.61) 118.12,45.61 116.56,44.05 116.56,43.51 114.5,41.45 104.55,41.45 103.91,42.09 95.86,42.09 94.69,43.26 94.69,45.8 97.16,48.26 97.43,48.26 98.02,48.84 98.02,50.38 99.36,51.72 99.36,53.94 99.75,54.32 99.75,54.79 99.85,54.89 99.86,54.89 v3(100.2,55.23)
  S8 w0.102: v2(175.67,67.25) 175.1,67.82 171.6,67.82 169.85,66.07 169.85,60.38 165.3,55.83 155.72,55.83 155.24,56.31 129.72,56.31 124.9,51.49 123.87,51.49 122.83,50.45 122.83,49.83 123.07,49.59 123.07,48.98 120.85,46.76 v2(120.85,45.61)
  BOTTOM w0.114: v2(175.67,67.25) 175.25,67.67 v1(174.83,67.67)
UART_BDX_RX1: length 115.5
  TOP w0.114: v2(176.33,66.78) 176.2,66.65 U13.16 ; U9.AH78 100.63,55.52 100.63,54.89 v2(100.3,54.56)
  S3 w0.102: v2(100.3,54.56) 100.3,53.24 99.75,52.68 99.75,51.77 98.25,50.27 98.25,48.43 97.85,48.03 97.25,48.03 94.92,45.7 94.92,43.35 95.85,42.42 114,42.42 115.9,44.32 116.51,44.32 118.02,45.83 119.67,45.83 120.04,46.2 v2(121.46,46.2)
  S8 w0.102: v2(176.33,66.78) 176.23,66.67 175.06,66.67 174.14,67.59 171.69,67.59 170.08,65.98 170.08,60.28 165.4,55.6 155.63,55.6 155.15,56.08 129.82,56.08 125,51.26 123.97,51.26 123.06,50.35 123.06,49.92 123.3,49.69 123.3,48.89 121.46,47.05 v2(121.46,46.2)
  BOTTOM w0.114: v2(176.33,66.78) v1(175.62,66.07)
UART_BDX_TX0: length 125
  TOP w0.114: U10.6 174.65,68.96 175.58,68.03 175.94,68.03 176.43,67.54 177.39,67.54 177.51,67.67 v2(180.82,67.67) ; R797.1 R796.2 102.09,38.55 102.09,39.71 101.26,40.54 100.13,40.54 v2(99.98,40.39) R288.1
  S8 w0.102: v2(99.98,40.39) 100.13,40.39 100.66,39.86 100.66,37.39 103.12,34.92 123.51,34.92 124.02,35.43 131.95,35.43 138.65,42.14 155.73,42.14 159.44,45.85 178.89,45.85 180.67,47.62 180.67,63.2 179.96,63.91 179.96,65.99 180.7,66.73 180.7,66.91 181.1,67.31 181.1,67.42 180.86,67.67 v2(180.82,67.67)
  BOTTOM w0.114: v2(99.98,40.39) 99.98,41.14 100,41.16 v1(100,41.17)
UART_BDX_TX1: length 140.2
  TOP w0.114: U10.7 175.15,68.99 175.87,68.28 176.04,68.28 176.53,67.79 177.29,67.79 177.48,67.97 179.63,67.97 v2(179.88,68.22) ; R257.1 v2(99.98,46.76) 99.98,46.73 100.44,46.27 100.44,44.11 100.37,44.03 100.37,43.37 100.44,43.3 100.44,41.14 100.71,40.87 101.47,40.87 101.97,40.37 101.98,40.37 102.21,40.13 R799.1 R798.2
  S3 w0.102: v2(115.9,36.73) 114.59,36.73 112.36,38.95 102.35,38.95 100.46,37.06 97.74,37.06 v2(96.01,35.33)
  S5 w0.102: v2(99.98,46.76) 99.21,46 99.21,45.44 97.94,44.17 96.6,44.17 95.83,43.41 95.83,40.87 96.11,40.59 96.11,39.57 96.01,39.47 v2(96.01,35.33)
  S8 w0.102: v2(179.88,68.22) 179.83,68.28 179.65,68.28 179.37,68 179.37,50.76 176.24,47.62 160.22,47.62 156.38,43.79 138.68,43.79 131.01,36.12 123.74,36.12 123.69,36.07 117.2,36.07 117.08,36.2 116.54,36.73 v2(115.9,36.73)
UART_CPLD_B2B_RX0: length 24.4
  TOP w0.114: R871.2 203.58,73.61 202.72,72.75 202.72,69.1 204.26,67.56 204.26,63.55 205.59,62.22 205.59,57.32 204.97,56.7 203.96,56.7 203.88,56.61 203.09,56.61 U12.G15 v3(202.09,56.61)
  BOTTOM w0.114: v1(203.15,56.64) 202.61,56.64 202.58,56.61 v3(202.09,56.61)
UART_CPLD_B2B_TX0: length 24.9
  TOP w0.114: R872.2 203.55,72.59 202.98,72.02 202.98,69.18 204.5,67.66 204.5,63.65 205.83,62.32 205.83,56.77 205.52,56.46 204.37,56.46 204.1,56.18 204.1,55.87 203.84,55.61 v3(202.09,55.61) U12.G14
  BOTTOM w0.114: v1(203.12,55.11) 202.59,55.11 v3(202.09,55.61)
UART_CPLD_BMC_RX0: length 236.3
  TOP w0.114: v2(183.58,43.73) 186.13,46.28 186.76,46.28 U12.R1 ; R321.1 v2(8.28,29.66)
  S5 w0.102: v2(8.28,29.66) 8.86,29.08 12.89,29.08 14.01,27.96 14.01,14.81 21.38,7.44 21.38,3.48 23.69,1.17 60.11,1.17 61.85,2.91 62.27,2.91 62.66,3.3 65.14,3.3 65.15,3.29 65.53,3.29 65.53,3.3 65.84,3.3 66.23,2.91 69.01,2.91 69.75,3.65 71.94,3.65 72.21,3.38 75.08,3.38 75.13,3.43 77.37,3.43 77.42,3.38 82.69,3.38 83.02,3.05 83.47,3.05 89.06,8.65 94.39,8.65 95.32,9.57 95.32,11.75 96.41,12.84 96.41,20.58 97.06,21.23 v2(98.77,21.23)
  S8 w0.102: v2(98.77,21.23) 99.24,21.69 99.24,24.3 99.98,25.04 146.82,25.04 149.23,27.46 157.89,27.46 161.36,30.93 164.53,30.93 165.12,31.52 166.27,31.52 166.84,30.96 170.52,30.96 171.53,31.97 171.53,34.55 172.04,35.06 173.92,35.06 175.74,36.88 176.17,37.31 176.3,37.44 176.3,41.62 178.02,43.34 183.19,43.34 v2(183.58,43.73)
  BOTTOM w0.114: v1(182.46,43.86) 183.45,43.86 v2(183.58,43.73)
UART_CPLD_BMC_TX0: length 243.4
  TOP w0.114: R315.1 v2(8.28,30.93) ; U12.M1 187.35,51.11 186.58,51.88 183.08,51.88 182.22,51.01 182.22,47.19 v2(183.59,45.82)
  S5 w0.102: v2(97.8,21.7) 97.21,21.7 96.18,20.67 96.18,12.93 95.09,11.85 95.09,9.67 94.3,8.87 88.97,8.87 83.37,3.28 83.12,3.28 82.79,3.61 77.52,3.61 77.47,3.66 72.6,3.66 72.29,3.96 67.82,3.96 67.36,3.51 66.26,3.51 65.47,4.29 63.33,4.29 62.17,3.14 61.75,3.14 60.01,1.39 23.79,1.39 21.61,3.57 21.61,7.53 14.23,14.91 14.23,28.05 12,30.29 8.92,30.29 v2(8.28,30.93)
  S8 w0.102: v2(97.8,21.7) 97.98,21.89 97.98,23.69 99.53,25.23 99.79,25.5 146.63,25.5 149.04,27.91 157.7,27.91 161.17,31.39 164.34,31.39 164.93,31.98 166.46,31.98 167.03,31.42 170.33,31.42 171.07,32.16 171.07,34.9 171.68,35.51 173.73,35.51 175.29,37.07 175.84,37.63 175.84,41.81 177.83,43.8 181.56,43.8 v2(183.59,45.82)
  BOTTOM w0.114: v2(183.59,45.82) 183.45,45.96 v1(182.59,45.96)
UART_TXD_R_0: length 18.8
  TOP w0.108: v4(100.91,58.41) 100.82,58.32 U9.AG75
  TOP w0.114: R288.2 v2(99.98,43)
  S10 w0.102: v2(99.98,43) 99.98,45.27 100.51,45.8 100.51,53.16 100.76,53.42 100.76,58.26 v4(100.91,58.41)
  BOTTOM w0.114: v1(101.24,57.23) 100.91,57.56 v4(100.91,58.41)
UART_TXD_R_1: length 11.9
  TOP w0.114: R257.2 v2(99.98,49.22) 100.48,49.73 100.48,53.77 100.94,54.23 100.94,56.16 101.17,56.39 101.17,56.71 100.82,57.06 U9.AH76
  BOTTOM w0.114: v2(99.98,49.22) 99.36,49.83 99.36,50.37 v1(98.83,50.9)
UCD9090_ALERT_L: length 123.2
  TOP w0.114: v2(166.47,2.82) 166.09,2.82 165.18,1.91 161.78,1.91 161.26,2.43 159.39,2.43 158.7,1.74 141.47,1.74 139.6,3.6 v2(139.6,4.64) ; U12.N16 205.1,48.59 205.1,42.18 v2(205.36,41.93)
  S5 w0.102: v2(205.36,41.93) 207.92,39.36 207.92,4.09 205.87,2.03 182.28,2.03 181.44,1.19 179.57,1.19 179.54,1.22 171.73,1.22 170.13,2.82 v2(166.47,2.82)
  BOTTOM w0.127: CONN16.78 v2(139.6,4.64)
UIM_PWR: length 2.4
  BOTTOM w0.305: v1(198.55,105.13) CONN13.36
USB1_PWRFAULT: length 411.2
  TOP w0.114: U12.D14 v3(202.09,59.61)
  S5 w0.102: v2(25.63,80.14) 29.67,80.14 v2(30.43,80.9)
  S8 w0.102: v2(145.21,3.76) 144.17,2.72 127.94,2.72 125.76,4.9 122.78,4.9 122.53,5.15 115.49,5.15 110.03,10.6 95.65,10.6 94.66,11.6 93.22,11.6 92.88,11.25 89.1,11.25 87.37,11.25 86.76,10.64 85.42,10.64 84.56,9.78 84.45,9.78 84.05,9.38 84.05,6.61 81.25,3.81 78.01,3.81 77.96,3.76 76.5,3.76 76.19,4.06 70.8,4.06 70.7,4.17 67.95,4.17 67.52,3.73 66.7,3.73 65.88,4.55 59.89,4.55 59.63,4.28 56.49,4.28 55.99,4.78 53.4,4.78 52.27,5.91 52.27,7.94 51.6,8.61 49.54,8.61 47.6,10.55 47.6,12.56 45.05,15.11 41.7,15.11 40.69,16.13 30.69,16.13 26.7,20.11 26.7,55.01 27.93,56.24 28.33,56.24 30.07,57.98 30.07,76.46 30.48,76.86 30.48,79.72 30.43,79.77 v2(30.43,80.9) 30.43,102.88 37.73,110.19 47.66,110.19 51.68,114.2 60.46,114.2 61.2,114.94 62.07,114.94 62.29,114.71 63.89,114.71 64.12,114.94 68.58,114.94 69.5,115.85 72.38,115.85 72.84,115.39 73.41,115.39 74.05,116.03 76.68,116.03 77.33,115.38 78.31,115.38 81.13,112.56 81.13,111.91 81.92,111.12 81.92,108.36 81.61,108.05 81.61,107.29 v2(82.07,106.83) ; v3(202.09,59.61) 202.47,59.99 202.47,63.09 202,63.56 194.12,63.56 193.3,62.74 191.41,62.74 189.04,65.11 182.57,65.11 181.82,65.86 v2(180.8,65.86)
  S10 w0.102: v2(145.21,3.76) 145.21,4.56 149.14,8.48 161.23,8.48 166.7,13.96 166.7,17.11 166.8,17.21 166.8,17.59 166.73,17.66 166.73,22.07 170.44,25.78 171.89,25.78 174.7,28.59 174.7,36.1 180.26,41.66 180.26,55.26 179.96,55.57 179.96,58.6 180.37,59.01 180.37,63.72 180.19,63.9 180.19,65.25 v2(180.8,65.86)
  BOTTOM w0.114: R471.1 82.83,105.94 82.07,106.71 v2(82.07,106.83) 81.13,105.89 v1(81.13,105.03) ; R939.1 26.08,79.68 v2(25.63,80.14)
  BOTTOM w0.127: v2(145.21,3.76) 145.21,3.68 145.6,3.29 CONN16.54
USB1_VBUS: length 507.4
  TOP w0.114: v2(148.6,4.7) 148.6,3.7 149,3.3 157.91,3.3 158.6,3.99 160.24,3.99 161.8,5.55 165.74,5.55 167.68,7.48 169.92,7.48 174.18,11.75 174.18,13.47 173.48,14.17 170.61,14.17 169.31,15.47 169.31,19.03 168.4,19.94 v2(168.4,21.34) ; U12.P9 v3(197.09,48.61) ; R29.2 v2(68.35,112.6)
  S3 w0.102: v2(100.5,15.18) 100.5,14.72 97.49,11.71 88.38,11.71 86.76,10.08 85.76,10.08 85.42,9.74 85.42,8.81 83.65,7.04 77.44,7.04 76.91,6.5 70.65,6.5 69.48,5.33 67.05,5.33 66.46,4.74 56.68,4.74 55.7,5.71 55.7,6.49 54.6,7.59 54.03,7.59 52.99,8.64 43.1,8.64 43,8.53 41.69,8.53 40.26,9.96 31.46,9.96 30.35,11.07 30.35,11.19 29.27,12.27 26.24,12.27 25.73,11.76 11.07,11.76 4.17,18.67 4.17,22.52 3.81,22.88 3.81,89.58 21.93,107.7 30.5,107.7 36.44,113.64 36.44,115.5 35.96,115.97 35.96,117.67 38.82,120.52 62.8,120.52 65.15,118.17 65.15,115.82 66.09,114.88 66.43,114.88 67.27,114.05 67.27,113.72 68.35,112.64 v2(68.35,112.6)
  S5 w0.102: v2(27.08,80.98) 26.06,81.99 26.06,83.17 26.21,83.32 26.21,86.92 29.34,90.04 29.34,100.08 30.99,101.73 51.94,101.73 54.61,104.39 60.33,104.39 62.36,106.43 71.38,106.43 71.81,106.86 71.81,109.42 71.27,109.96 71.27,109.97 71,110.24 70.99,110.24 68.63,112.6 v2(68.35,112.6)
  S8 w0.102: v3(197.09,48.61) 197.09,47.94 196.2,47.05 196.2,46.54 195.17,45.52 194.97,45.52 194.44,44.98 194.44,43.87 193.9,43.33 193.73,43.33 188.42,38.02 188.42,31.4 187.65,30.63 183,25.98 178.99,25.98 178.83,25.83 178.83,25.83 174.06,21.06 172.77,21.06 172.34,21.49 168.55,21.49 v2(168.4,21.34) 168.17,21.56 164,21.56 162.55,20.12 153.01,20.12 147.29,14.4 143.8,14.4 142.07,16.13 126.11,16.13 123.6,18.64 114.28,18.64 112.07,16.43 105.59,16.43 105.29,16.13 101.12,16.13 100.5,15.51 v2(100.5,15.18)
  BOTTOM w0.114: R938.1 v2(27.08,80.98)
  BOTTOM w0.127: CONN16.42 v2(148.6,4.7)
USB1_VBUS_R: length 48.4
  TOP w0.114: R29.1 v2(70.79,112.6) ; v4(94.35,82.79) 94.33,82.77 94.32,82.77 U9.BB21
  S3 w0.102: v4(94.35,82.79) 93.88,83.26 93.88,85.91 93.11,86.68 93.11,87.1 92.61,87.59 92.61,88.09 92.3,88.4 92.3,93.88 90.93,95.25 89.66,95.25 85.88,99.03 83.22,99.03 80.59,101.65 77.14,101.65 73.64,105.15 73.64,106.39 74.73,107.48 74.73,110.13 74.35,110.52 73.67,110.52 73.18,111 72.21,111 71.58,111.63 71.58,112.12 71.09,112.6 v2(70.79,112.6)
  BOTTOM w0.114: v1(69.77,112.98) 70.41,112.98 v2(70.79,112.6)
USB2_DEBUG_DN: length 116.6
  TOP w0.127: CONN1.2 184.77,119.18 184.58,118.99 184.58,118.39 184.15,117.96 180.69,117.96 176.93,121.72 147.41,121.72 141.23,115.54 134.49,115.54 v3(133.99,115.04) ; v4(99.59,88.62) U9.AK9
  S8 w0.102: v4(99.59,88.62) 99.95,88.98 99.95,90.47 99.21,91.21 97.26,91.21 96.55,91.92 96.55,93.89 97.16,94.5 97.16,94.93 97.92,95.69 97.92,98.45 100.58,101.12 116.99,101.12 122.63,106.76 128.57,106.76 134.8,112.99 134.8,115.18 134.51,115.47 134.09,115.47 133.99,115.37 v3(133.99,115.04)
USB2_DEBUG_DP: length 116.7
  TOP w0.127: v3(133.99,116.31) 134.49,115.8 141.12,115.8 147.3,121.98 177.04,121.98 180.8,118.22 184.04,118.22 184.32,118.5 184.32,118.99 184.12,119.18 CONN1.3 ; U9.AH9 100.56,88.07 v4(100.56,88.62)
  S8 w0.102: v4(100.56,88.62) 100.15,89.03 100.15,90.56 99.3,91.41 97.34,91.41 96.75,92.01 96.75,93.8 97.36,94.41 97.36,94.84 98.12,95.61 98.12,98.37 100.67,100.91 117.08,100.91 122.72,106.55 128.65,106.55 135,112.9 135,115.27 134.59,115.67 134.2,115.67 133.99,115.87 v3(133.99,116.31)
USB2_DN_3: length 171.7
  TOP w0.114: U9.AG7 v5(101.07,88.31)
  S3 w0.102: v5(101.07,88.31) 101.07,89.5 100.91,89.66 100.91,92.83 97.87,95.88 97.87,97.18 97.67,97.37 97.67,102.5 98.5,103.34 98.5,105.49 v3(98.82,105.8)
  S5 w0.102: v3(19.3,75.73) 19.63,76.06 19.63,78.14 22.1,80.6 22.1,86.24 21.89,86.45 21.89,96.76 13.88,104.77 13.88,104.94 13.88,115.64 17.19,118.95 24.18,118.95 24.85,119.62 30.24,119.62 30.28,119.66 38.18,119.66 39.4,118.44 43.94,118.44 44.63,119.13 50.94,119.13 51.55,119.74 95.78,119.74 98.81,116.71 98.81,113.32 99.31,112.82 99.31,112.01 98.79,111.49 98.79,107.9 98.48,107.59 98.48,106.15 v3(98.82,105.8)
  BOTTOM w0.127: CONN14.25 20.38,71.48 20.24,71.62 19.63,71.62 19.04,72.2 19.04,73.85 19.57,74.38 19.57,75.45 v3(19.3,75.73)
USB2_DP_3: length 169.7
  TOP w0.114: U9.AJ7 100.21,88.91 v5(100.52,89.22)
  S3 w0.102: v5(100.52,89.22) 100.71,89.41 100.71,92.75 97.66,95.8 97.66,97.09 97.46,97.29 97.46,102.59 98.3,103.42 98.3,105.51 v3(98.01,105.8)
  S5 w0.102: v3(20.13,75.73) 19.84,76.02 19.84,78.05 22.3,80.52 22.3,86.33 22.1,86.53 22.1,96.84 14.08,104.85 14.08,115.56 17.27,118.75 24.26,118.75 24.93,119.42 30.32,119.42 30.36,119.46 38.1,119.46 39.31,118.24 44.03,118.24 44.71,118.92 51.02,118.92 51.63,119.53 95.7,119.53 98.6,116.63 98.6,113.24 99.11,112.73 99.11,112.1 98.59,111.58 98.59,107.99 98.27,107.67 98.27,106.07 v3(98.01,105.8)
  BOTTOM w0.127: CONN14.23 20.44,72.08 20.24,71.88 19.74,71.88 19.3,72.31 19.3,73.74 19.84,74.27 19.84,75.43 v3(20.13,75.73)
USB2_EUSB_DN: length 87.4
  TOP w0.102: U9.AE4 101.81,90.71 102.16,91.06 102.16,91.39 102.02,91.53 102.02,92.25 102.05,92.28 102.05,92.3
  TOP w0.127: v3(102.82,94.06) 102.55,93.78 102.55,93.05 102.05,92.55 102.05,92.3 ; v3(158.47,96.78) 158.84,96.4 160.8,96.4 160.93,96.53 CONN5.4
  S8 w0.102: v3(158.47,96.78) 158.07,96.37 157.78,96.37 157.53,96.62 157.53,102.54 152.63,107.44 146.53,107.44 144.32,109.65 132.76,109.65 131.9,108.8 131.9,105.72 129.98,103.81 129.98,96.35 129.31,95.68 126.52,95.68 125.68,96.52 113.79,96.52 110.69,93.42 102.64,93.42 102.51,93.55 102.51,93.75 v3(102.82,94.06)
USB2_EUSB_DP: length 87.4
  TOP w0.102: U9.AE2 101.81,92.25 101.78,92.28 101.78,92.3
  TOP w0.127: 101.78,92.3 101.78,92.66 102.28,93.16 102.28,93.78 v3(102.01,94.06) ; CONN5.6 160.93,96.01 160.8,96.14 158.84,96.14 v3(158.47,95.76)
  S8 w0.102: v3(158.47,95.76) 158.07,96.17 157.7,96.17 157.33,96.54 157.33,96.92 157.15,97.1 157.15,97.33 157.33,97.51 157.33,97.74 157.15,97.91 157.15,98.14 157.33,98.32 157.33,98.55 157.15,98.73 157.15,98.95 157.33,99.13 157.33,99.36 157.15,99.54 157.15,99.77 157.33,99.95 157.33,100.17 157.15,100.35 157.15,100.58 157.33,100.76 157.33,100.99 157.15,101.16 157.15,101.39 157.33,101.57 157.33,102.46 152.54,107.24 146.45,107.24 144.24,109.45 132.84,109.45 132.11,108.71 132.11,105.64 130.19,103.72 130.19,96.27 129.4,95.48 126.43,95.48 125.59,96.32 113.88,96.32 110.78,93.22 102.56,93.22 102.31,93.46 102.31,93.75 v3(102.01,94.06)
USB2_FRONT_DN: length 132.1
  TOP w0.127: U9.AD3 102.44,90.85 102.44,91.41 v4(102.79,91.77)
  S10 w0.102: v2(137.97,4.78) 137.97,5.2 138.25,5.48 138.25,6.28 138.85,6.88 145.1,6.88 146.02,7.81 146.02,13.35 135.1,24.27 135.1,68.85 131.39,72.57 125.98,72.57 125.3,73.25 125.3,82.03 121.97,85.36 121.97,88.69 121.07,89.59 119.72,89.59 119.41,89.28 113.77,89.28 113.51,89.03 110.22,89.03 109.18,87.99 108.07,87.99 104.03,92.02 103.05,92.02 v4(102.79,91.77)
  BOTTOM w0.127: v2(137.97,4.78) 137.97,4.7 138.22,4.45 138.22,3.49 138.1,3.37 CONN16.84 ; v4(102.79,91.77) 102.97,91.59 104.39,91.59 v1(104.62,91.36)
USB2_FRONT_DP: length 131.1
  TOP w0.127: U9.AD1 102.31,92.25 102.67,92.61 v4(102.79,92.61)
  S10 w0.102: v2(138.73,4.78) 138.73,5.2 138.45,5.48 138.45,6.2 138.94,6.68 145.19,6.68 146.23,7.72 146.23,13.44 135.31,24.36 135.31,68.94 131.47,72.77 126.06,72.77 125.5,73.33 125.5,82.12 122.17,85.45 122.17,88.77 121.16,89.79 119.63,89.79 119.33,89.48 113.68,89.48 113.43,89.23 110.13,89.23 109.09,88.19 108.15,88.19 104.11,92.23 103.17,92.23 v4(102.79,92.61)
  BOTTOM w0.127: CONN16.82 138.6,3.37 138.49,3.49 138.49,4.45 138.73,4.7 v2(138.73,4.78) ; v4(102.79,92.61) 103.28,92.61 v1(103.63,92.25)
USB2_OC0_REAR_N: length 4
  TOP w0.114: R80.1 v2(83.97,107.59)
  BOTTOM w0.114: v2(83.97,107.59) R80.1 R471.2 83.97,105.77 82.98,104.78 v1(82.98,104.75)
USB2_OC0_REAR_R_N: length 19.3
  TOP w0.102: U9.BH1 91.42,92.84 91.67,93.09
  TOP w0.114: R79.2 R80.2 v2(83.97,105) 84.48,104.5 84.48,101.96 91.67,94.77 91.67,93.09
  BOTTOM w0.114: v1(84.61,104.22) 83.97,104.85 v2(83.97,105)
USB3_OC1_REAR_N: length 3.3
  TOP w0.114: v2(90.42,104.24) 90.19,104.01 R112.1 89.64,104.01 R90.1
  BOTTOM w0.114: v1(91.49,105.07) 90.67,104.24 v2(90.42,104.24)
USB3_OC1_REAR_R_N: length 16.8
  TOP w0.102: U9.BE2 92.9,92.29 93.32,92.71
  TOP w0.114: v2(90.42,103.5) 90.02,103.1 R112.2 89.64,102.36 89.46,102.18 89.46,99.06 93.32,95.2 93.32,92.71
  BOTTOM w0.114: v1(91.49,103.8) 91.2,103.5 v2(90.42,103.5) 90.02,103.1 R112.2
VENDER1: length 3
  TOP w0.114: TP2.1 v2(182.55,90.55) 182.55,90.2 182.55,90.2 CONN6.45
VENDER2: length 4.5
  TOP w0.114: CONN6.47 v2(181.75,91.69) 181.75,92.84 TP1.1
VR_P1V2_VDDQ_PWRGD: length 195.3
  TOP w0.114: v2(55.58,9.17) 55.85,9.45 56.49,9.45 56.64,9.3 U29.9 ; U12.L10 v3(198.09,51.61)
  S5 w0.102: v3(198.09,51.61) 198.09,51.61 197.61,51.13 197.61,49.43 197.37,49.18 196.63,49.18 194.85,47.4 192.16,47.4 190.98,46.22 190.98,45.19 190.53,44.75 189.08,43.29 189.08,35.14 180.31,26.37 180.15,26.37 179.35,25.56 179.35,25.41 177.27,23.33 177.27,16.19 176.34,15.27 173.11,15.27 169.13,11.29 161.48,11.29 157.31,7.12 139.12,7.12 138.27,7.98 130.83,7.98 129.85,7 128.69,7 127.88,7.81 126.74,7.81 126.69,7.75 125.35,7.75 125.13,7.97 123.43,7.97 122.81,7.35 122.19,7.35 v2(122.17,7.37)
  S8 w0.102: v2(122.17,7.37) 122.17,7.49 121.28,8.38 114.65,8.38 110.83,12.2 96.31,12.2 95.32,13.2 92.56,13.2 92.21,12.85 89.76,12.85 86.71,12.85 86.1,12.24 84.76,12.24 84.2,11.68 82.41,11.68 80.06,9.33 80.06,6.4 79.14,5.49 78.28,5.49 76.67,7.1 74.05,7.1 73.79,7.36 70.21,7.36 69.1,6.25 68.01,6.25 66.89,7.37 62.06,7.37 61.72,7.02 61.34,7.02 59.2,9.17 v2(55.58,9.17)
  BOTTOM w0.114: v2(122.17,7.37) 121.41,8.13 v1(119.51,8.13) ; v2(55.58,9.17) 55.58,8.52 56.4,7.69 56.4,4.99 57.63,3.76 R758.1
VR_P1V2_VDDQ_PWRGD_LED6: length 62.5
  TOP w0.114: LED6.C v2(202.06,117.61) ; U12.B9 v3(197.09,61.61)
  S5 w0.102: v2(202.06,117.61) 202.06,108.34 204.37,106.04 204.37,102.56 203.47,101.66 203.47,101.09 204.52,100.04 204.52,90.79 200.36,86.62 200.36,66.1 199.14,64.88 199.14,63.66 v3(197.09,61.61)
VR_P1V2_VDDQ_PWRGD_R: length 35.8
  TOP w0.114: LED6.A v2(202.06,120.9)
  S10 w0.102: v2(202.06,120.9) 201.52,120.35 201.52,112.4 198.04,108.93 192.55,108.93 182.25,98.63 v2(182.25,98.26)
  BOTTOM w0.114: R410.2 v2(202.06,120.9)
VR_P1V05_PCH_VRHOT_N: length 160.2
  TOP w0.114: U12.N12 v3(200.09,49.61)
  S3 w0.102: v2(80.57,2.36) 80.98,2.36 88.95,10.34 100.01,10.34 v2(104.15,14.47)
  S8 w0.102: v3(200.09,49.61) 200.09,49.59 200.53,49.15 200.53,47.05 200.92,46.67 200.92,46.04 200.31,45.44 200.31,44.45 199.03,43.18 198.03,43.18 197.82,42.97 196.79,42.97 195.42,41.6 195.42,39.46 190.63,34.67 190.63,27.15 188.04,24.56 179.6,24.56 177.93,22.89 177.93,21.71 177.23,21.01 177.23,20.01 176.69,19.47 176.22,19.47 174.77,18.02 174.77,16.25 170.13,11.61 160.46,11.61 156.29,7.44 138.19,7.44 131.36,14.27 119.72,14.27 118.93,15.06 106.16,15.06 105.83,14.73 104.41,14.73 v2(104.15,14.47)
  BOTTOM w0.114: v1(80.99,4.19) 80.99,3.95 R777.1 80.21,2.72 v2(80.57,2.36)
VR_P1V05_PCH_VSP_NC: length 2.5
  TOP w0.305: v4(86.96,89.44) 87.25,89.73 U9.BT5
  BOTTOM w0.114: v4(86.96,89.44) 86.79,89.61 C285.2 v1(87.73,90.35)
VR_P3V3_CPLD_EN: length 52.8
  TOP w0.114: U12.F6 v3(193.09,57.61)
  S8 w0.102: v3(193.09,57.61) 192.53,58.17 189.48,58.17 182.98,51.66 182.98,48.96 179.21,45.19 179.2,45.19 179.18,45.16 159.77,45.16 157.23,42.62 v2(157.23,41.2)
  BOTTOM w0.114: v2(157.23,41.2) 157.23,38.86 156.84,38.48 154.86,38.48 154.23,37.85 R732.1
VR_P5V_STBY_EN: length 103.1
  TOP w0.114: U12.D4 v3(191.09,59.61) ; R34.1 v2(129.79,112.17) 129.33,112.63 U4.7
  S3 w0.102: v3(191.09,59.61) 190.53,60.17 190.53,60.85 190.47,60.9 190.47,63.11 188.85,64.73 188.85,69.39 171.15,87.09 171.15,93.45 171.12,93.47 171.12,96.65 165.94,101.83 162.76,101.83 161.57,103.02 149.63,103.02 146.84,105.82 138.46,105.82 137.82,106.45 130.18,106.45 v2(129.49,105.77)
  BOTTOM w0.114: v2(129.49,105.77) 128.78,105.77 127.71,106.83 v1(127.71,107.49) 127.71,110.67 127.94,110.89 R455.2 129.77,112.17 v2(129.79,112.17)
VR_PVCCIN_EN: length 151.3
  TOP w0.114: R395.2 v2(76.33,2.74) ; U12.N9 v3(197.09,49.61)
  S3 w0.102: v2(98.91,14.21) 98.91,14 97.08,12.17 88.19,12.17 86.57,10.54 85.55,10.54 85.45,10.44 85.45,10.44 84.73,9.73 v2(84.73,9.09)
  S8 w0.102: v2(98.91,14.21) 98.91,14.64 100.86,16.59 105.1,16.59 105.4,16.89 111.88,16.89 114.09,19.1 114.47,19.1 114.47,19.1 140.09,19.1 140.42,18.77 146.2,18.77 150.72,23.29 169.34,23.29 171.02,24.97 176.78,24.97 178.53,26.72 182.12,26.72 182.31,26.72 187.96,32.38 187.96,38.21 193.27,43.52 193.27,44.5 194.74,45.97 194.98,45.97 195.51,46.5 195.51,47.01 196.24,47.74 196.24,49.22 196.63,49.61 v3(197.09,49.61)
  BOTTOM w0.114: v2(84.73,9.09) 84.73,7.16 82.96,5.39 v1(82.33,5.39) 81.88,5.84 81.14,5.84 R747.1 R746.1 79.56,6.35 79.04,5.84 77.11,5.84 76.33,5.05 v2(76.33,2.74)
VR_PVCCIN_VRHOT_N: length 174.5
  TOP w0.114: U12.P12 v3(200.09,48.61) ; R394.2 v2(75.41,2.74)
  S3 w0.102: v2(75.41,2.74) 75.9,2.26 77.42,2.26 78.11,2.95 81.24,2.95 88.86,10.57 99.57,10.57 v2(102.95,13.94)
  S8 w0.102: v2(102.95,13.94) 102.97,13.94 103.99,14.96 105.74,14.96 106.07,15.29 119.03,15.29 119.36,14.96 119.38,14.96 119.84,14.5 131.45,14.5 138.28,7.67 156.2,7.67 160.36,11.84 170.04,11.84 172.44,14.24 172.44,18.5 173.04,19.11 173.79,19.11 174.38,19.7 176.6,19.7 177,20.1 177,21.11 177.66,21.77 177.66,23.04 179.41,24.79 187.95,24.79 190.4,27.24 190.4,36.97 193.89,40.46 194.97,40.46 195.19,40.68 195.19,43 195.29,43.1 196.15,43.1 196.24,43.2 197.72,43.2 197.93,43.41 198.94,43.41 200.08,44.55 200.08,45.53 200.69,46.14 200.69,46.57 200.09,47.17 v3(200.09,48.61)
  BOTTOM w0.114: R750.1 76.02,3.76 75.41,3.15 v2(75.41,2.74) 75.95,2.21 77.33,2.21 78.29,3.17 R777.2 79.3,4.07 v1(79.54,4.3)
