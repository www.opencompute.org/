# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P2V5_SS: length 3.4
  TOP w0.381: v1(233.53,204.93) 234.38,205.78 PC249.1 232.56,206.13 PU12.5
P2V5_SW: length 7.6
  TOP w0.381: 231.08,204.71 231.26,204.52 PU12.2
  TOP w0.508: PC242.2 228.54,205.62 PL11.1
  BOTTOM w0.381: v1(229.55,204.58) 229.17,204.96 PR259.1
P2V5_VBST: length 3.9
  TOP w0.508: PU12.8 230.61,206.84 230.07,207.38 PR258.1
P2V5_VFB: length 27.5
  TOP w0.381: PU12.6 231.91,207.46 231.46,207.91 PC251.2 PR263.2 PR265.1 v1(234.31,208.37)
  T16 w0.381: v1(234.31,208.37) 234.31,211.08 232.79,212.6 222.45,212.6 v1(221.36,211.51)
  BOTTOM w0.381: v1(221.36,211.51) PR320.1 222.22,210.98 221.82,210.57 PQ16.2
P2V5_VFB_IN: length 10.3
  TOP w0.381: PR260.2 231.46,210.12 PC251.1 PR263.1 v1(232.54,209.89)
  T16 w0.381: v1(232.54,209.89) 231.91,210.52 227.1,210.52 v1(226.93,210.35)
  BOTTOM w0.381: PR329.1 226.2,209.62 v1(226.93,210.35)
P2V5_VFB_IN_R: length 3.8
  BOTTOM w0.381: PQ16.3 224.88,209.32 PR329.2 225.18,210.11 v2(224.62,210.67)
P2V5_VFB_R: length 3.7
  TOP w0.381: PQ17.3 223.42,212.37 v1(223.93,211.86)
  BOTTOM w0.381: v2(225.15,211.86) v1(223.93,211.86) 223.39,211.86 PR320.2
P2V5_VIN:
  vias: v1(232.27,198.18) v1(232.78,201.61) v1(233.08,198.18) v1(233.39,200.84) v1(233.8,198.63) v2(231.92,202.88) v2(233.21,202.88) v2(234.54,202.9) v2(234.53,197.69)
P2V5_VREF: length 104.5
  TOP w0.381: U70.D3 v4(111.6,130.45)
  TOP w0.508: R782.2 R781.1 68.91,181.02 v1(69.22,180.72)
  T14 w0.508: v1(72.05,133.22) 72.52,133.69 72.52,137.92 73.28,138.68 73.28,152.4 75.24,154.36 75.24,161.87 66.8,170.31 66.8,175.51 68.33,177.04 68.33,178.69 67.82,179.2 67.82,179.96 68.58,180.72 v1(69.22,180.72)
  BOTTOM w0.508: v1(72.05,133.22) 72.39,133.56 R13056.1 73.24,134.54 74.3,133.48 75.11,133.48 U115.1 82.68,132.33 84.1,130.91 v1(86.49,130.91) 86.87,131.3 86.87,133.22 90.3,136.65 95,136.65 96.01,137.67 104.14,137.67 105.25,138.78 C2462.1 108.26,138.25 109.6,136.91 v1(109.6,136.53) ; C1604.1 69.34,180.59 v1(69.22,180.72)
P3V3: length 1028.9
  TOP w0.254: v6(38.07,138.11) 37.57,138.11 37.31,138.36 37.31,148.62 36.58,149.35 35.18,149.35 34.82,149.71 PR83.1 ; PR428.1 8.26,164.42 8.51,164.17 9.44,164.17 10.31,163.29 10.31,162.95 10.31,162.95 10.31,152.91 10.57,152.65 v6(11.3,152.65)
  TOP w0.305: v1(102.11,91.4) 101.89,91.62 101.08,91.62 U85.10 ; 131.98,173.38 131.93,173.33 U176.20 ; v1(63.75,79.69) 63.99,79.45 U127.73 ; PR86.1 29.64,156.14 28.96,155.46 28.96,153.16 30.54,151.58 v1(31.21,151.58) ; U162.7 v1(88.93,79.92) ; U85.64 100.27,84.65 C1632.2 ; C1257.1 205.48,76.09 203.12,76.09 v1(201.92,77.29) ; PU10.10 262,154.64 ; U162.5 86.94,79.21 86.94,78.6 v1(87.19,78.35) 87.44,78.61 U162.6 ; U85.41 91.18,90.61 v1(91.02,90.45) ; v1(95.92,93.95) 95.27,94.6 U85.27 ; C2397.1 128.12,202.98 U178.14 ; U127.52 71.92,87.72 v1(71.88,87.69) ; v1(178.48,84.33) 178.48,87.27 170.52,95.23 170.52,104.01 165.23,109.31 165.23,124.47 167.03,126.27 167.03,132.94 156.21,143.76 137.79,143.76 129.23,152.33 54.03,152.33 51.59,149.89 46,149.89 v1(45.97,149.86)
  TOP w0.33: C1935.2 U108.5
  TOP w0.381: R1710.1 v1(116.71,171.69) ; v1(119,139.06) 118.58,139.06 R1699.1 ; R1999.2 v1(133.95,177.54) ; U70.H7 v4(115.6,126.45) ; R1702.1 v1(24.99,152.78) ; R1881.1 v1(103.6,187.39) ; R1882.1 v1(104.88,187.39) ; R1016.1 129.66,193.07 v1(130.28,192.46) 129.66,191.84 R1015.1 ; R12802.1 10.57,81.64 v1(11.05,81.15) 11.53,81.64 R12806.1 ; v1(117.84,81.41) 117.39,80.97 R623.2 ; R1013.1 129.85,189.29 v1(130.43,189.87) 129.74,190.56 R1014.1 ; R1144.1 v1(285.8,183.13) ; U140.8 11.14,76.29 11.58,76.73 C2042.2 11.58,77.95 v1(11.05,78.49) ; U23.B7 v4(136.21,99.36) ; C1935.2 v1(24.31,62.36) ; C2154.2 180.59,158.71 180.59,159.26 v1(180.34,159.51) 180.11,159.75 L172.1 ; R309.1 v1(298.16,86.37) ; 73.47,48.13 U96.10 ; U121.1 v1(35.65,49.32) ; v1(120.62,178.41) C2432.2 U177.5 ; R1788.2 155.12,123.2 v1(155.7,122.62) 156.08,123 R1781.2 R1782.2 ; v1(133.22,126.74) 132.62,126.14 R12789.1 ; v1(21.86,20.23) C1938.2 21.22,19.67 21.73,19.16 U105.5 ; U25.K11 v4(283.1,90.39) ; R12812.1 17.55,81.88 17.54,81.88 v1(17.53,81.88) ; v1(141.99,97.92) 141.63,97.57 R282.1 ; U127.6 69.97,74.36 v1(69.77,74.55) ; v1(54.97,77.12) R1627.1 ; R1104.1 v1(263.78,183.26) ; U136.5 C2368.1 v1(103.38,179.37) ; PR142.2 295.2,132.6 296.2,133.6 PR152.1 PR153.1 PR154.1 PC55.1 297.16,135.53 297.17,135.52 v1(297.17,135.51) ; R1706.1 v1(105.41,119.78) ; U70.J3 v4(111.6,125.65) ; v1(159.77,114.9) 159.54,114.66 R12767.1 ; v1(8.7,16.89) C1815.2 U107.5 ; R1705.1 v1(65.21,171.53) ; v1(125.86,130.11) 125.61,130.35 R996.1 ; R1907.2 v1(14.71,15.39) ; R1717.1 v1(75.8,171.58) ; R31.2 v1(169.05,138) ; v4(123.11,96.38) 123.47,96.74 123.6,96.74 U23.P9 ; R12937.1 v1(14.49,80.4) ; v1(127.38,201.29) 127.51,201.17 C2397.1 ; v1(105.15,133.04) 105.08,133.1 105.08,135.97 105.54,136.43 R822.1 ; R1689.2 v1(10.41,70.41) ; v1(114.2,96.13) 114.02,95.95 R1803.2 ; R29.2 169.2,133.92 v1(169.04,133.77) ; U70.C7 v4(115.6,131.25) U70.C8 ; v1(82.04,123.19) 81.83,122.98 C2426.2 U112.5 ; U110.1 28.66,49.32 v1(28.83,49.15) ; U137.5 93.58,178.86 C2123.1 v1(93.57,179.71) ; R1804.2 141.66,95.31 v1(142.24,95.89) 141.83,96.29 R284.2 ; R12801.1 v1(8.02,81.15) ; R1758.1 87.63,140.21 v1(87.25,139.83) ; U70.F7 v4(115.6,128.85) ; L139.2 C1644.2 124.86,118.13 v1(124.59,117.86) ; v1(72.77,74.48) 72.57,74.28 U127.10 ; R1806.2 125.75,81.28 v1(126.24,81.28) 126.76,81.28 R1810.2 ; v1(161.94,79.28) 161.48,78.82 R1569.2 ; D65.5 37.52,15.36 v1(37.89,15.73) ; R1712.1 v1(137.9,171.69) ; R1836.1 v1(85.22,171.58) ; v1(116.1,117.71) 115.95,117.86 R1756.1 ; v1(90.93,201.04) 90.65,200.76 R1830.2 ; v1(157.81,114.81) 158.13,114.49 R12765.1 ; R1709.1 v1(86.29,171.58) ; R1191.2 v1(33.28,52.9) ; R1741.1 v1(105.26,173.74) ; R1743.1 v1(103.98,173.74) ; v1(86.88,123.68) C2461.2 86.36,122.93 86.16,123.14 U111.5 ; J8.7 44.83,68.07 v1(44.7,67.94) ; U106.4 C2430.2 v1(22.8,11.88) ; v1(259.92,189.17) 259.66,189.17 259.28,188.79 R1103.1 ; v1(106.81,97.47) 106.81,97.92 106.04,98.68 CN6.3 ; U70.F11 v4(118.8,128.05) U70.G11 ; v1(37.75,50.74) 37.74,50.76 R12921.2 ; v1(260.58,157.1) PR236.1 259.49,155.22 PC210.1 262,154.64 ; 131.98,173.38 C2431.2 133.58,173.38 v1(133.86,173.1) ; R1129.1 v1(275.03,187.52) ; v1(65.03,132.71) 64.5,132.18 63.88,132.18 63.88,132.18 C2374.2 63.8,132.21 U200.5 ; R12821.2 v1(276.04,106.55) ; R1875.2 v1(110.35,173.74) ; R1700.1 v1(119,137.6) ; v4(131.24,95.43) 131.71,94.96 U23.F11 ; R1679.2 v1(16.91,103.15) ; R1688.2 v1(6.86,70.41) ; v1(226.12,81.7) 226,81.82 R635.2 ; R12972.2 v1(291.21,107.45) ; v1(79.5,80.82) 79.64,80.82 79.71,80.75 U127.30 ; R1049.2 v1(180.01,151.92) ; v1(105.26,128.5) 105.41,128.65 R1695.1 ; U138.5 96.76,178.86 C2209.1 96.2,178.87 v1(96.01,178.69) ; R1980.2 v1(151.1,123.29) ; D69.5 17.52,67.55 v1(17.27,67.31) ; R12773.1 181.61,159.51 v1(181.1,160.02) ; R1776.2 157.1,137.54 v1(156.59,138.05) 156.08,137.54 R1787.2 ; v1(163.83,133.66) 163.73,133.66 R1780.2 ; R1752.1 v1(20.95,165.86) ; v1(183.86,158.3) 183.86,158.46 183.62,158.7 R12774.1 ; U25.L6 v4(282.1,96.39) ; v1(152.68,123.3) R1789.2 ; R12480.2 v1(88.01,126.07) ; R1755.1 72.01,169.8 v1(71.63,169.42) ; R30.2 R300.2 169.44,131.95 v1(169.16,131.95) ; R1908.2 v1(14.71,13.39) ; R1048.2 180.01,154.51 v1(180.03,154.5) ; U25.T9 v4(277.1,93.39) ; U150.24 111.72,176.19 111.6,176.08 C1358.1 112.04,175.2 v1(112.35,175.51) ; R1764.2 100.4,173.52 99.97,173.09 v1(99.97,172.78) ; v1(17.4,80.64) 17.15,80.4 R12936.1 ; R1058.2 v1(107.39,193.71) ; v1(108.58,88.93) 108.41,88.75 U86.8 ; R12820.2 v1(117.07,89.68) ; R1655.2 31.69,86.61 v1(32,86.93) ; R1757.1 v1(117.89,171.78) ; U127.8 71.27,74.4 v1(71.42,74.55) ; U23.K6 v4(127.21,100.36) ; v1(169.08,136.07) 169.19,135.96 R28.2 ; R12971.2 288.09,107.27 v1(287.95,107.41) ; R1141.1 v1(270.69,187.08) ; R1883.1 v1(106.15,187.39) ; R1981.1 v1(88.12,172.7) ; U121.10 36.43,46.41 v1(36.5,46.34) ; R1739.1 v1(109.07,173.74) ; R1707.1 v1(84.15,171.58) ; v1(91.98,100.03) R1216.1 92.71,100.03 93.33,100.03 93.33,100.03 R1218.1 ; U25.K9 v4(283.1,93.39) ; U70.C6 v4(114,131.25) ; U70.J11 v4(118.8,125.65) ; v1(276.02,116.63) C2436.1 U46.8 ; R1704.1 v1(105.41,122.99) ; v1(84.76,172.8) C2433.2 U71.8 ; R999.1 R998.1 v1(105.92,133.1) ; v1(18.06,103.15) R1678.2 ; v1(113.02,187.38) 113.03,187.38 R1872.2 ; L137.2 v1(53.41,79.88) ; v1(69.98,173.74) C1635.1 U194.5 ; R1809.2 v1(123.67,81.64) ; U70.G6 v4(114,128.05) ; U70.L7 v4(115.6,124.05) U70.L8 ; R1690.2 v1(9.12,70.38) ; R1884.1 v1(107.42,187.39) ; U127.16 76.47,74.34 v1(76.12,74.68) 75.82,74.37 U127.15 ; R1130.1 v1(264.11,187.64) ; U70.G3 v4(111.6,128.05) U70.F2 ; U25.M10 v4(281.1,91.39) ; v1(29.06,46.18) 28.84,46.41 U110.10 ; R1220.1 v1(99.95,102.87) ; R12810.1 v1(21.46,81.85) ; D67.5 v1(9.78,14.54) ; PR420.1 v5(3.73,168.02) ; R1877.2 v1(108.69,187.39) ; R821.1 108.84,137.13 v1(108.84,136.53) ; R1677.2 v1(19.2,103.15) ; U70.H11 v4(118.8,126.45) ; R646.2 v1(125.98,126.26) ; R2000.2 v1(133.95,175.5) ; U70.G8 v4(116.4,128.05) ; v1(130.94,169.29) R12949.2 ; U70.K3 v4(111.6,124.85) ; D68.5 v1(31.17,66.97) ; R12807.1 v1(14.12,81.15) ; v1(130.43,195.58) R1703.1 ; v1(112.33,137.47) R1711.1 ; R1760.1 v1(114.03,171.72) ; R1716.1 v1(77.01,171.58) ; R1277.1 v1(264.45,112.05) ; R1747.1 v1(106.53,173.74) ; U70.L6 v4(114,124.05) ; R67.2 v1(172.48,130.23) ; R1198.2 v1(26.17,52.06) ; R1276.1 v1(264.41,113.32) ; R283.2 v1(142.03,98.84) ; R27.2 v1(172.48,132.78) ; R1713.1 v1(73.07,171.62) ; R1876.2 v1(111.9,187.39) ; U76.16 C1373.2 v1(134.67,180.92) ; R12916.2 v1(26.78,68.8) ; R1714.1 v1(136.63,171.69) ; R1694.1 v1(123.7,136.86) ; R1753.1 v1(20.95,164.47) ; R1745.1 v1(107.8,173.74) ; R1751.1 v1(115.29,171.72)
  TOP w0.508: R298.2 v1(183.45,123.8) ; R299.2 v1(183.45,122.53) ; v1(188.97,120.71) 188.56,120.29 R301.2 ; R32.2 v1(183.45,127.62) ; v1(186.93,130.16) R26.2
  T05 w0.305: v1(31.21,151.58) 32.93,149.86 v1(45.97,149.86)
  T18 w0.254: v1(186.93,130.16) 186.29,129.53 185.36,129.53 v1(183.45,127.62)
  T18 w0.381: v1(178.48,84.33) 182.52,80.28 198.93,80.28 201.92,77.29 v1(201.92,77.29)
  BOTTOM w0.305: U149.20 110.24,108.99 C1317.1
  BOTTOM w0.381: U54.24 101.79,27.11 C1360.1 v1(100.82,26.44) ; R1818.2 112.03,88.27 v1(112.52,87.77) ; R561.2 v1(210.47,36.72) R554.2 ; v1(134.11,40.01) 134.24,39.88 R341.2 ; C1634.2 v1(95.92,93.95) ; C2121.1 v1(102.11,91.4) ; R906.2 v1(283.45,36.27) R907.2 ; v1(229.56,27.05) R881.2 229.58,27.76 229.59,28.29 R879.2 ; R885.2 v1(225.18,36.72) R884.2 ; C1641.1 35.58,49.26 v1(35.65,49.32) ; R566.2 v1(252.41,36.72) R573.2 ; C895.2 120.31,128.46 119.9,128.05 v4(118.8,128.05) 118.83,128.02 C1401.1 118.83,126.48 v4(118.8,126.45) v4(118.8,125.65) ; R902.2 v1(291.17,30.07) ; R1613.1 v1(75.69,86.29) ; v1(69.77,74.55) 69.86,74.47 C1994.2 ; R904.2 288.72,28.15 v1(289.87,28.15) ; v1(85.47,27.87) C1375.2 U62.24 ; R1807.2 117.6,90.86 v1(117.09,91.37) 117.6,91.88 R1808.2 ; R328.2 v1(121.91,37.72) R335.2 ; v1(222.33,22.78) 222.72,23.17 R874.2 ; R1989.2 138.41,177.06 v1(138.18,177.29) ; v1(100.91,10.93) C1374.2 103.24,10.93 U68.16 ; R557.2 v1(239.43,36.72) R550.2 ; v1(246.36,28.63) C1366.1 247.06,27.76 247.95,26.87 U55.24 ; R558.2 v1(192.72,39.9) ; R316.2 v1(181.04,37.72) R323.2 ; R414.2 v1(181.42,20.04) ; R12771.1 R12769.1 v1(154.51,118.62) ; C985.2 126.71,100.86 v4(127.21,100.36) ; R1687.2 v1(4.15,73.76) ; R880.2 v1(228.31,20.06) ; R972.2 v1(105.42,6.33) ; C986.2 283.52,92.97 v4(283.1,93.39) ; v4(283.1,90.39) 282.68,89.97 C1397.2 ; R12915.1 v1(17.4,83.85) ; R741.2 261.23,35.98 v1(261.8,36.56) R747.2 ; R1576.2 273.46,80.29 v1(273.66,80.5) ; R438.2 v1(240.42,19.93) ; R841.2 v1(90.48,37.72) R840.2 ; R445.2 v1(241.82,20.02) ; R334.2 135.26,39.88 v1(135.13,40.01) ; R842.2 v1(88.6,23.09) ; R564.2 v1(238.06,36.72) R571.2 ; C1979.1 v1(36.5,46.34) ; R425.2 v1(191.07,18.05) ; U20.20 206.88,10.41 206.51,10.77 C789.2 v1(205.19,11.5) ; v4(111.6,125.65) 111.78,125.83 C1390.1 111.77,126.44 C1384.1 ; v4(111.6,125.65) v4(111.6,124.85) 110.81,124.06 C1395.1 ; v4(111.6,125.65) 110.86,125.65 C1385.1 ; v1(114.49,28.59) C1359.1 114.58,27.78 116.51,27.78 U53.24 ; R875.2 v1(223.84,22.8) ; R912.2 v1(279.33,36.27) R913.2 ; C1991.2 74.63,76.84 74.58,76.88 C1999.2 73.36,75.07 v1(72.77,74.48) ; R893.2 218.96,36.83 218.42,36.83 v1(218.31,36.72) R891.2 ; v1(9.59,36.58) 10.07,37.05 R13008.2 ; v1(168.28,82.42) 168.11,82.25 R1080.2 R1079.2 ; U63.24 C1372.2 v1(157.47,28.58) ; U14.14 159.93,11.42 158.57,10.07 C807.2 v1(157.71,9.68) ; R851.2 162.67,23.13 v1(162.63,23.09) ; v1(121.28,133.29) 121.28,132.77 C1393.1 122.12,132.85 v1(122.12,133.34) ; R862.2 v1(163.18,37.72) R863.2 ; R964.2 v1(108.61,21.54) ; R731.2 248.56,38.27 v1(248.24,38.6) ; R12468.1 279.86,197.93 v1(279.37,197.44) ; v1(247.7,9.12) 247.7,8.16 248.08,7.78 C843.2 248.58,7.86 248.58,9.51 248.61,9.54 U22.20 ; R410.2 v1(109.75,23.09) ; R688.2 185.66,37.61 v1(186.22,37.61) 186.24,37.59 R697.2 ; v1(87.3,9.12) 88.01,8.41 C771.2 88.81,8.99 88.81,9.79 88.84,9.81 U10.14 ; R833.2 v1(96.59,22.16) ; R400.2 v1(180.18,23.09) ; v1(232.11,28.65) C1367.1 232.71,27.75 233.59,26.87 U56.24 ; R837.2 v1(93.23,37.72) R836.2 ; C2097.1 88.27,80.59 v1(88.93,79.92) ; R543.2 v1(240.8,36.72) R536.2 ; R552.2 v1(253.78,36.72) R559.2 ; v1(288.18,19.87) 288.14,19.91 R539.2 ; v1(260.46,28.52) C1365.1 261.16,27.76 262.05,26.87 U57.24 ; R356.2 v1(119.16,37.72) R363.2 ; R368.2 v1(104.25,23.09) ; U18.14 219.89,12.25 219.07,11.42 C772.2 v1(218.34,9.55) ; R888.2 v1(222.44,36.72) R889.2 ; v1(256.35,20.91) 256.35,21.39 256.35,21.39 R447.2 ; v1(183.41,22.03) 183.39,22.01 183.39,21.31 R421.2 ; v1(123.83,87.62) 123.84,87.62 123.84,87.61 124.46,87.61 124.84,88 124.84,88.14 124.59,88.39 v1(123.83,88.39) ; v1(166.96,19.81) 166.96,19.83 R856.2 ; v1(28.83,49.15) 28.62,49.36 27.81,49.36 ; v1(139.2,115.03) 139.44,115.27 R12461.1 R12460.1 ; R1001.2 125.42,144.75 v1(125.82,145.15) ; R694.2 R693.2 128.72,37.61 v1(128.74,37.62) ; R586.2 v1(188.65,39.9) ; R551.2 v1(193.73,39.9) 194.23,39.9 194.75,39.37 R544.2 ; R375.2 v1(105.62,23.09) ; R314.2 v1(123.28,37.72) R321.2 ; U19.2 v1(239.4,13.19) ; v1(260.99,194.66) 260.73,194.4 R1124.1 ; R565.2 v1(191.7,39.9) ; R537.2 196.8,34.1 v1(196.83,34.07) ; R1988.2 v1(139.47,176.66) ; R441.2 v1(283.14,6.53) ; C2077.1 276.6,93.89 v4(277.1,93.39) ; v1(261.59,9.12) 261.59,8.64 262.03,8.2 C834.2 262.77,9.05 264.13,10.41 U21.14 ; R442.2 v1(212.02,20.31) ; R407.2 v1(180.18,22.16) ; U51.24 129.92,27.82 C1357.1 v1(128.31,28.59) ; R412.2 v1(123.79,23.09) ; v1(111.44,110.45) 111.38,110.39 R1846.2 ; U21.2 v1(264.78,15.67) ; v4(114,131.25) 114.16,131.41 C1402.2 ; R1273.1 v1(276.64,111.45) ; R1221.1 115.25,90.25 115.73,90.74 v1(115.95,90.74) 115.47,91.22 R1222.1 ; R861.2 v1(164.55,37.72) R860.2 ; R389.2 112.68,20.11 111.96,20.83 111.61,20.83 R403.2 111.36,21.08 v1(111.36,21.52) ; R1721.1 v1(123.69,121.64) ; R710.2 v1(118.34,20.55) ; U61.5 67.75,184.37 C2062.1 v1(68.68,184.3) ; R327.2 136.27,39.88 v1(136.14,40.01) ; R1143.1 v1(270.33,182.25) ; R1991.2 v1(140.49,176.66) ; R748.2 v1(263.52,38.27) ; v1(139.64,90.58) R1802.2 ; v1(116.1,117.71) 116.18,117.79 R1701.1 ; v1(226.57,22.67) 226.2,23.04 R878.2 ; R434.2 v1(281.77,6.53) ; R1801.2 138.48,90.63 139.27,89.84 v1(139.64,89.84) ; U48.24 C1364.1 v1(143.16,27.16) ; R417.2 v1(109.87,21.53) ; R890.2 220.2,22.71 v1(220.09,22.61) ; R985.2 v1(299.99,43.84) ; R830.2 v1(94.1,23.09) ; R340.2 v1(106.49,37.72) R347.2 ; U65.24 C1379.2 v1(274.99,27.13) ; R432.2 v1(192.08,18.05) ; R839.2 91.86,37.81 v1(91.77,37.72) 91.86,37.64 R838.2 ; L138.2 91.16,84.61 C1689.2 89.03,84.61 v3(88.9,84.74) ; R858.2 v1(165.93,37.72) R859.2 ; R448.2 v1(284.42,6.49) ; R333.2 v1(107.86,37.72) R326.2 ; U50.24 C2219.1 v1(274.56,10.42) ; v1(203.84,36.62) R675.2 ; R391.2 v1(121.04,22.16) ; v1(203.06,27.53) C1361.1 U49.24 ; R371.2 v1(146.97,23.09) ; v1(302.34,44.01) 302.13,43.8 R983.2 ; C1399.2 110.93,127.38 v4(111.6,128.05) 110.97,128.69 C1389.2 110.12,128.69 109.84,128.97 C1386.1 ; R1847.2 v1(108.71,110.55) ; R1620.2 v1(71.15,81.34) ; R574.2 v1(281.24,21.16) ; v1(185.39,28.59) C1362.1 187.51,27.71 U52.24 ; v1(247.14,36.62) R730.2 R723.2 ; v1(89.92,41.18) 89.91,41.19 R844.2 ; C1992.2 76.16,74.64 v1(76.12,74.68) ; R712.2 116.92,39.78 v1(116.41,39.27) ; v1(296.02,41.17) C1378.2 296.97,40.28 297.46,39.79 U69.16 ; L207.1 149.4,92.34 148.97,91.9 C2422.2 148.62,92.33 148.09,92.85 v1(147.93,92.85) ; R581.2 280.05,20.98 v1(279.87,21.16) ; R433.2 v1(253.83,20.95) ; R1797.2 141.62,99.24 v1(142.03,98.84) ; R329.2 v1(150.58,37.72) R336.2 ; R1267.1 v1(59.51,44.42) ; C2369.1 108.2,89.43 108.58,89.05 v1(108.58,88.93) ; R1685.2 9.21,91.63 v1(9.02,91.82) ; R1608.1 v1(5.74,44.86) ; v1(149.28,23.01) 149.72,23.45 R385.2 ; v1(137.16,40.01) 137.29,39.88 R320.2 ; R911.2 v1(280.71,36.27) R910.2 ; v1(166.25,23.8) 166.17,23.73 R854.2 ; U13.14 306.39,28.71 C853.2 v1(306.43,27.99) ; R582.2 v1(207.77,36.63) ; R903.2 v1(291.17,29.03) ; R319.2 v1(109.24,37.72) R312.2 ; R12986.1 v1(109.2,181.52) ; R679.2 v1(273.43,20.37) ; R12979.2 124.03,100.17 v4(124.21,100.36) 124.94,99.63 R12797.2 ; R1612.1 v1(75.69,77.4) ; v1(146.22,86.61) C2417.2 147.78,85.65 L208.1 ; U60.5 67.81,179.21 68.2,178.82 C2122.1 v1(67.44,178.33) ; R392.2 v1(149.72,22.16) ; R729.2 v1(249.71,20.95) ; R845.2 86.36,37.59 85.82,38.13 v1(85.27,38.13) ; R357.2 v1(147.83,37.72) R364.2 ; R1994.2 138.77,181.72 v1(139.33,182.28) 139.79,181.82 R1995.2 ; R398.2 v1(122.42,23.09) ; v1(143.94,37.62) R661.2 R652.2 ; C1317.1 109.63,109 v1(109.47,108.84) ; R1768.1 v1(25.02,46.35) ; R1204.2 v1(107.59,95.38) ; R1000.2 v1(122.63,145.35) ; v1(173.03,37.62) R657.2 R651.2 ; R420.2 152.43,21.54 152.47,21.58 v1(152.47,22.16) ; v4(131.24,95.43) 131.79,94.88 C898.2 ; R887.2 v1(223.81,36.72) R886.2 ; v1(115.27,37.62) R711.2 R705.2 ; R350.2 v1(149.21,37.72) R343.2 ; R1984.1 v1(83.31,177.29) ; R361.2 v1(105.11,37.72) R354.2 ; R595.2 v1(266.27,36.72) R598.2 ; R901.2 v1(291.33,31.17) ; C1387.2 U23.B7 v4(136.21,99.36) 135.71,99.86 C1404.1 ; v1(120.83,86.81) 121.19,86.45 R1805.2 ; R1983.2 v1(83.31,176.28) ; R1800.2 v1(140.78,90.58) ; R306.1 v4(283.14,100.43) ; U19.14 235.1,14.71 235,14.81 C844.2 v1(235,17.01) ; R1652.2 31.68,85.53 v1(32.26,86.11) 32.13,86.23 31.71,86.23 R1683.2 ; R732.2 v1(234.92,19.93) ; R908.2 282.08,36.06 v1(282.3,36.27) 282.08,36.49 R909.2 ; R898.2 v1(272.98,29.31) ; U16.2 174.42,16.59 v1(174.1,16.28) ; R1992.2 v1(140.81,182.28) ; R575.2 v1(209.1,36.72) R568.2 ; v1(161.3,23.09) R850.2 ; R594.2 v1(267.88,36.72) R597.2 ; v4(114,124.05) 114.01,124.05 C1391.2 115.6,124.05 v4(115.6,124.05) ; v1(141.8,90.58) R1799.2 ; U12.2 136.55,12.86 v1(136.45,12.76) ; v1(169.28,127.87) 169.01,127.6 R1734.1 ; R546.2 v1(288.04,18.84) ; R383.2 v1(133.48,18.55) ; C2000.2 71.84,87.73 v1(71.88,87.69) ; C1942.2 116.35,132 v4(115.6,131.25) ; R431.2 v1(239.05,19.93) ; R658.2 v1(174.16,39.27) ; R988.2 v1(296.78,43.77) ; L191.2 C2206.1 106.17,77.7 v3(106.3,77.57) ; R1767.1 v1(31.37,46.35) ; v1(272.29,20.34) R670.2 ; C2386.2 123.05,96.32 v4(123.11,96.38) ; R883.2 v1(226.56,36.72) R882.2 ; PR140.2 294.5,138.43 296.8,138.43 v1(297.05,138.68) ; R426.2 v1(252.46,20.95) ; v1(132.01,16.39) C753.2 132.01,13.56 U12.14 ; R864.2 v1(161.8,37.72) R865.2 ; R1812.2 v1(117.08,93.91) ; v1(275.44,184.47) 275.03,184.07 R1131.1 ; R12466.2 135.55,115.73 135.31,115.49 v1(135.31,115.17) ; R538.2 v1(255.16,36.72) R545.2 ; v4(114,128.05) 114.2,127.86 C897.2 ; R13068.1 71.19,132.4 v1(70.99,132.21) ; v1(32,86.93) 32,87.18 31.62,87.56 R1680.2 ; C1633.2 91.64,91.07 v1(91.02,90.45) ; R435.2 v1(210.65,20.31) ; R1126.1 v1(279.27,195.1) ; R974.2 v1(98.43,22.23) ; R826.2 v1(89.98,23.09) ; R372.2 v1(176.05,23.09) ; R449.2 v1(213.3,20.37) ; R399.2 v1(151.09,23.09) ; C1394.1 115.23,126.08 v4(115.6,126.45) ; R322.2 v1(151.96,37.72) R315.2 ; R1754.1 v1(88.01,178.08) ; v1(282.67,22.14) 282.27,22.54 R899.2 ; U170.5 C2334.2 57.97,83.51 v1(57.78,83.69) ; R698.2 v1(187.58,37.55) ; R1125.1 v1(271.27,195.13) ; R1861.2 v1(114.94,99.62) ; U47.24 C1363.1 v1(172.25,28.71) ; R973.2 100.97,21.67 101.5,22.2 v1(101.5,23.09) R714.2 ; R424.2 v1(237.67,19.93) ; v1(285.62,188.21) 285.31,187.9 R1142.1 ; C1382.2 64.63,79.87 63.93,79.87 v1(63.75,79.69) ; v1(111.92,12.09) R967.2 R966.2 ; v1(299.06,43.72) 298.92,43.58 R984.2 ; R440.2 v1(255.2,20.95) ; v1(259.84,198.05) R1127.1 ; R580.2 v1(251.03,36.72) R587.2 ; C2359.2 44.73,67.97 v1(44.7,67.94) ; R1622.2 v1(70.87,85.4) ; R829.2 v1(93.85,22.16) ; R1990.2 v1(141.51,176.66) ; R337.2 v1(179.67,37.72) R330.2 ; v1(206.53,20.31) R674.2 ; U15.2 v1(299.82,22.38) ; U16.14 173.77,11.53 172.41,10.18 C790.2 v1(171.48,9.68) ; C1307.1 v1(121.42,148.53) ; R914.2 274.21,35.54 v1(273.9,35.23) ; R406.2 v1(151.09,22.16) ; v1(301.28,43.68) 301.06,43.46 R982.2 ; R578.2 v1(236.68,36.72) R585.2 ; R579.2 v1(189.67,39.9) ; R376.2 v1(132.46,18.55) ; R1993.2 v1(141.83,182.28) ; v1(306.43,21) C825.2 306.39,21.73 U15.14 ; R405.2 v1(122.42,22.16) ; R12832.2 90.49,81.74 89.92,82.31 89.92,82.75 v1(89.92,82.75) ; R351.2 v1(178.29,37.72) R344.2 ; R1272.1 276.44,114.54 276.6,114.7 276.62,114.7 v1(276.86,114.94) ; v1(281.53,22.25) 281.26,22.53 R916.2 ; R382.2 v1(107,23.09) ; R963.2 v1(104.79,21.54) ; R968.2 v1(106.69,6.33) ; R1621.2 v1(70.77,82.35) ; R853.2 165.16,21.71 v1(165.59,22.13) ; C1410.1 v1(29.06,46.18) ; C1332.1 106.07,97.47 v1(106.81,97.47) ; R567.2 v1(282.29,21.06) ; R12791.1 R12792.1 162.66,85.83 162.05,85.22 v1(161.67,85.22) ; R1737.1 v1(103.25,180.88) ; v1(111.38,84.66) 112.72,84.66 L141.2 112.9,85.85 C1392.2 ; R1649.1 v1(157.89,120.63) ; R1811.2 117.31,92.89 v1(117.08,93.12) ; R852.2 v1(164.04,23.09) ; v1(163.45,92.08) R1646.1 ; R377.2 v1(119.67,23.09) ; R596.2 v1(268.11,21.96) ; R692.2 130.33,19.28 R369.2 v1(131.45,18.55) ; R404.2 R411.2 137.65,18.65 v1(137.54,18.55) ; R1798.2 v1(142.06,100.26) ; U10.2 v1(89.49,15.88) ; U14.2 v1(160.58,16.77) ; U64.24 218.99,26.87 C2221.2 v1(218.1,28.47) ; U13.2 v1(299.82,29.36) ; R868.2 158.55,38.59 v1(157.68,37.72) R869.2 ; R12898.2 v1(58.54,80) ; C2401.2 87.6,78.77 v1(87.19,78.35) 86.51,79.03 C1302.1 ; R540.2 v1(211.85,36.72) R547.2 ; C1396.1 117.45,133.49 v4(117.65,133.68) 117.65,134.51 C1398.1 ; R428.2 v1(209.28,20.31) ; v1(130.5,145.22) R1002.2 R1003.2 ; R832.2 v1(95.47,23.09) ; R397.2 v1(135.51,18.55) ; R855.2 v1(166.54,22.16) ; R396.2 v1(108.37,23.09) ; v1(91.35,23.09) R827.2 R828.2 ; R553.2 284.55,21.09 v1(284.32,21.32) ; R900.2 v1(284.2,22.91) ; v1(221.08,16.64) U18.2 ; R1731.1 v1(18.55,31.57) ; R572.2 v1(190.69,40.15) ; R1611.1 v1(75.69,76.13) ; C1400.2 116.75,127.71 v4(116.4,128.05) ; v1(232.79,36.67) R733.2 R724.2 ; R831.2 v1(95.22,22.16) ; R656.2 v1(173.51,23.07) ; R439.2 v1(193.1,18.05) ; C1995.2 71.64,74.34 v1(71.42,74.55) ; R358.2 v1(176.92,37.72) R365.2 ; R834.2 v1(94.61,37.72) R835.2 ; v1(275.21,36.27) 276.07,37.14 R917.2 ; R13009.2 v1(13.32,35.71) ; R427.2 v1(280.4,6.53) ; R1224.1 v1(112.47,92.56) ; v1(8.97,89.49) 9.07,89.59 R1661.1 ; R390.2 v1(134.49,18.55) ; R1777.2 v1(152.73,134.92) ; v1(101.22,37.62) R715.2 R706.2 ; R746.2 v1(262.66,21.96) ; R12985.1 v1(106.12,181.52) ; R384.2 v1(121.04,23.09) ; R660.2 v1(147.02,19.92) ; R599.2 v1(269.35,22.02) ; R857.2 v1(169.2,19.5) ; C1993.2 80.3,80.82 v1(79.5,80.82) ; R1128.1 v1(269.29,199.17) ; R386.2 v1(178.8,23.09) ; R313.2 v1(139.83,35.44) ; R446.2 v1(194.11,18.05) ; R370.2 v1(118.3,23.09) ; v1(183.86,158.3) 183.88,158.28 L174.1 ; R1219.1 v1(104.8,84.18) ; R1223.1 v1(112.44,89.52) ; R962.2 R965.2 107.34,21.47 v1(107.24,21.57) ; R1998.2 v1(136.73,182.29) ; R990.2 v1(306.41,43.77) ; R393.2 v1(178.8,22.16) ; v1(145.08,39.27) 145.08,39.34 R662.2 ; R734.2 v1(233.93,38.27) ; R560.2 v1(283.42,21.11) ; R877.2 v1(225.8,22.05) ; R1982.2 v1(87.25,174.85) ; R342.2 v1(120.53,37.72) R349.2 ; R676.2 v1(206.58,39.07) ; R905.2 288.72,27.16 v1(289.89,27.16) ; v1(148.34,23.09) R378.2 ; R680.2 v1(276.25,21.16) ; R12920.1 v1(21.27,84.07) ; R716.2 v1(102.36,39.27) ; R589.2 v1(206.46,36.58) ; R1850.2 114.85,103.43 v1(115.11,103.7) ; R876.2 v1(224.83,22.8) ; R669.2 v1(202.84,36.72) ; v1(115.33,104.47) 115.09,104.7 R1849.2 ; R413.2 v1(152.47,23.09) ; R687.2 v1(126.44,37.72) ; R379.2 v1(177.43,23.09) ; v1(278.97,21.16) R588.2 ; R969.2 v1(107.97,6.33) ; R1132.1 v1(268.09,181.55) ; v1(189.67,18.05) R696.2 ; C1388.1 114.86,128.85 v4(115.6,128.85) ; R1684.2 19.94,99.19 v1(19.56,98.81) ; R362.2 v1(131.06,40.01) ; v1(304.4,43.83) 304.27,43.69 R989.2 ; v1(184.53,155.57) 184.53,154.31 R1643.1 ; R1848.2 v1(112.52,110.64) ; R418.2 v1(139.96,20.83) ; R1686.2 v1(4.19,76.86) ; R419.2 v1(123.79,22.16) ; R867.2 v1(159.92,23.09) ; v1(132.08,40.01) R355.2 R348.2 ; R678.2 v1(277.65,6.53)
  BOTTOM w0.508: v1(92.53,195.71) 92.89,195.34 C2061.1 L192.2 ; L189.2 C2132.2 163.55,133.38 v1(163.83,133.66) ; L174.1 185.68,158.17 C2157.2 v1(184.93,157.01) ; v1(188.97,120.71) 187.09,122.59 183.52,122.59 v1(183.45,122.53)
  vias: v1(3.43,104.78) v1(3.43,103.89) v1(3.94,99.58) v1(4.45,101.47) v1(4.45,100.71) v1(4.82,99.58) v1(9.29,44.15) v1(10.05,44.15) v1(32.44,106.02) v1(32.43,105.24) v1(32.68,103.06) v1(33.57,103.04) v1(36.32,54.61) v1(37.08,54.61) v1(69.47,136.02) v1(70.36,136.4) v1(88.9,75.47) v1(88.9,74.75) v1(99.42,82.68) v1(99.93,75.99) v1(100.09,83.02) v1(100.64,76.03) v1(101.27,139.45) v1(102.05,172.63) v1(102.03,139.47) v1(106.55,116.39) v1(107.44,116.39) v1(111.63,138.68) v1(111.99,75.75) v1(112.39,138.68) v1(112.7,75.77) v1(121.41,149.35) v1(123.74,75.96) v1(124.46,75.97) v1(133.17,118.8) v1(133.17,118.09) v1(139.83,76.61) v1(139.83,75.9) v1(142.62,132.14) v1(143.51,132.14) v1(147.32,116.03) v1(147.33,115.32) v1(148.34,142.37) v1(149.22,142.37) v1(152.44,112.3) v1(152.91,75.56) v1(152.91,74.68) v1(153.33,112.3) v1(160.4,82.33) v1(161.16,82.33) v1(164.14,76.05) v1(164.85,76.08) v1(168.4,123.44) v1(168.53,124.38) v1(169.04,99.04) v1(169.04,98.28) v1(176.25,76.05) v1(176.97,76.02) v1(180.06,111.5) v1(180.8,111.5) v1(205.58,75.16) v1(205.58,74.4) v1(217.67,75.06) v1(217.67,74.3) v1(229.74,75.06) v1(229.74,74.3) v1(241.12,75.39) v1(241.15,74.68) v1(253.11,76.13) v1(253.06,75.37) v1(268.79,75.2) v1(268.76,74.44) v1(280.16,80.31) v1(281.05,80.31) v1(283.96,189.17) v1(284.23,188.47) v1(305.32,93.27) v1(305.32,92.43) v1(306.21,93.27) v1(306.21,92.43) v1(308.99,37.08) v1(309.75,38.48) v1(310.51,38.61) v2(11.25,166.74) v2(11.25,165.47) v2(11.25,164.2) v2(11.25,162.93) v2(12.52,166.74) v2(12.52,165.47) v2(12.52,164.2) v2(12.52,162.93) v2(13.79,166.74) v2(13.79,165.47) v2(13.79,164.2) v2(13.79,162.93) v2(15.06,166.74) v2(15.06,165.47) v2(15.06,164.2) v2(15.06,162.93) v2(16.33,166.74) v2(16.33,165.47) v2(16.33,164.2) v2(16.33,162.93) v2(17.6,166.74) v2(17.6,165.47) v2(17.6,164.2) v3(76.58,48.13) v6(11.24,161.83) v6(11.24,160.56) v6(11.24,159.42) v6(11.21,158.17) v6(11.21,157.03) v6(11.3,153.8) v6(12.51,161.83) v6(12.51,160.56) v6(12.51,159.42) v6(12.48,158.17) v6(12.48,157.03) v6(12.57,153.8) v6(12.57,152.65) v6(12.95,155.83) v6(12.95,154.81) v6(14.03,153.14) v6(14.01,152.23) v6(14.1,157.48) v6(15.24,157.48) v6(15.24,153.16) v6(15.24,152.15) v6(16.13,151.76) v6(16.39,161.85) v6(16.39,160.58) v6(16.39,159.44) v6(16.39,158.04) v6(16.39,156.77) v6(16.39,155.63) v6(16.44,154.4) v6(16.38,153.29) v6(16.85,152.35) v6(17.4,151.64) v6(17.66,158.94) v6(17.65,154.31) v6(17.65,153.16) v6(18.29,155.07) v6(18.29,152.15) v6(18.55,158.93) v6(37.98,139.15) v6(38.14,143.69) v6(38.14,142.55) v6(38.16,147.35) v6(38.16,146.08) v6(38.16,144.94) v6(38.95,139.15) v6(38.92,138.11) v6(39.43,147.35) v6(39.43,146.08) v6(39.43,144.94) v6(39.41,143.69) v6(39.41,142.55) v6(39.81,141.33) v6(39.79,140.29) v6(39.94,139.17) v6(39.91,138.13) v6(40.39,144.02) v6(40.39,143) v6(41.03,137.78) v6(41.4,144.02) v6(41.53,143) v6(41.53,138.68) v6(42.42,137.79) v6(42.8,138.81) v6(42.97,143.54) v6(42.97,142.27) v6(42.97,141.13) v6(42.97,139.97) v6(43.16,147.69) v6(43.16,146.45) v6(43.16,145.31) v6(43.56,138.18) v6(43.82,144.47) v6(44,140.32) v6(43.98,139.27) v6(44.33,137.48) v6(44.58,138.43) v6(44.71,144.45)
P3V3_BMC: length 172.9
  TOP w0.381: R12961.1 v1(54.86,133.6) 55.37,133.6 55.88,133.1 R12962.1 ; U154.F11 v4(68.13,113.73) ; U154.F12 v4(68.13,112.13) ; U154.H6 v4(66.53,117.73) ; v1(59.31,133.35) 58.93,132.97 R12964.1 ; U154.N17 v4(61.73,108.12) ; R12318.1 v1(66.55,95.56) ; R12368.2 104.87,141.62 v1(105.26,142.01) ; U154.F13 v4(68.13,111.33) ; U157.8 SK157.8 C2273.2 32.13,81.53 v1(32.64,82.04) ; SK158.8 v1(50.42,83.9) ; R12367.2 v1(95.89,139.76) ; R12333.2 60.22,95.78 60.07,95.63 v1(60.07,95.6) ; v1(62.23,128.4) 61.65,128.4 R12733.2 ; R12965.1 57.91,133.1 v1(58.17,133.35) ; R12322.1 76.06,126.35 v1(76.57,125.85) ; R12404.1 60.1,99.31 v1(60.18,99.39) ; U171.5 C2402.1 v1(142.3,201.11) ; U154.M6 v4(62.53,117.73) ; U154.U8 v4(58.53,116.13) ; v1(58.91,95.58) 59.33,95.15 R12401.1 ; v1(139.54,195.96) C2372.1 U148.5 ; U154.U9 v4(58.53,115.33) ; U154.F9 v4(68.13,115.33) ; R12366.2 v1(94.87,139.76) ; U154.F10 v4(68.13,114.53) ; U154.J17 v4(65.73,108.12) ; v1(97.92,142.3) R12370.2 ; v1(57.28,133.6) 56.9,133.22 R12963.1 ; U164.5 C2215.1 v1(138.05,201.11) ; v1(58.67,92.08) 59.24,92.64 C2268.2 L194.2 ; L198.1 46.96,106.21 C2316.1 44.67,105.05 v1(44.67,104.83) ; v1(70.29,128.72) 70.23,128.66 R12413.2 ; R12319.1 65.28,95.75 65.33,95.69 65.33,95.66 v1(65.82,95.17) ; R12329.1 v1(49.53,102.62) ; R13037.2 v1(132.67,195.25) ; R12416.1 v1(42.44,131.55) ; R12365.2 v1(91.82,139.76) ; U154.J6 v4(65.73,117.73) ; R12486.2 v1(132.59,196.47) ; U154.M17 v4(62.53,108.12) ; U154.N6 v4(61.73,117.73) ; U154.F8 v4(68.13,116.13) ; U154.H17 v4(66.53,108.12)
  TOP w0.508: J17.2 J17.1 88.77,146.23 C2437.2 v1(89.53,141.31)
  T05 w0.508: v1(39.75,190.26) v1(43.25,190.26)
  T14 w0.508: v1(116.05,116.42) 112.14,116.42 110.95,115.24 104.25,115.24 100.8,118.69 88.85,118.69 v1(88.07,117.91)
  BOTTOM w0.305: U102.5 C2161.1
  BOTTOM w0.381: R12359.1 v1(69.85,95.56) ; v1(62.29,129.99) C2298.1 60.85,129.87 61.24,129.47 L197.1 ; R12407.1 v1(52.45,96.27) R12411.1 ; U101.5 C2124.1 ; R12364.2 v1(41.78,81.28) ; C2271.1 68.09,116.16 v4(68.13,116.13) ; R12343.2 54.81,125.12 v1(55.35,125.66) 55.45,125.76 R12342.1 ; v4(62.53,108.12) 62.73,108.12 C2279.1 ; v4(61.73,108.12) 61.73,108.14 C2289.1 ; R12386.1 v1(46.33,96.34) R12381.1 ; v1(76.2,118.17) 76.07,118.04 R12323.1 ; R12722.1 v1(76.2,109.15) ; v4(68.13,112.13) 67.24,113.01 C2311.1 67.73,113.73 v4(68.13,113.73) ; L195.2 50.28,104.92 C2319.1 49.89,105.19 49.26,104.57 v1(49.26,104.22) ; v1(61.45,99.48) R12400.1 ; C2318.2 67.75,111.71 v4(68.13,111.33) ; v1(58.91,99.48) R12389.1 ; R12330.1 v1(87.5,102.8) ; R12382.1 v1(48.87,96.34) R12393.1 ; R12360.1 v1(69.85,99.37) ; L196.1 57.2,129.21 57.47,129.48 C2313.1 57.42,130.05 56.47,130.05 v1(56.26,129.84) ; R12723.1 v1(79.88,109.15) ; v1(60.18,99.39) R12405.1 ; v1(62.72,99.46) R12385.1 ; v1(43.05,96.9) 43.28,97.13 R12403.1 ; R12317.1 v1(65.26,99.39) ; R12396.1 74.93,95.92 v1(74.59,95.59) ; R12362.2 v1(41.78,84.71) ; R12406.1 54.93,95.67 v2(54.93,94.76) 54.93,94.55 v1(54.36,93.98) ; v1(65.82,95.17) 65.46,95.53 65.46,95.57 65.26,95.77 R12316.1 ; R12321.1 75.34,121.18 v1(75.44,121.28) ; R12397.1 v1(47.6,96.34) R12409.1 ; L199.1 42.51,103.23 C2314.1 v1(40.51,103.23) ; v1(63.64,95.63) 63.99,95.97 R12399.1 ; v4(61.73,117.73) 61.7,117.7 C2320.2 ; R12390.1 R12388.1 v1(62.72,95.46) ; v4(68.13,115.33) 67.55,114.75 C2315.2 ; v1(71.98,95.2) C2160.1 71.84,94.22 U99.5 ; R12378.1 v1(83.69,102.8) ; v1(83.71,117.84) 83.5,118.04 R12716.1 ; R12398.1 v1(63.99,99.48) ; R12384.1 v1(87.5,101.53) ; R12387.1 v1(45.06,96.34) R12412.1 ; R12358.2 v1(79.88,116.77) ; R12391.1 v1(58.91,95.58) ; R12417.1 48.79,129 v1(48.9,129.1) ; R12363.2 v1(41.86,83.39) ; R12392.1 R12394.1 v1(73.66,95.22) ; R12320.1 79.77,120.58 v1(79.78,120.57) ; C2317.2 66.27,117.18 v4(65.73,117.73) ; R12318.1 v1(66.55,95.56) ; R12328.1 v1(67.69,95.56) ; R12990.2 v1(60.96,83.82) ; R12379.1 v1(71.12,99.37) ; C2275.1 65.73,108.91 v4(65.73,108.12) ; R12357.2 v1(79.95,118.04) ; C2312.1 v4(58.53,116.13) ; v1(60.07,95.6) 60.07,95.63 60.18,95.74 R12410.1 ; R12331.1 v1(87.5,106.61) ; R12717.1 v1(77.47,107.88) ; R12395.1 v1(50.14,96.34) R12402.1 ; R12383.1 v1(51.41,96.34) R12408.1 ; v1(50.42,83.9) 50.46,83.95 C2272.2 ; R12377.1 v1(72.39,99.37) ; R12361.1 v1(87.5,107.88) ; v1(34.42,83.59) R12900.2 ; R12715.1 v1(83.69,116.77)
  BOTTOM w0.508: C2124.1 v1(116.05,116.42) ; C2161.1 v1(39.75,190.26)
  vias: v1(54.87,148.33) v1(54.86,147.57) v1(54.86,146.81) v1(54.86,146.05) v1(56.77,186.31) v1(57.4,186.75) v1(57.4,185.93) v1(68.28,149.86) v1(68.28,149.1) v1(84.33,149.84) v1(84.33,149.08) v1(105.54,198.63) v1(106.17,199.52) v1(106.81,198.63) v1(107.57,199.52) v1(108.2,198.63) v1(108.84,199.52) v1(109.47,198.63) v1(138.68,196.72) v2(105.95,204.92) v2(105.95,203.65) v2(105.95,202.38) v2(107.22,204.92) v2(107.22,203.65) v2(107.22,202.38) v2(108.49,204.92) v2(108.49,203.65) v2(108.49,202.38) v2(109.76,204.92) v2(109.76,203.65) v2(109.76,202.38)
P3V3_BMC_EN: length 7.9
  TOP w0.33: v1(60.29,196.76) 60.44,196.76 60.84,196.36 PU19.14
  TOP w0.381: v1(60.29,196.76) C2330.1 PR339.2 R12430.2 60.29,201.97 R12970.1
  BOTTOM w0.381: v1(60.29,196.76) 59.7,197.36 PR354.1
P3V3_BMC_FB: length 3.8
  TOP w0.305: 60.36,192.56 60.34,192.58 PU19.5
  TOP w0.381: PR357.1 PR356.2 60.35,191.4 PC325.2 60.36,192.56
P3V3_BMC_IN: length 2.5
  TOP w0.381: PR353.1 60.36,189.16 PC325.1 60.35,190.59 PR356.1
P3V3_BMC_PG: length 68.6
  TOP w0.305: PR355.2 PR351.2 58.85,195.13 v1(59.13,194.86)
  TOP w0.33: PU19.2 v1(59.13,194.86)
  T05 w0.117: v1(59.13,194.86) 60.2,193.78 60.2,186.43 64.37,182.26 64.37,176.87 64.37,176.87 64.37,176.13 v1(64.01,175.77)
  T14 w0.117: v1(64.01,175.77) 62.98,174.74 62.98,170.61 66,167.58 66,160.02 65.08,159.1 65.08,156.3 66,155.38 66,151.79 64.14,149.92 64.14,142.11 65.98,140.27 69.4,140.27 69.59,140.45 v1(69.6,140.45)
  BOTTOM w0.14: v1(69.6,140.45) 69.59,140.45 69.4,140.27 R12435.1
P3V3_BMC_VIN:
  vias: v1(61.37,199.03) v1(61.72,199.9) v1(61.71,197.25) v1(62.69,200.3) v2(60.71,201.17) v2(60.71,199.77) v2(60.71,198.17) v2(61.98,201.17)
P3V3_BMC_VOUT: length 10.2
  TOP w0.381: PR353.2 60.33,187.76 58.8,187.76 56.52,190.05 56.52,194.35 PR351.1
  vias: v1(62.34,190.5) v1(62.36,189.36) v1(63.02,187.88) v1(63.12,190.5) v1(63.12,189.36) v2(59.94,187.71) v2(61.21,187.71) v2(61.35,186.44)
P3V3_BOOT: length 3.6
  TOP w0.305: PU2.7 37.08,160.52 36.58,160.02
  TOP w0.508: PR94.1 35.66,159.1 36.58,160.02
P3V3_BOOT2: length 2.6
  TOP w0.305: PU22.7 10.91,173.53 10.91,172.77 10.79,172.66
  TOP w0.508: 10.79,172.66 PR427.1
P3V3_BP: length 9.7
  TOP w0.254: PU2.28 36.08,167.53 35.64,167.97 v1(35.64,168.03)
  TOP w0.381: PC45.2 35.64,168.86 v1(35.64,168.03)
  BOTTOM w0.381: PR91.1 31.08,167.94 v2(31.74,168.6) 32.56,169.42 34.8,169.42 35.64,168.57 v1(35.64,168.03)
P3V3_BP2: length 9.3
  TOP w0.254: PU22.28 v5(9.91,180.38)
  TOP w0.381: PC376.2 9.91,181 v5(9.91,180.38)
  T07 w0.381: v1(5.37,180.39) 5.97,180.99 7.97,180.99 8.58,180.38 v5(9.91,180.38)
  BOTTOM w0.381: v1(5.37,180.39) 5.5,180.26 PR437.1
P3V3_EN: length 45.1
  TOP w0.254: PU22.33 7.21,178.64 v5(6.42,179.43) 6.1,179.75 6.1,180.65 PR432.1
  TOP w0.305: 33.37,165.89 PU2.33
  TOP w0.381: PR96.1 31.41,168.29 v1(32.58,167.11) 33.37,166.32 33.37,165.89 ; PR50.2 27.44,170.49 v1(27.77,170.82)
  T07 w0.381: v5(6.42,179.43) 7.23,178.62 21.84,178.62 27.77,172.69 v1(27.77,170.82)
  T18 w0.381: v1(32.58,167.11) 31.48,167.11 v1(27.77,170.82)
  BOTTOM w0.381: PC62.2 33.01,167.11 v1(32.58,167.11) ; v5(6.42,179.43) 7.13,178.72 PC368.2
P3V3_FAN:
  vias: v1(287.27,193.17) v1(288.04,193.17) v2(287.73,192.26) v2(287.72,190.99)
P3V3_HWM: length 4.5
  TOP w0.305: U73.7 120.62,190.91 v1(120.52,191.01)
  TOP w0.381: R1040.1 v1(122.4,182.88) ; Q2.2 v1(112.8,201.52)
  BOTTOM w0.381: PC8.2 120.62,190.91 v1(120.52,191.01) ; PR346.2 v1(108.2,194.89)
  vias: v1(119.13,200.41) v1(119.63,199.9) v1(119.89,200.66)
P3V3_HWM_V33A: length 7.7
  TOP w0.356: U73.46 118.62,199.67 118.01,200.28
  TOP w0.381: 118.01,200.28 116.5,200.28 115.93,200.85 C2441.1 C2440.2 v1(116.84,202.77) L38.1
P3V3_HWM_V33FB: length 8.4
  TOP w0.14: Q2.1 PR2.1 D43.2 112.8,195.81 v1(113.28,195.33) 113.43,195.18 114.19,195.18 115.67,193.71 U73.58
P3V3_ILIM: length 3.4
  TOP w0.254: PU2.30 35.08,167.08 34.41,167.75 v1(34.41,168.02)
  TOP w0.381: PR80.2 34.41,169.14 v1(34.41,168.02)
P3V3_ILIM2: length 3.3
  TOP w0.254: PU22.30 8.91,179.92 8.27,180.56 PR435.2
P3V3_MARGIN_HI: length 5.6
  BOTTOM w0.254: PQ5.1 35.48,155.93 v2(34.75,155.21) 34.13,154.58 PR102.1 PC64.1 PR103.1
P3V3_MARGIN_LO: length 6.6
  BOTTOM w0.254: PC63.1 PR100.1 PR99.1 29.41,152.46 v2(28.45,153.42) 28.45,155.86 PQ4.1
P3V3_MODE: length 3.1
  TOP w0.254: PU2.39 32.83,162.37 32,161.54 v1(31.88,161.54)
  TOP w0.381: v1(31.88,161.54) 31.75,161.54 31.32,161.97 PR75.1
P3V3_MODE2: length 2.9
  TOP w0.254: PR423.2 4.83,174.1 v1(5.27,174.1) 6.08,174.1 6.52,174.54 6.52,174.55 6.69,174.71 6.72,174.74 PU22.39
P3V3_OCXO: length 1.2
  BOTTOM w0.381: PR388.1 16.83,147.96
  vias: v1(14.2,147.36) v1(14.2,146.6) v1(14.96,147.36) v1(14.96,146.6) v1(16.12,146.87) v1(17.01,146.87) v1(17.9,146.87) v1(18.66,146.87) v2(17.78,147.96) v2(19.3,147.96)
P3V3_OCXO_EN: length 4.2
  TOP w0.14: PU13.11 v1(24.98,149.94)
  BOTTOM w0.14: PR386.2 PR387.2 25.84,149.08 v1(24.98,149.94)
P3V3_OCXO_FB: length 3.7
  TOP w0.14: PU13.16 19.76,148.86 19.24,149.38 v1(18.83,149.38)
  BOTTOM w0.14: PR389.1 PR388.2 18.57,149.12 v1(18.83,149.38)
P3V3_OCXO_PG: length 2
  TOP w0.14: PU13.9 v1(25.78,148.21)
  BOTTOM w0.14: TP153.1 24.83,148.21 v1(25.78,148.21)
P3V3_OCXO_SS: length 2.3
  TOP w0.14: PU13.15 v1(20.16,149.94)
  BOTTOM w0.14: PC404.1 20.54,149.76 20.34,149.76 v1(20.16,149.94)
P3V3_PG: length 54.4
  TOP w0.254: PU2.34 32.88,164.87 32.69,165.06 32.69,165.07 32.26,165.5 v1(32.26,165.86) 32.26,166.35 PR92.2 30.41,169.17 PC47.2 ; PC374.2 4.24,180.53 PR425.2 6.04,178.73 v5(6.04,177.78) 6.58,177.24 PU22.34
  TOP w0.381: PR35.1 27.3,160.4 v1(27.56,160.4)
  T05 w0.381: v1(32.26,165.86) 30.64,164.24 30.64,162.79 28.25,160.4 v1(27.56,160.4)
  T07 w0.254: v1(32.26,165.86) 31.54,165.86 23.8,173.61 9.56,173.61 7.37,175.8 7.37,176.45 v5(6.04,177.78)
  BOTTOM w0.381: v1(32.26,165.86) 31.84,165.86 PR91.2 ; PR437.2 v5(6.04,177.78)
P3V3_QSFP1: length 27.7
  TOP w0.356: U42.9 306.34,85.3 306.59,85.05 306.59,84.41 v1(306.55,84.38)
  TOP w0.635: R1585.1 v1(283.39,75.95)
  T05 w0.635: v1(283.39,75.95) 284.48,75.95 287.27,78.74 305.92,78.74 v1(306.71,77.95)
  vias: v2(307.59,80.76)
P3V3_QSFP2: length 21.3
  TOP w0.381: v1(304.88,84.39) 305.13,84.39 305.84,85.1 U42.8
  TOP w0.635: R1588.1 v1(281.87,75.38)
  T05 w0.635: v1(281.87,75.38) 282.32,74.93 284.99,74.93 287.83,77.77 v1(297.41,77.77) v1(297.41,76.88)
  vias: v2(297.69,81.27)
P3V3_RAMP: length 2.9
  TOP w0.305: PU2.40 33.37,161.39 v1(33.15,161.16)
  TOP w0.381: v1(33.15,161.16) 32.74,160.75 PR74.2
P3V3_RAMP2: length 3.3
  TOP w0.254: PR418.2 5.27,172.85 v1(6.1,172.85) 6.6,172.85 7.21,173.45 PU22.40
P3V3_RSN: length 16.1
  TOP w0.254: PR90.1 33.86,151.33 v1(34.29,151.76) ; PU2.2 34.58,160.43 33.42,159.28 PR88.2 33.42,158.39 32.51,157.48 v1(32.51,155.57) 32.06,155.12 PR89.2
  T05 w0.254: v1(32.51,155.57) 32.77,155.57 34.67,153.67 34.67,152.15 v1(34.29,151.76)
  BOTTOM w0.254: PQ5.2 33.5,156.05 33.02,155.57 v1(32.51,155.57)
P3V3_RSN2: length 11.4
  TOP w0.305: PR431.2 6.86,170.94 8.41,172.5 PU22.2
  TOP w0.381: PR431.2 v1(5.6,169.5) PR426.2 ; PR438.1 v1(7.24,166.3)
  T03 w0.381: v1(5.6,169.5) 7.24,167.85 v1(7.24,166.3)
P3V3_RSP: length 13.4
  TOP w0.254: 33.66,160.53 34.08,160.95 PU2.1
  TOP w0.381: v1(29.79,159.84) 30.66,159.84 31.08,159.42 PR87.2 32.34,158.78 PR88.1 32.61,159.48 33.66,160.53
  BOTTOM w0.381: PC46.2 29.72,159.77 v1(29.79,159.84) 29.82,159.87 PR101.1 31.14,159.26 31.52,158.88 31.88,158.88 v2(32.13,158.62) 32.13,157.56 PQ4.2
P3V3_RSP2: length 7.2
  TOP w0.305: PR431.1 6.78,171.76 7.91,172.89 PU22.1
  TOP w0.381: v1(4.64,170.54) 4.42,170.77 PR439.2 4.61,171.76 PR431.1
  BOTTOM w0.381: PC377.2 4.46,170.73 v1(4.64,170.54)
P3V3_RSP2_R1: length 13.1
  TOP w0.381: PR420.2 3.73,169.96 v1(3.25,170.43) 3.04,170.64 PR439.1 ; PR428.2 v1(8.26,166.37)
  T03 w0.381: v1(3.25,170.43) 4.04,171.22 5.18,171.22 8.26,168.15 v1(8.26,166.37)
  BOTTOM w0.381: v1(3.25,170.43) 3.08,170.6 PC377.1
P3V3_RSP_R: length 2.8
  BOTTOM w0.381: PR101.2 32.92,159.87 v2(33.03,159.77) 33.56,159.24 PQ5.3
P3V3_RSP_R1: length 6.9
  TOP w0.381: PR87.1 PR504.2 28.38,157.35 v1(28.19,157.54)
  BOTTOM w0.381: v2(26.87,157.54) v1(28.19,157.54) 28.52,157.87 PR98.1 28.17,158.78 PC46.1
P3V3_RSP_R1R: length 5.8
  BOTTOM w0.254: PQ4.3 29.89,158.42 PR98.2
  BOTTOM w0.381: PR98.2 30.53,158.43 v2(31.1,157.86)
P3V3_RT: length 2.4
  TOP w0.254: PU2.38 32.47,162.87 v1(32.38,162.79) 31.66,162.79 PR76.2
P3V3_RT2: length 2.5
  TOP w0.254: PU22.38 6.22,175.24 v1(6.1,175.12) 5.97,174.99 5.61,174.99 PR440.2
P3V3_SB: length 438.7
  TOP w0.381: PR41.1 v1(27.56,165.92) ; v1(243.33,192.53) 242.87,192.99 PR42.1 ; PR25.1 v1(27.56,156.77) ; PR30.1 v1(279.02,126.04)
  TOP w0.508: PR47.1 v1(145.04,185.94)
  T03 w0.508: v1(59.64,163.07) 58.55,163.07 50.77,155.3 50.77,152.88 49.85,151.96 45.61,151.96 43.1,149.45 30.58,149.45 28.5,151.54 28.5,155.98 27.71,156.77 v1(27.56,156.77) 27.46,156.88 27.46,157.91 28.57,159.03 28.57,165.18 27.83,165.92 v1(27.56,165.92) ; v1(299.18,136.77) 299.18,135.74 301.37,133.55 301.37,130.84 297.61,127.08 280.19,127.08 279.15,126.04 v1(279.02,126.04) 277.49,126.04 275.92,127.61 275.92,137.69 289.61,151.38 289.61,187.83 283.62,193.83 250.98,193.83 248.67,191.52 244.11,191.52 243.33,192.3 v1(243.33,192.53) 243.33,193.85 242.47,194.72 242.47,203.02 239.4,206.1 210.03,206.1 207.04,203.1 204.19,203.1 202.49,201.4 202.49,195.2 195.45,188.16 195.12,188.16 195.11,188.15 166.74,188.15 163.6,185.01 151.97,185.01 150.74,186.25 145.35,186.25 v1(145.04,185.94)
  T16 w0.508: v1(145.04,185.94) 136.58,185.94 132.97,182.32 132.97,168.94 130.2,166.17 82.68,166.17 79.5,162.99 61.2,162.99 61.15,162.94 59.77,162.94 v1(59.64,163.07)
  BOTTOM w0.381: v1(299.18,136.77) 299.37,136.96 PR29.1
P3V3_SFP00: length 42.1
  TOP w0.305: 95.27,76.38 94.17,76.38 U26.9
  TOP w0.508: 96.22,73.11 C1254.1 C1253.1 96.22,75.84 95.68,76.38 95.27,76.38
  T03 w0.381: v1(88.17,42.12) 88.17,44.55 84.1,48.61 84.1,60.23 93.35,69.47 v1(93.35,72.39)
  BOTTOM w0.381: R1548.1 v1(88.17,42.12)
P3V3_SFP01: length 47.8
  TOP w0.305: U26.8 94.86,75.87 v1(95.15,75.58)
  T03 w0.381: v1(92.81,43.82) 92.81,44.22 92.33,44.7 89.03,44.7 87.06,46.68 87.06,49.39 88.15,50.48 88.15,51.54 85.85,53.84 85.85,60.9 96.01,71.06 96.01,74.71 v1(95.15,75.58)
  BOTTOM w0.381: v1(92.81,43.82) R1555.1
  BOTTOM w0.508: 96.22,73.11 C1256.1 C1255.1 95.24,75.49 v1(95.15,75.58)
  vias: v2(95,72.21)
P3V3_SFP02: length 43.6
  TOP w0.305: 107.61,76.38 106.25,76.38 U29.9
  TOP w0.508: 107.61,76.38 107.76,76.38 108.3,75.84 C1268.1 C1269.1 108.3,73.11
  P10 w0.508: v1(105.06,72.9) 98.35,66.2 98.35,46.28 101.35,43.28 v1(101.35,40.51)
  BOTTOM w0.381: R1557.1 102.47,40.95 102.03,40.51 v1(101.35,40.51)
P3V3_SFP03: length 42.3
  TOP w0.305: U29.8 107.04,75.87 v1(107.17,75.74)
  P10 w0.508: v1(107.17,75.74) 107.61,75.74 108.77,74.59 108.77,71.71 112.6,67.88 112.6,55.2 110.74,53.35 110.74,44.84 v1(110.03,44.13)
  BOTTOM w0.381: v1(110.03,44.13) 109.56,43.66 R1559.1 ; v1(107.17,75.74) 108.05,75.74 C1271.1 C1270.1 108.23,74.03 108.23,72.63 C1012.1
  vias: v2(106.56,71.95)
P3V3_SFP04: length 44.4
  TOP w0.305: U32.9 118.32,76.12 119.42,76.12
  TOP w0.508: 119.42,76.12 119.87,76.12 120.37,75.62 C1284.1 C1283.1 120.37,72.31 120.56,72.13 C1018.1
  P10 w0.508: v1(115.32,41.76) 116.21,42.65 116.21,45.19 115.28,46.12 113.54,46.12 112.5,47.15 112.5,52.52 114.74,54.76 114.74,56.94 113.36,58.31 113.36,68.79 v1(117.25,72.67)
  BOTTOM w0.381: v1(115.32,41.76) R1561.1
P3V3_SFP05: length 40.1
  TOP w0.305: v1(119.49,75.37) 119.25,75.37 119.01,75.62 U32.8
  P10 w0.508: v1(124.15,43.53) 124.85,44.23 124.85,52.35 124.07,53.13 124.07,56.6 122.15,58.51 122.15,70.28 120.27,72.16 120.27,74.59 v1(119.49,75.37)
  BOTTOM w0.381: R1563.1 v1(124.15,43.53)
  BOTTOM w0.508: 120.37,72.86 C1286.1 C1285.1 119.63,75.24 v1(119.49,75.37)
  vias: v2(118.62,71.95)
P3V3_SFP06: length 41.1
  TOP w0.305: U35.9 130.4,76.12 131.5,76.12
  TOP w0.508: 132.45,72.86 C1299.1 C1298.1 132.45,75.59 131.91,76.12 131.5,76.12
  P10 w0.508: v1(130.61,72.55) 126.11,68.04 126.11,59.86 126.95,59.02 126.95,45.54 127.96,44.53 127.96,43.11 v1(129.67,41.4)
  BOTTOM w0.381: v1(129.67,41.4) 129.69,41.38 R1565.1
P3V3_SFP07: length 43.4
  TOP w0.305: v1(131.54,75.31) 131.23,75.62 U35.8
  P10 w0.508: v1(138.53,43.15) 138.68,43.31 138.68,53.09 138.18,53.59 138.18,56.9 135.77,59.31 135.77,67.36 132.62,70.51 132.62,74.23 v1(131.54,75.31)
  BOTTOM w0.381: C1039.1 128.92,72.11 ; C1039.1 128.38,71.55 ; C1039.1 128.38,72.67 ; R1567.1 v1(138.53,43.15) ; C1036.1 132.45,72.31 C1301.1 C1300.1 131.61,75.24 v1(131.54,75.31)
  vias: v2(131.57,71.83)
P3V3_SFP08: length 42.5
  TOP w0.305: 147.44,76.38 146.34,76.38 U38.9
  TOP w0.508: 147.44,76.38 147.86,76.38 148.4,75.84 C1314.1 C1313.1 148.4,73.11
  P10 w0.508: v1(147.17,72.82) 141.04,66.69 141.04,46.47 144.03,43.48 144.03,41.28 v1(143.76,41.02)
  BOTTOM w0.381: v1(143.76,41.02) 144.12,41.38 R1570.1
P3V3_SFP09: length 43.2
  TOP w0.305: U38.8 147.09,75.87 v1(147.31,75.65)
  P10 w0.508: v1(147.31,75.65) 148.81,74.16 148.81,66.52 155.72,59.61 155.72,54.07 155.15,53.5 155.15,47.91 v1(151.48,44.25)
  BOTTOM w0.381: C1048.1 148.4,72.56 C1316.1 C1315.1 147.47,75.49 v1(147.31,75.65) ; R1572.1 v1(151.48,44.25)
  vias: v2(146.18,71.83)
P3V3_SFP10: length 40.7
  TOP w0.305: U27.9 158.42,76.38 159.52,76.38
  TOP w0.508: 159.52,76.38 159.93,76.38 160.47,75.84 C1259.1 C1258.1 160.47,73.11
  T16 w0.381: v1(157.71,72.82) 155.4,70.52 155.4,45.78 158.37,42.82 158.37,41.53 v1(157.99,41.15)
  BOTTOM w0.381: v1(157.99,41.15) 158.09,41.25 R1574.1
P3V3_SFP11: length 42.6
  TOP w0.305: v1(159.51,75.57) 159.21,75.87 U27.8
  T18 w0.381: v1(165.73,44.02) 167.2,45.49 167.2,56.17 164.59,58.78 164.59,67.38 160.27,71.7 160.27,74.81 v1(159.51,75.57)
  BOTTOM w0.381: C1063.1 156.94,72.37 ; C1063.1 156.4,72.93 ; C1063.1 156.4,71.81 ; R1577.1 v1(165.73,44.02) ; v1(159.51,75.57) 159.59,75.49 C1260.1 C1261.1 160.47,73.12
  vias: v2(159.26,71.83)
P3V3_SFP12: length 38.9
  TOP w0.305: 171.6,76.38 170.5,76.38 U30.9
  TOP w0.508: 172.55,73.11 C1274.1 C1273.1 172.55,75.84 172.01,76.38 171.6,76.38
  T16 w0.381: v1(172.85,41.91) 172.47,42.29 172.47,43.61 169.26,46.82 169.26,54.94 169.86,55.53 169.86,61.22 172.39,63.76 v1(172.39,71.48)
  BOTTOM w0.381: v1(172.85,41.91) 172.87,41.88 R1579.1
P3V3_SFP13: length 42.4
  TOP w0.305: U30.8 171.27,75.87 v1(171.58,75.57)
  T18 w0.381: v1(171.58,75.57) 172.49,74.65 172.49,72.98 177.45,68.02 177.45,61.06 180.76,57.75 180.76,57.08 181.63,56.21 181.63,45.76 180.49,44.62 v1(180.49,44.48)
  BOTTOM w0.381: 172.75,72.93 C1072.1 172.21,72.37 ; v1(171.58,75.57) 171.71,75.57 171.78,75.49 C1275.1 C1276.1 172.55,73.11 ; v1(180.49,44.48) R1581.1
  vias: v2(170.31,71.95)
P3V3_SFP14: length 38.3
  TOP w0.305: U33.9 182.57,76.38 183.67,76.38
  TOP w0.508: 184.63,73.11 C1289.1 C1288.1 184.63,75.84 184.09,76.38 183.67,76.38
  T14 w0.381: v1(183.06,71.32) 183.82,70.55 183.82,46.54 186.62,43.74 186.62,41.58 v1(186.56,41.53)
  BOTTOM w0.381: v1(186.56,41.53) 186.92,41.88 R1583.1
P3V3_SFP15: length 47.9
  TOP w0.305: U33.8 183.34,75.87 v1(183.64,75.57)
  T18 w0.381: v1(183.64,75.57) 184.53,74.68 184.53,71.88 193.09,63.32 193.09,58.9 195.45,56.54 195.45,53.72 196.09,53.08 196.09,46.01 194.05,43.97 v1(193.27,43.97)
  BOTTOM w0.381: v1(183.64,75.57) 183.72,75.49 C1290.1 C1291.1 184.63,73.34 184.24,72.95 ; R1586.1 193.58,43.66 v1(193.27,43.97) ; 184.82,71.81 C1084.1 ; C1084.1 184.29,72.37 ; C1084.1 184.82,72.93 ; C1087.1 180.56,72.93 ; C1087.1 181.09,72.37 ; C1087.1 180.56,71.81
  vias: v2(182.12,72.59)
P3V3_SFP16: length 46.7
  TOP w0.305: 211.55,76.38 210.45,76.38 U36.9
  TOP w0.508: 212.5,73.11 C1304.1 C1303.1 212.5,75.84 211.96,76.38 211.55,76.38
  P10 w0.508: v1(210.26,72.34) 210.26,71.15 198.93,59.82 198.93,45.58 v1(204.56,39.94)
  BOTTOM w0.381: R1554.1 v1(204.56,39.94) 203.96,39.34 v2(203.96,39.12)
P3V3_SFP17: length 53.7
  TOP w0.305: v1(211.55,75.57) 211.25,75.87 U36.8
  P10 w0.508: v1(210.69,41.82) 209.62,42.88 204.94,42.88 202.59,45.24 201.33,45.24 200,46.57 200,58.28 212.22,70.51 212.22,74.9 v1(211.55,75.57)
  BOTTOM w0.381: v1(210.69,41.82) 210.78,41.72 R1556.1 ; v1(211.55,75.57) 211.63,75.49 C1306.1 C1305.1 212.5,72.56 C1195.1
  vias: v2(211.46,72.39)
P3V3_SFP18: length 53
  TOP w0.305: U39.9 222.53,76.38 223.62,76.38
  TOP w0.508: 223.62,76.38 224.04,76.38 224.58,75.84 C1318.1 C1319.1 224.58,73.11
  P10 w0.254: v1(219.3,39.94) 218.15,39.94 216.92,41.18 216.92,46.9 217.65,47.63 217.99,47.63 218.33,47.96 220.67,45.61 220.67,41.32 v1(219.3,39.94)
  P10 w0.508: 218.33,47.96 218.33,49.91 218.6,50.18 218.6,55.72 217.55,56.77 217.55,68.13 v1(221.77,72.34)
  BOTTOM w0.381: R1558.1 v1(219.3,39.94)
P3V3_SFP19: length 52.8
  TOP w0.305: v1(223.62,75.57) 223.31,75.87 U39.8
  P10 w0.254: 229.25,46.92 227.98,48.19 227.98,48.16 224.69,44.87 224.69,42.83 v1(225.49,42.04) 226.91,42.04 229.25,44.38 229.25,46.92
  P10 w0.508: v1(223.62,75.57) 224.2,74.98 224.2,66.5 227.98,62.72 227.98,48.19
  BOTTOM w0.381: v1(225.49,42.04) 225.8,41.72 R1560.1 ; v1(223.62,75.57) 223.7,75.49 C1321.1 C1320.1 224.58,72.56 C1207.1
  vias: v2(223.39,72.64)
P3V3_SFP20: length 53.1
  TOP w0.305: 235.7,76.38 234.6,76.38 U28.9
  TOP w0.508: 235.7,76.38 236.12,76.38 236.65,75.84 C1263.1 C1264.1 236.65,73.11
  P10 w0.254: 234.91,45.68 234.91,41.59 v1(233.27,39.94) 232.09,39.94 231.17,40.86 231.17,46.9 232.03,47.76 232.84,47.76 234.91,45.68
  P10 w0.508: 232.71,47.76 232.71,57.36 230.12,59.94 230.12,68.2 v1(234.06,72.14)
  BOTTOM w0.381: R1562.1 v1(233.27,39.94)
P3V3_SFP21: length 52.9
  TOP w0.305: U28.8 235.25,75.87 235.56,75.57 v1(235.68,75.57)
  P10 w0.254: 241.72,47.65 239.42,45.35 v1(239.42,42.15) 240.15,42.15 243.5,45.5 243.5,47.1 242.56,48.03 242.18,47.65 241.72,47.65
  P10 w0.508: 242.56,48.03 241.84,48.76 241.84,63.85 237.62,68.07 237.62,73.63 v1(235.68,75.57)
  BOTTOM w0.381: v1(235.68,75.57) 235.76,75.49 C1265.1 C1266.1 236.65,72.56 C1219.1 ; R1564.1 239.81,41.76 v1(239.42,42.15)
  vias: v2(235.59,72.39)
