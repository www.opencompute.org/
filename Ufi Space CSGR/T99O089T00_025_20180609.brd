# Allegro board T99O089T00_025_20180609.brd (continued)
## Nets (continued)
P1V0_DDR_SW: PC173.2 PL8.1 PR200.1 PU8.2(SW2) PU8.11(SW1)
P1V0_DDR_VCC: PC174.1 PR196.1 PR203.1 PU8.13(VCC)
P1V0_DDR_VIN: PC167.1 PC168.1 PC169.1 PC170.1 PC171.1 PR195.2 PU8.3(VIN1)
P1V0_DDR_VOUT: PC175.1 PC176.1 PC177.1 PC178.1 PC179.1 PC180.1 PC181.1 PL8.2 PR198.1 PR199.1 PR201.1 PR202.1
P1V0_EN: PC164.2 PR54.2 PR187.1 PU7.33(EN)
P1V0_ILIM: PR172.2 PU7.30(ILIM)
P1V0_MARGIN_HI: PC166.1 PQ9.1(G) PR193.1 PR194.1
P1V0_MARGIN_LO: PC165.1 PQ8.1(G) PR190.1 PR191.1
P1V0_MODE: PR166.2 PU7.39(MODE)
P1V0_PG: PC150.2 PR48.1 PR182.2 PR183.2 PU7.34(PGD)
P1V0_RAMP: PR165.2 PU7.40(RAMP)
P1V0_RSN: PQ9.2(S) PR179.2 PR180.2 PR181.1 PU7.2(RSN)
P1V0_RSP: PC149.2 PQ8.2(S) PR178.2 PR179.1 PR192.1 PU7.1(RSP)
P1V0_RSP_R: PQ9.3(D) PR192.2
P1V0_RSP_R1: PC149.1 PR178.1 PR189.1 PR505.2
P1V0_RSP_R1R: PQ8.3(D) PR189.2
P1V0_RT: PR167.2 PU7.38(RT)
P1V0_SN: PC163.1 PR184.2
P1V0_SS: PR169.2 PU7.37(SS)
P1V0_SW: PC162.2 PL7.1 PR184.1 PU7.8(SW_8) PU7.9(SW_9) PU7.10(SW_10) PU7.11(SW_11) PU7.12(SW_12)
P1V0_VDD: PC138.1 PR168.1 PU7.26(VDD)
P1V0_VIN: PC139.1 PC140.1 PC141.1 PC142.1 PC143.1 PC144.1 PC145.1 PC146.1 PC155.1 PR168.2 PR171.1 PR173.1 PR174.1 PR176.1 PU7.21(PVIN_21) PU7.22(PVIN_22) PU7.23(PVIN_23) PU7.24(PVIN_24) PU7.25(PVIN_25)
P1V0_VSEL: PR170.2 PU7.36(VSEL)
P1V2: C51.1 C627.1 C628.1 C632.2 C633.1 C634.2 C635.1 C636.2 C637.1 C651.1 C652.2 C653.1 C654.1 C655.2 C656.1 C657.2 C658.1 C659.1 C660.2 C661.1 C665.1 C666.2 C667.1 C668.1 C669.2 C670.1 C671.2 C672.1 C673.1 C674.2 C675.1 C686.1 C687.2 C688.1 C689.1 C690.2 C691.1 C692.2 C693.1 C694.1 C695.2 C696.1 C697.2 C698.1 C699.2 C700.1 C711.2 C712.1 C713.1 C714.1 C715.1 C716.2 C724.2 C735.1 C736.1 C737.2 C738.2 C739.1 C740.2 C741.2 C742.1 C743.1 C744.2 C745.1 C746.2 C747.2 C748.1 C749.2 C750.2 C751.1 L2.1 PC195.1 PC196.1 PC197.1 PC198.1 PC199.1 PC200.1 PC201.1 PC207.1 PC208.1 PC209.1 PL9.2 PR220.1 PR221.1 PR235.1 PU10.2(VLDOIN) R95.2 R97.2 R138.2 R140.2 R179.2 R181.2 R1053.2 U2.B3(VDD_01) U2.B9(VDD_02) U2.D1(VDD_03) U2.G7(VDD_04) U2.J1(VDD_05) U2.J9(VDD_06) U2.L1(VDD_07) U2.L9(VDD_08) U2.R1(VDD_09) U2.T9(VDD_10) U3.B3(VDD_01) U3.B9(VDD_02) U3.D1(VDD_03) U3.G7(VDD_04) U3.J1(VDD_05) U3.J9(VDD_06) U3.L1(VDD_07) U3.L9(VDD_08) U3.R1(VDD_09) U3.T9(VDD_10) U4.B3(VDD_01) U4.B9(VDD_02) U4.D1(VDD_03) U4.G7(VDD_04) U4.J1(VDD_05) U4.J9(VDD_06) U4.L1(VDD_07) U4.L9(VDD_08) U4.R1(VDD_09) U4.T9(VDD_10) U5.B3(VDD_01) U5.B9(VDD_02) U5.D1(VDD_03) U5.G7(VDD_04) U5.J1(VDD_05) U5.J9(VDD_06) U5.L1(VDD_07) U5.L9(VDD_08) U5.R1(VDD_09) U5.T9(VDD_10) U6.B3(VDD_01) U6.B9(VDD_02) U6.D1(VDD_03) U6.G7(VDD_04) U6.J1(VDD_05) U6.J9(VDD_06) U6.L1(VDD_07) U6.L9(VDD_08) U6.R1(VDD_09) U6.T9(VDD_10) U7.B3(VDD_01) U7.B9(VDD_02) U7.D1(VDD_03) U7.G7(VDD_04) U7.J1(VDD_05) U7.J9(VDD_06) U7.L1(VDD_07) U7.L9(VDD_08) U7.R1(VDD_09) U7.T9(VDD_10)
P1V2_AGND: PC204.2 PQ13.2(S) PR225.2 PR226.2 PR227.2 PR228.1 PU9.7(AGND)
P1V2_BST: PR217.1 PU9.10(BST)
P1V2_CS: PR227.1 PU9.4(CS)
P1V2_EN: PC192.1 PR49.2 PU9.5(EN)
P1V2_FB: PC203.2 PQ12.2(S) PR224.2 PR226.1 PR232.1 PU9.6(FB)
P1V2_FB_IN: PC203.1 PR220.2 PR224.1 PR229.1
P1V2_FB_IN_R: PQ12.3(D) PR229.2
P1V2_FB_R: PQ13.3(D) PR232.2
P1V2_MARGIN_HI: PC206.1 PQ13.1(G) PR233.1 PR234.1
P1V2_MARGIN_LO: PC205.1 PQ12.1(G) PR230.1 PR231.1
P1V2_MODE: PR222.2 PR225.1 PU9.12(MODE)
P1V2_PG: PR33.1 PR218.2 PR223.1 PU9.9(PGOOD)
P1V2_REF: PC204.1 PU9.8(TRK/REF)
P1V2_SW: PC193.2 PL9.1 PR219.1 PU9.2(SW2) PU9.11(SW1)
P1V2_VCC: PC194.1 PR218.1 PR222.1 PU9.13(VCC)
P1V2_VDDQ: C52.1 C53.1 C54.2 C55.1 C56.1 C57.2 C58.1 C59.2 C60.1 C61.1 C62.2 C63.1 C64.2 C65.1 C66.1 C67.2 C68.1 C69.2 C70.1 C71.1 C72.2 C73.1 C74.1 C75.1 C76.2 C77.1 C78.1 C79.2 C80.1 C81.2 C82.1 C83.1 C84.2 C85.1 C86.2 C87.1 C88.1 C89.2 C90.1 C91.2 C92.1 C93.1 C94.2 C95.1 C96.1 C97.1 C98.2 C99.1 C100.1 C101.2 C102.1 C103.2 C104.1 C105.1 C106.2 C107.1 C108.2 C109.1 C110.1 C111.2 C112.1 C113.2 C114.1 C115.1 C116.2 C117.1 C118.1 C119.2 C120.1 C121.1 C122.2 C123.1 C124.2 C125.1 C126.1 C127.2 C128.1 C129.2 C130.1 C131.1 C132.2 C133.1 C134.2 C135.1 C136.1 C137.2 C138.1 C139.1 C140.2 C141.1 C142.1 C143.2 C144.1 C145.2 C146.1 C147.1 C148.2 C149.1 C150.2 C151.1 C152.1 C153.2 C154.1 C155.2 C156.1 C157.1 C158.2 C159.1 C160.1 C161.2 C162.1 C163.1 C164.2 C165.1 C166.2 C167.1 C168.1 C169.2 C170.1 C171.2 C172.1 C173.1 C174.2 C175.1 C176.2 C177.1 C178.1 C179.2 C180.1 C254.2 C255.1 C256.1 C257.2 C258.2 C259.1 C260.2 C261.1 C262.1 C274.1 C275.1 C276.1 C280.2 C281.1 C282.1 C283.2 C284.1 C285.2 C286.1 C287.1 C288.2 C289.1 C290.1 C302.2 C303.1 C304.1 C305.2 C306.1 C307.2 C308.1 C309.1 C310.2 C311.1 C312.1 C313.2 C314.1 C315.1 C316.2 C317.1 C318.2 C319.1 C320.1 C321.2 C322.1 C323.1 C324.1 C337.2 C338.1 C339.1 C340.2 C341.1 C342.2 C343.1 C344.1 C345.2 C346.1 C347.1 C360.2 C361.1 C362.1 C363.2 C364.1 C365.2 C366.1 C367.1 C368.2 C369.1 C370.1 L2.2 U1.AB2(DDR_VDDO_1) U1.AB5(DDR_VDDO_2) U1.AB8(DDR_VDDO_3) U1.AD4(DDR_VDDO_4) U1.AD7(DDR_VDDO_5) U1.AE2(DDR_VDDO_6) U1.AF6(DDR_VDDO_7) U1.AF9(DDR_VDDO_8) U1.AG4(DDR_VDDO_9) U1.AH2(DDR_VDDO_10) U1.AH8(DDR_VDDO_11) U1.AH11(DDR_VDDO_12) U1.AH14(DDR_VDDO_13) U1.AH17(DDR_VDDO_14) U1.AH29(DDR_VDDO_15) U1.AK4(DDR_VDDO_16) U1.AK7(DDR_VDDO_17) U1.AK10(DDR_VDDO_18) U1.AK13(DDR_VDDO_19) U1.AK16(DDR_VDDO_20) U1.AK19(DDR_VDDO_21) U1.AK22(DDR_VDDO_22) U1.AK25(DDR_VDDO_23) U1.AK28(DDR_VDDO_24) U1.AK31(DDR_VDDO_25) U1.AL2(DDR_VDDO_26) U1.AM6(DDR_VDDO_27) U1.AM9(DDR_VDDO_28) U1.AM12(DDR_VDDO_29) U1.AM15(DDR_VDDO_30) U1.AM18(DDR_VDDO_31) U1.AM21(DDR_VDDO_32) U1.AM24(DDR_VDDO_33) U1.AM27(DDR_VDDO_34) U1.AM30(DDR_VDDO_35) U1.AM33(DDR_VDDO_36) U1.AN4(DDR_VDDO_37) U1.AP2(DDR_VDDO_38) U1.AP6(DDR_VDDO_39) U1.AP8(DDR_VDDO_40) U1.AP11(DDR_VDDO_41) U1.AP14(DDR_VDDO_42) U1.AP17(DDR_VDDO_43) U1.AP20(DDR_VDDO_44) U1.AP23(DDR_VDDO_45) U1.AP26(DDR_VDDO_46) U1.AP29(DDR_VDDO_47) U1.AP32(DDR_VDDO_48) U1.AP35(DDR_VDDO_49) U1.AT4(DDR_VDDO_50) U1.AT7(DDR_VDDO_51) U1.AT10(DDR_VDDO_52) U1.AT13(DDR_VDDO_53) U1.AT16(DDR_VDDO_54) U1.AT19(DDR_VDDO_55) U1.AT22(DDR_VDDO_56) U1.AT25(DDR_VDDO_57) U1.AT28(DDR_VDDO_58) U1.AT31(DDR_VDDO_59) U1.AT34(DDR_VDDO_60) U1.AT37(DDR_VDDO_61) U2.A1(VDDQ_01) U2.A9(VDDQ_02) U2.C1(VDDQ_03) U2.D9(VDDQ_04) U2.F2(VDDQ_05) U2.F8(VDDQ_06) U2.G1(VDDQ_07) U2.G9(VDDQ_08) U2.J2(VDDQ_09) U2.J8(VDDQ_10) U3.A1(VDDQ_01) U3.A9(VDDQ_02) U3.C1(VDDQ_03) U3.D9(VDDQ_04) U3.F2(VDDQ_05) U3.F8(VDDQ_06) U3.G1(VDDQ_07) U3.G9(VDDQ_08) U3.J2(VDDQ_09) U3.J8(VDDQ_10) U4.A1(VDDQ_01) U4.A9(VDDQ_02) U4.C1(VDDQ_03) U4.D9(VDDQ_04) U4.F2(VDDQ_05) U4.F8(VDDQ_06) U4.G1(VDDQ_07) U4.G9(VDDQ_08) U4.J2(VDDQ_09) U4.J8(VDDQ_10) U5.A1(VDDQ_01) U5.A9(VDDQ_02) U5.C1(VDDQ_03) U5.D9(VDDQ_04) U5.F2(VDDQ_05) U5.F8(VDDQ_06) U5.G1(VDDQ_07) U5.G9(VDDQ_08) U5.J2(VDDQ_09) U5.J8(VDDQ_10) U6.A1(VDDQ_01) U6.A9(VDDQ_02) U6.C1(VDDQ_03) U6.D9(VDDQ_04) U6.F2(VDDQ_05) U6.F8(VDDQ_06) U6.G1(VDDQ_07) U6.G9(VDDQ_08) U6.J2(VDDQ_09) U6.J8(VDDQ_10) U7.A1(VDDQ_01) U7.A9(VDDQ_02) U7.C1(VDDQ_03) U7.D9(VDDQ_04) U7.F2(VDDQ_05) U7.F8(VDDQ_06) U7.G1(VDDQ_07) U7.G9(VDDQ_08) U7.J2(VDDQ_09) U7.J8(VDDQ_10)
P1V2_VIN: PC187.1 PC188.1 PC189.1 PC190.1 PC191.1 PR216.2 PU9.3(VIN1)
P1V05_CPU: J1.A22(PCIE0_RX1_N) R12281.2
P1V05_PECI: C2375.1 R12281.1 U154.V19(PECIVDD)
P1V8: C20.1 C421.1 C548.1 C581.1 C597.1 C601.1 C605.1 C609.1 C613.1 C617.1 C1996.2 C1997.2 C1998.2 C2001.2 C2083.1 C2171.2 C2387.2 C2389.1 L1.1 L3.2 L10.2 L12.2 L13.2 L14.2 L15.2 L16.2 L17.2 L18.2 L179.1 L190.2 L204.1 L205.2 PC71.1 PC72.1 PC73.1 PC74.1 PC75.1 PL4.2 PR107.1 PR108.1 PR328.1 R1060.2 U127.3(VDDDC[3]) U127.32(VDDDC[1]) U127.50(VDDDC[2]) U127.71(VDDDC[0])
P1V8_DDR_AVDD: C12.1 C13.1 C14.1 C15.1 C16.1 C17.1 C18.1 C19.1 C33.1 C46.1 L1.2 U1.AB11(DDRC_AVDD1P8) U1.AE11(DDRC_V_ANALOG1P8_1) U1.AF11(DDRC_V_ANALOG1P8_2) U1.AF21(DDRB_V_ANALOG1P8_1) U1.AF28(DDRA_V_ANALOG1P8_1) U1.AG17(DDRB_AVDD1P8) U1.AG21(DDRB_V_ANALOG1P8_2) U1.AG26(DDRA_AVDD1P8) U1.AG28(DDRA_V_ANALOG1P8_2)
P1V8_EN: PR36.2 PR105.1
P1V8_EN_R: PC70.1 PR105.2 PU3.7(EN)
P1V8_FB_IN: PC78.1 PR107.2 PR110.1 PR400.1
P1V8_FB_IN_R: PQ19.3(D) PR400.2
P1V8_MARGIN_HI: PC367.1 PQ20.1(G) PR399.1 PR403.1
P1V8_MARGIN_LO: PC366.1 PQ19.1(G) PR401.1 PR402.1
P1V8_PG: PC79.1 PR31.1 PR109.2 PR111.1 PU3.4(PG)
P1V8_SS: PC76.1 PU3.5(SS)
P1V8_SW: PC69.1 PL4.1 PR106.1 PU3.2(SW)
P1V8_VBST: PR104.1 PU3.8(VBST)
P1V8_VFB: PC78.2 PQ19.2(S) PR110.2 PR112.1 PR113.1 PR398.1 PU3.6(VFB)
P1V8_VFB_R: PQ20.3(D) PR398.2
P1V8_VIN: PC65.1 PC66.1 PC67.1 PC68.1 PR317.2 PU3.3(VIN)
P1V25: C490.1 C983.1 L6.1 L47.2 PC226.1 PC227.1 PC228.1 PC229.1 PC230.1 PC231.1 PC232.1 PL10.2 PR243.1 PR244.1 R1052.2
P1V25_AGND: PC235.2 PQ15.2(S) PR248.2 PR249.2 PR250.2 PR251.1 PU11.7(AGND)
P1V25_BST: PR241.1 PU11.10(BST)
P1V25_CS: PR250.1 PU11.4(CS)
P1V25_EN: PR34.2 PR239.1
P1V25_EN_R: PC223.1 PR239.2 PU11.5(EN)
P1V25_FB: PC234.2 PQ14.2(S) PR246.2 PR249.1 PR255.1 PU11.6(FB)
P1V25_FB_IN: PC234.1 PR243.2 PR246.1 PR252.1
P1V25_FB_IN_R: PQ14.3(D) PR252.2
P1V25_FB_R: PQ15.3(D) PR255.2
P1V25_MARGIN_HI: PC237.1 PQ15.1(G) PR256.1 PR257.1
P1V25_MARGIN_LO: PC236.1 PQ14.1(G) PR253.1 PR254.1
P1V25_MODE: PR245.2 PR248.1 PU11.12(MODE)
P1V25_PG: PR240.2 PR247.2 PR334.2 PU11.9(PGOOD)
P1V25_REF: PC235.1 PU11.8(TRK/REF)
P1V25_SW: PC225.2 PL10.1 PR242.1 PU11.2(SW2) PU11.11(SW1)
P1V25_VCC: PC224.1 PR240.1 PR245.1 PU11.13(VCC)
P1V25_VIN: PC218.1 PC219.1 PC220.1 PC221.1 PC222.1 PR238.2 PU11.3(VIN1)
P1V26_BMC: C2285.1 C2286.2 C2287.2 C2288.1 C2293.2 C2294.1 C2295.1 C2296.1 C2307.1 C2321.1 C2376.1 L200.1 L201.1 PC340.1 PC341.1 PC342.1 PC343.1 PC344.1 PL20.2 PR368.1 PR416.2 PU21.5(OUT) R12731.2 U154.F14(IV12D1) U154.F15(IV12D2) U154.K6(IV12D3) U154.K17(PEAV12) U154.L6(IV12D4) U154.L17(IV12D5) U154.P6(IV12D6) U154.P17(IV12D7) U154.R6(IV12D8) U154.R17(IV12D9) U154.U12(IV12D10) U154.U13(IV12D11)
P1V26_BMC_EN: C2332.1 PR341.1 PU21.8(EN) R12436.2
P1V26_BMC_FB: PR369.2 PR370.1 PU21.7(FB)
P1V26_BMC_FB_IN: PR370.2 PR416.1
P1V26_BMC_PG: PR366.2 PR371.2 PU21.1(PG) U160.3(M\R\)
P1V26_BMC_SW: PL20.1 PR367.1 PU21.3(SW)
P1V26_BMC_VIN: PC336.1 PC337.1 PC338.1 PC339.1 PR365.1 PR366.1 PU21.2(VIN)
P1V538_BMC: C2169.1 C2245.1 C2246.1 C2247.1 C2248.1 C2249.1 C2250.2 C2251.1 C2252.2 C2253.2 C2254.2 C2255.1 C2256.1 C2257.1 C2258.1 C2259.1 C2260.2 C2261.1 C2262.2 C2263.2 C2264.2 C2302.1 C2303.1 C2304.1 C2305.1 C2306.2 C2377.1 PC330.1 PC331.1 PC332.1 PC333.1 PC334.1 PL19.2 PR361.1 PR417.2 PU20.5(OUT) R12306.2 R12313.2 R12325.1 R12732.2 U154.U10(MVDD1) U154.U11(MVDD2) U154.U14(MVDD3) U154.U15(MVDD4) U155.A1(VDDQ_1) U155.A8(VDDQ_2) U155.B2(VDD_1) U155.C1(VDDQ_3) U155.C9(VDDQ_4) U155.D2(VDDQ_5) U155.D9(VDD_2) U155.E9(VDDQ_6) U155.F1(VDDQ_7) U155.G7(VDD_3) U155.H2(VDDQ_8) U155.H9(VDDQ_9) U155.K2(VDD_4) U155.K8(VDD_5) U155.N1(VDD_6) U155.N9(VDD_7) U155.R1(VDD_8) U155.R9(VDD_9)
P1V538_BMC_EN: C2331.1 PR340.1 PU20.8(EN) R12435.2
P1V538_BMC_FB: PR362.2 PR363.1 PU20.7(FB)
P1V538_BMC_FB_IN: PR363.2 PR417.1
P1V538_BMC_PG: PR359.2 PR364.2 PU20.1(PG) R12436.1
P1V538_BMC_SW: PL19.1 PR360.1 PU20.3(SW)
P1V538_BMC_VIN: PC326.1 PC327.1 PC328.1 PC329.1 PR358.1 PR359.1 PU20.2(VIN)
P2V5: C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 PC244.1 PC245.1 PC246.1 PC247.1 PC248.1 PL11.2 PR260.1 PR261.1 R1059.2 U2.B1(VPP_01) U2.R9(VPP_02) U3.B1(VPP_01) U3.R9(VPP_02) U4.B1(VPP_01) U4.R9(VPP_02) U5.B1(VPP_01) U5.R9(VPP_02) U6.B1(VPP_01) U6.R9(VPP_02) U7.B1(VPP_01) U7.R9(VPP_02)
P2V5_EN: PC243.1 PR12.1 PU12.7(EN)
P2V5_MARGIN_HI: PC309.1 PQ17.1(G) PR321.1 PR324.1
P2V5_MARGIN_LO: PC310.1 PQ16.1(G) PR322.1 PR323.1
P2V5_PG: PC252.1 PR262.2 PR264.1 PR332.1 PU12.4(PG)
P2V5_SS: PC249.1 PU12.5(SS)
P2V5_SW: PC242.2 PL11.1 PR259.1 PU12.2(SW)
P2V5_VBST: PR258.1 PU12.8(VBST)
P2V5_VFB: PC251.2 PQ16.2(S) PR263.2 PR265.1 PR320.1 PU12.6(VFB)
P2V5_VFB_IN: PC251.1 PR260.2 PR263.1 PR329.1
P2V5_VFB_IN_R: PQ16.3(D) PR329.2
P2V5_VFB_R: PQ17.3(D) PR320.2
P2V5_VIN: PC238.1 PC239.1 PC240.1 PC241.1 PR316.2 PR319.2 PU12.3(VIN)
P2V5_VREF: C1604.1 C2462.1 J19.2 R781.1 R782.2 R13056.1 U70.D3(NC_2) U115.1(CATHODE)
P3V3: C753.2 C771.2 C772.2 C789.2 C790.2 C807.2 C825.2 C834.2 C843.2 C844.2 C853.2 C894.1 C895.2 C896.2 C897.2 C898.2 C899.1 C984.1 C985.2 C986.2 C987.1 C1252.1 C1257.1 C1262.1 C1267.1 C1272.1 C1277.1 C1282.1 C1287.1 C1292.1 C1297.1 C1302.1 C1307.1 C1312.1 C1317.1 C1332.1 C1357.1 C1358.1 C1359.1 C1360.1 C1361.1 C1362.1 C1363.1 C1364.1 C1365.1 C1366.1 C1367.1 C1371.2 C1372.2 C1373.2 C1374.2 C1375.2 C1378.2 C1379.2 C1382.2 C1383.1 C1384.1 C1385.1 C1386.1 C1387.2 C1388.1 C1389.2 C1390.1 C1391.2 C1392.2 C1393.1 C1394.1 C1395.1 C1396.1 C1397.2 C1398.1 C1399.2 C1400.2 C1401.1 C1402.2 C1403.1 C1404.1 C1410.1 C1632.2 C1633.2 C1634.2 C1635.1 C1636.1 C1641.1 C1644.2 C1689.2 C1815.2 C1816.1 C1935.2 C1938.2 C1942.2 C1979.1 C1980.1 C1982.2 C1991.2 C1992.2 C1993.2 C1994.2 C1995.2 C1999.2 C2000.2 C2038.2 C2042.2 C2045.2 C2048.2 C2051.2 C2054.2 C2057.2 C2061.1 C2062.1 C2077.1 C2089.1 C2097.1 C2105.1 C2113.1 C2121.1 C2122.1 C2123.1 C2132.2 C2142.2 C2154.2 C2157.2 C2206.1 C2209.1 C2216.1 C2217.1 C2219.1 C2221.2 C2333.1 C2334.2 C2356.2 C2359.2 C2360.2 C2368.1 C2369.1 C2374.2 C2385.2 C2386.2 C2397.1 C2399.1 C2401.2 C2417.2 C2422.2 C2426.2 C2430.2 C2431.2 C2432.2 C2433.2 C2436.1 C2461.2 CN1.4 CN6.3 D65.5(VDD) D67.5(VDD) D68.5(VDD) D69.5(VDD) J8.7 L19.2 L135.2 L136.1 L137.2 L138.2 L139.2 L141.2 L171.1 L172.1 L173.1 L174.1 L175.1 L176.1 L177.1 L178.1 L180.1 L181.1 L182.1 L183.1 L185.1 L187.2 L188.2 L189.2 L191.2 L192.2 L203.1 L206.1 L207.1 L208.1 PC48.1 PC49.1 PC50.1 PC51.1 PC54.1 PC55.1 PC56.1 PC57.1 PC58.1 PC89.1 PC210.1 PC370.1 PC371.1 PC379.1 PC382.1 PC383.1 PC384.1 PC389.1 PC390.1 PC391.1 PL3.2 PL21.2 PR83.1 PR86.1 PR95.1 PR140.2 PR142.2 PR152.1 PR153.1 PR154.1 PR236.1 PR420.1 PR428.1 PR436.1 PU10.10(VIN) R26.2 R27.2 R28.2 R29.2 R30.2 R31.2 R32.2 R67.2 R282.1 R283.2 R284.2 R298.2 R299.2 R300.2 R301.2 R306.1 R309.1 R312.2 R313.2 R314.2 R315.2 R316.2 R319.2 R320.2 R321.2 R322.2 R323.2 R326.2 R327.2 R328.2 R329.2 R330.2 R333.2 R334.2 R335.2 R336.2 R337.2 R340.2 R341.2 R342.2 R343.2 R344.2 R347.2 R348.2 R349.2 R350.2 R351.2 R354.2 R355.2 R356.2 R357.2 R358.2 R361.2 R362.2 R363.2 R364.2 R365.2 R368.2 R369.2 R370.2 R371.2 R372.2 R375.2 R376.2 R377.2 R378.2 R379.2 R382.2 R383.2 R384.2 R385.2 R386.2 R389.2 R390.2 R391.2 R392.2 R393.2 R396.2 R397.2 R398.2 R399.2 R400.2 R403.2 R404.2 R405.2 R406.2 R407.2 R410.2 R411.2 R412.2 R413.2 R414.2 R417.2 R418.2 R419.2 R420.2 R421.2 R424.2 R425.2 R426.2 R427.2 R428.2 R431.2 R432.2 R433.2 R434.2 R435.2 R438.2 R439.2 R440.2 R441.2 R442.2 R445.2 R446.2 R447.2 R448.2 R449.2 R536.2 R537.2 R538.2 R539.2 R540.2 R543.2 R544.2 R545.2 R546.2 R547.2 R550.2 R551.2 R552.2 R553.2 R554.2 R557.2 R558.2 R559.2 R560.2 R561.2 R564.2 R565.2 R566.2 R567.2 R568.2 R571.2 R572.2 R573.2 R574.2 R575.2 R578.2 R579.2 R580.2 R581.2 R582.2 R585.2 R586.2 R587.2 R588.2 R589.2 R594.2 R595.2 R596.2 R597.2 R598.2 R599.2 R623.2 R635.2 R646.2 R651.2 R652.2 R656.2 R657.2 R658.2 R660.2 R661.2 R662.2 R669.2 R670.2 R674.2 R675.2 R676.2 R678.2 R679.2 R680.2 R687.2 R688.2 R692.2 R693.2 R694.2 R696.2 R697.2 R698.2 R705.2 R706.2 R710.2 R711.2 R712.2 R714.2 R715.2 R716.2 R723.2 R724.2 R729.2 R730.2 R731.2 R732.2 R733.2 R734.2 R741.2 R746.2 R747.2 R748.2 R821.1 R822.1 R826.2 R827.2 R828.2 R829.2 R830.2 R831.2 R832.2 R833.2 R834.2 R835.2 R836.2 R837.2 R838.2 R839.2 R840.2 R841.2 R842.2 R844.2 R845.2 R850.2 R851.2 R852.2 R853.2 R854.2 R855.2 R856.2 R857.2 R858.2 R859.2 R860.2 R861.2 R862.2 R863.2 R864.2 R865.2 R867.2 R868.2 R869.2 R874.2 R875.2 R876.2 R877.2 R878.2 R879.2 R880.2 R881.2 R882.2 R883.2 R884.2 R885.2 R886.2 R887.2 R888.2 R889.2 R890.2 R891.2 R893.2 R898.2 R899.2 R900.2 R901.2 R902.2 R903.2 R904.2 R905.2 R906.2 R907.2 R908.2 R909.2 R910.2 R911.2 R912.2 R913.2 R914.2 R916.2 R917.2 R962.2 R963.2 R964.2 R965.2 R966.2 R967.2 R968.2 R969.2 R972.2 R973.2 R974.2 R978.2 R979.2 R980.2 R981.2 R982.2 R983.2 R984.2 R985.2 R988.2 R989.2 R990.2 R996.1 R997.1 R998.1 R999.1 R1000.2 R1001.2 R1002.2 R1003.2 R1013.1 R1014.1 R1015.1 R1016.1 R1048.2 R1049.2 R1058.2 R1079.2 R1080.2 R1103.1 R1104.1 R1124.1 R1125.1 R1126.1 R1127.1 R1128.1 R1129.1 R1130.1 R1131.1 R1132.1 R1141.1 R1142.1 R1143.1 R1144.1 R1191.2 R1198.2 R1204.2 R1216.1 R1218.1 R1219.1 R1220.1 R1221.1 R1222.1 R1223.1 R1224.1 R1267.1 R1272.1 R1273.1 R1276.1 R1277.1 R1569.2 R1576.2 R1608.1 R1611.1 R1612.1 R1613.1 R1620.2 R1621.2 R1622.2 R1627.1 R1643.1 R1646.1 R1649.1 R1652.2 R1655.2 R1661.1 R1677.2 R1678.2 R1679.2 R1680.2 R1683.2 R1684.2 R1685.2 R1686.2 R1687.2 R1688.2 R1689.2 R1690.2 R1694.1 R1695.1 R1699.1 R1700.1 R1701.1 R1702.1 R1703.1 R1704.1 R1705.1 R1706.1 R1707.1 R1709.1 R1710.1 R1711.1 R1712.1 R1713.1 R1714.1 R1716.1 R1717.1 R1721.1 R1731.1 R1734.1 R1737.1 R1739.1 R1741.1 R1743.1 R1745.1 R1747.1 R1751.1 R1752.1 R1753.1 R1754.1 R1755.1 R1756.1 R1757.1 R1758.1 R1760.1 R1764.2 R1767.1 R1768.1 R1776.2 R1777.2 R1780.2 R1781.2 R1782.2 R1787.2 R1788.2 R1789.2 R1797.2 R1798.2 R1799.2 R1800.2 R1801.2 R1802.2 R1803.2 R1804.2 R1805.2 R1806.2 R1807.2 R1808.2 R1809.2 R1810.2 R1811.2 R1812.2 R1818.2 R1830.2 R1836.1 R1846.2 R1847.2 R1848.2 R1849.2 R1850.2 R1861.2 R1872.2 R1875.2 R1876.2 R1877.2 R1881.1 R1882.1 R1883.1 R1884.1 R1907.2 R1908.2 R1980.2 R1981.1 R1982.2 R1983.2 R1984.1 R1988.2 R1989.2 R1990.2 R1991.2 R1992.2 R1993.2 R1994.2 R1995.2 R1998.2 R1999.2 R2000.2 R2004.1 R12460.1 R12461.1 R12466.2 R12468.1 R12480.2 R12765.1 R12767.1 R12769.1 R12771.1 R12773.1 R12774.1 R12789.1 R12791.1 R12792.1 R12797.2 R12801.1 R12802.1 R12806.1 R12807.1 R12810.1 R12812.1 R12820.2 R12821.2 R12832.2 R12898.2 R12915.1 R12916.2 R12920.1 R12921.2 R12936.1 R12937.1 R12949.2 R12971.2 R12972.2 R12979.2 R12985.1 R12986.1 R13008.2 R13009.2 R13056.2 R13068.1 U10.2(B) U10.14(VCC) U12.2(B) U12.14(VCC) U13.2(B) U13.14(VCC) U14.2(B) U14.14(VCC) U15.2(B) U15.14(VCC) U16.2(B) U16.14(VCC) U18.2(B) U18.14(VCC) U19.2(B) U19.14(VCC) U20.20(VCC) U21.2(B) U21.14(VCC) U22.20(VCC) U23.B7(DVDD33_0) U23.F11(VDDOLV_L) U23.K6(VDDIO_SYS) U23.P9(DVDD33_1) U25.K9(DVDDIO0) U25.K11(DVDDIO1) U25.L6(DVDDIOSYS) U25.M10(VDDIOSYSLVL) U25.T9(DVDDIOLVL) U26.2(IN1) U26.3(IN2) U27.2(IN1) U27.3(IN2) U28.2(IN1) U28.3(IN2) U29.2(IN1) U29.3(IN2) U30.2(IN1) U30.3(IN2) U31.2(IN1) U31.3(IN2) U32.2(IN1) U32.3(IN2) U33.2(IN1) U33.3(IN2) U34.2(IN1) U34.3(IN2) U35.2(IN1) U35.3(IN2) U36.2(IN1) U36.3(IN2) U37.2(IN1) U37.3(IN2) U38.2(IN1) U38.3(IN2) U39.2(IN1) U39.3(IN2) U42.2(IN1) U42.3(IN2) U46.8(VCC) U47.24(VCC) U48.24(VCC) U49.24(VCC) U50.24(VCC) U51.24(VCC) U52.24(VCC) U53.24(VCC) U54.24(VCC) U55.24(VCC) U56.24(VCC) U57.24(VCC) U60.5(VCC) U61.5(VCC) U62.24(VCC) U63.24(VCC) U64.24(VCC) U65.24(VCC) U68.16(VDD) U69.16(VDD) U70.C6(VCCIO_8_3) U70.C7(VCCIO_8_2) U70.C8(VCCIO_8_1) U70.F2(VCCIO_1_1) U70.F7(VCC_ONE_4) U70.F11(VCCIO_6_2) U70.G3(VCCIO_1_2) U70.G6(VCC_ONE_3) U70.G8(VCC_ONE_2) U70.G11(VCCIO_6_1) U70.H7(VCC_ONE_1) U70.H11(VCCIO_5_2) U70.J3(VCCIO_2_2) U70.J11(VCCIO_5_1) U70.K3(VCCIO_2_1) U70.L6(VCCIO_3_3) U70.L7(VCCIO_3_2) U70.L8(VCCIO_3_1) U71.8(VCC) U76.16(VDD) U85.10(VDD3P3[0]) U85.27(VDD3P3[1]) U85.41(VDD3P3[2]) U85.64(VDD3P3[4]) U86.8(VCC) U96.10(VCC) U105.5(VCC) U106.4(V+) U107.5(VCC) U108.5(VCC) U110.1(VL) U110.10(VCC) U111.5(V+) U112.5(V+) U121.1(VL) U121.10(VCC) U127.6(VDDAP) U127.8(VDDAB) U127.10(VDDAX) U127.15(VDDAT) U127.16(VDDAR) U127.30(VDDDIO[1]) U127.52(VDDDIO[2]) U127.73(VDDDIO[0]) U136.5(VCC) U137.5(VCC) U138.5(VCC) U140.8(VCC) U149.20(VCC) U150.24(VCC) U162.5(VIO) U162.6(VDD) U162.7(REGIN) U170.5(V+) U176.20(VCC) U177.5(V+) U178.14(VCC) U194.5(VCC) U200.5(V+)
P3V3_BMC: C2124.1 C2160.1 C2161.1 C2215.1 C2268.2 C2271.1 C2272.2 C2273.2 C2275.1 C2279.1 C2289.1 C2298.1 C2311.1 C2312.1 C2313.1 C2314.1 C2315.2 C2316.1 C2317.2 C2318.2 C2319.1 C2320.2 C2372.1 C2402.1 C2437.2 J17.1 J17.2 L194.2 L195.2 L196.1 L197.1 L198.1 L199.1 PR346.1 PR349.2 PR350.2 PR358.2 PR365.2 R12311.2 R12316.1 R12317.1 R12318.1 R12319.1 R12320.1 R12321.1 R12322.1 R12323.1 R12328.1 R12329.1 R12330.1 R12331.1 R12333.2 R12338.2 R12342.1 R12343.2 R12357.2 R12358.2 R12359.1 R12360.1 R12361.1 R12362.2 R12363.2 R12364.2 R12365.2 R12366.2 R12367.2 R12368.2 R12370.2 R12377.1 R12378.1 R12379.1 R12381.1 R12382.1 R12383.1 R12384.1 R12385.1 R12386.1 R12387.1 R12388.1 R12389.1 R12390.1 R12391.1 R12392.1 R12393.1 R12394.1 R12395.1 R12396.1 R12397.1 R12398.1 R12399.1 R12400.1 R12401.1 R12402.1 R12403.1 R12404.1 R12405.1 R12406.1 R12407.1 R12408.1 R12409.1 R12410.1 R12411.1 R12412.1 R12413.2 R12416.1 R12417.1 R12486.2 R12715.1 R12716.1 R12717.1 R12722.1 R12723.1 R12733.2 R12900.2 R12961.1 R12962.1 R12963.1 R12964.1 R12965.1 R12990.2 R13037.2 SK157.8 SK158.8 U99.5(VCC) U101.5(VCC) U102.5(VCC) U148.5(VCC) U154.F8(R2VDD1) U154.F9(R2VDD2) U154.F10(R1VDD1) U154.F11(R1VDD2) U154.F12(PV33D1) U154.F13(PV33D2) U154.H6(PV33D3) U154.H17(PV33D4) U154.J6(PV33D5) U154.J17(PEAV33) U154.M6(PV33D6) U154.M17(PV33D7) U154.N6(PV33D8) U154.N17(PV33D9) U154.U8(PV33D10) U154.U9(PV33D11) U157.8(VCC) U164.5(VCC) U171.5(VCC) U179.8(VCC)
P3V3_BMC_EN: C2330.1 PR339.2 PR354.1 PU19.14(EN) R12430.2 R12970.1
P3V3_BMC_FB: PC325.2 PR356.2 PR357.1 PU19.5(FB)
P3V3_BMC_IN: PC325.1 PR353.1 PR356.1
P3V3_BMC_L2: PL18.1 PU19.11(L1)
P3V3_BMC_L3: PL18.2 PU19.9(L2)
P3V3_BMC_PG: PR351.2 PR355.2 PU19.2(PG) R12435.1
P3V3_BMC_VIN: PC315.1 PC316.1 PC317.1 PC318.1 PR347.2 PR348.2 PU19.12(VIN1) PU19.13(VIN2)
P3V3_BMC_VOUT: PC319.1 PC320.1 PC321.1 PC322.1 PC323.1 PR349.1 PR350.1 PR351.1 PR352.1 PR353.2 PU19.7(VOUT1) PU19.8(VOUT2)
P3V3_BOOT: PR94.1 PU2.7(BOOT)
P3V3_BOOT2: PR427.1 PU22.7(BOOT)
P3V3_BP: PC45.2 PR91.1 PU2.28(BP)
P3V3_BP2: PC376.2 PR437.1 PU22.28(BP)
P3V3_EN: PC62.2 PC368.2 PR50.2 PR96.1 PR432.1 PU2.33(EN) PU22.33(EN)
P3V3_FAN: C1553.1 C1554.1 J5.25 R2004.2 R2005.2
P3V3_HWM: L38.2 PC5.1 PC7.2 PC8.2 PC313.1 PC314.1 PD1.1(C) PR346.2 Q2.2(E) R1040.1 U73.7(V33DIO1) U73.44(V33DIO2) U73.45(V33D)
P3V3_HWM_V33A: C2440.2 C2441.1 L38.1 U73.46(V33A)
P3V3_HWM_V33FB: D43.2(C) PR2.1 Q2.1(B) U73.58(V33FB)
P3V3_ILIM: PR80.2 PU2.30(ILIM)
P3V3_ILIM2: PR435.2 PU22.30(ILIM)
P3V3_MARGIN_HI: PC64.1 PQ5.1(G) PR102.1 PR103.1
P3V3_MARGIN_LO: PC63.1 PQ4.1(G) PR99.1 PR100.1
P3V3_MODE: PR75.1 PU2.39(MODE)
P3V3_MODE2: PR423.2 PU22.39(MODE)
P3V3_OCXO: C2133.1 L186.1 PC405.1 PC406.1 PC407.1 PC409.1 PC3408.1 PR388.1 PU13.1(OUT1) PU13.18(OUT2) PU13.19(OUT3) PU13.20(OUT4)
P3V3_OCXO_EN: PR386.2 PR387.2 PU13.11(EN)
P3V3_OCXO_FB: PR388.2 PR389.1 PU13.16(FB)
P3V3_OCXO_PG: PU13.9(PG) TP153.1
P3V3_OCXO_SS: PC404.1 PU13.15(SS)
P3V3_PG: PC47.2 PC374.2 PR35.1 PR91.2 PR92.2 PR425.2 PR437.2 PU2.34(PGD) PU22.34(PGD)
P3V3_QSFP1: C1234.1 C1235.1 C1242.1 C1248.1 C1333.1 C1334.1 L129.2 L131.2 L133.2 R1585.1 U42.9(OUT1)
P3V3_QSFP2: C1238.1 C1239.1 C1245.1 C1251.1 C1335.1 C1336.1 L130.2 L132.2 L134.2 R1588.1 U42.8(OUT2)
P3V3_RAMP: PR74.2 PU2.40(RAMP)
P3V3_RAMP2: PR418.2 PU22.40(RAMP)
P3V3_RSN: PQ5.2(S) PR88.2 PR89.2 PR90.1 PU2.2(RSN)
P3V3_RSN2: PR426.2 PR431.2 PR438.1 PU22.2(RSN)
P3V3_RSP: PC46.2 PQ4.2(S) PR87.2 PR88.1 PR101.1 PU2.1(RSP)
P3V3_RSP2: PC377.2 PR431.1 PR439.2 PU22.1(RSP)
P3V3_RSP2_R1: PC377.1 PR420.2 PR428.2 PR439.1
P3V3_RSP_R: PQ5.3(D) PR101.2
P3V3_RSP_R1: PC46.1 PR87.1 PR98.1 PR504.2
P3V3_RSP_R1R: PQ4.3(D) PR98.2
P3V3_RT: PR76.2 PU2.38(RT)
P3V3_RT2: PR440.2 PU22.38(RT)
P3V3_SB: PR25.1 PR29.1 PR30.1 PR41.1 PR42.1 PR47.1
P3V3_SFP00: C994.1 C997.1 C1253.1 C1254.1 L49.2 L50.2 R1548.1 U26.9(OUT1)
P3V3_SFP01: C1000.1 C1003.1 C1255.1 C1256.1 L51.2 L52.2 R1555.1 U26.8(OUT2)
P3V3_SFP02: C1006.1 C1009.1 C1268.1 C1269.1 L53.2 L54.2 R1557.1 U29.9(OUT1)
P3V3_SFP03: C1012.1 C1015.1 C1270.1 C1271.1 L55.2 L56.2 R1559.1 U29.8(OUT2)
P3V3_SFP04: C1018.1 C1021.1 C1283.1 C1284.1 L57.2 L58.2 R1561.1 U32.9(OUT1)
P3V3_SFP05: C1024.1 C1027.1 C1285.1 C1286.1 L59.2 L60.2 R1563.1 U32.8(OUT2)
P3V3_SFP06: C1030.1 C1033.1 C1298.1 C1299.1 L61.2 L62.2 R1565.1 U35.9(OUT1)
P3V3_SFP07: C1036.1 C1039.1 C1300.1 C1301.1 L63.2 L64.2 R1567.1 U35.8(OUT2)
P3V3_SFP08: C1042.1 C1045.1 C1313.1 C1314.1 L65.2 L66.2 R1570.1 U38.9(OUT1)
P3V3_SFP09: C1048.1 C1051.1 C1315.1 C1316.1 L67.2 L68.2 R1572.1 U38.8(OUT2)
P3V3_SFP10: C1054.1 C1057.1 C1258.1 C1259.1 L69.2 L70.2 R1574.1 U27.9(OUT1)
P3V3_SFP11: C1060.1 C1063.1 C1260.1 C1261.1 L71.2 L72.2 R1577.1 U27.8(OUT2)
P3V3_SFP12: C1066.1 C1069.1 C1273.1 C1274.1 L73.2 L74.2 R1579.1 U30.9(OUT1)
P3V3_SFP13: C1072.1 C1075.1 C1275.1 C1276.1 L75.2 L76.2 R1581.1 U30.8(OUT2)
P3V3_SFP14: C1078.1 C1081.1 C1288.1 C1289.1 L77.2 L78.2 R1583.1 U33.9(OUT1)
P3V3_SFP15: C1084.1 C1087.1 C1290.1 C1291.1 L79.2 L80.2 R1586.1 U33.8(OUT2)
P3V3_SFP16: C1186.1 C1189.1 C1303.1 C1304.1 L113.2 L114.2 R1554.1 U36.9(OUT1)
P3V3_SFP17: C1192.1 C1195.1 C1305.1 C1306.1 L115.2 L116.2 R1556.1 U36.8(OUT2)
P3V3_SFP18: C1198.1 C1201.1 C1318.1 C1319.1 L117.2 L118.2 R1558.1 U39.9(OUT1)
P3V3_SFP19: C1204.1 C1207.1 C1320.1 C1321.1 L119.2 L120.2 R1560.1 U39.8(OUT2)
P3V3_SFP20: C1210.1 C1213.1 C1263.1 C1264.1 L121.2 L122.2 R1562.1 U28.9(OUT1)
P3V3_SFP21: C1216.1 C1219.1 C1265.1 C1266.1 L123.2 L124.2 R1564.1 U28.8(OUT2)
P3V3_SFP22: C1222.1 C1225.1 C1278.1 C1279.1 L125.2 L126.2 R1566.1 U31.9(OUT1)
P3V3_SFP23: C1228.1 C1231.1 C1280.1 C1281.1 L127.2 L128.2 R1568.1 U31.8(OUT2)
P3V3_SFP24: C1090.1 C1093.1 C1293.1 C1294.1 L81.2 L82.2 R1571.1 U34.9(OUT1)
P3V3_SFP25: C1096.1 C1098.1 C1295.1 C1296.1 L83.2 L84.2 R1573.1 U34.8(OUT2)
P3V3_SFP26: C1102.1 C1105.1 C1308.1 C1309.1 L85.2 L86.2 R1575.1 U37.9(OUT1)
P3V3_SFP27: C1108.1 C1111.1 C1310.1 C1311.1 L87.2 L88.2 R1578.1 U37.8(OUT2)
P3V3_SFP_DISCHARGE_P00: Q28.3(D2) R1548.2
P3V3_SFP_DISCHARGE_P01: Q28.6(D1) R1555.2
P3V3_SFP_DISCHARGE_P02: Q29.3(D2) R1557.2
P3V3_SFP_DISCHARGE_P03: Q29.6(D1) R1559.2
P3V3_SFP_DISCHARGE_P04: Q30.3(D2) R1561.2
P3V3_SFP_DISCHARGE_P05: Q30.6(D1) R1563.2
P3V3_SFP_DISCHARGE_P06: Q31.3(D2) R1565.2
P3V3_SFP_DISCHARGE_P07: Q31.6(D1) R1567.2
P3V3_SFP_DISCHARGE_P08: Q32.3(D2) R1570.2
P3V3_SFP_DISCHARGE_P09: Q32.6(D1) R1572.2
P3V3_SFP_DISCHARGE_P10: Q33.3(D2) R1574.2
P3V3_SFP_DISCHARGE_P11: Q33.6(D1) R1577.2
P3V3_SFP_DISCHARGE_P12: Q34.3(D2) R1579.2
P3V3_SFP_DISCHARGE_P13: Q34.6(D1) R1581.2
P3V3_SFP_DISCHARGE_P14: Q35.3(D2) R1583.2
P3V3_SFP_DISCHARGE_P15: Q35.6(D1) R1586.2
P3V3_SFP_DISCHARGE_P16: Q36.3(D2) R1554.2
P3V3_SFP_DISCHARGE_P17: Q36.6(D1) R1556.2
P3V3_SFP_DISCHARGE_P18: Q37.3(D2) R1558.2
P3V3_SFP_DISCHARGE_P19: Q37.6(D1) R1560.2
P3V3_SFP_DISCHARGE_P20: Q38.3(D2) R1562.2
P3V3_SFP_DISCHARGE_P21: Q38.6(D1) R1564.2
P3V3_SFP_DISCHARGE_P22: Q39.3(D2) R1566.2
P3V3_SFP_DISCHARGE_P23: Q39.6(D1) R1568.2
P3V3_SFP_DISCHARGE_P24: Q40.3(D2) R1571.2
P3V3_SFP_DISCHARGE_P25: Q40.6(D1) R1573.2
P3V3_SFP_DISCHARGE_P26: Q41.3(D2) R1575.2
P3V3_SFP_DISCHARGE_P27: Q41.6(D1) R1578.2
P3V3_SFP_DISCHARGE_P32: Q44.3(D2) R1585.2
P3V3_SFP_DISCHARGE_P33: Q44.6(D1) R1588.2
P3V3_SN: PC61.1 PR93.2
P3V3_SN2: PC388.1 PR433.2
P3V3_SS: PR78.2 PU2.37(SS)
P3V3_SS2: PR430.2 PU22.37(SS)
P3V3_STB: C3.1 C1368.1 C1377.2 C1412.2 C1413.2 C1548.2 C1678.2 C1817.2 C1818.2 C2002.1 C2162.1 C2224.2 C2229.2 C2361.2 C2373.2 C2403.2 C2404.2 C2439.2 C2446.1 C2447.1 C2448.1 C2449.1 C2450.1 C2451.1 C2463.1 J3.1 J20.1 L89.1 PC3.1 PC4.1 PC6.1 PD1.2(A) PR1.1 PU18.1(OUT) R742.2 R750.2 R751.2 R752.2 R946.2 R947.2 R948.2 R949.2 R950.2 R951.2 R952.2 R953.2 R956.2 R957.2 R958.2 R1024.2 R1025.1 R1026.1 R1027.1 R1028.1 R1029.2 R1030.2 R1038.1 R1039.1 R1046.2 R1083.2 R1097.2 R1098.2 R1099.2 R1153.2 R1157.2 R1175.2 R1180.2 R1268.2 R1281.2 R1750.1 R2005.1 R12295.1 R12302.1 R12471.2 R12487.2 R12896.1 R12908.2 R12909.2 R12945.2 R12946.2 R12975.2 R12977.2 R13017.2 R13018.2 R13019.2 R13021.2 R13030.2 R13087.2 R13090.2 U1.D25(THERM_DIODE_VDD3P3) U58.24(VCC) U59.5(VCC) U67.16(VDD) U74.8(VDD) U75.1(V+) U81.8(VCC) U89.15(VCC) U97.5(V+) U98.5(V+) U145.5(VCC) U151.5(V+) U152.5(V+) U156.5(V+) U165.5(V+) U172.5(V+) U173.5(V+) U180.4(VDD) U181.4(VDD) U182.4(VDD) U185.8(VDD) U196.5(VCC) U197.5(VCC) U198.4(VDD) U201.4(VDD)
P3V3_SW: PC60.2 PL3.1 PR93.1 PU2.8(SW_8) PU2.9(SW_9) PU2.10(SW_10) PU2.11(SW_11) PU2.12(SW_12)
P3V3_SW2: PC369.2 PL21.1 PR433.1 PU22.8(SW_8) PU22.9(SW_9) PU22.10(SW_10) PU22.11(SW_11) PU22.12(SW_12)
P3V3_VBAT: J1.A69(PCIE0_RX12_N) R12827.2
P3V3_VDD: PC34.1 PR77.1 PU2.26(VDD)
P3V3_VDD2: PC372.1 PR429.1 PU22.26(VDD)
P3V3_VIN: PC35.1 PC36.1 PC37.1 PC38.1 PC39.1 PC41.1 PC42.1 PR77.2 PR81.1 PR82.1 PR84.1 PR85.1 PU2.21(PVIN_21) PU2.22(PVIN_22) PU2.23(PVIN_23) PU2.24(PVIN_24) PU2.25(PVIN_25)
P3V3_VIN2: PC373.1 PC375.1 PC378.1 PC380.1 PC381.1 PC386.1 PC387.1 PR419.1 PR421.1 PR424.1 PR429.2 PR434.1 PU22.21(PVIN_21) PU22.22(PVIN_22) PU22.23(PVIN_23) PU22.24(PVIN_24) PU22.25(PVIN_25)
P3V3_VSEL: PR79.2 PU2.36(VSEL)
P3V3_VSEL2: PR422.2 PU22.36(VSEL)
P5V0: C1956.2 C1978.2 C2076.2 C2453.2 L20.2 PR58.2 PR59.2 PR63.1 PR109.1 PR155.2 PR159.1 PR163.1 PR262.1 PR312.1 PR314.1 R1057.2 U43.1(IN) U113.5(VS) U183.5(VS)
P5V0_EN: PC9.1 PC22.1 PR16.2 PR20.1 PU1.7(EN)
P5V0_FB_IN: PC30.1 PR61.2 PR64.1 PR68.1
P5V0_FB_IN_R: PQ2.3(D) PR68.2
P5V0_MARGIN_HI: PC33.1 PQ3.1(G) PR72.1 PR73.1
P5V0_MARGIN_LO: PC32.1 PQ2.1(G) PR69.1 PR70.1
P5V0_PG: PC31.1 PR46.2 PR63.2 PR65.1 PU1.4(PG)
P5V0_SS: PC28.1 PU1.5(SS)
P5V0_SW: PC21.2 PL2.1 PR60.1 PU1.2(SW)
P5V0_USB: C1685.1 C1686.2 D61.5(VDD) R12980.2 U43.6(OUT)
P5V0_VBST: PR57.1 PU1.8(VBST)
P5V0_VFB: PC30.2 PQ2.2(S) PR64.2 PR66.1 PR67.1 PR71.1 PU1.6(VFB)
P5V0_VFB_R: PQ3.3(D) PR71.2
P5V0_VIN: PC17.1 PC18.1 PC19.1 PC20.1 PR56.2 PR318.2 PU1.3(VIN)
P5V0_VOUT: PC23.1 PC24.1 PC25.1 PC26.1 PC27.1 PL2.2 PR58.1 PR59.1 PR61.1 PR62.1
P5V_SB: PC1.1 PC2.1 PC400.1 PC401.1 PC402.1 PC403.1 PQ21.1(D1) PQ21.5(D2) PQ21.8(D3) PR2.2 PR295.2 PR347.1 PR348.1 PR386.1 PU13.5(IN1) PU13.6(IN2) PU13.7(IN3) PU13.8(IN4) PU13.10(BIAS) PU18.5(EN) PU18.8(IN) Q2.3(C) R1279.2 R1280.2 R12283.2 R12428.1 R12824.2 R12825.2
P5V_SB_IN: CN3.E1 CN3.E2 CN3.E3 PC300.1 PD4.2 PQ21.2(S4) PQ21.3(S3) PQ21.6(S2) PQ21.7(S1) PR295.1 PR297.2
P10V_H2_EN_R: PR485.1 PU24.8(EN)
P10V_H2_FB: PC417.2 PQ25.2(S) PR482.1 PR483.2 PR501.1 PU24.5(FB)
P10V_H2_MODE: PR487.2 PR489.1 PU24.10(MODE)
P10V_H2_SW: PL23.1 PR484.1 PU24.2(SW)
P10V_H2_VIN: PC418.1 PC420.1 PC422.1 PC423.1 PC426.1 PR480.2 PR481.2 PU24.1(VIN)
P10V_H2_VMG-LOW1_R: PC434.1 PQ25.1(G) PR496.1 PR499.1
P10V_H2_VMG-LOW2_R: PC433.1 PQ24.1(G) PR497.1 PR498.1
P10V_H2_VOS: PC417.1 PR483.1 PR486.1 PR500.1 PU24.6(VOS)
P10V_H2_VOS_R: PQ25.3(D) PR500.2
P12V: C1550.1 C1556.1 C1557.1 C1558.1 C2060.1 C2176.1 C2423.1 CN3.P21 CN3.P22 CN3.P23 CN3.P24 CN3.P25 CN3.P26 CN3.P27 CN3.P28 CN3.P29 CN3.P30 J1.A2(12V_3) J1.A3(12V_4) J1.B1(12V_0) J1.B2(12V_1) J1.B3(12V_2) J6.3 J6.4 PC43.1 PC103.1 PC148.1 PR11.1 PR56.1 PR81.2 PR82.2 PR84.2 PR85.2 PR150.2 PR171.2 PR173.2 PR174.2 PR176.2 PR195.1 PR216.1 PR238.1 PR306.2 PR307.2 PR308.2 PR309.2 PR310.2 PR311.2 PR316.1 PR317.1 PR318.1 PR319.1 PR373.2 PR395.2 PR419.2 PR421.2 PR424.2 PR434.2 PR480.1 PR481.1 PR489.2 R1061.2 R12826.1 R12968.2 U104.8(VCC)
VBAT_VSENSE_IN: Q56.3(D) R12700.2 U154.L5(ADC0/GPIW0)
VCC_GNSS_RF: R12903.2 U124.9(VCC_RF)
VDD_CORE: C244.1 C245.1 C246.2 C247.1 C248.1 C249.2 C250.2 C251.1 C252.2 C253.1 C263.1 C264.1 C265.1 C266.1 C267.1 C268.2 C269.1 C270.1 C271.2 C272.1 C273.1 C277.2 C278.2 C279.1 C291.1 C292.2 C293.1 C294.1 C295.2 C296.1 C297.2 C298.1 C299.1 C300.2 C301.1 C325.1 C326.1 C327.2 C328.1 C329.1 C330.2 C331.1 C332.2 C333.1 C334.1 C335.2 C336.1 C348.1 C349.1 C350.2 C351.1 C352.1 C353.2 C354.1 C355.2 C356.1 C357.1 C358.2 C359.1 C371.1 C372.2 C373.1 C374.1 C375.2 C376.1 C377.2 C378.1 C379.1 C380.2 C381.1 C389.1 C390.1 C391.2 C392.1 C393.1 C394.2 C395.1 C396.2 C397.1 C398.1 C399.2 C400.1 C407.1 C408.1 C409.2 C410.1 C411.1 C412.2 C413.1 C414.2 C415.1 C416.1 C417.2 C418.1 PC105.1 PC109.1 PC110.1 PC111.1 PC112.1 PC113.1 PC114.1 PC123.1 PC127.1 PC131.1 PC132.1 PC133.1 PC134.1 PC135.1 PC136.1 PC307.1 PL5.2 PL6.2 PR139.1 PR325.1 PR326.1 PU5.5(VOS) PU6.5(VOS) R1056.2 U1.AA12(VDDC_46) U1.AA14(VDDC_47) U1.AA16(VDDC_48) U1.AA18(VDDC_49) U1.AA20(VDDC_50) U1.AA22(VDDC_51) U1.AA24(VDDC_52) U1.AA26(VDDC_53) U1.AB13(VDDC_54) U1.AB15(VDDC_55) U1.AB17(VDDC_56) U1.AB19(VDDC_57) U1.AB21(VDDC_58) U1.AB23(VDDC_59) U1.AB25(VDDC_60) U1.AB27(VDDC_61) U1.AC14(VDDC_62) U1.AC16(VDDC_63) U1.AC20(VDDC_64) U1.AC22(VDDC_65) U1.AC24(VDDC_66) U1.AC26(VDDC_67) U1.AC28(VDDC_68) U1.AD13(VDDC_69) U1.AD15(VDDC_70) U1.AD17(VDDC_71) U1.AD19(VDDC_72) U1.AD21(VDDC_73) U1.AD23(VDDC_74) U1.AE12(VDDC_75) U1.AE14(VDDC_76) U1.AE16(VDDC_77) U1.AE18(VDDC_78) U1.AE20(VDDC_79) U1.AE22(VDDC_80) U1.AE24(VDDC_81) U1.AF13(VDDC_82) U1.AF15(VDDC_83) U1.AF23(VDDC_84) U1.AG11(VDDC_85) U1.AG12(VDDC_86) U1.AG14(VDDC_87) U1.AG16(VDDC_88) U1.P11(VDDC_1) U1.P13(VDDC_2) U1.P15(VDDC_3) U1.P17(VDDC_4) U1.P19(VDDC_5) U1.P21(VDDC_6) U1.P25(VDDC_7) U1.P27(VDDC_8) U1.R12(VDDC_9) U1.R14(VDDC_10) U1.R16(VDDC_11) U1.R18(VDDC_12) U1.R20(VDDC_13) U1.R22(VDDC_14) U1.R24(VDDC_15) U1.R26(VDDC_16) U1.T11(VDDC_17) U1.T15(VDDC_18) U1.T17(VDDC_19) U1.T19(VDDC_20) U1.T21(VDDC_21) U1.T23(VDDC_22) U1.T27(VDDC_23) U1.U16(VDDC_24) U1.U18(VDDC_25) U1.U20(VDDC_26) U1.U22(VDDC_27) U1.V11(VDDC_28) U1.V15(VDDC_29) U1.V17(VDDC_30) U1.V21(VDDC_31) U1.V23(VDDC_32) U1.V27(VDDC_33) U1.W12(VDDC_34) U1.W14(VDDC_35) U1.W16(VDDC_36) U1.W20(VDDC_37) U1.W22(VDDC_38) U1.W24(VDDC_39) U1.W26(VDDC_40) U1.Y11(VDDC_41) U1.Y13(VDDC_42) U1.Y15(VDDC_43) U1.Y21(VDDC_44) U1.Y23(VDDC_45)
VDD_CORE_ADDR_TRISE: PR130.2 PR136.1 PU4.28(ADDR_TRISE)
VDD_CORE_BOOT1: PC95.1 PU5.9(BOOT)
VDD_CORE_BOOT2: PC125.1 PU6.9(BOOT)
VDD_CORE_BOOTR1: PR158.1 PU5.8(BOOTR)
VDD_CORE_BOOTR2: PR162.1 PU6.8(BOOTR)
VDD_CORE_COMP: PC86.1 PR144.1 PU4.11(COMP)
VDD_CORE_COMP_RC: PC88.1 PR144.2
VDD_CORE_CSP1: PU4.3(CSP1) PU5.2(IOUT)
VDD_CORE_CSP2: PU4.4(CSP2) PU6.2(IOUT)
VDD_CORE_CSP3: PR133.2 PU4.5(CSP3)
VDD_CORE_EN-FCCM1: PC101.1 PR157.2 PU5.11(EN/FCCM)
VDD_CORE_EN-FCCM2: PC365.1 PR161.2 PU6.11(EN/FCCM)
VDD_CORE_ENABLE: PC84.1 PR138.1 PU4.23(ENABLE)
VDD_CORE_F-MAX: PR120.2 PR124.1 PU4.32(F-IMAX)
VDD_CORE_IMON: PC83.1 PR132.1 PU4.2(IMON)
VDD_CORE_IMON_R: PR132.2 PR137.1
VDD_CORE_ISUM: PR148.1 PU4.12(ISUM)
VDD_CORE_LSET1: PR372.1 PU5.3(LSET)
VDD_CORE_LSET2: PR396.1 PU6.3(LSET)
VDD_CORE_O-USR: PR128.2 PR134.1 PU4.30(O-USR)
VDD_CORE_OCL-R: PR127.2 PR131.2 PU4.1(OCL-R)
VDD_CORE_PMB_ALERT_L: PJ1.8 PR122.1 PR153.2 PU4.25(PMB_ALERT#)
VDD_CORE_PMB_CLK: PJ1.9 PR152.2 PR337.2 PU4.24(PMB_CLK)
VDD_CORE_PMB_DIO: PJ1.10 PR154.2 PR338.2 PU4.26(PMB_DIO)
VDD_CORE_PWM1: PR397.1 PU4.38(PWM1)
VDD_CORE_PWM1_R: PR314.2 PR315.1 PR397.2 PU5.10(PWM)
VDD_CORE_PWM2: PR374.1 PU4.37(PWM2)
VDD_CORE_PWM2_R: PR312.2 PR313.1 PR374.2 PU6.10(PWM)
VDD_CORE_RESET_L: PC364.1 PR142.1 PU4.21(RESET#) TP120.1
VDD_CORE_SKIP#NVM: PR123.1 PU4.39(SKIP#-NVM)
VDD_CORE_SLEW_MODE: PR129.2 PR135.1 PU4.29(SLEW_MODE)
VDD_CORE_SW1: PL5.1 PR160.1 PU5.6(SW)
VDD_CORE_SW2: PL6.1 PR164.1 PU6.6(SW)
VDD_CORE_TSEN: PC82.2 PC93.1 PC116.1 PR126.2 PU4.40(TSEN) PU5.12(TAO/FLT) PU6.12(TAO/FLT)
VDD_CORE_V3R3: PC90.1 PR133.1 PR145.1 PR146.1 PR157.1 PR161.1 PU4.14(V3R3)
VDD_CORE_V5: PC91.1 PR155.1 PU4.15(V5)
VDD_CORE_VBOOT: PR121.2 PR125.1 PU4.31(VBOOT)
VDD_CORE_VDD1: PC104.1 PR159.2 PU5.4(VDD)
VDD_CORE_VDD2: PC102.1 PR163.2 PU6.4(VDD)
VDD_CORE_VIN: PC92.1 PR150.1 PU4.16(VIN)
VDD_CORE_VIN1: PC96.1 PC97.1 PC98.1 PC99.1 PC100.1 PR306.1 PR307.1 PR310.1 PR311.1 PU5.7(VIN)
VDD_CORE_VIN2: PC118.1 PC119.1 PC120.1 PC121.1 PC122.1 PR308.1 PR309.1 PR373.1 PR395.1 PU6.7(VIN)
VDD_CORE_VR_HOT_L: PR145.2 PU4.19(VR_HOT#)
VDD_CORE_VREF: PC86.2 PC87.1 PC88.2 PC94.1 PC117.1 PR120.1 PR121.1 PR127.1 PR128.1 PR129.1 PR130.1 PR148.2 PU4.13(VREF) PU5.1(REFIN) PU6.1(REFIN)
VDD_CORE_VSN: PC85.2 PR143.2 PR147.2 PR149.1 PU4.10(VSN)
VDD_CORE_VSP: PR506.2 PU4.9(VSP)
VDD_CORE_VSP_R: PC85.1 PR139.2 PR141.2 PR143.1 PR506.1
5P49V_VDDO: C2039.2 C2040.2 C2041.2 C2348.2 C2350.2 C2352.2 L171.2 U163.10(VDDO4) U163.15(VDDO3) U163.18(VDDO2) U163.21(VDDO1) U163.23(VDDO0)
BITS_CLK_SEL0: R1622.1 R1626.2 U127.65(CLK_SEL[0])
BITS_CLK_SEL1: R1621.1 R1625.2 U127.66(CLK_SEL[1])
BITS_CLK_SEL2: R1620.1 R1624.2 U127.67(CLK_SEL[2])
BITS_DATA_PD: R1614.1 U127.25(D[1]) U127.26(D[2]) U127.27(D[3]) U127.28(D[4]) U127.29(D[5]) U127.31(D[6]) U127.33(D[7])
BITS_IC_PD: R1623.1 U127.21(IC[0]) U127.40(IC[1])
BITS_LINE_ISO_EN: R1616.1 U127.2(THZ)
BITS_MPM: R1611.2 U127.22(MPM)
BITS_REFR: R1615.1 U127.9(REFR)
BITS_SPI_MODE_EN: R1612.2 U127.23(SPIEN)
BITS_T1_RRING: R1597.1 U127.18(RRING)
BITS_T1_RRING_CMC: D103.2(C) F2.1 L162.2
BITS_T1_RRING_CONN: F2.2 J7.BR2(1RX-)
BITS_T1_RRING_XFMR: D77.2(C) D93.4(TX2+IN) D93.7(TX2+OUT) R1596.2 R1597.2 T1.3
BITS_T1_RRING_XFMR_CMC: L162.1 T1.14
BITS_T1_RTIP: R1595.1 U127.17(RTIP)
BITS_T1_RTIP_CMC: D104.1(A) F1.1 L162.3
BITS_T1_RTIP_CONN: F1.2 J7.BR1(1RX+)
BITS_T1_RTIP_XFMR: D77.1(A) D93.5(TX2-IN) D93.6(TX2-OUT) R1595.2 R1596.1 T1.1
BITS_T1_RTIP_XFMR_CMC: L162.4 T1.16
BITS_T1_TRING: R1599.1 U127.12(TRING)
BITS_T1_TRING_CMC: D100.2(C) F4.1 L163.2
BITS_T1_TRING_CONN: F4.2 J7.BR5(B5)
BITS_T1_TRING_XFMR: C1981.2 D80.1(A) D93.1(TX1+IN) D93.10(TX1+OUT) R1599.2 T1.8
BITS_T1_TRING_XFMR_CMC: L163.1 T1.9
BITS_T1_TTIP: R1598.1 U127.11(TTIP)
BITS_T1_TTIP_CMC: D99.1(A) F3.1 L163.3
BITS_T1_TTIP_CONN: F3.2 J7.BR4(B4)
BITS_T1_TTIP_XFMR: C1981.1 D80.2(C) D93.2(TX1-IN) D93.9(TX1-OUT) R1598.2 T1.6
BITS_T1_TTIP_XFMR_CMC: L163.4 T1.11
BMC_ADCREXT: R12375.2 U154.P2(ADCREXT)
BMC_ADCVREFN: C2284.1 C2292.2 U154.K2(ADCVREFN)
BMC_ADCVREFP: C2283.2 C2284.2 U154.K1(ADCVREFP)
BMC_BS_ENTEST: R12337.1 U154.E4(ENTEST)
BMC_DACRSET: R12376.2 U154.R1(DACRSET)
BMC_FAN1_PWM_CTRL: R12965.2 U154.W4(GPION0/PWM0/VPIG0) U176.11(2A1)
BMC_FAN2_PWM_CTRL: R12963.2 U154.Y3(GPION1/PWM1/VPIG1) U176.13(2A2)
BMC_FAN3_PWM_CTRL: R12962.2 U154.AA2(GPION2/PWM2/VPIG2) U176.15(2A3)
BMC_FAN4_PWM_CTRL: R12961.2 U154.AB1(GPION3/PWM3/VPIG3) U176.17(2A4)
BMC_FAN5_PWM_CTRL: R12964.2 U154.W5(GPION4/PWM4/VPIG4) U200.1(NO)
BMC_HEATING_DONE: R1703.2 U70.B4(IO_8_21) U73.23(FPWM7/GPIO11) U154.H2(GPIOQ6/USB11_HDP4)
BMC_I2C9_SCL: R12715.2 U154.C5(GPIOA4/TIMER5/SCL9)
BMC_LPC_SIOONCTRL_N: R12342.2 U154.K20(GPIOY3/SIOONCTRL#)
BMC_OSC_OE: R12333.1 X13.1(ENABLE CONTROL)
BMC_PCIE_REXT: R12312.1 U154.D20(PEREXT)
BMC_PWRGD: R12417.2 U70.K2(IO_2_15) U160.2(R\E\S\E\T\) U164.1(INB) U171.1(INB)
BMC_ROMA0: R12386.2 U154.R20(ROMA0)
BMC_ROMA1: R12389.2 U154.R21(ROMA1)
BMC_ROMA2: R12391.2 U154.R22(ROMA2/GPOZ0/VPOB0)
BMC_ROMA3: R12393.2 U154.P18(ROMA3/GPOZ1/VPOB1)
BMC_ROMA4: R12397.2 U154.P19(ROMA4/GPOZ2/VPOB2)
BMC_ROMA5: R12400.2 U154.P20(ROMA5/GPOZ3/VPOB3)
BMC_ROMA6: R12405.2 U154.P21(ROMA6/GPOZ4/VPOB4)
BMC_ROMA7: R12410.2 U154.P22(ROMA7/GPOZ5/VPOB5)
BMC_ROMA8: R12381.2 U154.M19(ROMA8/GPOZ6/VPOB6)
BMC_ROMA9: R12383.2 U154.M20(ROMA9/GPOZ7/VPOB7)
BMC_ROMA10: R12385.2 U154.M21(ROMA10/GPOAA0/VPOG0)
BMC_ROMA11: R12388.2 U154.M22(ROMA11/GPOAA1/VPOG1)
BMC_ROMA12: R12392.2 U154.L18(ROMA12/GPOAA2/VPOG2)
BMC_ROMA13: R12394.2 U154.L19(ROMA13/GPOAA3/VPOG3)
BMC_ROMA14: R12396.2 U154.L20(ROMA14/GPOAA4/VPOG4)
BMC_ROMA15: R12399.2 U154.L21(ROMA15/GPOAA5/VPOG5)
BMC_ROMA16: R12402.2 U154.T18(ROMA16/GPOAA6/VPOG6)
BMC_ROMA17: R12409.2 U154.N18(ROMA17/GPOAA7/VPOG7)
BMC_ROMA18: R12382.2 U154.N19(ROMA18/GPIOAB0/VPOR0)
BMC_ROMA19: R12387.2 U154.M18(ROMA19/GPIOAB1/VPOR1)
BMC_ROMA20: R12390.2 U154.N22(ROMA20/GPIOAB2/VPOR2)
BMC_ROMA21: R12395.2 U154.N20(ROMA21/GPIOAB3/VPOR3)
BMC_ROMA22: R12398.2 U154.L22(ROMA22/GPIOS6/VPOR4)
BMC_ROMA23: R12384.2 U154.K18(ROMA23/GPIOS7/VPOR5)
BMC_ROMCS0_N: R12334.1 U154.R19(ROMCS0#)
BMC_ROMCS1_N: R12992.1 U154.V20(GPIOR0/ROMCS1#)
BMC_ROMD0: R12335.1 U154.T22(ROMD0)
BMC_ROMD1: R12336.1 U154.T21(ROMD1)
BMC_ROMD3: R12406.2 R13002.2 U154.U22(ROMD3)
BMC_ROMD4: R12407.2 R13003.2 U154.U21(ROMD4/GPIOS0/VPODE)
BMC_ROMD5: R12408.2 U154.T19(ROMD5/GPIOS1/VPOHS)
BMC_ROMD6: R12411.2 U154.V22(ROMD6/GPIOS2/VPOVS)
BMC_ROMD7: R12412.2 U154.U20(ROMD7/GPIOS3/VPOCLK)
BMC_SF1_SO: R12363.1 R12369.2 SK157.2 U157.2(SO/SIO1)
BMC_SF2_SO: R12987.2 SK158.2 U179.2(SO/SIO1)
BMC_SFLA_CS0_N: R12334.2 R12364.1 SK157.1 U157.1(CS#)
BMC_SFLA_CS1_N: R12990.1 R12992.2 SK158.1 U179.1(CS#)
BMC_SFLA_HOLD_N: R12900.1 R13003.1 SK157.7 SK158.7 U157.7(RESET#/SIO3) U179.7(RESET#/SIO3)
BMC_SFLA_MISO_D2: R12369.1 R12403.2 R12987.1 U154.T20(ROMD2)
BMC_SFLA_MOSI_D1: R12336.2 R12404.2 SK157.5 SK158.5 U157.5(SI/SIO0) U179.5(SI/SIO0)
BMC_SFLA_SCK: R12335.2 R12401.2 SK157.6 SK158.6 U157.6(SCLK) U179.6(SCLK)
BMC_SFLA_WP_N: R12362.1 R13002.1 SK157.3 SK158.3 U157.3(WP#/SIO2) U179.3(WP#/SIO2)
BMC_SIOS3_N: R12378.2 U154.C21(GPIOY0/SIOS3#)
BMC_SIOS5_N: R12377.2 U154.F20(GPIOY1/SIOS5#)
BMC_SIOSPWRREQ_N: R12379.2 U154.G20(GPIOY2/SIOPWREQ#)
BMC_SPI_CS1_N: R12361.2 U154.E18(GPIOB7/EXTRST#/SPICS1#)
BMC_UART_MUX_SEL: Q60.1(G) R12712.1 U154.C15(GPIOE1/NDCD3)
BMC_USB_MUX_SEL: R1405.2 U96.9(S) U154.AA1(GPIOM6/TXD2/VPIB8)
BUILD_ID0: R1740.2 R1741.2 U150.14(P11)
BUILD_ID1: R1742.2 R1743.2 U150.13(P10)
CAUI4_MAC_TO_PHY3_DN0: U1.C13(NIF_TX_07_N) U25.R11(SRD0N)
CAUI4_MAC_TO_PHY3_DN1: U1.A14(NIF_TX_06_N) U25.R13(SRD1N)
CAUI4_MAC_TO_PHY3_DN2: U1.C15(NIF_TX_05_N) U25.R15(SRD2N)
CAUI4_MAC_TO_PHY3_DN3: U1.A16(NIF_TX_04_N) U25.P17(SRD3N)
CAUI4_MAC_TO_PHY3_DN4: U1.C9(NIF_TX_03_N) U25.P1(SRD4N)
CAUI4_MAC_TO_PHY3_DN5: U1.A10(NIF_TX_02_N) U25.P3(SRD5N)
CAUI4_MAC_TO_PHY3_DN6: U1.C11(NIF_TX_01_N) U25.P5(SRD6N)
CAUI4_MAC_TO_PHY3_DN7: U1.A12(NIF_TX_00_N) U25.P7(SRD7N)
CAUI4_MAC_TO_PHY3_DP0: U1.D13(NIF_TX_07_P) U25.P11(SRD0P)
CAUI4_MAC_TO_PHY3_DP1: U1.B14(NIF_TX_06_P) U25.P13(SRD1P)
CAUI4_MAC_TO_PHY3_DP2: U1.D15(NIF_TX_05_P) U25.P15(SRD2P)
CAUI4_MAC_TO_PHY3_DP3: U1.B16(NIF_TX_04_P) U25.P18(SRD3P)
CAUI4_MAC_TO_PHY3_DP4: U1.D9(NIF_TX_03_P) U25.R1(SRD4P)
CAUI4_MAC_TO_PHY3_DP5: U1.B10(NIF_TX_02_P) U25.R3(SRD5P)
CAUI4_MAC_TO_PHY3_DP6: U1.D11(NIF_TX_01_P) U25.R5(SRD6P)
CAUI4_MAC_TO_PHY3_DP7: U1.B12(NIF_TX_00_P) U25.R7(SRD7P)
CAUI4_PHY3_TO_MAC_DN0: U1.K13(NIF_RX_07_N) U25.U12(STD0N)
CAUI4_PHY3_TO_MAC_DN1: U1.G14(NIF_RX_06_N) U25.U14(STD1N)
CAUI4_PHY3_TO_MAC_DN2: U1.K15(NIF_RX_05_N) U25.U16(STD2N)
CAUI4_PHY3_TO_MAC_DN3: U1.G16(NIF_RX_04_N) U25.T18(STD3N)
CAUI4_PHY3_TO_MAC_DN4: U1.K9(NIF_RX_03_N) U25.V2(STD4N)
CAUI4_PHY3_TO_MAC_DN5: U1.G10(NIF_RX_02_N) U25.V4(STD5N)
CAUI4_PHY3_TO_MAC_DN6: U1.K11(NIF_RX_01_N) U25.V6(STD6N)
CAUI4_PHY3_TO_MAC_DN7: U1.G12(NIF_RX_00_N) U25.V8(STD7N)
CAUI4_PHY3_TO_MAC_DP0: U1.J13(NIF_RX_07_P) U25.V12(STD0P)
CAUI4_PHY3_TO_MAC_DP1: U1.F14(NIF_RX_06_P) U25.V14(STD1P)
CAUI4_PHY3_TO_MAC_DP2: U1.J15(NIF_RX_05_P) U25.V16(STD2P)
CAUI4_PHY3_TO_MAC_DP3: U1.F16(NIF_RX_04_P) U25.U18(STD3P)
CAUI4_PHY3_TO_MAC_DP4: U1.J9(NIF_RX_03_P) U25.U2(STD4P)
CAUI4_PHY3_TO_MAC_DP5: U1.F10(NIF_RX_02_P) U25.U4(STD5P)
CAUI4_PHY3_TO_MAC_DP6: U1.J11(NIF_RX_01_P) U25.U6(STD6P)
CAUI4_PHY3_TO_MAC_DP7: U1.F12(NIF_RX_00_P) U25.U8(STD7P)
CAUI4_PHY3_TO_QSFP28_DN0: CJ12.U_37(U_TX1N) U25.A2(LTD4N)
CAUI4_PHY3_TO_QSFP28_DN1: CJ12.U_2(U_TX2N) U25.A4(LTD5N)
CAUI4_PHY3_TO_QSFP28_DN2: CJ12.U_34(U_TX3N) U25.A6(LTD6N)
CAUI4_PHY3_TO_QSFP28_DN3: CJ12.U_5(U_TX4N) U25.A8(LTD7N)
CAUI4_PHY3_TO_QSFP28_DN4: CJ12.L_37(L_TX1N) U25.B12(LTD0N)
CAUI4_PHY3_TO_QSFP28_DN5: CJ12.L_2(L_TX2N) U25.B14(LTD1N)
CAUI4_PHY3_TO_QSFP28_DN6: CJ12.L_34(L_TX3N) U25.B16(LTD2N)
CAUI4_PHY3_TO_QSFP28_DN7: CJ12.L_5(L_TX4N) U25.C18(LTD3N)
CAUI4_PHY3_TO_QSFP28_DP0: CJ12.U_36(U_TX1P) U25.B2(LTD4P)
CAUI4_PHY3_TO_QSFP28_DP1: CJ12.U_3(U_TX2P) U25.B4(LTD5P)
CAUI4_PHY3_TO_QSFP28_DP2: CJ12.U_33(U_TX3P) U25.B6(LTD6P)
CAUI4_PHY3_TO_QSFP28_DP3: CJ12.U_6(U_TX4P) U25.B8(LTD7P)
CAUI4_PHY3_TO_QSFP28_DP4: CJ12.L_36(L_TX1P) U25.A12(LTD0P)
CAUI4_PHY3_TO_QSFP28_DP5: CJ12.L_3(L_TX2P) U25.A14(LTD1P)
CAUI4_PHY3_TO_QSFP28_DP6: CJ12.L_33(L_TX3P) U25.A16(LTD2P)
CAUI4_PHY3_TO_QSFP28_DP7: CJ12.L_6(L_TX4P) U25.B18(LTD3P)
CAUI4_QSFP28_TO_PHY3_DN0: CJ12.U_18(U_RX1N) U25.E1(LRD4N)
CAUI4_QSFP28_TO_PHY3_DN1: CJ12.U_21(U_RX2N) U25.E3(LRD5N)
CAUI4_QSFP28_TO_PHY3_DN2: CJ12.U_15(U_RX3N) U25.E5(LRD6N)
CAUI4_QSFP28_TO_PHY3_DN3: CJ12.U_24(U_RX4N) U25.E7(LRD7N)
CAUI4_QSFP28_TO_PHY3_DN4: CJ12.L_18(L_RX1N) U25.D11(LRD0N)
CAUI4_QSFP28_TO_PHY3_DN5: CJ12.L_21(L_RX2N) U25.D13(LRD1N)
CAUI4_QSFP28_TO_PHY3_DN6: CJ12.L_15(L_RX3N) U25.D15(LRD2N)
CAUI4_QSFP28_TO_PHY3_DN7: CJ12.L_24(L_RX4N) U25.E17(LRD3N)
CAUI4_QSFP28_TO_PHY3_DP0: CJ12.U_17(U_RX1P) U25.D1(LRD4P)
CAUI4_QSFP28_TO_PHY3_DP1: CJ12.U_22(U_RX2P) U25.D3(LRD5P)
CAUI4_QSFP28_TO_PHY3_DP2: CJ12.U_14(U_RX3P) U25.D5(LRD6P)
CAUI4_QSFP28_TO_PHY3_DP3: CJ12.U_25(U_RX4P) U25.D7(LRD7P)
CAUI4_QSFP28_TO_PHY3_DP4: CJ12.L_17(L_RX1P) U25.E11(LRD0P)
CAUI4_QSFP28_TO_PHY3_DP5: CJ12.L_22(L_RX2P) U25.E13(LRD1P)
CAUI4_QSFP28_TO_PHY3_DP6: CJ12.L_14(L_RX3P) U25.E15(LRD2P)
CAUI4_QSFP28_TO_PHY3_DP7: CJ12.L_25(L_RX4P) U25.E18(LRD3P)
CLK_1M544_BITS_IN: R1618.1 U139.G10(IN11)
CLK_1M544_BITS_OSI: R12823.2 U127.75(OSCI)
CLK_1M544_BITS_RCVD: R1618.2 R13084.2 U127.70(REFA_OUT)
CLK_1M544_BITS_RCVD_TSCK: R13084.1 U127.56(TSCK / MTSCK)
CLK_1PPS_GNSS_EXTINT0: R1604.2 U124.4(EXTINT0)
CLK_1PPS_GNSS_IN: R1603.1 U139.E11(IN13)
CLK_1PPS_MAC_SYNC_IN0: R1444.1 R12925.1 U1.AA35(NSE_SYNC_IN0)
CLK_1PPS_MAC_SYNC_IN1: R1445.1 TP23.1 U1.AB35(NSE_SYNC_IN1)
CLK_1PPS_SMA1: D69.4(IO3) J15.1(RF) R1508.2
CLK_1PPS_SMA1_IN: R1508.1 U108.2(A)
CLK_1PPS_SMA2: D68.4(IO3) J12.1(RF) R1509.1
CLK_1PPS_SMA2_OUT: R1509.2 R1512.1
CLK_1PPS_SMA_BUF_IN: R1513.2 U108.4(Y)
CLK_1PPS_SMA_IN: R1513.1 R12915.2 R12917.1 U139.G12(IN7_POS)
CLK_1PPS_SMA_IN_DN: C2409.1 R12916.1 R12918.2 U139.G11(IN7_NEG)
CLK_1PPS_SMA_OUT: R1668.1 R1913.1
CLK_1PPS_SMA_OUT_AMP: R1512.2 R1514.1 U104.7
CLK_1PPS_SMA_OUT_FB: R1514.2 R1515.2 U104.6
CLK_1PPS_TOD_IN: R1589.2 R12920.2 R12922.1 U139.F12(IN8_POS)
CLK_1PPS_TOD_IN_DN: C2410.1 R12921.1 R12923.2 U139.F11(IN8_NEG)
CLK_1PPS_TOD_OUT: R1667.1 U121.5(D)
CLK_10M_GNSS_IN: R1610.2 U139.E10(IN14)
CLK_10M_SMA1: D67.4(IO3) J14.1(RF) R1500.2
CLK_10M_SMA1_IN: C2424.2 R1500.1
CLK_10M_SMA2: D65.4(IO3) J11.1(RF) R1499.1
CLK_10M_SMA2_REL_OUT: R1499.2 R1503.1
CLK_10M_SMA_BUF: R1904.2 U107.4(Y)
CLK_10M_SMA_BUF_IN: R1504.2 U105.4(Y)
CLK_10M_SMA_IN: R1504.1 U139.J10(IN9)
CLK_10M_SMA_OUT: R1671.1 R1901.1
CLK_10M_SMA_OUT_AMP: C2398.1 R1505.1 U104.1
CLK_10M_SMA_OUT_FB: R1505.2 R1903.1 U104.2
CLK_25M_5P49V_OUT0: R1076.2 R12789.2 U163.24(OUT0_SEL_I2CB)
CLK_25M_CPLD_CLK0: R995.1 U70.G5(CLK0_N)
CLK_25M_CPLD_OSC: R995.2 X1.3(OUT)
CLK_25M_MAC_CLOCK25: R1076.1 R1077.2 U1.AG36(CLOCK25)
CLK_25M_MAC_COREPLL_DN: C2339.1 R12454.2
CLK_25M_MAC_COREPLL_DP: C2338.1 R12453.2
CLK_25M_MAC_MCUPLL_DN: C2341.1 R12455.2
CLK_25M_MAC_MCUPLL_DP: C2340.1 R1888.2
CLK_25M_MAC_OSC: R1018.2 X5.3(OUT)
CLK_25M_MAC_OSC_DN1: C2400.2 R12792.2 R12794.1 U132.4(PCLK1_N)
CLK_25M_MAC_OSC_DP1: R1018.1 R12791.2 R12793.1 R12897.2 U132.3(PCLK1_P)
CLK_25M_MAC_TCXO: R12897.1 X8.4(RF OUTPUT)
CLK_25M_MAC_TSPLL_DN: C2344.1 R1889.2
CLK_25M_MAC_TSPLL_DP: C2345.1 R1890.2
CLK_25M_MAC_TSPLL_DPLL_DN: R1080.1 R1082.2 R12764.1 U132.7(PCLK0_N)
CLK_25M_MAC_TSPLL_DPLL_DP: R1079.1 R1081.2 R12763.1 U132.6(PCLK0_P)
CLK_25M_PCIE_OSC: R13081.1 X3.3(OUT)
CLK_25M_PCIE_XTALIN: C1690.2 U163.4(XIN/REF)
CLK_25M_SMU_OCXO: R1887.1 R12893.1 U139.E1(OSCI)
CLK_25M_SMU_OCXO_OUT0: R1887.2 X11.4(RF_OUTPUT)
CLK_25M_SMU_OCXO_OUT1: R12893.2 X14.4(OUTPUT)
CLK_25M_SMU_XTAL_IN0: C2393.2 R12805.1 U139.A12(XTAL1_IN) Y5.1
CLK_25M_SMU_XTAL_OUT0: C2394.2 R12805.2 U139.B12(XTAL1_OUT) Y5.3
CLK_25M_SRC_SEL: R1646.2 R12935.2 U132.2(SEL)
CLK_33M_LPC: J1.B66(PCIE0_TX12_P) R1761.1 U144.1(CLK_IN)
CLK_33M_LPC_BMC: R1831.2 U154.B20(LCLK)
CLK_33M_LPC_CPLD: R1829.2 U70.H5(IO_2_4)
CLK_48M_BMC_CLK: R12339.2 X13.3(OUT)
CLK_48M_BMC_CLKIN: R12339.1 U154.AB22(CLKIN)
CLK_50M_BMC_NCSI: R1819.2 U154.E11(RGMII1RXCK/RMII1RCLK/GPIOU4)
CLK_50M_NIC1_NCSI: R1817.2 U85.2(NC_SI_CLK_IN)
CLK_50M_OE: R1818.1 U143.2(OE)
CLK_50M_OUT0: R1819.1 U143.3(Y0)
CLK_50M_OUT1: R1817.1 U143.5(Y1)
CLK_50M_OUT2: R1816.1 U143.7(Y2)
CLK_50M_OUT3: R1863.1 U143.8(Y3)
CLK_100M_BMC_PCIE_DN: C2243.1 R12781.2 R12786.1
CLK_100M_BMC_PCIE_DP: C2242.1 R12782.2 R12785.1
CLK_100M_BMC_PCIE_REF_DN: C2243.2 U154.G21(PEREFCLKN)
CLK_100M_BMC_PCIE_REF_DP: C2242.2 U154.G22(PEREFCLKP)
CLK_100M_CPU_PCIE_DN: J1.A14(PCIE0_REFCLK_N) U163.2(CLKINB)
CLK_100M_CPU_PCIE_DP: J1.A13(PCIE0_REFCLK_P) U163.1(CLKIN)
CLK_100M_MAC_DDR_DN: C2384.1 R12753.1 R12754.2
CLK_100M_MAC_DDR_DP: C2383.1 R12752.1 R12755.2
CLK_100M_MAC_DDR_OSC_DN: R12773.2 R12775.1 U129.4(PCLK1_N) X7.5(O\U\T\)
CLK_100M_MAC_DDR_OSC_DP: R12774.2 R12776.1 U129.3(PCLK1_P) X7.4(OUT)
CLK_100M_MAC_DDRA_DN: C2347.1 R12448.2
CLK_100M_MAC_DDRA_DP: C2346.1 R12447.2
CLK_100M_MAC_DDRB_DN: C2236.1 R12450.2
CLK_100M_MAC_DDRB_DP: C2235.1 R12449.2
CLK_100M_MAC_DDRC_DN: C2238.1 R12451.2
CLK_100M_MAC_DDRC_DP: C2237.1 R12452.2
CLK_100M_MAC_PCIE_DN: C2342.1 R12779.2 R12788.1
CLK_100M_MAC_PCIE_DP: C2343.1 R12780.2 R12787.1
CLK_100M_NIC1_PCIE_DN: C2371.1 R12777.2 R12784.1
CLK_100M_NIC1_PCIE_DP: C2370.1 R12778.2 R12783.1
CLK_156M25_DPLL_REFCLK_DN: C2367.2 R12482.2 U135.11(I\N\2\)
CLK_156M25_DPLL_REFCLK_DP: C2366.2 R12482.1 U135.10(IN2)
CLK_156M25_MAC_NIF_LCPLL_DN: C2168.2 U1.M23(NIF_LCPLL_REFCLK_N)
CLK_156M25_MAC_NIF_LCPLL_DP: C2167.2 U1.M22(NIF_LCPLL_REFCLK_P)
CLK_156M25_MAC_NIFE_LCPLL0_DN: C2166.2 U1.U26(NIFE_LCPLL0_REFCLK_N)
CLK_156M25_MAC_NIFE_LCPLL0_DP: C2165.2 U1.U25(NIFE_LCPLL0_REFCLK_P)
CLK_156M25_MAC_NIFE_LCPLL1_DN: C2164.2 U1.U12(NIFE_LCPLL1_REFCLK_N)
CLK_156M25_MAC_NIFE_LCPLL1_DP: C2163.2 U1.U13(NIFE_LCPLL1_REFCLK_P)
CLK_156M25_OUT0_NIF_LCPLL_DN: R13073.1 U135.19(O\U\T\0\)
CLK_156M25_OUT0_NIF_LCPLL_DP: R13072.1 U135.20(OUT0)
CLK_156M25_OUT1_NIFE_LCPLL0_DN: R13075.1 U135.24(O\U\T\1\)
CLK_156M25_OUT1_NIFE_LCPLL0_DP: R13074.1 U135.25(OUT1)
CLK_156M25_OUT2_NIFE_LCPLL1_DN: R13077.1 U135.30(O\U\T\2\)
CLK_156M25_OUT2_NIFE_LCPLL1_DP: R13076.1 U135.31(OUT2)
CLK_156M25_OUT3_REF0_DN: R12750.2 U135.35(O\U\T\3\)
CLK_156M25_OUT3_REF0_DP: R12751.2 U135.36(OUT3)
CLK_156M25_PHY1_DN: C855.2 U23.J12(REFCKN)
CLK_156M25_PHY1_DP: C854.2 U23.K12(REFCKP)
CLK_156M25_PHY1_REFCLK_DN: C855.1 R1071.2
CLK_156M25_PHY1_REFCLK_DP: C854.1 R1070.2
CLK_156M25_PHY3_REFCLK_DN: C2204.1 R1073.2
CLK_156M25_PHY3_REFCLK_DP: C2205.1 R1072.2
CLK_156M25_PHY_REF0_DN: R12750.1 R12767.2 R12768.1 U133.7(PCLK0_N)
CLK_156M25_PHY_REF0_DP: R12751.1 R12765.2 R12766.1 U133.6(PCLK0_P)
CLK_156M25_PHY_REF1_DN: R1867.1 R12771.2 R12772.1 U133.4(PCLK1_N)
CLK_156M25_PHY_REF1_DP: R1866.1 R12769.2 R12770.1 U133.3(PCLK1_P)
CLK_156M25_PHY_SRC_SEL: R1649.2 R1650.2 U133.2(SEL)
CLK_156M25_PTP_REF_DN: C2367.1 R1673.1
CLK_156M25_PTP_REF_DP: C2366.1 R1672.1
CLK_DDR_SRC_SEL: R1643.2 R1645.2 U129.2(SEL)
CLK_LPC_OE: R1830.1 U144.2(OE)
CLK_LPC_OUT0: R1831.1 U144.3(Y0)
CLK_LPC_OUT1: R1829.1 U144.5(Y1)
CLK_LPC_OUT2: R1870.1 U144.7(Y2)
CLK_LPC_OUT3: R1869.1 U144.8(Y3)
CLK_MAC_SRD_REFCLK_OUT0: R6.1 U1.AM36(SRD_REFCLK_OUT_0)
CLK_MAC_SRD_REFCLK_OUT1: R1.1 U1.AK36(SRD_REFCLK_OUT_1)
