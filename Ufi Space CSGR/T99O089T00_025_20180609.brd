# Allegro board T99O089T00_025_20180609.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
(no net) on BOTTOM: 217.03,62.74 217.03,71.27 217.18,71.42 218.71,71.42 218.83,71.3 218.83,67.19 219.54,66.48 219.54,62.74 219.24,62.44 217.32,62.44
(no net) on BOTTOM: 306.09,153.49 306.97,152.61 306.97,144.02 306.71,143.76 302.81,143.76 302.64,143.93 302.64,153.34 302.77,153.47 302.79,153.49
(no net) on BOTTOM: 186.77,99.12 181.3,99.12 181.14,98.97 181.14,94.66 181.72,94.09 186.8,94.09 187.19,94.48 187.19,98.7
(no net) on BOTTOM: 187.58,77.05 216.91,77.05 217.42,77.55 217.42,83.35 217.01,83.75 205.65,83.75 205.25,84.15 205.25,87.28 206.72,88.75 208.24,88.75 208.49,89.01 208.49,92.39 208.06,92.83 187.25,92.83 186.58,92.16 186.58,78.05
(no net) on BOTTOM: 137.24,86.22 128.19,86.22 127.84,85.87 127.84,84.91 127.3,84.38 124.04,84.38 123.83,84.6 123.83,86.66 124.21,87.04 127.01,87.04 127.47,87.51 127.47,88.64 127.7,88.86 137.08,88.86 137.35,88.59 137.35,86.33
(no net) on BOTTOM: 64.43,200.45 67.25,200.45 69.22,202.42 69.22,209.29 68.92,209.59 66.45,209.59 66.32,209.46 66.32,205.08 64.3,203.06 64.3,200.57
(no net) on BOTTOM: 81.81,201.28 81.47,201.63 81.47,202.68 81.62,202.83 83.02,202.83 85.46,200.39 85.46,197.05 85.26,196.84 82.02,196.84 81.81,197.05
(no net) on BOTTOM: 77.56,206.64 77.56,203.98 77.99,203.55 80.52,203.55 80.95,203.99 80.95,206.56 80.62,206.9 77.82,206.9
(no net) on BOTTOM: 232.66,134.87 242.82,134.87 243.5,134.2 243.5,127.36 243.39,127.25 239.9,127.25 239.9,127.26 237.11,127.26 234.82,124.97 234.82,121.28 234.7,121.16 229.79,121.16 229.62,121.33 229.62,122.68 229.74,122.81 232.16,122.81 232.28,122.68 232.54,122.94 232.54,134.75
(no net) on BOTTOM: 28.83,181.94 32.79,185.89 32.79,188.18 33.38,188.78 37.21,188.78 37.72,188.27 37.72,182.68 35.81,180.77 35.81,173.31 35.42,172.92 29.69,172.92 28.83,173.77
(no net) on BOTTOM: 148.54,45.4 148.35,45.59 148.35,46.66 148.98,47.29 148.98,61.49 149.02,61.53 149.02,62.91 149.02,66.32 150.19,67.49 150.19,71.4 150.3,71.5 151.84,71.5 152.01,71.33 152.01,62.54 152.01,59.05 153.73,57.34 153.73,46.07 153.05,45.4
(no net) on BOTTOM: 145.74,116.98 143.28,116.98 142.9,117.37 142.9,118.39 143.06,118.56 145.57,118.56 145.78,118.35 145.78,117.03
(no net) on BOTTOM: 225.17,122.79 231.83,122.79 232.14,123.1 232.14,135.25 232.41,135.53 240.27,135.53 240.87,136.13 240.87,147.22 240.45,147.65 195.17,147.65 194.58,147.05 194.58,140.1 195.69,139 195.69,137.17 198.25,134.61 200.81,134.61 201.18,134.23 201.18,131.67 203.17,129.68 203.17,129.39 203.32,129.24 204.02,129.24 205.42,130.64 214.8,130.64 216.08,129.36 216.08,128.97 216.34,128.71 224.38,128.71 224.69,128.4 224.69,123.26
(no net) on BOTTOM: 71.16,133.71 69.06,133.71 68.96,133.81 68.96,136.23 69.48,136.75 70.97,136.75 71.22,136.49 71.22,133.77
(no net) on BOTTOM: 297.6,171.24 297.6,174.93 297.86,175.19 301.52,175.19 301.64,175.06 301.64,144.01 301.31,143.68 298.6,143.68 298.19,144.09 298.19,153.16 297.43,153.92 297.43,155.07 298.19,155.83 298.19,160.97 297.23,161.93 297.23,170.87
(no net) on BOTTOM: 275.03,106.45 268.37,106.45 268.22,106.3 268.22,104.49 268.4,104.3 273.63,104.3 274.7,103.24 274.7,102.52 275.17,102.05 278.54,102.05 278.82,102.32 278.82,103.64 278.47,103.98 277.52,103.98 277.27,104.24 277.27,105.5 276.88,105.88 275.6,105.88
(no net) on BOTTOM: 230.7,201.99 230.9,201.78 230.9,194.56 230.47,194.13 226.13,194.13 226.02,194.24 226.02,200.5 226.02,200.5 226.02,200.79 225.39,201.42 225.39,201.95 225.42,201.99
(no net) on BOTTOM: 34.72,86.44 36.5,86.44 36.71,86.65 36.71,88.02 36.53,88.2 34.82,88.2 34.56,87.93 34.56,86.6
(no net) on BOTTOM: 8.01,19.96 7.74,20.24 7.74,24.11 7.89,24.27 9.2,24.27 9.21,24.26 10.77,24.26 11.03,23.99 11.03,20.24 10.75,19.96
(no net) on BOTTOM: 55.32,48.2 55.14,48.02 55.14,45.91 55.44,45.6 57.2,45.6 57.35,45.76 57.35,48.17 57.31,48.2
(no net) on BOTTOM: 192.33,144.61 192.33,140.85 192.19,140.71 187.4,140.71 186.83,141.27 186.83,144.95 187.04,145.16 191.78,145.16
(no net) on BOTTOM: 165,62.1 165,71.01 165.15,71.16 166.69,71.16 166.8,71.05 166.8,66.93 167.51,66.22 167.51,63.39 169.05,61.85 171.31,61.85 176.96,56.19 176.96,47.72 176.07,46.82 172.73,46.82 172.4,47.15 172.4,55.43 170.95,56.89 170.21,56.89
(no net) on BOTTOM: 58,110.41 57.51,109.93 53.59,109.93 52.84,109.18 50.06,109.18 50.02,109.21 50.02,113.6 50.1,113.68 50.89,113.68 51.28,113.29 57.62,113.29 58,112.91
(no net) on BOTTOM: 177.16,44.95 176.82,45.28 176.82,46.95 177.61,47.73 177.61,56.19 173.17,60.62 173.17,66.06 174.35,67.24 174.35,71.15 174.45,71.25 175.99,71.25 176.17,71.07 176.17,62.38 182.23,56.32 182.23,45.99 181.19,44.95
(no net) on BOTTOM: 253.6,61.72 253.34,61.97 253.34,71.31 253.49,71.46 255.03,71.46 255.15,71.35 255.15,67.23 255.86,66.52 255.86,62.23 255.34,61.72
(no net) on BOTTOM: 166.78,195.95 165.27,197.46 165.27,204.37 163.9,205.75 151.66,205.75 151.49,205.92 151.49,208.22 152.11,208.84 166.73,208.84 173.3,202.28 175.61,202.28 177.3,200.59 177.3,197.07 176.19,195.95
(no net) on BOTTOM: 285.05,190.37 283.87,190.37 283.67,190.17 283.67,188.46 283.93,188.2 284.93,188.2 285.09,188.36 285.09,190.33
(no net) on BOTTOM: 266.69,139.65 266.57,139.53 266.57,118.36 266.88,118.05 269.97,118.05 270.07,118.14 270.07,139.52 269.94,139.65
(no net) on BOTTOM: 156.12,64.93 156.12,63.38 156.21,63.29 159.97,63.29 160.15,63.29 160.27,63.41 160.27,64.84 160.74,65.31 160.74,65.8 160.67,65.87 155.83,65.87 155.77,65.82 155.77,65.27
(no net) on BOTTOM: 80.62,202.75 80.73,202.64 80.73,194.4 78.99,192.66 75.95,192.66 75.69,192.91 75.69,201.42 75.67,201.44 75.67,201.53 75.31,201.89 75.31,202.72 75.34,202.75
(no net) on BOTTOM: 295.52,103.96 295.99,103.49 295.99,100.27 295.72,100 294.03,100 293.79,100.25 293.79,101.62 293.46,101.95 288.86,101.95 288.6,102.22 288.6,103.92 288.63,103.96
(no net) on BOTTOM: 193.6,132.2 193.56,132.17 191.51,132.17 191.33,132.35 191.33,134.15 191.51,134.33 193.51,134.33 193.6,134.25
(no net) on BOTTOM: 57.41,136.43 57.41,142.86 57.3,142.97 54.46,142.97 54.26,142.76 54.26,136.43 54.57,136.12 57.1,136.12
(no net) on BOTTOM: 92,66.88 92,72.97 92.19,73.16 96.4,73.16 96.57,73 96.57,66.93 96.47,66.84 92.04,66.84
(no net) on BOTTOM: 235.32,121.13 237.34,121.13 237.46,121.01 239.54,121.01 239.65,121.13 239.65,122.4 239.51,122.54 235.42,122.54 235.28,122.4 235.28,121.16
(no net) on BOTTOM: 91.52,45.4 91.32,45.59 91.32,46.66 91.72,47.05 91.72,61.25 92.79,62.32 96.57,62.32 96.86,62.61 96.86,66.08 98.02,67.24 98.02,71.15 98.12,71.25 99.66,71.25 99.84,71.07 99.84,56.73 96.7,53.59 96.7,46.07 96.03,45.4
(no net) on BOTTOM: 308.92,41.22 308.92,36.94 309.03,36.84 309.23,36.84 310.95,38.56 310.95,41.17 310.83,41.29 308.99,41.29
(no net) on BOTTOM: 106.39,117.6 106.26,117.47 106.26,116.05 106.48,115.83 108.32,115.83 108.55,116.05 108.55,117.57 108.52,117.6
(no net) on BOTTOM: 164.57,124.97 164.49,124.9 164.49,123.45 164.92,123.02 168.36,123.02 168.67,123.33 168.67,124.12 168.8,124.25 168.8,124.76 168.58,124.97
(no net) on BOTTOM: 140.81,105.49 140.81,102.39 140.93,102.27 143.5,102.27 143.82,102.58 143.82,105.36 143.49,105.69 141,105.69
(no net) on BOTTOM: 63.64,201.61 63.64,197.55 63.97,197.22 63.97,195.73 63.9,195.65 60.55,195.65 60.22,195.98 60.22,201.4 60.43,201.61
(no net) on BOTTOM: 78.73,184.08 83.81,184.08 83.93,183.95 83.93,181.79 83.31,181.17 81.76,181.17 81.18,180.59 81.18,175.2 80.63,174.65 78.34,174.65 78.22,174.78 78.22,183.57
(no net) on BOTTOM: 219.88,97.95 219.58,98.25 219.58,101.28 219.58,101.28 219.58,103.38 219.33,103.63 209.42,103.63 209.17,103.38 209.17,88.79 208.58,88.21 207.04,88.21 205.87,87.04 205.87,84.85 206.32,84.4 217.07,84.4 217.44,84.78 217.44,91.94 219.88,94.38
(no net) on BOTTOM: 33.79,99.34 33.94,99.19 33.94,96.59 33.67,96.32 26.18,96.32 25.91,96.59 25.91,99.15 26.1,99.34
(no net) on BOTTOM: 240.63,105.19 240.63,100.47 240.8,100.31 246.49,100.31 248.96,102.78 252.1,102.78 253.36,104.04 253.36,108.66 252.99,109.03 249.72,109.03 246.25,105.56 240.99,105.56
(no net) on BOTTOM: 277.94,105.26 277.78,105.41 277.78,107.13 278.08,107.43 283.2,107.43 283.28,107.36 283.28,105.37 283.17,105.26
(no net) on BOTTOM: 193.72,130.78 191.54,130.78 191.23,130.47 190.25,130.47 190.15,130.57 190.15,131.69 190.26,131.8 193.62,131.8 193.78,131.64 193.78,130.84
(no net) on BOTTOM: 193.8,103.82 195.83,103.82 196.09,104.07 196.09,104.88 196.57,104.88 197,105.31 197,106.5 196.51,106.99 193.8,106.99 193.55,106.74 193.55,104.07
(no net) on BOTTOM: 224.95,194.2 225.04,194.29 225.04,201.15 224.78,201.41 221.49,201.41 221.24,201.16 221.24,194.6 221.64,194.2
(no net) on BOTTOM: 213.79,200.78 213.45,201.12 213.45,202.17 213.6,202.32 215,202.32 216.24,201.09 216.24,195.95 216.11,195.81 213.98,195.81 213.79,196
(no net) on BOTTOM: 257.28,114.71 252.78,114.71 252.52,114.45 252.52,110.73 252.75,110.51 257.17,110.51 257.54,110.87 257.54,114.45
(no net) on BOTTOM: 151.27,186.92 151.27,189.75 151.71,190.2 157,190.2 157.34,190.54 158.72,190.54 158.95,190.77 158.95,192.83 159.49,193.37 159.49,204.27 159.74,204.52 163.91,204.52 164.37,204.06 164.37,187.34 163.6,186.57 157.23,186.57 151.62,186.57
(no net) on BOTTOM: 163.41,45.11 162.61,45.91 162.61,46.91 163.22,47.53 163.22,56.46 161.1,58.59 161.1,65.94 162.27,67.11 162.27,71.02 162.37,71.12 163.91,71.12 164.09,70.94 164.09,62.29 165.63,60.75 167.75,58.63 167.75,45.27 167.59,45.11
(no net) on BOTTOM: 213.07,170.77 213.22,170.91 213.22,171.75 213.62,172.14 220.56,172.14 220.77,172.35 220.77,173.62 220.64,173.76 199.06,173.76 198.83,173.53 198.83,170.87 198.93,170.77
(no net) on BOTTOM: 237.07,117.62 236.98,117.71 236.98,119.18 237.11,119.31 237.52,119.31 237.92,119.72 237.92,120.53 238.19,120.79 239.66,120.79 239.66,120.79 239.86,120.79 239.95,120.88 239.95,123.2 240.36,123.6 245.2,123.6 245.87,122.94 245.87,117.98 245.51,117.62
(no net) on BOTTOM: 193.34,108.17 193.34,107.38 193.46,107.26 195.4,107.26 195.43,107.29 195.43,108.94 195.26,109.1 193.81,109.1 193.67,108.96 193.67,108.5
(no net) on BOTTOM: 124.9,70.76 125.05,70.91 126.59,70.91 126.7,70.79 126.7,66.68 127.41,65.97 127.41,63.08 134.25,56.24 134.25,47.76 133.11,46.62 127.08,46.62 126.58,47.13 126.58,50.71 127.31,51.44 127.31,54.9 127.35,54.94 127.35,57.97 127.34,57.99 127.34,59.73 124.9,62.17
(no net) on BOTTOM: 163.18,138.85 164.8,138.85 165.39,138.25 166.57,138.25 166.76,138.44 166.76,139.64 166.35,140.04 163.14,140.04 163.05,139.95 163.05,138.97
(no net) on BOTTOM: 271.06,99.78 274.02,99.78 274.09,99.84 274.09,103.15 273.58,103.65 270.92,103.65 270.76,103.49 270.76,100.07
(no net) on BOTTOM: 262.3,147.43 262.08,147.66 260.2,147.66 259.97,147.88 259.97,148.16 259.86,148.27 257.26,148.27 256.92,147.94 256.92,144.56 257.13,144.35 261.68,144.35 262.3,144.98
(no net) on BOTTOM: 31.9,144.64 24.43,144.64 23.66,145.4 23.66,148.58 23.28,148.96 20.87,148.96 20.36,148.45 20.36,145.27 19.73,144.64 15.54,144.64 15.21,144.31 15.21,142.34 15.54,142.02 19.44,142.02 19.44,142.01 20.51,142.01 20.82,141.71 20.82,140.64 20.89,140.57 26.29,140.57 26.9,141.17 27.99,141.17 28.32,140.84 31.8,140.84 32.01,141.05 32.01,144.53
(no net) on BOTTOM: 103.94,64.93 103.94,63.38 104.04,63.29 107.8,63.29 107.8,63.29 107.98,63.29 108.1,63.41 108.1,64.84 108.56,65.31 108.56,65.8 108.49,65.87 103.66,65.87 103.6,65.82 103.6,65.27
(no net) on BOTTOM: 116.15,66.62 116.15,72.72 116.34,72.91 119.1,72.91 119.19,73 120.62,73 120.72,72.9 120.72,66.68 120.63,66.58 116.19,66.58
(no net) on BOTTOM: 236.47,110.61 236.47,104.81 237.36,103.92 238.65,103.92 238.91,104.18 238.91,110.58 238.79,110.7 236.57,110.7
(no net) on BOTTOM: 233.37,169.94 214.78,169.94 213.02,168.18 211.51,168.18 210.08,166.75 210.08,163.74 209.64,163.3 206.31,163.3 206.19,163.19 206.19,161.38 206.36,161.22 211.99,161.22 212.81,160.4 212.81,155.83 212.32,155.35 211.34,155.35 210.94,154.94 210.44,154.94 210.34,154.84 210.34,152.92 210.5,152.76 216.97,152.76 217.42,153.21 217.42,156.22 217.6,156.41 224.6,156.41 225.09,155.92 225.09,154.39 225.2,154.28 231.51,154.28 233.59,156.36 235.92,156.36 236.94,155.33 236.94,154.72 237.39,154.28 244.34,154.28 245,154.94 245,156.11 245.3,156.41 250.95,156.41 251.68,157.14 251.68,162.69 252.57,163.58 257.31,163.58 258.07,162.82 259.49,162.82 259.79,163.12 259.79,168.46 259.08,169.17 250.49,169.17 249.45,168.13 249.45,163.51 248.99,163.06 246.07,163.06 245.34,163.79 235.59,163.79 234.41,164.96 234.41,168.89
(no net) on BOTTOM: 295.74,76.13 295.52,76.36 295.52,82.64 295.96,83.08 303.31,83.08 303.66,83.43 303.66,84.59 303.83,84.76 305.05,84.76 305.18,84.63 305.18,82.73 303.78,81.33 299.44,81.33 299.32,81.2 299.32,76.3 299.15,76.13
(no net) on BOTTOM: 225.2,65.94 226.38,67.11 226.38,71.02 226.48,71.12 228.02,71.12 228.2,70.94 228.2,61.68 227.87,61.35 225.4,61.35 225.2,61.55
(no net) on BOTTOM: 192.12,113.94 194.56,113.94 195.42,114.8 195.42,115.32 195.27,115.47 193.89,115.47 193.16,114.74 192.19,114.74 192.06,114.61 192.06,114
(no net) on BOTTOM: 279.9,82.51 279.9,80.18 280.03,80.05 281.63,80.05 281.87,80.3 281.87,82.41 281.64,82.64 280.02,82.64
(no net) on BOTTOM: 192.32,109.57 192.11,109.78 192.11,110.61 192.16,110.66 195.59,110.66 195.75,110.66 195.88,110.52 195.88,110.09 195.36,109.57
(no net) on BOTTOM: 107.63,118.24 112.25,118.24 112.46,118.45 112.46,120.81 112.2,121.07 107.89,121.07 107.6,120.77 107.6,118.28
(no net) on BOTTOM: 261.52,61.69 261.52,65.98 262.69,67.16 262.69,71.06 262.8,71.17 264.34,71.17 264.51,70.99 264.51,63.53 264.51,63.02 264.51,61.98 264.03,61.5 261.7,61.5
(no net) on BOTTOM: 206.85,194.45 206.94,194.54 206.94,202.17 206.76,202.35 204.33,202.35 204.12,202.14 204.12,194.7 204.37,194.45
(no net) on BOTTOM: 136.82,108.24 136.99,108.41 136.99,109.83 136.65,110.17 130.95,110.17 130.73,109.95 130.73,108.36 130.85,108.24
(no net) on BOTTOM: 274.66,94.79 274.5,94.95 260.99,94.95 259.37,93.33 259.37,89.6 259.46,89.51 274.39,89.51 274.66,89.78
(no net) on BOTTOM: 106.38,45.11 105.58,45.91 105.58,46.91 106.2,47.53 106.2,60.5 108.92,63.22 108.92,66.06 110.1,67.24 110.1,71.15 110.2,71.25 111.74,71.25 111.92,71.07 111.92,46.46 110.56,45.11
(no net) on BOTTOM: 127.25,54.34 126.66,53.74 125.34,52.42 125.34,46.15 124.14,44.95 120.13,44.95 119.8,45.28 119.8,46.95 120.32,47.47 120.32,51.99 121,52.68 121,61.6 121,65.81 122.17,66.99 122.17,70.89 122.28,71 123.82,71 123.99,70.82 123.99,62.63 127.25,59.37 ; 1 cut-out
(no net) on BOTTOM: 193.03,113.27 189.56,113.27 189.41,113.11 189.41,111.54 189.6,111.34 193,111.34 193.06,111.4 193.06,113.24
(no net) on BOTTOM: 15.21,138.65 12.71,138.65 12.53,138.47 12.53,137.25 12.71,137.07 15.04,137.07 15.24,137.27 15.24,138.62
(no net) on BOTTOM: 262.36,148.51 262.05,148.2 260.54,148.2 260.3,148.44 260.3,149.5 260.22,149.58 260.22,150.75 260.44,150.96 262.07,150.96 262.36,150.68
(no net) on BOTTOM: 9.28,103.43 9.24,103.39 9.24,100.35 9.8,99.78 16.35,99.78 16.51,99.94 16.51,101.96 16.42,102.05 12.8,102.05 11.43,103.43
(no net) on BOTTOM: 237.12,115.79 240.45,115.79 240.63,115.98 240.63,117 240.42,117.21 237.29,117.21 237.09,117.01 237.09,115.82
(no net) on BOTTOM: 267.28,95.26 274.51,95.26 274.68,95.44 274.68,98.06 274.22,98.52 272.98,98.52 272.72,98.25 272.72,97.14 272.16,96.59 267.34,96.59 267.19,96.44 267.19,95.35
(no net) on BOTTOM: 55.32,37.51 48.78,37.51 48.58,37.31 48.58,34.4 48.85,34.13 55.19,34.13 55.45,34.38 55.45,37.38
(no net) on BOTTOM: 51.72,168.57 54.14,168.57 54.34,168.77 54.34,170.07 54.15,170.26 51.76,170.26 51.6,170.1 51.6,168.7
(no net) on BOTTOM: 204.9,63.47 204.9,71.02 205.05,71.17 206.59,71.17 206.7,71.06 206.7,66.94 207.41,66.23 207.41,63.34 207.36,63.29 205.08,63.29
(no net) on BOTTOM: 286.1,110.19 293.64,110.19 293.84,110.39 293.84,112.26 293.7,112.39 286.12,112.39 285.91,112.18 285.91,110.39
(no net) on BOTTOM: 142.13,86.3 138.55,86.3 138.45,86.4 138.45,89.21 138.59,89.35 142.11,89.35 142.3,89.15 142.3,86.47
(no net) on BOTTOM: 192.14,201.34 192.14,194.05 192.32,193.87 195.12,193.87 195.63,194.38 195.63,195.98 195.33,196.27 195.33,201.15 195.07,201.42 192.21,201.42
(no net) on BOTTOM: 191.05,128.24 189.01,128.24 188.87,128.37 188.87,129.78 189.06,129.97 190.97,129.97 191.11,129.83 191.11,128.29
(no net) on BOTTOM: 19.87,174.01 8.33,174.01 7.97,174.36 7.97,178.14 8.09,178.26 11.08,178.26 11.33,178.01 15.64,178.01 15.77,178.14 15.77,180.66 16.22,181.11 16.22,191.18 16.64,191.61 19.17,191.61 19.37,191.42 19.37,184.46 20.69,183.13 20.69,174.84
(no net) on BOTTOM: 195.23,130.12 192.8,130.12 192.76,130.08 192.76,127.95 192.91,127.8 195.05,127.8 195.31,128.06 195.31,130.03
(no net) on BOTTOM: 61.08,188.22 59.38,188.22 59.18,188.02 59.18,186.11 59.35,185.95 61.76,185.95 63.49,187.67 64.63,187.67 64.99,188.03 64.99,189.12 64.63,189.47 64.63,192.58 64.58,192.63 63.85,192.63 63.59,192.37 61.84,192.37 61.84,188.98
(no net) on BOTTOM: 31.91,145.17 32.01,145.27 32.01,148.18 31.74,148.45 29.21,148.45 28.03,147.26 26.74,147.26 26.56,147.09 26.56,145.34 26.73,145.17
(no net) on BOTTOM: 15.92,137.96 15.74,138.14 15.74,139.03 15.5,139.27 12.83,139.27 12.61,139.48 12.61,147.88 13.18,148.45 19.73,148.45 19.85,148.32 19.85,145.5 19.71,145.35 15.43,145.35 14.75,144.67 14.75,141.98 15.68,141.05 17.59,141.05 17.66,140.98 17.66,137.99 17.63,137.96
(no net) on BOTTOM: 231.3,119.52 231.09,119.73 231.09,120.71 231.24,120.85 233.5,120.85 233.9,120.46 236.2,120.46 236.28,120.38 236.28,119.65 236.16,119.52
(no net) on BOTTOM: 283.33,190.37 282.34,190.37 282.15,190.55 281.57,190.55 281.38,190.36 281.38,189.35 281.52,189.22 283.17,189.22 283.35,189.4 283.35,190.35
(no net) on BOTTOM: 131.83,195.14 143.87,195.14 144.09,195.37 144.09,208.17 143.46,208.8 108.53,208.8 105.12,205.39 105.12,197.41 105.68,196.85 112.26,196.85 116.46,201.05 130.36,201.05 131.4,200.01 131.4,195.57
(no net) on BOTTOM: 132.92,119.66 133.02,119.77 134.2,119.77 134.29,119.67 134.29,117.86 134.27,117.84 133.02,117.84 132.92,117.94
(no net) on BOTTOM: 271.76,107.54 264.52,107.54 264.14,107.92 264.14,111.22 264.35,111.44 271.6,111.44 271.92,111.11 271.92,107.7
(no net) on BOTTOM: 213.12,66.32 214.3,67.49 214.3,71.4 214.4,71.5 215.94,71.5 216.12,71.33 216.12,63.51 215.92,63.31 213.12,63.31
(no net) on BOTTOM: 240.63,114.54 240.28,114.19 240.28,110.43 241.02,109.69 249.71,109.69 250.21,110.19 250.21,113.94 249.6,114.54
(no net) on BOTTOM: 8.49,100.38 8.49,103.37 8.44,103.41 6.77,103.41 6.61,103.25 6.61,102.28 6.39,102.05 4.35,102.05 4.17,101.87 4.17,100.43 4.39,100.21 8.32,100.21
(no net) on BOTTOM: 227.85,96.68 227.85,93.45 229.05,92.25 229.05,90.9 229.46,90.5 232.7,90.5 233.81,89.38 233.81,83.77 234.35,83.23 242.23,83.23 242.94,83.94 242.94,86.54 242.53,86.95 241.22,86.95 239.01,89.16 239.01,91.73 238.04,92.71 234.77,92.71 230.73,96.75 227.93,96.75
(no net) on BOTTOM: 237.67,204.31 237.67,197.21 237.98,196.91 241,196.91 241.13,197.05 241.13,204.28 240.85,204.56 237.93,204.56
(no net) on BOTTOM: 144.18,104.13 144.18,102.03 144.3,101.9 147.59,101.9 147.92,102.23 147.92,104.26 147.74,104.44 144.49,104.44
(no net) on BOTTOM: 286.54,104.75 286.26,105.03 286.26,106.55 286.64,106.93 291.59,106.93 291.85,106.68 291.85,104.9 291.69,104.75
(no net) on BOTTOM: 199.01,101.78 199.01,95.69 199.26,95.43 208.53,95.43 208.91,95.81 208.91,101.4 208.53,101.78
(no net) on BOTTOM: 8.61,26.67 8.63,26.65 10.76,26.65 10.93,26.82 10.93,27.81 10.71,28.03 9.97,28.03 9.73,28.27 9.73,28.9 9.56,29.07 8.65,29.07 8.61,29.03
(no net) on BOTTOM: 169.84,165.71 180.72,165.71 183.13,168.12 183.13,185.88 180.38,188.63 168.34,188.63 167.67,187.96 167.67,185.73 168.21,185.19 176.66,185.19 177.5,184.35 177.5,173.04 177.49,173.03 177.49,170.71 176.33,169.54 174.62,169.54 174.62,169.55 169.29,169.55 169.08,169.34 169.08,166.47
(no net) on BOTTOM: 33.89,99.97 33.97,100.05 33.97,103.31 33.74,103.54 31.42,103.54 31.37,103.49 31.37,101.76 30.89,101.28 30.89,99.99 30.91,99.97
(no net) on BOTTOM: 73.44,140.32 73.44,148.26 73.11,148.58 69.86,148.58 69.58,148.3 69.58,142.99 70.79,141.78 70.79,140.64 71.29,140.14 73.26,140.14
(no net) on BOTTOM: 134.94,121.11 135.04,121.22 135.73,121.22 135.88,121.06 137.3,121.06 137.34,121.02 137.34,120.17 137.57,119.94 138.24,119.94 138.54,119.65 138.54,118.75 138.31,118.53 135.19,118.53 134.94,118.78
(no net) on BOTTOM: 187.13,194.51 187.28,194.36 188.75,194.36 188.85,194.46 188.85,197.68 188.67,197.86 187.37,197.86 187.13,197.62
(no net) on BOTTOM: 226.5,100.23 226.5,98.7 226.62,98.58 228.63,98.58 228.75,98.69 228.75,100.17 228.65,100.26 226.53,100.26
(no net) on BOTTOM: 55.51,49.82 55.29,50.04 55.29,61.71 55.57,61.98 57.01,61.98 57.19,61.8 57.19,51.29 57.32,51.16 57.32,49.87 57.28,49.82
(no net) on BOTTOM: 58.84,108.26 57.71,108.26 57.47,108.03 57.47,106.05 57.57,105.95 60.51,105.95 60.68,106.11 60.68,108.16 60.56,108.28 58.86,108.28
(no net) on BOTTOM: 190.09,127.57 192.52,127.57 192.69,127.4 192.69,125.17 192.39,124.87 190.33,124.87 190.01,125.2 190.01,127.49
(no net) on BOTTOM: 11.84,44.53 9.17,44.53 8.97,44.33 8.97,43.03 9.05,42.95 11.98,42.95 12.04,43.01 12.04,44.33
(no net) on BOTTOM: 307.85,144.81 307.85,173.84 305.53,176.16 295.78,176.16 295.34,176.59 295.34,183.43 295.67,183.76 310.44,183.76 311.12,183.07 311.12,144.75 310.81,144.43 308.22,144.43
(no net) on BOTTOM: 228.05,173.72 248.77,173.72 249.45,173.05 249.45,171.01 249.19,170.75 228.15,170.75 227.98,170.92 227.98,173.66
(no net) on BOTTOM: 175.41,184.17 164.85,184.17 164.33,183.65 164.33,172.5 166.25,170.58 172.32,170.58 173.65,171.91 176.41,171.91 176.77,172.27 176.77,183.97 176.57,184.17 175.42,184.17
(no net) on BOTTOM: 144.04,64.93 144.04,63.38 144.14,63.29 147.9,63.29 147.9,63.29 148.08,63.29 148.2,63.41 148.2,64.84 148.66,65.31 148.66,65.8 148.59,65.87 143.75,65.87 143.7,65.82 143.7,65.27
(no net) on BOTTOM: 158.53,204.25 158.53,191.22 158.45,191.14 155.18,191.14 154.15,192.17 154.15,196.04 153.87,196.32 151.93,196.32 151.49,196.77 151.49,204.19 151.8,204.49 158.28,204.49
(no net) on BOTTOM: 285.94,104.48 286.01,104.41 286.01,103.89 286.54,103.37 287.77,103.37 288.04,103.09 288.04,102.07 287.78,101.81 284.4,101.81 284.03,102.17 279.7,102.17 279.54,102.34 279.54,104.31 279.71,104.48
(no net) on G02: 1.22,0.51 1,0.51 0.65,0.65 0.51,1 0.51,208.52 0.51,208.98 0.65,209.33 1,209.47 1.46,209.47 38.51,209.47 39.55,209.91 39.99,210.95 39.99,214.79 39.99,214.83 40.14,215.18 40.48,215.32 312.48,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,5.09 312.99,4.97 312.85,4.62 312.5,4.48 288.55,4.48 288.55,4.11 83.44,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,5.1 82.42,10.48 81.97,11.52 80.94,11.96 63.41,11.96 62.64,11.73 62.1,11.14 43.51,11.14 42.47,10.7 42.03,9.66 42.03,1.27 42.03,1 41.89,0.65 41.54,0.51 ; 3 cut-outs
(no net) on T03: 200.79,148.39 233.04,148.39 245.7,135.74 245.7,117.43 247.82,115.31 269.77,115.31 270.59,116.13 270.59,158.97 267.75,161.8 267.75,165.75 267.74,165.76 267.74,189.1 265.05,191.8 242.46,191.8 241.82,192.43 241.82,201.99 239.48,204.33 234.69,204.33 233.05,202.69 216.16,202.69 197.46,184 197.46,151.72 ; 2 cut-outs
(no net) on T03: 105.57,141.92 105.57,148.9 104.11,150.36 84.24,150.36 84.07,150.19 84.07,148.91 84.21,148.77 85.52,148.77 86.29,148 86.29,142.97 89.94,139.32 96.15,139.32 98.29,141.46 105.12,141.46
(no net) on T03: 120.24,99.5 139.11,99.5 139.29,99.57 139.36,99.75 139.98,100.37 139.98,102.68 137.66,105 120.32,105 120.07,104.74 120.07,99.67
(no net) on T03: 90.42,92.01 90.42,85.65 91.87,84.2 99.21,84.2 99.44,84.43 99.44,88.21 99.24,88.42 96.99,88.42 96.9,88.32 93.34,88.32 92.2,89.47 92.2,92.01 91.95,92.26 90.68,92.26
(no net) on T03: 204.98,111.19 204.98,114.45 204.56,114.86 195.81,114.86 189.36,108.42 189.36,94.67 189.86,94.16 205.55,94.16 205.56,94.16 207.21,94.16 207.83,94.78 207.83,108.16 206.7,109.29 206.7,110.55 206.29,110.96 205.21,110.96
(no net) on T03: 15.33,96.96 15.1,97.19 15.1,101.58 15.52,102 23.25,102 23.71,101.55 23.71,97.12 23.55,96.96
(no net) on T03: 213.61,122.48 213.61,122.52 205.96,122.52 205.27,123.21 205.27,128.91 205.47,129.11 212.12,129.11 213.03,130.02 216.99,130.02 218.23,131.27 218.23,139.8 214.78,143.25 192.77,143.25 190.6,145.42 190.6,156.62 187.39,159.83 187.39,163.06 183.51,166.93 183.51,182.71 183.77,182.97 195.89,182.97 196.66,182.2 196.66,151.65 200.48,147.82 221.67,147.82 224.45,145.04 224.45,124.4 222.54,122.48 ; 1 cut-out
(no net) on T03: 222.65,111.45 222.64,111.44 207.93,111.44 207.92,111.44 207.54,111.44 207.27,111.16 207.27,109.21 208.38,108.11 208.38,94.69 208.85,94.22 232.8,94.22 233.53,94.95 233.53,111.1 233.18,111.45
(no net) on T03: 205.41,111.25 206.09,111.25 206.74,111.91 232.05,111.91 233.46,113.32 239.36,113.32 239.72,113.68 239.72,120.39 239.45,120.66 237.5,120.66 235.93,122.23 204.82,122.23 204.57,121.98 204.57,120.42 205.27,119.72 205.27,111.39
(no net) on T03: 21.8,199.69 21.8,195.77 22.59,194.97 45.78,194.97 57.5,206.68 62.45,206.68 63.6,207.84 63.6,210.04 63.51,210.13 54.65,210.13 48.35,203.83 39.87,203.83 35.88,199.85 21.95,199.85
(no net) on G04: 1.16,0.51 1,0.51 0.65,0.65 0.51,1 0.51,208.75 0.51,208.98 0.65,209.33 1,209.47 38.51,209.47 39.55,209.91 39.99,210.95 39.99,214.58 39.99,214.83 40.14,215.18 40.48,215.32 311.95,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,214.28 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,5.36 312.99,4.97 312.85,4.62 312.5,4.48 288.55,4.48 288.55,4.11 83.45,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,5.15 82.42,10.48 81.97,11.52 80.94,11.96 63.41,11.96 62.64,11.73 62.1,11.14 43.51,11.14 42.47,10.7 42.03,9.66 42.03,1.42 42.03,1 41.89,0.65 41.54,0.51 41.11,0.51 ; 21 cut-outs
(no net) on T05: 164.9,86.64 164.54,86.28 154.27,86.28 154.04,86.51 154.04,88.36 154.38,88.7 161.82,88.7 162.15,89.03 162.15,95.35 161.36,96.14 161.36,97.25 161.62,97.5 163.34,97.5 164.9,95.94
(no net) on T05: 189.25,130.83 191.56,130.83 193.14,132.4 193.14,140.27 190.34,143.06 180.61,143.06 178.91,141.36 178.91,139.22 184.49,133.64 186.44,133.64
(no net) on T05: 84.38,170.62 94.54,180.78 94.54,184.77 93.89,185.43 88.76,185.43 78.44,175.1 78.44,171.13 78.95,170.62
(no net) on T05: 124.54,185.73 124.54,183.85 125.34,183.06 131.96,183.06 134.75,185.85 134.75,187.37 137.12,189.74 145.78,189.74 151.58,183.93 165.67,183.93 168.06,186.33 180.02,186.33 182.18,184.16 220.17,184.16 222.57,181.77 222.57,171.55 222.8,171.32 225,171.32 225.57,171.9 225.57,182.95 227.37,184.75 227.37,187.03 226.3,188.11 166.83,188.11 164.65,185.92 153.15,185.92 145.26,193.82 135.38,193.82 131.07,189.51 131.07,188.45 128.58,185.97 124.78,185.97
(no net) on T05: 72.43,54.41 79.94,54.41 81.03,55.5 81.03,60.25 74,67.28 56.19,67.28 55.02,68.45 50.81,68.45 50.71,68.34 50.71,65.3 51.11,64.89 67.86,64.89 71.99,60.76 71.99,54.85
(no net) on T05: 144.35,124.53 144.08,124.8 137.91,124.8 137.63,124.52 137.63,118.55 138.35,117.83 144.16,117.83 144.35,118.03
(no net) on T05: 224.03,121.41 224.66,122.05 224.66,127.25 223.01,128.91 204.22,128.91 203.96,128.65 203.96,122.05 204.6,121.41
(no net) on T05: 126.95,95.43 126.95,91.19 127.19,90.96 136.81,90.96 145.52,99.68 145.52,102.74 145,103.27 142.43,103.27 135.07,95.9 127.43,95.9
(no net) on T05: 109.48,209.24 123.77,209.24 131.52,201.5 131.52,196.83 130.79,196.1 126.66,196.1 126.36,196.4 126.36,196.94 126.39,196.96 126.39,199.81 125.02,201.18 116.76,201.18 114.26,198.68 114.26,191.92 113.59,191.25 103.4,191.25 102.69,190.54 102.69,181.19 102.06,180.56 98.07,180.56 97.79,180.85 97.79,186.82 96.02,188.59 96.02,196.5 104.43,204.91 104.43,211.2 104.59,211.36 107.36,211.36
(no net) on T05: 184.06,160.51 170.71,160.51 156.29,146.08 156.29,137.98 162.61,131.65 169.36,131.65 169.54,131.84 169.54,145.89 174.63,150.98 183.49,150.98 184.25,151.74 184.25,154.32 185.31,155.38 185.31,159.25
(no net) on T05: 67.65,118.04 60,118.04 58.92,116.96 58.92,112.96 58.25,112.29 58.25,108.3 58.73,107.83 66.62,107.83 68.52,109.73 68.52,117.17
(no net) on T05: 280.47,102.78 280.78,103.09 287.08,103.09 287.09,103.08 287.88,103.08 288.17,102.79 288.17,88.7 287.42,87.95 281.04,87.95 280.47,88.51
(no net) on T05: 224.53,118.65 224.53,99.9 224.66,99.78 236.46,99.78 236.67,99.98 236.67,115.74 233.61,118.8 224.68,118.8
(no net) on T05: 260.11,199.45 278.44,199.45 283.84,194.05 287.62,194.05 288.67,193 288.67,181.99 287.78,181.1 265.38,181.1 263.49,183 263.49,186.76 261.43,188.81 259.88,188.81 259.47,189.22 259.47,198.81
(no net) on T05: 208.39,107.87 208.39,104.08 208.23,103.93 194.89,103.93 194.67,104.15 194.67,107.68 195.05,108.06 208.2,108.06
(no net) on G06: 1.32,0.51 1,0.51 0.65,0.65 0.51,1 0.51,208.74 0.51,208.98 0.65,209.33 1,209.47 38.51,209.47 39.55,209.91 39.99,210.95 39.99,214.55 39.99,214.83 40.14,215.18 40.48,215.32 311.93,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,214.26 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,5.97 312.99,4.97 312.85,4.62 312.5,4.48 311.38,4.48 288.55,4.48 288.55,4.11 83.76,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,5.45 82.42,10.48 81.97,11.52 80.94,11.96 63.41,11.96 62.64,11.73 62.1,11.14 43.51,11.14 42.47,10.7 42.03,9.66 42.03,1.6 42.03,1 41.89,0.65 41.54,0.51 40.94,0.51 40.93,0.51 ; 21 cut-outs
(no net) on T07: 155.36,135.95 161.8,135.95 162.69,135.06 162.69,125.92 161.8,125.03 158.87,125.03 158.58,125.32 158.58,127.65 159.51,128.58 159.51,132.14 157.86,133.79 155.39,133.79 155.13,134.04 155.13,135.72
(no net) on T07: 58.03,106.98 55.03,106.98 54.15,106.1 52.24,106.1 51.88,105.75 51.88,103.45 52.07,103.26 57.93,103.26 58.25,103.58 58.25,106.76
(no net) on T07: 201.37,123.85 195.7,123.85 195.45,123.6 195.45,121.88 195.85,121.48 201.1,121.48 201.53,121.92 201.53,123.69
(no net) on T07: 287.49,89.88 274.38,89.88 274.08,90.18 274.08,104.11 274.52,104.56 287.34,104.56 287.68,104.22 287.68,90.07
(no net) on T07: 281.56,143.82 295.4,143.82 297.05,142.17 297.05,132.26 295.91,131.12 282.32,131.12 280.67,132.77 280.67,142.93
(no net) on T07: 129.9,106.32 126.93,106.32 126.66,106.05 126.66,102.37 126.96,102.08 129.9,102.08 130.09,102.27 130.09,106.13
(no net) on T07: 265.71,115.68 265.29,116.1 265.29,132.13 264.68,132.74 257.08,132.74 255.38,134.44 255.38,148.47 249.21,154.64 249.21,165.13 242.43,171.92 198.81,171.92 197.5,173.23 197.5,177.69 198.43,178.62 244.45,178.62 251.58,171.49 254.37,171.49 260.6,165.26 260.6,156.87 261.7,155.77 261.7,152.35 263.04,151.01 264.17,151.01 264.4,150.78 264.4,146.44 269.44,141.41 269.44,116.2 268.91,115.68
(no net) on T07: 91.22,96.07 90.17,95.02 90.17,88.39 90.71,87.85 101.28,87.85 101.88,88.44 101.88,95.66 101.47,96.07
(no net) on T07: 121.53,182.51 109.43,194.61 108.13,194.61 107.93,194.8 107.93,200.96 108.8,201.82 119.57,201.82 120.19,201.2 120.19,197.35 120.73,196.81 127.18,196.81 127.31,196.68 127.31,192.23 126.85,191.76 123.76,191.76 123.31,191.31 123.31,190.16 124.95,188.52 124.95,182.76 124.7,182.51
(no net) on T07: 55.62,191.1 52.17,191.1 51.14,192.13 35.68,192.13 34.6,193.22 34.6,196.72 34.93,197.05 35.89,197.05 41.61,202.78 52.42,202.78 53.7,204.07 58.63,204.07 60.16,202.53 60.16,195.64
(no net) on T07: 271.95,114.78 271.95,117.47 272.59,118.11 294.64,118.11 296.55,116.2 296.55,108.58 294.64,106.68 273.27,106.68 272.46,105.88 272.46,93.72 261,82.26 251.93,82.26 251.66,82.53 251.66,87.89 252.22,88.45 256.66,88.45 263.97,95.77 263.97,111.14 264.28,111.45 268.62,111.45
(no net) on G08: 1.25,0.51 1,0.51 0.65,0.65 0.51,1 0.51,208.54 0.51,208.98 0.65,209.33 1,209.47 1.44,209.47 38.51,209.47 39.55,209.91 39.99,210.95 39.99,214.64 39.99,214.83 40.14,215.18 40.48,215.32 311.93,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,214.26 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,5.54 312.99,4.97 312.85,4.62 312.5,4.48 311.93,4.48 288.55,4.48 288.55,4.11 83.51,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,5.2 82.42,10.48 81.97,11.52 80.94,11.96 63.41,11.96 62.64,11.73 62.1,11.14 43.51,11.14 42.47,10.7 42.03,9.66 42.03,1.86 42.03,1 41.89,0.65 41.54,0.51 40.3,0.51 ; 21 cut-outs
(no net) on P09: 289,94.85 285.96,94.85 285.6,94.49 285.6,92.61 284.54,91.55 284.54,87.96 284.94,87.55 289.37,87.55 289.67,87.85 289.67,94.19
(no net) on P09: 130.9,197.15 111.13,197.15 108.56,194.57 108.56,189.78 109.49,188.84 120.78,188.84 125.09,184.54 133.19,184.54 134.08,185.42 134.08,188.67 133.56,189.19 130.11,189.19 129.44,189.87 129.44,195.51 130.07,196.14 130.96,196.14 131.02,196.2 131.02,197.03
(no net) on P09: 185.67,93.85 184.66,94.87 184.66,111.27 188.77,115.38 188.77,124.21 188.78,124.23 188.78,159.66 186.2,162.25 186.2,169.67 198.58,182.05 249.36,182.05 253.7,171.3 258.04,182.05 265.95,182.05 267.3,180.7 270.45,180.7 271.8,182.05 288.93,182.05 289.81,181.16 289.81,93.85 255.35,93.85 251.87,97.94 248.4,93.85 ; 1 cut-out
(no net) on P09: 1.22,0.89 0.71,1.4 0.71,96.06 0.51,96.06 0.51,209.47 39.12,209.47 39.12,208.81 39.34,208.59 44,208.59 45.13,209.71 45.13,214.78 45.68,215.32 299.92,215.32 299.92,207.04 303.31,203.66 312.99,203.66 312.99,14.34 311.71,14.34 311.71,11.3 305.36,4.95 288.8,4.95 288.54,4.7 288.54,4.14 288.16,3.76 84.53,3.76 84.53,16.41 61.37,16.41 61.37,16.43 60.76,16.43 60.76,10.82 41.4,10.82 40.84,10.26 40.84,3.22 40.77,3.15 40.77,1.17 40.49,0.89 ; 23 cut-outs
(no net) on P09: 283.95,88.03 280.65,88.03 280.24,88.45 280.24,92.81 281.54,94.11 281.54,96.21 282.66,97.33 286.78,97.33 287.05,97.05 287.05,95.44 286.78,95.16 286.12,95.16 285.34,94.38 285.34,92.93 284.07,91.66 284.07,88.16
(no net) on P10: 17.13,91.87 17.13,91.87 17.13,91.24 18.03,90.34 18.03,89.15 18.48,88.7 26.04,88.7 26.42,89.09 26.42,99.56 26.27,99.7 24.53,99.7 23.91,99.08 17.4,99.08 17.13,98.81
(no net) on P10: 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,4.97 312.85,4.62 312.5,4.48 288.55,4.48 288.55,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,10.45 81.97,11.52 80.91,11.96 63.44,11.96 62.65,11.74 62.1,11.14 43.54,11.14 42.47,10.7 42.03,9.63 42.03,1 41.89,0.65 41.54,0.51 1,0.51 0.65,0.65 0.51,1 0.51,208.98 0.65,209.33 1,209.47 38.48,209.47 39.55,209.91 39.99,210.98 39.99,214.83 40.14,215.18 40.48,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 ; 4 cut-outs
(no net) on P10: 211.07,98.4 210.28,99.2 210.28,105.37 210.74,105.84 223.8,105.84 224.44,105.19 224.44,98.61 224.24,98.4
(no net) on P10: 207.81,125.04 207.53,125.32 207.53,130.03 207.48,129.99 204.17,129.99 203.98,130.17 203.98,133.73 202.98,134.73 194.28,134.73 194.11,134.89 194.11,140.52 194.56,140.97 210.95,140.97 211.37,140.55 211.37,125.45 210.96,125.04
(no net) on P10: 9.17,89.69 9.36,89.87 17.45,89.87 17.68,89.64 17.68,85.42 17.27,85.01 3.79,85.01 3.29,85.5 3.29,89.37 3.61,89.69
(no net) on P10: 157.09,125.53 161.87,125.53 162.2,125.86 162.2,134.13 161.24,135.09 158.36,135.09 158.1,134.84 158.1,127.8 157.72,127.42 156.99,127.42 156.83,127.25 156.83,125.79
(no net) on P10: 286.35,95.2 286.35,82.49 285.98,82.12 273.06,82.12 271.6,83.59 271.6,93.06 274.22,95.68 285.87,95.68
(no net) on P10: 8.6,72.98 6.07,75.51 6.07,80.02 6.31,80.27 17.88,80.27 20.76,77.38 50.4,77.38 53.31,80.29 62.2,80.29 69.79,87.88 80.33,87.88 81.88,86.33 86.96,86.33 88.51,87.88 118.34,87.88 120.47,85.75 153.41,85.75 155.58,87.91 155.58,102.53 167.25,114.21 167.25,133.61 162.17,138.7 162.17,155.01 162.81,155.66 188.9,155.66 197.1,147.46 235.21,147.46 240.9,141.76 240.9,116.16 240.56,115.82 235.7,115.82 235.2,116.31 235.2,137.62 231.6,141.22 185.55,141.22 185.17,140.84 185.17,138.18 185.04,138.05 182.37,138.05 181.93,137.61 181.93,130.42 182.64,129.71 189.99,129.71 190.81,128.89 190.81,105.49 188.52,103.2 173.96,103.2 168.67,97.9 168.67,81.88 164.34,77.55 89.79,77.55 85.22,72.98 77.1,72.98 77.1,72.98 ; 1 cut-out
(no net) on P10: 106.33,130.91 106.33,136.77 106.68,137.12 109.45,137.12 110.05,136.52 110.05,134.28 109.41,133.63 109.41,132.58 109.61,132.39 111.58,132.39 111.88,132.08 111.88,130.35 111.88,130.35 111.88,129.56 111.6,129.29 111.22,129.29 110.76,128.83 108.41,128.83
(no net) on P10: 204.97,126.75 204.14,126.75 203.51,127.38 203.51,133.51 202.72,134.29 194.08,134.29 193.68,134.69 193.68,140.59 193.02,141.24 185.72,141.24 185.42,140.94 185.42,138.69 193.4,130.71 194.51,130.71 195.42,129.79 195.42,123.85 196.28,122.99 203.91,122.99 204.3,123.38 204.3,125.37 205.11,126.18 205.11,126.61
(no net) on P10: 207.38,129.65 207.38,125.1 207.77,124.71 211.52,124.71 211.63,124.82 211.63,129.02 211.75,129.14 222.98,129.14 223.52,128.59 223.52,122.43 223.15,122.06 216.32,122.06 216.18,121.92 216.18,121.68 216.19,121.67 216.19,120.21 216,120.03 191.73,120.03 191.05,120.7 191.05,129.02 190.25,129.82 183.39,129.82 182.27,130.94 182.27,136.87 182.86,137.46 186.49,137.46 193.44,130.51 194.39,130.51 195.23,129.67 195.23,123.66 196.07,122.82 204.42,122.82 204.42,125.14 204.52,125.25 204.53,125.25 205.25,125.96 205.25,126.6 205.27,126.62 204.88,127 204.25,127 203.65,127.6 203.65,129.57 203.85,129.76 207.27,129.76
(no net) on P10: 287.32,104.81 286.76,104.25 276.56,104.25 274.41,102.1 274.41,96.39 256.72,78.7 187.17,78.7 186.62,79.25 186.62,95.28 189.32,97.98 230.26,97.98 235.96,103.67 235.96,115.05 236.29,115.39 240.96,115.39 241.5,115.92 241.5,141.96 235.54,147.92 197.26,147.92 189.07,156.12 168.02,156.12 167.49,156.65 167.49,183.43 168.26,184.19 190,184.19 190.54,183.66 190.54,167.73 191.01,167.26 268.03,167.26 268.94,166.35 268.94,151.33 280.75,139.52 280.75,123.14 287.32,116.58 ; 3 cut-outs
(no net) on P10: 294.8,103.83 280.1,103.83 279.62,103.35 279.62,96.49 280.06,96.05 294.41,96.05 295.03,96.67 295.03,103.6
(no net) on P10: 9.42,31.23 9.42,26.82 9.65,26.59 12.02,26.59 25.73,40.3 34.65,40.3 40.74,46.38 40.74,54.96 40.75,54.96 40.75,55.53 41.23,56.01 53.94,56.01 54.35,55.6 54.35,50.12 54.56,49.91 56.18,49.91 56.35,50.08 56.35,57.12 54.92,58.55 38.2,58.55 36.76,57.11 36.76,48.09 33.07,44.41 22.6,44.41
(no net) on P10: 210.31,113.72 210.31,111.17 210.2,111.06 209.45,111.06 209.43,111.08 195.71,111.08 195.71,110.04 195.45,109.78 193.55,109.78 193.55,113.84 193.73,114.02 210.01,114.02
(no net) on P10: 145.91,97.44 120.97,97.44 120.21,96.68 120.21,86.81 120.79,86.24 146.47,86.24 146.8,86.57 146.8,96.54
(no net) on P10: 220.56,113.79 220.25,114.09 220.25,117.28 220.65,117.68 234.31,117.68 234.72,117.27 234.72,116.03 235.3,115.45 235.3,113.92 235.17,113.79
(no net) on P10: 268.08,167.59 191.12,167.59 190.83,167.89 190.83,183.79 190.14,184.48 168.14,184.48 167.23,183.57 167.23,171.76 166.85,171.38 159.01,171.38 155.21,167.59 68.93,167.59 66.93,165.59 66.93,147.34 65.61,146.02 49.24,146.02 49.23,146 14.41,146 3.32,157.09 3.32,207.27 3.93,207.88 26.69,207.88 29.69,204.88 47.66,204.88 49.83,207.05 49.83,212.18 50.51,212.87 169.28,212.87 170.02,212.13 170.02,207.8 173.51,204.32 178.72,204.32 181.74,207.34 181.74,212.27 182.34,212.87 295.27,212.87 297.26,210.87 297.26,205 299.95,202.31 309.36,202.31 310.47,201.2 310.47,132.3 308.59,130.42 300.94,130.42 296.48,125.96 296.48,124.01 295.84,123.37 282.01,123.37 281.17,124.21 281.17,139.59 269.26,151.5 269.26,166.41 ; 3 cut-outs
(no net) on P10: 202.31,114.61 202.32,114.6 201.99,114.27 194.57,114.27 194.4,114.44 194.4,118.02 195.97,119.59 202.03,119.59 202.31,119.31
(no net) on P10: 216.47,121.64 216.47,118.52 216.8,118.19 234.88,118.19 234.97,118.28 234.97,121.46 234.8,121.64
(no net) on P10: 82.42,89.16 82.42,94.87 87,99.44 87,111.51 86.79,111.72 79.88,111.72 71.13,102.97 54.92,102.97 53.07,104.83 53.07,121.41 54.3,122.65 93.97,122.65 106.18,134.86 121.85,134.86 122.33,134.38 122.33,113.17 120.92,111.76 112.41,111.76 112.23,111.57 112.23,103.21 114.92,100.52 118.73,100.52 118.98,100.77 120.03,100.77 120.23,100.98 120.23,106.04 121.02,106.83 127.44,106.83 127.92,107.31 127.92,123.46 144.86,140.4 154.96,140.4 155.45,140.89 155.45,154.19 145.89,163.75 110.48,163.75 110.17,163.44 110.17,157.93 113.59,154.5 113.59,145.42 112.29,144.12 83.1,144.12 68.18,129.2 52.1,129.2 49.83,126.93 45.12,126.93 44.33,127.72 44.33,132.41 43.61,133.13 41.02,133.13 40.27,132.38 40.27,126.59 42.87,123.99 45.38,123.99 46.33,123.04 46.33,82.95 45.83,82.45 45.83,78.18 46.15,77.86 50.24,77.86 53.14,80.75 61.95,80.75 69.53,88.33 81.6,88.33
(no net) on G11: 1.61,0.51 1,0.51 0.65,0.65 0.51,1 0.51,1.61 0.51,208.86 0.51,208.98 0.65,209.33 1,209.47 38.51,209.47 39.55,209.91 39.99,210.95 39.99,214.51 39.99,214.83 40.14,215.18 40.48,215.32 312.37,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,5.22 312.99,4.97 312.85,4.62 312.5,4.48 288.55,4.48 288.55,4.11 83.49,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,5.18 82.42,10.48 81.97,11.52 80.94,11.96 63.41,11.96 62.64,11.73 62.1,11.14 43.51,11.14 42.47,10.7 42.03,9.66 42.03,1.51 42.03,1 41.89,0.65 41.54,0.51 41.03,0.51 41.03,0.51 ; 21 cut-outs
(no net) on P12: 1.18,0.51 1,0.51 0.65,0.65 0.51,1 0.51,208.82 0.51,208.98 0.65,209.33 1,209.47 38.51,209.47 39.55,209.91 39.99,210.95 39.99,214.04 39.99,214.04 39.99,214.83 40.14,215.18 40.48,215.32 41.28,215.32 312.25,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,5.24 312.99,4.97 312.85,4.62 312.5,4.48 288.55,4.48 288.55,4.11 83.17,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,10.48 81.97,11.52 80.94,11.96 63.41,11.96 62.64,11.73 62.1,11.14 43.51,11.14 42.47,10.7 42.03,9.66 42.03,1.27 42.03,1 41.89,0.65 41.54,0.51 ; 18 cut-outs
(no net) on P12: 287.16,112.71 287.63,112.23 287.63,102.79 286.94,102.1 271.71,102.1 268.76,99.15 268.76,90.74 260.16,82.14 260.16,62.6 258.78,61.22 82.8,61.22 79.2,64.81 79.2,97.77 79.37,97.94 90.16,97.94 90.28,98.06 90.28,146.47 90.29,146.47 90.29,163.63 111.51,184.85 190.7,184.85 191.79,183.76 191.79,165.5 193.34,163.95 193.34,130.02 194.82,128.54 203.93,128.54 204.34,128.13 204.34,112.71 ; 6 cut-outs
(no net) on P12: 270.95,97.18 270.95,78.96 268.37,76.38 268.37,73.89 269.01,73.25 303.36,73.25 307.77,77.66 307.77,94.47 301.49,100.76 274.53,100.76
(no net) on P12: 271.78,153.04 254.02,170.8 251.26,170.8 245.81,176.24 192.61,176.24 192.1,175.74 192.1,165.68 193.64,164.14 193.64,130.2 194.98,128.85 223.16,128.85 224.54,127.48 224.54,113.43 224.87,113.09 271.14,113.09 271.78,113.74 ; 1 cut-out
(no net) on P12: 224.19,113.54 223.8,113.15 204.67,113.15 204.51,113.32 204.51,128.44 204.73,128.65 223.03,128.65 224.19,127.49
(no net) on P12: 272.06,153.09 253.81,171.34 257.74,182.28 247.55,176.68 192.58,176.68 192.08,177.17 192.08,183.94 190.8,185.23 111.46,185.23 90.07,163.83 69.43,163.83 66.97,161.37 66.97,154.76 65.11,152.89 59.15,152.89 59.14,152.9 20.75,152.9 17.9,150.05 2.59,150.05 1.7,150.95 1.7,208.2 2.18,208.69 39.31,208.69 42.26,205.74 47.34,205.74 49.62,208.02 49.62,212.93 51,214.31 169.89,214.31 171.81,212.38 175.53,205.06 180.38,211.68 183.01,214.31 300.87,214.31 301.06,214.11 301.06,208.19 304.77,204.49 311.96,204.49 312.18,204.27 312.18,113.25 311.9,112.98 272.2,112.98 272.06,113.12 ; 2 cut-outs
(no net) on P12: 78.96,97.8 79.27,98.1 89.55,98.1 90.04,98.6 90.04,151.97 89.69,152.32 51.54,152.32 51.31,152.1 51.31,132.77 36.4,132.77 36.4,91.84 31.95,87.4 31.95,80.95 32.89,80.01 77.72,80.01 78.96,81.25
(no net) on G13: 1.54,0.51 1,0.51 0.65,0.65 0.51,1 0.51,1.54 0.51,208.57 0.51,208.98 0.65,209.33 1,209.47 38.51,209.47 39.55,209.91 39.99,210.95 39.99,214.62 39.99,214.83 40.14,215.18 40.48,215.32 312.11,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,5.1 312.99,4.97 312.85,4.62 312.5,4.48 312.37,4.48 288.55,4.48 288.55,4.11 83.71,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,5.4 82.42,10.48 81.97,11.52 80.94,11.96 63.41,11.96 62.64,11.73 62.1,11.14 43.51,11.14 42.47,10.7 42.03,9.66 42.03,2.37 42.03,1 41.89,0.65 41.54,0.51 40.16,0.51 ; 21 cut-outs
(no net) on T14: 112.54,163.17 112.86,163.5 112.86,195.18 112.31,195.73 97.56,195.73 96.06,194.24 96.06,186.69 97.83,184.93 97.83,180.41 99.36,178.87 100.32,178.87 102.81,176.38 102.81,165.31 104.94,163.17
(no net) on T14: 98.55,97.59 101.73,94.42 101.73,89.06 100.77,88.11 95.41,88.11 95.03,88.49 95.03,89.18 94.46,89.74 90.43,89.74 90.04,90.13 90.04,94.29 89.92,94.42 89.79,94.42 88.9,95.31 88.9,97.08 89.41,97.59
(no net) on T14: 25.28,102.91 20.22,102.91 19.5,102.2 19.5,91.45 20.06,90.9 25.62,90.9 25.93,91.2 25.93,102.27
(no net) on T14: 89.41,85.15 87.63,86.92 87.63,93.65 88.01,94.04 89.41,94.04 89.92,93.53 89.92,89.79 90.3,89.41 94.04,89.41 94.75,88.7 94.75,85.59 94.31,85.15
(no net) on T14: 197.66,128.73 201.07,128.73 202.49,127.31 202.49,123.41 202.3,123.22 200.79,123.22 200.15,123.86 193.51,123.86 188.46,118.81 188.46,115.57 186.61,113.72 184.02,113.72 183.77,113.98 183.77,121.22 190.28,127.73 196.66,127.73
(no net) on T14: 272.5,143.73 260.27,155.96 260.27,178.51 260.86,179.1 280.82,179.1 285.12,183.4 287.58,183.4 289.96,181.03 289.96,158.31 297.06,151.21 297.06,143.98 299.49,141.55 299.49,135.84 295.79,132.15 295.79,111.49 290.45,106.15 266.97,106.15 264.04,109.07 264.04,115.55 265.69,117.2 270.55,117.2 270.55,117.21 270.96,117.21 272.5,118.75 ; 1 cut-out
(no net) on T14: 188.84,116.56 188.73,116.66 188.73,118.61 193.68,123.56 200.16,123.56 201.09,122.63 201.09,121.87 200.53,121.78 200.52,121.22 194.2,121.22 189.54,116.56
(no net) on T14: 288.77,85.58 288.16,84.97 270.69,84.97 270.23,85.43 270.23,101.18 271.32,102.27 287.51,102.27 288.77,101.01
(no net) on T14: 137.58,99.65 124.86,99.65 124.6,99.4 124.6,87.81 125.14,87.27 137.18,87.27 138.05,88.13 138.05,99.18
(no net) on T14: 58.13,108.92 47.49,108.92 45.11,106.54 45.11,103.38 46.4,102.08 48.92,102.08 51.22,104.38 56.05,104.38 58.19,106.52 58.19,108.87
(no net) on G15: 1.26,0.51 1,0.51 0.65,0.65 0.51,1 0.51,208.6 0.51,208.98 0.65,209.33 1,209.47 38.51,209.47 39.55,209.91 39.99,210.95 39.99,214.34 39.99,214.34 39.99,214.83 40.14,215.18 40.48,215.32 40.97,215.32 312.3,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,5.04 312.99,4.97 312.85,4.62 312.5,4.48 288.55,4.48 288.55,4.11 83.4,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,5.09 82.42,10.48 81.97,11.52 80.94,11.96 63.41,11.96 62.64,11.73 62.1,11.14 43.51,11.14 42.47,10.7 42.03,9.66 42.03,1.44 42.03,1 41.89,0.65 41.54,0.51 41.1,0.51 ; 21 cut-outs
(no net) on T16: 51.6,168.7 51.6,170.68 51.8,170.88 55.79,170.88 60.05,175.14 60.05,179 64.25,183.19 67.53,183.19 76.49,192.15 78.02,192.15 78.21,191.96 78.21,190.41 77.3,189.5 77.3,186.41 71.02,180.14 67.77,180.14 63.5,175.86 63.5,174.43 57.37,168.3 52,168.3
(no net) on T16: 38.84,187.1 50.67,198.93 65.58,198.93 67.31,200.66 67.31,203.84 68.58,205.1 85.15,205.1 85.53,205.49 95.13,205.49 95.92,204.69 98.22,204.69 98.42,204.89 98.42,208.91 97.79,209.55 59.05,209.55 54.61,205.1 41.91,205.1 31.75,194.94 31.75,186.06 25.4,179.71 25.4,146.88 25.65,146.63 31.82,146.63 32.08,146.88 32.08,169.46 38.84,176.22
(no net) on T16: 226.2,187.66 258.76,187.66 260.39,189.3 274.9,189.3 276.22,190.62 282.01,190.62 282.22,190.4 282.22,189.12 280.52,187.41 278.66,187.41 276.44,185.2 226.32,185.2 225.87,185.65 225.87,187.33
(no net) on T16: 35.94,109.79 35.94,123.86 36.47,124.38 47.27,124.38 51.44,128.55 51.44,140.7 52.26,141.52 58.55,141.52 59.67,140.4 59.67,125.38 60.1,124.95 61.6,124.95 62,124.54 62,123.69 61.73,123.42 60.48,123.42 59.67,122.61 59.67,110.44 58.59,109.36 36.37,109.36
(no net) on T16: 39.59,187.09 39.59,149.29 43.85,145.03 55.42,145.03 55.66,145.27 55.66,157.45 50.89,162.22 50.89,170.33 47.94,173.29 47.94,180.41 52.95,185.42 66.78,185.42 75.56,194.21 108.87,194.21 109.86,195.2 109.86,200.83 109.01,201.68 69.22,201.68 66.05,198.51 51.02,198.51
(no net) on T16: 57.41,61.77 57.41,72.1 54,75.5 43.9,75.5 42.9,76.49 42.9,86.49 41.14,88.25 35.12,88.25 34.76,87.89 34.76,85.91 37.26,83.4 37.26,76.31 40.58,73 52.28,73 55.1,70.18 55.1,61.82 55.51,61.41 57.04,61.41
(no net) on T16: 193.62,129.21 193.62,127.7 195.68,125.64 195.68,122.53 196.22,121.98 206.38,121.98 207.34,122.94 207.34,128.09 205.88,129.56 193.97,129.56
(no net) on T16: 13.37,100.05 13.85,99.57 13.85,98.24 13.86,98.24 13.86,97.56 12.91,96.61 12.91,93.16 13.16,92.9 18.74,92.9 18.96,93.12 18.96,95.38 19.14,95.56 21.75,95.56 21.96,95.35 21.96,92.21 21.46,91.71 15.23,91.71 13.56,90.05 11.18,90.05 10.35,90.88 10.35,99.18 11.23,100.05
(no net) on T16: 110.87,118.82 111.43,118.27 113.96,118.27 115.2,119.51 115.2,120.44 115.55,120.78 117.67,120.78 117.99,121.1 117.99,125.38 118.49,125.88 118.49,133.56 117.96,134.1 111.05,134.1 110.87,133.92
(no net) on T16: 74.55,134.81 74.55,142.16 74.06,142.66 69.75,142.66 59.94,132.85 59.94,125.55 60.25,125.24 61.73,125.24 62.32,124.65 62.32,123.56 61.89,123.13 60.92,123.13 59.94,122.15 59.94,110.18 59.05,109.29 59.03,109.29 58.77,109.02 36.57,109.02 35.79,108.25 35.79,102.95 36.45,102.29 37.01,102.29 37.03,102.31 65.43,102.31 68.2,105.07 68.2,105.16 68.71,105.66 68.71,121.16 68.2,121.67 68.2,128.46
(no net) on T16: 208.11,115.31 207.71,114.91 194.4,114.91 192.28,117.03 192.16,117.15 192.16,119.83 191.42,120.57 191.42,123.73 190.98,124.16 190.98,126.53 191.31,126.86 193.01,126.86 194.52,125.34 194.52,121.96 195.51,120.97 207.47,120.97 208.11,120.33
(no net) on T16: 85.68,188.06 89.03,188.06 89.45,187.64 89.45,185.27 85.35,181.17 85.35,176.61 86.5,175.46 102.54,175.46 103.61,176.54 103.61,187.95 100.7,190.87 85.79,190.87 85.37,190.44 85.37,188.37
(no net) on G17: 1.46,0.51 1,0.51 0.65,0.65 0.51,1 0.51,1.46 0.51,208.5 0.51,208.98 0.65,209.33 1,209.47 1.48,209.47 38.51,209.47 39.55,209.91 39.99,210.95 39.99,214.3 39.99,214.3 39.99,214.83 40.14,215.18 40.48,215.32 41.01,215.32 312.16,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,214.49 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,6.16 312.99,4.97 312.85,4.62 312.5,4.48 311.31,4.48 288.55,4.48 288.55,4.11 84.05,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,5.74 82.42,10.48 81.97,11.52 80.94,11.96 63.41,11.96 62.64,11.73 62.1,11.14 43.51,11.14 42.47,10.7 42.03,9.66 42.03,1.43 42.03,1 41.89,0.65 41.54,0.51 41.11,0.51 ; 21 cut-outs
