# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SFP+_P11_RATE_SEL: length 56.5
  T05 w0.117: v1(134.49,20.96) 136,22.47 143.74,22.47 145.05,23.78 149.62,23.78 150.44,24.6 151.86,24.6 151.9,24.65 151.9,25.51 152.23,25.84 153.1,25.84 161.1,33.84 161.1,37.82 161.67,38.39 163.74,38.39 165.12,39.77 165.12,43.95 163.86,45.21 163.86,46.88 163.09,47.65 163.09,48.21 162.56,48.74 161.84,48.74 CJ8.FL7
  T07 w0.117: CJ8.FL7 CJ8.FL9
  BOTTOM w0.14: R776.2 134.49,21.53 v1(134.49,20.96) R390.1
SFP+_P11_RATE_SEL_OUT: length 5.4
  BOTTOM w0.14: R776.1 134.92,22.76 v2(134.92,25.32) 134.52,25.71 U51.17
SFP+_P11_RX_LOS: length 51.4
  T05 w0.117: v1(150.29,23.09) 150.29,23.09 151.38,24.18 152.66,24.18 156,27.53 157.76,27.53 164.01,33.78 164.01,36.24 165.22,37.45 165.22,38.49 167.67,40.94 167.67,48.96 166.31,50.32 165.65,50.32 165.41,50.08 164.75,50.08 164.57,50.26 163.98,50.26 163.76,50.04 163.24,50.04 162.99,50.29 162.4,50.29 162.16,50.04 161.59,50.04 160.78,50.85 CJ8.FL8
  BOTTOM w0.14: R392.1 150.15,20.71 150.29,20.85 v1(150.29,23.09) 150.29,25.66 149.82,26.13 U48.17
SFP+_P11_RXVCC:
  vias: v2(153.42,65.22)
SFP+_P11_TX_DIS: length 91
  T03 w0.117: CJ8.FL3 164.97,50.14 166.52,50.14 167.87,48.79 167.87,36.58 161.6,30.31 153.21,30.31 147.09,24.19 144.98,24.19 143.3,22.51 133.11,22.51 132.11,21.51 132.11,20.82 131.68,20.39 121.26,20.39 120.11,21.54 v1(112.17,21.54)
  T14 w0.117: v1(112.17,21.54) 112.17,22.11 110.77,23.51 110.77,25.19 109.85,26.11 v1(107.19,26.11)
  BOTTOM w0.14: v1(107.19,26.11) 107.1,26.2 U54.17 ; R389.1 112.42,21.54 v1(112.17,21.54)
SFP+_P11_TX_FLT: length 80.8
  T03 w0.117: CJ8.FL2 166.43,50.85 168.29,48.99 168.29,36.4 161.78,29.89 153.39,29.89 147.26,23.76 145.15,23.76 143.47,22.09 133.28,22.09 132.54,21.34 132.54,20.65 131.75,19.87 121.89,19.87 121.08,19.07 v1(121.08,18.98)
  BOTTOM w0.14: U53.17 121.15,25.79 121.52,25.42 121.52,21.07 121.35,20.9 121.23,20.9 R391.1 121.04,19.04 121.08,19 v1(121.08,18.98)
SFP+_P11_TXVCC:
  vias: v2(163.58,62.43)
SFP+_P12_MOD_ABS: length 64.9
  TOP w0.14: v1(166.67,74.26) 166.67,75 167.04,75.37 U30.4
  T03 w0.117: v1(179.29,42.86) 179.29,44.3 178.13,45.46 178.13,46.86 177.36,47.63 177.36,48.48 177.75,48.88 177.75,49.78 176.91,50.62 176.91,51.96 CJ8.GT6
  T18 w0.117: v1(179.29,42.86) 180.38,41.77 180.38,25.48 v1(180.18,25.28) ; CJ8.GT6 176.79,52.96 176.29,52.96 176.08,53.18 175.41,53.18 175.19,52.95 174.7,52.95 174.45,53.21 173.87,53.21 173.49,52.83 172.72,52.83 172.47,53.09 172.47,56.41 172.39,56.49 172.39,56.96 169.29,60.06 169.29,71.88 166.92,74.26 v1(166.67,74.26)
  BOTTOM w0.14: Q34.5 v1(179.29,42.86) ; U47.16 179.45,26.28 180.18,25.56 v1(180.18,25.28) R400.1
SFP+_P12_RATE_SEL: length 93
  T03 w0.117: CJ8.GT7 CJ8.GT9 180.36,53.79 181.49,52.66 181.49,51.12 183.06,49.56 183.06,46.86 187.32,42.59 187.32,40.31 187.12,40.11 187.12,39.51 187,39.4 186.61,39.4 185.14,37.93 185.14,36.67 182.64,34.17 182.64,23.23 180.23,20.82 141.49,20.82 140.41,19.74 137.71,19.74 v1(136.38,18.41)
  T18 w0.117: CJ8.GT7 CJ8.GT9
  BOTTOM w0.14: v2(136.86,17.4) 136.38,17.89 v1(136.38,18.41) 136.07,18.72 136.07,19.92 135.89,20.09 R397.1 135.51,21.53 R777.2
SFP+_P12_RATE_SEL_OUT: length 5.5
  BOTTOM w0.14: U51.16 135.17,26.32 135.73,25.76 v2(135.73,24) 135.73,22.73 R777.1
SFP+_P12_RX_LOS: length 67.1
  T05 w0.117: CJ8.GT8 179.49,52.4 182.45,49.44 182.45,34.18 172.6,24.33 172.6,22.48 171.11,21 168.6,21 167.52,19.92 167.52,19.51 167.15,19.14 154.06,19.14 v1(153.75,19.45)
  T18 w0.117: v1(151.09,25.28) 152.07,24.3 152.5,24.3 153.75,23.04 v1(153.75,19.45)
  BOTTOM w0.14: U48.16 150.47,25.9 v1(151.09,25.28) R399.1
SFP+_P12_RXVCC: length 13
  TOP w0.635: C1068.1 173.63,62.26 v6(173.81,62.09)
  P10 w0.508: CJ8.GT15 176.95,57.37 177,57.37 178.31,58.68 178.31,61.09 177.31,62.09 v6(173.81,62.09)
SFP+_P12_TX_DIS: length 128.5
  T05 w0.117: v1(110.29,19.23) 111.42,18.1 123.04,18.1 124.15,19.21 134.89,19.21 135.08,19.41 143.77,19.41 144.46,18.72 178.34,18.72 179.47,19.84 179.47,20.41 180.98,21.92 180.98,25.86 187.45,32.33 187.45,36.88 187.02,37.32 187.02,37.79 187.45,38.22 187.45,39.35 187.12,39.68 187.12,40.11 187.45,40.44 187.45,43.96 184.14,47.27 184.14,49.65 181.86,51.93 181.86,53.02 180.33,54.55 175.72,54.55 CJ8.GT3
  BOTTOM w0.14: U54.16 107.75,26.74 108.37,26.12 R396.1 108.84,24.54 109.1,24.29 109.1,22.04 109.28,21.86 109.28,19.71 109.76,19.23 v1(110.29,19.23)
SFP+_P12_TX_FLT: length 83.6
  T05 w0.117: v1(121.8,18.98) 121.8,19.04 122.42,19.67 134.72,19.67 135.86,20.81 135.86,21.09 136.29,21.52 145.94,21.52 146.28,21.18 152.28,21.18 154.24,23.14 154.24,24.57 156.28,26.61 158.5,26.61 171.14,39.26 171.14,45.53 172.18,46.57 172.18,48.94 173.74,50.49 173.74,51.98 CJ8.GT2
  T14 w0.117: v1(121.8,18.98) 121.8,24.65 v1(122.42,25.28)
  BOTTOM w0.14: R398.1 v1(122.42,25.28) 122.42,25.51 121.8,26.13 U53.16
SFP+_P12_TXVCC: length 13.7
  TOP w0.635: v6(167.18,62.49) 166.9,62.77 C1065.1
  P10 w0.508: v6(167.18,62.49) 168.33,61.34 173.15,61.34 174.37,60.12 174.37,58.87 176.15,57.09 CJ8.GT16
SFP+_P13_MOD_ABS: length 77.6
  TOP w0.14: U30.5 167.58,73.86 166.69,72.97 v1(166.1,72.97)
  T03 w0.117: CJ8.GL6 176.15,48.97 175.77,48.59 175.77,47.6 176.55,46.82 176.55,43.63 v1(177.32,42.86)
  T18 w0.117: v1(177.32,42.86) 177.99,43.53 179.72,43.53 182.12,41.14 182.12,21.92 v1(180.18,19.98) ; CJ8.GL6 176.15,50.95 175.47,51.63 173.42,51.63 172.21,52.84 172.21,52.96 172.2,52.98 172.2,56.3 172.12,56.37 172.12,56.51 168.68,59.95 168.68,71.76 167.47,72.97 v1(166.1,72.97)
  BOTTOM w0.14: U47.15 180.1,26.31 180.8,25.61 180.8,20.89 180.63,20.71 R407.1 v1(180.18,19.98) ; Q34.2 v1(177.32,42.86)
SFP+_P13_RATE_SEL: length 58.9
  T03 w0.117: CJ8.GL7 CJ8.GL9
  T05 w0.117: CJ8.GL9 173.45,49.47 172.56,48.58 172.56,42.67 171.59,41.71 171.59,39.09 165.46,32.95 165.46,31.68 154.43,20.65 140.72,20.65 140.34,20.26 137.22,20.26 v1(136.53,20.96)
  BOTTOM w0.14: R778.2 136.53,21.53 v1(136.53,20.96) 136.53,20.2 R404.1
SFP+_P13_RATE_SEL_OUT: length 5.6
  BOTTOM w0.14: U51.15 135.82,26.43 136.65,25.6 v2(136.65,25.07) 136.65,22.83 R778.1
SFP+_P13_RX_LOS: length 54.5
  T05 w0.117: CJ8.GL8 175.09,50.85 176.15,49.8 176.15,48.95 176.4,48.7 176.92,48.7 177.35,48.28 177.35,47.62 176.55,46.82 176.55,43.45 165.88,32.77 165.88,31.5 154.6,20.23 151.78,20.23 v1(151.18,19.63)
  BOTTOM w0.14: v1(151.18,19.63) 151.09,19.72 R406.1 151.52,20.71 151.72,20.92 151.72,25.61 151.12,26.21 U48.15
SFP+_P13_RXVCC:
  vias: v2(165.61,62.68)
SFP+_P13_TX_DIS: length 105.1
  T03 w0.117: CJ8.GL3 179.32,48.71 180.47,48.71 181.61,47.58 181.61,37.12 180.33,35.85 180.33,34.57 175.87,30.11 v1(172.77,30.11)
  T07 w0.117: v1(112.23,19.34) 112.65,19.76 126,19.76 135,28.76 154.04,28.76 155.39,30.11 v1(172.77,30.11)
  BOTTOM w0.14: U54.15 108.4,28.82 108.54,28.96 110.01,28.96 110.87,28.1 110.87,20.4 111.01,20.26 111.36,20.26 R403.1 112.23,19.39 v1(112.23,19.34)
SFP+_P13_TX_FLT: length 94
  T03 w0.117: v1(122.56,19) 123,19.45 132.07,19.45 132.79,20.16 140.24,20.16 141.31,21.24 155.04,21.24 161.61,27.81 174.47,27.81 182.03,35.37 182.03,48.9 180.08,50.85 CJ8.GL2
  BOTTOM w0.14: U53.15 122.45,26.21 122.9,25.76 122.9,20.71 R405.1 122.42,19.14 v1(122.56,19) 122.68,18.88 v2(122.68,17.88)
SFP+_P13_TXVCC:
  vias: v2(175.52,62.43)
SFP+_P14_MOD_ABS: length 76.3
  TOP w0.14: U33.4 178.96,75.37 v1(178.79,75.21)
  T14 w0.117: v1(181.55,25.28) 181.55,26.59 185.48,30.52 185.48,39.07 189.84,43.43 192.06,43.43 192.16,43.33 192.52,43.33 v1(193.25,42.6)
  T18 w0.117: v1(178.79,75.21) 178.79,74.35 185.35,67.8 185.35,57.78 186.18,56.95 186.18,56.52 186.94,55.75 186.94,54.67 187.06,54.55 191.14,54.55 191.6,54.09 CJ8.HT6 191.6,51.73 191.21,51.34 191.21,50.57 191.98,49.81 191.98,48.88 191.56,48.46 191.56,47.65 192.39,46.83 192.39,45.34 191.86,44.81 191.86,43.63 192.89,42.6 v1(193.25,42.6)
  BOTTOM w0.14: R414.1 181.55,21.62 v1(181.55,25.28) 181.55,25.62 180.75,26.42 U47.14 ; Q35.5 193.02,42.38 v1(193.25,42.6)
SFP+_P14_RATE_SEL: length 103.9
  T03 w0.117: CJ8.HT7 CJ8.HT9 194.56,53.79 195.82,52.53 195.82,51.17 197.35,49.64 197.35,45.15 196.42,44.21 196.42,39.23 196.73,38.92 196.98,38.67 196.98,36.74 188.28,28.05 188.28,22.7 177.21,11.63 165.01,11.63 164.43,12.21 155.16,12.21 152.86,14.52 139.15,14.52 v1(137.65,16.02)
  T18 w0.117: CJ8.HT7 CJ8.HT9
  BOTTOM w0.14: v1(137.65,16.02) 138.22,16.6 138.22,19.91 138.04,20.09 R411.1 137.65,21.63 R779.2
SFP+_P14_RATE_SEL_OUT: length 5.8
  BOTTOM w0.14: U51.14 136.47,26.64 137.67,25.45 v2(137.67,23.88) 137.67,22.83 R779.1
SFP+_P14_RX_LOS: length 89.6
  T03 w0.117: CJ8.HT8 196.44,49.16 196.44,45.64 195.38,44.57 195.38,37.26 187.44,29.32 187.44,23.13 182.05,17.74 177.95,17.74 173.36,13.15 157.98,13.15 157.46,12.63 155.34,12.63 v1(151.37,16.6)
  T14 w0.117: v1(152.47,25.28) 153.03,24.71 153.03,18.26 v1(151.37,16.6)
  BOTTOM w0.14: U48.14 151.77,25.97 v1(152.47,25.28) R413.1
SFP+_P14_RXVCC: length 15
  TOP w0.635: C1080.1 185.71,62.93 v6(186.16,62.49)
  P10 w0.508: v6(186.16,62.49) 191.05,62.49 192.85,60.69 192.85,58.95 191.2,57.3 CJ8.HT15
SFP+_P14_TX_DIS: length 149.2
  T05 w0.117: CJ8.HT3 189.98,54.56 194.91,54.56 196.26,53.21 196.26,51.7 198.83,49.13 198.83,44.02 200.36,42.49 200.36,29.93 192.64,22.21 190.58,22.21 188.97,20.6 188.97,18.64 185.04,14.72 177.2,14.72 175.64,13.15 162.31,13.15 160.56,14.9 156.57,14.9 156.22,14.55 110.12,14.55 v1(109.12,15.55)
  T14 w0.117: v1(109.12,15.55) 106.77,17.9 106.77,20.05 107.81,21.09 107.81,22.32 107.67,22.46 107.67,23.2 v1(109.75,25.28)
  BOTTOM w0.14: R410.1 v1(109.75,25.28) 109.75,25.51 109.05,26.2 U54.14
SFP+_P14_TX_FLT: length 119.3
  T05 w0.117: v1(121.85,16.45) 122.99,17.6 137.9,17.6 139.29,18.99 140.34,18.99 141.03,18.3 180.99,18.3 193.17,30.47 193.17,33.75 196.56,37.14 196.56,37.9 194.42,40.03 194.42,43.62 193.4,44.64 191.97,44.64 190.8,45.8 190.8,46.82 190.03,47.59 190.03,48.46 189.78,48.72 189.02,48.72 188.78,48.97 188.78,49.78 188.01,50.55 188.01,52 CJ8.HT2
  T14 w0.117: v1(121.85,16.45) 121.85,16.58 123.12,17.86 123.12,24.61 v1(123.79,25.28)
  BOTTOM w0.14: R412.1 v1(123.79,25.28) 123.1,25.97 U53.14
SFP+_P14_TXVCC: length 16.3
  TOP w0.635: C1077.1 178.98,62.77 179.2,62.55 v6(179.2,62.49)
  P10 w0.508: v6(179.2,62.49) 180.22,61.47 187.84,61.47 188.72,60.58 188.72,58.4 CJ8.HT16
SFP+_P15_MOD_ABS: length 85.3
  TOP w0.14: v1(177.42,74.93) 177.73,74.63 178.96,74.63 179.2,74.87 U33.5
  T14 w0.117: v1(191.31,42.86) 189.87,42.86 186.89,39.88 186.89,23.32 182.82,19.25 v1(180.6,19.25)
  T18 w0.117: v1(191.31,42.86) 190.81,43.36 190.81,46.84 190.02,47.63 190.02,48.38 190.4,48.77 CJ8.HL6 189.62,51.63 187.67,51.63 186.67,52.63 186.67,55.64 185.91,56.4 185.91,56.5 184.84,57.57 184.84,67.71 177.62,74.93 v1(177.42,74.93)
  BOTTOM w0.14: Q35.2 190.83,42.38 v1(191.31,42.86) ; U47.13 181.4,26.55 182.17,25.78 182.17,20.97 182.78,20.37 R421.1 183.26,19.77 182.74,19.25 v1(180.6,19.25)
SFP+_P15_RATE_SEL: length 87.8
  T03 w0.117: CJ8.HL7 CJ8.HL9
  T05 w0.117: v1(139.96,18.42) 140.5,17.87 181.17,17.87 193.68,30.38 193.68,33.66 196.98,36.97 196.98,38.07 194.85,40.2 194.85,43.86 192.38,46.33 192.38,46.85 191.58,47.65 191.58,48.38 191.28,48.68 190.39,48.68 CJ8.HL7
  BOTTOM w0.14: R780.2 R418.1 v1(139.96,18.42) 139.31,17.78 v2(139.12,17.78)
SFP+_P15_RATE_SEL_OUT: length 8.7
  BOTTOM w0.14: R780.1 139.08,20.27 v2(139.08,21.55) 138.59,22.04 138.59,25.37 137.12,26.84 U51.13
SFP+_P15_RX_LOS: length 91
  T05 w0.117: CJ8.HL8 189.3,50.85 190.11,50.04 190.71,50.04 190.96,50.28 191.5,50.28 191.77,50.01 192.25,50.01 192.52,50.28 193.11,50.28 193.41,49.99 193.79,49.99 194.05,50.25 195.07,50.25 196.62,48.7 196.62,39.62 197.82,38.42 197.82,36.62 196.09,34.88 196.09,31.6 180.47,15.99 176.02,15.99 175,14.96 168.93,14.96 167.38,16.52 163.52,16.52 163.1,16.1 159.02,16.1 157.88,17.24 152.83,17.24 v1(152.68,17.09)
  BOTTOM w0.14: v1(152.68,17.09) 152.43,17.35 R420.1 152.85,20.68 153.06,20.89 153.06,25.36 152.42,25.99 U48.13
SFP+_P15_RXVCC:
  vias: v2(177.55,62.43)
SFP+_P15_TX_DIS: length 130.3
  T03 w0.117: v1(111.18,19.28) 112.96,17.5 131.46,17.5 131.72,17.75 140.24,17.75 140.82,18.33 152.84,18.33 153.86,17.31 153.86,15.3 155.69,13.48 157.11,13.48 158.59,14.96 161.88,14.96 165.5,18.58 181.7,18.58 186.25,23.13 186.25,34.35 185.56,35.04 185.56,37.75 186.79,38.97 193.61,38.97 194.3,39.66 194.3,44.76 195.7,46.16 195.7,47.59 194.57,48.72 193.55,48.72 CJ8.HL3
  BOTTOM w0.14: v1(111.18,19.28) 110.64,19.82 110.01,19.82 109.87,19.96 R417.1 109.99,20.2 110.33,20.2 110.5,20.37 110.5,24.32 110.43,24.4 110.43,25.89 109.7,26.61 U54.13
SFP+_P15_TX_FLT: length 122.3
  T03 w0.117: v1(123.24,16.25) 124.85,14.64 134.43,14.64 137.12,17.33 140.41,17.33 140.99,17.91 152.66,17.91 153.44,17.14 153.44,15.13 155.51,13.05 157.28,13.05 158.77,14.54 174.15,14.54 177.77,18.16 181.87,18.16 187.02,23.3 187.02,37.79 187.78,38.55 193.79,38.55 194.95,39.71 194.95,44.7 196.07,45.83 196.07,49.01 194.23,50.85 CJ8.HL2
  BOTTOM w0.14: v1(123.24,16.25) 123.48,16.49 123.48,20.4 R419.1 124.34,20.71 124.65,21.03 124.65,25.54 123.75,26.45 U53.13
SFP+_P15_TXVCC:
  vias: v2(189.11,63.7)
SFP+_P16_MOD_ABS: length 50.3
  TOP w0.14: U36.4 206.83,75.37 v1(206.62,75.16)
  T03 w0.117: v1(210.67,40.96) 211.33,41.62 211.33,43.74 208.47,46.6 208.47,47.58 209.15,48.26 209.15,49.07 208.57,49.65 208.57,50.71 209.2,51.34 CJ9.AT6
  T05 w0.117: v1(206.62,75.16) 207.52,74.27 207.52,59.46 209.17,57.81 209.17,57.28 208.53,56.64 208.53,55.75 209.2,55.08 CJ9.AT6 ; v1(211.85,38.98) 211.85,39.78 v1(210.67,40.96)
  BOTTOM w0.14: v1(210.67,40.96) 210.67,40.63 210.47,40.44 Q36.5 ; U49.11 211.67,33.25 212.6,34.18 212.6,37.98 212.31,38.27 R540.1 v1(211.85,38.98)
SFP+_P16_RATE_SEL: length 29.6
  T03 w0.117: CJ9.AT9 210.9,53.89 CJ9.AT7
  T07 w0.117: v1(195.99,37.52) 195.99,40.56 200.68,45.24 200.68,47.67 205.18,52.17 210.58,52.17 CJ9.AT9
  BOTTOM w0.14: R786.2 195.77,37.3 v1(195.99,37.52) 196.29,37.52 196.8,37.01 R537.1
SFP+_P16_RATE_SEL_OUT: length 4
  BOTTOM w0.14: R786.1 195.83,35.74 v2(195.83,34.67) 195.71,34.54 194.31,34.54 194.06,34.3 U52.11
SFP+_P16_RX_LOS: length 107.6
  T18 w0.117: CJ9.AT8 211.38,55.16 216.6,55.16 218.58,53.18 218.58,47.61 222.63,43.56 228.66,43.56 229.38,44.27 231.06,44.27 233.13,42.21 234.78,42.21 236.96,40.03 240.64,40.03 246,34.67 249.13,34.67 250.2,33.59 254.02,33.59 254.38,33.95 254.38,34.67 255.01,35.31 270.2,35.31 271.37,34.14 275.45,34.14 283.3,26.28 283.3,22.51 v1(283.73,22.09)
  BOTTOM w0.14: U50.11 283.17,15.54 283.78,14.92 284.67,14.92 285.12,15.37 285.12,18.54 R539.1 286.48,20.65 285.04,22.09 v1(283.73,22.09)
SFP+_P16_RXVCC: length 9.7
  TOP w0.635: v1(213.11,62.61) 213.59,63.08 C1188.1
  P10 w0.508: CJ9.AT15 209.2,57.85 210.45,59.1 210.45,59.95 v1(213.11,62.61)
SFP+_P16_TX_DIS: length 64.9
  T03 w0.117: v1(240.8,38.98) 240.16,38.34 240.16,36.2 239.52,35.56 228.22,35.56 226.53,33.87 225.53,33.87 225.32,34.08 225.32,35.09 224.41,36 224.41,37.47 223.86,38.01 219.96,38.01 219.25,38.73 215.05,38.73 213.38,40.4 213.38,45.07 212.46,45.98 212.46,46.89 213.27,47.7 213.27,54.57 212.64,55.2 209.84,55.2 207.83,53.19 CJ9.AT3
  BOTTOM w0.14: U56.11 240.62,33.25 241.55,34.18 241.55,38.01 241.29,38.27 R536.1 240.8,38.97 v1(240.8,38.98)
SFP+_P16_TX_FLT: length 94.7
  T14 w0.117: CJ9.AT2 206,53.08 206.76,52.32 208.66,52.32 209.04,51.94 209.04,51.18 207.26,49.4 203.89,49.4 203.17,48.68 203.17,47.75 202.74,47.33 202.74,39.33 204.42,37.65 204.42,34.76 208.6,30.57 237.36,30.57 238.29,31.5 242.22,31.5 243.15,30.57 251.17,30.57 254.53,33.93 254.53,34.54 255.72,35.73 255.72,38.44 v1(255.16,39.01)
  BOTTOM w0.14: v1(255.16,39.01) R538.1 255.61,38.27 255.8,38.09 255.8,34.18 254.97,33.36 U55.11
SFP+_P16_TXVCC: length 7.5
  TOP w0.635: v6(206.32,62.56) 206.85,63.09 C1185.1
  P10 w0.508: CJ9.AT16 207.42,58.58 207.41,58.58 207.07,58.91 207.07,61.82 v6(206.32,62.56)
SFP+_P17_MOD_ABS: length 53
  TOP w0.14: v1(205.61,73.31) 205.66,73.36 206.02,73.36 U36.5
  T05 w0.117: v1(205.61,73.31) 203.96,71.66 203.96,53.47 205.1,52.32 207.67,52.32 CJ9.AB6 208.4,49.91 209.04,49.28 209.04,48.01 207.65,46.61 207.65,42.53 v1(208.55,41.62) 209.8,40.37 209.8,36.48 v1(211.85,34.43)
  BOTTOM w0.14: Q36.2 208.33,40.44 208.55,40.66 v1(208.55,41.62) ; R547.1 v1(211.85,34.43) 211.85,34.19 211.01,33.36 U49.10
SFP+_P17_RATE_SEL: length 26.4
  T03 w0.117: CJ9.AB9 206.9,51.59 CJ9.AB7
  T07 w0.117: CJ9.AB9 206,50.41 204.55,48.96 204.55,47.63 205.26,46.92 205.26,45.9 204.28,44.92 201.1,44.92 196.57,40.39 196.57,37.3 196.22,36.95 195.28,36.95 v1(194.75,37.48)
  BOTTOM w0.14: R787.2 v1(194.75,37.48) R544.1
SFP+_P17_RATE_SEL_OUT: length 10.7
  BOTTOM w0.14: v2(198.5,29.34) 198.5,29.72 196.72,31.5 194.06,31.5 193.41,32.14 U52.10 193.41,34.47 R787.1
SFP+_P17_RX_LOS: length 122.1
  T14 w0.117: CJ9.AB8 203.35,50.19 200.28,47.12 200.28,38.01 208.13,30.15 254.44,30.15 261.86,22.73 269.75,22.73 270.76,21.72 270.76,19.98 270.76,19.64 272.28,18.12 276.47,18.12 277.57,17.02 284.5,17.02 v1(285.75,18.26)
  BOTTOM w0.14: R546.1 286.33,18.84 v1(285.75,18.26) 285.61,18.13 285.61,15.11 285.24,14.74 284.98,14.48 283.34,14.48 282.52,15.31 U50.10
SFP+_P17_RXVCC: length 20.8
  BOTTOM w0.61: C1194.1 207.22,63.67 207.22,61.94 206.5,61.21 204.89,61.21 204.28,60.6 204.28,50.39 205.09,49.59 206.27,49.59 206.76,49.11 207.89,49.11 CJ9.AB15
  vias: v2(205.61,65.73)
SFP+_P17_TX_DIS: length 45.6
  T18 w0.117: CJ9.AB3 210.8,49.8 211.46,49.15 213.77,49.15 214.87,48.05 214.87,45.78 217.98,42.67 226.14,42.67 227.58,41.23 227.58,39.5 228.73,38.35 228.73,36.4 231.83,33.29 239.66,33.29 v1(240.8,34.43)
  BOTTOM w0.14: R543.1 v1(240.8,34.43) 240.8,34.25 239.97,33.42 U56.10
SFP+_P17_TX_FLT: length 57.3
  T18 w0.117: CJ9.AB2 212.14,49.66 215.25,49.66 216.09,48.82 216.09,48.22 216.92,47.39 216.92,44.96 218.77,43.11 226.54,43.11 228.35,41.3 228.35,39.7 232.61,35.43 243.95,35.43 246.44,32.94 254.31,32.94 255.1,33.73 v1(255.1,34.3)
  BOTTOM w0.14: U55.10 254.32,33.49 255.1,34.27 v1(255.1,34.3) 255.1,35.11 R545.1
SFP+_P17_TXVCC: length 20.6
  BOTTOM w0.61: CJ9.AB16 209.14,47.25 209.14,48.12 209.23,48.21 209.23,48.21 209.93,48.91 210.15,49.2 210.25,49.29 210.29,49.32 210.44,49.41 210.6,49.46 210.78,49.48 210.95,49.47 211.12,49.42 211.28,49.35 211.4,49.26 211.45,49.2 212.33,49.2 213.24,50.11 213.24,57.93 214.13,58.83 214.13,63.49 C1191.1
  vias: v2(215.39,65.22)
SFP+_P18_MOD_ABS: length 69.4
  TOP w0.14: U39.4 218.85,75.37 v5(218.67,75.19)
  T05 w0.117: CJ9.BT6 223.45,54.91 222.78,55.58 222.78,56.65 224.66,58.53 224.66,70.99 221.44,74.21 219.64,74.21 v5(218.67,75.19)
  T07 w0.117: v1(210.47,39.01) 212.79,41.32 220.08,41.32 221.25,42.49 223.9,42.49 v1(225.46,40.92)
  T16 w0.117: CJ9.BT6 224.69,53.19 225.84,52.04 225.84,51.21 224.17,49.54 224.17,48.94 222.71,47.48 222.71,46.7 224.31,45.1 224.31,42.08 v1(225.46,40.92)
  BOTTOM w0.14: v1(210.47,39.01) R554.1 210.93,38.27 211.12,38.08 211.12,34.1 210.36,33.34 U49.9 ; Q37.5 v1(225.46,40.92)
SFP+_P18_RATE_SEL: length 44.3
  T03 w0.117: CJ9.BT7 225.15,53.89 CJ9.BT9
  T07 w0.117: CJ9.BT9 225.21,52.55 220.21,52.55 215.01,47.35 215.01,45.54 213.06,43.59 206.19,43.59 203.29,40.69 203.29,40.06 200.83,37.6 197.79,37.6 196.72,36.53 194.81,36.53 v1(193.73,37.61)
  BOTTOM w0.14: R551.1 v1(193.73,37.61) R788.2
SFP+_P18_RATE_SEL_OUT: length 10.7
  BOTTOM w0.14: v2(197.24,29.18) 197.24,30.35 196.54,31.05 193.87,31.05 193.68,31.24 193.68,31.24 192.76,32.15 U52.9 192.76,34.48 193.73,35.45 R788.1
SFP+_P18_RX_LOS: length 113.8
  T14 w0.117: v1(284.1,18.8) 282.74,17.44 277.75,17.44 276.64,18.54 272.45,18.54 271.19,19.81 271.19,21.89 269.84,23.24 261.95,23.24 256.28,28.91 256.28,38.87 255.27,39.88 253.73,39.88 253.22,39.37 253.22,36.43 251.9,35.12 244.24,35.12 242.32,33.19 230.33,33.19 227.58,35.94 227.58,36.7 226.57,37.72 222,37.72 220.89,38.82 220.89,41.11 216.92,45.09 216.92,47.05 222.07,52.21 223.9,52.21 225.05,53.36 CJ9.BT8
  BOTTOM w0.14: R553.1 284.55,19.25 v1(284.1,18.8) 283.46,18.16 282.37,18.16 281.87,17.66 U50.9
SFP+_P18_RXVCC: length 9.4
  TOP w0.635: v6(226.19,62.54) 225.88,62.54 225.66,62.76 C1200.1
  P10 w0.508: v6(226.19,62.54) 224.41,60.76 224.41,58.62 223.45,57.67 223.45,56.19 CJ9.BT15
SFP+_P18_TX_DIS: length 43
  T03 w0.117: v1(239.43,39.01) 238.52,38.1 235.71,38.1 234.82,38.99 229.62,38.99 228.5,40.11 228.5,45.29 229.12,45.91 229.12,46.87 228.5,47.49 228.5,53.19 226.41,55.28 222.08,55.28 221.05,54.25 221.05,53.19 CJ9.BT3
  BOTTOM w0.14: U56.9 239.32,33.49 240.12,34.29 240.12,38.04 239.89,38.27 R550.1 v1(239.43,39.01)
SFP+_P18_TX_FLT: length 72.6
  T14 w0.117: CJ9.BT2 220.25,52.61 214.88,47.25 214.88,45.69 220.34,40.23 220.34,36.45 220.98,35.81 223.52,35.81 228.34,31 237.11,31 238.04,31.93 242.39,31.93 243.32,31 249.77,31 253.11,34.34 253.11,35.25 254.35,36.49 254.35,38.44 v1(253.78,39.01)
  BOTTOM w0.14: U55.9 253.67,33.47 254.44,34.24 254.44,38.07 254.24,38.27 R552.1 v1(253.78,39.01)
SFP+_P18_TXVCC: length 8
  TOP w0.635: C1197.1 218.93,63.02 v6(219.36,62.59)
  P10 w0.508: v6(219.36,62.59) 221.16,60.79 221.16,59.09 CJ9.BT16
SFP+_P19_MOD_ABS: length 64.6
  TOP w0.14: U39.5 219.61,74.49 218.4,73.28 v5(217.68,73.28)
  T03 w0.117: v1(223.63,40.92) 222.16,42.4 222.16,46.9 223.42,48.16 223.42,49.13 222.65,49.89 CJ9.BB6
  T05 w0.117: v5(217.68,73.28) 217.68,66.04 218.44,65.28 218.44,53.94 220.02,52.36 221.89,52.36 CJ9.BB6
  T18 w0.117: v1(223.63,40.92) 224.16,40.92 225.13,39.96 225.13,38.7 224.56,38.13 224.56,36.26 223.92,35.63 211.67,35.63 v1(210.47,34.43)
  BOTTOM w0.14: U49.8 209.71,33.58 210.47,34.34 v1(210.47,34.43) R561.1 ; Q37.2 v1(223.63,40.92)
SFP+_P19_RATE_SEL: length 39.2
  T03 w0.117: CJ9.BB7 221.15,51.59 CJ9.BB9
  T07 w0.117: CJ9.BB9 220.25,50.19 216.99,46.92 216.99,46.71 213.45,43.17 206.36,43.17 203.71,40.51 203.71,39.88 201.01,37.18 197.96,37.18 196.89,36.11 194.22,36.11 v1(192.72,37.61)
  BOTTOM w0.14: R558.1 v1(192.72,37.61) R785.2
SFP+_P19_RATE_SEL_OUT: length 9.2
  BOTTOM w0.14: R785.1 192.72,35.19 192.11,34.59 U52.8 192.11,32.18 192.32,31.98 192.32,31.97 193.49,30.8 193.5,30.8 193.69,30.61 195.83,30.61 v2(196.34,30.1)
SFP+_P19_RX_LOS: length 99.7
  T14 w0.117: v1(283.13,18.85) 282.63,18.85 281.64,17.86 277.92,17.86 276.73,19.05 272.54,19.05 271.61,19.98 271.61,22.07 270.89,22.78 270.89,23.99 269.42,25.45 266.9,25.45 256.7,35.66 256.7,39.24 254.75,41.19 253.16,41.19 252.69,40.73 252.69,38.06 251.74,37.11 251.74,36.35 250.95,35.56 243.71,35.56 242.02,33.87 237.4,33.87 236.35,34.92 229.87,34.92 228.47,36.32 228.47,38.1 226.31,40.26 223.14,40.26 221.49,41.91 221.49,44.7 218.92,47.26 218.92,48.49 220.62,50.19 CJ9.BB8
  BOTTOM w0.14: R560.1 283.42,19.14 v1(283.13,18.85) 282.41,18.85 281.22,17.65 U50.8
SFP+_P19_RXVCC: length 17.8
  BOTTOM w0.61: CJ9.BB15 222.14,49.11 221.01,49.11 220.59,49.52 219.25,49.52 218.57,50.2 218.57,56.26 217.5,57.33 217.5,62.79
  vias: v2(217.68,65.86)
SFP+_P19_TX_DIS: length 31.4
  T14 w0.117: CJ9.BB3 225.05,49.92 222.63,47.5 222.63,46.49 227.9,41.23 227.9,40.33 232.62,35.61 238.26,35.61 v1(239.43,34.43)
  BOTTOM w0.14: U56.8 238.67,33.58 239.43,34.34 v1(239.43,34.43) R557.1
SFP+_P19_TX_FLT: length 38.9
  T18 w0.117: CJ9.BB2 229.24,46.81 229.24,45.97 230.19,45.02 230.99,45.02 232.76,43.24 240.98,43.24 243.33,40.89 243.33,39.37 247.21,35.49 252.73,35.49 v1(253.78,34.43)
  BOTTOM w0.14: R559.1 v1(253.78,34.43) 253.78,34.34 253.02,33.58 U55.8
SFP+_P19_TXVCC: length 17.7
  BOTTOM w0.61: CJ9.BB16 223.39,47.25 223.39,48.12 223.48,48.21 223.48,48.21 224.18,48.91 224.4,49.2 224.5,49.29 224.54,49.32 224.69,49.41 224.85,49.46 225.03,49.48 225.2,49.47 225.37,49.42 225.53,49.35 225.65,49.26 225.7,49.2 226.58,49.2 227.89,50.51 227.89,61.59
  vias: v2(227.58,65.1)
SFP+_P20_MOD_ABS: length 84.7
  TOP w0.14: v5(230.73,75.19) 230.92,75.37 U28.4
  T05 w0.117: CJ9.CT6 237.7,54.9 236.98,55.63 236.98,56.52 238.31,57.85 238.31,62.8 230.73,70.39 v5(230.73,75.19)
  T07 w0.117: v1(239.33,40.92) 238.4,40.92 237.71,41.61 234.1,41.61 230.79,38.31 229.32,38.31 227.06,36.05 216.02,36.05 214.69,37.38 210.06,37.38 209.1,38.34 v1(209.1,39.01)
  T16 w0.117: v1(239.33,40.92) 238.86,40.92 236.01,43.78 236.01,46.55 237.52,48.07 237.52,49.22 237.04,49.7 237.04,50.64 237.7,51.3 CJ9.CT6
  BOTTOM w0.14: U49.7 209.06,33.57 209.74,34.25 209.74,38.06 209.54,38.27 R568.1 v1(209.1,39.01) ; Q38.5 v1(239.33,40.92)
SFP+_P20_RATE_SEL: length 61
  T03 w0.117: CJ9.CT9 239.4,53.89 CJ9.CT7
  T07 w0.117: v1(191.7,37.61) 193.62,35.69 197.07,35.69 198.14,36.76 201.18,36.76 203.49,39.07 204.76,39.07 208.43,42.75 212.13,42.75 213.13,41.74 217.49,41.74 218.73,42.99 227.08,42.99 229.19,45.09 229.19,47.59 233.03,51.43 233.03,51.8 233.56,52.32 235.82,52.32 237.39,53.89 CJ9.CT7
  BOTTOM w0.14: R565.1 v1(191.7,37.61) R790.2
SFP+_P20_RATE_SEL_OUT: length 12.7
  BOTTOM w0.14: R790.1 191.7,35.19 191.46,34.96 U52.7 191.46,32.18 193.55,30.1 195.07,30.1 197.1,28.07 v2(198.5,28.07)
SFP+_P20_RX_LOS: length 79.1
  T14 w0.117: v1(281.59,18.89) 280.99,18.29 278.26,18.29 275.21,21.34 273.52,21.34 271.31,23.54 271.31,24.16 264.23,31.24 261.75,31.24 257.12,35.87 257.12,39.42 254.92,41.62 253.83,41.62 252.81,42.63 246.6,42.63 245.63,41.66 242.06,41.66 240.66,43.05 236.54,43.05 235.2,44.39 235.2,45.38 233,47.58 233,49.2 236.26,52.45 238.23,52.45 239.3,53.52 CJ9.CT8
  BOTTOM w0.14: R567.1 v1(281.59,18.89) 280.57,17.86 U50.7
SFP+_P20_RXVCC: length 8.9
  TOP w0.635: v6(237.38,62.49) 237.74,62.84 C1212.1
  P10 w0.508: v6(237.38,62.49) 238.66,61.21 238.66,58.36 237.7,57.4 237.7,56.19 CJ9.CT15
SFP+_P20_TX_DIS: length 25.2
  T03 w0.117: CJ9.CT3 234.45,53.19 232.92,51.65 232.92,47.75 234.95,45.72 234.95,42.11 v1(238.06,39.01)
  BOTTOM w0.14: v1(238.06,39.01) R564.1 238.49,38.27 238.73,38.03 238.73,34.28 238.02,33.57 U56.7
SFP+_P20_TX_FLT: length 44.1
  T14 w0.117: v1(252.09,38.99) 251.55,38.44 250.23,38.44 249.17,39.5 245.87,39.5 245.11,38.73 242.06,38.73 240.66,40.13 235.36,40.13 231.21,44.28 231.21,47.31 232.14,48.24 232.14,50.42 232.98,51.27 232.98,54.29 233.28,54.59 CJ9.CT2
  BOTTOM w0.14: U55.7 252.37,33.57 253.09,34.28 253.09,38.03 252.84,38.27 R566.1 252.41,38.68 v1(252.09,38.99)
SFP+_P20_TXVCC: length 10
  TOP w0.635: v6(231.29,62.49) 231.01,62.77 C1209.1
  P10 w0.508: v6(231.29,62.49) 233.17,62.49 235.55,60.1 235.55,58.93 236.89,57.59 CJ9.CT16
SFP+_P21_MOD_ABS: length 77.4
  TOP w0.14: U28.5 231.69,74.36 230.58,73.26 v5(229.84,73.26)
  T03 w0.117: v5(229.84,73.26) 229.84,71.66 232.26,69.25 232.26,56.78 233.63,55.41 237.24,55.41 237.71,54.95 237.71,54.23 236.9,53.42 CJ9.CB6 236.9,49.89 237.69,49.1 237.69,48.21 235.97,46.48 235.97,42.32 v1(237.36,40.92)
  T07 w0.117: v1(209.1,34.43) 210.29,35.63 227.24,35.63 229.5,37.88 232.45,37.88 235.49,40.92 v1(237.36,40.92)
  BOTTOM w0.14: U49.6 208.41,33.75 v1(209.1,34.43) R575.1 ; Q38.2 v1(237.36,40.92)
SFP+_P21_RATE_SEL: length 59.8
  T05 w0.117: CJ9.CB7 235.4,51.59 CJ9.CB9
  T07 w0.117: CJ9.CB9 234.5,50.23 231.09,46.82 231.09,45.32 226.82,41.04 226.82,40.72 224.26,38.16 210.3,38.16 209.81,38.66 209.81,39.93 209.21,40.53 206.81,40.53 204.94,38.65 203.67,38.65 201.36,36.34 198.39,36.34 197.32,35.27 193.16,35.27 v1(190.69,37.74)
  BOTTOM w0.14: R572.1 v1(190.69,37.74) R792.2
SFP+_P21_RATE_SEL_OUT: length 12.2
  BOTTOM w0.14: R792.1 190.81,35.94 U52.6 190.81,32.2 193.42,29.59 194.81,29.59 v2(197.1,27.3)
SFP+_P21_RX_LOS: length 70.3
  T14 w0.117: CJ9.CB8 236.55,50.19 237.7,49.04 237.7,48.29 236.11,46.69 236.11,44.43 236.98,43.56 240.92,43.56 242.4,42.08 245.46,42.08 246.43,43.05 252.98,43.05 254,42.04 255.1,42.04 257.54,39.59 257.54,36.05 261.92,31.66 264.41,31.66 268.79,27.28 271.68,27.28 275.46,23.5 275.46,22.87 276.81,21.52 276.81,20.87 278.98,18.71 280.4,18.71 v1(280.56,18.88)
  BOTTOM w0.14: R574.1 281.24,19.55 v1(280.56,18.88) 279.91,18.23 U50.6
SFP+_P21_RXVCC: length 16.6
  BOTTOM w0.61: CJ9.CB15 236.39,49.11 235.26,49.11 234.45,49.91 233.26,49.91 232.65,50.52 232.65,58.39 230.86,60.17 230.86,61.34
  vias: v2(229.87,65.6)
SFP+_P21_TX_DIS: length 24.9
  T03 w0.117: v1(241.91,40.05) 241.91,44.92 241.04,45.79 241.04,46.87 241.72,47.55 241.72,48.3 241,49.02 240.18,49.02 239.3,49.9 CJ9.CB3
  T16 w0.117: v1(241.91,40.05) 241.91,36.51 240.7,35.3 238.92,35.3 v1(238.06,34.43)
  BOTTOM w0.14: R571.1 v1(238.06,34.43) 237.37,33.75 U56.6
SFP+_P21_TX_FLT: length 29.8
  T03 w0.117: CJ9.CB2 241.02,50.19 243.44,47.77 243.44,45.88 242.55,44.98 242.55,37.65 244.27,35.93 248.04,35.93 250.48,33.49 251.46,33.49 v1(252.41,34.43)
  BOTTOM w0.14: U55.6 251.72,33.7 252.41,34.39 v1(252.41,34.43) R573.1
SFP+_P21_TXVCC: length 19.1
  BOTTOM w0.61: CJ9.CB16 237.64,47.25 237.64,48.12 237.73,48.21 237.73,48.21 238.43,48.91 238.65,49.2 238.75,49.29 238.79,49.32 238.94,49.41 239.1,49.46 239.28,49.48 239.45,49.47 239.62,49.42 239.78,49.35 239.9,49.26 239.95,49.2 240.83,49.2 241.74,50.11 241.74,57.75 241.13,58.36 240.31,58.36 239.35,59.32 239.35,61.66
  vias: v2(239.52,65.6)
SFP+_P22_MOD_ABS: length 102.6
  TOP w0.14: U31.4 243.22,75.37 242.9,75.05 242.9,74.32 241.91,73.33 v5(241.76,73.33)
  T05 w0.117: v5(241.76,73.33) 241.22,72.79 241.22,66.65 246.84,61.02 248.73,61.02 251.84,57.91 251.84,57.28 251.33,56.77 251.33,55.5 251.95,54.88 CJ9.DT6
  T07 w0.117: v1(207.53,34.25) 207.53,33.68 210.74,30.48 224.95,30.48 227.64,33.17 235.89,33.17 237.84,35.12 241.05,35.12 247.12,41.19 252.99,41.19 v1(253.62,40.57)
  T18 w0.117: v1(253.62,40.57) 254.02,40.97 254.02,45.6 255.96,47.55 255.96,51.23 255.54,51.65 254.69,51.65 253.88,52.47 252.68,52.47 CJ9.DT6
  BOTTOM w0.14: v1(253.62,40.57) 253.52,40.48 Q39.5 ; U49.5 207.76,34.02 v1(207.53,34.25) 207.53,34.88 R582.1
SFP+_P22_RATE_SEL: length 81.7
  T03 w0.117: CJ9.DT7 253.65,53.89 CJ9.DT9
  T07 w0.117: v1(189.67,37.61) 192.43,34.84 197.49,34.84 198.05,35.4 207.93,35.4 208.53,34.79 208.53,33.89 209.17,33.25 217.16,33.25 217.79,32.62 225.9,32.62 227.29,34.01 232.61,34.01 234.79,36.2 234.79,37.13 235.23,37.57 236.29,37.57 237.25,38.52 237.25,39.15 237.74,39.64 239.81,39.64 245.49,45.32 245.49,46.87 247.17,48.56 247.17,51.18 248.36,52.36 250.29,52.36 251.81,53.89 CJ9.DT7
  BOTTOM w0.14: R796.2 v1(189.67,37.61) R579.1
SFP+_P22_RATE_SEL_OUT: length 11.6
  BOTTOM w0.14: v2(184.86,29.52) 185.28,29.52 185.85,28.96 185.86,28.96 185.86,28.95 188.08,28.95 190.16,31.03 U52.5 190.16,35.09 189.67,35.58 R796.1
SFP+_P22_RX_LOS: length 53.6
  T14 w0.117: CJ9.DT8 253.55,52.9 254.76,51.69 255.46,51.69 257.86,49.29 258.65,49.29 259.74,48.21 259.74,45.57 260.35,44.96 260.35,43.05 264.29,39.12 264.29,35.56 270.85,29 271.95,29 272.5,28.45 276.35,28.45 280.6,24.2 v1(280.6,22.27)
  BOTTOM w0.14: U50.5 279.26,18.83 R581.1 280.52,19.61 280.62,19.71 280.62,22.24 v1(280.6,22.27)
SFP+_P22_RXVCC: length 12.2
  TOP w0.635: v6(248.62,62.31) 249.18,62.31 249.82,62.94 C1224.1
  P10 w0.508: CJ9.DT15 251.95,56.19 251.95,57.73 252.88,58.66 252.88,60.31 250.89,62.31 v6(248.62,62.31)
SFP+_P22_TX_DIS: length 30.5
  T07 w0.117: CJ9.DT3 245.95,53.19 242.95,50.19 242.95,48.16 243.38,47.73 243.38,45.71 242.78,45.11 242.78,43.39 239.52,40.13 237.45,40.13 236.68,39.36 v1(236.68,39.01)
  BOTTOM w0.14: U56.5 236.72,33.86 237.34,34.48 237.34,38.02 237.1,38.27 R578.1 v1(236.68,39.01)
SFP+_P22_TX_FLT: length 37.8
  T18 w0.117: CJ9.DT2 249.49,55.33 254.91,55.33 256.27,53.97 256.27,48.56 257.65,47.17 257.65,40.23 255.63,38.21 251.83,38.21 v1(251.03,39.01)
  BOTTOM w0.14: v1(251.03,39.01) R580.1 251.45,38.27 251.67,38.04 251.67,34.31 251.07,33.71 U55.5
SFP+_P22_TXVCC: length 11.8
  TOP w0.635: v6(247.09,62.36) 243.72,62.36 243.09,63 C1221.1
  P10 w0.508: CJ9.DT16 251.14,57.59 249.54,59.2 249.54,59.91 v6(247.09,62.36)
SFP+_P23_MOD_ABS: length 102.5
  TOP w0.14: v5(241.81,71.96) 243.76,73.92 U31.5
  T03 w0.117: CJ9.DB6 251.15,49.59 251.68,49.06 251.68,48.1 250.32,46.74 250.32,41.86 v1(251.59,40.6)
  T05 w0.117: v5(241.81,71.96) 243.72,70.05 247.26,70.05 256.36,60.95 256.36,56.46 251.49,51.59 CJ9.DB6
  T07 w0.117: v1(206.71,34.22) 206.71,33.9 210.55,30.06 227.03,30.06 227.83,30.86 238.36,30.86 241.66,34.17 241.66,35.14 246.06,39.53 248.35,39.53 249.42,40.6 v1(251.59,40.6)
  BOTTOM w0.14: v1(251.59,40.6) 251.47,40.48 Q39.2 ; U49.4 207.11,33.82 v1(206.71,34.22) 206.46,34.48 R589.1
SFP+_P23_RATE_SEL: length 83.4
  T03 w0.117: CJ9.DB7 249.65,51.59 CJ9.DB9
  T07 w0.117: CJ9.DB7 251.83,49.42 251.83,48.25 250.71,47.13 250.71,45.56 248.81,43.66 244.43,43.66 240.1,39.33 240.1,38.44 238.76,37.1 238.76,36.37 238.41,36.02 235.89,36.02 233.47,33.59 227.47,33.59 224.78,30.9 215.22,30.9 213.3,32.83 209,32.83 208.11,33.71 208.11,34.62 207.75,34.98 199.11,34.98 197.63,33.5 192.76,33.5 v1(188.65,37.61)
  BOTTOM w0.14: R797.2 v1(188.65,37.61) R586.1
SFP+_P23_RATE_SEL_OUT: length 8.9
  BOTTOM w0.14: R797.1 188.65,35.83 189.51,34.97 U52.4 189.51,31.65 187.58,29.72 v2(186.18,29.72)
SFP+_P23_RX_LOS: length 52.5
  T14 w0.117: CJ9.DB8 250.22,49.52 255.72,49.52 257.7,47.54 257.7,43.42 260.01,41.11 260.01,37.55 268.99,28.57 271.78,28.57 272.35,28 275.15,28 277.9,25.25 v1(277.9,24.39)
  BOTTOM w0.14: U50.4 278.61,18.77 278.97,19.13 R588.1 278.46,19.61 278.23,19.84 278.23,21.62 277.9,21.95 v1(277.9,24.39)
SFP+_P23_RXVCC: length 18.5
  BOTTOM w0.61: 243.1,62.34 243.1,60.52 247.14,56.48 247.14,50.2 247.75,49.59 249.02,49.59 249.5,49.11 250.64,49.11 CJ9.DB15
  vias: v2(241.68,65.1)
SFP+_P23_TX_DIS: length 36.3
  T07 w0.117: v1(235.84,34.05) 237.33,35.55 240.68,35.55 242.9,37.76 242.9,40.01 245.8,42.92 251.25,42.92 255.92,47.58 255.92,51.1 255.43,51.59 CJ9.DB3
  BOTTOM w0.14: R585.1 235.84,34.32 v1(235.84,34.05) 236.07,33.82 U56.4
SFP+_P23_TX_FLT: length 24.4
  T03 w0.117: CJ9.DB2 255.91,48.64 255.91,47.49 255.29,46.87 255.29,45.91 256.21,44.99 256.21,36.34 255.39,35.52 252.07,35.52 v1(250.8,34.25)
  BOTTOM w0.14: R587.1 251.03,34.46 250.83,34.25 v1(250.8,34.25) 250.8,34.22 250.42,33.84 U55.4
SFP+_P23_TXVCC: length 20.6
  BOTTOM w0.61: CJ9.DB16 251.89,47.25 251.89,48.12 251.98,48.21 251.98,48.21 252.43,48.66 252.44,48.66 252.67,48.89 252.9,49.2 253,49.29 253.04,49.32 253.19,49.41 253.35,49.46 253.53,49.48 253.7,49.47 253.87,49.42 254.03,49.35 254.15,49.26 254.2,49.2 255.08,49.2 256.12,50.24 256.12,57.33 255.24,58.22 254.83,58.22 251.95,61.1 251.95,62.65
  vias: v2(251.59,65.1)
SFP+_P24_MOD_ABS: length 122.6
  TOP w0.14: U34.4 254.93,75.42 v5(254.74,75.23)
  T07 w0.117: v1(209.17,23.08) 215.72,29.63 227.2,29.63 228.01,30.44 238.53,30.44 243.33,35.24 254.85,35.24 256.38,36.77 256.38,40.27 257.78,41.66 262.36,41.66 263.65,42.96 v1(267.41,42.96)
  T14 w0.117: v1(267.41,42.96) 267.41,44.81 270.25,47.65 270.25,51.34 269.85,51.74 268.91,51.74 268.19,52.46 266.93,52.46 CJ9.ET6 266.2,54.98 265.85,55.34 262.35,55.34 260.73,56.95 260.73,69.72 255.22,75.23 v5(254.74,75.23)
  BOTTOM w0.14: Q40.5 268.04,40.48 268.24,40.68 268.24,42.14 v1(267.41,42.96) ; R428.1 209.28,22.98 v1(209.17,23.08) 207.76,24.49 U49.20
SFP+_P24_RATE_SEL: length 107.1
  T03 w0.117: CJ9.ET7 267.9,53.89 CJ9.ET9
  T05 w0.117: v1(263.14,30.51) 265.68,33.05 265.68,39.12 264.8,40.01 264.8,46.86 266.06,48.13 266.06,49.15 265.43,49.78 265.43,50.42 267,51.99 CJ9.ET7
  T18 w0.117: v1(191.07,20.46) 191.07,21.72 196.1,26.75 219.16,26.75 222.96,30.55 239.28,30.55 239.65,30.17 253.4,30.17 253.73,30.51 v1(263.14,30.51)
  BOTTOM w0.14: R425.1 v1(191.07,20.46) R802.2
SFP+_P24_RATE_SEL_OUT: length 6
  BOTTOM w0.14: U52.20 190.16,25.99 190.37,25.79 190.37,24.19 v2(191.07,23.5) R802.1
SFP+_P24_RX_LOS: length 65.3
  T14 w0.117: CJ9.ET8 270.02,54.59 270.88,53.73 270.88,49.4 271.91,48.38 271.91,45.5 270.93,44.52 270.93,40.15 272.56,38.53 274.58,38.53 276.05,37.06 276.05,35.72 276.48,35.28 280.69,35.28 281.44,34.54 281.44,31.11 285.37,27.18 285.37,20.52 286.31,19.58 286.31,17.76 285.79,17.24 285.79,15.24 v1(279.67,9.13)
  BOTTOM w0.14: R427.1 280.4,8.37 279.67,9.1 v1(279.67,9.13) 279.26,9.53 U50.20
SFP+_P24_RXVCC: length 12.8
  TOP w0.635: v1(261.47,62.66) 261.93,63.13 261.98,63.13 C1092.1
  P10 w0.508: CJ9.ET15 266.2,57.82 267.06,58.67 267.06,60.54 264.93,62.66 v1(261.47,62.66)
SFP+_P24_TX_DIS: length 60
  T05 w0.117: CJ9.ET3 263.8,51.2 261.37,48.77 261.37,47.62 264.29,44.7 264.29,32.77 261.49,29.97 v1(261.49,29.21)
  T18 w0.117: v1(261.49,29.21) 259.92,29.21 259.19,28.48 252.56,28.48 249.4,25.33 240.88,25.33 v1(237.67,22.12)
  BOTTOM w0.14: U56.20 236.72,24.06 v2(237.23,23.55) 237.67,23.1 v1(237.67,22.12) R424.1
SFP+_P24_TX_FLT: length 41.7
  T05 w0.117: v1(252.46,23.13) 252.46,29.19 256.67,33.4 256.67,44.45 257.66,45.45 257.66,50.66 261.59,54.59 CJ9.ET2
  BOTTOM w0.14: U55.20 251.07,24.94 v2(251.86,24.16) 252.46,23.56 v1(252.46,23.13) R426.1
SFP+_P24_TXVCC: length 13.8
  TOP w0.762: v1(257.94,62.54) 256.29,62.54 255.25,63.57 C1089.1
  P10 w0.508: CJ9.ET16 264.11,58.88 264.11,60.09 262.99,61.21 259.26,61.21 v1(257.94,62.54)
SFP+_P25_MOD_ABS: length 114.1
  TOP w0.14: U34.5 255.93,74.54 255.48,74.09 v5(255.38,74.09)
  T03 w0.117: CJ9.EB6 265.4,49.81 266.06,49.15 266.06,48.14 264.77,46.85 264.77,43.79 v1(266.28,42.28)
  T07 w0.117: v1(266.28,42.28) 263.58,42.28 260.86,39.56 260.86,39.06 254.71,32.91 249.89,32.91 247.98,34.82 243.51,34.82 238.71,30.02 228.18,30.02 227.37,29.21 216.68,29.21 v1(210.49,23.03)
  T14 w0.117: CJ9.EB6 264.54,52.45 262.38,52.45 261.37,53.47 261.37,55.63 260.1,56.9 260.1,69.37 v5(255.38,74.09)
  BOTTOM w0.14: Q40.2 266.14,40.48 266.28,40.61 v1(266.28,42.28) ; U49.19 208.41,25.11 v1(210.49,23.03) 210.65,22.87 R435.1
SFP+_P25_RATE_SEL: length 98.8
  T03 w0.117: CJ9.EB7 263.9,51.59 CJ9.EB9
  T05 w0.117: CJ9.EB9 261.77,51.59 259.71,49.53 259.71,46.61 257.22,44.11 257.22,29.83 v1(257.14,29.75)
  T18 w0.117: v1(257.14,29.75) 239.48,29.75 239.1,30.13 223.13,30.13 219.34,26.33 196.27,26.33 192.08,22.14 v1(192.08,20.46)
  BOTTOM w0.14: R803.2 v1(192.08,20.46) R432.1
SFP+_P25_RATE_SEL_OUT: length 6.1
  BOTTOM w0.14: U52.19 190.81,25.54 v2(191.33,25.02) 192.08,24.27 R803.1
SFP+_P25_RX_LOS: length 59.5
  T16 w0.117: CJ9.EB8 262.89,50.19 261.49,48.79 261.49,47.44 263.52,45.41 263.52,39.41 264.29,38.64 264.29,30.61 263.4,29.72 263.4,21.72 265.11,20 267.78,20 268.9,18.89 272.99,18.89 280.98,10.9 v1(280.98,8.91)
  BOTTOM w0.14: R434.1 281.77,8.12 v1(280.98,8.91) 279.91,9.98 U50.19
SFP+_P25_RXVCC: length 19.4
  BOTTOM w0.61: 255.16,62.28 257.28,60.16 257.28,57.05 261.31,53.02 261.31,50.2 261.92,49.59 263.27,49.59 263.75,49.11 264.89,49.11 CJ9.EB15
  vias: v2(254,62.3)
SFP+_P25_TX_DIS: length 59.2
  T16 w0.117: CJ9.EB3 267.8,49.87 264.08,46.15 264.08,39.57 265.56,38.1 265.56,30.78 v1(264.08,29.31)
  T18 w0.117: v1(239.05,22.12) 239.86,22.93 247.76,22.93 251.95,27.12 261.89,27.12 v1(264.08,29.31)
  BOTTOM w0.14: U56.19 237.37,24.73 239.05,23.05 v1(239.05,22.12) R431.1
SFP+_P25_TX_FLT: length 46
  T16 w0.117: v1(253.83,23.13) 253.83,30.59 257.31,34.07 257.31,44.04 259.63,46.36 259.63,49.4 262.56,52.32 268.1,52.32 268.6,51.82 CJ9.EB2
  BOTTOM w0.14: U55.19 251.72,25.63 253.83,23.52 v1(253.83,23.13) R433.1
SFP+_P25_TXVCC: length 22.7
  BOTTOM w0.61: CJ9.EB16 266.14,47.25 266.14,48.12 266.23,48.21 266.23,48.21 266.93,48.91 267.15,49.2 267.25,49.29 267.29,49.32 267.44,49.41 267.6,49.46 267.78,49.48 267.95,49.47 268.12,49.42 268.28,49.35 268.4,49.26 268.97,49.26 270.29,50.58 270.29,57.33 269.03,58.59 264.88,58.59 263.53,59.95 263.53,61.76
  vias: v2(263.78,65.86)
SFP+_P26_MOD_ABS: length 127.1
  TOP w0.14: v5(269.73,75.05) 270.1,75.42 U37.4
  T07 w0.117: v1(278.51,42.53) 278.06,42.08 272.05,42.08 270.96,40.99 264.41,40.99 262.45,39.03 261.43,39.03 254.88,32.48 246.78,32.48 243.89,29.6 240.51,29.6 238.33,27.42 231.62,27.42 230.69,28.35 219.34,28.35 217.6,26.6 215.06,26.6 v1(211.68,23.22) ; CJ9.FT6 280.45,54.67 279.94,55.18 277,55.18 274.62,57.56 274.62,67.5 270.67,71.46 270.67,74.1 v5(269.73,75.05)
  T16 w0.117: v1(278.51,42.53) 278.51,46.23 280.42,48.13 280.42,49.05 279.68,49.79 279.68,50.57 280.45,51.34 CJ9.FT6
  BOTTOM w0.14: R442.1 212.02,22.88 v1(211.68,23.22) 211.28,23.22 209.06,25.43 U49.18 ; Q41.5 279.4,40.48 279.55,40.62 279.55,41.92 278.94,42.53 v1(278.51,42.53)
SFP+_P26_RATE_SEL: length 118.6
  T14 w0.117: CJ9.FT9 282.15,53.89 CJ9.FT7
  T16 w0.117: v1(271.57,30.6) 273.01,30.6 274.55,32.15 274.55,41.7 273.99,42.26 273.99,47.59 275.5,49.1 275.5,51.41 276.52,52.44 278.66,52.44 280.11,53.89 CJ9.FT7
  T18 w0.117: v1(193.1,20.46) 193.1,21.99 197.02,25.91 220.01,25.91 221.97,27.88 238.9,27.88 239.97,26.8 250.08,26.8 252.18,28.91 259.02,28.91 259.93,29.82 263.56,29.82 264.34,30.6 v1(271.57,30.6)
  BOTTOM w0.14: R439.1 v1(193.1,20.46) R804.2
SFP+_P26_RATE_SEL_OUT: length 6.3
  BOTTOM w0.14: R804.1 v2(193.1,23.5) 193.1,24.56 191.46,26.2 U52.18
SFP+_P26_RX_LOS: length 58.9
  T05 w0.117: v1(282.8,9.11) 283.72,10.03 283.72,17.4 285.12,18.8 285.12,22.99 284.73,23.37 284.73,32.34 287.06,34.66 287.06,37.42 288.71,39.07 288.71,40.69 287.19,42.21 287.19,44.74 288.54,46.1 288.54,51.05 285.01,54.59 CJ9.FT8
  BOTTOM w0.14: U50.18 280.57,10.04 280.93,9.68 281.3,9.68 281.86,9.11 v1(282.8,9.11) 283.14,8.77 R441.1
SFP+_P26_RXVCC: length 14.6
  TOP w0.635: v1(273.7,62.78) 274.06,63.14 C1104.1
  P10 w0.508: CJ9.FT15 280.45,57.78 281.4,58.72 281.4,60.25 280.56,61.09 275.39,61.09 v1(273.7,62.78)
SFP+_P26_TX_DIS: length 80.5
  T05 w0.117: v1(274.83,22.05) 274.83,25.01 276.99,27.17 276.99,34.67 277.24,34.92 277.24,37.59 278.63,38.98 278.63,41.14 279.53,42.04 279.53,43.05 278.89,43.69 278.89,46.61 280.42,48.13 280.42,49.15 279.78,49.78 279.78,50.67 280.42,51.31 280.42,52.07 279.3,53.19 CJ9.FT3
  T18 w0.117: v1(274.83,22.05) 272.36,22.05 269.88,19.57 264.41,19.57 262.82,17.98 258.93,17.98 258.04,18.87 244.47,18.87 242.05,21.29 241.25,21.29 v1(240.42,22.12)
  BOTTOM w0.14: U56.18 238.02,25.11 240.42,22.71 v1(240.42,22.12) R438.1
SFP+_P26_TX_FLT: length 54.7
  T05 w0.117: v1(274.19,30.73) 274.6,31.14 274.6,37.94 273.94,38.61 273.94,47.88 275.34,49.28 275.34,54.1 275.82,54.59 CJ9.FT2
  T18 w0.117: v1(274.19,30.73) 273.82,30.36 272.42,30.36 271.76,29.7 265.63,29.7 262.46,26.52 258.6,26.52 v1(255.2,23.13)
  BOTTOM w0.14: U55.18 252.37,25.7 253.61,24.46 254.24,24.46 255.2,23.49 v1(255.2,23.13) R440.1
SFP+_P26_TXVCC: length 15.6
  TOP w0.635: v1(267.61,62.78) 267.33,63.06 C1101.1
  P10 w0.508: CJ9.FT16 278.68,58.57 274.68,58.57 270.46,62.78 v1(267.61,62.78)
SFP+_P27_MOD_ABS: length 131.1
  TOP w0.14: U37.5 270.8,74.5 v5(270.05,73.76)
  T07 w0.117: v5(270.05,73.76) 270.05,71.1 272.08,69.06 272.08,62.97 274.2,60.85 274.2,57.46 275.59,56.07 275.59,53.05 276.23,52.41 278.83,52.41 CJ9.FB6 ; v1(281.56,40.73) 278.81,40.73 277.88,41.66 272.32,41.66 271.07,40.41 265.88,40.41 264.21,38.75 264.21,34.04 256.86,26.68 249.02,26.68 245.3,22.96 242.92,22.96 242.37,23.51 236.7,23.51 235.62,22.43 228.75,22.43 227.21,23.97 218.2,23.97 216.76,22.53 v1(213.3,22.53)
  T14 w0.117: CJ9.FB6 279.65,49.91 280.42,49.15 280.42,48.26 279.75,47.59 279.75,46.74 282.37,44.12 282.37,41.54 v1(281.56,40.73)
  BOTTOM w0.14: Q41.2 281.42,40.48 281.56,40.61 v1(281.56,40.73) ; U49.17 209.71,25.49 210.95,24.25 211.59,24.25 213.3,22.54 v1(213.3,22.53) R449.1
SFP+_P27_RATE_SEL: length 127
  T03 w0.117: CJ9.FB7 280.37,49.37 285.12,49.37 286.26,48.23 286.26,42.71 285.67,42.12 285.67,35.04 277.05,26.41 250.24,26.41 241.86,18.03 212.53,18.03 210.32,15.83 206.47,15.83 203.66,18.63 196.14,18.63 v1(194.3,20.46)
  T07 w0.117: CJ9.FB7 278.15,51.59 CJ9.FB9
  BOTTOM w0.14: R446.1 194.11,20.2 194.3,20.39 v1(194.3,20.46) 194.3,20.61 194.11,20.8 R806.2
SFP+_P27_RATE_SEL_OUT: length 6.4
  BOTTOM w0.14: U52.17 192.11,26.59 v2(193.93,24.77) 194.11,24.59 R806.1
SFP+_P27_RX_LOS: length 59.3
  T05 w0.117: CJ9.FB8 277.39,50.19 275.72,48.51 275.72,47.62 277.62,45.71 277.62,40.64 275.84,38.86 275.84,34.92 276.28,34.49 276.28,27.24 274.07,25.02 274.07,13.59 279.53,8.13 283.48,8.13 v1(284.42,9.06)
  BOTTOM w0.14: R448.1 v1(284.42,9.06) 283.51,9.97 281.64,9.97 281.22,10.39 U50.17
SFP+_P27_RXVCC: length 20.8
  BOTTOM w0.61: 267.49,61.96 268.25,61.2 269.93,61.2 271.17,59.96 271.17,57.32 275.53,52.96 275.53,50.22 276.17,49.59 277.52,49.59 278,49.11 279.14,49.11 CJ9.FB15
  vias: v2(266.06,65.6)
SFP+_P27_TX_DIS: length 82.1
  T05 w0.117: v1(276.05,23.27) 276.05,24.25 286.64,34.84 286.64,37.59 288.29,39.24 288.29,40.51 286.77,42.04 286.77,44.96 288.07,46.27 288.07,47.84 284.32,51.59 CJ9.FB3
  T18 w0.117: v1(241.82,22.15) 244.64,19.34 257.92,19.34 261.52,22.94 275.72,22.94 v1(276.05,23.27)
  BOTTOM w0.14: R445.1 v1(241.82,22.15) 238.67,25.3 U56.17
SFP+_P27_TX_FLT: length 59.2
  T05 w0.117: v1(278.33,29.82) 281.03,29.82 286.13,34.93 286.13,48.76 284.71,50.19 CJ9.FB2
  T18 w0.117: v1(278.33,29.82) 278.22,29.93 272.63,29.93 271.91,29.21 265.78,29.21 259.31,22.74 v1(257.29,22.74)
  BOTTOM w0.14: v1(257.29,22.74) 256.91,22.36 R447.1 256.35,23.4 254.59,25.16 253.65,25.16 253.02,25.79 U55.17
SFP+_P27_TXVCC: length 26.4
  BOTTOM w0.61: CJ9.FB16 280.39,47.25 280.39,48.12 280.48,48.21 280.48,48.21 281.18,48.91 281.4,49.2 281.5,49.29 281.54,49.32 281.69,49.41 281.85,49.46 282.03,49.48 282.2,49.47 282.37,49.42 282.53,49.35 282.65,49.26 282.7,49.2 283.58,49.2 284.7,50.32 284.7,53.16 285.2,53.67 285.2,60.3 284.26,61.24 276.97,61.24 276.11,62.11
  vias: v2(275.81,63.1)
SFP+_PWR_OC_GP1: length 89.2
  TOP w0.14: v1(118.54,82.25) 118.54,80.32 118.13,79.91 R628.2 R627.2 R625.2 ; R623.1 115.88,80.54 R625.2 ; R624.2 R625.2 ; U70.L5 v4(113.2,124.05)
  T03 w0.117: v4(113.2,124.05) 113.6,123.65 113.6,122.08 112.92,121.39 112.92,113.86 119.82,106.96 131.76,106.96 132.08,106.64 138.01,106.64 140.88,103.76 140.88,95.82 140.26,95.2 139.17,95.2 138.37,94.4 138.37,89.44 135.04,86.11 122.4,86.11 v1(118.54,82.25)
SFP+_PWR_OC_GP2: length 82.9
  TOP w0.14: U70.N9 116.9,122.76 116.9,121.78 v4(116.59,121.47) ; v1(152.53,81.41) 154.31,79.63 158.88,79.63 160.5,78.01 161.34,78.01 R1569.1 161.85,78.01 R629.2 R630.2 R631.2 164.34,78.05 164.34,78.98 R632.2
  T03 w0.117: v4(116.59,121.47) 116.59,120.02 117.01,119.59 118.08,119.59 119.46,118.21 119.46,116.38 125.04,110.8 140.16,110.8 148.16,102.8 148.16,94.05 146.63,92.53 v1(146.63,91.43)
  T05 w0.117: v1(152.53,81.41) 151.13,81.41 149.48,83.06 149.48,84.79 145.86,88.41 145.86,90.67 v1(146.63,91.43)
SFP+_PWR_OC_GP3: length 127.3
  TOP w0.14: v1(223.27,82.05) 224.31,81 R635.1 R633.2 R636.2 ; U70.M13 v4(120.4,123.25)
  T03 w0.117: v1(223.27,82.05) 222.91,82.41 185.23,82.41 178.6,89.04 173.98,89.04 165.86,97.16 165.86,98.4 154.96,109.29 154.96,109.29 154.7,109.55 149.22,109.55 144.59,114.17 142.25,114.17 141.9,114.17 141.9,114.17 126.58,114.17 122.94,117.82 122.94,119.89 121.28,121.54 121.28,122.37 v4(120.4,123.25)
SFP_PWR00_OC_N: length 26.7
  TOP w0.14: R624.1 114.34,80.72 112.39,78.78 111.87,78.25 105.22,78.25 94.89,78.25 v1(94.16,77.52) U26.10 ; U26.6 94.16,74.55 v1(93.92,74.3)
  BOTTOM w0.14: v1(93.92,74.3) 94.16,74.55 v1(94.16,77.52)
SFP_PWR01_OC_N: length 15.1
  TOP w0.14: U29.10 106.97,76.87 107.26,77.16 v1(107.95,77.16) 111.66,77.16 113.6,79.1 R625.1 ; U29.6 106.24,74.35 v1(106.11,74.21)
  BOTTOM w0.14: v1(107.95,77.16) 107.11,76.32 106.93,76.32 106.59,75.98 106.59,75.8 106.11,75.32 v1(106.11,74.21)
SFP_PWR02_OC_N: length 7.5
  TOP w0.14: v1(118.09,73.89) 118.32,74.12 U32.6 ; R627.1 116.9,78.69 v1(118.08,77.51) 118.32,77.27 U32.10
  BOTTOM w0.14: v1(118.08,77.51) 118.09,77.5 v1(118.09,73.89)
SFP_PWR03_OC_N: length 18.3
  TOP w0.14: U35.6 130.39,74.2 v1(130.18,73.99) ; R628.1 128.74,79.1 v1(130.36,77.47) 130.39,77.44 U35.10
  BOTTOM w0.14: v1(130.18,73.99) 130.3,74.11 130.3,77.41 v1(130.36,77.47)
SFP_PWR04_OC_N: length 21.9
  TOP w0.14: U38.6 146.34,74.65 146.19,74.51 v1(146.19,74.3) ; U38.10 146.34,77.63 v1(146.43,77.73) 146.54,77.73 147.43,78.62 159.26,78.62 160.68,77.19 161.78,77.19 R629.1
  BOTTOM w0.14: v1(146.43,77.73) 146.19,77.49 v1(146.19,74.3)
SFP_PWR05_OC_N: length 10.3
  TOP w0.14: U27.6 158.41,74.47 v1(158.12,74.17) ; U27.10 v1(158.41,77.45) 159.8,77.45 160.63,76.61 162.73,76.61 R630.1
  BOTTOM w0.14: v1(158.12,74.17) 158.12,77.16 v1(158.41,77.45)
SFP_PWR06_OC_N: length 11.9
  TOP w0.14: U30.6 170.49,74.48 v1(170.18,74.17) ; U30.10 v1(170.49,77.52) 169.71,78.31 165.81,78.31 164.7,77.19 164.42,77.19 R631.1
  BOTTOM w0.14: v1(170.18,74.17) 170.18,77.21 v1(170.49,77.52)
SFP_PWR07_OC_N: length 22.9
  TOP w0.14: R632.1 181.09,79.01 v1(182.57,77.52) U33.10
  TOP w0.305: v1(182.37,74.17) 182.57,74.37 U33.6
  BOTTOM w0.14: v1(182.57,77.52) 182.37,77.33 v1(182.37,74.17)
SFP_PWR08_OC_N: length 19.9
  TOP w0.14: R633.1 224.25,78.46 211.38,78.46 v1(210.44,77.52) U36.10 ; U36.6 210.44,74.5 v1(210.19,74.24)
  BOTTOM w0.14: v1(210.44,77.52) 210.19,77.27 v1(210.19,74.24)
SFP_PWR09_OC_N: length 9.1
  TOP w0.14: U39.6 222.52,74.51 v1(222.25,74.24) ; U39.10 v1(222.52,77.52) 224.58,77.52 R636.1
  BOTTOM w0.14: v1(222.52,77.52) 222.25,77.25 v1(222.25,74.24)
SFP_PWR10_OC_N: length 12.7
  TOP w0.14: v1(234.31,74.22) 234.6,74.5 U28.6 ; R637.1 228.42,78.36 233.96,78.36 v1(234.6,77.73) U28.10
  BOTTOM w0.14: v1(234.6,77.73) 234.6,74.5 v1(234.31,74.22)
SFP_PWR11_OC_N: length 23.7
  TOP w0.14: U31.10 v1(246.67,77.75) 245.33,79.1 R638.1 ; v1(246.48,74.17) 246.67,74.37 U31.6
  BOTTOM w0.14: v1(246.48,74.17) 246.73,74.42 246.73,77.69 v1(246.67,77.75)
SFP_PWR12_OC_N: length 18
  TOP w0.14: v1(258.6,74.19) 258.84,74.42 U34.6
  TOP w0.305: v1(258.84,77.57) U34.10
  BOTTOM w0.14: R639.1 271.27,77.57 v1(258.84,77.57) 258.84,76.01 v2(258.95,75.89) 258.95,75.06 258.6,74.71 v1(258.6,74.19)
SFP_PWR13_OC_N: length 7.7
  TOP w0.14: U37.10 274.27,76.92 274.57,77.22 v1(274.57,77.47) ; U37.6 274.17,74.92 v1(274.53,74.55)
  BOTTOM w0.14: R640.1 273.25,77.95 274.09,77.95 v1(274.57,77.47) 274.57,77.09 274.07,76.58 274.07,75.02 v1(274.53,74.55)
SFP_PWR_ILIM00: length 3.8
  TOP w0.14: v5(95,74.37) 95,74.95 94.57,75.37 U26.7
  BOTTOM w0.14: v5(95,74.37) 94.35,73.72 93.27,73.72 R606.1
SFP_PWR_ILIM01: length 4.2
  TOP w0.14: v5(107.17,74.68) 107.17,74.68 107.17,75 106.79,75.37 U29.7
  BOTTOM w0.14: R609.1 105.54,73.54 106.49,73.54 107.17,74.22 107.17,74.68 v5(107.17,74.68)
SFP_PWR_ILIM02: length 4.2
  TOP w0.14: v5(119.15,73.91) 119.15,74.84 118.87,75.12 U32.7
  BOTTOM w0.14: v5(119.15,73.91) 118.46,73.22 117.67,73.22 R612.1
SFP_PWR_ILIM03: length 3.9
  TOP w0.14: v5(131.15,73.97) 131.15,74.95 130.98,75.12 U35.7
  BOTTOM w0.14: v5(131.15,73.97) 130.51,73.33 129.64,73.33 R615.1
SFP_PWR_ILIM04: length 3.9
  TOP w0.14: v5(147.15,74.28) 147.09,74.34 147.09,75.07 146.79,75.37 U38.7
  BOTTOM w0.14: v5(147.15,74.28) 146.46,73.59 145.58,73.59 R618.1
