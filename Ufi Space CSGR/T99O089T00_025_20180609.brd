# Allegro board T99O089T00_025_20180609.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R687  4.7Kohm  [R-0402S0]  126.44 36.58 180 bottom
R688  4.7Kohm  [R-0402S0]  184.97 36.52 180 bottom
R689  0ohm  [R-0402S0]  128.91 19.71 0 bottom
R690  0ohm  [R-0402S0]  188.65 21.73 0 bottom
R691  0ohm  [R-0402S0]  127.77 19.71 0 bottom
R692  4.7Kohm  [R-0402S0]  130.31 19.71 0 bottom
R693  4.7Kohm  [R-0402S0]  128.72 36.58 180 bottom
R694  4.7Kohm  [R-0402S0]  129.74 36.58 180 bottom
R695  0ohm  [R-0402S0]  187.38 21.73 0 bottom
R696  4.7Kohm  [R-0402S0]  189.67 19.19 0 bottom
R697  4.7Kohm  [R-0402S0]  186.24 36.52 180 bottom
R698  4.7Kohm  [R-0402S0]  187.58 36.47 180 bottom
R699  4.7Kohm  [R-0402S0]  130.43 22.23 180 bottom
R700  4.7Kohm  [R-0402S0]  127.76 36.58 0 bottom
R701  4.7Kohm  [R-0402S0]  130.12 39.7 0 bottom
R702  4.7Kohm  [R-0402S0]  190.05 21.73 180 bottom
R703  4.7Kohm  [R-0402S0]  186.6 38.8 0 bottom
R704  4.7Kohm  [R-0402S0]  187.64 38.75 0 bottom
R705  4.7Kohm  [R-0402S0]  114.02 36.58 180 bottom
R706  4.7Kohm  [R-0402S0]  99.97 36.58 180 bottom
R707  0ohm  [R-0402S0]  116.92 21.59 0 bottom
R708  0ohm  [R-0402S0]  100.37 29.38 270 bottom
R709  0ohm  [R-0402S0]  115.78 21.59 0 bottom
R710  4.7Kohm  [R-0402S0]  118.34 21.59 0 bottom
R711  4.7Kohm  [R-0402S0]  115.27 36.58 180 bottom
R712  4.7Kohm  [R-0402S0]  117.69 39.78 270 bottom
R713  0ohm  [R-0402S0]  100.37 28.14 270 bottom
R714  4.7Kohm  [R-0402S0]  101.5 24.13 0 bottom
R715  4.7Kohm  [R-0402S0]  101.22 36.58 180 bottom
R716  4.7Kohm  [R-0402S0]  103.02 38.87 180 bottom
R717  4.7Kohm  [R-0402S0]  116.92 24.13 180 bottom
R718  4.7Kohm  [R-0402S0]  116.41 36.58 0 bottom
R719  4.7Kohm  [R-0402S0]  117.78 36.58 0 bottom
R720  4.7Kohm  [R-0402S0]  102.88 24.13 180 bottom
R721  4.7Kohm  [R-0402S0]  102.36 36.58 0 bottom
R722  4.7Kohm  [R-0402S0]  103.74 36.58 0 bottom
R723  4.7Kohm  [R-0402S0]  245.89 35.58 180 bottom
R724  4.7Kohm  [R-0402S0]  231.54 35.58 180 bottom
R725  0ohm  [R-0402S0]  248.37 21.9 0 bottom
R726  0ohm  [R-0402S0]  233.64 21.01 0 bottom
R727  0ohm  [R-0402S0]  247.11 21.94 0 bottom
R728  0ohm  [R-0402S0]  232.38 20.95 0 bottom
R729  4.7Kohm  [R-0402S0]  249.71 21.99 0 bottom
R730  4.7Kohm  [R-0402S0]  247.14 35.58 180 bottom
R731  4.7Kohm  [R-0402S0]  248.94 37.86 180 bottom
R732  4.7Kohm  [R-0402S0]  234.92 20.97 0 bottom
R733  4.7Kohm  [R-0402S0]  232.79 35.58 180 bottom
R734  4.7Kohm  [R-0402S0]  235.73 37.86 180 bottom
R735  4.7Kohm  [R-0402S0]  251.08 21.99 180 bottom
R736  4.7Kohm  [R-0402S0]  248.28 35.48 0 bottom
R737  4.7Kohm  [R-0402S0]  249.66 35.58 0 bottom
R738  4.7Kohm  [R-0402S0]  236.3 20.97 180 bottom
R739  4.7Kohm  [R-0402S0]  233.93 35.58 0 bottom
R740  4.7Kohm  [R-0402S0]  235.31 35.58 0 bottom
R741  4.7Kohm  [R-0402S0]  261.13 35.58 180 bottom
R742  4.7Kohm  [R-0402S0]  101.78 197.54 180 bottom
R743  0ohm  [R-0402S0]  262.11 20.88 0 bottom
R744  0ohm  [R-0402S0]  100.68 192.46 0 bottom
R745  0ohm  [R-0402S0]  261.06 20.92 0 bottom
R746  4.7Kohm  [R-0402S0]  262.66 23 0 bottom
R747  4.7Kohm  [R-0402S0]  262.38 35.58 180 bottom
R748  4.7Kohm  [R-0402S0]  264.18 37.86 180 bottom
R749  0ohm  [R-0402S0]  101.83 192.46 0 bottom
R750  4.7Kohm  [R-0402S0]  96.75 192.84 180 bottom
R751  4.7Kohm  [R-0402S0]  99.65 197.54 180 bottom
R752  4.7Kohm  [R-0402S0]  98.58 197.54 180 bottom
R753  4.7Kohm  [R-0402S0]  264.04 23 180 bottom
R754  4.7Kohm  [R-0402S0]  263.52 35.58 0 bottom
R755  4.7Kohm  [R-0402S0]  264.9 35.58 0 bottom
R756  4.7Kohm  [R-0402S0]  97.84 192.84 0 bottom
R757  4.7Kohm  [R-0402S0]  100.72 197.54 0 bottom
R758  4.7Kohm  [R-0402S0]  97.51 197.54 0 bottom
R759  150ohm  [R-0402S0]  135.13 36.58 180 bottom
R761  150ohm  [R-0402S0]  138.18 36.58 180 bottom
R762  150ohm  [R-0402S0]  137.16 36.58 180 bottom
R763  150ohm  [R-0402S0]  136.14 36.58 180 bottom
R765  150ohm  [R-0402S0]  134.11 36.58 180 bottom
R767  150ohm  [R-0402S0]  133.1 36.58 180 bottom
R769  150ohm  [R-0402S0]  132.08 36.58 180 bottom
R772  150ohm  [R-0402S0]  131.06 36.58 180 bottom
R773  150ohm  [R-0402S0]  131.45 22.23 0 bottom
R774  150ohm  [R-0402S0]  132.46 22.23 0 bottom
R775  150ohm  [R-0402S0]  133.78 22.24 0 bottom
R776  150ohm  [R-0402S0]  134.8 22.24 0 bottom
R777  150ohm  [R-0402S0]  135.82 22.24 0 bottom
R778  150ohm  [R-0402S0]  136.83 22.24 0 bottom
R779  150ohm  [R-0402S0]  137.85 22.24 0 bottom
R780  150ohm  [R-0402S0]  138.91 19.69 0 bottom
R781  22.6Kohm  [R-0402S0]  67.87 181.02 90 top
R782  1Kohm  [R-0402S0]  67.87 182.07 270 top
R783  10Kohm  [R-0402S0]  64.95 179.57 0 top
R784  10Kohm  [R-0402S0]  66.75 183.73 0 top
R785  150ohm  [R-0402S0]  192.72 36.47 180 bottom
R786  150ohm  [R-0402S0]  195.77 36.21 180 bottom
R787  150ohm  [R-0402S0]  194.75 36.21 180 bottom
R788  150ohm  [R-0402S0]  193.73 36.47 180 bottom
R790  150ohm  [R-0402S0]  191.7 36.47 180 bottom
R791  0ohm  [R-0402S0]  62.64 184.86 270 top
R792  150ohm  [R-0402S0]  190.69 36.47 180 bottom
R793  33ohm  [R-0402S0]  67.36 179.57 0 top
R794  33ohm  [R-0402S0]  67.77 183.73 180 top
R795  4.7Kohm  [R-0402S0]  64.84 173.33 180 top
R796  150ohm  [R-0402S0]  189.67 36.47 180 bottom
R797  150ohm  [R-0402S0]  188.65 36.47 180 bottom
R802  150ohm  [R-0402S0]  191.07 21.73 0 bottom
R803  150ohm  [R-0402S0]  192.08 21.73 0 bottom
R804  150ohm  [R-0402S0]  193.1 21.73 0 bottom
R806  150ohm  [R-0402S0]  194.11 21.73 0 bottom
R821  150ohm  [R-0402S0]  108.58 137.79 0 top
R822  150ohm  [R-0402S0]  105.54 137.54 0 top
R826  4.7Kohm  [R-0402S0]  89.98 24.13 0 bottom
R827  4.7Kohm  [R-0402S0]  91.35 24.13 0 bottom
R828  4.7Kohm  [R-0402S0]  92.73 24.13 0 bottom
R829  4.7Kohm  [R-0402S0]  93.85 21.12 180 bottom
R830  4.7Kohm  [R-0402S0]  94.1 24.13 0 bottom
R831  4.7Kohm  [R-0402S0]  95.22 21.12 180 bottom
R832  4.7Kohm  [R-0402S0]  95.47 24.13 0 bottom
R833  4.7Kohm  [R-0402S0]  96.59 21.12 180 bottom
R834  4.7Kohm  [R-0402S0]  94.61 38.87 0 bottom
R835  4.7Kohm  [R-0402S0]  94.61 36.58 180 bottom
R836  4.7Kohm  [R-0402S0]  93.23 36.58 180 bottom
R837  4.7Kohm  [R-0402S0]  93.23 38.87 0 bottom
R838  4.7Kohm  [R-0402S0]  91.86 36.58 180 bottom
R839  4.7Kohm  [R-0402S0]  91.86 38.87 0 bottom
R840  4.7Kohm  [R-0402S0]  90.48 36.58 180 bottom
R841  4.7Kohm  [R-0402S0]  90.48 38.87 0 bottom
R842  4.7Kohm  [R-0402S0]  88.6 24.13 0 bottom
R843  0ohm  [R-0402S0]  86.11 21.12 0 bottom
R844  4.7Kohm  [R-0402S0]  89.11 40.78 180 bottom
R845  4.7Kohm  [R-0402S0]  86.36 36.58 180 bottom
R846  0ohm  [R-0402S0]  87.36 21.12 0 bottom
R847  4.7Kohm  [R-0402S0]  87.23 24.13 180 bottom
R848  4.7Kohm  [R-0402S0]  89.11 38.99 180 bottom
R849  4.7Kohm  [R-0402S0]  87.76 36.58 0 bottom
R850  4.7Kohm  [R-0402S0]  161.3 24.13 0 bottom
R851  4.7Kohm  [R-0402S0]  162.67 24.13 0 bottom
R852  4.7Kohm  [R-0402S0]  164.04 24.13 0 bottom
R853  4.7Kohm  [R-0402S0]  165.16 21.12 180 bottom
R854  4.7Kohm  [R-0402S0]  165.42 24.13 0 bottom
R855  4.7Kohm  [R-0402S0]  166.54 21.12 180 bottom
R856  4.7Kohm  [R-0402S0]  167.81 21.09 0 bottom
R857  4.7Kohm  [R-0402S0]  169.2 20.62 0 bottom
R858  4.7Kohm  [R-0402S0]  165.93 38.87 0 bottom
R859  4.7Kohm  [R-0402S0]  165.93 36.58 180 bottom
R860  4.7Kohm  [R-0402S0]  164.55 36.58 180 bottom
R861  4.7Kohm  [R-0402S0]  164.55 38.87 0 bottom
R862  4.7Kohm  [R-0402S0]  163.18 36.58 180 bottom
R863  4.7Kohm  [R-0402S0]  163.18 38.87 0 bottom
R864  4.7Kohm  [R-0402S0]  161.8 36.58 180 bottom
R865  4.7Kohm  [R-0402S0]  161.8 38.87 0 bottom
R866  0ohm  [R-0402S0]  156.92 21.12 0 bottom
R867  4.7Kohm  [R-0402S0]  159.92 24.13 0 bottom
R868  4.7Kohm  [R-0402S0]  159.08 38.99 0 bottom
R869  4.7Kohm  [R-0402S0]  157.68 36.58 180 bottom
R870  0ohm  [R-0402S0]  158.29 21.12 0 bottom
R871  4.7Kohm  [R-0402S0]  158.55 24.13 180 bottom
R872  4.7Kohm  [R-0402S0]  160.43 38.99 180 bottom
R873  4.7Kohm  [R-0402S0]  159.08 36.58 0 bottom
R874  4.7Kohm  [R-0402S0]  222.72 23.84 0 bottom
R875  4.7Kohm  [R-0402S0]  223.84 23.84 0 bottom
R876  4.7Kohm  [R-0402S0]  224.83 23.84 0 bottom
R877  4.7Kohm  [R-0402S0]  225.8 21.01 180 bottom
R878  4.7Kohm  [R-0402S0]  226.2 23.84 0 bottom
R879  4.7Kohm  [R-0402S0]  229.18 28.92 90 bottom
R880  4.7Kohm  [R-0402S0]  228.31 21.1 0 bottom
R881  4.7Kohm  [R-0402S0]  229.16 27.74 90 bottom
R882  4.7Kohm  [R-0402S0]  226.56 37.86 0 bottom
R883  4.7Kohm  [R-0402S0]  226.56 35.58 180 bottom
R884  4.7Kohm  [R-0402S0]  225.18 35.58 180 bottom
R885  4.7Kohm  [R-0402S0]  225.18 37.86 0 bottom
R886  4.7Kohm  [R-0402S0]  223.81 35.58 180 bottom
R887  4.7Kohm  [R-0402S0]  223.81 37.86 0 bottom
R888  4.7Kohm  [R-0402S0]  222.44 35.58 180 bottom
R889  4.7Kohm  [R-0402S0]  222.44 37.86 0 bottom
R890  4.7Kohm  [R-0402S0]  220.2 23.84 0 bottom
R891  4.7Kohm  [R-0402S0]  218.31 35.58 180 bottom
R892  0ohm  [R-0402S0]  217.55 21.01 0 bottom
R893  4.7Kohm  [R-0402S0]  219.71 37.99 0 bottom
R894  0ohm  [R-0402S0]  218.93 21.01 0 bottom
R895  4.7Kohm  [R-0402S0]  219.21 23.84 180 bottom
R896  4.7Kohm  [R-0402S0]  221.06 37.99 180 bottom
R897  4.7Kohm  [R-0402S0]  219.71 35.58 0 bottom
R898  4.7Kohm  [R-0402S0]  274.1 29.31 270 bottom
R899  4.7Kohm  [R-0402S0]  282.27 23.32 0 bottom
R900  4.7Kohm  [R-0402S0]  283.34 23.32 0 bottom
R901  4.7Kohm  [R-0402S0]  290.29 31.17 90 bottom
R902  4.7Kohm  [R-0402S0]  290.13 30.07 90 bottom
R903  4.7Kohm  [R-0402S0]  290.13 29.03 90 bottom
R904  4.7Kohm  [R-0402S0]  288.06 28.4 90 bottom
R905  4.7Kohm  [R-0402S0]  288.06 27.41 90 bottom
R906  4.7Kohm  [R-0402S0]  283.45 37.42 0 bottom
R907  4.7Kohm  [R-0402S0]  283.45 35.13 180 bottom
R908  4.7Kohm  [R-0402S0]  282.08 35.13 180 bottom
R909  4.7Kohm  [R-0402S0]  282.08 37.42 0 bottom
R910  4.7Kohm  [R-0402S0]  280.71 35.13 180 bottom
R911  4.7Kohm  [R-0402S0]  280.71 37.42 0 bottom
R912  4.7Kohm  [R-0402S0]  279.33 35.13 180 bottom
R913  4.7Kohm  [R-0402S0]  279.33 37.42 0 bottom
R914  4.7Kohm  [R-0402S0]  275.21 35.13 180 bottom
R915  0ohm  [R-0402S0]  277.24 23.36 0 bottom
R916  4.7Kohm  [R-0402S0]  281.26 23.32 0 bottom
R917  4.7Kohm  [R-0402S0]  276.61 37.54 0 bottom
R918  0ohm  [R-0402S0]  278.62 23.36 0 bottom
R919  4.7Kohm  [R-0402S0]  279.89 23.32 180 bottom
R920  4.7Kohm  [R-0402S0]  277.96 37.54 180 bottom
R921  4.7Kohm  [R-0402S0]  276.61 35.13 0 bottom
R946  4.7Kohm  [R-0402S0]  89.41 182.94 180 bottom
R947  4.7Kohm  [R-0402S0]  89.41 179.89 0 bottom
R948  4.7Kohm  [R-0402S0]  91.44 179.89 0 bottom
R949  4.7Kohm  [R-0402S0]  90.42 179.89 0 bottom
R950  4.7Kohm  [R-0402S0]  90.93 182.94 0 bottom
R951  4.7Kohm  [R-0402S0]  91.95 182.94 0 bottom
R952  4.7Kohm  [R-0402S0]  91.57 186.11 0 bottom
R953  4.7Kohm  [R-0402S0]  92.58 186.11 0 bottom
R954  0ohm  [R-0402S0]  87.5 185.86 180 bottom
R955  0ohm  [R-0402S0]  88.52 185.98 180 bottom
R956  4.7Kohm  [R-0402S0]  89.53 186.11 180 bottom
R957  4.7Kohm  [R-0402S0]  87.38 179.89 0 bottom
R958  4.7Kohm  [R-0402S0]  86.36 179.89 0 bottom
R959  4.7Kohm  [R-0402S0]  90.55 186.11 0 bottom
R960  4.7Kohm  [R-0402S0]  87.38 182.94 0 bottom
R961  4.7Kohm  [R-0402S0]  86.36 182.94 0 bottom
R962  4.7Kohm  [R-0402S0]  106.06 20.5 180 bottom
R963  4.7Kohm  [R-0402S0]  104.79 20.5 180 bottom
R964  4.7Kohm  [R-0402S0]  108.61 20.5 180 bottom
R965  4.7Kohm  [R-0402S0]  107.34 20.5 180 bottom
R966  4.7Kohm  [R-0402S0]  110.87 13.23 90 bottom
R967  4.7Kohm  [R-0402S0]  110.87 12.09 90 bottom
R968  4.7Kohm  [R-0402S0]  106.69 7.37 0 bottom
R969  4.7Kohm  [R-0402S0]  107.97 7.37 0 bottom
R970  0ohm  [R-0402S0]  101.6 7.37 0 bottom
R971  0ohm  [R-0402S0]  102.88 7.37 0 bottom
R972  4.7Kohm  [R-0402S0]  105.42 7.37 0 bottom
R973  4.7Kohm  [R-0402S0]  100.97 20.5 180 bottom
R974  4.7Kohm  [R-0402S0]  98.43 20.5 180 bottom
R975  4.7Kohm  [R-0402S0]  104.15 7.37 180 bottom
R976  4.7Kohm  [R-0402S0]  102.25 20.5 0 bottom
R977  4.7Kohm  [R-0402S0]  99.7 20.5 0 bottom
R978  4.7Kohm  [R-0402S0]  308.76 39.9 90 bottom
R979  4.7Kohm  [R-0402S0]  308.76 40.92 90 bottom
R980  4.7Kohm  [R-0402S0]  308.76 37.87 90 bottom
R981  4.7Kohm  [R-0402S0]  308.76 38.88 90 bottom
R982  4.7Kohm  [R-0402S0]  301.06 42.65 180 bottom
R983  4.7Kohm  [R-0402S0]  302.13 42.65 180 bottom
R984  4.7Kohm  [R-0402S0]  298.92 42.65 180 bottom
R985  4.7Kohm  [R-0402S0]  299.99 42.65 180 bottom
R986  0ohm  [R-0402S0]  295.17 38.76 270 bottom
R987  0ohm  [R-0402S0]  295.17 37.74 270 bottom
R988  4.7Kohm  [R-0402S0]  296.78 42.65 180 bottom
R989  4.7Kohm  [R-0402S0]  304.27 42.65 180 bottom
R990  4.7Kohm  [R-0402S0]  306.41 42.65 180 bottom
R991  4.7Kohm  [R-0402S0]  297.85 42.65 0 bottom
R992  4.7Kohm  [R-0402S0]  303.2 42.65 0 bottom
R993  4.7Kohm  [R-0402S0]  305.34 42.65 0 bottom
R994  4.7Kohm  [R-0402S0]  103.55 135.76 270 top
R995  33ohm  [R-0402S0]  106.49 130.55 90 top
R996  4.7Kohm  [R-0402S0]  124.74 130.35 90 top
R997  4.7Kohm  [R-0402S0]  114.43 136.4 180 top
R998  4.7Kohm  [R-0402S0]  105.92 134.59 0 top
R999  4.7Kohm  [R-0402S0]  106.86 134.59 0 top
R1000  4.7Kohm  [R-0402S0]  122.63 143.41 180 bottom
R1001  4.7Kohm  [R-0402S0]  125.42 143.41 180 bottom
R1002  4.7Kohm  [R-0402S0]  130.5 143.41 180 bottom
R1003  4.7Kohm  [R-0402S0]  128.46 143.41 180 bottom
R1004  33  [R-0402S0]  120.36 143.41 0 bottom
R1006  4.7Kohm  [R-0402S0]  121.47 143.41 0 bottom
R1007  4.7Kohm  [R-0402S0]  127.17 143.41 0 bottom
R1013  100Kohm  [R-0402S0]  129.26 189.29 90 top
R1014  100Kohm  [R-0402S0]  129.26 190.56 90 top
R1015  100Kohm  [R-0402S0]  129.26 191.83 90 top
R1016  100Kohm  [R-0402S0]  129.26 193.1 90 top
R1017  100Kohm  [R-0402S0]  129.26 194.37 270 top
R1018  33ohm  [R-0402S0]  158.42 87.49 90 top
R1023  10Kohm  [R-0402S0]  133.48 193.42 180 top
R1024  10K  [R-0402S0]  69.63 127.51 180 bottom
R1025  4.7Kohm  [R-0402S0]  124.94 186.62 0 top
R1026  4.7Kohm  [R-0402S0]  128.5 186.62 0 top
R1027  100Kohm  [R-0402S0]  129.26 196.6 90 top
R1028  4.7Kohm  [R-0402S0]  125.86 196.47 0 bottom
R1029  4.7Kohm  [R-0402S0]  117.55 105.76 270 bottom
R1030  4.7Kohm  [R-0402S0]  117.3 102.86 270 bottom
R1031  4.7Kohm  [R-0402S0]  123.67 186.62 0 top
R1032  4.7Kohm  [R-0402S0]  122.15 199.07 270 bottom
R1033  4.7Kohm  [R-0402S0]  117.55 106.73 90 bottom
R1034  4.7Kohm  [R-0402S0]  117.3 101.89 90 bottom
R1035  0ohm  [R-0402S0]  126.21 186.62 0 top
R1036  0ohm  [R-0402S0]  127.48 186.62 0 top
R1037  0ohm  [R-0402S0]  129.77 197.92 90 top
R1038  100Kohm  [R-0402S0]  110.33 192.97 270 top
R1039  100Kohm  [R-0402S0]  110.33 191.7 270 top
R1040  20Kohm  [R-0402S0]  122.4 184.08 0 top
R1041  31.6Kohm  [R-0402S0]  112.87 192.97 90 top
R1042  31.6Kohm  [R-0402S0]  112.87 191.7 90 top
R1043  0ohm  [R-0402S0]  224.66 176.12 270 top
R1044  0ohm  [R-0402S0]  226.57 176.12 90 top
R1046  10K  [R-0402S0]  223.07 170.56 0 top
R1047  0ohm  [R-0402S0]  224.08 170.56 0 top
R1048  124ohm  [R-0402S0]  179.32 154.11 0 top
R1049  124ohm  [R-0402S0]  179.32 152.33 180 top
R1050  82.5ohm  [R-0402S0]  178.18 154.11 180 top
R1051  82.5ohm  [R-0402S0]  178.18 152.33 0 top
R1052  10Kohm  [R-0402S0]  118.59 184.08 180 top
R1053  10Kohm  [R-0402S0]  117.32 184.08 180 top
R1054  10Kohm  [R-0402S0]  116.05 184.08 180 top
R1055  10Kohm  [R-0402S0]  67.18 127.38 180 bottom
R1056  10Kohm  [R-0402S0]  114.78 184.08 180 top
R1057  10Kohm  [R-0402S0]  79.76 191.9 90 top
R1058  10Kohm  [R-0402S0]  107.79 192.97 90 top
R1059  10Kohm  [R-0402S0]  121.13 181.54 180 top
R1060  10Kohm  [R-0402S0]  119.86 181.54 180 top
R1061  10Kohm  [R-0402S0]  117.86 192.3 180 bottom
R1063  2.2Kohm  [R-0402S0]  119.89 192.3 0 bottom
R1065  4.99Kohm  [R-0402S0]  82.42 192.28 180 top
R1066  12Kohm  [R-0402S0]  112.87 194.24 270 top
R1067  10Kohm  [R-0402S0]  121.13 184.08 0 top
R1068  10Kohm  [R-0402S0]  119.86 184.08 0 top
R1070  33ohm  [R-0402S0]  162.05 114.5 180 top
R1071  33ohm  [R-0402S0]  163.35 114.5 180 top
R1072  33ohm  [R-0402S0]  162.61 117.4 270 top
R1073  33ohm  [R-0402S0]  162.61 118.68 270 top
R1074  4.7Kohm  [R-0402S0]  128.95 116.58 270 top
R1075  75ohm  [R-0402S0]  134.81 122.54 90 top
R1076  33ohm  [R-0402S0]  132.62 123.75 0 top
R1077  0ohm  [R-0402S0]  132.62 122.94 0 top
R1079  124ohm  [R-0402S0]  166.28 82.66 0 bottom
R1080  124ohm  [R-0402S0]  167.43 82.66 0 bottom
R1081  82.5ohm  [R-0402S0]  166.28 82.66 0 top
R1082  82.5ohm  [R-0402S0]  167.43 82.66 0 top
R1083  4.7Kohm  [R-0402S0]  117.55 104.79 270 bottom
R1084  4.7Kohm  [R-0402S0]  117.55 103.83 90 bottom
R1085  10Kohm  [R-0402S0]  66.48 175.19 180 bottom
R1086  10Kohm  [R-0402S0]  67.62 175.19 180 bottom
R1097  4.7Kohm  [R-0402S0]  100.2 181.91 180 top
R1098  4.7Kohm  [R-0402S0]  98.16 181.91 180 top
R1099  4.7Kohm  [R-0402S0]  95.3 184.03 270 bottom
R1100  4.7Kohm  [R-0402S0]  95.3 185.04 90 bottom
R1101  4.7Kohm  [R-0402S0]  101.21 181.91 0 top
R1102  4.7Kohm  [R-0402S0]  99.18 181.91 0 top
R1103  100Kohm  [R-0402S0]  259.69 188.27 270 top
R1104  100Kohm  [R-0402S0]  262.43 183.26 90 top
R1105  100Kohm  [R-0402S0]  262.99 188.83 180 bottom
R1107  100Kohm  [R-0402S0]  264.29 193.99 180 bottom
R1108  100Kohm  [R-0402S0]  272.29 193.99 180 bottom
R1109  100Kohm  [R-0402S0]  280.29 193.99 180 bottom
R1110  100Kohm  [R-0402S0]  265.3 197.16 180 bottom
R1111  100Kohm  [R-0402S0]  272.69 197.98 90 bottom
R1112  1Kohm  [R-0402S0]  102.92 174.81 0 top
R1113  0ohm  [R-0402S0]  265.3 193.99 0 bottom
R1114  0ohm  [R-0402S0]  273.3 193.99 0 bottom
R1115  0ohm  [R-0402S0]  281.3 193.99 0 bottom
R1116  0ohm  [R-0402S0]  266.32 197.16 0 bottom
R1117  0ohm  [R-0402S0]  272.69 198.99 270 bottom
R1118  0ohm  [R-0402S0]  261.75 193.35 0 bottom
R1119  0ohm  [R-0402S0]  270.25 193.99 0 bottom
R1120  0ohm  [R-0402S0]  278.26 193.99 0 bottom
R1121  0ohm  [R-0402S0]  260.98 196.91 0 bottom
R1122  0ohm  [R-0402S0]  270.33 198.15 90 bottom
R1124  100Kohm  [R-0402S0]  260.73 193.35 0 bottom
R1125  100Kohm  [R-0402S0]  271.27 193.99 0 bottom
R1126  100Kohm  [R-0402S0]  279.27 193.99 0 bottom
R1127  100Kohm  [R-0402S0]  259.84 196.91 0 bottom
R1128  100Kohm  [R-0402S0]  270.33 199.17 90 bottom
R1129  100Kohm  [R-0402S0]  275.44 188.28 270 top
R1130  100Kohm  [R-0402S0]  264.51 188.4 270 top
R1131  100Kohm  [R-0402S0]  275.44 183.08 90 bottom
R1132  100Kohm  [R-0402S0]  266.85 181.55 270 bottom
R1133  100Kohm  [R-0402S0]  278.71 189.75 180 bottom
R1134  100Kohm  [R-0402S0]  268.06 189.18 180 bottom
R1141  100Kohm  [R-0402S0]  269.49 187.08 90 top
R1142  100Kohm  [R-0402S0]  284.91 187.4 270 bottom
R1143  100Kohm  [R-0402S0]  270.74 183.06 90 bottom
R1144  100Kohm  [R-0402S0]  284.6 183.13 90 top
R1145  100Kohm  [R-0402S0]  272.13 188.52 180 bottom
R1146  100Kohm  [R-0402S0]  281.52 185.32 0 bottom
R1153  4.7Kohm  [R-0402S0]  44.58 200.28 0 top
R1154  0ohm  [R-0402S0]  45.72 200.28 0 top
R1157  4.7Kohm  [R-0402S0]  35.56 196.22 180 bottom
R1158  820ohm  [R-0402S0]  54.64 194.96 90 top
R1159  10Kohm  [R-0402S0]  54.64 193.95 270 top
R1161  0ohm  [R-0402S0]  36.83 196.22 0 bottom
R1166  0ohm  [R-0402S0]  44.32 191.13 270 bottom
R1170  100Kohm  [R-0402S0]  44.32 192.15 270 bottom
R1175  4.7Kohm  [R-0402S0]  44.45 196.09 0 top
R1176  0ohm  [R-0402S0]  45.47 196.09 0 top
R1177  10Kohm  [R-0402S0]  54.63 200.03 270 top
R1180  4.7Kohm  [R-0402S0]  35.69 193.68 0 bottom
R1181  820ohm  [R-0402S0]  54.63 201.04 90 top
R1183  0ohm  [R-0402S0]  36.83 193.68 180 bottom
R1188  0ohm  [R-0402S0]  44.58 191.9 180 top
R1190  100Kohm  [R-0402S0]  43.43 191.9 180 top
R1191  4.7Kohm  [R-0402S0]  33.28 51.78 0 top
R1192  4.7Kohm  [R-0402S0]  32.01 51.78 180 top
R1198  4.7Kohm  [R-0402S0]  27.05 51.66 0 top
R1199  4.7Kohm  [R-0402S0]  25.31 51.3 270 top
R1203  22  [R-0402S0]  104.27 90.86 270 top
R1204  4.7K  [R-0402S0]  107.19 94.67 90 bottom
R1205  22  [R-0402S0]  104.27 89.59 270 top
R1206  22  [R-0402S0]  104.14 88.32 270 top
R1207  0ohm  [R-0402S0]  88.9 95.82 270 top
R1208  0ohm  [R-0402S0]  88.93 92.77 270 top
R1209  0ohm  [R-0402S0]  88.9 94.55 270 top
R1210  0ohm  [R-0402S0]  88.9 87.82 270 top
R1211  0ohm  [R-0402S0]  88.9 89.09 270 top
R1212  4.99Kohm  [R-0402S0]  88.9 86.8 270 top
R1213  33ohm  [R-0402S0]  107.19 92.64 90 bottom
R1214  33ohm  [R-0402S0]  107.19 91.63 90 bottom
R1215  33ohm  [R-0402S0]  107.19 90.61 90 bottom
R1216  4.7K  [R-0402S0]  92.71 99.63 180 top
R1217  4.7K  [R-0402S0]  98.81 101.6 180 top
R1218  4.7K  [R-0402S0]  93.98 99.63 180 top
R1219  4.7K  [R-0402S0]  103.76 84.18 270 bottom
R1220  4.7K  [R-0402S0]  99.95 101.6 180 top
R1221  3.3Kohm  [R-0402S0]  114.55 89.85 0 bottom
R1222  3.3Kohm  [R-0402S0]  114.55 91.63 180 bottom
R1223  33Kohm  [R-0402S0]  111.3 89.52 270 bottom
R1224  33Kohm  [R-0402S0]  111.3 92.56 270 bottom
R1225  33ohm  [R-0402S0]  107.19 93.66 90 bottom
R1226  33Kohm  [R-0402S0]  111.3 90.53 90 bottom
R1227  33Kohm  [R-0402S0]  111.3 91.55 90 bottom
R1257  150ohm  [R-0402S0]  81.81 43.87 0 bottom
R1259  150ohm  [R-0402S0]  82.82 43.87 0 bottom
R1262  0ohm  [R-0402S0]  70.32 44.1 180 top
R1263  33ohm  [R-0402S0]  60.7 41.33 180 top
R1264  33ohm  [R-0402S0]  61.72 41.33 180 top
R1265  0ohm  [R-0402S0]  71.42 44.1 180 top
R1266  33Kohm  [R-0402S0]  58.54 44.55 180 bottom
R1267  4.7Kohm  [R-0402S0]  59.51 45.47 180 bottom
R1268  4.7Kohm  [R-0402S0]  48.13 189.61 0 bottom
R1270  4.7Kohm  [R-0402S0]  57.78 52.7 270 top
R1271  4.7Kohm  [R-0402S0]  114.4 83.17 180 bottom
R1272  33Kohm  [R-0402S0]  275.37 114.54 270 bottom
R1273  33Kohm  [R-0402S0]  275.37 111.45 270 bottom
R1274  33Kohm  [R-0402S0]  275.37 113.49 270 bottom
R1275  33Kohm  [R-0402S0]  275.37 110.44 90 bottom
R1276  3.3Kohm  [R-0402S0]  265.49 113.32 270 top
R1277  3.3Kohm  [R-0402S0]  265.49 112.05 270 top
R1278  33ohm  [R-0402S0]  275.37 112.47 270 bottom
R1279  4.7Kohm  [R-0402S0]  54.64 194.45 90 bottom
R1280  4.7Kohm  [R-0402S0]  54.65 200.03 90 bottom
R1281  4.7Kohm  [R-0402S0]  49.28 193.42 270 bottom
R1404  4.7Kohm  [R-0402S0]  70.74 48.13 0 bottom
R1405  4.7Kohm  [R-0402S0]  72.93 44.77 0 top
R1406  33ohm  [R-0402S0]  92.53 131.8 90 bottom
R1407  33ohm  [R-0402S0]  92.74 133.76 90 bottom
R1408  10Kohm  [R-0402S0]  89.41 132.25 270 top
R1409  0ohm  [R-0402S0]  76.83 85.02 90 bottom
R1411  0ohm  [R-0402S0]  76.83 83.75 90 bottom
R1412  0ohm  [R-0402S0]  76.83 78.67 90 bottom
R1432  4.7K  [R-0402S0]  218.4 113.56 0 bottom
R1433  4.7K  [R-0402S0]  219.42 113.56 0 bottom
R1434  4.7K  [S-R-0402]  202.86 111.98 90 bottom
R1435  4.7K  [S-R-0402]  202.86 110.98 90 bottom
R1436  4.7K  [R-0402S0]  214.88 120.99 90 bottom
R1437  4.7K  [R-0402S0]  214.5 119.56 90 bottom
R1438  4.7K  [R-0402S0]  169.91 122.73 270 top
R1439  4.7K  [R-0402S0]  169.91 121.45 270 top
R1440  4.7K  [S-R-0402]  211.36 113.5 180 bottom
R1441  4.7K  [R-0402S0]  204.72 117.91 0 bottom
R1442  4.7K  [R-0402S0]  220.86 119.16 90 bottom
R1443  4.7K  [R-0402S0]  177.05 137.87 270 top
R1444  4.7K  [R-0402S0]  182.25 117.86 90 top
R1445  4.7K  [R-0402S0]  190.25 123.7 270 bottom
R1446  4.7K  [R-0402S0]  173.52 123.87 90 top
R1447  4.7K  [R-0402S0]  178.05 119.89 270 bottom
R1448  4.7K  [R-0402S0]  184.53 121.34 270 top
R1450  4.7K  [R-0402S0]  198.88 120.65 90 bottom
R1451  4.7K  [R-0402S0]  177.05 122.6 270 top
R1452  4.7K  [R-0402S0]  170.29 123.78 270 top
R1453  4.7K  [R-0402S0]  170.17 125.78 270 top
R1499  10ohm  [R-0603S0]  34.73 15.27 0 top
R1500  10ohm  [R-0603S0]  13.05 14.28 180 top
R1503  33ohm  [R-0402S0]  27.08 18.13 270 top
R1504  33ohm  [R-0402S0]  23.7 17.82 180 top
R1505  45.3Kohm  [R-0402S0]  30.51 18.13 270 top
R1506  1Kohm  [R-0402S0]  33.79 18.52 180 top
R1508  10ohm  [R-0603S0]  20.55 66.6 90 top
R1509  10ohm  [R-0603S0]  34.44 66.75 0 top
R1512  33ohm  [R-0402S0]  24.97 12.53 270 top
R1513  33ohm  [R-0402S0]  22.69 67.01 180 top
R1514  1Kohm  [R-0402S0]  24.97 13.53 90 top
R1515  1Kohm  [R-0402S0]  24.97 14.69 90 top
R1539  33ohm  [R-0402S0]  177.05 128.96 270 top
R1540  33ohm  [R-0402S0]  177.05 127.69 270 top
R1548  100ohm  [R-0805]  86.85 43.01 180 bottom
R1554  100ohm  [R-0805]  205.7 40.83 180 bottom
R1555  100ohm  [R-0805]  93.98 42.93 0 bottom
R1556  100ohm  [R-0805]  211.93 40.83 0 bottom
R1557  100ohm  [R-0805]  102.47 42.67 180 bottom
R1558  100ohm  [R-0805]  220.57 40.83 180 bottom
R1559  100ohm  [R-0805]  108.53 42.77 0 bottom
R1560  100ohm  [R-0805]  226.67 40.83 0 bottom
R1561  100ohm  [R-0805]  116.89 42.65 180 bottom
R1562  100ohm  [R-0805]  234.44 40.83 180 bottom
R1563  100ohm  [R-0805]  122.98 42.65 0 bottom
R1564  100ohm  [R-0805]  240.53 40.87 0 bottom
R1565  100ohm  [R-0805]  131.27 42.26 180 bottom
R1566  100ohm  [R-0805]  248.69 40.87 180 bottom
R1567  100ohm  [R-0805]  137.36 42.26 0 bottom
R1568  100ohm  [R-0805]  254.78 40.87 0 bottom
R1569  4.7Kohm  [R-0402S0]  161.34 78.41 0 top
R1570  100ohm  [R-0805]  145.39 42.26 180 bottom
R1571  100ohm  [R-0805]  263.29 40.87 180 bottom
R1572  100ohm  [R-0805]  151.48 42.26 0 bottom
R1573  100ohm  [R-0805]  269.34 40.87 0 bottom
R1574  100ohm  [R-0805]  159.64 42.14 180 bottom
R1575  100ohm  [R-0805]  282.7 40.87 0 bottom
R1576  4.7Kohm  [R-0402S0]  273.05 79.75 90 bottom
R1577  100ohm  [R-0805]  165.73 42.14 0 bottom
R1578  100ohm  [R-0805]  276.61 40.87 180 bottom
R1579  100ohm  [R-0805]  174.4 42.77 180 bottom
R1581  100ohm  [R-0805]  180.49 42.57 0 bottom
R1583  100ohm  [R-0805]  188.39 42.77 180 bottom
R1585  100ohm  [R-0805]  283.39 77.78 0 top
R1586  100ohm  [R-0805]  194.49 42.77 0 bottom
R1588  100ohm  [R-0805]  279.85 75.38 90 top
R1589  33  [R-0402S0]  34.55 51.78 0 top
R1590  2.2ohm  [R-0603S0]  35.96 34.73 180 top
R1591  2.2ohm  [R-0603S0]  34.47 34.73 180 top
R1592  2.2ohm  [R-0603S0]  26.62 34.73 180 top
R1593  2.2ohm  [R-0603S0]  25.22 34.73 180 top
R1594  33  [R-0402S0]  28.32 51.66 0 top
R1595  0ohm  [R-0402S0]  76.92 70.49 180 top
R1596  120ohm  [R-0402S0]  51.69 64.52 0 top
R1597  0ohm  [R-0402S0]  78.04 70.49 180 top
R1598  0ohm  [R-0402S0]  72.98 70.49 180 top
R1599  0ohm  [R-0402S0]  74.04 70.49 180 top
R1600  10ohm  [R-0603S0]  10.14 25.72 270 bottom
R1602  33ohm  [R-0402S0]  5.08 34.48 0 bottom
R1603  33ohm  [R-0402S0]  5.33 40.32 270 bottom
R1604  33ohm  [R-0402S0]  5.66 38.82 270 bottom
R1605  33ohm  [R-0402S0]  17.29 35.64 270 bottom
R1606  33ohm  [R-0402S0]  17.29 36.78 270 bottom
R1607  33ohm  [R-0402S0]  17.29 37.92 270 bottom
R1608  4.7K  [R-0402S0]  5.33 44.15 270 bottom
R1609  33ohm  [R-0402S0]  16.41 30.56 270 bottom
R1610  33ohm  [R-0402S0]  5.33 43.11 90 bottom
R1611  510ohm  [R-0402S0]  76.83 76.13 90 bottom
R1612  510ohm  [R-0402S0]  76.83 77.4 90 bottom
R1613  4.7K  [R-0402S0]  76.83 86.29 90 bottom
R1614  10K  [R-0402S0]  76.83 79.94 270 bottom
R1615  10K  [R-0402S0]  71.75 77.4 180 bottom
R1616  10K  [R-0402S0]  70.48 77.4 180 bottom
R1617  49.9  [R-0402S0]  64.9 87.82 0 bottom
R1618  33ohm  [R-0402S0]  64.39 81.65 180 bottom
R1619  1Kohm  [R-0402S0]  70.1 79.31 270 bottom
R1620  4.7Kohm  [R-0402S0]  70.1 81.34 90 bottom
R1621  4.7Kohm  [R-0402S0]  69.72 82.35 90 bottom
R1622  4.7Kohm  [R-0402S0]  69.72 85.4 90 bottom
R1623  510ohm  [R-0402S0]  76.83 87.56 270 bottom
R1624  4.7Kohm  [R-0402S0]  70.1 80.32 270 bottom
R1625  4.7Kohm  [R-0402S0]  69.72 83.37 270 bottom
R1626  4.7Kohm  [R-0402S0]  69.72 84.39 270 bottom
R1627  4.7Kohm  [R-0402S0]  55.37 76.45 270 top
R1628  0ohm  [R-0402S0]  4.32 26.11 0 bottom
R1630  10Kohm  [R-0402S0]  64.84 173.33 0 bottom
R1631  150ohm  [R-0402S0]  299.56 46.02 180 bottom
R1632  150ohm  [R-0402S0]  300.71 19.1 0 bottom
R1633  150ohm  [R-0402S0]  298.29 46.02 180 bottom
R1634  150ohm  [R-0402S0]  299.44 19.1 0 bottom
R1635  150ohm  [R-0402S0]  304.64 46.02 180 bottom
R1636  150ohm  [R-0402S0]  303.25 19.1 0 bottom
R1637  150ohm  [R-0402S0]  303.37 46.02 180 bottom
R1638  150ohm  [R-0402S0]  301.98 19.1 0 bottom
R1639  150ohm  [R-0402S0]  307.18 46.02 180 bottom
R1640  150ohm  [R-0402S0]  305.79 19.1 0 bottom
R1641  150ohm  [R-0402S0]  305.91 46.02 180 bottom
R1642  150ohm  [R-0402S0]  304.52 19.1 0 bottom
R1643  10Kohm  [R-0402S0]  183.92 154.11 270 bottom
R1644  10Kohm  [R-0402S0]  187.32 154.62 270 bottom
R1645  10Kohm  [R-0402S0]  182.19 154.11 90 bottom
R1646  10Kohm  [R-0402S0]  163.45 90.93 0 bottom
R1647  10Kohm  [R-0402S0]  159.44 97.97 90 top
R1648  10Kohm  [R-0402S0]  157.7 97.97 270 top
R1649  10Kohm  [R-0402S0]  157.89 119.41 0 bottom
R1650  10Kohm  [R-0402S0]  159.42 119.15 270 bottom
R1651  10Kohm  [R-0402S0]  101.85 173.79 0 top
R1652  4.7Kohm  [R-0402S0]  30.99 85.53 90 bottom
R1655  4.7Kohm  [R-0402S0]  30.99 86.61 270 top
R1657  10Kohm  [R-0402S0]  94.61 174.05 90 top
R1661  4.7Kohm  [R-0402S0]  10.16 89.59 90 bottom
R1663  33ohm  [R-0402S0]  10.16 90.61 90 bottom
R1665  33ohm  [R-0402S0]  10.16 92.64 90 bottom
R1666  33ohm  [R-0402S0]  19.44 87.59 90 bottom
R1667  33ohm  [R-0402S0]  31.01 51.78 0 top
R1668  33ohm  [R-0402S0]  25.36 54.08 270 top
R1671  33ohm  [R-0402S0]  22.35 100.71 90 bottom
R1672  33ohm  [R-0402S0]  31.37 90.99 90 top
R1673  33ohm  [R-0402S0]  31.37 89.97 90 top
R1674  4.7Kohm  [R-0402S0]  30.99 88.7 270 bottom
R1675  33ohm  [R-0402S0]  30.99 84.51 270 bottom
R1676  33ohm  [R-0402S0]  30.99 85.53 90 top
R1677  4.7Kohm  [R-0402S0]  19.2 102.1 0 top
R1678  4.7Kohm  [R-0402S0]  18.06 102.1 0 top
R1679  4.7Kohm  [R-0402S0]  16.91 102.1 0 top
R1680  4.7Kohm  [R-0402S0]  30.99 87.56 90 bottom
R1681  4.7Kohm  [R-0402S0]  10.16 93.66 90 bottom
R1682  4.7Kohm  [R-0402S0]  19.11 88.92 180 bottom
R1683  4.7Kohm  [R-0402S0]  30.99 86.55 90 bottom
R1684  4.7Kohm  [R-0402S0]  21.08 99.19 270 bottom
R1685  4.7Kohm  [R-0402S0]  10.16 91.63 270 bottom
R1686  4.7Kohm  [R-0402S0]  5.49 76.86 270 bottom
R1687  4.7Kohm  [R-0402S0]  5.49 73.76 270 bottom
R1688  4.7Kohm  [R-0402S0]  6.86 71.45 180 top
R1689  4.7Kohm  [R-0402S0]  10.41 71.45 180 top
R1690  4.7Kohm  [R-0402S0]  9.12 71.42 180 top
R1691  4.7Kohm  [R-0402S0]  7.82 71.45 0 top
R1692  4.7Kohm  [R-0402S0]  5.49 75.81 90 bottom
R1693  4.7Kohm  [R-0402S0]  5.49 74.74 90 bottom
R1694  4.7Kohm  [R-0402S0]  122.43 136.45 180 top
R1695  4.7Kohm  [R-0402S0]  106.49 128.65 270 top
R1696  4.7Kohm  [R-0402S0]  122.37 122.68 270 bottom
R1697  4.7Kohm  [R-0402S0]  117.26 118.93 0 top
R1698  4.7Kohm  [R-0402S0]  102.23 97.09 180 bottom
R1699  4.7Kohm  [R-0402S0]  118.14 138.22 180 top
R1700  4.7Kohm  [R-0402S0]  119 136.45 180 top
R1701  4.7Kohm  [R-0402S0]  116.59 118.62 90 bottom
R1702  4.7Kohm  [R-0402S0]  26.04 152.78 270 top
R1703  4.7Kohm  [R-0402S0]  129.29 195.58 90 top
R1704  4.7Kohm  [R-0402S0]  106.49 122.99 270 top
R1705  4.7Kohm  [R-0402S0]  65.21 170.49 180 top
R1706  4.7Kohm  [R-0402S0]  106.49 119.78 270 top
R1707  4.7Kohm  [R-0402S0]  84.15 170.49 180 top
R1708  4.7Kohm  [R-0402S0]  117.07 138.22 180 top
R1709  4.7Kohm  [R-0402S0]  86.29 170.49 180 top
R1710  4.7Kohm  [R-0402S0]  116.71 170.62 180 top
R1711  4.7Kohm  [R-0402S0]  112.33 136.37 180 top
R1712  4.7Kohm  [R-0402S0]  137.9 170.62 180 top
R1713  4.7Kohm  [R-0402S0]  73.07 170.49 180 top
R1714  4.7Kohm  [R-0402S0]  136.63 170.62 180 top
R1715  4.7Kohm  [R-0402S0]  103.76 85.2 270 bottom
R1716  4.7Kohm  [R-0402S0]  77.01 170.49 180 top
R1717  4.7Kohm  [R-0402S0]  75.8 170.49 180 top
R1718  4.7Kohm  [R-0402S0]  124.79 125.12 90 top
R1719  4.7Kohm  [R-0402S0]  64.64 85.02 180 bottom
R1720  4.7Kohm  [R-0402S0]  4.06 34.48 180 bottom
R1721  4.7Kohm  [R-0402S0]  122.37 121.64 270 bottom
R1722  100Kohm  [R-0402S0]  88.39 182.94 0 bottom
R1724  4.7Kohm  [R-0402S0]  103.52 20.5 0 bottom
R1726  4.7Kohm  [R-0402S0]  89.11 36.58 0 bottom
R1728  4.7Kohm  [R-0402S0]  160.43 36.58 0 bottom
R1729  4.7Kohm  [R-0402S0]  121.28 126.52 0 bottom
R1730  4.7Kohm  [R-0402S0]  221.06 35.58 0 bottom
R1731  4.7Kohm  [R-0402S0]  16.41 31.57 270 bottom
R1732  4.7Kohm  [R-0402S0]  277.96 35.13 0 bottom
R1733  4.7Kohm  [R-0402S0]  309.12 42.16 270 bottom
R1734  4.7Kohm  [R-0402S0]  167.01 128.01 180 bottom
R1735  4.7Kohm  [R-0402S0]  106.33 126.52 90 bottom
R1736  4.7Kohm  [R-0402S0]  105.1 180.48 0 bottom
R1737  4.7Kohm  [R-0402S0]  103.98 180.48 0 bottom
R1738  4.7Kohm  [R-0402S0]  109.07 172.52 0 top
R1739  4.7Kohm  [R-0402S0]  109.07 174.81 0 top
R1740  4.7Kohm  [R-0402S0]  105.26 172.52 0 top
R1741  4.7Kohm  [R-0402S0]  105.26 174.81 0 top
R1742  4.7Kohm  [R-0402S0]  103.98 172.52 0 top
R1743  4.7Kohm  [R-0402S0]  103.98 174.81 0 top
R1744  4.7Kohm  [R-0402S0]  107.8 172.52 0 top
R1745  4.7Kohm  [R-0402S0]  107.8 174.81 0 top
R1746  4.7Kohm  [R-0402S0]  106.53 172.52 0 top
R1747  4.7Kohm  [R-0402S0]  106.53 174.81 0 top
R1748  0ohm  [R-0402S0]  120.14 136.45 180 top
R1749  0ohm  [R-0402S0]  121.28 136.45 180 top
R1750  4.7Kohm  [R-0402S0]  112.63 170.62 180 top
R1751  4.7Kohm  [R-0402S0]  115.29 170.62 180 top
R1752  4.7Kohm  [R-0402S0]  22.1 165.86 270 top
R1753  1Kohm  [R-0402S0]  22.1 164.47 270 top
R1754  100Kohm  [R-0402S0]  88.01 177.04 0 bottom
R1755  100Kohm  [R-0402S0]  72.01 170.49 0 top
R1756  4.7Kohm  [R-0402S0]  115.95 118.93 0 top
R1757  4.7Kohm  [R-0402S0]  117.89 170.62 180 top
R1758  4.7Kohm  [R-0402S0]  87.63 140.9 0 top
R1759  4.7Kohm  [R-0402S0]  74.42 130.7 270 bottom
R1760  4.7Kohm  [R-0402S0]  114.03 170.62 180 top
R1761  4.7Kohm  [R-0402S0]  134.33 170.62 0 top
R1764  1Kohm  [R-0402S0]  100.71 173.92 180 top
R1765  120ohm  [R-0402S0]  33.93 44.45 90 top
R1766  120ohm  [R-0402S0]  27.35 44.45 90 top
R1767  4.7Kohm  [R-0402S0]  32.64 46.35 90 bottom
R1768  4.7Kohm  [R-0402S0]  26.16 46.35 90 bottom
R1776  4.7K  [R-0402S0]  157.1 136.97 0 top
R1777  4.7K  [R-0402S0]  152.73 133.71 180 bottom
R1778  4.7K  [R-0402S0]  157.86 133.91 270 bottom
R1779  4.7K  [R-0402S0]  151.71 133.71 0 bottom
R1780  4.7K  [R-0402S0]  162.81 133.15 270 top
R1781  4.7K  [R-0402S0]  156.08 123.75 180 top
R1782  4.7K  [R-0402S0]  157.35 123.75 180 top
R1783  4.7K  [R-0402S0]  156.08 123.75 180 bottom
R1784  4.7K  [R-0402S0]  157.35 123.75 180 bottom
R1787  4.7K  [R-0402S0]  156.08 136.96 0 top
R1788  4.7K  [R-0402S0]  155.12 123.73 180 top
R1789  4.7K  [R-0402S0]  153.53 123.7 180 top
R1790  180ohm  [R-0402S0]  31.37 90.99 90 bottom
R1791  180ohm  [R-0402S0]  31.37 89.97 90 bottom
R1797  4.7K  [R-0402S0]  140.76 99.24 90 bottom
R1798  4.7K  [R-0402S0]  140.76 100.26 90 bottom
R1799  4.7K  [R-0402S0]  141.8 91.62 0 bottom
R1800  4.7K  [R-0402S0]  140.78 91.62 0 bottom
R1801  4.7K  [R-0402S0]  138.48 91.62 0 bottom
R1802  4.7K  [R-0402S0]  139.64 91.62 0 bottom
R1803  4.7K  [R-0402S0]  114.43 95.25 90 top
R1804  4.7K  [R-0402S0]  140.94 95.31 270 top
R1805  4.7K  [R-0402S0]  121.68 86.85 0 bottom
R1806  4.7K  [R-0402S0]  125.39 82.04 180 top
R1807  4.7K  [R-0402S0]  118.16 90.86 270 bottom
R1808  4.7K  [R-0402S0]  118.16 91.88 270 bottom
R1809  4.7K  [R-0402S0]  124.33 82.04 180 top
R1810  4.7K  [R-0402S0]  127.11 82.04 180 top
R1811  4.7K  [R-0402S0]  118.16 92.89 270 bottom
R1812  4.7K  [R-0402S0]  118.16 93.91 270 bottom
R1813  4.7K  [R-0402S0]  184.91 137.04 270 top
R1814  4.7K  [R-0402S0]  173.48 138.87 270 top
R1815  4.7K  [R-0402S0]  170.18 139.12 270 top
R1816  510ohm  [R-0402S0]  109.13 84.96 180 bottom
R1817  22ohm  [R-0402S0]  104.5 86.45 270 bottom
R1818  4.7k  [R-0402S0]  111.25 88.27 90 bottom
R1819  22ohm  [R-0402S0]  107.22 85.81 0 bottom
R1820  180ohm  [R-0402S0]  29.16 92.51 90 bottom
R1821  180ohm  [R-0402S0]  29.16 93.66 90 bottom
R1823  0ohm  [R-0402S0]  135.48 170.62 180 top
R1824  0ohm  [R-0402S0]  82.55 107.88 90 bottom
R1825  0ohm  [R-0402S0]  82.55 106.61 90 bottom
R1826  0ohm  [R-0402S0]  82.55 105.34 90 bottom
R1827  0ohm  [R-0402S0]  86.36 105.34 90 bottom
R1828  0ohm  [R-0402S0]  75.06 106.23 90 bottom
R1829  22ohm  [R-0402S0]  89.03 192.28 0 bottom
R1830  4.7k  [R-0402S0]  90.65 199.83 0 top
R1831  22ohm  [R-0402S0]  89.25 199.83 0 top
R1832  0ohm  [R-0402S0]  106.49 120.85 270 top
R1833  0ohm  [R-0402S0]  106.49 121.92 270 top
R1834  0ohm  [R-0402S0]  111.37 136.37 180 top
R1835  0ohm  [R-0402S0]  110.39 136.37 180 top
R1836  4.7Kohm  [R-0402S0]  85.22 170.49 180 top
R1843  10Kohm  [R-0402S0]  123.19 193.04 90 bottom
R1844  0ohm  [R-0402S0]  110.49 97.08 0 bottom
R1845  0ohm  [R-0402S0]  111.76 97.08 0 bottom
R1846  4.7Kohm  [R-0402S0]  111.38 109.4 180 bottom
R1847  4.7Kohm  [R-0402S0]  108.71 109.41 180 bottom
R1848  4.7Kohm  [R-0402S0]  112.52 109.56 180 bottom
R1849  4.7Kohm  [R-0402S0]  113.67 104.7 90 bottom
R1850  4.7Kohm  [R-0402S0]  113.67 103.43 90 bottom
R1851  4.7Kohm  [R-0402S0]  113.54 109.56 0 bottom
R1852  4.7Kohm  [R-0402S0]  107.68 109.41 0 bottom
R1853  33ohm  [R-0402S0]  104.78 97.08 0 bottom
R1854  33ohm  [R-0402S0]  106.55 109.4 0 bottom
R1855  33ohm  [R-0402S0]  107.19 112.52 270 bottom
R1856  33ohm  [R-0402S0]  107.19 113.54 270 bottom
R1857  33ohm  [R-0402S0]  103.5 97.08 180 bottom
R1858  33ohm  [R-0402S0]  107.95 97.08 180 bottom
R1859  33ohm  [R-0402S0]  109.22 97.08 180 bottom
R1860  33ohm  [R-0402S0]  113.67 102.16 270 bottom
R1861  4.7Kohm  [R-0402S0]  113.67 99.62 90 bottom
R1862  4.7Kohm  [R-0402S0]  113.67 100.89 270 bottom
R1863  510ohm  [R-0402S0]  110.67 81.54 90 bottom
R1866  0ohm  [R-0402S0]  29.16 93.66 90 top
R1867  0ohm  [R-0402S0]  29.16 92.51 90 top
R1868  1Kohm  [R-0402S0]  10.16 98.23 90 bottom
R1869  510ohm  [R-0402S0]  94.11 189.87 0 bottom
R1870  510ohm  [R-0402S0]  90.33 189.45 270 bottom
R1871  4.7Kohm  [R-0402S0]  158.49 122.99 180 bottom
R1872  4.7Kohm  [R-0402S0]  113.03 186.24 0 top
R1873  0ohm  [R-0402S0]  110.24 180.35 180 bottom
R1874  0ohm  [R-0402S0]  112.13 180.22 180 bottom
R1875  4.7Kohm  [R-0402S0]  110.35 174.81 180 top
R1876  4.7Kohm  [R-0402S0]  111.9 186.32 0 top
R1877  4.7Kohm  [R-0402S0]  108.69 186.32 0 top
R1878  4.7Kohm  [R-0402S0]  110.35 172.52 0 top
R1879  4.7Kohm  [R-0402S0]  110.83 186.32 180 top
R1880  4.7Kohm  [R-0402S0]  109.76 186.32 180 top
R1881  4.7Kohm  [R-0402S0]  103.6 186.32 180 top
R1882  4.7Kohm  [R-0402S0]  104.88 186.32 180 top
R1883  4.7Kohm  [R-0402S0]  106.15 186.32 180 top
R1884  4.7Kohm  [R-0402S0]  107.42 186.32 180 top
R1887  33ohm  [R-0402S0]  21.97 104.52 270 top
R1888  33ohm  [R-0402S0]  171.26 86.81 270 top
R1889  33ohm  [R-0402S0]  166.12 91.09 0 top
R1890  33ohm  [R-0402S0]  167.11 91.09 0 top
R1891  150ohm  [R-0402S0]  171.29 84.52 270 bottom
R1892  150ohm  [R-0402S0]  171.26 85.54 270 bottom
R1893  150ohm  [R-0402S0]  171.27 87.76 270 bottom
R1894  150ohm  [R-0402S0]  171.27 86.8 270 bottom
R1895  150ohm  [R-0402S0]  166.12 91.09 0 bottom
R1896  150ohm  [R-0402S0]  167.11 91.09 0 bottom
R1897  0ohm  [R-0402S0]  153.4 122.31 0 bottom
R1898  0ohm  [R-0402S0]  154.74 122.33 0 bottom
R1899  49.9  [R-0402S0]  278.68 92.42 0 bottom
R1900  49.9  [R-0402S0]  277.7 92.42 0 bottom
R1901  0ohm  [R-0402S0]  13.96 18.65 180 top
R1902  0ohm  [R-0402S0]  16.87 19.95 90 top
R1903  4.99Kohm  [R-0402S0]  15.64 21.93 0 top
R1904  150ohm  [R-0402S0]  10.29 18.29 270 bottom
R1905  150ohm  [R-0402S0]  10.49 21.93 180 top
R1906  150ohm  [R-0402S0]  12.52 21.93 0 top
R1907  10Kohm  [R-0402S0]  15.75 15.39 90 top
R1908  9.09Kohm  [R-0402S0]  15.75 13.39 90 top
R1909  10Kohm  [R-0402S0]  20.13 15.96 90 top
R1910  10Kohm  [R-0402S0]  15.75 14.41 270 top
R1911  10Kohm  [R-0402S0]  15.75 12.38 270 top
R1912  137Kohm  [R-0402S0]  17.91 17.65 180 top
R1913  0ohm  [R-0402S0]  25.22 17.47 270 top
R1914  0ohm  [R-0402S0]  25.22 18.48 270 top
R1915  33ohm  [R-0402S0]  147.57 80.9 270 top
R1916  0ohm  [R-0402S0]  25.36 55.7 270 top
R1917  0ohm  [R-0402S0]  25.36 56.72 270 top
R1918  33ohm  [R-0402S0]  150.32 86.73 90 top
R1919  10Kohm  [R-0402S0]  75.18 137.29 270 bottom
R1980  4.7K  [R-0402S0]  151.89 123.7 180 top
R1981  4.7Kohm  [R-0402S0]  88.89 173.1 0 top
R1982  4.7Kohm  [R-0402S0]  88.01 175.26 0 bottom
R1983  4.7Kohm  [R-0402S0]  84.1 175.87 180 bottom
R1984  4.7Kohm  [R-0402S0]  84.58 177.29 90 bottom
R1985  0ohm  [R-0402S0]  89.15 176.15 180 bottom
R1986  0ohm  [R-0402S0]  85.08 175.87 180 bottom
R1987  4.7Kohm  [R-0402S0]  89.92 173.1 180 top
R1988  4.7Kohm  [R-0402S0]  139.47 175.34 180 bottom
R1989  4.7Kohm  [R-0402S0]  138.41 175.3 180 bottom
R1990  4.7Kohm  [R-0402S0]  141.51 175.34 180 bottom
R1991  4.7Kohm  [R-0402S0]  140.49 175.34 180 bottom
R1992  4.7Kohm  [R-0402S0]  140.81 181.1 180 bottom
R1993  4.7Kohm  [R-0402S0]  141.83 181.1 180 bottom
R1994  4.7Kohm  [R-0402S0]  138.77 181.1 180 bottom
R1995  4.7Kohm  [R-0402S0]  139.79 181.1 180 bottom
R1996  0ohm  [R-0402S0]  134.99 179.58 90 top
R1997  0ohm  [R-0402S0]  134.99 178.56 90 top
R1998  4.7Kohm  [R-0402S0]  136.73 181.1 180 bottom
R1999  4.7Kohm  [R-0402S0]  134.99 177.54 90 top
R2000  4.7Kohm  [R-0402S0]  134.99 175.5 90 top
R2001  4.7Kohm  [R-0402S0]  137.75 181.1 0 bottom
R2002  4.7Kohm  [R-0402S0]  134.99 176.52 270 top
R2003  4.7Kohm  [R-0402S0]  134.99 174.49 270 top
R2004  0ohm  [R-0603S0]  284.51 190.68 180 bottom
R2005  0ohm  [R-0603S0]  282.86 190.68 180 bottom
R12281  0ohm  [S-R-0402]  50.53 103.47 270 bottom
R12282  4.99Kohm  [R-0402S0]  51.59 128.34 270 top
R12283  10Kohm  [R-0402S0]  51.59 130.35 90 top
R12284  4.7Kohm  [R-0402S0]  107.24 180.48 0 bottom
R12285  4.7Kohm  [R-0402S0]  108.23 180.48 0 bottom
R12286  33ohm  [R-0402S0]  78.16 63.63 90 top
R12287  33ohm  [R-0402S0]  79.68 66.37 90 top
R12288  10Kohm  [R-0402S0]  73.84 64.65 270 top
R12295  1Kohm  [R-0402S0]  74.33 58.56 270 top
R12302  10Kohm  [R-0402S0]  46.48 68.96 90 bottom
R12306  1Kohm  [R-0402S0]  36.3 116.53 0 bottom
R12308  1Kohm  [R-0402S0]  37.32 116.53 180 bottom
R12310  4.7Kohm  [R-0402S0]  75.06 104.71 90 bottom
R12311  4.7Kohm  [R-0402S0]  66.55 96.71 0 bottom
R12312  191ohm  [R-0402S0]  69.93 104.6 0 bottom
R12313  1Kohm  [R-0402S0]  49.86 112.37 270 bottom
R12314  1Kohm  [R-0402S0]  49.86 111.4 90 bottom
R12315  100ohm  [R-0402S0]  43.16 115.62 180 bottom
R12316  4.7K  [R-0402S0]  65.26 96.72 180 bottom
R12317  4.7K  [R-0402S0]  65.26 100.53 180 bottom
R12318  4.7K  [R-0402S0]  66.55 96.71 0 top
R12319  4.7K  [R-0402S0]  65.28 96.71 0 top
R12320  4.7K  [R-0402S0]  78.74 120.58 270 bottom
R12321  4.7K  [R-0402S0]  74.93 120.58 270 bottom
R12322  4.7K  [R-0402S0]  75.06 126.35 90 top
R12323  4.7K  [R-0402S0]  75.06 118.04 270 bottom
R12325  4.7Kohm  [R-0402S0]  39.09 109.8 90 bottom
R12326  240ohm  [R-0402S0]  45.95 114.5 90 bottom
R12328  4.7K  [R-0402S0]  67.69 96.71 180 bottom
R12329  4.7K  [R-0402S0]  49.53 101.47 180 top
R12330  4.7K  [R-0402S0]  86.36 102.8 270 bottom
R12331  4.7K  [R-0402S0]  86.36 106.61 270 bottom
R12333  4.7Kohm  [R-0402S0]  59.82 96.27 270 top
R12334  22ohm  [R-0402S0]  42.42 94.49 0 bottom
R12335  22ohm  [R-0402S0]  60.33 94.36 180 top
R12336  22ohm  [R-0402S0]  57.64 100.53 0 bottom
R12337  4.7Kohm  [R-0402S0]  75.06 119.31 90 bottom
R12338  4.7Kohm  [R-0402S0]  142.12 198.74 90 bottom
R12339  33ohm  [R-0402S0]  55.71 100.46 270 top
R12342  4.7Kohm  [R-0402S0]  56.26 125.35 0 bottom
R12343  4.7Kohm  [R-0402S0]  54.36 124.71 180 bottom
R12344  22  [R-0402S0]  78.56 105.03 90 bottom
R12345  22  [R-0402S0]  55.15 129.39 0 bottom
R12346  8.2Kohm  [R-0402S0]  53.8 102.51 0 bottom
R12347  0ohm  [R-0402S0]  51 104.34 180 top
R12348  0ohm  [R-0402S0]  50.06 104.34 180 top
R12349  22  [R-0402S0]  72.52 127.51 0 top
R12351  22  [R-0402S0]  82.04 113.22 90 bottom
R12352  22  [R-0402S0]  78.75 115.02 90 bottom
R12353  22  [R-0402S0]  75.06 112.96 90 bottom
R12356  10Kohm  [R-0402S0]  46.86 103.89 90 top
R12357  2.2Kohm  [R-0402S0]  78.74 118.04 90 bottom
R12358  2.2Kohm  [R-0402S0]  78.74 116.77 90 bottom
R12359  4.7Kohm  [R-0402S0]  69.85 96.71 180 bottom
R12360  4.7Kohm  [R-0402S0]  69.85 100.52 180 bottom
R12361  4.7Kohm  [R-0402S0]  86.36 107.88 270 bottom
R12362  2.2Kohm  [R-0402S0]  43.18 84.71 270 bottom
R12363  2.2Kohm  [R-0402S0]  43.18 83.39 270 bottom
R12364  2.2Kohm  [R-0402S0]  43.18 81.28 270 bottom
R12365  4.7Kohm  [R-0402S0]  91.82 140.9 180 top
R12366  4.7Kohm  [R-0402S0]  94.87 140.9 180 top
R12367  4.7Kohm  [R-0402S0]  95.89 140.9 180 top
R12368  4.7Kohm  [R-0402S0]  104.46 140.97 270 top
R12369  22ohm  [R-0402S0]  43.18 82.42 90 bottom
R12370  4.7Kohm  [R-0402S0]  97.92 140.9 0 top
R12371  22  [R-0402S0]  98.93 140.9 0 top
R12372  4.7Kohm  [R-0402S0]  92.84 140.9 0 top
R12373  4.7Kohm  [R-0402S0]  100.46 140.9 180 top
R12374  4.7Kohm  [R-0402S0]  109.22 140.9 0 top
R12375  49.9Kohm  [R-0402S0]  59.41 125.8 180 top
R12376  2.74Kohm  [R-0402S0]  58.4 125.8 180 top
R12377  4.7Kohm  [R-0402S0]  72.39 100.52 180 bottom
R12378  4.7Kohm  [R-0402S0]  82.55 102.8 270 bottom
R12379  4.7Kohm  [R-0402S0]  71.12 100.52 180 bottom
R12380  4.7Kohm  [R-0402S0]  71.51 127.51 180 top
R12381  4.7Kohm  [R-0402S0]  46.33 97.48 180 bottom
R12382  4.7Kohm  [R-0402S0]  48.87 95.2 0 bottom
R12383  4.7Kohm  [R-0402S0]  51.41 95.2 0 bottom
R12384  4.7Kohm  [R-0402S0]  86.36 101.53 270 bottom
R12385  4.7Kohm  [R-0402S0]  62.72 100.53 180 bottom
R12386  4.7Kohm  [R-0402S0]  46.33 95.2 0 bottom
R12387  4.7Kohm  [R-0402S0]  45.06 97.48 180 bottom
R12388  4.7Kohm  [R-0402S0]  62.72 96.72 180 bottom
R12389  4.7Kohm  [R-0402S0]  58.91 100.53 180 bottom
R12390  4.7Kohm  [R-0402S0]  61.45 96.72 180 bottom
R12391  4.7Kohm  [R-0402S0]  58.91 96.72 180 bottom
R12392  4.7Kohm  [R-0402S0]  72.39 96.71 180 bottom
R12393  4.7Kohm  [R-0402S0]  48.87 97.48 180 bottom
R12394  4.7Kohm  [R-0402S0]  73.66 96.71 180 bottom
R12395  4.7Kohm  [R-0402S0]  50.14 95.2 0 bottom
R12396  4.7Kohm  [R-0402S0]  74.93 96.71 180 bottom
R12397  4.7Kohm  [R-0402S0]  47.6 95.2 0 bottom
R12398  4.7Kohm  [R-0402S0]  63.99 100.53 180 bottom
R12399  4.7Kohm  [R-0402S0]  63.99 96.72 180 bottom
R12400  4.7Kohm  [R-0402S0]  61.45 100.53 180 bottom
R12401  4.7Kohm  [R-0402S0]  59.33 94.36 180 top
R12402  4.7Kohm  [R-0402S0]  50.14 97.48 180 bottom
R12403  4.7Kohm  [R-0402S0]  43.94 97.54 180 bottom
R12404  4.7Kohm  [R-0402S0]  59.69 98.5 90 top
R12405  4.7Kohm  [R-0402S0]  60.18 100.53 180 bottom
R12406  4.7Kohm  [R-0402S0]  54.74 96.27 180 bottom
R12407  4.7Kohm  [R-0402S0]  52.45 95.12 0 bottom
R12408  4.7Kohm  [R-0402S0]  51.41 97.48 180 bottom
R12409  4.7Kohm  [R-0402S0]  47.6 97.48 180 bottom
R12410  4.7Kohm  [R-0402S0]  60.18 96.72 180 bottom
R12411  4.7Kohm  [R-0402S0]  52.45 97.54 180 bottom
R12412  4.7Kohm  [R-0402S0]  45.06 95.2 0 bottom
R12413  3.3Kohm  [R-0402S0]  70.23 127.51 0 top
R12416  1Kohm  [R-0402S0]  42.44 130.46 180 top
R12417  100Kohm  [R-0402S0]  47.98 128.6 0 bottom
R12420  22  [R-0402S0]  43.5 130.46 180 top
R12428  16.5Kohm  [R-0402S0]  59.44 204.85 90 top
R12430  0ohm  [R-0603S0]  59.6 200.96 270 top
R12434  3.6Kohm  [R-0603S0]  58.29 202.44 270 top
R12435  0ohm  [R-0603S0]  67.93 140.27 270 bottom
R12436  0ohm  [R-0603S0]  83.29 138.14 90 top
R12437  22ohm  [R-0402S0]  84.4 79.88 270 bottom
R12438  22ohm  [R-0402S0]  84.2 81.79 180 bottom
R12439  4.7K  [R-0402S0]  189.94 119.3 0 top
R12440  4.7K  [R-0402S0]  189.94 117.5 0 top
R12441  150ohm  [R-0402S0]  183.13 148.52 180 bottom
R12442  150ohm  [R-0402S0]  184.15 148.52 180 bottom
R12443  150ohm  [R-0402S0]  185.67 148.52 180 bottom
R12444  150ohm  [R-0402S0]  186.69 148.52 180 bottom
R12445  150ohm  [R-0402S0]  186.56 152.71 270 bottom
R12446  150ohm  [R-0402S0]  186.56 151.69 270 bottom
R12447  33ohm  [R-0402S0]  183.13 148.52 180 top
R12448  33ohm  [R-0402S0]  184.15 148.52 180 top
R12449  33ohm  [R-0402S0]  185.67 148.52 180 top
R12450  33ohm  [R-0402S0]  186.69 148.52 180 top
R12451  33ohm  [R-0402S0]  186.56 152.71 270 top
R12452  33ohm  [R-0402S0]  186.56 151.69 270 top
R12453  33ohm  [R-0402S0]  171.29 84.52 270 top
R12454  33ohm  [R-0402S0]  171.26 85.54 270 top
R12455  33ohm  [R-0402S0]  171.26 87.77 270 top
R12460  4.7Kohm  [R-0402S0]  138.3 116.13 180 bottom
R12461  4.7Kohm  [R-0402S0]  139.44 116.13 180 bottom
R12462  4.7Kohm  [R-0402S0]  138.3 116.13 0 top
R12463  4.7Kohm  [R-0402S0]  139.44 116.13 0 top
R12464  4.7K  [R-0402S0]  137.16 116.13 180 top
R12465  4.7Kohm  [R-0402S0]  136.14 116.13 180 top
R12466  4.7Kohm  [R-0402S0]  136.14 116.13 0 bottom
R12468  100Kohm  [R-0402S0]  280.27 198.11 90 bottom
R12469  4.7Kohm  [R-0402S0]  75.06 102.36 270 bottom
R12470  33ohm  [R-0402S0]  85 125.66 180 top
R12471  4.7Kohm  [R-0402S0]  46.72 79.62 0 bottom
R12473  100ohm  [R-0402S0]  9.31 80.86 90 top
R12474  100ohm  [R-0402S0]  154.28 136.02 90 top
R12475  100ohm  [R-0402S0]  149.28 135.03 180 top
R12477  4.7K  [R-0402S0]  188.09 138.99 270 top
R12478  4.7K  [R-0402S0]  188.09 137.72 270 top
R12479  4.7Kohm  [R-0402S0]  86.06 125.66 0 top
R12480  4.7Kohm  [R-0402S0]  87.08 125.66 0 top
R12482  100ohm  [R-0402S0]  150.49 125.66 180 top
R12484  4.7Kohm  [R-0402S0]  17.91 92.33 270 bottom
R12485  33ohm  [R-0402S0]  109.98 85.78 270 top
R12486  10Kohm  [R-0402S0]  133.73 196.47 90 top
R12487  4.7Kohm  [R-0402S0]  82.5 171.79 90 bottom
R12499  0ohm  [R-0402S0]  140.17 170.62 0 top
R12500  0ohm  [R-0402S0]  141.44 170.62 0 top
R12699  10Kohm  [R-0402S0]  161.39 147.87 180 top
R12700  910Kohm  [R-0402S0]  163.64 142.03 90 top
R12701  0ohm  [R-0402S0]  106.49 126.11 270 top
R12702  0ohm  [R-0402S0]  106.49 125.04 270 top
R12703  0ohm  [R-0402S0]  106.49 127.2 270 top
R12704  4.7Kohm  [R-0402S0]  80.7 171.79 270 bottom
R12705  4.7Kohm  [R-0402S0]  47.74 79.62 0 bottom
R12709  0ohm  [R-0402S0]  119.36 170.62 180 top
R12710  910Kohm  [R-0402S0]  162.93 148.28 90 top
R12712  10Kohm  [R-0402S0]  95.76 131.19 90 top
R12715  4.7K  [R-0402S0]  82.55 116.77 270 bottom
R12716  4.7K  [R-0402S0]  82.55 118.04 270 bottom
R12717  4.7Kohm  [R-0402S0]  75.06 107.88 270 bottom
R12719  22  [R-0402S0]  68.96 127.51 180 top
R12720  4.7Kohm  [R-0402S0]  78.74 110.42 90 bottom
R12721  4.7Kohm  [R-0402S0]  75.06 110.42 90 bottom
R12722  4.7Kohm  [R-0402S0]  75.06 109.15 270 bottom
R12723  4.7Kohm  [R-0402S0]  78.74 109.15 270 bottom
R12724  22ohm  [R-0402S0]  7.62 46.61 180 top
R12725  22ohm  [R-0402S0]  8.64 46.61 180 top
R12728  22  [R-0402S0]  82.55 119.31 90 bottom
R12729  2.2Kohm  [R-0402S0]  75.06 116.77 90 bottom
R12730  22  [R-0402S0]  101.47 140.9 0 top
R12731  10Kohm  [R-0402S0]  62.59 125.75 270 top
R12732  10Kohm  [R-0402S0]  61.76 123.31 180 bottom
R12733  10Kohm  [R-0402S0]  60.81 127.96 270 top
R12734  10Kohm  [R-0402S0]  60.81 126.82 270 top
R12749  100ohm  [R-0402S0]  12.83 80.86 90 top
R12750  0ohm  [R-0402S0]  159.77 137.09 180 top
R12751  0ohm  [R-0402S0]  158.75 137.09 180 top
R12752  33ohm  [R-0402S0]  143.76 122.87 90 top
R12753  33ohm  [R-0402S0]  143.76 121.85 90 top
