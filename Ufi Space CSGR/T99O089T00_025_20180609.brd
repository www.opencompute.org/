# Allegro board T99O089T00_025_20180609.brd (continued)
## Nets (continued)
CLK_MAC_SRD_REFCLK_OUT2: R2.1 U1.AN36(SRD_REFCLK_OUT_2)
CLK_MAC_SRD_REFCLK_OUT3: R3.1 U1.AL36(SRD_REFCLK_OUT_3)
CLK_MAC_SYNCE_RCVD1_DN: C2363.1 R1.2 R9.1
CLK_MAC_SYNCE_RCVD1_DP: C2362.1 R6.2 R10.1
CLK_MAC_SYNCE_RCVD2_DN: C2365.1 R3.2 R7.1
CLK_MAC_SYNCE_RCVD2_DP: C2364.1 R2.2 R8.1
CLK_MAC_SYNCE_REFCLK1_DN: C2363.2 R12473.2 R12801.2 R12808.1 U139.M11(IN3_NEG)
CLK_MAC_SYNCE_REFCLK1_DP: C2362.2 R12473.1 R12802.2 R12809.1 U139.M12(IN3_POS)
CLK_MAC_SYNCE_REFCLK2_DN: C2365.2 R12474.2 U135.44(I\N\0\)
CLK_MAC_SYNCE_REFCLK2_DP: C2364.2 R12474.1 U135.43(IN0)
CLK_MAC_TS_BIT_CLK0: R71.1 R1451.2 U1.AD30(TS_BIT_CLK0)
CLK_MAC_TS_BIT_CLK1: R1448.2 R12941.1 U1.AD29(TS_BIT_CLK1)
CLK_MAC_TS_SYNC1: R12819.2 R12927.1 U1.AC30(TS_SYNC1)
CLK_NIC1_OSC_OE: R1271.1 X4.1(ENABLE CONTROL)
CLK_NIC1_XTAL1: R1210.2 U85.46(XTAL1)
CLK_NIC1_XTAL1_IN: C1622.2 R1210.1 Y2.1
CLK_NIC1_XTAL2: R1211.2 U85.45(XTAL2)
CLK_NIC1_XTAL2_OUT: C1623.2 R1211.1 Y2.3
CLK_OUT_BITS_OSCI: R1617.2 U127.61(CLK_GEN)
CLK_PHY1_SYNCE_RCVD2_DN: C2159.1 R275.1 U23.R7(RX_XCL_KN)
CLK_PHY1_SYNCE_RCVD2_DP: C2158.1 R273.1 U23.T7(RX_XCL_KP)
CLK_PHY1_SYNCE_RCVD_DN: C2407.1 R274.2 U23.T9(RX_PCL_KN)
CLK_PHY1_SYNCE_RCVD_DP: C2408.1 R272.2 U23.T10(RX_PCL_KP)
CLK_PHY1_SYNCE_REFCLK2_DN: C2159.2 R12475.2 U135.2(I\N\1\)
CLK_PHY1_SYNCE_REFCLK2_DP: C2158.2 R12475.1 U135.1(IN1)
CLK_PHY1_SYNCE_REFCLK_DN: C2407.2 R12812.2 R12813.1 R12914.2 U139.J11(IN6_NEG)
CLK_PHY1_SYNCE_REFCLK_DP: C2408.2 R12810.2 R12811.1 R12914.1 U139.J12(IN6_POS)
CLK_PHY3_SYNCE_RCVDA_DN: C2382.1 R13071.2 U25.D9(LPTESTA_N)
CLK_PHY3_SYNCE_RCVDA_DP: C2381.1 R13070.2 U25.E9(LPTESTA_P)
CLK_PHY3_SYNCE_RCVDB_DN: R12937.2 R12939.1 R13027.1 R13085.2 U25.V10(LPTESTB_N) U139.K11(IN5_NEG)
CLK_PHY3_SYNCE_RCVDB_DP: R12936.2 R12938.1 R13026.1 R13085.1 U25.U10(LPTESTB_P) U139.K12(IN5_POS)
CLK_PHY3_SYNCE_REFCLK1_DN: C2382.2 R12749.2 R12804.1 R12806.2 U139.L11(IN4_NEG)
CLK_PHY3_SYNCE_REFCLK1_DP: C2381.2 R12749.1 R12803.1 R12807.2 U139.L12(IN4_POS)
CLK_PTP_1PPS_APLL1: R12795.1 U170.1(NO)
CLK_PTP_1PPS_DPLL_BUFF: R1915.1 R1917.1
CLK_PTP_1PPS_DPLL_OUT: U170.4(COM) U175.1(CLK_IN)
CLK_PTP_1PPS_DPLL_OUT1: R1916.2 R1917.2 U168.1(CLK_IN)
CLK_PTP_1PPS_DPLL_TO_MAC: R1447.1 R1918.1 U1.AA33(GPIO1)
CLK_PTP_1PPS_DPLL_TO_PHY1: R12943.1 U23.F8(SYNC_OUT)
CLK_PTP_1PPS_DPLL_TO_PHY3: R12942.1 U25.K16(SYNC_OUT_AB)
CLK_PTP_1PPS_FRSYNC: R12800.1 U170.3(NC)
CLK_PTP_1PPS_MAC_TO_DPLL: R70.2 U139.H10(IN10)
CLK_PTP_1PPS_MAC_TO_SMA: R1914.1 R12925.2
CLK_PTP_1PPS_MFRSYNC: R1916.1 R12790.1
CLK_PTP_4K_DPLL_OUT: R1663.1 U174.1(CLK_IN)
CLK_PTP_4K_DPLL_TO_MAC: R1452.2 R12928.1 U1.AC29(TS_SYNC0)
CLK_PTP_4K_DPLL_TO_PHY1: R12930.1 U23.F7(SYNC_IN)
CLK_PTP_4K_DPLL_TO_PHY3: R12929.1 U25.K15(SYNC_IN_AB)
CLK_PTP_10M_MAC_TO_DPLL: R71.2 U139.F10(IN12)
CLK_PTP_10M_MAC_TO_SMA: R1902.1 R12941.2
CLKGEN_54M_XTAL_IN: U135.6(XB) Y1.1 Y3.3
CLKGEN_54M_XTAL_OUT: U135.5(XA) Y1.3 Y3.1
CPLD_CONF_DONE: R999.2 U70.C5(CONF_DONE)
CPLD_CONFIG_EN: R996.2 U70.E7(NCONFIG)
CPLD_CONFIG_SEL: R1697.2 R1701.2 U70.D7(IO_8_12) U154.A19(GPIOF5/NRTS4/SIOSCI#)
CPLD_CRC_ERROR: R997.2 U70.D6(CRC_ERROR)
CPLD_OSC_OE: R994.1 X1.1(ENABLE CONTROL)
CPLD_REV0: R1699.2 R1708.2 U70.G4(IO_1_11)
CPLD_STATUS_N: R998.2 U70.C4(NSTATUS)
CPU_BOOT_DONE: J1.B78(PCIE0_TX15_P) R1759.2 U154.C14(GPIOE6/TXD3)
CPU_CATERR_L: J1.A50(RSVD_6) R1760.2 U154.A2(GPIOC2/SD1DAT0/SCL11)
CPU_I2C0_BUFF_EN: R1981.2 R1987.1 R12728.2 U71.1(EN)
CPU_ME_RCVR_L: J1.B79(PCIE0_TX15_N) R1752.2 U154.C4(GPIOC0/SD1CLK/SCL10)
CPU_PROCHOT_L: J1.B51(PCIE0_TX8_N) R1751.2 U154.B3(GPIOC1/SD1CMD/SDA10)
CPU_PRSNT_L: J1.A1(PRSNT#1) R1705.2 U70.J8(IO_3_27) U154.C1(GPIOK2/SCL6)
CPU_PWRGD: J1.A11(PWRGD) R1657.2 U137.1(NC) U137.2(A) U138.2(A)
CPU_THERMTRIP_L: J1.B50(PCIE0_TX8_P) R1750.2 U145.2(INA) U154.E5(GPIOC3/SD1DAT1/SDA11)
CPU_TO_BMC_PWRGD: U137.4(Y) U154.B14(GPIOE7/RXD3)
CPU_TO_CPLD_PWRGD: U70.K8(IO_3_28) U138.4(Y)
DDR3_BMC_AD0: U154.AB14(MA0) U155.N3(A0)
DDR3_BMC_AD1: U154.W15(MA1) U155.P7(A1)
DDR3_BMC_AD2: U154.V15(MA2) U155.P3(A2)
DDR3_BMC_AD3: U154.Y16(MA3) U155.N2(A3)
DDR3_BMC_AD4: U154.AB15(MA4) U155.P8(A4)
DDR3_BMC_AD5: U154.W16(MA5) U155.P2(A5)
DDR3_BMC_AD6: U154.AA15(MA6) U155.R8(A6)
DDR3_BMC_AD7: U154.AB18(MA7) U155.R2(A7)
DDR3_BMC_AD8: U154.AB16(MA8) U155.T8(A8)
DDR3_BMC_AD9: U154.AA17(MA9) U155.R3(A9)
DDR3_BMC_AD10: U154.Y15(MA10) U155.L7(A10/AP)
DDR3_BMC_AD11: U154.AA16(MA11) U155.R7(A11)
DDR3_BMC_AD12: U154.W17(MA12) U155.N7(A12/\B\C)
DDR3_BMC_AD13: U154.Y17(MA13) U155.T3(A13/NC_6)
DDR3_BMC_AD14: U154.AB17(MA14) U155.T7(A14/NC_7)
DDR3_BMC_BA0: U154.W14(MBA0) U155.M2(BA0)
DDR3_BMC_BA1: U154.AA14(MBA1) U155.N8(BA1)
DDR3_BMC_BA2: U154.Y14(MBA2) U155.M3(BA2)
DDR3_BMC_CAS_N: U154.AB13(MCAS#) U155.K3(\\C\A\S)
DDR3_BMC_CKE: U154.Y12(MCKE) U155.K9(CKE)
DDR3_BMC_CLK_DN0: R12315.1 U154.AA12(MCK#) U155.K7(\\C\K)
DDR3_BMC_CLK_DP0: R12315.2 U154.AB12(MCK) U155.J7(CK)
DDR3_BMC_CS0_N: U154.AA13(MCS#) U155.L2(\\C\S)
DDR3_BMC_DM0: U154.W10(MDM0) U155.E7(DML)
DDR3_BMC_DM1: U154.V8(MDM1) U155.D3(DMU)
DDR3_BMC_DQ0: U154.W12(MDQ0) U155.H7(DQL7)
DDR3_BMC_DQ1: U154.V12(MDQ1) U155.H3(DQL4)
DDR3_BMC_DQ2: U154.AB11(MDQ2) U155.F8(DQL3)
DDR3_BMC_DQ3: U154.AA11(MDQ3) U155.F7(DQL1)
DDR3_BMC_DQ4: U154.Y11(MDQ4) U155.F2(DQL2)
DDR3_BMC_DQ5: U154.W11(MDQ5) U155.G2(DQL6)
DDR3_BMC_DQ6: U154.V11(MDQ6) U155.H8(DQL5)
DDR3_BMC_DQ7: U154.Y10(MDQ7) U155.E3(DQL0)
DDR3_BMC_DQ8: U154.V10(MDQ8) U155.D7(DQU0)
DDR3_BMC_DQ9: U154.AB9(MDQ9) U155.B8(DQU6)
DDR3_BMC_DQ10: U154.AA9(MDQ10) U155.A7(DQU4)
DDR3_BMC_DQ11: U154.Y9(MDQ11) U155.C3(DQU1)
DDR3_BMC_DQ12: U154.W9(MDQ12) U155.C2(DQU3)
DDR3_BMC_DQ13: U154.V9(MDQ13) U155.C8(DQU2)
DDR3_BMC_DQ14: U154.Y8(MDQ14) U155.A3(DQU7)
DDR3_BMC_DQ15: U154.W8(MDQ15) U155.A2(DQU5)
DDR3_BMC_DQS_DN0: U154.AA10(MDQS0#) U155.G3(\\D\Q\S\L)
DDR3_BMC_DQS_DN1: U154.AB8(MDQS1#) U155.B7(\\D\Q\S\U)
DDR3_BMC_DQS_DP0: U154.AB10(MDQS0) U155.F3(DQSL)
DDR3_BMC_DQS_DP1: U154.AA8(MDQS1) U155.C7(DQSU)
DDR3_BMC_MVREF: C2169.2 C2170.2 C2244.1 R12313.1 R12314.2 R12988.2 U154.V13(MVREF)
DDR3_BMC_ODT: U154.V14(MODT) U155.K1(ODT)
DDR3_BMC_RAS_N: U154.W13(MRAS#) U155.J3(\\R\A\S)
DDR3_BMC_WE_N: U154.Y13(MWE#) U155.L3(\\W\E)
DDR3_BMC_ZQ: R12326.1 U155.L8(ZQ)
DDR3_DRAM_MVREF: C2240.1 C2241.1 R12306.1 R12308.2 R12988.1 U155.H1(VREFDQ) U155.M8(VREFCA)
EEPROM_ADDR0: R1686.1 R1692.2 U140.1(A0)
EEPROM_ADDR0_SYS: R1097.1 R1101.2 U81.1(A0)
EEPROM_ADDR1: R1687.1 R1693.2 U140.2(A1) U140.3(A2)
EEPROM_ADDR1_SYS: R1098.1 R1102.2 U81.2(A1)
EEPROM_ADDR2_SYS: R13030.1 R13031.2 U81.3(A2)
EEPROM_WP: R1688.1 R1691.2 U140.7(WP)
EEPROM_WP_SYS: R1099.1 R1100.2 U81.7(WP)
FAN1_PRSNT_N: J5.1 R1118.1 U70.C11(IO_6_17)
FAN1_PWM_CTRL: J5.5 R12950.2 R12954.2
FAN1_TACH_IN: C1551.1 C1555.1 J5.3 R1107.2 R1113.1
FAN1_TACH_INT_INLET: C1552.1 Q3.1(G) Q4.3(C) R1104.2
FAN1_TACH_INT_INLET_N: C1551.2 R1105.1 R12993.2
FAN2_PRSNT_N: J5.9 R1119.1 U70.B11(IO_6_14)
FAN2_PWM_CTRL: J5.13 R12951.2 R12955.2
FAN2_TACH_IN: C1563.1 C1567.1 J5.11 R1108.2 R1114.1
FAN2_TACH_INT_INLET: C1565.1 Q8.1(G) Q10.3(C) R1132.2
FAN2_TACH_INT_INLET_N: C1563.2 R1134.1 R12994.2
FAN3_PRSNT_N: J5.17 R1120.1 U70.B13(IO_6_16)
FAN3_PWM_CTRL: J5.21 R12952.2 R12956.2
FAN3_TACH_IN: C1580.1 C1583.1 J5.19 R1109.2 R1115.1
FAN3_TACH_INT_INLET: C1581.1 Q16.1(G) Q18.3(C) R1144.2
FAN3_TACH_INT_INLET_N: C1580.2 R1146.1 R12995.2
FAN4_PRSNT_N: J5.2 R1121.1 U70.A10(IO_8_6)
FAN4_PWM_CTRL: J5.6 R12953.2 R12957.2
FAN4_TACH_IN: C1560.1 C1566.1 J5.4 R1110.2 R1116.1
FAN4_TACH_INT_INLET: C1562.1 Q7.1(G) Q9.3(C) R1131.2
FAN4_TACH_INT_INLET_N: C1560.2 R1133.1 R12996.2
FAN5_PRSNT_N: J5.10 R1122.1 U70.A11(IO_8_8)
FAN5_PWM_CTRL: J5.14 U200.4(COM)
FAN5_TACH_IN: C1577.1 C1582.1 J5.12 R1111.2 R1117.1
FAN5_TACH_INT_INLET: C1579.1 Q15.1(G) Q17.3(C) R1143.2
FAN5_TACH_INT_INLET_N: C1577.2 R1145.1 R12997.2
FAN45_TACH_SW: R12344.2 R13086.1 U70.D11(IO_6_22) U177.6(IN)
FAN_BMC_CNTRL: Q58.1(G) R12960.2 U154.A20(GPIOF2/NDSR4/SIOPWRGD) U176.1(1\O\E\) U200.6(IN)
GNSS_ANT_ON: R13006.2 U70.E10(IO_6_19) U124.14(ANT_ON)
GNSS_ANT_OPEN: R13008.1 U70.B2(IO_8_24) U183.4(OUT)
GNSS_ANT_PWREN: Q42.1(G) R13009.1 U70.A7(IO_8_13)
GNSS_ANT_SHORT_N: L164.2 R1600.2 U70.B1(IO_1_4) U183.3(VIN+)
GNSS_RF_IN: C1990.1 U124.11(RF_IN)
GNSS_RF_RC: C1990.2 L164.1 R1628.1
GNSS_RF_SMA: D63.2(CATHODE) J10.1(RF) R1628.2
HW_REV_ID0: R1744.2 R1745.2 U150.16(P13)
HW_REV_ID1: R1746.2 R1747.2 U150.15(P12)
HWM_FAN1_PRSNT_N: R1118.2 R1124.2 U154.V6(GPIOO0/TACH0/VPIG8) U178.1(1A)
HWM_FAN1_PWM_CTRL: R1013.2 U73.17(FPWM1/GPIO5) U176.2(1A1)
HWM_FAN1_TACH_IN: R1113.2 U73.31(PWM1/GPI1) U154.Y5(GPIOO1/TACH1/VPIG9)
HWM_FAN1TO4_PRSNT_N: U178.10(3B) U178.11(4Y)
HWM_FAN2_PRSNT_N: R1119.2 R1125.2 U154.AA4(GPIOO2/TACH2/VPIR0) U178.2(1B)
HWM_FAN2_PWM_CTRL: R1014.2 U73.18(FPWM2/GPIO6) U176.4(1A2)
HWM_FAN2_TACH_IN: R1114.2 U73.32(PWM2/GPI2) U154.AB3(GPIOO3/TACH3/VPIR1)
HWM_FAN3_PRSNT_N: R1120.2 R1126.2 U154.W6(GPIOO4/TACH4/VPIR2) U178.4(2A)
HWM_FAN3_PWM_CTRL: R1015.2 U73.19(FPWM3/GPIO7) U176.6(1A3)
HWM_FAN3_TACH_IN: R1115.2 U73.42(PWM3/GPI3) U154.AA5(GPIOO5/TACH5/VPIR3)
HWM_FAN4_PRSNT_N: R1121.2 R1127.2 U154.AB4(GPIOO6/TACH6/VPIR4) U178.5(2B)
HWM_FAN4_PWM_CTRL: R1016.2 U73.20(FPWM4/GPIO8) U176.8(1A4) U200.3(NC)
HWM_FAN4_TACH_IN: R1116.2 U154.V7(GPIOO7/TACH7/VPIR5) U177.1(NO)
HWM_FAN5_PRSNT_N: R1122.2 R1128.2 U154.Y6(GPIOP0/TACH8/VPIR6) U178.9(3A)
HWM_FAN5_TACH_IN: R1117.2 U154.AB5(GPIOP1/TACH9/VPIR7) U177.3(NC)
HWM_FAN12_PRSNT_N: U178.3(1Y) U178.13(4B)
HWM_FAN34_PRSNT_N: U178.6(2Y) U178.12(4A)
HWM_FAN45_TACH_IN: U73.41(PWM4/GPI4) U177.4(COM)
HWM_FAN_PRSNT_N: U73.35(GPIO18) U178.8(3Y)
HWM_JTAG_TRCK: R1031.2 U73.10(TRCK)
HWM_JTAG_TRST_N: R1032.2 U73.40(\\T\R\S\T)
HWM_P1V8_BPCAP: C1411.1 C2442.1 U73.47(BPCAP)
HWM_P3V3_BMC_EN: R12970.2 U73.39(TMS/GPIO22)
I2C0_HWM_MUX_SEL: R12471.1 R12705.1 U70.K10(IO_5_1) U156.6(IN) U173.6(IN)
I2C0_HWM_SCL: J5.22 R1035.1 R1043.1 U74.2(SCL) U156.4(COM) U185.2(SCL)
I2C0_HWM_SDA: J5.24 R1036.1 R1044.1 U74.1(SDA) U173.4(COM) U185.1(SDA)
I2C0_MGMT_MUX_SEL: R12487.1 R12704.1 U70.B6(IO_8_15) U165.6(IN) U172.6(IN)
I2C0_MISC_SCL: R50.1 R952.1 U67.12(SC3) U81.6(SCL)
I2C0_MISC_SDA: R51.1 R953.1 U67.11(SD3) U81.5(SDA)
I2C0_PCH_SCL: J1.B5(SMBCLK) R1754.2 R1985.2 U71.3(SCLIN)
I2C0_PCH_SDA: J1.B6(SMBDAT) R1755.2 R1986.2 U71.6(SDAIN)
I2C0_PSU1_SCL: C1594.1 CN3.A2 D54.2(C) R948.1 U67.7(SC1)
I2C0_PSU1_SDA: C1593.1 CN3.B3 D55.2(C) R949.1 U67.6(SD1)
I2C0_PSU2_SCL: C1600.1 CN3.C5 D52.2(C) R946.1 U67.5(SC0)
I2C0_PSU2_SDA: C1599.1 CN3.C4 D53.2(C) R947.1 U67.4(SD0)
I2C0_PWR_SCL: R744.2 R950.1 U67.10(SC2)
I2C0_PWR_SDA: R749.2 R951.1 U67.9(SD2)
I2C0_SYS_SCL: R971.2 R1982.1 R1985.1 R1997.2 U71.2(SCLOUT) U111.1(NO) U156.1(NO) U165.1(NO)
I2C0_SYS_SDA: R970.2 R1983.1 R1986.1 R1996.2 U71.7(SDAOUT) U112.1(NO) U172.1(NO) U173.1(NO)
I2C1_BMC_ALRT_N: R12328.2 U99.4(OUTY) U154.J21(GPIOB0/SALT1)
I2C1_BMC_SCL: R12316.2 U154.K21(SCL1) U156.3(NC)
I2C1_BMC_SDA: R12317.2 U154.K22(SDA1) U173.3(NC)
I2C2_BMC_ALRT_N: R12329.2 U102.4(OUTY) U154.J20(GPIOB1/SALT2)
I2C2_BMC_SCL: R12318.2 U154.J19(SCL2) U165.3(NC)
I2C2_BMC_SDA: R12319.2 U154.J18(SDA2) U172.3(NC)
I2C2_PCH_SCL: J1.A76(PCIE0_RX14_P) R12499.1
I2C2_PCH_SDA: J1.A77(PCIE0_RX14_N) R12500.1
I2C3_BMC_SCL: R12320.2 U111.3(NC) U154.D3(GPIOQ0/SCL3)
I2C3_BMC_SDA: R12321.2 U112.3(NC) U154.C2(GPIOQ1/SDA3)
I2C4_BMC_SCL: R1207.1 R12322.2 R12499.2 U154.B1(GPIOQ2/SCL4)
I2C4_BMC_SDA: R1208.1 R12323.2 R12500.2 U154.F5(GPIOQ3/SDA4)
I2C4_NIC_ARLT_N: R1209.1 R12331.2 U154.F18(GPIOB3/SALT4)
I2C_BUFF_READY: R1984.2 U71.5(READY)
I2C_CLK_SCL: R1675.1 R1898.2 R1994.1 U76.12(SC3)
I2C_CLK_SDA: R1676.1 R1897.2 R1995.1 U76.11(SD3)
I2C_CPLD_ALRT_N: J1.B10(P3.3VAUX) R1713.2 R12330.2 U70.C12(IO_6_15) U154.H18(GPIOB2/SALT3)
I2C_CPLD_MUX_EN: R12470.1 U70.A6(IO_8_14)
I2C_CPLD_MUX_SEL: R12470.2 R12479.1 R12480.1 U111.6(IN) U112.6(IN) U154.Y2(GPIOM5/NRTS2/VPIB7)
I2C_CPLD_SCL: U70.L11(IO_3_26) U111.4(COM)
I2C_CPLD_SDA: U70.K11(IO_5_2) U112.4(COM)
I2C_GNSS_SCL: R1606.1 R1990.1 U76.7(SC1)
I2C_GNSS_SDA: R1605.1 R1991.1 U76.6(SD1)
I2C_HWM_ADDR0: R1039.2 R1042.1 U73.61(PMBUS_ADDR0)
I2C_HWM_ADDR1: R1038.2 R1041.1 U73.60(PMBUS_ADDR1)
I2C_HWM_ALERT_N: R1027.2 R1037.2 U73.27(PMBALERT#)
I2C_HWM_CLK: J3.3 R1025.2 R1035.2 U73.15(PMBUS_CLK)
I2C_HWM_CNTRL: R1028.2 U73.28(PMBUS_CNTRL) U154.V5(GPIOM7/RXD2/VPIB9)
I2C_HWM_DAT: J3.2 R1026.2 R1036.2 U73.16(PMBUS_DATA)
I2C_IOP_ABS0_ADDR0: R656.1 R663.2 U47.21(A0)
I2C_IOP_ABS0_ADDR1: R657.1 R664.2 U47.2(A1)
I2C_IOP_ABS0_ADDR2: R658.1 R665.2 U47.3(A2)
I2C_IOP_ABS0_SCL: R653.1 U47.22(SCL)
I2C_IOP_ABS0_SDA: R655.1 U47.23(SDA)
I2C_IOP_ABS1_ADDR0: R674.1 R681.2 U49.21(A0)
I2C_IOP_ABS1_ADDR1: R675.1 R682.2 U49.2(A1)
I2C_IOP_ABS1_ADDR2: R676.1 R683.2 U49.3(A2)
I2C_IOP_ABS1_SCL: R671.1 U49.22(SCL)
I2C_IOP_ABS1_SDA: R673.1 U49.23(SDA)
I2C_IOP_ALRM_ADDR0: R1875.1 R1878.2 U150.21(A0)
I2C_IOP_ALRM_ADDR1: R1876.1 R1879.2 U150.2(A1)
I2C_IOP_ALRM_ADDR2: R1877.1 R1880.2 U150.3(A2)
I2C_IOP_ALRM_SCL: R1873.1 U150.22(SCL)
I2C_IOP_ALRM_SDA: R1874.1 U150.23(SDA)
I2C_IOP_DIS0_ADDR0: R714.1 R720.2 U54.21(A0)
I2C_IOP_DIS0_ADDR1: R715.1 R721.2 U54.2(A1)
I2C_IOP_DIS0_ADDR2: R716.1 R722.2 U54.3(A2)
I2C_IOP_DIS0_SCL: R708.1 U54.22(SCL)
I2C_IOP_DIS0_SDA: R713.1 U54.23(SDA)
I2C_IOP_DIS1_ADDR0: R732.1 R738.2 U56.21(A0)
I2C_IOP_DIS1_ADDR1: R733.1 R739.2 U56.2(A1)
I2C_IOP_DIS1_ADDR2: R734.1 R740.2 U56.3(A2)
I2C_IOP_DIS1_SCL: R726.1 U56.22(SCL)
I2C_IOP_DIS1_SDA: R728.1 U56.23(SDA)
I2C_IOP_FLT0_ADDR0: R710.1 R717.2 U53.21(A0)
I2C_IOP_FLT0_ADDR1: R711.1 R718.2 U53.2(A1)
I2C_IOP_FLT0_ADDR2: R712.1 R719.2 U53.3(A2)
I2C_IOP_FLT0_SCL: R707.1 U53.22(SCL)
I2C_IOP_FLT0_SDA: R709.1 U53.23(SDA)
I2C_IOP_FLT1_ADDR0: R729.1 R735.2 U55.21(A0)
I2C_IOP_FLT1_ADDR1: R730.1 R736.2 U55.2(A1)
I2C_IOP_FLT1_ADDR2: R731.1 R737.2 U55.3(A2)
I2C_IOP_FLT1_SCL: R725.1 U55.22(SCL)
I2C_IOP_FLT1_SDA: R727.1 U55.23(SDA)
I2C_IOP_FLT2_ADDR0: R746.1 R753.2 U57.21(A0)
I2C_IOP_FLT2_ADDR1: R747.1 R754.2 U57.2(A1)
I2C_IOP_FLT2_ADDR2: R748.1 R755.2 U57.3(A2)
I2C_IOP_LOS0_ADDR0: R660.1 R666.2 U48.21(A0)
I2C_IOP_LOS0_ADDR1: R661.1 R667.2 U48.2(A1)
I2C_IOP_LOS0_ADDR2: R662.1 R668.2 U48.3(A2)
I2C_IOP_LOS0_SCL: R654.1 U48.22(SCL)
I2C_IOP_LOS0_SDA: R659.1 U48.23(SDA)
I2C_IOP_LOS1_ADDR0: R678.1 R684.2 U50.21(A0)
I2C_IOP_LOS1_ADDR1: R679.1 R685.2 U50.2(A1)
I2C_IOP_LOS1_ADDR2: R680.1 R686.2 U50.3(A2)
I2C_IOP_LOS1_SCL: R672.1 U50.22(SCL)
I2C_IOP_LOS1_SDA: R677.1 U50.23(SDA)
I2C_IOP_QSFP28_SCL: R743.1 U57.22(SCL)
I2C_IOP_QSFP28_SDA: R745.1 U57.23(SDA)
I2C_IOP_RS0_ADDR0: R692.1 R699.2 U51.21(A0)
I2C_IOP_RS0_ADDR1: R693.1 R700.2 U51.2(A1)
I2C_IOP_RS0_ADDR2: R694.1 R701.2 U51.3(A2)
I2C_IOP_RS0_SCL: R689.1 U51.22(SCL)
I2C_IOP_RS0_SDA: R691.1 U51.23(SDA)
I2C_IOP_RS1_ADDR0: R696.1 R702.2 U52.21(A0)
I2C_IOP_RS1_ADDR1: R697.1 R703.2 U52.2(A1)
I2C_IOP_RS1_ADDR2: R698.1 R704.2 U52.3(A2)
I2C_IOP_RS1_SCL: R690.1 U52.22(SCL)
I2C_IOP_RS1_SDA: R695.1 U52.23(SDA)
I2C_IOP_VMG_ADDR0: R750.1 R756.2 U58.21(A0)
I2C_IOP_VMG_ADDR1: R751.1 R757.2 U58.2(A1)
I2C_IOP_VMG_ADDR2: R752.1 R758.2 U58.3(A2)
I2C_IOP_VMG_SCL: R744.1 U58.22(SCL)
I2C_IOP_VMG_SDA: R749.1 U58.23(SDA)
I2C_MAC_SCL: R50.2 U1.AC32(I2C_SCL)
I2C_MAC_SDA: R51.2 U1.AB31(I2C_SDA)
I2C_MGMT_MUX1_ADDR0: R958.1 R961.2 U67.1(A0)
I2C_MGMT_MUX1_ADDR1: R957.1 R960.2 U67.2(A1)
I2C_MGMT_MUX1_ADDR2: R956.1 R959.2 U67.13(A2)
I2C_MGMT_MUX1_SCL: R955.1 U67.14(SCL)
I2C_MGMT_MUX1_SDA: R954.1 U67.15(SDA)
I2C_MGMT_SCL: R955.2 U165.4(COM)
I2C_MGMT_SDA: R954.2 U172.4(COM)
I2C_MUX0_ADDR0: R2000.1 R2003.2 U76.1(A0)
I2C_MUX0_ADDR1: R1999.1 R2002.2 U76.2(A1)
I2C_MUX0_ADDR2: R1998.1 R2001.2 U76.13(A2)
I2C_MUX0_SCL: R1997.1 U76.14(SCL)
I2C_MUX0_SDA: R1996.1 U76.15(SDA)
I2C_MUX3_ADDR0: R845.1 R849.2 U62.1(A0)
I2C_MUX3_ADDR1: R844.1 R848.2 U62.2(A1)
I2C_MUX3_ADDR2: R842.1 R847.2 U62.21(A2)
I2C_MUX4_ADDR0: R869.1 R873.2 U63.1(A0)
I2C_MUX4_ADDR1: R868.1 R872.2 U63.2(A1)
I2C_MUX4_ADDR2: R867.1 R871.2 U63.21(A2)
I2C_MUX5_ADDR0: R891.1 R897.2 U64.1(A0)
I2C_MUX5_ADDR1: R893.1 R896.2 U64.2(A1)
I2C_MUX5_ADDR2: R890.1 R895.2 U64.21(A2)
I2C_MUX6_ADDR0: R914.1 R921.2 U65.1(A0)
I2C_MUX6_ADDR1: R917.1 R920.2 U65.2(A1)
I2C_MUX6_ADDR2: R916.1 R919.2 U65.21(A2)
I2C_QSFP28_MUX7_SCL: R987.1 U69.14(SCL)
I2C_QSFP28_MUX7_SDA: R986.1 U69.15(SDA)
I2C_QSFP28_P1_SCL: CJ12.U_11(U_SCL) R984.1 U69.12(SC3)
I2C_QSFP28_P1_SDA: CJ12.U_12(U_SDA) R985.1 U69.11(SD3)
I2C_QSFP28_P2_SCL: CJ12.L_11(L_SCL) R982.1 U69.10(SC2)
I2C_QSFP28_P2_SDA: CJ12.L_12(L_SDA) R983.1 U69.9(SD2)
I2C_QSFP28_P3_SCL: R980.1 U69.7(SC1)
I2C_QSFP28_P3_SDA: R981.1 U69.6(SD1)
I2C_QSFP28_P4_SCL: R978.1 U69.5(SC0)
I2C_QSFP28_P4_SDA: R979.1 U69.4(SD0)
I2C_SFP+_MUX2_SCL: R971.1 U68.14(SCL)
I2C_SFP+_MUX2_SDA: R970.1 U68.15(SDA)
I2C_SFP+_MUX3_SCL: R846.1 U62.22(SCL)
I2C_SFP+_MUX3_SDA: R843.1 U62.23(SDA)
I2C_SFP+_MUX4_SCL: R870.1 U63.22(SCL)
I2C_SFP+_MUX4_SDA: R866.1 U63.23(SDA)
I2C_SFP+_MUX5_SCL: R894.1 U64.22(SCL)
I2C_SFP+_MUX5_SDA: R892.1 U64.23(SDA)
I2C_SFP+_MUX6_SCL: R918.1 U65.22(SCL)
I2C_SFP+_MUX6_SDA: R915.1 U65.23(SDA)
I2C_SFP+_P00_SCL: CJ8.AT5(AT_SCL) R840.1 U62.5(SC0)
I2C_SFP+_P00_SDA: CJ8.AT4(AT_SDA) R841.1 U62.4(SD0)
I2C_SFP+_P01_SCL: CJ8.AL5(AL_SCL) R838.1 U62.7(SC1)
I2C_SFP+_P01_SDA: CJ8.AL4(AL_SDA) R839.1 U62.6(SD1)
I2C_SFP+_P02_SCL: CJ8.BT5(BT_SCL) R836.1 U62.9(SC2)
I2C_SFP+_P02_SDA: CJ8.BT4(BT_SDA) R837.1 U62.8(SD2)
I2C_SFP+_P03_SCL: CJ8.BL5(BL_SCL) R834.1 U62.11(SC3)
I2C_SFP+_P03_SDA: CJ8.BL4(BL_SDA) R835.1 U62.10(SD3)
I2C_SFP+_P04_SCL: CJ8.CT5(CT_SCL) R832.1 U62.14(SC4)
I2C_SFP+_P04_SDA: CJ8.CT4(CT_SDA) R833.1 U62.13(SD4)
I2C_SFP+_P05_SCL: CJ8.CL5(CL_SCL) R830.1 U62.16(SC5)
I2C_SFP+_P05_SDA: CJ8.CL4(CL_SDA) R831.1 U62.15(SD5)
I2C_SFP+_P06_SCL: CJ8.DT5(DT_SCL) R828.1 U62.18(SC6)
I2C_SFP+_P06_SDA: CJ8.DT4(DT_SDA) R829.1 U62.17(SD6)
I2C_SFP+_P07_SCL: CJ8.DL5(DL_SCL) R826.1 U62.20(SC7)
I2C_SFP+_P07_SDA: CJ8.DL4(DL_SDA) R827.1 U62.19(SD7)
I2C_SFP+_P08_SCL: CJ8.ET5(ET_SCL) R864.1 U63.5(SC0)
I2C_SFP+_P08_SDA: CJ8.ET4(ET_SDA) R865.1 U63.4(SD0)
I2C_SFP+_P09_SCL: CJ8.EL5(EL_SCL) R862.1 U63.7(SC1)
I2C_SFP+_P09_SDA: CJ8.EL4(EL_SDA) R863.1 U63.6(SD1)
I2C_SFP+_P10_SCL: CJ8.FT5(FT_SCL) R860.1 U63.9(SC2)
I2C_SFP+_P10_SDA: CJ8.FT4(FT_SDA) R861.1 U63.8(SD2)
I2C_SFP+_P11_SCL: CJ8.FL5(FL_SCL) R858.1 U63.11(SC3)
I2C_SFP+_P11_SDA: CJ8.FL4(FL_SDA) R859.1 U63.10(SD3)
I2C_SFP+_P12_SCL: CJ8.GT5(GT_SCL) R856.1 U63.14(SC4)
I2C_SFP+_P12_SDA: CJ8.GT4(GT_SDA) R857.1 U63.13(SD4)
I2C_SFP+_P13_SCL: CJ8.GL5(GL_SCL) R854.1 U63.16(SC5)
I2C_SFP+_P13_SDA: CJ8.GL4(GL_SDA) R855.1 U63.15(SD5)
I2C_SFP+_P14_SCL: CJ8.HT5(HT_SCL) R852.1 U63.18(SC6)
I2C_SFP+_P14_SDA: CJ8.HT4(HT_SDA) R853.1 U63.17(SD6)
I2C_SFP+_P15_SCL: CJ8.HL5(HL_SCL) R850.1 U63.20(SC7)
I2C_SFP+_P15_SDA: CJ8.HL4(HL_SDA) R851.1 U63.19(SD7)
I2C_SFP+_P16_SCL: CJ9.AT5(AT_SCL) R888.1 U64.5(SC0)
I2C_SFP+_P16_SDA: CJ9.AT4(AT_SDA) R889.1 U64.4(SD0)
I2C_SFP+_P17_SCL: CJ9.AB5(AB_SCL) R886.1 U64.7(SC1)
I2C_SFP+_P17_SDA: CJ9.AB4(AB_SDA) R887.1 U64.6(SD1)
I2C_SFP+_P18_SCL: CJ9.BT5(BT_SCL) R884.1 U64.9(SC2)
I2C_SFP+_P18_SDA: CJ9.BT4(BT_SDA) R885.1 U64.8(SD2)
I2C_SFP+_P19_SCL: CJ9.BB5(BB_SCL) R882.1 U64.11(SC3)
I2C_SFP+_P19_SDA: CJ9.BB4(BB_SDA) R883.1 U64.10(SD3)
I2C_SFP+_P20_SCL: CJ9.CT5(CT_SCL) R880.1 U64.14(SC4)
I2C_SFP+_P20_SDA: CJ9.CT4(CT_SDA) R881.1 U64.13(SD4)
I2C_SFP+_P21_SCL: CJ9.CB5(CB_SCL) R878.1 U64.16(SC5)
I2C_SFP+_P21_SDA: CJ9.CB4(CB_SDA) R879.1 U64.15(SD5)
I2C_SFP+_P22_SCL: CJ9.DT5(DT_SCL) R876.1 U64.18(SC6)
I2C_SFP+_P22_SDA: CJ9.DT4(DT_SDA) R877.1 U64.17(SD6)
I2C_SFP+_P23_SCL: CJ9.DB5(DB_SCL) R874.1 U64.20(SC7)
I2C_SFP+_P23_SDA: CJ9.DB4(DB_SDA) R875.1 U64.19(SD7)
I2C_SFP+_P24_SCL: CJ9.ET5(ET_SCL) R912.1 U65.5(SC0)
I2C_SFP+_P24_SDA: CJ9.ET4(ET_SDA) R913.1 U65.4(SD0)
I2C_SFP+_P25_SCL: CJ9.EB5(EB_SCL) R910.1 U65.7(SC1)
I2C_SFP+_P25_SDA: CJ9.EB4(EB_SDA) R911.1 U65.6(SD1)
I2C_SFP+_P26_SCL: CJ9.FT5(FT_SCL) R908.1 U65.9(SC2)
I2C_SFP+_P26_SDA: CJ9.FT4(FT_SDA) R909.1 U65.8(SD2)
I2C_SFP+_P27_SCL: CJ9.FB5(FB_SCL) R906.1 U65.11(SC3)
I2C_SFP+_P27_SDA: CJ9.FB4(FB_SDA) R907.1 U65.10(SD3)
I2C_SFP_IOP0_SCL: R653.2 R654.2 R671.2 R672.2 R966.1 U68.10(SC2)
I2C_SFP_IOP0_SDA: R655.2 R659.2 R673.2 R677.2 R967.1 U68.9(SD2)
I2C_SFP_IOP1_SCL: R689.2 R690.2 R707.2 R725.2 R964.1 U68.7(SC1)
I2C_SFP_IOP1_SDA: R691.2 R695.2 R709.2 R727.2 R965.1 U68.6(SD1)
I2C_SFP_IOP2_SCL: R708.2 R726.2 R743.2 R962.1 U68.5(SC0)
I2C_SFP_IOP2_SDA: R713.2 R728.2 R745.2 R963.1 U68.4(SD0)
I2C_SFP_MUX2_ADDR0: R974.1 R977.2 U68.1(A0)
I2C_SFP_MUX2_ADDR1: R973.1 R976.2 U68.2(A1)
I2C_SFP_MUX2_ADDR2: R972.1 R975.2 U68.13(A2)
I2C_SFP_MUX7_ADDR0: R990.1 R993.2 U69.1(A0)
I2C_SFP_MUX7_ADDR1: R989.1 R992.2 U69.2(A1)
I2C_SFP_MUX7_ADDR2: R988.1 R991.2 U69.13(A2)
I2C_SFP_MUX_SCL: R846.2 R870.2 R894.2 R918.2 R968.1 R987.2 U68.12(SC3)
I2C_SFP_MUX_SDA: R843.2 R866.2 R892.2 R915.2 R969.1 R986.2 U68.11(SD3)
I2C_SKUID_SCL: PR337.1 R1873.2 R1992.1 U76.10(SC2)
I2C_SKUID_SDA: PR338.1 R1874.2 R1993.1 U76.9(SD2)
I2C_SMU_EEPROM_SCL: R1690.1 U139.B11(MPU_MODE1/I2CM_SCL) U140.6(SCL)
I2C_SMU_EEPROM_SDA: R1689.1 U139.C11(MPU_MODE0/I2CM_SDA) U140.5(SDA)
I2C_SMU_SCL: R1652.1 R1675.2 U139.D10(I2C_SCL)
I2C_SMU_SDA: R1655.1 R1676.2 U139.C5(I2C_SDA)
I2C_TSEN1_ADDR0: R1029.1 R1033.2 U74.7(A0)
I2C_TSEN1_ADDR1: R1083.1 R1084.2 U74.6(A1)
I2C_TSEN1_ADDR2: R1030.1 R1034.2 U74.5(A2)
I2C_TSEN2_ADDR0: R13016.2 R13018.1 U185.7(A0)
I2C_TSEN2_ADDR1: R13020.2 R13021.1 U185.6(A1)
I2C_TSEN2_ADDR2: R13015.2 R13017.1 U185.5(A2)
I2C_TSEN_SCL: R1043.2 U75.8(SCL)
I2C_TSEN_SDA: R1044.2 U75.7(SDA)
IN_SEL0: R1777.1 R1779.2 U135.3(IN_SEL0)
IN_SEL1: R1776.1 R1778.2 U135.37(IN_SEL1)
INT1_GNSS_N: R1609.2 R1731.2 U70.F1(IO_1_6)
INT_ALRM0_N: R1884.2 U150.8(P04)
INT_ALRM1_N: R1883.2 U150.9(P05)
INT_ALRM2_N: R1882.2 U150.10(P06)
INT_ALRM3_N: R1881.2 U150.11(P07)
INT_BITS_N: R1613.2 U70.J13(IO_5_10) U127.39(I\N\T\) U162.18(GPIO.4/CS4#/EVTCNTR)
INT_BMC_LOAD_DEFAULT_N: R1835.1 U154.A1(GPIOC7/SD1WP#/SDA13)
INT_BMC_TO_CPU_N: J1.B20(PCIE0_TX1_N) R1758.2 U154.D1(GPIOK5/SDA7)
INT_BRD_ID_N: R1872.1 U150.1(I\N\T\)
INT_CHIP_CPLD_TO_CPU_N: J1.A17(PCIE0_RX0_N) R1707.2 U70.J6(IO_3_13)
INT_CJA_INTR_N: R1780.1 U70.G10(IO_6_2) U135.33(I\N\T\R\)
INT_CJA_LOL_N: R1734.2 U70.H9(IO_5_13) U135.27(L\O\L\)
INT_CPLD_NMI_N: R1706.2 R1832.2 R1833.2 U70.L2(IO_2_11)
INT_CPU_LOAD_DEFAULT_N: J1.A53(PCIE0_RX8_N) R1834.1
INT_CPU_TO_BMC_N: J1.B17(PRSNT2_L_0) R1836.2 U154.D4(GPIOC4/SD1DAT2/SCL12)
INT_FAN1_N: C1549.1 Q3.3(D) R1103.2 U70.C13(IO_6_10)
INT_FAN2_N: C1564.1 Q8.3(D) R1130.2 U70.D13(IO_6_8)
INT_FAN3_N: C1576.1 Q16.3(D) R1142.2 U70.E13(IO_6_4)
INT_FAN4_N: C1561.1 Q7.3(D) R1129.2 U70.F12(IO_6_5)
INT_FAN5_N: C1578.1 Q15.3(D) R1141.2 U70.E12(IO_6_6)
INT_FAN_CARD_N: J5.20 R12468.2 U70.J7(IO_3_17) U101.2(INA)
INT_HWM_ALERT_N: R1037.1 U70.J10(IO_5_3) U101.1(INB)
INT_LOAD_DEFAULT_N: R1711.2 R1834.2 R1835.2 U70.A4(IO_8_16)
INT_MAC_N: R67.1 U1.AH36(INT_N) U70.G9(IO_6_1)
INT_NIC1_ARLT_N: R1209.2 U85.35(SMB_ALRT_N)
INT_NMI_CPLD_TO_BMC_N: R1833.1 U154.B2(GPIOC6/SD1CD#/SCL13)
INT_NMI_CPLD_TO_CPU_N: J1.A16(PCIE0_RX0_P) R1832.1
INT_PHY1_N: R282.2 U23.G8(INTB) U70.E6(IO_8_19)
INT_PHY3_N: R306.2 U25.K1(EXT_INTRB_B) U25.M8(EXT_INTRB_A) U70.H8(IO_5_15)
INT_PSU1_N: C1597.2 R1161.1 U70.A3(IO_8_18) U102.1(INB)
INT_PSU2_N: C1603.2 R1183.1 U70.L4(IO_3_3) U102.2(INA)
INT_PTP_CPLD_TO_CPU_N: J1.A21(PCIE0_RX1_P) R1709.2 U70.H6(IO_2_2)
INT_QSFP28_N: R741.1 U57.1(I\N\T\) U70.N12(IO_3_20)
INT_SFP+_ABS_N0: R651.1 U47.1(I\N\T\) U70.M7(IO_3_11)
INT_SFP+_ABS_N1: R669.1 U49.1(I\N\T\) U70.M11(IO_3_25)
INT_SFP+_DIS_N0: R706.1 U54.1(I\N\T\)
INT_SFP+_DIS_N1: R724.1 U56.1(I\N\T\)
INT_SFP+_DIS_N2: R742.1 U58.1(I\N\T\)
INT_SFP+_FLT_N0: R705.1 U53.1(I\N\T\) U70.J5(IO_3_7)
INT_SFP+_FLT_N1: R723.1 U55.1(I\N\T\) U70.N10(IO_3_22)
INT_SFP+_LOS_N0: R652.1 U48.1(I\N\T\) U70.K6(IO_3_15)
INT_SFP+_LOS_N1: R670.1 U50.1(I\N\T\) U70.M10(IO_3_29)
INT_SFP+_RS_N0: R687.1 U51.1(I\N\T\)
INT_SFP+_RS_N1: R688.1 U52.1(I\N\T\)
INT_SFP_CPLD_TO_CPU_N: J1.A52(PCIE0_RX8_P) R1710.2 U70.B5(IO_8_17)
INT_SMU_N: R1685.1 U70.L10(IO_3_30) U139.J9(INT_REQ)
INT_TSEN_ALRT_N: R1024.1 R13019.1 U70.F8(IO_6_11) U74.3(OS/ALERT) U75.6(\\A\L\E\R\T/\T\H\E\R\M2) U99.1(INB) U185.3(OS/ALERT)
INT_TSEN_NMI_N: R1046.1 R1047.1 U70.E9(IO_6_13) U145.1(INB) U154.C3(GPIOC5/SD1DAT3/SDA12)
INT_TSEN_THERM_N: R1047.2 U75.4(\\T\H\E\R\M)
INT_VCORE_ALRT_N: PR122.2 R12716.2 U154.B4(GPIOA5/TIMER6/SDA9)
INT_VCORE_VR_FAULT_N: PR140.1 PU4.27(VR_FAULT#) U154.D2(GPIOK1/SDA5)
ISHARE: PC396.1 PR441.1 PU2.31(ISHARE)
ISHARE_R: PC394.1 PR441.2 PU22.31(ISHARE)
JITTER_A0: R1782.1 R1784.2 U135.16(A0/C\S\)
JITTER_A1: R1781.1 R1783.2 U135.15(A1/SDO)
JTAG_BITS_RST_N: R1619.2 U127.77(T\R\S\T\)
JTAG_BMC_PIN17_PD: J17.17 R12374.2
JTAG_BMC_RST_N: J17.15 R12420.1
JTAG_BMC_RTCK: R12373.2 R12730.1 U154.G4(RTCK)
JTAG_BMC_RTCK_SR: J17.11 R12730.2
JTAG_BMC_TCK: R12370.1 R12371.1 U154.F2(TCK)
JTAG_BMC_TCK_SR: J17.9 R12371.2
JTAG_BMC_TDI: J17.5 R12366.1 U154.F1(TDI/BDM)
JTAG_BMC_TDO: J17.13 R12368.1 U154.G3(TDO)
JTAG_BMC_TMS: J17.7 R12367.1 U154.G2(TMS)
JTAG_BMC_TRST_N: C2274.2 J17.3 R12365.1 R12372.2 R12413.1 U154.E1(NTRST)
JTAG_BRCM_OE: R1861.1 R1862.2 U149.1(1\O\E\) U149.19(2\O\E\)
JTAG_BRCM_RST_N: R49.2 R1857.1 U1.AH34(JTAG_TRST_N) U23.B11(TRSTB) U25.C9(TRSTB)
JTAG_BRCM_TDI: R1844.2 R1845.2 R1859.1
JTAG_BRCM_TMS: R1858.1 U1.AJ32(JTAG_TMS) U23.B6(TMS) U25.C10(TMS)
JTAG_CHAIN_RST_N: CN6.10 R1848.1 R1851.2 U149.11(2A1)
JTAG_CHAIN_TCK: CN6.6 R1847.1 R1852.2 U149.2(1A1)
JTAG_CHAIN_TCK_BUFF: R1853.1 U149.4(1A2) U149.6(1A3) U149.8(1A4)
JTAG_CHAIN_TDI: CN6.7 R1849.1 U149.15(2A3)
JTAG_CHAIN_TDO: CN6.9 R1850.1 R1860.2
JTAG_CHAIN_TMS: CN6.8 R1846.1 U149.13(2A2)
JTAG_CPLD_EN: CN1.7 R1003.1 R1007.2 U70.E5(JTAGEN)
JTAG_CPLD_TCK: R1004.2 R1006.2 U70.G2(TCK)
JTAG_CPLD_TCK_SR: CN1.1 R1004.1
JTAG_CPLD_TDI: CN1.9 R1002.1 U70.F5(TDI)
JTAG_CPLD_TDO: CN1.3 R1000.1 U70.F6(TDO)
JTAG_CPLD_TMS: CN1.5 R1001.1 U70.G1(TMS)
JTAG_MAC_TCE: R49.1 U1.AJ33(JTAG_TCE)
JTAG_MAC_TCK: R1854.1 U1.AH32(JTAG_TCK)
JTAG_MAC_TDI: R1845.1 U1.AH33(JTAG_TDI)
JTAG_MAC_TDO: R307.2 R308.2 R1844.1 U1.AG33(JTAG_TDO)
JTAG_NIC1_TCK: R1217.2 U85.19(JTAG_CLK)
JTAG_NIC1_TDI: R1216.2 U85.29(JTAG_TDI)
JTAG_NIC1_TMS: R1220.2 U85.18(JTAG_TMS)
JTAG_PHY1_TCK: R1855.1 U23.D6(TCK)
JTAG_PHY1_TDI: R277.2 U23.H6(TDI)
JTAG_PHY1_TDO: R281.2 U23.F6(TDO) U149.3(2Y4)
JTAG_PHY3_TCK: R1856.1 U25.G4(TCK)
JTAG_PHY3_TDI: R307.1 U25.F16(TDI)
JTAG_PHY3_TDO: R277.1 R281.1 R308.1 U25.G8(TDO)
JTAG_SMU_RST_N: R1868.2 U139.K3(TRSTB)
KR_CPU_TO_MAC_DN0: J1.B28(PCIE0_TX3_N) U1.P31(NIFE_RX_30_N)
KR_CPU_TO_MAC_DN1: J1.B24(PCIE0_TX2_N) U1.M31(NIFE_RX_28_N)
KR_CPU_TO_MAC_DP0: J1.B27(PCIE0_TX3_P) U1.P32(NIFE_RX_30_P)
KR_CPU_TO_MAC_DP1: J1.B23(PCIE0_TX2_P) U1.M32(NIFE_RX_28_P)
KR_IIO_LAN_RX0_DN: C2066.1 J1.A30(PCIE0_RX3_N)
KR_IIO_LAN_RX0_DP: C2065.1 J1.A29(PCIE0_RX3_P)
KR_IIO_LAN_RX1_DN: C2064.1 J1.A26(PCIE0_RX2_N)
KR_IIO_LAN_RX1_DP: C2063.1 J1.A25(PCIE0_RX2_P)
KR_MAC_TO_CPU_DN0: C2066.2 U1.P36(NIFE_TX_30_N)
KR_MAC_TO_CPU_DN1: C2064.2 U1.M36(NIFE_TX_28_N)
KR_MAC_TO_CPU_DP0: C2065.2 U1.P37(NIFE_TX_30_P)
KR_MAC_TO_CPU_DP1: C2063.2 U1.M37(NIFE_TX_28_P)
LED0_NIC1_LINK_FE: R1259.1 U85.31(LED0)
LED1_NIC1_ACT_N: C1672.1 OJ1.L2 OJ1.L4 U85.30(LED1)
LED2_NIC1_LINK_GE: R1257.1 U85.33(LED2)
LED_CPLD_STATUS1: D25.3 U70.M2(IO_2_7)
LED_CPLD_STATUS2: D25.4 U70.M4(IO_3_2)
LED_ETH_STAT_CLR_N: R12701.1 U20.2(1A1) U20.4(1A2)
LED_FAN_CLR_N: J5.23 R12703.1
LED_FAN_SCL: J5.16 R1748.1
LED_FAN_SCLK: R1700.2 R1748.2 U70.A12(IO_6_18)
LED_FAN_SDA: J5.18 R1749.1
LED_FAN_SDAT: R1694.2 R1749.2 U70.B12(IO_6_12)
LED_INIT_CLR_N: R1735.2 R12701.2 R12702.2 R12703.2 U70.J1(IO_2_1)
LED_MAC_SCLK: R53.2 U20.6(1A3)
LED_MAC_SCLK_SR: R53.1 U1.AA30(LED_CLK)
LED_MAC_SDAT: R55.2 U10.1(A)
LED_MAC_SDAT_SR: R55.1 U1.AB30(LED_DATA)
LED_NIC1_LINK_FE: C1674.1 OJ1.L1 R1259.2
LED_NIC1_LINK_GE: C1673.1 OJ1.L3 R1257.2
LED_PORT_BUF0_EN_N: R254.1 U20.1(1\O\E\) U20.19(2\O\E\)
LED_PORT_BUF1_EN_N: R263.1 U22.1(1\O\E\) U22.19(2\O\E\)
LED_PORT_CLK0: R258.1 U20.12(1Y4)
LED_PORT_CLK1: R259.1 U20.9(2Y1)
LED_PORT_CLK2: R260.1 U20.7(2Y2)
LED_PORT_CLK3: R264.1 U22.18(1Y1)
LED_PORT_CLK4: R265.1 U22.16(1Y2)
LED_PORT_CLK5: R266.1 U22.14(1Y3)
LED_PORT_CLK6: R267.1 U22.12(1Y4)
LED_PORT_CLK7: R268.1 U22.9(2Y1)
LED_PORT_CLK8: R269.1 U22.7(2Y2)
LED_PORT_CLK9: R270.1 U22.5(2Y3)
LED_PORT_CLK10: R271.1 U22.3(2Y4)
LED_PORT_CLK_BUF0: R257.1 U20.14(1Y3)
LED_PORT_CLK_BUF1: R261.1 U20.5(2Y3)
LED_PORT_CLK_BUF2: R262.1 U20.3(2Y4)
LED_PORT_CLK_IN0: R257.2 U20.8(1A4) U20.11(2A1) U20.13(2A2) U20.15(2A3) U20.17(2A4)
LED_PORT_CLK_IN1: R262.2 U22.11(2A1) U22.13(2A2) U22.15(2A3) U22.17(2A4)
LED_PORT_CLK_IN2: R261.2 U22.2(1A1) U22.4(1A2) U22.6(1A3) U22.8(1A4)
LED_PORT_CLR_N0: R255.1 U20.18(1Y1)
LED_PORT_CLR_N1: R256.1 U20.16(1Y2)
LED_PORT_STAT_CLK0: R258.2 U10.8(CLK)
LED_PORT_STAT_CLK1: R259.2 U12.8(CLK)
LED_PORT_STAT_CLK2: R260.2 U14.8(CLK)
LED_PORT_STAT_CLK3: R264.2 U16.8(CLK)
LED_PORT_STAT_CLK4: R265.2 U18.8(CLK)
LED_PORT_STAT_CLK5: R266.2 U19.8(CLK)
LED_PORT_STAT_CLK6: R267.2 U21.8(CLK)
LED_PORT_STAT_CLK7: R268.2 U13.8(CLK)
LED_PORT_STAT_CLK8: R269.2 U15.8(CLK)
LED_PORT_STAT_CLR_N0: R255.2 U10.9(CLR#) U12.9(CLR#) U14.9(CLR#) U16.9(CLR#) U18.9(CLR#)
LED_PORT_STAT_CLR_N1: R256.2 U13.9(CLR#) U15.9(CLR#) U19.9(CLR#) U21.9(CLR#)
LED_QSFP28_GRN_P1: C781.1 D41.1 U13.3(QA)
LED_QSFP28_GRN_P2: C783.1 D85.1 U13.5(QC)
LED_QSFP28_GRN_P3: C785.1 D87.1 U13.10(QE)
LED_QSFP28_GRN_P4: C787.1 D89.1 U13.12(QG)
LED_QSFP28_GRN_P5: C799.1 D42.1 U15.3(QA)
LED_QSFP28_GRN_P6: C801.1 D86.1 U15.5(QC)
LED_QSFP28_GRN_P7: C803.1 D88.1 U15.10(QE)
LED_QSFP28_GRN_P8: C805.1 D90.1 U15.12(QG)
LED_QSFP28_GRN_SR_P1: D41.3 R602.2
LED_QSFP28_GRN_SR_P2: D85.3 R1631.2
LED_QSFP28_GRN_SR_P3: D87.3 R1635.2
LED_QSFP28_GRN_SR_P4: D89.3 R1639.2
LED_QSFP28_GRN_SR_P5: D42.3 R603.2
LED_QSFP28_GRN_SR_P6: D86.3 R1632.2
LED_QSFP28_GRN_SR_P7: D88.3 R1636.2
LED_QSFP28_GRN_SR_P8: D90.3 R1640.2
LED_QSFP28_YEL_P1: C782.1 D41.2 U13.4(QB)
LED_QSFP28_YEL_P2: C784.1 D85.2 U13.6(QD)
LED_QSFP28_YEL_P3: C786.1 D87.2 U13.11(QF)
LED_QSFP28_YEL_P4: C788.1 D89.2 U13.13(QH) U15.1(A)
LED_QSFP28_YEL_P5: C800.1 D42.2 U15.4(QB)
LED_QSFP28_YEL_P6: C802.1 D86.2 U15.6(QD)
LED_QSFP28_YEL_P7: C804.1 D88.2 U15.11(QF)
LED_QSFP28_YEL_P8: C806.1 D90.2 U15.13(QH)
LED_QSFP28_YEL_SR_P1: D41.4 R604.2
LED_QSFP28_YEL_SR_P2: D85.4 R1633.2
LED_QSFP28_YEL_SR_P3: D87.4 R1637.2
LED_QSFP28_YEL_SR_P4: D89.4 R1641.2
LED_QSFP28_YEL_SR_P5: D42.4 R605.2
LED_QSFP28_YEL_SR_P6: D86.4 R1634.2
LED_QSFP28_YEL_SR_P7: D88.4 R1638.2
LED_QSFP28_YEL_SR_P8: D90.4 R1642.2
LED_SFP+_GRN_P0: C755.1 D1.1 U10.3(QA)
LED_SFP+_GRN_P1: C757.1 D2.1 U10.5(QC)
LED_SFP+_GRN_P2: C759.1 D3.1 U10.10(QE)
LED_SFP+_GRN_P3: C761.1 D4.1 U10.12(QG)
LED_SFP+_GRN_P4: C773.1 D5.1 U12.3(QA)
LED_SFP+_GRN_P5: C775.1 D6.1 U12.5(QC)
LED_SFP+_GRN_P6: C777.1 D7.1 U12.10(QE)
LED_SFP+_GRN_P7: C779.1 D8.1 U12.12(QG)
LED_SFP+_GRN_P8: C791.1 D9.1 U14.3(QA)
LED_SFP+_GRN_P9: C793.1 D10.1 U14.5(QC)
LED_SFP+_GRN_P10: C795.1 D11.1 U14.10(QE)
LED_SFP+_GRN_P11: C797.1 D12.1 U14.12(QG)
LED_SFP+_GRN_P12: C809.1 D13.1 U16.3(QA)
LED_SFP+_GRN_P13: C811.1 D14.1 U16.5(QC)
LED_SFP+_GRN_P14: C813.1 D15.1 U16.10(QE)
LED_SFP+_GRN_P15: C815.1 D16.1 U16.12(QG)
LED_SFP+_GRN_P16: C826.1 D33.1 U18.3(QA)
LED_SFP+_GRN_P17: C828.1 D34.1 U18.5(QC)
LED_SFP+_GRN_P18: C830.1 D35.1 U18.10(QE)
LED_SFP+_GRN_P19: C832.1 D36.1 U18.12(QG)
LED_SFP+_GRN_P20: C835.1 D37.1 U19.3(QA)
LED_SFP+_GRN_P21: C837.1 D38.1 U19.5(QC)
LED_SFP+_GRN_P22: C839.1 D39.1 U19.10(QE)
LED_SFP+_GRN_P23: C841.1 D40.1 U19.12(QG)
LED_SFP+_GRN_P24: C845.1 D17.1 U21.3(QA)
LED_SFP+_GRN_P25: C847.1 D18.1 U21.5(QC)
LED_SFP+_GRN_P26: C849.1 D19.1 U21.10(QE)
LED_SFP+_GRN_P27: C851.1 D20.1 U21.12(QG)
LED_SFP+_GRN_SR_P0: D1.3 R317.2
LED_SFP+_GRN_SR_P1: D2.3 R324.2
LED_SFP+_GRN_SR_P2: D3.3 R331.2
LED_SFP+_GRN_SR_P3: D4.3 R338.2
LED_SFP+_GRN_SR_P4: D5.3 R345.2
LED_SFP+_GRN_SR_P5: D6.3 R352.2
LED_SFP+_GRN_SR_P6: D7.3 R359.2
LED_SFP+_GRN_SR_P7: D8.3 R366.2
LED_SFP+_GRN_SR_P8: D9.3 R373.2
LED_SFP+_GRN_SR_P9: D10.3 R380.2
LED_SFP+_GRN_SR_P10: D11.3 R387.2
LED_SFP+_GRN_SR_P11: D12.3 R394.2
LED_SFP+_GRN_SR_P12: D13.3 R401.2
LED_SFP+_GRN_SR_P13: D14.3 R408.2
LED_SFP+_GRN_SR_P14: D15.3 R415.2
LED_SFP+_GRN_SR_P15: D16.3 R422.2
LED_SFP+_GRN_SR_P16: D33.3 R541.2
LED_SFP+_GRN_SR_P17: D34.3 R548.2
LED_SFP+_GRN_SR_P18: D35.3 R555.2
LED_SFP+_GRN_SR_P19: D36.3 R562.2
LED_SFP+_GRN_SR_P20: D37.3 R569.2
LED_SFP+_GRN_SR_P21: D38.3 R576.2
LED_SFP+_GRN_SR_P22: D39.3 R583.2
LED_SFP+_GRN_SR_P23: D40.3 R590.2
LED_SFP+_GRN_SR_P24: D17.3 R429.2
LED_SFP+_GRN_SR_P25: D18.3 R437.2
LED_SFP+_GRN_SR_P26: D19.3 R443.2
LED_SFP+_GRN_SR_P27: D20.3 R450.2
LED_SFP+_YEL_P0: C756.1 D1.2 U10.4(QB)
LED_SFP+_YEL_P1: C758.1 D2.2 U10.6(QD)
LED_SFP+_YEL_P2: C760.1 D3.2 U10.11(QF)
LED_SFP+_YEL_P3: C762.1 D4.2 U10.13(QH) U12.1(A)
LED_SFP+_YEL_P4: C774.1 D5.2 U12.4(QB)
LED_SFP+_YEL_P5: C776.1 D6.2 U12.6(QD)
LED_SFP+_YEL_P6: C778.1 D7.2 U12.11(QF)
LED_SFP+_YEL_P7: C780.1 D8.2 U12.13(QH) U14.1(A)
LED_SFP+_YEL_P8: C792.1 D9.2 U14.4(QB)
LED_SFP+_YEL_P9: C794.1 D10.2 U14.6(QD)
LED_SFP+_YEL_P10: C796.1 D11.2 U14.11(QF)
LED_SFP+_YEL_P11: C798.1 D12.2 U14.13(QH) U16.1(A)
LED_SFP+_YEL_P12: C810.1 D13.2 U16.4(QB)
LED_SFP+_YEL_P13: C812.1 D14.2 U16.6(QD)
LED_SFP+_YEL_P14: C814.1 D15.2 U16.11(QF)
LED_SFP+_YEL_P15: C816.1 D16.2 U16.13(QH) U18.1(A)
LED_SFP+_YEL_P16: C827.1 D33.2 U18.4(QB)
LED_SFP+_YEL_P17: C829.1 D34.2 U18.6(QD)
LED_SFP+_YEL_P18: C831.1 D35.2 U18.11(QF)
LED_SFP+_YEL_P19: C833.1 D36.2 U18.13(QH) U19.1(A)
LED_SFP+_YEL_P20: C836.1 D37.2 U19.4(QB)
LED_SFP+_YEL_P21: C838.1 D38.2 U19.6(QD)
LED_SFP+_YEL_P22: C840.1 D39.2 U19.11(QF)
LED_SFP+_YEL_P23: C842.1 D40.2 U19.13(QH) U21.1(A)
LED_SFP+_YEL_P24: C846.1 D17.2 U21.4(QB)
LED_SFP+_YEL_P25: C848.1 D18.2 U21.6(QD)
LED_SFP+_YEL_P26: C850.1 D19.2 U21.11(QF)
LED_SFP+_YEL_P27: C852.1 D20.2 U13.1(A) U21.13(QH)
LED_SFP+_YEL_SR_P0: D1.4 R318.2
LED_SFP+_YEL_SR_P1: D2.4 R325.2
LED_SFP+_YEL_SR_P2: D3.4 R332.2
LED_SFP+_YEL_SR_P3: D4.4 R339.2
LED_SFP+_YEL_SR_P4: D5.4 R346.2
LED_SFP+_YEL_SR_P5: D6.4 R353.2
LED_SFP+_YEL_SR_P6: D7.4 R360.2
LED_SFP+_YEL_SR_P7: D8.4 R367.2
LED_SFP+_YEL_SR_P8: D9.4 R374.2
LED_SFP+_YEL_SR_P9: D10.4 R381.2
LED_SFP+_YEL_SR_P10: D11.4 R388.2
LED_SFP+_YEL_SR_P11: D12.4 R395.2
LED_SFP+_YEL_SR_P12: D13.4 R402.2
LED_SFP+_YEL_SR_P13: D14.4 R409.2
LED_SFP+_YEL_SR_P14: D15.4 R416.2
LED_SFP+_YEL_SR_P15: D16.4 R423.2
LED_SFP+_YEL_SR_P16: D33.4 R542.2
LED_SFP+_YEL_SR_P17: D34.4 R549.2
LED_SFP+_YEL_SR_P18: D35.4 R556.2
LED_SFP+_YEL_SR_P19: D36.4 R563.2
LED_SFP+_YEL_SR_P20: D37.4 R570.2
LED_SFP+_YEL_SR_P21: D38.4 R577.2
LED_SFP+_YEL_SR_P22: D39.4 R584.2
LED_SFP+_YEL_SR_P23: D40.4 R591.2
LED_SFP+_YEL_SR_P24: D17.4 R430.2
LED_SFP+_YEL_SR_P25: D18.4 R436.2
LED_SFP+_YEL_SR_P26: D19.4 R444.2
LED_SFP+_YEL_SR_P27: D20.4 R451.2
LED_SYS_STAT_CLR_N: J8.3 R12702.1
LED_SYS_STAT_SCL: J8.4 R650.1
LED_SYS_STAT_SCLK: R650.2 R1695.2 U70.H2(IO_1_12)
LED_SYS_STAT_SDA: J8.6 R649.1
LED_SYS_STAT_SDAT: R649.2 R1704.2 U70.J2(IO_2_3)
LPC_BMC_FRAME_N: R1824.1 U154.A21(LFRAME#)
LPC_BMC_LAD0: R1825.1 U154.B21(LAD0)
LPC_BMC_LAD1: R1826.1 U154.A22(LAD1)
LPC_BMC_LAD2: R1827.1 U154.F19(LAD2)
LPC_BMC_LAD3: R1828.1 U154.C19(LAD3)
LPC_BMC_SERIRQ_N: R1823.1 U154.E17(LSIRQ#)
LPC_FRAME_PCH_N: J1.A68(PCIE0_RX12_P) R1712.2 R1824.2 U70.C2(IO_1_3)
LPC_LAD0_PCH: J1.A73(PCIE0_RX13_N) R1825.2 U70.E1(IO_1_8)
LPC_LAD1_PCH: J1.A72(PCIE0_RX13_P) R1826.2 U70.D1(IO_1_1)
LPC_LAD2_PCH: J1.B71(PCIE0_TX13_N) R1827.2 U70.E3(IO_1_5)
LPC_LAD3_PCH: J1.B70(PCIE0_TX13_P) R1828.2 U70.C1(IO_1_2)
LPC_PDN_N: R12359.2 U154.H19(GPIOB5/LPCPD#/LPCSMI#)
LPC_PME_N: R12360.2 U154.H20(GPIOB6/LPCPME#)
LPC_SERIRQ_PCH_N: J1.B67(PCIE0_TX12_N) R1714.2 R1823.2
MAC_COREPLL_LOCK: R12477.2 U1.AK33(C_PLL_LOCK) U70.G12(IO_5_16)
MAC_DDRA0_CHIP_ZQ: R104.2 U2.F9(ZQ)
MAC_DDRA0_TEN: R103.1 U2.N9(TEN)
MAC_DDRA0_VREFCA: C10.1 R95.1 R100.2 U2.M1(VREFCA)
MAC_DDRA1_CHIP_ZQ: R108.2 U3.F9(ZQ)
MAC_DDRA1_TEN: R106.1 U3.N9(TEN)
MAC_DDRA1_VREFCA: C11.1 R97.1 R102.2 U3.M1(VREFCA)
MAC_DDRA_A00: R88.1 U1.AU21(DDRA_A3_A6A11) U2.P3(A0) U3.P3(A0)
MAC_DDRA_A01: R89.1 U1.AK21(DDRA_A7) U2.P7(A1) U3.P7(A1)
MAC_DDRA_A02: R90.1 U1.AT20(DDRA_A1_A1A9) U2.R3(A2) U3.R3(A2)
MAC_DDRA_A03: R91.1 U1.AR25(DDRA_BA0_A2BA0) U2.N7(A3) U3.N7(A3)
MAC_DDRA_A04: R83.1 U1.AU22(DDRA_A4_A13A12) U2.N3(A4) U3.N3(A4)
MAC_DDRA_A05: R84.1 U1.AM23(DDRA_BA1_A5BA1) U2.P8(A5) U3.P8(A5)
MAC_DDRA_A06: R85.1 U1.AR20(DDRA_A0_A7A8) U2.P2(A6) U3.P2(A6)
MAC_DDRA_A07: R92.1 U1.AM22(DDRA_A12) U2.R8(A7) U3.R8(A7)
MAC_DDRA_A08: R86.1 U1.AN21(DDRA_A11) U2.R2(A8) U3.R2(A8)
MAC_DDRA_A09: R87.1 U1.AL21(DDRA_A8) U2.R7(A9) U3.R7(A9)
MAC_DDRA_A10: R94.1 U1.AU24(DDRA_A6) U2.M3(A10/AP) U3.M3(A10/AP)
MAC_DDRA_A11: R93.1 U1.AN20(DDRA_A9) U2.T2(A11) U3.T2(A11)
MAC_DDRA_A12: R96.1 U1.AP21(DDRA_A13) U2.M7(A12/BC_N) U3.M7(A12/BC_N)
MAC_DDRA_A13: R98.1 U1.AL22(DDRA_A10) U2.T8(A13) U3.T8(A13)
MAC_DDRA_ACT_N: R105.1 U1.AT24(DDRA_ACT_ABI_N) U2.L3(ACT_N) U3.L3(ACT_N)
MAC_DDRA_ALERT0_N: U1.AT27(DDRA_ALERT_N_0) U2.P9(ALERT_N)
MAC_DDRA_ALERT1_N: U1.AM25(DDRA_ALERT_N_1) U3.P9(ALERT_N)
MAC_DDRA_BA0: R109.1 U1.AT21(DDRA_A2_A0A10) U2.N2(BA0) U3.N2(BA0)
MAC_DDRA_BA1: R110.1 U1.AT26(DDRA_BG0_A4BA2) U2.N8(BA1) U3.N8(BA1)
MAC_DDRA_BG0: R111.1 U1.AT23(DDRA_A5_A14A15) U2.M2(BG0) U3.M2(BG0)
MAC_DDRA_CAS_N: R101.1 U1.AU25(DDRA_CAS_N) U2.M8(CAS_N/A15) U3.M8(CAS_N/A15)
MAC_DDRA_CLK_DN: R118.1 U1.AP24(DDRA_CK_N) U2.K8(CK_C) U3.K8(CK_C)
MAC_DDRA_CLK_DP: R117.1 U1.AP25(DDRA_CK_P) U2.K7(CK_T) U3.K7(CK_T)
MAC_DDRA_CLK_EN: R116.1 U1.AL24(DDRA_CKE) U2.K2(CKE) U3.K2(CKE)
MAC_DDRA_CS0_N: R113.1 U1.AU27(DDRA_CS_N_0) U2.L7(CS_N)
MAC_DDRA_CS1_N: R114.1 U1.AN24(DDRA_CS_N_1) U3.L7(CS_N)
MAC_DDRA_DBI0_N: U1.AN32(DDRA_DBI_N_0) U2.E7(DML_N/DBIL_N)
MAC_DDRA_DBI1_N: U1.AP30(DDRA_DBI_N_1) U2.E2(DMU_N/DBIU_N)
MAC_DDRA_DBI2_N: U1.AJ25(DDRA_DBI_N_2) U3.E7(DML_N/DBIL_N)
MAC_DDRA_DBI3_N: U1.AJ28(DDRA_DBI_N_3) U3.E2(DMU_N/DBIU_N)
MAC_DDRA_DQ00: U1.AN33(DDRA_DQ_1) U2.G2(DQL0)
MAC_DDRA_DQ01: U1.AP34(DDRA_DQ_0) U2.F7(DQL1)
MAC_DDRA_DQ02: U1.AT33(DDRA_DQ_5) U2.H3(DQL2)
MAC_DDRA_DQ03: U1.AT35(DDRA_DQ_4) U2.H7(DQL3)
MAC_DDRA_DQ04: U1.AP33(DDRA_DQ_3) U2.H2(DQL4)
MAC_DDRA_DQ05: U1.AR35(DDRA_DQ_2) U2.H8(DQL5)
MAC_DDRA_DQ06: U1.AR32(DDRA_DQ_6) U2.J3(DQL6)
MAC_DDRA_DQ07: U1.AP31(DDRA_DQ_7) U2.J7(DQL7)
MAC_DDRA_DQ08: U1.AR29(DDRA_DQ_13) U2.A3(DQU0)
MAC_DDRA_DQ09: U1.AR31(DDRA_DQ_11) U2.B8(DQU1)
MAC_DDRA_DQ10: U1.AR28(DDRA_DQ_15) U2.C3(DQU2)
MAC_DDRA_DQ11: U1.AU33(DDRA_DQ_9) U2.C7(DQU3)
MAC_DDRA_DQ12: U1.AP28(DDRA_DQ_12) U2.C2(DQU4)
MAC_DDRA_DQ13: U1.AT32(DDRA_DQ_10) U2.C8(DQU5)
MAC_DDRA_DQ14: U1.AT29(DDRA_DQ_14) U2.D3(DQU6)
MAC_DDRA_DQ15: U1.AU34(DDRA_DQ_8) U2.D7(DQU7)
MAC_DDRA_DQ16: U1.AN26(DDRA_DQ_22) U3.G2(DQL0)
MAC_DDRA_DQ17: U1.AN30(DDRA_DQ_17) U3.F7(DQL1)
MAC_DDRA_DQ18: U1.AM26(DDRA_DQ_21) U3.H3(DQL2)
MAC_DDRA_DQ19: U1.AN29(DDRA_DQ_19) U3.H7(DQL3)
MAC_DDRA_DQ20: U1.AM28(DDRA_DQ_20) U3.H2(DQL4)
MAC_DDRA_DQ21: U1.AM29(DDRA_DQ_16) U3.H8(DQL5)
MAC_DDRA_DQ22: U1.AL25(DDRA_DQ_23) U3.J3(DQL6)
MAC_DDRA_DQ23: U1.AL28(DDRA_DQ_18) U3.J7(DQL7)
MAC_DDRA_DQ24: U1.AK26(DDRA_DQ_31) U3.A3(DQU0)
MAC_DDRA_DQ25: U1.AM32(DDRA_DQ_29) U3.B8(DQU1)
MAC_DDRA_DQ26: U1.AH27(DDRA_DQ_25) U3.C3(DQU2)
MAC_DDRA_DQ27: U1.AK30(DDRA_DQ_24) U3.C7(DQU3)
MAC_DDRA_DQ28: U1.AJ26(DDRA_DQ_30) U3.C2(DQU4)
MAC_DDRA_DQ29: U1.AK29(DDRA_DQ_26) U3.C8(DQU5)
MAC_DDRA_DQ30: U1.AK27(DDRA_DQ_28) U3.D3(DQU6)
MAC_DDRA_DQ31: U1.AJ29(DDRA_DQ_27) U3.D7(DQU7)
MAC_DDRA_DQS0_DN: U1.AU36(DDRA_DQS0_WCK01_N) U2.F3(DQSL_C)
MAC_DDRA_DQS0_DP: U1.AT36(DDRA_DQS0_WCK01_P) U2.G3(DQSL_T)
MAC_DDRA_DQS1_DN: U1.AU30(DDRA_DQS1_N) U2.A7(DQSU_C)
MAC_DDRA_DQS1_DP: U1.AU31(DDRA_DQS1_P) U2.B7(DQSU_T)
MAC_DDRA_DQS2_DN: U1.AN27(DDRA_DQS2_WCK23_N) U3.F3(DQSL_C)
MAC_DDRA_DQS2_DP: U1.AP27(DDRA_DQS2_WCK23_P) U3.G3(DQSL_T)
MAC_DDRA_DQS3_DN: U1.AM31(DDRA_DQS3_N) U3.A7(DQSU_C)
MAC_DDRA_DQS3_DP: U1.AL31(DDRA_DQS3_P) U3.B7(DQSU_T)
MAC_DDRA_ODT: R115.1 U1.AU28(DDRA_ODT) U2.K3(ODT) U3.K3(ODT)
MAC_DDRA_PAR: R112.1 U1.AR26(DDRA_PAR) U2.T3(PAR) U3.T3(PAR)
MAC_DDRA_RAS_N: R107.1 U1.AR22(DDRA_RAS_N) U2.L8(RAS_N/A16) U3.L8(RAS_N/A16)
MAC_DDRA_RES_NEG: R125.2 U1.AJ23(DDRA_RES_NEG)
MAC_DDRA_RES_POS: R124.2 U1.AH23(DDRA_RES_POS)
MAC_DDRA_RES_VDD: R124.1 U1.AH22(DDRA_RES_VDD)
MAC_DDRA_RES_VSS: R125.1 U1.AJ22(DDRA_RES_VSS)
MAC_DDRA_RST_N: R123.1 U1.AR23(DDRA_RESET_N) U2.P1(RESET_N) U3.P1(RESET_N)
MAC_DDRA_WE_N: R99.1 U1.AP22(DDRA_WE_N) U2.L2(WE_N/A14) U3.L2(WE_N/A14)
MAC_DDRB0_CHIP_ZQ: R147.2 U4.F9(ZQ)
MAC_DDRB0_TEN: R146.1 U4.N9(TEN)
MAC_DDRB0_VREFCA: C31.1 R138.1 R142.2 U4.M1(VREFCA)
MAC_DDRB1_CHIP_ZQ: R151.2 U5.F9(ZQ)
MAC_DDRB1_TEN: R150.1 U5.N9(TEN)
MAC_DDRB1_VREFCA: C32.1 R140.1 R145.2 U5.M1(VREFCA)
MAC_DDRB_A00: R126.1 U1.AN9(DDRB_A6) U4.P3(A0) U5.P3(A0)
MAC_DDRB_A01: R127.1 U1.AH12(DDRB_A10) U4.P7(A1) U5.P7(A1)
MAC_DDRB_A02: R128.1 U1.AJ11(DDRB_A0_A7A8) U4.R3(A2) U5.R3(A2)
MAC_DDRB_A03: R129.1 U1.AL9(DDRB_A2_A0A10) U4.N7(A3) U5.N7(A3)
MAC_DDRB_A04: R130.1 U1.AP7(DDRB_A5_A14A15) U4.N3(A4) U5.N3(A4)
MAC_DDRB_A05: R131.1 U1.AJ16(DDRB_BA1_A5BA1) U4.P8(A5) U5.P8(A5)
MAC_DDRB_A06: R132.1 U1.AK9(DDRB_A1_A1A9) U4.P2(A6) U5.P2(A6)
MAC_DDRB_A07: R133.1 U1.AH15(DDRB_A7) U4.R8(A7) U5.R8(A7)
MAC_DDRB_A08: R134.1 U1.AN8(DDRB_A4_A13A12) U4.R2(A8) U5.R2(A8)
MAC_DDRB_A09: R135.1 U1.AH13(DDRB_A9) U4.R7(A9) U5.R7(A9)
MAC_DDRB_A10: R136.1 U1.AK11(DDRB_A13) U4.M3(A10/AP) U5.M3(A10/AP)
MAC_DDRB_A11: R137.1 U1.AM8(DDRB_A3_A6A11) U4.T2(A11) U5.T2(A11)
MAC_DDRB_A12: R139.1 U1.AJ14(DDRB_A12) U4.M7(A12/BC_N) U5.M7(A12/BC_N)
MAC_DDRB_A13: R141.1 U1.AH16(DDRB_A8) U4.T8(A13) U5.T8(A13)
MAC_DDRB_ACT_N: R149.1 U1.AR7(DDRB_ACT_ABI_N) U4.L3(ACT_N) U5.L3(ACT_N)
MAC_DDRB_ALERT0_N: U1.AT8(DDRB_ALERT_N_0) U4.P9(ALERT_N)
MAC_DDRB_ALERT1_N: U1.AK15(DDRB_ALERT_N_1) U5.P9(ALERT_N)
MAC_DDRB_BA0: R152.1 U1.AP9(DDRB_BA0_A2BA0) U4.N2(BA0) U5.N2(BA0)
MAC_DDRB_BA1: R153.1 U1.AJ13(DDRB_A11) U4.N8(BA1) U5.N8(BA1)
MAC_DDRB_BG0: R154.1 U1.AR8(DDRB_BG0_A4BA2) U4.M2(BG0) U5.M2(BG0)
MAC_DDRB_CAS_N: R144.1 U1.AT6(DDRB_CAS_N) U4.M8(CAS_N/A15) U5.M8(CAS_N/A15)
MAC_DDRB_CLK_DN: R161.1 U1.AM10(DDRB_CK_N) U4.K8(CK_C) U5.K8(CK_C)
MAC_DDRB_CLK_DP: R160.1 U1.AM11(DDRB_CK_P) U4.K7(CK_T) U5.K7(CK_T)
MAC_DDRB_CLK_EN: R159.1 U1.AL15(DDRB_CKE) U4.K2(CKE) U5.K2(CKE)
MAC_DDRB_CS0_N: R156.1 U1.AU7(DDRB_CS_N_0) U4.L7(CS_N)
MAC_DDRB_CS1_N: R157.1 U1.AL13(DDRB_CS_N_1) U5.L7(CS_N)
MAC_DDRB_DBI0_N: U1.AT18(DDRB_DBI_N_0) U4.E7(DML_N/DBIL_N)
MAC_DDRB_DBI1_N: U1.AT11(DDRB_DBI_N_1) U4.E2(DMU_N/DBIU_N)
MAC_DDRB_DBI2_N: U1.AN15(DDRB_DBI_N_2) U5.E7(DML_N/DBIL_N)
MAC_DDRB_DBI3_N: U1.AM20(DDRB_DBI_N_3) U5.E2(DMU_N/DBIU_N)
MAC_DDRB_DQ00: U1.AR17(DDRB_DQ_5) U4.G2(DQL0)
MAC_DDRB_DQ01: U1.AT17(DDRB_DQ_4) U4.F7(DQL1)
MAC_DDRB_DQ02: U1.AT15(DDRB_DQ_7) U4.H3(DQL2)
MAC_DDRB_DQ03: U1.AU18(DDRB_DQ_3) U4.H7(DQL3)
MAC_DDRB_DQ04: U1.AR16(DDRB_DQ_6) U4.H2(DQL4)
MAC_DDRB_DQ05: U1.AP19(DDRB_DQ_2) U4.H8(DQL5)
MAC_DDRB_DQ06: U1.AU19(DDRB_DQ_0) U4.J3(DQL6)
MAC_DDRB_DQ07: U1.AR19(DDRB_DQ_1) U4.J7(DQL7)
MAC_DDRB_DQ08: U1.AU9(DDRB_DQ_12) U4.A3(DQU0)
MAC_DDRB_DQ09: U1.AU13(DDRB_DQ_9) U4.B8(DQU1)
MAC_DDRB_DQ10: U1.AR11(DDRB_DQ_13) U4.C3(DQU2)
MAC_DDRB_DQ11: U1.AT14(DDRB_DQ_8) U4.C7(DQU3)
MAC_DDRB_DQ12: U1.AM14(DDRB_DQ_15) U4.C2(DQU4)
MAC_DDRB_DQ13: U1.AR14(DDRB_DQ_10) U4.C8(DQU5)
MAC_DDRB_DQ14: U1.AR13(DDRB_DQ_11) U4.D3(DQU6)
MAC_DDRB_DQ15: U1.AN14(DDRB_DQ_14) U4.D7(DQU7)
MAC_DDRB_DQ16: U1.AN11(DDRB_DQ_21) U5.G2(DQL0)
MAC_DDRB_DQ17: U1.AK17(DDRB_DQ_22) U5.F7(DQL1)
MAC_DDRB_DQ18: U1.AR10(DDRB_DQ_17) U5.H3(DQL2)
MAC_DDRB_DQ19: U1.AN12(DDRB_DQ_18) U5.H7(DQL3)
MAC_DDRB_DQ20: U1.AP10(DDRB_DQ_20) U5.H2(DQL4)
MAC_DDRB_DQ21: U1.AP12(DDRB_DQ_19) U5.H8(DQL5)
MAC_DDRB_DQ22: U1.AM13(DDRB_DQ_23) U5.J3(DQL6)
MAC_DDRB_DQ23: U1.AP13(DDRB_DQ_16) U5.J7(DQL7)
MAC_DDRB_DQ24: U1.AP16(DDRB_DQ_29) U5.A3(DQU0)
MAC_DDRB_DQ25: U1.AM19(DDRB_DQ_26) U5.B8(DQU1)
MAC_DDRB_DQ26: U1.AK20(DDRB_DQ_24) U5.C3(DQU2)
MAC_DDRB_DQ27: U1.AM17(DDRB_DQ_31) U5.C7(DQU3)
MAC_DDRB_DQ28: U1.AP15(DDRB_DQ_28) U5.C2(DQU4)
MAC_DDRB_DQ29: U1.AJ19(DDRB_DQ_30) U5.C8(DQU5)
MAC_DDRB_DQ30: U1.AH21(DDRB_DQ_25) U5.D3(DQU6)
MAC_DDRB_DQ31: U1.AJ20(DDRB_DQ_27) U5.D7(DQU7)
MAC_DDRB_DQS0_DN: U1.AU15(DDRB_DQS0_WCK01_N) U4.F3(DQSL_C)
MAC_DDRB_DQS0_DP: U1.AU16(DDRB_DQS0_WCK01_P) U4.G3(DQSL_T)
MAC_DDRB_DQS1_DN: U1.AT12(DDRB_DQS1_N) U4.A7(DQSU_C)
MAC_DDRB_DQS1_DP: U1.AU12(DDRB_DQS1_P) U4.B7(DQSU_T)
MAC_DDRB_DQS2_DN: U1.AL16(DDRB_DQS2_WCK23_N) U5.F3(DQSL_C)
MAC_DDRB_DQS2_DP: U1.AM16(DDRB_DQS2_WCK23_P) U5.G3(DQSL_T)
MAC_DDRB_DQS3_DN: U1.AN17(DDRB_DQS3_N) U5.A7(DQSU_C)
MAC_DDRB_DQS3_DP: U1.AN18(DDRB_DQS3_P) U5.B7(DQSU_T)
MAC_DDRB_ODT: R158.1 U1.AT9(DDRB_ODT) U4.K3(ODT) U5.K3(ODT)
MAC_DDRB_PAR: R155.1 U1.AU6(DDRB_PAR) U4.T3(PAR) U5.T3(PAR)
MAC_DDRB_RAS_N: R148.1 U1.AL10(DDRB_RAS_N) U4.L8(RAS_N/A16) U5.L8(RAS_N/A16)
MAC_DDRB_RST_N: R166.1 U1.AL12(DDRB_RESET_N) U4.P1(RESET_N) U5.P1(RESET_N)
MAC_DDRB_WE_N: R143.1 U1.AK12(DDRB_WE_N) U4.L2(WE_N/A14) U5.L2(WE_N/A14)
MAC_DDRC0_CHIP_ZQ: R189.2 U6.F9(ZQ)
MAC_DDRC0_TEN: R188.1 U6.N9(TEN)
MAC_DDRC0_VREFCA: C44.1 R179.1 R184.2 U6.M1(VREFCA)
MAC_DDRC1_CHIP_ZQ: R192.2 U7.F9(ZQ)
MAC_DDRC1_TEN: R191.1 U7.N9(TEN)
MAC_DDRC1_VREFCA: C45.1 R181.1 R186.2 U7.M1(VREFCA)
MAC_DDRC_A00: R167.1 U1.AM7(DDRC_A11) U6.P3(A0) U7.P3(A0)
MAC_DDRC_A01: R168.1 U1.AU4(DDRC_A1_A1A9) U6.P7(A1) U7.P7(A1)
MAC_DDRC_A02: R174.1 U1.AN6(DDRC_A13) U6.R3(A2) U7.R3(A2)
MAC_DDRC_A03: R169.1 U1.AM4(DDRC_BA0_A2BA0) U6.N7(A3) U7.N7(A3)
MAC_DDRC_A04: R175.1 U1.AL7(DDRC_A12) U6.N3(A4) U7.N3(A4)
MAC_DDRC_A05: R176.1 U1.AN3(DDRC_BG0_A4BA2) U6.P8(A5) U7.P8(A5)
MAC_DDRC_A06: R170.1 U1.AH9(DDRC_A9) U6.P2(A6) U7.P2(A6)
MAC_DDRC_A07: R171.1 U1.AT3(DDRC_A5_A14A15) U6.R8(A7) U7.R8(A7)
MAC_DDRC_A08: R172.1 U1.AG9(DDRC_A8) U6.R2(A8) U7.R2(A8)
MAC_DDRC_A09: R173.1 U1.AR5(DDRC_A2_A0A10) U6.R7(A9) U7.R7(A9)
MAC_DDRC_A10: R177.1 U1.AT5(DDRC_A0_A7A8) U6.M3(A10/AP) U7.M3(A10/AP)
MAC_DDRC_A11: R178.1 U1.AE9(DDRC_A7) U6.T2(A11) U7.T2(A11)
MAC_DDRC_A12: R180.1 U1.AP4(DDRC_A6) U6.M7(A12/BC_N) U7.M7(A12/BC_N)
MAC_DDRC_A13: R182.1 U1.AU3(DDRC_A3_A6A11) U6.T8(A13) U7.T8(A13)
MAC_DDRC_ACT_N: R190.1 U1.AT2(DDRC_ACT_ABI_N) U6.L3(ACT_N) U7.L3(ACT_N)
MAC_DDRC_ALERT0_N: U1.AR1(DDRC_ALERT_N_0) U6.P9(ALERT_N)
MAC_DDRC_ALERT1_N: U1.AH6(DDRC_ALERT_N_1) U7.P9(ALERT_N)
MAC_DDRC_BA0: R193.1 U1.AJ8(DDRC_A10) U6.N2(BA0) U7.N2(BA0)
MAC_DDRC_BA1: R194.1 U1.AR4(DDRC_A4_A13A12) U6.N8(BA1) U7.N8(BA1)
MAC_DDRC_BG0: R195.1 U1.AH7(DDRC_BA1_A5BA1) U6.M2(BG0) U7.M2(BG0)
MAC_DDRC_CAS_N: R185.1 U1.AP3(DDRC_CAS_N) U6.M8(CAS_N/A15) U7.M8(CAS_N/A15)
MAC_DDRC_CLK_DN: R202.1 U1.AK6(DDRC_CK_N) U6.K8(CK_C) U7.K8(CK_C)
MAC_DDRC_CLK_DP: R201.1 U1.AK5(DDRC_CK_P) U6.K7(CK_T) U7.K7(CK_T)
MAC_DDRC_CLK_EN: R200.1 U1.AG6(DDRC_CKE) U6.K2(CKE) U7.K2(CKE)
MAC_DDRC_CS0_N: R197.1 U1.AN2(DDRC_CS_N_0) U6.L7(CS_N)
MAC_DDRC_CS1_N: R198.1 U1.AM5(DDRC_CS_N_1) U7.L7(CS_N)
MAC_DDRC_DBI0_N: U1.AC4(DDRC_DBI_N_0) U6.E7(DML_N/DBIL_N)
MAC_DDRC_DBI1_N: U1.AH3(DDRC_DBI_N_1) U6.E2(DMU_N/DBIU_N)
MAC_DDRC_DBI2_N: U1.AE7(DDRC_DBI_N_2) U7.E7(DML_N/DBIL_N)
MAC_DDRC_DBI3_N: U1.AB6(DDRC_DBI_N_3) U7.E2(DMU_N/DBIU_N)
MAC_DDRC_DQ00: U1.AB1(DDRC_DQ_2) U6.G2(DQL0)
MAC_DDRC_DQ01: U1.AD2(DDRC_DQ_5) U6.F7(DQL1)
MAC_DDRC_DQ02: U1.AB3(DDRC_DQ_3) U6.H3(DQL2)
MAC_DDRC_DQ03: U1.AE1(DDRC_DQ_4) U6.H7(DQL3)
MAC_DDRC_DQ04: U1.AA2(DDRC_DQ_1) U6.H2(DQL4)
MAC_DDRC_DQ05: U1.AD3(DDRC_DQ_7) U6.H8(DQL5)
MAC_DDRC_DQ06: U1.AE3(DDRC_DQ_6) U6.J3(DQL6)
MAC_DDRC_DQ07: U1.AA3(DDRC_DQ_0) U6.J7(DQL7)
MAC_DDRC_DQ08: U1.AG2(DDRC_DQ_10) U6.A3(DQU0)
MAC_DDRC_DQ09: U1.AK2(DDRC_DQ_14) U6.B8(DQU1)
MAC_DDRC_DQ10: U1.AF1(DDRC_DQ_8) U6.C3(DQU2)
MAC_DDRC_DQ11: U1.AJ2(DDRC_DQ_13) U6.C7(DQU3)
MAC_DDRC_DQ12: U1.AF2(DDRC_DQ_9) U6.C2(DQU4)
MAC_DDRC_DQ13: U1.AM1(DDRC_DQ_12) U6.C8(DQU5)
MAC_DDRC_DQ14: U1.AG3(DDRC_DQ_11) U6.D3(DQU6)
MAC_DDRC_DQ15: U1.AM2(DDRC_DQ_15) U6.D7(DQU7)
MAC_DDRC_DQ16: U1.AK3(DDRC_DQ_21) U7.G2(DQL0)
MAC_DDRC_DQ17: U1.AE6(DDRC_DQ_16) U7.F7(DQL1)
MAC_DDRC_DQ18: U1.AL3(DDRC_DQ_22) U7.H3(DQL2)
MAC_DDRC_DQ19: U1.AG5(DDRC_DQ_18) U7.H7(DQL3)
MAC_DDRC_DQ20: U1.AL4(DDRC_DQ_23) U7.H2(DQL4)
MAC_DDRC_DQ21: U1.AD8(DDRC_DQ_20) U7.H8(DQL5)
MAC_DDRC_DQ22: U1.AH4(DDRC_DQ_19) U7.J3(DQL6)
MAC_DDRC_DQ23: U1.AC8(DDRC_DQ_17) U7.J7(DQL7)
MAC_DDRC_DQ24: U1.AB4(DDRC_DQ_24) U7.A3(DQU0)
MAC_DDRC_DQ25: U1.AF4(DDRC_DQ_31) U7.B8(DQU1)
MAC_DDRC_DQ26: U1.AE4(DDRC_DQ_28) U7.C3(DQU2)
MAC_DDRC_DQ27: U1.AF5(DDRC_DQ_30) U7.C7(DQU3)
MAC_DDRC_DQ28: U1.AB7(DDRC_DQ_26) U7.C2(DQU4)
MAC_DDRC_DQ29: U1.AC7(DDRC_DQ_29) U7.C8(DQU5)
MAC_DDRC_DQ30: U1.AA8(DDRC_DQ_27) U7.D3(DQU6)
MAC_DDRC_DQ31: U1.AA9(DDRC_DQ_25) U7.D7(DQU7)
MAC_DDRC_DQS0_DN: U1.AC2(DDRC_DQS0_WCK01_N) U6.F3(DQSL_C)
MAC_DDRC_DQS0_DP: U1.AC1(DDRC_DQS0_WCK01_P) U6.G3(DQSL_T)
MAC_DDRC_DQS1_DN: U1.AJ1(DDRC_DQS1_N) U6.A7(DQSU_C)
MAC_DDRC_DQS1_DP: U1.AH1(DDRC_DQS1_P) U6.B7(DQSU_T)
MAC_DDRC_DQS2_DN: U1.AJ5(DDRC_DQS2_WCK23_N) U7.F3(DQSL_C)
MAC_DDRC_DQS2_DP: U1.AJ4(DDRC_DQS2_WCK23_P) U7.G3(DQSL_T)
MAC_DDRC_DQS3_DN: U1.AD6(DDRC_DQS3_N) U7.A7(DQSU_C)
MAC_DDRC_DQS3_DP: U1.AD5(DDRC_DQS3_P) U7.B7(DQSU_T)
MAC_DDRC_ODT: R199.1 U1.AP1(DDRC_ODT) U6.K3(ODT) U7.K3(ODT)
MAC_DDRC_PAR: R196.1 U1.AR2(DDRC_PAR) U6.T3(PAR) U7.T3(PAR)
MAC_DDRC_RAS_N: R187.1 U1.AG8(DDRC_RAS_N) U6.L8(RAS_N/A16) U7.L8(RAS_N/A16)
MAC_DDRC_RES_NEG: R209.2 U1.AH10(DDRC_RES_NEG)
MAC_DDRC_RES_POS: R208.2 U1.AE10(DDRC_RES_POS)
MAC_DDRC_RES_VDD: R208.1 U1.AF10(DDRC_RES_VDD)
MAC_DDRC_RES_VSS: R209.1 U1.AJ10(DDRC_RES_VSS)
MAC_DDRC_RST_N: R207.1 U1.AN5(DDRC_RESET_N) U6.P1(RESET_N) U7.P1(RESET_N)
MAC_DDRC_WE_N: R183.1 U1.AJ7(DDRC_WE_N) U6.L2(WE_N/A14) U7.L2(WE_N/A14)
MAC_MCUPLL_LOCK: R12478.2 U1.AL33(UC_PLL_LOCK) U70.K12(IO_5_5)
MAC_PUC00_COREPLL_FREQ0: R32.1 R35.2 U1.AF37(PUC_00_CORE_PLL_FREQ_0)
MAC_PUC01_COREPLL_FREQ1: R33.2 U1.AG37(PUC_01_CORE_PLL_FREQ_1)
MAC_PUC02_COREPLL_FREQ2: R38.2 U1.AF32(PUC_02_CORE_PLL_FREQ_2)
MAC_PUC03_COREPLL_FREQ3: R31.1 R40.2 U1.AG32(PUC_03_CORE_PLL_FREQ_3)
MAC_PUC04_PD: R42.2 U1.AE34(PUC_04)
MAC_PUC05_I2C_ADDR0: R30.1 R34.2 U1.AF33(PUC_05_I2C_ADD_0)
MAC_PUC06_I2C_ADDR1: R29.1 R45.2 U1.AE32(PUC_06_I2C_ADD_1)
MAC_PUC07_PCIE_DIS: R28.1 R46.2 U1.AD33(PUC_07_PCIE_DIS)
MAC_PUC08_PD: R47.2 U1.AF34(PUC_08)
MAC_PUC09_PD: R48.2 U1.AF35(PUC_09)
MAC_PUC10_COREPLL_SEL: R27.1 U1.AE33(PUC_10)
MAC_PUC11_COREPLL_SEL: R26.1 U1.AF36(PUC_11)
MAC_RES_CAL0: R75.1 U1.N27(RES_CAL0)
MAC_RES_CAL1: R77.1 U1.N11(RES_CAL1)
MAC_THERM_DIODE_DN: R12906.2 U1.J25(THERM_DIODE_N)
MAC_THERM_DIODE_DP: R12905.2 U1.K25(THERM_DIODE_P)
MAC_VCORE_ROV0: R1813.2 U1.AL34(ROV_0) U150.4(P00)
MAC_VCORE_ROV1: R1814.2 U1.AJ34(ROV_1) U150.5(P01)
MAC_VCORE_ROV2: R1815.2 U1.AK34(ROV_2) U150.6(P02)
MDI_NIC1_DN0: D59.2(TX1-IN) D59.9(TX1-OUT) OJ1.BR1(D1-) U85.57(MDI_N[0])
MDI_NIC1_DN1: D59.5(TX2-IN) D59.6(TX2-OUT) OJ1.BR3(D2-) U85.54(MDI_N[1])
MDI_NIC1_DN2: D60.2(TX1-IN) D60.9(TX1-OUT) OJ1.BR5(D3-) U85.52(MDI_N[2])
