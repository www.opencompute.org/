# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INT_BMC_LOAD_DEFAULT_N: length 48.1
  TOP w0.117: R1835.1 v1(110.39,137.6)
  TOP w0.14: U154.A1 v4(72.13,121.73)
  T07 w0.117: v1(110.39,137.6) 110.17,137.38 100.8,137.38 95.9,132.48 95.9,131.24 91.06,126.4 91.06,125.98 89.41,124.33 87.36,124.33 86.54,125.15 84.39,125.15 83.06,123.83 81.03,123.83 80.78,123.58 79.85,123.58 79.84,123.58 79.24,123.58 78.99,123.83 74.23,123.83 v4(72.13,121.73)
INT_BMC_TO_CPU_N: length 48.4
  TOP w0.14: v1(71.75,125.35) 70.74,124.33 70.44,124.33 69.9,123.8 69.9,121.9 U154.D1 ; v1(86.36,141.35) 86.41,141.31 R1758.2
  T03 w0.117: v1(71.75,125.35) 72.14,124.97 77.09,124.97 77.6,125.48 v1(81.28,125.48)
  T05 w0.117: v1(81.28,125.48) 82.12,126.31 82.12,130.1 81.79,130.43 81.79,131.83 83.44,133.48 83.44,138.68 85.15,140.4 85.41,140.4 v1(86.36,141.35) 86.36,151.26 85.04,152.57 J1.B20
INT_BRD_ID_N: length 3.4
  TOP w0.14: R1872.1 113.03,185.55 v1(112.39,184.91) 111.72,184.23 U150.1
INT_CHIP_CPLD_TO_CPU_N: length 75.5
  TOP w0.14: R1707.2 84.15,166.96 82.04,164.85 J1.A17
  TOP w0.381: U70.J6 v4(114,126.45)
  T14 w0.117: v4(114,126.45) 113.84,126.29 113.25,126.29 112.8,125.84 112.8,125.49 112.57,125.25 109.84,125.25 108.9,124.32 107.05,124.32 106.79,124.59 104.27,124.59 104.15,124.47 102.08,124.47 99.74,126.81 99.74,137.59 100.17,138.02 100.17,140.56 100.97,141.36 100.97,142.94 98.09,145.83 98.09,152 96.27,153.82 96.27,154.33 95.37,155.23 94.16,155.23 93.12,156.26 93.12,156.75 92.38,157.49 83.51,157.49 J1.A17
INT_CJA_INTR_N: length 53.3
  TOP w0.14: U135.33 161.4,132.86 161.54,133 v1(161.54,133.03) 161.67,133.15 R1780.1 ; U70.G10 v4(118,127.25)
  T14 w0.117: v4(118,127.25) 118.37,126.88 120.73,126.88 122.96,124.65 122.96,124.21 123.34,123.83 124.18,123.83 125.14,124.79 126.67,124.79 133.31,131.43 133.72,131.43 v1(134.11,131.43) 143.83,131.43 147.04,134.64 150.74,134.64 151.37,134.01 159.2,134.01 160.19,133.03 v1(161.54,133.03)
INT_CJA_LOL_N: length 64.8
  TOP w0.14: U70.H9 v4(117.2,126.45) ; U135.27 160.97,129.86 161.16,130.05 162.05,130.05 162.31,129.79 164.83,129.79 v1(165.37,130.33)
  T14 w0.117: v1(165.37,130.33) 164.13,131.57 160.7,131.57 158.7,133.57 151.07,133.57 150.67,133.97 147.18,133.97 144.05,130.84 133.31,130.84 126.84,124.37 125.34,124.37 124.33,123.35 123.1,123.35 122.52,123.94 122.52,124.39 120.85,126.05 117.82,126.05 117.42,126.45 v4(117.2,126.45)
  BOTTOM w0.14: R1734.2 167.01,129.32 v2(166.55,129.78) 166,130.33 v1(165.37,130.33)
INT_CPLD_NMI_N: length 7.8
  TOP w0.14: R1706.2 R1832.2 R1833.2 108.47,121.92 109.35,122.8 109.35,123.36 110.02,124.03 110.78,124.03 U70.L2
INT_CPU_LOAD_DEFAULT_N: length 26.3
  TOP w0.14: R1834.1 v1(111.37,137.46)
  T14 w0.117: v1(111.37,137.46) 110.49,138.34 110.49,141.31 117.98,148.8 117.98,154.94 117.26,155.66 117.26,158.17 J1.A53
INT_CPU_TO_BMC_N: length 76.5
  TOP w0.14: U154.D4 v4(69.73,119.33) ; J1.B17 83.06,157.46 83.06,159.51 83.95,160.4 83.95,165.61 85.22,166.88 R1836.2
  T03 w0.117: J1.B17 81.01,157.48 63.86,157.48 v1(62.03,155.65)
  T05 w0.117: v4(69.73,119.33) 69.33,119.73 69.33,120.54 68.28,121.59 68.28,124.02 67.43,124.87 67.43,125.5 64.81,128.12 64.81,130.64 64.14,131.32 64.14,133.03 64.52,133.41 64.52,138.44 62.78,140.18 62.78,154.91 v1(62.03,155.65)
INT_FAN1_N: length 174.1
  TOP w0.14: U70.C13 v4(120.4,131.25) ; C1549.1 260.22,188.4 R1103.2 260.05,188.22 260.05,186.31 260.04,186.3 Q3.3 263.34,185.73 v1(263.4,185.67)
  T05 w0.117: v1(131.87,139.27) 129.14,139.27 121.12,131.25 v4(120.4,131.25)
  T14 w0.117: v1(131.87,139.27) 134.75,142.15 143,142.15 157.38,156.52 175.75,156.52 177.79,158.56 199.24,180.01 243.63,180.01 250.31,186.69 262.38,186.69 v1(263.4,185.67)
INT_FAN2_N: length 174.1
  TOP w0.14: C1564.1 265.05,188.52 R1130.2 264.86,188.34 Q8.3 264.86,185.08 v1(264.02,184.23) ; U70.D13 v4(120.4,130.45)
  T14 w0.117: v1(264.02,184.23) 263.94,184.15 262.76,184.15 260.74,186.17 250.39,186.17 243.8,179.59 199.41,179.59 175.92,156.1 157.55,156.1 143.18,141.73 135.63,141.73 130.52,136.61 126.2,136.61 120.93,131.34 120.93,130.97 v4(120.4,130.45)
INT_FAN3_N: length 196.7
  TOP w0.14: U70.E13 v4(120.4,129.65) ; v1(283.89,184.53) 284.35,184.53 285,185.18 Q16.3
  T14 w0.117: v1(283.89,184.53) 281.99,182.63 271.48,182.63 269.91,184.19 267.21,184.19 265.06,182.04 260.24,182.04 257.21,185.07 250.48,185.07 244.15,178.74 199.93,178.74 182.52,161.34 182.52,159.96 179.31,156.74 177.76,156.74 176.27,155.26 176.2,155.26 157.9,155.26 143.11,140.46 141.69,140.46 140.22,138.98 139.97,138.74 133.84,138.74 130.86,135.77 130.66,135.77 130.65,135.77 126.54,135.77 121.71,130.93 121.71,130.62 120.74,129.65 v4(120.4,129.65)
  BOTTOM w0.14: R1142.2 284.47,187.37 C1576.1 284.47,185.11 v1(283.89,184.53)
INT_FAN4_N: length 189.7
  TOP w0.14: v1(274.7,181.86) 274.83,181.99 274.83,184.78 Q7.3 275.79,188.23 R1129.2 275.97,188.41 C1561.1 ; U70.F12 v4(119.6,128.85)
  T14 w0.117: v4(119.6,128.85) 120.54,128.85 122.44,130.75 122.44,131.06 126.72,135.34 130.86,135.34 131.04,135.34 134.01,138.32 140.14,138.32 140.64,138.81 141.87,140.04 143.28,140.04 158.08,154.83 176.37,154.83 176.45,154.83 177.94,156.32 179.48,156.32 182.94,159.78 182.94,160.92 200.35,178.32 244.33,178.32 250.65,184.65 257.04,184.65 260.19,181.5 265.52,181.5 266.14,182.13 269.04,182.13 269.68,181.49 274.33,181.49 v1(274.7,181.86)
INT_FAN5_N: length 184.6
  TOP w0.14: v1(270.64,184.66) 271.09,185.11 Q15.3 C1578.1 R1141.2 ; U70.E12 v4(119.6,129.65)
  T14 w0.117: v1(270.64,184.66) 269.86,185.44 267.39,185.44 264.51,182.56 260.42,182.56 257.23,185.75 250.56,185.75 243.98,179.17 199.59,179.17 182.1,161.68 182.1,160.13 179.13,157.16 177.59,157.16 176.1,155.68 175.75,155.68 175.75,155.68 157.73,155.68 142.93,140.88 141.52,140.88 139.79,139.16 133.66,139.16 130.69,136.19 126.37,136.19 121.27,131.09 121.27,130.67 120.65,130.05 120,130.05 v4(119.6,129.65)
  BOTTOM w0.14: v2(269.44,184.66) v1(270.64,184.66)
INT_FAN_CARD_N: length 220.9
  TOP w0.14: v1(280.92,197.03) 280.32,197.64 J5.20 ; U70.J7 v4(115.6,125.65)
  T05 w0.117: v1(135.38,150.62) 133.35,148.59 133.35,146.05 125.69,138.39 121.5,138.39 121.03,137.92 121.03,137.5 119.33,135.8 119.09,135.56 119.09,134.96 118.24,134.11 118.24,133.65 117.6,133.02 117.6,126.29 117.37,126.05 116,126.05 v4(115.6,125.65)
  T14 w0.117: v1(135.38,150.62) 137.86,153.1 148.58,153.1 155.8,160.32 174.18,160.32 196.65,182.79 196.65,182.79 197.89,184.03 242.28,184.03 252.4,194.15 253.87,194.15 259.36,199.64 267.25,199.64 269.05,197.84 270.96,197.84 271.48,197.32 271.48,196.79 271.82,196.45 274.37,196.45 275.98,198.06 279.89,198.06 v1(280.92,197.03)
  BOTTOM w0.102: 114.3,121.54 115.44,121.54 116,122.09 116,125.3 115.65,125.65 v4(115.6,125.65)
  BOTTOM w0.14: v1(280.92,197.03) 280.68,197.28 R12468.2 ; 114.3,121.54 113.28,120.52 113.28,116.59 113.03,116.33 U101.2
INT_HWM_ALERT_N: length 99.9
  TOP w0.14: U70.J10 v4(118,125.65) ; v1(134.18,185.99) 131.65,188.52 131.65,193.23 131.21,193.67 131.21,196.88 R1037.1
  T14 w0.117: v4(118,125.65) 117.77,125.65 117.37,126.05 117.04,126.05 116.8,126.29 116.8,126.86 116.57,127.09 115.87,127.09 115.15,127.8 115.15,133.41 115.28,133.53 115.28,134.58 117.57,136.88 117.57,138.4 117.98,138.81 117.98,140.63 120.39,143.03 121.06,143.03 123.32,145.29 123.32,147.35 126.25,150.28 126.25,155.55 126.83,156.13 126.83,159.92 126.22,160.52 126.22,162.37 133.42,169.57 133.42,171.68 133.17,171.93 133.17,183.77 134.18,184.77 v1(134.18,185.99)
  BOTTOM w0.102: v4(118,125.65) 118,125.45 118.4,125.06 118.4,121.92
  BOTTOM w0.14: U101.1 113.03,115.68 113.79,116.44 113.79,119.51 v2(114.31,120.03) 115.19,120.9 118.02,120.9 118.4,121.28 118.4,121.92
INT_LOAD_DEFAULT_N: length 7.2
  TOP w0.14: U70.A4 112.61,132.65 112.61,134.29 111.97,134.93 110.68,134.93 110.39,135.22 R1835.2 R1834.2 R1711.2
INT_MAC_N: length 94.9
  TOP w0.14: U70.G9 v4(117.2,128.05) ; U1.AH36 v4(196.86,129.5) ; R67.1 v1(174.64,130.23)
  T05 w0.117: v4(196.86,129.5) 196.86,129.22 195.55,127.91 195.27,127.91 194.84,127.47 189.05,127.47 188.63,127.05 182.4,127.05 180.29,129.16 177.74,129.16 176.15,130.75 175.16,130.75 v1(174.64,130.23)
  T14 w0.117: v4(117.2,128.05) 117.6,127.65 118.18,127.65 118.59,127.24 121.06,127.24 123.04,125.27 126.56,125.27 134.25,132.97 144.77,132.97 147.04,135.25 148.48,135.25 150.99,137.76 153.48,137.76 154.4,136.84 164.2,136.84 166.7,134.33 170.81,134.33 171.7,133.44 172.98,133.44 173.81,132.61 173.81,131.07 v1(174.64,130.23)
INT_NIC1_ARLT_N: length 3.8
  TOP w0.14: U85.35 91.3,93.61 90.55,94.36 90.55,94.83 v6(90.24,95.14) 89.9,95.14 R1209.2
INT_NMI_CPLD_TO_BMC_N: length 41.2
  TOP w0.14: R1833.1 104.02,121.92 103.38,121.29 103.38,119.93 102.65,119.2 94.87,119.2 v1(90.75,123.32) ; U154.B2 v4(71.33,120.93)
  T07 w0.117: v1(90.75,123.32) 90.12,122.68 85.72,122.68 84.63,121.59 82.75,121.59 81.18,123.16 80.02,123.16 79.16,122.3 73.53,122.3 72.16,120.93 v4(71.33,120.93)
INT_NMI_CPLD_TO_CPU_N: length 59.4
  TOP w0.14: v5(104.27,121.22) 104.63,120.85 R1832.1
  T14 w0.117: J1.A16 81.04,155.92 81.89,155.08 81.89,153.97 83.14,152.71 92.14,152.71 95.55,149.31 95.55,145.45 96.72,144.27 97.85,144.27 99.33,142.79 99.33,138.6 97.29,136.56 97.29,127.47 102.19,122.57 102.91,122.57 v5(104.27,121.22)
INT_PHY1_N: length 86.7
  TOP w0.14: U23.G8 v4(131.21,98.36) ; U70.E6 v4(114,129.65) ; R282.2 139.1,97.57 v1(138.69,97.98)
  T07 w0.117: v1(129.29,130.84) 124.81,130.84 124.39,130.42 123.01,130.42 122.58,130.85 118.6,130.85 118.4,130.66 118.4,128.65 118.2,128.45 115.2,128.45 v4(114,129.65)
  T16 w0.117: v1(129.29,130.84) 128.91,130.46 128.91,122.31 127.92,121.32 127.92,119.76 119.56,111.4 119.56,110.04 113.96,104.43 113.96,98.51 114.65,97.82 122.58,97.82 123.12,98.36 v4(131.21,98.36)
  BOTTOM w0.14: v1(138.69,97.98) 138.44,97.73 137.64,97.73 136.88,96.97 136.01,96.97 135.74,97.24 135.74,97.59 135.45,97.88 131.69,97.88 v4(131.21,98.36)
INT_PHY3_N: length 212.2
  TOP w0.14: U25.K1 v4(283.1,101.39) 283.1,106.22 279.59,109.73 265.44,109.73 254.07,98.37 229.46,98.37 228.81,97.72 217.53,97.72 215.58,99.67 205.63,99.67 202.92,96.96 188.34,96.96 v1(186.28,94.9) ; U70.H8 v4(116.4,126.45) ; U25.M8 v4(281.1,94.39)
  T07 w0.117: v1(169.83,112.09) 169.83,108.72 182.61,95.95 185.23,95.95 v1(186.28,94.9)
  T14 w0.102: 120.63,124.46 120.57,124.46 116.96,124.46 116.8,124.61 116.8,125.83 116.4,126.23 v4(116.4,126.45)
  T14 w0.117: v1(127.36,120.78) 126.67,120.09 122.8,120.09 121.58,121.31 121.58,123.52 120.63,124.46
  T16 w0.117: v4(283.1,101.39) 280.58,98.87 280.58,94.91 v4(281.1,94.39)
  T18 w0.117: v1(169.83,112.09) 167.88,114.05 154.61,114.05 151.95,116.71 134.24,116.71 133.48,115.95 128.97,115.95 127.57,117.35 127.57,120.57 v1(127.36,120.78)
  BOTTOM w0.14: R306.2 283.24,101.24 v4(283.1,101.39)
INT_PSU1_N: length 218.7
  TOP w0.14: U70.A3 v4(111.6,132.85)
  T05 w0.117: v1(40.89,100.46) 39.88,100.46 37.68,102.66 37.68,104.72 36,106.4 36,123.22 38.25,125.48 40.13,125.48 41.48,126.82 41.48,128.32 47.69,134.53 49.64,134.53 50.97,135.86 50.97,167.65 46.57,172.06 46.57,187.33 46.26,187.64 46.26,188.47 41.9,192.82 39.02,192.82 38.19,193.66 38.19,196.1 v1(38.71,196.62)
  T16 w0.117: v4(111.6,132.85) 111.2,132.45 109.59,132.45 108.97,131.83 108.97,129.29 106.43,126.75 106.43,122.68 105.73,121.98 99.63,121.98 91.55,113.91 91.55,105.02 89.47,102.93 89.47,101.61 87.42,99.56 76.01,99.56 75.14,100.43 54.97,100.43 54.44,99.91 41.45,99.91 v1(40.89,100.46)
  BOTTOM w0.14: U102.1 41.13,192.74 40.26,193.62 40.26,195.58 v2(39.65,196.19) 39.22,196.62 v1(38.71,196.62) C1597.2 R1161.1
INT_PSU2_N: length 202.1
  TOP w0.14: U70.L4 v4(112.4,124.05)
  T05 w0.117: v1(39.37,193.4) 42,193.4 46.3,189.1 47.37,189.1 47.84,188.64 47.84,183.85 47.41,183.43 47.41,172.4 51.82,168 51.82,135.51 49.99,133.69 48.04,133.69 42.33,127.98 42.33,126.41 39.62,123.7 39.24,123.7 38.65,123.1 38.65,107.59 42.99,103.25 45.46,103.25 45.9,103.69 48.71,103.69 49.22,103.18 49.76,103.18 49.9,103.05 53.45,103.05 56.46,100.05 74.73,100.05 76.77,98 79.92,98 84.15,102.23 85.49,102.23 86.32,103.07 86.32,109.08 95.44,118.2 102.66,118.2 v1(102.87,117.98)
  T07 w0.102: v4(112.4,124.05) 112.01,123.66 112.01,122.31 111.05,121.34
  T07 w0.117: 111.05,121.34 107.69,117.98 v1(102.87,117.98)
  BOTTOM w0.14: R1183.1 C1603.2 39.24,193.27 v1(39.37,193.4) 40.27,192.51 40.27,190.78 40.58,190.47 41.45,190.47 41.78,190.81 U102.2
INT_PTP_CPLD_TO_CPU_N: length 70.1
  TOP w0.14: J1.A21 86.04,166.18 86.29,166.43 R1709.2 ; U70.H6 v4(114,127.25)
  T14 w0.117: v4(114,127.25) 113.5,126.75 113.18,126.75 112.86,126.43 110.4,126.43 108.71,124.74 107.23,124.74 106.7,125.28 106.7,126.18 104.53,128.34 102.05,128.34 101.32,128.34 100.16,129.51 100.16,137.25 100.59,137.68 100.59,140.35 101.39,141.15 101.39,143.12 100.2,144.31 100.2,151.57 97.83,153.94 97.83,154.77 96.93,155.67 95.72,155.67 95.12,156.26 95.12,156.48 93.56,158.04 86.95,158.04 J1.A21
INT_QSFP28_N: length 216.6
  TOP w0.14: U70.N12 v4(119.6,122.45)
  T03 w0.117: v4(119.6,122.45) 122.43,119.63 122.43,117.73 126.41,113.75 142.07,113.75 144.34,113.75 149.67,108.42 149.67,107.69 149.67,105.54 152.38,102.82 152.38,93.6 152.41,93.57 153.55,92.43 153.55,88.33 152.41,87.19 152.41,87.17 151.64,86.4 151.64,82.19 150.29,80.84 150.29,77.92 152.23,75.98 152.23,73.67 153.01,72.88 155.34,72.88 157.92,70.3 190.19,70.3 190.44,70.06 200.37,60.12 200.37,46.61 201.51,45.47 202.09,45.47 207.24,40.31 212.28,40.31 214.35,38.24 219.14,38.24 219.79,37.59 222.63,37.59 223.14,37.08 223.14,36.41 224.55,35 224.79,34.76 224.79,34.01 225.35,33.45 226.82,33.45 228.43,35.05 241.68,35.05 242.05,35.42 247.95,35.42 250.31,33.07 255.57,33.07 256.66,34.16 v1(261.82,34.16)
  BOTTOM w0.14: U57.1 262.57,33.41 v1(261.82,34.16) 261.13,34.85 R741.1
INT_SFP+_ABS_N0: length 139.9
  TOP w0.14: U70.M7 v4(115.6,123.25)
  T03 w0.117: v1(171.78,34.87) 172.26,35.35 172.26,44.29 169.65,46.89 169.65,61.41 164.08,66.98 149.42,66.98 143.02,73.38 143.02,85.4 146.05,88.43 146.05,92.58 147.73,94.27 147.73,102.63 139.99,110.38 124.83,110.38 119.04,116.16 119.04,118.03 117.9,119.17 116,119.17 115.45,119.72 115.45,120.55 116,121.1 116,122.85 v4(115.6,123.25)
  BOTTOM w0.14: U47.1 173.19,33.46 v1(171.78,34.87) R651.1
INT_SFP+_ABS_N1: length 162.1
  TOP w0.14: U70.M11 v4(118.8,123.25)
  T03 w0.117: v1(203.57,43.01) 203.57,43.39 201.87,45.09 201.19,45.09 200,46.27 200,59.9 190.02,69.88 155.25,69.88 151.81,73.33 151.81,75.81 149.87,77.75 149.87,85.22 151.99,87.35 151.99,93.39 151.96,93.42 151.96,102.64 149.25,105.36 149.25,108.25 145.93,111.56 142.98,111.56 141.21,113.33 126.15,113.33 122.01,117.48 122.01,119.37 119.2,122.18 119.2,122.85 v4(118.8,123.25)
  BOTTOM w0.14: U49.1 204.4,32.46 202.84,34.01 R669.1 202.39,35.17 202.18,35.38 202.18,37.59 202.95,38.35 202.95,42.39 v1(203.57,43.01)
INT_SFP+_DIS_N0: length 4.7
  BOTTOM w0.14: U54.1 100.96,33.46 v2(100.62,33.81) 99.97,34.45 R706.1
INT_SFP+_DIS_N1: length 4
  BOTTOM w0.14: U56.1 233.75,32.46 v2(232.41,33.8) 231.54,34.67 R724.1
INT_SFP+_DIS_N2: length 3.5
  TOP w0.14: U58.1 101.85,195.74 v1(102.08,195.51)
  BOTTOM w0.14: v1(102.08,195.51) 101.78,195.8 R742.1
INT_SFP+_FLT_N0: length 167.3
  TOP w0.14: U70.J5 v4(113.2,125.65)
  T03 w0.102: 114.29,125.25 113.6,125.25 v4(113.2,125.65)
  T03 w0.117: v1(115.32,26.38) 115.79,26.86 132.92,26.86 142.69,36.62 142.69,40.75 141.99,41.45 141.99,45.66 140.4,47.25 140.4,50.3 140.83,50.73 140.83,54 141.38,54.55 141.38,60.61 141.18,60.81 141.18,65.07 138.85,67.4 138.85,83.17 144.79,89.11 144.79,93.11 146.47,94.79 146.47,99.97 141.41,105.03 138.53,107.9 132.61,107.9 132.28,108.23 120.34,108.23 114.18,114.39 114.18,121.07 114.72,121.61 114.72,124.82 114.29,125.25
  T14 w0.117: v1(114.49,35) 114.49,31.03 112.91,29.45 112.91,27.95 114.48,26.38 v1(115.32,26.38)
  BOTTOM w0.14: R705.1 114.02,35.47 v1(114.49,35) 116.01,35 116.6,34.41 U53.1
INT_SFP+_FLT_N1: length 207.3
  TOP w0.14: U70.N10 v4(118,122.45)
  T03 w0.117: v1(247.32,33.8) 242.52,33.8 240.85,32.13 235.17,32.13 233.85,33.46 228.94,33.46 227.66,32.18 223.09,32.18 221.49,33.78 221.49,34.42 220.91,35 203.12,35 201.96,36.16 201.96,38.06 202.81,38.91 202.81,41.67 198.89,45.59 198.89,59.22 189.54,68.57 152,68.57 149.39,71.19 149.39,76.43 148.6,77.23 148.6,86.81 149.07,87.28 149.07,89.04 149.42,89.39 149.42,102.98 149.42,103.33 140.69,112.06 125.63,112.06 120.74,116.95 120.74,118.85 118,121.59 v4(118,122.45)
  BOTTOM w0.14: U55.1 248.47,33.49 248.16,33.8 v1(247.32,33.8) 247.27,33.8 R723.1
INT_SFP+_LOS_N0: length 125.2
  TOP w0.14: U70.K6 v4(114,125.65)
  T03 w0.117: v1(143.4,35.47) 143,35.87 143,36.34 143.11,36.45 143.11,40.92 142.62,41.41 142.62,45.55 140.77,47.41 140.77,50.15 141.2,50.57 141.2,53.85 141.75,54.39 141.75,65.58 140.77,66.56 140.77,79.27 142.18,80.68 142.18,85.4 142.18,85.4 142.18,85.75 145.21,88.78 145.21,92.93 146.89,94.62 146.89,102.28 140.85,108.33 132.78,108.33 132.46,108.65 132.11,108.65 120.52,108.65 114.61,114.56 114.61,120.88 114.64,120.93 115.04,121.34 115.04,125.01 114.4,125.65 v4(114,125.65)
  BOTTOM w0.14: U48.1 144.85,33.46 v2(143.89,34.42) 143.89,34.98 v1(143.4,35.47) R652.1
INT_SFP+_LOS_N1: length 243.5
  TOP w0.14: U70.M10 v4(118,123.25)
  T03 w0.117: v4(118,123.25) 118.4,122.85 118.4,121.78 121.16,119.02 121.16,117.13 125.8,112.49 140.86,112.49 144.52,108.83 146.74,108.83 148.4,107.16 148.4,105.01 149.84,103.57 149.84,103.5 149.84,103.5 149.84,102.81 149.84,102.8 149.84,89.21 149.6,88.97 149.5,88.87 149.5,87.04 149.02,86.57 149.02,77.4 149.81,76.61 149.81,73.58 154.36,69.04 189.67,69.04 199.26,59.44 199.26,45.82 203.24,41.84 203.24,39.21 204.94,37.5 213.35,37.5 215.4,35.45 222.11,35.45 222.94,34.61 222.94,33.85 224.19,32.6 227.49,32.6 228.77,33.88 231.59,33.88 231.59,33.88 234.02,33.88 235.35,32.55 240.68,32.55 242.71,34.58 247.6,34.58 249.96,32.22 255.95,32.22 256.84,33.11 266.89,33.11 271.58,28.42 v1(271.58,27.93)
  BOTTOM w0.14: v1(271.58,27.93) 271.58,19.13 271.86,18.85 R670.1 274.37,16.77 U50.1
INT_SFP+_RS_N0: length 5.1
  BOTTOM w0.14: R687.1 126.44,35.41 v2(126.9,34.95) 127.56,34.28 128.66,34.28 129.48,33.46 U51.1
INT_SFP+_RS_N1: length 4.5
  BOTTOM w0.14: R688.1 v2(184.97,34.87) 184.97,34.81 186.44,33.35 U52.1
INT_SFP_CPLD_TO_CPU_N: length 43.3
  TOP w0.14: U70.B5 v4(113.2,132.05) ; J1.A52 116.71,161.28 R1710.2
  T14 w0.117: J1.A52 117.43,160.95 118.97,159.41 118.97,156.14 119.83,155.28 119.83,149.93 112.96,143.07 112.96,133.28 112.8,133.12 112.8,132.45 v4(113.2,132.05)
INT_SMU_N: length 134
  TOP w0.14: U139.J9 v4(16.43,89.3) ; U70.L10 v4(118,124.05)
  T16 w0.102: v4(118,124.05) 118.04,124.05 118.4,123.69 118.4,122.05
  T16 w0.117: v4(16.43,89.3) 16.97,88.76 18.89,88.76 19.83,87.82 23.88,87.82 24.82,88.75 27.33,88.75 28.03,88.05 32.73,88.05 34.34,89.66 42.44,89.66 42.87,89.23 43.92,89.23 45.44,90.75 60.88,90.75 63.46,93.33 69.18,93.33 70.45,94.59 70.45,95.71 70.45,95.72 70.45,96.06 71.95,97.57 78.32,97.57 79.48,98.72 87.85,98.72 88.1,98.97 90.31,101.18 90.31,102.58 94.2,106.47 101.62,106.47 104.33,109.19 104.33,110.89 104.33,110.89 104.33,111.53 106.6,113.81 110.51,113.81 115.77,119.08 117.28,119.08 118.4,120.19 118.4,122.05
  BOTTOM w0.14: R1685.1 v2(11.68,91.63) 12.34,91.63 13.07,92.36 15.49,92.36 15.91,91.94 15.91,89.81 16.42,89.3 v4(16.43,89.3)
INT_TSEN_ALRT_N: length 352.1
  TOP w0.14: U75.6 226.79,173.32 227.58,174.12 227.58,175.7 v1(227.84,175.95) ; v1(118.77,101.07) 118.05,101.79 118.05,113.96 127.31,123.21 127.31,127.07 125.22,129.16 v1(123.95,129.16) ; U70.F8 v4(116.4,128.85)
  T03 w0.117: v1(157.93,153.87) 155.98,151.92 141,151.92 133.83,144.75 133.83,137.96 127.94,132.07 126.86,132.07 v1(123.95,129.16) 123.3,129.16 122.97,129.49 121.45,129.49 120.41,128.45 116.8,128.45 v4(116.4,128.85)
  T07 w0.117: v1(123.95,129.16) 128.52,129.16 130.94,131.57 130.94,135.89 126.63,140.2 121.64,140.2 121.4,139.95 120.03,139.95 119.79,140.2 113.55,140.2 110.82,142.92 109.06,142.92 108.89,143.09 99.64,143.09 99.47,142.92 87.6,142.92 87.02,143.51 v1(85.6,143.51)
  T14 w0.117: v1(227.84,175.95) 227.49,176.3 198.96,176.3 183.37,160.71 183.37,159.61 178.82,155.06 178.82,154.54 178.12,153.85 176.7,153.85 176.13,154.41 158.48,154.41 v1(157.93,153.87) ; v1(82.17,124.46) 81.3,123.59 80.41,123.59 78.99,122.17 77.3,122.17 76.47,121.34 76.47,120.64 74.95,119.12 74.95,106.07 70.67,101.8 68.4,101.8 65.53,98.93 65.53,97.52 67.16,95.89 67.16,95.35 v1(67.82,94.69)
  T16 w0.117: v1(68.71,131.09) 68.99,130.81 71.98,130.81 73.12,131.95 77.72,131.95 82.93,137.16 82.93,141.35 84.58,143 85.09,143 v1(85.6,143.51)
  T18 w0.117: v1(82.17,124.46) 82.17,125.48 81.41,126.24 77.09,126.24 75.31,128.02 74.68,128.02 74.17,128.52 74.17,130.81 73.66,131.32 72.39,131.32 71.88,130.81 68.99,130.81 v1(68.71,131.09)
  BOTTOM w0.14: v1(68.71,131.09) 67.88,130.27 67.88,128.33 69.11,127.1 R1024.1 69.63,126.85 67.82,125.04 67.82,123.83 68,123.64 U185.3 ; v1(67.82,94.69) 67.82,93.42 68.07,93.17 69.85,93.17 70.25,92.77 U99.1 ; R13019.1 118.49,100.8 v1(118.77,101.07) 119.36,101.07 119.97,100.46 119.97,98.6 121.4,97.16 122.59,97.16 122.87,96.88 128.38,96.88 128.77,96.49 U74.3
INT_TSEN_NMI_N: length 284.2
  TOP w0.14: U70.E9 v4(117.2,129.65) ; v1(52.07,186.69) 51.05,186.69 50.16,187.58 50.16,188.73 U145.1 ; U154.C3 v4(70.53,120.13) ; R1047.1 R1046.1 222.53,170.15 222.23,170.45 222.23,171.77 v1(221.86,172.14)
  T05 w0.117: v1(75.01,171.27) 75.01,169.25 72.26,166.51 72.26,160.14 73.25,159.15 73.25,155.85 72.26,154.86 72.26,152.86 73.84,151.27 73.84,137.98 72.85,136.99 72.85,132.05 71.25,130.44 71.25,129.67 70.87,129.29 70.87,125.31 71.63,124.55 71.63,123.06 70.93,122.36 70.93,120.76 70.53,120.36 v4(70.53,120.13)
  T07 w0.117: v1(52.07,186.69) 52.58,186.69 59.94,179.32 59.94,178.31 65.4,172.85 72.77,172.85 74.35,171.27 v1(75.01,171.27) ; v4(117.2,129.65) 116.8,130.05 116.8,133.2 116.53,133.48 115.95,133.48 114.89,134.53 108.03,134.53 107.99,134.49 105.16,134.49 103.67,135.98 101.94,135.98 101.56,135.6 100.48,135.6 96.74,131.86 96.74,130.89 92.07,126.22 92.07,123.03 90.47,121.43 85.87,121.43 85.15,120.71 81.72,120.71 81.15,121.28 78.99,121.28 77.86,120.15 74.55,120.15 74.04,119.63 71.02,119.63 v4(70.53,120.13)
  BOTTOM w0.102: 119.38,131.83 119.2,131.64 119.2,131.09 118.97,130.86 117.82,130.86 117.6,130.64 117.6,130.18 117.2,129.78 v4(117.2,129.65)
  BOTTOM w0.14: v1(221.86,172.14) 221.86,174.89 219.96,176.78 196.98,176.78 181.48,161.29 170.89,161.29 153.74,144.15 145.16,144.15 145.1,144.08 144.85,144.08 137.29,136.53 127.51,136.53 125.35,134.37 120.78,134.37 119.38,132.97 119.38,131.83
INT_TSEN_THERM_N: length 2.1
  TOP w0.14: R1047.2 v1(224.08,171.63) 224.08,171.9 223.58,172.41 U75.4
INT_VCORE_ALRT_N: length 329.9
  TOP w0.14: v1(81.03,118.04) 80.45,117.46 77.99,117.46 76.67,118.78 75.65,118.78 75.14,119.3 71.3,119.3 U154.B4
  T05 w0.117: v1(120.73,163.59) 117.27,163.59 116.01,162.33 116.01,160.33 117.02,159.31 117.02,155.94 116.08,155 116.08,153.14 113.44,150.5 113.44,145.92 111.49,143.97 104.3,143.97 96.87,136.53 96.87,123.74 93.94,120.81 84.38,120.81 81.61,118.04 v1(81.03,118.04)
  T16 w0.117: v1(304.33,138.35) 304.18,138.5 304.18,141.39 307.84,145.06 307.84,173.26 301.94,179.16 262.79,179.16 258.6,183.35 201.88,183.35 198.22,187.01 167.65,187.01 158.44,177.8 146.08,177.8 143.29,175 143.29,170.81 136.08,163.59 v1(120.73,163.59)
  BOTTOM w0.14: v1(304.33,138.35) 304.46,138.21 PR122.2 ; R12716.2 v1(81.03,118.04)
INT_VCORE_VR_FAULT_N: length 331.4
  TOP w0.14: U154.D2 v4(69.73,120.93) ; PU4.27 292.49,137.04 v1(292.61,137.16)
  T05 w0.117: v4(69.73,120.93) 68.75,121.91 68.75,124.15 67.86,125.04 67.86,125.67 67.48,126.05 67.48,133.69 65.7,135.46 65.7,138.09 66.29,138.67 66.29,152.64 66.02,152.91 66.02,155.24 65.09,156.17 65.09,159.35 66.09,160.35 66.09,164.89 72.01,170.81 72.01,176.13 75.95,180.08 80.83,180.08 85.47,184.71 v1(85.47,186.18)
  T18 w0.117: v1(85.47,186.18) 93.22,186.18 95.59,188.55 115.87,188.55 116.04,188.72 120.27,188.72 122.22,186.77 124.03,186.77 126.09,188.83 132.39,188.83 132.86,189.3 139.89,189.3 140.33,188.85 142.75,188.85 143.2,189.3 147.91,189.3 151.55,185.66 161.91,185.66 163.16,186.91 180.86,186.91 182.15,185.62 256.63,185.62 266.76,175.49 266.76,161.33 269.53,158.56 269.53,148.51 274.74,143.3 283.41,143.3 283.99,143.88 287.92,143.88 292.06,139.74 292.06,137.71 v1(292.61,137.16)
  BOTTOM w0.14: v1(292.61,137.16) 293.61,138.16 PR140.1
ISHARE: length 38
  TOP w0.305: v5(33.49,168.4) 33.49,167.92 34.58,166.83 PU2.31
  TOP w0.381: PC396.1 33.48,168.4 v5(33.49,168.4)
  T07 w0.381: v5(33.49,168.4) 33.49,169.1 21.19,181.4 18.43,181.4 17.04,182.79 8.61,182.79 v1(7.5,183.9)
  BOTTOM w0.381: v1(7.5,183.9) 8.54,182.86 PR441.1
ISHARE_R: length 5.7
  TOP w0.254: PU22.31 8.41,179.59 v5(7.69,180.32) 7.32,180.69 PC394.1
  BOTTOM w0.14: v5(7.69,180.32) v2(8.38,181.01) 8.74,181.36 PR441.2
JITTER_A0: length 5.8
  TOP w0.14: U135.16 156.08,125.68 156.81,124.95 v1(156.81,124.57) 157.22,124.16 R1782.1
  BOTTOM w0.14: R1782.1 157.22,124.16 v1(156.81,124.57) 156.72,124.66 156.72,125.27 156.18,125.8 v2(156.18,126.12)
JITTER_A1: length 5.3
  TOP w0.14: U135.15 155.58,125.4 v1(156.08,124.9) R1781.1
  BOTTOM w0.14: R1781.1 v1(156.08,124.9) v2(154.84,126.14)
JTAG_BITS_RST_N: length 6
  TOP w0.14: U127.77 67,76.85 68.58,78.43 v5(68.58,78.99)
  BOTTOM w0.14: R1619.2 68.89,79.31 v5(68.58,78.99)
JTAG_BMC_PIN17_PD: length 5.1
  TOP w0.14: J17.17 R12374.2
JTAG_BMC_RST_N: length 75.3
  TOP w0.14: R12420.1 46.62,133.99 v1(52.32,133.99)
  T07 w0.117: v1(52.32,133.99) 53.33,135 57.11,135 57.96,135.85 59.52,135.85 64.22,140.55 67.6,140.55 68.27,139.89 70.3,139.89 72.81,137.37 86.53,137.37 87.12,136.78 94.74,136.78 95.5,137.54 98.17,137.54 101.91,141.28 105.98,141.28 v1(106.68,141.99)
  T14 w0.117: J17.15 v1(106.68,141.99)
JTAG_BMC_RTCK: length 47.1
  TOP w0.102: U154.G4 v4(67.33,119.33)
  TOP w0.14: v1(94.74,138.18) 94.87,138.05 97.41,138.05 99.85,140.49 R12373.2 R12730.1
  T14 w0.117: v4(67.33,119.33) 67.73,119.73 72.61,119.73 74.21,121.33 74.21,123.61 75.29,124.68 76.54,124.68 77.66,125.8 77.66,127.44 78.32,128.1 78.32,129.63 81.31,132.62 82.12,132.62 86.48,136.97 88.25,136.97 89.79,138.52 94.4,138.52 v1(94.74,138.18)
JTAG_BMC_RTCK_SR: length 5.1
  TOP w0.14: J17.11 101.6,141.43 R12730.2
JTAG_BMC_TCK: length 44.3
  TOP w0.14: R12371.1 R12370.1 v1(97.92,139.63) ; U154.F2 v4(68.13,120.93)
  T14 w0.117: v1(97.92,139.63) 97.08,140.46 91.31,140.46 90.21,139.36 88.81,139.36 88.17,138.71 87.02,138.71 82.05,133.74 79,133.74 77.48,132.21 77.48,128.45 75.94,126.91 73.88,126.91 73.17,126.2 73.17,123.78 70.86,121.47 68.67,121.47 v4(68.13,120.93)
JTAG_BMC_TCK_SR: length 5.1
  TOP w0.14: J17.9 99.06,141.43 R12371.2
JTAG_BMC_TDI: length 44.9
  TOP w0.14: J17.5 94.87,145.47 v1(94.87,141.94) R12366.1 ; U154.F1 v4(67.73,121.98)
  T14 w0.117: v4(67.73,121.98) 67.73,123.19 71.67,127.13 72.48,127.13 73.54,128.19 73.54,129.21 74.37,130.04 74.37,132.98 75.97,134.58 81.7,134.58 86.51,139.39 86.51,139.98 88.48,141.94 v1(94.87,141.94)
JTAG_BMC_TDO: length 53.8
  TOP w0.14: R12368.1 103.91,141.12 v1(103.91,142.05) 103.91,146.13 J17.13 ; U154.G3 v4(67.33,120.13)
  T07 w0.117: v1(96.95,138.73) 98.6,138.73 101.94,142.07 103.9,142.07 v1(103.91,142.05)
  T14 w0.117: v4(67.33,120.13) 67.73,120.53 71.64,120.53 73.71,122.6 73.71,124.09 77.9,128.28 77.9,129.97 81.16,133.23 82.13,133.23 87.2,138.29 88.51,138.29 89.15,138.94 96.75,138.94 v1(96.95,138.73)
JTAG_BMC_TMS: length 47
  TOP w0.14: J17.7 96.52,142.19 v1(96.29,141.96) 95.89,141.55 R12367.1 ; U154.G2 v4(67.33,120.93)
  T14 w0.117: v1(96.29,141.96) 95.43,141.1 91.35,141.1 90.04,139.78 88.6,139.78 87.95,139.13 86.85,139.13 81.87,134.16 78.41,134.16 76.99,132.73 75.5,132.73 74.79,132.02 74.79,129.87 73.96,129.04 73.96,128.01 72.65,126.71 72.65,123.96 70.74,122.05 68.45,122.05 v4(67.33,120.93)
JTAG_BMC_TRST_N: length 47.7
  TOP w0.14: U154.E1 68.33,121.53 68.33,123.44 68.83,123.95 68.83,125.09 v1(69.72,125.98) 70.23,126.49 R12413.1 ; R12365.1 R12372.2 C2274.2 93.85,143.95 J17.3
  T14 w0.117: J17.3 91.44,145.54 86.36,140.46 85.47,140.46 80.45,135.44 80.45,135.4 80.12,135.07 80.08,135.07 80.01,135 75.79,135 75.46,134.67 73.94,133.16 73.94,132.81 73.94,130.22 73.12,129.39 73.12,128.36 72.52,127.76 71.5,127.76 v1(69.72,125.98)
JTAG_BRCM_OE: length 10.5
  BOTTOM w0.14: R1861.1 R1862.2 112,100.89 v2(111.72,100.62) U149.1 110.24,102.24 110.49,102.49 110.49,103.76 109.59,104.66 U149.19
JTAG_BRCM_RST_N: length 296.4
  TOP w0.14: U25.C9 v4(291.1,93.39) ; U23.B11 136.24,95.38 137.04,95.38 138.18,96.53 v1(138.18,96.67) ; U1.AH34 v4(198.86,129.5) ; R49.2 v1(183.53,128.89)
  T03 w0.117: v1(231.38,82.89) 229.64,84.64 187.25,84.64 184.18,87.71 v1(184.18,91.06) 184.18,96.28 185.42,97.52 185.42,107.95 188.57,111.1 191.18,111.1 194.21,114.14 194.21,115.11 195.11,116 197.04,116 197.39,115.65 199.28,115.65 199.64,116 200.13,116 200.74,116.61 200.74,117.12 204.26,120.65 204.26,129.66 204.03,129.9 199.26,129.9 v4(198.86,129.5) ; v1(250.18,82.17) 250.18,83.17 261.3,94.29 271.57,94.29 272.22,94.94 277.31,94.94 277.57,95.2 277.57,95.78 277.78,95.99 280.22,95.99 280.6,95.61 280.6,95.11 280.75,94.95 283.4,94.95 284.44,93.91 290.83,93.91 291.1,93.64 v4(291.1,93.39)
  T07 w0.117: v1(183.53,128.89) 184.18,129.54 187.58,129.54 189.23,127.89 195.33,127.89 196.47,129.03 198.4,129.03 v4(198.86,129.5) ; v1(103.5,95.94) 104.72,94.73 106.87,94.73 108.82,92.78 111.14,92.78 111.76,93.41 115.86,93.41 116.82,92.45 117.93,92.45 120.37,94.89 120.55,94.89 122.05,96.39 122.05,96.69 124.32,98.96 136.18,98.96 136.75,98.39 136.75,97.82 137.9,96.67 v1(138.18,96.67) 138.86,96.67 139.47,97.28 142.24,97.28 142.83,97.87 154.6,97.87 154.96,98.22 158.29,98.22 160.15,100.08 168.91,100.08 170.97,98.02 170.97,93.45 173.86,90.55 182.04,90.55 182.64,91.15 184.09,91.15 v1(184.18,91.06)
  T14 w0.117: v1(250.18,82.17) 249.91,81.9 232.38,81.9 v1(231.38,82.89)
  BOTTOM w0.14: R1857.1 v1(103.5,95.94)
JTAG_BRCM_TDI: length 3.9
  BOTTOM w0.14: v2(113.03,96.39) 112.75,96.68 R1845.2 R1844.2 R1859.1
JTAG_BRCM_TMS: length 325.9
  TOP w0.14: v4(136.21,100.36) U23.B6 ; U25.C10 v4(291.1,91.39) ; U1.AJ32 v4(200.86,130.5)
  T07 w0.117: v1(165.91,153.8) 170.98,158.87 182.22,158.87 182.65,159.29 189.02,159.29 198.27,150.03 198.27,134.52 198.78,134.01 198.91,134.01 199.44,133.48 199.44,132.35 199.89,131.9 200.03,131.9 200.46,131.46 200.46,130.9 v4(200.86,130.5) 201.26,130.09 201.83,130.09 202.46,129.46 202.46,129.33 202.69,129.09 202.83,129.09 203.31,128.61 203.31,128.48 203.69,128.09 203.83,128.09 204.46,127.46 204.46,127.33 204.89,126.9 224.03,126.9 224.41,126.51 224.41,121.38 225.21,120.58 230.63,120.58 231.32,119.89 231.32,116.28 231.65,115.95 235.84,115.95 241.94,109.86 241.94,104.27 241.43,103.76 241.43,84.84 246.89,79.38 258.83,79.38 260.1,78.11 274.57,78.11 279.15,82.68 289.43,82.68 290.6,83.85 290.6,90.89 v4(291.1,91.39)
  T16 w0.117: v1(112.42,95.48) 113.12,96.17 113.12,104.78 118.72,110.39 118.72,111.75 123.2,116.23 123.2,118.18 128.07,123.05 128.07,131.47 129.89,133.29 134.1,133.29 143,142.19 143,143.66 152.41,153.07 165.18,153.07 v1(165.91,153.8)
  T18 w0.117: v1(112.42,95.48) 112.58,95.48 114.64,97.54 119.63,97.54 121.06,98.96 131.85,98.96 132.65,99.76 135.61,99.76 v4(136.21,100.36)
  BOTTOM w0.14: R1858.1 109.15,95.48 v1(112.42,95.48) ; v4(291.1,91.39) 292.05,91.39 v2(292.1,91.44)
JTAG_CHAIN_RST_N: length 17.4
  TOP w0.14: CN6.10 113.66,107.87 v1(113.49,108.04)
  T14 w0.117: v1(113.49,108.04) 113.49,106.93 112.62,106.06 105.8,106.06 v1(104.65,104.9)
  BOTTOM w0.14: v1(113.49,108.04) 113.55,108.1 113.55,109.15 R1851.2 R1848.1 ; U149.11 104.39,105.16 v1(104.65,104.9)
JTAG_CHAIN_TCK: length 10.3
  TOP w0.14: v1(109.07,107.85) 108.58,107.37 CN6.6 108.58,104.28 v1(109.73,103.13)
  BOTTOM w0.14: R1852.2 R1847.1 108.71,108.21 v1(109.07,107.85) ; v1(109.73,103.13) 109.59,102.99 U149.2
JTAG_CHAIN_TCK_BUFF: length 9.5
  BOTTOM w0.14: R1853.1 104.78,98.04 v2(105.28,98.55) 105.69,98.96 U149.8 105.69,101.63 105.89,101.83 106.83,101.83 106.99,101.67 ; 106.99,101.67 107.18,101.85 108.08,101.85 108.29,101.64 U149.4 ; 106.99,101.67 U149.6
JTAG_CHAIN_TDI: length 21.1
  TOP w0.14: CN6.7 111.12,102.23 112.47,103.58 v1(112.47,107.19) 112.47,108.64 111.51,109.6 108.28,109.6 v1(106.62,107.94)
  BOTTOM w0.14: U149.15 106.99,107.26 106.62,107.63 v1(106.62,107.94) ; R1849.1 113.26,106.32 112.47,107.11 v1(112.47,107.19)
JTAG_CHAIN_TDO: length 6.5
  TOP w0.14: CN6.9 113.66,101.73 113.27,102.12 112.23,102.12 v1(112.05,101.94)
  BOTTOM w0.14: v1(112.05,101.94) 112.27,102.16 R1860.2 R1850.1
JTAG_CHAIN_TMS: length 16.2
  TOP w0.14: v1(105.16,102.93) 105.97,102.11 109.98,102.11 111.12,103.25 CN6.8 111.12,107.19 111.2,107.26 v1(111.2,107.31)
  BOTTOM w0.14: R1846.1 111.2,108.82 111.2,107.37 111.2,107.37 v1(111.2,107.31) ; v1(105.16,102.93) 105.69,103.46 U149.13
JTAG_CPLD_EN: length 29.6
  TOP w0.14: U70.E5 v4(113.2,129.65) ; CN1.7 125.44,142.11 v5(126.59,140.97)
  T18 w0.102: v4(113.2,129.65) 113.61,129.25 113.61,128.69 113.84,128.46 119.99,128.46 121.41,129.88 121.41,131.15
  T18 w0.117: v5(126.59,140.97) 126.59,136.33 121.41,131.15
  BOTTOM w0.14: v5(126.59,140.97) 127.17,141.56 R1007.2 127.67,143.01 127.67,143.01 127.96,143.01 127.96,143.01 R1003.1
JTAG_CPLD_TCK: length 22.6
  TOP w0.14: U70.G2 v4(110.8,128.05)
  T18 w0.117: v5(120.48,140.76) 119.8,140.76 117.35,138.3 115.31,138.3 111.42,134.41 111.42,133.42 110.4,132.4 110.4,128.45 v4(110.8,128.05)
  BOTTOM w0.14: R1006.2 R1004.2 120.36,140.87 v5(120.48,140.76)
JTAG_CPLD_TCK_SR: length 5.2
  TOP w0.14: v1(120.14,145.16) 119,145.16 117.82,143.99 CN1.1
  BOTTOM w0.14: v1(120.14,145.16) 120.36,144.94 R1004.1
JTAG_CPLD_TDI: length 32
  TOP w0.14: v5(130.68,141.03) 129.11,141.03 127.98,142.16 CN1.9 ; U70.F5 v4(113.2,128.85)
  T18 w0.102: v4(113.2,128.85) 113.2,128.61 113.6,128.22 113.6,127.91 113.84,127.66 119.78,127.66 121.82,129.7 121.82,130.96 127.12,136.26
  T18 w0.117: v5(130.68,141.03) 127.12,137.46 127.12,136.26
  BOTTOM w0.14: v5(130.68,141.03) 130.5,141.21 R1002.1
JTAG_CPLD_TDO: length 22.4
  TOP w0.14: CN1.3 120.36,142.06 121.53,140.9 v5(122.68,140.9) ; U70.F6 v4(114,128.85)
  T18 w0.117: v5(122.68,140.9) 119.96,138.18 119.96,137.3 116.2,133.53 115.71,133.53 114.94,132.75 114.94,129.78 v4(114,128.85)
  BOTTOM w0.14: v5(122.68,140.9) 122.63,140.96 R1000.1
JTAG_CPLD_TMS: length 29.8
  TOP w0.14: U70.G1 v4(110,128.05) ; CN1.5 122.9,142.06 123.93,141.03 v5(124.4,141.03)
  T18 w0.117: v5(124.4,141.03) 123.94,141.49 117.83,141.49 109.5,133.16 109.5,128.56 v4(110,128.05)
  BOTTOM w0.14: R1001.1 125.42,142.06 v5(124.4,141.03)
JTAG_MAC_TCE: length 17.5
  TOP w0.14: R49.1 v1(185.69,128.89) ; U1.AJ33 v4(199.86,130.5)
  T03 w0.117: v4(199.86,130.5) 199.46,130.9 198.69,130.9 198.36,130.57 198.36,130.43 197.83,129.9 197.69,129.9 197.46,129.66 197.46,129.53 197.03,129.09 195.45,129.09 194.95,129.59 192.87,129.59 192.2,128.92 190.51,128.92 190.35,128.75 188.63,128.75 188.18,129.2 186,129.2 v1(185.69,128.89)
JTAG_MAC_TCK: length 198.8
  TOP w0.14: U1.AH32 v4(200.86,129.5)
  T14 w0.117: v1(101.04,71.68) 102.82,69.9 134.35,69.9 137.55,73.1 137.55,76.81 139.56,78.82 152.09,78.82 153.03,79.76 157.98,79.76 159,80.77 164.31,80.77 166.47,82.94 174.63,82.94 184.53,92.84 186.82,92.84 189.14,95.16 189.14,100.84 195.02,106.71 195.02,107.53 195.48,108 206.23,108 206.35,108.12 206.35,120.12 206.07,120.4 205.18,120.4 204.34,121.23 204.34,126.7 204.04,127 203.58,127 203.38,127.2 203.38,127.76 203.15,127.99 202.68,127.99 202.4,128.27 202.4,128.75 202.2,128.94 201.63,128.94 201.08,129.5 v4(200.86,129.5)
  T16 w0.117: v1(101.04,71.68) 101.04,73.3 99.36,74.98 99.36,81.33 102.19,84.16 102.68,84.16 105.39,86.86 105.39,88.02 106.86,89.49 106.86,95.05 v1(106.02,95.89)
  T18 w0.117: v1(106.55,110.92) 106.02,110.39 v1(106.02,95.89)
  BOTTOM w0.14: R1854.1 v1(106.55,110.92)
JTAG_MAC_TDI: length 150
  TOP w0.14: U1.AH33 v4(199.86,129.5)
  T07 w0.117: v4(199.86,129.5) 199.36,129.99 199.36,131.56 198.83,132.09 198.69,132.09 198.33,132.46 198.33,133.59 197.83,134.09 197.69,134.09 197.43,134.35 197.43,150.27 188.84,158.87 182.82,158.87 182.35,158.39 171.1,158.39 166.74,154.03 v1(166.74,153.28)
  T16 w0.117: v1(166.74,153.28) 166.11,152.65 152.58,152.65 143.51,143.57 143.51,142.1 134.22,132.81 130.02,132.81 128.49,131.28 128.49,122.87 123.62,118 123.62,116.05 119.14,111.58 119.14,110.21 113.54,104.61 113.54,97.79 v1(113.79,97.54)
  BOTTOM w0.14: R1845.1 113.75,97.49 v1(113.79,97.54)
JTAG_MAC_TDO: length 292.8
  TOP w0.14: U1.AG33 v4(199.86,128.5) ; v1(298.21,88.67) R308.2 R307.2
  T03 w0.117: v1(298.21,88.67) 298.21,97.3 290.74,104.77 283.06,104.77 278.62,109.21 272.07,109.21 245.43,82.57 v1(241.93,82.57)
  T05 w0.117: v1(241.93,82.57) 239.91,84.59 187.69,84.59 182.45,89.82 v1(182.45,91.77)
  T07 w0.117: v1(182.45,91.77) 182.45,95.26 175.19,102.52 147.23,102.52 142.72,107.02 119.98,107.02 117.73,104.78 117.73,101.31 116.61,100.19 116.06,100.19 115.65,99.78 115.65,99.15 v1(114.91,98.41)
  T14 w0.117: v4(199.86,128.5) 200.31,128.94 201.09,128.94 201.4,128.63 201.4,128.3 201.6,128.09 202.12,128.09 202.4,127.82 202.4,127.27 202.63,127.04 203.01,127.04 203.38,126.67 203.38,121.42 203.46,121.34 203.46,121.33 203.69,121.09 203.7,121.09 204.66,120.14 204.98,120.14 205.36,119.76 205.36,111.44 205.26,111.34 205.26,111.33 205.03,111.09 205.02,111.09 204.92,111 194.92,111 194.44,110.52 194.44,106.74 188.72,101.03 188.72,95.47 186.73,93.47 184.16,93.47 v1(182.45,91.77)
  BOTTOM w0.14: R1844.1 111.42,98.42 114.9,98.42 v1(114.91,98.41)
JTAG_NIC1_TCK: length 8.2
  TOP w0.14: v1(99.27,93.87) U85.19 99.27,96.22 100.13,97.08 100.13,99.19 98.81,100.52 R1217.2
JTAG_NIC1_TDI: length 4.4
  TOP w0.14: U85.29 94.27,96.8 v6(92.71,98.36) R1216.2
JTAG_NIC1_TMS: length 6.8
  TOP w0.14: R1220.2 v1(100.95,100.19) 101.09,100.05 101.09,97.41 99.77,96.09 U85.18
JTAG_PHY1_TCK: length 34.4
  TOP w0.14: v4(134.21,100.36) U23.D6
  T18 w0.117: v4(134.21,100.36) 133.81,100.77 120.09,100.77 118.12,102.73 114.31,102.73 110.11,106.93 110.11,109.36 109.57,109.9 109.57,110.9 v1(108.58,111.89)
  BOTTOM w0.14: R1855.1 107.95,112.52 v1(108.58,111.89)
JTAG_PHY1_TDI: length 13.4
  TOP w0.14: v1(137.41,100.46) 137.79,100.08 140.22,100.08 R277.2 ; U23.H6 130.21,100.36 131.14,100.36 v4(131.24,100.26)
  T05 w0.117: v1(137.41,100.46) 137.02,100.85 131.82,100.85 v4(131.24,100.26)
  BOTTOM w0.14: v4(131.24,100.26) 132.02,99.47 v2(132.59,99.47)
JTAG_PHY1_TDO: length 39.5
  TOP w0.14: U23.F6 v4(132.21,100.36) ; R281.2 139.78,100.65 v1(139.11,100.65)
  T05 w0.117: v1(139.11,100.65) 138.33,99.87 132.7,99.87 v4(132.21,100.36)
  T18 w0.117: v1(108.94,102.93) 111.66,100.2 117.65,100.2 117.9,100.46 119.63,100.46 120.23,99.86 131.71,99.86 v4(132.21,100.36)
  BOTTOM w0.14: v1(108.94,102.93) U149.3 108.94,99.59 109.74,98.79 v2(109.99,98.79)
JTAG_PHY3_TCK: length 213.2
  TOP w0.14: v1(169.89,113.07) 169.17,112.35 169.17,109.08 184.67,93.58 237.54,93.58 242.22,88.9 252.86,88.9 271.55,107.59 276.62,107.59 277,107.97 v1(277.86,107.97) ; U25.G4 v4(287.1,98.39)
  T03 w0.117: v4(287.1,98.39) 286.64,98.85 286.64,102.99 285.32,104.3 282.93,104.3 279.26,107.97 v1(277.86,107.97)
  T07 w0.117: v1(169.89,113.07) 169.16,113.79 166.71,113.79 163.41,110.49 145.81,110.49 143.88,108.56 115.34,108.56 114.46,109.44 111.46,109.44 110.87,110.03 110.87,111.37 v1(110.26,111.98)
  BOTTOM w0.14: v1(110.26,111.98) 108.7,113.54 R1856.1
JTAG_PHY3_TDI: length 9.9
  TOP w0.14: v1(295.38,87.4) 295.48,87.5 R307.1 ; U25.F16 v4(288.1,85.39)
  T03 w0.117: v4(288.1,85.39) 288.52,85.81 290.35,85.81 291.41,86.87 294.85,86.87 v1(295.38,87.4)
JTAG_PHY3_TDO: length 188
  TOP w0.14: v1(141.99,101.29) 141.9,101.38 R281.1 141.32,100.41 R277.1 ; R308.1 v1(295.5,88.67)
  TOP w0.381: U25.G8 v4(287.1,94.39)
  T03 w0.117: v1(172.09,97.54) 173.23,97.54 173.86,98.17 178.53,98.17 181.09,95.62 181.09,89.38 186.25,84.22 229.26,84.22 231.94,81.53 247.9,81.53 261.08,94.71 270.86,94.71 273.07,96.92 277.34,96.92 277.55,97.13 277.55,97.7 277.77,97.92 281.35,97.92 281.64,97.63 281.64,96.1 281.82,95.91 283.52,95.91 284.56,94.88 286.31,94.88 286.8,94.39 v4(287.1,94.39) 287.7,94.98 287.7,95.64 287.94,95.88 290.32,95.88 290.64,96.2 290.64,96.53 290.96,96.85 293.78,96.85 295.5,95.12 v1(295.5,88.67)
  T07 w0.117: v1(141.99,101.29) 142.13,101.44 168.82,101.44 172.09,98.17 v1(172.09,97.54)
JTAG_SMU_RST_N: length 6.4
  TOP w0.14: U139.K3 v4(15.43,96.3)
  BOTTOM w0.14: v4(15.43,96.3) 14.9,96.83 14.1,96.83 13.01,97.92 v2(11.68,97.92) 11.56,97.92 11.24,98.23 R1868.2
KR_CPU_TO_MAC_DN0: length 142.6
  TOP w0.14: U1.P31 v4(201.86,114.5)
  T18 w0.102: v4(201.86,114.5) 201.56,114.5 201.46,114.39 201.46,114.17 201.19,113.89 199.42,113.89 198.46,112.93 198.46,112.24 198.11,111.89 195.54,111.89 195.5,111.85 195.48,111.85
  T18 w0.107: 195.48,111.85 192,111.85 191.32,111.17 185.36,111.17 182.74,113.79 178.3,113.79 173.58,118.5 173.58,125.23 170.05,128.76 170.05,140.34 157.54,152.85 94.74,152.85 93.98,153.61 93.98,154.81 93.4,155.39 92.73,155.39 92.7,155.37 92.65,155.23 J1.B28
KR_CPU_TO_MAC_DN1: length 147.1
  TOP w0.14: U1.M31 v4(201.86,112.5)
  T18 w0.102: v4(201.86,112.5) 201.56,112.5 201.46,112.39 201.46,112.17 201.19,111.89 198.99,111.89 198,110.9 195.41,110.9 195.38,110.86 195.35,110.86
  T18 w0.107: 195.35,110.86 193.17,110.86 191.83,109.52 184.88,109.52 181.9,112.5 176.42,112.5 169.77,119.15 169.77,124.73 167.87,126.63 167.87,139.47 155.52,151.82 91.36,151.82 89.89,153.3 89.89,155.01 89.41,155.49 88.91,155.49 88.88,155.46 88.74,155.39 88.7,155.37 88.65,155.23 J1.B24
KR_CPU_TO_MAC_DP0: length 142.6
  TOP w0.14: U1.P32 v4(200.86,114.5)
  T18 w0.102: 195.48,112.13 195.5,112.13 195.54,112.09 198.02,112.09 198.25,112.33 198.25,113.01 199.34,114.1 201.11,114.1 201.26,114.25 201.26,114.39 201.16,114.5 v4(200.86,114.5)
  T18 w0.107: 195.48,112.13 191.89,112.13 191.2,111.45 188.71,111.45 188.59,111.56 188.39,111.56 188.27,111.45 188.07,111.45 187.95,111.56 187.75,111.56 187.63,111.45 187.43,111.45 187.31,111.56 187.11,111.56 186.99,111.45 185.48,111.45 182.86,114.07 178.41,114.07 173.86,118.62 173.86,125.35 170.33,128.88 170.33,140.45 157.66,153.13 94.86,153.13 94.26,153.72 94.26,154.93 93.52,155.67 92.43,155.67 J1.B27
KR_CPU_TO_MAC_DP1: length 147.2
  TOP w0.14: U1.M32 v4(200.86,112.5)
  T18 w0.102: v4(200.86,112.5) 201.16,112.5 201.26,112.39 201.26,112.25 201.1,112.09 198.91,112.09 197.92,111.1 195.41,111.1 195.38,111.14 195.35,111.14
  T18 w0.107: J1.B23 88.43,155.67 88.67,155.67 88.71,155.69 88.79,155.77 89.52,155.77 90.17,155.13 90.17,153.41 91.48,152.1 155.63,152.1 168.15,139.59 168.15,126.75 170.05,124.84 170.05,119.27 176.54,112.78 182.02,112.78 183.41,111.39 183.58,111.39 183.72,111.24 183.72,111.08 183.87,110.93 184.03,110.93 184.17,110.79 184.17,110.63 184.32,110.48 184.48,110.48 184.63,110.34 184.63,110.17 185,109.8 191.71,109.8 193.05,111.14 195.35,111.14
KR_IIO_LAN_RX0_DN: length 8.3
  BOTTOM w0.104: J1.A30 95.07,160.86 94.74,160.19 94.51,160.12 94.42,160.16 94.12,160.46 94.12,162.86 93.86,163.12 93.86,166.47 C2066.1
KR_IIO_LAN_RX0_DP: length 8.5
  BOTTOM w0.104: J1.A29 94.44,159.74 94.39,159.88 94.26,159.94 94.23,159.97 93.85,160.35 93.85,162.75 93.59,163.01 93.59,166.47 C2065.1
KR_IIO_LAN_RX1_DN: length 8.3
  BOTTOM w0.104: C2064.1 90.69,166.47 90.69,162.89 90.18,162.38 90.18,160.4 90.42,160.16 90.51,160.12 90.65,160.16 J1.A26
KR_IIO_LAN_RX1_DP: length 8.6
  BOTTOM w0.104: C2063.1 90.42,166.46 90.42,163 89.92,162.49 89.92,160.29 90.26,159.94 90.39,159.88 90.44,159.74 J1.A25
KR_MAC_TO_CPU_DN0: length 139.7
  TOP w0.14: U1.P36 v4(196.86,114.5)
  T18 w0.102: 196.5,115.93 196.5,115.9 196.46,115.86 196.46,114.6 196.56,114.5 v4(196.86,114.5)
  T18 w0.107: 196.5,115.93 196.5,116.3 196.09,116.71 194.82,116.71 192.68,118.85 191.27,118.85 191.12,119 190.95,119 190.8,118.85 190.63,118.85 190.48,119 190.31,119 190.16,118.85 189.99,118.85 189.84,119 189.67,119 189.52,118.85 188.02,118.85 186.63,120.23 182.72,120.23 181.25,121.7 181.25,137.13 176.28,142.11 173.62,142.11 152.41,163.32 143.52,163.32 140.58,166.27 96.87,166.27 93.87,169.27 93.87,169.53 v4(94.08,169.75)
  BOTTOM w0.104: v4(94.08,169.75) 93.91,169.57 93.91,168 C2066.2
KR_MAC_TO_CPU_DN1: length 146.4
  TOP w0.14: U1.M36 v4(196.86,112.5)
  T18 w0.102: v4(196.86,112.5) 196.56,112.5 196.46,112.6 196.46,112.86 196.23,113.09 195.51,113.09 195.48,113.13 195.45,113.13
  T18 w0.107: v4(90.91,169.68) 90.69,169.47 90.69,169.19 92.24,167.64 92.24,166.85 93.97,165.13 139.43,165.13 142.48,162.08 151.67,162.08 172.75,141 175.62,141 177.16,139.45 177.16,119.89 179.14,117.92 179.39,117.92 179.49,117.82 179.49,117.56 179.68,117.37 181.71,117.37 185.74,113.34 188.15,113.34 189.03,114.22 191.36,114.22 191.51,114.38 191.68,114.38 191.83,114.22 192,114.22 192.16,114.38 192.31,114.38 192.47,114.22 193.34,114.22 194.43,113.13 195.45,113.13
  BOTTOM w0.104: v4(90.91,169.68) 90.68,169.46 90.68,168.05 C2064.2
KR_MAC_TO_CPU_DP0: length 139.4
  TOP w0.14: U1.P37 v4(195.86,114.5)
  T18 w0.102: v4(195.86,114.5) 196.16,114.5 196.26,114.6 196.26,115.86 196.22,115.9 196.22,115.93
  T18 w0.107: v4(93.37,169.75) 93.59,169.53 93.59,169.15 96.75,165.99 140.46,165.99 143.41,163.04 152.3,163.04 173.51,141.83 176.16,141.83 180.97,137.02 180.97,121.59 182.61,119.95 186.52,119.95 187.9,118.57 192.57,118.57 194.7,116.43 195.97,116.43 196.22,116.19 196.22,115.93
  BOTTOM w0.104: v4(93.37,169.75) 93.64,169.47 93.64,168.1 C2065.2
KR_MAC_TO_CPU_DP1: length 146.1
  TOP w0.14: U1.M37 v4(195.86,112.5)
  T18 w0.102: 195.45,112.85 195.48,112.85 195.51,112.89 196.14,112.89 196.26,112.77 196.26,112.6 196.16,112.5 v4(195.86,112.5)
  T18 w0.107: 195.45,112.85 194.31,112.85 193.22,113.94 189.14,113.94 188.26,113.07 185.62,113.07 181.6,117.09 179.56,117.09 176.89,119.77 176.89,139.33 175.5,140.72 172.64,140.72 151.56,161.8 142.37,161.8 139.32,164.85 93.85,164.85 91.96,166.74 91.96,167.53 90.41,169.07 90.41,169.47 v4(90.2,169.68)
  BOTTOM w0.104: C2063.2 90.42,168.05 90.42,169.46 v4(90.2,169.68)
LED0_NIC1_LINK_FE: length 82.5
  TOP w0.14: U85.31 93.27,96.15 91.19,98.23 v1(91.19,98.64)
  T03 w0.117: v1(91.19,98.64) 90.73,98.19 89.27,98.19 88.76,97.68 88.76,96.94 85.15,93.32 83.65,93.32 81.03,90.7 81.03,74.51 79.89,73.38 79.89,69.54 78.26,67.9 72.86,67.9 71.19,66.23 71.19,59.12 73.6,56.71 76.14,56.71 77.47,58.04 v1(78.36,58.04)
  BOTTOM w0.14: v1(78.36,58.04) 80.64,58.04 82.42,56.26 82.42,44.68 R1259.1
LED1_NIC1_ACT_N: length 96.2
  TOP w0.14: OJ1.L4 69.3,35.22 v1(66.42,38.1) C1672.1 ; v1(90.36,98.8) 90.78,99.22 91.43,99.22 91.92,98.73 91.92,98.33 93.77,96.48 U85.30
  T03 w0.117: v1(90.36,98.8) 89.29,98.8 88.34,97.86 88.34,97.11 84.98,93.75 83.47,93.75 80.6,90.88 80.6,74.69 79.47,73.55 79.47,72.69 78.39,71.61 73.01,71.61 70.77,69.37 70.77,57.78 68.26,55.27 68.26,39.93 v1(66.42,38.1)
  T14 w0.117: OJ1.L4 70.88,34.92 73.41,34.92 74.63,33.7 OJ1.L2
LED2_NIC1_LINK_GE: length 77.8
  TOP w0.14: U85.33 91.83,94.61 91.55,94.9 91.55,97.03 v1(91.01,97.57)
  T03 w0.117: v1(75.71,57.6) 75.64,57.53 73.38,57.53 71.61,59.3 71.61,66.06 73.03,67.48 78.43,67.48 80.31,69.36 80.31,73.2 81.45,74.34 81.45,90.53 83.82,92.9 85.33,92.9 89.03,96.6 90.05,96.6 v1(91.01,97.57)
  BOTTOM w0.14: v1(75.71,57.6) 76.13,57.18 80.75,57.18 81.81,56.12 R1257.1
LED_CPLD_STATUS1: length 17
  TOP w0.14: v1(107.82,135.58) 107.41,135.99 D25.3 ; U70.M2 v4(110.8,123.25)
  T05 w0.117: v4(110.8,123.25) 109.2,124.86 109.2,126.18 106.38,129 106.38,131.78 107.82,133.22 v1(107.82,135.58)
LED_CPLD_STATUS2: length 22.2
  TOP w0.14: U70.M4 v4(112.4,123.25) ; v1(106.81,136.4) 106.71,136.49 D25.4
  T05 w0.117: v1(106.81,136.4) 106.81,132.91 106.01,132.11 106.01,123.67 107.62,122.05 111.77,122.05 112,122.29 112,122.85 v4(112.4,123.25)
LED_ETH_STAT_CLR_N: length 198.1
  TOP w0.14: v5(105.28,125.48) 105.92,126.11 R12701.1
  T03 w0.102: 116.8,122.08 117.01,121.87 117.01,121.38 117.43,120.96
  T03 w0.117: 116.8,122.08 116.8,126.62 116.06,127.36 115.53,127.36 115.24,127.65 110.38,127.65 109.22,126.49 107.57,126.49 106.55,125.48 v5(105.28,125.48) ; 117.43,120.96 119.9,118.5 119.9,116.58 125.25,111.22 140.34,111.22 148.58,102.98 148.58,89.78 146.98,88.18 146.98,86.74 147.76,85.96 147.76,76.63 148.55,75.84 148.55,70.69 151.66,67.58 188.58,67.58 198.15,58.01 198.15,45.06 200.12,43.09 200.12,23.86 v1(206.96,17.02)
  BOTTOM w0.14: v1(206.96,17.02) 206.96,16.68 207.53,16.11 U20.2 207.53,14.14 207.75,13.92 208.64,13.92 208.83,14.12 U20.4
LED_FAN_CLR_N: length 213.2
  TOP w0.14: R12703.1 104.84,127.2 v1(104.73,127.31) ; v1(283.28,195.65) 283.39,195.65 284.32,194.73 J5.23
  T14 w0.117: v1(138.62,146.26) 139.66,147.29 147.55,147.29 157.2,156.94 175.57,156.94 177.37,158.73 199.06,180.43 243.45,180.43 250.14,187.11 262.23,187.11 263.57,188.45 278.49,188.45 283.28,193.24 v1(283.28,195.65)
  T18 w0.117: v1(138.62,146.26) 134.86,142.49 118.23,142.49 108.58,132.84 108.09,132.84 104.52,129.27 104.52,127.52 v1(104.73,127.31)
LED_FAN_SCL: length 183.2
  TOP w0.14: v5(122.05,139.02) 121.63,139.02 120.14,137.53 R1748.1 ; J5.16 v1(276.32,197.45)
  T14 w0.117: v5(122.05,139.02) 127.8,139.02 139.76,150.99 149.46,150.99 156.68,158.21 175.05,158.21 198.76,181.92 243.15,181.92 253.28,192.04 262.25,192.04 263.93,193.73 272.6,193.73 v1(276.32,197.45)
LED_FAN_SCLK: length 5.3
  TOP w0.14: U70.A12 119.22,132.47 119.22,134.16 v5(120.39,135.34) 120.39,135.79 R1748.2 R1700.2
LED_FAN_SDA: length 185.1
  TOP w0.14: R1749.1 121.28,137.4 121.53,137.64 v5(121.95,137.64) ; J5.18 v1(278.32,196.97)
  T14 w0.117: v5(121.95,137.64) 122.75,138.45 129.11,138.45 131.81,141.14 131.81,142.08 131.81,142.43 137.55,148.18 147.25,148.18 156.85,157.79 175.22,157.79 198.71,181.27 243.1,181.27 253.45,191.62 262.42,191.62 264.03,193.23 274.71,193.23 278.32,196.83 v1(278.32,196.97)
LED_FAN_SDAT: length 7.3
  TOP w0.14: U70.B12 119.59,132.04 119.59,133.37 120.67,134.46 121.37,134.46 v5(122.17,135.25) 122.17,135.25 122.43,135.51 R1694.2 R1749.2
LED_INIT_CLR_N: length 7.8
  TOP w0.14: R12703.2 R12701.2 R12702.2 107.3,125.04 v1(107.57,125.31) 107.96,125.31 108.14,125.13 108.78,125.13 109.71,126.05 U70.J1
  BOTTOM w0.14: v1(107.57,125.31) 106.74,126.14 R1735.2
LED_MAC_SCLK: length 146.6
  TOP w0.14: R53.2 174.87,121.33 174.88,121.32 v1(174.98,121.32)
  T14 w0.117: v1(174.98,121.32) 173.83,120.16 173.83,118.3 172.74,117.22 170.94,117.22 167.13,113.41 167.13,109.62 158.2,100.69 v1(158.2,99)
  T16 w0.117: v1(210.24,16.92) 209.09,18.06 202.07,18.06 199.83,20.3 199.83,57.2 187.75,69.29 187.75,78.95 177.16,89.53 173.86,89.53 165.48,97.92 159.29,97.92 v1(158.2,99)
  BOTTOM w0.14: v1(210.24,16.92) 210.13,16.81 U20.6
