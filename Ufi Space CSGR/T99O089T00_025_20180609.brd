# Allegro board T99O089T00_025_20180609.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
GMTH138R315A
  round 3.505 hole 3.505 unplated: (0,0)
  round 1.016 hole 0.711: 1(0,3) 2(2.121,2.121) 3(3,0) 4(2.121,-2.121) 5(0,-3) 6(-2.121,-2.121) 7(-3,0) 8(-2.121,2.121)
GMTH138R394KO472
  round 3.505 hole 3.505 unplated: (0,0)
  round 1.016 hole 0.711: 1(3.375,0) 2(2.387,2.387) 3(0,3.375) 4(-2.387,2.387) 5(-3.375,0) 6(-2.387,-2.387) 7(0,-3.375) 8(2.387,-2.387)
GMTH181R325S0
  round 4.597 hole 4.597 unplated: (0,0)
  round 0.813 hole 0.508: 1(0.102,3.516) 2(-2.415,2.558) 3(-3.516,0.102) 4(-2.558,-2.415) 5(-0.102,-3.516) 6(2.415,-2.558) 7(3.516,-0.102) 8(2.558,2.415)
ICT
  round 0.762 smd: 1(0,0)
L-2X1_2-4B
  rect 0.762x0.457 smd: 1(0.914,-0.4) 2(0.914,0.4) 3(-0.914,0.4) 4(-0.914,-0.4)
L-0603S0
  custom 0.191x0.191 smd: 1(0,-0.686) 2(0,0.686)
L-0805
  custom 0.254x0.254 smd: 1(0,-0.889) 2(0,0.889)
L-S3_08X2_9-2
  rect 1.041x1.194 smd: 1(0,1.248) 2(0,-1.248)
L-S3X3
  rect 2.997x1.397 smd: 1(0,1.106) 2(0,-1.106)
L-S4X4-2D-H1_8
  rect 4.191x1.727 smd: 1(0,1.644) 2(0,-1.644)
L-S4X4-2L
  rect 3.607x1.803 smd: 1(0,-1.6) 2(0,1.6)
L-S5_5X5-2
  rect 5.207x1.372 smd: 1(0,-2.572) 2(0,2.572)
L-S5_8X5_1-4
  rect 0.991x2.007 smd: 1(-2.1,-1.7) 2(2.1,-1.7) 3(2.1,1.7) 4(-2.1,1.7)
L-S5_49X5_18-2
  rect 2.819x1.905 smd: 1(0,2.296) 2(0,-2.296)
L-S6_86X6_47-2-H3
  rect 3.429x2.083 smd: 1(0,-2.894) 2(0,2.894)
L-S6_86X6_47-2A
  rect 3.429x2.083 smd: 1(0,-2.894) 2(0,2.894)
L-S10_2X7_8-2A
  rect 2.438x3.15 smd: 1(0,-4.033) 2(0,4.033)
L-S11_5X10-2
  rect 3.505x2.794 smd: 1(0,-4.876) 2(0,4.876)
LD-S1_6X0_8-4A
  rect 0.406x0.508 smd: 1(0.35,0.598) 2(-0.35,0.598) 3(0.35,-0.598) 4(-0.35,-0.598)
MPTH47X87R71X111
  oval 1.803x2.819 hole 1.194x2.21: 1(0,0)
MPTH122R177
  round 4.496 hole 3.099: 1(0,0)
MPTH138R197
  round 5.004 hole 3.505: 1(0,0)
MSOP-8
  rect 1.524x0.356 smd: 1(2.07,-0.975) 2(2.07,-0.325) 3(2.07,0.325) 4(2.07,0.975) 5(-2.07,0.975) 6(-2.07,0.325) 7(-2.07,-0.325) 8(-2.07,-0.975)
MSOP-8A
  rect 1.524x0.356 smd: 1(2.819,-0.975) 2(2.819,-0.325) 3(2.819,0.325) 4(2.819,0.975) 5(-2.819,0.975) 6(-2.819,0.325) 7(-2.819,-0.325) 8(-2.819,-0.975)
MSOP-14A
  rect 1.524x0.356 smd: 1(2.819,-1.95) 2(2.819,-1.3) 3(2.819,-0.65) 4(2.819,0) 5(2.819,0.65) 6(2.819,1.3) 7(2.819,1.95) 8(-2.819,1.95) 9(-2.819,1.3) 10(-2.819,0.65) 11(-2.819,0) 12(-2.819,-0.65) 13(-2.819,-1.3) 14(-2.819,-1.95)
MSOP-14S0
  rect 1.372x0.356 smd: 1(2.895,-1.95) 2(2.895,-1.3) 3(2.895,-0.65) 4(2.895,0) 5(2.895,0.65) 6(2.895,1.3) 7(2.895,1.95) 8(-2.895,1.95) 9(-2.895,1.3) 10(-2.895,0.65) 11(-2.895,0) 12(-2.895,-0.65) 13(-2.895,-1.3) 14(-2.895,-1.95)
O-2_5X2-4CS0
  rect 0.864x0.787 smd: 1(-0.92,-0.708) 2(0.92,-0.708) 3(0.92,0.708) 4(-0.92,0.708)
O-3_2X2_5-4JS0
  rect 1.6x1.372 smd: 1(-1.197,-0.978) 2(1.197,-0.978) 3(1.197,0.978) 4(-1.197,0.978)
O-5X3_2-4FS1
  rect 1.6x1.905 smd: 1(1.295,-2.045) 2(1.295,2.045) 3(-1.295,2.045) 4(-1.295,-2.045)
O-S2X1_6-4DS0
  rect 0.813x0.914 smd: 1(0.557,-0.707) 2(0.557,0.707) 3(-0.556,0.707) 4(-0.556,-0.707)
O-S3_2X2_5-4C
  rect 1.6x1.372 smd: 1(-1.197,-0.978) 2(1.197,-0.978) 3(1.197,0.978) 4(-1.197,0.978)
O-S3_2X2_5-4E
  rect 1.524x1.6 smd: 1(0.896,-1.208) 2(0.896,1.208) 3(-0.896,1.208) 4(-0.896,-1.208)
O-S3_2X2_5-6C
  rect 0.864x0.914 smd: 1(1.032,-1.401) 3(1.032,1.401) 4(-1.032,1.401) 6(-1.032,-1.401)
  rect 0.864x0.787 smd: 2(1.032,0) 5(-1.032,0)
O-S7X5-6
  rect 1.194x1.499 smd: 1(2.1,-2.55) 2(2.1,2.55) 4(-2.1,2.55) 5(-2.1,-2.55)
  rect 0.889x1.397 smd: 3(0,3.05) 6(0,-3.05)
O-S14_6X9_1-6
  rect 2.21x1.626 smd: 1(4.004,-2.54) 2(4.004,0) 3(4.004,2.54) 4(-4.004,2.54) 5(-4.004,0) 6(-4.004,-2.54)
O-S25_4X22-7
  rect 3.404x2.692 smd: 1(11.7,-8.9) 2(11.7,0) 3(11.7,8.9) 4(-11.7,8.9) 5(-11.7,3.81) 6(-11.7,-3.81) 7(-11.7,-8.9)
PBGA-12X12-144-H1_78
  round 0.508 smd: A1(-5.5,-5.5) A2(-5.5,-4.5) A3(-5.5,-3.5) A4(-5.5,-2.5) A5(-5.5,-1.5) A6(-5.5,-0.5) A7(-5.5,0.5) A8(-5.5,1.5) A9(-5.5,2.5) A10(-5.5,3.5) A11(-5.5,4.5) A12(-5.5,5.5) B1(-4.5,-5.5) B2(-4.5,-4.5) B3(-4.5,-3.5) B4(-4.5,-2.5) B5(-4.5,-1.5) B6(-4.5,-0.5) B7(-4.5,0.5) B8(-4.5,1.5) B9(-4.5,2.5) B10(-4.5,3.5) B11(-4.5,4.5) B12(-4.5,5.5) C1(-3.5,-5.5) C2(-3.5,-4.5) C3(-3.5,-3.5) C4(-3.5,-2.5) C5(-3.5,-1.5) C6(-3.5,-0.5) C7(-3.5,0.5) C8(-3.5,1.5) C9(-3.5,2.5) C10(-3.5,3.5) C11(-3.5,4.5) C12(-3.5,5.5) D1(-2.5,-5.5) D2(-2.5,-4.5) D3(-2.5,-3.5) D4(-2.5,-2.5) D5(-2.5,-1.5) D6(-2.5,-0.5) D7(-2.5,0.5) D8(-2.5,1.5) D9(-2.5,2.5) D10(-2.5,3.5) D11(-2.5,4.5) D12(-2.5,5.5) E1(-1.5,-5.5) E2(-1.5,-4.5) E3(-1.5,-3.5) E4(-1.5,-2.5) E5(-1.5,-1.5) E6(-1.5,-0.5) E7(-1.5,0.5) E8(-1.5,1.5) E9(-1.5,2.5) E10(-1.5,3.5) E11(-1.5,4.5) E12(-1.5,5.5) F1(-0.5,-5.5) F2(-0.5,-4.5) F3(-0.5,-3.5) F4(-0.5,-2.5) F5(-0.5,-1.5) F6(-0.5,-0.5) F7(-0.5,0.5) F8(-0.5,1.5) F9(-0.5,2.5) F10(-0.5,3.5) F11(-0.5,4.5) F12(-0.5,5.5) G1(0.5,-5.5) G2(0.5,-4.5) G3(0.5,-3.5) G4(0.5,-2.5) G5(0.5,-1.5) G6(0.5,-0.5) G7(0.5,0.5) G8(0.5,1.5) G9(0.5,2.5) G10(0.5,3.5) G11(0.5,4.5) G12(0.5,5.5) H1(1.5,-5.5) H2(1.5,-4.5) H3(1.5,-3.5) H4(1.5,-2.5) H5(1.5,-1.5) H6(1.5,-0.5) H7(1.5,0.5) H8(1.5,1.5) H9(1.5,2.5) H10(1.5,3.5) H11(1.5,4.5) H12(1.5,5.5) J1(2.5,-5.5) J2(2.5,-4.5) J3(2.5,-3.5) J4(2.5,-2.5) J5(2.5,-1.5) J6(2.5,-0.5) J7(2.5,0.5) J8(2.5,1.5) J9(2.5,2.5) J10(2.5,3.5) J11(2.5,4.5) J12(2.5,5.5) K1(3.5,-5.5) K2(3.5,-4.5) K3(3.5,-3.5) K4(3.5,-2.5) K5(3.5,-1.5) K6(3.5,-0.5) K7(3.5,0.5) K8(3.5,1.5) K9(3.5,2.5) K10(3.5,3.5) K11(3.5,4.5) K12(3.5,5.5) L1(4.5,-5.5) L2(4.5,-4.5) L3(4.5,-3.5) L4(4.5,-2.5) L5(4.5,-1.5) L6(4.5,-0.5) L7(4.5,0.5) L8(4.5,1.5) L9(4.5,2.5) L10(4.5,3.5) L11(4.5,4.5) L12(4.5,5.5) M1(5.5,-5.5) M2(5.5,-4.5) M3(5.5,-3.5) M4(5.5,-2.5) M5(5.5,-1.5) M6(5.5,-0.5) M7(5.5,0.5) M8(5.5,1.5) M9(5.5,2.5) M10(5.5,3.5) M11(5.5,4.5) M12(5.5,5.5)
PBGA-16X16-256B-H3_335
  round 0.508 smd: A1(-7.5,-7.5) A2(-7.5,-6.5) A3(-7.5,-5.5) A4(-7.5,-4.5) A5(-7.5,-3.5) A6(-7.5,-2.5) A7(-7.5,-1.5) A8(-7.5,-0.5) A9(-7.5,0.5) A10(-7.5,1.5) A11(-7.5,2.5) A12(-7.5,3.5) A13(-7.5,4.5) A14(-7.5,5.5) A15(-7.5,6.5) A16(-7.5,7.5) B1(-6.5,-7.5) B2(-6.5,-6.5) B3(-6.5,-5.5) B4(-6.5,-4.5) B5(-6.5,-3.5) B6(-6.5,-2.5) B7(-6.5,-1.5) B8(-6.5,-0.5) B9(-6.5,0.5) B10(-6.5,1.5) B11(-6.5,2.5) B12(-6.5,3.5) B13(-6.5,4.5) B14(-6.5,5.5) B15(-6.5,6.5) B16(-6.5,7.5) C1(-5.5,-7.5) C2(-5.5,-6.5) C3(-5.5,-5.5) C4(-5.5,-4.5) C5(-5.5,-3.5) C6(-5.5,-2.5) C7(-5.5,-1.5) C8(-5.5,-0.5) C9(-5.5,0.5) C10(-5.5,1.5) C11(-5.5,2.5) C12(-5.5,3.5) C13(-5.5,4.5) C14(-5.5,5.5) C15(-5.5,6.5) C16(-5.5,7.5) D1(-4.5,-7.5) D2(-4.5,-6.5) D3(-4.5,-5.5) D4(-4.5,-4.5) D5(-4.5,-3.5) D6(-4.5,-2.5) D7(-4.5,-1.5) D8(-4.5,-0.5) D9(-4.5,0.5) D10(-4.5,1.5) D11(-4.5,2.5) D12(-4.5,3.5) D13(-4.5,4.5) D14(-4.5,5.5) D15(-4.5,6.5) D16(-4.5,7.5) E1(-3.5,-7.5) E2(-3.5,-6.5) E3(-3.5,-5.5) E4(-3.5,-4.5) E5(-3.5,-3.5) E6(-3.5,-2.5) E7(-3.5,-1.5) E8(-3.5,-0.5) E9(-3.5,0.5) E10(-3.5,1.5) E11(-3.5,2.5) E12(-3.5,3.5) E13(-3.5,4.5) E14(-3.5,5.5) E15(-3.5,6.5) E16(-3.5,7.5) F1(-2.5,-7.5) F2(-2.5,-6.5) F3(-2.5,-5.5) F4(-2.5,-4.5) F5(-2.5,-3.5) F6(-2.5,-2.5) F7(-2.5,-1.5) F8(-2.5,-0.5) F9(-2.5,0.5) F10(-2.5,1.5) F11(-2.5,2.5) F12(-2.5,3.5) F13(-2.5,4.5) F14(-2.5,5.5) F15(-2.5,6.5) F16(-2.5,7.5) G1(-1.5,-7.5) G2(-1.5,-6.5) G3(-1.5,-5.5) G4(-1.5,-4.5) G5(-1.5,-3.5) G6(-1.5,-2.5) G7(-1.5,-1.5) G8(-1.5,-0.5) G9(-1.5,0.5) G10(-1.5,1.5) G11(-1.5,2.5) G12(-1.5,3.5) G13(-1.5,4.5) G14(-1.5,5.5) G15(-1.5,6.5) G16(-1.5,7.5) H1(-0.5,-7.5) H2(-0.5,-6.5) H3(-0.5,-5.5) H4(-0.5,-4.5) H5(-0.5,-3.5) H6(-0.5,-2.5) H7(-0.5,-1.5) H8(-0.5,-0.5) H9(-0.5,0.5) H10(-0.5,1.5) H11(-0.5,2.5) H12(-0.5,3.5) H13(-0.5,4.5) H14(-0.5,5.5) H15(-0.5,6.5) H16(-0.5,7.5) J1(0.5,-7.5) J2(0.5,-6.5) J3(0.5,-5.5) J4(0.5,-4.5) J5(0.5,-3.5) J6(0.5,-2.5) J7(0.5,-1.5) J8(0.5,-0.5) J9(0.5,0.5) J10(0.5,1.5) J11(0.5,2.5) J12(0.5,3.5) J13(0.5,4.5) J14(0.5,5.5) J15(0.5,6.5) J16(0.5,7.5) K1(1.5,-7.5) K2(1.5,-6.5) K3(1.5,-5.5) K4(1.5,-4.5) K5(1.5,-3.5) K6(1.5,-2.5) K7(1.5,-1.5) K8(1.5,-0.5) K9(1.5,0.5) K10(1.5,1.5) K11(1.5,2.5) K12(1.5,3.5) K13(1.5,4.5) K14(1.5,5.5) K15(1.5,6.5) K16(1.5,7.5) L1(2.5,-7.5) L2(2.5,-6.5) L3(2.5,-5.5) L4(2.5,-4.5) L5(2.5,-3.5) L6(2.5,-2.5) L7(2.5,-1.5) L8(2.5,-0.5) L9(2.5,0.5) L10(2.5,1.5) L11(2.5,2.5) L12(2.5,3.5) L13(2.5,4.5) L14(2.5,5.5) L15(2.5,6.5) L16(2.5,7.5) M1(3.5,-7.5) M2(3.5,-6.5) M3(3.5,-5.5) M4(3.5,-4.5) M5(3.5,-3.5) M6(3.5,-2.5) M7(3.5,-1.5) M8(3.5,-0.5) M9(3.5,0.5) M10(3.5,1.5) M11(3.5,2.5) M12(3.5,3.5) M13(3.5,4.5) M14(3.5,5.5) M15(3.5,6.5) M16(3.5,7.5) N1(4.5,-7.5) N2(4.5,-6.5) N3(4.5,-5.5) N4(4.5,-4.5) N5(4.5,-3.5) N6(4.5,-2.5) N7(4.5,-1.5) N8(4.5,-0.5) N9(4.5,0.5) N10(4.5,1.5) N11(4.5,2.5) N12(4.5,3.5) N13(4.5,4.5) N14(4.5,5.5) N15(4.5,6.5) N16(4.5,7.5) P1(5.5,-7.5) P2(5.5,-6.5) P3(5.5,-5.5) P4(5.5,-4.5) P5(5.5,-3.5) P6(5.5,-2.5) P7(5.5,-1.5) P8(5.5,-0.5) P9(5.5,0.5) P10(5.5,1.5) P11(5.5,2.5) P12(5.5,3.5) P13(5.5,4.5) P14(5.5,5.5) P15(5.5,6.5) P16(5.5,7.5) R1(6.5,-7.5) R2(6.5,-6.5) R3(6.5,-5.5) R4(6.5,-4.5) R5(6.5,-3.5) R6(6.5,-2.5) R7(6.5,-1.5) R8(6.5,-0.5) R9(6.5,0.5) R10(6.5,1.5) R11(6.5,2.5) R12(6.5,3.5) R13(6.5,4.5) R14(6.5,5.5) R15(6.5,6.5) R16(6.5,7.5) T1(7.5,-7.5) T2(7.5,-6.5) T3(7.5,-5.5) T4(7.5,-4.5) T5(7.5,-3.5) T6(7.5,-2.5) T7(7.5,-1.5) T8(7.5,-0.5) T9(7.5,0.5) T10(7.5,1.5) T11(7.5,2.5) T12(7.5,3.5) T13(7.5,4.5) T14(7.5,5.5) T15(7.5,6.5) T16(7.5,7.5)
PBGA-18X18-324-H3_08
  round 0.508 smd: A1(-8.5,-8.5) A2(-8.5,-7.5) A3(-8.5,-6.5) A4(-8.5,-5.5) A5(-8.5,-4.5) A6(-8.5,-3.5) A7(-8.5,-2.5) A8(-8.5,-1.5) A9(-8.5,-0.5) A10(-8.5,0.5) A11(-8.5,1.5) A12(-8.5,2.5) A13(-8.5,3.5) A14(-8.5,4.5) A15(-8.5,5.5) A16(-8.5,6.5) A17(-8.5,7.5) A18(-8.5,8.5) B1(-7.5,-8.5) B2(-7.5,-7.5) B3(-7.5,-6.5) B4(-7.5,-5.5) B5(-7.5,-4.5) B6(-7.5,-3.5) B7(-7.5,-2.5) B8(-7.5,-1.5) B9(-7.5,-0.5) B10(-7.5,0.5) B11(-7.5,1.5) B12(-7.5,2.5) B13(-7.5,3.5) B14(-7.5,4.5) B15(-7.5,5.5) B16(-7.5,6.5) B17(-7.5,7.5) B18(-7.5,8.5) C1(-6.5,-8.5) C2(-6.5,-7.5) C3(-6.5,-6.5) C4(-6.5,-5.5) C5(-6.5,-4.5) C6(-6.5,-3.5) C7(-6.5,-2.5) C8(-6.5,-1.5) C9(-6.5,-0.5) C10(-6.5,0.5) C11(-6.5,1.5) C12(-6.5,2.5) C13(-6.5,3.5) C14(-6.5,4.5) C15(-6.5,5.5) C16(-6.5,6.5) C17(-6.5,7.5) C18(-6.5,8.5) D1(-5.5,-8.5) D2(-5.5,-7.5) D3(-5.5,-6.5) D4(-5.5,-5.5) D5(-5.5,-4.5) D6(-5.5,-3.5) D7(-5.5,-2.5) D8(-5.5,-1.5) D9(-5.5,-0.5) D10(-5.5,0.5) D11(-5.5,1.5) D12(-5.5,2.5) D13(-5.5,3.5) D14(-5.5,4.5) D15(-5.5,5.5) D16(-5.5,6.5) D17(-5.5,7.5) D18(-5.5,8.5) E1(-4.5,-8.5) E2(-4.5,-7.5) E3(-4.5,-6.5) E4(-4.5,-5.5) E5(-4.5,-4.5) E6(-4.5,-3.5) E7(-4.5,-2.5) E8(-4.5,-1.5) E9(-4.5,-0.5) E10(-4.5,0.5) E11(-4.5,1.5) E12(-4.5,2.5) E13(-4.5,3.5) E14(-4.5,4.5) E15(-4.5,5.5) E16(-4.5,6.5) E17(-4.5,7.5) E18(-4.5,8.5) F1(-3.5,-8.5) F2(-3.5,-7.5) F3(-3.5,-6.5) F4(-3.5,-5.5) F5(-3.5,-4.5) F6(-3.5,-3.5) F7(-3.5,-2.5) F8(-3.5,-1.5) F9(-3.5,-0.5) F10(-3.5,0.5) F11(-3.5,1.5) F12(-3.5,2.5) F13(-3.5,3.5) F14(-3.5,4.5) F15(-3.5,5.5) F16(-3.5,6.5) F17(-3.5,7.5) F18(-3.5,8.5) G1(-2.5,-8.5) G2(-2.5,-7.5) G3(-2.5,-6.5) G4(-2.5,-5.5) G5(-2.5,-4.5) G6(-2.5,-3.5) G7(-2.5,-2.5) G8(-2.5,-1.5) G9(-2.5,-0.5) G10(-2.5,0.5) G11(-2.5,1.5) G12(-2.5,2.5) G13(-2.5,3.5) G14(-2.5,4.5) G15(-2.5,5.5) G16(-2.5,6.5) G17(-2.5,7.5) G18(-2.5,8.5) H1(-1.5,-8.5) H2(-1.5,-7.5) H3(-1.5,-6.5) H4(-1.5,-5.5) H5(-1.5,-4.5) H6(-1.5,-3.5) H7(-1.5,-2.5) H8(-1.5,-1.5) H9(-1.5,-0.5) H10(-1.5,0.5) H11(-1.5,1.5) H12(-1.5,2.5) H13(-1.5,3.5) H14(-1.5,4.5) H15(-1.5,5.5) H16(-1.5,6.5) H17(-1.5,7.5) H18(-1.5,8.5) J1(-0.5,-8.5) J2(-0.5,-7.5) J3(-0.5,-6.5) J4(-0.5,-5.5) J5(-0.5,-4.5) J6(-0.5,-3.5) J7(-0.5,-2.5) J8(-0.5,-1.5) J9(-0.5,-0.5) J10(-0.5,0.5) J11(-0.5,1.5) J12(-0.5,2.5) J13(-0.5,3.5) J14(-0.5,4.5) J15(-0.5,5.5) J16(-0.5,6.5) J17(-0.5,7.5) J18(-0.5,8.5) K1(0.5,-8.5) K2(0.5,-7.5) K3(0.5,-6.5) K4(0.5,-5.5) K5(0.5,-4.5) K6(0.5,-3.5) K7(0.5,-2.5) K8(0.5,-1.5) K9(0.5,-0.5) K10(0.5,0.5) K11(0.5,1.5) K12(0.5,2.5) K13(0.5,3.5) K14(0.5,4.5) K15(0.5,5.5) K16(0.5,6.5) K17(0.5,7.5) K18(0.5,8.5) L1(1.5,-8.5) L2(1.5,-7.5) L3(1.5,-6.5) L4(1.5,-5.5) L5(1.5,-4.5) L6(1.5,-3.5) L7(1.5,-2.5) L8(1.5,-1.5) L9(1.5,-0.5) L10(1.5,0.5) L11(1.5,1.5) L12(1.5,2.5) L13(1.5,3.5) L14(1.5,4.5) L15(1.5,5.5) L16(1.5,6.5) L17(1.5,7.5) L18(1.5,8.5) M1(2.5,-8.5) M2(2.5,-7.5) M3(2.5,-6.5) M4(2.5,-5.5) M5(2.5,-4.5) M6(2.5,-3.5) M7(2.5,-2.5) M8(2.5,-1.5) M9(2.5,-0.5) M10(2.5,0.5) M11(2.5,1.5) M12(2.5,2.5) M13(2.5,3.5) M14(2.5,4.5) M15(2.5,5.5) M16(2.5,6.5) M17(2.5,7.5) M18(2.5,8.5) N1(3.5,-8.5) N2(3.5,-7.5) N3(3.5,-6.5) N4(3.5,-5.5) N5(3.5,-4.5) N6(3.5,-3.5) N7(3.5,-2.5) N8(3.5,-1.5) N9(3.5,-0.5) N10(3.5,0.5) N11(3.5,1.5) N12(3.5,2.5) N13(3.5,3.5) N14(3.5,4.5) N15(3.5,5.5) N16(3.5,6.5) N17(3.5,7.5) N18(3.5,8.5) P1(4.5,-8.5) P2(4.5,-7.5) P3(4.5,-6.5) P4(4.5,-5.5) P5(4.5,-4.5) P6(4.5,-3.5) P7(4.5,-2.5) P8(4.5,-1.5) P9(4.5,-0.5) P10(4.5,0.5) P11(4.5,1.5) P12(4.5,2.5) P13(4.5,3.5) P14(4.5,4.5) P15(4.5,5.5) P16(4.5,6.5) P17(4.5,7.5) P18(4.5,8.5) R1(5.5,-8.5) R2(5.5,-7.5) R3(5.5,-6.5) R4(5.5,-5.5) R5(5.5,-4.5) R6(5.5,-3.5) R7(5.5,-2.5) R8(5.5,-1.5) R9(5.5,-0.5) R10(5.5,0.5) R11(5.5,1.5) R12(5.5,2.5) R13(5.5,3.5) R14(5.5,4.5) R15(5.5,5.5) R16(5.5,6.5) R17(5.5,7.5) R18(5.5,8.5) T1(6.5,-8.5) T2(6.5,-7.5) T3(6.5,-6.5) T4(6.5,-5.5) T5(6.5,-4.5) T6(6.5,-3.5) T7(6.5,-2.5) T8(6.5,-1.5) T9(6.5,-0.5) T10(6.5,0.5) T11(6.5,1.5) T12(6.5,2.5) T13(6.5,3.5) T14(6.5,4.5) T15(6.5,5.5) T16(6.5,6.5) T17(6.5,7.5) T18(6.5,8.5) U1(7.5,-8.5) U2(7.5,-7.5) U3(7.5,-6.5) U4(7.5,-5.5) U5(7.5,-4.5) U6(7.5,-3.5) U7(7.5,-2.5) U8(7.5,-1.5) U9(7.5,-0.5) U10(7.5,0.5) U11(7.5,1.5) U12(7.5,2.5) U13(7.5,3.5) U14(7.5,4.5) U15(7.5,5.5) U16(7.5,6.5) U17(7.5,7.5) U18(7.5,8.5) V1(8.5,-8.5) V2(8.5,-7.5) V3(8.5,-6.5) V4(8.5,-5.5) V5(8.5,-4.5) V6(8.5,-3.5) V7(8.5,-2.5) V8(8.5,-1.5) V9(8.5,-0.5) V10(8.5,0.5) V11(8.5,1.5) V12(8.5,2.5) V13(8.5,3.5) V14(8.5,4.5) V15(8.5,5.5) V16(8.5,6.5) V17(8.5,7.5) V18(8.5,8.5)
PBGA-37X37-1365
  round 0.508 smd: A2(-18,-17) A3(-18,-16) A4(-18,-15) A5(-18,-14) A6(-18,-13) A7(-18,-12) A8(-18,-11) A9(-18,-10) A10(-18,-9) A11(-18,-8) A12(-18,-7) A13(-18,-6) A14(-18,-5) A15(-18,-4) A16(-18,-3) A17(-18,-2) A18(-18,-1) A19(-18,0) A20(-18,1) A21(-18,2) A22(-18,3) A23(-18,4) A24(-18,5) A25(-18,6) A26(-18,7) A27(-18,8) A28(-18,9) A29(-18,10) A30(-18,11) A31(-18,12) A32(-18,13) A33(-18,14) A34(-18,15) A35(-18,16) A36(-18,17) AA1(2,-18) AA2(2,-17) AA3(2,-16) AA4(2,-15) AA5(2,-14) AA6(2,-13) AA7(2,-12) AA8(2,-11) AA9(2,-10) AA10(2,-9) AA11(2,-8) AA12(2,-7) AA13(2,-6) AA14(2,-5) AA15(2,-4) AA16(2,-3) AA17(2,-2) AA18(2,-1) AA19(2,0) AA20(2,1) AA21(2,2) AA22(2,3) AA23(2,4) AA24(2,5) AA25(2,6) AA26(2,7) AA27(2,8) AA28(2,9) AA29(2,10) AA30(2,11) AA31(2,12) AA32(2,13) AA33(2,14) AA34(2,15) AA35(2,16) AA36(2,17) AA37(2,18) AB1(3,-18) AB2(3,-17) AB3(3,-16) AB4(3,-15) AB5(3,-14) AB6(3,-13) AB7(3,-12) AB8(3,-11) AB9(3,-10) AB10(3,-9) AB11(3,-8) AB12(3,-7) AB13(3,-6) AB14(3,-5) AB15(3,-4) AB16(3,-3) AB17(3,-2) AB18(3,-1) AB19(3,0) AB20(3,1) AB21(3,2) AB22(3,3) AB23(3,4) AB24(3,5) AB25(3,6) AB26(3,7) AB27(3,8) AB28(3,9) AB29(3,10) AB30(3,11) AB31(3,12) AB32(3,13) AB33(3,14) AB34(3,15) AB35(3,16) AB36(3,17) AB37(3,18) AC1(4,-18) AC2(4,-17) AC3(4,-16) AC4(4,-15) AC5(4,-14) AC6(4,-13) AC7(4,-12) AC8(4,-11) AC9(4,-10) AC10(4,-9) AC11(4,-8) AC12(4,-7) AC13(4,-6) AC14(4,-5) AC15(4,-4) AC16(4,-3) AC17(4,-2) AC18(4,-1) AC19(4,0) AC20(4,1) AC21(4,2) AC22(4,3) AC23(4,4) AC24(4,5) AC25(4,6) AC26(4,7) AC27(4,8) AC28(4,9) AC29(4,10) AC30(4,11) AC31(4,12) AC32(4,13) AC33(4,14) AC34(4,15) AC35(4,16) AC36(4,17) AC37(4,18) AD1(5,-18) AD2(5,-17) AD3(5,-16) AD4(5,-15) AD5(5,-14) AD6(5,-13) AD7(5,-12) AD8(5,-11) AD9(5,-10) AD10(5,-9) AD11(5,-8) AD12(5,-7) AD13(5,-6) AD14(5,-5) AD15(5,-4) AD16(5,-3) AD17(5,-2) AD18(5,-1) AD19(5,0) AD20(5,1) AD21(5,2) AD22(5,3) AD23(5,4) AD24(5,5) AD25(5,6) AD26(5,7) AD27(5,8) AD28(5,9) AD29(5,10) AD30(5,11) AD31(5,12) AD32(5,13) AD33(5,14) AD34(5,15) AD35(5,16) AD36(5,17) AD37(5,18) AE1(6,-18) AE2(6,-17) AE3(6,-16) AE4(6,-15) AE5(6,-14) AE6(6,-13) AE7(6,-12) AE8(6,-11) AE9(6,-10) AE10(6,-9) AE11(6,-8) AE12(6,-7) AE13(6,-6) AE14(6,-5) AE15(6,-4) AE16(6,-3) AE17(6,-2) AE18(6,-1) AE19(6,0) AE20(6,1) AE21(6,2) AE22(6,3) AE23(6,4) AE24(6,5) AE25(6,6) AE26(6,7) AE27(6,8) AE28(6,9) AE29(6,10) AE30(6,11) AE31(6,12) AE32(6,13) AE33(6,14) AE34(6,15) AE35(6,16) AE36(6,17) AE37(6,18) AF1(7,-18) AF2(7,-17) AF3(7,-16) AF4(7,-15) AF5(7,-14) AF6(7,-13) AF7(7,-12) AF8(7,-11) AF9(7,-10) AF10(7,-9) AF11(7,-8) AF12(7,-7) AF13(7,-6) AF14(7,-5) AF15(7,-4) AF16(7,-3) AF17(7,-2) AF18(7,-1) AF19(7,0) AF20(7,1) AF21(7,2) AF22(7,3) AF23(7,4) AF24(7,5) AF25(7,6) AF26(7,7) AF27(7,8) AF28(7,9) AF29(7,10) AF30(7,11) AF31(7,12) AF32(7,13) AF33(7,14) AF34(7,15) AF35(7,16) AF36(7,17) AF37(7,18) AG1(8,-18) AG2(8,-17) AG3(8,-16) AG4(8,-15) AG5(8,-14) AG6(8,-13) AG7(8,-12) AG8(8,-11) AG9(8,-10) AG10(8,-9) AG11(8,-8) AG12(8,-7) AG13(8,-6) AG14(8,-5) AG15(8,-4) AG16(8,-3) AG17(8,-2) AG18(8,-1) AG19(8,0) AG20(8,1) AG21(8,2) AG22(8,3) AG23(8,4) AG24(8,5) AG25(8,6) AG26(8,7) AG27(8,8) AG28(8,9) AG29(8,10) AG30(8,11) AG31(8,12) AG32(8,13) AG33(8,14) AG34(8,15) AG35(8,16) AG36(8,17) AG37(8,18) AH1(9,-18) AH2(9,-17) AH3(9,-16) AH4(9,-15) AH5(9,-14) AH6(9,-13) AH7(9,-12) AH8(9,-11) AH9(9,-10) AH10(9,-9) AH11(9,-8) AH12(9,-7) AH13(9,-6) AH14(9,-5) AH15(9,-4) AH16(9,-3) AH17(9,-2) AH18(9,-1) AH19(9,0) AH20(9,1) AH21(9,2) AH22(9,3) AH23(9,4) AH24(9,5) AH25(9,6) AH26(9,7) AH27(9,8) AH28(9,9) AH29(9,10) AH30(9,11) AH31(9,12) AH32(9,13) AH33(9,14) AH34(9,15) AH35(9,16) AH36(9,17) AH37(9,18) AJ1(10,-18) AJ2(10,-17) AJ3(10,-16) AJ4(10,-15) AJ5(10,-14) AJ6(10,-13) AJ7(10,-12) AJ8(10,-11) AJ9(10,-10) AJ10(10,-9) AJ11(10,-8) AJ12(10,-7) AJ13(10,-6) AJ14(10,-5) AJ15(10,-4) AJ16(10,-3) AJ17(10,-2) AJ18(10,-1) AJ19(10,0) AJ20(10,1) AJ21(10,2) AJ22(10,3) AJ23(10,4) AJ24(10,5) AJ25(10,6) AJ26(10,7) AJ27(10,8) AJ28(10,9) AJ29(10,10) AJ30(10,11) AJ31(10,12) AJ32(10,13) AJ33(10,14) AJ34(10,15) AJ35(10,16) AJ36(10,17) AJ37(10,18) AK1(11,-18) AK2(11,-17) AK3(11,-16) AK4(11,-15) AK5(11,-14) AK6(11,-13) AK7(11,-12) AK8(11,-11) AK9(11,-10) AK10(11,-9) AK11(11,-8) AK12(11,-7) AK13(11,-6) AK14(11,-5) AK15(11,-4) AK16(11,-3) AK17(11,-2) AK18(11,-1) AK19(11,0) AK20(11,1) AK21(11,2) AK22(11,3) AK23(11,4) AK24(11,5) AK25(11,6) AK26(11,7) AK27(11,8) AK28(11,9) AK29(11,10) AK30(11,11) AK31(11,12) AK32(11,13) AK33(11,14) AK34(11,15) AK35(11,16) AK36(11,17) AK37(11,18) AL1(12,-18) AL2(12,-17) AL3(12,-16) AL4(12,-15) AL5(12,-14) AL6(12,-13) AL7(12,-12) AL8(12,-11) AL9(12,-10) AL10(12,-9) AL11(12,-8) AL12(12,-7) AL13(12,-6) AL14(12,-5) AL15(12,-4) AL16(12,-3) AL17(12,-2) AL18(12,-1) AL19(12,0) AL20(12,1) AL21(12,2) AL22(12,3) AL23(12,4) AL24(12,5) AL25(12,6) AL26(12,7) AL27(12,8) AL28(12,9) AL29(12,10) AL30(12,11) AL31(12,12) AL32(12,13) AL33(12,14) AL34(12,15) AL35(12,16) AL36(12,17) AL37(12,18) AM1(13,-18) AM2(13,-17) AM3(13,-16) AM4(13,-15) AM5(13,-14) AM6(13,-13) AM7(13,-12) AM8(13,-11) AM9(13,-10) AM10(13,-9) AM11(13,-8) AM12(13,-7) AM13(13,-6) AM14(13,-5) AM15(13,-4) AM16(13,-3) AM17(13,-2) AM18(13,-1) AM19(13,0) AM20(13,1) AM21(13,2) AM22(13,3) AM23(13,4) AM24(13,5) AM25(13,6) AM26(13,7) AM27(13,8) AM28(13,9) AM29(13,10) AM30(13,11) AM31(13,12) AM32(13,13) AM33(13,14) AM34(13,15) AM35(13,16) AM36(13,17) AM37(13,18) AN1(14,-18) AN2(14,-17) AN3(14,-16) AN4(14,-15) AN5(14,-14) AN6(14,-13) AN7(14,-12) AN8(14,-11) AN9(14,-10) AN10(14,-9) AN11(14,-8) AN12(14,-7) AN13(14,-6) AN14(14,-5) AN15(14,-4) AN16(14,-3) AN17(14,-2) AN18(14,-1) AN19(14,0) AN20(14,1) AN21(14,2) AN22(14,3) AN23(14,4) AN24(14,5) AN25(14,6) AN26(14,7) AN27(14,8) AN28(14,9) AN29(14,10) AN30(14,11) AN31(14,12) AN32(14,13) AN33(14,14) AN34(14,15) AN35(14,16) AN36(14,17) AN37(14,18) AP1(15,-18) AP2(15,-17) AP3(15,-16) AP4(15,-15) AP5(15,-14) AP6(15,-13) AP7(15,-12) AP8(15,-11) AP9(15,-10) AP10(15,-9) AP11(15,-8) AP12(15,-7) AP13(15,-6) AP14(15,-5) AP15(15,-4) AP16(15,-3) AP17(15,-2) AP18(15,-1) AP19(15,0) AP20(15,1) AP21(15,2) AP22(15,3) AP23(15,4) AP24(15,5) AP25(15,6) AP26(15,7) AP27(15,8) AP28(15,9) AP29(15,10) AP30(15,11) AP31(15,12) AP32(15,13) AP33(15,14) AP34(15,15) AP35(15,16) AP36(15,17) AP37(15,18) AR1(16,-18) AR2(16,-17) AR3(16,-16) AR4(16,-15) AR5(16,-14) AR6(16,-13) AR7(16,-12) AR8(16,-11) AR9(16,-10) AR10(16,-9) AR11(16,-8) AR12(16,-7) AR13(16,-6) AR14(16,-5) AR15(16,-4) AR16(16,-3) AR17(16,-2) AR18(16,-1) AR19(16,0) AR20(16,1) AR21(16,2) AR22(16,3) AR23(16,4) AR24(16,5) AR25(16,6) AR26(16,7) AR27(16,8) AR28(16,9) AR29(16,10) AR30(16,11) AR31(16,12) AR32(16,13) AR33(16,14) AR34(16,15) AR35(16,16) AR36(16,17) AR37(16,18) AT1(17,-18) AT2(17,-17) AT3(17,-16) AT4(17,-15) AT5(17,-14) AT6(17,-13) AT7(17,-12) AT8(17,-11) AT9(17,-10) AT10(17,-9) AT11(17,-8) AT12(17,-7) AT13(17,-6) AT14(17,-5) AT15(17,-4) AT16(17,-3) AT17(17,-2) AT18(17,-1) AT19(17,0) AT20(17,1) AT21(17,2) AT22(17,3) AT23(17,4) AT24(17,5) AT25(17,6) AT26(17,7) AT27(17,8) AT28(17,9) AT29(17,10) AT30(17,11) AT31(17,12) AT32(17,13) AT33(17,14) AT34(17,15) AT35(17,16) AT36(17,17) AT37(17,18) AU2(18,-17) AU3(18,-16) AU4(18,-15) AU5(18,-14) AU6(18,-13) AU7(18,-12) AU8(18,-11) AU9(18,-10) AU10(18,-9) AU11(18,-8) AU12(18,-7) AU13(18,-6) AU14(18,-5) AU15(18,-4) AU16(18,-3) AU17(18,-2) AU18(18,-1) AU19(18,0) AU20(18,1) AU21(18,2) AU22(18,3) AU23(18,4) AU24(18,5) AU25(18,6) AU26(18,7) AU27(18,8) AU28(18,9) AU29(18,10) AU30(18,11) AU31(18,12) AU32(18,13) AU33(18,14) AU34(18,15) AU35(18,16) AU36(18,17) B1(-17,-18) B2(-17,-17) B3(-17,-16) B4(-17,-15) B5(-17,-14) B6(-17,-13) B7(-17,-12) B8(-17,-11) B9(-17,-10) B10(-17,-9) B11(-17,-8) B12(-17,-7) B13(-17,-6) B14(-17,-5) B15(-17,-4) B16(-17,-3) B17(-17,-2) B18(-17,-1) B19(-17,0) B20(-17,1) B21(-17,2) B22(-17,3) B23(-17,4) B24(-17,5) B25(-17,6) B26(-17,7) B27(-17,8) B28(-17,9) B29(-17,10) B30(-17,11) B31(-17,12) B32(-17,13) B33(-17,14) B34(-17,15) B35(-17,16) B36(-17,17) B37(-17,18) C1(-16,-18) C2(-16,-17) C3(-16,-16) C4(-16,-15) C5(-16,-14) C6(-16,-13) C7(-16,-12) C8(-16,-11) C9(-16,-10) C10(-16,-9) C11(-16,-8) C12(-16,-7) C13(-16,-6) C14(-16,-5) C15(-16,-4) C16(-16,-3) C17(-16,-2) C18(-16,-1) C19(-16,0) C20(-16,1) C21(-16,2) C22(-16,3) C23(-16,4) C24(-16,5) C25(-16,6) C26(-16,7) C27(-16,8) C28(-16,9) C29(-16,10) C30(-16,11) C31(-16,12) C32(-16,13) C33(-16,14) C34(-16,15) C35(-16,16) C36(-16,17) C37(-16,18) D1(-15,-18) D2(-15,-17) D3(-15,-16) D4(-15,-15) D5(-15,-14) D6(-15,-13) D7(-15,-12) D8(-15,-11) D9(-15,-10) D10(-15,-9) D11(-15,-8) D12(-15,-7) D13(-15,-6) D14(-15,-5) D15(-15,-4) D16(-15,-3) D17(-15,-2) D18(-15,-1) D19(-15,0) D20(-15,1) D21(-15,2) D22(-15,3) D23(-15,4) D24(-15,5) D25(-15,6) D26(-15,7) D27(-15,8) D28(-15,9) D29(-15,10) D30(-15,11) D31(-15,12) D32(-15,13) D33(-15,14) D34(-15,15) D35(-15,16) D36(-15,17) D37(-15,18) E1(-14,-18) E2(-14,-17) E3(-14,-16) E4(-14,-15) E5(-14,-14) E6(-14,-13) E7(-14,-12) E8(-14,-11) E9(-14,-10) E10(-14,-9) E11(-14,-8) E12(-14,-7) E13(-14,-6) E14(-14,-5) E15(-14,-4) E16(-14,-3) E17(-14,-2) E18(-14,-1) E19(-14,0) E20(-14,1) E21(-14,2) E22(-14,3) E23(-14,4) E24(-14,5) E25(-14,6) E26(-14,7) E27(-14,8) E28(-14,9) E29(-14,10) E30(-14,11) E31(-14,12) E32(-14,13) E33(-14,14) E34(-14,15) E35(-14,16) E36(-14,17) E37(-14,18) F1(-13,-18) F2(-13,-17) F3(-13,-16) F4(-13,-15) F5(-13,-14) F6(-13,-13) F7(-13,-12) F8(-13,-11) F9(-13,-10) F10(-13,-9) F11(-13,-8) F12(-13,-7) F13(-13,-6) F14(-13,-5) F15(-13,-4) F16(-13,-3) F17(-13,-2) F18(-13,-1) F19(-13,0) F20(-13,1) F21(-13,2) F22(-13,3) F23(-13,4) F24(-13,5) F25(-13,6) F26(-13,7) F27(-13,8) F28(-13,9) F29(-13,10) F30(-13,11) F31(-13,12) F32(-13,13) F33(-13,14) F34(-13,15) F35(-13,16) F36(-13,17) F37(-13,18) G1(-12,-18) G2(-12,-17) G3(-12,-16) G4(-12,-15) G5(-12,-14) G6(-12,-13) G7(-12,-12) G8(-12,-11) G9(-12,-10) G10(-12,-9) G11(-12,-8) G12(-12,-7) G13(-12,-6) G14(-12,-5) G15(-12,-4) G16(-12,-3) G17(-12,-2) G18(-12,-1) G19(-12,0) G20(-12,1) G21(-12,2) G22(-12,3) G23(-12,4) G24(-12,5) G25(-12,6) G26(-12,7) G27(-12,8) G28(-12,9) G29(-12,10) G30(-12,11) G31(-12,12) G32(-12,13) G33(-12,14) G34(-12,15) G35(-12,16) G36(-12,17) G37(-12,18) H1(-11,-18) H2(-11,-17) H3(-11,-16) H4(-11,-15) H5(-11,-14) H6(-11,-13) H7(-11,-12) H8(-11,-11) H9(-11,-10) H10(-11,-9) H11(-11,-8) H12(-11,-7) H13(-11,-6) H14(-11,-5) H15(-11,-4) H16(-11,-3) H17(-11,-2) H18(-11,-1) H19(-11,0) H20(-11,1) H21(-11,2) H22(-11,3) H23(-11,4) H24(-11,5) H25(-11,6) H26(-11,7) H27(-11,8) H28(-11,9) H29(-11,10) H30(-11,11) H31(-11,12) H32(-11,13) H33(-11,14) H34(-11,15) H35(-11,16) H36(-11,17) H37(-11,18) J1(-10,-18) J2(-10,-17) J3(-10,-16) J4(-10,-15) J5(-10,-14) J6(-10,-13) J7(-10,-12) J8(-10,-11) J9(-10,-10) J10(-10,-9) J11(-10,-8) J12(-10,-7) J13(-10,-6) J14(-10,-5) J15(-10,-4) J16(-10,-3) J17(-10,-2) J18(-10,-1) J19(-10,0) J20(-10,1) J21(-10,2) J22(-10,3) J23(-10,4) J24(-10,5) J25(-10,6) J26(-10,7) J27(-10,8) J28(-10,9) J29(-10,10) J30(-10,11) J31(-10,12) J32(-10,13) J33(-10,14) J34(-10,15) J35(-10,16) J36(-10,17) J37(-10,18) K1(-9,-18) K2(-9,-17) K3(-9,-16) K4(-9,-15) K5(-9,-14) K6(-9,-13) K7(-9,-12) K8(-9,-11) K9(-9,-10) K10(-9,-9) K11(-9,-8) K12(-9,-7) K13(-9,-6) K14(-9,-5) K15(-9,-4) K16(-9,-3) K17(-9,-2) K18(-9,-1) K19(-9,0) K20(-9,1) K21(-9,2) K22(-9,3) K23(-9,4) K24(-9,5) K25(-9,6) K26(-9,7) K27(-9,8) K28(-9,9) K29(-9,10) K30(-9,11) K31(-9,12) K32(-9,13) K33(-9,14) K34(-9,15) K35(-9,16) K36(-9,17) K37(-9,18) L1(-8,-18) L2(-8,-17) L3(-8,-16) L4(-8,-15) L5(-8,-14) L6(-8,-13) L7(-8,-12) L8(-8,-11) L9(-8,-10) L10(-8,-9) L11(-8,-8) L12(-8,-7) L13(-8,-6) L14(-8,-5) L15(-8,-4) L16(-8,-3) L17(-8,-2) L18(-8,-1) L19(-8,0) L20(-8,1) L21(-8,2) L22(-8,3) L23(-8,4) L24(-8,5) L25(-8,6) L26(-8,7) L27(-8,8) L28(-8,9) L29(-8,10) L30(-8,11) L31(-8,12) L32(-8,13) L33(-8,14) L34(-8,15) L35(-8,16) L36(-8,17) L37(-8,18) M1(-7,-18) M2(-7,-17) M3(-7,-16) M4(-7,-15) M5(-7,-14) M6(-7,-13) M7(-7,-12) M8(-7,-11) M9(-7,-10) M10(-7,-9) M11(-7,-8) M12(-7,-7) M13(-7,-6) M14(-7,-5) M15(-7,-4) M16(-7,-3) M17(-7,-2) M18(-7,-1) M19(-7,0) M20(-7,1) M21(-7,2) M22(-7,3) M23(-7,4) M24(-7,5) M25(-7,6) M26(-7,7) M27(-7,8) M28(-7,9) M29(-7,10) M30(-7,11) M31(-7,12) M32(-7,13) M33(-7,14) M34(-7,15) M35(-7,16) M36(-7,17) M37(-7,18) N1(-6,-18) N2(-6,-17) N3(-6,-16) N4(-6,-15) N5(-6,-14) N6(-6,-13) N7(-6,-12) N8(-6,-11) N9(-6,-10) N10(-6,-9) N11(-6,-8) N12(-6,-7) N13(-6,-6) N14(-6,-5) N15(-6,-4) N16(-6,-3) N17(-6,-2) N18(-6,-1) N19(-6,0) N20(-6,1) N21(-6,2) N22(-6,3) N23(-6,4) N24(-6,5) N25(-6,6) N26(-6,7) N27(-6,8) N28(-6,9) N29(-6,10) N30(-6,11) N31(-6,12) N32(-6,13) N33(-6,14) N34(-6,15) N35(-6,16) N36(-6,17) N37(-6,18) P1(-5,-18) P2(-5,-17) P3(-5,-16) P4(-5,-15) P5(-5,-14) P6(-5,-13) P7(-5,-12) P8(-5,-11) P9(-5,-10) P10(-5,-9) P11(-5,-8) P12(-5,-7) P13(-5,-6) P14(-5,-5) P15(-5,-4) P16(-5,-3) P17(-5,-2) P18(-5,-1) P19(-5,0) P20(-5,1) P21(-5,2) P22(-5,3) P23(-5,4) P24(-5,5) P25(-5,6) P26(-5,7) P27(-5,8) P28(-5,9) P29(-5,10) P30(-5,11) P31(-5,12) P32(-5,13) P33(-5,14) P34(-5,15) P35(-5,16) P36(-5,17) P37(-5,18) R1(-4,-18) R2(-4,-17) R3(-4,-16) R4(-4,-15) R5(-4,-14) R6(-4,-13) R7(-4,-12) R8(-4,-11) R9(-4,-10) R10(-4,-9) R11(-4,-8) R12(-4,-7) R13(-4,-6) R14(-4,-5) R15(-4,-4) R16(-4,-3) R17(-4,-2) R18(-4,-1) R19(-4,0) R20(-4,1) R21(-4,2) R22(-4,3) R23(-4,4) R24(-4,5) R25(-4,6) R26(-4,7) R27(-4,8) R28(-4,9) R29(-4,10) R30(-4,11) R31(-4,12) R32(-4,13) R33(-4,14) R34(-4,15) R35(-4,16) R36(-4,17) R37(-4,18) T1(-3,-18) T2(-3,-17) T3(-3,-16) T4(-3,-15) T5(-3,-14) T6(-3,-13) T7(-3,-12) T8(-3,-11) T9(-3,-10) T10(-3,-9) T11(-3,-8) T12(-3,-7) T13(-3,-6) T14(-3,-5) T15(-3,-4) T16(-3,-3) T17(-3,-2) T18(-3,-1) T19(-3,0) T20(-3,1) T21(-3,2) T22(-3,3) T23(-3,4) T24(-3,5) T25(-3,6) T26(-3,7) T27(-3,8) T28(-3,9) T29(-3,10) T30(-3,11) T31(-3,12) T32(-3,13) T33(-3,14) T34(-3,15) T35(-3,16) T36(-3,17) T37(-3,18) U1(-2,-18) U2(-2,-17) U3(-2,-16) U4(-2,-15) U5(-2,-14) U6(-2,-13) U7(-2,-12) U8(-2,-11) U9(-2,-10) U10(-2,-9) U11(-2,-8) U12(-2,-7) U13(-2,-6) U14(-2,-5) U15(-2,-4) U16(-2,-3) U17(-2,-2) U18(-2,-1) U19(-2,0) U20(-2,1) U21(-2,2) U22(-2,3) U23(-2,4) U24(-2,5) U25(-2,6) U26(-2,7) U27(-2,8) U28(-2,9) U29(-2,10) U30(-2,11) U31(-2,12) U32(-2,13) U33(-2,14) U34(-2,15) U35(-2,16) U36(-2,17) U37(-2,18) V1(-1,-18) V2(-1,-17) V3(-1,-16) V4(-1,-15) V5(-1,-14) V6(-1,-13) V7(-1,-12) V8(-1,-11) V9(-1,-10) V10(-1,-9) V11(-1,-8) V12(-1,-7) V13(-1,-6) V14(-1,-5) V15(-1,-4) V16(-1,-3) V17(-1,-2) V18(-1,-1) V19(-1,0) V20(-1,1) V21(-1,2) V22(-1,3) V23(-1,4) V24(-1,5) V25(-1,6) V26(-1,7) V27(-1,8) V28(-1,9) V29(-1,10) V30(-1,11) V31(-1,12) V32(-1,13) V33(-1,14) V34(-1,15) V35(-1,16) V36(-1,17) V37(-1,18) W1(0,-18) W2(0,-17) W3(0,-16) W4(0,-15) W5(0,-14) W6(0,-13) W7(0,-12) W8(0,-11) W9(0,-10) W10(0,-9) W11(0,-8) W12(0,-7) W13(0,-6) W14(0,-5) W15(0,-4) W16(0,-3) W17(0,-2) W18(0,-1) W19(0,0) W20(0,1) W21(0,2) W22(0,3) W23(0,4) W24(0,5) W25(0,6) W26(0,7) W27(0,8) W28(0,9) W29(0,10) W30(0,11) W31(0,12) W32(0,13) W33(0,14) W34(0,15) W35(0,16) W36(0,17) W37(0,18) Y1(1,-18) Y2(1,-17) Y3(1,-16) Y4(1,-15) Y5(1,-14) Y6(1,-13) Y7(1,-12) Y8(1,-11) Y9(1,-10) Y10(1,-9) Y11(1,-8) Y12(1,-7) Y13(1,-6) Y14(1,-5) Y15(1,-4) Y16(1,-3) Y17(1,-2) Y18(1,-1) Y19(1,0) Y20(1,1) Y21(1,2) Y22(1,3) Y23(1,4) Y24(1,5) Y25(1,6) Y26(1,7) Y27(1,8) Y28(1,9) Y29(1,10) Y30(1,11) Y31(1,12) Y32(1,13) Y33(1,14) Y34(1,15) Y35(1,16) Y36(1,17) Y37(1,18)
PQFP-80B
  rect 0.406x1.524 smd: 1(-6.175,-7.873) 2(-5.525,-7.873) 3(-4.875,-7.873) 4(-4.225,-7.873) 5(-3.575,-7.873) 6(-2.925,-7.873) 7(-2.275,-7.873) 8(-1.625,-7.873) 9(-0.975,-7.873) 10(-0.325,-7.873) 11(0.325,-7.873) 12(0.975,-7.873) 13(1.625,-7.873) 14(2.275,-7.873) 15(2.925,-7.873) 16(3.575,-7.873) 17(4.225,-7.873) 18(4.875,-7.873) 19(5.525,-7.873) 20(6.175,-7.873) 41(6.175,7.873) 42(5.525,7.873) 43(4.875,7.873) 44(4.225,7.873) 45(3.575,7.873) 46(2.925,7.873) 47(2.275,7.873) 48(1.625,7.873) 49(0.975,7.873) 50(0.325,7.873) 51(-0.325,7.873) 52(-0.975,7.873) 53(-1.625,7.873) 54(-2.275,7.873) 55(-2.925,7.873) 56(-3.575,7.873) 57(-4.225,7.873) 58(-4.875,7.873) 59(-5.525,7.873) 60(-6.175,7.873)
  rect 1.524x0.406 smd: 21(7.873,-6.175) 22(7.873,-5.525) 23(7.873,-4.875) 24(7.873,-4.225) 25(7.873,-3.575) 26(7.873,-2.925) 27(7.873,-2.275) 28(7.873,-1.625) 29(7.873,-0.975) 30(7.873,-0.325) 31(7.873,0.325) 32(7.873,0.975) 33(7.873,1.625) 34(7.873,2.275) 35(7.873,2.925) 36(7.873,3.575) 37(7.873,4.225) 38(7.873,4.875) 39(7.873,5.525) 40(7.873,6.175) 61(-7.873,6.175) 62(-7.873,5.525) 63(-7.873,4.875) 64(-7.873,4.225) 65(-7.873,3.575) 66(-7.873,2.925) 67(-7.873,2.275) 68(-7.873,1.625) 69(-7.873,0.975) 70(-7.873,0.325) 71(-7.873,-0.325) 72(-7.873,-0.975) 73(-7.873,-1.625) 74(-7.873,-2.275) 75(-7.873,-2.925) 76(-7.873,-3.575) 77(-7.873,-4.225) 78(-7.873,-4.875) 79(-7.873,-5.525) 80(-7.873,-6.175)
R-0402H016HS40
  custom 0.114x0.114 smd: 1(0,-0.381) 2(0,0.381)
R-0402S0
  custom 0.127x0.127 smd: 1(0,-0.406) 2(0,0.406)
R-0603S0
  custom 0.191x0.191 smd: 1(0,-0.686) 2(0,0.686)
R-0805
  custom 0.254x0.254 smd: 1(0,-0.889) 2(0,0.889)
R-1206
  custom 0.362x0.362 smd: 1(0,-1.333) 2(0,1.333)
S-C-0402
  custom 0.133x0.133 smd: 1(0,-0.419) 2(0,0.419)
S-CJ-RJ45-2X1-16SL
  round 1.194 hole 0.889: AR1(-3.3,3.95) AR2(-2.03,5.22) AR3(-3.3,6.49) AR4(-2.03,7.76) AR5(-3.3,9.03) AR6(-2.03,10.3) AR7(-3.3,11.57) AR8(-2.03,12.84) BR1(3.3,3.95) BR2(2.03,5.22) BR3(3.3,6.49) BR4(2.03,7.76) BR5(3.3,9.03) BR6(2.03,10.3) BR7(3.3,11.57) BR8(2.03,12.84)
  round 1.88 hole 1.575: S1(-7.75,2.68) S2(7.75,7.76)
  round 2.591 hole 2.286: S3(-6.98,5.22) S5(6.98,10.3)
  round 2.896 hole 2.286: S4(-6.98,15.38) S6(6.98,0.14)
S-CJ-RJ45-D38_7X18_77-28SL
  round 2.108 hole 2.108 unplated: (0,16.775) (0,-1.325)
  round 1.194 hole 0.889: AR1(-2.03,2.945) AR2(-3.3,4.215) AR3(-2.03,5.485) AR4(-3.3,6.755) AR5(-2.03,8.025) AR6(-3.3,9.295) AR7(-2.03,10.565) AR8(-3.3,11.835) AR9(-2.03,13.105) AR10(-3.3,14.375) BR1(2.03,2.945) BR2(3.3,4.215) BR3(2.03,5.485) BR4(3.3,6.755) BR5(2.03,8.025) BR6(3.3,9.295) BR7(2.03,10.565) BR8(3.3,11.835) BR9(2.03,13.105) BR10(3.3,14.375) L1(3.3,16.915) L2(2.03,15.645) L3(-2.03,15.645) L4(-3.3,16.915) U1(-3.5,-3.445) U2(-1,-3.445) U3(1,-3.445) U4(3.5,-3.445)
  round 2.184 hole 1.575: S1(-8.03,1.025) S2(8.03,1.025) S3(8.03,11.025) S4(-8.03,11.025)
S-CN-S5X2-2_54S0
  rect 3.175x1.245 smd: 1(2.733,-5.08) 2(-2.733,-5.08) 3(2.733,-2.54) 4(-2.733,-2.54) 5(2.733,0) 6(-2.733,0) 7(2.733,2.54) 8(-2.733,2.54) 9(2.733,5.08) 10(-2.733,5.08)
S-CN-S7X2-2HD
  round 1.143 hole 1.143 unplated: (0,5) (0,-5)
  rect 2.743x0.991 smd: 1(2.122,-6) 2(-2.122,-6) 3(2.122,-4) 4(-2.122,-4) 5(2.122,-2) 6(-2.122,-2) 7(2.122,0) 8(-2.122,0) 9(2.122,2) 10(-2.122,2) 11(2.122,4) 12(-2.122,4) 13(2.122,6) 14(-2.122,6)
S-R-0402
  custom 0.133x0.133 smd: 1(0,-0.419) 2(0,0.419)
SC-70-5A
  rect 0.914x0.356 smd: 1(1.003,-0.65) 2(1.003,0) 3(1.003,0.65) 4(-1.003,0.65) 5(-1.003,-0.65)
SC-70-6
  rect 0.61x0.406 smd: 1(1.001,-0.65) 2(1.001,0) 3(1.001,0.65) 4(-1.001,0.65) 5(-1.001,0) 6(-1.001,-0.65)
SFP-2X1-76B
  round 2.5 hole 2.5 unplated: (-9.5,19.7) (9.5,19.7)
  round 0.686 hole 0.37: L_1(-7,20.92) L_2(-6.2,21.62) L_3(-5.4,20.22) L_4(-4.6,20.92) L_5(-3.8,21.62) L_6(-2.999,20.22) L_7(-2.199,20.92) L_8(-1.399,21.62) L_9(-0.599,20.22) L_10(0.201,20.92) L_11(1.001,21.62) L_12(1.801,20.22) L_13(2.601,20.92) L_14(3.401,21.62) L_15(4.201,20.22) L_16(5.002,20.92) L_17(5.802,21.62) L_18(6.602,20.22) L_19(7.402,20.92) L_20(7.402,24.92) L_21(6.602,24.22) L_22(5.802,25.62) L_23(5.002,24.92) L_24(4.201,24.22) L_25(3.401,25.62) L_26(2.601,24.92) L_27(1.801,24.22) L_28(1.001,25.62) L_29(0.201,24.92) L_30(-0.599,24.22) L_31(-1.399,25.62) L_32(-2.199,24.92) L_33(-2.999,24.22) L_34(-3.8,25.62) L_35(-4.6,24.92) L_36(-5.4,24.22) L_37(-6.2,25.62) L_38(-7,24.92) U_1(-7,28.92) U_2(-6.2,29.62) U_3(-5.4,28.22) U_4(-4.6,28.92) U_5(-3.8,29.62) U_6(-2.999,28.22) U_7(-2.199,28.92) U_8(-1.399,29.62) U_9(-0.599,28.22) U_10(0.201,28.92) U_11(1.001,29.62) U_12(1.801,28.22) U_13(2.601,28.92) U_14(3.401,29.62) U_15(4.201,28.22) U_16(5.002,28.92) U_17(5.802,29.62) U_18(6.602,28.22) U_19(7.402,28.92) U_20(7.402,32.92) U_21(6.602,32.22) U_22(5.802,33.62) U_23(5.002,32.92) U_24(4.201,32.22) U_25(3.401,33.62) U_26(2.601,32.92) U_27(1.801,32.22) U_28(1.001,33.62) U_29(0.201,32.92) U_30(-0.599,32.22) U_31(-1.399,33.62) U_32(-2.199,32.92) U_33(-2.999,32.22) U_34(-3.8,33.62) U_35(-4.6,32.92) U_36(-5.4,32.22) U_37(-6.2,33.62) U_38(-7,32.92)
  round 1.651 hole 1.05: S1(-9.5,-24.6) S2(-9.5,-15.6) S3(-9.5,-6.6) S4(-9.5,2.4) S5(-9.5,13.1) S15(9.5,13.1) S16(9.5,2.4) S17(9.5,-6.6) S18(9.5,-15.6) S19(9.5,-24.6)
  round 1.168 hole 0.56: S6(-9.5,24.55) S7(-9.5,28.55) S8(-9.5,32.55) S9(-4.8,36.35) S10(0,36.35) S11(4.8,36.35) S12(9.5,32.55) S13(9.5,28.55) S14(9.5,24.55)
  round 1.422 hole 0.81: S20(-5.125,18.25) S21(-1.625,18.25) S22(1.875,18.25) S23(5.375,18.25)
SFP-2X6-240E-TEMP
  round 1.6 hole 1.6 unplated: (-40.525,18.165) (-30.725,18.165) (-26.275,18.165) (-16.475,18.165) (-12.025,18.165) (-2.225,18.165) (2.225,18.165) (12.025,18.165) (16.475,18.165) (26.275,18.165) (30.725,18.165) (40.525,18.165)
  round 0.686 hole 0.37: AB1(-32.025,22.665) AB2(-32.825,21.965) AB3(-33.625,23.365) AB4(-34.425,22.665) AB5(-35.225,21.965) AB6(-36.025,23.365) AB7(-36.825,22.665) AB8(-37.625,21.965) AB9(-38.425,23.365) AB10(-39.225,22.665) AB11(-39.225,19.665) AB12(-38.425,20.365) AB13(-37.625,18.965) AB14(-36.825,19.665) AB15(-36.025,20.365) AB16(-35.225,18.965) AB17(-34.425,19.665) AB18(-33.625,20.365) AB19(-32.825,18.965) AB20(-32.025,19.665) AT1(-39.225,25.665) AT2(-38.425,26.365) AT3(-37.625,24.965) AT4(-36.825,25.665) AT5(-36.025,26.365) AT6(-35.225,24.965) AT7(-34.425,25.665) AT8(-33.625,26.365) AT9(-32.825,24.965) AT10(-32.025,25.665) AT11(-32.025,28.665) AT12(-32.825,27.965) AT13(-33.625,29.365) AT14(-34.425,28.665) AT15(-35.225,27.965) AT16(-36.025,29.365) AT17(-36.825,28.665) AT18(-37.625,27.965) AT19(-38.425,29.365) AT20(-39.225,28.665) BB1(-17.775,22.665) BB2(-18.575,21.965) BB3(-19.375,23.365) BB4(-20.175,22.665) BB5(-20.975,21.965) BB6(-21.775,23.365) BB7(-22.575,22.665) BB8(-23.375,21.965) BB9(-24.175,23.365) BB10(-24.975,22.665) BB11(-24.975,19.665) BB12(-24.175,20.365) BB13(-23.375,18.965) BB14(-22.575,19.665) BB15(-21.775,20.365) BB16(-20.975,18.965) BB17(-20.175,19.665) BB18(-19.375,20.365) BB19(-18.575,18.965) BB20(-17.775,19.665) BT1(-24.975,25.665) BT2(-24.175,26.365) BT3(-23.375,24.965) BT4(-22.575,25.665) BT5(-21.775,26.365) BT6(-20.975,24.965) BT7(-20.175,25.665) BT8(-19.375,26.365) BT9(-18.575,24.965) BT10(-17.775,25.665) BT11(-17.775,28.665) BT12(-18.575,27.965) BT13(-19.375,29.365) BT14(-20.175,28.665) BT15(-20.975,27.965) BT16(-21.775,29.365) BT17(-22.575,28.665) BT18(-23.375,27.965) BT19(-24.175,29.365) BT20(-24.975,28.665) CB1(-3.525,22.665) CB2(-4.325,21.965) CB3(-5.125,23.365) CB4(-5.925,22.665) CB5(-6.725,21.965) CB6(-7.525,23.365) CB7(-8.325,22.665) CB8(-9.125,21.965) CB9(-9.925,23.365) CB10(-10.725,22.665) CB11(-10.725,19.665) CB12(-9.925,20.365) CB13(-9.125,18.965) CB14(-8.325,19.665) CB15(-7.525,20.365) CB16(-6.725,18.965) CB17(-5.925,19.665) CB18(-5.125,20.365) CB19(-4.325,18.965) CB20(-3.525,19.665) CT1(-10.725,25.665) CT2(-9.925,26.365) CT3(-9.125,24.965) CT4(-8.325,25.665) CT5(-7.525,26.365) CT6(-6.725,24.965) CT7(-5.925,25.665) CT8(-5.125,26.365) CT9(-4.325,24.965) CT10(-3.525,25.665) CT11(-3.525,28.665) CT12(-4.325,27.965) CT13(-5.125,29.365) CT14(-5.925,28.665) CT15(-6.725,27.965) CT16(-7.525,29.365) CT17(-8.325,28.665) CT18(-9.125,27.965) CT19(-9.925,29.365) CT20(-10.725,28.665) DB1(10.725,22.665) DB2(9.925,21.965) DB3(9.125,23.365) DB4(8.325,22.665) DB5(7.525,21.965) DB6(6.725,23.365) DB7(5.925,22.665) DB8(5.125,21.965) DB9(4.325,23.365) DB10(3.525,22.665) DB11(3.525,19.665) DB12(4.325,20.365) DB13(5.125,18.965) DB14(5.925,19.665) DB15(6.725,20.365) DB16(7.525,18.965) DB17(8.325,19.665) DB18(9.125,20.365) DB19(9.925,18.965) DB20(10.725,19.665) DT1(3.525,25.665) DT2(4.325,26.365) DT3(5.125,24.965) DT4(5.925,25.665) DT5(6.725,26.365) DT6(7.525,24.965) DT7(8.325,25.665) DT8(9.125,26.365) DT9(9.925,24.965) DT10(10.725,25.665) DT11(10.725,28.665) DT12(9.925,27.965) DT13(9.125,29.365) DT14(8.325,28.665) DT15(7.525,27.965) DT16(6.725,29.365) DT17(5.925,28.665) DT18(5.125,27.965) DT19(4.325,29.365) DT20(3.525,28.665) EB1(24.975,22.665) EB2(24.175,21.965) EB3(23.375,23.365) EB4(22.575,22.665) EB5(21.775,21.965) EB6(20.975,23.365) EB7(20.175,22.665) EB8(19.375,21.965) EB9(18.575,23.365) EB10(17.775,22.665) EB11(17.775,19.665) EB12(18.575,20.365) EB13(19.375,18.965) EB14(20.175,19.665) EB15(20.975,20.365) EB16(21.775,18.965) EB17(22.575,19.665) EB18(23.375,20.365) EB19(24.175,18.965) EB20(24.975,19.665) ET1(17.775,25.665) ET2(18.575,26.365) ET3(19.375,24.965) ET4(20.175,25.665) ET5(20.975,26.365) ET6(21.775,24.965) ET7(22.575,25.665) ET8(23.375,26.365) ET9(24.175,24.965) ET10(24.975,25.665) ET11(24.975,28.665) ET12(24.175,27.965) ET13(23.375,29.365) ET14(22.575,28.665) ET15(21.775,27.965) ET16(20.975,29.365) ET17(20.175,28.665) ET18(19.375,27.965) ET19(18.575,29.365) ET20(17.775,28.665) FB1(39.225,22.665) FB2(38.425,21.965) FB3(37.625,23.365) FB4(36.825,22.665) FB5(36.025,21.965) FB6(35.225,23.365) FB7(34.425,22.665) FB8(33.625,21.965) FB9(32.825,23.365) FB10(32.025,22.665) FB11(32.025,19.665) FB12(32.825,20.365) FB13(33.625,18.965) FB14(34.425,19.665) FB15(35.225,20.365) FB16(36.025,18.965) FB17(36.825,19.665) FB18(37.625,20.365) FB19(38.425,18.965) FB20(39.225,19.665) FT1(32.025,25.665) FT2(32.825,26.365) FT3(33.625,24.965) FT4(34.425,25.665) FT5(35.225,26.365) FT6(36.025,24.965) FT7(36.825,25.665) FT8(37.625,26.365) FT9(38.425,24.965) FT10(39.225,25.665) FT11(39.225,28.665) FT12(38.425,27.965) FT13(37.625,29.365) FT14(36.825,28.665) FT15(36.025,27.965) FT16(35.225,29.365) FT17(34.425,28.665) FT18(33.625,27.965) FT19(32.825,29.365) FT20(32.025,28.665)
  round 1.168 hole 0.56: S1(-42.75,-20.125) S2(-42.75,-12.125) S3(-42.75,-4.125) S4(-42.75,3.875) S5(-42.75,11.875) S6(-42.75,18.665) S7(-42.75,22.165) S8(-42.75,25.665) S9(-42.75,29.165) S10(-39.125,31.445) S11(-35.625,31.445) S12(-32.125,31.445) S13(-28.5,29.165) S14(-28.5,25.665) S15(-28.5,22.165) S16(-28.5,18.665) S17(-24.875,31.445) S18(-21.375,31.445) S19(-17.875,31.445) S20(-14.25,29.165) S21(-14.25,25.665) S22(-14.25,22.165) S23(-14.25,18.665) S24(-10.625,31.445) S25(-7.125,31.445) S26(-3.625,31.445) S27(0,29.165) S28(0,25.665) S29(0,22.165) S30(0,18.665) S31(3.625,31.445) S32(7.125,31.445) S33(10.625,31.445) S34(14.25,29.165) S35(14.25,25.665) S36(14.25,22.165) S37(14.25,18.665) S38(17.875,31.445) S39(21.375,31.445) S40(24.875,31.445) S41(28.5,29.165) S42(28.5,25.665) S43(28.5,22.165) S44(28.5,18.665) S45(32.125,31.445) S46(35.625,31.445) S47(39.125,31.445) S48(42.75,29.165) S49(42.75,25.665) S50(42.75,22.165) S51(42.75,18.665) S52(39.125,16.445) S53(35.625,16.445) S54(32.125,16.445) S55(24.875,16.445) S56(21.375,16.445) S57(17.875,16.445) S58(10.625,16.445) S59(7.125,16.445) S60(3.625,16.445) S61(-3.625,16.445) S62(-7.125,16.445) S63(-10.625,16.445) S64(-17.875,16.445) S65(-21.375,16.445) S66(-24.875,16.445) S67(-32.125,16.445) S68(-35.625,16.445) S69(-39.125,16.445) S70(-28.5,11.875) S71(-28.5,3.875) S72(-28.5,-4.125) S73(-28.5,-12.125) S74(-28.5,-20.125) S75(-14.25,-20.125) S76(-14.25,-12.125) S77(-14.25,-4.125) S78(-14.25,3.875) S79(-14.25,11.875) S80(0,11.875) S81(0,3.875) S82(0,-4.125) S83(0,-12.125) S84(0,-20.125) S85(14.25,-20.125) S86(14.25,-12.125) S87(14.25,-4.125) S88(14.25,3.875) S89(14.25,11.875) S90(28.5,11.875) S91(28.5,3.875) S92(28.5,-4.125) S93(28.5,-12.125) S94(28.5,-20.125) S95(42.75,-20.125) S96(42.75,-12.125) S97(42.75,-4.125) S98(42.75,3.875) S99(42.75,11.875)
SFP-2X8-389
  round 1.85 hole 1.85 unplated: (-55.375,21.975) (-44.375,29.475) (-41.125,21.975) (-30.125,29.475) (-26.874,21.975) (-15.874,29.475) (-12.624,21.975) (-1.624,29.475) (1.626,21.975) (12.626,29.475) (15.876,21.975) (26.876,29.475) (30.126,21.975) (41.126,29.475) (44.376,21.975) (55.376,29.475)
  round 0.762 hole 0.46: AL1(-46.475,21.245) AL2(-47.275,22.625) AL3(-48.075,21.245) AL4(-48.875,22.625) AL5(-49.675,21.245) AL6(-50.475,22.625) AL7(-51.275,21.245) AL8(-52.075,22.625) AL9(-52.875,21.245) AL10(-53.675,22.625) AL11(-53.274,19.695) AL12(-52.475,18.305) AL13(-51.675,19.695) AL14(-50.875,18.305) AL15(-50.075,19.695) AL16(-49.275,18.305) AL17(-48.475,19.695) AL18(-47.675,18.305) AL19(-46.875,19.695) AL20(-46.075,18.305) AT1(-53.274,25.565) AT2(-52.475,24.175) AT3(-51.675,25.565) AT4(-50.875,24.175) AT5(-50.075,25.565) AT6(-49.275,24.175) AT7(-48.475,25.565) AT8(-47.675,24.175) AT9(-46.875,25.565) AT10(-46.075,24.175) AT11(-46.475,27.115) AT12(-47.275,28.495) AT13(-48.075,27.115) AT14(-48.875,28.495) AT15(-49.675,27.115) AT16(-50.475,28.495) AT17(-51.275,27.115) AT18(-52.075,28.495) AT19(-52.875,27.115) AT20(-53.675,28.495) BL1(-32.225,21.245) BL2(-33.025,22.625) BL3(-33.825,21.245) BL4(-34.625,22.625) BL5(-35.425,21.245) BL6(-36.225,22.625) BL7(-37.025,21.245) BL8(-37.825,22.625) BL9(-38.625,21.245) BL10(-39.425,22.625) BL11(-39.025,19.695) BL12(-38.224,18.305) BL13(-37.425,19.695) BL14(-36.625,18.305) BL15(-35.825,19.695) BL16(-35.025,18.305) BL17(-34.225,19.695) BL18(-33.425,18.305) BL19(-32.625,19.695) BL20(-31.825,18.305) BT1(-39.025,25.565) BT2(-38.224,24.175) BT3(-37.425,25.565) BT4(-36.625,24.175) BT5(-35.825,25.565) BT6(-35.025,24.175) BT7(-34.225,25.565) BT8(-33.425,24.175) BT9(-32.625,25.565) BT10(-31.825,24.175) BT11(-32.225,27.115) BT12(-33.025,28.495) BT13(-33.825,27.115) BT14(-34.625,28.495) BT15(-35.425,27.115) BT16(-36.225,28.495) BT17(-37.025,27.115) BT18(-37.825,28.495) BT19(-38.625,27.115) BT20(-39.425,28.495) CL1(-17.975,21.245) CL2(-18.775,22.625) CL3(-19.575,21.245) CL4(-20.375,22.625) CL5(-21.175,21.245) CL6(-21.975,22.625) CL7(-22.775,21.245) CL8(-23.575,22.625) CL9(-24.375,21.245) CL10(-25.174,22.625) CL11(-24.774,19.695) CL12(-23.974,18.305) CL13(-23.174,19.695) CL14(-22.374,18.305) CL15(-21.575,19.695) CL16(-20.774,18.305) CL17(-19.975,19.695) CL18(-19.174,18.305) CL19(-18.375,19.695) CL20(-17.575,18.305) CT1(-24.774,25.565) CT2(-23.974,24.175) CT3(-23.174,25.565) CT4(-22.374,24.175) CT5(-21.575,25.565) CT6(-20.774,24.175) CT7(-19.975,25.565) CT8(-19.174,24.175) CT9(-18.375,25.565) CT10(-17.575,24.175) CT11(-17.975,27.115) CT12(-18.775,28.495) CT13(-19.575,27.115) CT14(-20.375,28.495) CT15(-21.175,27.115) CT16(-21.975,28.495) CT17(-22.775,27.115) CT18(-23.575,28.495) CT19(-24.375,27.115) CT20(-25.174,28.495) DL1(-3.725,21.245) DL2(-4.525,22.625) DL3(-5.325,21.245) DL4(-6.124,22.625) DL5(-6.925,21.245) DL6(-7.724,22.625) DL7(-8.524,21.245) DL8(-9.324,22.625) DL9(-10.124,21.245) DL10(-10.924,22.625) DL11(-10.524,19.695) DL12(-9.724,18.305) DL13(-8.924,19.695) DL14(-8.124,18.305) DL15(-7.324,19.695) DL16(-6.524,18.305) DL17(-5.724,19.695) DL18(-4.924,18.305) DL19(-4.124,19.695) DL20(-3.324,18.305) DT1(-10.524,25.565) DT2(-9.724,24.175) DT3(-8.924,25.565) DT4(-8.124,24.175) DT5(-7.324,25.565) DT6(-6.524,24.175) DT7(-5.724,25.565) DT8(-4.924,24.175) DT9(-4.124,25.565) DT10(-3.324,24.175) DT11(-3.725,27.115) DT12(-4.525,28.495) DT13(-5.325,27.115) DT14(-6.124,28.495) DT15(-6.925,27.115) DT16(-7.724,28.495) DT17(-8.524,27.115) DT18(-9.324,28.495) DT19(-10.124,27.115) DT20(-10.924,28.495) EL1(10.526,21.245) EL2(9.726,22.625) EL3(8.926,21.245) EL4(8.126,22.625) EL5(7.326,21.245) EL6(6.526,22.625) EL7(5.726,21.245) EL8(4.926,22.625) EL9(4.126,21.245) EL10(3.326,22.625) EL11(3.726,19.695) EL12(4.526,18.305) EL13(5.326,19.695) EL14(6.126,18.305) EL15(6.926,19.695) EL16(7.726,18.305) EL17(8.526,19.695) EL18(9.326,18.305) EL19(10.126,19.695) EL20(10.926,18.305) ET1(3.726,25.565) ET2(4.526,24.175) ET3(5.326,25.565) ET4(6.126,24.175) ET5(6.926,25.565) ET6(7.726,24.175) ET7(8.526,25.565) ET8(9.326,24.175) ET9(10.126,25.565) ET10(10.926,24.175) ET11(10.526,27.115) ET12(9.726,28.495) ET13(8.926,27.115) ET14(8.126,28.495) ET15(7.326,27.115) ET16(6.526,28.495) ET17(5.726,27.115) ET18(4.926,28.495) ET19(4.126,27.115) ET20(3.326,28.495) FL1(24.776,21.245) FL2(23.976,22.625) FL3(23.176,21.245) FL4(22.376,22.625) FL5(21.576,21.245) FL6(20.776,22.625) FL7(19.976,21.245) FL8(19.176,22.625) FL9(18.376,21.245) FL10(17.576,22.625) FL11(17.976,19.695) FL12(18.776,18.305) FL13(19.576,19.695) FL14(20.376,18.305) FL15(21.176,19.695) FL16(21.976,18.305) FL17(22.776,19.695) FL18(23.576,18.305) FL19(24.376,19.695) FL20(25.176,18.305) FT1(17.976,25.565) FT2(18.776,24.175) FT3(19.576,25.565) FT4(20.376,24.175) FT5(21.176,25.565) FT6(21.976,24.175) FT7(22.776,25.565) FT8(23.576,24.175) FT9(24.376,25.565) FT10(25.176,24.175) FT11(24.776,27.115) FT12(23.976,28.495) FT13(23.176,27.115) FT14(22.376,28.495) FT15(21.576,27.115) FT16(20.776,28.495) FT17(19.976,27.115) FT18(19.176,28.495) FT19(18.376,27.115) FT20(17.576,28.495) GL1(39.026,21.245) GL2(38.226,22.625) GL3(37.426,21.245) GL4(36.626,22.625) GL5(35.826,21.245) GL6(35.026,22.625) GL7(34.226,21.245) GL8(33.426,22.625) GL9(32.626,21.245) GL10(31.826,22.625) GL11(32.226,19.695) GL12(33.026,18.305) GL13(33.826,19.695) GL14(34.626,18.305) GL15(35.426,19.695) GL16(36.226,18.305) GL17(37.026,19.695) GL18(37.826,18.305) GL19(38.626,19.695) GL20(39.426,18.305) GT1(32.226,25.565) GT2(33.026,24.175) GT3(33.826,25.565) GT4(34.626,24.175) GT5(35.426,25.565) GT6(36.226,24.175) GT7(37.026,25.565) GT8(37.826,24.175) GT9(38.626,25.565) GT10(39.426,24.175) GT11(39.026,27.115) GT12(38.226,28.495) GT13(37.426,27.115) GT14(36.626,28.495) GT15(35.826,27.115) GT16(35.026,28.495) GT17(34.226,27.115) GT18(33.426,28.495) GT19(32.626,27.115) GT20(31.826,28.495) HL1(53.276,21.245) HL2(52.476,22.625) HL3(51.676,21.245) HL4(50.876,22.625) HL5(50.076,21.245) HL6(49.276,22.625) HL7(48.476,21.245) HL8(47.676,22.625) HL9(46.876,21.245) HL10(46.076,22.625) HL11(46.476,19.695) HL12(47.276,18.305) HL13(48.076,19.695) HL14(48.876,18.305) HL15(49.676,19.695) HL16(50.476,18.305) HL17(51.276,19.695) HL18(52.076,18.305) HL19(52.876,19.695) HL20(53.676,18.305) HT1(46.476,25.565) HT2(47.276,24.175) HT3(48.076,25.565) HT4(48.876,24.175) HT5(49.676,25.565) HT6(50.476,24.175) HT7(51.276,25.565) HT8(52.076,24.175) HT9(52.876,25.565) HT10(53.676,24.175) HT11(53.276,27.115) HT12(52.476,28.495) HT13(51.676,27.115) HT14(50.876,28.495) HT15(50.076,27.115) HT16(49.276,28.495) HT17(48.476,27.115) HT18(47.676,28.495) HT19(46.876,27.115) HT20(46.076,28.495)
  round 1.651 hole 1.05: S1(-53.875,31.5) S2(-49.875,31.5) S3(-45.875,31.5) S4(-39.625,31.5) S5(-35.625,31.5) S6(-31.625,31.5) S7(-25.375,31.5) S8(-21.375,31.5) S9(-17.375,31.5) S10(-11.125,31.5) S11(-7.125,31.5) S12(-3.125,31.5) S13(3.125,31.5) S14(7.125,31.5) S15(11.125,31.5) S16(17.375,31.5) S17(21.375,31.5) S18(25.375,31.5) S19(31.625,31.5) S20(35.625,31.5) S21(39.625,31.5) S22(45.875,31.5) S23(49.875,31.5) S24(53.875,31.5) S25(-57,11.875) S26(-42.749,11.875) S27(-28.5,11.875) S28(-14.25,11.875) S29(0,11.875) S30(14.25,11.875) S31(28.5,11.875) S32(42.75,11.875) S33(57,11.875) S34(-57,3.875) S35(-42.749,3.875) S36(-28.5,3.875) S37(-14.25,3.875) S38(0,3.875) S39(14.25,3.875) S40(28.5,3.875) S41(42.75,3.875) S42(57,3.875) S43(-57,-4.125) S44(-42.749,-4.125) S45(-28.5,-4.125) S46(-14.25,-4.125) S47(0,-4.125) S48(14.25,-4.125) S49(28.5,-4.125) S50(42.75,-4.125) S51(57,-4.125) S52(-57,-12.125) S53(-42.749,-12.125) S54(-28.5,-12.125) S55(-14.25,-12.125) S56(0,-12.125) S57(14.25,-12.125) S58(28.5,-12.125) S59(42.75,-12.125) S60(57,-12.125) S61(-57,-20.125) S62(-42.749,-20.125) S63(-28.5,-20.125) S64(-14.25,-20.125) S65(0,-20.125) S66(14.25,-20.125) S67(28.5,-20.125) S68(42.75,-20.125) S69(57,-20.125)
SO-8J
  rect 1.651x0.635 smd: 1(3.545,-1.905) 2(3.545,-0.635) 3(3.545,0.635) 4(3.545,1.905) 5(-3.545,1.905) 6(-3.545,0.635) 7(-3.545,-0.635) 8(-3.545,-1.905)
SOD-323C
  rect 0.787x0.787 smd: 1(0,1.093) 2(0,-1.093)
SOD-323H1_1
  rect 0.711x0.914 smd: 1(0,1.2) 2(0,-1.2)
SOT-23-5
  rect 1.067x0.559 smd: 1(1.359,-0.95) 2(1.359,0) 3(1.359,0.95) 4(-1.359,0.95) 5(-1.359,-0.95)
SOT-23-6
  rect 1.067x0.559 smd: 1(1.359,-0.95) 2(1.359,0) 3(1.359,0.95) 4(-1.359,0.95) 5(-1.359,0) 6(-1.359,-0.95)
SOT-23-6H1_25
  rect 1.067x0.559 smd: 1(1.359,-0.95) 2(1.359,0) 3(1.359,0.95) 4(-1.359,0.95) 5(-1.359,0) 6(-1.359,-0.95)
SOT-23-8A
  rect 1.194x0.406 smd: 1(1.3,-0.975) 2(1.3,-0.325) 3(1.3,0.325) 4(1.3,0.975) 5(-1.3,0.975) 6(-1.3,0.325) 7(-1.3,-0.325) 8(-1.3,-0.975)
SOT-23BH1_11
  rect 1.067x1.016 smd: 1(0.92,-0.951) 2(0.92,0.951) 3(-0.921,0)
SOT-23D
  rect 1.143x1.016 smd: 1(1.143,-0.991) 2(1.143,0.991) 3(-1.143,0)
