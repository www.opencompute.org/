# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P3V3_SFP22: length 51.1
  TOP w0.305: 247.34,76.37 U31.9
  TOP w0.381: 248.79,73.1 249.14,73.44 C1279.1 C1278.1 249.14,75.57 v1(248.14,76.57) 247.53,76.57 247.34,76.37
  P10 w0.254: 245.33,42.41 245.33,46.97 246.6,48.25 249.26,45.59 249.26,41.71 247.85,40.3 v1(247.43,40.3) 245.33,42.41
  P10 w0.508: 246.6,48.25 247.14,48.78 247.14,57.15 244.5,59.79 244.5,71.13 v1(244.91,71.53)
  BOTTOM w0.381: v1(247.43,40.3) 247.76,39.98 R1566.1
P3V3_SFP23: length 52.8
  TOP w0.305: v1(247.75,75.57) 247.44,75.87 U31.8
  P10 w0.254: 256.34,48.24 256.43,48.24 257.69,46.99 257.69,44.12 256.32,42.76 v1(254.78,42.76) 253.95,43.59 253.95,45.51 255.04,46.6 255.18,46.88 256.23,47.93 256.23,48.35
  P10 w0.508: v1(247.75,75.57) 248.97,74.35 248.97,67.26 253.75,62.48 253.75,59.44 256.23,56.95 256.23,48.35 256.34,48.24
  BOTTOM w0.381: C1231.1 248.93,72.91 249.14,73.12 C1281.1 C1280.1 247.83,75.49 v1(247.75,75.57) ; R1568.1 v1(254.78,42.76)
  vias: v2(247.65,72.39)
P3V3_SFP24: length 54.6
  TOP w0.305: 260.47,76.42 U34.9
  TOP w0.508: 260.9,73.16 C1294.1 C1293.1 260.9,75.99 260.47,76.42
  P10 w0.254: 261.26,47.81 261.26,47.97 260.61,47.97 259.66,47.02 259.66,45.77 260.48,44.96 260.48,40.88 261.38,39.98 v1(262.12,39.98) 262.72,39.98 263.46,40.72 263.46,45.61 261.26,47.81
  P10 w0.508: v1(259.54,72.85) 256.67,69.98 256.67,61.59 261.37,56.89 261.37,48.07 261.26,47.97
  BOTTOM w0.381: R1571.1 v1(262.12,39.98)
P3V3_SFP25: length 54.8
  TOP w0.305: v1(259.92,75.66) 259.67,75.92 U34.8
  P10 w0.254: 271.94,47.39 271.94,45.35 v1(269.34,42.76) 268.8,42.76 268.06,43.5 268.06,45.49 269.47,46.9 269.47,46.9 270.3,47.73 270.3,48.31 271.01,48.31 271.94,47.39
  P10 w0.508: v1(259.92,75.66) 261.27,74.31 261.27,67.91 267.77,61.42 269.67,61.42 271.02,60.07 271.02,57.23 270.3,56.52 270.3,48.31
  BOTTOM w0.381: C1096.1 260.9,72.61 C1295.1 C1296.1 260.9,75.54 260.84,75.59 259.99,75.59 v1(259.92,75.66) ; R1573.1 v1(269.34,42.76)
  vias: v2(258.19,72.59)
P3V3_SFP26: length 61.3
  TOP w0.305: 275.18,76.42 275.18,76.42 U37.9
  TOP w0.508: 273.18,73.29 275.14,73.29 275.77,73.91 C1309.1 C1308.1 275.77,75.91 275.26,76.42 275.18,76.42
  P10 w0.508: v1(272.42,73.28) v1(278.76,73.28) 285.57,73.28 289.66,69.19 289.66,44.22 287.19,41.76 v1(281.57,41.76)
  BOTTOM w0.381: R1575.1 v1(281.57,41.76)
P3V3_SFP27: length 66.4
  TOP w0.305: U37.8 274.68,75.92 v1(274.86,75.74)
  T07 w0.508: v1(272.42,72.14) 273.56,72.14 275.34,73.91 275.34,75.26 v1(274.86,75.74)
  P10 w0.508: v1(272.42,72.14) 272.94,71.61 276.59,71.61 277.19,72.21 284.93,72.21 288.51,68.63 288.51,46.76 284.82,43.08 280.44,43.08 277.35,39.98 v1(275.34,39.98)
  BOTTOM w0.381: v1(274.86,75.74) 275.06,75.54 C1310.1 C1311.1 ; R1578.1 v1(275.34,39.98)
  vias: v2(270.15,72.33)
P3V3_SFP_DISCHARGE_P00: length 3.8
  BOTTOM w0.381: v2(86.85,45.36) R1548.2 89.12,43.89 Q28.3
P3V3_SFP_DISCHARGE_P01: length 3.1
  BOTTOM w0.381: Q28.6 91.52,42.61 92.09,42.04 v2(92.43,42.04) R1555.2
P3V3_SFP_DISCHARGE_P02: length 3.6
  BOTTOM w0.381: v2(102.45,45.14) 102.47,45.12 R1557.2 102.53,43.51 Q29.3
P3V3_SFP_DISCHARGE_P03: length 3.9
  BOTTOM w0.381: R1559.2 107.47,41.88 107.14,42.21 Q29.6 106.52,41.44 v2(107.19,40.77)
P3V3_SFP_DISCHARGE_P04: length 3.9
  BOTTOM w0.381: v2(116.33,45.21) 116.89,44.66 R1561.2 117.04,43.39 Q30.3
P3V3_SFP_DISCHARGE_P05: length 3.8
  BOTTOM w0.381: v2(121.28,40.77) 121.25,40.77 120.87,41.15 Q30.6 121.3,42.09 121.63,41.76 R1563.2
P3V3_SFP_DISCHARGE_P06: length 3.6
  BOTTOM w0.381: Q31.3 131.41,43 R1565.2 131.27,44.14 v2(131.7,44.58)
P3V3_SFP_DISCHARGE_P07: length 4.2
  BOTTOM w0.381: Q31.6 135.68,41.7 136.01,41.38 R1567.2 137.82,41.38 138.18,41.02 v2(138.18,40.01)
P3V3_SFP_DISCHARGE_P08: length 3.7
  BOTTOM w0.381: Q32.3 145.54,43 R1570.2 145.39,43.92 v2(146.05,44.58)
P3V3_SFP_DISCHARGE_P09: length 4
  BOTTOM w0.381: v2(152.72,40.2) 151.54,41.38 R1572.2 150.47,41.38 150.14,41.7 Q32.6
P3V3_SFP_DISCHARGE_P10: length 4.1
  BOTTOM w0.381: Q33.3 159.79,42.88 R1574.2 159.64,43.81 v2(160.53,44.7)
P3V3_SFP_DISCHARGE_P11: length 3.3
  BOTTOM w0.381: v2(163.77,40.55) 163.77,40.57 163.62,40.73 Q33.6 164.19,41.58 164.52,41.25 R1577.2
P3V3_SFP_DISCHARGE_P12: length 3.8
  BOTTOM w0.381: Q34.3 174.55,43.51 R1579.2 174.4,44.6 v2(175.01,45.21)
P3V3_SFP_DISCHARGE_P13: length 3.8
  BOTTOM w0.381: v2(177.93,40.89) 177.93,41.76 Q34.6 178.65,42.21 179.19,41.68 R1581.2
P3V3_SFP_DISCHARGE_P14: length 3.9
  BOTTOM w0.381: v2(187.58,44.99) 188.39,44.17 R1583.2 189.41,43.66 190.05,43.03 Q35.3
P3V3_SFP_DISCHARGE_P15: length 4.1
  BOTTOM w0.381: Q35.6 194.33,41.73 R1586.2 194.72,41.88 195.2,41.4 v2(195.2,40.39)
P3V3_SFP_DISCHARGE_P16: length 3.9
  BOTTOM w0.381: Q36.3 207.16,41.09 206.52,41.72 R1554.2 v2(204.09,41.72)
P3V3_SFP_DISCHARGE_P17: length 3.8
  BOTTOM w0.381: v2(213.49,39.94) R1556.2 211.77,39.79 Q36.6
P3V3_SFP_DISCHARGE_P18: length 3.9
  BOTTOM w0.381: Q37.3 220.72,41.57 R1558.2 220.57,42.64 v2(221.23,43.31)
P3V3_SFP_DISCHARGE_P19: length 4.7
  BOTTOM w0.381: Q37.6 225.07,40.27 225.4,39.94 R1560.2 227.39,39.94 228.22,39.12 v2(228.22,38.61)
P3V3_SFP_DISCHARGE_P20: length 4
  BOTTOM w0.381: v2(235.33,43.31) 234.44,42.41 R1562.2 235.39,41.72 235.54,41.57 Q38.3
P3V3_SFP_DISCHARGE_P21: length 4.2
  BOTTOM w0.381: Q38.6 238.91,40.27 239.2,39.98 R1564.2 240.81,39.98 v2(242.01,38.79)
P3V3_SFP_DISCHARGE_P22: length 4
  BOTTOM w0.381: Q39.3 250.22,41.13 249.58,41.76 R1566.2 248.69,42.57 v2(249.39,43.27)
P3V3_SFP_DISCHARGE_P23: length 4.1
  BOTTOM w0.381: Q39.6 254.63,39.83 R1568.2 255.67,39.98 v2(256.41,39.24)
P3V3_SFP_DISCHARGE_P24: length 4
  BOTTOM w0.381: v2(263.67,43.33) 263.29,42.94 R1571.2 264.04,41.76 264.68,41.13 Q40.3
P3V3_SFP_DISCHARGE_P25: length 3.8
  BOTTOM w0.381: v2(269.75,38.48) 269.72,38.48 269.34,38.86 R1573.2 268.33,39.98 268.17,39.83 Q40.6
P3V3_SFP_DISCHARGE_P26: length 4
  BOTTOM w0.381: v2(284.48,39.98) R1575.2 281.92,39.98 281.76,39.83 Q41.3
P3V3_SFP_DISCHARGE_P27: length 5.3
  BOTTOM w0.381: Q41.6 278.25,41.13 277.62,41.76 R1578.2 276.61,42.67 277.75,43.81 v2(278.26,43.81)
P3V3_SFP_DISCHARGE_P32: length 2.4
  TOP w0.381: R1585.2 v1(282.19,78.67) Q44.3
P3V3_SFP_DISCHARGE_P33: length 2
  TOP w0.381: Q44.6 v1(278.97,76.58) R1588.2
P3V3_SN: length 1.7
  TOP w0.508: PR93.2 PC61.1
P3V3_SN2: length 2
  TOP w0.508: PR433.2 PC388.1
P3V3_SS: length 3
  TOP w0.254: PR78.2 31.01,164.51 32.16,163.37 PU2.37
P3V3_SS2: length 3
  TOP w0.254: PU22.37 5.98,175.74 4.89,176.83 PR430.2
P3V3_STB: length 455.6
  TOP w0.305: U75.1 223.63,174.43
  TOP w0.381: U201.4 C2162.1 26.85,124.92 29.08,122.68 35.69,122.68 37.47,124.46 37.47,126.55 41.06,130.15 41.06,132.25 v1(41.66,132.84) ; U98.5 90.26,132.9 C2403.2 v1(89.81,134.11) ; U89.15 80.57,55.55 C2373.2 v1(80.57,56.19) ; R1039.1 v1(109.06,191.7) ; v1(93.91,182.32) C1548.2 95,183.01 95.58,183.59 U81.8 ; R1175.2 v1(44.45,197.36) ; U58.24 C1368.1 v1(104.17,191.57) ; v1(82.09,174.33) C2361.2 82.09,172.98 81.92,172.81 U165.5 ; U67.16 86.59,185.92 C1377.2 v1(85.9,188.34) ; U145.5 48.21,187.56 C2447.1 v1(48.46,186.61) ; U1.D25 v4(207.86,104.5) ; v1(79.61,173.9) 79.28,173.9 C2224.2 78.91,172.95 79.25,172.61 U172.5 ; v1(86.61,129.92) C2404.2 U97.5 ; R1097.2 v1(100.2,180.78) ; v1(51.7,192.84) 51.51,192.65 C2002.1 U196.5 ; R12295.1 v1(73.19,58.56) ; U59.5 C2448.1 132.51,189.75 v1(132.42,189.66) ; R12977.2 57.53,204 v1(57.99,203.54) ; U197.5 C2446.1 v1(52.86,198.44) ; v1(124.85,185.46) 124.94,185.55 R1025.1 ; U198.4 C2449.1 v1(86.69,111.46) ; v1(129.16,185.93) 128.87,186.21 R1026.1 ; R1038.1 v1(109.06,192.97) ; R1750.1 v1(112.63,171.73) ; R12975.2 v1(55.5,203.55) ; v1(95.74,180.81) 96.14,181.21 R13030.2 ; R1098.2 v1(98.16,180.87) ; R1027.1 v1(130.43,196.6) ; R1153.2 v1(44.58,201.42) ; R12896.1 v1(99.09,131.6) ; v1(74.24,66.42) C2229.2 U152.5
  TOP w0.508: v3(223.17,177.01) C2439.2 223.17,174.89 223.63,174.43 ; R1046.2 v3(223.07,171.69)
  T03 w0.508: v1(63.63,116.2) 63.63,114.68 65.41,112.9 71.37,112.9 72.52,111.76 77.09,111.76 77.55,111.3 82.22,111.3 82.68,111.76 86.39,111.76 v1(86.69,111.46)
  T03 w0.635: v3(172.31,113) 167.36,117.95 167.36,133.63 159,141.99 v3(155.07,141.99)
  T05 w0.381: v4(129.21,102.36) 129.21,101.4 129.92,100.69 129.92,99.17 129.35,98.61 124.54,98.61 123.86,99.29 120.96,99.29 120.24,100.01 120.24,101.24 118.85,102.63 116.53,102.63 v1(115.83,103.32)
  T05 w0.635: 194.82,106.68 192.41,106.68 190.37,108.71 176.6,108.71 v3(172.31,113)
  T14 w0.508: v3(45.72,67.94) 43.69,65.91 30.48,65.91 19.57,55 19.57,47.21 v3(17.92,45.56)
  T16 w0.508: v1(195.05,122.49) 195.05,125.54 193.2,127.39 190.99,127.39 188.52,124.93 188.52,121.82 186.66,119.95 181.3,119.95 177.78,116.43 175.74,116.43 v3(172.31,113)
  T18 w0.508: v3(223.17,177.01) 230.18,184.02 256.18,184.02 265.3,174.9 265.3,160.86 267.96,158.2 267.96,147.96 276.52,139.41 276.52,120.36 283.18,113.7 283.18,102.56 284.01,101.72 284.01,100.47 v4(285.1,99.39)
  BOTTOM w0.381: v4(129.21,102.36) 129.61,101.97 C1413.2 129.61,101.67 129.61,100.96 130.07,100.5 U74.8 ; v1(92.78,184.94) 92.58,185.14 R953.2 92.46,185.7 R952.2 ; v1(51.1,198.35) 51.45,198.7 R12946.2 ; R13018.2 R13021.2 v1(72.55,128.67) ; v1(127.02,196.57) 126.72,196.88 R1028.1 ; v1(90.18,183.73) 89.8,183.73 R946.2 ; U173.5 C1678.2 48.36,89.48 v1(48.51,89.63) ; U151.5 C1818.2 73.81,62 v1(73.53,61.72) ; R1024.2 69.63,128.49 v1(69.47,128.65) ; R948.2 91.44,179.13 v1(90.93,178.62) 90.42,179.13 R949.2 ; v1(74.73,55.86) 75.01,56.13 R12909.2 ; R12908.2 v1(74.76,54.95) ; R947.2 v1(89.41,178.62) ; v4(207.86,104.5) 208.28,104.91 C3.1 ; U182.4 C2451.1 285.55,99.01 285.17,99.39 v4(285.1,99.39) ; v1(115.83,103.32) 116.3,102.86 R1030.2 ; R12487.2 v1(82.91,171.09) ; R1029.2 117.06,105.76 116.25,104.95 v1(116.25,104.9) 116.36,104.79 R1083.2 ; R12945.2 v1(50.42,202.43) ; R958.2 v1(85.77,178.89) ; R751.2 99.65,198.3 v1(99.06,198.89) 98.58,198.41 R752.2 ; v1(46.1,81.66) 46.1,82.23 C1817.2 48.01,82.42 48.39,82.04 U156.5 ; U181.4 64.44,115.78 C2450.1 63.81,116.38 v1(63.63,116.2) ; U180.4 195.35,123.51 C2463.1 195.1,122.71 195.05,122.66 v1(195.05,122.49) ; R13019.2 v1(116.1,100.8) ; R956.2 89.53,187.96 v1(89.41,188.09) ; R1268.2 49.12,188.21 v1(49.28,188.21) ; R1157.2 v1(34.9,196.62) ; R1180.2 v1(35.69,192.53) ; R750.2 96.75,193.72 v1(96.48,193.99) ; v1(75.41,123.09) C1412.2 U185.8 ; R12302.1 45.72,68.61 v3(45.72,67.94) ; v1(57.43,199.34) 56.82,199.34 R13090.2 ; R1099.2 v1(94.23,184.03) ; R13087.2 v1(53.57,191.41) ; v1(92.44,182.05) 91.96,182.53 R951.2 R950.2 ; R12471.2 v1(46.72,78.58) ; v1(87.38,178.76) R957.2 ; R742.2 v1(101.78,198.65) ; R13017.2 v1(75.9,128.55) ; R1281.2 v1(48.87,192.66)
  BOTTOM w0.508: L89.1 v3(17.92,45.56)
  vias: v1(93.95,123.16) v1(94.74,127.25) v1(94.87,125.48) v1(94.87,124.59) v1(102.26,181.44) v1(104.78,211.07) v1(104.78,210.36) v1(104.78,209.65) v1(110.53,163.48) v1(111.51,163.45) v1(112.43,163.48) v1(141.22,138.18) v1(141.86,138.56) v1(142.62,138.56) v1(143.13,139.06) v1(226.19,186.94) v1(227.08,186.94) v1(281.69,189.48) v1(281.94,190.25) v2(130.43,188.24) v2(130.43,186.97) v2(131.7,188.24) v2(131.7,186.97) v2(132.97,188.24) v2(132.97,186.97) v3(51.6,67.91)
P3V3_SW: length 5.1
  TOP w0.508: PC60.2 37.97,156.43 ; PR93.1 42.65,156.49
P3V3_SW2: length 4.7
  TOP w0.508: 11.81,169.54 10.97,168.7 PC369.2 ; PR433.1 17.2,172.52
P3V3_VBAT: length 33.7
  TOP w0.381: R12827.2 162.2,151.85 156.27,157.79 135.2,157.79 J1.A69
P3V3_VDD: length 4.7
  TOP w0.254: v1(36.71,168.18) 37.08,167.81 PU2.26
  TOP w0.381: v1(36.71,168.18) 36.71,168.49 PR77.1
  BOTTOM w0.381: PC34.1 36.71,166.81 v1(36.71,168.18)
P3V3_VDD2: length 5.9
  TOP w0.254: PU22.26 10.92,179.33 10.61,179.63 v5(10.61,180.06)
  TOP w0.381: PR429.1 10.61,180.88 v5(10.61,180.06)
  BOTTOM w0.381: v5(10.61,180.06) 10.61,179.68 v2(10.09,179.16) 8.71,179.16 PC372.1
P3V3_VIN:
  vias: v2(38.41,166.8) v2(38.47,170.61) v2(38.48,169.34) v2(38.49,168.07) v2(40.39,179.96) v2(40.39,178.69) v2(40.39,177.42) v2(40.39,176.15) v2(40.39,174.88) v2(40.39,173.61) v6(36.73,179.76) v6(36.75,178.64) v6(37.61,179.76) v6(37.61,178.66) v6(37.72,172.47) v6(37.72,171.58) v6(38.73,172.47) v6(38.73,171.58) v6(38.88,179.7) v6(38.88,178.55) v6(38.88,177.46) v6(38.88,174.82) v6(38.88,173.68) v6(38.99,176.18)
P3V3_VIN2:
  vias: v2(11.94,182.75) v2(11.94,181.48) v2(11.94,180.21) v2(11.94,178.94) v2(13.46,180.21) v2(13.46,178.94) v2(14.48,192.15) v2(14.48,190.88) v2(14.48,189.61) v2(14.48,188.34) v2(14.48,187.07) v2(14.48,185.8) v6(10.56,192.08) v6(10.59,190.96) v6(11.45,190.98) v6(11.56,192.02) v6(12.06,184.78) v6(12.09,183.9) v6(12.83,192.02) v6(12.85,191) v6(12.85,189.91) v6(12.82,188.5) v6(12.95,187.2) v6(12.95,186.06) v6(12.95,184.86) v6(13,183.9)
P3V3_VSEL: length 3.4
  TOP w0.254: PU2.36 32.23,163.87 31.65,164.45 31.65,164.68 PR79.2
P3V3_VSEL2: length 3.3
  TOP w0.254: PU22.36 6.09,176.24 4.63,177.7 PR422.2
P5V0: length 465.9
  TOP w0.381: v1(292.73,157.98) 292.83,157.89 PR163.1 ; v1(84.68,201.69) 84.55,201.82 PR63.1 ; v1(77.95,191.83) 78.02,191.9 R1057.2 ; PR262.1 234.61,201.34 v1(234.86,201.08) ; v1(217.04,200.66) PR109.1 ; PR159.1 292.75,173.15 v1(292.73,173.17) ; v1(62.99,179.73) C2453.2 U113.5
  T05 w0.381: v1(292.73,173.17) 291.86,173.17 287.06,177.98 267.28,177.98 262.25,183.01 262.25,185.42 260.05,187.63 258.5,187.63 253.09,193.04 249.83,193.04 248.62,194.26 239.7,194.26 236.83,197.13 236.83,199.11 v1(234.86,201.08)
  T07 w0.381: v1(305.81,157.03) 305.39,157.03 301.9,160.53 298.18,160.53 297.02,159.37 293.61,159.37 292.73,158.5 v1(292.73,157.98) ; v1(292.73,173.17) 293.7,174.14 296.9,174.14 298.34,175.58 302.02,175.58 304.88,172.72 v1(305.84,172.72)
  T14 w0.762: v1(52.96,169.93) v1(53.82,169.93)
  T16 w0.381: v1(84.68,201.69) 84.68,202.99 86.66,204.98 94.02,204.98 95.29,203.71 120.17,203.71 123.83,207.37 125.45,207.37 v1(126.24,208.15)
  T18 w0.381: v1(126.24,208.15) 163.22,208.15 168.22,203.15 178.01,203.15 188.71,192.45 214.97,192.45 216.53,194.01 216.53,200.16 v1(217.04,200.66) 217.68,200.66 218.57,199.77 218.57,195.89 221.74,192.72 229.87,192.72 234.95,197.8 234.95,200.99 v1(234.86,201.08)
  BOTTOM w0.381: v1(305.84,172.72) 305.84,172.39 PR314.1 ; PR312.1 304.44,155.66 v1(305.81,157.03) ; U183.5 10.63,33.06 10.88,32.8 C1978.2 v1(11.81,32.13) ; v1(84.68,201.69) 86.94,199.43 86.94,192.61 86.16,191.83 v1(77.95,191.83)
  BOTTOM w0.635: PR155.2 287.53,128.22 288.16,127.58 291.92,127.58 297.98,133.64 297.98,140.93 294.64,144.27 294.64,151.13 292.73,153.04 v1(292.73,157.98) v1(292.73,173.17)
  BOTTOM w1.016: 35.31,87.88 35.31,107.06 34.29,108.08 34.29,122.64 39.36,127.72 41.02,127.72 47.54,134.24 50.17,134.24 52.07,136.14 52.07,168.91
  vias: v1(9.91,26.92) v1(10.67,26.92) v1(35.09,86.71) v1(35.93,86.71) v1(55.88,61.67) v1(56.06,51.11) v1(56.06,50.22) v1(56.7,61.66) v1(77.19,191.83) v1(77.19,190.81) v1(77.95,190.81)
P5V0_EN: length 7.2
  TOP w0.381: PU1.7 81.18,207.95 v1(81.18,207.95)
  BOTTOM w0.381: PR16.2 PR20.1 PC9.1 PC22.1 81.89,209.1 81.18,208.39 v1(81.18,207.95)
P5V0_FB_IN: length 5.4
  TOP w0.381: PC30.1 81.94,210.52 PR64.1 PR61.2 v1(83.44,211.89)
  BOTTOM w0.381: v1(83.44,211.89) 83.8,211.53 83.8,210.39 PR68.1
P5V0_FB_IN_R: length 3
  BOTTOM w0.381: PQ2.3 80.88,209.53 v2(81.79,210.44) 82.82,210.44 82.89,210.36 PR68.2
P5V0_MARGIN_HI: length 4.9
  TOP w0.14: v1(73.03,209.17) 72.82,209.38 PR72.1 PC33.1 PR73.1 PQ3.1
P5V0_MARGIN_LO: length 4.6
  BOTTOM w0.14: PQ2.1 76.8,208.54 v2(76.67,208.41) 76.55,208.29 PR70.1 PC32.1 PR69.1
P5V0_PG: length 92.4
  TOP w0.381: v1(87.5,202.49) 86.66,203.33 PC31.1 PR63.2 PR65.1 PU1.4 ; PR46.2 27.28,164.39 v1(27.48,164.59)
  T03 w0.381: v1(87.5,202.49) 87.5,201.8 79.31,193.61 61.53,193.61 53.06,185.14 33.76,185.14 26.54,177.93 26.54,165.53 v1(27.48,164.59)
P5V0_SS: length 3.8
  TOP w0.381: PU1.5 83.03,206.9 83.03,206.9 83.67,206.9 83.68,206.9 PC28.1 85.36,206.9 v1(85.98,207.52)
P5V0_SW: length 5.9
  TOP w0.381: PU1.2 81.18,205.59
  TOP w0.508: PC21.2 78.33,206.27 PL2.1
  vias: v1(79.47,206.23) v1(79.47,205.34) v2(78.99,204.09) v2(80.39,205.74) v2(80.39,204.09)
P5V0_USB: length 14.2
  TOP w0.508: D61.5 67.61,39.96
  TOP w0.762: 67.61,39.96 66.67,40.89 R12980.2 64.39,43.05 v1(62.29,45.15) 60.24,47.2 C1685.1
  vias: v1(55.63,47.37) v1(55.63,46.1)
P5V0_VBST: length 3.8
  TOP w0.381: PU1.8 80.53,207.6 80.47,207.66
  TOP w0.508: 80.47,207.66 79.73,208.4 PR57.1
P5V0_VFB: length 17.3
  TOP w0.381: PU1.6 81.83,208.24 81.38,208.69 PC30.2 PR64.2 83.86,209.15 PR66.1 PR67.1 84,211.08 84.33,211.41 84.33,212.34 83.57,213.11 79.87,213.11 v1(79.5,212.74) 79.28,212.96 PR71.1
  BOTTOM w0.381: PQ2.2 78.08,211.31 v1(79.5,212.74)
P5V0_VFB_R: length 2.5
  TOP w0.381: PR71.2 v1(76.98,212.96) 76.48,212.47 PQ3.3
P5V0_VIN:
  vias: v1(82.14,198.94) v1(82.7,202.37) v1(83,198.94) v1(83.31,201.61) v1(83.66,199.45) v2(82.3,197.99) v2(83.57,197.99) v2(84.29,200.82) v2(84.84,197.99) v2(84.96,199.52)
P5V0_VOUT: length 34.1
  TOP w0.381: v1(80.9,210.95) 81.2,211.25 PR61.1
  BOTTOM w0.381: v1(80.9,210.95) 80.9,212.98 79.83,214.05 72.63,214.05 70.23,211.65 v2(70.23,201.68) 70.23,195.45 71.32,194.37 v1(72.49,194.37)
  vias: v1(72.49,196.02) v1(72.62,201.22) v1(72.62,199.95) v1(72.62,198.18) v1(72.66,197.11) v1(73.5,194.37) v1(74.16,201.83) v2(72.92,191.94) v2(73.48,193.12)
P5V_SB: length 47.9
  TOP w0.381: PQ21.5 60.83,205.84 R12428.1 ; v1(46.99,195.59) 47.44,195.14 R12824.2 ; R12283.2 51.09,130.25 v1(50.37,130.25) ; R12825.2 v1(46.85,200.03)
  T14 w0.381: v1(55.03,199.29) 54.74,198.99 54.74,195.3 v1(55.76,194.29)
  T16 w0.381: v1(50.37,130.25) 49.07,130.25 44.96,134.37 35.43,134.37 31.88,137.92 31.88,144.91 30.73,146.05 v1(28.57,146.05)
  BOTTOM w0.381: PR386.1 v1(28.06,148.07) ; R1280.2 55.06,199.31 v1(55.03,199.29) ; v1(55.76,194.29) 55.59,194.45 R1279.2
  vias: v1(28.94,147.39) v1(29.32,148.15) v1(29.83,147.39) v1(30.21,148.15) v1(30.72,147.39) v1(31.1,148.15) v1(65.66,202.62) v1(65.66,201.73) v1(65.66,200.85) v1(66.42,202.62) v1(66.42,201.73) v1(66.42,200.85) v1(96.14,205.87) v1(96.9,204.99) v2(67.47,206.8) v2(67.47,205.53) v2(67.47,204.26) v2(67.47,202.99) v2(68.74,206.8) v2(68.74,205.53) v2(68.74,204.26) v2(68.74,202.99)
P5V_SB_IN:
  vias: v1(53.11,207.37) v1(53.24,208.25) v1(53.95,207.39) v1(54.08,208.28) v1(54.81,207.37) v1(54.94,208.25) v1(62.51,209.63) v1(62.48,208.76) v1(62.51,207.92) v1(63.25,208.76) v1(63.27,209.63) v1(63.27,207.92) v2(59.87,210.04) v2(59.87,208.77) v2(59.93,207.45) v2(61.14,210.04) v2(61.14,208.77) v2(61.2,207.45)
P10V_H2_EN_R: length 2.7
  TOP w0.254: PR485.1 79.41,187.72 77.7,186.01 PU24.8
P10V_H2_FB: length 14.3
  TOP w0.14: PR501.1 74.18,187.57 v1(74.74,187.01)
  TOP w0.254: PR482.1 75.82,181.74 v1(76.33,182.25) 76.7,182.62 PU24.5
  T05 w0.117: v1(76.33,182.25) 76.33,185.42 v1(74.74,187.01)
  BOTTOM w0.14: PQ25.2 72.92,183.26 v2(74.17,183.26) 74.41,183.02 PR483.2
  BOTTOM w0.254: v1(76.33,182.25) 76.16,182.07 PC417.2 PR483.2
P10V_H2_MODE: length 2.9
  TOP w0.254: PR489.1 PR487.2 76.6,187.05 76.7,186.95 PU24.10
P10V_H2_SW: length 3.4
  TOP w0.305: v1(75.41,184.46) PU24.2
  BOTTOM w0.508: v1(75.41,184.46) 76.02,185.07 PR484.1
P10V_H2_VIN: length 2.3
  TOP w0.305: v4(78.98,185.6) 78.34,184.96 PU24.1
  vias: v2(78.99,190.25) v2(79.12,187.58) v2(80.39,190.25) v4(79.25,186.33) v4(80.29,188.92) v4(80.29,188.16) v6(81.9,186.24) v6(81.9,185.22)
P10V_H2_VMG-LOW1_R: length 5.8
  TOP w0.381: v1(71.08,184.83) PR499.1 71.36,186.57 PC434.1 PR496.1
  BOTTOM w0.14: v1(71.08,184.83) 70.54,184.29 PQ25.1
P10V_H2_VMG-LOW2_R: length 3.7
  TOP w0.381: v1(71.08,188.13) PR497.1 71.97,187.43 PC433.1 PR498.1
  BOTTOM w0.14: v1(71.08,188.13) 71.18,188.02 PQ24.1
P10V_H2_VOS: length 15.1
  TOP w0.254: v1(73.8,186.94) 74.18,186.56 PR500.1 ; PU24.6 77.2,182.23 76.58,181.61 v1(76.58,181.36) 76.83,181.1 77.72,181.1 77.98,180.84 PR486.1
  BOTTOM w0.14: v1(76.58,181.36) 76.85,181.63 76.85,182.94 76.2,183.59 74.98,183.59 74.04,184.53 v2(74.04,185.29) 74.04,186.7 v1(73.8,186.94)
  BOTTOM w0.254: PR483.1 PC417.1 76.49,181.26 v1(76.58,181.36)
P10V_H2_VOS_R: length 6.3
  TOP w0.254: v1(72.89,184.57) 73.76,185.45 PR500.2
  BOTTOM w0.14: v1(72.89,184.57) 72.84,184.57 71.53,183.26 PQ25.3
P12V: length 273.1
  TOP w0.381: R12826.1 v1(32.12,18.92) ; v1(27.29,12.52) C2423.1 U104.8 ; R12968.2 65.15,129.16 v1(66.04,130.05) ; PR489.2 77.58,189.34 78.61,190.37 v6(81.82,190.37)
  T05 w0.381: v1(66.04,130.05) 66.04,130.68 66.93,131.57 66.93,133.46 65.15,135.23 65.15,138.7 64.01,139.84 64.01,152.03 65.04,153.07 J1.B2
  T14 w0.762: v6(7.37,185.98) 8.82,184.53 8.82,179.73 7.15,178.05 7.15,167.93 3.33,164.11 3.33,151.51 4.22,150.62 9.53,150.62 12.57,147.57 12.57,142.75 8.38,138.56 4.57,138.56 3.05,137.03 3.05,106.86 5.85,104.06 5.85,88.99 5.21,88.35 5.21,70.42 7.22,68.41 11.09,68.41 15.63,63.87 15.63,53.73 9.42,47.52 6.3,47.52 3.04,44.27 3.04,22.36 7.49,17.91 15.11,17.91 18.94,14.08 21.49,14.08 21.98,14.57 24.16,14.57 26.21,12.52 v1(27.29,12.52)
  T18 w0.508: v1(32.12,18.92) 32.13,18.92 32.64,18.41 32.64,16.18 29.82,13.35 28.13,13.35 v1(27.29,12.52)
  BOTTOM w0.381: PR11.1 v1(83.77,202.53) ; PR150.2 290.62,128.63 v1(290.63,128.64) ; R1061.2 v1(117.86,193.42)
  vias: v1(48.42,168.1) v1(48.42,167.34) v1(48.42,166.53) v1(49.31,168.1) v1(49.31,167.34) v1(49.31,166.53) v1(82.14,194.87) v1(82.14,193.99) v1(83.16,194.87) v1(83.16,193.99) v1(84.3,194.87) v1(84.3,193.99) v1(85.32,194.87) v1(85.32,193.99) v1(197.64,195.93) v1(197.64,194.92) v1(198.53,195.93) v1(198.53,194.92) v1(214.2,194.86) v1(214.27,194.08) v1(215.43,194.85) v1(215.41,194.08) v1(234.1,195.75) v1(234.1,194.86) v1(234.86,195.75) v1(234.86,194.86) v1(252.47,195.89) v1(252.45,195.17) v1(253.24,195.89) v1(253.22,195.17) v1(294.66,124.76) v1(294.66,123.74) v1(295.52,124.76) v1(295.52,123.74) v1(297.05,178.44) v1(297.05,177.17) v1(297.43,182.81) v1(297.43,181.92) v1(298.19,178.44) v1(298.19,177.17) v1(298.58,182.81) v1(298.58,181.92) v1(299.34,178.44) v1(299.34,177.17) v1(299.72,182.81) v1(299.72,181.92) v1(306.65,186.73) v1(306.65,185.84) v1(307.42,186.74) v1(307.42,185.85) v1(308.18,186.74) v1(308.18,185.85) v1(308.94,186.74) v1(308.94,185.85) v2(32.08,177.3) v2(32.08,176.03) v2(32.08,174.76) v2(32.08,173.49) v2(33.35,177.3) v2(33.35,176.03) v2(33.35,174.76) v2(33.35,173.49) v2(157.2,207.97) v2(157.2,206.7) v2(158.47,207.97) v2(158.47,206.7) v2(159.74,207.97) v2(159.74,206.7) v2(161.01,207.97) v2(161.01,206.7) v2(162.28,207.97) v2(162.28,206.7) v2(163.55,207.97) v2(163.55,206.7) v2(300.85,181.14) v2(300.85,179.87) v2(300.89,178.4) v2(300.89,177.13) v2(302.12,181.14) v2(302.12,179.87) v2(302.16,178.4) v2(302.16,177.13) v2(303.39,181.14) v2(303.39,179.87) v2(303.43,178.4) v2(303.43,177.13) v2(304.66,181.14) v2(304.66,179.87) v2(304.7,178.4) v2(304.7,177.13) v2(305.93,181.14) v2(305.93,179.87) v2(305.97,178.4) v2(305.97,177.13) v2(307.2,181.14) v2(307.2,179.87) v2(307.24,178.4) v2(307.24,177.13) v3(169.67,201.86) v3(169.67,200.72) v3(169.67,199.45) v3(169.67,198.18) v3(170.69,201.86) v3(170.69,200.72) v3(170.69,199.45) v3(170.69,198.18) v3(173.61,201.86) v3(173.61,200.72) v3(173.61,199.45) v3(173.61,198.18) v3(174.62,201.86) v3(174.62,200.72) v3(174.62,199.45) v3(174.62,198.18) v6(3.94,190.05) v6(3.94,188.4) v6(3.94,187.25) v6(3.94,185.98) v6(5.08,190.05) v6(5.08,188.4) v6(5.08,187.25) v6(5.08,185.98) v6(6.22,190.05) v6(6.22,188.4) v6(6.22,187.25) v6(6.22,185.98) v6(7.37,190.05) v6(7.37,188.4) v6(7.37,187.25) v6(34.3,188.22) v6(34.3,187.12) v6(34.25,184.13) v6(34.25,182.98) v6(35.45,188.22) v6(35.45,187.12) v6(35.39,184.08) v6(35.39,182.98) v6(36.54,188.22) v6(36.54,187.12) v6(36.54,184.08) v6(36.54,182.98) v6(82.72,189.74) v6(82.84,190.89) v6(83.76,189.67) v6(83.91,190.71)
VBAT_VSENSE_IN: length 122.4
  TOP w0.14: Q56.3 R12700.2 v1(162.22,142.03) ; U154.L5 v4(64.13,118.53)
  T07 w0.117: v1(128.31,134.4) 124.39,138.32 115.43,138.32 114.43,139.32 109.84,139.32 108.32,137.8 99.41,137.8 95.48,133.87 95.48,131.42 90.93,126.87 87.38,126.87 86.74,126.24 81,126.24 79.98,125.22 78.61,125.22 77.72,124.33 73.96,124.33 70.96,121.33 69.09,121.33 68.29,120.53 67.96,120.53 67.73,120.29 67.73,117.64 67.31,117.22 63.88,117.22 63.63,117.47 63.63,118.03 v4(64.13,118.53)
  T14 w0.117: v1(128.31,134.4) 128.85,133.86 130.91,133.86 134.2,137.16 143.09,137.16 145.88,139.95 145.88,140.97 148.13,143.22 161.04,143.22 v1(162.22,142.03)
VCC_GNSS_RF: length 2.5
  TOP w0.381: v1(4.23,31.59) 4.32,31.68 U124.9
  BOTTOM w0.381: R12903.2 4.35,31.71 v1(4.23,31.59)
VDD_CORE: length 239.8
  TOP w0.305: PU5.5 296.79,170.48 296.54,170.22
  TOP w0.381: U1.U16 v4(217.86,117.5) ; U1.AC26 v4(206.86,124.5) ; U1.AB25 v4(207.86,123.5) ; U1.T23 v4(209.86,116.5) ; U1.AA26 v4(206.86,122.5) ; U1.Y13 v4(220.86,121.5) ; U1.W22 v4(210.86,119.5) ; U1.AD21 v4(211.86,125.5) ; U1.T19 v4(214.86,116.5) ; U1.P15 v4(218.86,114.5) ; U1.AD19 v4(214.86,125.5) ; U1.AE20 v4(212.86,126.5) ; U1.AF23 v4(209.86,127.5) ; U1.V23 v4(209.86,118.5) ; U1.AB15 v4(218.86,123.5) ; U1.AD17 v4(216.86,125.5) ; R1056.2 v1(114.78,182.81) ; U1.AB17 v4(216.86,123.5) ; U1.R26 v4(206.86,115.5) ; U1.R22 v4(210.86,115.5) ; U1.AB27 v4(205.86,123.5) ; U1.AA14 v4(219.86,122.5) ; U1.AE18 v4(215.86,126.5) ; U1.W12 v4(221.86,119.5) ; U1.P21 v4(211.86,114.5) ; U1.R14 v4(219.86,115.5) ; U1.AB19 v4(214.86,123.5) ; U1.V11 v4(222.86,118.5) ; U1.Y11 v4(222.86,121.5) ; U1.T11 v4(222.86,116.5) ; U1.R16 v4(217.86,115.5) ; U1.P11 v4(222.86,114.5) ; U1.W26 v4(206.86,119.5) ; U1.R18 v4(215.86,115.5) ; U1.P19 v4(214.86,114.5) ; v1(294.76,154.7) 294.77,154.69 294.77,154.65 PU6.5 ; U1.P17 v4(216.86,114.5) ; U1.AG12 v4(221.86,128.5) ; U1.AA12 v4(221.86,122.5) ; U1.W14 v4(219.86,119.5) ; U1.AA16 v4(217.86,122.5) ; U1.AC28 v4(204.86,124.5) ; U1.P27 v4(205.86,114.5) ; U1.AE22 v4(210.86,126.5) ; U1.W24 v4(208.86,119.5) ; U1.Y21 v4(211.86,121.5) ; U1.AF15 v4(218.86,127.5) ; U1.AD13 v4(220.86,125.5) ; U1.Y15 v4(218.86,121.5) ; PR139.1 279.34,137.73 v1(279.91,138.3) ; 296.54,170.22 v1(293.89,170.22) ; U1.AE24 v4(208.86,126.5) ; U1.AD23 v4(209.86,125.5) ; U1.W16 v4(217.86,119.5) ; U1.AB13 v4(220.86,123.5) ; U1.R24 v4(208.86,115.5) ; U1.AE14 v4(219.86,126.5) ; U1.AG11 v4(222.86,128.5) ; U1.AC20 v4(212.86,124.5) ; U1.AB21 v4(211.86,123.5) ; U1.V15 v4(218.86,118.5) ; U1.AF13 v4(220.86,127.5) ; U1.AD15 v4(218.86,125.5) ; U1.R20 v4(212.86,115.5) ; U1.U18 v4(215.86,117.5) ; U1.R12 v4(221.86,115.5) ; U1.AA22 v4(210.86,122.5) ; U1.V17 v4(216.86,118.5) ; U1.AC16 v4(217.86,124.5) ; U1.AC24 v4(208.86,124.5) ; U1.U20 v4(212.86,117.5) ; U1.AC22 v4(210.86,124.5) ; U1.AE16 v4(217.86,126.5) ; U1.P13 v4(220.86,114.5) ; U1.AA20 v4(212.86,122.5) ; U1.W20 v4(212.86,119.5) ; U1.AG16 v4(217.86,128.5) ; U1.AE12 v4(221.86,126.5) ; U1.U22 v4(210.86,117.5) ; U1.AB23 v4(209.86,123.5) ; U1.AC14 v4(219.86,124.5) ; U1.P25 v4(207.86,114.5) ; U1.AA18 v4(215.86,122.5) ; U1.V27 v4(205.86,118.5) ; U1.AG14 v4(219.86,128.5) ; U1.T15 v4(218.86,116.5) ; U1.V21 v4(211.86,118.5) ; U1.Y23 v4(209.86,121.5) ; U1.AA24 v4(208.86,122.5) ; U1.T27 v4(205.86,116.5) ; U1.T17 v4(216.86,116.5) ; U1.T21 v4(211.86,116.5)
  T03 w0.381: v1(186.58,162.44) 174.97,162.44 154.4,183.01 147.32,183.01 145.8,184.53 143.64,184.53 142.75,185.42 135.89,185.42 134.11,183.64 119.54,183.64 119.12,183.22 119.12,182.62 118.56,182.06 115.53,182.06 v1(114.78,182.81)
  T07 w0.381: v1(293.89,170.22) 289.16,170.22 v6(288.08,169.14) ; v6(287.82,153.14) 289.38,154.7 v1(294.76,154.7)
  BOTTOM w0.381: v4(217.86,126.5) U1.AE16 C379.1 ; v4(212.86,124.5) 213.28,124.08 C291.1 ; C299.1 U1.Y23 v4(209.86,121.5) ; v4(221.86,126.5) U1.AE12 C371.1 ; v4(219.86,128.5) U1.AG14 C376.1 ; C397.1 214.44,116.91 v4(214.86,116.5) ; v4(218.86,118.5) 218.44,118.91 C279.1 ; C355.2 U1.U18 v4(215.86,117.5) ; v4(215.86,126.5) 215.78,126.5 C265.1 ; C400.1 218.44,116.91 v4(218.86,116.5) ; v4(221.86,119.5) U1.V11 C251.1 ; v4(222.86,121.5) 222.44,121.08 C375.2 ; v4(221.86,122.5) U1.AA12 C396.2 ; v4(206.86,124.5) 206.36,124 C297.2 ; v4(216.86,123.5) 216.44,123.08 C270.1 ; C393.1 216.44,116.91 v4(216.86,116.5) ; C352.1 U1.T27 v4(205.86,116.5) ; C358.2 218.44,127.08 v4(218.86,127.5) ; v4(211.86,114.5) 212.28,114.91 C328.1 U1.P21 v4(212.86,115.5) ; C246.2 205.36,119 v4(205.86,118.5) ; v4(212.86,119.5) 212.44,119.08 C333.1 ; v4(220.86,114.5) U1.P13 C380.2 ; C409.2 U1.AA14 v4(219.86,122.5) ; v4(217.86,128.5) U1.AG16 C266.1 ; C332.2 217.44,117.91 v4(217.86,117.5) ; C334.1 U1.V23 v4(209.86,118.5) ; v4(207.86,123.5) U1.AB25 C268.2 ; v4(218.86,114.5) 218.44,114.91 C253.1 ; v4(210.86,117.5) 210.44,117.08 C295.2 ; v4(208.86,119.5) 209.28,119.91 C354.1 ; C391.2 216.44,125.08 v4(216.86,125.5) ; C356.1 209.28,122.08 v4(208.86,122.5) ; C414.2 223.28,116.08 v4(222.86,116.5) ; v4(206.86,119.5) 206.44,119.91 C250.2 ; v4(207.86,114.5) U1.P25 C359.1 208.44,115.08 v4(208.86,115.5) ; v4(221.86,128.5) U1.AG12 C248.1 ; v4(212.86,122.5) 213.28,122.08 C301.1 ; C247.1 U1.AE14 v4(219.86,126.5) ; v4(210.86,115.5) U1.R22 C329.1 211.44,116.08 v4(211.86,116.5) ; v4(212.86,126.5) 213.28,126.08 C416.1 ; v4(219.86,119.5) 219.44,119.91 C372.2 ; C293.1 U1.Y21 v4(211.86,121.5) ; v4(217.86,115.5) 217.44,115.91 C411.1 ; v4(211.86,123.5) U1.AB21 C271.2 ; C417.2 218.44,125.08 v4(218.86,125.5) ; v4(210.86,119.5) 211.28,119.91 C336.1 ; C418.1 223.28,118.91 v4(222.86,118.5) ; v4(217.86,119.5) 217.44,119.91 C327.2 ; C415.1 211.36,127 v4(210.86,126.5) ; C398.1 U1.P17 v4(216.86,114.5) ; v4(220.86,125.5) 220.44,125.08 C394.2 ; v4(220.86,123.5) 220.44,123.08 C373.1 ; v4(208.86,124.5) 209.28,124.08 C249.2 ; C395.1 U1.R18 v4(215.86,115.5) ; v4(219.86,115.5) U1.R14 C381.1 ; v4(217.86,124.5) U1.AC16 C269.1 ; v4(222.86,128.5) U1.AG11 C378.1 ; C330.2 215.28,123.08 v4(214.86,123.5) 214.44,123.91 C272.1 ; v4(218.86,123.5) 218.44,123.08 C267.1 ; v4(209.86,125.5) U1.AD23 C296.1 ; v4(220.86,127.5) 220.44,127.08 C399.2 ; v4(211.86,118.5) U1.U22 C331.1 ; C350.2 215.78,122.5 v4(215.86,122.5) ; v4(210.86,122.5) 211.28,122.08 C294.1 ; v4(209.86,123.5) U1.AB23 C300.2 ; v4(210.86,124.5) 211.28,124.08 C335.2 ; C298.1 U1.AD21 v4(211.86,125.5) ; C353.2 222.44,114.91 v4(222.86,114.5) ; v4(212.86,117.5) 212.44,117.08 C278.2 ; C252.2 205.44,114.91 v4(205.86,114.5) ; C413.1 210.28,127.91 v4(209.86,127.5) ; C273.1 218.44,121.08 v4(218.86,121.5) ; C392.1 216.44,118.91 v4(216.86,118.5) ; C292.2 U1.AC28 v4(204.86,124.5) ; C374.1 U1.AC14 v4(219.86,124.5) ; v4(220.86,121.5) 220.44,121.08 C412.2 ; v4(208.86,126.5) 209.36,127 C351.1 ; C377.2 221.44,115.08 v4(221.86,115.5) ; v4(214.86,114.5) 214.44,114.91 C410.1 ; C277.2 209.44,116.91 v4(209.86,116.5) ; v4(206.86,122.5) 207.28,122.08 C357.1
  BOTTOM w0.508: v6(279.32,146.66) 279.32,138.9 v1(279.91,138.3)
  vias: v1(190.17,100.98) v1(190.88,100.97) v1(191.6,100.96) v1(192.31,100.96) v1(193.17,100.97) v1(236.6,112.02) v1(236.6,111.18) v1(237.36,112.02) v1(237.36,111.18) v1(238.12,112.02) v1(238.12,111.18) v1(239.37,108.34) v1(239.37,107.5) v1(240.13,108.34) v1(240.13,107.5) v1(241.02,108.34) v1(241.02,107.5) v1(242.16,99.52) v1(242.92,99.52) v1(243.68,99.52) v1(244.15,108.66) v1(244.15,107.82) v1(244.15,107.06) v1(244.15,106.3) v1(244.44,99.52) v1(244.99,108.66) v1(244.99,107.82) v1(244.99,107.06) v1(244.99,106.3) v1(245.21,99.52) v1(245.88,108.66) v1(245.88,107.82) v1(245.88,107.06) v1(245.88,106.3) v1(246.1,99.52) v2(269.41,160.1) v2(269.41,158.83) v2(269.41,157.56) v2(269.41,156.29) v2(269.41,155.02) v2(269.41,153.75) v2(269.41,152.48) v2(269.41,151.21) v2(269.42,149.87) v2(269.42,148.6) v2(270.68,160.1) v2(270.68,158.83) v2(270.68,157.56) v2(270.68,156.29) v2(270.68,155.02) v2(270.68,153.75) v2(270.8,150.87) v2(270.8,149.6) v2(270.81,148.25) v2(270.81,146.98) v2(272.08,148.25) v2(272.08,146.98) v2(273.35,148.25) v2(273.35,146.98) v2(285.24,150.89) v2(285.24,149.62) v2(285.24,148.35) v2(285.24,147.08) v2(285.66,166.82) v2(285.66,165.55) v2(286.51,150.89) v2(286.51,149.62) v2(286.51,148.35) v2(286.51,147.08) v2(286.93,166.82) v2(286.93,165.55) v2(287.78,150.89) v2(287.78,149.62) v2(287.78,148.35) v2(287.78,147.08) v2(288.2,166.82) v2(288.2,165.55) v4(189.74,106.46) v4(189.74,105.78) v4(190.37,106.84) v4(190.37,106.16) v4(190.37,105.41) v4(192.61,109.04) v4(192.95,108.44) v4(193.25,109.3) v6(269.25,168.83) v6(269.25,167.81) v6(269.75,164.64) v6(269.75,163.62) v6(270.17,167.49) v6(270.56,162.31) v6(270.56,161.29) v6(270.93,168.13) v6(271.04,164.59) v6(271.04,163.57) v6(271.53,153.11) v6(271.53,152.09) v6(271.57,167.49) v6(272.33,168.13) v6(272.25,150.73) v6(272.25,149.71) v6(272.46,166.22) v6(272.54,153.67) v6(272.84,152.63) v6(272.92,163.07) v6(272.97,167.49) v6(273.18,151.64) v6(273.73,168.13) v6(273.85,166.22) v6(273.85,163.55) v6(273.85,152.63) v6(273.94,149.99) v6(274.27,153.37) v6(274.49,167.49) v6(274.49,162.92) v6(274.49,151.11) v6(274.57,148.97) v6(274.95,148.08) v6(274.95,147.07) v6(275.25,168.13) v6(275.25,151.74) v6(275.38,166.22) v6(275.38,164.44) v6(275.38,149.84) v6(275.89,167.49) v6(275.89,151.11) v6(276.19,148.12) v6(276.19,147.11) v6(276.52,164.44) v6(276.65,168.13) v6(276.65,151.74) v6(276.78,166.22) v6(276.78,149.84) v6(277.28,167.49) v6(277.28,151.11) v6(277.63,148.12) v6(277.63,147.11) v6(277.79,164.44) v6(278.05,151.87) v6(278.17,166.22) v6(278.3,149.84) v6(278.43,163.17) v6(278.93,164.32) v6(279.15,150.88) v6(279.19,148.7) v6(279.32,163.17) v6(279.32,147.68) v6(279.57,169.14) v6(279.57,153.27) v6(280.2,168.38) v6(280.2,164.44) v6(280.2,152.51) v6(280.46,148.7) v6(280.46,147.68) v6(280.59,146.66) v6(280.71,169.14) v6(280.71,153.27) v6(281.35,168.38) v6(281.35,164.44) v6(281.35,152.51) v6(281.6,148.7) v6(281.56,147.83) v6(281.98,169.14) v6(281.98,153.27) v6(282.62,168.38) v6(282.62,164.44) v6(282.62,152.51) v6(282.87,148.7) v6(282.88,147.85) v6(283.21,153.29) v6(283.81,167.07) v6(283.81,166.05) v6(283.76,164.32) v6(283.76,163.3) v6(284.35,152.15) v6(285.41,153.14) v6(285.41,152.12) v6(285.5,155.83) v6(285.5,154.56) v6(285.62,161.16) v6(285.58,157.25) v6(285.67,169.14) v6(285.67,168.13) v6(285.67,164.32) v6(285.67,163.3) v6(285.73,159.53) v6(286.5,155.83) v6(286.5,154.56) v6(286.55,153.14) v6(286.55,152.12) v6(286.7,157.25) v6(286.81,169.14) v6(286.81,168.13) v6(286.77,161.22) v6(286.85,159.53) v6(287.23,164.22) v6(287.23,163.2) v6(287.52,155.83) v6(287.52,154.56) v6(287.72,157.25) v6(287.79,161.22) v6(287.82,152.12) v6(287.87,159.53) v6(288.08,168.13)
VDD_CORE_ADDR_TRISE: length 6.3
  TOP w0.254: v1(294.77,136.96) 294.08,136.96 293.58,137.45 PR130.2 292.45,137.89 292.1,137.54 PU4.28
  BOTTOM w0.381: PR136.1 294.78,136.98 v1(294.77,136.96) 294.39,136.58 v2(294.39,135.89)
VDD_CORE_BOOT1: length 3.6
  TOP w0.254: PU5.9 303.95,170.98 304.7,171.73 PC95.1
VDD_CORE_BOOT2: length 2.9
  TOP w0.254: PU6.9 303.3,155.15 304.01,155.86 PC125.1
VDD_CORE_BOOTR1: length 3.6
  TOP w0.254: PU5.8 304.17,170.48 v1(304.67,169.98) 305.3,169.98 PR158.1
VDD_CORE_BOOTR2: length 2.7
  TOP w0.254: PR162.1 304.68,154.65 PU6.8
VDD_CORE_COMP: length 3.5
  TOP w0.254: PU4.11 284.74,133.23 v1(284.48,132.97) 284.19,132.97 PR144.1 PC86.1
VDD_CORE_COMP_RC: length 1.5
  TOP w0.254: PR144.2 v1(282.29,132.52) 281.64,132.52 PC88.1
VDD_CORE_CSP1: length 48.4
  TOP w0.254: PU4.3 284.1,137.54 v1(283.97,137.67) ; v1(295.9,172.9) 296.82,171.98 PU5.2
  T05 w0.254: v1(283.97,137.67) 282.7,138.94 282.7,144.24 284.53,146.07 288.57,146.07 289.87,147.36 289.87,169.63 292.79,172.55 295.55,172.55 v1(295.9,172.9)
VDD_CORE_CSP2: length 34.2
  TOP w0.254: PU6.2 296.78,156.15 v1(295.26,157.67) ; v1(283,137.11) 283.08,137.04 PU4.4
  T05 w0.254: v1(283,137.11) 283.08,137.04 284.36,137.04 285.5,138.18 285.5,143.59 286.09,144.18 289.39,144.18 291.4,146.2 291.4,155.23 293.85,157.67 v1(295.26,157.67)
VDD_CORE_CSP3: length 2.4
  TOP w0.254: PR133.2 283.49,135.79 v1(283.97,136.27) 284.24,136.54 PU4.5
VDD_CORE_EN-FCCM1: length 6.5
  TOP w0.254: PU5.11 302.89,171.98 303.15,172.23 v1(303.15,173.28) 303.15,174.24 303.15,174.24 PR157.2
  BOTTOM w0.14: v2(304.93,173.01) 304.66,173.28 v1(303.15,173.28)
  BOTTOM w0.254: v1(303.15,173.28) 303.15,172.7 PC101.1
VDD_CORE_EN-FCCM2: length 5.6
  TOP w0.254: PR161.2 303.34,158.27 303.09,158.01 v1(303.09,157.35) 303.09,156.41 302.84,156.15 PU6.11
  BOTTOM w0.14: v2(304.17,158) 303.73,158 v1(303.09,157.35)
  BOTTOM w0.254: v1(303.09,157.35) 302.49,156.75 PC365.1
VDD_CORE_ENABLE: length 5.6
  TOP w0.254: PU4.23 292.19,135.04 292.87,134.36 PR138.1 v1(293.48,133.55)
  BOTTOM w0.254: PC84.1 293.48,133.93 v1(293.48,133.55)
VDD_CORE_F-MAX: length 3.4
  TOP w0.254: PU4.32 v1(289.95,140.88) PR124.1 291.51,141.51 PR120.2
VDD_CORE_IMON: length 3.7
  TOP w0.254: PU4.2 284.54,138.04 v1(283.64,138.95) 283.51,139.08 PC83.1 PR132.1
VDD_CORE_IMON_R: length 1.6
  TOP w0.381: PR137.1 v1(281.76,137.41) 281.76,137.92 PR132.2
VDD_CORE_ISUM: length 2.8
  TOP w0.254: PR148.1 284.86,131.6 285.47,132.21 v1(285.5,132.21) 286.07,132.21 286.45,132.58 PU4.12
VDD_CORE_LSET1: length 2.3
  TOP w0.254: v1(296.36,171.48) 296.36,171.48 PU5.3
  BOTTOM w0.381: PR372.1 296.36,171.72 v1(296.36,171.48)
VDD_CORE_LSET2: length 4.7
  TOP w0.254: PU6.3 296.4,155.65 v1(295.91,156.14)
  BOTTOM w0.14: v1(295.91,156.14) 295.17,156.14 v2(294.75,156.56)
  BOTTOM w0.254: v1(295.91,156.14) 296.04,156.27 297.55,156.27 PR396.1
VDD_CORE_O-USR: length 5.8
  TOP w0.254: PR128.2 293.84,139.95 293.58,140.21 PR134.1 292.98,140.58 291.83,139.43 v1(291.4,139.43) 291.26,139.28 PU4.30
VDD_CORE_OCL-R: length 4.3
  TOP w0.254: PU4.1 285.14,139.17 284.8,139.51 v1(284.78,139.51) 284.78,139.52 284.28,140.03 PR131.2 PR127.2
VDD_CORE_PMB_ALERT_L: length 22.8
  TOP w0.254: PU4.25 293.02,136.04 v1(293.24,135.82) 294.97,135.82 PR153.2
  TOP w0.381: v1(304.18,137.09) PJ1.8
  T05 w0.381: v1(304.18,137.09) 302.05,137.09 301.53,137.61 298.26,137.61 295.2,134.55 294.9,134.55 294.88,134.54 293.35,134.54 292.98,134.92 292.98,135.55 v1(293.24,135.82)
  BOTTOM w0.381: v1(304.18,137.09) 305.04,137.09 PR122.1
VDD_CORE_PMB_CLK: length 23.5
  TOP w0.254: PU4.24 292.63,135.54 292.99,135.18 v1(293.62,135.18) 294.67,135.18 PR152.2
  TOP w0.381: PJ1.9 304.94,139.63 v1(304.87,139.56)
  T05 w0.381: v1(293.62,135.18) 294.94,135.18 298.11,138.36 298.11,139.33 298.82,140.03 304.4,140.03 v1(304.87,139.56)
  BOTTOM w0.381: v1(304.87,139.56) 305.96,139.56 PR337.2 ; v1(293.62,135.18) 294.4,134.41 v2(295.02,134.41)
VDD_CORE_PMB_DIO: length 18
  TOP w0.254: PR154.2 293.93,136.35 293.74,136.54 v1(293.45,136.54) PU4.26
  TOP w0.381: v1(300.92,140.81) 300.9,140.79 PJ1.10
  T05 w0.381: v1(300.92,140.81) 297.95,140.81 297.16,140.01 294.99,140.01 293.88,138.9 293.88,136.96 v1(293.45,136.54)
  BOTTOM w0.381: PR338.2 301.49,141.38 v1(300.92,140.81)
VDD_CORE_PWM1: length 54.9
  TOP w0.254: PU4.38 286.95,140.44 v1(287.57,141.07)
  TOP w0.381: v1(306.35,173.54) 305.59,173.54 PR397.1
  T05 w0.381: v1(287.57,141.07) 288.95,141.07 289.43,141.54 295,141.54 295.91,142.46 306.16,142.46 307.72,144.02 307.72,172.17 v1(306.35,173.54)
VDD_CORE_PWM1_R: length 6.6
  TOP w0.254: PU5.10 302.98,171.48 v1(303.84,172.34) 304.27,172.77 PR397.2
  BOTTOM w0.254: v1(303.84,172.34) PR314.2 303.84,171.07 303.84,171.07 303.84,170.43 303.46,170.05 PR315.1
VDD_CORE_PWM2: length 37.9
  TOP w0.254: PU4.37 287.45,140.1 288.59,141.23 v1(288.59,141.78)
  TOP w0.381: v1(305.82,158) 305.7,158 PR374.1
  T05 w0.381: v1(288.59,141.78) 289.18,142.37 292.83,142.37 293.21,142.75 293.21,142.76 293.83,143.38 305.81,143.38 307.09,144.66 307.09,157.15 306.25,157.99 305.83,157.99 v1(305.82,158)
VDD_CORE_PWM2_R: length 6.6
  TOP w0.254: PU6.10 303.04,155.65 303.72,156.33 v1(303.72,156.61) 303.72,157.02 303.98,157.27 PR374.2
  BOTTOM w0.254: v1(303.72,156.61) 303.63,156.52 PR312.2 302.6,154.87 PR313.1
VDD_CORE_RESET_L: length 5.7
  TOP w0.254: PR142.1 293.11,132.6 292.48,133.22 v1(292.48,133.66) 292.1,134.04 PU4.21
  BOTTOM w0.14: PC364.1 291.57,132.23 TP120.1
  BOTTOM w0.254: PC364.1 292.06,133.24 v1(292.48,133.66)
VDD_CORE_SKIP#NVM: length 2.2
  TOP w0.254: PR123.1 286,141.19 v1(286.39,140.8) 286.45,140.74 PU4.39
VDD_CORE_SLEW_MODE: length 5.3
  TOP w0.254: PU4.29 291.96,138.04 292.35,138.43 292.35,138.81 v1(292.63,139.08) 292.75,139.21 PR135.1 293.58,138.81 293.84,138.56 295.07,138.56 PR129.2
VDD_CORE_SW1: length 2.6
  TOP w0.508: 293.2,163.34 PR160.1
VDD_CORE_SW2: length 2.6
  TOP w0.508: PR164.1 293.17,147.44
VDD_CORE_TSEN: length 56.4
  TOP w0.254: v1(284.11,140.66) PR126.2 PC82.2 285.05,140.71 285.95,139.81 PU4.40 ; PU6.12 v1(302.22,157.63) ; v1(302.3,173.1) PU5.12
  T03 w0.254: v1(302.3,173.1) 302.3,172.95 302.22,172.88 v1(302.22,157.63) 302.22,145.35 296.88,140.01 286.11,140.01 285.46,140.66 v1(284.11,140.66)
  BOTTOM w0.254: PC93.1 302.51,174.03 302.51,173.32 v1(302.3,173.1)
  BOTTOM w0.381: v1(302.22,157.63) 302.61,158.01 PC116.1
VDD_CORE_V3R3: length 73.7
  TOP w0.254: v1(286.89,131.12) 287.45,131.68 PU4.14
  TOP w0.381: v1(286.89,131.12) 286.89,130.79 PC90.1 ; PR145.1 290.49,130.37 PR146.1 290.48,130.37 v1(289.96,129.85) ; v1(281.56,135.76) 281.59,135.79 PR133.1 ; PR161.1 304.45,158.27 v1(305,158.81)
  TOP w0.508: PR157.1 304.35,174.5 v1(304.6,174.24)
  T03 w0.508: v1(281.56,135.76) 281.56,133.99 282.32,133.23 282.59,133.23 283,132.81 283,132.54 284.42,131.12 v1(286.89,131.12) 288.16,129.85 v1(289.96,129.85) 290.91,130.81 290.91,133.3 291.98,134.37 294.65,134.37 297.97,137.7 297.97,139.73 303.15,144.91 303.15,153.29 304.57,154.71 304.57,158.38 v1(305,158.81) 306.58,160.39 306.58,167.64 305.69,168.53 305.69,171.87 304.6,172.95 v1(304.6,174.24)
VDD_CORE_V5: length 5.8
  TOP w0.254: PU4.15 v1(287.95,131.08)
  TOP w0.381: PC91.1 287.95,130.43 v1(287.95,131.08)
  BOTTOM w0.381: PC91.1 287.53,130.66 v1(287.95,131.08) 287.95,131.68 v2(287.58,132.05)
VDD_CORE_VBOOT: length 4.4
  TOP w0.254: PU4.31 290.45,140.08 291.08,140.72 291.78,140.72 v1(291.94,140.87) PR125.1 PR121.2
VDD_CORE_VDD1: length 5.8
  TOP w0.254: PU5.4 296.6,170.98 296.41,170.78 295.33,170.78 v1(295.1,171.01)
  TOP w0.381: PR159.2 295.03,171.01 v1(295.1,171.01)
  BOTTOM w0.381: v1(295.1,171.01) 295.1,170.25 295.48,169.87 PC104.1
VDD_CORE_VDD2: length 6.7
  TOP w0.254: v1(295.4,155.38) 295.63,155.15 PU6.4
  TOP w0.381: v1(295.4,155.38) 294.26,156.51 PR163.2
  BOTTOM w0.14: v2(294.03,155.4) 295.38,155.4 v1(295.4,155.38)
  BOTTOM w0.254: PC102.1 295.47,155.38 v1(295.4,155.38)
VDD_CORE_VIN: length 6.2
  TOP w0.254: PU4.16 288.45,131.85 289.18,131.12 v1(289.3,131.12)
  TOP w0.381: v1(289.3,131.12) 289.3,130.36 PC92.1
  BOTTOM w0.381: PC92.1 288.95,130.76 v1(289.3,131.12) 289.4,131.22 v2(290.42,131.22)
VDD_CORE_VIN1:
  vias: v1(303.28,168.31) v1(303.58,163.42) v1(303.78,164.19) v1(303.91,168.64) v1(304.42,168.13) v1(304.73,163.61) v1(304.73,162.84) v1(304.73,161.96) v1(304.67,161.14) v1(304.85,164.37) v1(305.18,166.99) v1(305.31,165.97) v1(305.31,165.08) v2(305.87,167.84)
VDD_CORE_VIN2:
  vias: v1(304.55,148.97) v1(304.6,152.68) v1(304.6,148.11) v1(304.73,147.35) v1(304.73,146.46) v1(304.67,145.52) v1(304.67,144.63) v1(305.11,151.92) v1(305.11,151.16) v1(305.18,150.35) v1(305.18,149.46) v2(306.35,152.3)
VDD_CORE_VR_HOT_L: length 3.1
  TOP w0.254: PR145.2 291.45,131.59 290.96,132.08 290.31,132.08 289.95,132.44 PU4.19
VDD_CORE_VREF: length 87.4
  TOP w0.254: PU4.13 286.95,132.19 v1(286.64,131.88) ; PR128.1 296.06,139.41 v1(296.18,139.29) ; PR130.1 294.65,137.64 v1(295.11,137.64) 295.63,137.64 296.05,138.06 PR129.1
  TOP w0.381: PR121.1 v1(294.3,142.31) ; PR127.1 281.98,141.32 v1(281.62,141.68) ; PU6.1 297.41,157.65 296.98,158.08 PC94.1 v1(297.74,158.88) ; v1(291.47,143.15) 291.52,143.1 PR120.1 ; v1(296.6,175.41) PC117.1 297.48,173.63 PU5.1 ; PC88.2 281.61,131.5 PC86.2 282.93,131.01 283.29,130.66 PR148.2 285.41,130.66 v1(286.64,131.88)
  T05 w0.254: v1(297.74,158.88) 295.69,156.83 293.72,156.83 291.91,155.01 291.91,145.99 289.6,143.67 286.49,143.67 v1(286.13,143.31) ; v1(296.6,175.41) 296.7,175.31 296.7,172.79 295.95,172.04 293,172.04 290.38,169.42 290.38,147.15 288.79,145.56 284.74,145.56 283.34,144.16 v1(283.34,141.92)
  BOTTOM w0.254: v1(286.64,131.88) 285.94,131.18 PC87.1
VDD_CORE_VSN: length 8
  TOP w0.254: PR147.2 278.78,133.78 278.78,133.78 279.34,133.78 PR149.1 279.44,133.88 PR143.2 PC85.2 283.19,133.88 v1(283.37,133.71) 283.8,133.71 284.13,134.04 PU4.10
VDD_CORE_VSP: length 2.4
  TOP w0.254: PU4.9 284.5,134.54 284.06,134.98 v1(283.97,134.98) 283.69,134.7 PR506.2
VDD_CORE_VSP_R: length 4.9
  TOP w0.254: PR141.2 v1(278.51,134.75) 278.78,134.75 PR139.2 279.39,134.7 PR143.1 PC85.1 PR506.1
5P49V_VDDO: length 12
  TOP w0.305: U163.23 138.59,124.24 v1(138.27,124.56) ; v1(141.8,123.65) 141.3,123.15 U163.18 ; v1(142.25,121.3) 142.22,121.33 U163.15 ; v1(139.57,118.67) 139.59,118.69 U163.10 ; U163.21 139.59,124.35 v1(139.7,124.46)
  BOTTOM w0.381: v1(139.7,124.46) 140.17,123.99 C2348.2 ; C2350.2 141.9,122.92 141.9,123.54 v1(141.8,123.65) ; v1(139.57,118.67) 140.05,119.16 C2041.2 ; v1(142.25,121.3) 141.78,120.83 C2352.2 ; v1(138.27,124.56) 138.68,124.15 v2(138.68,123.7) 138.68,122.54 C2040.2
  vias: v1(143.17,118.28) v1(144.04,118.26)
BITS_CLK_SEL0: length 5.9
  TOP w0.14: U127.65 67.13,84.65 v5(68.2,85.72)
  BOTTOM w0.14: v5(68.2,85.72) 68.52,85.4 R1622.1 R1626.2
BITS_CLK_SEL1: length 5.6
  TOP w0.14: v5(67.82,84) U127.66
  BOTTOM w0.14: R1621.1 R1625.2 68.45,83.37 v5(67.82,84)
BITS_CLK_SEL2: length 8
  TOP w0.14: U127.67 67.52,83.35 68.58,82.3 v1(68.58,80.52)
  BOTTOM w0.14: v1(68.58,80.52) 68.78,80.32 R1624.2 R1620.1
BITS_DATA_PD: length 18.7
  TOP w0.14: 81.88,80.1 81.97,80.19 81.97,81.28 81.84,81.4 ; 81.88,80.1 U127.29 ; 81.88,80.1 81.97,80.02 81.97,79.38 ; U127.27 81.91,78.8 81.97,78.75 ; 81.97,78.11 81.97,77.64 81.83,77.5 U127.25 79.74,77.5 79.38,77.87 79.38,79.05 v5(78.49,79.94) ; 81.97,78.11 81.92,78.15 U127.26 ; 81.97,78.11 81.97,78.75 ; 81.97,79.38 81.97,78.75 ; 81.97,79.38 81.89,79.45 U127.28 ; 81.84,81.4 U127.31 ; 81.84,81.4 81.97,81.53 81.97,82.56 81.83,82.7 U127.33
  BOTTOM w0.14: v5(78.49,79.94) R1614.1
BITS_IC_PD: length 19.8
  TOP w0.14: U127.21 78.61,74.9 78.56,74.85 v1(78.56,74.85) ; v1(78.43,87.61) 78.78,87.25 U127.40
  T18 w0.117: v1(78.56,74.85) 78.51,74.9 78.32,74.9 77.22,76 77.22,86.4 v1(78.43,87.61)
  BOTTOM w0.14: R1623.1 77.29,87.61 v1(78.43,87.61)
BITS_LINE_ISO_EN: length 6.2
  TOP w0.14: U127.2 67.37,74.73 67.75,75.12 69.6,75.12 v5(70.36,75.88)
  BOTTOM w0.14: v5(70.36,75.88) 70.48,76 R1616.1
BITS_MPM: length 3.8
  TOP w0.14: v5(78.49,75.87) 78.81,75.55 U127.22
  BOTTOM w0.14: R1611.2 78.23,76.13 v5(78.49,75.87)
BITS_REFR: length 3.9
  TOP w0.14: v5(71.75,75.75) 72.01,75.5 72.01,74.17 71.92,74.08 U127.9
  BOTTOM w0.14: R1615.1 v5(71.75,75.75)
BITS_SPI_MODE_EN: length 4
  TOP w0.14: v5(78.4,77.23) 79.43,76.2 U127.23
  BOTTOM w0.14: v5(78.4,77.23) 78.34,77.23 78.17,77.4 R1612.2
BITS_T1_RRING: length 2.6
  TOP w0.104: R1597.1 77.57,71.37 77.57,72.1 77.77,72.29 U127.18
BITS_T1_RRING_CMC: length 21.7
  TOP w0.104: L162.2 50.79,43.22 50.9,43.11 50.9,42.33 51.87,41.35 51.87,40.75 51.77,40.64 D103.2 49.91,39.59 51.77,39.59 51.87,39.49 51.87,33.98 52.7,33.15 55.75,33.15 56.85,34.25 57.19,34.25 57.44,34 F2.1
BITS_T1_RRING_CONN: length 25.1
  TOP w0.104: F2.2 58.81,33.92 59.14,34.25 59.48,34.25 60.4,33.33 60.4,33.2 60.39,33.19 60.39,33.06 60.49,32.97 60.61,32.97 60.62,32.98 60.75,32.98 60.84,32.89 60.84,32.76 60.84,32.75 60.84,32.62 60.93,32.53 61.06,32.53 61.06,32.54 61.19,32.54 61.29,32.44 61.29,32.32 61.28,32.31 61.28,32.18 61.37,32.09 61.5,32.09 61.51,32.09 61.64,32.09 61.92,31.81 61.92,26.16 62.78,25.3 62.78,21.12 61.61,19.95 58.21,19.95 58.05,20.11 57.9,20.11 57.74,19.95 57.59,19.95 57.43,20.11 57.28,20.11 57.11,19.95 56.04,19.95 55.49,19.4 55.34,19.4 J7.BR2
BITS_T1_RRING_XFMR: length 47.4
  TOP w0.104: R1597.2 77.62,69.66 77.62,69.46 v4(77.8,69.27) ; v4(63.17,69.53) 61.78,69.53 D77.2 61.84,68.97 62.99,68.97 63.39,68.56 63.39,67.44 62.99,67.04 56.05,67.04 53.66,64.65 52.39,64.65 52.12,64.92 R1596.2 51.26,64.92 50.99,64.66 49.03,64.66 48.51,64.13 48.51,63.66 D93.7 48.2,63.35 48.2,61.83 D93.4 48.51,61.52 48.51,61.07 48.91,60.67 50.42,60.67 50.58,60.51 50.58,60.24 50.41,60.06 49.8,60.06 49.54,59.8 T1.3
  T14 w0.107: v4(77.8,69.27) 77.58,69.06 77.58,68.53 76.68,67.62 64.46,67.62 63.39,68.69 63.39,69.31 v4(63.17,69.53)
BITS_T1_RRING_XFMR_CMC: length 5
  TOP w0.104: L162.1 50.44,47.42 50.61,47.59 50.61,48.97 50.45,49.14 49.83,49.14 49.54,49.42 T1.14
BITS_T1_RTIP: length 2.5
  TOP w0.104: R1595.1 77.31,71.29 77.31,72.1 77.12,72.29 U127.17
BITS_T1_RTIP_CMC: length 21.3
  TOP w0.104: F1.1 57.44,34.71 57.24,34.51 56.74,34.51 55.64,33.41 52.82,33.41 52.14,34.09 52.14,39.49 52.24,39.59 54.1,39.59 D104.1 52.24,40.64 52.14,40.75 52.14,41.46 51.16,42.44 51.16,43.11 51.27,43.22 L162.3
BITS_T1_RTIP_CONN: length 25
  TOP w0.104: F1.2 58.81,34.78 59.09,34.51 59.6,34.51 62.18,31.92 62.18,26.27 63.05,25.41 63.05,21.01 61.72,19.68 56.15,19.68 55.68,19.21 55.68,19.07 J7.BR1
BITS_T1_RTIP_XFMR: length 47.4
  TOP w0.104: v4(63.88,69.53) 65.27,69.53 D77.1 65.22,68.97 64.01,68.97 63.66,68.62 63.66,67.33 63.1,66.77 56.16,66.77 54.84,65.45 54.84,65.32 54.9,65.26 54.9,65.13 54.81,65.04 54.68,65.04 54.62,65.1 54.49,65.1 54.4,65.01 54.4,64.88 54.46,64.82 54.46,64.69 54.36,64.6 54.23,64.6 54.18,64.66 54.05,64.66 53.77,64.38 52.39,64.38 52.12,64.11 R1596.1 51.26,64.11 50.98,64.39 49.15,64.39 48.78,64.02 48.78,63.66 D93.6 49.08,63.36 49.08,61.82 D93.5 48.78,61.52 48.78,61.18 49.02,60.94 50.53,60.94 50.85,60.62 50.85,60.16 50.95,60.06 51.82,60.06 52.08,59.8 T1.1 ; R1595.2 77.34,69.67 77.34,69.52 v4(77.09,69.27)
  T14 w0.107: v4(77.09,69.27) 77.3,69.06 77.3,68.65 76.56,67.9 64.57,67.9 63.67,68.81 63.67,69.31 v4(63.88,69.53)
BITS_T1_RTIP_XFMR_CMC: length 5.6
  TOP w0.104: T1.16 52.08,49.43 51.8,49.15 51.1,49.15 50.88,48.92 50.88,47.66 51.11,47.42 L162.4
BITS_T1_TRING: length 2.5
  TOP w0.104: U127.12 73.87,72.29 73.67,72.1 73.67,71.26 R1599.1
BITS_T1_TRING_CMC: length 18.2
  TOP w0.104: L163.2 44.11,43.27 44.22,43.17 44.22,42.44 43.49,41.71 43.49,40.75 43.39,40.64 D100.2 41.53,39.59 43.39,39.59 43.49,39.49 43.49,34.54 43,34.05 41.33,34.05 41.02,33.74 41.02,33.3 40.83,33.11 F4.1
BITS_T1_TRING_CONN: length 29.3
  TOP w0.104: F4.2 41.02,31.15 41.02,30.32 43.91,27.43 47.14,27.43 49.8,30.09 52.98,30.09 53.15,29.92 53.29,29.92 53.46,30.09 53.61,30.09 53.78,29.92 53.92,29.92 54.09,30.09 54.23,30.09 54.4,29.92 54.54,29.92 54.71,30.09 55.26,30.09 55.65,29.69 55.65,29.44 55.75,29.34 56,29.34 56.1,29.25 56.1,28.99 56.19,28.9 56.45,28.9 57.26,28.08 57.26,23.22 56.77,22.73 56.01,22.73 55.68,23.07 55.68,23.21 J7.BR5
