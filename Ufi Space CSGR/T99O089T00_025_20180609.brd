# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PHY1_SYNCE_RCVD2_DP: length 62.2
  TOP w0.104: U23.T7 121.55,99.03 118.84,99.03 v4(118.62,98.81) 118.41,99.02 118.14,99.02 117.92,98.8 R273.1 ; C2158.1 146.9,135.2 146.12,135.2 145.36,134.44 143.14,134.44 v4(142.95,134.63)
  T16 w0.107: v4(142.95,134.63) 142.74,134.41 140.29,134.41 140.15,134.55 139.97,134.55 139.83,134.41 139.06,134.41 134.32,129.67 134.32,117.19 132.99,115.87 127.2,115.87 117.32,105.99 117.32,99.45 117.77,99.01 118.41,99.01 v4(118.62,98.81)
CLK_PHY1_SYNCE_RCVD_DN: length 127.6
  TOP w0.104: U23.T9 121.35,96.49 119.79,96.49 v4(119.58,96.7) ; v4(19.08,78.13) 19.3,78.36 19.3,78.65 C2407.1
  T14 w0.107: v4(119.58,96.7) 119.43,96.55 119.43,96.55 119.36,96.48 118.83,96.48 118.41,96.06 118.41,84.08 115.8,81.47 92.94,81.47 84.83,73.36 67.55,73.36 67.08,73.36 65.99,74.45 36.08,74.45 34.43,72.8 24.22,72.8 21.23,75.78 21.23,78.22 20.57,78.89 19.56,78.89 19.29,78.62 19.29,78.35 v4(19.08,78.13)
  BOTTOM w0.104: R274.2 118.93,96.32 119.21,96.32 v4(119.58,96.7)
CLK_PHY1_SYNCE_RCVD_DP: length 128.2
  TOP w0.104: v4(119.58,95.97) 119.81,96.2 121.38,96.2 U23.T10 ; v4(19.79,78.13) 19.56,78.36 19.56,78.65 C2408.1
  T14 w0.107: v4(119.58,95.97) 119.58,96.04 119.42,96.2 118.95,96.2 118.69,95.94 118.69,83.96 115.92,81.19 93.06,81.19 84.95,73.08 67.43,73.08 66.96,73.08 65.87,74.17 36.2,74.17 34.54,72.52 26.48,72.52 26.38,72.42 26.38,72.36 26.29,72.27 26.16,72.27 26.06,72.36 26.06,72.42 25.97,72.52 25.84,72.52 25.74,72.42 25.74,72.36 25.65,72.27 25.52,72.27 25.42,72.36 25.42,72.42 25.33,72.52 25.2,72.52 25.1,72.42 25.1,72.36 25.01,72.27 24.88,72.27 24.78,72.36 24.78,72.42 24.69,72.52 24.11,72.52 22,74.62 21.87,74.62 21.86,74.61 21.73,74.61 21.64,74.71 21.64,74.84 21.64,74.85 21.64,74.98 21.55,75.07 21.42,75.07 21.41,75.07 21.28,75.07 21.18,75.16 21.18,75.29 21.19,75.3 21.19,75.43 20.95,75.67 20.95,78.1 20.45,78.61 19.68,78.61 19.57,78.5 19.57,78.35 v4(19.79,78.13)
  BOTTOM w0.104: R272.2 118.96,96.06 119.5,96.06 v4(119.58,95.97)
CLK_PHY1_SYNCE_REFCLK2_DN: length 6.7
  TOP w0.104: C2159.2 148.06,134.79 148.16,134.89 148.57,134.89 148.84,134.62 R12475.2 149.71,134.62 149.98,134.89 150.23,134.89 151.92,133.2 151.92,132.82 152.27,132.47 152.6,132.47 152.7,132.36 U135.2
CLK_PHY1_SYNCE_REFCLK2_DP: length 6.8
  TOP w0.104: C2158.2 148.08,135.3 148.23,135.16 148.62,135.16 148.89,135.43 R12475.1 149.71,135.43 149.98,135.16 150.34,135.16 152.18,133.31 152.18,132.93 152.36,132.75 152.64,132.75 152.75,132.86 U135.1
CLK_PHY1_SYNCE_REFCLK_DN: length 11
  TOP w0.104: C2407.2 19.29,80.21 19.29,80.46 19.02,80.73 R12914.2 19.02,80.93 19.3,81.21 19.3,81.57 R12812.2 19.29,82.17 19.29,82.52 R12813.1 18.95,83.08 19.29,83.43 19.29,84.45 18.62,85.12 17.37,85.12 16.41,86.08 16.41,87.28 U139.J11
CLK_PHY1_SYNCE_REFCLK_DP: length 10.2
  TOP w0.104: U139.J12 16.78,86.8 16.68,86.7 16.68,86.19 17.48,85.39 17.79,85.39 17.97,85.56 18.11,85.56 18.28,85.39 18.73,85.39 19.56,84.56 19.56,83.44 19.91,83.08 R12811.1 19.56,82.51 19.56,82.2 R12810.2 19.61,81.54 19.61,81.18 19.84,80.96 R12914.1 19.84,80.73 19.56,80.45 19.56,80.22 C2408.2
CLK_PHY3_SYNCE_RCVDA_DN: length 309
  TOP w0.104: C2382.1 12.73,78.59 12.73,77.18 15.49,74.42 27.68,74.42 27.89,74.22 30.47,74.22 30.67,74.42 v4(30.99,74.42)
  TOP w0.14: U25.D9 v4(290.1,93.39)
  T05 w0.107: v4(290.1,93.39) 289.85,93.39 289.74,93.28 289.74,92.93 290.06,92.61 292.58,92.61 294.16,91.03 294.16,83.83 292.37,82.04 270.91,82.04 266.21,77.34 261.48,77.34 259.98,78.84 194.78,78.84 185.86,69.92 90,69.92 88.96,70.97 65.3,70.97 62.65,73.62 39.65,73.62 38.11,75.16 31.34,75.16 30.99,74.8 v4(30.99,74.42)
  BOTTOM w0.104: R13071.2 290.1,93.16 v4(290.1,93.39)
CLK_PHY3_SYNCE_RCVDA_DP: length 309.9
  TOP w0.104: v4(30.49,74.92) 30.49,74.61 30.36,74.48 28,74.48 27.79,74.69 15.6,74.69 13,77.29 13,78.59 C2381.1
  TOP w0.14: U25.E9 v4(289.1,93.39)
  T05 w0.107: v4(30.49,74.92) 30.71,74.92 31.23,75.44 38.23,75.44 39.77,73.9 46.76,73.9 46.93,74.07 47.08,74.07 47.25,73.9 47.4,73.9 47.57,74.07 47.72,74.07 47.89,73.9 48.04,73.9 48.21,74.07 48.36,74.07 48.53,73.9 62.76,73.9 63.28,73.38 63.52,73.38 63.63,73.27 63.63,73.03 63.74,72.92 63.97,72.92 64.08,72.81 64.08,72.58 64.19,72.47 64.42,72.47 64.53,72.36 64.53,72.13 65.41,71.24 89.08,71.24 90.12,70.2 90.86,70.2 90.95,70.3 90.95,70.32 91.05,70.42 91.18,70.42 91.27,70.32 91.27,70.3 91.37,70.2 91.5,70.2 91.59,70.3 91.59,70.32 91.69,70.42 91.82,70.42 91.91,70.32 91.91,70.3 92.01,70.2 92.14,70.2 92.24,70.3 92.24,70.32 92.33,70.42 92.46,70.42 92.56,70.32 92.56,70.3 92.65,70.2 185.75,70.2 194.67,79.12 260.1,79.12 261.59,77.62 266.09,77.62 270.79,82.32 292.25,82.32 293.88,83.95 293.88,90.92 293.47,91.33 293.33,91.33 293.32,91.31 293.18,91.31 293.09,91.41 293.09,91.54 293.11,91.56 293.11,91.69 293.01,91.78 292.88,91.78 292.86,91.77 292.73,91.77 292.64,91.86 292.64,91.99 292.65,92.01 292.65,92.14 292.47,92.33 289.94,92.33 289.46,92.81 289.46,93.28 289.35,93.39 v4(289.1,93.39)
  BOTTOM w0.104: v4(289.1,93.39) 289.39,93.1 R13070.2
CLK_PHY3_SYNCE_RCVDB_DN: length 289.1
  TOP w0.104: v4(15.55,76.7) 15.77,76.93 15.77,77.07 15.73,77.12 15.73,78.69 15.46,78.96 R13085.2 15.46,79.72 15.75,80.01 15.75,81.03 15.56,81.21 R12937.2 R12939.1 15.58,82.14 15.77,82.33 15.77,84.95 15.49,85.22 15.49,87.37 U139.K11 ; v4(157.13,81.53) 157.35,81.31 159.02,81.31 159.6,80.72 209.12,80.72 212.92,84.52 251.49,84.52 256.76,89.8 270.85,89.8 R13027.1 271.49,89.79 273.5,89.79 275.6,91.88 U25.V10
  T07 w0.107: v4(15.55,76.7) 15.76,76.92 15.76,77.22 16.03,77.5 17.39,77.5 22.49,72.39 33.66,72.39 35.2,73.94 52.82,73.94 53.63,73.13 84.29,73.13 91.17,80.01 114.39,80.01 119.49,85.12 135.62,85.12 140.48,80.26 154.28,80.26 155.33,81.31 156.91,81.31 v4(157.13,81.53)
CLK_PHY3_SYNCE_RCVDB_DP: length 289
  TOP w0.104: v4(16.26,76.7) 16.04,76.93 16.04,77.18 16,77.23 16,78.69 16.27,78.96 R13085.1 16.27,79.74 16.01,80 16.01,81.03 16.2,81.21 R12936.2 R12938.1 16.23,82.14 16.04,82.33 16.04,85.06 15.76,85.33 15.76,86.63 U139.K12 ; v4(157.13,80.82) 157.35,81.04 158.91,81.04 159.49,80.46 209.23,80.46 213.03,84.26 213.42,84.26 213.55,84.13 213.74,84.13 213.86,84.26 251.6,84.26 256.87,89.53 270.85,89.53 R13026.1 271.48,89.52 273.62,89.52 275.42,91.33 276.04,91.33 U25.U10
  T07 w0.107: v4(157.13,80.82) 156.91,81.03 155.44,81.03 154.4,79.98 140.36,79.98 135.51,84.84 119.61,84.84 114.5,79.73 93.85,79.73 93.73,79.61 93.53,79.61 93.41,79.73 93.21,79.73 93.09,79.61 92.89,79.61 92.77,79.73 92.57,79.73 92.45,79.61 92.25,79.61 92.13,79.73 91.29,79.73 84.4,72.85 53.52,72.85 52.7,73.66 35.32,73.66 33.77,72.11 22.38,72.11 17.27,77.22 16.15,77.22 16.04,77.11 16.04,76.92 v4(16.26,76.7)
CLK_PHY3_SYNCE_REFCLK1_DN: length 9.9
  TOP w0.104: C2382.2 12.72,80.14 12.72,80.34 12.42,80.64 R12749.2 12.42,81.09 12.64,81.31 12.64,81.59 R12806.2 12.69,82.22 12.69,82.55 R12804.1 12.34,83.3 12.64,83.6 12.64,84.64 14.47,86.47 14.47,87.34 U139.L11
CLK_PHY3_SYNCE_REFCLK1_DP: length 8.8
  TOP w0.104: U139.L12 14.73,86.61 14.73,86.36 12.91,84.53 12.91,83.62 13.31,83.22 R12803.1 12.95,82.54 12.95,82.24 R12807.2 12.95,81.53 12.95,81.37 13.23,81.09 R12749.1 13.23,80.64 12.99,80.39 12.99,80.17 C2381.2
CLK_PTP_1PPS_APLL1: length 75.8
  T03 w0.117: v1(31.5,76.7) 29.2,76.7 27.18,74.68 9.53,74.68 5.2,79 5.2,91.62 v1(8.76,95.18)
  BOTTOM w0.14: U170.1 53.58,82.15 50.16,78.73 50.16,76.08 49.19,75.1 43.65,75.1 42.05,76.7 v1(31.5,76.7) ; R12795.1 v1(8.76,95.18)
CLK_PTP_1PPS_DPLL_BUFF: length 177.9
  TOP w0.14: v1(135.13,76.37) 139.66,80.9 R1915.1 ; v1(24.95,57.6) 24.8,57.45 24.8,56.87 R1917.1
  T03 w0.117: v1(24.95,57.6) 24.95,57.27 26.35,55.87 37.97,55.87 41.19,59.1 54.18,59.1 61.47,51.82 61.47,47.37 63.5,45.34 63.5,37.12 64.82,35.8 66.94,35.8 85.65,35.8 86.57,36.72 94.91,36.72 96.85,38.66 96.85,50.11 98.2,51.47 98.2,53.18 99.07,54.05 99.07,60.45 99.09,60.47 99.09,62.64 106.93,70.48 134.37,70.48 136.26,72.38 136.26,75.23 v1(135.13,76.37)
CLK_PTP_1PPS_DPLL_OUT: length 112.4
  TOP w0.14: v1(135.38,73.03) 135.38,75.34 139.79,79.76 149.48,79.76 152.15,82.42 U175.1
  T03 w0.117: v1(99.89,73.21) 100.9,73.21 102.74,71.37 131.95,71.37 133.6,73.03 v1(135.38,73.03)
  T16 w0.117: v1(56.43,84.29) 56.43,83.89 58.59,81.73 59.79,81.73 60.15,81.37 63.71,81.37 64.96,80.12 64.96,75.97 67.4,73.53 87.86,73.53 89.89,71.5 98.18,71.5 v1(99.89,73.21)
  BOTTOM w0.14: U170.4 v1(56.43,84.29)
CLK_PTP_1PPS_DPLL_OUT1: length 3.5
  TOP w0.14: R1916.2 R1917.2 25.87,56.83 v1(26.84,56.83) 27.08,56.58 U168.1
CLK_PTP_1PPS_DPLL_TO_MAC: length 80.1
  TOP w0.14: U1.AA33 v4(199.86,122.5) ; R1918.1 150.73,87.27 v1(150.42,87.58)
  T03 w0.117: v4(199.86,122.5) 199.36,122.99 194.79,122.99 194.46,122.66 194.46,121.94 194.13,121.62 191.35,121.62 190.71,122.25 189.3,122.25 187.44,120.39 179.06,120.39 v1(178.75,120.71)
  BOTTOM w0.14: v1(150.42,87.58) 151.76,88.92 151.76,92.12 152.5,92.86 152.5,104.24 153.85,105.59 160.83,105.59 165.61,110.36 165.61,115.06 167.21,116.66 167.51,116.66 167.52,116.67 168.37,116.67 168.37,116.66 177.49,116.66 178.46,117.63 R1447.1 178.46,120.42 v1(178.75,120.71)
CLK_PTP_1PPS_DPLL_TO_PHY1: length 28.5
  TOP w0.102: U23.F8 v4(132.21,97.36)
  T07 w0.117: v4(132.21,97.36) 131.66,96.81 131.66,92.2 132.04,91.82 141.73,91.82 142.75,90.8 v1(142.75,89.92)
  BOTTOM w0.14: R12943.1 149.45,86.74 147.33,86.74 146.56,87.5 145.16,87.5 v2(144.29,88.38) v1(142.75,89.92)
CLK_PTP_1PPS_DPLL_TO_PHY3: length 141.4
  TOP w0.14: U25.K16 v4(283.1,85.39)
  T03 w0.117: v1(152.34,77.03) 153.75,78.44 187.3,78.44 187.83,77.91 195.51,77.91 196.27,78.67 247.28,78.67 247.52,78.42 259.27,78.42 260.33,77.36 266.9,77.36 268.66,79.11 268.66,79.12 269.14,79.6 269.14,79.6 271.83,82.29 282,82.29 282.57,82.87 282.57,84.86 v4(283.1,85.39)
  BOTTOM w0.14: R12942.1 152.4,79.35 v2(152.4,78.98) 152.4,77.09 v1(152.34,77.03)
CLK_PTP_1PPS_FRSYNC: length 29.5
  BOTTOM w0.14: U170.3 53.61,83.45 47.75,77.6 34.54,77.6 v2(33.53,78.61) 31.39,80.75 R12800.1
CLK_PTP_1PPS_MAC_TO_DPLL: length 220.9
  TOP w0.14: U139.H10 v4(17.43,88.3) ; R70.2 v1(172.34,122.6)
  T07 w0.117: v1(142.11,77.98) 140.82,77.98 139.55,79.25 117.35,79.25 116.83,78.73 98.33,78.73 96.29,76.69 96.29,73.81 93.91,71.43 93.91,71.43 93.69,71.22 83.35,71.22 82.49,70.36 68.33,70.36 66.26,68.29 54.45,68.29 52.91,69.83 17.5,69.83 12.95,74.37 12.95,83.83 v4(17.43,88.3)
  T14 w0.117: v1(172.34,122.6) 172.34,122.94 171.48,123.8 170.59,123.8 169.96,123.17 169.96,119.01 165.6,114.65 165.6,110.93 165.55,110.88 165.55,110.42 156.09,100.97 v1(156.09,99.04)
  T16 w0.117: v1(142.11,77.98) 143.89,79.76 152.65,79.76 153.49,80.6 153.49,87.56 155.83,89.9 155.83,98.78 v1(156.09,99.04)
CLK_PTP_1PPS_MAC_TO_SMA: length 239.7
  TOP w0.14: v1(181.64,115.67) 181.64,116.64 R12925.2 ; R1914.1 v1(24.82,19.18)
  T05 w0.117: v1(24.82,19.18) 22.91,21.08 20.07,21.08 19.55,21.61 19.55,47.44 v1(22.16,50.05)
  T14 w0.117: v1(181.64,115.67) 181.69,115.62 181.69,114.4 180.84,113.56 178.98,113.56 166.11,100.69 166.11,97.66 164.72,96.27 164.72,91.95 163.49,90.72 163.49,89.32 162.47,88.31 160.77,88.31 160.1,87.63 152.65,87.63 149.61,84.58 149.61,82.39 146.91,79.69 137.19,79.69 132.84,75.35 132.84,72.7 131.1,70.96 103.24,70.96 101.6,72.61 100.44,72.61 100.1,72.26 98.68,72.26 93.12,66.71 88.38,66.71 78.89,57.21 76.78,57.21 76.33,56.76 75.29,56.76 75.2,56.85 72.6,56.85 72.24,56.49 69.47,56.49 66.64,53.66 66.12,53.15 60.48,53.15 54.98,58.65 41.14,58.65 38.1,55.61 36.87,55.61 36.87,55.61 36.21,55.61 36.21,55.61 30.61,55.61 29.96,54.96 26.14,54.96 25.16,53.98 25.16,53.06 v1(22.16,50.05)
CLK_PTP_1PPS_MFRSYNC: length 34.5
  TOP w0.14: v1(32.62,83.7) 31.81,84.51 R12790.1 ; R1916.1 24.56,55.7 v1(24.26,56.01)
  T18 w0.117: v1(24.26,56.01) 24.77,56.01 27.44,58.68 27.44,63.52 29.13,65.21 29.13,68.86 32.51,72.24 32.51,78.11 31.75,78.87 31.75,82.82 v1(32.62,83.7)
CLK_PTP_4K_DPLL_OUT: length 176
  TOP w0.14: v1(79.76,67.44) 79.76,68.58 89.82,78.65 94.01,78.65 94.52,79.15 104.85,79.15 111.49,79.15 114.2,81.86 115.93,81.86 115.94,81.87 116.28,81.87 120.2,85.78 147.06,85.78 149.8,88.52 152.9,88.52 153.53,89.15 U174.1
  T07 w0.117: v1(79.76,67.44) 79.63,67.31 70.08,67.31 68.29,65.52 55.97,65.52 52.54,68.95 30.85,68.95 29.72,67.82 23.24,67.82 22.11,68.95 17.13,68.95 12.06,74.01 12.06,78.87 9.79,81.14 9.79,90.03 9.21,90.61 v1(8.89,90.61)
  BOTTOM w0.14: R1663.1 v1(8.89,90.61)
CLK_PTP_4K_DPLL_TO_MAC: length 94.9
  TOP w0.14: v1(154.76,99.04) 154.76,97.72 152.4,95.35 R12928.1 ; v5(171.6,124.89) 171.6,124.89 171.6,124.68 R1452.2 ; U1.AC29 v4(203.86,124.5)
  T03 w0.117: v4(203.86,124.5) 203.33,123.96 203.33,120.24 200.3,117.22 199.9,117.22 199.35,116.67 199.35,116.3 199.04,115.99 197.67,115.99 197.28,116.38 194.95,116.38 193.67,115.1 193.67,114.86 192.92,114.11 189.81,114.11 188.01,112.32 187.82,112.32 187.54,112.04 184.88,112.04 184.6,112.32 179.21,112.32 179.16,112.37 179.08,112.37 174.11,117.35 172.39,117.35 170.64,119.1 170.62,119.1 169.99,119.73 169.99,123.24 171.6,124.84 171.6,124.89 v5(171.6,124.89)
  T14 w0.117: v5(171.6,124.89) 170.75,124.89 170.16,125.48 167.78,125.48 166.5,124.21 166.5,119.28 164.67,117.45 164.67,110.79 154.76,100.88 v1(154.76,99.04)
CLK_PTP_4K_DPLL_TO_PHY1: length 27.3
  TOP w0.14: U23.F7 v4(132.21,98.36) ; R12930.1 v1(154.9,94.77)
  T07 w0.117: v4(132.21,98.36) 132.68,97.89 132.68,96.81 133.1,96.39 137.16,96.39 138.05,95.5 140.67,95.5 141.56,94.61 147.7,94.61 148.94,93.38 153.51,93.38 v1(154.9,94.77)
CLK_PTP_4K_DPLL_TO_PHY3: length 138.4
  TOP w0.14: R12929.1 153.52,94.24 v1(153.52,94.95) ; U25.K15 v4(283.1,86.39)
  T05 w0.117: v4(283.1,86.39) 283.1,86 282.96,85.85 224.62,85.85 222.98,87.49 189.5,87.49 187.97,89.02 184.57,89.02 v1(183.35,90.24)
  T07 w0.117: v1(183.35,90.24) 182.69,89.59 173.43,89.59 165.1,97.92 159.83,97.92 158.83,96.92 155.49,96.92 v1(153.52,94.95)
CLK_PTP_10M_MAC_TO_DPLL: length 216.3
  TOP w0.14: U139.F10 v4(20.43,88.3)
  T05 w0.117: v4(20.43,88.3) 20.66,88.3 21.21,87.76 26.16,87.76 27.56,86.36 27.56,83.55 28.96,82.15 28.96,76.68 27.76,75.49 27.76,72.72 27.76,71.99 30.02,69.73 54.1,69.73 56.26,67.57 77.99,67.57 78.67,68.26 81.48,68.26 82.04,67.69 139.19,67.69 v1(139.83,68.33)
  T16 w0.117: v1(159.64,84.45) 159.26,84.07 159.26,81.41 156.46,78.61 151.13,78.61 148.78,76.26 148.78,72.58 144.53,68.33 v1(139.83,68.33)
  BOTTOM w0.14: R71.2 179.55,117.45 179.36,117.26 179.36,117.25 178.05,115.94 178.04,115.94 177.66,115.56 v2(173.92,115.56) 169.66,115.56 168.53,114.43 167.51,114.43 166.53,113.44 166.53,96.6 162.43,92.5 162.43,90.91 162.43,90.91 162.43,89.15 161.93,88.65 160.91,88.65 160.08,87.82 160.08,84.89 v1(159.64,84.45)
CLK_PTP_10M_MAC_TO_SMA: length 242.6
  TOP w0.14: R12941.2 181.1,120.2 180.21,119.31 180.21,115.56 v1(180.87,114.91) ; v1(17.34,21.27) 17.28,21.22 17.28,20.45 17.28,19.95 R1902.1
  T05 w0.117: v1(17.34,21.27) 17.4,21.34 17.4,24 16.81,24.59 16.81,45.94 22.86,52 v1(22.86,52)
  T14 w0.117: v1(180.87,114.91) 179.08,114.91 165.57,101.39 165.23,101.06 165.23,98.02 163.68,96.47 163.68,93.46 162.56,92.35 162.56,89.63 162.11,89.18 160.41,89.18 159.73,88.51 150.19,88.51 148.73,87.04 148.73,82.75 146.55,80.57 136.49,80.57 134.4,78.49 99.46,78.49 96.49,75.51 96.49,71.69 92.38,67.59 88.02,67.59 83.06,62.63 78.71,62.63 78.26,62.18 76.94,62.18 76.29,62.83 75.61,62.83 75.41,62.63 68.37,62.63 65.55,65.45 57.64,65.45 51.72,59.53 40.75,59.53 38.15,56.93 36.67,56.93 35.71,57.89 31.66,57.89 29.6,55.83 25.78,55.83 24.79,54.85 23.71,54.85 22.86,54 v1(22.86,52)
CLKGEN_54M_XTAL_IN: length 4.4
  TOP w0.14: Y3.3 149.6,129.49 Y1.1
  TOP w0.147: U135.6 151.61,130.36 151.46,130.21 150.91,130.21 150.5,129.79 149.74,129.79 Y1.1
CLKGEN_54M_XTAL_OUT: length 5.8
  TOP w0.14: Y3.1 148.14,131.41 Y1.3
  TOP w0.147: Y1.3 148.48,130.92 149.1,130.3 150.24,130.3 150.45,130.51 151.35,130.51 151.7,130.86 U135.5
CPLD_CONF_DONE: length 9.6
  TOP w0.14: R999.2 108.6,135 109.09,135.5 v1(109.09,135.52) ; U70.C5 v4(113.2,131.25)
  T14 w0.117: v4(113.2,131.25) 112.8,131.65 112.24,131.65 112,131.89 112,133.11 109.6,135.51 109.11,135.51 v1(109.09,135.52)
CPLD_CONFIG_EN: length 13.2
  TOP w0.14: v1(124.57,131.51) 124.33,131.27 R996.2 ; U70.E7 v4(115.6,129.65)
  T14 w0.117: v1(124.57,131.51) 124.55,131.5 124.55,130.93 123.49,129.86 122.15,129.86 120.74,128.45 116.21,128.45 116,128.66 116,129.25 v4(115.6,129.65)
CPLD_CONFIG_SEL: length 71.8
  TOP w0.14: U70.D7 v4(115.6,130.45) ; v4(72.14,106.55) 72.1,106.55 U154.A19 ; R1697.2 117.34,119.41 v1(117.34,120.2)
  T05 w0.117: v4(72.14,106.55) 72.78,105.91 75.4,105.91 76.65,104.66 85.05,104.66 85.53,105.14 85.53,109.41 95.11,118.99 103.61,118.99 104.56,118.03 113.49,118.03 114.46,119 116.2,119 117.34,120.14 v1(117.34,120.2) 116.64,120.9 115.82,120.9 115.06,121.67 115.06,126.59 116,127.54 116,130 115.6,130.4 v4(115.6,130.45)
  BOTTOM w0.14: v1(117.34,120.2) 117.34,118.97 R1701.2
CPLD_CRC_ERROR: length 6.5
  TOP w0.107: 114.8,132.96 114.8,130.45 U70.D6
  TOP w0.14: R997.2 114.43,134.99 115.06,134.36 115.06,133.22 114.8,132.96
CPLD_OSC_OE: length 2.6
  TOP w0.381: R994.1 v1(102.56,135.18) 101.93,134.55 X1.1
CPLD_REV0: length 50
  TOP w0.14: R1699.2 R1708.2 117.07,137.3 v1(116.91,137.13) ; U70.G4 v4(112.4,128.05)
  T03 w0.117: v4(112.4,128.05) 112,128.45 112,132.7 112.43,133.13 112.43,134.08 112.06,134.45 108.6,134.45 108.04,135.01 107.22,135.01 104.97,137.26 99.07,137.26 94.66,132.84 93.85,132.84 93.22,132.21 89.03,132.21 v1(88.22,133.01)
  T14 w0.117: v4(112.4,128.05) U70.G4 114.43,127.65 114.83,128.05 114.83,136.04 115.92,137.13 v1(116.91,137.13)
CPLD_STATUS_N: length 10.5
  TOP w0.14: U70.C4 v4(112.4,131.25) ; v1(105.79,135.64) 105.79,135.13 R998.2
  T14 w0.102: v4(112.4,131.25) 112.19,131.25 111.78,131.66 110.62,131.66 110.41,131.87 110.41,133 109.44,133.97 108.96,133.97
  T14 w0.117: 108.96,133.97 107.14,133.97 105.79,135.32 v1(105.79,135.64)
CPU_BOOT_DONE: length 148.2
  TOP w0.14: U154.C14 v4(70.53,110.53)
  T14 w0.117: v1(73.3,130.7) 70.69,130.7 69.3,132.08 68.07,132.08 67.22,132.93 67.22,134.92 64.28,137.87 64.28,139.64 63.75,140.17 63.75,152.53 64.15,152.92 64.15,154.28 v1(63.35,155.08)
  T18 w0.117: v4(70.53,110.53) U154.C14 70.13,118.72 69.92,118.93 63.84,118.93 63.73,119.04 63.73,121.38 64.39,122.05 64.39,122.81 67.06,125.48 67.06,127 69.47,129.41 72.02,129.41 v1(73.3,130.7) ; v1(63.35,155.08) 63.89,155.08 65.02,156.21 65.02,157.1 65.58,157.65 141.95,157.65 143.04,156.56 J1.B78
  BOTTOM w0.14: R1759.2 v1(73.3,130.7)
CPU_CATERR_L: length 98.8
  TOP w0.14: J1.A50 114.03,161.97 R1760.2 ; v1(81.03,120.58) 80.46,120.02 77.09,120.02 76.58,120.53 U154.A2
  T05 w0.117: v1(81.03,120.58) 79.73,121.88 79.73,123.19 79.12,123.8 79.12,125.7 80.99,127.56 80.99,129.45 80.01,130.43 80.01,132.25 81.28,133.52 81.28,138.81 80.01,140.08 80.01,150.75 82.04,152.78 82.04,154.91 83.06,155.93 83.06,159.26 84.07,160.27 84.07,161.49 v1(87.18,164.6)
  T18 w0.117: v1(87.18,164.6) 89.22,162.56 113.43,162.56 J1.A50
CPU_I2C0_BUFF_EN: length 67.8
  TOP w0.14: U71.1 R1981.2 R1987.1 92.3,173.51 95.5,170.31 95.5,164.21 v1(95.25,163.96)
  T05 w0.117: v1(95.25,163.96) 96.01,163.19 96.01,160.15 95.12,159.26 95.12,156.26 96.01,155.37 96.01,153.92 92.46,150.37 92.46,142.49 90.82,140.85 90.82,139.67 89.28,138.14 89.28,135.67 88.49,134.88 88.49,133.87 89.15,133.2 89.15,131.79 89.16,131.79 89.16,131.36 89.15,131.35 89.15,131.06 87.26,129.17 87.26,126.75 86.02,125.52 v1(86.02,124.29)
  BOTTOM w0.14: R12728.2 86.02,122.38 v1(86.02,124.29)
CPU_ME_RCVR_L: length 175
  TOP w0.14: U154.C4 v4(70.53,119.33) ; R1752.2 v1(23.37,165.86)
  T07 w0.117: v1(62.97,157.5) 62.97,157.55 61.26,159.26 55.63,159.26 54.4,158.03 33.61,158.03 33.27,158.37 33.19,158.37 28.44,163.13 28.44,163.63 28.05,164.02 25.21,164.02 v1(23.37,165.86)
  T14 w0.117: v4(70.53,119.33) 70.53,118.76 69.89,118.13 66.36,118.13 66.13,118.36 66.13,120.29 66.13,120.29 66.13,122.64 67.56,124.08 67.56,131.06 65.28,133.35 65.28,135.51 62.61,138.18 62.61,157.13 v1(62.97,157.5)
  T18 w0.117: J1.B79 142.57,157.92 63.4,157.92 v1(62.97,157.5)
CPU_PROCHOT_L: length 109.4
  TOP w0.14: J1.B51 117.02,157.43 117.02,159.32 116.06,160.28 116.06,161.48 115.43,162.11 v1(115.43,168.96) 115.29,169.1 R1751.2 ; U154.B3 v4(71.33,120.13)
  T03 w0.117: v1(76.18,169.29) 76.2,169.29 76.96,170.06 87.19,170.06 88.1,170.97 101.6,170.97 103.92,168.65 115.12,168.65 v1(115.43,168.96)
  T05 w0.117: v1(76.18,169.29) 73.53,166.65 73.53,163.07 75.31,161.29 75.31,152.78 74.83,152.3 74.83,135.03 74.22,134.42 74.22,130.48 73.28,129.54 73.28,124.04 72.64,123.41 72.64,120.9 71.87,120.13 v4(71.33,120.13)
CPU_PRSNT_L: length 114.6
  TOP w0.14: v1(76.58,129.03) 76.58,128.02 75.95,127.38 74.17,127.38 72.9,126.11 72.9,124.1 U154.C1 ; U70.J8 v4(116.4,125.65) ; R1705.2 v1(65.21,169.42)
  T03 w0.117: v1(90.3,126.24) 88.65,127.89 87.63,127.89 84.84,130.68 83.19,130.68 81.53,129.03 v1(76.58,129.03)
  T07 w0.117: v1(65.21,169.42) 64.04,168.26 J1.A1
  T14 w0.117: v4(116.4,125.65) 116,125.25 116,122.09 115.65,121.74 109.46,121.74 108.18,120.46 104.96,120.46 104.71,120.2 103.8,120.2 102.28,121.73 101.85,121.73 97.33,126.24 v1(90.3,126.24)
  T18 w0.117: J1.A1 63.32,158.95 62.36,157.99 62.36,156.46 62.74,156.08 62.74,150.62 63.88,149.48 63.88,142.49 68.96,137.41 74.55,137.41 78.49,133.48 78.49,130.43 77.09,129.03 v1(76.58,129.03)
CPU_PWRGD: length 36.1
  TOP w0.14: U137.1 93.58,174.77 93.73,174.62 94.08,174.62 ; 94.08,174.62 94.21,174.5 R1657.2 94.21,173.73 94.65,173.29 v1(94.74,173.29) 96.2,173.29 97.41,174.5 U138.2 ; 94.08,174.62 94.23,174.78 U137.2
  BOTTOM w0.14: v1(94.74,173.29) 93.29,171.83 88.14,171.83 78.74,162.43 74.91,162.43 74.04,161.56 J1.A11
CPU_THERMTRIP_L: length 197.6
  TOP w0.14: R1750.2 112.63,169.57 v1(113.03,169.16) ; v1(52.07,188.21) 51.82,188.21 51.31,188.72 51.31,189.1 50.98,189.43 U145.2 ; U154.E5 v4(68.93,118.53)
  T03 w0.117: v1(113.03,169.16) 104.09,169.16 101.89,171.37 87.75,171.37 86.81,170.43 79,170.43 77.22,172.21 v1(74.78,172.21)
  T05 w0.117: v4(68.93,118.53) 69.33,118.93 69.9,118.93 70.13,119.15 70.13,121.18 70.53,121.58 70.53,122.23 69.85,122.9 69.85,124.46 68.95,125.36 68.95,128.86 69.79,129.7 69.79,134.56 73.36,138.13 73.36,149.27 69.95,152.67 69.95,155.16 69.03,156.09 69.03,159.4 70.06,160.44 70.06,165.57 73.91,169.42 73.91,171.35 v1(74.78,172.21) ; J1.B50 115.04,159.2 114.22,160.02 114.22,167.97 v1(113.03,169.16)
  T07 w0.117: v1(113.03,169.16) 106.55,169.16 105.92,169.8 105.92,174.62 105.6,174.95 105.6,176.13 101.64,180.08 94.87,180.08 94.32,180.64 75.37,180.64 73.76,182.25 73.76,185.29 72.45,186.6 72.45,187.77 70.99,189.23 65.79,189.23 65.15,188.59 61.34,188.59 60.83,189.1 54.99,189.1 54.4,188.51 52.36,188.51 v1(52.07,188.21)
CPU_TO_BMC_PWRGD: length 81.8
  TOP w0.14: U137.4 94.88,176.93 94.49,176.53 92.46,176.53 v1(91.82,175.9) ; U154.B14 v4(71.33,110.53)
  T05 w0.117: v4(71.33,110.53) 71.33,110.82 74.04,113.54 74.04,124.21 74.55,124.71 74.55,127.51 74.17,127.89 74.17,129.26 74.89,129.98 74.89,134.07 75.99,135.17 75.99,136.53 77.91,138.44 77.91,151.45 75.95,153.42 75.95,161.42 77.6,163.07 80,163.07 88.91,171.97 88.91,172.55 91.82,175.46 v1(91.82,175.9)
CPU_TO_CPLD_PWRGD: length 80.5
  TOP w0.14: v1(98.83,177.3) 98.67,177.46 U138.4
  TOP w0.381: U70.K8 v4(116.4,124.85)
  T03 w0.117: v1(123.58,137.71) 123.58,142.73 122.06,144.25 122.06,152.82 121.83,153.06 121.83,155.24 121.26,155.81 121.26,159.53 122.17,160.43 122.17,172.34 119.58,174.93 115.81,174.93 113.76,176.98 104.03,176.98 103.7,177.3 v1(98.83,177.3)
  T05 w0.117: v4(116.4,124.85) 116.8,125.25 118.24,125.25 118.4,125.42 118.4,133.26 119.51,134.37 119.51,135.38 121.03,136.91 122.78,136.91 v1(123.58,137.71)
DDR3_BMC_AD0: length 19
  TOP w0.14: U155.N3 v4(40.65,112.91) ; U154.AB14 v4(54.27,110.93)
  T03 w0.102: v4(54.27,110.93) 54.22,110.87 53.26,110.87 53.19,110.94
  T03 w0.117: v4(40.65,112.91) 41.11,113.37 41.22,113.48 43.86,113.48 44.48,114.11 44.82,114.11 45.84,115.13 46.09,115.13 46.21,115.02 46.21,114.87 46.33,114.75 46.56,114.75 46.68,114.87 46.68,115.02 46.8,115.13 47.03,115.13 47.15,115.02 47.15,114.87 47.26,114.75 47.5,114.75 47.61,114.87 47.61,115.02 47.73,115.13 47.96,115.13 48.08,115.02 48.08,114.87 48.2,114.75 48.43,114.75 48.55,114.87 48.55,115.02 48.66,115.13 49,115.13 53.19,110.94
DDR3_BMC_AD1: length 19.6
  TOP w0.14: U155.P7 v4(43.85,112.11) ; U154.W15 v4(56.93,109.72)
  T05 w0.117: v4(56.93,109.72) 56.53,109.32 56.53,107.96 56.29,107.72 55.16,107.72 54.76,107.32 47.03,107.32 44.24,110.11 43.68,110.11 43.41,110.38 43.41,111.67 v4(43.85,112.11)
DDR3_BMC_AD2: length 22.8
  TOP w0.14: U155.P3 v4(40.65,112.11) ; U154.V15 v4(57.73,109.72)
  T07 w0.117: v4(40.65,112.11) 41.51,112.97 42.17,113.63 44,113.63 44.48,114.11 44.82,114.11 45.05,113.88 45.05,113.55 45.28,113.31 45.62,113.31 45.85,113.08 45.85,111.93 46.17,111.61 46.17,111.23 48.76,108.65 53.83,108.65 54.11,108.92 54.44,108.92 54.84,109.32 57.33,109.32 v4(57.73,109.72)
DDR3_BMC_AD3: length 20.1
  TOP w0.14: U155.N2 v4(39.85,112.91) ; U154.Y16 v4(56.13,108.92)
  T05 w0.117: v4(56.13,108.92) 55.73,108.52 55.09,108.52 54.69,108.12 48.39,108.12 45.85,110.67 45.85,110.68 45.62,110.91 45.28,110.91 45.05,111.15 45.05,111.48 44.82,111.71 44.48,111.71 44.25,111.95 44.25,112.28 44.02,112.51 40.25,112.51 v4(39.85,112.91)
DDR3_BMC_AD4: length 18.7
  TOP w0.14: U154.AB15 54.85,110.05 54.34,110.05 v4(54.27,110.13) ; U155.P8 v4(44.65,112.11)
  T03 w0.117: v4(54.27,110.13) 53.77,110.13 53.54,109.9 52.47,109.9 52.44,109.93 51.79,109.93 51.2,110.52 51.04,110.52 50.6,110.08 50.44,110.08 50.27,110.25 50.27,110.42 50.71,110.85 50.71,111.02 50.54,111.18 50.38,111.18 49.91,110.71 49.74,110.71 49.57,110.88 49.57,111.04 49.66,111.12 50.04,111.51 50.04,111.68 49.88,111.84 49.71,111.84 49.66,111.79 49.24,111.37 49.08,111.37 48.91,111.54 48.91,111.7 49.38,112.17 49.38,112.34 49.21,112.51 48.69,112.51 48.57,112.63 48.57,112.86 48.45,112.98 48.22,112.98 48.1,112.86 48.1,112.63 47.99,112.51 47.75,112.51 47.64,112.63 47.64,112.86 47.52,112.98 47.29,112.98 47.17,112.86 47.17,112.63 47.05,112.51 46.82,112.51 46.7,112.63 46.7,112.86 46.58,112.98 46.35,112.98 46.23,112.86 46.23,112.63 46.12,112.51 U155.P8 v4(44.65,112.11)
DDR3_BMC_AD5: length 22.7
  TOP w0.14: U155.P2 v4(39.85,112.11) ; U154.W16 v4(56.93,108.92)
  T07 w0.117: v4(56.93,108.92) 56.53,108.52 54.84,108.52 54.44,108.12 54.11,108.12 54,108.02 48.37,108.02 45.85,110.54 45.85,111.48 45.62,111.71 45.27,111.71 45.05,111.93 45.05,112.41 44.95,112.51 44.48,112.51 44.25,112.75 44.25,113.15 44.09,113.31 42.42,113.31 41.79,112.69 40.82,111.71 40.25,111.71 v4(39.85,112.11)
DDR3_BMC_AD6: length 18.7
  TOP w0.14: U155.R8 v4(44.65,111.31) ; U154.AA15 v4(55.33,109.72)
  T03 w0.117: v4(44.65,111.31) U155.R8 46.1,111.71 46.21,111.83 46.21,111.97 46.33,112.09 46.56,112.09 46.68,111.97 46.68,111.83 46.8,111.71 47.72,111.71 47.91,111.52 47.91,111.36 47.51,110.95 47.51,110.79 47.67,110.62 47.84,110.62 48.24,111.03 48.41,111.03 48.57,110.86 48.57,110.7 48.17,110.29 48.17,110.13 48.33,109.96 48.5,109.96 48.9,110.37 49.07,110.37 49.24,110.2 49.24,110.04 48.78,109.58 48.78,109.42 48.95,109.25 49.11,109.25 49.57,109.7 49.73,109.7 50.41,109.02 50.66,109.02 50.77,109.14 50.77,109.26 50.89,109.37 51.14,109.37 51.24,109.27 51.24,109.14 51.36,109.02 51.59,109.02 51.71,109.14 51.71,109.18 51.82,109.29 52.06,109.29 52.18,109.18 52.18,109.14 52.29,109.02 52.92,109.02 52.93,109.03 53.19,109.03 53.88,109.72 v4(55.33,109.72)
DDR3_BMC_AD7: length 18.7
  TOP w0.14: U154.AB18 v4(54.27,107.72) ; U155.R2 v4(39.85,111.31)
  T03 w0.117: v4(54.27,107.72) 54.27,106.85 53.92,106.5 45.95,106.5 41.14,111.31 v4(39.85,111.31)
DDR3_BMC_AD8: length 18.6
  TOP w0.14: U154.AB16 v4(54.27,109.32) ; v4(46.08,109.29) 46.08,108.9 45.71,108.53 45.05,108.53 44.68,108.9 44.68,110.54 U155.T8
  T03 w0.117: v4(54.27,109.32) 53.99,109.32 53.56,108.9 53.56,108.78 53.18,108.4 48.88,108.4 48.5,108.78 48.33,108.78 48.11,108.57 47.95,108.57 47.78,108.73 47.78,108.9 48,109.11 48,109.28 47.83,109.44 47.67,109.44 47.45,109.23 47.29,109.23 47.12,109.39 47.12,109.56 47.34,109.77 47.34,109.94 47.17,110.11 46.88,110.11 46.76,110.23 46.76,111.08 46.65,111.2 46.41,111.2 46.3,111.08 46.3,110.23 45.95,109.88 45.95,109.42 v4(46.08,109.29)
DDR3_BMC_AD9: length 19.6
  TOP w0.14: U154.AA17 v4(55.33,108.12) ; v4(41.79,109.7) 41.79,110.97 U155.R3
  T03 w0.117: v4(41.79,109.7) 45.62,105.86 54.17,105.86 54.74,106.43 54.74,107.54 v4(55.33,108.12)
DDR3_BMC_AD10: length 18.6
  TOP w0.14: U155.L7 v4(43.85,114.51) ; U154.Y15 v4(56.13,109.72)
  T03 w0.117: v4(56.13,109.72) 55.73,110.13 55.73,110.69 55.49,110.93 55.1,110.93 54.88,111.15 54.88,112.28 54.11,113.04 52.86,113.04 49.5,116.4 48.98,116.4 44.56,116.4 44.25,116.1 44.25,115.15 43.85,114.75 v4(43.85,114.51)
DDR3_BMC_AD11: length 18.9
  TOP w0.102: v4(43.85,111.31) 43.61,111.07 43.05,111.07 42.91,111.21 42.91,111.49 43.13,111.71 U155.R7
  TOP w0.14: U154.AA16 v4(55.33,108.92)
  T03 w0.117: v4(43.85,111.31) 44.05,111.31 44.25,111.11 44.25,109.97 44.71,109.51 44.88,109.51 44.88,109.51 45.04,109.51 45.21,109.35 45.21,109.18 45.21,109.18 45.21,109.02 46.45,107.77 46.78,107.77 46.9,107.89 46.9,108.33 47.01,108.45 47.18,108.45 47.36,108.27 47.36,107.89 47.48,107.77 53.3,107.77 53.87,108.34 53.87,108.69 54.11,108.92 v4(55.33,108.92)
DDR3_BMC_AD12: length 18.5
  TOP w0.14: U154.W17 v4(56.93,108.12) ; U155.N7 v4(43.85,112.91)
  T07 w0.117: v4(56.93,108.12) 56.53,107.72 54.84,107.72 54.44,107.32 46.9,107.32 45.05,109.18 45.05,111.48 44.82,111.71 44.48,111.71 44.25,111.95 44.25,112.28 43.85,112.68 v4(43.85,112.91)
DDR3_BMC_AD13: length 22.1
  TOP w0.14: U155.T3 v4(41.05,110.18) ; U154.Y17 v4(56.13,108.12)
  T03 w0.102: 55.04,105.33 56.29,105.33 56.52,105.56 56.52,107.73 v4(56.13,108.12)
  T03 w0.117: 55.04,105.33 53.82,105.33 53.72,105.24 45.29,105.24 41.05,109.47 v4(41.05,110.18)
DDR3_BMC_AD14: length 22.7
  TOP w0.14: U155.T7 v4(43.85,110.51) ; v4(54.27,108.52) 54.5,108.3 54.7,108.3 U154.AB17
  T03 w0.117: v4(54.27,108.52) 54.27,108.29 53.87,107.89 53.87,107.24 53.75,107.12 46.22,107.12 41.38,111.96 41.38,112.85 41.51,112.98 42.85,112.98 43.29,112.54 43.29,111.07 43.84,110.51 v4(43.85,110.51)
DDR3_BMC_BA0: length 22.5
  TOP w0.14: U155.M2 v4(39.85,113.71) ; U154.W14 v4(56.93,110.53)
  T07 w0.117: v4(39.85,113.71) U155.M2 44.03,114.11 44.25,114.33 44.25,114.68 44.48,114.91 44.82,114.91 46.17,113.56 46.17,112.12 48.87,109.42 53.8,109.42 54.11,109.72 54.44,109.72 54.84,110.13 56.53,110.13 v4(56.93,110.53)
DDR3_BMC_BA1: length 18.8
  TOP w0.14: U155.N8 v4(44.65,112.91) ; U154.AA14 v4(55.33,110.53)
  T03 w0.117: v4(44.65,112.91) 44.65,113.15 45.05,113.55 45.05,113.88 45.28,114.11 46.14,114.11 46.26,114 46.26,113.73 46.37,113.61 46.61,113.61 46.72,113.73 46.72,114 46.84,114.12 47.07,114.12 47.19,114 47.19,113.73 47.31,113.61 47.54,113.61 47.66,113.73 47.66,114 47.78,114.12 48.01,114.12 48.13,114 48.13,113.73 48.24,113.61 48.48,113.61 48.59,113.73 48.59,114 48.71,114.12 49.13,114.12 49.35,113.91 49.35,113.74 49.25,113.65 49.25,113.48 49.42,113.32 49.59,113.32 49.68,113.41 49.84,113.41 50.01,113.24 50.01,113.08 49.92,112.99 49.92,112.82 50.08,112.66 50.25,112.66 50.34,112.75 50.5,112.75 50.67,112.58 50.67,112.42 50.58,112.33 50.58,112.16 50.74,111.99 50.91,111.99 51,112.09 51.16,112.09 51.33,111.92 51.33,111.76 51.24,111.66 51.24,111.5 51.4,111.33 51.57,111.33 51.66,111.43 51.83,111.43 51.99,111.26 51.99,111.09 51.9,111 51.9,110.84 52.07,110.67 52.23,110.67 52.32,110.76 52.49,110.76 52.73,110.53 54.53,110.53 54.74,110.31 55.11,110.31 v4(55.33,110.53)
DDR3_BMC_BA2: length 20
  TOP w0.14: U154.Y14 v4(56.13,110.53) ; U155.M3 v4(40.65,113.71)
  T05 w0.117: v4(40.65,113.71) 43.62,113.71 44.25,113.08 44.25,112.75 44.48,112.51 45.62,112.51 45.85,112.28 45.85,111.93 48.86,108.92 54.76,108.92 55.16,109.32 55.49,109.32 55.73,109.56 55.73,109.89 56.13,110.29 v4(56.13,110.53)
DDR3_BMC_CAS_N: length 18.6
  TOP w0.14: U155.K3 v4(40.65,115.31) ; v4(53.7,111.33) 54.09,111.71 54.7,111.71 54.72,111.73 U154.AB13
  T03 w0.117: v4(53.7,111.33) 53.69,111.33 49.24,115.78 47.09,115.78 46.97,115.9 45.47,115.9 45.05,115.48 45.05,115.15 44.82,114.91 44.48,114.91 44.25,114.68 44.25,114.33 43.91,113.99 41.97,113.99 v4(40.65,115.31)
DDR3_BMC_CKE: length 18.5
  TOP w0.14: U154.Y12 v4(56.13,112.13) ; U155.K9 v4(45.45,115.31)
  T05 w0.117: v4(56.13,112.13) 55.53,112.72 53.06,112.72 50.47,115.31 50.21,115.31 50.1,115.2 50.1,114.62 49.98,114.5 49.75,114.5 49.63,114.62 49.63,115.2 49.51,115.31 49.28,115.31 49.16,115.2 49.16,114.62 49.04,114.5 48.81,114.5 48.69,114.62 48.69,115.2 48.58,115.31 48.34,115.31 48.23,115.2 48.23,114.62 48.11,114.5 47.88,114.5 47.76,114.62 47.76,115.2 47.64,115.31 47.41,115.31 47.29,115.2 47.29,114.62 47.17,114.5 46.94,114.5 46.82,114.62 46.82,115.2 46.71,115.31 v4(45.45,115.31)
DDR3_BMC_CLK_DN0: length 23.3
  TOP w0.104: v4(54.46,112.13) 54.5,112.17 55.37,112.17 U154.AA12
  TOP w0.14: U155.K7 v4(43.85,115.31)
  T07 w0.107: v4(54.46,112.13) 54.09,111.75 52.99,111.75 52.88,111.65 52.88,111.21 52.61,110.94 52.17,110.94 51.9,111.21 51.9,112.21 51.79,112.32 51.58,112.32 51.47,112.21 51.47,111.21 51.2,110.94 50.75,110.94 50.48,111.21 50.48,111.86 49.36,112.98 49.21,112.98 48.85,112.62 48.47,112.62 48.15,112.94 48.15,113.32 48.51,113.68 48.51,113.83 48.36,113.98 48.21,113.98 47.85,113.62 47.47,113.62 47.15,113.94 47.15,114.32 47.51,114.68 47.51,114.83 47.36,114.98 47.21,114.98 46.85,114.62 46.47,114.62 46.15,114.93 46.15,115.32 46.51,115.68 46.51,115.83 46.32,116.03 44.35,116.03 43.85,115.52 v4(43.85,115.31)
  BOTTOM w0.102: R12315.1 43.23,115.29 43.77,115.29 43.8,115.31 v4(43.85,115.31)
DDR3_BMC_CLK_DP0: length 23.3
  TOP w0.104: U154.AB12 55.15,112.53 55.26,112.64 55.26,112.78 55.14,112.91 54.53,112.91 v4(53.78,112.15)
  TOP w0.14: U155.J7 v4(43.85,116.11)
  T07 w0.107: v4(43.85,116.11) 44.05,116.11 44.24,116.31 44.82,116.31 44.99,116.48 45.14,116.48 45.31,116.31 46.43,116.31 46.79,115.94 46.79,115.56 46.43,115.2 46.43,115.05 46.58,114.9 46.73,114.9 47.09,115.26 47.48,115.26 47.79,114.95 47.79,114.56 47.43,114.2 47.43,114.05 47.58,113.9 47.73,113.9 48.09,114.26 48.48,114.26 48.79,113.95 48.79,113.56 48.43,113.2 48.43,113.05 48.58,112.9 48.73,112.9 49.09,113.26 49.48,113.26 50.76,111.97 50.76,111.33 50.87,111.22 51.08,111.22 51.19,111.33 51.19,112.32 51.46,112.59 51.91,112.59 52.18,112.32 52.18,111.33 52.28,111.22 52.5,111.22 52.6,111.33 52.6,111.76 52.87,112.03 53.66,112.03 v4(53.78,112.15)
  BOTTOM w0.102: R12315.2 43.18,116.05 43.75,116.05 43.81,116.11 v4(43.85,116.11)
DDR3_BMC_CS0_N: length 23.5
  TOP w0.14: U155.L2 v4(39.85,114.51) ; U154.AA13 v4(55.33,111.33)
  T03 w0.117: v4(39.85,114.51) U155.L2 40.25,115.61 40.52,115.88 42.1,115.88 43.53,117.31 46.13,117.31 46.93,118.11 49.45,118.11 50.16,117.4 50.16,116.97 51.05,116.08 53.91,116.08 54.84,115.14 54.84,113.1 55.33,112.62 v4(55.33,111.33)
DDR3_BMC_DM0: length 24.6
  TOP w0.102: U155.E7 v4(43.85,119.31)
  TOP w0.14: U154.W10 v4(56.93,114.53)
  T14 w0.117: v4(43.85,119.31) 44.07,119.31 44.47,119.71 45.62,119.71 47.73,117.6 47.73,116.64 47.61,116.52 47.34,116.52 47.22,116.41 47.22,116.17 47.34,116.06 47.61,116.06 47.73,115.94 47.73,115.7 47.61,115.59 47.34,115.59 47.22,115.47 47.22,115.24 47.34,115.12 47.61,115.12 47.73,115 47.73,114.77 47.61,114.65 47.34,114.65 47.22,114.54 47.22,114.3 47.34,114.19 47.61,114.19 47.73,114.07 47.73,113.84 47.61,113.72 47.34,113.72 47.22,113.6 47.22,113.37 47.34,113.25 47.61,113.25 47.73,113.13 47.73,113.09 47.97,112.85 52.43,112.85 53.7,114.12 54.12,114.12 55.01,113.23 56.2,113.23 56.53,113.56 56.53,114.13 v4(56.93,114.53)
DDR3_BMC_DM1: length 34
  TOP w0.102: U155.D3 v4(40.65,120.11)
  TOP w0.14: U154.V8 v4(57.73,116.13)
  T07 w0.117: v4(57.73,116.13) 57.33,116.53 57.33,117.09 57.09,117.33 56.76,117.33 56.53,117.56 56.53,121.2 56.11,121.61 56.11,122.12 54.95,123.28 54.95,124.37 51.88,127.44 42.27,127.44 41.91,127.08 39.62,124.79 39.62,123.19 39.45,123.02 39.45,120.75 39.68,120.51 40.25,120.51 v4(40.65,120.11)
DDR3_BMC_DQ0: length 25.2
  TOP w0.14: U155.H7 v4(43.85,116.91) ; U154.W12 v4(56.93,112.13)
  T14 w0.117: v4(43.85,116.91) U155.H7 45.61,117.31 45.85,117.08 45.85,111.05 46.3,110.6 46.62,110.6 47.3,109.92 47.6,109.92 47.71,110.03 47.71,110.2 47.83,110.32 48.06,110.32 48.18,110.2 48.18,110.03 48.3,109.92 48.53,109.92 48.65,110.03 48.65,110.2 48.76,110.32 49,110.32 49.12,110.2 49.12,110.03 49.23,109.92 49.47,109.92 49.58,110.03 49.58,110.2 49.7,110.32 49.93,110.32 50.05,110.2 50.05,110.03 50.17,109.92 50.4,109.92 50.52,110.03 50.52,110.2 50.63,110.32 50.87,110.32 50.98,110.2 50.98,110.03 51.1,109.92 51.34,109.92 51.45,110.03 51.45,110.2 51.57,110.32 51.8,110.32 51.92,110.2 51.92,110.03 52.04,109.92 52.27,109.92 52.39,110.03 52.39,110.2 52.5,110.32 52.74,110.32 52.85,110.2 52.85,110.03 52.97,109.92 53.5,109.92 54.11,110.53 54.44,110.53 54.84,110.93 55.49,110.93 55.73,111.16 55.73,111.49 55.96,111.73 56.53,111.73 v4(56.93,112.13)
DDR3_BMC_DQ1: length 24.7
  TOP w0.14: v1(42.27,118.18) 41.4,117.31 U155.H3 ; U154.V12 v4(57.73,112.13)
  T14 w0.117: v4(57.73,112.13) 57.33,112.53 55.47,112.53 54.67,111.73 53.46,111.73 52.68,110.94 47.22,110.94 46.21,111.96 46.21,117.52 45.62,118.11 42.34,118.11 v1(42.27,118.18)
DDR3_BMC_DQ2: length 26.7
  TOP w0.14: U154.AB11 54.52,113.33 53.92,112.72 52.43,112.72 52.3,112.85 52.3,113.36 52.56,113.61 53.84,113.61 v4(53.95,113.72) ; U155.F8 v4(44.65,118.51)
  T14 w0.117: v4(53.95,113.72) 53.95,113.23 52.29,111.57 51.35,111.57 51.24,111.69 51.24,112.1 51.12,112.21 50.89,112.21 50.77,112.1 50.77,111.69 50.65,111.57 50.42,111.57 50.3,111.69 50.3,112.1 50.18,112.21 49.95,112.21 49.83,112.1 49.83,111.69 49.72,111.57 49.48,111.57 49.37,111.69 49.37,112.1 49.25,112.21 49.02,112.21 48.9,112.1 48.9,111.69 48.78,111.57 48.55,111.57 48.43,111.69 48.43,112.1 48.31,112.21 48.08,112.21 47.96,112.1 47.96,111.69 47.85,111.57 47.6,111.57 46.59,112.58 46.59,117.94 45.62,118.91 45.05,118.91 v4(44.65,118.51)
DDR3_BMC_DQ3: length 24.7
  TOP w0.14: U155.F7 v4(43.85,118.51) ; U154.AA11 v4(55.33,113.73)
  T14 w0.117: v4(43.85,118.51) 43.45,118.91 43.45,119.48 43.68,119.71 44.02,119.71 44.25,119.95 44.25,120.28 44.48,120.51 45.7,120.51 46.29,119.93 46.45,119.93 46.62,120.1 46.79,120.1 46.95,119.93 46.95,119.77 46.78,119.6 46.78,119.43 46.95,119.27 47.11,119.27 47.28,119.44 47.45,119.44 47.62,119.27 47.62,119.11 47.44,118.93 47.44,118.77 47.61,118.6 47.77,118.6 47.95,118.78 48.11,118.78 48.28,118.61 48.28,118.45 48.1,118.27 48.1,118.11 48.49,117.72 48.49,116.36 48.61,116.24 48.76,116.24 48.87,116.12 48.87,115.89 48.76,115.77 48.61,115.77 48.49,115.66 48.49,115.42 48.61,115.3 48.76,115.3 48.87,115.19 48.87,114.95 48.76,114.84 48.61,114.84 48.49,114.72 48.49,113.73 48.74,113.48 49.12,113.48 49.22,113.59 49.22,113.97 49.32,114.07 49.47,114.07 49.57,113.97 49.57,113.59 49.67,113.48 52.06,113.48 53.02,114.44 54.61,114.44 v4(55.33,113.73)
DDR3_BMC_DQ4: length 26.9
  TOP w0.14: U155.F2 v4(39.85,118.51) ; U154.Y11 v4(56.13,113.73)
  T14 w0.117: v4(56.13,113.73) 54.93,114.93 54.93,117.46 54.66,117.73 53.72,117.73 47.49,123.96 43.28,123.96 41.05,121.73 41.05,119.15 40.82,118.91 U155.F2 v4(39.85,118.51)
DDR3_BMC_DQ5: length 33.4
  TOP w0.14: U154.W11 v4(56.93,113.73) ; U155.G2 v4(39.85,117.71)
  T14 w0.117: v4(39.85,117.71) 39.45,118.11 39.45,122.75 41.91,125.21 48.63,125.21 53.71,120.13 54.76,120.13 55.16,119.73 56.29,119.73 56.53,119.49 56.53,115.16 56.76,114.93 57.09,114.93 57.33,114.69 57.33,113.93 57.12,113.73 v4(56.93,113.73)
DDR3_BMC_DQ6: length 24.9
  TOP w0.14: U155.H8 v4(44.65,116.91) ; U154.V11 v4(57.73,113.73)
  T14 w0.117: v4(57.73,113.73) U154.V11 58.13,111.96 57.89,111.73 57.56,111.73 57.33,111.49 57.33,111.16 57.09,110.93 56.76,110.93 56.53,110.69 56.53,110.36 56.29,110.13 54.84,110.13 54.44,109.72 54.11,109.72 53.67,109.29 47.04,109.29 46.36,109.97 45.27,109.97 45.05,110.19 45.05,116.51 v4(44.65,116.91)
DDR3_BMC_DQ7: length 27.7
  TOP w0.102: U155.E3 v4(40.65,119.31)
  TOP w0.14: U154.Y10 v4(56.13,114.53)
  T14 w0.117: v4(56.13,114.53) 55.73,114.93 55.73,118.69 55.49,118.93 55.12,118.93 54.72,119.33 53.01,119.33 47.75,124.58 42.83,124.58 41.16,122.91 40.48,122.91 40.25,122.68 40.25,119.71 v4(40.65,119.31)
DDR3_BMC_DQ8: length 24.5
  TOP w0.102: U155.D7 v4(43.85,120.11)
  TOP w0.14: U154.V10 v4(57.73,114.53)
  T07 w0.117: v4(57.73,114.53) U154.V10 58.13,113.56 58.14,113.54 58.14,113.09 57.77,112.72 54.21,112.72 53.57,113.36 50.47,113.36 47.62,116.2 47.24,116.2 46.71,116.73 46.71,117.7 46.6,117.82 46.07,117.82 45.95,117.93 45.95,118.17 46.07,118.28 46.6,118.28 46.71,118.4 46.71,118.63 46.6,118.75 46.07,118.75 45.95,118.87 45.95,119.1 46.07,119.22 46.65,119.22 46.77,119.34 46.77,119.58 46.64,119.71 44.25,119.71 v4(43.85,120.11)
DDR3_BMC_DQ9: length 24.3
  TOP w0.102: U155.B8 v4(44.65,121.71)
  TOP w0.14: U154.AB9 v4(54.38,114.93)
  T07 w0.117: v4(44.65,121.71) 44.65,121.87 44.9,122.11 45.91,122.11 46.1,122.3 46.1,122.76 46.27,122.94 46.7,122.94 46.86,122.78 46.86,122.15 46.96,122.05 47.11,122.05 47.21,122.15 47.21,122.78 47.31,122.88 47.94,122.88 48.21,122.61 48.21,122.44 47.96,122.19 47.96,122.02 48.12,121.86 48.29,121.86 48.54,122.11 48.71,122.11 48.87,121.95 48.87,121.78 48.62,121.53 48.62,121.36 48.78,121.2 48.95,121.2 49.2,121.45 49.37,121.45 49.53,121.28 49.53,121.12 49.41,120.99 49.41,120.83 49.57,120.66 49.74,120.66 49.86,120.79 50.03,120.79 50.28,120.54 50.28,120.29 50.16,120.17 49.5,120.17 49.38,120.06 49.38,119.82 49.5,119.71 50.16,119.71 50.28,119.59 50.28,119.36 50.16,119.24 49.5,119.24 49.38,119.12 49.38,118.89 49.5,118.77 49.79,118.77 49.91,118.65 49.91,116.58 50.48,116 51.61,116 52.05,115.57 53.9,115.57 54.38,115.09 v4(54.38,114.93)
DDR3_BMC_DQ10: length 25.1
  TOP w0.14: v4(43.85,122.51) 43.7,122.51 43.54,122.68 43.54,123.25 43.7,123.41 44.15,123.41 44.25,123.31 U155.A7 ; U154.AA9 v4(55.33,115.33)
  T07 w0.117: v4(55.33,115.33) 54.6,115.33 54.04,115.89 52.24,115.89 51.79,116.33 51.4,116.33 51.11,116.63 50.74,116.63 50.55,116.82 50.55,117.72 50.66,117.83 51.42,117.83 51.54,117.95 51.54,118.18 51.42,118.3 51.02,118.3 50.91,118.42 50.91,118.65 51.02,118.77 51.42,118.77 51.54,118.89 51.54,119.12 51.42,119.24 51.02,119.24 50.91,119.35 50.91,119.59 51.02,119.7 51.42,119.7 51.54,119.82 51.54,120.05 51.42,120.17 51.02,120.17 50.91,120.29 50.91,120.8 48.19,123.51 45.91,123.51 45.32,122.91 44.91,122.91 44.8,123.03 44.8,123.4 44.68,123.52 44.45,123.52 44.33,123.4 44.33,123.03 44.21,122.91 43.97,122.91 43.85,122.8 v4(43.85,122.51)
DDR3_BMC_DQ11: length 27.2
  TOP w0.14: U154.Y9 v4(56.13,115.33) ; v4(42.02,121.36) 41.97,121.31 U155.C3
  T07 w0.117: v4(56.13,115.33) 55.89,115.33 55.49,115.73 55.14,115.73 54.73,116.13 54.73,116.69 54.5,116.93 53.94,116.93 53.48,117.39 53.48,121.84 53.07,122.24 53.07,123.51 51.04,125.55 43.03,125.55 42.02,124.53 v4(42.02,121.36)
DDR3_BMC_DQ12: length 24.5
  TOP w0.102: U155.C2 v4(39.85,120.91)
  TOP w0.14: U154.W9 v4(56.93,115.33)
  T07 w0.117: v4(56.93,115.33) 56.69,115.33 56.29,114.93 55.96,114.93 55.53,114.5 51.1,114.5 48.49,117.11 48.49,120.6 47.78,121.31 47.48,121.31 47.37,121.43 47.37,121.49 47.25,121.61 47.02,121.61 46.9,121.49 46.9,121.43 46.78,121.31 44.38,121.31 44.25,121.18 44.25,120.75 44.02,120.51 41.59,120.51 41.19,120.91 v4(39.85,120.91)
DDR3_BMC_DQ13: length 24.5
  TOP w0.102: U155.C8 v4(44.65,120.91)
  TOP w0.14: U154.V9 v4(57.73,115.33)
  T07 w0.117: v4(44.65,120.91) 44.65,120.79 44.93,120.51 47.7,120.51 47.87,120.34 47.87,120.1 47.75,119.98 47.34,119.98 47.22,119.87 47.22,119.63 47.34,119.51 47.75,119.51 47.87,119.4 47.87,119.16 47.75,119.05 47.34,119.05 47.22,118.93 47.22,118.7 47.34,118.58 47.75,118.58 47.87,118.46 47.87,118.23 47.75,118.11 47.34,118.11 47.22,118 47.22,117.76 47.34,117.65 47.75,117.65 47.87,117.53 47.87,116.85 50.73,113.99 53.51,113.99 53.65,114.12 54.36,114.12 55.26,113.23 57.21,113.23 57.33,113.35 57.33,114.93 v4(57.73,115.33)
DDR3_BMC_DQ14: length 25.4
  TOP w0.14: U154.Y8 v4(56.13,116.13) ; U155.A3 41.05,123.59 v4(41,123.64)
  T07 w0.117: v4(56.13,116.13) 56.13,116.14 55.73,116.53 55.73,116.66 55.73,116.66 55.73,117.09 55.49,117.33 55.06,117.33 54.84,117.55 54.84,120.78 54,121.62 54,121.94 53.7,122.24 53.7,123.77 51.28,126.19 42.79,126.19 41,124.4 41,123.65 v4(41,123.64)
DDR3_BMC_DQ15: length 28.7
  TOP w0.102: U155.A2 v4(39.85,122.51)
  TOP w0.14: U154.W8 v4(56.93,116.13)
  T07 w0.117: v4(39.85,122.51) 40.37,123.04 40.37,124.66 42.53,126.82 51.54,126.82 54.32,124.03 54.32,122.49 55.73,121.09 55.73,117.56 55.96,117.33 56.29,117.33 56.53,117.09 56.53,116.53 v4(56.93,116.13)
DDR3_BMC_DQS_DN0: length 29.4
  TOP w0.102: 52.94,114.39 52.93,114.39 52.7,114.62 52.7,114.77 v4(52.94,115.01) ; U154.AA10 55.07,114.48
  TOP w0.104: 55.07,114.48 54.78,114.48 54.68,114.39 52.94,114.39
  TOP w0.14: U155.G3 v4(40.65,117.71)
  T14 w0.107: v4(52.94,115.01) 52.81,114.88 52.81,114.75 52.29,114.23 51.16,114.23 50.14,115.25 50.14,118.93 49.6,119.47 49.45,119.47 49.15,119.17 48.77,119.17 48.45,119.49 48.45,119.87 48.75,120.17 48.75,120.32 48.6,120.47 48.45,120.47 48.15,120.17 47.77,120.17 47.46,120.49 47.46,120.87 47.75,121.17 47.75,121.32 45.71,123.36 43.53,123.36 43.03,122.87 43.03,119.69 41.31,117.97 40.91,117.97 v4(40.65,117.71)
DDR3_BMC_DQS_DN1: length 29.3
  TOP w0.102: 52.45,116.33 52.25,116.53 v4(52.25,116.61) ; U155.B7 44.25,121.85 44.12,121.71 v4(43.85,121.71)
  TOP w0.104: 52.45,116.33 52.45,116.2 52.79,115.86 53.11,115.86 53.22,115.76 53.22,115.62 53.32,115.52 53.53,115.52 53.64,115.62 53.64,115.76 53.74,115.86 54.81,115.86 54.93,115.75 U154.AB8
  T07 w0.107: v4(43.85,121.71) 43.85,121.56 43.74,121.45 43.35,121.45 43.18,121.62 43.18,122.1 43.29,122.21 43.31,122.21 43.41,122.32 43.41,122.53 43.31,122.64 43.29,122.64 43.18,122.74 43.18,122.96 43.29,123.06 43.37,123.06 43.48,123.17 43.48,123.38 43.37,123.49 43.29,123.49 43.18,123.6 43.18,123.89 43.7,124.41 44.88,124.41 45.01,124.28 45.31,124.28 45.44,124.41 45.74,124.41 45.86,124.28 46.16,124.28 46.29,124.41 48.35,124.41 48.81,123.95 49.19,123.95 49.75,124.51 49.9,124.51 50.05,124.36 50.05,124.21 49.49,123.65 49.49,123.27 49.81,122.95 50.19,122.95 51.13,123.89 51.24,123.89 51.43,123.7 51.43,123.59 50.49,122.65 50.49,122.27 50.8,121.95 51.81,121.95 52.02,121.74 52.02,121.59 51.79,121.35 51.79,120.97 52.45,120.3 52.45,120.06 52.3,119.91 52.3,119.63 52.45,119.48 52.45,119.21 52.3,119.05 52.3,118.78 52.45,118.63 52.45,118.35 52.3,118.2 52.3,117.93 52.45,117.77 52.45,116.81 v4(52.25,116.61)
DDR3_BMC_DQS_DP0: length 29.3
  TOP w0.102: v4(52.25,115.01) 52.49,114.77 52.49,114.54 52.91,114.12
  TOP w0.104: 52.91,114.12 54.92,114.12 U154.AB10
  TOP w0.14: v4(40.65,118.51) 40.91,118.51 41.05,118.65 U155.F3
  T14 w0.107: v4(40.65,118.51) 40.91,118.25 41.2,118.25 41.55,118.61 41.55,118.83 41.76,119.04 41.98,119.04 42.16,119.21 42.16,119.39 42.41,119.64 42.59,119.64 42.75,119.81 42.75,120.28 42.57,120.46 42.57,120.71 42.75,120.89 42.75,121.14 42.57,121.31 42.57,121.56 42.75,121.74 42.75,122.98 43.41,123.64 45.83,123.64 46.5,122.97 46.75,122.97 46.95,122.77 46.95,122.52 47.1,122.37 47.35,122.37 47.55,122.17 47.55,121.92 48.03,121.44 48.03,121.05 47.73,120.76 47.73,120.61 47.89,120.45 48.04,120.45 48.34,120.75 48.72,120.75 49.03,120.44 49.03,120.05 48.73,119.76 48.73,119.61 48.89,119.45 49.04,119.45 49.33,119.75 49.72,119.75 50.42,119.05 50.42,115.37 51.28,114.51 52.17,114.51 52.38,114.72 52.38,114.87 v4(52.25,115.01)
DDR3_BMC_DQS_DP1: length 29.4
  TOP w0.102: U155.C7 v4(43.85,120.91) ; 52.76,116.43 v4(52.94,116.61)
  TOP w0.104: U154.AA8 55.73,115.9 55.5,116.13 52.9,116.13 52.76,116.28 52.76,116.43
  T07 w0.107: v4(52.94,116.61) 52.73,116.81 52.73,120.42 52.07,121.08 52.07,121.24 52.3,121.47 52.3,121.85 51.93,122.23 50.92,122.23 50.77,122.38 50.77,122.53 51.71,123.47 51.71,123.82 51.36,124.17 51.01,124.17 50.07,123.23 49.92,123.23 49.77,123.38 49.77,123.53 50.33,124.09 50.33,124.47 50.01,124.79 49.63,124.79 49.07,124.23 48.92,124.23 48.47,124.69 43.58,124.69 42.9,124.01 42.9,121.5 43.23,121.17 43.59,121.17 v4(43.85,120.91)
DDR3_BMC_MVREF: length 12.5
  TOP w0.254: U154.V13 v4(57.73,111.33)
  BOTTOM w0.381: C2170.2 50.26,108.84 49.88,108.46 44.83,108.46 42.04,111.25 R12988.2
  vias: v2(51.76,112.76) v2(51.87,110.47) v2(53.03,112.76) v2(53.14,110.47) v2(55.24,112.78)
DDR3_BMC_ODT: length 24.4
  TOP w0.14: U155.K1 v4(39.05,115.31) ; U154.V14 v4(57.73,110.53)
  T07 w0.117: v4(57.73,110.53) 57.33,110.93 54.84,110.93 54.44,110.53 54.11,110.53 53.62,110.04 49.26,110.04 46.49,112.82 46.49,113.69 45.05,115.13 45.05,115.54 44.88,115.71 44.48,115.71 44.25,115.48 44.25,115.15 44.02,114.91 43.1,114.91 42.75,115.26 41.17,115.26 40.82,114.91 39.45,114.91 v4(39.05,115.31)
DDR3_BMC_RAS_N: length 19.8
  TOP w0.14: U155.J3 v4(41.76,116.51) ; U154.W13 v4(56.93,111.33)
  T05 w0.117: v4(41.76,116.51) 41.76,115.9 42.75,114.91 44.82,114.91 49.04,110.69 52.05,110.69 53.08,111.73 56.53,111.73 v4(56.93,111.33)
DDR3_BMC_WE_N: length 19.9
  TOP w0.14: U154.Y13 v4(56.13,111.33) ; U155.L3 v4(40.65,114.51)
  T05 w0.117: v4(40.65,114.51) 41.05,114.11 44.82,114.11 45.05,113.88 45.05,113.55 45.28,113.31 45.62,113.31 45.85,113.08 45.85,112.95 49.08,109.72 54.64,109.72 55.04,110.13 55.49,110.13 55.73,110.36 55.73,110.93 v4(56.13,111.33)
DDR3_BMC_ZQ: length 1.5
  TOP w0.14: U155.L8 v4(44.65,114.51)
  BOTTOM w0.14: R12326.1 44.66,114.5 v4(44.65,114.51)
DDR3_DRAM_MVREF: length 15
  TOP w0.381: U155.M8 v4(44.65,113.71) ; U155.H1 v4(39.05,116.91)
  T18 w0.381: v4(39.05,116.91) 39.05,116.53 39.5,116.08 41.15,116.08 43.51,113.71 v4(44.65,113.71)
  BOTTOM w0.381: v4(44.65,113.71) 44.5,113.86 C2240.1 R12988.1 ; v4(39.05,116.91) 39.02,116.94 C2241.1 R12308.2 R12306.1 36.05,117.19 v2(36.05,118.11)
EEPROM_ADDR0: length 3.8
  TOP w0.14: v1(7.02,75.84) 6.8,75.62 U140.1
  BOTTOM w0.14: R1686.1 R1692.2 6.99,75.81 v1(7.02,75.84)
EEPROM_ADDR0_SYS: length 3
  TOP w0.14: U81.1 v1(101.21,183.26) R1101.2 R1097.1
EEPROM_ADDR1: length 5.5
  TOP w0.14: U140.3 6.81,74.32 v1(6.95,74.46) 6.95,74.71 6.69,74.97 U140.2
  BOTTOM w0.14: v1(6.95,74.46) 6.67,74.74 R1693.2 R1687.1
EEPROM_ADDR1_SYS: length 5.1
  TOP w0.14: U81.2 100.09,184.92 v1(99.82,184.66) 99.18,184.01 R1102.2 R1098.1
EEPROM_ADDR2_SYS: length 7
  TOP w0.14: R13030.1 R13031.2 97.16,183.26 v1(97.66,183.76) 99.47,185.57 U81.3
