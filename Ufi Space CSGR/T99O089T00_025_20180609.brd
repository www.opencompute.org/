# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RST_I2C_MUX7_N: length 264
  TOP w0.14: v4(123.7,124.46) 123.6,124.37 120.09,124.37 U70.L13
  T03 w0.117: v1(229.42,81.59) 227.67,83.34 185.94,83.34 179.13,90.14 175.3,90.14 166.71,98.74 166.71,98.75 155.31,110.14 155.3,110.14 154.83,110.61 152.09,110.61 149.51,113.19 149.51,120.51 140.51,129.5 127.99,129.5 124.23,125.75 124.23,124.96 123.73,124.46 v4(123.7,124.46)
  T05 w0.117: v1(274.57,80.12) 275.07,79.63 306.2,79.63 310.09,75.73 310.09,54.2 308.2,52.31 308.2,50.67 306.95,49.41 306.95,45.6 307.85,44.7 v5(307.85,42.85)
  T14 w0.117: v1(229.42,81.59) 230.54,80.47 257.97,80.47 261.26,77.18 269.2,77.18 271.01,78.99 273.44,78.99 v1(274.57,80.12)
  BOTTOM w0.14: U69.3 305.19,38.49 305.71,39.01 305.71,40.41 307.28,41.98 307.28,42.46 307.67,42.85 v5(307.85,42.85) 308.03,42.85 R1733.2
RST_MAC_N: length 102.4
  TOP w0.14: U70.F10 v4(118,128.05) ; U1.AG31 v4(201.86,128.5) ; v1(179.2,131.98) 178.72,131.51 R68.1
  T05 w0.117: v4(201.86,128.5) 201.68,128.5 201.08,129.09 200.59,129.09 200.26,129.43 200.26,129.81 200.03,130.05 199.48,130.05 199.36,130.16 199.36,130.68 199.15,130.9 195.17,130.9 192.59,128.31 188.31,128.31 187.03,129.6 181.83,129.6 179.45,131.98 v1(179.2,131.98)
  T14 w0.117: v4(118,128.05) 118.23,128.05 118.72,127.56 121.34,127.56 123.21,125.69 124.26,125.69 125.72,127.15 125.73,127.15 127.88,129.3 129.99,129.3 136.58,135.89 143.63,135.89 147.78,140.04 168.91,140.04 170.26,138.69 170.26,137.01 171.32,135.96 172.99,135.96 174.26,134.68 176.18,134.68 178.88,131.98 v1(179.2,131.98)
RST_NIC1_N: length 47.6
  TOP w0.14: U85.1 101.08,86.5 101.85,85.72 v1(101.98,85.72) ; U70.N4 v4(112.4,122.45)
  T03 w0.117: v4(112.4,122.45) 109.08,119.13 109.08,114.5 105.92,111.34 105.92,102.17 104.08,100.33 102.49,100.33 101.22,99.06 101.22,86.49 v1(101.98,85.72)
  BOTTOM w0.14: v1(101.98,85.72) 102.51,85.2 R1715.2 R1219.2
RST_NIC1_PCIE_N: length 36.4
  TOP w0.14: U70.M5 v4(113.2,123.25) ; U85.17 100.27,96.01 102.15,97.89 v6(102.15,99.06)
  T03 w0.102: v4(113.2,123.25) 112.81,122.86 112.81,122.19 111.64,121.02
  T03 w0.117: v6(102.15,99.06) 103.55,99.06 106.43,101.94 106.43,104.14 110.87,108.58 110.87,114.14 110.6,114.41 110.6,119.98 111.64,121.02
  BOTTOM w0.14: v6(102.15,99.06) 102.23,98.98 R1698.2
RST_PHY1_N: length 59.3
  TOP w0.14: U23.D11 134.16,94.41 137,94.41 137.4,94.8 v4(137.4,94.98) ; U70.N5 v4(113.2,122.45)
  T03 w0.117: v4(137.4,94.98) 138.09,95.68 139.83,95.68 140.46,96.31 140.46,103.59 137.83,106.22 131.91,106.22 131.59,106.54 118.7,106.54 v1(113.25,111.99) 112.37,112.88 112.37,117.18 111.51,118.03 111.51,119.84 112.43,120.76 112.43,121.36 113.2,122.13 v4(113.2,122.45)
  BOTTOM w0.14: v4(137.4,94.98) 137.08,94.67 137.08,94.09 R286.1
RST_PHY3_N: length 277.8
  TOP w0.14: U70.D9 v4(117.2,130.45) ; U25.T10 v4(277.1,91.39)
  T14 w0.117: v4(117.2,130.45) 116.8,130.85 116.8,133.69 118.24,135.13 118.24,136.02 119.6,137.38 119.6,139.74 119.34,139.99 119.34,141.26 120.65,142.57 120.87,142.57 127.14,142.57 129.22,144.64 129.22,152.51 130,153.29 130,155.06 128.92,156.14 128.92,159.36 128.17,160.11 128.17,163.28 133.3,168.4 v1(143.13,168.4)
  T18 w0.117: v1(143.13,168.4) 146.62,171.9 163.5,171.9 170.19,165.2 186.01,165.2 197.8,177 221.62,177 225.04,173.57 248.32,173.57 250.12,171.77 250.12,170 258.61,161.51 261.27,161.51 266.79,156 266.79,146.67 274.29,139.17 274.29,119.46 280.6,113.15 280.6,92.92 279.84,92.16 277.87,92.16 v4(277.1,91.39)
  BOTTOM w0.14: v4(277.1,91.39) 277.6,90.89 R310.1
RST_SMU_N: length 134.9
  TOP w0.14: U139.K6 v4(15.43,93.3) ; U70.H13 v4(120.4,126.45)
  T07 w0.117: v4(120.4,126.45) U70.H13 115.3,126.85 115.03,126.59 115.03,121.87 114.62,121.46 114.62,119.07 110.7,115.15 107,115.15 103.74,111.89 103.74,111.19 103.74,110.84 103.74,110.84 103.74,108.47 101.74,106.46 93.63,106.46 93.38,106.22 84.37,97.21 77.69,97.21 74.8,100.1 56.15,100.1 53.26,97.21 45.42,97.21 45.06,97.56 42.37,97.56 41.66,96.84 41.66,95.76 41.03,95.13 34.79,95.13 32.51,97.41 27.3,97.41 25.72,95.83 16.2,95.83 15.95,95.58 15.95,93.82 v4(15.43,93.3)
  BOTTOM w0.14: v4(120.4,126.45) 120.75,126.11 v2(122.43,126.11)
RST_SW_BTN_N: length 125.8
  TOP w0.14: v1(49.28,67.91) 48.83,68.35 J8.11 ; U70.F4 v4(112.4,128.85)
  T03 w0.117: v1(102.74,125.73) 102.5,125.73 91.16,114.39 91.16,103.91 87.63,100.38 86.41,100.38 78.26,92.23 76.37,92.23 73.38,89.24 67.01,89.24 65.42,87.64 65.42,77.42 61.7,73.7 55.07,73.7 v1(49.28,67.91) ; v4(112.4,128.85) 112.8,129.25 112.8,131.42 113.04,131.65 116.16,131.65 116.98,132.48 116.98,136.29 117.73,137.03 v1(118.14,137.03)
  T16 w0.117: v1(118.14,137.03) 117.86,137.03 116.08,135.25 111,135.25 102.62,126.87 102.62,125.86 v1(102.74,125.73)
RST_SW_TO_CP2104: length 64.4
  TOP w0.14: J8.5 42.83,71.55 43.81,72.54 43.81,75.97 45.44,77.6 47.74,77.6 49.1,78.96 v1(49.1,80.4) ; U154.D15 v4(69.73,109.72)
  T18 w0.117: v1(49.1,80.4) 49.07,80.43 49.07,81.82 50.3,83.05 51.77,83.05 53.79,81.03 61.58,81.03 69.32,88.77 69.85,88.77 70.99,89.92 70.99,97.79 71.69,98.48 71.69,103.57 70.13,105.13 70.13,109.45 69.85,109.72 v4(69.73,109.72)
RST_USB_BRIDGE_N: length 75.1
  TOP w0.14: U70.K13 v4(120.4,124.85) 121.23,124.85 121.49,125.12 R1718.2 ; U162.9 88.71,80.92 89.03,81.23 89.03,83.31 88.04,84.3 v1(88.04,84.62)
  T07 w0.117: v4(120.4,124.85) 121.23,124.03 121.23,121.28 118.56,118.62 115.82,118.62 111.51,114.31 107.35,114.31 104.58,111.54 104.58,111.19 104.58,108.12 100.64,104.18 98.11,104.18 96.47,102.54 v1(91.32,102.54)
  T18 w0.117: v1(91.32,102.54) 91.31,102.53 91.31,102.49 90.93,102.11 90.93,100.08 92,99.02 92,97.74 92.64,97.1 92.64,95.14 91.9,94.4 91.9,86.86 89.16,84.12 88.54,84.12 v1(88.04,84.62)
RSVD_HWM_GPIO10: length 2.4
  TOP w0.14: v1(124.84,193.04) 125.01,193.21 U73.22
  BOTTOM w0.14: R1843.2 v1(124.84,193.04)
RTC_BAT_SENSE_EN_N: length 118.3
  TOP w0.14: R12710.1 163.84,148.28 v1(164.38,147.74) 164.38,145.94 Q56.1 ; U154.E3 v4(68.93,120.13)
  T07 w0.117: v1(129.67,134.62) 128.78,133.73 127.76,133.73 125.24,136.25 117.27,136.25 115.97,134.96 105.29,134.96 103.85,136.4 101.73,136.4 101.35,136.02 100.3,136.02 96.32,132.03 96.32,131.07 91.65,126.4 91.65,123.27 90.42,122.05 85.85,122.05 84.95,121.14 82.61,121.14 81.01,122.74 80.2,122.74 79.25,121.79 76.83,121.79 75.74,120.7 73.62,120.7 73.44,120.53 69.33,120.53 v4(68.93,120.13)
  T14 w0.117: v1(164.38,147.74) 160.27,143.64 147.95,143.64 145.46,141.15 145.46,140.13 142.91,137.58 134.03,137.58 131.07,134.62 v1(129.67,134.62)
SFI_PHY1_TO_SFP_DN0: length 52.6
  TOP w0.102: U23.T15 v4(121.21,90.36)
  T18 w0.107: v4(121.21,90.36) 120.8,89.95 120.46,89.95 118.87,88.36 118.87,84.71 114,79.83 113.47,79.83 108.83,75.18 108.83,74.09 103.37,68.64 102,68.64 91.77,58.41 88.89,58.41 88.18,57.69 88.18,56.21 88.33,56.06 88.49,55.96 88.53,55.82 CJ8.AT19
SFI_PHY1_TO_SFP_DN1: length 61.7
  TOP w0.102: U23.P16 v4(123.21,89.36)
  T18 w0.102: v4(123.21,89.36) 123.21,89.66 123.11,89.76 122.97,89.76 122.81,89.6 122.81,89.3 122.81,88.99 122.85,88.95 122.85,88.93
  T18 w0.107: 122.85,88.93 122.85,86.77 121.66,85.58 121.66,82.44 115.58,76.36 115.58,74.12 107.88,66.42 103.76,66.42 100.92,63.58 100.92,63.45 100.92,63.41 100.79,63.27 100.65,63.27 100.61,63.27 100.47,63.13 100.47,63 100.47,62.95 100.33,62.82 100.2,62.82 100.16,62.82 98.5,61.16 98.5,60.81 98.63,60.68 98.63,60.49 98.5,60.36 98.5,53.8 98.63,53.67 98.63,53.48 98.5,53.35 98.5,49.8 97.32,48.62 96.47,48.62 96.31,48.46 96.15,48.46 95.99,48.62 95.83,48.62 95.67,48.46 95.51,48.46 95.35,48.62 93.99,48.62 93.61,48.23 93.61,47.57 93.7,47.47 93.76,47.44 93.98,47.44 CJ8.AL19
SFI_PHY1_TO_SFP_DN2: length 47.8
  TOP w0.102: U23.M15 v4(125.21,90.36)
  T18 w0.102: 124.57,88.75 124.57,88.78 124.61,88.81 124.61,89.69 124.88,89.96 125.11,89.96 125.21,90.06 v4(125.21,90.36)
  T18 w0.107: 124.57,88.75 124.57,87.31 122.55,85.28 122.55,79.21 120.96,77.62 120.96,73.63 112.6,65.28 108.63,65.28 103.41,60.06 103.41,58.55 102.46,57.6 102.46,56.24 102.74,55.96 102.74,55.75 CJ8.BT19
SFI_PHY1_TO_SFP_DN3: length 55.6
  TOP w0.104: U23.J16 v4(128.21,89.36)
  T18 w0.107: CJ8.BL19 108.23,47.44 108.08,47.4 107.95,47.47 107.87,47.55 107.87,48.26 108.23,48.62 109.59,48.62 109.75,48.46 109.91,48.46 110.07,48.62 110.23,48.62 110.39,48.46 110.55,48.46 110.71,48.62 111.4,48.62 112.82,50.04 112.82,62.08 121.01,70.26 123.77,70.26 127.83,74.33 127.83,88.98 v4(128.21,89.36)
SFI_PHY1_TO_SFP_DN4: length 44.7
  TOP w0.104: U23.G16 v4(131.21,89.36)
  T18 w0.102: 131.58,88.88 131.58,88.9 131.62,88.94 131.62,89.6 131.46,89.76 131.31,89.76 131.21,89.66 v4(131.21,89.36)
  T18 w0.107: 131.58,88.88 131.58,79.41 132.4,78.59 132.4,72.42 121.68,61.71 121.68,59.38 120.63,58.32 117.43,58.32 116.71,57.61 116.71,56.27 116.97,56.02 116.97,55.55 CJ8.CT19
SFI_PHY1_TO_SFP_DN5: length 51.4
  TOP w0.104: U23.E15 v4(133.21,90.36)
  T18 w0.102: 133.86,88.87 133.86,88.88 133.82,88.92 133.82,89.66 133.52,89.95 133.29,89.95 133.19,90.06 133.19,90.33 v4(133.21,90.36)
  T18 w0.107: CJ8.CL19 122.48,47.44 122.33,47.4 122.2,47.47 122.1,47.58 122.1,48.26 122.46,48.63 124.37,48.63 126.97,51.24 126.97,59.55 128.72,61.29 128.72,65.34 134.05,70.68 134.05,79.5 133.86,79.69 133.86,86.48 133.98,86.6 133.98,86.8 133.86,86.92 133.86,87.12 133.98,87.24 133.98,87.44 133.86,87.56 133.86,87.76 133.98,87.88 133.98,88.08 133.86,88.2 133.86,88.87
SFI_PHY1_TO_SFP_DN6: length 38.6
  TOP w0.104: U23.C16 v4(135.21,89.36)
  T18 w0.102: v4(135.21,89.36) 135.21,89.66 135.31,89.76 135.46,89.76 135.62,89.6 135.62,88.81 135.58,88.78 135.58,88.75
  T18 w0.107: 135.58,88.75 135.58,79.79 136.4,78.97 136.4,65.09 131.93,60.63 131.93,58.17 130.96,57.2 130.96,56.27 131.24,55.99 131.24,55.58 CJ8.DT19
SFI_PHY1_TO_SFP_DN7: length 49.6
  TOP w0.104: U23.A15 v4(137.21,90.36)
  T18 w0.107: v4(137.21,90.36) 137.21,90.13 137.32,90.02 137.67,90.02 137.96,89.73 137.96,81.26 138.26,80.96 138.26,66.58 141.23,63.62 141.23,50.93 138.89,48.59 136.78,48.59 136.38,48.19 136.38,47.55 136.45,47.47 136.58,47.4 136.73,47.44 CJ8.DL19
SFI_PHY1_TO_SFP_DP0: length 52.5
  TOP w0.102: U23.T16 v4(121.21,89.36)
  T18 w0.107: v4(121.21,89.36) 120.91,89.67 120.58,89.67 119.15,88.24 119.15,87.38 119.27,87.26 119.27,87.06 119.15,86.94 119.15,86.74 119.27,86.62 119.27,86.42 119.15,86.3 119.15,86.1 119.27,85.98 119.27,85.78 119.15,85.66 119.15,84.59 114.11,79.55 113.59,79.55 109.11,75.07 109.11,73.98 103.49,68.36 102.12,68.36 101.8,68.04 101.8,67.79 101.7,67.69 101.45,67.69 101.35,67.59 101.35,67.34 101.24,67.24 101,67.24 91.88,58.13 90.6,58.13 90.45,57.98 90.28,57.98 90.13,58.13 89.01,58.13 88.46,57.57 88.46,56.33 88.5,56.28 88.63,56.2 88.78,56.24 CJ8.AT18
SFI_PHY1_TO_SFP_DP1: length 61.7
  TOP w0.102: U23.P15 v4(123.21,90.36)
  T18 w0.102: 122.57,88.93 122.57,88.95 122.61,88.99 122.61,89.68 122.88,89.96 123.11,89.96 123.21,90.06 v4(123.21,90.36)
  T18 w0.107: CJ8.AL18 93.73,47.01 93.69,47.16 93.69,47.16 93.53,47.25 93.33,47.45 93.33,48.35 93.88,48.9 97.2,48.9 98.22,49.91 98.22,61.27 103.65,66.7 107.77,66.7 115.3,74.24 115.3,76.48 121.38,82.56 121.38,85.7 122.57,86.88 122.57,88.93
SFI_PHY1_TO_SFP_DP2: length 47.7
  TOP w0.102: U23.M16 v4(125.21,89.36)
  T18 w0.102: v4(125.21,89.36) 125.21,89.66 125.11,89.76 124.97,89.76 124.81,89.6 124.81,88.81 124.85,88.78 124.85,88.75
  T18 w0.107: 124.85,88.75 124.85,87.19 124.45,86.79 124.45,86.62 124.31,86.48 124.13,86.48 123.99,86.34 123.99,86.16 123.85,86.02 123.68,86.02 123.54,85.88 123.54,85.71 123.4,85.57 123.23,85.57 122.83,85.17 122.83,79.09 121.24,77.5 121.24,73.52 112.72,65 108.75,65 107.51,63.76 107.51,63.53 107.39,63.42 107.16,63.42 107.05,63.3 107.05,63.08 106.94,62.96 106.71,62.96 103.69,59.95 103.69,58.43 102.74,57.48 102.74,56.39 102.89,56.24 103.03,56.24 CJ8.BT18
SFI_PHY1_TO_SFP_DP3: length 55.7
  TOP w0.104: U23.K16 v4(127.21,89.36)
  T18 w0.107: v4(127.21,89.36) 127.55,89.02 127.55,74.45 123.65,70.54 120.89,70.54 112.54,62.19 112.54,50.16 111.29,48.9 108.11,48.9 107.59,48.38 107.59,47.44 107.78,47.25 107.94,47.16 107.98,47.01 107.84,46.76 CJ8.BL18
SFI_PHY1_TO_SFP_DP4: length 44.7
  TOP w0.104: U23.G15 v4(131.21,90.36)
  T18 w0.102: 131.86,88.88 131.86,88.9 131.82,88.94 131.82,89.68 131.54,89.96 131.31,89.96 131.21,90.06 v4(131.21,90.36)
  T18 w0.107: CJ8.CT18 117.55,56.59 117.25,56.28 117.1,56.28 116.99,56.39 116.99,57.49 117.54,58.04 120.74,58.04 121.96,59.26 121.96,61.59 132.68,72.31 132.68,78.71 131.86,79.53 131.86,88.88
SFI_PHY1_TO_SFP_DP5: length 51.4
  TOP w0.104: U23.E16 v4(133.21,89.36)
  T18 w0.102: 133.58,88.87 133.58,88.88 133.61,88.91 133.61,88.99 133.62,89 133.62,89.57 133.44,89.75 133.29,89.75 133.19,89.65 133.19,89.38 v4(133.21,89.36)
  T18 w0.107: CJ8.CL18 122.09,46.76 122.23,47.01 122.19,47.16 122.03,47.25 121.82,47.46 121.82,48.38 122.35,48.91 124.25,48.91 124.71,49.37 124.71,49.56 124.84,49.69 125.03,49.69 125.16,49.82 125.16,50.02 125.29,50.14 125.49,50.14 125.61,50.27 125.61,50.47 125.74,50.6 125.94,50.6 126.69,51.35 126.69,52.75 126.58,52.86 126.58,53.07 126.69,53.18 126.69,59.66 128.44,61.41 128.44,65.46 133.77,70.79 133.77,79.38 133.58,79.57 133.58,88.87
SFI_PHY1_TO_SFP_DP6: length 38.6
  TOP w0.104: U23.C15 v4(135.21,90.36)
  T18 w0.102: v4(135.21,90.36) 135.21,90.06 135.31,89.96 135.54,89.96 135.82,89.68 135.82,88.81 135.86,88.78 135.86,88.75
  T18 w0.107: 135.86,88.75 135.86,79.91 136.68,79.09 136.68,64.98 132.21,60.51 132.21,58.06 131.24,57.09 131.24,56.39 131.35,56.28 131.55,56.28 131.8,56.54 CJ8.DT18
SFI_PHY1_TO_SFP_DP7: length 49.5
  TOP w0.104: U23.A16 v4(137.21,89.36)
  T18 w0.107: v4(137.21,89.36) 137.21,89.59 137.32,89.7 137.59,89.7 137.68,89.61 137.68,81.14 137.98,80.84 137.98,66.47 140.95,63.5 140.95,51.05 139.27,49.37 139.11,49.37 138.96,49.22 138.96,49.06 138.77,48.87 136.66,48.87 136.1,48.31 136.1,47.43 136.28,47.25 136.44,47.16 136.48,47.01 136.34,46.76 CJ8.DL18
SFI_SFP_TO_PHY1_DN0: length 54.8
  TOP w0.102: U23.T12 v4(121.21,93.36)
  T16 w0.107: v4(121.21,93.36) 121.21,93.14 121.11,93.03 119.69,93.03 118.41,91.76 118.41,84.38 114.57,80.54 112.53,80.54 108.12,76.13 108.12,73.09 99.12,64.09 97.09,64.09 96.25,63.25 96.08,63.25 95.94,63.11 95.94,62.94 95.8,62.8 95.63,62.8 95.49,62.66 95.49,62.49 95.35,62.35 95.18,62.35 95.04,62.21 95.04,62.04 93.63,60.63 93.63,58.53 94.7,57.45 94.7,56.76 93.96,56.02 93.75,56.02 93.62,56.1 93.58,56.24 CJ8.AT12
SFI_SFP_TO_PHY1_DN1: length 71.3
  TOP w0.102: U23.P13 v4(123.21,92.36)
  T16 w0.102: v4(123.21,92.36) 123.21,92.66 123.11,92.76 122.97,92.76 122.81,92.6 122.81,89.01 122.85,88.98 122.85,88.95
  T16 w0.107: 122.85,88.95 122.85,83.61 117.96,78.71 112.94,78.71 109.75,75.53 109.75,71 98.47,59.72 98.47,48.25 95.74,45.52 89.56,45.52 89.23,45.85 89.23,46.83 89.12,46.94 88.89,46.94 88.79,46.76 CJ8.AL12
SFI_SFP_TO_PHY1_DN2: length 49.2
  TOP w0.102: U23.M12 v4(125.21,93.36)
  T16 w0.102: v4(125.21,93.36) 125.21,93.06 125.11,92.96 124.88,92.96 124.61,92.69 124.61,88.81 124.57,88.78 124.57,88.75
  T16 w0.107: CJ8.BT12 107.83,56.24 107.87,56.1 108,56.02 108.27,56.02 108.77,56.52 108.77,57.4 107.49,58.68 107.49,59.43 107.37,59.55 107.37,59.75 107.49,59.87 107.49,60.07 107.37,60.19 107.37,60.39 107.49,60.51 107.49,62.8 114.79,70.1 117.49,70.1 120.81,73.42 120.81,76.52 124.57,80.28 124.57,88.75
SFI_SFP_TO_PHY1_DN3: length 67.1
  TOP w0.104: U23.J14 v4(128.21,91.36)
  T16 w0.102: 126.85,88.89 126.85,88.92 126.81,88.96 126.81,90.6 126.97,90.75 127.59,90.75 127.82,90.97 127.82,91.26 127.92,91.36 v4(128.21,91.36)
  T16 w0.107: CJ8.BL12 103.04,46.76 103.18,47.01 103.33,47.05 103.46,46.91 103.46,46.3 103.46,46.29 103.46,45.7 104.27,44.9 109.98,44.9 112.82,47.74 112.82,62.78 116.56,66.52 119.98,66.52 127.24,73.78 127.24,79.58 127.85,80.2 127.85,85.24 126.85,86.24 126.85,88.89
SFI_SFP_TO_PHY1_DN4: length 45.5
  TOP w0.104: U23.G13 v4(131.21,92.36)
  T16 w0.102: 131.58,88.89 131.58,88.91 131.62,88.95 131.62,92.6 131.46,92.76 131.31,92.76 131.21,92.66 v4(131.21,92.36)
  T16 w0.107: 131.58,88.89 131.58,84.88 132.32,84.14 132.32,72.28 132.04,71.99 131.79,71.99 131.69,71.89 131.69,71.65 131.58,71.54 131.34,71.54 131.23,71.44 131.23,71.19 121.9,61.86 121.9,61.33 121.8,61.24 121.79,61.24 121.69,61.15 121.69,61.01 121.79,60.92 121.8,60.92 121.9,60.83 121.9,60.69 121.8,60.6 121.79,60.6 121.69,60.51 121.69,60.37 121.79,60.28 121.8,60.28 121.9,60.19 121.9,60.05 121.8,59.96 121.79,59.96 121.69,59.87 121.69,59.73 121.79,59.64 121.8,59.64 121.9,59.55 121.9,59.08 123.14,57.84 123.14,56.59 122.57,56.02 122.25,56.02 122.12,56.1 122.08,56.24 CJ8.CT12
SFI_SFP_TO_PHY1_DN5: length 62
  TOP w0.104: U23.E12 v4(133.21,93.36)
  T16 w0.102: v4(133.21,93.36) 133.21,93.06 133.31,92.96 133.54,92.96 133.81,92.69 133.81,89.12 133.85,89.08 133.85,89.06
  T16 w0.107: 133.85,89.06 133.85,70.23 128.57,64.95 128.57,59.11 127,57.53 127,47.69 124.5,45.19 118.65,45.19 117.72,46.12 117.72,46.93 117.63,47.02 117.47,47.02 117.43,47.01 117.29,46.76 CJ8.CL12
SFI_SFP_TO_PHY1_DN6: length 41.1
  TOP w0.104: U23.C13 v4(135.21,92.36)
  T16 w0.102: 135.57,89.13 135.57,89.16 135.61,89.2 135.61,92.61 135.46,92.76 135.31,92.76 135.21,92.66 v4(135.21,92.36)
  T16 w0.107: CJ8.DT12 136.33,56.24 136.37,56.1 136.5,56.02 136.8,56.02 137.34,56.57 137.34,57.71 136.27,58.78 136.27,59.04 136.11,59.21 136.11,59.36 136.27,59.53 136.27,59.68 136.11,59.85 136.11,60 136.27,60.17 136.27,60.32 136.11,60.49 136.11,60.64 136.27,60.81 136.27,79.1 135.57,79.8 135.57,86.67 135.4,86.84 135.4,86.99 135.57,87.16 135.57,87.31 135.4,87.48 135.4,87.63 135.57,87.8 135.57,87.95 135.4,88.12 135.4,88.27 135.57,88.44 135.57,89.13
SFI_SFP_TO_PHY1_DN7: length 61.3
  TOP w0.104: U23.A12 v4(137.21,93.36)
  T16 w0.107: v4(137.21,93.36) 137.21,93.16 137.36,93.01 137.59,93.01 138.37,92.23 138.37,91.89 138.37,91.89 138.37,63.58 141.89,60.06 141.89,56.04 141.13,55.27 141.13,47.16 139.24,45.28 132.76,45.28 131.97,46.07 131.97,46.88 131.82,47.02 131.72,47.02 131.68,47.01 131.54,46.76 CJ8.DL12
SFI_SFP_TO_PHY1_DP0: length 54.7
  TOP w0.102: U23.T13 v4(121.21,92.36)
  T16 w0.107: v4(121.21,92.36) 121.21,92.65 121.11,92.76 119.81,92.76 118.69,91.64 118.69,84.26 114.69,80.26 112.64,80.26 108.39,76.01 108.39,72.97 99.23,63.81 97.21,63.81 93.91,60.51 93.91,58.64 94.98,57.57 94.98,56.65 94.07,55.74 93.67,55.74 93.48,55.86 93.33,55.82 CJ8.AT13
SFI_SFP_TO_PHY1_DP1: length 71.3
  TOP w0.102: U23.P12 v4(123.21,93.36)
  T16 w0.102: v4(123.21,93.36) 123.21,93.06 123.11,92.96 122.88,92.96 122.61,92.68 122.61,89.01 122.57,88.98 122.57,88.95
  T16 w0.107: CJ8.AL13 89.18,47.44 89.22,47.29 89.51,47 89.51,45.96 89.67,45.8 95.63,45.8 98.19,48.36 98.19,59.84 109.47,71.12 109.47,75.65 112.82,78.99 117.84,78.99 121.98,83.13 121.98,83.26 121.97,83.27 121.97,83.4 122.07,83.49 122.2,83.49 122.21,83.49 122.34,83.49 122.57,83.72 122.57,88.95
SFI_SFP_TO_PHY1_DP2: length 49.3
  TOP w0.102: U23.M13 v4(125.21,92.36)
  T16 w0.102: v4(125.21,92.36) 125.21,92.66 125.11,92.76 124.97,92.76 124.82,92.61 124.82,88.81 124.85,88.78 124.85,88.75
  T16 w0.107: CJ8.BT13 107.58,55.82 107.73,55.86 107.82,55.8 107.88,55.74 108.39,55.74 109.05,56.41 109.05,57.51 107.77,58.79 107.77,62.68 114.9,69.82 117.61,69.82 121.09,73.3 121.09,76.4 124.85,80.16 124.85,88.75
SFI_SFP_TO_PHY1_DP3: length 67
  TOP w0.104: U23.K14 v4(127.21,91.36)
  T16 w0.102: 126.57,88.89 126.57,88.92 126.61,88.96 126.61,90.69 126.88,90.96 127.51,90.96 127.61,91.06 127.61,91.26 127.51,91.36 v4(127.21,91.36)
  T16 w0.107: CJ8.BL13 103.47,47.51 103.47,47.29 103.74,47.01 103.74,46.18 103.74,46.18 103.74,45.82 104.38,45.18 109.86,45.18 110.75,46.06 110.75,46.27 110.87,46.39 111.08,46.39 111.2,46.51 111.2,46.73 111.32,46.85 111.53,46.85 111.65,46.96 111.65,47.18 111.77,47.3 111.99,47.3 112.54,47.86 112.54,59.72 112.42,59.84 112.42,60.04 112.54,60.16 112.54,60.36 112.42,60.49 112.42,60.68 112.54,60.81 112.54,62.9 116.45,66.8 119.86,66.8 126.96,73.89 126.96,79.7 127.57,80.31 127.57,85.12 126.57,86.12 126.57,88.89
SFI_SFP_TO_PHY1_DP4: length 45.6
  TOP w0.104: U23.G12 v4(131.21,93.36)
  T16 w0.102: v4(131.21,93.36) 131.21,93.06 131.31,92.96 131.54,92.96 131.82,92.68 131.82,88.95 131.86,88.91 131.86,88.89
  T16 w0.107: CJ8.CT13 121.83,55.82 121.98,55.86 122.07,55.8 122.13,55.74 122.69,55.74 123.42,56.48 123.42,57.95 122.18,59.2 122.18,61.74 132.6,72.16 132.6,84.25 131.86,85 131.86,88.89
SFI_SFP_TO_PHY1_DP5: length 61.9
  TOP w0.104: U23.E13 v4(133.21,92.36)
  T16 w0.102: 133.57,89.06 133.57,89.08 133.61,89.12 133.61,92.61 133.46,92.76 133.31,92.76 133.21,92.66 v4(133.21,92.36)
  T16 w0.107: CJ8.CL13 117.76,47.59 117.76,47.27 118,47.03 118,46.23 118.76,45.47 119.19,45.47 119.34,45.62 119.51,45.62 119.66,45.47 119.83,45.47 119.98,45.62 120.15,45.62 120.3,45.47 120.47,45.47 120.62,45.62 120.79,45.62 120.94,45.47 124.38,45.47 126.72,47.81 126.72,48.6 126.62,48.71 126.62,48.92 126.72,49.03 126.72,49.24 126.62,49.35 126.62,49.56 126.72,49.67 126.72,49.88 126.62,49.99 126.62,50.2 126.72,50.31 126.72,57.65 128.3,59.22 128.3,65.06 132.37,69.13 132.37,69.37 132.48,69.48 132.71,69.48 132.82,69.59 132.82,69.82 132.93,69.93 133.16,69.93 133.57,70.34 133.57,89.06
SFI_SFP_TO_PHY1_DP6: length 41.2
  TOP w0.104: U23.C12 v4(135.21,93.36)
  T16 w0.102: 135.85,89.13 135.85,89.16 135.81,89.2 135.81,92.69 135.54,92.96 135.31,92.96 135.21,93.06 v4(135.21,93.36)
  T16 w0.107: CJ8.DT13 136.08,55.82 136.23,55.86 136.32,55.8 136.38,55.74 136.91,55.74 137.62,56.45 137.62,57.82 136.55,58.89 136.55,79.21 135.85,79.91 135.85,89.13
SFI_SFP_TO_PHY1_DP7: length 61.2
  TOP w0.104: U23.A13 v4(137.21,92.36)
  T16 w0.107: v4(137.21,92.36) 137.21,92.59 137.36,92.73 137.48,92.73 138.09,92.12 138.09,92 138.09,91.4 137.94,91.25 137.94,91.08 138.09,90.93 138.09,90.76 137.94,90.61 137.94,90.44 138.09,90.29 138.09,63.46 141.61,59.95 141.61,56.15 140.85,55.39 140.85,49.81 140.7,49.67 140.7,49.49 140.85,49.35 140.85,49.17 140.7,49.03 140.7,48.85 140.85,48.71 140.85,48.53 140.7,48.39 140.7,48.21 140.85,48.07 140.85,47.27 139.13,45.56 135.02,45.56 134.89,45.69 134.7,45.69 134.57,45.56 134.38,45.56 134.25,45.69 134.06,45.69 133.93,45.56 133.74,45.56 133.61,45.69 133.42,45.69 133.29,45.56 132.87,45.56 132.24,46.19 132.24,46.99 131.99,47.25 131.97,47.26 131.93,47.44 CJ8.DL13
SFP28_PWR_OC_N: length 183
  TOP w0.14: v1(226.9,82.27) 227.29,82.27 228.95,80.6 R638.2 R637.2 ; U70.L12 v4(119.6,124.05)
  T03 w0.117: v1(226.9,82.27) 226.25,82.91 185.58,82.91 178.9,89.59 174.02,89.59 166.28,97.33 166.28,98.57 155.14,109.72 155.13,109.72 154.66,110.19 149.17,110.19 144.74,114.62 144.74,115.57 143.21,117.09 140.59,117.09 139.45,115.95 125.4,115.95 123.36,117.99 123.36,120.06 121.92,121.5 121.92,122.71 120.57,124.05 v4(119.6,124.05)
  T14 w0.117: v1(226.9,82.27) 229.57,82.27 230.81,81.03 258.3,81.03 261.56,77.76 268.47,77.76 v1(269.48,78.78)
  BOTTOM w0.14: v1(269.48,78.78) 269.5,78.76 R639.2 271.66,78.77 R640.2 272.62,79.73 R1576.1
SFP+_P00_MOD_ABS: length 147.3
  TOP w0.14: v5(87.86,68.71) 87.07,68.71 86.31,69.47 86.31,70.94 90.74,75.37 U26.4
  T07 w0.117: v5(87.86,68.71) 87.86,67.92 89.81,65.97 89.81,58.91 91.45,57.27 91.45,56.43 92.25,55.63 92.25,54.75 91.85,54.36 CJ8.AT6 93.04,51.22 93.04,50.54 92.26,49.76 92.26,48.8 91.82,48.36 91.82,47.68 92.64,46.86 92.64,45.61 91.54,44.52 91.54,43.69 92.06,43.18 v1(92.08,43.18) 93.94,41.32 93.94,39.87 99.83,33.98 149.3,33.98 150.05,33.24 170.1,33.24 170.19,33.15 178.18,33.15 180.24,35.21 180.24,39.21 v1(181.04,40.01)
  BOTTOM w0.14: Q28.5 92,43.26 v1(92.08,43.18) ; v1(181.04,40.01) R316.1 181.53,39.27 181.73,39.07 181.73,35.36 180.75,34.39 U47.11
SFP+_P00_RATE_SEL: length 64.4
  T07 w0.117: CJ8.AT7 CJ8.AT9 94.82,53.79 95.94,52.67 95.94,51.29 97.16,50.06 97.16,39.71 99.92,36.95 109.86,36.95 110.38,36.42 124.23,36.42 125.4,35.26 v1(139.06,35.26)
  BOTTOM w0.14: 138.94,36.83 138.94,35.39 v1(139.06,35.26) ; 138.94,36.83 139.09,36.98 139.83,36.98 R313.1 ; 138.94,36.83 138.78,36.98 R761.2
SFP+_P00_RATE_SEL_OUT: length 3.9
  BOTTOM w0.14: U51.11 136.47,34.4 137.07,35 137.94,35 v2(137.99,35.05) 138.18,35.24 R761.1
SFP+_P00_RX_LOS: length 82.3
  T07 w0.117: CJ8.AT8 93.6,52.4 96.74,49.26 96.74,39.53 99.75,36.53 109.69,36.53 110.33,35.89 114.41,35.89 115.45,34.84 121.95,34.84 122.72,35.61 122.72,35.67 123.05,36 123.58,36 125.18,34.4 149.48,34.4 149.85,34.03 151.99,34.03 153.04,35.07 v1(153.04,35.51)
  BOTTOM w0.14: U48.11 151.77,34.4 152.1,34.73 152.56,34.73 153.04,35.21 v1(153.04,35.51) 153.04,38.93 152.7,39.27 R315.1
SFP+_P00_RXVCC: length 13.2
  TOP w0.635: 97.31,64.04 C996.1 97.31,62.63 96.79,62.11 94.49,62.11 v1(94.11,62.49)
  P10 w0.508: CJ8.AT15 91.45,57.37 93.01,58.93 93.01,61.39 v1(94.11,62.49)
SFP+_P00_TX_DIS: length 40.4
  T05 w0.117: v1(109.24,40.01) 108.67,39.44 103.14,39.44 102.64,39.94 100.15,39.94 98.85,41.24 97.45,41.24 96.4,42.28 96.4,53.1 94.93,54.57 90.23,54.57 CJ8.AT3
  BOTTOM w0.14: v1(109.24,40.01) R312.1 109.72,39.27 109.86,39.13 109.86,35.06 109.05,34.25 U54.11
SFP+_P00_TX_FLT: length 79.8
  T07 w0.117: v1(123.57,30.15) 122.66,29.23 101.91,29.23 101.09,30.04 92.61,30.04 91.61,30.04 86.36,35.29 86.36,45.74 84.39,47.71 84.39,51.18 85.22,52.01 88.27,52.01 CJ8.AT2
  T14 w0.117: v1(123.28,39.96) 124.69,38.55 124.69,31.26 v1(123.57,30.15)
  BOTTOM w0.14: U53.11 123.1,34.25 123.95,35.1 123.95,39 123.68,39.27 R314.1 v1(123.28,39.96)
SFP+_P00_TXVCC: length 8.2
  TOP w0.635: 90.57,64.04 C993.1 v1(90.57,62.17)
  P10 w0.508: v1(90.57,62.17) 89.58,61.18 89.58,57.79 CJ8.AT16
SFP+_P01_MOD_ABS: length 151.9
  TOP w0.14: U26.5 90.87,74.87 87.4,71.4 87.4,70.05 v5(87,69.64)
  T07 w0.117: v5(87,69.64) 86.56,69.2 86.56,67.95 89.01,65.49 89.01,58.53 89.89,57.65 89.89,56.4 90.63,55.66 90.63,54.87 90.22,54.46 90.22,53.44 89.49,52.71 89.49,52.01 CJ8.AL6 90.07,50.26 89.51,50.26 89.05,49.8 89.05,49.14 88.62,48.71 87.48,48.71 86.97,48.2 86.97,46.84 90.14,43.66 v1(90.14,43.26) 88.27,41.38 88.27,37.92 88.28,37.91 88.28,37.49 88.27,37.48 88.27,35.23 90.26,33.24 98.85,33.24 99.31,32.78 110.34,32.78 112.16,30.96 113.1,30.96 114.91,32.78 124.59,32.78 126.41,30.96 127.86,30.96 128.86,31.96 136.69,31.96 137.69,30.96 176.59,30.96 181.04,35.41 v1(181.04,35.44)
  BOTTOM w0.14: Q28.2 v1(90.14,43.26) ; R323.1 v1(181.04,35.44) 181.04,35.38 180.1,34.44 U47.10
SFP+_P01_RATE_SEL: length 75.3
  T05 w0.117: CJ8.AL7 CJ8.AL9
  T07 w0.117: v1(129.31,30.84) 129.02,30.54 125.52,30.54 124.93,31.13 113.87,31.13 113.27,30.54 111.98,30.54 111.64,30.89 92.01,30.89 87.2,35.69 87.2,45.96 86.6,46.57 86.6,48.4 87.67,49.47 CJ8.AL9
  T14 w0.117: v1(137.16,37.72) 137.16,35.13 134.8,32.77 131.24,32.77 v1(129.31,30.84)
  BOTTOM w0.14: R320.1 137.16,38.33 v1(137.16,37.72) R762.2
SFP+_P01_RATE_SEL_OUT: length 7.7
  BOTTOM w0.14: v2(138.56,32) 138.05,31.5 136.65,31.5 135.82,32.32 U51.10 135.82,34.84 R762.1
SFP+_P01_RX_LOS: length 90.9
  T05 w0.117: v1(145.54,30.17) 146.98,30.17 v1(152.22,35.41)
  T07 w0.117: CJ8.AL8 88.52,50.85 86.23,48.55 86.23,46.42 86.78,45.86 86.78,35.52 91.84,30.47 92.44,30.47 92.44,30.47 107.31,30.47 107.66,30.12 113.45,30.12 114.04,30.71 123.95,30.71 124.8,29.86 145.23,29.86 v1(145.54,30.17)
  BOTTOM w0.14: R322.1 152.22,35.9 v1(152.22,35.41) 152.17,35.41 151.12,34.36 U48.10
SFP+_P01_RXVCC:
  vias: v2(88.52,62.3)
SFP+_P01_TX_DIS: length 30.5
  T07 w0.117: v1(109.24,35.44) 108.67,34.87 100.21,34.87 95.9,39.18 95.9,47.67 94.83,48.74 93.78,48.74 CJ8.AL3
  BOTTOM w0.14: U54.10 108.4,34.36 109.24,35.19 v1(109.24,35.44) R319.1
SFP+_P01_TX_FLT: length 45.3
  T07 w0.117: v1(123.28,35.44) 122.27,34.42 111.19,34.42 109.51,36.1 99.57,36.1 96.32,39.36 96.32,48.95 94.42,50.85 CJ8.AL2
  BOTTOM w0.14: U53.10 122.45,34.18 123.28,35.02 v1(123.28,35.44) R321.1
SFP+_P01_TXVCC:
  vias: v2(93.13,61.44)
SFP+_P02_MOD_ABS: length 129.5
  TOP w0.14: v1(102.47,75.21) 102.63,75.37 U29.4
  T03 w0.117: v1(107.43,42.86) 107.43,44.13 106.87,44.69 106.87,46.85 106.07,47.65 106.07,48.44 106.49,48.86 106.49,49.75 107.32,50.57 107.32,51.19 CJ8.BT6
  T07 w0.117: v1(179.67,40.01) 178.86,39.2 178.86,35.2 178.53,34.87 176.66,34.87 175.89,35.64 171.49,35.64 169.94,34.08 156.64,34.08 154.22,36.5 151.92,36.5 151.24,35.82 151.24,35.29 150.82,34.87 150.35,34.87 149.88,35.34 149.88,35.57 149.02,36.43 137.83,36.43 137.72,36.31 125.66,36.31 123.69,38.29 118.92,38.29 118.82,38.19 115.03,38.19 114.96,38.12 110.98,38.12 110.28,38.81 109.63,38.81 108.43,40.01 108.43,40.29 107.43,41.29 v1(107.43,42.86) ; v1(102.47,75.21) 102.47,74.27 104.16,72.57 104.16,58.94 105.72,57.38 105.72,56.42 106.48,55.66 106.48,54.68 106.1,54.31 CJ8.BT6
  BOTTOM w0.14: Q29.5 v1(107.43,42.86) ; U47.9 179.45,34.44 180.34,35.33 180.34,39.06 180.12,39.27 R330.1 v1(179.67,40.01)
SFP+_P02_RATE_SEL: length 46.8
  T03 w0.117: CJ8.BT7 CJ8.BT9
  T07 w0.117: CJ8.BT9 108.5,51.81 109.98,50.33 109.98,45.41 109.46,44.89 109.46,43.49 111.29,41.66 113.27,41.66 114.25,40.68 117.01,40.68 118.28,41.95 119.07,41.95 119.66,41.37 123.87,41.37 124.88,40.35 124.88,39.89 126.23,38.54 128.26,38.54 128.43,38.71 135.54,38.71 136.28,37.97 v1(136.28,37.67)
  T18 w0.117: CJ8.BT7 CJ8.BT9
  BOTTOM w0.14: R763.2 136.14,37.53 v1(136.28,37.67) 136.14,37.8 136.14,38.33 R327.1
SFP+_P02_RATE_SEL_OUT: length 8.7
  BOTTOM w0.14: v2(138.82,30.72) 138.68,30.86 136.4,30.86 135.17,32.08 U51.9 135.17,35.2 R763.1
SFP+_P02_RX_LOS: length 67.1
  T07 w0.117: v1(150.58,40.01) 150.02,39.44 146.88,39.44 145.8,38.35 143.87,38.35 143.64,38.12 137.76,38.12 136.74,39.13 127.52,39.13 127.35,38.96 126.41,38.96 125.31,40.06 125.31,40.52 124.04,41.79 119.83,41.79 119.25,42.37 118.1,42.37 116.83,41.1 114.43,41.1 113.45,42.08 111.72,42.08 110.62,43.18 110.62,50.37 110.19,50.8 110.19,53.54 109.15,54.57 108.07,54.57 107.7,54.2 CJ8.BT8
  BOTTOM w0.14: v1(150.58,40.01) R329.1 151.04,39.27 151.26,39.05 151.26,35.13 150.47,34.35 U48.9
SFP+_P02_RXVCC: length 10.2
  TOP w0.635: v1(109.38,62.36) C1008.1 109.38,64.04
  P10 w0.508: v1(109.38,62.36) 107.26,60.24 107.26,58.77 105.7,57.21 CJ8.BT15
SFP+_P02_TX_DIS: length 28.4
  T03 w0.117: v1(107.86,40.01) 107.54,40.01 100.87,46.67 100.87,47.28 98.64,49.52 98.64,50.77 99.44,51.56 100.98,51.56 103.21,53.79 CJ8.BT3
  BOTTOM w0.14: v1(107.86,40.01) R326.1 108.32,39.27 108.46,39.13 108.46,35.06 107.75,34.35 U54.9
SFP+_P02_TX_FLT: length 38.7
  T07 w0.117: v1(121.92,39.96) 120.68,38.71 118.75,38.71 118.74,38.71 114.2,38.71 114.04,38.54 111.98,38.54 108.1,42.42 108.1,43 107.56,43.53 104.5,43.53 101.25,46.78 101.25,49.35 102.49,50.59 102.49,51.99 CJ8.BT2
  BOTTOM w0.14: v1(121.92,39.96) 121.91,39.94 R328.1 122.39,39.27 122.55,39.12 122.55,35.1 121.8,34.35 U53.9
SFP+_P02_TXVCC: length 8.2
  TOP w0.635: v6(102.65,62.46) C1005.1 102.65,64.04
  P10 w0.508: v6(102.65,62.46) 103.25,61.86 103.25,58.37 CJ8.BT16
SFP+_P03_MOD_ABS: length 127.3
  TOP w0.14: U29.5 103.13,74.87 102.57,74.31 v1(101.27,74.31)
  T03 w0.117: v1(105.48,42.86) 105.42,42.86 101.35,46.93 101.35,49.41 102.48,50.54 102.48,51.08 103.03,51.63 104.12,51.63 CJ8.BL6
  T07 w0.117: v1(179.67,35.44) 179.28,35.05 179.28,35.03 177.82,33.57 170.37,33.57 170.27,33.66 155.69,33.66 153.27,36.08 152.09,36.08 151.66,35.65 151.66,35.11 150.99,34.45 150.03,34.45 149.65,34.82 143.24,34.82 142.06,36 138.28,36 138.16,35.89 125.49,35.89 124.53,36.85 111.06,36.85 109.51,38.39 108.68,38.39 107.15,39.91 107.15,40.49 105.48,42.16 v1(105.48,42.86) ; CJ8.BL6 104.86,50.85 103.74,51.97 103.74,52.73 104.52,53.52 104.52,54.31 104.89,54.68 104.89,55.66 104.14,56.42 104.14,57.79 103.51,58.42 103.51,72.58 101.77,74.31 v1(101.27,74.31)
  BOTTOM w0.14: Q29.2 v1(105.48,42.86) ; U47.8 178.8,34.4 179.67,35.27 v1(179.67,35.44) R337.1
SFP+_P03_RATE_SEL: length 44
  T03 w0.117: CJ8.BL7 CJ8.BL9
  T07 w0.117: v1(135.13,37.72) 134.14,36.73 126.03,36.73 123.99,38.77 123.99,40.05 123.52,40.52 121.69,40.52 121.1,39.94 121.1,39.77 120.77,39.44 117.04,39.44 116.64,39.84 114.7,39.84 113.82,38.96 112.16,38.96 108.52,42.6 108.52,43.31 106.8,45.03 106.36,45.03 105.28,46.11 105.28,46.83 104.52,47.6 104.52,49.05 CJ8.BL7
  BOTTOM w0.14: R759.2 v1(135.13,37.72) 135.13,38.33 R334.1
SFP+_P03_RATE_SEL_OUT: length 9.7
  BOTTOM w0.14: R759.1 134.52,35.57 U51.8 134.52,31.97 136.14,30.35 137.8,30.35 v2(138.7,29.46)
SFP+_P03_RX_LOS: length 61
  T07 w0.117: v1(150.58,35.44) 150.58,35.88 149.4,37.06 136.09,37.06 135.71,37.43 135.71,37.94 135.36,38.29 128.61,38.29 127.47,37.16 126.2,37.16 124.46,38.9 124.46,40.17 123.69,40.95 120.07,40.95 119.7,40.57 118.92,40.57 118.61,40.26 116.82,40.26 114.08,40.26 113.1,41.24 111.11,41.24 109.04,43.31 109.04,43.66 109.04,43.81 106.88,45.97 106.88,46.84 106.09,47.63 106.09,48.24 105.62,48.71 105.29,48.71 104.89,49.11 104.89,49.75 103.79,50.85 CJ8.BL8
  BOTTOM w0.14: R336.1 v1(150.58,35.44) 150.58,35.34 149.82,34.58 U48.8
SFP+_P03_RXVCC:
  vias: v2(101.21,62.25)
SFP+_P03_TX_DIS: length 19.6
  T03 w0.117: v1(107.86,35.44) 108.53,36.1 108.53,43.88 109.94,45.29 109.94,47.87 109.07,48.74 108.04,48.74 CJ8.BL3
  BOTTOM w0.14: R333.1 v1(107.86,35.44) 107.86,35.34 107.1,34.58 U54.8
SFP+_P03_TX_FLT: length 29.5
  T14 w0.117: CJ8.BL2 108.98,50.85 110.18,49.65 110.18,45.66 108.97,44.45 108.97,41.56 113.96,36.56 120.57,36.56 v1(121.72,35.41)
  BOTTOM w0.14: U53.8 121.15,34.58 121.72,35.16 v1(121.72,35.41) 121.91,35.6 R335.1
SFP+_P03_TXVCC:
  vias: v2(111.25,61.79)
SFP+_P04_MOD_ABS: length 107.6
  TOP w0.14: v1(114.54,74.95) 114.71,75.12 U32.4
  T03 w0.117: CJ8.CT6 119.93,51.98 119.93,50.58 120.78,49.73 120.78,48.84 120.37,48.43 120.37,47.62 121.13,46.85 121.13,45.5 121.8,44.83 v1(121.8,43.12)
  T07 w0.117: v1(178.29,40.01) 176.57,38.28 173.76,38.28 173.5,38.54 153.45,38.54 150.99,41 149.04,41 148.29,41.74 148.29,41.75 148.04,41.99 146.3,41.99 143.27,38.96 140.44,38.96 138.33,41.07 134.03,41.07 132.42,42.67 128.52,42.67 127.83,41.98 125.44,41.98 124.7,42.72 122.2,42.72 v1(121.8,43.12) ; v1(114.54,74.95) 114.54,74.16 117.04,71.67 117.04,63.67 117.73,62.97 117.73,59.62 119.97,57.38 119.97,56.43 120.72,55.68 120.72,54.81 120.35,54.44 CJ8.CT6
  BOTTOM w0.14: v1(121.8,43.12) 121.41,42.74 Q30.5 ; v1(178.29,40.01) R344.1 178.81,39.27 178.96,39.12 178.96,35.27 178.15,34.47 U47.7
SFP+_P04_RATE_SEL: length 35
  T03 w0.117: CJ8.CT7 CJ8.CT9
  T18 w0.117: v1(133.02,40.08) 131.48,38.54 125.58,38.54 119.56,44.56 119.56,46.81 118.79,47.57 118.79,48.5 119.18,48.89 119.18,49.78 119.94,50.54 119.94,51.48 119.53,51.89 119.53,52.68 120.65,53.79 CJ8.CT7 CJ8.CT9
  BOTTOM w0.14: v1(133.02,40.08) 133.23,40.08 133.68,39.63 133.68,38.6 133.82,38.46 R341.1 134.24,37.11 R765.2
SFP+_P04_RATE_SEL_OUT: length 10.7
  BOTTOM w0.14: v2(138.55,28.19) 137.28,29.46 136.14,29.46 133.87,31.73 U51.7 133.86,33.47 133.86,35.92 R765.1
SFP+_P04_RX_LOS: length 47.4
  T18 w0.117: v1(149.21,40.01) 149.21,40.32 147.4,42.13 143.74,42.13 143.12,41.51 136.87,41.51 136.14,40.78 132.66,40.78 131.17,42.27 129.26,42.27 128.75,41.76 124.68,41.76 121.14,45.31 121.14,46.84 120.37,47.61 120.37,48.43 120.73,48.79 120.73,49.73 121.54,50.54 121.54,51.99 CJ8.CT8
  BOTTOM w0.14: v1(149.21,40.01) R343.1 149.64,39.27 149.89,39.02 149.89,35.29 149.17,34.57 U48.7
SFP+_P04_RXVCC: length 9.1
  TOP w0.635: v6(121.1,62.49) 121.46,62.84 C1020.1
  P10 w0.508: CJ8.CT15 119.95,57.34 121.1,58.5 v6(121.1,62.49)
SFP+_P04_TX_DIS: length 74.7
  T05 w0.117: CJ8.CT3 118.73,54.56 123.3,54.56 124.71,53.15 124.71,50.78 126.21,49.28 126.21,42.46 126.79,41.88 127.3,41.88 128.44,40.75 128.44,39.18 129.31,38.31 129.31,32.92 123.9,27.51 118.09,27.51 116.24,25.66 111.47,25.66 v1(111.45,25.64)
  T14 w0.117: v1(111.45,25.64) 108.56,28.53 108.56,37.93 v1(106.49,40.01)
  BOTTOM w0.14: v1(106.49,40.01) R340.1 106.92,39.27 107.06,39.13 107.06,35.18 106.45,34.57 U54.7
SFP+_P04_TX_FLT: length 21.8
  T05 w0.117: CJ8.CT2 116.77,52.01 116.77,50.57 117.55,49.78 117.55,49.02 117.85,48.73 118.4,48.73 118.79,48.34 118.79,47.57 119.56,46.8 119.56,43.95 120.53,42.97 v1(120.53,40.01)
  BOTTOM w0.14: U53.7 120.5,34.57 121.18,35.25 121.18,39.12 121.03,39.27 R342.1 v1(120.53,40.01)
SFP+_P04_TXVCC: length 9.5
  TOP w0.635: C1017.1 114.73,62.77 v6(115.01,62.49)
  P10 w0.508: v6(115.01,62.49) 115.95,62.49 117.45,60.99 117.45,58.42 CJ8.CT16
SFP+_P05_MOD_ABS: length 107.4
  TOP w0.14: v1(113.16,74.86) 113.68,74.34 114.9,74.34 115.18,74.62 U32.5
  T03 w0.117: CJ8.CL6 119.15,48.86 118.79,48.5 118.79,47.57 119.56,46.8 119.56,42.99 v1(119.81,42.74)
  T07 w0.117: CJ8.CL6 117.99,52.02 117.99,52.71 118.77,53.49 118.77,54.51 119.14,54.88 119.14,55.66 118.39,56.41 118.39,57.79 117.01,59.17 117.01,61.75 116.21,62.56 116.21,71.61 113.16,74.65 v1(113.16,74.86) ; v1(178.29,35.44) 176.86,36.87 154.52,36.87 150.82,40.57 148.86,40.57 147.87,41.57 146.47,41.57 143.44,38.54 139.43,38.54 137.32,40.65 133.19,40.65 131.59,42.25 128.74,42.25 127.94,41.46 125.24,41.46 124.49,42.21 120.33,42.21 v1(119.81,42.74)
  BOTTOM w0.14: Q30.2 v1(119.81,42.74) ; U47.6 177.5,34.65 v1(178.29,35.44) R351.1
SFP+_P05_RATE_SEL: length 32.6
  T03 w0.117: CJ8.CL7 CJ8.CL9
  T18 w0.117: v1(133.1,37.72) 132.43,37.06 124.89,37.06 123.56,38.39 119.98,38.39 118.18,40.19 118.18,44.38 115.13,47.43 115.13,48.21 116.38,49.47 CJ8.CL9 CJ8.CL7
  BOTTOM w0.14: R767.2 v1(133.1,37.72) R348.1
SFP+_P05_RATE_SEL_OUT: length 11.5
  BOTTOM w0.14: v2(127,29.21) 130.3,29.21 133.22,32.13 U51.6 133.22,36.05 R767.1
SFP+_P05_RX_LOS: length 51.3
  T18 w0.117: CJ8.CL8 117.04,50.85 114.86,48.66 114.86,46.69 117.6,43.94 117.6,38.55 118.49,37.66 118.49,37.59 119.86,36.22 140.57,36.22 141.91,34.87 148.64,34.87 v1(149.21,35.44)
  BOTTOM w0.14: U48.6 148.52,34.75 v1(149.21,35.44) R350.1
SFP+_P05_RXVCC:
  vias: v2(113.54,61.67)
SFP+_P05_TX_DIS: length 39.3
  T03 w0.117: v1(107.04,29.8) 107.04,30.7 118.32,41.99 121.46,41.99 122.45,42.98 122.45,43.64 124.46,45.65 124.46,47.36 123.1,48.73 122.3,48.73 CJ8.CL3
  T14 w0.117: v1(107.04,29.8) 107.04,34.88 v1(106.49,35.44)
  BOTTOM w0.14: U54.6 105.8,34.75 v1(106.49,35.44) R347.1
SFP+_P05_TX_FLT: length 22.3
  T03 w0.117: CJ8.CL2 122.96,50.85 124.88,48.93 124.88,45.47 122.88,43.47 122.88,42.81 120.74,40.68 120.4,40.68 119.97,40.24 119.97,36 v1(120.53,35.44)
  BOTTOM w0.14: R349.1 v1(120.53,35.44) 119.85,34.75 U53.6
SFP+_P05_TXVCC:
  vias: v2(123.31,62.23)
SFP+_P06_MOD_ABS: length 92
  TOP w0.14: v1(125.75,74.51) 126.35,75.12 U35.4
  T03 w0.117: CJ8.DT6 135.77,51.24 135.77,50.51 135,49.74 135,48.87 134.59,48.46 134.59,47.63 135.38,46.84 135.38,46.17 136.16,45.4 v1(136.16,42.35)
  T07 w0.117: v1(176.92,40.01) 175.96,40.97 172.24,40.97 171.76,41.44 161.4,41.44 160.21,40.26 157.73,40.26 156.33,41.66 152.42,41.66 150.63,43.45 143.42,43.45 141.93,41.96 136.56,41.96 v1(136.16,42.35) ; CJ8.DT6 134.6,52.4 134.6,54.44 134.98,54.81 134.98,55.66 134.22,56.42 134.22,57.38 131.87,59.73 131.87,66.16 125.75,72.28 v1(125.75,74.51)
  BOTTOM w0.14: v1(176.92,40.01) R358.1 177.38,39.27 177.58,39.07 177.58,35.29 176.85,34.56 U47.5 ; Q31.5 v1(136.16,42.35)
SFP+_P06_RATE_SEL: length 28
  T03 w0.117: CJ8.DT9 CJ8.DT7 134.64,54.55 133.29,54.55 132.97,54.24 132.97,53.44 132.21,52.68 132.21,51.89 131.96,51.63 131.32,51.63 130.99,51.31 130.99,50.55 128.91,48.47 128.91,40 129.36,39.55 130.26,39.55 v1(132.08,37.72)
  T18 w0.117: CJ8.DT7 CJ8.DT9
  BOTTOM w0.14: R769.2 v1(132.08,37.72) R355.1
SFP+_P06_RATE_SEL_OUT: length 9.2
  BOTTOM w0.14: R769.1 132.57,35.68 U51.5 132.57,32.24 130.31,29.98 v2(128.4,29.98)
SFP+_P06_RX_LOS: length 26.7
  T05 w0.117: v1(148.08,40.39) 147.3,40.39 143.74,43.95 143.74,47.3 142.2,48.84 140.47,48.84 136.9,52.4 CJ8.DT8
  BOTTOM w0.14: U48.5 147.87,34.67 148.53,35.33 148.53,39.06 148.33,39.27 R357.1 147.83,40.14 v1(148.08,40.39)
SFP+_P06_RXVCC: length 9.7
  TOP w0.635: C1032.1 133.54,63.16 132.9,62.53 v1(132.63,62.53)
  P10 w0.508: v1(132.63,62.53) 132.63,58.76 134.2,57.19 CJ8.DT15
SFP+_P06_TX_DIS: length 74.6
  T05 w0.117: v1(107.5,25.45) 108.04,25.99 109.99,25.99 110.92,25.07 111.99,25.07 112.16,25.24 116.41,25.24 118.26,27.09 124.07,27.09 129.73,32.74 129.73,38.65 128.86,39.52 128.86,43.22 127.14,44.94 127.14,50.77 127.94,51.56 129.46,51.56 131.08,53.18 131.59,53.18 CJ8.DT3
  T14 w0.117: v1(105.11,40.01) 105.82,39.3 105.82,26.39 106.75,25.45 v1(107.5,25.45)
  BOTTOM w0.14: v1(105.11,40.01) R354.1 105.53,39.27 105.67,39.13 105.67,35.18 105.15,34.67 U54.5
SFP+_P06_TX_FLT: length 29
  T16 w0.117: v1(119.16,40.01) 120.87,41.72 128.03,41.72 129.27,42.96 129.27,48.84 131.04,50.6 131.04,52.03 CJ8.DT2
  BOTTOM w0.14: U53.5 119.2,34.67 119.86,35.33 119.86,39 119.59,39.27 R356.1 v1(119.16,40.01)
SFP+_P06_TXVCC: length 11.3
  TOP w0.635: v1(127.09,62.49) 126.81,62.77 C1029.1
  P10 w0.508: v1(127.09,62.49) 127.09,60.43 129.5,58.01 132.11,58.01 CJ8.DT16
SFP+_P07_MOD_ABS: length 92.9
  TOP w0.14: v1(124.83,73.34) 125.18,73.7 125.96,73.7 126.88,74.62 U35.5
  T03 w0.117: CJ8.DL6 133.4,48.92 133.02,48.54 133.02,47.61 133.79,46.85 133.79,42.75 v1(134.19,42.35)
  T07 w0.117: v1(176.1,39.98) 174.82,38.71 173.93,38.71 173.67,38.96 154.52,38.96 151.54,41.94 149.7,41.94 148.61,43.03 144.97,43.03 143.48,41.53 136.18,41.53 135.36,42.35 v1(134.19,42.35) ; v1(124.83,73.34) 124.83,72.6 131.45,65.98 131.45,58.98 132.64,57.79 132.64,56.39 133.39,55.65 133.39,54.84 133,54.45 133,53.47 132.18,52.66 132.18,52.07 CJ8.DL6
  BOTTOM w0.14: v1(134.19,42.35) Q31.2 ; v1(176.1,39.98) 176.22,39.87 176.22,36.43 176.48,36.17 R365.1 176.92,35.31 176.2,34.6 U47.4
SFP+_P07_RATE_SEL: length 16.2
  T03 w0.117: CJ8.DL7 CJ8.DL9
  T05 w0.117: CJ8.DL9 129.76,48.23 129.76,42.96 130.94,41.79 130.94,40.68 130.5,40.24 130.5,38.83 131.06,38.26 v1(131.06,37.72)
  BOTTOM w0.14: R772.2 v1(131.06,37.72) R362.1
SFP+_P07_RATE_SEL_OUT: length 3.1
  BOTTOM w0.14: U51.4 131.92,34.83 v2(131.61,35.15) 131.06,35.69 R772.1
SFP+_P07_RX_LOS: length 32.9
  T05 w0.117: v1(147.83,35.44) 147.07,36.2 147.07,38.09 145.1,40.06 143.46,40.06 142.64,40.88 142.64,46.06 142.14,46.56 142.13,46.56 141.83,46.86 141.83,46.87 137.07,51.63 135.91,51.63 135.44,52.11 135.44,52.7 134.93,53.21 134.33,53.21 134.1,52.98 133.49,52.98 133.26,53.21 132.73,53.21 132.21,52.7 132.21,51.26 CJ8.DL8
  BOTTOM w0.14: U48.4 147.22,34.82 v1(147.83,35.44) R364.1
SFP+_P07_RXVCC:
  vias: v2(125.48,62.56)
SFP+_P07_TX_DIS: length 69.6
  T03 w0.117: CJ8.DL3 136.56,48.72 137.35,48.72 138.67,47.4 138.67,43.81 139.1,43.39 139.1,38.86 133.77,33.53 130.01,33.53 127.36,30.88 110.71,30.88 107.16,27.33 103.96,27.33 v1(101.96,25.33)
  T14 w0.117: v1(105.11,35.44) 105.11,28.48 v1(101.96,25.33)
  BOTTOM w0.14: U54.4 104.5,34.82 v1(105.11,35.44) R361.1
SFP+_P07_TX_FLT: length 53.3
  T03 w0.117: v1(115.53,28.59) 122.96,28.59 124.83,30.46 127.54,30.46 130.19,33.11 133.95,33.11 139.52,38.68 139.52,43.56 139.27,43.81 139.1,43.98 139.1,49.07 137.31,50.85 CJ8.DL2
  T14 w0.117: v1(115.53,28.59) 115.53,31.81 v1(119.16,35.44)
  BOTTOM w0.14: U53.4 118.55,34.82 v1(119.16,35.44) R363.1
SFP+_P07_TXVCC:
  vias: v2(135.89,62.68)
SFP+_P08_MOD_ABS: length 79.8
  TOP w0.14: v5(142.39,75.04) 142.73,75.37 U38.4
  T03 w0.117: v1(150.32,42.51) 150.35,42.48 150.72,42.48 152.93,44.68 152.93,47.81 152.02,48.71 149.61,48.71 149.25,49.07 149.25,49.77 148.47,50.55 148.47,52.01 CJ8.ET6
  T07 w0.117: v5(142.39,75.04) 143.73,75.04 144.93,73.84 144.93,61.77 146.66,60.03 146.66,59.28 148.45,57.49 148.45,56.44 149.23,55.66 149.23,54.63 148.85,54.26 CJ8.ET6
  T18 w0.117: v1(150.32,42.51) 165.09,27.73 171.25,27.73 173.7,25.28 v1(176.05,25.28)
  BOTTOM w0.14: U47.20 176.85,26.08 v1(176.05,25.28) R372.1 ; Q32.5 150.18,42.35 150.32,42.5 v1(150.32,42.51)
SFP+_P08_RATE_SEL: length 59.9
  T03 w0.117: v1(131.45,20.96) 131.45,23.68 133.24,25.48 145.03,25.48 145.78,24.73 147,24.73 147.33,25.06 147.33,26.44 156.68,35.79 156.68,41.67 156.39,41.96 156.39,44.61 154.69,46.31 154.69,50.23 153.27,51.65 153.27,52.37 151.86,53.79 CJ8.ET9 CJ8.ET7
  T18 w0.117: CJ8.ET7 CJ8.ET9
  BOTTOM w0.14: R773.2 v1(131.45,20.96) R369.1
SFP+_P08_RATE_SEL_OUT: length 5.7
  BOTTOM w0.14: R773.1 131.45,23.91 v2(131.71,24.17) 132.46,24.93 132.46,26.49 132.57,26.6 U51.20
SFP+_P08_RX_LOS: length 36.4
  T03 w0.117: CJ8.ET8 151.63,51.22 152.92,51.22 154.19,49.95 154.19,34.82 146.76,27.39 v1(146.76,25.29)
  BOTTOM w0.14: R371.1 146.76,24.75 v1(146.76,25.29) 146.76,25.66 147.87,26.77 U48.20
SFP+_P08_RXVCC: length 10
  TOP w0.635: v1(149.01,62.61) 149.48,63.08 C1044.1 149.48,64.04
  P10 w0.508: v1(149.01,62.61) 150.12,61.51 150.12,58.89 148.45,57.23 CJ8.ET15
SFP+_P08_TX_DIS: length 95.3
  T05 w0.117: CJ8.ET3 147.24,54.57 151.6,54.57 153.21,52.96 153.21,49.55 153.79,48.97 153.79,39.79 154.45,39.13 154.45,32.97 153.36,31.89 153.36,30.61 147.48,24.73 146.39,24.73 145.87,25.24 137.28,25.24 135.56,23.52 134.74,22.7 130.13,22.7 128.36,20.94 120.61,20.94 119.56,19.88 113.77,19.88 113.32,20.33 105.32,20.33 v1(104.31,19.32)
  BOTTOM w0.14: v1(104.31,19.32) 104.22,19.41 104.22,21.87 104.8,22.46 104.8,24.4 104.66,24.54 R368.1 104.25,25.05 105.15,25.95 U54.20
SFP+_P08_TX_FLT: length 70.3
  T05 w0.117: CJ8.ET2 145.21,51.96 145.21,50.53 143.89,49.2 143.89,47.67 144.11,47.45 144.11,46.44 145.14,45.41 148.91,45.41 152.17,42.15 152.17,38.45 152.52,38.1 152.52,37.49 151.14,36.1 150.45,36.1 149.88,35.53 149.88,35.3 145.41,30.84 137.67,30.84 128.19,21.36 120.09,21.36 v1(119.26,20.53)
  BOTTOM w0.14: v1(119.26,20.53) 119.26,22.22 118.99,22.49 118.99,24.37 118.82,24.54 R370.1 118.3,24.76 119.2,25.66 U53.20
SFP+_P08_TXVCC: length 10.3
  TOP w0.635: v6(142.75,62.56) C1041.1 142.75,64.04
  P10 w0.508: v6(142.75,62.56) 143.72,61.6 145.29,61.6 146.52,60.36 146.52,57.85 CJ8.ET16
SFP+_P09_MOD_ABS: length 84.4
  TOP w0.14: v1(142.34,73.46) 142.34,73.96 143.26,74.87 U38.5
  T03 w0.117: v1(148.38,42.46) 145.43,42.46 143.85,44.04 143.85,48.09 144.49,48.73 147.08,48.73 147.65,49.3 CJ8.EL6
  T07 w0.117: v1(142.34,73.46) 142.45,73.36 142.74,73.36 144.02,72.08 144.02,61.93 145.89,60.07 145.89,58.43 146.89,57.43 146.89,56.4 147.63,55.65 147.63,54.69 147.22,54.28 147.22,53.44 146.46,52.68 146.46,52.04 CJ8.EL6
  T18 w0.117: v1(148.38,42.46) 149.47,42.46 164.62,27.31 171.07,27.31 173.8,24.59 176.74,24.59 v1(177.43,25.28)
  BOTTOM w0.14: R379.1 v1(177.43,25.28) 177.75,25.6 177.75,26.64 177.5,26.89 U47.19 ; v1(148.38,42.46) 148.27,42.35 Q32.2
SFP+_P09_RATE_SEL: length 49.1
  T05 w0.117: CJ8.EL7 147.61,48.71 148.54,48.71 148.9,48.36 148.9,47.58 149.65,46.83 149.65,45.91 150.24,45.31 151.23,45.31 152.59,43.95 152.59,38.84 153.6,37.82 153.6,35.28 144.22,25.9 135.55,25.9 v1(133.05,23.4)
  T18 w0.117: CJ8.EL7 CJ8.EL9
  BOTTOM w0.14: R376.1 R774.2 132.91,21.82 133.14,22.06 133.14,23.3 v1(133.05,23.4)
SFP+_P09_RATE_SEL_OUT: length 5.6
  BOTTOM w0.14: 133.22,25.81 133.28,25.76 133.28,24.59 132.46,23.77 R774.1 ; 133.22,25.81 U51.19 ; 133.22,25.81 v2(133.24,25.81)
SFP+_P09_RX_LOS: length 38.8
  T05 w0.117: CJ8.EL8 146.82,51.62 151.62,51.62 152.79,50.44 152.79,49.13 153.37,48.56 153.37,39.61 154.03,38.95 154.03,33.15 152.94,32.06 152.94,30.99 v1(147.95,25.99)
  BOTTOM w0.14: U48.19 148.52,26.57 147.95,26 v1(147.95,25.99) 147.95,25.44 148.34,25.04 R378.1
SFP+_P09_RXVCC:
  vias: v2(146.18,62.05)
SFP+_P09_TX_DIS: length 77.9
  T03 w0.117: CJ8.EL3 150.57,49.47 151.52,50.42 152.21,50.42 153.35,49.28 153.35,44.38 151.19,42.22 151.19,33.01 144.62,26.43 117.54,26.43 113.41,22.3 107.01,22.3 v1(106.3,21.59)
  BOTTOM w0.14: U54.19 105.8,25.45 105.62,25.27 R375.1 106.12,24.54 106.3,24.36 v1(106.3,21.59)
SFP+_P09_TX_FLT: length 59.7
  T03 w0.117: CJ8.EL2 152.74,50.85 153.77,49.82 153.77,34.99 144.79,26.01 120.41,26.01 v1(119.67,25.28)
  BOTTOM w0.14: U53.19 119.85,25.45 v1(119.67,25.28) R377.1
SFP+_P09_TXVCC:
  vias: v2(151.39,62.56)
SFP+_P10_MOD_ABS: length 70.3
  TOP w0.14: U27.4 154.7,75.37 v1(154.38,75.06)
  T03 w0.117: v1(164.53,42.23) 163.61,43.15 163.4,43.15 162.31,44.24 162.31,46.81 163.08,47.58 163.08,48.45 162.82,48.71 162.31,48.71 161.93,49.09 161.93,49.78 162.69,50.55 162.69,51.99 CJ8.FT6
  T18 w0.117: CJ8.FT6 163.1,54.05 162.6,54.55 159.31,54.55 157.93,55.94 157.93,57.17 156.85,58.25 156.85,72.74 154.52,75.06 v1(154.38,75.06) ; v1(178.8,25.28) 178.8,26.01 167.34,37.47 167.34,40.4 165.52,42.23 v1(164.53,42.23)
  BOTTOM w0.14: R386.1 v1(178.8,25.28) 178.15,25.92 U47.18 ; Q33.5 v1(164.53,42.23)
SFP+_P10_RATE_SEL: length 69.2
  T03 w0.117: CJ8.FT7 CJ8.FT9 166.07,53.79 167.24,52.62 167.24,51.49 169.07,49.65 169.07,46.95 171.11,44.91 171.11,41.92 171.84,41.2 171.84,38.75 171.43,38.35 167.69,34.6 160.66,27.58 155.75,27.58 152.31,24.13 148.38,24.13 147.63,23.39 147.63,22.71 146.59,21.66 134.18,21.66 v1(133.48,20.96)
  T18 w0.117: CJ8.FT7 CJ8.FT9
  BOTTOM w0.14: R775.2 133.48,21.53 v1(133.48,20.96) R383.1
SFP+_P10_RATE_SEL_OUT: length 5.4
  BOTTOM w0.14: U51.18 133.87,26.48 134.01,26.35 v2(134.01,24.05) 134.01,22.87 R775.1
SFP+_P10_RX_LOS: length 47.7
  T03 w0.117: v1(149.72,25.28) 153.91,29.47 161.95,29.47 167.51,35.03 171.41,38.93 171.41,41.03 170.69,41.75 170.69,42.1 170.69,44.8 168.7,46.79 168.7,49.28 166.55,51.43 165.67,51.43 CJ8.FT8
  BOTTOM w0.14: R385.1 v1(149.72,25.28) 149.17,25.82 U48.18
SFP+_P10_RXVCC: length 10.6
  TOP w0.635: v6(161.75,62.45) 161.56,62.65 C1056.1 161.56,64.04
  P10 w0.508: CJ8.FT15 162.7,55.34 162.7,57.41 163.96,58.66 163.96,60.83 162.34,62.45 v6(161.75,62.45)
SFP+_P10_TX_DIS: length 103.6
  T05 w0.117: v1(108.05,19.31) 108.66,19.91 112.61,19.91 114,18.52 119.68,18.52 121.25,20.09 134.55,20.09 135.44,20.98 135.44,21.27 136.12,21.95 148.99,21.95 149.34,21.6 151.33,21.6 151.8,22.07 151.8,23.22 152.33,23.76 152.83,23.76 156.18,27.11 158.4,27.11 167.3,36.01 167.3,39.38 168.51,40.6 168.51,50.26 167.13,51.64 167.13,53.39 165.94,54.58 161.49,54.58 CJ8.FT3
  BOTTOM w0.14: U54.18 106.45,25.53 107,24.98 R382.1 107.3,24.54 107.67,24.17 107.67,22.08 107.9,21.85 107.9,19.46 v1(108.05,19.31)
SFP+_P10_TX_FLT: length 79.5
  T05 w0.117: v1(119.22,19.09) 119.36,19.09 120.78,20.51 128.54,20.51 130.3,22.28 135.11,22.28 135.72,22.89 143.57,22.89 144.88,24.2 149.45,24.2 150.39,25.14 150.39,25.5 159.69,34.81 159.69,37.71 161.32,39.34 163.05,39.34 163.51,39.8 163.51,43.04 162.26,44.29 162.26,46.86 161.52,47.6 161.52,48.28 161.09,48.71 160.63,48.71 160.28,49.06 160.28,49.79 159.5,50.57 159.5,52 CJ8.FT2
  BOTTOM w0.14: v1(119.22,19.09) 120.4,20.26 120.4,24.38 120.55,24.54 R384.1 121.04,25.13 120.5,25.68 U53.18
SFP+_P10_TXVCC: length 12.8
  TOP w0.635: 154.83,64.04 C1053.1 154.83,62.7 v6(154.58,62.46)
  P10 w0.508: v6(154.58,62.46) 158.52,62.46 160.53,60.45 160.53,58.1 CJ8.FT16
SFP+_P11_MOD_ABS: length 82.4
  TOP w0.14: U27.5 155.26,74.87 154.43,74.04 v1(154.43,73.48)
  T03 w0.117: v1(162.56,42.23) 158.24,46.54 158.24,48.2 158.74,48.71 159.9,48.71 160.28,49.09 160.28,49.74 160.77,50.24 161.29,50.24 CJ8.FL6
  T18 w0.117: CJ8.FL6 161.13,51.62 159.18,51.62 158.24,52.56 158.24,54.99 157.66,55.58 157.66,56.72 156.34,58.04 156.34,72.65 155.51,73.48 v1(154.43,73.48) ; v1(178.8,19.98) 178.1,20.68 178.1,26.12 166.87,37.35 166.87,40.28 165.84,41.31 163.48,41.31 v1(162.56,42.23)
  BOTTOM w0.14: v1(178.8,19.98) R393.1 179.27,20.71 179.42,20.86 179.42,25.57 178.8,26.18 U47.17 ; Q33.2 v1(162.56,42.23)
