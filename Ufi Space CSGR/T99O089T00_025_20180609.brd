# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XFI_MAC_TO_SFP_DN17: length 70.8
  TOP w0.102: U1.C3 v4(230.86,103.5)
  T14 w0.102: v4(230.86,103.5) 230.86,103.79 230.76,103.89 230.57,103.89 230.46,103.79 230.46,103.27 230.64,103.1 231.17,103.1 231.46,102.81 231.46,101.12 231.5,101.08 231.5,101.06
  T14 w0.107: 231.5,101.06 231.5,94.7 224.52,87.73 218.43,87.73 216.09,85.39 216.09,62.56 213.85,60.32 213.85,50.74 211.86,48.75 211.86,48.25 211.53,47.91 211.37,47.82 211.33,47.68 CJ9.AB19
XFI_MAC_TO_SFP_DN18: length 53.5
  TOP w0.102: U1.A2 v4(231.86,101.5)
  T14 w0.107: CJ9.BT19 220.53,57.1 220.68,57.06 220.81,57.14 220.98,57.31 220.98,61.51 220.82,61.67 220.82,61.83 220.98,61.99 220.98,62.15 220.82,62.31 220.82,62.47 220.98,62.63 220.98,62.98 219.74,64.22 219.74,81.18 221.31,82.76 221.31,83.01 221.41,83.11 221.67,83.11 221.77,83.21 221.77,83.46 221.86,83.56 222.12,83.56 222.22,83.66 222.22,83.91 222.32,84.01 222.57,84.01 232.35,93.79 232.35,101.63 232.12,101.86 231.97,101.86 231.86,101.75 v4(231.86,101.5)
XFI_MAC_TO_SFP_DN19: length 64.9
  TOP w0.102: U1.C1 v4(232.86,103.5)
  T14 w0.102: 233.18,103.13 233.15,103.13 233.11,103.09 232.63,103.09 232.46,103.26 232.46,103.74 232.61,103.89 232.76,103.89 232.86,103.79 v4(232.86,103.5)
  T14 w0.107: 233.18,103.13 233.38,103.13 233.67,102.83 233.67,92.69 225.14,84.15 225.14,67.21 228.08,64.26 228.08,50.65 226.09,48.65 226.09,48.22 225.78,47.91 225.62,47.82 225.58,47.68 CJ9.BB19
XFI_MAC_TO_SFP_DN20: length 66.4
  TOP w0.102: U1.A24 v4(208.86,101.5)
  T16 w0.102: 207.5,101.08 207.5,101.11 207.46,101.14 207.46,101.7 207.66,101.89 208.76,101.89 208.86,101.79 v4(208.86,101.5)
  T16 w0.107: 207.5,101.08 207.5,100.28 205.73,98.51 205.73,87.73 206.38,87.08 206.63,87.08 206.73,86.98 206.73,86.74 206.84,86.63 207.08,86.63 207.18,86.53 207.18,86.28 207.29,86.18 207.53,86.18 207.64,86.08 207.64,85.83 213.11,80.36 213.11,71.53 214.53,70.1 214.66,70.1 214.67,70.11 214.8,70.11 214.9,70.01 214.9,69.88 214.89,69.88 214.89,69.74 214.98,69.65 215.12,69.65 215.12,69.65 215.25,69.65 215.35,69.56 215.35,69.43 215.34,69.42 215.34,69.29 215.44,69.2 215.57,69.2 215.57,69.2 215.71,69.2 215.8,69.11 215.8,68.98 215.8,68.97 215.8,68.84 223.27,61.37 228.15,61.37 233.3,56.23 233.95,56.23 234.61,56.88 234.74,56.96 234.78,57.1 CJ9.CT19
XFI_MAC_TO_SFP_DN21: length 82.5
  TOP w0.102: U1.C23 v4(209.86,103.5)
  T16 w0.102: 209.5,101.07 209.5,101.1 209.46,101.14 209.46,103.74 209.61,103.89 209.76,103.89 209.86,103.79 v4(209.86,103.5)
  T16 w0.107: CJ9.CB19 239.83,47.68 239.87,47.82 240.03,47.91 242.04,49.93 242.04,60.46 235.96,66.55 222.39,66.55 216.15,72.79 216.15,80.01 207.11,89.05 207.11,98.35 209.5,100.73 209.5,101.07
XFI_MAC_TO_SFP_DN22: length 73.5
  TOP w0.102: U1.A22 v4(210.86,101.5)
  T16 w0.102: 210.49,101.01 210.49,101.04 210.46,101.08 210.46,101.74 210.61,101.89 210.76,101.89 210.86,101.79 v4(210.86,101.5)
  T16 w0.107: 210.49,101.01 210.49,100.35 208.58,98.43 208.58,89.93 209.86,88.65 209.99,88.65 210.02,88.67 210.15,88.67 210.24,88.58 210.24,88.44 210.22,88.42 210.22,88.29 210.31,88.19 210.45,88.19 210.47,88.22 210.6,88.22 210.7,88.12 210.7,87.99 210.67,87.97 210.67,87.83 210.77,87.74 210.9,87.74 210.92,87.76 211.06,87.76 211.15,87.67 211.15,87.54 211.13,87.51 211.13,87.38 217.37,81.13 220.56,81.13 221.06,80.63 221.27,80.63 221.39,80.51 221.39,80.3 221.51,80.18 221.72,80.18 221.84,80.06 221.84,79.85 225.17,76.52 225.17,72.28 229.17,68.28 236.65,68.28 246.13,58.8 246.13,57.7 247.58,56.24 248.22,56.24 248.86,56.88 248.99,56.96 249.03,57.1 CJ9.DT19
XFI_MAC_TO_SFP_DN23: length 89.4
  TOP w0.102: U1.C21 v4(211.86,103.5)
  T16 w0.102: 211.5,101.07 211.5,101.09 211.47,101.13 211.47,103.7 211.64,103.87 211.78,103.87 211.86,103.79 v4(211.86,103.5)
  T16 w0.107: CJ9.DB19 254.08,47.68 254.12,47.82 254.28,47.91 256.19,49.82 256.19,61.33 251.42,66.09 241.29,66.09 237.26,70.13 231.26,70.13 228.47,72.91 228.47,75.14 220.64,82.97 218,82.97 210.44,90.53 210.44,98.53 211.5,99.6 211.5,101.07
XFI_MAC_TO_SFP_DN24: length 86.9
  TOP w0.102: U1.A20 v4(212.86,101.5)
  T16 w0.107: v4(212.86,101.5) 212.86,101.75 212.97,101.86 213.19,101.86 213.29,101.75 213.29,101.2 212.76,100.67 212.76,99.5 211.94,98.68 211.94,92.31 217.41,86.84 229.49,86.84 230.53,85.8 230.53,85.67 230.52,85.66 230.52,85.53 230.62,85.44 230.75,85.44 230.75,85.44 230.89,85.44 230.98,85.35 230.98,85.22 230.98,85.21 230.98,85.08 231.07,84.99 231.2,84.99 231.21,84.99 231.34,84.99 231.43,84.9 231.43,84.76 231.43,84.76 231.43,84.63 231.52,84.53 231.65,84.53 231.66,84.54 231.79,84.54 236.83,79.5 236.83,72.5 241.71,67.62 258.88,67.62 259.45,67.05 259.45,66.85 259.58,66.73 259.78,66.73 259.9,66.6 259.9,66.4 260.03,66.27 260.23,66.27 263.65,62.85 263.65,57.23 263.56,57.14 263.43,57.06 263.28,57.1 CJ9.ET19
XFI_MAC_TO_SFP_DN25: length 97.2
  TOP w0.102: U1.C19 v4(214.86,103.5)
  T16 w0.107: CJ9.EB19 268.33,47.68 268.37,47.82 268.53,47.91 270.52,49.9 270.52,61.46 262.46,69.52 248.99,69.52 248.26,70.25 248.26,70.42 248.12,70.56 247.95,70.56 230.05,88.46 218.53,88.46 214.18,92.81 214.18,100.36 214.43,100.61 214.43,103.68 214.6,103.86 214.75,103.86 214.86,103.75 v4(214.86,103.5)
XFI_MAC_TO_SFP_DN26: length 93.1
  TOP w0.102: U1.A18 v4(215.86,101.5)
  T16 w0.102: v4(215.86,101.5) 215.86,101.79 215.76,101.89 215.57,101.89 215.46,101.79 215.46,101.12 215.5,101.08 215.5,101.06
  T16 w0.107: CJ9.FT19 277.53,57.1 277.49,56.96 277.36,56.88 276.7,56.23 275.93,56.23 275,57.15 275,61.09 275.09,61.18 275.13,61.18 275.23,61.27 275.23,61.41 275.13,61.5 275.09,61.5 275,61.59 275,61.73 275.09,61.82 275.13,61.82 275.23,61.92 275.23,62.05 275.13,62.14 275.09,62.14 275,62.24 275,62.37 275.09,62.46 275.13,62.46 275.23,62.56 275.23,62.69 275.13,62.78 275.09,62.78 275,62.88 275,63.1 266.89,71.21 265.8,71.21 265.63,71.38 265.48,71.38 265.31,71.21 255.11,71.21 247.35,78.98 241.72,78.98 230.88,89.83 218.65,89.83 215.19,93.28 215.19,100 215.5,100.31 215.5,101.06
XFI_MAC_TO_SFP_DN27: length 108.2
  TOP w0.102: U1.C17 v4(216.86,103.5)
  T16 w0.102: v4(216.86,103.5) 216.86,103.79 216.81,103.84 216.57,103.84 216.47,103.74 216.47,101.06 216.5,101.02 216.5,100.99
  T16 w0.107: CJ9.FB19 282.58,47.68 282.62,47.82 282.78,47.91 284.94,50.08 284.94,60.45 284.07,61.33 279.07,61.33 259.43,80.97 241.52,80.97 231.42,91.06 219.38,91.06 216.18,94.26 216.18,99.7 216.5,100.03 216.5,100.99
XFI_MAC_TO_SFP_DP8: length 88.9
  TOP w0.102: U1.D29 v4(203.86,104.5)
  T14 w0.102: 202.79,99.9 203.19,100.29 203.19,100.67 203.26,100.74 203.26,103.83 203.53,104.1 203.76,104.1 203.86,104.2 v4(203.86,104.5)
  T14 w0.107: 202.79,99.9 197.94,99.9 187.45,89.41 184.93,89.41 177.08,81.56 168.54,81.56 165.52,78.54 157.01,78.54 155.48,77.01 155.48,71.17 146.62,62.3 146.62,60.13 146.48,60 146.48,59.81 146.62,59.68 146.62,59.49 146.48,59.36 146.48,59.17 146.62,59.04 146.62,56.32 146.32,56.02 145.95,56.02 145.82,56.1 145.78,56.24 CJ8.ET18
XFI_MAC_TO_SFP_DP9: length 91.6
  TOP w0.102: U1.B28 v4(204.86,102.5)
  T14 w0.102: v4(204.86,102.5) 204.86,102.2 204.76,102.1 204.53,102.1 204.26,101.83 204.26,100.63 204.22,100.59 204.22,100.56
  T14 w0.107: CJ8.EL18 150.59,46.76 150.73,47.01 150.69,47.16 150.53,47.25 150.27,47.51 150.27,48.43 150.75,48.91 152.53,48.91 154.18,50.56 154.18,50.59 155.33,51.74 155.33,60.97 156.38,62.02 156.38,67.9 160.88,72.4 160.88,74.91 163.08,77.11 165.51,77.11 168.53,80.14 177.33,80.14 181.9,84.71 187.45,84.71 201.29,98.55 202.99,98.55 204.22,99.79 204.22,100.56
XFI_MAC_TO_SFP_DP10: length 79.4
  TOP w0.102: U1.D27 v4(205.86,104.5)
  T14 w0.102: v4(205.86,104.5) 205.86,104.2 205.76,104.1 205.53,104.1 205.26,103.83 205.26,101.08 205.22,101.04 205.22,101.02
  T14 w0.107: CJ8.FT18 160.03,56.24 160.07,56.1 160.2,56.02 160.2,56.02 160.47,56.02 160.96,56.52 160.96,58.35 160.53,58.79 160.53,64.81 160.65,64.93 160.65,65.06 160.63,65.08 160.63,65.21 160.72,65.3 160.86,65.3 160.87,65.29 161,65.29 161.1,65.38 161.1,65.51 161.08,65.53 161.08,65.66 161.18,65.76 161.31,65.76 161.32,65.74 161.46,65.74 164.57,68.85 164.57,74.16 169.56,79.15 177.99,79.15 182.29,83.44 188.09,83.44 201.73,97.09 203.52,97.09 205.22,98.79 205.22,101.02
XFI_MAC_TO_SFP_DP11: length 81.6
  TOP w0.102: U1.B26 v4(206.86,102.5)
  T14 w0.102: v4(206.86,102.5) 206.86,102.2 206.76,102.1 206.53,102.1 206.25,101.82 206.25,101.03 206.22,100.99 206.22,100.96
  T14 w0.107: CJ8.FL18 164.84,46.76 164.98,47.01 164.94,47.16 164.78,47.25 164.57,47.46 164.57,48.38 165.1,48.91 166.63,48.91 169.57,51.86 169.57,61.51 173.13,65.07 173.13,74.85 176.41,78.13 178.86,78.13 183.05,82.32 188.62,82.32 201.9,95.61 204.11,95.61 206.39,97.89 206.39,99.4 206.22,99.57 206.22,100.96
XFI_MAC_TO_SFP_DP12: length 84
  TOP w0.102: U1.B8 v4(225.86,102.5)
  T14 w0.102: 225.22,101.14 225.22,101.17 225.26,101.21 225.26,101.83 225.53,102.1 225.76,102.1 225.86,102.2 v4(225.86,102.5)
  T14 w0.107: 225.22,101.14 225.22,98.87 220.99,94.64 204.51,94.64 204.51,94.64 202.97,94.64 188.98,80.64 182.99,80.64 179.54,77.19 179.54,74.4 175.19,70.04 175.19,58.85 175.03,58.69 175.03,58.53 175.19,58.37 175.19,58.21 175.03,58.05 175.03,57.89 175.19,57.73 175.19,56.39 174.82,56.02 174.45,56.02 174.32,56.1 174.28,56.24 CJ8.GT18
XFI_MAC_TO_SFP_DP13: length 92.6
  TOP w0.102: U1.D7 v4(226.86,104.5)
  T14 w0.102: 226.22,101.1 226.22,101.12 226.26,101.16 226.26,103.83 226.53,104.1 226.76,104.1 226.86,104.2 v4(226.86,104.5)
  T14 w0.107: 226.22,101.1 226.22,97.84 222.01,93.62 203.69,93.62 180.38,70.32 180.38,62.18 180.37,62.17 180.37,62.16 179.05,60.84 179.05,58.18 181.43,55.79 181.43,49.48 180.85,48.9 179.33,48.9 178.82,48.39 178.82,47.48 179.06,47.23 179.19,47.16 179.23,47.01 179.09,46.76 CJ8.GL18
XFI_MAC_TO_SFP_DP14: length 72.8
  TOP w0.102: U1.B6 v4(227.86,102.5)
  T14 w0.102: v4(227.86,102.5) 227.86,102.2 227.76,102.1 227.53,102.1 227.26,101.82 227.26,101.13 227.22,101.09 227.22,101.06
  T14 w0.107: 227.22,101.06 227.22,96.91 222.66,92.35 209.16,92.35 202.18,85.37 201.98,85.37 201.85,85.24 201.85,85.04 201.73,84.92 201.53,84.92 201.4,84.79 201.4,84.59 201.27,84.46 201.08,84.46 200.95,84.34 200.95,84.14 189.49,72.68 189.49,56.52 188.99,56.02 188.7,56.02 188.7,56.02 188.57,56.1 188.53,56.24 CJ8.HT18
XFI_MAC_TO_SFP_DP15: length 85
  TOP w0.102: U1.D5 v4(228.86,104.5)
  T14 w0.102: 228.22,101.14 228.22,101.16 228.25,101.2 228.25,103.8 228.54,104.09 228.75,104.09 228.86,104.2 v4(228.86,104.5)
  T14 w0.107: CJ8.HL18 193.34,46.76 193.48,47.01 193.44,47.16 193.28,47.25 193.25,47.28 193.06,47.28 192.61,46.82 192.61,45.79 193.01,45.39 195.16,45.39 196.42,46.65 196.42,46.86 196.54,46.98 196.75,46.98 196.87,47.1 196.87,47.31 196.99,47.43 197.2,47.43 197.32,47.55 197.32,47.76 197.45,47.88 197.65,47.88 199.14,49.37 199.14,59.74 199,59.88 199,60.06 199.14,60.2 199.14,60.38 199,60.52 199,60.7 199.14,60.84 199.14,61.02 199,61.16 199,61.34 199.14,61.48 199.14,62.22 203.27,66.35 203.27,77.77 207.69,82.2 207.69,82.42 207.81,82.53 208.03,82.53 208.14,82.65 208.14,82.87 208.26,82.99 208.48,82.99 208.6,83.1 208.6,83.32 208.71,83.44 208.93,83.44 216.58,91.08 223.29,91.08 228.93,96.72 228.93,100.16 228.22,100.87 228.22,101.14
XFI_MAC_TO_SFP_DP16: length 60.7
  TOP w0.102: U1.B4 v4(229.86,102.5)
  T14 w0.102: v4(229.86,102.5) 229.86,102.2 229.96,102.1 230.19,102.1 230.46,101.83 230.46,101.33 230.45,101.33 230.45,100.93 230.49,100.9 230.49,100.87
  T14 w0.107: CJ9.AT18 206.53,56.68 206.57,56.82 206.73,56.91 207.04,57.22 207.04,60.22 208.56,61.75 208.56,66.32 213.26,71.02 213.26,84.22 218.55,89.51 224.14,89.51 230.49,95.86 230.49,100.87
XFI_MAC_TO_SFP_DP17: length 70.9
  TOP w0.102: U1.D3 v4(230.86,104.5)
  T14 w0.102: v4(230.86,104.5) 230.86,104.2 230.76,104.1 230.48,104.1 230.26,103.88 230.26,103.19 230.56,102.89 231.09,102.89 231.26,102.72 231.26,101.12 231.22,101.08 231.22,101.06
  T14 w0.107: 231.22,101.06 231.22,94.82 224.41,88.01 218.31,88.01 215.81,85.51 215.81,62.67 213.57,60.44 213.57,50.86 211.58,48.86 211.58,48.36 211.36,48.14 211.23,48.06 211.08,48.1 CJ9.AB18
XFI_MAC_TO_SFP_DP18: length 53.5
  TOP w0.102: U1.B2 v4(231.86,102.5)
  T14 w0.107: CJ9.BT18 220.78,56.68 220.82,56.82 220.98,56.91 221.26,57.2 221.26,63.09 220.01,64.34 220.01,81.06 232.62,93.67 232.62,101.74 232.23,102.14 231.97,102.14 231.86,102.24 v4(231.86,102.5)
XFI_MAC_TO_SFP_DP19: length 64.8
  TOP w0.102: U1.D1 v4(232.86,104.5)
  T14 w0.102: v4(232.86,104.5) 232.86,104.2 232.76,104.1 232.53,104.1 232.26,103.82 232.26,103.18 232.54,102.89 233.11,102.89 233.15,102.85 233.18,102.85
  T14 w0.107: CJ9.BB18 225.33,48.1 225.48,48.06 225.61,48.14 225.81,48.34 225.81,48.77 227.8,50.77 227.8,64.14 224.86,67.09 224.86,84.27 233.39,92.8 233.39,102.72 233.26,102.85 233.18,102.85
XFI_MAC_TO_SFP_DP20: length 66.4
  TOP w0.102: U1.B24 v4(208.86,102.5)
  T16 w0.102: 207.22,101.08 207.22,101.11 207.26,101.14 207.26,101.78 207.58,102.1 208.76,102.1 208.86,102.2 v4(208.86,102.5)
  T16 w0.107: 207.22,101.08 207.22,100.4 205.46,98.63 205.46,87.62 212.83,80.25 212.83,71.41 223.15,61.09 228.04,61.09 233.18,55.95 234.07,55.95 234.78,56.66 234.88,56.72 235.03,56.68 CJ9.CT18
XFI_MAC_TO_SFP_DP21: length 82.5
  TOP w0.102: U1.D23 v4(209.86,104.5)
  T16 w0.102: v4(209.86,104.5) 209.86,104.2 209.76,104.1 209.53,104.1 209.26,103.83 209.26,101.14 209.22,101.1 209.22,101.07
  T16 w0.107: CJ9.CB18 239.58,48.1 239.73,48.06 239.86,48.14 241.76,50.05 241.76,60.34 235.84,66.27 222.28,66.27 215.87,72.67 215.87,79.9 206.83,88.93 206.83,98.46 209.22,100.85 209.22,101.07
XFI_MAC_TO_SFP_DP22: length 73.6
  TOP w0.102: U1.B22 v4(210.86,102.5)
  T16 w0.102: v4(210.86,102.5) 210.86,102.2 210.76,102.1 210.53,102.1 210.25,101.82 210.25,101.08 210.22,101.04 210.22,101.01
  T16 w0.107: CJ9.DT18 249.28,56.68 249.13,56.72 249.03,56.66 248.33,55.96 247.47,55.96 245.85,57.58 245.85,58.69 236.53,68 229.05,68 224.89,72.16 224.89,76.41 220.45,80.85 217.26,80.85 208.3,89.81 208.3,98.55 210.22,100.46 210.22,101.01
XFI_MAC_TO_SFP_DP23: length 89.4
  TOP w0.102: U1.D21 v4(211.86,104.5)
  T16 w0.102: 211.22,101.07 211.22,101.09 211.26,101.13 211.26,103.78 211.55,104.07 211.74,104.07 211.86,104.2 v4(211.86,104.5)
  T16 w0.107: 211.22,101.07 211.22,99.71 210.16,98.65 210.16,90.42 217.88,82.69 220.52,82.69 228.19,75.02 228.19,72.8 231.14,69.85 237.14,69.85 241.18,65.81 251.31,65.81 255.91,61.21 255.91,49.94 254.11,48.14 253.98,48.06 253.83,48.1 CJ9.DB18
XFI_MAC_TO_SFP_DP24: length 86.9
  TOP w0.102: U1.B20 v4(212.86,102.5)
  T16 w0.107: v4(212.86,102.5) 212.86,102.24 212.97,102.14 213.3,102.14 213.57,101.87 213.57,101.09 213.04,100.55 213.04,99.38 212.22,98.56 212.22,92.43 217.53,87.12 229.61,87.12 237.11,79.62 237.11,72.62 241.83,67.9 259,67.9 263.93,62.97 263.93,57.12 263.73,56.91 263.57,56.82 263.53,56.68 CJ9.ET18
XFI_MAC_TO_SFP_DP25: length 97.2
  TOP w0.102: U1.D19 v4(214.86,104.5)
  T16 w0.107: CJ9.EB18 268.08,48.1 268.23,48.06 268.36,48.14 270.24,50.02 270.24,61.35 262.34,69.24 248.87,69.24 229.94,88.18 218.41,88.18 213.9,92.69 213.9,100.48 214.15,100.73 214.15,103.8 214.49,104.14 214.75,104.14 214.86,104.24 v4(214.86,104.5)
XFI_MAC_TO_SFP_DP26: length 93.2
  TOP w0.102: U1.B18 v4(215.86,102.5)
  T16 w0.102: 215.22,101.06 215.22,101.08 215.26,101.12 215.26,101.88 215.48,102.1 215.76,102.1 215.86,102.2 v4(215.86,102.5)
  T16 w0.107: CJ9.FT18 277.78,56.68 277.63,56.72 277.53,56.66 276.82,55.95 275.81,55.95 274.72,57.04 274.72,62.98 266.77,70.93 255,70.93 247.23,78.7 241.61,78.7 230.76,89.55 218.53,89.55 214.91,93.16 214.91,100.12 215.22,100.43 215.22,101.06
XFI_MAC_TO_SFP_DP27: length 108.3
  TOP w0.102: U1.D17 v4(216.86,104.5)
  T16 w0.102: v4(216.86,104.5) 216.86,104.2 216.71,104.05 216.48,104.05 216.26,103.83 216.26,101.06 216.22,101.02 216.22,100.99
  T16 w0.107: 216.22,100.99 216.22,100.14 215.9,99.82 215.9,94.15 219.27,90.78 231.3,90.78 241.4,80.69 259.32,80.69 278.96,61.05 283.95,61.05 284.66,60.34 284.66,50.19 282.61,48.14 282.48,48.06 282.33,48.1 CJ9.FB18
XFI_PHY1_TO_MAC_DN0: length 84.4
  TOP w0.102: U1.H37 v4(195.86,108.5)
  TOP w0.14: U23.T2 v4(121.21,104.36)
  T16 w0.102: v4(121.21,104.36) 121.21,104.66 121.31,104.76 121.54,104.76 121.82,105.03 121.82,105.9 121.86,105.94 121.86,105.97
  T16 w0.107: v4(195.86,108.5) 195.86,108.75 195.75,108.86 194.91,108.86 193.66,110.11 192.03,110.11 191.39,109.47 150.13,109.47 145.95,113.65 127.91,113.65 121.86,107.6 121.86,105.97
XFI_PHY1_TO_MAC_DN1: length 85.4
  TOP w0.102: U1.H35 v4(197.86,108.5)
  TOP w0.14: U23.P1 v4(123.21,105.36)
  T16 w0.102: 122.85,105.84 122.85,105.82 122.81,105.78 122.81,105.12 122.97,104.96 123.11,104.96 123.21,105.06 v4(123.21,105.36) ; v4(197.86,108.5) 197.86,108.79 197.76,108.89 197.61,108.89 197.46,108.74 197.46,108.18 197.17,107.89 195.56,107.89 195.52,107.85 195.49,107.85
  T16 w0.107: 195.49,107.85 195.21,107.85 194.18,106.81 192.01,106.81 190.43,108.39 189.08,108.39 188.93,108.24 188.76,108.24 188.61,108.39 188.44,108.39 188.29,108.24 188.12,108.24 187.97,108.39 149.21,108.39 146.84,110.76 146.69,110.76 146.53,110.91 146.53,111.06 146.38,111.21 146.23,111.21 146.08,111.36 146.08,111.52 145.74,111.85 140.54,111.85 139.86,112.54 129.41,112.54 124.27,107.39 124.27,107.24 124.12,107.09 123.96,107.09 123.81,106.94 123.81,106.78 123.67,106.64 123.51,106.64 123.36,106.49 123.36,106.33 123.21,106.18 123.06,106.18 122.85,105.98 122.85,105.84
XFI_PHY1_TO_MAC_DN2: length 83.2
  TOP w0.102: U1.F36 v4(196.86,106.5)
  TOP w0.14: U23.M2 v4(125.21,104.36)
  T16 w0.102: 125.85,105.69 125.85,105.67 125.82,105.63 125.82,105.03 125.54,104.76 125.31,104.76 125.21,104.66 v4(125.21,104.36) ; 195.45,105.86 195.48,105.86 195.52,105.9 196.24,105.9 196.46,106.12 196.46,106.74 196.61,106.89 196.76,106.89 196.86,106.79 v4(196.86,106.5)
  T16 w0.107: 125.85,105.69 125.85,107.05 130.22,111.42 138.97,111.42 139.65,110.74 143.94,110.74 148.82,105.87 168.96,105.87 170.27,107.18 186.54,107.18 189.45,104.28 193.05,104.28 194.63,105.86 195.45,105.86
XFI_PHY1_TO_MAC_DN3: length 82.2
  TOP w0.102: U1.F34 v4(198.86,106.5)
  TOP w0.14: U23.J1 v4(128.21,105.36)
  T16 w0.102: v4(198.86,106.5) 198.86,106.79 198.76,106.89 197.58,106.89 197.46,106.77 197.46,105.22 197.14,104.9 195.53,104.9 195.49,104.86 195.46,104.86
  T16 w0.107: v4(128.21,105.36) 127.86,105.72 127.86,106.34 128.32,106.81 128.52,106.81 128.65,106.94 128.65,107.13 128.77,107.26 128.97,107.26 129.1,107.39 129.1,107.59 129.23,107.71 129.43,107.71 129.55,107.84 129.55,108.04 131.84,110.32 137.82,110.32 138.6,109.55 142.73,109.55 147.65,104.63 171.34,104.63 172.42,105.71 186.32,105.71 188.91,103.11 193.57,103.11 195.31,104.86 195.46,104.86
XFI_PHY1_TO_MAC_DN4: length 83.3
  TOP w0.102: U1.J33 v4(199.86,109.5)
  TOP w0.14: U23.G1 v4(131.21,105.36)
  T16 w0.102: 131.57,105.97 131.57,105.94 131.61,105.9 131.61,105.11 131.46,104.96 131.31,104.96 131.21,105.06 v4(131.21,105.36) ; v4(199.86,109.5) 199.86,109.2 199.76,109.1 199.53,109.1 199.26,108.82 199.26,103.29 199.06,103.09 195.43,103.09 195.39,103.13 195.36,103.13
  T16 w0.107: 131.57,105.97 131.57,107.14 133.07,108.64 142.44,108.64 147.33,103.76 173.12,103.76 174.21,104.84 185.01,104.84 187.72,102.14 193.97,102.14 194.97,103.13 195.36,103.13
XFI_PHY1_TO_MAC_DN5: length 82.6
  TOP w0.102: U1.G32 v4(200.86,107.5)
  TOP w0.14: U23.E2 v4(133.21,104.36)
  T16 w0.102: 200.22,101.11 200.22,101.13 200.26,101.17 200.26,106.82 200.53,107.1 200.76,107.1 200.86,107.2 v4(200.86,107.5) ; 132.57,105.8 132.57,105.77 132.61,105.74 132.61,105.03 132.88,104.76 133.11,104.76 133.21,104.66 v4(133.21,104.36)
  T16 w0.107: 132.57,105.8 132.57,106.19 133.93,107.55 141.99,107.55 146.87,102.67 185.36,102.67 188.35,99.68 198.95,99.68 200.22,100.96 200.22,101.11
XFI_PHY1_TO_MAC_DN6: length 82.4
  TOP w0.102: U1.J31 v4(201.86,109.5)
  TOP w0.14: U23.C1 v4(135.21,105.36)
  T16 w0.102: 135.58,105.77 135.58,105.74 135.62,105.7 135.62,105.07 135.51,104.96 135.31,104.96 135.21,105.06 v4(135.21,105.36) ; v4(201.86,109.5) 201.86,109.2 201.76,109.1 201.53,109.1 201.26,108.83 201.26,101.09 201.22,101.06 201.22,101.03
  T16 w0.107: 201.22,101.03 201.22,100.51 199.24,98.53 187.86,98.53 185.06,101.33 145.05,101.33 139.99,106.38 135.93,106.38 135.58,106.03 135.58,105.77
XFI_PHY1_TO_MAC_DN7: length 79.7
  TOP w0.102: U1.G30 v4(202.86,107.5)
  TOP w0.14: U23.A2 v4(137.21,104.36)
  T16 w0.102: v4(202.86,107.5) 202.86,107.22 202.98,107.1 203.19,107.1 203.46,106.83 203.46,101.13 203.5,101.09 203.5,101.07
  T16 w0.107: v4(137.21,104.36) 137.57,104.72 139.69,104.72 144.46,99.95 184.3,99.95 187.18,97.07 199.9,97.07 203.5,100.68 203.5,101.07
XFI_PHY1_TO_MAC_DP0: length 84.5
  TOP w0.102: U1.J37 v4(195.86,109.5)
  TOP w0.14: U23.T1 v4(121.21,105.36)
  T16 w0.102: 121.58,105.97 121.58,105.94 121.62,105.9 121.62,105.12 121.46,104.96 121.31,104.96 121.21,105.06 v4(121.21,105.36)
  T16 w0.107: v4(195.86,109.5) 195.86,109.24 195.75,109.14 195.03,109.14 193.77,110.39 191.92,110.39 191.27,109.75 150.24,109.75 146.06,113.93 127.79,113.93 121.58,107.72 121.58,105.97
XFI_PHY1_TO_MAC_DP1: length 85.5
  TOP w0.102: U1.J35 v4(197.86,109.5)
  TOP w0.14: U23.P2 v4(123.21,104.36)
  T16 w0.102: 195.49,108.13 195.52,108.13 195.56,108.09 197.09,108.09 197.26,108.26 197.26,108.82 197.53,109.1 197.76,109.1 197.86,109.2 v4(197.86,109.5) ; 122.57,105.84 122.57,105.82 122.61,105.78 122.61,105.03 122.88,104.76 123.11,104.76 123.21,104.66 v4(123.21,104.36)
  T16 w0.107: 195.49,108.13 195.1,108.13 194.06,107.09 192.12,107.09 190.54,108.67 149.32,108.67 145.86,112.13 140.66,112.13 139.98,112.82 129.3,112.82 122.57,106.09 122.57,105.84
XFI_PHY1_TO_MAC_DP2: length 83.3
  TOP w0.102: U1.G36 v4(196.86,107.5)
  TOP w0.14: U23.M1 v4(125.21,105.36)
  T16 w0.102: v4(125.21,105.36) 125.21,105.06 125.31,104.96 125.46,104.96 125.61,105.12 125.61,105.63 125.57,105.67 125.57,105.69 ; v4(196.86,107.5) 196.86,107.2 196.76,107.1 196.53,107.1 196.25,106.82 196.25,106.2 196.15,106.1 195.52,106.1 195.48,106.14 195.45,106.14
  T16 w0.107: 195.45,106.14 194.52,106.14 192.94,104.56 189.57,104.56 186.66,107.46 170.15,107.46 168.84,106.15 148.93,106.15 144.06,111.02 139.77,111.02 139.09,111.7 130.11,111.7 125.57,107.17 125.57,105.69
XFI_PHY1_TO_MAC_DP3: length 82.4
  TOP w0.102: U1.G34 v4(198.86,107.5)
  TOP w0.14: U23.K1 v4(127.21,105.36)
  T16 w0.102: 195.46,105.14 195.49,105.14 195.53,105.1 197.06,105.1 197.26,105.3 197.26,106.86 197.5,107.1 198.76,107.1 198.86,107.2 v4(198.86,107.5)
  T16 w0.107: v4(127.21,105.36) 127.58,105.72 127.58,106.46 131.72,110.6 137.94,110.6 138.71,109.83 142.85,109.83 147.77,104.91 171.22,104.91 172.3,105.99 186.43,105.99 189.03,103.39 193.45,103.39 195.2,105.14 195.46,105.14
XFI_PHY1_TO_MAC_DP4: length 83.1
  TOP w0.102: U1.H33 v4(199.86,108.5)
  TOP w0.14: U23.G2 v4(131.21,104.36)
  T16 w0.102: 131.85,105.97 131.85,105.94 131.81,105.9 131.81,105.03 131.54,104.76 131.31,104.76 131.21,104.66 v4(131.21,104.36) ; v4(199.86,108.5) 199.86,108.79 199.76,108.89 199.61,108.89 199.46,108.74 199.46,103.2 199.15,102.89 195.43,102.89 195.39,102.85 195.36,102.85
  T16 w0.107: 195.36,102.85 195.08,102.85 194.08,101.86 187.6,101.86 184.9,104.56 174.32,104.56 173.24,103.48 147.21,103.48 142.32,108.37 133.19,108.37 131.85,107.03 131.85,105.97
XFI_PHY1_TO_MAC_DP5: length 82.5
  TOP w0.102: U1.F32 v4(200.86,106.5)
  TOP w0.14: U23.E1 v4(133.21,105.36)
  T16 w0.102: v4(133.21,105.36) 133.21,105.06 133.11,104.96 132.97,104.96 132.81,105.12 132.81,105.74 132.85,105.77 132.85,105.8 ; v4(200.86,106.5) 200.86,106.79 200.76,106.89 200.61,106.89 200.46,106.74 200.46,101.17 200.5,101.13 200.5,101.11
  T16 w0.107: 200.5,101.11 200.5,100.84 199.06,99.4 188.23,99.4 185.24,102.39 184.97,102.39 184.87,102.29 184.65,102.29 184.55,102.39 184.33,102.39 184.23,102.29 184.01,102.29 183.91,102.39 183.69,102.39 183.59,102.29 183.37,102.29 183.27,102.39 146.75,102.39 142.87,106.27 142.62,106.27 142.52,106.38 142.52,106.62 142.41,106.73 142.17,106.73 142.06,106.83 142.06,107.08 141.87,107.27 134.04,107.27 132.85,106.07 132.85,105.8
XFI_PHY1_TO_MAC_DP6: length 82.4
  TOP w0.102: U1.H31 v4(201.86,108.5)
  TOP w0.14: U23.C2 v4(135.21,104.36)
  T16 w0.102: v4(201.86,108.5) 201.86,108.79 201.76,108.89 201.61,108.89 201.46,108.74 201.46,101.09 201.5,101.06 201.5,101.03 ; v4(135.21,104.36) 135.21,104.66 135.31,104.76 135.59,104.76 135.82,104.98 135.82,105.7 135.86,105.74 135.86,105.77
  T16 w0.107: 135.86,105.77 135.86,105.92 136.05,106.11 139.87,106.11 144.93,101.05 184.95,101.05 187.75,98.25 199.36,98.25 201.5,100.39 201.5,101.03
XFI_PHY1_TO_MAC_DP7: length 79.7
  TOP w0.102: U1.F30 v4(202.86,106.5)
  TOP w0.14: U23.A1 v4(137.21,105.36)
  T16 w0.102: 203.22,101.07 203.22,101.09 203.26,101.13 203.26,106.74 203.11,106.89 202.96,106.89 202.86,106.79 v4(202.86,106.5)
  T16 w0.107: v4(137.21,105.36) 137.57,105 137.82,105 137.92,105.09 137.92,105.14 138.01,105.23 138.14,105.23 138.24,105.14 138.24,105.09 138.33,105 138.46,105 138.56,105.09 138.56,105.14 138.65,105.23 138.78,105.23 138.88,105.14 138.88,105.09 138.97,105 139.1,105 139.2,105.09 139.2,105.14 139.29,105.23 139.42,105.23 139.52,105.14 139.52,105.09 139.61,105 139.81,105 144.58,100.23 184.42,100.23 187.3,97.35 199.78,97.35 203.22,100.79 203.22,101.07
XFI_SFP_TO_MAC_DN8: length 88.7
  TOP w0.102: U1.J29 v4(203.86,109.5)
  T07 w0.102: 203.22,101.08 203.22,101.11 203.26,101.15 203.26,108.83 203.53,109.1 203.76,109.1 203.86,109.2 v4(203.86,109.5)
  T07 w0.107: 203.22,101.08 203.22,99.85 200.49,97.11 200.34,97.11 200.19,96.96 200.19,96.81 200.04,96.66 199.89,96.66 199.74,96.51 199.74,96.36 199.59,96.21 199.43,96.21 199.28,96.06 199.28,95.91 185.24,81.87 170.29,81.87 167.37,78.95 165.13,78.95 150.45,64.26 150.45,58.8 151.56,57.68 151.56,56.49 151.01,55.93 150.84,55.93 150.75,56.02 150.62,56.1 150.58,56.24 CJ8.ET12
XFI_SFP_TO_MAC_DN9: length 105.1
  TOP w0.102: U1.G28 v4(204.86,107.5)
  T07 w0.102: v4(204.86,107.5) 204.86,107.2 204.76,107.1 204.52,107.1 204.26,106.83 204.26,101.08 204.22,101.05 204.22,101.02
  T07 w0.107: 204.22,101.02 204.22,98.43 186.16,80.37 171.14,80.37 164.73,73.97 164.55,73.97 164.42,73.83 164.42,73.65 164.28,73.51 164.1,73.51 163.96,73.38 163.96,73.2 156.26,65.5 156.26,61.22 156.14,61.1 156.14,60.9 156.26,60.78 156.26,60.58 156.14,60.46 156.14,60.26 156.26,60.14 156.26,59.94 156.14,59.82 156.14,59.62 156.26,59.5 156.26,57.74 155.22,56.7 155.22,51.63 155.07,51.48 155.07,51.31 155.22,51.16 155.22,50.99 155.07,50.84 155.07,50.67 155.22,50.52 155.22,50.35 155.07,50.2 155.07,50.03 155.22,49.88 155.22,47.28 154.89,46.95 154.71,46.95 154.57,46.82 154.57,46.63 154.44,46.5 154.25,46.5 154.12,46.37 154.12,46.18 153.63,45.7 145.42,45.7 144.99,46.13 144.99,46.82 145.44,47.28 145.7,47.28 145.73,47.25 145.89,47.16 145.93,47.01 145.79,46.76 CJ8.EL12
XFI_SFP_TO_MAC_DN10: length 79.2
  TOP w0.102: U1.J27 v4(205.86,109.5)
  T07 w0.102: v4(205.86,109.5) 205.86,109.2 205.76,109.1 205.53,109.1 205.26,108.82 205.26,100.33 205.22,100.29 205.22,100.23
  T07 w0.107: CJ8.FT12 164.83,56.24 164.87,56.1 165,56.02 165.34,56.02 166.14,56.82 166.14,57.53 164.7,58.98 164.7,61.49 164.57,61.62 164.57,61.81 164.7,61.94 164.7,62.13 164.57,62.26 164.57,62.45 164.7,62.58 164.7,66.26 177.25,78.81 186.61,78.81 205.22,97.43 205.22,100.23
XFI_SFP_TO_MAC_DN11: length 91.6
  TOP w0.102: U1.G26 v4(206.86,107.5)
  T07 w0.102: 206.22,100.2 206.22,100.22 206.26,100.26 206.26,106.83 206.53,107.1 206.76,107.1 206.86,107.2 v4(206.86,107.5)
  T07 w0.107: CJ8.FL12 160.04,46.76 160.18,47.01 160.14,47.16 160.08,47.2 159.57,47.2 159.03,46.66 159.03,45.87 159.74,45.16 160.15,45.16 160.31,45.32 160.47,45.32 160.63,45.16 160.79,45.16 160.95,45.32 161.11,45.32 161.27,45.16 161.43,45.16 161.59,45.32 161.75,45.32 161.91,45.16 166.49,45.16 169.4,48.07 169.4,48.93 169.24,49.08 169.24,49.25 169.4,49.4 169.4,49.57 169.24,49.72 169.24,49.89 169.4,50.04 169.4,50.21 169.24,50.36 169.24,50.53 169.4,50.68 169.4,59.29 169.83,59.73 169.83,59.91 169.97,60.05 170.15,60.05 170.28,60.18 170.28,60.37 170.42,60.5 170.6,60.5 170.74,60.63 170.74,60.82 170.87,60.95 171.06,60.95 206.22,96.12 206.22,100.2
XFI_SFP_TO_MAC_DN12: length 81.5
  TOP w0.102: U1.G8 v4(225.86,107.5)
  T07 w0.102: v4(225.86,107.5) 225.86,107.2 225.76,107.1 225.53,107.1 225.26,106.83 225.26,101.14 225.22,101.1 225.22,101.08
  T07 w0.107: 225.22,101.08 225.22,100.87 224.89,100.54 224.89,98.59 223.03,96.72 222.83,96.72 222.7,96.59 222.7,96.4 222.58,96.27 222.38,96.27 222.25,96.14 222.25,95.94 219.91,93.61 211.2,93.61 197.88,80.29 195.59,80.29 178.86,63.56 178.76,63.56 178.13,62.93 178.13,62.83 177.88,62.58 177.88,60.02 180.42,57.48 180.42,56.82 179.62,56.02 179.25,56.02 179.12,56.1 179.08,56.24 CJ8.GT12
XFI_SFP_TO_MAC_DN13: length 102.2
  TOP w0.102: U1.J7 v4(226.86,109.5)
  T07 w0.102: v4(226.86,109.5) 226.86,109.2 226.76,109.1 226.53,109.1 226.25,108.82 226.25,101.24 226.22,101.2 226.22,101.18
  T07 w0.107: 226.22,101.18 226.22,100.91 226.12,100.81 226.12,99.83 225.98,99.7 225.98,99.51 226.12,99.38 226.12,99.19 225.98,99.06 225.98,98.87 226.12,98.74 226.12,97.54 220.39,91.81 212.41,91.81 212.25,91.97 212.09,91.97 211.93,91.81 211.77,91.81 211.61,91.97 211.45,91.97 211.29,91.81 211.05,91.81 197.72,78.49 195.58,78.49 184.3,67.21 184.3,59.01 184.18,58.88 184.18,58.69 184.3,58.56 184.3,58.37 184.18,58.24 184.18,58.05 184.3,57.92 184.3,57.73 184.18,57.6 184.18,57.41 184.3,57.28 184.3,56.19 183.64,55.53 183.64,47.89 183.38,47.63 183.19,47.63 183.06,47.49 183.06,47.31 182.92,47.17 182.74,47.17 182.61,47.04 182.61,46.86 182.47,46.72 182.29,46.72 182.15,46.59 182.15,46.4 181.29,45.54 173.98,45.54 173.43,46.09 173.43,46.77 173.94,47.28 174.2,47.28 174.23,47.25 174.39,47.16 174.43,47.01 174.29,46.76 CJ8.GL12
XFI_SFP_TO_MAC_DN14: length 72.8
  TOP w0.102: U1.G6 v4(227.86,107.5)
  T07 w0.102: v4(227.86,107.5) 227.86,107.2 227.76,107.1 227.53,107.1 227.26,106.82 227.26,101.16 227.22,101.12 227.22,101.1
  T07 w0.107: CJ8.HT12 193.33,56.24 193.37,56.1 193.5,56.02 193.82,56.02 194.3,56.51 194.3,57.65 193.4,58.55 193.4,61.06 194.22,61.89 194.22,62.06 194.36,62.2 194.53,62.2 194.68,62.34 194.68,62.51 194.82,62.65 194.99,62.65 195.13,62.79 195.13,62.96 195.27,63.11 195.44,63.11 195.83,63.5 198.74,63.5 203.14,67.9 203.14,76.98 216.38,90.22 220.62,90.22 227.22,96.83 227.22,101.1
XFI_SFP_TO_MAC_DN15: length 93.5
  TOP w0.102: U1.J5 v4(228.86,109.5)
  T07 w0.102: v4(228.86,109.5) 228.86,109.2 228.76,109.1 228.53,109.1 228.25,108.82 228.25,101.29 228.22,101.25 228.22,101.22
  T07 w0.107: CJ8.HL12 188.54,46.76 188.68,47.01 188.64,47.16 188.48,47.25 188.45,47.28 188.26,47.28 187.66,46.67 187.66,45.91 188.35,45.21 188.8,45.21 188.95,45.36 189.12,45.36 189.27,45.21 189.44,45.21 189.59,45.36 189.76,45.36 189.91,45.21 190.08,45.21 190.23,45.36 190.4,45.36 190.55,45.21 195.95,45.21 198.3,47.57 198.3,48.17 198.15,48.32 198.15,48.49 198.3,48.64 198.3,48.81 198.15,48.96 198.15,49.13 198.3,49.28 198.3,49.45 198.15,49.6 198.15,49.77 198.3,49.92 198.3,59.12 198.9,59.71 198.9,59.85 198.89,59.86 198.89,59.99 198.98,60.08 199.11,60.08 199.12,60.07 199.25,60.07 199.35,60.17 199.35,60.3 199.34,60.31 199.34,60.44 199.43,60.53 199.56,60.53 199.57,60.52 199.71,60.52 212.31,73.13 212.31,83.63 217.6,88.92 220.89,88.92 228.73,96.76 228.73,100.43 228.22,100.94 228.22,101.22
XFI_SFP_TO_MAC_DN16: length 62.7
  TOP w0.102: U1.G4 v4(229.86,107.5)
  T07 w0.102: v4(229.86,107.5) 229.86,107.2 229.96,107.1 230.19,107.1 230.46,106.82 230.46,101.12 230.5,101.08 230.5,101.06
  T07 w0.107: CJ9.AT12 211.33,56.68 211.37,56.82 211.53,56.91 214.25,59.63 214.25,67.06 213.89,67.41 213.89,82.86 218.43,87.4 221.71,87.4 230.5,96.2 230.5,101.06
XFI_SFP_TO_MAC_DN17: length 77.3
  TOP w0.102: U1.J3 v4(230.86,109.5)
  T07 w0.102: 231.22,101.06 231.22,101.09 231.25,101.13 231.25,107.73 231.08,107.9 230.53,107.9 230.26,108.17 230.26,108.88 230.48,109.1 230.76,109.1 230.86,109.2 v4(230.86,109.5)
  T07 w0.107: CJ9.AB12 206.28,48.1 206.43,48.06 206.56,48.14 206.76,48.34 206.76,49.02 207.38,49.64 212.49,49.64 213.49,50.64 213.49,57.25 215.82,59.58 215.82,78.53 231.22,93.93 231.22,101.06
XFI_SFP_TO_MAC_DN18: length 57.7
  TOP w0.102: U1.G2 v4(231.86,107.5)
  T07 w0.102: 232.5,101.16 232.5,101.19 232.46,101.23 232.46,106.88 232.24,107.1 231.96,107.1 231.86,107.2 v4(231.86,107.5)
  T07 w0.107: 232.5,101.16 232.5,92.97 225.17,85.65 225.17,68.51 227.98,65.7 227.98,59.12 225.78,56.91 225.68,56.86 225.62,56.82 225.58,56.68 CJ9.BT12
XFI_SFP_TO_MAC_DN19: length 74.2
  TOP w0.102: U1.J1 v4(232.86,109.5)
  T07 w0.102: v4(232.86,109.5) 232.86,109.2 232.76,109.1 232.47,109.1 232.25,108.88 232.25,108.2 232.55,107.9 233.19,107.9 233.43,107.66 233.43,107.15 233.39,107.11 233.39,107.09
  T07 w0.107: 233.39,107.09 233.39,92.22 230.92,89.75 230.79,89.76 230.71,89.76 230.59,89.64 230.59,89.51 230.59,89.42 230.47,89.3 230.34,89.3 230.25,89.3 230.14,89.19 230.14,89.05 230.14,88.97 230.02,88.85 229.89,88.85 229.8,88.85 229.68,88.73 229.68,88.6 229.68,88.51 227.81,86.64 227.81,68.77 229.39,67.19 229.39,58.7 227.97,57.27 227.97,50.69 226.92,49.64 221.6,49.64 220.85,48.9 220.85,48.18 220.81,48.14 220.68,48.06 220.53,48.1 CJ9.BB12
XFI_SFP_TO_MAC_DN20: length 76.7
  TOP w0.102: U1.G24 v4(208.86,107.5)
  T18 w0.102: 208.22,101.08 208.22,101.11 208.26,101.15 208.26,106.83 208.53,107.1 208.76,107.1 208.86,107.2 v4(208.86,107.5)
  T18 w0.107: 208.22,101.08 208.22,100.91 205.26,97.95 205.26,87.34 213.21,79.39 213.21,70.64 222.78,61.06 227.97,61.06 233.88,55.15 238.07,55.15 239.58,56.66 239.68,56.72 239.83,56.68 CJ9.CT12
XFI_SFP_TO_MAC_DN21: length 92.8
  TOP w0.14: U1.K23 v4(209.86,110.5)
  T18 w0.102: 209.22,100.99 209.22,101.02 209.26,101.05 209.26,109.83 209.53,110.1 209.76,110.1 209.86,110.2 v4(209.86,110.5)
  T18 w0.107: CJ9.CB12 234.78,48.1 234.93,48.06 235.06,48.14 236.54,49.62 240.66,49.62 241.67,50.64 241.67,60.39 236.28,65.79 223.27,65.79 216.21,72.84 216.21,78.31 206.53,87.98 206.53,97.85 209.22,100.54 209.22,100.99
XFI_SFP_TO_MAC_DN22: length 82
  TOP w0.102: U1.G22 v4(210.86,107.5)
  T18 w0.102: 211.5,100.96 211.5,100.98 211.46,101.02 211.46,106.82 211.19,107.1 210.96,107.1 210.86,107.2 v4(210.86,107.5)
  T18 w0.107: CJ9.DT12 254.08,56.68 254.12,56.82 254.28,56.91 254.53,57.17 254.53,58.66 251.77,61.42 245.13,61.42 236.8,69.75 230.89,69.75 227.99,72.65 227.99,77.04 224.13,80.9 218.49,80.9 210.46,88.93 210.46,98.32 211.5,99.36 211.5,100.96
XFI_SFP_TO_MAC_DN23: length 92.3
  TOP w0.14: U1.K21 v4(211.86,110.5)
  T18 w0.102: 210.22,100.99 210.22,101.02 210.26,101.05 210.26,109.86 210.5,110.1 211.76,110.1 211.86,110.2 v4(211.86,110.5)
  T18 w0.107: CJ9.DB12 249.03,48.1 249.18,48.06 249.31,48.14 249.56,48.39 249.56,49.02 249.17,49.4 247.82,49.4 247.02,50.2 247.02,57 236.46,67.56 228.2,67.56 224.79,70.98 224.79,77.24 223.08,78.95 217.86,78.95 207.92,88.89 207.92,97.84 210.22,100.15 210.22,100.99
XFI_SFP_TO_MAC_DN24: length 90.6
  TOP w0.102: U1.G20 v4(212.86,107.5)
  T18 w0.107: v4(212.86,107.5) 212.86,107.24 212.97,107.14 213.32,107.14 213.59,106.86 213.59,99.7 214.21,99.08 214.21,93.56 219.07,88.69 229.73,88.69 240.06,78.37 240.06,72.16 243.63,68.59 258.39,68.59 268.88,58.09 268.88,57.27 268.53,56.91 268.37,56.82 268.33,56.68 CJ9.ET12
XFI_SFP_TO_MAC_DN25: length 102.5
  TOP w0.102: U1.K19 v4(214.86,110.5)
  T18 w0.102: 212.22,101.04 212.22,101.06 212.25,101.1 212.25,109.82 212.53,110.1 214.76,110.1 214.86,110.2 v4(214.86,110.5)
  T18 w0.107: 212.22,101.04 212.22,98.82 211.93,98.53 211.93,89.37 217.41,83.88 231.87,83.88 236.98,78.78 236.98,72.01 242.61,66.38 251.75,66.38 261.15,56.98 261.15,50.14 261.92,49.38 263.18,49.38 263.65,48.9 263.65,48.23 263.56,48.14 263.43,48.06 263.28,48.1 CJ9.EB12
XFI_SFP_TO_MAC_DN26: length 97.6
  TOP w0.102: U1.G18 v4(215.86,107.5)
  T18 w0.102: v4(215.86,107.5) 215.86,107.2 215.96,107.1 216.23,107.1 216.46,106.86 216.46,101.03 216.5,100.99 216.5,100.97
  T18 w0.107: CJ9.FT12 282.58,56.68 282.62,56.82 282.78,56.91 282.98,57.12 282.98,58.52 270.38,71.12 268.65,71.12 260.11,79.65 242.42,79.65 230.61,91.47 220.31,91.47 216.5,95.28 216.5,100.97
XFI_SFP_TO_MAC_DN27: length 106.4
  TOP w0.102: U1.K17 v4(216.86,110.5)
  T18 w0.102: 215.22,101 215.22,101.03 215.26,101.07 215.26,109.78 215.58,110.1 216.76,110.1 216.86,110.2 v4(216.86,110.5)
  T18 w0.107: 215.22,101 215.22,94.34 219.87,89.7 230.2,89.7 241.4,78.5 241.4,76.86 247.83,70.43 262.05,70.43 275.46,57.02 275.46,50.21 276.27,49.4 277.37,49.4 278,48.77 278,48.33 277.81,48.14 277.68,48.06 277.53,48.1 CJ9.FB12
XFI_SFP_TO_MAC_DP8: length 88.7
  TOP w0.102: U1.H29 v4(203.86,108.5)
  T07 w0.102: 203.5,101.08 203.5,101.11 203.47,101.15 203.47,108.74 203.61,108.89 203.76,108.89 203.86,108.79 v4(203.86,108.5)
  T07 w0.107: CJ8.ET13 150.33,55.82 150.48,55.86 150.57,55.8 150.72,55.65 151.12,55.65 151.84,56.37 151.84,57.8 150.73,58.92 150.73,64.14 165.25,78.67 167.49,78.67 170.41,81.59 185.36,81.59 203.5,99.73 203.5,101.08
XFI_SFP_TO_MAC_DP9: length 105.2
  TOP w0.102: U1.F28 v4(204.86,106.5)
  T07 w0.102: 204.5,101.02 204.5,101.05 204.46,101.08 204.46,106.75 204.61,106.89 204.76,106.89 204.86,106.79 v4(204.86,106.5)
  T07 w0.107: CJ8.EL13 146.18,47.44 146.03,47.4 145.9,47.47 145.82,47.56 145.32,47.56 144.71,46.94 144.71,46.01 145.3,45.42 153.75,45.42 155.5,47.17 155.5,56.58 156.54,57.62 156.54,65.38 171.25,80.09 186.28,80.09 204.5,98.32 204.5,101.02
XFI_SFP_TO_MAC_DP10: length 79.3
  TOP w0.102: U1.H27 v4(205.86,108.5)
  T07 w0.102: 205.5,100.23 205.5,100.26 205.46,100.3 205.46,108.74 205.61,108.89 205.76,108.89 205.86,108.79 v4(205.86,108.5)
  T07 w0.107: 205.5,100.23 205.5,97.31 186.72,78.54 177.37,78.54 164.98,66.14 164.98,59.1 166.42,57.65 166.42,56.7 165.46,55.74 164.88,55.74 164.82,55.8 164.73,55.86 164.58,55.82 CJ8.FT13
XFI_SFP_TO_MAC_DP11: length 91.7
  TOP w0.102: U1.F26 v4(206.86,106.5)
  T07 w0.102: v4(206.86,106.5) 206.86,106.79 206.76,106.89 206.61,106.89 206.46,106.74 206.46,100.26 206.5,100.22 206.5,100.2
  T07 w0.107: 206.5,100.2 206.5,96 169.67,59.18 169.67,47.96 166.6,44.88 159.63,44.88 158.75,45.76 158.75,46.77 159.45,47.47 160.15,47.47 160.28,47.4 160.43,47.44 CJ8.FL13
XFI_SFP_TO_MAC_DP12: length 81.6
  TOP w0.102: U1.F8 v4(225.86,106.5)
  T07 w0.102: 225.5,101.08 225.5,101.1 225.46,101.14 225.46,106.74 225.61,106.89 225.76,106.89 225.86,106.79 v4(225.86,106.5)
  T07 w0.107: 225.5,101.08 225.5,100.76 225.17,100.42 225.17,98.47 220.03,93.33 211.31,93.33 197.99,80.01 195.71,80.01 178.97,63.28 178.87,63.28 178.41,62.81 178.41,62.71 178.16,62.46 178.16,60.14 180.7,57.6 180.7,56.7 179.74,55.74 179.13,55.74 179.07,55.8 178.98,55.86 178.83,55.82 CJ8.GT13
XFI_SFP_TO_MAC_DP13: length 102.3
  TOP w0.102: U1.H7 v4(226.86,108.5)
  T07 w0.102: 226.5,101.18 226.5,101.2 226.46,101.24 226.46,108.74 226.61,108.89 226.76,108.89 226.86,108.79 v4(226.86,108.5)
  T07 w0.107: 226.5,101.18 226.5,100.79 226.4,100.69 226.4,97.42 220.5,91.53 211.16,91.53 197.84,78.21 195.7,78.21 184.58,67.1 184.58,56.07 183.92,55.41 183.92,47.78 181.41,45.26 173.86,45.26 173.15,45.97 173.15,46.89 173.82,47.56 174.32,47.56 174.4,47.47 174.53,47.4 174.68,47.44 CJ8.GL13
XFI_SFP_TO_MAC_DP14: length 72.8
  TOP w0.102: U1.F6 v4(227.86,106.5)
  T07 w0.102: 227.5,101.1 227.5,101.12 227.46,101.16 227.46,106.74 227.61,106.89 227.76,106.89 227.86,106.79 v4(227.86,106.5)
  T07 w0.107: CJ8.HT13 193.08,55.82 193.23,55.86 193.32,55.8 193.38,55.74 193.93,55.74 194.58,56.39 194.58,57.76 193.68,58.66 193.68,60.95 195.95,63.22 198.86,63.22 203.42,67.78 203.42,76.86 216.5,89.94 220.73,89.94 227.5,96.71 227.5,101.1
XFI_SFP_TO_MAC_DP15: length 93.6
  TOP w0.102: U1.H5 v4(228.86,108.5)
  T07 w0.102: v4(228.86,108.5) 228.86,108.79 228.76,108.89 228.61,108.89 228.46,108.74 228.46,101.29 228.49,101.25 228.49,101.22
  T07 w0.107: 228.49,101.22 228.49,101.05 229.01,100.54 229.01,96.64 221,88.64 217.71,88.64 212.59,83.52 212.59,73.02 198.58,59 198.58,47.45 196.06,44.93 188.24,44.93 187.38,45.79 187.38,46.79 188.15,47.56 188.57,47.56 188.65,47.47 188.78,47.4 188.93,47.44 CJ8.HL13
XFI_SFP_TO_MAC_DP16: length 62.6
  TOP w0.102: U1.F4 v4(229.86,106.5)
  T07 w0.102: v4(229.86,106.5) 229.86,106.79 229.96,106.89 230.1,106.89 230.26,106.74 230.26,101.12 230.22,101.08 230.22,101.06
  T07 w0.107: CJ9.AT13 211.08,57.1 211.23,57.06 211.36,57.14 213.97,59.75 213.97,60.1 213.81,60.27 213.81,60.42 213.97,60.59 213.97,60.74 213.81,60.91 213.81,61.06 213.97,61.23 213.97,66.94 213.61,67.3 213.61,82.98 218.32,87.68 221.59,87.68 227.07,93.16 227.07,93.31 227.22,93.46 227.37,93.46 227.52,93.61 227.52,93.76 227.67,93.91 227.82,93.91 227.97,94.06 227.97,94.21 228.12,94.36 228.27,94.36 230.22,96.31 230.22,101.06
XFI_SFP_TO_MAC_DP17: length 77.3
  TOP w0.102: U1.H3 v4(230.86,108.5)
  T07 w0.102: 231.49,101.06 231.49,101.09 231.46,101.13 231.46,107.81 231.17,108.1 230.62,108.1 230.46,108.26 230.46,108.79 230.56,108.89 230.76,108.89 230.86,108.79 v4(230.86,108.5)
  T07 w0.107: 231.49,101.06 231.49,93.81 216.1,78.42 216.1,59.46 213.77,57.13 213.77,50.53 212.61,49.36 207.49,49.36 207.04,48.91 207.04,48.22 206.73,47.91 206.57,47.82 206.53,47.68 CJ9.AB13
XFI_SFP_TO_MAC_DP18: length 57.7
  TOP w0.102: U1.F2 v4(231.86,106.5)
  T07 w0.102: 232.22,101.16 232.22,101.19 232.26,101.23 232.26,106.79 232.16,106.89 231.96,106.89 231.86,106.79 v4(231.86,106.5)
  T07 w0.107: CJ9.BT13 225.33,57.1 225.47,57.06 225.48,57.06 225.61,57.14 227.7,59.23 227.7,65.58 227.38,65.91 227.18,65.91 227.05,66.04 227.05,66.23 226.92,66.36 226.72,66.36 226.6,66.49 226.6,66.69 224.89,68.39 224.89,82.2 224.74,82.35 224.74,82.52 224.89,82.67 224.89,82.84 224.74,82.99 224.74,83.16 224.89,83.31 224.89,83.48 224.74,83.63 224.74,83.8 224.89,83.95 224.89,85.76 232.22,93.09 232.22,101.16
XFI_SFP_TO_MAC_DP19: length 74.1
  TOP w0.102: U1.H1 v4(232.86,108.5)
  T07 w0.102: v4(232.86,108.5) 232.86,108.79 232.76,108.89 232.56,108.89 232.46,108.79 232.46,108.28 232.64,108.1 233.27,108.1 233.63,107.75 233.63,107.15 233.67,107.11 233.67,107.09
  T07 w0.107: 233.67,107.09 233.67,92.1 228.09,86.53 228.09,68.88 229.67,67.3 229.67,60.37 229.86,60.19 229.86,60.05 229.67,59.87 229.67,59.73 229.86,59.55 229.86,59.41 229.67,59.23 229.67,58.58 228.24,57.15 228.24,50.58 227.03,49.36 221.72,49.36 221.13,48.78 221.13,48.07 220.98,47.91 220.82,47.82 220.78,47.68 CJ9.BB13
XFI_SFP_TO_MAC_DP20: length 76.6
  TOP w0.102: U1.F24 v4(208.86,106.5)
  T18 w0.102: v4(208.86,106.5) 208.86,106.79 208.76,106.89 208.61,106.89 208.46,106.74 208.46,101.15 208.5,101.11 208.5,101.08
  T18 w0.107: 208.5,101.08 208.5,100.79 205.54,97.83 205.54,87.45 213.49,79.51 213.49,70.75 213.71,70.53 213.94,70.53 214.05,70.42 214.05,70.19 214.16,70.08 214.39,70.08 214.5,69.97 214.5,69.74 214.61,69.63 214.84,69.63 214.95,69.51 214.95,69.29 222.9,61.34 228.08,61.34 228.18,61.24 228.45,61.24 228.54,61.14 228.54,60.88 228.64,60.79 228.9,60.79 228.99,60.69 228.99,60.43 229.09,60.33 229.35,60.33 229.45,60.24 229.45,59.98 233.99,55.43 237.96,55.43 239.41,56.88 239.54,56.96 239.58,57.1 CJ9.CT13
XFI_SFP_TO_MAC_DP21: length 92.7
  TOP w0.102: U1.J23 v4(209.86,109.5)
  T18 w0.102: 209.5,100.99 209.5,101.02 209.46,101.05 209.46,109.74 209.61,109.89 209.76,109.89 209.86,109.79 v4(209.86,109.5)
  T18 w0.107: CJ9.CB13 235.03,47.68 235.07,47.82 235.23,47.91 236.65,49.34 240.77,49.34 241.95,50.52 241.95,60.51 236.4,66.07 223.38,66.07 216.49,72.95 216.49,78.42 206.81,88.1 206.81,97.73 209.5,100.42 209.5,100.99
XFI_SFP_TO_MAC_DP22: length 81.9
  TOP w0.102: U1.F22 v4(210.86,106.5)
  T18 w0.102: v4(210.86,106.5) 210.86,106.79 210.96,106.89 211.11,106.89 211.26,106.74 211.26,101.02 211.22,100.98 211.22,100.96
  T18 w0.107: 211.22,100.96 211.22,99.48 210.18,98.43 210.18,88.82 218.38,80.62 224.01,80.62 227.71,76.92 227.71,72.54 230.78,69.47 236.69,69.47 245.01,61.15 245.38,61.15 245.48,61.05 245.48,61.04 245.57,60.95 245.7,60.95 245.8,61.04 245.8,61.05 245.89,61.15 246.02,61.15 246.12,61.05 246.12,61.04 246.21,60.95 246.34,60.95 246.44,61.04 246.44,61.05 246.53,61.15 246.66,61.15 246.76,61.05 246.76,61.04 246.85,60.95 246.98,60.95 247.08,61.04 247.08,61.05 247.17,61.15 251.66,61.15 254.25,58.55 254.25,57.29 254.11,57.14 253.98,57.06 253.83,57.1 CJ9.DT13
XFI_SFP_TO_MAC_DP23: length 92.3
  TOP w0.14: U1.J21 v4(211.86,109.5)
  T18 w0.102: v4(211.86,109.5) 211.86,109.79 211.76,109.89 210.58,109.89 210.47,109.78 210.47,101.05 210.5,101.02 210.5,100.99
  T18 w0.107: 210.5,100.99 210.5,100.03 208.2,97.73 208.2,89.01 217.98,79.23 223.2,79.23 225.07,77.36 225.07,71.09 228.32,67.84 236.58,67.84 247.3,57.12 247.3,50.32 247.94,49.68 249.29,49.68 249.83,49.14 249.83,48.27 249.48,47.91 249.32,47.82 249.28,47.68 CJ9.DB13
XFI_SFP_TO_MAC_DP24: length 90.6
  TOP w0.102: U1.F20 v4(212.86,106.5)
  T18 w0.107: v4(212.86,106.5) 212.86,106.75 212.97,106.86 213.2,106.86 213.31,106.75 213.31,99.58 213.93,98.96 213.93,93.44 218.95,88.41 229.61,88.41 238.45,79.58 238.45,79.4 238.59,79.26 238.77,79.26 238.9,79.12 238.9,78.95 239.04,78.81 239.22,78.81 239.78,78.25 239.78,72.05 243.51,68.31 258.27,68.31 259.47,67.11 259.47,66.98 259.47,66.98 259.47,66.84 259.56,66.75 259.69,66.75 259.7,66.75 259.83,66.75 259.92,66.66 259.92,66.53 259.92,66.52 259.92,66.39 260.01,66.3 260.15,66.3 260.15,66.3 260.28,66.3 260.38,66.21 260.38,66.07 260.37,66.07 260.37,65.94 260.47,65.84 260.6,65.84 260.6,65.85 260.73,65.85 268.61,57.98 268.61,57.39 268.36,57.14 268.23,57.06 268.08,57.1 CJ9.ET13
XFI_SFP_TO_MAC_DP25: length 102.4
  TOP w0.102: U1.J19 v4(214.86,109.5)
  T18 w0.102: v4(214.86,109.5) 214.86,109.79 214.76,109.89 212.61,109.89 212.46,109.74 212.46,101.1 212.5,101.06 212.5,101.04
  T18 w0.107: CJ9.EB13 263.53,47.68 263.57,47.82 263.73,47.91 263.93,48.12 263.93,49.02 263.29,49.66 262.03,49.66 261.43,50.26 261.43,57.1 251.87,66.66 242.72,66.66 237.26,72.12 237.26,78.89 231.99,84.16 217.53,84.16 212.21,89.48 212.21,98.41 212.5,98.7 212.5,101.04
XFI_SFP_TO_MAC_DP26: length 97.6
  TOP w0.102: U1.F18 v4(215.86,106.5)
  T18 w0.102: 216.22,100.97 216.22,100.99 216.26,101.03 216.26,106.78 216.14,106.89 215.96,106.89 215.86,106.79 v4(215.86,106.5)
  T18 w0.107: 216.22,100.97 216.22,95.16 220.2,91.19 230.49,91.19 242.3,79.38 242.72,79.38 242.85,79.25 243.04,79.25 243.17,79.38 260,79.38 268.53,70.84 270.27,70.84 270.52,70.58 270.52,70.45 270.52,70.45 270.52,70.31 270.61,70.22 270.75,70.22 270.75,70.23 270.88,70.23 270.98,70.13 270.98,70 270.97,69.99 270.97,69.86 271.07,69.77 271.2,69.77 271.2,69.77 271.34,69.77 271.43,69.68 271.43,69.55 271.42,69.54 271.42,69.41 271.52,69.32 271.65,69.32 271.66,69.32 271.79,69.32 282.7,58.41 282.7,57.23 282.61,57.14 282.48,57.06 282.33,57.1 CJ9.FT13
XFI_SFP_TO_MAC_DP27: length 106.5
  TOP w0.102: U1.J17 v4(216.86,109.5)
  T18 w0.102: 215.5,101 215.5,101.03 215.46,101.07 215.46,109.7 215.66,109.89 216.76,109.89 216.86,109.79 v4(216.86,109.5)
  T18 w0.107: CJ9.FB13 277.78,47.68 277.82,47.82 277.98,47.91 278.28,48.22 278.28,48.88 277.48,49.68 276.38,49.68 275.74,50.32 275.74,51.81 275.91,51.98 275.91,52.13 275.74,52.3 275.74,57.14 262.17,70.71 247.94,70.71 241.68,76.98 241.68,78.61 230.32,89.98 219.98,89.98 215.5,94.46 215.5,101
XTAL_SHIELD: length 3.6
  TOP w0.305: U135.7 151.52,129.86 v1(151.23,129.57) ; U135.4 151.42,131.36 v5(151.33,131.27)
  vias: v5(146.76,132.67) v5(146.76,131.78) v5(146.76,130.89) v5(146.76,130) v5(146.76,129.11) v5(146.76,128.22) v5(147.52,133.05) v5(147.52,127.71) v5(148.41,133.05) v5(148.41,127.71) v5(149.3,127.71) v5(149.42,133.05) v5(150.18,127.71) v5(150.31,132.92)
N58331367: length 1.3
  TOP w0.508: PC162.1 PR186.2
N61790231: length 31.1
  TOP w0.14: v1(174.98,122.6) R70.1 R1446.1 ; U1.AA34 v4(198.86,122.5)
  T03 w0.117: v1(174.98,122.6) 179.79,117.79 183.18,117.79 183.51,118.13 187.7,118.13 187.98,118.4 191.21,118.4 192.32,119.52 193.61,119.52 195.02,120.93 197.07,120.93 197.38,121.24 197.38,121.72 197.61,121.95 198.32,121.95 v4(198.86,122.5)
N62588129: length 10
  BOTTOM w0.14: R902.1 289.62,29.97 v2(288.56,29.97) 286.34,29.97 285.39,29.01 283.24,29.01 281.97,27.74 U65.16
N62588131: length 8.8
  BOTTOM w0.14: R903.1 286.42,29.03 285.61,28.21 v2(285.37,28.21) 283.34,28.21 282.62,27.5 U65.15
N62588133: length 5.7
  BOTTOM w0.14: R904.1 287.48,28.4 v2(286.54,27.46) 283.41,27.46 283.27,27.32 U65.14
N62588135: length 4.1
  BOTTOM w0.14: R905.1 286.67,26.42 v2(285.37,26.42) U65.13
N62588137: length 11.4
  BOTTOM w0.14: R901.1 288.34,31.17 287.78,30.61 285.91,30.61 v2(285.23,29.93) 284.79,29.48 282.83,29.48 281.32,27.98 U65.17
N62588141: length 4.8
  BOTTOM w0.14: R900.1 283.34,24.55 v2(283.08,24.81) 282.86,25.03 281.23,25.03 280.67,25.59 U65.18
N62588143: length 12.5
  BOTTOM w0.14: v2(275.26,31.3) 275.95,30.61 278.89,30.61 280.02,29.48 U65.19 280.02,25.41 280.87,24.56 281.43,24.56 R899.1
N62588145: length 6.8
  BOTTOM w0.14: R898.1 v2(275.58,29.31) 277.77,29.31 279.37,27.72 U65.20
N64116787: length 1.4
  TOP w0.508: PC21.1 PR57.2
N64116818: length 3.9
  BOTTOM w0.381: v2(73.79,205.72) PR60.2 75.6,203.94 PC29.1
N64130082: length 4
  BOTTOM w0.381: v2(240.54,210.06) PR219.2 242.25,207.89 PC202.1
N64130635: length 1.3
  TOP w0.508: PR217.2 PC193.1
N64131592: length 1.3
  TOP w0.381: PR241.2 PC225.1
N64156557: length 5.2
  TOP w0.14: U196.4 v1(54.23,193.29) R1159.1 53.24,194.94 Q23.5
  BOTTOM w0.14: R1279.1 v1(54.23,193.29)
N65289036: length 4.4
  BOTTOM w0.381: v2(185.67,209.42) 186.31,210.06 PR200.2 187.58,209.99 PC182.1
N65289586: length 1.8
  TOP w0.254: PR197.2 PC173.1
N65298280: length 8.9
  TOP w0.381: U23.C10 v4(135.21,95.36) ; U23.L7 v4(126.21,99.36) ; U23.L10 v4(126.21,95.36) ; U23.D7 v4(134.21,99.36) ; U23.J10 v4(128.21,96.36) ; U23.E10 v4(133.21,95.36)
  BOTTOM w0.305: v4(126.21,95.36) 126.21,95.12 125.6,94.51 125.6,93.89 C889.1
  BOTTOM w0.381: C893.2 125.79,99.78 v4(126.21,99.36) ; v4(135.21,95.36) 135.63,94.94 C890.2 ; v4(134.21,99.36) 133.71,99.86 C892.2 ; v4(133.21,95.36) 133.63,95.78 C891.1
  vias: v1(128.59,88.57) v1(128.59,87.81) v1(129.41,88.57) v1(129.41,87.81) v1(130.18,88.57) v1(130.18,87.81) v2(124.52,86.27) v2(124.52,85) v2(125.79,86.27) v2(125.79,85) v2(127.06,86.27) v2(127.06,85)
N65308915: length 10.7
  TOP w0.14: U23.T8 v4(122.21,98.36) 122.22,98.36 129.21,98.36 U23.H7
  BOTTOM w0.14: R12798.1 123.16,98.78 122.64,99.3 C2390.2 122.26,98.41 v4(122.21,98.36)
N65578454: length 6.9
  TOP w0.14: v1(55.49,126.61) 55.88,126.22 55.88,123.19 56.53,122.54 U154.Y1
  BOTTOM w0.14: TP70.1 55.37,126.49 v1(55.49,126.61)
