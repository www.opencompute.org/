# Allegro board T99O089T00_025_20180609.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 266.24,153.55 266.24,152.41 266.04,152.2 259.02,152.2 258.83,152.4 258.83,153.54 258.96,153.68 259.03,153.66 259.03,153.65 259.94,153.65 259.94,153.78 266.01,153.78
GND on TOP (solid shape): 266.29,150.6 266.29,145.19 266.15,145.05 264.89,145.05 264.79,145.14 264.79,149.66 264.54,149.92 264.54,149.94 263.95,150.53 263.95,150.8 264.04,150.89 266,150.89
GND on TOP (solid shape): 67.16,199.54 67.16,197.92 66.91,197.67 64.44,197.67 64.28,197.83 64.28,199.45 64.31,199.45 64.31,199.64 64.62,199.95 66.75,199.95
GND on TOP (solid shape): 80.73,204.72 80.73,202.67 80.72,202.67 80.72,201.76 80.73,201.76 80.73,194.4 78.99,192.66 75.95,192.66 75.69,192.91 75.69,202.54 75.73,202.58 77.9,202.58 80.12,204.8 80.66,204.8
GND on TOP (solid shape): 108.56,65.55 108.56,65.05 108.1,64.59 108.1,63.15 107.98,63.03 107.8,63.03 107.8,63.03 104.04,63.03 103.94,63.13 103.94,64.67 103.6,65.01 103.6,65.56 103.66,65.62 108.49,65.62
GND on TOP (solid shape): 120.64,65.55 120.64,65.05 120.18,64.59 120.18,63.15 120.06,63.03 119.88,63.03 116.12,63.03 116.02,63.13 116.02,64.67 115.68,65.01 115.68,65.56 115.73,65.62 120.57,65.62
GND on TOP (solid shape): 132.72,65.55 132.72,65.05 132.25,64.59 132.25,63.15 132.13,63.03 131.95,63.03 131.95,63.03 128.19,63.03 128.09,63.13 128.09,64.67 127.75,65.01 127.75,65.56 127.81,65.62 132.65,65.62
GND on TOP (solid shape): 148.66,65.55 148.66,65.05 148.2,64.59 148.2,63.15 148.08,63.03 147.9,63.03 147.9,63.03 144.14,63.03 144.04,63.13 144.04,64.67 143.7,65.01 143.7,65.56 143.75,65.62 148.59,65.62
GND on TOP (solid shape): 160.74,65.55 160.74,65.05 160.27,64.59 160.27,63.15 160.15,63.03 159.97,63.03 156.21,63.03 156.12,63.13 156.12,64.67 155.77,65.01 155.77,65.56 155.83,65.62 160.67,65.62
GND on TOP (solid shape): 172.82,65.55 172.82,65.05 172.35,64.59 172.35,63.15 172.23,63.03 172.05,63.03 172.05,63.03 168.29,63.03 168.19,63.13 168.19,64.67 167.85,65.01 167.85,65.56 167.91,65.62 172.74,65.62
GND on TOP (solid shape): 184.89,65.55 184.89,65.05 184.43,64.59 184.43,63.15 184.31,63.03 184.13,63.03 180.37,63.03 180.27,63.13 180.27,64.67 179.93,65.01 179.93,65.56 179.98,65.62 184.82,65.62
GND on TOP (solid shape): 212.77,65.8 212.77,65.31 212.3,64.84 212.3,63.41 212.18,63.29 212,63.29 208.24,63.29 208.14,63.38 208.14,64.93 207.8,65.27 207.8,65.82 207.86,65.87 212.69,65.87
GND on TOP (solid shape): 224.84,65.8 224.84,65.31 224.38,64.84 224.38,63.41 224.26,63.29 224.08,63.29 224.08,63.29 220.32,63.29 220.22,63.38 220.22,64.93 219.88,65.27 219.88,65.82 219.94,65.87 224.77,65.87
GND on TOP (solid shape): 230.81,203.96 230.81,202.59 230.9,202.5 230.9,194.56 230.48,194.13 226.13,194.13 226.02,194.24 226.02,195.48 226.01,195.5 226.01,201.13 226.55,201.67 227.84,201.67 230.2,204.03 230.74,204.03
GND on TOP (solid shape): 236.92,65.8 236.92,65.31 236.46,64.84 236.46,63.41 236.34,63.29 236.16,63.29 232.4,63.29 232.3,63.38 232.3,64.93 231.96,65.27 231.96,65.82 232.01,65.87 236.85,65.87
GND on TOP (solid shape): 249,65.8 249,65.31 248.53,64.84 248.53,63.41 248.41,63.29 248.23,63.29 248.23,63.29 244.47,63.29 244.37,63.38 244.37,64.93 244.03,65.27 244.03,65.82 244.09,65.87 248.93,65.87
GND on TOP (solid shape): 261.16,65.85 261.16,65.35 260.7,64.88 260.7,63.45 260.58,63.33 260.4,63.33 256.64,63.33 256.54,63.43 256.54,64.97 256.2,65.31 256.2,65.86 256.25,65.92 261.09,65.92
GND on TOP (solid shape): 273.24,65.85 273.24,65.35 272.77,64.88 272.77,63.45 272.65,63.33 272.47,63.33 268.71,63.33 268.61,63.43 268.61,64.97 268.27,65.31 268.27,65.86 268.33,65.92 273.17,65.92
GND on TOP (solid shape): 273.15,161.3 274.06,161.3 274.06,161.47 283.46,161.47 284.22,160.71 284.22,155.76 283.21,154.74 274.2,154.74 274.2,154.75 273.64,154.75 273.64,154.74 272.29,154.74 271.27,155.76 271.27,160.71 272.03,161.47 273.15,161.47
GND on TOP (solid shape): 301.43,174.55 301.43,143.38 300.99,142.93 298.58,142.93 298.19,143.31 298.19,158.82 298.2,158.88 298.19,158.93 298.19,173.75 298.19,173.75 298.19,174.64 298.52,174.97 301.01,174.97
GND on TOP (solid shape): 36.14,171.3 36.14,170.03 35.38,170.03 35.33,169.98 35.31,169.98 35.31,169.96 35.2,169.85 29.88,169.85 29.75,169.72 29.75,167.1 30.1,166.76 30.1,160.45 30,160.36 28.6,160.36 28.36,160.6 28.36,171.15 28.78,171.57 35.87,171.57
GND on TOP (solid shape): 103.45,123.83 103.45,122.25 102.84,121.64 102.84,120.25 102.38,119.79 100.59,119.79 100.26,120.12 100.26,120.38 100.26,120.39 100.28,120.52 100.26,120.66 100.26,120.66 100.26,123.77 100.51,124.03 103.25,124.03
GND on TOP (solid shape): 212.71,204.21 212.71,202.84 212.8,202.75 212.8,194.81 212.37,194.39 208.03,194.39 207.92,194.49 207.92,195.74 207.91,195.75 207.91,201.32 208.26,201.67 209.39,201.67 209.79,202.08 209.79,202.93 210.08,203.21 211.03,203.21 212.1,204.29 212.64,204.29
GND on TOP (solid shape): 96.49,65.55 96.49,65.05 96.02,64.59 96.02,63.15 95.9,63.03 95.72,63.03 94.29,63.03 94.28,63.03 94.11,63.06 93.94,63.03 93.93,63.03 91.96,63.03 91.86,63.13 91.86,64.67 91.52,65.01 91.52,65.56 91.58,65.62 96.41,65.62
GND on TOP (solid shape): 47.24,180.13 47.24,162.24 46.9,161.9 43.6,161.9 43.38,161.69 39.98,161.69 39.98,161.79 39.68,161.79 39.54,161.92 34.26,161.92 34.13,162.04 34.13,165.25 34.21,165.32 39.62,165.32 39.75,165.45 39.98,165.45 39.98,165.58 41.98,165.58 42.19,165.78 42.19,168.6 42.67,169.08 42.67,180 43.3,180.64 46.73,180.64
GND on TOP (solid shape): 244.12,203.39 244.15,203.39 244.15,203.37 245.06,203.37 245.06,203.39 245.19,203.39 245.39,203.59 245.77,203.59 245.85,203.67 246.81,203.67 246.87,203.73 247.04,203.73 247.17,203.6 247.17,202.79 246.96,202.57 246.95,202.57 246.58,202.2 246.3,202.2 246.25,202.15 246.25,196.25 245.75,195.75 242.07,195.75 241.9,195.93 241.9,204.16 241.99,204.25 243.26,204.25
GND on TOP (solid shape): 288.46,118.22 288.46,118.22 288.83,117.84 288.83,117.56 288.88,117.51 295.04,117.51 295.26,117.29 295.26,113.52 294.9,113.16 286.04,113.16 285.96,113.24 285.96,114.71 286.18,114.94 287.19,114.94 287.64,115.39 287.64,115.41 287.66,115.41 287.66,116.33 287.64,116.33 287.64,116.45 287.44,116.65 287.44,117.03 287.36,117.11 287.36,118.07 287.3,118.13 287.3,118.3 287.43,118.44 288.24,118.44
GND on TOP (solid shape): 84.36,148.23 84.36,140.92 83.87,140.43 78.13,140.43 77.24,139.54 74.31,139.54 73.81,140.04 73.81,141.11 74.15,141.44 74.15,142.8 74.23,142.88 74.23,144.5 74.28,144.56 75.99,144.56 76.31,144.24 76.31,141.89 76.58,141.62 77.99,141.62 78.39,141.22 81.49,141.22 81.78,141.51 82.77,141.51 82.94,141.69 82.94,142.37 82.25,143.06 82.25,144.62 82.66,145.03 82.66,148.46 84.13,148.46
GND on TOP (solid shape): 164.37,204.06 164.37,202.11 171.1,195.38 175.26,195.38 175.64,195 175.64,190.56 175.39,190.3 168.53,190.3 168.15,190.68 168.15,191.7 167.39,192.46 164.63,192.46 164.37,192.21 164.37,187.34 164.09,187.06 160.77,187.06 160.28,186.57 157.23,186.57 157,186.8 151.39,186.8 151.27,186.92 151.27,190.13 151.34,190.2 157,190.2 157.26,190.46 159.12,190.46 159.49,190.83 159.49,204.27 159.74,204.52 163.91,204.52
GND on TOP (solid shape): 188.59,204.98 188.59,204.08 189.28,203.39 189.31,203.39 189.31,203.37 190.22,203.37 190.22,203.39 190.35,203.39 190.55,203.59 190.93,203.59 190.96,203.62 191.99,203.62 192.1,203.73 192.2,203.73 192.33,203.6 192.33,202.79 192.12,202.57 192.11,202.57 191.73,202.2 191.46,202.2 191.41,202.15 191.41,195.99 191.19,195.77 189.67,195.77 189.13,196.32 189.13,197.81 188.73,198.21 187.08,198.21 187.06,198.23 187.06,205.09 187.2,205.23 188.34,205.23
GND on TOP (solid shape): 68.33,148.23 68.33,140.62 68.15,140.43 62.19,140.43 61.78,140.02 61.78,139.35 60.34,137.91 60.34,136.53 59.85,136.04 57.84,136.04 57.82,136.06 57.82,136.7 58.1,136.98 58.1,138.1 58.43,138.43 58.43,142.47 58.8,142.85 60.22,142.85 60.37,142.7 60.37,141.81 60.53,141.65 61.93,141.65 62.36,141.22 65.46,141.22 65.77,141.53 66.73,141.53 66.9,141.7 66.9,142.53 66.76,142.67 66.4,142.67 66.21,142.86 66.21,144.48 66.63,144.9 66.63,148.46 68.1,148.46
GND on TOP (solid shape): 151.29,196.11 151.29,193.58 151.17,193.45 148.69,193.45 148.42,193.72 148.42,194.56 148.1,194.88 147.16,194.88 147.04,194.76 147.04,185.55 146.94,185.45 145.71,185.45 145.48,185.68 145.55,185.97 145.45,186.24 145.45,192.85 145.45,192.86 145.49,193.04 145.45,193.22 145.45,193.23 145.45,196.03 145.92,196.49 150.91,196.49
GND on TOP (solid shape): 182.71,186.3 182.71,168.18 180.69,166.16 169.84,166.16 169.26,166.75 169.26,169.52 169.6,169.86 174.84,169.86 175.26,169.6 175.68,169.86 176.64,169.86 177.15,170.37 177.15,172.69 177.5,173.04 177.5,184.35 176.66,185.19 168.21,185.19 167.67,185.73 167.67,187.96 168.34,188.63 180.38,188.63
GND on TOP (solid shape): 83.93,183.95 83.93,181.79 83.31,181.17 81.76,181.17 81.18,180.59 81.18,175.16 80.54,174.52 78.54,174.52 78.22,174.84 78.22,179.5 78.27,179.53 78.31,179.55 78.38,179.6 78.41,179.63 78.44,179.67 78.47,179.71 78.5,179.76 78.53,179.81 78.55,179.86 78.57,179.93 78.57,179.99 78.58,180.04 78.58,180.27 78.56,180.33 78.56,180.37 78.53,180.45 78.48,180.53 78.44,180.59 78.36,180.67 78.36,181 78.22,181.15 78.22,183.7 78.09,183.83 76.06,183.83 76.06,184.06 78.32,184.06 78.32,184.08 83.81,184.08
GND on TOP (solid shape): 23.25,149.24 23.99,149.24 24.01,149.21 24.01,146 23.94,145.93 23.55,145.93 23.49,145.88 23.25,145.88 23.25,144.48 23.39,144.48 23.39,144.1 23.61,143.88 25.77,143.88 26.48,144.58 31.89,144.58 32.09,144.38 32.09,142.2 31.91,142.02 14.28,142.02 14.03,142.26 14.03,144.55 14.12,144.64 18.78,144.64 19.14,144.28 21.26,144.28 21.46,144.48 21.54,144.48 21.54,145.88 21.44,145.88 21.44,145.88 20.87,145.88 20.81,145.95 20.81,147.86 20.73,147.93 20.71,147.93 20.71,148 19.54,148 19.53,148.01 19.53,148.41 20.72,148.41 20.78,148.48 20.78,149.18 20.85,149.24 21.54,149.24 21.54,150.43 23.25,150.43
GND on TOP (solid shape): 234.66,169.69 235.16,169.69 235.96,168.89 236.09,168.89 237.32,167.66 237.32,166.44 236.38,165.51 236.38,155.16 236.74,154.8 236.74,152.68 224.28,152.68 224.28,163.77 225.4,164.9 225.6,164.93 225.71,164.77 225.71,153.74 233.92,153.74 233.92,167.59 230.15,167.59 229.99,167.7 230.03,167.89 231.4,169.27 231.4,169.69 231.58,169.69 231.58,170.49 234.66,170.49
GND on TOP (solid shape): 76.88,133.85 76.88,130.35 76.68,130.15 73.65,130.15 73.55,130.22 73.59,130.33 73.67,130.97 73.03,131.06 72.92,131.05 72.87,131.14 72.87,134.04 73.57,134.74 75.99,134.74
GND on TOP (solid shape): 155.76,104.45 155.76,99.36 155.63,99.05 155.75,98.74 155.76,98.73 155.76,98.59 155.48,98.31 155.09,98.31 155.09,98.72 154.76,99.5 154.44,98.72 154.44,98.31 153.34,98.31 153.23,98.43 153.23,104.54 153.32,104.64 155.57,104.64
GND on TOP (solid shape): 5.66,183.76 6.11,183.35 6.57,183.76 6.57,183.8 7.05,183.8 7.06,183.77 7.5,183.44 7.94,183.77 7.95,183.8 9.74,183.8 9.98,183.56 9.98,182.35 9.22,182.35 9.17,182.3 9.15,182.3 9.15,182.28 9.03,182.17 3.72,182.17 3.59,182.04 3.59,179.88 3.34,179.63 3.34,178.61 3.85,178.1 3.94,178.1 3.94,172.66 3.87,172.59 2.46,172.59 2.2,172.85 2.2,183.45 2.55,183.8 5.65,183.8
GND on TOP (solid shape): 131.33,148.68 131.33,146.14 130.77,145.59 130.74,145.61 130.37,145.66 130.09,145.42 127.6,145.42 127.3,145.72 127.3,145.9 127.33,145.91 127.38,145.94 127.43,145.98 127.49,146 127.56,145.98 128.29,146.32 127.56,146.66 127.49,146.63 127.43,146.66 127.38,146.69 127.33,146.72 127.3,146.73 127.3,150.23 127.44,150.37 129.64,150.37
GND on TOP (solid shape): outline of 166 points within 177.37,96.64 184.55,113.26
GND on TOP (solid shape): outline of 250 points within 40.84,205.83 48.84,213.83
GND on TOP (solid shape): outline of 250 points within 278.55,62.62 286.55,70.62
GND on TOP (solid shape): outline of 264 points within 2.6,140.78 10.86,149.03
GND on TOP (solid shape): outline of 264 points within 302.82,205.74 311.08,213.99
GND on TOP (solid shape): outline of 267 points within 2.62,54.49 12.62,64.5
GND on TOP (solid shape): outline of 267 points within 20.61,183.69 30.61,193.69
GND on TOP (solid shape): outline of 267 points within 48.7,172.55 58.7,182.55
GND on TOP (solid shape): outline of 267 points within 59.26,54.49 69.26,64.5
GND on TOP (solid shape): outline of 267 points within 93.3,107.39 103.3,117.4
GND on TOP (solid shape): outline of 267 points within 156.7,160.6 166.7,170.6
GND on TOP (solid shape): outline of 267 points within 170.92,204.86 180.92,214.86
GND on TOP (solid shape): outline of 267 points within 191.92,65.69 201.92,75.69
GND on TOP (solid shape): outline of 267 points within 248.7,172.55 258.7,182.55
GND on TOP (solid shape): outline of 267 points within 299.92,116.2 309.92,126.2
GND on TOP (solid shape): outline of 346 points within 69.02,127.57 81.74,138.08
GND on TOP (solid shape): outline of 366 points within 92.26,119.52 105.61,127.56
GND on TOP (solid shape): outline of 96 points within 92.69,87.03 100.35,94.7
GND on TOP (solid shape): outline of 94 points within 92.69,87.03 100.35,94.7
GND on TOP (solid shape): outline of 105 points within 117.45,190.53 125.29,198.38
GND on TOP (solid shape): outline of 972 points within 186.62,89.67 282.77,109.4
GND on TOP (solid shape): outline of 162072 points within 0.51,0.51 312.99,215.32
GND on BOTTOM (solid shape): 15.24,138.62 15.24,137.27 15.04,137.07 12.71,137.07 12.53,137.25 12.53,138.47 12.71,138.65 15.21,138.65
GND on BOTTOM (solid shape): 36.43,148.2 36.43,138.53 36.25,138.35 33.03,138.35 32.67,138.71 32.67,148.16 33.09,148.58 36.05,148.58
GND on BOTTOM (solid shape): 134.69,85.36 134.69,80.54 134.39,80.24 128.63,80.24 128.26,80.6 128.26,85.57 128.31,85.62 134.43,85.62
GND on BOTTOM (solid shape): 143.82,105.36 143.82,102.58 143.5,102.27 140.93,102.27 140.81,102.39 140.81,105.49 141,105.69 143.49,105.69
GND on BOTTOM (solid shape): 151.7,96.78 151.7,93.88 151.47,93.65 148.69,93.65 148.5,93.85 148.5,96.87 148.61,96.99 151.49,96.99
GND on BOTTOM (solid shape): 222.04,90.69 222.04,84.17 221.55,83.68 218.6,83.68 218.14,84.14 218.14,91.18 218.62,91.66 221.07,91.66
GND on BOTTOM (solid shape): 223.52,169.33 223.52,166.79 223.24,166.51 222.14,166.51 222.05,166.6 222.05,169.27 222.28,169.5 223.35,169.5
GND on BOTTOM (solid shape): 228.75,100.17 228.75,98.69 228.63,98.58 226.62,98.58 226.5,98.7 226.5,100.23 226.53,100.26 228.65,100.26
GND on BOTTOM (solid shape): 257.54,114.45 257.54,110.87 257.17,110.51 252.75,110.51 252.52,110.73 252.52,114.45 252.78,114.71 257.28,114.71
GND on BOTTOM (solid shape): 274.09,103.15 274.09,99.84 274.02,99.78 271.06,99.78 270.76,100.07 270.76,103.49 270.92,103.65 273.58,103.65
GND on BOTTOM (solid shape): 288.29,175.46 288.29,172.36 287.76,171.82 269.3,171.82 268.73,172.4 268.73,175.7 269.24,176.21 287.55,176.21
GND on BOTTOM (solid shape): 9.21,24.26 10.77,24.26 11.03,23.99 11.03,20.24 10.75,19.96 8.01,19.96 7.74,20.24 7.74,24.11 7.89,24.27 9.2,24.27
GND on BOTTOM (solid shape): 9.51,162.68 9.51,152.04 8.73,151.26 4.5,151.26 4.05,151.71 4.05,162.78 4.33,163.06 9.13,163.06
GND on BOTTOM (solid shape): 50.38,148.58 50.38,137.27 49.68,136.57 46.46,136.57 46.07,136.96 46.07,140.59 46.11,140.63 46.11,148.61 46.37,148.87 50.08,148.87
GND on BOTTOM (solid shape): 230.9,201.78 230.9,194.56 230.47,194.13 226.13,194.13 226.02,194.24 226.02,200.5 226.02,200.5 226.02,200.79 225.39,201.42 225.39,201.95 225.42,201.99 230.7,201.99
GND on BOTTOM (solid shape): 253.36,108.66 253.36,104.04 252.1,102.78 248.96,102.78 246.49,100.31 240.8,100.31 240.63,100.47 240.63,105.19 240.99,105.56 246.25,105.56 249.72,109.03 252.99,109.03
GND on BOTTOM (solid shape): 259.97,148.16 259.97,147.88 260.2,147.66 262.08,147.66 262.3,147.43 262.3,144.98 261.68,144.35 257.13,144.35 256.92,144.56 256.92,147.94 257.26,148.27 259.86,148.27
GND on BOTTOM (solid shape): 274.68,98.06 274.68,95.44 274.51,95.26 267.28,95.26 267.19,95.35 267.19,96.44 267.34,96.59 272.16,96.59 272.72,97.14 272.72,98.25 272.98,98.52 274.22,98.52
GND on BOTTOM (solid shape): 207.66,203.7 212.52,203.7 212.8,203.42 212.8,194.81 212.37,194.39 208.03,194.39 207.92,194.49 207.92,201.95 207.06,202.82 205.1,202.82 204.85,203.07 204.85,204.09 207.26,204.09
GND on BOTTOM (solid shape): 80.72,202.65 80.72,201.76 80.73,201.76 80.73,194.4 78.99,192.66 75.95,192.66 75.69,192.91 75.69,201.42 75.67,201.44 75.67,201.53 75.31,201.89 75.31,202.72 75.34,202.75 80.62,202.75
GND on BOTTOM (solid shape): 96.49,65.8 96.49,65.31 96.02,64.84 96.02,63.41 95.9,63.29 95.72,63.29 91.96,63.29 91.86,63.38 91.86,64.93 91.52,65.27 91.52,65.82 91.58,65.87 96.41,65.87
GND on BOTTOM (solid shape): 108.56,65.8 108.56,65.31 108.1,64.84 108.1,63.41 107.98,63.29 107.8,63.29 107.8,63.29 104.04,63.29 103.94,63.38 103.94,64.93 103.6,65.27 103.6,65.82 103.66,65.87 108.49,65.87
GND on BOTTOM (solid shape): 120.64,65.55 120.64,65.05 120.18,64.59 120.18,63.15 120.06,63.03 119.88,63.03 116.12,63.03 116.02,63.13 116.02,64.67 115.68,65.01 115.68,65.56 115.73,65.62 120.57,65.62
GND on BOTTOM (solid shape): 132.72,65.55 132.72,65.05 132.25,64.59 132.25,63.15 132.13,63.03 131.95,63.03 131.95,63.03 128.19,63.03 128.09,63.13 128.09,64.67 127.75,65.01 127.75,65.56 127.81,65.62 132.65,65.62
GND on BOTTOM (solid shape): 148.66,65.8 148.66,65.31 148.2,64.84 148.2,63.41 148.08,63.29 147.9,63.29 147.9,63.29 144.14,63.29 144.04,63.38 144.04,64.93 143.7,65.27 143.7,65.82 143.75,65.87 148.59,65.87
GND on BOTTOM (solid shape): 160.74,65.8 160.74,65.31 160.27,64.84 160.27,63.41 160.15,63.29 159.97,63.29 156.21,63.29 156.12,63.38 156.12,64.93 155.77,65.27 155.77,65.82 155.83,65.87 160.67,65.87
GND on BOTTOM (solid shape): 172.82,65.8 172.82,65.31 172.35,64.84 172.35,63.41 172.23,63.29 172.05,63.29 172.05,63.29 168.29,63.29 168.19,63.38 168.19,64.93 167.85,65.27 167.85,65.82 167.91,65.87 172.74,65.87
GND on BOTTOM (solid shape): 184.89,65.8 184.89,65.31 184.43,64.84 184.43,63.41 184.31,63.29 184.13,63.29 180.37,63.29 180.27,63.38 180.27,64.93 179.93,65.27 179.93,65.82 179.98,65.87 184.82,65.87
GND on BOTTOM (solid shape): 212.77,65.8 212.77,65.31 212.3,64.84 212.3,63.41 212.18,63.29 212,63.29 208.24,63.29 208.14,63.38 208.14,64.93 207.8,65.27 207.8,65.82 207.86,65.87 212.69,65.87
GND on BOTTOM (solid shape): 224.84,65.8 224.84,65.31 224.38,64.84 224.38,63.41 224.26,63.29 224.08,63.29 224.08,63.29 220.32,63.29 220.22,63.38 220.22,64.93 219.88,65.27 219.88,65.82 219.94,65.87 224.77,65.87
GND on BOTTOM (solid shape): 236.92,65.8 236.92,65.31 236.46,64.84 236.46,63.41 236.34,63.29 236.16,63.29 232.4,63.29 232.3,63.38 232.3,64.93 231.96,65.27 231.96,65.82 232.01,65.87 236.85,65.87
GND on BOTTOM (solid shape): 249,65.8 249,65.31 248.53,64.84 248.53,63.41 248.41,63.29 248.23,63.29 248.23,63.29 244.47,63.29 244.37,63.38 244.37,64.93 244.03,65.27 244.03,65.82 244.09,65.87 248.93,65.87
GND on BOTTOM (solid shape): 261.16,65.85 261.16,65.35 260.7,64.88 260.7,63.45 260.58,63.33 260.4,63.33 256.64,63.33 256.54,63.43 256.54,64.97 256.2,65.31 256.2,65.86 256.25,65.92 261.09,65.92
GND on BOTTOM (solid shape): 273.24,65.85 273.24,65.35 272.77,64.88 272.77,63.45 272.65,63.33 272.47,63.33 268.71,63.33 268.61,63.43 268.61,64.97 268.27,65.31 268.27,65.86 268.33,65.92 273.17,65.92
GND on BOTTOM (solid shape): 289.73,117.24 295.07,117.24 295.26,117.05 295.26,113.81 294.61,113.15 286.17,113.15 286.16,113.16 286.16,114.56 286.5,114.9 287.07,114.9 287.29,115.11 287.29,118.01 287.46,118.19 288.78,118.19
GND on BOTTOM (solid shape): 164.37,204.06 164.37,187.34 163.6,186.57 151.62,186.57 151.27,186.92 151.27,189.75 151.71,190.2 157,190.2 157.34,190.54 158.72,190.54 158.95,190.77 158.95,192.83 159.49,193.37 159.49,204.27 159.74,204.52 163.91,204.52
GND on BOTTOM (solid shape): 83.93,183.95 83.93,181.79 83.31,181.17 81.76,181.17 81.18,180.59 81.18,175.2 80.63,174.65 78.34,174.65 78.22,174.78 78.22,180.35 78.56,180.35 78.56,181.26 78.22,181.26 78.22,181.8 78.25,181.8 78.25,182.36 78.22,182.36 78.22,183.57 78.73,184.08 83.81,184.08
GND on BOTTOM (solid shape): 183.13,185.88 183.13,168.12 180.72,165.71 169.84,165.71 169.08,166.47 169.08,169.34 169.29,169.55 174.62,169.55 174.62,169.54 176.33,169.54 177.49,170.71 177.49,173.03 177.5,173.04 177.5,184.35 176.66,185.19 168.21,185.19 167.67,185.73 167.67,187.96 168.34,188.63 180.38,188.63
GND on BOTTOM (solid shape): 238.91,110.58 238.91,108.4 238.91,108.34 238.91,108.28 238.91,107.56 238.91,107.5 238.91,107.44 238.91,104.18 238.65,103.92 237.36,103.92 236.47,104.81 236.47,110.61 236.57,110.7 238.79,110.7
GND on BOTTOM (solid shape): 19.37,191.42 19.37,184.46 20.69,183.13 20.69,174.84 19.87,174.01 8.33,174.01 7.97,174.36 7.97,178.14 8.09,178.26 11.08,178.26 11.33,178.01 15.64,178.01 15.77,178.14 15.77,179.64 15.8,179.64 15.8,180.55 15.77,180.55 15.77,180.66 16.22,181.11 16.22,191.18 16.64,191.61 19.17,191.61
GND on BOTTOM (solid shape): 67.18,199.36 67.18,188.21 66.97,188 65.56,188 65.37,188.19 65.37,192.76 65.08,193.06 61.84,193.06 61.72,193.18 61.72,194.89 61.87,195.04 64.13,195.04 64.29,195.2 64.29,199.45 64.31,199.46 64.31,199.69 64.62,200 66.55,200
GND on BOTTOM (solid shape): 47.24,180.13 47.24,161.99 46.94,161.69 34.49,161.69 34.13,162.04 34.13,165.26 34.81,165.94 36.25,165.94 36.25,165.81 37.16,165.81 37.16,165.94 37.24,165.94 37.49,165.69 41.81,165.69 41.93,165.82 41.93,167.32 41.96,167.32 41.96,168.24 41.93,168.24 41.93,168.34 42.67,169.08 42.67,180 43.3,180.64 46.73,180.64
GND on BOTTOM (solid shape): 23.66,148.58 23.66,145.4 24.43,144.64 31.9,144.64 32.01,144.53 32.01,141.05 31.8,140.84 28.32,140.84 27.99,141.17 26.9,141.17 26.29,140.57 20.89,140.57 20.82,140.64 20.82,141.71 20.51,142.01 19.44,142.01 19.44,142.02 15.54,142.02 15.21,142.34 15.21,144.31 15.54,144.64 19.73,144.64 20.36,145.27 20.36,148.45 20.87,148.96 23.28,148.96
GND on BOTTOM (solid shape): 24.22,163.24 24.22,162.58 23.97,162.05 24.22,161.52 24.22,151.65 23.81,151.25 20.18,151.25 19.9,151.52 19.9,155.59 19.95,155.63 19.95,163.24 20.41,163.7 23.75,163.7
GND on BOTTOM (solid shape): 234.77,92.71 238.04,92.71 239.01,91.73 239.01,89.16 241.22,86.95 242.53,86.95 242.94,86.54 242.94,83.94 242.23,83.23 242.15,83.23 242.14,83.23 241.93,83.27 241.73,83.23 241.72,83.23 234.35,83.23 233.81,83.77 233.81,89.38 232.7,90.5 229.46,90.5 229.05,90.9 229.05,92.25 227.85,93.45 227.85,96.68 227.93,96.75 230.73,96.75
GND on BOTTOM (solid shape): 187.68,205.08 187.94,205.08 187.96,205.1 188.21,205.1 188.85,204.47 188.85,203.91 188.98,203.79 189.44,203.79 189.87,203.64 190.29,203.79 191.86,203.79 192.17,203.48 192.17,202.99 192.1,202.99 192.1,202.42 191.14,201.45 191.14,195.96 190.95,195.77 189.31,195.77 189.13,195.95 189.13,197.81 188.74,198.2 187.11,198.2 187.05,198.25 187.05,204.12 187.08,204.15 187.08,204.86 187.32,205.1 187.66,205.1
GND on BOTTOM (solid shape): 264.87,153.78 265.78,153.78 265.78,153.78 266.01,153.78 266.24,153.55 266.24,145.27 266.06,145.09 265.03,145.09 264.86,145.26 264.86,151.1 264.9,151.11 265.22,151.74 264.54,151.93 264.5,151.91 264.21,152.2 262.36,152.2 262.09,152.47 262.09,153.61 262.25,153.78 264.87,153.78
GND on BOTTOM (solid shape): 243.08,206.6 243.08,204.37 243.66,203.79 245.94,203.79 245.94,203.74 246.27,203.24 246.87,203.19 246.97,203.17 247.01,203.09 247.01,202.99 246.94,202.99 246.94,202.42 245.98,201.45 245.98,195.99 245.73,195.75 242.11,195.75 241.89,195.96 241.89,204.47 241.61,204.75 241.6,204.75 241.6,206.68 241.76,206.83 242.65,206.83 242.65,206.88 242.8,206.88
GND on BOTTOM (solid shape): 301.64,175.06 301.64,172.59 301.59,172.59 301.59,171.67 301.64,171.67 301.64,170.55 301.56,170.55 301.56,170.33 301.47,170.33 301.47,169.77 301.56,169.77 301.56,169.56 301.64,169.56 301.64,159.08 301.62,159.08 301.62,158.17 301.64,158.17 301.64,156.81 301.49,156.81 301.49,155.89 301.64,155.89 301.64,154.8 301.56,154.8 301.56,154.58 301.47,154.58 301.47,154.03 301.56,154.03 301.56,153.81 301.64,153.81 301.64,144.01 301.31,143.68 298.6,143.68 298.19,144.09 298.19,153.16 297.43,153.92 297.43,154.86 297.43,155.07 298.19,155.83 298.19,158.82 298.2,158.88 298.19,158.93 298.19,160.97 297.23,161.93 297.23,170.87 297.6,171.24 297.6,174.93 297.86,175.19 301.52,175.19
GND on BOTTOM (solid shape): 187.19,98.7 187.19,94.48 186.8,94.09 181.72,94.09 181.14,94.66 181.14,94.93 185.83,94.93 185.83,94.87 185.83,94.81 185.85,94.75 185.87,94.69 185.9,94.64 185.94,94.6 185.98,94.55 186.03,94.52 186.08,94.49 186.14,94.46 186.19,94.45 186.25,94.44 186.31,94.44 186.37,94.45 186.43,94.46 186.49,94.49 186.54,94.52 186.59,94.55 186.63,94.6 186.67,94.64 186.7,94.69 186.72,94.75 186.73,94.81 186.74,94.87 186.74,94.93 186.73,94.99 186.72,95.04 186.7,95.1 186.67,95.15 186.63,95.2 186.59,95.24 186.54,95.28 186.49,95.31 186.43,95.33 186.37,95.35 186.31,95.35 186.25,95.35 186.19,95.35 186.14,95.33 186.08,95.31 186.03,95.28 185.98,95.24 185.94,95.2 185.9,95.15 185.87,95.1 185.85,95.04 185.83,94.99 185.83,94.93 181.14,94.93 181.14,98.97 181.3,99.12 186.77,99.12
GND on BOTTOM (solid shape): 284.22,160.71 284.22,155.76 283.21,154.74 272.29,154.74 271.27,155.76 271.27,155.92 271.28,155.93 271.38,156.3 271.27,156.67 271.27,157.19 271.38,157.56 271.27,157.94 271.27,158.46 271.38,158.83 271.27,159.21 271.27,159.73 271.38,160.1 271.28,160.47 271.27,160.48 271.27,160.71 272.03,161.47 283.46,161.47
GND on BOTTOM (solid shape): 274.44,103.13 274.44,102.42 274.64,102.21 274.66,102.12 274.58,102.06 274.45,102.06 274.45,95.21 260.94,95.21 260.86,95.26 260.88,95.36 260.93,95.41 264.58,95.41 265.12,95.95 265.12,100.45 265.17,100.53 265.27,100.52 265.35,100.44 265.35,97.31 265.86,96.8 272.33,96.8 272.63,97.1 272.63,99.29 272.34,99.58 270.27,99.58 269.82,100.04 269.82,102.46 268.53,103.74 268.5,103.93 268.66,104.04 273.53,104.04
GND on BOTTOM (solid shape): 196.6,106.9 196.63,106.83 196.6,106.76 196.52,106.36 196.86,106.13 196.93,106.1 196.96,106.03 196.96,105.7 197,105.66 197,105.33 196.96,105.29 196.96,105.26 196.57,104.88 196.09,104.88 196.09,104.83 196.02,104.83 196.01,104.83 195.5,104.59 195.82,104.13 195.86,104.12 195.86,103.87 195.82,103.86 195.75,103.85 195.68,103.82 193.8,103.82 193.55,104.07 193.55,106.74 193.8,106.99 196.51,106.99
GND on BOTTOM (solid shape): outline of 115 points within 186.83,140.71 192.33,145.16
GND on BOTTOM (solid shape): outline of 183 points within 255.44,78.25 273.98,87.81
GND on BOTTOM (solid shape): 116.2,34.42 116.2,32.48 123.49,32.48 123.49,32.7 123.93,32.7 123.93,34.22 123.89,34.22 123.72,34.33 123.76,34.53 123.82,34.58 124.01,34.62 124.12,34.46 124.12,30.66 124.03,30.5 123.84,30.52 123.12,30.15 123.84,29.77 124.03,29.79 124.12,29.63 124.12,28.85 116.2,28.85 116.2,28.18 115.97,28.18 115.89,28.23 115.9,28.32 115.8,28.96 115.16,28.85 115.01,28.77 114.86,28.85 114.25,28.98 114.08,28.37 114.09,28.35 114.09,28.2 114.01,28.16 114.01,28.04 113.89,28.04 113.87,28.05 113.81,28.1 113.76,28.15 113.4,28.15 113.4,29.57 114.29,30.47 114.29,34.12 114.35,34.25 114.48,34.3 114.85,34.4 115.11,34.68 115.14,34.72 115.89,34.72
GND on BOTTOM (solid shape): outline of 178 points within 141.42,23.11 153.39,34.92
GND on BOTTOM (solid shape): outline of 250 points within 40.84,205.83 48.84,213.83
GND on BOTTOM (solid shape): outline of 250 points within 278.55,62.62 286.55,70.62
GND on BOTTOM (solid shape): outline of 264 points within 2.6,140.78 10.86,149.03
GND on BOTTOM (solid shape): outline of 264 points within 302.82,205.74 311.08,213.99
GND on BOTTOM (solid shape): outline of 267 points within 2.62,54.49 12.62,64.5
GND on BOTTOM (solid shape): outline of 267 points within 20.61,183.69 30.61,193.69
GND on BOTTOM (solid shape): outline of 267 points within 48.7,172.55 58.7,182.55
GND on BOTTOM (solid shape): outline of 267 points within 59.26,54.49 69.26,64.5
GND on BOTTOM (solid shape): outline of 267 points within 93.3,107.39 103.3,117.4
GND on BOTTOM (solid shape): outline of 267 points within 156.7,160.6 166.7,170.6
GND on BOTTOM (solid shape): outline of 267 points within 170.92,204.86 180.92,214.86
GND on BOTTOM (solid shape): outline of 267 points within 191.92,65.69 201.92,75.69
GND on BOTTOM (solid shape): outline of 267 points within 248.7,172.55 258.7,182.55
GND on BOTTOM (solid shape): outline of 267 points within 299.92,116.2 309.92,126.2
GND on BOTTOM (solid shape): outline of 134 points within 199.01,95.43 208.91,101.78
GND on BOTTOM (solid shape): outline of 468 points within 229.62,121.16 243.5,134.87
GND on BOTTOM (solid shape): outline of 153 points within 180.33,9.88 199.14,29.56
GND on BOTTOM (solid shape): outline of 655 points within 126,34.56 139.02,46.36
GND on BOTTOM (solid shape): outline of 782 points within 120.37,123.97 136.28,136.25
GND on BOTTOM (solid shape): outline of 791 points within 97.48,28.5 111.11,50.25
GND on BOTTOM (solid shape): outline of 793 points within 168.75,27.89 181.91,46.79
GND on BOTTOM (solid shape): outline of 817 points within 95.77,119.53 109.18,129.39
GND on BOTTOM (solid shape): outline of 829 points within 70.63,187.39 86.55,213.66
GND on BOTTOM (solid shape): outline of 1389 points within 88.23,115.26 108.93,138.32
GND on BOTTOM (solid shape): outline of 1479 points within 12.79,43.83 37.97,55.79
GND on BOTTOM (solid shape): outline of 10086 points within 106.51,89.19 195.29,143.36
GND on BOTTOM (solid shape): outline of 146115 points within 0.51,0.51 312.99,215.32
GND on G02 (solid shape): outline of 26798 points within 0.51,0.51 312.99,215.32
GND on T03 (solid shape): outline of 247 points within 21.62,184.71 29.59,192.68
GND on T03 (solid shape): outline of 247 points within 49.72,173.57 57.68,181.54
GND on T03 (solid shape): outline of 247 points within 60.28,55.51 68.25,63.48
GND on T03 (solid shape): outline of 247 points within 94.31,108.41 102.28,116.38
GND on T03 (solid shape): outline of 247 points within 157.72,161.61 165.68,169.58
GND on T03 (solid shape): outline of 247 points within 192.94,66.7 200.91,74.67
GND on T03 (solid shape): outline of 247 points within 249.72,173.57 257.68,181.54
GND on T03 (solid shape): outline of 250 points within 278.55,62.62 286.55,70.62
GND on T03 (solid shape): outline of 264 points within 2.6,140.78 10.86,149.03
GND on T03 (solid shape): outline of 3717 points within 0.51,0.51 312.99,215.32
GND on G04 (solid shape): outline of 13266 points within 0.51,0.51 312.99,215.32
GND on T05 (solid shape): outline of 247 points within 21.62,184.71 29.59,192.68
GND on T05 (solid shape): outline of 247 points within 49.72,173.57 57.68,181.54
GND on T05 (solid shape): outline of 247 points within 60.28,55.51 68.25,63.48
GND on T05 (solid shape): outline of 247 points within 94.31,108.41 102.28,116.38
GND on T05 (solid shape): outline of 247 points within 157.72,161.61 165.68,169.58
GND on T05 (solid shape): outline of 247 points within 192.94,66.7 200.91,74.67
GND on T05 (solid shape): outline of 247 points within 249.72,173.57 257.68,181.54
GND on T05 (solid shape): outline of 250 points within 278.55,62.62 286.55,70.62
GND on T05 (solid shape): outline of 264 points within 2.6,140.78 10.86,149.03
GND on T05 (solid shape): outline of 3776 points within 0.51,0.51 312.99,215.32
GND on G06 (solid shape): outline of 13520 points within 0.51,0.51 312.99,215.32
GND on T07 (solid shape): outline of 247 points within 21.62,184.71 29.59,192.68
GND on T07 (solid shape): outline of 247 points within 49.72,173.57 57.68,181.54
GND on T07 (solid shape): outline of 247 points within 60.28,55.51 68.25,63.48
GND on T07 (solid shape): outline of 247 points within 94.31,108.41 102.28,116.38
GND on T07 (solid shape): outline of 247 points within 157.72,161.61 165.68,169.58
GND on T07 (solid shape): outline of 247 points within 192.94,66.7 200.91,74.67
GND on T07 (solid shape): outline of 247 points within 249.72,173.57 257.68,181.54
GND on T07 (solid shape): outline of 250 points within 278.55,62.62 286.55,70.62
GND on T07 (solid shape): outline of 264 points within 2.6,140.78 10.86,149.03
GND on T07 (solid shape): outline of 3775 points within 0.51,0.51 312.99,215.32
GND on G08 (solid shape): outline of 13518 points within 0.51,0.51 312.99,215.32
GND on P09 (solid shape): outline of 250 points within 278.55,62.62 286.55,70.62
GND on P09 (solid shape): outline of 267 points within 20.61,183.69 30.61,193.69
GND on P09 (solid shape): outline of 267 points within 48.7,172.55 58.7,182.55
GND on P09 (solid shape): outline of 267 points within 59.26,54.49 69.26,64.5
GND on P09 (solid shape): outline of 267 points within 93.3,107.39 103.3,117.4
GND on P09 (solid shape): outline of 267 points within 156.7,160.6 166.7,170.6
GND on P09 (solid shape): outline of 267 points within 191.92,65.69 201.92,75.69
GND on P09 (solid shape): outline of 267 points within 248.7,172.55 258.7,182.55
GND on P09 (solid shape): outline of 3103 points within 0.51,0.51 312.99,215.32
GND on P10 (solid shape): outline of 247 points within 21.62,184.71 29.59,192.68
GND on P10 (solid shape): outline of 247 points within 49.72,173.57 57.68,181.54
GND on P10 (solid shape): outline of 247 points within 60.28,55.51 68.25,63.48
GND on P10 (solid shape): outline of 247 points within 94.31,108.41 102.28,116.38
GND on P10 (solid shape): outline of 247 points within 157.72,161.61 165.68,169.58
GND on P10 (solid shape): outline of 247 points within 192.94,66.7 200.91,74.67
GND on P10 (solid shape): outline of 247 points within 249.72,173.57 257.68,181.54
GND on P10 (solid shape): outline of 250 points within 278.55,62.62 286.55,70.62
GND on P10 (solid shape): outline of 264 points within 2.6,140.78 10.86,149.03
GND on P10 (solid shape): outline of 266 points within 20.52,183.6 30.7,193.78
GND on P10 (solid shape): outline of 266 points within 48.64,172.49 58.76,182.62
GND on P10 (solid shape): outline of 267 points within 170.92,204.86 180.92,214.86
GND on P10 (solid shape): outline of 279 points within 247.79,171.64 259.61,183.46
GND on P10 (solid shape): outline of 190 points within 211.57,121.89 234.95,140.97
GND on P10 (solid shape): outline of 128525 points within 0.51,0.51 312.99,215.32
GND on G11 (solid shape): outline of 13515 points within 0.51,0.51 312.99,215.32
GND on P12 (solid shape): outline of 263 points within 246.13,171.05 259.66,183.51
GND on P12 (solid shape): outline of 267 points within 20.61,183.69 30.61,193.69
GND on P12 (solid shape): outline of 267 points within 48.7,172.55 58.7,182.55
GND on P12 (solid shape): outline of 267 points within 59.26,54.49 69.26,64.5
GND on P12 (solid shape): outline of 267 points within 156.7,160.6 166.7,170.6
GND on P12 (solid shape): outline of 267 points within 191.92,65.69 201.92,75.69
GND on P12 (solid shape): outline of 267 points within 248.7,172.55 258.7,182.55
GND on P12 (solid shape): outline of 275 points within 92.91,107 103.69,117.79
GND on P12 (solid shape): outline of 275 points within 299.53,115.81 310.31,126.59
GND on P12 (solid shape): outline of 278 points within 19.72,182.8 31.5,194.58
GND on P12 (solid shape): outline of 281 points within 47.63,171.48 59.77,183.62
GND on P12 (solid shape): outline of 283 points within 155.49,159.39 167.91,171.81
GND on P12 (solid shape): outline of 284 points within 190.65,64.41 203.2,76.96
GND on P12 (solid shape): outline of 6437 points within 0.51,0.51 312.99,215.32
GND on G13 (solid shape): outline of 13528 points within 0.51,0.51 312.99,215.32
GND on T14 (solid shape): outline of 247 points within 21.62,184.71 29.59,192.68
GND on T14 (solid shape): outline of 247 points within 49.72,173.57 57.68,181.54
GND on T14 (solid shape): outline of 247 points within 60.28,55.51 68.25,63.48
GND on T14 (solid shape): outline of 247 points within 94.31,108.41 102.28,116.38
GND on T14 (solid shape): outline of 247 points within 157.72,161.61 165.68,169.58
GND on T14 (solid shape): outline of 247 points within 192.94,66.7 200.91,74.67
GND on T14 (solid shape): outline of 247 points within 249.72,173.57 257.68,181.54
GND on T14 (solid shape): outline of 250 points within 278.55,62.62 286.55,70.62
GND on T14 (solid shape): outline of 264 points within 2.6,140.78 10.86,149.03
GND on T14 (solid shape): outline of 3709 points within 0.51,0.51 312.99,215.32
GND on G15 (solid shape): outline of 13529 points within 0.51,0.51 312.99,215.32
GND on T16 (solid shape): outline of 247 points within 21.62,184.71 29.59,192.68
GND on T16 (solid shape): outline of 247 points within 49.72,173.57 57.68,181.54
GND on T16 (solid shape): outline of 247 points within 60.28,55.51 68.25,63.48
GND on T16 (solid shape): outline of 247 points within 94.31,108.41 102.28,116.38
GND on T16 (solid shape): outline of 247 points within 157.72,161.61 165.68,169.58
GND on T16 (solid shape): outline of 247 points within 192.94,66.7 200.91,74.67
GND on T16 (solid shape): outline of 247 points within 249.72,173.57 257.68,181.54
GND on T16 (solid shape): outline of 250 points within 278.55,62.62 286.55,70.62
GND on T16 (solid shape): outline of 264 points within 2.6,140.78 10.86,149.03
GND on T16 (solid shape): outline of 3867 points within 0.51,0.51 312.99,215.32
GND on G17 (solid shape): outline of 13523 points within 0.51,0.51 312.99,215.32
GND on T18 (solid shape): outline of 247 points within 21.62,184.71 29.59,192.68
GND on T18 (solid shape): outline of 247 points within 49.72,173.57 57.68,181.54
GND on T18 (solid shape): outline of 247 points within 60.28,55.51 68.25,63.48
GND on T18 (solid shape): outline of 247 points within 94.31,108.41 102.28,116.38
GND on T18 (solid shape): outline of 247 points within 157.72,161.61 165.68,169.58
GND on T18 (solid shape): outline of 247 points within 192.94,66.7 200.91,74.67
GND on T18 (solid shape): outline of 247 points within 249.72,173.57 257.68,181.54
GND on T18 (solid shape): outline of 250 points within 278.55,62.62 286.55,70.62
GND on T18 (solid shape): outline of 264 points within 2.6,140.78 10.86,149.03
GND on T18 (solid shape): outline of 3773 points within 0.51,0.51 312.99,215.32
GND on G19 (solid shape): outline of 14250 points within 0.51,0.51 312.99,215.32
P1V0 on TOP (solid shape): 156.53,107.33 156.53,105.29 156.22,104.97 153.02,104.97 152.87,104.82 152.87,104.76 152.87,104.76 152.87,98.01 152.61,97.75 149.04,97.75 148.91,97.89 148.91,107.4 149.14,107.64 156.23,107.64
P1V0 on TOP (solid shape): 176.77,183.97 176.77,170.94 176.41,170.58 175.79,170.58 175.69,170.64 175.72,170.75 175.41,171.55 175.1,170.75 175.13,170.64 175.03,170.58 166.24,170.58 164.33,172.49 164.33,183.65 164.85,184.17 175.41,184.17 175.42,184.17 176.57,184.17
P1V0 on BOTTOM (solid shape): 136.99,109.83 136.99,108.41 136.82,108.24 130.85,108.24 130.73,108.36 130.73,109.95 130.95,110.17 136.65,110.17
P1V0 on BOTTOM (solid shape): 142.3,89.15 142.3,86.47 142.13,86.3 138.55,86.3 138.45,86.4 138.45,89.21 138.59,89.35 142.11,89.35
P1V0 on BOTTOM (solid shape): 144.58,112.92 144.58,106.76 144.25,106.43 141.17,106.43 141.02,106.58 141.02,112.88 141.31,113.17 144.33,113.17
P1V0 on BOTTOM (solid shape): 193.24,122.03 193.24,121.2 193.16,121.12 190.26,121.12 190.08,121.3 190.08,122.06 190.23,122.2 193.07,122.2
P1V0 on BOTTOM (solid shape): 250.21,113.94 250.21,110.19 249.71,109.69 241.02,109.69 240.28,110.43 240.28,114.19 240.63,114.54 249.6,114.54
P1V0 on BOTTOM (solid shape): 283.28,107.36 283.28,105.37 283.17,105.26 277.94,105.26 277.78,105.41 277.78,107.13 278.08,107.43 283.2,107.43
P1V0 on BOTTOM (solid shape): 291.85,106.68 291.85,104.9 291.69,104.75 286.54,104.75 286.26,105.03 286.26,106.55 286.64,106.93 291.59,106.93
P1V0 on BOTTOM (solid shape): 176.77,183.97 176.77,172.27 176.41,171.91 173.65,171.91 172.32,170.58 166.25,170.58 164.33,172.5 164.33,183.65 164.85,184.17 175.41,184.17 175.42,184.17 176.57,184.17
P1V0 on BOTTOM (solid shape): 191.58,117.09 191.63,117.09 191.63,117.17 193.34,117.17 193.37,117.14 193.37,115.32 193.03,114.98 192.14,114.98 192.13,115.01 191.85,115.33 191.42,115.27 191.32,115.27 191.26,115.36 191.26,117.05 191.39,117.17 191.58,117.17
P1V0 on BOTTOM (solid shape): outline of 153 points within 239.43,86.15 264.87,100.46
P1V0 on BOTTOM (solid shape): outline of 224 points within 186.58,77.05 217.42,92.83
P1V0 on P10 (solid shape): outline of 42915 points within 167.49,78.7 287.32,184.19
P1V0 on P12 (solid shape): outline of 6761 points within 79.2,61.22 287.63,184.85
P1V0_DDR on TOP (solid shape): 188.85,197.68 188.85,196.21 189.52,195.55 189.52,180.51 189.2,180.19 183.82,180.19 183.26,180.75 183.26,194.18 184.36,195.28 186.36,195.28 187.13,196.05 187.13,197.62 187.37,197.86 188.67,197.86
P1V0_DDR on BOTTOM (solid shape): 188.85,197.68 188.85,194.46 188.75,194.36 187.28,194.36 187.13,194.51 187.13,197.62 187.37,197.86 188.67,197.86
P1V0_DDR on T03 (solid shape): outline of 8430 points within 183.51,122.48 224.45,182.97
P1V0_DDR_AGND on TOP (solid shape): 196.11,205.18 196.67,205.18 196.67,205.21 197.32,205.21 197.46,205.07 197.46,204.72 197.28,204.53 197.03,204.53 196.7,204.21 196.7,203.73 196.69,203.71 195.45,203.71 195.29,203.88 195.29,204.78 195.67,205.16 195.74,205.18 195.79,205.21 196.11,205.21
P1V0_DDR_SW on TOP (solid shape): 194.61,211.81 194.61,207.51 192.79,205.69 192.79,205.34 192.75,205.3 192.15,205.3 191.34,206.12 191.34,211.74 191.62,212.03 194.39,212.03
P1V0_DDR_VIN on TOP (solid shape): 193.37,202.13 193.37,202.02 195.28,200.11 195.28,194.66 195.14,194.52 192.49,194.52 192.14,194.86 192.14,202.11 192.29,202.26 193.24,202.26
P1V0_DDR_VIN on BOTTOM (solid shape): 193.97,201.42 194.31,201.33 194.65,201.42 195.07,201.42 195.33,201.15 195.33,196.27 195.63,195.98 195.63,194.38 195.12,193.87 192.32,193.87 192.14,194.05 192.14,201.34 192.21,201.42
P1V0_DDR_VOUT on TOP (solid shape): 188.54,211.18 188.54,206.57 187.83,205.86 186.52,205.86 186.29,205.63 186.29,195.98 186.08,195.77 183.81,195.77 183.43,196.14 183.43,210.88 183.86,211.31 188.42,211.31
P1V0_DDR_VOUT on BOTTOM (solid shape): 186.29,204.9 186.29,195.99 186.06,195.77 183.81,195.77 183.43,196.15 183.43,204.87 184.02,205.47 185.72,205.47
P1V0_SW on TOP (solid shape): 156.98,186.13 160.78,186.13 161.03,186.39 162.07,186.39 162.12,186.34 162.12,184.7 161.98,184.56 160.84,184.56 160.49,184.21 160.49,177.45 159.95,176.91 154.75,176.91 154.35,177.31 154.35,184.63 154.65,184.94 154.65,185.82 154.66,185.82 154.66,186.41 154.72,186.47 156.65,186.47
P1V0_VIN on TOP (solid shape): 158.53,204.25 158.53,191.24 158.05,190.76 156.88,190.76 156.68,190.56 154.65,190.56 154.65,191.66 154.62,191.7 154.62,191.83 154.15,192.3 154.15,196.04 153.36,196.83 151.77,196.83 151.49,197.11 151.49,204.19 151.8,204.49 158.28,204.49
P1V0_VIN on BOTTOM (solid shape): 158.53,204.25 158.53,191.22 158.45,191.14 155.18,191.14 154.15,192.17 154.15,196.04 153.87,196.32 151.93,196.32 151.49,196.77 151.49,204.19 151.8,204.49 158.28,204.49
P1V2 on TOP (solid shape): 259.18,168.96 259.18,162.91 258.85,162.58 253.06,162.58 252.88,162.76 252.88,168.61 253.44,169.17 258.97,169.17
P1V2 on TOP (solid shape): 243.38,211.18 243.38,206.57 242.67,205.86 241.37,205.86 241.13,205.63 241.13,197.05 241,196.91 237.98,196.91 237.67,197.21 237.67,210.49 238.49,211.31 243.26,211.31
P1V2 on TOP (solid shape): 261.76,150.95 261.76,150.94 261.77,150.94 261.85,150.86 262.38,150.86 262.38,150.86 262.61,150.86 262.7,150.77 262.7,150.42 262.47,150.19 262.47,148.61 262.07,148.21 258.75,148.21 258.62,148.34 258.62,150.17 258.98,150.53 259.82,150.53 259.82,150.55 260.24,150.98 261.73,150.98
P1V2 on BOTTOM (solid shape): 241.13,204.28 241.13,197.05 241,196.91 237.98,196.91 237.67,197.21 237.67,204.31 237.93,204.56 240.85,204.56
P1V2 on BOTTOM (solid shape): 262.36,150.68 262.36,148.51 262.05,148.2 260.54,148.2 260.3,148.44 260.3,149.5 260.22,149.58 260.22,150.75 260.44,150.96 262.07,150.96
P1V2 on BOTTOM (solid shape): outline of 1359 points within 225.11,154.28 237.49,161.61
P1V2 on BOTTOM (solid shape): outline of 1895 points within 254.14,117.63 265.71,130.61
P1V2 on BOTTOM (solid shape): outline of 1891 points within 236.16,154.28 259.79,169.17
P1V2 on BOTTOM (solid shape): outline of 4619 points within 206.19,152.76 236.38,169.94
P1V2 on T03 (solid shape): outline of 36604 points within 197.46,115.31 270.59,204.33
P1V2_AGND on TOP (solid shape): 251.96,205.17 252.32,205.17 252.41,205.07 252.41,204.55 252.3,204.43 251.77,204.43 251.54,204.21 251.54,203.73 251.53,203.71 250.29,203.71 250.13,203.88 250.13,204.73 250.48,205.09 250.5,205.09 250.59,205.12 250.66,205.17 251.96,205.17
P1V2_SW on TOP (solid shape): 249.82,211.37 249.82,207.84 247.69,205.72 247.69,205.65 247.56,205.52 247.56,205.34 246.38,205.34 246.18,205.54 246.18,211.36 246.3,211.48 249.71,211.48
P1V2_VDDQ on TOP (solid shape): 194.23,167.57 194.23,163.61 194.06,163.44 189.95,163.44 189.77,163.63 189.77,167.57 190.04,167.83 193.97,167.83
P1V2_VDDQ on TOP (solid shape): 251.52,167.53 251.52,162.66 252.22,161.96 254.11,161.96 254.37,161.7 254.37,158.41 254.07,158.1 248.8,158.1 248.2,158.71 248.2,167.49 248.56,167.86 251.19,167.86
P1V2_VDDQ on BOTTOM (solid shape): 257.4,162.9 257.4,158.68 256.96,158.24 252.32,158.24 252.03,158.52 252.03,162.45 252.84,163.25 257.05,163.25
P1V2_VDDQ on BOTTOM (solid shape): outline of 10922 points within 194.58,122.79 240.87,147.65
P1V2_VDDQ on P12 (solid shape): outline of 253 points within 192.1,113.09 271.78,176.24
P1V2_VIN on TOP (solid shape): 248.21,202.21 248.21,202.02 250.12,200.11 250.12,194.66 249.98,194.52 247.33,194.52 246.98,194.86 246.98,202.11 247.13,202.26 248.16,202.26
P1V2_VIN on BOTTOM (solid shape): 249.02,201.42 249.3,201.35 249.59,201.41 249.6,201.42 249.91,201.42 250.17,201.15 250.17,194.68 250.03,194.55 247.29,194.55 246.98,194.85 246.98,201.34 247.05,201.42
P1V05_PECI on BOTTOM (solid shape): outline of 305 points within 57.51,105.95 60.68,108.28
P1V05_PECI on T07 (solid shape): outline of 547 points within 51.88,103.26 58.25,106.98
P1V8 on TOP (solid shape): 7.19,84.57 7.19,79.46 6.96,79.23 5.56,79.23 5.3,79.5 5.3,84.64 5.39,84.73 7.03,84.73
P1V8 on TOP (solid shape): 181,140.76 181,138.22 180.91,138.13 180.64,138.2 180.38,138.11 179.05,138.11 178.88,138.28 178.88,140.71 179.08,140.91 180.85,140.91
P1V8 on TOP (solid shape): 206.94,206.29 206.94,189.49 188.91,171.46 188.91,165.06 186.72,162.87 186.69,162.88 186.26,162.76 186.14,162.33 186.15,162.3 184.9,161.06 177.67,161.06 172.51,155.9 172.51,150.61 172.07,150.17 168.27,150.17 167.83,150.62 167.83,163.45 169.98,165.6 180.88,165.6 183.28,168 183.28,173.36 202.82,192.9 202.82,206.89 203.05,207.12 206.11,207.12
P1V8 on BOTTOM (solid shape): 186.05,104.78 186.05,103.32 185.77,103.04 183.42,103.04 183.23,103.23 183.23,104.63 183.41,104.82 186.02,104.82
P1V8 on BOTTOM (solid shape): 191.11,129.83 191.11,128.29 191.05,128.24 189.01,128.24 188.87,128.37 188.87,129.78 189.06,129.97 190.97,129.97
P1V8 on BOTTOM (solid shape): 192.64,137.99 192.64,136.68 192.57,136.61 190.62,136.61 190.52,136.71 190.52,137.98 190.67,138.14 192.5,138.14
P1V8 on BOTTOM (solid shape): 193.06,113.24 193.06,111.4 193,111.34 189.6,111.34 189.41,111.54 189.41,113.11 189.56,113.27 193.03,113.27
P1V8 on BOTTOM (solid shape): 193.6,134.25 193.6,132.2 193.56,132.17 191.51,132.17 191.33,132.35 191.33,134.15 191.51,134.33 193.51,134.33
P1V8 on BOTTOM (solid shape): 206.94,202.17 206.94,194.54 206.85,194.45 204.37,194.45 204.12,194.7 204.12,202.14 204.33,202.35 206.76,202.35
P1V8 on BOTTOM (solid shape): 240.63,117 240.63,115.98 240.45,115.79 237.12,115.79 237.09,115.82 237.09,117.01 237.29,117.21 240.42,117.21
P1V8 on BOTTOM (solid shape): 166.76,139.64 166.76,138.44 166.57,138.25 165.39,138.25 164.8,138.85 163.18,138.85 163.05,138.97 163.05,139.95 163.14,140.04 166.35,140.04
P1V8 on BOTTOM (solid shape): 193.78,131.64 193.78,130.84 193.72,130.78 191.54,130.78 191.23,130.47 190.25,130.47 190.15,130.57 190.15,131.69 190.26,131.8 193.62,131.8
P1V8 on BOTTOM (solid shape): 239.65,122.4 239.65,121.13 239.54,121.01 237.46,121.01 237.34,121.13 235.32,121.13 235.28,121.16 235.28,122.4 235.42,122.54 239.51,122.54
P1V8 on T05 (solid shape): outline of 1126 points within 178.91,130.83 193.14,143.06
P1V8 on P10 (solid shape): outline of 22558 points within 6.07,72.98 240.9,155.66
P1V8_DDR_AVDD on TOP (solid shape): 183.11,139.17 183.11,135 182.95,134.84 181.84,134.84 181.68,135 181.68,139.52 182.77,139.52
P1V8_DDR_AVDD on T05 (solid shape): outline of 6009 points within 203.96,121.41 224.66,128.91
P1V8_DDR_AVDD on P10 (solid shape): outline of 7045 points within 182.27,120.03 223.52,137.46
P1V8_SW on TOP (solid shape): 211.77,206.47 211.77,205.6 211.94,205.43 213.31,205.43 213.42,205.33 213.42,204.84 213.38,204.81 212.13,204.81 210.9,203.57 208.9,203.57 208.84,203.64 208.84,207.04 208.89,207.09 211.15,207.09
P1V8_VIN on TOP (solid shape): 214.01,204.38 214.01,203.18 214.01,203.18 214.01,202.96 214.19,202.79 214.54,202.79 216.02,201.31 216.02,197.08 215.92,196.98 213.91,196.98 213.79,197.1 213.79,200.78 213.45,201.12 213.45,202.66 213.61,202.82 213.61,204.37 213.63,204.38 214.01,204.38
P1V8_VIN on BOTTOM (solid shape): 216.24,201.09 216.24,195.95 216.11,195.81 213.98,195.81 213.79,196 213.79,200.78 213.45,201.12 213.45,202.17 213.6,202.32 215,202.32
P1V25 on TOP (solid shape): 285.17,113.93 285.17,112.63 285.4,112.39 292.06,112.39 292.06,112.36 292.98,112.36 292.98,112.39 293.7,112.39 293.84,112.26 293.84,110.39 293.64,110.19 280.86,110.19 279.72,111.33 279.72,114.52 279.85,114.65 284.46,114.65
P1V25 on BOTTOM (solid shape): 292.06,112.36 292.98,112.36 292.98,112.39 293.7,112.39 293.84,112.26 293.84,110.39 293.64,110.19 286.1,110.19 285.91,110.39 285.91,112.18 286.12,112.39 292.06,112.39
