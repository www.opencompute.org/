# Allegro board T99O089T00_025_20180609.brd (continued)
## Nets (continued)
XFI_MAC_TO_PHY1_DP4: U1.D33(NIFE_TX_23_P) U23.G5(XFI4_IP)
XFI_MAC_TO_PHY1_DP5: U1.B32(NIFE_TX_22_P) U23.E4(XFI5_IP)
XFI_MAC_TO_PHY1_DP6: U1.D31(NIFE_TX_21_P) U23.C5(XFI6_IP)
XFI_MAC_TO_PHY1_DP7: U1.B30(NIFE_TX_20_P) U23.A4(XFI7_IP)
XFI_MAC_TO_SFP_DN8: CJ8.ET19(ET_TX_NDAT) U1.C29(NIFE_TX_19_N)
XFI_MAC_TO_SFP_DN9: CJ8.EL19(EL_TX_NDAT) U1.A28(NIFE_TX_18_N)
XFI_MAC_TO_SFP_DN10: CJ8.FT19(FT_TX_NDAT) U1.C27(NIFE_TX_17_N)
XFI_MAC_TO_SFP_DN11: CJ8.FL19(FL_TX_NDAT) U1.A26(NIFE_TX_16_N)
XFI_MAC_TO_SFP_DN12: CJ8.GT19(GT_TX_NDAT) U1.A8(NIFE_TX_32_N)
XFI_MAC_TO_SFP_DN13: CJ8.GL19(GL_TX_NDAT) U1.C7(NIFE_TX_33_N)
XFI_MAC_TO_SFP_DN14: CJ8.HT19(HT_TX_NDAT) U1.A6(NIFE_TX_34_N)
XFI_MAC_TO_SFP_DN15: CJ8.HL19(HL_TX_NDAT) U1.C5(NIFE_TX_35_N)
XFI_MAC_TO_SFP_DN16: CJ9.AT19(AT_TX_NDAT) U1.A4(NIFE_TX_36_N)
XFI_MAC_TO_SFP_DN17: CJ9.AB19(AB_TX_NDAT) U1.C3(NIFE_TX_37_N)
XFI_MAC_TO_SFP_DN18: CJ9.BT19(BT_TX_NDAT) U1.A2(NIFE_TX_38_N)
XFI_MAC_TO_SFP_DN19: CJ9.BB19(BB_TX_NDAT) U1.C1(NIFE_TX_39_N)
XFI_MAC_TO_SFP_DN20: CJ9.CT19(CT_TX_NDAT) U1.A24(NIF_TX_15_N)
XFI_MAC_TO_SFP_DN21: CJ9.CB19(CB_TX_NDAT) U1.C23(NIF_TX_14_N)
XFI_MAC_TO_SFP_DN22: CJ9.DT19(DT_TX_NDAT) U1.A22(NIF_TX_13_N)
XFI_MAC_TO_SFP_DN23: CJ9.DB19(DB_TX_NDAT) U1.C21(NIF_TX_12_N)
XFI_MAC_TO_SFP_DN24: CJ9.ET19(ET_TX_NDAT) U1.A20(NIF_TX_11_N)
XFI_MAC_TO_SFP_DN25: CJ9.EB19(EB_TX_NDAT) U1.C19(NIF_TX_10_N)
XFI_MAC_TO_SFP_DN26: CJ9.FT19(FT_TX_NDAT) U1.A18(NIF_TX_09_N)
XFI_MAC_TO_SFP_DN27: CJ9.FB19(FB_TX_NDAT) U1.C17(NIF_TX_08_N)
XFI_MAC_TO_SFP_DP8: CJ8.ET18(ET_TX_DAT) U1.D29(NIFE_TX_19_P)
XFI_MAC_TO_SFP_DP9: CJ8.EL18(EL_TX_DAT) U1.B28(NIFE_TX_18_P)
XFI_MAC_TO_SFP_DP10: CJ8.FT18(FT_TX_DAT) U1.D27(NIFE_TX_17_P)
XFI_MAC_TO_SFP_DP11: CJ8.FL18(FL_TX_DAT) U1.B26(NIFE_TX_16_P)
XFI_MAC_TO_SFP_DP12: CJ8.GT18(GT_TX_DAT) U1.B8(NIFE_TX_32_P)
XFI_MAC_TO_SFP_DP13: CJ8.GL18(GL_TX_DAT) U1.D7(NIFE_TX_33_P)
XFI_MAC_TO_SFP_DP14: CJ8.HT18(HT_TX_DAT) U1.B6(NIFE_TX_34_P)
XFI_MAC_TO_SFP_DP15: CJ8.HL18(HL_TX_DAT) U1.D5(NIFE_TX_35_P)
XFI_MAC_TO_SFP_DP16: CJ9.AT18(AT_TX_DAT) U1.B4(NIFE_TX_36_P)
XFI_MAC_TO_SFP_DP17: CJ9.AB18(AB_TX_DAT) U1.D3(NIFE_TX_37_P)
XFI_MAC_TO_SFP_DP18: CJ9.BT18(BT_TX_DAT) U1.B2(NIFE_TX_38_P)
XFI_MAC_TO_SFP_DP19: CJ9.BB18(BB_TX_DAT) U1.D1(NIFE_TX_39_P)
XFI_MAC_TO_SFP_DP20: CJ9.CT18(CT_TX_DAT) U1.B24(NIF_TX_15_P)
XFI_MAC_TO_SFP_DP21: CJ9.CB18(CB_TX_DAT) U1.D23(NIF_TX_14_P)
XFI_MAC_TO_SFP_DP22: CJ9.DT18(DT_TX_DAT) U1.B22(NIF_TX_13_P)
XFI_MAC_TO_SFP_DP23: CJ9.DB18(DB_TX_DAT) U1.D21(NIF_TX_12_P)
XFI_MAC_TO_SFP_DP24: CJ9.ET18(ET_TX_DAT) U1.B20(NIF_TX_11_P)
XFI_MAC_TO_SFP_DP25: CJ9.EB18(EB_TX_DAT) U1.D19(NIF_TX_10_P)
XFI_MAC_TO_SFP_DP26: CJ9.FT18(FT_TX_DAT) U1.B18(NIF_TX_09_P)
XFI_MAC_TO_SFP_DP27: CJ9.FB18(FB_TX_DAT) U1.D17(NIF_TX_08_P)
XFI_PHY1_TO_MAC_DN0: U1.H37(NIFE_RX_24_N) U23.T2(XFI0_ON)
XFI_PHY1_TO_MAC_DN1: U1.H35(NIFE_RX_26_N) U23.P1(XFI1_ON)
XFI_PHY1_TO_MAC_DN2: U1.F36(NIFE_RX_25_N) U23.M2(XFI2_ON)
XFI_PHY1_TO_MAC_DN3: U1.F34(NIFE_RX_27_N) U23.J1(XFI3_ON)
XFI_PHY1_TO_MAC_DN4: U1.J33(NIFE_RX_23_N) U23.G1(XFI4_ON)
XFI_PHY1_TO_MAC_DN5: U1.G32(NIFE_RX_22_N) U23.E2(XFI5_ON)
XFI_PHY1_TO_MAC_DN6: U1.J31(NIFE_RX_21_N) U23.C1(XFI6_ON)
XFI_PHY1_TO_MAC_DN7: U1.G30(NIFE_RX_20_N) U23.A2(XFI7_ON)
XFI_PHY1_TO_MAC_DP0: U1.J37(NIFE_RX_24_P) U23.T1(XFI0_OP)
XFI_PHY1_TO_MAC_DP1: U1.J35(NIFE_RX_26_P) U23.P2(XFI1_OP)
XFI_PHY1_TO_MAC_DP2: U1.G36(NIFE_RX_25_P) U23.M1(XFI2_OP)
XFI_PHY1_TO_MAC_DP3: U1.G34(NIFE_RX_27_P) U23.K1(XFI3_OP)
XFI_PHY1_TO_MAC_DP4: U1.H33(NIFE_RX_23_P) U23.G2(XFI4_OP)
XFI_PHY1_TO_MAC_DP5: U1.F32(NIFE_RX_22_P) U23.E1(XFI5_OP)
XFI_PHY1_TO_MAC_DP6: U1.H31(NIFE_RX_21_P) U23.C2(XFI6_OP)
XFI_PHY1_TO_MAC_DP7: U1.F30(NIFE_RX_20_P) U23.A1(XFI7_OP)
XFI_SFP_TO_MAC_DN8: CJ8.ET12(ET_RX_NDAT) U1.J29(NIFE_RX_19_N)
XFI_SFP_TO_MAC_DN9: CJ8.EL12(EL_RX_NDAT) U1.G28(NIFE_RX_18_N)
XFI_SFP_TO_MAC_DN10: CJ8.FT12(FT_RX_NDAT) U1.J27(NIFE_RX_17_N)
XFI_SFP_TO_MAC_DN11: CJ8.FL12(FL_RX_NDAT) U1.G26(NIFE_RX_16_N)
XFI_SFP_TO_MAC_DN12: CJ8.GT12(GT_RX_NDAT) U1.G8(NIFE_RX_32_N)
XFI_SFP_TO_MAC_DN13: CJ8.GL12(GL_RX_NDAT) U1.J7(NIFE_RX_33_N)
XFI_SFP_TO_MAC_DN14: CJ8.HT12(HT_RX_NDAT) U1.G6(NIFE_RX_34_N)
XFI_SFP_TO_MAC_DN15: CJ8.HL12(HL_RX_NDAT) U1.J5(NIFE_RX_35_N)
XFI_SFP_TO_MAC_DN16: CJ9.AT12(AT_RX_NDAT) U1.G4(NIFE_RX_36_N)
XFI_SFP_TO_MAC_DN17: CJ9.AB12(AB_RX_NDAT) U1.J3(NIFE_RX_37_N)
XFI_SFP_TO_MAC_DN18: CJ9.BT12(BT_RX_NDAT) U1.G2(NIFE_RX_38_N)
XFI_SFP_TO_MAC_DN19: CJ9.BB12(BB_RX_NDAT) U1.J1(NIFE_RX_39_N)
XFI_SFP_TO_MAC_DN20: CJ9.CT12(CT_RX_NDAT) U1.G24(NIF_RX_15_N)
XFI_SFP_TO_MAC_DN21: CJ9.CB12(CB_RX_NDAT) U1.K23(NIF_RX_14_N)
XFI_SFP_TO_MAC_DN22: CJ9.DT12(DT_RX_NDAT) U1.G22(NIF_RX_13_N)
XFI_SFP_TO_MAC_DN23: CJ9.DB12(DB_RX_NDAT) U1.K21(NIF_RX_12_N)
XFI_SFP_TO_MAC_DN24: CJ9.ET12(ET_RX_NDAT) U1.G20(NIF_RX_11_N)
XFI_SFP_TO_MAC_DN25: CJ9.EB12(EB_RX_NDAT) U1.K19(NIF_RX_10_N)
XFI_SFP_TO_MAC_DN26: CJ9.FT12(FT_RX_NDAT) U1.G18(NIF_RX_09_N)
XFI_SFP_TO_MAC_DN27: CJ9.FB12(FB_RX_NDAT) U1.K17(NIF_RX_08_N)
XFI_SFP_TO_MAC_DP8: CJ8.ET13(ET_RX_DAT) U1.H29(NIFE_RX_19_P)
XFI_SFP_TO_MAC_DP9: CJ8.EL13(EL_RX_DAT) U1.F28(NIFE_RX_18_P)
XFI_SFP_TO_MAC_DP10: CJ8.FT13(FT_RX_DAT) U1.H27(NIFE_RX_17_P)
XFI_SFP_TO_MAC_DP11: CJ8.FL13(FL_RX_DAT) U1.F26(NIFE_RX_16_P)
XFI_SFP_TO_MAC_DP12: CJ8.GT13(GT_RX_DAT) U1.F8(NIFE_RX_32_P)
XFI_SFP_TO_MAC_DP13: CJ8.GL13(GL_RX_DAT) U1.H7(NIFE_RX_33_P)
XFI_SFP_TO_MAC_DP14: CJ8.HT13(HT_RX_DAT) U1.F6(NIFE_RX_34_P)
XFI_SFP_TO_MAC_DP15: CJ8.HL13(HL_RX_DAT) U1.H5(NIFE_RX_35_P)
XFI_SFP_TO_MAC_DP16: CJ9.AT13(AT_RX_DAT) U1.F4(NIFE_RX_36_P)
XFI_SFP_TO_MAC_DP17: CJ9.AB13(AB_RX_DAT) U1.H3(NIFE_RX_37_P)
XFI_SFP_TO_MAC_DP18: CJ9.BT13(BT_RX_DAT) U1.F2(NIFE_RX_38_P)
XFI_SFP_TO_MAC_DP19: CJ9.BB13(BB_RX_DAT) U1.H1(NIFE_RX_39_P)
XFI_SFP_TO_MAC_DP20: CJ9.CT13(CT_RX_DAT) U1.F24(NIF_RX_15_P)
XFI_SFP_TO_MAC_DP21: CJ9.CB13(CB_RX_DAT) U1.J23(NIF_RX_14_P)
XFI_SFP_TO_MAC_DP22: CJ9.DT13(DT_RX_DAT) U1.F22(NIF_RX_13_P)
XFI_SFP_TO_MAC_DP23: CJ9.DB13(DB_RX_DAT) U1.J21(NIF_RX_12_P)
XFI_SFP_TO_MAC_DP24: CJ9.ET13(ET_RX_DAT) U1.F20(NIF_RX_11_P)
XFI_SFP_TO_MAC_DP25: CJ9.EB13(EB_RX_DAT) U1.J19(NIF_RX_10_P)
XFI_SFP_TO_MAC_DP26: CJ9.FT13(FT_RX_DAT) U1.F18(NIF_RX_09_P)
XFI_SFP_TO_MAC_DP27: CJ9.FB13(FB_RX_DAT) U1.J17(NIF_RX_08_P)
XTAL_SHIELD: U135.4(X1) U135.7(X2) Y1.2 Y1.4 Y3.2 Y3.4
N58331367: PC162.1 PR186.2
N61790231: R70.1 R1446.1 U1.AA34(GPIO0)
N62588129: R902.1 U65.16(SC5)
N62588131: R903.1 U65.15(SD5)
N62588133: R904.1 U65.14(SC4)
N62588135: R905.1 U65.13(SD4)
N62588137: R901.1 U65.17(SD6)
N62588141: R900.1 U65.18(SC6)
N62588143: R899.1 U65.19(SD7)
N62588145: R898.1 U65.20(SC7)
N64116787: PC21.1 PR57.2
N64116818: PC29.1 PR60.2
N64130082: PC202.1 PR219.2
N64130635: PC193.1 PR217.2
N64131592: PC225.1 PR241.2
N64156557: Q23.5(G2) R1159.1 R1279.1 U196.4(Y)
N65289036: PC182.1 PR200.2
N65289586: PC173.1 PR197.2
N65298280: C887.1 C888.1 C889.1 C890.2 C891.1 C892.2 C893.2 L39.2 U23.C10(DVDD_2) U23.D7(DVDD_0) U23.E10(DVDD_3) U23.J10(DVDD_4) U23.L7(DVDD_1) U23.L10(DVDD_5)
N65308915: C2390.2 R12798.1 U23.H7(V1P8_OUTB) U23.T8(V1P8_OUTA)
N65578454: TP70.1 U154.Y1(GPIOM2/NDSR2/VPIB4)
N65578539: TP82.1 U154.J3(GPIOJ3/SGPMI)
N65578541: TP81.1 U154.K5(GPIOJ2/SGPMO)
N65578543: TP80.1 U154.J4(GPIOJ1/SGPMLD)
N65578545: TP79.1 U154.J5(GPIOJ0/SGPMCK)
N65578551: TP84.1 U154.E13(GPIOG1/SGPSLD)
N65578553: TP83.1 U154.A14(GPIOG0/SGPSCK)
N65578559: TP89.1 U154.C13(GPIOG3/SGPSI1)
N65578561: TP87.1 U154.D13(GPIOG2/SGPSI0)
N65578594: TP69.1 U154.W2(GPIOM1/NDCD2/VPIB3)
N65578597: R12343.1 TP66.1 U154.V3(GPIOM0/NCTS2/VPIB2)
N65578809: TP85.1 U154.C22(GPIOI0/SYSCS#)
N65578811: TP88.1 U154.G18(GPIOI1/SYSCK)
N65578813: TP93.1 U154.C20(GPIOI3/SYSDI)
N65578815: TP91.1 U154.D19(GPIOI2/SYSDO)
N65578822: TP90.1 U154.G19(GPIOI5/SPICK/VBCK)
N65578824: TP86.1 U154.B22(GPIOI4/SPICS0#/VBCS#)
N65578831: TP94.1 U154.E20(GPIOI7/SPIDI/VBDI)
N65578833: TP92.1 U154.C18(GPIOI6/SPIDO/VBDO)
N66144514: PC3.2 PR1.2 PR3.1 PU18.3(NR/FB)
N66148865: PR175.2 PR177.2 PR505.1
N66362177: PC242.1 PR258.2
N66362186: PC250.1 PR259.2
N68263741: R1506.2 R12826.2 U104.3
N68263783: C2398.2 R1503.2
N68263901: C2424.1 R1907.1 R1910.2 U106.1(-IN)
N68909145: D99.2(C) D100.1(A) D101.1(A)
N68909205: D102.1(A) D103.1(A) D104.2(C)
N69918111: U127.62(IC[2]) U127.63(IC[3])
N69962598: R12823.1 X2.3(OUT)
N70148679: J20.2 J20.3 R1408.2 R13036.1 U97.6(IN) U98.6(IN)
N70231673: C2068.2 TP106.1
N70231675: C2067.2 TP105.1
N70233459: BAT1.P1(ANODE_1) BAT1.P3(ANODE_2) R12699.1 R12710.2 R12827.1
N70523844: C2383.2 R1048.1 R1050.2 U129.6(PCLK0_P)
N70523859: C2384.2 R1049.1 R1051.2 U129.7(PCLK0_N)
N70532709: R12485.2 X4.3(OUT)
N70701102: R1663.2 U139.L8(OUT1)
N70702856: R1665.2 U139.H9(DPLL1_LOCK)
N70702870: R1666.2 U139.E9(DPLL3_LOCK)
N70702946: R1672.2 R1790.1 U139.A8(OUT11_POS)
N70702948: R1673.2 R1791.1 U139.B8(OUT11_NEG)
N70703858: C2130.1 C2131.1 U139.D8(CAP3)
N70703933: C2127.1 C2128.1 C2129.1 U139.A9(CAP2) U139.C9(CAP1)
N70911322: C1987.2 C1988.2 C1989.2 L20.1 Q59.2(S) R12903.1 R13007.1
N70911341: R1602.2 U124.8(RESET_N)
N70911374: R1606.2 U124.19(SCL)
N70911387: R1605.2 U124.18(SDA)
N70911689: R1609.1 U124.15(EXTINT1)
N70911698: R12822.2 U124.7(VDD_USB)
N70911719: R1608.2 R1610.1 U124.1(TP2/SAFEBOOT_N)
N70911732: R1607.2 U124.20(TXD)
N70911743: R1603.2 U124.3(TIMEPULSE)
N71580969: R12797.1 R12798.2 U23.J6(VDDP_IN_SYS)
N71581462: R1797.1 U23.A8(SCL_4)
N71581465: R1798.1 U23.B8(SDA_4)
N71581546: R1799.1 U23.C9(SCL_5)
N71581548: R1800.1 U23.D9(SDA_5)
N71581627: R1801.1 U23.F9(SCL_6)
N71581629: R1802.1 U23.E9(SDA_6)
N71581714: R1803.1 U23.B9(SCL_7)
N71581716: R1804.1 U23.A9(SDA_7)
N71581908: R1805.1 U23.P8(SCL_0)
N71581910: R1806.1 U23.N8(SDA_0)
N71581930: R1807.1 U23.K9(SCL_1)
N71581932: R1808.1 U23.L9(SDA_1)
N71581962: R1809.1 U23.N9(SCL_2)
N71581964: R1810.1 U23.M9(SDA_2)
N71582004: R1811.1 U23.P10(SCL_3)
N71582006: R1812.1 U23.N10(SDA_3)
N71582475: C2204.2 U25.A10(REFCLKIN_N)
N71582478: C2205.2 U25.B10(REFCLKIN_P)
N72480397: D61.1(IO1) L140.4 OJ1.U3 R1265.2
N72480405: D61.6(IO4) L140.3 OJ1.U2 R1262.2
N72539929: R12288.2 R12911.1 U151.6(IN) U152.6(IN)
N72619067: C2210.1 C2211.1 L192.1 U144.6(VDD)
N72721990: C2343.2 R16.1 R12439.1 U1.V37(PCIE_REFCLK_P)
N72722010: C2342.2 R16.2 R12440.2 U1.V36(PCIE_REFCLK_N)
N72722462: C2346.2 R4.1 U1.AJ24(DDRA_REFCLK_P)
N72722464: C2347.2 R4.2 U1.AK24(DDRA_REFCLK_N)
N72722466: C2235.2 R5.1 U1.AL18(DDRB_REFCLK_P)
N72722468: C2236.2 R5.2 U1.AK18(DDRB_REFCLK_N)
N72722479: C2237.2 R11.1 U1.AF8(DDRC_REFCLK_P)
N72722481: C2238.2 R11.2 U1.AF7(DDRC_REFCLK_N)
N72722789: C2338.2 U1.V19(C_PLL_REFCLK_P)
N72722791: C2339.2 U1.V18(C_PLL_REFCLK_N)
N72722809: C2341.2 U1.W32(UC_PLL_REFCLK_N)
N72722811: C2340.2 U1.V32(UC_PLL_REFCLK_P)
N72722849: C2344.2 U1.U30(TS_PLL_REFCLK_N)
N72722851: C2345.2 U1.U29(TS_PLL_REFCLK_P)
N72724116: R12442.2 R12448.1 U129.10(Q0_N)
N72724118: R12441.2 R12447.1 U129.9(Q0_P)
N72724120: R12443.2 R12449.1 U129.11(Q1_P)
N72724122: R12444.2 R12450.1 U129.12(Q1_N)
N72724124: R12446.2 R12452.1 U129.13(Q2_P)
N72724126: R12445.2 R12451.1 U129.14(Q2_N)
N72725479: R1891.2 R12453.1 U132.9(Q0_P)
N72725483: R1892.2 R12454.1 U132.10(Q0_N)
N72725491: R1888.1 R1894.2 U132.11(Q1_P)
N72725499: R1893.2 R12455.1 U132.12(Q1_N)
N72725507: R1890.1 R1896.2 U132.13(Q2_P)
N72725515: R1889.1 R1895.2 U132.14(Q2_N)
N72854419: R12460.2 R12462.2 U163.8(SEL1/SDA)
N72854464: R12461.2 R12463.2 U163.9(SEL0/SCL)
N72858167: R12464.1 U163.7(SD/OE)
N72858665: R12783.2 U163.20(OUT1)
N72858667: R12784.2 U163.19(OUT1B)
N72858673: R12787.2 U163.14(OUT3)
N72858675: R12788.2 U163.13(OUT3B)
N72858677: R12786.2 U163.12(OUT4B)
N72858679: R12785.2 U163.11(OUT4)
N72858945: R12465.1 R12466.1 U163.6(CLKSEL)
N72863733: C1690.1 R1075.2 R13080.1
N73047684: R1789.1 R1897.1 U135.13(SDA/SDIO)
N73047688: R1788.1 R1898.1 U135.14(SCLK)
N73047760: R1787.1 U135.38(I2C_SEL)
N73048504: TP95.1 U135.28(L\O\S\_\X\A\X\B\)
N73054323: R1644.1 X7.1(OE)
N73073084: R1899.1 U25.P9(SPTEST_P)
N73073097: R1900.1 U25.R9(SPTEST_N)
N73140692: R1768.2 U110.7(SLR)
N73140789: R1767.2 U121.7(SLR)
N73155937: C2371.2 U85.25(PECLKN)
N73155940: C2370.2 U85.26(PECLKP)
N73156284: C2207.1 C2208.1 L191.1 U143.6(VDD)
N73156286: R12485.1 U143.1(CLK_IN)
N73430665: Q56.2(S) R12699.2
N73437259: TP65.1 U154.B15(GPIOE2/NDSR3)
N73437342: R12720.1 U154.E14(GPIOE4/NDTR3)
N73437369: R12721.1 U154.D14(GPIOE5/NRTS3)
N73438190: R12717.2 U154.D18(GPIOF0/NCTS4)
N73438376: TP68.1 U154.D17(GPIOF3/NRI4/SIOPBO#)
N73438412: R12722.2 U154.E16(GPIOF6/TXD4)
N73438424: R12723.2 U154.C17(GPIOF7/RXD4)
N73540220: Q12.1(G) R12880.1 R12998.1 R13001.2
N73688078: R12752.2 U163.17(OUT2)
N73688080: R12753.2 U163.16(OUT2B)
N73814180: R1073.1 R12982.1 U133.12(Q1_N)
N73814192: R1072.1 R12981.1 U133.11(Q1_P)
N73814194: R1071.1 R12984.1 U133.10(Q0_N)
N73814196: R1070.1 R12983.1 U133.9(Q0_P)
N73978233: R1820.1 R1867.2 U139.B6(OUT12_NEG)
N73978235: R1821.1 R1866.2 U139.A6(OUT12_POS)
N74576889: R12800.2 U139.E12(FRSYNC_8K_1PPS)
N74587656: R12795.2 U139.K5(OUT2)
N74595531: R1674.2 U139.A10(XTAL2_IN)
N74678994: C2325.1 R12416.2 R12420.2 U160.4(VCC)
N74679075: R12428.2 R12430.1 R12434.2
N74680300: PC324.1 PU19.3(VAUX)
N74682687: PC345.2 PR367.2
N74683537: PC335.2 PR360.2
N74685275: PR11.2 PR16.1 PR22.2
N74685283: PC14.1 PR41.2 PR43.2 PR46.1 PR50.1 PR53.1
N74685349: PC16.1 PR44.2 PR47.2 PR52.2 PR54.1 PR55.2 PR330.1
N74685355: PC11.1 PR25.2 PR28.2 PR35.2 PR36.1 PR38.2
N74685391: PC13.1 PR12.2 PR18.2 PR27.2 PR30.2 PR33.2 PR34.1 PR40.1
N74685429: PC12.1 PR26.2 PR29.2 PR31.2 PR32.1 PR39.1
N74685493: PC15.1 PR42.2 PR45.2 PR48.2 PR49.1 PR51.2 PR331.2
N74685644: PC311.1 PR332.2 PR333.2 PR334.1 PR335.1 PR336.1
N74687466: PC69.2 PR104.2
N74687472: PC77.1 PR106.2
N74690205: PC125.2 PR162.2
N74690227: PC137.1 PR164.2
N74690437: PC95.2 PR158.2
N74690459: PC115.1 PR160.2
N75215754: Q5.6(D1) Q23.2(G1) Q23.3(D2) R12824.1 R12829.2
N75216585: Q5.3(D2) Q24.2(G1) Q24.3(D2) R12825.1 R12830.2
N75511000: PR83.2 PR86.2 PR504.1
N75511258: PC60.1 PR94.2
N75511286: PC369.1 PR427.2
N75609157: OJ1.U1 R12980.1
N75767633: R13038.2 U171.4(OUTY)
N75769333: U148.4(OUTY) U164.2(INA)
N76078430: R12904.2 U127.53(TSFS / MTSFS) U127.54(TSIG / MTSIG) U127.55(TSD / MTSD)
N76218842: R1860.1 U149.17(2A4)
N76219186: R1859.2 U149.5(2Y3)
N76219190: R1856.2 U149.12(1Y4)
N76219192: R1858.2 U149.7(2Y2)
N76219194: R1854.2 U149.16(1Y2)
N76219196: R1855.2 U149.14(1Y3)
N76219198: R1857.2 U149.9(2Y1)
N76219205: R1853.2 U149.18(1Y1)
N76225319: C2335.2 U162.16(VPP)
N76226158: R12832.1 U162.8(VBUS)
N76335228: R12909.1 U89.16(FORCEOFF_)
N76335232: R12907.1 R12908.1 U89.12(FORCEON)
N76335242: R12910.2 U89.1(EN_)
N76341793: Q54.3(D) R12911.2
N76342023: Q54.1(G) R12912.1 R12913.1
N76605898: R1671.2 U139.C4(OUT7)
N76605919: R12763.2 U139.A3(OUT6_POS)
N76605922: R12764.2 U139.A4(OUT6_NEG)
N76660295: J1.B54(PCIE0_TX9_P) R12709.2
N77026396: C966.1 C967.1 C975.1 U25.H8(DVDDPSYS_A) U25.J11(DVDDP_A) U25.J13(VREGOUT_A)
N77026454: C968.1 C969.1 C976.1 U25.H6(DVDDPSYS_B) U25.J9(DVDDP_B) U25.K13(VREGOUT_B)
N77607673: C2412.1 T1.2
N77607680: C2414.1 T1.7
N77609229: C2413.2 T1.10
N77609387: C2411.1 T1.15
N77669526: R12927.2 TP22.1
N77675530: R12930.2 U174.4(Q3)
N77675568: R12929.2 U174.3(Q2)
N77675570: R12928.2 U174.2(Q1)
N77675657: R12931.2 U174.8(OE)
N77702972: R12943.2 U175.4(Q3)
N77703021: R12942.2 U175.2(Q1)
N77703106: R12944.2 U175.8(OE)
N77756862: C2427.2 R1904.1 R1905.2
N77757286: C2428.2 R1905.1 R1906.2
N77757443: C2425.2 C2429.2 R1906.1
N77758163: C2425.1 R1903.2
N77758452: R1908.1 R1911.2 R1912.2 U106.3(+IN)
N77758692: R1912.1 U105.2(A) U106.5(OUT)
N77764432: R1913.2 R1914.2 U104.5
N77764752: R1901.2 R1902.2 U107.2(A)
N77829110: R1909.1 U106.6(SHDN)
N79150666: Q58.3(D) R12949.1 U176.19(2\O\E\)
N79150678: R12953.1 U176.12(1Y4)
N79150683: R12951.1 U176.16(1Y2)
N79150686: R12952.1 U176.14(1Y3)
N79150691: R12950.1 U176.18(1Y1)
N79150702: R12957.1 U176.3(2Y4)
N79150705: R12955.1 U176.7(2Y2)
N79150708: R12956.1 U176.5(2Y3)
N79150713: R12954.1 U176.9(2Y1)
N79178768: R12344.1 U154.B19(GPIOF1/NDCD4/SIOPBI#)
N79892105: PC300.2 PD4.1 PQ21.4(G1) PR296.2 PR297.1
N81956957: Q4.1(B) R12993.1
N81957411: Q10.1(B) R12994.1
N81958061: Q18.1(B) R12995.1
N81958702: Q9.1(B) R12996.1
N81959147: Q17.1(B) R12997.1
N82446781: Q42.3(D) Q59.1(G) R13007.2
N82446790: Q59.3(D) R1600.1 R13004.1
N82446929: R13004.2 R13005.1 U183.1(VIN-)
N82573078: Q24.5(G2) R1177.1 R1280.1 U197.4(Y)
N83323038: TP145.1 U154.A16(GPIOD6/SD2CD#)
N83323893: TP146.1 U154.E15(GPIOD7/SD2WP#)
N83582989: Q60.3(D) R13036.2
N83584389: R12725.2 U124.6(USB_DP)
N83584392: R12724.2 U124.5(USB_DM)
N84148690: PC429.1 PR484.2
N84318236: R13068.2 R13069.2 U115.2(REF)
N84432227: PQ24.3(D) PR501.2
N84534648: D26.2 R13044.2
N84534754: D26.4 R13049.1
N84554322: C2406.1 R12905.1 U75.2(D+)
N84554326: C2406.2 R12906.1 U75.3(D-)
N84741258: R1077.1 R13080.2 R13081.2
N84802108: R13803.2 U70.D2(NC_3)
N84802297: R13082.1 U70.E2(NC_1)
N84853658: D25.1 R821.2
N84853670: D25.2 R822.2
N84948998: C2167.1 R13072.2
N84949005: C2168.1 R13073.2
N84949054: C2166.1 R13075.2
N84949057: C2165.1 R13074.2
N84949110: C2164.1 R13077.2
N84949113: C2163.1 R13076.2
N85275060: R791.1 U113.4(OUT)
N85395811: C2454.1 R781.2 R783.2 R793.2 U113.1(VIN-)
N85395871: R782.1 R784.1 R794.2 U113.3(VIN+)
N85396360: R795.1 U194.4(OUTY)
N85506243: R12719.2 U154.H1(GPIOQ7/USB11_HDN4)
N85523072: R1112.2 U136.4(OUTY)
N85655437: TP113.1 U154.E6(GPIOA3/TIMER4)
N85655438: TP97.1 U154.B5(GPIOA1/MAC2LINK)
N85655439: TP98.1 U154.A4(GPIOA2/TIMER3)
N85663082: U99.2(INA) U101.4(OUTY)
N86242490: Q6.1(G) R1268.1 U145.4(OUTY)
N86874213: R1918.2 U175.3(Q2)
N86874237: R1915.2 U175.5(Q4)
N86874469: R1604.1 U168.5(Q4)
N86874512: R1667.2 U168.2(Q1)
N86874530: R1668.2 U168.3(Q2)
N86874595: R12762.2 U168.8(OE)
N86875998: R12790.2 U139.C12(MFRSYNC_2K_1PPS)
N86876151: TP21.1 U168.4(Q3)
N87539978: R12880.2 U154.B13(GPIOG4/WDTRST1/OSCCLK)
N87780347: R1988.1 U76.5(SC0)
N87780349: R1989.1 U76.4(SD0)
N855994741: PC233.1 PR242.2

Pads without a net: CN1 6 8; CN6 4 5; D26 1 3; D61 3 4; D65 1 3 6; D67 1 3 6; D68 1 3 6; D69 1 3 6; J7 AR1 AR2 BR3 BR6 BR7 BR8; OJ1 AR1 AR2 AR7 AR8 AR9 AR10; PJ1 1 2 3 4 5 7; PU2 3 4 5 6; PU4 6 7 8 33 34 35 36; PU7 3 4 5 6 31 32 35; PU18 2 6 7; PU22 3 4 5 6; T1 4 5 12 13; U1 AB9 AB34 AB36 AC5 AC10 AC34 AC36 AD27 AD34 AD35 AE27 AE35 AH19 AJ37 AK14 AK37 AL1 AL6 AL19 AL27 AL30 AL37 AM37 AN23 AN37 AP18 AP37 AR34 AT30 AU10 L3 L4 L34 L35 M1 M2 M6 M7 N3 N4 N8 N9 N14 N15 N16 N24 N29 N30 N34 N35 P1 P2 P6 P7 P22 P23 R3 R4 R8 R9 R29 R30 R34 R35 T1 T2 T6 T7 T32 U3 U4 U8 U9 U28 U32 U34 U35 V1 V2 V6 V7 V13 V28 V29 V30 W3 W4 W8 W9 W13 W19 W25 W30 W31 W33 Y19 Y25; U2 T7; U3 T7; U4 T7; U5 T7; U6 T7; U7 T7; U23 A6 A7 A10 A11 B10 C6 C8 C11 D8 E6 E7 E11 G6 G10 G11 H8 H9 H10 J7 J8 J9 K8 L6 L8 M6 M7 M8 M11 N6 N7 N11 P6 P7 P11 R8 R9 R11; U25 G2 G3 G16 G17 G18 H2 H3 H4 H5 H13 H14 H15 H16 H17 H18 J2 J3 J4 J14 J15 J16 J17 J18 K2 K3 K4 K14 K17 K18 L1 L2 L3 L4 L5 L13 L14 L15 L16 L17 L18 M1 M2 M3 M4 M6 M12 M14 M15 M16 M17 M18 N2 N9 N16; U49 13 14 15 16; U50 13 14 15 16; U52 13 14 15 16; U55 13 14 15 16; U56 13 14 15 16; U57 6 7 10 11 15 16 19 20; U73 51 53 55 57; U85 22 43 44 60 61 62 63; U105 1; U107 1; U108 1; U124 2 16 17; U127 1 20 41 42 43 44 45 46 49 51 57 58 59 60 72 74; U129 8 15 16; U132 8 15 16; U133 8 13 14 15 16; U135 22 41 42; U138 1; U139 A1 A2 B10 C8 C10 D11 D12 E3 G3 G7 K9 K10 L6 M1 M2 M5 M6 M9 M10; U150 7; U154 A6 A7 A8 A10 A17 A18 AA7 AA22 AB7 B6 B7 B10 B16 B17 C7 C10 C16 D6 D7 D9 D10 D16 E7 E9 H21 H22 J1 J2 N21 R2 R3 R4 R18 T1 T2 T4 T5 U1 U2 U3 U4 U18 U19 V1 V2 V16 V21 W21 W22 Y22; U155 J1 J9 L1 L9 M7; U162 10 11 12 13 14 15 17 19 20 21; U174 5; U180 1 5; U181 1 5; U182 1 5; U198 1 5; U201 1 5; X7 2; X11 1 2 5 6; X14 1 2 5

## Via types
v1: diameter 0.508, hole 0.203, TOP to BOTTOM, 7075 vias
v2: diameter 0.889, hole 0.445, TOP to BOTTOM, 992 vias
v3: diameter 0.61, hole 0.305, TOP to BOTTOM, 137 vias
v4: diameter 0.483, hole 0.203, TOP to BOTTOM, 3305 vias
v5: diameter 0.559, hole 0.254, TOP to BOTTOM, 110 vias
v6: diameter 0.61, hole 0.254, TOP to BOTTOM, 571 vias
v7: diameter 0.457, hole 0.254, TOP to BOTTOM, 139 vias
v8: diameter 0.508, hole 0.305, TOP to BOTTOM, 120 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
GND: length 3865
  TOP w0.127: v1(67.44,12.45) 67.82,12.06 77.72,12.06 v1(78.11,12.45)
  TOP w0.254: PU24.11 76.2,186.53 ; U129.1 183.5,153.46 v7(183.32,153.28) ; v6(8.67,152.51) 9.51,152.51 9.91,152.91 9.91,163.12 9.27,163.76 8.23,163.76 PR438.2 ; v8(288.7,134.79) 288.95,134.54 PU4.17 ; PU4.22 290.57,134.54 290.32,134.79 v8(289.7,134.79) 290.45,134.04 PU4.20 ; v7(165.55,87.86) 165.37,88.03 U132.1 ; PU22.29 9.41,180.03 8.83,180.61 8.83,182.35 9.17,182.68 PC376.1 ; PU2.29 35.58,167.26 35,167.84 35,170.03 35.33,170.36 PC45.1 ; v7(158.24,118.09) 158.06,118.27 U133.1 ; PR90.2 33.86,149.91 34.89,148.88 36.41,148.88 36.91,148.39 36.91,138.92 36.65,138.66 v6(36.13,138.66) ; PU24.4 75.67,183.11 v1(75.5,182.94) ; v1(79.12,41.84) D60.3 D60.12 D60.8 v1(79.12,38.6) ; 76.25,188.52 PR487.1 ; PR135.2 v1(295.1,139.21) ; PC425.2 v1(78.56,189.22)
  TOP w0.305: U73.43 120.12,199.01 v1(120.12,197.99) ; v1(116.84,199.39) 117.22,199.01 U73.48 ; U42.1 306.84,88.41 v8(306.59,88.16) ; v1(116.33,198.88) 116.81,198.4 U73.49 ; 264.06,150.63 263.67,151.02 PU10.4 263.67,152.27 v8(263.92,152.52) ; U140.4 6.46,73.67 v1(6.73,73.41) ; 36.58,165.27 PU2.27 ; v1(116.81,190.05) 116.81,190.7 U73.64 ; PU24.3 78.46,183.96 v6(79.23,183.19) ; v8(208.49,76.62) 208.24,76.87 U36.1 ; v7(10.66,175.99) 10.42,176.24 PU22.27 ; U176.10 v1(125.47,177.55) ; v1(179.16,84.94) 179.16,87.41 171.1,95.47 171.1,104.18 165.84,109.45 165.84,124.43 167.49,126.09 167.49,133.25 156.36,144.37 138.06,144.37 129.65,152.79 53.73,152.79 51.44,150.5 v1(46.86,150.5) ; U143.4 v1(105.91,87.26) ; v1(121.39,190.94) 121.12,190.68 121.12,189.9 U73.8 ; U144.4 v1(88.91,196.02) ; v8(116.36,76.37) 116.11,76.62 U32.1 ; PU7.29 152.71,190.25 v7(153.04,189.92) ; v1(202.49,86.87) 190.75,86.87 185.03,92.6 184.36,92.6 166.82,110.14 166.82,123.97 168.4,125.56 168.4,134.11 167.94,134.58 167.94,149.19 152.16,164.96 152.16,171.07 149.04,174.19 149.04,174.2 147.51,175.74 147.51,178.72 PR180.1 ; PR482.2 75.01,181.85 75.01,181.85 75.01,182.44 v1(75.5,182.94) ; U162.2 85.44,80.42 v7(86.19,81.17) ; PU10.8 v8(263.17,153.02) ; U2.H1 v4(206.46,159.87) ; v1(31.7,152.25) 30.71,152.25 29.69,153.27 29.69,154.46 30.33,155.1 PR89.1 ; Q44.1 v1(280.97,76.79) ; Q44.4 v1(278,78.67) ; 9.42,177.76 9.42,178.44 PU22.29 ; D59.3 D59.12 D59.8 v1(74.55,38.6) ; U105.3 v1(19.72,16.85) ; PU24.7 78.33,183.11 ; v1(135.24,206.93) U178.7 ; 35.58,165.05 PU2.29
  TOP w0.33: PR355.1 v1(57.3,193.42) ; v1(63.3,194.58) 63.27,194.61 PU19.10 ; v1(59.55,192.98) 59.55,193.45 PU19.4 60.59,193.86 60.59,193.85 60.65,193.85 60.82,193.68 60.82,193.62 60.84,193.6 PU19.6 ; v1(59.42,195.97) 59.42,195.96 ; 59.42,195.96 PU19.15 ; 59.42,195.96 59.96,195.42 PU19.1 ; 151.05,193.56 151.05,193.24 152.59,191.7 152.59,191.66 152.71,191.55 PU7.29 ; U76.8 v1(142.37,175.28) ; v1(59.05,189.87) 58.73,189.87 58.4,190.2 PR357.2 ; v1(57.28,192.34) PC324.2
  TOP w0.356: PU7.27 153.71,188.75 v7(153.96,188.5)
  TOP w0.381: U1.C26 v4(206.86,103.5) ; U4.D8 v4(239.15,156.67) ; Q23.4 52.58,194.29 52.96,193.91 v1(52.96,193.55) ; PC7.1 v1(116.97,201.37) ; R1405.1 72.93,43.34 v1(72.77,43.18) ; R1405.1 72.56,44.36 ; R1405.1 73.3,44.36 ; R12829.1 v1(47.09,194.12) ; R12829.1 47.73,194.5 ; R12829.1 47.73,193.75 ; C245.2 238.56,113.47 v1(237.87,112.78) ; U1.Y3 v4(230.86,121.5) ; C2162.2 v1(24.77,124.92) ; C262.2 265.94,122.61 v1(265.2,122.61) ; C262.2 266.43,122.72 ; C262.2 266.14,121.83 v1(265.2,121.83) ; C262.2 265.62,122.12 ; C262.2 266.43,121.52 ; 62.36,41.74 C1680.2 ; C1680.2 v1(62.73,42.41) ; C1680.2 63.11,41.74 ; U1.L13 v4(220.86,111.5) ; R1159.2 55.04,193.76 v1(55.64,193.17) ; v1(225.52,172.15) 225.69,172.33 U75.5 ; 192.12,139.55 C2388.2 ; C2388.2 192.49,139.91 ; C2388.2 193.21,139.55 v1(193.37,139.4) ; v1(100.46,142.17) R12373.1 ; R12373.1 100.83,141.31 ; R12373.1 100.09,141.31 ; v4(233.86,130.5) 233.28,131.07 232.44,131.07 U1.AK1 ; C1263.2 v1(238.86,75.49) ; U3.A2 v4(217.83,154.27) ; C218.1 271.08,123.23 v1(271.49,122.83) 270.93,122.27 C186.2 ; v1(57.67,53.52) 57.38,53.23 R1270.1 ; 77.75,173.53 C2224.1 ; C2224.1 78.09,173.04 v1(77.89,172.84) ; C2224.1 78.09,173.9 ; U23.D1 v4(134.21,105.36) ; D73.2 24.95,25.36 25.22,25.63 v1(25.22,26.91) ; D73.2 v1(24.26,26.9) ; D73.2 23.7,25.36 23.32,25.74 v1(23.32,26.9) ; PR40.2 277.28,122.05 ; PR40.2 277.28,121.3 ; PR40.2 v1(278.07,121.68) ; U23.D12 v4(134.21,93.36) ; C2105.2 76.01,46.76 ; C2105.2 74.93,46.23 v1(74.55,46.23) ; C2105.2 75.46,46.29 ; C2105.2 74.91,46.76 ; U25.T1 v4(277.1,101.39) ; 169.76,125.41 R1453.1 ; R1453.1 v1(169.76,126.51) ; R1453.1 169.41,125.78 ; U1.L24 v4(208.86,111.5) ; 66.38,184.14 R784.2 ; R784.2 v1(66.75,184.78) ; R784.2 67.12,184.14 ; 125.01,118.94 C1644.1 ; C1644.1 v1(126.3,118.94) ; C1644.1 125.38,119.28 ; U1.B17 v4(216.86,102.5) ; PC92.2 289.69,128.63 290.52,129.47 v1(290.92,129.47) ; D97.1 v1(59.94,38.23) ; U1.L12 v4(221.86,111.5) ; U1.D30 v4(202.86,104.5) ; C1681.2 v1(59.69,42.41) ; C1681.2 59.31,41.74 ; C1681.2 60.06,41.74 ; U25.N17 v4(280.1,84.39) ; C1319.2 v1(226.79,74.09) ; v1(46.74,201.42) 47.12,201.04 R12830.1 ; U25.N5 v4(280.1,97.39) ; U1.H21 v4(211.86,108.5) ; R13049.2 81.45,133.53 ; R13049.2 80.19,133.53 v1(79.88,133.22) ; R13049.2 80.9,134 ; C1334.2 308.75,84.94 v1(308.48,85.21) ; C1334.2 309.22,84.07 ; C1334.2 308.75,83.52 ; v1(66.8,129.79) 67.18,129.41 C2292.1 ; C2215.2 136.46,201.48 ; C2215.2 v1(136.46,200.41) ; C2215.2 136.11,201.11 ; U96.5 v1(69.72,48.13) ; U1.AA31 v4(201.86,122.5) ; C1262.2 177.63,77.28 ; C1262.2 177.26,76.94 ; C1262.2 v1(178.39,76.94) ; C1042.2 149.4,72.74 ; C1042.2 149.4,72 ; C1042.2 v1(150.12,72.37) ; U25.C15 v4(291.1,87.39) U25.C14 ; U5.H1 v4(233.38,159.87) ; U154.M1 v4(62.53,121.73) ; J8.14 50.83,75.73 v1(51.09,75.98) ; U1.AC6 v4(227.86,124.5) ; Q15.2 274.05,186.68 v1(274.29,186.44) ; Q15.2 272.93,186.08 ; Q15.2 272.93,187.28 ; Q15.2 272.3,186.68 ; v1(250.42,151.69) C74.2 ; C74.2 249.53,152.46 v1(249.53,151.67) ; C74.2 250.44,153.35 251.33,152.46 v1(251.33,151.69) ; U5.C9 v4(226.18,155.87) ; D48.1 v1(42.62,198.05) ; C1069.2 167.67,72.74 ; C1069.2 167.67,72 ; C1069.2 v1(166.93,72.37) ; v1(295.15,140.82) 294.91,140.58 PR134.2 ; U98.2 v1(92.89,132.9) ; 173.07,138.5 R1814.1 ; R1814.1 172.97,138.87 v1(172.46,138.36) 172.46,138.25 172.85,137.87 R58.2 ; R1814.1 173.07,139.24 ; 173.12,123.5 R1446.2 ; R1446.2 172.59,123.87 v1(172.45,123.73) ; R1446.2 173.12,124.24 ; R12463.1 140.43,115.73 v1(140.59,115.57) ; R1190.1 43.81,192.3 ; R1190.1 v1(43.43,193.04) ; R1190.1 43.06,192.3 ; C1045.2 143.51,72.74 ; C1045.2 v1(142.77,72.37) ; C1045.2 143.51,72 ; 88.15,86.8 R1212.1 ; R1212.1 88.49,87.17 ; R1212.1 v1(88.49,86.06) ; 173.56,72 C1066.2 ; C1066.2 173.56,72.74 ; C1066.2 v1(174.27,72.37) ; U1.AC23 v4(209.86,124.5) ; U1.AN22 v4(210.86,134.5) ; U1.AA21 v4(211.86,122.5) ; R1878.1 110.72,172.12 ; R1878.1 109.98,172.12 ; R1878.1 v1(110.35,171.45) ; U1.R31 v4(201.86,115.5) ; U3.E9 v4(211.43,157.47) ; U25.T11 v4(277.1,90.39) ; C1283.2 v1(122.58,73.84) ; R42.1 v1(175.95,124.64) ; R42.1 176.67,125.01 ; R42.1 176.67,124.27 ; R1023.1 133.48,194.06 v1(133.1,194.44) ; PR124.2 v1(290.57,143.06) ; R1909.2 19.72,16.33 ; R1909.2 v1(19.05,15.96) ; R1909.2 19.72,15.59 ; U25.C3 v4(291.1,99.39) U25.B3 ; U1.V5 v4(228.86,118.5) ; U23.N1 v4(124.21,105.36) ; C2432.1 v1(120.62,179.22) ; U25.T8 v4(277.1,94.39) ; PC13.2 v1(278.78,123.02) ; U1.AJ15 v4(218.86,130.5) ; C212.2 213.65,174.87 v1(213.96,175.18) ; C1403.2 v1(166.62,76.94) ; C1403.2 165.19,76.94 ; C1403.2 165.56,77.28 ; U1.AA27 v4(205.86,122.5) ; U1.AL32 v4(200.86,132.5) ; PC236.2 v1(292.47,125.12) ; U139.C3 v4(23.43,96.3) ; U1.E27 v4(205.86,105.5) ; C1623.1 87.75,89.9 ; C1623.1 87.38,90.04 v1(87,90.42) ; C1623.1 87,89.9 ; C2114.2 v1(4.18,93.52) ; U1.C30 v4(202.86,103.5) ; PR254.2 291.77,124.35 ; PR254.2 v1(291.4,125.68) ; PR254.2 291.03,124.35 ; U1.R27 v4(205.86,115.5) ; 103.61,172.12 R1742.1 ; R1742.1 v1(103.98,171.45) ; R1742.1 104.36,172.12 ; D76.2 39.28,25.36 39.55,25.63 v1(39.55,26.91) ; D76.2 v1(38.58,26.9) ; D76.2 38.03,25.36 37.65,25.74 v1(37.65,26.9) ; v1(160.84,84.71) 160.84,83.88 C2051.1 ; U1.AG7 v4(226.86,128.5) ; U4.K1 v4(245.56,162.27) ; 140.71,200.74 C2402.2 ; C2402.2 v1(139.95,201.11) ; C2402.2 140.71,201.48 ; C1254.2 v1(98.38,74.09) ; v1(24.64,50.42) 24.9,50.68 R1199.1 ; C215.2 208.83,175 v1(209.01,175.18) ; 294.97,80.04 C1251.2 ; C1251.2 v1(294.08,80.41) ; C1251.2 294.97,80.78 ; R166.2 246.36,171.25 v1(246.78,171.68) ; v1(218.78,175.07) 218.48,174.77 C188.2 ; U23.B4 v4(136.21,102.36) ; U23.H4 v4(130.21,102.36) ; U1.K29 v4(203.86,110.5) ; U1.T10 v4(223.86,116.5) ; v4(60.78,114.88) 60.83,114.93 U154.P9 U154.N9 ; U25.B5 v4(291.1,97.39) U25.C5 ; U70.D5 v4(114,130.45) ; v1(114.81,141.6) 114.81,140.97 C1383.2 113.92,141.1 v1(113.92,141.6) ; v1(65.39,128.4) 65.18,128.4 C2435.1 R12969.1 ; U23.H1 v4(130.21,105.36) ; U1.R11 v4(222.86,115.5) ; C1284.2 v1(122.58,75.24) ; U1.AT1 v4(232.86,137.5) ; R12700.1 v1(164.04,141.31) ; R12700.1 164.04,142.4 ; R12700.1 164.39,142.03 ; C2209.2 97.56,179.24 ; C2209.2 97.56,178.5 ; C2209.2 v1(98.3,178.87) ; C2428.1 v1(11.51,20.89) ; R1738.1 109.45,172.12 ; R1738.1 v1(109.07,171.45) ; R1738.1 108.7,172.12 ; R13088.1 v1(55.12,188.34) ; R13088.1 54.39,187.97 ; R13088.1 54.39,188.71 ; 181.49,117.86 R1444.2 ; R1444.2 181.84,117.48 ; R1444.2 v1(181.84,118.62) ; 156.14,113.52 C2056.1 ; C2056.1 156.88,113.52 ; C2056.1 v1(156.51,112.88) ; R1438.1 169.51,123.1 ; R1438.1 169.12,122.73 v1(168.8,122.41) ; R1438.1 169.51,122.35 ; v1(88.65,131.57) 89,131.93 R1408.1 ; U6.E1 v4(253.3,118.66) ; 270.8,88.4 R13026.2 ; R13026.2 271.17,86.08 v1(272.16,85.09) ; R13026.2 271.54,88.4 ; U23.D14 v4(134.21,91.36) ; v1(271.49,126.89) 271.29,127.09 C220.2 ; U25.F3 v4(288.1,99.39) U25.E2 ; v1(173.65,76.44) 173.92,76.17 C1273.2 ; U1.AP5 v4(228.86,135.5) ; v1(135.64,122.04) 135.64,122.12 R1075.1 ; U25.D14 v4(290.1,87.39) ; C1312.2 113.38,77.03 ; C1312.2 113.01,76.68 ; C1312.2 114.21,76.68 v1(114.23,76.71) ; 91.18,179.39 U67.8 ; U67.8 91.44,180.24 ; U67.8 91.4,180.02 v1(92.2,180.02) ; U1.L20 v4(212.86,111.5) ; C1287.2 307.11,91.85 ; C1287.2 307.11,91.11 ; C1287.2 v1(307.85,91.48) ; R1065.1 82.79,192.68 ; R1065.1 82.42,193.03 ; R1065.1 C1419.1 80.62,192.68 v1(80.34,192.96) ; U1.T24 v4(208.86,116.5) ; v1(54.72,202.84) 55.03,202.53 C1601.2 ; R1452.1 169.18,123.78 v1(169.14,123.74) ; R1452.1 169.89,124.15 ; R1452.1 169.89,123.41 ; U1.AB14 v4(219.86,123.5) ; U25.D10 v4(290.1,91.39) ; R57.2 184.17,130.53 ; R57.2 184.17,129.79 ; R57.2 v1(183.45,130.16) ; 215.32,170.6 C370.2 ; C370.2 215.91,169.64 v1(216.16,169.39) ; C370.2 215.91,171.15 v1(215.38,171.68) ; C370.2 216.51,170.6 ; U1.R33 v4(199.86,115.5) ; R1708.1 117.07,138.91 v1(116.74,139.24) ; U1.AU23 v4(209.86,138.5) ; U25.P16 v4(279.1,85.39) ; U2.E8 v4(200.06,157.47) ; U25.E16 v4(289.1,85.39) U25.D16 v4(290.1,85.39) ; U25.C16 v4(290.1,85.39) ; v4(290.1,85.39) U25.C17 v4(290.1,84.39) ; v1(75.37,87.77) 75.17,87.97 U127.47 ; U139.H4 v4(17.43,95.3) ; 253.09,199.26 PR231.2 ; PR231.2 253.31,199.63 v1(253.87,199.07) 253.36,198.56 PC205.2 ; PR231.2 253.09,200 ; U1.E20 v4(212.86,105.5) ; v1(131.57,182.75) 132.01,183.2 Q58.2 ; U1.T4 v4(229.86,116.5) ; U23.F12 v4(132.21,93.36) ; 62.69,141.02 PU20.4 ; v1(65.63,175.74) U194.3 ; v4(24.43,91.3) U139.B7 ; U7.H9 v4(255.7,137.53) ; v1(243.59,175.18) 243.23,174.82 C224.1 ; v1(58.04,199.77) 58.38,199.43 PR339.1 ; C1102.2 268.09,73.13 v1(268.26,73.3) ; C1102.2 268.09,72.04 ; C1102.2 267.74,72.41 ; U1.K28 v4(204.86,110.5) ; U7.D8 v4(252.5,136.73) ; 103.74,138.53 C1381.2 ; C1381.2 v1(104.29,139.45) ; C1381.2 104.84,138.53 ; C1318.2 v1(226.79,75.49) ; U1.H10 v4(223.86,108.5) ; v1(101.8,213.8) PC4.2 ; 136.01,193.58 U148.3 ; U148.3 136.56,193.85 ; U148.3 135.2,193.85 v1(135,194.06) ; U4.C9 v4(238.35,155.87) ; U1.AJ27 v4(205.86,130.5) ; U1.L36 v4(196.86,111.5) ; 165.91,82.25 R1081.1 ; R1081.1 166.28,81.91 ; R1081.1 165.86,81.83 v1(165.86,81.53) ; C2229.1 73.43,66.09 ; C2229.1 73.43,65.35 ; C2229.1 v1(72.69,65.72) ; v1(238.38,72.37) C1213.2 ; C1213.2 237.66,72 ; C1213.2 237.66,72.74 ; C1578.2 v1(269.09,183.57) ; v1(262.41,163.25) 262.41,164.48 C51.2 ; U25.A5 v4(293.1,97.39) ; U1.K16 v4(217.86,110.5) ; v8(128.44,76.37) 128.19,76.62 U35.1 ; U1.K7 v4(226.86,110.5) ; U89.14 77.3,54.9 v1(77.22,54.99) ; v1(46.1,104.52) 46.46,104.17 R12356.2 ; U23.N13 v4(124.21,92.36) ; U139.L2 v4(14.43,97.3) ; U25.F15 v4(288.1,86.39) ; R58.2 173.12,138.24 ; R58.2 173.12,137.5 ; U1.AJ6 v4(227.86,130.5) ; U154.R5 v4(60.13,118.53) ; U25.R14 v4(278.1,87.39) ; U1.AN28 v4(204.86,134.5) ; C326.2 191.77,114.82 v1(191.69,114.9) ; C2429.1 13.98,22.34 ; C2429.1 v1(13.61,22.99) ; C2429.1 13.24,22.34 ; U23.N5 v4(124.21,101.36) ; 87.7,122.56 C2461.1 ; C2461.1 88.04,122.93 ; C2461.1 v1(87.7,123.7) ; X4.2 114.31,87.09 v1(114.17,87.23) ; C1057.2 v1(154.85,72.37) ; C1057.2 155.59,72 ; C1057.2 155.59,72.74 ; U25.J10 v4(285.1,91.39) ; U23.N2 v4(124.21,104.36) ; v1(134.24,198.34) U164.3 ; U164.3 135.26,198.07 ; U164.3 135.81,198.34 ; U1.H9 v4(224.86,108.5) ; 220.52,170.61 C75.2 ; C75.2 221.72,170.61 ; C75.2 v1(221.12,171.74) ; C75.2 221.12,169.81 ; C75.2 220.36,171.38 v1(220.36,171.79) ; U1.H20 v4(212.86,108.5) ; R12923.1 36.72,51.2 v1(36.2,50.67) 35.7,51.16 C2410.2 ; 87.38,128.76 C2404.1 ; C2404.1 87.7,129.11 v1(88.14,128.67) ; C2404.1 87,129.11 ; U127.4 68.67,74.52 v1(68.63,74.55) ; D49.1 42.41,202.24 v1(42.7,201.96) ; U154.M12 v4(62.53,112.13) U154.N12 ; v7(123.26,194.46) 123.97,194.46 124.72,195.21 U73.26 ; C1422.1 v1(119.86,185.35) ; v1(57.28,98.87) 57.28,98.39 X13.2 ; U139.F8 v4(20.43,90.3) ; U1.AG1 v4(232.86,128.5) ; U1.Y37 v4(195.86,121.5) ; Q7.2 279.08,186.7 v1(279.12,186.74) 279.12,187.7 C1561.2 ; Q7.2 277.63,187.29 ; Q7.2 277.63,186.1 ; Q7.2 277.01,186.7 ; U1.F21 v4(211.86,106.5) ; C2123.2 v1(95.02,178.87) ; C2123.2 94.39,179.24 ; C2123.2 94.39,178.5 ; v4(45.45,116.91) 45.45,116.91 U155.J8 ; PC186.2 201.04,207.67 v1(201.48,207.24) 200.95,206.71 PR215.2 ; U1.AN19 v4(214.86,134.5) ; v8(168.54,76.62) 168.29,76.87 U30.1 ; C1548.1 v1(93.87,181.5) ; C1548.1 95,181.16 ; C1548.1 95.37,181.5 ; U1.T16 v4(217.86,116.5) ; C1189.2 213.51,72.74 ; C1189.2 213.51,72 ; C1189.2 v1(214.63,72.37) ; R54.2 176.65,136.97 ; R54.2 176.65,136.23 ; R54.2 v1(175.93,136.6) ; C2059.1 164.34,97.87 ; C2059.1 163.32,98.52 v1(163.32,98.74) ; C2059.1 163.97,98.21 ; C2059.1 163.6,97.87 ; v1(54.86,93.34) 55.04,93.52 C2267.2 ; U25.V3 275.6,98.89 v4(276.1,99.39) U25.U3 ; C1421.1 v1(121.13,185.35) ; PC117.2 v1(295.22,175.41) ; Q3.2 262.5,186.68 ; Q3.2 261.26,186.68 ; Q3.2 261.92,186.72 v1(263.37,186.72) 263.37,187.69 C1549.2 ; Q3.2 261.88,187.28 ; R1102.1 99.55,181.5 ; R1102.1 98.81,181.5 ; R1102.1 v1(99.18,180.87) ; R273.2 116.59,98.59 v1(116.45,98.73) ; U1.R37 v4(195.86,115.5) ; U1.K26 v4(206.86,110.5) ; v1(126.85,72.11) 126.86,72.12 C1033.2 ; U4.D2 v4(244.76,156.67) ; R2002.1 134.59,176.89 ; R2002.1 v1(133.95,176.52) ; R2002.1 134.59,176.15 ; U1.U33 v4(199.86,118.5) ; U1.R13 v4(220.86,115.5) ; U154.J9 v4(65.73,115.33) ; U1.Y34 v4(198.86,121.5) ; v1(281.18,187.32) 281.56,187.71 C1581.2 ; U1.W10 v4(223.86,119.5) ; PR73.2 PC33.2 71.17,210.77 v1(71.17,210.16) ; PR73.2 72.01,212.98 ; PR73.2 71.66,212.61 ; U196.3 v1(54.23,189.23) ; PR113.2 216.93,210.68 v1(217.17,210.44) ; U1.T28 v4(204.86,116.5) ; U1.AA11 v4(222.86,122.5) ; C19.2 v1(179.32,137.21) ; C19.2 180.66,137.76 ; C19.2 180.66,136.66 ; U1.Y24 v4(208.86,121.5) ; U7.T1 v4(262.9,130.33) ; Q58.2 132.61,184.25 ; Q58.2 131.42,184.25 ; U1.AB12 v4(221.86,123.5) ; R12380.1 v1(71.51,128.77) ; U70.L9 v4(116.4,124.05) ; U3.M9 v4(211.43,163.87) ; 98.43,102.01 R1217.1 ; R1217.1 99.18,102.01 ; R1217.1 v1(98.81,102.87) ; v4(60.93,110.53) U154.P14 U154.P13 U154.P12 U154.N11 ; U25.B9 v4(292.1,93.39) ; C191.2 246.13,174.8 v1(246.51,175.18) 247.09,174.6 C193.2 ; Q16.2 v1(287.78,186.7) ; Q16.2 286.84,187.3 ; Q16.2 286.84,186.1 ; Q16.2 286.22,186.7 ; U1.L21 v4(211.86,111.5) ; U1.J4 v4(229.86,109.5) ; U1.AG10 v4(223.86,128.5) ; U1.AE21 v4(211.86,126.5) ; v1(176.04,123.06) 176.5,122.6 R1451.1 ; U112.2 78.53,122.98 v1(78.74,123.19) ; R47.1 v1(183.45,126.35) ; R47.1 184.17,126.72 ; R47.1 184.17,125.97 ; R1439.1 v1(168.79,121.45) ; R1439.1 169.51,121.82 ; R1439.1 169.51,121.08 ; v1(215.99,175.18) 215.58,174.77 C228.2 ; U139.D1 v4(22.43,98.3) ; U1.R6 v4(227.86,115.5) ; R12819.1 173.08,119.3 ; R12819.1 173.08,118.56 ; R12819.1 172.99,118.93 v1(172.47,118.41) ; U70.H12 v4(119.6,126.45) ; R12974.2 v1(45.47,202.35) R12973.2 ; C1938.1 20.41,20.6 ; C1938.1 v1(19.68,20.23) ; C1938.1 20.41,19.86 ; C236.2 271.19,125.16 v1(271.49,124.86) ; PC252.2 v1(235.88,204.79) ; 123.3,186.21 R1031.1 ; R1031.1 124.04,186.21 ; R1031.1 v1(123.67,185.58) ; U23.D13 v4(134.21,92.36) ; U1.R1 v4(232.86,115.5) ; U25.G6 v4(287.1,96.39) ; v1(250.45,72.37) C1225.2 ; C1225.2 249.74,72.74 ; C1225.2 249.74,72 ; R12803.2 v1(14.12,83.67) ; U1.E24 v4(208.86,105.5) ; U1.M21 v4(211.86,112.5) ; C2358.1 v1(139.57,132.21) ; U1.A5 v4(228.86,101.5) ; v1(265.77,140.4) C96.2 ; C96.2 264.99,141.6 v1(264.99,140.39) ; C96.2 265.78,142.37 266.57,141.59 v1(266.57,140.4) ; U33.1 180.36,76.87 v8(180.61,76.62) ; U1.AU14 v4(219.86,138.5) ; v1(38.15,57.99) 37.9,57.73 C2125.2 ; v1(203.99,213.8) PR403.2 ; U1.AN13 v4(220.86,134.5) ; C1238.2 v1(300.71,80.56) ; C1238.2 299.9,80.19 ; C1238.2 299.9,80.94 ; U2.T1 v4(206.46,167.08) ; U1.AR15 v4(218.86,136.5) ; 198.25,199.26 PR212.2 ; PR212.2 198.25,200 ; PR212.2 198.51,199.63 199.04,199.11 v1(199.04,199.1) 199.03,199.1 198.49,198.56 PC185.2 ; U1.AR9 v4(224.86,136.5) ; U25.J6 v4(285.1,96.39) ; U1.AB24 v4(208.86,123.5) ; C1210.2 v1(231.77,73.15) ; C1210.2 231.42,72.37 ; C1210.2 231.77,72 ; U4.B2 v4(244.76,155.07) ; U1.R32 v4(200.86,115.5) ; U1.L23 v4(209.86,111.5) ; U1.AN35 v4(197.86,134.5) ; U155.F9 v4(45.45,118.51) ; 49.89,106.36 C2290.1 ; C2290.1 C2291.2 ; C2290.1 49.52,106.71 ; C2290.1 49.37,106.19 C2297.2 48.62,104.76 v1(48.24,104.38) ; U23.T11 v4(121.21,94.36) ; U139.C2 v4(23.43,97.3) ; U25.H9 v4(286.1,93.39) ; R1451.1 176.65,122.97 ; R1451.1 176.65,122.23 ; C2440.1 v1(113.72,202.77) ; C1078.2 v1(179.74,71.66) ; C1078.2 179.4,72.37 ; C1078.2 179.74,72.74 ; C581.2 181.61,140.72 ; C581.2 181.61,139.98 ; C581.2 v1(182.33,140.35) ; U154.D11 v4(69.73,113.73) ; U1.A29 v4(203.86,101.5) ; U1.B29 v4(203.86,102.5) ; C2053.1 v1(165.1,82.3) ; C2053.1 164.73,83.02 ; C2053.1 165.47,83.02 ; U1.Y33 v4(199.86,121.5) ; C1598.1 43.81,196.49 ; C1598.1 v1(43.43,197.22) ; C1598.1 43.06,196.49 ; C1416.1 v1(116.05,185.35) ; U1.G25 v4(207.86,107.5) ; R69.2 176.65,135.69 ; R69.2 176.65,134.95 ; R69.2 v1(175.93,135.32) ; U1.W5 v4(228.86,119.5) ; U171.3 v1(139.51,197.49) ; R34.1 169.76,129.46 ; R34.1 169.76,128.72 ; R34.1 169.46,129.09 v1(169.11,128.74) ; C2291.2 51.28,106.71 ; C2291.2 50.91,106.36 ; U1.E26 v4(206.86,105.5) ; R13027.2 v1(270.39,90.92) ; R13027.2 271.17,91.27 ; R13027.2 271.54,90.92 ; 115.49,71.75 C1021.2 ; C1021.2 115.49,72.49 ; C1021.2 114.74,72.12 v1(114.73,72.11) ; U1.AF12 v4(221.86,127.5) ; C202.2 270.76,133.28 271.3,133.28 v1(271.51,133.5) ; C202.2 270.55,132.69 ; C202.2 271.15,133.5 ; C202.2 270.55,134.02 270.83,134.31 v1(271.41,134.31) ; PR487.1 76.6,189.24 v1(76.6,189.25) ; v1(12.83,19.68) 12.38,19.24 U107.3 ; PC82.1 285.05,142.49 v1(284.61,142.93) 284.11,142.43 PR126.1 ; 37.88,53.36 C2385.1 ; C2385.1 38.26,53.7 ; C2385.1 v1(37.1,53.7) ; U1.AE5 v4(228.86,126.5) ; U1.AU8 v4(225.86,138.5) ; C2373.1 v1(79.88,54.74) ; U154.C9 v4(70.53,115.33) ; 45.59,191.14 C1602.1 ; C1602.1 v1(46.74,191.49) ; C1602.1 45.22,191.49 ; U1.AJ3 v4(230.86,130.5) ; U154.AA18 v4(55.33,107.32) ; 117.07,87.42 R280.2 ; R280.2 117.07,88.16 ; R280.2 v1(116.39,87.79) ; U155.M1 v4(39.05,113.71) ; C1558.2 57.32,159 ; C1558.2 56.58,159 ; C1558.2 v1(56.95,158.29) ; v1(47.69,64.14) D93.8 D93.12 D93.3 v1(47.69,60.96) ; 104.3,182.96 U150.12 ; U150.12 104.56,183.47 v1(104.01,184.02) ; U150.12 104.56,182.11 ; Q8.2 266.7,187.41 ; Q8.2 266.08,186.81 ; Q8.2 266.7,186.21 ; Q8.2 268.16,186.81 v1(268.2,186.85) 268.2,187.81 C1564.2 ; PC172.2 v1(198.44,201.44) ; U1.L30 v4(202.86,111.5) ; U154.P11 61.29,113.36 60.84,113.36 60.83,113.36 v4(60.78,113.36) ; U1.K1 v4(232.86,110.5) ; R59.2 v1(172.4,135.32) ; R59.2 173.12,134.95 ; R59.2 173.12,135.69 ; U1.AL11 v4(222.86,132.5) ; U1.E12 v4(221.86,105.5) ; v1(299.01,134.32) 299.24,134.55 PJ1.6 v1(303.83,134.55) ; C1622.1 v1(87.38,86.24) ; C1622.1 87,87 ; C1622.1 87.75,87 ; C1222.2 v1(243.21,72.37) ; C1222.2 243.85,72 ; C1222.2 243.85,72.74 ; C1313.2 v1(150.6,74.09) ; PU13.12 23.04,148.91 v8(23.39,148.56) ; C1081.2 185.64,72.74 ; C1081.2 185.64,72 ; C1081.2 v1(186.35,72.37) ; U1.AA28 v4(204.86,122.5) ; U1.K36 v4(196.86,110.5) U1.K37 ; C2154.1 180.59,156.65 181.13,156.11 R12775.2 v1(181.61,155.45) ; C1635.2 v1(70.1,174.55) ; C1635.2 68.79,174.55 ; C1635.2 69.16,174.89 ; C2387.1 185.16,141.44 ; C2387.1 184.81,141.07 ; C2387.1 184.81,142.07 v1(184.71,142.16) 186.38,142.16 188.92,139.63 C613.2 ; C1672.2 v1(65.68,39.78) ; v1(286.72,127.88) 286.77,127.88 PC91.2 ; 100.15,137.32 C1371.1 ; C1371.1 100.89,137.32 ; C1371.1 100.52,137.01 v1(100.91,136.62) ; U1.AC27 v4(205.86,124.5) ; U38.1 144.13,76.87 v8(144.38,76.62) ; U1.A33 v4(199.86,101.5) ; U23.B2 v4(136.21,104.36) ; C2436.2 v1(274.46,115.95) ; C2436.2 274.46,117.01 ; C2436.2 274.12,116.63 ; U1.K5 v4(228.86,110.5) ; R1506.1 v1(34.54,18.92) ; R1506.1 33.79,19.27 ; R1506.1 33.42,18.92 ; 19.85,102.51 R12799.1 ; R12799.1 v1(20.22,103.15) ; R12799.1 20.59,102.51 ; U25.B11 v4(292.1,90.39) ; v1(57.85,124.28) 57.56,124.57 57.56,125.86 57.9,126.21 R12376.1 R12375.1 ; v1(66.04,182.38) 66.04,182.38 U113.2 ; v4(17.43,91.3) U139.H7 ; U139.J8 v4(16.43,90.3) ; U1.AA25 v4(207.86,122.5) ; v1(190.75,117.62) 190.75,117.47 190.37,117.09 R12440.1 ; U1.K33 v4(199.86,110.5) ; U23.R15 v4(122.21,90.36) ; U1.K35 v4(197.86,110.5) ; U23.B3 v4(136.21,103.36) ; U2.K1 v4(206.46,162.27) ; U1.J30 v4(202.86,109.5) ; 7.55,17.59 C1815.1 ; C1815.1 7.89,17.97 ; C1815.1 v1(7.89,16.87) ; U7.E9 v4(253.3,137.53) ; C1259.2 v1(163.02,75.49) ; U138.3 v1(98.06,173.99) ; U1.K24 v4(208.86,110.5) ; v1(192.95,146.51) 193.12,146.34 C24.2 ; U1.AA15 v4(218.86,122.5) ; C2044.1 v1(177.94,155.49) ; C2044.1 178.76,155.12 ; C2044.1 178.76,155.86 ; U154.J12 U154.K13 v4(64.93,111.33) ; v1(90.07,76.86) 89.99,76.94 C1297.2 ; U1.AF24 v4(208.86,127.5) ; v1(164.34,98.68) 164.74,98.28 C2058.2 ; U1.AL29 v4(203.86,132.5) ; U7.E1 v4(253.3,130.33) ; v8(220.56,76.62) 220.31,76.87 U39.1 ; C2439.1 v1(222.35,175.45) ; C2439.1 222.35,176.49 ; C2439.1 222.01,176.12 ; U179.4 59.21,88.12 ; U179.4 58.3,87.71 ; U179.4 59.21,87.3 ; v4(16.43,91.3) U139.J7 ; U3.K1 v4(218.63,162.27) ; R1718.1 125.2,124.05 v1(125.51,123.73) ; R1718.1 125.54,125.12 ; R1718.1 125.2,125.49 ; v1(62.94,178.87) 62.89,178.92 C2453.1 ; U7.M9 v4(259.7,137.53) ; 89.55,172.7 R1987.2 ; R1987.2 89.92,172.35 ; R1987.2 v1(90.78,172.7) ; 97.23,72 C997.2 ; C997.2 v1(97.9,72.37) ; C997.2 97.23,72.74 ; 299.54,72.51 C1243.2 299.54,73.25 ; U25.D18 v4(290.1,84.39) ; v4(290.1,84.39) U25.D17 ; R275.2 v1(116.39,99.6) ; U25.J12 v4(285.1,89.39) ; v1(30.99,16.85) 31.54,16.29 U104.4 ; R1740.1 v1(105.26,171.45) ; R1740.1 104.89,172.12 ; R1740.1 105.63,172.12 ; 24.25,68.19 C2409.2 ; C2409.2 v1(24.62,68.84) ; C2409.2 24.99,68.19 ; R12375.1 59.79,126.21 ; R12375.1 59.41,126.55 ; v1(92.65,139.49) 92.84,139.68 R12372.1 ; v1(84.71,110.79) 84.94,111.02 C2449.2 ; v1(36.7,192.53) 36.51,192.73 D50.1 ; v1(304.67,184.56) C1556.2 v1(306.58,184.56) ; 74.22,46.85 C2360.1 ; C2360.1 74.59,47.19 ; C2360.1 v1(73.41,47.19) ; C2441.2 v1(114.43,201.47) ; C2441.2 115.12,201.1 ; C2441.2 115.12,201.84 ; U1.AH26 v4(206.86,129.5) ; C2423.2 28.74,12.89 ; C2423.2 28.74,12.15 ; C2423.2 v1(29.38,12.52) ; U25.C13 v4(291.1,88.39) ; U1.T34 v4(198.86,116.5) ; 103.41,72 C1009.2 ; C1009.2 103.41,72.74 ; C1009.2 v1(102.72,72.37) ; U1.H24 v4(208.86,108.5) ; U154.L11 v4(64.13,112.93) U154.K11 ; X1.2 v1(101.93,129.98) ; R2003.1 134.59,174.86 ; R2003.1 134.59,174.11 ; R2003.1 v1(133.95,174.49) ; v1(289.78,124.56) 289.78,124.34 PC223.2 ; U1.T35 v4(197.86,116.5) ; C1368.2 v1(104.14,192.41) ; C1368.2 103.11,192.41 ; C1368.2 103.48,192.77 ; U1.B21 v4(211.86,102.5) ; 141.89,130.41 C2038.1 ; C2038.1 142.98,130.41 v1(143.14,130.24) ; C2038.1 142.26,130.06 ; R1068.1 v1(119.86,182.81) ; C2361.1 v1(82.9,172.89) ; C2361.1 82.9,173.95 ; C2361.1 83.25,173.58 ; R1443.1 v1(175.91,137.87) ; R1443.1 176.65,138.24 ; R1443.1 176.65,137.5 ; v1(25.52,105.92) C2078.2 ; C2274.1 v1(93.85,139.76) ; U2.C9 v4(199.26,155.87) ; v1(234.61,205.06) PR264.2 ; C2372.2 139.92,194.34 ; C2372.2 v1(139.54,193.7) ; C2372.2 139.17,194.34 ; v4(15.43,91.3) U139.K7 ; U2.B2 v4(205.66,155.07) ; U1.AU35 v4(197.86,138.5) ; U4.E1 v4(245.56,157.47) ; U23.D4 v4(134.21,102.36) ; U1.R15 v4(218.86,115.5) ; U1.A17 v4(216.86,101.5) ; U29.1 104.03,76.87 v8(104.28,76.62) ; Q12.2 v1(86.74,113.06) ; PC55.2 v1(296.57,137.75) ; U27.1 156.21,76.87 v8(156.46,76.62) ; 43.18,84.5 U157.4 43.18,85.32 ; U23.H15 v4(130.21,90.36) ; U25.U17 v4(276.1,84.39) 275.6,84.89 U25.V17 ; U1.D16 v4(217.86,104.5) ; Y2.2 v1(85.55,91.41) ; U1.C34 v4(198.86,103.5) ; U4.M9 v4(238.35,163.87) ; U25.R4 v4(278.1,98.39) ; U6.D2 v4(252.5,119.46) ; U1.AN25 v4(207.86,134.5) ; U4.T1 v4(245.56,167.08) ; R303.2 289.09,107.36 v1(289.26,107.53) ; U154.M2 v4(62.53,120.13) U154.M3 ; C2153.2 v1(148.85,137.03) ; U25.N11 v4(280.1,90.39) ; U1.AE19 v4(214.86,126.5) ; C181.2 v1(205.32,175.25) ; C181.2 204.52,174.37 ; C181.2 206.12,174.37 ; U1.R19 v4(214.86,115.5) ; U6.B2 v4(250.9,119.46) ; U3.A8 v4(212.23,154.27) ; U1.AU5 v4(228.86,138.5) ; C51.2 263.93,164.48 v1(263.93,163.25) ; C51.2 v1(263.17,163.25) ; U25.T17 v4(277.1,84.39) ; C2048.1 150.81,141.73 ; C2048.1 150.46,142.27 v1(150.24,142.49) ; C2048.1 150.46,141.36 ; R12913.2 v1(73.19,60.91) ; U2.H9 v4(199.26,159.87) ; U3.E1 v4(218.63,157.47) ; 4.69,79.94 C548.2 ; C548.2 v1(3.68,80.31) ; C548.2 4.69,80.68 ; v1(144.91,189.81) 144.59,190.13 PC16.2 ; Q57.2 93.22,137.79 v1(93.34,137.67) ; U1.J8 v4(225.86,109.5) ; v1(49.53,186.56) 49.28,186.82 C2447.2 ; U155.G1 v4(39.05,117.71) ; U139.H8 v4(17.43,90.3) ; U1.C4 v4(229.86,103.5) ; U1.P5 v4(228.86,114.5) ; U1.Y2 v4(231.86,121.5) ; U1.T5 v4(228.86,116.5) ; PR67.2 v1(84.82,210.98) ; v4(64.93,115.33) U154.K9 U154.L9 ; U1.AA29 v4(203.86,122.5) ; v1(89.98,129.91) 89.98,129.92 U97.2 ; C1033.2 127.57,72.49 ; C1033.2 127.57,71.75 ; R1911.1 v1(14.71,12.38) ; R1911.1 15.34,12.75 ; R1911.1 15.34,12.01 ; U7.H1 v4(255.7,130.33) ; U1.W6 v4(227.86,119.5) ; U23.F2 v4(132.21,104.36) ; U1.E36 v4(196.86,105.5) ; U154.L13 v4(64.13,111.33) ; v1(267.97,197.41) 268.32,197.76 J5.8 ; U1.R36 v4(196.86,115.5) ; U6.K9 v4(258.1,125.86) ; U1.AA7 v4(226.86,122.5) ; C1292.2 101.68,76.94 ; C1292.2 101.31,77.28 ; C1292.2 v1(100.59,76.94) ; R783.1 64.95,178.97 v1(65.56,178.36) 66.12,178.92 C2454.2 ; R12770.2 154.17,117.51 v1(153.81,117.86) ; U154.K14 v4(64.93,110.53) ; U25.U5 v4(276.1,97.39) 275.6,96.89 U25.V5 ; R45.1 169.76,133.27 ; R45.1 169.76,132.53 ; R45.1 v1(169.05,132.9) ; C2058.2 165.79,98.28 ; C2058.2 165.24,98.75 ; U1.N18 v4(215.86,113.5) ; U23.R4 v4(122.21,102.36) ; C2326.2 v1(142.37,195.33) ; U23.H13 v4(130.21,92.36) ; R12794.2 v1(163.45,86.09) ; C1935.1 v1(25.12,62.5) ; C1935.1 25.47,63.16 ; C1935.1 25.12,63.54 ; U4.A2 v4(244.76,154.27) ; PR215.2 200.79,206.34 ; PR215.2 200.79,207.08 ; U23.D15 v4(134.21,90.36) ; PC135.2 281.71,145.36 PC114.2 v1(280.49,145.77) ; U155.M9 v4(45.45,113.71) ; C2368.2 101.9,179.74 ; C2368.2 v1(101.17,179.37) ; C2368.2 101.9,179 ; 153.11,76.94 C2216.2 ; C2216.2 153.48,77.28 ; C2216.2 153.96,76.94 v1(154.18,77.16) ; U1.F17 v4(216.86,106.5) ; U127.68 66.15,82.7 v1(66.5,82.35) 66.19,82.05 U127.69 ; v1(46.87,129.1) 46.87,128.6 U160.1 45.17,127.93 v1(44.96,128.14) ; U1.U14 v4(219.86,117.5) ; U1.A21 v4(211.86,101.5) ; R12976.1 v1(53.75,204.19) ; U1.AE17 v4(216.86,126.5) ; R1051.1 v1(177.42,151.92) ; R1051.1 178.18,151.58 ; R1051.1 178.55,151.92 ; U25.K6 v4(283.1,96.39) ; U59.3 136.45,191.68 ; U59.3 v1(135.06,191.68) ; U59.3 135.9,191.95 ; U25.B7 v4(292.1,95.39) ; U1.J16 v4(217.86,109.5) ; v1(56.52,92.46) 56.77,92.71 C2266.1 ; v4(69.52,103.59) 69.52,104.33 U154.D22 69.46,104.66 69.46,105.19 U154.D21 ; C1299.2 v1(134.66,73.84) ; U1.E18 v4(215.86,105.5) ; 26.44,153.48 PR38.1 ; PR38.1 v1(27.18,153.85) ; PR38.1 26.44,154.22 ; C239.1 v1(271.38,138.17) ; v1(59.68,91.96) 60.07,92.35 C2268.1 ; v1(44.88,84.91) SK157.4 ; SK157.4 43.64,84.56 ; SK157.4 43.64,85.25 ; U1.C24 v4(208.86,103.5) ; 31.64,52.19 R1192.1 ; R1192.1 v1(32.01,52.9) ; R1192.1 32.38,52.19 ; C2316.2 46.2,107.04 ; C2316.2 45.83,107.4 ; C2316.2 43.96,107.04 v1(43.16,106.24) ; PR336.2 v1(275.38,121.68) ; C184.2 271.08,120.34 v1(271.38,120.03) 270.72,119.37 C238.2 ; U139.D7 v4(21.43,91.3) U139.E7 ; 106.16,172.12 R1746.1 ; R1746.1 v1(106.53,171.45) ; R1746.1 106.9,172.12 ; U1.AJ30 v4(202.86,130.5) ; U1.G29 v4(203.86,107.5) ; U25.A17 v4(293.1,84.39) U25.A18 ; R1697.1 v1(117.26,117.86) ; R1697.1 117.63,118.52 ; R1697.1 116.89,118.52 ; U23.N12 v4(124.21,93.36) ; SK158.4 60.3,87.71 v1(60.83,87.18) ; SK158.4 59.67,87.37 ; SK158.4 59.67,88.06 ; U154.K12 v4(64.13,112.13) U154.L12 ; D51.1 37.01,191.44 37.59,192.02 v1(37.59,192.15) ; U1.AF3 v4(230.86,127.5) ; U25.E6 v4(289.1,96.39) ; C2397.2 128.93,201.54 ; C2397.2 v1(129.79,201.17) ; C2397.2 128.93,200.8 ; R12793.2 162.66,87.86 ; R12793.2 v1(163.19,88.01) ; R12793.2 163.01,87.49 ; U25.R18 v4(278.1,83.39) ; U25.T2 v4(277.1,100.39) ; U154.M14 v4(62.53,110.53) ; U1.H11 v4(222.86,108.5) ; 184.16,137.04 R1813.1 ; R1813.1 184.5,137.41 ; R1813.1 v1(184.5,136.27) ; U201.2 v1(25.62,120.14) ; PR51.1 v1(241.68,193.1) ; PR51.1 242.05,193.99 ; PR51.1 241.31,193.99 ; 304.56,73.5 C1246.2 304.56,72.76 ; U1.AA6 v4(227.86,122.5) ; C1380.1 103.43,137.78 ; C1380.1 102.69,137.78 ; C1380.1 v1(103.06,138.62) ; CN6.2 v1(103.5,103.05) ; U1.M3 v4(230.86,112.5) ; PR321.2 226.04,211.78 v1(226.69,211.13) 226.2,210.64 PC309.2 ; U1.H23 v4(209.86,108.5) ; U1.F29 v4(203.86,106.5) ; C2217.2 141.4,77.28 ; C2217.2 141.03,76.94 ; C2217.2 v1(142.27,76.94) ; U1.AH5 v4(228.86,129.5) ; 7.67,82.9 R12808.2 ; R12808.2 v1(8.02,83.68) ; R12808.2 8.02,82.53 ; U154.A9 v4(72.38,114.93) ; U3.G8 v4(212.23,159.07) ; U139.B9 v4(24.43,89.3) ; X7.3 v1(188.33,158.22) ; U155.E8 v4(44.65,119.31) ; C1257.2 203.35,76.94 v1(202.41,77.88) ; U4.E9 v4(238.35,157.47) ; U1.E23 v4(209.86,105.5) ; U25.A9 v4(293.1,93.39) ; U139.G6 v4(18.43,93.3) ; U5.E9 v4(226.18,157.47) ; PR369.1 79.71,138.05 v1(79.37,138.39) PU21.6 ; U1.L10 v4(223.86,111.5) ; C241.2 237.44,175 v1(237.62,175.18) ; U23.B12 v4(136.21,93.36) ; U23.D5 v4(134.21,101.36) ; PU21.4 78.72,142.8 ; PU21.4 78.72,141.02 ; PU21.4 78.42,142.11 ; U1.P10 v4(223.86,114.5) ; U25.K8 v4(283.1,94.39) ; U1.E17 v4(216.86,105.5) ; U23.L4 v4(126.21,102.36) ; U23.D2 v4(134.21,104.36) ; C37.2 v1(192.15,149.42) ; C1277.2 242.42,76.94 v1(242.62,77.14) ; C1277.2 241.37,76.94 ; C1277.2 241.74,77.28 ; v1(72.39,189.1) 72.07,188.78 PC433.2 PR498.2 ; U1.R10 v4(223.86,115.5) ; PQ20.2 v1(206.17,211.64) ; 85.69,126.07 R12479.2 ; R12479.2 v1(86.06,126.83) ; R12479.2 86.43,126.07 ; R12734.2 C2378.2 61.22,125.46 v1(61.54,125.14) ; 295.15,73.12 C1236.2 295.15,72.37 ; PR257.2 281.76,125.33 v1(281.43,125.66) 280.8,125.03 PC237.2 ; PR257.2 281.39,124.88 ; PR257.2 282.13,124.88 ; U1.L33 v4(199.86,111.5) ; U1.T9 v4(224.86,116.5) ; C2333.2 v1(7.24,98.66) ; C2333.2 6.27,99.21 ; C2333.2 6.27,98.11 ; C2085.2 v1(6.65,88.29) ; v1(49.78,190.88) 50.22,190.45 U145.3 ; U75.5 224.86,172.82 ; U75.5 226.52,172.82 ; 253.53,76.98 C1272.2 ; C1272.2 v1(253.9,77.7) ; C1272.2 254.27,76.98 ; U1.AN1 v4(232.86,134.5) ; U2.M9 v4(199.26,163.87) ; D43.1 v1(110.4,195.13) ; D43.1 109.86,196.14 ; D43.1 110.4,196.59 ; D43.1 110.95,196.14 ; R48.1 v1(172.44,134.05) ; R48.1 173.12,133.68 ; R48.1 173.12,134.42 ; U155.B9 v4(45.45,121.71) ; 84.59,111.46 C2449.2 ; C2449.2 84.94,111.83 ; C2002.2 v1(52.21,191.37) ; C2002.2 51.14,191.37 ; C2002.2 51.51,191.03 ; U154.B8 v4(71.33,116.13) ; U23.F1 v4(132.21,105.36) ; v1(144.4,191.64) 144.39,191.64 144.15,191.4 PR55.1 ; U23.R1 v4(122.21,105.36) ; U25.H11 v4(286.1,90.39) ; U124.10 v1(4.21,30.58) ; U1.M29 v4(203.86,112.5) ; U1.R2 v4(231.86,115.5) ; U23.H2 v4(130.21,104.36) ; C2239.1 190.7,120.46 v1(191.48,119.69) ; U25.L9 v4(282.1,93.39) ; U1.W11 v4(222.86,119.5) ; C1252.2 v1(217.59,77.65) ; C1252.2 217.21,76.94 ; C1252.2 217.96,76.94 ; U1.AL20 v4(212.86,132.5) ; C1592.1 43.81,200.69 ; C1592.1 43.06,200.69 ; C1592.1 v1(43.43,201.42) ; U1.AR37 v4(195.86,136.5) ; U1.R5 v4(228.86,115.5) ; U1.L9 v4(224.86,111.5) ; PR125.2 v1(292.56,143.01) ; U154.V18 v4(57.73,107.32) ; U1.M33 v4(199.86,112.5) ; U127.48 v1(74.52,87.69) ; 121.38,71.76 C1018.2 ; C1018.2 121.38,72.5 ; C1018.2 121.4,72.11 v1(122.1,72.11) ; C1018.2 121.73,72.13 ; U197.3 57.2,198.58 v1(57.28,198.5) ; C2399.2 125.83,76.68 ; C2399.2 v1(125.46,77.4) ; C2399.2 125.09,76.68 ; U25.E12 v4(289.1,89.39) ; C1093.2 v1(255.27,72.41) ; C1093.2 256.01,72.78 ; C1093.2 256.01,72.04 ; U1.H14 v4(219.86,108.5) ; v1(77.6,74.61) 77.89,74.61 78.42,74.08 U127.19 ; U6.T1 v4(262.9,118.66) ; R1761.2 v1(134.33,171.69) ; R1761.2 133.96,171.03 ; R1761.2 134.7,171.03 ; 20.27,17.41 U105.3 19.18,17.41 ; U23.E8 v4(133.21,98.36) ; C1234.2 309.23,81.19 ; C1234.2 v1(309.98,80.82) 309.98,82.27 C1235.2 309.81,83.66 v1(309.96,83.81) ; C1234.2 309.23,80.45 ; R12960.1 v1(118.87,179.96) ; R12772.2 154.21,116.54 v1(153.85,116.18) ; U5.N1 v4(233.38,164.68) ; 74.78,144.64 C2288.2 74.18,143.84 ; U1.U17 v4(216.86,117.5) ; C1268.2 v1(110.51,75.49) ; U1.L15 v4(218.86,111.5) ; U7.F1 v4(254.1,130.33) ; U23.B15 v4(136.21,90.36) ; U106.2 17.27,13.46 v1(17.02,13.21) ; R1181.1 55.16,201.04 v1(55.61,200.6) R1177.2 ; U1.M30 v4(202.86,112.5) ; U5.T1 v4(233.38,167.08) ; U25.N13 v4(280.1,88.39) ; U70.A13 v4(120.4,132.85) ; U25.K10 v4(283.1,91.39) ; U1.B13 v4(220.86,102.5) ; PR123.2 v1(286.77,142.19) ; R1041.2 111.63,192.97 v1(111.6,192.99) ; v1(74.22,74.68) 74.52,74.38 U127.13 ; U1.N22 v4(210.86,113.5) ; C1420.1 v1(109.06,194.24) ; U168.6 35.01,55.28 v1(35.31,54.99) ; U25.P6 v4(279.1,96.39) ; PR65.2 84.71,205.26 v1(84.71,205.89) ; U1.E10 v4(223.86,105.5) ; C2115.2 v1(3.89,90.38) ; U25.P2 v4(279.1,100.39) ; X8.2 v1(157.29,91.64) ; 176.67,125.79 R38.1 ; R38.1 v1(176.02,126.16) ; R38.1 176.67,126.53 ; U1.D12 v4(221.86,104.5) ; Q24.4 v1(52.33,199.39) ; 176.65,129.86 R56.2 ; R56.2 176.65,130.6 ; R56.2 v1(175.93,130.23) ; C1186.2 v1(206.88,72.37) ; U23.L16 v4(126.21,89.36) ; U1.AC25 v4(207.86,124.5) ; v1(51.42,71.98) 50.83,71.39 J8.13 ; C2079.2 v1(23.75,105.64) ; U23.L11 v4(126.21,94.36) ; 88.4,140.49 C2437.1 88.77,140.15 ; U1.AJ21 v4(211.86,130.5) ; C1090.2 261.9,72.78 ; C1090.2 v1(262.54,72.41) ; C1090.2 261.9,72.04 ; 102.29,83.46 C1632.1 ; C1632.1 102.29,84.55 ; C1632.1 102.53,84.01 v1(103.01,83.52) ; U25.P4 v4(279.1,98.39) ; U1.H4 v4(229.86,108.5) ; v1(50.42,128.34) R12282.1 ; U1.V33 v4(199.86,119.5) ; U154.N10 U154.P10 v4(60.78,114.13) ; U1.H34 v4(198.86,108.5) ; U25.T5 v4(277.1,97.39) ; v1(263.08,75.15) 262.7,75.54 C1293.2 ; 169.76,134.57 R46.1 ; R46.1 169.76,135.31 ; R46.1 v1(169.05,134.94) ; U23.H3 v4(130.21,103.36) ; U1.Y8 v4(225.86,121.5) ; U25.A11 v4(293.1,90.39) ; C1298.2 v1(134.66,75.24) ; U25.C11 v4(291.1,90.39) ; 88.86,76.94 C1297.2 ; C1297.2 89.23,77.28 ; U25.D8 v4(290.1,94.39) ; U7.K1 v4(258.1,130.33) ; v1(134.56,72.11) 133.47,72.11 C1030.2 ; U1.M27 v4(205.86,112.5) ; U1.J26 v4(206.86,109.5) ; U25.R12 v4(278.1,89.39) ; U1.AN34 v4(198.86,134.5) ; PR362.1 63.08,138.12 v1(63.34,138.39) PU20.6 ; U2.N1 v4(206.46,164.68) ; U154.J13 v4(65.73,111.33) ; U1.E15 v4(218.86,105.5) ; PC94.2 294.89,158.88 v1(294.71,158.7) ; U26.1 91.96,76.87 v8(92.21,76.62) ; C1030.2 133.81,72.13 ; C1030.2 133.46,72.5 ; C1030.2 133.46,71.76 ; U1.AD12 v4(221.86,125.5) ; U1.Y26 v4(206.86,121.5) ; PC11.2 v1(27.56,155.25) ; v1(187.4,139.75) 187.68,139.47 R12477.1 R12478.1 ; v1(175.93,131.51) R68.2 ; R68.2 176.65,131.14 ; R68.2 176.65,131.88 ; U23.F4 v4(132.21,102.36) ; 161.48,72 C1054.2 ; C1054.2 161.48,72.74 ; C1054.2 v1(162.19,72.37) ; C2273.1 32.5,80.29 ; C2273.1 31.76,80.29 ; C2273.1 32.13,79.94 ; U1.E11 v4(222.86,105.5) ; U5.E3 v4(231.78,157.47) ; C1289.2 v1(186.84,74.09) ; v1(233.5,207.16) 233.72,206.95 PC249.2 ; U1.Y30 v4(202.86,121.5) ; v1(54.68,79.67) C1370.2 ; v1(45.27,128.98) 45.04,129.21 C2325.2 ; C2054.1 v1(152.49,114.71) ; C2054.1 152.12,114.08 ; C2054.1 152.87,114.08 ; C1201.2 225.59,72.74 ; C1201.2 225.59,72 ; C1201.2 v1(226.3,72.37) ; 95.35,130.82 R12712.2 ; R12712.2 v1(94.49,131.19) ; R12712.2 95.35,131.56 ; U139.G5 v4(18.43,94.3) ; U25.C7 v4(291.1,95.39) ; U4.E3 v4(243.96,157.47) ; U1.AA36 v4(196.86,122.5) ; U1.AG34 v4(198.86,128.5) ; U1.AD11 v4(222.86,125.5) ; U7.G8 v4(254.9,136.73) ; v1(136.14,115.01) R12465.2 ; PC76.2 v1(216.28,207.91) ; PC76.2 215.91,207.2 ; PC76.2 216.65,207.2 ; U1.R21 v4(211.86,115.5) ; PR111.2 217.04,204.09 v1(217.55,204.6) ; U70.M6 v4(114,123.25) ; U1.Y36 v4(196.86,121.5) ; U1.K2 v4(231.86,110.5) ; U1.M10 v4(223.86,112.5) ; U23.N4 v4(124.21,102.36) ; C213.1 228.6,170.19 v1(228.6,169.67) ; v4(130.21,93.36) U23.H12 ; U23.H12 v4(129.21,93.36) ; U23.H12 U23.H11 U23.J11 U23.K11 v4(127.21,94.36) ; 163.28,82.53 C2052.2 ; C2052.2 164.38,82.53 ; C2052.2 v1(163.83,81.75) ; C2090.2 v1(12.2,104.74) ; U25.N1 v4(280.1,101.39) ; U1.L17 v4(216.86,111.5) ; U1.G9 v4(224.86,107.5) ; PC2.2 v1(102.23,207.04) ; U1.K3 v4(230.86,110.5) ; R1042.2 v1(111.6,191.7) ; U2.K9 v4(199.26,162.27) ; v1(103.76,101.79) 103.5,101.53 CN6.1 ; U1.AL5 v4(228.86,132.5) ; U3.H9 v4(211.43,159.87) ; U5.E8 v4(226.98,157.47) ; U1.L6 v4(227.86,111.5) ; U1.AA23 v4(209.86,122.5) ; v8(244.72,76.62) 244.47,76.87 U31.1 ; U1.AG15 v4(218.86,128.5) ; R12434.1 57.48,202.44 v1(56.87,201.83) ; U139.E2 v4(21.43,97.3) ; v1(21.97,13.21) 22.09,13.32 C2430.1 ; U1.H16 v4(217.86,108.5) ; U1.AN31 v4(201.86,134.5) ; X3.2 v1(131.47,117.5) ; U1.E2 v4(231.86,105.5) ; 88.64,197.19 U144.4 88.91,198.04 ; v1(271.49,129.81) 271.31,129.99 C229.1 ; U25.E10 v4(289.1,91.39) ; v4(13.43,91.3) U139.M7 ; C1269.2 v1(110.51,74.09) ; C197.1 v1(199.68,175.07) ; R12938.2 v1(16.62,83.68) ; U3.D8 v4(212.23,156.67) ; R1066.1 v1(111.6,194.24) ; Q23.1 50.9,195.59 ; Q23.1 50.35,195.86 ; Q23.1 v1(49.4,195.59) ; C1303.2 v1(214.71,75.49) ; U1.AF17 v4(216.86,127.5) ; U1.P16 v4(217.86,114.5) ; PR496.2 PC434.2 v1(72.07,185.12) ; U1.U11 v4(222.86,117.5) ; U154.E8 v4(68.93,116.13) ; U1.AN16 v4(217.86,134.5) ; PC6.2 v1(103.6,213.8) ; C1314.2 v1(150.6,75.49) ; U1.L11 v4(222.86,111.5) ; U1.F13 v4(220.86,106.5) ; 167.79,97.31 C2057.1 ; C2057.1 168.54,97.31 ; C2057.1 v1(168.16,96.54) ; U1.AC3 v4(230.86,124.5) ; U139.G8 v4(18.43,90.3) ; U1.P12 v4(221.86,114.5) ; C1369.1 v1(55.7,79.65) ; U155.J2 v4(40.65,116.91) ; C1304.2 v1(214.71,74.09) ; U1.C16 v4(217.86,103.5) ; U1.AR12 v4(221.86,136.5) ; R13086.2 v1(79.78,106.05) ; v1(217.04,209.55) 216.93,209.66 PR112.2 ; U3.E3 v4(217.03,157.47) ; 267.73,76.36 C1267.2 267.39,75.99 ; C1418.1 v1(114.78,185.35) ; C1279.2 250.95,74.09 v1(251.34,73.71) ; R1067.1 v1(121.13,182.81) ; U139.F4 v4(20.43,95.3) ; U1.AA10 v4(223.86,122.5) ; U1.AB10 v4(223.86,123.5) ; v1(138.3,115.01) R12462.1 ; U155.T9 v4(45.45,110.51) ; U25.A7 v4(293.1,95.39) ; PR426.1 v5(4.77,168.02) ; PR426.1 4.4,168.68 ; PR426.1 5.14,168.68 ; C1377.1 87.83,188.34 v1(88.16,188.67) ; U1.AR3 v4(230.86,136.5) ; U1.C20 v4(212.86,103.5) ; U1.Y4 v4(229.86,121.5) ; 308.79,73.5 C1232.2 308.79,72.75 ; v1(115.64,92.84) 115.37,92.56 U86.4 ; U23.K2 v4(127.21,104.36) ; U25.C2 v4(291.1,100.39) ; U1.Y5 v4(228.86,121.5) ; U172.2 v1(79.25,169.35) ; U4.F1 v4(245.56,158.27) ; U37.1 271.5,76.92 v8(271.75,76.67) ; U1.B9 v4(224.86,102.5) ; v1(222.76,210.5) 223.28,210.5 PQ17.2 ; U23.N15 v4(124.21,90.36) U23.N16 v4(124.21,89.36) ; 10.77,77.1 C2042.1 ; C2042.1 v1(10.03,77.47) ; C2042.1 10.77,77.84 ; U1.K27 v4(205.86,110.5) ; R40.1 169.76,137.35 ; R40.1 169.76,136.61 ; R40.1 v1(169.05,136.98) ; U1.G13 v4(220.86,107.5) ; v1(275.38,123.02) PC311.2 ; U6.M9 v4(259.7,125.86) ; v1(137.16,115.01) R12464.2 ; R304.2 v1(290.2,107.45) ; U1.W7 v4(226.86,119.5) ; U1.A13 v4(220.86,101.5) ; U154.J11 U154.J10 v4(65.73,114.53) ; U1.AB18 v4(215.86,123.5) ; U25.R17 v4(278.1,84.39) ; U23.K15 v4(127.21,90.36) ; PR296.1 v1(52.81,209.75) ; C1274.2 v1(174.81,74.09) ; C208.1 230.1,169.82 v1(230.25,169.67) ; v1(62.1,127.51) 62.18,127.43 PC344.2 ; C1242.2 v1(303.37,80.82) ; U1.H15 v4(218.86,108.5) ; U25.E4 v4(289.1,98.39) ; U1.B37 v4(195.86,102.5) ; U5.G8 v4(226.98,159.07) ; U1.AM3 v4(230.86,133.5) ; Q18.2 281.9,187.04 v1(282.19,187.32) ; U1.E4 v4(229.86,105.5) ; U1.AG23 v4(209.86,128.5) ; U1.W2 v4(231.86,119.5) ; U139.D6 v4(22.43,93.3) ; v1(76.63,210.11) 76.11,210.63 PQ3.2 ; U1.Y10 v4(223.86,121.5) ; C2055.2 v1(155.2,112.27) ; C2055.2 154.65,113.14 ; C2055.2 155.74,113.14 ; C1687.1 131.08,116.95 ; C1687.1 131.08,116.21 ; C1687.1 131.8,116.58 v1(131.97,116.75) ; D65.2 37.52,16.57 v1(37.21,16.26) ; U1.D8 v4(225.86,104.5) ; U155.P9 v4(45.45,112.11) ; U1.E8 v4(225.86,105.5) ; U5.A8 v4(226.98,154.27) ; C187.1 217.89,174.72 v1(217.89,175.18) ; U2.D2 v4(205.66,156.67) ; U155.G8 v4(44.65,117.71) ; U1.V22 v4(210.86,118.5) ; U1.D34 v4(198.86,104.5) ; U127.35 79.75,84 v1(79.5,83.75) 79.9,83.35 U127.34 ; U104.4 32.07,16.56 ; U104.4 32.92,16.29 ; U1.G33 v4(199.86,107.5) ; U81.4 102.07,186.22 ; U81.4 v1(99.95,186.22) ; U81.4 101.21,186.49 ; U23.F10 v4(132.21,95.36) ; v1(64.01,194.58) v1(63.3,194.58) ; 229.29,76.94 C1282.2 ; C1282.2 v1(229.66,77.65) ; C1282.2 230.03,76.94 ; v1(51.31,197.1) 51.48,197.28 C2446.2 ; PC192.2 v1(253.28,201.44) ; U1.L14 v4(219.86,111.5) ; U1.AE31 v4(201.86,126.5) ; PR137.2 v1(280.19,136.66) ; J5.15 v1(276.32,195.56) ; U1.H13 v4(220.86,108.5) ; U25.G9 v4(287.1,93.39) ; U25.U7 v4(276.1,95.39) 275.6,94.89 U25.V7 ; U1.U23 v4(209.86,117.5) ; v1(100.79,172.69) 101.48,173.39 R1651.1 ; U25.P8 v4(279.1,94.39) ; U25.A15 v4(293.1,86.39) ; U154.C8 v4(70.53,116.13) ; U25.N7 v4(280.1,95.39) ; U1.AD16 v4(217.86,125.5) ; U1.AL14 v4(219.86,132.5) ; U1.D24 v4(208.86,104.5) ; 25.26,68.17 R12918.1 ; R12918.1 v1(25.63,68.8) ; R12918.1 26,68.17 ; U7.D2 v4(252.5,131.13) ; v1(159.38,85.34) 159.56,85.52 C2400.1 ; R1448.1 v1(183.39,121.34) ; R1448.1 184.12,121.71 ; R1448.1 184.12,120.97 ; U1.T18 v4(215.86,116.5) ; U23.H16 v4(130.21,89.36) ; v4(62.53,112.93) U154.M11 U154.M10 U154.M9 62.93,116.07 v1(62.46,116.53) ; U139.J6 v4(16.43,93.3) ; v8(21.39,148.56) 21.04,148.21 PU13.17 ; U25.F5 v4(288.1,97.39) ; U5.K1 v4(233.38,162.27) ; U1.D26 v4(206.86,104.5) ; U124.12 v1(5.42,27.55) ; U25.V9 275.6,92.89 v4(276.1,93.39) U25.U9 ; U1.AB26 v4(206.86,123.5) ; U154.D8 v4(69.73,116.13) ; v1(302.89,85.09) 302.67,84.86 C1335.2 ; PC1.2 v1(103.6,207.04) ; U23.R5 v4(122.21,101.36) ; U1.E28 v4(204.86,105.5) ; U1.K8 v4(225.86,110.5) ; U5.D8 v4(226.98,156.67) ; U1.L26 v4(206.86,111.5) ; U1.M14 v4(219.86,112.5) ; U25.D6 v4(290.1,96.39) ; C1414.1 118.59,185.6 118.48,185.5 v1(118.48,185.48) ; 187.7,131.06 R33.1 ; R33.1 186.81,131.43 v1(186.25,132) ; R33.1 187.7,131.8 ; U1.AJ9 v4(224.86,130.5) ; U1.A25 v4(207.86,101.5) ; U1.AA17 v4(216.86,122.5) ; R35.1 187.1,128.89 v1(186.94,128.73) ; C2448.2 v1(132.51,191.95) ; C2448.2 132.14,191.2 ; C2448.2 132.88,191.2 ; C203.1 240.34,174.85 v1(240.67,175.18) ; U1.E5 v4(228.86,105.5) ; C1198.2 219.69,72.74 ; C1198.2 v1(218.96,72.37) ; C1198.2 219.69,72 ; 132.97,172.22 C2431.1 ; C2431.1 133.38,172.57 v1(133.73,172.21) ; C2431.1 132.6,172.57 ; R12374.1 109.22,139.83 v1(108.97,139.57) ; R12374.1 108.85,140.49 ; R12374.1 109.59,140.49 ; U1.AC17 v4(216.86,124.5) ; v1(144.8,84.29) 144.86,84.23 U175.6 ; U25.F7 v4(288.1,95.39) ; U1.AA1 v4(232.86,122.5) ; R1515.1 v1(26.04,14.69) ; U1.F9 v4(224.86,106.5) ; U23.T6 v4(121.21,100.36) ; U1.E16 v4(217.86,105.5) ; 125.2,178.97 U176.10 125.47,179.82 ; U1.AE8 v4(225.86,126.5) ; C1688.2 v1(126.92,117.9) ; C1688.2 126.37,116.95 ; C1688.2 127.46,116.95 ; U1.F37 v4(195.86,106.5) ; U1.Y7 v4(226.86,121.5) ; U1.E3 v4(230.86,105.5) ; R302.2 v1(275.01,106.55) ; R302.2 274.64,105.86 ; R302.2 275.39,105.86 ; U1.H12 v4(221.86,108.5) ; U1.L22 v4(210.86,111.5) ; U1.AL23 v4(209.86,132.5) ; U1.AR24 v4(208.86,136.5) ; U155.E2 v4(39.85,119.31) ; PR149.2 v1(280.16,132.97) ; U1.AN10 v4(223.86,134.5) ; U155.D1 v4(39.05,120.11) ; U23.L15 v4(126.21,90.36) ; U1.U21 v4(211.86,117.5) ; U25.L11 v4(282.1,90.39) ; v1(274.95,72.41) C1105.2 ; U1.K34 v4(198.86,110.5) ; R65.2 176.65,133.15 ; R65.2 v1(175.93,132.78) ; R65.2 176.65,132.41 ; C207.2 v1(220.41,175.18) ; U25.D12 v4(290.1,89.39) ; U154.L14 v4(64.13,110.53) ; U1.Y14 v4(219.86,121.5) ; U1.B33 v4(199.86,102.5) ; U7.A2 v4(250.1,131.13) ; U1.E30 v4(202.86,105.5) ; U25.B15 v4(292.1,86.39) ; U1.L8 v4(225.86,111.5) ; U1.V16 v4(217.86,118.5) ; U1.E33 v4(199.86,105.5) ; U1.W36 v4(196.86,119.5) ; U25.F17 v4(288.1,84.39) ; U137.3 94.88,175.91 v1(95.25,176.28) ; U1.T25 v4(207.86,116.5) ; J8.8 v1(44.83,75.95) ; C2433.1 85.57,173.83 ; C2433.1 85.57,173.09 ; C2433.1 v1(86.34,173.46) ; X5.2 v1(158.62,83.47) ; Q24.1 49.95,201.26 v1(49.53,201.68) ; U1.AL26 v4(206.86,132.5) ; v1(60.96,133.6) 61.34,133.22 61.34,132.44 61.11,132.21 U200.2 ; Y5.2 21.97,80.93 21.59,80.54 21.59,76.92 C2394.1 22.29,75.82 22.67,75.44 25.67,75.44 v1(27.19,76.96) Y5.4 28.68,78.33 29.44,79.1 C2393.1 ; U7.E8 v4(253.3,136.73) ; D67.2 v1(7.11,14.54) ; D98.1 v1(62.1,38.22) ; U1.U5 v4(228.86,117.5) ; U25.C12 v4(291.1,89.39) ; PC83.2 v1(281.27,139.08) ; U1.V24 v4(208.86,118.5) ; U1.V20 v4(212.86,118.5) ; U23.K7 v4(127.21,99.36) ; U1.J34 v4(198.86,109.5) ; U1.P14 v4(219.86,114.5) ; U25.H7 v4(286.1,95.39) ; C1308.2 v1(277.14,76.45) ; U127.14 v1(75.17,74.75) ; U25.V1 v4(275.1,101.39) ; U25.J8 v4(285.1,94.39) ; U23.B16 v4(136.21,89.36) ; R1744.1 108.17,172.12 ; R1744.1 107.43,172.12 ; R1744.1 v1(107.8,171.45) ; U3.E8 v4(212.23,157.47) ; U3.C9 v4(211.43,155.87) ; C1006.2 110.33,72.37 v1(110.37,72.33) ; C1006.2 109.31,72.74 ; C1006.2 109.31,72 ; C1636.2 5.01,102.64 ; C1636.2 4.09,102.64 v1(3.56,102.11) ; C1636.2 4.47,102.17 ; U70.N1 v4(110,122.45) ; U5.D2 v4(232.58,156.67) ; C2051.1 160.78,84.23 ; C2051.1 160.41,83.88 ; U1.AD26 v4(206.86,125.5) ; U23.N14 v4(124.21,91.36) ; U23.R13 v4(122.21,92.36) ; U1.N26 v4(206.86,113.5) ; R63.2 184.17,125.44 ; R63.2 184.17,124.7 ; R63.2 v1(183.45,125.07) ; U25.T7 v4(277.1,95.39) ; U5.A2 v4(232.58,154.27) ; 291.91,106.27 R305.2 ; R305.2 292.65,106.27 ; R305.2 v1(292.28,106.93) ; U139.D3 v4(22.43,96.3) ; U23.F3 v4(132.21,103.36) ; U154.N4 v4(61.73,119.33) ; R1199.1 24.9,51.67 ; R1199.1 24.55,51.3 ; U23.F16 v4(132.21,89.36) ; U1.L37 v4(195.86,111.5) ; C2392.1 36.91,57.61 v1(38.1,58.8) ; U1.W15 v4(218.86,119.5) ; U70.A1 v4(110,132.85) ; C894.2 32.12,103.87 v1(32.45,104.2) ; C894.2 31.22,103.87 ; C894.2 31.59,103.51 ; U25.N3 v4(280.1,99.39) ; U23.L12 v4(126.21,93.36) ; R1101.1 v1(101.21,180.87) ; R1101.1 101.59,181.5 ; R1101.1 100.84,181.5 ; U1.G21 v4(211.86,107.5) ; PR498.2 73.09,188.69 ; PR498.2 73.46,188.35 ; U1.T14 v4(219.86,116.5) ; U155.D8 v4(44.65,120.11) ; U1.AL8 v4(225.86,132.5) ; U1.AU20 v4(212.86,138.5) ; U1.J20 v4(212.86,109.5) ; U154.B9 v4(71.33,115.33) ; R13031.1 v1(97.16,180.87) ; R13031.1 96.78,181.5 ; R13031.1 97.53,181.5 ; D61.2 v1(72.24,39.96) ; U1.Y35 v4(197.86,121.5) ; U1.AH25 v4(207.86,129.5) ; U1.Y27 v4(205.86,121.5) ; U1.AF14 v4(219.86,127.5) ; U25.V18 v4(275.1,83.39) ; R1879.1 v1(110.83,187.39) ; C2357.1 138.62,130.97 ; C2357.1 v1(138.25,132.03) ; C2357.1 137.88,130.97 ; U1.T8 v4(225.86,116.5) ; U155.B1 v4(39.05,121.71) ; U23.D10 v4(134.21,95.36) ; 169.77,138.75 R1815.1 ; R1815.1 v1(168.96,139.12) ; R1815.1 169.77,139.49 ; U139.K4 v4(15.43,95.3) ; U139.H11 v4(17.43,87.3) ; U1.W1 v4(232.86,119.5) ; U139.J3 v4(16.43,96.3) ; v8(232.64,76.62) 232.39,76.87 U28.1 ; U1.AA32 v4(200.86,122.5) ; R12804.2 v1(11.53,83.67) ; R12924.1 v1(94.89,135.03) ; U25.R8 v4(278.1,94.39) ; U7.E3 v4(253.3,131.93) ; C994.2 91.34,72.74 ; C994.2 91.34,72 ; C994.2 v1(90.6,72.37) ; U1.Y20 v4(212.86,121.5) ; U154.N13 v4(62.53,111.33) U154.M13 ; C1415.1 v1(117.32,185.48) ; U155.B3 v4(40.65,122.51) ; U1.V14 v4(219.86,118.5) ; R311.2 v1(298.08,85.2) ; U124.13 v1(18.27,28.38) ; U70.E11 v4(118.8,128.85) ; U70.G7 v4(115.6,128.05) ; U1.AR36 v4(196.86,136.5) ; U46.4 v1(266.83,110.77) ; U25.T13 v4(277.1,88.39) ; U177.2 119.89,174.12 v1(119.63,173.86) ; R64.2 v1(172.4,136.6) ; R64.2 173.12,136.97 ; R64.2 173.12,136.23 ; U1.G5 v4(228.86,107.5) ; U6.H1 v4(255.7,118.66) ; U71.4 89.61,177.24 v1(90.17,177.8) ; J5.26 v1(287.46,199) ; U1.G37 v4(195.86,107.5) ; C2374.1 v1(63.83,133.73) ; U25.E8 v4(289.1,94.39) ; U1.F25 v4(207.86,106.5) ; U1.AE23 v4(209.86,126.5) ; U6.H9 v4(255.7,125.86) ; U1.E9 v4(224.86,105.5) ; U25.F13 v4(288.1,88.39) ; R1910.1 v1(14.71,14.41) ; U1.N13 v4(220.86,113.5) ; U1.N10 v4(223.86,113.5) ; U1.E31 v4(201.86,105.5) ; U155.A9 v4(45.45,122.51) ; D44.1 v1(42.62,193.86) ; U25.T14 v4(277.1,87.39) ; U139.M3 v4(13.43,96.3) ; U1.H22 v4(210.86,108.5) ; U25.R16 v4(278.1,85.39) ; PR66.2 84.82,208.7 v1(84.68,208.56) ; U1.AU17 v4(216.86,138.5) ; Y2.4 v1(83.76,86.58) ; PC79.2 v1(218.31,204.53) ; v1(30.5,35.38) D92.8 D92.12 D92.3 ; U23.M10 v4(125.21,95.36) ; U1.P20 v4(212.86,114.5) ; U23.F14 v4(132.21,91.36) ; v1(76.88,65.41) 77.2,65.72 U152.2 ; U1.AF22 v4(210.86,127.5) ; U1.AB22 v4(210.86,123.5) ; C1278.2 v1(251.75,75.49) ; U1.L25 v4(207.86,111.5) ; U4.E8 v4(239.15,157.47) ; U25.F18 v4(288.1,83.39) ; U23.L1 v4(126.21,105.36) ; U1.V10 v4(223.86,118.5) ; U1.E29 v4(203.86,105.5) ; U1.E1 v4(232.86,105.5) ; PC28.2 v1(84.96,207.71) ; U1.G17 v4(216.86,107.5) ; U1.K20 v4(212.86,110.5) ; U1.T31 v4(201.86,116.5) ; U1.T12 v4(221.86,116.5) ; 176.65,133.68 R52.2 ; R52.2 176.65,134.42 ; R52.2 v1(175.93,134.05) ; U1.A9 v4(224.86,101.5) ; U6.E3 v4(253.3,120.26) ; U1.C8 v4(225.86,103.5) ; U154.L10 U154.K10 v4(64.93,114.53) ; 57.38,52.33 R1270.1 ; R1270.1 57.03,52.7 ; U1.AE15 v4(218.86,126.5) ; U139.B4 v4(24.43,95.3) ; U23.H14 v4(130.21,91.36) ; U25.C6 v4(291.1,96.39) ; U1.AF20 v4(212.86,127.5) ; U139.H3 v4(17.43,96.3) ; U154.E10 v4(68.93,114.53) ; U25.K12 v4(283.1,89.39) ; U1.K32 v4(200.86,110.5) ; U23.B5 v4(136.21,101.36) ; U1.R23 v4(209.86,115.5) ; U1.AC13 v4(220.86,124.5) ; U154.N14 v4(61.73,110.53) ; U23.C7 v4(135.21,99.36) ; U1.U10 v4(223.86,117.5) ; C2113.2 v1(103.19,82.61) ; X2.2 v1(61.43,76.11) ; U25.N15 v4(280.1,86.39) ; U1.R17 v4(216.86,115.5) ; U5.B2 v4(232.58,155.07) ; U1.L5 v4(228.86,111.5) ; U1.H26 v4(206.86,108.5) ; U1.R25 v4(207.86,115.5) ; U1.AU26 v4(206.86,138.5) ; C230.2 211.72,174.98 v1(211.93,175.18) ; U1.N33 v4(199.86,113.5) ; U25.F11 v4(288.1,90.39) ; U1.AH37 v4(195.86,129.5) ; U1.AH20 v4(212.86,129.5) ; U25.D4 v4(290.1,98.39) ; U2.F1 v4(206.46,158.27) ; v1(38.83,67.94) J8.1 ; U25.T6 v4(277.1,96.39) ; U25.T3 v4(277.1,99.39) ; U1.K12 v4(221.86,110.5) ; U1.AA19 v4(214.86,122.5) ; R1017.2 v1(130.36,194.37) ; U23.L3 v4(126.21,103.36) ; U1.AJ18 v4(215.86,130.5) ; U154.N5 v4(61.73,118.53) ; R12288.1 v1(72.69,64.65) ; R12288.1 73.43,65.02 ; R12288.1 73.43,64.27 ; U1.W28 v4(204.86,119.5) ; U25.P10 v4(279.1,91.39) ; C1264.2 v1(238.86,74.09) ; U1.L18 v4(215.86,111.5) ; U23.R3 v4(122.21,103.36) ; U1.AD18 v4(215.86,125.5) ; U23.F5 v4(132.21,101.36) ; U23.D16 v4(134.21,89.36) ; U1.AB28 v4(204.86,123.5) ; U23.H5 v4(130.21,101.36) ; U1.W17 v4(216.86,119.5) ; U1.T3 v4(230.86,116.5) ; U139.F3 v4(20.43,96.3) ; U1.AE25 v4(207.86,126.5) ; U1.AC9 v4(224.86,124.5) ; U1.AD28 v4(204.86,125.5) ; U1.T33 v4(199.86,116.5) ; C2091.2 12.47,104.04 v1(12.19,103.76) ; U7.K9 v4(258.1,137.53) ; U1.K6 v4(227.86,110.5) ; U155.G9 v4(45.45,117.71) ; U34.1 256.63,76.92 v8(256.88,76.67) ; U174.6 v1(147.07,90.45) ; v1(58.04,198.25) 58.25,198.03 C2330.2 ; U25.U11 v4(276.1,90.39) ; v1(178.31,157.73) 178.21,157.63 C2043.2 ; U25.D2 v4(290.1,100.39) ; U1.R28 v4(204.86,115.5) ; U1.E34 v4(198.86,105.5) ; U1.AB16 v4(217.86,123.5) ; U25.V11 v4(275.1,90.39) ; J8.2 v1(38.83,75.95) ; U139.L9 v4(14.43,89.3) ; U25.A3 v4(293.1,99.39) ; C183.2 245.17,174.72 v1(245.62,175.18) ; U23.D3 v4(134.21,103.36) ; U1.V26 v4(206.86,118.5) ; U1.T26 v4(206.86,116.5) ; J5.7 v1(268.32,195.64) ; U1.E6 v4(227.86,105.5) ; U1.AD24 v4(208.86,125.5) ; U5.E1 v4(233.38,157.47) ; U25.A1 v4(293.1,101.39) ; U3.F1 v4(218.63,158.27) ; U23.R14 v4(122.21,91.36) ; U1.AD14 v4(219.86,125.5) ; U1.AJ12 v4(221.86,130.5) ; U139.E8 v4(21.43,90.3) ; U1.N5 v4(228.86,113.5) ; U1.H18 v4(215.86,108.5) ; U1.T20 v4(212.86,116.5) ; U1.M5 v4(228.86,112.5) ; U136.3 v1(100.71,175.9) ; U3.K9 v4(211.43,162.27) ; U1.H17 v4(216.86,108.5) ; C1373.1 v1(135.39,182.5) ; PR53.2 v1(27.32,167.44) ; U1.D4 v4(229.86,104.5) ; C2084.2 v1(6.84,86.38) ; U1.D20 v4(212.86,104.5) ; U23.R12 v4(122.21,93.36) ; U23.L13 v4(126.21,92.36) ; v1(203.27,211.66) PC367.2 ; U3.D2 v4(217.83,156.67) ; R1050.1 178.18,154.86 ; R1050.1 v1(177.42,154.51) ; R1050.1 178.55,154.51 ; U3.T1 v4(218.63,167.08) ; PC15.2 v1(240.48,192.46) ; R1691.1 v1(7.82,70.41) ; U1.E25 v4(207.86,105.5) ; U1.AA4 v4(229.86,122.5) ; D69.2 v1(14.47,67.55) ; U1.B1 v4(232.86,102.5) ; U1.L16 v4(217.86,111.5) ; U1.P24 v4(208.86,114.5) ; U1.AR27 v4(205.86,136.5) ; R12776.2 183.55,156.11 v1(183.77,156.34) ; U1.AA5 v4(228.86,122.5) ; U139.B1 v4(24.43,98.3) ; U1.F33 v4(199.86,106.5) ; U198.2 v1(88.77,109.42) ; U139.D4 v4(22.43,95.3) ; U7.C9 v4(251.7,137.53) ; PC14.2 v1(27.48,168.97) ; U1.Y29 v4(203.86,121.5) ; U1.M35 v4(197.86,112.5) ; U7.B2 v4(250.9,131.13) ; U4.A8 v4(239.15,154.27) ; U1.AG22 v4(210.86,128.5) ; U1.AR30 v4(202.86,136.5) ; v1(55.68,195.91) C1595.2 R1158.1 ; R1880.1 v1(109.76,187.39) ; R12811.2 v1(21.46,82.86) ; U1.N17 v4(216.86,113.5) ; U1.AU2 v4(231.86,138.5) ; U1.B5 v4(228.86,102.5) ; U1.L19 v4(214.86,111.5) ; C1294.2 v1(263.1,74.14) ; U5.K9 v4(226.18,162.27) ; U1.R7 v4(226.86,115.5) ; U6.D8 v4(252.5,125.06) ; U1.AD22 v4(210.86,125.5) ; U139.J4 v4(16.43,95.3) ; U25.R2 v4(278.1,100.39) ; U1.AG19 v4(214.86,128.5) ; U25.U15 v4(276.1,86.39) ; U23.N3 v4(124.21,103.36) ; U25.T4 v4(277.1,98.39) ; U154.P4 v4(60.93,119.33) ; U7.N1 v4(260.5,130.33) ; U25.A13 v4(293.1,88.39) ; U155.T1 v4(39.05,110.51) ; 187.33,137.72 R12478.1 ; R12478.1 187.68,137.35 ; U1.E32 v4(200.86,105.5) ; U23.R16 v4(122.21,89.36) ; U1.AU29 v4(203.86,138.5) ; U1.Y22 v4(210.86,121.5) ; U2.E3 v4(204.86,157.47) ; U1.M9 v4(224.86,112.5) ; C1253.2 v1(98.43,75.49) ; U155.P1 v4(39.05,112.11) ; U139.F6 v4(20.43,93.3) ; U1.E37 v4(195.86,105.5) ; PC90.2 v1(285.13,128.61) ; D68.2 v1(28.38,66.97) ; U2.E9 v4(199.26,157.47) ; U1.M8 v4(225.86,112.5) ; PC31.2 v1(85.82,205.54) ; C192.1 v1(200.65,175.07) ; U6.A8 v4(250.1,125.06) ; C1288.2 v1(186.84,75.49) ; U1.P28 v4(204.86,114.5) ; U1.E35 v4(197.86,105.5) ; U25.R6 v4(278.1,96.39) ; U25.L7 v4(282.1,95.39) ; U1.N25 v4(207.86,113.5) ; U2.D8 v4(200.06,156.67) ; U1.P18 v4(215.86,114.5) ; U1.U19 v4(214.86,117.5) ; U25.V13 275.6,88.89 v4(276.1,88.39) U25.U13 ; U1.C25 v4(207.86,103.5) ; R12813.2 v1(17.5,82.86) ; C2332.2 83.98,140.79 v1(83.8,140.97) ; U139.H5 v4(17.43,94.3) ; U139.J5 v4(16.43,94.3) ; U1.U27 v4(205.86,117.5) ; U25.V15 v4(275.1,86.39) ; U23.F13 v4(132.21,92.36) ; U1.Y12 v4(221.86,121.5) ; U139.L1 v4(14.43,98.3) ; U6.K1 v4(258.1,118.66) ; U1.AB20 v4(212.86,123.5) ; U1.H30 v4(202.86,108.5) ; U58.12 v1(94.69,198.51) ; U154.AA19 v4(55.33,106.52) ; U70.J4 v4(112.4,125.65) ; U6.F1 v4(254.1,118.66) ; U6.C9 v4(251.7,125.86) ; C1309.2 v1(278,74.14) ; U1.F1 v4(232.86,106.5) ; U124.24 v1(18.68,42.39) ; U165.2 v1(81.92,169.35) ; U1.M24 v4(208.86,112.5) ; U1.P26 v4(206.86,114.5) ; U1.M4 v4(229.86,112.5) ; U139.H6 v4(17.43,93.3) ; U1.T30 v4(202.86,116.5) ; U4.K9 v4(238.35,162.27) ; U1.N12 v4(221.86,113.5) ; U4.H9 v4(238.35,159.87) ; U70.N13 v4(120.4,122.45) ; U1.B25 v4(207.86,102.5) ; U1.T22 v4(210.86,116.5) ; U4.N1 v4(245.56,164.68) ; U1.AA13 v4(220.86,122.5) ; U1.L2 v4(231.86,111.5) ; U1.F5 v4(228.86,106.5) ; PR131.1 v1(281.31,140.03) ; U1.E19 v4(214.86,105.5) ; U1.J12 v4(221.86,109.5) ; U5.M9 v4(226.18,163.87) ; U25.N18 v4(280.1,83.39) ; U6.N1 v4(260.5,118.66) ; C2403.1 v1(89,134.09) ; C1239.2 v1(300.99,85.35) ; U1.AF29 v4(203.86,127.5) ; U1.E7 v4(226.86,105.5) ; U6.A2 v4(250.1,119.46) ; U4.G8 v4(239.15,159.07) ; U1.U15 v4(218.86,117.5) ; U23.L14 v4(126.21,91.36) ; U1.H8 v4(225.86,108.5) ; U2.A2 v4(205.66,154.27) ; U1.H19 v4(214.86,108.5) ; R13042.2 v1(141.63,193.42) ; U3.H1 v4(218.63,159.87) ; U1.L31 v4(201.86,111.5) ; U1.L1 v4(232.86,111.5) ; U1.W29 v4(203.86,119.5) ; C1258.2 v1(161.84,73.15) ; U111.2 v1(83.82,123.14) ; U1.N28 v4(204.86,113.5) ; v1(167.77,81.53) 167.77,81.91 R1082.1 ; U23.L2 v4(126.21,104.36) ; U23.L5 v4(126.21,101.36) ; U70.F3 v4(111.6,128.85) ; PR265.2 v1(233.49,209.9) ; v1(95.76,174.05) R1657.1 ; U1.AC21 v4(211.86,124.5) ; U1.W21 v4(211.86,119.5) ; U154.J14 v4(65.73,110.53) ; U1.Y1 v4(232.86,121.5) ; U25.T16 v4(277.1,85.39) ; U1.M28 v4(204.86,112.5) ; U1.Y16 v4(217.86,121.5) ; U25.C1 v4(291.1,101.39) ; U1.AR21 v4(211.86,136.5) ; U1.T29 v4(203.86,116.5) ; U1.AG13 v4(220.86,128.5) ; C234.1 v1(271.38,139.13) ; U6.E9 v4(253.3,125.86) ; U1.E22 v4(210.86,105.5) ; U3.B2 v4(217.83,155.07) ; U25.B13 v4(292.1,88.39) ; U1.J24 v4(208.86,109.5) ; U1.Y9 v4(224.86,121.5) ; U25.T15 v4(277.1,86.39) ; U1.AD20 v4(212.86,125.5) ; U2.A8 v4(200.06,154.27) ; C223.2 v1(233.94,175.28) ; R12939.2 v1(15.15,83.65) ; U1.W23 v4(209.86,119.5) ; U1.E13 v4(220.86,105.5) ; U4.H1 v4(245.56,159.87) ; U3.N1 v4(218.63,164.68) ; U1.E21 v4(211.86,105.5) ; U139.F5 v4(20.43,94.3) ; U1.N20 v4(212.86,113.5) ; U6.G8 v4(254.9,125.06) ; U2.G8 v4(200.06,159.07) ; U1.W27 v4(205.86,119.5) ; U1.C12 v4(221.86,103.5) ; U1.H25 v4(207.86,108.5) ; U1.AC15 v4(218.86,124.5) ; U25.T12 v4(277.1,89.39) ; U23.B14 v4(136.21,91.36) ; U6.E8 v4(253.3,125.06) ; U1.AR6 v4(227.86,136.5) ; U1.M34 v4(198.86,112.5) ; U25.P14 v4(279.1,87.39) ; U1.N19 v4(214.86,113.5) ; U2.E1 v4(206.46,157.47) ; R123.2 v1(210.36,171.66) ; U25.P12 v4(279.1,89.39) ; U1.AF18 v4(215.86,127.5) ; U7.A8 v4(250.1,136.73) ; R12809.2 v1(10.61,83.63) ; U1.AF26 v4(206.86,127.5) ; U1.P33 v4(199.86,114.5) ; U23.K10 v4(127.21,95.36) ; U1.L7 v4(226.86,111.5) ; U25.C8 v4(291.1,94.39) ; U1.AF16 v4(217.86,127.5) ; U1.K31 v4(201.86,110.5) ; C2426.1 v1(81.2,124.46) ; U1.AE13 v4(220.86,126.5) ; U23.R2 v4(122.21,104.36) ; U139.G4 v4(18.43,95.3) ; U1.G1 v4(232.86,107.5) ; U25.C4 v4(291.1,98.39) ; U154.Y19 v4(56.13,106.52) ; U70.C3 v4(112.4,130.45) ; U25.R10 v4(278.1,91.39) ; C2327.1 v1(50.42,129.36) ; U1.K4 v4(229.86,110.5) ; U155.E1 v4(39.05,119.31) ; U1.AN7 v4(226.86,134.5) ; U25.F1 v4(287.1,101.39) ; U1.AD1 v4(232.86,125.5) ; U1.AR33 v4(199.86,136.5) ; U139.B5 v4(24.43,94.3) ; U1.L32 v4(200.86,111.5) ; U1.AU11 v4(222.86,138.5) ; U23.F15 v4(132.21,90.36) ; U5.H9 v4(226.18,159.87) ; U1.E14 v4(219.86,105.5) ; U25.E14 v4(289.1,87.39) ; U23.B13 v4(136.21,92.36) ; U23.B1 v4(136.21,105.36) ; U70.B8 v4(116.4,131.25) ; U1.AL17 v4(216.86,132.5) ; U5.F1 v4(233.38,158.27) ; U25.B17 v4(292.1,84.39) ; U108.3 v1(27.22,66.1) ; U1.AR18 v4(215.86,136.5) ; U1.AG25 v4(207.86,128.5) ; v1(70.62,74.68) U127.7 ; C1358.2 v1(111.6,173.69) ; R12978.1 v1(56.52,203.55) ; U1.AG27 v4(205.86,128.5) ; U1.K30 v4(202.86,110.5) ; U127.5 v1(69.32,71.96) ; U1.AU32 v4(200.86,138.5)
  TOP w0.508: v1(296.9,73.93) 296.26,73.93 295.91,74.28 C1237.2 296.32,74.78 v1(296.92,74.78) ; C1236.2 v1(296.01,72.74) ; C2437.1 v1(89.53,140.49) ; C1247.2 v1(306.57,74.78) C1233.2 ; v1(297.79,73.84) 298.4,73.84 298.75,74.19 C1244.2 ; C1243.2 v1(297.93,72.88) ; C1267.2 v1(267.73,75.31) ; C1232.2 v1(307.42,73.13) ; C1246.2 v1(305.43,73.13)
  TOP w1.778: X11.7 30.09,134.18 H23.1
  T05 w0.305: v1(31.7,152.25) 33.45,150.5 v1(46.86,150.5)
  P10 w0.152: v1(78.11,12.45) 77.7,12.04 67.84,12.04 v1(67.44,12.45)
  T18 w0.381: v1(179.16,84.94) 183.06,81.04 199.25,81.04 v1(202.41,77.88)
  T18 w1.016: 45.87,23.76 45.95,23.68 J7.AR5 J7.AR4
  T18 w1.524: J7.S1 45.87,18.1 J7.S3 J7.S4 ; J7.S5 60.6,24.18 J7.S2 60.6,15.56 J7.S6
  BOTTOM w0.152: v1(67.44,12.45) 67.84,12.05 77.71,12.05 v1(78.11,12.45)
  BOTTOM w0.254: PR100.2 PC63.2 v1(31.11,150.42) ; v4(260.5,130.33) 260.44,130.26 C45.2 260.44,128.54 R186.1 ; 34.43,163.62 v7(34.4,163.62) 33.87,163.62 33.54,163.94 PC62.1
  BOTTOM w0.305: v1(133.17,120.71) C2046.1 ; C1411.2 116.81,198.4 v1(116.33,198.88) ; U149.10 104.39,101.15 v1(103.76,101.79) ; C2148.1 156.86,132.73 v7(157.48,132.73) ; v1(160.83,133.82) 160.44,133.43 C2147.1
  BOTTOM w0.381: v1(45.34,193.42) 45.95,192.81 C1596.1 ; C2320.1 C2287.1 C2295.2 59.37,116.24 v4(59.15,116.46) ; C634.1 v1(208.88,156.73) 209.6,156.73 C315.2 ; 92.08,194.41 C2061.2 ; C2061.2 92.08,195.15 ; C2061.2 v1(91.31,194.78) ; C1626.1 95.3,92.31 ; C1626.1 95.78,91.48 v7(95.78,90.86) ; C1626.1 94.95,91.94 ; C1626.1 94.95,92.68 ; 156.46,132.55 C2148.1 ; C2148.1 157.06,133.13 ; C2148.1 155.86,133.13 ; R12922.2 20.62,84.74 ; R12922.2 20.25,84.02 v1(20.32,83.95) ; R12922.2 19.88,84.74 ; C2331.2 68.61,139.45 ; C2331.2 68.61,138.35 ; C2331.2 69.18,138.9 v1(69.6,139.32) ; v4(227.86,110.5) 227.44,110.91 C441.2 ; C2294.2 37.43,107.1 ; C2294.2 36.69,107.1 ; C2294.2 v1(37.06,106.39) ; v4(262.9,118.66) 263.38,118.19 C737.1 264.06,118.02 264.33,118.28 PC197.2 ; v4(210.86,134.5) 210.36,134.99 C322.2 ; CJ9.S60 246.92,43.54 246.92,42.93 246.92,42.93 246.92,42.31 R584.1 ; C1408.1 v1(111.25,117.02) 111.29,116.98 U101.3 ; C1408.1 111.62,117.75 ; C1408.1 110.88,117.75 ; C797.2 161.4,8.87 ; C797.2 v1(161.03,8.13) ; C797.2 160.66,8.87 ; C1983.1 13.54,43.31 ; C1983.1 12.45,43.31 ; C1983.1 v1(13,44.2) ; C556.1 U1.N33 v4(199.86,114.5) ; C969.2 282.6,88.89 v4(283.1,89.39) ; v4(216.86,111.5) 217.28,111.91 C583.2 ; C593.2 224.28,112.08 v4(223.86,112.5) ; C1640.1 92.78,87.98 ; C1640.1 93.13,87.61 ; C1640.1 93.42,88.24 v1(93.42,88.34) ; C1640.1 92.78,87.23 ; C1994.1 70.7,74.6 v1(70.62,74.68) ; C546.2 U1.Y16 v4(217.86,121.5) ; v4(45.45,113.71) 45.98,113.71 46.36,114.09 R12326.2 ; v4(201.86,110.5) 202.28,110.08 C544.2 ; R106.2 210.66,164.19 C633.2 211.18,164.12 v4(211.43,163.87) ; C460.2 208.44,103.08 v4(208.86,103.5) ; R1784.1 157.35,123.25 v1(156.72,122.61) 156.08,123.25 R1783.1 ; v1(49.66,198.75) 49.85,198.95 R12948.1 ; v1(162.9,123.03) 163.14,123.26 C2173.2 162.33,124.11 v1(161.93,123.7) ; v4(197.86,138.5) 198.35,138.01 C113.1 ; C1319.2 v1(226.79,74.09) ; R12947.1 52.06,201.7 ; R12947.1 v1(51.69,202.45) ; R12947.1 51.32,201.7 ; v4(210.86,108.5) U1.H22 C456.2 ; C225.2 271.49,120.8 v1(271.62,120.92) ; v4(39.05,113.71) 38.86,113.52 C2304.2 38.29,113.56 C2250.1 ; v1(258.19,116.19) 258.57,116.57 C744.1 ; v4(260.5,118.66) 260.52,118.65 C44.2 260.5,117.97 R184.1 ; U57.12 269.99,32.46 ; U57.12 v1(269.72,31.26) ; U57.12 269.72,33.31 ; C724.1 237.97,155.49 v4(238.35,155.87) ; 69.61,88.83 R12904.1 ; R12904.1 v1(69.95,90.3) ; R12904.1 69.95,88.46 ; 302.01,133.8 PR39.2 ; PR39.2 299.86,134.17 v1(299.09,133.39) ; PR39.2 302.01,134.54 ; C2389.2 237.07,120.23 237.45,119.85 v1(238.06,119.85) ; U16.7 v1(177.67,16.59) ; U16.7 177.67,18.74 ; U16.7 177.94,17.89 ; C899.2 126.62,88.95 v4(126.21,89.36) ; 252.38,210.73 PR234.2 ; PR234.2 252.76,210.78 v1(253.36,211.38) 253.72,211.03 PC206.2 ; PR234.2 253.13,210.73 ; R12984.2 163.72,114.1 ; R12984.2 162.98,114.1 ; R12984.2 163.35,113.75 ; R12984.2 163.83,113.61 v1(163.83,112.78) ; 29.88,44.86 C1410.2 ; C1410.2 30.22,45.23 ; C1410.2 v1(29.88,45.89) ; C474.2 U1.E2 v4(230.86,105.5) ; R1821.2 29.57,93.83 v1(30.21,94.48) ; v8(27.13,47.86) 27,47.99 C1980.2 ; v8(104.28,75.12) 104.41,74.99 R609.2 ; v1(75.37,87.77) 75.57,87.56 R1623.2 ; C2206.2 104.65,76.99 v8(104.28,76.62) ; C2206.2 104.65,78.07 ; C2206.2 104.3,77.7 ; C552.2 203.28,112.91 v4(202.86,112.5) ; v4(22.43,96.3) 21.93,96.8 C2104.2 ; v4(122.21,103.36) 122.63,103.78 C873.1 ; v1(32.51,89.53) 32.07,89.97 R1791.2 ; v1(55.5,83.32) 54.98,82.8 U170.2 ; C420.2 204.28,127.91 v4(203.86,127.5) 203.36,127 C419.1 ; v1(37.57,120.47) PC331.2 36.43,119.91 v1(36.89,119.44) ; v4(114,124.86) 114.39,125.24 C1394.2 ; C296.2 210.28,124.08 v4(209.86,124.5) ; v4(231.86,115.5) 231.36,115 C480.1 ; C469.1 229.28,118.08 v4(228.86,118.5) ; C14.2 U1.AB10 v4(223.86,122.5) ; v4(197.86,116.5) 197.36,117 C506.1 ; C963.1 280.52,89.97 v4(280.1,90.39) ; C20.2 239.22,115.17 ; C20.2 v1(238.85,114.45) ; C20.2 238.48,115.17 ; 177.83,43.51 Q34.4 ; Q34.4 v1(178.38,44.3) ; Q34.4 178.92,43.51 ; C675.2 238.28,162.35 v4(238.35,162.27) ; v4(208.86,116.5) 209.28,116.08 C277.1 ; C636.1 198.92,163.54 v4(199.26,163.87) 198.67,164.46 R103.2 ; C274.2 v1(235.8,155.72) ; C1374.1 101.6,12.13 ; C1374.1 101.97,11.77 ; C1374.1 v1(100.87,11.77) ; v4(238.35,163.87) 238.11,164.12 C695.1 236.67,164.12 R145.1 ; C2117.1 13.01,95.88 v4(13.43,96.3) ; Q38.1 236.41,39.95 v1(236.02,39.56) ; Q38.1 236.96,40.27 ; Q38.1 235.86,40.27 ; C450.2 226.37,117 v4(225.86,116.5) ; C2369.2 107.05,89.8 ; C2369.2 106.69,89.79 v1(105.79,89.79) ; C2369.2 107.05,89.06 ; C2369.2 106.71,89.43 ; v4(280.1,86.39) 279.68,86.81 C959.2 ; v4(215.86,111.5) 216.28,111.08 C430.2 ; v4(251.7,137.53) 251.32,137.91 C742.2 252.07,139.04 C71.2 ; R1698.1 v1(102.23,95.94) ; R1698.1 101.86,96.68 ; R1698.1 102.61,96.68 ; v4(228.86,101.5) 229.36,101 C448.2 ; 5.98,29.17 C1987.1 ; C1987.1 6.35,28.83 v1(6.6,28.57) ; C1987.1 6.72,29.17 ; C288.1 220.37,131.99 v4(219.86,132.5) ; v1(164.72,138.05) 164.43,137.76 C2174.2 ; C1689.1 89.13,85.42 v1(88.49,86.06) ; 116.06,134.9 C1398.2 ; C1398.2 116.42,135.27 ; C1398.2 116.42,134.69 v1(115.98,134.25) C1396.2 ; R684.1 v1(279.02,6.53) ; R684.1 278.65,7.17 ; R684.1 279.39,7.17 ; v1(102.11,90.61) 102.08,90.58 C2121.2 ; C761.2 91.16,7.6 ; C761.2 v1(90.78,6.96) ; C761.2 90.41,7.6 ; R12782.1 141.22,117.56 140.68,118.1 140.68,118.11 v1(140.66,118.12) ; C110.2 223.37,131.99 v4(222.86,132.5) ; v4(216.86,115.5) U1.R17 C393.2 ; C882.1 U23.H3 v4(130.21,102.36) ; C567.2 U1.AA5 v4(228.86,122.5) ; v1(9.91,30.23) 9.66,29.98 C1988.1 ; C80.2 255.45,139.02 C87.2 257.06,139.02 v1(257.11,139.07) ; v1(84.68,208.56) 84.14,209.1 PC22.2 ; R1623.2 76.43,87.19 ; R1623.2 76.43,87.93 ; v4(207.86,108.5) 207.78,108.5 C557.2 ; v4(226.18,162.27) 225.97,162.49 C716.1 ; v4(289.1,87.39) 288.68,86.97 C961.2 ; v4(134.21,105.36) 134.58,105.72 134.58,107.02 C876.2 ; 176.85,21.53 C812.2 ; C812.2 v1(177.45,22.24) ; C812.2 178.05,21.53 ; C517.2 200.36,110 v4(200.86,110.5) ; v4(223.86,128.5) U1.AG10 C18.2 ; 250.66,39.56 Q39.1 ; Q39.1 250.11,39.83 ; Q39.1 v1(251.63,39.83) ; R279.2 124.21,101.28 v4(124.21,101.36) ; R367.1 R366.1 v1(143.16,42.45) ; C697.1 252.95,116.58 v1(252.95,116.19) ; C697.1 252.56,116.61 ; C697.1 252.93,116.97 ; v1(279.61,22.22) 279.89,22.5 R919.1 ; v1(265.68,21.84) 265.36,22.16 R600.1 ; v1(236.04,159.98) 236.6,160.54 C65.2 ; v1(236.04,159.98) 235.66,159.98 C665.2 ; v1(236.04,159.98) 236.54,159.49 C64.1 ; C2451.2 286.37,98.65 v4(287.1,99.39) ; C375.1 U1.AA11 v4(222.86,122.5) ; PR387.1 27.72,149.08 ; PR387.1 27.37,149.64 v1(27.12,149.89) ; PR387.1 27.37,148.71 ; R1437.1 214.1,120.6 R1436.1 213.29,120.99 C293.2 213.28,121.08 v4(212.86,121.5) ; v4(40.65,116.91) 40.4,116.66 C2305.2 ; v1(53.47,104.01) 52.81,104.67 C2270.2 ; C5.1 250.92,116.58 v1(250.92,116.19) ; v1(45.2,104) 45.32,103.87 C2300.1 ; R276.2 v1(113.3,94.1) ; v1(294.43,28.58) C781.2 ; C781.2 295.07,28.21 ; C781.2 295.07,28.95 ; 172.04,8.87 C790.1 ; C790.1 172.78,8.87 ; C790.1 v1(172.41,8.16) ; v4(245.56,157.47) 245.92,157.84 C261.2 ; C1363.2 v1(171.41,28.74) ; v1(308.48,85.21) 308.75,84.94 C1334.2 ; Q5.1 v1(51.11,190.72) ; v4(24.43,95.3) U139.B4 C2112.2 ; v1(215.99,175.18) 216.09,175.08 C182.1 ; C715.2 258.17,137.6 v4(258.1,137.53) 258.22,137.41 C82.2 ; 37.32,115.78 R12308.1 ; R12308.1 37.48,115.97 37.48,115.48 v1(37.66,115.29) 38.33,115.96 C2241.2 ; R12308.1 36.95,116.13 ; 127.57,71.74 C1039.2 ; C1039.2 127.57,72.48 ; C1039.2 v1(126.85,72.11) ; v1(266.17,118.28) PC197.2 ; PC197.2 v1(264.95,117.39) ; C1375.1 86.66,28.71 ; C1375.1 86.29,29.07 ; C1375.1 85.92,28.71 ; C1210.2 v1(231.77,73.15) ; C1210.2 231.77,72 ; C1210.2 231.42,72.37 ; U183.2 v1(8.89,34.67) ; R1868.1 v1(9.75,97.54) ; R1868.1 9.75,98.6 ; R1868.1 9.41,98.23 ; C57.1 231.36,130 v4(230.86,130.5) ; R737.1 v1(249.66,36.62) ; Q34.1 v1(176.37,41.56) ; Q34.1 175.82,42.21 ; Q34.1 176.92,42.21 ; 175.8,21.53 C811.2 ; C811.2 176.55,21.53 ; C811.2 v1(176.18,22.24) ; v1(129.7,109.66) 129.05,109.66 128.67,109.28 C884.2 ; v4(195.86,107.5) U1.G37 C533.1 ; R1619.1 70.87,79.31 v1(71.37,79.81) 70.87,80.32 R1624.1 ; C1412.1 76.57,122.34 ; C1412.1 76.23,121.97 ; C1412.1 v1(76.23,123.06) ; C974.2 190.8,117.66 v1(190.75,117.62) ; v4(200.86,105.5) 200.36,105 C541.1 ; C259.2 v1(247.97,155.72) ; C463.2 U1.E19 v4(214.86,105.5) ; v4(253.3,125.86) 253.3,126.61 C70.2 ; C197.1 v1(199.68,175.07) ; 43.57,68.71 C2359.1 ; C2359.1 43.92,69.08 ; C2359.1 43.92,68.3 v1(43.56,67.94) ; 204.35,12.06 R254.2 ; R254.2 204.35,12.8 ; R254.2 v1(203.62,12.43) ; v4(262.9,130.33) 263.14,130.33 263.53,129.95 C750.1 ; v1(267.33,41.71) Q40.4 ; v1(209.72,161.51) 210.03,161.2 C319.2 209.97,160.48 C314.2 ; C1625.1 96.06,88.93 v7(96.52,89.39) ; v1(54.03,104.74) 54.03,105.35 C2269.2 ; v4(286.1,93.39) U25.H9 C976.2 ; v1(9.92,41.1) 9.92,41.61 9.59,41.94 C1982.1 9.49,41.94 9.16,41.61 v1(9.16,41.1) ; C2118.2 24.85,93.88 v4(24.43,94.3) ; v4(116.4,131.25) 117.19,132.04 C1942.1 ; R13015.1 74.81,128.53 v1(74.93,128.65) ; R13015.1 75.18,127.91 ; R13015.1 R13020.1 ; R13015.1 74.44,127.91 ; v4(21.43,90.3) 21.93,89.8 C2129.2 ; C1045.2 v1(142.77,72.37) ; C1045.2 143.51,72.74 ; C1045.2 143.51,72 ; C464.1 219.44,111.91 v4(219.86,111.5) ; 37.6,195.81 C1597.1 ; C1597.1 v1(38.76,195.81) ; C1597.1 37.97,195.46 ; 185.67,147.77 R12443.1 ; R12443.1 185.3,148.11 ; R12443.1 R12444.1 187.07,148.11 187.45,148.49 v1(187.45,149.48) ; 171.67,85.16 R1892.1 ; R1892.1 171.67,85.6 v1(172.24,86.16) 171.68,86.72 R1894.1 ; R1892.1 172.02,85.54 ; R1614.2 76.43,80.31 ; R1614.2 v1(75.69,79.94) ; R1614.2 76.43,79.57 ; v4(221.86,113.5) 221.44,113.91 C587.1 ; C565.2 236.18,117.9 C616.2 235.39,116.15 235.2,116.33 233.7,116.33 v4(232.86,115.5) 233.36,115 C470.1 ; v1(230.73,36.2) 230.92,36.38 R563.1 ; U48.12 152.69,33.46 ; U48.12 v1(152.42,32.26) ; U48.12 152.42,34.31 ; C447.2 225.44,103.08 v4(225.86,103.5) ; v1(14.86,103.65) 13.94,103.65 C2098.2 14.04,104.52 v1(14.86,104.52) ; v4(259.7,125.86) 260.08,126.24 C749.1 ; v4(65.73,115.33) 66.3,114.75 C2315.1 ; U60.3 65.8,182.13 66.04,182.37 v1(66.04,182.38) ; U60.3 66.35,181.5 ; U60.3 65.25,181.5 ; C2322.2 v1(39.73,103.08) ; v4(130.21,93.36) 129.71,92.86 C879.1 ; v4(201.86,105.5) 202.28,105.08 C559.1 ; 295.07,30.75 C783.2 ; C783.2 295.07,31.5 ; C783.2 v1(294.43,31.13) ; C284.2 232.16,153.85 v4(232.58,154.27) ; C896.1 182.5,112.72 v1(182.5,114.6) ; C896.1 182.27,112.85 ; C896.1 181.9,112.49 ; C896.1 182.64,112.49 ; Q6.2 52.36,193.84 v1(52.14,193.62) ; 158.53,132.62 C2144.1 ; C2144.1 158.51,132 v7(157.48,132) ; C2144.1 159.13,132.05 ; v1(243.59,175.18) 243.74,175.02 C243.2 ; 80.42,44.28 C1673.2 ; C1673.2 81.16,44.28 ; C1673.2 80.79,44.59 v1(81.15,44.96) ; v4(213.03,167.08) 212.74,167.36 C656.2 ; C2263.1 45.77,122.03 v4(45.45,121.71) ; v1(240.92,30.99) 241.27,31.34 U56.12 ; C794.2 163.6,22.15 v1(163.74,22.29) ; R896.1 v1(221.06,36.72) R1730.1 ; C295.1 U1.U23 v4(210.86,118.5) ; v4(199.86,107.5) 199.36,108 C520.1 ; R1006.1 v1(121.47,145.26) ; R1006.1 121.84,143.82 ; R1006.1 121.1,143.82 ; v4(205.86,110.5) U1.K28 C568.2 ; 62.84,181.04 PR298.2 ; PR298.2 62.49,181.41 ; PR298.2 62.84,181.64 v1(62.1,182.37) ; C1816.2 5.98,103.05 ; C1816.2 5.44,103.52 ; C1816.2 v1(3.35,103.05) ; C69.1 236,156.54 v1(235.8,156.73) C666.1 ; v4(226.18,155.87) 225.81,155.87 C670.2 ; Q28.4 91.15,44.4 ; Q28.4 90.37,43.91 ; Q28.4 v1(92.06,43.91) ; 85.35,79.18 C1302.2 ; C1302.2 85.7,79.61 v7(86.19,80.1) ; C1302.2 85.7,78.81 ; v1(274.78,20.47) 274.57,20.26 R685.1 ; 64.39,177.05 PR299.2 ; PR299.2 v1(65.38,177.39) ; PR299.2 64.02,177.39 ; v4(211.43,155.87) 211.04,155.49 C627.2 ; v1(171.66,42.5) R394.1 R395.1 ; R610.2 168.67,74.99 v8(168.54,75.12) ; C210.2 212.23,174.87 v1(211.93,175.18) ; C1979.2 35.02,46.71 ; C1979.2 34.68,46.34 ; C1979.2 35.02,45.55 v1(35.13,45.45) ; C2076.1 58.12,52.43 ; C2076.1 57.77,52.8 ; C2076.1 v1(57.77,51.77) ; 201.86,26.87 C1361.2 ; C1361.2 202.22,26.5 ; C1361.2 v1(202.22,27.53) ; C2300.1 45.69,103.11 ; C2300.1 44.95,103.11 ; R1638.1 v1(301.98,20.17) ; v4(210.86,121.5) 211.28,121.08 C299.2 ; C991.2 v1(191.48,119.69) ; R1900.2 277.7,91.79 v4(278.1,91.39) ; 62.49,184.96 PR301.2 ; PR301.2 62.34,185.46 v1(62.34,185.64) PR300.2 ; PR301.2 62.84,184.59 ; v4(207.86,111.5) 207.44,111.08 C585.1 ; 80.29,171.42 R12704.2 ; R12704.2 80.29,172.49 v1(80.64,172.85) ; R12704.2 79.94,171.79 ; C2110.2 20.85,90.72 v4(20.43,90.3) 20.01,89.88 C2081.2 ; D46.1 32.91,191.71 v1(32.65,191.97) ; 222.43,8.74 C831.2 ; C831.2 223.17,8.74 ; C831.2 v1(222.8,8.01) ; C214.2 209.01,174.68 v1(209.01,175.18) ; R1642.1 v1(304.52,20.17) ; v1(67.18,116.08) 67.25,116.15 C2271.2 ; v4(285.1,94.39) 284.68,93.97 C975.2 ; v1(56.77,79.38) 56.43,79.71 R12899.1 ; R263.2 C843.1 v1(247.75,6.96) ; C614.1 220.28,117.91 v4(219.86,117.5) ; v1(121.39,190.94) 121.44,190.9 PC8.1 ; v1(215.39,207.76) 215.64,207.5 PC70.2 ; C442.1 226.36,115 v4(226.86,115.5) ; v4(208.86,127.5) 209.28,127.91 C351.2 ; v1(181.51,32.26) 181.4,32.36 U47.12 ; 45.58,191.97 C1596.1 ; C1596.1 46.32,191.97 ; C459.1 224.28,111.08 v4(223.86,111.5) ; C693.2 202.67,158.55 v1(203.12,159.01) 202.63,159.5 C669.1 ; C2434.1 64.77,131.06 v1(65.28,131.57) 64.77,132.08 R12967.1 ; R1778.1 158.27,133.52 v7(157.48,132.73) ; 31.39,88.33 R1674.1 ; R1674.1 v1(32.09,88.7) ; R1674.1 31.39,89.08 ; R352.1 129.08,43.14 ; R352.1 128.73,42.77 ; R352.1 R353.1 130.34,44.16 v1(130.38,44.2) ; v1(250.23,127.89) 249.57,127.89 C38.1 ; C2218.1 118.87,193.85 v7(119.48,194.46) ; D47.1 v1(33.78,197.25) ; C2260.1 60.54,109.49 60.93,109.87 v4(60.93,110.53) 60.3,110.53 C2251.2 ; v1(49.15,191.85) Q5.4 ; v4(204.86,122.5) 204.44,122.08 C403.2 ; PC165.2 v1(146.23,176.41) ; C1263.2 v1(238.86,75.49) ; C1624.2 100.2,85.72 v1(99.46,84.98) ; C1624.2 99.4,85.94 ; C1624.2 101,85.94 ; C1624.2 100.2,86.54 ; v1(162.33,22.24) C793.2 ; 141.09,121.85 C2350.1 ; C2350.1 141.09,122.59 ; C2350.1 141.05,122.22 v7(140.41,121.58) 140.41,121.12 C2352.1 ; v1(263.4,20.83) 263.9,20.33 C845.2 ; C269.2 217.44,123.08 v4(217.86,123.5) ; 92.04,84.59 C1643.2 ; C1643.2 93.42,84.59 v1(93.6,84.77) 93.85,85.02 C1642.1 ; C1643.2 92.58,84.11 ; C1201.2 225.59,72.74 ; C1201.2 v1(226.3,72.37) ; C1201.2 225.59,72 ; R920.1 v1(277.96,36.27) R1732.1 ; 94.11,189.11 R1869.2 ; R1869.2 94.48,189.46 ; R1869.2 v1(93.37,189.46) ; C603.2 208.28,124.08 v4(207.86,124.5) 207.44,124.08 C602.1 ; C1631.2 95.78,89.91 ; C1631.2 95.43,90.28 ; C1631.2 95.64,90.13 v7(96.52,90.13) ; v4(226.86,134.5) 227.36,134 C337.1 ; C796.2 v1(162.3,8.13) ; C796.2 161.93,8.87 ; C796.2 162.67,8.87 ; v4(13.43,91.3) 13.93,91.8 C2093.2 ; C1554.2 286.13,194.43 ; C1554.2 v1(285.37,194.08) ; C1554.2 286.5,194.08 ; 10.57,93.29 R1681.2 ; R1681.2 v1(11.56,93.66) ; R1681.2 10.57,94.03 ; 221.16,8.74 C832.2 ; C832.2 221.9,8.74 ; C832.2 v1(221.53,8.01) ; U64.12 227.29,32.46 ; U64.12 227.02,33.31 ; U64.12 v1(227.02,31.32) ; v4(220.86,122.5) U1.AA13 C412.1 ; C853.1 307.24,29.12 ; C853.1 307.58,28.75 ; C853.1 v1(307.24,27.99) ; R702.1 v1(190.05,20.46) ; U22.10 254.46,17 v1(254.97,17.51) ; U22.10 254.46,15.42 ; U22.10 254.73,16.27 ; C2128.2 24.01,89.72 v4(24.43,89.3) ; C221.1 245.67,175.13 v1(245.62,175.18) ; C2303.2 38.68,111.74 v4(39.05,112.11) ; C2119.2 24.93,97.8 v4(24.43,98.3) ; C373.2 U1.AC13 v4(220.86,124.5) ; C878.2 U23.L14 v4(126.21,92.36) 125.71,92.86 C889.2 ; R605.1 v1(296.9,20.17) ; C219.2 v1(271.41,134.31) ; C863.1 123.79,90.94 v4(124.21,91.36) ; v4(221.86,125.5) 221.44,125.08 C371.2 ; U19.7 241.59,9.94 ; U19.7 v1(239.52,9.94) ; U19.7 240.74,9.67 ; C101.1 199.3,162.32 v4(199.26,162.27) 198.76,161.78 C674.1 ; v4(221.86,114.5) 222.28,114.08 C353.1 ; R1726.1 v1(89.11,37.72) R848.1 ; C292.1 205.28,123.08 v4(204.86,123.5) 204.36,124 C404.1 ; C1362.2 184.55,27.22 v1(184.74,27.03) ; C1362.2 184.55,28.08 ; C1362.2 184.2,27.71 ; 248.72,116.55 C4.1 ; C4.1 249.81,116.55 ; C4.1 249.62,116.19 v1(250.16,116.19) ; C4.1 249.26,116.08 ; C413.2 210.36,127 v4(209.86,126.5) ; v1(30.79,102.03) 30.36,102.46 C2089.2 ; C575.2 205.44,121.91 v4(205.86,121.5) ; v4(209.73,167.16) 210.25,167.68 C30.1 ; C300.1 210.28,122.08 v4(209.86,122.5) ; 266.33,22.6 R601.1 ; R601.1 267.07,22.6 ; R601.1 266.7,22.23 v1(267.08,21.84) ; PC340.2 75.62,145.36 v1(75.82,145.16) ; C256.2 253.67,118.29 v4(253.3,118.66) ; C1359.2 v1(113.65,28.65) ; R584.1 247.26,42.31 ; R584.1 246.92,42.68 ; R584.1 246.92,41.94 ; R555.1 218.76,41.76 ; R555.1 218.76,41.02 ; R555.1 219.1,41.39 ; C1317.2 110.61,109.81 ; C1317.2 v1(110.24,110.62) ; C1317.2 109.86,109.81 ; C2443.2 121.88,183.55 ; C2443.2 121.51,183.19 v1(121.13,182.81) ; C2443.2 121.14,183.55 ; C36.2 214.36,128.11 214.74,128.5 v4(214.86,128.5) ; C199.2 237.62,174.68 v1(237.62,175.18) ; v4(231.86,110.5) 231.44,110.91 C487.2 ; C958.1 288.68,97.97 v4(289.1,98.39) ; C795.2 163.95,8.87 ; C795.2 163.2,8.87 ; C795.2 v1(163.57,8.13) ; v1(283.99,123.13) 284.1,123.24 PR247.1 ; C2253.1 38.81,121.95 v4(39.05,121.71) ; C984.2 278.61,82.87 v4(278.1,83.39) ; 97.43,92.1 C1634.1 ; C1634.1 96.76,92.57 v7(96.52,92.34) ; C1634.1 97.98,92.57 ; v1(235.8,154.7) C40.1 235.08,154.3 235.5,153.88 C41.1 v1(236.34,153.43) ; R549.1 v1(217.58,39.47) ; v7(155.67,132.73) 155.46,132.95 C2150.1 ; v7(158.95,129.46) 159.3,129.81 C2155.1 ; Q39.4 253.21,41.13 ; Q39.4 v1(252.67,41.8) ; Q39.4 252.12,41.13 ; v4(206.86,121.5) 206.86,121.02 207.36,120.52 C606.1 ; C2308.2 v1(39.86,109.04) ; Q37.1 222.36,40.27 v1(221.77,39.68) ; Q37.1 223.09,40.27 ; Q37.1 222.54,40 ; C1372.1 v1(156.63,28.55) ; v4(211.43,162.27) 211.36,162.35 C628.2 ; v4(214.86,111.5) 214.44,111.91 C589.2 ; v4(288.1,90.39) 288.52,89.97 C978.2 ; R541.1 202.05,61.65 v1(202.61,62.21) 203.07,61.76 R542.1 ; C836.2 236.99,17.17 ; C836.2 237.34,16.8 ; C836.2 236.99,16.25 v1(237.24,16) ; 104.73,180.88 R1736.1 ; R1736.1 105.48,180.88 ; R1736.1 v1(105.1,181.53) ; v1(273.43,113.28) 273.64,113.49 R1274.2 ; v4(114,123.25) 114.05,123.21 C1391.1 ; PR22.1 86,201.81 v1(86.16,201.65) ; PC12.2 300.67,132.9 v1(300.48,133.09) ; v1(271.49,122.83) 271.39,122.73 C240.2 ; v1(60.63,130.76) 60.01,130.14 C2298.2 ; 189.49,123.7 R1445.2 ; R1445.2 189.84,124.07 ; R1445.2 189.84,123.2 v1(189.68,123.04) ; C1378.1 295.19,40.65 ; C1378.1 v1(295.19,39.62) ; C1378.1 294.83,40.28 ; R603.1 v1(298.17,20.17) ; C885.2 145.9,109.7 v1(146.05,109.86) ; C885.2 145.18,109.33 ; C885.2 145.18,110.07 ; v4(233.38,164.68) 233.43,164.63 C32.2 ; v4(14.43,89.3) 14.01,88.88 C2087.2 ; 36.71,205.38 C1600.2 ; C1600.2 37.46,205.38 ; C1600.2 v1(37.08,206.12) ; R577.1 R576.1 v1(244.63,37.05) ; Q32.1 v1(147.36,41.05) ; v4(219.86,127.5) 219.44,127.08 C376.2 ; C61.2 233.97,160.46 v4(233.38,159.87) 233.13,160.13 C63.2 ; C539.2 199.44,115.91 v4(199.86,115.5) ; v4(40.65,122.51) 41.01,122.51 41.39,122.13 C2261.2 ; C809.2 v1(173.63,22.24) ; C809.2 173.26,21.53 ; C809.2 174,21.53 ; C112.2 v1(221.05,155.72) ; v4(198.86,103.5) 199.28,103.08 C543.1 ; C1027.2 121.38,72.48 ; C1027.2 v1(122.1,72.11) ; C1027.2 121.38,71.74 ; v1(197.05,168.69) C27.1 C691.2 ; 275.78,110.07 R1275.2 ; R1275.2 v1(276.64,110.44) ; R1275.2 275.78,110.81 ; 143.36,119.52 R12779.1 ; R12779.1 142.94,119.47 v1(142.55,119.47) ; R12779.1 143.01,119.89 ; R12779.1 R12780.1 R12754.1 R12755.1 v1(143.36,123.9) ; R1084.1 v1(116.46,103.83) ; C1254.2 v1(98.38,74.09) ; C2145.1 159.11,131.42 v7(158.95,131.26) ; C2145.1 159.62,132.02 ; C2145.1 159.62,130.83 ; v1(304.65,44.95) 304.64,44.95 R1635.1 ; R604.1 v1(295.75,44.88) ; 111.08,81.17 R1863.2 ; R1863.2 111.42,81.54 ; R1863.2 v1(111.08,82.2) ; 237.87,41.57 Q38.4 ; Q38.4 238.96,41.57 ; Q38.4 v1(238.42,42.34) ; C1392.1 114.29,86.04 ; C1392.1 113.93,85.67 ; C1392.1 113.93,86.94 114.17,87.18 v1(114.17,87.23) ; C1318.2 v1(226.79,75.49) ; v4(111.6,128.85) 110.93,129.53 C1389.1 ; 40.88,104.43 C2323.1 ; C2323.1 41.25,104.07 ; C2323.1 C2324.2 v1(43.05,104.43) ; C226.2 v1(236.02,175.18) ; v1(104.09,83.01) C2207.2 ; C2207.2 103.62,82.1 ; C2207.2 104.09,81.55 ; 173.56,72 C1066.2 ; C1066.2 173.56,72.74 ; C1066.2 v1(174.27,72.37) ; 157.9,122.59 R1871.1 ; R1871.1 v1(158.49,121.92) ; R1871.1 159.09,122.59 ; v1(187.64,39.9) R704.1 186.65,39.16 R703.1 ; C572.2 216.44,113.91 v4(216.86,113.5) 217.28,113.91 C592.1 ; v4(288.1,95.39) U25.F7 C960.1 ; v4(222.86,115.5) 222.44,115.91 C414.1 ; v4(60.78,113.36) 60.68,113.36 60.59,113.36 60.21,113.74 C2247.2 ; R318.1 84.2,59.68 ; R318.1 84.57,59.34 ; R318.1 84.59,59.73 CJ8.S1 ; R318.1 R317.1 ; C2122.2 68.57,177.52 ; C2122.2 68.2,177.17 ; C2122.2 v1(67.44,177.52) ; C2143.1 v1(160.15,126.45) ; C394.1 U1.AE13 v4(220.86,126.5) ; C331.2 211.44,117.08 v4(211.86,117.5) ; C1599.2 37.36,201.29 ; C1599.2 v1(39.12,200.91) ; C1599.2 37.36,200.54 ; R12469.2 74.65,101.88 v1(75.06,101.47) ; R12469.2 74.65,102.73 ; R12469.2 74.3,102.36 ; v1(230.25,169.67) 230.25,169.4 229.86,169.01 PC198.2 231.15,168.41 v1(231.52,168.78) ; v4(201.86,122.5) 201.44,122.08 C386.2 ; C250.1 206.36,119 v4(206.86,118.5) ; C596.2 195.26,131.13 195.71,130.68 v4(195.71,130.43) ; 295.07,32.03 C784.2 ; C784.2 v1(294.43,32.4) ; C784.2 295.07,32.77 ; v4(15.43,91.3) 14.93,90.8 C2094.2 ; C472.1 229.28,114.08 v4(228.86,114.5) ; 115.49,71.74 C1024.2 ; C1024.2 v1(114.73,72.11) ; C1024.2 115.49,72.48 ; Q9.2 v1(278.89,185.09) ; v4(245.56,162.27) 245.63,162.35 C698.2 246.85,162.35 247.1,162.09 C696.2 ; C1986.1 17.83,40.33 ; C1986.1 v1(18.54,39.96) ; C1986.1 17.83,39.58 ; C424.2 211.71,100.57 C458.2 211.36,101 v4(211.86,101.5) ; C2427.1 12.06,17.48 ; C2427.1 11.31,17.48 ; C2427.1 v1(11.68,16.76) ; C2101.1 14.93,98.8 v4(14.43,98.3) ; C2047.1 137.95,121.08 ; C2047.1 138.29,120.71 ; C2047.1 138.27,121.03 v7(138.27,121.58) 137.81,122.04 C2040.1 ; R1899.2 278.68,91.81 v4(279.1,91.39) 279.6,90.89 C977.1 ; v1(172.11,83.81) 172.11,84.14 171.73,84.52 R1891.1 ; R207.2 267,125.53 v1(267.56,126.09) ; R332.1 R331.1 v1(101.09,45.16) ; C846.2 265.26,21 v1(265.05,21.21) ; C846.2 264.89,20.46 ; C846.2 265.63,20.46 ; C994.2 v1(90.6,72.37) ; C994.2 91.34,72 ; C994.2 91.34,72.74 ; C1941.2 113.75,82.77 ; C1941.2 113.01,82.77 ; C1941.2 v1(113.38,82.12) ; R437.1 v1(271.78,36.04) ; C313.1 225.36,124 v4(224.86,124.5) ; v4(130.21,104.36) 130.63,104.78 C872.1 ; v1(76.2,133.58) 76.2,133.69 U115.3 ; 72.8,93.99 C2160.2 ; C2160.2 v1(72.8,95.25) ; C2160.2 73.14,94.36 ; v4(209.86,138.5) 210.37,137.99 C320.2 ; v4(205.86,136.5) U1.AR27 C338.2 ; C316.1 226.36,131.99 v4(225.86,132.5) ; v4(122.21,91.36) 121.79,90.94 C864.1 ; v1(248.41,154.11) 248.41,153.89 248.03,153.51 C7.1 247.77,154 247.25,154.52 C6.1 v1(247.97,154.7) ; v1(129.46,40.26) 129.62,40.11 R701.1 ; v1(251.71,207.9) 251.82,207.79 PR223.2 ; Q32.4 v1(149.37,44.22) ; C970.2 U25.F5 v4(288.1,97.39) ; R1404.1 70.74,48.89 ; R1404.1 70.13,48.54 v1(69.72,48.13) ; R1404.1 71.11,48.54 ; C509.1 196.44,119.08 v4(196.86,119.5) 197.28,119.91 C528.2 ; v4(212.86,125.5) U1.AD20 C291.2 ; v4(280.1,88.39) 280.6,87.89 C971.1 ; v4(16.43,95.3) 16.93,95.8 C2139.1 ; C895.1 v1(121.95,128.92) 121.95,127.59 R1729.1 ; 174.31,23.73 R663.1 ; R663.1 175.05,23.73 ; R663.1 v1(174.68,23.09) ; R1816.2 109.59,85.37 v1(110.03,84.93) ; R1816.2 109.13,85.72 ; R1816.2 108.76,85.37 ; C868.1 125.79,104.78 v4(126.21,104.36) ; v4(223.86,113.5) 224.28,113.08 C591.2 ; R7.2 188.49,134.74 188.09,134.34 186.39,134.34 v1(186.23,134.51) ; v1(192.37,43.84) Q35.4 ; C339.2 207.04,160.46 v4(206.46,159.87) 206.2,160.13 C343.2 ; C844.1 v1(234.19,15.65) ; C844.1 234.19,16.69 ; C844.1 233.84,16.32 ; R104.1 199.22,157.44 v4(199.26,157.47) ; C425.1 211.28,111.91 v4(210.86,111.5) ; C2156.2 163.87,129.69 v1(164.46,130.28) ; C2156.2 164.57,129.34 ; C2156.2 163.87,128.57 ; C2124.2 v1(116.05,114.23) ; C2124.2 116.42,114.87 ; C2124.2 115.68,114.87 ; C271.1 212.28,122.08 v4(211.86,122.5) ; v1(271.38,120.03) 271.17,119.83 C233.2 ; PR340.2 68.61,142.21 ; PR340.2 68.61,141.12 ; PR340.2 v1(69.53,141.66) ; v1(58.67,196.6) 58.52,196.75 PR354.2 ; PC8.1 121.78,190.12 ; PC8.1 121.44,189.75 ; v1(94.26,93.94) 93.8,94.4 C1628.2 ; R13006.1 16,29.86 ; R13006.1 16,29.11 ; R13006.1 v1(15.36,29.48) ; U182.2 282.71,98 v4(283.1,98.39) ; C483.1 U1.M5 v4(228.86,113.5) ; C2377.2 62.53,122.53 v4(62.53,121.73) ; C17.2 212.28,126.08 v4(211.86,126.5) ; C1630.2 98.68,85.91 v1(98.04,85.27) 97.66,85.65 C1627.1 ; C1388.2 C1402.1 114.12,130.57 v4(114,130.45) ; v4(118.8,128.85) 118.78,128.88 C1406.1 ; C2348.1 139.39,122.59 v7(139.34,122.65) ; C2348.1 140.17,122.24 ; C2348.1 140.54,122.59 ; 185.68,155.85 C2157.1 ; C2157.1 v1(184.96,156.19) ; C2157.1 186.05,156.19 ; U185.4 69.79,124.29 v1(70.36,124.85) ; R12310.2 75.69,104.71 v1(76.33,104.07) ; C848.2 268.18,20.33 ; C848.2 v1(267.8,20.96) ; C848.2 267.43,20.33 ; v1(294.4,21.6) C799.2 ; C799.2 295.07,21.22 ; C799.2 295.07,21.97 ; R1063.1 121.22,192.71 v7(121.37,192.56) ; 302.67,83.52 C1335.2 ; C1335.2 302.67,84.86 v1(302.89,85.09) ; C1335.2 302.2,84.07 ; C956.2 U25.N3 v4(280.1,99.39) ; C1042.2 149.4,72.74 ; C1042.2 149.4,72 ; C1042.2 v1(150.12,72.37) ; R735.1 v1(251.08,20.93) 251.21,20.81 R270.2 ; R735.1 251.45,21.58 ; R735.1 250.71,21.58 ; C317.2 213.31,160.77 C635.2 213.9,160.31 v1(214.4,160.81) ; C762.2 v1(89.51,6.96) ; 89.86,192.68 C2211.2 ; C2211.2 v1(90.23,193.49) ; C2211.2 90.6,192.68 ; 146.9,175.01 PR191.2 ; PR191.2 v1(146.24,175.38) ; PR191.2 146.9,175.75 ; R991.1 298.22,43.06 ; R991.1 297.48,43.06 ; R991.1 v1(297.85,43.77) ; 128.2,13.68 C780.2 ; C780.2 C779.2 v1(127.82,12.41) ; C780.2 128.55,14.05 ; C54.1 229.37,137.99 v4(228.86,138.5) 228.86,139.31 C97.2 ; C329.2 U1.R21 v4(212.86,116.5) ; 75.59,136.92 R1919.1 ; R1919.1 v1(75.59,138.53) ; R1919.1 75.94,137.29 ; C833.2 v1(220.26,8.01) ; C833.2 219.88,8.71 ; C833.2 220.63,8.71 ; C748.2 263.23,124.58 v4(262.9,124.26) 262.15,123.51 R188.2 ; C1628.2 93.17,94.03 ; C1628.2 93.17,94.77 ; PR368.2 75.82,141.6 v1(75.95,141.48) ; C1304.2 v1(214.71,74.09) ; 207.2,208.54 PR402.2 ; PR402.2 206.76,209.32 v1(206.76,209.54) PC366.2 ; PR402.2 207.54,208.17 ; R756.1 97.84,193.65 v1(98.19,194) ; R756.1 97.46,193.25 ; R756.1 98.21,193.25 ; 94.89,184.67 R1100.1 ; R1100.1 v1(94.23,185.04) ; R1100.1 94.89,185.41 ; C1289.2 v1(186.84,74.09) ; C1243.2 v1(297.93,72.88) ; C1243.2 299.54,73.25 ; C1243.2 299.54,72.51 ; 158.73,130.17 C2155.1 ; C2155.1 159.3,130.77 ; R976.1 v1(102.25,21.54) ; v4(210.86,123.5) U1.AB22 C294.2 ; R451.1 290.35,40.55 v1(290.63,40.28) ; v1(190.88,114.85) 190.88,114.32 C605.2 ; C658.2 219.29,167.74 v4(218.63,167.08) ; C2140.2 v1(160.4,124.42) ; v1(99.19,22.23) 99.32,22.23 99.7,21.85 R977.1 ; C2307.2 36.94,105.24 ; C2307.2 36.73,104.89 v1(36.33,104.49) ; C2307.2 37.31,104.89 ; C2041.1 139.88,119.97 v7(139.34,120.51) ; C2041.1 140.33,120.32 ; C2041.1 140.7,119.97 ; C1273.2 173.92,76.17 v1(173.65,76.44) ; C1036.2 133.46,72.48 ; C1036.2 133.46,71.74 ; C1036.2 v1(134.56,72.11) ; C654.2 216.19,156.63 v4(217.03,157.47) ; C1365.2 259.62,28.13 ; C1365.2 v1(258.97,27.76) ; C1365.2 259.62,27.39 ; C216.1 246.64,175.05 v1(246.51,175.18) ; U15.7 298.57,25.89 ; U15.7 v1(299.92,25.63) ; U15.7 297.72,25.63 ; v4(230.86,116.5) 231.28,116.08 C486.1 ; C85.2 256.08,130.71 v4(255.7,130.33) 256.29,129.74 C83.2 256.29,129.18 255.52,128.41 C651.2 255.21,128.36 v1(254.29,128.36) R189.1 ; C426.2 221.44,103.08 v4(221.86,103.5) ; R12907.2 76.15,54.28 ; R12907.2 75.41,54.28 ; R12907.2 v1(75.78,54.99) ; U53.12 v1(123.75,32.26) ; C1407.2 117.18,123.28 v4(116.4,124.05) ; v4(210.86,113.5) 210.44,113.91 C599.2 ; R359.1 R360.1 129.91,46.19 v1(130.43,45.66) ; C2000.1 72.68,87.85 72.59,87.76 v1(72.59,87.69) ; C2000.1 73.04,88.58 ; C2000.1 72.68,88.95 ; 82.58,140.36 PR341.2 ; PR341.2 83.74,140.91 v1(83.8,140.97) ; PR341.2 82.58,141.45 ; v1(190.47,110.34) 190.86,110.73 C601.2 ; C111.1 201.36,138 v4(200.86,138.5) ; 244.1,10.09 C837.2 244.45,10.47 ; C1639.1 96.65,85.52 v1(96.27,85.15) ; R286.2 136.27,93.42 v4(136.21,93.36) ; C540.2 206.28,105.91 v4(205.86,105.5) ; C471.2 229.44,103.08 v4(229.86,103.5) ; v4(211.86,115.5) 211.44,115.08 C328.2 ; C876.2 136.21,106.63 v4(136.21,105.36) ; C876.2 135.2,107.29 ; C876.2 135.57,107.64 ; C876.2 134.83,107.64 ; v4(127.21,94.36) 127.8,94.95 U74.4 ; C231.2 270.99,129.81 v1(271.49,129.81) ; R1729.1 121.88,126.92 ; R1729.1 121.28,127.5 ; U50.12 283.82,16.28 v1(284.35,15.75) ; C1393.2 123.4,130.61 v1(123.73,130.94) ; R75.2 204.44,112.91 v4(204.86,112.5) ; C345.1 227.44,124.08 v4(227.86,124.5) ; C950.1 U25.H7 v4(286.1,95.39) 286.52,94.97 C980.1 ; 7.61,26.58 C1956.1 ; C1956.1 7.61,27.67 ; C1956.1 7.29,27.13 v1(6.73,27.69) ; v4(233.38,157.47) 233.75,157.84 C60.2 ; C35.2 207.28,127.91 v4(206.86,127.5) ; v1(71.51,128.77) 70.65,127.91 R13016.1 ; v4(21.43,97.3) 21.01,97.72 C2109.1 ; v4(195.86,136.5) 196.36,137 C103.1 ; 52.35,83.58 C2272.1 ; C2272.1 53.21,83.95 v1(53.47,84.2) ; C2272.1 52.35,84.32 ; v1(76.27,110.56) 76.14,110.42 R12721.2 ; C526.2 199.36,114 v4(199.86,113.5) ; 105.55,129.29 R13082.2 ; R13082.2 105.92,129.26 R1735.1 ; R13082.2 105.89,128.91 ; C1367.2 232.48,26.91 ; C1367.2 v1(232.11,25.85) ; C1367.2 231.74,26.91 ; R556.1 218.72,42.79 ; R556.1 218.72,42.05 ; R556.1 219.07,42.42 ; C577.2 208.44,111.08 v4(208.86,111.5) ; C1186.2 207.62,72.74 ; C1186.2 207.62,72 ; C1186.2 v1(206.88,72.37) ; C500.2 224.44,105.91 v4(224.86,105.5) ; C282.2 230.42,161.81 v1(230.53,161.93) ; v4(208.86,123.5) U1.AB24 C356.2 ; R1146.2 281.89,184.91 ; R1146.2 281.15,184.91 ; R1146.2 v1(281.52,184.15) ; C1642.1 94.22,85.63 ; C1642.1 93.48,85.63 ; C275.2 229.36,132 v4(228.86,132.5) ; 285.94,129.85 PC87.2 ; PC87.2 285.57,130.19 ; PC87.2 286.31,130.19 ; PC87.2 285.61,129.86 v1(284.97,129.86) ; C840.2 v1(230.76,11.47) ; C840.2 231.49,11.84 ; C840.2 231.49,11.1 ; R422.1 198.8,53.89 CJ9.S8 201.68,54.57 201.22,55.02 R423.1 ; R422.1 198.73,53.58 ; R422.1 199.08,53.95 ; C109.2 219.37,129.99 v4(218.86,130.5) ; v4(217.86,125.5) 217.44,125.08 C379.2 ; v1(262.67,37.12) 262.51,37.29 R430.1 ; C192.1 v1(200.65,175.07) ; v4(198.86,128.5) 199.28,128.08 C382.1 ; 250.84,19.84 R270.2 ; R270.2 251.58,19.84 ; R1032.1 122.9,199.07 ; R1032.1 122.55,199.44 ; R1032.1 122.55,198.15 v1(122.7,198.01) ; C354.2 209.44,119.08 v4(209.86,119.5) 210.28,119.91 C334.2 ; C266.2 217.28,127.08 v4(216.86,127.5) ; C527.1 196.33,120.96 v4(196.86,121.5) ; v4(65.73,114.53) 65.73,113.5 C2311.2 64.93,113.76 v4(64.93,114.53) ; C801.2 v1(294.43,24.14) ; C801.2 295.07,23.77 ; C801.2 295.07,24.51 ; R12766.2 157.75,114.1 157.37,113.72 157.37,112.91 v1(157.73,112.55) ; 90.18,186.52 R959.1 ; R959.1 90.92,186.52 ; R959.1 v1(90.55,188.4) ; C505.2 U1.R37 v4(195.86,115.5) 194.88,116.48 C510.2 ; C1069.2 v1(166.93,72.37) ; C1069.2 167.67,72 ; C1069.2 167.67,72.74 ; C962.1 288.6,88.89 v4(289.1,89.39) ; 251.55,116.61 C72.1 ; C72.1 251.18,116.97 ; C72.1 251.94,116.58 v1(251.94,116.19) ; v1(205.32,175.25) 205.32,175.2 205.48,175.05 C185.1 ; v4(250.1,119.46) 249.68,119.88 C81.1 ; C2111.2 U139.D7 v4(21.43,91.3) 21.93,90.8 C2131.2 ; U54.12 v1(109.7,32.26) ; U54.12 109.7,34.31 ; U54.12 109.97,33.46 ; C807.1 v1(158.57,8.16) ; C807.1 158.2,8.87 ; C807.1 158.94,8.87 ; C79.1 256.08,125.48 v4(255.7,125.86) 256.19,126.35 C84.1 ; v4(254.1,130.33) 253.67,129.9 C369.2 ; C201.2 218.99,174.86 v1(218.78,175.07) ; C1090.2 261.9,72.78 ; C1090.2 261.9,72.04 ; C1090.2 v1(262.54,72.41) ; v1(70.77,84.39) R1626.1 ; v4(127.21,99.36) 126.71,99.86 C893.1 ; v1(274.32,108.61) 274.32,108.24 C982.2 273.3,108.22 v1(273.3,108.63) ; R1110.1 264.9,196.75 v1(264.67,196.53) ; C1594.2 37.71,197.74 ; C1594.2 v1(37.36,198.48) ; C1594.2 37.36,197.37 ; U65.12 284.19,32.01 ; U65.12 283.92,32.86 ; U65.12 283.92,30.94 v1(283.59,30.61) ; R602.1 v1(297.02,44.88) ; 140.71,85.69 C886.2 ; C886.2 141.45,85.69 ; C886.2 v1(141.08,84.34) ; C377.1 221.36,116 v4(221.86,116.5) 222.28,116.91 C615.2 ; C535.2 204.36,105 v4(204.86,105.5) ; C827.2 v1(221.56,22.04) ; v4(205.86,117.5) 206.28,117.91 C352.2 ; C494.2 U1.B17 v4(216.86,102.5) ; C2401.1 88.42,78.55 v1(88.25,78.39) ; v4(201.86,115.5) 202.36,115 C551.1 ; v4(220.86,128.5) U1.AG13 C399.1 ; R1108.1 272.66,193.58 ; R1108.1 271.92,193.58 ; R1108.1 v1(272.29,192.46) ; U12.7 v1(136.45,9.61) ; U12.7 138.55,9.61 ; U12.7 137.7,9.34 ; R10.2 189.06,134.17 189.81,134.17 v1(189.99,133.99) ; v1(285.64,106.7) 285.64,106.11 285.26,105.73 C973.2 285.14,105.73 284.76,106.11 v1(284.76,106.71) ; R415.1 R416.1 v1(185.81,47.23) ; v4(288.1,88.39) 287.6,87.89 C972.2 ; v4(223.86,118.5) 224.28,118.08 C446.1 ; C68.2 245.17,160.26 v4(245.56,159.87) 246.14,160.46 C255.2 ; v1(108.97,139.57) 109.1,139.44 C2462.2 ; C1999.1 73.73,77.72 ; C1999.1 v1(73.36,78.45) ; C1999.1 72.99,77.72 ; C409.1 219.44,121.08 v4(219.86,121.5) ; 97.14,197.95 R758.1 ; R758.1 97.51,198.46 v1(97.26,198.7) ; R758.1 97.88,197.95 ; R600.1 265.74,22.6 ; R600.1 264.99,22.6 ; C29.1 v1(221.05,154.7) 221.05,153.72 C25.1 ; 75.32,73.04 C1992.1 ; C1992.1 74.97,73.41 ; C1992.1 75.32,74.59 v1(75.17,74.75) ; C1552.2 262.79,183.29 263.17,183.67 v1(263.17,184.74) 262.2,184.74 Q4.2 ; v4(215.86,105.5) 215.36,105 C498.1 ; C411.2 U1.P16 v4(217.86,114.5) 218.39,113.96 R1432.1 ; v4(212.86,129.5) 213.73,130.36 C50.2 ; v4(212.86,129.5) 212.36,129 C33.2 ; v4(212.86,129.5) U1.AH20 C23.2 ; C856.2 v1(278.91,104.66) ; R1895.1 v1(165.35,91.5) 165.19,91.34 R12935.1 ; 56.48,45.04 C1686.1 ; C1686.1 57.23,45.04 ; C1686.1 v1(56.86,44.4) ; C362.2 209.36,132 v4(209.86,132.5) ; 64.47,173.74 R1630.1 ; R1630.1 v1(64.84,174.57) ; R1630.1 65.21,173.74 ; v4(207.86,128.5) 208.28,128.91 C49.2 ; C1683.2 72.52,53.97 v1(72.77,53.72) ; C1409.2 v1(114.36,133.68) ; R921.1 v1(276.61,36.25) ; C740.1 258.32,126.08 v4(258.1,125.86) ; v8(232.64,75.12) 232.77,74.99 R608.2 ; R1852.1 v1(107.68,110.54) ; R1852.1 108.05,109.82 ; R1852.1 107.31,109.82 ; C573.2 212.44,111.08 v4(212.86,111.5) ; v4(205.86,128.5) 205.36,128 C46.2 ; v4(205.86,128.5) 205.36,129 C13.2 ; v4(205.86,128.5) U1.AG27 C21.2 ; v4(200.86,132.5) 200.37,132.98 C88.2 ; C968.2 284.68,95.97 v4(285.1,96.39) ; v4(202.86,103.5) 203.28,103.08 C554.1 ; C227.1 v1(271.49,131.41) ; R1134.2 267.21,189.59 v1(267.15,189.53) ; R1134.2 268.43,189.59 ; R1134.2 268.06,189.93 ; v4(230.86,127.5) 231.36,127 C286.2 ; R1447.2 177.65,120.5 v1(177.92,120.77) ; C2151.1 153.66,129.46 v7(154.2,129.46) ; C2151.1 153.54,128.74 ; C2151.1 154.12,129.34 ; v4(212.86,123.5) U1.AB20 C301.2 ; v4(219.86,108.5) U1.H14 C429.2 ; 103.78,6.96 R975.1 ; R975.1 v1(104.15,6.33) ; R975.1 104.52,6.96 ; C434.1 212.88,103.47 v4(212.86,103.5) ; R12983.2 162.42,114.1 ; R12983.2 161.54,113.59 v1(161.54,112.78) ; R12983.2 161.68,114.1 ; R12983.2 162.05,113.75 ; v4(211.86,130.5) 211.36,131 C99.2 ; C798.2 v1(159.76,8.13) ; C798.2 160.13,8.87 ; C798.2 159.39,8.87 ; C359.2 U1.P24 v4(209.86,115.5) ; C569.1 203.44,121.08 v4(203.86,121.5) ; C660.1 206.55,167.17 v4(206.46,167.08) ; U156.2 v1(48.39,84.29) ; C248.2 221.44,127.08 v4(221.86,127.5) 222.28,127.08 C378.2 ; C497.2 U1.B13 v4(220.86,102.5) ; C1674.2 83.84,44.45 v1(83.37,44.92) ; C1583.2 282.26,188.16 v1(282.45,188.34) ; R12777.1 v1(141.55,125.9) ; v4(23.43,96.3) 23.93,95.8 C2172.1 ; v4(227.86,136.5) U1.AR6 C365.1 ; R992.1 303.57,43.06 ; R992.1 v1(303.2,43.77) ; R992.1 302.83,43.06 ; v4(215.86,113.5) 215.44,113.91 C588.2 ; C835.2 238.04,16.62 ; C835.2 237.69,16.25 ; C835.2 v1(238.04,15.55) ; U63.12 v1(166.39,32.32) ; R1650.1 160.17,119.15 ; R1650.1 159.82,119.52 ; R1650.1 159.82,118.54 v7(159.38,118.09) ; C2092.1 20.93,95.8 v4(20.43,95.3) ; C516.2 198.28,105.08 v4(197.86,105.5) ; C2088.2 17.01,86.88 v4(17.43,87.3) ; C2080.1 20.01,92.88 v4(20.43,93.3) 20.93,93.8 C2096.2 ; 295.07,25.04 C802.2 ; C802.2 v1(294.4,25.41) ; C802.2 295.07,25.78 ; C465.2 U1.E15 v4(217.86,105.5) ; v4(219.86,105.5) 219.44,105.91 C504.2 ; U180.2 198.15,124.16 197.88,124.43 197.88,125.19 198.15,125.46 v4(198.83,125.46) ; C1303.2 v1(214.71,75.49) ; R722.1 v1(103.74,37.62) ; 140.69,120.46 C2352.1 ; C2352.1 140.69,121.2 ; C2352.1 140.34,120.83 ; C2095.2 20.93,94.8 v4(20.43,94.3) ; C549.2 207.64,100.63 C555.2 207.36,101 v4(207.86,101.5) ; C91.1 249.72,137.11 v4(250.1,136.73) ; v4(209.86,108.5) 210.28,108.91 C454.1 ; R310.2 277.52,89.97 v4(277.1,90.39) ; C816.2 173.97,8.87 ; C816.2 v1(173.6,7.93) ; C816.2 173.23,8.87 ; v4(228.86,135.5) 229.36,135 C281.2 ; v4(115.6,128.05) 115.91,127.75 C1400.1 115,127.18 114.83,127.02 C897.1 ; 33.74,49.26 C1641.2 ; C1641.2 34.09,48.7 v8(34.42,48.36) ; C1641.2 34.09,49.63 ; R682.1 v1(204.98,36.62) ; C672.2 218.99,165.04 v4(218.63,164.68) ; v1(171.66,47.2) R402.1 R401.1 ; C782.2 v1(294.41,29.85) ; C782.2 295.07,30.22 ; C782.2 295.07,29.48 ; R1843.1 122.31,193.51 v7(121.37,193.51) ; R1843.1 122.78,193.41 ; R1843.1 122.78,192.67 ; R1843.1 122.44,193.04 ; v1(78.12,62.79) 77.99,62.66 U151.2 ; C2246.2 60.15,114.75 v4(60.78,114.13) ; C2301.2 47.64,102.23 ; C2301.2 47.28,101.87 ; C2301.2 47.28,103.04 v1(47.37,103.12) ; v1(59.77,142.56) 59.21,142.56 C2302.2 59.45,141.41 v1(59.77,141.41) ; v4(229.86,105.5) U1.E3 C484.2 ; C2463.2 194.28,122.78 v1(193.86,122.36) 194.15,122.08 C529.2 194.76,121.48 194.94,121.67 195.69,121.67 v4(195.86,121.5) ; v1(224.6,159.28) 224.6,158.48 R151.1 ; Q35.1 v1(191.24,41.73) ; C570.2 207.44,113.91 v4(207.86,113.5) ; C34.2 215.44,127.08 v4(215.86,127.5) ; 150.56,174.88 PR194.2 ; PR194.2 v1(149.89,175.25) ; PR194.2 150.56,175.63 ; v4(222.86,138.5) 223.36,138 C56.2 ; C776.2 v1(143.07,11.23) ; C2356.1 v1(146.57,117.57) ; C2356.1 146.2,116.92 ; C2356.1 146.94,116.92 ; U47.12 181.67,33.46 ; U47.12 181.4,34.31 ; v4(277.1,94.39) 276.68,94.81 C2077.2 ; C346.2 U1.AU26 v4(206.86,138.5) ; C1364.2 v1(141.68,27.87) ; C1364.2 142.33,27.5 ; C1364.2 142.33,28.24 ; v1(120.57,95.69) 121.2,96.32 C2386.1 ; R1625.1 v1(70.87,83.37) ; C1253.2 v1(98.43,75.49) ; v4(201.86,134.5) 201.37,134.98 C361.2 ; 266.13,7.38 C850.2 ; C850.2 v1(266.5,6.65) ; C850.2 266.87,7.38 ; v1(66.79,188.33) 65.75,187.29 U61.3 ; v1(85.7,183.34) R961.1 R960.1 R1722.1 ; v4(205.86,115.5) 206.28,115.08 C252.1 ; C321.1 226.56,160.26 v4(226.18,159.87) 225.7,160.36 C340.1 ; v1(127.82,9.86) 128.09,10.14 C777.2 ; R339.1 R338.1 v1(115.32,43.09) ; v1(79.5,83.75) 79.61,83.64 80.36,83.64 C2001.1 ; v4(212.23,154.27) 211.85,153.89 C280.1 ; v4(218.63,162.27) 218.7,162.35 C659.2 219.46,162.37 C11.2 219.47,163.3 R102.1 ; v1(113.18,95) 113.53,95.35 R278.2 ; v1(106.05,118.62) 106.46,118.2 C987.2 ; Q37.4 223.94,41.57 v1(223.65,41.87) ; R1779.1 v1(151.71,135.1) ; Q41.1 v1(280.59,41.75) ; 89.14,42.34 Q28.1 ; Q28.1 88.59,42.61 ; Q28.1 90.11,42.61 v1(90.22,42.5) ; 100.85,90.58 C2121.2 ; C2121.2 101.22,90.24 ; v7(155.67,127.98) 156.31,127.35 C2141.1 ; C760.2 v1(92.06,6.96) ; C760.2 92.43,7.6 ; C760.2 91.69,7.6 ; U55.12 255.62,33.31 ; U55.12 v1(255.62,31.26) ; U55.12 255.89,32.46 ; C410.2 U1.N19 v4(214.86,113.5) ; C2280.2 61.42,127.51 v1(62.1,127.51) ; C967.2 284.6,88.89 v4(285.1,89.39) ; v4(66.93,108.84) 66.62,109.15 C2286.1 ; C759.2 v1(93.33,6.96) ; C759.2 92.96,7.6 ; C759.2 93.7,7.6 ; 64.64,78.66 C1382.1 ; C1382.1 63.9,79.01 v1(63.75,78.87) ; C1382.1 65.01,79.01 ; C2321.2 62.91,117.1 62.46,116.65 v1(62.46,116.53) ; 9.73,32.13 C1978.1 ; C1978.1 10.07,31.76 ; C1978.1 10.07,32.47 v1(9.78,32.77) ; v4(250.1,131.13) 249.68,131.55 C76.1 ; R12284.1 v1(107.24,181.54) ; v4(199.26,155.87) 198.87,155.49 C653.2 198.14,155.49 197.57,156.06 C90.2 ; R1033.1 117.02,106.73 v1(116.27,105.99) ; C104.2 220.36,137.99 v4(219.86,138.5) ; R1615.2 v1(71.75,78.54) ; R1870.2 89.58,189.1 v1(89.15,189.1) ; R1870.2 89.58,189.45 ; R1870.2 89.93,189.08 ; C78.2 255.96,118.92 v4(255.7,118.66) 256.29,118.08 C77.2 ; C2040.1 137.81,122.85 ; C2040.1 137.46,122.48 ; v1(293.38,106.2) C990.2 v1(294.64,105.22) ; C2462.2 109.45,138.78 ; C2462.2 109.1,138.41 ; 274.2,19.66 R685.1 ; R685.1 274.95,19.66 ; C1213.2 237.66,72.74 ; C1213.2 v1(238.38,72.37) ; C1213.2 237.66,72 ; v1(37.59,113.92) 37.21,113.54 36.63,113.54 PC332.2 36.43,113.91 v1(37.15,114.63) ; C198.2 240.85,175 v1(240.67,175.18) 240.98,175.18 C211.1 ; C580.2 187.02,103.85 v1(187.25,103.62) ; v4(18.43,90.3) 19.11,89.62 R1682.2 ; v8(271.75,75.17) 271.63,75.04 R617.2 ; v4(134.21,95.36) 134.71,94.86 C890.1 ; C368.1 231.36,133 v4(230.86,133.5) ; v4(136.21,103.36) 135.79,102.94 C867.2 ; C1417.1 66,127.79 v1(65.39,128.4) ; v1(163.7,119.11) 163.45,119.11 R12982.2 ; C2289.2 62.59,110.46 v4(62.53,110.53) ; v1(236.28,168.16) 236.72,167.72 C673.2 C39.1 ; v1(184.91,149.35) 184.91,148.38 184.64,148.11 R12442.1 ; U56.12 241.54,32.46 ; U56.12 241.27,33.31 ; C380.1 220.44,115.91 v4(220.86,115.5) ; C2262.1 47.36,120.18 C2259.2 47.36,118.57 46.88,118.09 C2264.1 45.83,118.09 v4(45.45,117.71) ; C566.1 220.44,113.91 v4(220.86,113.5) ; C1940.1 112.71,82.75 ; C1940.1 111.97,82.75 ; C1940.1 v1(112.34,81.99) ; v1(100.84,198.92) 100.72,198.79 R757.1 ; 273.98,72.04 C1105.2 ; C1105.2 v1(274.95,72.41) ; C1105.2 273.98,72.78 ; C421.2 194.53,133.88 v1(195.58,134.93) ; v1(27.71,101.26) 28.02,100.96 C2106.2 ; v4(218.86,119.5) 219.28,119.08 C372.1 ; C1997.1 73.76,85.75 ; C1997.1 73.02,85.75 ; C1997.1 v1(73.39,84.89) ; v1(157.23,42.37) R380.1 R381.1 ; C2219.2 v1(273.07,11.18) ; C2219.2 273.72,10.81 ; C2219.2 273.72,11.55 ; 87.17,82.64 C2335.1 ; C2335.1 v1(87.17,84.02) ; C2335.1 87.64,83.19 ; v1(160.05,112.56) 160.43,112.93 160.43,113.72 160.04,114.1 R12768.2 ; v1(165.99,126.24) 166.24,125.99 C2142.1 ; v4(24.43,91.3) 24.01,91.72 C2116.2 ; v1(53.8,101.47) R12346.2 ; R12346.2 53.43,102.1 ; R12346.2 54.17,102.1 ; v1(4.19,33.27) 4.06,33.4 R1720.1 ; C690.1 252.56,128.21 v1(252.25,127.9) ; R1616.2 v1(70.48,78.49) ; v4(244.76,154.27) 244.34,153.85 C66.2 244.13,153.44 C735.2 238.98,153.44 C59.1 239.15,154.02 v4(239.15,154.27) ; C475.2 228.28,105.08 v4(227.86,105.5) ; R1640.1 v1(305.79,20.17) ; R583.1 247.95,37.32 v1(248.1,37.46) ; C508.2 199.36,119 v4(199.86,119.5) ; C2097.2 87.74,82.02 87.26,81.54 v7(87.26,81.17) ; R1891.1 171.7,84.89 ; R1891.1 171.7,84.15 ; 37.6,194.08 C1603.1 ; C1603.1 v1(38.84,194.08) ; C1603.1 37.97,194.43 ; C870.1 U23.L1 v4(126.21,105.36) ; D53.1 40.39,202.69 v1(40.77,202.31) ; C2421.2 v1(144.61,83.4) ; C2421.2 145.5,83.03 ; C2421.2 145.5,83.77 ; v4(195.86,129.5) 196.36,130 C401.2 ; C579.2 202.36,121 v4(202.86,121.5) ; C595.2 206.44,125.08 v4(206.86,125.5) ; C204.2 230.76,170.18 231.39,169.54 v1(231.79,169.54) ; C2039.1 v1(143.78,115.13) ; C2039.1 144.32,115.96 ; C2039.1 143.23,115.96 ; 145.06,85.65 C2417.1 ; C2417.1 145.41,85.28 ; C2417.1 145.41,86.22 v1(145.29,86.34) ; v4(197.86,134.5) 198.37,135.01 C92.2 ; 304.97,43.06 R993.1 ; R993.1 v1(305.34,43.77) ; R993.1 305.71,43.06 ; R1274.2 274.96,113.86 ; R1274.2 274.96,113.12 ; R700.1 127.76,39.22 CJ8.S28 ; v4(214.86,126.5) 214.44,126.08 C265.2 ; v1(189.94,136.42) 190.37,136 C617.2 ; v1(268.07,184.87) 267.07,184.87 Q10.2 ; C279.2 U1.U15 v4(218.86,117.5) ; v1(157.23,47.07) R388.1 R387.1 ; v4(259.7,137.53) 259.95,137.78 C751.2 260.02,138.3 R191.2 ; C668.2 229.46,160.88 v4(229.09,161.24) 228.52,160.67 C667.2 ; C814.2 176.52,8.87 ; C814.2 175.77,8.87 ; C814.2 v1(176.14,8.23) ; 16.83,149.76 PR389.2 ; PR389.2 16.83,150.5 ; PR389.2 v1(16.16,150.13) ; v1(31.98,153.59) PC64.2 PR103.2 ; 38.59,189.24 C2161.2 ; C2161.2 38.94,188.87 ; C2161.2 v1(38.94,190.14) ; R618.2 v1(143.77,73.85) ; C810.2 175.27,21.53 ; C810.2 174.53,21.53 ; C810.2 v1(174.9,22.24) ; R1790.2 31.78,91.41 v1(31.37,91.82) ; C427.2 U1.E11 v4(222.86,105.5) ; v1(71.96,71.91) 72.48,72.43 C1995.1 ; R1617.1 64.33,88.22 v1(64.17,88.39) ; R1617.1 65.27,88.22 ; R1617.1 64.9,88.57 ; C2313.2 58.62,129.99 v1(59.05,130.43) ; C951.2 U25.K6 v4(283.1,96.39) ; C2450.2 65.25,115.65 v4(64.93,115.33) ; v4(224.86,130.5) 225.36,130 C117.2 ; C657.1 233.45,162.35 v4(233.38,162.27) ; v4(253.3,120.26) 252.42,121.14 C692.1 ; 256.01,72.04 C1093.2 ; C1093.2 256.01,72.78 ; C1093.2 v1(255.27,72.41) ; C2103.2 23.01,96.88 v4(23.43,97.3) ; 219.69,72 C1198.2 ; C1198.2 219.69,72.74 ; C1198.2 v1(218.96,72.37) ; C988.1 288.68,96.81 v4(289.1,96.39) ; C453.2 220.85,100.41 C435.2 221.36,101 v4(220.86,101.5) ; 266.38,106.92 C983.2 ; C983.2 v1(267.46,106.92) ; C983.2 266.75,106.57 ; R12910.1 72.6,57.56 ; R12910.1 72.26,57.19 ; R12910.1 72.6,56.82 ; v1(76.33,100.46) 76.05,100.18 R13001.1 ; C997.2 v1(97.9,72.37) ; C997.2 97.23,72.74 ; C997.2 97.23,72 ; R1434.1 202.44,111.91 v4(202.86,111.5) ; C1985.1 v1(18.66,41.23) ; C1985.1 17.82,41.6 ; C1985.1 17.82,40.85 ; v1(244.86,11.18) 244.6,11.43 C838.2 ; C553.2 204.28,107.08 v4(203.86,107.5) ; R184.1 260.5,116.6 ; R184.1 260.85,116.97 ; R681.1 v1(207.9,20.31) ; C611.2 202.44,116.08 v4(202.86,116.5) ; C391.1 U1.AE17 v4(216.86,126.5) U1.AF17 C12.2 ; C2001.1 80.37,83.99 ; C2001.1 80,83.63 ; 251.45,207.23 PR223.2 ; PR223.2 252.19,207.23 ; v4(132.21,91.36) 131.79,91.78 C858.2 ; 218.7,8.74 C772.1 ; C772.1 219.44,8.74 ; C772.1 v1(219.07,8.08) ; v1(296.57,137.75) 296.3,137.48 PR136.2 ; R562.1 v1(229.9,36.12) ; C2100.2 15.93,96.8 v4(16.43,96.3) ; v4(197.86,112.5) 197.36,113 C561.1 ; C55.2 224.36,133.99 v4(223.86,134.5) ; C1995.1 72.84,73.41 ; C1995.1 72.48,73.78 ; R1851.1 v1(113.54,110.61) ; R1851.1 113.17,109.97 ; R1851.1 113.91,109.97 ; R736.1 v1(248.28,36.62) ; C249.1 U1.AD24 v4(208.86,125.5) ; C841.2 v1(230.76,12.74) ; C841.2 231.49,13.11 ; C841.2 231.49,12.37 ; C481.2 229.28,107.91 v4(228.86,107.5) ; 154.91,132.38 C2150.1 ; C2150.1 154.31,132.95 ; R1645.1 181.78,153.68 v7(182.18,153.28) ; R1645.1 181.44,154.11 ; R1645.1 181.78,154.48 ; R12720.2 v1(79.88,110.42) ; R12720.2 79.15,110.05 ; R12720.2 79.15,110.79 ; v4(226.18,157.47) 226.17,157.46 C305.1 ; C1283.2 v1(122.58,73.84) ; 41.25,102.04 C2314.2 ; C2314.2 41.62,102.4 ; C2314.2 v1(40.51,102.4) ; v4(119.6,126.45) 119.67,126.52 C1401.2 ; U68.8 108.07,16.56 ; U68.8 v1(107.81,15.37) ; U68.8 107.81,17.41 ; Q30.1 v1(118.86,41.44) ; v4(224.86,101.5) 225.36,101 C440.2 ; v4(65.73,111.33) 66.11,111.71 C2318.1 ; v4(62.53,111.33) 61.59,111.33 61.21,111.71 PC341.2 61.49,112.3 62.36,112.3 v4(62.53,112.13) ; C415.2 211.28,127.91 v4(210.86,127.5) ; C2249.2 45.86,122.93 v4(45.45,122.51) ; C597.2 v1(184.23,106.64) ; C597.2 183.86,105.47 ; C597.2 184.6,105.47 ; PC199.2 223.39,166.52 C42.1 224.56,167.09 v1(224.88,167.41) 224.88,168.17 225.44,168.73 C699.1 ; C1081.2 185.64,72.74 ; C1081.2 v1(186.35,72.37) ; C1081.2 185.64,72 ; 103.96,42.21 Q29.1 ; Q29.1 105.06,42.21 ; Q29.1 v1(104.51,41.58) ; v4(200.06,154.27) 199.68,153.89 C89.1 199.72,153.6 202.04,153.6 C743.2 204.01,153.92 204.29,153.64 C258.1 205.24,153.85 v4(205.66,154.27) ; v4(201.86,126.5) 201.86,126.58 C383.2 ; R192.1 253.45,137.68 v4(253.3,137.53) ; v4(228.86,110.5) 228.44,110.91 C488.2 ; 295.07,22.5 C800.2 ; C800.2 v1(294.39,22.87) ; C800.2 295.07,23.24 ; C1567.2 264.54,189.31 v1(264.77,189.54) ; C437.2 U1.B5 v4(228.86,102.5) ; v1(265.23,6.65) C851.2 ; C851.2 265.6,7.38 ; C851.2 264.86,7.38 ; v4(245.56,164.68) 245.85,164.38 C31.2 246.39,164.36 R142.1 ; v1(279.53,183.26) 279.34,183.08 C1562.2 ; R686.1 v1(277.6,21.06) ; v1(69.14,90.3) 68.95,90.49 U99.3 ; C1582.2 v1(269.47,187.93) ; C1582.2 269.1,188.68 ; C1582.2 269.84,188.68 ; C1366.2 v1(244.88,27.76) ; C1366.2 245.52,27.39 ; C1366.2 245.52,28.13 ; PR354.2 58.52,197.73 ; PR354.2 58.18,197.36 ; v4(201.86,116.5) 201.44,116.08 C610.1 ; C1299.2 v1(134.66,73.84) ; C2317.1 66.27,115.85 v1(66.55,115.57) ; C576.1 212.36,114 v4(212.86,114.5) U1.N20 C574.1 ; v1(279.53,192.66) 280.29,193.42 R1109.1 ; C398.2 215.44,114.91 v4(215.86,114.5) ; v4(212.86,138.5) 213.51,139.14 C347.2 ; v4(219.86,118.5) 220.46,119.09 R1442.1 ; R1720.1 4.44,34.07 ; R1720.1 3.69,34.07 ; C405.2 205.28,125.08 v4(204.86,125.5) 204.44,125.08 C406.2 ; C806.2 v1(308.22,22.78) ; C310.1 226.98,154.02 v4(226.98,154.27) ; C2099.2 16.16,103.06 ; C2099.2 15.62,103.63 v1(16,104.01) ; C2099.2 15.07,103.06 ; C891.2 132.71,95.86 v4(132.21,95.36) 132.63,94.94 C898.1 ; 133.98,116.91 C2045.1 ; C2045.1 v1(133.1,117.25) ; C2045.1 134.35,117.25 ; v4(206.86,132.5) 206.37,132.99 C344.2 ; C571.1 206.44,111.08 v4(206.86,111.5) ; 190.98,113.85 C605.2 ; C605.2 191.35,114.21 ; v4(196.86,105.5) 196.36,105 C521.2 ; C306.2 216.28,130.91 v4(215.86,130.5) 216.37,129.99 C308.2 ; C741.1 257.43,116.59 v1(256.92,116.08) ; C384.2 U1.AN34 v4(198.86,134.5) ; v4(211.86,105.5) 212.28,105.08 C501.1 ; v1(13.34,88.07) 13.6,87.81 C2086.1 ; C550.2 203.71,101.34 v4(203.86,101.5) ; 165.87,125.56 C2142.1 ; C2142.1 166.61,125.56 ; v8(306.59,87.16) 306.62,87.12 R622.2 ; R664.1 v1(174.17,37.62) ; C200.1 v1(229.26,175.06) ; C1189.2 213.51,72.74 ; C1189.2 213.51,72 ; C1189.2 v1(214.63,72.37) ; C73.2 225.36,136 v4(224.86,136.5) ; v4(126.21,93.36) U23.L13 C881.1 ; C43.1 250.53,128.42 v1(251.04,127.91) 251.55,128.42 C367.2 ; v4(196.86,122.5) 197.28,122.08 C387.1 ; U62.12 v1(95.07,32.32) ; U62.12 95.07,34.31 ; U62.12 95.34,33.46 ; 296.3,136.6 PR136.2 ; PR136.2 296.65,136.98 ; C1102.2 268.09,73.13 v1(268.26,73.3) ; C1102.2 267.74,72.41 ; C1102.2 268.09,72.04 ; v8(220.56,75.12) 220.69,74.99 R619.2 ; C979.2 281.6,93.89 v4(282.1,93.39) U25.L9 C986.1 ; v4(132.21,104.36) 132.63,104.78 C871.2 ; C278.1 U1.U21 v4(212.86,118.5) ; C586.2 221.28,111.91 v4(220.86,111.5) ; 93.97,90.52 C1633.1 ; C1633.1 94.84,91.07 v7(95.05,90.86) ; C1633.1 93.97,91.61 ; R13020.1 73.52,128.26 ; R13020.1 73.89,127.91 ; R1692.1 v1(4.15,75.81) ; v1(75.69,130.43) 75.1,130.43 R1759.1 ; C608.2 v1(191.99,129.43) C2083.2 ; R12917.2 v1(18.41,83.85) ; v4(250.1,125.06) 249.72,125.44 C67.1 ; C205.2 229.49,170.4 v1(229.49,169.67) ; PC217.2 263.63,153.81 v8(263.92,153.52) ; C826.2 220.29,21.66 v1(220.6,21.97) ; C1284.2 v1(122.58,75.24) ; D45.1 v1(43.49,193.86) ; R1637.1 v1(303.37,44.95) ; C1309.2 v1(278,74.14) ; 58.17,44.15 R1266.1 ; R1266.1 58.91,44.15 ; R1266.1 v1(58.54,43.51) ; v4(218.86,122.5) U1.AA15 C273.2 ; C1314.2 v1(150.6,75.49) ; C116.1 204.37,137.99 v4(203.86,138.5) ; v1(30.1,91.69) 29.57,92.23 R1820.2 ; C955.1 278.68,94.81 v4(279.1,94.39) ; C2452.2 137.97,199.71 v1(138.31,200.05) ; C612.2 194.2,112.87 194.99,112.08 C523.1 195.36,112 v4(195.86,111.5) 195.76,111.4 194.78,111.4 194.53,111.65 C600.2 ; C466.1 218.44,108.91 v4(218.86,108.5) ; C830.2 224.44,8.74 ; C830.2 v1(224.07,8.03) ; C830.2 223.7,8.74 ; C364.2 208.36,133.99 v4(207.86,134.5) ; v1(46.61,88.79) 46.94,89.12 C1678.1 ; C845.2 264.36,20.33 ; C845.2 263.99,20.67 ; C2319.2 49.39,106.03 48.24,104.88 v1(48.24,104.38) ; C2319.2 50.02,106.39 ; C2319.2 50.39,106.03 ; C355.1 214.44,117.91 v4(214.86,117.5) ; C206.1 v1(207.41,175.18) ; v4(228.86,129.5) 229.36,129 C363.1 ; v4(232.86,119.5) 232.9,119.5 233.36,119.04 C476.1 ; v4(216.86,119.5) 217.28,119.08 C327.1 ; C1054.2 v1(162.19,72.37) ; C1054.2 161.48,72 ; C1054.2 161.48,72.74 ; C1288.2 v1(186.84,75.49) ; C1222.2 v1(243.21,72.37) ; R100.1 207.28,164.62 C10.2 206.5,164.63 v4(206.46,164.68) ; R1641.1 v1(305.91,44.95) ; v1(40.75,108.66) 41.13,108.28 C2309.1 C2310.2 ; C209.2 218.02,175.05 v1(217.89,175.18) ; v4(210.86,125.5) U1.AD22 C335.1 ; R1862.1 v1(114.94,100.89) ; v4(224.86,102.5) U1.B9 C493.1 ; C392.2 U1.U17 v4(216.86,117.5) ; C815.2 v1(174.87,7.93) ; C815.2 174.5,8.87 ; C815.2 175.24,8.87 ; v8(180.61,75.12) 180.74,74.99 R613.2 ; 224.85,207.85 PR322.2 ; PR322.2 225.72,208.35 v1(225.72,208.37) 226.24,207.86 PC310.2 ; PR322.2 225.22,208.19 ; R847.1 v1(87.23,23.09) ; C2275.2 65.64,110.44 v4(65.73,110.53) 65.76,110.56 C2293.1 ; PR3.2 99.31,206.91 v8(99.24,206.83) ; PR3.2 99.31,208.2 ; PR3.2 99.66,207.83 ; R667.1 v1(145.09,37.62) ; v1(262.77,6.68) C834.1 ; C834.1 262.4,7.39 ; C834.1 263.14,7.39 ; C803.2 v1(308.15,25.83) ; R592.2 v1(300.83,44.89) ; C1279.2 v1(250.51,73.17) ; C883.1 U23.L3 v4(126.21,102.36) ; R665.1 v1(175.54,37.62) ; U14.7 163.83,16.69 163.35,16.21 v1(163.35,15.57) ; v4(223.86,123.5) 223.36,124 C48.2 ; v4(245.56,167.08) 245.69,167.21 C694.2 ; 235.93,20.57 R738.1 ; R738.1 236.67,20.57 ; R738.1 v1(236.3,19.93) ; v1(182.39,148.11) R12441.1 ; C260.1 v1(208.88,155.72) ; v4(216.86,132.5) 217.37,131.98 C309.2 ; C58.2 231.36,124 v4(230.86,124.5) ; v4(69.52,103.59) 69.93,104 R12312.2 ; v4(209.86,105.5) U1.E23 C455.2 ; 74.83,130.32 R1759.1 ; R1759.1 74.83,131.07 ; R1759.1 75.17,130.7 ; v4(134.21,104.36) 134.63,104.78 C869.2 ; C2442.2 v1(115.06,198.2) ; C239.1 v1(271.38,138.17) ; v4(261.3,126.66) 261.57,126.93 C9.1 ; C1259.2 v1(163.02,75.49) ; R77.2 223.44,114.91 v4(223.86,114.5) 224.36,114 C445.1 ; 133.24,41.44 Q31.1 ; Q31.1 132.69,41.7 ; Q31.1 134.12,41.7 v1(134.24,41.58) ; PC368.1 7.13,176.39 7.53,175.99 v7(8.24,175.99) 8.27,175.99 ; C287.2 229.36,126 v4(228.86,126.5) ; R1107.1 v1(264.29,192.46) ; v4(206.86,113.5) 206.44,113.91 C582.1 ; v4(195.86,102.5) 196.28,102.08 C519.2 ; v4(45.45,112.11) 45.51,112.05 C2258.2 ; C686.2 233.86,167.55 v4(233.38,167.08) ; C1397.1 U25.L11 v4(283.1,91.39) ; v4(216.86,124.5) U1.AC17 C270.2 ; v1(190.07,132.41) 189.74,132.08 189,132.08 R9.2 ; v1(263.96,6.65) C852.2 ; C852.2 263.59,7.38 ; C852.2 264.33,7.38 ; C789.1 v1(203.56,10.77) ; Q41.4 v1(279.48,39.83) ; C1684.2 v1(76.86,51.67) ; C1684.2 77.21,52.33 ; C1684.2 76.86,52.71 ; 304.56,72.76 C1246.2 ; C1246.2 v1(305.43,73.13) ; C1246.2 304.56,73.5 ; PC364.2 290.2,134.28 v8(289.7,134.79) ; R668.1 v1(146.46,37.62) ; C1593.2 v1(34.16,206.1) ; C1593.2 32.9,206.1 ; C1593.2 33.27,205.75 ; C1818.1 73.81,63.82 ; C1818.1 74.34,64.01 v1(74.94,64.01) ; C1818.1 74.18,63.47 ; R872.1 v1(160.43,37.72) R1728.1 ; R443.1 v1(273.81,36.16) 274.04,36.16 R444.1 ; C1638.2 95.38,84.64 v1(95.12,84.38) ; C1638.2 94.83,85.86 ; C1638.2 95.92,85.86 ; C1678.1 46.94,89.85 ; C1678.1 46.59,89.48 ; 104.12,100.62 U149.10 104.39,99.76 ; PC9.2 83.87,207.7 84.95,207.7 v1(84.96,207.71) ; v4(219.86,116.5) 219.44,116.91 C381.2 ; v1(115.19,44.96) 115.03,45.12 R345.1 R346.1 ; U49.12 v1(212.32,31.26) ; U49.12 212.32,33.31 ; U49.12 212.58,32.46 ; C829.2 v1(224.1,22.04) ; 68.97,178.28 C1604.2 ; C1604.2 69.71,178.28 ; C1604.2 v1(69.34,177.55) ; v4(217.86,116.5) U1.T16 C332.1 ; v1(144.8,84.29) 145.03,84.52 C2420.1 ; v1(147.2,92.27) 147.56,91.9 C2422.1 ; C86.1 242.35,159.35 241.66,158.66 v1(241.39,158.66) C711.1 ; 164.22,91.34 R12935.1 ; R12935.1 164.59,91.68 ; R1450.1 198.48,121.11 v4(198.86,121.5) ; D52.1 v1(36.58,206.94) ; C1404.2 134.79,99.78 v4(135.21,99.36) 134.79,98.94 C1387.1 ; R897.1 v1(219.71,36.7) ; v4(218.86,115.5) U1.R15 C400.2 ; 105.58,126.52 R1735.1 ; R1735.1 105.77,126.36 104.78,126.36 v1(104.39,125.98) ; R1735.1 105.92,126.15 ; v4(17.43,96.3) 17.85,95.88 C2108.2 ; v4(226.86,105.5) 226.44,105.91 C449.2 ; v4(39.05,119.31) 38.97,119.24 C2254.1 ; Q33.4 v1(163.62,43.66) ; C775.2 142.35,12.87 ; C775.2 v1(143.07,12.5) ; C775.2 142.35,12.13 ; v1(47.75,85.35) U173.2 ; R1715.1 v1(104.9,85.2) ; C1385.2 108.76,125.5 v1(108.48,125.78) 109.14,126.44 C1384.2 C1399.1 109.56,127.38 109.12,127.82 C1386.2 ; C428.1 217.44,103.08 v4(217.86,103.5) ; R739.1 v1(233.93,36.62) ; 27.74,88.66 C2127.2 ; C2127.2 v1(28.57,89.21) ; C2127.2 27.74,89.76 ; C785.2 v1(307.49,33.91) ; R1111.1 v1(272.28,197.03) ; C350.1 214.44,122.08 v4(214.86,122.5) 214.36,123 C272.2 ; v4(202.86,130.5) 202.36,131 C93.2 ; v1(263.08,75.15) 262.82,75.41 C1296.2 ; R1719.1 65.01,84.62 ; R1719.1 64.64,84.27 ; R1719.1 63.81,84.62 v1(63.69,84.5) ; C366.2 203.37,132.99 v4(203.86,132.5) ; C1357.2 v1(126.75,27.82) ; C1009.2 v1(102.72,72.37) ; C1009.2 103.41,72 ; C1009.2 103.41,72.74 ; C530.2 v1(254.67,104.27) ; C530.2 255.04,101.07 ; C530.2 254.3,101.07 ; 75.7,99.57 R13001.1 ; R13001.1 76.05,99.2 ; C100.2 218.25,160.26 v4(218.63,159.87) 219.22,160.46 C114.2 ; v4(61.73,110.53) 61.57,110.37 C2285.2 ; PC243.2 v1(232.89,207.61) ; C433.2 U1.H17 v4(215.86,108.5) ; C594.1 208.28,126.08 v4(207.86,126.5) ; R12314.1 C2244.2 C2170.1 47.43,109.47 46.76,110.14 C2257.2 45.82,110.14 v4(45.45,110.51) ; v4(222.86,108.5) 222.44,108.91 C457.1 ; C687.1 207.26,162.34 C632.1 206.53,162.35 v4(206.46,162.27) ; Q36.1 v1(208.7,39.79) ; C242.1 271.36,133.34 v1(271.51,133.5) ; R755.1 v1(264.9,36.62) ; 67.45,183.49 C2062.2 ; C2062.2 67.82,183.14 ; C2062.2 v1(68.68,183.49) ; v6(42.01,188.27) 41.76,188.53 41.76,189.87 42.43,190.54 U102.3 ; v4(197.86,126.5) 197.36,127 C385.1 ; C2171.1 v1(165.11,141.35) ; C2171.1 165.48,140.63 ; C2171.1 164.73,140.63 ; C2130.2 29.06,90.59 ; C2130.2 v1(28.59,91.44) ; C2130.2 28.59,90.04 ; v1(79.55,79.98) 80.3,79.98 C1993.1 ; R740.1 v1(235.31,36.62) ; C892.1 U23.D5 v4(134.21,101.36) ; 32.28,152.56 PR103.2 ; PR103.2 32.62,152.19 ; C1989.1 v1(7.11,31.73) ; U21.7 v1(268.03,15.67) ; v4(225.86,112.5) 225.44,112.91 C436.1 ; R12445.1 v1(186.97,153.47) ; 217.26,27.39 C2221.1 ; C2221.1 v1(216.46,27.76) ; C2221.1 217.26,28.13 ; R757.1 101.09,197.95 ; R757.1 100.34,197.95 ; v4(196.86,136.5) U1.AR36 C402.2 ; C416.2 U1.AF20 v4(212.86,127.5) ; R1226.2 v1(112.37,90.53) ; C267.2 U1.AC15 v4(218.86,124.5) ; C336.2 211.44,119.08 v4(211.86,119.5) 212.28,119.91 C333.2 ; 145.52,84.15 C2420.1 ; C2420.1 145.52,84.89 ; R1440.1 211.36,113 v4(211.86,112.5) ; C318.1 217.41,153.85 v4(217.83,154.27) ; 309.52,41.79 R1733.1 ; R1733.1 v1(309.52,43.31) ; R1733.1 309.87,42.16 ; C607.2 208.44,118.91 v4(208.86,118.5) ; v1(286.38,189.23) 286.38,189.61 C1553.2 285.62,189.61 v1(285.62,189.23) ; C2306.1 v1(42.31,117.38) ; v4(223.86,105.5) 223.36,105 C503.1 ; C478.2 228.44,117.08 v4(228.86,117.5) ; v4(112.4,125.65) 112.62,125.87 C1390.2 ; PC32.2 PR70.2 v1(73.99,208.29) ; C485.2 U1.B1 v4(232.86,102.5) ; C536.1 U1.E35 v4(198.86,105.5) ; C1579.2 273.84,183.67 v1(274.19,184.02) ; C431.2 215.28,108.91 v4(214.86,108.5) ; 249.54,19.84 R271.2 ; R271.2 250.01,19.84 v1(250.48,20.31) ; R271.2 249.91,20.19 ; v4(215.86,136.5) 215.36,137 C102.2 ; v1(194.53,137.21) 194.3,136.98 C604.2 ; C502.2 216.44,105.91 v4(216.86,105.5) ; C562.2 206.36,105 v4(206.86,105.5) ; 47.37,79.21 R12705.2 ; R12705.2 v1(47.74,78.58) ; R12705.2 48.11,79.21 ; C1998.1 68.91,74.27 v1(68.63,74.55) ; C578.1 200.28,121.08 v4(199.86,121.5) ; R754.1 v1(263.52,36.62) ; 82.71,59.34 R317.1 ; R317.1 83.08,59.68 ; C787.2 v1(308.13,30.78) ; R593.2 v1(302.1,44.95) ; v1(279.43,190.16) R1133.2 ; C757.2 v1(91.1,22.16) ; v4(214.86,134.5) 215.37,133.98 C311.2 ; C1057.2 155.59,72.74 ; C1057.2 155.59,72 ; C1057.2 v1(154.85,72.37) ; C303.2 217.37,137.99 v4(216.86,138.5) ; C395.2 215.44,116.91 v4(215.86,116.5) ; R12899.1 56.8,80 ; R12899.1 56.06,80 ; 188.32,156.34 C2049.2 ; C2049.2 v1(189.2,156.89) ; C2049.2 188.32,157.43 ; v1(116.5,96.68) R274.1 ; C477.2 231.44,105.08 v4(231.86,105.5) ; v1(233.94,175.28) 234.09,175.13 C196.2 ; C714.2 251.32,126.25 v4(251.7,125.86) ; U20.10 v1(212.73,16.36) ; C788.2 v1(308.13,29.77) ; R13069.1 v1(70.94,131.46) ; v1(299.56,44.88) R1631.1 ; C1298.2 v1(134.66,75.24) ; C525.1 197.28,110.08 v4(196.86,110.5) ; R1433.1 219.42,114.05 v4(219.86,114.5) U1.P14 C253.2 ; C2296.2 64.62,110.22 v4(64.93,110.53) ; C418.2 U1.U10 v4(223.86,117.5) ; R683.1 v1(207.69,39.11) ; v4(134.21,91.36) 133.79,91.78 C865.1 ; C1576.2 286.51,186.77 v1(286.51,187.83) ; C98.1 v1(257.2,121.63) ; C1996.1 v1(72.05,84.41) ; v4(229.86,108.5) 230.36,108 C438.1 ; v1(26.77,101.26) 27.11,100.91 C2107.2 ; R1896.1 v1(168,91.5) ; R1696.1 122.78,123.05 ; R1696.1 122.78,122.31 ; R1696.1 v1(123.57,122.68) ; v4(45.45,116.91) 45.86,116.5 C2248.2 ; C1225.2 v1(250.45,72.37) ; C1225.2 249.74,72 ; C1225.2 249.74,72.74 ; C1295.2 262.98,74.01 v1(263.1,74.14) ; PR20.2 84.33,206.36 84.71,205.97 v1(84.71,205.89) ; Q31.4 135.79,43 ; Q31.4 v1(135.24,43.79) ; Q31.4 134.7,43 ; v1(203.15,160.03) 203.49,160.37 C108.1 ; v4(280.1,97.39) 279.6,96.89 C989.1 ; v7(155.67,128.72) 155.01,128.72 C2152.1 ; v1(45.05,72.1) 45.27,72.32 Q13.2 ; v4(14.43,97.3) 14.01,97.72 C2102.2 ; R2001.1 138.12,181.51 ; R2001.1 137.38,181.51 ; R2001.1 v1(137.75,182.33) ; 120.25,147.72 C1307.2 ; C1307.2 v1(121.44,147.72) ; C1307.2 120.62,147.37 ; C189.2 214.16,174.97 v1(213.96,175.18) ; C307.1 226.36,125.99 v4(225.86,126.5) 225.44,126.08 C342.1 ; C671.1 230.9,156.6 v4(231.78,157.47) ; v1(116.72,95.88) 116.93,95.67 R272.1 ; C235.2 271.18,126.59 v1(271.49,126.89) ; C2149.1 158.09,127.37 v7(157.48,127.98) ; R12981.2 163.47,116.95 v1(163.75,116.95) ; C609.2 v1(189.32,126.77) ; v1(109.73,116.11) C1405.2 ; R1105.2 262.98,189.22 262.44,189.22 v1(262.23,189.43) ; C1269.2 v1(110.51,74.09) ; 106.26,83.35 C2208.2 ; C2208.2 107,83.35 ; C2208.2 106.63,83.64 v1(106.26,84.01) ; C1238.2 v1(300.71,80.56) ; C758.2 v1(92.47,22.16) ; C584.2 U1.L11 v4(222.86,111.5) ; C285.1 211.44,136.08 v4(211.86,136.5) ; R150.2 224.6,164.74 225.09,164.25 C655.1 225.81,164.25 v4(226.18,163.87) ; C847.2 266.9,20.33 ; C847.2 266.16,20.33 ; C847.2 v1(266.53,20.96) ; R325.1 R324.1 v1(100.36,42.37) ; v4(206.86,129.5) 207.28,129.08 C15.2 ; U13.7 v1(299.86,32.61) ; 57.97,81.65 C2334.1 ; C2334.1 v1(57.28,81.99) ; C2334.1 58.34,81.99 ; U10.7 93,17.12 ; U10.7 92.74,16.27 ; U10.7 v1(92.74,18.29) ; C560.2 205.28,114.08 v4(204.86,114.5) ; v4(208.86,104.5) 208.44,104.08 C3.2 ; v1(57.85,124.28) 57.73,124.4 C2278.2 C2277.1 ; R849.1 v1(87.76,37.7) ; C2310.2 42.14,108.29 ; C2310.2 42.51,107.93 ; C222.2 271.28,124.66 v1(271.49,124.86) ; R606.2 92.34,74.99 v8(92.21,75.12) ; C966.2 284.6,90.89 v4(285.1,91.39) ; v1(110.37,72.33) 110.33,72.37 C1006.2 ; 258.27,190.09 C1555.2 ; C1555.2 v1(258.62,190.8) ; C1555.2 258.62,189.72 ; C115.2 219.06,157.84 v4(218.63,158.27) ; C1258.2 v1(161.84,73.15) ; v1(231.78,41.72) R570.1 ; R570.1 232.09,41.72 ; R570.1 232.83,41.72 ; C949.2 281.6,89.89 v4(282.1,90.39) 281.6,90.89 C952.1 ; C1006.2 109.31,72 ; C1006.2 109.31,72.74 ; C2279.2 63.61,110 v4(64.13,110.53) ; PC404.2 22.23,150.13 ; PC404.2 22.57,149.76 ; PC404.2 22.39,149.59 v8(22.39,148.56) ; PC404.2 22.23,149.38 ; R1435.1 202.44,110.91 v4(202.86,110.5) ; v4(126.21,90.36) 125.79,89.94 C859.2 ; C756.2 v1(89.72,22.16) ; C2312.2 59.21,117.84 v4(59.33,117.73) ; v8(116.36,74.87) 116.49,74.74 R612.2 ; v4(230.86,112.5) 231.36,113 C439.1 ; C2152.1 155.01,128.15 ; C2152.1 154.43,128.75 ; C2152.1 154.43,127.55 ; C283.1 219.37,135.99 v4(218.86,136.5) ; R1170.1 44.73,193.01 v1(44.45,193.29) ; R1170.1 44.73,191.78 ; R1170.1 45.08,192.15 ; v4(199.26,159.87) 199.12,160.01 C94.1 ; 273.8,26.42 C1379.1 ; C1379.1 274.15,26.05 ; C1379.1 v1(274.15,27.17) ; C289.2 222.36,135.99 v4(221.86,136.5) ; C95.2 204.37,134.99 v4(204.86,134.5) ; C1332.2 v1(106.81,96.68) ; v4(230.86,136.5) 231.36,136 C62.1 ; R13089.1 57.81,196.32 v1(58.04,196.09) ; R12778.1 138.98,125.9 v1(138.86,126.01) ; v4(39.05,120.11) 38.99,120.18 C2252.1 ; v4(60.78,114.88) 61.18,114.48 U181.2 ; 263.66,22.6 R753.1 ; R753.1 v1(264.04,21.96) ; R753.1 264.41,22.6 ; R1007.1 127.17,144.31 v1(126.77,144.7) ; R1007.1 127.54,143.82 ; R1007.1 126.8,143.82 ; C773.2 v1(135.63,17.01) ; R1639.1 v1(307.87,45.62) ; C358.1 218.28,127.91 v4(217.86,127.5) ; v4(227.86,122.5) U1.AA6 C590.1 ; C217.2 v1(204.51,175.1) ; C507.2 199.36,118 v4(199.86,118.5) ; C771.1 88.61,7.6 ; C771.1 v1(88.24,6.96) ; C771.1 87.87,7.6 ; 79.94,79.97 C1993.1 ; C1993.1 80.31,79.61 ; C745.2 264.36,137.81 v1(264.25,137.92) 263.8,138.38 C8.1 ; C1313.2 v1(150.6,74.09) ; C987.2 106.81,118.56 ; C987.2 107.18,118.2 ; v4(283.1,94.39) 283.52,93.97 C947.2 ; R1634.1 v1(299.44,20.17) ; C778.2 v1(127.82,11.14) ; C842.2 v1(230.76,14.01) ; C842.2 231.49,13.64 ; C842.2 231.49,14.38 ; C1629.2 101.21,93.17 ; C1629.2 100.84,93.52 ; C1629.2 v1(100.1,93.17) ; v4(290.1,91.39) 290.46,91.75 R13071.1 ; v1(143.16,47.15) R374.1 R373.1 ; C257.1 218.37,133.99 v4(217.86,134.5) 217.36,135 C304.2 ; v4(221.86,121.5) 221.44,121.08 C396.1 ; PR204.2 196.98,207.9 v1(196.88,208) ; PR204.2 196.61,207.23 ; PR204.2 197.35,207.23 ; v4(223.86,108.5) U1.H10 C462.1 ; v4(211.86,102.5) 211.44,102.08 C496.1 ; C1078.2 v1(179.74,71.66) ; C1078.2 179.4,72.37 ; C1078.2 179.74,72.74 ; PQ24.2 72.31,189.19 v1(72.39,189.1) ; C452.2 216.79,100.49 C461.2 216.36,101 v4(216.86,101.5) 217.36,101 C432.1 ; v1(171.68,88.51) R1893.1 ; v1(30.49,204.54) D55.1 ; U43.2 v1(58,49.4) ; R590.1 v1(259.4,36.17) ; v1(291.37,40.99) R450.1 ; v4(206.86,103.5) 207.28,103.08 C522.2 ; C2375.2 57.79,108.86 v4(57.73,108.92) ; v4(17.43,91.3) 17.43,92.26 R12484.2 ; C234.1 v1(271.38,139.13) ; R607.2 156.59,74.99 v8(156.46,75.12) ; C341.2 206.86,157.47 v4(206.46,157.47) ; C849.2 268.15,7.38 ; C849.2 267.4,7.38 ; C849.2 v1(267.77,6.65) ; v4(222.86,117.5) U1.U11 C251.2 ; v8(128.44,74.87) 128.57,74.74 R615.2 ; R699.1 v1(130.43,20.96) ; C357.2 U1.AB26 v4(206.86,123.5) ; C1278.2 250.51,75.83 v1(251,76.32) ; 43.5,103.25 C2299.2 ; C2299.2 v1(44.05,104.16) ; C2299.2 44.6,103.25 ; R108.1 210.85,157.47 v4(211.43,157.47) ; v4(130.21,92.36) 129.71,91.86 C880.2 ; C957.2 289.52,90.97 v4(289.1,91.39) 289.39,91.68 R13070.1 ; C2281.1 61.01,126.06 61.54,125.54 v1(61.54,125.14) 61.44,125.04 C2282.2 ; C107.2 222.36,129.99 v4(221.86,130.5) ; Q29.4 v1(106.52,44.15) ; C473.1 231.36,119 v4(231.86,119.5) ; R13005.2 v1(8.97,32.89) ; C397.2 U1.R19 v4(214.86,115.5) ; v1(45.91,83.94) 46.3,83.55 C1817.1 ; R591.1 v1(260.42,36.27) ; C2240.2 43.06,112.4 v1(42.67,112.01) ; v4(22.43,93.3) 22.93,93.8 C2082.2 ; C738.1 257.64,129.87 v4(258.1,130.33) ; C1566.2 v1(277.9,190.14) ; R147.1 237.75,157.47 v4(238.35,157.47) ; R548.1 v1(217.66,37.58) ; C786.2 v1(308.16,31.8) ; C495.2 U1.D24 v4(208.86,105.5) ; C875.2 v1(286.62,104.15) ; C875.2 287.67,104.15 ; C875.2 287.3,103.79 ; 177.05,8.87 C813.2 ; C813.2 177.79,8.87 ; C813.2 v1(177.42,8.13) ; C712.2 252.46,132.77 v4(253.3,131.93) 253.38,132.01 C713.2 253.38,133.62 253.96,134.2 C747.1 ; R1086.1 R1085.1 v1(65.72,174.79) ; R1086.1 67.62,174.44 ; R1086.1 68,174.79 ; v4(15.43,95.3) 15.85,95.72 C2120.2 ; C953.1 285.6,89.89 v4(286.1,90.39) 285.68,90.81 C954.1 ; 303.31,35.24 U69.8 ; U69.8 305.01,35.24 ; U69.8 v1(304.16,34.59) ; v1(56.38,127.57) 56.63,127.33 C2276.2 ; C417.1 U1.AE15 v4(218.86,126.5) ; v1(142.37,118.13) 142.23,118 R12781.1 ; C2210.2 v1(93.83,191.87) ; v4(226.86,128.5) 227.36,128 C302.1 ; R717.1 v1(116.92,23.09) ; C1565.2 v1(268.68,182.81) ; v8(208.49,75.12) 208.62,74.99 R616.2 ; v4(226.86,119.5) 226.35,118.99 C468.1 ; D54.1 v1(38.92,200.08) ; C828.2 v1(222.83,22.04) ; C598.1 208.44,114.08 v4(208.86,114.5) ; v1(15.62,34.42) 15.48,34.56 Q42.2 ; PR361.2 v1(59.39,137.58) ; C537.2 200.36,101 v4(199.86,101.5) 199.36,101 C518.1 199.77,100.5 C531.2 ; PC166.2 v1(149.89,176.41) ; R436.1 v1(272.8,36.06) ; C247.2 219.44,125.08 v4(219.86,125.5) ; R719.1 v1(117.78,37.62) ; v4(215.86,123.5) 215.44,123.91 C330.1 ; C1991.1 v1(74.67,79.01) ; C105.2 221.37,133.99 v4(220.86,134.5) ; R718.1 v1(116.41,37.62) ; v4(136.21,92.36) U23.B14 C862.1 ; C755.2 v1(88.35,22.16) ; C268.1 208.28,122.08 v4(207.86,122.5) ; R8.2 188.49,136.74 188.19,137.04 186.53,137.04 v1(186.23,136.74) ; v4(220.86,105.5) 220.44,105.91 C499.2 ; R721.1 v1(102.36,37.62) ; v4(126.21,101.36) 125.79,100.94 C985.1 ; C792.2 v1(161.06,22.24) ; v4(212.86,132.5) 212.36,133 C254.1 ; R1693.1 v1(4.16,74.74) ; C753.1 v1(132.82,16.26) ; C534.2 U1.E31 v4(202.86,105.5) ; Q30.4 v1(120.87,44.17) ; v4(204.86,157.47) 203.98,156.6 C652.1 ; R12337.2 v1(76.2,119.31) ; C1242.2 v1(303.37,80.82) ; v1(209.76,41.65) Q36.4 ; C1360.2 v1(99.34,27.11) ; v4(219.86,123.5) 219.44,123.08 C374.2 ; PC429.2 77.71,184.04 ; R611.2 244.85,74.99 v8(244.72,75.12) ; R1034.1 v1(116.21,101.89) ; R1441.1 204.72,119.36 v4(204.86,119.5) ; v1(233.21,171.16) 233.39,170.97 R146.2 ; C774.2 v1(134.57,17.06) ; v4(232.86,110.5) 232.44,110.91 C482.1 ; C298.2 212.28,124.08 v4(211.86,124.5) ; v1(224.33,16.67) U18.7 ; U18.7 224.33,18.74 ; U18.7 224.6,17.89 ; R429.1 261.49,37.27 v1(261.26,37.04) ; U51.12 v1(137.12,32.26) ; 187.73,155.24 C2050.1 ; C2050.1 v1(189.36,155.61) ; C2050.1 187.73,155.98 ; C861.2 127.63,90.78 v4(127.21,90.36) ; C538.1 206.36,110 v4(206.86,110.5) ; v4(204.86,110.5) 204.36,110 C515.1 ; U52.12 v1(194.71,32.15) ; C791.2 v1(159.79,22.17) ; R1632.1 v1(300.71,20.17) ; C246.1 205.44,119.91 v4(205.86,119.5) ; R1633.1 v1(298.29,44.88) ; v1(163.19,135.21) 163.19,135.25 163.4,135.46 C2146.2 ; C825.1 v1(307.24,21) ; v8(256.88,75.17) 257.01,75.04 R614.2 ; C1980.2 27,49.73 ; C1980.2 26.65,49.36 ; C866.1 123.79,104.78 v4(124.21,104.36) ; v4(243.96,157.47) 243.12,156.63 C689.2 ; C2390.1 121.42,100.15 v4(121.21,100.36) ; v1(147.07,90.45) 147.5,90.89 C2415.1 ; C444.2 226.36,108 v4(225.86,108.5) ; R1636.1 v1(303.25,20.17) ; v4(202.86,108.5) 202.44,108.91 C542.2 ; R873.1 v1(159.08,37.7) ; R409.1 R408.1 v1(185.81,42.53) ; v1(85.26,44.95) 84.85,44.54 C2220.2 ; R1227.2 v1(112.44,91.55) ; Q33.1 v1(161.61,40.93) ; C360.1 226.36,138 v4(225.86,138.5) ; v4(216.86,122.5) 216.44,122.08 C545.1 ; v1(185.8,110.47) 185.7,110.57 185.7,111.12 C388.2 186.19,111.37 186.69,110.87 v1(186.69,110.53) ; R895.1 v1(219.21,22.8) ; v1(51.18,117.22) 50.93,117.47 PC330.2 ; C688.2 v1(247.97,156.73) ; C524.2 197.28,115.91 v4(196.86,115.5) ; C16.2 222.44,125.08 v4(222.86,125.5) 223.28,125.08 C22.2 ; v4(221.86,123.5) 221.44,123.08 C47.2 ; C1413.1 128.79,101.05 128.79,100.78 v4(129.21,100.36) ; v4(136.21,91.36) 136.63,91.78 C860.1 ; C1308.2 v1(277.14,76.45) ; v1(186.76,150.89) 186.97,151.1 R12446.1 ; R569.1 v1(233.45,37.6) ; v4(280.1,95.39) U25.N7 C981.2 ; C746.1 255.45,122.25 v1(255,121.8) 254.5,122.3 C739.2 ; v1(208.88,154.7) C26.1 208.15,154.28 208.57,153.86 C28.1 v1(209.41,153.43) ; C1274.2 v1(174.81,74.09) ; C106.1 205.37,130.98 v4(205.86,130.5) ; Q40.1 v1(266.23,39.83) ; R12285.1 v1(108.23,181.58) ; v3(173.4,169.27) 173.49,169.36 PR181.2 ; C1268.2 v1(110.51,75.49) ; C1264.2 v1(238.86,74.09) ; C194.2 v1(233.13,175.1) ; C1395.2 108.97,124.05 ; C805.2 v1(308.21,23.8) ; C2256.2 41.41,120.18 v4(41.51,120.09) ; C2416.2 147.4,89.87 v1(147.07,89.53) ; v4(205.86,122.5) 206.36,123 C297.1 ; R1724.1 v1(103.52,21.54) ; Q17.2 v1(274.19,185.08) ; v4(199.86,112.5) U1.M33 C558.2 ; R720.1 v1(102.88,23.09) ; v1(308.14,24.81) C804.2 ; R666.1 v1(145.6,23.09) ; C839.2 v1(230.76,10.19) ; R1145.2 v1(272.13,189.67) ; R871.1 v1(158.55,23.09) ; C661.2 v1(221.05,156.73)
  BOTTOM w0.508: PC84.2 290.81,135.79 v8(289.7,135.79) ; C1244.2 298.71,74.55 v1(297.73,74.55) ; v4(206.86,138.5) 207.81,139.44 C290.2 ; C1247.2 306.12,74.04 v1(306.58,74.04) ; PC178.2 187.58,204.58 PC182.2 ; v4(222.86,138.5) 222.9,138.54 C53.2 ; C2132.1 163.04,134.19 v1(163.08,134.15) ; PC138.2 153.45,190.41 153.96,189.9 ; C2414.2 v5(44.5,62.31) ; v4(216.86,138.5) 216.7,138.66 C323.2 ; v4(200.86,138.5) 202.04,139.68 C312.2 ; C2412.2 v5(50.85,62.28)
  vias: v1(0.83,208) v1(0.83,206.73) v1(0.83,205.46) v1(0.83,204.19) v1(0.83,202.92) v1(0.83,201.65) v1(0.83,200.38) v1(0.83,199.11) v1(0.83,197.84) v1(0.83,196.57) v1(0.83,195.3) v1(0.83,194.03) v1(0.83,192.76) v1(0.83,191.49) v1(0.83,190.22) v1(0.83,188.95) v1(0.83,187.68) v1(0.83,186.41) v1(0.83,185.14) v1(0.83,183.87) v1(0.83,182.6) v1(0.83,181.33) v1(0.83,180.06) v1(0.83,178.79) v1(0.83,177.52) v1(0.83,176.25) v1(0.83,174.98) v1(0.83,173.71) v1(0.83,172.44) v1(0.83,171.17) v1(0.83,169.9) v1(0.83,168.63) v1(0.83,167.36) v1(0.83,166.09) v1(0.83,164.82) v1(0.83,163.55) v1(0.83,162.28) v1(0.83,161.01) v1(0.83,159.74) v1(0.83,158.47) v1(0.83,157.2) v1(0.83,155.93) v1(0.83,154.66) v1(0.83,153.39) v1(0.83,152.12) v1(0.83,150.85) v1(0.83,149.58) v1(0.83,148.31) v1(0.83,147.04) v1(0.83,145.77) v1(0.83,144.5) v1(0.83,143.23) v1(0.83,141.96) v1(0.83,140.69) v1(0.83,139.42) v1(0.83,138.15) v1(0.83,136.88) v1(0.83,135.61) v1(0.83,134.34) v1(0.83,133.07) v1(0.83,131.8) v1(0.83,130.53) v1(0.83,129.26) v1(0.83,127.99) v1(0.83,126.72) v1(0.83,125.45) v1(0.83,124.18) v1(0.83,122.91) v1(0.83,121.64) v1(0.83,120.37) v1(0.83,119.1) v1(0.83,117.83) v1(0.83,116.56) v1(0.83,115.29) v1(0.83,114.02) v1(0.83,112.75) v1(0.83,111.48) v1(0.83,110.21) v1(0.83,108.94) v1(0.83,107.67) v1(0.83,106.4) v1(0.83,105.13) v1(0.83,103.86) v1(0.83,102.59) v1(0.83,101.32) v1(0.83,100.05) v1(0.83,98.78) v1(0.83,97.51) v1(0.83,96.24) v1(0.83,94.97) v1(0.83,93.7) v1(0.83,92.43) v1(0.83,91.16) v1(0.83,89.89) v1(0.83,88.62) v1(0.83,87.35) v1(0.83,86.08) v1(0.83,84.81) v1(0.83,83.54) v1(0.83,82.27) v1(0.83,81) v1(0.83,79.73) v1(0.83,78.46) v1(0.83,77.19) v1(0.83,75.92) v1(0.83,74.65) v1(0.83,73.38) v1(0.83,72.11) v1(0.83,70.84) v1(0.83,69.57) v1(0.83,68.3) v1(0.83,67.03) v1(0.83,65.76) v1(0.83,64.49) v1(0.83,63.22) v1(0.83,61.95) v1(0.83,60.68) v1(0.83,59.41) v1(0.83,58.14) v1(0.83,56.87) v1(0.83,55.6) v1(0.83,54.33) v1(0.83,53.06) v1(0.83,51.79) v1(0.83,50.52) v1(0.83,49.25) v1(0.83,47.98) v1(0.83,46.71) v1(0.83,45.44) v1(0.83,44.17) v1(0.83,42.9) v1(0.83,41.63) v1(0.83,40.36) v1(0.83,39.09) v1(0.83,37.82) v1(0.83,36.55) v1(0.83,35.28) v1(0.83,34.01) v1(0.83,32.74) v1(0.83,31.47) v1(0.83,30.2) v1(0.83,28.93) v1(0.83,27.66) v1(0.83,26.39) v1(0.83,25.12) v1(0.83,23.85) v1(0.83,22.58) v1(0.83,21.31) v1(0.83,20.04) v1(0.83,18.77) v1(0.83,17.5) v1(0.83,16.23) v1(0.83,14.96) v1(0.83,13.69) v1(0.83,12.42) v1(0.83,11.15) v1(0.83,9.88) v1(0.83,8.61) v1(0.83,7.34) v1(0.83,6.07) v1(0.83,4.92) v1(0.83,3.78) v1(0.83,2.51) v1(1.02,1.27) v1(1.34,209.16) v1(2.09,0.95) v1(2.61,209.16) v1(2.85,1.84) v1(3.14,79.02) v1(3.28,71.94) v1(3.36,0.95) v1(3.58,66.7) v1(3.58,52.02) v1(3.72,46.86) v1(3.88,209.16) v1(4.12,1.84) v1(4.63,0.95) v1(4.92,49.66) v1(5.15,209.16) v1(5.39,1.84) v1(5.9,0.95) v1(6.42,209.16) v1(6.66,1.84) v1(6.98,49.41) v1(7.17,0.95) v1(7.69,209.16) v1(7.93,1.84) v1(8.13,24) v1(8.13,22.99) v1(8.13,22.1) v1(8.13,21.21) v1(8.13,20.32) v1(8.44,0.95) v1(8.64,77.47) v1(8.96,209.16) v1(9.2,1.84) v1(9.28,49.41) v1(9.71,0.95) v1(10.09,52.54) v1(10.23,209.16) v1(10.19,67.11) v1(10.41,24) v1(10.47,1.84) v1(10.98,0.95) v1(11.5,209.16) v1(11.74,1.84) v1(12.25,0.95) v1(12.77,209.16) v1(12.83,138.3) v1(12.83,137.41) v1(13.01,1.84) v1(13.52,0.95) v1(13.72,138.27) v1(13.72,137.41) v1(13.82,55.93) v1(14.04,209.16) v1(14.23,63.25) v1(14.28,1.84) v1(14.35,74.04) v1(14.71,137.44) v1(14.79,0.95) v1(15.31,209.16) v1(15.36,75.93) v1(15.49,143.51) v1(15.55,1.84) v1(16.06,0.95) v1(16.26,143) v1(16.38,75.95) v1(16.58,209.16) v1(16.82,1.84) v1(17.14,143) v1(17.14,0.94) v1(17.85,209.16) v1(17.93,72.07) v1(17.91,1.83) v1(18.03,142.99) v1(18.06,50.83) v1(18.41,0.94) v1(18.91,142.99) v1(18.92,77.45) v1(19.12,209.16) v1(19.2,73.15) v1(19.18,1.83) v1(19.93,142.99) v1(19.87,0.95) v1(20.07,77.47) v1(20.39,209.16) v1(20.45,143.89) v1(20.63,1.84) v1(20.95,143) v1(21.14,0.95) v1(21.66,209.16) v1(21.72,144.02) v1(21.9,1.84) v1(22.1,143) v1(22.23,0.97) v1(22.93,209.16) v1(22.86,144.02) v1(22.99,1.85) v1(23.11,143) v1(23.5,0.97) v1(24,143.51) v1(24.2,209.16) v1(24.26,1.85) v1(24.64,142.62) v1(24.95,0.95) v1(25.15,143.51) v1(25.47,209.16) v1(25.71,1.84) v1(25.78,142.75) v1(26.22,0.95) v1(26.36,143.29) v1(26.74,209.16) v1(26.88,142.56) v1(26.98,1.84) v1(27.51,143.17) v1(27.49,0.95) v1(27.94,94.23) v1(27.94,91.95) v1(28.01,209.16) v1(28.03,142.3) v1(28.25,1.84) v1(28.61,144.21) v1(28.58,143.22) v1(28.63,35.43) v1(28.76,0.95) v1(29.04,142.3) v1(29.28,209.16) v1(29.52,1.84) v1(29.8,75.07) v1(30.03,0.95) v1(30.09,142.33) v1(30.1,89.41) v1(30.31,96.19) v1(30.51,36.37) v1(30.55,209.16) v1(30.79,1.84) v1(30.86,73.66) v1(30.94,26.14) v1(30.94,25.25) v1(30.94,24.36) v1(31.11,142.33) v1(31.3,0.95) v1(31.82,209.16) v1(31.95,26.14) v1(31.95,25.25) v1(31.95,24.36) v1(32.06,1.84) v1(32.36,35.38) v1(32.57,0.95) v1(32.89,80.29) v1(33.09,209.16) v1(33.33,1.84) v1(33.84,0.95) v1(34.04,93.85) v1(34.04,92.2) v1(34.04,52.96) v1(34.36,209.16) v1(34.6,1.84) v1(35.11,0.95) v1(35.63,209.16) v1(35.87,1.84) v1(36.2,52.96) v1(36.38,0.95) v1(36.71,67.11) v1(36.9,209.16) v1(37.08,99.19) v1(37.14,1.84) v1(37.19,93.52) v1(37.65,0.95) v1(37.72,98.04) v1(38.17,209.16) v1(38.35,92.41) v1(38.41,1.84) v1(38.92,0.95) v1(39.44,209.16) v1(39.68,1.84) v1(40.19,0.95) v1(40.31,213.89) v1(40.31,212.62) v1(40.31,211.35) v1(40.31,210.08) v1(40.76,64.84) v1(40.77,11.05) v1(40.83,9.7) v1(40.83,8.43) v1(40.83,7.16) v1(40.83,5.89) v1(40.83,4.62) v1(40.83,3.35) v1(40.83,2.08) v1(40.92,215.01) v1(41.53,10.41) v1(41.59,9.07) v1(41.59,7.8) v1(41.59,6.53) v1(41.59,5.26) v1(41.59,3.99) v1(41.59,2.72) v1(41.59,1.45) v1(41.66,12.45) v1(42.19,215.01) v1(42.29,11.68) v1(42.7,61.91) v1(43.05,12.83) v1(43.46,215.01) v1(43.56,11.68) v1(44.32,12.83) v1(44.73,215.01) v1(44.83,11.68) v1(45.06,64.44) v1(45.59,12.83) v1(46,215.01) v1(46.1,11.68) v1(46.86,12.83) v1(47.27,215.01) v1(47.37,11.68) v1(48.13,12.83) v1(48.54,215.01) v1(48.64,11.68) v1(49.4,12.83) v1(49.81,215.01) v1(49.91,11.68) v1(50.31,63.32) v1(50.42,102.23) v1(50.67,12.83) v1(51.08,215.01) v1(51.18,11.68) v1(51.59,115.34) v1(51.94,12.83) v1(52.35,215.01) v1(52.45,11.68) v1(52.7,102.23) v1(53.21,12.83) v1(53.62,215.01) v1(53.64,116.56) v1(53.64,114.94) v1(53.72,11.68) v1(53.77,63.04) v1(54.26,60.3) v1(54.48,12.83) v1(54.89,215.01) v1(54.99,11.68) v1(55.75,166.24) v1(55.75,12.83) v1(56.16,215.01) v1(56.26,11.68) v1(56.64,167) v1(56.64,166.24) v1(57.02,12.83) v1(57.43,215.01) v1(57.53,11.68) v1(57.66,167) v1(57.66,166.24) v1(58.2,64.17) v1(58.29,12.83) v1(58.7,215.01) v1(58.8,11.68) v1(59.69,71.75) v1(59.69,70.23) v1(59.97,215.01) v1(60.07,11.68) v1(60.54,139.95) v1(60.49,50.71) v1(61.24,215.01) v1(61.34,11.68) v1(61.98,13.59) v1(62.36,12.45) v1(62.51,215.01) v1(62.51,51.63) v1(63.02,70.33) v1(63.25,13.59) v1(63.63,12.45) v1(63.78,215.01) v1(63.83,49.56) v1(63.83,48.69) v1(63.98,70.38) v1(64.36,44.94) v1(64.52,13.59) v1(64.75,49.58) v1(64.75,48.71) v1(64.9,12.45) v1(65.05,215.01) v1(65.62,49.58) v1(65.62,48.71) v1(65.73,42.17) v1(65.79,13.59) v1(66.17,12.45) v1(66.32,215.01) v1(66.45,199.39) v1(66.5,198.48) v1(66.53,49.58) v1(66.53,48.71) v1(66.76,190.05) v1(67.06,13.59) v1(67.19,143.96) v1(67.19,143) v1(67.4,49.58) v1(67.4,48.71) v1(67.51,50.71) v1(67.59,215.01) v1(67.75,144.57) v1(67.82,15.88) v1(67.85,98.19) v1(68.13,148.15) v1(68.1,147.21) v1(68.08,146.3) v1(68.12,145.44) v1(68.71,38.1) v1(68.86,215.01) v1(69.01,42.49) v1(69.13,45.92) v1(69.25,98.24) v1(70.13,215.01) v1(70.23,50.93) v1(70.99,38.1) v1(71.4,215.01) v1(71.58,57.14) v1(71.88,50.8) v1(72.38,69.21) v1(72.67,215.01) v1(72.77,37.52) v1(73.53,50.67) v1(73.53,49.28) v1(73.94,215.01) v1(74.3,37.39) v1(74.54,69.28) v1(74.55,42.93) v1(75.21,215.01) v1(75.56,139.95) v1(75.69,131.19) v1(75.82,144.15) v1(75.95,143.25) v1(75.95,142.36) v1(76.3,38.68) v1(76.43,139.95) v1(76.36,69.25) v1(76.48,215.01) v1(76.45,42.93) v1(76.58,131.19) v1(76.58,130.43) v1(76.93,202.04) v1(77.22,41.91) v1(77.28,139.95) v1(77.75,215.01) v1(77.95,202.11) v1(78.08,201) v1(78.08,199.95) v1(78.11,37.46) v1(78.2,198.56) v1(78.36,197.36) v1(78.36,196.22) v1(78.54,13.43) v1(78.58,201.61) v1(78.61,69.32) v1(79.02,215.01) v1(79.25,196.47) v1(79.5,201.99) v1(79.47,198.81) v1(79.63,12.45) v1(80.14,37.47) v1(80.29,215.01) v1(80.39,13.46) v1(80.46,198.84) v1(81.03,41.71) v1(81.03,12.45) v1(81.56,215.01) v1(81.61,72.02) v1(81.79,13.46) v1(82.42,12.45) v1(82.83,215.01) v1(82.93,11.05) v1(82.93,9.78) v1(82.93,6.73) v1(82.93,5.21) v1(83.21,143.96) v1(83.21,143) v1(83.19,13.46) v1(83.57,74.85) v1(83.77,144.57) v1(83.76,69.97) v1(83.92,130.07) v1(83.97,4.57) v1(84.1,215.01) v1(84.13,147.21) v1(84.1,146.3) v1(84.15,145.44) v1(84.07,132.33) v1(84.15,148.15) v1(84.24,64.86) v1(84.61,5.58) v1(85.09,77.72) v1(85.22,28.83) v1(85.24,4.57) v1(85.37,215.01) v1(85.37,6.47) v1(85.52,68.62) v1(85.58,133.96) v1(85.88,5.58) v1(86,72.5) v1(86.24,66.98) v1(86.44,135.94) v1(86.51,4.57) v1(86.64,215.01) v1(86.64,6.47) v1(87.15,5.58) v1(87.25,77.6) v1(87.61,74.37) v1(87.78,4.57) v1(87.91,215.01) v1(88.42,5.58) v1(89.05,4.57) v1(89.18,215.01) v1(89.46,169.63) v1(89.69,5.58) v1(90.32,4.57) v1(90.45,215.01) v1(90.81,82.8) v1(90.96,5.58) v1(91.65,169.69) v1(91.59,4.57) v1(91.72,215.01) v1(92.23,5.58) v1(92.63,169.75) v1(92.58,82.8) v1(92.84,83.69) v1(92.86,4.57) v1(92.99,215.01) v1(93.52,64.77) v1(93.52,64.01) v1(93.5,5.58) v1(94.13,4.57) v1(94.26,215.01) v1(94.26,6.47) v1(94.41,64.77) v1(94.41,64.01) v1(94.81,169.73) v1(94.77,5.58) v1(95.13,103.71) v1(95.07,82.78) v1(95.4,4.57) v1(95.53,215.01) v1(95.53,6.47) v1(96.04,5.58) v1(96.14,14.73) v1(96.69,105.38) v1(96.73,82.68) v1(96.67,4.57) v1(96.8,215.01) v1(96.77,84.07) v1(96.8,6.47) v1(97.03,99.82) v1(97.31,5.58) v1(97.79,97.34) v1(97.94,4.57) v1(98.07,215.01) v1(98.07,6.47) v1(98.55,99.82) v1(98.58,5.58) v1(99.19,83.95) v1(99.21,4.57) v1(99.34,215.01) v1(99.31,97.34) v1(99.34,6.47) v1(99.85,5.58) v1(100.48,4.57) v1(100.61,215.01) v1(100.76,120.05) v1(101.12,5.58) v1(101.22,14.73) v1(101.49,120.06) v1(101.75,4.57) v1(101.88,215.01) v1(102.26,120.06) v1(102.39,5.58) v1(103.02,4.57) v1(103.15,215.01) v1(103.12,123.19) v1(103.66,5.58) v1(104.29,4.57) v1(104.42,215.01) v1(104.93,5.58) v1(105.6,64.77) v1(105.6,64.01) v1(105.56,4.57) v1(105.69,215.01) v1(106.2,5.58) v1(106.49,64.77) v1(106.49,64.01) v1(106.83,4.57) v1(106.96,215.01) v1(107.47,5.58) v1(108.1,4.57) v1(108.23,215.01) v1(108.74,5.58) v1(109.37,6.47) v1(109.37,4.57) v1(109.5,215.01) v1(109.88,210.58) v1(110.01,5.58) v1(110.64,6.47) v1(110.64,4.57) v1(110.77,215.01) v1(110.87,210.56) v1(111.28,5.58) v1(111.78,210.58) v1(111.91,6.47) v1(111.91,4.57) v1(112.04,215.01) v1(111.96,73.24) v1(112.55,5.58) v1(113.18,6.47) v1(113.18,4.57) v1(113.31,215.01) v1(113.82,5.58) v1(114.45,6.47) v1(114.45,4.57) v1(114.58,215.01) v1(115.09,7.87) v1(115.09,5.58) v1(115.33,210.57) v1(115.32,150.88) v1(115.57,150.11) v1(115.72,6.47) v1(115.72,4.57) v1(115.85,215.01) v1(116.27,210.59) v1(116.33,150.24) v1(116.36,7.87) v1(116.36,5.58) v1(116.51,150.94) v1(116.99,6.47) v1(116.99,4.57) v1(117.12,215.01) v1(117.06,210.62) v1(117.36,85.46) v1(117.55,146.11) v1(117.63,7.87) v1(117.63,5.58) v1(117.67,64.52) v1(117.67,63.76) v1(117.73,11.43) v1(118.26,6.47) v1(118.26,4.57) v1(118.39,215.01) v1(118.56,64.52) v1(118.56,63.76) v1(118.9,7.87) v1(118.9,5.58) v1(119.23,98.44) v1(119.38,99.85) v1(119.53,6.47) v1(119.53,4.57) v1(119.66,215.01) v1(119.67,146.1) v1(120.17,7.87) v1(120.17,5.58) v1(120.35,97.03) v1(120.66,210.59) v1(120.8,6.47) v1(120.8,4.57) v1(120.93,215.01) v1(121.44,7.87) v1(121.44,5.58) v1(121.53,210.59) v1(122.05,11.56) v1(122.07,6.47) v1(122.07,4.57) v1(122.2,215.01) v1(122.48,210.59) v1(122.71,7.87) v1(122.71,5.58) v1(123.34,6.47) v1(123.34,4.57) v1(123.47,215.01) v1(123.93,146.28) v1(123.98,7.87) v1(123.98,5.58) v1(124.61,6.47) v1(124.61,4.57) v1(124.74,215.01) v1(125.25,7.87) v1(125.25,5.58) v1(125.88,6.47) v1(125.88,4.57) v1(126.01,215.01) v1(126.06,146.28) v1(126.52,5.58) v1(126.75,145.67) v1(127.15,6.47) v1(127.15,4.57) v1(127.28,215.01) v1(127.79,5.58) v1(128.22,145.72) v1(128.42,6.47) v1(128.42,4.57) v1(128.55,215.01) v1(128.84,83.66) v1(128.84,82.77) v1(128.84,81.88) v1(128.84,81) v1(129.06,5.58) v1(129.18,7.87) v1(129.73,83.66) v1(129.73,82.77) v1(129.73,81.88) v1(129.73,81) v1(129.69,6.47) v1(129.69,4.57) v1(129.82,215.01) v1(129.75,64.52) v1(129.75,63.76) v1(130.33,5.58) v1(130.4,147.69) v1(130.43,146.81) v1(130.45,7.87) v1(130.64,64.52) v1(130.64,63.76) v1(130.96,6.47) v1(130.96,4.57) v1(131.09,215.01) v1(131.06,147.96) v1(131.06,147.19) v1(131.06,146.3) v1(131.6,5.58) v1(131.72,7.87) v1(132.23,6.47) v1(132.23,4.57) v1(132.36,215.01) v1(132.87,5.58) v1(132.99,7.87) v1(133.5,6.47) v1(133.5,4.57) v1(133.63,215.01) v1(134.14,5.58) v1(134.26,7.87) v1(134.77,6.47) v1(134.77,4.57) v1(134.9,215.01) v1(135.24,123.7) v1(135.41,5.58) v1(135.53,7.87) v1(135.97,141.11) v1(135.97,140.22) v1(136.04,6.47) v1(136.04,4.57) v1(136.17,215.01) v1(136.71,123.7) v1(136.68,5.58) v1(136.8,7.87) v1(137.31,6.47) v1(137.31,4.57) v1(137.44,215.01) v1(137.75,141.11) v1(137.75,140.22) v1(137.95,5.58) v1(138.07,7.87) v1(138.58,6.47) v1(138.58,4.57) v1(138.71,215.01) v1(139.04,94.11) v1(139.09,92.68) v1(139.2,127.24) v1(139.22,5.58) v1(139.34,7.87) v1(139.95,73.86) v1(139.85,6.47) v1(139.85,4.57) v1(139.98,215.01) v1(140.49,5.58) v1(140.63,82.75) v1(141.12,6.47) v1(141.12,4.57) v1(141.25,215.01) v1(141.35,127.25) v1(141.76,5.58) v1(142.44,105.45) v1(142.39,6.47) v1(142.39,4.57) v1(142.52,215.01) v1(142.82,115.63) v1(142.88,94.08) v1(142.9,92.84) v1(143.01,105.02) v1(143.03,7.87) v1(143.03,5.58) v1(143.51,104.52) v1(143.69,134.98) v1(143.66,133.65) v1(143.66,6.47) v1(143.66,4.57) v1(143.79,215.01) v1(144.3,7.87) v1(144.3,5.58) v1(144.93,6.47) v1(144.93,4.57) v1(145.06,215.01) v1(145.31,123.32) v1(145.44,121.36) v1(145.41,16.26) v1(145.57,119.68) v1(145.57,7.87) v1(145.57,5.58) v1(145.7,64.77) v1(145.7,64.01) v1(146.2,6.47) v1(146.2,4.57) v1(146.33,215.01) v1(146.27,107.6) v1(146.3,11.18) v1(146.58,64.77) v1(146.58,64.01) v1(146.82,107.06) v1(146.84,7.87) v1(146.84,5.58) v1(147.12,126.36) v1(147.19,124.87) v1(147.36,106.45) v1(147.47,6.47) v1(147.47,4.57) v1(147.6,215.01) v1(148.11,7.87) v1(148.11,5.58) v1(148.74,6.47) v1(148.74,4.57) v1(148.87,215.01) v1(149.35,16.26) v1(149.38,7.87) v1(149.38,5.58) v1(150.01,6.47) v1(150.01,4.57) v1(150.14,215.01) v1(150.65,7.87) v1(150.65,5.58) v1(151,11.18) v1(151.13,96.65) v1(151.13,95.76) v1(151.13,95) v1(151.13,94.11) v1(151.28,6.47) v1(151.28,4.57) v1(151.41,215.01) v1(151.92,7.87) v1(151.92,5.58) v1(152.55,6.47) v1(152.55,4.57) v1(152.68,215.01) v1(152.65,141.22) v1(153.16,138.81) v1(153.19,7.87) v1(153.19,5.58) v1(153.54,141.22) v1(153.52,99.32) v1(153.49,98.6) v1(153.82,6.47) v1(153.82,4.57) v1(153.95,215.01) v1(154.46,5.58) v1(155.09,6.47) v1(155.09,4.57) v1(155.22,215.01) v1(155.32,138.81) v1(155.73,5.58) v1(155.75,118.14) v1(155.81,115.97) v1(156.34,81.92) v1(156.34,80.52) v1(156.36,6.47) v1(156.36,4.57) v1(156.49,215.01) v1(157,5.58) v1(157.23,10.67) v1(157.63,6.47) v1(157.63,4.57) v1(157.76,215.01) v1(157.77,64.77) v1(157.77,64.01) v1(158.12,138.2) v1(158.27,5.58) v1(158.66,64.77) v1(158.66,64.01) v1(158.9,6.47) v1(158.9,4.57) v1(159.03,215.01) v1(159.54,5.58) v1(160.03,189.44) v1(160.03,188.3) v1(160.03,187.15) v1(160.25,190.61) v1(160.17,6.47) v1(160.17,4.57) v1(160.3,215.01) v1(160.38,138.25) v1(160.81,5.58) v1(160.96,190.5) v1(161.22,189.44) v1(161.22,188.26) v1(161.16,187.32) v1(161.44,6.47) v1(161.44,4.57) v1(161.57,215.01) v1(162.09,201.58) v1(162.09,200.44) v1(162.09,199.29) v1(162.09,198.2) v1(162.09,196.75) v1(162.09,195.61) v1(162.09,194.47) v1(162.08,5.58) v1(162.71,6.47) v1(162.71,4.57) v1(162.84,215.01) v1(162.81,121.54) v1(163.26,201.61) v1(163.31,200.44) v1(163.31,199.29) v1(163.31,198.2) v1(163.31,196.75) v1(163.31,195.61) v1(163.31,194.47) v1(163.35,5.58) v1(163.98,6.47) v1(163.98,4.57) v1(164.11,215.01) v1(164.62,5.58) v1(165.23,8.13) v1(165.25,6.47) v1(165.25,4.57) v1(165.38,215.01) v1(165.5,127.51) v1(165.56,129.62) v1(165.61,89.64) v1(165.85,83.69) v1(165.89,5.58) v1(165.97,94.79) v1(166.31,132.38) v1(166.27,130.75) v1(166.52,6.47) v1(166.52,4.57) v1(166.65,215.01) v1(167,8.13) v1(167.15,94.82) v1(167.16,5.58) v1(167.46,89.51) v1(167.79,6.47) v1(167.79,4.57) v1(167.92,215.01) v1(167.89,83.69) v1(168.43,5.58) v1(168.66,9.53) v1(169.06,6.47) v1(169.06,4.57) v1(169.19,215.01) v1(169.47,87.99) v1(169.52,86.59) v1(169.49,85.72) v1(169.57,84.25) v1(169.7,5.58) v1(169.85,64.77) v1(169.85,64.01) v1(170.33,6.47) v1(170.33,4.57) v1(170.46,215.01) v1(170.74,64.77) v1(170.74,64.01) v1(170.69,10.92) v1(170.97,5.58) v1(171.6,6.47) v1(171.6,4.57) v1(171.73,215.01) v1(172.24,5.58) v1(172.87,6.47) v1(172.87,4.57) v1(173,215.01) v1(173.51,5.58) v1(174.14,6.47) v1(174.14,4.57) v1(174.27,215.01) v1(174.65,153.87) v1(174.62,152.53) v1(174.78,86.16) v1(174.78,83.9) v1(174.78,5.58) v1(175.41,6.47) v1(175.41,4.57) v1(175.54,215.01) v1(175.54,88.19) v1(175.74,86.56) v1(176.05,5.58) v1(176.32,73.34) v1(176.68,6.47) v1(176.68,4.57) v1(176.81,215.01) v1(177.32,5.58) v1(177.67,111.48) v1(177.94,103.93) v1(177.95,6.47) v1(177.95,4.57) v1(178.08,215.01) v1(178.43,111.48) v1(178.54,103.44) v1(178.59,5.58) v1(179.15,122.73) v1(179.18,111.47) v1(179.22,6.47) v1(179.22,4.57) v1(179.35,215.01) v1(179.72,106.55) v1(179.65,101.87) v1(179.86,5.58) v1(180.49,6.47) v1(180.49,4.57) v1(180.62,215.01) v1(180.57,103.52) v1(181.13,5.58) v1(181.28,103.51) v1(181.56,98.81) v1(181.76,6.47) v1(181.76,4.57) v1(181.89,215.01) v1(181.93,64.77) v1(181.93,64.01) v1(182.02,103.5) v1(182.29,98.81) v1(182.39,149.33) v1(182.42,147.09) v1(182.37,145.72) v1(182.35,98.03) v1(182.4,5.58) v1(182.73,103.5) v1(182.82,64.77) v1(182.82,64.01) v1(183.03,98.81) v1(183.03,6.47) v1(183.03,4.57) v1(183.13,97.76) v1(183.13,96.96) v1(183.16,215.01) v1(183.67,5.58) v1(184.3,6.47) v1(184.3,4.57) v1(184.43,215.01) v1(184.62,133.86) v1(184.62,132.33) v1(184.78,116.84) v1(184.89,146.99) v1(184.91,145.75) v1(184.94,5.58) v1(185.22,144.75) v1(185.17,95.12) v1(185.57,6.47) v1(185.57,4.57) v1(185.7,215.01) v1(186.18,95.89) v1(186.21,7.87) v1(186.21,5.58) v1(186.44,115.19) v1(186.69,96.52) v1(186.84,6.47) v1(186.84,4.57) v1(186.94,117.09) v1(186.97,215.01) v1(187.22,144.85) v1(187.2,143.38) v1(187.45,142.62) v1(187.48,7.87) v1(187.48,5.58) v1(188.11,6.47) v1(188.11,4.57) v1(188.24,215.01) v1(188.62,203.42) v1(188.6,202.54) v1(188.62,201.65) v1(188.62,200.63) v1(188.62,199.49) v1(188.62,198.47) v1(188.75,7.87) v1(188.75,5.58) v1(188.85,141.86) v1(188.98,144.78) v1(188.98,143.26) v1(189.09,75.57) v1(189.38,202.03) v1(189.38,6.47) v1(189.38,4.57) v1(189.51,215.01) v1(189.51,201.27) v1(189.64,198.73) v1(189.71,153.19) v1(189.71,151.18) v1(189.76,196.06) v1(189.97,161.47) v1(189.97,160.58) v1(190.02,134.92) v1(190.02,7.87) v1(190.02,5.58) v1(190.4,201.9) v1(190.37,159.77) v1(190.41,158.92) v1(190.65,6.47) v1(190.65,4.57) v1(190.78,215.01) v1(190.78,196.06) v1(190.86,161.47) v1(190.86,160.58) v1(191.29,7.87) v1(191.29,5.58) v1(191.39,105.34) v1(191.73,161.45) v1(191.77,160.66) v1(191.92,6.47) v1(191.92,4.57) v1(192.05,215.01) v1(192.28,105.34) v1(192.56,7.87) v1(192.56,5.58) v1(193.19,6.47) v1(193.19,4.57) v1(193.32,215.01) v1(193.83,7.87) v1(193.83,5.58) v1(194.46,6.47) v1(194.46,4.57) v1(194.59,215.01) v1(195.1,7.87) v1(195.1,5.58) v1(195.73,6.47) v1(195.73,4.57) v1(195.86,215.01) v1(196.37,7.87) v1(196.37,5.58) v1(197,6.47) v1(197,4.57) v1(197.13,215.01) v1(197.64,5.58) v1(198.27,6.47) v1(198.27,4.57) v1(198.4,215.01) v1(198.91,5.58) v1(199.54,6.47) v1(199.54,4.57) v1(199.67,215.01) v1(200.18,5.58) v1(200.81,6.47) v1(200.81,4.57) v1(200.94,215.01) v1(201.45,5.58) v1(201.82,75.6) v1(202.08,6.47) v1(202.08,4.57) v1(202.21,215.01) v1(202.72,5.58) v1(203.2,30.1) v1(203.35,6.47) v1(203.35,4.57) v1(203.48,215.01) v1(203.99,5.58) v1(204.62,6.47) v1(204.62,4.57) v1(204.75,215.01) v1(205.26,5.58) v1(205.89,6.47) v1(205.89,4.57) v1(206.02,215.01) v1(206.53,5.58) v1(207.16,6.47) v1(207.16,4.57) v1(207.29,215.01) v1(207.8,5.58) v1(208.43,6.47) v1(208.43,4.57) v1(208.56,215.01) v1(209.07,5.58) v1(209.55,195.77) v1(209.55,194.75) v1(209.7,6.47) v1(209.7,4.57) v1(209.83,215.01) v1(209.8,64.77) v1(209.8,64.01) v1(210.06,201.68) v1(210.06,200.66) v1(210.06,199.26) v1(210.19,197.87) v1(210.18,197.03) v1(210.34,5.58) v1(210.56,195.76) v1(210.56,194.75) v1(210.69,64.77) v1(210.69,64.01) v1(210.95,200.84) v1(210.97,6.47) v1(210.97,4.57) v1(211.1,215.01) v1(211.45,201.73) v1(211.45,198.43) v1(211.46,197.46) v1(211.61,5.58) v1(212.24,6.47) v1(212.24,4.57) v1(212.37,215.01) v1(212.88,5.58) v1(213.51,6.47) v1(213.51,4.57) v1(213.64,215.01) v1(214.15,5.58) v1(214.78,6.47) v1(214.78,4.57) v1(214.91,215.01) v1(215.42,5.58) v1(216.05,6.47) v1(216.05,4.57) v1(216.18,215.01) v1(216.69,5.58) v1(217.32,6.47) v1(217.32,4.57) v1(217.45,215.01) v1(217.96,5.58) v1(218.44,85.98) v1(218.44,85.22) v1(218.59,6.47) v1(218.59,4.57) v1(218.72,215.01) v1(219.23,5.58) v1(219.33,85.98) v1(219.33,85.22) v1(219.86,6.47) v1(219.86,4.57) v1(219.99,215.01) v1(220.22,85.98) v1(220.22,85.22) v1(220.5,5.58) v1(221.13,6.47) v1(221.13,4.57) v1(221.26,215.01) v1(221.36,85.98) v1(221.36,85.22) v1(221.77,5.58) v1(221.88,64.77) v1(221.88,64.01) v1(222.4,6.47) v1(222.4,4.57) v1(222.53,215.01) v1(222.54,169.18) v1(222.77,64.77) v1(222.77,64.01) v1(223.04,5.58) v1(223.26,168.89) v1(223.67,6.47) v1(223.67,4.57) v1(223.8,215.01) v1(224.31,5.58) v1(224.94,6.47) v1(224.94,4.57) v1(225.07,215.01) v1(225.58,5.58) v1(225.75,170.99) v1(226.21,6.47) v1(226.21,4.57) v1(226.34,215.01) v1(226.82,170.64) v1(226.85,5.58) v1(227.01,201.28) v1(226.97,7.74) v1(227.48,6.47) v1(227.48,4.57) v1(227.61,215.01) v1(227.65,195.51) v1(227.65,194.49) v1(227.84,16.26) v1(228.03,201.35) v1(228.14,99.95) v1(228.12,5.58) v1(228.16,200.23) v1(228.16,199.19) v1(228.17,99.11) v1(228.24,7.74) v1(228.28,197.8) v1(228.28,196.78) v1(228.66,195.51) v1(228.66,194.49) v1(228.75,6.47) v1(228.75,4.57) v1(228.88,215.01) v1(229.05,200.59) v1(229.39,5.58) v1(229.55,201.48) v1(229.55,198.18) v1(229.81,203.26) v1(230.02,6.47) v1(230.02,4.57) v1(230.15,215.01) v1(230.54,198.2) v1(230.57,202.37) v1(230.66,5.58) v1(231.29,6.47) v1(231.29,4.57) v1(231.42,215.01) v1(231.93,5.58) v1(232.05,7.74) v1(232.56,6.47) v1(232.56,4.57) v1(232.69,215.01) v1(232.67,169.31) v1(233.2,5.58) v1(233.32,7.74) v1(233.83,6.47) v1(233.83,4.57) v1(233.96,215.01) v1(233.95,64.77) v1(233.95,64.01) v1(234.44,91.31) v1(234.47,5.58) v1(234.59,7.74) v1(234.84,64.77) v1(234.84,64.01) v1(235.1,6.47) v1(235.1,4.57) v1(235.23,215.01) v1(235.2,90.42) v1(235.33,91.31) v1(235.74,5.58) v1(235.86,7.74) v1(236.09,90.42) v1(236.22,91.31) v1(236.37,6.47) v1(236.37,4.57) v1(236.5,215.01) v1(236.98,90.42) v1(237.01,5.58) v1(237.12,91.33) v1(237.24,6.47) v1(237.64,4.57) v1(237.74,104.9) v1(237.77,215.01) v1(237.87,90.42) v1(237.87,89.53) v1(237.87,88.65) v1(237.87,87.76) v1(238.12,104.27) v1(238.2,107.35) v1(238.23,106.51) v1(238.25,109.6) v1(238.25,108.84) v1(238.25,108.08) v1(238.25,105.66) v1(238.28,5.58) v1(238.51,6.47) v1(238.63,89.92) v1(238.63,89.03) v1(238.63,88.14) v1(238.63,87.25) v1(238.67,77.28) v1(238.91,4.57) v1(239.04,215.01) v1(239.39,86.95) v1(239.47,87.71) v1(239.55,5.58) v1(240.18,6.47) v1(240.18,4.57) v1(240.31,215.01) v1(240.82,5.58) v1(241.45,6.47) v1(241.45,4.57) v1(241.58,215.01) v1(242.09,5.58) v1(242.72,6.47) v1(242.72,4.57) v1(242.85,215.01) v1(243.44,202.54) v1(243.36,5.58) v1(243.46,203.42) v1(243.46,201.39) v1(243.46,200.25) v1(243.46,199.23) v1(243.46,198.22) v1(243.46,197.2) v1(243.84,196.06) v1(243.99,6.47) v1(243.99,4.57) v1(244.12,215.01) v1(244.38,202.15) v1(244.35,198.85) v1(244.63,5.58) v1(244.73,196.06) v1(245.11,202.15) v1(245.26,6.47) v1(245.26,4.57) v1(245.39,215.01) v1(245.62,196.06) v1(245.9,5.58) v1(246.03,64.77) v1(246.03,64.01) v1(246.53,4.57) v1(246.66,215.01) v1(246.92,64.77) v1(246.92,64.01) v1(247.17,5.33) v1(247.8,4.57) v1(247.93,215.01) v1(248.21,105.16) v1(248.21,104.27) v1(248.44,5.33) v1(249.07,4.57) v1(249.2,215.01) v1(249.23,105.16) v1(249.23,104.27) v1(249.71,5.33) v1(250.25,108.71) v1(250.25,107.82) v1(250.25,106.94) v1(250.25,106.05) v1(250.25,105.16) v1(250.25,104.27) v1(250.34,4.57) v1(250.47,215.01) v1(250.83,112.58) v1(250.83,111.82) v1(250.88,111.04) v1(250.98,5.33) v1(251.14,108.71) v1(251.14,107.82) v1(251.14,106.94) v1(251.14,106.05) v1(251.14,105.16) v1(251.14,104.27) v1(251.61,4.57) v1(251.74,215.01) v1(251.72,112.58) v1(251.72,111.82) v1(251.77,111.04) v1(252.02,108.71) v1(252.02,107.82) v1(252.02,106.94) v1(252.02,106.05) v1(252.02,105.16) v1(252.02,104.27) v1(252.25,5.58) v1(252.87,110.98) v1(252.91,108.71) v1(252.91,107.82) v1(252.91,106.94) v1(252.91,106.05) v1(252.91,105.16) v1(252.91,104.27) v1(252.88,4.57) v1(253.01,215.01) v1(253.52,5.58) v1(253.75,110.98) v1(254.15,4.57) v1(254.28,215.01) v1(254.48,151.84) v1(254.63,110.96) v1(254.79,5.58) v1(255.06,156.87) v1(255.32,197.51) v1(255.42,4.57) v1(255.55,215.01) v1(255.51,112.58) v1(255.51,111.82) v1(255.5,110.98) v1(256.11,205.5) v1(256.06,5.58) v1(256.16,14.73) v1(256.4,112.58) v1(256.4,111.82) v1(256.39,110.98) v1(256.57,82.75) v1(256.69,6.6) v1(256.69,4.57) v1(256.82,215.01) v1(257.05,207.95) v1(257.27,112.56) v1(257.27,111.79) v1(257.26,110.96) v1(257.33,5.58) v1(257.51,198.96) v1(257.96,6.6) v1(257.96,4.57) v1(258.09,215.01) v1(258.2,64.82) v1(258.2,64.05) v1(258.49,196.02) v1(258.55,83.36) v1(258.6,5.58) v1(258.73,211.45) v1(258.86,202.28) v1(259,205.6) v1(259.08,64.82) v1(259.08,64.05) v1(259.17,159.58) v1(259.23,6.6) v1(259.23,4.57) v1(259.33,84.07) v1(259.36,215.01) v1(259.41,171.49) v1(259.84,81.66) v1(259.87,5.58) v1(259.97,9.91) v1(260.35,82.42) v1(260.5,6.6) v1(260.5,4.57) v1(260.63,215.01) v1(260.99,83.31) v1(260.99,14.73) v1(261.14,5.58) v1(261.19,208.1) v1(261.47,203.31) v1(261.75,83.95) v1(261.77,6.6) v1(261.77,4.57) v1(261.9,215.01) v1(262.41,5.58) v1(263.04,4.57) v1(263.17,215.01) v1(263.26,200.9) v1(263.68,5.58) v1(264.1,72.86) v1(264.31,4.57) v1(264.44,215.01) v1(264.82,204.8) v1(264.92,150.11) v1(264.95,5.58) v1(265.13,145.41) v1(265.58,4.57) v1(265.71,215.01) v1(265.99,145.41) v1(266.19,210.7) v1(266.22,5.58) v1(266.45,83.95) v1(266.7,83.19) v1(266.85,4.57) v1(266.98,215.01) v1(267.33,82.55) v1(267.46,96.27) v1(267.46,83.44) v1(267.49,5.58) v1(267.84,81.66) v1(267.97,95.76) v1(268.1,82.8) v1(268.12,4.57) v1(268.25,215.01) v1(268.24,206.12) v1(268.24,201.46) v1(268.61,81.15) v1(268.73,82.17) v1(268.76,5.58) v1(269.39,6.6) v1(269.39,4.57) v1(269.52,215.01) v1(270.03,5.58) v1(270.27,64.82) v1(270.27,64.05) v1(270.66,6.6) v1(270.66,4.57) v1(270.79,215.01) v1(270.89,84.07) v1(271.02,103.38) v1(271.16,64.82) v1(271.16,64.05) v1(271.3,5.58) v1(271.65,83.44) v1(271.84,103.38) v1(271.93,6.6) v1(271.93,4.57) v1(272.06,215.01) v1(272.14,211.18) v1(272.42,83.44) v1(272.57,5.58) v1(272.67,103.38) v1(273.05,98.17) v1(273.2,6.6) v1(273.2,4.57) v1(273.33,215.01) v1(273.49,103.38) v1(273.65,207.28) v1(273.69,97.79) v1(273.84,5.58) v1(274.06,203.1) v1(274.47,6.6) v1(274.47,4.57) v1(274.6,215.01) v1(275.11,5.58) v1(275.74,6.6) v1(275.74,4.57) v1(275.87,215.01) v1(276.38,5.58) v1(277.01,4.57) v1(277.14,215.01) v1(277.41,212.07) v1(277.65,5.58) v1(277.79,201.38) v1(278.03,207.02) v1(278.16,71.24) v1(278.28,4.57) v1(278.41,215.01) v1(278.92,5.58) v1(279.55,4.57) v1(279.68,215.01) v1(280.19,5.58) v1(280.82,4.57) v1(280.95,215.01) v1(281.38,203.03) v1(281.46,5.58) v1(282.09,4.57) v1(282.22,215.01) v1(282.37,210.53) v1(282.73,5.58) v1(283.09,206.8) v1(283.36,4.57) v1(283.49,215.01) v1(284,5.58) v1(284.63,4.57) v1(284.76,215.01) v1(285.27,5.58) v1(285.9,6.6) v1(285.9,4.57) v1(286.03,215.01) v1(286.31,212.21) v1(286.31,208.99) v1(286.26,9.53) v1(286.48,201.33) v1(286.51,61.25) v1(286.54,5.58) v1(286.64,12.19) v1(287.17,6.6) v1(287.17,4.57) v1(287.3,215.01) v1(287.54,205.5) v1(287.6,114.72) v1(287.81,5.58) v1(288.44,6.6) v1(288.49,114.7) v1(288.57,215.01) v1(288.57,4.95) v1(289,115.49) v1(289.13,116.5) v1(289.2,5.96) v1(289.38,114.72) v1(289.84,215.01) v1(289.76,115.61) v1(289.84,6.85) v1(289.84,4.95) v1(289.87,197.94) v1(290.28,208.03) v1(290.4,114.72) v1(290.45,16) v1(290.47,5.96) v1(291.11,215.01) v1(291.11,6.85) v1(291.11,4.95) v1(291.54,114.72) v1(291.74,5.96) v1(291.92,203.17) v1(292.3,115.74) v1(292.38,215.01) v1(292.38,6.85) v1(292.38,4.95) v1(292.56,114.72) v1(292.99,22.99) v1(293.01,5.96) v1(293.37,33.15) v1(293.65,215.01) v1(293.65,6.85) v1(293.65,4.95) v1(294.13,19.3) v1(294.26,36.2) v1(294.28,5.96) v1(294.39,9.53) v1(294.92,215.01) v1(294.92,6.85) v1(294.92,4.95) v1(294.97,116.88) v1(294.97,115.87) v1(295.55,5.96) v1(296.19,215.01) v1(296.19,4.95) v1(296.33,106.19) v1(296.67,11.05) v1(296.82,5.96) v1(297.46,215.01) v1(297.46,4.95) v1(297.63,102.5) v1(298.15,202.9) v1(298.09,5.96) v1(298.54,165.82) v1(298.54,164.95) v1(298.46,150.14) v1(298.48,149.11) v1(298.46,148.02) v1(298.5,146.31) v1(298.63,173.79) v1(298.58,163.81) v1(298.58,162.54) v1(298.58,161.67) v1(298.55,158.04) v1(298.58,147.05) v1(298.59,114.92) v1(298.73,215.01) v1(298.66,105.65) v1(298.73,6.98) v1(298.73,4.95) v1(298.93,158.71) v1(298.9,126.56) v1(299.04,149.72) v1(299.21,165.46) v1(299.21,164.32) v1(299.18,163.3) v1(299.19,148.54) v1(299.27,174.68) v1(299.31,145.95) v1(299.31,145.06) v1(299.29,144.05) v1(299.42,161.35) v1(299.41,109.86) v1(299.36,5.96) v1(299.46,162.29) v1(299.52,150.53) v1(299.46,147.81) v1(299.46,146.79) v1(299.65,173.79) v1(299.56,157.83) v1(299.6,149.28) v1(299.68,166.18) v1(299.67,164.88) v1(299.72,163.81) v1(299.69,159.48) v1(299.72,9.53) v1(299.94,158.71) v1(300,215.01) v1(299.99,98.8) v1(300,6.98) v1(300,4.95) v1(300.13,148.32) v1(300.16,174.68) v1(300.35,164.32) v1(300.35,163.3) v1(300.41,147.24) v1(300.52,173.79) v1(300.58,157.83) v1(300.63,5.96) v1(301.12,14.99) v1(301.27,215.01) v1(301.27,6.98) v1(301.27,4.95) v1(301.37,11.05) v1(301.67,108.62) v1(301.9,5.96) v1(301.98,113.24) v1(302.54,215.01) v1(302.54,6.98) v1(302.54,4.95) v1(302.84,95.89) v1(302.77,9.53) v1(303.17,5.96) v1(303.81,215.01) v1(303.83,98.87) v1(303.81,6.98) v1(303.81,4.95) v1(303.86,110.54) v1(304.44,200.43) v1(304.44,5.96) v1(304.79,197.22) v1(305.08,215.01) v1(305.08,4.95) v1(305.71,5.96) v1(306.26,95.62) v1(306.35,4.95) v1(306.57,112.69) v1(306.87,110.03) v1(307.05,99.01) v1(306.98,5.96) v1(307.62,4.95) v1(308.25,5.96) v1(308.89,215.01) v1(308.89,201.36) v1(308.89,6.98) v1(308.89,4.95) v1(308.96,197.05) v1(309.52,5.96) v1(309.58,89.22) v1(309.85,106.19) v1(310.06,102.43) v1(310.09,92.95) v1(310.16,215.01) v1(310.16,6.98) v1(310.16,4.95) v1(310.3,109.99) v1(310.43,128.44) v1(310.37,113.69) v1(310.37,96.17) v1(310.79,5.96) v1(311.05,116.94) v1(311.02,32.51) v1(311.12,125.15) v1(311.15,122.28) v1(311.12,119.78) v1(311.15,29.72) v1(311.15,23.11) v1(311.15,20.57) v1(311.43,215.01) v1(311.43,6.98) v1(311.43,4.95) v1(311.56,13.09) v1(311.56,11.82) v1(311.56,10.55) v1(312.06,5.96) v1(312.2,14.19) v1(312.62,4.98) v1(312.67,214.75) v1(312.67,213.48) v1(312.67,212.21) v1(312.67,210.94) v1(312.67,209.67) v1(312.67,208.4) v1(312.67,207.13) v1(312.67,205.86) v1(312.67,204.59) v1(312.67,203.32) v1(312.67,202.05) v1(312.67,200.78) v1(312.67,199.51) v1(312.67,198.24) v1(312.67,196.97) v1(312.67,195.7) v1(312.67,194.43) v1(312.67,193.16) v1(312.67,191.89) v1(312.67,190.62) v1(312.67,189.35) v1(312.67,188.08) v1(312.67,186.81) v1(312.67,185.54) v1(312.67,184.27) v1(312.67,183) v1(312.67,181.73) v1(312.67,180.46) v1(312.67,179.19) v1(312.67,177.92) v1(312.67,176.65) v1(312.67,175.38) v1(312.67,174.11) v1(312.67,172.84) v1(312.67,171.57) v1(312.67,170.3) v1(312.67,169.03) v1(312.67,167.76) v1(312.67,166.49) v1(312.67,165.22) v1(312.67,163.95) v1(312.67,162.68) v1(312.67,161.41) v1(312.67,160.14) v1(312.67,158.87) v1(312.67,157.6) v1(312.67,156.33) v1(312.67,155.06) v1(312.67,153.79) v1(312.67,152.52) v1(312.67,151.25) v1(312.67,149.98) v1(312.67,148.71) v1(312.67,147.44) v1(312.67,146.17) v1(312.67,144.9) v1(312.67,143.63) v1(312.67,142.36) v1(312.67,141.09) v1(312.67,139.82) v1(312.67,138.55) v1(312.67,137.28) v1(312.67,136.01) v1(312.67,134.74) v1(312.67,133.47) v1(312.67,132.2) v1(312.67,130.93) v1(312.67,129.66) v1(312.67,128.39) v1(312.67,127.12) v1(312.67,125.85) v1(312.67,124.58) v1(312.67,123.31) v1(312.67,122.04) v1(312.67,120.77) v1(312.67,119.5) v1(312.67,118.23) v1(312.67,116.96) v1(312.67,115.69) v1(312.67,114.42) v1(312.67,113.15) v1(312.67,111.88) v1(312.67,110.61) v1(312.67,109.34) v1(312.67,108.07) v1(312.67,106.8) v1(312.67,105.53) v1(312.67,104.26) v1(312.67,102.99) v1(312.67,101.72) v1(312.67,100.45) v1(312.67,99.18) v1(312.67,97.91) v1(312.67,96.64) v1(312.67,95.37) v1(312.67,94.1) v1(312.67,92.83) v1(312.67,91.56) v1(312.67,90.29) v1(312.67,89.02) v1(312.67,87.75) v1(312.67,86.48) v1(312.67,85.21) v1(312.67,83.94) v1(312.67,82.67) v1(312.67,81.4) v1(312.67,80.13) v1(312.67,78.86) v1(312.67,77.59) v1(312.67,76.32) v1(312.67,75.05) v1(312.67,73.78) v1(312.67,72.51) v1(312.67,71.24) v1(312.67,69.97) v1(312.67,68.7) v1(312.67,67.43) v1(312.67,66.16) v1(312.67,64.89) v1(312.67,63.62) v1(312.67,62.35) v1(312.67,61.08) v1(312.67,59.81) v1(312.67,58.54) v1(312.67,57.27) v1(312.67,56) v1(312.67,54.73) v1(312.67,50.92) v1(312.67,49.65) v1(312.67,48.38) v1(312.67,47.11) v1(312.67,45.84) v1(312.67,44.57) v1(312.67,43.3) v1(312.67,42.03) v1(312.67,40.76) v1(312.67,39.49) v1(312.67,38.22) v1(312.67,36.95) v1(312.67,35.68) v1(312.67,34.41) v1(312.67,33.14) v1(312.67,31.87) v1(312.67,30.6) v1(312.67,29.33) v1(312.67,28.06) v1(312.67,26.79) v1(312.67,25.52) v1(312.67,24.25) v1(312.67,22.98) v1(312.67,21.71) v1(312.67,20.44) v1(312.67,19.17) v1(312.67,17.9) v1(312.67,16.63) v1(312.67,15.36) v1(312.67,9.22) v1(312.67,7.95) v1(312.67,6.86) v3(168.58,185.65) v3(169.59,169.27) v3(169.67,194.87) v3(169.67,193.73) v3(169.67,192.46) v3(169.67,191.19) v3(169.85,185.65) v3(170.69,194.87) v3(170.69,193.73) v3(170.69,192.46) v3(170.69,191.19) v3(170.86,169.27) v3(171.12,185.65) v3(172.13,169.27) v3(172.39,185.65) v3(173.74,194.87) v3(173.74,193.73) v3(173.74,192.46) v3(173.74,191.19) v3(173.66,185.65) v3(174.14,168.23) v3(174.14,166.96) v3(174.88,194.87) v3(174.88,193.73) v3(174.88,192.46) v3(174.88,191.19) v3(174.93,185.65) v3(176.2,185.65) v3(177.29,168) v3(177.3,166.75) v3(177.47,185.65) v3(178.48,169.27) v3(178.48,168) v3(178.48,166.73) v3(178.61,174.35) v3(178.61,173.08) v3(178.61,171.81) v3(178.61,170.54) v3(178.82,185.42) v3(179.88,183.24) v3(179.88,181.97) v3(179.88,180.7) v3(179.88,179.43) v3(179.88,178.16) v3(179.88,176.89) v3(179.88,175.62) v3(179.88,174.35) v3(179.88,173.08) v3(179.88,171.81) v3(179.88,170.54) v3(179.88,169.27) v3(179.88,168) v3(181.66,183.11) v3(181.66,181.84) v3(181.66,180.57) v3(181.71,179.35) v3(181.71,178.08) v3(181.71,176.81) v3(181.71,175.42) v3(181.71,174.15) v3(181.71,172.88) v4(15.01,177.72) v4(15.01,177.03) v4(15.01,176.35) v4(15.01,175.66) v4(15.01,174.97) v4(15.01,174.29) v4(15.69,177.72) v4(15.69,177.03) v4(15.69,176.35) v4(15.69,175.66) v4(15.69,174.97) v4(15.69,174.29) v4(17.01,179.88) v4(17.4,180.89) v4(17.9,180.26) v4(17.9,179.57) v4(18.31,191.23) v4(18.31,190.54) v4(18.31,186.61) v4(18.31,185.92) v4(18.64,182.8) v4(18.64,182.11) v4(18.59,180.26) v4(18.59,179.57) v4(19,191.23) v4(19,190.54) v4(19,186.61) v4(19,185.92) v4(19.33,182.8) v4(19.33,182.11) v4(23.43,88.3) v4(29.55,33.82) v4(31.45,33.82) v4(41.17,165.4) v4(41.17,164.71) v4(41.17,164.03) v4(41.17,163.34) v4(41.17,162.65) v4(41.17,161.97) v4(41.86,165.4) v4(41.86,164.71) v4(41.86,164.03) v4(41.86,163.34) v4(41.86,162.65) v4(41.86,161.97) v4(43.18,167.56) v4(43.56,168.57) v4(44.07,167.94) v4(44.07,167.25) v4(44.73,177.39) v4(44.73,176.7) v4(44.73,174.67) v4(44.73,173.98) v4(44.8,170.48) v4(44.8,169.79) v4(44.75,167.94) v4(44.75,167.25) v4(45.41,177.39) v4(45.41,176.7) v4(45.41,174.67) v4(45.41,173.98) v4(45.49,170.48) v4(45.49,169.79) v4(46.74,62.59) v4(46.88,156.44) v4(46.88,155.76) v4(47.57,156.44) v4(47.57,155.76) v4(48.25,156.44) v4(48.25,155.76) v4(48.64,62.59) v4(48.94,156.44) v4(48.94,155.76) v4(69.73,108.92) v4(70.53,108.92) v4(71.33,108.92) v4(72.38,114.13) v4(72.38,108.52) v4(72.39,107.72) v4(73.6,40.26) v4(75.5,40.26) v4(78.17,40.26) v4(78.47,176.97) v4(79.23,176.97) v4(80,176.97) v4(80.07,40.26) v4(80.38,177.73) v4(80.35,176.23) v4(108.75,123.35) v4(137.9,93.41) v4(158.3,190.28) v4(158.3,189.59) v4(158.3,188.91) v4(158.3,188.22) v4(158.3,187.53) v4(158.3,186.85) v4(158.99,190.28) v4(158.99,189.59) v4(158.99,188.91) v4(158.99,188.22) v4(158.99,187.53) v4(158.99,186.85) v4(160.17,193.2) v4(160.71,192.69) v4(160.71,191.93) v4(196.85,100.71) v4(280.1,93.39) v4(280.1,85.39) v4(281.1,96.39) v4(281.1,89.39) v4(281.1,87.39) v4(281.1,86.39) v4(281.1,85.39) v4(281.1,84.39) v4(281.1,83.39) v4(282.1,88.39) v4(282.1,87.39) v4(282.1,86.39) v4(282.1,85.39) v4(282.1,84.39) v4(282.1,83.39) v4(283.1,87.39) v4(283.1,84.39) v4(283.1,83.39) v4(285.1,87.39) v4(285.1,86.39) v4(285.1,85.39) v4(285.1,84.39) v4(285.1,83.39) v4(286.1,88.39) v4(286.1,87.39) v4(286.1,86.39) v4(286.1,85.39) v4(286.1,84.39) v4(286.1,83.39) v4(287.1,85.39) v4(287.1,84.39) v4(287.1,83.39) v6(4.51,162.72) v6(4.51,160.91) v6(4.53,159.01) v6(4.48,152.02) v6(4.61,157.38) v6(4.63,155.4) v6(4.63,153.68) v6(5.52,152.02) v6(5.6,162.72) v6(5.6,160.91) v6(5.62,159.01) v6(5.7,157.38) v6(5.72,155.4) v6(5.72,153.68) v6(6.74,162.74) v6(6.74,160.94) v6(6.66,152.05) v6(6.77,159.03) v6(6.84,157.41) v6(6.87,155.43) v6(6.87,153.7) v6(7.53,152.48) v6(16.74,177.48) v6(16.74,176.24) v6(16.74,175.1) v6(17.81,177.48) v6(17.8,176.24) v6(17.8,175.06) v6(18.95,175.09) v6(20.33,155.02) v6(20.58,163.38) v6(20.95,153.03) v6(20.95,151.76) v6(21.16,158.98) v6(21.29,155.02) v6(21.34,154.18) v6(21.73,163.38) v6(22.11,151.69) v6(22.23,159) v6(22.23,153.39) v6(22.31,161.83) v6(22.31,160.56) v6(22.26,154.62) v6(22.41,157.66) v6(22.38,156.44) v6(22.73,152.65) v6(23.25,151.72) v6(23.4,154.64) v6(23.39,153.37) v6(23.45,161.85) v6(23.45,160.58) v6(23.55,156.41) v6(23.56,157.69) v6(33.02,147.92) v6(33.02,146.75) v6(33.02,145.66) v6(33.02,144.23) v6(33.02,143.31) v6(33.02,142.33) v6(33.02,141.27) v6(33.02,140.17) v6(33.25,138.66) v6(33.91,147.95) v6(33.91,146.78) v6(33.94,145.69) v6(33.88,144.23) v6(33.9,143.31) v6(33.94,142.36) v6(33.94,141.29) v6(33.96,140.2) v6(34.19,138.66) v6(35.14,138.66) v6(40.72,188.27) v6(40.69,187.25) v6(40.67,183.44) v6(40.67,182.25) v6(41.99,187.25) v6(41.96,183.44) v6(41.96,182.25) v6(42.77,163.04) v6(42.91,165.16) v6(42.9,164.05) v6(43.41,188.27) v6(43.39,187.25) v6(43.36,183.44) v6(43.36,182.25) v6(43.69,163.07) v6(43.97,165.16) v6(43.96,164.05) v6(44.43,187.33) v6(44.4,183.52) v6(44.4,182.33) v6(44.45,188.35) v6(44.96,163.89) v6(46.52,148.52) v6(46.5,140.59) v6(47.24,138.96) v6(47.25,137.94) v6(47.26,136.89) v6(47.42,144.48) v6(47.66,148.52) v6(48.32,140.01) v6(48.31,138.99) v6(48.44,141.83) v6(48.37,137.94) v6(48.37,136.89) v6(48.5,147.22) v6(48.5,145.95) v6(48.49,144.5) v6(48.47,143.06) v6(49.02,140.97) v6(49.45,137.94) v6(49.45,136.89) v6(49.46,140.04) v6(49.45,139.01) v6(49.64,147.25) v6(49.64,145.98) v6(49.61,144.45) v6(49.62,143.08) v6(49.61,141.81) v6(79.25,182.12) v6(80.12,181.67) v6(81.9,183.45) v6(81.9,182.43) v6(258.44,147.07) v6(259.33,146.18) v6(260.48,145.92) v6(261.62,145.92) v6(265.86,150.12) v6(265.89,147.78) v6(269.16,174.35) v6(269.43,172.19) v6(269.79,175.49) v6(269.79,173.33) v6(270.55,174.35) v6(270.55,172.19) v6(270.94,173.28) v6(271.19,175.49) v6(271.82,157.46) v6(271.95,174.35) v6(271.95,159.62) v6(272.2,155.93) v6(272.46,160.76) v6(272.58,154.92) v6(272.71,158.6) v6(272.97,157.08) v6(273.47,174.35) v6(273.47,159.87) v6(273.68,175.52) v6(273.73,158.22) v6(274.07,156.72) v6(274.07,155.83) v6(274.37,159.55) v6(274.6,160.5) v6(274.87,158.86) v6(274.87,157.59) v6(275,174.35) v6(275.46,175.52) v6(276.01,158.86) v6(276.01,157.59) v6(276.73,175.47) v6(276.78,174.35) v6(277.03,158.86) v6(277.03,157.59) v6(278.17,174.35) v6(278.17,158.86) v6(278.17,157.59) v6(278.51,175.47) v6(279.06,156.57) v6(279.57,174.6) v6(279.82,158.86) v6(279.95,155.3) v6(280.13,175.44) v6(280.97,158.86) v6(281.09,174.6) v6(281.09,155.3) v6(281.91,175.44) v6(281.98,158.86) v6(282.11,155.3) v6(282.62,174.6) v6(283.13,159.87) v6(283.13,158.86) v6(283.25,155.3) v6(283.35,160.66) v6(283.63,175.44) v6(283.75,173.15) v6(283.89,156.19) v6(284.4,174.35) v6(284.52,172.19) v6(285.03,175.49) v6(285.16,173.21) v6(285.79,174.35) v6(285.92,172.19) v6(286.43,175.49) v6(286.55,173.21) v6(287.19,174.35) v6(287.32,172.19) v6(287.65,175.51) v6(287.95,173.21) v6(291.08,183.22) v6(291.08,182.07) v6(291.13,178.42) v6(291.13,177.27) v6(292.48,183.22) v6(292.48,182.07) v6(292.53,178.42) v6(292.53,177.27) v6(293.88,183.22) v6(293.88,182.07) v6(293.93,178.42) v6(293.93,177.27) v6(303.06,194.25) v6(303.06,193.24) v6(304.08,194.25) v6(304.08,193.24) v6(305.22,194.25) v6(305.22,193.24) v6(306.24,194.25) v6(306.24,193.24) v6(307.21,194.31) v6(307.21,193.29) v6(308.23,194.31) v6(308.23,193.29) v7(8.99,175.99) v7(9.75,177.41) v7(9.75,176.7) v7(9.75,175.99) v7(9.75,175.28) v7(9.75,174.57) v7(11.58,177.41) v7(11.58,176.7) v7(11.58,175.99) v7(11.58,175.28) v7(11.58,174.57) v7(12.34,175.99) v7(13.09,175.99) v7(35.15,163.62) v7(35.91,165.04) v7(35.91,164.33) v7(35.91,163.62) v7(35.91,162.91) v7(35.91,162.2) v7(36.83,163.62) v7(37.75,165.04) v7(37.75,164.33) v7(37.75,163.62) v7(37.75,162.91) v7(37.75,162.2) v7(38.5,163.62) v7(39.25,163.62) v7(85.12,81.17) v7(86.19,82.23) v7(96.52,91.6) v7(96.52,90.86) v7(97.26,90.86) v7(97.99,90.86) v7(120.42,194.46) v7(121.37,196.35) v7(121.37,195.4) v7(121.37,194.46) v7(122.31,194.46) v7(139.34,121.58) v7(151.53,188.5) v7(152.29,188.5) v7(153.04,189.21) v7(153.04,188.5) v7(153.04,187.79) v7(153.04,187.08) v7(154.2,131.26) v7(154.88,189.92) v7(154.88,189.21) v7(154.88,188.5) v7(154.88,187.79) v7(154.88,187.08) v7(154.94,131.26) v7(154.94,129.46) v7(155.63,188.5) v7(155.67,132) v7(155.67,131.26) v7(155.67,130.36) v7(155.67,129.46) v7(156.39,188.5) v7(156.58,131.26) v7(156.58,129.46) v7(157.48,131.26) v7(157.48,130.36) v7(157.48,129.46) v7(157.48,128.72) v7(158.21,131.26) v7(158.21,129.46) v7(158.24,116.95) v7(159.38,116.95) v7(165.55,86.71) v7(166.69,87.86) v7(166.69,86.71) v7(182.18,152.14) v7(183.32,152.14) v7(298.39,155.09) v7(298.39,153.22) v7(298.47,170.91) v7(298.47,169.04) v7(299.1,155.09) v7(299.1,153.22) v7(299.18,170.91) v7(299.18,169.04) v7(299.81,156.62) v7(299.81,155.86) v7(299.81,155.09) v7(299.81,154.15) v7(299.81,153.22) v7(299.81,152.45) v7(299.81,151.68) v7(299.89,172.45) v7(299.89,171.68) v7(299.89,170.91) v7(299.89,169.98) v7(299.89,169.04) v7(299.89,168.27) v7(299.89,167.51) v7(300.53,155.09) v7(300.53,153.22) v7(300.6,170.91) v7(300.6,169.04) v7(301.24,155.09) v7(301.24,153.22) v7(301.31,170.91) v7(301.31,169.04) v8(21.39,147.56) v8(21.39,146.56) v8(22.39,147.56) v8(22.39,146.56) v8(23.39,147.56) v8(23.39,146.56) v8(26.38,48.36) v8(26.38,47.36) v8(27.88,48.36) v8(27.88,47.36) v8(32.92,48.36) v8(32.92,47.36) v8(33.67,47.86) v8(34.42,47.36) v8(92.71,75.87) v8(93.21,76.62) v8(93.21,75.12) v8(98.04,206.83) v8(98.04,205.83) v8(98.64,206.33) v8(99.24,205.83) v8(104.78,75.87) v8(105.29,76.62) v8(105.29,75.12) v8(116.86,75.62) v8(117.36,76.37) v8(117.36,74.87) v8(128.94,75.62) v8(129.44,76.37) v8(129.44,74.87) v8(144.38,75.12) v8(144.88,75.87) v8(145.38,76.62) v8(145.38,75.12) v8(156.96,75.87) v8(157.46,76.62) v8(157.46,75.12) v8(169.04,75.87) v8(169.54,76.62) v8(169.54,75.12) v8(181.11,75.87) v8(181.61,76.62) v8(181.61,75.12) v8(208.99,75.87) v8(209.49,76.62) v8(209.49,75.12) v8(221.06,75.87) v8(221.56,76.62) v8(221.56,75.12) v8(233.14,75.87) v8(233.64,76.62) v8(233.64,75.12) v8(245.22,75.87) v8(245.72,76.62) v8(245.72,75.12) v8(257.38,75.92) v8(257.88,76.67) v8(257.88,75.17) v8(262.42,153.52) v8(262.42,152.52) v8(272.25,75.92) v8(272.75,76.67) v8(272.75,75.17) v8(286.7,137.79) v8(286.7,136.79) v8(286.7,135.79) v8(286.7,134.79) v8(287.7,137.79) v8(287.7,136.79) v8(287.7,135.79) v8(287.7,134.79) v8(288.7,137.79) v8(288.7,136.79) v8(288.7,135.79) v8(289.7,137.79) v8(289.7,136.79) v8(305.09,88.16) v8(305.09,87.16) v8(305.84,87.66)
