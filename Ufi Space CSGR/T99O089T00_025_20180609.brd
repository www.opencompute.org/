# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CAUI4_QSFP28_TO_PHY3_DN0: length 53.9
  TOP w0.102: U25.E1 v4(289.1,101.39)
  T18 w0.102: 293.67,101.02 293.65,101.02 293.61,100.98 289.21,100.98 289.1,101.09 v4(289.1,101.39)
  T18 w0.107: 293.67,101.02 295.48,101.02 309.37,87.14 309.37,79.82 309.84,79.34 309.84,63.89 308.09,62.13 307.92,62.04 307.88,61.89 CJ12.U_18
CAUI4_QSFP28_TO_PHY3_DN1: length 46.8
  TOP w0.102: U25.E3 v4(289.1,99.39)
  T18 w0.102: 293.65,99.03 293.63,99.03 293.59,98.99 290.87,98.99 290.7,99.16 290.7,99.66 290.37,99.99 289.77,99.99 289.5,99.72 289.5,99.49 289.4,99.39 v4(289.1,99.39)
  T18 w0.107: 293.65,99.03 294.25,99.03 300.25,93.03 300.25,82.68 308.48,74.45 308.48,66.52 308.09,66.13 307.92,66.04 307.88,65.89 CJ12.U_21
CAUI4_QSFP28_TO_PHY3_DN2: length 54.8
  TOP w0.102: U25.E5 v4(289.1,97.39)
  T16 w0.102: v4(289.1,97.39) 289.4,97.39 289.5,97.49 289.5,98.63 289.5,98.64 289.85,98.98 293.63,98.98 293.67,99.02 293.69,99.02
  T16 w0.107: 293.69,99.02 295.75,99.02 301.84,92.94 301.84,84.96 310.27,76.53 310.27,66.01 308.12,63.86 307.36,63.86 305.52,62.02 305.48,61.89 CJ12.U_15
CAUI4_QSFP28_TO_PHY3_DN3: length 42.1
  TOP w0.102: U25.E7 v4(289.1,95.39)
  T18 w0.102: 293.83,96.02 293.8,96.02 293.76,95.99 289.77,95.99 289.5,95.72 289.5,95.49 289.4,95.39 v4(289.1,95.39)
  T18 w0.107: 293.83,96.02 294.14,96.02 296.98,93.18 296.98,81.15 302.03,76.1 302.03,71.74 306.15,67.63 306.15,66.59 305.69,66.13 305.52,66.04 305.48,65.89 CJ12.U_24
CAUI4_QSFP28_TO_PHY3_DN4: length 57.4
  TOP w0.102: U25.D11 v4(290.1,90.39)
  T16 w0.102: v4(290.1,90.39) 289.8,90.39 289.7,90.29 289.7,90.06 289.43,89.79 288.85,89.79 288.7,89.64 288.7,82.88 288.73,82.84 288.73,82.82
  T16 w0.107: 288.73,82.82 288.73,82.54 287.99,81.8 287.99,59.17 291.33,55.83 307.8,55.83 308.28,55.35 308.28,54.32 308.09,54.13 307.92,54.04 307.88,53.89 CJ12.L_18
CAUI4_QSFP28_TO_PHY3_DN5: length 52
  TOP w0.102: U25.D13 v4(290.1,88.39)
  T16 w0.102: v4(290.1,88.39) 289.8,88.39 289.7,88.29 289.7,88.14 289.85,87.99 293.57,87.99 293.6,88.03 293.69,88.03
  T16 w0.107: 293.69,88.03 293.87,88.03 294.14,87.76 294.14,81.4 291.23,78.49 291.23,64.25 294.85,60.63 307.01,60.63 308.4,59.23 308.4,58.45 308.09,58.13 307.92,58.04 307.88,57.89 CJ12.L_21
CAUI4_QSFP28_TO_PHY3_DN6: length 50.7
  TOP w0.102: U25.D15 v4(290.1,86.39)
  T18 w0.102: 288.73,82.87 288.73,82.9 288.7,82.94 288.7,85.57 288.91,85.79 289.43,85.79 289.7,86.06 289.7,86.29 289.8,86.39 v4(290.1,86.39)
  T18 w0.107: CJ12.L_15 305.48,53.89 305.52,54.04 305.69,54.13 306.2,54.65 306.2,55.42 305.37,56.25 291.85,56.25 289.56,58.55 289.56,76.71 288.25,78.02 288.25,81.3 288.73,81.78 288.73,82.87
CAUI4_QSFP28_TO_PHY3_DN7: length 40.9
  TOP w0.102: U25.E17 v4(289.1,84.39)
  T18 w0.102: v4(289.1,84.39) 289.1,84.09 289.2,83.99 289.43,83.99 290.04,83.37 290.04,82.94 290.08,82.9 290.08,82.87
  T18 w0.107: CJ12.L_24 305.48,57.89 305.52,58.04 305.59,58.07 305.69,58.13 306.18,58.62 306.18,59.19 305.26,60.11 295.57,60.11 293.41,62.28 293.41,76.56 290.08,79.88 290.08,82.87
CAUI4_QSFP28_TO_PHY3_DP0: length 53.8
  TOP w0.104: U25.D1 v4(289.1,100.39)
  T18 w0.102: v4(289.1,100.39) 289.1,100.68 289.2,100.78 293.61,100.78 293.65,100.74 293.67,100.74
  T18 w0.107: CJ12.U_17 307.64,62.32 307.79,62.28 307.92,62.36 308.47,62.91 308.47,63.15 308.58,63.25 308.82,63.25 308.92,63.36 308.92,63.6 309.03,63.71 309.27,63.71 309.56,64 309.56,79.22 309.09,79.7 309.09,87.02 296.88,99.23 296.67,99.23 296.55,99.34 296.55,99.56 296.43,99.68 296.22,99.68 296.1,99.8 296.1,100.01 295.98,100.13 295.76,100.13 295.64,100.25 295.64,100.46 295.36,100.74 293.67,100.74
CAUI4_QSFP28_TO_PHY3_DP1: length 46.7
  TOP w0.102: U25.D3 v4(290.1,99.39)
  T18 w0.102: 293.65,98.75 293.63,98.75 293.59,98.79 290.79,98.79 290.5,99.08 290.5,99.58 290.29,99.79 289.86,99.79 289.7,99.63 289.7,99.49 289.8,99.39 v4(290.1,99.39)
  T18 w0.107: 293.65,98.75 294.13,98.75 294.7,98.18 294.7,98.05 294.7,97.97 294.82,97.85 294.95,97.85 295.03,97.85 295.15,97.73 295.15,97.6 295.15,97.52 295.27,97.4 295.4,97.4 295.48,97.4 299.97,92.92 299.97,82.56 308.2,74.33 308.2,69.52 308.1,69.42 308.06,69.42 307.96,69.33 307.96,69.2 308.06,69.1 308.1,69.1 308.2,69.01 308.2,68.88 308.1,68.78 308.06,68.78 307.96,68.69 307.96,68.56 308.06,68.46 308.1,68.46 308.2,68.37 308.2,68.24 308.1,68.14 308.06,68.14 307.96,68.05 307.96,67.92 308.06,67.82 308.1,67.82 308.2,67.73 308.2,66.64 307.92,66.36 307.79,66.28 307.64,66.32 CJ12.U_22
CAUI4_QSFP28_TO_PHY3_DP2: length 54.7
  TOP w0.102: U25.D5 v4(290.1,97.39)
  T16 w0.102: 293.69,98.74 293.67,98.74 293.63,98.78 289.94,98.78 289.7,98.54 289.7,97.49 289.8,97.39 v4(290.1,97.39)
  T16 w0.107: 293.69,98.74 295.64,98.74 301.56,92.82 301.56,91.54 301.44,91.41 301.44,91.22 301.56,91.09 301.56,90.9 301.44,90.77 301.44,90.58 301.56,90.45 301.56,84.84 308.18,78.22 308.18,78.09 308.15,78.05 308.15,77.92 308.24,77.82 308.37,77.82 308.41,77.86 308.54,77.86 308.63,77.77 308.63,77.63 308.6,77.6 308.6,77.47 308.69,77.37 308.82,77.37 308.86,77.41 308.99,77.41 309.09,77.31 309.09,77.18 309.05,77.15 309.05,77.01 309.14,76.92 309.28,76.92 309.31,76.96 309.45,76.96 309.99,76.42 309.99,66.12 308.01,64.14 307.25,64.14 305.38,62.28 305.24,62.32 CJ12.U_14
CAUI4_QSFP28_TO_PHY3_DP3: length 42.1
  TOP w0.102: U25.D7 v4(290.1,95.39)
  T18 w0.102: v4(290.1,95.39) 289.8,95.39 289.7,95.49 289.7,95.63 289.85,95.78 293.76,95.78 293.8,95.75 293.83,95.75
  T18 w0.107: CJ12.U_25 305.24,66.32 305.38,66.28 305.52,66.36 305.87,66.71 305.87,67.51 301.75,71.63 301.75,75.98 298.18,79.56 297.91,79.56 297.82,79.65 297.82,79.92 297.73,80.01 297.46,80.01 297.37,80.1 297.37,80.37 297.27,80.46 297.01,80.46 296.91,80.56 296.91,80.82 296.7,81.04 296.7,89.46 296.57,89.59 296.57,89.78 296.7,89.91 296.7,90.1 296.57,90.23 296.57,90.42 296.7,90.55 296.7,90.74 296.57,90.87 296.57,91.06 296.7,91.19 296.7,93.07 295.66,94.11 295.49,94.11 295.35,94.25 295.35,94.42 295.2,94.56 295.04,94.56 294.9,94.71 294.9,94.87 294.75,95.01 294.59,95.01 294.44,95.16 294.44,95.32 294.02,95.75 293.83,95.75
CAUI4_QSFP28_TO_PHY3_DP4: length 57.4
  TOP w0.102: U25.E11 v4(289.1,90.39)
  T16 w0.102: v4(289.1,90.39) 289.4,90.39 289.5,90.29 289.5,90.14 289.35,89.99 288.76,89.99 288.49,89.72 288.49,82.88 288.46,82.84 288.46,82.82
  T16 w0.107: CJ12.L_17 307.64,54.32 307.85,54.32 307.92,54.36 308,54.44 308,55.23 307.68,55.55 291.21,55.55 290.89,55.88 290.66,55.88 290.55,55.99 290.55,56.22 290.44,56.33 290.21,56.33 290.1,56.44 290.1,56.67 287.71,59.05 287.71,81.91 288.46,82.66 288.46,82.82
CAUI4_QSFP28_TO_PHY3_DP5: length 51.9
  TOP w0.102: U25.E13 v4(289.1,88.39)
  T16 w0.102: 293.63,87.75 293.6,87.75 293.57,87.78 289.77,87.78 289.5,88.06 289.5,88.29 289.4,88.39 v4(289.1,88.39)
  T16 w0.107: 293.63,87.75 293.76,87.75 293.86,87.64 293.86,81.52 290.95,78.6 290.95,64.14 294.74,60.35 305.32,60.35 305.49,60.18 305.64,60.18 305.81,60.35 306.89,60.35 307.02,60.22 307.02,60.09 307.02,60.08 307.02,59.95 307.11,59.86 307.25,59.86 307.25,59.86 307.38,59.86 308.12,59.12 308.12,58.56 307.92,58.36 307.79,58.28 307.64,58.32 CJ12.L_22
CAUI4_QSFP28_TO_PHY3_DP6: length 50.7
  TOP w0.102: U25.E15 v4(289.1,86.39)
  T18 w0.102: v4(289.1,86.39) 289.4,86.39 289.5,86.29 289.5,86.14 289.35,85.99 288.83,85.99 288.49,85.66 288.49,82.94 288.46,82.9 288.46,82.87
  T18 w0.107: 288.46,82.87 288.46,81.9 287.97,81.41 287.97,81.14 287.79,80.96 287.79,80.82 287.97,80.64 287.97,80.5 287.79,80.32 287.79,80.18 287.97,80 287.97,77.9 289.28,76.6 289.28,58.44 291.74,55.97 305.26,55.97 305.92,55.31 305.92,54.76 305.52,54.36 305.38,54.28 305.24,54.32 CJ12.L_14
CAUI4_QSFP28_TO_PHY3_DP7: length 40.9
  TOP w0.102: U25.E18 v4(289.1,83.39)
  T18 w0.102: 289.8,82.87 289.8,82.9 289.84,82.94 289.84,83.29 289.34,83.79 289.2,83.79 289.1,83.68 v4(289.1,83.39)
  T18 w0.107: CJ12.L_25 305.24,58.32 305.39,58.28 305.45,58.32 305.52,58.36 305.9,58.74 305.9,59.08 305.14,59.83 304.23,59.83 304.11,59.71 303.91,59.71 303.79,59.83 303.59,59.83 303.47,59.71 303.27,59.71 303.15,59.83 295.46,59.83 293.13,62.16 293.13,76.44 289.8,79.77 289.8,80.33 289.66,80.47 289.66,80.65 289.8,80.79 289.8,80.97 289.66,81.11 289.66,81.29 289.8,81.43 289.8,81.61 289.66,81.75 289.66,81.93 289.8,82.07 289.8,82.87
CLK_1M544_BITS_IN: length 55.7
  TOP w0.14: U139.G10 v4(18.43,88.3)
  T07 w0.117: v1(60.49,82.19) 59.45,81.15 52.03,81.15 48.6,77.72 33.66,77.72 28.14,83.24 28.14,86.55 25.78,88.9 20.19,88.9 19.6,88.3 v4(18.43,88.3)
  BOTTOM w0.14: v1(60.49,82.19) 61.44,81.25 R1618.1
CLK_1M544_BITS_OSI: length 1.9
  TOP w0.14: U127.75 63.23,78.15 R12823.2
CLK_1M544_BITS_RCVD: length 5.7
  TOP w0.14: v1(67.44,81.79) 67.05,81.4 U127.70
  BOTTOM w0.14: R13084.2 65.77,82.06 66.04,81.79 v1(67.44,81.79)
CLK_1M544_BITS_RCVD_TSCK: length 8.6
  TOP w0.14: U127.56 69.32,87.6 v1(69.22,87.5)
  BOTTOM w0.14: R13084.1 66.42,84.9 66.42,85.47 68.45,87.5 v1(69.22,87.5)
CLK_1PPS_GNSS_EXTINT0: length 2.5
  TOP w0.14: U124.4 v1(4.19,39.09)
  BOTTOM w0.14: R1604.2 4.35,38.82 4.19,38.98 v1(4.19,39.09)
CLK_1PPS_GNSS_IN: length 61.5
  TOP w0.14: U139.E11 v4(21.44,87.29)
  T05 w0.117: v1(6.86,40.57) 8.05,41.77 8.05,45.04 15.74,52.73 16.26,53.24 16.26,69.83 12.94,73.14 12.94,77.72 12.95,77.73 12.95,85.09 15.62,87.76 20.7,87.76 21.17,87.29 v4(21.44,87.29)
  BOTTOM w0.14: R1603.1 6.6,40.32 v1(6.86,40.57)
CLK_1PPS_MAC_SYNC_IN0: length 19.3
  TOP w0.14: v1(182.79,118.74) 182.65,118.6 R1444.1 R12925.1 ; U1.AA35 v4(197.86,122.5)
  T03 w0.117: v1(182.79,118.74) 183.05,119.01 187.34,119.01 187.61,119.28 187.63,119.28 188.21,119.86 189.29,119.86 189.99,120.56 193.86,120.56 195.31,122.01 197.09,122.01 197.57,122.5 v4(197.86,122.5)
CLK_1PPS_MAC_SYNC_IN1: length 8
  TOP w0.14: v1(192.66,123.42) 192.69,123.45 197.91,123.45 U1.AB35
  BOTTOM w0.14: R1445.1 191.67,123.7 TP23.1 191.95,123.42 v1(192.66,123.42)
CLK_1PPS_SMA1: length 8
  TOP w0.14: J15.1 20.09,63.9 18.31,65.68 D69.4 R1508.2
CLK_1PPS_SMA1_IN: length 7.8
  TOP w0.14: v1(19.81,67.82) 20.57,67.82 21.24,67.15 R1508.1 22.4,65.45 U108.2
CLK_1PPS_SMA2: length 8.1
  TOP w0.14: R1509.1 34.4,66.02 D68.4 32.15,65 33.8,63.35 J12.1
CLK_1PPS_SMA2_OUT: length 63.8
  TOP w0.14: v1(23.7,13.42) 23.75,13.37 23.75,13.34 R1512.1 ; R1509.2 v1(33.45,67.43)
  T03 w0.117: v1(33.45,67.43) 20.16,54.14 20.16,33.02 19.49,32.34 19.49,21.53 20.57,20.45 20.57,19.61 21.86,18.32 21.86,16.38 23.7,14.54 v1(23.7,13.42)
CLK_1PPS_SMA_BUF_IN: length 3.2
  TOP w0.14: R1513.2 23.2,66.1 U108.4 24.82,66.1 v1(25.4,66.67)
CLK_1PPS_SMA_IN: length 27.4
  TOP w0.104: v4(17.92,72.86) 18.24,72.86 18.54,72.56 19.6,71.5 21.34,71.5 23.24,69.6 23.24,67.52 23.14,67.42 R1513.1 ; U139.G12 v4(18.43,86.3)
  BOTTOM w0.104: R12915.2 R12917.1 18.41,86.29 v4(18.43,86.3) 18.43,86.56 18.54,86.67 18.68,86.67 19.18,86.17 19.18,80.5 17.64,78.96 17.64,73.46 17.92,73.17 v4(17.92,72.86)
CLK_1PPS_SMA_IN_DN: length 28.6
  TOP w0.104: R12916.1 R12918.2 C2409.1 23.68,67.36 23.51,67.53 23.51,69.71 21.45,71.77 19.71,71.77 18.65,72.82 18.43,73.05 v4(18.43,73.36)
  TOP w0.14: U139.G11 v4(18.43,87.3)
  BOTTOM w0.104: v4(18.43,73.36) 18.11,73.36 17.91,73.57 17.91,78.85 19.44,80.39 19.44,86.28 18.79,86.94 18.54,86.94 18.43,87.04 v4(18.43,87.3)
CLK_1PPS_SMA_OUT: length 49.5
  TOP w0.14: R1913.1 24.51,17.16 v1(24.51,16.76) ; R1668.1 24.24,54.08 v1(24.09,53.93)
  T05 w0.117: v1(24.09,53.93) 23.48,53.93 14.74,45.2 14.74,33.3 15.93,32.12 15.93,24.1 16.51,23.52 16.51,20.83 18.08,19.26 20.91,19.26 22.16,18.01 23.29,18.01 24.51,16.78 v1(24.51,16.76)
CLK_1PPS_SMA_OUT_AMP: length 4.9
  TOP w0.14: 26.22,13.53 26.4,13.72 26.41,13.72 ; 26.22,13.53 26.23,13.53 26.41,13.72 ; 26.22,13.53 R1514.1 R1512.2 ; 26.41,13.72 v1(26.54,13.85) 26.64,13.95 26.64,14.71 26.93,14.99 U104.7
CLK_1PPS_SMA_OUT_FB: length 5.4
  TOP w0.14: U104.6 24.77,15.64 v1(24.72,15.6) 24.56,15.44 R1515.2 R1514.2
CLK_1PPS_TOD_IN: length 44.2
  TOP w0.104: R1589.2 34.79,52.19 34.99,52.39 34.99,52.72 v4(34.77,52.94)
  TOP w0.14: U139.F12 v4(20.43,86.3)
  T05 w0.107: v4(34.77,52.94) 34.98,53.16 34.98,53.92 20.85,68.05 20.85,79.09 19.41,80.53 19.41,84.57 20.68,85.84 20.68,86.06 v4(20.43,86.3)
  BOTTOM w0.104: v4(20.43,86.3) 20.25,86.12 R12922.1 R12920.2
CLK_1PPS_TOD_IN_DN: length 45.5
  TOP w0.104: v4(35.48,52.94) 35.26,52.72 35.26,52.44 35.47,52.23 C2410.1
  TOP w0.14: U139.F11 v4(20.43,87.3) ; C2410.1 35.74,52.19 R12923.2 R12921.1
  T05 w0.107: v4(35.48,52.94) 35.26,53.16 35.26,54.03 21.13,68.17 21.13,79.2 19.68,80.64 19.68,84.45 20.95,85.72 20.95,86.78 v4(20.43,87.3)
CLK_1PPS_TOD_OUT: length 3
  TOP w0.14: U121.5 32.22,49.32 v1(31.62,49.91) 31.01,50.53 R1667.1
CLK_10M_GNSS_IN: length 61.8
  TOP w0.14: U139.E10 v4(21.43,88.3)
  T05 w0.117: v4(21.43,88.3) 20.83,88.9 13.28,88.9 12.06,87.68 12.06,72.78 15.38,69.47 15.38,53.6 6.85,45.08 v1(6.85,42.86)
  BOTTOM w0.14: R1610.2 6.6,43.11 v1(6.85,42.86)
CLK_10M_SMA1: length 16.1
  TOP w0.14: J14.1 16.17,6.69 10.85,12.01 D67.4 R1500.2
CLK_10M_SMA1_IN: length 3.7
  TOP w0.14: C2424.2 15.11,16.64 13.72,16.64 v1(13.05,15.97) R1500.1
CLK_10M_SMA2: length 10
  TOP w0.14: J11.1 36,11.62 36.57,12.19 D65.4 R1499.1
CLK_10M_SMA2_REL_OUT: length 11.9
  TOP w0.14: R1503.1 v1(26.67,17.35) ; v1(35.95,15.96) R1499.2
  T16 w0.117: v1(35.95,15.96) 28.36,15.96 26.96,17.35 v1(26.67,17.35)
CLK_10M_SMA_BUF: length 2.8
  TOP w0.14: U107.4 9.17,18.89 v1(9.02,19.05)
  BOTTOM w0.14: v1(9.02,19.05) 9.02,18.8 9.53,18.29 R1904.2
CLK_10M_SMA_BUF_IN: length 2.2
  TOP w0.14: R1504.2 23.25,17.41 v1(22.99,17.14) 22.61,17.14 22.34,17.41 U105.4
CLK_10M_SMA_IN: length 80.2
  TOP w0.14: U139.J10 v4(16.43,88.3) ; R1504.1 23.7,18.48 v1(23.32,18.86)
  T16 w0.117: v4(16.43,88.3) 16.43,87.25 13.01,83.82 13.01,77.16 16.01,74.16 16.01,45.48 14.61,44.07 14.61,33.53 17.27,30.86 17.27,24.86 18.18,23.95 18.18,19.91 19.23,18.86 v1(23.32,18.86)
CLK_10M_SMA_OUT: length 102.6
  TOP w0.14: R1901.1 v1(13.96,19.69)
  T16 w0.117: v1(13.96,19.69) 14.35,20.08 14.35,25.47 10.67,29.16 10.67,39.62 11.56,40.51 11.56,45.47 15.13,49.04 15.13,71.73 11.94,74.93 11.94,78.87 9.78,81.03 9.78,88.39 10.16,88.77 10.16,96.01 9.14,97.03 9.14,99.44 11.18,101.47 21.97,101.47 v1(22.48,101.98)
  BOTTOM w0.14: v1(22.48,101.98) 21.95,101.45 R1671.1
CLK_10M_SMA_OUT_AMP: length 6.9
  TOP w0.14: U104.1 30.23,14.34 v1(29.58,15) 29.21,15.37 29.21,18.13 C2398.1 R1505.1
CLK_10M_SMA_OUT_FB: length 23.8
  TOP w0.14: U104.2 30.85,14.99 30.35,15.49 30.35,17.14 30.91,17.71 R1505.2 31.2,18.13 v1(31.6,17.73) ; R1903.1 v1(15.64,20.83)
  T18 w0.117: v1(31.6,17.73) 31.04,18.29 24.13,18.29 23.88,18.03 22.43,18.03 21.54,18.92 17.54,18.92 v1(15.64,20.83)
CLK_25M_5P49V_OUT0: length 7.4
  TOP w0.14: R1076.2 R12789.2 136.63,125.26 138.09,123.8 U163.24
CLK_25M_CPLD_CLK0: length 8.6
  TOP w0.14: U70.G5 v4(113.2,128.05) ; v1(108.08,130.93) 107.28,130.93 R995.1
  T14 w0.117: v4(113.2,128.05) 112.8,128.45 111.32,128.45 110.88,128.89 110.88,129.56 110.39,130.05 108.96,130.05 v1(108.08,130.93)
CLK_25M_CPLD_OSC: length 2.5
  TOP w0.14: R995.2 105.37,131.26 X1.3
CLK_25M_MAC_CLOCK25: length 78.2
  TOP w0.14: R1076.1 132.04,123.35 v1(131.81,123.57) ; U1.AG36 v4(196.86,128.5)
  T14 w0.117: v4(196.86,128.5) 195.86,128.5 195.6,128.23 189.12,128.23 188.39,128.97 188.39,129.87 186.99,131.27 186.99,132.95 185.47,134.47 183.41,134.47 177.52,128.58 177.52,127.73 176.71,126.92 174.19,126.92 174.06,127.05 167.92,127.05 166.09,125.22 162.31,125.22 160.66,123.57 154.94,123.57 154.31,124.21 151.19,124.21 150.38,123.4 146.31,123.4 145.79,123.92 144.62,125.09 140.59,125.09 140.21,125.48 133.72,125.48 v1(131.81,123.57)
CLK_25M_MAC_COREPLL_DN: length 2.2
  TOP w0.104: R12454.2 172.05,85.16 173.2,85.16 C2339.1
CLK_25M_MAC_COREPLL_DP: length 2.2
  TOP w0.104: R12453.2 172.07,84.89 173.2,84.89 C2338.1
CLK_25M_MAC_MCUPLL_DN: length 2.2
  TOP w0.104: C2341.1 173.23,87.42 172.02,87.42 R12455.2
CLK_25M_MAC_MCUPLL_DP: length 2.2
  TOP w0.104: R1888.2 172.02,87.15 173.23,87.15 C2340.1
CLK_25M_MAC_OSC: length 2.3
  TOP w0.14: R1018.2 157.37,86.85 X5.3
CLK_25M_MAC_OSC_DN1: length 5.7
  TOP w0.104: R12794.1 161.85,86.44 162.06,86.65 163.99,86.65 164.11,86.53 U132.4
  TOP w0.14: R12794.1 v1(161.04,86.09) C2400.2
  BOTTOM w0.14: R12792.2 161.42,86.47 v1(161.04,86.09)
CLK_25M_MAC_OSC_DP1: length 7.9
  TOP w0.104: R12793.1 161.85,87.04 161.97,86.92 163.99,86.92 164.11,87.03 U132.3
  TOP w0.14: R1018.1 158.82,87.05 159,86.87 160.49,86.87 v1(161.11,87.49) R12793.1
  BOTTOM w0.14: R12793.1 v1(161.11,87.49)
CLK_25M_MAC_TCXO: length 3.6
  TOP w0.14: R12897.1 161.49,89.34 X8.4
CLK_25M_MAC_TSPLL_DN: length 1.3
  TOP w0.104: C2344.1 166.48,92.14 166.48,91.87 R1889.2
CLK_25M_MAC_TSPLL_DP: length 1.3
  TOP w0.104: R1890.2 166.75,91.86 166.75,92.15 C2345.1
CLK_25M_MAC_TSPLL_DPLL_DN: length 165.8
  TOP w0.104: R12764.1 29.91,95.15 30.54,95.15 v4(30.76,94.93) ; U132.7 166.37,85.27 166.25,85.16 166.25,84.95 166.35,84.85 166.73,84.85 166.99,84.59 166.99,84.21 v4(167.21,83.98) 166.99,83.76 166.99,83.2 167.12,83.07 R1082.2
  T05 w0.107: v4(30.76,94.93) 30.98,95.15 31.35,95.15 31.47,95.02 31.47,92.74 36.76,87.44 51.24,87.44 51.89,88.1 60.96,88.1 62.1,86.96 62.1,83.23 64.9,80.43 64.9,74.77 66.79,72.87 84.63,72.87 91,79.25 159.27,79.25 160.42,80.4 165.98,80.4 167,81.41 167,83.77 v4(167.21,83.98)
  BOTTOM w0.104: v4(167.21,83.98) 166.99,83.76 166.99,83.2 167.12,83.07 R1082.2
CLK_25M_MAC_TSPLL_DPLL_DP: length 165.8
  TOP w0.104: U132.6 165.87,85.27 165.98,85.16 165.98,84.84 166.24,84.58 166.62,84.58 166.72,84.48 166.72,84.21 v4(166.5,83.98) 166.72,83.76 166.72,83.17 166.62,83.07 R1081.2 ; R12763.1 29.91,95.42 30.54,95.42 v4(30.76,95.64)
  T05 w0.107: v4(166.5,83.98) 166.72,83.77 166.72,81.53 165.86,80.68 160.31,80.68 159.16,79.53 90.88,79.53 84.51,73.15 82.75,73.15 82.63,73.27 82.43,73.27 82.31,73.15 82.11,73.15 81.99,73.27 81.79,73.27 81.67,73.15 66.91,73.15 65.18,74.88 65.18,80.55 62.38,83.34 62.38,87.08 61.08,88.38 51.78,88.38 51.12,87.72 36.88,87.72 36.51,88.09 36.51,88.23 36.52,88.24 36.52,88.38 36.43,88.47 36.3,88.47 36.28,88.45 36.15,88.45 31.75,92.85 31.75,95.14 31.46,95.43 30.98,95.43 v4(30.76,95.64)
  BOTTOM w0.104: R1081.2 166.62,83.07 166.72,83.17 166.72,83.76 v4(166.5,83.98)
CLK_25M_PCIE_OSC: length 2.3
  TOP w0.14: R13081.1 130.83,122.02 131.47,121.39 X3.3
CLK_25M_PCIE_XTALIN: length 2.2
  TOP w0.14: C1690.2 U163.4
CLK_25M_SMU_OCXO: length 7
  TOP w0.14: R1887.1 v1(21.56,103.12) 21.21,102.77 21.21,98.08 U139.E1
CLK_25M_SMU_OCXO_OUT0: length 16.4
  TOP w0.14: R1887.2 v1(22.37,105.79) 21.94,106.23 21.94,112.11 23.21,113.38 X11.4
CLK_25M_SMU_OCXO_OUT1: length 12.8
  TOP w0.14: R12893.2 v1(20.75,105.79) 21.04,106.08 21.04,116.83 X14.4
CLK_25M_SMU_XTAL_IN0: length 9.8
  TOP w0.14: C2393.2 Y5.1 25.88,80.93 25.61,81.19 R12805.1 25.61,83.58 24.93,84.26 U139.A12
CLK_25M_SMU_XTAL_OUT0: length 12.5
  TOP w0.14: C2394.2 Y5.3 24.45,78.33 24.64,78.53 24.64,82.78 R12805.2 24.02,83.83 24.02,86.72 U139.B12
CLK_25M_SRC_SEL: length 5.1
  TOP w0.14: U132.2 164.07,87.53 163.83,87.77 163.83,88.65 v5(164.34,89.15)
  BOTTOM w0.14: v5(164.34,89.15) 164.59,89.41 R12935.2 R1646.2
CLK_33M_LPC: length 82
  TOP w0.14: v1(131.95,171.2) 132.94,170.21 R1761.1 134.33,168.87 128.12,162.67 128.12,160.04 128.96,159.2 128.96,156.41 130.92,154.45 J1.B66 ; U144.1 v1(90.86,195.67)
  T07 w0.117: v1(90.86,195.67) 91.35,195.67 94.86,192.16 100.97,192.16 103.07,190.06 103.07,188.67 102.49,188.09 102.49,183.26 104.39,181.36 104.39,178.94 104.92,178.42 104.92,178.39 105.41,177.9 105.44,177.9 106.05,177.29 112.69,177.29 114.96,175.01 120.26,175.01 121.94,173.34 130.83,173.34 131.95,172.21 v1(131.95,171.2)
CLK_33M_LPC_BMC: length 111.8
  TOP w0.14: U154.B20 v4(71.33,105.72) ; R1831.2 89.25,200.76 v1(89.66,201.17)
  T05 w0.117: v1(89.66,201.17) 89.66,200.86 94.23,196.29 94.23,194.18 94.74,193.67 94.74,187.04 96.13,185.65 96.13,181.85 96.58,181.4 96.58,179.64 96.83,179.39 96.83,176.59 91.95,171.7 90.48,171.7 81.92,163.14 81.92,160.66 81.03,159.77 81.03,155.83 80.02,154.82 80.02,152.45 78.79,151.22 78.79,135.78 77.6,134.59 77.6,122.68 76.33,121.41 76.33,120.65 75.06,119.38 75.06,113.28 71.73,109.95 71.73,108.56 70.93,107.76 U154.B20 v4(71.33,105.72)
CLK_33M_LPC_CPLD: length 89.6
  TOP w0.14: U70.H5 v4(113.2,127.25)
  T14 w0.117: v4(113.2,127.25) 113.13,127.25 112.63,126.75 108.13,126.75 106.33,128.55 106.33,128.94 105.7,129.57 104.81,129.57 104.46,129.22 101.69,129.22 101.04,129.87 101.04,135.87 103.58,138.41 103.58,140.87 102.84,141.61 102.84,150.18 100.26,152.75 100.26,155.11 100.83,155.67 100.83,156.92 98.94,158.8 98.94,159.81 98.12,160.64 98.12,171.92 97.1,172.94 97.1,179.07 96.58,179.59 96.58,183.88 94.2,186.25 94.2,190.18 93.13,191.26 88.91,191.26 v1(88.02,190.37)
  BOTTOM w0.14: v1(88.02,190.37) 88.02,191.27 88.63,191.87 R1829.2
CLK_48M_BMC_CLK: length 2.5
  TOP w0.14: R12339.2 56.26,100.32 v1(56.26,98.93) 56.26,98.13 X13.3
CLK_48M_BMC_CLKIN: length 4.2
  TOP w0.14: U154.AB22 54.93,100.84 R12339.1
CLK_50M_BMC_NCSI: length 88.8
  TOP w0.14: U154.E11 v4(68.93,113.73)
  T07 w0.117: v1(106.95,84.58) 106.95,83.84 105.54,82.42 104.14,82.42 103.32,81.6 89.34,81.6 87.63,83.31 84.81,83.31 83.48,84.64 82.57,84.64 78.31,88.9 66.17,88.9 65.66,89.41 v1(63.86,89.41)
  T18 w0.117: v1(63.86,89.41) 60.02,93.25 56.61,93.25 55.12,94.74 55.12,94.85 55.11,94.86 55.11,95.75 55.12,95.75 55.12,100.67 57.59,103.14 57.59,104.11 58.13,104.65 58.13,104.76 58.13,107.74 59.66,109.27 65.83,109.27 66.67,110.12 66.67,111.47 v4(68.93,113.73)
  BOTTOM w0.14: R1819.2 107.22,84.85 v1(106.95,84.58)
CLK_50M_NIC1_NCSI: length 3.5
  TOP w0.14: v1(102.71,86.9) 102,87.61 U85.2
  BOTTOM w0.14: v1(102.71,86.9) 103.16,86.45 R1817.2
CLK_50M_OE: length 5.2
  TOP w0.14: v1(109.55,87.79) 108.89,87.12 107.44,87.12 107.21,86.89 U143.2
  BOTTOM w0.14: R1818.1 110.03,88.27 v1(109.55,87.79)
CLK_50M_OUT0: length 3.2
  TOP w0.14: U143.3 106.56,87.16 v1(106.94,87.54)
  BOTTOM w0.14: R1819.1 107.22,87.26 v1(106.94,87.54)
CLK_50M_OUT1: length 7.4
  TOP w0.14: v1(105.14,83.25) 105.14,82.34 105.91,81.56 U143.5
  BOTTOM w0.14: R1817.1 105.19,86.45 105.92,85.73 v2(105.92,85.65) 105.92,85.05 105.63,84.77 105.63,83.75 v1(105.14,83.25)
CLK_50M_OUT2: length 5.1
  TOP w0.14: v1(108.91,83.49) 108.91,82.81 107.21,81.1 U143.7
  BOTTOM w0.14: v1(108.91,83.49) 109.13,83.7 R1816.1
CLK_50M_OUT3: length 4.8
  TOP w0.14: U143.8 108.68,80.3 109.82,81.44 v1(109.82,82.58)
  BOTTOM w0.14: R1863.1 110.26,82.14 v1(109.82,82.58)
CLK_100M_BMC_PCIE_DN: length 89.1
  TOP w0.104: C2243.1 68.71,99.79 68.59,99.67 68.59,99.07 v4(68.83,98.83) ; R12786.1 141.86,115.99 141.86,115.82 v4(142.08,115.6)
  T14 w0.107: v4(68.83,98.83) 68.67,98.67 68.67,97.97 69.46,97.18 69.57,97.18 82,97.18 85.91,101.08 85.91,101.2 85.91,101.2 85.91,103.18 86.94,104.22 88.49,104.22 90.59,106.31 101.38,106.31 104.78,109.72 104.78,111.82 106.4,113.44 131.13,113.44 134.25,116.56 141.5,116.56 141.86,116.2 141.86,115.81 v4(142.08,115.6)
  BOTTOM w0.104: R12786.1 141.86,115.99 141.86,115.82 v4(142.08,115.6)
CLK_100M_BMC_PCIE_DP: length 89.6
  TOP w0.104: C2242.1 68.13,99.79 68.32,99.59 68.32,98.94 68.22,98.83 v4(68.12,98.83) ; R12785.1 141.59,115.99 141.59,115.82 v4(141.37,115.6)
  T14 w0.107: v4(141.37,115.6) 141.58,115.81 141.58,116.09 141.38,116.28 134.37,116.28 131.24,113.16 106.51,113.16 105.06,111.71 105.06,109.6 101.49,106.03 90.7,106.03 88.61,103.94 87.06,103.94 86.18,103.06 86.18,101.32 86.18,101.31 86.18,100.97 82.12,96.9 71.44,96.9 71.29,96.75 71.12,96.75 70.97,96.9 70.8,96.9 70.65,96.75 70.48,96.75 70.33,96.9 70.16,96.9 70.01,96.75 69.84,96.75 69.69,96.9 69.69,96.9 69.34,96.9 68.39,97.85 68.39,98.44 68.39,98.56 v4(68.12,98.83)
  BOTTOM w0.104: R12785.1 141.6,115.98 141.6,115.83 v4(141.37,115.6)
CLK_100M_BMC_PCIE_REF_DN: length 5.6
  TOP w0.104: U154.G21 67.28,104.97 67.28,103.09 68.56,101.81 68.56,100.98 C2243.2
CLK_100M_BMC_PCIE_REF_DP: length 5
  TOP w0.104: U154.G22 67.01,104.45 67.01,102.99 67.14,102.86 67.14,102.73 67.13,102.72 67.13,102.59 67.22,102.5 67.35,102.5 67.36,102.51 67.49,102.51 67.58,102.41 67.58,102.29 67.57,102.28 67.57,102.15 67.66,102.06 67.79,102.06 67.8,102.06 67.93,102.06 68.3,101.7 68.3,100.98 C2242.2
CLK_100M_CPU_PCIE_DN: length 95
  TOP w0.104: v4(135.64,124.4) 135.86,124.17 135.86,123.22 136.64,122.43 137.28,122.43 U163.2
  T07 w0.107: J1.A14 78.7,160.27 77.67,160.27 75.82,158.43 75.82,153.46 77.42,151.86 84.11,151.86 85.85,150.11 85.85,145.91 87.71,144.05 116.29,144.05 117.99,142.34 131.04,142.34 135.99,137.39 135.99,133.18 135.85,133.05 135.85,124.61 v4(135.64,124.4)
CLK_100M_CPU_PCIE_DP: length 95
  TOP w0.104: v4(136.35,124.4) 136.12,124.17 136.12,123.33 136.75,122.7 137.25,122.7 U163.1
  T07 w0.107: J1.A13 78.43,159.73 78.39,159.87 78.39,159.89 78.28,159.99 77.78,159.99 76.1,158.31 76.1,156.88 76.23,156.76 76.23,156.56 76.1,156.44 76.1,156.24 76.23,156.12 76.23,155.92 76.1,155.8 76.1,155.6 76.23,155.48 76.23,155.28 76.1,155.16 76.1,153.57 77.54,152.13 84.23,152.13 84.59,151.77 84.76,151.77 84.9,151.62 84.9,151.46 85.05,151.31 85.21,151.31 85.36,151.17 85.36,151.01 86.13,150.23 86.13,146.02 87.83,144.33 113.79,144.33 113.97,144.5 114.11,144.5 114.29,144.33 114.43,144.33 114.61,144.5 114.75,144.5 114.93,144.33 115.07,144.33 115.25,144.5 115.39,144.5 115.57,144.33 116.4,144.33 118.11,142.62 131.16,142.62 136.27,137.51 136.27,133.07 136.13,132.93 136.13,124.61 v4(136.35,124.4)
CLK_100M_MAC_DDR_DN: length 59.8
  TOP w0.104: v4(144.93,122) 144.71,122.22 144.54,122.22 R12753.1 ; v4(173.92,152.87) 174.14,153.09 176,153.09 C2384.1
  T16 w0.107: v4(173.92,152.87) 173.71,153.09 168.62,153.09 164.54,149 151.83,149 145.33,142.5 145.33,125.52 146.44,124.42 146.44,122.73 145.93,122.22 145.15,122.22 v4(144.93,122)
  BOTTOM w0.104: v4(144.93,122) 144.7,122.23 144.55,122.23 R12753.1
CLK_100M_MAC_DDR_DP: length 59.8
  TOP w0.104: v4(173.92,153.58) 174.14,153.36 176.01,153.36 C2383.1 ; v4(144.93,122.71) 144.71,122.49 144.54,122.49 R12752.1
  T16 w0.107: v4(173.92,153.58) 173.71,153.36 168.51,153.36 164.42,149.28 151.71,149.28 145.05,142.62 145.05,125.41 146.16,124.3 146.16,122.84 145.81,122.5 145.15,122.5 v4(144.93,122.71)
  BOTTOM w0.104: R12752.1 144.53,122.5 144.72,122.5 v4(144.93,122.71)
CLK_100M_MAC_DDR_OSC_DN: length 15.1
  TOP w0.104: X7.5 186.83,156.45 187.31,156.45 187.58,156.72 187.58,158.14 186.15,159.57 182.67,159.57 182.16,159.06 182.16,158.04 182.01,157.89 R12773.2 R12775.1 181.84,156.93 182.12,156.65 182.12,154.84 182,154.72 U129.4
CLK_100M_MAC_DDR_OSC_DP: length 15
  TOP w0.104: U129.3 182.5,154.72 182.39,154.84 182.39,156.65 182.66,156.93 R12776.1 R12774.2 182.53,157.89 182.42,158 182.42,158.95 182.78,159.3 184.13,159.3 184.22,159.21 184.22,159.1 184.31,159 184.44,159 184.53,159.1 184.53,159.21 184.63,159.3 184.76,159.3 184.85,159.21 184.85,159.1 184.94,159 185.07,159 185.16,159.1 185.16,159.21 185.25,159.3 185.38,159.3 185.47,159.21 185.47,159.1 185.56,159 185.69,159 185.78,159.1 185.78,159.21 185.88,159.3 186.04,159.3 187.31,158.03 187.31,156.83 187.2,156.72 186.83,156.72 X7.4
CLK_100M_MAC_DDRA_DN: length 1.7
  TOP w0.104: C2347.1 183.81,147.05 183.81,147.78 R12448.2
CLK_100M_MAC_DDRA_DP: length 1.8
  TOP w0.104: R12447.2 183.21,148.11 183.55,147.78 183.55,147.07 183.53,147.05 183.53,147.04 183.21,146.72 C2346.1
CLK_100M_MAC_DDRB_DN: length 1.7
  TOP w0.104: C2236.1 186.35,147.06 186.35,147.77 186.43,147.85 R12450.2
CLK_100M_MAC_DDRB_DP: length 1.8
  TOP w0.104: C2235.1 185.74,146.72 186.08,147.06 186.08,147.71 R12449.2
CLK_100M_MAC_DDRC_DN: length 1.8
  TOP w0.104: C2238.1 188.32,152.58 188.09,152.35 187.2,152.35 186.97,152.58 R12451.2
CLK_100M_MAC_DDRC_DP: length 1.9
  TOP w0.104: R12452.2 186.97,151.97 187.08,152.08 188.07,152.08 188.32,151.84 C2237.1
CLK_100M_MAC_PCIE_DN: length 56.3
  TOP w0.104: v4(144.93,120.01) 144.71,120.23 144.51,120.23 R12788.1 ; C2342.1 187.81,118.3 186.49,118.3 185.93,117.73 185.93,117.48 v4(186.16,117.25)
  T16 w0.107: v4(144.93,120.01) 145.15,120.22 147.05,120.22 148.85,118.43 148.85,113.79 151.9,110.74 173.12,110.74 175.36,112.99 182.72,112.99 185.95,116.21 185.95,117.03 v4(186.16,117.25)
  BOTTOM w0.104: v4(144.93,120.01) 144.74,120.2 144.48,120.2 R12788.1
CLK_100M_MAC_PCIE_DP: length 57.3
  TOP w0.104: v4(185.45,117.25) 185.66,117.46 185.66,117.84 186.38,118.56 187.8,118.56 C2343.1 ; R12787.1 144.51,120.5 144.71,120.5 v4(144.93,120.72)
  T16 w0.107: v4(185.45,117.25) 185.67,117.03 185.67,116.32 185.53,116.18 185.39,116.18 185.36,116.22 185.22,116.22 185.13,116.13 185.13,115.99 185.17,115.96 185.17,115.83 185.07,115.73 184.94,115.73 184.9,115.77 184.77,115.77 184.68,115.67 184.68,115.54 184.71,115.5 184.71,115.37 182.61,113.27 175.24,113.27 173,111.02 152.01,111.02 151.02,112.01 151.02,112.28 150.93,112.37 150.67,112.37 150.57,112.47 150.57,112.73 150.48,112.82 150.21,112.82 149.13,113.91 149.13,118.54 148.33,119.34 148.33,119.56 148.21,119.68 147.99,119.68 147.88,119.79 147.88,120.01 147.76,120.13 147.54,120.13 147.17,120.5 145.15,120.5 v4(144.93,120.72)
  BOTTOM w0.104: R12787.1 144.42,120.58 144.8,120.58 v4(144.93,120.72)
CLK_100M_NIC1_PCIE_DN: length 68.3
  TOP w0.104: R12784.1 140.56,126.71 140.4,126.86 140.4,127.41 v4(140.61,127.62) ; C2371.1 96.13,99.07 96.13,100.4 96.67,100.94 96.67,103.98 96.17,104.48 v4(96.17,104.8)
  T18 w0.107: v4(140.61,127.62) 140.39,127.83 140.39,128.78 139.17,130 134.58,130 119.67,115.1 106.91,115.1 104.2,112.39 104.2,109.04 99.42,104.26 96.4,104.26 96.17,104.49 v4(96.17,104.8)
  BOTTOM w0.104: R12784.1 140.56,126.71 140.4,126.86 140.4,127.41 v4(140.61,127.62)
CLK_100M_NIC1_PCIE_DP: length 68
  TOP w0.104: R12783.1 139.95,126.71 140.14,126.9 140.14,127.38 v4(139.9,127.62) ; v4(95.67,104.29) 95.98,104.29 96.4,103.87 96.4,101.05 95.87,100.51 95.87,99.07 C2370.1
  T18 w0.107: v4(95.67,104.29) 95.97,104.29 96.29,103.98 99.53,103.98 104.48,108.93 104.48,112.27 107.02,114.82 119.79,114.82 134.7,129.73 139.05,129.73 139.32,129.45 139.32,129.21 139.43,129.1 139.67,129.1 140.11,128.67 140.11,127.83 v4(139.9,127.62)
  BOTTOM w0.104: R12783.1 139.95,126.71 140.14,126.9 140.14,127.38 v4(139.9,127.62)
CLK_156M25_DPLL_REFCLK_DN: length 6
  TOP w0.104: C2367.2 149.5,125.39 149.64,125.53 149.81,125.53 150.08,125.25 R12482.2 150.91,125.25 151.19,125.54 151.57,125.54 152.29,126.25 152.29,127.78 152.47,127.97 152.91,127.97 U135.11
CLK_156M25_DPLL_REFCLK_DP: length 6
  TOP w0.104: U135.10 152.89,128.23 152.36,128.23 152.02,127.89 152.02,126.36 151.46,125.8 151.18,125.8 150.92,126.07 R12482.1 150.07,126.07 149.8,125.79 149.64,125.79 149.5,125.93 C2366.2
CLK_156M25_MAC_NIF_LCPLL_DN: length 59.8
  TOP w0.104: v4(162.23,121.98) 162.04,122.17 161.81,122.17 C2168.2
  TOP w0.14: U1.M23 v4(209.86,112.5)
  T07 w0.102: 195.49,112.85 195.52,112.85 195.56,112.89 210.11,112.89 210.26,112.74 210.26,112.59 210.17,112.5 v4(209.86,112.5)
  T07 w0.107: 195.49,112.85 194.93,112.85 191.53,109.45 190.02,109.45 188.14,107.57 177.53,107.57 173.58,111.52 173.58,113.42 170.04,116.97 168.39,116.97 163.15,122.2 162.45,122.2 v4(162.23,121.98)
CLK_156M25_MAC_NIF_LCPLL_DP: length 60.2
  TOP w0.104: C2167.2 161.76,122.59 162.13,122.59 v4(162.23,122.7)
  TOP w0.14: U1.M22 v4(210.86,112.5)
  T07 w0.102: v4(210.86,112.5) 210.56,112.5 210.46,112.6 210.46,112.83 210.19,113.09 195.56,113.09 195.52,113.13 195.49,113.13
  T07 w0.107: 195.49,113.13 194.81,113.13 191.41,109.73 189.91,109.73 188.02,107.85 187.65,107.85 187.48,108.01 187.33,108.01 187.16,107.85 177.65,107.85 173.86,111.63 173.86,113.54 170.15,117.25 168.5,117.25 163.27,122.48 162.45,122.48 v4(162.23,122.7)
CLK_156M25_MAC_NIFE_LCPLL0_DN: length 61.7
  TOP w0.104: v4(165.72,128.21) 165.53,128.4 165.3,128.4 C2166.2
  TOP w0.14: U1.U26 v4(206.86,117.5)
  T07 w0.102: v4(206.86,117.5) 207.16,117.5 207.26,117.6 207.26,117.74 207.11,117.89 205.4,117.89 204.46,116.95 204.46,114.24 204.11,113.89 195.47,113.89 195.43,113.85 195.41,113.85
  T07 w0.107: 195.41,113.85 194.12,113.85 191.12,110.85 189.42,110.85 187.87,109.3 186.15,109.3 186.04,109.18 185.83,109.18 185.72,109.3 185.51,109.3 185.4,109.18 185.19,109.18 185.08,109.3 177.72,109.3 174.88,112.14 174.88,113.93 169.68,119.13 169.68,125.1 166.35,128.42 165.93,128.42 v4(165.72,128.21)
CLK_156M25_MAC_NIFE_LCPLL0_DP: length 61.8
  TOP w0.104: v4(165.72,128.92) 165.61,128.82 165.24,128.82 C2165.2
  TOP w0.14: U1.U25 v4(207.86,117.5)
  T07 w0.102: 195.41,114.13 195.43,114.13 195.47,114.09 204.03,114.09 204.25,114.32 204.25,117.03 205.32,118.09 207.19,118.09 207.47,117.82 207.47,117.6 207.57,117.5 v4(207.86,117.5)
  T07 w0.107: v4(165.72,128.92) 165.93,128.7 166.47,128.7 169.96,125.22 169.96,119.25 175.16,114.05 175.16,112.26 177.84,109.58 187.76,109.58 189.31,111.12 191,111.12 194.01,114.13 195.41,114.13
CLK_156M25_MAC_NIFE_LCPLL1_DN: length 74.7
  TOP w0.102: U1.U12 v4(220.86,118.5)
  TOP w0.104: v4(165.72,131.26) 165.53,131.44 165.3,131.44 C2164.2
  T07 w0.102: 221.08,119.02 221.1,119 221.16,119 221.26,118.9 221.26,118.25 221.11,118.1 220.96,118.1 220.86,118.2 v4(220.86,118.5)
  T07 w0.107: 221.08,119.02 219.72,120.38 203.97,120.38 200.96,117.38 197.98,117.38 197.16,116.56 196.85,116.56 196.75,116.47 196.66,116.37 196.53,116.37 196.43,116.47 196.34,116.56 196.21,116.56 196.11,116.47 196.02,116.37 195.89,116.37 195.79,116.47 195.7,116.56 191.51,116.56 187.6,112.64 185.87,112.64 185.74,112.51 185.55,112.51 185.42,112.64 185.23,112.64 185.1,112.51 184.91,112.51 184.78,112.64 179.87,112.64 173.44,119.07 173.44,125.56 167.53,131.47 165.93,131.47 v4(165.72,131.26)
CLK_156M25_MAC_NIFE_LCPLL1_DP: length 74.8
  TOP w0.102: U1.U13 v4(220.86,117.5)
  TOP w0.104: C2163.2 165.24,131.86 165.61,131.86 v4(165.72,131.97)
  T07 w0.102: v4(220.86,117.5) 220.86,117.79 220.96,117.89 221.19,117.89 221.46,118.16 221.46,118.98 221.3,119.14 221.3,119.2 221.28,119.21
  T07 w0.107: v4(165.72,131.97) 165.93,131.75 167.65,131.75 173.72,125.67 173.72,119.19 179.99,112.92 187.48,112.92 191.4,116.84 197.05,116.84 197.86,117.66 200.85,117.66 203.86,120.66 219.83,120.66 221.28,119.21
CLK_156M25_OUT0_NIF_LCPLL_DN: length 3.5
  TOP w0.104: U135.19 157.58,126.2 157.72,126.05 157.72,125.76 158.8,124.68 158.8,124.27 158.7,124.16 R13073.1
CLK_156M25_OUT0_NIF_LCPLL_DP: length 3.4
  TOP w0.104: U135.20 158.08,126.19 157.99,126.1 157.99,125.87 159.07,124.79 159.07,124.27 159.18,124.16 R13072.1
CLK_156M25_OUT1_NIFE_LCPLL0_DN: length 2.5
  TOP w0.104: U135.24 160.79,128.36 160.91,128.48 162,128.48 R13075.1
CLK_156M25_OUT1_NIFE_LCPLL0_DP: length 2.5
  TOP w0.104: U135.25 160.79,128.86 160.91,128.74 162.06,128.74 R13074.1
CLK_156M25_OUT2_NIFE_LCPLL1_DN: length 2.5
  TOP w0.104: U135.30 160.66,131.36 160.79,131.49 162.04,131.49 R13077.1
CLK_156M25_OUT2_NIFE_LCPLL1_DP: length 2.5
  TOP w0.104: U135.31 160.64,131.86 160.74,131.76 161.53,131.76 161.53,131.76 162.03,131.76 R13076.1
CLK_156M25_OUT3_REF0_DN: length 3.4
  TOP w0.104: R12750.2 159.4,136.31 159.4,135.78 158.46,134.84 158.46,134.69 158.58,134.57 U135.35
CLK_156M25_OUT3_REF0_DP: length 3.4
  TOP w0.104: R12751.2 159.13,136.31 159.13,135.89 158.19,134.95 158.19,134.69 158.08,134.57 U135.36
CLK_156M25_PHY1_DN: length 15
  TOP w0.104: C855.2 140.53,92.99 140.25,93.27 140,93.27 v4(139.75,93.02) ; U23.J12 v4(128.21,93.36)
  T18 w0.107: v4(139.75,93.02) 139.52,93.25 138.8,93.25 137.94,94.11 128.15,94.11 127.85,93.82 127.85,93.47 127.96,93.36 v4(128.21,93.36)
CLK_156M25_PHY1_DP: length 15.7
  TOP w0.104: C854.2 140.53,93.67 140.4,93.54 139.99,93.54 v4(139.75,93.78) ; U23.K12 v4(127.21,93.36)
  T18 w0.107: v4(139.75,93.78) 139.49,93.53 138.92,93.53 138.05,94.39 128.03,94.39 127.57,93.93 127.57,93.47 127.47,93.36 v4(127.21,93.36)
CLK_156M25_PHY1_REFCLK_DN: length 32.7
  TOP w0.104: R1071.2 162.83,113.58 162.83,113 v4(163.05,112.78) ; C855.1 141.78,93.33 141.97,93.33 v4(142.19,93.11)
  T14 w0.107: v4(163.05,112.78) 162.83,112.56 162.83,110.89 154.56,102.62 154.18,102.62 144.89,93.33 142.41,93.33 v4(142.19,93.11)
CLK_156M25_PHY1_REFCLK_DP: length 32.4
  TOP w0.104: R1070.2 162.56,113.58 162.56,113 v4(162.34,112.78) ; v4(142.19,93.82) 141.97,93.6 141.48,93.6 141.35,93.73 C854.1
  T14 w0.107: v4(162.34,112.78) 162.55,112.56 162.55,111.01 154.44,102.9 154.06,102.9 144.77,93.61 142.41,93.61 v4(142.19,93.82)
CLK_156M25_PHY3_REFCLK_DN: length 183.4
  TOP w0.104: v4(257.8,83.31) 257.8,82.99 257.99,82.8 259.21,82.8 260.3,83.89 260.3,84.02 260.24,84.09 260.24,84.22 260.33,84.31 260.46,84.31 260.52,84.24 260.65,84.24 260.74,84.34 260.74,84.46 260.68,84.53 260.68,84.66 260.77,84.75 260.9,84.75 260.96,84.69 261.09,84.69 261.43,85.02 267.66,85.02 270.62,82.05 271.26,82.05 271.43,82.23 271.57,82.23 271.74,82.05 271.88,82.05 272.06,82.23 272.19,82.23 272.37,82.05 293.64,82.05 295.68,84.09 298.21,84.09 299.37,85.25 299.37,91.09 298.34,92.12 297.64,92.12 C2204.1 ; v4(163.75,118.38) 163.53,118.16 163.12,118.16 163.02,118.26 R1073.2
  T05 w0.107: v4(257.8,83.31) 257.43,83.31 257.15,83.59 256.13,83.59 252.97,80.43 188.58,80.43 188.45,80.57 188.26,80.57 188.13,80.43 187.94,80.43 187.81,80.57 187.62,80.57 187.49,80.43 176.37,80.43 173.35,83.45 173.35,90.31 166.71,96.95 166.71,97.15 166.58,97.28 166.39,97.28 166.26,97.41 166.26,97.6 166.13,97.73 165.93,97.73 165.48,98.18 165.48,114.7 165.67,114.88 165.67,115.02 165.48,115.2 165.48,115.34 165.67,115.52 165.67,115.66 165.48,115.84 165.48,115.98 165.67,116.16 165.67,116.3 165.48,116.48 165.48,117.15 164.47,118.16 163.97,118.16 v4(163.75,118.38)
CLK_156M25_PHY3_REFCLK_DP: length 182.4
  TOP w0.104: R1072.2 163.02,117.79 163.12,117.89 163.53,117.89 v4(163.75,117.67) ; C2205.1 297.64,92.39 298.45,92.39 299.63,91.2 299.63,85.13 298.32,83.82 295.79,83.82 293.75,81.79 270.51,81.79 267.55,84.75 261.54,84.75 259.32,82.54 257.88,82.54 257.61,82.8 v4(257.3,82.8)
  T05 w0.107: v4(163.75,117.67) 163.97,117.89 164.35,117.89 165.2,117.04 165.2,98.07 173.08,90.19 173.08,83.34 176.26,80.15 253.08,80.15 256.24,83.31 257.03,83.31 257.33,83.01 257.33,82.83 v4(257.3,82.8)
CLK_156M25_PHY_REF0_DN: length 43.3
  TOP w0.104: U133.7 159.06,115.51 158.94,115.4 158.94,113.41 159.04,113.3 R12767.2 159.54,112.88 v4(159.21,112.55) ; R12750.1 159.4,137.88 159.4,138.04 v4(159.62,138.26)
  T16 w0.107: v4(159.21,112.55) 158.97,112.78 158.97,112.99 159.49,113.5 163.26,113.5 167.31,117.55 167.31,133.83 163.85,137.29 159.82,137.29 159.4,137.71 159.4,138.05 v4(159.62,138.26)
  BOTTOM w0.104: R12768.1 159.54,112.88 v4(159.21,112.55)
CLK_156M25_PHY_REF0_DP: length 43.3
  TOP w0.104: v4(158.91,138.26) 159.13,138.04 159.13,137.88 R12751.1 ; v4(158.5,112.55) 158.13,112.91 R12765.2 158.57,113.3 158.67,113.41 158.67,115.4 158.56,115.51 U133.6
  T16 w0.107: v4(158.5,112.55) 158.69,112.75 158.69,113.1 159.38,113.78 163.15,113.78 167.03,117.67 167.03,133.72 163.74,137.01 159.7,137.01 159.12,137.59 159.12,138.05 v4(158.91,138.26)
  BOTTOM w0.104: R12766.1 158.14,112.9 v4(158.5,112.55)
CLK_156M25_PHY_REF1_DN: length 146.3
  TOP w0.104: v4(33.4,92.73) 33.18,92.95 30,92.95 R1867.1 ; U133.4 156.8,116.77 156.68,116.89 156.37,116.89 v4(156.19,116.71) 156.06,116.83 155.54,116.83 155.32,116.61 R12772.1
  T05 w0.107: v4(33.4,92.73) 33.62,92.95 34.24,92.95 36.23,90.96 54.78,90.96 55.25,90.49 66.33,90.49 67.94,88.88 79.45,88.88 84.27,93.7 93.28,93.7 94.68,95.09 100.3,95.09 103.81,98.61 111.2,98.61 113.93,101.34 113.93,104.6 117.51,108.18 145.71,108.18 151.16,113.62 151.16,114.66 153.37,116.87 156.02,116.87 v4(156.19,116.71)
  BOTTOM w0.104: v4(156.19,116.71) 156.06,116.84 155.54,116.84 155.32,116.61 R12772.1
CLK_156M25_PHY_REF1_DP: length 147.6
  TOP w0.104: U133.3 156.8,117.27 156.68,117.16 156.45,117.16 v4(156.19,117.42) 155.87,117.1 155.54,117.1 155.32,117.32 R12770.1 ; R1866.1 30,93.22 33.18,93.22 v4(33.4,93.44)
  T05 w0.107: v4(33.4,93.44) 33.62,93.23 34.36,93.23 35,92.58 35.13,92.58 35.14,92.59 35.27,92.59 35.36,92.5 35.36,92.37 35.36,92.36 35.36,92.22 35.45,92.13 35.58,92.13 35.59,92.14 35.72,92.14 35.82,92.05 35.82,91.91 35.81,91.9 35.81,91.77 36.35,91.24 54.9,91.24 55.37,90.77 66.45,90.77 68.06,89.16 79.33,89.16 84.16,93.98 93.17,93.98 94.56,95.37 100.18,95.37 103.7,98.89 111.08,98.89 111.52,99.32 111.52,99.47 111.67,99.62 111.82,99.62 111.97,99.77 111.97,99.92 112.12,100.08 112.27,100.08 113.65,101.45 113.65,104.71 117.39,108.46 145.6,108.46 150.88,113.74 150.88,114.78 151.85,115.75 151.85,115.92 151.99,116.06 152.16,116.06 152.3,116.2 152.3,116.37 152.45,116.51 152.61,116.51 152.76,116.66 152.76,116.82 152.9,116.97 153.07,116.97 153.25,117.15 155.92,117.15 v4(156.19,117.42)
  BOTTOM w0.104: R12769.2 155.32,117.32 155.54,117.1 155.87,117.1 v4(156.19,117.42)
CLK_156M25_PHY_SRC_SEL: length 4.4
  TOP w0.14: v1(156.52,118.96) 156.52,118.06 156.8,117.77 U133.2
  BOTTOM w0.14: R1650.2 158.86,119 R1649.2 156.57,119 v1(156.52,118.96)
CLK_156M25_PTP_REF_DN: length 144.9
  TOP w0.104: v4(37.59,92.26) 37.21,92.26 35.3,90.35 32.15,90.35 R1673.1 ; C2367.1 148.32,125.53 148,125.53 v4(147.77,125.3)
  T05 w0.107: v4(147.77,125.3) 147.56,125.52 146.99,125.52 146.53,125.06 146.53,124.07 149.08,121.53 149.08,114.65 145.89,111.46 118.94,111.46 111.4,103.93 111.4,102.86 109.53,101 101.63,101 101.04,101.59 97.97,101.59 95.63,99.25 95.63,98.31 93.59,96.27 86.52,96.27 86.33,96.46 84.45,96.46 80.26,92.26 60.49,92.26 59.63,93.11 56.04,93.11 55.36,92.43 42.19,92.43 41.53,93.09 38.1,93.09 37.59,92.58 v4(37.59,92.26)
CLK_156M25_PTP_REF_DP: length 146
  TOP w0.104: v4(37.09,92.76) 37.09,92.51 35.19,90.62 34.41,90.62 34.28,90.75 34.1,90.75 33.97,90.62 33.78,90.62 33.65,90.75 33.47,90.75 33.34,90.62 33.16,90.62 33.03,90.75 32.85,90.75 32.72,90.62 32.15,90.62 R1672.1 ; C2366.1 148.32,125.79 148,125.79 v4(147.77,126.01)
  T05 w0.107: v4(37.09,92.76) 37.38,92.76 37.98,93.37 38.56,93.37 38.65,93.46 38.65,93.47 38.75,93.56 38.88,93.56 38.97,93.47 38.97,93.46 39.07,93.37 39.2,93.37 39.29,93.46 39.29,93.47 39.39,93.56 39.52,93.56 39.61,93.47 39.61,93.46 39.71,93.37 39.84,93.37 39.93,93.46 39.93,93.47 40.03,93.56 40.16,93.56 40.25,93.47 40.25,93.46 40.35,93.37 41.64,93.37 42.31,92.71 55.25,92.71 55.93,93.39 59.75,93.39 60.6,92.54 80.14,92.54 84.34,96.74 86.45,96.74 86.63,96.55 93.48,96.55 95.35,98.42 95.35,99.36 95.61,99.62 95.61,99.87 95.71,99.97 95.96,99.97 96.06,100.08 96.06,100.32 96.17,100.43 96.41,100.43 97.86,101.87 101.15,101.87 101.74,101.27 109.42,101.27 111.12,102.98 111.12,104.04 118.82,111.74 145.78,111.74 148.8,114.76 148.8,121.41 146.25,123.96 146.25,125.18 146.88,125.8 147.56,125.8 v4(147.77,126.01)
CLK_DDR_SRC_SEL: length 3.7
  TOP w0.14: U129.2 183,154.98 v1(183.33,155.31)
  BOTTOM w0.14: R1643.2 R1645.2 182.6,154.58 v1(183.33,155.31)
CLK_LPC_OE: length 2.5
  TOP w0.14: R1830.1 90.78,199.29 v1(90.78,198.56) 90.21,197.99 U144.2
CLK_LPC_OUT0: length 2.4
  TOP w0.14: U144.3 89.56,198.49 v1(89.39,198.66) 89.25,198.8 R1831.1
CLK_LPC_OUT1: length 3.4
  TOP w0.14: U144.5 v1(88.91,193.79)
  BOTTOM w0.14: v1(88.91,193.79) 89.03,193.68 R1829.1
CLK_LPC_OUT2: length 3.9
  TOP w0.14: U144.7 90.21,190.59 90.4,190.41 v1(91.57,190.41)
  BOTTOM w0.14: R1870.1 91.16,189.45 91.57,189.87 v1(91.57,190.41)
CLK_LPC_OUT3: length 4
  TOP w0.14: U144.8 91.97,191.55 92.84,190.68 92.84,190.31 v1(92.85,190.3)
  BOTTOM w0.14: v1(92.85,190.3) 92.87,190.27 R1869.1
CLK_MAC_SRD_REFCLK_OUT0: length 12.7
  TOP w0.104: v4(189.36,133.48) 189.11,133.23 188.87,133.23 R6.1
  TOP w0.14: U1.AM36 v4(196.86,133.5)
  T07 w0.107: v4(189.36,133.48) 189.59,133.25 190.63,133.25 191.45,132.43 191.81,132.43 192.79,131.46 193.03,131.22 195.72,131.22 196.45,131.95 197.1,131.95 197.36,132.21 197.36,133 v4(196.86,133.5)
CLK_MAC_SRD_REFCLK_OUT1: length 10.5
  TOP w0.104: R1.1 188.87,132.96 189.16,132.96 v4(189.36,132.77)
  TOP w0.14: U1.AK36 v4(196.86,131.5)
  T07 w0.107: v4(189.36,132.77) 189.56,132.97 190.51,132.97 191.33,132.15 191.69,132.15 192.67,131.18 192.91,130.94 195.83,130.94 196.39,131.5 v4(196.86,131.5)
CLK_MAC_SRD_REFCLK_OUT2: length 10.3
  TOP w0.102: U1.AN36 v4(196.86,134.5)
  TOP w0.104: v4(189.36,135.97) 189.16,135.77 188.87,135.77 R2.1
  T07 w0.107: v4(196.86,134.5) 196.35,133.99 194.44,133.99 192.67,135.75 189.57,135.75 v4(189.36,135.97)
CLK_MAC_SRD_REFCLK_OUT3: length 10.7
  TOP w0.104: v4(189.36,135.25) 189.11,135.5 188.72,135.5 188.49,135.28 R3.1
  TOP w0.14: U1.AL36 v4(196.86,132.5)
  T07 w0.107: v4(189.36,135.25) 189.57,135.47 192.56,135.47 194.32,133.71 195.65,133.71 v4(196.86,132.5)
CLK_MAC_SYNCE_RCVD1_DN: length 223.9
  TOP w0.104: C2363.1 9.22,78.59 9.22,78.4 v4(9,78.18) ; v4(185.25,132.68) 185.53,132.96 187.31,132.96 R1.2
  T14 w0.107: v4(9,78.18) 9.21,77.96 9.21,77.02 9.56,76.67 10.18,76.06 10.79,75.44 10.79,75.31 10.79,75.21 10.91,75.1 11.04,75.1 11.13,75.1 11.25,74.99 11.25,74.85 11.25,74.76 11.36,74.65 11.49,74.65 11.59,74.65 11.7,74.53 11.7,74.4 11.7,74.31 11.81,74.19 11.95,74.19 12.04,74.19 16.29,69.94 16.79,69.94 16.94,69.78 17.11,69.78 17.26,69.94 17.43,69.94 17.58,69.78 17.75,69.78 17.9,69.94 18.07,69.94 18.23,69.78 18.39,69.78 18.55,69.94 35.24,69.94 35.4,69.78 35.56,69.78 35.72,69.94 35.88,69.94 36.04,69.78 36.2,69.78 36.36,69.94 36.52,69.94 36.68,69.78 36.84,69.78 37,69.94 51.02,69.94 53.72,72.64 65.19,72.64 66.78,71.05 87.64,71.05 91.34,74.76 91.34,76.97 94.28,79.91 131.14,79.91 134.6,83.38 138.88,83.38 144.78,89.27 144.78,91.31 150.88,97.41 159.04,97.41 180.15,118.51 180.15,125.96 181.2,127.02 181.2,129.95 184.18,132.92 185.01,132.92 v4(185.25,132.68)
  BOTTOM w0.104: v4(185.25,132.68) 185.5,132.93 187.34,132.93 R1.2
CLK_MAC_SYNCE_RCVD1_DP: length 222.2
  TOP w0.104: R6.2 187.31,133.23 185.47,133.23 v4(185.25,133.44) ; v4(9.71,78.18) 9.49,78.4 9.49,78.59 C2362.1
  T14 w0.107: v4(185.25,133.44) 185.01,133.2 184.06,133.2 180.92,130.06 180.92,127.14 179.87,126.08 179.87,118.63 158.93,97.69 150.76,97.69 144.5,91.43 144.5,89.39 138.77,83.66 134.48,83.66 131.02,80.19 94.17,80.19 91.06,77.09 91.06,74.87 87.52,71.33 66.89,71.33 65.3,72.92 53.61,72.92 50.9,70.22 16.41,70.22 11.07,75.55 10.37,76.25 9.68,76.95 9.49,77.14 9.49,77.96 v4(9.71,78.18)
  BOTTOM w0.104: R6.2 187.27,133.2 185.5,133.2 v4(185.25,133.44)
CLK_MAC_SYNCE_RCVD2_DN: length 43.3
  TOP w0.104: R3.2 187.31,135.5 186.43,135.5 v4(186.18,135.25) ; C2365.1 154.1,138.35 154.1,138.55 v4(153.88,138.77)
  T16 w0.107: v4(186.18,135.25) 186.42,135.5 186.78,135.5 187.1,135.82 187.1,137.99 185.77,139.32 178.68,139.32 177.4,140.6 155.19,140.6 154.09,139.5 154.09,138.99 v4(153.88,138.77)
  BOTTOM w0.104: R3.2 187.31,135.5 186.43,135.5 v4(186.18,135.25)
CLK_MAC_SYNCE_RCVD2_DP: length 43.6
  TOP w0.104: C2364.1 154.37,138.35 154.37,138.55 v4(154.59,138.77) ; R2.2 187.31,135.77 186.43,135.77 v4(186.18,136.02)
  T16 w0.107: v4(154.59,138.77) 154.37,138.99 154.37,139.39 155.31,140.32 156.29,140.32 156.48,140.13 156.61,140.13 156.8,140.32 156.93,140.32 157.12,140.13 157.25,140.13 157.44,140.32 157.57,140.32 157.76,140.13 157.89,140.13 158.08,140.32 162.1,140.32 162.27,140.14 162.42,140.14 162.59,140.32 162.74,140.32 162.91,140.14 163.06,140.14 163.23,140.32 163.38,140.32 163.55,140.14 163.7,140.14 163.87,140.32 175.65,140.32 175.83,140.14 175.97,140.14 176.15,140.32 176.29,140.32 176.47,140.14 176.61,140.14 176.79,140.32 177.29,140.32 178.56,139.04 182.6,139.04 182.69,138.95 182.69,138.95 182.78,138.85 182.92,138.85 183.01,138.95 183.01,138.95 183.1,139.04 183.24,139.04 183.33,138.95 183.33,138.95 183.42,138.85 183.56,138.85 183.65,138.95 183.65,138.95 183.74,139.04 183.88,139.04 183.97,138.95 183.97,138.95 184.06,138.85 184.2,138.85 184.29,138.95 184.29,138.95 184.38,139.04 185.66,139.04 186.82,137.88 186.82,135.94 186.66,135.78 186.42,135.78 v4(186.18,136.02)
  BOTTOM w0.104: R2.2 187.31,135.77 186.43,135.77 v4(186.18,136.02)
CLK_MAC_SYNCE_REFCLK1_DN: length 11.6
  TOP w0.104: C2363.2 9.2,80.14 9.2,80.34 8.91,80.64 R12473.2 8.91,81.09 9.12,81.31 9.12,81.59 R12801.2 9.18,82.23 9.18,82.55 R12808.1 8.83,83.12 9.18,83.47 9.18,84.23 12.38,87.44 13.56,87.44 U139.M11
CLK_MAC_SYNCE_REFCLK1_DP: length 11.2
  TOP w0.104: C2362.2 9.47,80.17 9.47,80.39 9.72,80.64 R12473.1 9.72,81.09 9.44,81.37 9.44,81.57 R12802.2 9.45,82.19 9.45,82.55 R12809.1 9.79,83.17 9.45,83.52 9.45,84.12 12.49,87.17 13.56,87.17 U139.M12
CLK_MAC_SYNCE_REFCLK2_DN: length 3.7
  TOP w0.104: C2365.2 153.87,137.14 154.08,136.93 154.08,136.61 153.87,136.4 R12474.2 153.87,135.59 154.19,135.27 154.19,134.69 154.07,134.57 U135.44
CLK_MAC_SYNCE_REFCLK2_DP: length 3.8
  TOP w0.104: U135.43 154.58,134.57 154.46,134.69 154.46,135.37 154.68,135.59 R12474.1 154.68,136.4 154.39,136.69 154.39,136.99 154.54,137.14 C2364.2
CLK_MAC_TS_BIT_CLK0: length 34.4
  TOP w0.14: v1(178.17,122.6) R1451.2 ; U1.AD30 v4(202.86,125.5)
  T05 w0.117: v4(202.86,125.5) 202.26,124.9 199.69,124.9 198.32,123.52 194.26,123.52 192.76,122.02 188.95,122.02 187.2,120.27 180.72,120.27 178.39,122.6 v1(178.17,122.6)
  BOTTOM w0.14: v1(178.17,122.6) 178.45,122.6 179.71,121.34 R71.1
CLK_MAC_TS_BIT_CLK1: length 22.8
  TOP w0.14: v5(185.67,121.37) 185.65,121.34 R1448.2 R12941.1 ; U1.AD29 v4(203.86,125.5)
  T05 w0.117: v4(203.86,125.5) 203.46,125.9 198.66,125.9 197.26,124.5 193.14,124.5 192.84,124.19 189.43,124.19 187.45,122.21 186.52,122.21 v5(185.67,121.37)
CLK_MAC_TS_SYNC1: length 33.6
  TOP w0.14: U1.AC30 v4(202.86,124.5) ; R12927.1 R12819.2 175.44,118.93 v1(175.48,118.98)
  T05 w0.117: v1(175.48,118.98) 175.9,119.39 182.14,119.39 182.31,119.56 189.87,119.56 191.82,121.51 195.1,121.51 195.54,121.95 200.94,121.95 201.46,122.46 201.46,122.66 201.89,123.09 202.03,123.09 202.38,123.44 202.38,124.01 v4(202.86,124.5)
CLK_NIC1_OSC_OE: length 2.6
  TOP w0.14: X4.1 115.18,83.46 v1(115.5,83.14)
  BOTTOM w0.14: R1271.1 115.12,82.76 v1(115.5,83.14)
CLK_NIC1_XTAL1: length 2.8
  TOP w0.14: U85.46 89.6,88.11 R1210.2
CLK_NIC1_XTAL1_IN: length 2.9
  TOP w0.14: Y2.1 86.87,87.82 86.87,87.82 C1622.2 R1210.1
CLK_NIC1_XTAL2: length 2.9
  TOP w0.14: U85.45 90.59,88.61 90.11,89.09 R1211.2
CLK_NIC1_XTAL2_OUT: length 5.8
  TOP w0.14: R1211.1 C1623.2 83.92,89.09 83.76,89.24 Y2.3
CLK_OUT_BITS_OSCI: length 3.3
  TOP w0.14: v5(66.55,87.5) 66.3,87.25 U127.61
  BOTTOM w0.14: R1617.2 66.45,87.41 v5(66.55,87.5)
CLK_PHY1_SYNCE_RCVD2_DN: length 62.2
  TOP w0.104: v4(142.95,133.92) 143.2,134.17 145.47,134.17 146.23,134.93 146.87,134.93 C2159.1 ; R275.1 117.92,99.5 118.14,99.28 118.41,99.28 v4(118.62,99.49) 118.82,99.29 122.28,99.29 U23.R7
  T16 w0.107: v4(118.62,99.49) 118.41,99.29 117.88,99.29 117.6,99.57 117.6,105.87 127.32,115.59 133.11,115.59 134.6,117.08 134.6,129.56 139.17,134.13 142.74,134.13 v4(142.95,133.92)
