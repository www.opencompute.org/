# Allegro board T99O089T00_025_20180609.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
(no net) on TOP: 64.43,200.45 66.93,200.45 69.16,202.68 69.16,211.97 68.76,212.37 66.42,212.37 66.32,212.27 66.32,204.8 66.09,204.57 64.92,204.57 64.74,204.75 64.74,206.55 64.69,206.6 64.39,206.6 64.3,206.52 64.3,200.57
(no net) on TOP: 189.67,195.77 189.13,196.32 189.13,197.81 188.73,198.21 187.08,198.21 187.06,198.23 187.06,205.09 187.2,205.23 188.34,205.23 188.59,204.98 188.59,204.08 189.28,203.39 190.35,203.39 190.55,203.59 190.93,203.59 191.07,203.73 192.2,203.73 192.33,203.6 192.33,202.79 192.12,202.57 192.11,202.57 191.73,202.2 191.46,202.2 191.41,202.15 191.41,195.99 191.19,195.77
(no net) on TOP: 96.84,63.32 96.84,66.06 98.02,67.24 98.02,71.15 98.12,71.25 99.66,71.25 99.84,71.07 99.84,63.85 99.28,63.29 96.88,63.29
(no net) on TOP: 65.89,142.97 65.89,150.29 65.72,150.47 63.94,150.47 63.89,150.42 63.89,143.05 64,142.94 65.86,142.94
(no net) on TOP: 145.45,185.71 145.71,185.45 146.94,185.45 147.04,185.55 147.04,194.76 147.16,194.88 148.1,194.88 148.42,194.56 148.42,193.72 148.69,193.45 151.17,193.45 151.29,193.58 151.29,196.11 150.91,196.49 145.92,196.49 145.45,196.03
(no net) on TOP: 115.17,146.9 114.97,147.1 114.97,150.99 115.21,151.23 118.26,151.23 118.52,150.97 118.52,146.99 118.44,146.9
(no net) on TOP: 21.84,198.12 21.84,199.64 22.23,200.03 34.1,200.03 39.21,205.14 48.74,205.14 52.56,208.97 57.43,208.97 58.52,210.06 64.77,210.06 65.02,210.31 65.02,212.34 66.04,212.34 66.04,205.08 65.96,205 65.1,205 65.04,205.07 65.04,206.74 64.64,207.14 59.77,207.14 58.99,206.36 54.19,206.36 50.92,203.09 41.19,203.09 35.2,197.1 22.86,197.1
(no net) on TOP: 91.86,64.67 91.86,63.13 91.96,63.03 95.72,63.03 95.9,63.03 96.02,63.15 96.02,64.59 96.49,65.05 96.49,65.55 96.41,65.62 91.58,65.62 91.52,65.56 91.52,65.01
(no net) on TOP: 287.32,121.56 287.15,121.39 286.13,121.39 285.82,121.7 285.82,123.42 285.96,123.57 286.31,123.57 286.5,123.38 286.5,123.13 286.82,122.81 287.3,122.81 287.32,122.79
(no net) on TOP: 169.33,98.11 169.33,99.24 169.22,99.36 166.44,99.36 166.29,99.2 166.29,97.94 166.32,97.91 169.13,97.91
(no net) on TOP: 68.52,148.78 66.68,148.78 66.65,148.8 66.65,150.3 66.92,150.57 68.5,150.57 68.74,150.33 68.74,148.99
(no net) on TOP: 246.98,194.86 247.33,194.52 249.98,194.52 250.12,194.66 250.12,200.11 248.21,202.02 248.21,202.21 248.16,202.26 247.13,202.26 246.98,202.11
(no net) on TOP: 194.06,163.44 189.95,163.44 189.77,163.63 189.77,167.57 190.04,167.83 193.97,167.83 194.23,167.57 194.23,163.61
(no net) on TOP: 296.92,169.76 297.21,170.04 297.78,170.04 297.89,169.93 297.89,165.02 297.88,165.02 295.72,162.87 292.68,162.87 292.29,163.25 292.29,169.34 292.71,169.76
(no net) on TOP: 156.12,64.67 156.12,63.13 156.21,63.03 159.97,63.03 160.15,63.03 160.27,63.15 160.27,64.59 160.74,65.05 160.74,65.55 160.67,65.62 155.83,65.62 155.77,65.56 155.77,65.01
(no net) on TOP: 9.64,185.65 9.53,185.54 3.76,185.54 3.3,186 3.3,207.57 3.65,207.91 9.26,207.91 9.64,207.53
(no net) on TOP: 304.71,76.59 304.8,76.5 308.51,76.5 308.62,76.62 308.62,82.59 308.62,82.59 308.62,83.12 308.53,83.21 308,83.21 307.72,83.49 307.72,84.63 307.59,84.76 306.2,84.76 305.94,84.51 305.94,82.61 304.71,81.38
(no net) on TOP: 102.2,137.98 100.28,137.98 100.21,138.04 100.21,139.36 100.74,139.89 102.11,139.89 102.27,139.72 102.27,138.04
(no net) on TOP: 75.69,202.54 75.69,192.91 75.95,192.66 78.99,192.66 80.73,194.4 80.73,204.72 80.66,204.8 80.12,204.8 77.9,202.58 75.73,202.58
(no net) on TOP: 263.04,150.53 262.97,150.45 262.97,150.3 262.81,150.15 262.81,145.14 262.94,145 264.13,145 264.29,145.16 264.29,149.83 263.59,150.53
(no net) on TOP: 217.03,63.64 217.03,71.27 217.18,71.42 218.71,71.42 218.83,71.3 218.83,67.19 219.54,66.48 219.54,63.55 219.35,63.36 217.31,63.36
(no net) on TOP: 81.92,142.97 81.92,150.29 81.74,150.47 79.96,150.47 79.91,150.42 79.91,143.07 80.04,142.95 81.89,142.95
(no net) on TOP: 103.94,64.67 103.94,63.13 104.04,63.03 107.8,63.03 107.8,63.03 107.98,63.03 108.1,63.15 108.1,64.59 108.56,65.05 108.56,65.55 108.49,65.62 103.66,65.62 103.6,65.56 103.6,65.01
(no net) on TOP: 262.07,148.21 258.75,148.21 258.62,148.34 258.62,150.17 258.98,150.53 259.79,150.53 260.24,150.98 261.73,150.98 261.85,150.86 262.38,150.86 262.38,150.86 262.61,150.86 262.7,150.77 262.7,150.42 262.47,150.19 262.47,148.61
(no net) on TOP: 149.02,63.58 149.02,66.32 150.19,67.49 150.19,71.4 150.3,71.5 151.84,71.5 152.01,71.33 152.01,64.11 151.45,63.54 149.05,63.54
(no net) on TOP: 147.47,101.6 143.16,101.6 142.9,101.34 142.9,94.32 143.38,93.84 147.64,93.84 147.66,93.87 147.66,101.41
(no net) on TOP: 140.42,132.32 140.42,131.17 140.55,131.05 143.64,131.05 143.78,131.19 143.78,132.36 143.61,132.53 140.64,132.53
(no net) on TOP: 243.38,206.57 243.38,211.18 243.26,211.31 238.49,211.31 237.67,210.49 237.67,197.21 237.98,196.91 241,196.91 241.13,197.05 241.13,205.63 241.37,205.86 242.67,205.86
(no net) on TOP: 51.53,159.16 46.9,159.16 46.5,158.76 46.5,155.06 47.02,154.54 51.45,154.54 51.67,154.76 51.67,159.02
(no net) on TOP: 284.46,114.65 279.85,114.65 279.72,114.52 279.72,111.33 280.86,110.19 293.64,110.19 293.84,110.39 293.84,112.26 293.7,112.39 285.4,112.39 285.17,112.63 285.17,113.93
(no net) on TOP: 163.9,75.62 163.9,76.15 164.13,76.38 166.27,76.38 166.35,76.46 167.86,76.46 167.91,76.42 167.91,75.83 167.85,75.78 166.43,75.78 166.43,75.78 166.27,75.78 165.96,75.47 164.05,75.47
(no net) on TOP: 184.55,113.03 184.33,113.26 177.64,113.26 177.37,112.99 177.37,102.47 181.33,98.52 181.33,98.51 183.19,96.64 184.12,96.64 184.55,97.08
(no net) on TOP: 188.54,206.57 188.54,211.18 188.42,211.31 183.86,211.31 183.43,210.88 183.43,196.14 183.81,195.77 186.08,195.77 186.29,195.98 186.29,205.63 186.52,205.86 187.83,205.86
(no net) on TOP: 26.48,144.58 25.77,143.88 23.61,143.88 23.39,144.1 23.39,145.78 23.55,145.93 23.94,145.93 24.01,146 24.01,149.21 23.86,149.37 23.49,149.37 23.49,150.43 21.48,150.43 21.48,149.47 21.49,149.46 21.34,149.3 20.91,149.3 20.78,149.18 20.78,148.48 20.72,148.41 19.53,148.41 19.53,148.01 19.61,147.93 20.73,147.93 20.81,147.86 20.81,145.95 20.87,145.88 21.44,145.88 21.5,145.82 21.5,144.51 21.26,144.28 19.14,144.28 18.78,144.64 14.12,144.64 14.03,144.55 14.03,142.26 14.28,142.02 31.91,142.02 32.09,142.2 32.09,144.38 31.89,144.58
(no net) on TOP: 124.9,70.76 125.05,70.91 126.59,70.91 126.7,70.79 126.7,66.68 127.41,65.97 127.41,63.14 127.26,62.99 125.15,62.99 124.9,63.24
(no net) on TOP: 279.91,120.71 283.58,120.71 285.42,118.87 285.6,118.87 285.69,118.79 285.69,118.22 284.91,117.44 280.1,117.44 279.78,117.75 279.78,120.58
(no net) on TOP: 195.45,203.71 195.29,203.88 195.29,204.9 195.6,205.21 197.32,205.21 197.46,205.07 197.46,204.72 197.28,204.53 197.03,204.53 196.7,204.21 196.7,203.73 196.69,203.71
(no net) on TOP: 91.91,127.21 91.91,123.19 92.32,122.78 94.92,122.78 95.2,123.05 95.2,127.22 94.88,127.53 92.24,127.53
(no net) on TOP: 147.54,106.19 146.74,106.19 145.99,105.44 144.45,105.44 144.3,105.59 144.3,107.85 144.54,108.09 147.43,108.09 147.66,107.86 147.66,106.32
(no net) on TOP: 228.05,173.72 247.83,173.72 248.18,173.37 248.18,171.15 247.78,170.75 228.15,170.75 227.98,170.92 227.98,173.66
(no net) on TOP: 218.21,75.53 218.21,74.29 217.96,74.04 217.37,74.04 217.18,74.22 217.18,76.25 217.31,76.38 218.29,76.38 218.37,76.46 219.89,76.46 219.93,76.42 219.93,75.83 219.88,75.78 218.46,75.78
(no net) on TOP: 68.41,137.99 66.12,137.99 65.74,137.62 65.74,134.32 65.87,134.19 68.44,134.19 68.66,134.41 68.66,137.74
(no net) on TOP: 241.18,71.01 241.33,71.16 242.87,71.16 242.98,71.05 242.98,66.93 243.69,66.22 243.69,63.4 243.54,63.25 241.43,63.25 241.18,63.5
(no net) on TOP: 44.33,36.51 44.33,34.64 44.71,34.25 46.88,34.25 47.14,34.51 47.14,36.5 47.08,36.55 44.36,36.55
(no net) on TOP: 121,63.02 121,65.81 122.17,66.99 122.17,70.89 122.28,71 123.82,71 123.99,70.82 123.99,63.22 123.71,62.93 121.09,62.93
(no net) on TOP: 168.19,64.67 168.19,63.13 168.29,63.03 172.05,63.03 172.05,63.03 172.23,63.03 172.35,63.15 172.35,64.59 172.82,65.05 172.82,65.55 172.74,65.62 167.91,65.62 167.85,65.56 167.85,65.01
(no net) on TOP: 69.89,182.98 69.89,181.04 70.08,180.85 73.87,180.85 74.3,181.27 74.3,182.5 75.49,183.69 75.49,184.71 75.35,184.85 74.45,184.85 72.83,183.23 70.14,183.23
(no net) on TOP: 30,160.36 30.1,160.45 30.1,166.76 29.75,167.1 29.75,169.72 29.88,169.85 35.2,169.85 35.38,170.03 36.14,170.03 36.14,171.3 35.87,171.57 28.78,171.57 28.36,171.15 28.36,160.6 28.6,160.36
(no net) on TOP: 181,140.76 181,138.22 180.89,138.11 179.05,138.11 178.88,138.28 178.88,140.71 179.08,140.91 180.85,140.91
(no net) on TOP: 101.08,211.31 101.1,211.33 104.68,211.33 105.37,212.02 107.37,212.02 107.41,211.98 107.41,209.66 107.21,209.47 107.21,209.47 107.1,209.37 101.6,209.37 101.36,209.13 101.36,207.89 100.94,207.47 99.48,207.47 99.41,207.54 99.41,211.13 99.59,211.31
(no net) on TOP: 108.92,63.32 108.92,66.06 110.1,67.24 110.1,71.15 110.2,71.25 111.74,71.25 111.92,71.07 111.92,63.85 111.35,63.29 108.96,63.29
(no net) on TOP: 100.26,123.77 100.26,120.12 100.59,119.79 102.38,119.79 102.84,120.25 102.84,121.64 103.45,122.25 103.45,123.83 103.25,124.03 100.51,124.03
(no net) on TOP: 250.93,194.6 251.05,194.49 253.4,194.49 253.66,194.74 253.66,196.31 253.41,196.56 251.17,196.56 250.93,196.32
(no net) on TOP: 60.7,48.25 55.53,48.25 55.53,48.24 55.33,48.24 55.21,48.12 55.21,45.83 55.32,45.71 60.67,45.71 60.8,45.84 60.8,48.15
(no net) on TOP: 288.88,117.51 295.04,117.51 295.26,117.29 295.26,113.52 294.9,113.16 286.04,113.16 285.96,113.24 285.96,114.71 286.18,114.94 287.19,114.94 287.64,115.39 287.64,116.45 287.44,116.65 287.44,117.03 287.3,117.17 287.3,118.3 287.43,118.44 288.24,118.44 288.46,118.22 288.46,118.22 288.83,117.84 288.83,117.56
(no net) on TOP: 110.4,197.35 111.71,197.35 111.82,197.46 111.82,200.66 110.24,202.24 105.86,202.24 104.2,203.89 104.2,205.12 104.08,205.25 99.45,205.25 99.43,205.23 99.43,204.25 99.32,204.14 97.91,204.14 97.85,204.21 97.85,205.24 97.8,205.29 96.72,205.29 96.43,205.57 96.43,206.03 96.31,206.15 94.95,206.15 94.71,205.92 94.71,204.41 94.93,204.19 96.13,204.19 97.46,202.87 103.28,202.87 105.37,200.78 109.68,200.78 110.14,200.32 110.14,197.61
(no net) on TOP: 154.08,112 152.34,112 152.09,112.26 152.09,113.41 152.19,113.51 154.19,113.51 154.27,113.43 154.27,112.19
(no net) on TOP: 140.84,63.64 140.84,71.27 140.99,71.42 142.53,71.42 142.65,71.3 142.65,67.19 143.36,66.48 143.36,63.55 143.17,63.36 141.12,63.36
(no net) on TOP: 209.63,170.77 209.65,170.79 209.65,171.77 210.01,172.14 220.29,172.14 220.7,172.55 220.7,173.64 220.59,173.76 206.72,173.76 206.39,173.43 202.21,173.43 201.88,173.76 199.06,173.76 198.83,173.53 198.83,170.87 198.93,170.77
(no net) on TOP: 2.6,89.38 2.8,89.58 4.48,89.58 4.69,89.37 4.69,81.76 4.47,81.54 2.94,81.54 2.6,81.88
(no net) on TOP: 63.21,49.58 63.48,49.84 67.53,49.84 67.77,49.6 67.77,46.26 67.71,46.2 63.27,46.2 63.21,46.26
(no net) on TOP: 273.6,63.24 273.6,65.98 274.77,67.16 274.77,71.06 274.82,71.11 276.47,71.11 276.59,70.99 276.59,63.77 276.03,63.21 273.63,63.21
(no net) on TOP: 246.25,202.15 246.25,196.25 245.75,195.75 242.07,195.75 241.9,195.93 241.9,204.16 241.99,204.25 243.26,204.25 244.12,203.39 245.19,203.39 245.39,203.59 245.77,203.59 245.91,203.73 247.04,203.73 247.17,203.6 247.17,202.79 246.96,202.57 246.95,202.57 246.58,202.2 246.3,202.2
(no net) on TOP: 48.08,168.15 48.29,168.37 54.1,168.37 54.61,167.86 54.61,164.06 55.42,163.25 58.45,163.25 58.58,163.13 58.58,161.97 59.01,161.53 65.53,161.53 65.71,161.35 65.71,160.59 66.57,159.72 66.57,155.18 65.36,153.97 59.03,153.97 58.58,154.42 58.58,158.79 57.73,159.63 48.34,159.63 48.08,159.9
(no net) on TOP: 249.36,63.34 249.36,66.06 250.53,67.24 250.53,71.15 250.63,71.25 252.17,71.25 252.35,71.07 252.35,63.53 252.09,63.27 249.42,63.27
(no net) on TOP: 62.18,193.83 62.48,193.53 62.48,192.78 63.49,191.76 67.71,191.76 67.84,191.9 67.84,193.58 67.72,193.71 63.85,193.71 63.36,194.2 62.68,194.2 62.6,194.28 61.13,194.28 61.13,193.89 61.19,193.83
(no net) on TOP: 165.11,204.54 163.9,205.75 151.66,205.75 151.49,205.92 151.49,208.22 152.11,208.84 166.25,208.84 172.72,202.37 174.62,202.37 175.01,201.99 175.01,197.92 174.75,197.67 169.42,197.67 165.11,201.98
(no net) on TOP: 214.01,204.38 214.01,204.38 214.01,203.18 214.01,202.96 214.19,202.79 214.54,202.79 216.02,201.31 216.02,197.08 215.92,196.98 213.91,196.98 213.79,197.1 213.79,200.78 213.45,201.12 213.45,202.66 213.61,202.82 213.61,204.37 213.63,204.38
(no net) on TOP: 1,0.51 0.65,0.65 0.51,1 0.51,208.98 0.65,209.33 1,209.47 38.48,209.47 39.55,209.91 39.99,210.98 39.99,214.83 40.14,215.18 40.48,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,4.97 312.85,4.62 312.5,4.48 288.55,4.48 288.55,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,10.45 81.97,11.52 80.91,11.96 63.44,11.96 62.65,11.74 62.1,11.14 43.54,11.14 42.47,10.7 42.03,9.63 42.03,1 41.89,0.65 41.54,0.51 ; 47 cut-outs
(no net) on TOP: 165.45,86.08 165.4,86.13 164.2,86.13 163.6,85.53 162.62,85.53 161.58,84.48 161.58,83.95 161.61,83.92 162.56,83.92 162.92,83.55 165.3,83.55 165.45,83.7
(no net) on TOP: 237.28,63.28 237.28,66.06 238.45,67.24 238.45,71.15 238.56,71.25 240.1,71.25 240.27,71.07 240.27,63.47 239.99,63.19 237.37,63.19
(no net) on TOP: 144.04,64.67 144.04,63.13 144.14,63.03 147.9,63.03 147.9,63.03 148.08,63.03 148.2,63.15 148.2,64.59 148.66,65.05 148.66,65.55 148.59,65.62 143.75,65.62 143.7,65.56 143.7,65.01
(no net) on TOP: 40.03,36.48 40.03,34.6 40.27,34.36 42.67,34.36 42.95,34.63 42.95,36.5 42.88,36.57 40.11,36.57
(no net) on TOP: 101.23,84.54 99.84,84.54 99.67,84.37 99.67,83.48 99.15,82.96 99.15,82.29 99.34,82.1 101.22,82.1 101.29,82.17 101.29,84.47
(no net) on TOP: 63.13,142.96 63.13,141.5 63.53,141.5 63.53,142.72 63.54,142.73 63.54,149.57 63.52,149.6 60.89,149.6 60.74,149.45 60.74,146.05 61.96,144.83 61.96,143.63 62,143.6 62.49,143.6
(no net) on TOP: 23.28,103.68 30.21,103.68 30.28,103.61 30.28,101.9 30.08,101.7 23.45,101.7 23.24,101.91 23.24,103.64
(no net) on TOP: 58.8,164.14 55.65,164.14 55.4,164.39 55.4,167.24 55.62,167.46 58.65,167.46 59.02,167.09 59.02,164.36
(no net) on TOP: 285.92,195.22 288.13,195.22 288.33,195.02 288.33,193.06 288.1,192.83 285.98,192.83 285.87,192.95 285.87,195.17
(no net) on TOP: 63.27,197.55 62.81,197.55 62.04,196.79 62.04,195.8 61.31,195.8 61.23,195.88 61.23,201.12 61.71,201.59 63.63,201.59 63.63,201.5 63.64,201.49 63.64,197.92
(no net) on TOP: 247.69,205.72 247.69,205.45 247.58,205.34 246.38,205.34 246.18,205.54 246.18,211.36 246.3,211.48 249.71,211.48 249.82,211.37 249.82,207.84
(no net) on TOP: 5.39,84.73 7.03,84.73 7.19,84.57 7.19,79.46 6.96,79.23 5.56,79.23 5.3,79.5 5.3,84.64
(no net) on TOP: 27.24,104.46 27.24,106.12 27.41,106.29 32.55,106.29 32.71,106.13 32.71,104.98 32.16,104.43 27.27,104.43
(no net) on TOP: 133.08,63.02 133.08,65.81 134.25,66.99 134.25,70.89 134.35,71 135.89,71 136.07,70.82 136.07,63.22 135.78,62.93 133.17,62.93
(no net) on TOP: 155.3,84.69 155.36,84.74 155.36,86.8 155.2,86.95 154.06,86.95 153.86,86.75 153.86,84.82 153.99,84.69
(no net) on TOP: 266.01,153.78 259.06,153.78 258.83,153.54 258.83,152.4 259.02,152.2 266.04,152.2 266.24,152.41 266.24,153.55
(no net) on TOP: 191.01,106.86 191.01,103.94 191.13,103.82 192.66,103.82 192.78,103.94 192.78,106.86 192.66,106.99 191.13,106.99
(no net) on TOP: 82.66,148.46 82.66,145.03 82.25,144.62 82.25,143.06 82.94,142.37 82.94,141.69 82.77,141.51 81.78,141.51 81.49,141.22 78.39,141.22 77.99,141.62 76.58,141.62 76.31,141.89 76.31,144.24 75.99,144.56 74.28,144.56 74.23,144.5 74.23,142.88 74.15,142.8 74.15,141.44 73.81,141.11 73.81,140.04 74.31,139.54 77.24,139.54 78.13,140.43 83.87,140.43 84.36,140.92 84.36,148.23 84.13,148.46
(no net) on TOP: 175.41,184.17 164.85,184.17 164.33,183.65 164.33,172.49 166.24,170.58 176.41,170.58 176.77,170.94 176.77,183.97 176.57,184.17 175.42,184.17
(no net) on TOP: 295.41,118.25 295.9,118.73 295.9,121.21 295.72,121.39 290.92,121.39 289.01,119.47 288.82,119.47 288.77,119.42 288.77,118.39 288.91,118.25
(no net) on TOP: 124.54,76.51 124.92,76.13 125.18,76.13 126.17,76.13 126.25,76.21 127.77,76.21 127.81,76.16 127.81,75.58 127.76,75.53 126.34,75.53 126.33,75.52 126.17,75.52 125.86,75.21 123.37,75.21 123.22,75.36 123.22,76.25 123.47,76.51
(no net) on TOP: 23.34,145.67 23.96,145.67 24.02,145.73 24.02,147.73 24.04,147.74 25.72,147.74 25.92,147.94 25.92,148.44 25.7,148.66 24.06,148.66 24.03,148.69 24.03,149.15 24.09,149.21 31.78,149.21 31.98,149.01 31.98,145.17 31.96,145.15 25.9,145.15 25.26,144.51 23.44,144.51 23.28,144.68 23.28,145.6
(no net) on TOP: 185.59,141.17 185.26,140.85 185.26,138.93 185.31,138.88 186.62,138.88 186.95,139.22 186.95,140.59 186.37,141.17
(no net) on TOP: 66.63,148.46 66.63,144.9 66.21,144.48 66.21,142.86 66.4,142.67 66.76,142.67 66.9,142.53 66.9,141.7 66.73,141.53 65.77,141.53 65.46,141.22 62.36,141.22 61.93,141.65 60.53,141.65 60.37,141.81 60.37,142.7 60.22,142.85 58.8,142.85 58.43,142.47 58.43,138.43 58.1,138.1 58.1,136.98 57.82,136.7 57.82,136.06 57.84,136.04 59.85,136.04 60.34,136.53 60.34,137.91 61.78,139.35 61.78,140.02 62.19,140.43 68.15,140.43 68.33,140.62 68.33,148.23 68.1,148.46
(no net) on TOP: 301.89,154.16 301.95,154.1 303.99,154.1 304.46,153.63 305.9,153.63 306.95,152.58 306.95,144.83 306.96,144.82 306.96,144.53 306.2,143.76 302.64,143.76 302.39,144.02 302.39,148.72 301.89,149.22
(no net) on TOP: 82.03,204.89 82.03,204.89 82.03,203.69 82.03,203.47 82.21,203.3 82.36,203.3 85.86,199.8 85.86,197.81 85.55,197.49 81.93,197.49 81.81,197.6 81.81,201.28 81.47,201.63 81.47,203.17 81.63,203.33 81.63,204.87 81.65,204.89
(no net) on TOP: 160.1,83.14 160.24,83.28 162.49,83.28 162.55,83.21 162.55,82.39 162.2,82.04 160.25,82.04 160.1,82.19
(no net) on TOP: 297.77,154.22 297.83,154.16 297.83,149.05 296.03,147.25 296.03,147.25 295.91,147.12 292.86,147.12 292.35,147.63 292.35,153.85 292.72,154.22
(no net) on TOP: 152.87,98.01 152.87,104.76 152.87,104.76 152.87,104.82 153.02,104.97 156.22,104.97 156.53,105.29 156.53,107.33 156.23,107.64 149.14,107.64 148.91,107.4 148.91,97.89 149.04,97.75 152.61,97.75
(no net) on TOP: 154.65,184.94 154.65,185.82 154.66,185.82 154.66,186.41 154.72,186.47 156.65,186.47 156.98,186.13 160.78,186.13 161.03,186.39 162.07,186.39 162.12,186.34 162.12,184.7 161.98,184.56 160.84,184.56 160.49,184.21 160.49,177.45 159.95,176.91 154.75,176.91 154.35,177.31 154.35,184.63
(no net) on TOP: 180.27,64.67 180.27,63.13 180.37,63.03 184.13,63.03 184.31,63.03 184.43,63.15 184.43,64.59 184.89,65.05 184.89,65.55 184.82,65.62 179.98,65.62 179.93,65.56 179.93,65.01
(no net) on TOP: 76.68,130.15 76.88,130.35 76.88,133.85 75.99,134.74 73.57,134.74 72.87,134.04 72.87,130.22 72.93,130.15
(no net) on TOP: 294.34,122.33 295.88,122.33 296,122.45 296,124.8 295.75,125.05 294.39,125.05 294.27,124.94 294.27,122.4
(no net) on TOP: 73.46,144.6 75.04,146.17 75.04,149.86 74.78,150.11 71.64,150.11 70.77,149.24 70.77,139.88 70.98,139.67 73.35,139.67 73.46,139.78
(no net) on TOP: 171.1,195.38 175.26,195.38 175.64,195 175.64,190.56 175.39,190.3 168.53,190.3 168.15,190.68 168.15,191.7 167.39,192.46 164.63,192.46 164.37,192.21 164.37,187.34 164.09,187.06 160.77,187.06 160.28,186.57 157.23,186.57 157,186.8 151.39,186.8 151.27,186.92 151.27,190.13 151.34,190.2 157,190.2 157.26,190.46 159.12,190.46 159.49,190.83 159.49,204.27 159.74,204.52 163.91,204.52 164.37,204.06 164.37,202.11
(no net) on TOP: 208.03,194.39 207.92,194.49 207.92,195.74 207.91,195.75 207.91,201.32 208.26,201.67 209.39,201.67 209.79,202.08 209.79,202.93 210.08,203.21 211.03,203.21 212.1,204.29 212.64,204.29 212.71,204.21 212.71,202.84 212.8,202.75 212.8,194.81 212.37,194.39
(no net) on TOP: 153.23,104.54 153.23,98.43 153.34,98.31 155.48,98.31 155.76,98.59 155.76,104.45 155.57,104.64 153.32,104.64
(no net) on TOP: 127.3,150.23 127.3,145.72 127.6,145.42 130.6,145.42 131.33,146.14 131.33,148.68 129.64,150.37 127.44,150.37
(no net) on TOP: 232.09,195.99 232.09,194.62 232.41,194.31 235.01,194.31 235.26,194.57 235.26,195.95 235.07,196.15 232.26,196.15
(no net) on TOP: 18.55,145.35 19.28,144.62 21.19,144.62 21.23,144.66 21.23,145.58 21.2,145.62 20.64,145.62 20.54,145.72 20.54,147.64 20.51,147.67 19.33,147.67 19.2,147.8 19.2,148.35 19.1,148.45 14.14,148.45 13.85,148.16 13.85,145.55 14.06,145.35
(no net) on TOP: 264.79,149.66 263.95,150.51 263.95,150.8 264.04,150.89 266,150.89 266.29,150.6 266.29,145.19 266.15,145.05 264.89,145.05 264.79,145.14
(no net) on TOP: 148.98,139.18 152.3,139.18 152.55,138.94 152.55,136.17 152.39,136.01 150.93,136.01 150.71,136.23 150.71,137.7 150.55,137.86 149.07,137.86 148.92,138.02 148.92,139.12
(no net) on TOP: 162.81,95.91 162.48,95.58 162.48,94.88 162.23,94.63 160.94,94.63 160.87,94.7 160.87,97.64 161.03,97.8 162.84,97.8 163.35,97.29 167.19,97.29 167.3,97.18 167.3,96.13 167.08,95.91
(no net) on TOP: 158.28,204.49 158.53,204.25 158.53,191.24 158.05,190.76 156.88,190.76 156.68,190.56 154.65,190.56 154.65,191.66 154.15,192.17 154.15,196.04 153.36,196.83 151.77,196.83 151.49,197.11 151.49,204.19 151.8,204.49
(no net) on TOP: 92.58,94.74 92.58,86.87 100.71,86.87 100.71,94.74
(no net) on TOP: 150.67,139.99 153.59,139.99 153.86,140.26 153.86,141.45 153.62,141.69 151.25,141.69 150.62,141.06 150.62,140.04
(no net) on TOP: 173.17,63.28 173.17,66.06 174.35,67.24 174.35,71.15 174.45,71.25 175.99,71.25 176.17,71.07 176.17,63.47 175.88,63.19 173.26,63.19
(no net) on TOP: 247.55,114.83 247.62,114.89 251.88,114.89 252.1,114.66 252.1,110.89 251.91,110.7 250.66,110.7 250.52,110.84 250.52,111.11 250.2,111.43 247.82,111.43 247.55,111.71
(no net) on TOP: 158.22,115.13 158.22,116.13 158.11,116.24 157.17,116.24 156.52,115.6 153.34,115.6 153.24,115.5 153.24,114.15 153.26,114.12 157.21,114.12
(no net) on TOP: 181.68,139.52 181.68,135 181.84,134.84 182.95,134.84 183.11,135 183.11,139.17 182.77,139.52
(no net) on TOP: 13.59,103.04 5.98,103.04 5.89,102.94 5.89,100.76 6.12,100.53 9.5,100.53 10.97,99.06 13.46,99.06 13.66,99.26 13.66,102.97
(no net) on TOP: 262.05,147.47 261.96,147.57 258,147.57 257.74,147.3 257.74,145.47 258.2,145.01 261.85,145.01 262.05,145.21
(no net) on TOP: 244.51,66.88 244.51,73.16 244.66,73.31 248.91,73.31 249.08,73.14 249.08,73 249.08,73 249.08,66.93 248.98,66.84 244.55,66.84
(no net) on TOP: 76.92,204.08 76.86,204.15 76.86,207.55 76.9,207.6 79.17,207.6 79.79,206.97 79.79,206.11 79.96,205.94 81.33,205.94 81.44,205.83 81.44,205.38 81.37,205.32 80.15,205.32 78.92,204.08
(no net) on TOP: 76.06,184.08 83.81,184.08 83.93,183.95 83.93,181.79 83.31,181.17 81.76,181.17 81.18,180.59 81.18,175.16 80.54,174.52 78.54,174.52 78.22,174.84 78.22,183.7 78.09,183.83 76.06,183.83
(no net) on TOP: 63.03,196.87 62.35,196.18 62.35,195.29 61.1,195.29 61.1,194.99 63.47,194.99 63.54,195.06 67.66,195.06 67.81,195.22 67.81,196.71 67.65,196.87
(no net) on TOP: 265.42,63.69 265.42,71.31 265.57,71.46 267.11,71.46 267.22,71.35 267.22,67.23 267.93,66.52 267.93,63.6 267.74,63.41 265.7,63.41
(no net) on TOP: 230.29,75.53 230.29,74.29 230.04,74.04 229.44,74.04 229.26,74.22 229.26,76.25 229.38,76.38 230.37,76.38 230.45,76.46 231.97,76.46 232.01,76.42 232.01,75.83 231.96,75.78 230.54,75.78
(no net) on TOP: 177.07,71.01 177.22,71.16 178.76,71.16 178.88,71.05 178.88,66.93 179.59,66.22 179.59,63.4 179.44,63.25 177.32,63.25 177.07,63.5
(no net) on TOP: 152.39,76.38 154.19,76.38 154.27,76.46 155.79,76.46 155.83,76.42 155.83,75.83 155.78,75.78 154.36,75.78 154.35,75.78 154.19,75.78 153.79,75.38 153.79,74.5 153.61,74.32 152.41,74.32 152.24,74.5 152.24,76.24
(no net) on TOP: 161.1,63.2 161.1,65.94 162.27,67.11 162.27,71.02 162.37,71.12 163.91,71.12 164.09,70.94 164.09,63.72 163.53,63.16 161.13,63.16
(no net) on TOP: 182.71,168.18 182.71,186.3 180.38,188.63 168.34,188.63 167.67,187.96 167.67,185.73 168.21,185.19 176.66,185.19 177.5,184.35 177.5,173.04 177.15,172.69 177.15,170.37 176.64,169.86 169.6,169.86 169.26,169.52 169.26,166.75 169.84,166.16 180.69,166.16
(no net) on TOP: 116.15,66.62 116.15,72.6 116.33,72.78 120.53,72.78 120.72,72.59 120.72,66.68 120.63,66.58 116.19,66.58
(no net) on TOP: 253.34,63.69 253.34,71.31 253.49,71.46 255.03,71.46 255.15,71.35 255.15,67.23 255.86,66.52 255.86,63.6 255.67,63.41 253.62,63.41
(no net) on TOP: 237.19,109.62 237.45,109.88 238.37,109.88 238.54,109.7 238.54,105.32 238.74,105.11 240.26,105.11 240.32,105.06 240.32,102.61 240.2,102.49 238.7,102.49 237.19,104
(no net) on TOP: 268.5,74.13 268.37,74.27 268.37,76.3 268.58,76.51 271.08,76.51 271.12,76.46 271.12,75.88 271.07,75.82 269.49,75.82 269.16,75.49 269.16,74.26 269.03,74.13
(no net) on TOP: 123.14,203.91 120.65,201.41 120.65,200.86 119.82,200.03 119.82,198.52 119.77,198.47 119.03,198.47 118.97,198.53 118.97,199.92 118.85,200.05 118.85,203.64 119.29,204.08 119.92,204.08 119.99,204.15 119.99,204.23 119.9,204.31 105.35,204.31 105.2,204.45 105.2,207.83 105.37,208 122.36,208 123.14,207.22
(no net) on TOP: 88.67,63.39 88.67,70.79 88.72,70.85 90.41,70.85 90.47,70.79 90.47,66.93 91.18,66.22 91.18,63.3 90.99,63.11 88.95,63.11
(no net) on TOP: 229.1,63.5 229.1,71.01 229.25,71.16 230.79,71.16 230.91,71.05 230.91,66.93 231.62,66.22 231.62,63.39 231.49,63.26 229.34,63.26
(no net) on TOP: 27.94,173.43 27.94,181.52 32.46,186.04 32.46,188.36 32.87,188.78 37.21,188.78 37.72,188.27 37.72,182.68 35.81,180.77 35.81,172.92 28.46,172.92
(no net) on TOP: 5.27,99.69 5.27,94.33 5.05,94.11 3.47,94.11 3.29,94.28 3.29,99.6 3.56,99.87 5.1,99.87
(no net) on TOP: 5.69,90.05 5.65,90.09 5.65,97.13 5.75,97.23 7.68,97.23 7.87,97.04 7.87,90.32 7.61,90.05
(no net) on TOP: 113.31,136.55 114.71,136.55 114.74,136.58 114.74,137.38 115.17,137.82 115.17,139.16 115.05,139.28 111.55,139.28 111.36,139.09 111.36,138.29 111.52,138.14 112.71,138.14 112.99,137.86 112.99,136.87
(no net) on TOP: 213.82,196.17 215.77,196.17 216.08,195.86 216.08,193.99 215.87,193.78 213.94,193.78 213.66,194.06 213.66,196.02
(no net) on TOP: 82.55,187.38 84.19,187.38 84.31,187.51 84.31,190.97 84.03,191.26 81.62,191.26 81.39,191.03 81.39,190.04 82.49,188.95 82.49,187.45
(no net) on TOP: 148.31,105.76 146.94,105.76 145.93,104.74 144.44,104.74 144.24,104.54 144.24,102.33 144.49,102.08 148.28,102.08 148.4,102.2 148.4,105.66
(no net) on TOP: 232.11,204.13 232.11,204.13 232.11,202.93 232.11,202.71 232.29,202.54 232.98,202.54 234.12,201.39 234.12,196.83 234.02,196.73 232.01,196.73 231.89,196.84 231.89,200.52 231.55,200.87 231.55,202.4 231.71,202.56 231.71,204.11 231.73,204.13
(no net) on TOP: 3.94,178.1 3.85,178.1 3.34,178.61 3.34,179.63 3.59,179.88 3.59,182.04 3.72,182.17 9.03,182.17 9.22,182.35 9.98,182.35 9.98,183.56 9.74,183.8 2.55,183.8 2.2,183.45 2.2,172.85 2.46,172.59 3.87,172.59 3.94,172.66
(no net) on TOP: 226.55,201.67 226.01,201.13 226.01,195.5 226.02,195.48 226.02,194.24 226.13,194.13 230.48,194.13 230.9,194.56 230.9,202.5 230.81,202.59 230.81,203.96 230.74,204.03 230.2,204.03 227.84,201.67
(no net) on TOP: 190.92,107.75 190.64,107.48 190.64,103.27 190.8,103.11 193.41,103.11 193.65,102.88 193.65,99.69 193.44,99.48 187.32,99.48 187.25,99.55 187.25,113.17 187.31,113.23 189.27,113.23 189.3,113.19 189.3,111.99 189.44,111.85 193.19,111.85 193.54,111.51 193.54,108.57 192.72,107.75
(no net) on TOP: 293.18,189.93 308.75,189.93 309.2,189.48 309.2,185.75 309.02,185.56 293.39,185.56 292.65,186.29 292.65,189.4
(no net) on TOP: 213.12,63.58 213.12,66.32 214.3,67.49 214.3,71.4 214.4,71.5 215.94,71.5 216.12,71.33 216.12,64.11 215.56,63.54 213.16,63.54
(no net) on TOP: 82.09,186.94 83.74,186.94 83.93,186.75 83.93,184.97 83.81,184.84 76.06,184.84 75.93,184.97 75.93,185.1 78.35,185.1 78.47,185.22 78.47,186.28 78.73,186.28 79.94,187.48 79.94,189.1 80.25,189.41 81.55,189.41 81.83,189.14 81.83,187.2
(no net) on TOP: 247.52,108.93 247.52,100.76 247.73,100.54 252.91,100.54 253.37,101 253.37,108.71 252.98,109.1 247.68,109.1
(no net) on TOP: 194.07,157.68 189.76,157.68 189.47,157.97 189.47,161.35 189.92,161.81 193.91,161.81 194.26,161.46 194.26,157.86
(no net) on TOP: 39.71,54.89 39.71,55.26 39.6,55.38 36.18,55.38 36.04,55.24 36.04,54.43 36.2,54.27 39.09,54.27
(no net) on TOP: 252.88,162.76 253.06,162.58 258.85,162.58 259.18,162.91 259.18,168.96 258.97,169.17 253.44,169.17 252.88,168.61
(no net) on TOP: 250.29,203.71 250.13,203.88 250.13,205 250.3,205.17 251.96,205.17 251.96,205.17 252.32,205.17 252.41,205.07 252.41,204.55 252.3,204.43 251.77,204.43 251.54,204.21 251.54,203.73 251.53,203.71
(no net) on TOP: 185.25,63.34 185.25,66.06 186.43,67.24 186.43,71.15 186.53,71.25 188.07,71.25 188.25,71.07 188.25,63.53 187.99,63.27 185.32,63.27
(no net) on TOP: 92,72.97 92.19,73.16 96.4,73.16 96.57,73 96.57,66.68 96.4,66.51 92.11,66.51 92,66.63
(no net) on TOP: 261.62,125.26 261.5,125.38 261.5,126.32 261.05,126.77 247.82,126.77 245.07,129.51 245.07,143.74 239.08,149.73 196.77,149.73 194.83,151.67 194.83,176.72 202.53,184.42 217.58,184.42 220.9,187.75 220.9,195.1 220.92,195.11 220.92,206.63 221.15,206.87 224.21,206.87 225.04,206.04 225.04,184.05 224.69,183.69 224.68,183.69 222,181.01 204.47,181.01 198.38,174.93 198.38,168.16 198.58,167.96 198.58,154.21 200.37,152.42 240.67,152.42 247.86,145.23 247.86,130.6 249.11,129.36 261.67,129.36 262.55,128.48 262.55,125.92 262.35,125.72 261.89,125.26
(no net) on TOP: 62.04,193.44 62.04,192.68 63.62,191.1 64.32,191.1 64.61,190.82 64.61,186.93 64.44,186.76 62.4,186.76 61.29,185.65 59.34,185.65 59.17,185.82 59.17,188 59.31,188.14 60.89,188.14 61.07,188.31 61.07,192.77 61.18,192.88 61.18,193.34 61.28,193.44
(no net) on TOP: 203.05,207.12 202.82,206.89 202.82,192.9 183.28,173.36 183.28,168 180.88,165.6 169.98,165.6 167.83,163.45 167.83,150.62 168.27,150.17 172.07,150.17 172.51,150.61 172.51,155.9 177.67,161.06 184.9,161.06 188.91,165.06 188.91,171.46 206.94,189.49 206.94,206.29 206.11,207.12
(no net) on TOP: 84.4,148.71 82.72,148.71 82.66,148.77 82.66,150.24 82.84,150.42 84.44,150.42 84.64,150.22 84.64,148.96
(no net) on TOP: 73.29,47.78 73.19,47.87 73.19,48.54 73.31,48.67 76.73,48.67 76.91,48.49 76.91,47.93 76.76,47.78
(no net) on TOP: 69.9,178.05 70.46,177.49 73.36,177.49 73.93,176.93 73.93,175 74.24,174.68 77.46,174.68 77.58,174.81 77.58,178.58 76.97,179.2 76.97,180.57 76.95,180.59 74.46,180.59 73.96,180.08 70.08,180.08 69.9,179.91
(no net) on TOP: 69.22,134.73 71.04,134.73 72.33,133.45 72.33,131.7 71.78,131.15 69.27,131.15 69.13,131.29 69.13,134.64
(no net) on TOP: 35.2,26.42 27.67,26.42 27.62,26.37 27.62,24.36 27.87,24.1 34.96,24.1 35.25,24.38 35.25,26.37
(no net) on TOP: 192.14,194.86 192.49,194.52 195.14,194.52 195.28,194.66 195.28,200.11 193.37,202.02 193.37,202.21 193.32,202.26 192.29,202.26 192.14,202.11
(no net) on TOP: 137.94,142.51 135.53,142.51 135.36,142.33 135.36,139.27 135.47,139.17 137.98,139.17 138.14,139.33 138.14,142.3
(no net) on TOP: 27.31,140.33 27.31,138.28 27.44,138.16 30.94,138.16 31.12,138.33 31.12,140.28 30.87,140.52 27.51,140.52
(no net) on TOP: 268.75,66.92 268.75,73.34 268.96,73.55 273.26,73.55 273.32,73.49 273.32,66.98 273.22,66.88 268.79,66.88
(no net) on TOP: 225.2,63.2 225.2,65.94 226.38,67.11 226.38,71.02 226.48,71.12 228.02,71.12 228.2,70.94 228.2,63.72 227.63,63.16 225.24,63.16
(no net) on TOP: 306.41,88.73 305.73,88.73 305.69,88.77 305.69,89.83 304.62,90.89 304.62,93.27 304.88,93.53 306.33,93.53 306.56,93.3 306.56,89.88 306.43,89.75 306.43,88.75
(no net) on TOP, BOTTOM: 288.8,170.11 288.8,147.12 288.03,146.36 269.72,146.36 268.84,147.24 268.84,170.26 269.33,170.74 288.16,170.74
(no net) on TOP, BOTTOM: 148.5,96.87 148.5,93.85 148.69,93.65 151.47,93.65 151.7,93.88 151.7,96.78 151.49,96.99 148.61,96.99
(no net) on TOP, BOTTOM: 220.35,66.88 220.35,72.97 220.55,73.16 224.76,73.16 224.93,73 224.93,66.93 224.83,66.84 220.39,66.84
(no net) on TOP, BOTTOM: 244.37,64.93 244.37,63.38 244.47,63.29 248.23,63.29 248.23,63.29 248.41,63.29 248.53,63.41 248.53,64.84 249,65.31 249,65.8 248.93,65.87 244.09,65.87 244.03,65.82 244.03,65.27
(no net) on TOP, BOTTOM: 256.54,64.97 256.54,63.43 256.64,63.33 260.4,63.33 260.58,63.33 260.7,63.45 260.7,64.88 261.16,65.35 261.16,65.85 261.09,65.92 256.25,65.92 256.2,65.86 256.2,65.31
(no net) on TOP, BOTTOM: 156.25,66.88 156.25,72.97 156.44,73.16 160.65,73.16 160.82,73 160.82,66.93 160.72,66.84 156.29,66.84
(no net) on TOP, BOTTOM: 128.09,64.67 128.09,63.13 128.19,63.03 131.95,63.03 131.95,63.03 132.13,63.03 132.25,63.15 132.25,64.59 132.72,65.05 132.72,65.55 132.65,65.62 127.81,65.62 127.75,65.56 127.75,65.01
(no net) on TOP, BOTTOM: 168.33,66.88 168.33,72.97 168.52,73.16 172.73,73.16 172.9,73 172.9,66.93 172.8,66.84 168.37,66.84
(no net) on TOP, BOTTOM: 116.02,64.67 116.02,63.13 116.12,63.03 119.88,63.03 120.06,63.03 120.18,63.15 120.18,64.59 120.64,65.05 120.64,65.55 120.57,65.62 115.73,65.62 115.68,65.56 115.68,65.01
(no net) on TOP, BOTTOM: 104.07,66.88 104.07,72.97 104.27,73.16 108.48,73.16 108.65,73 108.65,66.93 108.55,66.84 104.11,66.84
(no net) on TOP, BOTTOM: 75.67,192.13 75.67,190.61 75.77,190.51 78.04,190.51 78.2,190.68 78.2,191.97 77.95,192.22 75.76,192.22
(no net) on TOP, BOTTOM: 232.3,64.93 232.3,63.38 232.4,63.29 236.16,63.29 236.34,63.29 236.46,63.41 236.46,64.84 236.92,65.31 236.92,65.8 236.85,65.87 232.01,65.87 231.96,65.82 231.96,65.27
(no net) on TOP, BOTTOM: 220.22,64.93 220.22,63.38 220.32,63.29 224.08,63.29 224.08,63.29 224.26,63.29 224.38,63.41 224.38,64.84 224.84,65.31 224.84,65.8 224.77,65.87 219.94,65.87 219.88,65.82 219.88,65.27
(no net) on TOP, BOTTOM: 232.43,66.88 232.43,72.97 232.62,73.16 236.84,73.16 237,73 237,66.93 236.91,66.84 232.47,66.84
(no net) on TOP, BOTTOM: 208.28,66.88 208.28,72.97 208.47,73.16 212.68,73.16 212.85,73 212.85,66.93 212.75,66.84 208.32,66.84
(no net) on TOP, BOTTOM: 144.17,66.88 144.17,72.97 144.37,73.16 148.58,73.16 148.74,73 148.74,66.93 148.65,66.84 144.21,66.84
(no net) on TOP, BOTTOM: 284.22,160.71 284.22,155.76 283.21,154.74 272.29,154.74 271.27,155.76 271.27,160.71 272.03,161.47 283.46,161.47
(no net) on TOP, BOTTOM: 208.14,64.93 208.14,63.38 208.24,63.29 212,63.29 212.18,63.29 212.3,63.41 212.3,64.84 212.77,65.31 212.77,65.8 212.69,65.87 207.86,65.87 207.8,65.82 207.8,65.27
(no net) on TOP, BOTTOM: 128.23,66.62 128.23,72.72 128.42,72.91 132.63,72.91 132.8,72.74 132.8,66.68 132.7,66.58 128.27,66.58
(no net) on TOP, BOTTOM: 268.61,64.97 268.61,63.43 268.71,63.33 272.47,63.33 272.65,63.33 272.77,63.45 272.77,64.88 273.24,65.35 273.24,65.85 273.17,65.92 268.33,65.92 268.27,65.86 268.27,65.31
(no net) on TOP, BOTTOM: 269.3,171.82 268.73,172.4 268.73,175.7 269.24,176.21 287.55,176.21 288.29,175.46 288.29,172.36 287.76,171.82
(no net) on TOP, BOTTOM: 180.4,66.88 180.4,72.97 180.6,73.16 184.81,73.16 184.97,73 184.97,66.93 184.88,66.84 180.44,66.84
(no net) on TOP, BOTTOM: 56.75,185.46 58.26,185.46 58.49,185.69 58.49,187.31 58.4,187.39 56.65,187.39 56.47,187.22 56.47,185.74
(no net) on TOP, BOTTOM: 256.67,66.92 256.67,73.02 256.87,73.21 261.08,73.21 261.24,73.04 261.24,66.98 261.15,66.88 256.71,66.88
(no net) on BOTTOM: 227.07,93.02 227.07,97.21 225.75,98.54 225.75,100.33 225.67,100.41 222.53,100.41 221.77,99.65 221.77,91.42 223.12,90.07 228,90.07 228.19,90.26 228.19,91.91
(no net) on BOTTOM: 168.19,64.93 168.19,63.38 168.29,63.29 172.05,63.29 172.05,63.29 172.23,63.29 172.35,63.41 172.35,64.84 172.82,65.31 172.82,65.8 172.74,65.87 167.91,65.87 167.85,65.82 167.85,65.27
(no net) on BOTTOM: 34.49,161.69 34.13,162.04 34.13,165.26 34.81,165.94 37.24,165.94 37.49,165.69 41.81,165.69 41.93,165.82 41.93,168.34 42.67,169.08 42.67,180 43.3,180.64 46.73,180.64 47.24,180.13 47.24,161.99 46.94,161.69
(no net) on BOTTOM: 15.24,178.49 15.14,178.39 11.71,178.39 11.27,178.83 11.27,181.71 10.74,182.24 10.74,190.11 10.22,190.63 10.22,192.43 10.51,192.71 14.87,192.71 15.24,192.35
(no net) on BOTTOM: 74.96,201.91 74.7,202.17 72.4,202.17 72.14,201.91 72.14,192.07 73.51,190.7 74.93,190.7 74.93,193.75 74.96,193.75
(no net) on BOTTOM: 9.65,192.39 9.65,185.24 3.81,185.24 3.3,185.74 3.3,192.37 3.6,192.67 9.37,192.67
(no net) on BOTTOM: 163.88,125.43 160.79,125.43 160.64,125.59 160.64,126.73 160.87,126.97 160.87,127.87 161.02,128.01 165,128.01 165.45,127.56 165.45,125.61 165.43,125.59 164.03,125.59
(no net) on BOTTOM: 304.71,76.59 304.8,76.5 308.35,76.5 308.62,76.77 308.62,82.59 307.72,83.49 307.72,84.63 307.59,84.76 306.2,84.76 305.94,84.51 305.94,82.35 304.71,81.12
(no net) on BOTTOM: 218.14,84.14 218.6,83.68 221.55,83.68 222.04,84.17 222.04,90.69 221.07,91.66 218.62,91.66 218.14,91.18
(no net) on BOTTOM: 232.33,194.59 235,194.59 235.16,194.75 235.16,195.87 234.93,196.1 232.3,196.1 232.17,195.97 232.17,194.75
(no net) on BOTTOM: 113.31,46.82 112.85,47.29 112.85,60.43 112.82,60.45 112.82,70.76 112.97,70.91 114.51,70.91 114.63,70.79 114.63,66.68 115.34,65.97 115.34,62.99 115.51,62.82 115.89,62.82 117.27,61.44 119.94,58.77 119.94,47.72 119.04,46.82
(no net) on BOTTOM: 264.86,151.56 264.21,152.2 262.36,152.2 262.09,152.47 262.09,153.61 262.25,153.78 266.01,153.78 266.24,153.55 266.24,145.27 266.06,145.09 265.03,145.09 264.86,145.26
(no net) on BOTTOM: 306.08,169.08 306.96,168.2 306.96,160.33 306.79,160.16 305.09,160.16 305.08,160.15 302.79,160.15 302.67,160.27 302.67,168.81 302.64,168.84 302.88,169.08
(no net) on BOTTOM: 18.39,140.96 18.39,137.99 18.71,137.67 30.59,137.67 31.09,138.17 31.09,140.32 30.91,140.5 26.99,140.5 26.24,139.74 20.68,139.74 20.34,140.08 20.34,140.82 20.16,141 18.42,141
(no net) on BOTTOM: 183.23,104.63 183.41,104.82 186.02,104.82 186.05,104.78 186.05,103.32 185.77,103.04 183.42,103.04 183.23,103.23
(no net) on BOTTOM: 245.98,195.99 245.98,201.45 247.01,202.49 247.01,203.48 246.7,203.79 243.66,203.79 243.08,204.37 243.08,206.6 242.8,206.88 241.81,206.88 241.6,206.68 241.6,204.75 241.61,204.75 241.89,204.47 241.89,195.96 242.11,195.75 245.73,195.75
(no net) on BOTTOM: 141.02,106.58 141.17,106.43 144.25,106.43 144.58,106.76 144.58,112.92 144.33,113.17 141.31,113.17 141.02,112.88
(no net) on BOTTOM: 268.75,66.92 268.75,73.33 268.98,73.56 273.23,73.56 273.32,73.47 273.32,66.98 273.22,66.88 268.79,66.88
(no net) on BOTTOM: 82.61,187.38 84.19,187.38 84.31,187.51 84.31,190.97 84.03,191.26 81.62,191.26 81.39,191.03 81.39,190.17 82.55,189.01 82.55,187.44
(no net) on BOTTOM: 65.23,207.01 64.97,206.76 62.28,206.76 62.28,206.76 59.69,206.76 59.19,207.26 59.19,210.31 59.48,210.61 64.77,210.61 65.23,210.15
(no net) on BOTTOM: 70.18,172.34 74.03,176.19 74.03,179.64 74.54,180.14 76.16,180.14 77.13,181.11 77.13,182.26 77.24,182.38 77.9,182.38 77.94,182.34 77.94,180.14 77.58,179.79 77.58,168.61 76.84,167.86 66.54,167.86 62.73,164.06 62.73,153.26 64,152 64,139.71 65.95,137.75 68.2,137.75 68.66,137.3 68.66,134.85 68.02,134.22 64.56,134.22 60.34,138.44 60.34,145.76 54.61,151.5 54.61,166.68 60.27,172.34
(no net) on BOTTOM: 290.18,118.25 294.39,118.25 294.71,118.56 294.71,120.99 294.26,121.43 290.76,121.43 290.12,120.79 290.12,118.3
(no net) on BOTTOM: 232.15,196.83 231.89,197.09 231.89,200.52 231.55,200.87 231.55,203.45 231.86,203.76 234.41,203.76 235,203.17 235,197.11 234.72,196.83
(no net) on BOTTOM: 37.72,109.55 37.49,109.32 36.7,109.32 35.7,110.32 35.7,112.36 35.78,112.44 37.5,112.44 37.72,112.21
(no net) on BOTTOM: 222.05,169.27 222.05,166.6 222.14,166.51 223.24,166.51 223.52,166.79 223.52,169.33 223.35,169.5 222.28,169.5
(no net) on BOTTOM: 189.36,94.67 189.61,94.42 197.99,94.42 198.12,94.54 198.12,97.58 196.14,99.56 189.62,99.56 189.36,99.29
(no net) on BOTTOM: 128.31,85.62 134.43,85.62 134.69,85.36 134.69,80.54 134.39,80.24 128.63,80.24 128.26,80.6 128.26,85.57
(no net) on BOTTOM: 133.89,107.51 133.99,107.4 133.99,106.02 133.76,105.78 125.75,105.78 125.39,106.13 125.39,107.21 125.69,107.51
(no net) on BOTTOM: 246.98,201.34 246.98,194.85 247.29,194.55 250.03,194.55 250.17,194.68 250.17,201.15 249.91,201.42 247.05,201.42
(no net) on BOTTOM: 191.14,195.96 191.14,201.45 192.17,202.49 192.17,203.48 191.86,203.79 188.98,203.79 188.85,203.91 188.85,204.47 188.21,205.1 187.96,205.1 187.94,205.08 187.68,205.08 187.66,205.1 187.32,205.1 187.08,204.86 187.08,204.15 187.05,204.12 187.05,198.25 187.11,198.2 188.74,198.2 189.13,197.81 189.13,195.95 189.31,195.77 190.95,195.77
(no net) on BOTTOM: 244.51,66.88 244.51,72.97 244.7,73.16 248.91,73.16 249.08,73 249.08,66.93 248.98,66.84 244.55,66.84
(no net) on BOTTOM: 156.73,52.57 156.73,56.17 152.92,59.98 152.92,71.27 153.07,71.42 154.61,71.42 154.72,71.3 154.72,67.19 155.43,66.48 155.43,63.3 157.75,60.99 157.75,61 162.69,56.05 162.69,47.76 161.98,47.05 155.84,47.05 155.31,47.57 155.31,51.64 156.24,52.57
(no net) on BOTTOM: 182.34,56.33 177.07,61.6 177.07,71.01 177.22,71.16 178.76,71.16 178.88,71.05 178.88,66.93 179.59,66.22 179.59,63.4 181.26,61.72 186.09,61.72 191.27,56.54 191.27,47.76 190.13,46.62 185.65,46.62 185.65,55.48 184.79,56.33
(no net) on BOTTOM: 199.33,133.81 197.66,133.81 195.54,131.69 195.54,126.48 195.75,126.27 201.61,126.27 202.1,126.77 202.1,130.31 199.71,132.69 199.71,133.43
(no net) on BOTTOM: 184.02,205.47 185.72,205.47 186.29,204.9 186.29,195.99 186.06,195.77 183.81,195.77 183.43,196.15 183.43,204.87
(no net) on BOTTOM: 252.32,158.24 256.96,158.24 257.4,158.68 257.4,162.9 257.05,163.25 252.84,163.25 252.03,162.45 252.03,158.52
(no net) on BOTTOM: 144.89,116.31 147.62,116.31 147.72,116.21 147.72,115.16 147.6,115.04 144.95,115.04 144.8,115.19 144.8,116.23
(no net) on BOTTOM: 57.26,106.12 57.07,105.93 50.85,105.93 50.82,105.96 50.82,108.32 51.23,108.73 52.94,108.73 53.59,109.38 57.1,109.38 57.26,109.23
(no net) on BOTTOM: 233.55,109.02 233.4,109.17 232.83,109.17 232.71,109.05 232.71,102.73 230.6,100.62 225.61,100.62 225.19,101.03 225.19,106.48 224.59,107.09 224.59,115.11 224.1,115.59 224.1,119.08 224.23,119.21 233.46,119.21 233.67,119.01 233.67,113.69 234.02,113.34 235.71,113.34 235.84,113.21 235.84,104.63 237.11,103.36 237.11,93.86 236.81,93.55 234.75,93.55 231.95,96.35 231.95,100.7 233.55,102.3
(no net) on BOTTOM: 184.24,111.86 179.89,111.86 179.69,111.66 179.69,110.33 179.83,110.19 184.19,110.19 184.29,110.29 184.29,111.81
(no net) on BOTTOM: 41.4,166.17 41.3,166.07 38.19,166.07 37.66,166.6 37.66,169.46 36.9,170.22 36.9,177.79 36.38,178.31 36.38,180.02 36.82,180.46 40.88,180.46 41.4,179.95
(no net) on BOTTOM: 180.27,64.93 180.27,63.38 180.37,63.29 184.13,63.29 184.31,63.29 184.43,63.41 184.43,64.84 184.89,65.31 184.89,65.8 184.82,65.87 179.98,65.87 179.93,65.82 179.93,65.27
(no net) on BOTTOM: outline of 92 points within 191.32,117.56 250.82,168.09
(no net) on BOTTOM: 265.42,71.31 265.57,71.46 267.11,71.46 267.22,71.35 267.22,67.23 267.93,66.52 267.93,61.89 267.65,61.61 265.72,61.61 265.42,61.92
(no net) on BOTTOM: 192.27,120.47 196.51,120.47 196.7,120.28 196.7,119.57 196.38,119.25 192.39,119.25 192.24,119.4 192.24,120.44
(no net) on BOTTOM: 128.08,186.95 124.8,186.95 124.34,186.48 124.34,183.93 124.61,183.65 133.1,183.65 133.71,184.27 133.71,189.55 133.17,190.1 131.23,190.1
(no net) on BOTTOM: 7.75,90.41 7.75,92.54 7.48,92.8 5.71,92.8 5.4,92.5 5.4,90.39 5.66,90.13 7.47,90.13
(no net) on BOTTOM: 229.49,60.75 229.1,61.14 229.1,71.01 229.25,71.16 230.79,71.16 230.91,71.05 230.91,66.93 231.62,66.22 231.62,61.09 231.27,60.75
(no net) on BOTTOM: 85.6,56.09 85.6,57.44 86.94,58.78 86.94,61.22 87,61.22 87,61.85 88.68,63.53 88.68,70.81 88.72,70.85 90.42,70.85 90.48,70.78 90.48,66.93 91.19,66.22 91.19,62.38 91.19,62.38 91.19,61.14 91.39,60.94 91.39,47.7 90.76,47.07 84.53,47.07 83.5,48.11 83.5,53.99
(no net) on BOTTOM: 191.53,44.79 191.03,45.3 191.03,46.8 191.78,47.56 191.78,56.95 187.14,61.6 187.13,61.6 185.43,63.3 185.25,63.3 185.25,66.06 186.43,67.24 186.43,71.15 186.53,71.25 188.07,71.25 188.25,71.07 188.25,68.35 192.62,63.98 196.02,63.98 198.81,61.19 198.81,56.96 197.77,55.93 197.14,55.93 196.39,55.18 196.39,45.83 195.35,44.79
(no net) on BOTTOM: 196.27,116.69 195.13,117.83 192.43,117.83 192.4,117.86 192.4,118.76 192.56,118.92 195.66,118.92 196.08,118.5 196.85,118.5 197.04,118.69 197.04,119.12 197.24,119.32 198.53,119.32 198.68,119.17 198.68,118.88 198.44,118.5 198.68,118.12 198.68,116.83 198.53,116.69
(no net) on BOTTOM: 82.06,186.94 83.74,186.94 83.93,186.75 83.93,184.97 83.81,184.84 79.62,184.84 79.36,184.59 78.6,184.59 78.47,184.72 78.47,190.44 78.77,190.74 80.75,190.74 80.96,190.54 80.96,189.92 81.81,189.06 81.81,187.47 81.79,187.45 81.79,187.21
(no net) on BOTTOM: 256.1,106.31 256.53,106.74 265.17,106.74 269.56,102.35 269.56,99.93 270.17,99.33 272.23,99.33 272.38,99.18 272.38,97.2 272.23,97.05 265.97,97.05 265.6,97.42 265.6,100.54 264.91,101.24 256.38,101.24 256.1,101.52
(no net) on BOTTOM: 142.32,53.82 140.84,55.3 140.84,71.27 140.99,71.42 142.53,71.42 142.65,71.3 142.65,67.19 143.36,66.48 143.36,63.21 146.32,63.21 148.42,61.11 148.42,47.7 147.79,47.07 141.59,47.07 140.86,47.79 140.86,50.9 142.32,52.37
(no net) on BOTTOM: 191.68,135.99 194.89,135.99 195.14,135.74 195.14,134.83 194.95,134.63 191.39,134.63 191.16,134.4 190.77,134.4 190.51,134.66 190.51,135.05 190.85,135.39 191.4,135.39 191.65,135.64 191.65,135.95
(no net) on BOTTOM: 17.18,40.88 17.25,40.94 17.25,42.45 17.11,42.59 15.94,42.59 15.65,42.3 10.72,42.3 10.58,42.15 10.58,41.04 10.74,40.88
(no net) on BOTTOM: 262.81,145.09 262.97,144.94 264.09,144.94 264.23,145.08 264.23,150.3 264.05,150.48 262.97,150.48 262.81,150.33
(no net) on BOTTOM: 282.37,191 286.81,191 287.3,190.51 288.02,190.51 288.35,190.85 288.35,193.4 288.24,193.51 285.9,193.51 285.83,193.44 285.83,192.6 285.57,192.33 282.54,192.33 282.31,192.11 282.31,191.06
(no net) on BOTTOM: 137.69,110.67 137.46,110.9 137.46,112.9 137.65,113.09 139.48,113.09 139.83,112.75 139.83,101.38 139.62,101.17 138.9,101.17 138.56,100.83 137.94,100.83 137.69,101.09
(no net) on BOTTOM: 1,0.51 0.65,0.65 0.51,1 0.51,208.98 0.65,209.33 1,209.47 38.48,209.47 39.55,209.91 39.99,210.98 39.99,214.83 40.14,215.18 40.48,215.32 312.5,215.32 312.85,215.18 312.99,214.83 312.99,14.06 312.88,14.06 312.17,13.76 311.87,13.05 311.87,10.55 312.17,9.84 312.88,9.54 312.99,9.54 312.99,4.97 312.85,4.62 312.5,4.48 288.55,4.48 288.55,4.11 82.91,4.11 82.56,4.25 82.42,4.6 82.42,10.45 81.97,11.52 80.91,11.96 63.44,11.96 62.65,11.74 62.1,11.14 43.54,11.14 42.47,10.7 42.03,9.63 42.03,1 41.89,0.65 41.54,0.51 ; 35 cut-outs
(no net) on BOTTOM: 134.51,44.79 134,45.3 134,46.8 134.76,47.56 134.76,56.95 133.08,58.63 133.08,61.24 133.08,61.24 133.08,65.81 134.25,66.99 134.25,70.89 134.35,71 135.89,71 136.07,70.82 136.07,63.51 137.31,62.26 138.52,62.26 139.72,61.06 139.72,45.68 138.84,44.79
(no net) on BOTTOM: 161.01,134.75 162.28,134.75 162.41,134.87 162.41,139.91 162.33,139.99 161.05,139.99 160.9,139.84 160.9,134.85
(no net) on BOTTOM: 183.13,112.68 187.92,112.68 188.2,112.96 188.2,114.59 187.87,114.92 183.73,114.92 183.04,114.23 183.04,112.77
(no net) on BOTTOM: 100.75,53.07 100.75,58.51 100.38,58.88 100.38,70.94 100.6,71.16 102.43,71.16 102.55,71.05 102.55,66.93 103.26,66.22 103.26,62.38 103.24,62.38 105.67,59.95 105.67,47.76 104.96,47.05 99.07,47.05 98.38,47.73 98.38,51.34 99.08,52.04 99.71,52.04
(no net) on BOTTOM: 243.36,87.48 244.7,86.15 260.59,86.15 260.77,86.33 260.77,88.81 260.53,89.04 259.34,89.04 258.88,89.51 258.88,93.72 260.83,95.67 264.47,95.67 264.87,96.06 264.87,100.36 264.76,100.46 254.12,100.46 254.07,100.41 248.13,100.41 246.59,98.87 239.7,98.87 239.43,98.6 239.43,89.42 241.37,87.48 ; 1 cut-out
(no net) on BOTTOM: 295.07,117.24 289.73,117.24 288.78,118.19 287.46,118.19 287.29,118.01 287.29,115.11 287.07,114.9 286.5,114.9 286.16,114.56 286.16,113.16 286.17,113.15 294.61,113.15 295.26,113.81 295.26,117.05
(no net) on BOTTOM: 222.85,87.65 223.18,87.99 227.5,87.99 229.29,89.78 232.09,89.78 232.92,88.95 232.92,83.57 233.71,82.77 249.43,82.77 250.37,83.72 253.33,83.72 253.61,83.44 253.61,79.42 253.09,78.89 224.36,78.89 222.85,80.4
(no net) on BOTTOM: 91.86,64.93 91.86,63.38 91.96,63.29 95.72,63.29 95.9,63.29 96.02,63.41 96.02,64.84 96.49,65.31 96.49,65.8 96.41,65.87 91.58,65.87 91.52,65.82 91.52,65.27
(no net) on BOTTOM: 235.7,115.13 237.96,115.13 238.05,115.04 238.05,113.92 237.77,113.64 234.06,113.64 233.85,113.85 233.85,115.55 234.13,115.83 235,115.83
(no net) on BOTTOM: 3.04,89.27 3.04,87.48 3.27,87.26 5.26,87.26 5.49,87.48 5.49,89.27 5.19,89.57 3.33,89.57
(no net) on BOTTOM: 212.8,194.81 212.37,194.39 208.03,194.39 207.92,194.49 207.92,201.95 207.06,202.82 205.1,202.82 204.85,203.07 204.85,204.09 207.26,204.09 207.66,203.7 212.52,203.7 212.8,203.42
(no net) on BOTTOM: 143.1,93.43 143.39,93.13 147.04,93.13 147.64,93.73 147.64,93.84 147.66,93.86 147.66,97.6 147.88,97.82 147.88,100.79 147.57,101.11 143.37,101.11 143.1,100.83
(no net) on BOTTOM: 237.28,61.75 237.28,66.06 238.45,67.24 238.45,71.15 238.56,71.25 240.1,71.25 240.27,71.07 240.27,61.93 239.75,61.41 237.62,61.41
(no net) on BOTTOM: 265.67,119.57 263.15,119.57 262.79,119.2 262.79,117.82 262.6,117.63 257.26,117.63 257.06,117.83 257.06,122.33 256.14,123.25 254.28,123.25 254.14,123.39 254.14,130.38 254.37,130.61 259,130.61 259.17,130.45 259.17,127.09 259.4,126.86 259.56,126.86 260.28,126.14 264.28,126.14 265.71,124.7 265.71,119.61
(no net) on BOTTOM: 193.34,117.17 191.39,117.17 191.25,117.04 191.26,117.02 191.26,115.08 191.36,114.98 193.03,114.98 193.37,115.32 193.37,117.14
(no net) on BOTTOM: 193.16,121.12 190.26,121.12 190.08,121.3 190.08,122.06 190.23,122.2 193.07,122.2 193.24,122.03 193.24,121.2
(no net) on BOTTOM: 46.94,37.51 40.4,37.51 40.2,37.31 40.2,34.4 40.47,34.13 46.81,34.13 47.06,34.38 47.06,37.38
(no net) on BOTTOM: 249.34,62.58 249.34,66.06 250.52,67.24 250.52,71.15 250.62,71.25 252.16,71.25 252.34,71.07 252.34,63.87 252.36,63.85 252.36,62.57 252.09,62.3 249.62,62.3
(no net) on BOTTOM: 192.58,136.61 190.62,136.61 190.52,136.71 190.52,137.98 190.67,138.14 192.5,138.14 192.64,137.99 192.64,136.68 192.58,136.61
(no net) on BOTTOM: 274.33,61.69 273.6,62.42 273.6,65.98 274.77,67.16 274.77,71.06 274.87,71.17 276.41,71.17 276.59,70.99 276.59,62 276.28,61.69
(no net) on BOTTOM: 260.98,85.59 255.85,85.59 255.44,85.18 255.44,79.95 257.14,78.25 270.19,78.25 273.98,82.05 273.98,87.16 273.34,87.81 261.65,87.81 261.38,87.54 261.38,86
(no net) on BOTTOM: 241.17,62.23 241.17,71.01 241.32,71.16 242.86,71.16 242.97,71.05 242.97,66.93 243.68,66.22 243.68,62.23 243.41,61.96 241.44,61.96
