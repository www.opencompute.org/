# Allegro board T99O089T00_025_20180609.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
P1V25 on BOTTOM (solid shape): 266.35,111.44 266.38,111.42 266.45,111.39 266.52,111.37 266.59,111.35 266.66,111.35 266.74,111.35 266.81,111.35 266.88,111.37 266.95,111.39 267.02,111.42 267.05,111.44 271.6,111.44 271.92,111.11 271.92,107.7 271.76,107.54 264.52,107.54 264.14,107.92 264.14,110.8 266.37,110.8 266.37,110.74 266.38,110.68 266.39,110.63 266.42,110.57 266.45,110.52 266.48,110.47 266.52,110.43 266.57,110.39 266.62,110.36 266.68,110.34 266.74,110.32 266.8,110.32 266.86,110.32 266.92,110.32 266.97,110.34 267.03,110.36 267.08,110.39 267.13,110.43 267.17,110.47 267.21,110.52 267.24,110.57 267.26,110.63 267.28,110.68 267.28,110.74 267.28,110.8 267.28,110.86 267.26,110.92 267.24,110.98 267.21,111.03 267.17,111.08 267.13,111.12 267.08,111.15 267.03,111.18 266.97,111.21 266.92,111.22 266.86,111.23 266.8,111.23 266.74,111.22 266.68,111.21 266.62,111.18 266.57,111.15 266.52,111.12 266.48,111.08 266.45,111.03 266.42,110.98 266.39,110.92 266.38,110.86 266.37,110.8 264.14,110.8 264.14,111.22 264.35,111.44
P1V25 on BOTTOM (solid shape): outline of 423 points within 222.85,78.89 253.61,89.78
P1V25 on T07 (solid shape): outline of 2525 points within 251.66,82.26 296.55,118.11
P1V25_AGND on TOP (solid shape): 286.5,123.38 286.5,123.13 286.82,122.81 287.3,122.81 287.32,122.79 287.32,121.56 287.15,121.39 286.54,121.39 285.82,122.11 285.82,122.22 285.85,122.22 285.85,122.78 285.82,122.78 285.82,123.42 285.96,123.57 286.31,123.57
P1V25_SW on TOP (solid shape): 285.42,118.87 285.6,118.87 285.69,118.79 285.69,118.22 284.91,117.44 280.1,117.44 279.78,117.75 279.78,120.58 279.91,120.71 283.58,120.71
P1V25_VIN on TOP (solid shape): 295.9,121.21 295.9,118.73 295.41,118.25 288.91,118.25 288.77,118.39 288.77,119.42 288.82,119.47 289.01,119.47 290.25,120.72 290.29,120.7 290.78,120.74 290.95,121.21 290.95,121.21 290.95,121.39 295.72,121.39
P1V25_VIN on BOTTOM (solid shape): 294.71,120.99 294.71,118.56 294.39,118.25 290.18,118.25 290.12,118.3 290.12,120.36 290.17,120.44 290.26,120.45 290.98,120.6 291.17,121.3 291.19,121.39 291.27,121.43 294.26,121.43
P1V26_BMC on TOP (solid shape): 75.04,149.86 75.04,146.17 73.46,144.6 73.46,139.78 73.35,139.67 70.98,139.67 70.77,139.88 70.77,149.24 71.64,150.11 74.78,150.11
P1V26_BMC on BOTTOM (solid shape): 73.44,148.26 73.44,140.32 73.26,140.14 71.29,140.14 70.79,140.64 70.79,141.78 69.58,142.99 69.58,148.3 69.86,148.58 73.11,148.58
P1V26_BMC on T05 (solid shape): outline of 1876 points within 58.25,107.83 68.52,118.04
P1V26_BMC on T16 (solid shape): outline of 9654 points within 35.79,102.29 74.55,142.66
P1V26_BMC_SW on TOP (solid shape): 79.53,149.57 79.53,142.74 79.56,142.72 79.56,141.5 79.16,141.5 79.16,142.8 79.16,142.85 79.15,142.9 79.15,142.95 79.12,142.97 79.03,143.11 78.89,143.2 78.5,143.6 78.02,143.6 77.98,143.63 77.98,144.55 77.98,145.18 76.76,146.4 76.76,149.74 76.86,149.84 79.26,149.84
P1V26_BMC_VIN on TOP (solid shape): 81.92,150.29 81.92,144.5 81.92,143.94 81.92,143.51 81.92,142.97 81.89,142.95 80.04,142.95 79.91,143.07 79.91,150.42 79.96,150.47 81.74,150.47
P1V538_BMC on TOP (solid shape): 59.01,149.52 59.01,143.94 57.44,142.37 57.44,136.06 57.41,136.04 55.24,136.04 54.92,136.36 54.92,144.06 55.58,144.72 55.58,149.32 55.85,149.59 58.94,149.59
P1V538_BMC on BOTTOM (solid shape): 37.72,112.21 37.72,109.55 37.49,109.32 36.7,109.32 35.7,110.32 35.7,112.36 35.78,112.44 37.5,112.44
P1V538_BMC on BOTTOM (solid shape): 57.41,142.86 57.41,136.43 57.1,136.12 54.57,136.12 54.26,136.43 54.26,142.76 54.46,142.97 57.3,142.97
P1V538_BMC on T16 (solid shape): outline of 8296 points within 35.94,109.36 62,141.52
P1V538_BMC_SW on TOP (solid shape): 63.54,149.57 63.54,142.73 63.53,142.72 63.53,141.5 63.14,141.5 63.14,142.11 63.13,142.16 63.13,142.21 63.13,142.96 62.49,143.6 62,143.6 61.96,143.63 61.96,144.55 61.96,144.83 60.74,146.05 60.74,149.45 60.89,149.6 63.52,149.6
P1V538_BMC_VIN on TOP (solid shape): 65.89,150.29 65.89,144.5 65.89,143.94 65.89,143.51 65.89,142.97 65.86,142.94 64,142.94 63.89,143.05 63.89,150.42 63.94,150.47 65.72,150.47
P2V5 on TOP (solid shape): outline of 383 points within 194.83,125.26 262.55,206.87
P2V5 on BOTTOM (solid shape): 225.04,201.15 225.04,194.29 224.95,194.2 221.64,194.2 221.24,194.6 221.24,201.16 221.49,201.41 224.78,201.41
P2V5 on BOTTOM (solid shape): outline of 439 points within 191.32,117.56 250.82,168.09
P2V5_SW on TOP (solid shape): 229.87,206.21 229.87,205.35 230.04,205.18 231.41,205.18 231.52,205.07 231.52,204.63 231.44,204.55 230.23,204.55 229,203.32 227,203.32 226.94,203.38 226.94,206.79 226.99,206.84 229.25,206.84
P2V5_VIN on TOP (solid shape): 232.11,204.13 232.11,202.93 232.11,202.93 232.11,202.71 232.29,202.54 232.98,202.54 234.12,201.39 234.12,196.83 234.02,196.73 232.01,196.73 231.89,196.84 231.89,200.52 231.55,200.87 231.55,202.4 231.71,202.56 231.71,204.11 231.73,204.13 232.11,204.13
P2V5_VIN on BOTTOM (solid shape): 235,203.17 235,201.64 234.97,201.56 234.89,201.54 234.41,201.08 234.89,200.62 234.97,200.6 235,200.52 235,197.11 234.72,196.83 232.15,196.83 231.89,197.09 231.89,200.52 231.55,200.87 231.55,203.45 231.86,203.76 234.41,203.76
P2V5_VREF on TOP (solid shape): 72.33,133.45 72.33,131.7 71.78,131.15 71.46,131.15 71.37,131.19 71.36,131.29 71.39,131.52 71.3,131.74 71.28,131.81 71.31,131.88 71.03,132.66 70.63,131.93 70.65,131.86 70.62,131.79 70.49,131.56 70.51,131.29 70.5,131.19 70.42,131.15 69.27,131.15 69.13,131.29 69.13,134.64 69.22,134.73 71.04,134.73
P2V5_VREF on P10 (solid shape): outline of 701 points within 106.33,128.83 111.88,137.12
P3V3 on TOP (solid shape): 5.27,99.69 5.27,94.33 5.05,94.11 3.47,94.11 3.29,94.28 3.29,99.6 3.56,99.87 5.1,99.87
P3V3 on TOP (solid shape): 9.08,105.31 9.08,103.77 8.95,103.64 3.26,103.64 3.13,103.76 3.13,105.21 3.37,105.45 8.95,105.45
P3V3 on TOP (solid shape): 39.71,55.26 39.71,54.89 39.09,54.27 36.2,54.27 36.04,54.43 36.04,55.24 36.18,55.38 39.6,55.38
P3V3 on TOP (solid shape): 76.91,48.49 76.91,47.93 76.76,47.78 73.29,47.78 73.19,47.87 73.19,48.54 73.31,48.67 76.73,48.67
P3V3 on TOP (solid shape): 102.27,139.72 102.27,138.04 102.2,137.98 100.28,137.98 100.21,138.04 100.21,139.36 100.74,139.89 102.11,139.89
P3V3 on TOP (solid shape): 143.78,132.36 143.78,131.19 143.64,131.05 140.55,131.05 140.42,131.17 140.42,132.32 140.64,132.53 143.61,132.53
P3V3 on TOP (solid shape): 149.89,142.11 149.89,139.88 149.84,139.82 148.18,139.82 148.07,139.94 148.07,142.46 148.24,142.63 149.38,142.63
P3V3 on TOP (solid shape): 162.55,83.21 162.55,82.39 162.21,82.05 160.24,82.05 160.1,82.19 160.1,83.14 160.24,83.28 162.49,83.28
P3V3 on TOP (solid shape): 169.33,99.24 169.33,98.11 169.13,97.91 166.32,97.91 166.29,97.94 166.29,99.2 166.44,99.36 169.22,99.36
P3V3 on TOP (solid shape): 101.29,84.47 101.29,82.17 101.22,82.1 99.34,82.1 99.15,82.29 99.15,82.96 99.67,83.48 99.67,84.37 99.84,84.54 101.23,84.54
P3V3 on TOP (solid shape): 18.93,167 18.93,155.23 19.21,154.95 19.21,151.5 18.83,151.11 11.25,151.11 10.72,151.64 10.72,167.05 10.92,167.26 18.68,167.26
P3V3 on TOP (solid shape): 45.09,153.38 45.09,140.81 45.37,140.53 45.37,137.03 45.34,137 38.13,137 37.74,137.4 37.74,153.59 37.96,153.81 44.66,153.81
P3V3 on TOP (solid shape): 91.62,76.34 91.62,75.83 91.59,75.8 90.53,75.8 89.22,74.49 88.75,74.49 88.57,74.67 88.57,76 88.95,76.38 89.51,76.38 91.58,76.38
P3V3 on TOP (solid shape): 207.86,76.42 207.86,75.83 207.8,75.78 206.39,75.78 206.13,75.53 206.13,74.29 205.88,74.04 205.29,74.04 205.1,74.22 205.1,76.25 205.23,76.38 205.79,76.38 206.22,76.38 206.3,76.46 207.81,76.46
P3V3 on TOP (solid shape): 306.56,93.3 306.56,91.76 306.55,91.76 306.55,91.2 306.56,91.2 306.56,89.88 306.43,89.75 306.43,88.75 306.41,88.73 305.73,88.73 305.69,88.77 305.69,89.83 304.62,90.89 304.62,93.27 304.88,93.53 306.33,93.53
P3V3 on TOP (solid shape): 154.27,113.43 154.27,113.37 154.2,113.14 154.27,112.91 154.27,112.19 154.08,112 152.34,112 152.09,112.26 152.09,113.41 152.19,113.51 154.19,113.51
P3V3 on TOP (solid shape): 270.72,76.48 270.8,76.47 271.11,76.47 271.12,76.46 271.12,75.88 271.07,75.82 269.49,75.82 269.16,75.49 269.16,74.26 269.03,74.13 268.5,74.13 268.37,74.27 268.37,76.3 268.58,76.51 270.63,76.51
P3V3 on TOP (solid shape): 32.71,106.13 32.71,104.98 32.39,104.66 32.37,104.66 32.19,104.58 32.05,104.43 31.62,104.43 31.62,104.44 31.57,104.44 31.57,104.43 27.27,104.43 27.24,104.46 27.24,106.12 27.41,106.29 32.55,106.29
P3V3 on TOP (solid shape): 115.17,139.16 115.17,137.82 114.74,137.38 114.74,137.24 114.73,137.16 114.74,137.08 114.74,136.58 114.71,136.55 114.15,136.55 113.31,136.55 112.99,136.87 112.99,137.86 112.71,138.14 111.52,138.14 111.36,138.29 111.36,139.09 111.55,139.28 115.05,139.28
P3V3 on TOP (solid shape): 103.25,76.44 103.33,76.43 103.65,76.43 103.65,76.42 103.65,75.83 103.6,75.78 102.18,75.78 102.18,75.78 102.02,75.78 101.7,75.47 99.8,75.47 99.65,75.62 99.65,76.15 99.87,76.38 101.03,76.38 101.58,76.38 102.01,76.38 102.09,76.46 103.16,76.46
P3V3 on TOP (solid shape): 167.5,76.44 167.58,76.43 167.9,76.43 167.91,76.42 167.91,75.83 167.85,75.78 166.43,75.78 166.43,75.78 166.27,75.78 165.96,75.47 164.05,75.47 163.9,75.62 163.9,76.15 164.13,76.38 165.28,76.38 165.84,76.38 166.27,76.38 166.35,76.46 167.41,76.46
P3V3 on TOP (solid shape): 179.58,76.44 179.66,76.43 179.97,76.43 179.98,76.42 179.98,75.83 179.93,75.78 178.51,75.78 178.51,75.78 178.34,75.78 178.03,75.47 176.13,75.47 175.98,75.62 175.98,76.15 176.2,76.38 177.35,76.38 177.91,76.38 178.34,76.38 178.42,76.46 179.49,76.46
P3V3 on TOP (solid shape): 243.68,76.44 243.76,76.43 244.08,76.43 244.09,76.42 244.09,75.83 244.04,75.78 242.62,75.78 242.37,75.53 242.37,74.57 242.24,74.45 240.97,74.45 240.82,74.6 240.82,76 241.2,76.38 242.02,76.38 242.45,76.38 242.53,76.46 243.59,76.46
P3V3 on TOP (solid shape): 140.77,76.38 141.68,76.38 142.11,76.38 142.19,76.46 143.26,76.46 143.34,76.44 143.43,76.43 143.74,76.43 143.75,76.42 143.75,75.83 143.7,75.78 142.28,75.78 142.28,75.78 142.11,75.78 141.8,75.47 139.47,75.47 139.32,75.62 139.32,76.71 139.52,76.91 140.24,76.91
P3V3 on TOP (solid shape): 155.42,76.44 155.5,76.43 155.82,76.43 155.83,76.42 155.83,75.83 155.78,75.78 154.36,75.78 154.35,75.78 154.19,75.78 153.79,75.38 153.79,74.5 153.61,74.32 152.41,74.32 152.24,74.5 152.24,76.24 152.39,76.38 153.2,76.38 153.76,76.38 154.19,76.38 154.27,76.46 155.33,76.46
P3V3 on TOP (solid shape): 124.92,76.13 125.18,76.13 125.74,76.13 126.17,76.13 126.25,76.21 127.31,76.21 127.4,76.18 127.48,76.17 127.8,76.17 127.81,76.16 127.81,75.58 127.76,75.53 126.34,75.53 126.33,75.52 126.17,75.52 125.86,75.21 123.37,75.21 123.22,75.36 123.22,76.25 123.47,76.51 124.54,76.51
P3V3 on TOP (solid shape): 115.73,76.16 115.73,75.58 115.68,75.53 114.26,75.53 114.26,75.52 114.09,75.52 113.78,75.21 113.45,75.21 113.16,75.32 112.87,75.21 111.88,75.21 111.72,75.36 111.72,75.9 111.95,76.13 113.1,76.13 113.66,76.13 114.09,76.13 114.17,76.21 115.69,76.21
P3V3 on TOP (solid shape): 219.53,76.44 219.61,76.43 219.93,76.43 219.93,76.42 219.93,75.83 219.88,75.78 218.46,75.78 218.21,75.53 218.21,75.35 218.21,75.34 218.18,75.19 218.21,75.03 218.21,75.02 218.21,74.29 217.96,74.04 217.37,74.04 217.18,74.22 217.18,76.25 217.31,76.38 217.86,76.38 218.29,76.38 218.37,76.46 219.44,76.46
P3V3 on TOP (solid shape): 231.6,76.44 231.69,76.43 232,76.43 232.01,76.42 232.01,75.83 231.96,75.78 230.54,75.78 230.29,75.53 230.29,75.38 230.29,75.37 230.25,75.19 230.29,75 230.29,74.99 230.29,74.29 230.04,74.04 229.44,74.04 229.26,74.22 229.26,76.25 229.38,76.38 229.94,76.38 230.37,76.38 230.45,76.46 231.52,76.46
P3V3 on TOP (solid shape): 255.84,76.48 255.93,76.47 256.24,76.47 256.25,76.46 256.25,75.88 256.2,75.82 254.78,75.82 254.66,75.71 254.65,75.7 254.4,75.57 254.27,75.32 254.26,75.31 253.99,75.04 252.88,75.04 252.7,75.21 252.7,76.28 252.85,76.42 253.62,76.42 254.18,76.42 254.61,76.42 254.69,76.51 255.76,76.51
P3V3 on TOP (solid shape): 121.69,150.14 121.69,148.26 121.65,148.17 121.57,148.16 120.99,147.72 121.57,147.28 121.65,147.26 121.69,147.18 121.69,146.95 121.57,146.83 119.62,146.83 119.29,147.16 119.29,150.18 119.49,150.37 121.46,150.37
P3V3 on BOTTOM (solid shape): 12.04,44.33 12.04,43.01 11.98,42.95 9.05,42.95 8.97,43.03 8.97,44.33 9.17,44.53 11.84,44.53
P3V3 on BOTTOM (solid shape): 71.22,136.49 71.22,133.77 71.16,133.71 69.06,133.71 68.96,133.81 68.96,136.23 69.48,136.75 70.97,136.75
P3V3 on BOTTOM (solid shape): 108.55,117.57 108.55,116.05 108.32,115.83 106.48,115.83 106.26,116.05 106.26,117.47 106.39,117.6 108.52,117.6
P3V3 on BOTTOM (solid shape): 134.29,119.67 134.29,117.86 134.27,117.84 133.02,117.84 132.92,117.94 132.92,119.66 133.02,119.77 134.2,119.77
P3V3 on BOTTOM (solid shape): 147.72,116.21 147.72,115.16 147.6,115.04 144.95,115.04 144.8,115.19 144.8,116.23 144.89,116.31 147.62,116.31
P3V3 on BOTTOM (solid shape): 184.29,111.81 184.29,110.29 184.19,110.19 179.83,110.19 179.69,110.33 179.69,111.66 179.89,111.86 184.24,111.86
P3V3 on BOTTOM (solid shape): 281.87,82.41 281.87,80.3 281.63,80.05 280.03,80.05 279.9,80.18 279.9,82.51 280.02,82.64 281.64,82.64
P3V3 on BOTTOM (solid shape): 285.09,190.33 285.09,188.36 284.93,188.2 283.93,188.2 283.67,188.46 283.67,190.17 283.87,190.37 285.05,190.37
P3V3 on BOTTOM (solid shape): 310.95,41.17 310.95,38.56 309.23,36.84 309.03,36.84 308.92,36.94 308.92,41.22 308.99,41.29 310.83,41.29
P3V3 on BOTTOM (solid shape): 18.93,167 18.93,151.57 18.48,151.11 11.25,151.11 10.7,151.66 10.7,167.04 10.92,167.26 18.68,167.26
P3V3 on BOTTOM (solid shape): 33.97,103.31 33.97,100.05 33.89,99.97 30.91,99.97 30.89,99.99 30.89,101.28 31.37,101.76 31.37,103.49 31.42,103.54 33.74,103.54
P3V3 on BOTTOM (solid shape): 45.09,147.91 45.09,137.31 44.77,136.99 37.89,136.99 37.33,137.55 37.33,147.56 37.77,147.99 45.01,147.99
P3V3 on BOTTOM (solid shape): 8.49,103.37 8.49,100.38 8.32,100.21 4.39,100.21 4.17,100.43 4.17,101.87 4.35,102.05 6.39,102.05 6.61,102.28 6.61,103.25 6.77,103.41 8.44,103.41
P3V3 on BOTTOM (solid shape): 168.8,124.76 168.8,124.25 168.67,124.12 168.67,123.33 168.36,123.02 164.92,123.02 164.49,123.45 164.49,124.9 164.56,124.97 165.43,124.97 168.58,124.97
P3V3 on T05 (solid shape): outline of 2321 points within 156.29,131.65 185.31,160.51
P3V3 on T05 (solid shape): outline of 3717 points within 259.47,181.1 288.67,199.45
P3V3 on P09 (solid shape): outline of 16250 points within 2.66,5.97 312.44,214.31
P3V3 on P12 (solid shape): 303.37,98.88 303.37,98.86 303.5,98.55 303.81,98.41 303.83,98.41 307.77,94.47 307.77,91.94 307.74,91.93 307.39,91.48 307.74,91.04 307.77,91.03 307.77,77.66 303.36,73.25 298.2,73.25 297.93,73.34 297.66,73.25 269.01,73.25 268.37,73.89 268.37,76.38 270.95,78.96 270.95,83.62 270.99,83.63 271.35,84.07 270.99,84.52 270.95,84.53 270.95,97.18 271.73,97.96 272.36,97.97 272.37,98.61 274.53,100.76 301.49,100.76
P3V3 on T14 (solid shape): outline of 16866 points within 260.27,106.15 299.49,183.4
P3V3 on TOP: 160.1,83.14 160.24,83.28 162.49,83.28 162.55,83.21 162.55,82.39 162.2,82.04 160.25,82.04 160.1,82.19
P3V3_BMC on TOP (solid shape): 58.49,187.31 58.49,185.69 58.26,185.46 56.75,185.46 56.47,185.74 56.47,187.22 56.65,187.39 58.4,187.39
P3V3_BMC on TOP (solid shape): 68.74,150.33 68.74,148.99 68.52,148.78 66.68,148.78 66.65,148.8 66.65,150.3 66.92,150.57 68.5,150.57
P3V3_BMC on TOP (solid shape): 84.64,150.22 84.64,148.96 84.4,148.71 82.72,148.71 82.66,148.77 82.66,150.24 82.84,150.42 84.44,150.42
P3V3_BMC on BOTTOM (solid shape): 58.49,187.31 58.49,185.69 58.26,185.46 56.75,185.46 56.47,185.74 56.47,187.22 56.65,187.39 58.4,187.39
P3V3_BMC on BOTTOM (solid shape): outline of 1731 points within 105.12,195.14 144.09,208.8
P3V3_BMC on T03 (solid shape): outline of 1199 points within 84.07,139.32 105.57,150.36
P3V3_BMC on P12 (solid shape): 90.04,151.97 90.04,135.76 89.97,135.51 90.04,135.26 90.04,126.62 89.84,126.24 90.04,125.86 90.04,99.13 89.91,98.87 89.97,98.57 89.99,98.54 89.55,98.1 79.27,98.1 78.96,97.8 78.96,81.25 77.72,80.01 76.15,80.01 76.14,80.05 75.69,80.4 75.25,80.05 75.24,80.01 71.79,80.01 71.37,80.27 70.96,80.01 64.08,80.01 63.75,80.15 63.43,80.01 59,80.01 58.99,80.05 58.54,80.46 58.08,80.05 58.08,80.01 55.98,80.01 55.7,80.11 55.41,80.01 54.99,80.01 54.68,80.13 54.38,80.01 53.85,80.01 53.84,80.04 53.41,80.34 52.98,80.04 52.97,80.01 44.07,80.01 43.69,80.21 43.31,80.01 41.34,80.01 41.32,80.04 40.89,80.34 40.47,80.04 40.45,80.01 32.89,80.01 31.95,80.95 31.95,87.4 36.4,91.84 36.4,104.03 36.44,104.04 36.79,104.49 36.44,104.93 36.4,104.94 36.4,132.77 41.2,132.77 41.21,132.73 41.66,132.38 42.1,132.73 42.11,132.77 51.31,132.77 51.31,152.1 51.54,152.32 89.69,152.32
P3V3_BMC on T16 (solid shape): outline of 8125 points within 39.59,145.03 109.86,201.68
P3V3_BMC_L2 on TOP (solid shape): 67.81,196.71 67.81,195.22 67.66,195.06 63.54,195.06 63.51,195.03 63.4,195.03 63.29,195.04 63.18,195.02 61.64,195.02 61.55,195.02 61.46,194.99 61.1,194.99 61.1,195.29 62.35,195.29 62.35,196.18 63.03,196.87 67.65,196.87
P3V3_BMC_L3 on TOP (solid shape): 61.37,194.28 61.5,194.21 61.64,194.19 63.07,194.19 63.23,194.13 63.4,194.14 63.42,194.14 63.85,193.71 67.72,193.71 67.84,193.58 67.84,191.9 67.71,191.76 63.49,191.76 62.48,192.78 62.48,193.53 62.18,193.83 61.19,193.83 61.13,193.89 61.13,194.28
P3V3_BMC_VIN on TOP (solid shape): 63.63,201.5 63.63,201.49 63.63,200.66 63.64,200.66 63.64,197.92 63.27,197.55 62.81,197.55 62.04,196.79 62.04,195.8 61.31,195.8 61.23,195.88 61.23,201.12 61.71,201.59 63.63,201.59
P3V3_BMC_VIN on BOTTOM (solid shape): 63.64,197.55 63.97,197.22 63.97,197.03 63.96,197.03 63.96,196.47 63.97,196.47 63.97,195.73 63.9,195.65 62.78,195.65 62.78,195.66 61.87,195.66 61.87,195.65 60.55,195.65 60.22,195.98 60.22,196.01 60.24,196.05 60.27,196.07 60.99,196.74 60.32,197.46 60.25,197.49 60.22,197.56 60.22,201.4 60.43,201.61 63.64,201.61
P3V3_BMC_VOUT on TOP (solid shape): 62.04,192.68 63.62,191.1 64.32,191.1 64.61,190.82 64.61,186.93 64.44,186.76 62.4,186.76 61.29,185.65 59.34,185.65 59.18,185.81 59.18,186.77 59.17,186.77 59.17,188 59.31,188.14 60.89,188.14 61.07,188.31 61.07,192.77 61.12,192.82 61.16,192.82 61.16,192.86 61.18,192.88 61.18,193.34 61.28,193.44 62.04,193.44
P3V3_BMC_VOUT on BOTTOM (solid shape): 64.63,192.58 64.63,189.47 64.99,189.12 64.99,188.03 64.63,187.67 63.49,187.67 61.76,185.95 59.35,185.95 59.18,186.11 59.18,188.02 59.38,188.22 61.08,188.22 61.84,188.98 61.84,192.37 63.59,192.37 63.85,192.63 64.58,192.63
P3V3_FAN on TOP (solid shape): 288.33,195.02 288.33,193.06 288.1,192.83 285.98,192.83 285.87,192.95 285.87,195.17 285.92,195.22 288.13,195.22
P3V3_FAN on BOTTOM (solid shape): 288.35,193.4 288.35,190.85 288.02,190.51 287.3,190.51 286.81,191 282.37,191 282.31,191.06 282.31,192.11 282.54,192.33 285.57,192.33 285.83,192.6 285.83,193.44 285.9,193.51 288.24,193.51
P3V3_HWM on TOP (solid shape): 123.14,207.22 123.14,203.91 120.65,201.41 120.65,200.86 119.82,200.03 119.82,199.65 119.8,199.65 119.8,199.27 119.73,199.14 119.71,199 119.71,198.47 119.03,198.47 118.97,198.53 118.97,198.77 119.03,198.88 119.05,199.01 119.05,199.85 118.85,200.05 118.85,203.64 119.29,204.08 119.92,204.08 119.99,204.15 119.99,204.23 119.9,204.31 105.35,204.31 105.2,204.45 105.2,207.83 105.37,208 122.36,208
P3V3_HWM on T07 (solid shape): outline of 2633 points within 107.93,182.51 127.31,201.82
P3V3_OCXO on TOP (solid shape): 19.2,148.35 19.2,147.8 19.33,147.67 20.51,147.67 20.54,147.64 20.54,145.72 20.64,145.62 21.2,145.62 21.23,145.58 21.23,144.66 21.19,144.62 19.28,144.62 18.55,145.35 14.06,145.35 13.85,145.55 13.85,148.16 14.14,148.45 19.1,148.45
P3V3_OCXO on BOTTOM (solid shape): 19.85,148.32 19.85,145.5 19.71,145.35 15.43,145.35 14.75,144.67 14.75,141.98 15.68,141.05 17.59,141.05 17.66,140.98 17.66,137.99 17.63,137.96 15.92,137.96 15.74,138.14 15.74,139.03 15.5,139.27 12.83,139.27 12.61,139.48 12.61,147.88 13.18,148.45 19.73,148.45
P3V3_QSFP1 on TOP (solid shape): 307.72,84.63 307.72,83.49 308,83.21 308.43,83.21 308.52,83.14 308.62,83.09 308.62,82.59 308.62,82.59 308.62,76.62 308.51,76.5 304.8,76.5 304.71,76.59 304.71,81.38 305.94,82.61 305.94,84.51 306.2,84.76 307.59,84.76
P3V3_QSFP1 on BOTTOM (solid shape): 307.72,84.63 307.72,83.49 308.62,82.59 308.62,76.77 308.35,76.5 304.8,76.5 304.71,76.59 304.71,81.12 305.94,82.35 305.94,84.51 306.2,84.76 307.59,84.76
P3V3_QSFP2 on TOP (solid shape): 305.18,84.63 305.18,82.73 303.93,81.47 299.59,81.47 299.45,81.33 299.44,81.33 299.32,81.2 299.32,76.3 299.15,76.13 295.74,76.13 295.52,76.36 295.52,80.13 295.53,80.13 295.53,80.69 295.52,80.69 295.52,81.66 296.3,82.44 299.32,82.44 299.94,83.07 303.29,83.07 303.67,83.45 303.67,84.6 303.83,84.76 305.05,84.76
P3V3_QSFP2 on BOTTOM (solid shape): 304.54,84.76 304.82,84.65 305.11,84.67 305.14,84.68 305.18,84.63 305.18,82.73 303.78,81.33 299.44,81.33 299.32,81.2 299.32,76.3 299.15,76.13 295.74,76.13 295.52,76.36 295.52,82.64 295.96,83.08 303.31,83.08 303.66,83.43 303.66,84.59 303.83,84.76
P3V3_SFP00 on TOP (solid shape): 96.57,73 96.57,66.68 96.4,66.51 92.11,66.51 92,66.63 92,72.97 92.19,73.16 96.4,73.16
P3V3_SFP01 on BOTTOM (solid shape): 92.91,73.16 93.01,73.09 92.97,72.98 93.35,71.69 93.73,72.98 93.69,73.09 93.79,73.16 96.4,73.16 96.57,73 96.57,66.93 96.47,66.84 92.04,66.84 92,66.88 92,72.97 92.19,73.16
P3V3_SFP02 on TOP (solid shape): 108.65,73 108.65,66.93 108.55,66.84 104.11,66.84 104.07,66.88 104.07,72.97 104.27,73.16 108.48,73.16
P3V3_SFP03 on BOTTOM (solid shape): 104.52,73.16 104.6,73.12 104.62,73.03 105.06,72.44 105.49,73.03 105.51,73.12 105.59,73.16 108.48,73.16 108.65,73 108.65,66.93 108.55,66.84 104.11,66.84 104.07,66.88 104.07,72.97 104.27,73.16
P3V3_SFP04 on TOP (solid shape): 120.72,72.59 120.72,66.68 120.63,66.58 116.19,66.58 116.15,66.62 116.15,72.6 116.33,72.78 120.53,72.78
P3V3_SFP05 on BOTTOM (solid shape): 120.72,72.9 120.72,66.68 120.63,66.58 116.19,66.58 116.15,66.62 116.15,72.72 116.34,72.91 116.71,72.91 116.79,72.87 116.81,72.78 117.25,72.21 117.69,72.78 117.71,72.87 117.79,72.91 119.1,72.91 119.19,73 120.62,73
P3V3_SFP06 on TOP (solid shape): 132.8,72.74 132.8,66.68 132.7,66.58 128.27,66.58 128.23,66.62 128.23,72.72 128.42,72.91 132.63,72.91
P3V3_SFP07 on BOTTOM (solid shape): 130.12,72.91 130.2,72.86 130.21,72.76 130.61,72.09 131.01,72.76 131.02,72.86 131.1,72.91 132.63,72.91 132.8,72.74 132.8,66.68 132.7,66.58 128.27,66.58 128.23,66.62 128.23,71.6 128.32,71.6 128.86,72.11 128.32,72.62 128.23,72.62 128.23,72.72 128.42,72.91
P3V3_SFP08 on TOP (solid shape): 148.74,73 148.74,66.93 148.65,66.84 144.21,66.84 144.17,66.88 144.17,72.97 144.37,73.16 148.58,73.16
P3V3_SFP09 on BOTTOM (solid shape): 146.66,73.16 146.75,73.12 146.76,73.02 147.17,72.37 147.58,73.02 147.59,73.12 147.68,73.16 148.58,73.16 148.74,73 148.74,66.93 148.65,66.84 144.21,66.84 144.17,66.88 144.17,72.97 144.37,73.16
P3V3_SFP10 on TOP (solid shape): 160.82,73 160.82,66.93 160.72,66.84 156.29,66.84 156.25,66.88 156.25,72.97 156.44,73.16 160.65,73.16
P3V3_SFP11 on BOTTOM (solid shape): 157.21,73.16 157.29,73.12 157.3,73.02 157.71,72.37 158.13,73.02 158.13,73.12 158.22,73.16 160.65,73.16 160.82,73 160.82,66.93 160.72,66.84 156.29,66.84 156.25,66.88 156.25,71.86 156.34,71.86 156.89,72.37 156.34,72.88 156.25,72.88 156.25,72.97 156.44,73.16
P3V3_SFP12 on TOP (solid shape): 172.9,73 172.9,66.93 172.8,66.84 168.37,66.84 168.33,66.88 168.33,72.97 168.52,73.16 172.73,73.16
P3V3_SFP13 on BOTTOM (solid shape): 172.9,73 172.9,72.88 172.8,72.88 172.33,72.62 172.35,72.08 172.36,71.99 172.29,71.92 171.99,71.25 172.72,71.16 172.83,71.19 172.9,71.09 172.9,66.93 172.8,66.84 168.37,66.84 168.33,66.88 168.33,72.97 168.52,73.16 172.73,73.16
P3V3_SFP14 on TOP (solid shape): 184.97,73 184.97,66.93 184.88,66.84 180.44,66.84 180.4,66.88 180.4,72.97 180.6,73.16 184.81,73.16
P3V3_SFP15 on BOTTOM (solid shape): outline of 115 points within 180.4,66.84 184.97,73.16
P3V3_SFP16 on TOP (solid shape): 212.85,73 212.85,66.93 212.75,66.84 208.32,66.84 208.28,66.88 208.28,72.97 208.47,73.16 212.68,73.16
P3V3_SFP17 on BOTTOM (solid shape): 212.85,73 212.85,66.93 212.75,66.84 208.32,66.84 208.28,66.88 208.28,72.37 209.8,72.37 209.8,72.31 209.81,72.25 209.83,72.19 209.85,72.14 209.88,72.09 209.92,72.04 209.96,72 210.01,71.96 210.06,71.93 210.11,71.91 210.17,71.89 210.23,71.89 210.29,71.89 210.35,71.89 210.41,71.91 210.46,71.93 210.52,71.96 210.56,72 210.61,72.04 210.64,72.09 210.67,72.14 210.7,72.19 210.71,72.25 210.72,72.31 210.72,72.37 210.71,72.43 210.7,72.49 210.67,72.54 210.64,72.6 210.61,72.64 210.56,72.69 210.52,72.72 210.46,72.75 210.41,72.78 210.35,72.79 210.29,72.8 210.23,72.8 210.17,72.79 210.11,72.78 210.06,72.75 210.01,72.72 209.96,72.69 209.92,72.64 209.88,72.6 209.85,72.54 209.83,72.49 209.81,72.43 209.8,72.37 208.28,72.37 208.28,72.97 208.47,73.16 212.68,73.16
P3V3_SFP18 on TOP (solid shape): 224.93,73 224.93,66.93 224.83,66.84 220.39,66.84 220.35,66.88 220.35,72.97 220.55,73.16 224.76,73.16
P3V3_SFP19 on BOTTOM (solid shape): 224.93,73 224.93,66.93 224.83,66.84 220.39,66.84 220.35,66.88 220.35,72.34 221.07,72.34 221.07,72.27 221.08,72.19 221.1,72.12 221.13,72.05 221.16,71.99 221.21,71.93 221.25,71.87 221.31,71.82 221.37,71.77 221.43,71.73 221.5,71.7 221.57,71.67 221.64,71.65 221.71,71.64 221.79,71.64 221.86,71.65 221.93,71.66 222,71.68 222.07,71.71 222.14,71.75 222.2,71.79 222.26,71.84 222.31,71.9 222.35,71.96 222.39,72.02 222.42,72.09 222.44,72.16 222.46,72.23 222.47,72.31 222.47,72.38 222.46,72.45 222.44,72.53 222.42,72.6 222.39,72.66 222.35,72.73 222.31,72.79 222.26,72.84 222.2,72.89 222.14,72.94 222.07,72.97 222,73 221.93,73.02 221.86,73.04 221.79,73.04 221.71,73.04 221.64,73.03 221.57,73.01 221.5,72.99 221.43,72.95 221.37,72.91 221.31,72.87 221.25,72.82 221.21,72.76 221.16,72.7 221.13,72.63 221.1,72.56 221.08,72.49 221.07,72.42 221.07,72.34 220.35,72.34 220.35,72.97 220.55,73.16 224.76,73.16
P3V3_SFP20 on TOP (solid shape): 237,73 237,66.93 236.91,66.84 232.47,66.84 232.43,66.88 232.43,72.97 232.62,73.16 236.84,73.16
P3V3_SFP21 on BOTTOM (solid shape): 237,73 237,66.93 236.91,66.84 232.47,66.84 232.43,66.88 232.43,72.14 233.36,72.14 233.37,72.06 233.38,71.99 233.4,71.92 233.42,71.85 233.46,71.78 233.5,71.72 233.55,71.66 233.6,71.61 233.66,71.56 233.72,71.52 233.79,71.49 233.86,71.47 233.93,71.45 234.01,71.44 234.08,71.44 234.15,71.44 234.23,71.46 234.3,71.48 234.37,71.51 234.43,71.54 234.49,71.59 234.55,71.63 234.6,71.69 234.64,71.75 234.68,71.81 234.71,71.88 234.74,71.95 234.75,72.02 234.76,72.1 234.76,72.17 234.75,72.25 234.74,72.32 234.71,72.39 234.68,72.46 234.64,72.52 234.6,72.58 234.55,72.64 234.49,72.69 234.43,72.73 234.37,72.77 234.3,72.79 234.23,72.82 234.15,72.83 234.08,72.84 234.01,72.83 233.93,72.82 233.86,72.81 233.79,72.78 233.72,72.75 233.66,72.71 233.6,72.66 233.55,72.61 233.5,72.55 233.46,72.49 233.42,72.43 233.4,72.36 233.38,72.28 233.37,72.21 233.36,72.14 232.43,72.14 232.43,72.97 232.62,73.16 236.84,73.16
P3V3_SFP22 on TOP (solid shape): 249.08,73.14 249.08,73 249.08,73 249.08,66.93 248.98,66.84 244.55,66.84 244.51,66.88 244.51,73.16 244.66,73.31 248.91,73.31
P3V3_SFP23 on BOTTOM (solid shape): 249.08,73 249.08,66.93 248.98,66.84 244.55,66.84 244.51,66.88 244.51,71.06 244.56,71.14 244.66,71.14 245.36,71.53 244.66,71.92 244.56,71.91 244.51,72 244.51,72.97 244.7,73.16 248.91,73.16
P3V3_SFP24 on TOP (solid shape): 261.24,73.04 261.24,66.98 261.15,66.88 256.71,66.88 256.67,66.92 256.67,73.02 256.87,73.21 261.08,73.21
P3V3_SFP25 on BOTTOM (solid shape): 258.78,73.21 258.86,73.17 258.88,73.07 259.54,72.15 260.2,73.07 260.21,73.17 260.3,73.21 261.08,73.21 261.24,73.04 261.24,66.98 261.15,66.88 256.71,66.88 256.67,66.92 256.67,73.02 256.87,73.21
P3V3_SFP26 on TOP (solid shape): 269.62,73.55 269.63,73.52 269.66,73.47 269.7,73.43 269.74,73.38 269.79,73.35 269.85,73.32 269.9,73.3 269.96,73.28 270.02,73.27 270.08,73.27 270.14,73.28 270.2,73.3 270.26,73.32 270.31,73.35 270.36,73.38 270.41,73.43 270.44,73.47 270.48,73.52 270.49,73.55 273.26,73.55 273.32,73.49 273.32,66.98 273.22,66.88 268.79,66.88 268.75,66.92 268.75,72.17 271.96,72.17 271.96,72.11 271.97,72.05 271.98,71.99 272,71.93 272.03,71.88 272.07,71.83 272.11,71.79 272.16,71.76 272.21,71.73 272.27,71.7 272.33,71.69 272.39,71.68 272.44,71.68 272.5,71.69 272.56,71.7 272.62,71.73 272.67,71.76 272.72,71.79 272.76,71.83 272.8,71.88 272.83,71.93 272.85,71.99 272.86,72.05 272.87,72.11 272.87,72.17 272.86,72.23 272.85,72.28 272.83,72.34 272.8,72.39 272.76,72.44 272.72,72.48 272.67,72.52 272.62,72.55 272.56,72.57 272.5,72.59 272.44,72.59 272.39,72.59 272.33,72.59 272.27,72.57 272.21,72.55 272.16,72.52 272.11,72.48 272.07,72.44 272.03,72.39 272,72.34 271.98,72.28 271.97,72.23 271.96,72.17 268.75,72.17 268.75,73.34 268.96,73.55
P3V3_SFP27 on BOTTOM (solid shape): 269.39,73.53 270.05,73.06 270.71,73.53 270.72,73.56 271.89,73.56 271.97,73.52 271.98,73.43 272.42,72.82 272.85,73.43 272.86,73.52 272.94,73.56 273.21,73.56 273.25,73.54 273.32,73.47 273.32,66.98 273.22,66.88 268.79,66.88 268.75,66.92 268.75,73.33 268.98,73.56 269.38,73.56
P3V3_STB on TOP (solid shape): 95.2,127.22 95.2,123.05 94.92,122.78 92.32,122.78 91.91,123.19 91.91,127.21 92.24,127.53 94.88,127.53
P3V3_STB on TOP (solid shape): 145.06,139.22 145.06,136.27 144.95,136.16 141.16,136.16 140.95,136.36 140.95,138.31 141.51,138.87 142.56,138.87 143.03,139.34 144.95,139.34
P3V3_STB on TOP (solid shape): 107.41,211.98 107.41,209.66 107.21,209.47 107.21,209.47 107.1,209.37 101.6,209.37 101.36,209.13 101.36,207.89 100.94,207.47 99.48,207.47 99.41,207.54 99.41,211.13 99.59,211.31 101.08,211.31 101.1,211.33 104.68,211.33 105.37,212.02 107.37,212.02
P3V3_STB on BOTTOM (solid shape): 282.34,190.37 283.33,190.37 283.35,190.35 283.35,189.4 283.17,189.22 281.52,189.22 281.38,189.35 281.38,190.36 281.57,190.55 282.15,190.55
P3V3_STB on BOTTOM (solid shape): outline of 235 points within 124.34,183.65 133.71,190.1
P3V3_STB on T05 (solid shape): outline of 870 points within 124.54,171.32 227.37,193.82
P3V3_STB on T05 (solid shape): outline of 1223 points within 50.71,54.41 81.03,68.45
P3V3_STB on T05 (solid shape): outline of 1530 points within 78.44,170.62 94.54,185.43
P3V3_STB on T05 (solid shape): outline of 2354 points within 194.67,103.93 208.39,108.06
P3V3_STB on T05 (solid shape): outline of 2614 points within 96.02,180.56 131.52,211.36
P3V3_STB on T07 (solid shape): outline of 3239 points within 34.6,191.1 60.16,204.07
P3V3_STB on P09 (solid shape): 128.44,197.15 128.85,196.9 129.26,197.15 130.9,197.15 131.02,197.03 131.02,196.2 130.96,196.14 130.07,196.14 129.44,195.51 129.44,189.87 130.11,189.19 133.56,189.19 134.08,188.67 134.08,186.44 134.04,186.43 133.72,185.99 134.04,185.55 134.08,185.54 134.08,185.42 133.19,184.54 125.09,184.54 124.12,185.5 124.12,185.53 123.99,185.9 123.62,186.03 123.6,186.03 120.78,188.84 109.49,188.84 108.56,189.78 108.56,194.57 111.13,197.15
P3V3_STB on P10 (solid shape): outline of 23757 points within 40.27,77.86 155.45,163.75
P3V3_STB on T14 (solid shape): outline of 4195 points within 96.06,163.17 112.86,195.73
P3V3_STB on T16 (solid shape): outline of 709 points within 225.87,185.2 282.22,190.62
P3V3_STB on T16 (solid shape): outline of 2828 points within 85.35,175.46 103.61,190.87
P3V3_STB on T18 (solid shape): outline of 1137 points within 43.2,67.52 52,90.08
P3V3_STB on T18 (solid shape): outline of 2980 points within 48.15,186.26 105.12,211.75
P3V3_SW on TOP (solid shape): 42.81,161.09 42.81,155.89 42.61,155.68 37.92,155.68 37.56,156.04 37.56,161.4 37.59,161.43 42.47,161.43
P3V3_SW2 on TOP (solid shape): 14.65,173.74 17.14,173.74 17.65,173.24 17.65,169.54 17.19,169.08 11.55,169.08 11.4,169.23 11.4,173.72 11.43,173.75 14.65,173.75
P3V3_VIN on TOP (solid shape): 41.4,179.92 41.4,166.36 40.92,165.88 39.75,165.88 39.55,165.68 37.52,165.68 37.52,166.81 37.57,166.93 37.59,167.05 37.59,168.33 37.59,168.33 37.59,168.38 37.92,168.71 37.92,169.93 37.82,170.03 36.85,170.03 36.85,171.62 36.47,172 36.07,172 36.07,172.72 36.07,172.72 36.07,179.99 36.36,180.29 41.03,180.29
P3V3_VIN on BOTTOM (solid shape): 41.4,179.95 41.4,168.24 41.35,168.24 41.35,167.32 41.4,167.32 41.4,166.71 41.38,166.71 41.38,166.15 41.3,166.07 38.19,166.07 37.66,166.6 37.66,169.46 36.9,170.22 36.9,177.79 36.38,178.31 36.38,180.02 36.82,180.46 40.88,180.46
P3V3_VIN2 on TOP (solid shape): 15.24,192.19 15.24,178.68 14.75,178.2 13.59,178.2 13.41,178.02 11.4,178.02 11.36,178.07 11.36,180.3 11.86,180.8 11.86,182.2 11.71,182.35 10.64,182.35 10.57,182.42 10.57,184.06 10.31,184.32 10.31,184.32 10.19,184.44 10.19,192.23 10.46,192.51 14.92,192.51
P3V3_VIN2 on BOTTOM (solid shape): 15.24,192.35 15.24,180.55 15.19,180.55 15.19,179.64 15.24,179.64 15.24,178.49 15.14,178.39 11.71,178.39 11.27,178.83 11.27,181.71 10.74,182.24 10.74,190.11 10.22,190.63 10.22,192.43 10.51,192.71 14.87,192.71
P5V0 on TOP (solid shape): 78.2,191.97 78.2,190.68 78.04,190.51 75.77,190.51 75.67,190.61 75.67,192.13 75.76,192.22 77.95,192.22
P5V0 on BOTTOM (solid shape): 36.71,88.02 36.71,86.65 36.5,86.44 34.72,86.44 34.56,86.6 34.56,87.93 34.82,88.2 36.53,88.2
P5V0 on BOTTOM (solid shape): 54.34,170.07 54.34,168.77 54.14,168.57 51.72,168.57 51.6,168.7 51.6,170.1 51.76,170.26 54.15,170.26
P5V0 on BOTTOM (solid shape): 78.2,191.97 78.2,190.68 78.04,190.51 75.77,190.51 75.67,190.61 75.67,192.13 75.76,192.22 77.95,192.22
P5V0 on BOTTOM (solid shape): 57.19,61.8 57.19,51.29 57.32,51.16 57.32,49.87 57.28,49.82 55.51,49.82 55.29,50.04 55.29,61.71 55.57,61.98 57.01,61.98
P5V0 on BOTTOM (solid shape): 9.73,28.9 9.73,28.27 9.97,28.03 10.71,28.03 10.93,27.81 10.93,26.82 10.76,26.65 8.63,26.65 8.61,26.67 8.61,29.03 8.65,29.07 9.56,29.07
P5V0 on P10 (solid shape): outline of 910 points within 9.42,26.59 56.35,58.55
P5V0 on T16 (solid shape): outline of 430 points within 34.76,61.41 57.41,88.25
P5V0 on T16 (solid shape): outline of 867 points within 51.6,168.3 78.21,192.15
P5V0_SW on TOP (solid shape): 79.79,206.97 79.79,206.11 79.96,205.94 81.33,205.94 81.44,205.83 81.44,205.38 81.37,205.32 80.15,205.32 78.92,204.08 76.92,204.08 76.86,204.15 76.86,207.55 76.9,207.6 79.17,207.6
P5V0_SW on BOTTOM (solid shape): 80.95,206.56 80.95,203.99 80.52,203.55 77.99,203.55 77.56,203.98 77.56,206.64 77.82,206.9 80.62,206.9
P5V0_USB on TOP (solid shape): 60.8,48.15 60.8,45.84 60.67,45.71 55.32,45.71 55.21,45.83 55.21,48.12 55.33,48.24 55.53,48.24 55.53,48.25 60.7,48.25
P5V0_USB on BOTTOM (solid shape): 57.35,48.17 57.35,45.76 57.2,45.6 55.44,45.6 55.14,45.91 55.14,48.02 55.32,48.2 57.31,48.2
P5V0_VIN on TOP (solid shape): 82.03,204.89 82.03,203.69 82.03,203.69 82.03,203.47 82.21,203.3 82.36,203.3 83.4,202.26 83.45,202.2 83.5,202.16 85.86,199.8 85.86,197.81 85.55,197.49 81.93,197.49 81.81,197.6 81.81,201.28 81.47,201.63 81.47,203.17 81.63,203.33 81.63,204.87 81.65,204.89 82.03,204.89
P5V0_VIN on BOTTOM (solid shape): 83.31,202.54 83.31,202.52 83.45,202.2 83.76,202.07 83.78,202.07 84.23,201.63 84.23,201.61 84.34,201.38 84.55,201.25 84.57,201.25 85.46,200.35 85.46,197.05 85.26,196.84 82.02,196.84 81.81,197.05 81.81,201.28 81.47,201.63 81.47,202.68 81.62,202.83 83.02,202.83
P5V0_VOUT on TOP (solid shape): 74.96,206.8 74.96,190.53 74.68,190.25 71.37,190.25 70.84,190.78 70.84,207.4 71.07,207.63 74.13,207.63
P5V0_VOUT on BOTTOM (solid shape): 74.96,201.91 74.96,193.75 74.93,193.75 74.93,190.7 73.51,190.7 72.14,192.07 72.14,201.91 72.4,202.17 74.7,202.17
P5V_SB on TOP (solid shape): 69.16,211.97 69.16,202.68 66.93,200.45 64.43,200.45 64.3,200.57 64.3,206.52 64.39,206.6 64.69,206.6 64.74,206.55 64.74,204.75 64.92,204.57 66.09,204.57 66.32,204.8 66.32,212.27 66.42,212.37 68.76,212.37
P5V_SB on TOP (solid shape): 96.43,206.03 96.43,205.57 96.72,205.29 97.8,205.29 97.85,205.24 97.85,204.21 97.91,204.14 99.32,204.14 99.43,204.25 99.43,205.23 99.45,205.25 104.08,205.25 104.2,205.12 104.2,203.89 105.86,202.24 110.24,202.24 111.82,200.66 111.82,198.35 111.81,198.35 111.81,197.45 111.71,197.35 110.4,197.35 110.14,197.61 110.14,200.32 109.68,200.78 105.37,200.78 103.28,202.87 97.46,202.87 96.13,204.19 94.93,204.19 94.71,204.41 94.71,205.92 94.95,206.15 96.31,206.15
P5V_SB on TOP (solid shape): 31.98,149.01 31.98,145.17 31.96,145.15 27.6,145.15 27.6,145.2 26.69,145.2 26.69,145.15 25.9,145.15 25.26,144.51 23.65,144.51 23.65,145.67 23.96,145.67 23.97,145.68 24.05,145.68 24.09,145.72 24.24,145.72 24.24,145.87 24.27,145.9 24.27,147.74 25.72,147.74 25.73,147.75 25.75,147.75 26.24,148.24 25.7,148.66 25.69,148.66 24.27,148.66 24.27,149.21 31.78,149.21
P5V_SB on BOTTOM (solid shape): 32.01,148.18 32.01,145.27 31.91,145.17 26.73,145.17 26.56,145.34 26.56,147.09 26.74,147.26 28.03,147.26 29.21,148.45 31.74,148.45
P5V_SB on BOTTOM (solid shape): 69.22,209.29 69.22,202.42 67.25,200.45 64.43,200.45 64.3,200.57 64.3,203.06 66.32,205.08 66.32,209.46 66.45,209.59 68.92,209.59
P5V_SB on T16 (solid shape): outline of 6001 points within 25.4,146.63 98.42,209.55
P5V_SB_IN on TOP (solid shape): outline of 191 points within 21.84,197.1 66.04,212.34
P5V_SB_IN on BOTTOM (solid shape): 65.23,210.15 65.23,207.01 64.97,206.76 62.28,206.76 62.28,206.76 59.69,206.76 59.19,207.26 59.19,210.31 59.48,210.61 64.77,210.61
P5V_SB_IN on T03 (solid shape): outline of 1720 points within 21.8,194.97 63.6,210.13
P10V_H2_SW on TOP (solid shape): 75.49,184.71 75.49,183.69 74.3,182.5 74.3,181.27 73.87,180.85 70.08,180.85 69.89,181.04 69.89,182.98 70.14,183.23 72.83,183.23 74.45,184.85 75.35,184.85
P10V_H2_VIN on TOP (solid shape): 81.83,189.14 81.83,187.2 82.09,186.94 83.74,186.94 83.93,186.75 83.93,184.97 83.81,184.84 78.32,184.84 78.32,184.87 76.03,184.87 75.93,184.97 75.93,185.1 78.35,185.1 78.47,185.22 78.47,186.25 78.51,186.28 78.73,186.28 79.76,187.31 79.96,187.51 80.02,187.78 80.02,188.47 80,188.64 79.94,188.79 79.94,189.05 79.97,189.13 80.25,189.41 81.55,189.41
P10V_H2_VIN on BOTTOM (solid shape): 80.96,190.54 80.96,189.92 81.81,189.06 81.81,187.47 81.79,187.45 81.79,187.21 82.06,186.94 83.74,186.94 83.93,186.75 83.93,184.97 83.81,184.84 79.62,184.84 79.36,184.59 78.6,184.59 78.47,184.72 78.47,188.66 78.5,188.73 78.57,188.77 78.8,188.83 78.96,189 79.05,189.06 79.14,189.01 79.98,189.26 79.12,189.47 79.04,189.42 78.95,189.46 78.79,189.62 78.57,189.68 78.5,189.71 78.47,189.78 78.47,190.44 78.77,190.74 80.75,190.74
P12V on TOP (solid shape): 9.64,207.53 9.64,185.65 9.53,185.54 3.76,185.54 3.3,186 3.3,207.57 3.65,207.91 9.26,207.91
P12V on TOP (solid shape): 198.81,196.31 198.81,194.74 198.56,194.49 196.21,194.49 196.09,194.6 196.09,196.32 196.33,196.56 198.57,196.56
P12V on TOP (solid shape): 216.08,195.86 216.08,193.99 215.87,193.78 213.94,193.78 213.66,194.06 213.66,196.02 213.82,196.17 215.77,196.17
P12V on TOP (solid shape): 235.26,195.95 235.26,194.57 235.01,194.31 232.41,194.31 232.09,194.62 232.09,195.99 232.26,196.15 235.07,196.15
P12V on TOP (solid shape): 253.66,196.31 253.66,194.74 253.4,194.49 251.05,194.49 250.93,194.6 250.93,196.32 251.17,196.56 253.41,196.56
P12V on TOP (solid shape): 296,124.8 296,122.45 295.88,122.33 294.34,122.33 294.27,122.4 294.27,124.94 294.39,125.05 295.75,125.05
P12V on TOP (solid shape): 309.2,189.48 309.2,185.75 309.02,185.56 293.39,185.56 292.65,186.29 292.65,189.4 293.18,189.93 308.75,189.93
P12V on TOP (solid shape): 84.31,190.97 84.31,187.51 84.19,187.38 82.55,187.38 82.49,187.45 82.49,188.95 81.39,190.04 81.39,191.03 81.62,191.26 84.03,191.26
P12V on TOP (solid shape): 37.72,188.27 37.72,182.68 35.81,180.77 35.81,172.92 28.46,172.92 27.94,173.43 27.94,181.52 32.46,186.04 32.46,188.36 32.87,188.78 37.21,188.78
P12V on TOP (solid shape): 311.15,183.08 311.15,144.67 311,144.52 307.96,144.52 307.85,144.64 307.85,173.84 305.44,176.25 297.08,176.25 296.67,176.66 296.67,183.23 297.18,183.74 310.49,183.74
P12V on TOP (solid shape): 172.72,202.37 174.62,202.37 175.01,201.99 175.01,197.92 174.75,197.67 169.42,197.67 165.11,201.98 165.11,204.54 163.9,205.75 151.66,205.75 151.49,205.92 151.49,208.22 152.11,208.84 166.25,208.84
P12V on TOP (solid shape): outline of 361 points within 48.08,153.97 66.57,168.37
P12V on BOTTOM (solid shape): 9.65,192.39 9.65,185.24 3.81,185.24 3.3,185.74 3.3,192.37 3.6,192.67 9.37,192.67
P12V on BOTTOM (solid shape): 235.16,195.87 235.16,194.75 235,194.59 232.33,194.59 232.17,194.75 232.17,195.97 232.3,196.1 234.93,196.1
P12V on BOTTOM (solid shape): 84.31,190.97 84.31,187.51 84.19,187.38 82.61,187.38 82.55,187.44 82.55,189.01 81.39,190.17 81.39,191.03 81.62,191.26 84.03,191.26
P12V on BOTTOM (solid shape): 37.72,188.27 37.72,182.68 35.81,180.77 35.81,173.31 35.42,172.92 29.69,172.92 28.83,173.77 28.83,181.94 32.79,185.89 32.79,188.18 33.38,188.78 37.21,188.78
P12V on BOTTOM (solid shape): 311.12,183.07 311.12,144.75 310.81,144.43 308.22,144.43 307.85,144.81 307.85,173.84 305.53,176.16 295.78,176.16 295.34,176.59 295.34,183.43 295.67,183.76 310.44,183.76
P12V on BOTTOM (solid shape): 173.3,202.28 175.61,202.28 177.3,200.59 177.3,197.07 176.19,195.95 166.78,195.95 165.27,197.46 165.27,204.37 163.9,205.75 151.66,205.75 151.49,205.92 151.49,208.22 152.11,208.84 166.73,208.84
P12V on P10 (solid shape): outline of 103991 points within 3.32,123.37 310.47,212.87
P12V on P12 (solid shape): outline of 1193 points within 1.7,112.98 312.18,214.31
VDD_CORE on TOP (solid shape): 288.8,170.11 288.8,147.12 288.03,146.36 269.72,146.36 268.84,147.24 268.84,160.82 271.02,160.82 271.02,155.65 272.18,154.49 272.31,154.49 272.35,154.47 272.41,154.44 272.47,154.42 272.53,154.41 272.59,154.41 272.65,154.41 272.71,154.43 272.77,154.45 272.83,154.47 272.85,154.49 273.64,154.49 273.64,154.44 274.2,154.44 274.2,154.49 283.31,154.49 284.48,155.65 284.48,160.82 283.57,161.73 274.06,161.73 274.06,161.91 273.15,161.91 273.15,161.73 271.93,161.73 271.02,160.82 268.84,160.82 268.84,170.26 269.33,170.74 288.16,170.74
VDD_CORE on TOP (solid shape): outline of 95 points within 234.42,99.26 246.42,115.12
VDD_CORE on TOP (solid shape): outline of 122 points within 187.25,99.48 193.65,113.23
VDD_CORE on BOTTOM (solid shape): 288.8,170.11 288.8,147.12 288.03,146.36 269.72,146.36 268.84,147.24 268.84,160.82 271.02,160.82 271.02,155.65 272.18,154.49 272.31,154.49 272.35,154.47 272.41,154.44 272.47,154.42 272.53,154.41 272.59,154.41 272.65,154.41 272.71,154.43 272.77,154.45 272.83,154.47 272.85,154.49 283.31,154.49 284.48,155.65 284.48,160.82 283.57,161.73 271.93,161.73 271.02,160.82 268.84,160.82 268.84,170.26 269.33,170.74 288.16,170.74
VDD_CORE on P09 (solid shape): outline of 680 points within 184.66,93.85 289.81,182.05
VDD_CORE on P12 (solid shape): 224.19,127.49 224.19,113.54 223.8,113.15 204.67,113.15 204.51,113.32 204.51,128.44 204.73,128.65 223.03,128.65
VDD_CORE_SW1 on TOP (solid shape): 297.89,169.93 297.89,165.04 295.72,162.87 292.68,162.87 292.29,163.25 292.29,169.34 292.71,169.76 296.92,169.76 297.21,170.04 297.78,170.04
VDD_CORE_SW2 on TOP (solid shape): 294.72,154.21 294.77,154.21 297.41,154.21 297.45,154.21 297.5,154.22 297.77,154.22 297.83,154.16 297.83,149.05 296.03,147.25 296.03,147.25 295.91,147.12 292.86,147.12 292.35,147.63 292.35,153.85 292.72,154.22 294.68,154.22
VDD_CORE_VIN1 on TOP (solid shape): 304.22,169.43 305.6,169.43 306.96,168.08 306.96,159.89 306.45,159.38 302.51,159.38 302.26,159.64 302.26,164.34 301.89,164.7 301.89,169.78 302.01,169.9 303.76,169.9
VDD_CORE_VIN1 on BOTTOM (solid shape): 306.96,168.2 306.96,160.33 306.79,160.16 305.09,160.16 305.08,160.15 302.79,160.15 302.67,160.27 302.67,168.81 302.64,168.84 302.88,169.08 306.08,169.08
VDD_CORE_VIN2 on TOP (solid shape): 304.46,153.63 305.9,153.63 306.95,152.58 306.95,144.83 306.96,144.82 306.96,144.53 306.2,143.76 302.64,143.76 302.39,144.02 302.39,147.59 302.39,147.59 302.39,148.5 302.39,148.5 302.39,148.72 301.92,149.18 301.92,149.52 301.89,149.52 301.89,154.1 303.99,154.1
VDD_CORE_VIN2 on BOTTOM (solid shape): 306.97,152.61 306.97,144.02 306.71,143.76 302.81,143.76 302.64,143.93 302.64,153.34 302.79,153.49 306.09,153.49
VDD_CORE_VREF on T07 (solid shape): outline of 2323 points within 280.67,131.12 297.05,143.82
(no net) on TOP: 140.77,76.38 142.11,76.38 142.19,76.46 143.71,76.46 143.75,76.42 143.75,75.83 143.7,75.78 142.28,75.78 142.28,75.78 142.11,75.78 141.8,75.47 139.47,75.47 139.32,75.62 139.32,76.71 139.52,76.91 140.24,76.91
(no net) on TOP: 227,203.32 226.94,203.38 226.94,206.79 226.99,206.84 229.25,206.84 229.87,206.21 229.87,205.35 230.04,205.18 231.41,205.18 231.52,205.07 231.52,204.63 231.44,204.55 230.23,204.55 229,203.32
(no net) on TOP: 208.9,203.57 208.84,203.64 208.84,207.04 208.89,207.09 211.15,207.09 211.77,206.47 211.77,205.6 211.94,205.43 213.31,205.43 213.42,205.33 213.42,204.84 213.38,204.81 212.13,204.81 210.9,203.57
(no net) on TOP: 308.36,190.85 308.65,191.14 308.65,194.48 308.21,194.91 302.73,194.91 302.34,194.53 302.34,191.05 302.54,190.85
(no net) on TOP: 48.41,36.41 48.41,34.37 48.52,34.25 50.95,34.25 51.33,34.63 51.33,36.51 51.29,36.54 48.53,36.54
(no net) on TOP: 99.65,75.62 99.65,76.15 99.87,76.38 102.01,76.38 102.09,76.46 103.61,76.46 103.65,76.42 103.65,75.83 103.6,75.78 102.18,75.78 102.18,75.78 102.02,75.78 101.7,75.47 99.8,75.47
(no net) on TOP: 111.72,75.36 111.72,75.9 111.95,76.13 114.09,76.13 114.17,76.21 115.69,76.21 115.73,76.16 115.73,75.58 115.68,75.53 114.26,75.53 114.26,75.52 114.09,75.52 113.78,75.21 111.88,75.21
(no net) on TOP: 119.62,146.83 121.57,146.83 121.69,146.95 121.69,150.14 121.46,150.37 119.49,150.37 119.29,150.18 119.29,147.16
(no net) on TOP: 261.52,63.24 261.52,65.98 262.69,67.16 262.69,71.06 262.8,71.17 264.34,71.17 264.51,70.99 264.51,63.77 263.95,63.21 261.55,63.21
(no net) on TOP: 165,63.5 165,71.01 165.15,71.16 166.69,71.16 166.8,71.05 166.8,66.93 167.51,66.22 167.51,63.39 167.38,63.26 165.23,63.26
(no net) on TOP: 88.95,76.38 91.58,76.38 91.62,76.34 91.62,75.83 91.59,75.8 90.53,75.8 89.22,74.49 88.75,74.49 88.57,74.67 88.57,76
(no net) on TOP: 149.84,139.82 148.18,139.82 148.07,139.94 148.07,142.46 148.24,142.63 149.38,142.63 149.89,142.11 149.89,139.88
(no net) on TOP: 251.19,167.86 248.56,167.86 248.2,167.49 248.2,158.71 248.8,158.1 254.07,158.1 254.37,158.41 254.37,161.7 254.11,161.96 252.22,161.96 251.52,162.66 251.52,167.53
(no net) on TOP: 196.09,194.6 196.21,194.49 198.56,194.49 198.81,194.74 198.81,196.31 198.57,196.56 196.33,196.56 196.09,196.32
(no net) on TOP: 240.45,112.33 240.65,112.53 240.65,114.65 241.12,115.12 245.94,115.12 246.17,114.88 246.17,110.26 246.42,110.01 246.42,99.44 246.23,99.26 235.08,99.26 234.42,99.91 234.42,111.77 234.99,112.33
(no net) on TOP: 79.15,142.95 79.15,141.5 79.56,141.5 79.56,142.72 79.53,142.74 79.53,149.57 79.26,149.84 76.86,149.84 76.76,149.74 76.76,146.4 77.98,145.18 77.98,143.63 78.02,143.6 78.5,143.6
(no net) on TOP: 152.92,63.64 152.92,71.27 153.07,71.42 154.61,71.42 154.72,71.3 154.72,67.19 155.43,66.48 155.43,63.55 155.24,63.36 153.2,63.36
(no net) on TOP: 253.99,75.04 252.88,75.04 252.7,75.21 252.7,76.28 252.85,76.42 254.61,76.42 254.69,76.51 256.21,76.51 256.25,76.46 256.25,75.88 256.2,75.82 254.78,75.82
(no net) on TOP: 187.13,196.05 186.36,195.28 184.36,195.28 183.26,194.18 183.26,180.75 183.82,180.19 189.2,180.19 189.52,180.51 189.52,195.55 188.85,196.21 188.85,197.68 188.67,197.86 187.37,197.86 187.13,197.62
(no net) on TOP: 71.07,207.63 70.84,207.4 70.84,190.78 71.37,190.25 74.68,190.25 74.96,190.53 74.96,206.8 74.13,207.63
(no net) on TOP: 100.75,63.39 100.75,71.01 100.9,71.16 102.43,71.16 102.55,71.05 102.55,66.93 103.26,66.22 103.26,63.3 103.07,63.11 101.03,63.11
(no net) on TOP: 144.95,139.34 143.03,139.34 142.56,138.87 141.51,138.87 140.95,138.31 140.95,136.36 141.16,136.16 144.95,136.16 145.06,136.27 145.06,139.22
(no net) on TOP: 204.95,63.64 204.95,71.27 205.1,71.42 206.64,71.42 206.75,71.3 206.75,67.19 207.46,66.48 207.46,63.55 207.27,63.36 205.23,63.36
(no net) on TOP: 57.44,136.06 57.44,142.37 59.01,143.94 59.01,149.52 58.94,149.59 55.85,149.59 55.58,149.32 55.58,144.72 54.92,144.06 54.92,136.36 55.24,136.04 57.41,136.04
(no net) on TOP: 112.82,63.24 112.82,70.76 112.97,70.91 114.51,70.91 114.63,70.79 114.63,66.68 115.34,65.97 115.34,63.14 115.21,63.01 113.06,63.01
(no net) on TOP: 301.89,169.78 302.01,169.9 303.76,169.9 304.22,169.43 305.6,169.43 306.96,168.08 306.96,159.89 306.45,159.38 302.51,159.38 302.26,159.64 302.26,164.34 301.89,164.7
(no net) on TOP: 141.34,130.36 141.48,130.23 141.48,129.15 141.3,128.96 137.37,128.96 137.29,129.05 137.29,130.24 137.41,130.36
(no net) on TOP: 3.26,103.64 3.13,103.76 3.13,105.21 3.37,105.45 8.95,105.45 9.08,105.31 9.08,103.77 8.95,103.64
(no net) on TOP: 295.52,81.66 295.52,76.36 295.74,76.13 299.15,76.13 299.32,76.3 299.32,81.2 299.44,81.33 299.45,81.33 299.59,81.47 303.93,81.47 305.18,82.73 305.18,84.63 305.05,84.76 303.83,84.76 303.67,84.6 303.67,83.45 303.29,83.07 299.94,83.07 299.32,82.44 296.3,82.44
(no net) on TOP: 53.47,212.85 64.26,212.85 64.77,212.34 64.77,210.82 64.52,210.57 55.2,210.57 55.01,210.75 53.26,210.75 53.24,210.77 53.24,212.62
(no net) on TOP: 242.37,75.53 242.37,74.57 242.24,74.45 240.97,74.45 240.82,74.6 240.82,76 241.2,76.38 242.45,76.38 242.53,76.46 244.05,76.46 244.09,76.42 244.09,75.83 244.04,75.78 242.62,75.78
(no net) on TOP: 194.61,207.16 192.75,205.3 192.15,205.3 191.34,206.12 191.34,211.74 191.62,212.03 194.39,212.03 194.61,211.81
(no net) on TOP: 266.69,139.65 266.57,139.53 266.57,123.27 266.68,123.17 267.23,123.17 267.54,122.86 267.54,118.29 267.78,118.05 269.97,118.05 270.07,118.14 270.07,139.52 269.94,139.65
(no net) on TOP: 307.85,144.64 307.85,173.84 305.44,176.25 297.08,176.25 296.67,176.66 296.67,183.23 297.18,183.74 310.49,183.74 311.15,183.08 311.15,144.67 311,144.52 307.96,144.52
(no net) on TOP: 175.98,75.62 175.98,76.15 176.2,76.38 178.34,76.38 178.42,76.46 179.94,76.46 179.98,76.42 179.98,75.83 179.93,75.78 178.51,75.78 178.51,75.78 178.34,75.78 178.03,75.47 176.13,75.47
(no net) on TOP: 52.71,36.5 52.71,34.64 53.09,34.25 55.26,34.25 55.52,34.51 55.52,36.5 55.49,36.52 52.73,36.52
(no net) on TOP: 298.19,173.75 298.19,173.75 298.19,174.64 298.52,174.97 301.01,174.97 301.43,174.55 301.43,143.38 300.99,142.93 298.58,142.93 298.19,143.31
