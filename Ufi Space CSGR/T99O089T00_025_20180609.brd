# Allegro board T99O089T00_025_20180609.brd (continued)
## Nets (continued)
MDI_NIC1_DN3: D60.5(TX2-IN) D60.6(TX2-OUT) OJ1.BR7(D4-) U85.49(MDI_N[3])
MDI_NIC1_DP0: D59.1(TX1+IN) D59.10(TX1+OUT) OJ1.BR2(D1+) U85.58(MDI_P[0])
MDI_NIC1_DP1: D59.4(TX2+IN) D59.7(TX2+OUT) OJ1.BR4(D2+) U85.55(MDI_P[1])
MDI_NIC1_DP2: D60.1(TX1+IN) D60.10(TX1+OUT) OJ1.BR6(D3+) U85.53(MDI_P[2])
MDI_NIC1_DP3: D60.4(TX2+IN) D60.7(TX2+OUT) OJ1.BR8(D4+) U85.50(MDI_P[3])
MIIM_BMC1_MDC: R12358.1 U154.C6(GPIOR6/MDC1)
MIIM_BMC1_MDIO: R12357.1 U154.A5(GPIOR7/MDIO1)
MIIM_BMC2_MDC: R12728.1 U154.A3(GPIOA6/TIMER7/MDC2)
MIIM_BMC2_MDIO: R12729.1 U154.D5(GPIOA7/TIMER8/MDIO2)
MIIM_MAC_ST_MDC0: R36.2 U1.AD36(MDC_0)
MIIM_MAC_ST_MDC1: R39.2 U1.AC37(MDC_1)
MIIM_MAC_ST_MDC2: R43.2 U1.AB37(MDC_2)
MIIM_MAC_ST_MDIO0: R37.2 U1.AD37(MDIO_0)
MIIM_MAC_ST_MDIO1: R41.2 U1.AC35(MDIO_1)
MIIM_MAC_ST_MDIO2: R44.2 U1.AE36(MDIO_2)
MIIM_PHY1_MDC: R36.1 R284.1 U23.G9(MDC)
MIIM_PHY1_MDIO: R37.1 R283.1 U23.G7(MDIO)
MIIM_PHY2_MDC: R39.1 R299.1
MIIM_PHY2_MDIO: R41.1 R298.1
MIIM_PHY3_MDC: R43.1 R301.1 U25.J1(MDC_B) U25.K5(MDC_A)
MIIM_PHY3_MDIO: R44.1 R300.1 U25.H1(MDIO_B) U25.J5(MDIO_A)
NCSI_BMC_CSRDV: R1206.2 U154.A11(RGMII1RXD2/RMII1CRSDV/GPIOV0)
NCSI_BMC_RXD0: R1203.2 U154.C11(RGMII1RXD0/RMII1RXD0/GPIOU6)
NCSI_BMC_RXD1: R1205.2 U154.B11(RGMII1RXD1/RMII1RXD1/GPIOU7)
NCSI_BMC_TXD0: R12352.2 U85.9(NC_SI_TXD0)
NCSI_BMC_TXD1: R12353.2 U85.8(NC_SI_TXD1)
NCSI_BMC_TXEN: R12351.2 U85.7(NC_SI_TX_EN)
NCSI_NIC1_CSRDV: R1206.1 U85.3(NC_SI_CSR_DV)
NCSI_NIC1_RXD0: R1203.1 U85.6(NC_SI_RXD0)
NCSI_NIC1_RXD1: R1205.1 U85.5(NC_SI_RXD1)
NIC1_CAP_BOT: C1637.1 U85.37(CBOT)
NIC1_CAP_TOP: C1637.2 U85.40(CTOP)
NIC1_DEV_OFF_N: R1218.2 U85.28(DEV_OFF_N)
NIC1_NVM_CLK: R1215.2 R1226.1 U86.6(SCLK)
NIC1_NVM_CLK_ST: R1215.1 U85.13(NVM_SK)
NIC1_NVM_CS_N: R1213.2 U86.1(CS#)
NIC1_NVM_CS_ST_N: R1213.1 U85.15(NVM_CS_N)
NIC1_NVM_HOLD_N: R1223.2 U86.7(NC/SIO3)
NIC1_NVM_SI: R1214.2 R1224.2 R1227.1 U86.5(SI/SIO0)
NIC1_NVM_SI_ST: R1214.1 U85.12(NVM_SI)
NIC1_NVM_SO: R1225.1 U85.14(NVM_SO)
NIC1_NVM_SO_OUT: R1221.2 R1225.2 U86.2(SO/SIO1)
NIC1_NVM_WP_N: R1222.2 U86.3(WP#/SIO2)
NIC1_RSET: R1212.2 U85.48(RSET)
NIC_ICM_CT1: C2220.1 OJ1.BR9(VCC)
NMI_BMC_TO_CPU_N: J1.B19(PCIE0_TX1_P) R1753.2 U154.H3(GPIOQ5/SDA14)
OSC_PCIE_25M_OE: R1074.1 X3.1(ENABLE CONTROL)
P10V_H2_SS/TR: PC425.1 PU24.9(SS/TR)
PCIE_BMC_TO_CPU_DN: C2074.2 U154.E21(PETXN)
PCIE_BMC_TO_CPU_DP: C2073.2 U154.E22(PETXP)
PCIE_BMC_WAKE_N: R12311.1 U154.J22(PEWAKE#)
PCIE_CPU_IIO_RX_DN0: C2070.1 J1.A48(PCIE0_RX7_N)
PCIE_CPU_IIO_RX_DN1: C2068.1 J1.A44(PCIE0_RX6_N)
PCIE_CPU_IIO_RX_DP0: C2069.1 J1.A47(PCIE0_RX7_P)
PCIE_CPU_IIO_RX_DP1: C2067.1 J1.A43(PCIE0_RX6_P)
PCIE_CPU_PCH_RX_DN0: C2074.1 J1.A65(PCIE0_RX11_N)
PCIE_CPU_PCH_RX_DN1: C2072.1 J1.A61(PCIE0_RX10_N)
PCIE_CPU_PCH_RX_DP0: C2073.1 J1.A64(PCIE0_RX11_P)
PCIE_CPU_PCH_RX_DP1: C2071.1 J1.A60(PCIE0_RX10_P)
PCIE_CPU_TO_BMC_DN: J1.B63(PCIE0_TX11_N) U154.F22(PERXN)
PCIE_CPU_TO_BMC_DP: J1.B62(PCIE0_TX11_P) U154.F21(PERXP)
PCIE_CPU_TO_MAC_DN: J1.B46(PCIE0_TX7_N) U1.W34(PCIE_RX0_N)
PCIE_CPU_TO_MAC_DP: J1.B45(PCIE0_TX7_P) U1.W35(PCIE_RX0_P)
PCIE_CPU_TO_NIC1_DN: J1.B59(PCIE0_TX10_N) U85.23(PE_RN)
PCIE_CPU_TO_NIC1_DP: J1.B58(PCIE0_TX10_P) U85.24(PE_RP)
PCIE_MAC_TO_CPU_DN: C2070.2 U1.T36(PCIE_TX0_N)
PCIE_MAC_TO_CPU_DP: C2069.2 U1.T37(PCIE_TX0_P)
PCIE_NIC1_TO_CPU_DN: C2072.2 U85.20(PE_TN)
PCIE_NIC1_TO_CPU_DP: C2071.2 U85.21(PE_TP)
PCIE_NIC1_WAKE_N: R1204.1 U85.16(PE_WAKE_N)
PD_COREPLL_BYP: R1443.2 U1.AK32(C_PLL_BYPASS)
PD_COREPLL_BYP_CLK0: R1436.2 U1.Y18(C_PLL_BYP_CLK0)
PD_COREPLL_BYP_CLK1: R1437.2 U1.W18(C_PLL_BYP_CLK1)
PD_MAC_TEST0: R52.1 U1.AL35(TEST_0)
PD_MAC_TEST1: R54.1 U1.AM35(TEST_1)
PD_MAC_TEST2: R56.1 U1.AH35(TEST_2)
PD_MAC_TEST3: R57.1 U1.AK35(TEST_3)
PD_MAC_TEST4: R58.1 U1.AJ35(TEST_4)
PD_MAC_TEST5: R59.1 U1.AF30(FTEST_0)
PD_MAC_TEST6: R63.1 U1.AH30(FTEST_1)
PD_MAC_TEST7: R64.1 U1.AG30(FTEST_2)
PD_MAC_TEST8: R65.1 U1.AH31(SCAN_MODE)
PD_MAC_TS_TIME_VAL0: R1453.2 U1.AE30(TS_TIME_VAL0)
PD_MAC_TS_TIME_VAL1: R1450.2 U1.AC31(TS_TIME_VAL1)
PD_MCUPLL_BYP_CLK0: R1438.2 U1.V31(UC_PLL_BYP_CLK0)
PD_MCUPLL_BYP_CLK1: R1439.2 U1.Y31(UC_PLL_BYP_CLK1)
PD_NIF_LCPLL_BYP_CLK: R1440.2 U1.N21(NIF_LCPLL_BYP_CLK)
PD_NIF_SRD_REFCLK_Q00_DN: R1433.2 U1.M15(NIF_SRD_REFCLK_Q00_N)
PD_NIF_SRD_REFCLK_Q00_DP: R1432.2 U1.M16(NIF_SRD_REFCLK_Q00_P)
PD_NIFE_LCPLL0_BYP_CLK: R1441.2 U1.U24(NIFE_LCPLL0_BYP_CLK)
PD_NIFE_LCPLL1_BYP_CLK: R1442.2 U1.V12(NIFE_LCPLL1_BYP_CLK)
PD_NIFE_SRD_REFCLK_Q05_DN: R1435.2 U1.L28(NIFE_SRD_REFCLK_Q05_N)
PD_NIFE_SRD_REFCLK_Q05_DP: R1434.2 U1.L29(NIFE_SRD_REFCLK_Q05_P)
PECI_PCH_BMC: J1.A19(RSVD_3) R12356.1 U154.AA21(PECI)
PHY1_PRTAD0: R280.1 R12820.1 U23.R10(PRTAD0)
PHY1_PRTAD1: R279.1 R12979.1 U23.R6(PRTAD1)
PHY1_PRTAD3: R278.1 U23.K5(PRTAD3)
PHY1_PRTAD4: R276.1 U23.J5(PRTAD4)
PHY3_PRTAD1: R302.1 R12821.1 U25.U1(ADR_1)
PHY3_PRTAD2: R303.1 R12971.1 U25.G1(ADR_2)
PHY3_PRTAD3: R304.1 R12972.1 U25.F2(ADR_3)
PHY3_PRTAD4: R305.1 U25.B1(ADR_4)
PHY3_SERBOOT: R309.2 R311.1 U25.G15(SERBOOT)
PSU1_ALRT_N: CN3.A1 D47.2(C) R1157.1 R1161.2
PSU1_EEPROM_WP: CN3.A3 R12945.1 R12947.2 U154.V4(GPIOM3/NRI2/VPIB5)
PSU1_PRSNT_IN_N: CN3.B2 R1154.2
PSU1_PRSNT_N: C1592.2 D49.2(C) R1153.1 R1154.1 U70.A2(IO_8_23) U154.G5(GPIOK6/SCL8)
PSU1_PSKILL: CN3.C3 R12974.1
PSU1_PSON_N: C1595.1 CN3.A4 D51.2(C) Q23.6(D1) R1158.2
PSU1_PWRGD: CN3.B4 D45.2(C) R1166.2 R1170.2
PSU1_PWROK: C1596.2 R1166.1 U59.1(B) U70.B3(IO_8_20) U154.AB6(GPIOP4/TACH12)
PSU1_PWRON_BMC_N: R13088.2 U154.W7(GPIOP2/TACH10/VPIR8) U196.2(A)
PSU1_PWRON_HWM_N: R13087.1 U73.33(GPIO16) U196.1(B)
PSU2_ALRT_N: CN3.A5 D46.2(C) R1180.1 R1183.2
PSU2_EEPROM_WP: CN3.D3 R12946.1 R12948.2 U154.W3(GPIOM4/NDTR2/VPIB6)
PSU2_PRSNT_IN_N: CN3.B5 R1176.2
PSU2_PRSNT_N: C1598.2 D48.2(C) R1175.1 R1176.1 U70.D8(IO_8_9) U154.F3(GPIOK7/SDA8)
PSU2_PSKILL: CN3.C2 R12973.1
PSU2_PSON_N: C1601.1 CN3.D1 D50.2(C) Q24.6(D1) R1181.2
PSU2_PWRGD: CN3.C1 D44.2(C) R1188.2 R1190.2
PSU2_PWROK: C1602.2 R1188.1 U59.2(A) U70.B7(IO_8_11) U154.Y7(GPIOP5/TACH13)
PSU2_PWRON_BMC_N: R13089.2 U154.AA6(GPIOP3/TACH11/VPIR9) U197.2(A)
PSU2_PWRON_HWM_N: R13090.1 U73.34(GPIO17) U197.1(B)
PSU_A0: CN3.D4 R12975.1 R12976.2
PSU_A1: CN3.B1 R12977.1 R12978.2
PSU_PWROK: R1023.2 U59.4(Y) U73.30(GPIO15)
PSU_THERM_SHTDN_DIS_N: Q5.2(G1) Q5.5(G2) Q6.3(D) R1281.1 U154.F4(GPIOK3/SDA6)
PTP_1PPS_MUX_SEL: R12898.1 R12899.2 U70.F13(IO_6_3) U170.6(IN)
PTP_1PPS_RS422_CONN_DN: D76.1(A) D92.5(TX2-IN) D92.6(TX2-OUT) J7.AR3(0TX+) R1590.2
PTP_1PPS_RS422_CONN_DP: D75.1(A) D92.4(TX2+IN) D92.7(TX2+OUT) J7.AR6(0TX-) R1591.2
PTP_1PPS_RS422_DN: L159.4 R1765.1 U121.9(B)
PTP_1PPS_RS422_DP: L159.1 R1765.2 U121.8(A)
PTP_1PPS_RS422_RL_DN: L159.3 R1590.1
PTP_1PPS_RS422_RL_DP: L159.2 R1591.1
PTP_1PPS_RS422_RXD_EN_N: R1192.2 U70.B10(IO_8_5) U121.4(#RE)
PTP_1PPS_RS422_RXD_IN: R1589.1 U121.2(R)
PTP_1PPS_RS422_TXD_EN: R1191.1 U70.A8(IO_8_2) U121.3(DE)
PTP_OSC_OE: R1627.2 X2.1(ENABLE CONTROL)
PTP_TOD_RS422_CONN_DN: D74.1(A) D92.2(TX1-IN) D92.9(TX1-OUT) J7.AR7(A7) R1592.2
PTP_TOD_RS422_CONN_DP: D73.1(A) D92.1(TX1+IN) D92.10(TX1+OUT) J7.AR8(A8) R1593.2
PTP_TOD_RS422_DN: L161.4 R1766.1 U110.9(B)
PTP_TOD_RS422_DP: L161.1 R1766.2 U110.8(A)
PTP_TOD_RS422_RL_DN: L161.3 R1592.1
PTP_TOD_RS422_RL_DP: L161.2 R1593.1
PTP_TOD_RS422_RXD_EN_N: R1199.2 U70.C9(IO_8_3) U110.4(#RE)
PTP_TOD_RS422_RXD_IN: R1594.1 U110.2(R)
PTP_TOD_RS422_TXD_EN: R1198.1 U70.C10(IO_8_1) U110.3(DE)
PWR_OFF_MAC: R69.1 U1.AJ31(DISCONNECT) U70.G13(IO_5_14)
PWREN_BMC_HEATER: PR485.2 R791.2 R795.2 R1630.2
PWREN_BMC_HEATER_CPLD: R1017.1 R1085.2 U70.A9(IO_8_4) U73.21(FPWM5/GPIO9) U194.2(INA)
PWREN_BMC_HEATER_HWM: R1086.2 U73.24(FPWM8/GPIO12) U194.1(INB)
PWREN_P1V0: PR44.1 U73.12(GPIO2)
PWREN_P1V2: PR45.1 U73.13(GPIO3)
PWREN_P1V8: PR28.1 U73.25(GPIO13)
PWREN_P1V25: PR27.1 U73.14(GPIO4)
PWREN_P3V3: PR43.1 U73.29(GPIO14)
PWREN_VCORE: PR26.1 U73.11(GPIO1)
PWROK_SYS_DC: PR335.2 U70.E4(IO_1_7) U154.A15(GPIOE3/NRI3)
QSFP28_P1_INT_N: CJ12.U_28(U_INT#) R595.1 U57.5(P01)
QSFP28_P1_LPMODE: CJ12.U_31(U_LP_MODE) R596.1 U57.14(P11)
QSFP28_P1_MODSEL_N: CJ12.U_8(U_MODSEL#) R592.1
QSFP28_P1_PRSNT_N: CJ12.U_27(U_MODPRS#) Q44.5(G2) R594.1 U42.4(E\N\1\) U57.9(P05)
QSFP28_P1_RST_N: CJ12.U_9(U_RESET#) R600.2 U57.18(P15)
QSFP28_P1_VCC: C1232.1 C1233.1 CJ12.U_30(U_VCC1) L129.1
QSFP28_P1_VCCRX: C1246.1 C1247.1 CJ12.U_10(U_VCC_RX) L133.1
QSFP28_P1_VCCTX: C1240.1 C1241.1 CJ12.U_29(U_VCC_TX) L131.1
QSFP28_P2_INT_N: CJ12.L_28(L_INT#) R598.1 U57.4(P00)
QSFP28_P2_LPMODE: CJ12.L_31(L_LP_MODE) R599.1 U57.13(P10)
QSFP28_P2_MODSEL_N: CJ12.L_8(L_MODSEL#) R593.1
QSFP28_P2_PRSNT_N: CJ12.L_27(L_MODPRS#) Q44.2(G1) R597.1 U42.5(E\N\2\) U57.8(P04)
QSFP28_P2_RST_N: CJ12.L_9(L_RESET#) R601.2 U57.17(P14)
QSFP28_P2_VCC: C1236.1 C1237.1 CJ12.L_30(L_VCC1) L130.1
QSFP28_P2_VCCRX: C1249.1 C1250.1 CJ12.L_10(L_VCC_RX) L134.1
QSFP28_P2_VCCTX: C1243.1 C1244.1 CJ12.L_29(L_VCC_TX) L132.1
QSFP28_PWR_OC_N: R646.1 U42.6(F\A\U\L\T\2\) U42.10(F\A\U\L\T\1\) U70.H10(IO_5_11)
QSFP_PWR_ILIM: R622.1 U42.7(ILIM)
RGMII_BMC_TXCTL: TP115.1 U154.B12(RGMII1TXCTL/GPIOT1)
RGMII_BMC_TXD0: R12352.1 U154.C12(RGMII1TXD0/RMII1TXD0/GPIOT2)
RGMII_BMC_TXD1: R12353.1 U154.D12(RGMII1TXD1/RMII1TXD1/GPIOT3)
RGMII_BMC_TXD2: TP116.1 U154.E12(RGMII1TXD2/GPIOT4)
RGMII_BMC_TXD3: TP117.1 U154.A13(RGMII1TXD3/GPIOT5)
RGMII_BMC_TXEN: R12351.1 U154.A12(RGMII1TXCK/RMII1TXEN/GPIOT0)
ROV_EN: PR32.2 PR138.2
ROV_PG: PR52.1 PR146.2 PU4.18(VR_RDY)
RST_BITS_N: R1719.2 U70.J12(IO_5_7) U127.64(R\E\S\E\T\)
RST_BMC_DDR3_CPLD_N: R12338.1 U70.K1(IO_2_13) U171.2(INA)
RST_BMC_DDR3_N: C2326.1 R12325.2 R13038.1 R13042.1 U155.T2(\\R\E\S\E\T)
RST_BMC_LPC_N: R1702.2 R12469.1 U70.M8(IO_3_14) U154.E19(GPIOB4/LPCRST#)
RST_BMC_PCIE_N: R12310.1 U70.N2(IO_2_8) U154.K19(PERST#)
RST_BMC_SYS_L: C2452.1 U154.W20(SRST#) U164.4(OUTY)
RST_BMC_TO_CPU_N: R1764.1 U136.1(INB) U154.H4(GPIOQ4/SCL14)
RST_BMC_TO_RTC: Q57.1(G) R12924.2 U154.B18(GPIOF4/NDTR4)
RST_BMC_WDT2: R12998.2 U154.Y21(GPIOG5/WDTRST2/USBCKI)
RST_BMC_WDT_L: Q12.3(D) U70.L1(IO_2_9)
RST_CJA_N: R1871.2 U70.J9(IO_5_9) U135.17(R\S\T\)
RST_CPLD_TO_BMC_SYS_L: R13037.1 U70.E8(IO_8_10) U148.2(INA)
RST_CPLD_TO_CPU_N: R1651.2 U70.H4(IO_2_6) U136.2(INA)
RST_CPU_PLTRST_N: J1.B30(RSVD_1) U70.K7(IO_3_19)
RST_CPU_PWRBTN_N: J1.B48(PRSNT2_L_2) R1757.2 U70.F9(IO_6_7) U154.E2(GPIOK4/SCL7)
RST_CPU_RTC_N: J1.B14(PCIE0_TX0_P) Q57.3(D)
RST_CPU_SYS_N: J1.B31(PRSNT2_L_1) R1112.1
RST_CPU_TO_BMC_N: J1.B15(PCIE0_TX0_N) R12486.1 U148.1(INB)
RST_CPU_TO_MB_I2C_N: J1.B11(WAKE_L) R1717.2
RST_CPU_TO_MB_PCIE_N: J1.B12(RSVD_0) R1716.2 R1756.2 U70.M1(IO_2_5)
RST_GNSS_N: R1602.1 R1720.2 U70.H3(IO_1_13)
RST_HWM_N: C2443.1 R1040.2 R12719.1 U70.A5(IO_8_22) U73.9(\\R\E\S\E\T)
RST_I2C_MUX0_N: U70.D12(IO_6_21) U76.3(RESET#)
RST_I2C_MUX1_N: R1722.2 R12729.2 U67.3(RESET#) U70.M12(IO_3_23)
RST_I2C_MUX2_N: R1724.2 U68.3(RESET#) U70.K5(IO_3_5)
RST_I2C_MUX3_N: R1726.2 U62.3(R\E\S\E\T\) U70.N6(IO_3_9)
RST_I2C_MUX4_N: R1728.2 U63.3(R\E\S\E\T\) U70.N7(IO_3_10)
RST_I2C_MUX5_N: R1730.2 U64.3(R\E\S\E\T\) U70.M9(IO_3_16)
RST_I2C_MUX6_N: R1732.2 U65.3(R\E\S\E\T\) U70.N11(IO_3_18)
RST_I2C_MUX7_N: R1733.2 U69.3(RESET#) U70.L13(IO_5_6)
RST_MAC_N: R68.1 U1.AG31(SYS_RST_N) U70.F10(IO_6_9)
RST_NIC1_N: R1219.2 R1715.2 U70.N4(IO_3_6) U85.1(LAN_PWR_GOOD)
RST_NIC1_PCIE_N: R1698.2 U70.M5(IO_3_4) U85.17(PE_RST_N)
RST_PHY1_N: R286.1 U23.D11(RESET_L) U70.N5(IO_3_8)
RST_PHY3_N: R310.1 U25.T10(RESETB) U70.D9(IO_6_20)
RST_SMU_N: R1729.2 U70.H13(IO_5_12) U139.K6(RSTB)
RST_SW_BTN_N: J8.11 U70.F4(IO_1_10)
RST_SW_TO_CP2104: J8.5 U154.D15(GPIOE0/NCTS3)
RST_USB_BRIDGE_N: R1718.2 U70.K13(IO_5_8) U162.9(R\S\T\)
RSVD_HWM_GPIO10: R1843.2 U73.22(FPWM6/GPIO10)
RTC_BAT_SENSE_EN_N: Q56.1(G) R12710.1 U154.E3(GPIOK0/SCL5)
SFI_PHY1_TO_SFP_DN0: CJ8.AT19(AT_TX_NDAT) U23.T15(SFP0_ON)
SFI_PHY1_TO_SFP_DN1: CJ8.AL19(AL_TX_NDAT) U23.P16(SFP1_ON)
SFI_PHY1_TO_SFP_DN2: CJ8.BT19(BT_TX_NDAT) U23.M15(SFP2_ON)
SFI_PHY1_TO_SFP_DN3: CJ8.BL19(BL_TX_NDAT) U23.J16(SFP3_ON)
SFI_PHY1_TO_SFP_DN4: CJ8.CT19(CT_TX_NDAT) U23.G16(SFP4_ON)
SFI_PHY1_TO_SFP_DN5: CJ8.CL19(CL_TX_NDAT) U23.E15(SFP5_ON)
SFI_PHY1_TO_SFP_DN6: CJ8.DT19(DT_TX_NDAT) U23.C16(SFP6_ON)
SFI_PHY1_TO_SFP_DN7: CJ8.DL19(DL_TX_NDAT) U23.A15(SFP7_ON)
SFI_PHY1_TO_SFP_DP0: CJ8.AT18(AT_TX_DAT) U23.T16(SFP0_OP)
SFI_PHY1_TO_SFP_DP1: CJ8.AL18(AL_TX_DAT) U23.P15(SFP1_OP)
SFI_PHY1_TO_SFP_DP2: CJ8.BT18(BT_TX_DAT) U23.M16(SFP2_OP)
SFI_PHY1_TO_SFP_DP3: CJ8.BL18(BL_TX_DAT) U23.K16(SFP3_OP)
SFI_PHY1_TO_SFP_DP4: CJ8.CT18(CT_TX_DAT) U23.G15(SFP4_OP)
SFI_PHY1_TO_SFP_DP5: CJ8.CL18(CL_TX_DAT) U23.E16(SFP5_OP)
SFI_PHY1_TO_SFP_DP6: CJ8.DT18(DT_TX_DAT) U23.C15(SFP6_OP)
SFI_PHY1_TO_SFP_DP7: CJ8.DL18(DL_TX_DAT) U23.A16(SFP7_OP)
SFI_SFP_TO_PHY1_DN0: CJ8.AT12(AT_RX_NDAT) U23.T12(SFP0_IN)
SFI_SFP_TO_PHY1_DN1: CJ8.AL12(AL_RX_NDAT) U23.P13(SFP1_IN)
SFI_SFP_TO_PHY1_DN2: CJ8.BT12(BT_RX_NDAT) U23.M12(SFP2_IN)
SFI_SFP_TO_PHY1_DN3: CJ8.BL12(BL_RX_NDAT) U23.J14(SFP3_IN)
SFI_SFP_TO_PHY1_DN4: CJ8.CT12(CT_RX_NDAT) U23.G13(SFP4_IN)
SFI_SFP_TO_PHY1_DN5: CJ8.CL12(CL_RX_NDAT) U23.E12(SFP5_IN)
SFI_SFP_TO_PHY1_DN6: CJ8.DT12(DT_RX_NDAT) U23.C13(SFP6_IN)
SFI_SFP_TO_PHY1_DN7: CJ8.DL12(DL_RX_NDAT) U23.A12(SFP7_IN)
SFI_SFP_TO_PHY1_DP0: CJ8.AT13(AT_RX_DAT) U23.T13(SFP0_IP)
SFI_SFP_TO_PHY1_DP1: CJ8.AL13(AL_RX_DAT) U23.P12(SFP1_IP)
SFI_SFP_TO_PHY1_DP2: CJ8.BT13(BT_RX_DAT) U23.M13(SFP2_IP)
SFI_SFP_TO_PHY1_DP3: CJ8.BL13(BL_RX_DAT) U23.K14(SFP3_IP)
SFI_SFP_TO_PHY1_DP4: CJ8.CT13(CT_RX_DAT) U23.G12(SFP4_IP)
SFI_SFP_TO_PHY1_DP5: CJ8.CL13(CL_RX_DAT) U23.E13(SFP5_IP)
SFI_SFP_TO_PHY1_DP6: CJ8.DT13(DT_RX_DAT) U23.C12(SFP6_IP)
SFI_SFP_TO_PHY1_DP7: CJ8.DL13(DL_RX_DAT) U23.A13(SFP7_IP)
SFP28_PWR_OC_N: R637.2 R638.2 R639.2 R640.2 R1576.1 U70.L12(IO_5_4)
SFP+_P00_MOD_ABS: CJ8.AT6(AT_ABS#) Q28.5(G2) R316.1 U26.4(E\N\1\) U47.11(P07)
SFP+_P00_RATE_SEL: CJ8.AT7(AT_RX_RATE_SEL) CJ8.AT9(AT_TX_RATE_SEL) R313.1 R761.2
SFP+_P00_RATE_SEL_OUT: R761.1 U51.11(P07)
SFP+_P00_RX_LOS: CJ8.AT8(AT_RX_LOSS) R315.1 U48.11(P07)
SFP+_P00_RXVCC: C995.1 C996.1 CJ8.AT15(AT_RX_VCC) L50.1
SFP+_P00_TX_DIS: CJ8.AT3(AT_TX_DISABLE) R312.1 U54.11(P07)
SFP+_P00_TX_FLT: CJ8.AT2(AT_TX_FAULT) R314.1 U53.11(P07)
SFP+_P00_TXVCC: C992.1 C993.1 CJ8.AT16(AT_TX_VCC) L49.1
SFP+_P01_MOD_ABS: CJ8.AL6(AL_ABS#) Q28.2(G1) R323.1 U26.5(E\N\2\) U47.10(P06)
SFP+_P01_RATE_SEL: CJ8.AL7(AL_RX_RATE_SEL) CJ8.AL9(AL_TX_RATE_SEL) R320.1 R762.2
SFP+_P01_RATE_SEL_OUT: R762.1 U51.10(P06)
SFP+_P01_RX_LOS: CJ8.AL8(AL_RX_LOSS) R322.1 U48.10(P06)
SFP+_P01_RXVCC: C1001.1 C1002.1 CJ8.AL15(AL_RX_VCC) L52.1
SFP+_P01_TX_DIS: CJ8.AL3(AL_TX_DISABLE) R319.1 U54.10(P06)
SFP+_P01_TX_FLT: CJ8.AL2(AL_TX_FAULT) R321.1 U53.10(P06)
SFP+_P01_TXVCC: C998.1 C999.1 CJ8.AL16(AL_TX_VCC) L51.1
SFP+_P02_MOD_ABS: CJ8.BT6(BT_ABS#) Q29.5(G2) R330.1 U29.4(E\N\1\) U47.9(P05)
SFP+_P02_RATE_SEL: CJ8.BT7(BT_RX_RATE_SEL) CJ8.BT9(BT_TX_RATE_SEL) R327.1 R763.2
SFP+_P02_RATE_SEL_OUT: R763.1 U51.9(P05)
SFP+_P02_RX_LOS: CJ8.BT8(BT_RX_LOSS) R329.1 U48.9(P05)
SFP+_P02_RXVCC: C1007.1 C1008.1 CJ8.BT15(BT_RX_VCC) L54.1
SFP+_P02_TX_DIS: CJ8.BT3(BT_TX_DISABLE) R326.1 U54.9(P05)
SFP+_P02_TX_FLT: CJ8.BT2(BT_TX_FAULT) R328.1 U53.9(P05)
SFP+_P02_TXVCC: C1004.1 C1005.1 CJ8.BT16(BT_TX_VCC) L53.1
SFP+_P03_MOD_ABS: CJ8.BL6(BL_ABS#) Q29.2(G1) R337.1 U29.5(E\N\2\) U47.8(P04)
SFP+_P03_RATE_SEL: CJ8.BL7(BL_RX_RATE_SEL) CJ8.BL9(BL_TX_RATE_SEL) R334.1 R759.2
SFP+_P03_RATE_SEL_OUT: R759.1 U51.8(P04)
SFP+_P03_RX_LOS: CJ8.BL8(BL_RX_LOSS) R336.1 U48.8(P04)
SFP+_P03_RXVCC: C1013.1 C1014.1 CJ8.BL15(BL_RX_VCC) L56.1
SFP+_P03_TX_DIS: CJ8.BL3(BL_TX_DISABLE) R333.1 U54.8(P04)
SFP+_P03_TX_FLT: CJ8.BL2(BL_TX_FAULT) R335.1 U53.8(P04)
SFP+_P03_TXVCC: C1010.1 C1011.1 CJ8.BL16(BL_TX_VCC) L55.1
SFP+_P04_MOD_ABS: CJ8.CT6(CT_ABS#) Q30.5(G2) R344.1 U32.4(E\N\1\) U47.7(P03)
SFP+_P04_RATE_SEL: CJ8.CT7(CT_RX_RATE_SEL) CJ8.CT9(CT_TX_RATE_SEL) R341.1 R765.2
SFP+_P04_RATE_SEL_OUT: R765.1 U51.7(P03)
SFP+_P04_RX_LOS: CJ8.CT8(CT_RX_LOSS) R343.1 U48.7(P03)
SFP+_P04_RXVCC: C1019.1 C1020.1 CJ8.CT15(CT_RX_VCC) L58.1
SFP+_P04_TX_DIS: CJ8.CT3(CT_TX_DISABLE) R340.1 U54.7(P03)
SFP+_P04_TX_FLT: CJ8.CT2(CT_TX_FAULT) R342.1 U53.7(P03)
SFP+_P04_TXVCC: C1016.1 C1017.1 CJ8.CT16(CT_TX_VCC) L57.1
SFP+_P05_MOD_ABS: CJ8.CL6(CL_ABS#) Q30.2(G1) R351.1 U32.5(E\N\2\) U47.6(P02)
SFP+_P05_RATE_SEL: CJ8.CL7(CL_RX_RATE_SEL) CJ8.CL9(CL_TX_RATE_SEL) R348.1 R767.2
SFP+_P05_RATE_SEL_OUT: R767.1 U51.6(P02)
SFP+_P05_RX_LOS: CJ8.CL8(CL_RX_LOSS) R350.1 U48.6(P02)
SFP+_P05_RXVCC: C1025.1 C1026.1 CJ8.CL15(CL_RX_VCC) L60.1
SFP+_P05_TX_DIS: CJ8.CL3(CL_TX_DISABLE) R347.1 U54.6(P02)
SFP+_P05_TX_FLT: CJ8.CL2(CL_TX_FAULT) R349.1 U53.6(P02)
SFP+_P05_TXVCC: C1022.1 C1023.1 CJ8.CL16(CL_TX_VCC) L59.1
SFP+_P06_MOD_ABS: CJ8.DT6(DT_ABS#) Q31.5(G2) R358.1 U35.4(E\N\1\) U47.5(P01)
SFP+_P06_RATE_SEL: CJ8.DT7(DT_RX_RATE_SEL) CJ8.DT9(DT_TX_RATE_SEL) R355.1 R769.2
SFP+_P06_RATE_SEL_OUT: R769.1 U51.5(P01)
SFP+_P06_RX_LOS: CJ8.DT8(DT_RX_LOSS) R357.1 U48.5(P01)
SFP+_P06_RXVCC: C1031.1 C1032.1 CJ8.DT15(DT_RX_VCC) L62.1
SFP+_P06_TX_DIS: CJ8.DT3(DT_TX_DISABLE) R354.1 U54.5(P01)
SFP+_P06_TX_FLT: CJ8.DT2(DT_TX_FAULT) R356.1 U53.5(P01)
SFP+_P06_TXVCC: C1028.1 C1029.1 CJ8.DT16(DT_TX_VCC) L61.1
SFP+_P07_MOD_ABS: CJ8.DL6(DL_ABS#) Q31.2(G1) R365.1 U35.5(E\N\2\) U47.4(P00)
SFP+_P07_RATE_SEL: CJ8.DL7(DL_RX_RATE_SEL) CJ8.DL9(DL_TX_RATE_SEL) R362.1 R772.2
SFP+_P07_RATE_SEL_OUT: R772.1 U51.4(P00)
SFP+_P07_RX_LOS: CJ8.DL8(DL_RX_LOSS) R364.1 U48.4(P00)
SFP+_P07_RXVCC: C1037.1 C1038.1 CJ8.DL15(DL_RX_VCC) L64.1
SFP+_P07_TX_DIS: CJ8.DL3(DL_TX_DISABLE) R361.1 U54.4(P00)
SFP+_P07_TX_FLT: CJ8.DL2(DL_TX_FAULT) R363.1 U53.4(P00)
SFP+_P07_TXVCC: C1034.1 C1035.1 CJ8.DL16(DL_TX_VCC) L63.1
SFP+_P08_MOD_ABS: CJ8.ET6(ET_ABS#) Q32.5(G2) R372.1 U38.4(E\N\1\) U47.20(P17)
SFP+_P08_RATE_SEL: CJ8.ET7(ET_RX_RATE_SEL) CJ8.ET9(ET_TX_RATE_SEL) R369.1 R773.2
SFP+_P08_RATE_SEL_OUT: R773.1 U51.20(P17)
SFP+_P08_RX_LOS: CJ8.ET8(ET_RX_LOSS) R371.1 U48.20(P17)
SFP+_P08_RXVCC: C1043.1 C1044.1 CJ8.ET15(ET_RX_VCC) L66.1
SFP+_P08_TX_DIS: CJ8.ET3(ET_TX_DISABLE) R368.1 U54.20(P17)
SFP+_P08_TX_FLT: CJ8.ET2(ET_TX_FAULT) R370.1 U53.20(P17)
SFP+_P08_TXVCC: C1040.1 C1041.1 CJ8.ET16(ET_TX_VCC) L65.1
SFP+_P09_MOD_ABS: CJ8.EL6(EL_ABS#) Q32.2(G1) R379.1 U38.5(E\N\2\) U47.19(P16)
SFP+_P09_RATE_SEL: CJ8.EL7(EL_RX_RATE_SEL) CJ8.EL9(EL_TX_RATE_SEL) R376.1 R774.2
SFP+_P09_RATE_SEL_OUT: R774.1 U51.19(P16)
SFP+_P09_RX_LOS: CJ8.EL8(EL_RX_LOSS) R378.1 U48.19(P16)
SFP+_P09_RXVCC: C1049.1 C1050.1 CJ8.EL15(EL_RX_VCC) L68.1
SFP+_P09_TX_DIS: CJ8.EL3(EL_TX_DISABLE) R375.1 U54.19(P16)
SFP+_P09_TX_FLT: CJ8.EL2(EL_TX_FAULT) R377.1 U53.19(P16)
SFP+_P09_TXVCC: C1046.1 C1047.1 CJ8.EL16(EL_TX_VCC) L67.1
SFP+_P10_MOD_ABS: CJ8.FT6(FT_ABS#) Q33.5(G2) R386.1 U27.4(E\N\1\) U47.18(P15)
SFP+_P10_RATE_SEL: CJ8.FT7(FT_RX_RATE_SEL) CJ8.FT9(FT_TX_RATE_SEL) R383.1 R775.2
SFP+_P10_RATE_SEL_OUT: R775.1 U51.18(P15)
SFP+_P10_RX_LOS: CJ8.FT8(FT_RX_LOSS) R385.1 U48.18(P15)
SFP+_P10_RXVCC: C1055.1 C1056.1 CJ8.FT15(FT_RX_VCC) L70.1
SFP+_P10_TX_DIS: CJ8.FT3(FT_TX_DISABLE) R382.1 U54.18(P15)
SFP+_P10_TX_FLT: CJ8.FT2(FT_TX_FAULT) R384.1 U53.18(P15)
SFP+_P10_TXVCC: C1052.1 C1053.1 CJ8.FT16(FT_TX_VCC) L69.1
SFP+_P11_MOD_ABS: CJ8.FL6(FL_ABS#) Q33.2(G1) R393.1 U27.5(E\N\2\) U47.17(P14)
SFP+_P11_RATE_SEL: CJ8.FL7(FL_RX_RATE_SEL) CJ8.FL9(FL_TX_RATE_SEL) R390.1 R776.2
SFP+_P11_RATE_SEL_OUT: R776.1 U51.17(P14)
SFP+_P11_RX_LOS: CJ8.FL8(FL_RX_LOSS) R392.1 U48.17(P14)
SFP+_P11_RXVCC: C1061.1 C1062.1 CJ8.FL15(FL_RX_VCC) L72.1
SFP+_P11_TX_DIS: CJ8.FL3(FL_TX_DISABLE) R389.1 U54.17(P14)
SFP+_P11_TX_FLT: CJ8.FL2(FL_TX_FAULT) R391.1 U53.17(P14)
SFP+_P11_TXVCC: C1058.1 C1059.1 CJ8.FL16(FL_TX_VCC) L71.1
SFP+_P12_MOD_ABS: CJ8.GT6(GT_ABS#) Q34.5(G2) R400.1 U30.4(E\N\1\) U47.16(P13)
SFP+_P12_RATE_SEL: CJ8.GT7(GT_RX_RATE_SEL) CJ8.GT9(GT_TX_RATE_SEL) R397.1 R777.2
SFP+_P12_RATE_SEL_OUT: R777.1 U51.16(P13)
SFP+_P12_RX_LOS: CJ8.GT8(GT_RX_LOSS) R399.1 U48.16(P13)
SFP+_P12_RXVCC: C1067.1 C1068.1 CJ8.GT15(GT_RX_VCC) L74.1
SFP+_P12_TX_DIS: CJ8.GT3(GT_TX_DISABLE) R396.1 U54.16(P13)
SFP+_P12_TX_FLT: CJ8.GT2(GT_TX_FAULT) R398.1 U53.16(P13)
SFP+_P12_TXVCC: C1064.1 C1065.1 CJ8.GT16(GT_TX_VCC) L73.1
SFP+_P13_MOD_ABS: CJ8.GL6(GL_ABS#) Q34.2(G1) R407.1 U30.5(E\N\2\) U47.15(P12)
SFP+_P13_RATE_SEL: CJ8.GL7(GL_RX_RATE_SEL) CJ8.GL9(GL_TX_RATE_SEL) R404.1 R778.2
SFP+_P13_RATE_SEL_OUT: R778.1 U51.15(P12)
SFP+_P13_RX_LOS: CJ8.GL8(GL_RX_LOSS) R406.1 U48.15(P12)
SFP+_P13_RXVCC: C1073.1 C1074.1 CJ8.GL15(GL_RX_VCC) L76.1
SFP+_P13_TX_DIS: CJ8.GL3(GL_TX_DISABLE) R403.1 U54.15(P12)
SFP+_P13_TX_FLT: CJ8.GL2(GL_TX_FAULT) R405.1 U53.15(P12)
SFP+_P13_TXVCC: C1070.1 C1071.1 CJ8.GL16(GL_TX_VCC) L75.1
SFP+_P14_MOD_ABS: CJ8.HT6(HT_ABS#) Q35.5(G2) R414.1 U33.4(E\N\1\) U47.14(P11)
SFP+_P14_RATE_SEL: CJ8.HT7(HT_RX_RATE_SEL) CJ8.HT9(HT_TX_RATE_SEL) R411.1 R779.2
SFP+_P14_RATE_SEL_OUT: R779.1 U51.14(P11)
SFP+_P14_RX_LOS: CJ8.HT8(HT_RX_LOSS) R413.1 U48.14(P11)
SFP+_P14_RXVCC: C1079.1 C1080.1 CJ8.HT15(HT_RX_VCC) L78.1
SFP+_P14_TX_DIS: CJ8.HT3(HT_TX_DISABLE) R410.1 U54.14(P11)
SFP+_P14_TX_FLT: CJ8.HT2(HT_TX_FAULT) R412.1 U53.14(P11)
SFP+_P14_TXVCC: C1076.1 C1077.1 CJ8.HT16(HT_TX_VCC) L77.1
SFP+_P15_MOD_ABS: CJ8.HL6(HL_ABS#) Q35.2(G1) R421.1 U33.5(E\N\2\) U47.13(P10)
SFP+_P15_RATE_SEL: CJ8.HL7(HL_RX_RATE_SEL) CJ8.HL9(HL_TX_RATE_SEL) R418.1 R780.2
SFP+_P15_RATE_SEL_OUT: R780.1 U51.13(P10)
SFP+_P15_RX_LOS: CJ8.HL8(HL_RX_LOSS) R420.1 U48.13(P10)
SFP+_P15_RXVCC: C1085.1 C1086.1 CJ8.HL15(HL_RX_VCC) L80.1
SFP+_P15_TX_DIS: CJ8.HL3(HL_TX_DISABLE) R417.1 U54.13(P10)
SFP+_P15_TX_FLT: CJ8.HL2(HL_TX_FAULT) R419.1 U53.13(P10)
SFP+_P15_TXVCC: C1082.1 C1083.1 CJ8.HL16(HL_TX_VCC) L79.1
SFP+_P16_MOD_ABS: CJ9.AT6(AT_ABS#) Q36.5(G2) R540.1 U36.4(E\N\1\) U49.11(P07)
SFP+_P16_RATE_SEL: CJ9.AT7(AT_RX_RATE_SEL) CJ9.AT9(AT_TX_RATE_SEL) R537.1 R786.2
SFP+_P16_RATE_SEL_OUT: R786.1 U52.11(P07)
SFP+_P16_RX_LOS: CJ9.AT8(AT_RX_LOSS) R539.1 U50.11(P07)
SFP+_P16_RXVCC: C1187.1 C1188.1 CJ9.AT15(AT_RX_VCC) L114.1
SFP+_P16_TX_DIS: CJ9.AT3(AT_TX_DISABLE) R536.1 U56.11(P07)
SFP+_P16_TX_FLT: CJ9.AT2(AT_TX_FAULT) R538.1 U55.11(P07)
SFP+_P16_TXVCC: C1184.1 C1185.1 CJ9.AT16(AT_TX_VCC) L113.1
SFP+_P17_MOD_ABS: CJ9.AB6(AB_ABS#) Q36.2(G1) R547.1 U36.5(E\N\2\) U49.10(P06)
SFP+_P17_RATE_SEL: CJ9.AB7(AB_RX_RATE_SEL) CJ9.AB9(AB_TX_RATE_SEL) R544.1 R787.2
SFP+_P17_RATE_SEL_OUT: R787.1 U52.10(P06)
SFP+_P17_RX_LOS: CJ9.AB8(AB_RX_LOSS) R546.1 U50.10(P06)
SFP+_P17_RXVCC: C1193.1 C1194.1 CJ9.AB15(AB_RX_VCC) L116.1
SFP+_P17_TX_DIS: CJ9.AB3(AB_TX_DISABLE) R543.1 U56.10(P06)
SFP+_P17_TX_FLT: CJ9.AB2(AB_TX_FAULT) R545.1 U55.10(P06)
SFP+_P17_TXVCC: C1190.1 C1191.1 CJ9.AB16(AB_TX_VCC) L115.1
SFP+_P18_MOD_ABS: CJ9.BT6(BT_ABS#) Q37.5(G2) R554.1 U39.4(E\N\1\) U49.9(P05)
SFP+_P18_RATE_SEL: CJ9.BT7(BT_RX_RATE_SEL) CJ9.BT9(BT_TX_RATE_SEL) R551.1 R788.2
SFP+_P18_RATE_SEL_OUT: R788.1 U52.9(P05)
SFP+_P18_RX_LOS: CJ9.BT8(BT_RX_LOSS) R553.1 U50.9(P05)
SFP+_P18_RXVCC: C1199.1 C1200.1 CJ9.BT15(BT_RX_VCC) L118.1
SFP+_P18_TX_DIS: CJ9.BT3(BT_TX_DISABLE) R550.1 U56.9(P05)
SFP+_P18_TX_FLT: CJ9.BT2(BT_TX_FAULT) R552.1 U55.9(P05)
SFP+_P18_TXVCC: C1196.1 C1197.1 CJ9.BT16(BT_TX_VCC) L117.1
SFP+_P19_MOD_ABS: CJ9.BB6(BB_ABS#) Q37.2(G1) R561.1 U39.5(E\N\2\) U49.8(P04)
SFP+_P19_RATE_SEL: CJ9.BB7(BB_RX_RATE_SEL) CJ9.BB9(BB_TX_RATE_SEL) R558.1 R785.2
SFP+_P19_RATE_SEL_OUT: R785.1 U52.8(P04)
SFP+_P19_RX_LOS: CJ9.BB8(BB_RX_LOSS) R560.1 U50.8(P04)
SFP+_P19_RXVCC: C1205.1 C1206.1 CJ9.BB15(BB_RX_VCC) L120.1
SFP+_P19_TX_DIS: CJ9.BB3(BB_TX_DISABLE) R557.1 U56.8(P04)
SFP+_P19_TX_FLT: CJ9.BB2(BB_TX_FAULT) R559.1 U55.8(P04)
SFP+_P19_TXVCC: C1202.1 C1203.1 CJ9.BB16(BB_TX_VCC) L119.1
SFP+_P20_MOD_ABS: CJ9.CT6(CT_ABS#) Q38.5(G2) R568.1 U28.4(E\N\1\) U49.7(P03)
SFP+_P20_RATE_SEL: CJ9.CT7(CT_RX_RATE_SEL) CJ9.CT9(CT_TX_RATE_SEL) R565.1 R790.2
SFP+_P20_RATE_SEL_OUT: R790.1 U52.7(P03)
SFP+_P20_RX_LOS: CJ9.CT8(CT_RX_LOSS) R567.1 U50.7(P03)
SFP+_P20_RXVCC: C1211.1 C1212.1 CJ9.CT15(CT_RX_VCC) L122.1
SFP+_P20_TX_DIS: CJ9.CT3(CT_TX_DISABLE) R564.1 U56.7(P03)
SFP+_P20_TX_FLT: CJ9.CT2(CT_TX_FAULT) R566.1 U55.7(P03)
SFP+_P20_TXVCC: C1208.1 C1209.1 CJ9.CT16(CT_TX_VCC) L121.1
SFP+_P21_MOD_ABS: CJ9.CB6(CB_ABS#) Q38.2(G1) R575.1 U28.5(E\N\2\) U49.6(P02)
SFP+_P21_RATE_SEL: CJ9.CB7(CB_RX_RATE_SEL) CJ9.CB9(CB_TX_RATE_SEL) R572.1 R792.2
SFP+_P21_RATE_SEL_OUT: R792.1 U52.6(P02)
SFP+_P21_RX_LOS: CJ9.CB8(CB_RX_LOSS) R574.1 U50.6(P02)
SFP+_P21_RXVCC: C1217.1 C1218.1 CJ9.CB15(CB_RX_VCC) L124.1
SFP+_P21_TX_DIS: CJ9.CB3(CB_TX_DISABLE) R571.1 U56.6(P02)
SFP+_P21_TX_FLT: CJ9.CB2(CB_TX_FAULT) R573.1 U55.6(P02)
SFP+_P21_TXVCC: C1214.1 C1215.1 CJ9.CB16(CB_TX_VCC) L123.1
SFP+_P22_MOD_ABS: CJ9.DT6(DT_ABS#) Q39.5(G2) R582.1 U31.4(E\N\1\) U49.5(P01)
SFP+_P22_RATE_SEL: CJ9.DT7(DT_RX_RATE_SEL) CJ9.DT9(DT_TX_RATE_SEL) R579.1 R796.2
SFP+_P22_RATE_SEL_OUT: R796.1 U52.5(P01)
SFP+_P22_RX_LOS: CJ9.DT8(DT_RX_LOSS) R581.1 U50.5(P01)
SFP+_P22_RXVCC: C1223.1 C1224.1 CJ9.DT15(DT_RX_VCC) L126.1
SFP+_P22_TX_DIS: CJ9.DT3(DT_TX_DISABLE) R578.1 U56.5(P01)
SFP+_P22_TX_FLT: CJ9.DT2(DT_TX_FAULT) R580.1 U55.5(P01)
SFP+_P22_TXVCC: C1220.1 C1221.1 CJ9.DT16(DT_TX_VCC) L125.1
SFP+_P23_MOD_ABS: CJ9.DB6(DB_ABS#) Q39.2(G1) R589.1 U31.5(E\N\2\) U49.4(P00)
SFP+_P23_RATE_SEL: CJ9.DB7(DB_RX_RATE_SEL) CJ9.DB9(DB_TX_RATE_SEL) R586.1 R797.2
SFP+_P23_RATE_SEL_OUT: R797.1 U52.4(P00)
SFP+_P23_RX_LOS: CJ9.DB8(DB_RX_LOSS) R588.1 U50.4(P00)
SFP+_P23_RXVCC: C1229.1 C1230.1 CJ9.DB15(DB_RX_VCC) L128.1
SFP+_P23_TX_DIS: CJ9.DB3(DB_TX_DISABLE) R585.1 U56.4(P00)
SFP+_P23_TX_FLT: CJ9.DB2(DB_TX_FAULT) R587.1 U55.4(P00)
SFP+_P23_TXVCC: C1226.1 C1227.1 CJ9.DB16(DB_TX_VCC) L127.1
SFP+_P24_MOD_ABS: CJ9.ET6(ET_ABS#) Q40.5(G2) R428.1 U34.4(E\N\1\) U49.20(P17)
SFP+_P24_RATE_SEL: CJ9.ET7(ET_RX_RATE_SEL) CJ9.ET9(ET_TX_RATE_SEL) R425.1 R802.2
SFP+_P24_RATE_SEL_OUT: R802.1 U52.20(P17)
SFP+_P24_RX_LOS: CJ9.ET8(ET_RX_LOSS) R427.1 U50.20(P17)
SFP+_P24_RXVCC: C1091.1 C1092.1 CJ9.ET15(ET_RX_VCC) L82.1
SFP+_P24_TX_DIS: CJ9.ET3(ET_TX_DISABLE) R424.1 U56.20(P17)
SFP+_P24_TX_FLT: CJ9.ET2(ET_TX_FAULT) R426.1 U55.20(P17)
SFP+_P24_TXVCC: C1088.1 C1089.1 CJ9.ET16(ET_TX_VCC) L81.1
SFP+_P25_MOD_ABS: CJ9.EB6(EB_ABS#) Q40.2(G1) R435.1 U34.5(E\N\2\) U49.19(P16)
SFP+_P25_RATE_SEL: CJ9.EB7(EB_RX_RATE_SEL) CJ9.EB9(EB_TX_RATE_SEL) R432.1 R803.2
SFP+_P25_RATE_SEL_OUT: R803.1 U52.19(P16)
SFP+_P25_RX_LOS: CJ9.EB8(EB_RX_LOSS) R434.1 U50.19(P16)
SFP+_P25_RXVCC: C1097.1 C1099.1 CJ9.EB15(EB_RX_VCC) L84.1
SFP+_P25_TX_DIS: CJ9.EB3(EB_TX_DISABLE) R431.1 U56.19(P16)
SFP+_P25_TX_FLT: CJ9.EB2(EB_TX_FAULT) R433.1 U55.19(P16)
SFP+_P25_TXVCC: C1094.1 C1095.1 CJ9.EB16(EB_TX_VCC) L83.1
SFP+_P26_MOD_ABS: CJ9.FT6(FT_ABS#) Q41.5(G2) R442.1 U37.4(E\N\1\) U49.18(P15)
SFP+_P26_RATE_SEL: CJ9.FT7(FT_RX_RATE_SEL) CJ9.FT9(FT_TX_RATE_SEL) R439.1 R804.2
SFP+_P26_RATE_SEL_OUT: R804.1 U52.18(P15)
SFP+_P26_RX_LOS: CJ9.FT8(FT_RX_LOSS) R441.1 U50.18(P15)
SFP+_P26_RXVCC: C1103.1 C1104.1 CJ9.FT15(FT_RX_VCC) L86.1
SFP+_P26_TX_DIS: CJ9.FT3(FT_TX_DISABLE) R438.1 U56.18(P15)
SFP+_P26_TX_FLT: CJ9.FT2(FT_TX_FAULT) R440.1 U55.18(P15)
SFP+_P26_TXVCC: C1100.1 C1101.1 CJ9.FT16(FT_TX_VCC) L85.1
SFP+_P27_MOD_ABS: CJ9.FB6(FB_ABS#) Q41.2(G1) R449.1 U37.5(E\N\2\) U49.17(P14)
SFP+_P27_RATE_SEL: CJ9.FB7(FB_RX_RATE_SEL) CJ9.FB9(FB_TX_RATE_SEL) R446.1 R806.2
SFP+_P27_RATE_SEL_OUT: R806.1 U52.17(P14)
SFP+_P27_RX_LOS: CJ9.FB8(FB_RX_LOSS) R448.1 U50.17(P14)
SFP+_P27_RXVCC: C1109.1 C1110.1 CJ9.FB15(FB_RX_VCC) L88.1
SFP+_P27_TX_DIS: CJ9.FB3(FB_TX_DISABLE) R445.1 U56.17(P14)
SFP+_P27_TX_FLT: CJ9.FB2(FB_TX_FAULT) R447.1 U55.17(P14)
SFP+_P27_TXVCC: C1106.1 C1107.1 CJ9.FB16(FB_TX_VCC) L87.1
SFP+_PWR_OC_GP1: R623.1 R624.2 R625.2 R627.2 R628.2 U70.L5(IO_3_1)
SFP+_PWR_OC_GP2: R629.2 R630.2 R631.2 R632.2 R1569.1 U70.N9(IO_3_24)
SFP+_PWR_OC_GP3: R633.2 R635.1 R636.2 U70.M13(IO_3_21)
SFP_PWR00_OC_N: R624.1 U26.6(F\A\U\L\T\2\) U26.10(F\A\U\L\T\1\)
SFP_PWR01_OC_N: R625.1 U29.6(F\A\U\L\T\2\) U29.10(F\A\U\L\T\1\)
SFP_PWR02_OC_N: R627.1 U32.6(F\A\U\L\T\2\) U32.10(F\A\U\L\T\1\)
SFP_PWR03_OC_N: R628.1 U35.6(F\A\U\L\T\2\) U35.10(F\A\U\L\T\1\)
SFP_PWR04_OC_N: R629.1 U38.6(F\A\U\L\T\2\) U38.10(F\A\U\L\T\1\)
SFP_PWR05_OC_N: R630.1 U27.6(F\A\U\L\T\2\) U27.10(F\A\U\L\T\1\)
SFP_PWR06_OC_N: R631.1 U30.6(F\A\U\L\T\2\) U30.10(F\A\U\L\T\1\)
SFP_PWR07_OC_N: R632.1 U33.6(F\A\U\L\T\2\) U33.10(F\A\U\L\T\1\)
SFP_PWR08_OC_N: R633.1 U36.6(F\A\U\L\T\2\) U36.10(F\A\U\L\T\1\)
SFP_PWR09_OC_N: R636.1 U39.6(F\A\U\L\T\2\) U39.10(F\A\U\L\T\1\)
SFP_PWR10_OC_N: R637.1 U28.6(F\A\U\L\T\2\) U28.10(F\A\U\L\T\1\)
SFP_PWR11_OC_N: R638.1 U31.6(F\A\U\L\T\2\) U31.10(F\A\U\L\T\1\)
SFP_PWR12_OC_N: R639.1 U34.6(F\A\U\L\T\2\) U34.10(F\A\U\L\T\1\)
SFP_PWR13_OC_N: R640.1 U37.6(F\A\U\L\T\2\) U37.10(F\A\U\L\T\1\)
SFP_PWR_ILIM00: R606.1 U26.7(ILIM)
SFP_PWR_ILIM01: R609.1 U29.7(ILIM)
SFP_PWR_ILIM02: R612.1 U32.7(ILIM)
SFP_PWR_ILIM03: R615.1 U35.7(ILIM)
SFP_PWR_ILIM04: R618.1 U38.7(ILIM)
SFP_PWR_ILIM05: R607.1 U27.7(ILIM)
SFP_PWR_ILIM06: R610.1 U30.7(ILIM)
SFP_PWR_ILIM07: R613.1 U33.7(ILIM)
SFP_PWR_ILIM08: R616.1 U36.7(ILIM)
SFP_PWR_ILIM09: R619.1 U39.7(ILIM)
SFP_PWR_ILIM10: R608.1 U28.7(ILIM)
SFP_PWR_ILIM11: R611.1 U31.7(ILIM)
SFP_PWR_ILIM12: R614.1 U34.7(ILIM)
SFP_PWR_ILIM13: R617.1 U37.7(ILIM)
SI5344B_OE_N: R1980.1 U135.12(O\E\)
SKU_ID0: R1736.2 R1737.2 U150.17(P14)
SKU_ID1: R1738.2 R1739.2 U150.18(P15)
SKU_ID2: R12284.2 R12985.2 U150.19(P16)
SKU_ID3: R12285.2 R12986.2 U150.20(P17)
SMB_NIC1_CLK: R1207.2 U85.34(SMB_CLK)
SMB_NIC1_DAT: R1208.2 U85.36(SMB_DAT)
SMU_DPLL1_LOCK: R1665.1 R1681.1 U70.L3(IO_2_14)
SMU_DPLL2_LOCK: R12484.1 U70.N8(IO_3_12) U139.G9(DPLL2_LOCK)
SMU_DPLL3_LOCK: R1666.1 R1682.1
SMU_I2C_ADDR1: R1684.1 U139.E5(I2C_AD1)
SMU_I2C_ADDR2: R1683.1 U139.D9(I2C_AD2)
SMU_INPUT0_LOS_N: R1677.1 R12799.2 U139.H1(XO_FREQ0/LOS0)
SMU_INPUT1_LOS_N: R1678.1 U70.B9(IO_8_7) U139.J1(XO_FREQ1/LOS1)
SMU_INPUT2_LOS_N: R1679.1 U139.J2(XO_FREQ2/LOS2)
SMU_INPUT3_LOS_N: R1680.1 U139.A11(SONET/SDH/LOS3)
SMU_MASTER: R1661.2 U139.K8(MS/SL)
SPI_BITS_CS_IN_N: R1409.2 U127.38(C\S\)
SPI_BITS_CS_N: R1409.1 U162.22(GPIO.0/CS0#)
SPI_BITS_MISO: R1412.1 U162.24(MISO)
SPI_BITS_MOSI: R1411.1 R12438.2
SPI_BITS_SCK: R12437.2 U127.36(D\S\ / R\D\ / SCLK)
SPI_BITS_SDI: R1411.2 U127.37(RW\ / W\R\ / SDI)
SPI_BITS_SDO: R1412.2 U127.24(D[0] / SDO)
SPI_PHY3_CLK: R1274.1 R1278.1 U46.6(SCLK)
SPI_PHY3_CS_N: U25.G12(SS_N_SROM) U46.1(CS#)
SPI_PHY3_HOLD_N: R1272.2 U46.7(NC/SIO3)
SPI_PHY3_MISO: R1276.2 U25.G14(MISO_SROM) U46.2(SO/SIO1)
SPI_PHY3_MOSI: R1273.2 R1275.1 U25.F9(MOSI_SROM) U46.5(SI/SIO0)
SPI_PHY3_SCK: R1278.2 U25.G10(SCK_SROM)
SPI_PHY3_WP_N: R1277.2 U46.3(WP#/SIO2)
SPI_USB_MOSI: R12438.1 U162.23(MOSI)
SPI_USB_SCK: R12437.1 U162.1(SCK)
SYNC: PR442.1 PU2.35(SYNC)
SYNC_R: PR442.2 PU22.35(SYNC)
TCXO_NCG: R1648.1 X8.1(NCG)
TCXO_OE: R1647.1 X5.1(ENABLE CONTROL) X8.6(TSC(ENABLE))
TP_CLK_25M_PCIE_XTALOUT: TP10.1 U163.3(XOUT)
TP_CPLD_PU_PD: R1696.2 R1721.2 TP20.1
TP_JTAG_BITS_TCK: TP2.1 U127.78(TCK)
TP_JTAG_BITS_TDI: TP3.1 U127.79(TDI)
TP_JTAG_BITS_TDO: TP4.1 U127.76(TDO)
TP_JTAG_BITS_TMS: TP1.1 U127.80(TMS)
TP_JTAG_CPU_TCK: J1.A5(JTAG_TCK) TP129.1
TP_JTAG_CPU_TDI: J1.A6(JTAG_TDI) TP130.1
TP_JTAG_CPU_TDO: J1.A7(JTAG_TDO) TP131.1
TP_JTAG_CPU_TMS: J1.A8(JTAG_TMS) TP132.1
TP_JTAG_NIC1_TDO: TP9.1 U85.4(JTAG_TDO)
TP_JTAG_SMU_TCK: TP6.1 U139.G1(TCK)
TP_JTAG_SMU_TDI: TP7.1 U139.L3(TDI)
TP_JTAG_SMU_TDO: TP8.1 U139.L5(TDO)
TP_JTAG_SMU_TMS: TP5.1 U139.F1(TMS)
TP_MAC_DDRA_AUX0: TP13.1 U1.AK23(DDRA_AUX_0)
TP_MAC_DDRA_AUX1: TP14.1 U1.AH24(DDRA_AUX_1)
TP_MAC_DDRA_PLL_CLK_MON: TP12.1 U1.AG29(DDRA_PLL_CLK_MON)
TP_MAC_DDRA_VREF_MON: TP11.1 U1.AH28(DDRA_VREF_MON)
TP_MAC_DDRB_AUX0: TP15.1 U1.AJ17(DDRB_AUX_0)
TP_MAC_DDRB_AUX1: TP16.1 U1.AH18(DDRB_AUX_1)
TP_MAC_DDRC_AUX0: TP17.1 U1.AK8(DDRC_AUX_0)
TP_MAC_DDRC_AUX1: TP18.1 U1.AD9(DDRC_AUX_1)
TP_MIIM_IIO_LAN_MDC: J1.A9(P3V3_1) TP133.1
TP_MIIM_IIO_LAN_MDIO: J1.A10(P3V3_2) TP134.1
TP_PCIE_CPU_IIO_RX_DN2: J1.A40(PCIE0_RX5_N) TP64.1
TP_PCIE_CPU_IIO_RX_DN3: J1.A36(PCIE0_RX4_N) TP60.1
TP_PCIE_CPU_IIO_RX_DP2: J1.A39(PCIE0_RX5_P) TP63.1
TP_PCIE_CPU_IIO_RX_DP3: J1.A35(PCIE0_RX4_P) TP59.1
TP_PCIE_IIO_TO_MB_TX1_DN: J1.B42(PCIE0_TX6_N) TP104.1
TP_PCIE_IIO_TO_MB_TX1_DP: J1.B41(PCIE0_TX6_P) TP103.1
TP_PCIE_IIO_TO_MB_TX2_DN: J1.B38(PCIE0_TX5_N) TP62.1
TP_PCIE_IIO_TO_MB_TX2_DP: J1.B37(PCIE0_TX5_P) TP61.1
TP_PCIE_IIO_TO_MB_TX3_DN: J1.B34(PCIE0_TX4_N) TP58.1
TP_PCIE_IIO_TO_MB_TX3_DP: J1.B33(PCIE0_TX4_P) TP57.1
TP_TCXO_REF_OUT: TP19.1 X8.3(NC)
UART_BMC_CONSOLE_RX: R1406.1 U154.G1(RXD5)
UART_BMC_CONSOLE_RX_OUT: R1406.2 U98.1(NO)
UART_BMC_CONSOLE_TX: R12349.2 U97.1(NO)
UART_BMC_TO_CPU: J1.B55(PCIE0_TX9_N) R12345.1
UART_BMC_TXD1: R12345.2 U154.W1(GPIOL6/TXD1/VPIB0)
UART_BMC_TXD5: R12349.1 R12380.2 U154.H5(TXD5)
UART_CPU_BMC_MUX_SEL: Q60.2(S) R12896.2 U70.H1(IO_1_9)
UART_CPU_CONSOLE_RX: J1.A56(PCIE0_RX9_P) R1407.1
UART_CPU_CONSOLE_RX_OUT: R1407.2 U98.3(NC)
UART_CPU_CONSOLE_TX: J1.A57(PCIE0_RX9_N) U97.3(NC)
UART_CPU_TO_BMC: R12709.1 U154.U5(GPIOL7/RXD1/VPIB1)
UART_MAC_TX0: R1539.2 U1.AD32(UART0_TX)
UART_MAC_TX1: R1540.2 U1.AB33(UART1_TX)
UART_RJ45_INVALID_N: R12912.2 U89.10(INVALIO)
UART_RS232_RX: C1680.1 D98.2 OJ1.AR6(E3-) R1264.2
UART_RS232_RX_IN: R1264.1 U89.8(R1IN)
UART_RS232_RX_RJ45: U89.9(R1OUT) U151.3(NC)
UART_RS232_RX_USB: J8.12 U151.1(NO)
UART_RS232_TX: C1681.1 D97.2 OJ1.AR3(E2+) R1263.2
UART_RS232_TX_OUT: R1263.1 U89.13(T1OUT)
UART_RS232_TX_RJ45: R12287.1 U89.11(T1IN)
UART_RS232_TX_RJ45_OUT: R12287.2 U152.3(NC)
UART_RS232_TX_USB: J8.10 R12286.1
UART_RS232_TX_USB_OUT: R12286.2 U152.1(NO)
UART_RXD_IN: U98.4(COM) U151.4(COM)
UART_TOD_GNSS_RXD: R1607.1 U1.AD31(UART1_RX)
UART_TOD_GNSS_TXD: R1540.1 U124.21(RXD)
UART_TOD_RS422_RXD: R1594.2 U1.AC33(UART0_RX)
UART_TOD_RS422_TXD: R1539.1 U110.5(D)
UART_TXD_OUT: U97.4(COM) U152.4(COM)
UART_XCVR_C1+: C1679.1 U89.2(C1+)
UART_XCVR_C1-: C1679.2 U89.4(C1-)
UART_XCVR_C2+: C1682.1 U89.5(C2+)
UART_XCVR_C2-: C1682.2 U89.6(C2-)
UART_XCVR_V+: C1683.1 U89.3(V+)
UART_XCVR_V-: C1684.1 U89.7(V-)
USB2_BMC_HDN: R12348.1 U154.AB20(USB2_DN/USB2_HDN)
USB2_BMC_HDP: R12347.1 U154.AB21(USB2_DP/USB2_HDP)
USB2_PCH_P0_DN: J1.B75(PCIE0_TX14_N) U96.2(1D-)
USB2_PCH_P0_DP: J1.B74(PCIE0_TX14_P) U96.1(1D+)
USB2_PCH_P1_DN: J1.A33(RSVD_5) R12724.1
USB2_PCH_P1_DP: J1.A32(RSVD_4) R12725.1
USB2_PCH_P3_DN: J1.A80(PCIE0_RX15_P) R12348.2
USB2_PCH_P3_DP: J1.A81(PCIE0_RX15_N) R12347.2
USB2VRES: R12346.1 U154.AA20(USB2VRES)
USB11_BMC_HDN: U96.4(2D-) U154.K3(USB11_DN/USB11_HDN2)
USB11_BMC_HDP: U96.3(2D+) U154.K4(USB11_DP/USB11_HDP2)
USB_CONSOLE_PRSNT: Q13.3(D) Q54.2(S) R12295.2
USB_CONSOLE_PRSNT_N: J8.9 Q13.1(G) R12302.2
USB_MUX_OE_N: R1404.2 U96.6(O\E\)
USB_PCH_P2_DN: J1.B9(JTAG_TRST#) U162.4(D-)
USB_PCH_P2_DP: J1.B8(P3V3_0) U162.3(D+)
USB_PORT_DN: L140.2 R1262.1 U96.7(D-)
USB_PORT_DP: L140.1 R1265.1 U96.8(D+)
USB_PWR_EN: R1270.2 U43.3(EN) U70.N3(IO_2_10)
USB_PWR_ILIM: R1266.2 U43.5(ILIM)
USB_PWR_OC_N: R1267.2 U43.4(F\A\U\L\T\) U70.M3(IO_2_12)
VCORE_SENSE_GND: PC392.2 PR147.1 U1.AC18(VSS_SENSE)
VCORE_SENSE_PWR: PC392.1 PR141.1 U1.AC19(VDDC_SENSE)
VFLT_P1V8_JA_VDD: C2146.1 C2147.2 C2148.2 C2149.2 C2150.2 C2174.1 L190.1 U135.21(VDD1) U135.32(VDD2) U135.39(VDD3) U135.40(VDD4)
VFLT_P1V8_SMU_VDDC: C2084.1 C2085.1 C2086.2 C2087.1 C2088.1 L179.2 U139.H12(VDDD_1_8_1) U139.L10(VDDD_1_8_0)
VFLT_P3V3_1PPS_BUFF: C2420.2 C2421.1 L208.2 R12944.1 U175.7(VDD)
VFLT_P3V3_1PPS_BUFF2: C2125.1 C2392.2 L185.2 R12762.1 U168.7(VDD)
VFLT_P3V3_4K_BUFF: C2415.2 C2416.1 L207.2 R12931.1 U174.7(VDD)
VFLT_P3V3_5P49V_VDDA: C2046.2 C2047.2 L173.2 U163.5(VDDA)
VFLT_P3V3_5P49V_VDDD: C2357.2 C2358.2 L203.2 U163.22(VDDD)
VFLT_P3V3_BMC_ADCAV33: C2280.1 C2281.2 C2282.1 C2283.1 L197.2 U154.P3(ADCAV33)
VFLT_P3V3_BMC_DACV33: C2276.1 C2277.2 C2278.1 L196.2 U154.P1(DACAV33) U154.T3(DACDV33)
VFLT_P3V3_BMC_HPLLAV33: C2299.1 C2300.2 C2301.1 L199.2 U154.V17(HPLLAV33)
VFLT_P3V3_BMC_MPLLAV33: C2290.2 C2291.1 C2297.1 L198.2 U154.AB19(MPLLAV33)
VFLT_P3V3_BMC_MPLLDV12: C2308.1 C2309.2 C2310.1 L200.2 U154.Y18(MPLLDV12)
VFLT_P3V3_BMC_OSC: C2266.2 C2267.1 L194.1 X13.4(VDD)
VFLT_P3V3_BMC_USB2AV33: C2269.1 C2270.1 L195.1 U154.W18(USB2AV33)
VFLT_P3V3_BMC_VPLLAV12: C2322.1 C2323.2 C2324.1 L201.2 U154.W19(V1PLLAV12) U154.Y20(V2PLLAV12)
VFLT_P3V3_CLK_25M: C2052.1 C2053.2 L175.2 U132.5(VCC)
VFLT_P3V3_CLK_156.25MHZ: C2055.1 C2056.2 L176.2 U133.5(VCC)
VFLT_P3V3_CPLD_OSC: C1380.2 C1381.1 L135.1 R994.2 X1.4(VDD)
VFLT_P3V3_CPLD_VDDA: C1405.1 C1406.2 C1407.1 C1408.2 C1409.1 L136.2 U70.D4(VDDA_3) U70.D10(VDDA_2) U70.K4(VDDA_1) U70.K9(VDDA_4)
VFLT_P3V3_DDR_CLK_100MHZ: C2043.1 C2044.2 L172.2 U129.5(VCC)
VFLT_P3V3_DDR_OSC_100MHZ: C2049.1 C2050.2 L174.2 R1644.2 X7.6(VDD)
VFLT_P3V3_GNSS_VBCKP: C1986.2 L89.2 R12902.1 U124.22(V_BCKP)
VFLT_P3V3_GNSS_VCC: C1983.2 C1985.2 L19.1 R12822.1 R12902.2 U124.23(VCC)
VFLT_P3V3_JA_VDDA: C2151.2 C2152.2 C2153.1 C2175.1 L188.1 U135.8(VDDA1) U135.9(VDDA2)
VFLT_P3V3_JA_VDDO: C2140.1 C2141.2 C2143.2 C2144.2 C2145.2 C2173.1 L187.1 U135.18(VDDO0) U135.23(VDDO1) U135.29(VDDO2) U135.34(VDDO3)
VFLT_P3V3_JA_VDDS: C2155.2 C2156.1 L189.1 U135.26(VDDS)
VFLT_P3V3_NIC1_AVDD: C1642.2 C1643.1 L138.1 U85.51(VDD3P3[3])
VFLT_P3V3_NIC1_OSC: C1940.2 C1941.1 L141.1 R1271.2 X4.4(VDD)
VFLT_P3V3_OCXO_DPLL: C2134.1 C2135.1 C2136.1 C2137.2 C2138.1 L186.2 X11.3(VCC) X14.6(VCC)
VFLT_P3V3_OSC_25M_BUF: C2058.1 C2059.2 L177.2 R1647.2 R1648.2 X5.4(VDD) X8.5(VCC)
VFLT_P3V3_PCIE_25M: C1687.2 C1688.1 L139.1 R1074.2 X3.4(VDD)
VFLT_P3V3_PTP_OSC: C1369.2 C1370.1 L137.1 X2.4(VDD)
VFLT_P3V3_SMU_VDDA1: C2098.1 C2099.1 C2100.1 C2101.2 C2102.1 C2103.1 C2104.1 L181.2 U139.C1(VDDA0) U139.D2(VDDA3) U139.K1(VDDA8) U139.K2(VDDA9)
VFLT_P3V3_SMU_VDDA2: C2106.1 C2107.1 C2108.1 C2109.2 C2110.1 C2111.1 C2112.1 C2139.2 L182.2 U139.C6(VDDA1) U139.C7(VDDA2) U139.F2(VDDA4) U139.F9(VDDA5) U139.G2(VDDA6) U139.H2(VDDA7)
VFLT_P3V3_SMU_VDDAO: C2114.1 C2115.1 C2116.1 C2117.2 C2118.1 C2119.1 C2120.1 C2172.2 L183.2 U139.A5(VDDAO0) U139.A7(VDDAO1) U139.B2(VDDAO2) U139.B3(VDDAO3) U139.L4(VDDAO4) U139.M4(VDDAO5)
VFLT_P3V3_SMU_VDDC: C2078.1 C2079.1 C2080.2 C2081.1 C2082.1 L178.2 U139.D5(VDDD0) U139.F7(VDDD1)
VFLT_P3V3_SMU_VDDO: C2090.1 C2091.1 C2092.2 C2093.1 C2094.1 C2095.1 C2096.1 L180.2 U139.E4(VDDDO0) U139.E6(VDDDO1) U139.L7(VDDDO2) U139.M8(VDDDO3)
VFLT_VP1P0_MAC_NIF_TRXVDD: C423.1 C424.1 C425.2 C426.1 C427.1 C428.2 C429.1 C430.1 C431.1 C432.2 C433.1 C434.2 C435.1 C452.1 C453.1 C454.2 C455.1 C456.1 C457.2 C458.1 C459.2 C460.1 C461.1 C462.2 C463.1 C464.2 C465.1 C466.2 L4.2 L21.2 U1.A11(NIF_TVDD1P0_Q00_01_1) U1.A15(NIF_TVDD1P0_Q00_01_2) U1.A19(NIF_TVDD1P0_Q02_03_1) U1.A23(NIF_TVDD1P0_Q02_03_2) U1.B11(NIF_TVDD1P0_Q00_01_3) U1.B15(NIF_TVDD1P0_Q00_01_4) U1.B19(NIF_TVDD1P0_Q02_03_3) U1.B23(NIF_TVDD1P0_Q02_03_4) U1.F11(NIF_RVDD1P0_Q00_01_1) U1.F15(NIF_RVDD1P0_Q00_01_2) U1.F19(NIF_RVDD1P0_Q02_03_1) U1.F23(NIF_RVDD1P0_Q02_03_2) U1.G11(NIF_RVDD1P0_Q00_01_3) U1.G15(NIF_RVDD1P0_Q00_01_4) U1.G19(NIF_RVDD1P0_Q02_03_3) U1.G23(NIF_RVDD1P0_Q02_03_4) U1.J10(NIF_RVDD1P0_Q00_01_5) U1.J14(NIF_RVDD1P0_Q00_01_6) U1.J18(NIF_RVDD1P0_Q02_03_5) U1.J22(NIF_RVDD1P0_Q02_03_6) U1.K10(NIF_RVDD1P0_Q00_01_7) U1.K14(NIF_RVDD1P0_Q00_01_8) U1.K18(NIF_RVDD1P0_Q02_03_7) U1.K22(NIF_RVDD1P0_Q02_03_8)
VFLT_VP1P0_MAC_NIFE_TRXVDD0: C513.1 C514.1 C515.2 C516.1 C517.1 C518.2 C519.1 C520.2 C521.1 C522.1 C523.2 C524.1 C525.2 C526.1 C531.1 C532.1 C533.2 C534.1 C535.1 C536.2 C537.1 C538.2 C539.1 C540.1 C541.2 C542.1 C543.2 C544.1 C549.1 C550.1 C551.2 C552.1 C553.1 C554.2 C555.1 C556.2 C557.1 C558.1 C559.2 C560.1 C561.2 C562.1 L8.2 U1.A27(NIFE_TVDD1P0_Q04_05_06_1) U1.A31(NIFE_TVDD1P0_Q04_05_06_2) U1.A35(NIFE_TVDD1P0_Q04_05_06_3) U1.B27(NIFE_TVDD1P0_Q04_05_06_4) U1.B31(NIFE_TVDD1P0_Q04_05_06_5) U1.B35(NIFE_TVDD1P0_Q04_05_06_6) U1.C28(NIFE_TVDD1P0_Q04_05_06_7) U1.C32(NIFE_TVDD1P0_Q04_05_06_8) U1.C36(NIFE_TVDD1P0_Q04_05_06_9) U1.D28(NIFE_TVDD1P0_Q04_05_06_10) U1.D32(NIFE_TVDD1P0_Q04_05_06_11) U1.D36(NIFE_TVDD1P0_Q04_05_06_12) U1.F27(NIFE_RVDD1P0_Q04_05_06_1) U1.F31(NIFE_RVDD1P0_Q04_05_06_2) U1.F35(NIFE_RVDD1P0_Q04_05_06_3) U1.G27(NIFE_RVDD1P0_Q04_05_06_4) U1.G31(NIFE_RVDD1P0_Q04_05_06_5) U1.G35(NIFE_RVDD1P0_Q04_05_06_6) U1.H28(NIFE_RVDD1P0_Q04_05_06_7) U1.H32(NIFE_RVDD1P0_Q04_05_06_8) U1.H36(NIFE_RVDD1P0_Q04_05_06_9) U1.J28(NIFE_RVDD1P0_Q04_05_06_10) U1.J32(NIFE_RVDD1P0_Q04_05_06_11) U1.J36(NIFE_RVDD1P0_Q04_05_06_12) U1.N31(NIFE_RVDD1P0_Q07_1) U1.N32(NIFE_RVDD1P0_Q07_2) U1.N36(NIFE_TVDD1P0_Q07_1) U1.N37(NIFE_TVDD1P0_Q07_2) U1.P29(NIFE_RVDD1P0_Q07_3) U1.P30(NIFE_RVDD1P0_Q07_4) U1.P34(NIFE_TVDD1P0_Q07_3) U1.P35(NIFE_TVDD1P0_Q07_4)
VFLT_VP1P0_MAC_NIFE_TRXVDD1: C436.2 C437.1 C438.2 C439.2 C440.1 C441.1 C442.2 C443.1 C444.1 C445.2 C446.2 C447.1 C448.1 C449.1 C450.1 C451.1 C468.2 C469.2 C470.2 C471.1 C472.2 C473.2 C474.1 C475.1 C476.2 C477.1 C478.1 C479.1 C480.2 C481.1 C482.2 C483.2 C484.1 C485.1 C486.2 C487.1 C488.1 C489.1 L5.1 U1.A3(NIFE_TVDD1P0_Q08_09_10_1) U1.A7(NIFE_TVDD1P0_Q08_09_10_2) U1.B3(NIFE_TVDD1P0_Q08_09_10_3) U1.B7(NIFE_TVDD1P0_Q08_09_10_4) U1.C2(NIFE_TVDD1P0_Q08_09_10_5) U1.C6(NIFE_TVDD1P0_Q08_09_10_6) U1.D2(NIFE_TVDD1P0_Q08_09_10_7) U1.D6(NIFE_TVDD1P0_Q08_09_10_8) U1.F3(NIFE_RVDD1P0_Q08_09_10_1) U1.F7(NIFE_RVDD1P0_Q08_09_10_2) U1.G3(NIFE_RVDD1P0_Q08_09_10_3) U1.G7(NIFE_RVDD1P0_Q08_09_10_4) U1.H2(NIFE_RVDD1P0_Q08_09_10_5) U1.H6(NIFE_RVDD1P0_Q08_09_10_6) U1.J2(NIFE_RVDD1P0_Q08_09_10_7) U1.J6(NIFE_RVDD1P0_Q08_09_10_8) U1.N1(NIFE_TVDD1P0_Q08_09_10_9) U1.N2(NIFE_TVDD1P0_Q08_09_10_10) U1.N6(NIFE_RVDD1P0_Q08_09_10_9) U1.N7(NIFE_RVDD1P0_Q08_09_10_10) U1.P3(NIFE_TVDD1P0_Q08_09_10_11) U1.P4(NIFE_TVDD1P0_Q08_09_10_12) U1.P8(NIFE_RVDD1P0_Q08_09_10_11) U1.P9(NIFE_RVDD1P0_Q08_09_10_12) U1.U1(NIFE_TVDD1P0_Q11_1) U1.U2(NIFE_TVDD1P0_Q11_2) U1.U6(NIFE_RVDD1P0_Q11_1) U1.U7(NIFE_RVDD1P0_Q11_2) U1.V3(NIFE_TVDD1P0_Q11_3) U1.V4(NIFE_TVDD1P0_Q11_4) U1.V8(NIFE_RVDD1P0_Q11_3) U1.V9(NIFE_RVDD1P0_Q11_4)
VFLT_VP1P0_MAC_PCIE_TRXVDD: C505.1 C506.2 C507.1 C508.1 C509.2 C510.1 L7.1 U1.U36(PCIE_TVDD1P0_1) U1.U37(PCIE_TVDD1P0_2) U1.V34(PCIE_RVDD1P0_1) U1.V35(PCIE_RVDD1P0_2)
VFLT_VP1P0_MACS_PCIE_PLL: C527.2 C528.1 C529.1 L9.1 U1.W37(PCIE_PVDD1P0)
VFLT_VP1P0_MACS_TSC_PLL: C564.1 C565.1 C566.2 C567.1 C568.1 C569.2 C570.1 C571.2 C572.1 C573.1 C574.2 C575.1 C576.2 C577.1 C582.2 C583.1 C584.1 C585.2 C586.1 C587.2 C588.1 C589.1 C590.2 C591.1 C592.2 C593.1 L11.2 U1.L27(NIFE_PVDD1P0_Q06) U1.M11(NIFE_PVDD1P0_Q10) U1.M12(NIFE_PVDD1P0_Q09) U1.M13(NIFE_PVDD1P0_Q08) U1.M17(NIF_PVDD1P0_Q00) U1.M18(NIF_PVDD1P0_Q01) U1.M19(NIF_PVDD1P0_Q02) U1.M20(NIF_PVDD1P0_Q03) U1.M25(NIFE_PVDD1P0_Q04) U1.M26(NIFE_PVDD1P0_Q05) U1.Y6(NIFE_PVDD1P0_Q11) U1.Y28(NIFE_PVDD1P0_Q07)
VFLT_VP1P0_PHY1_SFI_PLL: C877.1 C878.1 C879.2 C880.1 C881.2 L36.2 U23.J13(PVDDPLL_0) U23.K13(PVDDPLL_1)
VFLT_VP1P0_PHY1_SFI_PWR: C857.1 C858.1 C859.1 C860.2 C861.1 C862.2 C863.2 C864.2 C865.2 C900.1 L34.2 U23.A14(PVDDTX_B0) U23.C14(PVDDTX_B1) U23.E14(PVDDRX_B0) U23.G14(PVDDRX_B1) U23.J15(PVDDRX_A1) U23.M14(PVDDRX_A0) U23.P14(PVDDTX_A0) U23.T14(PVDDTX_A1)
VFLT_VP1P0_PHY1_XFI_PLL: C882.2 C883.2 C884.1 L37.1 U23.J4(XVDDPLL_0) U23.K4(XVDDPLL_1)
VFLT_VP1P0_PHY1_XFI_PWR: C866.2 C867.1 C868.2 C869.1 C870.2 C871.1 C872.2 C873.2 C874.1 L35.1 U23.A3(XVDDTX_B0) U23.C3(XVDDTX_B1) U23.E3(XVDDRX_B0) U23.G3(XVDDRX_B1) U23.J2(XVDDRX_A0) U23.M3(XVDDRX_A1) U23.P3(XVDDTX_A0) U23.T3(XVDDTX_A1)
VFLT_VP1P0_PHY3_DVDD: C943.1 C945.1 C947.1 C948.1 C949.1 C950.2 C951.1 C952.2 C953.2 C954.2 L44.2 U25.H10(DVDD0) U25.H12(DVDD1) U25.J7(DVDD2) U25.K7(DVDD3) U25.L8(DVDD4) U25.L10(DVDD5) U25.L12(DVDD6)
VFLT_VP1P0_PHY3_PLL: C988.2 C989.2 C990.1 L48.1 U25.F6(AVDDPLL0) U25.N6(AVDDPLL1)
VFLT_VP1P0_PHY3_XFI_RX: C944.1 C955.2 C956.1 C957.1 C958.2 C959.1 C960.2 C961.1 C962.2 C963.2 C964.1 L42.1 L45.1 U25.F4(AVDDRX0) U25.F8(AVDDRX1) U25.F10(AVDDRX2) U25.F12(AVDDRX3) U25.F14(AVDDRX4) U25.N4(AVDDRX5) U25.N8(AVDDRX6) U25.N10(AVDDRX7) U25.N12(AVDDRX8) U25.N14(AVDDRX9)
VFLT_VP1P0_PHY3_XFI_TX: C970.1 C971.2 C972.1 C973.1 L46.1 U25.G5(AVDDTX0) U25.G13(AVDDTX1) U25.M5(AVDDTX2) U25.M13(AVDDTX3)
VFLT_VP1P8_MAC_VDDO: C401.1 C402.1 C2388.1 L205.1 U1.AJ36(FC_SYNCE_VDDO_1) U1.AP36(FC_SYNCE_VDDO_2)
VFLT_VP1P8_MAC_VDDP: C403.1 C404.2 C405.1 C406.1 L204.2 U1.AB29(IO_VDDP_1P8_1) U1.AE28(IO_VDDP_1P8_2)
VFLT_VP1P8_MACS_BS01_PLL: C419.2 C420.1 L3.1 U1.AE29(FC_SYNCE_VDDP)
VFLT_VP1P8_MACS_BS_PLL: C610.2 C611.1 C612.1 L17.1 U1.U31(BS_PLL_AVDD1P8)
VFLT_VP1P8_MACS_CORE_PLL: C545.2 C546.1 C547.1 L10.1 U1.Y17(C_PLL_AVDD1P8)
VFLT_VP1P8_MACS_MCU_PLL: C578.2 C579.1 C580.1 L12.1 U1.Y32(UC_PLL_AVDD1P8)
VFLT_VP1P8_MACS_NIF_PLL: C598.2 C599.1 C600.1 L14.1 U1.N23(NIF_LCPLL_AVDD1P8)
VFLT_VP1P8_MACS_NIFE0_PLL: C606.2 C607.1 C608.1 L16.1 U1.V25(NIFE_LCPLL0_AVDD1P8)
VFLT_VP1P8_MACS_NIFE1_PLL: C614.2 C615.1 C616.1 L18.1 U1.T13(NIFE_LCPLL1_AVDD1P8)
VFLT_VP1P8_MACS_SYNCE0_PLL: C594.2 C595.1 C596.1 L13.1 U1.AE26(SYNCE_0_PLL_AVDD1P8)
VFLT_VP1P8_MACS_SYNCE1_PLL: C602.2 C603.1 C604.1 L15.1 U1.AD25(SYNCE_1_PLL_AVDD1P8)
VFLT_VP1P25_MAC_NIF_TVDD: C491.1 C492.1 C493.2 C494.1 C495.1 C496.2 C497.1 C498.2 C499.1 C500.1 C501.2 C502.1 C503.2 C504.1 L6.2 U1.C10(NIF_TVDD1P25_Q00_1) U1.C14(NIF_TVDD1P25_Q01_1) U1.C18(NIF_TVDD1P25_Q02_1) U1.C22(NIF_TVDD1P25_Q03_1) U1.D10(NIF_TVDD1P25_Q00_2) U1.D14(NIF_TVDD1P25_Q01_2) U1.D18(NIF_TVDD1P25_Q02_2) U1.D22(NIF_TVDD1P25_Q03_2)
VFLT_VP1P25_PHY3_XFI_TRX: C977.2 C978.1 C979.1 C980.2 C981.1 C982.1 L47.1 U25.G7(AVDDTXDRV0) U25.G11(AVDDTXDRV1) U25.M7(AVDDTXDRV2) U25.M9(AVDDTXDRV3) U25.M11(AVDDTXDRV4)
VFLT_VP3P3_MAC_VDDO: C382.2 C383.1 C384.1 C385.2 C386.1 C387.2 C388.1 L206.2 U1.AA37(IO_VDDO_3P3_1) U1.AB32(IO_VDDO_3P3_2) U1.AE37(IO_VDDO_3P3_3) U1.AF31(IO_VDDO_3P3_4) U1.AG35(IO_VDDO_3P3_5) U1.AM34(IO_VDDO_3P3_6)
VMG_BMC_HEATER_EN: U73.36(TCK/GPIO19) U154.Y4(GPION5/PWM5/VPIG5)
VMG_BMC_HEATER_HIGH: PR497.2 U61.4(Y)
VMG_BMC_HEATER_HIGH_BMC: PR301.1 U61.1(B) U154.AB2(GPION7/PWM7/VPIG7)
VMG_BMC_HEATER_HIGH_HWM: PR300.1 U61.2(A) U73.38(TDI/GPIO21)
VMG_BMC_HEATER_LOW: PR499.2 U60.4(Y)
VMG_BMC_HEATER_LOW_BMC: PR299.1 U60.1(B) U154.AA3(GPION6/PWM6/VPIG6)
VMG_BMC_HEATER_LOW_HWM: PR298.1 U60.2(A) U73.37(TDO/GPIO20)
VMG_P1V0_DDR_HIGH: PR214.2 U58.7(P03)
VMG_P1V0_DDR_LOW: PR211.2 U58.6(P02)
VMG_P1V0_PHY_HIGH: PR193.2 U58.9(P05)
VMG_P1V0_PHY_LOW: PR190.2 U58.8(P04)
VMG_P1V2_HIGH: PR233.2 U58.14(P11)
VMG_P1V2_LOW: PR230.2 U58.13(P10)
VMG_P1V8_HIGH: PR399.2 U58.16(P13)
VMG_P1V8_LOW: PR401.2 U58.15(P12)
VMG_P1V25_HIGH: PR256.2 U58.11(P07)
VMG_P1V25_LOW: PR253.2 U58.10(P06)
VMG_P2V5_HIGH: PR324.2 U58.5(P01)
VMG_P2V5_LOW: PR323.2 U58.4(P00)
VMG_P3V3_HIGH: PR102.2 U58.18(P15)
VMG_P3V3_LOW: PR99.2 U58.17(P14)
VMG_P5V_HIGH: PR72.2 U58.20(P17)
VMG_P5V_LOW: PR69.2 U58.19(P16)
VMON_BMC_HEATER: C2434.2 R12966.1 R12967.2 U154.L3(ADC2/GPIW2)
VMON_HWM_P1V0_PHY_VIN: C1416.2 R1054.1 U73.2(MON2)
VMON_HWM_P1V2_VIN: C1415.2 R1053.1 U73.3(MON3)
VMON_HWM_P1V8_VIN: C1422.2 R1060.1 R1068.2 U73.5(MON5)
VMON_HWM_P1V25_VIN: C1414.2 R1052.1 U73.4(MON4)
VMON_HWM_P3V3_VIN: C1420.2 R1058.1 R1066.2 U73.59(MON7)
VMON_HWM_P12V_VIN: C2218.2 R1061.1 R1063.2 U73.6(MON6)
VMON_HWM_TEMP_AMB: R13803.1 U73.54(MON12) U198.3(VOUT)
VMON_HWM_TEMP_BMC: R794.1 U73.50(MON10) U181.3(VOUT)
VMON_HWM_TEMP_CPU: J1.B82(RSVD_2) U73.52(MON11)
VMON_HWM_TEMP_HEATER: J19.3 R793.1 R1919.2 U73.63(MON9)
VMON_HWM_TEMP_MAC: U73.62(MON8) U180.3(VOUT)
VMON_HWM_TEMP_PHY3: U73.56(MON13) U182.3(VOUT)
VMON_HWM_VCORE_VIN: C1418.2 R1056.1 U73.1(MON1)
VMON_P1V0_DDR_VIN: C1417.2 R1055.1 U154.L1(ADC4/GPIW4)
VMON_P2V5_VIN: C1421.2 R1059.1 R1067.2 U154.L2(ADC3/GPIW3)
VMON_P5V0_VIN: C1419.2 R1057.1 R1065.2 U154.M5(ADC5/GPIW5)
VMON_P5V_SB_VIN: C2327.2 R12282.2 R12283.1 U154.M4(ADC6/GPIW6)
VMON_P12V_VIN: C2435.2 R12968.1 R12969.2 U154.L4(ADC1/GPIW1)
VMON_TEMP_OCXO: U154.P5(ADC15/GPIX7) U201.3(VOUT)
VOUT_HEATER_BMC: J19.1 PC419.1 PC421.1 PC424.1 PC427.1 PC428.1 PC430.1 PL23.2 PR486.2 R12966.2 R13044.1
VP0P9_NIC1_VOUT: C1624.1 C1625.2 C1626.2 C1627.2 C1628.1 C1629.1 C1630.1 C1631.1 U85.11(VDD0P9[0]) U85.32(VDD0P9[1]) U85.38(VDDO0P9_OUT) U85.42(VDD0P9[2]) U85.59(VDD0P9[3])
VP1P5_NIC1_VOUT: C1638.1 C1639.2 C1640.2 U85.39(VDD1P5_OUT) U85.47(VDD1P5[0]) U85.56(VDD1P5[1])
VSENSE_BMC_P1V26: R12731.1 U154.N3(ADC12/GPIX4)
VSENSE_BMC_P1V538: R12732.1 U154.N2(ADC13/GPIX5)
VSENSE_BMC_P3V3: C2378.1 R12733.1 R12734.1 U154.N1(ADC14/GPIX6)
VSHARE: PC395.1 PR443.1 PU2.32(VSHARE)
VSHARE_R: PC393.1 PR443.2 PU22.32(VSHARE)
VTT_DDR: C118.2 C119.1 C120.2 C121.2 C122.1 C123.2 C124.1 C125.2 C126.2 C127.1 C128.2 C129.1 C130.2 C131.2 C132.1 C133.2 C134.1 C135.2 C136.2 C137.1 C138.2 C139.2 C140.1 C141.2 C142.2 C143.1 C144.2 C145.1 C146.2 C147.2 C148.1 C149.2 C150.1 C151.2 C152.2 C153.1 C154.2 C155.1 C156.2 C157.2 C158.1 C159.2 C160.2 C161.1 C162.2 C163.2 C164.1 C165.2 C166.1 C167.2 C168.2 C169.1 C170.2 C171.1 C172.2 C173.2 C174.1 C175.2 C176.1 C177.2 C178.2 C179.1 C180.2 C181.1 C182.2 C183.1 C184.1 C185.2 C186.1 C187.2 C188.1 C189.1 C190.2 C191.1 C192.2 C193.1 C194.1 C195.2 C196.1 C197.2 C198.1 C199.1 C200.2 C201.1 C202.1 C203.2 C204.1 C205.1 C206.2 C207.1 C208.2 C209.1 C210.1 C211.2 C212.1 C213.2 C214.1 C215.1 C216.2 C217.1 C218.2 C219.1 C220.1 C221.2 C222.1 C223.1 C224.2 C225.1 C226.1 C227.2 C228.1 C229.2 C230.1 C231.1 C232.2 C233.1 C234.2 C235.1 C236.1 C237.2 C238.1 C239.2 C240.1 C241.1 C242.2 C243.1 PC211.1 PC212.1 PC213.1 PC214.1 PU10.3(VO) PU10.5(VOSNS) R83.2 R84.2 R85.2 R86.2 R87.2 R88.2 R89.2 R90.2 R91.2 R92.2 R93.2 R94.2 R96.2 R98.2 R99.2 R101.2 R105.2 R107.2 R109.2 R110.2 R111.2 R112.2 R113.2 R114.2 R115.2 R116.2 R117.2 R118.2 R126.2 R127.2 R128.2 R129.2 R130.2 R131.2 R132.2 R133.2 R134.2 R135.2 R136.2 R137.2 R139.2 R141.2 R143.2 R144.2 R148.2 R149.2 R152.2 R153.2 R154.2 R155.2 R156.2 R157.2 R158.2 R159.2 R160.2 R161.2 R167.2 R168.2 R169.2 R170.2 R171.2 R172.2 R173.2 R174.2 R175.2 R176.2 R177.2 R178.2 R180.2 R182.2 R183.2 R185.2 R187.2 R190.2 R193.2 R194.2 R195.2 R196.2 R197.2 R198.2 R199.2 R200.2 R201.2 R202.2
VTT_DDR_EN: PC217.1 PR18.1 PU10.7(EN)
VTT_DDR_PG: PR236.2 PR333.1 PU10.9(PGOOD)
VTT_DDR_REFIN: PC215.1 PR235.2 PR237.1 PU10.1(REFIN)
VTT_DDR_REFOUT: PC216.1 PU10.6(REFOUT)
XFI_MAC_TO_PHY1_DN0: U1.D37(NIFE_TX_24_N) U23.T5(XFI0_IN)
XFI_MAC_TO_PHY1_DN1: U1.D35(NIFE_TX_26_N) U23.P4(XFI1_IN)
XFI_MAC_TO_PHY1_DN2: U1.B36(NIFE_TX_25_N) U23.M5(XFI2_IN)
XFI_MAC_TO_PHY1_DN3: U1.B34(NIFE_TX_27_N) U23.J3(XFI3_IN)
XFI_MAC_TO_PHY1_DN4: U1.C33(NIFE_TX_23_N) U23.G4(XFI4_IN)
XFI_MAC_TO_PHY1_DN5: U1.A32(NIFE_TX_22_N) U23.E5(XFI5_IN)
XFI_MAC_TO_PHY1_DN6: U1.C31(NIFE_TX_21_N) U23.C4(XFI6_IN)
XFI_MAC_TO_PHY1_DN7: U1.A30(NIFE_TX_20_N) U23.A5(XFI7_IN)
XFI_MAC_TO_PHY1_DP0: U1.C37(NIFE_TX_24_P) U23.T4(XFI0_IP)
XFI_MAC_TO_PHY1_DP1: U1.C35(NIFE_TX_26_P) U23.P5(XFI1_IP)
XFI_MAC_TO_PHY1_DP2: U1.A36(NIFE_TX_25_P) U23.M4(XFI2_IP)
XFI_MAC_TO_PHY1_DP3: U1.A34(NIFE_TX_27_P) U23.K3(XFI3_IP)
