# Allegro board T99O089T00_025_20180609.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R12754  49.9  [R-0402S0]  143.76 121.85 90 bottom
R12755  49.9  [R-0402S0]  143.76 122.87 90 bottom
R12762  4.7K  [R-0402S0]  35.96 56.79 0 top
R12763  33ohm  [R-0402S0]  29.16 95.77 90 top
R12764  33ohm  [R-0402S0]  29.16 94.8 90 top
R12765  124ohm  [R-0402S0]  158.13 113.71 180 top
R12766  82.5ohm  [R-0402S0]  158.14 113.7 180 bottom
R12767  124ohm  [R-0402S0]  159.54 113.71 180 top
R12768  82.5ohm  [R-0402S0]  159.54 113.7 180 bottom
R12769  124ohm  [R-0402S0]  154.91 117.5 90 bottom
R12770  82.5ohm  [R-0402S0]  154.91 117.51 90 top
R12771  124ohm  [R-0402S0]  154.91 116.54 90 bottom
R12772  82.5ohm  [R-0402S0]  154.91 116.54 90 top
R12773  124ohm  [R-0402S0]  181.61 158.3 180 top
R12774  124ohm  [R-0402S0]  183.01 158.3 180 top
R12775  82.5ohm  [R-0402S0]  181.61 156.52 180 top
R12776  82.5ohm  [R-0402S0]  183.01 156.52 180 top
R12777  49.9  [R-0402S0]  140.81 126.3 180 bottom
R12778  49.9  [R-0402S0]  139.69 126.3 180 bottom
R12779  49.9  [R-0402S0]  143.76 119.89 90 bottom
R12780  49.9  [R-0402S0]  143.76 120.83 90 bottom
R12781  49.9  [R-0402S0]  142.23 116.77 0 bottom
R12782  49.9  [R-0402S0]  141.22 116.77 0 bottom
R12783  33ohm  [R-0402S0]  139.69 126.3 180 top
R12784  33ohm  [R-0402S0]  140.81 126.3 180 top
R12785  33ohm  [R-0402S0]  141.22 116.77 0 top
R12786  33ohm  [R-0402S0]  142.23 116.77 0 top
R12787  33ohm  [R-0402S0]  143.76 120.83 90 top
R12788  33ohm  [R-0402S0]  143.76 119.89 90 top
R12789  10Kohm  [R-0402S0]  132.62 125.67 180 top
R12790  33ohm  [R-0402S0]  30.99 84.51 90 top
R12791  100ohm  [R-0402S0]  162.26 87.49 270 bottom
R12792  1Kohm  [R-0402S0]  162.26 86.47 270 bottom
R12793  100ohm  [R-0402S0]  162.26 87.49 270 top
R12794  1Kohm  [R-0402S0]  162.26 86.09 270 top
R12795  33ohm  [R-0402S0]  10.29 95.18 90 bottom
R12797  0ohm  [R-0402S0]  124.94 98.95 180 bottom
R12798  0ohm  [R-0402S0]  123.57 98.57 90 bottom
R12799  4.7Kohm  [R-0402S0]  20.22 102.1 180 top
R12800  33ohm  [R-0402S0]  30.99 83.5 270 bottom
R12801  124ohm  [R-0402S0]  8.42 81.88 270 top
R12802  124ohm  [R-0402S0]  10.16 81.88 90 top
R12803  82.5ohm  [R-0402S0]  13.72 82.9 270 top
R12804  82.5ohm  [R-0402S0]  11.94 82.9 90 top
R12805  100ohm  [R-0402H016HS40]  25.23 83 90 top
R12806  124ohm  [R-0402S0]  11.94 81.88 270 top
R12807  124ohm  [R-0402S0]  13.72 81.88 90 top
R12808  82.5ohm  [R-0402S0]  8.42 82.9 90 top
R12809  82.5ohm  [R-0402S0]  10.2 82.9 270 top
R12810  124ohm  [R-0402S0]  20.32 81.85 90 top
R12811  82.5ohm  [R-0402S0]  20.32 82.86 270 top
R12812  124ohm  [R-0402S0]  18.59 81.88 270 top
R12813  82.5ohm  [R-0402S0]  18.54 82.86 90 top
R12819  4.7K  [R-0402S0]  173.48 118.93 270 top
R12820  4.7K  [R-0402S0]  117.48 89.01 90 top
R12821  4.7K  [R-0402S0]  276.04 105.45 0 top
R12822  0ohm  [R-0402S0]  9.5 38.73 270 bottom
R12823  33ohm  [R-0402S0]  62.74 78.07 270 top
R12824  4.7Kohm  [R-0402S0]  48.13 195.14 90 top
R12825  4.7Kohm  [R-0402S0]  48.1 200.03 90 top
R12826  1Kohm  [R-0402S0]  32.78 18.52 180 top
R12827  1Kohm  [R-0402S0]  161.8 149.28 270 top
R12829  10Kohm  [R-0402S0]  48.13 194.12 270 top
R12830  10Kohm  [R-0402S0]  48.1 201.04 270 top
R12832  10Kohm  [R-0402S0]  90.93 81.34 180 bottom
R12880  0ohm  [R-0402S0]  79.44 112.8 90 top
R12893  33ohm  [R-0402S0]  21.15 104.52 90 top
R12896  1Kohm  [R-0402S0]  98.68 132.33 90 top
R12897  33ohm  [R-0402S0]  159.23 87.49 90 top
R12898  4.7Kohm  [R-0402S0]  57.56 80.41 0 bottom
R12899  1Kohm  [R-0402S0]  56.43 80.41 180 bottom
R12900  2.2Kohm  [R-0402S0]  35.56 83.19 180 bottom
R12902  0ohm  [R-0402S0]  14.35 42.52 0 bottom
R12903  0ohm  [R-0402S0]  5.4 31.3 180 bottom
R12904  10K  [R-0402S0]  70.36 88.83 90 bottom
R12905  49.9ohm  [R-0402S0]  224.66 174.05 90 bottom
R12906  49.9ohm  [R-0402S0]  224.66 173.03 90 bottom
R12907  4.7Kohm  [R-0402S0]  75.78 53.88 180 bottom
R12908  4.7Kohm  [R-0402S0]  74.76 53.88 180 bottom
R12909  4.7Kohm  [R-0402S0]  75.82 56.13 270 bottom
R12910  4.7Kohm  [R-0402S0]  73.01 57.19 90 bottom
R12911  33ohm  [R-0402S0]  73.84 63.63 90 top
R12912  33ohm  [R-0402S0]  74.33 59.83 90 top
R12913  10Kohm  [R-0402S0]  74.33 60.91 90 top
R12914  100ohm  [R-0402S0]  19.43 80.83 90 top
R12915  124ohm  [R-0402S0]  17.4 84.89 180 bottom
R12916  1Kohm  [R-0402S0]  26.78 67.76 0 top
R12917  82.5ohm  [R-0402S0]  18.41 84.89 0 bottom
R12918  1Kohm  [R-0402S0]  25.63 67.76 180 top
R12920  124ohm  [R-0402S0]  21.27 85.15 180 bottom
R12921  1Kohm  [R-0402S0]  37.74 51.78 180 top
R12922  82.5ohm  [R-0402S0]  20.25 85.15 0 bottom
R12923  1Kohm  [R-0402S0]  36.72 51.78 0 top
R12924  10Kohm  [R-0402S0]  94.49 135.69 90 top
R12925  33ohm  [R-0402S0]  182.25 116.84 90 top
R12927  33ohm  [R-0402S0]  173.48 120.07 90 top
R12928  33ohm  [R-0402S0]  152.4 93.73 180 top
R12929  33ohm  [R-0402S0]  153.63 93.73 180 top
R12930  33ohm  [R-0402S0]  154.9 93.73 180 top
R12931  4.7K  [R-0402S0]  148.84 88.39 0 bottom
R12935  1Kohm  [R-0402S0]  164.59 90.93 0 bottom
R12936  124ohm  [R-0402S0]  16.62 80.81 0 top
R12937  124ohm  [R-0402S0]  15.15 80.81 0 top
R12938  82.5ohm  [R-0402S0]  16.62 82.54 0 top
R12939  82.5ohm  [R-0402S0]  15.15 82.54 0 top
R12941  33ohm  [R-0402S0]  184.53 120.2 90 top
R12942  33ohm  [R-0402S0]  151.38 80.77 180 bottom
R12943  33ohm  [R-0402S0]  151.13 85.47 90 bottom
R12944  4.7K  [R-0402S0]  148.16 82.63 0 bottom
R12945  4.7Kohm  [R-0402S0]  50.42 201.29 180 bottom
R12946  4.7Kohm  [R-0402S0]  51.45 199.36 0 bottom
R12947  4.7Kohm  [R-0402S0]  51.69 201.29 0 bottom
R12948  4.7Kohm  [R-0402S0]  50.43 199.36 180 bottom
R12949  4.7Kohm  [R-0402S0]  130.94 170.62 180 top
R12950  33ohm  [R-0402S0]  129.67 170.62 180 top
R12951  33ohm  [R-0402S0]  128.4 170.62 180 top
R12952  33ohm  [R-0402S0]  127.13 170.62 180 top
R12953  33ohm  [R-0402S0]  125.86 170.62 180 top
R12954  33ohm  [R-0402S0]  126.11 181.48 0 top
R12955  33ohm  [R-0402S0]  127.38 181.48 0 top
R12956  33ohm  [R-0402S0]  128.78 181.48 0 top
R12957  33ohm  [R-0402S0]  130.05 181.48 0 top
R12960  1Kohm  [R-0402S0]  118.87 178.82 180 top
R12961  100Kohm  [R-0402S0]  54.86 132.21 180 top
R12962  100Kohm  [R-0402S0]  55.88 132.21 180 top
R12963  100Kohm  [R-0402S0]  56.9 132.21 180 top
R12964  100Kohm  [R-0402S0]  58.93 132.21 180 top
R12965  100Kohm  [R-0402S0]  57.91 132.21 180 top
R12966  10Kohm  [R-0402S0]  63.88 129.92 90 bottom
R12967  2.2Kohm  [R-0402S0]  63.88 132.08 270 bottom
R12968  10Kohm  [R-0402S0]  64.39 129.16 270 top
R12969  2.2Kohm  [R-0402S0]  64.39 127 90 top
R12970  0ohm  [R-0603S0]  60.58 202.95 0 top
R12971  4.7K  [R-0402S0]  288.09 105.87 0 top
R12972  4.7K  [R-0402S0]  291.21 105.87 0 top
R12973  100ohm  [R-0402S0]  44.2 202.35 270 top
R12974  100ohm  [R-0402S0]  46.61 202.35 90 top
R12975  4.7Kohm  [R-0402S0]  55.5 204.6 180 top
R12976  100ohm  [R-0402S0]  54.48 204.6 0 top
R12977  4.7Kohm  [R-0402S0]  57.53 204.6 180 top
R12978  100ohm  [R-0402S0]  56.52 204.6 0 top
R12979  4.7K  [R-0402S0]  123.62 99.66 90 bottom
R12980  0.01ohm  [R-0805]  64.39 40.01 0 top
R12981  180ohm  [R-0402S0]  162.61 117.4 90 bottom
R12982  180ohm  [R-0402S0]  162.61 118.68 90 bottom
R12983  180ohm  [R-0402S0]  162.05 114.5 0 bottom
R12984  180ohm  [R-0402S0]  163.35 114.5 0 bottom
R12985  4.7Kohm  [R-0402S0]  106.12 180.48 0 bottom
R12986  4.7Kohm  [R-0402S0]  109.2 180.48 0 bottom
R12987  22ohm  [R-0402S0]  59.18 85.22 270 bottom
R12988  0ohm  [R-0402S0]  42.04 113.46 0 bottom
R12990  2.2Kohm  [R-0402S0]  59.18 83.82 90 bottom
R12992  22ohm  [R-0402S0]  76.6 98.57 90 top
R12993  1Kohm  [R-0402S0]  261.2 187.1 90 bottom
R12994  1Kohm  [R-0402S0]  269.24 186.56 180 bottom
R12995  1Kohm  [R-0402S0]  283.34 185.93 0 top
R12996  1Kohm  [R-0402S0]  278.87 187.63 90 bottom
R12997  1Kohm  [R-0402S0]  273.56 188.12 270 bottom
R12998  0ohm  [R-0402S0]  76.56 99.71 90 top
R13001  4.7Kohm  [R-0402S0]  76.45 99.57 90 bottom
R13002  0ohm  [R-0402S0]  53.72 96.27 180 bottom
R13003  0ohm  [R-0402S0]  52.45 93.34 180 bottom
R13004  560ohm  [R-0402S0]  8.57 31.19 270 bottom
R13005  100Kohm  [R-0402S0]  8.57 32.17 90 bottom
R13006  10Kohm  [R-0402S0]  16.41 29.48 90 bottom
R13007  100Kohm  [R-0402S0]  14.52 29.41 180 bottom
R13008  10Kohm  [R-0402S0]  10.48 37.34 270 bottom
R13009  10Kohm  [R-0402S0]  12.91 36.37 90 bottom
R13015  4.7Kohm  [R-0402S0]  74.81 127.51 0 bottom
R13016  4.7Kohm  [R-0402S0]  70.59 127.51 0 bottom
R13017  4.7Kohm  [R-0402S0]  75.9 127.51 180 bottom
R13018  4.7Kohm  [R-0402S0]  71.55 127.51 180 bottom
R13019  10K  [R-0402S0]  117.3 100.8 270 bottom
R13020  4.7Kohm  [R-0402S0]  73.52 127.51 0 bottom
R13021  4.7Kohm  [R-0402S0]  72.55 127.51 180 bottom
R13026  49.9  [R-0402S0]  271.17 88.81 180 top
R13027  49.9  [R-0402S0]  271.17 90.52 0 top
R13030  4.7Kohm  [R-0402S0]  96.14 181.91 180 top
R13031  4.7Kohm  [R-0402S0]  97.16 181.91 0 top
R13036  1Kohm  [R-0402S0]  95.76 133.99 180 bottom
R13037  10Kohm  [R-0402S0]  133.73 195.25 90 top
R13038  1.2Kohm  [R-0402S0]  141.22 196.47 270 top
R13042  1Kohm  [R-0402S0]  141.22 194.18 270 top
R13044  330ohm  [R-0603S0]  82.41 132.84 180 top
R13049  330ohm  [R-0603S0]  80.9 132.84 0 top
R13056  100ohm  [R-0805]  71.5 134.54 270 bottom
R13068  3.9Kohm  [R-0402S0]  72.16 132.4 90 bottom
R13069  12Kohm  [R-0402S0]  72.16 131.46 90 bottom
R13070  49.9  [R-0402S0]  289.39 92.39 180 bottom
R13071  49.9  [R-0402S0]  290.46 92.39 180 bottom
R13072  33ohm  [R-0402S0]  159.44 123.75 180 top
R13073  33ohm  [R-0402S0]  158.43 123.75 180 top
R13074  33ohm  [R-0402S0]  162.81 129.09 270 top
R13075  33ohm  [R-0402S0]  162.81 128.07 270 top
R13076  33ohm  [R-0402S0]  162.81 132.14 270 top
R13077  33ohm  [R-0402S0]  162.81 131.12 270 top
R13080  130ohm  [R-0402S0]  133.03 122.54 90 top
R13081  33ohm  [R-0402S0]  131.24 122.54 270 top
R13082  0ohm  [R-0402S0]  106.3 129.29 270 bottom
R13084  33ohm  [R-0402S0]  64.39 82.46 0 bottom
R13085  100ohm  [R-0402S0]  15.86 79.39 90 top
R13086  100Kohm  [R-0402S0]  79.38 105.28 270 top
R13087  4.7Kohm  [R-0402S0]  53.98 192.15 270 bottom
R13088  4.7Kohm  [R-0402S0]  53.99 188.34 90 top
R13089  4.7Kohm  [R-0402S0]  56.9 196.32 270 bottom
R13090  4.7Kohm  [R-0402S0]  56.26 198.37 180 bottom
R13803  0ohm  [R-0402S0]  116.08 138.18 180 top
SK157  ACA-SPI-004-K01  [CN-ACA-SPI-004K01SK]  39.64 83 0 top
SK158  ACA-SPI-004-K01  [CN-ACA-SPI-004K01SK]  55.67 85.81 0 top
T1  S553-6500-E6-F  [T-S12_7X9_398-16]  47.64 54.64 90 top
TP1  TP  [ICT]  69.22 77.4 90 bottom
TP2  TP  [ICT]  66.67 77.4 90 bottom
TP3  TP  [ICT]  67.94 77.4 90 bottom
TP4  TP  [ICT]  66.35 78.7 90 bottom
TP5  TP  [ICT]  19.64 97.04 270 bottom
TP6  TP  [ICT]  19.42 95.6 270 bottom
TP7  TP  [ICT]  12.19 96.71 270 bottom
TP8  TP  [ICT]  12.45 94.29 270 bottom
TP9  TP  [ICT]  101.6 89.49 180 bottom
TP10  TP  [ICT]  134.75 122.81 90 bottom
TP11  TP  [ICT]  191.87 145.56 90 bottom
TP12  TP  [ICT]  188.47 146.18 90 bottom
TP13  TP  [ICT]  189.36 148.34 90 bottom
TP14  TP  [ICT]  208.42 120.62 90 bottom
TP15  TP  [ICT]  192.18 147.33 0 bottom
TP16  TP  [ICT]  190.37 149.35 0 bottom
TP17  TP  [ICT]  243.73 141.73 180 bottom
TP18  TP  [ICT]  224.36 120.53 180 bottom
TP19  TP  [ICT]  159.25 90.22 270 bottom
TP20  TP  [ICT]  121.94 120.28 180 bottom
TP21  TP  [ICT]  28.67 54.33 270 bottom
TP22  TP  [ICT]  173.48 120 180 bottom
TP23  TP  [ICT]  191.73 123.64 180 bottom
TP57  TP  [ICT]  97.63 166.3 270 bottom
TP58  TP  [ICT]  96.36 166.3 270 bottom
TP59  TP  [ICT]  98.14 167.57 270 bottom
TP60  TP  [ICT]  99.41 167.57 270 bottom
TP61  TP  [ICT]  100.17 166.3 270 bottom
TP62  TP  [ICT]  101.44 166.3 270 bottom
TP63  TP  [ICT]  102.21 167.57 270 bottom
TP64  TP  [ICT]  103.48 167.57 270 bottom
TP65  TP  [ICT]  82.55 109.09 270 bottom
TP66  TP  [ICT]  55.24 123.32 270 bottom
TP68  TP  [ICT]  75.06 103.5 270 bottom
TP69  TP  [ICT]  56.64 122.56 180 bottom
TP70  TP  [ICT]  54.36 126.49 180 bottom
TP79  TP  [ICT]  65.11 122.26 180 bottom
TP80  TP  [ICT]  66.7 123.05 180 bottom
TP81  TP  [ICT]  64.69 121.02 180 bottom
TP82  TP  [ICT]  65.33 123.54 180 bottom
TP83  TP  [ICT]  82.04 111.82 90 bottom
TP84  TP  [ICT]  75.92 114.29 90 bottom
TP85  TP  [ICT]  82.55 101.53 90 bottom
TP86  TP  [ICT]  82.55 104.07 90 bottom
TP87  TP  [ICT]  75.06 111.69 90 bottom
TP88  TP  [ICT]  86.36 104.07 90 bottom
TP89  TP  [ICT]  78.24 111.56 90 bottom
TP90  TP  [ICT]  71.12 96.71 90 bottom
TP91  TP  [ICT]  78.36 103 90 bottom
TP92  TP  [ICT]  78.74 107.88 90 bottom
TP93  TP  [ICT]  76.96 103 90 bottom
TP94  TP  [ICT]  68.05 108.2 90 bottom
TP95  TP  [ICT]  163.83 131.29 270 bottom
TP97  TP  [ICT]  72.21 117.02 180 bottom
TP98  TP  [ICT]  77.17 116.02 180 bottom
TP103  TP  [ICT]  104.14 166.37 180 bottom
TP104  TP  [ICT]  105.41 166.37 180 bottom
TP105  TP  [ICT]  107.44 170.11 180 bottom
TP106  TP  [ICT]  108.71 170.11 180 bottom
TP113  TP  [ICT]  59.82 119.46 180 bottom
TP115  TP  [ICT]  81.03 115.5 180 bottom
TP116  TP  [ICT]  74.55 114.36 180 bottom
TP117  TP  [ICT]  80.01 111.95 180 bottom
TP120  TP  [ICT]  291.94 131.87 180 bottom
TP129  TP  [ICT]  66.67 166.56 180 bottom
TP130  TP  [ICT]  67.94 166.56 180 bottom
TP131  TP  [ICT]  69.22 166.56 180 bottom
TP132  TP  [ICT]  70.48 166.56 180 bottom
TP133  TP  [ICT]  71.81 166.56 180 bottom
TP134  TP  [ICT]  73.08 166.56 180 bottom
TP145  TP  [ICT]  82.69 110.51 180 bottom
TP146  TP  [ICT]  73.28 114.81 180 bottom
TP153  TP  [ICT]  24.82 148.19 180 bottom
U1  BCM88470CB0IFSBG  [PBGA-37X37-1365]  214.36 120 90 top
U2  MT40A256M16GE-083E IT:B  [FBGA-16X9-96A]  202.86 160.67 90 top
U3  MT40A256M16GE-083E IT:B  [FBGA-16X9-96A]  215.03 160.67 90 top
U4  MT40A256M16GE-083E IT:B  [FBGA-16X9-96A]  241.96 160.67 90 top
U5  MT40A256M16GE-083E IT:B  [FBGA-16X9-96A]  229.78 160.67 90 top
U6  MT40A256M16GE-083E IT:B  [FBGA-16X9-96A]  256.5 122.26 0 top
U7  MT40A256M16GE-083E IT:B  [FBGA-16X9-96A]  256.5 133.93 0 top
U10  74VHC164FT  [MSOP-14A]  90.79 14.3 90 bottom
U12  74VHC164FT  [MSOP-14A]  134.88 11.56 0 bottom
U13  74VHC164FT  [MSOP-14A]  301.39 30.66 180 bottom
U14  74VHC164FT  [MSOP-14A]  161.88 15.19 90 bottom
U15  74VHC164FT  [MSOP-14A]  301.39 23.68 180 bottom
U16  74VHC164FT  [MSOP-14A]  175.72 15.07 90 bottom
U18  74VHC164FT  [MSOP-14A]  222.38 15.07 90 bottom
U19  74VHC164FT  [MSOP-14A]  237.92 11.89 0 bottom
U20  SN74LVTH244ADW  [SSOP-20]  209.8 12.2 90 bottom
U21  74VHC164FT  [MSOP-14A]  266.08 13.99 90 bottom
U22  SN74LVTH244ADW  [SSOP-20]  251.53 13.45 90 bottom
U23  BCM82780FA3IFSBG  [PBGA-16X16-256B-H3_335]  129.21 97.36 180 top
U25  BCM82398AIFSBG  [PBGA-18X18-324-H3_08]  284.1 92.39 180 top
U26  TPS2560DRCR  [TQFN-3X3-10GSH]  92.71 75.87 180 top
U27  TPS2560DRCR  [TQFN-3X3-10GSH]  156.96 75.87 180 top
U28  TPS2560DRCR  [TQFN-3X3-10GSH]  233.14 75.87 180 top
U29  TPS2560DRCR  [TQFN-3X3-10GSH]  104.78 75.87 180 top
U30  TPS2560DRCR  [TQFN-3X3-10GSH]  169.04 75.87 180 top
U31  TPS2560DRCR  [TQFN-3X3-10GSH]  245.22 75.87 180 top
U32  TPS2560DRCR  [TQFN-3X3-10GSH]  116.86 75.62 180 top
U33  TPS2560DRCR  [TQFN-3X3-10GSH]  181.11 75.87 180 top
U34  TPS2560DRCR  [TQFN-3X3-10GSH]  257.38 75.92 180 top
U35  TPS2560DRCR  [TQFN-3X3-10GSH]  128.94 75.62 180 top
U36  TPS2560DRCR  [TQFN-3X3-10GSH]  208.99 75.87 180 top
U37  TPS2560DRCR  [TQFN-3X3-10GSH]  272.25 75.92 180 top
U38  TPS2560DRCR  [TQFN-3X3-10GSH]  144.88 75.87 180 top
U39  TPS2560DRCR  [TQFN-3X3-10GSH]  221.06 75.87 180 top
U42  TPS2560DRCR  [TQFN-3X3-10GSH]  305.84 87.66 90 top
U43  TPS2553DBVR-1  [SOT-23-6]  58 49 90 bottom
U46  MX25L1633EM2I-10G  [SO-8J]  271.73 112.68 180 top
U47  PCA9535PWR  [SSOP-24]  177.83 30.67 90 bottom
U48  PCA9535PWR  [SSOP-24]  148.85 30.67 90 bottom
U49  PCA9535PWR  [SSOP-24]  208.74 29.66 90 bottom
U50  PCA9535PWR  [SSOP-24]  280.24 13.98 90 bottom
U51  PCA9535PWR  [SSOP-24]  133.55 30.67 90 bottom
U52  PCA9535PWR  [SSOP-24]  191.14 30.55 90 bottom
U53  PCA9535PWR  [SSOP-24]  120.17 30.67 90 bottom
U54  PCA9535PWR  [SSOP-24]  106.13 30.67 90 bottom
U55  PCA9535PWR  [SSOP-24]  252.05 29.66 90 bottom
U56  PCA9535PWR  [SSOP-24]  237.69 29.66 90 bottom
U57  PCA9535PWR  [SSOP-24]  266.14 29.66 90 bottom
U58  PCA9535PWR  [SSOP-24]  98.27 194.37 90 top
U59  74HC1G32GW  [SOT-353-H1_1S0]  134.9 191.03 0 top
U60  74HC1G32GW  [SOT-353-H1_1S0]  66.8 180.85 180 bottom
U61  74HC1G32GW  [SOT-353-H1_1S0]  66.75 186.13 180 bottom
U62  PCA9548APWR  [SSOP-24]  91.5 30.67 90 bottom
U63  PCA9548APWR  [SSOP-24]  162.82 30.67 90 bottom
U64  PCA9548APWR  [SSOP-24]  223.45 29.66 90 bottom
U65  PCA9548APWR  [SSOP-24]  280.34 29.22 90 bottom
U67  PCA9546APW  [SSOP-16H1_1]  88.9 183.06 270 top
U68  PCA9546APW  [SSOP-16H1_1]  105.53 13.74 90 bottom
U69  PCA9546APW  [SSOP-16H1_1]  301.34 37.51 0 bottom
U70  10M04SAU169I7G  [FBGA-13X13-169A-H1_55]  115.2 127.65 270 top
U71  TCA4311A  [SSOP-8C]  86.83 176.26 0 top
U73  UCD90124ARGCR  [TQFN-9X9-64GSHS0]  121.37 194.46 0 top
U74  TMP75AIDGKR  [MSOP-8]  129.09 97.02 270 bottom
U75  TMP451AIDQFR  [TQFN-2X2-8]  224.63 173.57 180 top
U76  PCA9546APW  [SSOP-16H1_1]  139.27 178.1 270 top
U81  GT24C128B-2ZLI-TR  [MSOP-8A]  98.4 185.25 0 top
U85  WGI210IT SLJXQ  [TQFN-9X9-64QSH]  96.52 90.86 90 top
U86  MX25L1633EM2I-10G  [SO-8J]  110.79 90.66 0 top
U89  MAX3221IDBR  [SSOP-16A]  74.94 53.93 180 top
U96  TS3USB221RSER  [TQFN-2X1_5-10S1]  71.49 48.13 180 top
U97  TS5A3157  [SC-70-6]  89.66 129.92 0 top
U98  TS5A3157  [SC-70-6]  92.58 132.9 0 top
U99  74LVC1G08GW  [SOT-353-H1_1S0]  69.6 93.22 270 bottom
U101  74LVC1G08GW  [SOT-353-H1_1S0]  113.54 116.33 180 bottom
U102  74LVC1G08GW  [SOT-353-H1_1S0]  41.78 190.25 90 bottom
U104  LMH6643MMX/NOPB  [SSOP-8C]  30 15.32 0 top
U105  NL17SZ17DFT2G  [SC-70-5A]  20.73 18.06 180 top
U106  TLV3501AIDBVRG4  [SOT-23-6]  19.43 13.46 180 top
U107  NL17SZ17DFT2G  [SC-70-5A]  11.38 18.24 0 top
U108  NL17SZ17DFT2G  [SC-70-5A]  25.31 65.45 0 top
U110  SN65HVD01DRCR  [TQFN-3X3-10GSH]  27.13 47.86 90 top
U111  TS5A3157  [SC-70-6]  84 123.14 180 top
U112  TS5A3157  [SC-70-6]  78.79 122.98 180 top
U113  LM397MFX/NOPB  [SOT-23-5]  63.59 182.38 0 top
U115  TL431AQDBZR  [SOT-23H]  75.27 133.48 270 bottom
U121  SN65HVD01DRCR  [TQFN-3X3-10GSH]  33.67 47.86 90 top
U124  NEO-M8T-0  [E-PMODULE-S16X12_2-24]  11.22 35.38 180 top
U127  IDT82P2281  [PQFP-80B]  72.89 81.08 0 top
U129  8SLVP1204ANLGI8  [TQFN-3X3-16ESHS3]  182.75 152.71 180 top
U132  8SLVP1204ANLGI8  [TQFN-3X3-16ESHS3]  166.12 87.28 270 top
U133  8SLVP1204ANLGI8  [TQFN-3X3-16ESHS3]  158.81 117.52 270 top
U135  SI5344D-D09285-GMR  [TQFN-7X7-44CSH]  156.58 130.36 270 top
U136  74LVC1G08GW  [SOT-353-H1_1S0]  101.71 177.19 180 top
U137  NL17SZ17DFT2G  [SC-70-5A]  94.23 176.46 270 top
U138  NL17SZ17DFT2G  [SC-70-5A]  97.41 176.46 270 top
U139  82P33831ABAG  [PBGA-12X12-144-H1_78]  19.43 92.3 180 top
U140  GT24C128B-2ZLI-TR  [MSOP-8A]  8.32 74.65 180 top
U143  PI6CV304LEX  [MSOP-8A]  106.88 83.12 90 top
U144  PI6CV304LEX  [MSOP-8A]  89.89 194.37 90 top
U145  74LVC1G08GW  [SOT-353-H1_1S0]  49.21 189.43 0 top
U148  74LVC1G08GW  [SOT-353-H1_1S0]  137.02 194.5 180 top
U149  SN74LVC2244APWR  [SSOP-20]  107.31 103.43 270 bottom
U150  PCA9535PWR  [SSOP-24]  108.14 180.17 90 top
U151  TS5A3157  [SC-70-6]  76.11 62.66 0 bottom
U152  TS5A3157  [SC-70-6]  76.76 65.72 0 top
U154  AST2400A1-GP  [FBGA-22X22-408]  63.33 112.93 180 top
U155  W632GU6MB12I  [FBGA-16X9-96F]  42.65 116.91 270 top
U156  TS5A3157  [SC-70-6]  48.39 82.55 90 bottom
U157  MX25L25645GM2I-10G  [SO-8J]  39.64 83 0 top
U160  RT9817C-30PH  [SOT-143S0]  46.94 129.03 270 top
U162  CP2130-F01-GMR  [TQFN-4X4-24BSH-H0_8S2]  86.19 81.17 0 top
U163  5P49V5901B979NLGI8  [TQFN-4X4-24FSHS1]  139.34 121.58 270 top
U164  74LVC1G08GW  [SOT-353-H1_1S0]  136.27 198.99 180 top
U165  TS5A3157  [SC-70-6]  81.92 171.13 270 top
U168  830154AGI-08LFT  [MSOP-8A]  30.95 55.61 180 top
U170  TS5A3157  [SC-70-6]  55.43 82.8 180 bottom
U171  74LVC1G08GW  [SOT-353-H1_1S0]  140.52 198.98 180 top
U172  TS5A3157  [SC-70-6]  79.25 171.13 270 top
U173  TS5A3157  [SC-70-6]  47.75 87.12 270 bottom
U174  830154AGI-08LFT  [MSOP-8A]  151.38 90.13 0 top
U175  830154AGI-08LFT  [MSOP-8A]  149.33 83.9 0 top
U176  SN74LVTH244ADW  [SSOP-20]  128.4 176.15 90 top
U177  TS5A3157  [SC-70-6]  119.89 175.77 270 top
U178  SN74LVC08APWR  [MSOP-14S0]  131.06 204.98 0 top
U179  MX25L25645GM2I-10G  [SO-8J]  55.67 85.81 0 top
U180  TMP235A2DCKR  [SC-70-5A]  197.87 124.16 0 bottom
U181  TMP235A2DCKR  [SC-70-5A]  62.79 114.48 180 bottom
U182  TMP235A2DCKR  [SC-70-5A]  283.14 98 180 bottom
U183  LM397MFX/NOPB  [SOT-23-5]  9.27 34.67 180 bottom
U185  TMP75AIDGKR  [MSOP-8]  71.12 123.32 180 bottom
U194  74LVC1G08GW  [SOT-353-H1_1S0]  67.14 174.74 90 top
U196  74HC1G32GW  [SOT-353-H1_1S0]  53.58 191.18 270 top
U197  74HC1G32GW  [SOT-353-H1_1S0]  55.22 197.93 0 top
U198  TMP235A2DCKR  [SC-70-5A]  86.75 109.42 0 top
U200  TS5A3157  [SC-70-6]  61.59 132.21 180 top
U201  TMP235A2DCKR  [SC-70-5A]  25.62 122.18 270 top
X1  25MHz  [O-3_2X2_5-4JS0]  102.91 132.46 270 top
X2  SG-8101CE_1.544MHz_TCHPA  [O-3_2X2_5-4JS0]  59.05 77.09 0 top
X3  25MHz  [O-3_2X2_5-4JS0]  130.27 119.55 0 top
X4  50MHz  [O-S3_2X2_5-4C]  113.33 84.65 90 top
X5  25MHz  [O-3_2X2_5-4JS0]  156.18 84.45 0 top
X7  100MHz  [O-S3_2X2_5-6C]  187.3 155.89 0 top
X8  E6416LF  [O-S7X5-6]  159.39 92.9 180 top
X11  25MHz  [O-S25_4X22-7]  18.39 122.28 180 top
X13  48MHz  [O-2_5X2-4CS0]  56.9 97.14 90 top
X14  U6885LF  [O-S14_6X9_1-6]  16.74 119.66 180 top
Y1  48MHz  [O-S2X1_6-4DS0]  149.04 130.36 0 top
Y2  25MHz  [O-S3_2X2_5-4E]  84.66 89.02 0 top
Y3  54MHz  [O-S3_2X2_5-4E]  149.04 130.36 180 top
Y5  E5SB25E00002LE  [O-5X3_2-4FS1]  25.15 79.63 90 top

## Library data of the parts
BAT1 = BB3320E
C3 C5 C6 C8-C11 C26 C27 C29-C32 C39 C40 C42-C45 C382 C387 C406 C420 C425 C454 C459 C466 C505 C753 C755-C762 C771-C807 C809-C816 C825-C853 C896 C898 C975 C976 C986 C1369-C1371 C1380 C1382 C1389 C1391 C1392 C1399 C1400 C1402 C1406 C1408 C1411-C1413 C1548 C1558 C1604 C1625-C1627 C1632-C1634 C1639 C1640 C1642 C1644 C1687 C1689 C1690 C1940-C1942 C1978 C1985-C1987 C1992-C1995 C1997-C2001 C2042 C2044 C2048 C2050 C2051 C2053 C2054 C2056 C2057 C2059 C2125 C2132 C2139 C2141-C2145 C2147-C2152 C2154 C2155 C2157 C2171 C2172 C2239 C2266-C2268 C2272-C2274 C2277 C2281 C2287 C2290 C2300 C2309 C2317 C2318 C2320 C2323 C2370 C2371 C2385 C2386 C2388 C2392 C2415-C2417 C2420-C2422 C2431 C2437 C2439 C2441 C2443 C2452 PC29 PC42 PC47 PC55 PC61 PC62 PC69 PC77 PC89 PC90 PC92 PC95 PC125 PC146 PC150 PC157 PC163 PC164 PC174 PC194 PC224 PC250 PC333 PC343 PC364 PC368 PC374 PC377 PC378 PC388 PC389 PC422 PC424 PC429 = CAP_0
C4 C7 C12-C25 C28 C33-C38 C41 C46-C50 C53-C73 C75-C95 C97-C243 C245-C262 C264-C275 C277-C323 C326-C347 C349-C381 C383-C386 C388 C390-C405 C408-C419 C421 C424 C426-C442 C444-C453 C455-C458 C460-C465 C468-C489 C492-C504 C506-C511 C514-C562 C565-C617 C627 C628 C632-C637 C651-C661 C665-C675 C686-C700 C711-C716 C724 C735-C751 C856-C886 C888-C895 C897 C899 C900 C946-C974 C977-C985 C987-C991 C993 C996 C999 C1002 C1005 C1008 C1011 C1014 C1017 C1020 C1023 C1026 C1029 C1032 C1035 C1038 C1041 C1044 C1047 C1050 C1053 C1056 C1059 C1062 C1065 C1068 C1071 C1074 C1077 C1080 C1083 C1086 C1089 C1092 C1095 C1097 C1101 C1104 C1107 C1110 C1185 C1188 C1191 C1194 C1197 C1200 C1203 C1206 C1209 C1212 C1215 C1218 C1221 C1224 C1227 C1230 C1233 C1235 C1237 C1239 C1241 C1244 C1247 C1250 C1253-C1256 C1258-C1261 C1263-C1266 C1268-C1271 C1273-C1276 C1278-C1281 C1283-C1286 C1288-C1291 C1293-C1296 C1298-C1301 C1303-C1306 C1308-C1311 C1313-C1316 C1318-C1321 C1333-C1336 C1357-C1368 C1372-C1375 C1377-C1379 C1381 C1383-C1388 C1390 C1393-C1398 C1401 C1404 C1405 C1407 C1409 C1410 C1414-C1422 C1549-C1557 C1560-C1567 C1576-C1583 C1595 C1601 C1622-C1624 C1628-C1631 C1635-C1638 C1641 C1643 C1672-C1674 C1680 C1681 C1688 C1816 C1956 C1979-C1983 C1988-C1991 C1996 C2002 C2038-C2041 C2043 C2045-C2047 C2049 C2052 C2055 C2058 C2060-C2062 C2067 C2068 C2077-C2124 C2127-C2131 C2133-C2138 C2140 C2146 C2153 C2156 C2160-C2162 C2169 C2170 C2173-C2175 C2206-C2211 C2215 C2218-C2221 C2240 C2241 C2244-C2264 C2269-C2271 C2275 C2276 C2278-C2280 C2282-C2286 C2288 C2289 C2291-C2299 C2301-C2308 C2310-C2316 C2319 C2321 C2322 C2324-C2327 C2330-C2333 C2335 C2348 C2350 C2352 C2356-C2358 C2368 C2369 C2372 C2375-C2378 C2387 C2389 C2390 C2393 C2394 C2397 C2398 C2400 C2406 C2409-C2414 C2423-C2425 C2427-C2430 C2434-C2436 C2440 C2442 C2446-C2451 C2453 C2454 C2462 C2463 PC1-PC4 PC6-PC9 PC11-PC28 PC30-PC39 PC41 PC45 PC46 PC48-PC51 PC54 PC63-PC68 PC70-PC76 PC78 PC79 PC82-PC88 PC91 PC93 PC94 PC96-PC102 PC104 PC109-PC112 PC114-PC122 PC131-PC134 PC136-PC145 PC147 PC149 PC151-PC156 PC165-PC173 PC175-PC193 PC195-PC223 PC225-PC249 PC251 PC252 PC300 PC309-PC311 PC315-PC332 PC334-PC342 PC344 PC345 PC365-PC367 PC370 PC372 PC373 PC375 PC376 PC379-PC382 PC386 PC387 PC390-PC396 PC417-PC421 PC423 PC425-PC428 PC430 PC433 PC434 PC3408 = CAP
C51 C52 C74 C96 C244 C263 C276 C324 C325 C348 C389 C407 C422 C423 C443 C467 C490 C491 C512 C513 C563 C564 C887 C943-C945 PC5 PC57 PC58 PC105 PC123 PC127 PC307 PC313 PC314 PC371 PC383 = CAP-TAN
C854 C855 C2158 C2159 C2163-C2168 C2204 C2205 C2235-C2238 C2242 C2243 C2338-C2347 C2362-C2367 C2383 C2384 C2407 C2408 = CAP_0: signal model: CAP_0_C-0402S0_0.1UF_0.1uF
C992 C994 C995 C997 C998 C1000 C1001 C1003 C1004 C1006 C1007 C1009 C1010 C1012 C1013 C1015 C1016 C1018 C1019 C1021 C1022 C1024 C1025 C1027 C1028 C1030 C1031 C1033 C1034 C1036 C1037 C1039 C1040 C1042 C1043 C1045 C1046 C1048 C1049 C1051 C1052 C1054 C1055 C1057 C1058 C1060 C1061 C1063 C1064 C1066 C1067 C1069 C1070 C1072 C1073 C1075 C1076 C1078 C1079 C1081 C1082 C1084 C1085 C1087 C1088 C1090 C1091 C1093 C1094 C1096 C1098-C1100 C1102 C1103 C1105 C1106 C1108 C1109 C1111 C1184 C1186 C1187 C1189 C1190 C1192 C1193 C1195 C1196 C1198 C1199 C1201 C1202 C1204 C1205 C1207 C1208 C1210 C1211 C1213 C1214 C1216 C1217 C1219 C1220 C1222 C1223 C1225 C1226 C1228 C1229 C1231 C1232 C1234 C1236 C1238 C1240 C1242 C1243 C1245 C1246 C1248 C1249 C1251 C1252 C1257 C1262 C1267 C1272 C1277 C1282 C1287 C1292 C1297 C1302 C1307 C1312 C1317 C1332 C1403 C2216 C2217 C2399 C2402 = M-CAP
C1592-C1594 C1596-C1600 C1602 C1603 = CAP_2
C1678 C1679 C1682-C1684 C1686 C1815 C1817 C1818 C1935 C1938 C2076 C2224 C2229 C2334 C2359-C2361 C2373 C2374 C2401 C2403 C2404 C2426 C2432 C2433 C2461 = CAP_6
C1685 C2176 PC43 PC103 PC148 = CAP-TAN: signal model: DEFAULT_CAPACITOR_1.5e+08pF_1_2
C2063-C2066 C2069-C2074 = CAP: signal model: CAP_S-C-0402_0.1UF_0.1uF
C2381 C2382 = CAP_0: signal model: CAP_0_C-0402S0_680PF_680pF
CJ8 = 2*8 SFP+
CJ9 = UE86-3G6620-20361
CJ12 = SFP-2X1-76PIN-23G
CN1 CN6 = CON5X2_0
CN3 = 46437-1044
D1-D20 D25 D26 D33-D42 D85-D90 = LED-2GY-4
D43-D55 = DIODE_1SMB5915B
D59 D60 D92 D93 = RCLAMP2574N
D61 D65 D67-D69 = AZC099-04S
D63 = DIO-TVS
D73-D77 D80 D99-D104 = SIDACTOR
D97 D98 = DIO BV03C
F1 F2 = FUSE
F3 F4 = FUSE: signal model: FUSE_R-0603S0_0467.500NRHF_0467.500NRHF
H1-H13 H20 = Hole-MTG-8VIA
H14-H19 H21-H24 = TOOLING HOLE-1PIN-MPTH
J1 = PCI_EXP_CONN_0
J3 J19 J20 = CON4X1
J5 = HL2113V
J6 = CON2X2
J7 = RJ45-2X1-6G_0
J8 = HM2007E
J10-J12 J14 J15 = RF_CON-1-4G
J17 = CON10X2_0
L1 L19 L204 L206 = L-600-0805_0
L2-L18 L20 L21 L38 L39 L44 L89 L135-L139 L141 L171-L177 L185 L187-L192 L194-L201 L203 L205 L207 L208 = BEAD
L34 L35 L42 L45-L48 L129-L134 L164 L186 PL2-PL11 PL18-PL21 PL23 = INDUCTOR
L36 L37 L49-L88 L113-L128 L178-L183 = INDUCTOR-A
L140 = CHOKE-4
L159 L161-L163 = CHOKE-4L
OJ1 = J_1
PC56 PC158 PC384 = CAP: signal model: DEFAULT_CAPACITOR_10000pF_1_2
PC60 PC162 PC369 PC400 PC405 = CAP: signal model: DEFAULT_CAPACITOR_100000pF_1_2
PC113 PC135 PC403 = CAP: signal model: DEFAULT_CAPACITOR_1e+06pF_1_2
PC159 PC160 = CAP AL
PC401 PC402 = CAP_0: signal model: DEFAULT_CAPACITOR_2.2e+07pF_1_2
PC404 = CAP: signal model: DEFAULT_CAPACITOR_270pF_1_2
PC406 PC407 PC409 = CAP: signal model: DEFAULT_CAPACITOR_2.2e+07pF_1_2
PD1 = DIODE SCHOTTKY-A
PD4 = DIODE-2A
PJ1 = CON5X2
PQ2-PQ5 PQ8-PQ17 PQ19 PQ20 PQ24 PQ25 Q3 Q6-Q8 Q12 Q13 Q15 Q16 Q42 Q57 Q58 = NFET-3P-GSD
PQ21 = PFET-8P-DSG
PR1-PR3 PR11 PR26 PR39 PR40 PR43 PR53 PR56 PR58 PR59 PR61 PR63-PR80 PR83 PR87 PR88 PR90-PR93 PR95 PR96 PR98-PR103 PR107-PR113 PR120-PR132 PR134-PR150 PR152-PR155 PR157-PR170 PR172 PR175 PR178 PR179 PR181-PR185 PR187 PR189-PR196 PR198-PR201 PR203-PR216 PR218-PR220 PR222-PR238 PR240 PR242 PR243 PR245-PR257 PR260 PR262-PR265 PR295-PR301 PR306-PR326 PR328 PR329 PR333 PR336-PR338 PR346-PR352 PR354-PR357 PR359-PR364 PR366-PR373 PR387 PR388 PR395 PR396 PR398-PR403 PR416-PR418 PR422 PR423 PR425 PR428-PR433 PR435-PR440 PR480-PR484 PR496-PR501 PR504-PR506 R4 R5 R7-R11 R16 R26-R35 R38 R40 R42 R45-R52 R54 R56-R59 R63-R65 R67-R69 R75 R77 R83-R94 R96 R98 R99 R101 R103 R105-R107 R109-R118 R123-R137 R139 R141 R143 R144 R146 R148-R150 R152-R161 R166-R178 R180 R182 R183 R185 R187 R188 R190 R191 R193-R202 R207-R209 R255-R262 R264-R269 R277 R281 R283 R284 R298-R301 R307 R308 R312-R451 R536-R619 R622-R625 R627-R633 R635-R640 R646 R649-R759 R761-R763 R765 R767 R769 R772-R788 R790 R792 R795-R797 R802-R804 R806 R821 R822 R826-R921 R946-R1003 R1006 R1007 R1013-R1018 R1023-R1039 R1041-R1044 R1046-R1061 R1063 R1065-R1068 R1074-R1077 R1079-R1086 R1097-R1105 R1107-R1122 R1124-R1134 R1141-R1146 R1153 R1157 R1159 R1161 R1166 R1170 R1175 R1177 R1180 R1183 R1188 R1190-R1192 R1198 R1199 R1203 R1205-R1215 R1221-R1227 R1257 R1259 R1263 R1264 R1266-R1268 R1270-R1281 R1404-R1409 R1411 R1412 R1432-R1448 R1450-R1453 R1499 R1500 R1505 R1506 R1508 R1509 R1514 R1515 R1548 R1554-R1579 R1581 R1583 R1585 R1586 R1588 R1590-R1593 R1596 R1600 R1602-R1616 R1618-R1628 R1630-R1652 R1655 R1657 R1661 R1663 R1665 R1666 R1674 R1677-R1722 R1724 R1726 R1728-R1761 R1764-R1768 R1776-R1784 R1787-R1791 R1813-R1817 R1819-R1821 R1823-R1829 R1831-R1836 R1843-R1852 R1861-R1863 R1868-R1884 R1891-R1898 R1901-R1914 R1916 R1917 R1919 R1980-R1984 R1987-R2003 R12281-R12288 R12295 R12302 R12306 R12308 R12310-R12323 R12325 R12326 R12328-R12331 R12333-R12339 R12342-R12346 R12349 R12351-R12353 R12356-R12413 R12416 R12417 R12420 R12428 R12437-R12446 R12460-R12466 R12468 R12469 R12471 R12473-R12475 R12477-R12480 R12482 R12484-R12487 R12499 R12500 R12699-R12705 R12709 R12710 R12712 R12715-R12717 R12719-R12723 R12728-R12734 R12749 R12752 R12753 R12762 R12765-R12776 R12785-R12795 R12797-R12804 R12806-R12813 R12819 R12822-R12827 R12829 R12830 R12832 R12880 R12896-R12900 R12902-R12918 R12920-R12924 R12931 R12935-R12939 R12944-R12948 R12950-R12957 R12960-R12969 R12973-R12978 R12980-R12988 R12990 R12992-R12998 R13001-R13009 R13015-R13021 R13030 R13031 R13036-R13038 R13042 R13044 R13049 R13056 R13068 R13069 R13080-R13082 R13084-R13090 R13803 = RES
PR12 PR16 PR18 PR22 PR25 PR27-PR36 PR41 PR42 PR44-PR50 PR52 PR54 PR330-PR332 PR334 PR335 PR339-PR341 R2004 R2005 R12430 R12434-R12436 R12970 = RES_11
PR20 PR57 PR104 PR105 PR239 PR258 PR486 = RES_1
PR38 PR51 PR55 PR86 PR89 PR94 PR133 PR177 PR180 PR186 PR197 PR217 PR241 PR374 PR397 PR420 PR426 PR427 PR441-PR443 PR485 PR487 PR489 R36 R37 R39 R41 R43 R44 R53 R55 R70 R71 R95 R97 R100 R102 R104 R108 R138 R140 R142 R145 R147 R151 R179 R181 R184 R186 R189 R192 R254 R263 R270-R276 R278-R280 R282 R286 R302-R306 R309-R311 R791 R793 R794 R1004 R1154 R1158 R1176 R1181 R1204 R1216-R1220 R1503 R1504 R1512 R1513 R1539 R1540 R1589 R1594 R1617 R1667 R1668 R1671 R1675 R1676 R1797-R1812 R1853-R1860 R1887 R1899 R1900 R1915 R1918 R1985 R1986 R12470 R12754 R12755 R12777-R12782 R12820 R12821 R12893 R12925 R12927-R12930 R12941-R12943 R12949 R12971 R12972 R12979 R13026 R13027 R13070 R13071 = RES_0
PR60 PR106 PR259 PR353 = RES_5
PR62 PR202 PR221 PR244 PR261 = RES_H
PR81 PR82 PR84 PR85 PR171 PR173 PR174 PR176 PR419 PR421 PR424 PR434 = RES: signal model: DEFAULT_RESISTOR_0.005OHM_1_2
PR358 PR365 = RES: signal model: DEFAULT_RESISTOR_0.01OHM_1_2
PR386 = RES: signal model: DEFAULT_RESISTOR_10000OHM_1_2
PR389 = RES: signal model: DEFAULT_RESISTOR_1690OHM_1_2
PU1 PU3 PU12 = TPS562219_563219
PU2 = TPS543C20RVFR
PU4 = TPS53661RSBR_2
PU5 PU6 = CSD95372B_2
PU7 PU22 = TPS543C20
PU8 PU9 PU11 = MPQ8623GD
PU10 = TPS51200
PU13 = TPS74801RGWR
PU18 = S-TPS73701DRB
PU19 = TPS63070RNMR
PU20 PU21 = MP2143DJ
PU24 = TPS562219_0
Q2 Q4 Q9 Q10 Q17 Q18 = NPN-3P-BEC
Q5 Q23 Q24 Q28-Q41 Q44 = NFETX2-6P-SGD
Q54 Q56 Q59 Q60 = PFET-3P-GSD
R1-R3 R6 = RES: signal model: RES_R-0402S0_150OHM_150ohm
R1040 = RES: signal model: DEFAULT_RESISTOR_20000OHM_1_2
R1070-R1073 R1888-R1890 R12447-R12455 R12783 R12784 R13072-R13077 = RES: signal model: RES_R-0402S0_33OHM_33ohm
R1262 R1265 R1595 R1597-R1599 R12347 R12348 R12750 R12751 = RES: signal model: RES_R-0402S0_0OHM_0ohm
R1672 R1673 R12763 R12764 = RES_0: signal model: RES_0_R-0402S0_33OHM_33ohm
R1818 R1830 = RES_2
R1866 R1867 = RES_0: signal model: RES_0_R-0402S0_0OHM_0ohm
R12724 R12725 = RES: signal model: RES_R-0402S0_22OHM_22ohm
R12805 = M-RES
SK157 SK158 = CON4X2A
T1 = XFMR-T5008NL_1
TP1-TP23 TP57-TP66 TP68-TP70 TP79-TP95 TP97 TP98 TP103-TP106 TP113 TP115-TP117 TP120 TP129-TP134 TP145 TP146 TP153 = TP
U1 = BCM88470
U2-U7 = H5AN4G6NMFR-UHC
U10 U12-U16 U18 U19 U21 = SN74HC164D_0
U20 U22 U149 U176 = SN74LVTH244ADW
U23 = BCM82780F_0
U25 = BCM82391AKFSBG_0
U26-U39 U42 = TPS2560DRC
U43 = TPS2552DBVR
U46 U86 = MX25L8035EM2I
U47-U58 U150 = PCA9535PWR_0
U59-U61 U196 U197 = 74LVC1G08
U62-U65 = PCA9548APWR_0
U67-U69 U76 = PCA9546APW
U70 = 10M02SCU169C8G_2
U71 = TCA4311
U73 = UCD90124ARGCR_2
U74 U185 = ADT75ARZ
U75 = TMP451
U81 U140 = AT24C02N
U85 = i210-QFN64
U89 = MAX3221CAE
U96 = TS3USB221
U97 U98 U111 U112 U151 U152 U156 U165 U170 U172 U173 U177 U200 = TS5A3157
U99 U101 U102 U136 U145 U148 U164 U171 U194 = M74VHC1GT08-DFT1G
U104 = LM358
U105 U107 U108 U137 U138 = NL17SZ17DFT2G
U106 = TLV3501
U110 U121 = SN65HVD01DRCR
U113 U183 = LM397MF
U115 = TL431ACDBZR
U124 = MODULE-24PIN-G
U127 = IDT82P2281_2
U129 U132 U133 = 8SLVP1204ANLGI8
U135 = SI5340B-B-GM_3
U139 = 82P33731_0
U143 U144 = PI6CV304LEX_0
U154 = AST2400A1-GP
U155 = H5TQ1G63DFR-H9C_1
U157 U179 = MX25L12835FM2I-10G
U160 = G692L293TC
U162 = CP2130-F01-GMR
U163 = 5P49V5901A000NLGI8
U168 U174 U175 = 830154AGI-08LFT_2
U178 = SN74AHCT86DBR
U180-U182 U198 U201 = TPS71701DCKR_1
X1-X5 X13 = OSC
X7 = OSC-6D
X8 = E6416LF
X11 = OSC-7
X14 = M6163LF
Y1 Y3 Y5 = XTAL-4
Y2 = OSC-4R

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
BA-D23_1X5_8-3S0
  round 1.575 hole 0.965: P1(5,-1.8) P3(-5,-1.8)
  round 1.549 hole 0.94: P2(0,1.8)
C-0402S0
  custom 0.127x0.127 smd: 1(0,-0.406) 2(0,0.406)
C-0603S0
  custom 0.191x0.191 smd: 1(0,-0.686) 2(0,0.686)
C-0805
  custom 0.254x0.254 smd: 1(0,-0.889) 2(0,0.889)
C-0805-H0_95
  custom 0.254x0.254 smd: 1(0,-0.889) 2(0,0.889)
C-0805-H1_35
  custom 0.254x0.254 smd: 1(0,-0.889) 2(0,0.889)
C-1206
  custom 0.362x0.362 smd: 1(0,-1.333) 2(0,1.333)
C-1210
  custom 0.381x0.381 smd: 1(0,-1.27) 2(0,1.27)
C-1808
  custom 0.324x0.324 smd: 1(0,-2.045) 2(0,2.045)
C-S7_3X4_3-2
  rect 2.896x2.083 smd: 1(0,-3.117) 2(0,3.117)
C-TAN-S7_3X4_3
  rect 2.997x2.007 smd: 1(0,3.003) 2(0,-3.003)
C-TAN-S7_3X4_3-H2
  rect 2.997x2.007 smd: 1(0,3.003) 2(0,-3.003)
CAH-R8-H6_9S0
  rect 1.905x4.496 smd: 1(0,3.5) 2(0,-3.5)
CJ-RF-D3_5X3_5-1
  round 1.245 hole 0.94: 1(0,0)
  round 1.219 hole 0.914: S1(-1.27,-1.27) S2(1.27,-1.27) S3(1.27,1.27) S4(-1.27,1.27)
CJ-RF-D21X7-1
  round 2.21 hole 1.6: 1(0,0) S1(-2.54,2.54) S2(2.54,2.54) S3(-2.54,-2.54) S4(2.54,-2.54)
CN-10X2-2_54
  round 1.321 hole 0.991: 1(-11.43,-1.27) 2(-11.43,1.27) 3(-8.89,-1.27) 4(-8.89,1.27) 5(-6.35,-1.27) 6(-6.35,1.27) 7(-3.81,-1.27) 8(-3.81,1.27) 9(-1.27,-1.27) 10(-1.27,1.27) 11(1.27,-1.27) 12(1.27,1.27) 13(3.81,-1.27) 14(3.81,1.27) 15(6.35,-1.27) 16(6.35,1.27) 17(8.89,-1.27) 18(8.89,1.27) 19(11.43,-1.27) 20(11.43,1.27)
CN-ACA-SPI-004K01SK
  rect 1.499x0.508 smd: 1(4,-1.905) 2(4,-0.635) 3(4,0.635) 4(4,1.905) 5(-4,1.905) 6(-4,0.635) 7(-4,-0.635) 8(-4,-1.905)
CN-D2X2-3BRTS0
  round 2.997 hole 2.997 unplated: (0,-0.39)
  round 1.727 hole 1.118: 1(1.5,3.93) 2(-1.5,3.93) 3(1.5,6.93) 4(-1.5,6.93)
CN-D33_01X32-45SK-TEMP
  round 3.2 hole 3.2 unplated: (-13.165,1.914)
  round 1.321 hole 0.7: A1(-6.525,-3.086) A2(-4.525,-3.086) A3(-2.525,-3.086) A4(-0.525,-3.086) A5(1.475,-3.086) B1(-6.525,-1.086) B2(-4.525,-1.086) B3(-2.525,-1.086) B4(-0.525,-1.086) B5(1.475,-1.086) C1(-6.525,0.914) C2(-4.525,0.914) C3(-2.525,0.914) C4(-0.525,0.914) C5(1.475,0.914) D1(-6.525,2.914) D2(-4.525,2.914) D3(-2.525,2.914) D4(-0.525,2.914) D5(1.475,2.914) E1(-6.525,4.914) E2(-4.525,4.914) E3(-2.525,4.914) E4(-0.525,4.914) E5(1.475,4.914)
  round 1.626 hole 1.02: P11(6.045,-3.086) P12(6.045,-0.585) P13(6.045,1.915) P14(6.045,4.415) P15(6.045,6.915) P16(9.045,-3.086) P17(9.045,-0.585) P18(9.045,1.915) P19(9.045,4.415) P20(9.045,6.915) P21(11.545,-3.086) P22(11.545,-0.585) P23(11.545,1.915) P24(11.545,4.415) P25(11.545,6.915) P26(14.545,-3.086) P27(14.545,-0.585) P28(14.545,1.915) P29(14.545,4.415) P30(14.545,6.915)
CN-EXPPCI-164A
  round 2.591 hole 2.591 unplated: (-43.3,-4.5) (29.85,-4.5)
  round 0.94 hole 0.635: A1(41.5,1.98) A2(40.5,-0.02) A3(39.5,1.98) A4(38.5,-0.02) A5(37.5,1.98) A6(36.5,-0.02) A7(35.5,1.98) A8(34.5,-0.02) A9(33.5,1.98) A10(32.5,-0.02) A11(31.5,1.98) A12(28.5,-0.02) A13(27.5,1.98) A14(26.5,-0.02) A15(25.5,1.98) A16(24.5,-0.02) A17(23.5,1.98) A18(22.5,-0.02) A19(21.5,1.98) A20(20.5,-0.02) A21(19.5,1.98) A22(18.5,-0.02) A23(17.5,1.98) A24(16.5,-0.02) A25(15.5,1.98) A26(14.5,-0.02) A27(13.5,1.98) A28(12.5,-0.02) A29(11.5,1.98) A30(10.5,-0.02) A31(9.5,1.98) A32(8.5,-0.02) A33(7.5,1.98) A34(6.5,-0.02) A35(5.5,1.98) A36(4.5,-0.02) A37(3.5,1.98) A38(2.5,-0.02) A39(1.5,1.98) A40(0.5,-0.02) A41(-0.5,1.98) A42(-1.5,-0.02) A43(-2.5,1.98) A44(-3.5,-0.02) A45(-4.5,1.98) A46(-5.5,-0.02) A47(-6.5,1.98) A48(-7.5,-0.02) A49(-8.5,1.98) A50(-9.5,-0.02) A51(-10.5,1.98) A52(-11.5,-0.02) A53(-12.5,1.98) A54(-13.5,-0.02) A55(-14.5,1.98) A56(-15.5,-0.02) A57(-16.5,1.98) A58(-17.5,-0.02) A59(-18.5,1.98) A60(-19.5,-0.02) A61(-20.5,1.98) A62(-21.5,-0.02) A63(-22.5,1.98) A64(-23.5,-0.02) A65(-24.5,1.98) A66(-25.5,-0.02) A67(-26.5,1.98) A68(-27.5,-0.02) A69(-28.5,1.98) A70(-29.5,-0.02) A71(-30.5,1.98) A72(-31.5,-0.02) A73(-32.5,1.98) A74(-33.5,-0.02) A75(-34.5,1.98) A76(-35.5,-0.02) A77(-36.5,1.98) A78(-37.5,-0.02) A79(-38.5,1.98) A80(-39.5,-0.02) A81(-40.5,1.98) A82(-41.5,-0.02) B1(41.5,4.48) B2(40.5,6.48) B3(39.5,4.48) B4(38.5,6.48) B5(37.5,4.48) B6(36.5,6.48) B7(35.5,4.48) B8(34.5,6.48) B9(33.5,4.48) B10(32.5,6.48) B11(31.5,4.48) B12(28.5,6.48) B13(27.5,4.48) B14(26.5,6.48) B15(25.5,4.48) B16(24.5,6.48) B17(23.5,4.48) B18(22.5,6.48) B19(21.5,4.48) B20(20.5,6.48) B21(19.5,4.48) B22(18.5,6.48) B23(17.5,4.48) B24(16.5,6.48) B25(15.5,4.48) B26(14.5,6.48) B27(13.5,4.48) B28(12.5,6.48) B29(11.5,4.48) B30(10.5,6.48) B31(9.5,4.48) B32(8.5,6.48) B33(7.5,4.48) B34(6.5,6.48) B35(5.5,4.48) B36(4.5,6.48) B37(3.5,4.48) B38(2.5,6.48) B39(1.5,4.48) B40(0.5,6.48) B41(-0.5,4.48) B42(-1.5,6.48) B43(-2.5,4.48) B44(-3.5,6.48) B45(-4.5,4.48) B46(-5.5,6.48) B47(-6.5,4.48) B48(-7.5,6.48) B49(-8.5,4.48) B50(-9.5,6.48) B51(-10.5,4.48) B52(-11.5,6.48) B53(-12.5,4.48) B54(-13.5,6.48) B55(-14.5,4.48) B56(-15.5,6.48) B57(-16.5,4.48) B58(-17.5,6.48) B59(-18.5,4.48) B60(-19.5,6.48) B61(-20.5,4.48) B62(-21.5,6.48) B63(-22.5,4.48) B64(-23.5,6.48) B65(-24.5,4.48) B66(-25.5,6.48) B67(-26.5,4.48) B68(-27.5,6.48) B69(-28.5,4.48) B70(-29.5,6.48) B71(-30.5,4.48) B72(-31.5,6.48) B73(-32.5,4.48) B74(-33.5,6.48) B75(-34.5,4.48) B76(-35.5,6.48) B77(-36.5,4.48) B78(-37.5,6.48) B79(-38.5,4.48) B80(-39.5,6.48) B81(-40.5,4.48) B82(-41.5,6.48)
CN-S5X2-2_54AHDS0
  rect 2.362x1.245 smd: 1(3.007,-5.08) 2(-3.007,-5.08) 3(3.007,-2.54) 4(-3.007,-2.54) 5(3.007,0) 6(-3.007,0) 7(3.007,2.54) 8(-3.007,2.54) 9(3.007,5.08) 10(-3.007,5.08)
CN-S10_16X5_1-4
  rect 3.099x0.965 smd: 1(1.562,3.81) 2(-1.562,1.27) 3(1.562,-1.27) 4(-1.562,-3.81)
CN-S13X2-2HD
  round 1.143 hole 1.143 unplated: (0,11) (0,-11)
  rect 2.184x0.813 smd: 1(2.471,-12) 2(-2.471,-12) 3(2.471,-10) 4(-2.471,-10) 5(2.471,-8) 6(-2.471,-8) 7(2.471,-6) 8(-2.471,-6) 9(2.471,-4) 10(-2.471,-4) 11(2.471,-2) 12(-2.471,-2) 13(2.471,0) 14(-2.471,0) 15(2.471,2) 16(-2.471,2) 17(2.471,4) 18(-2.471,4) 19(2.471,6) 20(-2.471,6) 21(2.471,8) 22(-2.471,8) 23(2.471,10) 24(-2.471,10) 25(2.471,12) 26(-2.471,12)
D-SMA-H2_41
  rect 2.007x2.007 smd: 1(0,-1.999) 2(0,1.999)
D-SMAH2_3
  rect 2.007x2.007 smd: 1(0,1.999) 2(0,-1.999)
D-SMBS0
  rect 2.743x2.159 smd: 1(0,2.21) 2(0,-2.21)
DO-214A-H2_65
  rect 2.794x2.007 smd: 1(0,-2) 2(0,2)
E-PMODULE-S16X12_2-24
  rect 1.295x0.914 smd: 1(5.797,-7) 2(5.797,-5.9) 3(5.797,-4.8) 4(5.797,-3.7) 5(5.797,-2.6) 6(5.797,-1.5) 7(5.797,-0.4) 8(5.797,2.6) 9(5.797,3.7) 10(5.797,4.8) 11(5.797,5.9) 12(5.797,7) 13(-5.797,7) 14(-5.797,5.9) 15(-5.797,4.8) 16(-5.797,3.7) 17(-5.797,2.6) 18(-5.797,-0.4) 19(-5.797,-1.5) 20(-5.797,-2.6) 21(-5.797,-3.7) 22(-5.797,-4.8) 23(-5.797,-5.9) 24(-5.797,-7)
EQFN-3X2-10SS0
  rect 0.508x0.356 smd: 1(0.903,-1.25) 2(0.903,-0.65) 3(0.903,0) 4(0.903,0.65) 5(0.903,1.25) 6(-0.903,1.25) 7(-0.903,0.65) 8(-0.903,0) 9(-0.903,-0.65) 10(-0.903,-1.25)
  rect 1.092x0.457 smd: 11(0,-0.95) 12(0,0) 13(0,0.95)
F-S5_4X3_3-2
  rect 2.769x1.473 smd: 1(0,-2.437) 2(0,2.437)
FBGA-13X13-169A-H1_55
  round 0.356 smd: A1(-4.801,-4.801) A2(-4.801,-4) A3(-4.801,-3.2) A4(-4.801,-2.4) A5(-4.801,-1.6) A6(-4.801,-0.8) A7(-4.801,0) A8(-4.801,0.8) A9(-4.801,1.6) A10(-4.801,2.4) A11(-4.801,3.2) A12(-4.801,4) A13(-4.801,4.801) B1(-4,-4.801) B2(-4,-4) B3(-4,-3.2) B4(-4,-2.4) B5(-4,-1.6) B6(-4,-0.8) B7(-4,0) B8(-4,0.8) B9(-4,1.6) B10(-4,2.4) B11(-4,3.2) B12(-4,4) B13(-4,4.801) C1(-3.2,-4.801) C2(-3.2,-4) C3(-3.2,-3.2) C4(-3.2,-2.4) C5(-3.2,-1.6) C6(-3.2,-0.8) C7(-3.2,0) C8(-3.2,0.8) C9(-3.2,1.6) C10(-3.2,2.4) C11(-3.2,3.2) C12(-3.2,4) C13(-3.2,4.801) D1(-2.4,-4.801) D2(-2.4,-4) D3(-2.4,-3.2) D4(-2.4,-2.4) D5(-2.4,-1.6) D6(-2.4,-0.8) D7(-2.4,0) D8(-2.4,0.8) D9(-2.4,1.6) D10(-2.4,2.4) D11(-2.4,3.2) D12(-2.4,4) D13(-2.4,4.801) E1(-1.6,-4.801) E2(-1.6,-4) E3(-1.6,-3.2) E4(-1.6,-2.4) E5(-1.6,-1.6) E6(-1.6,-0.8) E7(-1.6,0) E8(-1.6,0.8) E9(-1.6,1.6) E10(-1.6,2.4) E11(-1.6,3.2) E12(-1.6,4) E13(-1.6,4.801) F1(-0.8,-4.801) F2(-0.8,-4) F3(-0.8,-3.2) F4(-0.8,-2.4) F5(-0.8,-1.6) F6(-0.8,-0.8) F7(-0.8,0) F8(-0.8,0.8) F9(-0.8,1.6) F10(-0.8,2.4) F11(-0.8,3.2) F12(-0.8,4) F13(-0.8,4.801) G1(0,-4.801) G2(0,-4) G3(0,-3.2) G4(0,-2.4) G5(0,-1.6) G6(0,-0.8) G7(0,0) G8(0,0.8) G9(0,1.6) G10(0,2.4) G11(0,3.2) G12(0,4) G13(0,4.801) H1(0.8,-4.801) H2(0.8,-4) H3(0.8,-3.2) H4(0.8,-2.4) H5(0.8,-1.6) H6(0.8,-0.8) H7(0.8,0) H8(0.8,0.8) H9(0.8,1.6) H10(0.8,2.4) H11(0.8,3.2) H12(0.8,4) H13(0.8,4.801) J1(1.6,-4.801) J2(1.6,-4) J3(1.6,-3.2) J4(1.6,-2.4) J5(1.6,-1.6) J6(1.6,-0.8) J7(1.6,0) J8(1.6,0.8) J9(1.6,1.6) J10(1.6,2.4) J11(1.6,3.2) J12(1.6,4) J13(1.6,4.801) K1(2.4,-4.801) K2(2.4,-4) K3(2.4,-3.2) K4(2.4,-2.4) K5(2.4,-1.6) K6(2.4,-0.8) K7(2.4,0) K8(2.4,0.8) K9(2.4,1.6) K10(2.4,2.4) K11(2.4,3.2) K12(2.4,4) K13(2.4,4.801) L1(3.2,-4.801) L2(3.2,-4) L3(3.2,-3.2) L4(3.2,-2.4) L5(3.2,-1.6) L6(3.2,-0.8) L7(3.2,0) L8(3.2,0.8) L9(3.2,1.6) L10(3.2,2.4) L11(3.2,3.2) L12(3.2,4) L13(3.2,4.801) M1(4,-4.801) M2(4,-4) M3(4,-3.2) M4(4,-2.4) M5(4,-1.6) M6(4,-0.8) M7(4,0) M8(4,0.8) M9(4,1.6) M10(4,2.4) M11(4,3.2) M12(4,4) M13(4,4.801) N1(4.801,-4.801) N2(4.801,-4) N3(4.801,-3.2) N4(4.801,-2.4) N5(4.801,-1.6) N6(4.801,-0.8) N7(4.801,0) N8(4.801,0.8) N9(4.801,1.6) N10(4.801,2.4) N11(4.801,3.2) N12(4.801,4) N13(4.801,4.801)
FBGA-16X9-96A
  round 0.356 smd: A1(-6.001,-3.2) A2(-6.001,-2.4) A3(-6.001,-1.6) A7(-6.001,1.6) A8(-6.001,2.4) A9(-6.001,3.2) B1(-5.201,-3.2) B2(-5.201,-2.4) B3(-5.201,-1.6) B7(-5.201,1.6) B8(-5.201,2.4) B9(-5.201,3.2) C1(-4.401,-3.2) C2(-4.401,-2.4) C3(-4.401,-1.6) C7(-4.401,1.6) C8(-4.401,2.4) C9(-4.401,3.2) D1(-3.6,-3.2) D2(-3.6,-2.4) D3(-3.6,-1.6) D7(-3.6,1.6) D8(-3.6,2.4) D9(-3.6,3.2) E1(-2.8,-3.2) E2(-2.8,-2.4) E3(-2.8,-1.6) E7(-2.8,1.6) E8(-2.8,2.4) E9(-2.8,3.2) F1(-2,-3.2) F2(-2,-2.4) F3(-2,-1.6) F7(-2,1.6) F8(-2,2.4) F9(-2,3.2) G1(-1.2,-3.2) G2(-1.2,-2.4) G3(-1.2,-1.6) G7(-1.2,1.6) G8(-1.2,2.4) G9(-1.2,3.2) H1(-0.4,-3.2) H2(-0.4,-2.4) H3(-0.4,-1.6) H7(-0.4,1.6) H8(-0.4,2.4) H9(-0.4,3.2) J1(0.4,-3.2) J2(0.4,-2.4) J3(0.4,-1.6) J7(0.4,1.6) J8(0.4,2.4) J9(0.4,3.2) K1(1.2,-3.2) K2(1.2,-2.4) K3(1.2,-1.6) K7(1.2,1.6) K8(1.2,2.4) K9(1.2,3.2) L1(2,-3.2) L2(2,-2.4) L3(2,-1.6) L7(2,1.6) L8(2,2.4) L9(2,3.2) M1(2.8,-3.2) M2(2.8,-2.4) M3(2.8,-1.6) M7(2.8,1.6) M8(2.8,2.4) M9(2.8,3.2) N1(3.6,-3.2) N2(3.6,-2.4) N3(3.6,-1.6) N7(3.6,1.6) N8(3.6,2.4) N9(3.6,3.2) P1(4.401,-3.2) P2(4.401,-2.4) P3(4.401,-1.6) P7(4.401,1.6) P8(4.401,2.4) P9(4.401,3.2) R1(5.201,-3.2) R2(5.201,-2.4) R3(5.201,-1.6) R7(5.201,1.6) R8(5.201,2.4) R9(5.201,3.2) T1(6.001,-3.2) T2(6.001,-2.4) T3(6.001,-1.6) T7(6.001,1.6) T8(6.001,2.4) T9(6.001,3.2)
FBGA-16X9-96F
  round 0.356 smd: A1(-6.001,-3.2) A2(-6.001,-2.4) A3(-6.001,-1.6) A7(-6.001,1.6) A8(-6.001,2.4) A9(-6.001,3.2) B1(-5.201,-3.2) B2(-5.201,-2.4) B3(-5.201,-1.6) B7(-5.201,1.6) B8(-5.201,2.4) B9(-5.201,3.2) C1(-4.401,-3.2) C2(-4.401,-2.4) C3(-4.401,-1.6) C7(-4.401,1.6) C8(-4.401,2.4) C9(-4.401,3.2) D1(-3.6,-3.2) D2(-3.6,-2.4) D3(-3.6,-1.6) D7(-3.6,1.6) D8(-3.6,2.4) D9(-3.6,3.2) E1(-2.8,-3.2) E2(-2.8,-2.4) E3(-2.8,-1.6) E7(-2.8,1.6) E8(-2.8,2.4) E9(-2.8,3.2) F1(-2,-3.2) F2(-2,-2.4) F3(-2,-1.6) F7(-2,1.6) F8(-2,2.4) F9(-2,3.2) G1(-1.2,-3.2) G2(-1.2,-2.4) G3(-1.2,-1.6) G7(-1.2,1.6) G8(-1.2,2.4) G9(-1.2,3.2) H1(-0.4,-3.2) H2(-0.4,-2.4) H3(-0.4,-1.6) H7(-0.4,1.6) H8(-0.4,2.4) H9(-0.4,3.2) J1(0.4,-3.2) J2(0.4,-2.4) J3(0.4,-1.6) J7(0.4,1.6) J8(0.4,2.4) J9(0.4,3.2) K1(1.2,-3.2) K2(1.2,-2.4) K3(1.2,-1.6) K7(1.2,1.6) K8(1.2,2.4) K9(1.2,3.2) L1(2,-3.2) L2(2,-2.4) L3(2,-1.6) L7(2,1.6) L8(2,2.4) L9(2,3.2) M1(2.8,-3.2) M2(2.8,-2.4) M3(2.8,-1.6) M7(2.8,1.6) M8(2.8,2.4) M9(2.8,3.2) N1(3.6,-3.2) N2(3.6,-2.4) N3(3.6,-1.6) N7(3.6,1.6) N8(3.6,2.4) N9(3.6,3.2) P1(4.401,-3.2) P2(4.401,-2.4) P3(4.401,-1.6) P7(4.401,1.6) P8(4.401,2.4) P9(4.401,3.2) R1(5.201,-3.2) R2(5.201,-2.4) R3(5.201,-1.6) R7(5.201,1.6) R8(5.201,2.4) R9(5.201,3.2) T1(6.001,-3.2) T2(6.001,-2.4) T3(6.001,-1.6) T7(6.001,1.6) T8(6.001,2.4) T9(6.001,3.2)
FBGA-22X22-408
  round 0.356 smd: A1(-8.401,-8.401) A2(-8.401,-7.601) A3(-8.401,-6.801) A4(-8.401,-6.001) A5(-8.401,-5.201) A6(-8.401,-4.401) A7(-8.401,-3.6) A8(-8.401,-2.8) A9(-8.401,-2) A10(-8.401,-1.2) A11(-8.401,-0.4) A12(-8.401,0.4) A13(-8.401,1.2) A14(-8.401,2) A15(-8.401,2.8) A16(-8.401,3.6) A17(-8.401,4.401) A18(-8.401,5.201) A19(-8.401,6.001) A20(-8.401,6.801) A21(-8.401,7.601) A22(-8.401,8.401) AA1(7.601,-8.401) AA2(7.601,-7.601) AA3(7.601,-6.801) AA4(7.601,-6.001) AA5(7.601,-5.201) AA6(7.601,-4.401) AA7(7.601,-3.6) AA8(7.601,-2.8) AA9(7.601,-2) AA10(7.601,-1.2) AA11(7.601,-0.4) AA12(7.601,0.4) AA13(7.601,1.2) AA14(7.601,2) AA15(7.601,2.8) AA16(7.601,3.6) AA17(7.601,4.401) AA18(7.601,5.201) AA19(7.601,6.001) AA20(7.601,6.801) AA21(7.601,7.601) AA22(7.601,8.401) AB1(8.401,-8.401) AB2(8.401,-7.601) AB3(8.401,-6.801) AB4(8.401,-6.001) AB5(8.401,-5.201) AB6(8.401,-4.401) AB7(8.401,-3.6) AB8(8.401,-2.8) AB9(8.401,-2) AB10(8.401,-1.2) AB11(8.401,-0.4) AB12(8.401,0.4) AB13(8.401,1.2) AB14(8.401,2) AB15(8.401,2.8) AB16(8.401,3.6) AB17(8.401,4.401) AB18(8.401,5.201) AB19(8.401,6.001) AB20(8.401,6.801) AB21(8.401,7.601) AB22(8.401,8.401) B1(-7.601,-8.401) B2(-7.601,-7.601) B3(-7.601,-6.801) B4(-7.601,-6.001) B5(-7.601,-5.201) B6(-7.601,-4.401) B7(-7.601,-3.6) B8(-7.601,-2.8) B9(-7.601,-2) B10(-7.601,-1.2) B11(-7.601,-0.4) B12(-7.601,0.4) B13(-7.601,1.2) B14(-7.601,2) B15(-7.601,2.8) B16(-7.601,3.6) B17(-7.601,4.401) B18(-7.601,5.201) B19(-7.601,6.001) B20(-7.601,6.801) B21(-7.601,7.601) B22(-7.601,8.401) C1(-6.801,-8.401) C2(-6.801,-7.601) C3(-6.801,-6.801) C4(-6.801,-6.001) C5(-6.801,-5.201) C6(-6.801,-4.401) C7(-6.801,-3.6) C8(-6.801,-2.8) C9(-6.801,-2) C10(-6.801,-1.2) C11(-6.801,-0.4) C12(-6.801,0.4) C13(-6.801,1.2) C14(-6.801,2) C15(-6.801,2.8) C16(-6.801,3.6) C17(-6.801,4.401) C18(-6.801,5.201) C19(-6.801,6.001) C20(-6.801,6.801) C21(-6.801,7.601) C22(-6.801,8.401) D1(-6.001,-8.401) D2(-6.001,-7.601) D3(-6.001,-6.801) D4(-6.001,-6.001) D5(-6.001,-5.201) D6(-6.001,-4.401) D7(-6.001,-3.6) D8(-6.001,-2.8) D9(-6.001,-2) D10(-6.001,-1.2) D11(-6.001,-0.4) D12(-6.001,0.4) D13(-6.001,1.2) D14(-6.001,2) D15(-6.001,2.8) D16(-6.001,3.6) D17(-6.001,4.401) D18(-6.001,5.201) D19(-6.001,6.001) D20(-6.001,6.801) D21(-6.001,7.601) D22(-6.001,8.401) E1(-5.201,-8.401) E2(-5.201,-7.601) E3(-5.201,-6.801) E4(-5.201,-6.001) E5(-5.201,-5.201) E6(-5.201,-4.401) E7(-5.201,-3.6) E8(-5.201,-2.8) E9(-5.201,-2) E10(-5.201,-1.2) E11(-5.201,-0.4) E12(-5.201,0.4) E13(-5.201,1.2) E14(-5.201,2) E15(-5.201,2.8) E16(-5.201,3.6) E17(-5.201,4.401) E18(-5.201,5.201) E19(-5.201,6.001) E20(-5.201,6.801) E21(-5.201,7.601) E22(-5.201,8.401) F1(-4.401,-8.401) F2(-4.401,-7.601) F3(-4.401,-6.801) F4(-4.401,-6.001) F5(-4.401,-5.201) F8(-4.401,-2.8) F9(-4.401,-2) F10(-4.401,-1.2) F11(-4.401,-0.4) F12(-4.401,0.4) F13(-4.401,1.2) F14(-4.401,2) F15(-4.401,2.8) F18(-4.401,5.201) F19(-4.401,6.001) F20(-4.401,6.801) F21(-4.401,7.601) F22(-4.401,8.401) G1(-3.6,-8.401) G2(-3.6,-7.601) G3(-3.6,-6.801) G4(-3.6,-6.001) G5(-3.6,-5.201) G18(-3.6,5.201) G19(-3.6,6.001) G20(-3.6,6.801) G21(-3.6,7.601) G22(-3.6,8.401) H1(-2.8,-8.401) H2(-2.8,-7.601) H3(-2.8,-6.801) H4(-2.8,-6.001) H5(-2.8,-5.201) H6(-2.8,-4.401) H17(-2.8,4.401) H18(-2.8,5.201) H19(-2.8,6.001) H20(-2.8,6.801) H21(-2.8,7.601) H22(-2.8,8.401) J1(-2,-8.401) J2(-2,-7.601) J3(-2,-6.801) J4(-2,-6.001) J5(-2,-5.201) J6(-2,-4.401) J9(-2,-2) J10(-2,-1.2) J11(-2,-0.4) J12(-2,0.4) J13(-2,1.2) J14(-2,2) J17(-2,4.401) J18(-2,5.201) J19(-2,6.001) J20(-2,6.801) J21(-2,7.601) J22(-2,8.401) K1(-1.2,-8.401) K2(-1.2,-7.601) K3(-1.2,-6.801) K4(-1.2,-6.001) K5(-1.2,-5.201) K6(-1.2,-4.401) K9(-1.2,-2) K10(-1.2,-1.2) K11(-1.2,-0.4) K12(-1.2,0.4) K13(-1.2,1.2) K14(-1.2,2) K17(-1.2,4.401) K18(-1.2,5.201) K19(-1.2,6.001) K20(-1.2,6.801) K21(-1.2,7.601) K22(-1.2,8.401) L1(-0.4,-8.401) L2(-0.4,-7.601) L3(-0.4,-6.801) L4(-0.4,-6.001) L5(-0.4,-5.201) L6(-0.4,-4.401) L9(-0.4,-2) L10(-0.4,-1.2) L11(-0.4,-0.4) L12(-0.4,0.4) L13(-0.4,1.2) L14(-0.4,2) L17(-0.4,4.401) L18(-0.4,5.201) L19(-0.4,6.001) L20(-0.4,6.801) L21(-0.4,7.601) L22(-0.4,8.401) M1(0.4,-8.401) M2(0.4,-7.601) M3(0.4,-6.801) M4(0.4,-6.001) M5(0.4,-5.201) M6(0.4,-4.401) M9(0.4,-2) M10(0.4,-1.2) M11(0.4,-0.4) M12(0.4,0.4) M13(0.4,1.2) M14(0.4,2) M17(0.4,4.401) M18(0.4,5.201) M19(0.4,6.001) M20(0.4,6.801) M21(0.4,7.601) M22(0.4,8.401) N1(1.2,-8.401) N2(1.2,-7.601) N3(1.2,-6.801) N4(1.2,-6.001) N5(1.2,-5.201) N6(1.2,-4.401) N9(1.2,-2) N10(1.2,-1.2) N11(1.2,-0.4) N12(1.2,0.4) N13(1.2,1.2) N14(1.2,2) N17(1.2,4.401) N18(1.2,5.201) N19(1.2,6.001) N20(1.2,6.801) N21(1.2,7.601) N22(1.2,8.401) P1(2,-8.401) P2(2,-7.601) P3(2,-6.801) P4(2,-6.001) P5(2,-5.201) P6(2,-4.401) P9(2,-2) P10(2,-1.2) P11(2,-0.4) P12(2,0.4) P13(2,1.2) P14(2,2) P17(2,4.401) P18(2,5.201) P19(2,6.001) P20(2,6.801) P21(2,7.601) P22(2,8.401) R1(2.8,-8.401) R2(2.8,-7.601) R3(2.8,-6.801) R4(2.8,-6.001) R5(2.8,-5.201) R6(2.8,-4.401) R17(2.8,4.401) R18(2.8,5.201) R19(2.8,6.001) R20(2.8,6.801) R21(2.8,7.601) R22(2.8,8.401) T1(3.6,-8.401) T2(3.6,-7.601) T3(3.6,-6.801) T4(3.6,-6.001) T5(3.6,-5.201) T18(3.6,5.201) T19(3.6,6.001) T20(3.6,6.801) T21(3.6,7.601) T22(3.6,8.401) U1(4.401,-8.401) U2(4.401,-7.601) U3(4.401,-6.801) U4(4.401,-6.001) U5(4.401,-5.201) U8(4.401,-2.8) U9(4.401,-2) U10(4.401,-1.2) U11(4.401,-0.4) U12(4.401,0.4) U13(4.401,1.2) U14(4.401,2) U15(4.401,2.8) U18(4.401,5.201) U19(4.401,6.001) U20(4.401,6.801) U21(4.401,7.601) U22(4.401,8.401) V1(5.201,-8.401) V2(5.201,-7.601) V3(5.201,-6.801) V4(5.201,-6.001) V5(5.201,-5.201) V6(5.201,-4.401) V7(5.201,-3.6) V8(5.201,-2.8) V9(5.201,-2) V10(5.201,-1.2) V11(5.201,-0.4) V12(5.201,0.4) V13(5.201,1.2) V14(5.201,2) V15(5.201,2.8) V16(5.201,3.6) V17(5.201,4.401) V18(5.201,5.201) V19(5.201,6.001) V20(5.201,6.801) V21(5.201,7.601) V22(5.201,8.401) W1(6.001,-8.401) W2(6.001,-7.601) W3(6.001,-6.801) W4(6.001,-6.001) W5(6.001,-5.201) W6(6.001,-4.401) W7(6.001,-3.6) W8(6.001,-2.8) W9(6.001,-2) W10(6.001,-1.2) W11(6.001,-0.4) W12(6.001,0.4) W13(6.001,1.2) W14(6.001,2) W15(6.001,2.8) W16(6.001,3.6) W17(6.001,4.401) W18(6.001,5.201) W19(6.001,6.001) W20(6.001,6.801) W21(6.001,7.601) W22(6.001,8.401) Y1(6.801,-8.401) Y2(6.801,-7.601) Y3(6.801,-6.801) Y4(6.801,-6.001) Y5(6.801,-5.201) Y6(6.801,-4.401) Y7(6.801,-3.6) Y8(6.801,-2.8) Y9(6.801,-2) Y10(6.801,-1.2) Y11(6.801,-0.4) Y12(6.801,0.4) Y13(6.801,1.2) Y14(6.801,2) Y15(6.801,2.8) Y16(6.801,3.6) Y17(6.801,4.401) Y18(6.801,5.201) Y19(6.801,6.001) Y20(6.801,6.801) Y21(6.801,7.601) Y22(6.801,8.401)
