# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SFP_PWR_ILIM05: length 3.9
  TOP w0.14: U27.7 158.87,75.37 159.17,75.07 v5(159.17,74.22)
  BOTTOM w0.14: R607.1 157.66,73.59 158.53,73.59 v5(159.17,74.22)
SFP_PWR_ILIM06: length 3.9
  TOP w0.14: U30.7 170.9,75.37 171.32,74.95 v5(171.32,74.42)
  BOTTOM w0.14: v5(171.32,74.42) 170.44,73.54 169.79,73.54 R610.1
SFP_PWR_ILIM07: length 4.3
  TOP w0.14: U33.7 183.03,75.37 183.45,74.95 v5(183.45,74.49)
  BOTTOM w0.14: R613.1 181.87,73.54 183.07,73.54 183.45,73.92 v5(183.45,74.49)
SFP_PWR_ILIM08: length 3.9
  TOP w0.14: v5(211.2,74.22) 211.2,75.07 210.89,75.37 U36.7
  BOTTOM w0.14: v5(211.2,74.22) 210.56,73.59 209.69,73.59 R616.1
SFP_PWR_ILIM09: length 3.8
  TOP w0.14: U39.7 222.97,75.37 223.27,75.07 v5(223.27,74.22)
  BOTTOM w0.14: R619.1 221.69,73.66 222.72,73.66 v5(223.27,74.22)
SFP_PWR_ILIM10: length 4
  TOP w0.14: U28.7 235.01,75.37 235.35,75.03 v5(235.35,74)
  BOTTOM w0.14: R608.1 233.89,73.54 234.89,73.54 v5(235.35,74)
SFP_PWR_ILIM11: length 4.2
  TOP w0.14: U31.7 247.11,75.37 247.63,74.85 247.63,74.33 247.62,74.32 v5(247.62,74.2)
  BOTTOM w0.14: R611.1 245.97,73.54 246.96,73.54 v5(247.62,74.2)
SFP_PWR_ILIM12: length 4.1
  TOP w0.14: v5(259.67,74.44) 259.67,75 259.26,75.42 U34.7
  BOTTOM w0.14: R614.1 258.18,73.53 259.07,73.53 259.67,74.13 v5(259.67,74.44)
SFP_PWR_ILIM13: length 5
  TOP w0.14: U37.7 274.44,75.42 275.06,74.79 275.06,74.33 274.64,73.91 273.81,73.91 v1(273.56,74.17)
  BOTTOM w0.14: v1(273.56,74.17) 273.46,74.27 R617.1
SI5344B_OE_N: length 3.6
  TOP w0.14: U135.12 154.07,126.52 153.53,125.97 v1(153.47,125.97) 151.89,124.39 R1980.1
SKU_ID0: length 5.2
  TOP w0.14: U150.17 107.16,178.33 106.75,178.75 v5(105.76,178.75)
  BOTTOM w0.14: v5(105.76,178.75) 105.1,179.4 R1736.2 R1737.2
SKU_ID1: length 6.2
  TOP w0.14: U150.18 107.81,176.63 108.55,175.9 v1(108.97,175.9) 109.07,175.79 R1739.2 109.55,175.21 109.7,175.06 109.7,173.2 109.43,172.93 R1738.2
SKU_ID2: length 4.3
  TOP w0.14: U150.19 108.47,178.3 v5(107.82,178.94)
  BOTTOM w0.14: v5(107.82,178.94) 107.24,179.53 R12284.2 R12985.2
SKU_ID3: length 4
  TOP w0.14: v5(109.09,178.82) 109.12,178.79 U150.20
  BOTTOM w0.14: v5(109.09,178.82) 108.23,179.68 R12285.2 R12986.2
SMB_NIC1_CLK: length 6
  TOP w0.14: U85.34 91.36,94.11 91.13,94.35 91.13,95.28 90.59,95.82 R1207.2 89.29,95.83 89.29,96.98 v1(89.93,97.61)
SMB_NIC1_DAT: length 2.9
  TOP w0.14: U85.36 90.53,93.11 v1(90.03,92.61) 89.49,92.61 R1208.2
SMU_DPLL1_LOCK: length 133.1
  TOP w0.14: U70.L3 v4(111.6,124.05)
  T07 w0.117: v1(8.89,93.66) 10.35,92.2 17.53,92.2 17.91,91.82 17.91,89.03 18.16,88.77 19.3,88.77 20.32,89.79 26.16,89.79 27.81,88.14 40.19,88.14 41.94,89.89 v1(43.35,89.89)
  T16 w0.117: v4(111.6,124.05) 108.43,124.05 106.93,122.55 106.93,118.11 103.91,115.08 103.91,109.36 101.44,106.9 94.03,106.9 89.89,102.76 89.89,101.35 87.68,99.14 75.72,99.14 74.85,100.01 67.96,100.01 67.01,99.06 67.01,97.75 60.43,91.17 44.63,91.17 v1(43.35,89.89)
  BOTTOM w0.14: v1(8.89,93.66) R1681.1 R1665.1
SMU_DPLL2_LOCK: length 125.3
  TOP w0.14: U70.N8 v4(116.4,122.45) ; U139.G9 v4(18.43,89.3)
  T07 w0.117: v4(116.4,122.45) 115.22,121.27 115.22,118.77 111.17,114.73 107.17,114.73 104.16,111.72 104.16,111.37 104.16,111.02 104.16,108.3 101.79,105.93 93.68,105.93 84.54,96.78 66.25,96.78 63.54,94.07 55.54,94.07 54.23,95.38 43.28,95.38 42.62,94.71 34.54,94.71 32.37,96.88 29.01,96.88 24.38,92.25 20.11,92.25 19.3,91.44 19.3,90.17 v4(18.43,89.3)
  BOTTOM w0.14: v4(18.43,89.3) 17.91,89.83 17.91,91.57 18.31,91.97 R12484.1 18.31,92.48 19.3,93.47 v2(19.3,93.73)
SMU_DPLL3_LOCK: length 1
  BOTTOM w0.14: R1682.1 19.04,88.44 R1666.1
SMU_I2C_ADDR1: length 7.6
  TOP w0.14: U139.E5 v4(21.43,94.3)
  T05 w0.117: v1(22.61,99.44) 21.93,98.76 21.93,94.8 v4(21.43,94.3)
  BOTTOM w0.14: v1(22.61,99.44) 22.35,99.19 R1684.1
SMU_I2C_ADDR2: length 11.7
  TOP w0.14: U139.D9 v4(22.43,89.3)
  BOTTOM w0.14: R1683.1 30.01,87.12 28.7,87.12 27.81,86.23 v2(25.53,86.23) 25.4,86.23 24.97,86.66 24.97,88.25 24.39,88.83 22.91,88.83 v4(22.43,89.3)
SMU_INPUT0_LOS_N: length 6.3
  TOP w0.14: R1677.1 R12799.2 20.22,100.48 v1(19.81,100.08) 19.05,99.31 18.54,99.31 17.8,98.58 17.8,97.93 U139.H1
SMU_INPUT1_LOS_N: length 136.3
  TOP w0.14: U70.B9 117.21,132.06 117.21,133.36 117.02,133.54 117.02,135.16 v1(117.55,135.69) ; U139.J1 16.93,98.46 v1(18.54,100.08) 18.54,101.21 R1678.1
  T07 w0.117: v1(117.55,135.69) 116.76,134.89 116.76,133.76 117.39,133.12 117.39,131.81 117.6,131.6 117.6,129.49 117.37,129.25 115.22,129.25 114.94,129.54 114.94,131.69 114.17,132.45 108.16,132.45 104.29,128.59 100.18,128.59 87.62,116.02 86.26,116.02 86.01,115.78 81.55,115.78 81.41,115.93 77.55,115.93 72.84,111.22 72.84,106.13 68.89,102.18 55.34,102.18 53.66,100.5 46.25,100.5 45.14,101.6 34.79,101.6 32.87,99.68 25.01,99.68 24.2,98.87 21.52,98.87 20.89,99.51 19.11,99.51 v1(18.54,100.08)
SMU_INPUT2_LOS_N: length 5.6
  TOP w0.14: U139.J2 16.42,97.31 16.42,99.22 v1(17.27,100.08) 17.27,101.34 R1679.1
SMU_INPUT3_LOS_N: length 6
  TOP w0.14: v1(25.48,87.26) U139.A11
  BOTTOM w0.14: R1680.1 27.26,87.56 v2(26.95,87.25) 25.48,87.25 v1(25.48,87.26)
SMU_MASTER: length 6.3
  TOP w0.14: U139.K8 v4(15.43,90.3)
  BOTTOM w0.14: R1661.2 12.13,89.59 v2(12.7,89.03) 13.4,89.03 14.22,89.85 14.99,89.85 15.43,90.29 v4(15.43,90.3)
SPI_BITS_CS_IN_N: length 3.9
  TOP w0.14: v1(78.36,85.02) 79.29,85.95 U127.38
  BOTTOM w0.14: R1409.2 v1(78.36,85.02)
SPI_BITS_CS_N: length 14.4
  TOP w0.14: U162.22 83.61,80.92 83.44,81.08 83.44,81.72 v1(83.06,82.1)
  T16 w0.117: v1(75.3,85.02) 74.55,84.27 74.55,83.31 76.01,81.84 82.8,81.84 v1(83.06,82.1)
  BOTTOM w0.14: R1409.1 v1(75.3,85.02)
SPI_BITS_MISO: length 10.2
  TOP w0.14: U162.24 84.23,79.54 83.69,78.99 v1(83.06,78.99)
  T05 w0.117: v1(75.69,78.67) 76.27,79.25 82.8,79.25 v1(83.06,78.99)
  BOTTOM w0.14: R1412.1 v1(75.69,78.67)
SPI_BITS_MOSI: length 10.7
  T16 w0.117: v1(75.31,83.75) 75.92,83.14 83.41,83.14 v1(83.57,82.99)
  BOTTOM w0.14: R12438.2 84.2,82.35 v1(83.57,82.99) ; R1411.1 v1(75.31,83.75)
SPI_BITS_SCK: length 8.1
  TOP w0.14: U127.36 82.1,84.65 v1(82.93,83.82)
  T14 w0.117: v1(82.93,80.01) 82.17,80.77 82.17,83.06 v1(82.93,83.82)
  BOTTOM w0.14: R12437.2 83.86,80.01 v1(82.93,80.01)
SPI_BITS_SDI: length 4.4
  TOP w0.14: v1(78.36,83.75) 78.36,84.14 79.52,85.3 U127.37
  BOTTOM w0.14: R1411.2 v1(78.36,83.75)
SPI_BITS_SDO: length 4.6
  TOP w0.14: U127.24 79.69,76.85 78.61,77.93 v1(78.61,78.54)
  BOTTOM w0.14: R1412.2 78.48,78.67 v1(78.61,78.54)
SPI_PHY3_CLK: length 4.9
  TOP w0.14: U46.6 276.25,112.04 276.94,112.73 v1(276.94,113.49)
  BOTTOM w0.14: R1278.1 R1274.1 v1(276.94,113.49)
SPI_PHY3_CS_N: length 42.9
  TOP w0.14: U46.1 v1(269.64,114.58) ; U25.G12 v4(287.1,89.39)
  T16 w0.117: v1(269.64,114.58) 271.58,112.65 278.23,112.65 282.24,108.64 287.64,108.64 288.58,107.7 288.58,93.1 287.6,92.12 287.6,89.89 v4(287.1,89.39)
SPI_PHY3_HOLD_N: length 3.6
  TOP w0.14: v1(273.81,114.54) 273.81,113.79 274.29,113.31 U46.7
  BOTTOM w0.14: R1272.2 v1(273.81,114.54)
SPI_PHY3_MISO: length 44.5
  TOP w0.14: U46.2 v1(266.76,113.31) 265.91,113.31 R1276.2 ; U25.G14 v4(287.1,87.39)
  T16 w0.117: v1(266.76,113.31) 268.35,111.72 268.35,107.95 270.99,105.31 281.62,105.31 284.09,102.84 284.09,93.02 284.51,92.6 285.86,92.6 286.52,91.95 286.52,87.7 286.83,87.39 v4(287.1,87.39)
SPI_PHY3_MOSI: length 31.2
  TOP w0.14: v1(273.7,110.71) 273.77,110.77 U46.5 ; U25.F9 v4(288.1,93.39)
  T16 w0.117: v1(273.7,110.71) 274.56,109.85 280.08,109.85 287.6,102.32 287.6,93.88 v4(288.1,93.39)
  BOTTOM w0.14: v1(273.7,110.71) 273.98,110.44 R1275.1 R1273.2
SPI_PHY3_SCK: length 32.4
  TOP w0.14: U25.G10 v4(287.1,91.39)
  T16 w0.117: v1(273.43,112.01) 273.05,111.63 273.05,110.49 274.17,109.37 279.85,109.37 286.59,102.64 286.59,92.75 287.1,92.24 v4(287.1,91.39)
  BOTTOM w0.14: v1(273.43,112.01) 273.89,112.47 R1278.2
SPI_PHY3_WP_N: length 2.3
  TOP w0.14: U46.3 v1(266.7,112.04) 265.91,112.04 R1277.2
SPI_USB_MOSI: length 3.2
  TOP w0.14: v1(82.8,80.96) 83.34,80.42 U162.23
  BOTTOM w0.14: R12438.1 83.23,81.38 v1(82.8,80.96)
SPI_USB_SCK: length 2.9
  TOP w0.14: U162.1 84.94,79.1 v1(84.2,78.36)
  BOTTOM w0.14: v1(84.2,78.36) 84.8,78.96 84.8,79.38 84.8,79.38 84.8,79.88 R12437.1
SYNC: length 38.1
  TOP w0.254: PU2.35 32.51,164.37 32.26,164.62 32.26,164.67 v1(32.23,164.7) ; PR442.1 3.82,179.47 v1(4.1,179.75)
  T07 w0.254: v1(32.23,164.7) 32.21,164.72 31.75,164.72 28.23,168.23 27.17,168.23 26.17,169.24 26.17,170.3 23.37,173.1 9.77,173.1 9.35,173.1 6.86,175.59 6.86,176.1 5.43,177.52 5.43,178.42 v1(4.1,179.75)
SYNC_R: length 3.8
  TOP w0.254: PU22.35 6.22,176.74 5.34,177.62 5.34,178.16 PR442.2
TCXO_NCG: length 2.5
  TOP w0.14: X8.1 R1648.1
TCXO_OE: length 17.1
  TOP w0.14: R1647.1 159.84,97.49 159.39,97.04 X8.6 159.39,94.88 156.19,91.68 v1(156.19,86.49) 156.19,83.67 155.98,83.47 X5.1
TP_CLK_25M_PCIE_XTALOUT: length 3.1
  TOP w0.14: U163.3 136.62,121.83 v1(136.53,121.92)
  BOTTOM w0.14: v1(136.53,121.92) 136.53,122.05 135.76,122.81 TP10.1
TP_CPLD_PU_PD: length 2.4
  BOTTOM w0.14: R1696.2 R1721.2 121.97,120.3 TP20.1
TP_JTAG_BITS_TCK: length 2.6
  TOP w0.14: U127.78 v1(66.29,76.2)
  BOTTOM w0.14: v1(66.29,76.2) 66.67,76.58 TP2.1
TP_JTAG_BITS_TDI: length 4.4
  TOP w0.14: v1(67.94,76.17) 67.23,76.17 66.6,75.55 U127.79
  BOTTOM w0.14: v1(67.94,76.17) TP3.1
TP_JTAG_BITS_TDO: length 3.7
  TOP w0.14: U127.76 66.42,77.5 v1(67.29,78.38)
  BOTTOM w0.14: TP4.1 66.97,78.7 v1(67.29,78.38)
TP_JTAG_BITS_TMS: length 6
  TOP w0.14: v1(69.14,76.02) 68.68,75.56 67.31,75.56 66.65,74.9 U127.80
  BOTTOM w0.14: TP1.1 69.22,76.1 v1(69.14,76.02)
TP_JTAG_CPU_TCK: length 8.2
  BOTTOM w0.14: J1.A5 68.04,161.94 66.67,163.31 TP129.1
TP_JTAG_CPU_TDI: length 6.1
  BOTTOM w0.14: TP130.1 67.94,163.32 69.04,162.22 J1.A6
TP_JTAG_CPU_TDO: length 7.9
  BOTTOM w0.14: TP131.1 69.22,163.38 70.04,162.55 J1.A7
TP_JTAG_CPU_TMS: length 5.8
  BOTTOM w0.14: J1.A8 71.04,162.82 70.48,163.38 TP132.1
TP_JTAG_NIC1_TDO: length 1.9
  TOP w0.14: v1(101.98,88.65) 101.95,88.61 U85.4
  BOTTOM w0.14: v1(101.98,88.65) 101.98,89.11 TP9.1
TP_JTAG_SMU_TCK: length 3.8
  TOP w0.14: U139.G1 v4(18.43,98.3)
  BOTTOM w0.14: v4(18.43,98.3) 18.99,97.74 18.99,96.03 TP6.1
TP_JTAG_SMU_TDI: length 3.2
  TOP w0.14: U139.L3 v4(14.43,96.3)
  BOTTOM w0.14: v4(14.43,96.3) 14.06,96.3 13.53,96.83 12.32,96.83 TP7.1
TP_JTAG_SMU_TDO: length 3
  TOP w0.14: U139.L5 v4(14.43,94.3)
  BOTTOM w0.14: v4(14.43,94.3) 13.99,93.87 12.87,93.87 TP8.1
TP_JTAG_SMU_TMS: length 2.3
  TOP w0.14: U139.F1 v4(20.43,98.3)
  BOTTOM w0.14: TP5.1 19.64,97.51 v4(20.43,98.3)
TP_MAC_DDRA_AUX0: length 32
  TOP w0.14: U1.AK23 v4(209.86,131.5)
  T14 w0.102: 202.46,136.27 202.46,138.48 200.2,140.75
  T14 w0.117: 200.2,140.75 199.15,141.8 195.27,141.8 191.13,145.94 190.74,145.94 v1(189.36,147.32) ; v4(209.86,131.5) 209.46,131.9 204.7,131.9 204.39,132.21 204.39,135.53 204.03,135.9 202.84,135.9 202.46,136.27
  BOTTOM w0.14: TP13.1 v1(189.36,147.32)
TP_MAC_DDRA_AUX1: length 10.2
  TOP w0.14: U1.AH24 v4(208.86,129.5)
  T14 w0.117: v4(207.86,121.5) 208.37,122 208.37,129 v4(208.86,129.5)
  BOTTOM w0.14: v4(207.86,121.5) 207.86,121.17 TP14.1
TP_MAC_DDRA_PLL_CLK_MON: length 29.3
  TOP w0.14: U1.AG29 v4(203.86,128.5)
  T14 w0.117: v4(203.86,128.5) 203.86,128.73 203.37,129.23 203.37,129.76 203.07,130.05 202.56,130.05 202.31,130.3 202.31,131.7 202.06,131.95 201.42,131.95 201.29,132.08 201.29,133.63 200.96,133.96 200.64,133.96 200.39,134.21 200.39,138.92 198.66,140.64 194.14,140.64 193.97,140.81 192.73,140.81 189.87,143.67 189.87,145.29 v1(189.35,145.8)
  BOTTOM w0.14: TP12.1 188.85,145.8 v1(189.35,145.8)
TP_MAC_DDRA_VREF_MON: length 27.1
  TOP w0.14: U1.AH28 v4(204.86,129.5)
  T14 w0.117: v1(190.88,145.22) 190.88,143.9 193.09,141.69 194.34,141.69 194.83,141.2 198.9,141.2 201.38,138.72 201.38,134.22 201.62,133.99 202.12,133.99 202.37,133.73 202.37,133.03 203.33,132.08 203.33,130.46 203.69,130.09 204.26,130.09 v4(204.86,129.5)
  BOTTOM w0.14: TP11.1 191.23,145.56 v1(190.88,145.22)
TP_MAC_DDRB_AUX0: length 50.2
  TOP w0.14: U1.AJ17 v4(216.86,130.5)
  T18 w0.117: v1(191.17,146.56) 192.06,145.67 192.06,139.78 192.85,138.99 192.85,137.69 193.56,136.98 193.56,127.64 196.19,125.01 210.1,125.01 210.36,125.27 210.36,127.71 210.75,128.09 211.03,128.09 211.26,128.33 211.26,128.61 211.69,129.04 212.55,129.04 212.6,129.09 213.42,129.09 214.33,130 216.36,130 v4(216.86,130.5)
  BOTTOM w0.14: TP15.1 191.4,146.56 v1(191.17,146.56)
TP_MAC_DDRB_AUX1: length 52
  TOP w0.14: U1.AH18 v4(215.86,129.5)
  T18 w0.117: v4(215.86,129.5) 214.86,129.5 213.26,127.9 212.69,127.9 212.46,127.66 212.46,127.23 212.13,126.9 211.53,126.9 211.3,126.67 211.3,124.18 211.07,123.95 196.72,123.95 193.29,127.38 193.29,136.87 192.58,137.58 192.58,138.88 191.79,139.67 191.79,142.51 190.17,144.12 190.17,148.26 v1(190.37,148.46)
  BOTTOM w0.14: TP16.1 v1(190.37,148.46)
TP_MAC_DDRC_AUX0: length 24.5
  TOP w0.14: U1.AK8 v4(225.86,131.5)
  T05 w0.117: v1(244.55,141.73) 243.69,141.73 233.94,131.98 226.34,131.98 v4(225.86,131.5)
  BOTTOM w0.14: v1(244.55,141.73) 244.55,141.73 TP17.1
TP_MAC_DDRC_AUX1: length 5.9
  TOP w0.14: U1.AD9 v4(224.86,125.5)
  BOTTOM w0.14: v4(224.86,125.5) 224.36,124.99 TP18.1
TP_MIIM_IIO_LAN_MDC: length 7.7
  BOTTOM w0.14: TP133.1 71.81,163.38 72.04,163.14 J1.A9
TP_MIIM_IIO_LAN_MDIO: length 5.6
  BOTTOM w0.14: J1.A10 73.04,161.64 73.08,161.67 TP134.1
TP_PCIE_CPU_IIO_RX_DN2: length 9.6
  BOTTOM w0.104: J1.A40 104.65,160.16 104.51,160.12 104.42,160.16 104.15,160.43 104.15,163.56 103.98,163.73 103.98,163.97 103.88,164.07 103.75,164.07 103.65,164.07 103.54,164.17 103.54,164.41 103.44,164.51 103.31,164.51 103.2,164.51 103,164.72 103,167.09 TP64.1
TP_PCIE_CPU_IIO_RX_DN3: length 9.6
  BOTTOM w0.104: J1.A36 100.65,160.16 100.51,160.12 100.46,160.12 100.22,160.36 100.22,162.42 98.95,163.69 98.95,164.22 99.1,164.38 99.1,164.53 98.95,164.69 98.95,164.85 99.1,165 99.1,165.16 98.95,165.31 98.95,167.1 TP60.1
TP_PCIE_CPU_IIO_RX_DP2: length 9.7
  BOTTOM w0.104: J1.A39 104.44,159.74 104.39,159.88 104.26,159.94 104.1,160.11 103.89,160.32 103.89,163.45 102.73,164.61 102.73,167.05 TP63.1
TP_PCIE_CPU_IIO_RX_DP3: length 9.7
  BOTTOM w0.104: TP59.1 98.68,167.03 98.68,163.58 99.95,162.31 99.95,160.25 100.42,159.78 100.42,159.71 J1.A35
TP_PCIE_IIO_TO_MB_TX1_DN: length 13.4
  BOTTOM w0.104: J1.B42 106.65,155.24 106.7,155.38 106.87,155.46 107.14,155.74 107.14,159.48 106.18,160.44 106.18,163.56 104.91,164.84 104.91,165.87 TP104.1
TP_PCIE_IIO_TO_MB_TX1_DP: length 13.3
  BOTTOM w0.104: TP103.1 104.64,165.87 104.64,164.73 105.92,163.45 105.92,162.67 105.83,162.58 105.79,162.58 105.7,162.49 105.7,162.36 105.79,162.27 105.83,162.27 105.92,162.18 105.92,160.33 106.87,159.37 106.87,155.85 106.71,155.68 106.58,155.62 106.44,155.66 J1.B41
TP_PCIE_IIO_TO_MB_TX2_DN: length 13.3
  BOTTOM w0.104: J1.B38 102.65,155.24 102.7,155.38 102.87,155.46 102.9,155.49 103.14,155.73 103.14,159.42 102.17,160.39 102.17,163.39 100.97,164.59 100.97,165.82 TP62.1
TP_PCIE_IIO_TO_MB_TX2_DP: length 13.2
  BOTTOM w0.104: TP61.1 100.7,165.78 100.7,164.48 101.9,163.28 101.9,162.86 101.75,162.71 101.75,162.55 101.9,162.4 101.9,162.24 101.75,162.08 101.75,161.92 101.9,161.77 101.9,160.28 102.87,159.31 102.87,155.84 102.71,155.68 102.58,155.62 102.44,155.66 J1.B37
TP_PCIE_IIO_TO_MB_TX3_DN: length 15.3
  BOTTOM w0.104: TP58.1 96.9,165.76 96.9,163.06 95.96,162.13 95.96,160.39 95.11,159.54 94.98,159.28 94.98,158.33 95.91,157.39 96.31,157.39 96.89,156.81 96.89,155.97 97.67,155.19 98.32,155.19 98.51,155.28 98.65,155.24 J1.B34
TP_PCIE_IIO_TO_MB_TX3_DP: length 15.3
  BOTTOM w0.104: TP57.1 97.17,165.83 97.17,164.78 97.26,164.69 97.33,164.69 97.42,164.6 97.42,164.47 97.33,164.37 97.26,164.37 97.17,164.28 97.17,164.15 97.26,164.06 97.33,164.06 97.42,163.97 97.42,163.84 97.33,163.75 97.26,163.75 97.17,163.66 97.17,162.95 96.23,162.02 96.23,160.28 95.33,159.38 95.25,159.22 95.25,158.44 96.02,157.66 96.42,157.66 97.16,156.92 97.16,156.08 97.78,155.46 98.26,155.46 98.39,155.52 98.44,155.66 J1.B33
TP_TCXO_REF_OUT: length 2.3
  TOP w0.14: X8.3 v1(159.39,91.18)
  BOTTOM w0.14: v1(159.39,91.18) 159.25,91.03 TP19.1
UART_BMC_CONSOLE_RX: length 31.6
  TOP w0.14: U154.G1 v4(66.93,121.98)
  T07 w0.102: 73.88,124.84 71.34,122.3 69.72,122.3 69.34,122.68 67.63,122.68 v4(66.93,121.98)
  T07 w0.117: 73.88,124.84 77.47,124.84 78.36,125.73 79.9,125.73 81.56,127.39 89.8,127.39 v1(91.57,129.16)
  BOTTOM w0.14: v1(91.57,129.16) 91.44,129.29 91.44,131.11 R1406.1
UART_BMC_CONSOLE_RX_OUT: length 2.6
  TOP w0.14: v1(94.46,132.25) U98.1
  BOTTOM w0.14: R1406.2 94.01,131.8 v1(94.46,132.25)
UART_BMC_CONSOLE_TX: length 21
  TOP w0.14: U97.1 90.54,129.27 v1(89.92,128.65) 89.21,127.95 87.32,127.95 86.49,128.78 85.34,128.78 84.33,127.76 81.66,127.76 79.76,129.67 74.8,129.67 73.05,127.91 R12349.2
UART_BMC_TO_CPU: length 85.5
  T16 w0.117: v1(61.98,135.64) 61.98,146.43 67.94,152.4 116.91,152.4 118.11,153.6 118.11,154.91 119.65,156.45 J1.B55
  BOTTOM w0.14: R12345.1 54.98,129.8 54.28,130.51 54.28,131.75 58.17,135.64 v1(61.98,135.64)
UART_BMC_TXD1: length 8.6
  TOP w0.14: U154.W1 v4(57.33,121.98)
  BOTTOM w0.14: v4(57.33,121.98) 57.33,122.87 57.19,123 57.19,125.85 v2(55.15,127.89) R12345.2
UART_BMC_TXD5: length 15
  TOP w0.14: v1(71.75,126.24) 71.51,126.49 R12380.2 R12349.1 ; U154.H5 v4(66.53,118.53)
  T07 w0.117: v4(66.53,118.53) 66.13,118.93 66.13,122.51 67.94,124.33 67.94,125.48 69.22,126.75 71.25,126.75 v1(71.75,126.24)
UART_CPU_BMC_MUX_SEL: length 18.5
  TOP w0.14: Q60.2 98.27,133.69 R12896.2 98.27,128.93 v1(98.93,128.27) 100.04,127.16 101.98,127.16 102.7,127.89 107.07,127.89 108.25,126.71 110.26,126.71 U70.H1
UART_CPU_CONSOLE_RX: length 50.2
  T16 w0.117: J1.A56 121.04,157.15 121.25,156.95 121.25,155.76 120.26,154.77 120.26,152.39 112.93,145.06 96.75,145.06 93.26,141.58 93.26,139.19 93.92,138.53 93.92,136.82 94.14,136.6 94.14,135.42 93.65,134.92 v1(92.44,134.92)
  BOTTOM w0.14: R1407.1 92.33,134.81 v1(92.44,134.92)
UART_CPU_CONSOLE_RX_OUT: length 2.1
  TOP w0.14: v1(94.36,133.55) U98.3
  BOTTOM w0.14: v1(94.36,133.55) 94.16,133.76 R1407.2
UART_CPU_CONSOLE_TX: length 52
  TOP w0.14: U97.3 v1(92.08,130.57)
  T16 w0.117: J1.A57 122.83,158.17 122.83,156.02 121.92,155.11 121.92,153.42 113.15,144.64 100.87,144.64 99.25,143.02 99.25,140.15 96.34,137.24 96.34,132.02 94.49,130.18 92.47,130.18 v1(92.08,130.57)
UART_CPU_TO_BMC: length 116.5
  TOP w0.14: U154.U5 v4(58.53,118.53) ; v1(118.75,168.84) 118.75,170.87 118.9,171.03 R12709.1
  T14 w0.117: v1(61.62,166.24) 58.36,162.98 58.36,159.95 59.56,158.75 59.56,152.69 58.21,151.34 58.21,136.48 55.75,134.02 55.75,132.08 55.44,131.77 55.44,130.37 54.73,129.66 54.73,124.14 56.43,122.44 56.43,122.01 56.96,121.48 58.11,121.48 58.53,121.06 v4(58.53,118.53)
  T16 w0.117: v1(118.75,168.84) 116.88,166.98 79.42,166.98 77.9,168.5 63.88,168.5 v1(61.62,166.24)
UART_MAC_TX0: length 29
  TOP w0.14: v1(178.54,128.59) 178.54,128.59 178.17,128.96 R1539.2 ; U1.AD32 v4(200.86,125.5)
  T03 w0.117: v4(200.86,125.5) 200.46,125.09 199.76,125.09 198.93,124.26 189.44,124.26 187.82,122.63 187.57,122.39 186.24,122.39 185.52,123.11 182.59,123.11 180.21,125.48 180.21,126.92 v1(178.54,128.59)
UART_MAC_TX1: length 29.1
  TOP w0.14: R1540.2 178.54,127.69 v1(179.01,127.22) ; U1.AB33 v4(199.86,123.5)
  T03 w0.117: v1(179.01,127.22) 179.79,126.44 179.79,123.4 181.29,121.91 185.45,121.91 185.45,121.91 185.9,121.91 185.9,121.91 187.69,121.91 189.47,123.69 190.92,123.69 192.02,122.58 192.98,122.58 194.21,123.81 199.54,123.81 v4(199.86,123.5)
UART_RJ45_INVALID_N: length 12.3
  TOP w0.14: R12912.2 v1(73.19,59.83) 72.44,59.08 72.44,57.97 74.03,56.37 74.03,54.62 74.79,53.87 75.8,53.87 77.36,52.3 U89.10
UART_RS232_RX: length 19.5
  TOP w0.14: R1264.2 C1680.1 62.73,40.27 D98.2 63.25,38.49 63.25,35.56 67.94,30.86 67.94,27.07 OJ1.AR6
UART_RS232_RX_IN: length 15.9
  TOP w0.14: R1264.1 v1(61.72,42.54) ; U89.8 v1(69.35,51.65)
  T14 w0.117: v1(69.35,51.65) 68.83,51.13 68.83,48.35 63.66,43.18 62.36,43.18 v1(61.72,42.54)
UART_RS232_RX_RJ45: length 15.2
  TOP w0.14: v1(78.64,61.45) 79.44,61.45 81.41,59.48 81.41,53.09 79.97,51.65 U89.9
  BOTTOM w0.14: U151.3 78.08,62.01 v1(78.64,61.45)
UART_RS232_RX_USB: length 38.1
  TOP w0.14: J8.12 48.83,76 48.94,76.11 v1(48.94,76.3)
  T16 w0.117: v1(48.94,76.3) 50.45,77.81 53.11,77.81 57.49,73.43 61.91,73.43 67.77,67.56 74.68,67.56 75.95,66.29 75.95,64.9 v1(76.71,64.14)
  BOTTOM w0.14: v1(76.71,64.14) 77.11,63.73 U151.1
UART_RS232_TX: length 25.5
  TOP w0.14: R1263.2 C1681.1 59.69,39.89 D97.2 59.94,39.63 61.21,38.35 61.21,36.7 67.44,30.48 67.44,23.37 68.89,21.91 OJ1.AR3
UART_RS232_TX_OUT: length 30.2
  TOP w0.14: v1(80.01,53.72) 79.48,54.25 U89.13 ; R1263.1 v1(60.7,42.54)
  T14 w0.117: v1(80.01,53.72) 78.99,52.7 78.99,47.37 76.45,44.83 66.17,44.83 63.12,41.78 61.46,41.78 v1(60.7,42.54)
UART_RS232_TX_RJ45: length 16.1
  TOP w0.14: U89.11 79.51,52.95 v1(79.88,52.58) ; R12287.1 v1(80.08,65.53)
  T03 w0.117: v1(79.88,52.58) 79.12,53.34 79.12,60.08 80.08,61.04 v1(80.08,65.53)
UART_RS232_TX_RJ45_OUT: length 1.5
  TOP w0.14: U152.3 v1(78.53,66.37) R12287.2
UART_RS232_TX_USB: length 43.6
  TOP w0.14: J8.10 46.83,75.75 47.4,76.32 v1(47.6,76.32) ; v1(79.31,63.63) R12286.1
  T16 w0.117: v1(79.31,63.63) 79.31,64.03 77.72,65.62 77.72,66.67 76.58,67.82 75.02,67.82 74.85,67.99 67.95,67.99 62.09,73.85 57.67,73.85 55.63,75.89 55.63,77.26 54.65,78.23 49.51,78.23 v1(47.6,76.32)
UART_RS232_TX_USB_OUT: length 1.7
  TOP w0.14: R12286.2 77.76,64.12 v1(78.05,64.41) 77.76,64.7 U152.1
UART_RXD_IN: length 161.5
  TOP w0.14: v1(91.19,134.32) 91.58,133.92 U98.4
  T07 w0.117: v1(38.73,130.68) 47.78,130.68 50.27,133.17 53.03,133.17 54.24,134.37 57.16,134.37 58.21,135.43 60.79,135.43 61.84,134.37 64.78,134.37 65.41,135 85.98,135 86.23,134.75 90.76,134.75 v1(91.19,134.32)
  T18 w0.117: v1(75.95,62.01) 74.39,62.01 73.66,62.74 73.66,65.79 72.54,66.9 43.42,66.9 42.43,67.89 42.43,77.61 44.32,79.5 44.32,80.64 43.31,81.66 43.31,88.58 42.28,89.6 42.28,97.91 42.8,98.42 42.8,103.25 38.35,107.7 38.35,124.97 38.73,125.35 v1(38.73,130.68)
  BOTTOM w0.14: U151.4 v1(75.95,62.01)
UART_TOD_GNSS_RXD: length 346
  TOP w0.14: U1.AD31 v4(201.86,125.5)
  T07 w0.117: v1(12.57,70.23) 12.57,71.63 4.95,79.25 4.95,94.06 12.36,101.47 21.47,101.47 22.41,100.53 32.53,100.53 34.67,102.67 34.67,129.09 40.26,134.67 48.54,134.67 52.05,138.18 52.05,139.42 64.19,151.57 64.19,155.05 65.06,155.92 65.06,159.18 65.85,159.96 65.85,161.76 71.93,167.85 77.71,167.85 79.21,166.35 143.78,166.35 151.51,158.62 159.72,158.62 168.3,150.04 179.48,150.04 181.66,147.85 181.66,139.73 183.87,137.53 183.87,133.96 182.41,132.5 182.41,126.07 182.75,125.73 183.64,125.73 184.4,124.97 184.4,124.67 186.05,123.02 187.28,123.02 189.26,125 201.37,125 v4(201.86,125.5)
  T14 w0.117: v1(12.57,70.23) 12.57,68.18 16.57,64.19 16.57,39.85 v1(18.49,37.92)
  BOTTOM w0.14: R1607.1 v1(18.49,37.92)
UART_TOD_GNSS_TXD: length 230
  TOP w0.14: v1(15.97,39.28) 16.17,39.09 U124.21 ; v1(175.93,127.69) R1540.1
  T07 w0.117: v1(30.48,82.42) 30.86,82.8 33.02,82.8 33.44,83.23 33.44,83.74 34.28,84.57 37.71,84.57 40.46,87.32 43.59,87.32 47.46,91.19 60.05,91.19 61.69,92.82 82.37,92.82 82.79,93.25 86.17,93.25 89.61,96.69 93.93,96.69 95.54,98.3 102.26,98.3 106.2,102.24 106.2,103.34 108.42,105.55 113.81,105.55 116.39,108.13 144.06,108.13 144.79,108.87 162.82,108.87 167.11,113.16 167.74,113.16 v1(167.76,113.14)
  T16 w0.117: v1(30.48,82.42) 29.08,81.03 29.08,64.39 16.89,52.2 16.89,40.2 v1(15.97,39.28)
  BOTTOM w0.14: v1(175.93,127.69) 177.12,126.5 177.12,124.42 177.87,123.67 179.43,123.67 180.72,122.38 180.72,117.2 180.61,117.08 180.61,117.08 180.16,116.63 180.15,116.63 179.14,115.62 179.14,115.61 177.98,114.44 169.82,114.44 168.52,113.14 v1(167.76,113.14)
UART_TOD_RS422_RXD: length 336.8
  TOP w0.14: R1594.2 29.09,52.06 v1(29.34,51.82) ; U1.AC33 v4(199.86,124.5)
  T07 w0.117: v1(29.34,51.82) 28.29,52.86 22.41,52.86 15.49,59.77 15.49,69.34 8.03,76.8 8.03,80.17 8.76,80.9 8.76,88.07 6.65,90.19 6.65,95.16 12.45,100.97 21.38,100.97 22.24,100.1 32.7,100.1 35.09,102.5 35.09,128.91 40.43,134.25 48.71,134.25 52.47,138.01 52.47,139.25 66.01,152.79 66.01,155.23 66.89,156.12 66.89,158.9 67.26,159.27 67.26,159.27 67.72,159.73 68.25,160.26 68.25,163.15 72.53,167.43 77.53,167.43 79.03,165.93 143.61,165.93 151.34,158.2 159.54,158.2 168.12,149.62 179.3,149.62 181.24,147.68 181.24,139.56 183.45,137.36 183.45,134.13 181.99,132.68 181.99,125.09 182.63,124.46 184.02,124.46 185.63,122.85 185.63,122.85 185.88,122.6 187.46,122.6 189.35,124.5 v4(199.86,124.5)
UART_TOD_RS422_TXD: length 217.7
  TOP w0.14: v1(23.77,49.9) 24.35,49.32 U110.5 ; v1(175.93,128.96) R1539.1
  T07 w0.117: v1(34.54,80.1) 41.35,86.9 43.77,86.9 47.54,90.68 60.22,90.68 61.95,92.4 82.55,92.4 82.97,92.82 86.34,92.82 89.79,96.27 94.11,96.27 95.72,97.88 102.09,97.88 102.43,97.88 106.62,102.06 106.62,103.16 108.59,105.13 113.98,105.13 116.56,107.71 144.23,107.71 144.92,108.4 163.14,108.4 167.05,112.31 v1(167.91,112.31)
  T16 w0.117: v1(23.77,49.9) 23.77,52.59 23.27,53.09 23.27,56.29 24.05,57.06 24.05,58.59 29.59,64.14 29.59,70.82 34.54,75.78 v1(34.54,80.1)
  BOTTOM w0.14: v1(167.91,112.31) 168.32,112.31 170.01,114 177.04,114 178.16,114 178.87,114.72 179.59,115.43 179.59,115.44 180.34,116.18 180.34,116.18 181.23,117.07 181.23,127.38 179.2,129.41 176.39,129.41 v1(175.93,128.96)
UART_TXD_OUT: length 170
  TOP w0.14: v1(68.33,68.58) 69.72,67.18 75.31,67.18 75.76,66.74 U152.4 ; U97.4 88.66,130.57 88.13,130.57 v1(87.76,130.94)
  T05 w0.117: v1(68.33,68.58) 68.2,68.45 56.62,68.45 54.46,70.61 30.38,70.61 28.64,72.35 28.64,75.12 31.24,77.72 31.24,87.38 29.34,89.28 29.34,97.54 34.73,102.93 34.73,123.36 38.06,126.69 v1(38.06,129.4)
  T07 w0.117: v1(87.76,130.94) 87.25,131.44 84.42,131.44 79.66,126.69 77.66,126.69 76.96,127.38 68.71,127.38 67.69,128.4 67.69,130.05 66.93,130.81 64.77,130.81 64.01,131.57 58.29,131.57 57.45,132.42 50.04,132.42 47.58,129.96 38.62,129.96 v1(38.06,129.4)
UART_XCVR_C1+: length 3.4
  TOP w0.14: U89.2 70.36,55.55 v1(70.2,55.39)
  BOTTOM w0.14: v1(70.2,55.39) 70.73,55.92 C1679.1
UART_XCVR_C1-: length 3.6
  TOP w0.14: v1(73.35,54.54) 73.06,54.25 U89.4
  BOTTOM w0.14: v1(73.35,54.54) 72.78,55.11 C1679.2
UART_XCVR_C2+: length 3.3
  TOP w0.14: U89.5 70.37,53.6 69.98,53.21 v1(69.98,52.7)
  BOTTOM w0.14: v1(69.98,52.7) 69.98,52.7 C1682.1
UART_XCVR_C2-: length 4.2
  TOP w0.14: v1(73.65,53.21) 73.4,52.95 U89.6
  BOTTOM w0.14: v1(73.65,53.21) 73.14,52.7 C1682.2
UART_XCVR_V+: length 3.5
  TOP w0.14: v1(69.86,53.98) 69.86,54.36 70.4,54.9 U89.3
  BOTTOM w0.14: C1683.1 69.86,53.97 v1(69.86,53.98)
UART_XCVR_V-: length 4.7
  TOP w0.14: v1(74.68,52.3) U89.7
  BOTTOM w0.14: v1(74.68,52.3) 74.71,52.33 C1684.1
USB2_BMC_HDN: length 5.6
  TOP w0.122: U154.AB20 54.63,105.83 50.85,105.83 50.4,105.39 50.4,105.09 R12348.1
USB2_BMC_HDP: length 5.2
  TOP w0.122: R12347.1 50.66,105.09 50.66,105.28 50.95,105.58 54.67,105.58 U154.AB21
USB2_PCH_P0_DN: length 145.9
  TOP w0.122: v4(72.83,50.31) 72.61,50.08 72.13,50.08 71.86,49.81 71.86,49.32 71.74,49.2 U96.2
  T16 w0.127: v4(72.83,50.31) 73.05,50.09 79.1,50.09 82.28,53.27 82.28,59.35 89.62,66.69 98.22,66.69 103.4,71.86 103.4,79.75 110.79,87.15 110.79,104.27 116.23,109.71 116.23,113.18 126.89,123.85 126.89,136.11 138.05,147.27 138.05,155.07 138.77,155.79 139.25,155.79 139.33,155.71 139.49,155.63 139.66,155.68 J1.B75
USB2_PCH_P0_DP: length 145.8
  TOP w0.122: v4(72.83,49.6) 72.61,49.83 72.24,49.83 72.12,49.7 72.12,49.32 72.24,49.2 U96.1
  T16 w0.127: v4(72.83,49.6) 73.05,49.82 77.32,49.82 77.48,49.66 77.7,49.66 77.86,49.82 78.08,49.82 78.24,49.66 78.46,49.66 78.62,49.82 79.21,49.82 82.55,53.16 82.55,59.24 89.74,66.42 98.34,66.42 103.67,71.75 103.67,79.64 111.06,87.03 111.06,104.16 116.5,109.59 116.5,113.07 127.16,123.73 127.16,136 138.32,147.16 138.32,152.88 138.43,152.99 138.46,152.99 138.57,153.1 138.57,153.26 138.46,153.37 138.43,153.37 138.32,153.48 138.32,154.95 138.88,155.52 139.14,155.52 139.17,155.48 139.37,155.38 139.43,155.21 J1.B74
USB2_PCH_P1_DN: length 194.6
  TOP w0.122: v4(7.77,49.4) 8,49.17 8,47.4 R12724.1
  T03 w0.127: J1.A33 97.66,159.71 97.72,159.88 97.92,159.98 98.19,160.25 98.19,161.3 96.91,162.58 61.11,162.58 60.34,161.82 58.82,161.82 51.56,154.56 51.56,136.91 50.16,135.51 40.53,135.51 35.31,130.28 35.31,90.81 36.58,89.53 36.58,75.95 31.75,71.12 19.81,71.12 15.86,67.17 15.86,55.14 11.55,50.84 8.54,50.84 7.99,50.29 7.99,49.62 v4(7.77,49.4)
USB2_PCH_P1_DP: length 193.5
  TOP w0.122: v4(8.48,49.4) 8.26,49.17 8.26,47.4 R12725.1
  T03 w0.127: v4(8.48,49.4) 8.26,49.62 8.26,50.17 8.65,50.56 10.08,50.56 10.27,50.38 10.46,50.38 10.65,50.56 11.67,50.56 16.13,55.03 16.13,67.05 19.92,70.85 31.86,70.85 36.85,75.83 36.85,89.65 35.58,90.92 35.58,130.17 40.65,135.24 50.28,135.24 51.83,136.79 51.83,154.45 58.93,161.54 60.45,161.54 61.22,162.31 96.8,162.31 97.92,161.19 97.92,160.37 97.76,160.21 97.6,160.13 97.43,160.18 J1.A32
USB2_PCH_P3_DN: length 146.1
  TOP w0.122: v1(51.23,102.23) 51.44,102.43 51.44,102.88 51.31,103 50.8,103 50.4,103.39 50.4,103.77 50.24,103.93 R12348.2
  T05 w0.127: v1(51.23,102.23) 51.23,102.21 51.45,101.99 51.45,101.46 54.13,98.78 54.13,95.8 55.6,94.33 60.16,94.33 61.06,93.43 79.47,93.43 85.76,99.72 88.2,99.72 89.96,101.48 95.8,101.48 107.52,113.2 117.64,113.2 128.41,123.97 128.41,127.02 149.05,147.65 149.05,157.62 146.46,160.21 145.76,160.21 145.65,160.15 145.6,160.13 145.43,160.18 J1.A80
USB2_PCH_P3_DP: length 146.6
  TOP w0.122: v1(51.94,102.23) 51.69,102.48 51.69,102.98 51.42,103.25 50.91,103.25 50.66,103.5 50.66,103.81 50.78,103.93 R12347.2
  T05 w0.127: v1(51.94,102.23) 51.94,102.21 51.72,101.99 51.72,101.58 53.11,100.19 53.42,100.19 53.53,100.07 53.53,99.76 53.65,99.65 53.96,99.65 54.07,99.53 54.07,99.22 54.4,98.9 54.4,95.92 55.72,94.6 60.27,94.6 61.17,93.7 79.36,93.7 85.65,99.99 88.09,99.99 89.85,101.75 95.69,101.75 107.41,113.47 117.53,113.47 118.02,113.96 118.02,114.26 118.14,114.38 118.44,114.38 118.56,114.5 118.56,114.8 118.68,114.92 118.98,114.92 119.1,115.04 119.1,115.34 119.22,115.46 119.52,115.46 128.14,124.08 128.14,127.13 146.51,145.5 146.51,145.65 146.48,145.69 146.48,145.84 146.59,145.96 146.75,145.96 146.78,145.92 146.94,145.92 147.05,146.04 147.05,146.19 147.02,146.22 147.02,146.38 147.13,146.49 147.29,146.49 147.32,146.46 147.48,146.46 147.59,146.57 147.59,146.73 147.56,146.76 147.56,146.92 147.67,147.03 147.83,147.03 147.86,147 148.01,147 148.78,147.77 148.78,157.51 148.6,157.69 148.39,157.69 148.23,157.85 148.23,158.06 148.06,158.23 147.85,158.23 147.69,158.39 147.69,158.6 146.35,159.94 145.82,159.94 145.72,159.88 145.66,159.71 J1.A81
USB2VRES: length 4
  TOP w0.14: U154.AA20 v4(55.33,105.72)
  BOTTOM w0.14: v4(55.33,105.72) 54.62,105.01 54.62,103.99 v2(54.52,103.9) 53.8,103.18 R12346.1
USB11_BMC_HDN: length 114.2
  TOP w0.102: U154.K3 v4(64.93,120.13)
  TOP w0.122: U96.4 70.74,49.2 70.86,49.32 70.86,50.07 v4(70.63,50.3)
  T18 w0.127: v4(64.93,120.13) 64.66,120.39 64.66,120.67 65.04,121.04 65.2,121.04 65.2,121.04 65.36,121.04 65.47,121.15 65.47,121.31 65.46,121.31 65.46,121.47 65.58,121.58 65.73,121.58 65.74,121.58 65.9,121.58 66.01,121.69 66.01,121.85 66,121.85 66,122.01 68.58,124.59 68.58,126.24 69.22,126.87 73.74,126.87 77.54,123.07 77.54,122.8 77.67,122.66 77.94,122.66 78.08,122.53 78.08,122.26 78.21,122.13 78.48,122.13 78.62,121.99 78.62,121.72 78.75,121.59 79.02,121.59 79.34,121.27 83.17,121.27 84.95,119.49 84.95,114.67 84.83,114.56 84.82,114.56 84.71,114.45 84.71,114.29 84.82,114.18 84.83,114.18 84.95,114.07 84.95,113.91 84.83,113.8 84.82,113.8 84.71,113.69 84.71,113.53 84.82,113.42 84.83,113.42 84.95,113.3 84.95,113.15 84.83,113.04 84.82,113.04 84.71,112.92 84.71,112.77 84.82,112.65 84.83,112.65 84.95,112.54 84.95,112.16 85.58,111.52 85.58,99.93 83.57,97.92 83.57,94.52 80.39,91.35 80.39,70.99 81.28,70.1 81.28,52.71 78.86,50.29 76.93,50.29 76.78,50.44 76.55,50.44 76.4,50.29 76.17,50.29 76.02,50.44 75.79,50.44 75.64,50.29 75.18,50.29 73.77,51.71 71.52,51.71 70.85,51.04 70.85,50.52 v4(70.63,50.3)
USB11_BMC_HDP: length 114.3
  TOP w0.102: U154.K4 v4(64.93,119.33)
  TOP w0.122: U96.3 71.24,49.2 71.12,49.32 71.12,50.07 v4(71.35,50.3)
  T18 w0.127: v4(64.93,119.33) 64.39,119.86 64.39,120.78 68.31,124.7 68.31,126.35 69.1,127.14 73.85,127.14 79.45,121.54 83.28,121.54 85.22,119.61 85.22,112.27 85.85,111.63 85.85,99.82 83.84,97.81 83.84,94.41 80.66,91.24 80.66,71.1 81.55,70.21 81.55,52.6 78.98,50.02 75.07,50.02 73.66,51.44 71.63,51.44 71.13,50.93 71.13,50.52 v4(71.35,50.3)
USB_CONSOLE_PRSNT: length 42.8
  TOP w0.14: Q54.2 v1(75.44,58.97) 75.14,58.97 R12295.2
  T16 w0.117: v1(48.15,67.91) 52.26,63.8 52.26,60.58 59.11,53.72 66.32,53.72 71.68,59.08 75.33,59.08 v1(75.44,58.97)
  BOTTOM w0.14: Q13.3 48.16,71.25 v2(48.16,68.94) 48.16,67.92 v1(48.15,67.91)
USB_CONSOLE_PRSNT_N: length 4.9
  TOP w0.14: J8.9 46.83,67.88 v1(46.78,67.83)
  BOTTOM w0.14: v1(46.78,67.83) 46.89,67.94 R12302.2 46.89,69.73 Q13.1
USB_MUX_OE_N: length 2.2
  TOP w0.14: v1(70.23,46.74) 70.74,47.25 U96.6
  BOTTOM w0.14: v1(70.23,46.74) 70.74,47.24 R1404.2
USB_PCH_P2_DN: length 100.3
  TOP w0.122: U162.4 86.44,78.65 86.32,78.53 86.32,78.16 86.52,77.95 v4(86.52,77.66)
  T18 w0.127: v4(86.52,77.66) 86.28,77.42 86.28,77.01 85.47,76.2 83.06,76.2 81.49,77.77 81.49,90.32 88.5,97.33 88.5,104.12 90.04,105.66 90.04,118.61 84.75,123.9 84.75,133.62 82.81,135.57 82.81,139.2 69.97,152.03 69.97,155.12 70.64,155.79 71.25,155.79 71.33,155.71 71.49,155.63 71.66,155.68 J1.B9
USB_PCH_P2_DP: length 100.2
  TOP w0.122: U162.3 85.94,78.65 86.06,78.53 86.06,78.17 85.81,77.92 v4(85.81,77.66)
  T18 w0.127: J1.B8 71.43,155.21 71.37,155.38 71.17,155.48 71.14,155.52 70.75,155.52 70.25,155.01 70.25,152.14 83.08,139.31 83.08,135.68 85.03,133.73 85.03,124.02 88.49,120.55 88.65,120.55 88.8,120.55 88.92,120.44 88.92,120.28 88.92,120.13 89.03,120.01 89.18,120.01 89.19,120.02 89.34,120.02 89.46,119.9 89.46,119.75 89.45,119.74 89.45,119.59 89.57,119.48 89.72,119.48 89.88,119.48 89.99,119.36 89.99,119.21 89.99,119.05 90.31,118.73 90.31,105.55 88.77,104.01 88.77,97.22 88.32,96.77 88.32,96.5 88.19,96.36 87.92,96.36 87.78,96.23 87.78,95.96 87.65,95.82 87.38,95.82 87.24,95.69 87.24,95.42 87.11,95.29 86.84,95.29 81.76,90.21 81.76,77.88 81.88,77.77 82.17,77.77 82.29,77.64 82.29,77.35 82.42,77.23 82.71,77.23 82.83,77.1 82.83,76.81 83.17,76.47 85.36,76.47 86.01,77.13 86.01,77.45 v4(85.81,77.66)
USB_PORT_DN: length 3.5
  TOP w0.122: R1262.1 70.45,44.65 L140.2 70.45,45.53 70.73,45.81 70.73,46.07 71.36,46.7 71.36,46.95 71.24,47.07 U96.7
USB_PORT_DP: length 3.5
  TOP w0.122: U96.8 71.74,47.07 71.62,46.95 71.62,46.6 70.99,45.97 70.99,45.8 71.25,45.53 L140.1 71.25,44.67 R1265.1
USB_PWR_EN: length 106.1
  TOP w0.14: v1(58.95,52.6) 58.84,52.7 R1270.2 ; U70.N3 v4(111.6,122.45)
  T03 w0.117: v1(69.36,65.24) 70.24,66.11 70.24,69.44 72.83,72.03 78.22,72.03 79.05,72.87 79.05,73.73 80.14,74.82 80.14,91.58 87.25,98.69 88.33,98.69 90.44,100.79 95.69,100.79 105.28,110.38 105.28,111.3 108.6,114.61 108.6,119.45 v4(111.6,122.45)
  T18 w0.117: v1(58.95,52.6) 59.19,52.84 65.02,52.84 69.96,57.78 69.96,64.64 v1(69.36,65.24)
  BOTTOM w0.14: U43.3 58.95,52.59 v1(58.95,52.6)
USB_PWR_ILIM: length 2.9
  BOTTOM w0.14: U43.5 58,46.27 v2(58.17,46.1) 58.54,45.73 R1266.2
USB_PWR_OC_N: length 114.3
  TOP w0.14: U70.M3 v4(111.6,123.25)
  T03 w0.117: v1(67.95,66.34) 67.2,67.09 67.2,76.41 69.49,78.7 69.49,85.37 70.18,86.05 73.23,86.05 74.25,87.07 76.86,87.07 77.76,87.97 77.76,90.47 86.4,99.11 88.16,99.11 90.26,101.22 95.52,101.22 104.86,110.56 104.86,111.47 108.17,114.79 108.17,121.39 109.63,122.85 111.2,122.85 v4(111.6,123.25)
  T18 w0.117: v1(67.95,66.34) 69.17,66.34 70.38,65.13 70.38,57.42 65.53,52.57 v1(65.53,52.07)
  BOTTOM w0.14: v1(65.53,52.07) 64.52,52.07 61.21,48.77 61.21,46.81 v2(60.68,46.28) 60.28,45.87 R1267.2 58.95,46.43 U43.4
VCORE_SENSE_GND: length 82.3
  TOP w0.254: PR147.1 273.64,133.78 v1(273.43,133.99)
  TOP w0.381: U1.AC18 v4(215.86,124.5)
  T05 w0.254: v1(273.43,133.99) 272.49,134.92 272.49,139.85 270.22,142.12 256.93,142.12 255.71,140.9 247.05,140.9 245.27,142.68 243.15,142.68 233.5,133.03 225.72,133.03 225.33,132.63 225.33,132.3 224.99,131.97 222.66,131.97 222.39,131.69 222.39,131.36 221.99,130.97 221.66,130.97 221.39,130.69 221.39,130.56 221.33,130.5 221.33,130.3 221.05,130.03 216.64,130.03 216.33,129.72 216.33,129.3 216.05,129.03 215.64,129.03 215.39,128.78 215.39,125.3 215.39,125.3 215.39,124.96 v4(215.86,124.5)
  BOTTOM w0.14: v1(273.43,133.99) v2(273.43,133.03)
  BOTTOM w0.381: v4(215.86,124.5) 215.36,125 PC392.2
VCORE_SENSE_PWR: length 82
  TOP w0.254: PR141.1 273.81,134.75 v1(273.56,135)
  TOP w0.381: U1.AC19 v4(214.86,124.5)
  T05 w0.254: v4(214.86,124.5) 214.38,124.98 214.38,128.68 215.72,130.03 216.05,130.03 216.33,130.3 216.33,130.63 216.66,130.97 220.99,130.97 221.33,131.3 221.33,131.63 221.66,131.97 221.99,131.97 222.33,132.3 222.33,132.63 222.66,132.97 224.99,132.97 225.39,133.36 225.39,133.69 225.69,133.99 233.1,133.99 242.75,143.64 245.67,143.64 247.45,141.86 255.31,141.86 256.12,142.67 270.46,142.67 273.05,140.08 273.05,135.51 v1(273.56,135)
  BOTTOM w0.381: PC392.1 214.44,124.91 v4(214.86,124.5)
VFLT_P1V8_JA_VDD: length 11.2
  TOP w0.305: v1(159.26,125.86) 158.88,125.86 158.58,126.16 U135.21
  TOP w0.356: v1(156.08,135.44) 156.08,135.38 156.58,134.89 U135.39 ; U135.32 161.09,132.36 v1(161.15,132.3) ; v1(155.45,134.93) 155.77,134.93 156.08,134.63 U135.40
  BOTTOM w0.381: v1(159.26,125.86) 158.9,126.21 C2149.2
  BOTTOM w0.508: v1(156.08,135.44) 156.46,135.06 C2148.2 ; v1(161.15,132.3) 160.83,132.62 C2147.2 ; C2150.2 154.91,134.4 v1(155.45,134.93)
  vias: v1(161.29,135.05) v1(162.13,135.02)
VFLT_P1V8_SMU_VDDC: length 3.4
  TOP w0.381: U139.H12 v4(17.43,86.3) ; U139.L10 v4(14.43,88.3)
  BOTTOM w0.381: C2087.1 14.85,88.72 v4(14.43,88.3) 14.85,87.88 C2086.2 ; C2088.1 17.85,86.72 v4(17.43,86.3)
  vias: v1(3.56,89.26) v1(4.34,89.29) v2(3.55,87.76) v2(4.95,87.76)
VFLT_P3V3_1PPS_BUFF: length 9.1
  TOP w0.381: U175.7 145.67,83.58 145.22,83.13 145.22,82.45 v1(144.83,82.05)
  BOTTOM w0.381: v1(144.83,82.05) 145.43,82.05 146.34,82.97 C2421.1 146.34,84.51 C2420.2 146.87,84.52 147.16,84.23 L208.2 147.83,83.37 R12944.1
VFLT_P3V3_1PPS_BUFF2: length 6.9
  TOP w0.305: U168.7 35.5,55.93 R12762.1
  TOP w0.381: R12762.1 C2392.2 C2125.1 L185.2 40.14,56.39 v1(40.35,56.59)
VFLT_P3V3_4K_BUFF: length 8
  TOP w0.381: v1(150.62,89.53) 150.36,89.8 U174.7
  BOTTOM w0.381: L207.2 150.04,90.89 C2415.2 148.63,90.88 C2416.1 148.63,89.01 R12931.1 149.89,88.8 v1(150.62,89.53)
VFLT_P3V3_5P49V_VDDA: length 1.2
  TOP w0.305: v1(136.27,120.58) 136.52,120.83 U163.5
  vias: v2(136.78,119.25) v2(138.05,119.25)
VFLT_P3V3_5P49V_VDDD: length 6.4
  TOP w0.305: U163.22 139.09,124.47
  TOP w0.381: 137.6,129.27 v1(137.6,128.13) 137.6,126.22 139.09,124.74 139.09,124.47
VFLT_P3V3_BMC_ADCAV33: length 18.7
  TOP w0.381: v1(66.13,129.03) C2283.1 ; U154.P3 v4(60.93,120.13)
  T07 w0.381: v1(59.19,129.45) 59.48,129.16 66,129.16 v1(66.13,129.03)
  BOTTOM w0.381: v1(59.19,129.45) 59.87,128.76 L197.2 C2280.1 59.87,127.2 59.88,127.19 C2281.2 C2282.1 59.88,124.83 60.91,123.81 60.91,122.35 60.73,122.17 60.73,120.32 v4(60.93,120.13)
VFLT_P3V3_BMC_DACV33: length 12.4
  TOP w0.381: v4(60.33,122.55) 60.59,122.55 61.33,121.81 U154.P1 ; U154.T3 v4(59.33,120.13)
  BOTTOM w0.381: v4(59.33,120.13) 60.02,120.82 60.02,121.55 v2(59.83,121.73) 59.83,121.73 59.83,122.05 v4(60.33,122.55) 60.33,123.5 59.5,124.33 59.27,124.33 C2278.1 C2277.2 58.56,127.19 58.58,127.2 C2276.1 L196.2
VFLT_P3V3_BMC_HPLLAV33: length 6.8
  TOP w0.381: U154.V17 v4(57.73,108.12)
  BOTTOM w0.381: v1(46.44,103.12) C2301.1 45.35,102.23 C2300.2 45.25,102.27 44.85,101.88 C2299.1 L199.2 v2(42.52,100.58)
VFLT_P3V3_BMC_MPLLAV33: length 8.1
  TOP w0.381: U154.AB19 52.84,106.92 52.21,107.55 C2291.1 C2290.2 48.63,107.55 C2297.1 47.22,107.57 L198.2
VFLT_P3V3_BMC_MPLLDV12: length 16.1
  TOP w0.381: U154.Y18 v4(56.13,107.32)
  T18 w0.381: v1(42.14,106.24) 44.17,108.28 50.4,108.28
  BOTTOM w0.381: C2310.1 43.34,107.1 v2(43.69,107.44) ; C2310.1 C2309.2 40.86,106.83 C2308.1 L200.2 ; C2310.1 v1(42.14,106.24)
VFLT_P3V3_BMC_OSC: length 4.1
  TOP w0.381: L194.1 C2266.2 C2267.1 55.83,94.95 v1(56.19,95.3) X13.4
VFLT_P3V3_BMC_USB2AV33: length 0.6
  TOP w0.381: U154.W18 v4(56.93,107.32)
  vias: v2(51.43,107.67) v2(52.7,107.67)
VFLT_P3V3_BMC_VPLLAV12: length 15.4
  TOP w0.381: v4(56.13,105.72) U154.Y20 v4(56.93,106.52) U154.W19
  T18 w0.381: v1(43.29,105.27) 43.5,105.48 50.65,105.48
  BOTTOM w0.381: v2(44.28,105.75) 43.8,105.27 v1(43.29,105.27) C2324.1 C2323.2 40.63,105.27 40.62,105.28 C2322.1 L201.2
VFLT_P3V3_CLK_25M:
  vias: v1(163.07,84.53)
VFLT_P3V3_CLK_156.25MHZ: length 3.7
  TOP w0.356: U133.5 157.84,116.07 ; 157.84,116.07 156.94,115.17 ; 157.84,116.07 157.38,116.07 156.38,115.06 v1(156.08,115.06)
VFLT_P3V3_CPLD_OSC: length 6.3
  TOP w0.381: X1.4 103.95,133.72 R994.2 104.29,136.1 C1381.1 103.69,137.16 103.47,136.94 C1380.2 L135.1
VFLT_P3V3_CPLD_VDDA: length 4.5
  TOP w0.381: U70.K4 v4(112.4,124.85) ; U70.K9 v4(117.2,124.85) ; U70.D4 v4(113.2,130.45) ; U70.D10 v4(118,130.45)
  BOTTOM w0.381: C1406.2 118,129.78 v4(118,130.45) ; v4(117.2,124.85) 117.32,124.74 C1407.1 ; C1409.1 v1(112.02,133.68)
  vias: v1(112.14,118.55) v1(112.17,119.43) v2(108.08,120.31) v2(109.35,120.31) v2(110.62,120.31)
VFLT_P3V3_DDR_CLK_100MHZ: length 6.2
  TOP w0.305: U129.5 181.3,154.49
  TOP w0.508: 181.3,154.49 v1(180.3,155.49) C2044.2 C2043.1 179.58,157.99 L172.2
VFLT_P3V3_DDR_OSC_100MHZ: length 6.4
  TOP w0.508: X7.6 185.63,153.84 v1(185.5,153.84)
  BOTTOM w0.508: v1(185.5,153.84) 186.27,154.62 R1644.2 C2050.2 186.92,156.86 C2049.1 186.94,156.89 L174.2
VFLT_P3V3_GNSS_VBCKP: length 8.9
  TOP w0.381: v1(15.68,43.18) 15.11,42.61 15.11,40.83 v1(15.68,40.26) 15.75,40.19 U124.22
  BOTTOM w0.381: v1(15.68,40.26) 16.71,40.26 C1986.2
  BOTTOM w0.508: L89.2 R12902.1 15.43,42.93 v1(15.68,43.18)
VFLT_P3V3_GNSS_VCC: length 8.3
  TOP w0.381: v1(15.88,41.53) 16.12,41.29 U124.23
  BOTTOM w0.381: R12822.1 v2(11.36,38.73) 12.98,38.73 v2(13.11,38.86) v2(14.08,39.83) 14.35,40.1 R12902.2
VFLT_P3V3_JA_VDDA: length 5.3
  TOP w0.305: U135.9 152.31,128.86 v1(152.01,129.16) 152.21,129.36 U135.8
  BOTTOM w0.381: C2151.2 152.2,129.34 v1(152.01,129.16) 152.01,128.72 v2(152.51,128.22) 152.58,128.15 C2152.2
  vias: v1(152.15,137.03) v1(152.15,136.27)
VFLT_P3V3_JA_VDDO: length 9.4
  TOP w0.356: U135.18 157.08,125.88 v1(157.1,125.86) ; U135.29 v1(161.11,130.86) ; U135.23 160.81,127.86 v1(161.16,127.51)
  TOP w0.381: U135.34 159.08,134.24 v1(159.64,134.8)
  BOTTOM w0.381: C2141.2 157.12,125.88 v1(157.1,125.86)
  BOTTOM w0.508: v1(161.16,127.51) 160.7,127.97 C2143.2 ; C2144.2 159.13,134.3 v1(159.64,134.8) ; v1(161.11,130.86) 160.55,131.42 C2145.2
  vias: v1(160.91,126.62) v1(161.8,126.62) v2(162.81,127.51) v2(164.21,127.51)
VFLT_P3V3_JA_VDDS: length 5.4
  TOP w0.356: v1(161.28,129.35) 161.27,129.36 160.14,129.36 U135.26
  BOTTOM w0.508: C2155.2 160.94,129.35 v1(161.28,129.35) 161.29,129.34 C2156.1 162.5,130.63 L189.1
VFLT_P3V3_NIC1_AVDD: length 8.4
  TOP w0.305: U85.51 93.77,87.03 94.07,87.34 v1(94.33,87.34)
  BOTTOM w0.254: v2(88.71,87.15) 88.71,86.97 89.72,85.96 L138.1
  BOTTOM w0.508: v1(94.33,87.34) 93.85,86.86 C1642.2 93.24,86.44 92.76,85.96 C1643.1 L138.1
VFLT_P3V3_NIC1_OSC: length 6.8
  TOP w0.381: v1(110.76,83.81) 112,83.81 X4.4
  BOTTOM w0.381: L141.1 114.4,84.72 R1271.2 113.42,83.57 C1941.1 112.37,83.61 C1940.2 110.99,83.59 v1(110.76,83.81)
VFLT_P3V3_OCXO_DPLL: length 44
  TOP w2.032: X11.3 14.68,113.38 16.64,115.34 16.64,120.6 18.24,122.2 X14.6 21.12,122.57 21.12,137.67 22.64,139.19 28.02,139.19
  vias: v1(29.97,139.47) v1(30.48,140.23) v1(30.61,138.68) v1(30.81,139.47) v2(27.77,138.46) v2(28.96,139.19)
VFLT_P3V3_OSC_25M_BUF: length 4.5
  TOP w0.381: 161.16,97.54 161.16,98.04 160.4,98.81 159.41,98.81 159.03,98.42 R1647.2 R1648.2
  vias: v1(154.33,86.66) v1(155.09,86.66) v1(161.67,97.03) v1(162.69,97.03)
VFLT_P3V3_PCIE_25M: length 10.1
  TOP w0.14: R1074.2 C1687.2 130.27,119.44 129.17,120.53 X3.4
  TOP w0.381: L139.1 C1688.1 128.92,115.58 129.35,116.02 R1074.2
VFLT_P3V3_PTP_OSC: length 5.6
  TOP w0.381: X2.4 56.32,78.07 56.32,78.07 C1369.2 C1370.1 54.29,77.67 L137.1 v1(53.41,76.65)
VFLT_P3V3_SMU_VDDA1: length 7.9
  TOP w0.381: v4(15.43,98.3) U139.K1 v4(15.43,97.3) U139.K2 ; U139.C1 v4(23.43,98.3) ; U139.D2 v4(22.43,97.3)
  BOTTOM w0.381: v4(15.43,97.3) 15.85,97.72 C2100.1 U139.K1 v4(15.43,98.3) ; v4(15.43,98.3) 14.93,97.8 C2102.1 ; v4(15.43,98.3) 15.85,98.72 C2101.2 ; v4(22.43,97.3) 22.01,97.72 C2104.1 ; C2103.1 U139.C1 v4(23.43,98.3)
  vias: v1(15.37,100.2) v1(16.26,100.2) v2(11.59,102.27) v2(11.56,100.97)
VFLT_P3V3_SMU_VDDA2: length 8.9
  TOP w0.381: U139.C6 v4(23.43,93.3) ; U139.H2 v4(17.43,97.3) ; U139.G2 v4(18.43,97.3) ; U139.F2 v4(20.43,97.3) ; v4(23.43,91.3) U139.C7 ; U139.F9 v4(20.43,89.3)
  BOTTOM w0.381: v4(20.43,97.3) 20.85,96.88 C2109.2 ; v4(23.43,91.3) U139.C7 C2111.1 ; v4(20.43,89.3) 20.93,89.8 C2110.1 ; C2108.1 U139.H2 v4(18.43,97.3) ; v4(23.43,93.3) 23.93,93.8 C2112.1 ; C2139.2 16.93,96.8 v4(17.43,97.3)
  vias: v1(26.18,99.03) v1(26.18,98.14) v2(26.42,96.77) v2(27.81,96.77)
VFLT_P3V3_SMU_VDDAO: length 8.5
  TOP w0.381: U139.B3 v4(24.43,96.3) ; U139.A5 v4(25.43,94.3) ; v4(25.43,91.3) U139.A7 ; U139.M4 v4(13.43,95.3) ; U139.L4 v4(14.43,95.3) ; U139.B2 v4(24.43,97.3)
  BOTTOM w0.381: v4(25.43,94.3) 25.01,94.72 C2118.1 ; v4(14.43,95.3) 14.93,95.8 C2120.1 ; v4(24.43,96.3) 24.85,95.88 C2172.2 ; C2116.1 U139.A7 v4(25.43,91.3) ; C2117.2 13.85,95.72 v4(13.43,95.3) ; C2119.1 24.81,96.88 24.43,97.26 v4(24.43,97.3)
  vias: v1(7.37,90.42) v1(7.49,91.19) v2(6.35,92.33) v2(6.35,90.93)
VFLT_P3V3_SMU_VDDC: length 3.5
  TOP w0.381: v4(20.43,91.3) U139.F7 ; U139.D5 v4(22.43,94.3)
  BOTTOM w0.381: C2082.1 22.85,94.72 v4(22.43,94.3) ; C2081.1 19.93,90.8 v4(20.43,91.3) 20.85,91.72 C2080.2
  vias: v1(23.79,102.12) v1(25.15,102.11)
VFLT_P3V3_SMU_VDDO: length 6.3
  TOP w0.381: U139.E6 v4(21.43,93.3) ; U139.M8 v4(13.43,90.3) ; v4(14.43,91.3) U139.L7 ; U139.E4 v4(21.43,95.3)
  BOTTOM w0.381: C2096.1 21.85,93.72 v4(21.43,93.3) ; C2092.2 21.85,95.72 v4(21.43,95.3) 21.85,94.88 C2095.1 ; v4(13.43,90.3) 13.93,90.8 C2094.1 ; C2093.1 14.85,91.72 v4(14.43,91.3)
  vias: v1(12.19,99.31) v1(13.34,99.44)
VFLT_VP1P0_MAC_NIF_TRXVDD: length 41.5
  TOP w0.381: U1.B23 v4(209.86,102.5) ; U1.B11 v4(222.86,102.5) ; v4(214.86,101.5) U1.A19 214.25,102.11 214.25,102.88 U1.B19 ; U1.A23 v4(209.86,101.5) ; U1.A15 v4(218.86,101.5) ; U1.F11 v4(222.86,106.5) ; U1.J22 v4(210.86,109.5) ; U1.J18 v4(215.86,109.5) ; U1.K14 v4(219.86,110.5) ; U1.B15 v4(218.86,102.5) ; U1.J10 v4(223.86,109.5) ; U1.A11 v4(222.86,101.5) ; U1.K10 v4(223.86,110.5) ; U1.G11 v4(222.86,107.5) ; U1.J14 v4(219.86,109.5) ; U1.G19 v4(214.86,107.5) ; U1.F15 v4(218.86,106.5) ; U1.F19 v4(214.86,106.5) ; U1.K18 v4(215.86,110.5) ; U1.G23 v4(209.86,107.5) ; U1.G15 v4(218.86,107.5) ; U1.K22 v4(210.86,110.5) ; U1.F23 v4(209.86,106.5)
  BOTTOM w0.381: C455.1 210.28,106.91 v4(209.86,106.5) ; C456.1 211.28,109.91 v4(210.86,109.5) ; v4(222.86,101.5) 222.36,101 C435.1 ; v4(223.86,109.5) 223.44,109.91 C462.2 ; C453.1 219.07,100.2 C432.2 218.36,101 v4(218.86,101.5) ; C466.2 U1.G15 v4(218.86,107.5) ; C428.2 U1.B15 v4(218.86,102.5) ; C426.1 U1.B11 v4(222.86,102.5) ; v4(222.86,107.5) U1.G11 C457.2 ; v4(218.86,106.5) 218.44,106.91 C465.1 ; v4(214.86,106.5) 214.44,106.91 C463.1 ; C434.2 213.87,102.49 v4(214.86,101.5) 215.36,101 C461.1 215.01,100.56 C452.1 ; v4(214.86,107.5) 215.36,108 C431.1 ; v4(209.86,102.5) 209.36,103 C460.1 ; C430.1 215.44,110.91 v4(215.86,110.5) ; C424.1 209.93,100.48 C458.1 210.36,101 v4(209.86,101.5) ; C454.2 U1.G23 v4(209.86,107.5) ; v4(219.86,109.5) 219.44,109.91 C429.1 ; v4(222.86,106.5) 222.44,106.91 C427.1 ; C464.2 U1.K14 v4(219.86,110.5) ; C433.1 216.28,109.91 v4(215.86,109.5) ; C425.2 U1.K22 v4(210.86,110.5) ; C459.2 223.44,110.91 v4(223.86,110.5)
  vias: v2(213,100.3) v2(213.66,99.21) v2(213.84,101.3) v2(214.38,97.54) v2(215.65,97.54) v2(216.92,97.54) v2(218.19,97.54) v2(219.46,97.54) v4(209.4,97.69) v4(209.4,96.93) v4(209.4,96.16) v4(209.4,95.4) v4(211.2,98.02) v4(211.2,97.33) v4(211.2,96.62) v4(211.2,95.76) v4(212.95,98.04) v4(212.95,97.33) v4(212.95,96.62) v4(212.98,95.89)
VFLT_VP1P0_MAC_NIFE_TRXVDD0: length 58.7
  TOP w0.381: U1.J36 v4(196.86,109.5) ; U1.H28 v4(204.86,108.5) ; U1.J32 v4(200.86,109.5) ; U1.P30 v4(202.86,114.5) ; U1.C32 v4(200.86,103.5) ; U1.D32 v4(200.86,104.5) ; U1.B31 v4(201.86,102.5) ; U1.N32 v4(200.86,113.5) ; U1.D28 v4(204.86,104.5) ; U1.A27 v4(205.86,101.5) ; U1.N36 v4(196.86,113.5) ; U1.P35 v4(197.86,114.5) ; U1.B27 v4(205.86,102.5) ; U1.B35 v4(197.86,102.5) ; U1.A31 v4(201.86,101.5) ; U1.F27 v4(205.86,106.5) ; U1.N37 v4(195.86,113.5) ; U1.P29 v4(203.86,114.5) ; U1.C28 v4(204.86,103.5) ; U1.P34 v4(198.86,114.5) ; U1.G27 v4(205.86,107.5) ; U1.C36 v4(196.86,103.5) ; U1.H36 v4(196.86,108.5) ; U1.A35 v4(197.86,101.5) ; U1.G31 v4(201.86,107.5) ; U1.F31 v4(201.86,106.5) ; U1.H32 v4(200.86,108.5) ; U1.G35 v4(197.86,107.5) ; U1.N31 v4(201.86,113.5) ; U1.F35 v4(197.86,106.5) ; U1.D36 v4(196.86,104.5) ; U1.J28 v4(204.86,109.5)
  BOTTOM w0.381: v4(201.86,101.5) 201.36,101 C537.1 201.93,100.35 C550.1 ; C521.1 196.36,104 v4(196.86,103.5) 196.36,103 C519.1 ; v4(200.86,109.5) U1.J32 C544.1 ; C535.1 204.36,104 v4(204.86,103.5) ; C541.2 200.36,104 v4(200.86,103.5) ; v4(200.86,104.5) U1.D32 C559.2 ; C534.1 201.44,106.08 201.68,106.32 v4(201.86,106.5) ; v4(201.86,102.5) U1.B31 C554.2 ; C531.1 197.99,100.55 C518.2 198.36,101 v4(197.86,101.5) ; C526.1 198.44,114.08 v4(198.86,114.5) U1.P34 C539.1 ; C551.2 203.28,114.91 v4(202.86,114.5) ; v4(200.86,108.5) 200.36,109 C517.1 ; C556.2 201.28,113.91 v4(200.86,113.5) 201.28,113.08 C558.1 ; v4(204.86,108.5) 204.36,108 C553.1 ; C522.1 U1.B27 v4(205.86,102.5) ; v1(194.18,101.02) 194.18,102.16 C514.1 194.94,102.16 v1(194.94,101.02) ; C525.2 196.44,109.91 v4(196.86,109.5) ; C549.1 205.87,100.42 C555.1 206.36,101 v4(205.86,101.5) ; C542.1 U1.G31 v4(201.86,107.5) ; C516.1 U1.D36 v4(196.86,104.5) ; v4(203.86,114.5) 204.36,114 C560.1 ; v4(196.86,108.5) 196.44,108.91 C533.2 ; v4(196.86,113.5) 197.28,113.91 C561.2 ; v4(205.86,106.5) 205.44,106.08 C540.1 ; v4(201.86,113.5) 202.36,113 C552.1 ; v4(197.86,107.5) U1.G35 C520.2 ; v4(204.86,104.5) U1.D28 C562.1 ; C536.2 197.44,106.08 v4(197.86,106.5) ; C515.2 204.44,109.08 v4(204.86,109.5) U1.J28 C538.2 ; v4(195.86,113.5) 195.36,113 C523.2 ; v4(197.86,114.5) 197.36,115 C524.1 ; v4(205.86,107.5) 205.94,107.5 C557.1 ; C543.2 U1.B35 v4(197.86,102.5)
  vias: v1(189.74,95.25) v1(190.5,95.25) v1(191.26,95.25) v2(193.29,99.06) v2(193.29,97.79) v2(194.56,99.06) v2(194.56,97.79) v2(195.83,99.06) v2(195.83,97.79) v4(193.61,107.99) v4(193.93,108.84)
