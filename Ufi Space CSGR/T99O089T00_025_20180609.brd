# Allegro board T99O089T00_025_20180609.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PC368  100nF  [C-0402S0]  7.13 178.11 180 bottom
PC369  100nF  [C-0603S0]  9.01 168.7 270 top
PC370  1uF  [C-0603S0]  19.54 154.12 270 top
PC371  330uF  [C-TAN-S7_3X4_3]  11.56 160.78 270 top
PC372  1uF  [C-0603S0]  8.57 178.62 0 bottom
PC373  22uF  [C-1210]  15.74 183.05 90 bottom
PC374  100nF  [C-0402S0]  3.83 181.5 270 top
PC375  2.2nF  [C-0402S0]  15.62 180.35 270 top
PC376  4.7uF  [C-0603S0]  9.6 181.99 180 top
PC377  1nF  [C-0603S0]  3.77 171.89 90 bottom
PC378  100nF  [C-0402S0]  15.49 178.57 90 bottom
PC379  100uF  [C-1210]  19.44 157 270 top
PC380  22uF  [C-1210]  15.74 186.86 270 top
PC381  22uF  [C-1210]  15.74 183.05 270 top
PC382  100uF  [C-1210]  19.44 157 90 bottom
PC383  330uF  [C-TAN-S7_3X4_3]  11.59 155.28 270 top
PC384  10nF  [S-C-0402]  45.73 137.32 270 top
PC386  1uF  [C-0603S0]  15.49 180.1 90 bottom
PC387  22uF  [C-1210]  15.74 190.67 270 top
PC388  1nF  [C-0603S0]  21.41 174.5 90 top
PC389  100nF  [C-0402S0]  19.57 152.86 270 top
PC390  100uF  [C-1210]  19.44 160.99 90 bottom
PC391  100uF  [C-1210]  19.44 160.99 270 top
PC392  0.1uF  [S-C-0402]  214.86 125 90 bottom
PC393  33pF  [C-0402S0]  6.28 181.92 0 top
PC394  33pF  [C-0402S0]  7.32 181.92 0 top
PC395  33pF  [C-0402S0]  32.44 169.6 0 top
PC396  33pF  [C-0402S0]  33.48 169.6 0 top
PC400  100nF  [C-0603S0]  27.14 144.89 180 top
PC401  22uF  [C-1210]  30.53 144.83 180 top
PC402  22uF  [C-1210]  30.55 144.83 0 bottom
PC403  1uF  [C-0805]  27.33 145.09 0 bottom
PC404  270pF  [C-0402S0]  21.82 149.76 90 bottom
PC405  100nF  [C-0603S0]  15.92 145.02 180 top
PC406  22uF  [C-0805]  17.01 145.02 0 bottom
PC407  22uF  [C-0805]  19.04 145.02 0 bottom
PC409  22uF  [C-0805]  17.54 145.02 180 top
PC417  22pF  [C-0402S0]  75.37 181.67 180 bottom
PC418  10uF  [C-1206]  83.21 184.33 180 top
PC419  10uF  [C-1206]  77.71 178.24 90 bottom
PC420  10uF  [C-1206]  80.63 184.33 180 top
PC421  10uF  [C-1206]  77.72 178.2 270 top
PC422  100nF  [C-0402S0]  78.86 184.38 0 bottom
PC423  10uF  [C-1206]  83.17 184.33 0 bottom
PC424  100nF  [C-0402S0]  78.1 182.08 90 bottom
PC425  3.3nF  [C-0402S0]  78.56 188.13 0 top
PC426  10uF  [C-1206]  80.63 184.33 0 bottom
PC427  10uF  [C-1206]  77.71 175.57 90 bottom
PC428  1uF  [C-0603S0]  78.25 180.8 90 bottom
PC429  1nF  [C-0603S0]  77.71 186.04 0 bottom
PC430  10uF  [C-1206]  77.71 175.57 270 top
PC433  100nF  [C-0402S0]  72.07 187.94 0 top
PC434  100nF  [C-0402S0]  72.07 186.16 180 top
PC3408  1uF  [C-0603S0]  14.55 145.02 180 top
PD1  B330A-13-F  [D-SMA-H2_41]  106.38 208.98 0 top
PD4  SMAJ16CA  [D-SMAH2_3]  56.64 209.8 0 top
PJ1  HS1105H-RN  [CN-S5X2-2_54AHDS0]  303.91 134.55 0 top
PL2  3.3uH 20% 6A 0.028ohm  [L-S6_86X6_47-2A]  75.03 205.86 90 top
PL3  470nH 20% 17.5A 0.004ohm  [L-S6_86X6_47-2-H3]  39.43 155.54 180 top
PL4  3.3uH 20% 6A 0.028ohm  [L-S6_86X6_47-2A]  207.01 205.34 90 top
PL5  120nH 10% 80A 0.00027ohm  [L-S10_2X7_8-2A]  290.14 166.4 90 top
PL6  120nH 10% 80A 0.00027ohm  [L-S10_2X7_8-2A]  290.06 150.47 90 top
PL7  360nH 20% 50A 0.0012ohm  [L-S11_5X10-2]  161.21 178.68 270 top
PL8  2.2uH 20% 8A 0.018ohm  [L-S6_86X6_47-2A]  190.37 209.49 90 top
PL9  2.2uH 20% 8A 0.018ohm  [L-S6_86X6_47-2A]  245.22 209.49 90 top
PL10  3.3uH 20% 6A 0.028ohm  [L-S6_86X6_47-2A]  281.51 116.38 180 top
PL11  3.3uH 20% 6A 0.028ohm  [L-S6_86X6_47-2A]  225.11 205.09 90 top
PL18  1.0uH +20%/-7% 9.6A 0.0146ohm  [L-S4X4-2L]  65.78 194.38 180 top
PL19  2.2uH  [L-S5_49X5_18-2]  60.28 148.15 270 top
PL20  2.2uH  [L-S5_49X5_18-2]  76.31 148.15 270 top
PL21  470nH 20% 17.5A 0.004ohm  [L-S6_86X6_47-2-H3]  14.34 167.91 180 top
PL23  1.0uH +20%/-7% 9.6A 0.0146ohm  [L-S4X4-2L]  71.72 180.58 180 top
PQ2  BSS138LT1 NFET 50V 200mA  [SOT-23I]  79.22 209.53 180 bottom
PQ3  BSS138LT1 NFET 50V 200mA  [SOT-23I]  75.34 211.62 180 top
PQ4  BSS138LT1 NFET 50V 200mA  [SOT-23I]  29.89 155.17 90 bottom
PQ5  BSS138LT1 NFET 50V 200mA  [SOT-23I]  34.49 158.1 270 bottom
PQ8  BSS138LT1 NFET 50V 200mA  [SOT-23I]  146.6 180.13 270 bottom
PQ9  BSS138LT1 NFET 50V 200mA  [SOT-23I]  150.38 180.15 270 bottom
PQ10  BSS138LT1 NFET 50V 200mA  [SOT-23I]  198.46 201.39 90 bottom
PQ11  BSS138LT1 NFET 50V 200mA  [SOT-23I]  198.5 210.03 90 top
PQ12  BSS138LT1 NFET 50V 200mA  [SOT-23I]  253.31 201.39 90 bottom
PQ13  BSS138LT1 NFET 50V 200mA  [SOT-23I]  253.34 210.03 90 top
PQ14  BSS138LT1 NFET 50V 200mA  [SOT-23I]  289.91 124.66 180 bottom
PQ15  BSS138LT1 NFET 50V 200mA  [SOT-23I]  281.75 123.17 90 bottom
PQ16  BSS138LT1 NFET 50V 200mA  [SOT-23I]  222.81 208.18 270 bottom
PQ17  BSS138LT1 NFET 50V 200mA  [SOT-23I]  222.71 211.22 270 top
PQ19  BSS138LT1 NFET 50V 200mA  [SOT-23I]  211.45 209.03 180 bottom
PQ20  BSS138LT1 NFET 50V 200mA  [SOT-23I]  207.32 211.67 180 top
PQ21  Si6415DQ-T1-GE3  [MSOP-8A]  65.53 208.66 90 top
PQ24  BSS138LT1 NFET 50V 200mA  [SOT-23I]  72.33 188.2 180 bottom
PQ25  BSS138LT1 NFET 50V 200mA  [SOT-23I]  71.53 181.71 90 bottom
PR1  22.6Kohm  [R-0402S0]  99.23 210.82 90 top
PR2  1ohm  [R-0603S0]  112.12 197.9 90 top
PR3  10Kohm  [R-0402S0]  98.9 207.83 90 bottom
PR11  18.2Kohm  [R-0603S0]  84.62 203.21 180 bottom
PR12  0ohm  [R-0603S0]  230.07 210.53 0 bottom
PR16  0ohm  [R-0603S0]  83.16 204.98 270 bottom
PR18  0ohm  [R-0603S0]  228.54 210.53 0 bottom
PR20  3Kohm  [R-0603S0]  83.16 206.36 90 bottom
PR22  3.6Kohm  [R-0603S0]  86 203.21 180 bottom
PR25  0ohm  [R-0603S0]  26.04 156.77 90 top
PR26  1Kohm  [R-0603S0]  302.13 138.49 90 bottom
PR27  0ohm  [R-0603S0]  277.15 127.52 90 top
PR28  0ohm  [R-0603S0]  26.04 158.3 90 top
PR29  0ohm  [R-0603S0]  302.13 136.96 90 bottom
PR30  0ohm  [R-0603S0]  277.15 126.04 90 top
PR31  0ohm  [R-0603S0]  302.13 135.44 90 bottom
PR32  0ohm  [R-0603S0]  302.13 131.5 270 bottom
PR33  0ohm  [R-0603S0]  277.15 124.52 90 top
PR34  0ohm  [R-0603S0]  276.42 119.65 180 top
PR35  0ohm  [R-0603S0]  26.04 159.82 90 top
PR36  0ohm  [R-0603S0]  26.04 161.35 270 top
PR38  174Kohm  [R-0402S0]  26.04 153.85 90 top
PR39  100Kohm  [R-0402S0]  302.41 134.17 270 bottom
PR40  100Kohm  [R-0402S0]  276.87 121.68 270 top
PR41  0ohm  [R-0603S0]  26.04 165.92 90 top
PR42  0ohm  [R-0603S0]  242.87 194.11 0 top
PR43  1Kohm  [R-0603S0]  26.04 162.87 90 top
PR44  0ohm  [R-0603S0]  143.43 187.33 90 top
PR45  0ohm  [R-0603S0]  244.25 194.11 0 top
PR46  0ohm  [R-0603S0]  26.04 164.39 270 top
PR47  0ohm  [R-0603S0]  143.43 185.94 90 top
PR48  0ohm  [R-0603S0]  245.62 194.11 0 top
PR49  0ohm  [R-0603S0]  239.11 194.11 180 top
PR50  0ohm  [R-0603S0]  26.04 170.49 270 top
PR51  174Kohm  [R-0402S0]  241.68 194.39 0 top
PR52  0ohm  [R-0603S0]  143.43 188.73 90 top
PR53  100Kohm  [R-0402S0]  26.04 167.44 270 top
PR54  0ohm  [R-0603S0]  143.43 192.67 270 top
PR55  174Kohm  [R-0402S0]  143.15 191.4 90 top
PR56  0.01ohm  [R-0805]  84.81 197.08 0 top
PR57  0603 0ohm 1%  [R-0603S0]  79.73 211.03 0 top
PR58  0.01ohm  [R-0805]  75.31 191.39 90 bottom
PR59  0.01ohm  [R-0805]  75.31 191.39 270 top
PR60  2.2  [R-1206]  76.93 205.72 270 bottom
PR61  10ohm  [R-0603S0]  81.89 211.89 270 top
PR62  330R  [R-0805]  75.44 196.34 90 bottom
PR63  10Kohm  [R-0402S0]  84.55 202.92 0 top
PR64  54.9Kohm  [R-0603S0]  82.57 209.84 180 top
PR65  20Kohm  [R-0402S0]  84.55 204.7 0 top
PR66  10Kohm  [R-0402S0]  84.41 209.3 270 top
PR67  2Mohm  [R-0402S0]  84.41 210.24 270 top
PR68  910Kohm  [R-0402S0]  83.36 210.36 270 bottom
PR69  10Kohm  [R-0402S0]  75.18 210.3 270 bottom
PR70  100Kohm  [R-0402S0]  75.18 208.29 270 bottom
PR71  160Kohm  [R-0402S0]  78.33 212.96 90 top
PR72  10Kohm  [R-0402S0]  72.41 210.54 90 top
PR73  100Kohm  [R-0402S0]  72.41 212.61 90 top
PR74  187Kohm  [R-0603S0]  30.53 160.75 270 top
PR75  23.7Kohm  [R-0402S0]  30.39 161.97 90 top
PR76  40.2Kohm  [R-0603S0]  30.52 163.24 270 top
PR77  1ohm  [R-0603S0]  37.25 169.72 0 top
PR78  8.66Kohm  [R-0402S0]  30.39 164.51 270 top
PR79  51.1Kohm  [R-0402S0]  30.39 165.53 270 top
PR80  18Kohm  [R-0402S0]  34.43 169.57 180 top
PR81  0.005ohm  [R-1206]  36.45 176.83 270 bottom
PR82  0.005ohm  [R-1206]  36.45 176.83 90 top
PR83  10ohm  [R-0402S0]  34.82 150.55 0 top
PR84  0.005ohm  [R-1206]  36.45 174.16 90 top
PR85  0.005ohm  [R-1206]  36.45 174.16 270 bottom
PR86  0ohm  [R-0402S0]  30.68 156.14 270 top
PR87  26.7Kohm  [R-0603S0]  30.4 158.78 270 top
PR88  10Kohm  [R-0402S0]  33.02 159.05 270 top
PR89  0ohm  [R-0402S0]  30.73 155.12 270 top
PR90  10ohm  [R-0402S0]  33.86 150.55 180 top
PR91  20Kohm  [R-0402S0]  31.08 167.03 0 bottom
PR92  30Kohm  [R-0402S0]  30.01 168.2 270 top
PR93  2.2ohm  [R-1206]  44.53 157.82 0 top
PR94  0ohm  [R-0603S0]  34.7 158.42 180 top
PR95  100ohm  [R-1206]  10.22 155.29 270 bottom
PR96  100Kohm  [R-0402S0]  31.41 169.59 0 top
PR98  357Kohm  [R-0603S0]  29.21 158.43 90 bottom
PR99  10Kohm  [R-0402S0]  29.98 152.46 90 bottom
PR100  100Kohm  [R-0402S0]  29.98 151.44 90 bottom
PR101  147Kohm  [R-0402S0]  31.54 159.87 90 bottom
PR102  10Kohm  [R-0402S0]  33.03 154.58 270 bottom
PR103  100Kohm  [R-0402S0]  33.03 152.56 270 bottom
PR104  0603 0ohm 1%  [R-0603S0]  211.97 210.45 0 top
PR105  0603 0ohm 1%  [R-0603S0]  215.64 203.56 180 bottom
PR106  2.2  [R-1206]  208.91 205.22 270 bottom
PR107  10ohm  [R-0603S0]  213.54 211.31 180 top
PR108  100ohm  [R-0805]  207.49 199.01 90 bottom
PR109  10Kohm  [R-0402S0]  217.04 201.78 0 top
PR110  13.7Kohm  [R-0402S0]  214.44 209.03 180 top
PR111  20Kohm  [R-0402S0]  217.04 203.56 0 top
PR112  10.2Kohm  [R-0402S0]  215.85 209.66 270 top
PR113  1.5Mohm  [R-0402S0]  215.85 210.68 270 top
PR120  124Kohm  [R-0402S0]  291.52 141.9 180 top
PR121  26.7Kohm  [R-0402S0]  293.51 141.9 180 top
PR122  0ohm  [R-0402S0]  305.35 137.81 180 bottom
PR123  20Kohm  [R-0402S0]  286 141.79 0 top
PR124  30Kohm  [R-0402S0]  290.57 141.92 0 top
PR125  39Kohm  [R-0402S0]  292.56 141.9 0 top
PR126  121Kohm  [R-0402S0]  284.11 141.78 180 top
PR127  102Kohm  [R-0402S0]  282.38 140.98 270 top
PR128  105Kohm  [R-0402S0]  295.66 139.95 90 top
PR129  16.5Kohm  [R-0402S0]  295.64 138.39 90 top
PR130  232Kohm  [R-0402S0]  293.99 137.89 90 top
PR131  56Kohm  [R-0402S0]  282.38 140.03 270 top
PR132  118Kohm  [R-0402S0]  282.38 138.13 90 top
PR133  0ohm  [R-0402S0]  282.64 135.79 270 top
PR134  150Kohm  [R-0402S0]  293.99 140.58 270 top
PR135  24Kohm  [R-0402S0]  293.99 139.21 270 top
PR136  24Kohm  [R-0402S0]  295.9 136.98 90 bottom
PR137  1Kohm  [R-0402S0]  281.36 136.66 90 top
PR138  0ohm  [R-0402S0]  293.89 134.36 270 top
PR139  10ohm  [R-0402S0]  279.34 135.15 180 top
PR140  10Kohm  [R-0402S0]  294.02 138.35 90 bottom
PR141  0ohm  [R-0402S0]  276.98 134.75 270 top
PR142  10Kohm  [R-0402S0]  293.89 132.6 270 top
PR143  4.99Kohm  [R-0402S0]  280.35 134.29 180 top
PR144  8.06Kohm  [R-0402S0]  283.34 132.52 90 top
PR145  10Kohm  [R-0402S0]  291.45 130.77 0 top
PR146  10Kohm  [R-0402S0]  290.48 130.78 0 top
PR147  0ohm  [R-0402S0]  276.98 133.78 270 top
PR148  0ohm  [R-0402S0]  284.86 131.06 180 top
PR149  10ohm  [R-0402S0]  279.34 133.37 180 top
PR150  1ohm  [R-0603S0]  288.95 129.32 0 bottom
PR152  10Kohm  [R-0402S0]  295.79 134.46 90 top
PR153  10Kohm  [R-0402S0]  295.79 135.41 90 top
PR154  10Kohm  [R-0402S0]  295.79 136.35 90 top
PR155  1ohm  [R-0603S0]  287.53 129.32 0 bottom
PR157  10Kohm  [R-0402S0]  303.56 174.5 90 top
PR158  2.2ohm  [R-0603S0]  306.24 170.23 270 top
PR159  1ohm  [R-0603S0]  294.26 172.47 180 top
PR160  1ohm  [R-0805]  294.09 160.74 270 top
PR161  10Kohm  [R-0402S0]  303.79 158.27 90 top
PR162  2.2ohm  [R-0603S0]  305.53 154.49 270 top
PR163  1ohm  [R-0603S0]  294.1 157.2 180 top
PR164  1ohm  [R-0805]  294.06 144.79 270 top
PR165  187Kohm  [R-0603S0]  147.48 185.96 270 top
PR166  121Kohm  [R-0402S0]  147.23 187.18 270 top
PR167  40.2Kohm  [R-0603S0]  147.48 188.4 270 top
PR168  1ohm  [R-0603S0]  152.56 196.5 0 top
PR169  8.66Kohm  [R-0402S0]  147.23 189.61 270 top
PR170  51.1Kohm  [R-0402S0]  147.23 190.55 270 top
PR171  0.005ohm  [R-1206]  152.65 205.18 0 top
PR172  28Kohm  [R-0402S0]  149.39 193.2 180 top
PR173  0.005ohm  [R-1206]  155.19 205.18 0 top
PR174  0.005ohm  [R-1206]  155.19 205.18 180 bottom
PR175  10ohm  [R-0402S0]  173.9 171.03 90 bottom
PR176  0.005ohm  [R-1206]  152.65 205.18 180 bottom
PR177  0ohm  [R-0402S0]  146.67 179.36 0 top
PR178  1.1Kohm  [R-0402S0]  146.67 183.78 0 top
PR179  10Kohm  [R-0402S0]  149.48 183.77 180 top
PR180  0ohm  [R-0402S0]  147.74 179.36 0 top
PR181  10ohm  [R-0402S0]  173.9 170.06 270 bottom
PR182  20Kohm  [R-0402S0]  151.29 191.29 270 bottom
PR183  30Kohm  [R-0402S0]  147.23 191.49 270 top
PR184  2.2ohm  [R-1206]  162.69 185.55 270 top
PR185  330ohm  [R-0805]  177.09 175.75 270 top
PR186  0ohm  [R-0603S0]  153.42 183.25 180 top
PR187  100Kohm  [R-0402S0]  147.23 193.38 90 top
PR189  2.7Kohm  [R-0402S0]  147.01 182.76 270 bottom
PR190  10Kohm  [R-0402S0]  147.31 174.27 270 bottom
PR191  100Kohm  [R-0402S0]  147.31 175.38 270 bottom
PR192  31.6Kohm  [R-0402S0]  150.48 182.76 90 bottom
PR193  10Kohm  [R-0402S0]  150.96 174.1 270 bottom
PR194  100Kohm  [R-0402S0]  150.96 175.25 270 bottom
PR195  0.01ohm  [R-0805]  195.68 195.36 90 top
PR196  10K  [R-0402S0]  193.17 206.09 90 bottom
PR197  0603-0ohm  [R-0603S0]  195.81 207.84 0 top
PR198  0.01ohm  [R-0805]  186.77 197.07 270 top
PR199  0.01ohm  [R-0805]  186.77 197.07 90 bottom
PR200  2.2ohm  [R-1206]  188.85 210.06 270 bottom
PR201  10ohm  [R-0603S0]  198.38 206.22 180 top
PR202  330R  [R-0805]  186.64 200.46 90 bottom
PR203  0ohm  [R-0402S0]  191.77 205.33 0 bottom
PR204  20Kohm  [R-0402S0]  196.98 206.83 180 bottom
PR205  1.1Kohm  [R-0402S0]  198.42 203.55 180 top
PR206  60.4Kohm  [R-0402S0]  193.17 204.92 90 bottom
PR207  10K  [R-0402S0]  196.38 203.55 0 top
PR208  8.87Kohm  [R-0402S0]  195.07 204.06 180 bottom
PR209  0603 0ohm 1%  [R-0603S0]  192.41 202.54 270 bottom
PR210  2.7Kohm  [R-0402S0]  197.68 198.09 90 bottom
PR211  10Kohm  [R-0402S0]  197.84 197.48 270 top
PR212  100Kohm  [R-0402S0]  197.84 199.63 270 top
PR213  31.6Kohm  [R-0402S0]  199.45 203.55 0 top
PR214  10Kohm  [R-0402S0]  200.38 205.71 270 top
PR215  100Kohm  [R-0402S0]  200.38 206.71 270 top
PR216  0.01ohm  [R-0805]  250.52 195.36 90 top
PR217  0603-0ohm  [R-0603S0]  250.65 207.84 0 top
PR218  10K  [R-0402S0]  248.01 206.09 90 bottom
PR219  2.2ohm  [R-1206]  243.59 210.06 270 bottom
PR220  10ohm  [R-0603S0]  253.22 206.22 180 top
PR221  330R  [R-0805]  241.48 199.32 90 bottom
PR222  0ohm  [R-0402S0]  246.61 205.33 0 bottom
PR223  20Kohm  [R-0402S0]  251.82 206.83 180 bottom
PR224  3.3Kohm  [R-0402S0]  253.28 203.55 180 top
PR225  60.4Kohm  [R-0402S0]  248.01 204.92 90 bottom
PR226  10K  [R-0402S0]  251.22 203.55 0 top
PR227  5.1Kohm  [R-0402S0]  250.04 203.42 180 bottom
PR228  0603 0ohm 1%  [R-0603S0]  247.25 202.54 270 bottom
PR229  27.4Kohm  [R-0402S0]  253.71 198.09 270 bottom
PR230  10Kohm  [R-0402S0]  252.68 197.48 270 top
PR231  100Kohm  [R-0402S0]  252.68 199.63 270 top
PR232  75Kohm  [R-0402S0]  254.3 203.55 0 top
PR233  10Kohm  [R-0402S0]  251.75 210.32 180 bottom
PR234  100Kohm  [R-0402S0]  252.76 210.32 180 bottom
PR235  10Kohm  [R-0603S0]  259.36 150.83 0 top
PR236  20Kohm  [R-0402S0]  260.98 156.32 270 top
PR237  10Kohm  [R-0603S0]  259.43 148.6 0 bottom
PR238  0.01ohm  [R-0805]  294.98 121.92 180 top
PR239  0603 0ohm 1%  [R-0603S0]  291.19 122.27 90 top
PR240  10K  [R-0402S0]  284.94 119.27 180 bottom
PR241  0603-0ohm  [R-0603S0]  283.19 121.91 90 top
PR242  2.2ohm  [R-1206]  283.16 115.97 90 bottom
PR243  10ohm  [R-0603S0]  284.81 124.48 270 top
PR244  330R  [R-0805]  288.82 112.74 180 bottom
PR245  0ohm  [R-0402S0]  285.7 117.87 90 bottom
PR246  3.9Kohm  [R-0402S0]  287.48 124.54 270 top
PR247  33Kohm  [R-0603S0]  284.92 122.56 0 bottom
PR248  60.4Kohm  [R-0402S0]  286.26 120.52 180 bottom
PR249  10K  [R-0402S0]  287.48 122.48 90 top
PR250  17.4Kohm  [R-0402S0]  286.64 121.92 270 bottom
PR251  0ohm  [R-0603S0]  287.99 118.51 0 bottom
PR252  31.6Kohm  [R-0402S0]  292.94 123.78 180 bottom
PR253  10Kohm  [R-0402S0]  293.55 123.95 0 top
PR254  100Kohm  [R-0402S0]  291.4 123.95 0 top
PR255  97.6Kohm  [R-0402S0]  287.48 125.56 90 top
PR256  10Kohm  [R-0402S0]  282.76 124.47 0 top
PR257  100Kohm  [R-0402S0]  281.76 124.47 0 top
PR258  0603 0ohm 1%  [R-0603S0]  230.07 210.53 0 top
PR259  2.2  [R-1206]  227.01 204.96 270 bottom
PR260  10ohm  [R-0603S0]  231.71 211.06 180 top
PR261  330R  [R-0805]  225.46 197.21 90 bottom
PR262  10Kohm  [R-0402S0]  234.61 202.16 0 top
PR263  22.6Kohm  [R-0402S0]  232.54 208.77 180 top
PR264  20Kohm  [R-0402S0]  234.61 203.94 0 top
PR265  10Kohm  [R-0402S0]  233.49 208.77 0 top
PR295  0.005ohm  [R-1206]  65.79 208.66 90 bottom
PR296  1Kohm  [R-0603S0]  53.72 210.44 0 top
PR297  91Kohm  [R-0603S0]  59.56 210.31 180 top
PR298  100Kohm  [R-0402S0]  63.25 181.41 270 bottom
PR299  100Kohm  [R-0402S0]  64.39 177.8 0 bottom
PR300  100Kohm  [R-0402S0]  63.25 186.13 270 bottom
PR301  100Kohm  [R-0402S0]  63.25 184.96 270 bottom
PR306  0.005ohm  [R-1206]  307.49 163.59 270 top
PR307  0.005ohm  [R-1206]  307.49 163.59 90 bottom
PR308  0.005ohm  [R-1206]  307.55 145.57 270 top
PR309  0.005ohm  [R-1206]  307.53 145.63 90 bottom
PR310  0.005ohm  [R-1206]  307.49 161 90 bottom
PR311  0.005ohm  [R-1206]  307.49 161 270 top
PR312  63.4Kohm  [R-0402S0]  304.04 154.87 270 bottom
PR313  33Kohm  [R-0402S0]  301.62 154.31 270 bottom
PR314  63.4Kohm  [R-0402S0]  304.25 171.2 270 bottom
PR315  33Kohm  [R-0402S0]  301.62 170.05 270 bottom
PR316  0.01ohm  [R-0805]  232.93 196.32 0 top
PR317  0.01ohm  [R-0805]  214.83 196.58 0 top
PR318  0.01ohm  [R-0805]  82.6 197.08 0 top
PR319  0.01ohm  [R-0805]  232.92 196.4 180 bottom
PR320  147Kohm  [R-0402S0]  222.63 211.51 90 bottom
PR321  100Kohm  [R-0402S0]  225.59 211.78 270 top
PR322  100Kohm  [R-0402S0]  225.22 207.44 180 bottom
PR323  10Kohm  [R-0402S0]  227.25 207.44 180 bottom
PR324  10Kohm  [R-0402S0]  225.59 209.62 270 top
PR325  100ohm  [R-0805]  276.53 161.6 0 bottom
PR326  100ohm  [R-0805]  276.43 154.49 180 bottom
PR328  100ohm  [R-0805]  207.47 197.08 90 bottom
PR329  287Kohm  [R-0402S0]  225.59 209.62 270 bottom
PR330  0ohm  [R-0603S0]  196.21 199.16 0 top
PR331  0ohm  [R-0603S0]  199.13 206.29 90 bottom
PR332  0ohm  [R-0603S0]  273.93 120.45 90 top
PR333  1Kohm  [R-0603S0]  273.93 127.52 90 top
PR334  0ohm  [R-0603S0]  273.93 124.52 270 top
PR335  0ohm  [R-0603S0]  273.93 126.04 270 top
PR336  100Kohm  [R-0402S0]  273.65 121.68 270 top
PR337  0ohm  [R-0402S0]  306 140 0 bottom
PR338  0ohm  [R-0402S0]  303.33 141.38 270 bottom
PR339  20K  [R-0603S0]  59.6 199.43 270 top
PR340  20K  [R-0603S0]  67.93 141.66 90 bottom
PR341  20K  [R-0603S0]  81.89 140.91 90 bottom
PR346  0.01ohm  [R-0603S0]  108.2 196.34 0 bottom
PR347  0.01ohm  [R-0603S0]  63.94 201.12 90 top
PR348  0.01ohm  [R-0603S0]  63.96 201.12 270 bottom
PR349  0.01ohm  [R-0603S0]  58.88 186.36 270 bottom
PR350  0.01ohm  [R-0603S0]  58.88 186.31 90 top
PR351  100Kohm  [R-0402S0]  57.71 195.13 270 top
PR352  330ohm  [R-0603S0]  64.95 189.95 90 bottom
PR353  33ohm  [R-0603S0]  60.34 188.46 180 top
PR354  100Kohm  [R-0402S0]  58.93 197.36 270 bottom
PR355  200Kohm  [R-0402S0]  57.71 194.15 270 top
PR356  174Kohm  [R-0402S0]  59.35 191 0 top
PR357  56Kohm  [R-0402S0]  58.4 191 180 top
PR358  0.01ohm  [R-0805]  66.25 149.63 270 top
PR359  100Kohm  [R-0402S0]  66.23 142.92 0 bottom
PR360  2.21ohm  [R-0603S0]  61.65 144.09 90 top
PR361  330ohm  [R-0603S0]  57.76 137.58 90 bottom
PR362  102Kohm  [R-0402S0]  63.48 137.61 270 top
PR363  160Kohm  [R-0402S0]  63.48 136.62 90 top
PR364  165Kohm  [R-0402S0]  66.25 141.7 0 top
PR365  0.01ohm  [R-0805]  82.27 149.63 270 top
PR366  100Kohm  [R-0402S0]  82.13 143.24 0 bottom
PR367  2.21ohm  [R-0603S0]  77.68 144.09 90 top
PR368  330ohm  [R-0603S0]  73.79 141.6 90 bottom
PR369  137Kohm  [R-0402S0]  80.12 137.49 270 top
PR370  150Kohm  [R-0402S0]  80.12 136.5 90 top
PR371  165Kohm  [R-0402S0]  82.27 141.7 0 top
PR372  86.6kohm  [R-0402S0]  297.43 172.4 90 bottom
PR373  0.005ohm  [R-1206]  307.54 148.22 90 bottom
PR374  0ohm  [R-0402S0]  304.57 157.27 90 top
PR386  10Kohm  [R-0402S0]  26.97 148.07 270 bottom
PR387  3.9Kohm  [R-0402S0]  26.97 149.08 270 bottom
PR388  5.36Kohm  [R-0402S0]  17.24 149.12 90 bottom
PR389  1.69Kohm  [R-0402S0]  17.24 150.13 270 bottom
PR395  0.005ohm  [R-1206]  307.54 148.22 270 top
PR396  86.6kohm  [R-0402S0]  297.96 156.26 90 bottom
PR397  0ohm  [R-0402S0]  304.67 173.02 90 top
PR398  118Kohm  [R-0402S0]  210.31 212.96 90 top
PR399  10Kohm  [R-0402S0]  204.39 210.6 90 top
PR400  147Kohm  [R-0402S0]  214.4 209.03 270 bottom
PR401  10Kohm  [R-0402S0]  207.95 210.55 270 bottom
PR402  100Kohm  [R-0402S0]  207.95 208.54 270 bottom
PR403  100Kohm  [R-0402S0]  204.39 212.66 90 top
PR416  10ohm  [R-0603S0]  78.48 137.18 0 top
PR417  10ohm  [R-0603S0]  61.85 137.31 0 top
PR418  187Kohm  [R-0603S0]  4.36 173.07 270 top
PR419  0.005ohm  [R-1206]  10.28 186.48 90 top
PR420  0ohm  [R-0402S0]  3.73 169.09 0 top
PR421  0.005ohm  [R-1206]  10.28 189.15 90 top
PR422  51.1Kohm  [R-0402S0]  4.23 177.85 270 top
PR423  51.1Kohm  [R-0402S0]  4.23 174.29 270 top
PR424  0.005ohm  [R-1206]  10.28 189.15 270 bottom
PR425  30Kohm  [R-0402S0]  3.85 180.51 270 top
PR426  0ohm  [R-0402S0]  4.77 169.09 0 top
PR427  0ohm  [R-0603S0]  9.61 170.79 180 top
PR428  10ohm  [R-0402S0]  8.26 165.16 0 top
PR429  1ohm  [R-0603S0]  11.09 182.04 0 top
PR430  8.66Kohm  [R-0402S0]  4.23 176.83 270 top
PR431  10Kohm  [R-0402S0]  5.6 171.35 180 top
PR432  100Kohm  [R-0402S0]  5.24 181.91 0 top
PR433  2.2ohm  [R-1206]  20.76 172.52 270 top
PR434  0.005ohm  [R-1206]  10.28 186.48 270 bottom
PR435  18Kohm  [R-0402S0]  8.27 181.89 180 top
PR436  100ohm  [R-1206]  37.14 140.81 270 bottom
PR437  20Kohm  [R-0402S0]  5.5 178.73 0 bottom
PR438  10ohm  [R-0402S0]  7.24 165.16 180 top
PR439  26.7Kohm  [R-0603S0]  3.73 171.56 270 top
PR440  40.2Kohm  [R-0603S0]  4.35 175.56 270 top
PR441  0ohm  [R-0402S0]  8.74 182.46 0 bottom
PR442  0ohm  [R-0402S0]  4.23 178.86 270 top
PR443  0ohm  [R-0402S0]  6.52 182.53 90 bottom
PR480  0.01ohm  [R-0805]  82.23 188.31 270 bottom
PR481  0.01ohm  [R-0805]  82.23 188.32 90 top
PR482  52.3Kohm  [R-0402S0]  75.41 181.27 90 top
PR483  430Kohm  [R-0402S0]  74.41 181.67 180 bottom
PR484  1ohm  [R-0805]  76.02 186.98 180 bottom
PR485  0ohm  [R-0402S0]  79.52 188.13 0 top
PR486  0ohm  [R-0603S0]  77.3 180.13 90 top
PR487  0ohm  [R-0402S0]  76.6 188.12 180 top
PR489  0ohm  [R-0402S0]  77.58 188.12 0 top
PR496  100Kohm  [R-0402S0]  73.09 186.16 180 top
PR497  10Kohm  [R-0402S0]  70.67 187.43 90 top
PR498  100Kohm  [R-0402S0]  73.09 187.94 0 top
PR499  10Kohm  [R-0402S0]  70.67 186.29 90 top
PR500  2.2Mohm  [R-0402S0]  74.18 185.86 180 top
PR501  86.6kohm  [R-0402S0]  74.18 188.78 0 top
PR504  0ohm  [R-0603S0]  30.4 157.35 90 top
PR505  0ohm  [R-0603S0]  146.67 181.59 0 top
PR506  0ohm  [R-0402S0]  282.64 134.7 270 top
PU1  TPS563219ADDFR  [SOT-23-8A]  81.51 205.6 270 top
PU2  TPS543C20RVFR  [TQFN-7X5-40DSH]  36.83 163.62 0 top
PU3  TPS563219ADDFR  [SOT-23-8A]  213.49 205.09 270 top
PU4  TPS53667RTAR  [TQFN-6X6-40SH-SPEC]  288.2 136.29 270 top
PU5  CSD95490Q5MC  [TQFN-6X5-12SH]  299.89 169.98 180 top
PU6  CSD95490Q5MC  [TQFN-6X5-12SH]  299.81 154.15 180 top
PU7  TPS543C20RVFR  [TQFN-7X5-40DSH]  153.96 188.5 0 top
PU8  MPQ8623GD-Z  [TQFN-3X2-14A]  193.17 203.81 0 top
PU9  MPQ8623GD-Z  [TQFN-3X2-14A]  248.01 203.81 0 top
PU10  TPS51200DRCR  [TQFN-3X3-10GSH]  263.17 153.02 270 top
PU11  MPQ8623GD-Z  [TQFN-3X2-14A]  287.22 119.27 90 top
PU12  TPS563219ADDFR  [SOT-23-8A]  231.59 204.83 270 top
PU13  TPS74801RGWR  [SQFN-5X5-20ESH]  22.39 147.56 0 top
PU18  TPS73701DRBR  [SQFN-3X3-8HSH]  98.64 206.33 90 top
PU19  TPS63070RNMR  [TQFN-3X2_5-15S0]  61.07 194.61 270 top
PU20  MP2161GJ-C499-Z  [SOT-23-8A]  63.67 140.81 90 top
PU21  MP2161GJ-C499-Z  [SOT-23-8A]  79.69 140.81 90 top
PU22  TPS543C20RVFR  [TQFN-7X5-40DSH]  10.66 175.99 0 top
PU24  TPS62135RGXR  [TQFN-3X2-11A]  76.95 184.46 270 top
Q2  PMST3904  [SOT-323AH1_1]  111.85 199.97 0 top
Q3  2N7002K-7  [SOT-23BH1_11]  260.96 185.73 0 top
Q4  PMST3904  [SOT-323AH1_1]  260.96 185.1 0 bottom
Q5  NTJD4401NT1G  [SOT-363S0]  50.46 190.85 270 bottom
Q6  2N7002K-7  [SOT-23BH1_11]  51.44 196.09 0 bottom
Q7  2N7002K-7  [SOT-23BH1_11]  276.71 185.74 0 top
Q8  2N7002K-7  [SOT-23BH1_11]  265.78 185.86 0 top
Q9  PMST3904  [SOT-323AH1_1]  276.71 185.74 0 bottom
Q10  PMST3904  [SOT-323AH1_1]  265.78 185.86 0 bottom
Q12  2N7002K-7  [SOT-23BH1_11]  84.45 113.98 270 top
Q13  2N7002K-7  [SOT-23BH1_11]  47.12 71.37 180 bottom
Q15  2N7002K-7  [SOT-23BH1_11]  272.01 185.73 0 top
Q16  2N7002K-7  [SOT-23BH1_11]  285.92 185.75 0 top
Q17  PMST3904  [SOT-323AH1_1]  272.01 185.73 0 bottom
Q18  PMST3904  [SOT-323AH1_1]  280.95 185.73 0 top
Q23  NTJD4401NT1G  [SOT-363S0]  51.36 194.94 180 top
Q24  NTJD4401NT1G  [SOT-363S0]  51.33 200.61 180 top
Q28  NTJD4401NT1G  [SOT-363S0]  90.14 43.26 180 bottom
Q29  NTJD4401NT1G  [SOT-363S0]  105.51 42.86 180 bottom
Q30  NTJD4401NT1G  [SOT-363S0]  119.86 42.74 180 bottom
Q31  NTJD4401NT1G  [SOT-363S0]  134.24 42.35 180 bottom
Q32  NTJD4401NT1G  [SOT-363S0]  148.36 42.35 180 bottom
Q33  NTJD4401NT1G  [SOT-363S0]  162.61 42.23 180 bottom
Q34  NTJD4401NT1G  [SOT-363S0]  177.37 42.86 180 bottom
Q35  NTJD4401NT1G  [SOT-363S0]  191.37 42.38 180 bottom
Q36  NTJD4401NT1G  [SOT-363S0]  208.75 40.44 180 bottom
Q37  NTJD4401NT1G  [SOT-363S0]  223.55 40.92 180 bottom
Q38  NTJD4401NT1G  [SOT-363S0]  237.41 40.92 180 bottom
Q39  NTJD4401NT1G  [SOT-363S0]  251.66 40.48 180 bottom
Q40  NTJD4401NT1G  [SOT-363S0]  266.32 40.48 180 bottom
Q41  NTJD4401NT1G  [SOT-363S0]  279.58 40.48 0 bottom
Q42  BSS138LT1 NFET 50V 200mA  [SOT-23I]  13.49 33.41 90 bottom
Q44  NTJD4401NT1G  [SOT-363S0]  279.97 78.02 0 top
Q54  AO3401  [SOT-23D]  77.63 59.96 180 top
Q56  AO3401  [SOT-23D]  163.23 144.64 90 top
Q57  2N7002K-7  [SOT-23BH1_11]  91.06 136.84 0 top
Q58  2N7002K-7  [SOT-23BH1_11]  131.06 185.17 270 top
Q59  AO3401  [SOT-23D]  11.93 29.04 0 bottom
Q60  AO3401  [SOT-23D]  97.31 134.86 270 top
R1  150ohm  [R-0402S0]  188.09 132.59 90 top
R2  150ohm  [R-0402S0]  188.09 136.14 90 top
R3  150ohm  [R-0402S0]  188.09 135.13 90 top
R4  100ohm  [S-R-0402]  209.35 130.5 180 bottom
R5  100ohm  [S-R-0402]  215.86 132.01 270 bottom
R6  150ohm  [R-0402S0]  188.09 133.6 90 top
R7  1Kohm  [R-0402S0]  188.09 135.13 90 bottom
R8  1Kohm  [R-0402S0]  188.09 136.14 90 bottom
R9  1Kohm  [R-0402S0]  188.09 132.59 90 bottom
R10  1Kohm  [R-0402S0]  188.09 133.6 90 bottom
R11  100ohm  [S-R-0402]  226.35 127.5 0 bottom
R16  100ohm  [R-0402S0]  192.76 118.35 180 top
R26  4.7K  [R-0402S0]  188.1 130.16 90 top
R27  4.7K  [R-0402S0]  173.52 132.78 90 top
R28  4.7K  [R-0402S0]  170.17 135.96 90 top
R29  4.7K  [R-0402S0]  170.17 133.92 90 top
R30  4.7K  [R-0402S0]  170.17 130.36 90 top
R31  4.7K  [R-0402S0]  170.17 138 90 top
R32  4.7K  [R-0402S0]  184.57 127.62 90 top
R33  4.7K  [R-0402S0]  188.1 131.43 270 top
R34  4.7K  [R-0402S0]  170.17 129.09 270 top
R35  4.7K  [R-0402S0]  188.1 128.89 270 top
R36  33ohm  [R-0402S0]  188.1 127.61 270 top
R37  33ohm  [R-0402S0]  188.1 126.34 270 top
R38  4.7K  [R-0402S0]  177.08 126.16 270 top
R39  33ohm  [R-0402S0]  188.1 123.8 270 top
R40  4.7K  [R-0402S0]  170.17 136.98 270 top
R41  33ohm  [R-0402S0]  188.1 125.07 270 top
R42  4.7K  [R-0402S0]  177.08 124.64 270 top
R43  33ohm  [R-0402S0]  187.98 121.25 270 top
R44  33ohm  [R-0402S0]  173.52 131.51 270 top
R45  4.7K  [R-0402S0]  170.17 132.9 270 top
R46  4.7K  [R-0402S0]  170.17 134.94 270 top
R47  4.7K  [R-0402S0]  184.57 126.35 270 top
R48  4.7K  [R-0402S0]  173.52 134.05 270 top
R49  0ohm  [R-0402S0]  184.57 128.89 90 top
R50  0ohm  [R-0402S0]  177.52 119.27 180 top
R51  0ohm  [R-0402S0]  176.49 119.27 180 top
R52  4.7K  [R-0402S0]  177.05 134.05 90 top
R53  33ohm  [R-0402S0]  173.52 121.33 270 top
R54  4.7K  [R-0402S0]  177.05 136.6 90 top
R55  33ohm  [R-0402S0]  169.92 120.17 90 top
R56  4.7K  [R-0402S0]  177.05 130.23 90 top
R57  4.7K  [R-0402S0]  184.57 130.16 90 top
R58  4.7K  [R-0402S0]  173.52 137.87 90 top
R59  4.7K  [R-0402S0]  173.52 135.32 90 top
R63  4.7K  [R-0402S0]  184.57 125.07 90 top
R64  4.7K  [R-0402S0]  173.52 136.6 90 top
R65  4.7K  [R-0402S0]  177.05 132.78 90 top
R67  4.7K  [R-0402S0]  173.52 130.23 90 top
R68  4.7K  [R-0402S0]  177.05 131.51 90 top
R69  4.7K  [R-0402S0]  177.05 135.32 90 top
R70  33ohm  [R-0402S0]  173.52 122.6 90 top
R71  33ohm  [R-0402S0]  179.71 117.86 0 bottom
R75  4.53Kohm  [S-R-0402]  204.86 112.99 270 bottom
R77  4.53Kohm  [S-R-0402]  223.36 114.5 180 bottom
R83  40.2ohm  [R-0402S0]  206.29 170.54 0 top
R84  40.2ohm  [R-0402S0]  200.18 170.54 180 bottom
R85  40.2ohm  [R-0402S0]  211.56 170.54 180 bottom
R86  40.2ohm  [R-0402S0]  210.36 170.54 180 bottom
R87  40.2ohm  [R-0402S0]  200.18 170.54 0 top
R88  40.2ohm  [R-0402S0]  207.31 170.54 0 top
R89  40.2ohm  [R-0402S0]  201.2 170.54 0 top
R90  40.2ohm  [R-0402S0]  209.35 170.54 180 bottom
R91  40.2ohm  [R-0402S0]  202.22 170.54 0 top
R92  40.2ohm  [R-0402S0]  199.16 170.54 180 bottom
R93  33ohm  [R-0402S0]  209.35 170.54 0 top
R94  40.2ohm  [R-0402S0]  205.27 170.54 0 top
R95  100  [R-0402S0]  209.3 163.45 0 bottom
R96  40.2ohm  [R-0402S0]  203.23 170.54 0 top
R97  100  [R-0402S0]  220.47 165.43 180 bottom
R98  40.2ohm  [R-0402S0]  199.16 170.54 0 top
R99  40.2ohm  [R-0402S0]  207.31 170.54 180 bottom
R100  100  [R-0402S0]  208.28 164.21 0 bottom
R101  40.2ohm  [R-0402S0]  202.22 170.54 180 bottom
R102  100  [R-0402S0]  220.47 163.7 180 bottom
R103  4.7K  [R-0402S0]  198.48 164.87 0 bottom
R104  240  [R-0402S0]  198.41 157.84 180 bottom
R105  40.2ohm  [R-0402S0]  204.25 170.54 0 top
R106  4.7K  [R-0402S0]  210.66 165.45 0 bottom
R107  40.2ohm  [R-0402S0]  203.23 170.54 180 bottom
R108  240  [R-0402S0]  210.63 158.09 180 bottom
R109  40.2ohm  [R-0402S0]  212.76 170.54 180 bottom
R110  40.2ohm  [R-0402S0]  201.2 170.54 180 bottom
R111  40.2ohm  [R-0402S0]  208.33 170.54 180 bottom
R112  40.2ohm  [R-0402S0]  208.33 170.54 0 top
R113  40.2ohm  [R-0402S0]  204.25 170.54 180 bottom
R114  40.2ohm  [R-0402S0]  214.44 170.57 0 top
R115  40.2ohm  [R-0402S0]  205.27 170.54 180 bottom
R116  40.2ohm  [R-0402S0]  206.29 170.54 180 bottom
R117  40.2ohm  [R-0402S0]  202.2 162.29 90 bottom
R118  40.2ohm  [R-0402S0]  202.2 161.35 90 bottom
R123  4.7K  [R-0402S0]  210.36 170.57 0 top
R124  40.2ohm  [S-R-0402]  210.86 129.01 270 bottom
R125  60.4ohm  [S-R-0402]  210.86 130.01 270 bottom
R126  40.2ohm  [R-0402S0]  243.3 170.57 0 top
R127  40.2ohm  [R-0402S0]  237.19 170.57 0 top
R128  40.2ohm  [R-0402S0]  245.21 170.57 180 bottom
R129  40.2ohm  [R-0402S0]  238.21 170.57 0 top
R130  40.2ohm  [R-0402S0]  242.28 170.57 0 top
R131  40.2ohm  [R-0402S0]  236.04 170.57 180 bottom
R132  40.2ohm  [R-0402S0]  247.25 170.57 180 bottom
R133  40.2ohm  [R-0402S0]  235.02 170.57 180 bottom
R134  40.2ohm  [R-0402S0]  246.23 170.57 180 bottom
R135  40.2ohm  [R-0402S0]  236.17 170.57 0 top
R136  40.2ohm  [R-0402S0]  241.26 170.57 0 top
R137  33ohm  [R-0402S0]  245.34 170.57 0 top
R138  100  [R-0402S0]  248.41 163.19 0 bottom
R139  40.2ohm  [R-0402S0]  239.23 170.57 0 top
R140  100  [R-0402S0]  236.09 162.94 90 bottom
R141  40.2ohm  [R-0402S0]  235.15 170.57 0 top
R142  100  [R-0402S0]  247.4 163.96 0 bottom
R143  40.2ohm  [R-0402S0]  243.17 170.57 180 bottom
R144  40.2ohm  [R-0402S0]  238.08 170.57 180 bottom
R145  100  [R-0402S0]  236.09 163.96 270 bottom
R146  4.7K  [R-0402S0]  234.01 170.57 180 bottom
R147  240  [R-0402S0]  237.54 158.09 180 bottom
R148  40.2ohm  [R-0402S0]  239.1 170.57 180 bottom
R149  40.2ohm  [R-0402S0]  240.24 170.57 0 top
R150  4.7K  [R-0402S0]  225.01 165.5 270 bottom
R151  240  [R-0402S0]  225.07 158.42 90 bottom
R152  40.2ohm  [R-0402S0]  248.27 170.57 180 bottom
R153  40.2ohm  [R-0402S0]  237.06 170.57 180 bottom
R154  40.2ohm  [R-0402S0]  244.19 170.57 180 bottom
R155  40.2ohm  [R-0402S0]  244.32 170.57 0 top
R156  40.2ohm  [R-0402S0]  240.12 170.57 180 bottom
R157  40.2ohm  [R-0402S0]  231.08 170.57 0 top
R158  40.2ohm  [R-0402S0]  241.14 170.57 180 bottom
R159  40.2ohm  [R-0402S0]  242.15 170.57 180 bottom
R160  40.2ohm  [R-0402S0]  241.92 160.87 90 bottom
R161  40.2ohm  [R-0402S0]  241.92 161.82 90 bottom
R166  4.7K  [R-0402S0]  246.36 170.57 0 top
R167  40.2ohm  [R-0402S0]  266.4 129.46 270 top
R168  40.2ohm  [R-0402S0]  266.4 135.26 270 top
R169  40.2ohm  [R-0402S0]  266.4 134.3 270 top
R170  40.2ohm  [R-0402S0]  266.4 127.52 90 bottom
R171  33ohm  [R-0402S0]  266.4 138.17 270 top
R172  40.2ohm  [R-0402S0]  266.4 128.49 90 bottom
R173  40.2ohm  [R-0402S0]  266.4 136.23 270 top
R174  40.2ohm  [R-0402S0]  266.4 129.46 90 bottom
R175  40.2ohm  [R-0402S0]  266.4 130.43 270 top
R176  40.2ohm  [R-0402S0]  266.4 138.17 90 bottom
R177  40.2ohm  [R-0402S0]  266.4 131.39 270 top
R178  40.2ohm  [R-0402S0]  266.4 127.52 270 top
R179  100  [R-0402S0]  260.1 115.95 90 bottom
R180  40.2ohm  [R-0402S0]  266.4 133.33 270 top
R181  100  [R-0402S0]  259.33 127.56 270 bottom
R182  33ohm  [R-0402S0]  266.4 137.2 270 top
R183  40.2ohm  [R-0402S0]  266.4 131.39 90 bottom
R184  100  [R-0402S0]  260.1 116.97 270 bottom
R185  40.2ohm  [R-0402S0]  266.4 136.23 90 bottom
R186  100  [R-0402S0]  260.02 128.52 270 bottom
R187  40.2ohm  [R-0402S0]  266.4 135.26 90 bottom
R188  4.7K  [R-0402S0]  261.46 123.51 90 bottom
R189  240  [R-0402S0]  254.29 127.04 0 bottom
R190  40.2ohm  [R-0402S0]  266.4 132.36 270 top
R191  4.7K  [R-0402S0]  261.28 138.3 270 bottom
R192  240  [R-0402S0]  253.86 138.44 90 bottom
R193  40.2ohm  [R-0402S0]  266.38 126.55 90 bottom
R194  40.2ohm  [R-0402S0]  266.4 137.2 90 bottom
R195  40.2ohm  [R-0402S0]  266.4 130.42 90 bottom
R196  40.2ohm  [R-0402S0]  266.4 128.49 270 top
R197  40.2ohm  [R-0402S0]  266.4 123.6 270 top
R198  40.2ohm  [R-0402S0]  266.4 134.3 90 bottom
R199  40.2ohm  [R-0402S0]  266.4 133.33 90 bottom
R200  40.2ohm  [R-0402S0]  266.4 132.36 90 bottom
R201  40.2ohm  [R-0402S0]  257.31 134.48 0 bottom
R202  40.2ohm  [R-0402S0]  258.26 134.48 0 bottom
R207  4.7K  [R-0402S0]  266.38 125.53 90 bottom
R208  40.2ohm  [S-R-0402]  224.36 127.5 0 bottom
R209  60.4ohm  [S-R-0402]  223.37 129.5 0 bottom
R254  4.7Kohm  [R-0402S0]  204.76 12.43 270 bottom
R255  33ohm  [R-0402S0]  204.78 9.78 270 bottom
R256  33ohm  [R-0402S0]  215.54 13.12 90 bottom
R257  33ohm  [R-0402S0]  215.54 12.11 90 bottom
R258  33ohm  [R-0402S0]  215.54 11.01 90 bottom
R259  33ohm  [R-0402S0]  212.47 18.29 180 bottom
R260  33ohm  [R-0402S0]  211.2 18.29 180 bottom
R261  33ohm  [R-0402S0]  209.93 18.29 180 bottom
R262  33ohm  [R-0402S0]  208.66 18.29 180 bottom
R263  4.7Kohm  [R-0402S0]  249.81 7.37 0 bottom
R264  33ohm  [R-0402S0]  250.82 7.37 0 bottom
R265  33ohm  [R-0402S0]  251.97 7.37 0 bottom
R266  33ohm  [R-0402S0]  253.11 7.37 0 bottom
R267  33ohm  [R-0402S0]  254.38 7.37 0 bottom
R268  33ohm  [R-0402S0]  253.81 19.43 180 bottom
R269  33ohm  [R-0402S0]  252.51 19.43 180 bottom
R270  4.7Kohm  [R-0402S0]  251.21 19.43 180 bottom
R271  4.7Kohm  [R-0402S0]  249.91 19.43 180 bottom
R272  49.9  [R-0402S0]  118.16 95.67 90 bottom
R273  49.9  [R-0402S0]  117.51 98.59 90 top
R274  49.9  [R-0402S0]  118.16 96.68 90 bottom
R275  49.9  [R-0402S0]  117.51 99.6 90 top
R276  4.7K  [R-0402S0]  114.34 94.1 270 bottom
R277  0ohm  [R-0402S0]  140.94 100.39 90 top
R278  4.7K  [R-0402S0]  114.25 95.35 270 bottom
R279  4.7K  [R-0402S0]  123.21 100.69 90 bottom
R280  4.7K  [R-0402S0]  117.48 87.79 90 top
R281  0ohm  [R-0402S0]  140.92 101.38 90 top
R282  4.7K  [R-0402S0]  140.92 97.57 90 top
R283  1Kohm  [R-0402S0]  140.92 98.84 270 top
R284  1Kohm  [R-0402S0]  140.92 96.29 270 top
R286  4.7K  [R-0402S0]  136.68 94.09 270 bottom
R298  1Kohm  [R-0402S0]  184.57 123.8 90 top
R299  1Kohm  [R-0402S0]  184.57 122.53 90 top
R300  1Kohm  [R-0402S0]  170.17 131.63 90 top
R301  1Kohm  [R-0402S0]  187.98 120.29 270 top
R302  4.7K  [R-0402S0]  275.01 105.45 0 top
R303  4.7K  [R-0402S0]  289.09 105.87 0 top
R304  4.7K  [R-0402S0]  290.2 105.87 0 top
R305  4.7K  [R-0402S0]  292.28 105.87 0 top
R306  4.7K  [R-0402S0]  283.97 100.84 180 bottom
R307  0ohm  [R-0402S0]  296.84 87.5 270 top
R308  0ohm  [R-0402S0]  296.84 88.67 270 top
R309  4.7K  [R-0402S0]  296.84 86.37 90 top
R310  4.7K  [S-R-0402]  277.6 90.39 0 bottom
R311  4.7K  [R-0402S0]  296.84 85.2 270 top
R312  4.7Kohm  [R-0402S0]  109.24 38.87 0 bottom
R313  4.7Kohm  [R-0402S0]  139.83 36.58 0 bottom
R314  4.7Kohm  [R-0402S0]  123.28 38.87 0 bottom
R315  4.7Kohm  [R-0402S0]  151.96 38.87 0 bottom
R316  4.7Kohm  [R-0402S0]  181.04 38.87 0 bottom
R317  150ohm  [R-0402S0]  83.08 58.93 0 bottom
R318  150ohm  [R-0402S0]  84.2 58.93 0 bottom
R319  4.7Kohm  [R-0402S0]  109.24 36.58 180 bottom
R320  4.7Kohm  [R-0402S0]  137.29 38.87 180 bottom
R321  4.7Kohm  [R-0402S0]  123.28 36.58 180 bottom
R322  4.7Kohm  [R-0402S0]  151.96 36.58 180 bottom
R323  4.7Kohm  [R-0402S0]  181.04 36.58 180 bottom
R324  150ohm  [R-0402S0]  99.95 43.13 270 bottom
R325  150ohm  [R-0402S0]  99.95 44.14 270 bottom
R326  4.7Kohm  [R-0402S0]  107.86 38.87 0 bottom
R327  4.7Kohm  [R-0402S0]  136.27 38.87 180 bottom
R328  4.7Kohm  [R-0402S0]  121.91 38.87 0 bottom
R329  4.7Kohm  [R-0402S0]  150.58 38.87 0 bottom
R330  4.7Kohm  [R-0402S0]  179.67 38.87 0 bottom
R331  150ohm  [R-0402S0]  99.95 45.16 270 bottom
R332  150ohm  [R-0402S0]  99.95 46.17 270 bottom
R333  4.7Kohm  [R-0402S0]  107.86 36.58 180 bottom
R334  4.7Kohm  [R-0402S0]  135.26 38.87 180 bottom
R335  4.7Kohm  [R-0402S0]  121.91 36.58 180 bottom
R336  4.7Kohm  [R-0402S0]  150.58 36.58 180 bottom
R337  4.7Kohm  [R-0402S0]  179.67 36.58 180 bottom
R338  150ohm  [R-0402S0]  113.97 43.09 270 bottom
R339  150ohm  [R-0402S0]  113.97 44.1 270 bottom
R340  4.7Kohm  [R-0402S0]  106.49 38.87 0 bottom
R341  4.7Kohm  [R-0402S0]  134.24 38.87 180 bottom
R342  4.7Kohm  [R-0402S0]  120.53 38.87 0 bottom
R343  4.7Kohm  [R-0402S0]  149.21 38.87 0 bottom
R344  4.7Kohm  [R-0402S0]  178.29 38.87 0 bottom
R345  150ohm  [R-0402S0]  113.97 45.12 270 bottom
R346  150ohm  [R-0402S0]  113.97 46.13 270 bottom
R347  4.7Kohm  [R-0402S0]  106.49 36.58 180 bottom
R348  4.7Kohm  [R-0402S0]  133.1 38.87 180 bottom
R349  4.7Kohm  [R-0402S0]  120.53 36.58 180 bottom
R350  4.7Kohm  [R-0402S0]  149.21 36.58 180 bottom
R351  4.7Kohm  [R-0402S0]  178.29 36.58 180 bottom
R352  150ohm  [R-0402S0]  128.32 43.14 270 bottom
R353  150ohm  [R-0402S0]  128.32 44.16 270 bottom
R354  4.7Kohm  [R-0402S0]  105.11 38.87 0 bottom
R355  4.7Kohm  [R-0402S0]  132.08 38.87 180 bottom
R356  4.7Kohm  [R-0402S0]  119.16 38.87 0 bottom
R357  4.7Kohm  [R-0402S0]  147.83 38.87 0 bottom
R358  4.7Kohm  [R-0402S0]  176.92 38.87 0 bottom
R359  150ohm  [R-0402S0]  128.32 45.17 270 bottom
R360  150ohm  [R-0402S0]  128.32 46.19 270 bottom
R361  4.7Kohm  [R-0402S0]  105.11 36.58 180 bottom
R362  4.7Kohm  [R-0402S0]  131.06 38.87 180 bottom
R363  4.7Kohm  [R-0402S0]  119.16 36.58 180 bottom
R364  4.7Kohm  [R-0402S0]  147.83 36.58 180 bottom
R365  4.7Kohm  [R-0402S0]  176.92 36.58 180 bottom
R366  150ohm  [R-0402S0]  142.75 43.21 270 bottom
R367  150ohm  [R-0402S0]  142.75 44.22 270 bottom
R368  4.7Kohm  [R-0402S0]  104.25 24.13 0 bottom
R369  4.7Kohm  [R-0402S0]  131.45 19.69 0 bottom
R370  4.7Kohm  [R-0402S0]  118.3 24.13 0 bottom
R371  4.7Kohm  [R-0402S0]  146.97 24.13 0 bottom
R372  4.7Kohm  [R-0402S0]  176.05 24.13 0 bottom
R373  150ohm  [R-0402S0]  142.75 45.24 270 bottom
R374  150ohm  [R-0402S0]  142.75 46.26 270 bottom
R375  4.7Kohm  [R-0402S0]  105.62 24.13 0 bottom
R376  4.7Kohm  [R-0402S0]  132.46 19.69 0 bottom
R377  4.7Kohm  [R-0402S0]  119.67 24.13 0 bottom
R378  4.7Kohm  [R-0402S0]  148.34 24.13 0 bottom
R379  4.7Kohm  [R-0402S0]  177.43 24.13 0 bottom
R380  150ohm  [R-0402S0]  156.82 43.13 270 bottom
R381  150ohm  [R-0402S0]  156.82 44.15 270 bottom
R382  4.7Kohm  [R-0402S0]  107 24.13 0 bottom
R383  4.7Kohm  [R-0402S0]  133.48 19.69 0 bottom
R384  4.7Kohm  [R-0402S0]  121.04 24.13 0 bottom
R385  4.7Kohm  [R-0402S0]  149.72 24.13 0 bottom
R386  4.7Kohm  [R-0402S0]  178.8 24.13 0 bottom
R387  150ohm  [R-0402S0]  156.82 45.16 270 bottom
R388  150ohm  [R-0402S0]  156.82 46.18 270 bottom
R389  4.7Kohm  [R-0402S0]  113.03 20.52 0 bottom
R390  4.7Kohm  [R-0402S0]  134.49 19.69 0 bottom
R391  4.7Kohm  [R-0402S0]  121.04 21.12 180 bottom
R392  4.7Kohm  [R-0402S0]  149.72 21.12 180 bottom
R393  4.7Kohm  [R-0402S0]  178.8 21.12 180 bottom
R394  150ohm  [R-0402S0]  171.25 43.26 270 bottom
R395  150ohm  [R-0402S0]  171.25 44.27 270 bottom
R396  4.7Kohm  [R-0402S0]  108.37 24.13 0 bottom
R397  4.7Kohm  [R-0402S0]  135.51 19.69 0 bottom
R398  4.7Kohm  [R-0402S0]  122.42 24.13 0 bottom
R399  4.7Kohm  [R-0402S0]  151.09 24.13 0 bottom
R400  4.7Kohm  [R-0402S0]  180.18 24.13 0 bottom
R401  150ohm  [R-0402S0]  171.25 45.29 270 bottom
R402  150ohm  [R-0402S0]  171.25 46.31 270 bottom
R403  4.7Kohm  [R-0402S0]  111.55 20.49 180 bottom
R404  4.7Kohm  [R-0402S0]  136.63 19.69 0 bottom
R405  4.7Kohm  [R-0402S0]  122.42 21.12 180 bottom
R406  4.7Kohm  [R-0402S0]  151.09 21.12 180 bottom
R407  4.7Kohm  [R-0402S0]  180.18 21.12 180 bottom
R408  150ohm  [R-0402S0]  185.4 43.28 270 bottom
R409  150ohm  [R-0402S0]  185.4 44.3 270 bottom
R410  4.7Kohm  [R-0402S0]  109.75 24.13 0 bottom
R411  4.7Kohm  [R-0402S0]  137.65 19.69 0 bottom
R412  4.7Kohm  [R-0402S0]  123.79 24.13 0 bottom
R413  4.7Kohm  [R-0402S0]  152.47 24.13 0 bottom
R414  4.7Kohm  [R-0402S0]  181.42 21.09 0 bottom
R415  150ohm  [R-0402S0]  185.4 45.32 270 bottom
R416  150ohm  [R-0402S0]  185.4 46.33 270 bottom
R417  4.7Kohm  [R-0402S0]  109.87 20.49 180 bottom
R418  4.7Kohm  [R-0402S0]  139.96 19.69 180 bottom
R419  4.7Kohm  [R-0402S0]  123.79 21.12 180 bottom
R420  4.7Kohm  [R-0402S0]  152.43 21.09 180 bottom
R421  4.7Kohm  [R-0402S0]  183.26 20.77 180 bottom
R422  150ohm  [R-0402S0]  198.33 53.95 270 bottom
R423  150ohm  [R-0402S0]  198.33 55.02 270 bottom
R424  4.7Kohm  [R-0402S0]  237.67 20.97 0 bottom
R425  4.7Kohm  [R-0402S0]  191.07 19.19 0 bottom
R426  4.7Kohm  [R-0402S0]  252.46 21.99 0 bottom
R427  4.7Kohm  [R-0402S0]  280.4 7.57 0 bottom
R428  4.7Kohm  [R-0402S0]  209.28 21.35 0 bottom
R429  150ohm  [R-0402S0]  261.49 38.15 180 bottom
R430  150ohm  [R-0402S0]  262.51 38.15 180 bottom
R431  4.7Kohm  [R-0402S0]  239.05 20.97 0 bottom
R432  4.7Kohm  [R-0402S0]  192.08 19.19 0 bottom
R433  4.7Kohm  [R-0402S0]  253.83 21.99 0 bottom
R434  4.7Kohm  [R-0402S0]  281.77 7.57 0 bottom
R435  4.7Kohm  [R-0402S0]  210.65 21.35 0 bottom
R436  150ohm  [R-0402S0]  272.8 37.17 180 bottom
R437  150ohm  [R-0402S0]  271.78 37.17 180 bottom
R438  4.7Kohm  [R-0402S0]  240.42 20.97 0 bottom
R439  4.7Kohm  [R-0402S0]  193.1 19.19 0 bottom
R440  4.7Kohm  [R-0402S0]  255.2 21.99 0 bottom
R441  4.7Kohm  [R-0402S0]  283.14 7.57 0 bottom
R442  4.7Kohm  [R-0402S0]  212.02 21.35 0 bottom
R443  150ohm  [R-0402S0]  273.81 37.36 180 bottom
R444  150ohm  [R-0402S0]  274.83 37.36 180 bottom
R445  4.7Kohm  [R-0402S0]  241.82 21.06 0 bottom
R446  4.7Kohm  [R-0402S0]  194.11 19.19 0 bottom
R447  4.7Kohm  [R-0402S0]  256.35 21.95 0 bottom
R448  4.7Kohm  [R-0402S0]  284.42 7.54 0 bottom
R449  4.7Kohm  [R-0402S0]  213.3 21.42 0 bottom
R450  150ohm  [R-0402S0]  291.37 42.11 180 bottom
R451  150ohm  [R-0402S0]  290.35 42.11 180 bottom
R536  4.7Kohm  [R-0402S0]  240.8 37.86 0 bottom
R537  4.7Kohm  [R-0402S0]  196.8 36.18 0 bottom
R538  4.7Kohm  [R-0402S0]  255.16 37.86 0 bottom
R539  4.7Kohm  [R-0402S0]  286.89 19.91 90 bottom
R540  4.7Kohm  [R-0402S0]  211.85 37.86 0 bottom
R541  150ohm  [R-0402S0]  202.05 61.18 0 bottom
R542  150ohm  [R-0402S0]  203.07 61.18 0 bottom
R543  4.7Kohm  [R-0402S0]  240.8 35.58 180 bottom
R544  4.7Kohm  [R-0402S0]  194.75 38.75 180 bottom
R545  4.7Kohm  [R-0402S0]  255.16 35.58 180 bottom
R546  4.7Kohm  [R-0402S0]  286.83 18.84 90 bottom
R547  4.7Kohm  [R-0402S0]  211.85 35.58 180 bottom
R548  150ohm  [R-0402S0]  218.44 37.99 180 bottom
R549  150ohm  [R-0402S0]  218.44 39.88 180 bottom
R550  4.7Kohm  [R-0402S0]  239.43 37.86 0 bottom
R551  4.7Kohm  [R-0402S0]  193.73 38.75 180 bottom
R552  4.7Kohm  [R-0402S0]  253.78 37.86 0 bottom
R553  4.7Kohm  [R-0402S0]  284.55 19.94 180 bottom
R554  4.7Kohm  [R-0402S0]  210.47 37.86 0 bottom
R555  150ohm  [R-0402S0]  218.35 41.39 270 bottom
R556  150ohm  [R-0402S0]  218.31 42.42 270 bottom
R557  4.7Kohm  [R-0402S0]  239.43 35.58 180 bottom
R558  4.7Kohm  [R-0402S0]  192.72 38.75 180 bottom
R559  4.7Kohm  [R-0402S0]  253.78 35.58 180 bottom
R560  4.7Kohm  [R-0402S0]  283.42 19.94 180 bottom
R561  4.7Kohm  [R-0402S0]  210.47 35.58 180 bottom
R562  150ohm  [R-0402S0]  229.9 37.29 180 bottom
R563  150ohm  [R-0402S0]  230.92 37.29 180 bottom
R564  4.7Kohm  [R-0402S0]  238.06 37.86 0 bottom
R565  4.7Kohm  [R-0402S0]  191.7 38.75 180 bottom
R566  4.7Kohm  [R-0402S0]  252.41 37.86 0 bottom
R567  4.7Kohm  [R-0402S0]  282.29 19.99 180 bottom
R568  4.7Kohm  [R-0402S0]  209.1 37.86 0 bottom
R569  150ohm  [R-0402S0]  232.3 37.6 270 bottom
R570  150ohm  [R-0402S0]  232.46 42.13 180 bottom
R571  4.7Kohm  [R-0402S0]  238.06 35.58 180 bottom
R572  4.7Kohm  [R-0402S0]  190.69 39.01 180 bottom
R573  4.7Kohm  [R-0402S0]  252.41 35.58 180 bottom
R574  4.7Kohm  [R-0402S0]  281.24 20.02 180 bottom
R575  4.7Kohm  [R-0402S0]  209.1 35.58 180 bottom
R576  150ohm  [R-0402S0]  245.32 37.45 180 bottom
R577  150ohm  [R-0402S0]  246.33 37.45 180 bottom
R578  4.7Kohm  [R-0402S0]  236.68 37.86 0 bottom
R579  4.7Kohm  [R-0402S0]  189.67 38.75 180 bottom
R580  4.7Kohm  [R-0402S0]  251.03 37.86 0 bottom
R581  4.7Kohm  [R-0402S0]  280.05 20.02 180 bottom
R582  4.7Kohm  [R-0402S0]  207.77 35.53 180 bottom
R583  150ohm  [R-0402S0]  247.34 37.73 180 bottom
R584  150ohm  [R-0402S0]  246.51 42.31 270 bottom
R585  4.7Kohm  [R-0402S0]  236.68 35.58 180 bottom
R586  4.7Kohm  [R-0402S0]  188.65 38.75 180 bottom
R587  4.7Kohm  [R-0402S0]  251.03 35.58 180 bottom
R588  4.7Kohm  [R-0402S0]  278.97 20.02 180 bottom
R589  4.7Kohm  [R-0402S0]  206.46 35.5 180 bottom
R590  150ohm  [R-0402S0]  259.4 37.37 180 bottom
R591  150ohm  [R-0402S0]  260.42 37.37 180 bottom
R592  0ohm  [R-0402S0]  300.83 46.02 0 bottom
R593  0ohm  [R-0402S0]  302.1 46.02 0 bottom
R594  4.7Kohm  [R-0402S0]  267.88 37.86 0 bottom
R595  4.7Kohm  [R-0402S0]  266.27 37.86 0 bottom
R596  4.7Kohm  [R-0402S0]  268.11 23 0 bottom
R597  4.7Kohm  [R-0402S0]  267.88 35.58 180 bottom
R598  4.7Kohm  [R-0402S0]  266.27 35.58 180 bottom
R599  4.7Kohm  [R-0402S0]  269.35 23.07 0 bottom
R600  4.7Kohm  [R-0402S0]  265.36 23 180 bottom
R601  4.7Kohm  [R-0402S0]  266.7 23 180 bottom
R602  150ohm  [R-0402S0]  297.02 46.02 180 bottom
R603  150ohm  [R-0402S0]  298.17 19.1 0 bottom
R604  150ohm  [R-0402S0]  295.75 46.02 180 bottom
R605  150ohm  [R-0402S0]  296.9 19.1 0 bottom
R606  24Kohm  [R-0402S0]  92.74 73.85 270 bottom
R607  24Kohm  [R-0402S0]  157 73.85 270 bottom
R608  24Kohm  [R-0402S0]  233.18 73.85 270 bottom
R609  24Kohm  [R-0402S0]  104.82 73.85 270 bottom
R610  24Kohm  [R-0402S0]  169.07 73.85 270 bottom
R611  24Kohm  [R-0402S0]  245.25 73.85 270 bottom
R612  24Kohm  [R-0402S0]  116.9 73.59 270 bottom
R613  24Kohm  [R-0402S0]  181.15 73.85 270 bottom
R614  24Kohm  [R-0402S0]  257.42 73.89 270 bottom
R615  24Kohm  [R-0402S0]  128.97 73.59 270 bottom
R616  24Kohm  [R-0402S0]  209.02 73.85 270 bottom
R617  24Kohm  [R-0402S0]  272.04 74.27 270 bottom
R618  24Kohm  [R-0402S0]  144.92 73.85 270 bottom
R619  24Kohm  [R-0402S0]  221.1 73.85 270 bottom
R622  24Kohm  [R-0402S0]  306.22 86.39 90 bottom
R623  4.7Kohm  [R-0402S0]  116.72 80.97 270 top
R624  0ohm  [R-0402S0]  114.87 80.32 180 top
R625  0ohm  [R-0402S0]  115.88 79.5 0 top
R627  0ohm  [R-0402S0]  116.9 79.5 0 top
R628  0ohm  [R-0402S0]  117.92 79.5 0 top
R629  0ohm  [R-0402S0]  162.29 77.6 0 top
R630  0ohm  [R-0402S0]  163.3 77.6 0 top
R631  0ohm  [R-0402S0]  164.3 77.6 0 top
R632  0ohm  [R-0402S0]  164.72 79.01 90 top
R633  0ohm  [R-0402S0]  224.89 79.5 0 top
R635  4.7Kohm  [R-0402S0]  224.89 81.41 0 top
R636  0ohm  [R-0402S0]  226.16 79.5 0 top
R637  0ohm  [R-0402S0]  227.68 79.5 0 top
R638  0ohm  [R-0402S0]  228.95 79.5 0 top
R639  0ohm  [R-0402S0]  271.65 78.35 180 bottom
R640  0ohm  [R-0402S0]  272.62 78.36 180 bottom
R646  4.7Kohm  [R-0402S0]  124.82 126.26 270 top
R649  0ohm  [R-0402S0]  106.49 124.03 270 top
R650  0ohm  [R-0402S0]  106.49 129.6 270 top
R651  4.7Kohm  [R-0402S0]  171.78 36.58 180 bottom
R652  4.7Kohm  [R-0402S0]  142.7 36.58 180 bottom
R653  0ohm  [R-0402S0]  171.46 20.61 0 bottom
R654  0ohm  [R-0402S0]  145.55 20.99 0 bottom
R655  0ohm  [R-0402S0]  170.33 20.53 0 bottom
R656  4.7Kohm  [R-0402S0]  173.51 24.13 0 bottom
R657  4.7Kohm  [R-0402S0]  173.03 36.58 180 bottom
R658  4.7Kohm  [R-0402S0]  174.83 38.87 180 bottom
R659  0ohm  [R-0402S0]  144.45 20.96 0 bottom
R660  4.7Kohm  [R-0402S0]  147.02 20.96 0 bottom
R661  4.7Kohm  [R-0402S0]  143.94 36.58 180 bottom
R662  4.7Kohm  [R-0402S0]  146.01 39.86 270 bottom
R663  4.7Kohm  [R-0402S0]  174.68 24.13 180 bottom
R664  4.7Kohm  [R-0402S0]  174.17 36.58 0 bottom
R665  4.7Kohm  [R-0402S0]  175.54 36.58 0 bottom
R666  4.7Kohm  [R-0402S0]  145.6 24.13 180 bottom
R667  4.7Kohm  [R-0402S0]  145.09 36.58 0 bottom
R668  4.7Kohm  [R-0402S0]  146.46 36.58 0 bottom
R669  4.7Kohm  [R-0402S0]  202.84 35.58 180 bottom
R670  4.7Kohm  [R-0402S0]  272.29 19.26 180 bottom
R671  0ohm  [R-0402S0]  205.32 21.39 0 bottom
R672  0ohm  [R-0402S0]  276.44 7.61 0 bottom
R673  0ohm  [R-0402S0]  203.96 21.35 0 bottom
R674  4.7Kohm  [R-0402S0]  206.53 21.35 0 bottom
R675  4.7Kohm  [R-0402S0]  203.84 35.58 180 bottom
R676  4.7Kohm  [R-0402S0]  206.58 37.89 180 bottom
R677  0ohm  [R-0402S0]  273.89 12.61 270 bottom
R678  4.7Kohm  [R-0402S0]  277.65 7.57 0 bottom
R679  4.7Kohm  [R-0402S0]  273.43 19.26 180 bottom
R680  4.7Kohm  [R-0402S0]  276.25 20.02 180 bottom
R681  4.7Kohm  [R-0402S0]  207.9 21.35 180 bottom
R682  4.7Kohm  [R-0402S0]  204.98 35.58 0 bottom
R683  4.7Kohm  [R-0402S0]  207.69 37.89 0 bottom
R684  4.7Kohm  [R-0402S0]  279.02 7.57 180 bottom
R685  4.7Kohm  [R-0402S0]  274.57 19.26 0 bottom
R686  4.7Kohm  [R-0402S0]  277.6 20.02 0 bottom
