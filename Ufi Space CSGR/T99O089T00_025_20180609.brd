# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N65578539: length 4.2
  TOP w0.14: U154.J3 v4(65.73,120.13)
  BOTTOM w0.102: v4(65.73,120.13) 65.83,120.23 65.83,123.04 TP82.1
N65578541: length 3.3
  TOP w0.14: U154.K5 v4(64.93,118.53)
  BOTTOM w0.102: TP81.1 64.53,120.87 64.53,118.93 v4(64.93,118.53)
N65578543: length 4.7
  TOP w0.102: U154.J4 v4(65.73,119.33)
  BOTTOM w0.102: v4(65.73,119.33) 66.12,119.72 66.12,122.48 TP80.1
N65578545: length 4.6
  TOP w0.14: U154.J5 v4(65.73,118.53)
  BOTTOM w0.102: TP79.1 65.33,122.04 65.33,118.92 v4(65.73,118.53)
N65578551: length 9.1
  TOP w0.14: U154.E13 v4(68.93,111.33)
  BOTTOM w0.102: v4(68.93,111.33) 69.33,111.73 69.33,112.29 69.88,112.83 72.54,112.83 73.33,113.63 73.89,113.63
  BOTTOM w0.14: 73.89,113.63 75.25,113.63 TP84.1
N65578553: length 10.9
  TOP w0.14: U154.A14 73.53,110.93 74.24,111.63 80.64,111.63 v1(81.03,112.01)
  BOTTOM w0.14: TP83.1 82.02,111.8 81.24,111.8 v1(81.03,112.01)
N65578559: length 8.7
  TOP w0.14: U154.C13 v4(70.53,111.33)
  BOTTOM w0.102: 75.69,111.06 73.31,111.06 72.91,111.45 71.99,111.45 71.87,111.33 v4(70.53,111.33)
  BOTTOM w0.14: TP89.1 76.2,111.56 75.69,111.06
N65578561: length 6.1
  TOP w0.14: U154.D13 v4(69.73,111.33)
  BOTTOM w0.102: 73.66,111.69 73.63,111.72 70.12,111.72 v4(69.73,111.33)
  BOTTOM w0.14: TP87.1 73.66,111.69
N65578594: length 2.6
  TOP w0.14: U154.W2 v4(57.73,120.93)
  BOTTOM w0.14: TP69.1 56.64,122.01 v4(57.73,120.93)
N65578597: length 6.7
  TOP w0.102: U154.V3 v4(57.73,120.13)
  BOTTOM w0.102: 56.1,122.21 56.1,120.82 56.39,120.52 57.33,120.52 v4(57.73,120.13)
  BOTTOM w0.14: R12343.1 55.24,123.42 TP66.1 55.24,123.06 56.1,122.21
N65578809: length 14.1
  TOP w0.14: v1(81.15,101.53) 80.58,102.11 71.75,102.11 70.13,103.74 U154.C22
  BOTTOM w0.14: TP85.1 v1(81.15,101.53)
N65578811: length 21.9
  TOP w0.14: U154.G18 v4(67.33,107.32)
  T03 w0.102: v4(67.33,107.32) 67.33,107.08 67.73,106.67 67.73,105.55 67.96,105.32 75.14,105.32 75.69,104.78 81.58,104.78 82.42,103.93 v1(84.16,103.93)
  BOTTOM w0.14: v1(84.16,103.93) 84.3,104.07 TP88.1
N65578813: length 9.9
  TOP w0.14: U154.C20 v4(70.53,105.72)
  BOTTOM w0.102: TP93.1 76.96,104.39 76.01,105.34 74.3,105.34 73.35,104.39 71.63,104.39 70.56,105.46 70.56,105.69 v4(70.53,105.72)
N65578815: length 12.1
  TOP w0.14: U154.D19 v4(69.73,106.52)
  BOTTOM w0.102: TP91.1 78.36,103.63 76.4,105.6 74.19,105.6 73.24,104.65 71.76,104.65 70.93,105.47 70.93,105.88 70.69,106.12 70.25,106.12 70.2,106.17 69.84,106.52 v4(69.73,106.52)
N65578822: length 14.2
  TOP w0.14: U154.G19 v4(67.33,106.52)
  BOTTOM w0.102: v4(67.33,106.52) 67.73,106.12 67.73,105.33 67.58,105.18 67.58,103.8 68.69,102.69 71.43,102.69 71.77,102.35 71.77,101.39 71.63,101.25 71.63,97.21 TP90.1
N65578824: length 12.6
  TOP w0.14: U154.B22 72.39,103.07 80.02,103.07 v1(81.03,104.07)
  BOTTOM w0.14: TP86.1 v1(81.03,104.07)
N65578831: length 3.4
  TOP w0.14: U154.E20 v4(68.93,105.72)
  BOTTOM w0.102: TP94.1 68.53,107.72 68.53,106.12 v4(68.93,105.72)
N65578833: length 9.3
  TOP w0.14: U154.C18 v4(70.53,107.32)
  BOTTOM w0.102: TP92.1 78.17,107.31 74.04,107.31 73.91,107.19 71.92,107.19 71.67,106.93 70.92,106.93 v4(70.53,107.32)
N66144514: length 4.5
  TOP w0.381: PU18.3 98.31,208.85 98.51,209.04 ; 98.51,209.04 v5(98.51,209.03) ; 98.51,209.04 98.83,209.36 PC3.2 PR1.2
  BOTTOM w0.381: PR3.1 98.5,209.03 v5(98.51,209.03)
N66148865: length 38.9
  TOP w0.381: PR505.1 PR177.2 146.12,179.77 v1(145.41,180.47)
  T18 w0.305: v1(145.41,180.47) 146.3,181.36 149.1,181.36 150.82,179.63 158.93,179.63 168,170.56 173.61,170.56 173.86,170.81 175.13,170.81 v1(175.41,171.09)
  BOTTOM w0.381: PR175.2 175.35,171.03 v1(175.41,171.09)
N66362177: length 1.5
  TOP w0.508: PR258.2 PC242.1
N66362186: length 3.6
  BOTTOM w0.381: v2(224.31,202.98) PC250.1 225.87,204.77 PR259.2
N68263741: length 4.8
  TOP w0.14: U104.3 33.04,15.64 33.79,16.4 v1(33.79,17.14) R1506.2 R12826.2
N68263783: length 1.7
  TOP w0.14: v1(28.1,17.43) 28.4,17.73 C2398.2 R1503.2
N68263901: length 3.9
  TOP w0.14: C2424.1 R1907.1 R1910.2 16.69,14.41 16.69,14.41 v1(17.14,14.41) U106.1
N68909145:
  vias: v1(40.54,34.61) v1(41.42,34.61) v1(42.31,34.61) v1(44.96,34.54) v1(45.85,34.54) v1(46.74,34.54) v2(40.77,36.96) v2(40.77,35.56) v2(42.29,36.96) v2(42.29,35.56)
N68909205:
  vias: v1(48.9,34.54) v1(49.78,34.54) v1(50.67,34.54) v1(53.34,34.54) v1(54.23,34.54) v1(55.12,34.54) v2(53.34,36.96) v2(53.34,35.56) v2(54.86,36.96) v2(54.86,35.56)
N69918111: length 3
  TOP w0.14: U127.63 63.9,85.95 63.75,86.09 v1(63.75,86.49) 63.87,86.6 U127.62
N69962598: length 2.1
  TOP w0.14: X2.3 R12823.1
N70148679: length 28.1
  TOP w0.14: U97.6 89.14,129.27 89.41,129.54 89.41,130.96 89.81,131.37 R1408.2 U98.6 91.65,132.25 v1(93.09,130.81) 93.09,130.15 96.49,126.76 J20.2 97.92,122.05 99.03,123.16 J20.3
  BOTTOM w0.14: R13036.1 v2(95.76,131.32) 95,130.56 93.34,130.56 v1(93.09,130.81)
N70231673: length 2.9
  BOTTOM w0.104: TP106.1 108.54,170.11 108.18,169.74 108.18,168.04 C2068.2
N70231675: length 2.8
  BOTTOM w0.104: TP105.1 107.91,169.64 107.91,168.03 C2067.2
N70233459: length 23.3
  TOP w0.381: R12710.2 R12699.1 R12827.1 158.55,149.28 155.33,146.06 BAT1.P1 BAT1.P3
N70523844: length 5.2
  TOP w0.104: C2383.2 177.19,153.56 177.4,153.35 177.83,153.35 R1050.2 178.53,153.35 178.97,153.35 R1048.1 179.66,153.36 179.97,153.36 180.48,152.84 180.62,152.84 180.74,152.96 U129.6
N70523859: length 5.2
  TOP w0.104: C2384.2 177.19,152.88 177.39,153.09 177.83,153.09 R1051.2 178.5,153.06 179,153.06 R1049.1 179.68,153.1 179.86,153.1 180.37,152.58 180.62,152.58 180.74,152.46 U129.7
N70532709: length 2
  TOP w0.14: R12485.2 110.52,85.91 v1(111.12,85.91) 112.3,85.91 X4.3
N70701102: length 5
  TOP w0.14: U139.L8 v4(14.43,90.3)
  BOTTOM w0.14: R1663.2 12.13,90.61 v2(12.32,90.42) 12.86,89.88 13.62,89.88 14.04,90.3 v4(14.43,90.3)
N70702856: length 10.5
  TOP w0.14: U139.H9 v4(17.43,89.3)
  BOTTOM w0.14: R1665.2 10.89,92.96 v2(12.32,92.96) 12.53,92.75 16.11,92.75 16.93,91.93 16.93,89.8 17.43,89.31 v4(17.43,89.3)
N70702870: length 3.5
  TOP w0.14: U139.E9 v4(21.43,89.3)
  BOTTOM w0.14: R1666.2 20.07,87.81 20.73,87.81 20.92,88.01 20.92,88.8 v4(21.43,89.3)
N70702946: length 7.5
  TOP w0.104: U139.A8 25.12,90.62 29.85,90.62 v4(30.07,90.84) 30.29,90.62 30.59,90.62 R1672.2
  BOTTOM w0.104: v4(30.07,90.84) 30.23,90.68 30.65,90.68 R1672.2
N70702948: length 8.7
  TOP w0.104: U139.B8 24.38,90.35 29.85,90.35 v4(30.07,90.13) 30.29,90.35 30.59,90.35 R1673.2
  BOTTOM w0.104: R1673.2 30.64,90.3 30.24,90.3 v4(30.07,90.13)
N70703858: length 5.9
  TOP w0.381: U139.D8 v4(22.43,90.3)
  BOTTOM w0.381: v4(22.43,90.3) 22.85,90.72 C2131.1 23.1,90.55 v2(25.99,90.55) 27.18,90.55 C2130.1
N70703933: length 6.8
  TOP w0.381: U139.A9 v4(25.43,89.3) ; U139.C9 v4(23.43,89.3)
  T16 w0.381: v4(25.43,89.3) 25.43,89.57 25.05,89.95 23.81,89.95 23.43,89.57 v4(23.43,89.3)
  BOTTOM w0.381: v4(23.43,89.3) U139.C9 C2129.1 ; C2127.1 25.52,89.21 v4(25.43,89.3) U139.A9 C2128.1
N70911322: length 17.5
  T03 w0.381: v1(14.99,27.95) 10.06,27.95 v1(7.11,30.89)
  BOTTOM w0.381: C1989.2 v1(7.11,30.89) ; C1989.2 R12903.1 ; C1989.2 6.35,29.98 C1987.2 C1988.2 L20.1 ; v1(14.99,27.95) 14.99,28.55 R13007.1 14.03,29.01 Q59.2
N70911341: length 3.1
  TOP w0.14: v1(6.29,34.23) 5.42,33.36 U124.8
  BOTTOM w0.14: v1(6.29,34.23) 6.13,34.07 R1602.2
N70911374: length 2.5
  TOP w0.14: v1(15.73,36.84) 15.77,36.88 U124.19
  BOTTOM w0.14: v1(15.73,36.84) 15.8,36.78 R1606.2
N70911387: length 2.6
  TOP w0.14: U124.18 15.96,35.78 v1(15.73,35.56)
  BOTTOM w0.14: R1605.2 15.81,35.64 v1(15.73,35.56)
N70911689: length 3.3
  TOP w0.14: U124.15 v1(18.54,30.58)
  BOTTOM w0.14: R1609.1 18.52,30.56 v1(18.54,30.58)
N70911698: length 5.4
  TOP w0.381: U124.7 7.06,35.78 8.88,37.61 v1(8.88,37.61)
  BOTTOM w0.381: v1(8.88,37.61) 9.09,37.82 R12822.2
N70911719: length 3.6
  TOP w0.14: U124.1 v1(4.06,42.39)
  BOTTOM w0.14: v1(4.06,42.39) 4.2,42.39 R1610.1 4.93,43.64 R1608.2
N70911732: length 2.7
  TOP w0.14: U124.20 15.95,37.98 v1(15.71,38.23)
  BOTTOM w0.14: v1(15.71,38.23) 16.01,37.92 R1607.2
N70911743: length 2.9
  TOP w0.14: v1(3.94,40.77) 4.52,40.19 U124.3
  BOTTOM w0.14: R1603.2 4.39,40.32 v1(3.94,40.77)
N71580969: length 6.6
  TOP w0.14: U23.J6 v4(128.21,100.36)
  BOTTOM w0.14: v4(128.21,100.36) 127.92,100.36 127.68,100.12 127.68,99.01 126.96,98.3 v2(126.24,98.3) 125.18,98.3 R12797.1 124.01,98.54 R12798.2
N71581462: length 4.3
  TOP w0.14: U23.A8 v4(137.21,98.36)
  BOTTOM w0.14: R1797.1 140.25,99.35 v2(138.56,99.35) 138.21,99.35 v4(137.21,98.36)
N71581465: length 5.7
  TOP w0.14: v4(136.23,98.34) 135.74,97.86 U23.B8
  BOTTOM w0.14: v4(136.23,98.34) 136.23,98.38 v2(137.16,99.31) 137.92,100.08 140.17,100.08 R1798.1
N71581546: length 12.2
  TOP w0.14: U23.C9 v4(135.21,97.36)
  BOTTOM w0.14: R1799.1 141.5,92.34 141.5,95.87 140,97.37 v2(139.78,97.37) 139.69,97.28 137.79,97.28 137.16,96.64 135.93,96.64 v4(135.21,97.36)
N71581548: length 11.8
  TOP w0.14: U23.D9 v4(134.21,97.36)
  BOTTOM w0.14: v4(134.21,97.36) 134.69,96.88 135.25,96.88 135.82,96.32 137.72,96.32 138.22,95.82 139.69,95.82 v2(140.4,95.82) 141.14,95.07 141.14,92.39 R1800.1
N71581627: length 10.6
  TOP w0.102: U23.F9 v4(132.21,96.36)
  BOTTOM w0.14: R1801.1 138.48,94.06 v2(138.13,94.4) 138.13,95.08 137.53,95.67 135.64,95.67 134.97,96.35 134.03,96.35 133.74,96.64 132.49,96.64 v4(132.21,96.36)
N71581629: length 11.9
  TOP w0.14: U23.E9 v4(133.21,97.36)
  BOTTOM w0.14: R1802.1 140.38,92.77 140.38,94.47 140.37,94.48 v2(140.37,94.51) 140.37,94.66 139.5,95.52 138.1,95.52 137.62,96 135.73,96 135.11,96.62 134.26,96.62 133.53,97.36 v4(133.21,97.36)
N71581714: length 24.8
  TOP w0.14: v1(115.71,95.68) 115.27,95.25 R1803.1 ; U23.B9 135.73,96.86 136.24,97.37 v4(136.24,97.38)
  T03 w0.117: v1(115.71,95.68) 116.52,94.87 135.64,94.87 136.24,95.47 v4(136.24,97.38)
N71581716: length 5.3
  TOP w0.14: U23.A9 137.14,97.28 138.43,97.28 138.86,96.85 138.86,95.96 139.52,95.31 R1804.1
N71581908: length 11.4
  TOP w0.14: v4(123.22,97.29) 123.71,97.79 U23.P8
  T05 w0.117: v1(121.69,88.37) 121.69,95.76 v4(123.22,97.29)
  BOTTOM w0.14: R1805.1 121.69,87.27 v1(121.69,88.37)
N71581910: length 16.3
  TOP w0.14: R1806.1 125.39,83.36 v1(125.59,83.57) ; U23.N8 v4(124.21,97.36)
  T05 w0.117: v1(125.59,83.57) 125.1,84.06 125.1,88.69 124.7,89.09 124.7,96.92 124.26,97.36 v4(124.21,97.36)
N71581930: length 12.5
  TOP w0.14: U23.K9 v4(127.21,96.36)
  BOTTOM w0.14: R1807.1 118.93,90.86 v2(120.14,92.08) 120.9,92.84 124.42,92.84 124.71,93.13 124.71,94.18 125.73,95.2 125.73,95.63 125.98,95.89 126.74,95.89 v4(127.21,96.36)
N71581932: length 10.6
  TOP w0.14: U23.L9 v4(126.21,96.36)
  BOTTOM w0.14: R1808.1 118.93,91.88 120.4,93.34 120.4,93.47 120.78,93.85 122.05,93.85 122.56,94.36 v2(123.7,94.36) 123.83,94.36 124.71,95.25 124.71,95.76 125.32,96.36 v4(126.21,96.36)
N71581962: length 15.8
  TOP w0.14: v1(123.64,82.82) 124.01,82.45 R1809.1 ; U23.N9 v4(124.21,96.36)
  T05 w0.117: v1(123.64,82.82) 124.35,83.53 124.35,88.63 123.74,89.24 123.74,95.89 v4(124.21,96.36)
N71581964: length 16.8
  TOP w0.14: v1(126.4,82.45) R1810.1 ; U23.M9 v4(125.22,97.35)
  T05 w0.117: v4(125.22,97.35) 125.7,96.87 125.7,84.63 126.4,83.93 v1(126.4,82.45)
N71582004: length 6.4
  TOP w0.14: U23.P10 v4(123.25,95.39)
  BOTTOM w0.14: v4(123.25,95.39) 122.69,94.83 120.94,94.83 v2(119.61,93.5) 119,92.89 R1811.1
N71582006: length 7.3
  TOP w0.14: U23.N10 v4(124.23,95.38)
  BOTTOM w0.14: v4(124.23,95.38) 123.8,95.8 122.84,95.8 122.19,95.16 119.81,95.16 v2(119.44,94.79) R1812.1
N71582475: length 4.1
  TOP w0.104: C2204.2 296.07,92.13 292.84,92.13 U25.A10
N71582478: length 5.2
  TOP w0.104: U25.B10 292.11,92.4 296.08,92.4 C2205.2
N72480397: length 38
  TOP w0.122: v4(70.21,38.14) 69.98,38.36 69.98,38.89 70.1,39.01 ; 70.1,39.01 69.98,39.14 69.98,41.15 70.99,42.16 70.99,42.55 71.25,42.81 L140.4 71.25,43.53 R1265.2 ; 70.1,39.01 D61.1
  T18 w0.127: v4(70.21,38.14) 69.99,37.92 69.99,37.47 69.47,36.96 68.29,36.96 66.79,35.45 66.79,18.97 72.78,12.98 OJ1.U3
N72480405: length 37.9
  TOP w0.122: 69.6,39.01 69.72,39.14 69.72,41.25 70.74,42.27 70.74,42.42 70.45,42.7 L140.3 70.45,43.56 R1262.2 ; 69.6,39.01 D61.6 ; 69.6,39.01 69.72,38.89 69.72,38.36 v4(69.49,38.14)
  T18 w0.127: v4(69.49,38.14) 69.71,37.92 69.71,37.59 69.36,37.23 68.18,37.23 66.52,35.56 66.52,21.98 66.4,21.87 66.31,21.87 66.2,21.76 66.2,21.6 66.31,21.49 66.4,21.49 66.52,21.38 66.52,21.22 66.4,21.11 66.31,21.11 66.2,20.99 66.2,20.84 66.31,20.73 66.4,20.73 66.52,20.61 66.52,20.46 66.4,20.34 66.31,20.34 66.2,20.23 66.2,20.07 66.31,19.96 66.4,19.96 66.52,19.85 66.52,18.86 71.6,13.78 OJ1.U2
N72539929: length 7.3
  TOP w0.14: v1(75.89,63.79) 75.89,63.19 75.31,62.61 74.24,62.61 R12911.1 R12288.2 74.67,65.07 v1(74.93,65.07) U152.6
  BOTTOM w0.14: U151.6 75.61,63.31 75.89,63.59 v1(75.89,63.79)
N72619067: length 6.4
  TOP w0.381: v1(89.28,190.25) 89.56,190.53 U144.6
  BOTTOM w0.508: L192.1 C2210.1 C2211.1 90.23,190.93 v2(90.09,190.79) 89.54,190.25 v1(89.28,190.25)
N72721990: length 8.4
  TOP w0.104: U1.V37 196.14,118.77 195.75,118.77 195.45,118.48 193.46,118.48 193.19,118.75 R16.1 192.33,118.75 192.05,118.48 190.35,118.48 R12439.1 189.6,118.56 189.07,118.56 188.96,118.67 C2343.2
N72722010: length 9.5
  TOP w0.104: C2342.2 188.97,118.17 189.11,118.3 189.54,118.3 R12440.2 190.25,118.21 192.05,118.21 192.33,117.94 R16.2 193.19,117.94 193.46,118.21 195.56,118.21 195.86,118.51 196.87,118.51 U1.V36
N72722462: length 39
  TOP w0.104: C2346.2 183.13,145.37 v4(183.24,145.26)
  TOP w0.14: U1.AJ24 v4(208.86,130.5)
  T03 w0.102: v4(208.86,130.5) 208.86,130.79 208.76,130.89 208.48,130.89 208.26,131.11 208.26,138.92 208.22,138.96 208.22,138.99
  T03 w0.107: v4(183.24,145.26) 183.46,145.04 183.46,144.44 185.93,141.97 186.94,141.97 187.95,140.97 190.88,140.97 191.53,140.32 207.08,140.32 208.22,139.18 208.22,138.99
  BOTTOM w0.102: R4.1 208.93,130.5 v4(208.86,130.5)
N72722464: length 38.8
  TOP w0.104: v4(184,145.26) 184.14,145.41 C2347.2
  TOP w0.14: U1.AK24 v4(208.86,131.5)
  T03 w0.102: 208.5,138.99 208.5,138.96 208.46,138.92 208.46,131.2 208.56,131.1 208.76,131.1 208.86,131.2 v4(208.86,131.5)
  T03 w0.107: 208.5,138.99 208.5,139.3 207.2,140.6 191.64,140.6 191,141.25 188.06,141.25 187.06,142.25 186.04,142.25 183.74,144.56 183.74,145 v4(184,145.26)
  BOTTOM w0.102: v4(208.86,131.5) 209.35,131.01 R4.2
N72722466: length 43.5
  TOP w0.104: C2235.2 185.67,145.34 v4(185.83,145.19)
  TOP w0.14: U1.AL18 v4(215.86,132.5)
  T03 w0.102: v4(215.86,132.5) 215.86,132.2 215.96,132.1 216.1,132.1 216.26,132.25 216.26,138.85 216.22,138.89 216.22,138.91
  T03 w0.107: v4(185.83,145.19) 186,145.01 186,144.45 186.5,143.95 187.49,143.95 187.64,143.8 187.81,143.8 187.96,143.95 188.13,143.95 188.28,143.8 188.45,143.8 188.6,143.95 189.81,143.95 192.15,141.61 213.98,141.61 216.22,139.36 216.22,138.91
  BOTTOM w0.102: v4(215.86,132.5) 216.28,132.08 R5.1
N72722468: length 43.6
  TOP w0.104: v4(186.51,145.19) 186.69,145.36 C2236.2
  TOP w0.14: U1.AK18 v4(215.86,131.5)
  T03 w0.102: v4(215.86,131.5) 215.86,131.79 215.96,131.89 216.19,131.89 216.47,132.17 216.47,132.33 216.47,138.85 216.5,138.89 216.5,138.91
  T03 w0.107: v4(186.51,145.19) 186.28,144.96 186.28,144.57 186.62,144.23 189.92,144.23 192.26,141.89 214.09,141.89 216.5,139.48 216.5,138.91
  BOTTOM w0.102: R5.2 215.44,131.91 v4(215.86,131.5)
N72722479: length 79
  TOP w0.104: v4(190.1,151.85) 189.88,152.07 189.5,152.07 C2237.2
  TOP w0.14: U1.AF8 v4(225.86,127.5)
  T18 w0.102: v4(225.86,127.5) 226.16,127.5 226.28,127.62 226.28,127.77 226.16,127.9 214.45,127.9 214.42,127.86 214.39,127.86
  T18 w0.107: 214.39,127.86 214.24,127.86 214.13,127.75 214.13,121.24 213.2,120.31 194.62,120.31 194.48,120.16 194.3,120.16 194.16,120.31 193.98,120.31 193.84,120.16 193.66,120.16 188.01,125.82 188.01,148.52 190.73,151.25 190.73,151.96 190.62,152.06 190.32,152.06 v4(190.1,151.85)
  BOTTOM w0.102: v4(225.86,127.5) 226.28,127.91 R11.1
N72722481: length 79.1
  TOP w0.104: C2238.2 189.5,152.34 189.88,152.34 v4(190.1,152.56)
  TOP w0.14: U1.AF7 v4(226.86,127.5)
  T18 w0.102: 214.39,128.14 214.42,128.14 214.45,128.1 226.24,128.1 226.49,127.86 226.49,127.6 226.59,127.5 v4(226.86,127.5)
  T18 w0.107: 214.39,128.14 214.12,128.14 213.85,127.87 213.85,121.36 213.08,120.59 193.64,120.59 188.28,125.94 188.28,148.41 191.01,151.13 191.01,152.07 190.74,152.34 190.32,152.34 v4(190.1,152.56)
  BOTTOM w0.102: v4(226.86,127.5) 226.44,127.08 R11.2
N72722789: length 69.2
  TOP w0.104: v4(175.06,84.71) 174.87,84.52 C2338.2
  TOP w0.14: U1.V19 v4(214.86,118.5)
  T05 w0.107: v4(214.86,118.5) 215.11,118.5 215.22,118.6 215.22,118.9 215.02,119.1 214.36,119.1 213.92,118.66 213.92,101.3 211.94,99.32 187.95,99.32 178.59,89.96 178.59,86.39 177.11,84.91 176.66,84.91 176.57,84.82 176.47,84.72 176.34,84.72 176.25,84.82 176.15,84.91 176.02,84.91 175.93,84.82 175.83,84.72 175.7,84.72 175.61,84.82 175.51,84.91 175.26,84.91 v4(175.06,84.71)
N72722791: length 69.4
  TOP w0.104: v4(175.06,85.39) 174.92,85.54 C2339.2
  TOP w0.14: U1.V18 v4(215.86,118.5)
  T05 w0.107: v4(175.06,85.39) 175.26,85.19 177,85.19 178.31,86.5 178.31,90.07 187.83,99.6 211.83,99.6 213.64,101.42 213.64,118.78 214.25,119.38 215.14,119.38 215.5,119.02 215.5,118.6 215.61,118.5 v4(215.86,118.5)
N72722809: length 47.3
  TOP w0.104: v4(175.01,87.68) 174.93,87.77 C2341.2
  TOP w0.14: U1.W32 v4(200.86,119.5)
  T14 w0.102: v4(200.86,119.5) 200.86,119.2 200.76,119.1 200.47,119.1 200.25,118.88 200.25,118.12 200.22,118.08 200.22,118.05
  T14 w0.107: 200.22,118.05 200.22,117.9 199.89,117.57 197.82,117.57 197.12,116.87 195.13,116.87 193.8,115.54 193.8,112.58 185.36,104.14 185.36,96.82 175.98,87.43 175.27,87.43 v4(175.01,87.68)
N72722811: length 47.5
  TOP w0.104: C2340.2 174.89,86.81 v4(175.03,86.94)
  TOP w0.14: U1.V32 v4(200.86,118.5)
  T14 w0.102: 200.49,118.05 200.49,118.08 200.46,118.12 200.46,118.79 200.56,118.89 200.76,118.89 200.86,118.79 v4(200.86,118.5)
  T14 w0.107: v4(175.03,86.94) 175.24,87.15 176.09,87.15 185.64,96.7 185.64,104.02 194.08,112.46 194.08,115.43 195.24,116.59 197.23,116.59 197.94,117.29 200,117.29 200.49,117.79 200.49,118.05
N72722849: length 54.2
  TOP w0.104: C2344.2 166.48,93.68 166.48,93.91 v4(166.26,94.14) ; U1.U30 v4(202.86,117.5)
  T14 w0.107: v4(166.26,94.14) 166.47,93.92 166.47,93.47 166.85,93.09 169.81,93.09 179.6,102.88 179.6,105.25 186.26,111.9 187.16,111.9 195.25,120 202.2,120 203.22,118.98 203.22,117.6 203.11,117.5 v4(202.86,117.5)
N72722851: length 54.2
  TOP w0.104: U1.U29 v4(203.86,117.5) ; v4(166.97,94.14) 166.75,93.91 166.75,93.68 C2345.2
  T14 w0.107: v4(166.97,94.14) 166.75,93.92 166.75,93.59 166.97,93.37 169.7,93.37 179.32,103 179.32,105.36 186.14,112.18 187.04,112.18 195.13,120.27 202.32,120.27 203.5,119.09 203.5,117.6 203.61,117.5 v4(203.86,117.5)
N72724116: length 4.9
  TOP w0.104: U129.10 182.5,150.74 182.41,150.65 182.41,150.41 182.73,150.09 183.42,150.09 183.93,149.58 v4(183.95,149.58) 183.72,149.35 183.72,149.14 183.93,148.93 R12448.1
  BOTTOM w0.104: R12448.1 183.94,148.93 183.72,149.15 183.72,149.35 v4(183.95,149.58)
N72724118: length 4.4
  TOP w0.104: U129.9 182,150.78 182.14,150.64 182.14,150.3 182.63,149.81 182.93,149.81 v4(183.16,149.58) 183.29,149.58 183.45,149.42 183.45,149.15 183.23,148.93 R12447.1
  BOTTOM w0.104: v4(183.16,149.58) 183.22,149.58 183.45,149.35 183.45,149.15 183.23,148.93 R12447.1
N72724120: length 6.4
  TOP w0.104: R12449.1 185.75,148.93 186.04,149.21 186.04,149.44 v4(185.8,149.68) 185.99,149.87 185.99,150.12 185.81,150.3 184.36,150.3 184.36,150.3 183.57,150.3 183.11,150.76 183.11,151.15 U129.11
  BOTTOM w0.104: v4(185.8,149.68) 186.02,149.47 186.02,149.05 185.9,148.93 R12449.1
N72724122: length 6.5
  TOP w0.104: U129.12 183.4,151.15 183.4,150.86 183.69,150.56 184.47,150.56 184.47,150.56 185.92,150.56 186.26,150.23 186.26,149.91 v4(186.49,149.68) 186.31,149.5 186.31,149.14 186.53,148.93 R12450.1
  BOTTOM w0.104: R12450.1 186.41,148.93 186.28,149.05 186.28,149.48 v4(186.49,149.68)
N72724124: length 3.2
  TOP w0.102: v4(185.33,151.85) 185.13,152.06 184.86,152.06 184.77,151.96 U129.13
  TOP w0.104: R12452.1 185.77,152.08 185.56,152.08 v4(185.33,151.85)
  BOTTOM w0.14: v4(185.33,151.85) 186,151.85 R12452.1
N72724126: length 3.2
  TOP w0.102: U129.14 184.77,152.46 184.86,152.36 185.13,152.36 v4(185.33,152.57)
  TOP w0.104: v4(185.33,152.57) 185.56,152.34 185.79,152.34 R12451.1
  BOTTOM w0.14: R12451.1 186.01,152.57 v4(185.33,152.57)
N72725479: length 5.4
  TOP w0.104: R12453.1 v4(170.22,84.52) 169.85,84.89 169.17,84.89 168.34,85.72 168.34,86.55 168.24,86.65 168.18,86.65 168.07,86.53 U132.9
  BOTTOM w0.104: R12453.1 v4(170.22,84.52)
N72725483: length 5.4
  TOP w0.104: R12454.1 v4(170.2,85.54) 169.82,85.16 169.28,85.16 168.61,85.83 168.61,86.66 168.35,86.92 168.24,86.92 168.13,87.03 U132.10
  BOTTOM w0.104: R12454.1 v4(170.2,85.54)
N72725491: length 4.4
  TOP w0.104: U132.11 168.13,87.53 168.24,87.65 168.7,87.65 169.19,87.15 169.85,87.15 v4(170.2,86.81) R1888.1
  BOTTOM w0.104: R1894.2 170.2,86.8 v4(170.2,86.81)
N72725499: length 4.4
  TOP w0.104: U132.12 168.13,88.03 168.24,87.92 168.81,87.92 169.3,87.42 169.83,87.42 v4(170.18,87.77) R12455.1
  BOTTOM w0.104: v4(170.18,87.77) 170.19,87.76 R1893.2
N72725507: length 2.8
  TOP w0.104: R1890.1 167.11,90.17 v4(166.98,90.04) 166.75,89.81 166.75,89.41 166.87,89.29 U132.13
  BOTTOM w0.104: v4(166.98,90.04) 167.11,90.17 R1890.1
N72725515: length 2.8
  TOP w0.104: U132.14 166.37,89.29 166.48,89.41 166.48,89.8 v4(166.24,90.04) 166.12,90.17 R1889.1
  BOTTOM w0.104: v4(166.24,90.04) 166.12,90.17 R1889.1
N72854419: length 4.4
  TOP w0.14: U163.8 138.59,117.82 v5(138.43,117.66) 138.3,117.53 R12462.2
  BOTTOM w0.14: R12462.2 138.3,117.53 v5(138.43,117.66)
N72854464: length 4.7
  TOP w0.14: U163.9 139.09,118.96 139.04,118.92 139.04,118.31 v5(139.7,117.66) 139.7,116.79 R12463.2
  BOTTOM w0.14: v5(139.7,117.66) 139.7,116.79 R12463.2
N72858167: length 3.5
  TOP w0.14: R12464.1 v5(137.16,117.66) 138.09,118.59 U163.7
N72858665: length 2.8
  TOP w0.104: R12783.2 140.04,125.9 140.21,125.73 140.21,124.21 140.09,124.09 U163.20
N72858667: length 2.7
  TOP w0.104: R12784.2 140.63,125.9 140.47,125.74 140.47,124.2 140.59,124.09 U163.19
N72858673: length 2.3
  TOP w0.104: U163.14 141.85,120.83 141.96,120.71 142.57,120.71 142.79,120.5 143.02,120.5 R12787.2
N72858675: length 2.3
  TOP w0.104: U163.13 141.85,120.33 141.96,120.44 142.46,120.44 142.68,120.23 143.02,120.23 R12788.2
N72858677: length 3.4
  TOP w0.104: R12786.2 142.09,117.18 141.83,117.43 141.83,118.07 140.97,118.92 140.72,118.92 140.48,119.16 140.48,119.52 U163.12
N72858679: length 3.4
  TOP w0.104: U163.11 140.2,119.51 140.2,119.06 140.61,118.66 140.86,118.66 141.56,117.96 141.56,117.38 141.36,117.18 R12785.2
N72858945: length 5.7
  TOP w0.14: R12465.1 135.89,116.79 v5(135.89,117.66) 137.38,119.15 U163.6
  BOTTOM w0.14: R12465.1 135.89,116.79 v5(135.89,117.66)
N72863733: length 2.2
  TOP w0.14: R13080.1 R1075.2 C1690.1
N73047684: length 5.6
  TOP w0.14: R1789.1 153.53,124.7 v1(153.8,124.97) 154.58,125.75 U135.13
  BOTTOM w0.14: R1897.1 153.54,122.85 v2(153.54,123.83) 153.54,124.76 153.75,124.97 v1(153.8,124.97)
N73047688: length 5.1
  TOP w0.14: R1788.1 154.81,124.45 v1(154.81,124.89) 155.08,125.16 U135.14
  BOTTOM w0.14: R1898.1 154.88,122.88 v2(154.88,123.94) 154.88,124.83 v1(154.81,124.89)
N73047760: length 3.1
  TOP w0.14: R1787.1 156.84,135.79 156.84,135.28 157.08,135.05 U135.38
N73048504: length 4.4
  TOP w0.14: v1(163.58,130.43) 163.51,130.36 U135.28
  BOTTOM w0.14: v1(163.58,130.43) 163.83,130.68 TP95.1
N73054323: length 2.7
  TOP w0.508: X7.1 v1(189.35,154.48)
  BOTTOM w0.508: v1(189.35,154.48) 189.22,154.62 R1644.1
N73073084: length 3.1
  TOP w0.14: U25.P9 v4(279.1,93.39)
  BOTTOM w0.14: v2(280.04,92.33) 279.53,92.83 R1899.1 278.68,93.13 278.93,93.39 v4(279.1,93.39)
N73073097: length 11.2
  TOP w0.14: U25.R9 v4(278.1,93.39)
  BOTTOM w0.14: v2(280.59,100.33) 280.17,99.9 277.83,99.9 277.59,99.66 277.59,94.18 278.1,93.67 v4(278.1,93.39) 277.7,92.99 R1900.1
N73140692: length 2.7
  TOP w0.14: U110.7 26.63,45.68 v1(26.16,45.21)
  BOTTOM w0.14: R1768.2 26.57,45.62 v1(26.16,45.21)
N73140789: length 2.6
  TOP w0.14: v1(32.77,45.21) 33.17,45.62 U121.7
  BOTTOM w0.14: v1(32.77,45.21) 33.05,45.49 R1767.2
N73155937: length 2.7
  TOP w0.104: U85.25 96.27,96.08 96.15,96.19 96.15,97.55 C2371.2
N73155940: length 2.7
  TOP w0.104: C2370.2 95.89,97.51 95.89,96.19 95.77,96.08 U85.26
N73156284: length 7.1
  TOP w0.305: v1(107.8,82.6) 106.56,81.36 U143.6
  BOTTOM w0.381: L191.1 C2207.1 105.9,82.54 C2208.1 107.73,82.54 v1(107.8,82.6)
N73156286: length 1.8
  TOP w0.14: R12485.1 108.74,85.78 108.58,85.94 U143.1
N73430665: length 2.2
  TOP w0.14: R12699.2 161.71,147.47 v1(162.24,146.94) Q56.2
N73437259: length 12.1
  TOP w0.14: v1(81.03,109.15) 80.43,109.75 71.3,109.75 U154.B15
  BOTTOM w0.14: v1(81.03,109.15) 81.08,109.09 TP65.1
N73437342: length 10.4
  TOP w0.14: U154.E14 v4(68.93,110.53)
  BOTTOM w0.102: R12720.1 v2(77.22,110.42) 76.73,109.94 74.17,109.94 73.98,110.13 69.32,110.13 v4(68.93,110.53)
N73437369: length 5.9
  TOP w0.14: U154.D14 v4(69.73,110.53)
  BOTTOM w0.102: v4(69.73,110.53) 69.73,110.55 70.1,110.93 72.14,110.93 v2(72.26,110.8)
  BOTTOM w0.14: R12721.1 72.64,110.42 v2(72.26,110.8)
N73438190: length 5.9
  TOP w0.14: U154.D18 v4(69.73,107.32)
  BOTTOM w0.102: R12717.2 73.97,107.88 73.96,107.89 v2(73.32,107.89) 73.09,108.12 71.88,108.12 71.49,107.73 70.13,107.73 v4(69.73,107.32)
N73438376: length 10.2
  TOP w0.14: U154.D17 v4(69.73,108.12)
  BOTTOM w0.102: 70.48,104.9 70.48,105.18 70.13,105.53 70.13,105.88 69.89,106.12 69.52,106.12 69.33,106.31 69.33,107.69 69.73,108.08 v4(69.73,108.12)
  BOTTOM w0.14: 70.48,104.9 71.63,103.76 72.14,103.76 72.87,103.02 74.07,103.02 74.55,103.5 TP68.1
N73438412: length 6.9
  TOP w0.14: U154.E16 v4(68.93,108.92)
  BOTTOM w0.102: v2(73.53,109.41) 73.22,109.72 71.08,109.72 70.69,109.33 69.33,109.33 v4(68.93,108.92)
  BOTTOM w0.14: R12722.2 73.79,109.15 v2(73.53,109.41)
N73438424: length 9
  TOP w0.14: U154.C17 v4(70.53,108.12)
  BOTTOM w0.102: v4(70.53,108.12) 70.93,108.53 71.83,108.53 72.22,108.92 72.54,108.92 72.82,108.64 76.71,108.64 v2(77.22,109.15) R12723.2
N73540220: length 23.2
  TOP w0.14: R12880.1 80.95,112.8 81.2,113.06 Q12.1 83.5,111.7 81.92,110.11 81.92,101.22 81.2,100.5 v1(77.64,100.5) 76.96,99.82 R12998.1
  BOTTOM w0.14: v1(77.64,100.5) 76.86,99.72 R13001.2
N73688078: length 2.4
  TOP w0.104: U163.17 141.85,122.33 141.97,122.21 142.2,122.21 142.47,122.49 142.98,122.49 R12752.2
N73688080: length 2.4
  TOP w0.104: U163.16 141.85,121.83 141.97,121.95 142.31,121.95 142.58,122.22 142.98,122.22 R12753.2
N73814180: length 2.9
  TOP w0.104: R1073.1 162.02,118.49 v1(161.54,118.49) 161.23,118.17 160.92,118.17 160.82,118.27 U133.12
  BOTTOM w0.104: R1073.1 161.73,118.68 v1(161.54,118.49)
N73814192: length 3
  TOP w0.104: U133.11 160.82,117.77 160.95,117.91 161.24,117.91 v1(161.54,117.6) 162.01,117.6 R1072.1
  BOTTOM w0.104: R1072.1 161.74,117.4 v1(161.54,117.6)
N73814194: length 6
  TOP w0.104: U133.10 160.73,117.27 161.52,116.49 162.53,116.49 162.83,116.18 162.83,115.82 v4(163.05,115.6) 162.83,115.38 162.83,115.01 162.93,114.91 R1071.1
  BOTTOM w0.104: R1071.1 163.05,114.91 162.94,115.01 162.94,115.49 v4(163.05,115.6)
N73814196: length 5.5
  TOP w0.104: R1070.1 162.46,114.91 162.56,115.01 162.56,115.38 v4(162.34,115.6) 162.56,115.82 162.56,116.07 162.42,116.22 161.41,116.22 161.29,116.33 161.29,116.33 160.85,116.77 U133.9
  BOTTOM w0.104: v4(162.34,115.6) 162.47,115.47 162.47,115.01 162.36,114.91 R1070.1
N73978233: length 6.7
  TOP w0.104: U139.B6 24.41,92.32 26.1,92.32 26.73,92.95 27.69,92.95 v4(27.91,92.73) 28.13,92.95 28.31,92.95 R1867.2
  BOTTOM w0.104: v4(27.91,92.73) 28.04,92.86 28.41,92.86 R1867.2
N73978235: length 5.7
  TOP w0.104: R1866.2 28.31,93.22 28.13,93.22 v4(27.91,93.44) 27.69,93.22 27.34,93.22 27.21,93.34 27.03,93.34 26.9,93.22 26.62,93.22 25.99,92.59 25.04,92.59 24.93,92.69 U139.A6
  BOTTOM w0.104: R1866.2 28.44,93.34 28.01,93.34 v4(27.91,93.44)
N74576889: length 11
  TOP w0.14: U139.E12 v4(21.43,86.3)
  BOTTOM w0.14: v4(21.43,86.3) v2(23.2,84.54) 29.54,84.54 R12800.2
N74587656: length 7
  TOP w0.14: U139.K5 v4(15.43,94.3)
  BOTTOM w0.14: v2(10.69,96.39) R12795.2 12.57,95.18 13.01,94.74 14.99,94.74 v4(15.43,94.3)
N74595531: length 6.1
  TOP w0.14: v5(25.53,88.2) U139.A10
  BOTTOM w0.14: R1674.2 29.57,88.7 v2(29.24,88.38) 29.06,88.2 v5(25.53,88.2)
N74678994: length 3.6
  TOP w0.14: U160.4 45.92,130.05 C2325.1 R12420.2 R12416.2
N74679075: length 3.9
  TOP w0.381: R12428.2 59.03,204.85 59.03,203.56 v1(58.98,203.5) R12434.2 58.98,201.02 R12430.1
N74680300: length 2.4
  TOP w0.305: PU19.3 59.48,194.36 v1(58.86,193.74) 58.28,193.15 PC324.1
N74682687: length 1.5
  TOP w0.381: PR367.2 76.99,142.95 PC345.2
N74683537: length 1.5
  TOP w0.381: PR360.2 60.97,142.95 PC335.2
N74685275: length 4.4
  BOTTOM w0.381: v2(87.38,204.6) 86.68,203.9 PR22.2 PR11.2 83.84,204.68 PR16.1
N74685283: length 8.7
  TOP w0.381: v1(24.51,170.49) PR50.1 PC14.1 25.35,168.38 25.63,168.1 PR53.1 25.63,166.91 25.35,166.63 PR41.2 PR46.1 PR43.2
N74685349: length 70.1
  TOP w0.381: v1(150.57,202.23) 142.75,194.4 PR54.1 PR55.2 PC16.1 PR52.2 PR44.2 PR47.2 ; PR330.1 v1(196.21,197.67)
  T14 w0.381: v1(150.57,202.23) 151.06,202.72 177.68,202.72 183.54,196.85 191.77,196.85 192.57,196.05 195.37,196.05 196.21,196.89 v1(196.21,197.67)
N74685355: length 8.6
  TOP w0.381: v1(24.67,162.05) 25.35,161.38 PR36.1 PR35.2 PR28.2 PR25.2 PC11.1 25.35,154.13 PR38.2
N74685391: length 123.8
  TOP w0.381: PR34.1 276.46,120.39 PR40.1 PC13.1 PR33.2 PR30.2 PR27.2 276.46,128.56 277.57,129.67 v1(277.88,129.67)
  T05 w0.381: v1(227.6,209.85) 229.52,209.85 232.88,206.49 232.88,204.66 234.07,203.47 234.07,200.68 235.56,199.19 235.56,194.87 239.35,191.08 253.03,191.08 258.08,186.03 259.94,186.03 261.25,184.72 261.25,182.7 267.31,176.64 267.31,161.19 267.3,161.18 267.3,152.2 277.62,141.88 277.62,129.92 v1(277.88,129.67)
  BOTTOM w0.381: v1(227.6,209.85) PR18.2 PR12.2
N74685429: length 8.7
  BOTTOM w0.203: PR32.1 PC12.1 PR39.1 PR31.2 PR29.2 PR26.2 302.82,139.57 v2(302.36,140.03)
N74685493: length 57.6
  TOP w0.508: PR48.2 PR45.2 PR42.2 PR51.2 PC15.1 PR49.1 v1(237.87,194.8)
  BOTTOM w0.381: PR331.2 201.13,206.29 201.93,205.49 201.93,195.33 203.79,193.47 213.96,193.47 214,193.43 215.68,193.43 215.72,193.47 236.54,193.47 v1(237.87,194.8)
N74685644: length 7.9
  TOP w0.381: v1(273.25,119.58) PR332.2 PR336.1 PC311.1 PR334.1 PR335.1 PR333.2
N74687466: length 1.5
  TOP w0.508: PC69.2 PR104.2
N74687472: length 3.6
  BOTTOM w0.381: PR106.2 205.55,205.22 PC77.1 v2(205.49,206.63)
N74690205: length 1.4
  TOP w0.254: PR162.2 306.19,154.51 PC125.2
N74690227: length 2.1
  TOP w0.508: PC137.1 296.83,144.78 296.83,144.79 PR164.2
N74690437: length 2.3
  TOP w0.381: PC95.2 PR158.2 v1(306.93,169.39)
N74690459: length 2.1
  TOP w0.508: PC115.1 296.99,160.74 PR160.2
N75215754: length 7
  TOP w0.14: Q23.2 49.66,194.94 49.53,194.81 49.53,194.44 ; R12824.1 R12829.2 49.22,194.12 49.53,194.44 ; v1(50.8,193.42) 50.35,193.87 Q23.3 49.68,194.29 49.53,194.44
  BOTTOM w0.14: v1(50.8,193.42) 51.11,193.11 Q5.6
N75216585: length 17.9
  TOP w0.14: R12825.1 R12830.2 49.02,201.04 49.45,200.61 Q24.2 50.98,200.61 51.18,200.41 51.18,200.15 50.99,199.96 Q24.3 50.32,198.28 49.78,197.74 48.13,197.74 v1(48.01,197.61)
  BOTTOM w0.14: v1(48.01,197.61) 48.01,192.4 48.57,191.84 48.57,191.2 49.81,189.97 Q5.3
N75511000: length 9.8
  TOP w0.254: v1(31.88,156.14) PR86.2 PR504.1 ; v1(35.63,151.76) PR83.2
  T05 w0.254: v1(35.63,151.76) 35.18,152.21 35.18,153.92 32.89,156.21 31.95,156.21 v1(31.88,156.14)
N75511258: length 2.2
  TOP w0.508: PC60.1 33.42,157.12 34.03,157.73 PR94.2
N75511286: length 2.5
  TOP w0.508: PC369.1 8.33,169.75 8.68,170.1 PR427.2
N75609157: length 28.1
  TOP w0.762: R12980.1 v3(64.39,37.85)
  BOTTOM w0.762: v3(64.39,37.85) 66.93,35.31 66.93,15.15 OJ1.U1
N75767633: length 1.9
  TOP w0.14: R13038.2 v1(141.63,197.49) 141.63,198.22 U171.4
N75769333: length 7.1
  TOP w0.14: U164.2 135.94,198.99 136.37,198.56 v1(136.37,197.99) 137.01,197.35 137.01,194.21 137.36,193.85 U148.4
N76078430: length 6.1
  TOP w0.14: v1(70.61,87.69) 71.13,87.69 71.27,87.83 U127.53 ; v1(70.61,87.69) 70.11,87.69 69.97,87.83 U127.55 ; v1(70.61,87.69) 70.62,87.69 U127.54
  BOTTOM w0.14: v1(70.61,87.69) 70.76,87.84 R12904.2
N76218842: length 13.7
  T03 w0.117: v1(107.36,102.91) 108.99,101.28 114.31,101.28 v1(115.19,102.16)
  BOTTOM w0.14: v1(115.19,102.16) R1860.1 ; U149.17 108.29,104.99 107.36,104.06 v1(107.36,102.91)
N76219186: length 3.8
  BOTTOM w0.14: R1859.2 109.22,97.86 v2(108.38,98.7) 107.64,99.44 U149.5
N76219190: length 8.6
  BOTTOM w0.14: R1856.2 106.43,113.54 v2(105.16,112.27) 104.52,111.63 104.52,108.08 105.04,107.56 U149.12
N76219192: length 3.8
  BOTTOM w0.14: R1858.2 v2(106.8,98.64) 106.34,99.1 U149.7
N76219194: length 3.2
  BOTTOM w0.14: U149.16 107.64,107.77 v2(107.57,107.84) 106.55,108.86 R1854.2
N76219196: length 7.2
  BOTTOM w0.14: U149.14 106.34,107.27 105.41,108.2 v2(105.41,108.46) 105.41,111.15 R1855.2
N76219198: length 4
  BOTTOM w0.14: U149.9 105.04,99.58 104.65,99.19 104.17,99.19 v2(103.72,98.74) 103.5,98.53 R1857.2
N76219205: length 13.4
  T07 w0.117: v1(105.02,95.62) 105.02,97.21 108.2,100.39 v1(108.2,102.93)
  BOTTOM w0.14: U149.18 108.94,104.75 108.2,104.01 v1(108.2,102.93) ; R1853.2 104.78,95.87 v1(105.02,95.62)
N76225319: length 2.9
  TOP w0.305: U162.16 v1(85.94,84.58)
  BOTTOM w0.381: v1(85.94,84.58) 85.8,84.44 C2335.2
N76226158: length 3
  TOP w0.14: v1(89.75,80.6) 88.87,80.6 88.69,80.42 U162.8
  BOTTOM w0.14: R12832.1 90.6,80.6 v1(89.75,80.6)
N76335228: length 2.3
  TOP w0.14: v1(77.34,56.2) U89.16
  BOTTOM w0.14: v1(77.34,56.2) 76.3,56.2 R12909.1
N76335232: length 3.8
  TOP w0.14: v1(77.09,53.68) 77.16,53.6 U89.12
  BOTTOM w0.14: v1(77.09,53.68) 76.88,53.47 R12907.1 R12908.1
N76335242: length 3.4
  TOP w0.14: v1(73.28,55.88) 72.96,56.2 U89.1
  BOTTOM w0.14: v1(73.28,55.88) 73.41,56.02 R12910.2
N76341793: length 9
  TOP w0.14: Q54.3 77.71,59.96 v1(77.6,60.07) ; v1(72.69,63.5) 72.82,63.63 R12911.2
  T03 w0.117: v1(72.69,63.5) 74.24,61.96 74.24,60.81 74.98,60.07 v1(77.6,60.07)
N76342023: length 3.1
  TOP w0.14: R12912.1 R12913.1 74.77,60.95 75.2,60.95 v1(75.44,60.71) 76.25,60.71 Q54.1
N76605898: length 7.4
  TOP w0.14: U139.C4 v4(23.43,95.3)
  T05 w0.117: v4(23.43,95.3) 22.95,95.78 22.95,98.51 v1(23.88,99.44)
  BOTTOM w0.14: R1671.2 23.11,100.71 23.88,99.95 v1(23.88,99.44)
N76605919: length 4.1
  TOP w0.104: U139.A3 25.3,95.44 28.42,95.44 R12763.2
N76605922: length 4.1
  TOP w0.104: R12764.2 28.39,95.17 25.3,95.17 U139.A4
N76660295: length 17.4
  TOP w0.14: J1.B54 119.41,154.45 120.9,155.94 120.9,159.53 119.95,160.48 119.95,169.62 R12709.2
N77026396: length 7
  TOP w0.381: U25.J11 v4(285.1,90.39) ; U25.H8 v4(286.1,94.39) ; U25.J13 v4(285.1,88.39)
  BOTTOM w0.381: C966.1 284.68,89.97 v4(285.1,90.39) ; v4(285.1,88.39) 284.68,87.97 C967.1 284.1,87.47 v2(284.1,86.74) v2(284.1,85.47) ; C975.1 U25.H8 v4(286.1,94.39)
N77026454: length 7.3
  TOP w0.381: U25.J9 v4(285.1,93.39) ; U25.K13 v4(283.1,88.39) ; U25.H6 v4(286.1,96.39)
  BOTTOM w0.381: v4(285.1,93.39) 284.68,92.97 C976.1 284.68,92.38 284.99,92.08 286.51,92.08 v2(286.89,92.46) ; v4(286.1,96.39) U25.H6 C968.1 ; C969.1 282.68,87.97 v4(283.1,88.39)
N77607673: length 3
  TOP w0.635: T1.2 v1(50.81,57.65)
  BOTTOM w0.762: C2412.1 50.85,57.69 v1(50.81,57.65)
N77607680: length 3
  TOP w0.635: T1.7 v1(44.46,57.65)
  BOTTOM w0.762: v1(44.46,57.65) 44.5,57.69 C2414.1
N77609229: length 4.5
  TOP w0.635: v1(44.5,52.17) 44.46,52.13 T1.10
  BOTTOM w0.762: v1(44.5,52.17) C2413.2
N77609387: length 4.9
  TOP w0.635: T1.15 v1(50.81,52.37)
  BOTTOM w0.762: C2411.1 50.85,52.33 v1(50.81,52.37)
N77669526: length 2.3
  TOP w0.14: v1(172.23,119.75) 172.56,120.07 R12927.2
  BOTTOM w0.14: TP22.1 172.48,120 v1(172.23,119.75)
N77675530: length 2.5
  TOP w0.14: R12930.2 154.2,92.63 v1(154.2,91.95) U174.4
N77675568: length 4.2
  TOP w0.14: U174.3 153.32,90.45 152.91,90.86 v1(152.91,91.82) 152.91,92.6 R12929.2
N77675570: length 5.6
  TOP w0.14: U174.2 152.92,89.8 v1(152.79,89.67) 152.54,89.67 152.13,90.08 152.13,93.05 R12928.2
N77675657: length 3.2
  TOP w0.381: v1(147.68,87.84) 147.68,88.77 148.06,89.15 U174.8
  BOTTOM w0.381: R12931.2 148.7,87.84 v1(147.68,87.84)
N77702972: length 3
  TOP w0.14: U175.4 152.15,85.72 v1(152.65,86.23)
  BOTTOM w0.14: R12943.2 151.89,85.47 v1(152.65,86.23)
N77703021: length 3.7
  TOP w0.14: v1(150.79,83.06) 151.31,83.58 U175.2
  BOTTOM w0.14: v1(150.79,83.06) 151.38,82.47 R12942.2
N77703106: length 2.1
  TOP w0.381: v1(146.93,82.24) 146.51,82.66 U175.8
  BOTTOM w0.381: v1(146.93,82.24) 146.94,82.23 R12944.2
N77756862: length 4.7
  TOP w0.14: v1(11.68,19.68) 10.49,20.88 R1905.2
  BOTTOM w0.14: v1(11.68,19.68) C2427.2 R1904.1
N77757286: length 2.7
  TOP w0.14: v1(12.52,22.99) R1906.2 C2428.2 R1905.1
N77757443: length 2.9
  TOP w0.14: v1(12.52,20.75) R1906.1 C2429.2 C2425.2
N77758163: length 1.8
  TOP w0.14: C2425.1 R1903.2 v1(15.64,23.11)
N77758452: length 9.4
  TOP w0.14: R1912.2 v1(17.91,16.48) 17.91,16 19.3,14.6 19.3,12.83 18.99,12.51 U106.3 16.96,12.51 16.82,12.38 R1911.2 R1908.1
N77758692: length 8.7
  TOP w0.14: U106.5 21.46,13.46 21.97,13.97 21.97,15.62 20.82,16.78 v1(20.82,17.85) 20.61,18.06 U105.2 18.41,18.06 R1912.1
N77764432: length 4.2
  TOP w0.14: R1914.2 R1913.2 25.63,16.79 26.13,16.29 v1(26.55,16.29) U104.5
N77764752: length 4.8
  TOP w0.14: U107.2 R1901.2 14.77,18.24 v1(15.85,19.33) R1902.2
N77829110: length 1.7
  TOP w0.14: R1909.1 20.79,15.71 v1(20.79,15.11) U106.6
N79150666: length 18.2
  TOP w0.14: Q58.3 131.79,186.09 132.21,185.67 v1(132.21,185.29) ; R12949.1 v1(130.94,171.7) 130.94,171.83 130.67,172.1 U176.19
  T16 w0.117: v1(132.21,185.29) 132.21,175.9 130.94,174.62 v1(130.94,171.7)
N79150678: length 2.4
  TOP w0.14: U176.12 126.12,171.97 v1(125.86,171.7) R12953.1
N79150683: length 2.4
  TOP w0.14: U176.16 128.72,172.16 128.4,171.83 v1(128.4,171.7) R12951.1
N79150686: length 2.4
  TOP w0.14: R12952.1 v1(127.13,171.7) 127.42,172 U176.14
N79150691: length 2.5
  TOP w0.14: R12950.1 v1(129.67,171.7) 129.67,171.83 130.02,172.19 U176.18
N79150702: length 2.1
  TOP w0.14: R12957.1 v1(130.05,180.21) 130.02,180.19 U176.3
N79150705: length 2.1
  TOP w0.14: U176.7 v1(127.42,180.21) 127.42,181.04 R12955.1
N79150708: length 2.1
  TOP w0.14: U176.5 v1(128.72,180.21) 128.72,181.02 R12956.1
N79150713: length 2.1
  TOP w0.14: U176.9 v1(126.12,180.21) 126.12,180.94 126.11,180.95 R12954.1
N79178768: length 9.2
  TOP w0.14: U154.B19 v4(71.33,106.52)
  BOTTOM w0.14: v4(71.33,106.52) 71.53,106.52 72.01,106.05 73.41,106.05 74.36,107 76.77,107 77.47,106.3 v2(77.47,105.95) 77.47,105.71 R12344.1
N79892105:
  vias: v1(59.56,212.22) v1(61.21,212.22)
N81956957: length 3.3
  BOTTOM w0.14: v2(259.71,187.1) R12993.1 260.8,187.1 260.8,186.21 261.26,185.75 Q4.1
N81957411: length 2.9
  BOTTOM w0.14: R12994.1 268.95,185.87 v2(268.13,185.87) 267.5,186.51 Q10.1
N81958061: length 1.6
  TOP w0.14: Q18.1 v1(282.74,185.08) 282.89,185.08 R12995.1
N81958702: length 2.5
  BOTTOM w0.14: R12996.1 278.35,187.73 277.51,187.73 v2(277.35,187.58) 277.35,186.7 Q9.1
N81959147: length 3.7
  BOTTOM w0.14: v2(274.7,189.36) 273.96,188.62 R12997.1 273.96,187.39 Q17.1
N82446781: length 7
  BOTTOM w0.14: R13007.2 13.28,29.82 Q59.1 13.07,31.85 Q42.3 14.37,33.15 v2(16.13,33.15)
N82446790: length 8.8
  BOTTOM w0.381: R13004.1 9.96,31.19 10.78,30.36 Q59.3 11.84,27.99 11.84,27.21 12.39,26.65 v2(12.39,26.07) 12.05,25.72 R1600.1
N82446929: length 4.8
  BOTTOM w0.14: v2(6.1,32.89) 6.92,33.72 U183.1 7.91,32.42 R13005.1 R13004.2
N82573078: length 4.8
  TOP w0.14: U197.4 R1177.1 53.59,200.03 v1(53.21,200.41) 53.21,200.47 53.07,200.61 Q24.5
  BOTTOM w0.14: R1280.1 53.59,200.03 v1(53.21,200.41)
N83323038: length 13.2
  TOP w0.14: U154.A16 v4(72.39,109.32)
  T03 w0.102: 73.66,109.79 72.85,109.79 v4(72.39,109.32)
  T03 w0.117: 73.66,109.79 83.41,109.79 83.44,109.82 v1(83.45,109.82)
  BOTTOM w0.14: TP145.1 82.69,110.1 82.97,109.82 v1(83.45,109.82)
N83323893: length 10.1
  TOP w0.14: U154.E15 v4(68.93,109.72)
  BOTTOM w0.102: v4(68.93,109.72) 68.53,110.12 68.53,114 68.65,114.12 71.7,114.12 72.11,114.53 73,114.53 TP146.1
N83582989: length 3.4
  TOP w0.14: Q60.3 v1(95.6,136)
  BOTTOM w0.14: v1(95.6,136) 95.76,135.85 R13036.2
N83584389: length 11.9
  TOP w0.122: R12725.2 8.26,45.82 8.26,40.59 8.36,40.49 8.4,40.49 8.51,40.38 8.51,40.23 8.4,40.12 8.36,40.12 8.26,40.01 8.26,39.86 8.36,39.75 8.4,39.75 8.51,39.65 8.51,39.5 8.4,39.39 8.36,39.39 8.26,39.28 8.26,38.61 6.95,37.31 6.47,37.31 6.35,37.19 6.35,37.01 6.22,36.88 U124.6
N83584392: length 11
  TOP w0.122: R12724.2 8,45.82 8,38.71 6.85,37.56 6.47,37.56 6.35,37.68 6.35,37.86 6.22,37.98 U124.5
N84148690: length 3.3
  BOTTOM w0.305: PC429.1 77.88,186.89 77.88,187.95 v2(77.71,188.11) 76.26,188.11 PR484.2
N84318236: length 4.3
  BOTTOM w0.14: R13069.2 R13068.2 ; R13069.2 72.56,130.38 v2(72.45,130.27) ; R13069.2 73.4,131.46 U115.2
N84432227: length 2.5
  TOP w0.381: v1(73.91,189.79) 73.91,189.46 PR501.2
  BOTTOM w0.14: PQ24.3 73.47,189.34 v1(73.91,189.79)
N84534648: length 2
  TOP w0.14: R13044.2 82.41,131.2 v1(82.42,131.19) 82.42,130.36 D26.2
N84534754: length 2
  TOP w0.14: D26.4 v1(81.12,131.19) 81.12,131.94 R13049.1
N84554322: length 2.9
  TOP w0.14: v1(222.5,173.92) 222.6,173.82 U75.2
  BOTTOM w0.14: v1(222.5,173.92) 222.54,173.96 C2406.1 223.35,174.05 R12905.1
N84554326: length 2.9
  TOP w0.14: U75.3 222.66,173.32 v1(222.5,173.16)
  BOTTOM w0.14: v1(222.5,173.16) 222.54,173.12 C2406.2 224.17,173.12 R12906.1
N84741258: length 1
  TOP w0.14: R13081.2 R13080.2
N84802108: length 10.2
  TOP w0.14: v1(115.71,136.06) 116.08,136.42 R13803.2 ; U70.D2 v4(110.8,130.45)
  T18 w0.102: 112.23,132.79 112.01,132.57 112.01,131.66 v4(110.8,130.45)
  T18 w0.117: 112.23,132.79 115.5,136.06 v1(115.71,136.06)
N84802297: length 5.1
  TOP w0.14: v1(107.95,129.54) 109.08,129.54 109.77,128.85 110.8,128.85 U70.E2
  BOTTOM w0.14: v1(107.95,129.54) 107.7,129.29 R13082.1
N84853658: length 1.2
  TOP w0.14: D25.1 108.52,138.27 R821.2
N84853670: length 1.3
  TOP w0.14: R822.2 105.86,138.27 D25.2
N84948998: length 2.6
  TOP w0.104: C2167.1 160.29,122.48 159.32,122.48 159.07,122.74 159.07,122.97 R13072.2
N84949005: length 3.1
  TOP w0.104: C2168.1 160.31,122.22 159.21,122.22 158.8,122.63 158.8,122.97 R13073.2
N84949054: length 1.5
  TOP w0.104: R13075.2 163.22,128.29 163.37,128.45 164.03,128.45 164.16,128.32 C2166.1
N84949057: length 1.5
  TOP w0.104: C2165.1 164.16,128.85 164.02,128.71 163.39,128.71 163.22,128.88 R13074.2
N84949110: length 1.5
  TOP w0.104: R13077.2 163.22,131.34 163.37,131.5 164.03,131.5 164.16,131.37 C2164.1
N84949113: length 1.5
  TOP w0.104: C2163.1 164.16,131.9 164.02,131.76 163.39,131.76 163.22,131.93 R13076.2
N85275060: length 3.2
  TOP w0.14: v1(60.96,182.37) 61.28,182.37 U113.4 R791.1
N85395811: length 5
  TOP w0.14: U113.1 64.95,181.42 R783.2 C2454.1 R793.2 67.46,180.08 R781.2
N85395871: length 4.3
  TOP w0.14: U113.3 65.84,183.33 v1(65.91,183.4) 66.68,183.4 R784.1 R794.2 67.77,182.58 67.46,182.27 R782.1
N85396360: length 1.6
  TOP w0.14: R795.1 U194.4
N85506243: length 6.9
  TOP w0.14: R12719.2 68.96,126.49 68.26,125.79 68.26,124.13 66.13,121.99 U154.H1
N85523072: length 1.6
  TOP w0.14: U136.4 102.49,176.31 v1(102.49,175.9) 102.92,175.46 R1112.2
N85655437: length 10.4
  TOP w0.14: U154.E6 v4(68.93,117.73)
  BOTTOM w0.102: TP113.1 60.36,118.92 62.15,118.92 62.94,118.13 68.52,118.13 v4(68.93,117.73)
N85655438: length 1.7
  TOP w0.14: U154.B5 v4(71.33,117.73)
  BOTTOM w0.14: v4(71.33,117.73) 71.51,117.73 TP97.1
N85655439: length 7.1
  TOP w0.14: v1(77.02,117.03) 76.57,117.47 75.95,117.47 74.56,118.86 71.8,118.86 U154.A4
  BOTTOM w0.14: TP98.1 77.17,116.87 v1(77.02,117.03)
N85663082: length 60.8
  T16 w0.117: v1(72.26,91.11) 74.93,93.78 74.93,95 76.71,96.77 79.25,96.77 80.4,97.93 88.18,97.93 92.87,102.62 95.38,102.62 98.42,105.66 102.36,105.66 105.41,108.71 105.41,111.25 107.06,112.9 110.53,112.9 v1(111.55,111.89)
  BOTTOM w0.14: U99.2 69.6,91.47 69.95,91.11 v1(72.26,91.11) ; v1(111.55,111.89) 113.67,114 113.67,115.85 114.54,116.73 U101.4
N86242490: length 15.8
  TOP w0.14: U145.4 46.99,190.08 v1(46.76,190.3)
  T18 w0.117: v1(52.07,198.12) 51.6,197.65 50.84,197.65 49.4,196.22 48.39,196.22 46.1,193.93 46.1,190.97 v1(46.76,190.3)
  BOTTOM w0.14: v1(46.76,190.3) 47.05,190.02 R1268.1 ; Q6.1 52.36,197.83 v1(52.07,198.12)
N86874213: length 4.3
  TOP w0.14: R1918.2 149.92,85.03 v1(150.62,84.33) 150.72,84.23 U175.3
N86874237: length 5.2
  TOP w0.14: U175.5 147.53,84.88 147.98,84.43 R1915.2
N86874469: length 34.8
  TOP w0.14: U168.5 33.14,54.63 v1(32.64,54.13)
  T07 w0.117: v1(6.86,39.18) 9.19,39.18 19.09,49.09 24.19,49.09 24.85,49.75 28.62,49.75 30.12,51.25 30.12,52.15 32.1,54.13 v1(32.64,54.13)
  BOTTOM w0.14: v1(6.86,39.18) 6.49,38.82 R1604.1
N86874512: length 6
  TOP w0.14: U168.2 29.92,55.93 30.75,55.1 v1(30.75,53.85) 30.75,52.44 R1667.2
N86874530: length 3.2
  TOP w0.14: R1668.2 v5(26.5,54.08) 26.67,54.25 26.67,54.86 27.09,55.28 U168.3
N86874595: length 8
  TOP w0.305: U168.8 34.87,56.58 35.48,57.2 R12762.2
  TOP w0.381: R12762.2 35.96,57.93 v1(39.37,61.34)
N86875998: length 9.3
  TOP w0.14: v1(28.96,83.69) 29.78,84.51 R12790.2 ; U139.C12 v4(23.43,86.3)
  T16 w0.117: v4(23.43,86.3) 26.04,83.69 v1(28.96,83.69)
N86876151: length 2.2
  TOP w0.14: v1(27.69,53.85) 27.69,54.18 U168.4
  BOTTOM w0.14: TP21.1 28.19,53.85 v1(27.69,53.85)
N87539978: length 8.9
  TOP w0.14: R12880.2 v1(78.3,112.8) 77.33,112.8 76.87,112.34 74.31,112.34 73.32,111.35 71.3,111.35 U154.B13
N87780347: length 3.2
  TOP w0.14: v1(139.32,173.61) 139.6,173.89 U76.5
  BOTTOM w0.14: R1988.1 139.47,173.76 v1(139.32,173.61)
N87780349: length 3.7
  TOP w0.14: v1(138.05,173.61) 138.43,173.61 138.95,174.13 U76.4
  BOTTOM w0.14: R1989.1 138.41,173.97 v1(138.05,173.61)
N855994741: length 3.7
  BOTTOM w0.381: PC233.1 PR242.2 v2(284.49,114.1)

## Copper pours and planes (outline as drawn)
GND on TOP (solid shape): 19.14,134.88 2.39,134.88 2.39,135.78 19.14,135.78
GND on TOP (solid shape): 3.29,108.78 2.39,108.78 2.39,135.79 3.29,135.79
GND on TOP (solid shape): 34.39,134.88 22.99,134.88 22.99,135.78 34.39,135.78
GND on TOP (solid shape): 34.39,108.78 22.95,108.78 22.95,109.68 34.39,109.68
GND on TOP (solid shape): 19.88,108.78 2.39,108.78 2.39,109.68 19.88,109.68
GND on TOP (solid shape): 34.39,124.05 33.49,124.05 33.49,132.15 34.39,132.15
GND on TOP (solid shape): 34.39,108.78 33.49,108.78 33.49,120.77 34.39,120.77
GND on TOP (solid shape): 35.25,26.37 35.25,24.38 34.96,24.1 27.87,24.1 27.62,24.36 27.62,26.37 27.67,26.42 35.2,26.42
GND on TOP (solid shape): 36.43,148.2 36.43,138.53 36.25,138.35 33.03,138.35 32.67,138.71 32.67,148.16 33.09,148.58 36.05,148.58
GND on TOP (solid shape): 51.67,159.02 51.67,154.76 51.45,154.54 47.02,154.54 46.5,155.06 46.5,158.76 46.9,159.16 51.53,159.16
GND on TOP (solid shape): 59.02,167.09 59.02,164.36 58.8,164.14 55.65,164.14 55.4,164.39 55.4,167.24 55.62,167.46 58.65,167.46
GND on TOP (solid shape): 67.01,190.51 67.01,187.05 66.93,186.97 65.38,186.97 65.36,187 65.36,190.51 65.46,190.61 66.91,190.61
GND on TOP (solid shape): 67.77,49.6 67.77,46.26 67.71,46.2 63.27,46.2 63.21,46.26 63.21,49.58 63.48,49.84 67.53,49.84
GND on TOP (solid shape): 118.52,150.97 118.52,146.99 118.44,146.9 115.17,146.9 114.97,147.1 114.97,150.99 115.21,151.23 118.26,151.23
GND on TOP (solid shape): 138.14,142.3 138.14,139.33 137.98,139.17 135.47,139.17 135.36,139.27 135.36,142.33 135.53,142.51 137.94,142.51
GND on TOP (solid shape): 151.7,96.78 151.7,93.88 151.47,93.65 148.69,93.65 148.5,93.85 148.5,96.87 148.61,96.99 151.49,96.99
GND on TOP (solid shape): 153.86,141.45 153.86,140.26 153.59,139.99 150.67,139.99 150.62,140.04 150.62,141.06 151.25,141.69 153.62,141.69
GND on TOP (solid shape): 192.78,106.86 192.78,103.94 192.66,103.82 191.13,103.82 191.01,103.94 191.01,106.86 191.13,106.99 192.66,106.99
GND on TOP (solid shape): 194.26,161.46 194.26,157.86 194.07,157.68 189.76,157.68 189.47,157.97 189.47,161.35 189.92,161.81 193.91,161.81
GND on TOP (solid shape): 253.37,108.71 253.37,101 252.91,100.54 247.73,100.54 247.52,100.76 247.52,108.93 247.68,109.1 252.98,109.1
GND on TOP (solid shape): 262.05,147.47 262.05,145.21 261.85,145.01 258.2,145.01 257.74,145.47 257.74,147.3 258,147.57 261.96,147.57
GND on TOP (solid shape): 288.29,175.46 288.29,172.36 287.76,171.82 269.3,171.82 268.73,172.4 268.73,175.7 269.24,176.21 287.55,176.21
GND on TOP (solid shape): 308.65,194.48 308.65,191.14 308.36,190.85 302.54,190.85 302.34,191.05 302.34,194.53 302.73,194.91 308.21,194.91
GND on TOP (solid shape): 9.51,162.68 9.51,152.04 8.73,151.26 4.5,151.26 4.05,151.71 4.05,162.78 4.33,163.06 9.13,163.06
GND on TOP (solid shape): 147.66,107.86 147.66,106.32 147.54,106.19 146.74,106.19 145.99,105.44 144.45,105.44 144.3,105.59 144.3,107.85 144.54,108.09 147.43,108.09
GND on TOP (solid shape): 24.22,163.47 24.22,151.65 23.81,151.25 20.04,151.25 19.9,151.38 19.9,155.3 19.95,155.35 19.95,163.24 20.41,163.7 23.98,163.7
GND on TOP (solid shape): 50.38,148.58 50.38,137.27 49.68,136.57 46.46,136.57 46.07,136.96 46.07,140.59 46.11,140.63 46.11,148.61 46.37,148.87 50.08,148.87
GND on TOP (solid shape): 21.08,191.9 21.08,174.31 20.77,174.01 13.84,174.01 13.84,177.89 15.82,177.89 16.02,178.1 16.02,180.92 16.22,181.11 16.22,192.14 16.47,192.4 20.58,192.4
GND on TOP (solid shape): 238.54,109.7 238.54,105.32 238.74,105.11 240.26,105.11 240.32,105.06 240.32,102.61 240.2,102.49 238.7,102.49 237.19,104 237.19,109.62 237.45,109.88 238.37,109.88
GND on TOP (solid shape): 252.1,114.66 252.1,110.89 251.91,110.7 250.66,110.7 250.52,110.84 250.52,111.11 250.2,111.43 247.82,111.43 247.55,111.71 247.55,114.83 247.62,114.89 251.88,114.89
