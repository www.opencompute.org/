# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAC_DDRB_DQ19: length 58.8
  TOP w0.14: U5.H7 v4(227.78,159.87) ; U1.AN12 v4(221.86,134.5)
  T05 w0.117: v4(221.86,134.5) 222.35,134.99 222.35,135.75 222.65,136.05 223.04,136.05 223.34,136.35 223.34,138.92 230.58,146.16 230.58,146.81 230.46,146.92 229.96,146.92 229.84,147.04 229.84,147.27 229.96,147.39 230.46,147.39 230.58,147.51 230.58,147.81 230.7,147.93 232.2,147.93 232.35,148.07 232.35,148.31 232.23,148.42 230.7,148.42 230.58,148.54 230.58,148.75 230.72,148.89 232.22,148.89 232.34,149.01 232.34,149.24 232.22,149.36 230.7,149.36 230.58,149.48 230.58,149.68 230.72,149.83 232.24,149.83 232.35,149.94 232.35,150.18 232.24,150.29 230.7,150.29 230.58,150.41 230.58,150.62 230.72,150.76 232.24,150.76 232.35,150.88 232.35,151.11 232.24,151.23 230.7,151.23 230.58,151.35 230.58,151.55 230.72,151.7 232.23,151.7 232.35,151.81 232.35,152.05 232.23,152.16 230.7,152.16 230.58,152.28 230.58,152.49 230.72,152.63 232.24,152.63 232.35,152.75 232.35,152.96 232.24,153.07 230.72,153.07 230.58,153.21 230.58,153.45 230.7,153.57 231.17,153.57 231.29,153.68 231.29,153.92 231.17,154.03 230.69,154.03 230.58,154.15 230.58,154.38 230.69,154.5 231.15,154.5 231.27,154.62 231.27,154.85 231.15,154.97 230.67,154.97 230.56,155.08 230.56,155.32 230.67,155.43 231.15,155.43 231.27,155.55 231.27,155.79 231.15,155.9 230.67,155.9 230.55,156.02 230.55,156.25 230.67,156.37 231.15,156.37 231.27,156.49 231.27,156.72 231.15,156.84 230.62,156.84 230.51,156.95 230.51,157.19 230.62,157.3 231.15,157.3 231.27,157.42 231.27,157.65 231.15,157.77 230.7,157.77 230.58,157.89 230.58,158.25 228.95,159.87 v4(227.78,159.87)
MAC_DDRB_DQ20: length 57.4
  TOP w0.14: U5.H2 v4(232.58,159.87) ; U1.AP10 v4(223.86,135.5)
  T05 w0.117: v4(223.86,135.5) 224.13,135.5 224.64,136 225.12,136 225.3,136.19 225.3,136.67 225.69,137.05 226.37,137.05 226.46,137.14 226.46,138.66 227.86,140.06 230.48,140.06 230.64,140.22 230.66,140.22 234.47,144.03 234.47,144.06 235.05,144.63 235.05,145.51 235.17,145.63 236.31,145.63 236.42,145.75 236.42,145.98 236.31,146.1 235.17,146.1 235.05,146.21 235.05,146.45 235.17,146.56 236.31,146.56 236.42,146.68 236.42,146.91 236.31,147.03 235.17,147.03 235.05,147.15 235.05,147.38 235.17,147.5 236.68,147.5 236.8,147.61 236.8,147.85 236.68,147.97 235.17,147.97 235.05,148.08 235.05,148.32 235.17,148.43 236.69,148.43 236.81,148.55 236.81,148.78 236.69,148.9 235.17,148.9 235.05,149.02 235.05,149.25 235.17,149.37 236.67,149.37 236.78,149.48 236.78,149.72 236.67,149.83 235.17,149.83 235.05,149.95 235.05,150.19 235.17,150.3 236.63,150.3 236.75,150.42 236.75,150.65 236.63,150.77 235.6,150.77 235.49,150.89 235.49,151.12 235.6,151.24 236.6,151.24 236.72,151.35 236.72,151.59 236.6,151.7 235.63,151.7 235.52,151.82 235.52,152.05 235.63,152.17 236.58,152.17 236.7,152.29 236.7,152.52 236.58,152.64 235.7,152.64 235.58,152.76 235.58,153.94 235.47,154.06 235.17,154.06 235.05,154.18 235.05,157.46 235.17,157.57 235.54,157.57 235.66,157.69 235.66,157.93 235.54,158.04 235.17,158.04 235.05,158.16 235.05,158.96 234.53,159.47 232.98,159.47 v4(232.58,159.87)
MAC_DDRB_DQ21: length 58
  TOP w0.14: U5.H8 v4(226.98,159.87) ; U1.AP12 v4(221.86,135.5)
  T05 w0.117: v4(221.86,135.5) 221.86,135.87 222.38,136.39 222.38,139.69 222.5,139.8 223.1,139.8 223.21,139.92 223.21,140.15 223.1,140.27 222.5,140.27 222.38,140.39 222.38,140.65 222.76,141.03 222.92,141.03 223.7,140.25 223.86,140.25 224.03,140.42 224.03,140.58 223.25,141.36 223.25,141.52 223.42,141.69 223.58,141.69 224.36,140.91 224.52,140.91 224.69,141.08 224.69,141.24 223.91,142.02 223.91,142.18 224.08,142.35 224.24,142.35 225.02,141.57 225.18,141.57 225.35,141.74 225.35,141.9 224.57,142.68 224.57,142.84 224.74,143.01 224.91,143.01 225.68,142.24 225.84,142.24 226.01,142.4 226.01,142.57 225.24,143.34 225.24,143.51 225.4,143.67 225.57,143.67 226.34,142.9 226.51,142.9 226.67,143.06 226.67,143.23 225.9,144 225.9,144.17 226.06,144.33 226.23,144.33 227,143.56 227.17,143.56 228.33,144.72 228.33,145.26 228.16,145.42 228,145.42 226.98,144.41 226.81,144.41 226.56,144.66 226.56,144.83 227.06,145.33 227.06,145.5 226.32,146.23 226.32,146.4 226.49,146.56 226.65,146.56 227.05,146.16 227.05,146.16 227.39,145.83 227.56,145.83 227.8,146.07 227.97,146.07 228.72,145.33 228.88,145.33 229.05,145.49 229.05,145.66 228.19,146.52 228.19,146.68 228.35,146.85 228.52,146.85 229.38,145.99 229.55,145.99 229.71,146.15 229.71,146.32 228.96,147.07 228.96,147.23 229.39,147.66 229.39,147.82 229.27,147.94 229.27,148.1 229.44,148.27 229.61,148.27 229.72,148.15 229.88,148.15 229.97,148.24 229.97,148.92 229.85,149.04 229.78,149.04 229.67,149.16 229.67,149.39 229.78,149.51 229.85,149.51 229.97,149.62 229.97,158.4 228.9,159.47 227.38,159.47 v4(226.98,159.87)
MAC_DDRB_DQ22: length 61.9
  TOP w0.14: U5.J3 v4(231.78,161.47) ; U1.AM13 v4(220.86,133.5)
  T05 w0.102: 231.09,139.43 228.07,139.43
  T05 w0.117: 228.07,139.43 227.32,138.68 227.32,137.24 227.02,136.93 226.56,136.93 226.34,136.71 226.34,136.11 226.15,135.92 225.54,135.92 225.35,135.73 225.35,135.25 225.07,134.97 224.46,134.97 224.34,134.86 224.34,134.2 224.11,133.96 221.32,133.96 v4(220.86,133.5) ; 231.09,139.43 232.25,139.43 232.38,139.55 232.38,139.92 231.87,140.42 231.87,140.59 232.04,140.75 232.2,140.75 232.71,140.25 232.87,140.25 233.04,140.41 233.04,140.58 232.53,141.09 232.53,141.25 232.7,141.42 232.86,141.42 233.28,140.99 233.45,140.99 233.61,141.16 233.61,141.32 233.19,141.75 233.19,141.91 233.36,142.08 233.52,142.08 233.97,141.63 234.14,141.63 234.31,141.79 234.31,141.96 233.85,142.41 233.85,142.57 234.02,142.74 234.18,142.74 234.69,142.23 234.86,142.23 235.02,142.4 235.02,142.56 234.52,143.07 234.52,143.23 234.68,143.4 234.85,143.4 235.35,142.89 235.52,142.89 235.68,143.06 235.68,143.22 235.18,143.73 235.18,143.9 235.33,144.05 235.49,144.05 236.05,143.49 236.25,143.49 236.36,143.61 236.36,143.81 235.74,144.44 235.74,144.63 235.9,144.8 236.07,144.8 236.73,144.13 237.45,144.13 237.65,144.33 237.65,154.01 237.54,154.12 236.59,154.12 236.47,154.24 236.47,154.47 236.59,154.59 237.01,154.59 237.13,154.71 237.13,154.94 237.01,155.06 236.59,155.06 236.47,155.17 236.47,155.41 236.59,155.52 237.01,155.52 237.13,155.64 237.13,155.87 237.01,155.99 236.59,155.99 236.47,156.11 236.47,156.34 236.59,156.46 237.01,156.46 237.13,156.58 237.13,156.81 237.01,156.93 236.59,156.93 236.47,157.04 236.47,157.28 236.59,157.39 237.01,157.39 237.13,157.51 237.13,157.87 236.44,158.56 236.27,158.56 236.16,158.45 235.99,158.45 235.83,158.62 235.83,158.78 235.94,158.89 235.94,159.06 234.16,160.84 231.9,160.84 231.78,160.96 v4(231.78,161.47)
MAC_DDRB_DQ23: length 59.4
  TOP w0.14: v4(229.38,158.27) 228.72,158.94 228.72,160.38 228.18,160.91 U5.J7 ; U1.AP13 v4(220.86,135.5)
  T05 w0.117: v4(229.38,158.27) 229.06,157.95 229.06,157.44 229.17,157.32 229.19,157.32 229.31,157.2 229.31,156.97 229.19,156.85 229.17,156.85 229.06,156.74 229.06,156.5 229.17,156.38 229.19,156.38 229.31,156.27 229.31,156.03 229.19,155.92 229.17,155.92 229.06,155.8 229.06,155.57 229.17,155.45 229.19,155.45 229.31,155.33 229.31,155.1 229.19,154.98 229.17,154.98 229.06,154.87 229.06,154.63 229.17,154.52 229.19,154.52 229.31,154.4 229.31,154.16 229.19,154.05 229.17,154.05 229.06,153.93 229.06,153.7 229.17,153.58 229.19,153.58 229.31,153.46 229.31,153.23 229.19,153.11 229.17,153.11 229.06,153 229.06,152.76 229.17,152.65 229.19,152.65 229.31,152.53 229.31,152.3 229.19,152.18 229.17,152.18 229.06,152.06 229.06,151.83 229.17,151.71 229.19,151.71 229.31,151.59 229.31,151.36 229.19,151.24 229.17,151.24 229.06,151.13 229.06,150.89 229.17,150.78 229.19,150.78 229.31,150.66 229.31,150.43 229.19,150.31 229.17,150.31 229.06,150.19 229.06,149.31 228.87,149.12 228,149.12 227.84,148.96 227.84,148.67 228.55,147.95 228.55,147.79 228.24,147.47 228.07,147.47 226.92,148.63 226.75,148.63 226.59,148.46 226.59,148.22 227.68,147.13 227.68,146.97 227.45,146.74 227.29,146.74 225.38,148.64 225.22,148.64 225.05,148.48 225.05,148.31 226.13,147.23 226.13,147.07 225.47,146.41 225.47,146.25 226.2,145.52 226.2,145.36 226.03,145.19 225.87,145.19 225.14,145.91 224.98,145.91 224.81,145.75 224.81,145.58 225.57,144.83 225.57,144.66 225.4,144.5 225.24,144.5 224.48,145.25 224.32,145.25 224.15,145.09 224.15,144.92 224.91,144.16 224.91,144 224.74,143.83 224.58,143.83 223.82,144.59 223.66,144.59 223.49,144.43 223.49,144.26 224.24,143.51 224.24,143.35 224.07,143.18 223.91,143.18 223.11,143.98 222.94,143.98 222.78,143.82 222.78,143.65 223.58,142.85 223.58,142.68 223.42,142.52 223.25,142.52 222.4,143.37 222.23,143.37 222.07,143.2 222.07,143.04 222.92,142.19 222.92,142.02 222.75,141.86 222.59,141.86 221.84,142.61 221.67,142.61 221.39,142.32 221.39,141.7 221.27,141.58 221.07,141.58 220.95,141.47 220.95,141.23 221.07,141.12 221.7,141.12 221.82,141 221.82,140.76 221.7,140.65 221.07,140.65 220.95,140.53 220.95,140.3 221.07,140.18 221.7,140.18 221.82,140.06 221.82,139.83 221.7,139.71 221.07,139.71 220.95,139.6 220.95,139.36 221.07,139.25 221.27,139.25 221.39,139.13 221.39,136.02 v4(220.86,135.5)
MAC_DDRB_DQ24: length 57.3
  TOP w0.14: U1.AP16 v4(217.86,135.5) ; U5.A3 v4(231.78,154.27)
  T18 w0.117: v4(217.86,135.5) 217.86,135.81 217.37,136.3 217.37,138.87 217.48,138.99 217.55,138.99 217.67,139.1 217.67,139.34 217.55,139.45 217.48,139.45 217.37,139.57 217.37,139.84 223.57,146.04 230.71,146.04 230.82,146.15 230.82,146.37 230.94,146.49 231.17,146.49 231.29,146.37 231.29,146.15 231.41,146.04 231.79,146.04 231.91,146.15 231.91,146.63 231.58,146.96 231.58,147.13 231.74,147.29 231.91,147.29 232.46,146.74 232.46,146.16 232.58,146.04 233.03,146.04 233.15,146.16 233.15,147.23 233.03,147.35 232.8,147.35 232.68,147.47 232.68,147.74 232.75,147.82 233.03,147.82 233.15,147.93 233.15,148.03 233.26,148.15 233.58,148.15 233.69,148.03 233.69,146.96 233.81,146.84 234.04,146.84 234.16,146.96 234.16,148.03 234.28,148.15 234.78,148.15 234.9,148.26 234.9,148.5 234.78,148.61 233.26,148.61 233.15,148.73 233.15,148.96 233.26,149.08 234.78,149.08 234.9,149.2 234.9,149.43 234.78,149.55 233.26,149.55 233.15,149.67 233.15,149.9 233.26,150.02 234.78,150.02 234.9,150.13 234.9,150.37 234.78,150.48 233.26,150.48 233.15,150.6 233.15,150.83 233.26,150.95 234.78,150.95 234.9,151.07 234.9,151.3 234.78,151.42 233.26,151.42 233.15,151.53 233.15,151.86 233.26,151.98 234.43,151.98 234.59,152.15 234.59,152.33 234.48,152.45 233.26,152.45 233.15,152.56 233.15,152.86 233.26,152.97 233.74,152.97 233.89,153.12 233.89,153.29 233.74,153.44 233.26,153.44 233.15,153.56 233.15,153.74 232.98,153.9 232.98,154.56 232.87,154.67 231.9,154.67 231.78,154.56 v4(231.78,154.27)
MAC_DDRB_DQ25: length 61
  TOP w0.14: U5.B8 v4(226.98,155.07) ; U1.AM19 v4(214.86,133.5)
  T18 w0.117: v4(214.86,133.5) 215.18,133.5 215.29,133.61 215.29,134.9 215.16,135.04 214.49,135.04 214.37,134.92 214.37,134.44 214.24,134.31 213.94,134.31 213.83,134.43 213.83,140.22 214.2,140.6 214.2,140.77 213.84,141.13 213.84,141.29 214.01,141.46 214.17,141.46 214.53,141.1 214.7,141.1 215.12,141.52 215.12,141.68 214.01,142.79 214.01,142.95 214.18,143.12 214.35,143.12 215.45,142.01 215.62,142.01 215.81,142.21 215.81,142.38 215.66,142.53 215.66,142.69 215.83,142.86 215.99,142.86 216.14,142.71 216.31,142.71 216.48,142.87 216.48,143.04 216.32,143.19 216.32,143.36 216.49,143.52 216.65,143.52 216.81,143.37 216.97,143.37 217.14,143.53 217.14,143.7 216.98,143.85 216.98,144.02 217.15,144.18 217.32,144.18 217.47,144.03 217.63,144.03 217.8,144.2 217.8,144.36 217.65,144.51 217.65,144.68 217.81,144.84 217.98,144.84 218.13,144.69 218.29,144.69 218.46,144.86 218.46,145.02 218.31,145.17 218.31,145.34 218.47,145.51 218.64,145.51 218.79,145.35 218.96,145.35 219.12,145.52 219.12,145.68 218.97,145.84 218.97,146 219.13,146.17 219.3,146.17 219.45,146.01 219.62,146.01 219.78,146.18 219.78,146.35 219.63,146.5 219.63,146.66 219.8,146.83 219.96,146.83 220.11,146.68 220.28,146.68 220.44,146.84 220.44,147.01 220.29,147.16 220.29,147.32 220.46,147.49 220.62,147.49 220.77,147.34 220.94,147.34 221.11,147.5 221.11,147.67 220.95,147.82 220.95,147.99 221.12,148.15 221.28,148.15 221.44,148 221.6,148 221.77,148.16 221.77,148.33 221.61,148.48 221.61,148.65 221.78,148.81 221.94,148.81 222.1,148.66 222.26,148.66 222.71,149.1 223.03,149.1 223.15,148.99 223.15,148.61 223.27,148.49 223.5,148.49 223.62,148.61 223.62,148.99 223.73,149.1 223.97,149.1 224.08,148.99 224.08,148.61 224.2,148.49 224.43,148.49 224.55,148.61 224.55,149.37 224.75,149.57 225.97,149.57 226.09,149.69 226.09,149.86 225.97,149.97 223.41,149.97 223.29,150.09 223.29,150.32 223.41,150.44 225.95,150.44 226.09,150.58 226.09,150.79 225.97,150.91 223.41,150.91 223.29,151.03 223.29,151.26 223.41,151.38 225.95,151.38 226.09,151.52 226.09,151.75 225.97,151.87 224.47,151.87 224.36,151.99 224.36,152.22 224.47,152.34 225.97,152.34 226.09,152.45 226.09,152.7 225.97,152.82 225.39,152.82 225.27,152.94 225.27,153.17 225.39,153.29 225.97,153.29 226.58,153.9 226.58,154.44 226.98,154.84 v4(226.98,155.07)
MAC_DDRB_DQ26: length 63.6
  TOP w0.14: U5.C3 v4(231.78,155.87) ; U1.AK20 v4(212.86,131.5)
  T18 w0.117: v4(212.86,131.5) 212.62,131.5 212.11,132.01 211.55,132.01 211.36,132.2 211.36,144.77 211.99,145.4 211.99,145.56 211.23,146.33 211.23,146.49 211.39,146.66 211.56,146.66 212.32,145.9 212.49,145.9 212.65,146.06 212.65,146.23 211.89,146.99 211.89,147.15 212.06,147.32 212.22,147.32 212.98,146.56 213.15,146.56 213.31,146.72 213.31,146.89 212.55,147.65 212.55,147.81 212.72,147.98 212.88,147.98 213.64,147.22 213.81,147.22 213.98,147.38 213.98,147.55 213.21,148.31 213.21,148.48 213.38,148.64 213.54,148.64 214.31,147.88 214.47,147.88 214.64,148.04 214.64,148.21 213.87,148.97 213.87,149.14 214.04,149.3 214.21,149.3 214.97,148.54 215.13,148.54 215.3,148.71 215.3,148.87 214.54,149.63 214.54,149.8 214.7,149.96 214.87,149.96 215.63,149.2 215.79,149.2 215.96,149.37 215.96,149.53 215.2,150.29 215.2,150.46 215.36,150.63 215.53,150.63 216.29,149.86 216.46,149.86 216.62,150.03 216.62,150.19 215.86,150.96 215.86,151.12 216.02,151.29 216.19,151.29 216.95,150.52 217.12,150.52 217.28,150.69 217.28,150.86 216.52,151.62 216.52,151.78 216.69,151.95 216.85,151.95 217.61,151.19 217.78,151.19 218.62,152.03 221.47,152.03 222.76,153.32 222.76,155.8 223.24,156.27 U5.C3 v4(231.78,155.87)
MAC_DDRB_DQ27: length 60.5
  TOP w0.14: U1.AM17 v4(216.86,133.5) ; U5.C7 v4(227.78,155.87)
  T18 w0.117: v4(216.86,133.5) 216.86,133.15 216.74,133.03 215.53,133.03 215.38,132.89 215.38,132.58 215.25,132.45 214.14,132.45 213.39,133.2 213.39,138.87 213.02,139.25 213.02,142.77 214.46,144.21 214.62,144.21 215.38,143.45 215.55,143.45 215.71,143.61 215.71,143.78 214.95,144.54 214.95,144.7 215.17,144.92 215.33,144.92 216.08,144.17 216.25,144.17 216.41,144.33 216.41,144.5 215.66,145.25 215.66,145.41 215.83,145.58 215.99,145.58 216.74,144.83 216.91,144.83 217.07,145 217.07,145.16 216.32,145.91 216.32,146.07 216.49,146.24 216.65,146.24 217.4,145.49 217.57,145.49 217.73,145.66 217.73,145.82 216.99,146.57 216.99,146.74 217.15,146.9 217.32,146.9 218.07,146.15 218.23,146.15 218.4,146.32 218.4,146.48 217.65,147.23 217.65,147.4 217.81,147.56 217.98,147.56 218.73,146.81 218.89,146.81 219.06,146.98 219.06,147.14 218.31,147.89 218.31,148.06 218.47,148.22 218.64,148.22 219.39,147.48 219.55,147.48 219.72,147.64 219.72,147.81 218.97,148.56 218.97,148.72 219.14,148.89 219.3,148.89 220.05,148.14 220.21,148.14 220.38,148.3 220.38,148.47 219.63,149.22 219.63,149.38 219.8,149.55 219.96,149.55 220.71,148.8 220.88,148.8 221.04,148.96 221.04,149.13 220.29,149.88 220.29,150.04 220.46,150.21 220.62,150.21 221.37,149.46 221.54,149.46 221.85,149.78 221.85,149.94 221.32,150.47 221.32,150.64 221.49,150.8 221.65,150.8 222.18,150.27 222.6,150.27 222.72,150.39 222.72,150.58 222.6,150.7 222.42,150.7 222.3,150.81 222.3,151.05 222.42,151.17 222.6,151.17 222.72,151.28 222.72,151.5 225.89,154.67 226.43,154.67 226.58,154.82 226.58,155.24 226.82,155.47 227.62,155.47 227.78,155.63 v4(227.78,155.87)
MAC_DDRB_DQ28: length 56.9
  TOP w0.14: U5.C2 v4(232.58,155.87) ; U1.AP15 v4(218.86,135.5)
  T18 w0.117: v4(218.86,135.5) 218.49,135.5 218.37,135.61 218.37,140.02 223.81,145.46 233.57,145.46 235.53,147.43 235.53,147.73 235.65,147.85 235.95,147.85 236.07,147.97 236.07,148.2 235.95,148.32 235.65,148.32 235.53,148.43 235.53,148.78 235.65,148.9 236.36,148.9 236.47,149.01 236.47,149.25 236.36,149.36 235.65,149.36 235.53,149.48 235.53,149.71 235.65,149.83 236.36,149.83 236.47,149.95 236.47,150.18 236.36,150.3 235.65,150.3 235.53,150.41 235.53,150.65 235.65,150.77 236.36,150.77 236.47,150.88 236.47,151.12 236.36,151.23 235.65,151.23 235.53,151.35 235.53,151.58 235.65,151.7 236.36,151.7 236.47,151.82 236.47,152.05 236.36,152.17 235.65,152.17 235.53,152.28 235.53,152.48 234.68,153.34 234.68,153.5 235.2,154.02 235.2,154.19 235.03,154.35 234.87,154.35 234.35,153.83 234.18,153.83 233.88,154.13 233.88,154.6 234,154.72 234.99,154.72 235.11,154.83 235.11,155.18 234.99,155.3 234.6,155.3 234.48,155.41 234.48,155.71 234.6,155.83 234.78,155.83 234.9,155.94 234.9,156.18 234.78,156.29 234.6,156.29 234.48,156.41 234.48,156.64 234.6,156.76 234.78,156.76 234.9,156.88 234.9,157.11 234.78,157.23 234.6,157.23 234.48,157.34 234.48,157.58 234.6,157.69 234.78,157.69 234.9,157.81 234.9,158.05 234.78,158.16 234.6,158.16 234.48,158.28 234.48,159.12 234.36,159.24 234.14,159.24 234.01,159.11 234.01,155.59 233.9,155.47 232.7,155.47 232.58,155.59 v4(232.58,155.87)
MAC_DDRB_DQ29: length 64.3
  TOP w0.14: U1.AJ19 v4(214.86,130.5) ; U5.C8 v4(226.98,155.87)
  T18 w0.117: v4(226.98,155.87) 226.81,155.87 226.41,155.47 224.1,155.47 223.75,155.12 223.75,153.42 221.73,151.4 220.84,151.4 219.99,150.55 219.82,150.55 218.99,151.39 218.82,151.39 218.66,151.23 218.66,151.06 219.49,150.22 219.49,150.06 219.33,149.89 219.16,149.89 218.32,150.73 218.16,150.73 217.99,150.56 217.99,150.4 218.83,149.56 218.83,149.4 218.67,149.23 218.5,149.23 217.66,150.07 217.5,150.07 217.33,149.9 217.33,149.74 218.17,148.9 218.17,148.73 218.01,148.57 217.84,148.57 217,149.41 216.84,149.41 216.67,149.24 216.67,149.08 217.51,148.24 217.51,148.07 217.34,147.91 217.18,147.91 216.34,148.75 216.18,148.75 216.01,148.58 216.01,148.41 216.85,147.58 216.85,147.41 216.68,147.25 216.52,147.25 215.68,148.08 215.51,148.08 215.35,147.92 215.35,147.75 216.19,146.92 216.19,146.75 216.02,146.58 215.86,146.58 215.02,147.42 214.85,147.42 214.69,147.26 214.69,147.09 215.53,146.25 215.53,146.09 215.36,145.92 215.19,145.92 214.36,146.76 214.19,146.76 214.03,146.6 214.03,146.43 214.86,145.59 214.86,145.43 214.7,145.26 214.53,145.26 213.7,146.1 213.53,146.1 213.36,145.93 213.36,145.77 214.2,144.93 214.2,144.77 214.04,144.6 213.87,144.6 213.03,145.44 212.87,145.44 212.7,145.27 212.7,145.11 213.54,144.27 213.54,144.1 213.38,143.94 213.21,143.94 212.37,144.78 212.21,144.78 212.04,144.61 212.04,144.45 212.88,143.61 212.88,143.44 212.37,142.93 212.37,132.36 212.73,132 213.36,132 v4(214.86,130.5)
MAC_DDRB_DQ30: length 63.5
  TOP w0.14: U5.D3 v4(231.78,156.67) ; U1.AH21 v4(211.86,129.5)
  T18 w0.117: v4(231.78,156.67) 230.58,157.87 227.95,157.87 227.95,157.87 226.02,157.87 226.01,157.87 222.2,157.87 222.09,157.99 222.09,158.19 221.97,158.3 221.73,158.3 221.62,158.19 221.62,157.99 221.5,157.87 221.27,157.87 221.15,157.99 221.15,158.19 221.03,158.3 220.8,158.3 220.68,158.19 220.68,157.99 220.57,157.87 220.03,157.87 219.82,157.66 219.82,153.7 219.53,153.41 214.86,153.41 214.16,152.71 213.99,152.71 213.3,153.4 213.13,153.4 212.97,153.23 212.97,153.07 213.66,152.38 213.66,152.21 213.5,152.05 213.33,152.05 212.64,152.74 212.47,152.74 212.31,152.57 212.31,152.41 213,151.71 213,151.55 212.84,151.38 212.67,151.38 211.98,152.08 211.81,152.08 211.65,151.91 211.65,151.75 212.34,151.05 212.34,150.89 212.17,150.72 212.01,150.72 211.32,151.42 211.15,151.42 210.98,151.25 210.98,151.09 211.68,150.39 211.68,150.23 209.36,147.91 209.36,147.06 209.47,146.94 209.66,146.94 209.78,146.82 209.78,146.59 209.66,146.47 209.47,146.47 209.36,146.36 209.36,146.12 209.47,146.01 209.66,146.01 209.78,145.89 209.78,145.66 209.66,145.54 209.47,145.54 209.36,145.42 209.36,144.9 209.47,144.79 209.51,144.79 209.62,144.67 209.62,144.44 209.51,144.32 209.47,144.32 209.36,144.2 209.36,143.97 209.47,143.85 209.51,143.85 209.62,143.73 209.62,143.5 209.51,143.38 209.47,143.38 209.36,143.27 209.36,143.03 209.47,142.92 209.51,142.92 209.62,142.8 209.62,142.57 209.51,142.45 209.47,142.45 209.36,142.33 209.36,142.1 209.47,141.98 209.51,141.98 209.62,141.86 209.62,141.63 209.51,141.51 209.47,141.51 209.36,141.4 209.36,141.16 209.47,141.05 209.51,141.05 209.62,140.93 209.62,140.7 209.51,140.58 209.47,140.58 209.36,140.46 209.36,140.23 209.47,140.11 209.51,140.11 209.62,140 209.62,139.76 209.51,139.64 209.47,139.64 209.36,139.53 209.36,130.37 209.73,130 211.36,130 v4(211.86,129.5)
MAC_DDRB_DQ31: length 64.3
  TOP w0.14: U1.AJ20 v4(212.86,130.5) ; U5.D7 v4(227.78,156.67)
  T18 w0.117: v4(212.86,130.5) 212.37,130.99 210.66,130.99 210.33,131.31 210.33,139.25 210.79,139.7 210.79,140.09 210.67,140.21 210.3,140.21 210.18,140.32 210.18,140.56 210.3,140.67 210.67,140.67 210.79,140.79 210.79,141.02 210.67,141.14 210.3,141.14 210.18,141.26 210.18,141.49 210.3,141.61 210.67,141.61 210.79,141.73 210.79,141.96 210.67,142.08 210.3,142.08 210.18,142.19 210.18,142.43 210.3,142.54 210.67,142.54 210.79,142.66 210.79,142.89 210.67,143.01 210.3,143.01 210.18,143.13 210.18,143.36 210.3,143.48 210.67,143.48 210.79,143.6 210.79,143.83 210.67,143.95 210.3,143.95 210.18,144.06 210.18,144.3 210.3,144.41 210.67,144.41 210.79,144.53 210.79,144.76 210.67,144.88 210.3,144.88 210.18,145 210.18,145.23 210.3,145.35 210.67,145.35 210.79,145.46 210.79,145.81 210.56,146.03 210.56,146.64 210.55,146.65 210.82,146.92 210.82,147.08 210.29,147.6 210.19,147.7 210.19,147.87 210.36,148.03 210.52,148.03 210.95,147.6 211.15,147.41 211.31,147.41 211.48,147.58 211.48,147.74 210.85,148.36 210.85,148.53 211.02,148.7 211.19,148.7 211.81,148.07 211.97,148.07 212.14,148.24 212.14,148.4 211.52,149.03 211.52,149.19 211.68,149.36 211.85,149.36 212.47,148.73 212.63,148.73 212.8,148.9 212.8,149.06 212.18,149.69 212.18,149.85 212.34,150.02 212.51,150.02 213.13,149.4 213.3,149.4 213.46,149.56 213.46,149.73 212.84,150.35 212.84,150.51 213,150.68 213.17,150.68 213.79,150.06 213.96,150.06 214.12,150.22 214.12,150.39 213.5,151.01 213.5,151.18 213.67,151.34 213.83,151.34 214.45,150.72 214.62,150.72 214.78,150.88 214.78,151.05 214.16,151.67 214.16,151.84 214.33,152 214.49,152 215.11,151.38 215.28,151.38 215.45,151.55 215.45,151.71 214.82,152.33 214.82,152.5 214.99,152.66 215.15,152.66 215.78,152.04 215.94,152.04 216.55,152.65 220.57,152.65 221.88,153.97 221.88,156.76 222.19,157.07 227.38,157.07 v4(227.78,156.67)
MAC_DDRB_DQS0_DN: length 72.1
  TOP w0.102: U1.AU15 v4(218.86,138.5) ; U4.F3 v4(243.96,159.07)
  T16 w0.107: v4(243.96,159.07) 243.69,158.81 243.69,157.85 243.05,157.2 242.14,157.2 242.04,157.09 242.04,156.88 242.14,156.77 243.06,156.77 243.34,156.5 243.34,156.06 243.06,155.79 242.14,155.79 242.04,155.68 242.04,155.47 242.14,155.36 243.06,155.36 243.34,155.09 243.34,154.65 243.06,154.38 242.14,154.38 242.04,154.27 242.04,154.06 242.14,153.95 243.06,153.95 243.34,153.68 243.34,153.23 243.06,152.96 242.14,152.96 242.04,152.86 242.04,152.64 242.14,152.54 243.06,152.54 243.34,152.27 243.34,151.82 243.06,151.55 242.14,151.55 242.04,151.44 242.04,151.23 242.14,151.12 243.06,151.12 243.34,150.85 243.34,150.28 243.06,150.01 242.09,150.01 241.98,149.9 241.98,149.69 242.09,149.58 243.06,149.58 243.34,149.31 243.34,148.08 242.66,147.4 242.27,147.4 240.91,148.77 240.75,148.77 240.6,148.62 240.6,148.47 241.97,147.1 241.97,146.72 241.66,146.41 241.27,146.41 239.91,147.77 239.75,147.77 239.6,147.62 239.6,147.47 240.97,146.1 240.97,145.72 240.66,145.41 240.28,145.41 238.91,146.77 238.76,146.77 238.6,146.62 238.6,146.47 239.97,145.1 239.97,144.72 239.66,144.41 239.28,144.41 237.91,145.78 237.76,145.78 237.61,145.62 237.61,145.47 238.97,144.11 238.97,143.72 238.29,143.04 221.9,143.04 218.5,139.64 218.5,138.6 218.61,138.5 v4(218.86,138.5)
MAC_DDRB_DQS0_DP: length 72.1
  TOP w0.102: U4.G3 v4(243.16,159.07) ; U1.AU16 v4(217.86,138.5)
  T16 w0.107: v4(243.16,159.07) 243.42,158.81 243.42,157.96 242.93,157.48 242.03,157.48 241.76,157.21 241.76,156.76 242.03,156.49 242.95,156.49 243.06,156.39 243.06,156.17 242.95,156.07 242.03,156.07 241.76,155.8 241.76,155.35 242.03,155.08 242.95,155.08 243.06,154.97 243.06,154.76 242.95,154.65 242.03,154.65 241.76,154.38 241.76,153.94 242.03,153.67 242.95,153.67 243.06,153.56 243.06,153.35 242.95,153.24 242.03,153.24 241.76,152.97 241.76,152.53 242.03,152.26 242.95,152.26 243.06,152.15 243.06,151.94 242.95,151.83 242.03,151.83 241.76,151.56 241.76,151.11 242.03,150.84 242.95,150.84 243.06,150.74 243.06,150.39 242.95,150.28 241.98,150.28 241.71,150.01 241.71,149.57 241.98,149.3 242.95,149.3 243.06,149.19 243.06,148.2 242.54,147.68 242.39,147.68 241.02,149.05 240.64,149.05 240.32,148.74 240.32,148.36 241.69,146.99 241.69,146.84 241.54,146.69 241.39,146.69 240.02,148.05 239.64,148.05 239.32,147.74 239.32,147.36 240.69,145.99 240.69,145.84 240.54,145.69 240.39,145.69 239.02,147.05 238.64,147.05 238.33,146.74 238.33,146.36 239.69,144.99 239.69,144.84 239.54,144.69 239.39,144.69 238.02,146.06 237.64,146.06 237.33,145.74 237.33,145.36 238.69,143.99 238.69,143.84 238.17,143.32 221.79,143.32 218.22,139.75 218.22,138.6 218.07,138.46 217.9,138.46 v4(217.86,138.5)
MAC_DDRB_DQS1_DN: length 70.3
  TOP w0.102: U1.AT12 v4(221.86,137.5) ; U4.A7 v4(239.95,154.27)
  T18 w0.107: v4(221.86,137.5) 221.36,138 221.36,139.4 224.2,142.24 225.34,142.24 225.61,141.97 225.61,141.49 225.72,141.38 225.93,141.38 226.04,141.49 226.04,141.97 226.31,142.24 226.75,142.24 227.02,141.97 227.02,141.49 227.13,141.38 227.34,141.38 227.45,141.49 227.45,141.97 227.72,142.24 228.16,142.24 228.43,141.97 228.43,141.49 228.54,141.38 228.75,141.38 228.86,141.49 228.86,141.97 229.13,142.24 229.58,142.24 229.85,141.97 229.85,141.49 229.95,141.38 230.17,141.38 230.27,141.49 230.27,141.97 230.54,142.24 230.99,142.24 231.26,141.97 231.26,141.49 231.37,141.38 231.58,141.38 231.69,141.49 231.69,141.97 231.96,142.24 232.4,142.24 232.67,141.97 232.67,141.49 232.78,141.38 232.99,141.38 233.1,141.49 233.1,141.97 233.37,142.24 236.89,142.24 237.06,142.07 237.45,142.07 237.56,142.17 237.56,143.3 237.92,143.66 238.39,143.66 238.66,143.39 238.66,141.31 238.76,141.2 238.92,141.2 239.02,141.31 239.02,143.68 239.29,143.95 240.11,143.95 240.38,143.68 240.38,141.23 240.58,141.03 241.34,141.03 242.13,141.83 242.13,142.07 241.14,143.07 241.14,143.5 241.54,143.9 241.96,143.9 242.91,142.95 243.06,142.95 243.41,143.3 243.41,143.45 242.88,143.98 242.88,144.4 243.15,144.67 243.58,144.67 244.07,144.18 244.48,144.18 244.71,144.42 244.71,145.2 244.61,145.31 243.35,145.31 243.08,145.58 243.08,146.03 243.41,146.36 244.62,146.36 244.72,146.46 244.72,146.68 244.62,146.78 243.63,146.78 243.36,147.05 243.36,147.59 243.63,147.86 244.62,147.86 244.73,147.96 244.73,148.18 244.62,148.28 243.63,148.28 243.36,148.55 243.36,149.78 242.83,150.3 242.83,150.68 243.05,150.9 243.05,151.05 242.9,151.2 242.75,151.2 242.53,150.98 242.15,150.98 240.47,152.66 240.47,153.21 240.37,153.31 240.27,153.31 240.16,153.42 240.16,153.63 240.27,153.74 240.37,153.74 240.47,153.85 240.47,154.43 240.37,154.53 240.06,154.53 239.95,154.43 v4(239.95,154.27)
MAC_DDRB_DQS1_DP: length 70.5
  TOP w0.102: U1.AU12 v4(221.86,138.5) ; U4.B7 v4(239.95,155.07)
  T18 w0.107: v4(239.95,155.07) 239.95,155.07 239.95,154.92 240.06,154.81 240.48,154.81 240.75,154.54 240.75,152.77 241.3,152.23 241.45,152.23 241.58,152.35 241.77,152.35 241.9,152.22 241.9,152.07 241.75,151.93 241.75,151.77 242.26,151.26 242.41,151.26 242.63,151.48 243.01,151.48 243.33,151.16 243.33,150.78 243.11,150.57 243.11,150.42 243.64,149.89 243.64,148.67 243.74,148.56 244.74,148.56 245.01,148.29 245.01,147.85 244.74,147.58 243.74,147.58 243.64,147.47 243.64,147.17 243.74,147.06 244.73,147.06 245,146.79 245,146.35 244.73,146.08 243.52,146.08 243.36,145.91 243.36,145.7 243.46,145.59 244.72,145.59 244.99,145.32 244.99,144.31 244.59,143.9 243.95,143.9 243.46,144.39 243.27,144.39 243.16,144.29 243.16,144.09 243.69,143.56 243.69,143.18 243.18,142.67 242.79,142.67 241.85,143.62 241.65,143.62 241.42,143.38 241.42,143.18 242.41,142.19 242.41,141.72 241.45,140.75 240.47,140.75 240.1,141.12 240.1,143.56 240,143.67 239.41,143.67 239.3,143.56 239.3,141.19 239.03,140.92 238.65,140.92 238.38,141.19 238.38,143.28 238.27,143.38 238.03,143.38 237.84,143.19 237.84,142.06 237.57,141.79 236.95,141.79 236.77,141.96 233.48,141.96 233.38,141.86 233.38,141.37 233.11,141.1 232.66,141.1 232.39,141.37 232.39,141.86 232.28,141.96 232.07,141.96 231.96,141.86 231.96,141.37 231.69,141.1 231.25,141.1 230.98,141.37 230.98,141.86 230.87,141.96 230.66,141.96 230.55,141.86 230.55,141.37 230.28,141.1 229.84,141.1 229.57,141.37 229.57,141.86 229.46,141.96 229.25,141.96 229.14,141.86 229.14,141.37 228.87,141.1 228.42,141.1 228.15,141.37 228.15,141.86 228.05,141.96 227.83,141.96 227.73,141.86 227.73,141.37 227.46,141.1 227.01,141.1 226.74,141.37 226.74,141.86 226.64,141.96 226.42,141.96 226.32,141.86 226.32,141.37 226.05,141.1 225.6,141.1 225.33,141.37 225.33,141.86 225.22,141.96 224.32,141.96 223.08,140.73 223.08,140.58 223.12,140.55 223.12,140.4 222.97,140.25 222.82,140.25 222.78,140.28 222.63,140.28 222.48,140.13 222.48,139.98 222.51,139.94 222.51,139.79 222.36,139.64 222.21,139.64 222.18,139.67 222.03,139.67 221.64,139.29 221.64,138.6 221.75,138.5 v4(221.86,138.5)
MAC_DDRB_DQS2_DN: length 64.9
  TOP w0.102: U1.AL16 v4(217.86,132.5)
  TOP w0.14: U5.F3 v4(231.78,158.27)
  T05 w0.107: v4(231.78,158.27) 231.52,158.53 231.29,158.53 229.29,160.53 223.6,160.53 222.66,159.59 222.66,158.47 222.83,158.29 222.83,158.04 222.66,157.86 222.66,157.61 222.83,157.44 222.83,157.19 222.66,157.01 222.66,153.65 222.38,153.38 220.37,153.38 220.27,153.27 220.27,153.06 220.37,152.95 222.38,152.95 222.66,152.68 222.66,152.24 222.38,151.97 220.37,151.97 220.27,151.86 220.27,151.65 220.37,151.54 222.38,151.54 222.66,151.27 222.66,150.83 222.38,150.56 220.37,150.56 220.27,150.45 220.27,150.24 220.37,150.13 222.38,150.13 222.66,149.86 222.66,149.41 222.38,149.14 220.37,149.14 220.27,149.04 220.27,148.82 220.37,148.72 222.38,148.72 222.66,148.45 222.66,148.07 221.15,146.56 220.76,146.56 220.05,147.27 219.9,147.27 219.75,147.12 219.75,146.97 220.46,146.26 220.46,145.88 220.15,145.56 219.76,145.56 219.08,146.25 218.93,146.25 218.78,146.1 218.78,145.94 219.46,145.26 219.46,144.88 219.15,144.56 218.76,144.56 218.43,144.9 218.28,144.9 218.13,144.75 218.13,144.59 218.46,144.26 218.46,143.88 217.99,143.41 217.99,140.7 218.1,140.59 218.1,140.59 218.21,140.49 218.21,140.27 218.1,140.17 218.1,140.17 217.99,140.06 217.99,139.85 218.1,139.74 218.1,139.74 218.21,139.63 218.21,139.42 218.1,139.31 218.1,139.31 217.99,139.21 217.99,138.96 218.34,138.61 218.34,132.98 v4(217.86,132.5)
MAC_DDRB_DQS2_DP: length 64.8
  TOP w0.102: U1.AM16 v4(217.86,133.5)
  TOP w0.14: U5.G3 v4(231.78,159.07)
  T05 w0.107: v4(217.86,133.5) 217.74,133.37 217.48,133.37 217.37,133.48 217.37,138.61 217.71,138.96 217.71,143.53 218.18,144 218.18,144.15 217.85,144.48 217.85,144.86 218.17,145.18 218.55,145.18 218.88,144.84 219.03,144.84 219.18,145 219.18,145.15 218.5,145.83 218.5,146.21 218.81,146.53 219.2,146.53 219.88,145.84 220.03,145.84 220.18,146 220.18,146.15 219.47,146.86 219.47,147.24 219.79,147.55 220.17,147.55 220.88,146.84 221.03,146.84 222.38,148.19 222.38,148.33 222.27,148.44 220.26,148.44 219.99,148.71 219.99,149.15 220.26,149.42 222.27,149.42 222.38,149.53 222.38,149.74 222.27,149.85 220.26,149.85 219.99,150.12 219.99,150.57 220.26,150.84 222.27,150.84 222.38,150.94 222.38,151.16 222.27,151.26 220.26,151.26 219.99,151.53 219.99,151.98 220.26,152.25 222.27,152.25 222.38,152.35 222.38,152.57 222.27,152.67 220.26,152.67 219.99,152.94 219.99,153.39 220.26,153.66 222.27,153.66 222.38,153.77 222.38,159.71 223.48,160.81 223.91,160.81 224.01,160.91 224.01,161.01 224.1,161.11 224.23,161.11 224.33,161.01 224.33,160.91 224.42,160.81 224.55,160.81 224.65,160.91 224.65,161.01 224.74,161.11 224.87,161.11 224.97,161.01 224.97,160.91 225.06,160.81 229.4,160.81 231.4,158.81 231.52,158.81 v4(231.78,159.07)
MAC_DDRB_DQS3_DN: length 59.4
  TOP w0.102: U1.AN17 v4(216.86,134.5)
  TOP w0.14: U5.A7 v4(227.78,154.27)
  T18 w0.107: v4(216.86,134.5) 216.61,134.5 216.5,134.6 216.5,134.94 216.16,135.28 216.16,135.43 216.3,135.56 216.3,135.71 216.15,135.87 216,135.87 215.86,135.73 215.71,135.73 215.3,136.14 215.3,138.67 215.07,138.91 215.09,138.92 215.09,139.88 215.43,140.23 215.58,140.23 215.66,140.15 215.81,140.15 215.96,140.3 215.96,140.46 215.88,140.53 215.88,140.68 216.03,140.83 216.18,140.83 216.26,140.76 216.41,140.76 216.56,140.91 216.56,141.06 216.49,141.13 216.49,141.28 222.6,147.4 225.36,147.4 225.63,147.67 225.63,148.44 225.74,148.54 225.95,148.54 226.06,148.44 226.06,147.67 226.33,147.4 226.84,147.4 227.11,147.67 227.11,152.25 227.22,152.35 227.43,152.35 227.54,152.25 227.54,147.67 227.81,147.4 228.44,147.4 228.71,147.67 228.71,152.32 228.81,152.43 229.03,152.43 229.13,152.32 229.13,147.67 229.4,147.4 229.98,147.4 230.37,147.79 230.37,154.15 229.5,155.02 228.75,155.02 228.46,154.73 228.46,153.86 228.35,153.75 227.76,153.75 227.66,153.86 227.66,154.15 v4(227.78,154.27)
MAC_DDRB_DQS3_DP: length 59.4
  TOP w0.102: U1.AN18 v4(215.86,134.5)
  TOP w0.14: U5.B7 v4(227.78,155.07)
  T18 w0.107: v4(215.86,134.5) 216.11,134.5 216.22,134.6 216.22,134.83 215.1,135.95 214.81,135.95 214.41,136.34 214.41,138.64 214.81,139.04 214.81,140 222.49,147.68 225.25,147.68 225.36,147.79 225.36,148.55 225.63,148.82 226.07,148.82 226.34,148.55 226.34,147.79 226.45,147.68 226.73,147.68 226.84,147.79 226.84,152.36 227.11,152.63 227.55,152.63 227.82,152.36 227.82,147.79 227.93,147.68 228.32,147.68 228.43,147.79 228.43,152.44 228.7,152.71 229.14,152.71 229.41,152.44 229.41,147.79 229.52,147.68 229.86,147.68 230.09,147.9 230.09,154.04 229.38,154.74 228.87,154.74 228.74,154.61 228.74,153.74 228.47,153.47 227.65,153.47 227.38,153.74 227.38,154.67 v4(227.78,155.07)
MAC_DDRB_ODT: length 90.9
  TOP w0.14: U5.K3 v4(231.78,162.27) ; U4.K3 v4(243.96,162.27) ; U1.AT9 v4(224.86,137.5)
  T05 w0.117: v4(231.78,162.27) 232.18,162.67 234.68,162.67 234.8,162.56 234.8,162.24 234.91,162.12 235.15,162.12 235.27,162.24 235.27,162.52 235.38,162.63 235.62,162.63 235.73,162.52 235.73,162.26 235.85,162.14 236.08,162.14 236.2,162.26 236.2,162.56 236.32,162.67 243.56,162.67 v4(243.96,162.27)
  T07 w0.117: v4(231.78,162.27) 232.18,161.87 233.91,161.87 234.48,161.3 234.48,153.46 235.78,152.16 240.98,152.16 241.4,151.74 243.77,151.74 243.89,151.62 243.89,151.38 243.77,151.27 241.75,151.27 241.63,151.15 241.63,150.91 241.75,150.8 243.77,150.8 243.89,150.68 243.89,150.45 243.77,150.33 241.75,150.33 241.63,150.21 241.63,149.98 241.75,149.86 243.77,149.86 243.89,149.75 243.89,149.51 243.77,149.4 241.75,149.4 241.63,149.28 241.63,149.05 241.75,148.93 243.77,148.93 243.89,148.81 243.89,145.51 242.34,143.96 240.6,143.96 239.98,143.34 239.98,143.18 240.12,143.04 240.12,142.87 239.96,142.71 239.79,142.71 239.65,142.85 239.44,142.85 238.6,142.01 237.77,142.01 237.62,142.16 227.5,142.16 227.11,141.77 226.94,141.77 226.88,141.83 226.72,141.83 226.55,141.66 226.55,141.5 226.61,141.44 226.61,141.27 226.44,141.11 226.28,141.11 226.22,141.17 226.05,141.17 225.89,141 225.89,140.84 225.95,140.78 225.95,140.61 225.78,140.45 225.46,140.45 225.29,140.27 225.29,139.95 224.33,138.99 224.33,138.26 224.86,137.73 v4(224.86,137.5)
  BOTTOM w0.14: R158.1 242.2,169.1 242.2,163.41 243.33,162.27 v4(243.96,162.27)
MAC_DDRB_PAR: length 79.8
  TOP w0.14: R155.1 243.51,169.35 243.51,167.52 v4(243.96,167.08) U4.T3 ; U5.T3 v4(231.78,167.08) ; U1.AU6 v4(227.86,138.5)
  T05 w0.117: v4(231.78,167.08) 232.77,168.06 234.32,168.06 235.1,167.28 236.94,167.28 238.21,168.55 242.48,168.55 v4(243.96,167.08)
  T14 w0.117: v4(231.78,167.08) U5.T3 231.38,165.2 231.1,164.92 229.78,164.92 229.67,165.04 229.67,165.82 229.78,165.94 230.62,165.94 230.73,166.06 230.73,166.29 230.62,166.41 229.4,166.41 229.29,166.53 229.29,166.76 229.4,166.88 230.62,166.88 230.73,166.99 230.73,167.23 230.62,167.34 229.4,167.34 229.29,167.46 229.29,167.97 229.4,168.09 232.11,168.09 232.56,168.54 234.5,168.54 237.78,165.25 237.78,164.82 237.78,154.19 238.45,153.52 239.83,153.52 240.79,152.56 240.79,144.99 239.96,144.16 239.96,144.15 238.11,142.3 230.63,142.3 227.86,139.53 v4(227.86,138.5)
MAC_DDRB_RAS_N: length 93.1
  TOP w0.14: U1.AL10 v4(223.86,132.5) ; U5.L8 v4(226.98,163.07) ; U4.L8 v4(239.15,163.07)
  T07 w0.117: v4(223.86,132.5) 223.38,132.97 221.63,132.97 221.39,133.22 221.39,134.7 221.06,135.02 218.6,135.02 218.32,135.31 218.32,140.15 224.2,146.03 232.26,146.03 232.38,146.14 232.38,148.89 232.5,149 232.73,149 232.85,148.89 232.85,146.14 232.97,146.03 233.18,146.03 233.29,146.14 233.29,148.1 233.41,148.21 233.64,148.21 233.76,148.1 233.76,146.14 233.88,146.03 234.31,146.03 234.48,146.2 234.48,147.88 232.44,149.92 232.28,149.92 232.08,149.72 231.92,149.72 231.75,149.89 231.75,150.05 231.95,150.25 231.95,150.41 231.66,150.69 230.65,150.69 228.28,153.06 228.28,153.07 227.6,153.75 225.93,153.75 225.68,154.01 225.68,160.18 225.86,160.36 227.59,160.36 227.71,160.47 227.71,160.71 227.59,160.82 225.62,160.82 225.5,160.94 225.5,162.38 225.79,162.67 226.58,162.67 v4(226.98,163.07)
  T16 w0.117: v4(226.98,163.07) U5.L8 234.5,162.67 234.66,162.51 234.97,162.51 235.13,162.67 235.44,162.67 235.6,162.51 235.91,162.51 236.07,162.67 236.37,162.67 236.53,162.51 236.84,162.51 237,162.67 238.75,162.67 v4(239.15,163.07)
  BOTTOM w0.102: v4(239.15,163.07) 239.55,163.47 240.2,163.47
  BOTTOM w0.14: 240.2,163.47 241.31,164.58 241.31,168.52 240.28,169.54 239.71,169.54 R148.1
MAC_DDRB_RST_N: length 89.8
  TOP w0.14: R166.1 246.73,169.78 246.73,166.65 v4(245.56,165.48) U4.P1 ; U1.AL12 v4(221.86,132.5) ; U5.P1 v4(233.38,165.48)
  T07 w0.117: v4(233.38,165.48) 233.78,165.88 240.7,165.88 240.82,165.76 240.82,165.22 240.94,165.11 241.17,165.11 241.29,165.22 241.29,165.6 241.42,165.74 241.62,165.74 241.76,165.6 241.76,165.22 241.9,165.08 U4.P1 v4(245.56,165.48)
  T14 w0.117: v4(221.86,132.5) 221.37,132.01 220.62,132.01 220.34,132.29 220.34,132.67 220,133 219.56,133 219.32,133.25 219.32,141.81 220.76,143.25 220.76,143.48 220.88,143.59 221.12,143.59 221.23,143.71 221.23,143.94 221.12,144.06 220.88,144.06 220.76,144.18 220.76,144.47 221.07,144.77 221.23,144.77 221.79,144.22 221.96,144.22 222.12,144.38 222.12,144.55 221.57,145.1 221.57,145.27 221.73,145.43 221.9,145.43 222.45,144.88 222.62,144.88 222.78,145.04 222.78,145.21 222.23,145.76 222.23,145.93 222.39,146.09 222.56,146.09 223.11,145.54 223.28,145.54 223.44,145.7 223.44,145.87 222.89,146.43 222.89,146.59 223.05,146.76 223.22,146.76 223.78,146.2 223.94,146.2 224.11,146.36 224.11,146.53 223.55,147.09 223.55,147.25 223.72,147.42 223.88,147.42 224.44,146.86 224.6,146.86 224.77,147.03 224.77,147.19 224.21,147.75 224.21,147.91 224.38,148.08 224.54,148.08 225.1,147.52 225.26,147.52 225.43,147.69 225.43,147.85 224.87,148.41 224.87,148.57 225.04,148.74 225.2,148.74 225.76,148.18 225.92,148.18 226.09,148.35 226.09,148.51 225.53,149.07 225.53,149.24 225.7,149.4 225.86,149.4 226.42,148.85 226.59,148.85 226.75,149.01 226.75,149.18 226.2,149.73 226.2,149.9 226.36,150.06 226.53,150.06 227.08,149.51 227.25,149.51 227.41,149.67 227.41,149.84 226.86,150.39 226.86,150.56 227.38,151.09 227.38,151.23 227.26,151.35 226.66,151.35 226.54,151.47 226.54,151.7 226.66,151.82 227.83,151.82 227.94,151.94 227.94,152.16 227.83,152.28 226.58,152.28 226.47,152.39 226.47,152.63 226.58,152.74 227.83,152.74 227.94,152.86 227.94,153.09 227.83,153.21 226.58,153.21 226.47,153.33 226.47,153.56 226.58,153.68 227.26,153.68 227.38,153.79 227.38,163.24 227.38,163.24 227.38,163.27 227.58,163.47 228.42,163.47 228.52,163.58 228.52,163.99 228.67,164.14 229.73,164.14 229.84,164.02 229.84,163.76 229.96,163.64 230.19,163.64 230.31,163.76 230.31,164.16 230.43,164.28 232.83,164.28 232.97,164.41 232.97,164.5 232.98,164.51 U5.P1 v4(233.38,165.48)
MAC_DDRB_WE_N: length 92.8
  TOP w0.14: U5.L2 v4(232.58,163.07) ; U1.AK12 v4(221.86,131.5) ; U4.L2 v4(244.76,163.07)
  T14 w0.117: v4(232.58,163.07) U5.L2 231.39,162.67 231.1,162.96 230.26,162.96 229.91,162.62 229.91,161.2 230.03,161.09 230.51,161.09 230.63,160.97 230.63,160.74 230.51,160.62 230.03,160.62 229.91,160.5 229.91,160.27 230.03,160.15 230.51,160.15 230.63,160.03 230.63,159.8 230.51,159.68 230.03,159.68 229.91,159.57 229.91,159.33 230.03,159.22 230.51,159.22 230.63,159.1 230.63,158.87 230.51,158.75 230.03,158.75 229.91,158.63 229.91,158.4 230.03,158.28 230.51,158.28 230.63,158.17 230.63,157.93 230.51,157.82 230.03,157.82 229.91,157.7 229.91,157.46 230.03,157.35 230.51,157.35 230.63,157.23 230.63,157 230.51,156.88 230.03,156.88 229.91,156.76 229.91,156.53 230.03,156.41 230.51,156.41 230.63,156.3 230.63,156.06 230.51,155.95 230.03,155.95 229.91,155.83 229.91,155.6 230.03,155.48 230.51,155.48 230.63,155.36 230.63,155.13 230.51,155.01 230.03,155.01 229.91,154.89 229.91,154.66 230.03,154.54 230.51,154.54 230.63,154.43 230.63,154.19 230.51,154.08 230.03,154.08 229.91,153.96 229.91,153.73 230.03,153.61 230.51,153.61 230.63,153.49 230.63,153.26 230.51,153.14 230.03,153.14 229.91,153.02 229.91,152.79 230.03,152.67 230.51,152.67 230.63,152.56 230.63,152.32 230.51,152.21 230.03,152.21 229.91,152.09 229.91,151.86 230.03,151.74 230.51,151.74 230.63,151.62 230.63,151.39 230.51,151.27 230.03,151.27 229.91,151.16 229.91,150.92 230.03,150.8 230.51,150.8 230.63,150.69 230.63,150.45 230.51,150.34 230.03,150.34 229.91,150.22 229.91,149.93 229.8,149.81 229.35,149.81 229.23,149.69 229.23,149.46 229.35,149.34 229.8,149.34 229.91,149.22 229.91,148.59 229.31,147.99 229.15,147.99 228.76,148.37 228.6,148.37 228.43,148.2 228.43,148.04 228.81,147.66 228.81,147.49 228.65,147.33 228.48,147.33 228.2,147.6 228.1,147.71 227.94,147.71 227.77,147.54 227.77,147.37 228.15,146.99 228.15,146.83 227.99,146.66 227.82,146.66 227.44,147.04 227.28,147.04 227.11,146.88 227.11,146.71 227.49,146.33 227.49,146.17 227.33,146 227.16,146 226.78,146.38 226.61,146.38 226.45,146.22 226.45,146.05 226.83,145.67 226.83,145.51 226.66,145.34 226.5,145.34 226.12,145.72 225.95,145.72 225.79,145.56 225.79,145.39 225.89,145.29 226.17,145.01 226.17,144.85 226,144.68 225.84,144.68 225.46,145.06 225.29,145.06 225.13,144.89 225.13,144.73 225.46,144.39 225.51,144.35 225.51,144.18 225.34,144.02 225.18,144.02 225.05,144.15 224.87,144.33 224.8,144.4 224.63,144.4 224.47,144.23 224.47,144.07 224.85,143.69 224.85,143.52 224.68,143.36 224.52,143.36 224.13,143.74 223.97,143.74 223.8,143.57 223.8,143.41 224.18,143.03 224.18,142.86 224.02,142.7 223.85,142.7 223.47,143.08 223.31,143.08 223.14,142.91 223.14,142.74 223.52,142.36 223.52,142.2 223.36,142.03 223.19,142.03 222.81,142.41 222.65,142.41 222.48,142.25 222.48,142.08 222.86,141.7 222.86,141.54 222.7,141.37 222.53,141.37 222.15,141.75 221.99,141.75 221.82,141.59 221.82,141.42 222.2,141.04 222.2,140.88 222.03,140.71 221.87,140.71 221.49,141.09 221.32,141.09 221.16,140.93 221.16,140.76 221.54,140.38 221.54,140.22 221.34,140.02 221.34,133.44 221.8,132.99 221.94,132.99 222.26,132.66 222.26,132.22 221.86,131.82 v4(221.86,131.5)
  T18 w0.117: v4(232.58,163.07) 232.98,162.67 234.52,162.67 234.73,162.46 234.99,162.46 235.2,162.67 235.46,162.67 235.67,162.46 235.92,162.46 236.13,162.67 236.39,162.67 236.6,162.46 236.86,162.46 237.07,162.67 241.37,162.67 241.49,162.56 241.49,162.41 241.6,162.3 241.84,162.3 241.96,162.41 241.96,162.56 242.07,162.67 242.31,162.67 242.42,162.56 242.42,162.41 242.54,162.3 242.77,162.3 242.89,162.41 242.89,162.56 243.01,162.67 U4.L2 v4(244.76,163.07)
  BOTTOM w0.102: v4(244.76,163.07) 244.76,163.08 244.36,163.48 243.55,163.48
  BOTTOM w0.14: R143.1 243.17,169.02 243.06,168.91 243.06,163.96 243.55,163.48
MAC_DDRC0_CHIP_ZQ: length 4.4
  TOP w0.254: U6.F9 v4(254.1,125.86)
  BOTTOM w0.102: v4(254.1,125.86) 253.7,125.46 253.7,123.88 v2(253.1,123.28)
  BOTTOM w0.254: v4(254.1,125.86) 254.29,126.05 R189.2
MAC_DDRC0_TEN: length 4.3
  TOP w0.14: U6.N9 v4(260.5,125.86)
  BOTTOM w0.102: v4(260.5,125.86) 260.91,125.46 260.91,123.66 R188.1
  BOTTOM w0.14: R188.1 v2(261.06,122.4)
MAC_DDRC0_VREFCA: length 4.6
  TOP w0.254: U6.M1 v4(259.7,118.66)
  BOTTOM w0.14: v2(259.33,114.81) 259.69,115.16 R179.1
  BOTTOM w0.254: R179.1 R184.2 259.68,116.98 C44.1 259.68,118.64 v4(259.7,118.66)
MAC_DDRC1_CHIP_ZQ: length 2.8
  TOP w0.254: U7.F9 v4(254.1,137.53)
  BOTTOM w0.381: v2(254,139.57) 254.27,139.31 R192.2 254.27,137.69 v4(254.1,137.53)
MAC_DDRC1_TEN: length 4.1
  TOP w0.14: U7.N9 v4(260.5,137.53)
  BOTTOM w0.102: v4(260.5,137.53) 260.9,137.14 261.47,137.14 261.7,137.37 261.7,138.29 R191.1
  BOTTOM w0.14: R191.1 261.68,139.22 v2(261.49,139.41)
MAC_DDRC1_VREFCA: length 4.6
  TOP w0.254: U7.M1 v4(259.7,130.33)
  BOTTOM w0.14: R181.1 260.81,127.56 v2(260.86,127.51)
  BOTTOM w0.254: R181.1 259.74,128.4 R186.2 259.6,128.54 C45.1 259.6,130.23 v4(259.7,130.33)
MAC_DDRC_A00: length 80.8
  TOP w0.14: v4(261.3,131.93) U7.P3 260.9,132.48 261.13,132.7 262.96,132.7 263.3,132.36 263.3,132.35 265.07,130.58 265.07,130.38 R167.1 ; v4(261.3,120.26) U6.P3 ; U1.AM7 v4(226.86,133.5)
  T07 w0.117: v4(226.86,133.5) 227.39,132.97 229.12,132.97 229.39,132.71 229.39,132.36 229.67,132.07 232.66,132.07 233.74,130.99 235.29,130.99 235.75,130.53 238.82,130.53 238.94,130.41 238.94,129.38 239.06,129.27 239.29,129.27 239.41,129.38 239.41,130.41 239.52,130.53 239.93,130.53 240.05,130.41 240.05,128.39 240.16,128.28 240.4,128.28 240.51,128.39 240.51,130.41 240.63,130.53 240.98,130.53 241.52,129.98 241.52,129.81 241.13,129.42 241.13,129.26 241.3,129.09 241.46,129.09 241.85,129.48 242.02,129.48 242.18,129.32 242.18,129.15 241.79,128.76 241.79,128.6 241.96,128.43 242.12,128.43 242.51,128.82 242.68,128.82 245.92,125.58 246.09,125.58 246.87,126.35 247.03,126.35 247.2,126.19 247.2,126.02 246.42,125.25 246.42,125.08 246.59,124.92 246.75,124.92 247.53,125.69 247.69,125.69 247.86,125.53 247.86,125.36 247.08,124.58 247.08,124.42 247.41,124.09 247.58,124.09 248.05,124.56 248.21,124.56 248.38,124.4 248.38,124.23 247.91,123.76 247.91,123.59 249.78,121.72 254.33,121.72 254.96,121.09 255.47,121.09 255.59,121.2 255.59,121.78 255.7,121.9 255.94,121.9 256.06,121.78 256.06,121.2 256.17,121.09 257.73,121.09 257.85,121.2 257.85,121.73 257.97,121.85 258.2,121.85 258.32,121.73 258.32,121.2 258.43,121.09 258.67,121.09 258.78,121.2 258.78,121.73 258.9,121.85 259.13,121.85 259.25,121.73 259.25,121.2 259.37,121.09 259.64,121.09 259.76,121.2 259.76,121.38 259.88,121.49 260.11,121.49 260.23,121.38 260.23,121.2 260.35,121.09 260.48,121.09 v4(261.3,120.26)
  T18 w0.117: v4(261.3,131.93) 261.7,131.53 261.7,128.67 261.98,128.39 261.98,126.38 261.7,126.1 261.7,120.66 v4(261.3,120.26)
MAC_DDRC_A01: length 75.5
  TOP w0.14: U1.AU4 v4(229.86,138.5) ; R168.1 264.9,135.26 264.46,134.83 261.17,134.83 260.9,135.09 U7.P7 v4(261.3,135.93) ; v4(261.3,124.26) U6.P7
  T07 w0.117: v4(229.86,138.5) 230.43,139.06 233.45,139.06 233.57,138.95 233.57,138.6 233.69,138.48 233.92,138.48 234.04,138.6 234.04,138.95 234.15,139.06 234.39,139.06 234.5,138.95 234.5,138.6 234.62,138.48 234.85,138.48 234.97,138.6 234.97,138.95 235.08,139.06 235.32,139.06 235.44,138.95 235.44,138.6 235.55,138.48 235.79,138.48 235.91,138.6 235.91,138.95 236.02,139.06 236.26,139.06 236.37,138.95 236.37,138.6 236.49,138.48 236.72,138.48 236.84,138.6 236.84,138.95 236.95,139.06 237.19,139.06 237.31,138.95 237.31,138.6 237.42,138.48 237.66,138.48 237.77,138.6 237.77,138.95 237.89,139.06 238.13,139.06 238.24,138.95 238.24,138.6 238.36,138.48 238.59,138.48 238.71,138.6 238.71,138.95 238.83,139.06 239.06,139.06 239.18,138.95 239.18,138.6 239.29,138.48 239.53,138.48 239.64,138.6 239.64,138.95 239.76,139.06 239.99,139.06 240.11,138.95 240.11,138.6 240.23,138.48 240.46,138.48 240.58,138.6 240.58,138.95 240.7,139.06 240.93,139.06 241.05,138.95 241.05,138.6 241.16,138.48 241.4,138.48 241.51,138.6 241.51,138.95 241.63,139.06 241.86,139.06 241.98,138.95 241.98,138.6 242.1,138.48 242.33,138.48 242.45,138.6 242.45,138.95 242.57,139.06 242.8,139.06 242.92,138.95 242.92,138.6 243.03,138.48 243.27,138.48 243.38,138.6 243.38,138.95 243.5,139.06 243.73,139.06 243.85,138.95 243.85,138.6 243.97,138.48 244.2,138.48 244.32,138.6 244.32,138.95 244.43,139.06 244.67,139.06 244.79,138.95 244.79,138.6 244.9,138.48 245.14,138.48 245.25,138.6 245.25,138.95 245.37,139.06 246.12,139.06 248.94,136.24 248.94,130.64 249.8,129.78 259.65,129.78 262.08,127.36 262.08,126.47 261.7,126.1 261.7,124.66 v4(261.3,124.26)
  T16 w0.117: v4(261.3,124.26) 261.7,124.66 261.7,126.1 261.98,126.38 261.98,126.95 261.98,126.95 261.98,129.59 261.7,129.86 261.7,132.09 261.69,132.1 261.69,135.54 v4(261.3,135.93)
MAC_DDRC_A02: length 81.9
  TOP w0.14: U1.AN6 v4(227.86,134.5) ; v4(262.1,131.93) U7.R3 ; v4(262.1,120.26) U6.R3
  T07 w0.117: v4(262.1,131.93) 262.5,131.53 262.5,130.16 262.69,129.98 262.69,129.8 262.57,129.68 262.24,129.68 262.13,129.56 262.13,129.33 262.24,129.21 262.57,129.21 262.69,129.1 262.69,128.86 262.57,128.75 262.24,128.75 262.13,128.63 262.13,128.4 262.24,128.28 262.57,128.28 262.69,128.16 262.69,126.21 262.5,126.03 262.5,120.66 v4(262.1,120.26) 260.14,122.23 250.01,122.23 248.94,123.3 248.94,125.25 246.97,127.22 246.8,127.22 246.01,126.43 245.84,126.43 245.67,126.59 245.67,126.76 246.47,127.55 246.47,127.72 246.34,127.85 246.18,127.85 245.38,127.05 245.22,127.05 245.05,127.22 245.05,127.38 245.85,128.18 245.85,128.34 245.36,128.83 245.36,129.56 245.24,129.67 244.87,129.67 244.75,129.56 244.75,127.96 244.63,127.84 244.4,127.84 244.28,127.96 244.28,129.53 244.14,129.67 243.91,129.67 243.79,129.56 243.79,128.95 243.67,128.83 243.44,128.83 243.32,128.95 243.32,129.56 243.21,129.67 242.57,129.67 240.71,131.53 240.54,131.53 240.07,131.06 239.91,131.06 239.74,131.23 239.74,131.4 240.21,131.86 240.21,132.03 239.9,132.34 239.11,132.34 238.99,132.22 238.99,131.19 238.87,131.07 238.64,131.07 238.52,131.19 238.52,132.22 238.41,132.34 238.17,132.34 238.06,132.22 238.06,131.19 237.94,131.07 237.7,131.07 237.59,131.19 237.59,132.22 237.47,132.34 237.24,132.34 237.12,132.22 237.12,131.19 237,131.07 236.77,131.07 236.65,131.19 236.65,132.22 236.54,132.34 234.3,132.34 234.18,132.22 234.18,131.85 234.07,131.73 233.83,131.73 233.72,131.85 233.72,132.22 233.6,132.34 233.14,132.34 232.45,133.03 229.68,133.03 229.37,133.34 229.37,133.77 229.11,134.03 228.33,134.03 v4(227.86,134.5)
  BOTTOM w0.14: R174.1 266,129.67 263.32,132.35 262.52,132.35 v4(262.1,131.93)
