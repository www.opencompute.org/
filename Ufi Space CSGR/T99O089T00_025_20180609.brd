# Allegro board T99O089T00_025_20180609.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SOT-23H
  rect 1.143x1.016 smd: 1(1.143,-0.991) 2(1.143,0.991) 3(-1.143,0)
SOT-23I
  rect 1.143x1.016 smd: 1(1.143,-0.991) 2(1.143,0.991) 3(-1.143,0)
SOT-143S0
  rect 1.422x1.168 smd: 1(1.1,-0.749)
  rect 1.422x1.016 smd: 2(1.1,0.95) 3(-1.1,0.95) 4(-1.1,-0.95)
SOT-323AH1_1
  rect 0.914x0.711 smd: 1(0.95,-0.65) 2(0.95,0.65) 3(-0.95,0)
SOT-353-H1_1S0
  rect 0.914x0.356 smd: 1(1.003,-0.65) 2(1.003,0) 3(1.003,0.65) 4(-1.003,0.65) 5(-1.003,-0.65)
SOT-363S0
  rect 0.914x0.356 smd: 1(1.003,-0.65) 2(1.003,0) 3(1.003,0.65) 4(-1.003,0.65) 5(-1.003,0) 6(-1.003,-0.65)
SQFN-3X3-8HSH
  rect 0.813x0.457 smd: 1(1.456,-0.975) 2(1.456,-0.325) 3(1.456,0.325) 4(1.456,0.975) 5(-1.456,0.975) 6(-1.456,0.325) 7(-1.456,-0.325) 8(-1.456,-0.975)
  custom 0.4x0.4 smd: 9(0,0)
SQFN-5X5-20ESH
  rect 0.457x0.965 smd: 1(-1.3,-2.381) 2(-0.65,-2.381) 3(0,-2.381) 4(0.65,-2.381) 5(1.3,-2.381) 11(1.3,2.381) 12(0.65,2.381) 13(0,2.381) 14(-0.65,2.381) 15(-1.3,2.381)
  rect 0.965x0.457 smd: 6(2.381,-1.3) 7(2.381,-0.65) 8(2.381,0) 9(2.381,0.65) 10(2.381,1.3) 16(-2.381,1.3) 17(-2.381,0.65) 18(-2.381,0) 19(-2.381,-0.65) 20(-2.381,-1.3)
  rect 3.251x3.251 smd: 21(0,0)
SSOP-8C
  rect 1.524x0.356 smd: 1(2.069,-0.975) 2(2.069,-0.325) 3(2.069,0.325) 4(2.069,0.975) 5(-2.069,0.975) 6(-2.069,0.325) 7(-2.069,-0.325) 8(-2.069,-0.975)
SSOP-16A
  rect 1.524x0.356 smd: 1(3.556,-2.276) 2(3.556,-1.626) 3(3.556,-0.975) 4(3.556,-0.325) 5(3.556,0.325) 6(3.556,0.975) 7(3.556,1.626) 8(3.556,2.276) 9(-3.556,2.276) 10(-3.556,1.626) 11(-3.556,0.975) 12(-3.556,0.325) 13(-3.556,-0.325) 14(-3.556,-0.975) 15(-3.556,-1.626) 16(-3.556,-2.276)
SSOP-16H1_1
  rect 1.524x0.356 smd: 1(2.819,-2.276) 2(2.819,-1.626) 3(2.819,-0.975) 4(2.819,-0.325) 5(2.819,0.325) 6(2.819,0.975) 7(2.819,1.626) 8(2.819,2.276) 9(-2.819,2.276) 10(-2.819,1.626) 11(-2.819,0.975) 12(-2.819,0.325) 13(-2.819,-0.325) 14(-2.819,-0.975) 15(-2.819,-1.626) 16(-2.819,-2.276)
SSOP-20
  rect 1.524x0.356 smd: 1(2.819,-2.925) 2(2.819,-2.275) 3(2.819,-1.625) 4(2.819,-0.975) 5(2.819,-0.325) 6(2.819,0.325) 7(2.819,0.975) 8(2.819,1.625) 9(2.819,2.275) 10(2.819,2.925) 11(-2.819,2.925) 12(-2.819,2.275) 13(-2.819,1.625) 14(-2.819,0.975) 15(-2.819,0.325) 16(-2.819,-0.325) 17(-2.819,-0.975) 18(-2.819,-1.625) 19(-2.819,-2.275) 20(-2.819,-2.925)
SSOP-24
  rect 1.524x0.356 smd: 1(2.794,-3.576) 2(2.794,-2.926) 3(2.794,-2.276) 4(2.794,-1.626) 5(2.794,-0.975) 6(2.794,-0.325) 7(2.794,0.325) 8(2.794,0.975) 9(2.794,1.626) 10(2.794,2.276) 11(2.794,2.926) 12(2.794,3.576) 13(-2.794,3.576) 14(-2.794,2.926) 15(-2.794,2.276) 16(-2.794,1.626) 17(-2.794,0.975) 18(-2.794,0.325) 19(-2.794,-0.325) 20(-2.794,-0.975) 21(-2.794,-1.626) 22(-2.794,-2.276) 23(-2.794,-2.926) 24(-2.794,-3.576)
T-S12_7X9_398-16
  rect 1.651x0.635 smd: 1(4.256,-4.445) 2(4.256,-3.175) 3(4.256,-1.905) 4(4.256,-0.635) 5(4.256,0.635) 6(4.256,1.905) 7(4.256,3.175) 8(4.256,4.445) 9(-4.256,4.445) 10(-4.256,3.175) 11(-4.256,1.905) 12(-4.256,0.635) 13(-4.256,-0.635) 14(-4.256,-1.905) 15(-4.256,-3.175) 16(-4.256,-4.445)
TQFN-2X1_5-10S1
  rect 0.381x0.559 smd: 1(-0.75,-0.63) 2(-0.25,-0.63) 3(0.25,-0.63) 4(0.75,-0.63) 6(0.75,0.63) 7(0.25,0.63) 8(-0.25,0.63) 9(-0.75,0.63)
  rect 0.61x0.381 smd: 5(0.853,0) 10(-0.853,0)
TQFN-2X2-8
  rect 1.118x0.381 smd: 1(1.008,-0.749)
  rect 1.016x0.381 smd: 2(1.057,-0.251) 3(1.057,0.251) 4(1.057,0.749) 5(-1.057,0.749) 6(-1.057,0.251) 7(-1.057,-0.251) 8(-1.057,-0.749)
TQFN-3X2-11A
  rect 0.381x2.311 smd: 1(-0.5,0) 2(0,0) 3(0.5,0)
  rect 0.61x0.381 smd: 4(1.354,-0.75) 5(1.354,-0.25) 6(1.354,0.25) 7(1.354,0.75) 8(-1.354,0.75) 9(-1.354,0.25) 10(-1.354,-0.25) 11(-1.354,-0.75)
TQFN-3X2-14A
  rect 0.381x0.61 smd: 1(-1,-0.854) 5(1,-0.854) 8(1,0.854) 10(0,0.854) 12(-1,0.854)
  rect 0.381x0.813 smd: 2(-0.5,-0.756) 4(0.5,-0.756) 9(0.5,0.756) 11(-0.5,0.756)
  rect 0.381x1.397 smd: 3(0,-0.448)
  rect 0.61x0.381 smd: 6(1.354,-0.25) 7(1.354,0.25) 13(-1.354,0.25) 14(-1.354,-0.25)
TQFN-3X2_5-15S0
  rect 0.381x0.61 smd: 1(-0.75,-1.104) 2(-0.25,-1.104) 3(0.25,-1.104) 4(0.75,-1.104)
  rect 0.61x0.381 smd: 5(1.354,-0.725) 6(1.354,-0.225) 8(1.354,0.775) 12(-1.354,0.775) 14(-1.354,-0.225) 15(-1.354,-0.725)
  custom 0.125x0.125 smd: 7(1.354,0.275) 13(-1.354,0.275)
  rect 0.381x1.372 smd: 9(0.5,0.735) 11(-0.5,0.735)
  rect 0.381x1.702 smd: 10(0,0.57)
TQFN-3X3-10GSH
  rect 0.813x0.381 smd: 1(1.455,-1) 2(1.455,-0.5) 3(1.455,0) 4(1.455,0.5) 5(1.455,1) 6(-1.455,1) 7(-1.455,0.5) 8(-1.455,0) 9(-1.455,-0.5) 10(-1.455,-1)
  custom 0.423x0.423 smd: 11(0,0)
TQFN-3X3-16ESHS3
  rect 0.381x0.813 smd: 1(-0.75,-1.455) 2(-0.25,-1.455) 3(0.25,-1.455) 4(0.75,-1.455) 9(0.75,1.455) 10(0.25,1.455) 11(-0.25,1.455) 12(-0.75,1.455)
  rect 0.813x0.381 smd: 5(1.455,-0.75) 6(1.455,-0.25) 7(1.455,0.25) 8(1.455,0.75) 13(-1.455,0.75) 14(-1.455,0.25) 15(-1.455,-0.25) 16(-1.455,-0.75)
  rect 1.803x1.803 smd: 17(0,0)
TQFN-4X4-24BSH-H0_8S2
  custom 0.095x0.095 smd: 1(-1.25,-1.956) 6(1.25,-1.956) 7(1.956,-1.25) 12(1.956,1.25) 13(1.25,1.956) 18(-1.25,1.956) 19(-1.956,1.25) 24(-1.956,-1.25)
  rect 0.381x0.813 smd: 2(-0.75,-1.956) 3(-0.25,-1.956) 4(0.25,-1.956) 5(0.75,-1.956) 14(0.75,1.956) 15(0.25,1.956) 16(-0.25,1.956) 17(-0.75,1.956)
  rect 0.813x0.381 smd: 8(1.956,-0.75) 9(1.956,-0.25) 10(1.956,0.25) 11(1.956,0.75) 20(-1.956,0.75) 21(-1.956,0.25) 22(-1.956,-0.25) 23(-1.956,-0.75)
  rect 2.794x2.794 smd: 25(0,0)
TQFN-4X4-24FSHS1
  custom 0.096x0.096 smd: 1(-1.25,-1.959) 6(1.25,-1.959) 7(1.959,-1.25) 12(1.959,1.25) 13(1.25,1.959) 18(-1.25,1.959) 19(-1.959,1.25) 24(-1.959,-1.25)
  rect 0.381x0.813 smd: 2(-0.75,-1.956) 3(-0.25,-1.956) 4(0.25,-1.956) 5(0.75,-1.956) 14(0.75,1.956) 15(0.25,1.956) 16(-0.25,1.956) 17(-0.75,1.956)
  rect 0.813x0.381 smd: 8(1.956,-0.75) 9(1.956,-0.25) 10(1.956,0.25) 11(1.956,0.75) 20(-1.956,0.75) 21(-1.956,0.25) 22(-1.956,-0.25) 23(-1.956,-0.75)
  rect 2.87x2.87 smd: 25(0,0)
TQFN-6X5-12SH
  rect 0.914x0.381 smd: 1(2.406,-2.501) 2(2.406,-2.001) 3(2.406,-1.5) 4(2.406,-1) 5(2.406,-0.5) 8(-2.406,-0.5) 9(-2.406,-1) 10(-2.406,-1.5) 11(-2.406,-2.001) 12(-2.406,-2.501)
  custom 0.229x0.229 smd: 6(2.155,1.25) 7(-2.155,1.25)
  custom 0.85x0.85 smd: 13(0,0)
TQFN-6X6-40SH-SPEC
  rect 0.381x1.016 smd: 1(-2.25,-3.057) 2(-1.75,-3.057) 3(-1.25,-3.057) 4(-0.75,-3.057) 5(-0.25,-3.057) 6(0.25,-3.057) 7(0.75,-3.057) 8(1.25,-3.057) 9(1.751,-3.057) 10(2.251,-3.057) 21(2.251,3.057) 22(1.751,3.057) 23(1.25,3.057) 24(0.75,3.057) 25(0.25,3.057) 26(-0.25,3.057) 27(-0.75,3.057) 28(-1.25,3.057) 29(-1.75,3.057) 30(-2.25,3.057)
  rect 1.016x0.381 smd: 11(3.057,-2.25) 12(3.057,-1.75) 13(3.057,-1.25) 14(3.057,-0.75) 15(3.057,-0.25) 16(3.057,0.25) 17(3.057,0.75) 18(3.057,1.25) 19(3.057,1.751) 20(3.057,2.251) 31(-3.057,2.251) 32(-3.057,1.751) 33(-3.057,1.25) 34(-3.057,0.75) 35(-3.057,0.25) 36(-3.057,-0.25) 37(-3.057,-0.75) 38(-3.057,-1.25) 39(-3.057,-1.75) 40(-3.057,-2.25)
  rect 4.242x4.242 smd: 41(0,0)
TQFN-7X5-40DSH
  rect 0.381x0.813 smd: 1(-2.751,-2.455) 2(-2.25,-2.455) 3(-1.75,-2.455) 4(-1.25,-2.455) 5(-0.75,-2.455) 6(-0.25,-2.455) 7(0.25,-2.455) 8(0.75,-2.455) 9(1.25,-2.455) 10(1.751,-2.455) 11(2.251,-2.455) 12(2.751,-2.455) 21(2.751,2.455) 22(2.251,2.455) 23(1.751,2.455) 24(1.25,2.455) 25(0.75,2.455) 26(0.25,2.455) 27(-0.25,2.455) 28(-0.75,2.455) 29(-1.25,2.455) 30(-1.75,2.455) 31(-2.25,2.455) 32(-2.751,2.455)
  rect 0.813x0.381 smd: 13(3.456,-1.751) 14(3.456,-1.25) 15(3.456,-0.75) 16(3.456,-0.25) 17(3.456,0.25) 18(3.456,0.75) 19(3.456,1.25) 20(3.456,1.75) 33(-3.456,1.75) 34(-3.456,1.25) 35(-3.456,0.75) 36(-3.456,0.25) 37(-3.456,-0.25) 38(-3.456,-0.75) 39(-3.456,-1.25) 40(-3.456,-1.751)
  rect 5.41x3.404 smd: 41(0,0)
TQFN-7X7-44CSH
  rect 0.381x1.016 smd: 1(-2.501,-3.557) 2(-2.001,-3.557) 3(-1.5,-3.557) 4(-1,-3.557) 5(-0.5,-3.557) 6(0,-3.557) 7(0.5,-3.557) 8(1,-3.557) 9(1.5,-3.557) 10(2.001,-3.557) 11(2.501,-3.557) 23(2.501,3.557) 24(2.001,3.557) 25(1.5,3.557) 26(1,3.557) 27(0.5,3.557) 28(0,3.557) 29(-0.5,3.557) 30(-1,3.557) 31(-1.5,3.557) 32(-2.001,3.557) 33(-2.501,3.557)
  rect 1.016x0.381 smd: 12(3.557,-2.501) 13(3.557,-2.001) 14(3.557,-1.5) 15(3.557,-1) 16(3.557,-0.5) 17(3.557,0) 18(3.557,0.5) 19(3.557,1) 20(3.557,1.5) 21(3.557,2.001) 22(3.557,2.501) 34(-3.557,2.501) 35(-3.557,2.001) 36(-3.557,1.5) 37(-3.557,1) 38(-3.557,0.5) 39(-3.557,0) 40(-3.557,-0.5) 41(-3.557,-1) 42(-3.557,-1.5) 43(-3.557,-2.001) 44(-3.557,-2.501)
  rect 5.309x5.309 smd: 45(0,0)
TQFN-9X9-64GSHS0
  custom 0.095x0.095 smd: 1(-3.751,-4.557) 16(3.751,-4.557) 17(4.557,-3.751) 32(4.557,3.751) 33(3.751,4.557) 48(-3.751,4.557) 49(-4.557,3.751) 64(-4.557,-3.751)
  rect 0.381x1.016 smd: 2(-3.251,-4.557) 3(-2.751,-4.557) 4(-2.251,-4.557) 5(-1.751,-4.557) 6(-1.25,-4.557) 7(-0.75,-4.557) 8(-0.25,-4.557) 9(0.25,-4.557) 10(0.75,-4.557) 11(1.25,-4.557) 12(1.75,-4.557) 13(2.25,-4.557) 14(2.751,-4.557) 15(3.251,-4.557) 34(3.251,4.557) 35(2.751,4.557) 36(2.25,4.557) 37(1.75,4.557) 38(1.25,4.557) 39(0.75,4.557) 40(0.25,4.557) 41(-0.25,4.557) 42(-0.75,4.557) 43(-1.25,4.557) 44(-1.751,4.557) 45(-2.251,4.557) 46(-2.751,4.557) 47(-3.251,4.557)
  rect 1.016x0.381 smd: 18(4.557,-3.251) 19(4.557,-2.751) 20(4.557,-2.251) 21(4.557,-1.751) 22(4.557,-1.25) 23(4.557,-0.75) 24(4.557,-0.25) 25(4.557,0.25) 26(4.557,0.75) 27(4.557,1.25) 28(4.557,1.75) 29(4.557,2.25) 30(4.557,2.751) 31(4.557,3.251) 50(-4.557,3.251) 51(-4.557,2.751) 52(-4.557,2.25) 53(-4.557,1.75) 54(-4.557,1.25) 55(-4.557,0.75) 56(-4.557,0.25) 57(-4.557,-0.25) 58(-4.557,-0.75) 59(-4.557,-1.25) 60(-4.557,-1.751) 61(-4.557,-2.251) 62(-4.557,-2.751) 63(-4.557,-3.251)
  rect 4.343x4.343 smd: 65(0,0)
TQFN-9X9-64QSH
  rect 0.381x1.016 smd: 1(-3.751,-4.557) 2(-3.251,-4.557) 3(-2.751,-4.557) 4(-2.25,-4.557) 5(-1.75,-4.557) 6(-1.25,-4.557) 7(-0.75,-4.557) 8(-0.25,-4.557) 9(0.25,-4.557) 10(0.75,-4.557) 11(1.25,-4.557) 12(1.751,-4.557) 13(2.251,-4.557) 14(2.751,-4.557) 15(3.251,-4.557) 16(3.751,-4.557) 33(3.751,4.557) 34(3.251,4.557) 35(2.751,4.557) 36(2.251,4.557) 37(1.751,4.557) 38(1.25,4.557) 39(0.75,4.557) 40(0.25,4.557) 41(-0.25,4.557) 42(-0.75,4.557) 43(-1.25,4.557) 44(-1.75,4.557) 45(-2.25,4.557) 46(-2.751,4.557) 47(-3.251,4.557) 48(-3.751,4.557)
  rect 1.016x0.381 smd: 17(4.557,-3.751) 18(4.557,-3.251) 19(4.557,-2.751) 20(4.557,-2.25) 21(4.557,-1.75) 22(4.557,-1.25) 23(4.557,-0.75) 24(4.557,-0.25) 25(4.557,0.25) 26(4.557,0.75) 27(4.557,1.25) 28(4.557,1.751) 29(4.557,2.251) 30(4.557,2.751) 31(4.557,3.251) 32(4.557,3.751) 49(-4.557,3.751) 50(-4.557,3.251) 51(-4.557,2.751) 52(-4.557,2.251) 53(-4.557,1.751) 54(-4.557,1.25) 55(-4.557,0.75) 56(-4.557,0.25) 57(-4.557,-0.25) 58(-4.557,-0.75) 59(-4.557,-1.25) 60(-4.557,-1.75) 61(-4.557,-2.25) 62(-4.557,-2.751) 63(-4.557,-3.251) 64(-4.557,-3.751)
  rect 3.505x3.505 smd: 65(0,0)

## Nets
