# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P1V0: length 132.9
  TOP w0.305: PR177.1 146.91,178.71 146.91,175.36 151.62,170.65 151.62,164.74 167.39,148.97 167.39,134.24 167.94,133.68 167.94,125.85 166.29,124.2 166.29,109.79 184.08,92.01 184.72,92.01 190.5,86.23 202.95,86.23 203.96,87.25 v1(203.96,89.72)
  TOP w0.381: v1(190.37,121.43) 190.27,121.43 189.89,121.05 C2239.2 189.89,119.75 R12439.2 ; R1054.2 v1(116.05,182.81)
  BOTTOM w0.381: PR175.1 172.9,171.03 v3(172.58,171.35)
  vias: v1(135.93,109.58) v1(136.71,109.58) v1(139.63,89) v1(139.63,87.99) v1(140.5,89) v1(140.5,87.99) v1(141.28,89) v1(141.28,87.99) v1(142.65,112.89) v1(143.44,112.89) v1(144.24,112.89) v1(150.66,107.04) v1(151.44,107.04) v1(152.19,107.04) v1(152.97,107.04) v1(153.84,107.04) v1(154.62,107.04) v1(155.49,107.04) v1(156.27,107.04) v1(186.89,86.55) v1(187.27,91.38) v1(187.45,87.12) v1(187.83,91.95) v1(188.05,87.67) v1(188.47,92.46) v1(189.5,89.17) v1(190.02,89.75) v1(190.63,90.35) v1(190.73,79.07) v1(191.26,90.99) v1(191.44,79.07) v1(191.9,91.57) v1(192.21,115.45) v1(192.2,79.07) v1(192.91,79.07) v1(193,115.45) v1(193.53,81.83) v1(194.24,81.83) v1(194.95,81.83) v1(195.66,81.83) v1(196.42,81.83) v1(197.18,81.83) v1(202.99,81.83) v1(203.75,81.83) v1(204.51,81.83) v1(205.27,81.83) v1(243.24,96.15) v1(243.25,95.36) v1(243.25,94.47) v1(243.25,93.58) v1(244.05,96.13) v1(244.06,95.34) v1(244.06,94.45) v1(244.06,93.56) v1(244.84,96.14) v1(244.84,95.34) v1(244.84,94.46) v1(244.84,93.57) v1(245.19,92.33) v1(245.19,91.44) v1(245.2,90.65) v1(245.65,96.16) v1(245.66,95.37) v1(245.66,94.48) v1(245.66,93.59) v1(245.97,92.34) v1(245.97,91.45) v1(245.98,90.66) v1(246.54,96.16) v1(246.55,95.37) v1(246.55,94.48) v1(246.55,93.59) v1(246.79,92.36) v1(246.79,91.48) v1(246.8,90.68) v1(247.23,110.83) v1(247.61,92.42) v1(247.6,91.49) v1(247.61,90.7) v1(248.16,110.87) v1(248.41,91.51) v1(248.41,90.72) v1(248.45,92.43) v1(249.01,110.83) v1(249.94,110.87) v1(278.23,106.55) v1(278.99,106.55) v1(286.77,106.3) v1(287.1,105.64) v2(192.41,88.01) v2(192.41,86.74) v2(192.41,85.47) v2(192.41,84.2) v2(192.41,82.93) v2(193.68,88.01) v2(193.68,86.74) v2(193.68,85.47) v2(193.68,84.2) v2(193.68,82.93) v2(194.94,88.01) v2(194.94,86.74) v2(194.94,85.47) v2(194.94,84.2) v2(194.94,82.93) v2(196.22,88.01) v2(196.22,86.74) v2(196.22,85.47) v2(196.22,84.2) v2(196.22,82.93) v2(197.49,88.01) v2(197.49,86.74) v2(197.49,85.47) v2(197.49,84.2) v2(197.49,82.93) v2(198.75,88.01) v2(198.75,86.74) v2(198.75,85.47) v2(198.75,84.2) v2(198.75,82.93) v2(200.03,88.01) v2(200.03,86.74) v2(200.03,85.47) v2(200.03,84.2) v2(200.03,82.93) v2(201.29,88.01) v2(201.29,86.74) v2(201.29,85.47) v2(201.29,84.2) v2(201.29,82.93) v3(168.45,183.88) v3(168.45,182.99) v3(168.45,172.19) v3(168.45,171.3) v3(168.58,174.35) v3(168.58,173.46) v3(169.72,174.01) v3(169.85,183.88) v3(169.85,182.99) v3(169.85,172.19) v3(169.85,171.3) v3(170.1,179.43) v3(170.1,178.54) v3(170.23,177.4) v3(170.23,176.51) v3(170.18,175.39) v3(171.24,183.88) v3(171.24,182.99) v3(171.24,172.19) v3(171.24,171.3) v3(171.5,179.43) v3(171.5,178.54) v3(171.62,177.4) v3(171.62,176.51) v3(171.58,175.39) v3(172.64,179.56) v3(172.64,178.67) v3(172.58,172.24) v3(172.85,182.88) v3(172.85,181.61) v3(172.85,180.59) v3(174.16,183.37) v3(174.16,182.35) v3(174.16,181.34) v3(174.29,179.69) v3(174.29,178.67) v3(174.29,177.65) v3(174.42,176.26) v3(174.42,175.37) v3(174.43,172.38) v3(174.48,174.32) v3(174.48,173.43) v3(175.43,174.22) v3(175.53,173.23) v3(175.53,172.22)
P1V0_BOOT: length 2.4
  TOP w0.305: PU7.7 154.21,185.34 153.99,185.11
  TOP w0.381: PR186.1 153.42,184.55 153.99,185.11
P1V0_BP: length 6.2
  TOP w0.305: PC147.2 152.27,194.38 v1(152.27,193.29) 153.21,192.36 PU7.28
  BOTTOM w0.381: v1(152.27,193.29) 151.7,192.72 v2(151.7,192.4) PR182.1
P1V0_DDR: length 197.7
  TOP w0.381: U1.AF25 v4(207.86,127.5) ; v1(191.52,144.65) 191.75,144.87 C24.1 ; U1.AC12 v4(221.86,124.5) ; C37.1 191.47,147.2 v1(191.21,147.47) ; U1.AG18 v4(215.86,128.5) ; U1.AG20 v4(212.86,128.5) ; U1.AG24 v4(208.86,128.5) ; U1.AF27 v4(205.86,127.5) ; U1.AC11 v4(222.86,124.5) ; U1.AF19 v4(214.86,127.5) ; U1.AD10 v4(223.86,125.5)
  T07 w0.381: v1(185.71,181.62) 185.71,180.48 v1(185.72,180.46) 185.72,169.34 176.4,160.02 150.9,160.02 144.01,166.9 79.59,166.9 78.09,168.4 68.56,168.4 v1(68,167.84)
  T14 w0.381: v1(68,167.84) 70.04,165.8 70.04,160.63 69.08,159.67 69.08,155.97 70.05,155 70.05,153.35 70.61,152.79 70.61,140.21 71.37,139.45 71.37,136.27 v1(68.2,133.1)
  BOTTOM w0.381: v4(222.86,124.5) 222.44,124.08 C48.1 ; v4(208.86,128.5) 208.44,128.08 C49.1 ; C34.1 U1.AG18 v4(215.86,128.5) 214.96,129.39 C50.1 ; R1055.2 67.18,129 67.47,129.29 67.47,131.23 68.2,131.95 v1(68.2,133.1) ; C35.1 207.44,127.08 v4(207.86,127.5) ; C22.1 223.44,125.91 v4(223.86,125.5) ; C21.1 206.28,127.08 v4(205.86,127.5) ; C47.1 U1.AC12 v4(221.86,124.5) ; C23.1 213.28,128.08 v4(212.86,128.5) ; C36.1 214.44,127.08 v4(214.86,127.5)
  vias: v1(183.92,182.65) v1(183.93,181.62) v1(183.95,180.46) v1(185.7,182.65) v1(187.35,182.67) v1(187.36,181.65) v1(187.35,180.52) v1(187.48,195.8) v1(187.45,194.72) v1(188.37,195.8) v1(188.42,194.69) v1(189.19,182.75) v1(189.2,181.72) v1(189.19,180.59)
P1V0_DDR_AGND: length 13.7
  TOP w0.254: PQ11.2 197.51,205.33 v1(197.13,204.95)
  TOP w0.356: 195.32,204.05 194.52,204.05 PU8.7
  BOTTOM w0.381: PR209.1 193.09,203.38 193.57,203.86 PR206.2 194.62,204.92 PR208.2 195.96,204.47 196.44,204.95 v1(197.13,204.95)
P1V0_DDR_BST: length 4.2
  TOP w0.254: PU8.10 193.17,205.53 194.79,207.16 PR197.1
P1V0_DDR_CS: length 3.4
  TOP w0.356: PU8.4 193.67,202.44 194.09,202.03 v1(194.31,202.03)
  BOTTOM w0.381: PR208.1 195.07,203.58 194.31,202.82 v1(194.31,202.03)
P1V0_DDR_EN: length 4.5
  TOP w0.381: PU8.5 194.56,202.95 194.94,202.56 v1(195.52,202.56) 196.17,201.92 PC172.1 196.17,199.9 PR330.2
P1V0_DDR_FB: length 9.1
  TOP w0.254: PU8.6 194.97,203.56 195.2,203.33 195.71,203.33 195.89,203.15 PR207.1 PC183.2 PR205.2 PR213.1
  TOP w0.356: v1(199.45,201.51) PR213.1
  BOTTOM w0.356: v1(199.45,201.51) PQ10.2
  BOTTOM w0.381: v2(200.79,202.59) 200.73,202.54 PQ10.2
P1V0_DDR_FB_IN: length 11.4
  TOP w0.254: PC183.1 PR205.1 198.44,203.96 v1(198.44,204.69) 198.38,204.76 PR201.2
  BOTTOM w0.356: v1(198.44,204.69) 197.71,203.96 196.85,203.96 196.34,203.45 196.34,200.91 196.09,200.66 196.09,199.01 197.01,198.09 PR210.1
P1V0_DDR_FB_IN_R: length 4.3
  BOTTOM w0.381: PQ10.3 198.32,200.11 198.32,198.33 PR210.2 199.87,198.09 v2(200,198.22)
P1V0_DDR_FB_R: length 6.1
  TOP w0.254: PQ11.3 199.39,208.89 v1(199.57,208.71) 199.29,208.43 199.29,204.12 PR213.2
P1V0_DDR_MARGIN_HI: length 5.8
  TOP w0.254: PR214.1 PR215.1 PC186.1 199.98,208.29 200.15,208.47 200.15,209.29 199.49,209.95 v1(199.49,210.19) PQ11.1
P1V0_DDR_MARGIN_LO: length 6.2
  TOP w0.356: PR211.1 PC185.1 PR212.1 v1(197.44,200.38)
  BOTTOM w0.356: v1(197.44,200.38) 197.47,200.41 PQ10.1
  BOTTOM w0.381: v1(197.44,200.38) 197.44,199.9 v2(197,199.47)
P1V0_DDR_MODE: length 4.4
  TOP w0.356: PU8.12 190.94,204.66 v1(190.91,204.69)
  BOTTOM w0.381: PR206.1 PR203.2 191.77,204.92 191.15,204.92 190.91,204.69 v1(190.91,204.69) 190.56,204.34 v2(189.87,204.34)
P1V0_DDR_PG: length 8
  TOP w0.254: PU8.9 193.67,205.1 194.24,205.67 v1(194.61,205.67)
  BOTTOM w0.381: PR331.1 198.32,206.42 PR204.1 196.42,206.42 195.96,206.88 v2(195.07,206.88) 194.61,206.42 v1(194.61,205.67) 194,205.67 PR196.2
P1V0_DDR_REF: length 2.7
  TOP w0.254: PU8.8 194.63,204.66 v1(195.58,205.61) 195.7,205.74 PC184.1
P1V0_DDR_SW: length 5.6
  TOP w0.356: PU8.2 192.67,204.42 PU8.11 192.67,205.59
  TOP w0.381: PC173.2 194.34,211.68
  BOTTOM w0.381: v1(191.77,210.06) PR200.1
P1V0_DDR_VCC: length 6.3
  TOP w0.356: PU8.13 191.81,204.05 190.63,204.05 190.32,204.36 PC174.1
  TOP w0.381: v1(190.25,205.61) 189.76,205.13 PC174.1
  BOTTOM w0.381: v1(190.25,205.61) 190.37,205.74 PR203.1 192.13,206.09 PR196.1
P1V0_DDR_VIN: length 1.5
  TOP w0.356: PU8.3 193.17,201.9
  vias: v1(194.18,200.5) v1(194.18,199.61) v1(194.18,198.73) v1(194.18,197.84) v1(194.18,196.82) v1(194.97,197.84) v1(194.97,196.82) v2(192.63,195.6) v2(192.63,194.33) v2(193.9,195.6) v2(193.9,194.33) v2(195.06,194.97)
P1V0_DDR_VOUT: length 32.3
  TOP w0.381: PR201.1 v1(198.38,207.74)
  BOTTOM w0.381: v1(198.38,207.74) 198.38,208.91 v2(197.34,209.95) v2(196.22,211.07) 195.52,211.77 v2(194.29,211.77) v2(192.59,211.77) 186.19,211.77 182.75,208.32 182.75,198.05 183.13,197.67 v1(184.4,197.67)
  vias: v1(184.53,205.08) v1(184.53,204.06) v1(184.53,202.54) v1(184.53,201.65) v1(184.53,200.38) v1(184.53,199.49) v1(184.53,198.47)
P1V0_EN: length 11.8
  TOP w0.254: PU7.33 150.5,190.8 149.76,191.55 v1(149.26,191.55) 148.46,192.35 148.46,193.04 148.12,193.38 PR187.1 PC164.2
  TOP w0.381: v1(145.03,193.04) 144.66,192.67 PR54.2
  T18 w0.254: v1(149.26,191.55) 148.14,192.67 145.41,192.67 v1(145.03,193.04)
P1V0_ILIM: length 3.9
  TOP w0.254: PR172.2 150.1,192.79 v1(150.43,192.46) 151.2,192.46 152.21,191.45 PU7.30
P1V0_MARGIN_HI: length 4.9
  BOTTOM w0.14: PQ9.1 v2(151.37,177.61) PC166.1 PR194.1 PR193.1
P1V0_MARGIN_LO: length 4.8
  BOTTOM w0.14: PR190.1 PR191.1 PC165.1 v2(147.72,177.52) 147.72,178.86 PQ8.1
P1V0_MODE: length 2.9
  TOP w0.254: PU7.39 147.71,187.25 PR166.2
P1V0_PG: length 136.4
  TOP w0.254: PU7.34 149.92,189.75 v1(149.51,190.15) 148.17,191.49 PR183.2 PC150.2
  TOP w0.381: v1(247.14,193.29) 246.89,193.29 246.76,193.43 PR48.1
  T03 w0.381: v1(149.51,190.15) 149.51,188.56 152.27,185.8 163.32,185.8 166.37,188.85 194.82,188.85 201.42,195.45 201.42,201.68 203.96,204.22 206.63,204.22 213.51,211.1 216,211.1 217.75,212.85 236.3,212.85 246.96,202.2 246.96,193.48 v1(247.14,193.29)
  BOTTOM w0.381: v1(149.51,190.15) 149.74,190.15 PR182.2
P1V0_RAMP: length 2.7
  TOP w0.254: PU7.40 148.96,186.75 PR165.2
P1V0_RSN: length 45.9
  TOP w0.305: PU7.2 151.71,185.16 151.31,184.76 150.98,184.76 v1(150.5,184.28)
  TOP w0.381: v1(148.72,180.65) 148.72,182.62 149.45,183.36 PR179.2 ; v1(148.72,180.65) 149.79,180.65 150.5,181.36 v1(150.5,184.28) ; v1(148.72,180.65) 148.63,180.65 PR180.2
  T18 w0.305: v1(175.26,170.05) 175.06,170.26 174.09,170.26 173.84,170 167.77,170 158.7,179.07 150.3,179.07 v1(148.72,180.65)
  BOTTOM w0.381: v1(175.26,170.05) 174.32,170.05 PR181.1 ; PQ9.2 149.39,179.98 v1(148.72,180.65)
P1V0_RSP: length 16.9
  TOP w0.305: PU7.1 150.61,186.04
  TOP w0.381: 150.61,186.04 149.48,184.91 PR179.1 148.95,184.18 v1(148.72,184.4) 148.46,184.66 147.15,184.66 PR178.2 145.19,184.18 v1(144.78,183.77)
  BOTTOM w0.381: v1(148.72,184.4) 149.16,183.96 PC149.2 PR192.1 ; PQ8.2 144.78,178.99 144.4,179.37 v2(144.4,181.72) 144.4,183.39 v1(144.78,183.77)
P1V0_RSP_R: length 2.9
  BOTTOM w0.381: v2(152.02,182.82) 150.89,182.82 PR192.2 150.89,181.8 PQ9.3
P1V0_RSP_R1: length 4.7
  TOP w0.381: v1(147.83,183.9) 147.3,183.37 PR178.1 PR505.2
  BOTTOM w0.381: PC149.1 PR189.1 147.41,183.48 v1(147.83,183.9)
P1V0_RSP_R1R: length 2.6
  BOTTOM w0.381: PQ8.3 146.6,182.19 146.6,182.76 PR189.2 145.79,182.76 v2(145.54,183.01)
P1V0_RT: length 2.6
  TOP w0.254: PU7.38 148.82,187.75 PR167.2
P1V0_SN: length 2.9
  TOP w0.508: PC163.1 165.4,186.93 PR184.2
P1V0_SS: length 3.4
  TOP w0.254: PU7.37 149.66,188.25 148.3,189.61 PR169.2
P1V0_SW: length 1
  TOP w0.508: PC162.2 154.47,179.92
P1V0_VDD: length 6.9
  TOP w0.305: PU7.26 154.21,191.67 153.67,192.21 153.67,193.29 v1(153.42,193.55)
  TOP w0.508: v1(153.42,193.55) 153.42,194.96 PR168.1
  BOTTOM w0.381: PC138.1 153.45,193.51 v1(153.42,193.55)
P1V0_VIN:
  vias: v1(154.61,200.8) v1(154.61,199.53) v1(154.67,198.28) v1(154.67,196.88) v1(154.67,195.64) v1(154.67,194.37) v1(154.67,193.22) v1(155.5,200.16) v1(155.5,198.89) v1(155.5,197.49) v1(155.5,196.22) v1(155.5,194.95) v1(155.5,193.68) v1(155.5,192.54) v1(156.39,200.8) v1(156.39,199.53) v1(156.4,198.28) v1(156.4,196.88) v1(156.4,195.64) v1(156.4,194.37) v1(156.4,193.22) v1(157.15,192.67) v1(157.64,193.18) v2(152.02,202.06) v2(152.02,200.79) v2(152.02,199.52) v2(152.02,198.25) v2(152.02,196.98) v2(153.54,202.06) v2(153.54,200.79) v2(153.54,199.52) v2(153.54,198.25) v2(153.54,196.98)
P1V0_VSEL: length 3.6
  TOP w0.254: PR170.2 148.09,190.55 149.89,188.75 PU7.36
P1V2: length 249.7
  TOP w0.305: U2.J1 v4(206.46,161.47) ; 262.53,150.68 262.67,150.81 PU10.2
  TOP w0.381: U5.D1 v4(233.38,156.67) ; R1053.2 v1(117.32,182.81) ; U7.J9 v4(257.3,137.53) ; U7.D1 v4(252.5,130.33) ; U3.R1 v4(218.63,166.28) ; U6.B3 v4(250.9,120.26) ; U3.B9 v4(211.43,155.07) ; U6.R1 v4(262.1,118.66) ; U3.J9 v4(211.43,161.47) ; U5.L9 v4(226.18,163.07) ; U2.R1 v4(206.46,166.28) ; U3.L1 v4(218.63,163.07) ; U2.L9 v4(199.26,163.07) ; U4.J1 v4(245.56,161.47) ; U3.J1 v4(218.63,161.47) ; U6.D1 v4(252.5,118.66) ; U2.T9 v4(199.26,167.08) ; U5.R1 v4(233.38,166.28) ; U2.L1 v4(206.46,163.07) ; U4.B9 v4(238.35,155.07) ; U6.B9 v4(250.9,125.86) ; U7.L1 v4(258.9,130.33) ; U4.R1 v4(245.56,166.28) ; U3.L9 v4(211.43,163.07) ; U2.G7 v4(200.86,159.07) ; U3.D1 v4(218.63,156.67) ; U5.J1 v4(233.38,161.47) ; U6.G7 v4(254.9,124.26) ; U5.B9 v4(226.18,155.07) ; U4.B3 v4(243.96,155.07) ; U7.J1 v4(257.3,130.33) ; PR220.1 v1(253.22,207.74) ; U6.T9 v4(262.9,125.86) ; U7.B3 v4(250.9,131.93) ; U3.G7 v4(213.03,159.07) ; U4.J9 v4(239.15,160.67) ; U5.J9 v4(226.18,161.47) ; U4.D1 v4(245.56,156.67) ; U4.T9 v4(238.35,167.08) ; U4.L1 v4(245.56,163.07) ; U6.J1 v4(257.3,118.66) ; U2.B9 v4(199.26,155.07) ; U6.L9 v4(258.9,125.86) ; U4.G7 v4(239.95,159.07) ; U3.B3 v4(217.03,155.07) ; U5.G7 v4(227.78,159.07) ; U6.L1 v4(258.9,118.66) ; U2.D1 v4(206.46,156.67) ; U7.T9 v4(262.9,137.53) ; U7.G7 v4(254.9,135.93) ; U7.R1 v4(262.1,130.33) ; U5.L1 v4(233.38,163.07) ; U4.L9 v4(238.35,163.07) ; U2.J9 v4(199.26,161.47) ; U7.L9 v4(258.9,137.53) ; U5.B3 v4(231.78,155.07) ; U5.T9 v4(226.18,167.08) ; U7.B9 v4(250.9,137.53) ; U2.B3 v4(204.86,155.07) ; U6.J9 v4(257.3,125.86) ; U3.T9 v4(211.43,167.08)
  T03 w0.381: v1(117.32,182.81) 117.32,183.36 118.49,184.53 133.99,184.53 135.64,186.18 143,186.18 144.02,185.17 150.75,185.17 151.64,184.28 163.96,184.28 167,187.32 201.17,187.32
  BOTTOM w0.381: C749.2 259.24,126.2 v4(258.9,125.86) ; v4(239.95,159.07) 240.37,159.49 C711.2 ; C748.1 263.14,125.86 v4(262.9,125.86) ; v4(211.43,167.08) 211.91,167.55 C656.1 ; C744.2 258.57,118.33 v4(258.9,118.66) ; C653.1 198.83,154.65 v4(199.26,155.07) ; v1(238.99,197.19) 237.5,197.19 236.88,197.81 236.88,208.75 239.84,211.71 247.89,211.71 250.64,208.96 252,208.96 v1(253.22,207.74) ; C737.2 262.54,118.22 v4(262.1,118.66) ; C712.1 251.24,132.27 v4(250.9,131.93) ; C745.1 263.19,137.53 v4(262.9,137.53) ; C739.1 254.5,123.86 v4(254.9,124.26) 255.45,123.72 C746.2 ; v4(226.18,163.07) 225.84,163.41 C655.2 ; v4(199.26,163.07) 198.88,162.7 C636.2 ; C689.1 243.62,155.41 v4(243.96,155.07) ; C689.1 243.12,154.87 ; C689.1 242.56,155.41 ; C661.1 218.69,156.73 v4(218.63,156.67) ; C697.2 252.56,118.6 v4(252.5,118.66) ; v4(233.38,156.67) 233.44,156.73 C666.2 ; v4(238.35,163.07) 238.14,163.29 C695.2 236.84,163.29 R140.2 ; v4(245.56,161.47) 245.59,161.51 C698.1 246.61,161.25 C696.1 ; v4(254.9,135.93) 254.8,135.83 C747.2 ; v1(264.05,120.82) 264.05,120.51 264.5,120.06 PC197.1 v1(264.95,121.04) ; v4(239.15,160.67) 238.32,161.51 C675.1 ; v4(211.43,161.47) 211.4,161.51 C628.1 ; v4(213.03,159.07) 213.43,159.48 C635.1 ; C659.1 218.66,161.51 v4(218.63,161.47) ; R95.2 210.35,163.04 C633.1 211.22,163.29 v4(211.43,163.07) ; v4(226.18,155.07) 225.76,154.65 C670.1 ; v4(257.3,118.66) 257.43,118.54 C741.2 ; v4(199.26,161.47) 198.72,160.94 C674.2 ; v1(203.85,159.19) 203.85,158.34 202.36,156.85 C743.1 ; C660.2 206.52,166.33 v4(206.46,166.28) ; C634.2 206.52,156.73 v4(206.46,156.67) ; C673.1 238.12,167.31 v4(238.35,167.08) ; C692.2 251.11,120.47 v4(250.9,120.26) ; v4(257.3,137.53) 257.34,137.56 C715.1 ; v4(258.9,137.53) 259.11,137.74 C751.1 ; v4(245.56,156.67) 245.61,156.73 C688.1 ; C669.2 201.28,159.5 v4(200.86,159.07) 201.38,158.55 C693.1 201.61,156.45 C743.1 ; v4(238.35,155.07) 237.93,154.65 C724.2 ; v4(254.1,131.93) 254.22,132.04 C713.1 ; v1(221.14,168.99) 221.14,167.65 PC199.1 220.37,167.76 v1(220.37,168.79) ; v4(258.9,130.33) 258.48,129.91 C738.2 258.48,129.22 C651.1 ; v4(227.92,167.21) 228.08,167.38 PC198.1 228.08,169.01 v1(227.57,169.52) ; v4(250.9,125.86) 250.48,126.29 C714.1 ; R181.2 v1(258.27,127.56) 257.78,127.56 C651.1 ; v4(262.1,130.33) 262.1,130.27 C750.2 ; v4(226.18,167.08) 225.97,167.29 C699.2 ; C687.2 207.26,161.51 C632.2 206.49,161.51 v4(206.46,161.47) ; v4(227.78,159.07) 228.18,159.48 C667.1 C668.1 ; C654.1 216.69,155.41 v4(217.03,155.07) ; C671.2 231.57,155.28 v4(231.78,155.07) ; C665.1 234.82,161.66 234.82,162.69 234.44,163.07 v4(233.38,163.07) ; C694.1 245.65,166.37 v4(245.56,166.28) ; v4(250.9,137.53) 250.48,137.95 C742.1 ; v4(233.38,166.28) 233.82,166.71 C686.1 ; v4(252.5,130.33) 252.56,130.27 C690.2 ; v4(257.3,125.86) 257.48,126.04 C740.2 257.3,126.7 C651.1 ; v4(226.18,161.47) 226,161.65 C716.2 ; C627.1 211.01,154.65 v4(211.43,155.07) ; v4(239.96,155.87) 240.51,155.87 C735.1 ; R97.2 219.49,165.84 C672.1 219.03,165.87 v4(218.63,166.28) 218.83,166.28 C658.1 ; C691.1 198.96,167.38 v4(199.26,167.08) ; C651.1 257.01,128.33 257.01,130.04 v4(257.3,130.33) ; C743.1 203.09,155.7 203.5,155.28 C652.2 204.65,155.28 v4(204.86,155.07) ; R179.2 v1(261.37,115.95) ; C657.2 233.42,161.51 v4(233.38,161.47) ; R138.2 247.69,162.79 v1(247.64,162.84)
  vias: v1(238.12,203.13) v1(238.12,201.48) v1(238.12,200.08) v1(239.01,198.02) v1(239.25,204.06) v1(239.25,199.36) v1(239.27,202.37) v1(239.27,200.84) v1(240,198.06) v1(240,197.19) v1(255.67,168.81) v1(255.67,167.8) v1(256.8,168.83) v1(256.8,167.81) v1(257.73,168.8) v1(257.73,167.79) v1(258.78,168.82) v1(258.78,167.81) v1(258.82,164.14) v1(258.82,163.12) v2(249.24,159.48) v2(249.24,158.21) v2(249.24,156.94) v2(250.51,159.48) v2(250.51,158.21) v2(250.51,156.94) v6(260.6,150.55) v6(260.73,149.66) v6(261.62,150.6) v6(261.75,149.71)
P1V2_AGND: length 14.3
  TOP w0.254: PQ13.2 252.35,205.2 v1(251.97,204.82)
  TOP w0.356: 250.16,204.05 249.36,204.05 PU9.7
  BOTTOM w0.381: PR228.1 247.93,203.73 248.42,204.21 PR225.2 248.9,204.92 248.93,204.9 248.95,204.9 250.02,203.83 PR227.2 250.98,203.83 v1(251.97,204.82)
P1V2_BST: length 4.1
  TOP w0.254: 248.01,205.21 PU9.10
  TOP w0.381: 248.01,205.21 248.01,205.34 249.83,207.16 PR217.1
P1V2_CS: length 2.8
  TOP w0.254: PU9.4 248.51,203.05 248.51,202.49 248.94,202.05 v1(249.31,202.05)
  BOTTOM w0.381: PR227.1 250.04,202.79 v1(249.31,202.05)
P1V2_EN: length 23.3
  TOP w0.254: v1(250.95,200.34) 251.01,200.39 PC192.1 249.5,202.95 PU9.5
  TOP w0.381: PR49.2 v1(239.11,192.49)
  BOTTOM w0.381: v1(239.11,192.49) 240.63,194 250.57,194 250.95,194.38 v1(250.95,200.34)
P1V2_FB: length 9.4
  TOP w0.254: PR232.1 PR224.2 PC203.2 PR226.1 250.16,203.15 249.75,203.56 PU9.6
  TOP w0.356: v1(254.3,201.51) PR232.1
  BOTTOM w0.356: v1(254.3,201.51) PQ12.2
  BOTTOM w0.381: v2(254.89,203.93) 254.3,203.34 PQ12.2
P1V2_FB_IN: length 12.6
  TOP w0.381: PC203.1 PR224.1 v1(253.28,204.65) 253.28,205.47 PR220.2
  BOTTOM w0.356: v1(253.28,204.65) 253.48,204.85 255.44,204.85 255.91,204.38 255.91,199.88 PR229.1
P1V2_FB_IN_R: length 3.7
  BOTTOM w0.356: PR229.2 253.31,198.69 253.11,198.88 253.11,200.06 PQ12.3
  BOTTOM w0.381: v2(252.53,197.31) 252.92,197.31 253.31,197.69 PR229.2
P1V2_FB_R: length 6
  TOP w0.381: PR232.2 254.56,204.22 v1(254.56,208.41) 254.08,208.89 PQ13.3
P1V2_MARGIN_HI: length 4.8
  TOP w0.14: v1(255.04,209.92) 254.33,210.62 PQ13.1
  BOTTOM w0.14: PR233.1 PR234.1 PC206.1 v1(255.04,209.92)
P1V2_MARGIN_LO: length 6.7
  TOP w0.14: v1(252.28,200.38) PR231.1 PC205.1 PR230.1
  BOTTOM w0.14: v2(251.84,198.91) 251.84,199.94 v1(252.28,200.38) 252.31,200.41 PQ12.1
P1V2_MODE: length 4.1
  TOP w0.254: v1(245.85,204.66) 247.01,204.66 PU9.12
  BOTTOM w0.254: PR225.1 PR222.2 246.11,204.92 v1(245.85,204.66)
  BOTTOM w0.381: v2(246.63,203.84) 246.61,203.86 PR222.2
P1V2_PG: length 103.5
  TOP w0.254: v1(249.2,205.54) 248.99,205.54 248.51,205.06 PU9.9
  TOP w0.381: v1(278.89,125.02) 278.39,124.52 PR33.1
  T07 w0.381: v1(249.2,205.54) 251.39,203.35 253.37,203.35 256.51,200.2 256.51,196.01 260.6,191.92 260.6,184.78 263.65,181.74 263.65,168.2 269.52,162.33 269.52,146.91 276.73,139.7 276.73,133.35 279.67,130.42 279.67,125.77 278.91,125.02 v1(278.89,125.02)
  BOTTOM w0.254: 248.42,206.09 PR218.2 ; v1(249.2,205.54) 249.16,205.58
  BOTTOM w0.381: 248.42,206.09 248.5,206.09 249.01,205.58 249.16,205.58 ; v2(254,206.42) PR223.1 251.77,206.38 250.12,206.38 249.29,205.54 v1(249.2,205.54)
P1V2_REF: length 2.7
  TOP w0.254: PC204.1 250.59,205.74 v1(250.39,205.54) 249.52,204.66 PU9.8
P1V2_SW: length 5.3
  TOP w0.356: PU9.2 247.51,204.42 PU9.11 247.51,205.59
  TOP w0.508: PC193.2 249.58,211.17
  BOTTOM w0.381: PR219.1 v1(246.63,210.06)
P1V2_VCC: length 6.3
  TOP w0.254: v1(244.98,205.49) 244.61,205.11 PC194.1 245.29,204.36 245.6,204.05 246.65,204.05 PU9.13
  BOTTOM w0.254: v1(244.98,205.49) 245.23,205.74 PR222.1 246.97,206.09 PR218.1
P1V2_VDDQ: length 253.6
  TOP w0.14: U6.J2 v4(257.3,119.46) ; U7.J2 v4(257.3,131.13)
  TOP w0.305: U2.J2 v4(205.66,161.47)
  TOP w0.381: v1(218.87,171.64) 219.34,171.17 C75.1 v1(219.34,169.49) ; U5.F8 v4(226.98,158.27) ; C156.1 235.51,174.61 v1(235.06,175.07) ; U4.G1 v4(245.56,159.07) ; U1.AD7 v4(226.86,125.5) ; U1.AT10 v4(223.86,137.5) ; v1(271.49,125.75) 271.11,126.13 C163.1 ; U7.F2 v4(254.1,131.13) ; U3.A9 v4(211.43,154.27) ; v1(214.97,175.18) 214.62,174.82 C136.1 ; U4.D9 v4(238.35,156.67) ; U1.AD4 v4(229.86,125.5) ; U1.AG4 v4(229.86,128.5) ; C119.2 206.9,174.61 v1(206.44,175.07) ; U5.G1 v4(233.38,159.07) ; U1.AE2 v4(231.86,126.5) ; U1.AK22 v4(210.86,131.5) ; U7.D9 v4(252.5,137.53) ; C174.2 242.14,175.18 v1(242.57,175.18) 242.27,174.87 C143.2 ; U1.AT37 v4(195.86,137.5) ; U1.AK4 v4(229.86,131.5) ; U5.G9 v4(226.18,159.07) ; U1.AB5 v4(228.86,123.5) ; U1.AP8 v4(225.86,135.5) ; U1.AF9 v4(224.86,127.5) ; C150.2 270.92,131.92 v1(271.38,132.38) ; U1.AT7 v4(226.86,137.5) ; U1.AT25 v4(207.86,137.5) ; U6.A1 v4(250.1,118.66) ; v1(260.56,140.4) 260.56,141.59 259.78,142.37 C96.1 ; U1.AP17 v4(216.86,135.5) ; U2.G9 v4(199.26,159.07) ; v1(217.69,169.47) C370.1 217.69,171.61 v1(217.49,171.8) ; U1.AN4 v4(229.86,134.5) ; U1.AT16 v4(217.86,137.5) ; C166.2 v1(271.38,137.2) ; U1.AK31 v4(201.86,131.5) ; U1.AT19 v4(214.86,137.5) ; U3.J2 v4(217.83,161.47) ; v1(232.16,175.3) 231.79,174.93 C139.1 231.75,174.34 C140.2 230.22,174.33 C153.2 C146.1 v1(228.35,175.13) ; v1(236.73,175.18) 236.73,175.18 236.73,174.6 C148.2 ; C157.1 270.92,118.41 v1(271.38,118.86) ; C96.1 258.99,141.6 v1(258.99,140.39) ; C96.1 v1(259.76,140.4) ; U2.J8 v4(200.06,160.67) ; U1.AM18 v4(215.86,133.5) ; U1.AL2 v4(231.86,132.5) ; U6.J8 v4(257.3,125.06) ; U1.AK7 v4(226.86,131.5) ; U6.F8 v4(254.1,125.06) ; U1.AH8 v4(225.86,129.5) ; v1(271.62,135.27) 270.92,135.27 C118.1 271.14,136.24 v1(271.51,136.24) ; U4.A9 v4(238.35,154.27) ; v1(266.17,119.38) 266.17,120.08 C262.1 266.5,120.34 266.88,119.96 v1(266.88,119.4) ; U6.C1 v4(251.7,118.66) ; U2.A1 v4(206.46,154.27) ; U2.A9 v4(199.26,154.27) ; U3.G1 v4(218.63,159.07) ; C125.1 212.69,174.8 v1(213.07,175.18) ; v1(217.01,175.18) 216.55,174.72 C133.1 ; C172.1 270.98,121.3 v1(271.49,121.81) ; U1.AP29 v4(203.86,135.5) ; U1.AP32 v4(200.86,135.5) ; U6.F2 v4(254.1,119.46) ; C124.2 208.12,174.6 208.12,175.18 v1(208.12,175.18) ; C134.2 239.37,175.03 v1(239.53,175.18) ; v1(210.91,175.18) 210.76,175.03 C123.1 ; U1.AB8 v4(225.86,123.5) ; U1.AM6 v4(227.86,132.5) ; C178.1 271.34,128.06 v1(271.49,127.91) ; U6.G1 v4(254.9,118.66) ; U6.D9 v4(252.5,125.86) ; U1.AH11 v4(222.86,129.5) ; U1.AK13 v4(220.86,131.5) ; v1(271.49,130.7) 270.91,130.7 C176.2 ; U7.G9 v4(254.9,137.53) ; U1.AP35 v4(197.86,135.5) ; U4.F8 v4(239.15,158.27) ; U2.D9 v4(199.26,156.67) ; U1.AP2 v4(231.86,135.5) ; U5.F2 v4(232.58,158.27) ; U1.AM21 v4(211.86,133.5) ; U5.J2 v4(232.58,161.47) ; U1.AK16 v4(217.86,131.5) ; U1.AM9 v4(224.86,133.5) ; v1(244.61,175.18) 244.2,174.77 C155.2 ; U1.AM24 v4(208.86,133.5) ; U1.AK28 v4(204.86,131.5) ; v1(219.67,175.18) 219.45,174.95 C130.1 ; U1.AM33 v4(199.86,133.5) ; U1.AP11 v4(222.86,135.5) ; U4.F2 v4(244.76,158.27) ; U6.G9 v4(254.9,125.86) ; U2.C1 v4(206.46,155.87) ; U6.A9 v4(250.1,125.86) ; U2.G1 v4(206.46,159.07) ; U4.J2 v4(244.76,161.47) ; U2.F8 v4(200.06,158.27) ; C160.1 203.17,174.93 v1(203.54,175.3) ; U5.A9 v4(226.18,154.27) ; U1.AH17 v4(216.86,129.5) ; U1.AH14 v4(219.86,129.5) ; U7.J8 v4(256.5,136.73) ; U1.AH29 v4(203.86,129.5) ; C171.2 v1(271.39,129.02) ; U1.AM12 v4(221.86,133.5) ; U3.F8 v4(212.23,158.27) ; U1.AF6 v4(227.86,127.5) ; U7.G1 v4(254.9,130.33) ; U5.C1 v4(233.38,155.87) ; U3.G9 v4(211.43,159.07) ; U7.A9 v4(250.1,137.53) ; U5.D9 v4(226.18,156.67) ; U1.AM15 v4(218.86,133.5) ; U1.AP6 v4(227.86,135.5) ; U3.F2 v4(217.83,158.27) ; C129.2 v1(201.61,175.07) ; U7.C1 v4(251.7,130.33) ; U7.F8 v4(254.1,136.73) ; C161.2 v1(238.41,175.08) ; U1.AP14 v4(219.86,135.5) ; U1.AT13 v4(220.86,137.5) ; U5.A1 v4(233.38,154.27) ; U3.A1 v4(218.63,154.27) ; U1.AK10 v4(223.86,131.5) ; U1.AT22 v4(210.86,137.5) ; U1.AB2 v4(231.86,123.5) ; U1.AK25 v4(207.86,131.5) ; U1.AT4 v4(229.86,137.5) ; U5.J8 v4(226.98,161.47) ; U1.AH2 v4(231.86,129.5) ; U7.A1 v4(250.1,130.33) ; U4.G9 v4(238.35,159.07) ; C145.2 v1(209.79,175.08) ; C177.1 271.13,124.2 v1(271.49,123.84) ; U1.AP20 v4(212.86,135.5) ; U1.AT28 v4(204.86,137.5) ; U2.F2 v4(205.66,158.27) ; U1.AP23 v4(209.86,135.5) ; U1.AK19 v4(214.86,131.5) ; U3.J8 v4(212.23,161.47) ; U1.AT34 v4(198.86,137.5) ; U1.AP26 v4(206.86,135.5) ; U4.A1 v4(245.56,154.27) ; U1.AT31 v4(201.86,137.5) ; U4.C1 v4(245.56,155.87) ; U3.C1 v4(218.63,155.87) ; U4.J8 v4(239.95,160.67) ; U1.AM30 v4(202.86,133.5) ; U3.D9 v4(211.43,156.67) ; U1.AM27 v4(205.86,133.5)
  BOTTOM w0.381: C107.1 222.44,129.08 v4(222.86,129.5) ; v1(239.53,175.18) 239.88,174.82 C152.1 ; v1(213.07,175.18) 213.2,175.05 C137.2 ; C308.1 216.44,129.08 v4(216.86,129.5) ; v4(211.43,159.07) 210.97,159.54 C314.1 ; C89.2 198.84,153.85 v4(199.26,154.27) ; v4(219.86,135.5) 219.44,135.08 C283.2 ; v1(271.49,127.91) 271.13,127.55 C164.2 ; C256.1 254.51,118.27 v4(254.9,118.66) ; v1(271.49,123.84) 271.33,123.69 C180.1 ; C367.1 251.55,130.18 v4(251.7,130.33) ; C360.2 226.44,137.07 v4(226.86,137.5) ; C82.1 256.58,136.66 v4(256.5,136.73) 256.37,136.86 C87.1 ; C342.2 225.36,127 v4(224.86,127.5) ; C170.1 v1(271.38,132.38) ; v4(212.23,161.47) 211.81,161.06 C317.1 211.59,160.54 C319.1 ; C169.2 271.36,125.62 v1(271.49,125.75) ; v4(217.86,137.5) 217.44,137.08 C303.1 ; C70.1 252.45,125.91 v4(252.5,125.86) ; C310.2 225.76,153.85 v4(226.18,154.27) ; v4(202.86,133.5) 203.28,133.91 C366.1 ; v4(206.46,155.87) 206.61,155.72 C260.2 ; C151.1 238.92,174.57 v1(238.41,175.08) ; C158.2 270.88,128.52 v1(271.39,129.02) ; v4(239.95,160.67) 239.95,160.63 240.51,160.08 241.33,160.08 C86.2 ; v4(217.86,131.5) 217.44,131.08 C309.1 ; v4(251.7,118.66) 251.55,118.51 C72.2 ; C93.1 202.28,131.91 v4(201.86,131.5) ; C80.1 254.9,137.64 v4(254.9,137.53) ; v4(232.58,158.27) v4(233.38,159.07) ; v4(233.38,159.07) 233.78,158.68 C60.1 ; v4(233.38,159.07) 233.93,159.62 C61.1 ; C341.1 206.85,158.68 v4(206.46,159.07) ; C108.2 C343.1 205.37,161.18 v4(205.66,161.47) ; v4(227.86,132.5) U1.AM6 C337.2 ; C131.1 217.06,175.13 v1(217.01,175.18) ; v4(220.86,137.5) 220.44,137.08 C104.1 ; v4(204.86,137.5) 204.44,137.08 C116.2 ; v4(215.86,133.5) 215.44,133.08 C311.1 ; v4(254.9,130.33) 255.45,129.78 C83.1 ; v4(254.9,130.33) 254.51,129.93 C369.1 ; v4(254.9,130.33) v4(254.1,131.13) ; C259.1 245.71,155.72 v4(245.56,155.87) ; v4(254.1,119.46) v4(254.9,118.66) ; v4(254.9,118.66) 255.45,118.12 C77.1 ; v4(226.86,131.5) 226.44,131.08 C316.2 ; C254.2 212.28,133.91 v4(211.86,133.5) ; C56.1 223.44,137.08 v4(223.86,137.5) ; v4(205.86,133.5) 206.28,133.91 C344.1 ; v4(233.38,155.87) 233.53,155.72 C274.1 ; C261.1 245.95,158.68 v4(245.56,159.07) ; C132.2 210.3,174.57 v1(209.79,175.08) ; v4(195.86,137.5) 196.28,137.91 C103.2 ; C154.1 v1(232.16,175.3) ; v4(201.86,137.5) 201.44,137.08 C111.2 ; C173.1 271.44,121.76 v1(271.49,121.81) ; C282.1 C63.1 232.29,161.18 v4(232.58,161.47) ; C92.1 198.28,135.91 v4(197.86,135.5) ; C99.1 210.44,131.08 v4(210.86,131.5) ; C67.2 249.68,126.28 v4(250.1,125.86) ; C140.2 C141.1 v1(231.2,175.2) ; C101.2 200.05,160.68 v4(200.06,160.67) ; v1(228.35,175.13) 228.32,175.11 C147.1 ; v4(250.1,130.33) 249.72,130.71 C76.2 ; v4(257.3,131.13) 256.88,131.55 C85.1 ; C305.2 226.13,156.62 v4(226.18,156.67) ; v4(212.86,135.5) 212.36,136 C285.2 ; C91.2 249.68,137.95 v4(250.1,137.53) ; v1(219.67,175.18) 219.67,174.63 C138.1 ; v4(224.86,133.5) 224.44,133.08 C55.1 ; v4(231.86,126.5) 231.45,126.08 C286.1 ; v4(222.86,135.5) 222.44,135.08 C289.1 ; C302.2 227.44,127.08 v4(227.86,127.5) ; v4(231.86,135.5) 231.44,135.08 C62.2 ; C304.1 216.44,135.08 v4(216.86,135.5) ; C58.1 231.44,123.08 v4(231.86,123.5) ; C110.1 223.44,131.08 v4(223.86,131.5) ; v4(226.86,125.5) 226.44,125.08 C307.2 ; v4(257.3,119.46) 257.01,119.75 C78.1 C98.2 ; v4(233.38,154.27) 233.38,154.02 C284.1 ; C135.1 215.13,175.02 v1(214.97,175.18) ; v4(227.86,135.5) 227.44,135.08 C365.2 ; C90.1 199.05,156.47 v4(199.26,156.67) ; C364.1 208.44,133.08 v4(208.86,133.5) ; C59.2 237.94,153.85 v4(238.35,154.27) ; C165.1 271.61,135.27 v1(271.62,135.27) ; C95.1 204.28,135.91 v4(203.86,135.5) ; v4(210.86,137.5) 210.44,137.08 C320.1 ; C73.1 225.44,135.08 v4(225.86,135.5) ; v4(199.86,133.5) 200.28,133.91 C88.1 ; C69.2 238.22,156.54 v4(238.35,156.67) ; v4(211.43,156.67) 211.42,156.66 C315.1 ; v1(271.38,118.86) C175.1 ; v4(245.56,154.27) 245.17,153.89 C66.1 ; C142.1 v1(235.06,175.07) ; v4(245.56,159.07) v4(244.76,158.27) ; v4(245.56,159.07) 246.1,159.62 C255.1 ; v4(231.86,129.5) 231.45,129.08 C57.2 ; C306.1 215.36,131 v4(214.86,131.5) ; C321.2 227.4,161.06 v4(226.98,161.47) ; v4(211.43,154.27) 211.01,153.85 C280.2 ; v1(244.61,175.18) 244.71,175.08 C159.1 ; v4(205.66,158.27) v4(206.46,159.07) ; v4(206.46,159.07) 207,159.62 C339.1 ; v4(225.86,129.5) 225.44,129.08 C117.1 ; C115.1 219.03,158.68 v4(218.63,159.07) ; v4(221.86,133.5) 221.44,133.08 C105.1 ; v4(199.26,159.07) 199.16,159.17 C94.2 ; v1(208.12,175.18) 208.12,175.18 208.37,174.92 C122.2 ; C313.2 226.28,123.91 v4(225.86,123.5) ; C129.2 v1(201.61,175.07) ; C368.2 231.44,132.08 v4(231.86,132.5) ; v4(229.86,131.5) 229.44,131.08 C275.1 ; C71.1 252.49,137.54 v4(252.5,137.53) ; v1(210.91,175.18) 211.27,174.82 C127.2 ; C361.1 201.28,135.91 v4(200.86,135.5) ; v4(204.86,131.5) 205.28,131.91 C106.2 ; C79.2 256.88,124.64 v4(257.3,125.06) ; v4(206.46,154.27) 206.08,153.89 C258.2 ; v4(214.86,137.5) 215.28,137.91 C102.1 ; C100.1 217.41,161.06 v4(217.83,161.47) ; C338.1 207.28,135.91 v4(206.86,135.5) ; C318.2 218.25,153.89 v4(218.63,154.27) ; C362.1 208.36,132 v4(207.86,131.5) ; v1(271.49,130.7) 271.23,130.45 C179.2 ; C68.1 244.34,161.06 v4(244.76,161.47) ; v4(219.86,129.5) 219.44,129.08 C109.1 ; v1(242.57,175.18) 242.78,174.97 C162.1 ; v4(238.35,159.07) 238.3,159.07 237.88,159.49 C64.2 237.8,159.58 C65.1 ; v4(229.86,137.5) 229.44,137.07 C54.2 ; v4(254.9,125.86) 255.35,126.31 C84.2 ; v4(229.86,134.5) 229.44,134.08 C281.1 ; C120.1 v1(203.54,175.3) ; C257.2 218.44,133.08 v4(218.86,133.5) ; C346.1 207.44,137.08 v4(207.86,137.5) ; v1(236.73,175.18) 236.73,175.18 236.99,174.92 C149.1 ; C126.1 v1(206.44,175.07) ; C112.1 218.78,155.72 v4(218.63,155.87) ; C81.2 249.72,119.04 v4(250.1,118.66) ; v4(218.63,159.07) v4(217.83,158.27) ; v4(218.63,159.07) 219.18,159.62 C114.1 ; C288.2 220.44,131.08 v4(220.86,131.5) ; v4(209.86,135.5) 210.28,135.91 C322.1 ; C168.1 v1(271.51,136.24) ; C166.2 v1(271.38,137.2) ; C340.2 225.74,159.52 v4(226.18,159.07) ; C113.2 198.44,137.08 v4(198.86,137.5) ; v4(228.86,123.5) 228.36,124 C345.2 ; C121.1 v1(202.58,175.2) ; C287.1 229.44,125.08 v4(229.86,125.5) ; C363.2 229.44,128.08 v4(229.86,128.5)
  vias: v1(192.35,167.14) v1(192.35,166.38) v1(193.17,167.13) v1(193.17,166.38) v1(193.93,167.13) v1(193.93,166.37) v1(194.9,144) v1(194.88,143.28) v1(195.26,144.66) v1(195.51,142.96) v1(234.31,140.9) v1(235.07,140.9) v1(235.83,140.9) v1(236.59,140.9) v1(252.42,160.03) v1(252.42,159.26) v1(252.42,158.5) v1(253.24,160.02) v1(253.24,159.26) v1(253.24,158.5) v1(254,159.26) v1(254,158.5) v2(253.04,162.73) v2(253.04,161.46) v2(254.31,162.73) v2(254.31,161.46) v2(255.58,162.71) v2(255.58,161.44) v2(255.61,160.16) v2(255.61,158.87) v2(256.85,162.71) v2(256.85,161.44) v2(256.88,160.16) v2(256.88,158.87)
P1V2_VIN: length 1.5
  TOP w0.381: PU9.3 248.01,201.9
  vias: v1(249.03,200.5) v1(249.03,199.61) v1(249.03,198.73) v1(249.03,197.84) v1(249.03,196.82) v1(249.81,197.84) v1(249.81,196.82) v2(247.58,195.48) v2(248.92,195.49)
P1V05_CPU: length 109.9
  T07 w0.381: v1(48.26,102.87) 47.75,102.36 43.56,102.36 38.61,107.31 36.96,107.31 35.81,108.46 35.81,128.78 38.99,131.95 41.93,131.95 42.31,132.33 46.35,132.33 47.5,133.48 49.02,133.48 53.97,138.43 57.78,138.43 61.72,142.37 61.72,146.33 67.99,152.6 67.99,154.84 69.06,155.91 69.06,159.26 70.12,160.33 70.12,161.52 71.27,162.66 85.33,162.66 J1.A22
  BOTTOM w0.381: v1(48.26,102.87) 48.86,103.47 R12281.2
P1V05_PECI: length 2
  TOP w0.381: U154.V19 v4(57.73,106.52)
  BOTTOM w0.381: R12281.1 51.55,103.47 51.56,103.48 51.89,103.48 v1(52.21,103.8)
P1V8: length 110.9
  TOP w0.305: U127.50 73.22,87.73 v1(73.39,87.56)
  TOP w0.381: U127.3 68.02,74.28 67.89,74.4 v1(67.89,74.43) ; R1060.2 119.46,181.13 119.08,181.51 v1(119.08,181.51) ; U127.71 66.31,80.75 v1(66.67,80.39) ; PR107.1 214.34,212 v1(214.5,211.84) ; v1(183.3,142.77) 183.97,142.1 C2387.2 ; v1(79.43,82.43) 79.8,82.05 U127.32
  TOP w0.508: L204.1 183.97,139.68 C2387.2 ; L205.2 191.08,140.47 C613.1 189.94,142.04 v3(189.48,142.49)
  T03 w0.508: v1(170.11,164.32) 170.11,166.02 154.39,181.74 145.03,181.74 143.38,183.39 135.13,183.39 133.34,181.6 119.17,181.6 v1(119.08,181.51)
  BOTTOM w0.381: v1(71.09,86.68) C1996.2 73.3,86.68 C1997.2 v1(73.39,87.56) ; v1(79.43,82.43) 79.8,82.8 80.36,82.8 C2001.2 ; v1(204.71,194.74) 203.81,194.74 202.56,195.98 v2(202.56,207.66) 202.56,209.68 205.36,212.47 v2(208.02,212.47) v2(209.51,212.47) v2(211.1,212.47) v2(212.52,212.47) 213.87,212.47 v1(214.5,211.84) ; v1(67.89,74.43) 67.89,74.4 68.08,74.22 C1998.2
  vias: v1(6.09,79.51) v1(6.82,79.51) v1(165.48,138.68) v1(166.37,138.68) v1(169.04,150.69) v1(169.13,151.97) v1(170.41,151.99) v1(170.37,150.69) v1(171.64,150.69) v1(171.68,151.99) v1(179.25,140.6) v1(179.96,140.56) v1(180.62,142.62) v1(182.43,142.77) v1(183.18,140.63) v1(183.51,103.5) v1(184.28,103.5) v1(189.35,129.32) v1(189.79,112.91) v1(189.79,112.19) v1(190.08,129.32) v1(190.46,131.08) v1(190.55,112.91) v1(190.55,112.19) v1(190.82,137.87) v1(191.25,131.08) v1(191.39,137.41) v1(191.59,134.04) v1(192.3,134.06) v1(204.71,195.63) v1(205.43,200) v1(205.44,199.15) v1(205.44,198.26) v1(205.44,197.39) v1(205.44,196.5) v1(205.45,201.67) v1(205.45,200.83) v1(205.59,195.64) v1(205.58,194.75) v1(237.83,121.32) v1(238.6,121.31) v1(239.31,121.28) v1(239.61,116.1) v1(240.37,116.1)
P1V8_DDR_AVDD: length 12.8
  TOP w0.381: U1.AG28 v4(204.86,128.5) ; U1.AG17 v4(216.86,128.5) ; U1.AB11 v4(222.86,123.5) ; U1.AG21 v4(211.86,128.5) ; U1.AG26 v4(206.86,128.5) ; U1.AF28 v4(204.86,127.5) ; U1.AF21 v4(211.86,127.5) ; U1.AE11 v4(222.86,126.5) ; U1.AF11 v4(222.86,127.5)
  BOTTOM w0.381: v4(216.86,128.5) U1.AG17 C12.1 ; v4(204.86,128.5) 204.44,128.91 C13.1 ; v4(211.86,128.5) 212.28,128.08 C33.1 ; C16.1 U1.AE11 v4(222.86,126.5) ; v4(222.86,127.5) 223.28,127.08 C18.1 ; v4(211.86,127.5) U1.AF21 C17.1 ; v4(204.86,127.5) 205.28,127.08 C46.1 ; C15.1 206.44,128.91 v4(206.86,128.5) ; v4(222.86,123.5) 222.44,123.08 C14.1
  vias: v1(182.62,136.58) v1(182.66,135.27)
P1V8_EN: length 248.7
  TOP w0.381: PR36.2 v1(27.48,161.35)
  T03 w0.381: v1(38.79,192.14) 45.38,192.14 46.45,193.22 47.34,193.22 49.06,194.94 50.79,194.94 54.23,198.38 54.23,200.28 57.23,203.28 57.23,204.35 58.62,205.74 62.38,205.74 68.84,212.2 68.84,212.2 69.24,212.6 76.15,212.6 76.79,211.96 80.39,211.96 81.15,212.72 142.49,212.72 152.53,202.69 180.47,202.69 190.35,212.58 v1(216.15,212.58)
  T14 w0.381: v1(27.48,161.35) 25.98,162.84 25.98,179.1 31.56,184.67 31.56,187.5 34.3,190.25 38,190.25 38.79,191.05 v1(38.79,192.14)
  BOTTOM w0.381: v1(216.15,212.58) 216.85,212.58 218.44,210.99 218.44,206.88 216.79,205.23 216.79,203.26 216.41,202.88 PR105.1
P1V8_EN_R: length 6.1
  TOP w0.254: v1(213.16,207.44) 213.16,207.44 PU3.7
  BOTTOM w0.381: v1(213.16,207.44) 213.16,206.57 214.19,205.55 PC70.1 PR105.2
P1V8_FB_IN: length 4.3
  TOP w0.381: PR107.2 213.54,209.61 PC78.1 PR110.1 v1(214.44,210.14)
  BOTTOM w0.381: PR400.1 214.81,209.77 v1(214.44,210.14)
P1V8_FB_IN_R: length 2.8
  BOTTOM w0.381: v2(214.44,207.85) 213.99,208.3 PR400.2 PQ19.3
P1V8_MARGIN_HI: length 5
  TOP w0.381: PR399.1 PC367.1 PR403.1 PQ20.1 206.17,213.11 206.56,213.49 207.13,213.49 v1(207.14,213.49)
P1V8_MARGIN_LO: length 5.2
  BOTTOM w0.14: PQ19.1 209.67,207.39 v2(208.66,207.39) 208.35,207.7 PR402.1 PC366.1 PR401.1
P1V8_PG: length 153
  TOP w0.381: PU3.4 215.55,203.79 216.18,203.15 PR111.1 PR109.2 PC79.1 v1(218.31,201.28)
  T05 w0.381: v1(300.35,135.74) 299.43,135.74 297.33,133.64 297.33,131.95 291.87,126.49 284.27,126.49 283.58,125.8 283.58,125.11 282.75,124.27 278.44,124.27 276.94,125.78 276.94,141.66 266.66,151.94 266.66,161.44 266.67,161.45 266.67,175.92 252.2,190.4 239.1,190.4 236.04,193.45 222.18,193.45 218.31,197.31 v1(218.31,201.28)
  BOTTOM w0.381: v1(300.35,135.74) 300.66,135.44 PR31.1
P1V8_SS: length 3.6
  TOP w0.381: v1(217.42,207.49) 217.42,207.14 216.68,206.39 PC76.1 215.66,206.39 215.01,206.39 215.01,206.39 PU3.5
P1V8_SW: length 7.3
  TOP w0.381: 212.98,204.96 213.16,204.78 PU3.2
  TOP w0.508: PL4.1 210.44,205.88 PC69.1
  BOTTOM w0.381: PR106.1 211.07,205.22 v1(211.45,204.83)
P1V8_VBST: length 3.6
  TOP w0.508: PR104.1 211.96,209.76 211.96,207.64 212.51,207.09 PU3.8
P1V8_VFB: length 21.6
  TOP w0.381: PR398.1 214.76,212.96 215.44,212.28 PR113.1 PR112.1 215.44,209.23 215.63,209.04 v1(215.63,208.62) PR110.2 PC78.2 213.36,208.16 213.81,207.71 PU3.6
  BOTTOM w0.381: PQ19.2 211.41,210.02 212.47,211.07 215.34,211.07 v2(215.8,210.62) 215.8,208.79 v1(215.63,208.62)
P1V8_VFB_R: length 2
  TOP w0.381: PQ20.3 209.76,212.96 PR398.2
P1V8_VIN:
  vias: v1(214.17,198.43) v1(214.99,201.55) v1(214.98,198.43) v1(215.49,200.91) v1(215.7,198.89) v2(214.29,197.31) v2(215.27,196.4) v2(215.78,197.65)
P1V25: length 246.3
  TOP w0.381: v1(118.34,182.81) 118.59,183.06 R1052.2 ; PR243.1 284.12,125.18 v1(284.48,125.53)
  T07 w0.381: v1(118.34,182.81) 118.85,182.81 120.45,181.21 131.55,181.21 133.86,183.51 143.51,183.51 144.4,182.63 152.78,182.63 154.18,184.02 165.23,184.02 165.96,184.75 173.26,184.75 173.68,184.33 256.49,184.33 261.09,179.73 261.09,167.23 267.1,161.22 267.1,145.8 272.49,140.41 272.49,116.59
  BOTTOM w0.381: v1(284.48,125.53) 285.64,126.7 295.32,126.7 296.57,125.45 296.57,113.69 294.94,112.06 v1(293.51,112.06)
  vias: v1(251.97,82.68) v1(252.35,83.44) v1(252.73,82.68) v1(253.11,83.44) v1(264.41,111.12) v1(264.41,110.36) v1(265.3,111.12) v1(265.3,110.36) v1(286.93,110.64) v1(288.11,110.64) v1(289.64,110.64) v1(290.53,110.64) v1(291.8,110.64) v1(292.68,110.64) v1(293.51,111.04) v2(229.24,85.09) v2(229.24,83.82) v2(230.5,85.09) v2(230.5,83.82) v2(231.78,85.09) v2(231.78,83.82)
P1V25_AGND: length 9.7
  TOP w0.356: 286.97,121.43 PU11.7
  BOTTOM w0.381: PQ15.2 285.06,124.31 v1(286.21,123.16) 286.23,123.13 PR250.2 286.23,120.95 PR248.2 286.74,120.93 287.99,119.68 PR251.1
P1V25_BST: length 4.1
  TOP w0.254: PR241.1 283.87,121.01 285.6,119.27 PU11.10
P1V25_CS: length 3.9
  TOP w0.254: PU11.4 288.46,119.77 288.49,119.8 288.5,119.8 288.66,119.97 288.66,119.97 289,120.31 v1(289,120.41)
  BOTTOM w0.381: v1(289,120.41) 288.55,120.41 PR250.1
P1V25_EN: length 19.6
  TOP w0.381: PR34.2 277.21,118.97 v1(278.7,120.45) ; PR239.1 v1(292.84,122.27)
  T03 w0.381: v1(292.84,122.27) 288.12,122.27 285.33,119.48 279.67,119.48 v1(278.7,120.45)
P1V25_EN_R: length 5
  TOP w0.254: PR239.2 PC223.1 289.08,121.91 288.08,120.91 PU11.5
  TOP w0.381: PR239.2 v1(290.5,121.11)
P1V25_FB: length 10.3
  TOP w0.254: PU11.6 287.47,120.63 287.47,121.07 287.88,121.48 PR249.1 PC234.2 PR246.2 PR255.1
  TOP w0.356: PR255.1 290.01,125.56 v1(290.1,125.65)
  BOTTOM w0.381: v1(290.1,125.65) PQ14.2 287.39,125.65 v2(287.23,125.49)
P1V25_FB_IN: length 11
  TOP w0.254: PR243.2 286.27,124.48 v1(286.33,124.54) PR246.1 PC234.1
  BOTTOM w0.356: v1(286.33,124.54) 287.27,123.6 287.27,123.19 288.29,122.17 291.8,122.17 292.94,123.31 PR252.1
P1V25_FB_IN_R: length 4.4
  BOTTOM w0.356: PR252.2 291.52,124.19 PQ14.3
  BOTTOM w0.381: PR252.2 293.49,124.19 294.01,123.67 v2(294.01,122.66)
P1V25_FB_R: length 8.8
  TOP w0.381: PR255.2 v1(286.28,125.56)
  T03 w0.381: v1(286.28,125.56) 285.49,125.56 283.22,123.28 v1(283.11,123.28)
  BOTTOM w0.381: v1(283.11,123.28) 282.39,123.28 281.75,122.64 PQ15.3 v2(281.75,120.4)
P1V25_MARGIN_HI: length 6.3
  TOP w0.14: PR256.1 PR257.1 PC237.1 280.57,124.07 v1(279.89,123.39)
  BOTTOM w0.14: v1(279.89,123.39) 280.76,124.26 PQ15.1 280.76,125.62 v2(280.34,126.03)
P1V25_MARGIN_LO: length 5.9
  TOP w0.14: v1(290.65,123.54) PR254.1 PC236.1 PR253.1
  BOTTOM w0.14: PQ14.1 290.52,123.67 v1(290.65,123.54) 291,123.19 v2(291.59,123.19)
P1V25_MODE: length 4.3
  TOP w0.254: v1(286.37,117.11) 286.37,118.27 PU11.12
  BOTTOM w0.381: v1(286.37,117.11) 286.11,117.38 PR245.2 286.11,118.85 v2(286.26,119) PR248.1
P1V25_PG: length 16.6
  TOP w0.254: PU11.9 286.47,119.77 285.97,119.77 v1(285.17,120.57)
  TOP w0.381: v1(275.54,124.56) 275.53,124.56 275.49,124.52 PR334.2
  T03 w0.381: v1(285.17,120.57) 284.76,120.17 280.52,120.17 276.13,124.56 v1(275.54,124.56)
  BOTTOM w0.381: PR247.2 285.17,121.63 v1(285.17,120.57) 285.17,119.91 PR240.2
P1V25_REF: length 2.7
  TOP w0.254: PC235.1 285.29,122.1 286.37,121.02 PU11.8
P1V25_SW: length 7.8
  TOP w0.356: PU11.2 PU11.11 286.47,118.77 285.22,118.77
  TOP w0.381: PL10.1 279.86,120.92 PC225.2
  BOTTOM w0.381: v1(281.83,117.65) PR242.1
P1V25_VCC: length 7.7
  TOP w0.254: v1(285.57,116.99) 285.57,116.35 286.06,115.87 PC224.1 286.66,116.43 286.97,116.74 286.97,117.92 PU11.13
  BOTTOM w0.381: v1(285.57,116.99) 285.29,117.26 PR245.1 285.29,118.51 PR240.1 284.22,118.86 v2(283.72,118.36)
P1V25_VIN: length 1.5
  TOP w0.381: PU11.3 289.13,119.27
  vias: v1(291.41,120.29) v1(291.9,121.08) v1(292.3,120.29) v1(293.15,121.11) v1(293.19,120.29) v2(294.23,120.78)
P1V26_BMC: length 29.3
  TOP w0.381: U154.R17 v4(60.13,108.12) ; U154.F14 v4(68.13,110.53) ; U154.K6 v4(64.93,117.73) ; U154.R6 v4(60.13,117.73) ; U154.L17 v4(64.13,108.12) ; v4(58.53,111.33) U154.U13 v4(58.53,112.13) U154.U12 ; U154.K17 v4(64.93,108.12) ; PU21.5 78.72,138.1 PR416.2 75.27,137.87 73.19,139.94 ; U154.L6 v4(64.13,117.73) ; U154.P17 v4(60.93,108.12) ; U154.P6 v4(60.93,117.73) ; U154.F15 v4(68.13,109.72)
  TOP w0.508: v1(63,125.09) R12731.2 PC344.1
  BOTTOM w0.381: v4(58.53,111.33) 59.05,111.33 59.43,111.71 PC341.1 59.26,112.19 58.59,112.19 v4(58.53,112.13) ; v4(68.13,110.53) 68.09,110.56 C2293.2 ; v1(37.06,108.72) C2294.1 37.49,107.93 37.76,108.2 L200.1 ; C2321.1 63.77,117.37 v4(64.13,117.73) ; C2285.1 60.93,108.35 v4(60.93,108.12) ; v4(60.13,117.73) 59.8,117.4 C2295.1 ; C2287.2 60.74,117.54 v4(60.93,117.73) ; v4(64.93,108.12) 64.62,108.43 C2296.1 ; C2286.2 67.99,109.59 v4(68.13,109.72) ; L201.1 37.57,103.91 37.43,104.05 C2307.1 v1(36.94,103.3)
  vias: v1(71.63,140.45) v1(71.86,145.49) v1(71.86,144.47) v1(71.86,143.33) v1(71.86,142.31) v1(71.88,141.49) v1(72.49,140.45) v2(70.19,147.99) v2(70.19,146.72) v2(70.19,145.45) v2(70.19,144.18) v2(70.61,142.72) v2(71.46,147.99) v2(71.46,146.72) v2(72.87,147.58)
P1V26_BMC_EN: length 4.9
  TOP w0.381: PU21.8 v1(81.57,139.51) C2332.1 R12436.2
  BOTTOM w0.381: v1(81.57,139.51) 81.21,139.87 PR341.1
P1V26_BMC_FB: length 3.2
  TOP w0.381: PR370.1 PR369.2 v1(80.52,138.17) 80.02,138.68 PU21.7
P1V26_BMC_FB_IN: length 2.4
  TOP w0.381: v1(77.34,136.4) 77.44,136.5 PR416.1 78.49,136.5 PR370.2
P1V26_BMC_PG: length 45.4
  TOP w0.14: U160.3 v1(47.89,132.45) ; PU21.1 81.44,142.11 v1(81.44,142.11) PR371.2
  T07 w0.117: v1(81.44,142.11) 77.12,137.79 73.03,137.79 69.85,140.97 64.01,140.97 59.31,136.27 57.78,136.27 56.93,135.42 51.99,135.42 49.02,132.45 v1(47.89,132.45)
  BOTTOM w0.14: PR366.2 82.13,142.32 81.91,142.11 v1(81.44,142.11)
P1V26_BMC_VIN: length 3.4
  TOP w0.381: PU21.2 80.02,143.22 80.39,143.6 v1(80.99,143.6)
  BOTTOM w0.381: PR366.1 81.04,143.65 v1(80.99,143.6)
P1V538_BMC: length 55.9
  TOP w0.381: U155.H2 v4(39.85,116.91) ; U155.H9 46.99,117.31 v4(47.26,117.04) ; U155.R1 v4(39.05,111.31) ; PC334.1 57.21,135.89 57.59,135.51 60.23,135.51 60.83,136.11 60.83,137.65 61.18,137.99 PR417.2 62.13,137.99 62.69,138.55 PU20.5 ; U155.A8 v4(44.65,122.51) ; U155.C1 v4(39.05,120.91) ; U154.U14 v4(58.53,110.53) ; U154.U10 v4(58.53,114.53) ; U155.K2 v4(39.85,115.31) ; U155.A1 v4(39.05,122.51) ; U155.R9 v4(45.45,111.31) ; U155.B2 v4(39.85,121.71) ; U154.U11 v4(58.53,113.73) ; U155.N1 v4(39.05,112.91) ; U155.E9 v4(45.45,119.31) ; U154.U15 v4(58.53,109.72) ; U155.F1 v4(39.05,118.51) ; U155.K8 v4(44.65,115.31) ; U155.D9 v4(45.45,120.11) ; U155.G7 v4(43.85,117.71) ; U155.C9 v4(45.45,120.91) ; U155.D2 v4(39.85,120.11) ; U155.N9 v4(45.45,112.91)
  BOTTOM w0.381: v4(44.65,115.31) 45.03,115.69 C2248.1 ; C2252.2 38.95,121.01 v4(39.05,120.91) ; v4(44.65,122.51) 45.03,122.89 C2249.1 ; C2246.1 58.75,114.75 v4(58.53,114.53) ; v4(39.85,120.11) 40.57,120.84 C2256.1 ; R12732.2 61.5,123.98 v1(61.5,124.34) 61.62,124.46 62.16,124.46 C2377.1 ; C2303.1 38.64,110.91 v4(39.05,111.31) ; C2305.1 39.56,116.63 v4(39.85,116.91) ; v4(58.53,110.53) 58.62,110.43 C2251.1 ; C2169.1 R12313.2 48.88,112.37 v2(47.5,110.98) C2257.1 45.78,110.98 v4(45.45,111.31) ; v4(39.05,112.91) 38.82,112.68 C2304.1 ; C2260.2 58.76,109.49 v4(58.53,109.72) ; v4(45.45,119.31) 45.57,119.2 C2259.1 ; R12325.1 38.49,109.6 v1(37.34,109.6) ; PC330.1 49.15,117.43 v1(49.19,117.39) ; C2262.2 45.55,120.21 v4(45.45,120.11) ; v4(43.85,117.71) 43.34,118.22 C2306.2 ; v1(36.85,115.3) 36.3,115.84 R12306.2 ; C2263.2 45.73,121.19 v4(45.45,120.91) ; C2247.1 58.54,113.74 v4(58.53,113.73) ; C2250.2 39.13,114.59 v4(39.85,115.31) ; v4(45.45,112.91) 45.48,112.89 C2258.1 ; C2254.2 38.94,118.4 v4(39.05,118.51) ; v4(39.05,122.51) 38.77,122.79 C2253.2 ; v4(47.26,117.04) 47.04,117.26 C2264.2 ; v1(37.56,121.94) 36.73,121.94 PC331.1 36.43,122.38 36.81,122.76 v1(37.58,122.76) ; v4(39.85,121.71) 40,121.86 C2261.1
  vias: v1(37.44,110.35) v1(37.47,111.06) v1(55.2,141.09) v1(55.2,139.95) v1(56.09,137.41) v1(56.09,136.39) v2(54.89,136.79) v2(55.03,142.43) v2(55.44,138.99) v2(56.93,140.27) v2(56.93,139)
P1V538_BMC_EN: length 5.6
  TOP w0.381: v1(65.62,139.51) PU20.8
  BOTTOM w0.381: PR340.1 R12435.2 C2331.1 66.23,138.9 v1(65.62,139.51)
P1V538_BMC_FB: length 2.9
  TOP w0.381: PR363.1 PR362.2 63.99,137.72 63.99,138.12 63.99,138.12 63.99,139.51 PU20.7
P1V538_BMC_FB_IN: length 1.2
  TOP w0.381: PR363.2 61.95,136.62 61.95,136.62 PR417.1
P1V538_BMC_PG: length 25.3
  TOP w0.14: PR364.2 v1(65.41,142.11) 65.41,142.11 PU20.1
  TOP w0.254: v1(84.63,138.73) 84.57,138.73 R12436.1
  T03 w0.117: v1(65.41,142.11) 70.23,137.29 83.19,137.29 v1(84.63,138.73)
  BOTTOM w0.14: PR359.2 65.82,142.51 v1(65.41,142.11)
P1V538_BMC_VIN: length 3.6
  TOP w0.381: v1(64.97,143.6) 64.37,143.6 63.99,143.22 PU20.2
  BOTTOM w0.381: v1(64.97,143.6) 65.24,143.33 PR359.1
P2V5: length 243.7
  TOP w0.381: U6.R9 v4(262.1,125.86) ; U5.R9 v4(226.18,166.28) 225.88,166.28 ; 238.05,166.28 v4(238.35,166.28) U4.R9 ; v1(121.54,179.96) 121.13,180.37 R1059.2 ; U2.B1 v4(206.46,155.07) ; U5.B1 v4(233.38,155.07) ; U4.B1 v4(245.56,155.07) ; v4(262.1,137.53) U7.R9 ; v1(232.71,211.43) 232.4,211.74 PR260.1 ; U7.B1 v4(250.9,130.33) ; U3.B1 v4(218.63,155.07) ; 211.18,166.28 v4(211.43,166.28) U3.R9 ; U2.R9 v4(199.26,166.28) ; U6.B1 v4(250.9,118.66)
  TOP w0.762: 207.9,152.3 207.9,162.99 211.18,166.28 ; 225.88,166.28 223.65,164.04 223.65,152.11 ; 238.05,166.28 237.02,165.24 237.02,155.42 237.37,155.07 237.37,152.28
  T14 w0.381: v1(223.11,194.5) 218.85,190.25 166.96,190.25 162.93,186.21 150.4,186.21 150.02,186.59 143.08,186.59 141.13,188.54 127.93,188.54 126.66,189.81 122.9,189.81 119.21,186.12 119.21,182.29 119.72,181.78 v1(121.54,179.96)
  BOTTOM w0.381: C7.2 246.39,154.69 C6.2 245.92,154.7 v4(245.56,155.07) ; C30.2 210.87,166.84 v4(211.43,166.28) ; v4(226.18,166.28) 225.94,166.52 C42.2 ; C28.2 207.2,154.59 C26.2 206.83,154.7 v4(206.46,155.07) ; C39.2 238.29,166.21 v4(238.35,166.28) ; C8.2 262.67,138.09 v4(262.1,137.53) ; v4(262.1,125.86) 262.8,126.56 C9.2 ; C27.2 198.02,167.52 v4(199.26,166.28) ; v4(250.9,130.33) 250.53,129.96 C43.2 ; v4(218.63,155.07) 219,154.7 C29.2 219.47,154.69 C25.2 ; v4(233.38,155.07) 233.75,154.7 C40.2 234.13,154.59 C41.2 ; v1(223.11,194.5) 220.9,194.5 v2(219.67,195.73) 219.46,195.94 219.46,211.23 221.14,212.91 231.23,212.91 v1(232.71,211.43) ; C4.2 250.42,117.92 C5.2 250.53,118.29 v4(250.9,118.66)
  BOTTOM w0.508: 262.67,138.96 C8.2
  BOTTOM w0.762: 262.67,138.96 262.67,140.68 261.87,141.48 248.03,141.48
  vias: v1(195.63,165.66) v1(195.66,166.52) v1(195.78,167.44) v1(196.55,165.53) v1(196.62,167.28) v1(196.75,166.45) v1(223.12,195.34) v1(223.46,200.28) v1(223.46,199.43) v1(223.47,198.51) v1(223.47,197.58) v1(223.47,196.56) v1(223.84,201.12) v1(223.98,195.33) v1(223.97,194.49) v1(224.75,201.07) v2(196.94,150.61) v2(196.94,149.34) v2(198.21,150.61) v2(198.21,149.34) v2(199.48,150.61) v2(199.48,149.34) v2(200.75,150.61) v2(200.75,149.34) v2(202.02,150.61) v2(202.02,149.34) v2(203.29,150.61) v2(203.29,149.34) v2(221.97,200.87) v2(221.97,199.6) v2(221.97,198.33) v2(222.01,197) v2(222.01,195.73)
P2V5_EN: length 6.3
  TOP w0.254: v1(231.26,207.19) 231.26,207.19 PU12.7
  BOTTOM w0.381: PR12.1 230.99,211.22 231.52,210.69 PC243.1 231.52,207.45 v1(231.26,207.19)
P2V5_MARGIN_HI: length 8.2
  TOP w0.14: PR324.1 PC309.1 PR321.1 224.93,211.78 224.29,211.14 222.01,211.14 221.72,210.85 PQ17.1 v1(220.34,210.08)
P2V5_MARGIN_LO: length 4.6
  BOTTOM w0.14: v2(228.36,207.03) PR323.1 PC310.1 PR322.1 PQ16.1
P2V5_PG: length 112.3
  TOP w0.381: PU12.4 PR264.1 PR262.2 PC252.1 235.88,192.29 v1(235.89,192.28) ; PR332.1 v1(275.38,120.45)
  T05 w0.381: v1(235.89,192.28) 238.58,189.59 251.87,189.59 260.4,181.05 260.4,181.04 266.04,175.4 266.04,161.72 266.03,161.71 266.03,151.67 276.31,141.4 276.31,125.51 276.61,125.21 276.61,121.68 v1(275.38,120.45)
