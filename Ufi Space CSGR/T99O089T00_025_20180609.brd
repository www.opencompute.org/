# Allegro board T99O089T00_025_20180609.brd (continued)
## Nets (continued)
GND: BAT1.P2(CATHODE) C3.2 C4.1 C5.1 C6.1 C7.1 C8.1 C9.1 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.1 C26.1 C27.1 C28.1 C29.1 C30.1 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.1 C39.1 C40.1 C41.1 C42.1 C43.1 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.1 C55.2 C56.2 C57.1 C58.2 C59.1 C60.2 C61.2 C62.1 C63.2 C64.1 C65.2 C66.2 C67.1 C68.2 C69.1 C70.2 C71.2 C72.1 C73.2 C74.2 C75.2 C76.1 C77.2 C78.2 C79.1 C80.2 C81.1 C82.2 C83.2 C84.1 C85.2 C86.1 C87.2 C88.2 C89.1 C90.2 C91.1 C92.2 C93.2 C94.1 C95.2 C96.2 C97.2 C98.1 C99.2 C100.2 C101.1 C102.2 C103.1 C104.2 C105.2 C106.1 C107.2 C108.1 C109.2 C110.2 C111.1 C112.2 C113.1 C114.2 C115.2 C116.1 C117.2 C181.2 C182.1 C183.2 C184.2 C185.1 C186.2 C187.1 C188.2 C189.2 C190.1 C191.2 C192.1 C193.2 C194.2 C195.1 C196.2 C197.1 C198.2 C199.2 C200.1 C201.2 C202.2 C203.1 C204.2 C205.2 C206.1 C207.2 C208.1 C209.2 C210.2 C211.1 C212.2 C213.1 C214.2 C215.2 C216.1 C217.2 C218.1 C219.2 C220.2 C221.1 C222.2 C223.2 C224.1 C225.2 C226.2 C227.1 C228.2 C229.1 C230.2 C231.2 C232.1 C233.2 C234.1 C235.2 C236.2 C237.1 C238.2 C239.1 C240.2 C241.2 C242.1 C243.2 C244.2 C245.2 C246.1 C247.2 C248.2 C249.1 C250.1 C251.2 C252.1 C253.2 C254.1 C255.2 C256.2 C257.1 C258.1 C259.2 C260.1 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.1 C269.2 C270.2 C271.1 C272.2 C273.2 C274.2 C275.2 C276.2 C277.1 C278.1 C279.2 C280.1 C281.2 C282.2 C283.1 C284.2 C285.1 C286.2 C287.2 C288.1 C289.2 C290.2 C291.2 C292.1 C293.2 C294.2 C295.1 C296.2 C297.1 C298.2 C299.2 C300.1 C301.2 C302.1 C303.2 C304.2 C305.1 C306.2 C307.1 C308.2 C309.2 C310.1 C311.2 C312.2 C313.1 C314.2 C315.2 C316.1 C317.2 C318.1 C319.2 C320.2 C321.1 C322.2 C323.2 C324.2 C325.2 C326.2 C327.1 C328.2 C329.2 C330.1 C331.2 C332.1 C333.2 C334.2 C335.1 C336.2 C337.1 C338.2 C339.2 C340.1 C341.2 C342.1 C343.2 C344.2 C345.1 C346.2 C347.2 C348.2 C349.2 C350.1 C351.2 C352.2 C353.1 C354.2 C355.1 C356.2 C357.2 C358.1 C359.2 C360.1 C361.2 C362.2 C363.1 C364.2 C365.1 C366.2 C367.2 C368.1 C369.2 C370.2 C371.2 C372.1 C373.2 C374.2 C375.1 C376.2 C377.1 C378.2 C379.2 C380.1 C381.2 C382.1 C383.2 C384.2 C385.1 C386.2 C387.1 C388.2 C389.2 C390.2 C391.1 C392.2 C393.2 C394.1 C395.2 C396.1 C397.2 C398.2 C399.1 C400.2 C401.2 C402.2 C403.2 C404.1 C405.2 C406.2 C407.2 C408.2 C409.1 C410.2 C411.2 C412.1 C413.2 C414.1 C415.2 C416.2 C417.1 C418.2 C419.1 C420.2 C421.2 C422.2 C423.2 C424.2 C425.1 C426.2 C427.2 C428.1 C429.2 C430.2 C431.2 C432.1 C433.2 C434.1 C435.2 C436.1 C437.2 C438.1 C439.1 C440.2 C441.2 C442.1 C443.2 C444.2 C445.1 C446.1 C447.2 C448.2 C449.2 C450.2 C451.2 C452.2 C453.2 C454.1 C455.2 C456.2 C457.1 C458.2 C459.1 C460.2 C461.2 C462.1 C463.2 C464.1 C465.2 C466.1 C467.2 C468.1 C469.1 C470.1 C471.2 C472.1 C473.1 C474.2 C475.2 C476.1 C477.2 C478.2 C479.2 C480.1 C481.2 C482.1 C483.1 C484.2 C485.2 C486.1 C487.2 C488.2 C489.2 C490.2 C491.2 C492.2 C493.1 C494.2 C495.2 C496.1 C497.2 C498.1 C499.2 C500.2 C501.1 C502.2 C503.1 C504.2 C505.2 C506.1 C507.2 C508.2 C509.1 C510.2 C511.2 C512.2 C513.2 C514.2 C515.1 C516.2 C517.2 C518.1 C519.2 C520.1 C521.2 C522.2 C523.1 C524.2 C525.1 C526.2 C527.1 C528.2 C529.2 C530.2 C531.2 C532.2 C533.1 C534.2 C535.2 C536.1 C537.2 C538.1 C539.2 C540.2 C541.1 C542.2 C543.1 C544.2 C545.1 C546.2 C547.2 C548.2 C549.2 C550.2 C551.1 C552.2 C553.2 C554.1 C555.2 C556.1 C557.2 C558.2 C559.1 C560.2 C561.1 C562.2 C563.2 C564.2 C565.2 C566.1 C567.2 C568.2 C569.1 C570.2 C571.1 C572.2 C573.2 C574.1 C575.2 C576.1 C577.2 C578.1 C579.2 C580.2 C581.2 C582.1 C583.2 C584.2 C585.1 C586.2 C587.1 C588.2 C589.2 C590.1 C591.2 C592.1 C593.2 C594.1 C595.2 C596.2 C597.2 C598.1 C599.2 C600.2 C601.2 C602.1 C603.2 C604.2 C605.2 C606.1 C607.2 C608.2 C609.2 C610.1 C611.2 C612.2 C613.2 C614.1 C615.2 C616.2 C617.2 C627.2 C628.2 C632.1 C633.2 C634.1 C635.2 C636.1 C637.2 C651.2 C652.1 C653.2 C654.2 C655.1 C656.2 C657.1 C658.2 C659.2 C660.1 C661.2 C665.2 C666.1 C667.2 C668.2 C669.1 C670.2 C671.1 C672.2 C673.2 C674.1 C675.2 C686.2 C687.1 C688.2 C689.2 C690.1 C691.2 C692.1 C693.2 C694.2 C695.1 C696.2 C697.1 C698.2 C699.1 C700.2 C711.1 C712.2 C713.2 C714.2 C715.2 C716.1 C724.1 C735.2 C736.2 C737.1 C738.1 C739.2 C740.1 C741.1 C742.2 C743.2 C744.1 C745.2 C746.1 C747.1 C748.2 C749.1 C750.1 C751.2 C753.1 C755.2 C756.2 C757.2 C758.2 C759.2 C760.2 C761.2 C762.2 C771.1 C772.1 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C783.2 C784.2 C785.2 C786.2 C787.2 C788.2 C789.1 C790.1 C791.2 C792.2 C793.2 C794.2 C795.2 C796.2 C797.2 C798.2 C799.2 C800.2 C801.2 C802.2 C803.2 C804.2 C805.2 C806.2 C807.1 C809.2 C810.2 C811.2 C812.2 C813.2 C814.2 C815.2 C816.2 C825.1 C826.2 C827.2 C828.2 C829.2 C830.2 C831.2 C832.2 C833.2 C834.1 C835.2 C836.2 C837.2 C838.2 C839.2 C840.2 C841.2 C842.2 C843.1 C844.1 C845.2 C846.2 C847.2 C848.2 C849.2 C850.2 C851.2 C852.2 C853.1 C856.2 C857.2 C858.2 C859.2 C860.1 C861.2 C862.1 C863.1 C864.1 C865.1 C866.1 C867.2 C868.1 C869.2 C870.1 C871.2 C872.1 C873.1 C874.2 C875.2 C876.2 C877.2 C878.2 C879.1 C880.2 C881.1 C882.1 C883.1 C884.2 C885.2 C886.2 C887.2 C888.2 C889.2 C890.1 C891.2 C892.1 C893.1 C894.2 C895.1 C896.1 C897.1 C898.1 C899.2 C900.2 C943.2 C944.2 C945.2 C946.2 C947.2 C948.2 C949.2 C950.1 C951.2 C952.1 C953.1 C954.1 C955.1 C956.2 C957.2 C958.1 C959.2 C960.1 C961.2 C962.1 C963.1 C964.2 C965.2 C966.2 C967.2 C968.2 C969.2 C970.2 C971.1 C972.2 C973.2 C974.2 C975.2 C976.2 C977.1 C978.2 C979.2 C980.1 C981.2 C982.2 C983.2 C984.2 C985.1 C986.1 C987.2 C988.1 C989.1 C990.2 C991.2 C992.2 C993.2 C994.2 C995.2 C996.2 C997.2 C998.2 C999.2 C1000.2 C1001.2 C1002.2 C1003.2 C1004.2 C1005.2 C1006.2 C1007.2 C1008.2 C1009.2 C1010.2 C1011.2 C1012.2 C1013.2 C1014.2 C1015.2 C1016.2 C1017.2 C1018.2 C1019.2 C1020.2 C1021.2 C1022.2 C1023.2 C1024.2 C1025.2 C1026.2 C1027.2 C1028.2 C1029.2 C1030.2 C1031.2 C1032.2 C1033.2 C1034.2 C1035.2 C1036.2 C1037.2 C1038.2 C1039.2 C1040.2 C1041.2 C1042.2 C1043.2 C1044.2 C1045.2 C1046.2 C1047.2 C1048.2 C1049.2 C1050.2 C1051.2 C1052.2 C1053.2 C1054.2 C1055.2 C1056.2 C1057.2 C1058.2 C1059.2 C1060.2 C1061.2 C1062.2 C1063.2 C1064.2 C1065.2 C1066.2 C1067.2 C1068.2 C1069.2 C1070.2 C1071.2 C1072.2 C1073.2 C1074.2 C1075.2 C1076.2 C1077.2 C1078.2 C1079.2 C1080.2 C1081.2 C1082.2 C1083.2 C1084.2 C1085.2 C1086.2 C1087.2 C1088.2 C1089.2 C1090.2 C1091.2 C1092.2 C1093.2 C1094.2 C1095.2 C1096.2 C1097.2 C1098.2 C1099.2 C1100.2 C1101.2 C1102.2 C1103.2 C1104.2 C1105.2 C1106.2 C1107.2 C1108.2 C1109.2 C1110.2 C1111.2 C1184.2 C1185.2 C1186.2 C1187.2 C1188.2 C1189.2 C1190.2 C1191.2 C1192.2 C1193.2 C1194.2 C1195.2 C1196.2 C1197.2 C1198.2 C1199.2 C1200.2 C1201.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.2 C1209.2 C1210.2 C1211.2 C1212.2 C1213.2 C1214.2 C1215.2 C1216.2 C1217.2 C1218.2 C1219.2 C1220.2 C1221.2 C1222.2 C1223.2 C1224.2 C1225.2 C1226.2 C1227.2 C1228.2 C1229.2 C1230.2 C1231.2 C1232.2 C1233.2 C1234.2 C1235.2 C1236.2 C1237.2 C1238.2 C1239.2 C1240.2 C1241.2 C1242.2 C1243.2 C1244.2 C1245.2 C1246.2 C1247.2 C1248.2 C1249.2 C1250.2 C1251.2 C1252.2 C1253.2 C1254.2 C1255.2 C1256.2 C1257.2 C1258.2 C1259.2 C1260.2 C1261.2 C1262.2 C1263.2 C1264.2 C1265.2 C1266.2 C1267.2 C1268.2 C1269.2 C1270.2 C1271.2 C1272.2 C1273.2 C1274.2 C1275.2 C1276.2 C1277.2 C1278.2 C1279.2 C1280.2 C1281.2 C1282.2 C1283.2 C1284.2 C1285.2 C1286.2 C1287.2 C1288.2 C1289.2 C1290.2 C1291.2 C1292.2 C1293.2 C1294.2 C1295.2 C1296.2 C1297.2 C1298.2 C1299.2 C1300.2 C1301.2 C1302.2 C1303.2 C1304.2 C1305.2 C1306.2 C1307.2 C1308.2 C1309.2 C1310.2 C1311.2 C1312.2 C1313.2 C1314.2 C1315.2 C1316.2 C1317.2 C1318.2 C1319.2 C1320.2 C1321.2 C1332.2 C1333.2 C1334.2 C1335.2 C1336.2 C1357.2 C1358.2 C1359.2 C1360.2 C1361.2 C1362.2 C1363.2 C1364.2 C1365.2 C1366.2 C1367.2 C1368.2 C1369.1 C1370.2 C1371.1 C1372.1 C1373.1 C1374.1 C1375.1 C1377.1 C1378.1 C1379.1 C1380.1 C1381.2 C1382.1 C1383.2 C1384.2 C1385.2 C1386.2 C1387.1 C1388.2 C1389.1 C1390.2 C1391.1 C1392.1 C1393.2 C1394.2 C1395.2 C1396.2 C1397.1 C1398.2 C1399.1 C1400.1 C1401.2 C1402.1 C1403.2 C1404.2 C1405.2 C1406.1 C1407.2 C1408.1 C1409.2 C1410.2 C1411.2 C1412.1 C1413.1 C1414.1 C1415.1 C1416.1 C1417.1 C1418.1 C1419.1 C1420.1 C1421.1 C1422.1 C1548.1 C1549.2 C1550.2 C1552.2 C1553.2 C1554.2 C1555.2 C1556.2 C1557.2 C1558.2 C1561.2 C1562.2 C1564.2 C1565.2 C1566.2 C1567.2 C1576.2 C1578.2 C1579.2 C1581.2 C1582.2 C1583.2 C1592.1 C1593.2 C1594.2 C1595.2 C1596.1 C1597.1 C1598.1 C1599.2 C1600.2 C1601.2 C1602.1 C1603.1 C1604.2 C1622.1 C1623.1 C1624.2 C1625.1 C1626.1 C1627.1 C1628.2 C1629.2 C1630.2 C1631.2 C1632.1 C1633.1 C1634.1 C1635.2 C1636.2 C1638.2 C1639.1 C1640.1 C1641.2 C1642.1 C1643.2 C1644.1 C1672.2 C1673.2 C1674.2 C1678.1 C1680.2 C1681.2 C1683.2 C1684.2 C1685.2 C1686.1 C1687.1 C1688.2 C1689.1 C1815.1 C1816.2 C1817.1 C1818.1 C1935.1 C1938.1 C1940.1 C1941.2 C1942.1 C1956.1 C1978.1 C1979.2 C1980.2 C1982.1 C1983.1 C1985.1 C1986.1 C1987.1 C1988.1 C1989.1 C1991.1 C1992.1 C1993.1 C1994.1 C1995.1 C1996.1 C1997.1 C1998.1 C1999.1 C2000.1 C2001.1 C2002.2 C2038.1 C2039.1 C2040.1 C2041.1 C2042.1 C2043.2 C2044.1 C2045.1 C2046.1 C2047.1 C2048.1 C2049.2 C2050.1 C2051.1 C2052.2 C2053.1 C2054.1 C2055.2 C2056.1 C2057.1 C2058.2 C2059.1 C2060.2 C2061.2 C2062.2 C2076.1 C2077.2 C2078.2 C2079.2 C2080.1 C2081.2 C2082.2 C2083.2 C2084.2 C2085.2 C2086.1 C2087.2 C2088.2 C2089.2 C2090.2 C2091.2 C2092.1 C2093.2 C2094.2 C2095.2 C2096.2 C2097.2 C2098.2 C2099.2 C2100.2 C2101.1 C2102.2 C2103.2 C2104.2 C2105.2 C2106.2 C2107.2 C2108.2 C2109.1 C2110.2 C2111.2 C2112.2 C2113.2 C2114.2 C2115.2 C2116.2 C2117.1 C2118.2 C2119.2 C2120.2 C2121.2 C2122.2 C2123.2 C2124.2 C2125.2 C2127.2 C2128.2 C2129.2 C2130.2 C2131.2 C2132.1 C2133.2 C2134.2 C2135.2 C2136.2 C2137.1 C2138.2 C2139.1 C2140.2 C2141.1 C2142.1 C2143.1 C2144.1 C2145.1 C2146.2 C2147.1 C2148.1 C2149.1 C2150.1 C2151.1 C2152.1 C2153.2 C2154.1 C2155.1 C2156.2 C2157.1 C2160.2 C2161.2 C2162.2 C2170.1 C2171.1 C2172.1 C2173.2 C2174.2 C2175.2 C2176.2 C2206.2 C2207.2 C2208.2 C2209.2 C2210.2 C2211.2 C2215.2 C2216.2 C2217.2 C2218.1 C2219.2 C2220.2 C2221.1 C2224.1 C2229.1 C2239.1 C2240.2 C2241.2 C2244.2 C2245.2 C2246.2 C2247.2 C2248.2 C2249.2 C2250.1 C2251.2 C2252.1 C2253.1 C2254.1 C2255.2 C2256.2 C2257.2 C2258.2 C2259.2 C2260.1 C2261.2 C2262.1 C2263.1 C2264.1 C2266.1 C2267.2 C2268.1 C2269.2 C2270.2 C2271.2 C2272.1 C2273.1 C2274.1 C2275.2 C2276.2 C2277.1 C2278.2 C2279.2 C2280.2 C2281.1 C2282.2 C2285.2 C2286.1 C2287.1 C2288.2 C2289.2 C2290.1 C2291.2 C2292.1 C2293.1 C2294.2 C2295.2 C2296.2 C2297.2 C2298.2 C2299.2 C2300.1 C2301.2 C2302.2 C2303.2 C2304.2 C2305.2 C2306.1 C2307.2 C2308.2 C2309.1 C2310.2 C2311.2 C2312.2 C2313.2 C2314.2 C2315.1 C2316.2 C2317.1 C2318.1 C2319.2 C2320.1 C2321.2 C2322.2 C2323.1 C2324.2 C2325.2 C2326.2 C2327.1 C2330.2 C2331.2 C2332.2 C2333.2 C2334.1 C2335.1 C2348.1 C2350.1 C2352.1 C2356.1 C2357.1 C2358.1 C2359.1 C2360.1 C2361.1 C2368.2 C2369.2 C2372.2 C2373.1 C2374.1 C2375.2 C2376.2 C2377.2 C2378.2 C2385.1 C2386.1 C2387.1 C2388.2 C2389.2 C2390.1 C2392.1 C2393.1 C2394.1 C2397.2 C2399.2 C2400.1 C2401.1 C2402.2 C2403.1 C2404.1 C2409.2 C2410.2 C2411.2 C2412.2 C2413.1 C2414.2 C2415.1 C2416.2 C2417.1 C2420.1 C2421.2 C2422.1 C2423.2 C2426.1 C2427.1 C2428.1 C2429.1 C2430.1 C2431.1 C2432.1 C2433.1 C2434.1 C2435.1 C2436.2 C2437.1 C2439.1 C2440.1 C2441.2 C2442.2 C2443.2 C2446.2 C2447.2 C2448.2 C2449.2 C2450.2 C2451.2 C2452.2 C2453.1 C2454.2 C2461.1 C2462.2 C2463.2 CJ8.AL1(AL_TX_GND1) CJ8.AL10(AL_RX_GND1) CJ8.AL11(AL_RX_GND2) CJ8.AL14(AL_RX_GND3) CJ8.AL17(AL_TX_GND2) CJ8.AL20(AL_TX_GND3) CJ8.AT1(AT_TX_GND1) CJ8.AT10(AT_RX_GND1) CJ8.AT11(AT_RX_GND2) CJ8.AT14(AT_RX_GND3) CJ8.AT17(AT_TX_GND2) CJ8.AT20(AT_TX_GND3) CJ8.BL1(BL_TX_GND1) CJ8.BL10(BL_RX_GND1) CJ8.BL11(BL_RX_GND2) CJ8.BL14(BL_RX_GND3) CJ8.BL17(BL_TX_GND2) CJ8.BL20(BL_TX_GND3) CJ8.BT1(BT_TX_GND1) CJ8.BT10(BT_RX_GND1) CJ8.BT11(BT_RX_GND2) CJ8.BT14(BT_RX_GND3) CJ8.BT17(BT_TX_GND2) CJ8.BT20(BT_TX_GND3) CJ8.CL1(CL_TX_GND1) CJ8.CL10(CL_RX_GND1) CJ8.CL11(CL_RX_GND2) CJ8.CL14(CL_RX_GND3) CJ8.CL17(CL_TX_GND2) CJ8.CL20(CL_TX_GND3) CJ8.CT1(CT_TX_GND1) CJ8.CT10(CT_RX_GND1) CJ8.CT11(CT_RX_GND2) CJ8.CT14(CT_RX_GND3) CJ8.CT17(CT_TX_GND2) CJ8.CT20(CT_TX_GND3) CJ8.DL1(DL_TX_GND1) CJ8.DL10(DL_RX_GND1) CJ8.DL11(DL_RX_GND2) CJ8.DL14(DL_RX_GND3) CJ8.DL17(DL_TX_GND2) CJ8.DL20(DL_TX_GND3) CJ8.DT1(DT_TX_GND1) CJ8.DT10(DT_RX_GND1) CJ8.DT11(DT_RX_GND2) CJ8.DT14(DT_RX_GND3) CJ8.DT17(DT_TX_GND2) CJ8.DT20(DT_TX_GND3) CJ8.EL1(EL_TX_GND1) CJ8.EL10(EL_RX_GND1) CJ8.EL11(EL_RX_GND2) CJ8.EL14(EL_RX_GND3) CJ8.EL17(EL_TX_GND2) CJ8.EL20(EL_TX_GND3) CJ8.ET1(ET_TX_GND1) CJ8.ET10(ET_RX_GND1) CJ8.ET11(ET_RX_GND2) CJ8.ET14(ET_RX_GND3) CJ8.ET17(ET_TX_GND2) CJ8.ET20(ET_TX_GND3) CJ8.FL1(FL_TX_GND1) CJ8.FL10(FL_RX_GND1) CJ8.FL11(FL_RX_GND2) CJ8.FL14(FL_RX_GND3) CJ8.FL17(FL_TX_GND2) CJ8.FL20(FL_TX_GND3) CJ8.FT1(FT_TX_GND1) CJ8.FT10(FT_RX_GND1) CJ8.FT11(FT_RX_GND2) CJ8.FT14(FT_RX_GND3) CJ8.FT17(FT_TX_GND2) CJ8.FT20(FT_TX_GND3) CJ8.GL1(GL_TX_GND1) CJ8.GL10(GL_RX_GND1) CJ8.GL11(GL_RX_GND2) CJ8.GL14(GL_RX_GND3) CJ8.GL17(GL_TX_GND2) CJ8.GL20(GL_TX_GND3) CJ8.GT1(GT_TX_GND1) CJ8.GT10(GT_RX_GND1) CJ8.GT11(GT_RX_GND2) CJ8.GT14(GT_RX_GND3) CJ8.GT17(GT_TX_GND2) CJ8.GT20(GT_TX_GND3) CJ8.HL1(HL_TX_GND1) CJ8.HL10(HL_RX_GND1) CJ8.HL11(HL_RX_GND2) CJ8.HL14(HL_RX_GND3) CJ8.HL17(HL_TX_GND2) CJ8.HL20(HL_TX_GND3) CJ8.HT1(HT_TX_GND1) CJ8.HT10(HT_RX_GND1) CJ8.HT11(HT_RX_GND2) CJ8.HT14(HT_RX_GND3) CJ8.HT17(HT_TX_GND2) CJ8.HT20(HT_TX_GND3) CJ8.S1(GND1) CJ8.S2(GND2) CJ8.S3(GND3) CJ8.S4(GND4) CJ8.S5(GND5) CJ8.S6(GND6) CJ8.S7(GND7) CJ8.S8(GND8) CJ8.S9(GND9) CJ8.S10(GND10) CJ8.S11(GND11) CJ8.S12(GND12) CJ8.S13(GND13) CJ8.S14(GND14) CJ8.S15(GND15) CJ8.S16(GND16) CJ8.S17(GND17) CJ8.S18(GND18) CJ8.S19(GND19) CJ8.S20(GND20) CJ8.S21(GND21) CJ8.S22(GND22) CJ8.S23(GND23) CJ8.S24(GND24) CJ8.S25(GND25) CJ8.S26(GND26) CJ8.S27(GND27) CJ8.S28(GND28) CJ8.S29(GND29) CJ8.S30(GND30) CJ8.S31(GND31) CJ8.S32(GND32) CJ8.S33(GND33) CJ8.S34(GND34) CJ8.S35(GND35) CJ8.S36(GND36) CJ8.S37(GND37) CJ8.S38(GND38) CJ8.S39(GND39) CJ8.S40(GND40) CJ8.S41(GND41) CJ8.S42(GND42) CJ8.S43(GND43) CJ8.S44(GND44) CJ8.S45(GND45) CJ8.S46(GND46) CJ8.S47(GND47) CJ8.S48(GND48) CJ8.S49(GND49) CJ8.S50(GND50) CJ8.S51(GND51) CJ8.S52(GND52) CJ8.S53(GND53) CJ8.S54(GND54) CJ8.S55(GND55) CJ8.S56(GND56) CJ8.S57(GND57) CJ8.S58(GND58) CJ8.S59(GND59) CJ8.S60(GND60) CJ8.S61(GND61) CJ8.S62(GND62) CJ8.S63(GND63) CJ8.S64(GND64) CJ8.S65(GND65) CJ8.S66(GND66) CJ8.S67(GND67) CJ8.S68(GND68) CJ8.S69(GND69) CJ9.AB1(AB_TX_GND1) CJ9.AB10(AB_RX_GND1) CJ9.AB11(AB_RX_GND2) CJ9.AB14(AB_RX_GND3) CJ9.AB17(AB_TX_GND2) CJ9.AB20(AB_TX_GND3) CJ9.AT1(AT_TX_GND1) CJ9.AT10(AT_RX_GND1) CJ9.AT11(AT_RX_GND2) CJ9.AT14(AT_RX_GND3) CJ9.AT17(AT_TX_GND2) CJ9.AT20(AT_TX_GND3) CJ9.BB1(BB_TX_GND1) CJ9.BB10(BB_RX_GND1) CJ9.BB11(BB_RX_GND2) CJ9.BB14(BB_RX_GND3) CJ9.BB17(BB_TX_GND2) CJ9.BB20(BB_TX_GND3) CJ9.BT1(BT_TX_GND1) CJ9.BT10(BT_RX_GND1) CJ9.BT11(BT_RX_GND2) CJ9.BT14(BT_RX_GND3) CJ9.BT17(BT_TX_GND2) CJ9.BT20(BT_TX_GND3) CJ9.CB1(CB_TX_GND1) CJ9.CB10(CB_RX_GND1) CJ9.CB11(CB_RX_GND2) CJ9.CB14(CB_RX_GND3) CJ9.CB17(CB_TX_GND2) CJ9.CB20(CB_TX_GND3) CJ9.CT1(CT_TX_GND1) CJ9.CT10(CT_RX_GND1) CJ9.CT11(CT_RX_GND2) CJ9.CT14(CT_RX_GND3) CJ9.CT17(CT_TX_GND2) CJ9.CT20(CT_TX_GND3) CJ9.DB1(DB_TX_GND1) CJ9.DB10(DB_RX_GND1) CJ9.DB11(DB_RX_GND2) CJ9.DB14(DB_RX_GND3) CJ9.DB17(DB_TX_GND2) CJ9.DB20(DB_TX_GND3) CJ9.DT1(DT_TX_GND1) CJ9.DT10(DT_RX_GND1) CJ9.DT11(DT_RX_GND2) CJ9.DT14(DT_RX_GND3) CJ9.DT17(DT_TX_GND2) CJ9.DT20(DT_TX_GND3) CJ9.EB1(EB_TX_GND1) CJ9.EB10(EB_RX_GND1) CJ9.EB11(EB_RX_GND2) CJ9.EB14(EB_RX_GND3) CJ9.EB17(EB_TX_GND2) CJ9.EB20(EB_TX_GND3) CJ9.ET1(ET_TX_GND1) CJ9.ET10(ET_RX_GND1) CJ9.ET11(ET_RX_GND2) CJ9.ET14(ET_RX_GND3) CJ9.ET17(ET_TX_GND2) CJ9.ET20(ET_TX_GND3) CJ9.FB1(FB_TX_GND1) CJ9.FB10(FB_RX_GND1) CJ9.FB11(FB_RX_GND2) CJ9.FB14(FB_RX_GND3) CJ9.FB17(FB_TX_GND2) CJ9.FB20(FB_TX_GND3) CJ9.FT1(FT_TX_GND1) CJ9.FT10(FT_RX_GND1) CJ9.FT11(FT_RX_GND2) CJ9.FT14(FT_RX_GND3) CJ9.FT17(FT_TX_GND2) CJ9.FT20(FT_TX_GND3) CJ9.S1(GND1) CJ9.S2(GND2) CJ9.S3(GND3) CJ9.S4(GND4) CJ9.S5(GND5) CJ9.S6(GND6) CJ9.S7(GND7) CJ9.S8(GND8) CJ9.S9(GND9) CJ9.S10(GND10) CJ9.S11(GND11) CJ9.S12(GND12) CJ9.S13(GND13) CJ9.S14(GND14) CJ9.S15(GND15) CJ9.S16(GND16) CJ9.S17(GND17) CJ9.S18(GND18) CJ9.S19(GND19) CJ9.S20(GND20) CJ9.S21(GND21) CJ9.S22(GND22) CJ9.S23(GND23) CJ9.S24(GND24) CJ9.S25(GND25) CJ9.S26(GND26) CJ9.S27(GND27) CJ9.S28(GND28) CJ9.S29(GND29) CJ9.S30(GND30) CJ9.S31(GND31) CJ9.S32(GND32) CJ9.S33(GND33) CJ9.S34(GND34) CJ9.S35(GND35) CJ9.S36(GND36) CJ9.S37(GND37) CJ9.S38(GND38) CJ9.S39(GND39) CJ9.S40(GND40) CJ9.S41(GND41) CJ9.S42(GND42) CJ9.S43(GND43) CJ9.S44(GND44) CJ9.S45(GND45) CJ9.S46(GND46) CJ9.S47(GND47) CJ9.S48(GND48) CJ9.S49(GND49) CJ9.S50(GND50) CJ9.S51(GND51) CJ9.S52(GND52) CJ9.S53(GND53) CJ9.S54(GND54) CJ9.S55(GND55) CJ9.S56(GND56) CJ9.S57(GND57) CJ9.S58(GND58) CJ9.S59(GND59) CJ9.S60(GND60) CJ9.S61(GND61) CJ9.S62(GND62) CJ9.S63(GND63) CJ9.S64(GND64) CJ9.S65(GND65) CJ9.S66(GND66) CJ9.S67(GND67) CJ9.S68(GND68) CJ9.S69(GND69) CJ9.S70(GND70) CJ9.S71(GND71) CJ9.S72(GND72) CJ9.S73(GND73) CJ9.S74(GND74) CJ9.S75(GND75) CJ9.S76(GND76) CJ9.S77(GND77) CJ9.S78(GND78) CJ9.S79(GND79) CJ9.S80(GND80) CJ9.S81(GND81) CJ9.S82(GND82) CJ9.S83(GND83) CJ9.S84(GND84) CJ9.S85(GND85) CJ9.S86(GND86) CJ9.S87(GND87) CJ9.S88(GND88) CJ9.S89(GND89) CJ9.S90(GND90) CJ9.S91(GND91) CJ9.S92(GND92) CJ9.S93(GND93) CJ9.S94(GND94) CJ9.S95(GND95) CJ9.S96(GND96) CJ9.S97(GND97) CJ9.S98(GND98) CJ9.S99(GND99) CJ12.L_1(L_GND1) CJ12.L_4(L_GND2) CJ12.L_7(L_GND3) CJ12.L_13(L_GND4) CJ12.L_16(L_GND5) CJ12.L_19(L_GND6) CJ12.L_20(L_GND7) CJ12.L_23(L_GND8) CJ12.L_26(L_GND9) CJ12.L_32(L_GND10) CJ12.L_35(L_GND11) CJ12.L_38(L_GND12) CJ12.S1(GND1) CJ12.S2(GND2) CJ12.S3(GND3) CJ12.S4(GND4) CJ12.S5(GND5) CJ12.S6(GND6) CJ12.S7(GND7) CJ12.S8(GND8) CJ12.S9(GND9) CJ12.S10(GND10) CJ12.S11(GND11) CJ12.S12(GND12) CJ12.S13(GND13) CJ12.S14(GND14) CJ12.S15(GND15) CJ12.S16(GND16) CJ12.S17(GND17) CJ12.S18(GND18) CJ12.S19(GND19) CJ12.S20(GND20) CJ12.S21(GND21) CJ12.S22(GND22) CJ12.S23(GND23) CJ12.U_1(U_GND1) CJ12.U_4(U_GND2) CJ12.U_7(U_GND3) CJ12.U_13(U_GND4) CJ12.U_16(U_GND5) CJ12.U_19(U_GND6) CJ12.U_20(U-GND7) CJ12.U_23(U_GND8) CJ12.U_26(U_GND9) CJ12.U_32(U_GND10) CJ12.U_35(U_GND11) CJ12.U_38(U_GND12) CN1.2 CN1.10 CN3.D2 CN3.D5 CN3.E4 CN3.E5 CN3.P11 CN3.P12 CN3.P13 CN3.P14 CN3.P15 CN3.P16 CN3.P17 CN3.P18 CN3.P19 CN3.P20 CN6.1 CN6.2 D43.1(A) D44.1(A) D45.1(A) D46.1(A) D47.1(A) D48.1(A) D49.1(A) D50.1(A) D51.1(A) D52.1(A) D53.1(A) D54.1(A) D55.1(A) D59.3(GND1) D59.8(GND2) D59.11(S1) D59.12(S2) D59.13(S3) D60.3(GND1) D60.8(GND2) D60.11(S1) D60.12(S2) D60.13(S3) D61.2(GND) D63.1(ANODE) D65.2(GND) D67.2(GND) D68.2(GND) D69.2(GND) D73.2(C) D74.2(C) D75.2(C) D76.2(C) D92.3(GND1) D92.8(GND2) D92.11(S1) D92.12(S2) D92.13(S3) D93.3(GND1) D93.8(GND2) D93.11(S1) D93.12(S2) D93.13(S3) D97.1 D98.1 D101.2(C) D102.2(C) H1.1(GND1) H1.2(GND2) H1.3(GND3) H1.4(GND4) H1.5(GND5) H1.6(GND6) H1.7(GND7) H1.8(GND8) H2.1(GND1) H2.2(GND2) H2.3(GND3) H2.4(GND4) H2.5(GND5) H2.6(GND6) H2.7(GND7) H2.8(GND8) H3.1(GND1) H3.2(GND2) H3.3(GND3) H3.4(GND4) H3.5(GND5) H3.6(GND6) H3.7(GND7) H3.8(GND8) H4.1(GND1) H4.2(GND2) H4.3(GND3) H4.4(GND4) H4.5(GND5) H4.6(GND6) H4.7(GND7) H4.8(GND8) H5.1(GND1) H5.2(GND2) H5.3(GND3) H5.4(GND4) H5.5(GND5) H5.6(GND6) H5.7(GND7) H5.8(GND8) H6.1(GND1) H6.2(GND2) H6.3(GND3) H6.4(GND4) H6.5(GND5) H6.6(GND6) H6.7(GND7) H6.8(GND8) H7.1(GND1) H7.2(GND2) H7.3(GND3) H7.4(GND4) H7.5(GND5) H7.6(GND6) H7.7(GND7) H7.8(GND8) H8.1(GND1) H8.2(GND2) H8.3(GND3) H8.4(GND4) H8.5(GND5) H8.6(GND6) H8.7(GND7) H8.8(GND8) H9.1(GND1) H9.2(GND2) H9.3(GND3) H9.4(GND4) H9.5(GND5) H9.6(GND6) H9.7(GND7) H9.8(GND8) H10.1(GND1) H10.2(GND2) H10.3(GND3) H10.4(GND4) H10.5(GND5) H10.6(GND6) H10.7(GND7) H10.8(GND8) H11.1(GND1) H11.2(GND2) H11.3(GND3) H11.4(GND4) H11.5(GND5) H11.6(GND6) H11.7(GND7) H11.8(GND8) H12.1(GND1) H12.2(GND2) H12.3(GND3) H12.4(GND4) H12.5(GND5) H12.6(GND6) H12.7(GND7) H12.8(GND8) H13.1(GND1) H13.2(GND2) H13.3(GND3) H13.4(GND4) H13.5(GND5) H13.6(GND6) H13.7(GND7) H13.8(GND8) H14.1 H15.1 H16.1 H17.1 H18.1 H19.1 H20.1(GND1) H20.2(GND2) H20.3(GND3) H20.4(GND4) H20.5(GND5) H20.6(GND6) H20.7(GND7) H20.8(GND8) H21.1 H22.1 H23.1 H24.1 J1.A4(GND_34) J1.A12(GND_35) J1.A15(GND_36) J1.A18(GND_37) J1.A20(GND_38) J1.A23(GND_39) J1.A24(GND_40) J1.A27(GND_41) J1.A28(GND_42) J1.A31(GND_43) J1.A34(GND_44) J1.A37(GND_45) J1.A38(GND_46) J1.A41(GND_47) J1.A42(GND_48) J1.A45(GND_49) J1.A46(GND_50) J1.A49(GND_51) J1.A51(GND_52) J1.A54(GND_53) J1.A55(GND_54) J1.A58(GND_55) J1.A59(GND_56) J1.A62(GND_57) J1.A63(GND_58) J1.A66(GND_59) J1.A67(GND_60) J1.A70(GND_61) J1.A71(GND_62) J1.A74(GND_63) J1.A75(GND_64) J1.A78(GND_65) J1.A79(GND_66) J1.A82(GND_67) J1.B4(GND_0) J1.B7(GND_1) J1.B13(GND_2) J1.B16(GND_3) J1.B18(GND_4) J1.B21(GND_5) J1.B22(GND_6) J1.B25(GND_7) J1.B26(GND_8) J1.B29(GND_9) J1.B32(GND_10) J1.B35(GND_11) J1.B36(GND_12) J1.B39(GND_13) J1.B40(GND_14) J1.B43(GND_15) J1.B44(GND_16) J1.B47(GND_17) J1.B49(GND_18) J1.B52(GND_19) J1.B53(GND_20) J1.B56(GND_21) J1.B57(GND_22) J1.B60(GND_23) J1.B61(GND_24) J1.B64(GND_25) J1.B65(GND_26) J1.B68(GND_27) J1.B69(GND_28) J1.B72(GND_29) J1.B73(GND_30) J1.B76(GND_31) J1.B77(GND_32) J1.B80(GND_33) J1.B81(PRSNT2_L_3) J3.4 J5.7 J5.8 J5.15 J5.26 J6.1 J6.2 J7.AR4(A4) J7.AR5(A5) J7.S1(GND1) J7.S2(GND2) J7.S3(GND3) J7.S4(GND4) J7.S5(GND5) J7.S6(GND6) J8.1 J8.2 J8.8 J8.13 J8.14 J10.S1(GND(1)) J10.S2(GND(2)) J10.S3(GND(5)) J10.S4(GND(4)) J11.S1(GND(1)) J11.S2(GND(2)) J11.S3(GND(5)) J11.S4(GND(4)) J12.S1(GND(1)) J12.S2(GND(2)) J12.S3(GND(5)) J12.S4(GND(4)) J14.S1(GND(1)) J14.S2(GND(2)) J14.S3(GND(5)) J14.S4(GND(4)) J15.S1(GND(1)) J15.S2(GND(2)) J15.S3(GND(5)) J15.S4(GND(4)) J17.4 J17.6 J17.8 J17.10 J17.12 J17.14 J17.16 J17.18 J17.19 J17.20 J19.4 J20.4 OJ1.AR4(E2-) OJ1.AR5(E3+) OJ1.BR10(GND) OJ1.S1(GND1) OJ1.S2(GND2) OJ1.S3(GND3) OJ1.S4(GND4) OJ1.U4 PC1.2 PC2.2 PC4.2 PC5.2 PC6.2 PC7.1 PC8.1 PC9.2 PC11.2 PC12.2 PC13.2 PC14.2 PC15.2 PC16.2 PC17.2 PC18.2 PC19.2 PC20.2 PC22.2 PC23.2 PC24.2 PC25.2 PC26.2 PC27.2 PC28.2 PC29.2 PC31.2 PC32.2 PC33.2 PC34.2 PC35.2 PC36.2 PC37.2 PC38.2 PC39.2 PC41.2 PC42.2 PC43.2 PC45.1 PC47.1 PC48.2 PC49.2 PC50.2 PC51.2 PC54.2 PC55.2 PC56.2 PC57.2 PC58.2 PC61.2 PC62.1 PC63.2 PC64.2 PC65.2 PC66.2 PC67.2 PC68.2 PC70.2 PC71.2 PC72.2 PC73.2 PC74.2 PC75.2 PC76.2 PC77.2 PC79.2 PC82.1 PC83.2 PC84.2 PC87.2 PC89.2 PC90.2 PC91.2 PC92.2 PC93.2 PC94.2 PC96.2 PC97.2 PC98.2 PC99.2 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC127.2 PC131.2 PC132.2 PC133.2 PC134.2 PC135.2 PC136.2 PC137.2 PC138.2 PC139.2 PC140.2 PC141.2 PC142.2 PC143.2 PC144.2 PC145.2 PC146.2 PC147.1 PC148.2 PC150.1 PC151.2 PC152.2 PC153.2 PC154.2 PC155.2 PC156.2 PC157.2 PC158.2 PC159.2(C) PC160.2(C) PC163.2 PC164.1 PC165.2 PC166.2 PC167.2 PC168.2 PC169.2 PC170.2 PC171.2 PC172.2 PC174.2 PC175.2 PC176.2 PC177.2 PC178.2 PC179.2 PC180.2 PC181.2 PC182.2 PC185.2 PC186.2 PC187.2 PC188.2 PC189.2 PC190.2 PC191.2 PC192.2 PC194.2 PC195.2 PC196.2 PC197.2 PC198.2 PC199.2 PC200.2 PC201.2 PC202.2 PC205.2 PC206.2 PC207.2 PC208.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC219.2 PC220.2 PC221.2 PC222.2 PC223.2 PC224.2 PC226.2 PC227.2 PC228.2 PC229.2 PC230.2 PC231.2 PC232.2 PC233.2 PC236.2 PC237.2 PC238.2 PC239.2 PC240.2 PC241.2 PC243.2 PC244.2 PC245.2 PC246.2 PC247.2 PC248.2 PC249.2 PC250.2 PC252.2 PC307.2 PC309.2 PC310.2 PC311.2 PC313.2 PC314.2 PC315.2 PC316.2 PC317.2 PC318.2 PC319.2 PC320.2 PC321.2 PC322.2 PC323.2 PC324.2 PC326.2 PC327.2 PC328.2 PC329.2 PC330.2 PC331.2 PC332.2 PC333.2 PC334.2 PC335.1 PC336.2 PC337.2 PC338.2 PC339.2 PC340.2 PC341.2 PC342.2 PC343.2 PC344.2 PC345.1 PC364.2 PC365.2 PC366.2 PC367.2 PC368.1 PC370.2 PC371.2 PC372.2 PC373.2 PC374.1 PC375.2 PC376.1 PC378.2 PC379.2 PC380.2 PC381.2 PC382.2 PC383.2 PC384.2 PC386.2 PC387.2 PC388.2 PC389.2 PC390.2 PC391.2 PC393.2 PC394.2 PC395.2 PC396.2 PC400.2 PC401.2 PC402.2 PC403.2 PC404.2 PC405.2 PC406.2 PC407.2 PC409.2 PC418.2 PC419.2 PC420.2 PC421.2 PC422.2 PC423.2 PC424.2 PC425.2 PC426.2 PC427.2 PC428.2 PC429.2 PC430.2 PC433.2 PC434.2 PC3408.2 PJ1.6 PQ3.2(S) PQ17.2(S) PQ20.2(S) PQ24.2(S) PR3.2 PR20.2 PR22.1 PR38.1 PR39.2 PR40.2 PR51.1 PR53.2 PR55.1 PR62.2 PR65.2 PR66.2 PR67.2 PR70.2 PR73.2 PR74.1 PR75.2 PR76.1 PR78.1 PR79.1 PR80.1 PR89.1 PR90.2 PR92.1 PR95.2 PR96.2 PR100.2 PR103.2 PR108.2 PR111.2 PR112.2 PR113.2 PR123.2 PR124.2 PR125.2 PR126.1 PR131.1 PR134.2 PR135.2 PR136.2 PR137.2 PR149.2 PR165.1 PR166.1 PR167.1 PR169.1 PR170.1 PR172.1 PR180.1 PR181.2 PR183.1 PR185.2 PR187.2 PR191.2 PR194.2 PR202.2 PR204.2 PR209.2 PR212.2 PR215.2 PR221.2 PR223.2 PR228.2 PR231.2 PR234.2 PR237.2 PR244.2 PR247.1 PR251.2 PR254.2 PR257.2 PR261.2 PR264.2 PR265.2 PR296.1 PR298.2 PR299.2 PR300.2 PR301.2 PR313.2 PR315.2 PR321.2 PR322.2 PR325.2 PR326.2 PR328.2 PR336.2 PR339.1 PR340.2 PR341.2 PR352.2 PR354.2 PR355.1 PR357.2 PR361.2 PR362.1 PR364.1 PR368.2 PR369.1 PR371.1 PR372.2 PR387.1 PR389.2 PR396.2 PR402.2 PR403.2 PR418.1 PR422.1 PR423.1 PR425.1 PR426.1 PR430.1 PR432.2 PR435.1 PR436.2 PR438.2 PR440.1 PR482.2 PR487.1 PR496.2 PR498.2 PU1.1(GND) PU2.13(PGND_13) PU2.14(PGND_14) PU2.15(PGND_15) PU2.16(PGND_16) PU2.17(PGND_17) PU2.18(PGND_18) PU2.19(PGND_19) PU2.20(PGND_20) PU2.27(GND) PU2.29(AGND) PU2.41(EPAD) PU3.1(GND) PU4.17(GND1) PU4.20(GND2) PU4.22(GND3) PU4.41(PAD) PU5.13(PGND) PU6.13(PGND) PU7.13(PGND_13) PU7.14(PGND_14) PU7.15(PGND_15) PU7.16(PGND_16) PU7.17(PGND_17) PU7.18(PGND_18) PU7.19(PGND_19) PU7.20(PGND_20) PU7.27(GND) PU7.29(AGND) PU7.41(EPAD) PU8.1(PGND1) PU8.14(PGND2) PU9.1(PGND1) PU9.14(PGND2) PU10.4(PGND) PU10.8(GND) PU10.11(E-PAD) PU11.1(PGND1) PU11.14(PGND2) PU12.1(GND) PU13.2(NC1) PU13.3(NC2) PU13.4(NC3) PU13.12(GND) PU13.13(NC4) PU13.14(NC5) PU13.17(NC6) PU13.21(E-PAD) PU18.4(GND1) PU18.9(GND2) PU19.1(PS/SYNC) PU19.4(GND) PU19.6(FB2) PU19.10(PGND) PU19.15(VSEL) PU20.4(PGND) PU20.6(AGND) PU21.4(PGND) PU21.6(AGND) PU22.13(PGND_13) PU22.14(PGND_14) PU22.15(PGND_15) PU22.16(PGND_16) PU22.17(PGND_17) PU22.18(PGND_18) PU22.19(PGND_19) PU22.20(PGND_20) PU22.27(GND) PU22.29(AGND) PU22.41(EPAD) PU24.3(GND) PU24.4(FB2) PU24.7(PG) PU24.11(VSEL) Q3.2(S) Q4.2(E) Q5.1(S1) Q5.4(S2) Q6.2(S) Q7.2(S) Q8.2(S) Q9.2(E) Q10.2(E) Q12.2(S) Q13.2(S) Q15.2(S) Q16.2(S) Q17.2(E) Q18.2(E) Q23.1(S1) Q23.4(S2) Q24.1(S1) Q24.4(S2) Q28.1(S1) Q28.4(S2) Q29.1(S1) Q29.4(S2) Q30.1(S1) Q30.4(S2) Q31.1(S1) Q31.4(S2) Q32.1(S1) Q32.4(S2) Q33.1(S1) Q33.4(S2) Q34.1(S1) Q34.4(S2) Q35.1(S1) Q35.4(S2) Q36.1(S1) Q36.4(S2) Q37.1(S1) Q37.4(S2) Q38.1(S1) Q38.4(S2) Q39.1(S1) Q39.4(S2) Q40.1(S1) Q40.4(S2) Q41.1(S1) Q41.4(S2) Q42.2(S) Q44.1(S1) Q44.4(S2) Q57.2(S) Q58.2(S) R7.2 R8.2 R9.2 R10.2 R33.1 R34.1 R35.1 R38.1 R40.1 R42.1 R45.1 R46.1 R47.1 R48.1 R52.2 R54.2 R56.2 R57.2 R58.2 R59.2 R63.2 R64.2 R65.2 R68.2 R69.2 R75.2 R77.2 R100.1 R102.1 R103.2 R104.1 R106.2 R108.1 R123.2 R142.1 R145.1 R146.2 R147.1 R150.2 R151.1 R166.2 R184.1 R186.1 R188.2 R189.1 R191.2 R192.1 R207.2 R254.2 R263.2 R270.2 R271.2 R272.1 R273.2 R274.1 R275.2 R276.2 R278.2 R279.2 R280.2 R286.2 R302.2 R303.2 R304.2 R305.2 R310.2 R311.2 R317.1 R318.1 R324.1 R325.1 R331.1 R332.1 R338.1 R339.1 R345.1 R346.1 R352.1 R353.1 R359.1 R360.1 R366.1 R367.1 R373.1 R374.1 R380.1 R381.1 R387.1 R388.1 R394.1 R395.1 R401.1 R402.1 R408.1 R409.1 R415.1 R416.1 R422.1 R423.1 R429.1 R430.1 R436.1 R437.1 R443.1 R444.1 R450.1 R451.1 R541.1 R542.1 R548.1 R549.1 R555.1 R556.1 R562.1 R563.1 R569.1 R570.1 R576.1 R577.1 R583.1 R584.1 R590.1 R591.1 R592.2 R593.2 R600.1 R601.1 R602.1 R603.1 R604.1 R605.1 R606.2 R607.2 R608.2 R609.2 R610.2 R611.2 R612.2 R613.2 R614.2 R615.2 R616.2 R617.2 R618.2 R619.2 R622.2 R663.1 R664.1 R665.1 R666.1 R667.1 R668.1 R681.1 R682.1 R683.1 R684.1 R685.1 R686.1 R699.1 R700.1 R701.1 R702.1 R703.1 R704.1 R717.1 R718.1 R719.1 R720.1 R721.1 R722.1 R735.1 R736.1 R737.1 R738.1 R739.1 R740.1 R753.1 R754.1 R755.1 R756.1 R757.1 R758.1 R783.1 R784.2 R847.1 R848.1 R849.1 R871.1 R872.1 R873.1 R895.1 R896.1 R897.1 R919.1 R920.1 R921.1 R959.1 R960.1 R961.1 R975.1 R976.1 R977.1 R991.1 R992.1 R993.1 R1006.1 R1007.1 R1017.2 R1023.1 R1031.1 R1032.1 R1033.1 R1034.1 R1041.2 R1042.2 R1050.1 R1051.1 R1063.1 R1065.1 R1066.1 R1067.1 R1068.1 R1075.1 R1081.1 R1082.1 R1084.1 R1085.1 R1086.1 R1100.1 R1101.1 R1102.1 R1105.2 R1107.1 R1108.1 R1109.1 R1110.1 R1111.1 R1133.2 R1134.2 R1145.2 R1146.2 R1158.1 R1159.2 R1170.1 R1177.2 R1181.1 R1190.1 R1192.1 R1199.1 R1212.1 R1217.1 R1226.2 R1227.2 R1266.1 R1270.1 R1274.2 R1275.2 R1404.1 R1405.1 R1408.1 R1432.1 R1433.1 R1434.1 R1435.1 R1436.1 R1437.1 R1438.1 R1439.1 R1440.1 R1441.1 R1442.1 R1443.1 R1444.2 R1445.2 R1446.2 R1447.2 R1448.1 R1450.1 R1451.1 R1452.1 R1453.1 R1506.1 R1515.1 R1614.2 R1615.2 R1616.2 R1617.1 R1619.1 R1623.2 R1624.1 R1625.1 R1626.1 R1630.1 R1631.1 R1632.1 R1633.1 R1634.1 R1635.1 R1636.1 R1637.1 R1638.1 R1639.1 R1640.1 R1641.1 R1642.1 R1645.1 R1650.1 R1651.1 R1657.1 R1674.1 R1681.2 R1682.2 R1691.1 R1692.1 R1693.1 R1696.1 R1697.1 R1698.1 R1708.1 R1715.1 R1718.1 R1719.1 R1720.1 R1722.1 R1724.1 R1726.1 R1728.1 R1729.1 R1730.1 R1732.1 R1733.1 R1735.1 R1736.1 R1738.1 R1740.1 R1742.1 R1744.1 R1746.1 R1759.1 R1761.2 R1778.1 R1779.1 R1783.1 R1784.1 R1790.2 R1791.2 R1813.1 R1814.1 R1815.1 R1816.2 R1820.2 R1821.2 R1843.1 R1851.1 R1852.1 R1862.1 R1863.2 R1868.1 R1869.2 R1870.2 R1871.1 R1878.1 R1879.1 R1880.1 R1891.1 R1892.1 R1893.1 R1894.1 R1895.1 R1896.1 R1899.2 R1900.2 R1909.2 R1910.1 R1911.1 R1919.1 R1987.2 R2001.1 R2002.1 R2003.1 R12282.1 R12284.1 R12285.1 R12288.1 R12308.1 R12310.2 R12312.2 R12314.1 R12326.2 R12337.2 R12346.2 R12356.2 R12372.1 R12373.1 R12374.1 R12375.1 R12376.1 R12380.1 R12434.1 R12440.1 R12441.1 R12442.1 R12443.1 R12444.1 R12445.1 R12446.1 R12462.1 R12463.1 R12464.2 R12465.2 R12469.2 R12477.1 R12478.1 R12479.2 R12484.2 R12700.1 R12704.2 R12705.2 R12712.2 R12720.2 R12721.2 R12734.2 R12754.1 R12755.1 R12766.2 R12768.2 R12770.2 R12772.2 R12775.2 R12776.2 R12777.1 R12778.1 R12779.1 R12780.1 R12781.1 R12782.1 R12793.2 R12794.2 R12799.1 R12803.2 R12804.2 R12808.2 R12809.2 R12811.2 R12813.2 R12819.1 R12829.1 R12830.1 R12899.1 R12904.1 R12907.2 R12910.1 R12913.2 R12917.2 R12918.1 R12922.2 R12923.1 R12924.1 R12935.1 R12938.2 R12939.2 R12947.1 R12948.1 R12960.1 R12967.1 R12969.1 R12973.2 R12974.2 R12976.1 R12978.1 R12981.2 R12982.2 R12983.2 R12984.2 R13001.1 R13005.2 R13006.1 R13015.1 R13016.1 R13020.1 R13026.2 R13027.2 R13031.1 R13042.2 R13049.2 R13069.1 R13070.1 R13071.1 R13082.2 R13086.2 R13088.1 R13089.1 SK157.4 SK158.4 U1.A5(SRD_AGND_1) U1.A9(SRD_AGND_2) U1.A13(SRD_AGND_3) U1.A17(SRD_AGND_4) U1.A21(SRD_AGND_5) U1.A25(SRD_AGND_6) U1.A29(SRD_AGND_7) U1.A33(SRD_AGND_8) U1.AA1(VSS_51) U1.AA4(VSS_52) U1.AA5(SRD_AGND_268) U1.AA6(SRD_AGND_269) U1.AA7(VSS_53) U1.AA10(VSS_54) U1.AA11(DDRC_AVSS) U1.AA13(VSS_55) U1.AA15(VSS_56) U1.AA17(VSS_57) U1.AA19(VSS_58) U1.AA21(VSS_59) U1.AA23(VSS_60) U1.AA25(VSS_61) U1.AA27(VSS_62) U1.AA28(SRD_AGND_270) U1.AA29(SRD_AGND_271) U1.AA31(UC_PLL_AGND) U1.AA32(VSS_63) U1.AA36(VSS_64) U1.AB10(VSS_65) U1.AB12(VSS_66) U1.AB14(VSS_67) U1.AB16(VSS_68) U1.AB18(VSS_69) U1.AB20(VSS_70) U1.AB22(VSS_71) U1.AB24(VSS_72) U1.AB26(VSS_73) U1.AB28(VSS_74) U1.AC3(VSS_75) U1.AC6(VSS_76) U1.AC9(VSS_77) U1.AC13(VSS_78) U1.AC15(VSS_79) U1.AC17(VSS_80) U1.AC21(VSS_81) U1.AC23(VSS_82) U1.AC25(VSS_83) U1.AC27(VSS_84) U1.AD1(VSS_85) U1.AD11(VSS_86) U1.AD12(VSS_87) U1.AD14(VSS_88) U1.AD16(VSS_89) U1.AD18(VSS_90) U1.AD20(VSS_91) U1.AD22(VSS_92) U1.AD24(VSS_93) U1.AD26(SYNCE_0_PLL_AGND) U1.AD28(VSS_94) U1.AE5(VSS_95) U1.AE8(VSS_96) U1.AE13(VSS_97) U1.AE15(VSS_98) U1.AE17(VSS_99) U1.AE19(VSS_100) U1.AE21(VSS_101) U1.AE23(VSS_102) U1.AE25(SYNCE_1_PLL_AGND) U1.AE31(VSS_103) U1.AF3(VSS_104) U1.AF12(VSS_105) U1.AF14(VSS_106) U1.AF16(VSS_107) U1.AF17(DDRB_AVSS) U1.AF18(VSS_108) U1.AF20(VSS_109) U1.AF22(VSS_110) U1.AF24(VSS_111) U1.AF26(VSS_112) U1.AF29(VSS_113) U1.AG1(VSS_114) U1.AG7(VSS_115) U1.AG10(VSS_116) U1.AG13(VSS_117) U1.AG15(VSS_118) U1.AG19(VSS_119) U1.AG22(VSS_120) U1.AG23(VSS_121) U1.AG25(VSS_122) U1.AG27(VSS_123) U1.AG34(VSS_124) U1.AH5(VSS_125) U1.AH20(VSS_126) U1.AH25(VSS_127) U1.AH26(DDRA_AVSS) U1.AH37(VSS_128) U1.AJ3(VSS_129) U1.AJ6(VSS_130) U1.AJ9(VSS_131) U1.AJ12(VSS_132) U1.AJ15(VSS_133) U1.AJ18(VSS_134) U1.AJ21(VSS_135) U1.AJ27(VSS_136) U1.AJ30(VSS_137) U1.AK1(VSS_138) U1.AL5(VSS_139) U1.AL8(VSS_140) U1.AL11(VSS_141) U1.AL14(VSS_142) U1.AL17(VSS_143) U1.AL20(VSS_144) U1.AL23(VSS_145) U1.AL26(VSS_146) U1.AL29(VSS_147) U1.AL32(VSS_148) U1.AM3(VSS_149) U1.AN1(VSS_150) U1.AN7(VSS_151) U1.AN10(VSS_152) U1.AN13(VSS_153) U1.AN16(VSS_154) U1.AN19(VSS_155) U1.AN22(VSS_156) U1.AN25(VSS_157) U1.AN28(VSS_158) U1.AN31(VSS_159) U1.AN34(VSS_160) U1.AN35(VSS_161) U1.AP5(VSS_162) U1.AR3(VSS_163) U1.AR6(VSS_164) U1.AR9(VSS_165) U1.AR12(VSS_166) U1.AR15(VSS_167) U1.AR18(VSS_168) U1.AR21(VSS_169) U1.AR24(VSS_170) U1.AR27(VSS_171) U1.AR30(VSS_172) U1.AR33(VSS_173) U1.AR36(VSS_174) U1.AR37(VSS_175) U1.AT1(VSS_176) U1.AU2(VSS_177) U1.AU5(VSS_178) U1.AU8(VSS_179) U1.AU11(VSS_180) U1.AU14(VSS_181) U1.AU17(VSS_182) U1.AU20(VSS_183) U1.AU23(VSS_184) U1.AU26(VSS_185) U1.AU29(VSS_186) U1.AU32(VSS_187) U1.AU35(VSS_188) U1.B1(SRD_AGND_9) U1.B5(SRD_AGND_10) U1.B9(SRD_AGND_11) U1.B13(SRD_AGND_12) U1.B17(SRD_AGND_13) U1.B21(SRD_AGND_14) U1.B25(SRD_AGND_15) U1.B29(SRD_AGND_16) U1.B33(SRD_AGND_17) U1.B37(SRD_AGND_18) U1.C4(SRD_AGND_19) U1.C8(SRD_AGND_20) U1.C12(SRD_AGND_21) U1.C16(SRD_AGND_22) U1.C20(SRD_AGND_23) U1.C24(SRD_AGND_24) U1.C25(SRD_AGND_25) U1.C26(SRD_AGND_26) U1.C30(SRD_AGND_27) U1.C34(SRD_AGND_28) U1.D4(SRD_AGND_29) U1.D8(SRD_AGND_30) U1.D12(SRD_AGND_31) U1.D16(SRD_AGND_32) U1.D20(SRD_AGND_33) U1.D24(SRD_AGND_34) U1.D26(SRD_AGND_35) U1.D30(SRD_AGND_36) U1.D34(SRD_AGND_37) U1.E1(SRD_AGND_38) U1.E2(SRD_AGND_39) U1.E3(SRD_AGND_40) U1.E4(SRD_AGND_41) U1.E5(SRD_AGND_42) U1.E6(SRD_AGND_43) U1.E7(SRD_AGND_44) U1.E8(SRD_AGND_45) U1.E9(SRD_AGND_46) U1.E10(SRD_AGND_47) U1.E11(SRD_AGND_48) U1.E12(SRD_AGND_49) U1.E13(SRD_AGND_50) U1.E14(SRD_AGND_51) U1.E15(SRD_AGND_52) U1.E16(SRD_AGND_53) U1.E17(SRD_AGND_54) U1.E18(SRD_AGND_55) U1.E19(SRD_AGND_56) U1.E20(SRD_AGND_57) U1.E21(SRD_AGND_58) U1.E22(SRD_AGND_59) U1.E23(SRD_AGND_60) U1.E24(SRD_AGND_61) U1.E25(SRD_AGND_62) U1.E26(SRD_AGND_63) U1.E27(SRD_AGND_64) U1.E28(SRD_AGND_65) U1.E29(SRD_AGND_66) U1.E30(SRD_AGND_67) U1.E31(SRD_AGND_68) U1.E32(SRD_AGND_69) U1.E33(SRD_AGND_70) U1.E34(SRD_AGND_71) U1.E35(SRD_AGND_72) U1.E36(SRD_AGND_73) U1.E37(SRD_AGND_74) U1.F1(SRD_AGND_75) U1.F5(SRD_AGND_76) U1.F9(SRD_AGND_77) U1.F13(SRD_AGND_78) U1.F17(SRD_AGND_79) U1.F21(SRD_AGND_80) U1.F25(SRD_AGND_81) U1.F29(SRD_AGND_82) U1.F33(SRD_AGND_83) U1.F37(SRD_AGND_84) U1.G1(SRD_AGND_85) U1.G5(SRD_AGND_86) U1.G9(SRD_AGND_87) U1.G13(SRD_AGND_88) U1.G17(SRD_AGND_89) U1.G21(SRD_AGND_90) U1.G25(SRD_AGND_91) U1.G29(SRD_AGND_92) U1.G33(SRD_AGND_93) U1.G37(SRD_AGND_94) U1.H4(SRD_AGND_95) U1.H8(SRD_AGND_96) U1.H9(SRD_AGND_97) U1.H10(SRD_AGND_98) U1.H11(SRD_AGND_99) U1.H12(SRD_AGND_100) U1.H13(SRD_AGND_101) U1.H14(SRD_AGND_102) U1.H15(SRD_AGND_103) U1.H16(SRD_AGND_104) U1.H17(SRD_AGND_105) U1.H18(SRD_AGND_106) U1.H19(SRD_AGND_107) U1.H20(SRD_AGND_108) U1.H21(SRD_AGND_109) U1.H22(SRD_AGND_110) U1.H23(SRD_AGND_111) U1.H24(SRD_AGND_112) U1.H25(SRD_AGND_113) U1.H26(SRD_AGND_114) U1.H30(SRD_AGND_115) U1.H34(SRD_AGND_116) U1.J4(SRD_AGND_117) U1.J8(SRD_AGND_118) U1.J12(SRD_AGND_119) U1.J16(SRD_AGND_120) U1.J20(SRD_AGND_121) U1.J24(SRD_AGND_122) U1.J26(SRD_AGND_123) U1.J30(SRD_AGND_124) U1.J34(SRD_AGND_125) U1.K1(SRD_AGND_126) U1.K2(SRD_AGND_127) U1.K3(SRD_AGND_128) U1.K4(SRD_AGND_129) U1.K5(SRD_AGND_130) U1.K6(SRD_AGND_131) U1.K7(SRD_AGND_132) U1.K8(SRD_AGND_133) U1.K12(SRD_AGND_134) U1.K16(SRD_AGND_135) U1.K20(SRD_AGND_136) U1.K24(SRD_AGND_137) U1.K26(SRD_AGND_138) U1.K27(SRD_AGND_139) U1.K28(SRD_AGND_140) U1.K29(SRD_AGND_141) U1.K30(SRD_AGND_142) U1.K31(SRD_AGND_143) U1.K32(SRD_AGND_144) U1.K33(SRD_AGND_145) U1.K34(SRD_AGND_146) U1.K35(SRD_AGND_147) U1.K36(SRD_AGND_148) U1.K37(SRD_AGND_149) U1.L1(SRD_AGND_150) U1.L2(SRD_AGND_151) U1.L5(SRD_AGND_152) U1.L6(SRD_AGND_153) U1.L7(SRD_AGND_154) U1.L8(SRD_AGND_155) U1.L9(SRD_AGND_156) U1.L10(SRD_AGND_157) U1.L11(SRD_AGND_158) U1.L12(SRD_AGND_159) U1.L13(SRD_AGND_160) U1.L14(SRD_AGND_161) U1.L15(SRD_AGND_162) U1.L16(SRD_AGND_163) U1.L17(SRD_AGND_164) U1.L18(SRD_AGND_165) U1.L19(SRD_AGND_166) U1.L20(SRD_AGND_167) U1.L21(SRD_AGND_168) U1.L22(SRD_AGND_169) U1.L23(SRD_AGND_170) U1.L24(SRD_AGND_171) U1.L25(SRD_AGND_172) U1.L26(SRD_AGND_173) U1.L30(SRD_AGND_174) U1.L31(SRD_AGND_175) U1.L32(SRD_AGND_176) U1.L33(SRD_AGND_177) U1.L36(SRD_AGND_178) U1.L37(SRD_AGND_179) U1.M3(SRD_AGND_180) U1.M4(SRD_AGND_181) U1.M5(SRD_AGND_182) U1.M8(SRD_AGND_183) U1.M9(SRD_AGND_184) U1.M10(SRD_AGND_185) U1.M14(SRD_AGND_186) U1.M21(SRD_AGND_187) U1.M24(SRD_AGND_188) U1.M27(SRD_AGND_189) U1.M28(SRD_AGND_190) U1.M29(SRD_AGND_191) U1.M30(SRD_AGND_192) U1.M33(SRD_AGND_193) U1.M34(SRD_AGND_194) U1.M35(SRD_AGND_195) U1.N5(SRD_AGND_196) U1.N10(SRD_AGND_197) U1.N12(SRD_AGND_198) U1.N13(SRD_AGND_199) U1.N17(SRD_AGND_200) U1.N18(SRD_AGND_201) U1.N19(SRD_AGND_202) U1.N20(SRD_AGND_203) U1.N22(NIF_LCPLL_AGND) U1.N25(SRD_AGND_204) U1.N26(SRD_AGND_205) U1.N28(SRD_AGND_206) U1.N33(SRD_AGND_207) U1.P5(SRD_AGND_208) U1.P10(SRD_AGND_209) U1.P12(VSS_1) U1.P14(VSS_2) U1.P16(VSS_3) U1.P18(VSS_4) U1.P20(VSS_5) U1.P24(VSS_6) U1.P26(VSS_7) U1.P28(SRD_AGND_210) U1.P33(SRD_AGND_211) U1.R1(SRD_AGND_212) U1.R2(SRD_AGND_213) U1.R5(SRD_AGND_214) U1.R6(SRD_AGND_215) U1.R7(SRD_AGND_216) U1.R10(SRD_AGND_217) U1.R11(VSS_8) U1.R13(VSS_9) U1.R15(VSS_10) U1.R17(VSS_11) U1.R19(VSS_12) U1.R21(VSS_13) U1.R23(VSS_14) U1.R25(VSS_15) U1.R27(VSS_16) U1.R28(SRD_AGND_218) U1.R31(SRD_AGND_219) U1.R32(SRD_AGND_220) U1.R33(SRD_AGND_221) U1.R36(SRD_AGND_222) U1.R37(SRD_AGND_223) U1.T3(SRD_AGND_224) U1.T4(SRD_AGND_225) U1.T5(SRD_AGND_226) U1.T8(SRD_AGND_227) U1.T9(SRD_AGND_228) U1.T10(SRD_AGND_229) U1.T12(VSS_17) U1.T14(VSS_18) U1.T16(VSS_19) U1.T18(VSS_20) U1.T20(VSS_21) U1.T22(VSS_22) U1.T24(VSS_23) U1.T25(VSS_24) U1.T26(VSS_25) U1.T28(SRD_AGND_230) U1.T29(SRD_AGND_231) U1.T30(SRD_AGND_232) U1.T31(SRD_AGND_233) U1.T33(SRD_AGND_234) U1.T34(SRD_AGND_235) U1.T35(SRD_AGND_236) U1.U5(SRD_AGND_237) U1.U10(SRD_AGND_238) U1.U11(VSS_26) U1.U14(NIFE_LCPLL1_AGND) U1.U15(VSS_27) U1.U17(VSS_28) U1.U19(VSS_29) U1.U21(VSS_30) U1.U23(VSS_31) U1.U27(VSS_32) U1.U33(SRD_AGND_239) U1.V5(SRD_AGND_240) U1.V10(SRD_AGND_241) U1.V14(VSS_33) U1.V16(VSS_34) U1.V20(VSS_35) U1.V22(VSS_36) U1.V24(NIFE_LCPLL0_AGND) U1.V26(VSS_37) U1.V33(SRD_AGND_242) U1.W1(SRD_AGND_243) U1.W2(SRD_AGND_244) U1.W5(SRD_AGND_245) U1.W6(SRD_AGND_246) U1.W7(SRD_AGND_247) U1.W10(SRD_AGND_248) U1.W11(VSS_38) U1.W15(VSS_39) U1.W17(C_PLL_AGND) U1.W21(VSS_40) U1.W23(VSS_41) U1.W27(VSS_42) U1.W28(SRD_AGND_249) U1.W29(SRD_AGND_250) U1.W36(SRD_AGND_251) U1.Y1(SRD_AGND_252) U1.Y2(SRD_AGND_253) U1.Y3(SRD_AGND_254) U1.Y4(SRD_AGND_255) U1.Y5(SRD_AGND_256) U1.Y7(SRD_AGND_257) U1.Y8(SRD_AGND_258) U1.Y9(SRD_AGND_259) U1.Y10(SRD_AGND_260) U1.Y12(VSS_43) U1.Y14(VSS_44) U1.Y16(VSS_45) U1.Y20(VSS_46) U1.Y22(VSS_47) U1.Y24(VSS_48) U1.Y26(VSS_49) U1.Y27(SRD_AGND_261) U1.Y29(SRD_AGND_262) U1.Y30(VSS_50) U1.Y33(SRD_AGND_263) U1.Y34(SRD_AGND_264) U1.Y35(SRD_AGND_265) U1.Y36(SRD_AGND_266) U1.Y37(SRD_AGND_267) U2.A2(VSSQ_01) U2.A8(VSSQ_02) U2.B2(VSS_01) U2.C9(VSSQ_03) U2.D2(VSSQ_04) U2.D8(VSSQ_05) U2.E1(VSS_02) U2.E3(VSSQ_06) U2.E8(VSSQ_07) U2.E9(VSS_03) U2.F1(VSSQ_08) U2.G8(VSS_04) U2.H1(VSSQ_09) U2.H9(VSSQ_10) U2.K1(VSS_05) U2.K9(VSS_06) U2.M9(VSS_07) U2.N1(VSS_08) U2.T1(VSS_09) U3.A2(VSSQ_01) U3.A8(VSSQ_02) U3.B2(VSS_01) U3.C9(VSSQ_03) U3.D2(VSSQ_04) U3.D8(VSSQ_05) U3.E1(VSS_02) U3.E3(VSSQ_06) U3.E8(VSSQ_07) U3.E9(VSS_03) U3.F1(VSSQ_08) U3.G8(VSS_04) U3.H1(VSSQ_09) U3.H9(VSSQ_10) U3.K1(VSS_05) U3.K9(VSS_06) U3.M9(VSS_07) U3.N1(VSS_08) U3.T1(VSS_09) U4.A2(VSSQ_01) U4.A8(VSSQ_02) U4.B2(VSS_01) U4.C9(VSSQ_03) U4.D2(VSSQ_04) U4.D8(VSSQ_05) U4.E1(VSS_02) U4.E3(VSSQ_06) U4.E8(VSSQ_07) U4.E9(VSS_03) U4.F1(VSSQ_08) U4.G8(VSS_04) U4.H1(VSSQ_09) U4.H9(VSSQ_10) U4.K1(VSS_05) U4.K9(VSS_06) U4.M9(VSS_07) U4.N1(VSS_08) U4.T1(VSS_09) U5.A2(VSSQ_01) U5.A8(VSSQ_02) U5.B2(VSS_01) U5.C9(VSSQ_03) U5.D2(VSSQ_04) U5.D8(VSSQ_05) U5.E1(VSS_02) U5.E3(VSSQ_06) U5.E8(VSSQ_07) U5.E9(VSS_03) U5.F1(VSSQ_08) U5.G8(VSS_04) U5.H1(VSSQ_09) U5.H9(VSSQ_10) U5.K1(VSS_05) U5.K9(VSS_06) U5.M9(VSS_07) U5.N1(VSS_08) U5.T1(VSS_09) U6.A2(VSSQ_01) U6.A8(VSSQ_02) U6.B2(VSS_01) U6.C9(VSSQ_03) U6.D2(VSSQ_04) U6.D8(VSSQ_05) U6.E1(VSS_02) U6.E3(VSSQ_06) U6.E8(VSSQ_07) U6.E9(VSS_03) U6.F1(VSSQ_08) U6.G8(VSS_04) U6.H1(VSSQ_09) U6.H9(VSSQ_10) U6.K1(VSS_05) U6.K9(VSS_06) U6.M9(VSS_07) U6.N1(VSS_08) U6.T1(VSS_09) U7.A2(VSSQ_01) U7.A8(VSSQ_02) U7.B2(VSS_01) U7.C9(VSSQ_03) U7.D2(VSSQ_04) U7.D8(VSSQ_05) U7.E1(VSS_02) U7.E3(VSSQ_06) U7.E8(VSSQ_07) U7.E9(VSS_03) U7.F1(VSSQ_08) U7.G8(VSS_04) U7.H1(VSSQ_09) U7.H9(VSSQ_10) U7.K1(VSS_05) U7.K9(VSS_06) U7.M9(VSS_07) U7.N1(VSS_08) U7.T1(VSS_09) U10.7(GND) U12.7(GND) U13.7(GND) U14.7(GND) U15.7(GND) U16.7(GND) U18.7(GND) U19.7(GND) U20.10(GND) U21.7(GND) U22.10(GND) U23.B1(VSS_01) U23.B2(VSS_08) U23.B3(VSS_16) U23.B4(VSS_23) U23.B5(VSS_30) U23.B12(VSS_50) U23.B13(VSS_57) U23.B14(VSS_64) U23.B15(VSS_71) U23.B16(VSS_79) U23.C7(VSS_38) U23.D1(VSS_02) U23.D2(VSS_09) U23.D3(VSS_17) U23.D4(VSS_24) U23.D5(VSS_31) U23.D10(VSS_41) U23.D12(VSS_51) U23.D13(VSS_58) U23.D14(VSS_65) U23.D15(VSS_72) U23.D16(VSS_80) U23.E8(VSS_40) U23.F1(VSS_03) U23.F2(VSS_10) U23.F3(VSS_18) U23.F4(VSS_25) U23.F5(VSS_32) U23.F10(VSS_42) U23.F12(VSS_52) U23.F13(VSS_59) U23.F14(VSS_66) U23.F15(VSS_73) U23.F16(VSS_81) U23.H1(VSS_04) U23.H2(VSS_11) U23.H3(VSS_19) U23.H4(VSS_26) U23.H5(VSS_33) U23.H11(VSS_45) U23.H12(VSS_53) U23.H13(VSS_60) U23.H14(VSS_67) U23.H15(VSS_74) U23.H16(VSS_82) U23.J11(VSS_46) U23.K2(VSS_12) U23.K7(VSS_39) U23.K10(VSS_43) U23.K11(VSS_47) U23.K15(VSS_75) U23.L1(VSS_05) U23.L2(VSS_13) U23.L3(VSS_20) U23.L4(VSS_27) U23.L5(VSS_34) U23.L11(VSS_48) U23.L12(VSS_54) U23.L13(VSS_61) U23.L14(VSS_68) U23.L15(VSS_76) U23.L16(VSS_83) U23.M10(VSS_44) U23.N1(VSS_06) U23.N2(VSS_14) U23.N3(VSS_21) U23.N4(VSS_28) U23.N5(VSS_35) U23.N12(VSS_55) U23.N13(VSS_62) U23.N14(VSS_69) U23.N15(VSS_77) U23.N16(VSS_84) U23.R1(VSS_07) U23.R2(VSS_15) U23.R3(VSS_22) U23.R4(VSS_29) U23.R5(VSS_36) U23.R12(VSS_56) U23.R13(VSS_63) U23.R14(VSS_70) U23.R15(VSS_78) U23.R16(VSS_85) U23.T6(VSS_37) U23.T11(VSS_49) U25.A1(VSS0) U25.A3(VSS6) U25.A5(VSS7) U25.A7(VSS8) U25.A9(VSS9) U25.A11(VSS1) U25.A13(VSS2) U25.A15(VSS3) U25.A17(VSS4) U25.A18(VSS5) U25.B3(VSS14) U25.B5(VSS15) U25.B7(VSS16) U25.B9(VSS17) U25.B11(VSS10) U25.B13(VSS11) U25.B15(VSS12) U25.B17(VSS13) U25.C1(VSS18) U25.C2(VSS26) U25.C3(VSS27) U25.C4(VSS28) U25.C5(VSS29) U25.C6(VSS30) U25.C7(VSS31) U25.C8(VSS32) U25.C11(VSS19) U25.C12(VSS20) U25.C13(VSS21) U25.C14(VSS22) U25.C15(VSS23) U25.C16(VSS24) U25.C17(VSS25) U25.D2(VSS39) U25.D4(VSS40) U25.D6(VSS41) U25.D8(VSS42) U25.D10(VSS33) U25.D12(VSS34) U25.D14(VSS35) U25.D16(VSS36) U25.D17(VSS37) U25.D18(VSS38) U25.E2(VSS47) U25.E4(VSS48) U25.E6(VSS49) U25.E8(VSS50) U25.E10(VSS43) U25.E12(VSS44) U25.E14(VSS45) U25.E16(VSS46) U25.F1(VSS51) U25.F3(VSS57) U25.F5(VSS58) U25.F7(VSS59) U25.F11(VSS52) U25.F13(VSS53) U25.F15(VSS54) U25.F17(VSS55) U25.F18(VSS56) U25.G6(VSS60) U25.G9(VSS61) U25.H7(VSS63) U25.H9(VSS64) U25.H11(VSS62) U25.J6(VSS67) U25.J8(VSS68) U25.J10(VSS65) U25.J12(VSS66) U25.K6(VSS71) U25.K8(VSS72) U25.K10(VSS69) U25.K12(VSS70) U25.L7(VSS74) U25.L9(VSS75) U25.L11(VSS73) U25.N1(VSS76) U25.N3(VSS82) U25.N5(VSS83) U25.N7(VSS84) U25.N11(VSS77) U25.N13(VSS78) U25.N15(VSS79) U25.N17(VSS80) U25.N18(VSS81) U25.P2(VSS89) U25.P4(VSS90) U25.P6(VSS91) U25.P8(VSS92) U25.P10(VSS85) U25.P12(VSS86) U25.P14(VSS87) U25.P16(VSS88) U25.R2(VSS99) U25.R4(VSS100) U25.R6(VSS101) U25.R8(VSS102) U25.R10(VSS93) U25.R12(VSS94) U25.R14(VSS95) U25.R16(VSS96) U25.R17(VSS97) U25.R18(VSS98) U25.T1(VSS103) U25.T2(VSS111) U25.T3(VSS112) U25.T4(VSS113) U25.T5(VSS114) U25.T6(VSS115) U25.T7(VSS116) U25.T8(VSS117) U25.T11(VSS104) U25.T12(VSS105) U25.T13(VSS106) U25.T14(VSS107) U25.T15(VSS108) U25.T16(VSS109) U25.T17(VSS110) U25.U3(VSS122) U25.U5(VSS123) U25.U7(VSS124) U25.U9(VSS125) U25.U11(VSS118) U25.U13(VSS119) U25.U15(VSS120) U25.U17(VSS121) U25.V1(VSS126) U25.V3(VSS132) U25.V5(VSS133) U25.V7(VSS134) U25.V9(VSS135) U25.V11(VSS127) U25.V13(VSS128) U25.V15(VSS129) U25.V17(VSS130) U25.V18(VSS131) U26.1(GND) U26.11(EPAD) U27.1(GND) U27.11(EPAD) U28.1(GND) U28.11(EPAD) U29.1(GND) U29.11(EPAD) U30.1(GND) U30.11(EPAD) U31.1(GND) U31.11(EPAD) U32.1(GND) U32.11(EPAD) U33.1(GND) U33.11(EPAD) U34.1(GND) U34.11(EPAD) U35.1(GND) U35.11(EPAD) U36.1(GND) U36.11(EPAD) U37.1(GND) U37.11(EPAD) U38.1(GND) U38.11(EPAD) U39.1(GND) U39.11(EPAD) U42.1(GND) U42.11(EPAD) U43.2(GND) U46.4(GND) U47.12(GND) U48.12(GND) U49.12(GND) U50.12(GND) U51.12(GND) U52.12(GND) U53.12(GND) U54.12(GND) U55.12(GND) U56.12(GND) U57.12(GND) U58.12(GND) U59.3(GND) U60.3(GND) U61.3(GND) U62.12(GND) U63.12(GND) U64.12(GND) U65.12(GND) U67.8(VSS) U68.8(VSS) U69.8(VSS) U70.A1(GND_14) U70.A13(GND_13) U70.B8(GND_12) U70.C3(GND_11) U70.D5(GND_10) U70.E11(GND_9) U70.F3(GND_8) U70.G7(GND_7) U70.H12(GND_6) U70.J4(GND_5) U70.L9(GND_4) U70.M6(GND_3) U70.N1(GND_2) U70.N13(GND_1) U71.4(GND) U73.8(DVSS1) U73.26(DVSS2) U73.43(DVSS3) U73.48(AVSS2) U73.49(AVSS1) U73.64(AVSS3) U73.65(THERMAL PAD) U74.4(GND) U75.5(GND) U76.8(VSS) U81.4(GND) U85.65(EPAD_GND) U86.4(GND) U89.14(GND) U96.5(GND) U97.2(GND) U98.2(GND) U99.3(GND) U101.3(GND) U102.3(GND) U104.4(GND) U105.3(GND) U106.2(V-) U107.3(GND) U108.3(GND) U110.6(GND1) U110.11(GND2) U111.2(GND) U112.2(GND) U113.2(GND) U115.3(ANODE) U121.6(GND1) U121.11(GND2) U124.10(GND_1) U124.12(GND_2) U124.13(GND_3) U124.24(GND_4) U127.4(GNDDC[3]) U127.5(GNDAP) U127.7(GNDAB) U127.13(GNDAX) U127.14(GNDAT) U127.19(GNDAR) U127.34(GNDDIO[1]) U127.35(GNDDC[1]) U127.47(GNDDC[2]) U127.48(GNDDIO[2]) U127.68(GNDDC[0]) U127.69(GNDDIO[0]) U129.1(VEE) U129.17(EPAD) U132.1(VEE) U132.17(EPAD) U133.1(VEE) U133.17(EPAD) U135.45(GND_PAD) U136.3(GND) U137.3(GND) U138.3(GND) U139.B1(VSSAO0) U139.B4(VSSAO1) U139.B5(VSSAO2) U139.B7(VSSAO3) U139.B9(VSSA0) U139.C2(VSSA1) U139.C3(VSS0) U139.D1(VSSA2) U139.D3(VSSCOM) U139.D4(VSSD0) U139.D6(VSSA3) U139.D7(VSSA4) U139.E2(VSSA5) U139.E7(VSSDO0) U139.E8(VSSA6) U139.F3(VSSA7) U139.F4(VSSDO1) U139.F5(VSS1) U139.F6(VSSD1) U139.F8(VSSA8) U139.G4(VSS2) U139.G5(VSS3) U139.G6(VSS4) U139.G8(VSS5) U139.H3(VSSA9) U139.H4(VSS6) U139.H5(VSS7) U139.H6(VSS8) U139.H7(VSS9) U139.H8(VSS10) U139.H11(VSSD2) U139.J3(VSS11) U139.J4(VSS12) U139.J5(VSS13) U139.J6(VSS14) U139.J7(VSS15) U139.J8(VSS16) U139.K4(VSSAO4) U139.K7(VSSDO2) U139.L1(VSSA10) U139.L2(VSSA11) U139.L9(VSSD3) U139.M3(VSSAO5) U139.M7(VSSDO3) U140.4(GND) U143.4(GND) U144.4(GND) U145.3(GND) U148.3(GND) U149.10(GND) U150.12(GND) U151.2(GND) U152.2(GND) U154.A9(RGMII2RXD0/RMII2RXD0/GPIOV4) U154.AA18(PLLVSS2) U154.AA19(PLLVSS1) U154.B8(RGMIICK) U154.B9(RGMII2RXCTL/GPIOV3) U154.C8(RGMII2RXD3/RMII2RXER/GPIOV7) U154.C9(RGMII2RXCK/RMII2RCLK/GPIOV2) U154.D8(RGMII2RXD2/RMII2CRSDV/GPIOV6) U154.D11(RGMII1RXCTL/GPIOU5) U154.D21(PEAGND1) U154.D22(PEAGND2) U154.E8(RGMII2RXD1/RMII2RXD1/GPIOV5) U154.E10(RGMII1RXD3/RMII1RXER/GPIOV1) U154.J9(GND6) U154.J10(GND1) U154.J11(GND2) U154.J12(GND3) U154.J13(GND4) U154.J14(GND5) U154.K9(GND12) U154.K10(GND7) U154.K11(GND8) U154.K12(GND9) U154.K13(GND10) U154.K14(GND11) U154.L9(GND18) U154.L10(GND13) U154.L11(GND14) U154.L12(GND15) U154.L13(GND16) U154.L14(GND17) U154.M1(ADC9/GPIX1) U154.M2(ADC8/GPIX0) U154.M3(ADC7/GPIW7) U154.M9(GND24) U154.M10(GND19) U154.M11(GND20) U154.M12(GND21) U154.M13(GND22) U154.M14(GND23) U154.N4(ADC11/GPIX3) U154.N5(ADC10/GPIX2) U154.N9(GND30) U154.N10(GND25) U154.N11(GND26) U154.N12(GND27) U154.N13(GND28) U154.N14(GND29) U154.P4(ADCAVSS) U154.P9(GND36) U154.P10(GND31) U154.P11(GND32) U154.P12(GND33) U154.P13(GND34) U154.P14(GND35) U154.R5(DACAVSS) U154.V18(PLLVSS3) U154.Y19(USB2AVSS) U155.A9(VSS_1) U155.B1(VSSQ_1) U155.B3(VSS_2) U155.B9(VSSQ_2) U155.D1(VSSQ_3) U155.D8(VSSQ_4) U155.E1(VSS_3) U155.E2(VSSQ_5) U155.E8(VSSQ_6) U155.F9(VSSQ_7) U155.G1(VSSQ_8) U155.G8(VSS_4) U155.G9(VSSQ_9) U155.J2(VSS_5) U155.J8(VSS_6) U155.M1(VSS_7) U155.M9(VSS_8) U155.P1(VSS_9) U155.P9(VSS_10) U155.T1(VSS_11) U155.T9(VSS_12) U156.2(GND) U157.4(GND) U160.1(GND) U162.2(GND) U162.25(EPAD) U163.25(E_PAD) U164.3(GND) U165.2(GND) U168.6(GND) U170.2(GND) U171.3(GND) U172.2(GND) U173.2(GND) U174.6(GND) U175.6(GND) U176.10(GND) U177.2(GND) U178.7(GND) U179.4(GND) U180.2(GND) U181.2(GND) U182.2(GND) U183.2(GND) U185.4(GND) U194.3(GND) U196.3(GND) U197.3(GND) U198.2(GND) U200.2(GND) U201.2(GND) X1.2(GND) X2.2(GND) X3.2(GND) X4.2(GND) X5.2(GND) X7.3(GND) X8.2(GND) X11.7(GND) X13.2(GND) X14.3(GND) Y2.2(GND1) Y2.4(GND2) Y5.2 Y5.4
P1V0: C422.1 C467.1 C511.1 C512.1 C530.1 C563.1 C856.1 C875.1 C876.1 C885.1 C886.1 C946.1 C965.1 C974.1 C991.1 C2239.2 L4.1 L5.2 L7.2 L8.1 L9.2 L11.1 L21.1 L34.1 L35.2 L36.1 L37.2 L39.1 L42.2 L44.1 L45.2 L46.2 L48.2 PC151.1 PC152.1 PC153.1 PC154.1 PC156.1 PC157.1 PC158.1 PC159.1(A) PC160.1(A) PL7.2 PR175.1 PR177.1 PR185.1 R1054.2 R12439.2
P1V0_BOOT: PR186.1 PU7.7(BOOT)
P1V0_BP: PC147.2 PR182.1 PU7.28(BP)
P1V0_DDR: C21.1 C22.1 C23.1 C24.1 C34.1 C35.1 C36.1 C37.1 C47.1 C48.1 C49.1 C50.1 PR198.2 PR199.2 R1055.2 U1.AC11(DDRC_VDDC_1) U1.AC12(DDRC_VDDC_2) U1.AD10(DDRC_VDDC_3) U1.AF19(DDRB_VDDC_1) U1.AF25(DDRA_VDDC_1) U1.AF27(DDRA_VDDC_2) U1.AG18(DDRB_VDDC_2) U1.AG20(DDRB_VDDC_3) U1.AG24(DDRA_VDDC_3)
P1V0_DDR_AGND: PC184.2 PQ11.2(S) PR206.2 PR207.2 PR208.2 PR209.1 PU8.7(AGND)
P1V0_DDR_BST: PR197.1 PU8.10(BST)
P1V0_DDR_CS: PR208.1 PU8.4(CS)
P1V0_DDR_EN: PC172.1 PR330.2 PU8.5(EN)
P1V0_DDR_FB: PC183.2 PQ10.2(S) PR205.2 PR207.1 PR213.1 PU8.6(FB)
P1V0_DDR_FB_IN: PC183.1 PR201.2 PR205.1 PR210.1
P1V0_DDR_FB_IN_R: PQ10.3(D) PR210.2
P1V0_DDR_FB_R: PQ11.3(D) PR213.2
P1V0_DDR_MARGIN_HI: PC186.1 PQ11.1(G) PR214.1 PR215.1
P1V0_DDR_MARGIN_LO: PC185.1 PQ10.1(G) PR211.1 PR212.1
P1V0_DDR_MODE: PR203.2 PR206.1 PU8.12(MODE)
P1V0_DDR_PG: PR196.2 PR204.1 PR331.1 PU8.9(PGOOD)
P1V0_DDR_REF: PC184.1 PU8.8(TRK/REF)
