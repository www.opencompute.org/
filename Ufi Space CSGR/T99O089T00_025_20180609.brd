# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LED_MAC_SCLK_SR: length 37.3
  TOP w0.14: U1.AA30 v4(202.86,122.5) ; R53.1 v1(172.3,121.33)
  T05 w0.117: v4(202.86,122.5) 202.26,121.9 201.69,121.9 201.46,121.66 201.46,121.53 200.84,120.9 193.85,120.9 191.63,118.68 184.87,118.68 183.22,117.03 176.11,117.03 174.07,119.07 174.07,120.64 173.15,121.56 172.53,121.56 v1(172.3,121.33)
LED_MAC_SDAT: length 177
  TOP w0.14: v1(167.94,115.65) 169.52,117.22 R55.2
  T03 w0.117: v1(157.21,99.02) 157.21,98.55 155.75,97.09 155.75,89.71 153.23,87.2 153.23,79.19 v1(151.53,77.49)
  T14 w0.117: v1(151.53,77.49) 151.51,77.47 150.12,77.47 149.2,76.55 149.2,73.03 142,65.83 88.75,65.83 82.76,59.84 82.76,49.06 86.5,45.32 86.5,22.62 v1(84.08,20.2) ; v1(157.21,99.02) 157.21,100.84 166.43,110.06 166.43,110.51 166.48,110.56 166.48,110.85 166.5,110.87 166.5,114.2 v1(167.94,115.65)
  BOTTOM w0.14: U10.1 88.84,17.98 87.69,19.12 85.15,19.12 v1(84.08,20.2)
LED_MAC_SDAT_SR: length 44.1
  TOP w0.14: R55.1 v1(171.07,120.17) ; U1.AB30 v4(202.86,123.5)
  T05 w0.117: v1(171.07,120.17) 171.07,118.55 176.41,113.21 183.39,113.21 184.25,112.35 187.01,112.35 190.72,116.05 191.79,116.05 194.49,118.74 194.49,119.11 195.4,120.02 201.95,120.02 203.26,121.33 203.26,123.09 v4(202.86,123.5)
LED_NIC1_LINK_FE: length 16.4
  BOTTOM w0.14: R1259.2 C1674.1 83.84,43.07 82.36,41.59 82.36,36.41 79.29,33.34 OJ1.L1
LED_NIC1_LINK_GE: length 21.8
  BOTTOM w0.14: OJ1.L3 70.57,33.69 73.45,36.58 80.66,36.58 81.92,37.83 81.92,41.91 80.79,43.04 C1673.1 80.82,43.47 80.82,43.47 81.3,43.47 R1257.2
LED_PORT_BUF0_EN_N: length 9.7
  BOTTOM w0.14: R254.1 205.61,12.87 v2(205.61,14.42) 205.61,14.54 206.09,15.02 U20.1 206.88,11.66 207.54,10.99 207.54,9.39 U20.19
LED_PORT_BUF1_EN_N: length 10.5
  BOTTOM w0.14: v2(247.23,16.27) U22.1 248.61,13.17 249.26,12.52 U22.19 249.26,9.39 249.14,9.28 249.14,8.44 R263.1
LED_PORT_CLK0: length 4.3
  BOTTOM w0.14: U20.12 212.08,10.32 212.43,10.68 v2(214.04,10.68) 214.8,10.68 R258.1
LED_PORT_CLK1: length 4.5
  BOTTOM w0.14: U20.9 212.08,17.49 R259.1 213.03,17.88 213.36,17.55 v2(213.36,17.14)
LED_PORT_CLK2: length 3.1
  BOTTOM w0.14: R260.1 211.31,17.77 v2(211.31,16.71) 211.31,16.35 210.78,15.82 U20.7
LED_PORT_CLK3: length 3.2
  BOTTOM w0.14: U22.18 249.91,8.86 v2(249.91,8.86) 250.82,7.94 R264.1
LED_PORT_CLK4: length 3.2
  BOTTOM w0.14: U22.16 251.21,9.7 251.79,9.12 v2(251.79,8.86) 251.79,7.95 R265.1
LED_PORT_CLK5: length 3.1
  BOTTOM w0.14: U22.14 252.51,9.55 v2(253.11,8.95) R266.1
LED_PORT_CLK6: length 3.2
  BOTTOM w0.14: U22.12 253.81,9.58 v2(254.53,8.86) 254.53,7.93 R267.1
LED_PORT_CLK7: length 2.8
  BOTTOM w0.14: R268.1 v2(253.81,17.9) U22.9
LED_PORT_CLK8: length 2.8
  BOTTOM w0.14: U22.7 v2(252.51,17.93) R269.1
LED_PORT_CLK9: length 2.8
  BOTTOM w0.14: U22.5 v2(251.21,17.95) R270.1
LED_PORT_CLK10: length 2.8
  BOTTOM w0.14: R271.1 249.91,19 249.86,18.96 v2(249.86,17.95) 249.91,17.9 U22.3
LED_PORT_CLK_BUF0: length 6.1
  BOTTOM w0.14: U20.14 210.78,10.47 212.32,12 v2(214.01,12) 215.03,12 R257.1
LED_PORT_CLK_BUF1: length 3.2
  BOTTOM w0.14: R261.1 209.3,17.25 v2(209.3,16.71) 209.48,16.53 U20.5
LED_PORT_CLK_BUF2: length 3.2
  BOTTOM w0.14: R262.1 208.03,17.25 v2(208.03,16.84) 208.18,16.68 U20.3
LED_PORT_CLK_IN0: length 22.5
  BOTTOM w0.14: U20.8 211.43,13.37 208.83,10.77 U20.17 208.83,8.24 209.09,7.98 209.95,7.98 210.13,8.16 ; U20.15 210.13,8.16 ; 210.13,8.16 210.31,7.98 211.23,7.98 211.43,8.18 ; U20.13 211.43,8.18 ; 211.43,8.18 211.63,7.98 212.49,7.98 212.73,8.22 U20.11 214.41,9.38 v2(214.49,9.3) 215.97,9.3 216.63,9.96 216.63,11.42 R257.2
LED_PORT_CLK_IN1: length 57.4
  T18 w0.117: v1(208.66,19.54) 210.4,17.8 245.22,17.8 250.15,12.86 v1(250.15,12.73)
  BOTTOM w0.14: 251.87,11.65 252.01,11.79 252.97,11.79 253.16,11.61 ; 251.87,11.65 251.86,11.64 U22.15 ; 251.87,11.65 251.77,11.75 250.69,11.75 250.56,11.61 ; U22.13 253.16,11.61 ; 253.16,11.61 253.31,11.76 254.28,11.76 254.46,11.59 U22.11 255.34,10.63 256.18,11.48 v2(256.18,12.14) ; U22.17 250.56,11.61 ; 250.56,11.61 250.15,12.02 v1(250.15,12.73) ; R262.2 v1(208.66,19.54)
LED_PORT_CLK_IN2: length 50.4
  T18 w0.117: v1(248.03,18.08) 247.89,18.22 211.22,18.22 v1(209.93,19.51)
  BOTTOM w0.14: U22.4 250.56,15.23 ; 250.56,15.23 250.7,15.09 251.77,15.09 251.86,15.18 ; 250.56,15.23 250.56,15.2 250.44,15.09 249.4,15.09 249.26,15.24 U22.2 249.26,17.06 248.23,18.08 v1(248.03,18.08) ; U22.6 251.86,15.18 ; 251.86,15.18 252,15.04 252.93,15.04 253.16,15.26 U22.8 ; R261.2 v1(209.93,19.51)
LED_PORT_CLR_N0: length 5.7
  BOTTOM w0.14: R255.1 v2(205.19,8.38) 205.52,8.05 207.89,8.05 208.18,8.34 U20.18
LED_PORT_CLR_N1: length 8.1
  BOTTOM w0.14: U20.16 209.48,10.64 212.2,13.36 v2(213.96,13.36) 214.9,13.36 R256.1
LED_PORT_STAT_CLK0: length 129.6
  T07 w0.117: v1(95.84,9.41) 96.14,9.72 116.04,9.72 116.79,10.47 128.92,10.47 130.42,8.97 134.2,8.97 135.42,10.2 136.59,10.2 137.3,9.49 140.04,9.49 140.65,10.1 155.6,10.1 157.25,11.76 164.59,11.76 165.42,10.93 167.71,10.93 168.4,11.63 177.04,11.63 178.18,10.49 193.47,10.49 194.24,9.72 215.39,9.72 v1(215.82,10.15)
  BOTTOM w0.14: R258.2 215.94,10.27 v1(215.82,10.15) ; U10.8 94.31,11.49 v2(94.87,10.92) 95.84,9.95 v1(95.84,9.41)
LED_PORT_STAT_CLK1: length 93.3
  T07 w0.117: v1(214.55,14.14) 211.61,14.14 207.6,10.14 194.57,10.14 192.44,12.26 167.64,12.26 166.73,11.36 165.59,11.36 164.77,12.18 156.91,12.18 155.26,10.52 141.07,10.52 140.73,10.86 134.67,10.86 v1(133.4,9.59)
  BOTTOM w0.14: R259.2 213.78,18.7 v2(214.17,18.31) 214.55,17.93 v1(214.55,14.14) ; v1(133.4,9.59) 133.38,9.61 U12.8
LED_PORT_STAT_CLK2: length 54.6
  T18 w0.117: v1(166.88,15.53) 167.75,14.67 178.37,14.67 182.64,18.94 203.6,18.94 206.04,21.39 210.38,21.39 211.22,20.55 211.22,19.47 v1(211.2,19.46)
  BOTTOM w0.14: R260.2 v1(211.2,19.46) ; v1(166.88,15.53) 166.88,14.56 164.7,12.37 U14.8
LED_PORT_STAT_CLK3: length 79.9
  T05 w0.117: v1(246.56,9.55) 246.12,9.99 245.06,9.99 243.63,11.42 235.6,11.42 235.01,10.82 224.75,10.82 222.71,12.87 209.89,12.87 209.71,13.04 203.16,13.04 202.72,12.6 178.85,12.6 v1(177.82,13.63)
  BOTTOM w0.14: R264.2 250.29,6.43 247.32,6.43 246.91,6.84 246.91,9.2 v1(246.56,9.55) ; v1(177.82,13.63) 177.67,13.49 U16.8
LED_PORT_STAT_CLK4: length 33.6
  T07 w0.117: v1(245.69,10.57) 238,10.57 236.7,9.27 230.28,9.27 227.3,12.25 v1(225.25,12.25)
  BOTTOM w0.14: v1(245.69,10.57) 245.69,7.4 247.1,5.99 250.99,5.99 R265.2 ; v1(225.25,12.25) U18.8
LED_PORT_STAT_CLK5: length 30.8
  T07 w0.117: v1(236.35,9.84) 236.67,9.84 237.94,11.1 240.96,11.1 241.85,11.99 255.19,11.99 v1(256.69,10.49)
  BOTTOM w0.14: R266.2 253.8,6.27 255.5,6.27 257.05,7.82 257.05,10.13 v1(256.69,10.49) ; U19.8 236.24,9.94 v1(236.35,9.84)
LED_PORT_STAT_CLK6: length 20.6
  T07 w0.117: v1(256.01,9.45) 257.36,9.45 260.56,12.65 v1(269.32,12.65)
  BOTTOM w0.14: v1(269.32,12.65) 268.54,12.65 268.03,12.14 U21.8 ; v1(256.01,9.45) 256.01,8 v2(255.81,7.81) 254.97,6.96 R267.2
LED_PORT_STAT_CLK7: length 63.4
  T07 w0.117: v1(255.02,20.01) 258.01,20.01 263.27,14.75 269.01,14.75 271.74,17.48 283.92,17.48 287.79,21.35 289.49,21.35 294.88,26.73 302.01,26.73 303.02,27.74 v1(303.02,32.94)
  BOTTOM w0.14: R268.2 254.85,19.84 v1(255.02,20.01)
  BOTTOM w0.157: v1(303.02,32.94) 303.35,32.61 U13.8
LED_PORT_STAT_CLK8: length 63.7
  T07 w0.117: v1(253.07,20.3) 254.06,19.3 258.08,19.3 263.06,14.33 287.2,14.33 289.17,16.3 289.17,19.33 290.34,20.49 v1(290.83,20.49) 294.46,20.49 295.53,21.57 295.53,25.43 296.41,26.31 302.67,26.31 v1(303.02,25.96)
  BOTTOM w0.14: v1(253.07,20.3) 252.61,19.84 R269.2 ; U15.8 303.35,25.63 v1(303.02,25.96)
LED_PORT_STAT_CLR_N0: length 149.9
  T05 w0.117: v1(177.02,13.59) 177.02,13.64 177.58,14.2 178.54,14.2 179.27,13.47 v1(202.31,13.47) 209.89,13.47 210.07,13.29 223.72,13.29 v1(224.12,13.69)
  T07 w0.117: v1(177.02,13.59) 176.89,13.72 v1(163.18,13.72) 162.38,14.51 158.23,14.51 155.6,11.88 141.99,11.88 141.71,12.16 137.6,12.16 137.21,11.77 134.57,11.77 v1(133.28,10.47) 131.39,10.47 131.18,10.69 129.45,10.69 128.31,11.82 126.47,11.82 125.34,12.95 117.74,12.95 115.23,10.43 101.36,10.43 101.19,10.26 95.87,10.26 v1(94.82,9.22)
  BOTTOM w0.14: U18.9 223.68,13.24 v1(224.12,13.69) ; v1(133.28,10.47) 133.06,10.26 U12.9 ; R255.2 203.4,9.78 202.31,10.87 v1(202.31,13.47) ; U14.9 v1(163.18,13.72) ; U16.9 v1(177.02,13.59) ; U10.9 92.09,10.66 92.29,10.46 92.29,10.46 92.71,10.03 94,10.03 v1(94.82,9.22)
LED_PORT_STAT_CLR_N1: length 119.2
  T07 w0.117: v1(269.62,17.42) 271.01,18.8 277.87,18.8 279.04,19.97 285.78,19.97 287.65,21.84 289.38,21.84 294.7,27.15 301.44,27.15 v1(301.85,27.56)
  T16 w0.117: v1(236.48,10.59) 237.07,9.99 237.07,8.88 237.89,8.06 239.83,8.06 243.54,11.76 262.83,11.76 268.48,17.42 v1(269.62,17.42)
  BOTTOM w0.14: U21.9 267.38,12.96 269.62,15.21 v1(269.62,17.42) ; 303.02,31.93 301.85,30.76 v1(301.85,27.56) 301.85,25.93 302.81,24.98 U15.9 ; R256.2 217.2,11.87 217.2,8.6 218.53,7.28 225.27,7.28 v2(226.8,8.81) 227.46,9.47 233.43,9.47 233.81,9.85 233.81,10.23 234.17,10.59 U19.9 v1(236.48,10.59)
  BOTTOM w0.157: U13.9 303.06,31.96 303.02,31.93
LED_QSFP28_GRN_P1: length 27.8
  TOP w0.14: v1(294.1,50.18) 294.02,50.1 D41.1
  T05 w0.117: v1(296.98,28.58) 297.16,28.76 297.16,30.15 296.16,31.15 296.16,39.88 294.05,42 294.05,48.05 293.62,48.48 293.62,49.7 v1(294.1,50.18)
  BOTTOM w0.14: C781.1 v1(296.98,28.58) 297.25,28.86 297.25,29.67 297.59,30.01 U13.3
LED_QSFP28_GRN_P2: length 35.4
  TOP w0.14: v1(294.34,60.01) 294.04,60.31 D85.1
  T03 w0.117: v1(294.34,60.01) 294.14,60.01 293.14,59.01 293.14,54.46 295.06,52.54 v1(295.06,43.43) 295.06,41.08 297.69,38.45 297.69,31.93 v1(297.01,31.25)
  BOTTOM w0.14: U13.5 297.07,31.31 v1(297.01,31.25) 296.88,31.13 C783.1
LED_QSFP28_GRN_P3: length 35.7
  TOP w0.14: D87.1 310.39,60.63 309.97,61.05 v1(309.51,61.05)
  T07 w0.117: v1(309.51,61.05) 309.74,60.83 309.74,58.6 309.7,58.57 309.7,53.92 309.37,53.59 309.37,52.07 306.72,49.42 306.72,47.46 307.15,47.03 307.15,43.24 305.94,42.03 v1(305.94,34.04)
  BOTTOM w0.14: C785.1 306.68,33.55 306.2,34.04 v1(305.94,34.04) 305.51,33.6 305.51,31.64 305.18,31.31 U13.10
LED_QSFP28_GRN_P4: length 26.3
  TOP w0.14: D89.1 310.39,50.58 310.2,50.77 309.38,50.77 v1(308.68,50.08)
  T07 w0.117: v1(306.04,30.78) 306.78,31.52 306.78,40.43 308.44,42.09 308.44,44.88 309.4,45.85 309.4,49.36 v1(308.68,50.08)
  BOTTOM w0.14: C787.1 v1(306.04,30.78) 305.27,30.01 U13.12
LED_QSFP28_GRN_P5: length 15
  BOTTOM w0.14: U15.3 297.61,23.03 297.14,22.56 297.14,22.04 296.7,21.6 C799.1 295.88,18.13 v2(295.45,17.7) 293,15.25 293,13.46 293.32,13.13 294.21,13.13 294.41,12.93 D42.1
LED_QSFP28_GRN_P6: length 17.1
  T07 w0.117: v1(298.45,12.51) 299.21,13.27 299.21,14.48 297.59,16.1 297.59,23.68 v1(297.01,24.27)
  BOTTOM w0.14: C801.1 296.88,24.14 v1(297.01,24.27) 297.07,24.33 U15.5 ; v1(298.45,12.51) D86.1
LED_QSFP28_GRN_P7: length 21.7
  T07 w0.117: v1(303.15,13.72) 304,14.57 304,23.89 v1(305.94,25.83)
  BOTTOM w0.14: U15.10 305.18,24.33 305.37,24.51 305.37,25.26 v1(305.94,25.83) ; D88.1 306.71,12.07 306.45,11.81 305.05,11.81 v1(303.15,13.72)
  BOTTOM w0.157: C803.1 v1(305.94,25.83)
LED_QSFP28_GRN_P8: length 18.4
  T07 w0.117: v1(307.47,13.21) 307.72,13.21 308.48,13.97 v1(308.48,19.05) 308.48,21.28 306.56,23.2 306.54,23.2 v1(305.94,23.8)
  BOTTOM w0.14: U15.12 305.17,23.03 v1(305.94,23.8) C805.1 ; D90.1 309.4,12.11 309.2,11.91 308.08,11.91 307.47,12.52 v1(307.47,13.21)
LED_QSFP28_GRN_SR_P1: length 4.9
  TOP w0.14: D41.3 294.28,48.91 v1(294.36,48.99)
  BOTTOM w0.14: v1(294.36,48.99) 294.71,48.99 297.02,46.68 R602.2
LED_QSFP28_GRN_SR_P2: length 16.5
  TOP w0.14: v1(294.33,59.22) 294.23,59.12 D85.3
  BOTTOM w0.14: R1631.2 294.51,51.48 294.51,53.39 293.62,54.28 v2(293.62,56.16) 293.62,58.51 v1(294.33,59.22)
LED_QSFP28_GRN_SR_P3: length 17.9
  TOP w0.14: v1(308.86,59.53) 309.05,59.72 310.23,59.72 310.39,59.56 D87.3
  T14 w0.117: v1(304.64,47.77) 305.09,47.77 308.96,51.64 308.96,53.17 309.68,53.9 309.68,58.72 v1(308.86,59.53)
  BOTTOM w0.14: v1(304.64,47.77) R1635.2
LED_QSFP28_GRN_SR_P4: length 4.7
  TOP w0.14: v1(308.58,47.03) 309.26,47.03 310.39,48.16 D89.3
  BOTTOM w0.14: v1(308.58,47.03) 307.79,47.03 R1639.2
LED_QSFP28_GRN_SR_P5: length 6.5
  BOTTOM w0.14: R603.2 298.17,17.93 v2(296.15,15.91) 294.41,14.17 D42.3
LED_QSFP28_GRN_SR_P6: length 6.5
  BOTTOM w0.14: R1632.2 300.71,17.8 v2(299.89,16.98) 297.1,14.2 D86.3
LED_QSFP28_GRN_SR_P7: length 6.4
  BOTTOM w0.14: R1636.2 303.25,18.08 v2(305.12,16.2) 306.71,14.61 D88.3
LED_QSFP28_GRN_SR_P8: length 6.5
  BOTTOM w0.14: R1640.2 308.54,15.94 v2(308.56,15.94) 309.4,15.1 D90.3
LED_QSFP28_YEL_P1: length 25.9
  TOP w0.14: v1(292.07,50.18) 292.15,50.1 D41.2
  T05 w0.117: v1(292.07,50.18) 292.07,49.43 293.62,47.88 293.62,39.75 295.61,37.77 295.61,30.84 v1(296.59,29.85)
  BOTTOM w0.14: U13.4 297.4,30.66 v1(296.59,29.85) C782.1
LED_QSFP28_YEL_P2: length 35.5
  TOP w0.14: D85.2 291.73,60.31 v1(291.59,60.45)
  T03 w0.117: v1(296.96,32.49) 296.96,36.54 290.11,43.39 290.11,58.97 v1(291.59,60.45)
  BOTTOM w0.14: C784.1 295.97,32.49 v1(296.96,32.49) 297.49,31.96 U13.6
LED_QSFP28_YEL_P3: length 35.7
  TOP w0.14: v1(308.88,60.39) 308.96,60.31 D87.2
  T18 w0.117: v1(308.88,60.39) 309.81,59.46 309.81,53.95 309.4,53.54 309.4,51.95 306.83,49.38 306.83,45.34 307.08,45.09 307.08,35.7 v1(307.72,35.05)
  BOTTOM w0.14: v1(307.72,35.05) 308.23,34.54 308.23,32.89 307.85,32.51 306.96,32.51 306.68,32.23 C786.1 306.29,31.8 305.15,30.66 U13.11
LED_QSFP28_YEL_P4: length 38.6
  TOP w0.14: v1(307.52,48.67) 308.29,49.44 309.03,49.44 D89.2
  T05 w0.117: v1(305.94,29.77) 306.9,30.72 306.9,39.92 308.44,41.46 308.44,45.86 307.52,46.78 v1(307.52,48.67)
  T07 w0.117: v1(305.94,29.77) 304.29,28.12 304.29,25.02 300.53,21.26 v1(299.85,21.26)
  BOTTOM w0.14: v1(299.85,21.26) 299.38,21.73 U15.1 ; C788.1 v1(305.94,29.77) 305.54,29.36 U13.13
LED_QSFP28_YEL_P5: length 16.3
  T05 w0.117: v1(296.59,22.87) 296.04,22.31 296.04,18.67 v1(292.23,14.86)
  BOTTOM w0.14: D42.2 292.92,12.51 292.23,13.21 v1(292.23,14.86) ; U15.4 297.4,23.68 v1(296.59,22.87) C800.1
LED_QSFP28_YEL_P6: length 18.9
  T07 w0.117: v1(296.83,25.41) 295.95,24.54 295.95,16.47 v1(298.58,13.84)
  BOTTOM w0.14: v1(298.58,13.84) 297.86,13.13 296.59,13.13 296.4,12.94 D86.2 ; C802.1 v1(296.83,25.41) 297.26,24.98 U15.6
LED_QSFP28_YEL_P7: length 16.6
  T07 w0.117: v1(305.94,24.81) 305.18,24.05 305.18,14.22 v1(304.67,13.72)
  BOTTOM w0.14: D88.2 305.82,12.51 304.67,13.66 v1(304.67,13.72) ; U15.11 305.08,23.68 305.81,24.41 305.81,24.68 v1(305.94,24.81) C804.1
LED_QSFP28_YEL_P8: length 14.5
  T07 w0.117: v1(307.85,14.22) v1(307.85,20.19) 307.85,21.32 306.38,22.78 v1(305.94,22.78)
  BOTTOM w0.14: D90.2 308.32,12.51 308.12,12.72 308.12,13.96 v1(307.85,14.22) ; C806.1 v1(305.94,22.78) 305.54,22.38 U15.13
LED_QSFP28_YEL_SR_P1: length 5.8
  TOP w0.14: D41.4 291.89,48.91 v1(291.82,48.84)
  BOTTOM w0.14: v1(291.82,48.84) 293.35,48.84 R604.2
LED_QSFP28_YEL_SR_P2: length 17.1
  TOP w0.14: D85.4 291.55,59.12 v1(291.02,58.6)
  BOTTOM w0.14: v1(291.02,58.6) 291.02,56.33 v2(291.53,55.82) 294,53.35 294,51.36 298.29,47.07 R1633.2
LED_QSFP28_YEL_SR_P3: length 17.5
  TOP w0.14: v1(308.91,56.39) 309.69,57.17 D87.4
  T03 w0.117: v1(304.07,49.22) 306.78,49.22 309.24,51.68 309.24,53.46 309.63,53.84 309.63,55.68 v1(308.91,56.39)
  BOTTOM w0.14: R1637.2 303.37,48.53 v1(304.07,49.22)
LED_QSFP28_YEL_SR_P4: length 5.1
  TOP w0.14: v1(308.84,48.3) 308.84,48.73 309.02,48.91 D89.4
  BOTTOM w0.14: v1(308.84,48.3) 308.38,47.84 307.33,47.84 R1641.2
LED_QSFP28_YEL_SR_P5: length 6.3
  BOTTOM w0.14: D42.4 293.71,14.74 v2(294.67,15.7) 296.9,17.94 296.9,18.69 R605.2
LED_QSFP28_YEL_SR_P6: length 6.2
  BOTTOM w0.14: D86.4 296.4,14.89 v2(298.3,16.79) 299.44,17.93 R1634.2
LED_QSFP28_YEL_SR_P7: length 6.7
  BOTTOM w0.14: D88.4 306.01,14.04 v2(303.41,16.65) 301.98,18.08 R1638.2
LED_QSFP28_YEL_SR_P8: length 6.7
  BOTTOM w0.14: D90.4 308.7,14.36 v2(307.15,15.91) 304.52,18.54 R1642.2
LED_SFP+_GRN_P0: length 41
  TOP w0.14: D1.1 84.79,52.96 v1(84.91,52.83)
  T07 w0.117: v1(84.91,52.83) 83.97,51.89 83.97,47.52 85.88,45.6 85.88,35.17 87.83,33.22 87.83,21.71 88.85,20.7 v1(88.85,19.48)
  BOTTOM w0.14: U10.3 90.14,18.19 v1(88.85,19.48) 88.35,19.98 C755.1
LED_SFP+_GRN_P1: length 48.7
  TOP w0.14: v1(97.16,52.68) 97.02,52.82 D2.1
  T07 w0.117: v1(95.99,18.26) 95.1,19.15 91.93,19.15 v1(91.1,19.98)
  BOTTOM w0.14: C757.1 v1(91.1,19.98) 91.44,19.64 U10.5 ; v1(97.16,52.68) 97.28,52.68 97.74,52.22 97.74,51.76 96.44,50.46 96.44,44.02 96.32,43.9 96.32,29.37 96.44,29.25 96.44,27.64 97.28,26.8 97.31,26.8 99.53,24.58 99.53,23.62 98.81,22.91 98.29,22.91 97.72,22.33 97.72,19.99 v1(95.99,18.26)
LED_SFP+_GRN_P2: length 54.4
  TOP w0.14: D3.1 99.01,52.95 99.15,52.81 v1(99.34,52.81)
  T14 w0.117: v1(97.03,28.7) 97.54,28.7 98.3,27.94 98.3,26.33 99.94,24.7 99.94,20.48 92.93,13.47 v1(92.93,9.18)
  BOTTOM w0.14: C759.1 93.33,8.77 v1(92.93,9.18) 92.91,9.18 91.73,10.36 91.72,10.36 91.44,10.65 U10.10 ; v1(99.34,52.81) 98.7,52.81 v2(98.41,52.51) 98.22,52.33 98.22,51.72 96.89,50.39 96.89,44.02 96.76,43.9 96.76,29.56 96.89,29.43 96.89,28.84 v1(97.03,28.7)
LED_SFP+_GRN_P3: length 71.1
  TOP w0.14: v1(111.53,52.68) 111.53,52.72 111.27,52.97 D4.1
  T03 w0.117: v1(113.45,12.64) 111.18,10.37 99.79,10.37 99.44,10.71 90.68,10.71 v1(90.14,10.16)
  BOTTOM w0.14: C761.1 90.78,9.15 90.14,9.8 v1(90.14,10.16) U10.12 ; v1(111.53,52.68) 111.37,52.68 110.9,52.21 110.9,51.67 110.89,51.67 110.89,44.25 110.39,43.75 110.39,30.28 110.8,29.86 110.8,29.86 111.38,29.28 111.38,26.97 113.78,24.58 113.78,12.97 v1(113.45,12.64)
LED_SFP+_GRN_P4: length 68.8
  TOP w0.14: D5.1 113.26,52.73 113.62,52.38 113.62,52.36 v1(113.59,52.33)
  T07 w0.117: v1(117.3,15.74) 118.08,14.96 135.91,14.96 v1(136.5,15.56)
  BOTTOM w0.14: v1(113.59,52.33) 111.89,50.63 111.89,43.82 111.72,43.65 111.72,42.49 112.22,41.99 113.21,41.99 114.09,41.1 114.09,38.9 113.29,38.09 113.29,34.85 114.02,34.11 114.02,30.58 113.12,29.69 113.12,27.57 115.17,25.52 115.17,17.87 v1(117.3,15.74) ; v1(136.5,15.56) C773.1 135.63,12.63 136.07,12.18 137.67,12.18 U12.3
LED_SFP+_GRN_P5: length 63.4
  TOP w0.14: v1(125.61,52.73) 125.52,52.82 D6.1
  T14 w0.117: v1(139.37,11.42) 139.2,11.59 131.92,11.59 131.13,10.79 129.63,10.79 128.72,11.69 127.2,11.69 126.66,12.24 v1(124.64,12.24)
  BOTTOM w0.14: v1(125.61,52.73) 126.01,52.73 126.4,52.34 126.4,51.79 125.3,50.69 125.3,43.01 124.84,42.55 124.84,26.66 125.54,25.95 125.54,20.62 124.64,19.72 v1(124.64,12.24)
  BOTTOM w0.157: U12.5 138.86,10.91 v1(139.37,11.42) 140.45,12.5 C775.1
LED_SFP+_GRN_P6: length 54.5
  TOP w0.14: v1(127.84,52.81) 127.65,52.81 127.51,52.95 127.51,53.51 127.53,53.53 D7.1
  T14 w0.117: v1(130.07,10.12) 129,10.12 128.69,10.43 126.06,10.43 v1(125.38,11.12)
  BOTTOM w0.14: v1(127.84,52.81) 127.48,52.81 126.85,52.18 126.85,51.64 125.74,50.53 125.74,43.2 125.74,43.2 125.74,42.83 125.28,42.37 125.28,27.65 128.05,24.89 128.05,22.5 125.12,19.58 125.12,12.88 125.38,12.63 v1(125.38,11.12) ; C777.1 130.05,10.14 v1(130.07,10.12) 130.86,10.91 U12.10
LED_SFP+_GRN_P7: length 60.4
  TOP w0.14: v1(139.91,52.68) 139.77,52.82 D8.1
  T07 w0.117: v1(130.1,12.33) 130.24,12.19 137.04,12.19 137.43,12.58 141.41,12.58 v1(142.52,13.69)
  BOTTOM w0.14: U12.12 130.22,12.21 v1(130.1,12.33) 130.02,12.41 C779.1 ; v1(142.52,13.69) 142.67,13.84 142.67,14.13 142.65,14.15 142.65,20.03 139.83,22.86 139.83,28.18 142.88,31.23 142.88,33.03 140.95,34.95 140.95,37.65 139.74,38.86 139.51,39.09 139.51,42.36 139.74,42.59 139.74,51.01 140.49,51.76 140.49,52.19 140,52.68 v1(139.91,52.68)
LED_SFP+_GRN_P8: length 68.3
  TOP w0.14: v1(142.09,52.81) 141.78,53.12 D9.1
  T14 w0.117: v1(144.43,13.01) 145.3,13.88 155.46,13.88 156.97,15.39 156.97,17.08 v1(159.79,19.9)
  BOTTOM w0.14: v1(144.43,13.01) 143.1,14.34 143.1,23.94 140.65,26.38 140.65,28.38 143.32,31.05 143.32,33.22 141.4,35.14 141.4,37.83 139.95,39.27 139.95,42.18 140.18,42.41 140.18,50.94 142.06,52.81 v1(142.09,52.81) ; U14.3 161.23,18.01
  BOTTOM w0.157: C791.1 v1(159.79,19.9) 160.58,19.11 160.89,19.11 161.23,18.77 161.23,18.01
LED_SFP+_GRN_P9: length 49
  TOP w0.14: v1(154.16,52.68) 154.02,52.82 D10.1
  T03 w0.117: v1(162.46,19.76) 161.52,18.82 160.72,18.82 v1(157.99,16.1)
  BOTTOM w0.14: U14.5 162.53,18.01 ; v1(154.16,52.68) 154.5,52.68 154.78,52.4 154.78,51.79 153.96,50.96 153.96,39.53 154.1,39.39 154.1,33.98 153.78,33.66 153.78,21.28 157.99,17.07 v1(157.99,16.1)
  BOTTOM w0.157: 162.53,18.01 162.53,19.7 v1(162.46,19.76) 162.33,19.89 C793.1
LED_SFP+_GRN_P10: length 54.9
  TOP w0.14: D11.1 156.03,53.12 v1(156.34,52.81)
  T14 w0.117: v1(163.29,10.75) 163.29,12.05 160.73,14.61 159.77,14.61 v1(159.11,13.95)
  BOTTOM w0.14: U14.10 162.53,11.18 162.96,10.75 v1(163.29,10.75) 163.57,10.46 C795.1 ; v1(156.34,52.81) 156.31,52.81 154.4,50.91 154.4,42.14 155.08,41.46 155.72,41.46 156.53,40.65 156.53,35.78 154.23,33.48 154.23,21.46 158.75,16.94 158.75,16.28 159.11,15.92 v1(159.11,13.95)
LED_SFP+_GRN_P11: length 56.7
  TOP w0.14: D12.1 168.27,52.82 v1(168.41,52.68)
  T14 w0.117: v1(170.77,26.04) 171.96,24.85 171.96,20.95 167.77,16.76 167.77,11.9 165.76,9.89 162.02,9.89 161.23,10.69 v1(161.23,10.77)
  BOTTOM w0.14: C797.1 161.03,10.34 161.23,10.54 v1(161.23,10.77) U14.12 ; v1(170.77,26.04) 170.77,26.25 167.59,29.43 167.59,44.31 168.99,45.71 168.99,52.19 168.5,52.68 v1(168.41,52.68)
LED_SFP+_GRN_P12: length 42.6
  TOP w0.14: v1(170.59,52.81) 170.28,53.12 D13.1
  T18 w0.117: v1(171.22,23.32) 171.13,23.32 170.6,22.79 170.6,22.16 172.33,20.42 173.7,20.42 v1(174.42,19.7)
  BOTTOM w0.14: v1(171.22,23.32) 171.34,23.45 171.34,26.42 168.37,29.39 v2(168.37,29.89) 168.03,30.23 168.03,44.02 169.38,45.37 169.38,51.63 170.56,52.81 v1(170.59,52.81) ; 173.63,20.49 v1(174.42,19.7) 175.07,19.05 U16.3
  BOTTOM w0.157: 173.63,20.49 C809.1
LED_SFP+_GRN_P13: length 49.1
  TOP w0.14: v1(182.66,52.68) 182.52,52.82 D14.1
  T07 w0.117: v1(176.33,19.71) 177.57,19.71 v1(177.6,19.74)
  BOTTOM w0.14: v1(182.66,52.68) 182.75,52.68 183.24,52.19 183.24,45.52 182.18,44.46 182.18,42.05 182.63,41.6 182.63,27.08 185.03,24.68 185.03,20.28 182.14,17.39 v2(179.86,17.39) 179.83,17.39 177.6,19.63 v1(177.6,19.74) ; C811.1 176.33,20.56 v1(176.33,19.71) 176.37,19.67 U16.5
LED_SFP+_GRN_P14: length 57.8
  TOP w0.14: D15.1 184.46,53.45 184.46,52.66 184.51,52.6 184.51,52.59 184.82,52.28 184.83,52.28 v1(185.02,52.1)
  BOTTOM w0.14: v1(185.02,52.1) 184.13,51.21 184.13,45.26 183.07,44.2 183.07,42.59 183.81,41.85 184.74,41.85 185.68,40.91 185.68,38.87 184.2,37.39 184.2,34.4 185.63,32.97 185.63,31.51 183.7,29.58 183.7,27.26 185.92,25.04 185.92,15.17 181.2,10.46 178.79,10.46 178.01,9.68 C813.1 177.42,10.18 v2(176.94,10.66) 176.37,11.23 U16.10
LED_SFP+_GRN_P15: length 67.6
  TOP w0.14: v1(196.91,52.68) 196.77,52.82 D16.1
  T07 w0.117: v1(179.71,9.6) 175.77,9.6 v1(174.95,10.42)
  BOTTOM w0.14: C815.1 174.87,10.34 v1(174.95,10.42) 175.07,10.54 U16.12 ; v1(196.91,52.68) 197,52.68 198,51.68 198,43.89 196.75,42.64 196.75,38.92 199.86,35.81 199.86,20.84 188.62,9.6 v1(179.71,9.6)
LED_SFP+_GRN_P16: length 55.7
  TOP w0.14: D33.1 v1(202.54,48.27)
  T07 w0.117: v1(201.35,20.25) 202.66,21.56 215.16,21.56 217.52,19.2 220.18,19.2 v1(220.66,19.68)
  BOTTOM w0.14: v1(201.35,20.25) 200.3,21.29 200.3,36 199.98,36.32 199.72,36.58 199.72,46.65 201.35,48.27 v1(202.54,48.27) ; U18.3 221.73,18.75 220.81,19.68 v1(220.66,19.68) 220.29,20.05 C826.1
LED_SFP+_GRN_P17: length 39.7
  TOP w0.14: D34.1 v1(213.85,48.09)
  T05 w0.117: v1(222.83,19.82) 221.89,20.76 216.73,20.76 213.87,23.62 v1(213.87,24.13) 213.87,43.81 214.93,44.88 214.93,47.51 214.36,48.09 v1(213.85,48.09)
  BOTTOM w0.14: C828.1 v1(222.83,19.82) 222.83,19.36 223.03,19.16 U18.5
LED_SFP+_GRN_P18: length 47.8
  TOP w0.14: D35.1 217.3,48.29 v1(217.17,48.16)
  T16 w0.117: v1(217.17,48.16) 216.86,47.85 216.86,41.56 218.96,39.47 218.96,25.11 218.54,24.7 218.54,22.5 219.96,21.09 222.68,21.09 223.4,20.37 223.4,10.61 v1(223.65,10.36)
  BOTTOM w0.14: U18.10 223.03,11.33 223.65,10.71 v1(223.65,10.36) 224.07,9.93 C830.1 v2(225.34,9.55)
LED_SFP+_GRN_P19: length 50.1
  TOP w0.14: v1(225.03,46.2) 225.94,46.2 228.1,48.36 D36.1
  T16 w0.117: v1(225.03,46.2) 225.03,43.65 227.89,40.79 227.89,30.71 226.77,29.59 226.77,25.07 227.34,24.5 227.34,22.02 226.41,21.09 v1(226.41,14.75) 226.41,11.36 224.77,9.72 222.1,9.72 v1(221.53,10.29)
  BOTTOM w0.14: C832.1 v1(221.53,10.29) 221.73,10.49 U18.12
LED_SFP+_GRN_P20: length 51.1
  TOP w0.14: D37.1 231.21,48.44 v1(230.86,48.44)
  T16 w0.117: v1(230.86,48.44) 231.02,48.28 231.02,45.77 228.96,43.7 228.96,30.31 231.22,28.06 231.22,17.45 233.81,14.86 238.64,14.86 v1(240.03,16.25)
  BOTTOM w0.14: U19.3 239.05,12.54 238.51,13.09 238.51,14.86 238.85,15.2 C835.1 v1(240.03,16.25)
LED_SFP+_GRN_P21: length 55.6
  TOP w0.14: D38.1 242.35,48.24 243.4,47.19 243.4,44.61 v1(243.65,44.36)
  T16 w0.117: v1(237.67,9.35) 237.67,10.3 242.69,15.32 242.69,43.4 v1(243.65,44.36)
  BOTTOM w0.14: U19.5 240.72,11.26 238.77,11.26 237.67,10.16 v1(237.67,9.35) 237.67,8.59 238.89,7.37 241.3,7.37 243.29,9.35 243.29,9.96 C837.1
LED_SFP+_GRN_P22: length 55.5
  TOP w0.14: D39.1 245.34,48.79 v1(245.08,49.05)
  T07 w0.117: v1(243.69,12.65) 241.91,12.65 240.82,11.56 234.5,11.56 v1(233.17,10.23)
  T16 w0.117: v1(243.69,12.65) 245.76,14.72 245.76,23.85 248.18,26.27 248.18,29.87 245.3,32.74 245.3,39.12 245.55,39.36 245.76,39.57 245.76,43.84 245.49,44.11 245.49,48.64 v1(245.08,49.05)
  BOTTOM w0.14: C839.1 233.13,10.19 v1(233.17,10.23) 233.38,10.43 233.38,10.44 234.17,11.24 U19.10
LED_SFP+_GRN_P23: length 56.4
  TOP w0.14: v1(253.07,45.51) 253.85,45.51 256.6,48.26 D40.1
  T07 w0.117: v1(247.48,14.36) 247.25,14.13 242,14.13 240.42,12.56 233.72,12.56 v1(233.5,12.77)
  T16 w0.117: v1(253.07,45.51) 253.07,43.64 249.14,39.71 249.14,16.02 v1(247.48,14.36)
  BOTTOM w0.14: C841.1 233.04,12.74 233.07,12.77 v1(233.5,12.77) 233.5,12.7 233.67,12.54 U19.12
LED_SFP+_GRN_P24: length 39.8
  TOP w0.14: v1(262.49,42.88) 263.3,43.69 263.3,45.77 261.47,47.6 261.47,49.03 261.1,49.4 260.26,49.4 260.05,49.19 D17.1
  T05 w0.117: v1(262.49,42.88) 260.68,41.06 260.68,36.89 261.15,36.42 261.15,34.82 260.65,34.32 260.65,29.25 261.15,28.75 261.15,22.06 262.96,20.25 v1(262.96,19.52)
  BOTTOM w0.14: U21.3 265.43,17.76 265.02,18.16 264.1,18.16 v2(263.87,18.4) 263.87,18.89 264.03,19.05 264.03,19.47 C845.1 v1(262.96,19.52)
LED_SFP+_GRN_P25: length 61.8
  TOP w0.14: D18.1 270.85,49.23 271.04,49.41 271.92,49.41 v1(272.24,49.09)
  T18 w0.117: v1(272.24,49.09) 273.1,48.23 275.09,48.23 277.33,45.98 280.61,45.98 286.09,40.5 v1(286.09,22.23) 286.09,21.45 284.6,19.97 278.61,19.97 277.35,18.71 v1(266.73,18.71)
  BOTTOM w0.14: U21.5 v1(266.73,18.71) 266.73,19.32 C847.1
LED_SFP+_GRN_P26: length 49.8
  TOP w0.14: D19.1 v1(273.67,48.79)
  T05 w0.14: v1(270.55,12.39) 270.55,44.89 269.53,45.9 269.53,46.88 270.7,48.05 272.93,48.05 v1(273.67,48.79)
  BOTTOM w0.14: v1(270.55,12.39) v2(270.55,10.61) 270.55,10.04 268.7,8.2 C849.1 267.77,9.16 266.73,10.2 U21.10
LED_SFP+_GRN_P27: length 68
  TOP w0.14: D20.1 v1(285.1,48.11)
  T14 w0.117: v1(265.19,9.32) 265.95,10.08 267.41,10.08 267.95,9.54 278.14,9.54 279.42,8.26 281.43,8.26 281.94,8.76 281.94,9.32 289.18,16.56 289.18,23.19 v1(289.99,24)
  T18 w0.117: v1(285.1,48.11) 287.66,48.11 288.92,46.85 288.92,25.08 v1(289.99,24)
  BOTTOM w0.14: C851.1 265.19,8.24 v1(265.19,9.32) 265.43,9.56 U21.12
LED_SFP+_GRN_SR_P0: length 4.5
  TOP w0.14: v1(84.94,55.88) 84.79,55.73 D1.3
  BOTTOM w0.14: R317.2 83.08,57.74 v1(84.94,55.88)
LED_SFP+_GRN_SR_P1: length 18.8
  TOP w0.14: v1(97.2,55.43) 97.16,55.43 97.02,55.29 D2.3
  T07 w0.117: v1(97.2,55.43) 96.64,54.87 96.64,51.81 97.41,51.05 97.41,50.34 97.58,50.16 97.58,41.86 97.92,41.53 v1(99.67,41.53)
  BOTTOM w0.14: R324.2 99.55,42.62 99.55,42.32 99.67,42.2 v1(99.67,41.53)
LED_SFP+_GRN_SR_P2: length 16.7
  TOP w0.14: v1(99.7,56.31) 99.01,55.63 D3.3
  T07 w0.117: v1(98.43,43.94) 98.17,44.2 98.17,54.79 v1(99.7,56.31)
  BOTTOM w0.14: v1(98.43,43.94) 98.43,44.04 R331.2
LED_SFP+_GRN_SR_P3: length 18
  TOP w0.14: D4.3 111.27,55.1 111.12,55.24 v1(110.62,55.24)
  T07 w0.117: v1(114.17,42.16) 113.83,42.5 111.89,42.5 111.12,43.27 111.12,51.55 111.01,51.67 111.01,54.86 v1(110.62,55.24)
  BOTTOM w0.14: v1(114.17,42.16) 113.57,42.77 R338.2
LED_SFP+_GRN_SR_P4: length 16.9
  TOP w0.14: D5.3 113.26,56.24 v1(113.67,56.64)
  T07 w0.117: v1(112.48,44.21) 112.01,44.68 112.01,51.12 112.41,51.52 112.41,55.39 v1(113.67,56.64)
  BOTTOM w0.14: R345.2 113.39,45.12 v1(112.48,44.21)
LED_SFP+_GRN_SR_P5: length 14.9
  TOP w0.14: v1(124.84,54.61) 124.97,54.74 125.51,54.74 D6.3
  T07 w0.117: v1(124.84,54.61) 124.84,44.63 v1(126.93,42.55)
  BOTTOM w0.14: R352.2 127.32,42.55 v1(126.93,42.55)
LED_SFP+_GRN_SR_P6: length 16.5
  TOP w0.14: v1(128.4,56.26) 128.14,56.26 127.51,55.63 127.51,54.75 D7.3
  T07 w0.117: v1(126.9,44.16) 126.77,44.3 126.77,54.89 128.14,56.26 v1(128.4,56.26)
  BOTTOM w0.14: R359.2 v1(126.9,44.16)
LED_SFP+_GRN_SR_P7: length 15
  TOP w0.14: D8.3 v1(139.19,54.73)
  T07 w0.117: v1(139.19,54.73) 139.19,54.73 139.19,44.64 v1(141.31,42.52)
  BOTTOM w0.14: R366.2 141.66,42.52 v1(141.31,42.52)
LED_SFP+_GRN_SR_P8: length 16.8
  TOP w0.14: D9.3 141.78,55.65 142.39,56.26 v1(142.75,56.26)
  T07 w0.117: v1(142.75,56.26) 142.39,56.26 141.02,54.89 141.02,44.41 v1(141.24,44.19)
  BOTTOM w0.14: R373.2 142.29,45.24 v1(141.24,44.19)
LED_SFP+_GRN_SR_P9: length 15
  TOP w0.14: v1(153.27,54.74) 153.29,54.74 153.3,54.73 D10.3
  T05 w0.117: v1(153.27,54.74) 153.29,54.74 153.64,54.38 153.64,51.81 154.31,51.14 154.31,43.7 155.36,42.65 v1(155.45,42.65)
  BOTTOM w0.14: v1(155.45,42.65) 155.79,42.65 156.27,43.13 R380.2
LED_SFP+_GRN_SR_P10: length 15
  TOP w0.14: D11.3 156.03,54.73 156.03,55.32 156.46,55.75 v1(156.59,55.75)
  T05 w0.117: v1(155.4,44.15) 155.27,44.28 155.27,54.56 156.46,55.75 v1(156.59,55.75)
  BOTTOM w0.14: R387.2 v1(155.4,44.15)
LED_SFP+_GRN_SR_P11: length 19.1
  TOP w0.14: v1(168.45,55.43) 168.41,55.43 168.27,55.29 D12.3
  T18 w0.117: v1(168.45,55.43) 167.74,54.72 167.74,43.22 168.92,42.03 v1(170.13,42.03)
  BOTTOM w0.14: v1(170.13,42.03) 170.17,42.03 170.18,42.04 170.56,42.04 170.85,42.32 R394.2 ; v1(168.45,55.43) 168.84,55.03 v2(168.84,54.48)
LED_SFP+_GRN_SR_P12: length 16.8
  TOP w0.14: D13.3 170.28,55.65 v1(170.95,56.31)
  T18 w0.117: v1(169.59,44.03) 169.16,44.45 169.16,50.42 169.54,50.8 169.54,54.91 v1(170.95,56.31)
  BOTTOM w0.14: R401.2 169.59,44.03 v1(169.59,44.03)
LED_SFP+_GRN_SR_P13: length 17.7
  TOP w0.14: D14.3 182.52,55.22 v1(182.37,55.37)
  T18 w0.117: v1(182.37,55.37) 182.12,55.12 182.12,42.92 183.13,41.91 184.53,41.91 v1(185.04,42.42)
  BOTTOM w0.14: v1(185.04,42.42) 184.99,42.46 R408.2
LED_SFP+_GRN_SR_P14: length 16.3
  TOP w0.14: D15.3 184.53,54.73 184.53,55.65 185.02,56.13 v1(185.29,56.13)
  T18 w0.117: v1(185.29,56.13) 185.02,56.13 183.71,54.83 183.71,44.97 183.81,44.88 183.81,44.37 v1(183.99,44.19)
  BOTTOM w0.14: v1(183.99,44.19) 184.99,45.19 R415.2
LED_SFP+_GRN_SR_P15: length 3.2
  TOP w0.14: v1(196.22,55.24) 196.34,55.24 196.77,54.81 D16.3
  BOTTOM w0.14: v1(196.22,55.24) 196.22,54.94 v2(196.78,54.37) 197.2,53.95 R422.2
LED_SFP+_GRN_SR_P16: length 11.5
  TOP w0.14: D33.3 203.05,50.69 202.73,51.02 v1(202.73,51.94)
  BOTTOM w0.14: v1(202.73,51.94) 203,52.21 203,58.03 201.99,59.04 v2(201.99,59.6) 201.99,60.71 R541.2
LED_SFP+_GRN_SR_P17: length 18.4
  TOP w0.14: D34.3 213.85,50.67 v1(214.54,51.36)
  T03 w0.117: v1(214.54,51.36) 214.54,48.37 214.87,48.05 214.87,45.42 214.52,45.07 v1(214.52,42.45)
  BOTTOM w0.14: R548.2 215.22,38.4 214.5,39.12 214.5,42.43 v1(214.52,42.45)
LED_SFP+_GRN_SR_P18: length 17
  TOP w0.14: v1(217.59,51.87) 217.13,51.41 217.13,50.68 217.3,50.51 D35.3
  T03 w0.117: v1(215.78,43.96) 215.87,44.05 217.66,44.05 219.46,45.85 219.46,46.74 218.57,47.62 218.57,51.11 217.81,51.87 v1(217.59,51.87)
  BOTTOM w0.14: v1(215.78,43.96) 215.78,43.56 R555.2
LED_SFP+_GRN_SR_P19: length 19.4
  TOP w0.14: D36.3 228.1,51.19 v1(226.89,52.4)
  T05 w0.117: v1(226.89,52.4) 228.33,50.96 228.33,48.57 229.12,47.79 229.12,42.93 v1(229.65,42.39)
  BOTTOM w0.14: R562.2 229.9,38.7 228.98,39.62 228.98,41.72 v1(229.65,42.39)
LED_SFP+_GRN_SR_P20: length 17.3
  TOP w0.14: D37.3 231.55,51 v1(230.87,51.68)
  T05 w0.117: v1(232.44,40.76) 232.44,42.38 231.13,43.7 231.13,47.82 231.58,48.27 231.58,50.97 v1(230.87,51.68)
  BOTTOM w0.14: v1(232.44,40.76) 232.44,39.16 v2(232.28,38.99) 231.89,38.61 R569.2
LED_SFP+_GRN_SR_P21: length 16.7
  TOP w0.14: D38.3 242.35,50.67 v1(242.61,50.93)
  T14 w0.117: v1(242.61,50.93) 242.61,48.67 243.53,47.75 243.53,46.22 244.63,45.12 v1(244.63,42.83)
  BOTTOM w0.14: R576.2 244.68,37.86 243.33,39.21 243.33,41.53 v1(244.63,42.83)
LED_SFP+_GRN_SR_P22: length 18.5
  TOP w0.14: D39.3 245.8,50.49 245.56,50.73 v1(245.56,51.31)
  T03 w0.117: v1(245.56,51.31) 245.56,50.73 247.02,49.27 247.02,47.67 247.82,46.87 247.82,45.9 246.87,44.95 246.87,39.3 v1(247.34,38.83)
  BOTTOM w0.14: R583.2 v1(247.34,38.83) 246.72,39.45 v2(246.72,40.93)
LED_SFP+_GRN_SR_P23: length 17.4
  TOP w0.14: v1(257.05,51.15) 256.6,50.7 D40.3
  T07 w0.117: v1(257.05,51.15) 257.62,50.58 257.62,44.64 v1(259.16,43.1)
  BOTTOM w0.14: v1(259.16,43.1) 258.53,43.1 v2(257.82,42.39) 257.55,42.12 257.55,39.63 R590.2
LED_SFP+_GRN_SR_P24: length 18
  TOP w0.14: D17.3 260.05,51.17 v1(259.53,51.7)
  T03 w0.117: v1(259.53,51.7) 258.68,51.7 257.62,50.64 257.62,46.63 v1(259.21,45.04)
  BOTTOM w0.14: v1(259.21,45.04) 260.62,43.62 v2(260.62,43.31) 260.62,39.42 R429.2
LED_SFP+_GRN_SR_P25: length 16.5
  TOP w0.14: D18.3 270.85,50.68 v1(271.42,51.25)
  T03 w0.117: v1(272.24,43.17) 272.56,43.49 272.56,45.81 271.87,46.5 271.87,48.51 271.42,48.95 v1(271.42,51.25)
  BOTTOM w0.14: v1(272.24,43.17) 271.14,42.07 271.14,38.22 R437.2
LED_SFP+_GRN_SR_P26: length 14.7
  TOP w0.14: v1(274.62,43.44) 274.62,44.18 276.43,45.99 276.43,46.88 275.75,47.56 275.75,49.05 275.38,49.41 274.44,49.41 274.3,49.55 D19.3
  BOTTOM w0.14: R443.2 274.03,37.98 274.03,41.63 v2(274.39,41.99) 274.62,42.23 v1(274.62,43.44)
LED_SFP+_GRN_SR_P27: length 16.2
  TOP w0.14: v1(285.55,51.75) 285.1,51.3 D20.3
  BOTTOM w0.14: v1(285.55,51.75) 286.22,52.42 288.3,52.42 289.45,51.27 v2(289.45,48.62) 289.45,46.01 291.37,44.1 R450.2
LED_SFP+_YEL_P0: length 46.8
  TOP w0.14: D1.2 85.49,53.35 85.65,53.19 v1(85.65,52.83)
  T07 w0.117: v1(85.65,52.83) 85.65,53.24 85.48,53.4 84.57,53.4 82.72,51.54 82.72,37.74 87.41,33.05 87.41,24.23 86.62,23.44 86.62,21.92 87.89,20.65 87.89,19.5 88.48,18.91 89.86,18.91 v1(90.33,19.38)
  BOTTOM w0.14: C756.1 89.72,19.98 v1(90.33,19.38) 90.79,18.92 U10.4
LED_SFP+_YEL_P1: length 43.4
  TOP w0.14: v1(97.21,51.97) 97.72,52.48 D2.2
  T07 w0.117: v1(95.84,19.61) 92.84,19.61 v1(92.47,19.98)
  BOTTOM w0.14: v1(95.84,19.61) 96.32,19.61 97.2,20.49 97.2,26.11 96,27.31 96,29.06 95.87,29.19 95.87,43.9 96,44.02 96,50.76 v1(97.21,51.97) ; C758.1 v1(92.47,19.98) 92.09,19.59 U10.6
LED_SFP+_YEL_P2: length 51.7
  TOP w0.14: v1(99.34,52.1) 99.39,52.15 99.49,52.15 99.9,52.56 99.9,53 99.71,53.19 D3.2
  T14 w0.117: v1(91.41,9.59) 91.41,12.55 97.28,18.42 97.28,23.28 97.06,23.51 v1(97.06,27.84)
  BOTTOM w0.14: v1(97.06,27.84) 97.61,28.39 97.61,29.34 97.21,29.74 97.21,49.96 v1(99.34,52.1) ; C760.1 92.06,8.95 v1(91.41,9.59) 90.79,10.22 U10.11
LED_SFP+_YEL_P3: length 99.9
  TOP w0.14: v1(111.52,51.88) 111.97,52.33 111.97,52.35 112.05,52.43 112.05,52.94 111.97,53.01 D4.2
  T03 w0.117: v1(114.81,12.01) 113.54,12.01 111.48,9.94 99.61,9.94 99.27,10.29 91.16,10.29 90.47,9.59 89.96,9.59 89.86,9.5 v1(89.51,9.5)
  T14 w0.117: v1(139.02,13.69) 138.8,13.91 116.71,13.91 v1(114.81,12.01)
  BOTTOM w0.14: C762.1 v1(89.51,9.5) 89.49,9.53 U10.13 ; U12.1 138.83,13.51 v1(139.02,13.69) ; v1(114.81,12.01) 114.22,12.6 114.22,24.76 111.89,27.09 111.89,29.41 111.25,30.05 110.83,30.47 110.83,43.78 111.19,44.13 111.19,51.54 v1(111.52,51.88)
LED_SFP+_YEL_P4: length 68.8
  TOP w0.14: v1(114.05,52.87) 114.05,52.89 113.96,52.97 D5.2
  T07 w0.117: v1(133.74,15.56) 130.52,15.56 128.74,17.34 125.61,17.34 123.71,15.44 118.75,15.44 117.73,16.45 116.13,16.45 v1(115.53,15.85)
  BOTTOM w0.14: v1(133.74,15.56) C774.1 134.57,12.78 135.78,11.56 U12.4 ; v1(115.53,15.85) 114.73,16.65 114.73,25.33 112.33,27.73 112.33,29.59 111.28,30.65 111.28,43.71 111.48,43.91 111.48,50.81 112.43,51.76 112.43,52.15 113.15,52.87 v1(114.05,52.87)
LED_SFP+_YEL_P5: length 66.2
  TOP w0.14: D6.2 126.22,52.48 v1(125.75,52.01)
  T14 w0.117: v1(139.37,10.05) 138.26,11.17 132.1,11.17 130.28,9.35 125.52,9.35 v1(123.51,11.36)
  BOTTOM w0.14: v1(125.75,52.01) 124.85,51.12 124.85,43.2 124.4,42.74 124.4,26.47 125.1,25.77 125.1,20.83 124.04,19.77 124.04,11.89 v1(123.51,11.36)
  BOTTOM w0.157: C776.1 140.55,11.23 v1(139.37,10.05) 139.23,10.05 139.03,10.26 U12.6
LED_SFP+_YEL_P6: length 53.1
  TOP w0.14: D7.2 128.23,53.53 128.21,53.51 128.21,53.19 128.4,53 128.4,52.56 127.99,52.15 127.89,52.15 v1(127.84,52.1)
  T18 w0.117: v1(130.18,11.39) 129.82,11.75 127.27,11.75 v1(126.72,11.2)
  BOTTOM w0.14: C778.1 129.93,11.14 v1(130.18,11.39) 130.35,11.56 U12.11 ; v1(126.72,11.2) 126.72,12.11 125.57,13.27 125.57,19.39 128.49,22.32 128.49,25.07 125.73,27.83 125.73,42.18 126.31,42.77 126.31,50.49 127.84,52.02 v1(127.84,52.1)
LED_SFP+_YEL_P7: length 80
  TOP w0.14: D8.2 140.47,52.48 v1(139.96,51.97)
  T07 w0.117: v1(159.77,16.71) 158.02,14.96 141.56,14.96 v1(140.29,13.69) 139.72,13.13 137.9,13.13 137.69,13.34 v1(130.23,13.34)
  BOTTOM w0.14: v1(140.29,13.69) 139.47,14.51 139.47,16.71 140.67,17.9 140.67,21.23 139.32,22.58 139.32,28.3 142.43,31.41 142.43,32.85 140.51,34.77 140.51,37.46 139.29,38.68 139.06,38.91 139.06,42.55 139.29,42.78 139.29,51.31 v1(139.96,51.97) ; U12.13 130.71,12.86 v1(130.23,13.34) 129.89,13.68 C780.1
  BOTTOM w0.157: U14.1 159.93,16.87 v1(159.77,16.71)
LED_SFP+_YEL_P8: length 69.4
  TOP w0.14: D9.2 142.48,53.16 142.7,52.95 142.7,52.45 142.34,52.1 v1(142.09,52.1)
  T14 w0.117: v1(161.06,19.82) 158.75,17.51 158.75,14.84 156.84,12.92 v1(146.38,12.92)
  BOTTOM w0.14: U14.4 161.88,18.01 ; v1(146.38,12.92) 143.54,15.77 143.54,24.12 141.15,26.51 141.15,28.25 143.76,30.86 143.76,33.4 141.84,35.32 141.84,38.68 142.57,39.41 142.57,40.83 141.8,41.61 141.14,41.61 140.66,42.09 140.66,50.66 v1(142.09,52.1)
  BOTTOM w0.157: C792.1 161.06,19.82 v1(161.06,19.82) 161.88,19 161.88,18.01
LED_SFP+_YEL_P9: length 54.4
  TOP w0.14: D10.2 154.72,52.48 v1(154.21,51.97)
  T03 w0.117: v1(163.81,19.87) 163.81,19.2 160.14,15.53 158.36,15.53 v1(156.87,14.04)
  BOTTOM w0.14: v1(156.87,14.04) 156.87,17.56 153.4,21.04 153.34,21.09 153.34,33.85 153.66,34.16 153.66,39.2 153.51,39.35 153.51,51.27 v1(154.21,51.97) ; U14.6 163.18,18.01
  BOTTOM w0.157: C794.1 163.6,20.07 v1(163.81,19.87) 163.18,19.24 163.18,18.01
LED_SFP+_YEL_P10: length 51.4
  TOP w0.14: v1(156.34,52.1) 156.59,52.1 156.95,52.45 156.95,52.95 156.73,53.16 D11.2
  T14 w0.117: v1(162.26,10.46) 162.26,11.86 v1(160.17,13.95)
  BOTTOM w0.14: v1(156.34,52.1) 154.85,50.6 154.85,42.32 155.25,41.92 155.9,41.92 156.97,40.84 v2(156.97,29.97) 156.97,29.64 156.1,28.77 156.1,27.54 156.53,27.11 156.53,22.13 156.31,21.92 156.31,20.32 156.68,19.96 159.19,17.45 159.19,16.47 160.17,15.48 v1(160.17,13.95) ; C796.1 162.3,10.25 162.26,10.29 v1(162.26,10.46) 162.26,10.82 161.88,11.2 U14.11
LED_SFP+_YEL_P11: length 63.6
  TOP w0.14: v1(168.46,51.97) 168.97,52.48 D12.2
  T14 w0.117: v1(172.03,16.23) 172.03,15.57 165.94,9.47 161.17,9.47 v1(160.09,10.55)
  T18 w0.117: v1(172.03,16.23) 172.03,16.38 170.58,17.84 170.58,20.82 168.12,23.27 168.12,25.18 169.11,26.16 v1(169.9,26.16)
  BOTTOM w0.14: U16.1 173.77,17.02 172.98,16.23 v1(172.03,16.23) ; U14.13 160.58,11.2 160.09,10.72 v1(160.09,10.55) 159.76,10.21 C798.1 ; v1(168.46,51.97) 168.33,51.84 168.33,45.76 167.15,44.58 167.15,28.91 v1(169.9,26.16)
LED_SFP+_YEL_P12: length 42.4
  TOP w0.14: D13.2 170.98,53.16 171.2,52.95 171.2,52.45 170.84,52.1 v1(170.59,52.1)
  T18 w0.117: v1(175.36,19.66) 174,21.02 172.76,21.02 v1(171.25,22.53)
  BOTTOM w0.14: v1(171.25,22.53) 171.8,23.08 171.8,26.6 169.71,28.68 v2(169.71,29.32) 169.71,30.13 168.48,31.37 168.48,43.94 169.88,45.33 169.88,51.38 v1(170.59,52.1) ; U16.4 175.72,19.31 v1(175.36,19.66) 174.9,20.12 174.9,20.23
  BOTTOM w0.157: 174.9,20.23 C810.1
LED_SFP+_YEL_P13: length 46.6
  TOP w0.14: v1(182.71,51.97) 183.22,52.48 D14.2
  BOTTOM w0.14: U16.6 177.02,20.29 C812.1 177.87,20.71 178.27,20.31 178.27,19.83 179.75,18.36 v2(181.05,18.36) 182.48,18.36 183.99,19.87 183.99,22.27 182.61,23.65 182.61,26.17 182.18,26.61 182.18,41.31 181.74,41.76 181.74,44.7 182.71,45.68 v1(182.71,51.97)
LED_SFP+_YEL_P14: length 58.2
  TOP w0.14: v1(185.04,52.81) 185.23,53 D15.2
  T14 w0.117: v1(179.1,11.35) 176.74,11.35 v1(175.89,10.5)
  BOTTOM w0.14: v1(179.1,11.35) 181.46,11.35 185.47,15.36 185.47,24.86 183.25,27.08 183.25,29.76 185.19,31.7 185.19,32.79 183.76,34.22 183.76,37.65 185.24,39.13 185.24,40.72 184.55,41.41 183.61,41.41 182.63,42.39 182.63,44.34 183.59,45.3 183.59,51.41 184.98,52.81 v1(185.04,52.81) ; C814.1 176.14,10.24 v1(175.89,10.5) 175.72,10.67 U16.11
LED_SFP+_YEL_P15: length 97
  TOP w0.14: v1(196.96,51.97) 197.47,52.48 D16.2
  T07 w0.117: v1(220.18,15.21) 219.67,14.71 207.29,14.71 204.76,17.24 v1(195.25,17.24)
  T14 w0.117: v1(187.3,11.31) 186.67,11.94 175.25,11.94 v1(173.79,10.47)
  BOTTOM w0.14: v1(220.18,15.21) 220.43,15.46 U18.1 ; v1(196.96,51.97) 197.49,51.44 197.49,44.34 196.3,43.15 196.3,38.6 199.41,35.49 199.41,21.4 v1(195.25,17.24) 189.32,11.31 v1(187.3,11.31) ; U16.13 174.42,10.89 174,10.47 v1(173.79,10.47) 173.79,10.39 173.6,10.21 C816.1
LED_SFP+_YEL_P16: length 54.8
  TOP w0.14: v1(203.69,48.16) 203.75,48.22 D33.2
  T07 w0.117: v1(202.82,20.19) 203.77,21.14 214.96,21.14 217.32,18.78 220.71,18.78 221.59,19.66 v1(221.64,19.66)
  BOTTOM w0.14: U18.4 222.38,18.93 v1(221.64,19.66) 221.56,19.74 C827.1 ; v1(203.69,48.16) 202.65,47.12 202.65,43.5 200.17,41.01 200.17,36.76 200.42,36.5 200.75,36.18 200.75,22.26 v1(202.82,20.19)
LED_SFP+_YEL_P17: length 39
  TOP w0.14: v1(215.19,48.79) 215.19,48.79 D34.2
  T05 w0.117: v1(215.19,48.79) 215.41,48.79 216.92,47.28 216.92,39.02 216.3,38.41 v1(216.3,36.96) 216.3,33.86 217.47,32.69 217.47,22.76 219.04,21.19 222.65,21.19 v1(224.1,19.74)
  BOTTOM w0.14: C829.1 v1(224.1,19.74) 224.1,19.64 223.68,19.22 U18.6
LED_SFP+_YEL_P18: length 45.7
  TOP w0.14: v1(216.31,45.15) 216.87,45.71 216.87,46.97 218,48.1 D35.2
  T16 w0.117: v1(222.8,10.42) 222.26,10.95 222.26,19.9 221.63,20.54 219.8,20.54 217.09,23.25 v1(217.09,34.41) 217.02,34.48 217.02,40.76 216.43,41.35 216.43,45.03 v1(216.31,45.15)
  BOTTOM w0.14: U18.11 222.38,10.87 222.8,10.45 v1(222.8,10.42) C831.1
LED_SFP+_YEL_P19: length 71.5
  TOP w0.14: D36.2 229.33,48.79 v1(229.44,48.68)
  T03 w0.117: v1(239.4,14.15) 238.65,13.41 225.24,13.41 224.65,12.81 222.62,12.81 v1(220.41,10.6)
  T16 w0.117: v1(229.44,48.68) 229.22,48.46 229.22,45.04 228.54,44.36 228.54,22.96 229,22.51 229,14.72 230.35,13.36 235.17,13.36 235.96,14.15 v1(239.4,14.15)
  BOTTOM w0.14: U18.13 221.08,11.27 v1(220.41,10.6) 220.26,10.45 C833.1 ; U19.1 239.71,13.84 v1(239.4,14.15)
LED_SFP+_YEL_P20: length 43.7
  TOP w0.14: D37.2 232.25,48.33 231.15,47.22 231.15,45.77 v1(232.47,44.44)
  T16 w0.117: v1(232.47,44.44) 234.65,42.27 234.65,21.95 235.67,20.93 235.67,16.14 v1(236.18,15.62)
  BOTTOM w0.14: C836.1 236.18,16.3 236.18,16.29 v1(236.18,15.62) 236.18,14.5 238.79,11.89 U19.4
LED_SFP+_YEL_P21: length 54.5
  TOP w0.14: D38.2 243.54,48.79 v1(243.71,48.63)
  T16 w0.117: v1(238.51,8.94) 238.51,10.46 243.25,15.2 243.25,42.52 244.65,43.92 244.65,45.17 243.37,46.45 243.37,48.29 v1(243.71,48.63)
  BOTTOM w0.14: U19.6 239.16,10.59 238.51,9.94 v1(238.51,8.94) 239.31,8.13 v2(239.9,8.13) 239.91,8.13 241.43,8.13 242.57,9.27 242.57,10.71 C838.1
LED_SFP+_YEL_P22: length 55.5
  TOP w0.14: D39.2 246.5,48.42 245.44,47.36 245.44,45.27 v1(246.18,44.53)
  T07 w0.117: v1(245.52,12.83) 244.88,13.47 242.13,13.47 240.8,12.14 233.63,12.14 v1(233.32,11.82)
  T16 w0.117: v1(246.18,44.53) 246.18,39.4 245.72,38.94 245.72,32.92 248.6,30.04 248.6,26.09 248.36,25.85 248.36,25.85 246.18,23.67 246.18,13.49 v1(245.52,12.83)
  BOTTOM w0.14: C840.1 232.89,11.47 233.24,11.82 v1(233.32,11.82) 233.37,11.82 233.44,11.89 U19.11
LED_SFP+_YEL_P23: length 74.5
  TOP w0.14: v1(258.25,48.58) 258.04,48.79 D40.2
  T07 w0.117: v1(256.41,18.16) 256.41,17.3 254.04,14.93 238.63,14.93 237.92,14.22 v1(233.48,14.22)
  T16 w0.117: v1(258.25,48.58) 257.72,48.04 257.72,45.42 256.52,44.22 256.52,34.02 251.76,29.26 251.76,20.12 252.98,18.9 255.67,18.9 v1(256.41,18.16)
  BOTTOM w0.14: U21.1 263.35,16.81 262,18.16 v1(256.41,18.16) ; U19.13 234.18,13.19 233.48,13.89 233.48,14.15 ; C842.1 233.34,14.01 233.48,14.15 ; 233.48,14.15 v1(233.48,14.22)
LED_SFP+_YEL_P24: length 41.7
  TOP w0.14: D17.2 260.75,48.26 259.59,47.1 259.59,45.63 261.58,43.65 v1(261.58,42.81)
  T05 w0.117: v1(265.71,18.56) 265.15,18 262,18 259.76,20.24 259.76,33.96 258.79,34.92 258.79,38 260.03,39.23 260.03,41.27 v1(261.58,42.81)
  BOTTOM w0.14: U21.4 266.08,18.19 v1(265.71,18.56) 265.26,19.01 C846.1
LED_SFP+_YEL_P25: length 34.5
  TOP w0.14: D18.2 271.55,48.14 271.96,47.74 271.96,44.37 v1(271.78,44.2)
  T16 w0.117: v1(269.35,20.35) 270.62,21.62 270.62,43.04 v1(271.78,44.2)
  BOTTOM w0.14: v1(269.35,20.35) 268.52,19.52 C848.1 267.8,18.5 v2(267.74,18.43) 267.38,18.07 U21.6
LED_SFP+_YEL_P26: length 49
  TOP w0.14: D19.2 275,48.35 273.88,47.22 273.88,45.85 v1(273.2,45.17)
  T05 w0.14: v1(266.33,9.5) 267.38,10.55 270.51,10.55 271.35,11.4 271.35,12.72 270.99,13.09 270.99,44.35 271.81,45.17 v1(273.2,45.17)
  BOTTOM w0.14: C850.1 266.5,9.32 v1(266.33,9.5) 266.08,9.75 U21.11
LED_SFP+_YEL_P27: length 82.6
  TOP w0.14: v1(285.14,44.63) 286.19,45.68 286.19,47.82 285.8,48.21 D20.2
  T14 w0.117: v1(298.57,28.06) 298.07,27.56 294.89,27.56 289.6,22.27 289.6,16.24 283.59,10.23 283.59,8.76 282.57,7.75 278.43,7.75 277.16,9.02 267.27,9.02 266.85,8.6 264.72,8.6 264.29,9.03 v1(264.29,9.45)
  BOTTOM w0.14: C852.1 263.96,9.11 v1(264.29,9.45) 264.78,9.93 U21.13 ; v1(285.14,44.63) 285.6,44.17 285.6,38.5 v2(288.37,35.74) 292.99,31.11 292.99,28.7 294.13,27.56 298.07,27.56 v1(298.57,28.06) U13.1
LED_SFP+_YEL_SR_P0: length 4.3
  TOP w0.14: v1(85.09,57.35) 85.62,56.82 85.62,55.6 85.49,55.47 D1.4
  BOTTOM w0.14: v1(85.09,57.35) 84.2,58.24 R318.2
LED_SFP+_YEL_SR_P1: length 17.9
  TOP w0.14: D2.4 97.72,55.9 v1(97.46,56.16)
  T05 w0.117: v1(97.46,56.16) 97.86,55.76 97.86,42.98 v1(98.42,42.42)
  BOTTOM w0.14: R325.2 99.55,44.05 98.42,42.93 v1(98.42,42.42)
LED_SFP+_YEL_SR_P2: length 10.8
  TOP w0.14: D3.4 v1(99.71,55.45)
  T07 w0.117: v1(99.44,47.5) 98.64,48.3 98.64,54.34 99.71,55.41 v1(99.71,55.45)
  BOTTOM w0.14: v1(99.44,47.5) 99.55,47.39 R332.2
LED_SFP+_YEL_SR_P3: length 16.8
  TOP w0.14: D4.4 111.97,55.9 v1(111.71,56.16)
  T07 w0.117: v1(112.49,43.18) 112.38,43.18 111.55,44.02 111.55,51.18 112.04,51.67 112.04,55.83 v1(111.71,56.16)
  BOTTOM w0.14: R339.2 113.39,44.1 112.49,43.2 v1(112.49,43.18)
LED_SFP+_YEL_SR_P4: length 10.7
  TOP w0.14: D5.4 v1(113.96,55.37)
  T07 w0.117: v1(113.67,47.5) 112.89,48.27 112.89,54.3 v1(113.96,55.37)
  BOTTOM w0.14: R346.2 113.57,47.4 v1(113.67,47.5)
LED_SFP+_YEL_SR_P5: length 15.7
  TOP w0.14: D6.4 126.22,55.39 v1(125.73,55.88)
  T07 w0.117: v1(125.73,55.88) 126.26,55.35 126.26,44 126.85,43.41 v1(126.93,43.41)
  BOTTOM w0.14: R353.2 127.67,44.16 v1(126.93,43.41)
LED_SFP+_YEL_SR_P6: length 11.1
  TOP w0.14: D7.4 v1(128.9,54.73)
  T07 w0.117: v1(127.92,47.01) 127.14,47.79 127.14,54.38 127.5,54.74 128.89,54.74 v1(128.9,54.73)
  BOTTOM w0.14: v1(127.92,47.01) R360.2
LED_SFP+_YEL_SR_P7: length 15.5
  TOP w0.14: v1(140.08,55.75) 140.47,55.36 D8.4
  T07 w0.117: v1(141.33,43.31) 141.31,43.31 140.48,44.15 140.48,55.36 v1(140.08,55.75)
  BOTTOM w0.14: v1(141.33,43.31) 142.24,44.22 R367.2
LED_SFP+_YEL_SR_P8: length 11
  TOP w0.14: D9.4 v1(143.13,54.73)
  T07 w0.117: v1(143.13,54.73) 141.74,54.73 141.39,54.38 141.39,48.03 v1(142.34,47.07)
  BOTTOM w0.14: v1(142.34,47.07) R374.2
LED_SFP+_YEL_SR_P9: length 15.3
  TOP w0.14: v1(154.43,55.75) 154.72,55.46 D10.4
  T05 w0.117: v1(154.43,55.75) 154.77,55.41 154.77,43.98 155.37,43.39 v1(155.43,43.39)
  BOTTOM w0.14: v1(155.43,43.39) 156.19,44.15 R381.2
LED_SFP+_YEL_SR_P10: length 11.3
  TOP w0.14: D11.4 v1(157.48,54.73)
  T05 w0.117: v1(157.48,54.73) 155.99,54.73 155.64,54.38 155.64,47.77 v1(156.42,47)
  BOTTOM w0.14: v1(156.42,47) R388.2
LED_SFP+_YEL_SR_P11: length 18.4
  TOP w0.14: D12.4 168.97,55.9 v1(168.71,56.16)
  T18 w0.117: v1(168.71,56.16) 169.16,55.71 169.16,50.93 168.28,50.04 168.28,43.64 v1(169.25,42.67)
  BOTTOM w0.14: R395.2 170.85,44.1 169.42,42.67 v1(169.25,42.67)
LED_SFP+_YEL_SR_P12: length 11.2
  TOP w0.14: D13.4 v1(171.68,54.73)
  T16 w0.117: v1(171.68,54.73) 170.24,54.73 169.8,54.29 169.8,48.12 v1(170.85,47.07)
  BOTTOM w0.14: R402.2 170.85,47.07 v1(170.85,47.07)
LED_SFP+_YEL_SR_P13: length 16.8
  TOP w0.14: v1(182.96,56.16) 183.22,55.9 D14.4
  T18 w0.117: v1(182.96,56.16) 183.34,55.79 183.34,44.93 183.18,44.76 183.18,43.64 183.64,43.18 v1(183.84,43.18)
  BOTTOM w0.14: R409.2 184.99,44.18 183.99,43.18 v1(183.84,43.18)
LED_SFP+_YEL_SR_P14: length 11.5
  TOP w0.14: D15.4 185.37,54.86 v1(186.11,54.86)
  T18 w0.117: v1(186.11,54.86) 184.63,54.86 184.14,54.38 184.14,49.12 v1(184.99,48.26)
  BOTTOM w0.14: v1(184.99,48.26) R416.2
LED_SFP+_YEL_SR_P15: length 2.4
  TOP w0.14: D16.4 197.47,55.64 v1(197.23,55.88)
  BOTTOM w0.14: R423.2 197.92,55.19 v1(197.23,55.88)
LED_SFP+_YEL_SR_P16: length 11.1
  TOP w0.14: D33.4 203.75,51 v1(203.41,51.35)
  BOTTOM w0.14: v1(203.41,51.35) 203.41,58.95 v2(203.25,59.1) 203.07,59.29 R542.2
LED_SFP+_YEL_SR_P17: length 17.2
  TOP w0.14: D34.4 214.55,50.48 215.08,51.01 v1(215.08,51.98)
  T03 w0.117: v1(215.08,51.98) 215.08,49.87 215.95,49.01 215.95,48.51 216.79,47.66 216.79,46.54 214.99,44.74 214.99,43.38 v1(215.2,43.16)
  BOTTOM w0.14: R549.2 217.79,40.28 v2(216.02,42.05) 215.2,42.87 v1(215.2,43.16)
LED_SFP+_YEL_SR_P18: length 10.7
  TOP w0.14: D35.4 218,50.72 v1(217.76,50.97)
  BOTTOM w0.14: R556.2 216.84,43.49 216.84,47.55 216.49,47.9 216.49,48.54 v2(217.26,49.31) 217.76,49.81 v1(217.76,50.97)
LED_SFP+_YEL_SR_P19: length 16.8
  TOP w0.14: D36.4 228.8,50.98 v1(229.16,51.34)
  T03 w0.117: v1(229.16,51.34) 229.16,49.87 230.15,48.89 230.15,48.37 231.13,47.39 231.13,44.81 231.11,44.79 231.11,44.25 v1(230.34,43.48)
  BOTTOM w0.14: v1(230.34,43.48) 230.34,43.01 230.87,42.48 230.87,41.43 231.27,41.03 231.27,38.05 R563.2
