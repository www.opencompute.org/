# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PD_NIFE_LCPLL1_BYP_CLK: length 1.6
  TOP w0.14: U1.V12 v4(221.86,118.5)
  BOTTOM w0.14: R1442.2 221.27,119.08 v4(221.86,118.5)
PD_NIFE_SRD_REFCLK_Q05_DN: length 2.5
  TOP w0.14: U1.L28 v4(204.86,111.5)
  BOTTOM w0.102: v4(204.86,111.5) 204.35,110.98 R1435.2
PD_NIFE_SRD_REFCLK_Q05_DP: length 1.5
  TOP w0.14: U1.L29 v4(203.86,111.5)
  BOTTOM w0.102: v4(203.86,111.5) 203.37,111.98 R1434.2
PECI_PCH_BMC: length 115.8
  TOP w0.14: R12356.1 47.27,104.44 v1(47.37,104.55) ; U154.AA21 v4(55.33,104.93)
  T03 w0.117: J1.A19 84.04,161.06 83.37,161.73 62.42,161.73 58.17,157.48 56.9,157.48 53.09,153.67 53.09,136.02 51.18,134.11 41.78,134.11 39.5,131.83 39.5,129.67 37.72,127.89 37.72,123.57 38.23,123.06 38.23,107.95 42.8,103.38 45.85,103.38 47.01,104.55 v1(47.37,104.55)
  T05 w0.117: v4(55.33,104.93) 54.86,105.41 48.24,105.41 v1(47.37,104.55)
PHY1_PRTAD0: length 12.3
  TOP w0.14: R12820.1 R280.1 119.03,87.79 119.76,88.52 v1(119.76,90.42) 119.76,93.55 121.62,95.41 122.26,95.41 U23.R10
PHY1_PRTAD1: length 2.6
  TOP w0.14: U23.R6 v4(122.21,100.36)
  BOTTOM w0.14: v4(122.21,100.36) 122.54,100.69 R279.1 122.94,100.55 122.94,99.94 R12979.1
PHY1_PRTAD3: length 16.9
  TOP w0.14: U23.K5 v4(127.21,101.36)
  T07 w0.117: v4(127.21,101.36) 126.71,100.86 119.49,100.86 119.12,100.48 118.23,100.48 117.35,99.6 117.35,98.72 115.59,96.97 v1(115.19,96.97)
  BOTTOM w0.14: R278.1 114.9,95.59 114.9,96.68 v1(115.19,96.97)
PHY1_PRTAD4: length 17.6
  TOP w0.14: U23.J5 v4(128.21,101.36)
  T07 w0.117: v1(115.91,94.34) 121.44,99.87 127.41,99.87 127.67,100.13 127.67,100.82 v4(128.21,101.36)
  BOTTOM w0.14: R276.1 115.67,94.1 v1(115.91,94.34)
PHY3_PRTAD1: length 5.8
  TOP w0.14: U25.U1 276.6,101.23 v1(276.06,101.77) 275.01,102.82 R302.1 R12821.1
PHY3_PRTAD2: length 8.3
  TOP w0.14: v4(286.1,100.39) U25.G1 286.6,101.94 289.09,104.44 R303.1 R12971.1
  BOTTOM w0.14: v4(286.1,100.39) v2(285.16,100.39)
PHY3_PRTAD3: length 8.6
  TOP w0.14: U25.F2 v4(288.1,100.39) 288.1,102.55 290.2,104.65 R304.1 R12972.1
  BOTTOM w0.14: v4(288.1,100.39) v2(287.15,100.39)
PHY3_PRTAD4: length 7.3
  TOP w0.14: R305.1 292.28,101.57 v4(292.1,101.39) U25.B1
  BOTTOM w0.14: v4(292.1,101.39) 291.6,100.89 290.52,100.89 v2(290.08,101.33)
PHY3_SERBOOT: length 15.5
  TOP w0.14: R309.2 R311.1 v1(295.5,85.2) ; U25.G15 v4(287.1,86.39)
  T03 w0.117: v4(287.1,86.39) 287.63,85.86 287.63,83.01 288.02,82.62 292.92,82.62 v1(295.5,85.2)
PSU1_ALRT_N: length 18
  T03 w0.117: v1(28.42,204.96) 28.42,205.17 CN3.A1
  BOTTOM w0.14: R1161.2 R1157.1 35.53,195.78 D47.2 32.7,195.78 28.44,200.04 28.44,204.95 v1(28.42,204.96)
PSU1_EEPROM_WP: length 131.6
  TOP w0.102: U154.V4 v4(57.73,119.33)
  T05 w0.117: v1(48.6,201.94) 48.6,201.33 48.89,201.04 54.29,201.04 56.26,199.07 56.26,196.94 58.31,194.89 58.31,187.79 64,182.11 64,177.03 61.57,174.6 61.57,172.98 58.54,169.95 58.54,165.5 55.27,162.22 55.27,152.73 57.27,150.73 57.27,136.24 56.18,135.15 56.18,132.52 56.9,131.8 56.9,125.48 55.75,124.33 55.75,123.32 56.77,122.3 56.77,121.8 57.33,121.25 57.33,119.94 57.73,119.54 v4(57.73,119.33)
  T18 w0.117: CN3.A3 22.53,207.06 23.5,206.09 26.93,206.09 26.94,206.1 30.43,206.1 30.98,205.54 39.06,205.54 39.88,204.72 46.48,204.72 48.6,202.6 v1(48.6,201.94)
  BOTTOM w0.14: v1(48.6,201.94) 48.6,201.46 49.17,200.89 R12945.1 R12947.2
PSU1_PRSNT_IN_N: length 25
  TOP w0.14: R1154.2 v1(45.72,201.55)
  T05 w0.117: CN3.B2 25.51,204.09 29.08,204.09 29.34,203.84 30.99,203.84 32.64,205.49 37.18,205.49 37.3,205.61 41.4,205.61 45.47,201.55 v1(45.72,201.55)
PSU1_PRSNT_N: length 165.5
  TOP w0.14: U154.G5 v4(67.33,118.53) ; U70.A2 110.8,132.85 v4(110.8,133.65) ; v1(40.7,199.84) D49.2 43.4,199.84 C1592.2 R1153.1 R1154.1
  T03 w0.117: v4(110.8,133.65) 110.43,134.03 108.42,134.03 107.86,134.59 105.95,134.59 103.7,136.83 101.86,136.83 101.61,136.59 91.97,126.94 91.97,122.66 90.71,121.41 78.49,121.41 78.48,121.41 76.8,121.41 76.04,120.65 73.15,120.65 71.43,118.93 67.73,118.93 v4(67.33,118.53)
  T05 w0.117: v1(40.7,199.84) 40.7,199.08 51.44,188.34 51.44,186.03 48.25,182.85 48.25,172.75 52.71,168.3 52.71,135.21 52.04,134.55 50.42,132.92 v1(50.42,131.85)
  T07 w0.117: v4(67.33,118.53) U154.G5 64.75,118.13 64.53,118.35 64.53,122.42 63.5,123.44 61.34,123.44 57.53,127.25 57.53,129.67 56.72,130.48 56.72,131.37 56.24,131.85 v1(50.42,131.85)
PSU1_PSKILL: length 28.3
  TOP w0.14: R12974.1 v1(47.79,202.35)
  T18 w0.117: CN3.C3 23.56,204.09 28.32,204.09 28.57,203.84 30.86,203.84 32.26,205.23 36.96,205.23 37.97,204.22 45.93,204.22 v1(47.79,202.35)
PSU1_PSON_N: length 53.7
  TOP w0.14: CN3.A4 19.52,206.05 19.52,197.65 21.21,195.96 28.32,195.96 31.37,192.91 32.63,192.91 D51.2 34.72,191.44 34.92,191.64 v1(34.92,192.15) ; v1(49.12,196.98) 49.76,196.34 53.79,196.34 C1595.1 R1158.2 53.9,194.96 53.27,195.59 Q23.6
  T18 w0.117: v1(34.92,192.15) 34.92,192.91 36.7,194.69 44.45,194.69 46.74,196.98 v1(49.12,196.98)
PSU1_PWRGD: length 33.1
  T18 w0.117: v1(38.75,197.87) 37.55,199.08 29.75,199.08 28.78,200.04 22.18,200.04 21.56,200.66 21.56,204.04 CN3.B4
  BOTTOM w0.14: v1(38.75,197.87) 39.47,197.15 40.08,197.15 41.09,196.14 D45.2 41.09,193.73 42.67,192.15 R1170.2 43.92,192.15 R1166.2
PSU1_PWROK: length 238
  TOP w0.14: v1(135.45,187.39) 135.9,187.85 U59.1 ; U70.B3 v4(111.6,132.05) ; U154.AB6 v4(54.27,117.33) 53.87,117.33 53.47,117.73 v1(53.47,127)
  T03 w0.117: v4(111.6,132.05) 110.05,133.6 108.25,133.6 107.94,133.92 107.94,133.92 107.69,134.16 105.78,134.16 103.53,136.41 102.03,136.41 92.39,126.77 92.39,122.49 92.14,122.24 90.89,120.99 82.82,120.99 81.84,120 73.39,120 71.52,118.13 55.07,118.13 v4(54.27,117.33)
  T05 w0.117: v1(135.45,187.39) 135.45,185.61 132.29,182.46 132.29,172.13 132.77,171.65 132.77,170.25 136.02,167 136.02,160.03 135.13,159.14 135.13,156.21 133.99,155.07 133.99,154 130.53,150.55 120.66,150.55 115.83,145.72 115.83,140.9 114.13,139.2 114.13,136.95 111.2,134.02 111.2,132.45 v4(111.6,132.05)
  T14 w0.117: v1(53.77,187.38) 53.77,186.68 60.69,179.76 60.69,166.01 57.94,163.26 57.94,159.1 59.14,157.9 59.14,152.87 57.78,151.51 57.78,136.65 56.19,135.06 55.14,135.06 54.1,134.02 54.1,127.64 v1(53.47,127)
  BOTTOM w0.14: v1(53.77,187.38) 53.59,187.56 53.54,187.58 51.35,187.58 51.09,187.32 49.03,187.32 47.49,188.86 47.11,188.86 45.95,190.02 C1596.2 45.85,191.16 45.85,191.16 44.76,191.16 R1166.1
PSU1_PWRON_BMC_N: length 85.9
  TOP w0.14: U154.W7 v4(56.93,116.93) ; v1(50.77,188.09) 51.28,187.58 52.83,187.58 53.58,188.33 R13088.2 U196.2
  T05 w0.117: v4(56.93,116.93) 56.53,116.53 54.4,116.53 51.25,119.67 51.25,130.11 49.85,131.5 49.85,132.95 52.24,135.34 52.24,168.18 47.83,172.58 47.83,183.16 50.77,186.11 v1(50.77,188.09)
PSU1_PWRON_HWM_N: length 83.2
  TOP w0.14: U196.1 52.93,190.74 53.07,190.88 54.48,190.88 v1(55.75,192.15) ; v1(125.12,200.28) U73.33
  T14 w0.117: v1(55.75,192.15) 56.14,191.76 62.22,191.76 73.65,203.19 91.39,203.19 91.41,203.17 92.33,203.17 93.13,202.37 99.93,202.37 101.29,203.73 121.39,203.73 124.84,200.28 v1(125.12,200.28)
  BOTTOM w0.14: R13087.1 v1(55.75,192.15)
PSU2_ALRT_N: length 26.8
  T07 w0.117: CN3.A5 19.5,206.09 19.5,200.69 20.15,200.05 27.28,200.05 v1(32.71,194.62)
  BOTTOM w0.14: v1(32.71,194.62) 33.22,194.11 D46.2 35.66,194.11 R1180.1 R1183.2
PSU2_EEPROM_WP: length 126.6
  TOP w0.102: U154.W3 v4(56.93,120.13)
  T05 w0.117: v1(49.28,199.64) 49.02,199.39 49.02,198.45 50.91,196.56 56.01,196.56 57.94,194.63 57.94,187.64 63.63,181.95 63.63,177.29 61.2,174.87 61.2,173.13 54.8,166.72 54.8,151.93 56.42,150.31 56.42,139.45 55.12,138.15 55.12,135 55.46,134.66 55.46,129.63 54.73,128.9 54.73,123.71 56.26,122.17 56.26,120.79 v4(56.93,120.13)
  T14 w0.117: v1(49.28,199.64) 48.26,200.66 42.07,200.66 41.25,201.48 37.9,201.48 35.97,199.55 28.55,199.55 28.06,200.04 23.56,200.04 CN3.D3
  BOTTOM w0.14: v1(49.28,199.64) 49.4,199.76 R12948.2 R12946.1
PSU2_PRSNT_IN_N: length 35
  TOP w0.14: R1176.2 v1(45.47,197.23)
  T18 w0.117: CN3.B5 19.56,204.04 19.56,198.5 20.04,198.02 29.88,198.02 30.23,198.37 36.2,198.37 37.34,197.23 41.15,197.23 41.78,196.6 44.83,196.6 v1(45.47,197.23)
PSU2_PRSNT_N: length 186.4
  TOP w0.14: D48.2 41.81,195.68 C1598.2 R1175.1 R1176.1 46.1,195.05 v1(46.1,194.82) ; U154.F3 v4(68.13,120.13) ; U70.D8 v4(116.4,130.45)
  T05 w0.117: v4(68.13,120.13) 67.73,120.53 67.73,121.25 67.56,121.41 66.67,121.41 66.36,121.72 66.36,124.84 66.7,125.17 66.7,125.64 64.39,127.95 64.39,130.18 63.25,131.32 63.25,137.03 62.19,138.09 62.19,150.73 60.71,152.22 60.71,156.97 63.88,160.15 63.88,165.48 67.69,169.29 68.96,169.29 71.5,171.83 71.5,176.22 73.66,178.38 73.66,184.91 71.75,186.82 71.75,192.14 62.8,201.09 56.44,201.09 55.63,201.9 54.35,201.9 52.85,203.41 47.66,203.41 47.22,202.97 47.22,201.94 47.74,201.42 47.74,198.44 46.1,196.8 v1(46.1,194.82)
  T07 w0.117: v4(68.13,120.13) 68.53,119.73 68.53,119.05 68.65,118.93 75.38,118.93 75.56,118.75 77.72,118.75 78.93,119.95 81.56,119.95 82.97,118.55 84.39,118.55 85,119.16 89.39,119.16 93.2,122.97 93.2,124.82 97.39,129.01 104.12,129.01 108.36,133.25 114.17,133.25 114.94,132.49 114.94,132.16 115.44,131.65 115.77,131.65 116,131.42 116,130.85 v4(116.4,130.45)
PSU2_PSKILL: length 22.1
  TOP w0.14: R12973.1 43.34,202.35 v1(43.03,202.65)
  T14 w0.117: v1(43.03,202.65) 42.74,202.95 36.94,202.95 33.91,199.92 29.44,199.92 27.33,202.04 25.56,202.04 CN3.C2
PSU2_PSON_N: length 51.8
  TOP w0.14: CN3.D1 25.54,202.06 22.1,202.06 21.52,201.47 21.52,197.69 22.61,196.6 28.32,196.6 31.45,193.47 D50.2 v1(34.11,192.72) ; v1(53.09,202.06) C1601.1 R1181.2 53.85,201.04 53.63,201.26 Q24.6
  T18 w0.117: v1(34.11,192.72) 36.65,195.26 44.42,195.26 47.5,198.34 47.5,198.75 49.02,200.28 51.31,200.28 v1(53.09,202.06)
PSU2_PWRGD: length 25.8
  TOP w0.14: R1188.2 R1190.2 43.4,191.46 D44.2 41.08,191.46 40.64,191.9 40.64,196.91 v1(39.74,197.81)
  T18 w0.117: v1(39.74,197.81) 38.03,199.52 30.08,199.52 CN3.C1
PSU2_PWROK: length 282.8
  TOP w0.14: U154.Y7 v4(56.13,116.93) ; R1188.1 C1602.2 46.84,192.3 47.8,191.34 v1(47.8,191.08) ; U70.B7 v4(115.6,132.05) ; U59.2 136.58,191.03 137.16,190.45 v1(137.16,189.99)
  T03 w0.117: v1(83.94,119.15) 83.53,118.73 73.02,118.73 71.61,117.33 56.53,117.33 v4(56.13,116.93)
  T07 w0.117: v1(47.8,191.08) 47.8,190.83 48.85,189.78 56.56,189.78 58.04,191.26 68.37,191.26 v1(68.56,191.07) ; v1(83.94,119.15) 84.18,119.15 86.01,120.97 90.61,120.97 92.78,123.14 92.78,126.33 95.88,129.43 103.9,129.43 108.58,134.11 114.68,134.11 115.06,133.74 115.06,132.82 115.6,132.27 v4(115.6,132.05)
  T14 w0.117: v1(137.16,189.99) 137.16,196.21 132.85,200.53 126.47,200.53 124.99,199.05 117.9,199.05 116.33,197.49 82.17,197.49 77.98,193.29 75.44,193.29 73.21,191.07 v1(68.56,191.07)
  T18 w0.117: v4(115.6,132.05) 116.59,132.05 118.64,134.11 123.77,134.11 125.98,136.32 125.98,141.35 126.49,141.86 142.62,141.86 151.15,150.38 v1(155.32,150.38)
  BOTTOM w0.14: v1(137.16,189.99) 138.31,189.99 143.13,185.17 151.76,185.17 153.84,183.09 153.84,151.86 v1(155.32,150.38)
PSU2_PWRON_BMC_N: length 91.2
  TOP w0.14: U197.2 55.56,197.93 55.37,197.74 55.37,196.86 55.64,196.6 56.01,196.6 56.39,196.22 v1(56.39,195.2) ; U154.AA6 v4(55.33,117.73)
  T05 w0.117: v4(55.33,117.73) 54.11,117.73 51.69,120.14 51.69,131.67 53.13,133.12 53.13,168.47 48.68,172.93 48.68,180.88 56.39,188.59 v1(56.39,195.2)
  BOTTOM w0.14: v1(56.39,195.2) 56.39,196.22 R13089.2
PSU2_PWRON_HWM_N: length 77
  TOP w0.14: U197.1 57.21,197.28 v1(57.36,197.43) ; v1(124.71,201.29) 124.46,201.04 124.46,200.02 124.62,199.87 U73.34
  T14 w0.117: v1(57.36,197.43) 58.36,197.43 64.54,203.61 92.66,203.61 93.53,202.74 99.57,202.74 100.93,204.1 121.91,204.1 v1(124.71,201.29)
  BOTTOM w0.14: R13090.1 56.82,197.97 v1(57.36,197.43)
PSU_A0: length 39.9
  TOP w0.14: R12975.1 R12976.2 v1(54.48,205.64)
  T07 w0.117: CN3.D4 21.52,202.06 27.43,202.06 30.35,199.14 35.43,199.14 39.62,203.33 51.43,203.33 53.75,205.64 v1(54.48,205.64)
PSU_A1: length 34.2
  TOP w0.14: R12977.1 R12978.2 v1(56.52,205.64)
  T07 w0.117: CN3.B1 27.63,203.96 30.99,203.96 32.51,205.49 36.58,205.49 37.72,204.34 51.93,204.34 53.83,206.25 55.91,206.25 v1(56.52,205.64)
PSU_PWROK: length 13.8
  TOP w0.14: U73.30 127.36,197.21 128.78,198.63 130.56,198.63 131.78,197.4 131.78,194.23 v1(132.21,193.8) 132.99,193.01 R1023.2 133.9,192.6 U59.4
PSU_THERM_SHTDN_DIS_N: length 102.8
  TOP w0.14: U154.F4 v4(68.13,119.33)
  T03 w0.117: v4(68.13,119.33) 67.73,119.73 63.66,119.73 62.86,118.93 61.51,118.93 61.33,119.11 61.33,119.56 61.16,119.73 56.66,119.73 56.53,119.86 56.53,120.31 56.11,120.73 56.11,120.99 56.11,122.36 52.79,125.68 52.79,127.21 v1(53.47,127.89)
  T14 w0.117: v1(53.47,127.89) 52.58,128.78 52.58,132.21 53.62,133.25 53.62,134.14 54.96,135.48 56.02,135.48 57.25,136.71 57.25,151.73 58.67,153.16 58.67,157.61 57.4,158.88 57.4,163.32 60.27,166.19 60.27,179.59 52.87,186.98 v1(52.87,189.1)
  BOTTOM w0.14: v1(52.87,189.1) 52.75,188.98 50.67,188.98 50.46,189.19 Q5.2 Q5.5 50.46,192.64 R1281.1 49.68,193.42 49.68,194.21 50.51,195.04 Q6.3
PTP_1PPS_MUX_SEL: length 109.1
  TOP w0.14: v1(102.47,102.3) 101.9,102.87 101.9,106.6 105.52,110.22 105.52,111.11 107.44,113.03 116.28,113.03 126.7,123.45 126.7,126.83 125.24,128.29 121.71,128.29 121.33,128.68 120.23,128.68 U70.F13
  T14 w0.117: v1(102.47,102.3) 102.47,101.92 102.02,101.47 88.8,101.47 87.69,100.37 87.2,99.88 87.2,99.88 80.62,93.29 66.19,93.29 60.53,87.64 57.79,87.64 54.86,84.71 54.86,82.8 v1(55.51,82.15)
  BOTTOM w0.14: v1(55.51,82.15) U170.6 R12899.2 R12898.1
PTP_1PPS_RS422_CONN_DN: length 59.3
  TOP w0.104: J7.AR3 50.86,21.14 52.07,22.35 52.71,22.35 53.35,23 53.35,28.05 52.32,29.08 50.17,29.08 47.51,26.43 44.21,26.43 41.04,23.25 36.94,23.25 36.33,23.87 36.33,28.96 36.56,29.19 38.41,29.19 D76.1 38.37,29.57 36.6,29.57 36.33,29.84 36.33,30.78 35.87,31.24 31.75,31.24 31.59,31.4 31.59,32.35 31.75,32.52 D92.5 31.88,33.05 31.88,34.59 D92.6 31.75,35.13 31.59,35.3 31.59,36.36 31.85,36.63 32.54,36.63 33.06,36.12 33.06,33.49 33.91,32.64 34.93,32.64 35.35,33.06 35.35,33.43 R1590.2
PTP_1PPS_RS422_CONN_DP: length 59.2
  TOP w0.104: R1591.2 35.08,33.43 35.08,33.17 34.81,32.91 34.02,32.91 33.32,33.6 33.32,36.28 32.7,36.9 31.74,36.9 31.32,36.47 31.32,35.3 31.15,35.13 D92.7 31.01,34.58 31.01,33.06 D92.4 31.15,32.52 31.32,32.35 31.32,31.29 31.64,30.98 35.76,30.98 36.06,30.67 36.06,29.84 35.79,29.57 34.02,29.57 D75.1 33.98,29.19 35.83,29.19 36.06,28.96 36.06,23.75 36.83,22.99 41.15,22.99 44.32,26.16 47.62,26.16 50.28,28.82 52.21,28.82 53.09,27.94 53.09,25.08 52.93,24.93 52.93,24.77 53.09,24.62 53.09,24.46 52.93,24.3 52.93,24.14 53.09,23.99 53.09,23.83 52.93,23.68 52.93,23.52 53.09,23.37 53.09,23.11 52.6,22.62 51.93,22.62 50.82,23.73 J7.AR6
PTP_1PPS_RS422_DN: length 5.9
  TOP w0.104: U121.9 34.17,45.85 34.06,45.73 34.06,45.07 34.34,44.79 R1765.1 34.34,44.02 34.06,43.75 34.06,42.5 34.22,42.34 L159.4
PTP_1PPS_RS422_DP: length 5.8
  TOP w0.104: L159.1 33.69,42.34 33.8,42.44 33.8,43.75 33.52,44.02 R1765.2 33.52,44.83 33.79,45.09 33.79,45.73 33.67,45.85 U121.8
PTP_1PPS_RS422_RL_DN: length 5.1
  TOP w0.104: L159.3 34.22,38.14 34.12,38.03 34.12,37.51 34.65,36.97 34.91,36.97 35.35,36.53 35.35,36.03 R1590.1
PTP_1PPS_RS422_RL_DP: length 5.1
  TOP w0.104: L159.2 33.75,38.14 33.85,38.03 33.85,37.4 34.54,36.7 34.8,36.7 35.08,36.42 35.08,36.03 R1591.1
PTP_1PPS_RS422_RXD_EN_N: length 206.5
  TOP w0.14: R1192.2 v1(32.61,50.77) 33.17,50.21 U121.4 ; U70.B10 v4(118,132.05)
  T03 w0.117: v4(118,132.05) 118.4,132.45 118.4,135.8 119.72,137.12 119.72,139.3 115.48,143.53 115.48,147.49 111.45,151.52 60.69,151.52 57.53,154.69 v1(57.15,154.69)
  T14 w0.117: v1(57.15,154.69) 56.22,153.76 56.22,150.48 54.27,148.53 54.27,136.83 47.54,130.1 41.74,130.1 35.8,124.16 35.8,106.1 37.71,104.19 37.71,101.32 38.98,100.06 38.98,96.53 v1(39.37,96.14)
  T18 w0.117: v1(39.37,96.14) 39.37,95.72 40.73,94.36 40.73,91.35 40.73,91.35 40.73,90.59 37.47,87.33 37.47,74.63 31.88,69.04 31.88,65.06 29.4,62.58 29.4,53.99 v1(32.61,50.77)
PTP_1PPS_RS422_RXD_IN: length 2.8
  TOP w0.14: U121.2 34.17,49.89 34.49,50.2 34.75,50.2 v1(35.06,50.51) 35.06,50.87 R1589.1
PTP_1PPS_RS422_TXD_EN: length 203.3
  TOP w0.14: U70.A8 v4(116.4,132.85) ; R1191.1 33.79,50.87 v1(33.79,50.54) 33.67,50.42 U121.3
  T03 w0.117: v1(57.78,153.54) 60.23,151.1 111.28,151.1 115.06,147.32 115.06,143.13 115.95,142.24 115.95,139.57 114.55,138.18 114.55,134.7 v4(116.4,132.85)
  T14 w0.117: v1(57.78,153.54) 57.28,153.54 56.64,152.91 56.64,139.07 54.69,137.11 54.69,136.23 53.09,134.62 53.09,133.35 50.93,131.19 49.23,131.19 47.71,129.68 47.36,129.68 41.92,129.68 36.28,124.05 36.28,115.53 36.28,115.53 36.28,115.06 36.28,115.06 36.28,108.01 38.13,106.16 38.13,101.5 39.45,100.18 39.45,97.5 v1(40.02,96.94)
  T18 w0.117: v1(33.79,50.54) 35.07,51.82 36.83,51.82 38.99,53.98 38.99,60.33 38.1,61.21 38.1,72.01 39.5,73.41 39.5,76.45 38.35,77.6 38.35,86.36 41.15,89.15 41.15,91.18 41.15,91.18 41.15,94.54 41.15,94.54 41.15,95.81 v1(40.02,96.94)
PTP_OSC_OE: length 2.2
  TOP w0.14: R1627.2 56.12,76.11 v1(56.52,76.11) X2.1
PTP_TOD_RS422_CONN_DN: length 55.7
  TOP w0.104: R1592.2 26.2,34.04 26.05,33.9 26.05,33.25 26.27,33.03 27.19,33.03 27.81,33.65 27.81,36.32 28.31,36.82 29.32,36.82 29.69,36.45 29.69,35.3 29.85,35.13 D92.9 29.98,34.59 29.98,33.05 D92.2 29.85,32.52 29.69,32.35 29.69,31.21 29.19,30.72 27.16,30.72 26.8,30.36 26.8,29.87 27.1,29.57 28.82,29.57 D74.1 28.86,29.19 27.03,29.19 26.8,28.96 26.8,23.98 26.8,23.75 28.67,21.87 28.9,21.87 29.06,22.03 29.21,22.03 29.38,21.87 29.52,21.87 29.69,22.03 29.84,22.03 30,21.87 30.15,21.87 30.31,22.03 30.46,22.03 30.62,21.87 41.81,21.87 43.54,23.59 43.54,23.72 43.51,23.75 43.51,23.88 43.6,23.97 43.73,23.97 43.76,23.94 43.89,23.94 43.98,24.04 43.98,24.16 43.95,24.19 43.95,24.32 44.05,24.41 44.17,24.41 44.2,24.39 44.33,24.39 44.42,24.48 44.42,24.61 44.4,24.63 44.4,24.76 44.49,24.85 44.62,24.85 44.64,24.83 44.77,24.83 44.97,25.03 45.39,25.03 45.56,25.2 45.7,25.2 45.87,25.03 46.02,25.03 46.18,25.2 46.33,25.2 46.5,25.03 46.64,25.03 46.81,25.2 46.95,25.2 47.12,25.03 49.17,25.03 50.04,25.91 50.04,26.24 49.94,26.34 49.67,26.34 J7.AR7
PTP_TOD_RS422_CONN_DP: length 55.8
  TOP w0.104: R1593.2 25.79,33.48 25.79,33.14 26.16,32.77 27.3,32.77 28.08,33.54 28.08,36.21 28.42,36.55 29.21,36.55 29.42,36.34 29.42,35.3 29.25,35.13 D92.10 29.11,34.58 29.11,33.06 D92.1 29.25,32.52 29.42,32.35 29.42,31.32 29.08,30.99 27.05,30.99 26.53,30.47 26.53,29.86 26.24,29.57 24.47,29.57 D73.1 24.43,29.19 26.31,29.19 26.53,28.97 26.53,24.09 26.53,23.63 28.56,21.6 41.92,21.6 45.09,24.77 49.28,24.77 50.82,26.31 J7.AR8
PTP_TOD_RS422_DN: length 5.9
  TOP w0.104: U110.9 27.63,45.85 27.51,45.73 27.51,45.13 27.76,44.88 R1766.1 27.76,44.02 27.49,43.75 27.49,43.39 27.64,43.24 27.64,42.44 27.75,42.34 L161.4
PTP_TOD_RS422_DP: length 5.9
  TOP w0.104: L161.1 27.27,42.34 27.37,42.44 27.37,43.13 27.22,43.28 27.22,43.75 26.95,44.02 R1766.2 26.95,44.85 27.15,45.06 27.25,45.16 27.25,45.73 27.13,45.85 U110.8
PTP_TOD_RS422_RL_DN: length 5.4
  TOP w0.104: R1592.1 26.05,35.98 26.05,36.3 26.53,36.78 26.97,36.78 27.64,37.45 27.64,38.03 27.75,38.14 L161.3
PTP_TOD_RS422_RL_DP: length 5.4
  TOP w0.104: R1593.1 25.79,35.98 25.79,36.41 26.42,37.05 26.86,37.05 27.37,37.56 27.37,38.03 27.27,38.14 L161.2
PTP_TOD_RS422_RXD_EN_N: length 214.7
  TOP w0.14: R1199.2 25.71,50.48 v1(25.77,50.42) 26.03,50.16 26.42,50.16 26.63,49.96 U110.4 ; U70.C9 v4(117.2,131.25)
  T03 w0.117: v4(117.2,131.25) 117.6,131.65 119.22,131.65 119.76,132.19 119.76,135.64 120.14,136.02 120.14,139.54 115.91,143.78 115.91,147.67 111.63,151.95 61.03,151.95 58.04,154.94 v1(58.04,155.7)
  T14 w0.117: v1(38.2,95.99) 34.89,99.3 34.89,124.44 41.39,130.94 47.19,130.94 53.34,137.09 53.34,148.79 55.38,150.83 55.38,155.71 56.88,157.21 57.55,157.21 58.05,156.71 58.05,155.71 v1(58.04,155.7)
  T18 w0.117: v1(25.77,50.42) 28.32,52.97 28.32,63.16 30.01,64.85 30.01,68.49 36.54,75.02 36.54,87.59 39.88,90.93 39.88,93.89 38.2,95.57 v1(38.2,95.99)
PTP_TOD_RS422_RXD_IN: length 2.5
  TOP w0.14: R1594.1 28.45,51.12 v1(28.45,50.55) 28.19,50.29 27.94,50.29 27.63,49.98 U110.2
PTP_TOD_RS422_TXD_EN: length 213.6
  TOP w0.14: U110.3 v1(27.13,50.55) 27.13,51.16 R1198.1 ; U70.C10 v4(118,131.25)
  T03 w0.117: v4(118,131.25) 118.4,130.85 120.57,130.85 120.82,131.11 120.82,134.75 120.99,134.91 120.99,139.29 116.33,143.95 116.33,147.84 111.8,152.37 61.37,152.37 58.93,154.81 58.93,155.83 58.31,156.44 v1(56.92,156.44)
  T14 w0.117: v1(56.92,156.44) 55.8,155.33 55.8,150.66 53.85,148.7 53.85,137.01 47.36,130.52 41.57,130.52 35.37,124.33 35.37,102.01 38.35,99.03 v1(38.35,97.16)
  T18 w0.117: v1(27.13,50.55) 27.13,51.13 28.74,52.75 28.74,62.52 30.48,64.26 30.48,68.24 36.96,74.72 36.96,87.42 40.3,90.76 40.3,91.52 40.31,91.53 40.31,94.19 38.77,95.73 38.77,96.74 v1(38.35,97.16)
PWR_OFF_MAC: length 99.1
  TOP w0.14: R69.1 v1(178.17,135.32) ; U1.AJ31 v4(201.86,130.5) ; U70.G13 120.67,127.65 v4(121.07,128.05)
  T03 w0.117: v4(201.86,130.5) 201.36,130.99 199.68,130.99 199.35,131.33 199.35,131.76 199.14,131.97 198.62,131.97 198.37,132.21 198.37,132.81 198.58,133.01 198.97,133.01 199.38,133.42 199.38,135.76 199.11,136.03 195.46,136.03 195.05,136.44 191.25,136.44 190.4,137.29 180.14,137.29 v1(178.17,135.32)
  T14 w0.117: v4(121.07,128.05) 121.55,128.05 122.53,127.07 125.04,127.07 127.69,129.72 129.81,129.72 136.4,136.31 143.45,136.31 147.6,140.46 169.09,140.46 172.36,137.19 176.31,137.19 v1(178.17,135.32)
PWREN_BMC_HEATER: length 34.6
  TOP w0.14: v1(65.1,184.71) 64.95,184.86 R791.2 ; PR485.2 v1(79.52,189.25) ; R795.2 64.06,172.92 63.63,173.35 v1(63.63,173.74)
  T03 w0.117: v1(79.52,189.25) 78.62,188.34 72.01,188.34 71.63,188.72 69.11,188.72 v1(65.1,184.71)
  T05 w0.117: v1(63.63,173.74) 63.63,174.24 64.77,175.39 64.77,184.38 v1(65.1,184.71)
  BOTTOM w0.14: v1(63.63,173.74) 63.63,173.35 64.06,172.92 R795.2
PWREN_BMC_HEATER_CPLD: length 155
  TOP w0.14: U73.21 126.79,192.71 127.13,193.04 127.13,193.42 v1(128.07,194.37) R1017.1 128.85,194.06 129.16,193.75 130.31,193.75 131.12,192.94 131.12,188.3 133.22,186.19 v1(133.22,185.8) ; v1(66.74,176.72) 67.14,176.31 U194.2 ; U70.A9 116.89,132.54 116.89,133.14 116.56,133.46 116.56,134.71 116.13,135.15 115.57,135.15 115.15,135.56 115.15,137.12 v1(115.19,137.16)
  T14 w0.117: v1(115.19,137.16) 115.19,138.42 120.52,143.76 120.9,143.76 122.11,144.97 122.11,146.67 125.88,150.43 125.88,155.09 125.26,155.71 125.26,157.73 124.91,158.08 124.91,159.18 124.2,159.9 124.2,161.33 132.77,169.9 132.77,171.54 132.62,171.69 132.62,184.2 133.22,184.8 v1(133.22,185.8)
  T18 w0.117: v1(66.74,176.72) 66.74,176.94 66.74,179.4 70.57,183.23 70.57,185.05 72.08,186.56 72.61,186.56 75.81,189.76 78.69,189.76 81.41,192.48 91.21,192.48 91.88,193.15 96.18,193.15 96.91,192.43 101.98,192.43 106.35,196.8 120.81,196.8 121.04,197.03 122.77,197.03 124.79,195.01 126.63,195.01 126.98,194.66 127.78,194.66 v1(128.07,194.37)
  BOTTOM w0.14: v1(66.74,176.72) 66.48,176.46 R1085.2
PWREN_BMC_HEATER_HWM: length 73.6
  TOP w0.14: U73.24 v1(124.86,194.21) ; U194.1 68.17,175.74 v1(68.89,176.46)
  T16 w0.117: v1(68.89,176.46) 69.66,176.46 73.15,179.96 76.33,179.96 77.85,181.48 77.85,189.48 80.75,192.39 101.11,192.39 102.87,190.63 114,190.63 115.44,192.07 122.1,192.07 124.23,194.21 v1(124.86,194.21)
  BOTTOM w0.14: v1(68.89,176.46) 68.03,175.6 R1086.2
PWREN_P1V0: length 26.1
  TOP w0.254: PR44.1 v1(144.96,187.33)
  TOP w0.305: U73.12 123.12,189.9 123.12,189.04 v1(123.03,188.95)
  T03 w0.381: v1(123.03,188.95) 123.03,188.38 124.59,186.82 128.65,186.82 130.3,188.47 143.82,188.47 v1(144.96,187.33)
PWREN_P1V2: length 128.2
  TOP w0.305: v1(124.21,188.46) 123.62,189.05 U73.13
  TOP w0.381: PR45.1 v1(244.25,192.46)
  T14 w0.381: v1(124.21,188.46) 125.73,186.94 134.62,186.94 135.33,186.23 142.01,186.23 143,185.24 163.9,185.24 167.77,189.1 240.89,189.1 244.25,192.46 v1(244.25,192.46)
  BOTTOM w0.14: v2(245.41,192.46) v1(244.25,192.46)
PWREN_P1V8: length 152
  TOP w0.305: U73.25 126.69,194.71 v1(127.21,195.22)
  TOP w0.381: PR28.1 v1(27.43,159.01)
  T03 w0.381: v1(37.72,191.01) 38.11,191.4 45.6,191.4 46.74,192.53 47.62,192.53 49.35,194.25 51.37,194.25 55.82,198.7 55.82,199.71 57.33,201.22 58.09,201.22 59.94,203.07 59.94,204.25 60.73,205.03 62.64,205.03 69.53,211.91 75.87,211.91 77.72,210.06 81.15,210.06 81.41,210.31 89.06,210.31 95.15,204.22 122.94,204.22 125.86,201.29 125.86,196.58 v1(127.21,195.22)
  T14 w0.381: v1(27.43,159.01) 25.91,160.53 25.91,161.95 25.3,162.56 25.3,179.38 30.86,184.95 30.86,187.77 34.09,191.01 v1(37.72,191.01)
PWREN_P1V25: length 203.4
  TOP w0.305: U73.14 124.12,190.77 v1(124.16,190.8)
  TOP w0.381: PR27.1 v1(277.84,128.65)
  T07 w0.381: v1(277.84,128.65) 274.8,131.68 274.8,139.06 267.97,145.9 267.97,161.32 261.77,167.51 261.77,180.01 256.37,185.42 223.65,185.42 222.37,186.7 165.87,186.7 164.41,185.24 136.2,185.24 132.84,188.59 127.89,188.59 125.68,190.8 v1(124.16,190.8)
PWREN_P3V3: length 143.7
  TOP w0.305: U73.29 v1(124.71,196.71)
  TOP w0.381: v1(27.43,163.45) 26.85,162.87 PR43.1
  T03 w0.381: v1(36.07,189.48) 48.74,189.48 49.06,189.8 53.02,189.8 54.99,191.77 54.99,196.9 56.5,198.42 56.5,199.42 57.61,200.53 58.42,200.53 60.63,202.74 60.63,203.96 61.01,204.34 62.36,204.34 62.36,204.34 62.93,204.34 69.81,211.23 74.54,211.23 76.47,209.3 81.53,209.3 81.87,209.63 88.77,209.63 94.87,203.53 121.34,203.53 124.33,200.53 124.33,198.88 124.84,198.37 124.84,196.83 v1(124.71,196.71)
  T14 w0.381: v1(36.07,189.48) 34.51,189.48 32.24,187.21 32.24,184.39 26.67,178.82 26.67,164.21 v1(27.43,163.45)
PWREN_VCORE: length 218.7
  TOP w0.305: v1(122.91,190.94) 122.62,190.65 122.62,189.9 U73.11
  T18 w0.381: v1(122.91,190.94) 123.74,190.11 125.34,190.11 126.49,191.26 129.67,191.26 130.05,190.88 147.5,190.88 152.17,186.21 161.68,186.21 163.68,188.21 185.55,188.21 187.59,186.17 256.86,186.17 267.31,175.72 267.31,161.56 270.08,158.79 270.08,148.74 274.97,143.86 283.18,143.86 283.76,144.43 293.75,144.43 v1(299.02,139.16)
  BOTTOM w0.381: PR26.1 299.7,138.49 v1(299.02,139.16)
PWROK_SYS_DC: length 346.1
  TOP w0.14: PR335.2 v1(275.46,126.04) ; U70.E4 v4(112.4,129.65) ; v1(81.03,110.42) 80.36,111.08 74.32,111.08 73.6,110.36 71.97,110.36 U154.A15
  T05 w0.117: v1(244.09,187.02) 244.91,187.83 251.71,187.83 264.8,174.75 264.8,162.23 262.81,160.24 262.81,156.62 265.48,153.96 265.48,151.31 275.46,141.32 v1(275.46,126.04)
  T07 w0.117: v4(112.4,129.65) 112,129.25 110.64,129.25 109.32,127.94 109.32,123.26 107.87,121.81 97.2,121.81 87.52,112.13 84.85,112.13 83.14,110.42 v1(81.03,110.42) ; v1(124.08,197.1) 124.46,197.49 127.89,197.49 128.4,197.99 131.44,197.99 132.21,197.23 133.1,197.23 142.3,188.03 148.04,188.03 149.86,186.21 163.86,186.21 164.9,187.25 222.96,187.25 224.03,186.18 243.26,186.18 v1(244.09,187.02)
  T14 w0.117: v4(112.4,129.65) 112,130.05 111.44,130.05 111.2,130.29 111.2,130.62 110.97,130.85 109.66,130.85 105.03,135.48 105.03,137.29 108.94,141.19 108.94,141.6 113.83,146.49 113.83,155.24 113.26,155.81 113.26,159.42 113.95,160.11 113.95,169.33 113.46,169.82 113.46,172.1 114.3,172.94 114.3,180.47 113.78,180.98 113.54,181.23 113.54,182.97 114.11,183.54 114.11,185.29 113.67,185.73 113.67,190.03 116.41,192.78 116.41,195.06 118.7,197.35 119.34,197.35 119.34,197.35 122.81,197.35 123.06,197.1 v1(124.08,197.1)
QSFP28_P1_INT_N: length 71.4
  T07 w0.117: v1(266.27,39.01) 266.85,39.58 270.42,39.58 272.42,37.58 283.52,37.58 285.11,39.17 285.11,43.18 289.02,47.09 289.02,64.98 291.78,67.73 301.64,67.73 CJ12.U_28
  BOTTOM w0.14: U57.5 265.17,33.33 265.59,33.75 266.53,33.75 266.95,34.17 266.95,38 266.69,38.27 R595.1 v1(266.27,39.01)
QSFP28_P1_LPMODE: length 70
  T03 w0.117: CJ12.U_31 299.24,67.73 292.14,67.73 289.18,64.77 289.18,38.71 286.09,35.62 286.09,34.86 277.22,25.99 269.95,25.99 v1(268.11,24.15)
  BOTTOM w0.14: R596.1 v1(268.11,24.15) 268.11,24.63 v2(268.5,25.02) 269.07,25.58 U57.14
QSFP28_P1_MODSEL_N: length 25.8
  T05 w0.117: CJ12.U_8 300.16,60.34 300.8,59.71 300.8,58.32 298.48,56.01 295.02,56.01 293.84,54.83 293.84,52.09 298.3,47.64 v1(300.53,47.64)
  BOTTOM w0.14: v1(300.53,47.64) 300.58,47.64 300.83,47.39 R592.1
QSFP28_P1_PRSNT_N: length 134.9
  TOP w0.14: U42.4 305.34,89.63 305.05,89.92 304.16,89.92 303.89,89.64 v1(303.89,89.3) ; Q44.5 v1(279.91,78.02)
  T05 w0.117: CJ12.U_27 301.91,63.96 291.41,63.96 289.17,61.72 289.17,45.33 v1(287.86,44.02)
  T07 w0.117: v1(287.86,44.02) 285.84,42 285.84,39.21 283.78,37.16 269.73,37.16 v1(267.88,39.01) ; v1(279.91,78.02) 284.06,82.17 296.04,82.17 303.17,89.3 v1(303.89,89.3)
  BOTTOM w0.14: v1(267.88,39.01) R594.1 268.34,38.27 268.73,37.88 268.73,34.31 267.77,33.34 U57.9 ; v1(303.89,89.3) 306.93,89.3 v2(309.12,87.11) 310.64,85.59 310.64,75.95 309.88,75.18 309.88,65.78 308.41,64.31 304.46,64.31 CJ12.U_27
QSFP28_P1_RST_N: length 74.4
  T03 w0.117: CJ12.U_9 300.96,58.45 300.03,57.51 300.03,56.57 301.12,55.47 301.12,54.66 298.37,51.9 298.37,46.69 298.81,46.25 298.81,44.37 298.49,44.05 298.49,29.06 297.12,27.69 295.51,27.69 292.97,25.15 271.5,25.15 269.72,23.37 266.14,23.37 v1(265.36,24.15)
  BOTTOM w0.14: U57.18 266.47,25.63 v2(265.82,24.98) 265.36,24.53 v1(265.36,24.15) R600.2
QSFP28_P1_VCC: length 13.8
  TOP w0.635: 310.26,72.64 310.26,71.12 307.46,68.32 v1(306.96,68.32)
  T03 w0.635: CJ12.U_30 300.96,66.45 302.82,68.31 306.96,68.31 v1(306.96,68.32)
QSFP28_P1_VCCRX: length 10.6
  T07 w0.61: v1(303.78,71.88) 303.78,66.92 303.05,66.18 303.04,66.18 301.79,64.93 301.79,62.13 CJ12.U_10
QSFP28_P1_VCCTX: length 10.5
  BOTTOM w0.635: 302.74,73.25 302.74,68.68 301.48,67.42 301.48,66.39 CJ12.U_29 ; v2(302.4,80.37) 303.27,79.5 L131.1
QSFP28_P2_INT_N: length 55.6
  T07 w0.117: v1(266.27,34.43) 267.19,33.52 275.86,33.52 276.17,33.21 284.36,33.21 286.81,35.66 286.81,36.54 289.66,39.39 289.66,41.11 298.19,49.64 298.19,51.4 302.56,55.78 CJ12.L_28
  BOTTOM w0.14: R598.1 v1(266.27,34.43) 265.54,34.43 264.52,33.42 U57.4
QSFP28_P2_LPMODE: length 66.1
  T03 w0.117: CJ12.L_31 298.43,60.54 295.07,60.54 292.75,62.87 290.85,62.87 289.69,61.7 289.69,38.97 289.69,38.62 286.51,35.45 286.51,34.69 277.4,25.57 270.71,25.57 v1(269.35,24.21)
  BOTTOM w0.14: U57.13 269.72,25.16 v2(269.79,25.09) 269.79,24.65 v1(269.35,24.21) R599.1
QSFP28_P2_MODSEL_N: length 9.2
  T14 w0.117: v1(302.1,47.64) 302.1,49.88 301.47,50.52 301.47,51.87 300.16,53.18 CJ12.L_8
  BOTTOM w0.14: R593.1 v1(302.1,47.64)
QSFP28_P2_PRSNT_N: length 127
  TOP w0.14: Q44.2 281.64,78.02 v1(282.07,77.6) ; v1(303.4,88.51) 303.91,88.51 304.51,89.11 U42.5
  T03 w0.117: v1(303.4,88.51) 304.32,88.51 304.84,89.03 307.4,89.03 309.15,87.27 309.15,67.75 309.71,67.19 309.71,65.04 308.91,64.24 304.93,64.24 302.43,61.74 302.43,60.73 303.36,59.81 CJ12.L_27
  T07 w0.117: v1(267.88,34.43) 274.59,34.43 275.46,35.31 284.98,35.31 289.24,39.57 289.24,46.42 v1(290.76,47.95) ; CJ12.L_27 303.36,54.69 301.55,52.87 301.55,49.34 v1(301.5,49.29) ; v1(303.4,88.51) 303.01,88.51 296.1,81.6 288.23,81.6 284.23,77.6 v1(282.07,77.6)
  T18 w0.117: v1(301.5,49.29) 297.86,49.29 296.51,47.95 v1(290.76,47.95)
  BOTTOM w0.14: U57.8 267.12,33.58 267.88,34.34 v1(267.88,34.43) R597.1
QSFP28_P2_RST_N: length 53.2
  T07 w0.117: CJ12.L_9 300.96,50.51 297.17,46.73 295.92,46.73 290.08,40.89 290.08,39.95 290.08,39.22 287.23,36.37 287.23,35.84 287.23,35.49 280.32,28.57 271.17,28.57 v1(266.7,24.11)
  BOTTOM w0.14: U57.17 v2(267.12,24.96) 267.12,24.53 v1(266.7,24.11) R601.2
QSFP28_P2_VCC: length 23.1
  BOTTOM w0.635: CJ12.L_30 300.95,57.42 300.95,59.56 300.19,60.33 295.15,60.33 290.58,64.9 290.58,67.64 v1(294.51,71.58)
QSFP28_P2_VCCRX: length 35.7
  BOTTOM w0.61: CJ12.L_10 301.76,56.9 303.39,58.53 303.39,59.58 302.34,60.62 302.34,61.49 303.34,62.49 303.34,63.31 302.51,64.14 294.64,64.14 293.37,65.41 293.37,68.71 295.78,71.12 300.84,71.12 301.45,71.73 301.45,73.19
QSFP28_P2_VCCTX: length 16.3
  P10 w0.61: v1(300.26,72.01) 299.86,71.61 299.86,69.07 300.94,68 300.94,66.48 300.08,65.63 300.08,64.41 301.04,63.45 301.04,62.59 300.19,61.74 300.19,61.73 300.1,61.64 300.1,60.34 301.76,58.68 CJ12.L_29
QSFP28_PWR_OC_N: length 223.9
  TOP w0.14: R646.1 v1(123.78,126.26) ; U42.6 v1(304.19,86.2) ; U42.10 v1(307.48,86.2) ; U70.H10 v4(118,126.45)
  T03 w0.117: v1(271.57,80.33) 272.65,81.41 295.66,81.41 300.45,86.2 v1(304.19,86.2) v1(307.48,86.2) ; v1(230.1,82.58) 230.1,82.58 228.92,83.76 186.11,83.76 179.3,90.57 175.47,90.57 167.13,98.91 167.13,98.92 155.49,110.56 155.48,110.56 154.93,111.11 152.18,111.11 149.93,113.37 149.93,120.68 140.69,129.93 140.06,129.93 140.06,129.93 127.81,129.93 124.15,126.26 v1(123.78,126.26) 122.15,126.26 121.41,127 118.55,127 v4(118,126.45)
  T14 w0.117: v1(230.1,82.58) 230.11,82.58 231.2,81.48 258.26,81.48 261.37,84.58 267.32,84.58 v1(271.57,80.33)
QSFP_PWR_ILIM: length 2.7
  TOP w0.14: v1(304.93,85.34) 305.05,85.34 305.34,85.63 U42.7
  BOTTOM w0.14: v1(304.93,85.34) 305.31,85.34 305.81,85.85 R622.1
RGMII_BMC_TXCTL: length 11.4
  TOP w0.14: U154.B12 71.3,112.9 71.88,112.9 71.98,112.8 72.61,112.8 75.17,115.36 v1(80.01,115.36)
  BOTTOM w0.14: v1(80.01,115.36) 80.89,115.36 TP115.1
RGMII_BMC_TXD0: length 10.2
  TOP w0.14: U154.C12 v4(70.53,112.13)
  BOTTOM w0.102: 76.48,112.33 74.45,112.33 74.25,112.13 v4(70.53,112.13)
  BOTTOM w0.14: 76.48,112.33 76.94,112.79 76.94,113.91 v2(77.37,114.33) 78.06,115.02 R12352.1
RGMII_BMC_TXD1: length 5.8
  TOP w0.14: U154.D12 v4(69.73,112.13)
  BOTTOM w0.102: 73.66,112.96 73.65,112.95 v2(73.57,112.95) 73.2,112.58 70.18,112.58 v4(69.73,112.13)
  BOTTOM w0.14: R12353.1 73.66,112.96
RGMII_BMC_TXD2: length 7.4
  TOP w0.14: U154.E12 v4(68.93,112.13)
  BOTTOM w0.102: v4(68.93,112.13) 68.93,112.67 69.47,113.22 71.56,113.22 72.06,113.72 72.7,113.72 73.03,114.05 74.24,114.05 TP116.1
RGMII_BMC_TXD3: length 11.8
  TOP w0.14: U154.A13 73.06,111.73 75.83,114.49 79.44,114.49 v1(80.23,113.7)
  BOTTOM w0.14: TP117.1 80.23,112.16 v1(80.23,113.7)
RGMII_BMC_TXEN: length 11.9
  TOP w0.14: U154.A12 71.81,112.45 72.89,112.45 75.23,114.78 80.6,114.78 v1(81.1,114.29)
  BOTTOM w0.14: v1(81.1,114.29) 81.64,113.75 R12351.1
ROV_EN: length 9.8
  TOP w0.254: v1(294.51,133.48) 294.3,133.69 PR138.2
  T03 w0.381: v1(299.01,131.5) 296.49,131.5 v1(294.51,133.48)
  BOTTOM w0.14: v1(294.51,133.48) 294.56,133.43 v2(294.56,132.46)
  BOTTOM w0.381: PR32.2 v1(299.01,131.5)
ROV_PG: length 191.3
  TOP w0.254: PU4.18 v1(289.45,131.99) 289.45,131.9 290.17,131.18 PR146.2
  TOP w0.381: PR52.1 v1(144.96,188.73)
  T18 w0.381: v1(289.45,131.99) 288.26,131.99 285.5,134.76 285.5,140.74 283.49,142.75 274.51,142.75 268.98,148.28 268.98,158.33 266.2,161.1 266.2,175.21 256.34,185.06 181.81,185.06 180.53,186.35 163.39,186.35 162.14,185.11 150.36,185.11 147.58,187.88 145.8,187.88 v1(144.96,188.73)
  BOTTOM w0.14: v1(289.45,131.99) 288.8,132.65 v2(288.8,132.84)
RST_BITS_N: length 88.9
  TOP w0.14: U70.J12 v4(119.6,125.65) ; v1(63.63,85.4) 63.73,85.3 U127.64
  T03 w0.117: v1(66.67,94.36) 62.87,90.55 62.87,86.16 v1(63.63,85.4)
  T07 w0.117: v4(119.6,125.65) 120,125.25 120.57,125.25 121.65,124.18 121.65,120.38 116.97,115.7 113.79,115.7 111.98,113.88 107.52,113.88 105.01,111.37 105.01,107.45 101.31,103.76 98.29,103.76 96.58,102.05 94.55,102.05 94.26,101.77 90.12,101.77 82.02,93.67 67.37,93.67 v1(66.67,94.36)
  BOTTOM w0.14: v1(63.63,85.4) 63.65,85.43 64.64,85.43 R1719.2
RST_BMC_DDR3_CPLD_N: length 98.1
  TOP w0.14: U70.K1 v4(110,124.85) ; v1(140.46,198.69) 140.17,198.98 U171.2
  T05 w0.117: v4(110,124.85) 110,126.18 109.13,127.05 109.13,128.28 108.68,128.73 107.76,128.73 106.75,129.74 106.75,131.44 110.18,134.87 110.18,136.83 109.72,137.29 109.72,139.14 114.51,143.93 114.51,146.87 120.05,152.41 120.05,154.68 121.26,155.89 121.26,159.62 122.16,160.52 122.16,170.33 121.8,170.69 v1(121.8,175.08)
  T16 w0.117: v1(121.8,175.08) 121.99,174.88 123.02,174.88 123.42,175.29 123.42,181.55 124.26,182.39 124.26,187.35 126.89,189.98 128.2,189.98 128.98,190.75 133.31,190.75 136.43,193.88 136.43,195.49 139.63,198.69 v1(140.46,198.69)
  BOTTOM w0.14: R12338.1 140.52,198.74 v1(140.46,198.69)
RST_BMC_DDR3_N: length 202.4
  TOP w0.14: R13038.1 C2326.1 R13042.1 140.82,185.39 v1(139.95,184.53) ; v1(39.28,102.29) 38.86,102.71 38.86,108.92 v1(40.25,110.31) U155.T2
  T16 w0.117: v1(139.95,184.53) 138.49,183.07 138.49,180.64 137.17,179.31 137.17,176.4 139.04,174.52 142.03,174.52 142.66,173.9 142.66,171.15 135.86,164.35 120.63,164.35 119.93,163.65 119.93,160.32 119.26,159.65 119.26,158.34 120.83,156.77 120.83,156.13 119.83,155.13 119.83,154.13 117.67,151.97 88.98,151.97 86.23,149.22 86.23,142.03 85.79,141.59 85.79,141.12 86.23,140.68 86.23,138.14 77.43,129.33 77.43,128.57 76.3,127.44 70.17,127.44 68.71,125.98 68.71,121.49 69.33,120.87 69.33,105.56 69.09,105.32 67.86,105.32 67.48,104.95 67.48,103.59 65.13,101.24 55.01,101.24 54.15,100.37 42.47,100.37 41.47,101.37 40.2,101.37 v1(39.28,102.29)
  BOTTOM w0.14: R12325.2 39.74,109.8 v1(40.25,110.31)
RST_BMC_LPC_N: length 144.4
  TOP w0.14: U70.M8 v4(116.4,123.25) ; R1702.2 v1(27.56,152.78) ; U154.E19 v4(68.93,106.52)
  T03 w0.102: 67.73,107.7 67.73,107.15 67.95,106.93 68.27,106.93 68.68,106.52 v4(68.93,106.52)
  T03 w0.117: v1(39.75,126.11) 44.83,126.11 55.22,115.73 59.15,115.73 59.56,115.32 59.56,109.98 59.94,109.6 67.18,109.6 67.73,109.06 67.73,107.7
  T05 w0.117: v4(68.93,106.52) 69.33,106.12 69.33,105.42 69.85,104.9 73.78,104.9 75,103.69 75,102.8 v1(76.33,101.47) 78.87,101.47 79.64,102.24 81.86,102.24 83.04,103.41 84.97,103.41 85.9,104.34 85.9,109.25 95.27,118.62 103.45,118.62 104.42,117.65 114.1,117.65 114.86,118.41 116.51,118.41 118.11,120.02 118.11,121.55 v4(116.4,123.25) ; v1(39.75,126.11) 39.75,130.94 32.26,138.43 32.26,148.08 v1(27.56,152.78)
  BOTTOM w0.14: R12469.1 75.46,102.08 76.07,101.47 v1(76.33,101.47)
RST_BMC_PCIE_N: length 59.7
  TOP w0.14: U70.N2 v4(110.8,122.45) ; U154.K19 v4(64.93,106.52)
  T05 w0.117: v4(64.93,106.52) 65.33,106.12 65.33,104.6 65.51,104.41 66.37,104.41 67.79,102.99 72.83,102.99 v1(73.53,103.69)
  T07 w0.117: v1(73.53,103.69) 74.72,103.69 79.58,108.55 84.69,108.55 97.42,121.28 102.75,121.28 103.48,120.56 108.91,120.56 v4(110.8,122.45)
  BOTTOM w0.14: v1(73.53,103.69) 73.53,103.98 74.26,104.71 R12310.1
RST_BMC_SYS_L: length 178.8
  TOP w0.14: U154.W20 v4(56.93,105.72) ; U164.4 v1(138.31,198.34)
  T03 w0.117: v1(138.31,198.34) 137.92,197.95 137.92,195.83 135.25,193.17 129.79,193.17 129.24,193.72 126.89,193.72 125.54,195.07 123.75,195.07 121.97,196.86 107.96,196.86 105.28,194.18 105.28,191.53 102.01,188.25 101.98,188.25 101.96,188.23 94.51,188.23 92.51,186.23 86.94,186.23 80.71,180 69.17,180 68.96,180.21 67.56,180.21 66.42,179.07 66.42,177.55 65.53,176.66 63.93,176.66 v1(59.46,172.19)
  T05 w0.117: v1(59.46,172.19) 58.4,172.19 54.3,168.09 54.3,132.44 54.1,132.25 54.1,122.81 55.73,121.19 55.73,119.96 55.96,119.73 57.09,119.73 57.33,119.49 U154.W20 v4(56.93,105.72)
  BOTTOM w0.102: v4(56.93,105.72) 56.53,105.33 56.53,104.76 56.62,104.67 56.62,103.7
  BOTTOM w0.14: v2(53.18,100.37) 53.88,100.37 54.59,101.07 54.59,102.54 55.42,103.38 56.29,103.38 56.62,103.7 ; v1(138.31,198.34) 137.75,198.9 C2452.1
RST_BMC_TO_CPU_N: length 98.5
  TOP w0.14: U136.1 100.12,177.84 99.69,177.42 v1(99.69,175.06) 100.43,174.33 100.71,174.33 R1764.1 ; U154.H4 v4(66.53,119.33)
  T05 w0.117: v4(66.53,119.33) 66.93,119.73 66.93,120.53 64.01,123.44 64.01,125.09 63.25,125.86 63.25,127 63.75,127.51 63.75,129.67 62.61,130.81 62.61,136.91 61.77,137.74 61.77,150.41 60.23,151.95 60.23,157.13 63.25,160.15 v1(63.25,166.88)
  T07 w0.117: v1(63.25,166.88) 63.25,168.69 64.52,169.96 64.95,169.96 64.97,169.98 71.86,169.98 71.89,169.96 87.99,169.96 89.35,171.32 94.36,171.32 98.1,175.06 v1(99.69,175.06)
RST_BMC_TO_RTC: length 51.1
  TOP w0.14: Q57.1 93.25,135.89 v1(93.45,135.69) R12924.2 ; U154.B18 v4(71.33,107.32)
  T16 w0.117: v4(71.33,107.32) U154.B18 70.36,107.72 70.13,107.96 70.13,121.26 69.72,121.67 69.72,121.81 69.73,121.81 69.73,122.15 69.72,122.15 69.72,125.09 71.5,126.87 76.33,126.87 77.85,128.4 77.85,129.16 85.6,136.91 92.23,136.91 v1(93.45,135.69)
RST_BMC_WDT2: length 23.4
  TOP w0.14: R12998.2 74.99,99.71 73.91,100.79 73.9,100.79 v1(73.7,101) ; U154.Y21 v4(56.13,104.92)
  T05 w0.117: v1(73.7,101) 72.58,102.12 57.9,102.12 56.64,103.38 56.64,104.41 v4(56.13,104.92)
RST_BMC_WDT_L: length 31.1
  TOP w0.14: v1(87.27,113.97) 86.34,114.9 Q12.3 ; v4(107.95,122.68) 107.95,123.43 108.48,123.96 109.27,123.96 109.68,124.37 110.32,124.37 U70.L1
  T07 w0.117: v1(87.27,113.97) 88.52,113.97 96.93,122.38 107.65,122.38 v4(107.95,122.68)
RST_CJA_N: length 56.5
  TOP w0.14: v1(157.35,125.15) 157.04,125.15 156.58,125.62 U135.17 ; U70.J9 v4(117.2,125.65)
  T14 w0.102: v4(117.2,125.65) 117.6,125.25 120.91,125.25 121.09,125.07
  T14 w0.117: 121.09,125.07 122.1,124.06 122.1,121.69 122.98,120.8 126.01,120.8 129.17,123.97 129.17,124.6 134.13,129.56 141.41,129.56 144.65,126.32 144.65,126.3 146.67,124.28 150.02,124.28 152.26,126.52 155.54,126.52 156.91,125.15 v1(157.35,125.15)
  BOTTOM w0.14: v1(157.35,125.15) 157.84,125.15 v2(158.41,124.59) 158.49,124.5 R1871.2
RST_CPLD_TO_BMC_SYS_L: length 91.1
  TOP w0.14: U148.2 135.44,194.5 134.7,195.25 R13037.1 134.14,194.03 135.14,193.03 136.92,193.03 137.92,192.02 137.92,188.34 v1(136.91,187.32) ; U70.E8 v4(116.4,129.65)
  T05 w0.117: v1(136.91,187.32) 136.91,186.44 134.49,184.02 134.49,181.54 132.72,179.77 132.72,172.3 133.2,171.82 133.2,170.59 138.18,165.61 138.18,160.4 139.06,159.51 139.06,158.69 140.91,156.84 140.91,155.5 140.15,154.74 140.15,153.74 138.05,151.64 135.38,151.64 132.72,148.97 132.72,146.03 126.42,139.74 121.58,139.74 120.48,138.64 120.48,137.66 118.66,135.85 118.66,135.36 116.8,133.5 116.8,130.05 v4(116.4,129.65)
RST_CPLD_TO_CPU_N: length 60.4
  TOP w0.14: R1651.2 101.35,174.71 101.35,175.14 v1(101.38,175.18) 101.6,175.4 101.6,176.91 101.32,177.19 U136.2 ; U70.H4 v4(112.4,127.25)
  T14 w0.117: v4(112.4,127.25) 112.18,127.25 111.78,127.65 110.52,127.65 110.4,127.77 110.4,128.22 109.97,128.65 107.87,128.65 106.68,129.84 106.68,133.24 104.61,135.31 104.61,137.63 106.04,139.06 106.04,144.66 105.41,145.29 105.41,151.55 103.95,153 103.95,155.29 103.1,156.14 103.1,159.45 102.06,160.49 102.06,164.13 101.38,164.81 v1(101.38,175.18)
RST_CPU_PLTRST_N: length 54.5
  TOP w0.14: U70.K7 v4(115.6,124.85)
  T18 w0.117: v1(107.82,141.99) 107.82,140.08 106.17,138.43 106.17,136.14 106.68,135.64 106.68,132.02 103.89,129.23 103.89,126.21 103.88,126.2 103.88,125.77 103.89,125.76 103.89,125.48 104.91,124.45 115.2,124.45 v4(115.6,124.85)
  BOTTOM w0.14: v1(107.82,141.99) 107.82,150.75 106.81,151.76 97.73,151.76 J1.B30
RST_CPU_PWRBTN_N: length 144.3
  TOP w0.14: U70.F9 v4(117.2,128.85) ; R1757.2 118.11,169.99 118.11,160.28 119,159.39 119,156.04 118.43,155.47 114.06,155.47 J1.B48 ; v1(70.36,130.05) 70.87,129.54 70.87,126.24 69.46,124.83 69.46,123.43 68.9,122.88 68.9,120.9 U154.E2
  T14 w0.117: v1(70.36,130.05) 70.36,130.43 69.13,131.66 67.86,131.66 66.8,132.72 66.8,134.75 63.86,137.69 63.86,139.47 63.25,140.08 63.25,153.59 63.46,153.81 v1(63.5,153.81)
  T18 w0.117: J1.B48 113.04,156.56 112.37,157.23 67.57,157.23 67.06,156.72 67.06,156.08 66.42,155.45 64.86,155.45 63.5,154.09 v1(63.5,153.81)
  BOTTOM w0.102: v4(117.2,128.85) 116.81,129.25 116.81,130.65 117,130.85 117.45,130.85 117.61,131.01 117.61,131.42 117.84,131.65 118.15,131.65 118.4,131.89 118.4,133.11
  BOTTOM w0.14: 118.4,133.11 118.4,134.91 119.89,136.4 119.89,139.83 113.92,145.8 113.92,153.57 J1.B48
RST_CPU_RTC_N: length 24
  TOP w0.14: Q57.3 90.14,137.7 v1(90.04,137.79)
  T18 w0.117: v1(90.04,137.79) 90.04,140.27 90.05,140.28 90.05,141.52 90.04,141.53 90.04,142.11 85.57,146.58 85.57,150.9 83.69,152.78 80.71,152.78 J1.B14
RST_CPU_SYS_N: length 23.1
  TOP w0.14: R1112.1 102.92,172.52 100.08,169.67 v1(97.28,169.67)
  T14 w0.117: J1.B31 95.26,157.23 95.26,159.4 96.01,160.15 96.01,168.4 v1(97.28,169.67)
RST_CPU_TO_BMC_N: length 117.6
  TOP w0.14: U148.1 136.01,195.71 135.25,196.47 R12486.1 v1(134.14,197.21)
  T05 w0.117: J1.B15 79.26,157.23 79.26,159.4 80.14,160.27 80.14,162.6 89.33,171.79 89.33,172.37 94.23,177.28 94.23,179.12 95.09,179.99 95.09,185.45 93.86,186.67 93.86,187.62 92.24,189.25 91.57,189.25 90.75,190.07 90.75,194.17 89.92,195 89.92,196.98 89.05,197.84 89.05,197.84 88.57,198.32 88.57,201.66 98.87,211.96 124.38,211.96 133.42,202.92 133.42,197.92 v1(134.14,197.21)
RST_CPU_TO_MB_I2C_N: length 15.4
  TOP w0.14: J1.B11 74.84,157.24 74.84,161.89 73.64,163.09 73.64,167.93 R1717.2
RST_CPU_TO_MB_PCIE_N: length 88.5
  TOP w0.14: R1716.2 77.01,169.12 77.86,168.27 77.86,163.54 75.66,161.35 75.66,155.83 J1.B12 ; U70.M1 v4(110,123.25) ; R1756.2 115.95,120.05 v1(116.02,120.11)
  T14 w0.117: v4(110,123.25) 110,123.22 107.91,121.13 105.04,121.13 104.53,120.62 103.98,120.62 102.46,122.15 102.02,122.15 96.87,127.29 96.87,136.74 97.12,136.99 98.91,138.77 98.91,142.11 97.16,143.85 96.55,143.85 95,145.4 95,149.26 92.05,152.2 79.29,152.2 J1.B12
  T18 w0.117: v4(110,123.25) 110.4,122.85 110.4,122.01 110.62,121.79 114.33,121.79 v1(116.02,120.11)
RST_GNSS_N: length 179
  TOP w0.14: U70.H3 v4(111.6,127.25)
  T03 w0.117: v1(4.07,36.2) 4.07,34.53 5.89,32.72 7.74,32.72 8.46,32 10.38,32 11.78,30.61 16.51,30.61 19.25,33.35 19.25,54.52 29.84,65.11 29.84,66.67 31.48,68.31 37.08,68.31 38.24,67.14 49.46,67.14 55.52,73.2 61.79,73.2 65.87,77.28 65.87,85.61 69.07,88.81 73.58,88.81 76.57,91.81 78.43,91.81 86.58,99.96 87.81,99.96 91.58,103.73 91.58,114.09 99.79,122.3 106.65,122.3 v4(111.6,127.25)
  BOTTOM w0.14: v1(4.07,36.2) 4.06,36.18 R1720.2 R1602.1
RST_HWM_N: length 119.7
  TOP w0.14: R1040.2 v1(122.4,185.29) 122.4,186.93 121.62,187.71 U73.9 ; v1(69.09,130.18) 69.22,130.05 69.22,129.22 68.96,128.97 68.96,128.96 68.89,128.89 68.89,127.98 R12719.1 ; U70.A5 v4(113.2,132.85)
  T03 w0.117: v1(69.09,130.18) 69.6,130.68 69.6,132.33 71.88,134.62 83.44,134.62 84.07,135.25 88.39,135.25 89.62,136.48 93.77,136.48 94.41,137.12 96.82,137.12 97.75,138.05 109.14,138.05 113.2,133.98 v4(113.2,132.85)
  T14 w0.117: v4(113.2,132.85) 113.39,133.04 113.39,142.81 121.83,151.25 121.83,155.56 121.26,156.13 121.26,159.31 120.12,160.46 120.12,171.29 123.32,174.49 123.32,184.38 v1(122.4,185.29)
  BOTTOM w0.14: v1(122.4,185.29) 122.4,185.25 C2443.1
RST_I2C_MUX0_N: length 64.1
  TOP w0.14: U76.3 138.3,176.15 137.34,177.11 v1(136.53,177.11) ; U70.D12 v4(119.6,130.45)
  T05 w0.117: v1(136.53,177.11) 137.34,176.3 137.34,170.25 139.95,167.64 139.95,160.53 140.84,159.64 140.84,158.88 142.88,156.84 142.88,155.96 141.99,155.07 141.99,153.8 124.21,136.02 122.05,136.02 119.38,133.35 119.38,131.83 119.2,131.65 119.2,130.85 v4(119.6,130.45)
RST_I2C_MUX1_N: length 148.4
  TOP w0.14: U67.3 87.92,181.14 v1(88.32,181.54) ; U70.M12 v4(119.6,123.25)
  T03 w0.117: v1(88.32,181.54) 89.65,180.21 90.93,180.21 93.27,177.87 103.82,177.87 104.29,177.4 113.94,177.4 115.98,175.35 119.75,175.35 122.59,172.52 122.59,163.18 123.83,161.94 123.83,160.25 122.95,159.38 122.95,156.16 122.26,155.47 122.26,153.34 122.7,152.9 122.7,146.38 125.14,143.94 125.14,136.69 v1(123.61,135.16)
  T05 w0.117: v1(123.61,135.16) 122.72,134.27 120.96,134.27 120,133.31 120,123.65 v4(119.6,123.25)
  T14 w0.102: v4(119.6,123.25) 119.19,122.84 119.19,122.62 119.2,122.62 119.2,122.29 119.19,122.29 119.19,121.99
  T14 w0.117: 119.19,121.99 118.06,120.86 109.69,120.86 108.04,119.22 104.08,119.22 102,121.3 101.67,121.3 100.7,122.28 86.09,122.28 84.6,123.77 83.61,123.77 82.43,122.6 81.48,122.6 81.26,122.82 80.35,122.82 78.76,121.23 78.76,119.75 76.2,117.19 v1(76.2,116.77)
  BOTTOM w0.14: R12729.2 v1(76.2,116.77) ; v1(88.32,181.54) 88.39,181.61 R1722.2
RST_I2C_MUX2_N: length 171.4
  TOP w0.14: U70.K5 v4(113.2,124.85)
  T03 w0.117: v1(103.52,19.35) 104.16,20 104.16,22.02 105.03,22.89 105.03,23.65 105.51,24.13 107.24,24.13 110.38,27.28 131.41,27.28 136.91,32.78 138.24,32.78 142.27,36.8 142.27,40.57 140.36,42.48 140.36,43.91 140.03,44.24 140.03,50.01 139.19,50.85 139.19,53.28 141,55.09 141,60.2 140.54,60.67 140.54,64.73 138.36,66.9 138.36,83.28 144.36,89.28 144.36,93.28 146.05,94.97 146.05,99.79 141.23,104.61 141.23,104.61 138.36,107.48 132.43,107.48 132.11,107.81 120.17,107.81 113.76,114.21 113.76,121.25 114.4,121.89 114.4,124.22 114.17,124.46 113.6,124.46 v4(113.2,124.85)
  BOTTOM w0.14: R1724.2 v1(103.52,19.35) 103.52,18.95 v2(104.25,18.22) 104.55,17.91 U68.3
RST_I2C_MUX3_N: length 165.8
  TOP w0.14: U70.N6 v4(114,122.45)
  T03 w0.117: v4(114,122.45) 114,122.02 113.34,121.36 113.34,114.04 119.99,107.38 131.93,107.38 132.26,107.06 138.18,107.06 141.06,104.18 145.63,99.62 145.63,95.14 143.94,93.46 143.94,89.46 137.94,83.46 137.94,83.11 137.94,69.85 126.82,58.73 126.82,49.44 128.49,47.76 128.49,38.82 129.31,38 129.31,34.06 v1(128.55,33.3)
  T07 w0.117: v1(89.25,35.18) 90.77,33.66 99.02,33.66 99.38,33.3 v1(128.55,33.3)
  BOTTOM w0.14: U62.3 89.22,35.15 v1(89.25,35.18) 89.25,36.03 R1726.2
RST_I2C_MUX4_N: length 134.3
  TOP w0.381: U70.N7 v4(115.6,122.45)
  T03 w0.117: v1(160.43,35.05) 159.79,35.69 159.79,41.74 155.06,46.47 155.06,50.39 153.64,51.81 153.64,52.53 151.59,54.58 149.12,54.58 148.85,54.31 148.85,53.49 148.06,52.7 148.06,52.06 147.63,51.62 145.05,51.62 144.15,52.52 144.15,56.01 142.88,57.27 142.88,61.22 143.55,61.88 143.55,66.38 141.22,68.71 141.22,79 142.6,80.37 142.6,85.57 145.63,88.6 145.63,92.76 147.31,94.44 147.31,102.46 141.02,108.75 132.96,108.75 132.63,109.07 131.93,109.07 125.5,109.07 118.62,115.95 118.62,117.86 117.73,118.75 115.82,118.75 115.03,119.54 115.03,120.72 115.58,121.28 115.58,122.43 v4(115.6,122.45)
  BOTTOM w0.14: R1728.2 v1(160.43,35.05) 160.43,35.02 160.54,34.91 U63.3
RST_I2C_MUX5_N: length 183
  TOP w0.14: v1(117.49,121.51) 117.2,121.8 117.2,123.26 U70.M9
  T03 w0.117: v1(117.49,121.51) 120.32,118.68 120.32,116.75 125.43,111.64 140.51,111.64 149,103.15 149,89.56 148.65,89.22 148.65,87.48 148.18,87.01 148.18,76.98 148.97,76.19 148.97,71.01 151.83,68.15 189.36,68.15 198.52,58.99 198.52,45.37 200.54,43.35 200.54,35.98 203.14,33.39 219.79,33.39 v1(220.68,34.27)
  BOTTOM w0.14: R1730.2 221.06,34.89 220.68,34.51 v1(220.68,34.27) 221.17,33.77 U64.3 221.17,31.18 220.22,30.23 v2(218.31,30.23)
RST_I2C_MUX6_N: length 235.2
  TOP w0.14: U70.N11 v4(118.8,122.45)
  T03 w0.117: v1(277.96,33.99) 268.68,33.99 268.22,33.53 256.66,33.53 255.78,32.64 250.14,32.64 247.78,35 242.53,35 240.5,32.97 235.52,32.97 234.19,34.3 231.42,34.3 228.59,34.3 227.31,33.03 225.18,33.03 224.37,33.83 224.37,34.18 224.37,34.58 223.09,35.87 215.72,35.87 213.46,38.13 204.95,38.13 203.71,39.37 203.71,41.91 203.66,41.96 203.66,42.02 201.8,43.87 v1(201.8,44.32) 201.55,44.58 201.17,44.58 199.84,45.91 199.77,45.91 199.63,46.04 199.63,59.67 189.84,69.46 155.08,69.46 151.38,73.15 151.38,75.64 149.44,77.58 149.44,85.44 151.51,87.51 151.51,91.06 150.26,92.3 150.26,103.74 148.82,105.19 148.82,108.07 145.76,111.14 142.81,111.14 141.04,112.91 125.98,112.91 121.58,117.3 121.58,119.2 118.8,121.98 v4(118.8,122.45)
  BOTTOM w0.14: U65.3 278.07,33.8 277.96,33.91 v1(277.96,33.99) R1732.2
