# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAC_DDRA_CS1_N: length 67.9
  TOP w0.14: R114.1 214.44,163.39 213.72,162.67 U3.L7 v4(213.03,163.07) ; U1.AN24 v4(208.86,134.5)
  T14 w0.117: v4(208.86,134.5) 208.46,134.09 206.66,134.09 206.35,134.41 206.35,138.89 200.56,144.68 200.56,150.83 202.47,152.74 207.78,152.74 207.9,152.86 207.9,153.94 208.01,154.06 208.25,154.06 208.36,153.94 208.36,152.86 208.48,152.74 209.7,152.74 210.42,153.46 210.42,155 210.3,155.12 209.87,155.12 209.75,155.23 209.75,155.47 209.87,155.58 210.3,155.58 210.42,155.7 210.42,155.93 210.3,156.05 209.87,156.05 209.75,156.17 209.75,156.4 209.87,156.52 210.3,156.52 210.42,156.64 210.42,157.34 210.3,157.45 208.01,157.45 207.9,157.57 207.9,157.8 208.01,157.92 210.4,157.92 210.52,158.04 210.52,158.27 210.4,158.39 208.01,158.39 207.9,158.51 207.9,158.74 208.01,158.86 210.3,158.86 210.42,158.97 210.42,162.34 210.75,162.67 212.63,162.67 v4(213.03,163.07)
MAC_DDRA_DBI0_N: length 64.2
  TOP w0.14: U1.AN32 v4(200.86,134.5) ; U2.E7 v4(200.86,157.47)
  T16 w0.117: v4(200.86,157.47) 200.46,157.07 191.92,157.07 191.16,156.32 191.16,149.38 192.25,148.3 192.25,137.45 193.25,136.44 193.25,133.09 192.72,132.57 192.72,130.86 192.84,130.74 193.2,130.74 193.32,130.86 193.32,131.86 193.44,131.98 193.69,131.98 193.81,131.85 193.81,130.38 193.93,130.26 194.18,130.26 194.3,130.38 194.3,131.89 194.41,132 194.62,132 194.74,131.89 194.74,131.06 194.83,130.98 195.72,130.98 195.84,131.1 195.84,131.39 195.95,131.51 196.19,131.51 196.3,131.39 196.3,131.1 196.42,130.98 203.21,130.98 203.33,131.1 203.33,131.93 203.2,132.06 200.48,132.06 200.37,132.18 200.37,132.81 200.51,132.95 202.23,132.95 202.35,133.07 202.35,133.87 202.23,133.99 200.87,133.99 200.75,134.11 200.75,134.38 v4(200.86,134.5)
MAC_DDRA_DBI1_N: length 63
  TOP w0.14: U2.E2 v4(205.66,157.47) ; U1.AP30 v4(202.86,135.5)
  T18 w0.117: v4(202.86,135.5) 203.13,135.5 203.35,135.72 203.35,145.73 203.24,145.85 203.01,145.85 202.89,145.97 202.89,146.2 203.01,146.32 203.24,146.32 203.35,146.43 203.35,146.71 203.21,146.85 202.82,146.85 202.7,146.97 202.7,147.41 202.58,147.53 202.35,147.53 202.23,147.41 202.23,146.97 202.11,146.85 201.88,146.85 201.76,146.97 201.76,147.41 201.65,147.53 201.41,147.53 201.3,147.41 201.3,146.97 201.18,146.85 200.73,146.85 200.61,146.97 200.61,147.77 200.73,147.89 203.46,147.89 203.58,148.01 203.58,148.24 203.46,148.36 200.73,148.36 200.61,148.47 200.61,148.71 200.73,148.82 203.46,148.82 203.58,148.94 203.58,149.18 203.46,149.29 200.73,149.29 200.61,149.41 200.61,149.64 200.73,149.76 203.46,149.76 203.58,149.88 203.58,150.11 203.46,150.23 200.73,150.23 200.61,150.34 200.61,150.58 200.73,150.69 203.46,150.69 203.58,150.81 203.58,151.04 203.46,151.16 200.73,151.16 200.61,151.28 200.61,151.51 200.73,151.63 203.46,151.63 203.58,151.75 203.58,151.98 203.46,152.1 200.73,152.1 200.61,152.21 200.61,152.84 201.37,153.6 201.37,158.12 201.52,158.27 204.11,158.27 204.51,157.87 204.69,157.87 204.69,157.87 205.02,157.87 205.03,157.87 205.26,157.87 v4(205.66,157.47)
MAC_DDRA_DBI2_N: length 60
  TOP w0.14: v4(213.03,157.47) U3.E7 ; U1.AJ25 v4(207.86,130.5)
  T16 w0.117: v4(207.86,130.5) 207.86,130.82 207.69,130.99 204.54,130.99 204.34,131.18 204.34,133.73 204.6,133.99 205.1,133.99 205.38,134.26 205.38,139.48 206.96,141.05 206.96,141.05 207.37,141.47 207.37,141.48 213.54,147.66 213.54,148.78 213.66,148.9 214.61,148.9 214.72,149.02 214.72,149.18 214.54,149.37 213.66,149.37 213.54,149.48 213.54,149.72 213.66,149.83 214.87,149.83 214.98,149.95 214.98,150.18 214.87,150.3 213.66,150.3 213.54,150.42 213.54,150.65 213.66,150.77 214.87,150.77 214.98,150.89 214.98,151.12 214.87,151.24 213.66,151.24 213.54,151.35 213.54,151.59 213.66,151.7 214.87,151.7 214.98,151.82 214.98,152.05 214.87,152.17 213.66,152.17 213.54,152.29 213.54,152.52 213.66,152.64 214.87,152.64 214.98,152.76 214.98,152.99 214.87,153.11 213.66,153.11 213.54,153.22 213.54,153.46 213.66,153.57 214.87,153.57 214.98,153.69 214.98,153.92 214.87,154.04 213.66,154.04 213.54,154.16 213.54,154.39 213.66,154.51 214.87,154.51 214.98,154.62 214.98,154.86 214.87,154.98 213.66,154.98 213.54,155.09 213.54,155.33 213.66,155.44 214.87,155.44 214.98,155.56 214.98,155.79 214.87,155.91 213.66,155.91 213.54,156.03 213.54,156.26 213.66,156.38 214.87,156.38 214.98,156.49 214.98,157.44 214.86,157.56 214.33,157.56 214.21,157.44 214.21,157.17 214.09,157.05 213.86,157.05 213.74,157.17 213.74,157.44 213.62,157.56 213.12,157.56 v4(213.03,157.47)
MAC_DDRA_DBI3_N: length 58.1
  TOP w0.14: U3.E2 v4(217.83,157.47) ; U1.AJ28 v4(204.86,130.5)
  T05 w0.117: v4(217.83,157.47) 217.43,157.07 216.15,157.07 215.74,156.66 215.74,152.21 212.33,148.8 206.13,148.8 206.02,148.68 206.02,148.43 206.13,148.32 207.91,148.32 208.02,148.2 208.02,147.97 207.91,147.85 206.16,147.85 206.02,147.71 206.02,147.5 206.13,147.38 207.91,147.38 208.02,147.26 208.02,147.03 207.91,146.91 206.16,146.91 206.02,146.77 206.02,146.56 206.13,146.45 207.91,146.45 208.02,146.33 208.02,146.1 207.91,145.98 206.16,145.98 206.02,145.84 206.02,145.63 206.13,145.51 207.91,145.51 208.02,145.4 208.02,145.16 207.88,145.02 206.13,145.02 206.02,144.9 206.02,144.66 206.13,144.54 206.97,144.54 207.08,144.42 207.08,144.19 206.97,144.07 206.13,144.07 206.02,143.96 206.02,143.72 206.13,143.6 206.94,143.6 207.06,143.49 207.06,143.25 206.94,143.14 206.13,143.14 206.02,143.02 206.02,142.49 205.42,141.89 205.42,141.08 205.31,140.96 205.02,140.96 204.9,140.85 204.9,140.61 205.02,140.5 205.31,140.5 205.42,140.38 205.42,140.15 205.31,140.03 205.02,140.03 204.9,139.91 204.9,139.68 205.02,139.56 205.31,139.56 205.42,139.45 205.42,131.06 v4(204.86,130.5)
MAC_DDRA_DQ00: length 63.2
  TOP w0.14: U1.AN33 v4(199.86,134.5) ; U2.G2 v4(205.66,159.07)
  T16 w0.117: v4(205.66,159.07) 205.26,158.67 205.26,156.51 205.02,156.27 204.69,156.27 204.46,156.04 204.46,156 202.34,153.88 202.34,153.29 202.45,153.17 203.21,153.17 203.33,153.06 203.33,152.82 203.21,152.71 202.45,152.71 202.34,152.59 202.34,152.36 202.45,152.24 203.21,152.24 203.33,152.12 203.33,151.89 203.21,151.77 202.26,151.77 201.75,151.27 201.75,150.01 201.63,149.89 201.26,149.89 201.14,149.77 201.14,149.54 201.26,149.42 201.63,149.42 201.75,149.31 201.75,149.07 201.63,148.95 201.26,148.95 201.14,148.84 201.14,148.6 201.26,148.49 201.63,148.49 201.75,148.37 201.75,148.04 201.61,147.89 200.77,147.89 200.65,148.01 200.65,149.37 200.53,149.48 200.3,149.48 200.18,149.37 200.18,148.01 200.07,147.89 198.51,147.89 198.33,147.71 198.33,146.79 198.47,146.64 198.88,146.64 199,146.76 199,147.46 199.12,147.58 199.35,147.58 199.47,147.46 199.47,146.76 199.58,146.64 199.82,146.64 199.93,146.76 199.93,147.46 200.05,147.58 200.28,147.58 200.4,147.46 200.4,146.76 200.52,146.64 200.89,146.64 201.01,146.76 201.01,147.41 201.13,147.53 201.36,147.53 201.48,147.41 201.48,146.76 201.59,146.64 202.12,146.64 202.23,146.53 202.23,146.29 202.12,146.18 198.45,146.18 198.33,146.06 198.33,145.85 198.47,145.71 201.33,145.71 201.45,145.59 201.45,145.39 201.33,145.27 198.45,145.27 198.33,145.15 198.33,144.92 198.45,144.8 200.31,144.8 200.43,144.68 200.43,144.45 200.31,144.33 198.45,144.33 198.33,144.22 198.33,141.11 197.38,140.16 197.38,138.28 197.61,138.05 197.95,138.05 197.95,138.05 198.35,137.65 198.35,137.29 198.6,137.04 199.11,137.04 199.36,136.79 199.36,135.2 199.86,134.7 v4(199.86,134.5)
MAC_DDRA_DQ01: length 61.4
  TOP w0.102: U1.AP34 v4(198.86,135.5)
  TOP w0.14: U2.F7 v4(200.86,158.27)
  T16 w0.117: v4(200.86,158.27) 201.34,157.79 201.34,156.59 201.03,156.27 192.18,156.27 191.78,155.87 191.78,151.34 191.78,150.87 192.62,150.02 194.07,150.02 194.26,149.84 194.26,149.59 194.14,149.48 193.11,149.48 192.99,149.36 192.99,149.13 193.11,149.01 194.14,149.01 194.26,148.89 194.26,148.66 194.14,148.54 193.11,148.54 192.99,148.43 192.99,148.19 193.11,148.08 194.14,148.08 194.26,147.96 194.26,147.65 194.14,147.53 193.35,147.53 193.23,147.41 193.23,147.25 193.38,147.1 194.11,147.1 194.26,146.95 194.26,146.26 192.95,144.95 192.95,141.93 193.07,141.81 193.61,141.81 193.71,141.7 193.71,141.56 193.61,141.45 193.07,141.45 192.97,141.35 192.97,141.21 193.07,141.1 194.16,141.1 194.26,141 194.26,140.85 194.16,140.75 193.07,140.75 192.97,140.65 192.97,140.25 193.08,140.14 194.33,140.14 194.48,139.99 194.48,138.82 194.32,138.67 193.02,138.67 192.87,138.52 192.87,137.64 193.61,136.9 193.61,132.7 193.73,132.58 196.05,132.58 196.17,132.46 196.17,132.07 196.25,131.98 199.19,131.98 199.31,132.11 199.31,134.75 198.86,135.21 v4(198.86,135.5)
MAC_DDRA_DQ02: length 61
  TOP w0.14: U2.H3 204.72,160.27 204.86,160.13 v4(204.86,159.87) ; U1.AT33 v4(199.86,137.5)
  T16 w0.117: v4(199.86,137.5) 200.03,137.66 200.03,137.92 199.9,138.05 199.6,138.05 199.4,138.25 199.4,138.9 200.61,140.11 200.61,142.93 206.99,149.31 206.99,151.25 206.88,151.37 204.71,151.37 204.6,151.49 204.6,151.72 204.71,151.84 206.88,151.84 206.99,151.96 206.99,152.19 206.88,152.31 204.71,152.31 204.6,152.42 204.6,152.66 204.71,152.77 206.88,152.77 206.99,152.89 206.99,153.06 206.88,153.17 204.71,153.17 204.6,153.29 204.6,153.52 204.71,153.64 206.88,153.64 206.99,153.76 206.99,158.12 207.11,158.24 207.64,158.24 207.82,158.42 207.82,158.76 207.7,158.88 207.05,158.88 206.93,159 206.93,159.23 207.05,159.35 207.7,159.35 207.82,159.47 207.82,159.7 207.7,159.82 207.05,159.82 206.93,159.93 206.93,160.17 207.05,160.28 207.7,160.28 207.82,160.4 207.82,160.57 207.7,160.69 202.79,160.69 202.54,160.94 202.54,161.32 202.31,161.55 201.52,161.55 201.42,161.45 201.42,161.25 201.54,161.14 201.81,161.14 201.93,161.02 201.93,160.79 201.81,160.67 201.54,160.67 201.42,160.55 201.42,159.71 201.54,159.59 201.85,159.59 201.97,159.71 201.97,160.26 202.09,160.38 202.32,160.38 202.44,160.26 202.44,159.71 202.56,159.59 203.53,159.59 203.72,159.78 203.72,160.16 203.84,160.28 204.07,160.28 204.19,160.16 204.19,159.71 204.31,159.59 204.74,159.59 204.86,159.71 v4(204.86,159.87)
MAC_DDRA_DQ03: length 59.1
  TOP w0.14: U2.H7 v4(200.86,159.87) ; U1.AT35 v4(197.86,137.5)
  T16 w0.117: v4(200.86,159.87) 200.86,159.65 202.61,157.89 202.61,157.61 202.5,157.49 202.43,157.49 202.31,157.37 202.31,157.14 202.43,157.02 202.5,157.02 202.61,156.91 202.61,156.67 202.5,156.56 202.43,156.56 202.31,156.44 202.31,155.89 201.1,154.67 198.5,154.67 198.3,154.47 198.15,154.47 197.95,154.67 197.8,154.67 197.59,154.47 197.45,154.47 197.24,154.67 193.05,154.67 192.93,154.56 192.93,154.18 193.05,154.06 195.46,154.06 195.58,153.94 195.58,153.71 195.46,153.59 193.05,153.59 192.93,153.48 192.93,153.24 193.05,153.13 195.46,153.13 195.58,153.01 195.58,152.78 195.46,152.66 193.05,152.66 192.93,152.54 192.93,152.26 193.05,152.15 195.5,152.15 195.64,152.01 195.64,151.75 195.53,151.64 193.06,151.64 192.94,151.52 192.94,151.33 193.1,151.17 195.53,151.17 195.64,151.05 195.64,146.02 194.1,144.47 194.1,143.04 195.4,141.73 195.4,135.55 195.52,135.43 196.26,135.43 196.35,135.51 196.35,135.93 196.47,136.06 197.26,136.06 197.38,136.17 197.38,137.48 197.49,137.6 197.76,137.6 v4(197.86,137.5)
MAC_DDRA_DQ04: length 63.3
  TOP w0.14: U2.H2 v4(205.66,159.87) ; U1.AP33 v4(199.86,135.5)
  T16 w0.117: v4(205.66,159.87) 205.94,159.87 206.06,159.76 206.06,154.81 205.92,154.67 205.49,154.67 205.26,154.91 205.26,155.34 205.13,155.47 204.54,155.47 204.04,154.97 204.04,154.81 204.38,154.47 204.38,154.3 204.22,154.14 204.05,154.14 203.71,154.48 203.54,154.48 203.04,153.97 203.04,153.76 203.16,153.64 203.92,153.64 204.02,153.54 204.02,150.91 204.14,150.8 206.21,150.8 206.32,150.68 206.32,150.45 206.21,150.33 202.44,150.33 202.32,150.22 202.32,149.97 202.44,149.86 206.21,149.86 206.32,149.75 206.32,149.51 206.18,149.37 203.73,149.37 203.62,149.25 203.62,148.94 203.73,148.82 205.22,148.82 205.33,148.7 205.33,148.47 205.22,148.35 204.14,148.35 204.02,148.24 204.02,147.15 200.62,143.75 199.07,143.75 198.96,143.64 198.96,143.4 199.07,143.29 199.92,143.29 200.04,143.17 200.04,143.16 200.04,142.94 199.92,142.82 199.07,142.82 198.96,142.7 198.96,142.47 199.07,142.35 199.92,142.35 200.04,142.23 200.04,142 199.92,141.88 199.07,141.88 198.96,141.77 198.96,141.53 199.07,141.42 199.92,141.42 200.04,141.3 200.04,140.43 199.69,140.08 199.53,140.08 198.88,140.73 198.71,140.73 198.55,140.56 198.55,140.4 199.19,139.75 199.19,139.59 199.03,139.42 198.86,139.42 198.22,140.07 198.05,140.07 197.88,139.9 197.88,139.74 198.38,139.24 198.38,138.23 198.55,138.05 198.99,138.05 199.3,137.74 199.3,137.36 199.63,137.03 200.08,137.03 200.35,136.75 200.35,136.21 200.52,136.05 201.06,136.05 201.36,135.75 201.36,135.2 201.18,135.03 200.03,135.03 199.86,135.2 v4(199.86,135.5)
MAC_DDRA_DQ05: length 60.1
  TOP w0.14: U2.H8 v4(200.06,159.87) ; U1.AR35 v4(197.86,136.5)
  T16 w0.117: v4(197.86,136.5) 197.86,136.63 197.98,136.74 198.72,136.74 199,136.46 199,136.16 198.83,135.99 198.52,135.99 198.4,135.87 198.4,133.02 198.28,132.9 197.47,132.9 197.36,133.02 197.36,134.83 197.24,134.95 196.46,134.95 196.34,134.83 196.34,133.24 196.22,133.12 195.9,133.12 195.79,133.24 195.79,134.2 195.67,134.32 195.44,134.32 195.32,134.2 195.32,133.28 195.17,133.12 195.03,133.12 194.88,133.27 194.88,134.27 194.76,134.39 194.55,134.39 194.44,134.27 194.44,133.24 194.32,133.12 194.1,133.12 193.99,133.24 193.99,135.87 195.07,136.95 195.07,140.27 194.83,140.51 194.83,141.49 193.52,142.8 193.52,144.71 194.83,146.02 194.83,150.48 194.71,150.6 192.86,150.6 192.35,151.1 192.35,155.07 192.76,155.47 197.02,155.47 197.12,155.58 197.12,155.6 197.22,155.7 197.37,155.7 197.47,155.6 197.47,155.58 197.57,155.47 197.72,155.47 197.82,155.58 197.82,155.6 197.92,155.7 198.07,155.7 198.17,155.6 198.17,155.58 198.27,155.47 201.33,155.47 201.84,155.99 201.84,158.09 201.26,158.67 200.57,158.67 200.46,158.79 200.46,159.73 200.31,159.87 v4(200.06,159.87)
MAC_DDRA_DQ06: length 62.8
  TOP w0.14: U1.AR32 v4(200.86,136.5) ; U2.J3 v4(204.86,161.47)
  T16 w0.117: v4(200.86,136.5) 200.86,136.83 200.4,137.29 200.4,138.88 201.18,139.66 201.18,142.69 207.57,149.07 207.57,157.36 208.39,158.18 208.39,161.16 208.25,161.3 206.91,161.3 206.65,161.04 203.27,161.04 202.44,161.88 201.03,161.88 201.02,161.87 199.09,161.87 199.09,161.88 198.49,161.88 198.21,162.16 198.21,162.59 198.32,162.71 198.71,162.71 198.83,162.82 198.83,163.06 198.71,163.17 198.32,163.17 198.21,163.29 198.21,163.52 198.32,163.64 198.71,163.64 198.83,163.76 198.83,163.99 198.71,164.11 198.32,164.11 198.21,164.22 198.21,164.46 198.32,164.57 198.71,164.57 198.83,164.69 198.83,164.93 198.71,165.04 198.32,165.04 198.21,165.16 198.21,165.39 198.32,165.51 198.71,165.51 198.83,165.63 198.83,165.86 198.71,165.98 198.32,165.98 198.21,166.09 198.21,166.56 198.32,166.68 199.09,166.68 199.09,166.68 199.52,166.68 199.66,166.54 199.66,162.91 199.89,162.67 201.23,162.67 202.06,163.51 202.5,163.51 202.61,163.39 202.61,162.61 202.73,162.49 202.97,162.49 203.08,162.61 203.08,163.39 203.2,163.51 203.78,163.51 204.02,163.27 204.02,161.92 204.47,161.47 v4(204.86,161.47)
MAC_DDRA_DQ07: length 63.9
  TOP w0.14: U1.AP31 v4(201.86,135.5) ; U2.J7 v4(200.86,160.67)
  T16 w0.117: v4(201.86,135.5) 201.86,135.76 201.39,136.23 201.39,138.87 201.75,139.23 201.75,140.5 201.76,140.51 201.76,142.45 208.18,148.87 208.18,157.16 208.96,157.94 208.96,161.55 208.64,161.87 204.58,161.87 204.34,162.11 204.34,163.63 204.09,163.89 201.5,163.89 201.09,163.47 200.63,163.47 200.46,163.65 200.46,167.49 200.25,167.7 197.81,167.7 197.63,167.51 197.63,157.79 197.75,157.66 198.59,157.66 198.71,157.78 198.71,160.1 198.88,160.27 200.74,160.27 200.86,160.39 v4(200.86,160.67)
MAC_DDRA_DQ08: length 64
  TOP w0.14: U2.A3 v4(204.86,154.27) ; U1.AR29 v4(203.86,136.5)
  T18 w0.117: v4(204.86,154.27) 204.86,153.82 204.97,153.7 206.99,153.7 207.11,153.59 207.11,153.35 206.99,153.23 204.97,153.23 204.86,153.12 204.86,152.88 205.03,152.71 206.13,152.71 206.25,152.59 206.25,152.4 206.36,152.28 207.45,152.28 207.57,152.16 207.57,151.93 207.45,151.81 206.36,151.81 206.25,151.69 206.25,151.46 206.36,151.34 207.45,151.34 207.57,151.23 207.57,150.99 207.45,150.88 206.36,150.88 206.25,150.76 206.25,150.53 206.36,150.41 207.45,150.41 207.57,150.29 207.57,150.06 207.45,149.94 206.36,149.94 206.25,149.82 206.25,149.59 206.36,149.47 207.45,149.47 207.57,149.36 207.57,149.12 207.45,149.01 206.36,149.01 206.25,148.89 206.25,148.66 206.36,148.54 207.45,148.54 207.57,148.42 207.57,148.19 207.45,148.07 206.36,148.07 206.25,147.96 206.25,147.32 206.08,147.15 205.07,147.15 204.95,147.03 204.95,146.8 205.07,146.68 206.91,146.68 207.03,146.57 207.03,146.33 206.91,146.21 205.07,146.21 204.95,146.1 204.95,145.86 205.07,145.75 206.91,145.75 207.03,145.63 207.03,145.4 206.91,145.28 205.07,145.28 204.95,145.16 204.95,144.93 205.07,144.81 206.91,144.81 207.03,144.7 207.03,144.46 206.91,144.35 205.07,144.35 204.95,144.23 204.95,143.99 205.07,143.88 206.91,143.88 207.03,143.76 207.03,143.29 206.91,143.17 205.07,143.17 204.95,143.06 204.95,142.82 205.07,142.71 206.91,142.71 207.03,142.59 207.03,142.36 206.91,142.24 205.07,142.24 204.95,142.12 204.95,141.89 205.07,141.77 206.08,141.77 206.19,141.66 206.19,141.42 206.08,141.31 205.07,141.31 204.95,141.19 204.95,140.95 205.07,140.84 206.08,140.84 206.19,140.72 206.19,140.49 206.08,140.37 205.07,140.37 204.95,140.25 204.95,140.02 205.07,139.9 206.08,139.9 206.19,139.79 206.19,139.17 206.21,139.15 205.96,138.9 205.69,138.9 205.29,138.49 205.29,137.1 205.11,136.92 204.28,136.92 v4(203.86,136.5)
MAC_DDRA_DQ09: length 63.4
  TOP w0.14: U2.B8 v4(200.06,155.07) ; U1.AR31 v4(201.86,136.5)
  T18 w0.117: v4(201.86,136.5) 202.01,136.5 202.34,136.17 202.34,132.24 202.11,132.01 201.57,132.01 201.35,132.23 201.35,136.02 200.56,136.02 200.43,135.9 200.43,132.16 200.3,132.03 199.49,132.03 199.34,132.19 199.34,135.84 199.16,136.02 198.46,136.02 198.35,135.91 198.35,132.11 198.22,131.98 197.51,131.98 197.33,132.16 197.33,136.67 197.65,136.99 201.09,136.99 201.35,137.25 201.35,143.99 200.26,145.08 196.69,145.08 195.82,145.95 195.82,149.33 193.89,151.26 193.89,153.5 195.06,154.67 199.66,154.67 v4(200.06,155.07)
MAC_DDRA_DQ10: length 63.7
  TOP w0.14: U2.C3 v4(204.86,155.87) ; U1.AR28 v4(204.86,136.5)
  T18 w0.117: v4(204.86,136.5) 205.38,135.97 205.38,133.07 205.5,132.95 207.1,132.95 207.31,133.17 207.31,139.52 207.62,139.82 207.62,140.09 207.5,140.21 206.92,140.21 206.81,140.33 206.81,140.56 206.97,140.73 208.06,140.73 208.14,140.81 208.14,141.11 208.06,141.2 206.92,141.2 206.81,141.31 206.81,141.5 206.92,141.61 207.5,141.61 207.62,141.73 207.62,141.79 207.74,141.9 207.98,141.9 208.1,142.02 208.1,142.26 207.98,142.37 207.74,142.37 207.62,142.49 207.62,142.72 207.74,142.84 207.98,142.84 208.1,142.96 208.1,143.19 207.98,143.31 207.74,143.31 207.62,143.42 207.62,143.66 207.74,143.77 207.98,143.77 208.1,143.89 208.1,144.12 207.98,144.24 207.74,144.24 207.62,144.36 207.62,144.59 207.74,144.71 207.98,144.71 208.1,144.83 208.1,145.06 207.98,145.18 207.74,145.18 207.62,145.29 207.62,145.53 207.74,145.64 207.98,145.64 208.1,145.76 208.1,145.99 207.98,146.11 207.74,146.11 207.62,146.23 207.62,146.46 207.74,146.58 207.98,146.58 208.1,146.7 208.1,146.93 207.98,147.05 207.74,147.05 207.62,147.16 207.62,147.43 208.14,147.95 208.14,149.23 208.26,149.35 209.05,149.35 209.17,149.46 209.17,149.7 209.05,149.81 208.26,149.81 208.14,149.93 208.14,150.14 208.26,150.26 209.51,150.26 209.62,150.37 209.62,150.61 209.51,150.73 208.26,150.73 208.14,150.84 208.14,151.18 208.26,151.3 209.51,151.3 209.62,151.42 209.62,151.65 209.51,151.77 208.26,151.77 208.14,151.89 208.14,152.12 208.26,152.24 209.51,152.24 209.62,152.35 209.62,152.59 209.51,152.7 208.26,152.7 208.14,152.82 208.14,153.07 208.26,153.18 208.59,153.18 208.71,153.3 208.71,153.53 208.59,153.65 208.26,153.65 208.14,153.77 208.14,157.38 208.42,157.66 209.5,157.66 209.65,157.82 209.65,158.9 209.58,158.97 208.59,158.97 208.47,158.85 208.47,158.49 208.36,158.37 208.12,158.37 208,158.49 208,158.85 207.89,158.97 207.45,158.97 207.31,158.83 207.31,154.98 207.01,154.67 205.49,154.67 205.26,154.91 205.26,155.71 205.09,155.87 v4(204.86,155.87)
MAC_DDRA_DQ11: length 60.1
  TOP w0.14: U2.C7 v4(200.86,155.87) ; U1.AU33 v4(199.86,138.5)
  T18 w0.117: v4(199.86,138.5) 199.86,141.23 199.74,141.35 199.38,141.35 199.28,141.45 199.28,142.88 199.18,142.98 199.03,142.98 198.93,142.88 198.93,141.45 198.82,141.35 198.68,141.35 198.58,141.45 198.58,142.88 198.47,142.98 198.33,142.98 198.23,142.88 198.23,141.45 198.12,141.35 197.98,141.35 197.88,141.45 197.88,142.88 197.77,142.98 197.63,142.98 197.53,142.88 197.53,141.45 197.42,141.35 197.28,141.35 197.17,141.45 197.17,142.88 197.07,142.98 196.93,142.98 196.82,142.88 196.82,141.45 196.72,141.35 195.84,141.35 194.6,142.59 194.59,142.59 194.19,143 194.19,143.01 194.11,143.09 194.11,145.88 194.21,145.98 194.21,149.3 192.74,150.77 192.74,154.53 192.28,155 192.28,158.55 193.2,159.47 194.3,159.47 194.42,159.36 194.42,158.54 194.53,158.43 194.77,158.43 194.89,158.54 194.89,159.36 195,159.47 195.24,159.47 195.35,159.36 195.35,158.54 195.47,158.43 195.7,158.43 195.82,158.54 195.82,159.36 195.94,159.47 196.17,159.47 196.29,159.36 196.29,158.54 196.4,158.43 196.64,158.43 196.75,158.54 196.75,159.36 196.87,159.47 197.11,159.47 197.22,159.36 197.22,158.54 197.34,158.43 197.57,158.43 197.69,158.54 197.69,159.36 197.81,159.47 198.04,159.47 198.16,159.36 198.16,158.54 198.27,158.43 198.51,158.43 198.62,158.54 198.62,159.36 198.74,159.47 199.42,159.47 199.66,159.24 199.66,156.51 199.77,156.4 199.77,156.39 199.89,156.27 200.46,156.27 v4(200.86,155.87)
MAC_DDRA_DQ12: length 64
  TOP w0.14: U1.AP28 v4(204.86,135.5) ; U2.C2 v4(205.66,155.87)
  T18 w0.117: v4(205.66,155.87) 206.06,155.47 206.63,155.47 206.91,155.75 206.91,159.27 207.18,159.54 210.18,159.54 210.31,159.42 210.31,157.09 210.19,156.97 209.74,156.97 209.62,156.86 209.62,156.62 209.74,156.51 210.19,156.51 210.31,156.39 210.31,156.16 210.19,156.04 209.74,156.04 209.62,155.92 209.62,155.69 209.74,155.57 210.19,155.57 210.31,155.45 210.31,155.22 210.19,155.1 209.74,155.1 209.62,154.99 209.62,154.75 209.74,154.64 210.19,154.64 210.31,154.52 210.31,149.74 208.73,148.17 208.73,148.14 208.72,148.12 208.72,140.2 208.26,139.74 208.26,130.24 208,129.98 207.54,129.98 207.26,130.26 207.26,131.88 207.14,132.01 206.55,132.01 206.4,131.86 206.4,130.05 206.3,129.95 205.54,129.95 205.36,130.13 205.36,132.64 205.1,132.9 204.67,132.9 204.42,132.64 204.42,130.26 204.21,130.05 203.58,130.05 203.35,130.28 203.35,134.78 203.58,135.01 204.84,135.01 204.96,135.12 204.96,135.39 v4(204.86,135.5)
MAC_DDRA_DQ13: length 61.1
  TOP w0.14: U2.C8 v4(200.06,155.87) ; U1.AT32 v4(200.86,137.5)
  T18 w0.102: 200.34,138.77 200.71,139.15 200.71,140.75
  T18 w0.117: 200.34,138.77 200.34,138.02 v4(200.86,137.5) ; v4(200.06,155.87) 199.66,155.47 199.01,155.47 198.75,155.73 198.75,157.41 198.31,157.85 197.87,157.85 197.75,157.73 197.75,155.62 197.64,155.5 197.4,155.5 197.29,155.62 197.29,157.73 197.17,157.85 196.94,157.85 196.82,157.73 196.82,155.62 196.7,155.5 196.47,155.5 196.35,155.62 196.35,157.73 196.24,157.85 196,157.85 195.89,157.73 195.89,155.62 195.77,155.5 195.53,155.5 195.42,155.62 195.42,157.73 195.3,157.85 195.07,157.85 194.95,157.73 194.95,155.62 194.83,155.5 194.6,155.5 194.48,155.62 194.48,157.73 194.37,157.85 194.13,157.85 194.02,157.73 194.02,155.62 193.9,155.5 193.67,155.5 193.55,155.62 193.55,157.73 193.43,157.85 193.1,157.85 192.91,157.66 192.91,155.25 193.32,154.84 193.32,151.01 195.25,149.08 195.25,145.71 196.45,144.51 197.23,144.51 197.35,144.39 197.35,144.06 197.46,143.95 197.7,143.95 197.81,144.06 197.81,144.39 197.93,144.51 198.17,144.51 198.28,144.39 198.28,144.06 198.4,143.95 198.63,143.95 198.75,144.06 198.75,144.39 198.87,144.51 199.1,144.51 199.22,144.39 199.22,144.06 199.33,143.95 199.57,143.95 199.68,144.06 199.68,144.39 199.8,144.51 200.02,144.51 200.71,143.82 200.71,140.75
MAC_DDRA_DQ14: length 61.9
  TOP w0.14: U1.AT29 v4(203.86,137.5) ; U2.D3 v4(204.86,156.67)
  T18 w0.117: v4(204.86,156.67) 203.69,157.84 201.94,157.84 201.83,157.72 201.83,156.81 201.94,156.7 202.13,156.7 202.25,156.81 202.25,157.22 202.36,157.33 202.6,157.33 202.71,157.22 202.71,156.81 202.83,156.7 203.06,156.7 203.18,156.81 203.18,157.22 203.3,157.33 203.53,157.33 203.65,157.22 203.65,156.81 203.77,156.7 204.07,156.7 204.19,156.58 204.19,156.35 204.07,156.23 201.94,156.23 201.83,156.11 201.83,155.88 201.94,155.76 204.07,155.76 204.19,155.64 204.19,155.41 204.07,155.29 201.94,155.29 201.83,155.18 201.83,154.94 201.94,154.83 204.07,154.83 204.19,154.71 204.19,154.48 204.07,154.36 201.94,154.36 201.83,154.24 201.83,153.94 201.94,153.82 204.12,153.82 204.24,153.71 204.24,153.47 204.12,153.36 201.94,153.36 201.85,153.26 201.85,152.93 201.97,152.81 204.11,152.81 204.35,152.58 204.35,152.23 204.47,152.11 205.39,152.11 205.54,151.97 205.54,151.74 205.42,151.62 204.47,151.62 204.35,151.5 204.35,151.3 204.49,151.15 205.42,151.15 205.54,151.04 205.54,150.8 205.42,150.69 204.47,150.69 204.35,150.57 204.35,150.36 204.49,150.22 205.42,150.22 205.54,150.1 205.54,149.87 205.42,149.75 204.47,149.75 204.35,149.63 204.35,149.43 204.49,149.28 205.42,149.28 205.54,149.17 205.54,148.93 205.42,148.82 204.47,148.82 204.35,148.7 204.35,148.49 204.49,148.35 205.42,148.35 205.54,148.23 205.54,148 205.42,147.88 204.47,147.88 204.35,147.77 204.35,147.54 204.23,147.43 204.1,147.43 203.99,147.31 203.99,147.08 204.1,146.96 204.23,146.96 204.35,146.84 204.35,146.61 204.23,146.49 204.1,146.49 203.99,146.38 203.99,146.14 204.1,146.03 204.23,146.03 204.35,145.91 204.35,145.67 204.23,145.56 204.1,145.56 203.99,145.44 203.99,145.21 204.1,145.09 204.23,145.09 204.35,144.97 204.35,144.74 204.23,144.62 204.1,144.62 203.99,144.51 203.99,144.27 204.1,144.16 204.23,144.16 204.35,144.04 204.35,143.81 204.23,143.69 204.1,143.69 203.99,143.57 203.99,143.34 204.1,143.22 204.23,143.22 204.35,143.1 204.35,142.87 204.23,142.75 204.1,142.75 203.99,142.64 203.99,142.4 204.1,142.29 204.23,142.29 204.35,142.17 204.35,141.94 204.23,141.82 204.1,141.82 203.99,141.7 203.99,141.47 204.1,141.35 204.23,141.35 204.35,141.23 204.35,141 204.23,140.88 204.1,140.88 203.99,140.77 203.99,140.53 204.1,140.42 204.23,140.42 204.35,140.3 204.35,140.07 204.23,139.95 204.1,139.95 203.99,139.83 203.99,139.6 204.1,139.48 204.23,139.48 204.35,139.37 204.35,138.27 203.87,137.79 203.87,137.74 203.86,137.73 v4(203.86,137.5)
MAC_DDRA_DQ15: length 59.3
  TOP w0.14: U2.D7 v4(200.86,156.67) ; U1.AU34 v4(198.86,138.5)
  T18 w0.117: v4(198.86,138.5) 198.18,139.17 197.62,139.17 197.51,139.28 197.51,140.3 197.41,140.41 197.27,140.41 197.16,140.3 197.16,139.28 197.06,139.17 196.92,139.17 196.81,139.28 196.81,140.3 196.71,140.41 196.57,140.41 196.46,140.3 196.46,139.28 196.36,139.17 196.21,139.17 196.11,139.28 196.11,140.3 196.01,140.41 195.86,140.41 195.76,140.3 195.76,139.28 195.66,139.17 195.51,139.17 195.41,139.28 195.41,140.3 195.31,140.41 195.16,140.41 195.06,140.3 195.06,139.28 194.96,139.17 194.62,139.17 193.19,140.61 193.19,145.77 193.64,146.22 193.64,149.06 192.14,150.56 192.14,154.24 191.69,154.69 191.69,159.11 192.86,160.27 196.14,160.27 196.26,160.39 196.26,161.99 196.37,162.11 196.61,162.11 196.72,161.99 196.72,160.39 196.84,160.27 197.07,160.27 197.19,160.39 197.19,161.99 197.31,162.11 197.54,162.11 197.66,161.99 197.66,160.39 197.77,160.27 198.01,160.27 198.13,160.39 198.13,161.99 198.24,162.11 198.48,162.11 198.59,161.99 198.59,160.39 198.71,160.27 200.22,160.27 200.46,160.04 200.46,157.07 v4(200.86,156.67)
MAC_DDRA_DQ16: length 57.1
  TOP w0.14: U3.G2 v4(217.83,159.07) ; U1.AN26 v4(206.86,134.5)
  T16 w0.117: v4(217.83,159.07) 218.23,158.67 219.32,158.67 219.98,158.02 220.42,158.02 220.54,158.14 220.54,158.51 220.65,158.63 220.89,158.63 221,158.51 221,158.14 221.12,158.02 221.35,158.02 221.47,158.14 221.47,158.51 221.59,158.63 221.82,158.63 221.94,158.51 221.94,158.14 222.06,158.02 223.58,158.02 223.7,157.9 223.7,157.6 223.81,157.49 224.24,157.49 224.36,157.37 224.36,157.13 224.24,157.02 223.81,157.02 223.7,156.9 223.7,156.67 223.81,156.55 224.24,156.55 224.36,156.43 224.36,156.2 224.24,156.08 223.81,156.08 223.7,155.97 223.7,155.73 223.81,155.62 224.24,155.62 224.36,155.5 224.36,155.27 224.21,155.12 223.42,155.12 223.31,155.01 223.31,154.77 223.42,154.66 224.24,154.66 224.36,154.54 224.36,154.33 224.21,154.19 223.42,154.19 223.31,154.07 223.31,153.84 223.42,153.72 224.24,153.72 224.36,153.6 224.36,153.4 224.21,153.25 223.42,153.25 223.31,153.14 223.31,152.9 223.42,152.79 224.24,152.79 224.36,152.67 224.36,152.46 224.24,152.34 223.48,152.34 223.31,152.17 223.31,151.88 223.42,151.76 225.23,151.76 225.35,151.64 225.35,151.41 225.23,151.29 223.42,151.29 223.31,151.18 223.31,150.86 223.42,150.74 224.16,150.74 224.28,150.63 224.28,150.39 224.16,150.28 223.42,150.28 223.31,150.16 223.31,150.08 223.09,149.87 219.13,149.87 209.37,140.11 209.37,136.34 209.01,135.98 208.66,135.98 208.39,135.71 208.39,135.27 208.12,135.01 207.59,135.01 207.08,134.5 v4(206.86,134.5)
MAC_DDRA_DQ17: length 54.4
  TOP w0.14: U1.AN30 v4(202.86,134.5) ; U3.F7 v4(213.03,158.27)
  T16 w0.117: v4(213.03,158.27) 213.53,158.27 213.65,158.39 213.65,158.57 213.76,158.69 215.53,158.69 215.64,158.8 215.64,159.04 215.53,159.16 213.76,159.16 213.65,159.27 213.65,159.51 213.76,159.62 215.53,159.62 215.64,159.74 215.64,159.97 215.53,160.09 213.76,160.09 213.65,160.21 213.65,160.48 213.53,160.59 210.37,160.59 210.16,160.38 210.16,160.17 210.04,160.05 209.72,160.05 209.6,159.94 209.6,159.7 209.72,159.58 210.04,159.58 210.16,159.47 210.16,159.23 210.04,159.12 209.72,159.12 209.6,159 209.6,158.77 209.72,158.65 210.04,158.65 210.16,158.53 210.16,158.3 210.04,158.18 209.72,158.18 209.6,158.07 209.6,157.83 209.72,157.72 210.04,157.72 210.16,157.6 210.16,156.82 210.04,156.71 209.72,156.71 209.6,156.59 209.6,156.36 209.72,156.24 210.04,156.24 210.16,156.12 210.16,155.89 210.04,155.77 209.72,155.77 209.6,155.65 209.6,155.42 209.72,155.3 210.04,155.3 210.16,155.19 210.16,154.95 210.04,154.84 209.72,154.84 209.6,154.72 209.6,154.49 209.72,154.37 210.04,154.37 210.16,154.25 210.16,152.82 210.04,152.71 209.31,152.71 209.19,152.59 209.19,152.35 209.31,152.24 210.04,152.24 210.16,152.12 210.16,151.89 210.04,151.77 209.31,151.77 209.19,151.65 209.19,151.42 209.31,151.3 210.04,151.3 210.16,151.19 210.16,150.95 210.04,150.84 209.31,150.84 209.19,150.72 209.19,150.49 209.31,150.37 210.04,150.37 210.16,150.25 210.16,149.59 202.44,141.86 202.44,134.92 v4(202.86,134.5)
MAC_DDRA_DQ18: length 56.7
  TOP w0.14: U3.H3 v4(217.03,159.87) ; U1.AM26 v4(206.86,133.5)
  T16 w0.117: v4(217.03,159.87) 217.43,159.47 217.43,158.11 217.67,157.87 219.31,157.87 219.43,157.76 219.43,154.68 219.54,154.56 219.78,154.56 219.89,154.68 219.89,157.32 220.01,157.43 222.41,157.43 222.73,157.12 222.73,156.75 222.61,156.63 221.91,156.63 221.79,156.51 221.79,156.28 221.96,156.11 223,156.11 223.11,156 223.11,155.76 223,155.64 221.91,155.64 221.79,155.53 221.79,155.35 221.91,155.23 222.61,155.23 222.73,155.11 222.73,154.76 222.61,154.65 222.34,154.65 222.22,154.53 222.22,154.29 222.34,154.18 222.61,154.18 222.73,154.06 222.73,150.7 222.47,150.44 218.06,150.44 217.94,150.33 217.94,149.5 217.82,149.38 217.59,149.38 217.47,149.5 217.47,150.35 217.33,150.5 216.94,150.5 216.85,150.4 216.85,148.45 216.82,148.43 209.14,140.74 209.14,140.73 208.35,139.94 208.35,139.68 208.46,139.56 208.82,139.56 208.94,139.45 208.94,139.21 208.82,139.09 208.46,139.09 208.35,138.98 208.35,136.26 208.04,135.95 207.58,135.95 207.32,135.69 207.32,135.26 207.06,135 206.7,135 206.39,134.69 206.39,133.61 206.51,133.5 v4(206.86,133.5)
MAC_DDRA_DQ19: length 54.5
  TOP w0.14: U1.AN29 v4(203.86,134.5) ; U3.H7 v4(213.03,159.87)
  T16 w0.117: v4(203.86,134.5) 204.35,134.99 204.35,139.26 206.38,141.29 206.38,141.29 206.79,141.7 206.79,141.72 210.2,145.12 210.2,145.28 208.93,146.55 208.93,146.71 209.1,146.88 209.26,146.88 210.53,145.61 210.69,145.61 210.86,145.78 210.86,145.95 209.6,147.21 209.6,147.37 209.76,147.54 209.93,147.54 211.19,146.28 211.35,146.28 211.52,146.44 211.52,146.61 210.26,147.87 210.26,148.03 210.42,148.2 210.59,148.2 211.85,146.94 212.01,146.94 212.63,147.55 212.63,148.36 212.51,148.48 211.55,148.48 211.43,148.59 211.43,148.83 211.55,148.94 212.51,148.94 212.63,149.06 212.63,149.29 212.51,149.41 211.55,149.41 211.43,149.53 211.43,149.76 211.55,149.88 212.51,149.88 212.63,149.99 212.63,150.23 212.51,150.35 211.55,150.35 211.43,150.46 211.43,150.7 211.55,150.81 212.51,150.81 212.63,150.93 212.63,151.16 212.51,151.28 211.55,151.28 211.43,151.4 211.43,151.63 211.55,151.75 212.51,151.75 212.63,151.86 212.63,152.1 212.51,152.21 211.55,152.21 211.43,152.33 211.43,152.57 211.55,152.68 212.51,152.68 212.63,152.8 212.63,153.03 212.51,153.15 211.55,153.15 211.43,153.27 211.43,153.5 211.55,153.62 212.51,153.62 212.63,153.73 212.63,159.47 v4(213.03,159.87)
MAC_DDRA_DQ20: length 55.3
  TOP w0.14: U3.H2 v4(217.83,159.87) ; U1.AM28 v4(204.86,133.5)
  T16 w0.117: v4(217.83,159.87) 218.23,159.47 218.8,159.47 219.06,159.21 219.5,159.21 219.61,159.33 219.61,159.91 219.73,160.03 219.96,160.03 220.08,159.91 220.08,159.33 220.2,159.21 220.43,159.21 220.55,159.33 220.55,159.91 220.66,160.03 220.9,160.03 221.01,159.91 221.01,159.33 221.13,159.21 221.48,159.21 221.6,159.33 221.6,159.96 221.72,160.08 221.95,160.08 222.07,159.96 222.07,159.33 222.19,159.21 222.4,159.21 222.52,159.1 222.52,158.75 222.64,158.63 222.87,158.63 222.99,158.75 222.99,159.1 223.1,159.21 223.32,159.21 224.93,157.61 224.93,153 225.96,151.97 225.96,150.69 225.84,150.57 225.03,150.57 224.92,150.45 224.92,150.22 225.03,150.1 225.84,150.1 225.96,149.99 225.96,149.56 225.69,149.3 219.37,149.3 210.35,140.28 210.35,136.42 209.9,135.97 209.77,135.97 209.36,135.57 209.36,135.43 208.92,134.99 208.79,134.99 208.37,134.57 208.37,134.43 207.95,134.02 207.82,134.02 207.33,133.54 207.33,133.4 206.95,133.02 205.34,133.02 v4(204.86,133.5)
MAC_DDRA_DQ21: length 55.5
  TOP w0.14: U1.AM29 v4(203.86,133.5) ; U3.H8 v4(212.23,159.87)
  T16 w0.117: v4(203.86,133.5) 203.35,134 203.35,141.97 203.46,142.07 203.62,142.07 204.74,140.96 204.91,140.96 205.07,141.12 205.07,141.29 203.95,142.4 203.95,142.57 204.12,142.73 204.28,142.73 205.4,141.62 205.57,141.62 205.73,141.78 205.73,141.95 204.62,143.07 204.62,143.23 204.78,143.4 204.95,143.4 206.06,142.28 206.23,142.28 206.39,142.44 206.39,142.61 205.28,143.73 205.28,143.89 205.44,144.06 205.61,144.06 206.73,142.94 206.89,142.94 207.06,143.11 207.06,143.27 205.94,144.39 205.94,144.55 206.1,144.72 206.27,144.72 207.39,143.6 207.55,143.6 207.72,143.77 207.72,143.93 206.6,145.05 206.6,145.21 206.77,145.38 206.93,145.38 208.05,144.26 208.21,144.26 208.38,144.43 208.38,144.59 207.26,145.71 207.26,145.88 207.43,146.04 207.59,146.04 208.71,144.92 208.87,144.92 209.04,145.09 209.04,145.25 207.92,146.37 207.92,146.54 210.82,149.44 210.82,159.27 211.03,159.47 211.83,159.47 v4(212.23,159.87)
MAC_DDRA_DQ22: length 58.2
  TOP w0.14: U3.J3 v4(217.03,161.47) ; U1.AL25 v4(207.86,132.5)
  T16 w0.117: v4(217.03,161.47) 217.03,161.15 217.24,160.94 218.92,160.94 219.25,161.27 219.89,161.27 220.01,161.39 220.01,161.59 220.12,161.7 220.36,161.7 220.48,161.59 220.48,161.39 220.59,161.27 220.83,161.27 220.94,161.39 220.94,161.59 221.06,161.7 221.29,161.7 221.41,161.59 221.41,161.39 221.53,161.27 221.76,161.27 221.88,161.39 221.88,161.59 221.99,161.7 222.23,161.7 222.34,161.59 222.34,161.39 222.46,161.27 222.7,161.27 222.81,161.39 222.81,161.59 222.93,161.7 223.16,161.7 223.28,161.59 223.28,161.39 223.4,161.27 223.63,161.27 223.75,161.39 223.75,161.59 223.86,161.7 224.1,161.7 224.21,161.59 224.21,161.39 224.33,161.27 224.64,161.27 225.35,160.56 227.91,160.56 228.37,160.1 228.37,150.32 226.2,148.15 219.91,148.15 212.35,140.58 212.35,134.29 212.07,134.02 209.68,134.02 209.35,133.68 209.35,133.28 209.08,133 208.37,133 v4(207.86,132.5)
MAC_DDRA_DQ23: length 56.8
  TOP w0.14: U3.J7 v4(213.83,161.47) ; U1.AL28 v4(204.86,132.5)
  T16 w0.117: v4(204.86,132.5) 205.32,132.04 206.97,132.04 207.39,132.46 207.39,132.59 207.8,133 207.94,133 208.37,133.44 208.37,133.58 208.85,134.05 208.99,134.05 209.91,134.97 210.91,134.97 211.35,135.42 211.35,140.46 219.61,148.72 225.96,148.72 226.67,149.43 226.67,152.33 225.7,153.29 225.7,159.24 224.28,160.66 219.46,160.66 219.18,160.38 216.33,160.38 215.24,161.47 v4(213.83,161.47)
MAC_DDRA_DQ24: length 57.7
  TOP w0.14: U3.A3 v4(217.03,154.27) ; U1.AK26 v4(206.86,131.5)
  T05 w0.117: v4(206.86,131.5) 207.32,131.95 207.32,139.8 207.64,140.11 207.64,140.28 206.96,140.96 206.96,141.13 207.12,141.29 207.29,141.29 207.97,140.61 208.13,140.61 208.3,140.78 208.3,140.94 207.62,141.62 207.62,141.79 207.78,141.95 207.95,141.95 208.63,141.27 208.79,141.27 208.96,141.44 208.96,141.6 208.28,142.28 208.28,142.45 208.44,142.61 208.61,142.61 209.29,141.93 209.46,141.93 209.62,142.1 209.62,142.26 208.94,142.94 208.94,143.11 209.11,143.28 209.27,143.28 209.95,142.59 210.12,142.59 210.53,143.01 210.53,143.18 209.36,144.35 209.36,144.52 209.52,144.68 209.69,144.68 210.23,144.15 210.87,143.51 211.03,143.51 211.39,143.87 211.39,144.03 211.27,144.15 211.09,144.33 211.02,144.39 211.02,144.56 211.19,144.72 211.36,144.72 211.72,144.36 211.88,144.36 213.2,145.67 213.2,145.97 213.31,146.09 213.7,146.09 213.82,146.21 213.82,146.44 213.7,146.56 213.31,146.56 213.2,146.67 213.2,146.91 213.31,147.02 213.7,147.02 213.82,147.14 213.82,147.38 213.7,147.49 213.31,147.49 213.2,147.61 213.2,148.03 213.47,148.3 213.63,148.3 214.74,147.19 214.9,147.19 215.07,147.36 215.07,147.53 213.96,148.63 213.96,148.8 214.13,148.96 214.29,148.96 215.4,147.86 215.56,147.86 215.73,148.02 215.73,148.19 214.63,149.29 214.63,149.46 214.79,149.62 214.96,149.62 216.06,148.52 216.23,148.52 216.39,148.68 216.39,148.85 215.29,149.95 215.29,150.12 215.45,150.28 215.62,150.28 216.72,149.18 216.89,149.18 217.05,149.34 217.05,149.51 215.95,150.61 215.95,150.78 216.27,151.1 216.44,151.1 216.74,150.8 216.91,150.8 217.07,150.96 217.07,151.13 216.77,151.43 216.77,151.6 217.03,151.86 v4(217.03,154.27)
MAC_DDRA_DQ25: length 52
  TOP w0.14: U1.AM32 v4(200.86,133.5) ; U3.B8 v4(212.23,155.07)
  T05 w0.117: v4(212.23,155.07) 211.83,154.67 211.04,154.67 210.92,154.56 210.92,152.81 210.08,151.97 199.74,151.97 198.32,150.55 198.32,150.32 198.21,150.2 197.42,150.2 197.31,150.08 197.31,149.85 197.42,149.73 198.21,149.73 198.32,149.62 198.32,149.38 198.21,149.27 197.42,149.27 197.31,149.15 197.31,148.92 197.42,148.8 198.21,148.8 198.32,148.68 198.32,148.45 198.21,148.33 197.42,148.33 197.31,148.21 197.31,147.98 197.42,147.86 198.21,147.86 198.32,147.75 198.32,147.51 198.21,147.4 197.42,147.4 197.31,147.28 197.31,147.05 197.42,146.93 198.21,146.93 198.32,146.81 198.32,146.58 198.21,146.46 197.42,146.46 197.31,146.35 197.31,146.11 197.42,145.99 198.21,145.99 198.32,145.88 198.32,145.64 198.21,145.53 197.42,145.53 197.31,145.41 197.31,145.18 197.42,145.06 198.21,145.06 198.32,144.94 198.32,144.71 198.21,144.59 197.42,144.59 197.31,144.48 197.31,144.24 197.42,144.13 198.21,144.13 198.32,144.01 198.32,143.77 198.21,143.66 197.42,143.66 197.31,143.54 197.31,143.31 197.42,143.19 198.21,143.19 198.32,143.07 198.32,142.84 198.21,142.72 197.42,142.72 197.31,142.61 197.31,142.37 197.42,142.26 198.21,142.26 198.32,142.14 198.32,141.92 200.38,139.86 200.38,133.98 v4(200.86,133.5)
MAC_DDRA_DQ26: length 59.6
  TOP w0.14: U3.C3 v4(217.03,155.87) ; U1.AH27 v4(205.86,129.5)
  T05 w0.117: v4(205.86,129.5) 206.3,129.94 206.3,130.7 206.58,130.99 208.07,130.99 208.38,131.3 208.38,139.83 210.99,142.45 211.16,142.45 213.18,140.43 213.34,140.43 213.51,140.59 213.51,140.76 211.49,142.78 211.49,142.94 211.66,143.11 211.82,143.11 213.84,141.09 214,141.09 214.17,141.25 214.17,141.42 212.15,143.44 212.15,143.6 212.41,143.87 212.58,143.87 214.32,142.13 214.48,142.13 214.65,142.29 214.65,142.46 212.91,144.2 212.91,144.36 213.28,144.73 213.45,144.73 214.3,143.88 214.46,143.88 214.63,144.05 214.63,144.21 213.78,145.06 213.78,145.23 217.66,149.11 217.66,150.17 217.77,150.29 218.47,150.29 218.59,150.4 218.59,150.64 218.47,150.76 217.77,150.76 217.66,150.87 217.66,151.11 217.77,151.22 218.47,151.22 218.59,151.34 218.59,151.57 218.47,151.69 217.77,151.69 217.66,151.81 217.66,152.04 217.77,152.16 218.47,152.16 218.59,152.27 218.59,152.51 218.47,152.62 217.77,152.62 217.66,152.74 217.66,152.98 217.77,153.09 218.47,153.09 218.59,153.21 218.59,153.44 218.47,153.56 217.77,153.56 217.66,153.68 217.66,153.88 217.43,154.11 217.43,155.47 v4(217.03,155.87)
MAC_DDRA_DQ27: length 56.3
  TOP w0.14: U1.AK30 v4(202.86,131.5) ; U3.C7 v4(213.03,155.87)
  T05 w0.117: v4(202.86,131.5) 202.86,132.39 203.27,132.8 203.27,140.3 202.06,141.51 202.06,141.98 201.94,142.1 201.51,142.1 201.4,142.22 201.4,142.45 201.51,142.57 201.94,142.57 202.06,142.69 202.06,142.95 202.17,143.07 203.34,143.07 203.45,143.19 203.45,143.42 203.34,143.54 202.17,143.54 202.06,143.65 202.06,143.89 202.17,144 203.34,144 203.45,144.12 203.45,144.35 203.34,144.47 202.17,144.47 202.06,144.59 202.06,144.82 202.17,144.94 203.34,144.94 203.45,145.06 203.45,145.29 203.34,145.41 202.17,145.41 202.06,145.52 202.06,145.76 202.17,145.87 203.34,145.87 203.45,145.99 203.45,146.22 203.34,146.34 202.17,146.34 202.06,146.46 202.06,146.69 202.17,146.81 203.34,146.81 203.45,146.92 203.45,147.16 203.34,147.28 202.17,147.28 202.06,147.39 202.06,147.63 202.17,147.74 203.34,147.74 203.45,147.86 203.45,148.09 203.34,148.21 202.17,148.21 202.06,148.33 202.06,148.56 202.17,148.68 203.34,148.68 203.45,148.79 203.45,149.03 203.34,149.14 202.17,149.14 202.06,149.26 202.06,149.94 202.17,150.06 211.1,150.06 214.46,153.41 214.46,155.08 213.67,155.87 v4(213.03,155.87)
MAC_DDRA_DQ28: length 59.4
  TOP w0.14: U3.C2 v4(217.83,155.87) ; U1.AJ26 v4(206.86,130.5)
  T05 w0.117: v4(206.86,130.5) 206.86,130.44 207.27,130.03 209.12,130.03 209.39,130.3 209.39,139.05 209.54,139.2 210.04,139.2 210.14,139.3 210.14,139.71 210.04,139.81 209.29,139.81 209.19,139.91 209.19,140.11 209.29,140.21 210.04,140.21 210.14,140.32 210.14,140.77 210.24,140.87 210.45,140.87 210.55,140.77 210.55,139.3 210.65,139.2 210.92,139.2 211.02,139.3 211.02,141.36 211.13,141.46 211.33,141.46 211.43,141.36 211.43,139.3 211.53,139.2 211.76,139.2 211.86,139.3 211.86,140.62 211.96,140.72 212.17,140.72 212.27,140.62 212.27,139.3 212.37,139.2 212.8,139.2 212.9,139.3 212.9,139.98 213,140.09 213.2,140.09 213.31,139.98 213.31,139.3 213.41,139.2 213.61,139.2 213.71,139.3 213.71,139.98 213.81,140.09 214.02,140.09 214.12,139.98 214.12,139.3 214.22,139.2 215.14,139.2 215.24,139.3 215.24,139.53 215.12,139.64 214.77,139.64 214.65,139.76 214.65,139.99 214.77,140.11 215.25,140.11 215.37,140.23 215.37,140.46 215.25,140.58 214.77,140.58 214.65,140.69 214.65,140.93 214.77,141.05 215.12,141.05 215.24,141.16 215.24,141.44 215.36,141.55 215.81,141.55 215.92,141.67 215.92,141.9 215.81,142.02 215.36,142.02 215.24,142.14 215.24,142.37 215.36,142.49 215.81,142.49 215.92,142.6 215.92,142.84 215.81,142.95 215.36,142.95 215.24,143.07 215.24,143.31 215.36,143.42 215.81,143.42 215.92,143.54 215.92,143.77 215.81,143.89 215.36,143.89 215.24,144.01 215.24,144.24 215.36,144.36 215.81,144.36 215.92,144.47 215.92,144.71 215.81,144.82 215.36,144.82 215.24,144.94 215.24,145.88 219.21,149.85 219.21,155.14 218.88,155.47 218.23,155.47 v4(217.83,155.87)
MAC_DDRA_DQ29: length 57.2
  TOP w0.14: U1.AK29 v4(203.86,131.5) ; U3.C8 v4(212.23,155.87)
  T05 w0.117: v4(212.23,155.87) U3.C8 214.04,156.27 215.11,155.21 215.11,153.17 211.4,149.46 204.44,149.46 204.32,149.34 204.32,149.07 204.44,148.95 205.27,148.95 205.38,148.84 205.38,148.6 205.27,148.49 204.26,148.49 204.14,148.37 204.14,148.14 204.26,148.02 205.27,148.02 205.38,147.9 205.38,147.67 205.27,147.55 204.26,147.55 204.14,147.44 204.14,147.2 204.26,147.09 205.27,147.09 205.38,146.97 205.38,146.73 205.27,146.62 204.26,146.62 204.14,146.5 204.14,146.27 204.26,146.15 205.27,146.15 205.38,146.03 205.38,145.8 205.27,145.68 204.26,145.68 204.14,145.57 204.14,145.33 204.26,145.22 205.27,145.22 205.38,145.1 205.38,144.87 205.27,144.75 204.26,144.75 204.14,144.63 204.14,144.4 204.26,144.28 205.27,144.28 205.38,144.16 205.38,143.93 205.27,143.81 204.26,143.81 204.14,143.7 204.14,143.46 204.26,143.35 205.27,143.35 205.38,143.23 205.38,143 205.27,142.88 204.44,142.88 204.32,142.76 204.32,142.61 204.2,142.49 202.78,142.49 202.67,142.38 202.67,142.14 202.78,142.03 204.2,142.03 204.32,141.91 204.32,141.64 204.2,141.52 203.37,141.52 203.25,141.4 203.25,141.17 203.37,141.05 204.2,141.05 204.32,140.94 204.32,132.22 203.86,131.75 v4(203.86,131.5)
MAC_DDRA_DQ30: length 58.1
  TOP w0.14: U1.AK27 v4(205.86,131.5) ; U3.D3 v4(217.03,156.67)
  T05 w0.117: v4(205.86,131.5) 206.37,132.01 206.37,139.17 206.26,139.29 205.96,139.29 205.84,139.41 205.84,139.64 205.96,139.76 206.26,139.76 206.37,139.88 206.37,140.11 206.26,140.23 205.96,140.23 205.84,140.34 205.84,140.58 205.96,140.69 206.26,140.69 206.37,140.81 206.37,141.65 206.69,141.96 206.69,142.12 206.59,142.22 206.59,142.39 206.75,142.55 206.92,142.55 207.02,142.45 207.18,142.45 207.97,143.24 207.97,143.41 207.61,143.77 207.61,143.94 207.77,144.1 207.94,144.1 208.3,143.74 208.47,143.74 208.7,143.98 208.7,145.19 208.82,145.31 211.92,145.31 212.04,145.42 212.04,145.66 211.92,145.77 208.82,145.77 208.7,145.89 208.7,146.15 208.82,146.27 212.51,146.27 212.62,146.38 212.62,146.62 212.51,146.74 208.82,146.74 208.7,146.85 208.7,147.09 208.82,147.2 212.51,147.2 212.62,147.32 212.62,147.55 212.51,147.67 208.82,147.67 208.7,147.79 208.7,148.11 208.82,148.22 212.58,148.22 216.4,152.04 216.4,156.04 v4(217.03,156.67)
MAC_DDRA_DQ31: length 57.3
  TOP w0.14: U3.D7 v4(213.03,156.67) ; U1.AJ29 v4(203.86,130.5)
  T05 w0.117: v4(203.86,130.5) 203.36,131 201.62,131 201.35,131.26 201.35,131.71 201.09,131.96 200.65,131.96 200.33,132.28 200.33,132.69 200.01,133.01 199.62,133.01 199.35,133.29 199.35,138.91 199.01,139.24 199.01,139.41 199.41,139.8 199.41,139.97 199.27,140.11 199.1,140.11 198.05,139.05 197.88,139.05 197.72,139.22 197.72,139.38 198.75,140.41 198.75,140.63 198.58,140.79 198.39,140.79 197.11,139.51 196.94,139.51 196.78,139.68 196.78,139.84 198.07,141.14 198.07,141.3 197.92,141.45 197.75,141.45 197.36,141.06 196.76,141.06 196.65,141.18 196.65,150.32 197.35,151.03 197.51,151.03 197.67,150.87 197.83,150.87 198,151.04 198,151.2 197.84,151.36 197.84,151.52 198.01,151.69 198.17,151.69 198.33,151.53 198.49,151.53 198.66,151.7 198.66,151.87 198.51,152.02 198.51,152.18 198.93,152.61 206.35,152.61 206.46,152.73 206.46,152.82 206.58,152.94 206.81,152.94 206.93,152.82 206.93,152.73 207.05,152.61 207.28,152.61 207.4,152.73 207.4,152.82 207.51,152.94 207.75,152.94 207.87,152.82 207.87,152.73 207.98,152.61 209.57,152.61 210.29,153.33 210.29,156.32 211.04,157.07 212.63,157.07 v4(213.03,156.67)
MAC_DDRA_DQS0_DN: length 58
  TOP w0.14: U1.AU36 v4(196.86,138.5) ; U2.F3 v4(204.86,158.27)
  T16 w0.107: v4(204.86,158.27) 204.6,158.53 204.22,158.53 203.84,158.16 203.84,157.94 203.95,157.84 203.96,157.84 204.06,157.73 204.06,157.52 203.96,157.41 203.95,157.41 203.84,157.3 203.84,157.09 203.95,156.98 203.96,156.98 204.06,156.88 204.06,156.66 203.96,156.56 203.95,156.56 203.84,156.45 203.84,156.06 201.23,153.45 197.06,153.45 196.67,153.06 196.67,152.91 196.78,152.8 201.28,152.8 201.55,152.53 201.55,152.12 201.26,151.83 196.87,151.83 196.67,151.63 196.67,151.38 196.78,151.27 200.62,151.27 200.89,151 200.89,150.58 200.59,150.29 196.8,150.29 196.67,150.16 196.67,149.73 196.78,149.63 198.92,149.63 199.19,149.36 199.19,148.91 198.92,148.64 196.78,148.64 196.67,148.53 196.67,147.86 196.78,147.76 197.29,147.76 197.56,147.49 197.56,147.04 197.29,146.77 196.78,146.77 196.67,146.66 196.67,146.45 196.78,146.34 197.29,146.34 197.56,146.07 197.56,145.63 197.29,145.36 196.78,145.36 196.67,145.25 196.67,145.04 196.78,144.93 197.29,144.93 197.56,144.66 197.56,144.22 197.29,143.95 196.78,143.95 196.67,143.84 196.67,143.63 196.78,143.52 197.29,143.52 197.56,143.25 197.56,142.8 197.29,142.53 196.78,142.53 196.67,142.43 196.67,142.21 196.78,142.11 197.29,142.11 197.56,141.84 197.56,141.39 197.29,141.12 196.78,141.12 196.67,141.01 196.67,140.76 196.46,140.55 196.46,140.19 196.57,140.08 196.59,140.08 196.7,139.97 196.7,139.76 196.59,139.65 196.57,139.65 196.46,139.55 196.46,139.33 196.57,139.23 196.59,139.23 196.7,139.12 196.7,138.9 196.59,138.8 196.57,138.8 196.46,138.69 196.46,138.25 196.58,138.13 196.75,138.13 196.86,138.24 v4(196.86,138.5)
MAC_DDRA_DQS0_DP: length 58.1
  TOP w0.14: U2.G3 v4(204.86,159.07) ; U1.AT36 v4(196.86,137.5)
  T16 w0.107: v4(204.86,159.07) 204.6,158.81 204.11,158.81 203.56,158.27 203.56,156.17 201.12,153.73 196.94,153.73 196.39,153.18 196.39,152.79 196.66,152.52 201.17,152.52 201.27,152.42 201.27,152.24 201.14,152.11 196.75,152.11 196.39,151.74 196.39,151.26 196.66,150.99 200.5,150.99 200.61,150.89 200.61,150.7 200.48,150.57 196.69,150.57 196.39,150.27 196.39,149.62 196.66,149.35 198.8,149.35 198.91,149.24 198.91,149.03 198.8,148.92 196.66,148.92 196.39,148.65 196.39,147.75 196.66,147.48 197.17,147.48 197.28,147.37 197.28,147.16 197.17,147.05 196.66,147.05 196.39,146.78 196.39,146.33 196.66,146.06 197.17,146.06 197.28,145.96 197.28,145.74 197.17,145.64 196.66,145.64 196.39,145.37 196.39,144.92 196.66,144.65 197.17,144.65 197.28,144.55 197.28,144.33 197.17,144.23 196.66,144.23 196.39,143.96 196.39,143.51 196.66,143.24 197.17,143.24 197.28,143.13 197.28,142.92 197.17,142.81 196.66,142.81 196.39,142.54 196.39,142.1 196.66,141.83 197.17,141.83 197.28,141.72 197.28,141.51 197.17,141.4 196.66,141.4 196.39,141.13 196.39,140.87 196.18,140.67 196.18,138.14 196.46,137.86 196.75,137.86 196.86,137.75 v4(196.86,137.5)
MAC_DDRA_DQS1_DN: length 59.3
  TOP w0.14: U2.A7 v4(200.86,154.27) ; U1.AU30 v4(202.86,138.5)
  T18 w0.107: v4(200.86,154.27) 200.74,154.16 200.74,153.86 200.32,153.45 199.97,153.45 199.86,153.34 199.86,147.06 199.59,146.79 199.15,146.79 198.88,147.06 198.88,153.34 198.77,153.45 198.56,153.45 198.45,153.34 198.45,147.06 198.18,146.79 197.74,146.79 197.47,147.06 197.47,153.37 197.36,153.47 197.14,153.47 197.03,153.37 197.03,151.43 196.76,151.16 196.31,151.16 196.04,151.43 196.04,153.34 195.94,153.45 195.29,153.45 194.92,153.08 194.92,151.68 196.07,150.53 196.22,150.53 196.24,150.55 196.4,150.55 196.55,150.4 196.55,150.25 196.53,150.23 196.53,150.07 196.85,149.75 196.85,146.37 197.12,146.11 201.67,146.11 202.5,145.28 202.5,140.36 202.61,140.25 202.66,140.25 202.77,140.15 202.77,139.93 202.66,139.82 202.61,139.82 202.5,139.72 202.5,139.5 202.61,139.4 202.66,139.4 202.77,139.29 202.77,139.08 202.66,138.97 202.61,138.97 202.5,138.86 202.5,138.6 202.61,138.5 v4(202.86,138.5)
