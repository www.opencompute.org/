# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAC_DDRC_DQ01: length 54
  TOP w0.14: U1.AD2 v4(231.86,125.5) ; U6.F7 v4(254.1,124.26)
  T05 w0.117: v4(231.86,125.5) 231.86,125.8 232,125.94 233.64,125.94 233.96,126.26 238.06,126.26 238.69,125.63 238.86,125.63 239.35,126.12 239.52,126.12 239.68,125.95 239.68,125.79 239.19,125.29 239.19,125.13 239.35,124.96 239.52,124.96 240.01,125.46 240.18,125.46 240.34,125.29 240.34,125.13 239.85,124.63 239.85,124.47 240.05,124.26 240.64,124.26 240.76,124.38 240.76,125.64 240.88,125.76 241.11,125.76 241.23,125.64 241.23,124.38 241.34,124.26 241.58,124.26 241.69,124.38 241.69,125.64 241.81,125.76 242.04,125.76 242.16,125.64 242.16,124.38 242.28,124.26 242.51,124.26 242.63,124.38 242.63,125.64 242.75,125.76 242.98,125.76 243.1,125.64 243.1,124.38 243.21,124.26 243.45,124.26 243.56,124.38 243.56,125.64 243.68,125.76 243.91,125.76 244.03,125.64 244.03,124.38 244.15,124.26 244.38,124.26 244.5,124.38 244.5,125.64 244.61,125.76 244.85,125.76 244.96,125.64 244.96,124.38 245.08,124.26 245.32,124.26 245.43,124.38 245.43,125.64 245.55,125.76 245.78,125.76 245.9,125.64 245.9,124.38 246.02,124.26 246.25,124.26 246.37,124.38 246.37,125.64 246.48,125.76 246.72,125.76 246.83,125.64 246.83,124.38 246.95,124.26 247.18,124.26 247.3,124.38 247.3,125.64 247.42,125.76 247.65,125.76 247.77,125.64 247.77,124.38 247.89,124.26 248.12,124.26 248.24,124.38 248.24,125.64 248.35,125.76 248.59,125.76 248.7,125.64 248.7,125.49 248.82,125.37 249.16,125.37 249.27,125.26 249.27,125.02 249.16,124.9 248.82,124.9 248.7,124.79 248.7,124.38 248.82,124.26 249.46,124.26 249.58,124.38 249.58,124.55 249.7,124.66 253.99,124.66 254.1,124.55 v4(254.1,124.26)
MAC_DDRC_DQ02: length 56.4
  TOP w0.14: U6.H3 v4(255.7,120.26) ; U1.AB3 v4(230.86,123.5)
  T05 w0.117: v4(230.86,123.5) 231.17,123.5 231.35,123.31 231.35,121.35 231.06,121.06 229.92,121.06 229.77,120.91 229.77,120.06 229.88,119.94 230.18,119.94 230.3,120.06 230.3,120.59 230.44,120.73 230.65,120.73 230.77,120.61 230.77,120.08 230.88,119.96 231.12,119.96 231.23,120.08 231.23,120.59 231.38,120.73 231.61,120.73 231.73,120.61 231.73,120.04 231.84,119.92 232.28,119.92 232.41,120.05 232.41,120.81 232.59,120.99 233.48,120.99 239.73,114.73 249.54,114.73 249.64,114.83 249.64,115.11 249.74,115.21 249.89,115.21 249.99,115.11 249.99,114.83 250.09,114.73 250.24,114.73 250.34,114.83 250.34,115.11 250.45,115.21 250.59,115.21 250.69,115.11 250.69,114.83 250.8,114.73 250.94,114.73 251.04,114.83 251.04,115.11 251.15,115.21 251.29,115.21 251.39,115.11 251.39,114.83 251.5,114.73 251.64,114.73 251.74,114.83 251.74,115.11 251.85,115.21 251.99,115.21 252.1,115.11 252.1,114.83 252.2,114.73 252.34,114.73 252.45,114.83 252.45,115.11 252.55,115.21 252.69,115.21 252.8,115.11 252.8,114.83 252.9,114.73 253.04,114.73 253.15,114.83 253.15,115.11 253.25,115.21 253.39,115.21 253.5,115.11 253.5,114.83 253.6,114.73 253.75,114.73 253.85,114.83 253.85,115.11 253.95,115.21 254.1,115.21 254.2,115.11 254.2,114.83 254.3,114.73 254.45,114.73 254.55,114.83 254.55,115.11 254.65,115.21 254.8,115.21 254.9,115.11 254.9,114.83 255,114.73 258.94,114.73 259.56,115.36 259.56,117.63 259.31,117.88 257.12,117.88 256.69,118.31 256.69,119.71 256.14,120.26 v4(255.7,120.26)
MAC_DDRC_DQ03: length 51.9
  TOP w0.14: U6.H7 v4(255.7,124.26) ; U1.AE1 v4(232.86,126.5)
  T05 w0.117: v4(232.86,126.5) 233.47,126.5 233.75,126.78 234.32,126.78 234.44,126.89 234.44,127.63 234.56,127.74 234.79,127.74 234.91,127.63 234.91,126.94 235.02,126.83 235.24,126.83 235.37,126.97 235.37,127.63 235.49,127.74 235.72,127.74 235.84,127.63 235.84,126.94 235.95,126.83 236.17,126.83 236.31,126.97 236.31,127.63 236.42,127.74 236.66,127.74 236.77,127.63 236.77,126.94 236.89,126.83 237.11,126.83 237.24,126.97 237.24,127.63 237.36,127.74 237.59,127.74 237.71,127.63 237.71,126.94 237.82,126.83 238.04,126.83 238.18,126.97 238.18,127.63 238.29,127.74 238.5,127.74 238.62,127.63 238.62,126.67 238.74,126.55 238.97,126.55 239.09,126.67 239.09,127.6 239.23,127.74 239.46,127.74 239.58,127.63 239.58,126.87 240.1,126.35 240.82,126.35 240.94,126.46 240.94,127.24 241.06,127.36 241.29,127.36 241.41,127.24 241.41,126.46 241.52,126.35 241.76,126.35 241.87,126.46 241.87,127.24 241.99,127.36 242.22,127.36 242.34,127.24 242.34,126.46 242.46,126.35 242.69,126.35 242.81,126.46 242.81,127.24 242.92,127.36 243.16,127.36 243.28,127.24 243.28,126.46 243.39,126.35 243.63,126.35 243.74,126.46 243.74,127.24 243.86,127.36 244.09,127.36 244.21,127.24 244.21,126.46 244.33,126.35 244.56,126.35 244.68,126.46 244.68,127.24 244.79,127.36 245.03,127.36 245.14,127.24 245.14,126.46 245.26,126.35 245.5,126.35 245.61,126.46 245.61,127.24 245.73,127.36 245.96,127.36 246.08,127.24 246.08,126.46 246.2,126.35 246.43,126.35 246.55,126.46 246.55,127.24 246.66,127.36 246.9,127.36 247.01,127.24 247.01,126.46 247.13,126.35 247.36,126.35 247.48,126.46 247.48,127.24 247.6,127.36 247.83,127.36 247.95,127.24 247.95,126.46 248.07,126.35 248.32,126.35 248.43,126.46 248.43,127.24 248.55,127.36 248.78,127.36 248.9,127.24 248.9,126.46 249.02,126.35 254.39,126.35 254.5,126.23 254.5,124.9 254.74,124.66 255.48,124.66 255.7,124.44 v4(255.7,124.26)
MAC_DDRC_DQ04: length 56
  TOP w0.14: U1.AA2 v4(231.86,122.5) ; U6.H2 v4(255.7,119.46)
  T05 w0.117: v4(255.7,119.46) 256.1,119.06 256.1,118.01 256.84,117.27 258.86,117.27 258.98,117.15 258.98,115.6 258.7,115.32 255.91,115.32 255.66,115.56 255.66,116.47 255.54,116.59 255.31,116.59 255.19,116.47 255.19,115.94 255.07,115.82 254.84,115.82 254.72,115.94 254.72,116.47 254.61,116.59 254.37,116.59 254.26,116.47 254.26,115.94 254.14,115.82 253.87,115.82 253.75,115.95 253.75,116.84 253.62,116.96 249.55,116.96 249.3,116.71 249.3,115.79 248.93,115.42 247.27,115.42 247.17,115.52 247.17,116.1 247.06,116.2 246.92,116.2 246.82,116.1 246.82,115.52 246.71,115.42 246.57,115.42 246.47,115.52 246.47,116.1 246.36,116.2 246.22,116.2 246.11,116.1 246.11,115.52 246.01,115.42 245.87,115.42 245.76,115.52 245.76,116.1 245.66,116.2 245.52,116.2 245.41,116.1 245.41,115.52 245.31,115.42 245.17,115.42 245.06,115.52 245.06,116.1 244.96,116.2 244.82,116.2 244.71,116.1 244.71,115.52 244.61,115.42 244.46,115.42 244.36,115.52 244.36,116.1 244.26,116.2 244.11,116.2 244.01,116.1 244.01,115.52 243.91,115.42 243.76,115.42 243.66,115.52 243.66,116.1 243.56,116.2 243.41,116.2 243.31,116.1 243.31,115.52 243.21,115.42 243.06,115.42 242.96,115.52 242.96,116.1 242.86,116.2 242.71,116.2 242.61,116.1 242.61,115.52 242.51,115.42 242.36,115.42 242.26,115.52 242.26,116.1 242.16,116.2 242.01,116.2 241.91,116.1 241.91,115.52 241.81,115.42 241.52,115.42 241.4,115.53 241.4,116.61 241.05,116.97 238.89,116.97 234.07,121.78 233.91,121.78 233.68,121.55 233.52,121.55 233.35,121.72 233.35,121.89 233.73,122.27 233.73,122.43 233.18,122.99 232.05,122.99 231.86,122.8 v4(231.86,122.5)
MAC_DDRC_DQ05: length 55.1
  TOP w0.14: U1.AD3 v4(230.86,125.5) ; U6.H8 v4(255.7,125.06)
  T05 w0.117: v4(255.7,125.06) 255.42,125.06 255.3,125.18 255.3,126.19 254.4,127.09 249.95,127.09 248.69,128.35 247.76,128.35 247.64,128.23 247.64,128.06 247.52,127.95 247.34,127.95 247.2,128.09 247.2,129.76 247.08,129.87 246.85,129.87 246.73,129.76 246.73,128.09 246.59,127.95 246.4,127.95 246.26,128.09 246.26,129.76 246.15,129.87 245.91,129.87 245.8,129.76 245.8,128.09 245.65,127.95 245.47,127.95 245.33,128.09 245.33,129.76 245.21,129.87 244.98,129.87 244.86,129.76 244.86,128.09 244.72,127.95 244.54,127.95 244.39,128.09 244.39,129.76 244.28,129.87 244.04,129.87 243.93,129.76 243.93,128.09 243.78,127.95 243.6,127.95 243.46,128.09 243.46,129.76 243.34,129.87 243.11,129.87 242.99,129.76 242.99,128.09 242.85,127.95 242.67,127.95 242.52,128.09 242.52,129.76 242.41,129.87 242.17,129.87 242.06,129.76 242.06,128.09 241.91,127.95 241.73,127.95 241.59,128.09 241.59,129.76 241.47,129.87 241.24,129.87 241.12,129.76 241.12,128.09 240.98,127.95 240.75,127.95 240.63,128.06 240.63,128.23 240.51,128.35 234.54,128.35 233.19,127 231.67,127 231.37,126.7 231.37,126.01 v4(230.86,125.5)
MAC_DDRC_DQ06: length 53.4
  TOP w0.14: U1.AE3 v4(230.86,126.5) ; U6.J3 v4(257.3,120.26)
  T05 w0.117: v4(257.3,120.26) 256.86,120.26 256.19,120.93 256.19,126.17 254.69,127.66 254.01,127.66 253.04,128.63 250.28,128.63 249.87,129.04 249.7,129.04 249.33,128.67 249.19,128.67 249,128.85 249,129 249.37,129.37 249.37,129.54 249.08,129.83 248.91,129.83 248.13,129.05 247.96,129.05 247.8,129.22 247.8,129.38 248.58,130.16 248.58,130.33 248.4,130.51 240.53,130.51 240.41,130.39 240.41,129.05 240.29,128.94 240.06,128.94 239.94,129.05 239.94,130.39 239.83,130.51 239.59,130.51 239.48,130.39 239.48,129.05 239.36,128.94 239.13,128.94 239.01,129.05 239.01,130.39 238.89,130.51 238.66,130.51 238.54,130.39 238.54,129.05 238.43,128.94 238.19,128.94 238.07,129.05 238.07,130.39 237.96,130.51 237.71,130.51 237.59,130.39 237.59,129.08 237.48,128.96 237.24,128.96 237.13,129.08 237.13,130.39 237.01,130.51 236.83,130.51 236.31,130 236.31,129.83 236.68,129.46 236.68,129.3 236.52,129.13 236.35,129.13 235.98,129.5 235.82,129.5 235.24,128.93 234.21,128.93 233.25,127.97 231.64,127.97 231.33,127.67 231.33,127.23 230.86,126.76 v4(230.86,126.5)
MAC_DDRC_DQ07: length 55.8
  TOP w0.14: U1.AA3 v4(230.86,122.5) ; U6.J7 v4(257.3,124.26)
  T05 w0.117: v4(230.86,122.5) 230.41,122.05 229.62,122.05 229.36,122.3 229.36,128.78 229.57,128.99 233.25,128.99 233.93,129.67 235.17,129.67 236.59,131.08 237.2,131.08 237.32,131.2 237.32,131.28 237.44,131.4 237.67,131.4 237.79,131.28 237.79,131.2 237.91,131.08 238.14,131.08 238.26,131.2 238.26,131.28 238.37,131.4 238.61,131.4 238.72,131.28 238.72,131.2 238.84,131.08 239.07,131.08 239.19,131.2 239.19,131.28 239.31,131.4 239.54,131.4 239.66,131.28 239.66,131.2 239.78,131.08 240.01,131.08 240.13,131.2 240.13,131.28 240.24,131.4 240.48,131.4 240.59,131.28 240.59,131.2 240.71,131.08 240.94,131.08 241.06,131.2 241.06,131.28 241.18,131.4 241.41,131.4 241.53,131.28 241.53,131.2 241.64,131.08 241.88,131.08 242,131.2 242,131.28 242.11,131.4 242.35,131.4 242.46,131.28 242.46,131.2 242.58,131.08 242.81,131.08 242.93,131.2 242.93,131.28 243.05,131.4 243.28,131.4 243.4,131.28 243.4,131.2 243.51,131.08 243.75,131.08 243.86,131.2 243.86,131.28 243.98,131.4 244.22,131.4 244.33,131.28 244.33,131.2 244.45,131.08 244.68,131.08 244.8,131.2 244.8,131.28 244.92,131.4 245.15,131.4 245.27,131.28 245.27,131.2 245.38,131.08 245.62,131.08 245.73,131.2 245.73,131.28 245.85,131.4 246.08,131.4 246.2,131.28 246.2,131.2 246.32,131.08 246.55,131.08 246.67,131.2 246.67,131.28 246.79,131.4 247.02,131.4 247.14,131.28 247.14,131.2 247.25,131.08 247.49,131.08 247.6,131.2 247.6,131.28 247.72,131.4 247.95,131.4 248.07,131.28 248.07,131.2 248.19,131.08 248.64,131.08 248.65,131.07 248.69,131.07 250.55,129.22 251.04,129.22 251.15,129.33 251.15,129.61 251.27,129.72 251.5,129.72 251.62,129.61 251.62,129.33 251.74,129.22 251.97,129.22 252.09,129.33 252.09,129.61 252.2,129.72 252.44,129.72 252.56,129.61 252.56,129.33 252.67,129.22 252.91,129.22 253.02,129.33 253.02,129.61 253.14,129.72 253.37,129.72 253.49,129.61 253.49,129.33 253.61,129.22 254.51,129.22 254.94,128.79 255.1,128.79 255.88,129.56 256.04,129.56 256.21,129.39 256.21,129.23 255.35,128.37 255.35,127.88 256.43,126.8 256.43,126.8 256.64,126.59 256.64,122.35 256.76,122.23 257.15,122.23 257.28,122.36 257.28,124.24 v4(257.3,124.26)
MAC_DDRC_DQ08: length 49.1
  TOP w0.14: U6.A3 v4(250.1,120.26) ; U1.AG2 v4(231.86,128.5)
  T16 w0.117: v4(231.86,128.5) 232.37,127.98 233.26,127.98 234.34,126.9 234.34,120.07 235.9,118.51 247.47,118.51 248.49,119.54 248.49,120.01 248.49,120.54 248.61,120.66 249.53,120.66 251.15,122.28 255.79,122.28 255.9,122.16 255.9,120.9 255.79,120.78 254.85,120.78 254.73,120.9 254.73,120.95 254.61,121.06 254.38,121.06 254.26,120.95 254.26,120.9 254.15,120.78 253.84,120.78 253.73,120.9 253.73,121.81 253.61,121.93 253.38,121.93 253.26,121.81 253.26,121 253.14,120.88 252.91,120.88 252.79,121 252.79,121.81 252.67,121.93 252.44,121.93 252.32,121.81 252.32,121 252.21,120.88 251.97,120.88 251.86,121 251.86,121.81 251.74,121.93 251.51,121.93 251.39,121.81 251.39,121 251.27,120.88 250.32,120.88 250.1,120.67 v4(250.1,120.26)
MAC_DDRC_DQ09: length 48.6
  TOP w0.14: U6.B8 v4(250.9,125.06) ; U1.AK2 231.86,131.5 233.99,131.5 v4(235.04,130.45)
  T16 w0.117: v4(250.9,125.06) 250.5,124.66 249.93,124.66 248.42,123.15 247.3,123.15 247.18,123.27 247.18,123.54 247.06,123.65 246.83,123.65 246.71,123.54 246.71,123.27 246.6,123.15 246.36,123.15 246.25,123.27 246.25,123.54 246.13,123.65 245.89,123.65 245.78,123.54 245.78,123.27 245.66,123.15 245.43,123.15 245.31,123.27 245.31,123.54 245.19,123.65 244.96,123.65 244.84,123.54 244.84,123.27 244.73,123.15 244.49,123.15 244.38,123.27 244.38,123.54 244.26,123.65 244.03,123.65 243.91,123.54 243.91,123.27 243.79,123.15 243.56,123.15 243.44,123.27 243.44,123.54 243.32,123.65 243.09,123.65 242.97,123.54 242.97,123.27 242.86,123.15 242.62,123.15 242.51,123.27 242.51,123.54 242.39,123.65 242.16,123.65 242.04,123.54 242.04,123.27 241.92,123.15 241.1,123.15 240.84,123.42 236.51,123.42 236.4,123.54 236.4,123.77 236.51,123.89 241.21,123.89 241.32,124 241.32,124.22 241.19,124.35 236.56,124.35 236.4,124.52 236.4,124.75 236.51,124.87 239.86,124.87 239.98,124.99 239.98,125.22 239.86,125.34 236.51,125.34 236.4,125.45 236.4,129.09 v4(235.04,130.45)
MAC_DDRC_DQ10: length 48.8
  TOP w0.14: U1.AF1 v4(232.86,127.5) ; U6.C3 v4(251.7,120.26)
  T16 w0.117: v4(251.7,120.26) 251.7,120.01 251.55,119.86 249.63,119.86 247.63,117.86 247.05,117.86 246.93,117.74 246.93,116.99 246.81,116.87 246.58,116.87 246.46,116.99 246.46,117.74 246.35,117.86 246.11,117.86 246,117.74 246,116.99 245.88,116.87 245.65,116.87 245.53,116.99 245.53,117.74 245.41,117.86 245.18,117.86 245.06,117.74 245.06,116.99 244.95,116.87 244.71,116.87 244.59,116.99 244.59,117.74 244.48,117.86 244.24,117.86 244.13,117.74 244.13,116.99 244.01,116.87 243.78,116.87 243.66,116.99 243.66,117.74 243.54,117.86 243.31,117.86 243.19,117.74 243.19,116.99 243.08,116.87 242.84,116.87 242.73,116.99 242.73,117.74 242.61,117.86 242.37,117.86 242.26,117.74 242.26,116.99 242.14,116.87 241.91,116.87 241.79,116.99 241.79,117.74 241.67,117.86 241.44,117.86 241.32,117.74 241.32,117.5 241.21,117.38 240.97,117.38 240.86,117.5 240.86,117.74 240.74,117.86 240.51,117.86 240.39,117.74 240.39,117.5 240.27,117.38 240.04,117.38 239.92,117.5 239.92,117.74 239.8,117.86 239.57,117.86 239.45,117.74 239.45,117.5 239.34,117.38 239.1,117.38 238.99,117.5 238.99,117.74 238.87,117.86 238.64,117.86 238.52,117.74 238.52,117.5 238.4,117.38 238.17,117.38 238.05,117.5 238.05,117.74 237.94,117.86 237.7,117.86 237.58,117.74 237.58,117.5 237.47,117.38 237.23,117.38 237.12,117.5 237.12,117.74 237,117.86 236.77,117.86 236.65,117.74 236.65,117.5 236.53,117.38 236.3,117.38 236.18,117.5 236.18,117.74 236.07,117.86 235.74,117.86 233.92,119.68 233.92,120.51 233.8,120.62 233.47,120.62 233.35,120.74 233.35,120.97 233.47,121.09 233.8,121.09 233.92,121.21 233.92,121.44 233.8,121.56 233.47,121.56 233.35,121.67 233.35,121.91 233.47,122.02 233.8,122.02 233.92,122.14 233.92,122.37 233.8,122.49 233.47,122.49 233.35,122.61 233.35,122.84 233.47,122.96 233.8,122.96 233.92,123.08 233.92,123.31 233.8,123.43 233.47,123.43 233.35,123.54 233.35,123.78 233.47,123.89 233.8,123.89 233.92,124.01 233.92,124.24 233.8,124.36 233.47,124.36 233.35,124.48 233.35,124.71 233.47,124.83 233.8,124.83 233.92,124.95 233.92,125.18 233.8,125.3 233.47,125.3 233.35,125.41 233.35,125.65 233.47,125.76 233.8,125.76 233.92,125.88 233.92,126.44 v4(232.86,127.5)
MAC_DDRC_DQ11: length 48.6
  TOP w0.14: U1.AJ2 v4(231.86,130.5) ; U6.C7 v4(251.7,124.26)
  T16 w0.117: v4(251.7,124.26) 251.7,123.77 252.12,123.35 256.02,123.35 256.13,123.23 256.13,122.86 256.02,122.74 250.75,122.74 249.24,121.23 248.02,121.23 247.92,121.13 247.92,119.78 247.23,119.09 237.74,119.09 237.74,119.09 236.26,119.09 234.75,120.6 234.75,120.88 234.86,121 236.06,121 236.17,120.88 236.17,120.32 236.29,120.2 236.52,120.2 236.64,120.32 236.64,120.88 236.76,121 236.97,121 237.08,121.12 237.08,121.35 236.97,121.47 234.86,121.47 234.75,121.58 234.75,128.02 233.75,129.02 232.77,129.02 232.34,129.44 232.34,130.01 v4(231.86,130.5)
MAC_DDRC_DQ12: length 50.3
  TOP w0.14: U6.C2 v4(251.7,119.46) ; U1.AF2 v4(231.86,127.5)
  T16 w0.117: v4(231.86,127.5) 232.33,127.03 232.33,120.88 232.21,120.76 231.87,120.76 231.75,120.64 231.75,120.41 231.87,120.29 232.21,120.29 232.33,120.18 232.33,119.31 232.61,119.03 233.7,119.03 235.94,116.79 236.32,116.79 236.44,116.67 236.44,115.92 236.56,115.8 236.79,115.8 236.91,115.92 236.91,116.67 237.03,116.79 237.26,116.79 237.38,116.67 237.38,115.92 237.49,115.8 237.73,115.8 237.84,115.92 237.84,116.67 237.96,116.79 238.19,116.79 238.31,116.67 238.31,115.92 238.43,115.8 238.66,115.8 238.78,115.92 238.78,116.67 238.9,116.79 240.92,116.79 241.1,116.62 241.1,114.76 241.27,114.58 241.55,114.58 241.67,114.7 241.67,116.17 241.78,116.29 242.02,116.29 242.13,116.17 242.13,114.7 242.25,114.58 242.56,114.58 242.68,114.7 242.68,116.17 242.79,116.29 243.13,116.29 243.25,116.16 243.6,116.16 243.72,116.29 244.06,116.29 244.19,116.16 244.53,116.16 244.66,116.29 245.21,116.29 245.33,116.17 245.33,114.55 245.42,114.46 245.67,114.46 245.79,114.58 245.79,116.17 245.91,116.29 246.29,116.29 246.41,116.17 246.41,115.67 246.53,115.55 246.76,115.55 246.88,115.67 246.88,116.17 246.99,116.29 247.5,116.29 247.92,116.71 247.92,116.88 247.8,117 247.8,117.17 247.96,117.34 248.13,117.34 248.25,117.21 248.42,117.21 248.58,117.37 248.58,117.54 248.46,117.67 248.46,117.83 248.62,118 248.79,118 248.92,117.87 249.08,117.87 249.45,118.24 249.45,118.86 249.66,119.06 251.3,119.06 v4(251.7,119.46)
MAC_DDRC_DQ13: length 44.5
  TOP w0.14: U1.AM1 233.36,133 v4(234.86,131.5) ; U6.C8 v4(251.7,125.06)
  T16 w0.117: v4(234.86,131.5) 236.97,129.38 236.97,126.91 237.09,126.79 239.86,126.79 239.98,126.68 239.98,126.44 239.86,126.33 237.09,126.33 236.97,126.21 236.97,126.03 237.09,125.91 240.44,125.91 241.21,125.14 241.38,125.14 241.53,125.29 241.69,125.29 241.86,125.12 241.86,124.96 241.71,124.81 241.71,124.64 242.13,124.23 242.52,124.23 242.64,124.34 242.64,125.16 242.76,125.28 242.99,125.28 243.11,125.16 243.11,124.34 243.23,124.23 243.46,124.23 243.58,124.34 243.58,125.16 243.69,125.28 243.93,125.28 244.04,125.16 244.04,124.34 244.16,124.23 244.39,124.23 244.51,124.34 244.51,125.16 244.63,125.28 244.86,125.28 244.98,125.16 244.98,124.34 245.1,124.23 245.33,124.23 245.45,124.34 245.45,125.16 245.56,125.28 245.8,125.28 245.91,125.16 245.91,124.34 246.03,124.23 246.26,124.23 246.38,124.34 246.38,125.16 246.5,125.28 246.73,125.28 246.85,125.16 246.85,124.34 246.96,124.23 247.23,124.23 247.41,124.4 247.41,125.19 247.52,125.3 247.91,125.3 248.03,125.18 248.03,124.1 248.15,123.98 248.38,123.98 248.5,124.1 248.5,125.18 248.61,125.3 249.22,125.3 249.38,125.46 251.3,125.46 v4(251.7,125.06)
MAC_DDRC_DQ14: length 50.7
  TOP w0.14: U1.AG3 v4(230.86,128.5) ; U6.D3 v4(252.5,120.26)
  T16 w0.117: v4(230.86,128.5) 231.22,128.5 231.34,128.38 231.34,121 231.23,120.88 230.9,120.88 230.78,120.77 230.78,120.53 230.9,120.42 231.23,120.42 231.34,120.3 231.34,118.22 231.55,118.01 233.09,118.01 233.53,117.58 233.7,117.58 233.94,117.82 234.1,117.82 234.27,117.65 234.27,117.49 234.03,117.25 234.03,117.08 234.19,116.92 234.36,116.92 234.6,117.16 234.76,117.16 234.93,116.99 234.93,116.83 234.69,116.59 234.69,116.42 234.85,116.26 235.02,116.26 235.26,116.5 235.42,116.5 235.59,116.33 235.59,116.17 235.35,115.92 235.35,115.76 235.91,115.19 236.38,115.19 236.49,115.08 236.49,114.37 236.61,114.25 236.84,114.25 236.96,114.37 236.96,115.08 237.08,115.19 237.31,115.19 237.43,115.08 237.43,114.37 237.54,114.25 237.78,114.25 237.89,114.37 237.89,115.08 238.01,115.19 239.43,115.19 239.55,115.08 239.55,114.24 239.66,114.13 239.87,114.13 239.99,114.24 239.99,115.18 240.1,115.3 240.38,115.3 240.5,115.18 240.5,114.55 241.16,113.88 243.55,113.88 243.67,114 243.67,115.47 243.78,115.59 244.02,115.59 244.13,115.47 244.13,114 244.25,113.88 245.91,113.88 250.03,118 251.91,118 252.1,118.19 252.1,119.86 v4(252.5,120.26)
MAC_DDRC_DQ15: length 46.3
  TOP w0.14: U6.D7 v4(252.5,124.26) ; v1(235.86,131.5) 233.86,133.5 231.86,133.5 U1.AM2
  T16 w0.117: v1(235.86,131.5) 236,131.5 236.39,131.11 236.39,130.8 236.56,130.62 236.87,130.62 237.05,130.45 237.05,130.14 237.23,129.96 237.54,129.96 238.25,129.25 238.25,129.09 237.56,128.4 237.56,128.23 237.72,128.07 237.89,128.07 238.58,128.76 238.74,128.76 238.91,128.59 238.91,128.42 238.22,127.74 238.22,127.57 238.38,127.41 238.55,127.41 239.24,128.09 239.4,128.09 241.62,125.87 248.98,125.87 249.39,126.28 249.39,127.08 249.51,127.19 249.94,127.19 250.06,127.08 250.06,126.54 250.18,126.42 250.41,126.42 250.53,126.54 250.53,127.08 250.65,127.19 250.88,127.19 251,127.08 251,126.54 251.11,126.42 251.35,126.42 251.46,126.54 251.46,127.08 251.58,127.19 251.99,127.19 252.1,127.08 252.1,125.68 252.32,125.46 256.7,125.46 256.82,125.35 256.82,124.97 256.7,124.85 256.4,124.85 256.28,124.73 256.28,124.5 256.4,124.38 256.7,124.38 256.82,124.26 256.82,123.86 256.63,123.67 252.71,123.67 252.5,123.88 v4(252.5,124.26)
MAC_DDRC_DQ16: length 64.5
  TOP w0.14: U1.AK3 v4(230.86,131.5) ; U7.G2 v4(254.9,131.13)
  T16 w0.117: v4(230.86,131.5) 230.85,131.5 230.51,131.5 230.38,131.37 230.38,131.14 230.51,131.01 233.09,131.01 234.3,132.21 236.17,132.21 236.64,131.75 236.8,131.75 237.07,132.01 237.23,132.01 237.4,131.85 237.4,131.68 237.13,131.41 237.13,131.25 237.3,131.08 237.46,131.08 237.73,131.35 237.89,131.35 238.06,131.19 238.06,131.02 237.79,130.75 237.79,130.59 237.96,130.42 238.12,130.42 238.39,130.69 238.55,130.69 238.72,130.52 238.72,130.36 238.45,130.09 238.45,129.93 238.62,129.76 238.78,129.76 239.05,130.03 239.22,130.03 239.38,129.86 239.38,129.7 239.12,129.43 239.12,129.27 239.28,129.1 239.45,129.1 239.71,129.37 239.88,129.37 240.04,129.2 240.04,129.04 239.78,128.77 239.78,128.6 239.94,128.44 240.11,128.44 240.37,128.71 240.54,128.71 240.7,128.54 240.7,128.37 240.44,128.11 240.44,127.94 240.6,127.78 240.77,127.78 241.04,128.04 241.2,128.04 241.37,127.88 241.37,127.71 241.1,127.45 241.1,127.28 241.88,126.5 242.39,126.5 242.5,126.61 242.5,127.63 242.62,127.74 242.85,127.74 242.97,127.63 242.97,126.61 243.09,126.5 243.32,126.5 243.44,126.61 243.44,127.63 243.55,127.74 243.79,127.74 243.9,127.63 243.9,126.61 244.02,126.5 244.26,126.5 244.37,126.61 244.37,127.63 244.49,127.74 244.72,127.74 244.84,127.63 244.84,126.61 244.96,126.5 245.19,126.5 245.31,126.61 245.31,127.63 245.42,127.74 245.66,127.74 245.77,127.63 245.77,126.61 245.89,126.5 246.12,126.5 246.24,126.61 246.24,127.63 246.36,127.74 246.59,127.74 246.71,127.63 246.71,126.61 246.83,126.5 247.06,126.5 247.18,126.61 247.18,127.63 247.29,127.74 247.53,127.74 247.64,127.63 247.64,126.61 247.76,126.5 248.65,126.5 248.77,126.61 248.77,127.4 251.19,129.82 252.91,129.82 253.03,129.71 253.03,129.45 252.91,129.33 251.25,129.33 251.13,129.22 251.13,128.98 251.25,128.87 252.91,128.87 253.03,128.75 253.03,126.54 253.14,126.42 253.38,126.42 253.49,126.54 253.49,126.86 253.61,126.98 254.29,126.98 254.41,127.09 254.41,127.33 254.29,127.44 253.61,127.44 253.49,127.56 253.49,128.76 253.61,128.88 253.83,128.88 253.95,129 253.95,129.23 253.83,129.35 253.61,129.35 253.49,129.47 253.49,129.71 253.61,129.82 254.39,129.82 254.51,129.94 254.51,130.16 254.5,130.16 254.5,130.73 v4(254.9,131.13)
MAC_DDRC_DQ17: length 69.7
  TOP w0.14: U7.F7 v4(254.1,135.93) ; U1.AE6 v4(227.86,126.5)
  T16 w0.117: v4(254.1,135.93) 254.5,136.33 255.14,136.33 255.3,136.49 255.3,137.9 255.08,138.13 255.08,138.45 255.19,138.57 255.69,138.57 255.8,138.69 255.8,138.92 255.69,139.04 255.23,139.04 255.08,139.19 255.08,139.62 255.19,139.74 255.89,139.74 256.01,139.86 256.01,140.09 255.89,140.21 255.37,140.21 255.25,140.32 255.25,140.61 255.37,140.73 256.65,140.73 256.77,140.84 256.77,141.08 256.65,141.19 255.36,141.19 255.24,141.31 255.24,141.54 255.36,141.66 256.63,141.66 256.74,141.78 256.74,143.11 256.63,143.23 256.3,143.23 256.18,143.11 256.18,142.26 256.07,142.14 255.86,142.14 255.71,142.29 255.71,142.99 255.6,143.11 255.36,143.11 255.25,142.99 255.25,142.41 254.82,141.98 247.64,141.98 244.05,138.39 243.77,138.39 243.73,138.44 233.25,138.44 232.79,137.98 226.66,137.98 226.4,137.72 226.4,132.23 226.15,131.97 225.64,131.97 225.34,131.68 225.34,127.3 225.65,127 226.03,127 226.35,126.68 226.35,124.12 226.47,124.01 227.29,124.01 227.43,124.15 227.43,126.38 227.55,126.5 v4(227.86,126.5)
MAC_DDRC_DQ18: length 63.4
  TOP w0.14: U7.H3 v4(255.7,131.93) ; U1.AL3 v4(230.86,132.5)
  T16 w0.117: v4(230.86,132.5) 230.86,132.86 230.98,132.97 231.5,132.97 231.62,133.09 231.62,133.62 231.74,133.74 231.97,133.74 232.09,133.62 232.09,133.09 232.2,132.97 232.86,132.97 234.03,134.14 237.97,134.14 238.29,133.82 238.46,133.82 238.84,134.21 239,134.21 239.17,134.04 239.17,133.87 238.79,133.49 238.79,133.01 238.95,132.85 239.48,132.85 239.64,133.02 239.64,134.15 239.76,134.27 239.99,134.27 240.11,134.15 240.11,133.12 240.23,133 240.46,133 240.58,133.12 240.58,134.15 240.7,134.27 240.93,134.27 241.05,134.15 241.05,133.12 241.16,133 241.4,133 241.51,133.12 241.51,134.15 241.63,134.27 241.86,134.27 241.98,134.15 241.98,133.12 242.1,133 242.33,133 242.45,133.12 242.45,134.15 242.57,134.27 242.8,134.27 242.92,134.15 242.92,133.12 243.03,133 243.27,133 243.38,133.12 243.38,134.15 243.5,134.27 243.73,134.27 243.85,134.15 243.85,133.12 243.97,133 244.2,133 244.32,133.12 244.32,134.15 244.43,134.27 244.67,134.27 244.79,134.15 244.79,133.12 244.9,133 245.14,133 245.25,133.12 245.25,134.15 245.37,134.27 245.6,134.27 245.72,134.15 245.72,133.12 245.84,133 246.07,133 246.19,133.12 246.19,134.15 246.3,134.27 246.54,134.27 246.65,134.15 246.65,133.12 246.77,133 247.01,133 247.12,133.12 247.12,134.15 247.24,134.27 247.47,134.27 247.59,134.15 247.59,133.12 247.71,133 247.94,133 248.06,133.12 248.06,134.15 248.17,134.27 248.41,134.27 248.52,134.15 248.52,133.12 248.64,133 248.82,133 249.63,133.81 249.9,133.81 250.01,133.93 250.01,134.31 250.13,134.42 250.36,134.42 250.48,134.31 250.48,133.93 250.6,133.81 250.83,133.81 250.95,133.93 250.95,134.31 251.07,134.42 251.3,134.42 251.42,134.31 251.42,133.93 251.53,133.81 251.77,133.81 251.88,133.93 251.88,134.31 252,134.42 252.23,134.42 252.35,134.31 252.35,133.93 252.47,133.81 252.7,133.81 252.82,133.93 252.82,134.31 252.93,134.42 253.17,134.42 253.29,134.31 253.29,133.93 253.4,133.81 253.64,133.81 253.75,133.93 253.75,134.31 253.87,134.42 254.1,134.42 254.22,134.31 254.22,133.93 254.34,133.81 254.58,133.81 254.69,133.93 254.69,134.31 254.81,134.42 255.04,134.42 255.16,134.31 255.16,133.93 255.28,133.81 256.24,133.81 256.36,133.7 256.36,133.4 256.24,133.28 255.64,133.28 255.52,133.17 255.52,132.93 255.64,132.82 256.24,132.82 256.36,132.7 256.36,132.24 256.05,131.93 v4(255.7,131.93)
MAC_DDRC_DQ19: length 68
  TOP w0.14: U1.AG5 v4(228.86,128.5) ; U7.H7 v4(255.7,135.93)
  T16 w0.117: v4(228.86,128.5) 229.39,127.97 229.39,122.13 229.23,121.98 228.47,121.98 228.32,122.13 228.32,128.73 228.11,128.94 227.5,128.94 227.35,129.1 227.35,131.55 227.89,132.09 228.03,132.09 228.31,132.38 228.31,135.54 228.74,135.97 232.9,135.97 233.13,136.19 233.61,136.19 233.73,136.31 233.73,136.67 233.85,136.78 234.08,136.78 234.2,136.67 234.2,136.31 234.31,136.19 234.55,136.19 234.66,136.31 234.66,136.67 234.78,136.78 235.01,136.78 235.13,136.67 235.13,136.31 235.25,136.19 235.48,136.19 235.6,136.31 235.6,136.67 235.72,136.78 235.95,136.78 236.07,136.67 236.07,136.31 236.18,136.19 236.42,136.19 236.53,136.31 236.53,136.67 236.65,136.78 236.88,136.78 237,136.67 237,136.31 237.12,136.19 237.35,136.19 237.47,136.31 237.47,136.67 237.58,136.78 237.82,136.78 237.94,136.67 237.94,136.31 238.05,136.19 238.29,136.19 238.4,136.31 238.4,136.67 238.52,136.78 238.75,136.78 238.87,136.67 238.87,136.31 238.99,136.19 239.22,136.19 239.34,136.31 239.34,136.67 239.45,136.78 239.69,136.78 239.8,136.67 239.8,136.31 239.92,136.19 240.16,136.19 240.27,136.31 240.27,136.67 240.39,136.78 240.62,136.78 240.74,136.67 240.74,136.31 240.86,136.19 241.09,136.19 241.21,136.31 241.21,136.67 241.32,136.78 241.56,136.78 241.67,136.67 241.67,136.31 241.79,136.19 242.02,136.19 242.14,136.31 242.14,136.67 242.26,136.78 242.49,136.78 242.61,136.67 242.61,136.31 242.73,136.19 242.96,136.19 243.08,136.31 243.08,136.67 243.19,136.78 243.43,136.78 243.54,136.67 243.54,136.31 243.66,136.19 243.99,136.19 248.01,140.22 251.99,140.22 252.4,139.82 252.4,138.07 252.1,137.78 252.1,135.76 252.35,135.52 255.5,135.52 255.7,135.72 v4(255.7,135.93)
MAC_DDRC_DQ20: length 63.8
  TOP w0.14: U1.AL4 v4(229.86,132.5) ; U7.H2 v4(255.7,131.13)
  T16 w0.117: v4(229.86,132.5) 230.33,132.96 230.33,133.64 230.78,134.09 233.39,134.09 234.18,134.88 248.09,134.88 248.21,135 248.21,137.46 248.32,137.57 248.56,137.57 248.67,137.46 248.67,135 248.79,134.88 249.02,134.88 249.14,135 249.14,137.46 249.26,137.57 249.49,137.57 249.61,137.46 249.61,135 249.72,134.88 255.56,134.88 255.67,134.76 255.67,134.36 255.79,134.24 256.03,134.24 256.14,134.36 256.14,134.76 256.26,134.88 258.1,134.88 258.22,134.76 258.22,134.16 258.1,134.04 256.91,134.04 256.79,133.93 256.79,131.77 256.68,131.65 256.4,131.65 256.28,131.54 256.28,131.3 256.4,131.19 256.68,131.19 256.79,131.07 256.79,130.84 256.68,130.72 256.4,130.72 256.28,130.6 256.28,130.37 256.4,130.25 256.68,130.25 256.79,130.14 256.79,129.7 256.39,129.29 256.39,129.12 256.27,129 255.59,129 255.47,128.88 255.47,128.65 255.59,128.53 256.27,128.53 256.39,128.41 256.39,128.18 256.27,128.06 255.59,128.06 255.47,127.95 255.47,127.71 255.59,127.6 256.27,127.6 256.39,127.48 256.39,126.62 256.26,126.5 256.01,126.5 255.9,126.61 255.9,127.07 255.78,127.18 255.55,127.18 255.43,127.07 255.43,126.61 255.31,126.5 255.15,126.5 255.03,126.61 255.03,129.32 255.3,129.6 255.3,130.73 v4(255.7,131.13)
MAC_DDRC_DQ21: length 73.1
  TOP w0.14: U7.H8 v4(255.7,136.73) ; U1.AD8 v4(225.86,125.5)
  T16 w0.117: v4(225.86,125.5) 225.35,126 224.64,126 224.36,126.28 224.36,131.71 224.63,131.97 225.13,131.97 225.39,132.23 225.39,138.71 225.67,139 234.82,139 234.83,139.01 243.86,139.01 248.27,143.43 248.27,147.43 250.22,149.38 254.03,149.38 256.15,147.25 256.15,147.09 256.13,147.07 255.81,146.75 255.81,146.58 255.98,146.42 256.14,146.42 256.46,146.74 256.48,146.76 256.65,146.76 257.49,145.92 257.49,145.51 257.37,145.39 256.1,145.39 255.99,145.28 255.99,145.04 256.1,144.93 257.37,144.93 257.49,144.81 257.49,144.58 257.37,144.46 256.09,144.46 255.98,144.34 255.98,144.11 256.09,143.99 257.37,143.99 257.49,143.88 257.49,140.43 256.82,139.76 256.41,139.35 256.41,137.44 v4(255.7,136.73)
MAC_DDRC_DQ22: length 66.5
  TOP w0.14: U1.AH4 v4(229.86,129.5) ; U7.J3 v4(257.3,131.93)
  T16 w0.117: v4(229.86,129.5) 229.4,129.95 228.63,129.95 228.45,130.13 228.45,131.74 228.8,132.09 229.03,132.09 229.26,132.33 229.26,132.55 229.26,132.55 229.26,134.83 229.53,135.09 233.03,135.09 233.55,135.62 245.27,135.62 245.39,135.74 245.39,136.59 245.5,136.71 245.74,136.71 245.85,136.59 245.85,135.74 245.97,135.62 246.39,135.62 246.51,135.74 246.51,137.79 246.63,137.9 246.86,137.9 246.98,137.79 246.98,135.74 247.09,135.62 247.46,135.62 247.57,135.74 247.57,138.06 247.69,138.18 248.12,138.18 248.23,138.3 248.23,138.53 248.12,138.65 247.69,138.65 247.57,138.76 247.57,138.97 248.18,139.58 248.56,139.58 248.68,139.46 248.68,138.27 248.79,138.16 249.03,138.16 249.14,138.27 249.14,139.46 249.26,139.58 249.49,139.58 249.61,139.46 249.61,138.27 249.73,138.16 249.96,138.16 250.08,138.27 250.08,139.46 250.2,139.58 250.43,139.58 250.55,139.46 250.55,138.27 250.66,138.16 250.9,138.16 251.01,138.27 251.01,139.46 251.13,139.58 251.71,139.58 251.82,139.46 251.82,138.22 251.3,137.7 251.3,135.44 251.55,135.2 258.68,135.2 258.8,135.08 258.8,133.65 258.68,133.53 258.48,133.53 258.37,133.42 258.37,133.18 258.48,133.07 258.68,133.07 258.8,132.95 258.8,132.69 258.63,132.52 257.43,132.52 257.3,132.39 v4(257.3,131.93)
MAC_DDRC_DQ23: length 73
  TOP w0.14: U7.J7 v4(256.5,135.93) ; U1.AC8 v4(225.86,124.5)
  T16 w0.117: v4(256.5,135.93) 256.9,136.33 256.9,137.77 258.06,138.93 258.06,146.16 254.27,149.95 249.8,149.95 247.69,147.85 247.69,143.66 243.62,139.59 224.69,139.59 224.37,139.26 224.37,138.9 224.27,138.8 223.79,138.8 223.68,138.7 223.68,138.55 223.79,138.45 224.27,138.45 224.37,138.35 224.37,132.23 224.12,131.97 223.61,131.97 223.36,131.72 223.36,125.24 223.61,124.99 225.37,124.99 v4(225.86,124.5)
MAC_DDRC_DQ24: length 67.9
  TOP w0.14: U1.AB4 v4(229.86,123.5) ; U7.A3 v4(250.1,131.93)
  T18 w0.117: v4(229.86,123.5) 229.81,123.5 229.69,123.61 229.69,123.9 229.81,124.02 233.67,124.02 234.33,123.36 234.49,123.36 235.5,124.36 235.66,124.36 235.83,124.2 235.83,124.03 234.82,123.03 234.82,122.86 235.28,122.41 235.45,122.41 235.67,122.64 235.84,122.64 236,122.47 236,122.31 235.78,122.08 235.78,121.91 236.22,121.47 236.22,119.59 236.75,119.06 239.83,119.06 240.33,119.56 240.33,121.82 240.45,121.94 240.88,121.94 241,121.82 241,119.58 241.11,119.46 241.35,119.46 241.46,119.58 241.46,121.82 241.58,121.94 241.81,121.94 241.93,121.82 241.93,119.58 242.05,119.46 242.28,119.46 242.4,119.58 242.4,121.82 242.51,121.94 242.75,121.94 242.86,121.82 242.86,119.58 242.98,119.46 243.22,119.46 243.33,119.58 243.33,121.82 243.45,121.94 243.68,121.94 243.8,121.82 243.8,119.58 243.92,119.46 244.15,119.46 244.27,119.58 244.27,121.82 244.38,121.94 244.62,121.94 244.73,121.82 244.73,119.58 244.85,119.46 245.08,119.46 245.2,119.58 245.2,121.82 245.32,121.94 245.55,121.94 245.67,121.82 245.67,119.58 245.79,119.46 246.02,119.46 246.14,119.58 246.14,121.82 246.25,121.94 246.73,121.94 247.6,122.81 247.6,127.34 249.6,129.34 249.6,131.43 v4(250.1,131.93)
MAC_DDRC_DQ25: length 66
  TOP w0.14: U1.AF4 v4(229.86,127.5) ; U7.B8 v4(250.9,136.73)
  T18 w0.117: v4(229.86,127.5) 229.92,127.43 230.1,127.43 230.7,128.02 233.8,128.02 233.92,127.91 233.92,127.71 234.03,127.59 234.22,127.59 234.33,127.71 234.33,128.24 234.45,128.35 234.68,128.35 234.8,128.24 234.8,127.76 234.97,127.59 235.15,127.59 235.27,127.71 235.27,128.24 235.39,128.35 235.62,128.35 235.74,128.24 235.74,127.76 235.9,127.59 236.09,127.59 236.2,127.71 236.2,128.24 236.32,128.35 236.55,128.35 236.67,128.24 236.67,127.76 236.84,127.59 237.07,127.59 237.19,127.71 237.19,128.21 237.31,128.33 237.77,128.33 238.14,127.95 238.31,127.95 238.65,128.29 238.82,128.29 238.98,128.13 238.98,127.96 238.64,127.62 238.64,127.45 239.11,126.98 239.49,126.98 239.6,127.1 239.6,128.69 239.72,128.81 239.95,128.81 240.07,128.69 240.07,127.1 240.19,126.98 240.39,126.98 240.51,127.1 240.51,129.56 240.62,129.67 240.86,129.67 240.97,129.56 240.97,127.1 241.09,126.98 241.32,126.98 241.44,127.1 241.44,129.56 241.56,129.67 241.79,129.67 241.91,129.56 241.91,127.1 242.02,126.98 242.26,126.98 242.38,127.1 242.38,129.56 242.49,129.67 242.73,129.67 242.84,129.56 242.84,127.1 242.96,126.98 243.19,126.98 243.31,127.1 243.31,129.56 243.43,129.67 243.66,129.67 243.78,129.56 243.78,127.1 243.89,126.98 244.13,126.98 244.24,127.1 244.24,129.56 244.36,129.67 244.6,129.67 244.71,129.56 244.71,127.1 244.83,126.98 245.06,126.98 245.18,127.11 245.18,128.26 247.24,130.32 247.24,135.38 248.99,137.13 250.76,137.13 250.9,136.99 v4(250.9,136.73)
MAC_DDRC_DQ26: length 67.4
  TOP w0.14: U1.AE4 v4(229.86,126.5) ; U7.C3 v4(251.7,131.93)
  T18 w0.117: v4(229.86,126.5) 229.86,126.89 229.98,127.01 233.86,127.01 234.46,126.41 234.83,126.41 234.94,126.52 234.94,126.89 235.06,127.01 235.29,127.01 235.41,126.89 235.41,126.52 235.53,126.41 235.76,126.41 235.88,126.52 235.88,126.89 236,127.01 236.23,127.01 236.35,126.89 236.35,126.52 236.46,126.41 236.7,126.41 236.81,126.52 236.81,126.89 236.93,127.01 237.16,127.01 237.28,126.89 237.28,126.52 237.4,126.41 237.63,126.41 237.75,126.52 237.75,126.89 237.87,127.01 238.1,127.01 238.22,126.89 238.22,126.52 238.33,126.41 245.6,126.41 245.76,126.56 245.76,128.03 247.81,130.08 247.81,134.12 247.93,134.24 248.8,134.24 248.92,134.36 248.92,134.59 248.8,134.71 247.93,134.71 247.81,134.82 247.81,135.15 248.32,135.66 248.49,135.66 249.33,134.82 249.49,134.82 249.66,134.98 249.66,135.15 248.82,135.99 248.82,136.15 249,136.33 251.09,136.33 251.29,136.13 251.29,136.11 251.3,136.09 251.3,135.32 251.42,135.21 255.74,135.21 255.85,135.09 255.85,134.85 255.74,134.74 251.42,134.74 251.3,134.62 251.3,134.39 251.42,134.27 255.74,134.27 255.85,134.15 255.85,133.92 255.74,133.8 251.42,133.8 251.3,133.69 251.3,133.44 251.42,133.32 254.21,133.32 254.33,133.21 254.33,132.97 254.21,132.86 251.42,132.86 251.3,132.74 251.3,132.33 v4(251.7,131.93)
MAC_DDRC_DQ27: length 68.6
  TOP w0.14: U7.C7 v4(251.7,135.93) ; U1.AF5 v4(228.86,127.5)
  T18 w0.117: v4(251.7,135.93) 251.7,136.15 251.3,136.55 251.3,137.76 251.06,138.01 249.05,138.01 246.67,135.62 246.67,134.25 246.55,134.13 244.26,134.13 244.14,134.01 244.14,133.78 244.26,133.66 246.55,133.66 246.67,133.55 246.67,133.19 246.55,133.07 243.19,133.07 243.08,132.95 243.08,132.72 243.19,132.6 246.55,132.6 246.67,132.49 246.67,132.28 246.55,132.16 242.18,132.16 242.06,132.04 242.06,131.81 242.18,131.69 246.55,131.69 246.67,131.57 246.67,131.39 246.55,131.27 241.34,131.27 241.22,131.15 241.22,130.92 241.34,130.8 246.44,130.8 246.56,130.69 246.56,130.45 246.36,130.26 245.93,130.26 245.82,130.14 245.82,129.76 245.7,129.65 245.47,129.65 245.35,129.76 245.35,130.17 245.23,130.28 240.3,130.28 238.98,128.96 238.08,128.96 237.96,129.08 237.96,129.3 237.84,129.42 237.61,129.42 237.49,129.3 237.49,129.08 237.38,128.96 237.14,128.96 237.03,129.08 237.03,129.3 236.91,129.42 236.68,129.42 236.56,129.3 236.56,129.08 236.44,128.96 236.21,128.96 236.09,129.08 236.09,129.3 235.97,129.42 235.74,129.42 235.62,129.3 235.62,129.08 235.51,128.96 235.27,128.96 235.16,129.08 235.16,129.3 235.04,129.42 234.81,129.42 234.69,129.3 234.69,129.08 234.57,128.96 234.34,128.96 234.22,129.08 234.22,129.3 234.11,129.42 233.87,129.42 233.75,129.3 233.75,129.08 233.64,128.96 230.7,128.96 230.36,128.62 230.36,128.35 230,127.99 229.59,127.99 229.09,127.5 v4(228.86,127.5)
MAC_DDRC_DQ28: length 70.7
  TOP w0.14: U7.C2 v4(251.7,131.13) ; U1.AB7 v4(226.86,123.5)
  T18 w0.117: v4(226.86,123.5) 226.86,123.56 226.98,123.68 227.26,123.68 227.38,123.56 227.38,123.03 227.26,122.92 226.47,122.92 226.31,123.07 226.31,123.86 226.46,124 228.12,124 228.32,123.8 228.32,123.31 228.61,123.01 233.81,123.01 234.08,122.74 234.08,122.58 233.49,121.98 233.49,121.81 233.65,121.65 233.82,121.65 234.41,122.25 234.58,122.25 234.74,122.08 234.74,121.91 234.15,121.32 234.15,121.15 234.31,120.99 234.48,120.99 235.07,121.58 235.24,121.58 235.64,121.18 235.64,120.77 235.53,120.66 235.01,120.66 234.9,120.54 234.9,120.31 235.01,120.19 235.53,120.19 235.64,120.07 235.64,119.35 236.51,118.48 236.99,118.48 240.06,118.48 240.46,118.88 241.21,118.88 241.33,118.76 241.33,118.16 241.45,118.04 241.68,118.04 241.8,118.16 241.8,118.76 241.91,118.88 242.15,118.88 242.26,118.76 242.26,118.16 242.38,118.04 242.61,118.04 242.73,118.16 242.73,118.76 242.85,118.88 243.08,118.88 243.2,118.76 243.2,118.16 243.32,118.04 243.55,118.04 243.67,118.16 243.67,118.76 243.78,118.88 244.02,118.88 244.13,118.76 244.13,118.16 244.25,118.04 244.48,118.04 244.6,118.16 244.6,118.76 244.72,118.88 244.95,118.88 245.07,118.76 245.07,118.16 245.18,118.04 245.42,118.04 245.54,118.16 245.54,118.76 245.65,118.88 245.89,118.88 246,118.76 246,118.16 246.12,118.04 246.35,118.04 246.47,118.16 246.47,118.76 246.59,118.88 247.29,118.88 247.49,119.08 247.49,119.24 246.72,120.02 246.72,120.18 246.88,120.35 247.05,120.35 247.83,119.57 247.99,119.57 248.21,119.79 248.21,120.76 248.09,120.87 246.85,120.87 246.73,120.99 246.73,121.22 246.85,121.34 248.09,121.34 248.21,121.46 248.21,127.13 248.7,127.62 248.86,127.62 248.93,127.56 249.09,127.56 249.26,127.73 249.26,127.89 249.19,127.95 249.19,128.12 249.68,128.6 252.79,128.6 252.91,128.72 252.91,129.58 252.71,129.77 252.36,129.77 252.24,129.66 252.24,129.05 252.12,128.94 251.89,128.94 251.77,129.05 251.77,129.66 251.66,129.77 251.42,129.77 251.31,129.66 251.31,129.05 251.19,128.94 250.62,128.94 250.5,129.05 250.5,130.55 250.68,130.73 251.58,130.73 251.7,130.85 v4(251.7,131.13)
MAC_DDRC_DQ29: length 70.7
  TOP w0.14: U7.C8 v4(251.7,136.73) ; U1.AC7 v4(226.86,124.5)
  T18 w0.117: v4(251.7,136.73) 252.1,137.13 252.1,138.28 252.28,138.46 254.39,138.46 254.51,138.58 254.51,138.86 254.39,138.97 251.21,138.97 251.09,138.86 251.09,138.6 250.97,138.49 250.74,138.49 250.62,138.6 250.62,138.86 250.51,138.97 250.27,138.97 250.16,138.86 250.16,138.65 250.04,138.54 249.43,138.54 249.27,138.69 249.27,139.32 249.39,139.44 254.39,139.44 254.51,139.56 254.51,139.89 254.39,140.01 249.22,140.01 248.34,139.13 248.34,138.97 248.67,138.64 248.67,138.47 248.51,138.3 248.34,138.3 248.01,138.64 247.84,138.64 247.41,138.2 247.41,138.04 247.74,137.7 247.74,137.54 247.58,137.37 247.41,137.37 247.08,137.71 246.91,137.71 246.75,137.54 246.75,137.38 247.08,137.04 247.08,136.88 246.92,136.71 246.75,136.71 246.42,137.05 246.25,137.05 246.09,136.88 246.09,136.72 246.42,136.38 246.42,136.22 246.25,136.05 246.09,136.05 245.76,136.39 245.59,136.39 245.12,135.92 245.12,135.75 245.83,135.05 245.83,134.89 245.66,134.72 245.5,134.72 244.79,135.42 244.63,135.42 240.44,131.23 240.27,131.23 239.88,131.62 239.72,131.62 239.55,131.46 239.55,131.29 239.94,130.9 239.94,130.74 239.21,130.01 239,130.01 238.88,130.12 238.88,131.59 238.76,131.7 238.53,131.7 238.41,131.59 238.41,130.12 238.3,130.01 238.06,130.01 237.95,130.12 237.95,131.59 237.83,131.7 237.59,131.7 237.48,131.59 237.48,130.12 237.36,130.01 236.91,130.01 236.79,130.12 236.79,130.98 236.68,131.09 236.44,131.09 236.33,130.98 236.33,130.12 236.21,130.01 230.72,130.01 230.3,129.59 230.3,129.22 230.1,129.02 229.69,129.02 229.3,128.63 229.3,128.31 229.04,128.05 228.77,128.05 228.34,127.62 228.34,126.23 228.1,125.99 227.5,125.99 227.36,125.85 227.36,124.61 227.24,124.5 v4(226.86,124.5)
MAC_DDRC_DQ30: length 71.1
  TOP w0.14: U1.AA8 v4(225.86,122.5) ; U7.D3 v4(252.5,131.93)
  T18 w0.117: v4(252.5,131.93) 252.9,131.53 253.47,131.53 253.7,131.29 253.7,129.98 253.88,129.8 254.1,129.8 254.22,129.68 254.22,129.18 254.34,129.06 254.57,129.06 254.69,129.18 254.69,129.68 254.8,129.8 254.99,129.8 255.12,129.67 255.12,126.93 254.68,126.5 249.65,126.5 249.53,126.38 249.53,123.55 249.65,123.43 252.18,123.43 252.3,123.32 252.3,123.08 252.18,122.97 249.65,122.97 249.53,122.85 249.53,122.62 249.65,122.5 252.18,122.5 252.3,122.38 252.3,122.15 252.18,122.03 249.65,122.03 249.53,121.91 249.53,121.68 249.65,121.56 252.18,121.56 252.3,121.45 252.3,121.21 252.18,121.1 249.65,121.1 249.53,120.98 249.53,118.75 247.65,116.87 234.47,116.87 233.48,117.86 233.48,118.8 233.37,118.9 226.77,118.9 226.31,119.36 226.31,120.31 226.2,120.42 224.6,120.42 224.48,120.54 224.48,120.77 224.6,120.89 226.2,120.89 226.31,121.01 226.31,122.04 v4(225.86,122.5)
MAC_DDRC_DQ31: length 73
  TOP w0.14: U1.AA9 v4(224.86,122.5) ; U7.D7 v4(252.5,135.93)
  T18 w0.117: v4(224.86,122.5) 224.46,122.5 224.35,122.61 224.35,125.75 224.62,126.02 227.01,126.02 227.35,126.36 227.35,127.64 227.76,128.05 228.08,128.05 228.34,128.31 228.34,128.6 228.79,129.05 229.09,129.05 229.37,129.34 229.37,129.67 229.7,129.99 230.1,129.99 230.31,130.2 230.31,130.64 230.67,130.99 231.11,130.99 231.43,131.31 231.43,133.1 231.79,133.47 232.52,133.47 232.79,133.2 232.79,131.14 232.9,131.02 233.14,131.02 233.3,131.19 233.3,133.39 233.42,133.51 233.65,133.51 233.77,133.39 233.77,131.14 233.89,131.02 234.07,131.02 234.19,131.14 234.19,132.2 234.3,132.31 240.57,132.31 248.02,139.77 248.02,139.78 248.93,140.68 255.14,140.68 255.26,140.57 255.26,138.8 255.37,138.69 255.61,138.69 255.73,138.8 255.73,140.57 255.84,140.68 256.18,140.68 256.3,140.57 256.3,139.85 256.41,139.74 256.65,139.74 256.77,139.85 256.77,140.57 256.88,140.68 257.12,140.68 257.23,140.57 257.23,139.85 257.35,139.74 257.58,139.74 257.7,139.85 257.7,140.57 257.82,140.68 258.11,140.68 258.24,140.55 258.24,138.18 258.11,138.05 253.02,138.05 252.91,137.94 252.91,137.7 252.9,137.69 252.9,136.33 v4(252.5,135.93)
MAC_DDRC_DQS0_DN: length 53
  TOP w0.14: U6.F3 v4(254.1,120.26) ; U1.AC2 v4(231.86,124.5)
  T05 w0.107: v4(231.86,124.5) 232.33,124.02 233.88,124.02 234.37,124.51 236.23,124.51 236.23,124.51 237.53,124.51 240.76,121.28 241.84,121.28 241.97,121.15 241.97,119.25 242.24,118.98 242.69,118.98 242.96,119.25 242.96,121.18 243.07,121.28 243.25,121.28 243.36,121.18 243.36,119.22 243.63,118.95 244.08,118.95 244.35,119.22 244.35,121.18 244.45,121.28 244.67,121.28 244.77,121.18 244.77,119.22 245.04,118.95 245.49,118.95 245.76,119.22 245.76,121.18 245.87,121.28 246.08,121.28 246.19,121.18 246.19,119.22 246.46,118.95 246.9,118.95 247.17,119.22 247.17,121.18 247.28,121.28 247.49,121.28 247.6,121.18 247.6,119.22 247.87,118.95 248.31,118.95 248.58,119.22 248.58,121.18 248.69,121.28 249.21,121.28 249.48,121.55 249.48,122.78 249.59,122.89 249.8,122.89 249.91,122.78 249.91,121.55 250.18,121.28 250.62,121.28 250.89,121.55 250.89,122.78 251,122.89 251.21,122.89 251.32,122.78 251.32,121.55 251.59,121.28 254.06,121.28 254.36,120.98 254.36,120.52 v4(254.1,120.26)
MAC_DDRC_DQS0_DP: length 52.9
  TOP w0.14: U1.AC1 v4(232.86,124.5) ; U6.G3 v4(254.9,120.26)
  T05 w0.107: v4(254.9,120.26) 254.64,120.52 254.64,121.09 254.17,121.56 253.84,121.56 253.63,121.77 253.42,121.77 253.21,121.56 252.99,121.56 252.78,121.77 252.56,121.77 252.35,121.56 251.7,121.56 251.6,121.67 251.6,122.9 251.33,123.17 250.88,123.17 250.61,122.9 250.61,121.67 250.51,121.56 250.29,121.56 250.19,121.67 250.19,122.9 249.92,123.17 249.47,123.17 249.2,122.9 249.2,121.67 249.09,121.56 248.57,121.56 248.3,121.29 248.3,119.34 248.2,119.23 247.98,119.23 247.88,119.34 247.88,121.29 247.61,121.56 247.16,121.56 246.89,121.29 246.89,119.34 246.79,119.23 246.57,119.23 246.47,119.34 246.47,121.29 246.2,121.56 245.75,121.56 245.48,121.29 245.48,119.34 245.37,119.23 245.16,119.23 245.05,119.34 245.05,121.29 244.78,121.56 244.34,121.56 244.07,121.29 244.07,119.34 243.96,119.23 243.75,119.23 243.64,119.34 243.64,121.29 243.37,121.56 242.95,121.56 242.68,121.29 242.68,119.37 242.57,119.26 242.36,119.26 242.25,119.37 242.25,121.27 241.96,121.56 240.88,121.56 237.65,124.79 236.12,124.79 236.11,124.79 235.99,124.79 235.86,124.92 235.56,124.92 235.43,124.79 235.14,124.79 235,124.92 234.71,124.92 234.58,124.79 234.25,124.79 233.76,124.3 233.05,124.3 v4(232.86,124.5)
MAC_DDRC_DQS1_DN: length 47.2
  TOP w0.14: U6.A7 v4(250.1,124.26) ; U1.AJ1 v4(232.86,130.5)
  T16 w0.107: v4(232.86,130.5) 232.86,130.24 233,130.1 234.13,130.1 235.63,128.59 235.63,122.87 235.83,122.67 240.53,122.67 240.82,122.38 240.82,120.28 240.92,120.17 241.14,120.17 241.27,120.31 241.27,122.14 241.54,122.41 241.98,122.41 242.25,122.14 242.25,120.28 242.36,120.17 242.55,120.17 242.68,120.31 242.68,122.14 242.95,122.41 243.4,122.41 243.67,122.14 243.67,120.28 243.77,120.17 243.96,120.17 244.09,120.31 244.09,122.14 244.36,122.41 244.81,122.41 245.08,122.14 245.08,120.28 245.19,120.17 245.37,120.17 245.51,120.31 245.51,122.14 245.78,122.41 246.22,122.41 246.49,122.14 246.49,120.28 246.6,120.17 246.79,120.17 246.89,120.28 246.89,121.99 247.16,122.26 248.93,122.26 249.62,122.95 249.62,123.1 249.6,123.12 249.6,123.27 249.75,123.42 249.9,123.42 249.92,123.4 250.07,123.4 250.36,123.69 250.36,124 v4(250.1,124.26)
MAC_DDRC_DQS1_DP: length 47.4
  TOP w0.14: U1.AH1 v4(232.86,129.5) ; U6.B7 v4(250.9,124.26)
  T16 w0.107: v4(250.9,124.26) 250.64,124 250.64,123.57 249.05,121.98 247.28,121.98 247.17,121.87 247.17,120.16 246.9,119.89 246.48,119.89 246.21,120.16 246.21,122.02 246.1,122.13 245.89,122.13 245.78,122.02 245.78,120.19 245.49,119.89 245.07,119.89 244.8,120.16 244.8,122.02 244.69,122.13 244.48,122.13 244.37,122.02 244.37,120.19 244.08,119.89 243.66,119.89 243.39,120.16 243.39,122.02 243.28,122.13 243.07,122.13 242.96,122.02 242.96,120.19 242.66,119.89 242.25,119.89 241.97,120.16 241.97,122.02 241.87,122.13 241.65,122.13 241.55,122.02 241.55,120.19 241.25,119.89 240.81,119.89 240.54,120.16 240.54,122.27 240.41,122.39 235.71,122.39 235.36,122.75 235.36,128.47 234.01,129.82 232.97,129.82 232.86,129.71 v4(232.86,129.5)
MAC_DDRC_DQS2_DN: length 65.9
  TOP w0.109: U7.F3 v4(254.9,132.73)
  TOP w0.14: U1.AJ5 v4(228.86,130.5)
  T16 w0.102: v4(228.86,130.5) 229.16,130.5 229.26,130.6 229.26,131.74 229.61,132.09 231.41,132.09 231.65,131.85 231.7,131.85 231.72,131.83
  T16 w0.107: 231.72,131.83 231.83,131.73 232.5,131.73 234.09,133.31 237.43,133.31 239.47,131.27 239.62,131.27 240.55,132.2 240.93,132.2 241.25,131.88 241.25,131.5 240.32,130.57 240.32,130.42 240.47,130.27 240.62,130.27 241.55,131.2 241.93,131.2 242.25,130.88 242.25,130.5 241.32,129.57 241.32,129.42 241.91,128.83 242.85,128.83 242.95,128.94 242.95,131.87 243.22,132.14 243.67,132.14 243.94,131.87 243.94,128.94 244.05,128.83 244.26,128.83 244.37,128.94 244.37,131.87 244.64,132.14 245.08,132.14 245.35,131.87 245.35,128.94 245.46,128.83 245.67,128.83 245.78,128.94 245.78,131.87 246.05,132.14 246.49,132.14 246.76,131.87 246.76,128.94 246.87,128.83 247.08,128.83 247.19,128.94 247.19,131.87 247.46,132.14 247.91,132.14 248.18,131.87 248.18,128.94 248.28,128.83 248.74,128.83 249.25,129.34 249.25,132.66 249.9,133.31 254.04,133.31 254.69,132.67 254.84,132.67 v4(254.9,132.73)
MAC_DDRC_DQS2_DP: length 65.9
  TOP w0.109: U7.G3 v4(254.9,131.93)
  TOP w0.14: U1.AJ4 v4(229.86,130.5)
  T16 w0.102: v4(229.86,130.5) 229.56,130.5 229.46,130.6 229.46,131.66 229.69,131.89 231.32,131.89 231.5,131.71 231.5,131.65 231.52,131.64
  T16 w0.107: v4(254.9,131.93) 254.9,132.06 253.93,133.03 250.02,133.03 249.53,132.54 249.53,129.22 248.86,128.55 248.17,128.55 247.9,128.83 247.9,131.75 247.79,131.86 247.58,131.86 247.47,131.75 247.47,128.83 247.2,128.55 246.75,128.55 246.48,128.83 246.48,131.75 246.38,131.86 246.16,131.86 246.06,131.75 246.06,128.83 245.79,128.55 245.34,128.55 245.07,128.83 245.07,131.75 244.97,131.86 244.75,131.86 244.65,131.75 244.65,128.83 244.38,128.55 243.93,128.55 243.66,128.83 243.66,131.75 243.55,131.86 243.34,131.86 243.23,131.75 243.23,128.83 242.96,128.55 241.79,128.55 241.04,129.31 241.04,129.69 241.97,130.62 241.97,130.77 241.82,130.92 241.66,130.92 240.74,129.99 240.36,129.99 240.04,130.31 240.04,130.69 240.97,131.62 240.97,131.77 240.82,131.92 240.67,131.92 239.74,130.99 239.36,130.99 237.31,133.03 234.2,133.03 232.62,131.45 231.71,131.45 231.52,131.64
