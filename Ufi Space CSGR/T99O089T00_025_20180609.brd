# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2C_CPLD_SCL: length 42.2
  TOP w0.14: U70.L11 v4(118.8,124.05) ; v1(84.07,122.17) 84.39,122.49 U111.4
  T14 w0.117: v1(99.82,120.52) 98.93,121.41 84.84,121.41 v1(84.07,122.17)
  T18 w0.117: v1(99.82,120.52) 100.2,120.9 102.87,120.9 103.25,120.52 104.56,120.52 105.05,121.01 113.14,121.01 114.74,119.41 117.63,119.41 118.4,120.17 118.4,123.65 v4(118.8,124.05)
I2C_CPLD_SDA: length 48
  TOP w0.14: U70.K11 v4(118.8,124.85) ; U112.4 80.62,122.33 v1(80.77,122.17)
  T14 w0.117: v1(80.77,122.17) 82.04,120.9 97.67,120.9 v1(98.55,120.02)
  T18 w0.117: v4(118.8,124.85) 119.2,124.45 119.2,120.03 117.93,118.76 114.32,118.76 112.49,120.59 105.22,120.59 103.99,119.36 99.21,119.36 v1(98.55,120.02)
I2C_GNSS_SCL: length 276.5
  TOP w0.14: v1(141.86,173.61) 141.48,173.61 140.9,174.19 U76.7
  T07 w0.117: v1(57.91,184.55) 58.07,184.71 61.11,184.71 64.37,181.44 70.64,181.44 73.56,178.52 83.23,178.52 85.85,175.9 87.54,175.9 89.11,174.33 92.29,174.33 95,177.04 97.79,177.04 98.17,176.66 100.8,176.66 102.62,174.84 102.62,170.18 105.2,167.6 135.98,167.6 139.32,170.94 139.32,171.7 140.59,172.97 141.22,172.97 v1(141.86,173.61)
  T18 w0.117: v1(57.91,184.55) 57.81,184.45 51.12,184.45 47.09,180.42 47.09,161.61 44.46,158.98 44.46,147.62 45.44,146.64 45.44,138.42 45.33,138.31 45.33,136.57 43.69,134.93 39.96,134.93 35.06,130.03 35.06,103.51 26.53,94.97 26.53,84.51 28.79,82.25 28.79,76.37 22.86,70.45 22.86,57.78 19.49,54.41 19.49,37.77 v1(18.49,36.78)
  BOTTOM w0.14: v1(141.86,173.61) 141.51,173.96 R1990.1 ; R1606.1 v1(18.49,36.78)
I2C_GNSS_SDA: length 277.8
  TOP w0.14: v1(140.59,173.61) 140.25,173.95 U76.6
  T07 w0.117: v1(140.59,173.61) 138.81,171.83 138.81,171.2 135.64,168.02 105.54,168.02 103.25,170.31 103.25,174.4 103.12,174.53 103.12,176.28 101.47,177.93 95.29,177.93 92.11,174.75 89.28,174.75 86.75,177.28 85.48,177.28 83.82,178.94 73.82,178.94 70.9,181.86 64.55,181.86 61.28,185.13 57.62,185.13 57.28,184.78 57.28,184.15 v1(57.66,183.77)
  T18 w0.117: v1(57.66,183.77) 57.4,184.03 51.3,184.03 47.52,180.25 47.52,161.43 44.88,158.8 44.88,147.8 45.86,146.82 45.86,136.51 43.87,134.51 40.14,134.51 35.48,129.86 35.48,103.34 26.95,94.8 26.95,84.69 29.21,82.42 29.21,76.2 23.37,70.36 23.37,57.66 19.91,54.2 19.91,37.05 v1(18.49,35.64)
  BOTTOM w0.14: R1605.1 v1(18.49,35.64) ; v1(140.59,173.61) 140.49,173.71 R1991.1
I2C_HWM_ADDR0: length 7
  TOP w0.14: R1039.2 111.38,191.06 113.03,191.06 113.28,191.32 R1042.1 v1(114.05,191.7) 114.1,191.7 114.61,192.21 U73.61
I2C_HWM_ADDR1: length 7
  TOP w0.14: R1038.2 111.38,192.33 113.13,192.33 113.28,192.49 R1041.1 v1(113.92,192.97) 114.18,192.71 U73.60
I2C_HWM_ALERT_N: length 4.8
  TOP w0.14: R1037.2 128.85,197.41 v1(128.85,197.36) R1027.2 128.02,196.6 127.38,195.96 126.87,195.96 126.62,195.71 U73.27
I2C_HWM_CLK: length 80.8
  TOP w0.14: J3.3 139.39,139.67 v1(140.03,140.3) ; U73.15 124.62,189.02 124.94,188.7 R1025.2 R1035.2 v1(126.21,187.89)
  T16 w0.117: v1(152.65,174.75) 151.64,173.74 151.64,157.35 143.76,149.48 143.76,145.76 140.03,142.02 v1(140.03,140.3)
  T18 w0.117: v1(152.65,174.75) 149.47,177.93 145.78,177.93 145.43,177.93 143.13,180.23 143.13,182.43 138.9,186.65 127.44,186.65 v1(126.21,187.89)
I2C_HWM_CNTRL: length 140.4
  TOP w0.14: U73.28 125.07,196.21 v1(124.71,195.85) ; U154.V5 v4(57.73,118.53)
  T03 w0.117: v1(124.71,195.85) 123.8,195.85 122.38,197.28 107.63,197.28 103.25,192.9 103.25,190.12 101.79,188.66 92.92,188.66 92.21,187.94 92.21,187.48 91.54,186.81 84.84,186.81 82.38,184.34 79.29,184.34 78.46,183.51 74.66,183.51 73.28,182.13 68,182.13 58.69,172.81 58.69,170.17 59.16,169.7 v1(59.18,169.7)
  T05 w0.117: v1(59.18,169.7) 58.99,169.5 58.99,165.41 55.85,162.27 55.85,153.35 57.68,151.52 57.68,135.82 57.16,135.3 56.55,134.69 56.55,132.81 57.95,131.42 57.95,125.51 57.28,124.84 57.28,122.94 58.23,121.98 58.23,119.04 v4(57.73,118.53)
  BOTTOM w0.14: R1028.2 124.92,196.06 v1(124.71,195.85)
I2C_HWM_DAT: length 78.5
  TOP w0.14: R1026.2 R1036.2 127.48,187.36 127.6,187.48 v1(127.6,187.84) 126.73,188.71 125.62,188.71 125.12,189.21 U73.16 ; J3.2 v1(141.93,142.79)
  T16 w0.117: v1(153.16,173.86) 152.15,172.85 152.15,157.14 144.27,149.27 144.27,145.67 141.93,143.33 v1(141.93,142.79)
  T18 w0.117: v1(127.6,187.84) 128.16,188.41 132.57,188.41 132.58,188.42 139.66,188.42 143.76,184.32 143.76,180.19 145.6,178.35 150.07,178.35 153.29,175.13 153.29,173.99 v1(153.16,173.86)
I2C_IOP_ABS0_ADDR0: length 5.2
  BOTTOM w0.14: R656.1 174.68,24.54 R663.2 174.68,25.22 175.01,25.55 v2(175.14,25.55) 176.2,26.61 U47.21
I2C_IOP_ABS0_ADDR1: length 4.2
  BOTTOM w0.14: R657.1 R664.2 174.17,35.3 v2(174.37,35.09) 174.9,34.57 U47.2
I2C_IOP_ABS0_ADDR2: length 5.7
  BOTTOM w0.14: R658.1 174.83,36.43 175.09,36.17 R665.2 175.65,36.06 v1(175.65,35.07) 175.55,34.97 U47.3
I2C_IOP_ABS0_SCL: length 9
  BOTTOM w0.14: U47.22 175.55,26.71 175.16,26.32 174.42,26.32 v2(173.74,25.65) 172.79,24.69 172.79,22.35 R653.1
I2C_IOP_ABS0_SDA: length 10.1
  BOTTOM w0.14: U47.23 174.9,26.89 174.78,26.76 173.08,26.76 v2(172.75,26.44) 172.34,26.03 172.34,22.55 171.44,21.65 171.02,21.65 170.33,20.96 R655.1
I2C_IOP_ABS1_ADDR0: length 6.8
  BOTTOM w0.14: R681.2 R674.1 206.43,21.86 v1(206.43,23.08) 207.11,23.77 U49.21
I2C_IOP_ABS1_ADDR1: length 5.1
  BOTTOM w0.14: R675.1 R682.2 204.98,34.8 204.47,34.29 v2(204.47,34.16) 204.47,34.04 204.72,33.78 205.49,33.78 205.81,33.46 U49.2
I2C_IOP_ABS1_ADDR2: length 7.7
  BOTTOM w0.14: U49.3 206.46,33.64 205.73,34.37 205.73,36.61 205.47,36.87 v2(205.47,37.53) 206.53,37.53 R676.1 207.69,37.48 R683.2
I2C_IOP_ABS1_SCL: length 5.6
  BOTTOM w0.14: R671.1 205.32,23.8 v2(205.66,24.15) 206.46,24.95 U49.22
I2C_IOP_ABS1_SDA: length 5.9
  BOTTOM w0.14: R673.1 203.96,23.68 v2(204.2,23.92) 205.81,25.53 U49.23
I2C_IOP_ALRM_ADDR0: length 5.7
  TOP w0.14: U150.21 109.77,176.62 110.35,176.04 v1(110.35,175.85) R1875.1 110.82,175.21 110.97,175.06 110.97,173.2 110.7,172.93 R1878.2
I2C_IOP_ALRM_ADDR1: length 4.1
  TOP w0.14: R1876.1 R1879.2 110.83,185.08 v5(111.07,184.84) U150.2
I2C_IOP_ALRM_ADDR2: length 4.3
  TOP w0.14: R1877.1 R1880.2 v5(109.76,185.25) 110.42,184.6 U150.3
I2C_IOP_ALRM_SCL: length 2.6
  TOP w0.14: U150.22 110.42,178.69 v5(110.36,178.75)
  BOTTOM w0.14: v5(110.36,178.75) 110.24,178.87 R1873.1
I2C_IOP_ALRM_SDA: length 3.1
  TOP w0.14: v5(111.79,178.72) 111.41,178.72 111.07,178.38 U150.23
  BOTTOM w0.14: v5(111.79,178.72) 112.13,179.06 R1874.1
I2C_IOP_DIS0_ADDR0: length 5.4
  BOTTOM w0.14: R714.1 R720.2 102.88,25.28 v2(103.33,25.73) 104.5,26.9 U54.21
I2C_IOP_DIS0_ADDR1: length 5.4
  BOTTOM w0.14: R721.2 R715.1 101.22,35.18 v2(101.35,35.05) 102.62,35.05 103.2,34.47 U54.2
I2C_IOP_DIS0_ADDR2: length 5.5
  BOTTOM w0.14: U54.3 103.85,35 v2(103.76,35.09) 103.74,35.11 R722.2 103.41,36.17 103.02,36.56 R716.1
I2C_IOP_DIS0_SCL: length 6
  BOTTOM w0.14: v2(100.77,30.73) R708.1 101.52,29.38 101.84,29.7 103.18,29.7 103.85,29.03 U54.22
I2C_IOP_DIS0_SDA: length 7.3
  BOTTOM w0.14: U54.23 103.2,28.84 102.93,29.11 102.26,29.11 101.29,28.14 R713.1 100.77,28.32 100.35,28.75 99.61,28.75 99.48,28.87 99,28.87 98.38,29.49 v2(98.38,29.88)
I2C_IOP_DIS1_ADDR0: length 7.1
  BOTTOM w0.14: U56.21 236.07,24.43 235.86,24.22 v2(235.86,22.74) 236.3,22.3 R738.2 R732.1
I2C_IOP_DIS1_ADDR1: length 4.2
  BOTTOM w0.14: R733.1 R739.2 233.93,34.28 v2(234.12,34.09) 234.77,33.44 U56.2
I2C_IOP_DIS1_ADDR2: length 6.9
  BOTTOM w0.14: R734.1 235.73,37.46 234.61,37.46 v2(234.53,37.37) 234.53,35.57 234.54,35.56 234.54,35.45 234.81,35.17 R740.2 235.31,34.7 235.16,34.54 235.16,33.77 235.42,33.51 U56.3
I2C_IOP_DIS1_SCL: length 6.2
  BOTTOM w0.14: U56.22 235.42,24.41 235.42,24.41 235.42,24.21 v2(234.27,23.07) 233.64,22.44 R726.1
I2C_IOP_DIS1_SDA: length 6.5
  BOTTOM w0.14: U56.23 234.77,25.7 v2(232.95,23.88) 232.38,23.31 R728.1
I2C_IOP_FLT0_ADDR0: length 7.5
  BOTTOM w0.14: R710.1 117.6,22.74 117.6,24.27 117.34,24.54 R717.2 116.92,24.72 118.06,25.86 v2(118.23,25.86) 118.55,26.18 U53.21
I2C_IOP_FLT0_ADDR1: length 4.2
  BOTTOM w0.14: R711.1 R718.2 116.41,35.91 v2(117.05,35.27) 117.25,35.07 U53.2
I2C_IOP_FLT0_ADDR2: length 7.4
  BOTTOM w0.14: R712.1 118.1,39.03 v2(117.65,38.58) 117.07,38 117.07,36.38 117.28,36.17 R719.2 117.9,36.06 U53.3
I2C_IOP_FLT0_SCL: length 9.7
  BOTTOM w0.14: v2(117.6,19.68) 117.6,21.84 117.45,22 R707.1 116.28,22.63 116.28,24.84 117.46,26.02 117.46,26.18 117.9,26.61 U53.22
I2C_IOP_FLT0_SDA: length 6.6
  BOTTOM w0.14: R709.1 115.78,25.61 v2(116.2,26.04) 116.48,26.04 117.25,26.8 U53.23
I2C_IOP_FLT1_ADDR0: length 6.1
  BOTTOM w0.14: R735.2 R729.1 249.71,23.13 v2(250.37,23.79) 250.42,23.84 U55.21
I2C_IOP_FLT1_ADDR1: length 8
  BOTTOM w0.14: R730.1 248.28,35.17 R736.2 248.28,34.31 249.12,33.47 U55.2 249.12,31.44 248.07,30.4 v2(246.76,30.4)
I2C_IOP_FLT1_ADDR2: length 5.6
  BOTTOM w0.14: R731.1 248.94,35.41 249.18,35.17 R737.2 249.66,34.11 v2(249.68,34.09) 249.77,34 U55.3
I2C_IOP_FLT1_SCL: length 5.1
  BOTTOM w0.14: U55.22 249.77,25.28 v2(249.28,24.79) 248.37,23.88 R725.1
I2C_IOP_FLT1_SDA: length 5.4
  BOTTOM w0.14: R727.1 247.11,23.86 v2(247.35,24.09) 249.12,25.86 U55.23
I2C_IOP_FLT2_ADDR0: length 5
  BOTTOM w0.14: U57.21 v2(264.52,24.96) 264.52,23.89 R753.2 R746.1
I2C_IOP_FLT2_ADDR1: length 4
  BOTTOM w0.14: R747.1 R754.2 263.52,34.3 v2(263.27,34.05) 263.22,33.99 U57.2
I2C_IOP_FLT2_ADDR2: length 9.7
  BOTTOM w0.14: v2(261.24,31.24) 263.65,31.24 263.87,31.46 U57.3 263.87,33.56 264.9,34.59 R755.2 264.89,35.18 264.41,35.18 264.18,35.41 R748.1
I2C_IOP_LOS0_ADDR0: length 8
  BOTTOM w0.14: U48.21 147.22,26.75 146.16,25.69 146.16,25.5 145.6,24.94 R666.2 146.04,24.54 146.29,24.29 146.29,22.43 v2(146.38,22.34) 147.02,21.71 R660.1
I2C_IOP_LOS0_ADDR1: length 4.2
  BOTTOM w0.14: R661.1 R667.2 145.09,35.47 v2(145.46,35.1) 145.92,34.64 U48.2
I2C_IOP_LOS0_ADDR2: length 7.3
  BOTTOM w0.14: U48.3 146.57,36.06 R668.2 145.99,36.17 145.8,36.36 145.8,38.32 v2(146.07,38.6) 146.41,38.94 R662.1
I2C_IOP_LOS0_SCL: length 7.5
  BOTTOM w0.14: U48.22 146.57,26.8 145.38,25.61 v2(145.18,25.61) 144.91,25.35 144.91,23.03 145.09,22.85 145.09,21.86 R654.1
I2C_IOP_LOS0_SDA: length 7.7
  BOTTOM w0.14: U48.23 145.92,26.86 145.68,26.62 144.87,26.62 144.32,26.07 v2(144.32,22.53) 144.32,21.49 R659.1
I2C_IOP_LOS1_ADDR0: length 5
  BOTTOM w0.14: R678.1 R684.2 279.02,8.37 v2(278.31,9.09) 278.31,9.72 278.61,10.03 U50.21
I2C_IOP_LOS1_ADDR1: length 5.3
  BOTTOM w0.14: R679.1 R685.2 275.25,18.85 v2(275.87,18.23) 276.87,18.23 277.31,17.79 U50.2
I2C_IOP_LOS1_ADDR2: length 4.3
  BOTTOM w0.14: R680.1 276.75,19.61 277.6,19.61 R686.2 277.6,18.67 v2(277.74,18.53) 277.96,18.31 U50.3
I2C_IOP_LOS1_SCL: length 4
  BOTTOM w0.14: U50.22 277.96,10.09 277.12,9.25 v2(276.83,9.25) 276.44,8.85 R672.1
I2C_IOP_LOS1_SDA: length 4.2
  BOTTOM w0.14: R677.1 274.33,12.57 v2(275.46,12.57) 276.88,12.57 277.31,12.14 U50.23
I2C_IOP_QSFP28_SCL: length 6.8
  BOTTOM w0.14: R743.1 261.82,21.58 261.82,23.89 262.51,24.58 v2(262.89,24.58) 263.87,25.56 U57.22
I2C_IOP_QSFP28_SDA: length 6.9
  BOTTOM w0.14: R745.1 261.06,24.35 v2(261.39,24.68) 262.27,25.56 262.98,25.56 263.22,25.8 U57.23
I2C_IOP_RS0_ADDR0: length 9
  BOTTOM w0.14: U51.21 131.92,26.07 v2(131.46,25.61) 130.81,24.96 130.81,23.75 130.81,23.02 R699.2 130.01,22.63 129.87,22.5 129.87,20.56 R692.1
I2C_IOP_RS0_ADDR1: length 5.1
  BOTTOM w0.14: R700.2 128.72,36.17 R693.1 128.72,35.11 v2(128.78,35.05) 129.03,34.8 130.18,34.8 130.62,34.36 U51.2
I2C_IOP_RS0_ADDR2: length 7.2
  BOTTOM w0.14: R701.2 129.98,39.14 v2(129.98,38.13) 130.37,37.73 130.37,36.4 130.15,36.17 R694.1 129.74,35.87 131.27,34.33 U51.3
I2C_IOP_RS0_SCL: length 8.7
  BOTTOM w0.14: R689.1 129.38,20.59 129.38,23.82 v2(129.87,24.3) 130.25,24.68 130.25,25.98 131.27,27.01 U51.22
I2C_IOP_RS0_SDA: length 8.9
  BOTTOM w0.14: R691.1 128.94,21.28 128.94,25.43 v2(129.31,25.81) 130.62,27.12 U51.23
I2C_IOP_RS1_ADDR0: length 9
  BOTTOM w0.14: R696.1 189.42,19.85 189.42,21.92 189.64,22.14 R702.2 190.05,23.69 189.51,24.23 v2(189.51,25.22) U52.21
I2C_IOP_RS1_ADDR1: length 7.3
  BOTTOM w0.14: R703.2 186.62,38.4 186.85,38.17 186.85,36.25 186.71,36.11 R697.1 186.24,34.94 v2(186.26,34.92) 186.57,34.62 187.96,34.62 188.21,34.37 U52.2
I2C_IOP_RS1_ADDR2: length 10.4
  BOTTOM w0.14: R704.2 188.13,37.86 188.13,36.2 187.99,36.06 R698.1 187.58,35.63 188.86,34.35 U52.3 188.86,32.14 187.7,30.98 v2(186.32,30.98)
I2C_IOP_RS1_SCL: length 5.7
  BOTTOM w0.14: U52.22 188.86,26.03 188.62,25.79 v2(188.62,23.54) 188.62,22.17 R690.1
I2C_IOP_RS1_SDA: length 6
  BOTTOM w0.14: U52.23 188.21,26.25 187.38,25.43 v2(187.38,25.01) R695.1
I2C_IOP_VMG_ADDR0: length 4.8
  TOP w0.14: U58.21 99.9,192.61 v1(99.29,193.22)
  BOTTOM w0.14: v1(99.29,193.22) 98.5,192.44 R756.2 R750.1
I2C_IOP_VMG_ADDR1: length 4.5
  TOP w0.14: v1(100.81,195.51) 101.2,195.9 U58.2
  BOTTOM w0.14: v1(100.81,195.51) 100.72,195.6 R757.2 R751.1
I2C_IOP_VMG_ADDR2: length 5.2
  TOP w0.14: v1(98.9,195.89) 100.26,195.89 100.55,196.18 U58.3
  BOTTOM w0.14: v1(98.9,195.89) 98.58,196.22 R752.1 R758.2
I2C_IOP_VMG_SCL: length 3.8
  TOP w0.14: U58.22 v1(100.55,194.11)
  BOTTOM w0.14: R744.1 100.68,193.98 v1(100.55,194.11)
I2C_IOP_VMG_SDA: length 4.3
  TOP w0.14: U58.23 101.2,193.23 v1(102.08,194.11)
  BOTTOM w0.14: R749.1 101.83,193.86 v1(102.08,194.11)
I2C_MAC_SCL: length 38
  TOP w0.14: v1(177.48,117.91) 177.52,117.96 R50.2 ; U1.AC32 v4(200.86,124.5)
  T03 w0.117: v4(200.86,124.5) 200.83,124.5 200.42,124.09 200.42,121.31 200.08,120.97 197.7,120.97 197.32,120.59 195.31,120.59 194.33,119.61 194.33,118.14 193.29,117.1 191.04,117.1 189.78,115.84 189.09,115.84 187.29,114.04 187.1,114.04 186.82,113.76 185.59,113.76 185.31,114.04 179.93,114.04 177.48,116.49 v1(177.48,117.91)
  BOTTOM w0.14: v2(174.37,118.11) 174.91,117.56 176.94,117.56 177.29,117.91 v1(177.48,117.91)
I2C_MAC_SDA: length 37.3
  TOP w0.14: U1.AB31 v4(201.86,123.5) ; R51.2 v1(176.49,118.22)
  T03 w0.102: 195.65,120.13 197.65,120.13 198.06,120.53 200.53,120.53 201.29,121.3 201.29,122.93 v4(201.86,123.5)
  T03 w0.117: v1(176.49,118.22) 176.49,116.88 179.75,113.62 185.14,113.62 185.42,113.34 187,113.34 187.28,113.62 187.47,113.62 189.27,115.42 189.62,115.42 189.62,115.42 189.95,115.42 191.21,116.68 193.58,116.68 195.06,118.15 195.06,119.54 195.65,120.13
  BOTTOM w0.14: v1(176.49,118.22) 176.57,118.3 v2(176.57,119.95)
I2C_MGMT_MUX1_ADDR0: length 4
  TOP w0.14: U67.1 86.62,181.22 86.43,181.41 v1(86.11,181.41)
  BOTTOM w0.14: R961.2 86.11,182.28 v1(86.11,181.41) 86.11,180.55 R958.1
I2C_MGMT_MUX1_ADDR1: length 3.4
  TOP w0.14: v1(87.38,181.41) 87.27,181.31 U67.2
  BOTTOM w0.14: R960.2 v1(87.38,181.41) R957.1
I2C_MGMT_MUX1_ADDR2: length 4.9
  TOP w0.14: U67.13 88.57,185.04 89.03,184.59 v1(89.53,184.59)
  BOTTOM w0.14: R956.1 R959.2 90.55,185.05 90.09,184.59 v1(89.53,184.59)
I2C_MGMT_MUX1_SCL: length 2.8
  TOP w0.14: v1(88.14,184.46) 87.92,184.67 U67.14
  BOTTOM w0.14: v1(88.14,184.46) 88.52,184.84 R955.1
I2C_MGMT_MUX1_SDA: length 2.8
  TOP w0.14: U67.15 87.27,184.87 v1(86.87,184.46)
  BOTTOM w0.14: R954.1 87.5,185.1 v1(86.87,184.46)
I2C_MGMT_SCL: length 20.8
  TOP w0.14: v1(83.6,172.33) 83.4,172.13 U165.4
  T16 w0.117: v1(88.61,187.53) 88.61,187.04 82.17,180.59 82.17,175.77 83.6,174.34 v1(83.6,172.33)
  BOTTOM w0.14: R955.2 88.52,187.44 v1(88.61,187.53)
I2C_MGMT_SDA: length 19.6
  TOP w0.14: U172.4 79.9,173.12 v1(79.95,173.16)
  T16 w0.117: v1(87.29,187.41) 87.29,186.48 81.41,180.59 81.41,174.62 v1(79.95,173.16)
  BOTTOM w0.14: v1(87.29,187.41) 87.5,187.2 R954.2
I2C_MUX0_ADDR0: length 2.9
  TOP w0.14: R2000.1 R2003.2 135.96,174.49 v1(136.23,174.75) 136.76,175.28 U76.1
I2C_MUX0_ADDR1: length 6.7
  TOP w0.14: R1999.1 R2002.2 137.29,176.52 137.65,176.17 U76.2 137.65,174.33 v1(136.65,173.33)
I2C_MUX0_ADDR2: length 6
  TOP w0.14: v1(138.05,178.56) 138.95,179.46 U76.13
  BOTTOM w0.14: R1998.1 R2001.2 137.75,178.86 v1(138.05,178.56)
I2C_MUX0_SCL: length 4.7
  TOP w0.14: R1997.1 135.54,178.41 v1(136.6,178.41) 136.98,178.41 138.3,179.73 U76.14
I2C_MUX0_SDA: length 3.4
  TOP w0.14: U76.15 137.65,179.88 137.4,179.63 v1(136.21,179.63) 135.45,179.63 R1996.1
I2C_MUX3_ADDR0: length 5.4
  BOTTOM w0.14: U62.1 87.27,33.46 86.72,34.01 v2(86.72,34.77) 87.76,35.81 R849.2 R845.1
I2C_MUX3_ADDR1: length 8.2
  BOTTOM w0.14: U62.2 88.57,34.49 88.27,34.8 88.27,38.14 87.93,38.47 87.93,39.06 v2(87.93,39.06) 88.27,39.4 R848.2 R844.1
I2C_MUX3_ADDR2: length 5.2
  BOTTOM w0.14: U62.21 89.87,26.35 v2(89.06,25.54) 88.6,25.08 R842.1 R847.2
I2C_MUX4_ADDR0: length 4.7
  BOTTOM w0.14: U63.1 159.24,34.07 158.4,34.91 v2(158.4,35.09) 158.4,35.33 159.08,36.01 R873.2 R869.1
I2C_MUX4_ADDR1: length 8.8
  BOTTOM w0.14: 159.75,39.26 159.61,39.4 R868.1 158.21,39.4 v2(157.86,39.75) ; 159.75,39.26 159.89,39.4 R872.2 ; 159.75,39.26 159.68,39.19 159.68,35.78 159.64,35.74 159.64,34.73 159.9,34.47 159.9,33.47 U63.2
I2C_MUX4_ADDR2: length 5.2
  BOTTOM w0.14: R871.2 R867.1 159.92,25.28 v2(160.49,25.85) 161.19,26.55 U63.21
I2C_MUX5_ADDR0: length 4.6
  BOTTOM w0.14: U64.1 219.87,33.24 219.25,33.86 v2(219.25,34.14) 219.25,34.22 219.71,34.68 R897.2 R891.1
I2C_MUX5_ADDR1: length 11.1
  BOTTOM w0.14: 220.35,38.3 220.35,34.94 220.16,34.75 220.16,33.82 220.39,33.59 220.41,33.59 220.52,33.48 U64.2 220.52,31.42 220.22,31.11 218.82,31.11 v2(218.31,31.62) ; 220.35,38.3 220.26,38.4 R893.1 ; 220.35,38.3 220.45,38.4 R896.2
I2C_MUX5_ADDR2: length 4.6
  BOTTOM w0.14: U64.21 221.82,25.57 221.28,25.03 v2(221.28,24.72) 220.81,24.25 R890.1 R895.2
I2C_MUX6_ADDR0: length 5.1
  BOTTOM w0.14: U65.1 276.77,32.65 276.39,33.03 275.99,33.03 275.72,33.3 v2(275.72,33.66) 276.61,34.55 R921.2 R914.1
I2C_MUX6_ADDR1: length 7.5
  BOTTOM w0.14: R917.1 277.08,37.95 277.29,37.74 ; R920.2 277.5,37.95 277.29,37.74 ; U65.2 277.42,33.31 v2(277.06,33.66) 277.06,34.24 277.29,34.47 277.29,37.74
I2C_MUX6_ADDR2: length 4.6
  BOTTOM w0.14: U65.21 278.72,25.6 v2(279.53,24.79) 279.89,24.44 R919.2 R916.1
I2C_QSFP28_MUX7_SCL: length 3.4
  BOTTOM w0.14: U69.14 297.73,38.49 v2(296.82,37.58) 295.74,37.58 R987.1
I2C_QSFP28_MUX7_SDA: length 3.1
  BOTTOM w0.14: U69.15 297.02,39.14 v2(296.79,38.9) 296.64,38.76 R986.1
I2C_QSFP28_P1_SCL: length 31.8
  T14 w0.117: CJ12.U_11 302.56,60.52 303.26,59.83 303.26,58.41 302.53,57.68 302.53,56.7 303.38,55.85 303.38,54.49 302.04,53.15 302.04,50.8 302.86,49.99 302.86,47.02 301.36,45.52 301.36,44.59 300.65,43.89 300.65,42.67 v1(299.44,41.45)
  BOTTOM w0.14: R984.1 298.92,41.97 v1(299.44,41.45) 300.42,40.47 300.42,37.83 299.78,37.19 U69.12
I2C_QSFP28_P1_SDA: length 31.3
  T05 w0.117: v1(300.45,41.45) 300.56,41.55 300.56,43.84 301.59,44.87 301.59,45.17 302.22,45.8 302.22,45.85 302.67,46.3 302.67,50.23 300.2,52.69 300.2,53.7 301.91,55.4 301.91,57.22 303.36,58.68 CJ12.U_12
  BOTTOM w0.14: R985.1 299.99,41.91 v1(300.45,41.45) 301.15,40.75 301.15,37.68 300.01,36.54 U69.11
I2C_QSFP28_P2_SCL: length 24.3
  T05 w0.117: CJ12.L_11 302.56,53.48 302.1,53.02 302.1,51.32 303.09,50.33 303.09,47.55 304.04,46.6 304.04,44.6 303.76,44.32 303.76,43.49 v1(301.6,41.32)
  BOTTOM w0.14: R982.1 301.06,41.86 v1(301.6,41.32) 301.6,37.32 300.16,35.89 U69.10
I2C_QSFP28_P2_SDA: length 27.1
  T05 w0.117: CJ12.L_12 305.44,51.33 305.44,46.48 307.09,44.83 307.09,43.18 304.98,41.07 v1(302.36,41.07)
  BOTTOM w0.14: R983.1 302.36,42.01 v1(302.36,41.07) 302.36,37.23 300.37,35.24 U69.9
I2C_QSFP28_P3_SCL: length 5.3
  BOTTOM w0.14: U69.7 v2(306.43,35.89) 306.78,35.89 307.72,36.83 307.72,37.23 R980.1
I2C_QSFP28_P3_SDA: length 5.2
  BOTTOM w0.14: R981.1 308.36,38.86 v2(306.83,37.34) 306.32,37.34 305.52,36.54 U69.6
I2C_QSFP28_P4_SCL: length 5.3
  BOTTOM w0.14: R978.1 308.02,39.9 v2(307.11,38.99) 305.31,37.19 U69.5
I2C_QSFP28_P4_SDA: length 6
  BOTTOM w0.14: U69.4 305.3,37.84 306.2,38.73 306.2,39.59 v2(307.09,40.48) 307.52,40.92 R979.1
I2C_SFP+_MUX2_SCL: length 3.8
  BOTTOM w0.14: U68.14 104.52,10.89 104.52,9.66 v2(103.82,8.95) 102.88,8.01 R971.1
I2C_SFP+_MUX2_SDA: length 4.7
  BOTTOM w0.14: R970.1 101.6,8.83 v2(101.73,8.96) 102.49,9.72 103.55,9.72 103.9,10.08 U68.15
I2C_SFP+_MUX3_SCL: length 8.2
  BOTTOM w0.14: U62.22 89.22,26.93 88.36,26.08 87.94,26.08 v2(87.68,25.82) 86.36,24.5 86.36,22.52 R846.1
I2C_SFP+_MUX3_SDA: length 8.5
  BOTTOM w0.14: U62.23 88.57,26.98 88.19,26.59 87.02,26.59 v2(86.26,25.83) 85.6,25.17 85.6,22.04 R843.1
I2C_SFP+_MUX4_SCL: length 8.2
  BOTTOM w0.14: R870.1 157.81,22.01 157.81,25.09 158.34,25.62 v2(158.75,25.62) 159.18,25.62 160.54,26.98 U63.22
I2C_SFP+_MUX4_SDA: length 8.6
  BOTTOM w0.14: R866.1 157.21,21.82 157.21,25.99 v2(157.32,26.1) 157.89,26.67 159.59,26.67 159.89,26.98 U63.23
I2C_SFP+_MUX5_SCL: length 8.1
  BOTTOM w0.14: R894.1 218.06,22.28 v2(218.06,22.73) 218.06,24.38 218.64,24.96 220.37,24.96 221.17,25.77 U64.22
I2C_SFP+_MUX5_SDA: length 8.2
  BOTTOM w0.14: R892.1 217.17,21.8 217.17,24.73 v2(218,25.56) 220.12,25.56 220.52,25.96 U64.23
I2C_SFP+_MUX6_SCL: length 7.5
  BOTTOM w0.14: v2(274.95,28.19) 277.62,28.19 278.07,27.75 U65.22 278.07,25.17 278.62,24.63 R918.1
I2C_SFP+_MUX6_SDA: length 3.7
  BOTTOM w0.14: R915.1 276.74,23.76 276.42,24.08 v2(276.42,24.59) 277.42,25.59 U65.23
I2C_SFP+_P00_SCL: length 22.7
  T07 w0.117: v1(90.48,35.44) 89.92,36 89.92,40.33 91.04,41.46 91.04,46.85 90.3,47.6 90.3,48.48 90.63,48.81 90.63,49.75 91.44,50.56 91.44,51.41 91.05,51.79 CJ8.AT5
  BOTTOM w0.14: R840.1 v1(90.48,35.44) 90.52,35.4 U62.5
I2C_SFP+_P00_SDA: length 28.2
  T05 w0.117: v1(90.48,40.01) 89.91,40.01 89.03,40.89 89.03,43.94 84.2,48.77 84.2,50.8 85.22,51.82 87,51.82 88.27,53.09 89.15,53.09 89.84,52.4 CJ8.AT4
  BOTTOM w0.14: v1(90.48,40.01) R841.1 90.01,39.27 89.79,39.05 89.79,35.69 89.92,35.56 89.92,33.5 U62.4
I2C_SFP+_P01_SCL: length 21.9
  T05 w0.117: v1(91.86,35.44) 92.53,36.11 92.53,40.61 95.87,43.95 95.87,47.79 94.96,48.7 92.22,48.7 CJ8.AL5
  BOTTOM w0.14: U62.7 91.82,35.4 v1(91.86,35.44) R838.1
I2C_SFP+_P01_SDA: length 25.8
  T05 w0.117: CJ8.AL4 91.49,51.62 88.62,51.62 88.27,51.27 88.27,50.61 87.2,49.54 87.2,46.48 88.85,44.83 89.92,44.83 91.19,43.56 91.19,40.29 v1(91.49,39.98)
  BOTTOM w0.14: U62.6 91.17,39 91.44,39.27 R839.1 91.86,39.62 v1(91.49,39.98)
I2C_SFP+_P02_SCL: length 44.4
  T03 w0.117: CJ8.BT5 106.09,54.58 109.49,54.58 110.6,53.47 110.6,35.99 109.47,34.87 93.8,34.87 v1(93.23,35.44)
  BOTTOM w0.14: R836.1 v1(93.23,35.44) 93.12,35.33 U62.9
I2C_SFP+_P02_SDA: length 54.6
  T05 w0.117: v1(93.23,40.01) 93.94,39.3 93.94,35.3 94.37,34.87 94.99,34.87 96.3,36.18 109.09,36.18 111.02,38.11 111.02,44.88 110.97,44.93 110.97,50.26 110.51,50.72 110.51,53.26 109.19,54.58 104.94,54.58 104.5,54.15 CJ8.BT4
  BOTTOM w0.14: U62.8 92.47,39.01 92.74,39.27 R837.1 v1(93.23,40.01)
I2C_SFP+_P03_SCL: length 37.5
  T05 w0.117: CJ8.BL5 106.47,48.7 108.17,48.7 108.3,48.84 109.1,48.84 110.22,47.71 110.22,45.71 109.22,44.7 109.22,40.82 109.8,40.24 109.8,39.77 108.73,38.71 95.91,38.71 v1(94.61,40.01)
  BOTTOM w0.14: v1(94.61,40.01) R834.1 95.04,39.27 95.25,39.06 95.25,35.08 94.42,34.26 U62.11
I2C_SFP+_P03_SDA: length 37.1
  T05 w0.117: CJ8.BL4 107.28,51.63 109.08,51.63 110.6,50.11 110.6,38.28 108.94,36.62 95.79,36.62 v1(94.61,35.44)
  BOTTOM w0.14: R835.1 v1(94.61,35.44) 93.77,34.6 U62.10
I2C_SFP+_P04_SCL: length 59.5
  T03 w0.117: v1(95.89,25.3) 96.54,25.96 99.34,25.96 101.29,27.9 106.09,27.9 112.15,33.96 122.61,33.96 125.48,36.83 125.48,49.87 123.74,51.62 121.43,51.62 121.14,51.91 121.14,52.71 120.05,53.79 CJ8.CT5
  BOTTOM w0.14: R832.1 95.47,24.89 v1(95.89,25.3) 95.89,25.59 94.42,27.05 U62.14
I2C_SFP+_P04_SDA: length 67.3
  T05 w0.117: CJ8.CT4 119.54,51.61 123.36,51.61 125.79,49.18 125.79,42.64 125.79,42.29 126.62,41.46 127.13,41.46 128.02,40.57 128.02,38.18 116.79,26.95 105.22,26.95 102.94,24.66 101.01,24.66 99.31,22.96 96.42,22.96 v1(96.29,23.09)
  BOTTOM w0.14: U62.13 95.07,27.25 96.65,25.67 96.65,23.45 v1(96.29,23.09) 95.97,22.77 95.97,20.92 96.18,20.71 R833.1
I2C_SFP+_P05_SCL: length 54.5
  T05 w0.117: CJ8.CL5 120.36,49.06 120.36,47.6 121.14,46.82 121.14,45.58 124.72,42 124.72,36.07 116.56,27.92 101.13,27.92 99.58,26.37 94.7,26.37 94.1,25.77 v1(94.1,25.28)
  BOTTOM w0.14: R830.1 v1(94.1,25.28) 94.1,25.69 93.12,26.66 U62.16
I2C_SFP+_P05_SDA: length 60
  T05 w0.117: CJ8.CL4 121.28,50.85 122.33,49.8 122.33,49.12 122.74,48.72 123.11,48.72 125.14,46.68 125.14,35.9 116.74,27.5 102.94,27.5 101.32,25.87 95.47,25.87 v1(94.9,25.3)
  BOTTOM w0.14: U62.15 93.77,26.86 94.9,25.74 v1(94.9,25.3) 94.9,22.59 94.74,22.43 94.74,20.86 94.88,20.71 R831.1
I2C_SFP+_P06_SCL: length 76.9
  T03 w0.117: CJ8.DT5 134.24,53.79 135,53.03 135.77,53.03 135.89,53.16 136.53,53.16 137,52.69 137,51.99 139.61,49.38 139.61,44.07 139.94,43.74 139.94,38.51 134.12,32.69 130.36,32.69 127.56,29.88 125.26,29.88 123.22,27.85 109.02,27.85 107.92,26.74 106.66,26.74 104.41,24.49 101.48,24.49 100.54,25.44 97.21,25.44 96.48,24.71 93.23,24.71 v1(92.66,25.28)
  BOTTOM w0.14: R828.1 92.73,25.19 92.66,25.25 v1(92.66,25.28) 92.59,25.28 91.82,26.04 U62.18
I2C_SFP+_P06_SDA: length 88.2
  T05 w0.117: v1(94.59,18.18) 95.29,18.88 101.48,18.88 103.55,20.95 113.13,20.95 116.1,23.92 124.39,23.92 126.11,25.64 131.83,25.64 142.27,36.08 142.27,40.57 140.49,42.35 140.49,47.18 138.46,49.22 138.46,49.63 137.69,50.39 137.21,50.39 136.92,50.1 136.26,50.1 135.79,50.57 135.79,51.23 135.37,51.65 133.76,51.65 CJ8.DT4
  BOTTOM w0.14: U62.17 92.47,26.4 93.32,25.56 93.32,20.85 93.46,20.71 R829.1 93.85,18.93 v1(94.59,18.18)
I2C_SFP+_P07_SCL: length 80.9
  T05 w0.117: v1(89.98,25.28) 90.54,25.84 92.9,25.84 93.28,25.46 93.28,21.93 93.61,21.6 99.8,21.6 100.58,22.37 100.58,23.48 101.17,24.08 110.3,24.08 111.42,22.96 113.31,22.96 115.12,24.77 116.54,24.77 118.39,26.61 125.62,26.61 125.95,26.94 130.32,26.94 134.62,31.24 134.62,32.38 139.45,37.21 139.45,39.58 138.95,40.08 138.95,40.96 133.79,46.11 133.79,46.82 134.6,47.62 134.6,48.33 134.2,48.72 CJ8.DL5
  BOTTOM w0.14: R826.1 v1(89.98,25.28) 90.52,25.82 U62.20
I2C_SFP+_P07_SDA: length 82.4
  T05 w0.117: v1(91.35,25.28) 91.96,24.67 91.96,21.95 92.73,21.18 100.7,21.18 101.73,22.2 103.01,22.2 103.57,22.76 103.57,23.21 104.01,23.66 110.12,23.66 111.24,22.54 113.7,22.54 115.51,24.35 123.95,24.35 126.04,26.44 132.03,26.44 140.4,34.8 140.4,39.22 139.37,40.25 139.37,47.17 137.83,48.71 135.28,48.71 135,48.98 CJ8.DL4
  BOTTOM w0.14: U62.19 91.17,25.45 v1(91.35,25.28) R827.1
I2C_SFP+_P08_SCL: length 36.7
  T03 w0.117: CJ8.ET5 147.65,54.19 147.65,55.63 148.44,56.42 148.44,57.1 149.07,57.73 151.51,57.73 152.58,56.66 152.58,54.55 153.94,53.2 154.37,53.2 155.53,52.04 155.53,46.62 160.55,41.6 160.55,39.33 161.11,38.77 161.11,36.13 v1(161.8,35.44)
  BOTTOM w0.14: R864.1 v1(161.8,35.44) 161.84,35.4 U63.5
I2C_SFP+_P08_SDA: length 27.9
  T18 w0.117: CJ8.ET4 148.02,51.64 151.69,51.64 154.58,48.75 154.58,46.75 161.32,40.01 v1(161.8,40.01)
  BOTTOM w0.14: v1(161.8,40.01) R865.1 161.34,39.27 161.2,39.13 161.2,33.47 U63.4
I2C_SFP+_P09_SCL: length 27.7
  T18 w0.117: v1(163.22,35.44) 162.4,36.26 157.17,36.26 153.51,39.91 153.51,47.3 152.11,48.69 149.23,48.69 CJ8.EL5
  BOTTOM w0.14: R862.1 163.18,35.48 v1(163.22,35.44) 163.14,35.35 U63.7
I2C_SFP+_P09_SDA: length 27
  T18 w0.117: CJ8.EL4 149.97,50.13 152.29,50.13 154.16,48.26 154.16,46.57 161.32,39.41 162.57,39.41 162.94,39.78 v1(162.94,40.03)
  BOTTOM w0.14: v1(162.94,40.03) 163.18,39.8 R863.1 162.76,39.27 162.49,39 U63.6
I2C_SFP+_P10_SCL: length 26.9
  T03 w0.117: CJ8.FT5 162.82,53.79 163.92,52.69 163.92,51.8 164.34,51.38 164.34,50.62 163.45,49.73 163.45,49.17 163.91,48.71 166.19,48.71 167.45,47.45 167.45,38.14 v1(164.75,35.44)
  BOTTOM w0.14: U63.9 164.44,34.86 164.7,35.12 164.7,35.39 v1(164.75,35.44) 164.55,35.63 R860.1
I2C_SFP+_P10_SDA: length 24.7
  T03 w0.117: v1(164.55,40.01) 163.98,40.01 157.86,46.13 157.86,48.91 159.49,50.54 159.49,51.36 159.77,51.63 160.74,51.63 CJ8.FT4
  BOTTOM w0.14: v1(164.55,40.01) R861.1 164.11,39.27 163.96,39.11 163.96,34.97 163.79,34.81 U63.8
I2C_SFP+_P11_SCL: length 21
  T05 w0.117: CJ8.FL5 163.4,48.77 166.06,48.77 167.16,47.67 167.16,41.24 v1(165.93,40.01)
  BOTTOM w0.14: U63.11 165.74,34.26 166.68,35.19 166.68,39.13 166.54,39.27 R858.1 v1(165.93,40.01)
I2C_SFP+_P11_SDA: length 23.6
  T05 w0.117: v1(165.93,35.44) 166.87,36.38 166.87,39.55 168.09,40.77 168.09,49.15 165.64,51.61 164.26,51.61 CJ8.FL4
  BOTTOM w0.14: U63.10 165.09,34.6 v1(165.93,35.44) R859.1
I2C_SFP+_P12_SCL: length 56.7
  T03 w0.117: CJ8.GT5 177.04,53.79 178.18,52.65 178.18,52.01 178.56,51.63 180.06,51.63 182.45,49.25 182.45,34.81 182.22,34.58 182.22,23.4 180.41,21.6 168.43,21.6 v1(167.81,22.22)
  BOTTOM w0.14: U63.14 165.74,27.05 167.09,25.71 v2(167.09,25.39) 167.09,24.96 167.81,24.23 v1(167.81,22.22) 167.81,22.14 167.81,22.14 R856.1
I2C_SFP+_P12_SDA: length 63
  T05 w0.117: v1(168.15,19.55) 169.02,20.42 175.55,20.42 176.72,21.59 176.72,23.19 177.29,23.76 178.08,23.76 179.51,25.18 179.51,26.12 185.02,31.63 185.02,40.66 182.88,42.8 182.88,49.87 181.49,51.25 181.49,52.85 181.1,53.24 180.29,53.24 180.01,52.96 179.48,52.96 179.21,53.22 178.69,53.22 178.43,52.96 177.89,52.96 177.63,53.22 177.07,53.22 176.25,52.4 CJ8.GT4
  BOTTOM w0.14: v1(168.15,19.55) 168.4,19.81 168.4,20.83 168.6,21.02 R857.1 169.2,21.83 168.46,22.57 168.46,25.24 166.39,27.3 U63.13
I2C_SFP+_P13_SCL: length 42
  T05 w0.117: CJ8.GL5 177.79,48.64 177.81,48.63 178.99,48.63 179.16,48.79 180.16,48.79 181.61,47.35 181.61,35.2 171.75,25.35 165.59,25.35 165.38,25.56 v1(165.38,25.65)
  BOTTOM w0.14: R854.1 165.42,25.61 v1(165.38,25.65) 165.38,25.72 164.44,26.66 U63.16
I2C_SFP+_P13_SDA: length 53.6
  T05 w0.117: CJ8.GL4 178.54,51.63 179.73,51.63 182.03,49.34 182.03,34.76 171.92,24.65 171.92,22.4 170.94,21.42 167.68,21.42 v1(165.97,19.71)
  BOTTOM w0.14: v1(165.97,19.71) 166.54,20.28 R855.1 166.93,20.71 167.14,20.93 167.14,23.99 166.2,24.94 166.2,25.92 165.64,26.48 165.35,26.48 165.09,26.74 U63.15
I2C_SFP+_P14_SCL: length 83
  T03 w0.117: v1(165.89,12.27) 177.26,12.27 187.86,22.87 187.86,28.22 196.56,36.92 196.56,38.49 196.24,38.81 195.99,39.05 195.99,44.55 196.98,45.54 196.98,49.15 193.96,52.17 193.96,52.76 193.67,53.05 191.54,53.05 CJ8.HT5
  T14 w0.117: v1(163.67,25.26) 164.38,24.54 164.88,24.04 164.88,13.28 v1(165.89,12.27)
  BOTTOM w0.14: U63.18 163.14,25.79 v1(163.67,25.26) 163.75,25.26 164.04,24.96 R852.1
I2C_SFP+_P14_SDA: length 86.1
  T05 w0.117: CJ8.HT4 190.45,52.4 191.3,53.24 191.85,53.24 192.04,53.05 192.77,53.05 192.91,53.19 193.54,53.19 193.7,53.03 194.34,53.03 194.53,53.22 195.26,53.22 195.85,52.63 195.85,51.59 195.91,51.53 195.91,51.52 198.41,49.02 198.41,43.58 199.94,42.05 199.94,30.15 192.42,22.63 188.66,22.63 181.16,15.14 176.37,15.14 175.35,14.12 166.94,14.12 v1(165.53,15.53)
  BOTTOM w0.14: U63.17 163.79,26.15 164.78,25.16 164.78,22.85 164.49,22.56 164.49,20.93 164.7,20.71 R853.1 165.16,15.9 v1(165.53,15.53)
I2C_SFP+_P15_SCL: length 74.8
  T05 w0.117: v1(162.69,16.67) 163.4,17.38 181.27,17.38 195.45,31.56 195.45,34.85 197.4,36.79 197.4,38.25 195.68,39.96 195.68,47.63 194.59,48.72 191.95,48.72 CJ8.HL5
  T14 w0.117: v1(162.69,16.67) 161.72,17.64 161.72,22.53 162.05,22.87 162.05,24.52 v1(161.3,25.28)
  BOTTOM w0.14: U63.20 161.84,25.82 v1(161.3,25.28) R850.1
I2C_SFP+_P15_SDA: length 82.5
  T05 w0.117: v1(164.19,15.57) 164.71,16.1 167.2,16.1 168.76,14.54 175.17,14.54 176.2,15.56 180.99,15.56 188.48,23.06 192.25,23.06 199.52,30.33 199.52,40.97 197.04,43.44 197.04,48.81 194.24,51.62 192.77,51.62 CJ8.HL4
  T14 w0.117: v1(164.19,15.57) 164.19,16.67 163.19,17.66 163.19,24.75 v1(162.67,25.28)
  BOTTOM w0.14: R851.1 v1(162.67,25.28) 162.49,25.45 U63.19
I2C_SFP+_P16_SCL: length 35.7
  T14 w0.117: CJ9.AT5 208.4,53.11 208.93,52.58 210.82,52.58 211.58,51.82 211.58,51.31 209.57,49.3 209.57,48.37 208.41,47.2 208.41,46.64 213.61,41.43 213.61,37.68 216.19,35.1 221.61,35.1 v1(222.28,34.43)
  BOTTOM w0.14: R888.1 222.28,35.01 v1(222.28,34.43) 222.47,34.24 U64.5
I2C_SFP+_P16_SDA: length 46
  T18 w0.117: CJ9.AT4 207.52,53.98 206.5,53.98 204.09,51.56 204.09,51.02 200.57,47.5 200.57,42.91 205.27,38.21 221.64,38.21 v1(222.44,39.01)
  BOTTOM w0.14: U64.4 221.82,33.6 221.71,33.71 221.71,38.06 221.92,38.27 R889.1 v1(222.44,39.01)
I2C_SFP+_P17_SCL: length 32.2
  T14 w0.117: CJ9.AB5 209.2,48.52 207.52,46.84 207.52,44.32 208.41,43.43 210.44,43.43 213.11,40.77 213.11,37.59 217.17,33.53 222.82,33.53 v1(223.7,34.41)
  BOTTOM w0.14: R886.1 223.7,35.06 v1(223.7,34.41) 223.77,34.34 U64.7
I2C_SFP+_P17_SDA: length 33.5
  T18 w0.117: CJ9.AB4 210,49.09 207.45,46.55 207.45,43.62 208.15,42.93 212.06,42.93 213.67,41.32 221.17,41.32 v1(223.48,39.01)
  BOTTOM w0.14: v1(223.48,39.01) 223.81,38.68 R887.1 223.33,38.27 223.12,38.06 U64.6
I2C_SFP+_P18_SCL: length 28.2
  T03 w0.117: CJ9.BT5 222.81,54.59 225.71,51.69 227.06,51.69 227.75,51 227.75,47.83 226.79,46.87 226.79,45.91 227.75,44.95 227.75,39.41 225.88,37.54 v1(225.88,34.43)
  BOTTOM w0.14: U64.9 225.07,33.63 v1(225.88,34.43) 225.88,34.73 225.44,35.17 R884.1
I2C_SFP+_P18_SDA: length 28.6
  T05 w0.117: CJ9.BT4 223.39,52.35 223.39,51.31 221.53,49.44 219.61,49.44 218.82,48.66 218.82,47.43 221.4,44.85 221.4,41.98 223.37,40.01 223.89,40.01 v1(224.54,39.37)
  BOTTOM w0.14: U64.8 224.42,34.4 224.51,34.49 224.51,38.07 224.71,38.27 R885.1 225.18,38.72 v1(224.54,39.37)
I2C_SFP+_P19_SCL: length 22.2
  T05 w0.117: v1(227.33,38.06) 225.72,38.06 225.3,38.48 225.3,39.69 224.54,40.45 224.54,44.72 222.63,46.62 222.63,47.5 223.45,48.32 CJ9.BB5
  BOTTOM w0.14: U64.11 226.37,33.47 227.33,34.42 v1(227.33,38.06) 227.12,38.27 R882.1
I2C_SFP+_P19_SDA: length 22.5
  T05 w0.117: CJ9.BB4 225.74,49.4 226.57,49.4 227.45,48.52 227.45,47.53 226.79,46.87 226.79,45.77 227.71,44.85 227.71,40.63 v1(225.91,38.82)
  BOTTOM w0.14: v1(225.91,38.82) 225.91,35.35 226.08,35.17 R883.1 226.56,34.72 226.56,34.72 226.56,34.28 225.72,33.45 U64.10
I2C_SFP+_P20_SCL: length 41.1
  T05 w0.117: CJ9.CT5 237.11,54.38 237.11,52.45 237.62,51.94 237.62,51.05 236.94,50.37 236.94,49.57 237.49,49.02 237.49,48.13 235.98,46.62 235.98,40.94 235.33,40.3 235.33,38.74 235.82,38.24 235.82,35.93 234.99,35.09 234.99,33.93 228.73,27.66 228.73,26.61 v1(227.46,25.34)
  BOTTOM w0.14: U64.14 226.37,25.85 226.88,25.34 v1(227.46,25.34) 227.9,24.9 227.9,21.92 R880.1
I2C_SFP+_P20_SDA: length 35.3
  T05 w0.117: CJ9.CT4 235.12,53.89 232.92,51.69 232.92,47.62 235.55,44.99 235.55,41.12 234.57,40.13 234.57,34.16 227.94,27.53 v1(227.94,26.87)
  BOTTOM w0.14: R881.1 228.75,27.68 v1(227.94,26.87) U64.13
I2C_SFP+_P21_SCL: length 40.7
  T05 w0.117: v1(225.92,25.04) 226.27,24.69 228.13,24.69 230.5,27.06 230.5,28.7 234.7,32.89 235.84,32.89 237.25,34.3 237.25,39.61 236.6,40.26 236.6,42.55 241.68,47.62 241.68,48.43 240.71,49.4 238.49,49.4 CJ9.CB5
  BOTTOM w0.14: U64.16 225.07,25.89 v1(225.92,25.04) 226.2,24.76 R878.1
I2C_SFP+_P21_SDA: length 44.1
  T05 w0.117: CJ9.CB4 238.5,51.81 238.89,52.2 240.88,52.2 241.79,51.29 241.79,49.64 243.46,47.97 243.46,45.33 242.7,44.56 242.7,34.42 237.54,29.26 v1(233.5,29.26)
  T07 w0.117: v1(227.96,28.92) 228.3,29.26 v1(233.5,29.26)
  BOTTOM w0.14: R879.1 v1(227.96,28.92) 226.78,28.92 225.72,27.86 U64.15
I2C_SFP+_P22_SCL: length 57.8
  T05 w0.117: CJ9.DT5 250.37,55.37 248.16,55.37 246.89,54.1 246.89,48.51 245.49,47.12 245.49,29.33 v1(243.95,27.8)
  T07 w0.117: v1(243.95,27.8) 240.98,24.83 232.04,24.83 231.24,25.62 228.86,25.62 228.57,25.91 224.93,25.91 v1(223.98,24.97)
  BOTTOM w0.14: U64.18 223.77,25.18 v1(223.98,24.97) 224.7,24.25 R876.1
I2C_SFP+_P22_SDA: length 61.7
  T05 w0.117: v1(244.24,26.19) 245.61,27.55 245.61,28.85 245.91,29.16 245.91,33.3 249.05,36.43 249.05,45.72 247.26,47.51 247.26,51.93 249.22,53.89 CJ9.DT4
  T18 w0.117: v1(244.24,26.19) 244.07,26.01 239.97,26.01 235.54,21.58 227.51,21.58 v1(225.8,19.87)
  BOTTOM w0.14: U64.17 224.42,25.52 225.5,24.45 225.5,22.58 225.06,22.14 225.06,20.83 225.29,20.6 R877.1 v1(225.8,19.87)
I2C_SFP+_P23_SCL: length 52.2
  T05 w0.117: v1(247.7,31.91) 250.23,34.44 250.23,46.52 251.95,48.25 CJ9.DB5
  T07 w0.117: v1(247.7,31.91) 246.88,31.91 244.01,29.04 240.82,29.04 238.6,26.82 231.51,26.82 230.4,27.92 225.16,27.92 v1(222.25,25.01)
  BOTTOM w0.14: R874.1 222.25,24.71 v1(222.25,25.01) 222.47,25.23 U64.20
I2C_SFP+_P23_SDA: length 59.3
  T05 w0.117: CJ9.DB4 252.75,50.4 253.75,49.4 254.89,49.4 255.91,48.39 255.91,47.5 253.37,44.96 253.37,41.53 252.97,41.14 252.97,31.29 250.79,29.11 v1(247.44,29.11)
  T07 w0.117: v1(223.12,25.03) 225.6,27.5 228.25,27.5 229.36,26.4 238.84,26.4 241.06,28.62 244.18,28.62 244.92,29.35 247.21,29.35 v1(247.44,29.11)
  BOTTOM w0.14: U64.19 v1(223.12,25.03) 223.12,24.96 R875.1
I2C_SFP+_P24_SCL: length 40.1
  T18 w0.117: CJ9.ET5 265.4,52.79 265.85,52.35 268.15,52.35 268.57,51.92 268.57,51.37 267.38,50.18 267.38,49.49 264.7,46.81 264.7,39.57 266.55,37.72 277.62,37.72 278.64,36.7 278.64,34.68 v1(279.33,33.99)
  BOTTOM w0.14: R912.1 v1(279.33,33.99) 279.37,33.95 U65.5
I2C_SFP+_P24_SDA: length 37.4
  T03 w0.117: CJ9.ET4 264.6,53.89 265.97,52.52 268.06,52.52 268.88,51.71 269.78,51.71 270.35,51.13 270.35,47.79 268.02,45.46 268.02,41.69 271.27,38.45 278.99,38.45 v1(279.28,38.74)
  BOTTOM w0.14: v1(279.28,38.74) 279.33,38.69 R913.1 278.86,37.82 278.65,37.62 278.65,33.67 278.72,33.6 U65.4
I2C_SFP+_P25_SCL: length 33.6
  T14 w0.117: v1(280.78,33.99) 279.97,33.18 277.23,33.18 276.75,33.66 272.28,33.66 269.92,36.03 269.92,39.59 268.6,40.91 266.11,40.91 264.68,42.33 264.68,46.84 266.2,48.36 CJ9.EB5
  BOTTOM w0.14: U65.7 280.67,33.88 280.78,33.98 v1(280.78,33.99) 280.78,34 280.71,34.07 R910.1
I2C_SFP+_P25_SDA: length 44
  T03 w0.117: CJ9.EB4 265.5,52.39 262.54,52.39 261.11,50.97 261.11,47.88 263.88,45.11 263.88,40.28 266.21,37.95 279.93,37.95 v1(280.54,38.56)
  BOTTOM w0.14: U65.6 280.02,37.58 280.26,37.82 R911.1 280.71,38.4 v1(280.54,38.56)
I2C_SFP+_P26_SCL: length 33.3
  T14 w0.117: CJ9.FT5 278.95,55.3 276.4,55.3 275.25,54.14 275.25,48.63 273.95,47.33 273.95,42.65 278.8,37.8 280.26,37.8 281.56,36.5 281.56,35.75 282.48,34.83 v1(282.48,34.01)
  BOTTOM w0.14: R908.1 282.48,34.33 v1(282.48,34.01) 282.46,33.99 282.46,33.7 281.97,33.21 U65.9
I2C_SFP+_P26_SDA: length 27.1
  T14 w0.117: v1(282.08,38.72) 279.19,41.61 279.19,44.17 275.72,47.64 275.72,51.94 277.66,53.89 CJ9.FT4
  BOTTOM w0.14: U65.8 281.32,33.41 281.42,33.51 281.42,37.6 281.65,37.82 R909.1 v1(282.08,38.72)
I2C_SFP+_P27_SCL: length 24.9
  T14 w0.117: v1(283.45,38.8) 283.45,41.01 286.25,43.8 286.25,47.97 284.89,49.32 282.66,49.32 281.79,50.19 CJ9.FB5
  BOTTOM w0.14: v1(283.45,38.8) R906.1 284,37.82 284.23,37.6 284.23,33.76 283.27,32.81 U65.11
I2C_SFP+_P27_SDA: length 28
  T14 w0.117: CJ9.FB4 282.49,50.89 283.21,51.6 284.4,51.6 288.67,47.33 288.67,39.2 v1(283.45,33.99)
  BOTTOM w0.14: U65.10 282.62,33.02 283.45,33.85 v1(283.45,33.99) R907.1
I2C_SFP_IOP0_SCL: length 191.9
  T07 w0.117: v1(205.49,15.45) 204.94,15.99 204.18,15.99 203.16,14.96 177.37,14.96 v1(172.75,19.59) 172.27,20.07 171.03,20.07 169.76,18.79 146.53,18.79 v1(145.55,19.77) 144.94,20.38 142.99,20.38 137.11,14.51 110.5,14.51 109.4,13.41 v1(109.1,13.41)
  T14 w0.117: v1(205.49,15.45) 206.31,15.45 210.24,11.51 228.94,11.51 229.48,12.05 231.59,12.05 232.38,11.26 235.69,11.26 236.46,12.03 266.98,12.03 268.72,10.29 v1(272.31,10.29)
  BOTTOM w0.14: v1(205.49,15.45) 205.32,15.62 R671.2 ; v1(272.31,10.29) 272.93,10.29 276.02,7.2 R672.2 ; v1(172.75,19.59) 172.13,20.21 R653.2 ; R654.2 v1(145.55,19.77) ; U68.10 107.16,12.36 108.21,13.41 v1(109.1,13.41) 109.28,13.23 R966.1
I2C_SFP_IOP0_SDA: length 186
  T07 w0.117: v1(204.6,15.42) 203.72,14.54 176.92,14.54 v1(171.96,19.5) 171.22,19.5 170.09,18.37 145.89,18.37 v1(144.45,19.81) 143.02,19.81 137.22,14.01 111.55,14.01 109.6,12.07 v1(109.1,12.07)
  T14 w0.117: v1(272.68,12.61) 271.51,13.78 243.18,13.78 242.02,12.62 236.6,12.62 235.8,13.42 227.99,13.42 227.59,13.02 209.73,13.02 206.66,16.09 205.27,16.09 v1(204.6,15.42)
  BOTTOM w0.14: R967.1 109.88,12.09 109.86,12.07 v1(109.1,12.07) 108.33,12.07 107.81,11.54 U68.9 ; R673.2 203.96,16.06 v1(204.6,15.42) ; v1(272.68,12.61) R677.2 ; R655.2 170.95,19.5 v1(171.96,19.5) ; R659.2 v1(144.45,19.81)
I2C_SFP_IOP1_SCL: length 157.1
  T03 w0.117: v1(130.43,18.42) 130.05,18.8 124.08,18.8 123.69,18.41 119.01,18.41 v1(116.97,20.45)
  T07 w0.117: v1(248.37,20.24) 246.05,17.92 232.72,17.92 232.33,17.53 223.26,17.53 221.72,15.99 219.84,15.99 218.98,15.13 207.68,15.13 205,17.81 198.3,17.81 197.39,18.72 188.81,18.72 v1(187.9,19.64) 187.83,19.71 182.8,19.71 181.71,20.8 140.91,20.8 139.54,19.43 131.44,19.43 v1(130.43,18.42)
  T14 w0.117: v1(116.97,20.45) 116.32,19.8 115.03,19.8 114.78,20.05 109.72,20.05 v1(108.93,19.26)
  BOTTOM w0.14: v1(187.9,19.64) 188.65,20.39 R690.2 ; R689.2 129.8,18.42 v1(130.43,18.42) ; v1(116.97,20.45) 116.92,20.5 R707.2 ; R725.2 v1(248.37,20.24) ; R964.1 108.93,19.77 v1(108.93,19.26) 108.93,19.18 107.16,17.4 U68.7
I2C_SFP_IOP1_SDA: length 154.4
  T03 w0.117: v1(115.78,20.45) 118.31,17.92 128.77,17.92 v1(129.08,18.23)
  T07 w0.117: v1(129.08,18.23) 130.86,20 137.7,20 139.09,21.4 182.02,21.4 183.14,20.27 v1(187.13,20.27) 188.42,20.27 189.46,19.23 197.72,19.23 198.5,18.44 205.21,18.44 205.83,17.82 210.45,17.82 210.76,17.51 221.45,17.51 221.89,17.96 232.15,17.96 232.54,18.34 244.99,18.34 v1(246.89,20.24)
  T14 w0.117: v1(115.78,20.45) 115.63,20.6 108.3,20.6 107.34,19.63 v1(107.34,19.35)
  BOTTOM w0.14: R691.2 128.84,18.23 v1(129.08,18.23) ; v1(187.13,20.27) 187.38,20.52 R695.2 ; R727.2 247.11,20.46 v1(246.89,20.24) ; R965.1 v1(107.34,19.35) 107.34,18.56 106.51,17.73 U68.6 ; v1(115.78,20.45) R709.2
I2C_SFP_IOP2_SCL: length 189.1
  T07 w0.117: v1(106.06,19.35) 107.01,18.41 125.47,18.41 133.49,26.43 146.22,26.43 147.97,28.18 154.11,28.18 154.48,27.81 191.07,27.81 199.39,19.48 205.59,19.48 206.26,18.82 210.86,18.82 211.33,18.35 220.88,18.35 221.43,18.9 229.97,18.9 230.58,19.51 v1(233.91,19.51) 234.05,19.36 244.05,19.36 246.78,22.09 259.86,22.09 v1(262.11,19.84)
  T14 w0.117: v1(106.06,19.35) 104.68,20.73 101.85,20.73 100.78,21.81 100.78,25.4 101.59,26.21 101.59,27.88 100.02,29.45 v1(99.24,29.45)
  BOTTOM w0.14: R726.2 233.64,19.78 v1(233.91,19.51) ; R962.1 v1(106.06,19.35) 106.06,18.69 105.86,18.48 U68.5 ; R708.2 99.89,29.45 v1(99.24,29.45) ; R743.2 v1(262.11,19.84)
I2C_SFP_IOP2_SDA: length 185.9
  T07 w0.117: v1(105.11,19.31) 106.43,17.99 125.86,17.99 133.73,25.86 146.38,25.86 147.25,26.73 181.48,26.73 182.73,25.48 192.59,25.48 199.15,18.91 205.34,18.91 206.01,18.24 210.62,18.24 210.93,17.93 221.27,17.93 221.72,18.38 231.98,18.38 v1(232.54,18.94) 244.44,18.94 247.17,21.67 259.27,21.67 v1(261.06,19.88)
  T14 w0.117: v1(99.06,28.22) 100.03,27.25 100.03,25.63 100.36,25.31 100.36,21.53 101.71,20.18 104.24,20.18 105.11,19.32 v1(105.11,19.31)
  BOTTOM w0.14: R963.1 104.79,19.62 v1(105.11,19.31) 105.21,19.21 U68.4 ; v1(232.54,18.94) 232.52,18.94 232.38,19.08 R728.2 ; R713.2 99.14,28.14 v1(99.06,28.22) ; R745.2 v1(261.06,19.88)
I2C_SFP_MUX2_ADDR0: length 6.3
  BOTTOM w0.14: U68.1 103.23,16.56 v2(101.23,18.56) R977.2 R974.1
I2C_SFP_MUX2_ADDR1: length 5.5
  BOTTOM w0.14: R973.1 R976.2 102.25,18.96 v2(102.51,18.69) 103.56,17.64 103.57,17.64 103.76,17.45 103.76,17.45 103.9,17.3 U68.2
I2C_SFP_MUX2_ADDR2: length 4.5
  BOTTOM w0.14: R975.2 R972.1 105.42,8.93 v2(105.37,8.98) 105.21,9.15 U68.13
I2C_SFP_MUX7_ADDR0: length 4
  BOTTOM w0.14: U69.1 304.16,40.19 v2(305,41.02) 305.34,41.36 R993.2 R990.1
I2C_SFP_MUX7_ADDR1: length 5.7
  BOTTOM w0.14: R989.1 R992.2 303.2,41.8 303.58,41.42 v2(303.58,41.02) 302.92,40.36 302.92,39.46 303.24,39.14 U69.2
I2C_SFP_MUX7_ADDR2: length 8.1
  BOTTOM w0.14: U69.13 299.65,37.84 299.85,38.04 299.85,40.02 298.99,40.89 v2(297.92,40.89) 297.85,40.95 R991.2 R988.1
I2C_SFP_MUX_SCL: length 250.4
  T07 w0.117: v1(293.24,37.74) 291.21,37.74 285.01,31.54 285.01,29.13 278.62,22.74 v1(278.62,22.28) 278.28,21.95 278.28,20.88 277.86,20.46 275.97,20.46 275.28,21.16 272.49,21.16 270.74,22.9 264.99,22.9 262.42,25.48 249.33,25.48 245,21.15 220.87,21.15 v1(219.53,19.82)
  T14 w0.117: v1(86.97,19.98) 88.59,18.37 88.59,9.46 89.51,8.53 95.83,8.53 97.11,9.81 102.58,9.81 103.88,8.51 v1(106.7,8.51) 107.08,8.51 109.98,11.41 109.98,12.12 111.97,14.11 115.5,14.11 116.3,14.91 151.43,14.91 156.9,20.38 158.31,20.38 v1(158.83,19.87)
  T16 w0.117: v1(219.53,19.82) 218.84,20.51 216.14,20.51 213.8,18.16 212.47,18.16 208.79,14.48 190.63,14.48 186.76,18.35 160.34,18.35 v1(158.83,19.87)
  BOTTOM w0.14: R918.2 v1(278.62,22.28) ; R968.1 106.7,7.79 v1(106.7,8.51) 106.7,8.87 105.86,9.71 U68.12 ; v1(86.97,19.98) 87.36,20.36 R846.2 ; v1(219.53,19.82) 218.93,20.42 R894.2 ; R870.2 158.29,20.4 v1(158.83,19.87) ; R987.2 v1(293.24,37.74)
I2C_SFP_MUX_SDA: length 255.5
  T07 w0.117: v1(218.24,19.89) 218.24,23.01 218.77,23.54 226.96,23.54 228.5,22.01 235.88,22.01 236.96,23.09 242.19,23.09 242.74,22.54 245.56,22.54 249.07,26.05 262.66,26.05 265.23,23.48 271.11,23.48 271.88,22.7 275.45,22.7 275.97,22.18 v1(277.24,22.18) 284.44,29.37 284.44,31.9 291.29,38.76 v1(291.62,38.76)
  T14 w0.117: v1(85.6,19.98) 88.01,17.57 88.01,9.22 89.27,7.96 96.07,7.96 97.35,9.24 102.39,9.24 103.74,7.89 107.34,7.89 v1(107.95,8.51) 110.56,11.12 110.56,11.88 112.21,13.53 115.74,13.53 116.54,14.33 151.67,14.33 157.1,19.76 v1(157.79,19.76)
  T16 w0.117: v1(157.79,19.76) 159.77,17.78 185.99,17.78 191.06,12.7 202.69,12.7 203.9,13.9 209.03,13.9 212.71,17.59 214.03,17.59 216.34,19.89 v1(218.24,19.89)
  BOTTOM w0.14: R986.2 v1(291.62,38.76) ; R969.1 107.95,7.79 v1(107.95,8.51) 106.51,9.96 U68.11 ; R892.2 217.55,20.13 217.79,19.89 v1(218.24,19.89) ; R866.2 156.92,20.63 v1(157.79,19.76) ; R843.2 86.11,20.49 v1(85.6,19.98) ; R915.2 v1(277.24,22.18)
I2C_SKUID_SCL: length 252.7
  TOP w0.14: U76.10 140.9,179.84 141.22,179.52 v1(141.22,178.31)
  T16 w0.117: v1(141.22,178.31) 158.04,178.31 167.16,187.43 198.4,187.43 202.06,183.77 258.77,183.77 262.96,179.58 302.12,179.58 308.26,173.43 308.26,143.4 v1(306.38,141.52)
  T18 w0.117: v1(141.22,178.31) 141.22,180.34 140.1,181.46 140.1,182.95 139.59,183.46 114.15,183.46 113.52,182.83 111.59,182.83 v1(110.24,181.48)
  BOTTOM w0.14: v1(141.22,178.31) 141.35,178.44 141.35,180.15 R1992.1 ; PR337.1 306,141.14 v1(306.38,141.52) ; R1873.2 v1(110.24,181.48)
I2C_SKUID_SDA: length 252.9
  TOP w0.14: v1(142.38,178.92) 141.55,179.75 U76.9
  T16 w0.117: v1(142.38,178.92) 158.13,178.92 167.06,187.85 198.57,187.85 202.23,184.19 259.11,184.19 263.3,180 302.29,180 308.68,173.61 308.68,142.95 306.58,140.84 305.56,140.84 v1(305.05,141.35)
  T18 w0.117: v1(142.38,178.92) 142.42,178.88 142.42,178.31 141.77,177.66 140.61,177.66 139.89,178.38 139.89,179.82 138.13,181.58 122.43,181.58 121.97,182.04 112.8,182.04 v1(111.38,180.63)
  BOTTOM w0.14: v1(142.38,178.92) 142.38,180.15 R1993.1 ; v1(305.05,141.35) 305.03,141.38 PR338.1 ; R1874.2 v1(111.38,180.63)
I2C_SMU_EEPROM_SCL: length 32.4
  TOP w0.14: R1690.1 v1(9.12,72.59) 9.12,73.64 9.81,74.32 U140.6 ; U139.B11 v4(24.43,87.3)
  T18 w0.117: v4(24.43,87.3) 23.91,87.82 22.23,87.82 21.97,87.57 21.97,85.98 21.59,85.6 13.97,85.6 12.45,84.07 12.45,77.98 9.12,74.66 v1(9.12,72.59)
I2C_SMU_EEPROM_SDA: length 27.5
  TOP w0.14: R1689.1 v1(10.41,72.59) 11.14,73.32 U140.5 ; U139.C11 v4(23.43,87.3)
  T18 w0.117: v1(10.41,72.59) 10.41,75.06 13.08,77.72 13.08,83.69 14.35,84.96 22.23,84.96 22.99,85.72 22.99,86.86 v4(23.43,87.3)
I2C_SMU_SCL: length 12.3
  TOP w0.14: U139.D10 v4(22.43,88.3)
  BOTTOM w0.14: v4(22.43,88.3) 22.95,87.79 22.95,86.1 23.83,85.22 27.94,85.22 v2(28.19,85.47) 28.25,85.53 R1652.1 R1675.2
I2C_SMU_SDA: length 13.5
  TOP w0.14: R1676.2 30.58,86.03 30.58,86.03 R1655.1 29.73,86.61 v1(29.46,86.35) ; U139.C5 v4(23.43,94.3)
  T05 w0.117: v4(23.43,94.3) 26.55,91.18 26.55,90.37 29.46,87.45 v1(29.46,86.35)
I2C_TSEN1_ADDR0: length 20.9
  T03 w0.117: v1(119.13,105.15) 119.98,104.29 119.98,100.67 121.2,99.45 123.22,99.45 124.04,98.63 128.95,98.63 v4(130.21,97.36)
  BOTTOM w0.14: U74.7 129.42,98.15 v4(130.21,97.36) ; R1033.2 R1029.1 118.53,105.76 119.13,105.16 v1(119.13,105.15)
I2C_TSEN1_ADDR1: length 18.4
  T03 w0.117: v1(119.13,103.67) 119.46,103.34 119.46,100.58 121.02,99.02 122.91,99.02 123.73,98.2 128.37,98.2 v4(129.21,97.36)
  BOTTOM w0.14: R1083.1 R1084.2 118.98,103.83 v1(119.13,103.67) ; U74.6 128.77,97.8 v4(129.21,97.36)
I2C_TSEN1_ADDR2: length 15.9
  BOTTOM w0.14: U74.5 128.12,98.27 127.26,97.41 125.75,97.41 125.37,97.79 121.47,97.79 120.63,98.63 120.63,100.79 v2(119.3,102.13) 118.43,102.13 118.19,101.89 R1034.2 R1030.1
I2C_TSEN2_ADDR0: length 6.8
  BOTTOM w0.14: R13018.1 R13016.2 70.59,126.57 70.71,126.44 v2(70.71,125.81) 70.71,125.45 71.5,124.66 71.5,123.57 72.08,122.99 U185.7
I2C_TSEN2_ADDR1: length 6.1
  BOTTOM w0.14: R13021.1 R13020.2 73.52,126.73 v2(72.71,125.93) 72.71,125.29 72.01,124.59 72.01,123.95 72.32,123.64 U185.6
I2C_TSEN2_ADDR2: length 5.8
  BOTTOM w0.14: R13015.2 R13017.1 75.9,125.69 v2(75.31,125.09) 74.51,124.29 U185.5
I2C_TSEN_SCL: length 2.1
  TOP w0.14: R1043.2 v1(225.07,175.34) 225.69,174.71 U75.8
I2C_TSEN_SDA: length 3.2
  TOP w0.14: U75.7 226.34,173.82 226.52,174 v1(226.52,175.14) 226.52,175.27 226.16,175.63 R1044.2
IN_SEL0: length 3.5
  TOP w0.14: U135.3 152.23,131.86 v1(152.13,131.96)
  BOTTOM w0.14: R1779.2 R1777.1 152.73,132.56 v1(152.13,131.96)
IN_SEL1: length 4.3
  TOP w0.14: R1776.1 157.52,136.14 v5(157.52,135.31) 157.58,135.26 U135.37
  BOTTOM w0.14: R1778.2 157.45,135.24 v5(157.52,135.31)
INT1_GNSS_N: length 162.1
  TOP w0.14: U70.F1 110.31,128.55 109.02,128.55 v4(108.43,127.95)
  T03 w0.117: v1(14.86,31.24) 16.92,33.3 16.92,52.78 29.08,64.94 29.08,66.67 31.35,68.94 49.5,68.94 54.78,74.22 61.62,74.22 64.83,77.43 64.83,87.84 66.65,89.66 73.2,89.66 76.2,92.65 78.09,92.65 86.23,100.8 86.23,102.84 90.74,107.35 90.74,114.57 102.92,126.75 104.5,126.75 104.5,126.74 104.97,126.74 104.97,126.75 105.66,126.75 106.05,127.13 107.6,127.13 v4(108.43,127.95)
  BOTTOM w0.14: v1(14.86,31.24) 15.19,31.57 R1731.2 R1609.2
INT_ALRM0_N: length 3.2
  TOP w0.14: R1884.2 107.42,185.36 v5(107.56,185.22) 107.16,184.83 U150.8
INT_ALRM1_N: length 3.1
  TOP w0.14: U150.9 106.51,184.98 v5(106.27,185.22) 106.15,185.34 R1883.2
INT_ALRM2_N: length 3.4
  TOP w0.14: R1882.2 v5(104.88,185.24) 105.86,184.25 U150.10
INT_ALRM3_N: length 4
  TOP w0.14: R1881.2 v5(103.6,185.1) 103.6,184.92 103.87,184.66 104.52,184.66 105.21,183.97 U150.11
INT_BITS_N: length 81.8
  TOP w0.14: U70.J13 v4(120.4,125.65) ; U127.39 78.67,86.6 v1(78.36,86.29) ; U162.18 v1(84.94,84.45)
  T07 w0.117: v1(84.63,95.15) 84.63,95.59 90.39,101.35 94.44,101.35 94.73,101.63 99.78,101.63 105.43,107.28 105.43,111.19 107.7,113.46 112.32,113.46 114.05,115.19 117.35,115.19 122.07,119.91 122.07,124.39 120.81,125.65 v4(120.4,125.65)
  T14 w0.117: v1(84.94,84.45) 83.99,85.4 79.25,85.4 v1(78.36,86.29) 77.73,86.92 77.73,88.25 v1(84.63,95.15)
  BOTTOM w0.14: R1613.2 v1(78.36,86.29)
