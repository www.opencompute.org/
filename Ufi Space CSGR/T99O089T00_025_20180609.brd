# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAC_DDRC_A03: length 78.9
  TOP w0.14: U6.N7 v4(260.5,124.26) ; v4(260.5,135.93) U7.N7 260.1,134.98 260.54,134.54 265.75,134.54 R169.1 ; U1.AM4 v4(229.86,133.5)
  T14 w0.117: v4(229.86,133.5) 230.27,133.09 231.39,133.09 231.87,133.57 237.25,133.57 238.29,132.53 238.29,129.1 241.02,126.37 241.81,126.37 241.93,126.25 241.93,125.47 242.05,125.35 242.28,125.35 242.4,125.47 242.4,126.25 242.52,126.37 242.95,126.37 243.09,126.23 243.09,124.3 243.21,124.19 243.45,124.19 243.56,124.3 243.56,126.25 243.68,126.37 243.89,126.37 244.03,126.23 244.03,124.61 244.15,124.49 244.37,124.49 244.5,124.62 244.5,126.25 244.61,126.37 244.82,126.37 244.94,126.25 244.94,125.29 245.06,125.18 245.29,125.18 245.41,125.29 245.41,126.25 245.52,126.37 245.76,126.37 245.87,126.25 245.87,125.29 245.99,125.18 246.22,125.18 246.34,125.29 246.34,126.25 246.46,126.37 246.69,126.37 246.81,126.25 246.81,125.29 246.93,125.18 247.16,125.18 247.28,125.29 247.28,126.25 247.39,126.37 247.63,126.37 247.74,126.25 247.74,125.29 247.86,125.18 248.09,125.18 248.21,125.29 248.21,126.25 248.33,126.37 248.56,126.37 248.68,126.25 248.68,125.29 248.79,125.18 249.03,125.18 249.15,125.29 249.15,126.25 249.26,126.37 256.17,126.37 256.35,126.19 256.64,126.19 256.81,126.37 258.29,126.37 258.5,126.16 258.5,125.65 258.69,125.46 259.07,125.46 259.13,125.41 259.13,125.41 259.3,125.24 259.3,124.9 259.54,124.66 260.1,124.66 v4(260.5,124.26)
  T16 w0.117: v4(260.5,124.26) 260.9,124.66 260.9,126.1 260.55,126.45 260.55,129.22 260.9,129.57 260.9,133.68 260.79,133.79 260.72,133.79 260.6,133.91 260.6,134.14 260.72,134.26 260.79,134.26 260.9,134.38 260.9,134.61 260.79,134.73 260.72,134.73 260.6,134.85 260.6,135.08 260.72,135.2 260.79,135.2 260.9,135.31 260.9,135.53 v4(260.5,135.93)
MAC_DDRC_A04: length 82.4
  TOP w0.14: R175.1 263.43,132.99 260.46,132.99 260.1,132.64 U7.N3 v4(260.5,131.93) ; U1.AL7 v4(226.86,132.5) ; U6.N3 v4(260.5,120.26)
  T07 w0.117: v4(226.86,132.5) 227.37,131.99 229.14,131.99 229.38,131.75 229.38,131.26 229.58,131.06 231.42,131.06 231.54,131.17 231.54,131.41 231.66,131.53 231.89,131.53 232.01,131.41 232.01,131.17 232.12,131.06 233.01,131.06 233.34,130.72 233.34,130.25 233.72,129.88 237.61,129.88 239.74,127.76 239.94,127.76 239.95,127.75 240.61,127.75 240.62,127.76 240.88,127.76 241,127.87 241,128.08 241.11,128.2 241.35,128.2 241.46,128.08 241.46,127.87 241.58,127.76 243.01,127.76 243.33,127.43 243.33,127.27 242.81,126.75 242.81,126.59 242.98,126.42 243.14,126.42 243.66,126.94 243.82,126.94 243.99,126.77 243.99,126.61 243.47,126.09 243.47,125.92 243.64,125.76 243.8,125.76 244.32,126.28 244.49,126.28 244.65,126.11 244.65,125.95 244.13,125.43 244.13,125.26 244.3,125.1 244.46,125.1 244.98,125.61 245.15,125.61 245.31,125.45 245.31,125.28 244.8,124.77 244.8,124.6 244.96,124.44 245.13,124.44 245.64,124.95 245.81,124.95 245.97,124.79 245.97,124.62 245.46,124.11 245.46,123.94 245.62,123.77 245.79,123.77 246.3,124.29 246.47,124.29 246.64,124.13 246.64,123.96 246.12,123.44 246.12,123.28 246.28,123.11 246.45,123.11 246.97,123.63 247.13,123.63 247.3,123.46 247.3,123.3 246.78,122.78 246.78,122.62 246.95,122.45 247.11,122.45 247.63,122.97 247.79,122.97 247.96,122.8 247.96,122.64 247.44,122.12 247.44,121.96 247.61,121.79 247.77,121.79 248.29,122.31 248.45,122.31 248.62,122.14 248.62,121.98 248.1,121.46 248.1,121.29 248.27,121.13 248.43,121.13 248.95,121.65 249.12,121.65 249.28,121.48 249.28,121.32 248.76,120.8 248.76,120.63 248.93,120.47 249.09,120.47 249.39,120.77 249.87,120.77 249.98,120.88 249.98,121.2 250.1,121.32 250.33,121.32 250.45,121.2 250.45,120.88 250.57,120.77 250.8,120.77 250.92,120.88 250.92,121.2 251.04,121.32 251.27,121.32 251.39,121.2 251.39,120.88 251.5,120.77 251.74,120.77 251.85,120.88 251.85,121.2 251.97,121.32 252.2,121.32 252.32,121.2 252.32,120.88 252.44,120.77 252.67,120.77 252.79,120.88 252.79,121.2 252.91,121.32 253.14,121.32 253.26,121.2 253.26,120.88 253.37,120.77 253.61,120.77 253.72,120.88 253.72,121.2 253.84,121.32 254.07,121.32 254.19,121.2 254.19,120.88 254.31,120.77 260,120.77 v4(260.5,120.26)
  T16 w0.117: v4(260.5,131.93) 260.1,131.53 260.1,130.16 260.02,130.08 260.02,126.11 260.1,126.03 U6.N3 v4(260.5,120.26)
MAC_DDRC_A05: length 75.3
  TOP w0.14: v4(261.3,125.06) U6.P8 ; v4(261.3,136.73) U7.P8 ; U1.AN3 v4(230.86,134.5)
  T14 w0.117: v4(230.86,134.5) 231.36,134.99 233.89,134.99 234,134.88 234,134.74 234.12,134.63 234.35,134.63 234.47,134.74 234.47,134.88 234.59,134.99 234.82,134.99 234.94,134.88 234.94,134.74 235.06,134.63 235.29,134.63 235.41,134.74 235.41,134.88 235.52,134.99 235.76,134.99 235.87,134.88 235.87,134.74 235.99,134.63 236.22,134.63 236.34,134.74 236.34,134.88 236.46,134.99 237.31,134.99 239.33,132.97 239.33,129.63 240.36,128.61 240.97,128.61 241.09,128.49 241.09,127.83 241.21,127.72 241.44,127.72 241.56,127.83 241.56,128.49 241.67,128.61 242.04,128.61 242.16,128.49 242.16,127.55 242.27,127.44 242.51,127.44 242.63,127.55 242.63,128.49 242.74,128.61 242.98,128.61 243.09,128.49 243.09,127.55 243.21,127.44 243.44,127.44 243.56,127.55 243.56,128.49 243.68,128.61 243.91,128.61 244.03,128.49 244.03,127.55 244.14,127.44 244.38,127.44 244.49,127.55 244.49,128.49 244.61,128.61 244.85,128.61 244.96,128.49 244.96,127.55 245.08,127.44 245.31,127.44 245.43,127.55 245.43,128.49 245.55,128.61 245.78,128.61 245.9,128.49 245.9,127.55 246.01,127.44 246.25,127.44 246.36,127.55 246.36,128.49 246.48,128.61 246.71,128.61 246.83,128.49 246.83,127.55 246.95,127.44 247.18,127.44 247.3,127.55 247.3,128.49 247.42,128.61 247.62,128.61 247.74,128.72 247.74,128.82 247.85,128.94 248.09,128.94 248.2,128.82 248.2,128.72 248.32,128.61 248.56,128.61 248.67,128.72 248.67,128.82 248.79,128.94 249.02,128.94 249.14,128.82 249.14,128.72 249.26,128.61 249.49,128.61 249.61,128.72 249.61,128.82 249.72,128.94 249.96,128.94 250.07,128.82 250.07,128.72 250.19,128.61 250.42,128.61 250.54,128.72 250.54,128.82 250.66,128.94 250.89,128.94 251.01,128.82 251.01,128.72 251.13,128.61 251.36,128.61 251.48,128.72 251.48,128.82 251.59,128.94 251.83,128.94 251.94,128.82 251.94,128.72 252.06,128.61 252.7,128.61 253.3,129.2 258.23,129.2 259.54,127.89 259.54,126.85 260.1,126.29 260.1,125.7 260.34,125.46 260.68,125.46 261.08,125.06 v4(261.3,125.06)
  T18 w0.117: v4(261.3,125.06) 260.9,125.46 260.9,126.1 260.62,126.38 260.62,126.95 260.63,126.95 260.63,129.89 260.9,130.16 260.9,134.82 261.03,134.95 261.03,135.28 260.9,135.42 260.9,136.21 261.3,136.61 v4(261.3,136.73)
  BOTTOM w0.102: v4(261.3,136.73) 261.71,136.32 262.47,136.32
  BOTTOM w0.14: 262.47,136.32 262.74,136.59 264.74,136.59 265.18,137.03 265.18,137.35 R176.1
MAC_DDRC_A06: length 89.1
  TOP w0.14: v4(261.3,131.13) U7.P2 ; v4(261.3,119.46) U6.P2 ; U1.AH9 v4(224.86,129.5)
  T05 w0.117: v4(261.3,131.13) 260.9,130.73 260.9,129.31 261.02,129.2 261.58,129.2 261.69,129.08 261.69,128.85 261.58,128.73 261.02,128.73 260.9,128.61 260.9,128.27 260.9,128.27 260.9,128.21 260.54,127.85 260.54,126.39 260.9,126.03 U6.P2 v4(261.3,119.46)
  T07 w0.117: v4(224.86,129.5) 225.37,128.99 225.37,127.22 225.58,127.01 229.02,127.01 229.35,126.68 229.35,126.21 229.55,126.01 233.12,126.01 233.45,125.68 233.45,120.93 234.01,120.38 234.01,118.3 234.13,118.18 234.51,118.18 234.63,118.3 234.63,119.19 234.77,119.33 234.98,119.33 235.1,119.22 235.1,118.34 235.21,118.23 235.45,118.23 235.56,118.34 235.56,119.19 235.71,119.33 235.91,119.33 236.03,119.22 236.03,118.35 236.19,118.2 236.53,118.2 236.64,118.31 236.64,118.98 236.76,119.1 236.99,119.1 237.11,118.98 237.11,118.31 237.23,118.2 237.59,118.2 237.71,118.31 237.71,118.84 237.83,118.96 238.06,118.96 238.18,118.84 238.18,118.35 238.36,118.16 238.53,118.16 238.64,118.28 238.64,119.01 238.79,119.16 238.99,119.16 239.11,119.04 239.11,118.25 239.23,118.13 240.09,118.13 240.2,118.25 240.2,120.67 240.35,120.81 240.58,120.81 240.7,120.69 240.7,119.15 240.81,119.03 241.09,119.03 241.21,119.15 241.21,121 241.33,121.11 241.56,121.11 241.68,121 241.68,119.15 241.8,119.03 242.19,119.03 242.31,119.15 242.31,119.66 242.43,119.78 242.66,119.78 242.78,119.66 242.78,119.15 242.89,119.03 243.68,119.03 244.02,118.69 244.02,118.53 243.99,118.49 243.99,118.33 244.15,118.16 244.32,118.16 244.35,118.2 244.52,118.2 244.68,118.03 244.68,117.87 244.65,117.83 244.65,117.67 244.81,117.5 244.98,117.5 245.01,117.54 245.18,117.54 245.73,116.98 259.66,116.98 260.9,118.23 260.9,119.06 v4(261.3,119.46)
  BOTTOM w0.102: 263.53,130.72 261.94,130.72 261.54,131.13 v4(261.3,131.13)
  BOTTOM w0.14: R170.1 264.36,129.16 264.36,129.89 263.53,130.72
MAC_DDRC_A07: length 78.7
  TOP w0.14: R171.1 266,139.54 265.86,139.68 262.34,139.68 262.2,139.54 262.2,138.4 262.39,138.21 263.18,138.21 263.32,138.07 263.32,136.85 263.18,136.71 262.15,136.71 v4(262.12,136.74) U7.R8 ; U1.AT3 v4(230.86,137.5) ; v4(262.1,125.06) U6.R8
  T14 w0.117: v4(230.86,137.5) 231,137.5 231.41,137.09 233.47,137.09 233.59,136.97 233.59,136.27 233.7,136.15 233.94,136.15 234.08,136.29 234.08,137.53 234.2,137.65 234.43,137.65 234.55,137.53 234.55,136.27 234.66,136.15 234.87,136.15 235.01,136.29 235.01,137.53 235.13,137.65 235.36,137.65 235.48,137.53 235.48,136.27 235.6,136.15 235.81,136.15 235.92,136.27 235.92,136.97 236.04,137.09 236.7,137.09 240.26,133.53 240.26,133.52 241.54,132.24 247.52,132.24 247.64,132.12 247.64,131.34 247.76,131.22 247.99,131.22 248.11,131.34 248.11,132.12 248.22,132.24 248.46,132.24 248.57,132.12 248.57,131.34 248.69,131.22 248.93,131.22 249.04,131.34 249.04,132.12 249.16,132.24 249.33,132.24 249.68,132.59 253.75,132.59 254.35,133.2 256.16,133.2 256.64,132.72 260.28,132.72 260.9,132.09 260.9,130.01 261.13,129.78 261.13,129.61 260.95,129.44 260.95,129.27 261.12,129.1 261.28,129.1 261.46,129.28 261.63,129.28 261.98,128.93 261.98,128.73 261.87,128.61 261,128.61 260.88,128.49 260.88,128.26 261,128.14 261.87,128.14 261.98,128.03 261.98,127.79 261.87,127.67 261.76,127.67 261.64,127.56 261.64,127.32 261.76,127.21 261.87,127.21 261.98,127.09 261.98,126.31 261.7,126.03 261.7,125.7 262.1,125.3 v4(262.1,125.06)
  T18 w0.117: v4(262.12,136.74) 262.5,136.36 262.5,135.36 262.33,135.18 262.33,134.89 262.5,134.72 262.5,134.42 262.33,134.25 262.33,133.96 262.5,133.78 262.5,130.16 262.51,130.16 262.51,126.03 262.5,126.03 262.5,125.46 v4(262.1,125.06)
MAC_DDRC_A08: length 86.9
  TOP w0.14: U1.AG9 v4(224.86,128.5) ; v4(262.1,119.46) U6.R2 ; v4(262.1,131.13) U7.R2
  T05 w0.117: v4(262.1,131.13) 262.5,130.73 262.5,130.16 262.84,129.83 263.48,129.83 263.6,129.71 263.6,129.42 263.72,129.3 264.02,129.3 264.13,129.18 264.13,128.95 264.02,128.83 263.72,128.83 263.6,128.72 263.6,127.13 262.5,126.03 262.5,119.86 v4(262.1,119.46)
  T14 w0.117: v4(262.1,119.46) 261.7,119.06 261.7,118.12 260.98,117.4 253.46,117.4 253.45,117.41 250.66,117.41 250.04,117.41 249.65,117.41 246.59,117.41 246.58,117.42 241.64,117.42 241.53,117.54 241.53,120.11 241.41,120.22 241.18,120.22 241.06,120.11 241.06,117.54 240.94,117.42 240.57,117.42 240.46,117.54 240.46,121.12 240.34,121.24 240.11,121.24 239.99,121.12 239.99,119.2 239.87,119.09 236.76,119.09 236.65,119.2 236.65,120.13 236.53,120.25 236.3,120.25 236.18,120.13 236.18,119.2 236.06,119.09 235.71,119.09 235.25,119.54 235.25,120.51 235.37,120.63 236.48,120.63 236.6,120.75 236.6,120.98 236.43,121.15 234.81,121.15 234.69,121.27 234.69,121.5 234.81,121.62 236.48,121.62 236.6,121.73 236.6,121.92 236.48,122.03 235.37,122.03 235.25,122.15 235.25,124.26 234.49,125.02 230.84,125.02 230.83,125.02 226.67,125.02 226.26,125.42 226.26,125.66 226.03,125.9 225.88,125.9 225.41,126.36 225.41,127.65 224.86,128.2 v4(224.86,128.5)
  BOTTOM w0.102: v4(262.1,131.13) 262.5,131.52 263.44,131.52
  BOTTOM w0.14: R172.1 264.9,129.58 264.9,130.06 263.44,131.52
MAC_DDRC_A09: length 77.7
  TOP w0.14: v4(262.1,135.93) U7.R7 261.7,135.36 261.92,135.15 264.09,135.15 265.18,136.23 R173.1 ; v4(262.1,124.26) U6.R7 ; U1.AR5 v4(228.86,136.5)
  T07 w0.117: v4(262.1,124.26) 260.71,122.87 256.67,122.87 256.55,122.98 256.55,123.51 256.43,123.63 256.2,123.63 256.08,123.51 256.08,122.98 255.97,122.87 255.73,122.87 255.62,122.98 255.62,123.51 255.5,123.63 255.27,123.63 255.15,123.51 255.15,122.98 255.03,122.87 254.8,122.87 254.68,122.98 254.68,123.51 254.56,123.63 254.33,123.63 254.21,123.51 254.21,122.98 254.1,122.87 253.86,122.87 253.75,122.98 253.75,123.51 253.63,123.63 253.4,123.63 253.28,123.51 253.28,122.98 253.16,122.87 252.93,122.87 252.81,122.98 252.81,123.51 252.69,123.63 252.46,123.63 252.34,123.51 252.34,122.98 252.23,122.87 251.99,122.87 251.88,122.98 251.88,123.51 251.76,123.63 251.53,123.63 251.41,123.51 251.41,122.98 251.29,122.87 251.06,122.87 250.94,122.98 250.94,123.51 250.83,123.63 250.59,123.63 250.47,123.51 250.47,122.98 250.36,122.87 250.17,122.87 249.45,123.58 249.45,125.48 245.88,129.05 245.88,130.1 245.76,130.22 242.89,130.22 242.77,130.33 242.77,130.57 242.89,130.68 245.76,130.68 245.88,130.8 245.88,131.06 245.77,131.18 241.86,131.18 241.71,131.32 241.71,131.49 242.09,131.87 242.09,132.03 241.92,132.2 241.76,132.2 241.38,131.82 241.22,131.82 240.01,133.03 233.28,133.03 232.82,133.48 231.61,133.48 231.1,133.99 229.67,133.99 229.3,134.37 229.3,136.06 v4(228.86,136.5)
  T16 w0.117: v4(262.1,124.26) 262.5,124.66 262.5,126.03 262.66,126.19 262.66,130.01 262.5,130.16 262.5,135.53 v4(262.1,135.93)
MAC_DDRC_A10: length 78.3
  TOP w0.14: R177.1 264.08,133.31 259.95,133.31 259.3,132.67 U7.M3 v4(259.7,131.93) ; U6.M3 v4(259.7,120.26) ; U1.AT5 v4(228.86,137.5)
  T07 w0.117: v4(259.7,120.26) 259.3,119.86 248.79,119.86 243.46,125.2 242.64,125.2 242.53,125.32 242.53,125.95 242.41,126.07 242.18,126.07 242.06,125.95 242.06,125.32 241.94,125.2 241.22,125.2 240.98,125.44 240.98,125.61 242.26,126.89 242.26,127.06 242.1,127.22 241.93,127.22 240.67,125.96 240.46,125.96 240.29,126.13 240.29,126.29 240.89,126.89 240.89,127.06 240.72,127.22 240.56,127.22 239.96,126.62 239.79,126.62 237.08,129.34 236.8,129.34 236.68,129.23 236.68,128.9 236.57,128.78 236.33,128.78 236.22,128.9 236.22,129.23 236.1,129.34 235.87,129.34 235.75,129.23 235.75,128.9 235.63,128.78 235.4,128.78 235.28,128.9 235.28,129.23 235.16,129.34 234.93,129.34 234.81,129.23 234.81,128.9 234.7,128.78 234.46,128.78 234.35,128.9 234.35,129.23 234.23,129.34 233.73,129.34 233.02,130.05 229.58,130.05 229.36,130.27 229.36,130.65 229.04,130.98 226.7,130.98 226.45,131.22 226.45,133.66 226.8,134.01 226.95,134.01 227.38,134.45 227.38,134.6 227.74,134.95 227.88,134.95 228.35,135.41 228.35,137.38 228.47,137.5 v4(228.86,137.5)
  T18 w0.117: v4(259.7,120.26) 260.1,120.66 260.1,125.23 259.87,125.46 259.54,125.46 259.3,125.7 259.3,126.47 259.49,126.65 259.49,129.98 259.3,130.16 259.3,131.53 v4(259.7,131.93)
MAC_DDRC_A11: length 92.7
  TOP w0.14: U6.T2 v4(262.9,119.46) ; U7.T2 v4(262.9,131.13) 263.78,130.25 263.78,129.38 263.92,129.24 264.2,129.24 264.34,129.1 264.34,128.82 264.2,128.68 263.92,128.68 263.78,128.54 263.78,127.47 263.97,127.28 264.45,127.28 264.59,127.42 264.59,128.28 264.73,128.42 265.01,128.42 265.15,128.28 265.15,127.66 265.29,127.52 R178.1 ; U1.AE9 v4(224.86,126.5)
  T14 w0.117: v4(262.9,119.46) 262.5,119.06 262.5,117.91 261.48,116.88 253.24,116.88 253.24,116.88 252.66,116.88 252.66,116.88 252.23,116.88 252.23,116.88 251.65,116.88 251.65,116.88 251.21,116.88 251.21,116.88 250.63,116.88 250.63,116.88 250.45,116.88 250.45,116.88 249.87,116.88 249.87,116.88 246.38,116.88 246.36,116.9 239.84,116.9 239.72,117.01 239.72,118.41 239.61,118.52 239.42,118.52 239.3,118.41 239.3,117.48 239.19,117.36 238.95,117.36 238.84,117.48 238.84,118.36 238.67,118.52 238.49,118.52 238.37,118.41 238.37,117.48 238.25,117.36 238.02,117.36 237.9,117.48 237.9,118.36 237.74,118.52 237.55,118.52 237.43,118.41 237.43,117.48 237.32,117.36 237.07,117.36 236.95,117.48 236.95,118.31 236.79,118.47 236.6,118.47 236.48,118.35 236.48,117.48 236.37,117.36 236.13,117.36 236.02,117.48 236.02,118.31 235.85,118.47 235.62,118.47 235.5,118.35 235.5,117.51 235.38,117.39 234.96,117.39 234.82,117.53 234.82,117.82 234.7,117.94 233.52,117.94 233.4,118.06 233.4,118.29 233.52,118.41 234.64,118.41 234.82,118.59 234.82,118.82 234.69,118.95 233.64,118.95 233.52,119.07 233.52,119.3 233.64,119.42 234.7,119.42 234.82,119.54 234.82,119.76 234.7,119.87 234.2,119.87 234.09,119.99 234.09,121.11 233.97,121.23 233.52,121.23 233.4,121.34 233.4,122.05 233.52,122.16 233.89,122.16 234.01,122.28 234.01,122.51 233.89,122.63 233.52,122.63 233.4,122.75 233.4,122.98 233.52,123.1 233.89,123.1 234.01,123.21 234.01,123.85 233.89,123.97 224.47,123.97 224.35,124.09 224.35,124.36 224.24,124.48 223.62,124.48 223.5,124.59 223.5,124.83 223.62,124.94 224.24,124.94 224.35,125.06 224.35,126.38 224.47,126.5 v4(224.86,126.5)
  T16 w0.117: v4(262.9,131.13) 263.32,130.71 263.32,129.7 263.44,129.59 263.71,129.59 263.83,129.47 263.83,129.23 263.71,129.12 263.44,129.12 263.32,129 263.32,128.77 263.44,128.65 263.66,128.65 263.78,128.53 263.78,128.3 263.66,128.18 263.44,128.18 263.32,128.06 263.32,127.83 263.44,127.72 263.64,127.72 263.75,127.6 263.75,127.37 263.64,127.25 263.44,127.25 263.32,127.13 263.32,119.88 v4(262.9,119.46)
MAC_DDRC_A12: length 80.5
  TOP w0.14: v4(259.7,135.93) U7.M7 259.3,135.09 260.15,134.25 265.08,134.25 R180.1 ; U6.M7 v4(259.7,124.26) ; U1.AP4 v4(229.86,135.5)
  T07 w0.117: v4(259.7,124.26) U6.M7 258.74,123.86 258.5,124.1 258.5,124.43 258.27,124.66 257.94,124.66 257.7,124.9 257.7,125.23 257.47,125.46 257.14,125.46 256.18,126.42 249.25,126.42 246.4,129.27 246.4,131.76 246.29,131.87 242.96,131.87 242.85,131.99 242.85,132.22 242.96,132.34 246.29,132.34 246.4,132.46 246.4,132.71 246.29,132.82 241.11,132.82 240.99,132.94 240.99,133.17 241.11,133.29 246.29,133.29 246.4,133.41 246.4,133.69 246.26,133.83 245.92,133.83 245.8,133.94 245.8,134.56 245.68,134.68 245.45,134.68 245.33,134.56 245.33,133.94 245.22,133.83 240,133.83 239.88,133.71 239.88,133.68 239.77,133.56 239.53,133.56 239.42,133.68 239.42,133.71 239.3,133.83 239.07,133.83 238.95,133.71 238.95,133.68 238.83,133.56 238.6,133.56 238.48,133.68 238.48,133.71 238.37,133.83 238.13,133.83 238.02,133.71 238.02,133.68 237.9,133.56 237.66,133.56 237.55,133.68 237.55,133.71 237.43,133.83 237.2,133.83 237.08,133.71 237.08,133.68 236.96,133.56 236.73,133.56 236.61,133.68 236.61,133.71 236.5,133.83 236.26,133.83 236.15,133.71 236.15,133.68 236.03,133.56 235.8,133.56 235.68,133.68 235.68,133.71 235.56,133.83 235.33,133.83 235.21,133.71 235.21,133.68 235.09,133.56 234.86,133.56 234.74,133.68 234.74,133.71 234.63,133.83 234.39,133.83 234.28,133.71 234.28,133.68 234.16,133.56 233.93,133.56 233.81,133.68 233.81,133.71 233.69,133.83 231.86,133.83 231.34,134.35 231.34,134.71 231.02,135.03 230.32,135.03 v4(229.86,135.5)
  T16 w0.117: v4(259.7,135.93) U7.M7 259.3,130.16 259.5,129.97 259.5,126.22 259.3,126.03 259.3,124.66 v4(259.7,124.26)
MAC_DDRC_A13: length 77.1
  TOP w0.14: U7.T8 v4(262.9,135.93) 264.37,135.93 264.54,136.1 264.54,137.05 264.4,137.19 263.86,137.19 263.72,137.33 263.72,138.18 264.39,138.84 264.96,138.84 265.1,138.7 265.1,137.07 265.24,136.93 265.86,136.93 266,137.07 R182.1 ; U1.AU3 v4(230.86,138.5) ; U6.T8 v4(262.9,125.06)
  T14 w0.117: v4(230.86,138.5) 231.33,138.97 236.29,138.97 237.12,138.14 237.14,138.14 241.92,133.36 242.9,133.36 243.02,133.47 243.02,133.72 243.14,133.84 243.37,133.84 243.49,133.72 243.49,133.47 243.6,133.36 243.84,133.36 243.95,133.47 243.95,133.72 244.07,133.84 244.31,133.84 244.42,133.72 244.42,133.47 244.54,133.36 244.77,133.36 244.89,133.47 244.89,133.72 245.01,133.84 245.24,133.84 245.36,133.72 245.36,133.47 245.47,133.36 245.71,133.36 245.82,133.47 245.82,133.72 245.94,133.84 246.17,133.84 246.29,133.72 246.29,133.47 246.41,133.36 249.21,133.36 249.32,133.47 249.32,134.1 249.44,134.22 249.67,134.22 249.79,134.1 249.79,133.52 249.96,133.36 250.33,133.36 250.44,133.47 250.44,134.25 250.56,134.37 250.79,134.37 250.91,134.25 250.91,133.47 251.03,133.36 251.27,133.36 251.38,133.47 251.38,134.28 251.5,134.4 251.74,134.4 251.85,134.28 251.85,133.47 251.97,133.36 252.2,133.36 252.32,133.47 252.32,134.28 252.44,134.4 252.67,134.4 252.79,134.28 252.79,133.47 252.9,133.36 253.14,133.36 253.25,133.47 253.25,134.28 253.37,134.4 261.23,134.4 263.59,132.04 263.59,125.75 v4(262.9,125.06)
  T18 w0.117: v4(262.9,125.06) 263.41,125.57 263.41,133.44 263.53,133.55 263.71,133.55 263.83,133.67 263.83,133.9 263.71,134.02 263.53,134.02 263.41,134.14 263.41,134.37 263.53,134.49 263.71,134.49 263.83,134.6 263.83,134.84 263.71,134.95 263.53,134.95 263.41,135.07 263.41,135.42 v4(262.9,135.93)
MAC_DDRC_ACT_N: length 77.4
  TOP w0.14: U6.L3 v4(258.9,120.26) ; U1.AT2 v4(231.86,137.5) ; R190.1 264.76,133.6 259.29,133.6 258.5,132.81 U7.L3 v4(258.9,131.93)
  T14 w0.117: v4(258.9,120.26) 260.17,121.53 260.17,122 260.33,122.16 261.35,122.16 261.47,122.05 261.47,121.46 261.58,121.34 261.82,121.34 261.93,121.46 261.93,122.05 262.05,122.16 262.34,122.16 262.46,122.28 262.46,122.55 262.34,122.67 260.54,122.67 260.4,122.81 260.4,123.04 260.52,123.16 262.39,123.16 262.5,123.28 262.5,126.03 262.51,126.03 262.51,129.26 261.7,130.06 261.7,132.09 259.93,133.86 254.38,133.86 253.54,133.03 249.61,133.03 249.42,132.83 241.7,132.83 236.92,137.61 236.91,137.61 236.34,138.18 233.3,138.18 233.09,137.98 232.34,137.98 v4(231.86,137.5)
  T16 w0.117: v4(258.9,120.26) U6.L3 258.5,126.36 258.96,126.82 258.96,128.41 258.86,128.51 258.55,128.51 258.44,128.61 258.44,128.76 258.55,128.86 258.86,128.86 258.96,128.96 258.96,129.21 258.5,129.67 258.5,131.53 v4(258.9,131.93)
MAC_DDRC_ALERT0_N: length 54
  TOP w0.14: U1.AR1 v4(232.86,136.5) ; v4(261.3,125.86) U6.P9
  T07 w0.117: v4(261.3,125.86) 260.62,126.54 260.62,127.52 258.99,129.15 249.55,129.15 248.33,130.36 248.33,135.84 246.23,137.95 245.17,137.95 245.05,137.84 245.05,137.26 244.94,137.14 244.7,137.14 244.59,137.26 244.59,137.84 244.47,137.95 244.24,137.95 244.12,137.84 244.12,137.26 244,137.14 243.77,137.14 243.65,137.26 243.65,137.84 243.54,137.95 243.3,137.95 243.18,137.84 243.18,137.26 243.07,137.14 242.83,137.14 242.72,137.26 242.72,137.84 242.6,137.95 242.37,137.95 242.25,137.84 242.25,137.26 242.13,137.14 241.9,137.14 241.78,137.26 241.78,137.84 241.67,137.95 241.43,137.95 241.32,137.84 241.32,137.26 241.2,137.14 240.96,137.14 240.85,137.26 240.85,137.84 240.73,137.95 240.5,137.95 240.38,137.84 240.38,137.26 240.26,137.14 240.03,137.14 239.91,137.26 239.91,137.84 239.8,137.95 239.56,137.95 239.45,137.84 239.45,137.26 239.33,137.14 239.1,137.14 238.98,137.26 238.98,137.84 238.86,137.95 238.63,137.95 238.51,137.84 238.51,137.26 238.39,137.14 238.16,137.14 238.04,137.26 238.04,137.84 237.93,137.95 237.69,137.95 237.58,137.84 237.58,137.26 237.46,137.14 237.23,137.14 237.11,137.26 237.11,137.84 236.99,137.95 236.76,137.95 236.64,137.84 236.64,137.26 236.52,137.14 236.29,137.14 236.17,137.26 236.17,137.84 236.06,137.95 235.82,137.95 235.71,137.84 235.71,137.26 235.59,137.14 235.36,137.14 235.24,137.26 235.24,137.84 235.12,137.95 234.32,137.95 v4(232.86,136.5)
MAC_DDRC_ALERT1_N: length 77.9
  TOP w0.14: U1.AH6 v4(227.86,129.5) ; U7.P9 v4(261.3,137.53)
  T14 w0.117: v4(261.3,137.53) 261.3,137.71 260.96,138.05 255.63,138.05 255.52,138.17 255.52,139 255.4,139.12 255.17,139.12 255.05,139 255.05,138.17 254.93,138.05 254.7,138.05 254.58,138.17 254.58,139 254.46,139.12 254.23,139.12 254.11,139 254.11,138.17 254,138.05 253.76,138.05 253.65,138.17 253.65,139 253.53,139.12 253.3,139.12 253.18,139 253.18,138.17 253.06,138.05 252.83,138.05 252.71,138.17 252.71,139 252.59,139.12 252.36,139.12 252.24,139 252.24,138.17 252.13,138.05 251.89,138.05 251.78,138.17 251.78,139 251.66,139.12 251.43,139.12 251.31,139 251.31,138.17 251.19,138.05 250.96,138.05 250.84,138.17 250.84,139 250.73,139.12 250.49,139.12 250.37,139 250.37,138.17 250.26,138.05 250.02,138.05 249.91,138.17 249.91,139 249.79,139.12 249.56,139.12 249.44,139 249.44,138.17 249.32,138.05 249.09,138.05 248.97,138.17 248.97,139 248.86,139.12 248.62,139.12 248.51,139 248.51,138.17 248.39,138.05 248.15,138.05 248.04,138.17 248.04,139 247.92,139.12 247.69,139.12 247.57,139 247.57,138.17 247.45,138.05 247.22,138.05 247.1,138.17 247.1,139 246.99,139.12 246.75,139.12 246.64,139 246.64,138.17 246.52,138.05 246.29,138.05 246.17,138.17 246.17,139 246.05,139.12 245.82,139.12 245.7,139 245.7,138.17 245.58,138.05 245.35,138.05 245.23,138.17 245.23,139 245.12,139.12 244.88,139.12 244.77,139 244.77,138.17 244.65,138.05 244.42,138.05 244.3,138.17 244.3,139 244.18,139.12 243.95,139.12 243.83,139 243.83,138.17 243.72,138.05 243.48,138.05 243.36,138.17 243.36,139 243.25,139.12 243.01,139.12 242.9,139 242.9,138.17 242.78,138.05 242.55,138.05 242.43,138.17 242.43,139 242.31,139.12 242.08,139.12 241.96,139 241.96,138.17 241.85,138.05 241.61,138.05 241.5,138.17 241.5,139 241.38,139.12 241.14,139.12 241.03,139 241.03,138.17 240.91,138.05 240.14,138.05 237.82,140.36 237.82,140.88 237.02,141.68 230.96,141.68 228.38,139.09 228.38,132.3 228.09,132.02 227.54,132.02 227.36,131.84 227.36,130 v4(227.86,129.5)
MAC_DDRC_BA0: length 88.6
  TOP w0.14: U6.N2 v4(260.5,119.46) ; U1.AJ8 v4(225.86,130.5) ; U7.N2 v4(260.5,131.13)
  T05 w0.117: v4(260.5,131.13) 260.1,130.73 260.1,130.16 260.02,130.08 260.02,129.83 260.14,129.71 260.26,129.71 260.37,129.59 260.37,129.36 260.26,129.24 260.14,129.24 260.02,129.13 260.02,128.89 260.14,128.78 260.26,128.78 260.37,128.66 260.37,128.42 260.26,128.31 260.14,128.31 260.02,128.19 260.02,126.11 260.1,126.03 260.1,123.76 260.22,123.65 260.23,123.65 260.35,123.53 260.35,123.29 260.23,123.18 260.22,123.18 260.1,123.06 260.1,122.83 260.22,122.71 260.23,122.71 260.35,122.59 260.35,122.36 260.23,122.24 260.22,122.24 260.1,122.13 260.1,121.89 260.22,121.78 260.23,121.78 260.35,121.66 260.35,121.03 260.1,120.78 U6.N2 v4(260.5,119.46)
  T07 w0.117: v4(260.5,119.46) 260.1,119.06 260.1,118.4 259.21,117.51 245.95,117.51 241.42,122.03 241.25,122.03 240.56,121.34 240.39,121.34 240.22,121.5 240.22,121.67 240.92,122.36 240.92,122.53 240.61,122.84 239.71,122.84 239.59,122.72 239.59,122.25 239.47,122.13 239.24,122.13 239.12,122.25 239.12,122.72 239.01,122.84 238.77,122.84 238.66,122.72 238.66,122.25 238.54,122.13 238.31,122.13 238.19,122.25 238.19,122.72 238.07,122.84 237.84,122.84 237.72,122.72 237.72,122.25 237.6,122.13 237.37,122.13 237.25,122.25 237.25,122.72 237.14,122.84 236.57,122.84 236.45,122.72 236.45,120.04 236.33,119.92 236.1,119.92 235.98,120.04 235.98,122.72 235.86,122.84 235.63,122.84 235.51,122.72 235.51,120.04 235.4,119.92 235.16,119.92 235.05,120.04 235.05,120.91 234.93,121.03 234.05,121.03 233.93,121.14 233.93,121.38 234.05,121.49 234.93,121.49 235.05,121.61 235.05,121.85 234.93,121.96 234.05,121.96 233.93,122.08 233.93,122.31 234.05,122.43 234.93,122.43 235.05,122.55 235.05,122.72 234.93,122.84 233.95,122.84 233.83,122.96 233.83,126.42 233.28,126.97 229.64,126.97 229.35,127.26 229.35,127.66 229,128.01 226.55,128.01 226.34,128.21 226.34,130.01 v4(225.86,130.5)
  BOTTOM w0.102: v4(260.5,131.13) 260.9,130.73 261.45,130.73 261.71,130.48 261.71,129.43
  BOTTOM w0.14: 261.71,129.43 262.31,128.83 263.72,128.83 265.97,126.58 R193.1
MAC_DDRC_BA1: length 76.7
  TOP w0.14: U6.N8 v4(260.5,125.06) ; U1.AR4 v4(229.86,136.5) ; U7.N8 v4(260.5,136.73)
  T14 w0.117: v4(229.86,136.5) 230.36,136 230.36,134.42 230.69,134.09 237.04,134.09 237.04,134.09 237.47,134.09 238.81,132.75 238.81,129.32 241.24,126.89 247.98,126.89 248.1,127.01 248.1,127.75 248.22,127.87 248.45,127.87 248.57,127.75 248.57,127.01 248.69,126.89 248.92,126.89 249.04,127.01 249.04,127.75 249.15,127.87 249.39,127.87 249.5,127.75 249.5,127.01 249.62,126.89 252.84,126.89 252.94,127 252.94,127.91 253.05,128.02 253.19,128.02 253.29,127.91 253.29,127 253.4,126.89 253.54,126.89 253.64,127 253.64,127.46 253.75,127.56 253.89,127.56 253.99,127.46 253.99,127 254.1,126.89 254.24,126.89 254.34,127 254.34,127.38 254.45,127.48 254.59,127.48 254.7,127.38 254.7,127 254.8,126.89 254.94,126.89 255.05,127 255.05,128.01 255.15,128.11 255.29,128.11 255.4,128.01 255.4,127 255.5,126.89 255.64,126.89 255.75,127 255.75,128.05 255.85,128.15 255.99,128.15 256.1,128.05 256.1,127 256.2,126.89 256.35,126.89 256.45,127 256.45,128.18 256.55,128.28 256.7,128.28 256.8,128.18 256.8,127 256.9,126.89 257.05,126.89 257.15,127 257.15,128.18 257.25,128.28 257.4,128.28 257.5,128.18 257.5,127 257.65,126.85 258.48,126.85 259.3,126.03 259.3,125.7 259.54,125.46 259.87,125.46 260.27,125.06 v4(260.5,125.06)
  T18 w0.117: v4(260.5,125.06) 260.5,125.25 260.1,125.65 260.1,126.03 260.02,126.11 260.02,130.08 260.1,130.16 260.1,133.79 260.27,133.96 260.27,134.26 260.1,134.43 260.1,134.73 260.27,134.9 260.27,135.2 260.1,135.36 U7.N8 v4(260.5,136.73)
  BOTTOM w0.102: v4(260.5,136.73) 260.9,136.34 260.9,135.71
  BOTTOM w0.14: 260.9,135.71 261.19,135.41 263.12,135.41 263.9,136.2 264.9,136.2 265.9,137.2 R194.1
MAC_DDRC_BG0: length 89.3
  TOP w0.14: U7.M2 v4(259.7,131.13) ; U1.AH7 v4(226.86,129.5) ; U6.M2 v4(259.7,119.46)
  T05 w0.117: v4(259.7,131.13) 259.3,130.73 259.3,130.16 259.46,130.01 259.46,129.58 259.26,129.37 259.26,129.11 259.46,128.91 259.46,128.64 259.26,128.44 259.26,128.18 259.46,127.97 259.46,126.19 259.3,126.03 259.3,124.1 259.46,123.94 259.46,123.44 259.34,123.32 259.2,123.32 259.08,123.21 259.08,122.97 259.2,122.86 259.34,122.86 259.46,122.74 259.46,122.5 259.34,122.39 259.2,122.39 259.08,122.27 259.08,122.04 259.2,121.92 259.34,121.92 259.46,121.8 259.46,121.03 259.3,120.87 U6.M2 v4(259.7,119.46)
  T07 w0.117: v4(259.7,119.46) 259.3,119.06 259.3,118.26 259.08,118.04 246.4,118.04 241.01,123.44 240.26,123.44 240.14,123.55 240.14,124.27 240.02,124.39 239.79,124.39 239.67,124.27 239.67,123.55 239.55,123.44 239.19,123.44 239.07,123.55 239.07,125.82 238.95,125.94 238.72,125.94 238.6,125.82 238.6,123.55 238.48,123.44 238.21,123.44 237.98,123.66 237.98,126.89 237.87,127.01 237.63,127.01 237.52,126.89 237.52,123.52 237.4,123.4 236.93,123.4 236.82,123.52 236.82,125.49 236.7,125.61 236.47,125.61 236.35,125.49 236.35,123.52 236.23,123.4 236,123.4 235.88,123.52 235.88,125.71 235.76,125.82 235.22,125.82 235.1,125.71 235.1,123.41 234.98,123.3 234.75,123.3 234.63,123.41 234.63,125.71 234.52,125.82 234.33,125.82 234.22,125.94 234.22,126.13 234.33,126.24 234.76,126.24 234.87,126.36 234.87,126.59 234.76,126.71 234.33,126.71 234.22,126.83 234.22,126.94 234.76,127.48 234.76,127.65 234.6,127.81 234.43,127.81 233.89,127.27 233.72,127.27 232.97,128.02 229.59,128.02 229.33,128.27 229.33,128.74 229.09,128.99 227.36,128.99 v4(226.86,129.5)
  BOTTOM w0.102: v4(259.7,131.13) 260.11,131.53 260.11,132.18
  BOTTOM w0.14: 260.11,132.18 260.19,132.26 260.67,132.74 263.68,132.74 R195.1
MAC_DDRC_CAS_N: length 79.2
  TOP w0.14: U1.AP3 v4(230.86,135.5) ; U6.M8 v4(259.7,125.06) ; U7.M8 v4(259.7,136.73)
  T07 w0.117: v4(230.86,135.5) 231.34,135.97 233.38,135.97 233.48,135.87 233.82,135.87 233.94,135.98 233.94,136.52 234.05,136.63 234.29,136.63 234.4,136.52 234.4,135.98 234.52,135.87 234.75,135.87 234.87,135.98 234.87,136.52 234.99,136.63 235.22,136.63 235.34,136.52 235.34,135.98 235.45,135.87 235.69,135.87 235.8,135.98 235.8,136.52 235.92,136.63 236.16,136.63 236.27,136.52 236.27,135.98 236.39,135.87 236.62,135.87 236.74,135.98 236.74,136.52 236.86,136.63 237.09,136.63 237.21,136.52 237.21,135.98 237.32,135.87 237.56,135.87 237.67,135.98 237.67,136.52 237.79,136.63 238.02,136.63 238.14,136.52 238.14,135.98 238.26,135.87 238.49,135.87 238.61,135.98 238.61,136.52 238.73,136.63 238.96,136.63 239.08,136.52 239.08,135.98 239.19,135.87 239.43,135.87 239.54,135.98 239.54,136.52 239.66,136.63 239.89,136.63 240.01,136.52 240.01,135.98 240.13,135.87 240.36,135.87 240.48,135.98 240.48,136.52 240.6,136.63 240.83,136.63 240.95,136.52 240.95,135.98 241.06,135.87 241.3,135.87 241.41,135.98 241.41,136.52 241.53,136.63 241.76,136.63 241.88,136.52 241.88,135.98 242,135.87 242.23,135.87 242.35,135.98 242.35,136.52 242.46,136.63 242.7,136.63 242.82,136.52 242.82,135.98 242.93,135.87 243.17,135.87 243.28,135.98 243.28,136.52 243.4,136.63 243.63,136.63 243.75,136.52 243.75,135.98 243.87,135.87 244.1,135.87 244.22,135.98 244.22,136.52 244.33,136.63 244.57,136.63 244.68,136.52 244.68,135.98 244.8,135.87 245.04,135.87 245.15,135.98 245.15,136.52 245.27,136.63 245.5,136.63 245.62,136.52 245.62,135.98 245.74,135.87 246.66,135.87 247.8,134.73 247.8,129.47 248.65,128.62 252.94,128.62 253.9,127.66 255.64,127.66 255.75,127.78 255.75,128.11 255.87,128.22 256.1,128.22 256.22,128.11 256.22,127.78 256.34,127.66 256.57,127.66 256.69,127.78 256.69,128.11 256.99,128.41 258.74,128.41 259.3,127.85 259.3,125.46 v4(259.7,125.06)
  T18 w0.117: v4(259.7,125.06) 259.47,125.06 259.07,125.46 258.69,125.46 258.5,125.65 258.5,126.55 258.96,127.01 258.96,127.85 258.57,128.23 258.57,130.02 258.5,130.09 258.5,132.46 259.3,133.26 U7.M8 v4(259.7,136.73)
  BOTTOM w0.102: v4(259.7,136.73) 260.1,136.33 260.1,135.62 260.24,135.48
  BOTTOM w0.14: 260.24,135.48 260.64,135.08 263.59,135.08 264.19,135.68 265.44,135.68 R185.1
MAC_DDRC_CLK_DN: length 75.9
  TOP w0.109: v4(258.1,135.93) U7.K8 ; v4(258.1,124.26) U6.K8
  TOP w0.14: U1.AK6 v4(227.86,131.5)
  T14 w0.102: 231.77,131.18 231.75,131.17 231.7,131.17 231.43,130.9 228.52,130.9 228.26,131.16 228.26,131.39 228.16,131.5 v4(227.86,131.5)
  T14 w0.107: 231.77,131.18 233.06,132.48 236.85,132.48 237.26,132.07 237.26,129.88 237.15,129.77 234.71,129.77 234.44,129.5 234.44,129.06 234.71,128.79 237.15,128.79 243.51,122.43 245.09,122.43 245.36,122.7 245.36,124.03 245.47,124.14 245.68,124.14 245.79,124.03 245.79,122.7 246.06,122.43 246.5,122.43 246.77,122.7 246.77,124.03 246.88,124.14 247.09,124.14 247.2,124.03 247.2,122.7 247.47,122.43 247.91,122.43 248.19,122.7 248.19,124.03 248.29,124.14 248.51,124.14 248.61,124.03 248.61,122.7 248.88,122.43 249.41,122.43 249.68,122.7 249.68,123.22 249.79,123.32 250,123.32 250.11,123.22 250.11,122.7 250.38,122.43 250.82,122.43 251.09,122.7 251.09,123.22 251.2,123.32 251.41,123.32 251.52,123.22 251.52,122.7 251.79,122.43 252.24,122.43 252.51,122.7 252.51,123.22 252.61,123.32 252.83,123.32 252.93,123.22 252.93,122.7 253.2,122.43 258.14,122.43 258.9,123.19 258.9,123.71 258.6,124 258.36,124 v4(258.1,124.26)
  T18 w0.107: v4(258.1,135.93) 257.84,135.67 257.84,134.98 256.61,133.74 256.61,133.51 256.77,133.35 256.77,133.08 256.61,132.93 256.61,132.66 256.77,132.5 256.77,132.23 256.61,132.07 256.61,124.08 256.91,123.78 257.45,123.78 257.68,124 257.93,124 258.1,124.18 v4(258.1,124.26)
  BOTTOM w0.104: v4(258.1,135.93) 257.84,135.66 257.84,135.31 R202.1
MAC_DDRC_CLK_DP: length 75.9
  TOP w0.109: v4(258.1,123.46) U6.K7 ; U7.K7 v4(257.3,135.93)
  TOP w0.14: U1.AK5 v4(228.86,131.5)
  T14 w0.102: 231.57,131.38 231.55,131.36 231.55,131.31 231.34,131.1 228.61,131.1 228.46,131.25 228.46,131.39 228.56,131.5 v4(228.86,131.5)
  T14 w0.107: v4(258.1,123.46) 258.36,123.72 258.49,123.72 258.62,123.59 258.62,123.31 258.02,122.71 257.49,122.71 257.38,122.82 257.38,122.86 257.27,122.97 257.06,122.97 256.95,122.86 256.95,122.82 256.85,122.71 256.63,122.71 256.53,122.82 256.53,122.86 256.42,122.97 256.21,122.97 256.1,122.86 256.1,122.82 255.99,122.71 255.78,122.71 255.67,122.82 255.67,122.86 255.57,122.97 255.35,122.97 255.25,122.86 255.25,122.82 255.14,122.71 254.93,122.71 254.82,122.82 254.82,122.86 254.71,122.97 254.5,122.97 254.39,122.86 254.39,122.82 254.29,122.71 253.32,122.71 253.21,122.82 253.21,123.33 252.94,123.6 252.5,123.6 252.23,123.33 252.23,122.82 252.12,122.71 251.91,122.71 251.8,122.82 251.8,123.33 251.53,123.6 251.09,123.6 250.82,123.33 250.82,122.82 250.71,122.71 250.5,122.71 250.39,122.82 250.39,123.33 250.12,123.6 249.67,123.6 249.4,123.33 249.4,122.82 249.3,122.71 249,122.71 248.89,122.82 248.89,124.14 248.62,124.41 248.18,124.41 247.91,124.14 247.91,122.82 247.8,122.71 247.59,122.71 247.48,122.82 247.48,124.14 247.21,124.41 246.76,124.41 246.49,124.14 246.49,122.82 246.39,122.71 246.17,122.71 246.07,122.82 246.07,124.14 245.8,124.41 245.35,124.41 245.08,124.14 245.08,122.82 244.97,122.71 243.62,122.71 237.27,129.07 234.83,129.07 234.72,129.17 234.72,129.39 234.83,129.49 237.27,129.49 237.54,129.76 237.54,132.19 236.97,132.76 232.94,132.76 231.57,131.38
  T18 w0.107: v4(258.1,123.46) 258.1,123.59 257.97,123.72 257.79,123.72 257.57,123.5 256.79,123.5 256.33,123.96 256.33,133.86 257.56,135.09 257.56,135.67 v4(257.3,135.93)
  BOTTOM w0.104: v4(257.3,135.93) 257.57,135.66 257.57,135.14 R201.1
MAC_DDRC_CLK_EN: length 88.5
  TOP w0.14: U7.K2 v4(258.1,131.13) ; U6.K2 v4(258.1,119.46) ; U1.AG6 v4(227.86,128.5)
  T05 w0.117: v4(258.1,119.46) U6.K2 257.7,126.4 257.05,127.05 257.05,127.61 256.95,127.71 256.73,127.71 256.63,127.82 256.63,127.96 256.73,128.06 256.95,128.06 257.05,128.17 257.05,128.31 256.95,128.41 256.73,128.41 256.63,128.52 256.63,128.66 256.73,128.76 256.95,128.76 257.05,128.87 257.05,129.51 257.7,130.16 257.7,130.73 257.7,130.73 257.7,130.89 257.94,131.13 v4(258.1,131.13)
  T14 w0.117: v4(258.1,119.46) 257.7,119.06 256.88,119.06 256.76,119.18 256.76,119.68 256.65,119.79 256.41,119.79 256.3,119.68 256.3,119.18 256.18,119.06 249.8,119.06 249.5,119.36 249.5,120.44 249.39,120.55 248.95,120.55 248.83,120.44 248.83,118.72 248.71,118.6 248.48,118.6 248.36,118.72 248.36,120.44 248.25,120.55 248.01,120.55 247.9,120.44 247.9,118.72 247.78,118.6 247.54,118.6 247.43,118.72 247.43,120.44 247.31,120.55 247.08,120.55 246.96,120.44 246.96,118.72 246.84,118.6 246.61,118.6 246.49,118.72 246.49,120.44 246.38,120.55 246.14,120.55 246.03,120.44 246.03,118.72 245.91,118.6 245.68,118.6 245.56,118.72 245.56,120.44 245.44,120.55 245.21,120.55 245.09,120.44 245.09,118.72 244.97,118.6 244.74,118.6 244.62,118.72 244.62,120.44 244.51,120.55 244.27,120.55 244.16,120.44 244.16,118.72 244.04,118.6 243.81,118.6 243.69,118.72 243.69,120.44 243.57,120.55 243.34,120.55 243.22,120.44 243.22,118.72 243.1,118.6 242.87,118.6 242.75,118.72 242.75,120.44 242.64,120.55 242.62,120.55 237.78,125.39 235.9,125.39 234.29,127 234.12,127 233.76,126.64 233.59,126.64 233.43,126.8 233.43,126.97 233.79,127.33 233.79,127.5 233.2,128.09 227.98,128.09 227.86,128.21 v4(227.86,128.5)
  BOTTOM w0.102: v4(258.1,131.13) 258.51,131.53 258.51,132.46
  BOTTOM w0.14: 258.51,132.46 259.52,133.46 264.89,133.46 R200.1
MAC_DDRC_CS0_N: length 64
  TOP w0.14: R197.1 263.45,123.6 263.24,123.39 258.8,123.39 258.5,123.69 U6.L7 v4(258.9,124.26) ; U1.AN2 v4(231.86,134.5)
  T07 w0.117: v4(258.9,124.26) 258.9,124.5 258.5,124.9 258.5,126.12 257.57,127.06 249.43,127.06 247.06,129.42 247.06,134.12 245.85,135.34 244.82,135.34 244.7,135.22 244.7,134.51 244.58,134.4 244.35,134.4 244.23,134.51 244.23,135.22 244.12,135.34 243.88,135.34 243.76,135.22 243.76,134.51 243.65,134.4 243.41,134.4 243.3,134.51 243.3,135.22 243.18,135.34 242.95,135.34 242.83,135.22 242.83,134.51 242.71,134.4 242.48,134.4 242.36,134.51 242.36,135.22 242.25,135.34 242.01,135.34 241.9,135.22 241.9,134.51 241.78,134.4 241.54,134.4 241.43,134.51 241.43,135.22 241.31,135.34 241.08,135.34 240.96,135.22 240.96,134.51 240.84,134.4 240.61,134.4 240.49,134.51 240.49,135.22 240.38,135.34 240.14,135.34 240.03,135.22 240.03,134.51 239.91,134.4 239.68,134.4 239.56,134.51 239.56,135.22 239.44,135.34 239.21,135.34 239.09,135.22 239.09,134.51 238.97,134.4 238.74,134.4 238.62,134.51 238.62,135.22 238.51,135.34 238.27,135.34 238.16,135.22 238.16,134.51 238.04,134.4 237.81,134.4 237.69,134.51 237.69,135.22 237.57,135.34 237.34,135.34 237.22,135.22 237.22,134.51 237.1,134.4 236.87,134.4 236.75,134.51 236.75,135.22 236.64,135.34 236.4,135.34 236.29,135.22 236.29,134.51 236.17,134.4 235.94,134.4 235.82,134.51 235.82,135.22 235.7,135.34 235.47,135.34 235.35,135.22 235.35,134.51 235.24,134.4 235,134.4 234.88,134.51 234.88,135.22 234.77,135.34 234.53,135.34 234.42,135.22 234.42,134.51 234.3,134.4 234.07,134.4 233.95,134.51 233.95,135.22 233.83,135.34 233.45,135.34 233.02,134.9 232.27,134.9 v4(231.86,134.5)
MAC_DDRC_CS1_N: length 81.8
  TOP w0.14: U1.AM5 v4(228.86,133.5) ; U7.L7 v4(258.9,135.93)
  T14 w0.117: v4(258.9,135.93) 258.34,135.37 249.17,135.37 249.05,135.49 249.05,137.35 248.94,137.47 248.7,137.47 248.58,137.35 248.58,135.49 248.47,135.37 248.23,135.37 248.12,135.49 248.12,137.35 248,137.47 247.77,137.47 247.65,137.35 247.65,135.49 247.53,135.37 247.3,135.37 247.18,135.49 247.18,137.35 247.07,137.47 246.83,137.47 246.72,137.35 246.72,135.49 246.6,135.37 246.36,135.37 246.25,135.49 246.25,137.35 246.13,137.47 245.9,137.47 245.78,137.35 245.78,135.49 245.66,135.37 245.43,135.37 245.31,135.49 245.31,137.35 245.2,137.47 244.96,137.47 244.85,137.35 244.85,135.49 244.73,135.37 244.5,135.37 244.38,135.49 244.38,137.35 244.26,137.47 244.03,137.47 243.91,137.35 243.91,135.49 243.79,135.37 243.56,135.37 243.44,135.49 243.44,137.35 243.33,137.47 243.09,137.47 242.98,137.35 242.98,135.49 242.86,135.37 242.53,135.37 242.41,135.49 242.41,137.35 242.3,137.47 242.06,137.47 241.95,137.35 241.95,135.49 241.83,135.37 241.49,135.37 240.92,135.95 240.92,136.11 241.01,136.2 241.01,136.37 240.84,136.53 240.68,136.53 240.59,136.44 240.42,136.44 240.26,136.61 240.26,136.77 240.34,136.86 240.34,137.03 240.18,137.19 240.01,137.19 239.93,137.1 239.76,137.1 239.59,137.27 239.59,137.44 239.68,137.52 239.68,137.69 239.52,137.85 239.35,137.85 239.26,137.77 239.1,137.77 238.93,137.93 238.93,138.1 239.02,138.19 239.02,138.35 238.86,138.52 238.69,138.52 238.6,138.43 238.44,138.43 238.27,138.59 238.27,138.76 238.36,138.85 238.36,139.01 238.19,139.18 238.03,139.18 237.94,139.09 237.78,139.09 237.61,139.25 237.61,139.42 237.7,139.51 237.7,139.67 237.53,139.84 237.37,139.84 237.28,139.75 237.11,139.75 236.71,140.16 230.25,140.16 229.33,139.24 229.33,133.97 v4(228.86,133.5)
  BOTTOM w0.14: v4(258.9,135.93) 258.9,135.03 259.64,134.3 R198.1
MAC_DDRC_DBI0_N: length 56.2
  TOP w0.14: U1.AC4 v4(229.86,124.5) ; U6.E7 v4(253.3,124.26)
  T05 w0.117: v4(229.86,124.5) 229.86,124.78 230.1,125.02 233.64,125.02 234.3,125.68 237.81,125.68 241.16,122.33 241.58,122.33 241.7,122.45 241.7,123.54 241.82,123.65 242.05,123.65 242.17,123.54 242.17,122.45 242.28,122.33 242.52,122.33 242.63,122.45 242.63,123.54 242.75,123.65 242.98,123.65 243.1,123.54 243.1,122.45 243.22,122.33 243.45,122.33 243.57,122.45 243.57,123.54 243.69,123.65 243.92,123.65 244.04,123.54 244.04,122.45 244.15,122.33 244.39,122.33 244.5,122.45 244.5,123.54 244.62,123.65 244.85,123.65 244.97,123.54 244.97,122.45 245.09,122.33 245.32,122.33 245.44,122.45 245.44,123.54 245.56,123.65 245.79,123.65 245.91,123.54 245.91,122.45 246.02,122.33 246.26,122.33 246.37,122.45 246.37,123.54 246.49,123.65 246.72,123.65 246.84,123.54 246.84,122.45 246.96,122.33 247.19,122.33 247.31,122.45 247.31,123.54 247.42,123.65 247.66,123.65 247.78,123.54 247.78,122.45 247.89,122.33 248.23,122.33 248.45,122.55 248.45,123.42 248.72,123.68 251.82,123.68 252.02,123.49 252.02,122.61 252.14,122.48 252.48,122.48 252.6,122.6 252.6,123.26 252.71,123.37 252.95,123.37 253.06,123.26 253.06,122.6 253.18,122.48 253.41,122.48 253.53,122.6 253.53,123.26 253.65,123.37 253.88,123.37 254,123.26 254,122.6 254.12,122.48 254.35,122.48 254.47,122.6 254.47,123.26 254.58,123.37 254.82,123.37 254.93,123.26 254.93,122.6 255.05,122.48 255.63,122.48 255.75,122.6 255.75,123.66 255.63,123.78 253.79,123.78 v4(253.3,124.26)
MAC_DDRC_DBI1_N: length 50.3
  TOP w0.14: U1.AH3 v4(230.86,129.5) ; U6.E2 v4(253.3,119.46)
  T16 w0.117: v4(253.3,119.46) 253.44,119.46 253.7,119.2 253.7,117.13 253.54,116.97 253.32,116.97 253.2,117.09 253.2,117.97 253.09,118.09 252.85,118.09 252.74,117.97 252.74,117.19 252.59,117.05 252.35,117.05 252.23,117.17 252.23,117.41 252.12,117.53 251.88,117.53 251.77,117.41 251.77,117.34 251.65,117.23 250.06,117.23 246.15,113.31 240.92,113.31 240.7,113.54 236.51,113.54 233.05,116.99 229.73,116.99 229.44,117.29 229.44,120.73 229.55,120.84 230.22,120.84 230.34,120.96 230.34,129.91 230.46,130.03 231.29,130.03 231.37,129.95 231.37,129.04 231.29,128.96 230.94,128.96 230.86,129.04 v4(230.86,129.5)
MAC_DDRC_DBI2_N: length 70.5
  TOP w0.14: U1.AE7 v4(226.86,126.5) ; v4(253.3,135.93) U7.E7
  T16 w0.117: v4(226.86,126.5) 226.87,126.5 227.31,126.93 227.31,127.88 227.14,128.05 226.63,128.05 226.37,128.31 226.37,131.68 226.66,131.97 227.04,131.97 227.27,132.21 227.27,136.48 227.89,137.09 233.03,137.09 233.23,137.3 233.68,137.3 233.8,137.42 233.8,137.74 233.91,137.86 234.15,137.86 234.26,137.74 234.26,137.42 234.38,137.3 234.61,137.3 234.73,137.42 234.73,137.74 234.85,137.86 235.08,137.86 235.2,137.74 235.2,137.42 235.32,137.3 235.42,137.3 235.67,137.55 235.67,137.74 235.78,137.86 236.02,137.86 236.13,137.74 236.13,137.42 236.19,137.36 236.54,137.36 236.6,137.42 236.6,137.74 236.72,137.86 236.95,137.86 237.07,137.74 237.07,137.42 237.13,137.36 237.47,137.36 237.54,137.42 237.54,137.74 237.65,137.86 237.89,137.86 238,137.74 238,137.42 238.06,137.36 238.41,137.36 238.47,137.42 238.47,137.74 238.59,137.86 238.82,137.86 238.94,137.74 238.94,137.42 239,137.36 239.34,137.36 239.4,137.42 239.4,137.74 239.52,137.86 239.76,137.86 239.87,137.74 239.87,137.42 239.93,137.36 240.28,137.36 240.34,137.42 240.34,137.74 240.46,137.86 240.69,137.86 240.81,137.74 240.81,137.42 240.87,137.36 241.21,137.36 241.27,137.42 241.27,137.74 241.39,137.86 241.62,137.86 241.74,137.74 241.74,137.42 241.8,137.36 242.15,137.36 242.21,137.42 242.21,137.74 242.33,137.86 242.56,137.86 242.68,137.74 242.68,137.42 242.74,137.36 243.08,137.36 243.14,137.42 243.14,137.74 243.26,137.86 243.49,137.86 243.61,137.74 243.61,137.42 243.73,137.3 243.98,137.3 247.47,140.8 247.95,140.8 248.06,140.91 248.06,141.29 248.17,141.39 248.41,141.39 248.53,141.28 248.53,140.94 248.67,140.8 248.89,140.8 249.01,140.91 249.01,141.28 249.12,141.39 249.36,141.39 249.47,141.28 249.47,140.94 249.61,140.8 249.83,140.8 249.94,140.91 249.94,141.28 250.06,141.39 250.29,141.39 250.41,141.28 250.41,140.94 250.55,140.8 250.76,140.8 250.88,140.91 250.88,141.28 250.99,141.39 251.23,141.39 251.34,141.28 251.34,140.94 251.48,140.8 251.69,140.8 251.81,140.91 251.81,141.28 251.93,141.39 252.16,141.39 252.28,141.28 252.28,140.94 252.42,140.8 252.63,140.8 252.75,140.91 252.75,141.28 252.86,141.39 253.1,141.39 253.21,141.28 253.21,140.94 253.35,140.8 253.56,140.8 253.68,140.91 253.68,141.28 253.8,141.39 254.03,141.39 254.15,141.28 254.15,140.97 254.22,140.89 254.52,140.89 254.64,140.78 254.64,140.44 254.5,140.3 253.14,140.3 253.02,140.18 253.02,139.96 253.17,139.8 254.36,139.8 254.47,139.69 254.47,139.5 254.33,139.36 253.16,139.36 253.04,139.25 253.04,139.05 253.16,138.93 254.29,138.93 254.41,138.82 254.41,138.61 254.27,138.47 253.19,138.47 253.07,138.35 253.07,138.12 253.19,138 254.39,138 254.5,137.88 254.5,137.36 254.27,137.13 253.94,137.13 253.7,136.89 253.7,136.05 253.59,135.93 v4(253.3,135.93)
MAC_DDRC_DBI3_N: length 69
  TOP w0.14: U1.AB6 v4(227.86,123.5) ; U7.E2 v4(253.3,131.13)
  T18 w0.117: v4(253.3,131.13) 252.9,130.73 252.9,130.16 253.59,129.47 253.59,128.31 253.48,128.19 253.2,128.19 253.08,128.07 253.08,127.74 253.2,127.62 254.44,127.62 254.54,127.52 254.54,127.17 254.41,127.04 249.36,127.04 248.95,126.63 248.95,118.99 248.6,118.63 248.45,118.63 248.23,118.85 248.09,118.85 247.98,118.75 247.98,118.6 248.2,118.38 248.2,118.24 248.1,118.13 247.96,118.13 247.74,118.35 247.59,118.35 247.49,118.25 247.49,118.11 247.71,117.89 247.71,117.74 247.41,117.45 240.4,117.45 240.28,117.56 240.28,117.72 240.17,117.84 239.93,117.84 239.82,117.72 239.82,117.56 239.7,117.45 239.47,117.45 239.35,117.56 239.35,117.72 239.23,117.84 239,117.84 238.88,117.72 238.88,117.56 238.76,117.45 238.53,117.45 238.41,117.56 238.41,117.72 238.3,117.84 238.06,117.84 237.95,117.72 237.95,117.56 237.83,117.45 237.6,117.45 237.48,117.56 237.48,117.72 237.36,117.84 237.13,117.84 237.01,117.72 237.01,117.56 236.9,117.45 236.37,117.45 236.25,117.56 236.25,117.92 236.13,118.04 235.9,118.04 235.78,117.92 235.78,117.56 235.66,117.45 235.21,117.45 235.09,117.56 235.09,119.78 234.97,119.89 234.74,119.89 234.62,119.78 234.62,117.56 234.5,117.45 234.32,117.45 233.98,117.79 233.98,120.3 233.47,120.82 232.24,120.82 232.12,120.7 232.12,120.11 232,120 231.77,120 231.65,120.11 231.65,120.95 231.53,121.07 231.33,121.07 231.21,120.95 231.21,120.11 231.09,119.99 230.88,119.99 230.77,120.11 230.77,120.9 230.63,121.05 230.35,121.05 230.24,120.93 230.24,120.16 230.09,120.02 229.86,120.02 229.74,120.13 229.74,120.93 229.63,121.05 229.43,121.05 229.31,120.93 229.31,120.14 229.19,120.02 228.96,120.02 228.84,120.14 228.84,120.61 228.72,120.73 228.49,120.73 228.37,120.61 228.37,120.14 228.26,120.02 228.02,120.02 227.91,120.14 227.91,120.61 227.79,120.73 227.55,120.73 227.44,120.61 227.44,120.14 227.32,120.02 227,120.02 226.92,120.1 226.92,120.95 227.03,121.06 228.27,121.06 228.39,121.18 228.39,122.73 227.86,123.26 v4(227.86,123.5)
MAC_DDRC_DQ00: length 53.6
  TOP w0.14: U6.G2 v4(254.9,119.46) ; U1.AB1 v4(232.86,123.5)
  T05 w0.102: v4(254.9,119.46) 255.3,119.07 255.3,118.34 255.4,118.24 255.41,118.24 255.52,118.12 255.52,117.88
  T05 w0.117: v4(232.86,123.5) 234.37,123.5 234.49,123.38 234.49,122.4 234.6,122.28 234.79,122.28 234.9,122.4 234.9,123.58 235.02,123.7 235.26,123.7 235.37,123.58 235.37,122.45 235.54,122.28 235.72,122.28 235.84,122.4 235.84,123.58 235.96,123.7 236.48,123.7 236.6,123.58 236.6,123.31 236.72,123.2 237.73,123.2 237.84,123.08 237.84,122.85 237.73,122.73 236.87,122.73 236.76,122.61 236.76,120.11 237.84,119.03 239.08,119.03 239.19,118.91 239.19,118.23 239.31,118.12 239.54,118.12 239.66,118.23 239.66,118.91 239.78,119.03 240.01,119.03 240.13,118.91 240.13,118.23 240.24,118.12 240.63,118.12 240.74,118.23 240.74,120.39 240.86,120.5 241.09,120.5 241.21,120.39 241.21,118.23 241.33,118.12 241.82,118.12 241.92,118.01 241.92,117.48 242.02,117.37 242.17,117.37 242.27,117.48 242.27,118.01 242.38,118.12 242.52,118.12 242.62,118.01 242.62,117.48 242.73,117.37 242.87,117.37 242.97,117.48 242.97,118.01 243.08,118.12 243.22,118.12 243.32,118.01 243.32,117.48 243.43,117.37 243.57,117.37 243.67,117.48 243.67,118.01 243.78,118.12 248.84,118.12 248.95,118.23 248.95,118.53 249.07,118.65 249.3,118.65 249.42,118.53 249.42,118.23 249.54,118.12 249.97,118.12 250.07,118.01 250.07,117.64 250.17,117.54 250.32,117.54 250.42,117.64 250.42,118.01 250.52,118.12 250.67,118.12 250.77,118.01 250.77,117.64 250.88,117.54 251.02,117.54 251.12,117.64 251.12,118.01 251.23,118.12 251.37,118.12 251.47,118.01 251.47,117.64 251.58,117.54 251.72,117.54 251.82,117.64 251.82,118.01 251.93,118.12 252.07,118.12 252.17,118.01 252.17,117.64 252.28,117.54 252.42,117.54 252.53,117.64 252.53,118.01 252.63,118.12 252.77,118.12 252.88,118.01 252.88,117.64 252.98,117.54 253.12,117.54 253.23,117.64 253.23,118.01 253.33,118.12 253.87,118.12 254.13,117.86 254.13,117.47 254.38,117.22 255.27,117.22 255.52,117.47 255.52,117.88
