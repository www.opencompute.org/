# Allegro board T99O089T00_025_20180609.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EEPROM_WP: length 6.4
  TOP w0.14: U140.7 9.44,74.97 7.82,73.35 v1(7.82,72.59) R1691.2 R1688.1
EEPROM_WP_SYS: length 3.7
  TOP w0.14: v1(96.95,184.92) U81.7
  BOTTOM w0.14: R1099.1 R1100.2 96.83,185.04 v1(96.95,184.92)
FAN1_PRSNT_N: length 179.3
  TOP w0.14: U70.C11 v4(118.8,131.25) ; J5.1 v1(262.32,195.64)
  T14 w0.117: v1(262.32,195.64) 262.32,194.7 260.93,193.31 252.75,193.31 242.63,183.18 198.24,183.18 197.5,182.44 174.53,159.47 156.15,159.47 148.93,152.25 139.21,152.25 128.68,141.72 122.53,141.72 120.44,139.63 120.44,136.7 119.18,135.44 119.18,134 118.4,133.22 118.4,131.65 v4(118.8,131.25)
  BOTTOM w0.14: v1(262.32,195.64) v2(262.32,194.68) 261.75,194.11 R1118.1
FAN1_PWM_CTRL: length 173.9
  TOP w0.14: R12954.2 v1(126.11,182.63) ; R12950.2 v1(129.67,169.29) ; J5.5 266.32,192.79 v1(267.08,192.02)
  T16 w0.117: v1(129.67,169.29) 128.97,168.6 128.16,168.6 127.73,169.03 127.73,169.36 127.26,169.83 126.33,169.83 124.48,171.68 124.48,181 v1(126.11,182.63) 127.54,184.05 128.21,184.05 133.56,189.4 135.75,189.4 138.63,192.28 144.78,192.28 145.71,191.34 146.16,191.34 151.95,185.56 162.33,185.56 166.5,189.73 253.11,189.73 256.47,193.09 266.01,193.09 v1(267.08,192.02)
FAN1_TACH_IN: length 12.3
  TOP w0.14: J5.3 v1(264.32,195.64)
  BOTTOM w0.14: v1(264.32,195.64) 264.29,195.6 R1107.2 ; R1107.2 263.61,194.39 262.72,193.51 v2(262.72,192.02) 262.72,190.84 261.67,189.79 C1551.1 259.73,189.79 C1555.1 ; R1107.2 R1113.1
FAN1_TACH_INT_INLET: length 8.4
  TOP w0.14: Q3.1 262.03,184.63 R1104.2 260.88,183.26 v1(259.97,184.17)
  BOTTOM w0.14: Q4.3 259.97,185.06 v1(259.97,184.17) 259.97,184.16 260.11,184.02 260.86,184.02 261.42,183.47 C1552.1 v2(261.42,181.78)
FAN1_TACH_INT_INLET_N: length 4
  BOTTOM w0.14: C1551.2 261.61,187.73 R12993.2 262.4,187.1 v2(262.68,187.38) 262.99,187.69 R1105.1
FAN2_PRSNT_N: length 185.4
  TOP w0.14: J5.9 v1(270.32,195.64) ; U70.B11 v4(118.8,132.05)
  T14 w0.117: v4(118.8,132.05) 119.53,132.78 119.53,132.94 121.5,134.92 121.5,136.37 121.28,136.58 121.28,139.28 121.69,139.69 127.85,139.69 139.57,151.41 149.28,151.41 156.5,158.63 174.88,158.63 198.34,182.09 198.59,182.34 242.98,182.34 253.1,192.46 261.75,192.46 263.58,194.28 268.97,194.28 v1(270.32,195.64)
  BOTTOM w0.14: v2(269.14,194.16) 269.37,194.39 R1119.1 270.25,195.57 v1(270.32,195.64)
FAN2_PWM_CTRL: length 177.9
  TOP w0.14: R12951.2 v1(128.4,169.16) ; J5.13 274.32,191.29 v1(273.86,190.83) ; R12955.2 v1(127.38,182.63)
  T16 w0.117: v1(273.86,190.83) 273.24,191.46 264.29,191.46 263.27,192.48 256.57,192.48 253.39,189.31 166.67,189.31 162.5,185.14 151.77,185.14 145.98,190.92 139.57,190.92 137.62,188.98 133.73,188.98 v1(127.38,182.63) 124.91,180.15 124.91,171.85 126.33,170.43 127.57,170.43 128.4,169.6 v1(128.4,169.16)
FAN2_TACH_IN: length 17.3
  TOP w0.14: J5.11 v1(272.32,195.64)
  BOTTOM w0.14: C1567.1 265.14,188.5 C1563.1 265.17,189.04 266.22,190.08 266.22,192.53 269.9,196.22 271.74,196.22 v1(272.32,195.64) 272.29,195.6 R1108.2 R1114.1
FAN2_TACH_INT_INLET: length 6.1
  TOP w0.14: Q8.1 265.56,184.91 v1(265.56,184.91)
  BOTTOM w0.14: R1132.2 266.45,182.73 C1565.1 265.56,183.62 v2(265.56,183.9) v1(265.56,184.91) 265.56,185.14 Q10.3
FAN2_TACH_INT_INLET_N: length 3.9
  BOTTOM w0.14: C1563.2 266.79,188.77 R1134.1 268.06,188.18 v2(268.48,187.76) 269.24,187 R12994.2
FAN3_PRSNT_N: length 190.1
  TOP w0.14: U70.B13 v4(120.4,132.05) ; v1(278.26,195.66) 278.32,195.6 J5.17
  T14 w0.117: v1(278.26,195.66) 278.26,194.42 272.81,188.98 263.5,188.98 262.06,187.54 249.96,187.54 243.28,180.85 198.89,180.85 175.4,157.36 157.03,157.36 147.42,147.76 137.73,147.76 132.23,142.26 132.23,140.97 129.29,138.03 125.68,138.03 122.93,135.27 122.93,134.79 122.3,134.16 121.34,134.16 120.8,133.62 120.8,132.45 v4(120.4,132.05)
  BOTTOM w0.14: R1120.1 v1(278.26,195.66)
FAN3_PWM_CTRL: length 186.6
  TOP w0.14: J5.21 282.32,192.66 280.92,191.26 v1(279.78,191.26) ; R12952.2 v1(127.13,169.16) ; R12956.2 v1(128.78,182.63)
  T16 w0.117: v1(279.78,191.26) 275.84,191.26 274.83,190.25 273.05,190.25 272.26,191.04 263.83,191.04 262.89,191.97 256.87,191.97 253.78,188.88 166.85,188.88 162.68,184.71 151.6,184.71 145.81,190.5 139.74,190.5 137.79,188.55 134,188.55 128.78,183.33 v1(128.78,182.63) 128.78,181.61 129.41,180.97 129.41,179.2 130.05,178.56 130.05,175.13 129.1,174.19 129.1,171.13 130.23,169.99 130.23,169.06 129.35,168.18 127.68,168.18 127.13,168.72 v1(127.13,169.16)
FAN3_TACH_IN: length 13.8
  TOP w0.14: J5.19 v5(280.32,196.27)
  BOTTOM w0.14: C1580.1 280.25,187.63 C1583.1 280.78,191.37 281.94,192.53 281.94,194.26 281.81,194.39 R1115.1 R1109.2 280.29,196.24 v5(280.32,196.27)
FAN3_TACH_INT_INLET: length 12.4
  TOP w0.14: Q16.1 285.89,184.8 v1(285.85,184.76) 285.34,184.76 284.2,183.61 R1144.2 281.18,183.13 280.01,184.31 Q18.3 280.01,188.15 C1581.1
FAN3_TACH_INT_INLET_N: length 5.6
  TOP w0.14: R12995.2 v1(283.34,187.58)
  BOTTOM w0.14: C1580.2 280.35,185.72 R1146.1 282.3,185.72 283.34,186.76 v1(283.34,187.58)
FAN4_PRSNT_N: length 177.7
  TOP w0.14: U70.A10 v4(118,132.85) ; J5.2 261.48,199 v1(261.11,198.63)
  T14 w0.117: v1(261.11,198.63) 259.28,198.63 254.38,193.73 252.58,193.73 242.45,183.61 198.06,183.61 197.08,182.62 174.35,159.89 155.98,159.89 148.76,152.67 139,152.67 128.47,142.14 120.82,142.14 119.76,141.08 119.76,140.17 120.02,139.91 120.02,137.04 118.76,135.78 118.76,134.03 118,133.27 v4(118,132.85)
  BOTTOM w0.14: R1121.1 260.98,198.5 v1(261.11,198.63)
FAN4_PWM_CTRL: length 175.2
  TOP w0.14: J5.6 266.32,197.1 265.3,196.09 265.3,192.28 v1(263.14,190.12) ; R12957.2 v1(130.05,182.63) ; R12953.2 v1(125.86,169.04)
  T16 w0.117: v1(263.14,190.12) 259.04,190.12 257.39,188.46 167.02,188.46 162.85,184.29 151.42,184.29 147.58,188.13 134.18,188.13 130.05,184 v1(130.05,182.63) 130.05,181.64 130.72,180.97 130.72,179.54 131.24,179.02 131.24,175.56 130.37,174.69 130.37,170.93 131.5,169.8 131.5,169.06 130.2,167.75 127.14,167.75 v1(125.86,169.04)
  BOTTOM w0.14: v1(263.14,190.12) 263.14,190.35 v2(263.91,191.11)
FAN4_TACH_IN: length 29.5
  TOP w0.14: J5.4 v1(264.32,197.45)
  T18 w0.117: v1(264.32,197.45) 264.32,197.75 266.45,199.87 275.62,199.87 277.7,197.79 277.7,195.9 277.69,195.9 277.69,192.82 v1(278.36,192.15)
  BOTTOM w0.14: R1116.1 R1110.2 264.44,197.57 v1(264.32,197.45) ; v1(278.36,192.15) 277.54,191.32 276.87,191.32 276.27,190.73 C1566.1 276.27,189.04 C1560.1
FAN4_TACH_INT_INLET: length 7.6
  TOP w0.14: v1(276.57,184.63) 276.74,184.79 Q7.1
  BOTTOM w0.14: R1131.2 275.85,183.9 v1(276.57,184.63) 276.57,185.53 276.35,185.74 Q9.3 ; R1131.2 C1562.1 ; R1131.2 275.85,182.12 v2(276.23,181.74)
FAN4_TACH_INT_INLET_N: length 3.9
  BOTTOM w0.14: C1560.2 277.95,189.35 R1133.1 279.03,189.35 v2(279.7,188.68) 279.7,188.06 R12996.2
FAN5_PRSNT_N: length 186
  TOP w0.14: U70.A11 v4(118.8,132.85) ; J5.10 270.32,197.17 v1(269.98,196.83)
  T14 w0.117: v1(269.98,196.83) 269.98,196.57 268.46,195.05 263.32,195.05 261.16,192.89 252.93,192.89 242.8,182.76 198.41,182.76 197.92,182.27 174.7,159.05 156.33,159.05 149.11,151.83 139.39,151.83 127.67,140.11 122.05,140.11 121.52,140.11 120.86,139.46 120.86,136.41 121.08,136.19 121.08,135.13 v4(118.8,132.85)
  BOTTOM w0.14: R1122.1 269.92,196.89 v1(269.98,196.83) v2(268.86,196.83)
FAN5_PWM_CTRL: length 295.1
  TOP w0.14: v1(70.36,138.81) 70.1,138.56 65.79,138.56 65.15,137.92 65.15,136.53 64.39,135.76 63.37,135.76 61.85,134.24 61.85,131.7 61.99,131.56 U200.4 ; J5.14 274.32,197.57 v1(274.49,197.41)
  T05 w0.117: v1(89.31,204.29) 89.31,203.31 88.01,202.01 88.01,193.04 89.98,191.07 89.98,187.27 88.52,185.8 87.23,185.8 81.08,179.65 76.13,179.65 72.43,175.96 72.43,169.03 67.99,164.59 67.99,160.54 67.13,159.69 67.13,155.95 68.03,155.05 68.03,152.95 70.48,150.5 70.48,138.94 v1(70.36,138.81)
  T14 w0.117: v1(274.49,197.41) 262.49,209.4 251.74,209.4 248.53,212.6 220.48,212.6 219.7,211.83 215.71,211.83 214.94,212.6 190.77,212.6 181.4,203.23 159.64,203.23 158.57,204.29 122.24,204.29 122.06,204.47 100.78,204.47 99.5,203.19 93.6,203.19 92.82,203.98 89.62,203.98 v1(89.31,204.29)
FAN5_TACH_IN: length 16.8
  TOP w0.14: J5.12 272.32,197.91 v1(273.17,197.07)
  BOTTOM w0.14: R1117.1 R1111.2 273.1,197.14 v1(273.17,197.07) v2(274.57,195.66) 275.34,194.9 275.34,192.53 274.57,191.77 273.14,191.77 C1577.1 C1582.1
FAN5_TACH_INT_INLET: length 7.4
  TOP w0.14: Q15.1 271.9,184.78 v1(271.65,184.53)
  BOTTOM w0.14: v2(272.46,181.61) C1579.1 R1143.2 271.14,184.02 v1(271.65,184.53) 271.65,185.29 271.22,185.73 Q17.3
FAN5_TACH_INT_INLET_N: length 3.6
  BOTTOM w0.14: C1577.2 R1145.1 R12997.2 273.15,189.2 v2(273.3,189.36)
FAN45_TACH_SW: length 118
  TOP w0.14: v1(78.87,106.43) 78.97,106.32 R13086.1 ; U70.D11 v4(118.8,130.45) ; U177.6 v1(118.38,176.77)
  T03 w0.117: v4(118.8,130.45) 119.2,130.05 120.98,130.05 129.06,138.13 129.06,149.12 128.17,150.01 128.17,154.88 129.05,155.76 129.05,159.08 128.01,160.12 128.01,161.38 124.23,165.17 124.23,171.48 119.93,175.77 119.37,175.77 v1(118.38,176.77)
  T07 w0.117: v1(78.87,106.43) 78.87,106.44 79.74,107.3 85.46,107.3 87.36,109.21 87.36,110.63 94.14,117.41 107.69,117.41 107.85,117.56 107.86,117.56 111.82,121.52 113.81,121.52 114.61,122.33 114.61,126.91 115.36,127.65 119.05,127.65 119.2,127.81 119.2,129.02 119.2,129.02 119.2,130.06 v4(118.8,130.45)
  BOTTOM w0.14: 78.97,105.53 R12344.2 78.97,105.53 ; 78.97,105.53 78.97,106.33 v1(78.87,106.43)
FAN_BMC_CNTRL: length 157.6
  TOP w0.14: U154.A20 72.72,106.12 v4(73.28,106.68) ; R12960.2 v1(116.99,178.41) ; Q58.1 130.81,183.55 130.81,180.72 v1(131.32,180.21) U176.1 ; v1(63.88,135) 63.37,135 62.6,134.22 U200.6
  T05 w0.117: v1(116.99,178.41) 114.68,176.1 114.68,171.22 113.9,170.43 104.52,170.43 99.95,165.86 99.95,160.64 99.06,159.75 99.06,158.5 98.3,157.73 97.66,157.73 97.03,157.1 97.03,155.7 97.92,154.81 97.92,153.8 95.12,151 95.12,144.15 91.19,140.21 91.19,136.27 v1(90.42,135.51) 90.42,131.44 88.77,129.79 88.77,123.48 86.7,121.41 84.23,121.41 81.48,118.66 79.27,118.66 78.13,117.51 78.13,113.93 73.28,109.07 v4(73.28,106.68)
  T07 w0.117: v1(63.88,135) 63.88,136.4 65.66,138.18 71.41,138.18 72.64,136.95 86.31,136.95 87.76,135.51 v1(90.42,135.51)
  T18 w0.117: v1(116.99,178.41) 116.99,179.27 118.35,180.63 120.72,180.63 121.06,180.97 130.56,180.97 v1(131.32,180.21)
GNSS_ANT_ON: length 183.6
  TOP w0.14: U70.E10 v4(118,128.85) ; U124.14 v1(18.54,29.48)
  BOTTOM w0.102: v4(118,128.85) 117.6,128.45 115.26,128.45 115.16,128.35 114.45,128.35 114.35,128.46 113.85,128.46 113.6,128.2 113.6,122.22 112.85,121.48
  BOTTOM w0.14: 112.85,121.48 106.11,121.48 103.89,119.25 95.39,119.25 90.65,114.52 90.65,103.9 89.73,102.97 89.73,100.23 88.08,98.59 84.19,98.59 82.06,96.45 82.06,74.05 78.34,70.34 68.24,70.34 65.15,67.25 56.53,67.25 54.49,65.21 44.57,65.21 41.8,62.44 41.8,59.22 39.06,56.49 39.06,53.38 38.39,52.71 38.39,45.19 36.03,42.83 21.21,42.83 v2(20.44,42.06) 19.43,41.05 19.43,29.97 18.94,29.48 v1(18.54,29.48) 18.31,29.48 R13006.2
GNSS_ANT_OPEN: length 172.1
  TOP w0.14: U70.B2 v4(110.8,132.05)
  T03 w0.117: v1(11.81,37.34) 11.48,37.66 11.48,46.03 13.38,47.93 v1(13.38,48.85)
  BOTTOM w0.14: v1(11.81,37.34) R13008.1 10.88,35.87 U183.4 ; v1(13.38,48.85) v2(14.49,49.95) 17.37,52.83 28.45,52.83 31.23,55.61 37.15,55.61 40.81,59.27 40.81,62.7 44.2,66.09 54.15,66.09 56.14,68.07 64.69,68.07 67.58,70.96 77.94,70.96 81.41,74.44 81.41,96.74 83.92,99.25 87.72,99.25 89.02,100.56 89.02,103.26 90.05,104.28 90.05,114.88 108.56,133.39 110.3,133.39 110.8,132.88 v4(110.8,132.05)
GNSS_ANT_PWREN: length 179.5
  TOP w0.14: U70.A7 v4(115.6,132.85)
  T03 w0.117: v1(12.62,48.09) 11.11,46.58 11.11,37.07 v1(11.81,36.37)
  BOTTOM w0.14: v4(115.6,132.85) 115.31,133.15 115.31,134.2 114.86,134.65 v2(110.82,134.65) 109.33,134.65 89.7,115.03 89.7,104.43 88.67,103.4 88.67,100.7 87.57,99.6 83.78,99.6 81.06,96.89 81.06,74.58 77.79,71.31 67.38,71.31 64.5,68.43 55.84,68.43 53.93,66.53 44.02,66.53 40.31,62.81 40.31,59.29 37.07,56.06 28.62,56.06 27.52,54.95 23.67,54.95 22.31,53.59 17.02,53.59 12.64,49.21 12.64,48.1 v1(12.62,48.09) ; Q42.1 R13009.1 v1(11.81,36.37)
GNSS_ANT_SHORT_N: length 195.1
  TOP w0.14: U70.B1 v4(110,132.05)
  T18 w0.117: v1(9.45,24.82) 8.26,26.02 8.26,35.05 8.82,35.62 v1(9.34,35.62)
  BOTTOM w0.14: v4(110,132.05) 109.85,132.21 108.61,132.21 107.82,132.21 90.36,114.75 90.36,104.15 89.33,103.13 89.33,100.43 87.85,98.94 84.05,98.94 81.72,96.61 81.72,74.31 78.07,70.65 67.87,70.65 64.91,67.69 56.37,67.69 54.3,65.62 44.4,65.62 41.37,62.59 41.37,59.27 38.24,56.14 38.24,53.58 37.14,52.48 37.14,44.74 35.96,43.56 21.5,43.56 18.2,46.86 v2(12.43,46.86) 10.41,46.86 8.17,44.62 8.17,38.65 7.91,38.39 U183.3 v1(9.34,35.62)
  BOTTOM w0.381: L164.2 R1600.2 v1(9.45,24.82)
GNSS_RF_IN: length 2.3
  TOP w0.14: U124.11 v1(4.32,29.48)
  BOTTOM w0.14: C1990.1 v1(4.32,29.48)
GNSS_RF_RC: length 3.7
  BOTTOM w0.14: R1628.1 C1990.2
  BOTTOM w0.381: L164.1 5.9,25.72 v2(5.48,26.15) 5.1,26.52 R1628.1
GNSS_RF_SMA: length 19.7
  BOTTOM w0.14: R1628.2 4.32,25.15 5.41,24.06 D63.2 5.41,12.89 6,12.3 J10.1
HW_REV_ID0: length 6.1
  TOP w0.14: U150.16 106.51,176.63 107.12,176.02 107.44,176.02 v1(107.57,175.9) 107.8,175.66 R1745.2 108.28,175.21 108.43,175.06 108.43,173.33 108.03,172.93 R1744.2
HW_REV_ID1: length 5.7
  TOP w0.14: U150.15 105.86,176.33 v1(106.3,175.9) 106.3,175.45 R1747.2 107.01,175.21 107.16,175.06 107.16,173.33 106.76,172.93 R1746.2
HWM_FAN1_PRSNT_N: length 296.3
  TOP w0.14: U154.V6 v4(57.73,117.73) ; v1(132.59,202.82) 132.8,203.03 U178.1
  T18 w0.102: 53.39,121.03 54.48,121.03 54.68,120.84 54.68,120.45 54.93,120.2 54.93,119.95 55.15,119.73 55.47,119.73 55.73,119.47 55.73,118.36 55.98,118.12 57.33,118.12 v4(57.73,117.73)
  T18 w0.117: 53.39,121.03 52.74,121.68 52.74,122.2 52.74,132.17 54.23,133.66 54.23,159.77 62.74,168.28 62.74,173.7 66.31,177.27 66.31,179.57 70.14,183.4 70.14,185.22 71.91,186.98 72.43,186.98 75.63,190.18 78.51,190.18 81.32,192.99 86.01,192.99 86.91,193.89 86.91,195.41 88.37,196.86 105.81,196.86 106.18,197.23 120.1,197.23 121.4,198.52 126.98,198.52 127.44,198.98 128.75,198.98 v1(132.59,202.82) 132.72,202.95 137.16,202.95 137.72,203.51 162.68,203.51 165.9,200.28 165.9,192.7 169.28,189.32 186.04,189.32 187.19,188.17 259.92,188.17 261.04,189.28 261.04,190.3 261.59,190.85 v1(261.62,190.85)
  BOTTOM w0.14: R1118.2 R1124.2 260.73,191.77 261.62,190.88 v1(261.62,190.85)
HWM_FAN1_PWM_CTRL: length 23.6
  TOP w0.14: U73.17 126.82,190.71 v1(128.13,189.4) 128.24,189.29 R1013.2 ; v1(130.67,177.55) U176.2
  T05 w0.117: v1(130.67,177.55) 129.38,178.83 129.38,180.54 128.44,181.48 125.35,181.48 124.41,182.42 124.41,183.23 124.23,183.41 124.23,186.78 126.84,189.4 v1(128.13,189.4)
HWM_FAN1_TACH_IN: length 300.7
  TOP w0.14: U73.31 126.97,197.71 v1(127.48,198.21) ; U154.Y5 v4(56.13,118.53)
  T18 w0.102: 54.1,122.61 54.1,121.46 54.23,121.33 54.56,121.33 54.93,120.96 54.93,120.71 55.11,120.53 55.47,120.53 55.73,120.27 55.73,119.96 55.98,119.72 56.29,119.72 56.52,119.49 56.52,118.92 v4(56.13,118.53)
  T18 w0.117: v1(264.03,190.12) 261.66,187.74 187.01,187.74 185.86,188.9 169.1,188.9 165.48,192.52 165.48,200.11 162.5,203.09 137.9,203.09 133.31,198.5 127.76,198.5 v1(127.48,198.21) 127.48,197.51 129.03,195.95 129.03,194.52 128.28,193.77 126.92,193.77 124.99,191.84 115.29,191.84 113.95,190.5 103.26,190.5 102.69,191.07 93.52,191.07 93.18,191.41 87.65,191.41 83.24,187 83.24,185.27 82.28,184.31 78.02,184.31 77.34,183.64 74.56,183.64 71.72,180.81 71.72,177.87 66.24,172.39 66.24,167.09 63.49,164.34 60.07,164.34 55.2,159.47 55.2,150.38 56.64,148.93 56.64,139.63 55.28,138.27 55.28,136.07 55.8,135.55 55.8,132.93 54.1,131.24 54.1,122.61
  BOTTOM w0.14: v1(264.03,190.12) 265.3,191.39 v2(265.3,191.72) R1113.2
HWM_FAN1TO4_PRSNT_N: length 3.5
  TOP w0.14: U178.10 129.53,205.63 v1(129.67,205.49) 129.67,205.12 129.53,204.98 U178.11
HWM_FAN2_PRSNT_N: length 302.9
  TOP w0.102: U154.AA4 v4(55.33,119.33)
  TOP w0.14: U178.2 v1(135.38,203.68)
  T18 w0.102: v4(55.33,119.33) 55.04,119.33 54.66,119.71 54.66,120.03 54.56,120.13 54.11,120.13
  T18 w0.117: v1(270.18,192.41) 268.75,190.98 264.8,190.98 264.21,191.57 261.44,191.57 258.98,189.1 186.85,189.1 186.21,189.74 169.45,189.74 166.32,192.87 166.32,200.46 162.85,203.93 135.64,203.93 v1(135.38,203.68) 135.13,203.93 131.79,203.93 126.81,198.94 120.9,198.94 120.73,198.77 118.81,198.77 117.58,200 111.23,200 110.74,200.48 105.87,200.48 102.67,197.28 85.6,197.28 84.4,196.08 82.55,196.08 79.23,192.76 77.32,192.76 75.51,190.95 73.13,190.95 71.88,189.7 71.88,189.32 71.87,189.32 71.87,188.89 71.88,188.88 71.88,187.57 69.72,185.41 69.72,185.05 69.72,185.05 69.72,183.59 62.29,176.16 62.29,168.43 53.81,159.94 53.81,133.83 52.32,132.35 52.32,122.02 52.32,122.02 52.32,121.51 53.53,120.29 53.87,120.29 54.03,120.13 54.11,120.13
  BOTTOM w0.14: v1(270.18,192.41) 270.18,193.5 R1119.2 R1125.2
HWM_FAN2_PWM_CTRL: length 23.6
  TOP w0.14: R1014.2 127.83,190.56 127.82,190.56 v1(127.82,190.56) 127.17,191.21 U73.18 ; U176.4 v1(129.37,177.55)
  T05 w0.117: v1(127.82,190.56) 127.81,190.56 127.41,190.56 123.15,186.3 123.15,183.89 123.99,183.05 123.99,180.81 125.62,179.19 127.73,179.19 v1(129.37,177.55)
HWM_FAN2_TACH_IN: length 314
  TOP w0.14: v1(126.87,199.9) 125.93,198.95 U73.32 ; U154.AB3 v4(54.27,119.73)
  T16 w0.117: v1(273.3,192.66) 272.45,193.52 269.4,193.52 267.21,195.71 267.21,198.77 259.47,206.5 235.04,206.5 234.21,205.67 230.44,205.67 229.96,206.16 212.47,206.16 211.75,206.88 204.09,206.88 203.37,206.16 195.83,206.16 195.81,206.18 195.35,206.18 195.33,206.16 194.92,206.16 194.66,206.42 184.63,206.42 183.14,204.93 183.14,201.25 178.53,196.64 168.33,196.64 166.06,198.91 166.06,202.09 164.53,203.62 140.15,203.62 138.87,202.35 135.34,202.35 133.65,200.65 129.58,200.65 129.42,200.81 127.79,200.81 v1(126.87,199.9)
  T18 w0.117: v4(54.27,119.73) 54.02,119.73 53.87,119.87 53.36,119.87 51.9,121.33 51.9,121.85 51.9,132.52 53.39,134.01 53.39,160.12 61.87,168.6 61.87,176.34 67.72,182.18 67.72,186.92 72.17,191.37 75.33,191.37 77.15,193.18 79.05,193.18 82.37,196.5 84.23,196.5 85.5,197.78 102.41,197.78 105.53,200.9 110.92,200.9 111.37,200.46 117.73,200.46 119,199.19 120.55,199.19 120.73,199.37 126.47,199.37 126.87,199.77 v1(126.87,199.9)
  BOTTOM w0.14: v2(274.35,192.94) 273.94,192.53 273.43,192.53 v1(273.3,192.66) R1114.2
HWM_FAN3_PRSNT_N: length 338.5
  TOP w0.14: U154.W6 v4(56.93,117.73) ; U178.4 134.89,204.98 135.2,204.67 136.98,204.67 138.05,205.74 v1(138.05,206.88)
  T18 w0.102: v4(56.93,117.73) 56.53,117.33 55.01,117.33 54.61,117.73 53.9,117.73
  T18 w0.117: v1(276.99,192.28) 277.14,192.43 277.14,197.43 276.56,198.02 269.52,198.02 265.53,194.03 257.86,194.03 255.3,191.47 188.3,191.47 183.36,196.42 169.16,196.42 167.84,197.74 167.84,201.85 162.84,206.86 138.07,206.86 v1(138.05,206.88) 137.33,207.6 128.48,207.6 127,206.12 102.2,206.12 99.99,203.92 95.32,203.92 93.54,205.7 87.75,205.7 86.81,204.77 73.52,204.77 66.12,197.37 65.11,197.37 64.76,197.37 60.71,193.32 60.71,183.53 59.97,182.79 59.97,175.31 55.74,171.08 55.74,169.21 51.28,164.75 51.28,136.28 49.79,134.79 48.85,133.85 48.85,130.85 47.58,129.59 47.58,127.57 49.66,125.5 49.66,120.4 52.35,117.7 53.87,117.7 53.9,117.73
  BOTTOM w0.14: v1(276.99,192.28) 277.14,192.43 277.14,192.9 277.83,193.58 R1120.2 R1126.2
HWM_FAN3_PWM_CTRL: length 25.6
  TOP w0.14: U73.19 127.7,191.71 v1(128.02,192.02) 128.66,192.02 R1015.2 ; U176.6 v1(128.07,177.55)
  T05 w0.117: v1(128.02,192.02) 127.65,192.02 124.78,189.15 124.1,189.15 123.47,188.52 123.47,187.22 121.83,185.59 121.83,184.62 123.57,182.88 123.57,180.64 125.44,178.77 126.85,178.77 v1(128.07,177.55)
HWM_FAN3_TACH_IN: length 328.1
  TOP w0.14: U154.AA5 v4(55.33,118.53) ; U73.42 v1(120.62,200.01)
  T16 w0.117: v1(120.62,200.01) 120.62,202.3 121.69,203.38 129.36,203.38 131.04,201.7 133.91,201.7 134.98,202.77 138.18,202.77 139.72,204.32 164.9,204.32 166.48,202.73 166.48,199.09 168.51,197.06 178.36,197.06 182.72,201.43 182.72,205.1 184.45,206.84 194.84,206.84 195.08,206.6 195.99,206.6 196.01,206.58 202.9,206.58 203.71,207.39 211.96,207.39 212.77,206.58 230.13,206.58 230.62,206.1 234.04,206.1 235.84,207.9 250.57,207.9 251.46,207.01 259.56,207.01 269.11,197.46 269.11,195.45 270.63,193.94 279.9,193.94 280.67,193.17 v1(280.67,192.41)
  T18 w0.117: v4(55.33,118.53) 54.53,119.33 54,119.33 53.87,119.45 53.11,119.45 51.48,121.08 51.48,121.67 51.48,134.1 52.96,135.58 52.96,160.29 61.45,168.78 61.45,176.51 67.29,182.36 67.29,187.09 72,191.8 75.17,191.8 76.97,193.6 78.88,193.6 82.2,196.93 83.9,196.93 89.22,202.24 89.22,202.24 90.17,203.19 92.44,203.19 93.73,201.89 105.12,201.89 105.31,202.09 119.41,202.09 120.62,200.88 v1(120.62,200.01)
  BOTTOM w0.14: R1115.2 281.3,193.04 v1(280.67,192.41)
HWM_FAN4_PRSNT_N: length 303.5
  TOP w0.14: U154.AB4 v4(54.27,118.93) ; U178.5 135.1,205.63 v1(135.38,205.34)
  T18 w0.117: v1(256.79,190.75) 256.25,190.21 169.58,190.21 166.88,192.91 166.88,200.66 162.2,205.34 v1(135.38,205.34) 134.61,204.57 102.36,204.57 100.86,203.07 94.58,203.07 93.35,204.3 93.34,204.3 92.78,204.86 88.09,204.86 87.16,203.93 74.52,203.93 61.72,191.13 61.72,184.47 62.89,183.3 62.89,181.69 60.87,179.67 60.87,175.02 57.55,171.7 57.55,168.93 52.54,163.92 52.54,135.76 51.68,134.9 51.05,134.27 51.05,121.5 51.05,120.9 52.93,119.03 54.17,119.03 v4(54.27,118.93)
  BOTTOM w0.14: v1(256.79,190.75) 259.84,193.8 R1127.2 R1121.2
HWM_FAN4_PWM_CTRL: length 139.6
  TOP w0.14: v1(123.32,171.17) 123.32,173.8 126.77,177.25 v1(126.77,177.55) U176.8 ; R1016.2 128.72,193.23 127.85,193.23 v1(127.77,193.15) 126.83,192.21 U73.20 ; v1(66.17,133.22) 66.17,131.32 65.66,130.81 61.85,130.81 61.1,131.56 U200.3
  T05 w0.117: v1(127.77,193.15) 127.77,192.74 124.62,189.58 122.78,189.58 121.79,188.59 121.79,186.74 120.61,185.56 120.61,184.57 121.79,183.39 121.79,181.68 125.14,178.33 125.98,178.33 v1(126.77,177.55)
  T18 w0.117: v1(66.17,133.22) 66.17,134.49 62.23,138.43 62.23,148.18 60.2,150.21 60.2,156.08 61.21,157.1 61.21,158.71 68.5,165.99 71.63,165.99 75.92,170.28 86.56,170.28 87.72,171.45 101.47,171.45 102.2,170.72 122.87,170.72 v1(123.32,171.17)
HWM_FAN4_TACH_IN: length 287.6
  TOP w0.14: v1(117.73,173.78) 118.72,174.77 U177.1 ; U154.V7 v4(57.73,116.93)
  T16 w0.117: v1(266.32,195.89) 264.15,193.73 256.46,193.73 252.89,190.15 166.32,190.15 162.15,185.98 152.12,185.98 146.94,191.16 146.94,192.02 145.29,193.68 143.3,193.68 142.42,192.79 138.28,192.79 135.31,189.82 133.38,189.82 130.9,187.34 128.67,187.34 127.25,185.93 127.25,184.56 125.89,183.19 125.88,183.19 125.54,182.86 125.54,182.85 123.97,181.27 123.97,174.66 122.61,173.29 118.21,173.29 v1(117.73,173.78)
  T18 w0.117: v4(57.73,116.93) 58.93,118.13 58.93,121.41 59.61,122.1 59.61,122.68 60.45,123.52 60.45,129.54 61.72,130.81 61.72,134.37 61.34,134.75 61.34,147.82 59.43,149.73 59.43,159.44 60.77,160.78 61.92,160.78 62.27,160.78 70.53,169.04 70.53,170.73 72.01,172.21 72.01,172.72 74.29,175 75.72,175 75.78,175.06 84.47,175.06 85.41,174.12 94.33,174.12 94.94,174.74 98.32,174.74 99.03,174.02 103.46,174.02 103.75,174.31 111.72,174.31 113.24,172.79 116.74,172.79 v1(117.73,173.78)
  BOTTOM w0.14: R1116.2 v1(266.32,195.89) 266.32,194.95 v2(266.57,194.69)
HWM_FAN5_PRSNT_N: length 318
  TOP w0.14: v1(126.49,205.49) 127.28,206.28 U178.9 ; U154.Y6 v4(56.13,117.73)
  T18 w0.102: 53.35,118.55 53.87,118.55 53.89,118.53 54.57,118.53 54.98,118.12 55.49,118.12 55.88,117.73 v4(56.13,117.73)
  T18 w0.117: v1(270.87,196.93) 270.87,196.92 270.21,196.27 270.15,196.27 267.49,193.61 258.53,193.61 255.97,191.05 187.53,191.05 182.59,196 168.99,196 167.41,197.57 167.41,201.09 162.26,206.25 128.4,206.25 127.64,205.49 v1(126.49,205.49) 102.16,205.49 100.17,203.49 95,203.49 93.22,205.28 87.92,205.28 86.99,204.35 73.7,204.35 66.3,196.95 64.94,196.95 61.21,193.23 61.21,183.44 60.39,182.62 60.39,175.14 57.13,171.87 57.13,169.11 52.12,164.1 52.12,135.93 51.87,135.69 50.63,134.45 50.63,134.44 49.69,133.5 49.69,126.67 50.57,125.8 50.57,120.68 52.7,118.55 53.35,118.55
  BOTTOM w0.14: v2(270.23,200.36) 270.73,199.85 R1128.2 R1122.2 270.73,197.07 v1(270.87,196.93)
HWM_FAN5_TACH_IN: length 345.1
  TOP w0.14: U154.AB5 v4(54.27,118.13) ; v1(115.64,174.06) 115.7,174.01 115.7,173.99 116.59,173.1 119.96,173.1 120.54,173.67 U177.3
  T03 w0.117: v1(56.35,169.13) 63.72,169.13 64.88,170.29 73.07,170.29 73.69,170.9 73.69,172.24 76.09,174.64 80.95,174.64 81.4,175.09 83.78,175.09 86.96,171.92 103.01,171.92 103.75,172.66 114.24,172.66 v1(115.64,174.06)
  T16 w0.117: v1(115.64,174.06) 116.08,174.5 116.08,179.75 119.13,182.8 119.13,185.67 120.78,187.32 120.78,188.98 122.34,190.54 122.34,191.17 122.67,191.5 123.3,191.5 123.83,192.02 124.63,192.02 125.43,192.83 125.43,196.86 123.2,199.09 119.05,199.09 118.56,199.58 118.56,201.24 122.06,204.74 165.16,204.74 166.9,203 166.9,199.26 168.68,197.49 178.18,197.49 182.3,201.6 182.3,205.28 184.66,207.64 194.95,207.64 195.45,207.14 200.15,207.14 200.91,207.9 203.85,207.9 206.78,210.82 214.75,210.82 216.92,208.66 218.31,208.66 219.97,207.01 230.3,207.01 230.79,206.52 233.82,206.52 235.71,208.41 250.95,208.41 251.59,209.04 258.31,209.04 268.98,198.37 271.03,198.37 v1(271.4,198.74)
  T18 w0.117: v1(56.35,169.13) 51.7,164.48 51.7,136.11 50.21,134.62 49.27,133.68 49.27,130.68 49.02,130.43 48.01,129.41 48.01,127.76 50.15,125.62 50.15,120.5 52.52,118.13 v4(54.27,118.13)
  BOTTOM w0.14: R1117.2 271.65,198.99 v1(271.4,198.74) 271.4,200 v2(271.7,200.3)
HWM_FAN12_PRSNT_N: length 6.1
  TOP w0.14: U178.13 v1(130.3,203.68) 130.91,203.68 131.56,204.33 U178.3
HWM_FAN34_PRSNT_N: length 6.6
  TOP w0.14: U178.6 132.74,206.28 v1(132.08,205.61) 130.79,204.33 U178.12
HWM_FAN45_TACH_IN: length 36.3
  TOP w0.14: v1(121.53,200.09) 121.12,199.68 U73.41 ; v1(117.22,176.15) 117.6,175.77 120.14,175.77 120.54,176.16 U177.4
  T16 w0.117: v1(117.22,176.15) 117.22,177.47 121.65,181.89 121.65,187.12 121.2,187.57 121.2,188.43 123.59,190.82 123.59,191.04 124.15,191.6 124.8,191.6 125.85,192.65 125.85,197.03 123.37,199.51 122.1,199.51 v1(121.53,200.09)
HWM_FAN_PRSNT_N: length 10.5
  TOP w0.14: U73.35 124.12,204.51 126.54,206.93 v1(126.75,206.93) U178.8
HWM_JTAG_TRCK: length 3.8
  TOP w0.14: U73.10 122.12,188.15 v1(122.81,187.46) 123.25,187.03 R1031.2
HWM_JTAG_TRST_N: length 2.2
  TOP w0.14: U73.40 121.62,199.01 v1(121.62,197.94)
  BOTTOM w0.14: v1(121.62,197.94) 121.74,198.06 R1032.2
HWM_P1V8_BPCAP: length 3.5
  TOP w0.14: v1(118.09,198.07) 118.12,198.1 118.12,199.01 U73.47
  BOTTOM w0.14: C2442.1 C1411.1 117.41,197.39 v1(118.09,198.07)
HWM_P3V3_BMC_EN: length 70.4
  TOP w0.14: v1(121.29,201.24) 122.07,200.45 122.07,199.06 U73.39 ; R12970.2 v1(61.59,203.63)
  T03 w0.117: v1(61.59,203.63) 63,203.63 70.04,210.68 74.31,210.68 76.33,208.66 82.04,208.66 82.46,209.07 88.45,209.07 95.42,202.11 120.42,202.11 v1(121.29,201.24)
I2C0_HWM_MUX_SEL: length 112
  TOP w0.14: U70.K10 v4(118,124.85)
  T14 w0.117: v1(46.86,81.28) 45.94,80.35 44.55,80.35 43.89,81.01 43.89,85.71 45.48,87.29 47.41,87.29 v1(49.53,89.41)
  T16 w0.102: v4(118,124.85) 118.4,124.46 118.95,124.46 119.2,124.22 119.2,121.88
  T16 w0.117: v1(49.53,89.41) 50.44,90.32 61.05,90.32 63.64,92.91 69.36,92.91 70.87,94.42 70.87,95.89 72.12,97.14 78.5,97.14 79.65,98.3 88.03,98.3 88.52,98.79 95.78,106.05 101.79,106.05 104.75,109.01 104.75,111.36 106.78,113.39 110.68,113.39 115.95,118.66 118.02,118.66 119.2,119.83 119.2,121.88
  BOTTOM w0.14: v1(46.86,81.28) 47.13,81.55 U156.6 R12705.1 R12471.1 ; U173.6 49.01,88.12 49.53,88.65 v1(49.53,89.41)
I2C0_HWM_SCL: length 569.9
  TOP w0.14: R1035.1 126.21,185.8 v1(126.56,185.45) ; v1(282.7,197.36) 282.32,197.74 J5.22 ; R1043.1 224.26,176.76 v1(224.54,177.04)
  T05 w0.117: v1(282.7,197.36) 283.34,197.36 284.99,199.01 284.99,203 273.74,214.25 213.2,214.25 211.71,212.76 189.35,212.76 179.75,203.15 152.63,203.15 151.75,204.03 137.45,204.03 135.18,201.76 135.18,196.89 134.12,195.83 132.29,195.83 131.32,194.86 131.32,192.62 129.09,190.4 129.09,189.21 128.45,188.57 127.39,188.57 126.91,188.09 126.91,186.72 126.56,186.36 v1(126.56,185.45) ; v1(113.36,184.97) 112.79,184.4 112.79,182.73 112.97,182.56 112.97,177.36 110.24,174.62 103.25,174.62 102.61,173.99 99.69,173.99 98.67,172.97 98.67,170.04 96.14,167.51 93.47,167.51 88.14,162.18 88.14,160.27 87,159.13 87,156.08 85.98,155.07 85.98,153.29 87.12,152.15 87.12,141.09 86.11,140.08 86.11,138.68 84.07,136.65 84.07,133.52 83.17,132.61 v1(83.17,128.62)
  T07 w0.117: v4(129.21,96.36) 127.71,94.85 121.14,94.85 117.86,91.57 117.86,89.53 116.97,88.65 111.93,88.65 109.88,86.6 103.83,86.6 102.27,85.03 101.08,85.03 99.39,86.72 92.86,86.72 91.37,88.2 89.81,88.2 87.8,90.22 87.8,90.73 86.32,92.21 82.95,92.21 82.54,91.8 62.35,91.8 53.98,83.42 50.81,83.42 50.17,82.78 v1(50.17,81.55)
  T14 w0.117: v1(282.7,197.36) 283.34,197.36 284.1,198.12 286.26,198.12 289.01,195.37 289.01,189.44 284.61,185.04 284.61,184.41 281.15,180.95 259.92,180.95 256.8,184.08 250.89,184.08 244.56,177.75 225.25,177.75 v1(224.54,177.04)
  T16 w0.117: v1(83.17,128.62) 83.73,128.06 83.73,125.01 82.57,123.84 80.88,123.84 80.41,124.32 80.41,124.82 80.01,125.22 74.8,125.22 73.34,123.75 v1(70.67,123.75)
  T18 w0.117: v1(126.56,185.45) 125.57,184.46 114.12,184.46 113.6,184.97 v1(113.36,184.97) ; v1(50.17,81.55) 52.98,78.74 62.48,78.74 63.46,77.76 72.05,77.76 72.64,78.36 72.64,80.01 76.31,83.67 76.31,86.74 78.49,88.92 78.49,91.9 81.35,94.76 81.35,99.84 82.29,100.79 82.29,116.38 81.2,117.47 78.49,117.47 78.36,117.6 75.69,117.6 74.68,118.62 74.68,122.3 73.22,123.75 v1(70.67,123.75)
  BOTTOM w0.14: v4(129.21,96.36) 129.42,96.15 U74.2 ; v1(70.67,123.75) 70.62,123.7 70.6,123.7 69.9,122.99 U185.2 ; U156.4 v1(50.17,81.55)
I2C0_HWM_SDA: length 564.3
  TOP w0.14: v1(128.03,185.42) 127.48,185.96 R1036.1 ; R1044.1 226.97,176.78 v1(227.2,177.01) ; J5.24 v1(284.32,201.04)
  T05 w0.117: v1(83.97,129.08) 84.84,129.94 84.84,136.4 88.01,139.57 88.01,141.86 87.69,142.18 87.69,149.57 89.92,151.79 89.92,155.47 88.9,156.49 88.9,159.51 89.92,160.53 89.92,162.69 93.6,166.37 96.06,166.37 101.01,171.32 101.99,171.32 103.58,172.92 112.47,172.92 113.54,173.99 113.54,183.75 v1(113.41,183.89) ; v1(128.03,185.42) 128.03,186.03 129.67,187.67 129.67,190.16 135.76,196.26 135.76,201.42 137.79,203.45 151.51,203.45 152.39,202.58 180.12,202.58 189.73,212.18 211.95,212.18 213.44,213.67 273.44,213.67 284.32,202.8 v1(284.32,201.04)
  T07 w0.117: v1(50.9,82.42) 51.28,82.8 58.11,82.8 59.44,84.13 59.44,87.81 62.88,91.26 70.67,91.26 72.15,89.78 78.68,89.78 82.94,85.52 90.35,85.52 90.97,86.15 99.15,86.15 100.84,84.45 102.49,84.45 104.21,86.17 110.06,86.17 111.09,87.2 112.99,87.2 113.54,87.76 115.19,87.76 115.82,87.12 117.22,87.12 118.49,88.39 118.49,91.61 120.74,93.85 127.71,93.85 v4(130.21,96.36)
  T14 w0.117: v1(227.2,177.01) 244.64,177.01 251.07,183.44 256.61,183.44 259.61,180.44 281.24,180.44 285.08,184.28 285.08,184.9 289.43,189.26 289.43,195.93 v1(284.32,201.04)
  T16 w0.117: v1(83.97,129.08) 84.71,128.34 84.71,125.09 83.06,123.44 83.06,122.94 81.66,121.54 79.63,121.54 79.12,122.05 75.57,122.05 74.64,122.98 v1(70.7,122.98)
  T18 w0.117: v1(70.7,122.98) 72.86,122.98 74.24,121.6 74.24,116.9 75.09,116.05 80.69,116.05 81.72,115.02 81.72,101.02 80.77,100.08 80.77,95 77.85,92.08 77.85,89.25 74.3,85.7 74.3,83.69 70.24,79.63 65.66,79.63 64.68,80.6 52.72,80.6 v1(50.9,82.42) ; v1(113.41,183.89) 126.49,183.89 v1(128.03,185.42)
  BOTTOM w0.14: v1(50.9,82.42) 50.9,82.4 49.73,83.57 49.73,86.2 48.79,87.14 47.48,87.14 47.1,87.52 U173.4 ; v1(70.7,122.98) 70.06,122.34 U185.1 ; v4(130.21,96.36) 130.07,96.22 U74.1
I2C0_MGMT_MUX_SEL: length 97.6
  TOP w0.14: U172.6 78.6,171.59 78.95,171.24 80.75,171.24 81.27,171.75 U165.6 81.27,173.24 v1(81.11,173.39) ; U70.B6 v4(114,132.05)
  T14 w0.117: v1(121.24,171.51) 122.07,170.67 122.07,160.27 123.16,159.18 123.16,158.44 124.83,156.77 124.83,155.34 124,154.51 124,149.1 120.96,146.06 120.96,144.78 113.95,137.77 113.95,133.51 114.4,133.05 114.4,132.45 v4(114,132.05)
  T16 w0.117: v1(81.11,173.39) 81.29,173.22 81.29,171.29 82.35,170.23 89.71,170.23 89.89,170.41 91.21,170.41 91.24,170.38 92.97,170.38 93.07,170.48 94.38,170.48 94.48,170.38 120.11,170.38 v1(121.24,171.51)
  BOTTOM w0.14: R12487.1 R12704.1 81.1,172.28 81.34,172.52 81.34,173.17 v1(81.11,173.39)
I2C0_MISC_SCL: length 140.8
  TOP w0.14: U67.12 89.23,186.76 90.11,187.65 91.37,187.65 v1(91.57,187.85) 91.93,188.21 95.89,188.21 97.15,186.95 v1(97.15,185.89) 96.84,185.57 U81.6 ; R50.1 176.55,120.64 v1(175.9,120.64)
  T03 w0.117: v1(175.9,120.64) 174.72,120.64 174.31,121.05 174.31,127.55 170.69,131.18 170.69,146.23 153.68,163.24 131.66,163.24 126.49,168.4 126.49,173.03 126.13,173.4 126.13,174.99 124.4,176.71 120.34,176.71 119.21,177.84 115.74,177.84 110.92,182.67 97.2,182.67 96.26,183.61 96.26,185.25 96.89,185.89 v1(97.15,185.89)
  BOTTOM w0.14: v1(91.57,187.85) R952.1
I2C0_MISC_SDA: length 136.8
  TOP w0.14: U67.11 89.88,186.78 90.28,187.18 92.39,187.18 v1(92.84,187.64) 95.77,187.64 96.07,187.33 v1(96.07,187.07) 95.58,186.58 U81.5 ; R51.1 176.23,119.93 v1(175.01,119.93)
  T03 w0.117: v1(175.01,119.93) 174.83,119.93 173.84,120.92 173.84,125.5 170.26,129.07 170.26,146.06 153.51,162.81 130.81,162.81 124.84,168.78 124.84,174.37 122.92,176.29 120.17,176.29 119.04,177.42 115.57,177.42 110.74,182.25 97.38,182.25 97.03,182.24 95.84,183.44 95.84,185.43 96.07,185.66 v1(96.07,187.07)
  BOTTOM w0.14: R953.1 92.58,187.38 v1(92.84,187.64)
I2C0_PCH_SCL: length 44.5
  TOP w0.14: v1(70.87,172.09) 70.87,170.94 69.22,169.29 69.22,167.51 67.94,166.24 67.94,160.33 67.25,159.64 67.25,157.24 J1.B5 ; U71.3 90.36,176.59 v1(90.55,176.78)
  T03 w0.117: v1(70.87,172.09) 74.32,175.53 80.54,175.53 82.94,177.94 84.59,177.94 85.23,177.29 88.75,177.29 89.26,176.78 v1(90.55,176.78)
  BOTTOM w0.14: R1754.2 88.09,176.56 R1985.2 90.32,176.56 v1(90.55,176.78)
I2C0_PCH_SDA: length 38.2
  TOP w0.14: v1(73.41,173.23) 72.01,171.83 R1755.2 72.01,170.9 71.59,170.9 69.84,169.15 69.84,160.07 69.04,159.27 J1.B6 ; v1(86.36,176.53) 86.3,176.59 U71.6
  T03 w0.117: v1(73.41,173.23) 75.24,175.06 80.78,175.06 81.23,175.51 85.34,175.51 v1(86.36,176.53)
  BOTTOM w0.14: R1986.2 86.11,176.28 v1(86.36,176.53)
I2C0_PSU1_SCL: length 89.4
  TOP w0.14: U67.7 90.53,181.07 91.16,181.7 v1(91.31,181.7)
  T07 w0.117: v1(29.44,204.94) 28.32,206.05 25.54,206.05 CN3.A2
  T14 w0.117: v1(91.31,181.7) 90.84,181.23 90.05,181.23 89.86,181.41 89.86,181.8 89.41,182.25 85.16,182.25 82.84,179.93 71.75,179.93 69.9,181.78 64.31,181.78 53.66,192.43 53.66,193.73 48.64,198.75 38.61,198.75 37.59,197.74 v1(35.81,197.74)
  BOTTOM w0.14: v1(35.81,197.74) C1594.1 36.55,199.23 D54.2 31.24,199.26 29.44,201.06 v1(29.44,204.94) ; R948.1 91.44,181.58 v1(91.31,181.7)
I2C0_PSU1_SDA: length 89.6
  TOP w0.14: U67.6 89.88,181.24 v1(90.42,181.79)
  T14 w0.117: v1(90.42,181.79) 90.42,181.86 89.62,182.67 84.99,182.67 82.79,180.47 71.8,180.47 69.56,182.71 67.74,182.71 66.42,184.02 65.33,184.02 64.66,183.36 63.46,183.36 54.86,191.95 54.86,194.31 54.18,194.99 54.18,200.58 53.6,201.16 47.76,201.16 44.51,204.41 37.65,204.41 35.15,206.91 v1(34.14,206.91)
  BOTTOM w0.14: v1(90.42,181.79) R949.1 ; v1(34.14,206.91) C1593.1 33.24,206.94 D55.2 30.62,206.07 23.24,206.07 22.53,205.36 CN3.B3
I2C0_PSU2_SCL: length 92
  TOP w0.14: v1(89.28,181.54) 89.23,181.48 U67.5
  T05 w0.117: v1(40.75,198) 40.75,198.06 40.01,198.8 40.01,203.07 v1(38.1,204.98)
  T14 w0.117: v1(34.67,204.54) 33.17,206.04 20.13,206.04 19.56,205.47 19.56,204.09 CN3.C5 ; v1(89.28,181.54) 88.27,180.53 84.59,180.53 83.38,179.32 71.75,179.32 69.72,181.36 64.01,181.36 55.63,189.74 54.45,189.74 54.44,189.75 54.02,189.75 54.01,189.74 45.59,189.74 40.75,194.58 v1(40.75,198)
  BOTTOM w0.14: v1(89.28,181.54) 89.41,181.67 R946.1 ; v1(38.1,204.98) 37.69,204.57 C1600.1 37.05,204.54 D52.2 v1(34.67,204.54)
I2C0_PSU2_SDA: length 97.5
  TOP w0.14: U67.4 88.57,179.18 v1(88.39,179)
  T05 w0.117: v1(31.95,194.18) 31.95,197.05 v1(35.81,200.91)
  T07 w0.117: v1(31.95,194.18) 31.95,193.73 34.32,191.36 36.75,191.36 36.97,191.57 44.65,191.57 48.77,187.45 52.32,187.45 52.96,188.09 54.23,188.09 54.52,187.8 60.11,187.8 60.77,187.14 69.66,187.14 70.36,186.44 70.36,183.16 73.88,179.64 87.75,179.64 v1(88.39,179)
  T14 w0.117: v1(36.2,203.58) 35.81,203.96 34.42,203.96 33.91,204.47 31.37,204.47 30.92,204.02 26.95,204.02 26.93,204.04 21.5,204.04 CN3.C4
  BOTTOM w0.14: v1(35.81,200.91) C1599.1 36.55,202.66 D53.2 36.52,203.26 v1(36.2,203.58) ; v1(88.39,179) 88.39,179.83 88.86,180.29 R947.1
I2C0_PWR_SCL: length 19.1
  TOP w0.14: U67.10 90.53,184.74 v1(90.93,184.34)
  T07 w0.117: v5(100.56,189.79) 99.57,188.81 91.69,188.81 90.93,188.05 v1(90.93,184.34)
  BOTTOM w0.14: R950.1 v1(90.93,184.34) ; R744.2 100.68,189.92 v5(100.56,189.79)
I2C0_PWR_SDA: length 18.1
  TOP w0.14: v1(91.95,184.34) 91.8,184.34 91.18,184.96 U67.9
  T07 w0.117: v5(101.95,189.79) 100.41,188.25 94.91,188.25 91.95,185.29 v1(91.95,184.34)
  BOTTOM w0.14: R951.1 v1(91.95,184.34) ; R749.2 101.83,189.92 v5(101.95,189.79)
I2C0_SYS_SCL: length 367.2
  TOP w0.14: U111.1 83,125.36 82.12,126.24 79.88,126.24 v1(78.61,127.51) ; v1(81.15,169.22) 81.27,169.33 U165.1 ; U71.2 90.1,175.94 v1(90.56,175.49) ; R1997.2 v1(133.95,178.56)
  T05 w0.117: v1(68.33,171.07) 68.03,170.78 64.95,170.78 62.19,168.02 62.19,162.94 58.81,159.56 58.81,150.82 58.22,150.24 58.22,135.2 v1(58.67,134.75)
  T07 w0.117: v1(78.61,127.51) 78.61,132.25 76.7,134.16 68.12,134.16 66.1,132.14 61.66,132.14 59.63,134.17 59.25,134.17 v1(58.67,134.75)
  T14 w0.117: v1(68.33,171.07) 68.33,170.81 68.83,170.31 73.33,170.31 74.98,168.66 79.38,168.66 79.66,168.95 80.88,168.95 v1(81.15,169.22) 81.15,169.5 81.67,170.01 87.28,170.01 89.44,172.18 89.44,174.37 v1(90.56,175.49) ; v1(78.61,127.51) 78.61,126.06 76.64,124.09 75.38,124.09 74.63,123.34 74.63,121.15 74.07,120.59 74.07,106.41 70.55,102.89 66.43,102.89 63.31,99.77 63.31,98.03 64.36,96.99 64.36,93.28 59.93,88.84 53.81,88.84 51.38,86.41 51.38,84.04 49.38,82.04 48.31,82.04 47,83.35 v1(47,83.73)
  T16 w0.117: v1(47,83.73) 47.24,83.49 49.46,83.49 49.73,83.23 51.33,83.23 53.73,80.83 56.77,80.83 58.29,79.31 61.55,79.31 62.95,77.92 62.95,75.8 67.85,70.89 79.12,70.89 81.09,68.93 81.09,62.44 76.89,58.24 75.09,58.24 73.97,57.13 72.98,57.13 70.43,54.58 69.34,54.58 68.37,53.6 68.37,52.53 68.36,52.52 68.36,47.86 67.57,47.07 67.57,37.28 69.14,35.7 76.44,35.7 78.18,33.96 78.18,23.68 83.66,18.2 89.71,18.2 95.59,12.31 v1(97.81,12.31)
  BOTTOM w0.14: v1(47,83.73) 47.18,83.55 U156.1 ; v1(133.95,178.56) 134.62,179.23 134.62,179.83 134.24,180.21 132.97,180.21 131.89,179.14 125.29,179.14 123.51,177.36 121.35,177.36 119.32,175.33 116.01,175.33 113.72,177.61 100.4,177.61 98.11,175.33 93.79,175.33 92.96,174.5 91.54,174.5 v1(90.56,175.49) 90.3,175.74 R1985.1 88.09,175.74 R1982.1 ; R971.2 102.29,6.38 101.03,6.38 100.27,7.14 100.27,9.85 v1(97.81,12.31)
I2C0_SYS_SDA: length 369.7
  TOP w0.14: U71.7 85.68,175.94 v1(86.36,175.26) ; U172.1 78.6,169.46 v1(78.36,169.22) ; v1(79.25,128.4) 78.49,128.4 77.79,127.7 U112.1 ; R1996.2 v1(133.95,179.58)
  T05 w0.117: v1(69.22,170.87) 68.7,170.35 65.21,170.35 62.61,167.75 62.61,162.69 59.23,159.3 59.23,150.64 58.76,150.17 58.76,135.68 v1(59.69,134.75)
  T07 w0.117: v1(59.69,134.75) 60.87,134.75 62.52,133.1 64.13,133.1 65.62,134.58 77.03,134.58 79.25,132.36 v1(79.25,128.4)
  T14 w0.117: v1(79.25,128.4) 79.25,124.97 76.05,121.77 76.05,120.84 74.52,119.31 74.52,106.27 70.63,102.37 66.91,102.37 64.65,100.11 64.65,98.17 64.98,97.83 64.98,93.1 60.16,88.28 53.84,88.28 52.1,86.53 52.1,82.06 51.02,80.98 48.56,80.98 46.43,83.11 46.43,84.15 46.95,84.67 47.92,84.67 48.6,85.34 v1(48.77,85.34) ; v1(86.36,175.26) 86.67,175.57 87.79,175.57 89.02,174.34 89.02,172.35 87.11,170.44 79.57,170.44 v1(78.36,169.22) 77.67,169.22 76.58,170.31 74.22,170.31 73.66,170.87 v1(69.22,170.87)
  T16 w0.117: v1(48.77,85.34) 49.54,84.57 51.23,84.57 54.55,81.25 57.83,81.25 58.22,80.85 59.43,80.85 59.94,80.35 61.25,80.35 63.61,77.99 63.61,75.86 68.16,71.32 79.3,71.32 81.59,69.03 81.59,62.34 75.78,56.53 73.04,56.53 71.78,55.28 71.78,54.76 70.36,53.35 69.41,53.35 68.79,52.72 68.79,52.35 68.78,52.34 68.78,47.51 68.07,46.8 68.07,37.55 69.43,36.19 76.69,36.19 78.6,34.27 78.6,23.85 83.83,18.62 89.9,18.62 95.43,13.09 98.04,13.09 v1(99.14,11.98)
  BOTTOM w0.14: R1983.1 R1986.1 86.16,175.46 v1(86.36,175.26) 86.36,174.75 87.12,173.99 93.09,173.99 93.98,174.88 98.3,174.88 100.58,177.16 113.54,177.16 115.82,174.88 119.51,174.88 121.54,176.91 123.7,176.91 125.48,178.69 132.21,178.69 133.1,179.58 v1(133.95,179.58) ; U173.1 48.4,85.71 v1(48.77,85.34) ; v1(99.14,11.98) 99.14,11.65 100.72,10.07 100.72,7.35 101.11,6.96 R970.2
I2C1_BMC_ALRT_N: length 13.3
  TOP w0.14: U154.J21 v4(65.73,104.92)
  BOTTOM w0.102: 65.73,103.6 v4(65.73,104.92)
  BOTTOM w0.14: 65.73,103.6 66.8,102.52 v2(66.8,102.04) 67.69,101.15 67.69,100.08 67.28,99.66 67.28,97.52 R12328.2 68.24,97.11 68.95,96.41 U99.4
I2C1_BMC_SCL: length 41.8
  TOP w0.14: U154.K21 v4(64.93,104.92)
  T14 w0.117: v4(64.93,104.92) 64.93,102.65 62.07,99.79 62.07,91.79 60.07,89.79 54.16,89.79 49.04,84.67 v1(49.04,82.82)
  BOTTOM w0.102: 64.93,103.37 v4(64.93,104.92)
  BOTTOM w0.14: U156.3 v1(49.04,82.82) ; 64.93,103.37 65.8,102.5 65.8,99.15 65.26,98.6 v2(65.26,98.37) R12316.2
I2C1_BMC_SDA: length 36.3
  TOP w0.14: U154.K22 v4(64.53,103.85)
  T14 w0.117: v4(64.53,103.85) 64.53,103.43 60.77,99.67 60.77,96.59 61.61,95.75 61.61,91.92 59.9,90.21 51.39,90.21 46.86,85.69 v1(46.86,85.34)
  BOTTOM w0.14: R12317.2 65.26,101.9 v2(65.14,102.02) 65.14,102.47 64.53,103.08 v4(64.53,103.85) ; v1(46.86,85.34) 47.1,85.58 U173.3
I2C2_BMC_ALRT_N: length 128.8
  TOP w0.14: v1(50.29,101.06) R12329.2 48.59,101.06 v1(48.24,101.41) ; U154.J20 v4(65.73,105.72)
  T05 w0.117: v1(48.24,101.41) 46.91,101.41 45.58,102.74 42.9,102.74 38.23,107.42 38.23,124.72 38.57,125.05 40.31,125.05 41.91,126.66 41.91,128.16 47.86,134.11 49.82,134.11 51.39,135.69 51.39,167.83 46.99,172.23 v1(46.99,188.09)
  T07 w0.117: v4(65.73,105.72) 65.33,105.32 65.33,104.57 64.93,104.17 64.93,103.41 64.38,102.86 54.22,102.86 52.27,100.92 50.44,100.92 v1(50.29,101.06)
  BOTTOM w0.14: v1(46.99,188.09) 45.83,189.24 U102.4
I2C2_BMC_SCL: length 101.7
  TOP w0.102: R12318.2 66.55,97.64 v4(66.15,98.03)
  TOP w0.14: U154.J19 v4(65.73,106.52) ; U165.3 v1(82.56,168.14)
  T03 w0.117: v1(60.83,163.7) 61.4,164.27 71.05,164.27 74.18,167.4 81.83,167.4 v1(82.56,168.14)
  T14 w0.102: 60.53,121.2 60.53,115.65 60.2,115.32 60.2,112.14 61.41,110.93 62.67,110.93 64.52,109.09 64.52,107.18 64.78,106.92 65.33,106.92 v4(65.73,106.52)
  T14 w0.117: v1(60.83,163.7) 60.35,163.22 60.35,159.03 60.8,158.57 60.8,157.3 60.24,156.74 60.24,152.57 60.24,152.23 58.63,150.61 58.63,136.26 56.29,133.93 56.29,132.56 56.64,132.21 56.64,130.43 60.07,127 60.07,123.19 59.69,122.81 59.69,122.05 60.53,121.2
  T18 w0.102: 66.59,104.17 66.13,104.63 66.13,106.12 v4(65.73,106.52)
  T18 w0.117: v4(66.15,98.03) 66.45,98.03 66.89,98.47 66.89,103.87 66.59,104.17
I2C2_BMC_SDA: length 95.3
  TOP w0.102: v4(66.22,98.79) 65.89,98.79 65.28,98.17 R12319.2
  TOP w0.14: U172.3 79.9,168.29 v1(79.76,168.15) ; U154.J18 v4(65.73,107.32)
  T03 w0.117: v1(79.76,168.15) 79.43,167.82 74.01,167.82 71.6,165.41 61.78,165.41 v1(61.34,164.97)
  T14 w0.102: v4(65.73,107.32) 65.32,107.73 65.32,108.72 62.93,111.1 62.93,120.58 61.96,121.56 61.96,122.19
  T14 w0.117: 61.96,122.19 60.71,123.44 60.71,129.29 61.34,129.92 61.34,131.44 60.33,132.46 60.33,137.03 61.21,137.92 61.21,153.11 60.71,153.62 60.71,156.55 61.8,157.65 61.8,164.51 v1(61.34,164.97)
  T18 w0.102: 65.73,103.38 65.73,104.17 65.33,104.57 65.33,106.92 v4(65.73,107.32)
  T18 w0.117: 65.73,103.38 66.22,102.88 v4(66.22,98.79)
I2C2_PCH_SCL: length 9.6
  TOP w0.14: R12499.1 140.18,170.2 140.18,165.51 141.04,164.65 J1.A76
I2C2_PCH_SDA: length 11.5
  TOP w0.14: R12500.1 141.44,165.45 142.04,164.84 J1.A77
I2C3_BMC_SCL: length 16.4
  TOP w0.14: U111.3 82.23,122.49 81.03,121.28 77.65,121.28 v1(77.22,120.85) ; U154.D3 v4(69.73,120.13)
  BOTTOM w0.102: v4(69.73,120.13) 69.87,120.13 70.26,119.73 71.73,119.73
  BOTTOM w0.14: 71.73,119.73 71.95,119.95 75.81,119.95 76.71,120.85 v1(77.22,120.85) 78.07,120.85 R12320.2
I2C3_BMC_SDA: length 10.1
  TOP w0.14: U112.3 76.99,122.33 76.71,122.05 74.13,122.05 v1(73.41,121.32) ; U154.C2 v4(70.53,120.93)
  BOTTOM w0.14: v4(70.53,120.93) 71.01,121.41 71.63,121.41 72.01,121.03 73.12,121.03 v1(73.41,121.32) 73.78,121.32 R12321.2
I2C4_BMC_SCL: length 151.3
  TOP w0.14: R12322.2 74.38,126.35 v1(73.86,125.83) 73.86,124.25 U154.B1 ; R12499.2 v1(140.17,171.69) ; v1(86.08,128.04) 86.78,127.34 88.13,127.34 89.15,126.32 89.15,115.57 90.3,114.43 90.3,101.35 87.38,98.43 v1(87.38,97.36) 87.38,96.93 R1207.1
  T05 w0.117: v1(113.72,173.35) 112.85,172.49 103.76,172.49 102.08,170.81 101.09,170.81 95.64,165.35 93.98,165.35 92.08,163.45 92.08,160.4 93.09,159.38 93.09,156.21 93.83,155.47 93.83,153.87 90.17,150.22 90.17,139.62 88.86,138.31 88.86,135.85 85.47,132.46 85.47,128.65 v1(86.08,128.04)
  T07 w0.117: v1(73.86,125.83) 74.64,126.62 77.13,126.62 77.48,126.27 79.83,126.27 81.38,127.81 85.85,127.81 v1(86.08,128.04)
  T18 w0.117: v1(113.72,173.35) 115.33,174.97 120.11,174.97 121.21,173.86 134.98,173.86 136.36,172.48 139.32,172.48 140.11,171.69 v1(140.17,171.69)
I2C4_BMC_SDA: length 163.7
  TOP w0.14: R12500.2 v1(141.44,171.69) ; v1(86.87,116.71) 89.79,113.79 89.79,108.58 88.39,107.19 83.57,107.19 82.8,106.43 82.8,98.49 R1208.1 ; U154.F5 v4(68.13,118.53)
  T05 w0.117: v1(89.14,164.83) 86.11,161.79 86.11,160.4 85.09,159.38 85.09,156.39 84.08,155.38 84.08,152.98 82.26,151.16 82.26,133.9 80.52,132.16 80.52,130.52 81.41,129.62 81.41,126.97 80.52,126.08 80.52,123.57 81.59,122.5 81.59,120.35 81.12,119.88 80.45,119.88 v1(79.88,119.31)
  T07 w0.117: v1(86.87,116.71) 86.35,116.71 85.84,116.2 83.24,116.2 81.93,117.52 81.93,118.15 81.48,118.61 80.59,118.61 v1(79.88,119.31)
  T16 w0.117: v1(141.44,171.69) 141.44,170.53 135.74,164.83 v1(89.14,164.83)
  BOTTOM w0.102: 72.77,118.54 70.31,118.54 69.93,118.92 68.52,118.92 v4(68.13,118.53)
  BOTTOM w0.14: 72.77,118.54 72.98,118.75 v2(73.53,118.75) 74.24,118.04 R12323.2 74.65,118.4 74.92,118.67 75.88,118.67 75.96,118.75 76.46,118.75 77.02,119.31 v1(79.88,119.31)
I2C4_NIC_ARLT_N: length 32.6
  TOP w0.14: U154.F18 v4(68.13,107.32) ; R1209.1 85.98,97.06 85.98,105.47 v1(84.84,106.61)
  T03 w0.102: v1(84.84,106.61) 84.13,107.31 79.12,107.31 78.99,107.19 72.03,107.19 71.76,106.92 68.72,106.92 68.32,107.32 v4(68.13,107.32)
  BOTTOM w0.14: R12331.2 v1(84.84,106.61)
I2C_BUFF_READY: length 3.2
  TOP w0.14: U71.5 85.54,177.24 86.11,177.8 v1(86.11,177.92)
  BOTTOM w0.14: v1(86.11,177.92) 86.11,177.8 85.6,177.29 R1984.2
I2C_CLK_SCL: length 242.1
  TOP w0.14: v1(139.32,178.82) 139.6,179.1 U76.12
  T05 w0.117: v1(154.74,121.21) 154.56,121.39 154.56,122.94 154.94,123.32 157.48,123.32 158.62,124.46 158.62,126.75 160.02,128.14 160.02,132.08 158.05,134.05 155.13,134.05 154.18,135 154.18,136.91 151.89,139.19 151.89,143.13 154.18,145.41 154.18,153.67 152.02,155.83 152.02,170.94 147.96,175.01 147.96,178.05 146.18,179.83 143.26,179.83 142.62,180.47 140.46,180.47 139.32,179.32 v1(139.32,178.82)
  T14 w0.117: v1(154.74,121.21) 154.74,120.7 144.65,110.62 119.18,110.62 113.98,105.42 113.98,100.56 112.23,98.81 104.83,98.81 103.81,97.79 101.67,97.79 98.83,100.63 89.15,100.63 80.97,92.45 80.62,92.45 69.86,92.45 65.42,88.01 65.42,84.67 61.59,80.84 52.91,80.84 49.42,77.35 34.3,77.35 31.35,80.29 31.35,83.89 32.29,84.84 v1(32.77,84.84)
  BOTTOM w0.14: v1(32.77,84.84) 31.72,84.84 R1675.1 ; v1(139.32,178.82) 138.77,179.36 R1994.1 ; R1898.2 v1(154.74,121.21)
I2C_CLK_SDA: length 239.8
  TOP w0.14: R1676.1 31.45,85.47 32.77,85.47 v1(33.15,85.85) ; v1(140.5,179.36) 140.25,179.62 U76.11
  T05 w0.117: v1(140.5,179.36) 141.18,180.05 142.45,180.05 143.08,179.41 145.67,179.41 147.19,177.89 147.19,174.88 151.6,170.47 151.6,155.65 153.76,153.5 153.76,145.59 151.47,143.3 151.47,139.01 153.54,136.94 153.54,134.87 154.81,133.6 157.9,133.6 159.6,131.91 159.6,128.36 158.12,126.87 158.12,124.71 157.23,123.83 153.92,123.83 153.42,123.32 153.42,121.28 v1(153.4,121.26)
  T14 w0.117: v1(33.15,85.85) 33.53,85.47 33.53,83.31 33.02,82.8 32.26,82.8 31.81,82.35 31.81,80.43 34.47,77.77 49.24,77.77 52.73,81.26 61.42,81.26 65,84.84 65,89.03 68.84,92.87 80.79,92.87 88.97,101.05 99,101.05 101.84,98.21 103.64,98.21 104.65,99.23 112.04,99.23 113.23,100.42 113.23,105.62 118.64,111.04 123.24,111.04 144.48,111.04 153.4,119.96 v1(153.4,121.26)
  BOTTOM w0.14: v1(140.5,179.36) 139.79,180.08 R1995.1 ; R1897.2 v1(153.4,121.26)
I2C_CPLD_ALRT_N: length 177.6
  TOP w0.14: R1713.2 73.07,168.83 72.01,167.77 72.01,160.36 71.25,159.6 71.25,158.55 73.04,156.75 J1.B10 ; U70.C12 v4(119.6,131.25) ; U154.H18 v4(66.53,107.32)
  T03 w0.117: v1(84.84,102.8) 84.14,102.11 80.49,102.11 79.5,103.1 68.44,103.1 66.93,104.61 66.93,106.92 v4(66.53,107.32)
  T05 w0.117: J1.B10 73.04,152.67 74.28,151.43 74.28,137.78 73.27,136.77 73.27,131.66 72.02,130.41 72.02,127.75 72.52,127.25 72.52,124.71 72.26,124.46 72.26,122.91 71.73,122.37 71.73,120.76 71.49,120.53 71.16,120.53 70.93,120.29 70.93,109.56 70.69,109.32 68.53,109.32 v4(66.53,107.32)
  T07 w0.117: J1.B10 73.04,149.08 79.25,142.88 82.04,142.88 82.93,141.99 91.69,141.99 92.46,141.22 98.3,141.22 99.8,142.72 108.74,142.72 111.63,139.83 119.63,139.83 119.89,139.57 121.54,139.57 121.79,139.83 126.24,139.83 130.43,135.64 130.43,133.99 129.54,133.1 125.22,133.1 123.78,131.65 120,131.65 v4(119.6,131.25)
  BOTTOM w0.14: R12330.2 v1(84.84,102.8)
I2C_CPLD_MUX_EN: length 58.1
  TOP w0.14: R12470.1 84.06,127 81.41,127 v1(80.26,128.14) ; U70.A6 v4(114,132.85)
  T03 w0.117: v1(79.88,135.64) 82.55,135.64 83.82,136.91 93.6,136.91 94.23,137.54 96.65,137.54 99.75,140.64 105.74,140.64 106.17,140.21 107.82,140.21 108.25,140.64 112.08,140.64 113.88,138.85 113.88,132.98 v4(114,132.85)
  T05 w0.117: v1(80.26,128.14) 80.26,128.85 78.61,130.5 78.61,134.37 v1(79.88,135.64)
I2C_CPLD_MUX_SEL: length 39.6
  TOP w0.14: U111.6 R12470.2 R12479.1 R12480.1 87.6,125.25 v1(87.88,124.97) ; U112.6 v1(79.79,124.3) ; U154.Y2 v4(56.93,120.93)
  T03 w0.117: v4(56.93,120.93) 57.54,121.54 60.45,121.54 62.1,123.19 68.58,123.19 69.47,122.3 71.5,122.3 73.03,123.83 78.49,123.83 78.96,124.3 v1(79.79,124.3) 80.17,124.3 80.64,123.83 82.68,123.83 84.01,125.16 87.7,125.16 v1(87.88,124.97)
