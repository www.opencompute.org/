# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PD_LAN_NCSI_CLKIN_TXD0_1_EN: length 11.3
  TOP w0.089: 116.6,64.83 U1.Y78 116.79,64.34 116.6,64.15 U1.W77 116.71,63.49 117.21,63.49 117.59,63.11 U1.AA75 118.1,62.61 118.51,62.21 118.51,61.97 U1.AA72
  TOP w0.109: 116.6,64.83 116.6,65.8 116.73,65.93 116.73,66.69 115.08,68.34 v2(115.06,68.34) 114.82,68.58 R17.1
PD_REFCLK14IN: length 5.2
  TOP w0.152: U1.W9 v1(117.83,32.68)
  BOTTOM w0.102: R143.2 117.39,33.12 v1(117.83,32.68) 117.83,32.19 118.23,31.78 118.23,30.32 v2(117.75,29.84)
PD_RSV1: length 1.9
  TOP w0.152: U1.AK66 v1(121.8,56.67)
  BOTTOM w0.102: v1(121.8,56.67) 122.13,56.33 R90.2
PD_RSV2: length 8.4
  TOP w0.089: U1.E72 110.12,61.12 109.53,61.72 109.03,61.72 108.81,61.5 108.51,61.5 108.16,61.15 106.9,61.15 106.57,61.48 106.57,62.7 105.55,63.72
  TOP w0.109: R93.2 104.92,64.51 v2(105.54,63.9) 105.54,63.73 105.55,63.72
PD_TEST0: length 7.2
  TOP w0.089: 144.29,62.56 143.81,62.56 143.45,62.92 U1.CU76
  TOP w0.109: R171.2 150.34,62.56 144.29,62.56
PD_TEST1: length 11.3
  TOP w0.109: R170.2 150.01,63.6 149.2,62.78 145.21,62.78 144.94,63.05 144.94,64.35 144.47,64.82 141.88,64.82 141.4,64.34 U1.CM78
PD_TEST_CPU_TSTSTRAP: length 5.8
  TOP w0.089: v1(107.47,52.7) 107.88,52.7 108.23,53.05 108.82,53.05 109,52.87 109.35,52.87 109.53,53.05 110,53.05 U1.E55
  BOTTOM w0.102: R147.2 109.37,51.46
  BOTTOM w0.109: v1(107.47,52.7) 107.51,52.7 R148.1 108.75,51.46 109.37,51.46
PD_TEST_NOA_COMP: length 2.8
  TOP w0.109: U1.AA66 117.83,56.85 117.57,56.58 116.92,56.58 v1(116.84,56.66)
  BOTTOM w0.089: v1(116.84,56.66) 116.51,56.99 R169.2
PECI_PCH: length 48.5
  TOP w0.109: R311.1 119.58,73.02 119.15,73.45 v3(118.82,73.45)
  TOP w0.152: U1.BG16 v1(129.22,35.83)
  T03 w0.097: 124.24,66.08 124.24,68.36 120.44,72.17 119.48,72.17 118.82,72.83 v3(118.82,73.45)
  T03 w0.102: 124.24,66.08 124.24,59.95 124.66,59.53 124.66,56.99 124.04,56.36 124.04,52 124.23,51.81 124.23,51.45 122.54,49.76 122.54,46.12 124.73,43.92 126.72,43.92 127.4,43.24 127.4,42.15 130.13,39.42 130.13,38.02 129.82,37.71 129.82,37.14 130.11,36.85 130.11,36.52 129.88,36.29 129.69,36.29 v1(129.22,35.83)
PECI_PCH_BMC: length 165.5
  TOP w0.109: v3(29.52,25.34) 30.38,26.2 30.38,33.7 28.87,35.22 28.87,41.81 30.6,43.54 30.6,45.5 29.71,46.39 29.71,48.72 30.6,49.62 30.6,53.16 32.43,54.99 37.21,54.99 38.01,55.79 41.49,55.79 v3(41.59,55.68) ; R105.2 R311.2 118.47,72.71 118.24,72.94 118.24,73.88 v3(117.78,74.34)
  T03 w0.097: v3(41.59,55.68) 42.82,56.9 42.82,64.82 45.51,67.52 63.99,67.52 69.36,72.89 70.86,72.89 72.29,74.33 73.06,74.33 74.77,72.61 74.77,72.35 76.81,70.32 81.25,70.32 82.45,71.52 88.11,71.52 89.13,72.53 91.03,72.53 91.95,73.45 94.47,73.45 95.71,74.69 95.71,76.87 96.08,77.25 96.66,77.25 97.07,77.65 97.74,77.65 98.36,77.03 100.83,77.03 101,76.85 115.27,76.85 v3(117.78,74.34)
  BOTTOM w0.109: v3(29.52,25.34) 29.52,24.47 30.71,23.28 30.71,20.69 31.17,20.23 34.5,20.23 35.74,18.99 35.74,10.49 35.74,10.49 35.74,8.75 35.35,8.37 J10.A19
PHY_BDXDE_WAKE_3V3_L: length 3.5
  TOP w0.109: U12.2 72.16,29.81 72.44,30.09 73.19,30.09 73.76,29.52 U13.4
PHY_BDXDE_WAKE_L: length 66.9
  TOP w0.109: v3(82.95,32.39) 82.93,32.37 R201.2 82.4,30.98 81.66,30.24 81.66,29.86 81.32,29.52 U13.13
  T08 w0.097: v1(117.24,67.25) 117.62,66.87 117.62,65 116.28,63.65 109.99,63.65 109.82,63.48 109.71,63.48 109.49,63.25 109.49,63.15 109.03,62.69 109.03,62.69 108.8,62.46 108.8,62.46 106.56,60.22 106.56,48.09 105.88,47.42 101.17,47.42 99.43,47.42 97.54,45.53 97.54,45.28 97.54,41.77 93.3,37.53 90.03,37.53 87.04,34.54 84.59,34.54 82.95,32.91 v3(82.95,32.39)
  BOTTOM w0.089: 117.4,67.25 v1(117.24,67.25) 117.06,67.25 v2(116.48,67.83) ; 117.62,66.81 117.82,66.61 R51.1
  BOTTOM w0.102: 117.4,67.25 117.62,67.02 117.62,66.81
PHY_BDXDE_WAKE_L_ST: length 3.8
  TOP w0.089: v1(118.39,65.96) 118.78,65.57 118.78,64.17 118.93,64.02 118.93,63.25 U1.AD76
  BOTTOM w0.089: R51.2 118.08,65.66 v1(118.39,65.96)
PHY_WAKE_L_ST: length 67.6
  TOP w0.089: v1(127.02,22.46) 127.02,22.49 127.27,22.74 127.27,27.93 U1.BA1
  TOP w0.109: v3(69.69,29.62) 70.19,29.12 R53.2
  T03 w0.097: v3(78.83,24.09) 75.23,24.09 v3(69.69,29.62)
  T05 w0.089: 119.98,22.29 120.1,22.18 124.84,22.18 125.13,22.46 v1(127.02,22.46)
  T05 w0.097: 119.98,22.29 114.27,22.29 114,22.02 89.02,22.02 88.33,22.7 86.6,22.7 85.09,24.21 83.98,24.21 83.85,24.09 v3(78.83,24.09)
PM_SYNC_PCH: length 58.8
  TOP w0.089: v1(110.05,64.99) 110.62,64.99 111.27,64.33 111.27,63.79 U1.H77
  TOP w0.152: U1.BT9 v1(133.19,32.39)
  T10 w0.089: v1(133.19,32.39) 133.1,32.49 133.1,33.39 132.91,33.58 132.91,33.84 132.8,33.95 132.8,34.27 132.91,34.38 132.91,34.64 133.08,34.81 133.08,35.13 132.85,35.36 132.84,35.36 132.58,35.61 132.58,35.99 132.36,36.22 132.12,36.45 132.12,36.81 131.8,37.14 131.8,37.95 132.1,38.25 132.1,38.57 131.87,38.79 130.24,38.79 126.87,42.17 125.39,42.17 125.02,42.55 125.02,43.06 124.6,43.47 119.77,43.47 119.42,43.83 119.42,54.67 119.42,54.67 119.42,54.99 119.41,55 119.41,56.2 119.29,56.32 119.24,56.37 119.24,58.62 117.74,60.11 117.74,61.5 117.82,61.58 117.82,61.58 117.97,61.74 117.97,62.54 117.62,62.9 117.62,65.72 117.26,66.07 116.78,66.07 115.27,64.55 110.49,64.55 v1(110.05,64.99)
  BOTTOM w0.089: v1(133.19,32.39) 133.08,32.29 133.08,30.93 v2(132.48,30.34)
PROCHOT_L: length 6
  TOP w0.109: R220.2 67.03,11.65 67.03,8.93 67.35,8.61 J10.B51
PU_ADR_IN: length 1.2
  TOP w0.152: U1.AD66 v1(118.82,57.3)
  BOTTOM w0.089: R72.2 119.11,57.01 v1(118.82,57.3)
PU_BDXDE_INTVRMEN: length 5.7
  TOP w0.089: 123.06,26.18 123.06,27.78 123.32,28.05 123.32,28.74 U1.AP2
  TOP w0.109: v1(123.21,25.87) 123.21,26.03 123.06,26.18
  BOTTOM w0.089: R273.2 122.9,26.18 v1(123.21,25.87) v2(124.59,25.87)
PU_BDXDE_RI_L: length 9.9
  TOP w0.152: U1.BF11 128.97,32.71 128.67,32.71 128.24,32.28 128.24,31.8 v1(128.24,31.8)
  BOTTOM w0.089: R71.2 125.77,27.68 127.87,27.68 v2(128.9,28.71)
  BOTTOM w0.102: v2(128.9,28.71) 129.03,28.84 129.03,31.01 v1(128.24,31.8)
PU_BDXDE_SPARE5: length 8.7
  TOP w0.089: U1.D71 109.51,60.47 109.51,60 109.31,59.8 109.03,59.8 108.86,59.98 108.54,59.98 108.39,59.82 106.9,59.82 106.05,60.68
  TOP w0.109: 106.05,60.68 106.03,60.68 v2(105.97,60.74) 105.97,61.01 105.43,61.56 105.43,61.97 105.66,62.21 105.66,62.67 104.84,63.49 R114.2
PU_BDXDE_SUSACK_L: length 13.8
  TOP w0.089: 126.07,21.95 126.07,23.47 126.7,24.1 126.7,27.64 126.51,27.84 126.51,28.45 126.46,28.5 126.46,28.51 126.16,28.81 126.16,29.09 126.46,29.38 126.46,29.9 U1.AY4
  TOP w0.109: R76.2 v3(127.98,18.7) 127.98,18.83 127.53,19.28 127.53,20.01 126.07,21.47 126.07,21.95
PU_BMBUSY_N_GPIO0: length 1.4
  TOP w0.152: v1(127.03,40.57) U1.BB28
  BOTTOM w0.108: v1(127.03,40.57) 127.02,40.58 127.02,41.16 R70.2
PU_BMCINIT: length 4
  TOP w0.089: U1.AD69 118.82,60.12
  TOP w0.152: 118.82,60.12 v1(118.8,60.14)
  BOTTOM w0.089: R66.2 118.51,62.96 119.14,62.33 119.14,61.37 118.93,61.16 118.93,60.84 119.14,60.63 119.14,60.48 v1(118.8,60.14)
PU_DDR3_4_STRAP: length 22.9
  TOP w0.109: R280.2 v3(114.01,72.56)
  TOP w0.152: U1.AK69 v1(121.3,59.3)
  T05 w0.089: v1(121.3,59.3) 121.3,60.36 121.73,60.8 121.73,61.23 122.09,61.58 122.09,62.02 121.38,62.73 121.38,66.31
  T05 w0.097: v3(114.01,72.56) 114.72,71.85 114.72,70.37 115.53,69.56 120.26,69.56 121.38,68.44 121.38,66.31
  BOTTOM w0.109: v2(113.25,71.79) 113.25,71.8 v3(114.01,72.56) 114.03,72.58 R285.1
PU_DSWODVREN: length 5
  TOP w0.089: U1.AL1 122.04,26.1
  TOP w0.109: 122.04,26.1 v1(121.91,25.97)
  BOTTOM w0.089: v2(123.49,24.95) 122.93,24.95 v1(121.91,25.97) 121.89,25.99 R271.2
PU_EAR_L: length 1.6
  TOP w0.127: U1.AH62 v1(121.43,55.63)
  BOTTOM w0.102: R113.2 121.6,55.46 v1(121.43,55.63)
PU_GPIO51_GSXDOUT: length 31.8
  TOP w0.109: v3(129.51,9.56) R244.1
  TOP w0.152: U1.BL18 v1(130.71,36.69)
  T10 w0.089: 129.13,21.61 129.13,30.84 128.76,31.21 128.76,32.66 128.32,33.1 128.32,33.42 128.84,33.94 128.84,34.64 129.63,35.43 129.63,35.8 130.53,36.69 v1(130.71,36.69)
  T10 w0.097: 129.13,21.61 128.79,21.27 128.79,10.27 v3(129.51,9.56)
  BOTTOM w0.109: R244.1 v3(129.51,9.56)
PU_GPIO72_BATLOW_L: length 17.9
  TOP w0.089: U1.BB4 127.01,29.94 126.66,29.58 126.66,29.28 127.45,28.49 127.45,21.61
  TOP w0.109: R74.2 v3(127.98,14.89) 128.61,15.52 128.61,19.45 128.47,19.59 128.47,20.5 127.45,21.52 127.45,21.61
PU_INTRUDER_L: length 6.3
  TOP w0.089: U1.AK2 121.55,28.16 121.53,28.14 121.53,25.61 121.79,25.34
  TOP w0.109: 121.79,25.34 121.81,25.32 v1(121.81,25.24)
  BOTTOM w0.089: R78.2 120.8,26.61 v2(120.8,25.37) 121.01,25.16 121.73,25.16 v1(121.81,25.24)
PU_NCTF4: length 5.2
  TOP w0.152: U1.BA18 v1(127.04,35.76)
  BOTTOM w0.102: v2(129.18,32.38) 129.18,33.52 128.83,33.87 128.83,34 128.14,34.69 R184.2
  BOTTOM w0.108: R184.2 127.5,34.78 127.5,35.15 127.07,35.58 127.07,35.73 v1(127.04,35.76)
PU_P2E_RCOMP: length 1.8
  TOP w0.33: v1(117.43,39.77) U1.AA27
  BOTTOM w0.305: R182.2 117.74,40.07 v1(117.43,39.77)
PU_PE_HP_SDA: length 7.2
  TOP w0.108: U1.AN67 123.28,57.71 123.64,57.35 123.64,56.81 123.03,56.2 v1(123.03,54.03)
  TOP w0.152: U1.AN67 U1.AR67
  BOTTOM w0.102: R109.2 123.67,54.66 123.67,54.45 123.25,54.03 v1(123.03,54.03)
PU_PIRQA_L: length 3
  TOP w0.152: v1(129.24,37.56) 129.24,37.55 129.53,37.26 U1.BG20
  BOTTOM w0.089: v1(129.24,37.56) 129.24,38.67 128.62,39.29 R73.2
PU_PIRQB_L: length 1.9
  TOP w0.152: U1.BF22 129.46,38.12 129.74,38.4 v1(129.74,38.41)
  BOTTOM w0.089: v1(129.74,38.41) 129.76,38.44 R75.2
PU_PIRQC_L: length 93.4
  TOP w0.109: R46.1 50.27,28.79 v3(50.27,29.96)
  TOP w0.152: U1.AR11 124.59,33.29 v1(124.7,33.29)
  T05 w0.089: 105.55,37.09 109.17,33.48 111.15,33.48 111.75,32.88 112.07,32.88 112.47,33.28 112.47,33.43 112.7,33.65 118.37,33.65 118.44,33.72 122.79,33.72 123.58,32.93 124.38,32.93 v1(124.7,33.29)
  T05 w0.097: v3(72.33,38.37) 72.64,38.67 73.35,38.67 73.38,38.64 73.76,38.64 74.48,37.92 104.73,37.92 105.55,37.09
  T08 w0.097: v3(72.33,38.37) 72.64,38.67 73.35,38.67 73.6,38.42 73.6,37.79 72.35,36.54 72.35,35.83 71.8,35.28 71,35.28 70.61,34.89 70.61,34.33 67.67,31.39 61.9,31.39 60.96,30.45 55.88,30.45 55.5,30.83 51.13,30.83 v3(50.27,29.96)
  BOTTOM w0.089: R77.2 125.94,33.31 125.94,33.22 125.78,33.06 124.96,33.06 v1(124.7,33.29)
  BOTTOM w0.109: v2(71.25,39.01) 71.88,38.37 v3(72.33,38.37)
PU_PIRQD_L: length 105.1
  TOP w0.109: v3(49.48,30.41) 49.23,30.15 49.23,28.6 48.33,27.7 R45.1
  TOP w0.152: v1(130.68,38.4) 130.64,38.36 130.46,38.36 U1.BH22
  T05 w0.089: 105.55,35.54 108.82,32.28 111.69,32.28 112.29,31.67 112.29,31.6 112.74,31.15 113.06,31.15 113.84,31.94 116.7,31.94 117.23,31.41 127.37,31.41 127.85,31.89 127.85,31.96 128.32,32.43 128.32,33.42 128.62,33.72 128.62,35.85 129.33,36.56 129.33,36.85 129.66,37.18 129.66,37.54 130.53,38.4 v1(130.68,38.4)
  T05 w0.097: v3(71.88,36.08) 72.73,35.24 73.11,35.24 74.15,36.28 104.82,36.28 105.55,35.54
  T05 w0.102: v1(125.61,42.79) 126.05,42.35 127.04,42.35 128.32,41.07 128.32,40.45 128.83,39.94 129.45,39.94 130.66,38.73 130.66,38.42 v1(130.68,38.4)
  T08 w0.097: v3(49.48,30.41) 50.26,31.18 55.75,31.18 56.18,30.75 60.76,30.75 61.7,31.69 67.49,31.69 70.28,34.48 70.28,35.04 70.82,35.58 71.37,35.58 v3(71.88,36.08)
  BOTTOM w0.089: R80.2 126.03,42.37 v1(125.61,42.79)
PU_RSVD0: length 9.5
  TOP w0.152: U1.BL14 v1(130.71,34.97)
  BOTTOM w0.102: v1(130.71,34.97) 130.71,35.94 130.27,36.38 130.27,37.04 130.61,37.38 130.61,37.71 130.24,38.07 130.24,40.76 129.33,41.68 129.33,41.9 128.58,42.64 R67.2
PU_SAFE_MODE_BOOT: length 1.3
  TOP w0.152: U1.AF69 v1(119.31,59.29)
  BOTTOM w0.102: R291.2 118.67,59.19 119.21,59.19 v1(119.31,59.29)
PU_SATA_RCOMP: length 1.6
  TOP w0.254: U1.BB32 127.27,42.47 v1(126.91,42.83)
  BOTTOM w0.305: R30.2 127.36,43.29 v1(126.91,42.83)
PU_SGPIO22_SATA_CLOCK: length 32.7
  TOP w0.109: R33.2 v3(134.08,5.24)
  TOP w0.152: U1.BN14 v1(131.7,34.97)
  T10 w0.089: 132.08,21.61 132.08,31.37 132.09,31.38 132.09,31.7 131.81,31.98 131.81,32.6 131.31,33.09 131.31,33.62 131.7,34.01 v1(131.7,34.97)
  T10 w0.097: v3(134.08,5.24) 133.57,5.75 133.57,9.43 133.1,9.91 133.1,20.59 132.08,21.61
PU_SGPIO38_PCH_SLOAD: length 24.7
  TOP w0.109: R34.2 v3(141.7,14.89)
  TOP w0.152: U1.BP13 v1(133.19,34.11)
  T08 w0.089: v1(133.19,34.11) 133.19,33.01 133.57,32.62 133.57,31.98 133.29,31.7 133.29,31.38 133.52,31.15 133.6,31.15 133.83,30.91 133.83,30.1 136.11,27.82 136.11,23.49 137.99,21.61
  T08 w0.097: v3(141.7,14.89) 141.5,15.1 141.5,18.1 137.99,21.61
PU_SGPIO39_SATA_DATAOUT0: length 36
  TOP w0.109: R36.2 v3(137.13,5.24)
  TOP w0.152: v1(133.68,36.69) 134.12,36.43 U1.BU18
  T03 w0.089: v1(133.68,36.69) 133.68,35.67 133.18,35.16 133.18,34.7 132.8,34.32 132.8,33.69 133.1,33.4 133.1,32.93 132.58,32.41 132.58,32.23 132.3,31.95 132.3,28.96 133.07,28.19 133.07,21.61
  T03 w0.097: v3(137.13,5.24) 136.21,6.15 136.21,8.01 134.77,9.45 134.77,19.8 133.07,21.51 133.07,21.61
PU_SGPIO48_SATA_DATAOUT1: length 27
  TOP w0.109: R35.2 v3(143.22,14.89)
  TOP w0.152: U1.BT16 v1(133.19,35.83)
  T08 w0.089: v1(133.19,35.83) 133.19,34.84 133.7,34.32 133.7,33.87 134.07,33.5 134.07,32.83 133.79,32.55 133.79,32.23 134.07,31.95 134.07,30.93 134.05,30.91 134.05,30.59 136.34,28.3 136.34,23.68 138.42,21.61
  T08 w0.097: v3(143.22,14.89) 142.77,15.35 142.77,17.26 138.42,21.61
PU_TEST_NCTF_TP3: length 1.2
  TOP w0.152: U1.BA27 126.63,40.17 v1(126.24,40.57)
  BOTTOM w0.102: R65.2 125.7,40.57 v1(126.24,40.57)
PWR_EN_CPU_VCCIN: length 75.9
  TOP w0.109: v3(60.72,36.42) 60.74,36.4 60.74,36.4 61.17,35.98 62.18,35.98 62.36,36.15 R378.2
  TOP w0.254: PR152.1 80.61,69.91 80.61,69.38 v3(80.62,69.38)
  BOTTOM w0.109: v3(80.62,69.38) 80.49,69.5 79.7,69.5 79.29,69.09 79.29,68.94 78.21,67.86 77.57,67.86 74.39,64.68 74.39,62.64 72.23,60.49 70.63,60.49 v2(70.36,60.21) 70.16,60.41 66.28,60.41 65.43,61.26 64.43,61.26 62.55,59.38 62.55,54.47 63.03,53.99 63.03,41.96 62.28,41.21 62.28,37.6 61.17,36.49 60.79,36.49 v3(60.72,36.42) 60.7,36.42 60.42,36.14 60.4,36.14 60.27,36.01 58.86,36.01 58.46,36.4 58.46,37.12 57.85,37.74 54.99,37.74 51.81,34.56 51.36,34.56 50.06,33.27 50.06,32.63 49.82,32.38 49.4,32.38 47.42,30.4 47.42,28.46 47.18,28.23 PR239.1 46.35,29.34 PC304.1 PR241.1
PWR_EN_VP0P6_DDR4_VTT: length 231.7
  TOP w0.109: R379.2 56.87,29.01 v3(56.34,28.48) ; v3(178.79,92.07) 178.94,92.22 PR38.2
  T10 w0.097: v3(178.79,92.07) 177.44,90.71 145.41,90.71 143.69,92.44 140.77,92.44 138.64,94.57 80.23,94.57 77.95,92.29 74.19,92.29 64.23,82.33 38.41,82.33 35.36,79.28 35.36,74.49 30.73,69.87 30.73,47.62 34.26,44.09 34.26,36.44 40.65,30.05 48.55,30.05 49.94,28.67 52.1,28.67 53.98,30.55 54.6,30.55 56.34,28.82 v3(56.34,28.48)
  BOTTOM w0.109: PR232.1 PC302.1 56.03,29.65 PR231.1 55.83,29.46 55.83,28.99 v3(56.34,28.48)
PWR_EN_VP1P2_DDR4_VDD: length 206.3
  TOP w0.152: PR186.1 193.4,34.56 v3(193.9,35.07)
  T03 w0.097: v3(59.13,34.58) 58.88,34.33 58.88,27.07 53.37,21.56 50.87,21.56 v3(50.81,21.5)
  T05 w0.097: v3(193.9,35.07) 195.68,33.29 195.68,32.4 192.87,29.59 192.87,27.21 191.21,25.56 191.21,15.66 192.13,14.75 192.13,12.61 192.79,11.95 192.79,10.81 v3(192.91,10.68)
  T08 w0.097: v3(50.81,21.5) 51.8,20.52 73.6,20.52 74.55,21.46 103.02,21.46 103.61,22.05 106.56,22.05 106.73,21.88 118.47,21.88 120.46,19.89 120.46,17.94 120.92,17.48 124.05,17.48 126.21,15.32 126.77,15.32 128.58,13.51 129.25,13.51 130.42,12.34 130.42,9.56 132.36,7.62 138.53,7.62 139.01,7.14 142.99,7.14 145.74,9.89 155.86,9.89 156.74,9.01 165.48,9.01 165.81,8.68 169.14,8.68 169.39,8.42 174.14,8.42 174.23,8.51 182.66,8.51 184.55,10.4 192,10.4 192.28,10.68 v3(192.91,10.68)
  BOTTOM w0.109: PR228.1 63.7,35.26 PC301.1 PR229.1 60.83,35.26 60.13,34.55 R375.2 59.16,34.55 v3(59.13,34.58)
PWR_EN_VP1P3: length 99.8
  TOP w0.109: v3(37.57,41.09) 37.41,40.93 35.51,40.93 35.26,40.67 R376.2
  TOP w0.254: v3(51.84,75.37) 51.84,76.4 PC36.1 53.25,75.02 PU5.5 ; PR223.1 16.92,83.12 PC298.1 v3(18.54,83.96) PR224.1
  T08 w0.097: v3(18.54,83.96) 18.54,82.64 28.52,72.66 35.41,72.66 35.86,73.11 39.04,73.11 39.33,73.4 45.92,73.4 46.66,72.66 50.14,72.66 51.84,74.37 v3(51.84,75.37)
  BOTTOM w0.109: v3(37.57,41.09) 37.57,45.46 38.48,46.37 40.64,46.37 41.15,45.86 44.07,45.86 44.46,45.47 45.22,45.47 46.08,46.34 46.08,50.1 44.97,51.21 44.97,51.99 45.47,52.48 48.28,52.48 48.86,53.06 48.86,55.64 48.87,55.65 48.87,63.25 47.62,64.49 47.62,69.41 50.16,71.95 50.16,73.55 51.84,75.23 v3(51.84,75.37)
PWR_EN_VP1P05: length 23.7
  TOP w0.109: v3(50.67,27.96) 51.81,29.09 R372.2
  BOTTOM w0.109: v3(50.67,27.96) 49,27.96 46.96,25.92 43.76,25.92 38.58,31.11 v2(38.58,31.49) 38.28,31.78 38.28,34.13 PR2.1 39.82,34.42 PC299.1 PR219.1
PWR_EN_VP1P05_PCH: length 54.3
  TOP w0.109: v3(66.76,32.47) 65.86,32.47 63.7,34.63 60.93,34.63 v3(59.43,33.13)
  TOP w0.152: v3(87.6,33.5) 87.84,33.26 PU24.2
  T08 w0.097: v1(55.2,38.26) 56.22,37.24 57.88,37.24 59.78,35.34 64.31,35.34 66.76,32.89 v3(66.76,32.47)
  BOTTOM w0.109: v2(59.93,29.51) 59.91,29.5 PR233.1 59.2,29.9 PC303.1 PR234.1 59.2,32.9 v3(59.43,33.13) ; v1(55.2,38.26) 55.07,38.39 R373.2 ; v3(87.6,33.5) 84.55,36.55 76.79,36.55 76.6,36.74 70.85,36.74 66.76,32.66 v3(66.76,32.47)
PWR_EN_VP1P5_PCH: length 35.8
  TOP w0.109: R374.2 34.8,41.54 34.29,41.04 33.5,41.04 31.8,42.74 v3(31.8,43.06)
  TOP w0.254: v3(36,59.06) 36,61.01 37.16,62.17 PR236.1 38.47,62.27 PR235.1 41.14,62.27 PC305.1 41.16,63.55 41.51,63.9 42.37,63.9 42.75,64.28 PC29.1 43.49,64.63 43.86,65 PU6.5
  T05 w0.097: v3(36,59.06) 36,55.39 34.51,53.9 34.51,46.3 31.8,43.59 v3(31.8,43.06)
PWR_EN_VP1P05VDD: length 0.8
  TOP w0.109: PR281.1 v3(75.21,55.77)
PWR_EN_VP1P7: length 144.2
  TOP w0.109: R371.2 v3(36.91,39.11)
  TOP w0.254: v3(25.37,92.87) 25.98,92.26 25.98,90.97 26.74,90.21 27.26,90.21 27.85,89.61 PU14.15
  TOP w0.381: v3(48.15,73.51) PR222.1 48.13,74.38 PC297.1 PR221.1
  T08 w0.097: v3(48.15,73.51) 49.8,73.51 50.78,74.48 50.78,74.84 50.39,75.22 45.17,75.22 41.82,78.57 40.3,78.57 36.23,82.64 36.23,89.08 33.67,91.64 26.81,91.64 25.58,92.87 v3(25.37,92.87) 25,93.23 22.12,93.23 20.19,91.3 17.83,91.3 8.35,81.82 4.54,81.82 1.87,79.15 1.87,63.96 5.05,60.78 6.57,60.78 9.28,58.07 22.24,58.07 24.56,55.75 25.21,55.75 29.81,51.14 29.81,46.66 30.86,45.61 32.19,45.61 34.66,43.14 34.66,40.01 35.57,39.11 v3(36.91,39.11)
PWR_EN_VP2P5_DDR4_VPP: length 196.4
  TOP w0.254: PU20.7 151.7,83.75 152.33,83.12 152.33,83.11 v7(152.35,83.09)
  T10 w0.097: v7(152.35,83.09) 152.33,83.11 152.33,83.25 150.32,85.25 142.95,85.25 138.81,89.4 138.81,92.16 138.03,92.93 117.34,92.93 116.77,92.36 114.58,92.36 114.01,92.93 99.06,92.93 97.44,91.31 91.43,91.31 84.81,84.69 68.89,84.69 65.26,81.07 64.55,80.36 48.02,80.36 ; 40.4,79.61 36.94,76.15 36.94,71.74 36.45,71.26 36.45,68.72 36.45,68.13 33.96,65.64 33.96,48.93 39.72,43.16 39.72,35.13 42.31,32.55 47.01,32.55 47.45,32.11 48.88,32.11 49.17,31.82 v3(49.45,31.82)
  T10 w0.109: 48.02,80.36 47.35,79.68 40.47,79.68 40.4,79.61
  BOTTOM w0.109: v3(49.45,31.82) 49.7,32.07 49.94,32.07 50.63,32.75 50.63,33.39 50.99,33.75 51.71,33.75 v2(51.89,33.93) 51.98,33.93 R370.2 52.78,34.68 52.78,32.48 PR227.1 PC300.1 52.98,29.27 PR226.1
PWR_EN_VP3P3: length 76.5
  TOP w0.109: PU2.1 v3(46.56,80.24)
  TOP w0.254: v3(10.62,41.44) PC296.1 9.66,40.83 9.38,40.55 PR1.1 9.38,39.81 8.97,39.41 6.94,39.41 6.56,39.79 PR218.1
  T05 w0.097: 43.26,75.92 43.26,74.74 41.86,73.34 41.86,69.25 40.92,68.31 40.92,67.05 40.27,66.4 40.27,63.92 38.47,62.12 28.66,62.12 25.99,59.45 v3(25.99,57.95) ; v3(46.56,80.24) 45.9,80.24 44.27,78.62
  T05 w0.109: 43.26,75.92 44.27,76.93 44.27,78.62
  BOTTOM w0.109: v3(10.62,41.44) 10.75,41.31 24.72,41.31 26.67,43.26 26.67,56.88 26.67,56.88 26.67,57.25 26.67,57.25 26.67,57.27 v3(25.99,57.95)
PWR_EN_VP3P3_A: length 135.3
  TOP w0.254: PU25.2 v3(40.72,75.41)
  T08 w0.097: v3(44.66,32.04) 43.66,33.04 43.66,35.73 42.01,37.37 40.85,37.37 39.45,38.78 39.45,43.35 32.52,50.27 32.52,51.82 27.82,56.52 24.63,56.52 22.48,58.67 9.53,58.67 6.82,61.38 5.91,61.38 2.52,64.78 2.52,76.34 3.62,77.44 7.74,77.44 21.68,91.38 25.45,91.38 25.93,90.89 33.58,90.89 35.63,88.83 35.63,82.39 39.2,78.83 39.2,76.88 39.78,76.3 v3(40.72,75.41)
  BOTTOM w0.109: v3(44.66,32.04) 43.89,32.8 43.41,32.8 R377.2 43.39,32.29 43.83,31.85 PR238.1 PC306.1 43.83,28.76 PR237.1
PWR_EN_VP5P0: length 12.1
  TOP w0.254: v7(10.41,45.12) 10.41,45.2 9.91,45.7 PU1.7
  TOP w0.381: v3(15.78,46.14) PC295.1 PR216.2 PR217.1
  BOTTOM w0.381: v3(15.78,46.14) 14.83,45.19 10.49,45.19 10.42,45.12 v7(10.41,45.12)
PWR_ENST_CPU_VCCIN: length 4.2
  TOP w0.089: U31.A13 58.7,36.79 58.77,36.86
  TOP w0.109: 58.77,36.86 58.84,36.92 58.99,36.92 59.02,36.9 59.46,36.9 59.62,37.05 v3(59.7,37.05) 59.86,37.05 59.86,37.05 60.08,37.05 60.28,36.85 61.28,36.85 R378.1
PWR_ENST_VP0P6_DDR4_VTT: length 6.6
  TOP w0.089: U31.C15 56.23,34.2 56.23,33.62 56.23,33.62 56.23,33.43 56.36,33.31 56.36,32.8
  TOP w0.109: v2(58.04,29.89) R379.1 56.36,30.4 56.36,32.8
PWR_ENST_VP1P2_DDR4_VDD: length 7
  TOP w0.089: U31.B14 v1(57.13,35.3)
  BOTTOM w0.109: v2(62.56,36.58) 61.81,35.83 60.53,35.83 60.07,35.37 R375.1 58.9,35.37 58.37,34.84 57.59,34.84 v1(57.13,35.3)
PWR_ENST_VP1P3: length 10.1
  TOP w0.089: 41.62,37.5 41.88,37.24 44.16,37.24 44.64,37.72 U31.P12
  TOP w0.109: R376.1 v3(36.96,40.4) 38.72,40.4 41.62,37.5
PWR_ENST_VP1P05: length 4.3
  TOP w0.089: 52.55,32.8 52.55,32.88 U31.G16
  TOP w0.109: 52.55,32.8 v2(52.55,31) R372.1
PWR_ENST_VP1P05_PCH: length 11.1
  TOP w0.089: U31.J16 v1(49.64,32.8) ; U31.G11 v1(52.13,38.3)
  BOTTOM w0.109: v1(52.13,38.3) 52.23,38.39 R373.1 53.76,38.28 53.76,36.95 51.86,35.04 50.96,35.04 49.64,33.72 v1(49.64,32.8)
PWR_ENST_VP1P5_PCH: length 10.1
  TOP w0.089: U31.R12 43.17,38.26 42.39,38.26 42.3,38.18 41.62,38.18
  TOP w0.109: R374.1 39.72,41.54 v3(40.74,40.52) 40.74,40.33 40.99,40.08 40.99,38.64 41.45,38.18 41.62,38.18
PWR_ENST_VP1P7: length 7.3
  TOP w0.109: v3(37.67,37.61) 37.72,37.66 R371.1 40.3,38.37 41.88,36.79 U31.T13
  BOTTOM w0.109: v3(37.67,37.61) v2(38.57,37.61)
PWR_ENST_VP2P5_DDR4_VPP: length 5.1
  TOP w0.089: U31.D15 54.64,34.72 v1(54.16,34.23)
  BOTTOM w0.109: v1(54.16,34.23) 54.02,34.23 53.57,34.68 R370.1 53.57,35.17 54.71,36.31 54.71,36.47 54.96,36.72 55.12,36.72 55.14,36.74 55.42,36.74 55.7,37.02 v2(55.7,37.11)
PWR_ENST_VP3P3_A: length 3.6
  TOP w0.089: U31.P15 v1(44.15,34.3)
  BOTTOM w0.109: R377.1 43.44,33.59 v1(44.15,34.3) 44.19,34.3 v2(45.47,35.58)
PWRGD_APWROK: length 141.3
  TOP w0.109: U31.B5 v1(57.13,45.28) ; R84.2 v3(131.03,5.24)
  TOP w0.152: v1(128.71,33.26) 128.71,33.28 128.73,33.31 U1.BE13
  T05 w0.097: v3(131.03,5.24) 131.03,6.18 133.28,8.43 133.28,9.86 132.57,10.57 132.51,10.57 131.94,11.14 131.94,15.73 131.13,16.55 125.59,16.55 124.73,17.4 121,17.4 120.62,17.78 120.62,18.03 120.62,18.03 120.62,19.3 119.81,20.12 116.56,20.12 116.04,20.64 115.25,20.64 115.09,20.47 109.03,20.47 107.03,18.47 98.69,18.47 95.47,15.25 92.22,15.25 88.1,19.37 85.32,19.37 82.81,21.87 73.15,21.87 66.25,28.77 66.25,31.54 64.99,32.8 64.99,33.91 60.86,38.04 60.3,38.04 59.96,38.38 59.96,38.64 56.72,41.89 56.72,42.46 56.96,42.7 57.14,42.7 57.55,43.11 57.55,44.87 v1(57.13,45.28)
  T10 w0.089: 129.43,21.61 129.43,30.98 129.07,31.33 129.07,32.9 v1(128.71,33.26)
  T10 w0.097: 129.43,21.61 130.02,21.02 130.02,6.26 v3(131.03,5.24)
PWRGD_BDXDE_LAN: length 110.3
  TOP w0.089: 119.49,66.05 119.49,64.75 119.68,64.56 119.68,63.71 U1.AE77
  TOP w0.109: 119.49,66.05 v1(119.9,66.45) ; R402.1 26,67.98 26.54,67.44 27.25,67.44 27.64,67.84 R203.1 ; R203.1 27.83,67.77 U14.4 ; R203.1 27.64,67.97 27.91,68.23 v3(28.35,68.23)
  T08 w0.097: v3(28.35,68.23) 27.86,67.74 27.86,67.04 28.11,66.79 28.47,66.79 28.82,67.14 38.5,67.14 38.82,66.82 40.35,66.82 40.61,67.07 40.61,67.48 41.76,68.63 48.8,68.63 49.71,67.72 63.66,67.72 64.05,67.33 70.44,67.33 70.76,67.01 80.41,67.01 81.29,67.89 82.53,67.89 82.84,68.2 96.99,68.2 97.01,68.18 102.84,68.18 106.84,72.18 112.38,72.18 114.32,70.24 116.43,70.24 119.49,67.18 119.49,66.86 v1(119.9,66.45)
  BOTTOM w0.109: v3(28.35,68.23) v2(27.29,68.23)
PWRGD_CPLD_BDXDE_LAN: length 44.4
  TOP w0.109: U31.A6 v1(58.13,44.28) ; v3(39.19,59.02) 37.49,59.02 36.78,58.31 34.8,58.31 34.26,58.85 34.26,67.22 34.81,67.77 U14.13
  T08 w0.097: v1(58.13,44.28) 57.55,44.86 56.39,44.86 54.87,46.38 53.02,46.38 47.34,52.07 47.34,54.44 46.94,54.84 46.15,54.84 45.04,55.95 45.04,57.22 44.17,58.09 40.69,58.09 39.76,59.02 v3(39.19,59.02)
  BOTTOM w0.109: v2(38.46,59.83) 38.46,59.75 v3(39.19,59.02)
PWRGD_CPU0: length 187.2
  TOP w0.089: v1(145.79,45.69) 145.64,45.69 145.24,45.3 144.91,45.3 144.5,45.7 144.38,45.7 144.31,45.77 143.82,45.77 143.48,45.43 143.19,45.43 142.84,45.78 U1.CR39 ; U1.V76 116.14,63.14 116.14,63.86 115.82,64.17 115.82,66.31
  TOP w0.109: v3(112.73,73.21) 112.73,73.07 113.25,72.55 113.25,69.71 113.5,69.46 R95.2 113.94,68.6 115.51,67.02 115.51,66.62 115.82,66.31
  TOP w0.152: U1.BU11 v1(133.68,33.25)
  T03 w0.097: 119.27,73.39 119.27,73.19 119.99,72.47 120.88,72.47 122.35,71 ; v3(112.73,73.21) 112.44,73.5 112.42,73.5 111.3,74.62 106.48,74.62 106.01,74.15 104.1,74.15 103.33,74.92 98.91,74.92 97.31,73.32 v3(97.05,73.32)
  T03 w0.102: 122.35,71 125.24,68.11 125.24,65.73 125.18,65.66 125.18,61.65 124.87,61.34 124.87,60.72 125.15,60.43 125.15,56.86 124.24,55.94 124.24,52.41 124.42,52.22 124.42,51.25 122.73,49.56 122.73,46.26 124.82,44.17 128.03,44.17 128.67,44.81 134.38,44.81 134.77,44.42 v1(135.17,44.42) ; v3(112.73,73.21) 112.93,73.01 114.27,73.01 115.14,73.88 119,73.88 119.25,73.63 119.25,73.59 119.27,73.57 119.27,73.39
  T05 w0.089: v1(133.68,33.25) 134.15,33.72 134.34,33.72 134.56,33.95 134.56,34.27 134.29,34.55 134.29,35.39 134.56,35.67 134.56,35.99 134.29,36.27 134.29,37.11 134.56,37.38 134.56,37.71 134.29,37.98 134.29,38.82 134.56,39.1 134.56,39.42 134.29,39.7 134.29,40.54 134.56,40.82 134.56,41.14 134.21,41.5 134.21,42.18 134.56,42.54 134.56,42.86 134.29,43.14 134.29,43.72 134.99,44.42 v1(135.17,44.42)
  T05 w0.102: v1(145.79,45.69) 144.96,44.86 135.62,44.86 v1(135.17,44.42)
  T08 w0.097: v3(97.05,73.32) 97.26,73.12 97.26,72.07 96.09,70.9 90.72,70.9 89.77,71.85 86.51,71.85 86.42,71.94 82.54,71.94 81.28,70.68 64.33,70.68 62.99,69.33 50.23,69.33 49.59,69.97 40.46,69.97 39.17,71.26 v3(33.85,71.26)
  BOTTOM w0.109: R404.1 37.61,66.38 37.61,66.78 37.05,67.34 36.51,67.34 36.29,67.13 U11.13 34.37,67.13 34.05,67.44 34.05,69.04 33.85,69.25 v3(33.85,71.26)
PWRGD_CPU0_CPLD: length 108.4
  TOP w0.109: U31.C6 v1(56.13,44.28)
  T05 w0.097: v3(29.34,18.69) 29.34,20.16 28.11,21.38 28.11,32.8 26.84,34.07 26.84,45.34 28.3,46.8 28.3,48.48 28.85,49.03 28.85,55.31 27.89,56.28 26.42,56.28 25.56,57.13 25.56,59.45 29.63,63.52 31.26,63.52 v3(32.14,64.41)
  T08 w0.097: v3(39.85,58.33) 39.87,58.33 40.4,57.79 44.05,57.79 44.74,57.1 44.74,54.24 52.94,46.04 54.37,46.04 v1(56.13,44.28)
  BOTTOM w0.109: v3(29.34,18.69) 29.34,18.13 28.57,17.37 28.57,15.43 28.08,14.94 28.08,14 25.1,11.02 25.1,6.45 J10.A11 ; v3(39.85,58.33) 38.22,58.33 36.36,60.19 34.96,60.19 v2(32.14,63.01) v3(32.14,64.41) 32.14,66.92 31.72,67.34 30.92,67.34 30.7,67.13 U11.4
PWRGD_CPU_VCCIN: length 77.3
  TOP w0.109: U31.A12 v1(58.39,37.79) ; U31.N1 v1(45.15,49.28)
  TOP w0.203: v3(78.33,68.65) 78.33,69.63 78.6,69.91 78.6,70.61 78.19,71.02 PR135.2
  TOP w0.254: PU17.3 78.45,73.04 77.58,72.17 77.58,71.38 PR135.2
  T08 w0.097: v1(58.39,37.79) 58.35,37.75 56.47,37.75 55.5,38.73 53.67,38.73 52.61,39.78 51.02,39.78 50.72,40.09 50.72,44.79 49.24,46.26 49.24,48.17 48.61,48.8 45.56,48.8 45.15,49.22 v1(45.15,49.28)
  BOTTOM w0.109: v1(58.39,37.79) 58.44,37.85 61.27,37.85 61.82,38.39 PC326.1 61.71,38.61 61.35,38.96 61.35,41.05 62.72,42.41 62.72,53.66 62.07,54.31 62.07,59.48 64.43,61.85 65.92,61.85 v2(66.64,61.12) 72.1,61.12 74.01,63.03 74.01,65.14 77.05,68.18 77.9,68.18 78.33,68.61 v3(78.33,68.65)
PWRGD_CPU_VCCIO_R: length 3.2
  BOTTOM w0.109: v2(75.4,40.27) 75.66,40.01 R343.2 76.83,40.01 77.24,39.6 77.24,39.23 77.47,39 Q1.2
PWRGD_VP0P6_DDR4_VTT: length 230.5
  TOP w0.109: PU11.9 182.66,91.59 182.43,91.36 182.23,91.36 182.07,91.2 v3(181.96,91.2) PR191.2 ; U31.B16 v1(57.13,33.3)
  T10 w0.097: v3(181.96,91.2) 181.47,90.71 180.17,90.71 179.78,90.33 145.37,90.33 143.56,92.14 140.63,92.14 138.51,94.26 80.56,94.26 78.21,91.9 74.34,91.9 64.39,81.95 38.45,81.95 35.65,79.15 35.65,74.28 33.07,71.69 33.07,67.12 32.72,66.77 32.72,48.4 35.05,46.07 35.05,36.88 35.95,35.98 37.08,35.98 42.54,30.52 48.51,30.52 50.01,29.02 51.97,29.02 54.28,31.33 55.17,31.33 v1(57.13,33.3)
  BOTTOM w0.109: PR234.2 57.83,32.6 v1(57.13,33.3)
PWRGD_VP1P2_DDR4_VDD: length 206
  TOP w0.109: v3(50.65,22.19) 50.8,22.19 51.11,22.5 51.11,26.58 53.16,28.63 53.16,30.69 53.82,31.35 v3(53.82,31.77) ; U31.C14 v1(55.13,36.3)
  TOP w0.254: v3(196.24,32.83) 196.24,32.71 196.23,32.7 PU21.3
  T05 w0.097: v3(193.42,9.92) 193.42,12.21 192.89,12.74 192.89,15.03 191.72,16.19 191.72,25.64 193.17,27.09 193.17,28.85 196.24,31.92 v3(196.24,32.83)
  T08 w0.097: v3(50.65,22.19) 50.32,21.86 50.32,21.3 51.4,20.22 73.73,20.22 74.46,20.95 90.44,20.95 91.18,20.22 97.43,20.22 98.38,21.16 103.82,21.16 104.41,21.75 106.43,21.75 106.6,21.58 118.35,21.58 120.16,19.77 120.16,17.82 120.79,17.18 123.56,17.18 126.28,14.46 127.2,14.46 129.01,12.65 129.69,12.65 129.94,12.4 130.04,12.3 130.04,9.52 132.24,7.32 136.93,7.32 137.78,6.46 142.74,6.46 145.86,9.59 155.65,9.59 156.54,8.7 165.2,8.7 165.74,8.17 169.23,8.17 169.74,7.66 177.18,7.66 177.67,8.14 182.85,8.14 184.73,10.02 193.32,10.02 v3(193.42,9.92)
  BOTTOM w0.109: v3(53.82,31.77) 54.26,31.77 PR232.2 54.58,32.24 54.58,35.54 55.13,36.1 v1(55.13,36.3)
  BOTTOM w0.152: PR203.2 v2(196.72,34.41) 196.24,33.92 v3(196.24,32.83)
PWRGD_VP1P3: length 54.1
  TOP w0.109: U31.P13 v1(44.15,36.3)
  TOP w0.254: PU5.3 54.25,75.34 v3(54.42,75.52) PR13.2
  T03 w0.097: v3(54.42,75.52) 46.99,68.09 45.65,68.09 42.52,64.95 42.52,57.21 40.02,54.72 v3(39.61,54.72)
  T08 w0.097: v3(39.61,54.72) 39.61,52.23 39.88,51.96 39.88,47.2 42.52,44.56 42.52,38.01 44.01,36.53 44.01,36.44 v1(44.15,36.3)
  BOTTOM w0.109: PR219.2 41.29,35.72 43.2,35.72 43.77,36.3 v1(44.15,36.3)
PWRGD_VP1P05: length 49.7
  TOP w0.089: U31.H16 U31.H15 U31.G15
  TOP w0.109: PR277.2 73.63,50.79 73.03,50.18 73.03,43.95 v3(75.16,41.82) ; U31.H16 v1(51.13,33.3)
  TOP w0.254: PU27.3 72.74,52.25 73.15,51.83 PR277.2
  T08 w0.097: v3(66.03,33.01) 65.93,32.91 60.53,32.91 59.62,33.82 51.65,33.82 v1(51.13,33.3)
  BOTTOM w0.109: v3(75.16,41.82) 75.97,41.82 76.55,41.23 R343.1 75.99,40.83 75.89,40.92 72.27,40.92 66.03,34.67 66.03,33.02 v3(66.03,33.01) ; v1(51.13,33.3) 51.61,32.82 PR227.2
PWRGD_VP1P5: length 65.7
  TOP w0.109: U31.T12 v1(42.04,37.79)
  TOP w0.254: PR11.2 43.2,67.33 v3(43.46,67.07) 43.46,67.06 43.46,66.64 43.79,66.31 44.09,66 PU6.3
  BOTTOM w0.109: v3(43.46,67.07) 43.46,66.66 45.84,64.28 47.39,64.28 48,63.68 48,58.78 48.53,58.24 48.53,53.18 48.15,52.8 44.2,52.8 43.55,52.15 43.55,51.36 44.03,50.89 44.86,50.89 45.77,49.97 45.77,48.02 43.94,46.19 41.45,46.19 40.96,46.68 37.47,46.68 35.03,44.24 35.03,40.05 36.74,38.34 v2(40.47,38.34) 41.02,37.79 v1(42.04,37.79) 42.99,36.85 44.32,36.85 44.7,36.47 44.7,35.94 43.99,35.22 43.21,35.22 42.64,34.65 42.64,31.71 PR238.2
PWRGD_VP1P05_M: length 6.9
  BOTTOM w0.109: R341.2 75.91,37.92 76.55,37.28 v2(76.94,37.28) 78.24,37.28 79.31,38.35 Q1.6 79.92,38.39 80.49,38.39 80.61,38.51 80.61,38.9 80.5,39 Q1.5
PWRGD_VP1P05_PCH: length 96.9
  TOP w0.254: PU24.6 88.43,31.26 88.07,30.9 v3(87.76,30.9) 87.76,30.59 87.45,30.27 PR26.2
  TOP w0.381: U31.J15 v1(49.15,34.3) ; PR236.2 38.3,60.8 36.7,59.2 v3(36.7,59.19) ; U31.F12 v1(53.13,37.3)
  T05 w0.381: v3(49.48,26.83) 49.48,28.37 50.84,29.73 50.84,32.6 v1(49.15,34.3)
  T08 w0.381: v3(36.7,59.19) 36.97,59.19 37.94,58.22 37.94,57.45 39.62,55.77 40.05,55.77 40.66,55.15 40.66,52.56 40.82,52.4 40.82,48.69 46.1,43.41 46.1,42.71 45.49,42.1 45.49,40.78 46.12,40.15 46.12,37.32 v1(49.15,34.3)
  BOTTOM w0.381: v3(87.76,30.9) 87.47,30.9 84.04,34.33 73.55,34.33 72.51,35.37 70.36,35.37 69.42,34.43 69.42,33.11 68,31.69 62.33,31.69 61.04,30.39 61.04,28.54 60.06,27.57 51.5,27.57 50.77,26.83 v3(49.48,26.83) ; v1(49.15,34.3) 49.15,34.71 50.39,35.95 51.88,35.95 53.13,37.21 v1(53.13,37.3)
PWRGD_VP1P7: length 117.5
  TOP w0.089: v1(42.13,36.23) 42.26,36.36 43.2,36.36 U31.R13
  TOP w0.254: v3(26.31,92.91) 26.43,92.79 26.43,91.16 26.72,90.87 PR33.2 28.05,90.87 PC112.1 28.07,90.23 28.35,89.95 PU14.14 ; PR224.2 18.54,92.52 v3(18.9,92.88)
  T08 w0.097: v1(42.13,36.23) 42,36.23 41.88,36.36 37.48,36.36 34.31,39.53 34.31,42.86 31.97,45.2 30.77,45.2 29.38,46.58 29.38,51.06 25,55.45 24.44,55.45 22.11,57.77 9.16,57.77 6.48,60.45 4.96,60.45 1.52,63.88 1.52,79.44 4.29,82.2 8.22,82.2 v3(18.9,92.88) 21.11,92.88 21.81,93.58 25.79,93.58 26.31,93.06 v3(26.31,92.91)
PWRGD_VP2P5_DDR4_VPP: length 205.7
  TOP w0.254: v7(149.81,85.89) 150.4,86.47 PU20.4
  TOP w0.381: U31.D14 v1(55.13,35.3)
  T10 w0.381: v1(55.13,35.3) 55.13,34.42 54.34,33.63 52.26,33.63 49.77,31.14 42.81,31.14 39.1,34.86 39.1,42.91 33.34,48.67 33.34,66.21 35.6,68.48 35.6,71.58 36.32,72.29 36.32,76.4 38.17,78.25 38.17,80.04 39.03,80.9 40.49,80.9 41.08,80.31 44.67,80.31 45.69,81.33 64.64,81.33 68.65,85.33 84.46,85.33 91.06,91.93 97.18,91.93 98.8,93.55 138.29,93.55 139.65,92.19 139.65,91.48 140.29,90.84 140.29,89.11 143.51,85.89 v7(149.81,85.89)
  BOTTOM w0.381: v7(149.81,85.89) 149.86,85.89 150.17,86.2 PR79.2 150.12,88.25 PC322.1 147.93,88.25 PR265.1 ; v1(55.13,35.3) 55.23,35.3 56.31,34.22 v2(57.12,34.22) 58.11,34.22 58.44,33.89 PR229.2
PWRGD_VP3P3: length 144.7
  TOP w0.089: U31.T15 v1(42.16,34.31)
  TOP w0.254: PR221.2 50.84,75.11 50.4,74.66 v3(50.35,74.66)
  TOP w0.381: PR221.2 50.84,77.1 51.17,77.43 51.17,79.12 50.82,79.47 PR242.2 50.37,79.51 PU2.4
  T08 w0.097: v3(50.35,74.66) 45.22,74.66 41.6,78.28 40.17,78.28 35.93,82.51 35.93,88.96 33.55,91.34 26.24,91.34 25.75,91.84 21.71,91.84 11.31,81.44 6.52,81.44 2.22,77.14 2.22,64.65 5.79,61.08 6.69,61.08 9.41,58.37 22.36,58.37 24.69,56.05 27.88,56.05 30.19,53.73 30.19,50.97 35.33,45.83 36.38,45.83 39.09,43.12 39.09,38.57 40.59,37.07 41.89,37.07 42.56,36.4 42.56,34.71 v1(42.16,34.31)
PWRGD_VP3P3_A: length 58.1
  TOP w0.109: U31.N16 v1(45.64,33.1)
  TOP w0.254: PU25.6 v3(41.22,79.11) 41.22,80.01 PR252.2
  T03 w0.097: v3(39.12,55.35) 39.15,55.39 40.24,55.39 42.22,57.37 42.22,65.16 44.42,67.36 44.42,75.91 v3(41.22,79.11)
  T08 w0.097: v3(39.12,55.35) 39.15,55.35 39.35,55.15 39.79,55.15 40.04,54.9 40.04,52.3 40.2,52.14 40.2,47.3 43.66,43.84 43.66,38.13 45.64,36.15 v1(45.64,33.1)
  BOTTOM w0.109: v1(45.64,33.1) 45.64,32.4 C174.1 45.13,31.88 PR241.2
PWRGD_VP5P0: length 9.8
  TOP w0.254: PR218.2 6.46,41.72 PR17.1 PR244.2 6.46,44.13 6.68,44.36 6.68,45.21 v3(6.97,45.5) ; PU1.4 v7(7.43,49.73)
  BOTTOM w0.381: v3(6.97,45.5) 6.89,45.59 PC13.1 6.89,49.19 v7(7.43,49.73)
PWRUP_RST_L: length 14.2
  TOP w0.109: U31.N2 v1(45.15,48.28) ; U34.1 R385.2 42.16,56.45 42.16,55.52 42.39,55.29 C173.1 41.63,54.25 v3(41.63,49.83)
  BOTTOM w0.109: v1(45.15,48.28) 44.65,48.78 41.78,48.78 41.66,48.91 41.66,49.8 v3(41.63,49.83)
RST_CPLD_CPU_RSMRST_L: length 6.7
  TOP w0.109: U18.2 37.47,45.12 R212.1 38.18,45.1 v3(38.31,45.23) 38.87,45.79 U31.T4
RST_PCIE_PCH_N_GPIO19: length 15.2
  TOP w0.089: U1.BT3 134.07,29.3 134.07,28.53 134.21,28.39 134.21,27.78 133.87,27.45 133.87,23.59 135.86,21.61
  TOP w0.109: 135.86,21.61 138.65,18.81 v3(138.65,18.7) R245.1
  BOTTOM w0.109: R245.1 v3(138.65,18.7)
RST_PLTRST_L: length 120.7
  TOP w0.089: 58.77,37.3 57.13,37.3 U31.B12
  TOP w0.109: C171.1 61,37.73 v3(60.57,37.3) 60.2,37.68 59.15,37.68 58.77,37.3
  TOP w0.152: v1(128.18,39.28) 128.42,39.28 U1.BE24
  T05 w0.089: v1(128.18,39.28) 128.12,39.28 127.42,38.59 127.42,35.6 126.38,34.55 119.01,34.55 118.29,33.84 111.91,33.84 111.79,33.71 109.39,33.71 105.55,37.55
  T05 w0.097: v3(60.57,37.3) 60.58,37.3 62.23,35.65 62.23,30.57 64.85,27.96 v3(64.85,27.35) ; v3(72.4,39.18) 72.93,39.71 77.59,39.71 78.9,38.4 104.71,38.4 105.55,37.55
  T08 w0.097: v3(60.57,37.3) 65.94,37.3 67.82,39.18 v3(72.4,39.18)
  BOTTOM w0.109: v3(64.85,27.35) 64.85,23.97 59.44,18.56 46.05,18.56 44.65,19.96 v2(44.58,19.96) R103.1
RST_PLTRST_LPC_L: length 5.5
  TOP w0.109: v3(41.22,19.75) 41.56,19.41 J1.5
  BOTTOM w0.109: v2(41.86,18.89) 41.86,19.12 v3(41.22,19.75) 41.43,19.96 R103.2
RST_RSMRST_L: length 157.9
  TOP w0.089: U1.AV4 125.4,29.83 124.92,29.83 124.68,29.58 124.68,29.3 124.86,29.12 124.86,28.77 124.68,28.59 124.68,27.89 124.63,27.83 124.63,27.51 124.99,27.15 124.99,26.36
  TOP w0.102: U1.AV4 125.36,30.09 124.86,30.09 124.51,30.44 124.51,30.73
  TOP w0.109: U31.R4 43.62,45.79 43.18,46.23 40.77,46.23 39.61,47.39 v3(39.34,47.39) C172.1 ; 124.99,26.36 124.99,21.66 125.6,21.05 125.6,19.56 v3(126.46,18.7) R87.2
  TOP w0.127: U1.AR7 124.51,30.73
  T05 w0.097: v3(126.46,18.7) 126.46,18.81 123.58,21.69 119.58,21.69 119.28,21.99 114.9,21.99 114.59,21.67 105.76,21.67 104.98,20.9 104.98,20.52 v3(106.6,18.9) ; v3(39.34,47.39) 39.34,45.5 37.83,43.99 37.65,43.82 36.6,42.76 35.18,41.35 35.18,38.24 34.78,37.84 34.78,18.19 v3(35.18,17.8)
  T08 w0.097: v3(106.6,18.9) 106.78,18.72 106.78,16.75 106.2,16.17 105.31,16.17 103.12,18.35 99.03,18.35 98.57,17.9 98.4,17.72 87.36,17.72 86.39,16.76 86.39,15.66 86.26,15.54 85.8,15.54 85.27,16.07 64.55,16.07 63.45,17.17 36.38,17.17 35.75,17.8 v3(35.18,17.8)
RST_SRTCRST_L: length 101.5
  TOP w0.108: v1(123.7,26.31) 123.61,26.39 123.61,27.15 123.39,27.38 123.39,27.74 123.59,27.95 123.59,28.52 123.88,28.8 123.88,29.09 123.53,29.44 U1.AP4
  TOP w0.109: v3(198.25,5.6) 197.49,6.37 J3.1
  T08 w0.089: v1(123.7,26.31) 123.7,21.61
  T08 w0.097: v3(198.25,5.6) 198.25,7.28 194.21,11.32 192.28,11.32 191.71,10.75 184.34,10.75 182.54,8.96 172.96,8.96 172.72,8.72 170.27,8.72 167.88,11.11 145.38,11.11 143.39,9.13 135.43,9.13 134.57,9.98 133.28,11.27 133.28,12.1 131.04,14.35 130.97,14.35 130.43,14.88 130.43,15.72 128.72,17.43 127.12,17.43 123.7,20.86 123.7,21.61
  BOTTOM w0.109: v3(198.25,5.6) 198.63,5.22 R130.2 C35.1
RST_TPM_N: length 78.9
  TOP w0.109: R310.1 R352.2 185.29,11.7 184.4,12.59 173.03,12.59 172.09,13.54 160.21,13.54 v3(159.13,12.46)
  TOP w0.14: v1(134.18,37.55) U1.BV20
  BOTTOM w0.089: v1(134.18,37.55) 134.31,37.55 134.71,37.14 142.44,37.14 v2(143.1,36.48) 143.81,35.76 143.81,32.83 139.06,28.08 139.06,22.75 140.21,21.61
  BOTTOM w0.109: 140.21,21.61 145.16,16.65 154.94,16.65 v3(159.13,12.46)
RTCRST_L: length 203.9
  TOP w0.109: v3(88.01,23.71) 88.01,23.99 86.97,25.04 82.7,25.04 80.67,23 66.5,23 64.14,25.37 v3(64.14,27.32) ; v3(193.93,5.6) 195.28,5.6 196.49,6.82 R312.2 R129.2 C33.1 200.3,12.69 202.56,10.43 J3.3
  TOP w0.152: U1.AP9 v1(123.29,31.82)
  T08 w0.089: v1(123.29,31.82) 122.87,32.25 119.53,32.25 118.71,33.07 116.73,33.07 116.47,32.81 116.47,31.76 116.61,31.61 116.61,29.68 115.53,28.59 105.55,28.59
  T08 w0.097: v3(88.01,23.71) 88.11,23.61 94.39,23.61 95,24.22 95,27.17 96.42,28.59 105.55,28.59
  T10 w0.089: 120.22,22.05 120.22,24.86 122.17,26.81 122.17,30.31 123.29,31.43 v1(123.29,31.82)
  T10 w0.097: 120.22,22.05 120.22,19.4 120.09,19.27 120.09,15.12 120.6,14.62 123.27,14.62 125.45,12.44 125.45,5.46 127.25,3.67 141.76,3.67 v3(142.37,3.06)
  BOTTOM w0.109: R461.2 v2(59.82,21.23) 59.92,21.23 64.14,25.44 v3(64.14,27.32) ; v3(193.93,5.6) 193.93,4.33 191.2,1.61 143.82,1.61 v3(142.37,3.06)
SATA0GP_GP21: length 8.5
  TOP w0.089: v1(132.6,23) 133.28,23.68 133.28,27.76 133.43,27.91 U1.BR2
  BOTTOM w0.089: v2(130.9,21.88) TP6.1 132.24,22.64 v1(132.6,23)
SATA3_SSD_RX_N: length 3.9
  BOTTOM w0.135: C202.1 69.11,75.33 68.84,75.05 67.44,75.05 66.9,75.58 66.42,75.58 66.31,75.69 J9.43
SATA3_SSD_RX_P: length 3.9
  BOTTOM w0.135: J9.41 66.3,75.19 66.36,75.25 66.77,75.25 67.3,74.72 68.84,74.72 69.11,74.44 C201.1
SATA3_SSD_TX_N: length 3.7
  BOTTOM w0.135: J9.47 66.03,76.69 66.05,76.71 66.35,76.71 66.39,76.75 68.76,76.75 C203.1
SATA3_SSD_TX_P: length 3.7
  BOTTOM w0.135: C204.1 69.04,77.33 69.04,77.33 68.78,77.08 66.36,77.08 66.25,77.19 J9.49
SATA_P2_RX_N: length 96.6
  TOP w0.089: v1(135.66,43.56) U1.CA33
  T10 w0.089: 124.27,63.18 arc(124.35,63.07) 124.37,62.93 124.37,60.33 124.37,60.33 124.37,60.21 arc(124.32,59.96) 124.19,59.76 123.97,59.54 arc(123.88,59.41) 123.85,59.25 123.85,58.67 arc(123.81,58.48) 123.71,58.32 123.64,58.26 arc(123.52,58.09) 123.48,57.88 123.48,54.82 arc(123.52,54.63) 123.63,54.46 123.66,54.43 123.73,54.37 123.76,54.34 arc(123.85,54.2) 123.88,54.04 123.88,52.97 arc(123.93,52.73) 124.06,52.54 124.17,52.42 124.39,52.21 arc(124.52,52.01) 124.57,51.78 124.57,51.7 arc(124.52,51.48) 124.4,51.3 123.92,50.82 123.81,50.71 arc(123.6,50.39) 123.53,50.02 123.53,46.03 arc(123.61,45.62) 123.84,45.27 123.92,45.19 124.33,44.78 124.6,44.52 arc(124.94,44.28) 125.35,44.2 129.14,44.2 arc(129.54,44.28) 129.87,44.51 129.93,44.56 130.36,45 arc(130.81,45.3) 131.35,45.41 133.66,45.41 arc(134.02,45.33) 134.32,45.13 134.59,44.86 arc(134.72,44.67) 134.77,44.43 134.77,44.36 arc(134.78,44.29) 134.82,44.22 135.3,43.75 135.37,43.68 arc(135.5,43.59) v1(135.66,43.56)
  T10 w0.135: v3(70.75,75.47) 70.75,75.15 arc(70.81,75.02) 70.94,74.96 71.18,74.96 arc(71.58,74.8) 71.75,74.4 71.75,71.66 arc(71.84,71.21) 72.09,70.83 74.94,67.99 arc(75.12,67.86) 75.34,67.82 79.61,67.82 arc(79.76,67.85) 79.88,67.93 arc(80.08,68.06) 80.31,68.11 83.03,68.11 arc(83.21,68.07) 83.36,67.97 arc(83.41,67.94) 83.47,67.93 108.36,67.93 arc(108.71,68) 109.01,68.2 109.33,68.51 arc(109.8,68.83) 110.36,68.94 114.68,68.94 arc(115.1,68.86) 115.45,68.62 arc(115.74,68.43) 116.09,68.36 117.87,68.36 arc(118.17,68.3) 118.42,68.13 arc(118.57,68.03) 118.74,68 120.68,68 arc(120.98,67.94) 121.23,67.77 121.49,67.52 arc(121.69,67.21) 121.76,66.85 121.76,66.09 arc(121.83,65.72) 122.04,65.41 124.27,63.18
  BOTTOM w0.135: C202.2 69.93,75.3 70.15,75.07 70.48,75.07 70.75,75.34 v3(70.75,75.47)
SATA_P2_RX_P: length 96.6
  TOP w0.089: v1(135.17,42.7) U1.BY32
  T10 w0.089: v1(135.17,42.7) 135.2,42.73 135.2,43.34 arc(135.15,43.56) 135.03,43.75 134.69,44.09 arc(134.6,44.21) 134.58,44.36 134.58,44.43 arc(134.54,44.59) 134.45,44.73 134.19,45 arc(133.94,45.16) 133.66,45.21 131.34,45.21 arc(130.89,45.13) 130.5,44.87 129.96,44.32 arc(129.61,44.09) 129.21,44.01 125.32,44.01 arc(124.87,44.1) 124.49,44.36 123.79,45.06 123.71,45.14 arc(123.43,45.55) 123.34,46.03 123.34,50.02 arc(123.42,50.47) 123.68,50.84 123.77,50.94 124.14,51.31 124.27,51.43 arc(124.35,51.56) 124.38,51.7 124.38,51.78 arc(124.34,51.94) 124.25,52.07 124.04,52.29 123.93,52.4 arc(123.75,52.66) 123.69,52.97 123.69,54.04 arc(123.67,54.13) 123.62,54.21 123.5,54.32 123.5,54.33 arc(123.35,54.56) 123.29,54.82 123.29,57.91 arc(123.34,58.16) 123.48,58.37 123.49,58.38 arc(123.61,58.56) 123.66,58.79 123.66,59.31 arc(123.69,59.48) 123.79,59.63 124.05,59.89 arc(124.15,60.04) 124.18,60.21 124.18,60.41 124.18,60.41 124.18,62.59 arc(124.15,62.75) 124.07,62.89 arc(124.06,62.9) 124.06,62.9
  T10 w0.135: 124.06,62.9 121.8,65.15 arc(121.51,65.59) 121.41,66.1 121.41,66.85 arc(121.37,67.08) 121.24,67.27 120.98,67.52 arc(120.85,67.62) 120.68,67.65 118.74,67.65 arc(118.43,67.71) 118.17,67.89 arc(118.03,67.98) 117.87,68.01 115.94,68.01 arc(115.6,68.08) 115.31,68.27 115.22,68.36 arc(114.96,68.53) 114.67,68.59 110.44,68.59 arc(109.94,68.49) 109.52,68.21 109.26,67.95 arc(108.85,67.67) 108.36,67.58 83.4,67.58 arc(83.27,67.6) 83.16,67.68 arc(83.07,67.74) 82.96,67.76 80.35,67.76 arc(80.22,67.73) 80.11,67.66 arc(79.89,67.52) 79.65,67.47 75.34,67.47 arc(74.99,67.54) 74.69,67.74 74.57,67.87 72.18,70.25 71.85,70.58 arc(71.52,71.08) 71.4,71.66 71.4,74.4 arc(71.34,74.55) 71.18,74.61 70.89,74.61 arc(70.74,74.55) 70.68,74.39 v3(70.68,74.02)
  BOTTOM w0.135: C201.2 70.36,74.36 70.68,74.04 v3(70.68,74.02)
SATA_P2_TX_AC_N: length 104.5
  TOP w0.089: U1.BV28 134.33,40.69 134.18,40.78 v1(134.18,40.98)
  T10 w0.089: v1(134.18,40.98) 134.18,40.66 arc(134.28,40.51) 134.46,40.55 arc(134.55,40.67) 134.58,40.82 134.58,40.96 arc(134.62,41.19) 134.76,41.39 arc(134.79,41.42) 134.82,41.45 arc(134.85,41.47) 134.87,41.49 arc(135.01,41.63) 135.07,41.82 arc(135.07,41.89) 135.09,41.97 arc(135.1,41.99) 135.1,42.01 arc(135.2,42.19) 135.34,42.33 arc(135.44,42.41) 135.52,42.52 arc(135.55,42.56) 135.56,42.6 arc(135.58,42.68) 135.58,42.76 arc(135.64,43.03) 135.86,43.21 arc(136,43.32) 136.05,43.49 136.05,43.57 arc(136.02,43.7) 135.95,43.82 135.93,43.84 135.88,43.89 arc(135.84,43.92) 135.81,43.95 arc(135.78,43.97) 135.74,43.99 arc(135.62,44.14) 135.58,44.33 135.58,44.99 arc(135.5,45.38) 135.28,45.71 133.97,47.02 arc(133.54,47.67) 133.38,48.45 133.38,52.1 arc(132.95,53.14) 131.91,53.58 126.1,53.58 arc(125.9,53.62) 125.73,53.73 arc(125.58,53.83) 125.4,53.87 125.2,53.87 arc(124.93,53.92) 124.7,54.07 124.26,54.51 arc(124.08,54.79) 124.01,55.13 124.01,56.8 arc(124.09,57.21) 124.32,57.56 125.42,58.65 arc(125.59,58.91) 125.65,59.22 125.65,63.32 arc(125.67,63.45) 125.74,63.55
  T10 w0.135: 125.74,63.55 126.56,64.36 arc(126.79,64.71) 126.87,65.11 126.87,66.58 arc(126.77,67.05) 126.51,67.45 124.39,69.56 arc(124.14,69.73) 123.85,69.79 122.13,69.79 arc(121.95,69.75) 121.81,69.65 121.8,69.65 arc(121.65,69.54) 121.48,69.48 arc(121.43,69.48) 121.38,69.48 114.85,69.48 arc(114.81,69.48) 114.76,69.48 arc(114.6,69.54) 114.46,69.64 arc(114.3,69.75) 114.1,69.79 107.86,69.79 104.07,73.58 99.51,73.58 95.72,69.79 82.72,69.79 arc(82.45,69.84) 82.21,70 82.08,70.13 arc(81.93,70.23) 81.74,70.27 80.5,70.27 arc(80.35,70.24) 80.23,70.16 arc(79.95,69.97) 79.63,69.91 78.47,69.91 arc(78.22,69.96) 78.02,70.1 77.98,70.14 arc(77.77,70.27) 77.53,70.32 77.24,70.32 arc(76.61,70.45) 76.07,70.81 75.37,71.5 75.37,71.5 74.01,72.87 arc(73.78,73.21) 73.7,73.62 73.7,75.62 arc(73.64,75.92) 73.46,76.17 arc(73.18,76.36) 72.85,76.43 71.44,76.43 71.32,76.55 70.91,76.55 v3(70.76,76.39)
  BOTTOM w0.135: C203.2 69.93,76.52 70.05,76.64 70.57,76.64 70.76,76.45 v3(70.76,76.39)
SATA_P2_TX_AC_P: length 104.5
  TOP w0.089: U1.BW26 v1(134.67,40.12)
  T10 w0.089: v1(134.67,40.12) 134.77,40.21 134.77,40.96 arc(134.8,41.12) 134.89,41.26 arc(134.92,41.28) 134.94,41.31 arc(134.97,41.33) 135,41.35 arc(135.19,41.55) 135.26,41.81 arc(135.26,41.86) 135.27,41.92 arc(135.28,41.93) 135.28,41.95 arc(135.35,42.07) 135.45,42.17 arc(135.58,42.28) 135.68,42.41 arc(135.76,42.59) 135.77,42.78 arc(135.8,42.93) 135.93,43.04 135.93,43.03 arc(136.15,43.21) 136.24,43.49 136.24,43.57 arc(136.2,43.78) 136.08,43.95 136.06,43.98 136.01,44.03 arc(135.97,44.06) 135.93,44.1 arc(135.89,44.12) 135.86,44.14 arc(135.79,44.23) 135.77,44.33 135.77,44.99 arc(135.68,45.45) 135.42,45.84 134.11,47.15 arc(133.71,47.75) 133.57,48.45 133.57,52.1 arc(133.08,53.28) 131.91,53.77 126.1,53.77 arc(125.98,53.79) 125.87,53.86 arc(125.65,54.01) 125.4,54.06 125.23,54.06 arc(125.01,54.1) 124.82,54.23 124.67,54.37 124.4,54.65 arc(124.25,54.87) 124.2,55.13 124.2,56.8 arc(124.27,57.14) 124.46,57.42 125.55,58.52 arc(125.76,58.84) 125.84,59.22 125.84,63.07 arc(125.85,63.15) 125.9,63.21
  T10 w0.135: 125.9,63.21 126.8,64.12 arc(127.11,64.57) 127.22,65.11 127.22,66.65 arc(127.11,67.19) 126.8,67.65 124.69,69.76 arc(124.27,70.04) 123.78,70.14 122.06,70.14 arc(121.81,70.09) 121.61,69.95 arc(121.47,69.86) 121.31,69.83 114.92,69.83 arc(114.78,69.86) 114.66,69.94 arc(114.44,70.08) 114.18,70.14 108.01,70.14 104.22,73.93 99.36,73.93 95.57,70.14 82.9,70.14 arc(82.59,70.2) 82.33,70.37 arc(82.06,70.56) 81.74,70.62 80.5,70.62 arc(80.22,70.56) 79.98,70.4 arc(79.82,70.3) 79.63,70.26 78.47,70.26 arc(78.36,70.28) 78.26,70.35 78.23,70.38 arc(77.91,70.6) 77.53,70.67 77.24,70.67 arc(76.74,70.77) 76.32,71.05 75.52,71.85 75.52,71.85 74.26,73.11 arc(74.1,73.35) 74.05,73.62 74.05,75.62 arc(73.96,76.05) 73.71,76.42 arc(73.32,76.68) 72.85,76.78 71.59,76.78 71.46,76.91 70.99,77.38 v3(70.76,77.38)
  BOTTOM w0.135: v3(70.76,77.38) 69.96,77.38 C204.2
SATA_PRESENT_L_ST: length 3.7
  BOTTOM w0.109: R389.1 67.79,65.69 v2(67.53,65.44) 67.28,65.18 J9.1
SATA_SSD_PRESENT_L: length 16.7
  T05 w0.097: v3(69.44,68.49) 68.65,69.27 68.65,78.53 v3(69.29,79.16)
  BOTTOM w0.109: R389.2 69.97,66.99 v2(70.2,67.22) 70.2,67.72 v3(69.44,68.49) ; R391.2 R388.2 69.93,79.8 v3(69.29,79.16)
SATALED_L: length 39.1
  TOP w0.109: v3(144.4,11.75) 144.62,11.97 R29.2 145.99,12.45 D1.2
  TOP w0.152: U1.BF14 v1(129.22,34.11)
  T08 w0.089: v1(129.22,34.11) 128.84,33.73 127.66,33.73 127.34,33.41 127.34,32.52 127.61,32.25 127.61,31.2 127.89,30.91 127.89,22.04 128.33,21.61
  T08 w0.097: v3(144.4,11.75) 144.32,11.67 139.49,11.67 138.72,12.44 136.78,12.44 134.51,14.7 134.51,16.21 133.05,17.67 131.32,17.67 129.86,19.13 129.38,19.13 128.71,19.8 128.71,20.51 128.33,20.9 128.33,21.61
SFPP0_KR_RX0_AC_N: length 85.4
  TOP w0.099: v3(102.71,49.47) 102.72,49.47 103.04,49.15 103.29,49.15 103.53,49.39 C16.1
  T10 w0.102: v3(46.43,11.09) 46.08,11.45 46.08,14.81 arc(46.09,14.9) 46.14,14.97 46.85,15.68 arc(47.42,16.06) 48.1,16.2 48.41,16.2 arc(49.09,16.33) 49.67,16.72 52.83,19.88 arc(54.04,20.68) 55.46,20.97 56.08,20.97 arc(56.31,20.98) 56.54,20.98 arc(57.24,21.12) 57.83,21.52 arc(60.87,23.55) 64.46,24.26 65.39,24.26 arc(67.69,24.72) 69.65,26.03 72.89,29.27 arc(73.85,30.7) 74.19,32.39 arc(74.46,33.75) 75.23,34.91 76.24,35.92 arc(76.79,36.37) 77.42,36.72 77.51,36.74 77.52,36.75 77.91,36.83 77.96,36.83 arc(79.37,37.11) 80.56,37.91 81.64,38.99 arc(83.37,40.14) 85.4,40.55 96.27,40.55 arc(97.94,40.88) 99.36,41.82 99.45,41.92 arc(99.95,42.66) 100.12,43.53 100.12,43.54 arc(100.15,43.98) 100.24,44.41 arc(100.9,45.48) 102.06,45.99 arc(103.12,46.35) 103.94,47.11 arc(104.12,47.5) 104.14,47.92 arc(104.11,48.12) 104.07,48.32 arc(104.05,48.41) 104.02,48.49 arc(103.95,48.69) 103.88,48.89 arc(103.84,48.93) 103.8,48.97 arc(103.48,49.15) 103.12,49.21 102.97,49.21 v3(102.71,49.47)
  BOTTOM w0.099: J10.A30 46.35,8.45 46,8.8 46,10.67 v3(46.43,11.09)
SFPP0_KR_RX0_AC_P: length 85.1
  TOP w0.099: C14.1 103.53,48.68 103.38,48.83 103,48.83 102.72,48.55 v3(102.71,48.55)
  T10 w0.102: v3(102.71,48.55) 102.97,48.81 103.12,48.81 arc(103.35,48.78) 103.55,48.66 arc(103.6,48.52) 103.64,48.38 arc(103.71,48.13) 103.75,47.87 arc(103.73,47.59) 103.62,47.33 arc(102.91,46.69) 102.01,46.38 arc(100.65,45.78) 99.86,44.51 arc(99.76,44.03) 99.73,43.54 99.73,43.53 arc(99.58,42.81) 99.17,42.2 99.08,42.1 arc(97.79,41.24) 96.27,40.94 85.4,40.94 arc(83.22,40.5) 81.36,39.27 80.29,38.19 arc(79.22,37.48) 77.96,37.23 77.86,37.23 77.43,37.13 77.43,37.13 77.33,37.11 arc(76.6,36.72) 75.96,36.2 74.95,35.19 arc(74.09,33.9) 73.79,32.39 arc(73.49,30.86) 72.62,29.55 69.37,26.3 arc(67.54,25.08) 65.39,24.66 64.46,24.66 arc(60.72,23.91) 57.55,21.8 arc(57.09,21.49) 56.54,21.38 arc(56.3,21.37) 56.05,21.36 55.46,21.36 arc(53.89,21.05) 52.55,20.16 49.39,17 arc(48.94,16.7) 48.41,16.59 48.1,16.59 arc(47.27,16.43) 46.57,15.96 45.86,15.25 arc(45.73,15.05) 45.68,14.81 45.68,13.87 45.42,13.61 45.42,13.47 45.68,13.21 45.68,13 45.48,12.8 45.48,12.6 45.68,12.4 45.68,12.19 45.48,11.99 45.48,11.78 45.68,11.58 45.68,11.17 v3(45.6,11.09)
  BOTTOM w0.099: v3(45.6,11.09) 45.68,11.02 45.68,8.79 45.35,8.46 J10.A29
