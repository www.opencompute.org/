# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SFPP0_KR_RX0_N: length 15.6
  TOP w0.099: v3(105.17,49.47) 105.17,49.33 105.01,49.16 104.65,49.16 C16.2 ; U1.N62 v1(114.37,55.86)
  T10 w0.102: v1(114.37,55.86) 114.37,55.85 114.61,55.61 114.61,55.34 114.29,55.02 113.82,55.02 arc(113.32,54.86) 113.01,54.43 arc(112.94,54.02) 112.92,53.61 arc(112.93,53.41) 112.94,53.21 112.96,53.1 arc(112.97,53.04) 112.98,52.98 arc(112.71,52.12) 112.01,51.56 110.99,51.13 109.93,50.73 109.89,50.68 108.58,49.62 107.64,49.24 107.55,49.22 arc(107.34,49.19) 107.13,49.18 107.04,49.18 106.85,49.37 106.71,49.37 106.49,49.15 106.25,49.15 106.06,49.34 105.89,49.34 105.7,49.15 105.49,49.15 v3(105.17,49.47)
SFPP0_KR_RX0_P: length 15.9
  TOP w0.099: C14.2 104.66,48.85 105,48.85 105.17,48.67 v3(105.17,48.52)
  TOP w0.127: U1.R62 v1(115.36,55.86)
  T10 w0.102: v3(105.17,48.52) 105.41,48.76 106.41,48.76 107.14,48.78 arc(107.39,48.8) 107.62,48.84 arc(107.63,48.84) 107.64,48.84 107.76,48.87 108.78,49.28 110.17,50.4 111.14,50.76 111.69,51 arc(111.92,51.1) 112.16,51.2 arc(113.04,51.9) 113.37,52.98 arc(113.37,53) 113.37,53.02 arc(113.37,53.04) 113.37,53.05 113.33,53.26 arc(113.32,53.44) 113.31,53.62 arc(113.34,53.98) 113.41,54.34 arc(113.58,54.53) 113.82,54.63 114.45,54.63 115,55.17 115,55.5 v1(115.36,55.86)
SFPP0_KR_TX0_N: length 97.1
  TOP w0.099: v1(112.38,55.86) 112.16,56.09 arc(112.09,56.13) 112.02,56.15 U1.J62 ; J10.B28 44.35,8.4 44.01,8.74 44.01,10.95 v3(44.15,11.09)
  T10 w0.102: v3(44.15,11.09) 43.95,11.28 43.95,12.03 44.08,12.15 44.08,12.44 43.95,12.56 43.95,12.76 arc(44.41,15.06) 45.71,17 45.97,17.26 arc(46.39,17.54) 46.89,17.64 47.82,17.64 arc(48.72,17.82) 49.48,18.33 52.86,21.71 arc(53.76,22.32) 54.83,22.53 55.95,22.53 55.96,22.53 arc(56.05,22.53) 56.13,22.53 arc(57.24,22.79) 58.17,23.43 59.11,24.37 arc(60.57,25.35) 62.3,25.69 65.51,25.69 arc(67.34,26.05) 68.88,27.09 70.5,28.71 arc(70.95,29.37) 71.1,30.16 71.1,31.1 arc(71.36,32.41) 72.11,33.52 76.31,37.72 arc(76.92,38.13) 77.64,38.27 arc(79.08,38.56) 80.3,39.38 80.81,39.88 arc(82.95,41.31) 85.47,41.82 94,41.82 arc(95.72,42.16) 97.18,43.13 97.18,43.13 arc(97.2,43.14) 97.21,43.16 arc(98.02,44.34) 98.37,45.73 98.37,45.74 98.37,46 arc(98.59,47.07) 99.19,47.97 101.41,50.19 arc(101.8,50.45) 102.26,50.54 105.13,50.54 arc(105.24,50.55) 105.35,50.56 105.36,50.56 106.18,50.71 106.74,50.81 107.24,50.72 108.67,50.97 109.83,51.79 110.45,52.66 111.34,53.29 111.89,54.07 111.94,54.38 112.07,55.12 112.05,55.27 112.1,55.55 arc(112.11,55.58) 112.12,55.6 v1(112.38,55.86)
SFPP0_KR_TX0_P: length 97
  TOP w0.099: J10.B27 43.35,8.43 43.69,8.77 43.69,10.72 v3(43.32,11.09) ; v1(111.39,55.86) 111.25,56 arc(111.09,56.11) U1.F62
  T10 w0.102: v3(43.32,11.09) 43.56,11.33 43.56,12.76 arc(44.05,15.21) 45.43,17.28 45.69,17.54 arc(46.24,17.91) 46.89,18.04 47.82,18.04 arc(48.57,18.19) 49.2,18.61 52.58,21.99 arc(53.61,22.68) 54.83,22.92 56.11,22.92 56.12,22.92 arc(57.08,23.15) 57.9,23.71 58.83,24.65 arc(60.42,25.71) 62.3,26.09 65.51,26.09 arc(67.18,26.42) 68.6,27.36 70.22,28.99 arc(70.58,29.52) 70.71,30.16 70.71,31.1 arc(71,32.56) 71.83,33.8 76.03,38 arc(76.77,38.49) 77.64,38.67 77.64,38.67 arc(78.93,38.92) 80.02,39.65 80.53,40.16 arc(82.8,41.68) 85.47,42.21 94.01,42.21 arc(95.57,42.52) 96.9,43.41 96.93,43.43 arc(97.66,44.5) 97.97,45.75 arc(97.98,45.88) 97.98,46 97.98,46 arc(98.22,47.22) 98.91,48.25 101.13,50.47 arc(101.65,50.81) 102.26,50.94 105.13,50.94 arc(105.21,50.94) 105.29,50.95 106.11,51.09 106.74,51.21 107.24,51.12 108.51,51.34 109.55,52.07 110.16,52.94 111.06,53.57 111.52,54.22 111.72,55.39 111.71,55.48 111.54,55.71 v1(111.39,55.86)
SFPP1_KR_RX1_AC_N: length 85.8
  TOP w0.099: C15.1 103.13,52.36 102.91,52.36 102.63,52.08 v3(102.63,52.03)
  T10 w0.102: v3(42.26,9.74) 42,10 42,11.26 42,11.26 42,12.18 42.33,14.02 42.59,15.52 43.57,16.91 43.59,16.93 44.05,18 48.09,22.04 arc(50.02,23.33) 52.29,23.78 55.92,23.78 arc(56.73,23.94) 57.43,24.41 64.55,31.53 arc(64.64,31.62) 64.71,31.71 arc(65.08,32.37) 65.21,33.11 65.21,33.11 arc(65.21,33.11) 65.21,33.11 arc(65.26,33.39) 65.42,33.63 71.02,39.23 arc(71.04,39.24) 71.05,39.26 arc(72.2,40.02) 73.55,40.29 75.05,40.29 76.19,40.29 arc(79.16,40.88) 81.68,42.57 81.78,42.67 81.78,42.67 arc(82.57,43.19) 83.49,43.37 87.14,43.37 arc(89.71,43.88) 91.88,45.34 93.95,47.4 arc(94.51,47.78) 95.17,47.91 96.36,47.91 arc(97.3,48.1) 98.1,48.63 101.75,52.29 102.38,52.29 v3(102.63,52.03)
  BOTTOM w0.099: v3(42.26,9.74) 42.01,9.5 42.01,8.68 42.35,8.34 J10.A26
SFPP1_KR_RX1_AC_P: length 86.4
  TOP w0.099: C13.1 103.16,52.68 102.91,52.68 102.63,52.96 v3(102.63,52.98)
  T10 w0.102: 64.41,31.95 64.41,31.96 ; 64.41,31.95 64.41,31.96 ; 64.41,31.95 arc(64.41,31.95) 64.41,31.96 ; 64.41,31.95 arc(64.71,32.49) 64.81,33.11 arc(64.9,33.54) 65.14,33.91 70.77,39.53 arc(72.05,40.39) 73.55,40.69 74.88,40.69 74.88,40.69 76.19,40.69 arc(79.01,41.25) 81.4,42.85 arc(81.45,42.89) 81.51,42.94 arc(82.42,43.55) 83.49,43.77 87.14,43.77 arc(89.55,44.25) 91.6,45.62 93.67,47.68 arc(94.36,48.14) 95.17,48.31 96.36,48.31 arc(97.15,48.46) 97.82,48.91 101.59,52.68 102.34,52.68 v3(102.63,52.98) ; 64.41,31.96 arc(64.34,31.88) 64.28,31.81 57.15,24.69 arc(56.58,24.31) 55.92,24.17 52.29,24.17 arc(49.87,23.69) 47.81,22.32 43.72,18.23 43.26,17.16 43.16,17.01 42.22,15.67 41.94,14.09 41.62,12.25 41.61,12.25 41.61,11.43 41.61,11.42 41.61,9.92 v3(41.43,9.74)
  BOTTOM w0.099: v3(41.43,9.74) 41.69,9.48 41.69,8.69 41.35,8.35 J10.A25
SFPP1_KR_RX1_N: length 13.8
  TOP w0.099: v3(105.17,52.03) 105.17,52.12 104.93,52.37 104.6,52.37 C15.2 ; U1.T64 v1(114.86,57.29)
  T10 w0.102: v1(114.86,57.29) 114.71,57.29 114.56,57.14 114.56,56.81 114.31,56.55 arc(114.08,56.4) 113.81,56.35 110.82,56.35 arc(110.82,56.35) 110.81,56.35 110.79,56.35 110.69,56.36 110.68,56.36 110.64,56.36 110.25,56.29 108.97,55.4 108.54,54.78 107.26,53.88 106.43,52.7 105.92,52.34 105.87,52.29 105.43,52.29 v3(105.17,52.03)
SFPP1_KR_RX1_P: length 13.2
  TOP w0.099: C13.2 104.56,52.68 104.99,52.68 105.15,52.84 v3(105.15,52.98)
  TOP w0.127: U1.P64 v1(113.87,57.29)
  T10 w0.102: v3(105.15,52.98) 105.42,52.7 105.75,52.7 106.14,52.98 106.97,54.16 108.26,55.06 108.69,55.68 110.09,56.66 110.61,56.76 110.71,56.75 110.71,56.75 110.81,56.74 113.81,56.74 arc(113.93,56.77) 114.03,56.83 114.17,56.97 114.17,57.17 114.04,57.29 v1(113.87,57.29)
SFPP1_KR_TX1_N: length 99.6
  TOP w0.099: v3(40.17,11.06) 40.01,10.9 40.01,8.73 40.35,8.38 J10.B24
  TOP w0.127: U1.J66 v1(112.38,57.58)
  T10 w0.102: v3(40.17,11.06) 39.97,11.26 39.97,12.67 arc(40.52,15.41) 42.07,17.73 42.14,17.8 47.62,23.28 arc(49.53,24.55) 51.77,25 55.8,25 arc(56.26,25.09) 56.66,25.35 61.86,30.55 arc(62.47,31.48) 62.69,32.56 62.69,32.99 arc(62.85,33.8) 63.31,34.48 71.38,42.56 arc(71.97,42.95) 72.66,43.09 79.42,43.09 arc(80.12,43.23) 80.72,43.63 80.82,43.73 arc(82.31,44.72) 84.07,45.07 87.77,45.07 arc(89.45,45.41) 90.86,46.35 90.87,46.35 93.06,48.55 arc(93.76,49.02) 94.59,49.18 95.47,49.18 arc(96.65,49.42) 97.64,50.08 100.82,53.26 arc(101.63,53.8) 102.58,53.99 102.94,53.99 arc(103.41,54.09) 103.82,54.36 104.46,55 104.64,55.18 arc(104.96,55.39) 105.34,55.47 105.9,55.47 arc(106.58,55.6) 107.16,55.99 107.99,56.83 arc(108.27,57.02) 108.6,57.08 111.32,57.08 arc(111.84,57.19) 112.29,57.48 v1(112.38,57.58)
SFPP1_KR_TX1_P: length 99.6
  TOP w0.099: v3(39.35,11.06) 39.69,10.72 39.69,8.73 39.35,8.38 J10.B23 ; U1.F66 v1(111.39,57.58)
  T10 w0.102: v3(39.35,11.06) 39.58,11.3 39.58,12.67 arc(40.16,15.56) 41.79,18.01 41.79,18.01 46.82,23.03 47.34,23.56 arc(49.38,24.92) 51.77,25.39 55.8,25.39 arc(56.11,25.45) 56.38,25.63 61.58,30.83 arc(62.11,31.63) 62.3,32.56 62.3,32.99 arc(62.49,33.95) 63.03,34.76 71.11,42.83 arc(71.82,43.31) 72.66,43.48 79.42,43.48 arc(79.97,43.59) 80.44,43.9 80.54,44.01 arc(82.16,45.09) 84.07,45.47 87.77,45.47 arc(89.3,45.77) 90.59,46.63 90.7,46.75 92.78,48.83 arc(93.61,49.38) 94.59,49.58 95.47,49.58 arc(96.49,49.78) 97.36,50.36 98.94,51.94 100.54,53.54 arc(101.48,54.16) 102.58,54.38 102.95,54.38 arc(103.26,54.45) 103.53,54.62 104.22,55.32 104.34,55.43 arc(104.81,55.75) 105.37,55.86 105.9,55.86 arc(106.43,55.97) 106.88,56.27 107.67,57.07 arc(108.13,57.37) 108.66,57.48 108.84,57.65 109.07,57.65 109.24,57.48 109.47,57.48 109.65,57.65 109.88,57.65 110.05,57.48 110.29,57.48 110.46,57.65 110.69,57.65 110.87,57.48 111.15,57.48 arc(111.28,57.5) v1(111.39,57.58)
SKU_ID0: length 3.2
  TOP w0.109: U31.P5 v1(44.15,44.3)
  BOTTOM w0.109: R431.1 R432.1 43.82,44.62 v1(44.15,44.3)
SKU_ID1: length 4.5
  TOP w0.109: U31.P6 45.13,43.3 v1(45.15,43.3)
  BOTTOM w0.109: v1(45.15,43.3) 44.96,43.11 R434.1 R433.1
SKU_ID2: length 3.2
  TOP w0.109: U31.P7 v1(44.15,42.3)
  BOTTOM w0.109: v1(44.15,42.3) 44.15,41.14 R436.1 R435.1
SLP3_CPU_L: length 6
  TOP w0.152: U1.AC71 118.5,60.44 119.07,61 v1(119.32,61)
  BOTTOM w0.089: R96.1 118.41,63.8 R85.2 ; v1(119.32,61) 119.55,61 120.03,61.48
  BOTTOM w0.102: R96.1 118.4,63.66 120.03,62.03 120.03,61.48
SLP3_L: length 164.8
  TOP w0.089: U1.AY2 126.71,28.74 126.71,28.05 126.88,27.87 126.88,23.9 126.49,23.51 v1(126.49,23.13)
  TOP w0.109: U31.B9 v1(57.13,40.3)
  T03 w0.089: 105.55,66.15 107.12,64.58 116.65,64.58 v1(117.11,65.04)
  T03 w0.097: v3(47.14,63.65) 47.2,63.71 47.2,65.17 48.94,66.92 73.93,66.92 74.86,65.98 82.17,65.98 83.11,66.92 104.79,66.92 105.55,66.15
  T08 w0.097: v3(43.88,57.36) 44.44,56.79 44.44,54.11 53.71,44.84 54.75,44.84 55.59,43.99 55.59,41.84 v1(57.13,40.3)
  T10 w0.089: v1(126.49,23.13) 126.49,23.38 126.91,23.8 126.91,30.91 126.65,31.16 126.65,31.97 126.35,32.27 126.35,32.83 126.53,33.01 126.53,33.02 126.97,33.46 126.97,33.56 127.42,34.01 127.42,34.45 127.5,34.53 127.5,35.31 127.7,35.52 127.7,36.91 127.52,37.09 127.52,37.88 127.48,37.93 127.48,41.03 126.52,41.99 125.3,41.99 124.83,42.45 124.83,42.98 124.53,43.29 119.67,43.29 118.62,44.34 118.62,53.39 118.38,53.63 118.38,58.52 117.73,59.17 117.35,59.17 116.92,59.6 116.92,61.51 117.11,61.7 v1(117.11,65.04)
  BOTTOM w0.089: R85.1 117.49,64.66 v1(117.11,65.04)
  BOTTOM w0.109: v3(47.14,63.65) 46.99,63.5 46.99,59.02 46.99,59.01 46.99,58.65 46.61,58.28 U30.18 44.6,58.28 43.89,57.57 43.89,57.37 v3(43.88,57.36)
SLP4_L: length 108.8
  TOP w0.089: v1(125.69,24.78) 126.1,25.18 126.1,27.65 126.01,27.74 U1.AW1
  TOP w0.109: U31.C9 v1(56.13,40.3)
  T03 w0.097: v3(71.12,36.04) 70.32,36.85 61.85,36.85 57.99,40.71 56.42,40.71 56.13,40.43 v1(56.13,40.3)
  T05 w0.089: v1(125.69,24.78) 124.04,23.13 121.15,23.13 120.95,22.94 119.33,22.94
  T05 w0.097: v3(71.12,36.04) 71.12,35.9 72.77,34.26 75.49,34.26 77.09,32.66 77.09,27.6 79.83,24.86 80.19,24.86 80.26,24.93 87.4,24.93 88.47,23.87 88.47,23.1 89.25,22.32 111.94,22.32 112.92,23.3 114.65,23.3 115.01,22.94 119.33,22.94
  T08 w0.097: v3(43.92,55.77) 44.14,55.55 44.14,53.98 53.53,44.6 53.53,44.2 53.95,43.78 54.35,43.78 55.21,42.91 55.21,41.31 56.13,40.39 v1(56.13,40.3)
  BOTTOM w0.109: U30.14 44.02,55.68 v3(43.92,55.77)
SLPA_L: length 3.4
  TOP w0.152: U1.BB7 v1(126.52,30.75)
  BOTTOM w0.089: R83.2 125.71,29.26 v2(126.26,29.8) 126.26,30.49 v1(126.52,30.75)
SMB_CPU_XDP_LVC3_CLK: length 12.1
  TOP w0.109: R409.2 18.71,68.21 15.21,71.71 15.21,74.38 v3(15.08,74.51) 14.24,75.34 11.7,75.34 J12.53
SMB_CPU_XDP_LVC3_DAT: length 13.5
  TOP w0.109: J12.51 13.43,74.86 v3(13.71,74.58) 14.81,73.48 14.81,71.6 18.81,67.6 20.5,67.6 R407.2
SMB_HOST_3V3SB_ALERT_L: length 222.5
  TOP w0.109: v3(52.29,62.57) 53.36,62.57 58.24,67.45 64.14,67.45 65.02,68.34 65.02,70.37 64.5,70.9 U27.3 ; v3(28.83,14.89) 27.38,13.44 25.77,13.44 24.35,12.02 J10.B10 ; R188.1 v3(137.13,11.84)
  T05 w0.097: v3(28.83,14.89) 29.56,15.62 30.31,15.62 32.45,17.77 32.45,24.91 29.94,27.42 29.94,33.18 28.38,34.74 28.38,41.19 29.51,42.32 32.09,42.32 32.56,42.79 32.56,43.34 35.53,46.3 35.53,47.4 43.49,55.37 43.49,55.95 43.76,56.22 44.11,56.22 45.94,58.05 45.94,60.05 48.03,62.14 51.86,62.14 v3(52.29,62.57) ; v3(137.13,11.84) 136.37,12.61 136.37,15.88 135.07,17.18 126.95,17.18 125.45,18.68 125.45,18.97 123.33,21.09 119.25,21.09 118.95,21.39 115.15,21.39 114.84,21.07 108.18,21.07 107.13,20.02 v3(107.13,19.41)
  T08 w0.097: v3(28.83,14.89) 31.27,17.33 35.31,17.33 36.96,15.68 55.63,15.68 55.86,15.45 67.13,15.45 67.36,15.68 85.2,15.68 85.65,15.23 86.74,15.23 87.1,15.59 87.1,16.12 87.75,16.77 88.13,16.77 88.78,17.43 98.56,17.43 99.16,18.02 102.95,18.02 102.95,18.02 102.98,18.02 103.16,17.84 105.21,15.79 106.43,15.79 107.13,16.49 v3(107.13,19.41)
  BOTTOM w0.109: R188.1 v3(137.13,11.84) ; U30.1 51.83,62.18 52.16,62.52 52.24,62.52 v3(52.29,62.57)
SMB_HOST_3V3SB_ALERT_L_ST: length 20.8
  TOP w0.109: R188.2 v3(137.13,14.89)
  TOP w0.152: v1(130.68,30.89) 130.64,30.93 130.64,30.95 U1.BH7
  T08 w0.089: v1(130.68,30.89) 130.68,29.17 131.41,28.43 131.41,22.55 132.36,21.61
  T08 w0.097: v3(137.13,14.89) 136.62,15.4 136.62,16.97 135.07,18.53 135.07,19.03 134.51,19.58 134.51,20.15 133.96,20.7 133.26,20.7 132.36,21.61
SMB_HOST_3V3SB_CLK: length 286.7
  TOP w0.109: J10.B5 19.35,10.26 17.78,11.83 17.78,17.14 20.47,19.83 24.97,19.83 26.52,21.38 v3(27.25,21.38) ; 28.56,53.92 R317.1 ; 28.56,53.92 29.85,55.21 29.85,59.82 22.89,66.79 22.89,68.68 22.37,69.19 v3(21.51,69.19) 21.12,69.19 20.9,68.97 R155.2 20.88,68.21 R409.1 ; 28.56,53.92 28.56,54.75 v3(28.03,55.28) ; R324.1 v3(62.22,78.12) ; R187.1 v3(138.65,11.62)
  T05 w0.097: v3(138.65,11.62) 137.84,12.44 137.84,15.93 135.97,17.8 126.76,17.8 125.75,18.81 125.75,19.1 123.46,21.39 119.37,21.39 119.07,21.69 115.03,21.69 114.71,21.37 106.07,21.37 v3(105.41,20.72) ; v3(27.25,21.38) 27.81,21.93 27.81,32.67 26.54,33.94 26.54,45.46 28,46.92 28,48.61 28.55,49.16 28.55,54.76 v3(28.03,55.28)
  T08 w0.097: v3(62.22,78.12) 60.58,78.12 57.21,74.75 53.29,74.75 52.2,73.67 52.2,72.46 50.6,70.86 46.41,70.86 44.16,73.1 39.45,73.1 38.5,72.15 25.6,72.15 22.64,69.19 v3(21.51,69.19) ; v3(105.41,20.72) 104.95,20.26 98.75,20.26 97.81,19.32 84.13,19.32 83.44,18.63 82.88,18.63 81.28,20.22 74.58,20.22 73.06,18.7 43.75,18.7 41.45,21 36.53,21 35.71,20.18 28.45,20.18 v3(27.25,21.38)
  BOTTOM w0.109: R328.1 40.58,61.14 39.97,61.76 36.65,61.76 33.26,65.15 33.26,68.72 31.34,70.65 29.02,70.65 27.46,69.08 22.53,69.08 21.96,68.51 21.96,66.79 22.12,66.63 22.12,66.27 21.87,66.02 21.05,66.02 21.05,66.02 20.74,66.02 20.49,66.28 20.49,68.43 21.25,69.19 v3(21.51,69.19)
SMB_HOST_3V3SB_CLK_ST: length 23.9
  TOP w0.109: R187.2 v3(138.65,14.89)
  TOP w0.152: U1.BN11 v1(131.7,33.25)
  T08 w0.089: v1(131.7,33.25) 131.7,32.08 131.28,31.66 131.28,31.3 131.25,31.27 131.25,30.73 131.34,30.64 131.34,29.65 131.85,29.14 131.85,29.11 132.05,28.91 132.05,22.99 133.38,21.66 134.35,21.66 134.4,21.61
  T08 w0.097: 134.4,21.61 135.46,20.55 135.46,20.24 136.49,19.21 136.49,19.1 136.51,19.08 136.51,18.54 137.58,17.47 137.58,17.18 138.22,16.53 138.22,15.32 v3(138.65,14.89)
SMB_HOST_3V3SB_DAT: length 286.7
  TOP w0.109: v3(28.13,54.53) 28.13,54.48 27.55,53.91 R318.1 27.53,55.53 29.49,57.49 29.49,59.67 22.71,66.45 v3(21.68,66.45) 21.68,67.18 21.7,67.2 R407.1 ; v3(27.22,20.54) 26.62,20.54 25.48,19.4 20.8,19.4 18.26,16.85 18.26,11.86 20.35,9.77 J10.B6 ; R323.1 v3(62.22,76.85)
  T05 w0.097: v3(132.56,11.13) 133.27,11.84 133.27,16.49 132.91,16.85 125.71,16.85 124.86,17.7 121.12,17.7 120.92,17.9 120.92,19.56 120.06,20.42 116.76,20.42 116.09,21.09 115.27,21.09 114.96,20.77 108.49,20.77 v3(108.13,20.41) ; v3(27.22,20.54) 26.53,21.23 26.53,23.42 27.51,24.4 27.51,32.55 26.24,33.82 26.24,45.59 27.7,47.05 27.7,48.73 28.13,49.15 v3(28.13,54.53)
  T08 w0.097: v3(21.68,66.45) 27,71.77 38.89,71.77 39.92,72.8 43.82,72.8 46.23,70.4 50.7,70.4 52.55,72.25 52.55,73.6 53.41,74.46 57.42,74.46 58.8,75.84 61.2,75.84 v3(62.22,76.85) ; v3(108.13,20.41) 107.59,20.41 107.56,20.44 106.02,20.44 105.36,19.78 98.69,19.78 97.85,18.94 84.17,18.94 83.54,18.3 82.75,18.3 81.13,19.92 79.41,19.92 79.31,19.82 79.31,19.31 79.22,19.21 79.02,19.21 78.93,19.31 78.93,19.82 78.83,19.92 78.64,19.92 78.54,19.82 78.54,19.31 78.44,19.21 78.25,19.21 78.15,19.31 78.15,19.82 78.06,19.92 77.86,19.92 77.77,19.82 77.77,19.31 77.67,19.21 77.48,19.21 77.38,19.31 77.38,19.82 77.29,19.92 77.09,19.92 77,19.82 77,19.31 76.9,19.21 76.71,19.21 76.61,19.31 76.61,19.82 76.51,19.92 76.32,19.92 76.22,19.82 76.22,19.31 76.13,19.21 75.93,19.21 75.84,19.31 75.84,19.82 75.74,19.92 75.55,19.92 75.45,19.82 75.45,19.31 75.36,19.21 75.16,19.21 75.07,19.31 75.07,19.82 74.97,19.92 74.7,19.92 73.18,18.4 43.52,18.4 41.21,20.7 36.74,20.7 35.83,19.79 27.34,19.79 27.22,19.91 v3(27.22,20.54)
  BOTTOM w0.109: v3(132.56,11.13) 133.27,11.84 133.27,13.34 132.84,13.77 R154.2 131.92,14.41 131.92,16.14 R186.1 ; R329.1 36.91,62.14 33.62,65.42 33.62,68.94 31.56,71.01 28.65,71.01 27.1,69.46 22.4,69.46 21.32,68.38 21.32,68.38 21.25,68.3 21.25,66.89 v3(21.68,66.45)
SMB_HOST_3V3SB_DAT_ST: length 19.7
  TOP w0.152: U1.BJ13 v1(131.21,34.11)
  T08 w0.089: v1(131.21,34.11) 130.87,34.11 130.19,33.43 130.19,33.13 129.71,32.65 129.71,32.19 130.12,31.78 130.12,31.39 130.02,31.29 130.02,22.79 131.2,21.61
  T08 w0.097: 131.2,21.61 132.56,20.25 v3(132.56,19.97)
  BOTTOM w0.109: R186.2 131.92,18.22 131.92,19.34 v3(132.56,19.97)
SMB_INA230_ALRT_PROCHOT_L: length 118.3
  TOP w0.109: v3(127.98,9.56) R100.1 ; U31.B10 v1(57.13,39.3)
  TOP w0.152: v1(127.5,30.75) 127.74,30.99 U1.BC9
  T05 w0.097: v1(57.13,39.3) 56.72,38.88 56.72,37.69 60.73,33.68 60.73,25.47 64.15,22.04 68.41,22.04 70.32,20.13 81.2,20.13 83.4,17.94 87.55,17.94 91.64,13.84 96.47,13.84 97.82,15.2 119.35,15.2 119.97,15.82 123.47,15.82 126.92,12.37 126.92,10.62 v3(127.98,9.56)
  T10 w0.089: 127.81,21.61 127.81,30.45 v1(127.5,30.75)
  T10 w0.097: 127.81,21.61 127.81,21.48 127.95,21.34 127.95,20.63 127.55,20.23 127.55,9.99 v3(127.98,9.56)
  BOTTOM w0.109: R100.1 v3(127.98,9.56)
SMB_SMLINK0_3V3SB_ALRT: length 45.1
  TOP w0.152: U1.BL7 v1(130.71,31.54)
  T03 w0.089: 131.57,21.61 129.16,24.02 124.71,24.02 122.3,21.61
  T03 w0.097: v3(133.93,19.98) 132.44,21.48 131.7,21.48 131.57,21.61 ; v3(124.05,14.6) 122.1,14.6 120.65,16.04 120.65,19.83 121.28,20.46 121.28,20.59 122.3,21.61
  T08 w0.089: v1(130.71,31.54) 130.29,31.12 130.29,23.08 131.76,21.61
  T08 w0.097: 131.76,21.61 132.97,20.4 133.51,20.4 v3(133.93,19.98)
  BOTTOM w0.109: v3(124.05,14.6) 124.05,15.86 123.14,16.78 122.2,16.78 ; v3(133.93,19.98) 133.44,19.49 133.44,18.19 134.05,17.58 R64.2
SMB_SMLINK0_3V3SB_CLK: length 92.3
  TOP w0.109: R62.2 v3(139.92,18.32)
  TOP w0.152: U1.BR7 v1(132.69,31.54)
  T08 w0.089: v1(132.69,31.54) 132.69,29.97 134.77,27.9 134.77,22.74 135.24,22.27 135.98,22.27 136.64,21.61
  T08 w0.097: v3(139.92,18.32) 136.64,21.61
  BOTTOM w0.109: v3(139.92,18.32) 140.8,17.44 140.8,12.11 139.61,10.91 137.6,10.91 136.32,9.64 136.32,6.99 135.59,6.26 127.66,6.26 127.36,6.57 127.36,7.31 125.03,9.63 125.03,12.44 123.52,13.95 123.36,13.95 107.58,13.95 103.55,17.97 103.29,18.24 98.68,18.24 94.23,13.79 94.23,13.49 94.23,11.57 93.04,10.38 93.04,8.96 92.35,8.27 J10.A76
SMB_SMLINK0_3V3SB_DAT: length 89.7
  TOP w0.109: R63.2 v3(132.56,5.24)
  TOP w0.152: U1.BN18 v1(131.7,36.69)
  T10 w0.089: v1(131.7,36.69) 131.7,35.6 131.24,35.14 131.24,34.73 130.78,34.27 130.78,34.04 130.32,33.59 130.32,33.05 130.82,32.56 130.82,31.98 131.1,31.7 131.1,27.81 131.49,27.41 131.49,21.73 131.49,21.73 131.49,21.61
  T10 w0.097: v3(132.56,5.24) 131.95,5.84 131.95,21.14 131.49,21.6 131.49,21.61
  BOTTOM w0.109: J10.A77 93.42,6.27 93.42,10.25 94.59,11.42 94.59,13.64 98.83,17.88 103.04,17.88 107.33,13.59 123.37,13.59 124.67,12.29 124.67,9.28 126.95,7 126.95,6.33 127.38,5.9 131.89,5.9 v3(132.56,5.24)
SMB_SMLINK1_3V3SB_CLK: length 15.6
  TOP w0.152: U1.BG9 129.72,31.56 v1(129.73,31.55)
  T08 w0.089: v1(129.73,31.55) 129.83,31.45 129.83,22.46 130.69,21.61
  T08 w0.097: v3(131.03,20.1) 131.03,21.24 131.02,21.24 131.02,21.27 130.69,21.61
  BOTTOM w0.109: R59.2 130.4,18.22 130.4,19.46 v3(131.03,20.1)
SMB_SMLINK1_3V3SB_DAT: length 14
  TOP w0.152: U1.BB11 v1(127.82,33.34)
  T08 w0.089: v1(128.47,22.61) 128.97,23.11 128.97,31.03 128.82,31.17 128.82,32.34 v1(127.82,33.34)
  BOTTOM w0.089: R60.2 128.25,22.39 v1(128.47,22.61) v2(128.47,23.68)
SMI_ACTIVE_L: length 120.7
  TOP w0.089: v1(133.47,22.37) 133.47,27.64 133.64,27.81 133.64,28.53 133.77,28.66 133.77,29.1 133.43,29.44 U1.BR4
  TOP w0.109: R332.2 48.24,61.29 U28.2 48.24,59.32 v3(48.43,59.12)
  T03 w0.097: v3(96.65,23.89) 96.3,23.54 88.84,23.54 83.01,29.38 83.01,30.01 80.74,32.28 80.74,37.74 75.77,42.71 67.76,42.71 67.49,42.98 64.03,42.98 62.5,44.52 62.5,50.56 61.61,51.45 61.21,51.45 60.25,52.41 60.25,53.03 56.65,56.63 56.08,56.63 53.3,59.42 48.73,59.42 v3(48.43,59.12)
  T05 w0.089: v1(133.47,22.37) 132.35,22.37 130.98,23.73 130.27,23.73 128.65,25.35 124.66,25.35 123.16,23.85 121.26,23.85 120.94,24.16 119.9,24.16 119.27,23.54
  T05 w0.097: 119.27,23.54 115.26,23.54 114.89,23.9 112.52,23.9 112.27,23.66 107.7,23.66 107.24,23.2 97.34,23.2 v3(96.65,23.89)
SMI_ACTIVE_L_BUF: length 5.7
  TOP w0.109: U28.4 v3(47.59,57.15) 47.44,57.01 R325.2
  BOTTOM w0.109: v2(47.76,53.73) 47.44,54.05 47.44,57.06 47.55,57.17 47.57,57.17 v3(47.59,57.15)
SMI_ACTIVE_L_R: length 11.3
  TOP w0.109: R325.1 47.84,55.24 48.64,56.04 49.34,56.04 49.59,55.79 51.02,55.79 51.3,55.51 R326.2 51.97,55.28 52.04,55.34 52.16,55.34 v3(52.16,55.35)
  BOTTOM w0.109: v2(49.83,53.25) 49.83,53.37 49.17,54.03 49.17,55.51 49.34,55.68 U30.11 51.83,55.68 52.16,55.35 v3(52.16,55.35)
SPI_BUF_SSB_CLK: length 32.1
  TOP w0.109: v3(178.18,6.75) 178.1,6.83 175.24,6.83 174.01,8.06 J6.4 ; v3(161.75,7.59) 161.44,7.89 R422.1
  T03 w0.097: v3(161.75,7.59) 166.12,7.59 166.78,8.24 175.22,8.24 175.49,8.51 176.41,8.51 v3(178.18,6.75)
  BOTTOM w0.109: U20.14 178.91,7.47 178.89,7.44 178.88,7.44 v3(178.18,6.75) ; v2(163.5,9.92) 163.5,9.34 v3(161.75,7.59)
SPI_BUF_SSB_CLK_ST: length 12.7
  TOP w0.109: U23.6 159.63,6.76 v3(160.11,7.24) 160.63,7.76 R422.2
  BOTTOM w0.109: v2(166.54,7.32) 166.09,6.87 U24.6 160.48,6.87 v3(160.11,7.24)
SPI_BUF_SSB_CS0_L: length 23.2
  TOP w0.109: R228.2 166.37,4.99 v3(166.27,4.99) 166.04,4.77 166.04,4.49 165.78,4.22 U23.1 ; v3(176.3,5.65) 174.39,5.65 174.01,5.26 J6.3
  T03 w0.097: v3(166.27,4.99) 169.05,4.99 169.71,5.65 v3(176.3,5.65)
  BOTTOM w0.109: U20.12 178.91,8.77 178.89,8.74 178.88,8.74 176.3,6.16 v3(176.3,5.65) ; v3(166.27,4.99) 166.64,5.36 v2(166.64,5.85)
SPI_BUF_SSB_CS1_L: length 33.1
  TOP w0.109: v3(175.74,8.08) 176.44,7.38 178.44,7.38 179.09,6.73 J6.7
  T03 w0.097: v3(175.74,8.08) 175.23,7.57 169.23,7.57 168.88,7.23 166.7,7.23 163.65,4.18 v3(159.27,4.18)
  BOTTOM w0.109: v3(175.74,8.08) 175.74,8.26 175.23,8.77 U20.9 ; R304.2 155.54,3.1 155.83,2.81 v2(157.61,2.81) 157.9,2.81 v3(159.27,4.18) 159.12,4.33 U24.1
SPI_BUF_SSB_HOLD_L: length 13.3
  TOP w0.109: v3(161.51,5.62) 161.02,6.11 159.84,6.11 159.23,5.49 U23.7 156.69,5.49 v3(156.3,5.88)
  BOTTOM w0.109: v2(162.25,2.55) 161.51,3.28 v3(161.51,5.62) 164.61,5.62 164.63,5.6 U24.7 ; v3(156.3,5.88) 156.15,6.03 R227.2
SPI_BUF_SSB_MISO: length 15.3
  TOP w0.109: J6.5 176.55,4.86 v3(177.29,5.6) ; R443.1 v3(168.71,5.45)
  T03 w0.097: v3(168.71,5.45) 169.8,6.54 176.35,6.54 v3(177.29,5.6)
  BOTTOM w0.109: v3(177.29,5.6) 178.03,4.87 U20.18
SPI_BUF_SSB_MISO_ST: length 12.8
  TOP w0.109: R443.2 166.94,5.49 U23.2 163.72,5.49 163.41,5.19 160.68,5.19 v3(160.24,5.62)
  BOTTOM w0.109: U24.2 160.22,5.6 v3(160.24,5.62) 160.83,5.04 v2(160.83,2.6)
SPI_BUF_SSB_MOSI: length 39.6
  TOP w0.109: J6.6 176.55,8.49 177.15,7.89 179.32,7.89 v3(181.36,5.86) ; R421.1 v3(159.79,8.27)
  T03 w0.097: v3(159.79,8.27) 160.24,8.72 175.02,8.72 175.29,8.99 178.22,8.99 v3(181.36,5.86)
  BOTTOM w0.109: v3(181.36,5.86) 181.05,6.17 U20.16 ; v3(155.19,8.93) 155.8,9.54 157.86,9.54 159.13,8.27 v3(159.79,8.27)
SPI_BUF_SSB_MOSI_ST: length 12.1
  TOP w0.109: R421.2 v3(158.98,9.49) 158.98,8.25 158.77,8.03 U23.5
  BOTTOM w0.109: U24.5 164.81,9.81 163.78,10.84 160.43,10.84 v2(159.99,10.4) 159.72,10.4 158.98,9.67 v3(158.98,9.49)
SPI_BUF_SSB_WP_L: length 17.3
  TOP w0.109: v3(162.41,9.69) 162.71,9.69 163.37,9.03 165.74,9.03 166.95,7.81 R225.2 R226.1 166.91,6.76 U23.3
  BOTTOM w0.109: v2(154.94,7.13) 156.72,7.13 156.97,6.87 U24.3 159.01,6.87 161.83,9.69 v3(162.41,9.69)
SPI_MUX_SSB_CS0_L: length 17.5
  T03 w0.097: v3(182.19,11.61) 181.21,10.64 172.8,10.64 v3(172.79,10.65)
  BOTTOM w0.109: U21.3 182.19,11.61 v3(182.19,11.61) v2(181.17,11.61) ; U20.8 173.28,8.12 173.2,8.2 173.2,10.24 v3(172.79,10.65) U22.1
SPI_MUX_SSB_CS1_L: length 15.5
  T03 w0.097: v3(172.55,9.15) 172.86,9.47 182.29,9.47 v3(182.37,9.39)
  BOTTOM w0.109: U20.11 182.35,9.42 v3(182.37,9.39) 183.29,10.31 U21.1 ; U22.3 171.91,9.35 172.1,9.15 v3(172.55,9.15)
SPI_SSB_CLK: length 82.8
  TOP w0.089: U1.BG13 130.01,34.11 v1(130.21,34.11)
  T03 w0.097: v3(169.87,7.15) 169.94,7.07 177.17,7.07 178.81,5.43 181.53,5.43 181.79,5.68 181.79,6.43 v3(181.3,6.92)
  T05 w0.097: v3(169.87,7.15) 169.87,9.74 169.51,10.09 169.51,12.24 v3(169.04,12.72)
  T08 w0.089: 129.99,21.61 129.34,22.25 129.34,33.08 129.33,33.09 129.33,33.41 129.46,33.54 129.46,33.54 130.03,34.11 v1(130.21,34.11)
  T08 w0.097: v3(169.04,12.72) 168.08,13.67 146.12,13.67 145.45,13 140.89,13 140.79,13.1 140.45,13.44 139.6,13.44 139.21,13.83 137.52,13.83 136.14,15.2 136.14,16.72 134.59,18.28 134.59,18.8 133.89,19.49 132.36,19.49 132.23,19.62 130.9,19.62 130.55,19.97 130.55,21.04 129.99,21.61
  BOTTOM w0.109: R218.1 182.69,6.92 182.57,6.92 182.3,7.18 181.94,7.18 181.67,6.92 v3(181.3,6.92) ; v2(169.49,8.1) 169.49,7.52 v3(169.87,7.15) 169.91,7.1 R217.1
SPI_SSB_CLK_ST: length 3.2
  BOTTOM w0.109: R217.2 171.84,7.1 172.11,7.38 v2(172.54,7.38) 172.87,7.38 173.43,6.82 U20.6
SPI_SSB_CS0_L: length 70.6
  TOP w0.152: v1(131.7,31.54) U1.BN7
  T08 w0.089: 135.08,21.61 133.22,23.47 133.22,28 132.12,29.1 132.12,31.11 v1(131.7,31.54)
  T08 w0.097: 135.08,21.61 137.56,19.13 137.56,18.45 139.29,16.72 139.29,15.17 140.05,14.41 140.83,14.41 141.28,13.96 143.64,13.96 144.45,14.77 168.68,14.77 170.53,12.91 170.53,12.77 171.11,12.19 185.24,12.19 v3(185.51,12.46)
  BOTTOM w0.109: v2(184.3,12.81) 185.16,12.81 v3(185.51,12.46) U21.4
SPI_SSB_CS1_L: length 59.5
  TOP w0.089: v1(132.71,33.23) 132.71,33.24 U1.BT13
  T08 w0.089: 137.31,21.61 135.83,23.09 135.83,27.54 133.06,30.31 133.06,31.03 133.08,31.05 133.08,31.95 132.71,32.33 v1(132.71,33.23)
  T08 w0.097: 137.31,21.61 141.02,17.9 141.02,14.9 141.48,14.44 143.44,14.44 144.06,15.06 144.25,15.24 168.92,15.24 171.2,12.97 v3(171.2,12.72)
  BOTTOM w0.109: U22.4 169.81,9.35 170.15,9.69 170.15,11.23 171.2,12.28 v3(171.2,12.72)
SPI_SSB_MISO: length 95.3
  TOP w0.152: U1.BJ20 130.23,37.54 v1(130.21,37.55)
  T05 w0.097: v3(184.02,3.95) 183.17,3.09 176.4,3.09 176.16,3.33 171.87,3.33 171.53,2.99 170.56,2.99 170.41,2.84 169.89,2.84 169.53,3.2 169.53,3.87 v3(169.81,4.15) 169.34,4.63 169.34,8.59 168.28,9.65 v3(168.28,12.72)
  T08 w0.089: v1(130.21,37.55) 130.69,37.07 130.87,37.07 131.1,36.85 131.1,36.27 130.82,35.99 130.82,35.63 130.32,35.13 130.32,35.03 129.69,34.39 129.69,34.03 129.39,33.72 129.38,33.72 129.15,33.49 129.15,31.05 129.15,21.93 129.48,21.61
  T08 w0.097: v3(168.28,12.72) 167.95,13.04 150.43,13.04 149.93,12.53 139.3,12.53 139.24,12.59 138.48,13.35 136.54,13.35 135.08,14.81 135.08,16.32 133.12,18.27 132.07,18.27 131.21,19.13 130.72,19.13 130.08,19.77 130.08,20.73 129.48,21.33 129.48,21.61
  BOTTOM w0.109: v2(164.19,13.27) 167.72,13.27 v3(168.28,12.72) ; v3(184.02,3.95) 184.02,4.5 183.17,5.35 R40.1 ; v3(169.81,4.15) 169.91,4.05 R215.1
SPI_SSB_MISO_ST: length 4.2
  BOTTOM w0.109: U20.2 173.49,4.22 173.16,3.89 171.57,3.89 R215.2 171.41,3.11 v2(171.58,2.94)
SPI_SSB_MOSI: length 66.8
  TOP w0.152: U1.BL11 v1(130.71,33.25)
  T05 w0.097: v3(170.05,12.72) 170.43,12.34 170.43,5.63 v3(169.87,5.07)
  T08 w0.089: v1(130.71,33.25) 130.71,32.08 131.1,31.7 131.1,31.38 131.06,31.34 131.06,29.67 131.67,29.07 131.67,22.97 133.03,21.61
  T08 w0.097: v3(170.05,12.72) 168.48,14.29 146.06,14.29 145.26,13.48 141.08,13.48 140.94,13.63 140.65,13.92 139.8,13.92 139.41,14.31 138.56,14.31 137.64,15.23 137.64,16.13 137.1,16.67 137.1,17.28 136.03,18.34 136.03,18.88 134.99,19.93 134.99,20.35 134.16,21.18 133.46,21.18 133.03,21.61
  BOTTOM w0.109: R39.1 170.54,5.13 R216.1 v3(169.87,5.07) ; v3(170.05,12.72) 169.54,12.21 v2(169.54,11.95)
SPI_SSB_MOSI_ST: length 3.4
  BOTTOM w0.109: U20.4 173.39,5.52 v2(172.51,4.64) 172.01,4.64 171.58,5.07 R216.2
SRC1CLKRQB_GP18: length 6.4
  TOP w0.089: U1.BN4 132.44,29.73 132.6,29.57 132.6,29.3 132.78,29.12 132.78,28.5 132.71,28.44 132.65,28.37 132.65,28.05 132.86,27.83 132.86,26.74 v1(132.48,26.36)
  BOTTOM w0.089: v1(132.48,26.36) 132.91,26.36 TP8.1 133.49,27.32 v2(132.95,27.87)
SUS_WARN_L: length 1.2
  TOP w0.152: U1.AY11 v1(125.76,32.68)
  BOTTOM w0.102: R82.2 125.47,32.41 125.74,32.68 v1(125.76,32.68)
SVID_CPU_ALERT_L: length 329.1
  TOP w0.109: PR175.2 v3(71.25,46.75) PR109.1 ; PR172.1 72.87,72.91 v3(72.74,72.79)
  T03 w0.097: v3(72.74,72.79) 73.59,71.93 73.59,69.66 75.51,67.75 80.29,67.75 80.78,68.24 81.46,68.24 81.73,68.51 82.3,68.51 84.19,70.4 95.64,70.4 99.35,74.11 103.01,74.11 103.27,73.85 106.64,70.48 117.37,70.48 117.74,70.48 118.59,69.63 120.39,69.63 123.43,66.59 v1(123.62,66.59)
  T05 w0.097: v3(93.96,16.18) 93.89,16.25 92.65,16.25 87.55,21.35 85.3,21.35 83.49,23.15 76.24,23.15 75.02,24.37 75.02,29.92 72.14,32.81 70.95,32.81 69.66,34.09 69.66,39.51 70.99,40.83 70.99,46.5 v3(71.25,46.75) 71.73,47.23 78.58,47.23 80.69,45.12 87.63,45.12 89.16,46.65 89.16,63.89 85.39,67.66 80.62,67.66 80.27,67.32 74.39,67.32 72.61,69.1 72.61,69.46 72.61,71.34 72.35,71.61 72.35,71.97 72.74,72.36 v3(72.74,72.79)
  T10 w0.097: v3(202.39,32.29) 203.3,31.38 203.3,27.87 199.74,24.31 199.74,17.45 199.31,17.01 199.31,13.16 201.04,11.43 201.04,9.41 193.15,1.52 124.73,1.52 124.1,2.16 124.1,11.88 122.75,13.22 96.91,13.22 v3(93.96,16.18)
  BOTTOM w0.102: v2(124.1,68.55) 124.1,67.08 v1(123.62,66.59) 123.59,66.59 123.15,66.15 123.15,64.78 123.48,64.44 123.48,63.56 123.22,63.3 R122.2 123.11,63.09 122.66,62.64 R108.2
  BOTTOM w0.109: v3(72.74,72.79) 73.25,73.29 PR112.2 ; PR182.1 PR201.2 202.29,32.19 v3(202.39,32.29)
SVID_CPU_DIO: length 324
  TOP w0.109: PR107.1 v3(72.26,46.75) PR196.2 ; v3(198.9,35.21) 198.98,35.13 PR110.2 ; PR170.1 72.9,71.9 v3(72.79,71.79)
  TOP w0.152: PR110.2 PR179.1
  T03 w0.097: v3(72.79,71.79) 73.03,71.54 73.03,69.53 75.25,67.31 80.47,67.31 80.77,67.61 80.96,67.8 81.28,67.8 81.28,67.8 81.64,67.8 81.91,68.07 82.48,68.07 84.37,69.96 95.83,69.96 99.54,73.67 102.83,73.67 106.2,70.3 106.46,70.04 117.56,70.04 118.41,69.19 119.94,69.19 v1(120.67,68.47)
  T05 w0.097: v3(72.79,71.79) 73.05,71.52 73.05,69.28 74.57,67.76 80.09,67.76 80.18,67.85 80.43,68.1 85.57,68.1 89.6,64.07 89.6,46.46 89.34,46.21 87.82,44.68 80.51,44.68 78.44,46.75 v3(72.26,46.75) 71.5,45.99 71.5,40.68 70.1,39.28 70.1,34.27 71.06,33.31 72.42,33.31 75.46,30.27 75.46,24.55 76.42,23.59 83.67,23.59 85.48,21.79 87.73,21.79 92.74,16.78 94.21,16.78 v3(94.83,16.16)
  T10 w0.097: v3(198.9,35.21) 198.9,34.6 202.83,30.67 202.83,28.05 202.83,28.04 202.83,28.01 199.3,24.49 199.3,17.63 198.87,17.2 198.87,12.84 200.53,11.18 200.53,9.54 192.95,1.96 139.53,1.96 138.94,2.56 138.05,2.56 137.54,2.05 124.97,2.05 124.54,2.48 124.54,12.06 122.93,13.66 97.33,13.66 v3(94.83,16.16)
  BOTTOM w0.089: R106.2 121.43,63.35 R119.2
  BOTTOM w0.102: R119.2 121.3,64.29 121.3,67.83 v1(120.67,68.47)
  BOTTOM w0.109: PR173.2 73.28,72.28 v3(72.79,71.79)
SYS_PWROK: length 166.7
  TOP w0.109: J12.47 13.9,73.86 14.45,73.31 14.45,71.07 18.45,67.07 R398.2 C189.1 19.41,65.62 19.41,65.72 19.68,66 20.07,66 20.26,65.8 22.77,65.8 28.98,59.59 v3(28.98,59.56) ; U31.G1 v1(52.13,49.28)
  TOP w0.152: U1.BP5 v1(133.45,30.75)
  T03 w0.089: 111.36,25.26 113.06,26.96 v1(113.54,26.96) ; 108.91,26.3 108.42,26.8 105.55,26.8
  T03 w0.097: 108.91,26.3 108.92,26.3 108.92,25.9 109.7,25.13 111.23,25.13 111.36,25.26 ; v1(52.13,49.28) 52.13,47.18 53.67,45.64 53.67,41.93 55.7,39.89 55.7,39.14 59.04,35.8 70.67,35.8 71.27,35.2 74.2,35.2 76.83,32.56 76.83,29.35 78.11,28.08 78.11,28 78.36,27.75 78.44,27.75 81.04,25.15 81.04,24.06 83.19,21.91 85.22,21.91 85.66,21.47 97.97,21.47 98.34,21.83 98.55,21.83 103.52,26.8 105.55,26.8
  T05 w0.089: v1(113.54,26.96) 114.83,26.96 116.96,29.09 131.78,29.09 v1(133.45,30.75)
  T08 w0.097: v3(28.98,59.56) 29.68,59.56 30.22,60.11 40.62,60.11 41.01,59.72 41.01,59.37 41.5,58.89 42.7,58.89 43.79,59.97 44.28,59.97 44.37,59.88 45.51,59.88 v3(46.55,58.83) 46.55,58.55 46.27,58.28 46.27,55.99 46.53,55.74 49.68,55.74 50.96,54.46 50.96,52.16 51.2,51.92 51.2,50.21 v1(52.13,49.28)
  BOTTOM w0.109: U30.19 46.46,58.93 v3(46.55,58.83)
SYS_RESET_L: length 140.1
  TOP w0.109: v3(43.05,23.77) 41.15,23.77 40.74,23.36 40.74,15.41 42.8,13.35 46.55,13.35 47.93,11.97 47.93,10.78 47.62,10.47 47.62,9.06 47.35,8.78 J10.B31 ; J12.48 4.41,73.86 4.15,74.13 3.72,74.13 2.38,72.79 2.38,70.7 v3(2.95,70.14) ; U31.M9 46.15,41.28 v1(46.15,41.3)
  T05 w0.097: v3(46.23,51.07) 46.23,51.58 47.75,53.1 50.42,53.1 51.14,53.82 51.14,54.81 48.6,57.34 48.19,57.34 47.72,57.82 v3(46.7,57.82) ; v1(46.15,41.3) 45.64,40.79 45.64,33.69 45.22,33.27 45.22,32.93 45.56,32.59 45.56,25.13 44.2,23.77 v3(43.05,23.77)
  T08 w0.097: v3(46.7,57.82) 46.98,58.09 46.98,59.01 45.81,60.18 44.5,60.18 44.18,60.5 30.12,60.5 29.86,60.24 23.64,60.24 22.62,59.21 9.41,59.21 6.94,61.68 6.04,61.68 2.95,64.77 v3(2.95,70.14)
  BOTTOM w0.109: R339.2 43.21,23.61 v3(43.05,23.77) 42.56,23.27 R342.2 ; U30.17 46.51,57.63 v3(46.7,57.82) ; C188.1 4.46,69.74 R397.2 4.44,69.98 4.04,70.38 3.19,70.38 v3(2.95,70.14) ; v1(46.15,41.3) 45.92,41.52 45.92,44.1 46.79,44.97 46.79,46.88 47.7,47.79 48.26,47.79 48.67,48.2 48.67,50.39 47.87,51.19 46.35,51.19 v3(46.23,51.07)
SYS_RESET_R_L: length 3.4
  BOTTOM w0.109: Q3.1 40.79,22.84 41.21,23.27 ; 41.21,23.27 R342.1 ; 41.21,23.27 v2(41.21,21.81)
TP_CPU_SLP_SUS_N: length 5.5
  TOP w0.152: U1.AY7 126.26,31.26 v1(126.26,31.81)
  BOTTOM w0.089: TP1.1 126.51,28.57 v2(127.53,28.57) 127.53,28.95
  BOTTOM w0.102: v1(126.26,31.81) 127.02,31.05 127.02,29.46 127.53,28.95
TP_DDR0_DQS_DN10: length 3.1
  TOP w0.127: U1.CD9 v1(137.15,32.39)
  BOTTOM w0.089: v2(136.96,29.97) 136.96,29.99 137.15,30.18 v1(137.15,32.39)
TP_DDR0_DQS_DN11: length 5
  TOP w0.127: U1.CF14 v1(137.64,34.97)
  BOTTOM w0.089: v2(141.83,35.12) 141.55,35.39 138.06,35.39 v1(137.64,34.97)
TP_DDR0_DQS_DN12: length 7
  TOP w0.127: U1.CC22 v1(136.65,38.4)
  BOTTOM w0.089: v2(141.7,40.17) 141.19,39.66 136.87,39.66 136.65,39.44 v1(136.65,38.4)
TP_DDR0_DQS_DN13: length 5.4
  TOP w0.127: U1.CC67 v1(136.65,58.44)
  BOTTOM w0.089: v2(136.42,62.85) 136.79,62.48 136.79,61.72 136.76,61.7 136.76,60.84 137.04,60.56 137.04,59.99 136.65,59.6 v1(136.65,58.44)
TP_DDR0_DQS_DN14: length 3.6
  TOP w0.165: v1(139.63,58.44) 139.91,58.72 U1.CK67
  BOTTOM w0.089: v2(141.7,60.36) 141.7,60.1 140.03,58.44 v1(139.63,58.44)
TP_DDR0_DQS_DN15: length 3.5
  TOP w0.127: U1.BR71 v1(132.69,60.15)
  BOTTOM w0.089: v1(132.69,60.15) 132.96,60.15 133.75,60.94 v2(133.75,62.52)
TP_DDR0_DQS_DN16: length 9.6
  TOP w0.165: U1.BP66 v1(132.2,57.58)
  BOTTOM w0.089: v2(135.81,64.37) 135.81,61.53 135.55,61.27 135.55,60.85 135.15,60.44 135.15,59.82 134.78,59.45 134.78,59.09 134.29,58.6 134.29,58.38 133.87,57.96 132.58,57.96 v1(132.2,57.58)
TP_DDR0_DQS_DN17: length 4.5
  TOP w0.127: U1.CK22 v1(139.63,38.4)
  BOTTOM w0.089: v1(139.63,38.4) 140.1,37.93 142.39,37.93 v2(143.1,38.64)
TP_DDR0_DQS_DP10: length 2.2
  TOP w0.127: U1.CF7 v1(137.64,31.54)
  BOTTOM w0.089: v2(138.3,30.13) 137.64,30.78 v1(137.64,31.54)
TP_DDR0_DQS_DP11: length 7.1
  TOP w0.127: U1.CD13 v1(137.15,34.11)
  BOTTOM w0.089: v1(137.15,34.11) 137.56,34.53 142.67,34.53 v2(143.22,35.09)
TP_DDR0_DQS_DP12: length 6.9
  TOP w0.127: U1.CF22 v1(137.64,38.4)
  BOTTOM w0.089: v2(143.1,40.17) 142.21,39.28 140.96,39.28 140.51,38.82 137.89,38.82 137.64,38.57 v1(137.64,38.4)
TP_DDR0_DQS_DP13: length 5.4
  TOP w0.127: U1.CF67 v1(137.64,58.44)
  BOTTOM w0.089: v1(137.64,58.44) 137.75,58.54 137.75,59.45 138.03,59.73 138.03,60.31 137.75,60.59 137.75,61.17 137.86,61.28 v2(137.86,62.92)
TP_DDR0_DQS_DP14: length 2.1
  TOP w0.165: U1.CM67 140.9,58.72 v1(140.62,58.44)
  BOTTOM w0.089: v2(141.83,59.09) 141.27,59.09 v1(140.62,58.44)
TP_DDR0_DQS_DP15: length 1.8
  TOP w0.165: U1.BP72 v1(132.2,61.01)
  BOTTOM w0.089: v2(132.05,62.16) 132.05,61.16 v1(132.2,61.01)
TP_DDR0_DQS_DP16: length 6.6
  TOP w0.165: U1.BR67 v1(132.69,58.44)
  BOTTOM w0.089: v2(134.79,63.43) 134.79,62.06 134.81,62.05 134.81,61.72 134.79,61.71 134.79,61.18 134.78,61.17 134.78,60.81 134.29,60.31 134.29,60.13 133.57,59.42 133.57,59.13 133.35,58.91 133.06,58.91 132.69,58.54 v1(132.69,58.44)
TP_DDR0_DQS_DP17: length 1.9
  TOP w0.127: U1.CM22 v1(140.62,38.4)
  BOTTOM w0.089: v2(141.83,38.64) 141.59,38.4 v1(140.62,38.4)
TP_DDR_VREFDQ0: length 3.7
  TOP w0.089: v1(146.43,51.31) 146.33,51.31 145.92,50.9 144.75,50.9 144.42,51.22 U1.CV51
  BOTTOM w0.089: v2(146.65,50.4) 146.43,50.63 v1(146.43,51.31)
TP_DDR_VREFDQ1: length 3.3
  TOP w0.089: v1(144.98,51.3) 144.76,51.52 143.9,51.52 143.75,51.37 142.98,51.37 U1.CT51
  BOTTOM w0.089: v1(144.98,51.3) v2(144.98,52.23)
TP_GPIO_4: length 37.9
  TOP w0.109: U31.K2 v1(48.15,48.28)
  T05 w0.097: v1(48.15,48.28) 47.81,48.28 45.38,45.86 43.16,45.86 42.55,45.26 41.46,45.26 41.21,45.26 38.45,42.49 38.27,42.32 38.1,42.14 38.1,35.83 37.01,34.74 37.01,33.69 37.46,33.24 37.46,31.79 38.1,31.16 38.1,21.84 39.62,20.31 v3(39.62,20.18)
  BOTTOM w0.109: v3(39.62,20.18) 39.8,20.36 v2(39.8,21.2)
TP_GPIO_26: length 120.7
  TOP w0.089: U1.BB14 127.87,34.13 v1(128.14,34.13)
  T03 w0.089: 105.55,30.17 107.85,30.17 110.39,32.71 110.63,32.71 110.63,32.7 110.95,32.7 110.95,32.71 113.13,32.71 113.21,32.79 115.58,32.79 116.92,31.46 118.41,31.46 118.66,31.71 120.16,31.71 120.73,32.27 124.38,32.27 124.74,31.92 124.74,31.71 125.04,31.41 127.37,31.41 127.85,31.89 127.85,31.96 128.21,32.32 128.21,34.06 v1(128.14,34.13)
  T03 w0.097: v3(89.78,30.23) 91.06,28.94 100.3,28.94 101.53,30.17 105.55,30.17
  T08 w0.097: v3(25.7,24.73) 27.34,24.73 28.37,23.7 31.11,23.7 31.58,23.23 45.56,23.23 47.22,24.88 51.03,24.88 52.85,23.07 72.52,23.07 78.62,29.17 80.4,29.17 80.72,28.85 88.8,28.85 89.78,29.83 v3(89.78,30.23)
  BOTTOM w0.109: R308.1 23.09,21.25 25.16,23.32 25.16,24.18 v3(25.7,24.73) 25.81,24.73 26.28,24.26 v2(26.28,23.65)
TP_NCTF_11: length 2.9
  TOP w0.152: U1.P11 v1(113.87,33.25)
  BOTTOM w0.089: v2(114.98,33.78) 114.4,33.78 v1(113.87,33.25) 113.87,33 114.19,32.67 R167.1
TP_RSVD96: length 2.3
  TOP w0.108: v1(133.19,55.85) 133.39,55.85 U1.BT62
  BOTTOM w0.108: v1(133.19,55.85) 133.19,55.34 132.84,54.99 v2(132.84,54.35)
TP_RSVD97: length 1.6
  TOP w0.152: U1.AR71 v1(124.76,60.17)
  BOTTOM w0.102: v2(125.75,60.17) v1(124.76,60.17)
TP_RSVD_21: length 8.2
  TOP w0.089: U1.AP75 123.53,63.11 123.19,63.44 123.19,63.9 123.32,64.02 123.32,64.52 123.21,64.63
  TOP w0.109: 123.21,64.63 123.14,64.7 123.14,67.37 121.06,69.46 R166.1
TP_RSVD_56: length 2.3
  TOP w0.089: v2(105.66,58.15) U1.A66
TP_RSVD_57: length 4
  TOP w0.089: U1.C66 108.49,58.15 108.08,58.56 106.55,58.56 v2(105.66,59.45)
TP_RSVD_60: length 2.2
  TOP w0.089: U1.A55 106.66,53.2 v2(106.02,52.57)
TP_RSVD_61: length 3.7
  TOP w0.089: U1.C55 109.12,53.2 108.97,53.36 108.46,53.36 108.08,53.74 106.32,53.74 v2(105.89,54.17)
TP_RSVD_90: length 2.3
  TOP w0.089: U1.A49 106.83,50.23 v2(105.99,51.07)
TP_SPI_SSB_IO2: length 0.6
  TOP w0.152: U1.BF18 v1(129.72,36.69)
TP_SPI_SSB_IO3: length 1.1
  TOP w0.089: v1(128.74,38.4) 128.73,38.39 U1.BE20
TP_TPM_GPIO: length 1.9
  TOP w0.109: U25.6 v3(192.15,6.86)
  BOTTOM w0.109: TP4.1 v3(192.15,6.86)
TP_TSTCLK_SC_N: length 6.4
  TOP w0.089: U1.A73 107.08,61.49 106.83,61.75 106.83,61.75 106.82,61.76 106.82,62.87 106.3,63.39 106.3,64.07
  TOP w0.109: 106.3,64.07 106.3,64.41 v2(105.53,65.18) 105.18,65.53 R3.2
TP_TSTCLK_SC_P: length 6.2
  TOP w0.089: 106.82,66.31 106.82,63.32 U1.A74
  TOP w0.109: 106.82,66.31 v2(106.82,66.82) R2.2
TP_U34_4: length 2.4
  TOP w0.109: v3(37.23,58.13) 37.66,58.56 U34.4
  BOTTOM w0.109: v3(37.23,58.13) 37.25,58.13 37.81,57.56 TP9.1
TP_XDP_CPU_TCK1: length 3.8
  TOP w0.109: v3(13.68,75.86) J12.55
  BOTTOM w0.109: TP11.1 11.92,75.86 v3(13.68,75.86)
TP_XDP_PCH_TCK: length 3.7
  BOTTOM w0.109: v2(135.64,10.94) 136.27,11.57 136.27,13.61 136.1,13.77 R448.2
TPM_BUF_SSB_CLK: length 14.4
  TOP w0.109: v3(181.74,10.05) 181.74,8.4 182.37,7.76 R221.1
  BOTTOM w0.109: v3(181.74,10.05) 179.94,11.85 178.96,11.85 178.05,10.94 v2(178.05,10.81) 178.05,10.48 176.38,8.8 176.38,7.99 175.85,7.47 U20.7
TPM_BUF_SSB_MISO: length 12.5
  TOP w0.109: R183.1 183.87,3 182.73,1.86 176.18,1.86 175.44,2.61 v3(175.44,2.9)
  BOTTOM w0.109: v3(175.44,2.9) 175.44,4.5 175.07,4.87 U20.3
TPM_BUF_SSB_MOSI: length 24.6
  TOP w0.109: v3(177.64,3.89) 177.64,2.64 178.11,2.18 182.54,2.18 183.36,3 R192.1
  BOTTOM w0.109: U20.5 175.19,6.17 175.36,6 175.36,5.18 176.64,3.89 v3(177.64,3.89) 177.64,4.46 177.29,4.82 176.35,4.82 175.77,5.39 175.77,6.74 176.97,7.94 176.97,8.66 178.87,10.56 179.23,10.56 v2(179.67,11.01)
TPM_CLK: length 2.5
  TOP w0.109: R221.2 184.4,7.76 184.91,7.26 v3(185.17,7.26) 185.56,6.86 U25.19
TPM_CS_N: length 4.3
  TOP w0.109: R395.1 R102.2 184.53,5.86 v3(185.04,6.36) U25.20
  BOTTOM w0.109: v3(185.04,6.36) 184.05,6.36 v2(183.97,6.44)
TPM_MISO: length 2.7
  TOP w0.109: R183.2 185.12,3.06 185.25,3.19 v3(186.06,3.19) 186.27,3.4 U25.24
TPM_MOSI: length 2.5
  TOP w0.109: U25.21 185.3,5.86 v3(184.85,5.42) 184.4,4.97 R192.2
TPM_PIRQ#: length 3.4
  TOP w0.109: U25.18 185.69,7.36 185.01,8.04 184.91,8.04 v3(184.18,8.78) R305.2
TPM_PRSENCE: length 4.2
  TOP w0.109: v3(192.66,7.89) 192.13,7.36 U25.7
  BOTTOM w0.109: R350.2 R316.1 192.79,7.76 v3(192.66,7.89)
TPM_RST#: length 2.8
  TOP w0.109: R310.2 186.27,10.62 v3(186.27,8.53) U25.17
TPM_SSB_CLK_ST: length 3.1
  BOTTOM w0.109: R218.2 182.7,8.09 v2(181.55,8.09) 181.53,8.12 U20.13
TPM_SSB_CS2_L: length 92.5
  TOP w0.089: U1.BJ9 130.42,32.39 v1(130.21,32.39)
  TOP w0.109: v3(182.57,6.09) 182.81,5.86 R102.1
  T10 w0.089: v1(130.21,32.39) 130.21,22.2 130.81,21.61
  T10 w0.097: v3(141.6,5.16) 139.77,5.16 139.32,4.72 132.08,4.72 131.65,5.14 131.65,20.76 130.81,21.61
  BOTTOM w0.089: v2(130.21,29.7) v1(130.21,32.39)
  BOTTOM w0.109: v3(182.57,6.09) 183.12,6.09 185.09,4.13 185.09,2.33 184.68,1.92 144.85,1.92 v3(141.6,5.16)
TPM_SSB_MISO_ST: length 5.9
  BOTTOM w0.109: U20.17 180.96,5.52 181.12,5.35 R40.2 181.97,5.12 182.27,4.82 183.01,4.82 183.53,4.3 183.53,3.51 v2(184.12,2.93)
TPM_SSB_MOSI_ST: length 9
  T05 w0.097: v3(172.51,6.08) 172.51,6.22 172.62,6.32 v3(177.31,6.32)
  BOTTOM w0.109: v3(172.51,6.08) 172.47,6.11 R39.2 ; U20.15 179.19,6.82 178.62,6.25 177.38,6.25 v3(177.31,6.32)
TXT_AGENT: length 24.1
  TOP w0.108: U1.AM72 v1(122.79,60.16)
  TOP w0.109: v3(114.06,74.41) 114.15,74.41 114.53,74.03 R281.2 R286.1
  T05 w0.097: 122.04,67.73 122.04,68.83 120.55,70.31 116.73,70.31 116.22,70.82 116.22,71.92 114.06,74.08 v3(114.06,74.41)
  T05 w0.102: v1(122.79,60.16) 122.79,61.5 122.94,61.66 122.94,62.13 122.04,63.03 122.04,67.73
  BOTTOM w0.109: v3(114.06,74.41) v2(115.03,74.41)
TXT_PLTEN: length 3.9
  TOP w0.152: v1(123.77,60.17) 123.77,60.3 123.78,60.31 U1.AP72
  BOTTOM w0.102: R282.1 124.71,61.47 v2(124.33,61.08)
  BOTTOM w0.109: v1(123.77,60.17) 123.77,60.53 v2(124.33,61.08)
U5_EN: length 3.7
  BOTTOM w0.109: R18.2 93.01,28.24 90.9,28.24 v2(90.81,28.34) 90.81,27.83 90.81,27.83 U5.5
U7_EN: length 6.9
  TOP w0.109: R118.2 143.26,90.16 142.72,89.62 v3(142.72,89.44) 142.72,89.31 142.22,88.81 U7.5
  BOTTOM w0.109: v2(141.3,85.76) 141.88,86.33 141.88,88.48 142.72,89.31 v3(142.72,89.44)
U9_EN: length 3.4
  TOP w0.109: U9.2 94.23,18.47 R150.2 v2(94.28,17.42)
U34_MR_L: length 9
  TOP w0.109: U34.3 42.24,58.56 R387.1 ; v3(45.15,64.02) 45.15,63.46 42.39,60.7 R459.1 42.39,58.71 R387.1 ; R384.2 R387.1
U34_MR_R_L: length 28.4
  TOP w0.089: v1(44.17,48.28) 44.64,47.81 U31.P2
  TOP w0.109: v3(46.55,60.05) 46.39,60.21 43.94,60.21 43.43,59.71 R459.2
  T05 w0.097: v1(44.17,48.28) 44.17,48.3 43.56,48.91 43.56,49.46 42.71,50.31 v3(42.55,50.31) 42.8,50.56 46.35,50.56 48.51,52.72 50.55,52.72 51.44,53.61 51.44,55.13 50.42,56.15 50.42,59.96 49.91,60.47 46.97,60.47 v3(46.55,60.05)
U34_SENSE: length 4.4
  TOP w0.109: R386.2 36.79,57.61 U34.5 38.59,57.61 v3(39.51,56.69)
  BOTTOM w0.109: v3(39.51,56.69) 40.01,57.18 v2(40.48,57.18)
USB2_P2_DN: length 6.7
  TOP w0.135: J10.B9 23.35,8.42 23.01,8.75 23.01,11.24 22.71,11.55 22.71,12.05 R467.1
USB2_P2_DP: length 6.7
  TOP w0.135: R466.1 22.38,12 22.38,11.41 22.68,11.11 22.68,8.73 22.35,8.4 J10.B8
USB2_PCH_P0_DN: length 47.7
  TOP w0.089: U1.AD3 119.07,29.18 arc(119.12,28.95) 119.25,28.76 arc(119.31,28.67) 119.35,28.57 119.36,28.56 119.36,28.11 arc(119.28,27.69) 119.03,27.32 118.74,27.03 arc(118.62,26.85) 118.58,26.64 118.58,25.97 arc(118.54,25.79) v1(118.44,25.64)
  TOP w0.135: J10.B75 91.35,8.41 91.01,8.74 91.01,10.13 v3(91.32,10.43) 91.26,10.48 91.26,11.78 v2(91.69,12.21)
  T10 w0.135: v3(91.32,10.43) 91.03,10.72 91.03,11.22 arc(91.03,11.23) 91.02,11.25 91.02,13.54 arc(91.32,15.05) 92.16,16.34 92.19,16.36 arc(93.38,17.16) 94.79,17.44 98.49,17.44 arc(98.72,17.48) 98.92,17.62 arc(98.96,17.65) 99.02,17.66 105.86,17.66 arc(106.8,17.84) 107.59,18.37 108.83,19.61 arc(108.96,19.76) 109.06,19.94 arc(109.11,20.09) 109.15,20.25 arc(109.2,20.51) 109.34,20.72 109.42,20.8 110.27,21.65 arc(110.62,21.88) 111.03,21.97 115.6,21.97 arc(116.02,22.05) 116.38,22.29 118.08,23.99 arc(118.33,24.35) 118.43,24.77 arc(118.44,24.83) 118.44,24.9 v1(118.44,25.64)
USB2_PCH_P0_DP: length 48.3
  TOP w0.089: U1.AD1 119.17,28.11 arc(119.1,27.76) 118.9,27.46 118.6,27.16 arc(118.44,26.92) 118.39,26.64 118.39,26.3 arc(118.31,26.12) 118.13,26.05 v1(117.87,26.05)
  TOP w0.135: v2(90.32,13.05) 90.32,12.81 90.38,12.74 v3(90.38,10.43) 90.68,10.13 90.68,8.74 90.35,8.4 J10.B74
  T10 w0.135: v3(90.38,10.43) 90.67,10.72 90.67,11.71 90.46,11.92 90.46,12.25 90.67,12.46 90.67,12.78 90.46,13 90.46,13.32 90.67,13.54 arc(91,15.18) 91.91,16.58 arc(91.93,16.59) 91.94,16.61 arc(93.25,17.48) 94.79,17.79 98.49,17.79 arc(98.59,17.81) 98.67,17.86 arc(98.83,17.97) 99.02,18.01 100.21,18.01 100.4,18.19 100.75,18.19 100.94,18.01 101.29,18.01 101.48,18.19 101.83,18.19 102.02,18.01 102.37,18.01 102.56,18.19 102.91,18.19 103.09,18.01 105.86,18.01 arc(106.66,18.17) 107.34,18.62 108.58,19.86 arc(108.67,19.96) 108.74,20.08 arc(108.78,20.19) 108.8,20.3 arc(108.87,20.65) 109.07,20.94 109.23,21.1 110.02,21.9 arc(110.48,22.21) 111.03,22.32 115.6,22.32 arc(115.89,22.37) 116.13,22.54 117.83,24.24 117.83,24.24 arc(118.01,24.49) 118.09,24.79 arc(118.09,24.85) 118.09,24.9 118.09,25.11 arc(118.09,25.18) 118.07,25.26 118.06,25.34 arc(118.06,25.35) 118.06,25.35 117.89,26.04 v1(117.87,26.05)
USB2_PCH_P1_DN: length 96.9
  TOP w0.089: U1.AK9 121.98,32.11 v3(122.28,31.82)
  T03 w0.135: v3(122.28,31.82) 122,31.54 122,27.22 121.36,26.58 121.36,24.93 118.06,21.64 116.12,21.64 114.54,20.06 109.44,20.06 108.25,18.87 108.25,17.83 105.3,14.88 77.34,14.88 76.76,15.46 72.59,15.46 72.01,14.88 55.89,14.88 55.15,15.62 49.98,15.62 49.8,15.43 49.45,15.43 49.26,15.62 48.53,15.62 47.9,14.99 47.9,14.72 48.13,14.48 v3(48.13,14.11)
  BOTTOM w0.135: J10.A33 49.35,8.55 49.07,8.83 49.07,11.52 47.9,12.69 47.9,13.88 v3(48.13,14.11)
USB2_PCH_P1_DP: length 96.9
  TOP w0.089: v3(121.31,31.82) 121.1,31.82 U1.AH9
  T03 w0.135: v3(121.31,31.82) 121.65,31.48 121.65,27.36 121.01,26.73 121.01,25.08 117.92,21.99 115.98,21.99 114.4,20.41 109.29,20.41 107.9,19.02 107.9,17.98 105.16,15.23 77.48,15.23 76.9,15.81 72.44,15.81 71.86,15.23 56.03,15.23 55.29,15.97 48.39,15.97 47.55,15.13 47.55,14.72 47.29,14.46 v3(47.29,14.11)
  BOTTOM w0.135: v3(47.29,14.11) 47.57,13.83 47.57,12.55 48.74,11.38 48.74,8.84 48.35,8.45 J10.A32
USB2_PCH_P2_DN: length 113.7
  TOP w0.089: v1(119.67,26.79) 119.78,26.9 119.78,28.61 119.91,28.74 119.91,29.08 119.57,29.43 U1.AE4
  TOP w0.135: v3(22.96,14.6) 22.68,14.32 22.68,13.66 R467.2
  T08 w0.135: v1(119.67,26.79) 120.11,26.34 120.11,24.73 119.02,23.64 108.97,23.64 108.33,23 102.94,23 102.54,22.61 74.39,22.61 73.22,21.44 53.09,21.44 51.14,23.38 47.63,23.38 46.24,22 24.81,22 22.71,19.9 22.71,14.85 v3(22.96,14.6)
USB2_PCH_P2_DP: length 113.7
  TOP w0.089: U1.AE2 119.59,28.93 119.59,27.26 119.28,26.95 119.28,26.38 v1(119.56,26.1)
  TOP w0.135: v3(22.14,14.6) 22.35,14.38 22.35,13.65 R466.2
  T08 w0.135: v3(22.14,14.6) 22.36,14.82 22.36,15.23 22.17,15.41 22.17,15.74 22.36,15.92 22.36,16.39 22.2,16.55 22.2,17.01 22.36,17.17 22.36,17.92 22.17,18.1 22.17,18.61 22.36,18.79 22.36,20.04 24.67,22.35 25.79,22.35 25.99,22.55 26.33,22.55 26.52,22.35 26.87,22.35 27.06,22.55 27.41,22.55 27.6,22.35 46.1,22.35 47.48,23.73 51.29,23.73 53.23,21.79 73.07,21.79 74.24,22.96 102.4,22.96 102.79,23.35 108.18,23.35 108.82,23.99 113.74,23.99 113.95,24.2 114.28,24.2 114.49,23.99 114.82,23.99 115.03,24.2 115.36,24.2 115.57,23.99 118.88,23.99 119.76,24.87 119.76,25.9 v1(119.56,26.1)
USB2_PCH_P3_DN: length 43
  TOP w0.135: U1.AG7 120.13,31.25 v3(119.79,30.9)
  T03 w0.135: v3(100.26,16.32) 100.26,16.76 100.51,17.01 100.51,17.84 102.1,19.42 105.58,19.42 107.73,21.58 113.84,21.58 115.44,23.18 117.46,23.18 120.12,25.84 120.12,30.57 v3(119.79,30.9)
  BOTTOM w0.135: v3(100.26,16.32) 100.26,15.89 100.51,15.64 100.51,15 99.85,14.34 98.72,14.34 96.68,12.31 96.68,8.78 96.35,8.45 J10.A80
USB2_PCH_P3_DP: length 43
  TOP w0.135: v3(120.8,30.93) 121.12,31.25 U1.AJ7
  T03 w0.135: v3(120.8,30.93) 120.47,30.6 120.47,25.69 117.61,22.83 115.59,22.83 113.98,21.23 107.87,21.23 105.72,19.07 102.24,19.07 100.86,17.69 100.86,16.96 101.09,16.74 v3(101.09,16.32)
  BOTTOM w0.135: J10.A81 97.35,8.45 97.01,8.78 97.01,12.17 98.86,14.01 99.98,14.01 100.84,14.87 100.84,15.66 101.09,15.91 v3(101.09,16.32)
USB_OC_0_L: length 17.3
  TOP w0.089: 132.29,21.61 131.31,22.59 130.95,22.59 129.97,23.57 U1.BH1
  TOP w0.109: 132.29,21.61 132.79,21.1 133.57,21.1 134.71,19.96 134.71,15.52 v3(134.08,14.89)
  BOTTOM w0.109: R157.2 v3(134.08,14.89)
USB_OC_1_L: length 16.4
  TOP w0.089: 128.63,21.61 128.08,22.16 128.08,27.37 128.48,27.77 U1.BE2
  TOP w0.109: R158.2 v3(129.51,14.89) 130.13,15.52 130.13,18.89 130.01,19.01 130.01,20.23 128.63,21.61
USB_OC_2_L: length 14.6
  TOP w0.089: U1.BG4 129.47,29.44 129.81,29.1 129.81,28.52 129.68,28.39 129.68,23.51 131.58,21.61
  TOP w0.109: 131.58,21.61 132.47,20.72 132.61,20.72 132.87,20.72 133.39,20.19 133.39,19.51 134.08,18.82 v3(134.08,18.7) R159.2
