# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_A_SA0: length 6.9
  BOTTOM w0.109: 186.96,82.92 CN1.256
  BOTTOM w0.127: v2(188.23,79.41) 188.94,79.41 R229.2 R232.1 188.34,80.79 187.42,81.71 187.42,82.58 187.09,82.92 186.96,82.92
DDR4_A_SA1: length 4.5
  BOTTOM w0.109: CN1.260 186.85,83.92 186.96,84.03
  BOTTOM w0.127: R233.1 R230.2 v2(187.95,84.72) 187.66,84.72 186.96,84.03
DDR4_A_SA2: length 4.4
  TOP w0.127: R231.2 R234.1 187.46,60.47 v3(187.4,60.41)
  BOTTOM w0.109: 186.96,60.41 CN1.166
  BOTTOM w0.127: 186.96,60.41 v3(187.4,60.41) 187.46,60.41 187.88,60 v2(187.88,59.37)
DDR4_B_A0: length 40.7
  TOP w0.089: U1.CV60 144.4,55.18 144.54,55.32 146.59,55.32 146.73,55.47 148.56,55.47 148.79,55.7 149.9,55.7 v1(150.87,54.73)
  TOP w0.109: v1(171.85,52.88) 171.72,52.61 171.34,52.47 170.12,52.47 169.89,52.32 169.38,52.32 169.23,52.47 168.14,52.47 167.64,52.97 166.49,52.97 CN2.144
  T10 w0.152: v1(171.85,52.88) 172.51,53.53 172.51,53.92 172.2,54.23 171.37,54.23 171.19,54.05 171.19,53.97 171.01,53.79 170.76,53.79 170.58,53.97 170.58,54.05 170.4,54.23 170.15,54.23 169.97,54.05 169.97,53.97 169.79,53.79 169.54,53.79 169.36,53.97 169.36,54.05 169.18,54.23 167.52,54.23 166.55,55.2 165.46,55.2 165.28,55.38 165.28,55.94 165.1,56.11 164.85,56.11 164.67,55.94 164.67,55.38 164.49,55.2 164.24,55.2 164.06,55.38 164.06,55.94 163.88,56.11 163.63,56.11 163.45,55.94 163.45,55.38 163.27,55.2 151.34,55.2 v1(150.87,54.73)
DDR4_B_A1: length 36.3
  TOP w0.089: U1.CU50 143.34,50.72 144.34,50.72 144.37,50.69 144.56,50.5 146.15,50.5 146.19,50.54 147.91,50.54 v1(148.67,51.31)
  TOP w0.109: v1(169.06,50.52) 169.39,50.18 169.95,50.18 170.01,50.12 170.34,50.12 170.48,50.26 170.99,50.26 171.13,50.12 171.46,50.12 171.69,50.35 171.69,50.36 172.25,50.91 172.58,50.91 173.28,50.21 174.28,50.21 174.42,50.22 CN2.133
  T10 w0.152: v1(169.06,50.52) 169.05,50.51 167.89,50.51 166,52.4 160.88,52.4 160.61,52.67 160.61,52.83 160.34,53.09 159.97,53.09 159.7,52.83 159.7,52.67 159.43,52.4 159.05,52.4 158.78,52.67 158.78,52.83 158.52,53.09 158.14,53.09 157.87,52.83 157.87,52.67 157.6,52.4 157.22,52.4 156.95,52.67 156.95,52.83 156.69,53.09 156.31,53.09 156.04,52.83 156.04,52.67 155.77,52.4 153.78,52.4 152.23,50.85 149.13,50.85 v1(148.67,51.31)
DDR4_B_A2: length 39.7
  TOP w0.089: v1(147.96,51.31) 147.48,50.82 146.17,50.82 146.04,50.69 144.65,50.69 144.42,50.92 143.91,50.92 143.75,51.08 143.19,51.08 142.84,50.73 U1.CR50
  TOP w0.109: v1(171.85,49.65) 170.99,49.34 170.9,49.25 170.58,49.25 170.28,49.43 170.03,49.43 169.83,49.24 169.47,49.24 168.74,49.97 CN2.132
  T05 w0.152: v1(147.96,51.31) 149.1,52.45 151.99,52.45 152.35,52.09 159.66,52.09 159.78,51.96 159.78,51.26 159.91,51.13 160.29,51.13 160.42,51.26 160.42,51.96 160.54,52.09 160.86,52.09 161.18,51.77 161.18,51.07 161.43,50.82 168.12,50.82 168.88,50.06 169.34,50.06 169.39,50.11 169.93,50.11 169.98,50.06 170.48,50.06 170.53,50.11 170.91,50.11 171.37,49.65 v1(171.85,49.65)
DDR4_B_A3: length 41.8
  TOP w0.089: U1.CT49 143.06,50.23 143.21,50.38 143.69,50.38 143.84,50.53 144.26,50.53 144.48,50.31 145.62,50.31 145.66,50.26 148.32,50.26 148.69,50.63
  TOP w0.109: v1(169.62,49.65) 170.17,49.65 170.57,50.05 170.9,50.05 171.13,49.82 171.45,49.82 171.69,50.05 172.02,50.05 172.36,49.71 172.87,49.71 173.09,49.93 173.33,49.93 173.55,49.71 174.28,49.71 174.42,49.72 CN2.131
  TOP w0.171: v1(150.27,51.31) 149.6,50.63 148.69,50.63
  T05 w0.152: v1(150.27,51.31) 150.27,51.64 150.39,51.78 150.54,51.93 151.79,51.93 152.19,51.54 159,51.54 159.2,51.34 159.2,51.12 159.02,50.94 155.85,50.94 155.65,50.75 155.65,50.5 155.85,50.31 167.95,50.31 168.7,49.55 169.52,49.55 v1(169.62,49.65)
DDR4_B_A4: length 42.6
  TOP w0.089: 148.76,50.18 148.56,49.98 145.66,49.98 145.53,50.12 144.18,50.12 U1.CV49
  TOP w0.109: CN2.128 167.31,48.97 167.66,48.62 167.66,47.83 167.76,47.74 168.06,47.74 168.37,48.04 168.37,48.88 168.25,49 168.25,49.56 168.35,49.66 168.72,49.66 169.06,49.32 v1(169.06,49.02)
  TOP w0.171: 148.76,50.18 149.86,50.18 v1(150.98,51.31)
  T05 w0.152: v1(150.98,51.31) 151.46,50.83 152.24,50.83 152.42,51.01 154.96,51.01 155.15,50.82 155.15,50.56 154.96,50.37 153.24,50.37 153.11,50.24 153.11,49.99 153.31,49.8 167.77,49.8 167.9,49.66 167.9,49.41 167.78,49.29 165.5,49.29 165.37,49.16 165.37,48.85 165.5,48.72 168.26,48.72 168.55,49.02 v1(169.06,49.02)
DDR4_B_A5: length 39.9
  TOP w0.089: U1.CR48 142.84,49.74 143.19,50.09 143.75,50.09 143.91,49.93 145.33,49.93 v1(145.73,49.53)
  TOP w0.109: CN2.126 167.34,48.47 167.44,48.37 167.44,47.74 167.66,47.52 168.17,47.52 168.96,48.31 169.03,48.31 169.56,48.83 169.75,48.83 170.11,48.47 170.11,48.34 169.92,48.15 v1(169.62,48.15)
  T10 w0.152: v1(169.62,48.15) 169.49,48.02 169.42,48.02 169.41,48.01 166.45,48.01 165.4,49.06 164.64,49.06 164.37,49.33 164.37,50.38 164.1,50.65 163.72,50.65 163.45,50.38 163.45,49.33 163.19,49.06 162.53,49.06 160.97,50.62 160.07,50.62 159.8,50.89 159.8,50.99 159.53,51.25 159.15,51.25 158.89,50.99 158.89,50.89 158.62,50.62 158.24,50.62 157.97,50.89 157.97,50.99 157.7,51.25 157.32,51.25 157.06,50.99 157.06,50.89 156.79,50.62 156.41,50.62 156.14,50.89 156.14,50.99 155.87,51.25 155.5,51.25 155.23,50.99 155.23,50.89 154.96,50.62 154.27,50.62 152.62,48.97 146.28,48.97 v1(145.73,49.53)
DDR4_B_A6: length 40.8
  TOP w0.089: U1.CT47 143.06,49.24 143.2,49.38 143.74,49.38 143.9,49.54 144.33,49.54 144.74,49.13 146.04,49.13 v1(146.44,49.53)
  TOP w0.109: v1(171.29,49.02) 170.85,49.02 170.76,48.93 170.76,48.73 171.22,48.28 171.35,48.28 171.97,48.9 171.97,49.2 172.24,49.47 173.32,49.47 173.49,49.3 173.49,48.8 173.58,48.71 174.28,48.71 174.42,48.72 CN2.127
  T10 w0.152: v1(171.29,49.02) 170.89,49.02 170.4,48.53 169.94,48.53 169.82,48.65 169.35,48.65 169.23,48.53 168.25,48.53 166.81,49.97 166.73,50.05 166.35,50.05 165.96,49.66 165.65,49.66 165.31,50.01 165.31,50.31 165.7,50.7 165.7,51.08 164.87,51.91 164.08,51.91 163.81,51.64 163.81,51.41 163.54,51.15 163.17,51.15 162.9,51.41 162.9,51.64 162.63,51.91 162.25,51.91 161.98,51.64 161.98,51.41 161.72,51.15 161.34,51.15 161.07,51.41 161.07,51.64 160.8,51.91 154.37,51.91 152.72,50.26 147.17,50.26 v1(146.44,49.53)
DDR4_B_A7: length 43.1
  TOP w0.089: U1.CR46 142.57,48.75 142.7,48.88 142.97,48.88 143.2,49.11 143.74,49.11 143.91,48.94 144.39,48.94 144.6,48.73 146.35,48.73 146.37,48.71 147.93,48.71 v1(148.75,49.53)
  TOP w0.109: CN2.122 167.34,47.47 167.55,47.26 168.32,47.26 168.56,47.5 168.56,47.59 168.98,48.01 169.13,48.01 169.55,47.59 169.68,47.59 170.1,48.01 170.25,48.01 170.74,47.52 v1(171.29,47.52)
  T05 w0.152: v1(171.29,47.52) 170.99,47.21 170.65,47.21 170.34,46.89 170.11,46.89 169.72,47.29 169.51,47.29 169.26,47.04 156.48,47.04 156.29,47.23 156.29,47.58 156.42,47.7 159.15,47.7 159.27,47.83 159.27,48.15 159.15,48.28 152.22,48.28 152.02,48.48 151.79,48.52 149.25,49.03 v1(148.75,49.53)
DDR4_B_A8: length 41.8
  TOP w0.089: U1.CV47 144.35,49.24 144.66,48.94 147.27,48.94 v1(147.86,49.53)
  TOP w0.109: CN2.125 174.42,48.22 174.28,48.21 173.57,48.21 173.48,48.11 173.48,47.57 173.37,47.47 172.95,47.47 172.86,47.55 172.86,48.43 172.78,48.52 172.53,48.52 172.45,48.43 172.45,47.58 172.36,47.49 171.91,47.49 171.64,47.76 171.64,47.94 v1(171.85,48.15)
  T05 w0.152: v1(171.85,48.15) 172.1,48.15 172.26,48.31 172.26,48.53 172,48.79 171.73,48.79 171.5,48.56 171.09,48.56 170.89,48.76 170.71,48.76 170.3,48.36 170.12,48.36 169.69,48.79 169.49,48.79 169.15,48.46 168.65,48.46 168.3,48.11 163.08,48.11 162.89,48.3 162.89,48.59 163.02,48.72 164.8,48.72 164.86,48.78 164.86,49.16 164.74,49.29 152.86,49.29 151.81,50.34 151.25,50.34 151.11,50.48 148.81,50.48 v1(147.86,49.53)
DDR4_B_A9: length 42.5
  TOP w0.089: U1.CT44 143.06,48.25 143.21,48.11 143.75,48.11 143.91,47.95 145.43,47.95 v1(145.83,47.55)
  TOP w0.109: CN2.121 174.42,47.22 174.28,47.21 173.51,47.21 173.48,47.24 172.9,47.24 172.1,47.26 171.6,47.26 171.46,47.12 171.13,47.12 170.99,47.26 170.48,47.26 170.34,47.12 169.46,47.12 v1(169.06,47.52)
  T10 w0.152: v1(145.83,47.55) 146.76,48.48 154.15,48.48 154.42,48.75 154.42,49.7 154.69,49.97 155.07,49.97 155.33,49.7 155.33,48.75 155.6,48.48 155.98,48.48 156.25,48.75 156.25,49.7 156.52,49.97 156.9,49.97 157.16,49.7 157.16,48.75 157.43,48.48 157.81,48.48 158.08,48.75 158.08,49.7 158.35,49.97 158.72,49.97 158.99,49.7 158.99,48.75 159.26,48.48 159.64,48.48 159.91,48.75 159.91,49.7 160.17,49.97 160.55,49.97 160.82,49.7 160.82,48.75 161.09,48.48 164.62,48.48 165.59,47.52 v1(169.06,47.52)
DDR4_B_A10: length 40.6
  TOP w0.089: U1.CU61 144.36,55.68 144.38,55.7 146.33,55.7 146.66,56.03 148.06,56.03 v1(148.72,56.69)
  TOP w0.109: v1(171.29,55.52) 170.77,55.52 170.25,54.99 170.1,54.99 169.69,55.4 169.57,55.4 169.19,55.03 168.93,55.03 168.67,55.29 168.26,55.29 167.95,54.98 167.59,54.98 167.46,55.11 167.46,55.28 167.28,55.47 CN2.146
  T10 w0.089: 169.84,55.76 169.46,55.76 169.32,55.9 168.9,55.9 168.76,55.76 168.15,55.76 168.14,55.77
  T10 w0.102: v1(171.29,55.52) 171.14,55.67 170.61,55.67 170.33,55.95 170.02,55.95 169.84,55.76
  T10 w0.152: 168.14,55.77 166.35,57.57 164.81,57.57 164.55,57.83 164.55,58.36 164.28,58.62 163.9,58.62 163.63,58.36 163.63,57.83 163.36,57.57 162.98,57.57 162.72,57.83 162.72,58.36 162.45,58.62 162.07,58.62 161.8,58.36 161.8,57.83 161.53,57.57 161.16,57.57 160.89,57.83 160.89,58.36 160.62,58.62 160.24,58.62 159.97,58.36 159.97,57.83 159.71,57.57 148.96,57.57 148.72,57.33 v1(148.72,56.69)
DDR4_B_A11: length 43
  TOP w0.089: U1.CU46 144.31,48.75 144.52,48.54 146.27,48.54 146.36,48.46 147.26,48.46 147.32,48.41 149.05,48.41 v1(150.17,49.53)
  TOP w0.109: v1(171.85,46.65) 170.98,46.33 170.88,46.23 170.61,46.23 170.35,46.42 169.95,46.42 169.78,46.25 169.45,46.25 168.74,46.97 CN2.120
  T05 w0.152: v1(150.17,49.53) 150.62,49.98 151.22,49.98 152.42,48.78 162.2,48.78 162.39,48.59 162.39,48.28 162.26,48.15 160.04,48.15 159.91,48.02 159.91,47.81 160.1,47.62 168.5,47.62 168.84,47.96 169.21,47.96 169.23,47.93 169.48,47.69 169.76,47.69 170,47.93 170.36,47.93 170.56,47.73 170.91,47.73 171.11,47.93 171.47,47.93 171.78,47.62 171.78,46.72 v1(171.85,46.65)
DDR4_B_A12: length 31.8
  TOP w0.089: 170.9,47.05 170.57,47.05 170.17,46.65 v1(169.62,46.65) ; v1(146.54,47.55) 145.95,48.14 144.18,48.14 U1.CV44
  TOP w0.109: 170.9,47.05 171.07,46.88 171.52,46.88 171.69,47.05 172.02,47.05 172.2,46.88 173.37,46.88 173.54,46.71 174.28,46.71 174.42,46.72 CN2.119
  T10 w0.152: v1(169.62,46.65) 169.25,47.02 163.94,47.02 162.98,47.98 146.97,47.98 v1(146.54,47.55)
DDR4_B_A13: length 44
  TOP w0.089: v1(145.7,58.68) 145.28,58.26 144.53,58.26 144.33,58.45 143.85,58.45 143.7,58.3 142.98,58.3 U1.CT66
  TOP w0.109: v1(171.29,58.52) 171.36,58.45 171.36,58.14 171.27,58.05 170.64,58.05 170.58,58.11 169.98,58.11 169.46,58.62 169.46,58.68 169.22,58.92 168.83,58.92 168.37,58.46 166.5,58.46 CN2.158
  T05 w0.152: v1(171.29,58.52) 171.75,58.52 172.29,57.97 172.29,57.5 172.27,57.48 171.8,57.01 171.8,56.74 171.55,56.48 171.09,56.48 170.99,56.59 169.95,56.59 169.59,56.94 169.59,57.08 169.2,57.48 168.92,57.48 168.67,57.23 168.33,57.23 168.15,57.41 167.76,57.41 167.27,56.92 164.86,56.92 164.74,57.04 164.74,57.86 164.61,57.99 164.23,57.99 164.1,57.86 164.1,57.11 163.91,56.92 163.52,56.92 163.37,57.07 163.37,58.4 163.21,58.56 162.89,58.56 162.77,58.44 162.77,57.74 162.64,57.61 162.25,57.61 162.07,57.8 162.07,58.43 161.94,58.56 159.34,58.56 159.23,58.46 152,58.46 151.79,58.24 150.13,58.24 150.12,58.26 146.12,58.26 v1(145.7,58.68)
DDR4_B_A14: length 41.8
  TOP w0.089: U1.CV62 144.36,56.17 144.45,56.09 145.44,56.09 145.61,56.26 145.97,56.26 v1(146.41,56.69)
  TOP w0.109: CN2.151 174.42,56.72 174.28,56.71 173.55,56.71 173.43,56.84 173.43,57.07 173.33,57.17 173.05,57.17 172.94,57.06 172.94,56.03 172.8,55.9 172.63,55.9 172.45,56.07 172.45,56.51 172.36,56.59 172.17,56.59 172.08,56.68 171.58,56.68 171.39,56.49 171.39,56.29 171.53,56.15 v1(171.85,56.15)
  T05 w0.152: v1(146.41,56.69) 146.88,56.23 152.35,56.23 152.92,55.66 154.89,55.66 155.02,55.53 155.02,55.18 154.87,55.03 154.13,55.03 154,54.9 154,54.52 154.15,54.38 168.65,54.38 168.96,54.68 169.14,54.68 169.37,54.45 169.8,54.45 170.01,54.66 170.35,54.66 170.6,54.4 171.72,54.18 172.84,54.4 173.35,54.91 173.35,55.32 172.51,56.15 v1(171.85,56.15)
DDR4_B_A15: length 41.8
  TOP w0.089: v1(150.15,58.68) 149.16,57.69 146.54,57.69 146.34,57.49 144.57,57.49 144.54,57.46 143.77,57.46 143.62,57.31 142.98,57.31 U1.CT64
  TOP w0.109: v1(171.85,57.65) 171,57.35 170.9,57.25 170.61,57.25 170.28,57.42 170.06,57.42 169.72,57.25 169.51,57.25 169.4,57.3 168.9,57.8 168.9,57.82 168.67,58.05 167.4,58.05 167.31,57.96 166.5,57.96 CN2.156
  T10 w0.152: v1(171.85,57.65) 171.85,57.22 171.85,56.74 171.67,56.56 171.09,56.56 171.05,56.6 170.49,56.6 170.42,56.52 170,56.52 169.74,56.79 169.49,56.79 169.26,56.56 168.7,56.56 166.13,59.13 158.97,59.13 158.7,58.87 158.7,58.55 158.43,58.28 158.05,58.28 157.78,58.55 157.78,58.87 157.52,59.13 157.14,59.13 156.87,58.87 156.87,58.55 156.6,58.28 156.22,58.28 155.95,58.55 155.95,58.87 155.69,59.13 155.31,59.13 155.04,58.87 155.04,58.55 154.77,58.28 154.39,58.28 154.13,58.55 154.13,58.87 153.86,59.13 153.21,59.13 152.13,58.06 150.76,58.06 v1(150.15,58.68)
DDR4_B_A16: length 40.8
  TOP w0.089: U1.CT62 142.97,56.31 143.69,56.31 143.86,56.47 144.33,56.47 144.53,56.28 145.28,56.28 v1(145.7,56.69)
  TOP w0.109: v1(169.06,57.02) 169.06,56.64 168.97,56.55 168.31,56.55 167.96,56.2 167.81,56.2 167.72,56.29 167.72,56.73 168.09,57.11 168.09,57.69 167.98,57.8 167.54,57.8 167.43,57.68 167.43,57.04 167.34,56.96 166.5,56.96 CN2.152
  T05 w0.152: v1(145.7,56.69) 145.62,56.77 145.62,57.57 145.91,57.86 152.01,57.86 152.08,57.92 155.17,57.92 156.67,56.42 159.17,56.42 159.4,56.66 159.4,57.86 159.6,58.07 159.91,58.07 160.1,57.88 160.1,56.59 160.27,56.42 160.61,56.42 160.8,56.61 160.8,57.93 160.94,58.07 161.24,58.07 161.43,57.88 161.43,56.59 161.61,56.42 161.88,56.42 162.07,56.61 162.07,56.78 162.2,56.91 162.61,56.91 162.77,56.76 162.77,56.59 162.94,56.42 167.47,56.42 167.97,56.92 168.96,56.92 v1(169.06,57.02)
DDR4_B_ACT_L: length 33.3
  TOP w0.089: U1.CU41 143.57,46.77 143.58,46.78 144.49,46.78 144.69,46.58 146.39,46.58 146.5,46.47 149.9,46.47 v1(150.98,47.55)
  TOP w0.109: CN2.114 166.49,45.47 167.43,45.47 167.52,45.38 167.52,45.04 167.61,44.95 168.1,44.95 168.43,44.62 168.56,44.62 169.09,45.15 v1(169.62,45.15)
  T05 w0.152: v1(150.98,47.55) 150.98,47.39 151.11,47.23 151.61,47.13 154.93,47.13 155.08,46.98 155.08,46.71 154.93,46.56 154.7,46.56 154.51,46.37 154.51,46.06 154.7,45.87 168.47,45.87 169.19,45.15 v1(169.62,45.15)
DDR4_B_ALERT_L: length 33.6
  TOP w0.089: v1(147.96,47.55) 147.56,47.15 144.92,47.15 144.52,47.55 143.83,47.55 143.69,47.41 142.98,47.41 U1.CT42
  TOP w0.109: v1(169.06,46.02) 169.06,46.32 168.66,46.72 168.49,46.72 168.42,46.65 168.42,45.63 168.28,45.49 168.04,45.49 167.9,45.63 167.9,46.63 167.81,46.72 167.53,46.72 167.41,46.6 167.41,46.07 167.3,45.96 166.5,45.96 CN2.116
  T10 w0.152: v1(169.06,46.02) 169.04,46.02 169,45.98 168.13,45.98 167.7,45.55 153.23,45.55 152.47,46.31 149.2,46.31 v1(147.96,47.55)
DDR4_B_BA0: length 32.6
  TOP w0.089: v1(148.01,56.69) 147.27,56.3 146.68,56.3 145.65,55.9 144.31,55.9 144.3,55.89 143.99,55.89 143.37,56.02 143.27,56.02 143.11,55.97 143.01,55.86 142.6,55.74 142.58,55.75 U1.CR61
  TOP w0.109: v1(169.62,56.15) 169.11,56.15 168.54,55.58 168.03,55.58 167.15,56.47 CN2.150
  T05 w0.152: v1(169.62,56.15) 169.2,56.57 168.33,56.57 167.68,55.93 156.41,55.93 154.91,57.42 148.74,57.42 v1(148.01,56.69)
DDR4_B_BA1: length 40.7
  TOP w0.089: v1(150.15,56.69) 149.62,56.16 148.7,56.16 148.28,55.75 146.66,55.75 146.42,55.51 144.46,55.51 144.44,55.49 143.91,55.49 143.75,55.33 142.98,55.33 U1.CT60
  TOP w0.109: CN2.145 174.42,55.22 174.28,55.21 173.58,55.21 173.25,54.88 173.25,54.59 172.89,54.23 169.91,54.23 169.62,54.52 v1(169.62,54.88)
  T10 w0.089: v1(169.62,54.88) 169.39,55.11 168.82,55.11 168.66,55.27 168.14,55.27
  T10 w0.152: v1(150.15,56.69) 150.95,55.89 152.49,55.89 153.37,56.77 153.91,56.77 154.18,56.5 154.18,56.13 154.45,55.86 154.82,55.86 155.09,56.13 155.09,56.5 155.36,56.77 155.74,56.77 156.01,56.5 156.01,56.13 156.27,55.86 156.65,55.86 156.92,56.13 156.92,56.5 157.19,56.77 157.57,56.77 157.84,56.5 157.84,56.13 158.1,55.86 158.48,55.86 158.75,56.13 158.75,56.5 159.02,56.77 159.4,56.77 159.66,56.5 159.66,56.13 159.93,55.86 160.31,55.86 160.58,56.13 160.58,56.5 160.85,56.77 161.22,56.77 161.49,56.5 161.49,56.13 161.76,55.86 162.14,55.86 162.41,56.13 162.41,56.5 162.67,56.77 165.6,56.77 166.48,55.89 167.28,55.89 167.9,55.27 168.14,55.27
DDR4_B_BG0: length 43.4
  TOP w0.089: U1.CR41 142.84,46.77 143.19,47.12 143.69,47.12 143.84,46.97 144.57,46.97 144.76,46.77 149.49,46.77 v1(150.27,47.55)
  TOP w0.109: CN2.115 174.42,45.72 174.28,45.71 173.63,45.71 173.44,45.9 173.44,46.34 173.35,46.43 172.6,46.43 172.41,46.23 172.09,46.23 171.8,45.95 171.8,45.74 171.45,45.39 171.1,45.39 170.92,45.56 170.76,45.56 170.65,45.66 170.65,45.88 170.79,46.02 v1(171.29,46.02)
  T05 w0.152: v1(171.29,46.02) 171.46,46.18 173.18,46.18 173.31,46.05 173.31,45.8 173.18,45.67 171.72,45.67 171.6,45.55 171.58,45.55 171.39,45.36 171.17,45.36 170.87,45.65 170.59,45.65 170.28,45.33 170.1,45.33 169.48,45.96 169.48,46.19 169.23,46.43 168.88,46.43 156.04,46.43 155.78,46.69 155.78,47.51 155.65,47.65 152.22,47.65 151.86,48.01 150.24,48.33 149.98,48.33 149.87,48.22 149.87,47.96 v1(150.27,47.55)
DDR4_B_BG1: length 40.7
  TOP w0.089: v1(148.67,47.55) 148.08,46.96 144.84,46.96 144.54,47.26 U1.CV42
  TOP w0.109: CN2.113 174.42,45.22 174.28,45.21 173.56,45.21 173.42,45.07 173.42,44.74 173.28,44.6 172.92,44.6 172.5,45.02 172.5,45.25 173.13,45.89 173.13,46.05 173.04,46.14 172.65,46.14 172.52,46.01 172.2,46.01 172.06,45.87 172.06,45.61 171.85,45.41 v1(171.85,45.15)
  T10 w0.152: v1(148.67,47.55) 148.67,47.53 149.3,46.91 154.02,46.91 154.29,46.64 154.29,46.33 154.56,46.06 154.94,46.06 155.2,46.33 155.2,46.64 155.47,46.91 155.85,46.91 156.12,46.64 156.12,46.33 156.39,46.06 156.77,46.06 157.03,46.33 157.03,46.64 157.3,46.91 157.68,46.91 157.95,46.64 157.95,46.33 158.22,46.06 158.59,46.06 158.86,46.33 158.86,46.64 159.13,46.91 161.09,46.91 161.52,46.47 169.2,46.47 169.55,46.12 169.55,45.84 169.85,45.54 170.3,45.54 170.43,45.68 170.87,45.68 171.01,45.54 171.48,45.54 172,46.07 172.41,46.07 172.65,45.83 172.65,45.5 172.3,45.15 v1(171.85,45.15)
DDR4_B_CKE0: length 37.7
  TOP w0.089: v1(148.63,45.69) 148.17,46.15 146.4,46.15 146.26,46.28 144.6,46.28 144.31,46.57 143.85,46.57 143.55,46.27 U1.CT40
  TOP w0.171: v1(172.41,44.52) 172.68,44.25 173.3,44.25 173.35,44.21 174.28,44.21 174.42,44.22 CN2.109
  T05 w0.152: v1(148.63,45.69) 148.63,46.52 148.95,46.84 150.93,46.84 152.14,46.6 153.38,45.35 158.26,45.35 158.39,45.23 158.39,44.59 158.51,44.47 158.83,44.47 158.96,44.59 158.96,45.16 159.08,45.29 159.46,45.29 159.59,45.16 159.59,44.59 159.72,44.47 160.04,44.47 160.16,44.59 160.16,45.16 160.35,45.35 165.39,45.35 165.5,45.24 166.77,45.24 166.79,45.23 167.81,45.23 168.03,45.01 168.05,45.01 168.44,44.62 168.44,44.61 168.5,44.55 168.5,44.46 168.61,44.34 168.86,44.1 169.21,44.1 169.44,44.33 169.79,44.33 170.04,44.08 170.32,44.08 170.6,44.37 170.85,44.37 171.12,44.1 171.47,44.1 171.52,44.1 171.66,44.24 172.14,44.24 v1(172.41,44.52)
DDR4_B_CKE1: length 34.5
  TOP w0.089: 145.74,44.91 144.75,44.91 144.38,45.28 U1.CV38
  TOP w0.127: v1(167.94,44.52) 167.89,44.47 166.49,44.47 CN2.110
  TOP w0.152: v1(150.13,45.69) 149.35,44.91 145.74,44.91
  T05 w0.152: v1(167.94,44.52) 166.8,44.52 166.57,44.75 165.98,44.75 165.82,44.59 165.82,43.94 165.67,43.78 165.35,43.78 165.19,43.94 165.19,44.59 165.03,44.75 164.71,44.75 164.55,44.59 164.55,43.94 164.4,43.78 164.08,43.78 163.92,43.94 163.92,44.59 163.76,44.75 163.44,44.75 163.28,44.59 163.28,43.94 163.13,43.78 162.81,43.78 162.65,43.94 162.65,44.59 162.49,44.75 162.17,44.75 162.01,44.59 162.01,43.94 161.86,43.78 161.54,43.78 161.38,43.94 161.38,44.59 161.22,44.75 160.9,44.75 160.74,44.59 160.74,43.94 160.59,43.78 158.31,43.78 157.36,44.74 153.29,44.74 151.89,46.14 150.52,46.42 150.34,46.38 150.13,46.17 v1(150.13,45.69)
DDR4_B_CS0_L: length 37.4
  TOP w0.089: U1.CR63 142.84,56.67 143.19,57.03 143.52,57.03 143.68,56.86 144.52,56.86 144.75,57.1 150.42,57.1 150.83,56.69 v1(150.86,56.69)
  TOP w0.171: CN2.149 174.42,56.22 174.28,56.21 173.55,56.21 173.42,56.08 173.42,55.78 172.76,55.12 v1(171.85,54.88)
  T05 w0.152: v1(171.85,54.88) 171.85,55.55 171.71,55.69 171.47,55.93 171.12,55.93 170.6,55.41 170.6,55.34 170.35,55.1 170,55.1 169.76,55.34 169.76,55.37 169.74,55.39 169.74,55.43 169.44,55.73 169.24,55.93 168.88,55.93 168.55,55.6 168.17,55.6 168.02,55.44 168.02,55.05 167.82,54.86 167.62,54.86 167.36,55.11 165.71,55.11 165.47,54.87 165.06,54.87 164.82,55.11 164.44,55.11 164.2,54.87 163.79,54.87 163.55,55.11 163.17,55.11 162.93,54.87 162.52,54.87 162.28,55.11 161.9,55.11 161.66,54.87 156.57,54.87 155.15,56.3 152.99,56.3 152.48,56.8 152.18,56.8 151.84,57.14 151.31,57.14 v1(150.86,56.69)
DDR4_B_CS1_L: length 35.7
  TOP w0.089: v1(146.41,58.68) 146.29,58.68 145.68,58.07 144.45,58.07 144.36,58.15 U1.CV66
  TOP w0.171: CN2.157 174.42,58.22 174.28,58.21 173.64,58.21 173.43,58.31 172.66,58.93 v1(171.85,59.15)
  T05 w0.152: v1(146.41,58.68) 147.1,59.36 151.24,59.36 151.48,59.61 152.22,59.61 152.3,59.52 158.87,59.52 158.96,59.61 164.26,59.61 164.74,59.13 165.1,59.13 165.29,59.32 165.29,60.01 165.45,60.17 165.77,60.17 165.93,60.01 165.93,59.41 166.09,59.25 166.4,59.25 166.56,59.41 166.56,60.01 166.72,60.17 167.04,60.17 167.2,60.01 167.2,59.41 167.36,59.25 167.78,59.25 168.4,58.64 168.58,58.64 168.92,58.98 169.2,58.98 169.44,58.73 169.79,58.73 169.81,58.75 169.82,58.75 170,58.93 170.01,58.93 170.25,59.18 170.25,59.33 170.53,59.61 170.89,59.61 171.34,59.15 v1(171.85,59.15)
DDR4_B_DQ0: length 46.1
  TOP w0.089: U1.CG1 138.88,28.17 139.09,27.95 139.09,27.73 139.29,27.52 139.29,25.06
  TOP w0.102: 139.29,25.06 139.29,25.04
  TOP w0.109: v1(140.47,24.57) 139.76,24.57 139.29,25.04 ; v1(168,19.19) 167.76,18.96 CN2.8
  T10 w0.097: v1(168,19.19) 166.59,19.19 165.12,17.72 162.71,17.72 161.69,18.73 161.22,18.73 161.08,18.59 161.08,18.03 160.94,17.88 160.74,17.88 160.6,18.03 160.6,18.59 160.46,18.73 160.26,18.73 160.12,18.59 160.12,18.03 159.97,17.88 159.77,17.88 159.63,18.03 159.63,18.59 159.49,18.73 159.29,18.73 159.15,18.59 159.15,18.03 159.01,17.88 158.81,17.88 158.67,18.03 158.67,18.59 158.53,18.73 158.33,18.73 158.19,18.59 158.19,18.03 158.04,17.88 157.84,17.88 157.7,18.03 157.7,18.59 157.56,18.73 157.36,18.73 157.22,18.59 157.22,18.03 157.08,17.88 156.88,17.88 156.74,18.03 156.74,18.59 156.6,18.73 156.4,18.73 156.25,18.59 156.25,18.05 156.16,17.96 155.87,17.96 155.77,18.05 155.77,18.59 155.63,18.73 154.4,18.73 153.58,17.92 148.39,17.92 141.74,24.57 v1(140.47,24.57)
DDR4_B_DQ1: length 45.8
  TOP w0.089: U1.CG3 138.88,28.7 138.57,28.4 138.57,27.97 139.08,27.46 139.08,24.84
  TOP w0.109: v1(173.2,17.92) 173.2,18.39 173.52,18.71 174.42,18.71 CN2.7 ; v1(141.02,24.07) 139.85,24.07 139.08,24.84
  T10 w0.097: v1(141.02,24.07) 141.62,24.07 143.86,21.83 143.86,21.82 148.44,17.24 165.63,17.24 166.85,18.46 170.31,18.46 170.45,18.32 170.45,18.17 170.59,18.03 170.79,18.03 170.93,18.17 170.93,18.32 171.07,18.46 171.27,18.46 171.41,18.32 171.41,18.17 171.55,18.03 171.75,18.03 171.89,18.17 171.89,18.32 172.04,18.46 172.66,18.46 v1(173.2,17.92)
DDR4_B_DQ2: length 46.2
  TOP w0.089: 142.37,26.03 140.87,27.53 140.87,28.39 141.04,28.56 141.17,28.69 141.17,29.23 141.14,29.26 U1.CM3
  TOP w0.109: v1(170.46,21.93) 170.1,21.93 169.58,21.41 168.17,21.41 167.62,21.96 CN2.20 ; 142.37,26.03 v1(143.01,26.03)
  T10 w0.097: v1(170.46,21.93) 169.96,22.43 169.96,23.24 169.71,23.49 167.29,23.49 165,25.77 163.71,25.77 163.57,25.63 163.57,25.39 163.41,25.23 163.25,25.23 163.09,25.39 163.09,25.63 162.95,25.77 162.75,25.77 162.61,25.63 162.61,25.39 162.47,25.25 162.27,25.25 162.12,25.39 162.12,25.63 161.98,25.77 161.78,25.77 161.64,25.63 161.64,25.39 161.5,25.25 161.3,25.25 161.16,25.39 161.16,25.63 161.02,25.77 160.82,25.77 160.68,25.63 160.68,25.39 160.53,25.25 160.33,25.25 160.19,25.39 160.19,25.63 160.05,25.77 157.21,25.77 157.07,25.63 157.07,25.49 156.98,25.4 156.69,25.4 156.59,25.49 156.59,25.63 156.45,25.77 156.25,25.77 156.11,25.63 156.11,25.49 156.01,25.39 155.72,25.39 155.63,25.49 155.63,25.63 155.48,25.77 155.28,25.77 155.14,25.63 155.14,25.49 155.05,25.39 154.76,25.39 154.66,25.49 154.66,25.63 154.52,25.77 153.01,25.77 152.35,25.11 149.66,25.11 149.22,24.68 147.57,24.68 144.58,27.67 143.38,27.67 142.99,27.27 142.99,26.06 v1(143.01,26.03)
DDR4_B_DQ3: length 46.4
  TOP w0.089: U1.CN4 141.64,29.84 141.04,29.84 140.81,29.61 140.81,29.23 140.91,29.13 140.91,28.77 140.87,28.73 140.66,28.52 140.66,27.46 142.5,25.63 142.55,25.63
  TOP w0.109: v1(171.46,21.93) 171.98,22.46 173.34,22.46 173.58,22.21 174.28,22.21 174.42,22.21 CN2.21 ; v1(143.53,25.51) 143.41,25.63 142.55,25.63
  T10 w0.097: v1(171.46,21.93) 170.96,21.43 169.34,21.43 168.39,22.38 166.01,22.38 165.38,23.01 165.38,23.03 164.43,23.98 163.34,23.98 163.23,24.09 163.23,24.28 163.12,24.39 162.96,24.39 162.84,24.28 162.84,24.09 162.73,23.98 162.57,23.98 162.46,24.09 162.46,24.28 162.35,24.39 162.19,24.39 162.07,24.28 162.07,24.09 161.96,23.98 161.8,23.98 161.69,24.09 161.69,24.28 161.57,24.39 161.41,24.39 161.3,24.28 161.3,24.09 161.19,23.98 161.03,23.98 160.91,24.09 160.91,24.28 160.8,24.39 160.64,24.39 160.53,24.28 160.53,24.09 160.41,23.98 160.25,23.98 160.14,24.09 160.14,24.28 160.03,24.39 159.87,24.39 159.76,24.28 159.76,24.09 159.64,23.98 159.48,23.98 159.37,24.09 159.37,24.28 159.26,24.39 159.1,24.39 158.98,24.28 158.98,24.09 158.87,23.98 158.71,23.98 158.6,24.09 158.6,24.28 158.48,24.39 158.32,24.39 158.21,24.28 158.21,24.09 158.1,23.98 157.94,23.98 157.83,24.09 157.83,24.28 157.71,24.39 157.55,24.39 157.44,24.28 157.44,24.09 157.33,23.98 157.17,23.98 157.05,24.09 157.05,24.28 156.94,24.39 156.78,24.39 156.67,24.28 156.67,24.09 156.55,23.98 156.39,23.98 156.28,24.09 156.28,24.28 156.17,24.39 156.01,24.39 155.89,24.28 155.89,24.09 155.78,23.98 155.62,23.98 155.51,24.09 155.51,24.25 155.41,24.35 155.22,24.35 155.12,24.25 155.12,24.09 155.01,23.98 153.83,23.98 153.22,24.58 149.69,24.58 149.43,24.32 145.72,24.32 144.53,25.51 v1(143.53,25.51)
DDR4_B_DQ4: length 45.8
  TOP w0.089: U1.CF2 138.38,27.89 138.87,27.4 138.87,24.62
  TOP w0.109: 138.87,24.62 139.71,23.78 140.46,23.78 141.23,23.01 v1(142.03,23.01) ; v1(167.23,16.14) 167.49,16.4 167.49,17.8 167.32,17.96 CN2.4
  T10 w0.089: 167.11,16.27 v1(167.23,16.14)
  T10 w0.097: 167.11,16.27 166.21,16.27 166.07,16.13 166.07,15.83 165.93,15.69 165.73,15.69 165.59,15.83 165.59,16.13 165.45,16.27 165.25,16.27 165.11,16.13 165.11,15.83 164.97,15.69 164.77,15.69 164.63,15.83 164.63,16.13 164.48,16.27 164.28,16.27 164.14,16.13 164.14,15.83 164,15.69 163.8,15.69 163.66,15.83 163.66,16.13 163.52,16.27 163.32,16.27 163.18,16.13 163.18,15.83 163.04,15.69 162.84,15.69 162.69,15.83 162.69,16.13 162.55,16.27 162.35,16.27 162.21,16.13 162.21,15.83 162.07,15.69 161.87,15.69 161.73,15.83 161.73,16.13 161.59,16.27 161.39,16.27 161.25,16.13 161.25,15.83 161.11,15.69 160.91,15.69 160.76,15.83 160.76,16.13 160.62,16.27 160.42,16.27 160.28,16.13 160.28,15.83 160.14,15.69 159.94,15.69 159.8,15.83 159.8,16.13 159.66,16.27 147.52,16.27 142.03,21.76 v1(142.03,23.01)
DDR4_B_DQ5: length 45.9
  TOP w0.089: 138.66,24.4 138.66,27.34 138.18,27.82 138.18,28.32 138.03,28.8 138.03,29.09 138.22,29.28 U1.CF4
  TOP w0.109: v1(173.25,17.24) 173.25,17.37 173.58,17.71 174.42,17.71 CN2.3 ; 138.66,24.4 139.57,23.48 140.34,23.48 141.38,22.44 v1(142.6,22.44)
  T10 w0.089: 168.53,17.54 172.94,17.54 v1(173.25,17.24)
  T10 w0.097: v1(142.6,22.44) 142.6,21.81 147.68,16.72 167.71,16.72 168.53,17.54
DDR4_B_DQ6: length 46.1
  TOP w0.089: 142.55,25.3 140.46,27.39 140.46,28.65 140.55,28.74 U1.CL2
  TOP w0.102: 142.87,25.3 142.55,25.3
  TOP w0.109: 142.87,25.3 143.99,24.17 144.26,24.17 v1(144.55,24.46) ; CN2.16 167.48,20.96 168.01,20.42 169.95,20.42 v1(170.46,20.93)
  T10 w0.089: 145.48,22.57 149.04,22.57 150.12,23.64 150.42,23.64
  T10 w0.097: v1(144.55,24.46) 144.49,24.4 144.49,23.56 145.48,22.57 ; v1(170.46,20.93) 169.94,20.42 166.92,20.42 166.12,21.22 162.79,21.22 162.07,21.94 161.29,21.94 161.14,21.79 161.14,21.54 161,21.4 160.8,21.4 160.66,21.54 160.66,21.79 160.49,21.97 160.35,21.97 160.18,21.79 160.18,21.54 160.04,21.4 159.84,21.4 159.7,21.54 159.7,21.79 159.55,21.94 159.35,21.94 159.21,21.79 159.21,21.54 159.07,21.4 158.87,21.4 158.73,21.54 158.73,21.79 158.59,21.94 158.39,21.94 158.25,21.79 158.25,21.54 158.11,21.4 157.91,21.4 157.77,21.54 157.77,21.79 157.62,21.94 157.42,21.94 157.28,21.79 157.28,21.54 157.14,21.4 156.94,21.4 156.8,21.54 156.8,21.79 156.66,21.94 156.46,21.94 156.32,21.79 156.32,21.54 156.18,21.4 155.98,21.4 155.84,21.54 155.84,21.79 155.69,21.94 155.49,21.94 155.35,21.79 155.35,21.54 155.21,21.4 155.01,21.4 154.87,21.54 154.87,21.79 154.73,21.94 153.43,21.94 151.72,23.64 150.42,23.64
DDR4_B_DQ7: length 46
  TOP w0.089: U1.CK4 140.36,29.41 140.23,29.28 140.23,27.33 142.58,24.98
  TOP w0.109: v1(169.46,20.93) 169.85,20.93 170.36,21.44 172.67,21.44 172.9,21.21 174.28,21.21 174.42,21.21 CN2.17 ; v1(145.06,23.96) 144.97,23.87 143.69,23.87 142.58,24.98
  T10 w0.089: 145.63,23.02 148.99,23.02
  T10 w0.097: v1(145.06,23.96) 144.9,23.8 144.9,23.52 145.41,23.02 145.63,23.02 ; 148.99,23.02 150.1,24.14 152.63,24.14 153.19,23.57 153.19,23.56 153.48,23.27 154.94,23.27 155.09,23.13 155.09,22.91 155.19,22.8 155.46,22.8 155.57,22.91 155.57,23.13 155.71,23.27 155.91,23.27 156.05,23.13 156.05,22.91 156.19,22.77 156.39,22.77 156.53,22.91 156.53,23.13 156.67,23.27 156.87,23.27 157.02,23.13 157.02,22.91 157.16,22.77 157.36,22.77 157.5,22.91 157.5,23.13 157.64,23.27 157.84,23.27 157.98,23.13 157.98,22.91 158.12,22.77 158.32,22.77 158.46,22.91 158.46,23.13 158.61,23.27 158.81,23.27 158.95,23.13 158.95,22.91 159.09,22.77 159.29,22.77 159.43,22.91 159.43,23.13 159.57,23.27 159.77,23.27 159.91,23.13 159.91,22.91 160.05,22.77 160.25,22.77 160.39,22.91 160.39,23.13 160.54,23.27 160.74,23.27 160.88,23.13 160.88,22.91 161.02,22.77 161.22,22.77 161.36,22.91 161.36,23.13 161.5,23.27 161.93,23.27 163.52,21.68 168.32,21.68 169.06,20.93 v1(169.46,20.93)
DDR4_B_DQ8: length 45
  TOP w0.089: 145.38,30.52 145.38,30.81 144.37,31.82 143.42,31.82 U1.CU8
  TOP w0.109: 145.38,30.52 145.38,30.45 146.61,29.22 146.61,28.32 147.65,27.28 v1(147.65,26.17) ; v1(170.46,23.95) 170.15,23.95 169.69,23.49 167.91,23.49 167.44,23.96 CN2.28
  T05 w0.089: v1(147.65,26.17) 147.65,24.09 148.69,23.05 148.69,21.07
  T05 w0.097: v1(170.46,23.95) 170.11,23.95 169.65,23.49 168.3,23.49 164.9,20.08 163.3,20.08 163.13,20.25 163.13,20.45 162.96,20.62 162.72,20.62 162.55,20.45 162.55,20.25 162.38,20.08 162.14,20.08 161.97,20.25 161.97,20.48 161.84,20.62 161.52,20.62 161.39,20.49 161.39,20.25 161.22,20.08 160.98,20.08 160.81,20.25 160.81,20.54 160.71,20.65 160.43,20.65 160.15,20.37 153.77,20.37 152.41,19.01 150.2,19.01 148.69,20.52 148.69,21.07
DDR4_B_DQ9: length 45.1
  TOP w0.089: U1.CR8 142.89,31.92 143.09,32.11 143.41,32.11 143.5,32.02 144.44,32.02 146.02,30.44
  TOP w0.109: CN2.29 174.42,24.21 174.28,24.21 173.06,24.21 172.87,24.4 171.91,24.4 v1(171.46,23.95) ; 146.02,30.44 146.91,29.55 146.91,28.4 148.2,27.11 v1(148.2,25.62)
  T05 w0.089: v1(148.2,25.62) 148.2,24.53 149.57,23.16 150.23,23.16
  T05 w0.097: 150.23,23.16 151.91,23.16 153.57,21.51 153.98,21.51 154.15,21.34 154.15,21 154.32,20.83 154.56,20.83 154.73,21 154.73,21.34 154.9,21.51 155.14,21.51 155.31,21.34 155.31,21 155.48,20.83 155.72,20.83 155.89,21 155.89,21.34 156.06,21.51 156.3,21.51 156.47,21.34 156.47,21 156.64,20.83 156.88,20.83 157.05,21 157.05,21.34 157.22,21.51 157.46,21.51 157.63,21.34 157.63,21 157.8,20.83 158.04,20.83 158.21,21 158.21,21.34 158.38,21.51 158.62,21.51 158.79,21.34 158.79,21 158.96,20.83 159.2,20.83 159.36,21 159.36,21.34 159.53,21.51 165.36,21.51 168.25,24.4 171.01,24.4 v1(171.46,23.95)
DDR4_B_DQ10: length 44.9
  TOP w0.089: U1.CU13 144.28,33.9 145.36,32.81 145.36,32.7 146.21,31.86 146.38,31.86
  TOP w0.109: 146.38,31.86 146.45,31.78 148.24,31.78 151.49,28.54 151.49,26.42 v1(151.65,26.26) ; v1(170.46,26.98) 170.66,26.98 171.12,26.52 171.89,26.52 172.57,27.21 174.28,27.21 174.42,27.21 CN2.41
  T05 w0.089: v1(151.65,26.26) 152.54,27.16
  T05 w0.097: v1(170.46,26.98) 169.52,27.91 168.57,27.91 167.13,29.35 162.76,29.35 162.62,29.21 162.62,28.92 162.48,28.78 162.28,28.78 162.14,28.92 162.14,29.21 162,29.35 161.8,29.35 161.66,29.21 161.66,28.92 161.52,28.78 161.32,28.78 161.17,28.92 161.17,29.21 161.03,29.35 160.83,29.35 160.69,29.21 160.69,28.92 160.55,28.78 160.35,28.78 160.21,28.92 160.21,29.21 160.07,29.35 159.87,29.35 159.73,29.21 159.73,28.92 159.59,28.78 159.39,28.78 159.24,28.92 159.24,29.21 159.1,29.35 158.9,29.35 158.76,29.21 158.76,28.92 158.62,28.78 158.42,28.78 158.28,28.92 158.28,29.21 158.14,29.35 157.94,29.35 157.8,29.21 157.8,28.92 157.66,28.78 157.45,28.78 157.31,28.92 157.31,29.21 157.17,29.35 156.97,29.35 156.83,29.21 156.83,28.92 156.69,28.78 156.49,28.78 156.35,28.92 156.35,29.21 156.21,29.35 156.01,29.35 155.87,29.21 155.87,28.92 155.72,28.78 155.52,28.78 155.38,28.92 155.38,29.21 155.24,29.35 154.74,29.35 152.54,27.16
DDR4_B_DQ11: length 45.1
  TOP w0.089: 146.36,32.15 146.22,32.15 145.6,32.77 145.6,32.85 144.36,34.09 143.65,34.09 143.48,34.25 143.18,34.25 142.83,33.9 U1.CR13
  TOP w0.109: v1(152.17,25.75) 152.33,25.91 152.33,28.62 148.8,32.15 146.36,32.15 ; v1(169.46,26.98) 169.2,26.98 168.77,26.56 168.13,26.56 167.97,26.72 167.97,26.99 167.5,27.46 166.49,27.46 CN2.42
  T05 w0.097: v1(152.17,25.75) 153.89,27.47 154.89,27.47 155.06,27.64 155.06,27.94 155.23,28.1 155.47,28.1 155.64,27.94 155.64,27.64 155.81,27.47 156.05,27.47 156.22,27.64 156.22,27.94 156.39,28.1 156.63,28.1 156.8,27.94 156.8,27.64 156.97,27.47 157.21,27.47 157.38,27.64 157.38,27.94 157.55,28.1 157.79,28.1 157.96,27.94 157.96,27.64 158.13,27.47 158.37,27.47 158.54,27.64 158.54,27.94 158.71,28.1 158.95,28.1 159.12,27.94 159.12,27.64 159.29,27.47 159.53,27.47 159.7,27.64 159.7,27.94 159.87,28.1 160.11,28.1 160.28,27.94 160.28,27.64 160.45,27.47 160.69,27.47 160.85,27.64 160.85,27.94 161.02,28.1 161.26,28.1 161.43,27.94 161.43,27.64 161.6,27.47 161.84,27.47 162.01,27.64 162.01,27.94 162.18,28.1 162.42,28.1 162.59,27.94 162.59,27.64 162.76,27.47 165.22,27.47 165.39,27.64 165.39,27.94 165.56,28.1 165.8,28.1 165.97,27.94 165.97,27.64 166.14,27.47 166.38,27.47 166.55,27.64 166.55,27.94 166.72,28.1 166.96,28.1 167.13,27.94 167.13,27.64 167.3,27.47 168.96,27.47 v1(169.46,26.98)
DDR4_B_DQ12: length 44.9
  TOP w0.089: 144.8,29.88 144.8,30.83 144.22,31.41 143.81,31.41 143.62,31.22 143.62,30.68 U1.CU5 ; 145.97,27.9 145.97,28.64 144.8,29.81
  TOP w0.109: CN2.24 166.36,22.96 167.43,22.96 167.74,22.96 168.25,22.44 169.94,22.44 170.45,22.95 v1(170.46,22.95) ; 144.8,29.81 144.8,29.88 ; v1(146.05,27.83) 145.97,27.9
  T05 w0.089: 146.52,21.61 146.52,23.34 146.05,23.82 146.05,25.24
  T05 w0.097: 146.52,21.61 146.52,20.88 149.41,17.99 153.44,17.99 154.32,18.87 165.74,18.87 169.24,22.37 169.88,22.37 170.06,22.55 170.06,22.55 v1(170.46,22.95) ; v1(146.05,27.83) 146.05,25.24
DDR4_B_DQ13: length 45.1
  TOP w0.089: U1.CT7 143.23,31.14 143.72,31.63 144.28,31.63 145.06,30.85 145.06,30.44
  TOP w0.109: v1(169.46,22.95) 169.74,22.95 170.25,23.46 172,23.46 172.26,23.21 174.28,23.21 174.42,23.21 CN2.25 ; v1(146.58,27.3) 146.58,27.92 146.3,28.19 146.3,28.92 145.06,30.17 145.06,30.44
  T05 w0.097: v1(169.46,22.95) 169.2,22.95 168.6,22.34 168.1,22.34 165.28,19.52 159.76,19.52 159.37,19.91 154.33,19.91 152.94,18.52 149.81,18.52 147.66,20.66 147.66,21.63 147.49,21.8 147.14,21.8 147.04,21.9 147.04,22.29 147.14,22.38 147.49,22.38 147.66,22.55 147.66,23.23 146.58,24.31 v1(146.58,27.3)
DDR4_B_DQ14: length 45.1
  TOP w0.089: 146.27,31.57 146.21,31.57 145.16,32.62 145.16,32.74 144.5,33.4 U1.CV12
  TOP w0.109: 146.27,31.57 146.44,31.4 147.74,31.4 150.52,28.62 v1(150.52,27.38) ; v1(171.46,25.98) 171.05,25.98 170.64,26.39 169.28,26.39 168.99,26.1 167.66,26.1 167.3,26.46 CN2.38
  T05 w0.089: 152.17,25.12 152.29,25.12
  T05 w0.097: 152.29,25.12 152.86,25.12 153.73,25.98 154.53,25.98 154.7,26.15 154.7,26.58 154.87,26.75 155.11,26.75 155.28,26.58 155.28,26.15 155.44,25.98 155.68,25.98 155.85,26.15 155.85,26.58 156.02,26.75 156.26,26.75 156.43,26.58 156.43,26.15 156.6,25.98 156.84,25.98 157.01,26.15 157.01,26.58 157.18,26.75 157.42,26.75 157.59,26.58 157.59,26.15 157.76,25.98 158,25.98 158.17,26.15 158.17,26.58 158.34,26.75 158.58,26.75 158.75,26.58 158.75,26.15 158.92,25.98 159.16,25.98 159.33,26.15 159.33,26.58 159.5,26.75 159.74,26.75 159.91,26.58 159.91,26.15 160.08,25.98 160.32,25.98 160.49,26.15 160.49,26.58 160.66,26.75 160.9,26.75 161.07,26.58 161.07,26.15 161.24,25.98 165.67,25.98 166.27,26.58 170.86,26.58 v1(171.46,25.98) ; v1(150.52,27.38) 150.49,27.35 150.49,26.79 152.17,25.12
DDR4_B_DQ15: length 45.2
  TOP w0.089: U1.CT12 143,33.56 143.46,33.56 143.91,33.12 144.39,33.12 146.23,31.27
  TOP w0.109: v1(150.02,27.91) 150.02,28.48 147.48,31.02 146.49,31.02 146.23,31.27 ; v1(170.46,25.98) 170.97,25.47 172.65,25.47 173.39,26.21 174.28,26.21 174.42,26.21 CN2.37
  T05 w0.097: v1(150.02,27.91) 150.02,26.65 152.2,24.48 153.5,24.48 153.64,24.62 153.64,25.06 153.74,25.16 154.03,25.16 154.12,25.06 154.12,24.62 154.26,24.48 154.46,24.48 154.61,24.62 154.61,25.1 154.75,25.24 154.95,25.24 155.09,25.1 155.09,24.62 155.23,24.48 155.43,24.48 155.57,24.62 155.57,25.1 155.71,25.24 155.91,25.24 156.05,25.1 156.05,24.62 156.19,24.48 156.39,24.48 156.54,24.62 156.54,25.1 156.68,25.24 156.88,25.24 157.02,25.1 157.02,24.62 157.16,24.48 157.36,24.48 157.5,24.62 157.5,25.1 157.63,25.23 157.85,25.23 157.98,25.1 157.98,24.62 158.12,24.48 160.04,24.48 160.21,24.65 160.21,24.8 160.38,24.97 160.62,24.97 160.79,24.8 160.79,24.65 160.96,24.48 161.2,24.48 161.37,24.65 161.37,24.8 161.54,24.97 161.78,24.97 161.95,24.8 161.95,24.65 162.12,24.48 162.63,24.48 162.83,24.68 162.83,25.06 162.97,25.2 165.92,25.2 166.71,26 168.73,26 169.11,26.38 170.06,26.38 v1(170.46,25.98)
DDR4_B_DQ16: length 37.3
  TOP w0.089: v1(149.82,32.77) 148.75,33.85 146.14,33.85 144.61,35.38 U1.CV16
  TOP w0.109: CN2.50 166.49,29.46 166.49,29.46 167.52,29.46 168.02,28.96 168.66,28.96 169.1,29.4 v1(169.46,29.4)
  T10 w0.089: 151.11,31.04 149.82,32.33 v1(149.82,32.77)
  T10 w0.097: v1(169.46,29.4) 169.23,29.4 168.63,28.8 165.42,28.8 164.97,29.26 161.83,29.26 160.54,30.54 159.44,30.54 159.3,30.4 159.3,30.13 159.16,29.99 158.96,29.99 158.82,30.13 158.82,30.4 158.68,30.54 158.48,30.54 158.34,30.4 158.34,30.13 158.19,29.99 157.99,29.99 157.85,30.13 157.85,30.4 157.71,30.54 157.51,30.54 157.37,30.4 157.37,30.13 157.23,29.99 157.03,29.99 156.89,30.13 156.89,30.4 156.75,30.54 156.55,30.54 156.41,30.4 156.41,30.13 156.26,29.99 156.06,29.99 155.92,30.13 155.92,30.4 155.78,30.54 155.58,30.54 155.44,30.4 155.44,30.13 155.3,29.99 155.1,29.99 154.96,30.13 154.96,30.4 154.82,30.54 154.62,30.54 154.48,30.4 154.48,30.13 154.33,29.99 154.13,29.99 153.99,30.13 153.99,30.4 153.85,30.54 153.65,30.54 153.51,30.4 153.51,30.13 153.37,29.99 153.17,29.99 153.03,30.13 153.03,30.4 152.89,30.54 151.61,30.54 151.11,31.04
DDR4_B_DQ17: length 37.4
  TOP w0.089: v1(149.09,32.77) 148.29,33.57 146.15,33.57 144.64,35.08 143.9,35.08 143.46,35.53 143.21,35.53 143.06,35.38 U1.CT16
  TOP w0.109: CN2.49 174.42,29.21 174.28,29.21 173.51,29.21 173.14,28.83 171.29,28.83 170.72,29.4 v1(170.46,29.4)
  T10 w0.089: v1(149.09,32.77) 149.09,32.33 152.14,29.28 152.54,29.28
  T10 w0.097: v1(170.46,29.4) 169.93,28.87 169.33,28.87 168.84,28.38 165.24,28.38 164.99,28.63 164.79,28.83 161.26,28.83 160.81,29.28 159.79,29.28 159.65,29.14 159.65,28.97 159.51,28.83 159.31,28.83 159.17,28.97 159.17,29.14 159.03,29.28 158.83,29.28 158.68,29.14 158.68,28.97 158.54,28.83 158.34,28.83 158.2,28.97 158.2,29.14 158.06,29.28 157.86,29.28 157.72,29.14 157.72,28.97 157.58,28.83 157.38,28.83 157.24,28.97 157.24,29.14 157.1,29.28 152.54,29.28
DDR4_B_DQ18: length 37.6
  TOP w0.089: v1(149.77,35.07) 148.77,36.06 145.78,36.06 144.48,37.36 U1.CV20
  TOP w0.109: v1(170.46,32.43) 170.1,32.43 169.66,31.99 169.13,31.99 168.67,32.46 CN2.62
  T10 w0.097: v1(170.46,32.43) 170.1,32.43 169.69,32.02 169.63,32.02 169.63,32.02 169.28,32.02 169.28,32.02 169.16,32.02 168.67,32.51 166.44,32.51 165.03,33.92 163.36,33.92 162.64,34.65 162.12,34.65 161.97,34.79 161.97,34.9 161.83,35.04 161.63,35.04 161.49,34.9 161.49,34.79 161.35,34.65 161.15,34.65 161.01,34.79 161.01,34.9 160.87,35.04 160.67,35.04 160.53,34.9 160.53,34.79 160.39,34.65 160.19,34.65 160.04,34.79 160.04,34.9 159.9,35.04 159.7,35.04 159.56,34.9 159.56,34.79 159.42,34.65 159.22,34.65 159.08,34.79 159.08,34.9 158.94,35.04 158.74,35.04 158.6,34.9 158.6,34.79 158.46,34.65 158.25,34.65 158.11,34.79 158.11,34.9 157.97,35.04 157.77,35.04 157.63,34.9 157.63,34.79 157.49,34.65 157.29,34.65 157.15,34.79 157.15,34.9 157.01,35.04 156.81,35.04 156.67,34.9 156.67,34.79 156.52,34.65 156.32,34.65 156.18,34.79 156.18,34.9 156.04,35.04 155.84,35.04 155.7,34.9 155.7,34.79 155.56,34.65 155.36,34.65 155.22,34.79 155.22,34.9 155.08,35.04 154.88,35.04 154.74,34.9 154.74,34.79 154.59,34.65 154.39,34.65 154.25,34.79 154.25,34.9 154.11,35.04 153.91,35.04 153.77,34.9 153.77,34.79 153.63,34.65 153.43,34.65 153.29,34.79 153.29,34.85 153.19,34.95 152.9,34.95 152.81,34.85 152.81,34.79 152.66,34.65 150.19,34.65 v1(149.77,35.07)
DDR4_B_DQ19: length 37.5
  TOP w0.089: U1.CT20 142.88,37.41 143.56,37.41 143.9,37.06 144.51,37.06 145.73,35.85 148.3,35.85 v1(149.06,35.09)
  TOP w0.109: CN2.63 174.42,32.71 174.28,32.71 173.58,32.71 172.86,31.99 171.9,31.99 v1(171.46,32.43)
  T10 w0.097: v1(171.46,32.43) 170.95,32.94 167.04,32.94 165.49,34.49 163.91,34.49 162.76,35.64 154.63,35.64 154.49,35.78 154.49,35.95 154.34,36.11 154.16,36.11 154.01,35.95 154.01,35.78 153.87,35.64 153.66,35.64 153.52,35.78 153.52,35.95 153.38,36.09 153.18,36.09 153.04,35.95 153.04,35.78 152.9,35.64 152.7,35.64 152.56,35.78 152.56,35.95 152.42,36.09 152.22,36.09 152.08,35.95 152.08,35.78 151.93,35.64 151.73,35.64 151.59,35.78 151.59,35.95 151.45,36.09 151.25,36.09 151.11,35.95 151.11,35.78 150.97,35.64 150.77,35.64 150.63,35.78 150.63,35.95 150.49,36.09 150.29,36.09 150.15,35.95 150.15,35.78 150,35.64 149.6,35.64 v1(149.06,35.09)
DDR4_B_DQ20: length 37.3
  TOP w0.089: U1.CU15 143.53,34.69 144.49,34.69 144.54,34.64 146.02,33.17 146.03,33.17 146.53,33.17 v1(146.93,32.77)
  TOP w0.109: CN2.46 166.49,28.46 166.49,28.46 168.91,28.46 169.33,28.88 170.58,28.88 171.06,28.4 v1(171.46,28.4)
  T10 w0.089: v1(146.93,32.77) 152.28,27.42 152.33,27.43
  T10 w0.097: v1(171.46,28.4) 170.48,27.42 161.16,27.42 160.95,27.21 160.68,27.21 160.47,27.42 160.2,27.42 159.99,27.21 159.71,27.21 159.5,27.42 158.48,27.42 158.48,27.42 152.33,27.43
DDR4_B_DQ21: length 37.4
  TOP w0.089: U1.CR15 142.84,34.89 143.19,35.24 143.48,35.24 143.83,34.88 144.57,34.88 146.09,33.36 147.08,33.36 v1(147.67,32.77)
  TOP w0.109: CN2.45 174.42,28.21 174.28,28.21 173.58,28.21 173.35,27.98 170.88,27.98 v1(170.46,28.4)
  T10 w0.089: v1(147.67,32.77) 147.67,32.77 152.54,27.89
  T10 w0.097: v1(170.46,28.4) 169.95,27.89 155.75,27.89 155.6,28.03 155.6,28.18 155.46,28.32 155.26,28.32 155.12,28.18 155.12,28.03 154.98,27.89 154.78,27.89 154.64,28.03 154.64,28.18 154.5,28.32 154.3,28.32 154.16,28.18 154.16,28.03 154.02,27.89 153.82,27.89 153.67,28.03 153.67,28.18 153.53,28.32 153.33,28.32 153.19,28.18 153.19,28.03 153.05,27.89 152.54,27.89
DDR4_B_DQ22: length 37.4
  TOP w0.089: v1(146.89,35.08) 146.6,35.38 145.64,35.38 144.34,36.67 143.53,36.67 U1.CU19
  TOP w0.109: CN2.58 167.4,31.46 168.11,30.75 169.04,30.75 169.31,31.03 170.05,31.03 v1(170.46,31.43)
  T10 w0.089: 147.7,33.79 148.01,33.48 154.22,33.48 154.35,33.35 154.35,33.32 154.48,33.19 154.67,33.19 154.8,33.32 154.8,33.35 154.93,33.48 155.11,33.48 155.24,33.35 155.24,33.32 155.37,33.19 155.55,33.19 155.68,33.32 155.68,33.35 155.82,33.48 156,33.48 156.13,33.35 156.13,33.32 156.26,33.19 156.44,33.19 156.57,33.32 156.57,33.35 156.7,33.48 156.89,33.48 157.02,33.35 157.02,33.32 157.15,33.19 157.33,33.19 157.46,33.32 157.46,33.35 157.59,33.48 160.97,33.48 163.16,31.29 ; 167.59,31.29 167.22,31.29 167.09,31.16 167.09,30.82 166.96,30.69 166.77,30.69 166.64,30.82 166.64,31.16 166.51,31.29 166.33,31.29 166.2,31.16 166.2,30.82 166.07,30.69 165.89,30.69 165.76,30.82 165.76,31.16 165.63,31.29 164.85,31.29
  T10 w0.097: v1(146.89,35.08) 146.89,34.6 147.7,33.79 ; 167.59,31.29 167.95,30.93 169.95,30.93 v1(170.46,31.43) ; 163.16,31.29 164.85,31.29
DDR4_B_DQ23: length 37.2
  TOP w0.089: U1.CR19 142.84,36.87 143.14,37.17 143.14,37.17 143.19,37.22 143.48,37.22 143.77,36.93 143.77,36.93 143.82,36.87 144.42,36.87 145.68,35.62 147.08,35.62 v1(147.6,35.09)
  TOP w0.109: v1(169.46,31.43) 169.85,31.43 170.26,31.84 171.64,31.84 172.04,31.44 173.12,31.44 173.39,31.71 174.28,31.71 174.42,31.71 CN2.59
  T10 w0.089: 161.38,34.12 148.26,34.12 147.84,34.53
  T10 w0.097: v1(169.46,31.43) 169.4,31.49 169.08,31.49 168.68,31.89 165.8,31.89 165.66,32.03 165.66,32.26 165.52,32.4 165.31,32.4 165.18,32.26 165.18,32.03 165.04,31.89 164.84,31.89 164.69,32.03 164.69,32.26 164.55,32.41 164.35,32.41 164.21,32.26 164.21,32.03 164.07,31.89 163.61,31.89 162.83,32.68 162.82,32.68 162.74,32.76 162.74,32.96 162.85,33.06 162.85,33.26 162.71,33.4 162.51,33.4 162.4,33.3 162.2,33.3 161.38,34.12 ; v1(147.6,35.09) 147.6,34.77 147.84,34.53
DDR4_B_DQ24: length 40.1
  TOP w0.089: v1(147.79,37.29) 147.37,36.87 145.88,36.87 145.56,37.19 145.56,37.75 144.46,38.85 U1.CU24
  TOP w0.109: CN2.70 167.43,34.46 167.9,33.99 169.67,33.99 169.92,34.24 169.92,34.8 170.13,35.01 170.34,35.01 170.46,34.89 v1(170.46,34.45)
  T05 w0.097: v1(170.46,34.45) 170.88,34.45 170.96,34.36 170.96,32.23 170.66,31.92 170.25,31.92 170.06,32.11 169.83,32.11 169.64,31.92 169.21,31.92 169.02,31.73 168.79,31.73 168.6,31.92 168.25,31.92 167.85,31.53 160.41,31.53 160.36,31.48 155.31,31.48 152.72,34.08 152.67,34.08 150.72,36.02 149.06,36.02 v1(147.79,37.29)
DDR4_B_DQ25: length 40.3
  TOP w0.089: v1(147.05,37.29) 147.23,37.29 147.37,37.43 147.37,37.56 147.21,37.71 145.87,37.71 145.72,37.87 144.54,39.04 143.9,39.04 143.76,39.19 143.18,39.19 142.84,38.85 U1.CR24
  TOP w0.109: CN2.71 174.42,34.71 174.28,34.71 173.42,34.71 173.25,34.88 171.85,34.88 171.46,34.48 v1(171.46,34.45)
  T05 w0.097: v1(147.05,37.29) 148.77,35.58 150.61,35.58 152.12,34.08 152.12,34.02 152.49,33.65 152.54,33.65 155.14,31.06 160.54,31.06 160.59,31.1 168.1,31.1 168.25,30.96 170.63,30.96 170.94,31.26 170.94,31.54 171.29,31.9 171.57,31.9 171.93,32.25 171.93,33.98 v1(171.46,34.45)
DDR4_B_DQ26: length 40.1
  TOP w0.089: U1.CU28 143.82,40.83 143.82,40.83 143.82,40.83 144.4,40.83 145.54,39.69 148.17,39.69 v1(149.21,38.65)
  TOP w0.109: CN2.83 174.42,37.71 174.28,37.71 172.05,37.71 171.9,37.56 171.9,37.05 171.76,36.9 171.2,36.9 171.05,37.06 171.05,37.68 170.95,37.77 170.75,37.77 v1(170.46,37.48)
  T05 w0.097: v1(170.46,37.48) 170.02,37.92 169.63,37.92 168.92,38.63 160.88,38.63 160.74,38.77 160.74,39.09 160.6,39.23 160.4,39.23 160.26,39.09 160.26,38.77 160.12,38.63 159.92,38.63 159.78,38.77 159.78,39.09 159.63,39.23 159.43,39.23 159.29,39.09 159.29,38.77 159.15,38.63 158.95,38.63 158.81,38.77 158.81,39.09 158.67,39.23 158.47,39.23 158.33,39.09 158.33,38.77 158.19,38.63 157.99,38.63 157.84,38.77 157.84,39.09 157.7,39.23 157.5,39.23 157.36,39.09 157.36,38.77 157.22,38.63 157.02,38.63 156.88,38.77 156.88,39.09 156.74,39.23 156.54,39.23 156.4,39.09 156.4,38.77 156.26,38.63 156.06,38.63 155.91,38.77 155.91,39.09 155.77,39.23 155.57,39.23 155.43,39.09 155.43,38.77 155.29,38.63 154.48,38.63 154,39.11 151.71,39.11 151.07,39.75 150.3,39.75 v1(149.21,38.65)
DDR4_B_DQ27: length 40.1
  TOP w0.089: U1.CR28 142.84,40.83 143.19,41.18 143.74,41.18 143.9,41.02 144.49,41.02 145.54,39.97 148.62,39.97 v1(149.95,38.65)
  TOP w0.109: CN2.84 167.84,37.96 168,37.8 168,37.08 168.11,36.98 168.82,36.98 168.91,37.06 168.91,38.02 169.03,38.14 169.37,38.14 169.46,38.05 v1(169.46,37.48)
  T05 w0.097: v1(149.95,38.65) 149.95,38.69 150.57,39.31 150.87,39.31 151.51,38.68 153.49,38.68 153.97,38.2 160.22,38.2 160.36,38.06 160.36,37.78 160.5,37.63 160.7,37.63 160.84,37.78 160.84,38.06 160.98,38.2 161.18,38.2 161.32,38.06 161.32,37.8 161.47,37.66 161.67,37.66 161.81,37.8 161.81,38.06 161.95,38.2 162.15,38.2 162.29,38.06 162.29,37.8 162.43,37.66 162.63,37.66 162.77,37.8 162.77,38.06 162.91,38.2 164.82,38.2 164.96,38.06 164.96,37.67 165.11,37.53 165.31,37.53 165.45,37.67 165.45,38.06 165.59,38.2 165.79,38.2 165.93,38.06 165.93,37.67 166.07,37.53 166.27,37.53 166.41,37.67 166.41,38.06 166.55,38.2 166.75,38.2 166.89,38.06 166.89,37.67 167.04,37.53 167.24,37.53 167.38,37.67 167.38,38.06 167.52,38.2 168.74,38.2 v1(169.46,37.48)
DDR4_B_DQ28: length 40.1
  TOP w0.089: U1.CV23 144.07,38.35 144.54,38.35 145.31,37.58 145.31,37.18 145.86,36.62 147.65,36.62 147.87,36.85 148.84,36.85 v1(149.25,37.26)
  TOP w0.109: v1(170.46,33.45) 170.81,33.45 170.92,33.33 170.92,33.07 170.8,32.94 168.25,32.94 167.74,33.46 166.49,33.46 CN2.66
  T05 w0.097: v1(170.46,33.45) 170.46,33.88 170.32,34.01 170.1,34.01 169.94,33.85 169.94,32.97 169.88,32.91 169.09,32.91 168.99,32.81 168.99,32.4 168.94,32.35 168.55,32.35 168.48,32.41 168.48,32.91 168.35,33.04 168.16,33.04 168.04,32.91 168.04,32.34 167.91,32.21 167.65,32.21 167.59,32.28 167.59,32.79 167.52,32.86 167.32,32.86 167.21,32.75 167.21,32.1 167.08,31.97 166.44,31.97 166.42,31.96 160.23,31.96 160.18,31.91 155.54,31.91 152.04,35.41 151.85,35.41 150.82,36.44 149.63,36.44 149.25,36.82 v1(149.25,37.26)
DDR4_B_DQ29: length 40
  TOP w0.089: U1.CT23 143.6,38.35 143.93,38.03 144.59,38.03 145.11,37.51 145.11,37.11 145.82,36.39 149.12,36.39 v1(149.98,37.26)
  TOP w0.109: CN2.67 174.42,33.71 174.28,33.71 171.86,33.71 171.59,33.98 170.2,33.98 170.06,33.83 170.06,33.54 169.97,33.45 v1(169.46,33.45)
  T05 w0.097: v1(149.98,37.26) 149.98,37.16 150.3,36.85 150.93,36.85 151.94,35.84 152.82,35.84 153.26,35.39 153.26,35.02 153.41,34.87 153.79,34.87 153.94,34.71 153.94,34.34 154.1,34.18 154.47,34.18 154.63,34.03 154.63,33.66 154.78,33.5 155.15,33.5 155.31,33.35 155.31,32.97 155.46,32.82 155.84,32.82 156.32,32.34 156.71,32.34 156.85,32.48 156.85,32.86 157,33 157.2,33 157.34,32.86 157.34,32.48 157.48,32.34 157.68,32.34 157.82,32.48 157.82,32.86 157.96,33 158.16,33 158.3,32.86 158.3,32.48 158.44,32.34 160.01,32.34 160.07,32.4 165.18,32.4 165.32,32.54 165.32,32.71 165.46,32.86 165.66,32.86 165.8,32.71 165.8,32.54 165.94,32.4 166.26,32.4 167.91,34.05 168.86,34.05 v1(169.46,33.45)
