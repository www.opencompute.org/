# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SGND_VCORE: length 32
  TOP w0.109: 72.58,77.31 v3(72.57,77.31)
  TOP w0.254: v3(87.37,75.71) 87.37,76.96 86.46,77.87 84.73,77.87 PR140.2 84.81,77.74 PR133.2 PC192.2 ; v3(75.67,75.48) PU17.29 77.85,75.48 v4(78.05,75.68) ; PU17.22 78.45,77.08 v4(78.05,76.68)
  TOP w0.381: v3(78.82,69.26) 79.14,69.58 PR202.2 ; PC188.2 73.4,74.47 72.51,74.47 72.18,74.8 72.18,76.05 71.8,76.42 71.8,77.38 ; v3(86.99,75.09) 86.93,75.15 PC193.2 85.49,74.24 PR141.2 85.68,74.02 v3(85.68,73.34) ; PR148.2 85.83,71.53 85.83,73.19 v3(85.68,73.34) ; v3(85.68,73.34) PR147.2 ; v3(81.5,69.43) 81.3,69.64 PR149.2 ; v3(76.85,69.41) 76.94,69.49 PC187.2 ; PC189.2 72.58,77.31
  T05 w0.381: v3(72.57,77.31) 72.84,77.05 72.84,77.05 74.4,75.48 v3(75.67,75.48)
  BOTTOM w0.381: 80.37,77.61 PR156.2
  vias: v4(78.05,74.68) v4(79.05,76.68) v4(79.05,75.68) v4(79.05,74.68) v4(80.05,76.68) v4(80.05,75.68) v4(80.05,74.68)
SGND_VP1P2_DDR4_VDD: length 12.5
  TOP w0.254: PU21.29 196.83,28.74 v4(196.63,28.54) ; PU21.22 196.23,27.14 v4(196.63,27.54) ; v4(194.63,27.54) 195.03,27.14 PU21.19
  TOP w0.381: PR157.2 v3(189.81,22) ; PR158.2 188.8,27.83 PC240.2 PR189.2 PC239.2 v3(189.1,25.8) ; v3(195.25,35.29) 195.43,35.12 PC233.2 PR200.2 ; PR178.2 189.2,35.09 v3(188.99,35.09) ; v3(189.07,31.13) PR176.2 PR177.2
  vias: v4(194.63,29.54) v4(194.63,28.54) v4(195.63,29.54) v4(195.63,28.54) v4(195.63,27.54) v4(196.63,29.54)
SGND_VP1P05: length 33
  TOP w0.254: PU27.19 68.2,53.45 v4(68.6,53.85) ; v4(69.6,51.85) 69.8,51.65 PU27.29 ; PR284.2 75.54,52.72 v3(75.6,52.66) ; v4(68.6,51.85) 68.2,52.25 PU27.22
  BOTTOM w0.254: v4(69.6,51.85) 69.22,51.47 PC348.2 ; v4(68.6,51.85) 68.07,51.32 PC329.2 ; v4(70.6,51.85) 71.63,50.82 PC347.2
  BOTTOM w0.305: PJ22.1 67.31,55.52 67.56,55.26
  BOTTOM w0.381: v4(70.6,53.85) 74.18,53.85 75.37,52.66 v3(75.6,52.66)
  BOTTOM w0.508: 67.44,53.22 66.24,53.22 66.08,53.38 65.9,53.38 64.8,54.47 64.66,54.47 63.76,55.37 63.76,57.97 64.74,58.95 66.43,58.95 66.93,58.46 PR274.2 PR300.2 PC332.2 PC339.2 PR275.2 PR285.2 PR269.2 PR296.2
  vias: v4(68.6,52.85) v4(69.6,53.85) v4(69.6,52.85) v4(70.6,52.85)
VCC_CORE_VIN_SHAPE:
  vias: v3(88.39,87.05)
VCC_SENSE: length 92.9
  TOP w0.127: U1.AT77 124.33,63.79 124.33,64.56
  TOP w0.203: v1(124.83,66.28) 124.82,66.28 124.33,65.79 124.33,64.56
  TOP w0.254: v3(78.8,82.38) 78.61,82.57 77.47,82.57 76.96,82.06 PR154.1
  T08 w0.254: v3(78.8,82.38) 78.58,82.6 78.58,82.79 78.58,83.32 87.75,92.49 98.29,92.49 99.69,93.89 125.54,93.89 127.27,92.16 127.27,69.3 125.06,67.09 125.06,66.5 v1(124.83,66.28)
  BOTTOM w0.089: v2(124.88,67.26) 124.83,67.21 v1(124.83,66.28)
  BOTTOM w0.254: v1(124.83,66.28) 124.82,66.28 124.21,65.66 124.21,63.83 124.53,63.5 124.79,63.5 124.79,63.5 125.86,63.5 126.01,63.65 PR137.2
VCCINT_CPLD: length 3.8
  TOP w0.381: U31.H10 v1(51.13,39.3) ; U31.J7 v1(49.15,43.28) ; U31.H8 v1(51.13,42.28) ; U31.J9 v1(49.15,40.3)
  BOTTOM w0.381: R365.1 49.07,40.38 v1(49.15,40.3)
  vias: v2(50.27,41.25)
VSS_SENSE: length 90.4
  TOP w0.089: U1.AT75 124.52,63.12 124.91,63.51
  TOP w0.203: v1(124.79,65.5) 124.73,65.45 124.73,64.59 124.66,64.52 124.66,64.16 124.91,63.91 124.91,63.51
  TOP w0.254: PR153.2 78.11,81.85 v3(78.2,81.93)
  T08 w0.254: v3(78.2,81.93) 78.2,82.71 78.2,82.75 78.2,82.79 78.2,83.48 87.59,92.87 98.13,92.87 99.53,94.27 125.7,94.27 127.65,92.31 127.65,69.14 125.49,66.98 125.49,66.21 v1(124.79,65.5)
  BOTTOM w0.254: v1(124.79,65.5) 124.59,65.3 124.59,64.15 124.77,63.97 PR136.1
10GBE_SPI_CLK_1V05: length 44.9
  TOP w0.089: 113.81,58.44 113.53,58.72 U1.M67
  TOP w0.109: v2(79.5,66.01) 78.87,65.37 U4.12 76.99,65.37 76.55,64.93 v3(76.55,63.41)
  TOP w0.152: 113.81,58.44 v1(113.84,58.41)
  T03 w0.089: 105.55,59.45 105.76,59.45 106.76,58.46 113.79,58.46 v1(113.84,58.41)
  T03 w0.097: v3(76.55,63.41) 78.06,61.89 99.39,61.89 101.6,59.68 103.84,59.68 104.07,59.46 105.55,59.46 105.55,59.45
10GBE_SPI_CLK_3V3: length 7.2
  TOP w0.109: R20.1 69.28,64.78 v3(68.55,64.04)
  BOTTOM w0.109: v3(68.55,64.04) 68.55,63.11 v2(68.85,62.81) 68.9,62.75 70.61,62.75 70.87,63.01 70.87,64.07 71.56,64.77 U3.6
10GBE_SPI_CLK_3V3_ST: length 2.3
  TOP w0.109: R20.2 70.59,65.37 U4.5
10GBE_SPI_CS_1V05_L: length 43.7
  TOP w0.089: v1(114.85,59) 114.65,59 U1.P67
  TOP w0.109: v3(81.12,63.28) 81.12,63.79 80.84,64.07 79.08,64.07 78.42,64.72 U4.11
  T03 w0.089: 105.55,59.93 107.06,59.93 107.27,59.73 113.32,59.73 114.04,59 v1(114.85,59)
  T03 w0.097: v3(81.12,63.28) 82.03,62.37 99.82,62.37 101.45,60.74 102.05,60.74 102.36,61.05 103.15,61.05 104.26,59.93 105.55,59.93
  BOTTOM w0.089: v1(114.85,59) 114.93,58.93 R11.1 114.54,57.89 113.38,57.89 v2(112.89,58.38)
10GBE_SPI_CS_3V3_L: length 18.7
  TOP w0.109: v3(74.9,63.52) 73.37,61.99 69.77,61.99 69.28,62.48 R21.1
  BOTTOM w0.109: v3(74.9,63.52) 74.9,64.1 78.1,67.31 U3.1 79.13,67.33 82.3,67.33 v2(82.55,67.58) 82.67,67.46 R4.1
10GBE_SPI_CS_3V3_ST_L: length 3.7
  TOP w0.109: v2(70.1,62.63) R21.2 70.96,64.72 U4.6
10GBE_SPI_DI_1V05: length 40.4
  TOP w0.089: v1(108.12,60.66) 108.12,60.69 108.37,60.93 108.37,60.94 108.55,61.13 108.89,61.13 U1.C73
  TOP w0.109: U4.13 76.88,66.02 75.79,64.93 v3(75.79,63.41)
  T03 w0.089: v1(108.12,60.66) 106.41,60.66 105.55,61.52 105.55,61.52
  T03 w0.097: 105.55,61.52 105.16,61.91 101.35,61.91 100.3,62.96 83.51,62.96 82.58,63.9 76.28,63.9 v3(75.79,63.41)
  BOTTOM w0.102: v1(108.12,60.66) 108.15,60.64 108.15,59.67 v2(108.17,59.65)
10GBE_SPI_DO_1V05: length 35.9
  TOP w0.089: v1(107.26,62.26) 107.67,61.85 108.74,61.85 108.8,61.91 109.58,61.91 U1.D74
  TOP w0.109: v3(85.55,65.19) 85.86,64.87 85.86,62.88 85.37,62.39 R12.2
  T10 w0.097: v3(105.13,62.37) 104.53,61.77 104.53,58.78 104,58.25 103.72,58.25 103.16,58.81 100.96,58.81 100.93,58.84 100.46,58.84 94.11,65.19 v3(85.55,65.19)
  BOTTOM w0.089: v2(107.26,63.15) v1(107.26,62.26) 107.15,62.37 106.22,62.37
  BOTTOM w0.109: 106.22,62.37 v3(105.13,62.37) 104.88,62.63 R16.2
10GBE_SPI_DO_1V05_ST: length 5.1
  TOP w0.109: U2.4 84.26,63.92 85.3,63.92 85.37,63.84 85.37,63.31 85.27,63.21 83.7,63.21 83.49,63 83.49,62.52 83.65,62.37 84.23,62.37 R12.1
10GBE_SPI_HOLD_3V3_L: length 3.9
  BOTTOM w0.109: v2(70.1,63.39) 69.97,63.52 R5.1 71.46,66.04 U3.7
10GBE_SPI_MISO_3V3: length 14.1
  TOP w0.109: v3(80.99,65.51) 80.99,65.5 80.68,65.19 79.4,65.19 79.23,65.01 79.23,64.75 79.37,64.61 81.06,64.61 81.66,64.01 U2.3
  BOTTOM w0.109: R13.1 81.19,65.31 v3(80.99,65.51) 78.33,65.51 77.91,65.09 77.91,62.8 79.08,61.64 v2(79.58,61.64)
10GBE_SPI_MISO_3V3_ST: length 9.7
  BOTTOM w0.109: R13.2 82.67,65.66 82.51,65.83 81.6,65.83 81.39,66.04 U3.2 78.16,66.04 77.42,65.29 77.42,61.8 v2(77.52,61.7)
10GBE_SPI_MOSI_3V3: length 10.7
  TOP w0.109: v3(67.91,64.55) 67.91,65.44 68.37,65.9 R19.1
  BOTTOM w0.109: v3(67.91,64.55) 67.53,64.17 v2(67.53,63.28) 67.53,62.54 68.07,62 71.75,62 72.06,62.31 U3.5
10GBE_SPI_MOSI_3V3_ST: length 3.4
  TOP w0.109: v2(70.1,67.07) R19.2 70.23,66.02 U4.4
10GBE_SPI_WP_3V3_L: length 4.5
  BOTTOM w0.109: U3.3 79.76,64.77 80.23,64.3 R6.1 v2(81.6,62.5)
ADC_CPU_TEMP_SENSOR: length 67.1
  TOP w0.109: J10.B82 98.35,11.19 95.2,14.34 90.81,14.34 90.27,14.88 86.92,14.88 86.08,15.71 86.08,16.5 86.59,17.01 87.96,17.01 89.18,18.23 89.18,23.43 90.7,24.96 91.77,24.96 v3(92.15,24.58)
  T08 w0.089: 105.55,42.12 105.66,42.23 108.08,42.23 110.69,44.85 v1(110.69,44.92)
  T08 w0.097: v3(92.15,24.58) 92.15,25.42 95.89,29.15 95.89,35.6 101.85,41.57 105,41.57 105.55,42.12
  BOTTOM w0.089: v1(110.69,44.92) 110.22,44.45 U36.3 110.22,42.16 v2(110.33,42.05)
ADR_TRIGGER_L_GPIO37: length 14.7
  TOP w0.089: U1.BL2 131.47,28.93 131.47,27.75 131.52,27.7 131.52,22.99 132.9,21.61
  TOP w0.109: 132.9,21.61 133.1,21.41 133.94,21.41 135.6,19.74 v3(135.6,18.7) R254.1
  BOTTOM w0.109: R254.1 v3(135.6,18.7)
AUD_AZA_SDO: length 29.8
  TOP w0.152: U1.BD22 v1(128.04,38.65)
  T08 w0.089: v1(128.04,38.65) 127.42,38.04 127.42,35.6 126.95,35.13 126.38,35.13 125.37,34.12 125.37,32.25 125.64,31.98 125.64,31.49 125.14,30.99 125.14,28.83 126.11,27.86 126.11,24.15 125.43,23.46 125.43,21.61
  T08 w0.097: 125.43,21.61 125.43,21 v3(126.46,19.97)
  BOTTOM w0.109: R299.2 127.22,14.54 127.22,17.27 126.91,17.58 R303.1 125.78,18.27 125.78,19.29 v3(126.46,19.97)
BDX_CLKIN_SATA_N: length 2
  TOP w0.152: U1.BH33 v1(129.72,43.56)
  BOTTOM w0.108: v1(129.72,43.56) 129.4,43.56 R37.2
BDX_CLKIN_SATA_P: length 4
  TOP w0.152: U1.BG32 v1(129.22,42.69)
  BOTTOM w0.108: R38.2 130.45,43.08 v2(130.81,42.72) 130.78,42.69 v1(129.22,42.69)
BDXDE_CATERR_L: length 88
  TOP w0.109: v3(63.1,28.74) 63.36,29 R193.2 64.89,30.03 U10.10
  TOP w0.152: v1(117.8,58.45) 117.53,58.72 U1.Y67
  T05 w0.089: v1(117.8,58.45) 117.84,58.49 117.84,61.59 117.98,61.72 117.98,64.81 v1(117.1,65.68)
  T08 w0.097: v3(63.1,28.74) 63.24,28.6 69.69,28.6 70.65,29.55 70.65,31.04 83.8,44.19 88.33,44.19 91.84,47.7 98,47.7 101.13,50.84 105.38,50.84 106.35,51.81 106.35,60.38 109.81,63.84 115.27,63.84 v1(117.1,65.68)
  BOTTOM w0.109: v2(62.06,28.74) v3(63.1,28.74)
BDXDE_CPU2PCH_THROT_1V05: length 26.2
  TOP w0.109: v3(113.89,73.44) 113.28,74.05 R252.2 113.25,74.05 112.6,74.05 112.22,73.67 112.22,72.3 111.94,72.02 R205.1 R257.1
  TOP w0.152: U1.AL74 v1(122.55,61.82)
  T05 w0.097: 113.99,73.31 113.89,73.41 v3(113.89,73.44)
  T05 w0.102: 113.99,73.31 115.16,72.14 115.16,70.7 115.94,69.91 120.34,69.91 121.74,68.51 121.74,67.86 121.73,67.86 121.73,66.18 121.74,66.18 121.74,62.78 122.55,61.96 v1(122.55,61.82)
  BOTTOM w0.109: v3(113.89,73.44) 113.12,72.68 v2(111.47,72.68)
BDXDE_CPU2PCH_THROT_1V05_R: length 136.2
  TOP w0.109: R205.2 111.71,74.11 v3(112.47,74.87) ; U15.4 30.01,30.18 30.07,30.24 30.07,33.33 28.56,34.84 28.56,42.08 30.21,43.74 30.21,45.44 29.39,46.26 29.39,48.98 30.21,49.8 30.21,60.76 29.85,61.12 29.82,61.12 25.75,65.19 v3(25.75,66.2)
  T03 w0.097: v3(104.87,74.58) 106.12,75.84 111.51,75.84 v3(112.47,74.87)
  T08 w0.097: v3(25.75,66.2) 25.75,66.23 29.58,70.06 34.33,70.06 34.44,70.16 36.87,70.16 36.87,70.17 37.23,70.17 37.23,70.16 39.68,70.16 40.25,69.59 49.54,69.59 50.1,69.03 63.24,69.03 64.59,70.38 81.51,70.38 82.78,71.64 83.15,71.64 84.19,70.6 96.84,70.6 99.84,73.59 103.4,73.59 104.39,74.58 v3(104.87,74.58)
BDXDE_CPU2PCH_THROT_3V3: length 3.5
  TOP w0.109: U15.13 35.71,30.18 v3(36.06,29.83) 36.43,29.45 R206.1 R204.2
BDXDE_CPU_RSMRST_L: length 112.3
  TOP w0.089: U1.R77 114.45,63.77 114.45,64.54 114.24,64.74 ; v1(113.48,67.56) 111.6,69.44 R115.2
  TOP w0.109: 114.24,64.74 114.24,66.8 v1(113.48,67.56) ; R104.2 30.79,45.75 30.02,46.52 30.02,48.48 30.96,49.42 30.96,53.07 32.49,54.61 38.27,54.61 v3(38.4,54.48)
  T03 w0.097: v1(113.48,67.56) 112.69,68.36 110.68,68.36 109.89,68.36 108.75,67.22 82.98,67.22 82.05,66.28 74.99,66.28 74.05,67.22 45.63,67.22 43.2,64.78 43.2,55.02 42.78,54.61 41.68,54.61 41.33,54.26 39.5,54.26 39.47,54.29 38.58,54.29 v3(38.4,54.48)
BDXDE_CPU_RSMRST_L_R: length 2.3
  TOP w0.109: U18.4 32.77,45.77 R104.1 32.76,46.34 32.61,46.49 v3(32.61,46.52)
BDXDE_CPU_THERMTRIP_L: length 104
  TOP w0.152: U1.AF72 v1(120.31,61)
  T08 w0.089: v1(120.31,61) 120.71,61.4 122.68,61.4 122.94,61.66 122.94,61.98 122.71,62.21
  T08 w0.097: v3(40.18,67.25) 40.18,67.48 41.63,68.93 48.93,68.93 49.84,68.02 63.79,68.02 64.18,67.63 70.56,67.63 70.89,67.3 80.03,67.3 80.91,68.19 82.4,68.19 83.59,69.37 96.24,69.37 97.14,68.48 102.71,68.48 106.71,72.48 112.75,72.48 113.76,71.47 114.4,71.47 115.33,70.54 118.13,70.54 120.16,68.51 120.16,68.23 121.28,67.1 121.28,63.63 122.71,62.21
  BOTTOM w0.109: U11.12 37.27,67.78 37.47,67.58 R197.2 37.82,67.94 38.11,68.22 39.63,68.22 39.69,68.28 v2(40.38,68.28) 40.38,67.46 v3(40.18,67.25)
BDXDE_DDR4_RESET_L: length 59.1
  TOP w0.089: U1.CR43 142.34,48.25 142.69,48.6 142.98,48.6 143.19,48.4 143.56,48.4 143.72,48.56 144.23,48.56 144.46,48.33 146.14,48.33 146.37,48.1 151.86,48.1 152.17,47.8 152.17,46.91 v1(150.94,45.69)
  TOP w0.109: CN2.108 166.49,43.97 168.06,43.97 168.36,44.26 168.66,44.26 168.82,44.11 169.19,44.11 169.47,44.39 169.76,44.39 169.99,44.16 169.99,44.16 170.01,44.14 170.34,44.14 170.36,44.16 170.36,44.16 170.56,44.36 170.88,44.36 171.13,44.11 171.52,44.11 171.62,44.21 172.11,44.21 172.52,43.81 v1(172.97,43.81)
  T05 w0.152: v1(150.94,45.69) 150.94,45.39 154.63,41.7 167.39,41.7 169.12,43.43 171.57,43.43 171.65,43.35 172.08,43.35 172.53,43.81 v1(172.97,43.81)
  T08 w0.102: v1(172.97,43.81) 173.4,43.38 184.28,43.38 v1(184.7,43.81)
  BOTTOM w0.109: v1(184.7,43.81) 185.19,43.81 185.29,43.91 CN1.108
BDXDE_DRAM01_PWROK: length 84.5
  TOP w0.109: v1(145.07,53.33) 144.94,53.2 U1.CV55
  TOP w0.152: v1(127.22,31.81) 126.77,32.1 U1.BA9
  T08 w0.089: 128.03,21.61 127.62,22.02 127.62,30.09 127.12,30.59 127.12,30.91 127.22,31.02 v1(127.22,31.81)
  T08 w0.097: 128.03,21.61 128.03,20.77 128.41,20.39 128.41,19.45 129.08,18.79 129.08,18.52 129.64,17.96 130.61,17.96 131.2,17.37 132.25,17.37 133.28,16.34 133.28,15.08 135.13,13.24 135.5,13.24 136.33,12.4 136.33,12.03 137.28,11.08 140.47,11.08 140.52,11.04 141.81,11.04 141.9,11.13 142.26,11.13 142.35,11.04 143.27,11.04 v3(143.6,10.7)
  T10 w0.097: 143.99,41.8 143.99,32.5 139.32,27.83 139.32,22.1 145.35,16.07 145.35,11.64 144.42,10.7 v3(143.6,10.7)
  T10 w0.109: v1(145.07,53.33) 144.88,53.33 143.99,52.44 143.99,41.8
  BOTTOM w0.109: v3(143.6,10.7) 143.62,10.68 R69.2
BDXDE_ERR0_GTL_L: length 81.8
  TOP w0.089: U1.AC77 118.58,65.12 v1(118.39,65.32)
  TOP w0.109: U10.13 66.84,30.32 67.29,29.87 67.29,29.12 R196.2 67.91,29.5 v3(67.91,29.62)
  T08 w0.089: 116.36,66.08 114.69,64.41
  T08 w0.097: 116.36,66.08 116.39,66.11 116.39,67.22 117,67.83 117.7,67.83 118.78,66.76 118.78,65.71 v1(118.39,65.32) ; 114.69,64.41 111.71,64.41 111.71,64.41 107.78,64.41 105.03,61.66 104.95,61.66 104.43,61.14 104.43,61.08 102.84,59.48 99.31,59.48 98,60.79 96.17,60.79 88.72,53.34 88.72,47.09 87.44,45.81 82.34,45.81 75.97,39.44 75.97,37.99 71.78,33.8 71.02,33.8 67.91,30.69 v3(67.91,29.62)
  BOTTOM w0.109: v2(67.61,30.67) 67.61,29.93 v3(67.91,29.62)
BDXDE_ERR0_LVT3_L: length 7.9
  TOP w0.109: R345.1 62.65,40.75 62.65,40.11 63.84,38.92 64.07,38.92 64.09,38.9 v3(64.09,38.9) 64.79,38.9 65.69,38.01 66.51,38.01 66.84,37.68 U10.4
  BOTTOM w0.109: v2(64.99,38.92) 64.98,38.92 64.11,38.92 v3(64.09,38.9)
BDXDE_ERR0_LVT3_L_R: length 4.1
  TOP w0.089: 58.77,40.79 U31.A9
  TOP w0.109: 58.77,40.79 59.94,40.79 v3(59.94,40.78) 59.95,40.79 61.55,40.79 R345.2
BDXDE_ERR1_GTL_L: length 80.4
  TOP w0.089: 118,66.21 118,64.89 118.37,64.51 118.37,64.16 118.24,64.03 118.24,63.44 118.58,63.11 U1.AC75
  TOP w0.109: 118,66.21 v1(118.39,66.59) ; U10.12 66.19,30.26 66.14,30.21 R195.2 66.64,29.5 v3(66.77,29.5)
  T08 w0.089: 115.15,64.6 114.77,64.22 111.63,64.22
  T08 w0.097: 111.63,64.22 108.66,64.22 106.78,62.34 106.78,61.55 105.56,60.33 105.56,56.84 103.16,54.44 101.31,54.44 95.17,48.3 91.59,48.3 88.08,44.79 83.44,44.79 70.03,31.39 69.8,31.39 69.04,30.63 69.04,29.59 68.65,29.19 67.07,29.19 v3(66.77,29.5) ; v1(118.39,66.59) 118.39,66.65 117.4,67.64 117.08,67.64 116.67,67.23 116.67,66.12 115.15,64.6
  BOTTOM w0.109: v2(66.69,28.43) 66.77,28.51 v3(66.77,29.5)
BDXDE_ERR1_LVT3_L: length 13.9
  TOP w0.109: U10.5 66.19,35.4 66.37,35.22 67.74,35.22 v3(67.97,34.99) ; v3(63.96,39.61) 63.62,39.61 63.02,40.22 63.02,41.08 62.48,41.61 R346.1
  T05 w0.097: v3(63.96,39.61) 64.23,39.61 67.97,35.88 v3(67.97,34.99)
  BOTTOM w0.109: v3(63.96,39.61) 63.3,40.28 v2(63.3,40.43)
BDXDE_ERR1_LVT3_L_R: length 4.1
  TOP w0.089: 58.77,41.79 U31.A8
  TOP w0.109: 58.77,41.79 v3(60.96,41.79) 61.54,41.79 R346.2
BDXDE_ERR2_GTL_L: length 78.5
  TOP w0.089: v1(117.23,66.46) 117.49,66.2 117.49,65.29 117.52,65.26 117.52,64.62 117.8,64.35 117.8,64.17 117.95,64.03 117.95,63.24 U1.AB76
  TOP w0.109: U10.11 65.54,30.17 65,29.63 R194.2 65.02,29 v3(65.52,29.5)
  T08 w0.097: v1(117.23,66.46) 117.23,66.41 114.85,64.03 109.73,64.03 105.85,60.16 105.85,56.71 103.29,54.14 101.44,54.14 95.3,48 91.72,48 88.21,44.49 83.62,44.49 70.35,31.22 70.35,29.67 69.57,28.9 66.13,28.9 v3(65.52,29.5)
  BOTTOM w0.109: v3(65.52,29.5) 65.52,30.64 v2(65.65,30.77)
BDXDE_ERR2_LVT3_L: length 11.2
  TOP w0.089: 58.77,40.04 57.89,40.04 U31.A10
  TOP w0.109: 58.77,40.04 61.33,40.04 61.84,39.53 62.78,39.53 64.05,38.26 64.32,38.26 64.34,38.24 v3(64.35,38.24) 64.38,38.26 64.99,38.26 65.54,37.71 U10.6
  BOTTOM w0.109: v3(64.35,38.24) 64.37,38.22 64.37,37.22 v2(64.47,37.12)
BDXDE_ME_DRIVE_L: length 121.3
  TOP w0.109: R68.2 v3(126.46,9.56) ; U31.B13 56.21,36.36 v1(56.21,36.23)
  TOP w0.152: v1(127.03,38.17) 127.43,38.57 U1.BB23
  T05 w0.097: v3(126.46,9.56) 126.46,11.52 123.16,14.82 97.88,14.82 96.6,13.54 91.52,13.54 87.42,17.64 83.21,17.64 81.02,19.83 70.01,19.83 68.29,21.55 63.13,21.55 58.95,25.72 58.95,30.89 56.72,33.12 56.72,35.73 v1(56.21,36.23)
  T10 w0.089: 125.68,21.61 125.68,24.13 126.08,24.53 126.08,25.46 126.1,25.47 126.1,31.43 125.87,31.65 125.87,31.97 126.16,32.27 126.16,33.56 126.64,34.04 126.64,34.76 127.42,35.54 127.42,36.4 126.63,37.19 126.63,37.77 v1(127.03,38.17)
  T10 w0.097: v3(126.46,9.56) 126.46,12.72 125.68,13.5 125.68,16.13 126.26,16.71 126.26,17.73 125.68,18.31 125.68,21.61
BDXDE_PECID0: length 21.1
  TOP w0.109: R263.1 v3(101.74,60.21)
  TOP w0.152: U1.L72 112.59,61.01 v1(112.38,61.01)
  T10 w0.089: v1(112.38,61.01) 112.09,61.29 112.09,61.95 109.87,64.17 105.55,64.17
  T10 w0.097: v3(101.74,60.21) 101.17,60.78 101.17,63.08 102.26,64.17 105.55,64.17
  BOTTOM w0.109: R263.1 v3(101.74,60.21) 101.74,60.61 102.18,61.05 103.44,61.05 v2(103.6,60.89)
BDXDE_PIRQC_L: length 3.8
  TOP w0.109: v2(47.62,25.54) 47.35,25.82 R46.2 46.81,27.22 45.9,27.22 45.72,27.04 U35.7
BDXDE_PIRQD_L: length 5.1
  TOP w0.109: 45.21,27.7 45.22,27.7 U35.6 ; 45.21,27.7 44.07,27.7 v3(43.69,27.32) ; 45.21,27.7 R45.2
BDXDE_PME_L: length 1.3
  TOP w0.152: U1.BE16 128.67,35.57 v1(128.19,35.77)
  BOTTOM w0.108: v1(128.19,35.77) 128.19,35.65 128.53,35.31 R79.2
BDXDE_RESET_L: length 242.8
  TOP w0.089: U1.L76 113.05,63.19 113.05,63.95 112.85,64.16 112.85,64.62 112.34,65.13 112.34,66.14
  TOP w0.109: U13.11 79.66,28.22 79.14,28.74 v3(79.02,28.74) ; R123.2 109.57,68.91 v1(111.88,66.59) 112.34,66.14
  TOP w0.152: U1.BU7 v1(133.68,31.54)
  T05 w0.089: v1(133.68,31.54) 133.83,31.38 133.83,30.59 132.09,28.85 117.35,28.85 115.07,26.57 113.13,26.57 111.36,28.34 109.73,28.34 108.78,27.39 105.55,27.39
  T05 w0.097: 105.55,27.39 80.37,27.39 v3(79.02,28.74)
  T08 w0.097: v1(111.88,66.59) 111.32,67.15 111.32,67.39 110.45,68.27 107.66,68.27 103.99,64.6 101.97,64.6 101.53,65.03 95.67,65.03 93.19,62.55 67.56,62.55 67.12,62.99 62.53,62.99 62.13,62.59 58.45,62.59 57.74,63.3 51.46,63.3 50.48,62.32 45.32,62.32 45.05,62.6 23.38,62.6 22.35,61.57 19.85,61.57 19.46,61.18 14.51,61.18 v3(14.45,61.25)
  T10 w0.089: v1(111.88,66.59) 111.97,66.59 113.32,67.95 113.92,67.95 114.48,67.39 115.99,67.39 116.53,66.85 117.41,66.85 117.8,66.47 117.8,62.97 118.15,62.62 118.15,61.65 117.93,61.42 117.93,60.19 118.43,59.68 119.47,59.68 119.69,59.46 119.69,59.13 119.42,58.86 119.42,56.45 119.47,56.4 119.6,56.28 119.6,55.08 119.6,55.07 119.6,54.6 119.6,54.59 119.6,43.95 119.9,43.65 124.68,43.65 125.2,43.14 125.2,42.65 125.5,42.35 127.01,42.35 129.72,39.65 132.36,39.65 132.58,39.42 132.58,39.1 132.3,38.82 132.3,38.23 132.61,37.93 132.61,37.37 133.29,36.68 133.29,36.4 133.57,36.12 133.57,35.72 134.02,35.28 134.02,35.27 134.07,35.22 134.07,34.55 133.79,34.27 133.79,34.24 133.78,34.22 133.78,33.79 134.1,33.46 134.1,32.95 133.78,32.62 133.78,31.63 v1(133.68,31.54)
  BOTTOM w0.109: v3(14.45,61.25) 14.2,61 9.48,61 8.53,61.95 v2(8.53,63.87) 8.53,67.92 7.73,68.72 R406.2
BDXDE_RESET_L_R: length 10.7
  TOP w0.109: v3(3.6,67.86) 3.19,68.27 3.19,69.76 3.38,69.96 3.38,70.32 2.7,71 2.7,72.49 3.47,73.26 4.41,73.26 4.52,73.36 J12.46
  BOTTOM w0.109: v3(3.6,67.86) 3.85,68.11 4.82,68.11 R406.1
BDXDE_RTCX1: length 10.9
  TOP w0.089: U1.AT2 124.49,28.92 124.49,27.97 124.45,27.92 124.45,27.43 124.68,27.2 124.68,26.36 124.62,26.3
  TOP w0.109: 124.62,26.3 124.62,23.93 v2(124.38,23.69) 124.33,23.64 124.33,23.64 123.62,22.93 R61.2 123.62,21.27 C27.1 123.67,20.21 124.06,19.82 Y2.1
BDXDE_RTCX2: length 12.7
  TOP w0.089: 124.21,26.23 124.5,26.52 124.5,27.02 124.26,27.25 124.26,28 124.31,28.05 124.31,28.37 124.18,28.5 124.18,29.12 124.36,29.3 124.36,29.78 U1.AT4
  TOP w0.109: 124.21,26.23 124.21,25.11 v2(123.99,24.9) 122.25,23.16 R61.1 122.25,21.27 C26.1 122.2,20.48 121.56,19.84 Y2.2
BDXDE_SPKR: length 37.2
  TOP w0.109: R302.1 v3(135.6,5.24)
  TOP w0.152: U1.BP20 v1(132.2,37.55)
  T10 w0.089: 134.29,21.61 134.29,23.04 133.41,23.91 133.41,28.94 133.06,29.3 133.06,31.04 133.27,31.25 133.27,31.93 133.57,32.23 133.57,32.81 133.29,33.09 133.29,33.56 133.57,33.84 133.57,34.42 133.27,34.73 133.27,35.2 132.93,35.54 132.8,35.67 132.8,36.03 132.43,36.4 132.3,36.53 132.3,37.44 v1(132.2,37.55)
  T10 w0.097: v3(135.6,5.24) 134.84,6 134.84,20.93 134.29,21.48 134.29,21.61
  BOTTOM w0.109: R302.1 v3(135.6,5.24)
BDXDE_SVID_ALERT_L: length 6.7
  TOP w0.152: U1.AK72 v1(122.29,61.01)
  BOTTOM w0.089: R108.1 123.47,62.34 123.13,62 123.13,61.85 122.94,61.66 122.71,61.43 122.71,61.43 v1(122.29,61.01) 122.29,60.87 122.46,60.69 122.8,60.69 123.31,60.18 123.31,59.91 123.48,59.74 124.38,59.74 125.23,58.88 v2(125.23,58.8)
BDXDE_SVID_CLK: length 5.3
  TOP w0.152: U1.AH72 v1(121.3,61.01)
  BOTTOM w0.102: 121.11,62.83 121.78,62.83 122.07,62.54 122.07,62.18 121.95,62.07 121.95,61.73 121.3,61.08 v1(121.3,61.01)
  BOTTOM w0.108: R107.1 120.82,64.21 120.95,64.08 120.95,62.99 121.11,62.83
BDXDE_SVID_DATA: length 5.1
  TOP w0.089: U1.AJ71 121.51,60.44 v1(121.79,60.15)
  BOTTOM w0.089: v2(122.32,59.3) 122.32,59.63 v1(121.79,60.15)
  BOTTOM w0.102: R106.1 122.29,63.3 122.29,62.12 122.16,61.98 122.16,61.53 121.79,61.16 121.79,60.16 v1(121.79,60.15)
BDXDE_SYS_RESET: length 6.5
  BOTTOM w0.109: Q2.1 36.26,24.72 v2(36.86,25.31) 37.85,25.31 Q3.3 40.87,24.69 R340.2
BDXDE_SYS_RESET_L: length 124.3
  TOP w0.089: U1.BL4 131.45,29.42 131.11,29.09 131.11,28.5 131.28,28.34 131.28,27.67 131.33,27.62 131.33,26.38 131,26.05 v1(130.94,26.05)
  T03 w0.097: v3(31.44,21.06) 33.04,22.66 49.02,22.66 49.2,22.49 50.74,20.95 76.3,20.95 80.01,24.66 v3(80.01,25.29)
  T05 w0.089: v1(130.94,26.05) 131.1,25.89 132.53,25.89 133.86,24.55 133.86,22.21 133.63,21.98 131.39,21.98 128.2,25.17 125.1,25.17 123.25,23.32 121.07,23.32 120.99,23.24 119.27,23.24
  T05 w0.097: v3(80.01,25.29) 87.5,25.29 89.9,22.9 107.36,22.9 107.82,23.36 112.39,23.36 112.64,23.6 114.77,23.6 115.14,23.24 119.27,23.24
  BOTTOM w0.109: v3(31.44,21.06) 31.73,21.34 R338.2 33.22,23.48 Q2.3
BDXDE_THERMTRIP_L: length 6
  TOP w0.109: R219.2 66.67,11.55 66.67,8.9 66.35,8.58 J10.B50
BDXDE_THERMTRIP_PCH_L: length 77.1
  TOP w0.109: U19.4 67.18,40.26 67.28,40.16 R213.2 67.28,39.41 67.56,39.13 70.97,39.13 71.86,38.24 71.86,37.54 73.06,36.33 75.58,36.33 v3(76.71,35.21)
  TOP w0.152: U1.BJ16 v1(130.21,35.83)
  T05 w0.089: 105.55,27.85 108.48,27.85 109.27,28.64 114.92,28.64 116.39,30.12 128.43,30.12 129.16,30.84 129.16,32.14 130.32,33.31 130.32,33.41 130.6,33.69 130.6,34.27 130.21,34.66 v1(130.21,35.83)
  T05 w0.097: 105.55,27.85 91.37,27.85 90.58,28.64 82.8,28.64 76.71,34.74 v3(76.71,35.21)
BIOS_ADV_FUNCTIONS_GPIO36: length 13.3
  TOP w0.089: 135.22,21.61 133.69,23.14 133.69,27.57 133.93,27.8 U1.BT1
  TOP w0.109: R253.2 v3(137.13,18.7) 137.13,19.7 135.22,21.61
  BOTTOM w0.109: R253.2 v3(137.13,18.7)
BIOS_CS_SEL_L: length 179.1
  TOP w0.109: U31.K1 v1(48.15,49.28)
  T05 w0.097: v1(48.15,49.28) 48.08,49.28 46.58,47.79 41.97,47.79 39.94,45.75 39.94,45.26 38.07,43.39 37.9,43.22 37.2,42.52 35.82,41.14 35.82,37.67 35.53,37.38 35.53,21.76 v3(35.94,21.35)
  T08 w0.097: v3(166.16,10.52) 165.9,10.79 147.57,10.79 146.98,10.19 145.61,10.19 144.25,8.83 132.68,8.83 131.64,9.87 131.64,12.23 131.21,12.65 130.83,12.65 127.86,15.62 127.37,15.62 126.32,16.68 125.28,16.68 124.18,17.78 121.04,17.78 120.76,18.07 120.76,20.02 118.6,22.18 106.85,22.18 106.68,22.35 103.48,22.35 102.9,21.76 74.43,21.76 73.48,20.82 52.78,20.82 50.85,22.75 47.87,22.75 46.48,21.35 v3(35.94,21.35)
  BOTTOM w0.109: v3(166.16,10.52) 166.7,11.07 R223.1
BIOS_RCVR_BOOT_L: length 34.7
  TOP w0.109: R289.2 v3(138.65,9.56)
  TOP w0.152: U1.BU22 v1(133.68,38.4)
  T03 w0.089: 134.34,21.61 134.34,24.12 133.87,24.59 133.87,30.87 134.23,31.23 134.23,31.9 134.56,32.23 134.56,32.55 134.29,32.83 134.29,33.58 134.56,33.85 134.56,34.27 134.29,34.55 134.29,35.23 134.56,35.51 134.56,36.08 134.09,36.56 134.09,36.9 133.68,37.31 v1(133.68,38.4)
  T03 w0.097: v3(138.65,9.56) 136.29,11.92 136.29,19.25 134.34,21.2 134.34,21.61
  BOTTOM w0.109: R289.2 v3(138.65,9.56)
BMC_RTCRST_L: length 182.9
  TOP w0.109: v3(31.38,14.57) 32.01,13.94 32.01,11.27 30.35,9.61 J10.B14 ; R314.2 187.99,12.69 187.43,13.24 172.82,13.24 172.21,13.86 157.23,13.86 154.26,10.89 147.53,10.89 146.69,10.06 143.5,10.06 142.3,11.26 139.64,11.26 138.66,10.28 126.65,10.28 123.14,13.79 96.82,13.79 95.45,15.15 91.57,15.15 90.73,15.99 87.58,15.99 v3(87.56,15.97) ; R314.2 v3(194.44,11.78) ; R314.2 R312.1
  T08 w0.097: v3(31.38,14.57) 31.38,14.93 33.45,17 35.13,17 36.75,15.38 55.5,15.38 55.73,15.15 67.26,15.15 67.49,15.38 85.01,15.38 85.47,14.93 87.03,14.93 87.56,15.46 v3(87.56,15.97)
BMC_TO_HOST_INT_L: length 58.9
  TOP w0.109: v3(46.2,54.26) 46.45,54.01 46.45,53.77 R357.2 R438.2 ; J10.B20 36.35,8.85 36.04,9.16 36.04,13.5 v3(33.62,15.91)
  T05 w0.097: v3(33.62,15.91) 34.18,16.46 34.18,38.51 34.42,38.75 34.42,41.53 35.43,42.54 35.43,43.96 38.37,46.9 38.37,47.8 45.25,54.68 45.77,54.68 v3(46.2,54.26)
  BOTTOM w0.109: v2(33.19,17.07) 33.62,16.63 v3(33.62,15.91)
BMC_TO_HOST_INT_L_R: length 5.3
  TOP w0.089: 47.14,49.82 v1(47.47,49.49)
  TOP w0.109: R357.1 46.71,51.75 47.08,51.37 47.08,49.87 47.14,49.82 ; U31.L1 47.64,49.31 v1(47.47,49.49)
  BOTTOM w0.109: v2(47.47,50.5) v1(47.47,49.49)
BMC_TO_HOST_NMI_L: length 57.1
  TOP w0.109: R437.2 R358.2 v3(45.43,54.25) ; J10.B19 35.35,8.81 35.72,9.19 35.72,13.05 v3(33.62,15.15)
  T05 w0.097: v3(45.43,54.25) 45.35,54.25 38.67,47.57 38.67,46.77 36.02,44.13 36.02,42.71 34.8,41.48 34.8,38.5 34.48,38.18 34.48,16 v3(33.62,15.15)
  BOTTOM w0.109: v3(45.43,54.25) 45.12,53.95 v2(44.54,53.95)
BMC_TO_HOST_NMI_L_R: length 5.9
  TOP w0.089: v1(46.55,49.51) 46.36,49.7 46.36,49.82
  TOP w0.109: v1(46.55,49.51) 46.55,48.88 U31.M1 ; 46.36,49.82 46.36,50.16 44.96,51.56 44.96,52.09 44.68,52.36 R358.1
  BOTTOM w0.109: v2(46.93,48.5) 46.55,48.88 v1(46.55,49.51)
BUILD_ID0: length 8.3
  TOP w0.109: U31.E4 v1(54.13,45.3)
  BOTTOM w0.109: v1(54.13,45.3) v2(55.35,45.3) 55.57,45.3 56.13,45.86 57.31,45.86 57.6,46.15 59.38,46.15 59.54,45.99 R423.1 R424.1
BUILD_ID1: length 5.8
  TOP w0.109: U31.E5 v1(54.13,44.3)
  BOTTOM w0.109: R425.1 R426.1 57.89,43.35 57.53,43.71 56.96,43.71 56.96,43.7 54.73,43.7 v1(54.13,44.3)
CLK_25M_CPLD: length 15
  TOP w0.109: U31.J12 v1(49.15,37.3) ; R363.2 36.47,39.78 37.19,39.78 37.45,39.53 v3(37.48,39.53)
  BOTTOM w0.109: v1(49.15,37.3) 48.7,37.3 48.45,37.54 43.81,37.54 42.41,38.94 42.41,38.97 42.06,39.31 40.64,39.31 40.42,39.53 v2(39.12,39.53) v3(37.48,39.53)
CLK_25M_CPLD_ST: length 3.4
  TOP w0.109: v3(33.18,40.5) Y4.3 35.09,39.22 R363.1
CLK_33M_BUF: length 38.7
  TOP w0.109: v3(96.39,20.83) 95.38,19.81 95.38,17.54 94.59,16.76 92.6,16.76 92.01,17.35 U9.1
  T03 w0.089: 105.55,26.4 105.77,26.62 108.14,26.62 108.45,26.3 ; 111.93,25.26 112.57,25.26 115.17,27.85 115.17,31.26 v1(114.88,31.55)
  T03 w0.097: 105.55,26.4 103.69,26.4 98.11,20.83 v3(96.39,20.83) ; 111.93,25.26 111.4,24.73 109.53,24.73 108.52,25.74 108.52,26.24 108.45,26.3
  BOTTOM w0.089: R139.2 116.63,30.21 v2(116.3,29.88)
  BOTTOM w0.102: R139.2 116.16,31 115.61,31.55 v1(114.88,31.55)
CLK_33M_BUF_ST: length 2.6
  TOP w0.152: U1.AA9 v1(117.34,31.85)
  BOTTOM w0.102: v2(115.67,32.57) 116.45,31.8 R139.1 117.28,31.8 v1(117.34,31.85)
CLK_33M_LPC: length 3.8
  TOP w0.152: U1.AC67 v1(118.82,58.44)
  BOTTOM w0.089: R149.1 118.51,58.12 v1(118.82,58.44) 118.72,58.44 117.73,59.42 117.73,60.33 R146.2
CLK_33M_LPC_EDGE: length 19.4
  TOP w0.109: R151.2 81.22,20.73 80.14,19.65 v3(80.14,18.3) 80.14,17.16 80.75,16.55 80.75,12.57 82.63,10.68 82.63,10.03 82.35,9.74 J10.B66
  BOTTOM w0.109: v2(79.5,17.54) 79.5,17.67 v3(80.14,18.3)
CLK_33M_LPC_EDGE_ST: length 3.1
  TOP w0.109: R151.1 84.81,21.23 v2(85.37,21.23) 86.38,20.22 U9.5
CLK_33M_LPC_HDR: length 89.2
  TOP w0.109: v3(37.56,18.66) J1.1
  T03 w0.097: v3(95.44,20.86) 94.2,19.62 84.97,19.62 84.61,19.97 84.61,20.28 84.09,20.8 77.83,20.8 76.6,19.57 50.16,19.57 48.94,20.8 48.28,20.8 47.55,21.53 38.96,21.53 37.56,20.13 37.56,18.84 37.56,18.84 v3(37.56,18.66)
  BOTTOM w0.089: R136.2 v2(109.52,28.46) 105.55,28.46
  BOTTOM w0.109: v3(95.44,20.86) 95.91,21.33 95.91,24.93 97.59,26.61 97.59,30.12 97.82,30.35 100.48,30.35 102.36,28.46 105.55,28.46
CLK_33M_LPC_HDR_ST: length 10.3
  TOP w0.089: U1.Y11 117.17,32.97 v1(116.86,32.65)
  BOTTOM w0.089: R136.1 112.92,28.46 v2(113.52,27.87) 114.02,27.37 114.73,27.37 117.16,29.8 117.16,31.07 117.73,31.64 117.73,32.02 117.09,32.65 v1(116.86,32.65)
CLK_33M_LPC_SL: length 55.8
  TOP w0.109: R152.2 82.73,18.16 82.33,18.56 81.28,18.56 v3(80.9,18.18) ; U31.J5 v1(49.15,45.28)
  T05 w0.097: v3(80.9,18.18) 80.9,18.53 80.2,19.24 69.6,19.24 68.24,20.59 60.72,20.59 52.37,28.94 52.37,34.22 50.26,36.33 50.26,44.17 v1(49.15,45.28)
  BOTTOM w0.109: v2(80.77,16.91) 80.77,18.05 v3(80.9,18.18)
CLK_33M_LPC_SL_ST: length 4.6
  TOP w0.109: U9.7 85.13,18.47 84.82,18.16 R152.1 84.27,17.86 84.07,17.67 82.8,17.67 v2(82.42,17.29)
CLK_33M_LPC_ST: length 60.5
  TOP w0.109: v3(91.53,24.22) v2(91.53,22.85) 91.53,22.33 91.06,21.86 91.06,20.04 91.05,20.03 91.05,19.5 91.06,19.49 91.06,19.23 91.17,19.12 U9.3
  T08 w0.089: v1(116.35,61.01) 116.75,61.01 117.73,60.02 117.73,59.35 115.06,56.68 111.22,56.68 109.17,54.62 109.17,47.91 105.98,44.71 105.55,44.71
  T08 w0.097: 105.55,44.71 101.1,44.71 100.25,43.86 100.25,40.65 95.36,35.76 95.36,29.97 91.53,26.14 v3(91.53,24.22)
  BOTTOM w0.089: v1(116.35,61.01) 116.35,60.91 R146.1
CLK_33M_PCICLKIN: length 50.4
  TOP w0.109: R153.2 83.58,15.86 84.05,15.39 84.79,15.39 85.12,15.71 85.12,16.63 85.83,17.34 87.78,17.34 88.65,18.2 88.65,27.77 v3(91.27,30.39)
  TOP w0.152: U1.AC7 v1(117.84,30.93)
  T05 w0.089: 115.87,30.19 116.62,30.93 v1(117.84,30.93) ; 105.55,28.79 107.11,28.79 107.66,29.34 109.62,29.34 109.86,29.1 114.79,29.1 115.74,30.05
  T05 w0.097: 115.87,30.19 115.74,30.05 ; 105.55,28.79 92.86,28.79 v3(91.27,30.39)
CLK_33M_PCICLKIN_BUF_ST: length 3.4
  TOP w0.109: v2(84.4,16.02) R153.1 84.66,17.14 85.34,17.82 U9.8
CLK_100M_PCIE0_SLOT_N: length 102.6
  TOP w0.135: v1(116.51,25.8) arc(116.68,26.06) 116.74,26.37 116.74,28.12 arc(116.79,28.37) 116.93,28.58 117.09,28.74 arc(117.13,28.84) 117.09,28.94 117.08,28.95 arc(117.03,28.99) 116.97,29.02 arc(116.78,29.04) U1.W2
  T03 w0.135: v3(30.81,11.32) 30.81,11.84 31.34,12.38 34.66,12.38 39.61,17.33 39.93,17.66 77.92,17.66 78.9,16.68 84.18,16.68 85.78,18.29 97.71,18.29 102.28,22.85 107.01,22.85 107.53,23.37 112.36,23.37 113.62,24.63 115.8,24.63 116.32,25.15 116.32,25.62 v1(116.51,25.8)
  BOTTOM w0.135: J10.A14 30.35,8.43 30.01,8.76 30.01,9.15 30.41,9.55 30.41,10.93 v3(30.81,11.32)
CLK_100M_PCIE0_SLOT_P: length 103.4
  TOP w0.102: U1.W4 116.6,29.76 arc(116.57,29.54) 116.48,29.34 arc(116.43,29.28) 116.38,29.22 arc(116.28,29.07) 116.24,28.89
  TOP w0.135: v1(115.82,25.8) 116.17,26.15 arc(116.35,26.41) 116.41,26.73 116.41,28.27 arc(116.39,28.37) 116.33,28.46 arc(116.26,28.56) 116.24,28.69 116.24,28.89
  T03 w0.135: v3(29.78,11.32) 31.2,12.73 34.51,12.73 39.25,17.48 39.79,18.01 78.06,18.01 79.04,17.03 84.03,17.03 85.64,18.64 97.56,18.64 102.13,23.2 106.87,23.2 107.39,23.72 112.22,23.72 113.48,24.98 115.66,24.98 115.97,25.3 115.97,25.64 v1(115.82,25.8)
  BOTTOM w0.135: v3(29.78,11.32) 30.08,11.02 30.08,9.69 29.68,9.29 29.68,8.82 29.35,8.49 J10.A13
CLK_100M_XDP_PE_N: length 147.7
  TOP w0.135: v3(27.53,59.34) 27.15,58.96 10.64,58.96 8.86,60.74 8.86,70.01 7.87,71 7.87,71.95 7.54,72.28 7.27,72.28 7.18,72.36 J12.42 ; v1(110.51,26.96) 110.75,26.71 111.36,26.71 111.58,26.94 111.58,27.82 111.5,27.9 111.5,28.91 U1.H2
  T03 w0.135: v3(27.53,59.34) 28.15,58.72 29.92,58.72 35.59,53.04 38.06,53.04 38.2,53.19 39.01,53.19 39.16,53.04 41.67,53.04 41.97,53.33 44.92,53.33 45.01,53.25 51.04,53.25 51.35,52.94 52.51,52.94 52.65,53.08 56.22,53.08 60.48,48.82 60.48,45.17 63.56,42.09 65.88,42.09 66.17,42.09 67.51,40.75 76.59,40.75 79.43,37.9 79.43,31.2 82.49,28.14 82.49,24.46 83.79,23.16 85.7,23.16 86.24,22.62 97.5,22.62 102.83,27.95 108.62,27.95 109.74,26.83 110.38,26.83 v1(110.51,26.96)
  BOTTOM w0.109: 27.71,60.33 v2(27.71,60.5)
  BOTTOM w0.135: v3(27.53,59.34) 27.71,59.53 27.71,60.33
CLK_100M_XDP_PE_P: length 149.1
  TOP w0.135: J12.40 7.18,71.86 7.27,71.95 7.4,71.95 7.54,71.81 7.54,70.86 8.53,69.87 8.53,60.6 10.5,58.63 27.24,58.63 27.53,58.34 v3(27.53,58.17) ; v1(110.53,26.16) 110.75,26.38 111.49,26.38 111.91,26.8 111.91,27.96 111.84,28.04 111.84,28.38 111.84,28.39 111.84,29.12 111.73,29.23 111.73,29.86 U1.H4
  T03 w0.135: v3(27.53,58.17) 27.72,58.37 29.77,58.37 35.45,52.69 38.2,52.69 38.35,52.84 38.87,52.84 39.01,52.69 41.82,52.69 42.11,52.98 44.78,52.98 44.86,52.9 50.89,52.9 51.2,52.59 52.65,52.59 52.79,52.73 56.07,52.73 60.13,48.67 60.13,45.03 63.42,41.74 66.02,41.74 67.37,40.39 76.44,40.39 79.08,37.76 79.08,31.05 82.14,28 82.14,24.32 83.65,22.81 85.55,22.81 86.09,22.27 97.64,22.27 102.97,27.6 108.48,27.6 109.6,26.48 110.2,26.48 v1(110.53,26.16)
  BOTTOM w0.135: v2(27.82,57.26) 27.82,57.89 v3(27.53,58.17)
CLK_DDR4_A_CK0_N: length 59.7
  TOP w0.102: U1.CJ47 v1(139.13,49.56)
  T03 w0.089: 141.25,50.25 141.2,50.21 141.05,50.21 140.82,50.08 arc(140.62,50.02) 140.42,50.07 140.42,50.08 arc(140.09,50.16) 139.78,50.05 139.21,49.64 v1(139.13,49.56)
  T03 w0.102: 183.15,52.14 183.16,52.15 183.16,53.08
  T03 w0.152: 141.34,50.25 143.96,52.87 157.93,52.87 159.49,54.43 175.19,54.43 175.66,53.96 175.66,52.66 175.77,52.55 176.25,52.55 176.41,52.7 176.41,54.18 176.66,54.43 177.36,54.43 177.7,54.1 177.7,53.6 177.8,53.49 178.21,53.49 178.32,53.61 178.32,54.13 178.62,54.43 179.28,54.43 179.61,54.1 179.61,53.72 179.7,53.62 180.12,53.62 180.22,53.72 180.22,54.14 180.5,54.43 181.06,54.43 181.38,54.1 181.38,53.85 181.61,53.62 182.75,53.62 183.16,53.21 183.16,53.08 ; v1(183.03,52.02) 183.15,52.14
  T03 w0.159: 141.34,50.25 141.25,50.25
  BOTTOM w0.089: v1(183.03,52.02) 183.03,52.14 182.7,52.47 181.2,52.47 181.04,52.62 180.54,52.62
  BOTTOM w0.109: 180.54,52.62 179.5,51.58 179.17,51.58 179.09,51.66 CN1.139
CLK_DDR4_A_CK0_P: length 59.7
  TOP w0.102: U1.CL47 v1(140.12,49.56)
  T03 w0.089: v1(140.12,49.56) 139.98,49.47 arc(139.71,49.52) 139.75,49.8 139.89,49.89 arc(140.1,49.96) 140.32,49.91 140.33,49.91 arc(140.62,49.83) 140.91,49.91 141.1,50.02 141.21,50.02 141.25,49.98
  T03 w0.102: 182.9,53.1 182.9,52.59 182.52,52.21 182.52,51.7 182.39,51.58 181.93,51.58 181.83,51.67 181.83,51.94 v1(181.91,52.02)
  T03 w0.152: 182.9,53.1 182.64,53.36 181.5,53.36 181.12,53.74 181.12,53.99 180.95,54.16 180.61,54.16 180.48,54.03 180.48,53.61 180.23,53.36 179.59,53.36 179.34,53.61 179.34,53.99 179.17,54.16 178.73,54.16 178.59,54.02 178.59,53.5 178.32,53.23 177.69,53.23 177.43,53.49 177.43,53.99 177.25,54.17 176.77,54.17 176.67,54.07 176.67,52.59 176.36,52.28 175.66,52.28 175.39,52.55 175.39,53.85 175.08,54.16 159.6,54.16 158.04,52.6 144.08,52.6 141.88,50.41
  T03 w0.159: 141.88,50.41 141.88,50.23 141.76,50.11 141.58,50.11 141.45,49.98 141.25,49.98
  BOTTOM w0.089: 180.1,51.87 180.63,52.4 180.95,52.4 181.12,52.24 181.69,52.24 v1(181.91,52.02)
  BOTTOM w0.109: 180.1,51.87 179.39,51.16 CN1.137
CLK_DDR4_A_CK2_N: length 57.3
  TOP w0.102: U1.CG47 v1(138.14,49.56)
  T03 w0.089: 141.37,48.48 141.33,48.44 141.11,48.44 arc(140.96,48.42) 140.82,48.36 arc(140.62,48.31) 140.42,48.35 140.42,48.36 arc(140.12,48.44) 139.83,48.36 arc(139.63,48.31) 139.43,48.36 arc(139.13,48.44) 138.83,48.36 arc(138.44,48.36) 138.23,48.7 138.23,48.73 arc(138.17,48.98) 137.99,49.18 137.97,49.27 v1(138.14,49.56)
  T03 w0.152: 141.61,49.18 144.49,52.06 144.6,52.06 144.6,52.05 158.76,52.05 160.32,53.62 174.37,53.62 174.77,53.22 174.77,51.07 175.02,50.82 175.41,50.82 175.66,51.07 177.26,51.07 177.44,51.24 177.44,52.2 177.63,52.39 177.72,52.48 178.56,52.48 178.84,52.2 178.84,51.84 179.08,51.6 180.38,51.6 v1(180.79,52.02)
  T03 w0.159: 141.61,49.18 141.61,48.99 141.69,48.92 141.69,48.64 141.53,48.48 141.37,48.48
  BOTTOM w0.089: 184.5,51.82 184.28,51.61 183.99,51.61 183.84,51.75 183.34,51.75 183.18,51.6 182.89,51.6 182.69,51.8 182.69,51.8 182.69,51.8 182.24,51.8 182.2,51.76 182.2,51.76 182.07,51.63 181.75,51.63 181.62,51.75 181.05,51.75 v1(180.79,52.02)
  BOTTOM w0.109: 184.5,51.82 185.16,51.82 185.24,51.91 CN1.140
CLK_DDR4_A_CK2_P: length 57.3
  TOP w0.102: U1.CF45 v1(137.64,48.71)
  T03 w0.089: 141.37,48.21 141.33,48.25 141.11,48.25 arc(141.01,48.23) 140.91,48.19 arc(140.62,48.12) 140.33,48.19 140.32,48.19 arc(140.12,48.25) 139.92,48.19 arc(139.63,48.12) 139.33,48.19 arc(139.13,48.25) 138.93,48.19 arc(138.35,48.19) 138.04,48.68 138.04,48.72 arc(138,48.89) 137.89,49.02 137.81,49 v1(137.64,48.71)
  T03 w0.152: 141.96,49.14 144.6,51.79 158.87,51.79 160.43,53.35 174.26,53.35 174.5,53.11 174.5,50.96 174.91,50.55 175.52,50.55 175.77,50.8 177.37,50.8 177.7,51.13 177.7,52.09 177.83,52.21 178.45,52.21 178.58,52.09 178.58,51.73 178.97,51.33 180.08,51.33 v1(180.27,51.15)
  T03 w0.159: 141.37,48.21 141.64,48.21 141.96,48.53 141.96,49.14
  BOTTOM w0.089: 184.59,51.61 184.37,51.39 183.9,51.39 183.75,51.54 183.43,51.54 183.27,51.38 182.8,51.38 182.6,51.58 182.33,51.58 182.16,51.41 181.66,51.41 181.53,51.54 180.66,51.54 v1(180.27,51.15)
  BOTTOM w0.109: CN1.138 185.33,51.41 185.14,51.61 184.59,51.61
CLK_DDR4_B_CK0_N: length 37.7
  TOP w0.089: v1(145.72,54.73) 145.72,54.61 145.42,54.31 144.47,54.31 144.29,54.49 143.9,54.49 143.73,54.33 143.18,54.33 143.13,54.37 142.9,54.37 142.84,54.31 U1.CT58
  TOP w0.109: CN2.139 174.42,51.72 173.65,51.72 173.47,51.9 173.35,52.01 172.98,52.01 172.83,51.86 172.56,51.86 v1(172.41,52.02)
  T05 w0.089: v1(172.41,52.02) 172.59,52.02 arc(172.77,51.87) 172.67,51.67 172.59,51.63 arc(172.45,51.6) 172.31,51.61 arc(172.24,51.63) 172.18,51.66 172.02,51.77 arc(171.97,51.89) 171.95,52.02 171.95,52.21 171.39,52.77 171.39,52.99 171.44,53.04
  T05 w0.152: 171.44,53.04 171.44,53.42 171.03,53.83 171.03,53.83 171.01,53.84 169.52,53.84 169.17,53.49 168.93,53.49 168.56,53.85 168.12,53.85 167.71,53.43 167.71,53.03 167.55,52.88 167.16,52.88 166.26,53.77 153.74,53.77 152.01,55.51 151.85,55.67 146.09,55.67 145.79,55.37 145.79,55.07 145.72,54.99 v1(145.72,54.73)
CLK_DDR4_B_CK0_P: length 37.6
  TOP w0.089: v1(146.43,54.73) 146.63,54.52 146.63,54.35 146.5,54.22 146.33,54.22 146.22,54.33 145.7,54.33 145.5,54.12 144.39,54.12 144.32,54.19 U1.CV58
  TOP w0.109: v1(172.97,51.15) 172.97,51.7 173.07,51.8 173.26,51.8 173.5,51.57 173.5,51.31 173.6,51.21 174.28,51.21 174.42,51.22 CN2.137
  T05 w0.089: 171.17,53.04 171.2,53 171.2,52.69 171.76,52.13 171.76,52.02 arc(171.79,51.81) 171.88,51.63 172.08,51.5 arc(172.17,51.46) 172.26,51.43 172.69,51.31 arc(172.84,51.25) v1(172.97,51.15)
  T05 w0.152: 171.17,53.04 171.17,53.31 170.9,53.58 169.63,53.58 169.28,53.22 168.81,53.22 168.45,53.58 168.23,53.58 167.97,53.32 167.97,52.92 167.66,52.61 167.05,52.61 166.15,53.51 153.63,53.51 152.55,54.6 152.39,54.6 152.26,54.72 152.26,54.88 151.82,55.32 151.74,55.4 151.17,55.4 151.07,55.3 150.89,55.3 150.79,55.4 150.61,55.4 150.51,55.3 150.33,55.3 150.23,55.4 150.05,55.4 149.95,55.3 149.77,55.3 149.67,55.4 149.49,55.4 149.39,55.29 149.21,55.29 149.11,55.39 148.93,55.39 148.83,55.29 148.65,55.29 148.55,55.39 148.37,55.39 148.27,55.29 148.09,55.29 147.99,55.39 147.81,55.39 147.71,55.29 147.53,55.29 147.42,55.4 147.25,55.4 147.14,55.3 146.97,55.3 146.86,55.4 146.21,55.4 146.07,55.26 146.07,55.09 v1(146.43,54.73)
CLK_DDR4_B_CK2_N: length 35.9
  TOP w0.089: U1.CR57 142.4,53.75 142.78,53.75 143.19,53.35 143.5,53.35 143.65,53.5 144.61,53.5 144.85,53.74 148.23,53.74 148.48,53.99 148.48,54.65 v1(148.56,54.73)
  TOP w0.109: v1(167.94,52.02) 168.11,51.84 168.11,51.76 167.95,51.59 167.66,51.59 167.53,51.72 167.53,51.89 167.4,52.02 166.55,52.02 166.49,51.97 CN2.140
  T05 w0.089: v1(148.56,54.73) 148.38,54.73 148.21,54.56 148.21,54.16 148.29,54.08 148.4,54.08 ; 150.86,54.08 151.04,54.08 151.15,54.18 151.3,54.18 151.4,54.08 151.55,54.08 151.65,54.18 151.81,54.18 151.91,54.08 152.13,54.08 ; 167.55,51.64 167.64,51.64 167.64,51.64 167.69,51.6 167.94,51.6 arc(168.06,51.61) 168.17,51.66 168.3,51.75 arc(168.39,51.86) 168.4,52.01 arc(168.31,52.14) 168.17,52.19 168.11,52.19 v1(167.94,52.02)
  T05 w0.097: 148.4,54.08 148.7,54.08 148.8,54.18 148.93,54.18 149.03,54.08 149.16,54.08 149.26,54.18 149.39,54.18 149.49,54.08 149.61,54.08 149.72,54.18 149.84,54.18 149.94,54.08 150.07,54.08 150.17,54.18 150.3,54.18 150.4,54.08 150.53,54.08 150.63,54.18 150.76,54.18 150.86,54.08
  T05 w0.152: 167.55,51.64 166.22,51.64 166.07,51.79 166.07,52.54 165.69,52.92 165.11,52.92 164.79,52.6 164.79,51.95 164.69,51.84 164.33,51.84 164.09,52.08 164.09,52.59 163.78,52.91 163.21,52.91 162.89,52.59 162.89,52.42 162.77,52.29 162.32,52.29 162.2,52.42 162.2,52.6 161.88,52.91 153.29,52.91 152.13,54.08
CLK_DDR4_B_CK2_P: length 36
  TOP w0.089: U1.CU57 143.11,53.7 143.02,53.78 143.02,53.89 143.23,54.1 143.43,54.1 143.83,53.69 144.53,53.69 144.77,53.93 145.83,53.93 145.93,54.03 146.06,54.03 146.16,53.93 146.74,53.93 146.85,54.03 146.97,54.03 147.07,53.93 147.2,53.93 147.3,54.03 147.43,54.03 147.53,53.93 147.66,53.93 147.76,54.03 147.89,54.03 147.99,53.93 148.15,53.93 148.29,54.07 148.29,54.28 v1(147.85,54.73)
  TOP w0.109: CN2.138 166.49,51.47 167.47,51.47 167.55,51.38 168.04,51.38 168.67,52.02 v1(169.06,52.02)
  T05 w0.089: 167.65,51.37 167.69,51.41 167.8,51.41 167.94,51.41 arc(168.11,51.43) 168.26,51.49 168.57,51.69 arc(168.81,51.85) v1(169.06,52.02) ; 148.01,54.08 148.01,54.07 148.24,53.84
  T05 w0.097: v1(147.85,54.73) 148.01,54.56 148.01,54.08
  T05 w0.152: 167.65,51.37 166.11,51.37 165.8,51.68 165.8,52.43 165.58,52.65 165.22,52.65 165.06,52.49 165.06,51.83 164.8,51.58 164.22,51.58 163.83,51.97 163.83,52.48 163.67,52.64 163.32,52.64 163.16,52.48 163.16,52.31 162.88,52.02 162.21,52.02 161.93,52.31 161.93,52.49 161.77,52.65 153.18,52.65 151.99,53.84 148.3,53.84 148.3,53.84 148.24,53.84
CLK_M2_SUSCLK: length 175.1
  TOP w0.109: U31.H5 v1(51.13,45.28)
  T05 w0.097: v3(131.03,11.21) 130.22,12.02 130.22,12.37 129.09,13.5 127.77,13.5 124.27,17 120.83,17 120.62,17.22 118.21,17.22 117.73,16.73 116.49,16.73 115.96,16.2 109.88,16.2 108.41,17.67 99.3,17.67 96.18,14.54 91.93,14.54 87.84,18.64 85.05,18.64 82.82,20.87 70.71,20.87 68.5,23.08 64.54,23.08 61.76,25.87 61.76,33.71 59.04,36.43 59.04,37.98 57.22,39.8 56.04,39.8 55.04,40.8 55.04,45.23 54.38,45.89 51.74,45.89 v1(51.13,45.28) 51.13,49.15 52.43,50.45 54.37,50.45 54.6,50.68 57.58,50.68 60.98,47.28 61.92,47.28 62.87,48.23 62.87,50.18 62.43,50.61 62.43,57.62 58.11,61.95 58.11,62.55 57.75,62.91 57.25,62.91 56.89,62.55 56.89,62.54 v3(56.74,62.39)
  BOTTOM w0.109: R52.2 131.16,12.96 131.8,12.32 131.8,11.98 v3(131.03,11.21) ; v3(56.74,62.39) 55.48,63.65 51.32,63.65 50.54,63.65 48.26,65.93 48.26,69.15 49.36,70.25 49.36,70.27 50.78,71.69 50.78,73.29 52.46,74.97 52.46,77.25 57.15,81.94 J9.68
CLK_M2_SUSCLK_ST: length 26.2
  TOP w0.152: U1.BD11 128.18,32.94 v1(127.73,32.68)
  T08 w0.089: 128.79,21.61 128.08,22.32 128.08,30.98 127.85,31.21 127.85,32.56 v1(127.73,32.68)
  T08 w0.097: v3(129.4,19.97) 129.35,20.02 129.35,20.56 128.79,21.11 128.79,21.61
  BOTTOM w0.102: v1(127.73,32.68) 127.73,31.71 128.11,31.33 v2(128.11,29.8)
  BOTTOM w0.109: v3(129.4,19.97) 128.75,19.32 128.75,18.35 R250.2 129.99,17.58 130.27,17.31 130.27,14.54 R255.1 R52.1
CLK_SVID_CPU: length 331.2
  TOP w0.109: v3(72.74,73.55) 72.99,73.8 PR171.1 ; PR197.1 v3(70.23,46.78) PR108.1
  T03 w0.097: v3(72.74,73.55) 72.03,72.83 72.03,69.85 75.04,66.84 80.3,66.84 80.3,66.83 80.67,66.83 81.16,67.33 81.84,67.33 82.11,67.59 82.68,67.59 83.45,68.36 85.18,68.36 86.31,69.48 96.02,69.48 99.73,73.19 102.63,73.19 105.72,70.1 106.26,69.56 117.36,69.56 118.69,68.23 119.41,68.23 v1(119.65,68.47)
  T05 w0.097: v3(72.74,73.55) 71.91,72.72 71.91,72.21 71.87,72.17 71.87,71.41 71.91,71.37 71.91,71.36 72.13,71.14 72.13,69.66 72.13,68.9 72.41,68.62 74.19,66.84 74.25,66.84 74.31,66.78 80.35,66.78 80.41,66.84 80.47,66.84 80.81,67.19 85.19,67.19 88.68,63.69 88.68,46.84 87.44,45.6 80.89,45.6 78.78,47.71 71.53,47.71 71.49,47.67 71.13,47.67 v3(70.23,46.78) 70.23,46.18 70.43,45.99 70.43,41.11 69.19,39.87 69.19,33.89 70.78,32.3 71.82,32.3 72.69,31.43 74.53,29.59 74.53,27.32 74.52,27.3 74.52,24.1 75.95,22.67 83.29,22.67 85.1,20.87 85.49,20.87 85.49,20.87 87.26,20.87 88.29,19.84 88.3,19.84 92.42,15.72 95.26,15.72 v3(95.72,16.19)
  T10 w0.097: v3(95.72,16.19) 97.77,14.14 123.13,14.14 125.01,12.26 125.01,5.23 127.05,3.19 141.2,3.19 141.95,2.44 192.75,2.44 200.03,9.71 200.03,11.01 198.39,12.64 198.39,17.39 198.83,17.83 198.83,24.69 198.86,24.73 198.86,24.75 202.36,28.25 v3(202.36,29.76)
  BOTTOM w0.089: v1(119.65,68.47) 119.9,68.47 120.92,67.45
  BOTTOM w0.102: R107.2 121.05,65.51 121.05,67.32 120.92,67.45
  BOTTOM w0.109: R465.2 77.44,41.95 75.95,43.45 73.56,43.45 v3(70.23,46.78) ; v2(120.86,69.38) 120.48,69.38 119.67,68.57 119.67,68.49 v1(119.65,68.47) ; PR180.1 PR111.1 202.29,29.83 v3(202.36,29.76) ; v3(72.74,73.55) 73.37,74.18 PR174.1
CLK_XDP_CPU_TCK: length 209.4
  TOP w0.089: U1.T76 114.98,63.24 114.98,63.98 114.75,64.21 114.75,64.87 v1(114.65,64.97)
  TOP w0.109: R411.1 24.54,65.65 29.45,60.74 29.62,60.74 v3(29.69,60.67) ; v3(134.11,11.07) 133.64,11.53 133.64,12.53 R464.2
  T03 w0.097: v3(98.32,29.71) 98.32,30.22 96.93,31.61 96.93,36.6 90.5,43.03 77.41,43.03 76.54,43.91 68.62,43.91 68.35,44.18 64.79,44.18 63.44,45.52 63.44,57.79 65.1,59.44 v3(65.1,60.58)
  T08 w0.089: v1(114.65,64.97) 114.28,64.6 106.75,64.6 105.55,63.4
  T08 w0.097: 105.55,63.4 104.03,61.88 104.03,61.1 102.72,59.78 99.46,59.78 98.16,61.09 94.27,61.09 93.9,60.72 65.24,60.72 v3(65.1,60.58) 55.99,60.58 55.81,60.76 52.32,60.76 52.04,60.48 44.62,60.48 44.3,60.8 29.82,60.8 v3(29.69,60.67)
  BOTTOM w0.089: v1(114.65,64.97) 114.65,63.95 R179.1
  BOTTOM w0.109: v3(98.32,29.71) 98.32,29.07 107.95,19.45 107.95,18.12 111.44,14.63 120.66,14.63 121.16,15.13 121.16,15.38 121.61,15.83 122.18,15.83 122.43,15.58 122.43,15.56 127.48,10.51 133.55,10.51 v3(134.11,11.07)
CMOS_CLR: length 19.6
  TOP w0.089: U31.C13 55.08,37.35 54.36,37.35 54.1,37.1 54.1,35.45 53.98,35.32 53.34,35.32 53.09,35.07 53.09,32.91 53.2,32.8
  TOP w0.109: 53.2,32.8 53.47,32.53 53.98,32.53 54.25,32.25 54.25,31.03 53.52,30.29 53.52,28.41 52.98,27.88 v3(52.98,26.94)
  BOTTOM w0.109: 54.59,24.65 Q6.1 ; 54.59,24.65 R460.2 ; 54.59,24.65 54.28,24.65 v2(53.06,25.87) 53.06,26.86 v3(52.98,26.94)
CORE_VRHOT_L: length 100.2
  TOP w0.109: U33.1 54.44,24.94 54.85,24.53 56.24,24.53 57.15,25.44 57.15,27.37 58.93,29.15 58.93,33.29 60.58,34.94 65,34.94 66.65,33.29 v3(68.31,33.29)
  TOP w0.254: PU17.30 76.02,75.08 75.67,74.74 75.27,74.74 v3(75.26,74.73)
  T05 w0.097: v3(68.31,33.29) 68.75,33.72 68.75,40.16 69.95,41.36 69.95,45.79 69.65,46.09 69.65,46.87 70.93,48.15 75.25,48.15 75.51,48.41 79.11,48.41 79.42,48.1 81.74,48.1 87.76,54.12 87.76,60.77 83.69,64.84 75.58,64.84 71.69,68.72 71.69,70.96 71.43,71.23 71.43,72.92 73.25,74.73 v3(75.26,74.73)
  BOTTOM w0.109: v2(77.64,77.48) 77.64,77.05 76.91,76.32 PR209.2
  BOTTOM w0.152: v3(75.26,74.73) 75.26,74.79 75.1,74.95 75.1,75.6 75.28,75.77 75.28,75.77 75.82,76.32 PR209.2
CPLD_BDXDE_THERMTRIP_L: length 140.1
  TOP w0.109: U31.A5 v1(58.13,45.28) ; R219.1 65.91,12.74 65.58,12.41 65.58,11.56 v3(66.04,11.1)
  T05 w0.097: v3(66.04,11.1) 66.63,10.5 67.75,10.5 68.41,11.17 68.41,13.04 66.12,15.34 44.91,15.34 42.19,18.06 42.19,20.16 39.59,22.75 39.59,41.52 41.42,43.35 42.24,43.35 42.72,42.87 48.32,42.87 48.56,43.11 48.56,45.43 49.5,46.36 49.5,49.01 52.65,52.17 55.14,52.17 55.67,51.64 59.65,51.64 v3(60.97,50.32)
  T08 w0.097: v3(60.97,50.32) 60.07,49.42 60.07,47.08 58.28,45.28 v1(58.13,45.28) 58.09,45.28 57.63,45.75 55.93,45.75 54.96,46.72 53.11,46.72 48.94,50.89 48.94,54.2 48,55.14 46.28,55.14 45.34,56.07 45.34,57.35 44.3,58.39 41.57,58.39 40.48,59.48 v3(40.48,59.65)
  BOTTOM w0.109: v3(60.97,50.32) 60.96,50.31 v2(59.78,50.31) ; U11.5 31.79,67.78 32.66,66.9 32.66,63.82 35.47,61.02 v2(38.92,61.02) 39.11,61.02 v3(40.48,59.65)
CPLD_CATERR_L_LATCH: length 17.9
  TOP w0.109: v1(54.7,49.94) 54.7,48.86 U31.D1
  T08 w0.097: v3(49.62,58.28) 52.32,58.28 52.72,57.87 52.72,57.26 54.11,55.88 54.39,55.6 54.39,50.67 54.7,50.35 v1(54.7,49.94)
  BOTTOM w0.109: U30.6 50.87,58.83 50.18,58.83 v3(49.62,58.28) ; v1(54.7,49.94) 54.7,50.72 53.98,51.45 v2(53.98,52.72)
CPLD_CLEAR_LATCH: length 16.9
  TOP w0.109: U31.F1 v1(52.64,49.82)
  T08 w0.097: v1(52.64,49.82) 52.64,49.85 51.5,50.99 51.5,52.04 51.26,52.29 51.26,54.58 49.77,56.07 46.8,56.07 v3(46.7,56.17)
  BOTTOM w0.109: v2(42.45,54.96) 42.52,55.03 U30.13 46.47,55.03 46.7,55.26 v3(46.7,56.17)
CPLD_CPU2PCH_THROT: length 11.1
  TOP w0.089: 44.54,32.8 45.1,33.36 v1(45.1,34.25) 45.1,34.25 U31.N15
  TOP w0.109: 44.54,32.8 43.64,31.89 41.61,31.89 39.98,30.27 R206.2
CPLD_CPU_DIMM_EVENT_CO_L: length 175.3
  TOP w0.109: U31.B4 v1(57.13,46.28)
  T05 w0.097: v1(57.13,46.28) 58.97,46.28 63.5,41.76 63.5,40.77 68.4,35.87 68.4,34.51 67.79,33.9 67.79,33.2 68.15,32.85 68.49,32.85 70.1,31.23 72.21,31.23 74.06,29.39 74.06,27.52 74.03,27.49 74.03,24.01 75.8,22.23 83.11,22.23 85.12,20.22 v3(85.22,20.22)
  T08 w0.097: v3(195.1,9.82) 194.59,9.82 194.18,9.41 189.36,9.41 188.59,8.65 187.07,8.65 186.56,9.16 185.17,9.16 183.77,7.76 178.08,7.76 177.39,7.08 171.6,7.08 170.71,6.18 166.27,6.18 165.28,5.19 155.41,5.19 154.5,4.29 141.72,4.29 140.03,5.97 129.82,5.97 128.71,7.08 128.71,7.5 128.41,7.8 128.41,12.4 127.33,13.49 126.41,13.49 123.31,16.58 120.55,16.58 118.71,18.42 118.71,18.5 116.96,20.25 116.88,20.25 116.15,20.98 106.35,20.98 106.18,21.15 105.23,21.15 104.65,20.56 98.62,20.56 97.68,19.62 85.82,19.62 v3(85.22,20.22)
  BOTTOM w0.109: v3(195.1,9.82) 197.61,12.34 197.61,13.76 197.72,13.87 U32.4
CPLD_DEBUG_MODE: length 7.4
  TOP w0.109: v3(37.72,51.11) R362.1 R360.2 41.14,49.29 U31.T2
