# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_B_DQ30: length 40
  TOP w0.089: v1(147.02,38.65) 146.59,39.09 145.54,39.09 144.5,40.12 144.33,40.12 144.11,40.33 U1.CV27
  TOP w0.109: CN2.79 174.42,36.71 174.28,36.71 173.57,36.71 172.83,35.97 170.2,35.97 170.02,36.15 170.02,36.34 170.15,36.48 v1(170.46,36.48)
  T05 w0.097: v1(147.02,38.65) 146.7,38.32 146.58,38.32 146.49,38.23 146.49,38.11 146.82,37.78 153.16,37.78 155.87,35.07 156.33,35.07 156.47,35.21 156.47,35.48 156.61,35.62 156.81,35.62 156.95,35.48 156.95,35.21 157.09,35.07 157.29,35.07 157.43,35.21 157.43,35.48 157.57,35.62 157.77,35.62 157.91,35.48 157.91,35.21 158.06,35.07 158.26,35.07 158.4,35.21 158.4,35.48 158.54,35.62 158.74,35.62 158.88,35.48 158.88,35.21 159.02,35.07 159.22,35.07 159.36,35.21 159.36,35.48 159.5,35.62 159.7,35.62 159.84,35.48 159.84,35.21 159.99,35.07 160.19,35.07 160.33,35.21 160.33,35.48 160.46,35.61 160.68,35.61 160.81,35.48 160.81,35.21 160.95,35.07 165.8,35.07 167.36,36.62 168.91,36.62 169.17,36.88 170.06,36.88 v1(170.46,36.48)
DDR4_B_DQ31: length 40.5
  TOP w0.089: U1.CT27 143.03,40.33 143.07,40.38 143.56,40.38 143.81,40.63 144.27,40.63 145.51,39.39 147.05,39.39 v1(147.79,38.65)
  TOP w0.109: v1(171.46,36.48) 171.05,36.48 170.59,36.95 169.33,36.95 168.99,36.6 167.95,36.6 167.58,36.96 166.49,36.96 CN2.80
  T05 w0.097: v1(147.79,38.65) 148.2,38.24 153.3,38.24 155.06,36.49 155.66,36.49 155.8,36.63 155.8,37.18 155.94,37.33 156.14,37.33 156.28,37.18 156.28,36.63 156.42,36.49 156.62,36.49 156.76,36.63 156.76,37.18 156.9,37.33 157.1,37.33 157.24,37.18 157.24,36.63 157.39,36.49 157.59,36.49 157.73,36.63 157.73,37.18 157.87,37.33 158.07,37.33 158.21,37.18 158.21,36.63 158.35,36.49 166.37,36.49 166.93,37.05 168.73,37.05 168.77,37.09 170.97,37.09 171.46,36.6 v1(171.46,36.48)
DDR4_B_DQ32: length 41.7
  TOP w0.089: U1.CT73 143.43,61.41 143.83,61 144.18,61 144.57,61.39 146.89,61.39 v1(147.3,61.79)
  TOP w0.109: v1(169.46,62.4) 169.86,62.4 170,62.55 170,62.84 169.84,63 169.06,63 168.9,62.84 168.9,62.27 168.59,61.96 168.12,61.96 167.61,62.47 CN2.174
  T05 w0.097: v1(169.46,62.4) 169.22,62.4 168.78,62.83 168.12,62.83 167.92,62.63 167.56,62.63 167.43,62.76 167.43,63.32 167.27,63.48 167.05,63.48 166.87,63.3 166.87,62.75 166.75,62.63 166.39,62.63 166.26,62.75 166.26,63.93 166.09,64.1 165.78,64.1 165.63,63.95 165.63,63.42 165.5,63.29 165.15,63.29 165.02,63.43 161.75,63.43 161.56,63.62 161.56,63.96 161.39,64.13 161.16,64.13 160.99,63.96 160.99,63.56 160.86,63.43 160.63,63.43 160.48,63.58 160.48,64 160.35,64.13 160.14,64.13 159.97,63.96 159.97,63.58 159.85,63.45 159.66,63.45 159.53,63.58 159.53,64 159.4,64.13 159.19,64.13 159.02,63.96 159.02,63.58 158.89,63.45 158.7,63.45 158.58,63.58 158.58,63.94 158.39,64.13 153.73,64.13 153.03,63.43 150.41,63.43 149.98,63.01 149.98,62.71 149.7,62.42 147.03,62.42 146.93,62.33 146.93,62.16 v1(147.3,61.79)
DDR4_B_DQ33: length 41.8
  TOP w0.089: v1(146.59,61.79) 146.16,62.22 144.64,62.22 144.26,61.85 143.72,61.85 U1.CU74
  TOP w0.109: v1(170.46,62.4) 170.46,62.7 170.59,62.83 170.89,62.83 171.03,62.69 171.03,62.17 171.37,61.83 173.15,61.83 173.24,61.92 173.24,62.09 173.35,62.21 174.28,62.21 174.42,62.22 CN2.173
  T05 w0.097: v1(146.59,61.79) 146.13,61.34 145.54,61.34 145.23,61.64 145.23,62.68 145.39,62.83 149.39,62.83 149.55,62.99 149.55,63.44 149.96,63.86 152.82,63.86 153.52,64.56 161.94,64.56 162.07,64.43 162.07,63.96 162.17,63.86 162.45,63.86 162.58,63.98 162.58,64.36 162.77,64.56 163.02,64.56 163.21,64.36 163.21,64.02 163.38,63.86 165.08,63.86 165.18,63.96 165.18,64.34 165.43,64.59 166.78,64.59 167.36,64.01 168.02,63.34 168.88,63.34 169.26,62.96 170.63,62.96 170.8,62.8 170.8,62.57 170.62,62.4 v1(170.46,62.4)
DDR4_B_DQ34: length 41.7
  TOP w0.089: 141.78,66.54 141.67,66.54 139.87,64.74 U1.CJ78
  TOP w0.102: v1(146.66,65.4) 146.29,65.77 145.37,65.77 144.59,66.54 141.78,66.54
  TOP w0.109: CN2.187 174.42,65.72 174.28,65.71 173.58,65.71 173.34,65.95 173,65.95 172.9,65.86 172.9,65.04 172.75,64.89 172.2,64.89 172.03,65.07 172.03,65.91 171.92,66.01 171.55,66.01 171.46,65.92 v1(171.46,65.43)
  T05 w0.097: v1(146.66,65.4) 146.66,65.39 146.76,65.29 147.61,65.29 148.01,65.7 148.01,66.43 148.97,67.4 155.17,67.4 155.53,67.04 162.45,67.04 162.56,67.14 164.82,67.14 165.06,67.38 168.91,67.38 169.32,66.97 170.66,66.97 170.99,66.64 170.99,65.64 171.21,65.42 171.44,65.42 v1(171.46,65.43)
DDR4_B_DQ35: length 41.8
  TOP w0.089: U1.CJ76 139.87,63.86 139.54,64.18 139.54,64.76 140.56,65.78 140.62,65.78 141.67,66.84
  TOP w0.102: v1(148.29,65.42) 148.29,65.4 148.18,65.29 147.32,65.29 146.55,66.06 145.49,66.06 144.71,66.84 141.67,66.84
  TOP w0.109: v1(170.46,65.43) 170.1,65.43 169.66,64.99 169.44,64.99 169.29,64.84 169.07,64.84 168.93,64.99 168.93,65.29 168.84,65.38 168.6,65.38 168.51,65.29 168.51,64.99 168.42,64.9 168.2,64.9 168.11,64.99 168.11,65.34 167.99,65.47 CN2.186
  T05 w0.097: v1(148.29,65.42) 148.44,65.57 148.44,66.22 149.1,66.89 154.97,66.89 155.27,66.59 162.71,66.59 162.84,66.72 164.99,66.72 165.23,66.95 168.65,66.95 168.96,66.64 168.96,66.28 169.3,65.93 169.62,65.93 170.12,65.43 v1(170.46,65.43)
DDR4_B_DQ36: length 41.8
  TOP w0.089: U1.CU71 144.25,60.81 144.64,61.2 147.39,61.2 147.57,61.38 148.28,61.38 148.53,61.63 148.53,62.05 148.71,62.22 149.24,62.22 v1(149.68,61.79)
  TOP w0.109: v1(171.46,61.4) 171.06,61.4 170.55,61.92 170.07,61.92 170,61.84 169.71,61.84 169.64,61.92 169.04,61.92 168.58,61.46 166.5,61.46 CN2.170
  T05 w0.097: v1(171.46,61.4) 171.84,61.4 172.28,61.84 172.28,61.84 172.59,62.14 172.59,62.8 172.43,62.96 172.07,62.96 171.93,62.82 171.93,62.28 171.6,61.96 168.31,61.96 168.09,62.18 166.15,62.18 165.47,62.86 157.56,62.86 157.43,62.99 157.43,63.2 157.5,63.26 158,63.26 158.07,63.32 158.07,63.52 157.94,63.64 154,63.64 153.36,63 150.58,63 150.44,62.86 150.44,62.46 149.77,61.79 v1(149.68,61.79)
DDR4_B_DQ37: length 41.5
  TOP w0.089: v1(148.97,61.79) 148.19,61.02 144.82,61.02 144.29,60.49 143.18,60.49 143.04,60.63 U1.CR71
  TOP w0.109: v1(170.46,61.4) 170.46,61.15 170.54,61.06 170.94,61.06 171.14,60.85 171.49,60.85 171.69,61.05 171.9,61.26 172.03,61.26 172.48,60.81 172.68,60.81 172.77,60.91 172.77,61.12 172.86,61.21 172.99,61.21 173.08,61.12 173.08,60.98 173.22,60.83 173.31,60.83 173.69,61.21 174.28,61.21 174.28,61.21 174.42,61.22 CN2.169
  T05 w0.097: v1(148.97,61.79) 148.97,61.79 148.97,61.49 149.13,61.34 152.15,61.34 152.3,61.48 152.3,61.81 152.14,61.97 151.17,61.97 151.01,62.12 151.01,62.48 151.11,62.58 153.56,62.58 154.2,63.22 154.83,63.22 155.06,62.99 155.06,62.21 155.21,62.05 155.59,62.05 155.78,62.25 155.78,63.07 155.93,63.22 156.67,63.22 156.85,63.04 156.85,62.58 156.99,62.44 165.29,62.44 165.98,61.76 167.91,61.76 168.13,61.53 168.38,61.53 168.9,61.01 169.29,61.01 169.68,61.4 v1(170.46,61.4)
DDR4_B_DQ38: length 41.9
  TOP w0.089: U1.CL77 140.55,63.81 140.39,63.96 140.39,64.68 141.66,65.95 141.81,65.95
  TOP w0.102: 141.81,65.95 144.36,65.95 145.71,64.6 149.69,64.6 149.88,64.79 149.88,65.17 v1(149.68,65.36)
  TOP w0.109: v1(169.46,64.43) 169.72,64.43 170.26,64.98 171.5,64.98 172.1,64.37 172.1,64.21 172.29,64.02 172.57,64.02 173.26,64.71 174.28,64.71 174.42,64.72 CN2.183
  T05 w0.089: v1(169.46,64.43) 169.4,64.49 169.16,64.49 168.76,64.89
  T05 w0.097: v1(149.68,65.36) 149.53,65.51 149.53,65.81 149.68,65.95 150.69,65.95 150.94,65.7 150.94,65.31 151.08,65.17 151.21,65.17 151.34,65.29 151.34,65.61 151.43,65.7 151.63,65.7 151.72,65.61 151.72,65.23 151.79,65.16 152.03,65.16 152.1,65.23 152.1,65.64 152.16,65.7 163.27,65.7 163.4,65.82 167.77,65.82 167.96,65.63 167.96,65.47 167.81,65.32 167.81,65.1 167.86,65.05 168.01,64.89 168.76,64.89
DDR4_B_DQ39: length 41.7
  TOP w0.089: U1.CK75 140.36,63.18 140.19,63.35 140.19,64.76 141.68,66.24 141.81,66.24
  TOP w0.102: 141.81,66.24 144.48,66.24 145.83,64.89 148.51,64.89 v1(148.97,65.36)
  TOP w0.109: v1(170.46,64.43) 170.05,64.03 169.18,64.03 169.03,63.88 169.03,63.68 168.77,63.41 168.22,63.41 168.05,63.57 168.05,64.36 167.95,64.47 CN2.182
  T05 w0.089: v1(170.46,64.43) 170.64,64.62 170.64,64.66
  T05 w0.097: v1(148.97,65.36) 148.8,65.54 148.8,65.95 149.3,66.46 154.72,66.46 155.02,66.16 162.94,66.16 163.06,66.27 167.98,66.27 169.34,64.92 170.57,64.92 170.64,64.85 170.64,64.66
DDR4_B_DQ40: length 47.1
  TOP w0.089: U1.CF77 138.19,63.79 138.19,64.94 139.54,66.29 139.54,66.81 142.22,69.49 142.85,69.49 142.95,69.39 v1(143.35,69.39)
  TOP w0.109: v1(171.46,67.45) 171.1,67.45 171.01,67.54 171.01,67.76 171.21,67.96 171.79,67.96 171.88,68.05 171.88,68.4 171.99,68.51 172.6,68.51 172.73,68.38 172.73,67.81 172.83,67.71 174.28,67.71 174.42,67.72 CN2.195
  T10 w0.097: v1(143.35,69.39) 143.35,68.95 143.45,68.85 143.6,68.85 144.7,69.95 154.83,69.95 154.97,69.81 154.97,69.56 155.11,69.42 155.31,69.42 155.45,69.56 155.45,69.81 155.59,69.95 155.79,69.95 155.94,69.81 155.94,69.56 156.08,69.42 156.28,69.42 156.42,69.56 156.42,69.81 156.56,69.95 156.76,69.95 156.9,69.81 156.9,69.56 157.04,69.42 157.24,69.42 157.38,69.56 157.38,69.81 157.53,69.95 157.73,69.95 157.87,69.81 157.87,69.56 158.01,69.42 158.21,69.42 158.35,69.56 158.35,69.81 158.49,69.95 158.97,69.95 160.39,68.53 166.37,68.53 166.93,67.97 170.93,67.97 v1(171.46,67.45)
DDR4_B_DQ41: length 47.3
  TOP w0.089: U1.CF75 138.38,63.12 138.73,63.47 138.73,63.77 138.55,63.95 138.48,64.03 138.48,64.82 139.82,66.16 139.82,66.77 141.09,68.04 141.32,68.04 142.36,69.08 142.54,69.08 v1(142.82,68.8)
  TOP w0.109: v1(170.46,67.45) 170.46,67.82 170.34,67.93 170.05,67.93 169.92,67.8 169.92,67.24 169.67,66.99 167.68,66.99 167.53,67.14 167.53,67.34 167.4,67.47 CN2.194
  T10 w0.097: v1(170.46,67.45) 170.64,67.26 170.64,67.07 170.46,66.89 169.29,66.89 168.92,67.26 165.94,67.26 165.12,68.08 158.52,68.08 158.38,68.22 158.38,68.49 158.24,68.63 158.04,68.63 157.9,68.49 157.9,68.22 157.76,68.08 157.55,68.08 157.41,68.22 157.41,68.49 157.27,68.63 157.07,68.63 156.93,68.49 156.93,68.22 156.79,68.08 156.59,68.08 156.45,68.22 156.45,68.49 156.31,68.63 156.11,68.63 155.97,68.49 155.97,68.22 155.82,68.08 155.28,68.08 153.84,69.52 144.92,69.52 143.55,68.15 142.95,68.15 142.83,68.28 142.83,68.8 v1(142.82,68.8)
DDR4_B_DQ42: length 47.3
  TOP w0.089: U1.CB77 136.4,64.84 138.02,66.46
  TOP w0.102: v1(141.34,71.24) 141.02,71.24 140.96,71.29 140.08,71.29 138.02,69.23 138.02,66.46
  TOP w0.109: v1(170.46,70.48) 170.62,70.48 171.15,69.96 171.81,69.96 172.56,70.71 174.28,70.71 174.42,70.72 CN2.207
  T10 w0.097: v1(141.34,71.24) 141.27,71.32 141.27,71.98 142.18,72.89 142.76,72.89 143.31,72.34 169.61,72.34 170.01,71.93 170.01,71.72 170.3,71.43 170.6,71.43 170.7,71.33 170.7,70.73 v1(170.46,70.48)
DDR4_B_DQ43: length 47.2
  TOP w0.089: U1.CB75 136.4,63.11 136.06,63.45 136.06,63.74 136.19,63.87 136.19,64.95 137.73,66.49
  TOP w0.102: 137.73,66.49 137.73,69.35 140.15,71.78 v1(141.85,71.78)
  TOP w0.109: v1(169.46,70.48) 169.46,71.02 169.33,71.14 169.03,71.14 168.91,71.03 168.91,70.06 168.82,69.98 168.02,69.98 167.93,70.06 167.93,70.78 167.74,70.97 CN2.208
  T10 w0.097: v1(169.46,70.48) 169.54,70.48 169.75,70.69 169.75,71.02 168.86,71.91 142.62,71.91 142.48,71.77 141.86,71.77 v1(141.85,71.78)
DDR4_B_DQ44: length 47.1
  TOP w0.089: v1(141.75,67.79) 141.75,67.79 141.14,67.79 140.1,66.75 140.1,66.11 138.88,64.89 U1.CG78
  TOP w0.109: v1(169.46,66.45) 169.81,66.45 170.24,66.87 171.69,66.87 172.15,66.42 172.92,66.42 173.21,66.71 174.28,66.71 174.42,66.72 CN2.191
  T10 w0.097: v1(141.75,67.79) 143.79,67.79 145.1,69.1 151.79,69.1 152.67,68.22 152.87,68.22 153.42,68.77 153.62,68.77 153.76,68.63 153.76,68.43 153.21,67.88 153.21,67.68 153.35,67.54 153.55,67.54 154.1,68.09 154.3,68.09 154.44,67.95 154.44,67.75 153.89,67.2 153.89,67 154.24,66.65 161.44,66.65 161.58,66.8 161.58,67.49 161.73,67.64 161.93,67.64 162.07,67.49 162.07,66.8 162.21,66.65 162.41,66.65 162.55,66.8 162.55,67.49 162.69,67.64 162.89,67.64 163.03,67.49 163.03,66.8 163.17,66.65 166.72,66.65 167.45,65.93 168.93,65.93 v1(169.46,66.45)
DDR4_B_DQ45: length 47.2
  TOP w0.089: U1.CG76 138.88,63.26 138.97,63.35 138.97,63.84 139.16,64.02 139.16,64.79 140.43,66.06 140.61,66.06 140.91,66.36 140.91,66.57 141.32,66.97 141.32,67.14 v1(141.19,67.26)
  TOP w0.109: CN2.190 167.69,66.47 168.23,65.93 170.74,65.93 170.86,66.05 170.86,66.34 170.75,66.45 v1(170.46,66.45)
  T10 w0.097: v1(170.46,66.45) 170.99,65.92 170.99,65.15 170.73,64.89 166.65,64.89 165.46,66.08 153.84,66.08 151.24,68.67 150.52,68.67 150.38,68.53 150.38,68.35 150.24,68.21 150.04,68.21 149.9,68.35 149.9,68.53 149.76,68.67 149.56,68.67 149.42,68.53 149.42,68.35 149.27,68.21 149.07,68.21 148.93,68.35 148.93,68.53 148.79,68.67 148.59,68.67 148.45,68.53 148.45,68.35 148.31,68.21 148.11,68.21 147.97,68.35 147.97,68.53 147.83,68.67 147.63,68.67 147.48,68.53 147.48,68.35 147.34,68.21 147.14,68.21 147,68.35 147,68.53 146.86,68.67 146.66,68.67 146.52,68.53 146.52,68.35 146.38,68.21 146.18,68.21 146.04,68.35 146.04,68.53 145.9,68.67 145.28,68.67 143.87,67.26 v1(141.19,67.26)
DDR4_B_DQ46: length 47.1
  TOP w0.089: 138.61,66.43 136.9,64.72 U1.CC78
  TOP w0.102: v1(139.72,69.62) 139.23,69.62 138.61,68.99 138.61,66.43
  TOP w0.109: v1(170.46,69.48) 170.12,69.48 170.02,69.38 170.02,69.13 170.18,68.97 172.62,68.97 173.36,69.71 174.28,69.71 174.42,69.72 CN2.203
  T10 w0.097: v1(139.72,69.62) 140.22,69.11 140.54,69.11 141.64,70.22 142.21,70.22 143.05,71.06 162.01,71.06 162.15,70.92 162.15,70.62 162.29,70.48 162.49,70.48 162.63,70.62 162.63,70.92 162.77,71.06 162.97,71.06 163.11,70.92 163.11,70.62 163.25,70.48 163.45,70.48 163.59,70.62 163.59,70.92 163.74,71.06 163.94,71.06 164.08,70.92 164.08,70.62 164.22,70.48 164.42,70.48 164.56,70.62 164.56,70.92 164.7,71.06 167.02,71.06 168.2,69.87 170.06,69.87 170.45,69.48 v1(170.46,69.48)
DDR4_B_DQ47: length 47.3
  TOP w0.089: U1.CC76 136.9,63.31 136.77,63.43 136.77,63.85 136.61,64.02 136.61,64.73 138.32,66.43
  TOP w0.102: v1(140.23,70.12) 139.33,70.12 138.32,69.11 138.32,66.43
  TOP w0.109: CN2.204 167.42,69.97 167.82,69.58 168.96,69.58 169.28,69.89 170.64,69.89 171.05,69.48 v1(171.46,69.48)
  T10 w0.097: v1(140.23,70.12) 140.93,70.12 141.54,70.73 142.04,70.73 142.79,71.48 168.08,71.48 168.9,70.66 168.9,70.49 169.14,70.25 169.29,70.09 170.43,70.09 170.61,69.91 171.03,69.91 v1(171.46,69.48)
DDR4_B_DQ48: length 53.4
  TOP w0.089: U1.BW78 134.92,64.51 134.74,64.69 134.74,65.22 136.06,66.54 136.06,68.19 136.15,68.28 136.33,68.28 136.42,68.37 136.42,68.55 136.33,68.64 136.15,68.64 136.06,68.73 136.06,68.9 136.15,68.99 136.33,68.99 136.42,69.08 136.42,69.26 136.33,69.35 136.15,69.35 136.06,69.44 136.06,69.69 136.93,70.57 137.11,70.57 137.21,70.47 v1(137.21,70.15)
  TOP w0.109: CN2.216 167.61,72.97 168.12,72.46 168.6,72.46 168.9,72.75 168.9,73.34 169.06,73.5 169.84,73.5 170,73.34 170,73.05 169.86,72.9 v1(169.46,72.9)
  T05 w0.097: v1(169.46,72.9) 169.14,72.9 168.55,72.31 167.92,72.31 167.81,72.41 167.81,72.84 167.66,72.99 166.7,72.99 166.55,72.85 166.55,72.73 166.39,72.57 166.17,72.57 166.01,72.73 166.01,75 165.71,75.31 165.08,75.31 164.86,75.08 164.62,75.08 164.37,75.33 164.08,75.33 163.89,75.14 163.59,75.14 163.47,75.25 163.47,75.56 163.29,75.74 163.05,75.74 162.96,75.65 162.96,75.41 162.78,75.24 162.5,75.24 161.61,74.35 142.94,74.35 140.53,71.94 140.53,71.67 139.42,70.56 138.23,70.56 137.82,70.15 v1(137.21,70.15)
DDR4_B_DQ49: length 53.7
  TOP w0.089: U1.BW76 134.92,63 134.81,62.89 134.65,62.89 134.51,63.02 134.51,63.2 134.77,63.45 134.77,63.74 135.23,64.19 135.23,64.49 134.93,64.78 134.93,65.14 136.25,66.46 136.25,67.87 136.37,67.99 136.52,67.99 136.76,68.23 136.76,69.64 136.87,69.76 137.11,69.76 137.21,69.66 v1(137.21,69.41)
  TOP w0.109: v1(170.46,72.9) 170.46,73.2 170.59,73.33 170.89,73.33 171.03,73.19 171.03,72.44 171.14,72.33 173.19,72.33 173.28,72.42 173.28,72.61 173.39,72.71 174.28,72.71 174.42,72.72 CN2.215
  T05 w0.097: v1(137.21,69.41) 137.73,69.41 138.58,70.26 139.49,70.26 143.15,73.92 162.47,73.92 162.74,74.19 162.92,74.37 165.31,74.37 165.53,74.15 165.53,72.46 165.92,72.08 166.73,72.08 167.44,71.37 167.75,71.37 167.86,71.48 167.86,71.75 167.99,71.88 168.3,71.88 168.44,71.73 168.44,71.62 168.6,71.46 168.82,71.46 168.98,71.62 168.98,72.06 169.36,72.44 169.72,72.44 170.18,72.9 v1(170.46,72.9)
DDR4_B_DQ50: length 53.6
  TOP w0.089: U1.BP78 132.94,64.97
  TOP w0.102: 132.94,64.97 133.07,65.11 133.07,67.25 134.51,68.69 134.51,69.29 v1(135.03,69.8)
  TOP w0.109: v1(170.46,75.93) 170.1,75.93 169.66,75.49 169.02,75.49 168.54,75.97 CN2.228
  T05 w0.097: v1(170.46,75.93) 170.54,75.93 170.7,75.77 170.7,75.52 170.59,75.41 169.34,75.41 167.91,76.83 167.91,77.52 166.53,78.9 163.09,78.9 160.99,76.8 141.94,76.8 135.82,70.68 135.82,69.55 135.66,69.39 135.44,69.39 v1(135.03,69.8)
DDR4_B_DQ51: length 53.7
  TOP w0.089: U1.BP76 132.94,63.32 132.84,63.41 132.84,63.9 132.58,64.16 132.58,65.03 132.64,65.09
  TOP w0.102: v1(135.02,70.52) 134.97,70.52 134.22,69.77 134.22,68.81 132.78,67.37 132.78,65.23 132.64,65.09
  TOP w0.109: CN2.229 174.42,76.22 174.28,76.21 173.58,76.21 173.28,76.51 172.02,76.51 171.46,75.95 v1(171.46,75.93)
  T05 w0.097: v1(135.02,70.52) 135.02,70.57 141.68,77.23 160.82,77.23 162.66,79.07 162.91,79.32 166.71,79.32 168.87,77.16 168.87,76.78 169.25,76.4 170.99,76.4 v1(171.46,75.93)
DDR4_B_DQ52: length 53.6
  TOP w0.089: v1(137.21,67.23) 137.21,67.44 137.1,67.55 136.74,67.55 136.63,67.44 136.63,67.13 136.87,66.89 136.87,66.76 136.63,66.52 136.63,66.21 136.78,66.06 136.78,65.93 136.57,65.72 136.44,65.72 136.31,65.85 136.18,65.85 136.03,65.71 136.03,65.56 136.16,65.43 136.16,65.3 136,65.14 135.87,65.14 135.73,65.28 135.61,65.28 135.45,65.12 135.45,65 135.71,64.73 135.71,64.6 135.61,64.5 135.61,64.17 135.68,64.1 135.68,63.69 135.59,63.6 U1.BY77
  TOP w0.109: CN2.211 174.42,71.72 174.28,71.71 173.58,71.71 173.39,71.52 173.39,71.15 173.24,71 172.88,71 172.74,71.14 172.74,71.39 172.65,71.48 172.23,71.48 172.15,71.39 172.15,71.28 172.06,71.19 171.74,71.19 171.65,71.28 171.65,71.37 171.56,71.45 170.9,71.45 v1(170.46,71.9)
  T05 w0.097: v1(137.21,67.23) 137.62,67.23 138.48,68.09 139.39,68.09 141.34,70.04 142.2,70.04 144.94,72.79 163.91,72.79 164.04,72.66 164.04,72.41 163.97,72.34 163.08,72.34 162.96,72.21 162.96,71.96 163.02,71.9 164.74,71.9 164.86,71.77 164.86,70.63 165.05,70.44 167.72,70.44 168.17,69.99 169.82,69.99 170.01,70.18 170.01,71.14 170.46,71.58 v1(170.46,71.9)
DDR4_B_DQ53: length 53.6
  TOP w0.089: v1(137.21,67.94) 136.85,67.94 136.44,67.52 136.44,66.38 135.12,65.06 135.12,64.86 135.42,64.56 135.42,64.11 135.07,63.76 135.07,63.45 135.41,63.11 U1.BY75
  TOP w0.109: v1(171.46,71.9) 171.06,71.9 170.63,72.33 170.63,72.4 170.54,72.49 169.44,72.49 168.91,71.96 166.5,71.96 CN2.212
  T05 w0.097: v1(137.21,67.94) 137.64,67.94 138.1,68.4 139.26,68.4 144.08,73.22 164.12,73.22 165.69,71.64 166.51,71.64 166.58,71.57 166.58,71.33 166.51,71.26 165.37,71.26 165.31,71.2 165.31,70.96 165.38,70.88 168.04,70.88 168.16,71.01 169.21,71.01 169.97,71.78 169.97,72.05 170.39,72.47 170.89,72.47 v1(171.46,71.9)
DDR4_B_DQ54: length 53.9
  TOP w0.089: 133.54,64.14 133.54,64.03 133.43,63.93 U1.BR77
  TOP w0.102: v1(135.03,67.59) 134.71,67.9 134.55,67.9 133.66,67.01 133.66,64.87 133.54,64.74 133.54,64.14
  TOP w0.109: v1(170.46,74.93) 170.05,74.53 169.18,74.53 168.96,74.31 168.18,74.31 167.52,74.97 CN2.224
  T05 w0.097: v1(170.46,74.93) 169.99,74.47 168.25,74.47 167.97,74.74 167.97,75.26 165.19,78.04 163.44,78.04 161.35,75.95 142.32,75.95 136.6,70.23 136.6,67.43 136.19,67.03 135.68,67.03 135.56,67.15 135.56,67.41 135.37,67.59 v1(135.03,67.59)
DDR4_B_DQ55: length 53.7
  TOP w0.089: U1.BR75 133.43,63.1 133.07,63.47 133.07,63.98 133.24,64.16
  TOP w0.102: v1(135.03,68.3) 134.54,68.3 133.37,67.13 133.37,64.99 133.24,64.87 133.24,64.16
  TOP w0.109: v1(169.46,74.93) 169.85,74.93 170.26,75.34 173.62,75.34 173.75,75.21 174.28,75.21 174.42,75.22 CN2.225
  T05 w0.097: v1(169.46,74.93) 169.21,74.93 165.67,78.47 163.26,78.47 161.17,76.38 142.14,76.38 141.82,76.05 136.22,70.45 136.22,68.32 135.89,67.99 135.33,67.99 v1(135.03,68.3)
DDR4_B_DQ56: length 60.1
  TOP w0.089: U1.BL77 131.26,63.79 131.26,64.62 131.16,64.73 131.16,66.03 130.96,66.24 130.96,69.62 131.39,70.06 131.63,70.06 131.74,69.95 131.74,69.55 v1(132.18,69.11)
  TOP w0.109: v1(171.46,77.95) 171.1,77.95 171.01,78.04 171.01,78.26 171.2,78.45 171.79,78.45 171.88,78.54 171.88,78.94 171.99,79.05 172.64,79.05 172.73,78.96 172.73,78.35 172.87,78.21 174.28,78.21 174.42,78.22 CN2.237
  T10 w0.097: v1(171.46,77.95) 171.46,78.19 171.15,78.5 167.97,78.5 167.85,78.63 167.85,78.85 167.75,78.95 167.47,78.95 167.34,78.82 167.34,78.53 167.21,78.4 166.93,78.4 166.83,78.5 166.83,78.82 166.7,78.95 163.5,78.95 160.97,76.41 140.64,76.41 137.66,73.43 134.69,73.43 133.66,72.41 133.66,71.6 133.27,71.2 133.27,69.34 133.03,69.11 v1(132.18,69.11)
DDR4_B_DQ57: length 60
  TOP w0.089: v1(132.18,68.4) 131.9,68.4 131.81,68.49 131.81,68.94 131.64,69.11 131.47,69.11 131.35,69 131.35,68.34 131.45,68.25 131.55,68.25 131.64,68.16 131.64,67.91 131.55,67.82 131.45,67.82 131.25,67.62 131.25,66.28 131.35,66.17 131.35,64.81 131.45,64.7 131.45,64.08 131.82,63.71 131.82,63.49 131.45,63.12 U1.BL75
  TOP w0.109: v1(170.46,77.95) 170.46,78.34 170.34,78.46 170.08,78.46 169.92,78.3 169.92,77.72 169.7,77.49 167.68,77.49 167.53,77.64 167.53,77.84 167.4,77.97 CN2.236
  T10 w0.089: 133.7,68.66 133.7,69.49
  T10 w0.097: 133.7,69.49 133.7,71.03 134.09,71.42 134.09,72.23 134.86,73 137.84,73 140.79,75.96 161.12,75.96 163.26,78.1 165.5,78.1 165.76,77.84 166.82,77.84 166.96,77.7 166.96,77.12 167.1,76.98 167.3,76.98 167.45,77.12 167.45,77.7 167.59,77.84 168.83,77.84 169.16,77.51 170.01,77.51 v1(170.46,77.95) ; 133.7,68.66 133.44,68.4 v1(132.18,68.4)
DDR4_B_DQ58: length 60.2
  TOP w0.102: U1.BG77 129.47,63.84 129.38,63.93 129.38,65.21 128.66,65.94 128.66,69.09 v1(129.97,70.4)
  TOP w0.109: v1(170.46,80.98) 170.85,81.38 173.39,81.38 173.55,81.22 CN2.249
  T10 w0.097: v1(170.46,80.98) 170.45,80.99 170.45,81.69 170.16,81.98 161.81,81.98 160.03,80.2 159.43,80.2 159.29,80.34 159.29,80.41 159.14,80.55 158.94,80.55 158.8,80.41 158.8,80.34 158.66,80.2 158.46,80.2 158.32,80.34 158.32,80.41 158.18,80.55 157.98,80.55 157.84,80.41 157.84,80.34 157.7,80.2 157.5,80.2 157.36,80.34 157.36,80.41 157.21,80.55 157.01,80.55 156.87,80.41 156.87,80.34 156.73,80.2 141.11,80.2 136.69,75.78 133.67,75.78 131.69,73.8 131.46,73.8 130.35,72.69 130.35,72.18 130.34,72.18 130.34,70.78 v1(129.97,70.4)
DDR4_B_DQ59: length 60.1
  TOP w0.089: U1.BG75 129.47,63.1 129.82,63.46 129.82,63.9 129.67,64.05
  TOP w0.102: 129.67,64.05 129.67,65.33 128.95,66.06 128.95,68.6 v1(129.97,69.62)
  TOP w0.109: CN2.250 167.82,81.47 168.09,81.74 169.36,81.74 169.62,81.48 169.62,81.15 v1(169.46,80.98)
  T10 w0.097: v1(169.46,80.98) 169.46,80.98 169.82,80.98 170.01,81.17 170.01,81.42 169.88,81.55 168.1,81.55 167.97,81.42 167.97,81.08 167.85,80.95 167.55,80.95 167.47,81.04 167.47,81.42 167.34,81.55 161.98,81.55 160.15,79.72 141.23,79.72 136.87,75.35 133.84,75.35 131.87,73.38 131.64,73.38 130.77,72.51 130.77,70.13 130.26,69.62 v1(129.97,69.62)
DDR4_B_DQ60: length 60.2
  TOP w0.089: v1(132.18,66.26) 132.18,66.14 131.73,65.69 131.73,65.27 131.82,65.18 132.02,65.18 132.16,65.04 132.16,64.59 131.95,64.38 U1.BM78
  TOP w0.109: v1(170.46,76.95) 170.75,76.95 170.87,76.83 170.87,76.55 170.74,76.43 168.27,76.43 168.01,76.69 168.01,76.85 167.88,76.97 CN2.232
  T10 w0.097: v1(132.18,66.26) 132.76,66.26 132.89,66.14 132.89,65.73 133.02,65.6 134.18,65.6 134.56,65.98 134.56,70.69 134.94,71.06 134.94,71.88 135.22,72.15 138.19,72.15 141,74.96 152.39,74.96 152.56,74.79 152.56,74.61 152.73,74.44 152.97,74.44 153.14,74.61 153.14,74.79 153.31,74.96 153.55,74.96 153.72,74.79 153.72,74.61 153.89,74.44 154.13,74.44 154.3,74.61 154.3,74.79 154.47,74.96 154.71,74.96 154.88,74.79 154.88,74.61 155.04,74.44 155.28,74.44 155.45,74.61 155.45,74.79 155.62,74.96 155.86,74.96 156.03,74.79 156.03,74.61 156.2,74.44 156.44,74.44 156.61,74.61 156.61,74.79 156.78,74.96 157.02,74.96 157.19,74.79 157.19,74.61 157.36,74.44 157.6,74.44 157.77,74.61 157.77,74.79 157.94,74.96 158.18,74.96 158.35,74.79 158.35,74.61 158.52,74.44 158.76,74.44 158.93,74.61 158.93,74.79 159.1,74.96 159.34,74.96 159.51,74.79 159.51,74.61 159.68,74.44 159.92,74.44 160.09,74.61 160.09,74.79 160.26,74.96 160.5,74.96 160.67,74.79 160.67,74.61 160.84,74.44 161.08,74.44 161.25,74.61 161.25,74.79 161.42,74.96 167.33,74.96 167.84,75.47 169.58,75.47 169.94,75.83 169.94,76.44 v1(170.46,76.95)
DDR4_B_DQ61: length 60
  TOP w0.089: v1(132.18,66.97) 132.18,67.12 131.76,67.54 131.63,67.54 131.54,67.45 131.54,66.92 131.63,66.83 131.73,66.83 131.83,66.74 131.83,66.5 131.74,66.41 131.63,66.41 131.54,66.32 131.54,66.21 131.67,66.08 131.67,65.95 131.54,65.82 131.54,65.06 131.64,64.96 131.83,64.96 131.92,64.87 131.92,64.77 131.64,64.49 131.64,64.16 131.85,63.96 131.98,63.96 132.04,63.89 132.04,63.41 131.95,63.31 U1.BM76
  TOP w0.109: CN2.233 174.42,77.22 174.28,77.21 171.86,77.21 171.67,77.39 170.17,77.39 170.06,77.28 170.06,77.04 169.97,76.95 v1(169.46,76.95)
  T10 w0.097: v1(169.46,76.95) 168.88,76.37 167.34,76.37 167.2,76.23 167.2,75.66 167.05,75.51 166.85,75.51 166.71,75.66 166.71,76.23 166.57,76.37 166.37,76.37 166.23,76.23 166.23,75.66 166.09,75.51 165.89,75.51 165.75,75.66 165.75,76.23 165.61,76.37 162.19,76.37 161.34,75.52 140.96,75.52 138.02,72.58 135.04,72.58 134.51,72.05 134.51,71.24 134.13,70.86 134.13,66.7 134.03,66.59 133.52,66.59 133.42,66.69 133.42,67.3 133.3,67.42 132.62,67.42 v1(132.18,66.97)
DDR4_B_DQ62: length 60
  TOP w0.102: U1.BH78 129.97,65.46 129.24,66.18 129.24,67.27 v1(129.97,67.99)
  TOP w0.109: CN2.245 174.42,80.22 174.28,80.21 173.57,80.21 172.84,79.48 170.24,79.48 170.04,79.68 170.04,79.88 170.14,79.98 v1(170.46,79.98)
  T10 w0.097: v1(170.46,79.98) 170.06,80.37 169.22,80.37 168.95,80.1 166.9,80.1 166.78,80.22 166.78,80.52 166.67,80.63 166.48,80.63 166.32,80.47 166.32,80.23 166.2,80.1 165.93,80.1 165.81,80.22 165.81,80.5 165.69,80.63 165.4,80.63 165.31,80.53 165.31,80.23 165.18,80.1 161.86,80.1 160.58,78.83 141.55,78.83 137.22,74.5 134.24,74.5 132.27,72.52 131.99,72.52 131.63,72.16 131.63,70.07 131.63,67.83 131.21,67.42 130.54,67.42 v1(129.97,67.99)
DDR4_B_DQ63: length 60.5
  TOP w0.089: U1.BH76 130.02,63.16 130.02,63.91 130.26,64.14
  TOP w0.102: v1(129.94,67.2) 129.53,66.8 129.53,66.3 130.26,65.58 130.26,64.14
  TOP w0.109: v1(171.46,79.98) 171.45,79.98 170.95,80.47 CN2.246
  T10 w0.097: v1(129.94,67.2) 129.54,67.6 129.54,68.88 129.78,69.13 130.24,69.13 131.2,70.09 131.2,70.24 131.2,72.33 131.82,72.95 132.1,72.95 133.82,74.67 134.07,74.92 137.04,74.92 141.38,79.26 160.4,79.26 162.2,81.06 166.85,81.06 167.38,80.53 168.77,80.53 168.83,80.59 170.9,80.59 171.46,80.04 v1(171.46,79.98)
DDR4_B_DQS0_N: length 46.3
  TOP w0.089: v1(141.18,25.81) 141.26,25.73 141.26,25.56 141.02,25.32 140.77,25.32 139.87,26.22 139.87,27.67 139.56,27.98 139.56,28.34 139.78,28.56 139.94,28.56 140.01,28.49 140.01,28.36 U1.CJ1
  TOP w0.109: v1(170.46,19.92) 170.66,19.92 170.86,19.72 170.86,19.07 171.18,18.75 172.85,18.75 173.11,19.01 173.11,19.69 173.25,19.83 173.44,19.83 173.56,19.71 174.28,19.71 174.42,19.71 CN2.11
  T10 w0.097: v1(170.46,19.92) 170.67,19.92 170.85,19.75 170.85,19.5 170.67,19.33 169.13,19.33 168.55,19.91 163.29,19.91 163.15,20.05 163.15,20.06 163.01,20.2 162.81,20.2 162.67,20.06 162.67,20.05 162.53,19.91 162.33,19.91 162.19,20.05 162.19,20.06 162.05,20.2 161.85,20.2 161.7,20.06 161.7,20.05 161.56,19.91 159.66,19.91 159.37,20.2 153.2,20.2 152.17,19.17 149.82,19.17 147.85,21.15 146.14,21.15 143.39,23.89 143.39,24.78 142.2,25.97 141.79,25.97 141.55,25.73 141.55,25.73 141.47,25.66 141.33,25.66 v1(141.18,25.81)
DDR4_B_DQS0_P: length 46.4
  TOP w0.089: U1.CJ3 139.87,28.96 139.34,28.43 139.34,27.89 139.65,27.58 139.65,26.13 140.68,25.1 141.11,25.1 141.37,25.36 141.6,25.36 v1(141.7,25.26)
  TOP w0.109: CN2.13 174.42,20.21 174.28,20.21 173.63,20.21 173.49,20.07 173.15,20.07 172.87,19.78 172.87,19.11 172.75,18.99 171.28,18.99 171.1,19.17 171.1,19.74 171.27,19.92 v1(171.46,19.92)
  T10 w0.097: v1(141.7,25.26) 141.64,25.33 141.64,25.52 141.88,25.76 142.11,25.76 143.18,24.69 143.18,23.8 146.05,20.94 147.76,20.94 149.73,18.96 152.26,18.96 153.28,19.99 159.29,19.99 159.58,19.7 168.46,19.7 169.04,19.11 170.76,19.11 171.08,19.43 171.08,19.73 171.26,19.92 v1(171.46,19.92)
DDR4_B_DQS1_N: length 45.4
  TOP w0.089: v1(148.66,27.25) 148.66,27.56 148.81,27.72 148.81,28.39 144.28,32.93 143.82,32.93 143.45,33.3 143.23,33.3 143.01,33.08 143.01,33 143.11,32.91 U1.CU10
  TOP w0.109: v1(170.46,24.97) 170.08,24.97 169.67,24.56 168.97,24.56 168.67,24.26 168.16,24.26 167.74,24.68 167.74,24.99 167.68,25.06 167.48,25.06 167.38,24.96 166.49,24.96 CN2.32
  T05 w0.097: v1(170.46,24.97) 169.85,25.57 168.15,25.57 167.85,25.28 167.61,25.28 167.46,25.12 167.46,24.88 167.31,24.73 167.07,24.73 166.91,24.58 166.91,24.34 166.13,23.55 163.04,23.55 162.78,23.29 162.78,23.03 162.64,22.89 162.44,22.89 162.29,23.03 162.29,23.29 162.03,23.55 161.65,23.55 161.39,23.29 161.39,23.03 161.25,22.89 161.05,22.89 160.91,23.03 160.91,23.29 160.64,23.55 160.27,23.55 160,23.29 160,23.03 159.86,22.89 159.66,22.89 159.52,23.03 159.52,23.29 159.26,23.55 158.88,23.55 158.62,23.29 158.62,23.03 158.48,22.89 158.28,22.89 158.13,23.03 158.13,23.29 157.87,23.55 157.49,23.55 157.23,23.29 157.23,23.03 157.09,22.89 156.89,22.89 156.75,23.03 156.75,23.29 156.48,23.55 156.11,23.55 155.84,23.29 155.84,23.03 155.7,22.89 155.5,22.89 155.36,23.03 155.36,23.29 155.1,23.55 152.42,23.55 150.24,25.74 149.24,25.74 148.13,26.84 148.13,27.16 148.22,27.25 v1(148.66,27.25)
DDR4_B_DQS1_P: length 45.4
  TOP w0.089: v1(148.03,27.87) 148.22,27.68 148.51,27.68 148.62,27.79 148.62,28.31 144.2,32.74 143.66,32.74 143.48,32.56 143.19,32.56 142.84,32.91 U1.CR10
  TOP w0.109: v1(169.46,24.97) 169.46,25.28 169.31,25.42 169.02,25.42 168.86,25.26 168.86,24.78 168.58,24.49 168.26,24.49 167.98,24.78 167.98,25.09 167.78,25.29 167.54,25.29 167.38,25.46 CN2.34
  T05 w0.097: v1(148.03,27.87) 148.03,27.43 147.92,27.33 147.92,26.75 149.15,25.53 150.15,25.53 152.34,23.34 155.01,23.34 155.15,23.2 155.15,22.94 155.41,22.68 155.61,22.68 155.79,22.68 156.05,22.94 156.05,23.2 156.19,23.34 156.39,23.34 156.54,23.2 156.54,22.94 156.8,22.68 157.18,22.68 157.44,22.94 157.44,23.2 157.58,23.34 157.78,23.34 157.92,23.2 157.92,22.94 158.19,22.68 158.56,22.68 158.83,22.94 158.83,23.2 158.97,23.34 159.17,23.34 159.31,23.2 159.31,22.94 159.57,22.68 159.95,22.68 160.21,22.94 160.21,23.2 160.36,23.34 160.56,23.34 160.7,23.2 160.7,22.94 160.96,22.68 161.34,22.68 161.6,22.94 161.6,23.2 161.74,23.34 161.94,23.34 162.08,23.2 162.08,22.94 162.35,22.68 162.72,22.68 162.99,22.94 162.99,23.2 163.13,23.34 166.22,23.34 168.24,25.36 169.76,25.36 169.94,25.18 169.94,25.07 169.84,24.97 v1(169.46,24.97)
DDR4_B_DQS2_N: length 37.7
  TOP w0.089: v1(151.98,32.77) 151.83,32.77 151.72,32.88 151.72,33.46 150.65,34.53 146.06,34.53 145.7,34.89 145.7,34.89 144.56,36.03 143.98,36.03 143.82,36.18 143.82,36.3 143.89,36.37 U1.CV18
  TOP w0.109: CN2.53 174.42,30.21 174.28,30.21 173.63,30.21 173.47,30.37 173.28,30.37 173.12,30.21 173.12,29.51 172.84,29.23 172.31,29.23 171.54,30 171.25,30 170.83,30.42 v1(170.46,30.42)
  T10 w0.097: v1(170.46,30.42) 170.72,30.42 170.84,30.3 170.84,30.12 170.75,30.02 168.95,30.02 168.85,30.13 162.76,30.13 161.15,31.74 155.3,31.74 155.18,31.85 154.81,31.85 154.7,31.74 154.04,31.74 153.9,31.88 153.9,31.95 153.66,32.18 153.22,32.18 152.99,31.95 152.99,31.88 152.85,31.74 152.23,31.74 151.71,32.26 151.71,32.65 151.83,32.77 v1(151.98,32.77)
DDR4_B_DQS2_P: length 37.7
  TOP w0.089: v1(151.25,32.77) 151.39,32.77 151.51,32.89 151.51,33.37 150.56,34.32 145.97,34.32 145.61,34.67 145.61,34.67 144.47,35.81 143.89,35.81 143.62,36.08 143.62,36.31 143.55,36.38 142.84,36.38 U1.CT18
  TOP w0.109: v1(171.46,30.42) 172.41,29.46 172.74,29.46 172.89,29.6 172.89,30.31 173.18,30.61 173.53,30.61 173.63,30.71 174.28,30.71 174.42,30.71 CN2.55
  T10 w0.097: v1(151.25,32.77) 151.38,32.77 151.5,32.65 151.5,32.17 152.14,31.53 152.94,31.53 153.2,31.79 153.2,31.86 153.31,31.97 153.57,31.97 153.68,31.86 153.68,31.79 153.95,31.53 161.06,31.53 162.67,29.92 168.76,29.92 168.86,29.81 170.83,29.81 171.05,30.03 171.05,30.28 171.19,30.42 v1(171.46,30.42)
DDR4_B_DQS3_N: length 40.9
  TOP w0.089: v1(152.1,37.29) 151.8,37.6 151.8,37.77 151.49,38.08 149.83,38.08 149.67,38.25 145.98,38.25 144.4,39.83 143.83,39.83 143.48,40.19 143.19,40.19 143.05,40.05 143.05,39.9 143.11,39.84 U1.CU26
  TOP w0.109: v1(170.46,35.47) 170.08,35.47 169.67,35.06 169.29,35.06 168.67,34.43 168.05,34.43 167.8,34.69 167.8,35.46 167.65,35.61 167.53,35.61 167.38,35.46 166.5,35.46 CN2.74
  T05 w0.089: v1(170.46,35.47) 170.1,35.82
  T05 w0.097: v1(152.1,37.29) 151.84,37.03 151.84,36.84 152.12,36.57 153.5,36.57 153.52,36.55 153.52,36.55 155.83,34.24 160.34,34.24 160.61,33.98 160.61,33.43 160.75,33.29 160.95,33.29 161.09,33.43 161.09,33.98 161.36,34.24 161.73,34.24 161.99,33.98 161.99,33.43 162.14,33.29 162.34,33.29 162.48,33.43 162.48,33.98 162.74,34.24 166.87,34.24 167.45,34.82 167.45,35.65 167.82,36.02 167.87,36.07 169.85,36.07 170.1,35.82
DDR4_B_DQS3_P: length 40.9
  TOP w0.089: U1.CR26 142.84,39.84 143.2,39.48 143.49,39.48 143.66,39.64 144.32,39.64 145.91,38.06 149.59,38.06 149.75,37.89 151.41,37.89 151.61,37.7 151.61,37.54 v1(151.37,37.29)
  TOP w0.109: v1(169.46,35.47) 169.46,35.78 169.31,35.92 169.02,35.92 168.86,35.76 168.86,34.96 168.57,34.67 168.15,34.67 168.03,34.79 168.03,35.56 167.75,35.84 167.49,35.84 167.37,35.96 166.49,35.96 CN2.76
  T05 w0.089: v1(169.46,35.47) 169.79,35.47 169.88,35.55 169.88,35.69
  T05 w0.097: 169.88,35.69 169.72,35.86 167.95,35.86 167.66,35.56 167.66,34.73 166.96,34.03 162.83,34.03 162.69,33.89 162.69,33.34 162.42,33.08 162.05,33.08 161.78,33.34 161.78,33.89 161.64,34.03 161.44,34.03 161.3,33.89 161.3,33.34 161.04,33.08 160.66,33.08 160.4,33.34 160.4,33.89 160.26,34.03 155.74,34.03 153.43,36.34 152.05,36.34 151.63,36.76 151.63,37.03 v1(151.37,37.29)
DDR4_B_DQS4_N: length 41.7
  TOP w0.089: U1.CM76 141.04,63 140.91,63 140.79,63.13 140.79,63.34 140.89,63.44 140.89,63.86 140.67,64.08 140.67,64.56 141.52,65.41 144.44,65.41 145.74,64.11 147.56,64.11 148.05,63.62 148.05,63.5 v1(148.25,63.3)
  TOP w0.109: CN2.177 174.42,63.22 174.28,63.21 173.63,63.21 173.49,63.36 173.34,63.36 173.12,63.13 173.12,62.78 172.75,62.42 172.22,62.42 171.65,62.99 171.31,62.99 171.03,63.27 171.03,63.51 170.89,63.64 170.68,63.64 v1(170.46,63.42)
  T05 w0.089: 169.74,63.81 169.18,63.81
  T05 w0.097: v1(148.25,63.3) 147.98,63.57 147.98,63.77 148.68,64.47 149.08,64.47 149.18,64.37 149.36,64.37 149.46,64.47 149.64,64.47 149.74,64.37 149.92,64.37 150.02,64.47 150.2,64.47 150.3,64.37 150.48,64.37 150.58,64.47 150.76,64.47 150.86,64.37 151.04,64.37 151.14,64.47 151.32,64.47 151.42,64.37 151.6,64.37 151.71,64.48 152.67,64.48 153.17,64.98 163.59,64.98 163.7,65.09 166.91,65.09 168.2,63.81 168.72,63.81 168.72,63.81 169.18,63.81 ; v1(170.46,63.42) 170.67,63.42 170.77,63.52 170.77,63.71 170.66,63.81 169.74,63.81
DDR4_B_DQS4_P: length 41.7
  TOP w0.089: v1(147.44,63.3) 147.73,63.3 147.86,63.43 147.86,63.54 147.48,63.92 147.2,63.92 147.1,63.82 146.97,63.82 146.87,63.92 145.66,63.92 144.36,65.22 141.6,65.22 140.86,64.49 140.86,64.16 141.08,63.94 141.08,63.66 141.74,63 U1.CN75
  TOP w0.109: v1(171.46,63.42) 171.46,63.72 171.64,63.9 171.84,63.9 172.05,63.69 172.05,62.92 172.32,62.65 172.66,62.65 172.88,62.88 172.88,63.23 173.24,63.59 173.52,63.59 173.63,63.71 174.28,63.71 174.42,63.72 CN2.179
  T05 w0.097: v1(171.46,63.42) 170.85,64.02 168.63,64.02 168.63,64.02 168.28,64.02 167,65.3 163.61,65.3 163.5,65.19 153.05,65.19 152.54,64.69 148.52,64.69 147.71,63.88 147.71,63.58 v1(147.44,63.3)
DDR4_B_DQS5_N: length 47.5
  TOP w0.089: v1(141.09,68.95) 140.61,68.95 140.36,69.2 139.99,69.2 139.05,68.26 139.05,66.47 137.4,64.82 137.4,64.1 137.39,64.1 137.03,63.73 137.03,63.51 137.13,63.41 137.2,63.41 U1.CD77
  TOP w0.109: CN2.198 166.5,68.46 167.38,68.46 167.55,68.63 167.68,68.63 167.8,68.51 167.8,67.78 168.18,67.41 168.63,67.41 169.28,68.06 169.67,68.06 170.08,68.46 v1(170.46,68.46)
  T10 w0.097: v1(170.46,68.46) 170.45,68.46 169.83,69.09 168.91,69.09 168.7,69.29 166.43,69.29 166.26,69.46 166.26,70.24 166.03,70.48 165.54,70.48 165.31,70.24 165.31,69.42 165.11,69.23 161.48,69.23 160.08,70.63 143.58,70.63 141.42,68.48 141.2,68.48 141.09,68.59 v1(141.09,68.95)
DDR4_B_DQS5_P: length 47.5
  TOP w0.089: U1.CD75 137.39,63.11 137.74,63.46 137.74,63.75 137.59,63.9 137.59,64.74 139.24,66.39 139.24,68.18 140.07,69.01 140.28,69.01 140.48,68.81 140.52,68.76 v1(140.52,68.38)
  TOP w0.109: v1(169.46,68.46) 169.56,68.46 169.69,68.6 169.69,68.86 169.47,69.08 168.99,69.08 168.86,68.95 168.86,67.97 168.53,67.64 168.28,67.64 168.04,67.88 168.04,68.61 167.78,68.87 167.47,68.87 167.36,68.97 CN2.200
  T10 w0.097: v1(169.46,68.46) 169.5,68.51 169.5,68.79 169.41,68.87 168.82,68.87 168.61,69.08 166.34,69.08 166.05,69.38 166.05,70.16 165.94,70.27 165.63,70.27 165.52,70.16 165.52,69.33 165.2,69.01 161.4,69.01 159.99,70.42 143.7,70.42 141.48,68.2 141.09,68.2 140.91,68.38 v1(140.52,68.38)
DDR4_B_DQS6_N: length 53.3
  TOP w0.089: v1(138.81,71.78) 138.44,71.78 138.17,72.04 137.61,72.04 135.52,69.95 135.52,66.75 134.22,65.46 134.22,64.17 134.11,64.06 134.03,64.06 133.93,64.16 U1.BT78
  TOP w0.109: v1(170.46,73.92) 170.88,73.92 171.31,73.49 171.63,73.49 171.81,73.31 172.14,72.98 172.15,72.98 172.19,72.93 172.73,72.93 173.06,73.26 173.06,73.39 173.46,73.8 174.34,73.8 174.42,73.72 CN2.219
  T05 w0.097: v1(138.81,71.78) 138.81,71.34 138.86,71.28 139.2,71.28 139.9,71.98 139.9,72.44 142.88,75.43 161.6,75.43 162.89,76.72 165.82,76.72 167.3,75.24 167.3,73.89 167.5,73.68 169.08,73.68 169.26,73.5 169.7,73.5 169.71,73.5 170.47,73.5 170.58,73.61 170.58,73.8 v1(170.46,73.92)
DDR4_B_DQS6_P: length 53.3
  TOP w0.089: v1(138.26,71.32) 138.26,71.68 138.1,71.85 137.69,71.85 135.71,69.87 135.71,66.67 134.41,65.38 134.41,64.09 134.08,63.75 U1.BT76
  TOP w0.109: CN2.221 173.55,74.22 172.82,73.49 172.82,73.36 172.63,73.17 172.29,73.17 172.24,73.21 172.24,73.21 171.98,73.48 171.54,73.92 v1(171.46,73.92)
  T05 w0.097: v1(138.26,71.32) 138.44,71.32 138.69,71.07 138.77,71.07 138.78,71.07 139.29,71.07 140.11,71.89 140.11,72.36 142.97,75.22 161.68,75.22 162.97,76.51 165.73,76.51 167.08,75.16 167.08,73.8 167.41,73.47 168.99,73.47 169.17,73.29 169.62,73.29 170.29,73.29 170.29,73.29 170.7,73.29 170.83,73.42 170.83,73.42 171.07,73.66 171.07,73.66 171.33,73.92 v1(171.46,73.92)
DDR4_B_DQS7_N: length 61.5
  TOP w0.089: v1(132.18,71.32) 131.93,71.07 130.7,71.07 130.48,70.85 130.48,65.96 130.63,65.8 130.63,64.76 130.47,64.59 130.47,64.08 130.65,63.9 130.65,63.79 U1.BJ77
  TOP w0.109: v1(170.46,78.97) 170.05,78.97 169.6,78.51 169.23,78.51 168.55,77.83 168.16,77.83 167.8,78.2 167.8,78.91 167.67,79.04 167.46,79.04 167.38,78.96 166.51,78.96 CN2.240
  T10 w0.097: v1(170.46,78.97) 169.85,79.57 169.15,79.57 169.05,79.66 162.47,79.66 160.04,77.23 159.58,77.23 159.41,77.4 159.41,77.91 159.09,78.22 158.3,78.22 157.98,77.91 157.98,77.43 157.79,77.23 157.3,77.23 157.13,77.4 157.13,77.94 156.85,78.22 156.09,78.22 155.82,77.95 155.82,77.39 155.67,77.23 155.09,77.23 154.94,77.38 154.94,77.86 154.69,78.12 154.12,78.12 153.83,77.82 153.83,77.36 153.7,77.23 140.56,77.23 137.4,74.07 134.42,74.07 133.02,72.67 133.02,71.86 132.87,71.71 132.87,71.71 132.47,71.32 v1(132.18,71.32)
DDR4_B_DQS7_P: length 61.4
  TOP w0.089: U1.BJ75 130.46,63.1 130.84,63.48 130.84,63.98 130.66,64.16 130.66,64.52 130.82,64.68 130.82,65.88 130.67,66.04 130.67,70.77 130.77,70.88 131.88,70.88 v1(132.18,70.58)
  TOP w0.109: v1(169.46,78.97) 169.43,78.99 169.43,79.26 169.36,79.34 168.94,79.34 168.86,79.26 168.86,78.47 168.46,78.08 168.26,78.08 168.04,78.29 168.04,79.01 167.71,79.34 167.47,79.34 167.34,79.47 CN2.242
  T10 w0.097: v1(169.46,78.97) 169.43,78.99 169.43,79.2 169.28,79.36 169.06,79.36 168.97,79.45 162.56,79.45 160.13,77.02 159.5,77.02 159.2,77.32 159.2,77.82 159.01,78.01 158.38,78.01 158.19,77.82 158.19,77.34 157.88,77.02 157.21,77.02 156.92,77.32 156.92,77.85 156.76,78.01 156.18,78.01 156.04,77.86 156.04,77.3 155.76,77.02 155,77.02 154.73,77.29 154.73,77.77 154.6,77.9 154.21,77.9 154.04,77.73 154.04,77.27 153.79,77.02 140.65,77.02 137.49,73.86 134.51,73.86 133.23,72.58 133.23,71.78 132.62,71.16 132.62,71.13 132.2,70.71 132.2,70.6 v1(132.18,70.58)
DDR4_B_DQS8_N: length 41.3
  TOP w0.089: U1.CV34 143.96,43.42 143.71,43.42 143.53,43.23 143.53,43.1 143.76,42.87 144.14,42.87 144.39,43.12 144.56,43.12 145.61,42.07 148.6,42.07 148.7,41.97 148.83,41.97 148.93,42.07 149.06,42.07 149.16,41.97 149.28,41.97 149.39,42.07 149.51,42.07 149.61,41.97 149.74,41.97 149.84,42.07 150.95,42.07 151.16,41.86 151.16,40.92 v1(150.91,40.66)
  TOP w0.109: v1(170.46,40.92) 170.88,40.92 171.31,40.49 171.65,40.49 171.82,40.32 171.82,40.1 172.2,39.71 172.86,39.71 173.12,39.97 173.12,40.71 173.22,40.81 173.54,40.81 173.63,40.71 174.28,40.71 174.42,40.71 CN2.95
  T10 w0.089: v1(150.91,40.66) 151.09,40.66 151.16,40.73 151.16,40.82
  T10 w0.097: 151.16,40.82 151.16,41.13 151.51,41.48 152.78,41.48 154.35,39.91 164.38,39.91 165.05,39.24 165.53,39.24 165.77,39.48 165.77,40.19 165.99,40.41 166.68,40.41 166.89,40.2 166.89,39.4 166.99,39.3 167.53,39.3 167.63,39.4 167.63,40.29 167.93,40.59 169.21,40.59 169.27,40.52 170.76,40.52 170.86,40.62 170.86,40.82 170.76,40.92 v1(170.46,40.92)
DDR4_B_DQS8_P: length 41.4
  TOP w0.089: v1(151.67,40.66) 151.35,40.98 151.35,41.94 151.03,42.26 145.69,42.26 144.64,43.31 144.52,43.31 144.23,43.61 143.63,43.61 143.48,43.45 143.33,43.3 U1.CT34
  TOP w0.109: CN2.97 174.42,41.21 174.28,41.21 173.64,41.21 173.63,41.21 173.47,41.04 173.12,41.04 172.89,40.81 172.89,40.07 172.76,39.95 172.3,39.95 172.05,40.2 172.05,41.19 171.84,41.4 171.64,41.4 171.46,41.22 v1(171.46,40.92)
  T10 w0.097: v1(171.46,40.92) 171.45,40.91 171.14,40.91 171.07,40.84 171.07,40.53 170.85,40.31 169.19,40.31 169.12,40.38 168.01,40.38 167.84,40.21 167.84,39.32 167.62,39.09 166.9,39.09 166.68,39.31 166.68,40.11 166.59,40.2 166.08,40.2 165.98,40.11 165.98,39.39 165.62,39.03 164.96,39.03 164.29,39.7 154.22,39.7 153.85,40.08 153.66,40.08 153.48,40.26 153.48,40.44 153.3,40.62 153.12,40.62 152.94,40.81 152.94,40.99 152.71,41.21 152.28,41.21 152.17,41.11 152,41.11 151.9,41.21 151.62,41.21 151.44,41.02 151.44,40.76 151.53,40.66 v1(151.67,40.66)
DDR4_B_ECC0: length 41.1
  TOP w0.089: v1(149.48,40.66) 148.46,41.67 145.67,41.67 145.03,42.31 U1.CV31
  TOP w0.109: CN2.92 167.62,39.96 168.12,39.46 168.6,39.46 168.9,39.75 168.9,40.34 169.06,40.5 169.84,40.5 170,40.34 170,40.05 169.86,39.9 v1(169.46,39.9)
  T10 w0.089: 151.01,40.09 151.83,39.27
  T10 w0.097: 151.83,39.27 152.18,39.27 152.32,39.41 152.32,39.92 152.46,40.06 152.66,40.06 152.8,39.92 152.8,39.41 152.95,39.27 156.64,39.27 156.78,39.13 156.78,38.76 156.92,38.62 157.12,38.62 157.26,38.76 157.26,39.13 157.4,39.27 157.6,39.27 157.74,39.13 157.74,38.76 157.89,38.62 158.09,38.62 158.23,38.76 158.23,39.13 158.37,39.27 158.57,39.27 158.71,39.13 158.71,38.76 158.85,38.62 159.05,38.62 159.19,38.76 159.19,39.13 159.33,39.27 159.53,39.27 159.68,39.13 159.68,38.76 159.82,38.62 160.02,38.62 160.16,38.76 160.16,39.13 160.3,39.27 160.5,39.27 160.64,39.13 160.64,38.76 160.78,38.62 160.98,38.62 161.12,38.76 161.12,39.13 161.26,39.27 161.46,39.27 161.61,39.13 161.61,38.76 161.75,38.62 161.95,38.62 162.09,38.76 162.09,39.13 162.23,39.27 162.43,39.27 162.57,39.13 162.57,38.76 162.71,38.62 162.91,38.62 163.05,38.76 163.05,39.13 163.19,39.27 163.65,39.27 164.32,38.61 168.36,38.61 169.46,39.7 v1(169.46,39.9) ; v1(149.48,40.66) 150.04,40.09 151.01,40.09
DDR4_B_ECC1: length 40.9
  TOP w0.089: U1.CT31 143.06,42.31 143.12,42.37 143.55,42.37 143.73,42.19 143.73,42.19 143.9,42.01 145.02,42.01 145.56,41.47 146.45,41.47 146.53,41.4 147.01,41.4 147.14,41.27 148.13,41.27 v1(148.74,40.66)
  TOP w0.109: CN2.91 174.42,39.71 174.28,39.71 173.43,39.71 173.05,39.33 171.21,39.33 171.03,39.51 171.03,40.19 170.75,40.47 170.57,40.47 170.46,40.36 v1(170.46,39.9)
  T10 w0.097: v1(170.46,39.9) 169.94,39.39 169.94,38.8 169.63,38.48 168.85,38.48 168.28,37.92 168.28,37.92 167.79,37.43 167.5,37.43 167.36,37.57 167.36,37.89 167.21,38.03 167.01,38.03 166.87,37.89 166.87,37.57 166.73,37.43 166.53,37.43 166.39,37.57 166.39,37.89 166.25,38.03 166.05,38.03 165.91,37.89 165.91,37.57 165.77,37.43 165.08,37.43 164.35,38.17 158.33,38.17 158.19,38.03 158.19,37.78 158.05,37.63 157.85,37.63 157.71,37.78 157.71,38.03 157.57,38.17 157.37,38.17 157.23,38.03 157.23,37.78 157.09,37.63 156.89,37.63 156.75,37.78 156.75,38.03 156.6,38.17 156.09,38.17 155.94,38.31 155.94,38.47 155.8,38.61 155.6,38.61 155.46,38.47 155.46,38.31 155.32,38.17 155.12,38.17 154.98,38.31 154.98,38.47 154.84,38.61 154.64,38.61 154.5,38.47 154.5,38.31 154.36,38.17 154.04,38.17 153.37,38.84 151.63,38.84 150.81,39.66 149.74,39.66 v1(148.74,40.66)
DDR4_B_ECC2: length 40.9
  TOP w0.089: v1(148.74,42.79) 147.77,43.76 145.31,43.76 144.95,44.11 144.53,44.11 144.46,44.19 144.18,44.19 U1.CV36
  TOP w0.109: v1(169.46,41.93) 169.85,41.93 170.26,42.34 171.64,42.34 172.1,41.87 173.29,41.87 173.63,42.21 174.28,42.21 174.42,42.21 CN2.101
  T10 w0.097: v1(169.46,41.93) 169.11,41.93 168.66,41.48 168.17,41.48 168.04,41.61 168.04,42.29 167.94,42.38 167.69,42.38 167.59,42.29 167.59,41.61 167.47,41.48 167.28,41.48 167.15,41.61 167.15,42.28 167.05,42.37 166.86,42.37 166.77,42.28 166.77,41.61 166.64,41.48 166.51,41.48 166.39,41.61 166.39,41.93 166.26,42.06 166.14,42.06 166.01,41.93 166.01,41.54 165.94,41.48 165.47,41.48 164.87,40.88 161.91,40.88 161.45,41.34 161.18,41.34 161.04,41.19 161.04,41.03 160.9,40.89 160.7,40.89 160.56,41.03 160.56,41.19 160.41,41.34 160.21,41.34 160.07,41.19 160.07,41.03 159.93,40.89 159.73,40.89 159.59,41.03 159.59,41.19 159.45,41.34 159.25,41.34 159.11,41.19 159.11,41.03 158.97,40.89 158.77,40.89 158.63,41.03 158.63,41.19 158.48,41.34 158.28,41.34 158.14,41.19 158.14,41.03 158,40.89 157.8,40.89 157.66,41.03 157.66,41.19 157.52,41.34 157.32,41.34 157.18,41.19 157.18,41.03 157.04,40.89 156.84,40.89 156.7,41.03 156.7,41.19 156.55,41.34 156.35,41.34 156.21,41.19 156.21,41.03 156.07,40.89 155.87,40.89 155.73,41.03 155.73,41.19 155.59,41.34 154.13,41.34 153.1,42.37 150.91,42.37 150.22,41.68 149.42,41.68 148.74,42.35 v1(148.74,42.79)
DDR4_B_ECC3: length 41.1
  TOP w0.089: v1(149.48,42.79) 148.2,44.06 145.33,44.06 145.02,44.38 144.44,44.38 144.24,44.58 143.9,44.58 143.68,44.36 143.1,44.36 143.04,44.29 U1.CT36
  TOP w0.109: CN2.105 174.42,43.21 174.28,43.21 172.99,43.21 172.87,43.09 172.87,42.9 172.96,42.81 173.41,42.81 173.5,42.72 173.5,42.54 173.17,42.2 172.23,42.2 172.03,42.4 172.03,42.83 171.93,42.93 v1(171.46,42.93)
  T10 w0.097: v1(149.48,42.79) 149.48,42.47 149.72,42.23 150.18,42.23 150.77,42.81 153.26,42.81 154.2,41.88 158.81,41.88 158.95,42.02 158.95,42.24 159.09,42.38 159.29,42.38 159.44,42.24 159.44,42.02 159.58,41.88 159.78,41.88 159.92,42.02 159.92,42.24 160.06,42.38 160.26,42.38 160.4,42.24 160.4,42.02 160.54,41.88 160.74,41.88 160.88,42.02 160.88,42.24 161.03,42.38 161.23,42.38 161.37,42.24 161.37,42.02 161.51,41.88 162.01,41.88 162.15,41.74 162.15,41.48 162.29,41.34 162.49,41.34 162.63,41.48 162.63,41.74 162.77,41.88 162.97,41.88 163.11,41.74 163.11,41.48 163.26,41.34 163.46,41.34 163.6,41.48 163.6,41.74 163.74,41.88 163.94,41.88 164.08,41.74 164.08,41.48 164.22,41.34 164.42,41.34 164.56,41.48 164.56,41.74 164.7,41.88 165.09,41.88 166.17,42.96 168.72,42.96 169.24,42.43 170.63,42.43 171.13,42.93 v1(171.46,42.93)
DDR4_B_ECC4: length 41
  TOP w0.089: U1.CU30 143.53,41.62 143.9,41.62 143.9,41.62 144.24,41.62 144.24,41.62 144.78,41.62 145.34,41.06 146.14,41.06 v1(146.54,40.66)
  TOP w0.109: CN2.88 166.5,38.96 168.86,38.96 169.39,39.49 170.47,39.49 171.06,38.9 v1(171.46,38.9)
  T10 w0.089: 152.51,37.99 152.54,37.96
  T10 w0.097: v1(171.46,38.9) 170.9,38.34 170.9,37.3 170.59,36.99 169.32,36.99 168.89,36.55 167.92,36.55 167.78,36.41 167.78,36.24 167.64,36.09 167.44,36.09 167.3,36.24 167.3,36.41 167.16,36.55 166.96,36.55 166.82,36.41 166.82,36.24 166.67,36.09 166.47,36.09 166.33,36.24 166.33,36.41 166.19,36.55 155.51,36.55 154.97,37.1 153.41,37.1 152.54,37.96 ; v1(146.54,40.66) 146.53,40.65 146.53,40.58 145.65,39.7 145.65,38.48 146.14,37.99 152.51,37.99
DDR4_B_ECC5: length 41.2
  TOP w0.089: U1.CR30 142.84,41.82 143.19,42.17 143.48,42.17 143.83,41.81 144.32,41.81 144.92,41.81 145.46,41.27 146.3,41.27 146.43,41.14 146.83,41.14 v1(147.3,40.66)
  TOP w0.109: CN2.87 174.42,38.71 174.28,38.71 173.58,38.71 173.48,38.6 173.48,38.19 173.34,38.05 172.97,38.05 172.83,38.19 172.83,38.35 172.7,38.48 172.23,38.48 172.14,38.39 172.14,38.19 172.05,38.1 171.73,38.1 171.65,38.19 171.65,38.39 171.56,38.48 170.88,38.48 v1(170.46,38.9)
  T10 w0.097: v1(147.3,40.66) 147.84,40.12 147.84,39.93 147.61,39.7 147.61,39.5 147.76,39.36 147.96,39.36 148.18,39.58 148.38,39.58 148.74,39.23 150.67,39.23 151.48,38.41 152.95,38.41 153.64,37.73 155.13,37.73 155.71,37.15 158.35,37.15 158.94,37.74 160.21,37.74 160.35,37.59 160.35,37.25 160.49,37.11 160.69,37.11 160.83,37.25 160.83,37.59 160.98,37.74 161.18,37.74 161.32,37.59 161.32,37.25 161.46,37.11 161.66,37.11 161.8,37.25 161.8,37.59 161.94,37.74 162.14,37.74 162.28,37.59 162.28,37.25 162.42,37.11 162.62,37.11 162.76,37.25 162.76,37.59 162.91,37.74 164.1,37.74 164.23,37.61 164.23,37.61 164.83,37.01 168.71,37.01 168.93,37.23 168.93,37.66 169.33,38.06 169.93,38.06 170.46,38.58 v1(170.46,38.9)
DDR4_B_ECC6: length 41.1
  TOP w0.089: v1(146.54,42.78) 146.13,43.19 145.19,43.19 144.8,43.58 144.53,43.58 144.31,43.8 U1.CU35
  TOP w0.109: CN2.100 167.93,41.96 168.05,41.85 168.05,41.05 168.2,40.9 168.84,40.9 169.03,41.09 169.03,41.38 169.18,41.53 170.05,41.53 v1(170.46,41.93)
  T10 w0.097: v1(170.46,41.93) 170.46,41.93 169.95,41.43 169.26,41.43 168.88,41.04 165.72,41.04 165.13,40.44 154.42,40.44 152.94,41.93 151.07,41.93 150.41,41.27 148.53,41.27 148.38,41.41 148.38,41.76 148.24,41.9 148.04,41.9 147.9,41.76 147.9,41.41 147.76,41.27 147.56,41.27 147.42,41.41 147.42,41.76 147.28,41.9 147.08,41.9 146.94,41.76 146.94,41.41 146.8,41.27 146.6,41.27 146.45,41.41 146.45,41.76 146.31,41.9 146.11,41.9 145.97,41.76 145.97,41.41 145.83,41.27 145.42,41.27 145.15,41.54 145.15,42.09 145.41,42.36 146.12,42.36 v1(146.54,42.78)
