# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPLD_ERROR0_L_LATCH: length 19.3
  TOP w0.109: U31.D3 v1(55.13,47.28)
  T08 w0.097: v3(53.44,58.07) 53.44,57.56 55.97,55.02 55.97,53.5 56.28,53.2 56.28,48.43 v1(55.13,47.28)
  BOTTOM w0.109: v2(54.71,55.03) 54.71,55.3 53.98,56.04 53.98,56.92 53.44,57.45 v3(53.44,58.07) 53.43,58.07 53.23,58.28 U30.7
CPLD_ERROR1_L_LATCH: length 16.4
  TOP w0.109: U31.E2 v1(54.13,48.28)
  T08 w0.097: v1(54.13,48.28) 54.06,48.36 54.06,49.56 53.77,49.84 53.77,55 53,55.78 51.41,55.78 v3(49.62,57.56)
  BOTTOM w0.109: U30.8 50.91,57.69 49.75,57.69 v3(49.62,57.56) ; v2(53.54,46.32) 53.59,46.37 53.59,47.74 v1(54.13,48.28)
CPLD_ERROR2_L_LATCH: length 13.9
  TOP w0.109: U31.E3 v1(54.13,47.28)
  T08 w0.097: v3(52.24,56.98) 52.43,56.98 54.07,55.34 54.07,49.97 54.39,49.65 54.55,49.49 54.55,48.11 54.13,47.7 v1(54.13,47.28)
  BOTTOM w0.109: U30.9 v3(52.24,56.98) 52.29,56.93 52.62,56.93 52.75,56.8 v2(53.21,56.8)
CPLD_FAST_PROCHOT_L: length 134.5
  TOP w0.109: v3(67.61,11.05) 67.91,11.34 67.91,12.44 67.6,12.74 R220.1 ; v3(35.65,64.42) 34.89,64.42 34.64,64.68 34.64,66.84 34.92,67.12 U14.12 ; R347.1 62.99,48.66 61.47,50.18 61.47,50.69 61.54,50.76 v3(61.54,50.82)
  T03 w0.097: v3(35.65,64.42) 35.57,64.34 35.57,57.94 37.32,56.2 37.32,54.86 38.19,53.99 39.34,53.99 39.38,53.96 41.45,53.96 41.81,54.31 44.26,54.31 44.99,55.04 47.61,55.04 48.15,55.58 49.89,55.58 50.96,54.52 56.33,54.52 56.71,54.14 58.72,54.14 59.82,53.04 59.82,52.09 61.01,50.89 61.47,50.89 v3(61.54,50.82)
  T05 w0.097: v3(61.54,50.82) 61.34,50.82 59.5,52.66 52.73,52.66 49.12,49.05 49.12,46.57 47.96,45.41 47.96,44.08 47.44,43.57 46.85,43.57 46.61,43.81 41.45,43.81 39.29,41.65 39.29,22.62 41.75,20.16 41.75,17.82 44.53,15.04 65.15,15.04 67.63,12.56 67.63,11.06 v3(67.61,11.05)
  BOTTOM w0.109: v2(36.69,63.54) 36.53,63.54 v3(35.65,64.42) ; v3(61.54,50.82) 61.54,50.87 61.53,50.89 v2(61.53,51.73)
CPLD_FAST_PROCHOT_L_R: length 8
  TOP w0.109: R347.2 62.03,48.4 v3(61.52,48.91) ; U31.C4 v1(56.13,46.28)
  BOTTOM w0.109: v3(61.52,48.91) 61.21,48.91 v2(60.71,48.4) 59.07,46.77 56.61,46.77 56.13,46.29 v1(56.13,46.28)
CPLD_FIVR_FAULT: length 31.8
  TOP w0.109: U13.7 76.29,27.57 77.16,28.44 77.16,32.2 75.06,34.31 72.29,34.31 72.06,34.08 67.41,34.08 v3(67.22,34.27) ; U31.B8 v1(57.13,42.28)
  T05 w0.097: v1(57.13,42.28) 57.13,42.01 59.05,40.09 61.02,40.09 62.5,38.62 62.5,38.15 66.39,34.27 v3(67.22,34.27)
CPLD_GPIO27_MGPIO6: length 88.4
  TOP w0.109: U31.B6 v1(57.13,44.28)
  TOP w0.152: U1.BB16 v1(127.96,35.18)
  T05 w0.089: v1(127.96,35.18) 127.96,34.55 126.66,33.25 125.77,33.25 124.8,32.28 120.43,32.28 120.26,32.11 118.72,32.11 118.59,32.24 113.75,32.24 113.54,32.02 113.21,32.02 112.76,32.47 109.09,32.47 105.55,36
  T05 w0.097: 105.55,36 104.98,36.58 73.4,36.58 v3(72.8,35.98)
  T08 w0.097: v1(57.13,44.28) 58.17,43.25 58.17,40.91 59.82,39.26 59.82,38.66 60.87,37.61 65.41,37.61 68.04,40.24 73.08,40.24 73.9,39.43 73.9,37.08 v3(72.8,35.98)
  BOTTOM w0.102: R89.2 127.61,35.5 127.64,35.5 v1(127.96,35.18)
  BOTTOM w0.109: v2(73.71,35.98) v3(72.8,35.98)
CPLD_M2_DEVSLP: length 65.8
  TOP w0.109: U31.E16 v1(53.64,33.05)
  T05 w0.097: v3(57.5,62.3) 57.5,61.86 62.03,57.33 62.03,50.47 61.45,49.89 59.71,49.89 58.52,51.08 54.43,51.08 54.21,50.85 52.27,50.85 50.54,49.13 50.54,45.02 50.72,44.84 50.72,44.11 51,43.83 52.18,43.83 52.67,43.34 52.67,39.26 53.64,38.29 v1(53.64,33.05)
  BOTTOM w0.109: v3(57.5,62.3) 57.5,62.5 55.73,64.27 50.81,64.27 48.9,66.18 48.9,68.92 52.16,72.19 v2(52.16,72.95) 52.16,73.63 52.9,74.37 R390.1
CPLD_M2_DEVSLP_R: length 3.4
  BOTTOM w0.109: R390.2 53.73,74.44 v2(55.22,74.44) J9.38
CPLD_PCH_THERMTRIP_L: length 7.5
  TOP w0.089: 58.77,42.79 U31.A7
  TOP w0.109: 58.77,42.79 59.84,42.79 v3(59.94,42.69) 59.95,42.7 62.59,42.7 63.23,42.05 63.23,41.31 63.63,40.91 U19.2
CPLD_PCHHOT_L_LATCH: length 15.5
  TOP w0.109: U31.D2 v1(55.13,48.28)
  T08 w0.097: v1(55.13,48.28) 55.17,48.32 55.17,49.66 55.26,49.75 55.26,55.15 53.02,57.39 53.02,57.99 52.55,58.47 v3(52.55,58.83)
  BOTTOM w0.109: v1(55.13,48.28) 56.19,48.28 v2(56.25,48.22) ; U30.5 50.99,59.6 51.78,59.6 v3(52.55,58.83)
CPLD_PCIE_RESET_L: length 62.7
  TOP w0.109: v3(31.55,18.63) 31.88,18.63 35.43,15.08 40.36,15.08 42.57,12.87 46.59,12.87 47.62,11.84 47.62,10.91 46.35,9.64 J10.B30 ; R344.1 36.29,48.29 v3(36.04,48.55)
  T05 w0.097: v3(36.04,48.55) 34.89,47.4 34.89,46.26 32.23,43.59 32.23,42.88 31.97,42.63 29.39,42.63 28.08,41.32 28.08,34.58 29.6,33.06 29.6,27.33 32.15,24.78 32.15,19.24 v3(31.55,18.63)
CPLD_PCIE_RESET_L_R: length 7.8
  TOP w0.109: R344.2 40.73,48.29 41.67,47.35 v1(43.08,47.35) U31.R3
  BOTTOM w0.109: v2(41.98,47.81) 42.62,47.81 v1(43.08,47.35)
CPLD_PIRQC_L: length 7.1
  TOP w0.109: U35.2 45.72,30.31 45.97,30.56 46.99,30.56 48.15,31.72 v1(48.15,34.3) U31.K15
CPLD_PIRQD_L: length 8.7
  TOP w0.109: U31.L15 v1(47.08,34.24) 47.08,32.55 47.62,32.01 47.62,31.64 46.86,30.88 45.59,30.88 45.22,30.5 U35.3
  BOTTOM w0.109: v1(47.08,34.24) 47.06,34.26 v2(47.06,35.36)
CPLD_PIRQE_L_GPIO2: length 113.4
  TOP w0.109: U31.K16 v1(48.64,32.8)
  T05 w0.097: v1(48.64,32.8) 48.64,27.92 48.25,27.53 48.25,21.66 48.51,21.4 v3(48.62,21.4)
  T08 w0.097: v3(48.62,21.4) 49.35,21.4 50.84,19.92 73.85,19.92 74.59,20.65 90.11,20.65 90.84,19.92 97.56,19.92 98.5,20.86 104.52,20.86 105.11,21.45 106.31,21.45 106.48,21.28 117.36,21.28 119.21,19.43 119.21,18.35 120.67,16.88 123.44,16.88 126.53,13.79 127.45,13.79 128.71,12.53 128.71,8.6 130.85,6.46 137.08,6.46 v3(137.13,6.51)
  BOTTOM w0.109: R44.2 v3(137.13,6.51)
CPLD_PIRQE_L_GPIO2_R: length 31.5
  TOP w0.109: R442.2 v3(137.13,9.56)
  TOP w0.152: U1.BV16 v1(134.18,35.83)
  T03 w0.089: 134.04,21.61 134.04,23.32 133.27,24.09 133.27,28.54 133.06,28.75 133.06,31.36 133.08,31.38 133.08,31.55 133.59,32.05 133.59,32.61 134.07,33.09 134.07,33.53 133.79,33.81 133.79,34.53 134.07,34.81 134.07,35.72 v1(134.18,35.83)
  T03 w0.097: 134.04,21.61 134.04,21.3 134.04,20.96 135.07,19.93 135.07,11.62 v3(137.13,9.56)
  BOTTOM w0.109: R442.2 v3(137.13,9.56)
CPLD_PIRQF_L_GPIO3: length 107.5
  TOP w0.109: R43.2 133.06,7.63 133.19,7.75 133.19,8.92 v3(132.56,9.56) ; U31.L16 v1(47.64,32.8)
  T05 w0.097: v1(47.64,32.8) 47.64,21.51 48.54,20.62 52.68,20.62 53.16,20.13 68.28,20.13 69.47,18.94 78.16,18.94 79.76,17.34 87.3,17.34 91.39,13.24 96.72,13.24 97.94,14.47 98.19,14.47 123.09,14.47 124.83,12.73 126.01,11.55 126.01,9.4 126.28,9.13 132.13,9.13 v3(132.56,9.56)
CPLD_PIRQF_L_GPIO3_R: length 33.8
  TOP w0.109: v3(131.03,9.56) R441.2 R43.1
  TOP w0.152: U1.BN22 132,38.12 v1(131.71,38.41)
  T10 w0.089: v1(131.71,38.41) 131.62,38.31 131.62,37.32 131.1,36.8 131.1,36.34 130.73,35.97 130.73,35.62 130.14,35.03 130.14,34.59 129.61,34.06 129.61,33.95 129.33,33.67 129.33,31.4 129.91,30.82 129.91,21.61
  T10 w0.097: v3(131.03,9.56) 130.4,10.19 130.4,21.12 129.91,21.61
CPLD_PIRQG_L_GPIO4: length 112.8
  TOP w0.109: U31.M16 46.58,33.73 v1(46.58,33.05)
  T05 w0.097: v3(128.75,4.97) 128.47,4.68 126.41,4.68 125.53,5.57 125.53,11.61 122.97,14.17 98.07,14.17 97.02,13.12 96.84,12.94 91.27,12.94 87.17,17.04 79.63,17.04 78.04,18.64 69.35,18.64 68.15,19.83 54.97,19.83 53.42,18.28 47.52,18.28 46.48,19.32 46.48,31.89 46.58,31.99 v1(46.58,33.05)
  BOTTOM w0.109: v3(128.75,4.97) 128.75,3.6 129.04,3.31 R42.2 130.59,3.31 v2(131.03,3.75)
CPLD_PIRQG_L_GPIO4_R: length 39.2
  TOP w0.109: v3(129.74,5.22) 129.74,5.15 129.51,4.91 R440.2
  TOP w0.152: v1(131.21,37.55) U1.BL22
  T10 w0.089: 128.11,21.61 128.08,21.64 128.08,30.73 127.73,31.08 127.73,32.13 127.34,32.52 127.34,33.41 127.66,33.73 127.98,33.73 128.03,33.69 128.29,33.69 128.62,34.02 128.62,34.86 128.82,35.06 128.82,36.02 129.12,36.32 129.12,36.63 129.64,37.16 130.81,37.16 v1(131.21,37.55)
  T10 w0.097: 128.11,21.61 128.49,21.22 128.49,6.26 129.57,5.18 129.7,5.18 v3(129.74,5.22)
  BOTTOM w0.109: R440.2 129.51,4.99 v3(129.74,5.22)
CPLD_PIRQH_L_GPIO5: length 124.1
  TOP w0.109: v3(138.65,1.98) 136.64,1.98 136.4,2.23 136.4,5.22 135.66,5.96 126.44,5.96 125.27,7.13 125.27,11.22 123.01,13.48 96.65,13.48 95.35,14.77 91.26,14.77 90.81,15.23 87.35,15.23 86.82,15.76 v3(86.82,16.48) ; U31.M15 v1(46.15,34.3)
  T05 w0.097: v1(46.15,34.3) 46.15,18.59 46.76,17.98 53.54,17.98 55.03,19.47 67.74,19.47 68.09,19.47 69.23,18.34 77.91,18.34 79.87,16.38 83.02,16.38 84.02,15.38 86.21,15.38 86.82,15.99 v3(86.82,16.48)
  BOTTOM w0.109: R41.2 v3(138.65,1.98)
CPLD_PIRQH_L_GPIO5_R: length 39.3
  TOP w0.109: R439.2 v3(138.65,5.24)
  TOP w0.152: U1.BW22 v1(134.67,38.4)
  T03 w0.089: 134.78,21.61 134.78,28.68 135.06,28.97 135.06,31.76 134.78,32.04 134.78,32.55 135.06,32.83 135.06,33.41 134.78,33.69 134.78,34.27 135.06,34.55 135.06,35.13 134.78,35.41 134.78,35.99 135.06,36.27 135.06,36.85 134.67,37.23 v1(134.67,38.4)
  T03 w0.097: 134.78,21.61 134.78,21.19 136.59,19.37 136.59,13.14 138.02,11.72 138.02,11.28 139.17,10.13 139.17,8.93 138.22,7.99 138.22,5.67 v3(138.65,5.24)
  BOTTOM w0.109: R439.2 v3(138.65,5.24)
CPLD_PLTRST_L_LATCH: length 15.6
  TOP w0.109: U31.E1 v1(53.64,49.39)
  T08 w0.097: v1(53.64,49.39) 53.47,49.56 53.47,53.31 52.28,54.5 51.77,54.5 49.89,56.37 47.26,56.37 v3(46.7,56.93)
  BOTTOM w0.109: U30.15 45.36,56.29 46.07,56.29 v3(46.7,56.93) ; v2(53.64,50.44) v1(53.64,49.39)
CPLD_PROCHOT_L_LATCH: length 18.8
  TOP w0.109: U31.F2 v1(53.13,48.28)
  T08 w0.097: v1(53.13,48.28) 53.13,50.58 51.91,51.8 v3(51.91,54.01)
  BOTTOM w0.109: v3(51.91,54.01) 54.58,54.01 55.34,54.77 55.34,56.78 55,57.12 55,57.62 54.01,58.61 53.53,58.61 51.91,60.23 U30.4
CPLD_RTCRST_L: length 176.5
  TOP w0.089: 50.28,32.8 50.06,33.01 50.06,36.37 U31.J13
  TOP w0.109: R314.1 194.21,13.73 172.78,13.73 172.27,14.24 157.02,14.24 154.09,11.31 146.56,11.31 143.65,11.31 143.38,11.58 139.47,11.58 138.49,10.6 126.86,10.6 123.35,14.1 97.01,14.1 95.58,15.54 92.05,15.54 89.92,17.67 89.92,23.51 v3(90.81,24.4) ; v3(86.74,23.64) 85.78,22.67 v2(83.08,22.67) 81.46,22.67 78.61,19.83 51.49,19.83 50.19,21.12 50.19,28.24 50.75,28.79 50.75,32.33 50.28,32.8
  T08 w0.097: v3(90.81,24.4) 90.17,25.03 88.26,25.03 86.87,23.64 v3(86.74,23.64)
CPLD_THERMTRIP_L_LATCH: length 20.5
  TOP w0.109: U31.F3 v1(53.13,47.28)
  T08 w0.097: v1(53.13,47.28) 53.13,47.32 49.32,51.14 49.32,54.24 48.13,55.44 46.4,55.44 45.64,56.2 45.64,57.89 v3(43.99,59.55)
  BOTTOM w0.109: v3(43.99,59.55) 45.3,59.55 U30.20 ; v1(53.13,47.28) 52.93,47.28 v2(52.07,48.15)
CPLD_VRHOT_L: length 7.8
  TOP w0.089: U31.D16 v1(55.13,33.3) 55.13,32.8
  TOP w0.109: 55.13,32.8 55.13,32.5 55.78,31.86 55.78,27.49 U33.4
  BOTTOM w0.109: v1(55.13,33.3) 55.13,34.14 v2(55.21,34.22)
CPU_BOOT_DONE: length 107.5
  TOP w0.109: J10.B78 94.35,8.82 94.62,9.09 94.62,9.74 94.61,9.74 94.61,10.63 v3(94.96,10.98)
  TOP w0.152: v1(134.67,36.69) 135.11,36.43 U1.BW18
  T10 w0.089: v1(134.67,36.69) 135.03,36.69 135.55,36.17 135.55,35.41 135.28,35.13 135.28,34.67 135.77,34.17 135.77,33.69 136.05,33.41 136.05,32.83 135.77,32.55 135.77,31.98 136.05,31.7 136.05,30.86 136.01,30.82 136.01,23.64 138.05,21.61
  T10 w0.097: 138.05,21.61 141.22,18.43 141.22,10.68 142.03,9.87 142.03,4.98 141.47,4.42 127.99,4.42 126.49,5.91 v3(126.49,6.82)
  BOTTOM w0.089: v2(141.7,36.48) 141.5,36.28 135.15,36.28 134.74,36.69 v1(134.67,36.69)
  BOTTOM w0.109: v3(94.96,10.98) 94.96,13.49 98.98,17.52 102.89,17.52 107.18,13.23 123.01,13.23 124.31,11.93 124.31,9.01 v3(126.49,6.82)
CPU_DCPRTC: length 1.5
  TOP w0.254: U1.AW16 125.44,35.76 v1(125.44,35.77)
  BOTTOM w0.305: C38.1 126.05,35.21 125.49,35.77 v1(125.44,35.77)
CPU_DCPSST: length 4.3
  TOP w0.254: v1(125.43,37.37) U1.AW19
  BOTTOM w0.089: C183.1 128.5,37.25 128.07,36.82 127.79,36.82 127.64,36.96 125.84,36.96 v1(125.43,37.37)
CPU_DCPSUS1: length 1.1
  TOP w0.254: U1.AU16 v1(124.63,35.77)
  BOTTOM w0.305: U1.AU16 v1(124.63,35.77)
CPU_DCPSUS2: length 1.1
  TOP w0.152: U1.AK14 v1(121.43,34.97)
  BOTTOM w0.108: U1.AK14 v1(121.43,34.97)
CPU_DCPSUS3: length 2.6
  TOP w0.33: U1.AP30 v1(123.03,42.17) ; U1.AP28 v1(123.03,41.37)
  BOTTOM w0.381: C181.1 122.96,42.24 v1(123.03,42.17) v1(123.03,41.37)
CPU_DCPSUSBY: length 2.2
  TOP w0.254: U1.AW21 v1(125.43,38.17)
  TOP w0.305: v1(125.43,38.17) U1.AU21
  BOTTOM w0.305: v1(125.43,38.17) 125.43,38.18 125.05,38.57 C179.1
CPU_DIMM_EVENT_CO_L: length 68.3
  TOP w0.109: v1(171.29,50.52) 170.74,50.52 170.34,50.91 170.01,50.91 169.99,50.89 169.99,50.89 169.85,50.75 169.39,50.75 169.25,50.89 169.24,50.9 169.22,50.91 168.89,50.91 168.44,50.46 166.5,50.46 CN2.134
  T03 w0.097: v3(191.13,14.37) 190.47,14.37 190.3,14.54
  T03 w0.102: 190.3,14.54 185.09,19.76 185.09,43.48 185.9,44.29 185.9,48.85 184.88,49.87 184.16,49.87 183.51,50.52 v1(183.03,50.52)
  T05 w0.152: v1(183.03,50.52) 182.66,50.52 182.2,50.05 181.62,50.05 181.55,50.12 181.06,50.12 180.99,50.05 173.47,50.05 172.58,50.93 172.24,50.93 171.82,50.52 v1(171.29,50.52)
  BOTTOM w0.109: v1(183.03,50.52) 183.58,50.52 184.01,50.94 184.31,50.94 184.5,50.75 185.08,50.75 185.42,50.41 CN1.134 ; v3(191.13,14.37) 191.62,13.88 R359.1 194.65,13.88 194.72,13.96 195.88,13.96 195.97,13.87 U32.3
CPU_GPIO44_R: length 26.1
  TOP w0.152: v1(128.73,36.69) 128.67,36.65 U1.BD18
  T08 w0.089: v1(128.73,36.69) 128.76,36.65 128.76,35.17 128.13,34.54 127.94,34.54 127.42,34.01 127.42,34.01 127.19,33.78 127.19,33.78 127.12,33.72 127.12,32.51 126.83,32.22 126.83,31.65 126.93,31.55 126.93,29.51 127.44,29.01 127.44,21.65 127.48,21.61
  T08 w0.097: v3(127.98,19.97) 127.65,20.3 127.65,21.43 127.48,21.61
  BOTTOM w0.109: R49.1 128.75,14.54 128.75,16.74 127.23,18.25 127.23,19.22 v3(127.98,19.97)
CPU_GPIO45_R: length 35.6
  TOP w0.089: U1.BA21 126.28,37.4 126.24,37.4 v1(126.23,37.39)
  T10 w0.089: v1(126.23,37.39) 126.23,37.15 126.64,36.74 126.64,35.63 125.84,34.82 125.84,33.3 125.37,32.84 125.37,32.34 125.64,32.07 125.64,31.42 125.14,30.92 125.14,28.38 125.4,28.12 125.4,27.51 125.18,27.29 125.18,21.61
  T10 w0.097: 125.18,21.61 125.27,21.52 125.27,13.2 126.03,12.45 126.03,9.79 126.03,9.78 126.03,5.67 v3(126.46,5.24)
  BOTTOM w0.109: R48.1 v3(126.46,5.24)
CPU_GPIO46_R: length 40.7
  TOP w0.089: v1(126.25,36.58) 126.25,36.58 U1.BA19
  TOP w0.109: R47.1 107.62,15.76 v3(108.41,16.55)
  T10 w0.089: v1(126.25,36.58) 125.85,36.18 125.3,36.18 125.04,35.91 125.04,35.42 124.24,34.62 124.24,34.02 123.99,33.78 123.22,33.78 122.25,32.81 122.25,32.4 122.12,32.27 120.9,32.27 120.19,31.56 119.56,31.56 119.3,31.31 119.3,29.68 120.28,28.7 120.28,28.58 120.27,28.57 120.27,25.92 119.42,25.08 119.42,23.51 119.27,23.36
  T10 w0.097: v3(108.41,16.55) 109.52,15.43 118.59,15.43 119.25,16.09 119.25,17.67 119,17.92 119,23.09 119.27,23.36
CPU_I2C1_ALERT_L_1V05: length 116.2
  TOP w0.152: U1.AN71 123.29,60.44 v1(123.29,61.03)
  T08 w0.089: 122.99,69.48 122.99,63.95 124.05,62.88 124.05,61.56 123.52,61.03 v1(123.29,61.03)
  T08 w0.097: 122.99,69.48 122.99,69.99 120.27,72.71 118.94,72.71 117.77,73.88 115.95,73.88 114.94,74.9 113.59,74.9 112.98,74.29 106.81,74.29 106.02,75.07 104.42,75.07 103.35,74.01 96.42,74.01 93.75,71.34 90.86,71.34 88.37,73.83 83.16,73.83 80.31,70.98 76.2,70.98 75.49,71.69 74.17,71.69 73.46,70.98 69.88,70.98 68.55,72.3 68.55,73.63 63.27,78.91 56.18,78.91 55.45,78.17 53.42,78.17 51.21,75.96 51.21,74.34 49.86,72.99 46.76,72.99 45.87,73.88 38.91,73.88 38.51,73.47 33.4,73.47 v3(33.25,73.32)
  BOTTOM w0.109: R199.2 v3(33.25,73.32)
CPU_I2C1_ALERT_L_1V05_R: length 12
  BOTTOM w0.109: U11.11 37.37,68.43 37.8,68.85 v2(37.8,71.28) 36.94,71.28 35.71,72.51 R199.1 R198.2
CPU_I2C1_ALERT_L_3V3: length 89.4
  T05 w0.097: v3(38.81,33.11) 39,32.93 39,22.46 40.72,20.74 40.72,18.43 46.6,12.54 60.65,12.54 63.14,10.05 66.04,10.05 v3(66.19,9.9)
  T10 w0.097: v3(38.81,33.11) 38.3,33.62 37.62,33.62 34.67,36.57 34.67,45.99 32.31,48.35 32.31,62.47 31.65,63.14 31.65,65.27 32.31,65.93 v3(32.31,68.14)
  BOTTOM w0.109: J10.A50 66.35,9.74 v3(66.19,9.9) ; U11.6 31.59,68.43 31.88,68.14 v3(32.31,68.14)
CPU_PECI: length 10.4
  TOP w0.089: U1.AL78 122.04,64.86 121.68,65.23
  TOP w0.109: 121.68,65.23 121.68,67.07 121.05,67.71 119.19,67.71 118.76,68.14 R124.2 119.18,69.46 119.27,69.55 119.27,71.24 R105.1
CPU_PRSNT_L: length 96.5
  TOP w0.109: J10.B81 97.35,11.61 95.02,13.94 v2(89.13,13.94) 89.05,14.01 84.66,14.01 v3(84.62,14.05)
  T08 w0.097: v3(15.35,13.35) 19.67,13.35 20.25,12.77 72.59,12.77 73.28,12.08 73.45,11.91 80.13,11.91 82.49,14.27 84.4,14.27 v3(84.62,14.05)
  BOTTOM w0.109: J10.A1 15.62,6.96 15.62,13.08 v3(15.35,13.35)
CPU_PWR_DEBUG_L: length 121.1
  TOP w0.089: v1(114.7,66.29) 115.43,65.56 115.43,63.78 U1.U77
  TOP w0.109: v3(18.38,63.41) 19.21,63.41 R401.2 19.22,64.39 C192.1 19.04,64.4 17.52,65.92 17.52,67.44 14.06,70.9 14.06,73.06 13.76,73.36 J12.45
  T08 w0.089: 114.7,66.3 v1(114.7,66.29)
  T08 w0.097: v3(18.38,63.41) 19.91,64.93 26.13,64.93 26.78,65.58 40.55,65.58 41.66,66.68 42.24,66.68 43.05,67.5 48.53,67.5 49.2,66.82 63.29,66.82 63.68,66.43 70.07,66.43 70.47,66.03 77.19,66.03 77.24,65.98 81.89,65.98 83.21,67.3 96.62,67.3 96.64,67.28 103.21,67.28 106.29,70.37 111.65,70.37 114.32,67.7 114.32,66.69 114.7,66.3
CPU_RSVD95: length 5.8
  TOP w0.089: U1.A76 107.29,63.57 107.29,65.9 107.7,66.31
  TOP w0.109: 107.7,66.31 v2(108.22,66.83) 108.22,67.68 R168.1
CPU_THERMTRIP_L: length 10.6
  TOP w0.152: U1.AU9 v1(124.26,31.81)
  T10 w0.089: v1(124.26,31.81) 124.08,31.81 122.45,30.19 122.45,25.34 121.9,24.78 121.39,24.78 120.85,24.24 v3(120.85,23.66)
CPU_THROTTLE_L: length 85.7
  TOP w0.089: v1(132.47,27.09) 132.44,27.12 U1.BN2
  TOP w0.109: U17.2 R177.2 67.44,43.96 67.94,43.45 v3(68.05,43.45)
  T03 w0.097: v3(68.05,43.45) 68.19,43.31 76.02,43.31 81.42,37.91 81.42,32.45 83.61,30.26 83.61,29.81 v3(89.14,24.27)
  T05 w0.089: 119.27,24.14 119.98,24.85 121.98,24.85 122.55,25.41 124.21,25.41 124.51,25.72 128.45,25.72 129.83,27.1 132.47,27.1 v1(132.47,27.09) ; 105.98,26.3 106.41,26.73 108.03,26.73 108.45,26.3
  T05 w0.097: 119.27,24.14 115.51,24.14 115.32,24.33 115.14,24.5 112.27,24.5 112.02,24.26 109.86,24.26 108.62,25.5 108.62,25.74 108.62,25.74 108.62,26.14 108.45,26.3 ; 105.98,26.3 105.73,26.05 96.9,26.05 94.44,23.59 89.83,23.59 v3(89.14,24.27)
  BOTTOM w0.109: v3(68.05,43.45) 67.91,43.31 v2(66.97,43.31)
CPU_THROTTLE_L_R: length 4.5
  TOP w0.089: U31.A4 58.77,45.79
  TOP w0.109: 58.77,45.79 58.86,45.79 v3(59.12,45.52) 59.46,45.86 R211.2
CPU_THROTTLE_R1_L: length 4.8
  TOP w0.109: U17.4 62.75,44.61 R210.2 62.64,45.76 R211.1 63.17,45.86 63.81,46.5 v3(64.77,46.5)
CPU_UART0_RXD_1V05: length 67.6
  TOP w0.089: U1.AG77 120.78,63.6 121.43,64.26 121.43,64.84 121,65.27
  TOP w0.109: 121,65.27 121,66.1 120.59,66.52 v1(120.57,66.52)
  T08 w0.097: v3(84.58,32.69) 84.61,32.69 84.77,32.85 87.76,32.85 88.09,33.18 88.09,34.32 90.4,36.63 93.18,36.63 93.68,36.63 98.04,41 98.44,41.4 98.44,45.16 99.8,46.52 100.8,46.52 106.12,46.52 107.97,48.36 107.97,59.28 108.36,59.67 108.36,59.77 111.56,62.97 119.44,62.97 120.93,64.47 120.93,66.15 v1(120.57,66.52)
  BOTTOM w0.109: R112.2 83.77,33.56 84.58,32.75 84.58,32.69 v3(84.58,32.69) 84.55,32.66 84.53,32.66 83.59,31.72 R456.1
CPU_UART0_RXD_3V3: length 119.9
  TOP w0.109: J2.3 v3(146.98,7.55)
  T05 w0.097: v3(146.98,7.55) 146.98,6.53 146.43,5.99 141.3,5.99 139.05,3.74 126.02,3.74 124.49,5.27 124.49,11.38 122.59,13.27 98.85,13.27 97.1,11.52 94.36,11.52 93.73,10.89 89.51,10.89 89.01,10.39 82.59,10.39 81.74,11.24 73.15,11.24 v3(72.35,10.44)
  BOTTOM w0.109: U8.7 73.57,30.8 73.04,31.33 v2(72.62,31.33) 71.95,31.33 70.82,30.19 70.82,29.35 69.06,27.6 69.06,23.06 69.65,22.47 69.65,11.21 70.2,10.66 72.13,10.66 v3(72.35,10.44) J10.A56
CPU_UART0_TXD_1V05: length 66
  TOP w0.152: U1.AG75 v1(120.54,61.82)
  T08 w0.089: 105.55,46.22 106.09,46.22 108.16,48.29 108.16,59.2 111.43,62.47 119.89,62.47 v1(120.54,61.82)
  T08 w0.097: 105.55,46.22 99.93,46.22 98.74,45.03 98.74,41.23 93.98,36.47 93.98,32.94 91.9,30.85 88.72,30.85 87.66,29.78 v3(87.66,29.28)
  BOTTOM w0.089: R274.1 120.82,62.1 v1(120.54,61.82)
  BOTTOM w0.102: R268.2 120.46,63.02 120.82,62.66 R274.1
  BOTTOM w0.109: v3(87.66,29.28) 87.03,29.91 86.12,29.91 85.72,29.51 85.72,28.97 85.34,28.59 84.71,28.59 83.69,29.61 R454.1
CPU_UART0_TXD_3V3: length 106.3
  TOP w0.109: J2.2 v3(146.05,6.62)
  T05 w0.097: v3(72.34,11.59) 81.84,11.59 82.74,10.69 88.89,10.69 89.59,11.39 89.99,11.39 90.35,11.75 93.7,11.75 93.85,11.9 96.88,11.9 98.54,13.57 122.72,13.57 124.79,11.5 124.79,5.4 124.8,5.39 126.14,4.04 138.82,4.04 141.4,6.62 v3(146.05,6.62)
  BOTTOM w0.109: J10.A57 73.35,10.59 v3(72.34,11.59) 72.34,14.39 76.2,18.25 v2(76.2,22.93) R458.2
CPU_UART1_RXD_1V05: length 66.9
  TOP w0.089: v1(120.54,65.86) 120.64,65.76 120.64,65.33 121.05,64.91 U1.AH78
  T08 w0.097: v1(120.54,65.86) 120.54,64.79 118.98,63.23 111.48,63.23 106.94,58.68 106.94,47.71 106.04,46.82 100.92,46.82 99.68,46.82 98.14,45.28 98.14,41.52 97.91,41.3 93.55,36.93 90.28,36.93 87.29,33.94 84.88,33.94 83.99,33.06 83.99,32.33 v3(84.53,31.79)
  BOTTOM w0.109: v2(86.26,31) 86.23,31.03 86.23,31.13 85.58,31.79 v3(84.53,31.79) 84.58,31.74 R111.2 83.62,30.65 R455.1
CPU_UART1_RXD_3V3: length 30.3
  TOP w0.109: v3(71.6,11.61) 71.04,11.05 71.04,8.72 71.35,8.41 J10.B55
  BOTTOM w0.109: U8.6 73.52,30.15 73.34,29.97 72.04,29.97 69.6,27.52 69.6,23.54 v2(70.28,22.86) 70.28,11.41 70.61,11.08 71.07,11.08 v3(71.6,11.61)
CPU_UART1_TXD_1V05: length 76.5
  TOP w0.089: v1(119.91,65.81) 120.37,65.35 120.37,63.93 120.22,63.78 120.22,63.46 120.58,63.11 U1.AH76
  T08 w0.097: v3(86.38,29.28) 85.93,29.28 83.69,31.51 83.69,33.22 84.71,34.24 87.16,34.24 90.15,37.23 93.43,37.23 97.84,41.65 97.84,45.41 99.56,47.12 101.05,47.12 101.05,47.12 106.01,47.12 106.75,47.86 106.75,59.99 108,61.25 109.1,61.25 111.28,63.43 117.53,63.43 v1(119.91,65.81)
  BOTTOM w0.089: R269.2 R275.1 119.21,69.1 119.21,68.23 119.46,67.98 119.46,66.26 v1(119.91,65.81)
  BOTTOM w0.109: v3(86.38,29.28) 86.38,28.99 85.61,28.22 83.96,28.22 R453.1
CPU_UART1_TXD_3V3: length 24.9
  TOP w0.109: J10.B54 70.35,8.34 70.67,8.67 70.67,11.46 v3(70.83,11.62)
  BOTTOM w0.109: R457.2 70.04,27.28 70.04,25.05 v2(71.33,23.77) 71.33,12.11 v3(70.83,11.62)
CPU_VCC_SENSE: length 2.9
  TOP w0.089: v1(134.44,30.75) 134.12,30.43 U1.BT5
  BOTTOM w0.102: v2(134.87,28.68) C182.1 134.87,30.32 v1(134.44,30.75)
DDR4_A_A0: length 63.4
  TOP w0.102: U1.CK49 v1(139.63,50.42)
  T08 w0.089: v1(139.63,50.42) 139.46,50.72 139.48,50.8 arc(139.65,50.82) 139.83,50.77 arc(140.12,50.69) 140.42,50.77 140.42,50.77 arc(140.62,50.82) 140.82,50.77 arc(141.11,50.65) 141.42,50.6 142.44,50.6
  T08 w0.152: 142.44,50.6 143.87,52.02 152.38,52.02 154.26,53.91 155.14,53.91 155.32,54.09 155.32,54.37 155.5,54.55 155.75,54.55 155.93,54.37 155.93,54.09 156.11,53.91 156.36,53.91 156.54,54.09 156.54,54.37 156.72,54.55 156.97,54.55 157.15,54.37 157.15,54.09 157.33,53.91 157.58,53.91 157.76,54.09 157.76,54.37 157.93,54.55 158.19,54.55 158.37,54.37 158.37,54.09 158.54,53.91 158.8,53.91 158.98,54.09 158.98,54.37 159.15,54.55 159.41,54.55 159.58,54.37 159.58,54.09 159.76,53.91 160.02,53.91 160.19,54.09 160.19,54.37 160.37,54.55 160.63,54.55 160.8,54.37 160.8,54.09 160.98,53.91 161.24,53.91 161.41,54.09 161.41,54.37 161.59,54.55 161.84,54.55 162.02,54.37 162.02,54.09 162.2,53.91 162.45,53.91 162.63,54.09 162.63,54.37 162.81,54.55 163.06,54.55 163.24,54.37 163.24,54.09 163.42,53.91 163.67,53.91 163.85,54.09 163.85,54.37 164.03,54.55 164.28,54.55 164.46,54.37 164.46,54.09 164.64,53.91 164.89,53.91 165.07,54.09 165.07,54.37 165.25,54.55 165.5,54.55 165.68,54.37 165.68,54.09 165.86,53.91 166.11,53.91 166.29,54.09 166.29,54.37 166.47,54.55 166.72,54.55 166.9,54.37 166.9,54.09 167.1,53.89 178.64,53.89 178.83,53.71 183.02,53.71 183.44,54.13 184.1,54.13 184.3,53.93 184.3,53.59 v1(183.59,52.88)
  BOTTOM w0.165: CN1.144 185.35,52.91 185.12,53.13 185.12,53.81 185.04,53.9 183.07,53.9 182.93,53.75 182.93,52.8 183.07,52.65 183.36,52.65 v1(183.59,52.88)
DDR4_A_A1: length 58.7
  TOP w0.102: v1(139.63,46.99) 139.88,46.84 U1.CK41
  T08 w0.152: v1(139.63,46.99) 140.02,46.99 140.44,46.57 141.3,46.57 143.73,49 151.14,49 154.08,51.94 163.59,51.94 163.77,52.12 163.77,52.72 163.95,52.9 164.2,52.9 164.38,52.72 164.38,52.12 164.56,51.94 164.81,51.94 164.99,52.12 164.99,52.72 165.17,52.9 165.42,52.9 165.6,52.72 165.6,52.12 165.78,51.94 166.03,51.94 166.21,52.12 166.21,52.72 166.39,52.9 166.64,52.9 166.82,52.72 166.82,52.12 167,51.94 167.35,51.94 167.75,51.55 168.14,51.55 168.41,51.82 168.57,51.82 168.91,51.48 169.19,51.48 169.41,51.71 169.82,51.71 170,51.53 170.4,51.53 170.58,51.71 170.86,51.71 171.14,51.43 171.42,51.43 171.65,51.66 172,51.66 172.29,51.38 172.51,51.38 173.18,52.05 173.7,52.05 173.88,51.87 173.88,51.72 174.05,51.55 174.31,51.55 174.49,51.72 174.49,51.87 174.66,52.05 174.92,52.05 175.09,51.87 175.09,51.72 175.27,51.55 175.53,51.55 175.7,51.72 175.7,51.87 175.88,52.05 176.14,52.05 176.31,51.87 176.31,51.72 176.49,51.55 176.74,51.55 176.92,51.72 176.92,51.87 177.1,52.05 177.35,52.05 177.53,51.87 177.53,51.72 177.71,51.55 177.96,51.55 178.14,51.72 178.14,51.87 178.32,52.05 178.64,52.05 180.17,50.52 v1(180.79,50.52)
  BOTTOM w0.109: CN1.133 179,50.16 179.25,50.42 179.39,50.42 179.56,50.25 179.56,49.15 179.65,49.07 179.89,49.07 179.98,49.15 179.98,49.36 180.42,49.8 180.42,49.96 179.96,50.42 179.96,50.62 180.08,50.74 180.57,50.74 v1(180.79,50.52)
DDR4_A_A2: length 58.6
  TOP w0.102: v1(140.62,46.99) U1.CM41
  T03 w0.102: 142.57,48.92 142.57,48.36 141.69,47.48 140.96,47.33 v1(140.62,46.99)
  T03 w0.152: 142.57,48.92 144.49,50.84 159.3,50.84 159.78,51.32 162.7,51.32 162.83,51.45 162.83,51.83 162.7,51.96 161.05,51.96 160.93,52.09 160.93,52.34 161.1,52.52 168.23,52.52 168.32,52.43 168.68,52.43 168.76,52.52 169.29,52.52 169.47,52.33 169.8,52.33 169.99,52.51 170.39,52.51 170.57,52.33 170.91,52.33 171.09,52.51 171.56,52.51 171.71,52.36 172.06,52.36 172.22,52.52 172.65,52.52 172.84,52.33 173.18,52.33 173.94,51.57 173.94,50.39 174.49,49.83 175.89,49.83 176.14,50.08 181.09,50.08 181.16,50.15 181.62,50.15 181.71,50.06 182.22,50.06 182.29,50.13 182.67,50.13 v1(183.59,49.65)
  BOTTOM w0.109: CN1.132 185.22,49.91 185.09,49.78 185.09,49.3 184.99,49.2 184.25,49.2 184.14,49.31 184.14,49.94 183.82,50.25 183.37,50.25 183.22,50.11 182.96,50.11 182.87,50.02 182.87,49.73 182.95,49.65 v1(183.59,49.65)
DDR4_A_A3: length 60.7
  TOP w0.102: U1.CF41 v1(137.64,46.99)
  T03 w0.102: 142.97,48.71 142.97,48.28 141.87,47.18 141.3,47.06 140.8,46.55 140.44,46.55
  T03 w0.152: 142.97,48.71 144.59,50.33 159.66,50.33 160.01,50.69 165.5,50.69 165.62,50.82 165.62,51.2 165.5,51.32 163.72,51.32 163.59,51.45 163.59,51.83 163.72,51.96 167.15,51.96 167.74,51.36 168.02,51.36 168.28,51.63 168.76,51.63 168.96,51.43 169.18,51.43 169.52,51.76 169.74,51.76 170.07,51.43 170.3,51.43 170.62,51.75 170.84,51.75 171.2,51.39 171.42,51.39 171.76,51.73 171.99,51.73 172.3,51.42 172.57,51.42 172.78,51.62 173.16,51.62 173.44,51.35 173.44,49.74 173.92,49.26 175.78,49.26 176.28,49.77 181.24,49.77 v1(181.35,49.65)
  T03 w0.159: 140.44,46.55 140.39,46.6 139.86,46.6 139.81,46.55 139.45,46.55 139.37,46.63 138.89,46.63 138.82,46.55 138.45,46.55 138.31,46.7 v1(137.64,46.99)
  BOTTOM w0.109: CN1.131 179.1,49.66 179.25,49.52 179.25,48.88 179.38,48.75 179.73,48.75 179.82,48.84 180.26,48.84 180.39,48.97 180.39,49.4 181.15,50.16 181.61,50.16 181.72,50.05 181.72,49.74 181.64,49.65 v1(181.35,49.65)
DDR4_A_A4: length 60.1
  TOP w0.089: U1.CL39 v1(140.12,46.13)
  T03 w0.102: v1(140.12,46.13) 140.85,46.13 141.47,46.76 142.01,46.86 143.35,48.2 143.35,48.48
  T03 w0.152: 143.35,48.48 144.82,49.95 151.05,49.95 151.18,49.82 166.89,49.82 167.02,49.95 167.02,50.56 166.89,50.69 166.26,50.69 166.13,50.82 166.13,51.2 166.26,51.32 167.02,51.32 168.32,50.03 169.21,50.03 169.36,50.18 169.8,50.18 170.05,49.93 170.3,49.93 170.55,50.18 170.99,50.18 171.25,49.93 171.42,49.93 171.62,50.13 172.08,50.13 172.19,50.02 172.9,50.02 173.12,49.8 173.12,49.26 173.46,48.92 175.81,48.92 176.54,48.19 178.77,48.19 178.93,48.34 178.93,48.66 178.77,48.82 176.55,48.82 176.39,48.98 176.39,49.27 176.58,49.46 180.35,49.46 v1(180.79,49.02)
  BOTTOM w0.109: CN1.128 183.7,48.91 183.19,49.42 182.86,49.42 182.63,49.18 182.31,49.18 182.08,49.42 181.74,49.42 181.45,49.12 181.1,49.02 v1(180.79,49.02)
DDR4_A_A5: length 61.6
  TOP w0.102: U1.CG39 v1(138.14,46.13)
  T08 w0.089: v1(138.14,46.13) 138.9,45.8 138.93,45.78 arc(139.14,45.58) 139.23,45.29 139.23,45.26 arc(139.43,44.92) 139.83,44.93 arc(140.12,45) 140.42,44.93 140.42,44.92 arc(140.62,44.87) 140.82,44.93 arc(140.95,44.98) 141.09,45 141.34,45.25
  T08 w0.152: v1(181.35,48.15) 181.3,48.2 180.33,48.2 178.63,49.89 178.25,49.89 178.07,49.71 178.07,49.68 177.9,49.51 177.64,49.51 177.46,49.68 177.46,49.71 177.29,49.89 177.03,49.89 176.86,49.71 176.86,49.68 176.68,49.51 176.42,49.51 176.25,49.68 176.25,49.71 176.07,49.89 175.81,49.89 175.64,49.71 175.64,49.68 175.46,49.51 175.21,49.51 175.03,49.68 175.03,49.71 174.85,49.89 174.6,49.89 174.42,49.71 174.42,49.68 174.24,49.51 173.99,49.51 173.81,49.68 173.81,49.71 173.63,49.89 172.89,49.89 172.2,49.19 171.73,49.19 171.69,49.23 171.68,49.23 171.49,49.42 171.48,49.42 171.47,49.43 171.12,49.43 171.1,49.42 171.09,49.42 170.91,49.23 170.56,49.23 170.33,49.46 170.02,49.46 169.79,49.23 169.78,49.23 169.72,49.18 169.51,49.18 169.45,49.23 169.44,49.23 169.25,49.42 169.24,49.42 169.23,49.43 167.83,49.43 167.65,49.61 167.65,49.76 167.47,49.94 167.22,49.94 167.04,49.76 167.04,49.61 166.86,49.43 166.61,49.43 166.43,49.61 166.43,49.76 166.25,49.94 166,49.94 165.82,49.76 165.82,49.61 165.64,49.43 165.39,49.43 165.21,49.61 165.21,49.76 165.03,49.94 164.78,49.94 164.6,49.76 164.6,49.61 164.42,49.43 164.17,49.43 163.99,49.61 163.99,49.76 163.82,49.94 163.56,49.94 163.38,49.76 163.38,49.61 163.21,49.43 162.95,49.43 162.77,49.61 162.77,49.76 162.6,49.94 162.34,49.94 162.17,49.76 162.17,49.61 161.99,49.43 161.73,49.43 161.56,49.61 161.56,49.76 161.38,49.94 161.12,49.94 160.95,49.76 160.95,49.61 160.77,49.43 160.51,49.43 160.34,49.61 160.34,49.76 160.16,49.94 159.91,49.94 159.73,49.76 159.73,49.61 159.55,49.43 159.3,49.43 159.12,49.61 159.12,49.76 158.94,49.94 158.69,49.94 158.51,49.76 158.51,49.61 158.33,49.43 158.08,49.43 157.9,49.61 157.9,49.76 157.72,49.94 157.47,49.94 157.29,49.76 157.29,49.61 157.11,49.43 156.86,49.43 156.68,49.61 156.68,49.76 156.5,49.94 156.25,49.94 156.07,49.76 156.07,49.61 155.89,49.43 155.64,49.43 155.46,49.61 155.46,49.76 155.28,49.94 155.03,49.94 154.85,49.76 154.85,49.61 154.67,49.43 153.57,49.43 152.16,48.03 144.53,48.03 141.76,45.25 141.34,45.25
  BOTTOM w0.109: CN1.126 185.39,48.41 185.11,48.69 184.25,48.69 183.99,48.43 183.99,47.98 183.77,47.75 183.42,47.75 183.25,47.92 182.81,47.92 182.64,47.75 182.24,47.75 182.08,47.91 181.59,47.91 v1(181.35,48.15)
DDR4_A_A6: length 60.8
  TOP w0.102: U1.CK37 v1(139.63,45.27)
  T08 w0.152: v1(183.03,49.02) 182.67,49.02 182.16,48.51 181.73,48.51 181.5,48.74 181.15,48.74 180.95,48.53 180.64,48.53 180.19,48.99 180.19,49.51 179.28,50.42 178.17,50.42 177.99,50.6 177.99,50.82 177.82,51 177.56,51 177.39,50.82 177.39,50.6 177.21,50.42 176.95,50.42 176.78,50.6 176.78,50.82 176.6,51 176.34,51 176.17,50.82 176.17,50.6 175.99,50.42 175.73,50.42 175.56,50.6 175.56,50.82 175.38,51 175.13,51 174.95,50.82 174.95,50.6 174.77,50.42 174.52,50.42 174.34,50.6 174.34,50.82 174.16,51 173.91,51 173.73,50.82 173.73,50.6 173.55,50.42 173.11,50.42 172.59,50.94 172.24,50.94 172.03,50.73 171.68,50.73 171.47,50.93 171.12,50.93 170.87,50.69 170.59,50.69 170.35,50.93 170,50.93 169.48,50.41 169.48,50.34 169.23,50.1 168.88,50.1 168.64,50.34 168.64,50.54 168.49,50.69 167.74,50.69 167.25,51.18 166.19,51.18 166.01,51.01 166.01,50.95 165.83,50.77 165.58,50.77 165.4,50.95 165.4,51.01 165.22,51.18 164.97,51.18 164.79,51.01 164.79,50.95 164.61,50.77 164.36,50.77 164.18,50.95 164.18,51.01 164,51.18 163.75,51.18 163.57,51.01 163.57,50.95 163.39,50.77 163.14,50.77 162.96,50.95 162.96,51.01 162.78,51.18 162.53,51.18 162.35,51.01 162.35,50.95 162.17,50.77 161.92,50.77 161.74,50.95 161.74,51.01 161.57,51.18 161.31,51.18 161.13,51.01 161.13,50.95 160.96,50.77 160.7,50.77 160.52,50.95 160.52,51.01 160.35,51.18 160.09,51.18 159.91,51.01 159.91,50.95 159.74,50.77 159.48,50.77 159.31,50.95 159.31,51.01 159.13,51.18 158.87,51.18 158.7,51.01 158.7,50.95 158.52,50.77 158.26,50.77 158.09,50.95 158.09,51.01 157.91,51.18 157.66,51.18 157.48,51.01 157.48,50.95 157.3,50.77 157.05,50.77 156.87,50.95 156.87,51.01 156.69,51.18 154.24,51.18 153.33,50.27 153.33,50.22 151.62,48.51 144.11,48.51 141.52,45.92 140.61,45.92 140.18,45.49 139.84,45.49 v1(139.63,45.27)
  BOTTOM w0.109: CN1.127 179.12,48.66 179.35,48.43 179.77,48.43 179.92,48.58 180.92,48.58 181.1,48.76 181.6,48.76 181.75,48.62 182.08,48.62 182.22,48.76 182.72,48.76 v1(183.03,49.02)
DDR4_A_A7: length 62.5
  TOP w0.102: U1.CD39 v1(137.15,46.13)
  T03 w0.089: v1(137.15,46.13) 137.91,45.8 137.94,45.78 arc(138.14,45.73) 138.34,45.78 arc(138.63,45.86) 138.93,45.78 arc(139.13,45.73) 139.33,45.78 arc(139.63,45.86) 139.92,45.78 arc(140.12,45.73) 140.32,45.78 140.32,45.79 140.68,45.79
  T03 w0.102: 171.73,49.19 171.45,49.47 171.17,49.47 170.89,49.19 170.61,49.19 170.33,49.47 170.02,49.47 169.74,49.19 169.46,49.19 169.19,49.47 168.26,49.47 ; 144.62,48.99 142.19,46.56 141.65,46.45 140.99,45.79 140.68,45.79
  T03 w0.152: v1(183.03,47.52) 183.03,48.43 182.85,48.61 182.29,48.61 182.08,48.4 181.81,48.4 181.61,48.61 181.15,48.61 180.94,48.4 180.1,48.4 179.98,48.53 179.98,48.78 179.77,48.99 179.53,48.99 179.35,48.81 179.35,47.98 179.18,47.81 176.32,47.81 175.61,48.52 173.26,48.52 172.59,49.19 171.73,49.19 ; 144.62,48.99 151.26,48.99 151.59,49.32 164.33,49.32 164.48,49.16 164.48,48.66 164.61,48.53 164.86,48.53 164.99,48.66 164.99,49.16 165.14,49.32 165.34,49.32 165.5,49.16 165.5,48.4 165.62,48.28 165.88,48.28 166.01,48.4 166.01,49.16 166.16,49.32 166.39,49.32 166.51,49.19 166.51,48.4 166.64,48.28 166.89,48.28 167.02,48.4 167.02,49.16 167.17,49.32 168.1,49.32 168.26,49.47
  BOTTOM w0.109: v1(183.03,47.52) 182.72,47.52 182.57,47.37 182.57,47.19 182.75,47.01 183.26,47.01 183.54,47.29 183.79,47.29 184.07,47.01 184.37,47.01 184.63,47.26 184.63,47.92 184.78,48.08 185.06,48.08 185.17,47.97 185.17,47.56 185.32,47.41 CN1.122
DDR4_A_A8: length 61.4
  TOP w0.089: U1.CM37 v1(140.62,45.27)
  T03 w0.102: 144.62,48.51 142.37,46.26 141.87,46.16 141.11,45.41 140.75,45.41 v1(140.62,45.27)
  T03 w0.152: v1(183.59,48.15) 184.16,48.73 184.41,48.73 184.76,48.38 184.76,47.26 184.4,46.91 184.07,46.91 183.79,47.19 183.43,47.19 183.28,47.04 182.82,47.04 182.55,47.31 182.55,47.47 182.33,47.69 182.33,47.69 182.08,47.93 181.74,47.93 181.54,47.73 181.18,47.73 180.94,47.98 180.34,47.98 179.8,47.44 176.09,47.44 175.41,48.13 173.02,48.13 172.31,48.84 171.9,48.84 171.42,48.35 171.19,48.35 170.76,48.78 170.58,48.78 170.37,48.57 169.9,48.57 169.69,48.78 169.46,48.78 169.18,48.51 168.65,48.51 167.91,47.77 164.1,47.77 163.97,47.89 163.97,48.66 163.85,48.78 163.63,48.78 163.47,48.62 163.47,47.89 163.34,47.77 163.08,47.77 162.96,47.89 162.96,48.66 162.83,48.78 162.58,48.78 162.45,48.66 162.45,48.02 162.32,47.89 162.07,47.89 161.94,48.02 161.94,48.66 161.81,48.78 151.93,48.78 151.65,48.51 144.62,48.51
  BOTTOM w0.109: CN1.125 179.04,48.16 179.1,48.22 180.85,48.22 181.19,48.55 181.52,48.55 181.66,48.41 181.66,48.41 181.73,48.34 182.09,48.34 182.16,48.41 182.31,48.55 183.19,48.55 v1(183.59,48.15)
DDR4_A_A9: length 58.8
  TOP w0.089: U1.CJ35 v1(139.13,44.41)
  T08 w0.089: 141.81,44.35 141.3,44.06 arc(141.1,44.01) 140.91,44.07 arc(140.62,44.15) 140.33,44.07 140.32,44.07 arc(140.12,44.01) 139.92,44.07 139.89,44.08 v1(139.13,44.41)
  T08 w0.152: v1(180.79,47.52) 180.6,47.33 179.61,47.33 179.43,47.5 179.43,47.68 179.25,47.86 179,47.86 178.82,47.68 178.82,47.5 178.64,47.33 178.39,47.33 178.21,47.5 178.21,47.68 178.03,47.86 177.78,47.86 177.6,47.68 177.6,47.5 177.42,47.33 177.17,47.33 176.99,47.5 176.99,47.68 176.81,47.86 176.56,47.86 176.38,47.68 176.38,47.5 176.2,47.33 175.95,47.33 175.77,47.5 175.77,47.68 175.59,47.86 175.34,47.86 175.16,47.68 175.16,47.5 174.98,47.33 174.73,47.33 174.55,47.5 174.55,47.68 174.37,47.86 174.12,47.86 173.94,47.68 173.94,47.5 173.76,47.33 173.23,47.33 172.66,47.9 172.26,47.9 172.1,47.73 172.03,47.73 172.03,47.73 171.68,47.73 171.68,47.73 171.67,47.73 171.47,47.93 171.12,47.93 170.88,47.7 170.59,47.7 170.35,47.93 170,47.93 169.8,47.73 169.44,47.73 169.2,47.98 167.56,47.98 166.92,47.33 166.36,47.33 166.18,47.51 166.18,47.78 166,47.96 165.75,47.96 165.57,47.78 165.57,47.51 165.39,47.33 165.14,47.33 164.96,47.51 164.96,47.78 164.78,47.96 164.53,47.96 164.35,47.78 164.35,47.51 164.17,47.33 163.92,47.33 163.74,47.51 163.74,47.78 163.56,47.96 163.31,47.96 163.13,47.78 163.13,47.51 162.95,47.33 162.7,47.33 162.52,47.51 162.52,47.78 162.34,47.96 162.09,47.96 161.91,47.78 161.91,47.51 161.74,47.33 161.48,47.33 161.3,47.51 161.3,47.78 161.13,47.96 160.87,47.96 160.69,47.78 160.69,47.51 160.52,47.33 160.26,47.33 160.08,47.51 160.08,47.78 159.91,47.96 159.65,47.96 159.48,47.78 159.48,47.51 159.3,47.33 153.27,47.33 152.26,46.32 144.83,46.32 142.85,44.35 141.81,44.35
  BOTTOM w0.109: v1(180.79,47.52) 180.64,47.52 180.49,47.36 180.49,46.71 180.32,46.55 180.11,46.55 179.98,46.68 179.98,47.51 180.04,47.58 180.04,47.9 179.95,47.99 179.65,47.99 179.56,47.9 179.56,46.98 179.47,46.89 179.34,46.89 179.07,47.16 CN1.121
DDR4_A_A10: length 62.7
  TOP w0.102: U1.CJ51 v1(139.13,51.28)
  T08 w0.089: v1(139.13,51.28) 139.3,50.99 139.39,50.96 arc(139.66,51.01) 139.92,50.94 arc(140.12,50.88) 140.32,50.94 140.33,50.94 arc(140.62,51.01) 140.91,50.94 arc(141.02,50.89) 141.13,50.88 141.84,50.88
  T08 w0.152: 141.84,50.88 143.47,52.52 151.94,52.52 154.5,55.07 159.32,55.07 159.5,55.25 159.5,55.61 159.68,55.79 159.93,55.79 160.11,55.61 160.11,55.25 160.29,55.07 160.54,55.07 160.72,55.25 160.72,55.61 160.9,55.79 161.15,55.79 161.33,55.61 161.33,55.25 161.51,55.07 161.76,55.07 161.94,55.25 161.94,55.61 162.12,55.79 162.37,55.79 162.55,55.61 162.55,55.25 162.73,55.07 162.98,55.07 163.16,55.25 163.16,55.61 163.34,55.79 163.59,55.79 163.77,55.61 163.77,55.25 163.95,55.07 164.2,55.07 164.38,55.25 164.38,55.61 164.56,55.79 164.81,55.79 164.99,55.61 164.99,55.25 165.17,55.07 165.42,55.07 165.6,55.25 165.6,55.61 165.78,55.79 166.03,55.79 166.21,55.61 166.21,55.25 166.39,55.07 166.98,55.07 167.65,54.41 172.49,54.41 173.16,55.07 174.2,55.07 174.38,54.9 174.38,54.46 174.55,54.28 174.81,54.28 174.99,54.46 174.99,54.9 175.16,55.07 176.71,55.07 176.89,54.9 176.89,54.44 177.07,54.26 177.32,54.26 177.5,54.44 177.5,54.9 177.68,55.07 178.31,55.07 179.32,54.07 182.53,54.07 183.03,54.57 183.03,55.08 v1(183.03,55.52)
  BOTTOM w0.109: 185.13,55.18 185.36,55.41 CN1.146
  BOTTOM w0.165: 185.13,55.18 185.13,55.05 185.5,54.68 185.5,54.48 185.32,54.3 184.63,54.3 184.52,54.41 184.21,54.41 184.11,54.3 183.12,54.3 183.03,54.39 v1(183.03,55.52)
DDR4_A_A11: length 58.3
  TOP w0.102: U1.CG35 v1(138.14,44.41)
  T03 w0.089: v1(138.14,44.41) 138.99,44.8 139.14,44.82 140.61,44.87 arc(140.72,44.88) 140.82,44.93 141.67,45.41 142.02,45.76 142.64,46.07 142.88,46.26
  T03 w0.102: 168.74,47.97 169.22,47.97 169.47,47.71 169.76,47.71 169.95,47.9 169.98,47.9 170.05,47.97 170.3,47.97 170.36,47.91 170.38,47.91 170.59,47.71 170.9,47.71 171.16,47.96 171.44,47.96 171.7,47.7 ; 143.7,46.95 142.88,46.26
  T03 w0.152: 168.74,47.97 168.03,47.26 161.56,47.26 161.43,47.39 161.43,48.15 161.31,48.28 161.09,48.28 160.98,48.17 160.98,47.44 160.8,47.26 160.54,47.26 160.42,47.39 160.42,48.15 160.29,48.28 160.04,48.28 159.91,48.15 159.91,47.64 159.78,47.51 159.53,47.51 159.4,47.64 159.4,48.15 159.27,48.28 159.15,48.28 152.16,48.28 151.91,48.03 145.26,48.03 144.9,47.96 143.7,46.95 ; 171.7,47.7 175.61,47.07 180.89,47.07 181.05,47.09 181.53,47.09 181.85,46.78 182.05,46.49 182.05,46.48 182.3,46.23 182.64,46.23 182.65,46.24 182.66,46.24 182.85,46.43 182.9,46.48 182.9,46.48 v1(183.59,46.65)
  BOTTOM w0.109: CN1.120 185.39,46.91 185.17,47.13 184.92,47.13 184.81,47.02 184.81,46.83 185.06,46.58 185.06,46.58 185.17,46.48 185.17,46.29 185.08,46.2 185.05,46.2 184.96,46.11 184.96,46.03 184.84,45.92 184.62,45.92 184.53,46.01 184.53,46.69 184.44,46.78 184.18,46.78 184.09,46.69 184.09,46.15 184.01,46.06 183.88,46.06 183.59,46.36 v1(183.59,46.65)
DDR4_A_A12: length 60.5
  TOP w0.102: U1.CF37 v1(137.64,45.27)
  T08 w0.089: 141.42,44.79 141.14,44.81 arc(141.02,44.8) 140.91,44.76 arc(140.62,44.68) 140.33,44.75 140.32,44.76 arc(140.12,44.81) 139.92,44.76 arc(139.63,44.68) 139.33,44.76 arc(139.13,44.81) 138.93,44.76 arc(138.63,44.68) 138.34,44.76 138.31,44.78 v1(137.64,45.27)
  T08 w0.152: v1(181.35,46.65) 181.35,47.55 180.97,47.93 180.62,47.93 179.95,47.93 179.55,48.33 178.36,48.33 178.18,48.51 178.18,48.74 178,48.92 177.75,48.92 177.57,48.74 177.57,48.51 177.39,48.33 177.14,48.33 176.96,48.51 176.96,48.74 176.78,48.92 176.53,48.92 176.35,48.74 176.35,48.51 176.17,48.33 175.92,48.33 175.74,48.51 175.74,48.74 175.56,48.92 175.31,48.92 175.13,48.74 175.13,48.51 174.95,48.33 174.7,48.33 174.52,48.51 174.52,48.74 174.34,48.92 174.09,48.92 173.91,48.74 173.91,48.51 173.73,48.33 172.98,48.33 172.55,48.76 171.75,48.76 171.55,48.56 171.06,48.56 170.89,48.74 170.61,48.74 170.43,48.56 169.95,48.56 169.77,48.74 169.44,48.74 169.26,48.56 158.87,48.56 158.69,48.38 158.69,48.05 158.51,47.88 158.26,47.88 158.08,48.05 158.08,48.38 157.9,48.56 157.65,48.56 157.47,48.38 157.47,48.05 157.29,47.88 157.04,47.88 156.86,48.05 156.86,48.38 156.68,48.56 156.43,48.56 156.25,48.38 156.25,48.05 156.07,47.88 155.82,47.88 155.64,48.05 155.64,48.38 155.46,48.56 155.21,48.56 155.03,48.38 155.03,48.05 154.85,47.88 154.6,47.88 154.42,48.05 154.42,48.38 154.24,48.56 153.61,48.56 152.16,47.11 144.63,47.11 142.31,44.79 141.42,44.79
  BOTTOM w0.109: CN1.119 179.16,46.66 179.24,46.58 179.24,45.99 179.35,45.87 179.48,45.87 179.78,46.17 180.3,46.17 180.57,46.44 180.69,46.44 180.84,46.6 180.84,46.86 181.2,47.21 181.63,47.21 181.87,46.98 181.87,46.84 181.68,46.65 v1(181.35,46.65)
DDR4_A_A13: length 62
  TOP w0.102: v1(139.63,53.86) U1.CK56
  T03 w0.089: 140.53,55.14 140.1,55.14 140.08,55.11 arc(139.83,54.99) 139.72,54.73 139.72,53.95 v1(139.63,53.86)
  T03 w0.152: v1(183.03,58.52) 182.57,58.52 182.06,58.01 181.68,58.01 181.5,58.19 181.2,58.19 181,57.98 180.64,57.98 180.26,58.36 179.84,58.36 179.26,58.95 174.45,58.95 174.29,58.79 174.29,58.47 174.45,58.32 177.72,58.32 177.88,58.16 177.88,57.84 177.72,57.68 174.19,57.68 173.76,58.11 173.58,58.11 173.15,57.68 ; 140.53,55.14 140.91,55.14 141.02,55.24 142.18,55.24 144.81,57.87 144.81,57.88 145.1,58.17 145.12,58.17 145.13,58.18 151.71,58.18 151.71,58.18 155.34,58.18 155.85,57.67 167.93,57.67 168.33,58.07 169.3,58.07 169.34,58.11 169.92,58.11 169.97,58.06 170.35,58.06 170.4,58.11 171.06,58.11 171.12,58.06 171.6,58.06 171.69,58.15 172.1,58.15 172.21,58.03 172.57,58.03 172.92,57.68
  T03 w0.159: 173.15,57.68 172.92,57.68
  BOTTOM w0.109: CN1.158 185.37,58.41 185.17,58.62 185.17,59.61 185.03,59.75 184.69,59.75 184.53,59.6 184.53,59.28 184.45,59.19 184.09,59.19 183.98,59.31 183.98,59.55 183.86,59.66 183.46,59.66 183.03,59.23 v1(183.03,58.52)
DDR4_A_A14: length 61.1
  TOP w0.089: U1.CM52 v1(140.62,52.14)
  T08 w0.152: v1(183.59,56.15) 183.15,56.15 182.67,56.62 182.26,56.62 181.98,56.34 181.98,56.18 181.21,55.41 181.21,55.34 180.97,55.1 180.61,55.1 178.42,57.29 173.35,57.29 173.13,57.51 172.3,57.51 172.03,57.23 171.67,57.23 171.47,57.43 171.12,57.43 170.88,57.2 170.59,57.2 170.35,57.43 169.99,57.43 169.79,57.23 169.44,57.23 169.24,57.43 169.23,57.43 168.88,57.43 168.65,57.2 168.28,57.2 167.95,57.52 159.34,57.52 158.35,56.53 157.78,56.53 157.6,56.71 157.6,57.35 157.42,57.53 157.17,57.53 156.99,57.35 156.99,56.71 156.81,56.53 156.56,56.53 156.38,56.71 156.38,57.35 156.2,57.53 155.95,57.53 155.77,57.35 155.77,56.71 155.59,56.53 155.34,56.53 155.16,56.71 155.16,57.35 154.98,57.53 154.73,57.53 154.55,57.35 154.55,56.71 154.37,56.53 153.57,56.53 152.5,55.46 151.67,55.46 151.49,55.64 151.49,55.66 151.32,55.84 151.06,55.84 150.88,55.66 150.88,55.64 150.71,55.46 150.45,55.46 150.27,55.64 150.27,55.66 150.1,55.84 149.84,55.84 149.67,55.66 149.67,55.64 149.49,55.46 149.23,55.46 149.06,55.64 149.06,55.66 148.88,55.84 148.62,55.84 148.45,55.66 148.45,55.64 148.27,55.46 148.01,55.46 147.84,55.64 147.84,55.66 147.66,55.84 147.41,55.84 147.23,55.66 147.23,55.64 147.05,55.46 146.8,55.46 146.62,55.64 146.62,55.66 146.44,55.84 146.19,55.84 146.01,55.66 146.01,55.64 145.83,55.46 144.47,55.46 142.53,53.53 142.53,53.03 141.59,52.09 140.67,52.09 v1(140.62,52.14)
  BOTTOM w0.109: CN1.151 178.34,56.66 180.57,56.66 arc(180.79,56.6) 181.02,56.66 arc(181.34,56.76) 181.67,56.67 181.68,56.66 arc(181.91,56.6) 182.14,56.66 182.58,56.66 182.66,56.59 183.5,56.59 183.59,56.5 v1(183.59,56.15)
DDR4_A_A15: length 62.7
  TOP w0.102: U1.CJ54 v1(139.13,53)
  T03 w0.089: v1(139.13,53) 139.8,53.49 139.83,53.51 arc(139.97,53.65) 140.03,53.85 140.03,53.97 140.17,54.11
  T03 w0.097: 168.56,57.1 168.93,57.47 169.19,57.47 169.46,57.2 169.74,57.2 170.02,57.47 170.33,57.47 170.61,57.2 170.86,57.2 171.14,57.47 171.42,57.47 171.7,57.2 172,57.2 172.27,57.46 172.63,57.46 ; v1(183.59,57.65) 183.08,57.65 182.62,57.2 182.36,57.2 182.05,57.5 181.81,57.5 181.5,57.2 181.22,57.2 180.92,57.5 180.67,57.5 180.41,57.25 179.98,57.25 179.87,57.36
  T03 w0.152: 140.97,54.2 141.83,54.2 145.31,57.68 154.58,57.68 ; 172.72,57.37 178.84,57.37 178.99,57.52 178.99,57.84 178.83,58 178.44,58 178.3,58.14 178.3,58.46 178.48,58.64 179.13,58.64 179.74,58.02 179.74,57.48 179.87,57.36 ; 155.34,57.1 168.56,57.1
  T03 w0.159: 155.34,57.1 154.83,56.59 152.8,56.59 152.67,56.72 152.67,56.97 152.86,57.17 154.58,57.17 154.7,57.29 154.7,57.55 154.58,57.68 ; 140.97,54.2 140.79,54.38 140.43,54.38 140.17,54.11 ; 172.63,57.46 172.72,57.37
  BOTTOM w0.109: CN1.156 185.28,57.91 185.16,57.8 184.74,57.8 184.59,57.95 184.59,58.29 184.88,58.58 184.88,58.85 184.79,58.94 183.96,58.94 183.76,58.74 183.58,58.74 183.44,58.6 183.44,58.36 183.05,57.97 183.05,57.82 183.22,57.65 v1(183.59,57.65)
DDR4_A_A16: length 61.5
  TOP w0.102: U1.CF49 v1(137.64,50.42)
  T08 w0.152: v1(137.64,50.42) 137.99,50.77 138.35,50.77 138.6,51.02 138.6,51.4 139.11,51.91 139.11,52.34 139.43,52.65 139.84,52.65 139.95,52.54 140.34,52.54 140.45,52.65 140.82,52.65 140.92,52.55 141.33,52.55 141.8,53.02 141.8,54.17 145.74,58.11 146.58,58.11 146.76,57.93 146.76,57.55 146.94,57.37 147.19,57.37 147.37,57.55 147.37,57.93 147.55,58.11 147.8,58.11 147.98,57.93 147.98,57.55 148.16,57.37 148.41,57.37 148.59,57.55 148.59,57.93 148.77,58.11 149.02,58.11 149.2,57.93 149.2,57.55 149.38,57.37 149.63,57.37 149.81,57.55 149.81,57.93 149.99,58.11 150.24,58.11 150.42,57.93 150.42,57.55 150.6,57.37 150.85,57.37 151.03,57.55 151.03,57.93 151.21,58.11 151.46,58.11 151.64,57.93 151.64,57.55 151.82,57.37 152.07,57.37 152.25,57.55 152.25,57.93 152.43,58.11 152.68,58.11 152.86,57.93 152.86,57.55 153.04,57.37 153.29,57.37 153.47,57.55 153.47,57.93 153.65,58.11 168.66,58.11 168.94,57.83 169.15,57.83 169.43,58.11 169.79,58.11 170.05,57.84 170.3,57.84 170.56,58.11 170.9,58.11 171.14,57.88 171.45,57.88 171.69,58.11 172.06,58.11 172.11,58.06 178.73,58.06 179.77,57.02 v1(180.79,57.02)
  BOTTOM w0.109: CN1.152 185.18,56.91 184.15,56.6 183.91,56.66 183.34,57.27 183.19,57.42 182.92,57.42 182.63,57.25 182.36,57.25 182.08,57.42 181.74,57.42 181.62,57.33 v1(180.79,57.02)
DDR4_A_ACT_L: length 52.1
  TOP w0.102: U1.CF33 v1(137.64,43.56)
  T03 w0.089: v1(137.64,43.56) 138.55,43.98 139.49,43.99 140.19,44.01 140.3,44.06 140.33,44.07 arc(140.35,44.09) 140.38,44.1 141.8,45.26 142.09,45.54 144.54,46.72
  T03 w0.152: v1(181.35,45.15) 181.25,45.9 181.21,46.15 181.21,46.19 180.97,46.43 180.93,46.43 180.74,46.48 175.61,46.64 171.89,47.11 ; 144.54,46.72 144.58,46.75 168.42,46.75
  T03 w0.159: 168.42,46.75 168.7,47.04 169.34,47.04 169.41,47.11 169.98,47.11 170,47.09 170.35,47.09 170.37,47.11 170.81,47.11 171.29,47.06 171.47,47.06 171.67,47.11 171.89,47.11
  BOTTOM w0.109: v1(181.35,45.15) 181.89,45.15 182.32,44.72 182.6,44.72 182.87,44.99 183.19,44.99 183.45,44.73 183.76,44.73 183.99,44.95 184.3,44.95 184.5,44.75 184.88,44.75 185.16,45.03 185.16,45.26 185.31,45.41 CN1.114
DDR4_A_ALERT_L: length 49.1
  TOP w0.102: U1.CK33 v1(139.63,43.56)
  T03 w0.089: 144.4,46.26 142.23,45.36 140.89,44.01 140.85,44.01 arc(140.63,43.99) 140.42,43.91 140.39,43.89 v1(139.63,43.56)
  T03 w0.102: 168.89,46.44 169.22,46.44 169.46,46.2 169.74,46.2 170.02,46.48 170.33,46.48 170.61,46.2 170.86,46.2 171.14,46.48 171.42,46.48 171.72,46.18
  T03 w0.152: v1(180.79,46.02) 180.73,46.08 172.21,46.08 ; 144.4,46.26 168.7,46.26 168.89,46.44 ; 171.72,46.18 172.1,46.18
  T03 w0.159: 172.1,46.18 172.21,46.08
  BOTTOM w0.109: v1(180.79,46.02) 181.6,46.31 181.8,46.43 182,46.43 182.39,46.25 182.56,46.25 182.91,46.42 183.1,46.42 183.25,46.36 183.77,45.84 184.2,45.66 185.06,45.66 185.3,45.91 CN1.116
DDR4_A_BA0: length 62.2
  TOP w0.102: U1.CH52 v1(138.63,52.14)
  T03 w0.097: v1(181.35,56.15) 181.18,55.98 180.67,55.98 180.38,55.69
  T03 w0.102: 168.63,55.34 168.67,55.3 168.67,55.3 168.95,55.02 169.17,55.02 169.49,55.34 169.77,55.34 170.08,55.03 170.3,55.03 170.61,55.34 170.86,55.34 171.18,55.02 171.41,55.02 171.7,55.32 172,55.32 172.31,55.01
  T03 w0.152: v1(138.63,52.14) 138.96,52.14 139.44,51.66 139.85,51.66 140.05,51.86 140.28,51.86 140.48,51.66 140.86,51.66 141.07,51.86 141.47,51.86 143.6,53.99 157.75,53.99 159.34,55.58 167.4,55.58 167.85,55.13 168.16,55.13 168.37,55.34 168.58,55.34 ; 180.38,55.69 180.1,55.69 179.54,56.24 175.46,56.24 175.33,56.11 175.33,55.79 175.51,55.61 179.3,55.61 179.47,55.44 179.47,55.12 179.32,54.97 173.69,54.97 173.21,55.46 172.98,55.46 172.54,55.01 172.31,55.01
  T03 w0.159: 168.58,55.34 168.63,55.34
  BOTTOM w0.109: v1(181.35,56.15) 181.84,56.15 182.35,55.64 182.53,55.64 182.96,56.08 183.1,56.08 183.53,55.64 183.66,55.64 184.02,56 184.02,56.15 184.12,56.26 184.4,56.26 184.48,56.18 185.06,56.18 185.29,56.41 CN1.150
DDR4_A_BA1: length 63
  TOP w0.102: U1.CL51 v1(140.12,51.28)
  T08 w0.089: 141.85,51.68 141.12,51.68 arc(141.01,51.67) 140.91,51.63 140.88,51.61 v1(140.12,51.28)
  T08 w0.152: 141.85,51.68 144.25,54.08 152.16,54.08 153.86,55.78 158.64,55.78 159.17,56.31 159.88,56.31 160.06,56.49 160.06,56.76 160.24,56.94 160.49,56.94 160.67,56.76 160.67,56.49 160.85,56.31 161.1,56.31 161.28,56.49 161.28,56.76 161.46,56.94 161.71,56.94 161.89,56.76 161.89,56.49 162.07,56.31 162.32,56.31 162.5,56.49 162.5,56.76 162.68,56.94 162.93,56.94 163.11,56.76 163.11,56.49 163.29,56.31 163.54,56.31 163.72,56.49 163.72,56.76 163.9,56.94 164.15,56.94 164.33,56.76 164.33,56.49 164.5,56.31 164.76,56.31 164.94,56.49 164.94,56.76 165.11,56.94 165.37,56.94 165.55,56.76 165.55,56.49 165.72,56.31 165.98,56.31 166.16,56.49 166.16,56.76 166.33,56.94 166.59,56.94 166.76,56.76 166.76,56.49 166.94,56.31 167.5,56.31 167.78,56.59 172.41,56.59 173.41,55.59 173.89,55.59 174.07,55.77 174.07,56.52 174.25,56.7 174.5,56.7 174.68,56.52 174.68,55.77 174.86,55.59 175.11,55.59 175.29,55.77 175.29,56.52 175.47,56.7 175.72,56.7 175.9,56.52 175.9,55.77 176.08,55.59 176.33,55.59 176.51,55.77 176.51,56.52 176.69,56.7 176.94,56.7 177.12,56.52 177.12,55.77 177.3,55.59 177.55,55.59 177.73,55.77 177.73,56.52 177.91,56.7 178.16,56.7 178.34,56.52 178.34,55.77 178.52,55.59 178.52,55.59 179.71,54.4 180.46,54.4 180.8,54.75 181.22,54.75 v1(181.35,54.88)
  BOTTOM w0.165: CN1.145 179.11,55.16 179.27,54.99 179.27,54.15 179.41,54.01 181.72,54.01 181.83,54.12 181.83,54.77 181.72,54.88 v1(181.35,54.88)
