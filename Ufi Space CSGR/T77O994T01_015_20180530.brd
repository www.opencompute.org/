# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_A_DQ42: length 63.3
  TOP w0.102: U1.CL72 v1(140.12,61.01)
  T03 w0.097: v1(140.12,61.01) 139.83,61.01 139.31,60.5 138.96,60.5 138.68,60.78 138.68,61.26 138.91,61.49 138.91,67.76 146.18,75.03 167.4,75.03 167.8,75.43 171.6,75.43 173.05,73.98 178.5,73.98 182,70.48 v1(182.19,70.48)
  BOTTOM w0.109: v1(182.19,70.48) 181.71,70.01 180.69,70.01 180.6,69.92 180.6,69.56 180.51,69.47 180.29,69.47 180.18,69.59 180.18,69.92 180.09,70.01 179.58,70.01 179.34,70.24 179.34,70.55 179.24,70.66 CN1.207
DDR4_A_DQ43: length 63.3
  TOP w0.102: U1.CJ72 v1(139.13,61.01)
  T03 w0.097: v1(139.13,61.01) 139.93,61.81 139.93,66.9 147.34,74.31 149.01,74.31 149.15,74.17 149.15,74.1 149.29,73.96 149.49,73.96 149.63,74.1 149.63,74.17 149.77,74.31 149.97,74.31 150.11,74.17 150.11,74.1 150.26,73.96 150.46,73.96 150.6,74.1 150.6,74.17 150.74,74.31 150.94,74.31 151.08,74.17 151.08,74.1 151.22,73.96 151.42,73.96 151.56,74.1 151.56,74.17 151.7,74.31 151.9,74.31 152.04,74.17 152.04,74.1 152.19,73.96 152.39,73.96 152.53,74.1 152.53,74.17 152.67,74.31 152.87,74.31 153.01,74.17 153.01,74.1 153.15,73.96 153.35,73.96 153.49,74.1 153.49,74.17 153.63,74.31 153.83,74.31 153.98,74.17 153.98,74.1 154.12,73.96 154.32,73.96 154.46,74.1 154.46,74.17 154.6,74.31 154.8,74.31 154.94,74.17 154.94,74.1 155.08,73.96 155.28,73.96 155.42,74.1 155.42,74.17 155.56,74.31 155.76,74.31 155.91,74.17 155.91,74.1 156.05,73.96 156.25,73.96 156.39,74.1 156.39,74.17 156.53,74.31 156.73,74.31 156.87,74.17 156.87,74.1 157.01,73.96 157.21,73.96 157.35,74.1 157.35,74.17 157.49,74.31 157.69,74.31 157.84,74.17 157.84,74.1 157.98,73.96 158.18,73.96 158.32,74.1 158.32,74.17 158.46,74.31 158.66,74.31 158.8,74.17 158.8,74.1 158.94,73.96 159.14,73.96 159.28,74.1 159.28,74.17 159.42,74.31 159.63,74.31 159.77,74.17 159.77,74.1 159.91,73.96 160.11,73.96 160.25,74.1 160.25,74.17 160.39,74.31 160.59,74.31 160.73,74.17 160.73,74.1 160.87,73.96 161.07,73.96 161.21,74.1 161.21,74.17 161.36,74.31 167.56,74.31 167.67,74.43 171.69,74.43 172,74.11 172,73.77 172.3,73.47 178.2,73.47 v1(181.19,70.48)
  BOTTOM w0.109: v1(181.19,70.48) 181.23,70.48 181.63,70.89 183.4,70.89 183.74,70.54 184.82,70.54 185.2,70.91 CN1.208
DDR4_A_DQ44: length 63.1
  TOP w0.102: U1.CM64 v1(140.62,56.72)
  T03 w0.097: v1(140.62,56.72) 140.62,56.9 142.26,58.54 142.26,58.98 145.88,62.6 152.37,62.6 154.66,64.89 155.21,64.89 155.35,64.75 155.35,64.36 155.5,64.22 155.7,64.22 155.84,64.36 155.84,64.75 155.98,64.89 156.18,64.89 156.32,64.75 156.32,64.36 156.46,64.22 156.66,64.22 156.8,64.36 156.8,64.75 156.94,64.89 157.14,64.89 157.28,64.75 157.28,64.36 157.43,64.22 157.63,64.22 157.77,64.36 157.77,64.75 157.91,64.89 158.11,64.89 158.25,64.75 158.25,64.36 158.39,64.22 158.59,64.22 158.73,64.36 158.73,64.75 158.87,64.89 159.07,64.89 159.22,64.75 159.22,64.36 159.36,64.22 159.56,64.22 159.7,64.36 159.7,64.75 159.84,64.89 160.04,64.89 160.18,64.75 160.18,64.36 160.32,64.22 160.52,64.22 160.66,64.36 160.66,64.75 160.8,64.89 161,64.89 161.15,64.75 161.15,64.36 161.29,64.22 161.49,64.22 161.63,64.36 161.63,64.75 161.77,64.89 162.67,64.89 162.72,64.94 172.61,64.94 172.75,64.8 172.75,64.54 172.89,64.4 173.09,64.4 173.23,64.54 173.23,64.8 173.37,64.94 173.57,64.94 173.71,64.8 173.71,64.54 173.85,64.4 174.06,64.4 174.2,64.54 174.2,64.8 174.34,64.94 177.3,64.94 177.44,64.8 177.44,64.53 177.58,64.38 177.78,64.38 177.92,64.53 177.92,64.8 178.06,64.94 178.26,64.94 178.4,64.8 178.4,64.53 178.54,64.38 178.74,64.38 178.88,64.53 178.88,64.8 179.03,64.94 182.39,64.94 182.7,65.25 182.7,66.54 182.39,66.85 181.89,66.85 181.48,66.43 v1(181.19,66.43)
  BOTTOM w0.109: v1(181.19,66.43) 180.9,66.43 180.41,66.93 179.62,66.93 179.35,66.66 CN1.191
DDR4_A_DQ45: length 63.4
  TOP w0.102: U1.CK64 v1(139.63,56.72)
  T03 w0.089: 151.31,63.98 145.81,63.98 143.52,61.69 143.52,60.73
  T03 w0.097: 143.52,60.73 141.69,58.9 141.69,58.42 140.38,57.11 140.02,57.11 v1(139.63,56.72) ; 151.31,63.98 152.48,63.98 154.45,65.96 156.31,65.96 156.45,66.1 156.45,66.44 156.55,66.54 156.83,66.54 156.93,66.44 156.93,66.1 157.07,65.96 157.27,65.96 157.41,66.1 157.41,66.44 157.55,66.58 157.75,66.58 157.89,66.44 157.89,66.1 158.04,65.96 158.24,65.96 158.38,66.1 158.38,66.44 158.52,66.58 158.72,66.58 158.86,66.44 158.86,66.1 159,65.96 159.2,65.96 159.34,66.1 159.34,66.44 159.48,66.58 159.68,66.58 159.83,66.44 159.83,66.1 159.97,65.96 160.17,65.96 160.31,66.1 160.31,66.44 160.45,66.58 160.65,66.58 160.79,66.44 160.79,66.1 160.93,65.96 161.13,65.96 161.27,66.1 161.27,66.44 161.41,66.58 161.61,66.58 161.76,66.44 161.76,66.1 161.9,65.96 162.1,65.96 162.24,66.1 162.24,66.44 162.38,66.58 162.58,66.58 162.72,66.44 162.72,66.1 162.86,65.96 163.06,65.96 163.2,66.1 163.2,66.44 163.34,66.58 163.54,66.58 163.69,66.44 163.69,66.1 163.83,65.96 164.03,65.96 164.17,66.1 164.17,66.44 164.31,66.58 164.51,66.58 164.65,66.44 164.65,66.1 164.79,65.96 164.99,65.96 165.13,66.1 165.13,66.44 165.28,66.58 165.48,66.58 165.62,66.44 165.62,66.1 165.76,65.96 165.96,65.96 166.1,66.1 166.1,66.44 166.24,66.58 166.44,66.58 166.58,66.44 166.58,66.1 166.72,65.96 181.71,65.96 v1(182.19,66.43)
  BOTTOM w0.109: CN1.190 185.24,66.41 185.08,66.25 184.83,66.25 184.63,66.46 184.1,66.46 183.99,66.57 183.99,67.02 183.9,67.11 183.45,67.11 183.21,66.87 182.87,66.87 182.76,66.76 182.76,66.28 182.67,66.19 182.44,66.19 v1(182.19,66.43)
DDR4_A_DQ46: length 63.1
  TOP w0.102: U1.CM71 v1(140.62,60.15)
  T03 w0.089: 168.45,72.41 164.58,72.41
  T03 w0.097: 164.58,72.41 148.46,72.41 141.25,65.19 141.25,61.23 140.62,60.61 v1(140.62,60.15) ; 168.45,72.41 174.4,72.41 174.56,72.24 174.56,72.04 173.91,71.39 173.91,71.19 174.05,71.05 174.25,71.05 174.9,71.7 175.1,71.7 175.24,71.56 175.24,71.36 174.59,70.71 174.59,70.51 174.73,70.37 174.93,70.37 175.59,71.02 175.79,71.02 176.08,70.73 177.32,70.73 177.46,70.59 177.46,69.99 177.6,69.85 177.8,69.85 177.94,69.99 177.94,70.59 178.08,70.73 178.71,70.73 179.05,70.39 179.05,70.19 178.91,70.05 178.91,69.85 179.06,69.7 179.25,69.7 179.4,69.84 179.6,69.84 179.74,69.7 179.74,69.5 179.6,69.36 179.6,69.16 179.74,69.02 179.94,69.02 180.08,69.16 180.28,69.16 180.42,69.02 182.03,69.02 182.19,69.18 v1(182.19,69.48)
  BOTTOM w0.109: CN1.203 179.75,69.66 179.86,69.55 179.86,69 179.95,68.91 181.44,68.91 182.01,69.48 v1(182.19,69.48)
DDR4_A_DQ47: length 63.2
  TOP w0.102: U1.CK71 v1(139.63,60.15)
  T03 w0.089: 167.55,73.05 164.72,73.05
  T03 w0.097: v1(183.19,69.48) 182.68,69.99 180.06,69.99 179.36,70.68 179.36,70.88 179.58,71.11 179.58,71.31 179.44,71.45 179.24,71.45 179.02,71.23 178.82,71.23 178.53,71.52 178.14,71.52 178,71.66 178,71.97 177.86,72.11 177.66,72.11 177.51,71.97 177.51,71.66 177.37,71.52 177.17,71.52 177.03,71.66 177.03,71.97 176.89,72.11 176.69,72.11 176.55,71.97 176.55,71.66 176.41,71.52 176.23,71.52 174.83,72.91 172.06,72.91 171.56,73.41 167.91,73.41 167.55,73.05 ; 164.72,73.05 148.12,73.05 147.75,72.68 147.55,72.68 147.43,72.79 147.23,72.79 147.09,72.65 147.09,72.45 147.21,72.33 147.21,72.13 147.07,71.99 146.87,71.99 146.75,72.11 146.55,72.11 146.41,71.97 146.41,71.77 146.53,71.65 146.53,71.45 146.38,71.31 146.18,71.31 146.06,71.43 145.87,71.43 145.72,71.29 145.72,71.09 145.84,70.97 145.84,70.77 145.7,70.63 145.5,70.63 145.38,70.75 145.18,70.75 145.04,70.6 145.04,70.4 145.16,70.29 145.16,70.09 140.83,65.75 140.83,61.12 140.18,60.48 139.95,60.48 v1(139.63,60.15)
  BOTTOM w0.109: v1(183.19,69.48) 183.19,69.48 182.73,69.48 182.61,69.6 182.61,69.8 182.72,69.91 CN1.204
DDR4_A_DQ48: length 71.9
  TOP w0.102: U1.BT72 v1(133.19,61.01)
  T08 w0.097: v1(133.19,61.01) 132.99,61.21 132.99,62.17 133.9,63.09 135.43,63.09 138.45,66.11 138.45,69.61 141.52,72.68 141.52,72.78 142.33,73.59 146.94,73.59 147.84,74.5 172.93,74.5 173.12,74.31 173.12,73.42 173.24,73.3 173.38,73.3 173.5,73.42 173.5,74.37 173.69,74.56 173.82,74.56 174.01,74.37 174.01,73.42 174.13,73.29 174.26,73.29 174.39,73.42 174.39,74.37 174.51,74.5 174.82,74.5 175.28,74.04 175.28,72.61 175.58,72.31 177.73,72.31 177.82,72.41 177.82,73.48 177.94,73.6 178.14,73.6 178.32,73.42 178.32,72.31 178.48,72.16 178.71,72.16 178.83,72.28 178.83,72.66 178.96,72.79 179.34,72.79 179.47,72.66 179.47,72.54 179.59,72.41 180.34,72.41 180.83,72.9 v1(181.19,72.9)
  BOTTOM w0.109: v1(181.19,72.9) 181.59,72.9 181.99,72.49 183.36,72.49 183.99,73.13 185.03,73.13 185.25,72.91 CN1.216
DDR4_A_DQ49: length 71.8
  TOP w0.102: U1.BU71 v1(133.68,60.15)
  T08 w0.097: v1(182.19,72.9) 181.61,72.32 181.02,72.32 180.65,71.95 179.13,71.95 178.97,71.79 178.97,71.2 178.81,71.04 178.5,71.04 178.34,71.2 178.34,71.69 178.18,71.85 175.25,71.85 174.26,72.84 172.24,72.84 172.08,73 172.08,73.18 171.85,73.42 169.29,73.42 168.8,73.91 167.53,73.91 167.37,74.07 148.11,74.07 147.97,73.93 147.97,73.8 148.1,73.68 150.64,73.68 150.77,73.55 150.77,73.29 150.64,73.17 142.51,73.17 141.95,72.6 141.95,72.51 138.78,69.34 138.78,66.01 135.48,62.71 134.56,62.71 133.98,62.12 133.98,61.56 133.68,61.27 v1(133.68,60.15)
  BOTTOM w0.109: v1(182.19,72.9) 182.5,72.9 182.6,73 182.6,73.3 182.49,73.41 180.95,73.41 180.85,73.32 180,73.32 179.34,72.66 CN1.215
DDR4_A_DQ50: length 72
  TOP w0.102: U1.BG72 v1(129.22,61.01)
  T08 w0.089: v1(129.22,61.01) 129.22,61.91 129.89,62.58
  T08 w0.097: v1(182.19,75.93) 182.13,75.99 182.13,76.24 181.75,76.63 181.75,77 181.31,77.44 181.04,77.44 179.98,78.5 179.34,78.5 179.21,78.63 179.21,79.39 179.11,79.5 178.81,79.5 178.57,79.25 177.93,79.25 177.69,79.5 163.95,79.5 161.65,77.19 142.1,77.19 141.75,77.19 135.47,70.91 135.47,66.77 134.26,65.55 132.86,65.55 129.89,62.58
  BOTTOM w0.109: v1(182.19,75.93) 182.74,75.38 183.66,75.38 183.79,75.5 183.79,76.32 183.88,76.41 184.56,76.41 184.65,76.32 184.65,76.05 184.79,75.92 CN1.228
DDR4_A_DQ51: length 72
  TOP w0.102: U1.BH71 v1(129.72,60.15)
  T08 w0.089: 135.91,66.69 135.91,69.18
  T08 w0.097: v1(183.19,75.93) 182.72,75.46 182.04,75.46 181.71,75.79 181.71,76.07 181.33,76.45 179.95,76.45 178.71,77.69 175.83,77.69 175.02,78.51 163.6,78.51 161.85,76.76 141.93,76.76 135.91,70.75 135.91,69.18 ; v1(129.72,60.15) 129.72,61.82 133.06,65.17 134.38,65.17 135.91,66.69
  BOTTOM w0.109: CN1.229 180.73,76.16 180.9,76.33 181.37,76.33 181.49,76.21 181.89,76.21 182.01,76.33 183.09,76.33 183.19,76.24 v1(183.19,75.93)
DDR4_A_DQ52: length 72
  TOP w0.102: U1.BV72 v1(134.18,61.01)
  T08 w0.097: v1(134.18,61.01) 134.39,61.01 134.97,61.59 134.97,62.06 135.23,62.33 135.53,62.33 139.09,65.88 139.09,68.14 143.65,72.7 155.59,72.7 155.72,72.83 155.72,73.04 155.59,73.17 151.53,73.17 151.4,73.29 151.4,73.42 151.53,73.55 163.34,73.55 163.84,73.05 167.69,73.05 168.02,73.38 168.65,73.38 168.91,73.12 168.91,72.74 169.24,72.41 173.73,72.41 174.77,71.37 177.57,71.37 177.74,71.19 177.74,70.91 178.04,70.61 179.07,70.61 179.9,71.44 181.73,71.44 v1(182.19,71.9)
  BOTTOM w0.109: v1(182.19,71.9) 181.79,71.9 181.36,72.33 180.83,72.33 180.72,72.22 180.72,71.74 180.63,71.65 180.32,71.65 180.22,71.74 180.22,72.09 180.14,72.18 179.89,72.18 179.81,72.09 179.81,71.84 179.63,71.66 CN1.211
DDR4_A_DQ53: length 71.9
  TOP w0.102: v1(134.67,60.15) U1.BW71
  T08 w0.097: v1(183.19,71.9) 182.3,71.01 180.08,71.01 179.19,70.12 177.69,70.12 176.94,70.87 173.23,70.87 172.87,71.23 169.17,71.23 168.12,72.28 163.85,72.28 163.08,73.04 156.48,73.04 156.36,72.92 156.36,72.78 156.48,72.66 161.31,72.66 161.43,72.53 161.43,72.41 161.31,72.28 143.82,72.28 139.39,67.84 139.39,65.76 135.91,62.28 135.91,61.77 135.66,61.51 135.66,60.88 134.93,60.15 v1(134.67,60.15)
  BOTTOM w0.109: CN1.212 185.31,71.91 184.8,71.4 183.69,71.4 v1(183.19,71.9)
DDR4_A_DQ54: length 71.8
  TOP w0.102: U1.BJ72 v1(130.21,61.01)
  T08 w0.089: v1(130.21,61.01) 130.21,61.83 133.16,64.78 134.51,64.78 136.34,66.62 136.34,69 136.34,69.01 136.34,70.22 136.34,70.57
  T08 w0.097: v1(182.19,74.93) 181.9,74.93 181.4,75.43 181.05,75.43 180.64,75.84 179.83,75.84 178.56,77.1 175.78,77.1 174.83,78.06 173.56,78.06 173.44,77.93 173.44,77.8 173.51,77.73 174.52,77.73 174.64,77.62 174.64,77.48 174.51,77.36 172.64,77.36 172.51,77.49 165.63,77.49 164.99,76.85 162.54,76.85 162.28,76.59 162.03,76.34 142.1,76.34 136.34,70.57
  BOTTOM w0.109: v1(182.19,74.93) 182.58,74.93 183.04,74.48 183.65,74.48 183.74,74.56 183.74,75.04 183.83,75.14 184.07,75.14 184.16,75.05 184.16,74.63 184.25,74.54 184.55,74.54 184.66,74.64 184.66,74.87 184.71,74.91 CN1.224
DDR4_A_DQ55: length 71.9
  TOP w0.102: U1.BL71 v1(130.71,60.15)
  T08 w0.089: 136.76,69.18 136.76,66.53
  T08 w0.097: 136.76,66.53 134.59,64.36 133.35,64.36 130.71,61.72 v1(130.71,60.15) ; v1(181.19,74.93) 180.65,74.39 179.9,74.39 179.52,74.77 179.52,75.38 178.93,75.97 175.88,75.97 175.35,76.5 167.84,76.5 167.55,76.22 166.01,76.22 165.88,76.34 165.88,76.47 166.01,76.6 167.4,76.6 167.52,76.72 167.52,76.85 167.4,76.98 165.75,76.98 165.12,76.34 162.65,76.34 162.22,75.91 142.28,75.91 136.76,70.39 136.76,69.18
  BOTTOM w0.109: CN1.225 179.1,75.16 179.37,75.43 179.52,75.43 179.74,75.22 179.86,75.22 180.05,75.41 180.05,75.72 180.14,75.81 180.69,75.81 180.78,75.72 180.78,75.59 180.86,75.5 181.66,75.5 181.82,75.34 181.82,75.09 181.66,74.93 v1(181.19,74.93)
DDR4_A_DQ56: length 80
  TOP w0.102: U1.BU67 v1(133.68,58.44)
  T03 w0.097: v1(183.19,77.95) 183.33,77.81 183.33,77.46 183.21,77.34 179.2,77.34 178.84,77.7 178.31,77.7 178.17,77.84 178.17,78.22 178.02,78.36 177.82,78.36 177.68,78.22 177.68,77.84 177.54,77.7 173.37,77.7 171.6,79.47 167.62,79.47 167.48,79.33 167.48,79.12 167.33,78.98 167.13,78.98 166.99,79.12 166.99,79.33 166.85,79.47 166.65,79.47 166.51,79.33 166.51,79.12 166.37,78.98 166.17,78.98 166.03,79.12 166.03,79.33 165.89,79.47 165.69,79.47 165.55,79.33 165.55,79.12 165.4,78.98 165.2,78.98 165.06,79.12 165.06,79.33 164.92,79.47 164.72,79.47 164.58,79.33 164.58,79.12 164.44,78.98 164.24,78.98 164.1,79.12 164.1,79.33 163.96,79.47 163.76,79.47 163.62,79.33 163.62,79.12 163.47,78.98 163.27,78.98 163.13,79.12 163.13,79.33 162.99,79.47 162.65,79.47 160.1,76.92 143.38,76.92 140.27,73.82 138.58,73.82 135.8,71.03 135.8,66.26 135.66,66.12 135.13,66.12 134.99,65.98 134.99,65.78 135.13,65.64 135.66,65.64 135.8,65.5 135.8,65.3 135.66,65.16 135.13,65.16 134.99,65.01 134.99,64.81 135.13,64.67 135.66,64.67 135.8,64.53 135.8,64.33 135.66,64.19 135.13,64.19 134.99,64.05 134.99,63.85 135.13,63.71 135.66,63.71 135.8,63.57 135.8,63.35 134.95,62.5 134.95,61.64 134.69,61.39 134.69,60.85 134.2,60.36 134.2,59.98 133.68,59.46 v1(133.68,58.44)
  BOTTOM w0.109: CN1.237 180.38,78.17 180.99,77.55 182.53,77.55 182.93,77.95 v1(183.19,77.95)
DDR4_A_DQ57: length 79.7
  TOP w0.102: U1.BT66 v1(133.19,57.58)
  T03 w0.097: v1(133.19,57.58) 133.19,58.62 132.74,59.08 132.74,59.51 133.22,59.99 133.22,60.42 133.68,60.88 133.68,61.26 133.98,61.56 133.98,62.81 134.12,62.95 134.33,62.95 134.47,63.09 134.47,63.29 134.33,63.43 134.12,63.43 133.98,63.57 133.98,63.77 134.12,63.92 134.33,63.92 134.47,64.06 134.47,64.26 134.33,64.4 134.12,64.4 133.98,64.54 133.98,64.74 134.12,64.88 134.33,64.88 134.47,65.02 134.47,65.22 134.33,65.36 134.12,65.36 133.98,65.5 133.98,65.7 134.12,65.85 134.33,65.85 134.47,65.99 134.47,66.19 134.33,66.33 134.12,66.33 133.98,66.47 133.98,71.18 137.33,74.53 140.01,74.53 142.91,77.43 159.61,77.43 162.17,79.99 168.58,79.99 169.07,80.48 171.85,80.48 172,80.33 172,79.78 172.54,79.24 173.57,79.24 173.71,79.1 173.71,78.43 173.85,78.29 174.05,78.29 174.2,78.43 174.2,79.1 174.34,79.24 174.54,79.24 174.68,79.1 174.68,78.43 174.82,78.29 175.02,78.29 175.16,78.43 175.16,79.1 175.3,79.24 177.92,79.24 179.33,77.83 180.76,77.83 181.03,77.56 181.8,77.56 v1(182.19,77.95)
  BOTTOM w0.109: v1(182.19,77.95) 182.45,77.95 182.86,78.36 184.48,78.36 184.6,78.24 184.6,77.51 184.7,77.41 185,77.41 185.09,77.5 185.09,77.87 185.14,77.92 CN1.236
DDR4_A_DQ58: length 79.7
  TOP w0.102: U1.BH67 v1(129.72,58.44)
  T03 w0.097: v1(182.19,80.98) 182.2,80.99 182.2,82.44 180.68,83.96 169.98,83.96 169.22,84.72 162.21,84.72 158.82,81.33 142.04,81.33 138.54,77.83 135.35,77.83 130.46,72.93 130.46,66.58 128.77,61.37 128.77,60.75 129.21,60.32 129.21,59.94 128.77,59.51 128.77,59.1 129.22,58.65 v1(129.72,58.44)
  BOTTOM w0.109: v1(182.19,80.98) 181.71,80.51 179.58,80.51 179.34,80.74 179.34,81.01 179.19,81.17 CN1.249
DDR4_A_DQ59: length 79.8
  TOP w0.102: U1.BG66 v1(129.22,57.58)
  T03 w0.097: v1(129.22,57.58) 129.92,58.07 130.1,58.25 130.12,58.41 130.12,58.66 129.81,58.97 129.81,59.53 130.19,59.91 130.19,60.32 129.71,60.8 129.71,62.14 130.73,66.25 130.83,66.56 130.83,69.38 130.93,69.48 130.93,72.76 135.51,77.33 138.68,77.33 142.02,80.68 158.97,80.68 162.5,84.22 168.05,84.22 168.73,83.54 177.6,83.54 177.93,83.2 178.13,83.2 178.18,83.25 178.37,83.25 178.52,83.1 178.52,82.91 178.47,82.86 178.47,82.66 178.79,82.35 179.24,82.35 179.38,82.2 179.38,82.18 179.53,82.04 179.73,82.04 179.87,82.18 179.87,82.2 180.01,82.35 180.75,82.35 181.19,81.9 v1(181.19,80.98)
  BOTTOM w0.109: CN1.250 185.18,81.42 184.8,81.04 183.74,81.04 183.4,81.38 181.5,81.38 181.19,81.07 v1(181.19,80.98)
DDR4_A_DQ60: length 79.8
  TOP w0.102: v1(134.67,58.44) U1.BW67
  T03 w0.097: v1(182.19,76.93) 182.19,76.78 181.78,76.37 180.97,76.37 180.42,75.82 179.48,75.82 179.11,75.45 177.66,75.45 176.98,76.14 175.36,76.14 174.67,75.45 173.83,75.45 172.84,76.45 167.14,76.45 167,76.59 167,77.83 166.86,77.97 166.66,77.97 166.52,77.83 166.52,76.59 166.38,76.45 166.18,76.45 166.04,76.59 166.04,77.83 165.9,77.97 165.7,77.97 165.55,77.83 165.55,76.59 165.41,76.45 163.24,76.45 162.78,75.99 144.31,75.99 143.92,75.59 143.92,75.39 144.43,74.88 144.43,74.68 144.29,74.54 144.09,74.54 143.57,75.05 143.38,75.05 143.23,74.91 143.23,74.71 143.74,74.19 143.74,74 143.6,73.85 143.4,73.85 142.89,74.36 142.69,74.36 142.55,74.22 142.55,74.02 143.06,73.51 143.06,73.31 142.92,73.17 142.72,73.17 142.21,73.68 142.01,73.68 141.63,73.3 141.63,73.1 141.72,73.01 141.72,72.81 141.57,72.67 141.37,72.67 141.29,72.76 141.09,72.76 140.94,72.62 140.94,72.42 141.03,72.33 141.03,72.13 140.89,71.99 140.69,71.99 140.6,72.08 140.4,72.08 140.26,71.93 140.26,71.73 140.35,71.65 140.35,71.45 140.21,71.3 140.01,71.3 139.92,71.39 139.72,71.39 139.58,71.25 139.58,71.05 139.67,70.96 139.67,70.76 139.53,70.62 139.33,70.62 139.24,70.71 139.04,70.71 138.12,69.79 138.12,63.46 136.89,62.23 136.89,61.65 136.62,61.39 136.62,60.85 136.11,60.35 136.11,59.96 135.66,59.51 135.66,59.1 135.2,58.64 134.88,58.64 v1(134.67,58.44)
  BOTTOM w0.109: v1(182.19,76.93) 182.44,76.69 182.67,76.69 182.76,76.78 182.76,77.26 182.87,77.37 183.21,77.37 183.45,77.61 183.9,77.61 183.99,77.52 183.99,77.07 184.1,76.96 184.63,76.96 184.83,76.75 185.07,76.75 185.23,76.92 CN1.232
DDR4_A_DQ61: length 80
  TOP w0.102: U1.BV66 v1(134.18,57.58)
  T03 w0.089: 135.91,62.38 136.5,62.97 136.5,63.49 136.63,63.62 137.27,63.62 137.4,63.76 137.4,63.94 137.27,64.07 136.63,64.07 136.5,64.2 136.5,64.38 136.63,64.51 137.27,64.51 137.4,64.64 137.4,64.83 137.27,64.96 136.63,64.96 136.5,65.09 136.5,65.27 136.63,65.4 137.27,65.4 137.4,65.53 137.4,65.72 137.27,65.85 136.63,65.85 136.5,65.98 136.5,70.67 137.57,71.74
  T03 w0.097: v1(134.18,57.58) 134.18,58.61 134.67,59.1 134.67,59.49 135.12,59.94 135.12,60.32 135.63,60.83 135.63,61.36 135.91,61.64 135.91,62.38 ; v1(181.19,76.93) 180.88,76.93 180.2,76.25 179.42,76.25 179.22,76.45 179.22,76.77 179.11,76.88 178.63,76.88 178.5,76.75 178.5,76.22 178.32,76.04 177.84,76.04 177.66,76.22 177.66,76.93 177.44,77.16 174.72,77.16 174.57,77 174.57,76.29 174.39,76.11 174.11,76.11 173.93,76.29 173.93,76.85 173.81,76.97 172.72,76.97 172.22,77.47 168.22,77.47 167.24,78.46 163.78,78.46 163.32,78 163.12,78 162.65,78.47 162.45,78.47 162.3,78.33 162.3,78.13 162.78,77.66 162.78,77.46 162.64,77.32 162.44,77.32 161.96,77.79 161.76,77.79 161.62,77.65 161.62,77.45 162.1,76.97 162.1,76.77 161.77,76.45 143.91,76.45 140.5,73.04 138.87,73.04 137.57,71.74
  BOTTOM w0.109: CN1.233 179.16,77.17 179.27,77.06 179.27,76.76 179.38,76.65 179.64,76.65 179.75,76.76 179.75,77.76 179.86,77.87 180.26,77.87 180.61,77.52 180.61,76.84 180.74,76.72 181.08,76.72 181.19,76.83 v1(181.19,76.93)
DDR4_A_DQ62: length 80.1
  TOP w0.102: U1.BL67 v1(130.71,58.44)
  T03 w0.097: v1(130.71,58.44) 130.81,59.26 130.81,59.31 arc(130.86,59.5) 131.01,59.64 arc(131.22,59.85) 131.3,60.13 131.3,60.16 arc(131.36,60.36) 131.5,60.5 131.75,60.74 131.75,61.23 132,61.49 132,62.36 131.67,62.69 131.67,69.06 131.79,69.17 131.79,72.31 135.82,76.35 138.96,76.35 141.72,79.11 158.6,79.11 162.68,83.19 166,83.19 166.56,82.63 172.15,82.63 173,81.78 174.15,81.78 174.29,81.92 174.29,82.09 174.43,82.23 174.63,82.23 174.78,82.09 174.78,81.92 174.92,81.78 175.12,81.78 175.26,81.92 175.26,82.09 175.4,82.23 175.6,82.23 175.74,82.09 175.74,81.92 175.88,81.78 176.08,81.78 176.22,81.92 176.22,82.09 176.36,82.23 176.56,82.23 176.71,82.09 176.71,81.92 176.85,81.78 177.05,81.78 177.19,81.92 177.19,82.09 177.33,82.23 177.53,82.23 177.67,82.09 177.67,81.79 178.49,80.97 179.47,80.97 180.92,79.52 181.73,79.52 v1(182.19,79.98)
  BOTTOM w0.109: v1(182.19,79.98) 181.99,79.98 181.52,79.52 180.86,79.52 180.76,79.62 180.76,80.1 180.66,80.2 180.43,80.2 180.33,80.1 180.33,79.49 180.25,79.41 179.95,79.41 179.86,79.5 179.86,80.03 179.73,80.17 CN1.245
DDR4_A_DQ63: length 79.5
  TOP w0.102: U1.BJ66 v1(130.21,57.58)
  T03 w0.097: v1(130.21,57.58) 130.31,58.4 130.31,58.45 arc(130.33,58.58) 130.38,58.71 130.56,59.06 130.59,59.15 arc(130.61,59.21) 130.61,59.28 130.61,59.32 arc(130.7,59.6) 130.91,59.81 arc(131.05,59.95) 131.11,60.14 131.11,60.17 arc(131.11,60.22) 131.12,60.27 131.12,60.49 130.75,60.85 130.75,61.51 131.24,65.95 131.24,69.13 131.36,69.26 131.36,72.58 135.57,76.79 138.8,76.79 141.93,79.92 158.81,79.92 162.52,83.63 167.16,83.63 167.73,83.06 175.3,83.06 175.44,82.92 175.44,82.8 175.58,82.66 175.78,82.66 175.92,82.8 175.92,82.92 176.07,83.06 176.27,83.06 176.41,82.92 176.41,82.8 176.55,82.66 176.75,82.66 176.89,82.8 176.89,82.92 177.03,83.06 177.47,83.06 178.94,81.59 180.31,81.59 180.64,81.26 180.64,80.84 181,80.49 182.92,80.49 183.19,80.21 v1(183.19,79.98)
  BOTTOM w0.109: v1(183.19,79.98) 183.19,80.37 183.46,80.64 184.65,80.64 184.71,80.57 184.71,80.12 184.82,80 185.04,80 185.13,80.09 185.13,80.33 185.22,80.42 CN1.246
DDR4_A_DQS0_N: length 64.2
  TOP w0.089: v1(136.8,26.44) 136.35,26.89 136.35,27.36 136.53,27.54 136.53,28.33 136.75,28.55 136.75,29.09 136.4,29.44 U1.CB4
  T03 w0.097: v1(182.19,19.92) 182.27,20 182.58,20 182.64,19.94 182.64,19.66 182.42,19.45 179.81,19.45 177.15,16.8 172.14,16.8 171.11,17.82 167.7,17.82 166.01,16.13 146.71,16.13 140.55,22.29 138.31,22.29 137.74,22.86 137.74,25.76 137.41,26.09 137.15,26.09 v1(136.8,26.44)
  BOTTOM w0.109: v1(182.19,19.92) 182.12,19.92 181.73,20.31 181.03,20.31 181,20.29 180.8,20.29 180.71,20.2 180.71,19.74 180.65,19.68 180.44,19.68 180.36,19.76 180.36,20.22 180.3,20.29 180.14,20.29 179.68,19.82 179.11,19.82 178.94,19.65 CN1.11
DDR4_A_DQS0_P: length 64.2
  TOP w0.089: v1(136.78,25.67) 136.74,25.63 136.52,25.63 136.39,25.75 136.39,26.58 136.16,26.81 136.16,27.44 136.34,27.62 136.34,28.41 136.56,28.62 136.56,28.79 U1.CB2
  T03 w0.097: v1(183.19,19.92) 182.86,19.59 182.51,19.24 179.89,19.24 177.24,16.58 172.05,16.58 171.02,17.61 167.79,17.61 166.1,15.92 146.62,15.92 140.46,22.08 138.23,22.08 137.53,22.77 137.53,25.67 137.32,25.88 137.06,25.88 136.85,25.67 v1(136.78,25.67)
  BOTTOM w0.109: CN1.13 179.07,20.15 179.17,20.06 179.58,20.06 180.04,20.52 180.9,20.52 180.9,20.53 181.82,20.53 182.02,20.33 182.35,20.33 182.77,19.92 v1(183.19,19.92)
DDR4_A_DQS1_N: length 62.8
  TOP w0.102: U1.CH7 v1(138.63,31.54)
  T08 w0.089: 181.89,24.61 182.19,24.91 v1(182.19,24.97) ; 145.61,28.88 145.6,28.89 145.6,28.9 145.55,28.94 145.55,28.95 145.27,29.23 144.71,29.23 139.91,29.23 138.77,30.37 138.77,30.92 139.03,31.18 139.03,31.61 arc(138.89,31.84) 138.63,31.94 arc(138.58,31.94) 138.53,31.95 arc(138.3,31.81) 138.44,31.58 v1(138.63,31.54)
  T08 w0.097: 181.89,24.61 181.89,24.59 181.64,24.34 181.35,24.34 180.9,24.34 180.77,24.21 179.04,24.21 178.47,24.78 175.1,24.78 174.67,25.21 174.67,25.74 172.78,27.63 168.13,27.63 166.33,25.83 162.92,25.83 162.76,25.66 162.76,25.42 162.46,25.12 162.05,25.12 161.75,25.42 161.75,25.66 161.58,25.83 161.34,25.83 161.18,25.66 161.18,25.42 160.88,25.12 160.47,25.12 160.17,25.42 160.17,25.66 160,25.83 157.22,25.83 157.05,25.66 157.05,24.94 156.76,24.64 156.34,24.64 156.05,24.94 156.05,25.66 155.88,25.83 155.64,25.83 155.47,25.66 155.47,24.94 155.18,24.64 154.76,24.64 154.47,24.94 154.47,25.66 154.3,25.83 153.84,25.83 152.74,24.72 149.77,24.72 145.61,28.88
  BOTTOM w0.089: 183.02,25.35 183.56,25.35 183.72,25.19
  BOTTOM w0.109: v1(182.19,24.97) 182.58,25.35 182.74,25.35 183.02,25.35 ; CN1.32 185.3,24.9 185.15,25.05 184.87,25.05 184.59,25.33 184.19,25.33 184.14,25.28 184.14,24.92 184.06,24.83 183.81,24.83 183.72,24.92 183.72,25.19
DDR4_A_DQS1_P: length 62.8
  TOP w0.102: U1.CG9 v1(138.14,32.39)
  T08 w0.089: 145.76,29.03 145.35,29.44 144.71,29.44 143.86,29.44 139.99,29.44 138.98,30.44 138.98,30.82 139.24,31.08 139.24,31.62 arc(139.14,31.91) 138.87,32.07 arc(138.77,32.12) 138.66,32.16 arc(138.5,32.18) 138.34,32.19 arc(138.2,32.25) v1(138.14,32.39) ; v1(181.19,24.97) 181.58,24.97 181.68,24.87 181.68,24.68
  T08 w0.097: 181.68,24.68 181.55,24.55 181.44,24.55 181.44,24.55 180.94,24.55 180.94,24.55 180.81,24.55 180.69,24.42 179.12,24.42 178.56,24.99 175.19,24.99 174.88,25.3 174.88,25.82 172.87,27.84 168.04,27.84 166.25,26.04 162.84,26.04 162.54,25.74 162.54,25.5 162.37,25.33 162.13,25.33 161.97,25.5 161.97,25.74 161.67,26.04 161.26,26.04 160.96,25.74 160.96,25.5 160.79,25.33 160.55,25.33 160.39,25.5 160.39,25.74 160.09,26.04 157.13,26.04 156.84,25.74 156.84,25.02 156.67,24.85 156.43,24.85 156.26,25.02 156.26,25.74 155.97,26.04 155.55,26.04 155.26,25.74 155.26,25.02 155.09,24.85 154.85,24.85 154.68,25.02 154.68,25.74 154.39,26.04 153.76,26.04 152.65,24.93 149.86,24.93 145.76,29.03
  BOTTOM w0.102: 184.19,25.57 183.06,25.57 183.04,25.59
  BOTTOM w0.109: 183.04,25.59 183.04,25.59 182.43,25.59 182.21,25.37 182,25.37 181.6,24.97 v1(181.19,24.97) ; CN1.34 185.21,25.4 185.09,25.28 184.97,25.28 184.68,25.57 184.19,25.57
DDR4_A_DQS2_N: length 60
  TOP w0.089: v1(138.14,34.11) 138.43,33.82 U1.CG13
  T03 w0.089: 142.15,32.79 142.11,32.82 142,32.82 141.92,32.91 141.62,32.91 141.54,32.82 141.32,32.82 141.24,32.91 140.99,32.91 140.9,32.82 140.72,32.82 arc(140.56,32.85) 140.42,32.91 arc(140.12,32.99) 139.83,32.91 arc(139.63,32.85) 139.43,32.91 arc(139.13,32.99) 138.83,32.91 arc(138.44,32.9) 138.23,33.24 138.23,33.27 arc(138.15,33.56) 137.94,33.76 arc(137.8,33.9) 137.74,34.1 arc(137.74,34.11) 137.74,34.13 arc(137.8,34.32) 137.94,34.46 arc(138.06,34.5) 138.19,34.53 arc(138.34,34.45) 138.31,34.28 v1(138.14,34.11)
  T03 w0.097: 142.15,32.79 144.06,30.88 152.71,30.88 153.98,29.6 155.71,29.6 155.97,29.34 155.97,28.85 156.12,28.71 156.32,28.71 156.46,28.85 156.46,29.34 156.72,29.6 157.1,29.6 157.36,29.34 157.36,28.85 157.5,28.71 157.7,28.71 157.84,28.85 157.84,29.34 158.11,29.6 165.95,29.6 167.73,27.83 172.92,27.83 173.94,28.84 178.58,28.84 179.77,30.04 180.88,30.04 180.9,30.01 182.64,30.01 182.7,30.08 182.7,30.48 182.6,30.58 182.36,30.58 v1(182.19,30.42)
  BOTTOM w0.102: 180.8,30.81 181.5,30.81
  BOTTOM w0.109: 181.5,30.81 182.05,30.81 182.19,30.67 v1(182.19,30.42) ; 180.8,30.81 180.71,30.73 180.71,30.26 180.65,30.2 180.44,30.2 180.36,30.27 180.36,30.74 180.3,30.8 180.09,30.8 179.61,30.32 179.11,30.32 178.95,30.15 CN1.53
DDR4_A_DQS2_P: length 60
  TOP w0.102: U1.CH14 v1(138.63,34.97)
  T03 w0.089: v1(183.19,30.42) 183.19,30.27 182.91,29.99 ; 142.01,32.63 142,32.63 140.72,32.63 arc(140.51,32.66) 140.32,32.74 arc(140.12,32.79) 139.92,32.74 arc(139.63,32.66) 139.33,32.74 arc(139.13,32.79) 138.93,32.74 arc(138.35,32.74) 138.04,33.23 138.04,33.26 arc(137.99,33.46) 137.84,33.6 arc(137.63,33.81) 137.55,34.09 arc(137.55,34.11) 137.55,34.13 arc(137.63,34.42) 137.84,34.62 138.28,34.87 arc(138.45,34.95) v1(138.63,34.97)
  T03 w0.097: 142.01,32.63 143.97,30.67 152.62,30.67 153.89,29.39 155.62,29.39 155.76,29.25 155.76,28.76 156.03,28.5 156.4,28.5 156.67,28.76 156.67,29.25 156.81,29.39 157.01,29.39 157.15,29.25 157.15,28.76 157.42,28.5 157.79,28.5 158.05,28.76 158.05,29.25 158.2,29.39 165.86,29.39 167.64,27.62 173.01,27.62 174.03,28.63 178.67,28.63 179.86,29.83 180.79,29.83 180.82,29.8 182.72,29.8 182.91,29.99
  BOTTOM w0.109: CN1.55 179.07,30.65 179.17,30.56 179.51,30.56 179.99,31.04 182.15,31.04 182.77,30.42 v1(183.19,30.42)
DDR4_A_DQS3_N: length 57
  TOP w0.102: U1.CD24 v1(137.15,39.26)
  T08 w0.089: 140.82,37.79 140.74,37.79 140.72,37.81 140.61,37.81 arc(140.46,37.83) 140.32,37.89 140.32,37.89 arc(140.12,37.95) 139.92,37.89 arc(139.63,37.81) 139.33,37.89 arc(139.13,37.95) 138.93,37.89 arc(138.35,37.89) 138.04,38.38 138.04,38.42 arc(137.99,38.61) 137.84,38.75 arc(137.63,38.96) 137.55,39.24 137.55,39.27 arc(137.17,39.66) 136.75,39.32 136.81,39.26 v1(137.15,39.26)
  T08 w0.097: 140.82,37.79 143.17,37.79 144.52,36.44 145.37,36.44 145.57,36.25 145.86,36.25 146.05,36.44 153.3,36.44 153.57,36.71 153.57,36.92 153.71,37.06 153.91,37.06 154.05,36.92 154.05,36.71 154.32,36.44 165.66,36.44 165.75,36.53 165.75,36.53 167.34,38.12 172.76,38.12 175.69,35.19 178.89,35.19 179.24,34.83 180.92,34.83 180.94,34.85 181.65,34.85 181.9,35.09 181.9,35.17 v1(182.19,35.47)
  BOTTOM w0.102: 183.64,35.87 182.9,35.87
  BOTTOM w0.109: v1(182.19,35.47) 182.6,35.87 182.9,35.87 ; 183.64,35.87 183.72,35.78 183.72,35.32 183.81,35.23 184.06,35.23 184.14,35.32 184.14,35.78 184.23,35.88 184.52,35.88 184.83,35.57 185.13,35.57 185.29,35.41 CN1.74
DDR4_A_DQS3_P: length 57.1
  TOP w0.102: U1.CB24 v1(136.16,39.26)
  T08 w0.089: v1(136.16,39.26) 136.5,39.26 136.56,39.33 arc(137.17,39.85) 137.74,39.28 137.74,39.25 arc(137.8,39.06) 137.94,38.92 arc(138.15,38.71) 138.23,38.43 138.23,38.39 arc(138.44,38.05) 138.83,38.06 arc(139.13,38.14) 139.43,38.06 arc(139.63,38) 139.83,38.06 arc(140.12,38.14) 140.42,38.06 arc(140.51,38.02) 140.61,38 140.7,38 140.72,38.02 140.79,38.02 140.8,38 140.82,38
  T08 w0.097: v1(181.19,35.47) 181.62,35.47 181.71,35.38 181.71,35.28 181.69,35.26 181.69,35.18 181.56,35.06 180.85,35.06 180.84,35.04 179.33,35.04 178.97,35.4 175.77,35.4 172.84,38.33 167.25,38.33 165.6,36.68 165.6,36.68 165.58,36.65 154.4,36.65 154.26,36.8 154.26,37 154,37.27 153.62,37.27 153.36,37 153.36,36.8 153.22,36.65 144.61,36.65 143.26,38 140.82,38
  BOTTOM w0.102: 184.55,36.09 182.9,36.09
  BOTTOM w0.109: CN1.76 185.19,35.91 185.09,35.8 184.93,35.8 184.65,36.09 184.55,36.09 ; 182.9,36.09 182.48,36.09 182.26,35.87 182,35.87 181.6,35.47 v1(181.19,35.47)
DDR4_A_DQS4_N: length 59
  TOP w0.102: U1.CD69 v1(137.15,59.29)
  T08 w0.089: v1(137.15,59.29) 136.99,59.14 arc(136.82,59.11) 136.74,59.26 136.75,59.35 arc(136.97,59.65) 137.35,59.64 arc(137.64,59.56) 137.94,59.64 arc(138.14,59.69) 138.34,59.64 arc(138.63,59.56) 138.93,59.64 arc(139.13,59.69) 139.33,59.64 arc(139.63,59.56) 139.92,59.64 arc(140.12,59.69) 140.32,59.64 140.4,59.6 arc(140.64,59.53) 140.87,59.6 141.07,59.6 141.11,59.64
  T08 w0.097: v1(182.19,63.42) 182.35,63.26 182.55,63.26 182.68,63.39 182.68,63.75 182.6,63.82 177.72,63.82 176.57,64.98 173.86,64.98 172.99,65.84 169.07,65.84 168.71,65.48 168.7,65.48 168.68,65.46 160.36,65.46 160.19,65.29 160.19,65.28 159.9,64.98 159.48,64.98 159.19,65.28 159.19,65.29 159.02,65.46 158.78,65.46 158.61,65.29 158.61,65.28 158.32,64.98 157.9,64.98 157.61,65.28 157.61,65.29 157.44,65.46 157.2,65.46 157.03,65.29 157.03,65.28 156.74,64.98 156.32,64.98 156.03,65.28 156.03,65.29 155.86,65.46 155.62,65.46 155.45,65.29 155.45,65.28 155.16,64.98 154.74,64.98 154.45,65.28 154.45,65.29 154.28,65.46 153.68,65.46 152.05,63.83 150.23,63.83 150.1,63.71 149.84,63.71 149.72,63.83 145.3,63.83 141.11,59.64
  BOTTOM w0.109: v1(182.19,63.42) 182.13,63.42 181.73,63.81 181.03,63.81 181,63.79 180.8,63.79 180.71,63.7 180.71,63.24 180.65,63.18 180.44,63.18 180.36,63.26 180.36,63.72 180.3,63.79 180.14,63.79 179.68,63.32 179.26,63.32 179.1,63.16 CN1.177
DDR4_A_DQS4_P: length 59
  TOP w0.102: U1.CB69 v1(136.16,59.29)
  T08 w0.089: v1(136.16,59.29) 136.5,59.29 136.56,59.36 arc(136.88,59.82) 137.44,59.81 arc(137.64,59.75) 137.84,59.81 arc(138.14,59.88) 138.44,59.81 arc(138.63,59.75) 138.83,59.81 arc(139.13,59.88) 139.43,59.81 arc(139.63,59.75) 139.83,59.81 arc(140.12,59.88) 140.42,59.81 140.49,59.76 arc(140.64,59.72) 140.78,59.76 140.82,59.79 140.96,59.79 140.96,59.79
  T08 w0.097: v1(183.19,63.42) 183.12,63.42 182.89,63.65 182.89,63.83 182.69,64.03 179.17,64.03 179.02,64.18 178.88,64.18 178.73,64.03 177.81,64.03 176.65,65.19 173.94,65.19 173.08,66.05 168.97,66.05 168.59,65.67 160.27,65.67 159.98,65.38 159.98,65.37 159.81,65.2 159.57,65.2 159.4,65.37 159.4,65.38 159.11,65.67 158.69,65.67 158.4,65.38 158.4,65.37 158.23,65.2 157.99,65.2 157.82,65.37 157.82,65.38 157.53,65.67 157.11,65.67 156.82,65.38 156.82,65.37 156.65,65.2 156.41,65.2 156.24,65.37 156.24,65.38 155.95,65.67 155.53,65.67 155.24,65.38 155.24,65.37 155.07,65.2 154.83,65.2 154.66,65.37 154.66,65.38 154.37,65.67 153.59,65.67 151.96,64.04 145.22,64.04 140.96,59.79
  BOTTOM w0.109: CN1.179 179.13,63.66 179.23,63.56 179.58,63.56 180.04,64.02 180.9,64.02 180.9,64.03 181.85,64.03 182.04,63.83 182.35,63.83 182.77,63.42 v1(183.19,63.42)
DDR4_A_DQS5_N: length 63.2
  TOP w0.102: U1.CL69 v1(140.12,59.29)
  T03 w0.089: v1(140.12,59.29) 139.78,59.29 139.72,59.35 arc(139.95,59.65) 140.32,59.64 arc(140.46,59.58) 140.61,59.56 140.87,59.56 141.21,59.9 141.21,60.41 141.9,61.1
  T03 w0.097: 141.9,61.1 141.9,64.53 148.48,71.11 148.89,71.11 149.03,70.97 149.03,70.29 149.3,70.03 149.67,70.03 149.94,70.29 149.94,70.97 150.08,71.11 150.28,71.11 150.42,70.97 150.42,70.29 150.68,70.03 151.06,70.03 151.32,70.29 151.32,70.97 151.47,71.11 151.67,71.11 151.81,70.97 151.81,70.29 152.07,70.03 152.45,70.03 152.71,70.29 152.71,70.97 152.85,71.11 171.5,71.11 173.68,68.92 178.8,68.92 178.98,68.75 178.98,68.55 178.92,68.49 178.92,68.29 179.06,68.15 179.26,68.15 179.32,68.21 179.52,68.21 179.89,67.84 181.69,67.84 181.97,68.12 181.97,68.24 v1(182.19,68.46)
  BOTTOM w0.109: CN1.198 185.29,68.41 185.13,68.57 184.84,68.57 184.59,68.83 184.19,68.83 184.14,68.78 184.14,68.32 184.06,68.23 183.81,68.23 183.72,68.32 183.72,68.78 183.65,68.86 182.59,68.86 v1(182.19,68.46)
DDR4_A_DQS5_P: length 63.2
  TOP w0.102: U1.CJ69 v1(139.13,59.29)
  T03 w0.089: v1(139.13,59.29) 139.47,59.29 139.53,59.36 arc(139.85,59.82) 140.42,59.81 arc(140.51,59.77) 140.61,59.75 140.79,59.75 141.02,59.98 141.02,60.52 141.68,61.18
  T03 w0.097: v1(181.19,68.46) 181.22,68.49 181.7,68.49 181.76,68.44 181.76,68.21 181.6,68.05 179.98,68.05 178.89,69.14 173.77,69.14 171.59,71.32 152.76,71.32 152.5,71.05 152.5,70.38 152.36,70.24 152.16,70.24 152.02,70.38 152.02,71.05 151.75,71.32 151.38,71.32 151.11,71.05 151.11,70.38 150.97,70.24 150.77,70.24 150.63,70.38 150.63,71.05 150.37,71.32 149.99,71.32 149.73,71.05 149.73,70.38 149.58,70.24 149.38,70.24 149.24,70.38 149.24,71.05 148.98,71.32 148.39,71.32 141.69,64.62 141.69,61.19 141.68,61.18
  BOTTOM w0.109: CN1.200 185.23,68.91 185.12,68.81 184.94,68.81 184.68,69.07 182.49,69.07 182.29,68.87 182,68.87 181.6,68.47 181.19,68.47 v1(181.19,68.46)
DDR4_A_DQS6_N: length 72.8
  TOP w0.102: U1.BM72 v1(131.21,61.01)
  T08 w0.089: 133.52,63.89 131.85,62.22 131.85,61.61 131.61,61.36 131.61,61 arc(131.56,60.83) 131.45,60.7 131.37,60.72 v1(131.21,61.01)
  T08 w0.097: 133.52,63.89 135.28,63.89 137.81,66.42 137.81,69.99 139.95,72.13 139.95,72.39 142.89,75.33 143.91,75.33 144.1,75.14 144.18,75.06 144.18,74.65 144.25,74.58 144.68,74.58 144.78,74.68 144.78,75.01 145.09,75.33 145.94,75.33 146.13,75.14 146.13,74.74 146.28,74.58 146.59,74.58 146.68,74.68 146.68,75.01 147.1,75.43 163.48,75.43 163.65,75.25 167.6,75.25 168.03,75.67 169.04,75.67 169.18,75.54 171.95,75.54 172.13,75.35 175,75.35 175.02,75.33 175.02,75.33 176.14,74.2 177.33,74.2 177.6,74.48 177.6,75.24 177.88,75.52 178.64,75.52 178.96,75.2 178.96,74.16 179.55,73.58 180.98,73.58 181.03,73.53 182.58,73.53 182.68,73.63 182.68,73.89 182.52,74.06 182.33,74.06 v1(182.19,73.92)
  BOTTOM w0.109: CN1.219 179.08,73.66 179.22,73.8 179.65,73.8 180.14,74.29 180.3,74.29 180.36,74.22 180.36,73.76 180.44,73.68 180.65,73.68 180.71,73.74 180.71,74.2 180.83,74.31 181.73,74.31 182.12,73.92 v1(182.19,73.92)
DDR4_A_DQS6_P: length 72.8
  TOP w0.102: U1.BN71 v1(131.7,60.15)
  T08 w0.089: v1(131.7,60.15) 131.53,60.45 131.56,60.54 arc(131.73,60.73) 131.8,60.99 arc(131.8,60.99) 131.8,61 131.8,61.28 132.04,61.53 132.04,62.14 132.17,62.27 132.27,62.27 132.41,62.41 132.41,62.51 132.5,62.6 132.62,62.6 132.73,62.71 132.73,62.83 133.58,63.68 133.87,63.68
  T08 w0.097: 133.87,63.68 135.37,63.68 138.02,66.33 138.02,69.9 140.16,72.04 140.16,72.3 142.98,75.12 143.83,75.12 143.97,74.97 143.97,74.56 144.16,74.37 144.77,74.37 144.99,74.59 144.99,74.92 145.18,75.12 145.86,75.12 145.92,75.05 145.92,74.65 146.19,74.37 146.68,74.37 146.89,74.59 146.89,74.92 147.18,75.21 163.39,75.21 163.57,75.04 167.69,75.04 168.11,75.46 168.96,75.46 169.09,75.33 171.86,75.33 172.04,75.14 174.91,75.14 174.93,75.12 176.06,73.99 177.42,73.99 177.81,74.39 177.81,75.15 177.97,75.31 178.55,75.31 178.75,75.11 178.75,74.08 179.46,73.37 180.89,73.37 180.94,73.32 182.66,73.32 182.9,73.55 182.9,73.67 183.15,73.92 v1(183.19,73.92)
  BOTTOM w0.109: CN1.221 179.11,74.16 179.22,74.06 179.58,74.06 180.05,74.54 181.84,74.54 182.04,74.33 182.35,74.33 182.83,73.85 183.13,73.85 v1(183.19,73.92)
DDR4_A_DQS7_N: length 79.6
  TOP w0.102: U1.BN67 v1(131.7,58.44)
  T03 w0.089: 133.2,62.41 133.26,62.36 133.26,61.71 132.8,61.25 132.8,61.12 132.79,61.12 132.79,60.99 arc(132.7,60.71) 132.49,60.5 arc(132.35,60.36) 132.29,60.16 132.29,60.13 arc(132.21,59.85) 132,59.64 arc(131.85,59.5) 131.8,59.31 131.8,59.27 arc(131.71,58.99) 131.5,58.78 arc(131.36,58.64) 131.3,58.45 131.3,58.42 arc(131.33,58.27) 131.42,58.15 131.53,58.03 131.69,58.03 131.8,58.14 131.8,58.34 v1(131.7,58.44)
  T03 w0.097: 133.2,62.41 133.2,71.77 136.86,75.43 139.61,75.43 142.3,78.12 159.1,78.12 162.73,81.75 171.93,81.75 173.87,79.81 174.69,79.81 174.96,80.08 174.96,80.83 175.1,80.97 175.3,80.97 175.44,80.83 175.44,80.08 175.71,79.81 176.08,79.81 176.35,80.08 176.35,80.83 176.49,80.97 176.69,80.97 176.83,80.83 176.83,80.08 177.09,79.81 178.18,79.81 179.66,78.34 179.98,78.34 181.03,78.34 181.57,78.34 181.83,78.61 181.83,78.78 182.02,78.97 v1(182.19,78.97)
  BOTTOM w0.109: CN1.240 185.28,78.92 185.13,79.07 184.84,79.07 184.59,79.33 184.19,79.33 184.14,79.28 184.14,78.82 184.06,78.73 183.81,78.73 183.72,78.82 183.72,79.28 183.64,79.37 182.62,79.37 182.21,78.97 v1(182.19,78.97)
DDR4_A_DQS7_P: length 79.8
  TOP w0.102: U1.BM66 v1(131.21,57.58)
  T03 w0.089: v1(131.21,57.58) 131.35,57.62 131.44,57.75 131.42,57.87 131.29,58.01 arc(131.16,58.2) 131.11,58.42 131.11,58.45 arc(131.19,58.74) 131.41,58.95 arc(131.55,59.09) 131.61,59.28 131.61,59.32 arc(131.69,59.6) 131.9,59.81 arc(132.04,59.95) 132.1,60.14 132.1,60.17 arc(132.19,60.46) 132.4,60.66 132.39,60.68 arc(132.53,60.81) 132.58,61 132.58,61.2 132.6,61.21 132.6,61.34 133.05,61.79 133.05,62.26 132.99,62.33
  T03 w0.097: v1(181.19,78.97) 181.53,78.97 181.62,78.87 181.62,78.7 181.48,78.55 179.74,78.55 178.27,80.03 177.18,80.03 177.04,80.17 177.04,80.91 176.77,81.18 176.4,81.18 176.14,80.91 176.14,80.17 175.99,80.03 175.79,80.03 175.65,80.17 175.65,80.91 175.39,81.18 175.01,81.18 174.75,80.91 174.75,80.17 174.61,80.03 173.96,80.03 172.02,81.96 162.64,81.96 159.01,78.33 142.21,78.33 139.52,75.64 136.78,75.64 132.99,71.86 132.99,62.33
  BOTTOM w0.109: v1(181.19,78.97) 181.6,78.97 182,79.37 182.31,79.37 182.52,79.58 184.67,79.58 184.94,79.31 185.12,79.31 185.23,79.42 CN1.242
DDR4_A_DQS8_N: length 52.8
  TOP w0.102: U1.CL24 v1(140.12,39.26)
  T03 w0.089: v1(140.12,39.26) 139.78,39.26 139.72,39.2 arc(139.95,38.9) 140.32,38.92 arc(140.62,38.99) 140.91,38.92 140.98,38.92
  T03 w0.097: 140.98,38.92 143.87,38.92 145.06,40.1 159.87,40.1 160.44,39.53 168.07,39.53 169.36,38.24 172.51,38.24 173.82,39.54 178.88,39.54 179.87,40.53 179.93,40.53 180.45,40.53 180.61,40.53 180.61,40.53 182.5,40.53 182.77,40.79 182.77,40.82 182.77,40.91 182.57,41.1 182.38,41.1 v1(182.19,40.92)
  BOTTOM w0.109: v1(182.19,40.92) 182.18,40.91 181.88,40.91 181.75,41.04 181.75,41.16 181.6,41.31 181.03,41.31 181,41.29 180.8,41.29 180.71,41.2 180.71,40.74 180.65,40.68 180.44,40.68 180.36,40.76 180.36,41.22 180.3,41.29 180.14,41.29 179.63,40.78 179.07,40.78 178.95,40.66 CN1.95
DDR4_A_DQS8_P: length 52.8
  TOP w0.102: U1.CJ24 v1(139.13,39.26)
  T03 w0.089: 140.98,38.71 140.96,38.71 140.95,38.71 140.89,38.71 140.89,38.71 140.87,38.71 140.86,38.73 140.82,38.75 arc(140.62,38.8) 140.42,38.75 arc(139.85,38.74) 139.53,39.2 139.47,39.26 v1(139.13,39.26)
  T03 w0.097: v1(183.19,40.92) 182.59,40.32 180.61,40.32 180.61,40.32 180.36,40.32 180.36,40.32 179.95,40.32 178.97,39.33 173.9,39.33 172.59,38.02 169.28,38.02 167.98,39.32 160.35,39.32 159.78,39.89 145.14,39.89 143.96,38.71 140.98,38.71
  BOTTOM w0.089: 180.91,41.54 181.71,41.54
  BOTTOM w0.109: v1(183.19,40.92) 182.77,40.92 182.36,41.33 181.92,41.33 181.71,41.54 ; 180.91,41.54 180.9,41.52 180.04,41.52 179.58,41.06 179.17,41.06 179.07,41.16 CN1.97
DDR4_A_ECC0: length 52.4
  TOP w0.102: U1.CL20 v1(140.12,37.55)
  T03 w0.089: 151.47,39.2 145.64,39.2
  T03 w0.097: 145.64,39.2 144.38,37.94 140.52,37.94 v1(140.12,37.55) ; v1(181.19,39.9) 181.13,39.9 181.06,39.84 180.87,39.84 180.48,39.44 180.23,39.44 179.54,38.75 178.04,38.75 177.49,38.2 177.17,38.2 177.03,38.06 177.03,37.78 176.88,37.64 176.68,37.64 176.54,37.78 176.54,38.06 176.4,38.2 176.2,38.2 176.06,38.06 176.06,37.78 175.92,37.64 175.72,37.64 175.58,37.78 175.58,38.06 175.44,38.2 175.24,38.2 175.09,38.06 175.09,37.78 174.95,37.64 174.75,37.64 174.61,37.78 174.61,38.06 174.47,38.2 174.11,38.2 172.9,36.98 169.18,36.98 168.91,37.26 168.91,37.66 167.82,38.75 151.92,38.75 151.47,39.2
  BOTTOM w0.109: CN1.92 185.25,39.91 185.03,40.13 183.99,40.13 183.36,39.49 181.99,39.49 181.59,39.9 v1(181.19,39.9)
DDR4_A_ECC1: length 52.6
  TOP w0.102: U1.CJ20 v1(139.13,37.55)
  T03 w0.097: v1(182.19,39.9) 181.84,39.9 181.35,39.41 181.05,39.41 180.57,38.93 180.33,38.93 179.72,38.32 178.77,38.32 178.56,38.11 178.56,37.91 178.85,37.62 178.85,37.42 178.71,37.28 178.51,37.28 178.22,37.57 178.02,37.57 177.56,37.11 173.97,37.11 172.83,35.97 168.7,35.97 166.46,38.22 151.72,38.22 151.46,37.96 145.54,37.96 144.91,37.33 140.59,37.33 140.33,37.08 139.95,37.08 139.48,37.55 v1(139.13,37.55)
  BOTTOM w0.109: v1(182.19,39.9) 182.26,39.97 182.26,40.27 182.12,40.41 180.95,40.41 180.85,40.32 180,40.32 179.34,39.66 CN1.91
DDR4_A_ECC2: length 52.3
  TOP w0.102: U1.CL28 v1(140.12,40.98)
  T03 w0.097: v1(140.12,40.98) 140.31,40.79 141.58,40.79 141.9,41.1 145.1,41.1 145.47,41.48 154.88,41.48 155.28,41.09 165.17,41.09 165.62,41.54 166.39,41.54 166.89,41.04 168.66,41.04 169.32,40.37 172.81,40.37 173.05,40.61 173.05,40.96 174.01,41.92 174.65,41.92 174.79,41.78 174.79,41.53 174.94,41.39 175.14,41.39 175.28,41.53 175.28,41.78 175.42,41.92 175.62,41.92 175.76,41.78 175.76,41.53 175.9,41.39 176.1,41.39 176.24,41.53 176.24,41.78 176.38,41.92 176.58,41.92 176.72,41.78 176.72,41.53 176.87,41.39 177.07,41.39 177.21,41.53 177.21,41.78 177.35,41.92 177.55,41.92 177.69,41.78 177.69,41.53 177.83,41.39 178.03,41.39 178.17,41.53 178.17,41.78 178.31,41.92 179.4,41.92 179.83,41.49 180.44,41.49 180.88,41.93 v1(181.19,41.93)
  BOTTOM w0.109: v1(181.19,41.93) 181.66,41.93 181.82,42.09 181.82,42.34 181.66,42.5 180.86,42.5 180.78,42.59 180.78,42.72 180.69,42.81 180.14,42.81 180.05,42.72 180.05,42.41 179.86,42.22 179.74,42.22 179.52,42.43 179.37,42.43 179.1,42.16 CN1.101
DDR4_A_ECC3: length 52.6
  TOP w0.102: U1.CJ28 v1(139.13,40.98)
  T03 w0.097: v1(183.19,42.93) 182.75,42.49 173.5,42.49 172.48,41.47 168.24,41.47 167.7,42.01 165.45,42.01 164.96,41.52 159.01,41.52 158.62,41.91 157.76,41.91 157.65,41.79 157.65,41.73 157.54,41.62 157.38,41.62 157.27,41.73 157.27,41.79 157.15,41.91 156.99,41.91 156.88,41.79 156.88,41.73 156.77,41.62 156.61,41.62 156.49,41.73 156.49,41.79 156.38,41.91 156.22,41.91 156.11,41.79 156.11,41.73 155.99,41.62 155.83,41.62 155.72,41.73 155.72,41.79 155.61,41.91 145.18,41.91 144.91,41.64 141.77,41.64 141.3,41.17 140.6,41.17 140.32,41.33 arc(140.12,41.38) 139.92,41.33 139.89,41.31 v1(139.13,40.98)
  BOTTOM w0.109: v1(183.19,42.93) 183.19,43.24 183.09,43.33 182.01,43.33 181.89,43.21 181.49,43.21 181.33,43.37 180.54,43.37 180.33,43.16 CN1.105
DDR4_A_ECC4: length 52.5
  TOP w0.102: U1.CM18 v1(140.62,36.69)
  T03 w0.097: v1(140.62,36.69) 152.7,36.69 153.73,37.72 165.37,37.72 165.95,37.14 166.15,37.14 166.25,37.24 166.45,37.24 166.59,37.09 166.59,36.89 166.49,36.79 166.49,36.59 166.64,36.45 166.84,36.45 166.94,36.55 167.14,36.55 167.28,36.41 167.28,36.21 167.18,36.11 167.18,35.91 168.13,34.96 172.69,34.96 174.26,36.53 178.62,36.53 180.53,38.44 181.35,38.44 181.63,38.72 181.63,39.03 182,39.4 182.69,39.4 v1(183.19,38.9)
  BOTTOM w0.109: v1(183.19,38.9) 183.37,38.9 183.97,39.5 184.51,39.5 184.6,39.4 184.6,38.49 184.69,38.4 185.04,38.4 185.14,38.5 185.14,38.77 185.28,38.91 CN1.88
DDR4_A_ECC5: length 52.5
  TOP w0.102: U1.CK18 v1(139.63,36.69)
  T03 w0.097: v1(182.19,38.9) 182.19,38.74 182.06,38.6 182.06,38.55 181.53,38.02 181.05,38.02 180.64,37.61 180.64,37.28 178.55,35.19 178.14,35.19 178.02,35.08 178.02,35.06 177.91,34.94 177.75,34.94 177.64,35.06 177.64,35.08 177.52,35.19 177.36,35.19 177.25,35.08 177.25,35.06 177.14,34.94 176.98,34.94 176.86,35.06 176.86,35.08 176.75,35.19 176.59,35.19 176.48,35.08 176.48,35.06 176.37,34.94 176.21,34.94 176.09,35.06 176.09,35.08 175.98,35.19 175.82,35.19 175.71,35.08 175.71,35.06 175.59,34.94 175.43,34.94 175.32,35.06 175.32,35.08 175.21,35.19 175.05,35.19 174.93,35.08 174.93,35.06 174.82,34.94 174.66,34.94 174.55,35.06 174.55,35.08 174.44,35.19 173.83,35.19 172.59,33.95 168.11,33.95 166.04,36.02 166.04,36.04 165.49,36.59 153.59,36.59 153.14,36.14 140.48,36.14 139.93,36.69 v1(139.63,36.69)
  BOTTOM w0.109: CN1.87 180.16,38.66 180.83,39.33 181.36,39.33 181.79,38.9 v1(182.19,38.9)
DDR4_A_ECC6: length 52.3
  TOP w0.102: U1.CM26 v1(140.62,40.12)
  T03 w0.097: v1(140.62,40.12) 141.45,40.12 141.86,40.53 145.13,40.53 145.65,41.06 145.66,41.06 145.66,41.05 154.1,41.05 154.49,40.66 166.68,40.66 167.02,40.32 168.63,40.32 168.87,40.07 168.87,39.63 169.12,39.38 172.83,39.38 173.67,40.22 173.67,40.22 173.79,40.34 173.79,40.75 173.93,40.89 174.13,40.89 174.27,40.75 174.27,40.34 174.41,40.2 174.61,40.2 174.75,40.34 174.75,40.56 174.85,40.66 175.14,40.66 175.23,40.56 175.23,40.34 175.38,40.2 177.42,40.2 177.56,40.34 177.56,40.44 177.7,40.58 177.9,40.58 178.04,40.44 178.04,40.34 178.18,40.2 178.5,40.2 179.37,41.07 180.7,41.07 181.02,41.39 182.03,41.39 182.19,41.55 v1(182.19,41.93)
  BOTTOM w0.109: v1(182.19,41.93) 182.58,41.93 183.04,41.48 183.65,41.48 183.74,41.56 183.74,42.04 183.83,42.14 184.07,42.14 184.16,42.05 184.16,41.65 184.25,41.56 184.55,41.56 184.66,41.67 184.66,41.85 184.71,41.91 CN1.100
DDR4_A_ECC7: length 52.4
  TOP w0.102: U1.CK26 v1(139.63,40.12)
  T03 w0.089: 141.58,42.01 141.91,42.33 143.49,42.33 ; 144.84,42.33 146.19,42.33
  T03 w0.097: 146.19,42.33 160.38,42.33 160.77,41.94 164.7,41.94 165.19,42.43 172.63,42.43 173.14,42.94 180.43,42.94 180.84,43.35 181.36,43.35 181.79,42.92 182.18,42.92 v1(182.19,42.93) ; 141.58,42.01 140.93,41.36 140.65,41.36 140.42,41.49 arc(140.12,41.57) 139.83,41.49 arc(139.67,41.44) 139.51,41.45 138.97,41.45 138.73,41.22 138.73,40.97 arc(138.79,40.77) 138.93,40.63 138.96,40.62 v1(139.63,40.12) ; 143.49,42.33 144.84,42.33
  BOTTOM w0.109: CN1.104 184.79,42.91 184.65,43.05 184.65,43.32 184.56,43.41 183.88,43.41 183.79,43.32 183.79,42.5 183.66,42.38 182.74,42.38 v1(182.19,42.93)
DDR4_A_ODT0: length 55.2
  TOP w0.102: v1(137.64,53.86) U1.CF56
  TOP w0.109: v1(183.03,57.02) 182.54,57.02 181.91,57.65 v1(181.35,57.65)
  T03 w0.089: v1(137.64,53.86) 138.31,53.36 138.34,53.35 arc(138.48,53.2) 138.54,53.01 arc(138.55,52.96) 138.58,52.92 138.9,52.6 139.34,52.6 139.72,52.98 139.72,53.01 arc(139.93,53.35) 140.32,53.35 140.33,53.34 arc(140.62,53.27) 140.91,53.35 arc(141.01,53.39) 141.12,53.4 141.74,53.4 141.8,53.46
  T03 w0.097: v1(183.03,57.02) 182.64,56.62 181.75,56.62 181.6,56.78 181.11,56.78 180.91,56.58 180.65,56.58 180.45,56.78 180.11,56.78
  T03 w0.102: 179.84,57.06 180.11,56.78
  T03 w0.152: 179.84,57.06 173.47,57.06 173.31,56.9 173.13,56.9 172.71,56.48 ; 168.68,56.61 155.79,56.61 155.28,56.1 144.44,56.1 141.8,53.46
  T03 w0.159: 172.71,56.48 172.26,56.48 172.03,56.71 171.75,56.71 171.47,56.43 171.22,56.43 170.86,56.79 170.58,56.79 170.2,56.41 170,56.41 169.73,56.68 169.38,56.68 169.19,56.49 168.8,56.49 168.68,56.61
  BOTTOM w0.171: v1(181.35,57.65) 180.94,57.65 180.44,58.15 179.98,58.15 179.49,57.66 CN1.155
DDR4_A_ODT1: length 55.2
  TOP w0.102: U1.CM60 v1(140.62,55.57)
  T03 w0.102: 168.63,58.69 170.89,58.69 171.17,58.97 171.45,58.97 171.73,58.69 171.98,58.69 172.41,59.12 173.09,59.12 ; v1(181.35,59.15) 181.2,59 180.67,59 180.42,58.75 179.9,58.75
  T03 w0.152: 173.09,59.12 173.36,59.12 173.5,59.26 178.01,59.26 178.01,59.26 179.38,59.26 179.9,58.75 ; 140.74,55.7 141.93,55.7 144.56,58.32 144.56,58.86 144.9,59.2 151.97,59.2 151.97,59.19 152.2,58.96 156.92,58.96 157.56,58.33 157.94,58.33 158.07,58.46 158.07,58.84 158.19,58.96 158.58,58.96 158.7,58.84 158.7,58.33 158.83,58.2 159.21,58.2 159.34,58.33 159.34,58.84 159.46,58.96 159.85,58.96 159.97,58.84 159.97,58.33 160.1,58.2 160.48,58.2 160.61,58.33 160.61,58.84 160.71,58.94 161.14,58.94 161.24,58.84 161.24,58.33 161.37,58.2 161.75,58.2 161.88,58.33 161.88,58.84 161.98,58.94 162.39,58.94 162.51,58.81 162.51,58.33 162.66,58.18 163.02,58.18 163.15,58.31 163.15,58.84 163.27,58.96 163.66,58.96 163.78,58.84 163.78,58.33 163.93,58.18 164.29,58.18 164.42,58.31 164.42,58.84 164.54,58.96 164.93,58.96 165.05,58.84 165.05,58.33 165.2,58.18 167.5,58.18 168.02,58.69 168.63,58.69
  T03 w0.159: v1(140.62,55.57) 140.74,55.7
  BOTTOM w0.171: v1(181.35,59.15) 180.95,59.56 180.55,59.56 180.47,59.64 179.52,59.64 179.05,59.16 CN1.161
DDR4_A_PAR: length 63.3
  TOP w0.102: U1.CM49 v1(140.62,50.42)
  T08 w0.152: v1(140.62,50.42) 140.8,50.24 151.45,50.24 154.62,53.4 154.98,53.4 155.16,53.22 155.16,52.77 155.33,52.59 155.59,52.59 155.76,52.77 155.76,53.22 155.94,53.4 156.2,53.4 156.37,53.22 156.37,52.77 156.55,52.59 156.81,52.59 156.98,52.77 156.98,53.22 157.16,53.4 157.42,53.4 157.59,53.22 157.59,52.77 157.77,52.59 158.02,52.59 158.2,52.77 158.2,53.22 158.38,53.4 158.63,53.4 158.81,53.22 158.81,52.77 158.99,52.59 159.24,52.59 159.42,52.77 159.42,53.22 159.6,53.4 159.85,53.4 160.03,53.22 160.03,52.77 160.21,52.59 160.46,52.59 160.64,52.77 160.64,53.22 160.82,53.4 161.07,53.4 161.25,53.22 161.25,52.77 161.43,52.59 161.68,52.59 161.86,52.77 161.86,53.22 162.04,53.4 162.29,53.4 162.47,53.22 162.47,52.77 162.65,52.59 162.9,52.59 163.08,52.77 163.08,53.22 163.26,53.4 173.53,53.4 173.7,53.22 173.7,52.71 173.88,52.53 174.14,52.53 174.31,52.71 174.31,53.22 174.49,53.4 174.75,53.4 174.92,53.22 174.92,52.71 175.1,52.53 175.35,52.53 175.53,52.71 175.53,53.22 175.71,53.4 175.96,53.4 176.14,53.22 176.14,52.71 176.32,52.53 176.57,52.53 176.75,52.71 176.75,53.22 176.93,53.4 177.18,53.4 177.36,53.22 177.36,52.71 177.54,52.53 177.79,52.53 177.97,52.71 177.97,53.22 178.15,53.4 178.4,53.4 178.58,53.22 178.58,52.71 178.76,52.53 179.01,52.53 179.19,52.71 179.19,53.22 179.37,53.4 180.83,53.4 v1(181.35,52.88)
  BOTTOM w0.165: v1(181.35,52.88) 181.52,53.05 181.79,53.05 181.95,53.21 181.95,53.44 181.8,53.6 179.45,53.6 179.36,53.51 179.36,52.94 179.09,52.66 CN1.143
