# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IRQ_SERIAL_ST: length 3.4
  TOP w0.109: v3(90.89,68.94) U16.4 91.66,70.23 92.05,69.84 R209.1
IRQ_SERIRQ_DATA: length 95
  TOP w0.089: U1.AE75 119.57,63.11 119.23,63.44 119.23,63.74 119.45,63.96 119.45,64.52 119.27,64.7
  TOP w0.109: v1(119.9,67.14) 119.85,67.14 119.27,66.56 119.27,64.7 ; v3(86.69,68.94) R208.1
  T03 w0.097: v1(119.9,67.14) 118.44,67.14 117.9,67.68 116.59,67.68 116.46,67.81 116.46,68.11 115.92,68.65 115.72,68.65 115.62,68.56 115.62,67.52 115.53,67.43 115.33,67.43 115.24,67.52 115.24,68.56 115.14,68.65 114.95,68.65 114.85,68.56 114.85,67.52 114.75,67.43 114.56,67.43 114.46,67.52 114.46,68.56 114.37,68.65 108.95,68.65 108.86,68.56 108.86,67.95 108.76,67.85 108.57,67.85 108.47,67.95 108.47,68.56 108.37,68.65 108.06,68.65 107.97,68.56 107.97,67.61 107.87,67.52 107.68,67.52 107.58,67.61 107.58,68.56 107.48,68.65 107.29,68.65 107.19,68.56 107.19,67.61 107.1,67.52 106.9,67.52 106.81,67.61 106.81,68.56 106.71,68.65 106.52,68.65 106.42,68.56 106.42,67.61 106.33,67.52 106.13,67.52 106.04,67.61 106.04,68.56 105.94,68.65 105.75,68.65 105.65,68.56 105.65,67.61 105.55,67.52 105.36,67.52 105.26,67.61 105.26,68.56 105.17,68.65 104.97,68.65 104.88,68.56 104.88,67.61 104.78,67.52 104.59,67.52 104.49,67.61 104.49,68.56 104.4,68.65 104.2,68.65 104.11,68.56 104.11,67.61 104.01,67.52 103.82,67.52 103.72,67.61 103.72,68.56 103.62,68.65 103.43,68.65 103.33,68.56 103.33,67.61 103.24,67.52 103.04,67.52 102.95,67.61 102.95,68.56 102.85,68.65 102.66,68.65 102.56,68.56 102.56,67.61 102.46,67.52 102.27,67.52 102.18,67.61 102.18,68.56 102.08,68.65 101.89,68.65 101.79,68.56 101.79,67.61 101.69,67.52 101.5,67.52 101.4,67.61 101.4,68.56 101.31,68.65 101.11,68.65 101.02,68.56 101.02,67.61 100.92,67.52 100.73,67.52 100.63,67.61 100.63,68.56 100.53,68.65 100.34,68.65 100.24,68.56 100.24,67.61 100.15,67.52 99.96,67.52 99.86,67.61 99.86,68.56 99.76,68.65 99.57,68.65 99.47,68.56 99.47,67.61 99.38,67.52 99.18,67.52 99.09,67.61 99.09,68.56 98.99,68.65 98.8,68.65 98.7,68.56 98.7,67.61 98.6,67.52 98.41,67.52 98.31,67.61 98.31,68.56 98.22,68.65 98.02,68.65 97.93,68.56 97.93,67.61 97.83,67.52 97.64,67.52 97.54,67.61 97.54,68.56 97.45,68.65 97.25,68.65 97.16,68.56 97.16,67.61 97.06,67.52 96.87,67.52 96.77,67.61 96.77,68.56 96.67,68.65 96.48,68.65 96.38,68.56 96.38,67.61 96.29,67.52 96.09,67.52 96,67.61 96,68.56 95.9,68.65 95.71,68.65 95.61,68.56 95.61,67.61 95.52,67.52 95.32,67.52 95.23,67.61 95.23,68.56 95.13,68.65 94.83,68.65 94.54,68.37 94.02,68.37 93.93,68.27 93.93,67.61 93.83,67.52 93.64,67.52 93.54,67.61 93.54,68.27 93.44,68.37 93.25,68.37 93.15,68.27 93.15,67.61 93.06,67.52 92.86,67.52 92.77,67.61 92.77,68.27 92.67,68.37 92.48,68.37 92.38,68.27 92.38,67.61 92.29,67.52 92.09,67.52 92,67.61 92,68.27 91.9,68.37 91.71,68.37 91.61,68.27 91.61,67.61 91.51,67.52 91.32,67.52 91.22,67.61 91.22,68.27 91.13,68.37 90.93,68.37 90.84,68.27 90.84,67.61 90.74,67.52 90.55,67.52 90.45,67.61 90.45,68.27 90.36,68.37 90.16,68.37 90.07,68.27 90.07,67.61 89.97,67.52 89.78,67.52 89.68,67.61 89.68,68.27 89.58,68.37 89.39,68.37 89.29,68.27 89.29,67.61 89.2,67.52 89,67.52 88.91,67.61 88.91,68.27 88.81,68.37 88.62,68.37 88.52,68.27 88.52,67.61 88.42,67.52 88.23,67.52 88.14,67.61 88.14,68.27 88.04,68.37 87.85,68.37 87.75,68.27 87.75,67.61 87.65,67.52 87.46,67.52 87.36,67.61 87.36,68.27 v3(86.69,68.94)
IRQ_SERIRQ_DATA_ST: length 3.3
  TOP w0.109: U16.3 88.17,70.23 88.03,70.37 R208.2 87.5,69.49 v3(88.18,68.82)
IRQ_SERIRQ_DIR: length 49.8
  TOP w0.089: U1.AD74 119.2,62.12 v1(119.53,61.79)
  TOP w0.109: v3(96.42,72.96) 96.34,72.89 94.48,72.89 94.39,72.79 R293.1 94.39,72.36 94.28,72.24 94.25,72.24 93.53,71.52 93.29,71.52 92.84,71.06 92.84,70.86 R288.2 92.76,70.88 U16.5
  T03 w0.089: v1(119.53,61.79) 120.74,63.01 122.08,63.01 124.05,64.98 124.05,66.31
  T03 w0.097: 124.05,66.31 124.05,68.13 121.71,70.47 120.57,70.47 120.34,70.7 120.34,71.31 120.19,71.46 119.58,71.46 118.99,72.04 113.17,72.04 111.81,73.4 111.81,73.68 111.17,74.32 106.68,74.32 106.22,73.85 103.94,73.85 103.74,74.05 103.74,74.05 103.21,74.59 99.16,74.59 97.25,72.69 96.7,72.69 v3(96.42,72.96)
  BOTTOM w0.109: v2(95.77,73.98) 96.4,73.35 96.4,72.98 v3(96.42,72.96)
JTAG_PCH_TCK: length 19.9
  TOP w0.089: U1.BM3 131.87,29.37 131.87,28.59 131.66,28.38 131.66,27.82 131.7,27.78 131.7,23.26 133.16,21.8 134.16,21.8 134.35,21.61
  TOP w0.109: R464.1 R185.1 v3(135.6,14.89) 136.07,15.35 136.07,19.89 134.35,21.61
JTAG_PCH_TDI: length 11.1
  TOP w0.089: U1.BM5 131.95,29.94 132.28,29.6 132.28,29.3 132.1,29.12 132.1,28.5 132.23,28.37 132.23,28.05 132.08,27.89 132.08,25.79 v1(132.48,25.39)
  BOTTOM w0.089: v1(132.48,25.39) 133.21,25.39 133.49,25.67 133.99,25.67 v2(134.48,25.18) 134.75,24.91 134.75,22.27 R462.2
JTAG_PCH_TDO: length 6.1
  TOP w0.089: U1.BK3 130.96,29.38 130.8,29.22 130.8,28.51 130.64,28.36 130.64,27.12 130.52,27 130.52,25.5 v1(130.9,25.11)
  BOTTOM w0.089: TP3.1 130.34,25.67 v1(130.9,25.11)
JTAG_PCH_TMS: length 8.7
  TOP w0.089: v1(130.88,24.2) 130.33,24.74 130.33,27.08 130.46,27.21 U1.BJ2
  BOTTOM w0.089: R463.2 127.35,24.4 v2(129.73,24.4) 130.67,24.4 v1(130.88,24.2)
JTAG_TCK: length 76.2
  TOP w0.109: J8.1 20.48,16.95 18.99,15.47 18.99,13.81 R369.1 19.56,14.22 v3(19.63,14.29) ; U31.P3 v1(44.15,47.28)
  T05 w0.097: v3(19.63,14.29) 24.77,19.43 28.11,19.43 28.51,19.02 28.51,18.27 27.95,17.7 27.95,14.65 28.52,14.08 33.16,14.08 36.04,16.95 36.04,20.36 37.5,21.82 37.5,23.08 37.5,30.75 36.2,32.05 36.2,35.09 36.8,35.7 36.8,36.64 36.35,37.1 36.34,37.1 36.17,37.27 36.17,41.06 37.5,42.39 38.02,42.92 38.02,42.92 38.2,43.09 40.96,45.85 41.71,45.85 42.18,45.85 43.61,47.28 v1(44.15,47.28)
  BOTTOM w0.109: v3(19.63,14.29) 19.56,14.37 19.56,15.64 22.71,18.79 R86.1 22.71,20.16 R308.2
JTAG_TDI: length 201.6
  TOP w0.109: R368.2 20.57,13.81 v3(20.8,14.04) 20.8,14.87 21.38,15.44 24.2,15.44 25.07,14.58 25.9,14.58 26.18,14.86 26.18,15.39 26.34,15.55 30.5,15.55 31.34,16.39 J8.9 ; U31.L6 v1(47.15,44.28)
  T03 w0.097: v3(124.97,3.31) 124.87,3.31 124.21,3.97 124.21,11.59 122.57,13.22 97.68,13.22 96.05,11.59 94.25,11.59 93.34,10.68 92.56,10.68 91.95,11.29 89.5,11.29 88.74,10.53 85.78,10.53 85.17,11.14 80.18,11.14 79.9,10.86 78.03,10.86 77.65,11.24 76.16,11.24 75.77,10.86 73.91,10.86 71.19,13.58 57.06,13.58 54.86,11.38 51.26,11.38 50.86,10.98 48.56,10.98 46.79,12.75 39.28,12.75 37.08,10.56 v3(34.54,10.56)
  T05 w0.097: v3(20.8,14.04) 20.8,13.81 21.43,13.18 36.22,13.18 40.41,17.37 40.41,20.59 38.7,22.31 38.7,31.7 38.3,32.1 38.3,33.94 38.7,34.33 38.7,41.89 41.42,44.62 42.83,44.62 43.38,45.18 45.47,45.18 46.02,44.62 46.81,44.62 v1(47.15,44.28)
  T10 w0.097: v3(34.54,10.56) 32.13,12.97 21.69,12.97 20.8,13.86 v3(20.8,14.04)
  BOTTOM w0.109: v3(20.8,14.04) 20.8,14.79 24.49,18.47 R88.1 ; R48.2 v3(124.97,3.31)
JTAG_TDO: length 180.7
  TOP w0.109: v3(27.91,18.81) 27.53,18.43 24.38,18.43 23.72,17.77 J8.3 ; U31.M5 v1(46.15,45.28)
  T05 w0.097: v3(127.98,11.21) 128.41,11.64 128.41,12.4 128.16,12.65 128.05,12.65 124.28,16.42 119.66,16.42 119.03,15.8 109.71,15.8 109.49,16.02 v3(102.72,16.02) ; v3(27.91,18.81) 26.01,16.91 24.64,16.91 24.49,16.75 24.49,13.88 24.89,13.48 36.09,13.48 40.11,17.5 40.11,20.38 38.4,22.1 38.4,31.47 37.87,31.99 37.87,34.09 38.4,34.61 38.4,42.02 38.57,42.19 38.57,42.19 41.33,44.96 42.68,44.96 43.28,45.56 45.87,45.56 v1(46.15,45.28)
  T08 w0.097: v3(27.91,18.81) 27.91,15.79 28.19,15.51 28.19,14.49 29.62,13.07 72.72,13.07 73.58,12.21 80.01,12.21 82.47,14.67 84.84,14.67 85.29,14.21 87.56,14.21 88.01,14.67 88.47,14.67 89.26,15.46 102.16,15.46 v3(102.72,16.02)
  BOTTOM w0.109: R92.1 R366.2 27.66,18.56 v3(27.91,18.81) ; v3(127.98,11.21) 128.65,11.88 128.65,12.29 R49.2
JTAG_TMS: length 146.1
  TOP w0.109: J8.5 26.26,16.5 25.65,15.89 v3(25.65,15.23) ; U31.N4 v1(45.15,46.28) ; v3(105.66,16.9) 105.99,16.57 R47.2
  T05 w0.097: v3(25.65,15.23) 25.65,14.32 26.19,13.78 33.69,13.78 36.32,16.41 36.32,16.81 36.34,16.83 36.34,20.15 37.8,21.61 37.8,30.98 36.5,32.27 36.5,34.92 37.1,35.51 37.1,36.77 36.47,37.39 36.47,40.94 37.8,42.27 37.8,42.27 38.15,42.62 38.15,42.62 38.32,42.79 38.32,42.79 41.08,45.56 41.58,45.56 41.58,45.55 42.41,45.55 43.14,46.28 v1(45.15,46.28)
  T08 w0.097: v3(25.65,15.23) 25.65,15.24 25.65,15.89 26.71,16.94 26.71,18.72 27.23,19.24 35.53,19.24 36.83,17.95 64.87,17.95 65.25,17.57 83.65,17.57 84.41,18.32 98.15,18.32 98.78,18.96 103.6,18.96 v3(105.66,16.9)
  BOTTOM w0.109: R367.2 28.19,20.7 28.17,20.67 R94.1 28.17,19.85 28.39,19.63 28.39,18.6 25.65,15.86 25.65,15.24 v3(25.65,15.23)
KR_EPHY_RBIAS: length 2.3
  TOP w0.152: U1.P56 v1(114.86,53.86)
  BOTTOM w0.102: v1(114.86,53.86) 115.17,53.86 115.9,54.58 R1.1
KR_EPHY_REFCLK_IN: length 11
  TOP w0.109: U1.J58 111.61,54.43 111.25,54.07 110.75,54.07 110.54,54.28 110.54,54.31 110.31,54.54 110.02,54.54 109.82,54.34 109.52,54.34 109.32,54.54 109.02,54.54 108.72,54.24 108.46,54.24 108.07,54.63 106.51,54.63 v2(105.67,55.47) 105.49,55.65 C17.1 102.28,55.65 Y1.1
KR_EPHY_REFCLK_OUT: length 12.5
  TOP w0.089: v2(105.58,56.74) 105.55,56.74
  TOP w0.109: U1.F58 110.52,54.81 110.04,54.81 109.82,55.04 109.52,55.04 109.32,54.84 109.03,54.84 109,54.86 109,54.86 108.82,55.04 108.53,55.04 108.36,54.86 107.46,54.86 v2(105.58,56.74) ; 105.55,56.74 C18.1 104.08,56.74 103.97,56.62 100.97,56.62 100.57,57.02 Y1.3
LAN_10GE_P0_MDIO_DIR_1V05: length 11
  TOP w0.109: R284.1 v3(101.74,61.23)
  TOP w0.152: U1.E75 v1(109.88,63.09)
  T10 w0.089: v1(109.88,63.09) 105.55,63.09
  T10 w0.097: v3(101.74,61.23) 102.53,62.01 103.58,62.01 104.66,63.09 105.55,63.09
  BOTTOM w0.109: R284.1 v3(101.74,61.23)
LAN_10GE_P1_MDIO_DIR_1V05: length 3.5
  TOP w0.108: U1.N72 v1(113.63,61.88)
  BOTTOM w0.102: v2(113.34,64.63) 113.33,64.62 R278.2 R283.1 113.33,62.18 v1(113.63,61.88)
LAN_I2C0_SCL_1V05_R: length 12.9
  TOP w0.109: R8.1 104.75,61.48 105,61.23 v3(105.13,61.23)
  TOP w0.152: U1.R72 v1(114.37,61.01)
  T10 w0.102: v1(114.37,61.01) 114.27,61.01 113.87,60.6 113.59,60.6 113.33,60.34 113.33,60.33
  T10 w0.109: 113.33,60.33 113,60 106.99,60 105.76,61.23 v3(105.13,61.23)
  BOTTOM w0.089: 105.55,60.82 106.08,60.29 v2(106.08,60.28)
  BOTTOM w0.109: 105.55,60.82 105.15,61.22 105.14,61.22 v3(105.13,61.23)
LAN_I2C0_SDA_1V05_R: length 14.2
  TOP w0.108: U1.U72 115.85,60.36 115.53,60.04 114.95,60.04 114.85,60.14 v1(114.85,60.14)
  TOP w0.109: v3(105.11,60.49) 104.96,60.34 R7.1
  T10 w0.102: v3(105.11,60.49) 105.87,60.49 106.65,59.71 114.42,59.71 114.85,60.14 v1(114.85,60.14)
  BOTTOM w0.109: v2(104.31,59.8) 104.77,60.26 104.88,60.26 v3(105.11,60.49)
LAN_I2C1_SCL_1V05_R: length 13.4
  TOP w0.152: U1.P71 114.32,60.44 113.93,60.83 113.54,60.83 v1(113.36,61.01)
  T10 w0.102: v1(105.89,61.74) 106.56,61.07 109.76,61.07 110.26,60.57 112.93,60.57 v1(113.36,61.01)
  BOTTOM w0.089: R10.1 109.3,61.36 109.15,61.51 v2(106.77,61.51) 106.22,61.51
  BOTTOM w0.109: v1(105.89,61.74) 106.12,61.51 106.22,61.51
LAN_I2C1_SDA_1V05_R: length 1.3
  TOP w0.152: U1.T71 115.36,61 v1(115.36,61.01)
  BOTTOM w0.089: v1(115.36,61.01) 115.59,60.78 R9.1
LAN_MDC0_I2C_CLK_1V05: length 65.6
  TOP w0.152: v1(115.86,59) 115.86,59.58 U1.U69
  T08 w0.089: v1(115.86,59) 115.86,59.95 115.19,60.61 110.87,60.61 108.92,58.66 108.92,47.91 106.32,45.32 105.55,45.32
  T08 w0.097: v3(86.95,24.42) 88.3,25.77 90.37,25.77 94.88,30.28 94.88,35.98 99.64,40.75 99.64,44.66 100.3,45.32 105.55,45.32
  BOTTOM w0.109: U5.2 89.16,26.28 88.24,25.37 87.96,25.37 87.01,24.42 v3(86.95,24.42) 86.89,24.42 86.43,23.96 86.01,23.96 85.55,24.42 v2(85.55,25.69) 84.7,26.54 R14.1
LAN_MDC0_I2C_CLK_3V3: length 89.6
  T03 w0.097: v3(92.2,20.83) 91.92,21.11 85.61,21.11 85.55,21.17 85.54,21.17 85.12,21.58 77.47,21.58 76.35,20.46 50.8,20.46 48.9,22.36 34.69,22.36 33.07,20.74 33.07,17.97 32.41,17.31 28.97,17.31 26.8,15.14 v3(26.8,14.96)
  BOTTOM w0.109: J10.A9 23.35,11.55 26.75,14.96 v3(26.8,14.96) ; R451.2 94.57,26.07 94.95,25.69 94.95,23.72 v2(94.49,23.26) 93.68,23.26 92.2,21.78 v3(92.2,20.83)
LAN_MDC0_I2C_CLK_3V3_R: length 2.5
  BOTTOM w0.109: U5.7 92,26.28 92.07,26.34 v2(92.08,26.34) 92.87,26.34 R451.1
LAN_MDIO0_I2C_DATA_1V05: length 68.8
  TOP w0.152: U1.W69 116.84,59.03 116.84,59.02 v1(116.84,59.01)
  T08 w0.089: v1(116.84,59.01) 116.84,59.98 115.75,61.06 115.75,61.17 115.52,61.4 111.23,61.4 108.66,58.83 108.66,48.04 106.24,45.62 105.55,45.62
  T08 w0.097: v3(86.19,24.4) 86.19,24.42 88.18,26.41 90.59,26.41 94.58,30.4 94.58,36.22 99.34,40.99 99.34,44.79 100.18,45.62 105.55,45.62
  BOTTOM w0.109: 86.19,24.42 v2(87.71,25.94) 88.45,26.68 U5.3 ; 86.19,24.42 v3(86.19,24.4) ; 86.19,24.42 86.19,26.58 85.17,27.59 R15.1
LAN_MDIO0_I2C_DATA_3V3: length 91.2
  T03 w0.097: v3(27.43,14.62) 27.43,15.34 29.1,17.01 32.59,17.01 33.43,17.85 33.43,20.67 34.82,22.06 48.74,22.06 50.72,20.08 76.43,20.08 77.63,21.28 85,21.28 85.41,20.87 85.43,20.87 85.48,20.81 89.86,20.81 90.37,20.31 92.43,20.31 v3(92.96,20.84)
  BOTTOM w0.109: R452.2 v2(95.06,27.09) 95.31,26.84 95.31,23.2 94.75,22.63 94.24,22.63 92.96,21.35 v3(92.96,20.84) ; J10.A10 24.35,11.79 27.18,14.62 v3(27.43,14.62)
LAN_MDIO0_I2C_DATA_3V3_R: length 3
  BOTTOM w0.109: U5.6 91.31,26.68 92.08,27.45 v2(92.08,27.61) 92.62,27.61 R452.1
LAN_NCSI_RXD0: length 21.6
  TOP w0.089: v1(117.34,59.86) 117.34,59.87 U1.Y71
  TOP w0.109: v3(101.68,62.77) 101.55,62.65 100.54,62.65 100.19,62.3 R290.2 R295.1
  T03 w0.089: v1(117.34,59.86) 117.29,59.86 116.92,60.23 116.92,61.12 116.65,61.39 116.4,61.39 116.16,61.63 116.16,62.14 115.9,62.39 111.59,62.39 111.07,61.88 107.1,61.88 106.58,62.39 105.72,62.39 105.55,62.56
  T03 w0.097: v3(101.68,62.77) 101.81,62.77 102.1,63.07 105.05,63.07 105.55,62.56
LAN_NCSI_RXD1: length 20.9
  TOP w0.089: v1(117.34,61.01) 117.12,61.01 116.84,61.29 U1.W72
  TOP w0.109: v3(100.62,64) 100.58,63.97 100.58,63.96 100.19,63.57 R272.2 R277.1
  T03 w0.089: 105.55,63.09 105.96,62.69 116.62,62.69 117.05,62.27 117.05,61.38 117.34,61.09 v1(117.34,61.01)
  T03 w0.097: v3(100.62,64) 100.66,64.04 104.6,64.04 105.55,63.09
LAN_NCSI_TRI_EN_L: length 8.6
  TOP w0.109: R256.1 118.25,71.24 118.25,69.61 118.1,69.46 R251.2 118,69.2 118,68.38 v2(118.01,68.37) 118,68.36 118,67.96 118.89,67.07 118.89,65.73 118.97,65.65 118.97,64.44 U1.AD78
LAN_SMBCLK: length 26.2
  TOP w0.089: v1(122.45,65.93) 122.45,65.01 122.54,64.92 122.54,64.11 122.88,63.77 122.88,63.44 122.54,63.11 U1.AM75
  TOP w0.109: v3(110.13,73.6) 110.03,73.6 R469.1
  T03 w0.089: v1(123.57,67.58) 123.57,68.22 122.6,69.18 122.57,69.18 122.27,69.48
  T03 w0.097: v3(110.13,73.6) 111.79,71.95 111.79,71.74 111.88,71.64 118.87,71.64 119.35,71.17 119.35,70.66 119.51,70.5 120.02,70.5 120.4,70.12 121.64,70.12 122.27,69.48
  BOTTOM w0.089: 122.91,69.48 123.51,68.88 123.51,68.3 123.57,68.25 v1(123.57,67.58) 122.95,66.96 122.95,66.42 v1(122.45,65.93)
  BOTTOM w0.109: v2(123.06,69.93) 122.91,69.78 122.91,69.48
LAN_SMBDATA: length 70.8
  TOP w0.089: U1.AM77 122.35,63.79 122.35,64.85 122.06,65.14
  TOP w0.109: v1(122.44,66.56) 122.05,66.17 122.05,65.15 122.06,65.14 ; v3(108.35,73.3) 108.33,73.31 R468.1
  T08 w0.089: 121.97,69.48 121.97,67.04 v1(122.44,66.56)
  T08 w0.097: v3(67.91,68.36) 68.52,68.97 69.56,68.97 70.3,68.23 70.81,68.23 71.14,67.9 79.78,67.9 81.07,69.19 81.07,69.61 81.43,69.97 96.49,69.97 97.38,69.08 102.46,69.08 106.68,73.3 v3(108.35,73.3) 108.35,73.78 108.44,73.88 109.43,73.88 109.7,73.6 109.7,73.4 109.98,73.12 111.84,73.12 112.6,73.88 114.4,73.88 115.57,72.71 117.88,72.71 118.34,72.25 120.3,72.25 121.97,70.59 121.97,69.48
  BOTTOM w0.109: v2(67.53,66.84) 67.91,67.22 v3(67.91,68.36)
LED_CPLD_1: length 10
  TOP w0.109: U31.B3 v1(57.13,47.28)
  TOP w0.254: Q5.5 55.07,53.36 54.84,53.12 54.84,52.69 54.83,52.68 v3(54.83,51.66)
  BOTTOM w0.254: v1(57.13,47.28) 57.58,47.73 57.58,51.06 57.07,51.56 54.93,51.56 v3(54.83,51.66)
LED_CPLD_1_R: length 3.6
  TOP w0.254: R383.1 54.61,58.54 54.2,58.13 v3(54.2,57.8) D6.1
  BOTTOM w0.254: v2(54.6,56.45) 54.6,57.4 v3(54.2,57.8)
LED_CPLD_2: length 10.7
  TOP w0.109: 56.1,49.82 56.1,48.25 U31.C2
  TOP w0.254: 56.1,49.82 v3(55.85,50.07) 55.34,50.58 52.74,50.58 52.42,50.9 52.42,52.78 52.99,53.36 Q5.2
  BOTTOM w0.254: v3(55.85,50.07) 56.53,50.76 v2(56.53,50.83)
LED_CPLD_2_R: length 3.3
  TOP w0.254: R382.1 55.98,58.41 55.6,58.03 v3(55.6,57.8) D5.1
  BOTTOM w0.254: v3(55.6,57.8) 55.6,57.56 56.29,56.88 v2(56.29,56.53)
LED_CPLD_3: length 8.2
  TOP w0.109: 58.64,49.82 58.64,48.79 v1(58.13,48.28) U31.A2
  TOP w0.254: Q4.2 59.68,53.36 60.04,52.99 60.04,52.12 58.64,50.72 58.64,49.82
  BOTTOM w0.254: v2(59.26,48.28) v1(58.13,48.28)
LED_CPLD_3_R: length 2.8
  TOP w0.254: D4.1 v3(57.51,57.8) 57.5,57.81 R381.1
  BOTTOM w0.254: v2(57.51,58.99) v3(57.51,57.8)
LED_CPLD_4: length 5.6
  TOP w0.254: U31.B1 56.79,48.94 v1(56.79,49.54) 56.79,51.93 56.3,52.42 56.3,52.99 56.67,53.36 Q4.5
LED_CPLD_4_R: length 2.8
  TOP w0.254: D3.1 v3(58.9,57.8) 58.9,57.93 58.9,57.94 R380.1
  BOTTOM w0.254: v2(58.9,56.62) v3(58.9,57.8)
LPC_FRAME_L: length 122.5
  TOP w0.109: v3(42.04,25.34) 41.71,25.34 40.34,23.97 40.34,23.65 40.25,23.56 40.25,19.03 39.56,18.34 J1.3 ; U31.T11 v1(41.99,38.79)
  T05 w0.097: v1(41.99,38.79) 41.63,38.43 41.63,31.67 42.82,30.47 42.82,26.13 v3(42.04,25.34) 42.04,23.87 44.51,21.4 44.51,18.82 45.77,17.55 53.72,17.55 55.21,19.05 67.91,19.05 69.05,17.91 77.74,17.91 79.7,15.95 81.7,15.95 v3(83.92,13.73)
  T08 w0.097: v3(117.63,16.25) 117.63,15.79 115.26,13.42 91.39,13.42 89.21,11.24 86.41,11.24 v3(83.92,13.73)
  BOTTOM w0.109: J10.A68 84.35,13.3 v3(83.92,13.73) ; v3(42.04,25.34) 42.67,25.97 v2(42.82,25.97) ; v3(117.63,16.25) 117.68,16.25 118.14,16.7 118.14,17.34 R54.2
LPC_FRAME_L_R: length 11.4
  TOP w0.089: 121.05,26.3 U1.AH1
  TOP w0.109: 121.05,26.3 121.05,24.97 120.21,24.12 120.14,24.12 119.95,23.94 119.95,23.31 119.64,23 119.64,22.63 118.46,21.45 v3(118.46,20.85)
  BOTTOM w0.109: R54.1 118.48,18.47 119.09,19.08 119.09,20.23 118.47,20.85 v3(118.46,20.85)
LPC_LAD0: length 116.9
  TOP w0.109: v3(41.71,25.97) 39.56,23.83 J1.4 ; U31.T10 v1(42.04,39.79)
  T05 w0.097: v1(42.04,39.79) 41.91,39.79 41.23,39.11 41.23,28.16 41.71,27.68 v3(41.71,25.97) 41.45,25.72 41.45,23.87 44.1,21.21 44.1,18.57 45.52,17.15 53.88,17.15 55.38,18.64 67.75,18.64 68.88,17.51 77.5,17.51 79.46,15.55 80.91,15.55 81.04,15.55 83.41,13.17 88.65,13.17 v3(89.36,12.46)
  T08 w0.097: v3(89.36,12.46) 90.72,13.83 114.06,13.83 114.62,14.38 114.76,14.38 114.89,14.25 115.02,14.25 115.16,14.39 115.16,14.53 115.03,14.66 115.03,14.79 115.17,14.93 115.3,14.93 115.43,14.8 115.57,14.8 115.71,14.93 115.71,15.07 115.58,15.2 115.58,15.34 115.71,15.47 115.85,15.47 115.98,15.34 116.12,15.34 116.25,15.48 116.25,15.62 116.12,15.75 116.12,15.88 116.54,16.3 v3(116.66,16.3)
  BOTTOM w0.109: v3(41.71,25.97) 41.25,25.52 v2(40.69,25.52) ; R58.2 116.93,17.13 116.66,16.86 v3(116.66,16.3) ; J10.A73 89.35,9.84 89.33,9.86 89.33,9.93 89.05,10.21 89.05,12.16 v3(89.36,12.46)
LPC_LAD0_R: length 13.3
  TOP w0.089: 120.35,26.46 120.35,28.53 120.14,28.73 120.14,29.36 U1.AF3
  TOP w0.109: 120.35,26.46 120.27,26.38 120.27,25.21 119.42,24.37 117.99,24.37 116.93,23.31 v3(116.93,20.85)
  BOTTOM w0.109: R58.1 v3(116.93,20.85)
LPC_LAD1: length 118.4
  TOP w0.109: J1.10 45.56,23.63 45.45,23.74 44.9,23.74 42.68,25.96 42.68,26.2 41.56,27.32 v3(41.17,27.32) ; U31.T9 v1(41.91,40.79)
  T05 w0.097: v1(41.91,40.79) 41.91,40.37 40.82,39.28 40.82,27.67 v3(41.17,27.32) 41.17,26.01 40.97,25.81 40.97,23.74 43.7,21.01 43.7,18.4 45.35,16.75 54.05,16.75 55.54,18.24 67.58,18.24 68.72,17.11 77.27,17.11 79.23,15.15 80.87,15.15 83.24,12.77 87.7,12.77 v3(87.78,12.69)
  T08 w0.097: v3(116.16,17.16) 116.16,17.06 113.72,14.63 89.87,14.63 87.93,12.69 v3(87.78,12.69)
  BOTTOM w0.109: J10.A72 88.35,8.13 88.92,8.69 88.92,9.76 88.49,10.19 88.49,11.98 v3(87.78,12.69) ; R57.2 115.65,17.66 116.13,17.18 116.14,17.18 v3(116.16,17.16)
LPC_LAD1_R: length 15.7
  TOP w0.089: U1.AG4 120.56,29.46 120.9,29.12 120.9,28.81 120.77,28.68 120.77,25.03 119.76,24.02 119.76,23.74 119.27,23.25
  TOP w0.109: 119.27,23.25 v2(118.64,22.62) 118.02,22 118.02,20.44 116.2,18.62 v3(116.2,18.3)
  BOTTOM w0.109: v3(116.2,18.3) 116.2,18.31 116.04,18.47 R57.1 v2(114.62,19.26)
LPC_LAD2: length 120.8
  TOP w0.109: v3(40.61,26.48) 40.69,26.56 41.74,26.56 42.27,26.03 42.27,25.79 43.81,24.24 43.81,23.26 43.56,23 J1.8 ; U31.T8 41.92,41.79 v1(41.91,41.8) ; v3(87.58,11.93) 87.58,10.59 86.96,9.97 86.96,8.61 87.35,8.22 J10.B71 ; R56.2 117.43,17.16 v3(117.55,17.16)
  T05 w0.097: v3(87.58,11.93) 87.14,12.37 83.08,12.37 80.7,14.74 79.06,14.74 77.1,16.71 68.38,16.71 67.25,17.84 55.71,17.84 54.22,16.35 45.19,16.35 43.3,18.23 43.3,20.82 40.46,23.66 40.46,26.33 v3(40.61,26.48) 40.42,26.67 40.42,39.48 41.32,40.38
  T05 w0.109: v1(41.91,41.8) 41.32,41.21 41.32,40.38
  T08 w0.097: v3(87.58,11.93) 87.78,11.93 90.08,14.23 113.9,14.23 116.37,16.7 116.37,16.7 116.83,17.16 v3(117.55,17.16)
  BOTTOM w0.109: v3(40.61,26.48) 39.7,26.48 v2(39.67,26.51)
LPC_LAD2_R: length 13.5
  TOP w0.089: 120.06,22.22 121.26,23.41 121.26,27.96 121.34,28.05 121.34,28.68 121.21,28.81 121.21,29.09 121.57,29.44 U1.AL3
  TOP w0.109: R56.1 116.93,18.71 v2(119.57,21.34) 120.06,21.83 120.06,22.22
LPC_LAD3: length 120.9
  TOP w0.109: v3(86.87,11.88) 86.87,11.5 86.52,11.15 86.52,8.35 86.35,8.18 J10.B70 ; R55.2 115.3,17.53 115.3,17.03 v3(115.41,16.92) ; J1.7 43.56,19.57 v3(42.27,20.87) ; U31.T7 v1(41.91,42.79)
  T05 w0.097: v3(86.87,11.88) 86.76,11.88 86.67,11.97 82.91,11.97 82.21,12.67 73.46,12.67 69.82,16.3 68.22,16.3 67.08,17.44 55.88,17.44 54.38,15.95 44.9,15.95 42.9,17.95 42.9,20.23 v3(42.27,20.87) 40.02,23.11 40.02,40.77 40.36,41.11 40.61,41.11 41.91,42.41 v1(41.91,42.79)
  T08 w0.097: v3(115.41,16.92) 113.52,15.03 89.71,15.03 88.69,14.01 88.55,14.01 88.4,14.16 88.27,14.16 88.13,14.03 88.13,13.89 88.28,13.74 88.28,13.6 87.9,13.22 86.28,13.22 86.06,13 86.06,12.62 86.15,12.52 86.77,12.52 86.87,12.43 v3(86.87,11.88)
  BOTTOM w0.109: v2(42.99,21.59) v3(42.27,20.87)
LPC_LAD3_R: length 12.6
  TOP w0.089: 120.06,26.34 U1.AF1
  TOP w0.109: R55.1 115.44,19.95 115.57,20.08 v3(115.57,20.13) 115.57,22.77 117.58,24.78 119.25,24.78 120.06,25.59 120.06,26.34
LVC1_LAN_NCSI_ARB_OUT: length 9.6
  TOP w0.089: U1.AB78 118.08,64.45 117.75,64.78
  TOP w0.109: 117.75,64.78 117.75,67.6 117.39,67.96 v2(116.33,67.96) 115.71,68.58 R270.2 115.92,69.46 116.22,69.76 116.22,71.24 R276.1
LVC3_IRQ_CPU_CATERR_L: length 12.1
  TOP w0.109: U31.C8 v1(56.13,42.28) ; U10.7 64.89,37.26 64.49,37.66 64.22,37.66 62.66,39.21 60.93,39.21 v3(60.69,39.45)
  BOTTOM w0.109: v3(60.69,39.45) 59.02,39.45 56.19,42.28 v1(56.13,42.28)
LVC3_RISER1_ID4_N_PU: length 12.9
  TOP w0.089: 127.82,21.61 127.82,27.53 128.27,27.99 128.27,28.56 127.99,28.85 U1.BD3
  TOP w0.109: 127.82,21.61 128.79,20.63 128.79,19.72 128.92,19.58 128.92,19.29 v3(129.51,18.7) R165.2
LVC3_RST_CPU_RESET_L: length 25.5
  TOP w0.089: U31.A11 57.75,38.9 58.77,38.9
  TOP w0.109: v3(60.83,38.47) 61.27,38.47 C175.1 61.39,38.9 58.77,38.9 ; U13.6 71.61,28.22 71,28.82 71,29.58 v3(69.88,30.7)
  T05 w0.097: v3(60.83,38.47) 60.86,38.47 65.38,33.95 65.38,32.91 67.39,30.89 69.69,30.89 v3(69.88,30.7)
  BOTTOM w0.109: v2(59.66,38.47) v3(60.83,38.47)
M2_ACT: length 3.5
  BOTTOM w0.109: v2(55.5,68.72) 55.21,68.44 TP10.1 55.3,67.43 J9.10
M2_CONFIG_0: length 3.6
  BOTTOM w0.109: J9.21 v2(67.48,70.19) 69.11,70.19 R392.2
M2_CONFIG_1: length 4.5
  BOTTOM w0.109: J9.69 v2(67.5,82.19) 69.03,82.19 R393.2 R391.1
M2_CONFIG_2: length 3.5
  BOTTOM w0.109: J9.75 v2(67.86,83.69) 69.12,83.69 R394.2
MANUFACTURING_DET_L: length 1.3
  TOP w0.152: U1.BB27 127.91,40.49 v1(127.92,40.56)
  BOTTOM w0.102: v1(127.92,40.56) 127.92,40.49 127.55,40.13 R91.2
ME_RCVR_L: length 91.8
  TOP w0.109: R301.1 v3(140.18,14.89) ; v3(95.53,12.39) 95.53,10.68 94.97,10.13 94.97,8.8 95.35,8.43 J10.B79
  TOP w0.152: U1.BP9 v1(132.2,32.39)
  T05 w0.097: v3(140.18,14.89) 140.18,13.23 139.45,12.5 139.45,9.31 137.79,7.66 137.79,5.3 136.88,4.38 126.29,4.38 125.09,5.57 125.09,11.62 122.84,13.87 98.21,13.87 96.75,12.41 95.55,12.41 v3(95.53,12.39)
  T08 w0.089: v1(132.2,32.39) 132.27,32.32 132.27,31.39 132.31,31.35 132.31,29.87 133.69,28.49 133.69,23.44 135.52,21.61 135.8,21.61
  T08 w0.097: 135.8,21.61 138.22,19.18 138.22,18.52 140.35,16.4 140.35,15.07 v3(140.18,14.89)
  BOTTOM w0.109: R301.1 v3(140.18,14.89)
MUX_HDR_SEL_L: length 14.6
  TOP w0.109: R222.1 168.81,3.22 v3(169.09,3.22)
  BOTTOM w0.109: U20.19 178.91,4.22 178.89,4.19 178.88,4.19 178.61,3.92 178.61,2.93 178.14,2.46 174.76,2.46 174.26,2.95 174.26,3.52 U20.1 173.79,3.57 172.52,2.3 170.52,2.3 169.61,3.22 v3(169.09,3.22)
NC_LAN_JTCK: length 1.6
  TOP w0.152: U1.G74 v1(111.63,61.87)
  BOTTOM w0.089: v1(111.63,61.87) 111.63,62.62 v2(111.42,62.82)
NC_LAN_JTMS: length 1.6
  TOP w0.089: v1(109.19,62.3) 109.36,62.47 U1.C76
  BOTTOM w0.102: v1(109.19,62.3) 108.46,62.3 v2(108.3,62.14)
NC_LAN_JTRST_N: length 1.6
  TOP w0.089: v1(113.85,60.17) 113.85,60.15 113.87,60.14 U1.N69
  BOTTOM w0.089: v1(113.85,60.17) 113.85,60.17 v2(112.81,60.17)
NMI_EVENT_L: length 113.6
  TOP w0.089: U1.BP1 133.09,28.06 133.09,25.29 v1(132.5,24.7)
  TOP w0.109: v3(52.5,60.33) 52.2,60.04 51.23,60.04 51.11,60.16 U29.2 51.11,61.98 R333.2
  T03 w0.097: v3(97.41,24.27) 96.51,25.17 90.96,25.17 89.64,23.84 88.97,23.84 83.31,29.5 83.31,30.14 81.12,32.33 81.12,37.78 75.89,43.01 67.88,43.01 67.61,43.28 64.74,43.28 62.79,45.22 62.79,50.98 61.94,51.83 61.34,51.83 60.69,52.48 60.69,53.08 56.03,57.74 56.03,58.13 55.58,58.59 54.74,58.59 52.99,60.33 v3(52.5,60.33)
  T05 w0.089: 119.27,23.84 120.1,24.67 122.06,24.67 122.56,25.16 124.21,25.16 124.58,25.53 131.67,25.53 v1(132.5,24.7)
  T05 w0.097: 119.27,23.84 115.39,23.84 115.02,24.2 112.39,24.2 112.15,23.96 107.58,23.96 107.12,23.5 98.19,23.5 v3(97.41,24.27)
  BOTTOM w0.109: v3(97.41,24.27) v2(97.41,23.26)
NMI_EVENT_L_BUF: length 10.1
  TOP w0.109: R330.2 50.45,58.69 U29.4 50.46,59.34 50.7,59.58 52.31,59.58 52.63,59.9 52.68,59.9 52.93,60.15 52.93,60.82 53.34,61.23 56.01,61.23 56.9,60.34 v3(56.9,60.15)
NMI_EVENT_L_R: length 5.1
  TOP w0.109: R330.1 51.26,56.3 R327.2 52.28,56.28 v3(52.29,56.27)
  BOTTOM w0.109: v2(53.54,55.51) 53.54,55.56 52.83,56.27 v3(52.29,56.27) 52.26,56.29 51,56.29 U30.10
P_CPU_ALERT: length 4.2
  TOP w0.203: PU17.32 76.7,74.28 v3(76.17,73.75) 76.16,73.75 75.32,72.91 PR172.2
  BOTTOM w0.109: v2(76.35,74.71) 76.38,74.67 76.38,73.96 v3(76.17,73.75)
P_CPU_B-RAMP_10: length 5.4
  TOP w0.254: PU17.11 81.81,75.08 82.42,74.47 82.42,74.08 82.72,73.78 83.29,73.78 83.54,73.52 PR147.1 83.55,73.33 PR144.2
  TOP w0.381: PR144.2 83.44,72.38 82.91,72.91 v3(82.88,72.91)
P_CPU_CCOMP+_10: length 1.9
  TOP w0.254: PC190.1 73.62,80.07 PR150.2
  TOP w0.381: v3(72.66,80.94) PR150.2
P_CPU_CCOMP_10: length 7.3
  TOP w0.254: PR151.1 73.64,78.32 PC190.2 PC191.2 PR134.2 75.41,78.73 75.78,78.37 v3(75.79,78.37) 75.79,78.29 75.91,78.16 75.91,77.31 76.55,76.68 PU17.26
  BOTTOM w0.381: v2(75.05,78.95) 75.2,78.95 v3(75.79,78.37)
P_CPU_CCSN1+_10: length 8.5
  TOP w0.381: PNTC2.1 116.61,92.57 v3(116.34,92.85)
  BOTTOM w0.381: PR119.2 v2(112.9,90.31) 112.44,90.78 112.44,91.57 113,92.14 115.74,92.14 116.21,92.61 116.21,92.62 116.31,92.72 116.31,92.82 v3(116.34,92.85)
P_CPU_CCSN1_10: length 42.4
  TOP w0.254: PU17.18 80.05,78.65 80.75,79.35 PC168.1 80.77,79.67 80.77,80.33 v3(80.86,80.42)
  T08 w0.254: v3(113.07,85.13) 113.07,85.12 112.35,84.39 108.64,84.39 107.55,83.3 84.25,83.3 81.37,80.42 v3(80.86,80.42)
  BOTTOM w0.254: v3(113.07,85.13) 113.07,84.06 113.14,84 v2(113.14,83.99)
  BOTTOM w0.381: PR121.2 112.92,88 PR119.1 112.9,87.39 113.07,87.22 PR118.1 v3(113.07,85.13)
P_CPU_CCSN2+_10: length 8.3
  TOP w0.381: v3(111.46,79.77) 111.46,76.24 110.67,75.45 PNTC3.1
  BOTTOM w0.381: v3(111.46,79.77) 112.14,79.77 112.39,79.53 PR126.2 112.9,80.79 v2(112.65,81.04)
P_CPU_CCSN2_10: length 48.3
  TOP w0.254: v3(80.1,81.17) 80.04,81.1 PC178.1 80.04,79.53 79.65,79.14 PU17.19
  T08 w0.254: v3(113.07,75.94) 113.02,75.99 113.02,75.99 112.89,76.12 112.89,76.2 112.39,76.7 104.57,76.7 102.93,75.05 95.38,75.05 94.58,74.25 92.1,74.25 91.62,74.74 90.12,74.74 86.52,78.34 81.92,78.34 80.1,80.16 v3(80.1,81.17)
  BOTTOM w0.254: v2(114.23,77.57) 113.94,77.87 PR128.2
  BOTTOM w0.381: PR156.1 80.09,79.95 80.09,81.15 v3(80.1,81.17) ; v3(113.07,75.94) PR125.1 113.07,78.54 PR126.1 112.92,78.73 PR128.2
P_CPU_CCSP1+_10: length 2.4
  BOTTOM w0.381: v2(110.74,86.76) 111.04,87.05 111.04,88 ; 111.04,88 PR120.2 ; 111.04,88 PR117.1
P_CPU_CCSP1_10: length 50.3
  TOP w0.254: PU17.17 80.45,78.16 81.04,78.75 81.05,78.75 81.5,79.2 81.5,79.21 81.55,79.26 81.55,79.64 PC168.2 81.53,79.67 81.53,81.35 v3(81.63,81.44)
  TOP w0.381: PNTC2.2 116.88,93.38 116.65,93.61 116.02,93.61 115.89,93.48 115.73,93.48 115.45,93.2 v3(115.45,92.92)
  T08 w0.254: v3(112.35,85.12) 112.01,84.78 108.48,84.78 107.39,83.68 83.79,83.68 81.63,81.52 v3(81.63,81.44)
  BOTTOM w0.381: v3(115.45,92.92) 115.42,92.9 112.69,92.9 111.67,91.88 111.67,89.76 111.88,89.56 PR117.2 111.89,88.02 111.89,87.39 112.26,87.02 PR118.2 112.26,85.21 v3(112.35,85.12)
P_CPU_CCSP2+_10: length 3.2
  BOTTOM w0.381: PR124.1 110.91,78.86 PR127.2 109.72,78.65 109.72,77.23 v2(109.41,76.92)
P_CPU_CCSP2_10: length 48.6
  TOP w0.254: v3(79.29,81.17) 79.29,80.35 PC178.2 79.25,80.26 PU17.20
  TOP w0.381: PNTC3.2 111.48,75.16 v3(112.26,75.94)
  T08 w0.254: v3(112.26,75.94) 111.96,76.24 104.82,76.24 103.12,74.54 95.52,74.54 94.71,73.74 91.91,73.74 91.41,74.23 89.97,74.23 89.6,74.61 86.34,77.87 81.63,77.87 81.33,78.16 81.32,78.16 79.27,80.21 79.27,81.15 v3(79.29,81.17)
  BOTTOM w0.381: PR125.2 112.26,78.37 PR124.2 ; PR125.2 111.84,77.69 v2(111.26,77.11) ; PR125.2 v3(112.26,75.94) ; v3(79.29,81.17) 79.27,81.15 79.27,79.75 PR155.2
P_CPU_CGFB_10: length 4.7
  TOP w0.254: PU17.23 78.05,78.35 77.83,78.56 77.83,79.04 v3(77.82,79.05) 77.85,79.09 77.85,80.08 PR153.1
  BOTTOM w0.254: v3(77.82,79.05) 77.75,79.12 77.75,80.23 78.17,80.65 v2(78.19,80.65)
P_CPU_CPWM1_10: length 43
  TOP w0.254: v3(79.85,72.68) 79.65,72.88 PU17.6
  TOP w0.381: v3(95.79,85.2) 96.73,85.2 PR130.1
  T03 w0.381: v3(95.79,85.2) 94.88,84.29 75.64,84.29 74.25,82.89 74.25,80.02 73.96,79.73 73.96,74.54 75.52,72.98 75.52,72.66 77.12,71.07 79.24,71.07 79.8,71.62 79.8,72.63 v3(79.85,72.68)
  BOTTOM w0.381: v3(79.85,72.68) 79.8,72.73 v2(79.8,73.59)
P_CPU_CPWM1_DR1_10: length 2.2
  TOP w0.381: PR130.2 97.7,86.42 v3(97.68,86.44) 97.77,86.53 PU18.12
P_CPU_CPWM2_10: length 22.5
  TOP w0.254: v3(78.85,72.02) 79.25,72.42 PU17.5
  TOP w0.381: v3(93.22,75.52) 93.25,75.52 93.53,75.24 94.69,75.24 PR131.1
  T03 w0.381: v3(93.22,75.52) 92.94,75.24 90,75.24 89.27,74.52 86.75,74.52 86.47,74.8 86.1,74.8 84.46,76.43 82.61,76.43 79.81,73.63 79.45,73.63 78.85,73.02 v3(78.85,72.02)
  BOTTOM w0.381: v3(78.85,72.02) 78.54,71.71 v2(77.96,71.71)
P_CPU_CPWM2_DR2_10: length 4.6
  TOP w0.254: PR131.2 95.91,75.2 97.4,76.69 v3(97.4,76.84) 97.4,76.87 97.77,77.24 PU19.12
  BOTTOM w0.381: v3(97.4,76.84) 97.99,77.43 v2(97.99,77.77)
P_CPU_CPWM3_10: length 7.6
  TOP w0.254: v3(79.95,69.04) 79.72,69.27 79.72,70.77 79.49,71.01 PR202.1 78.89,71.01 78.18,71.71 78.18,72.19 78.32,72.33 78.32,72.34 78.85,72.86 PU17.4
  BOTTOM w0.152: v2(80.99,67.98) 80.87,67.98 79.95,68.89 v3(79.95,69.04)
P_CPU_CTHWEM_10: length 6.7
  TOP w0.254: PNTC4.2 PR133.1 PC192.1 83.16,76.06 82.94,76.28 PU17.14
  TOP w0.381: v3(86.53,75.79) 86.51,75.79 86.5,75.81 86.05,75.81 85.83,76.03 PNTC4.2
  BOTTOM w0.381: v2(85.6,75.81) 86.5,75.81 86.53,75.78 v3(86.53,75.79)
P_CPU_CVFB_10: length 4.7
  TOP w0.254: PR154.2 76.96,79.82 v3(77.22,79.56) 77.22,78.62 77.65,78.2 PU17.24
  BOTTOM w0.254: v3(77.22,79.56) 77.22,80.53 76.96,80.8 v2(76.85,80.8)
P_CPU_DR1_BST_20: length 3.8
  TOP w0.381: PC165.2 95.67,87.77 v3(96.29,88.4) 96.42,88.4 97.08,89.06 PU18.9
  BOTTOM w0.381: v3(96.29,88.4) 96.42,88.53 v2(97.25,88.53)
P_CPU_DR1_BST_RC_20: length 3.1
  TOP w0.381: PC165.1 94.58,87.77 v3(94.02,88.32) 94.33,88.63 PR114.2
  BOTTOM w0.381: v2(92.96,88.45) 93.9,88.45 v3(94.02,88.32)
P_CPU_DR1_BSTR_20: length 3.8
  TOP w0.305: v3(96.53,89.7) 96.67,89.56 PU18.8
  TOP w0.381: v3(96.53,89.7) 96.53,89.68 96.05,89.19 PR114.1
  BOTTOM w0.381: v2(95.15,89.44) 95.4,89.7 v3(96.53,89.7)
P_CPU_DR1_LX_40: length 7
  TOP w0.381: PL10.1 v3(110,89.55)
  BOTTOM w0.381: v2(110,90.72) v3(110,89.55) 110.05,89.5 PR120.1 ; v3(106.4,90.47) 107.7,90.47 109.01,89.16 PC167.1
P_CPU_DR2_BST_20: length 3.8
  TOP w0.254: PU19.9 96.68,79.02 96.36,78.71 v3(96.36,78.67) 96.33,78.67 95.55,77.89 PC186.2
  BOTTOM w0.381: v3(96.36,78.67) 97.15,78.67 v2(97.33,78.85)
P_CPU_DR2_BST_RC_20: length 2.8
  TOP w0.254: PR115.2 94.2,78.44 94.1,78.34 94.1,78.32 94,78.21 v3(94,78.19) 94.41,78.19 PC186.1
  BOTTOM w0.381: v3(94,78.19) v2(94.66,78.85)
P_CPU_DR2_BSTR_20: length 3.7
  TOP w0.305: PU19.8 v3(96.46,79.53) 95.96,79.53 PR115.1
  BOTTOM w0.381: v2(97.43,80.35) 96.61,79.53 v3(96.46,79.53)
P_CPU_DR2_LX_40: length 5.1
  TOP w0.381: PL13.1 v3(109.98,80.41)
  BOTTOM w0.381: PC177.1 107.19,79.64 v3(106.73,80.1) ; PR127.1 109.92,80.35 v3(109.98,80.41) 110.06,80.49 v2(110.06,81.61)
P_CPU_DROOP_10: length 7.2
  TOP w0.254: PU17.25 76.7,77.08 76.39,77.4 v3(76.39,79.1) 76.39,79.52 75.86,80.05 PR134.1 PC191.1 74.52,80.85 PR150.1
  BOTTOM w0.109: v3(76.39,79.1) 76.39,79.28 75.76,79.9 v2(75.76,80.09)
P_CPU_ENABLE_10: length 5
  TOP w0.254: PU17.8 80.45,73.36 80.88,72.93 v3(81,72.93) 81.26,72.68 81.26,71.75 80.51,71 PR152.2
  BOTTOM w0.109: v3(81,72.93) 81.79,72.15 v2(81.79,71.92)
P_CPU_F-IMAX_10: length 8.8
  TOP w0.109: v3(83.94,68.86) 83.67,69.13 PR148.1
  TOP w0.254: PR148.1 PR145.2 83.55,71.54 83.21,71.54 82.22,72.53 82.22,73.63 81.96,73.89 81.96,74.27 81.55,74.68 PU17.10
  BOTTOM w0.109: v2(84.05,67.69) 83.94,67.81 v3(83.94,68.86)
P_CPU_IMON_10: length 4
  TOP w0.254: PC193.1 PR143.2 83.34,75.15 v3(83.01,75.48) 82.6,75.88 PU17.13
P_CPU_O-USR_10: length 5.5
  TOP w0.254: v3(83.06,70.98) 82.92,70.98 82.85,71.04 PR146.2 82.24,71.03 PR149.1 81.3,71.14 81.72,71.56 81.72,73.32 81,74.03 PU17.9
P_CPU_OCP-I_10: length 5.7
  TOP w0.254: PR141.1 83.86,74.23 PR143.1 83.03,74.34 v3(82.98,74.38) 82.94,74.42 82.94,74.73 82.19,75.48 PU17.12
  BOTTOM w0.381: v3(82.98,74.38) 82.18,74.38 v2(81.78,74.78)
P_CPU_SB1_20: length 4
  BOTTOM w0.381: PC167.2 v2(107.06,88.86) 107.06,86.53 PR116.1
P_CPU_SB2_20: length 4.8
  BOTTOM w0.381: PR123.1 108.88,80.9 PC177.2 108.88,79.14 108.46,78.71 v2(108.46,78.38)
P_CPU_SKIP#_1_10: length 4.3
  TOP w0.254: PU18.10 97.24,88.56 96.46,87.78 96.46,87.46 v3(96.28,87.28) 95.94,87.28 PR122.2
  BOTTOM w0.381: v2(95.24,87.74) 95.7,87.28 v3(96.28,87.28)
P_CPU_SKIP#_2_10: length 4.3
  TOP w0.254: PU19.10 97,78.52 96.36,77.88 v3(96.36,77.79) PR129.2
  BOTTOM w0.381: v3(96.36,77.79) 95.65,77.79 v2(95.19,77.33)
P_CPU_SKIP#_10: length 34.2
  TOP w0.254: PR122.1 94.3,86.88 94.04,87.14 v3(93.97,87.14) ; PR129.1 94.59,77.12 v3(93.97,77.12) ; v3(80.75,72.04) 80.75,72.07 80.47,72.35 80.47,72.78 80.05,73.21 PU17.7
  T03 w0.381: v3(93.97,77.12) 94.11,77.12 95.05,76.18 95.05,74.91 94.39,74.25 90.26,74.25 89.64,73.63 86.2,73.63 85.92,73.91 85.16,73.91 83.49,72.25 80.95,72.25 v3(80.75,72.04)
  T10 w0.254: v3(93.97,77.12) 94.25,77.12 94.89,77.76 94.89,86.3 94.05,87.14 v3(93.97,87.14)
  BOTTOM w0.381: v2(92.98,86.82) 93.29,87.13 93.87,87.13 93.87,87.14 v3(93.97,87.14)
P_CPU_SLEWA_10: length 6.1
  TOP w0.254: PU17.15 81.85,76.68 83.03,77.87 83.87,77.87 PR140.1 PR142.2 83.9,80.15 v3(84.17,80.42)
P_CPU_V5A_10: length 7.7
  TOP w0.254: PU17.28 75.99,75.88 75.48,76.39 v3(75.2,76.39) 74.92,76.11 74.34,76.11 PR138.2 74.51,75.9 PC188.1
  BOTTOM w0.109: v2(73.75,78.98) 74.39,78.34 74.39,77.2 v3(75.2,76.39)
P_CPU_VBAT_10: length 5.7
  TOP w0.254: PU17.16 81.36,77.08 81.7,77.42
  TOP w0.381: PR132.2 82.62,81.91 v3(82.62,79.04) 82.62,78.34 81.7,77.42
P_CPU_VCLK: length 3
  TOP w0.254: PR171.2 75.44,73.8 76.32,74.68 PU17.31
P_CPU_VDD_10: length 6
  TOP w0.254: PC187.1 76.88,71.09 75.89,71.09 PR139.2 75.96,71.6 76.12,71.6 v3(77.26,72.74) 77.46,72.94 77.76,72.94 78.05,73.23 PU17.2
  BOTTOM w0.381: v2(77.23,73.68) 77.26,73.65 v3(77.26,72.74)
P_CPU_VDIO: length 5.7
  TOP w0.203: PR170.2 74.84,72.28 75.69,72.28 v3(76.47,73.06) 77.14,73.73 PU17.1
  BOTTOM w0.109: v2(75.61,71.64) 76.35,72.37 76.35,72.93 v3(76.47,73.06)
P_CPU_VREF_10: length 34.3
  TOP w0.254: PNTC4.1 86.27,76.88 86.58,76.57 v3(86.58,76.51) ; PU17.27 77.08,76.29 76.23,76.29 75.36,77.16 v3(75.36,77.43) 74.63,77.43 PC189.1 74.5,77.32 PR151.2 ; PR142.1 v3(85.49,79.52)
  TOP w0.381: v3(82.12,68.94) 82.22,69.04 82.22,70.2 PR146.1 ; PR145.1 84.35,72.37 PR144.1 v3(85.19,72.38)
  T05 w0.254: v3(82.12,68.94) 83.12,68.94 85.19,71.01 v3(85.19,72.38) 85.01,72.56 85.01,74.94 86.02,75.95 86.02,76 86.32,76.3 86.37,76.3 v3(86.58,76.51) 81.43,76.51 80.71,77.22 75.61,77.22 75.41,77.43 v3(75.36,77.43)
  BOTTOM w0.254: v3(85.49,79.52) 85.49,77.66 86.58,76.57 v3(86.58,76.51)
P_DDR4_ALERT: length 3.2
  TOP w0.152: v3(198.72,31.18) 198.7,31.16 198.7,30.78 197.85,29.94 PU21.32
  BOTTOM w0.109: v3(198.72,31.18) 199.05,31.51 PR182.2
P_DDR4_B-RAMP: length 5.7
  TOP w0.254: PU21.11 192.82,29.14 192.01,29.95 v3(192.01,30.11)
  TOP w0.381: PR176.1 PR165.2 192.01,30.11 v3(192.01,30.11)
  BOTTOM w0.381: v3(192.01,30.11) 193.08,30.11 v2(193.15,30.04)
P_DDR4_CCSN1+_10: length 4.2
  BOTTOM w0.109: PR163.2 206.37,60.7 205.99,61.08 205.99,62.29 v2(206.76,63.06)
  BOTTOM w0.254: PR163.2 206.76,59.8 PNTC6.1
P_DDR4_CCSN1_10: length 55.5
  TOP w0.254: PR168.2 203.54,58.96 PR162.1 204.06,58.18 204.42,57.82 205.97,57.82 v3(206.76,57.04) ; PU21.18 194.63,25.51 v3(194.56,25.44) 194.41,25.29 PC215.1
  T05 w0.254: v3(194.56,25.44) 194.56,24.78 195.05,24.29 198.58,24.29 199.6,25.31 202.9,25.31 207.47,29.88 207.47,56.32 v3(206.76,57.04)
  BOTTOM w0.254: v3(206.76,57.04) 207.52,57.8 207.52,61.23 207.24,61.51 PR163.1
P_DDR4_CCSP1+_10: length 1.1
  TOP w0.381: PR161.1 203.86,60.72 PR167.2
P_DDR4_CCSP1_10: length 53.9
  TOP w0.254: v3(193.29,24.4) 193.01,24.68 PC215.2 193.04,25.31 193.04,25.67 193.29,25.92 193.93,25.92 194.23,26.23 PU21.17 ; PR161.2 204.88,58.89 PR162.2 204.89,58.42 206.23,58.42 206.58,58.07 v3(206.71,58.07)
  T05 w0.254: v3(206.71,58.07) 207.98,56.8 207.98,29.63 203.15,24.8 199.85,24.8 198.83,23.78 194.67,23.78 194.06,24.4 v3(193.29,24.4)
  BOTTOM w0.254: PNTC6.2 v3(206.71,58.07)
P_DDR4_CGFB_10: length 5.3
  TOP w0.254: PU21.23 196.63,25.81 v3(196.34,25.52) 195.83,25.01 195.1,25.01 PR187.1
  BOTTOM w0.381: v2(196.16,24.25) 196.16,24.79 196.31,24.93 196.31,25.49 v3(196.34,25.52)
P_DDR4_COMP_10: length 9.5
  TOP w0.254: PC238.2 196.84,22.63 196.7,22.77 PR183.2 196.7,23.49 197,23.79 197.43,23.79 197.94,24.3 PR190.2 197.94,24.7 v3(198.4,25.16) 198.4,27.24 198.11,27.54 PU21.26
  BOTTOM w0.109: PR184.1 197.97,25.59 v3(198.4,25.16) 199.58,25.16 v2(199.68,25.26)
P_DDR4_COMP_RC_10: length 3.1
  TOP w0.109: v3(197.5,20.86) 197.35,20.86 PC236.2
  TOP w0.254: PC236.2 196.94,21.37 197.51,21.94 PR183.1
P_DDR4_CPWM1_DR1_10: length 5
  TOP w0.381: PR181.2 204.04,74.71 v3(204.04,73.55)
  BOTTOM w0.254: 202.46,72.34 202.26,72.14 PU22.12
  BOTTOM w0.381: v3(204.04,73.55) 204.09,73.55 204.09,73.23 203.2,72.34 202.46,72.34
P_DDR4_CVFB_10: length 5.3
  TOP w0.254: PR188.2 195.63,24.53 196.07,24.53 v3(197.06,25.52) 197.03,25.55 PU21.24
  BOTTOM w0.381: v3(197.06,25.52) 197.06,25.19 197.56,24.69 v2(197.56,24.02)
P_DDR4_DR1_BST_20: length 7.5
  BOTTOM w0.254: 200.2,73.47 PU22.9
  BOTTOM w0.381: 200.2,73.47 200.23,73.5 PC241.2 200.87,74.79 201.03,74.96 203.68,74.96 v2(204.6,75.88)
P_DDR4_DR1_BST_RC_20: length 5.5
  BOTTOM w0.381: v2(201.86,75.79) 201.67,75.61 PC241.1 200.23,75.61 199.51,76.32 198.22,76.32 197.56,75.66 PR199.2
P_DDR4_DR1_BSTR_20: length 3.2
  BOTTOM w0.254: 199.7,73.8 PU22.8
  BOTTOM w0.381: PR199.1 199.7,74.31 199.7,73.8
P_DDR4_DR1_LX_40: length 7
  TOP w0.381: PC214.1 205.06,64.04 v3(205.57,63.54) ; PR167.1 202.29,61.15 202.78,61.64 v3(204.1,61.64)
  BOTTOM w0.381: v3(204.1,61.64) 203.78,61.97 202.83,61.97 PL14.1
  vias: v2(197.61,65.55)
P_DDR4_DROOP_10: length 7.8
  TOP w0.109: PC236.1 196.03,20.54 v3(196.42,20.15)
  TOP w0.254: PC236.1 PC238.1 196.03,23.48 PR190.1 197.13,24.69 197.23,24.79 197.23,24.96 197.64,25.36 197.64,27.09 PU21.25
P_DDR4_F-IMAX: length 7.3
  TOP w0.254: PU21.10 193.01,29.54 192.76,29.79 192.76,30.19 192.15,30.8 191.7,30.8 v3(191.69,30.8)
  TOP w0.381: v3(191.69,30.8) 191.75,30.86 191.75,31.26 190.98,32.02 190.75,32.02 PR177.1 190.63,32.53 190.91,32.81 PR166.2
  BOTTOM w0.381: v2(191.44,31.92) 191.44,31.46 191.69,31.21 v3(191.69,30.8)
P_DDR4_IMON: length 5.6
  TOP w0.254: PU21.13 192.3,28.34 192.15,28.49 v3(192.08,28.49)
  TOP w0.381: PC240.1 PR164.2 190.75,28.72 191.85,28.72 v3(192.08,28.49)
  BOTTOM w0.381: v2(190.78,28.51) 190.81,28.49 v3(192.08,28.49)
P_DDR4_MODE: length 4.9
  TOP w0.254: PU21.4 195.83,32 v3(195.25,32.58) 195.25,32.84 194.45,33.64 PR200.1
  BOTTOM w0.109: v3(195.25,32.58) v2(195.25,33.76)
P_DDR4_O-USR: length 7.5
  TOP w0.254: v3(192.76,31.88) 192.76,31.03 193.68,30.11 PU21.9
  TOP w0.381: v3(192.76,31.88) 192.38,32.26 192.38,33.67 191.36,34.69 PR169.2 PR178.1
P_DDR4_OCP-I: length 7.7
  TOP w0.254: PR164.1 189.81,29.25 189.97,29.4 v3(191.59,29.4) 191.97,29.4 192.64,28.74 PU21.12
  TOP w0.381: PR164.1 188.8,28.84 PR158.1
  BOTTOM w0.381: v3(191.59,29.4) 191.77,29.23 192.56,29.23 192.89,28.9 192.89,28.88 v2(193.15,28.62)
P_DDR4_PWM1: length 59.8
  TOP w0.254: PU21.6 195.03,31.89 194.05,32.87 v3(194.05,33)
  TOP w0.381: v3(203.72,77.52) 203.58,77.38 PR181.1
  T05 w0.381: v3(194.05,33) 194.05,33.4 192.95,34.49 192.95,36.06 193.88,36.99 198.34,36.99 199.47,38.12 199.47,47.68 200.85,49.06 200.85,57.18 198.96,59.07 198.96,61.88 198.96,62.62 205.19,68.85 205.19,68.86 205.76,69.43 205.76,75.48 204.35,76.89 203.78,77.46 203.76,77.46 203.76,77.48 v3(203.72,77.52)
P_DDR4_SB1_20: length 2.7
  TOP w0.381: PR160.1 PC214.2 205.88,65.08 v3(206.01,65.22)
P_DDR4_SKIP: length 59.8
  TOP w0.254: PR198.1 201.53,77.26 v3(201.52,77.27) ; v3(194,31.99) 194.63,31.35 PU21.7
  T05 w0.254: v3(194,31.99) 193.94,31.99 193.88,32.04 193.75,32.04 192.1,33.69 192.1,36.47 193.71,38.07 193.79,38.07 194.34,38.62 196.66,38.62 198.64,40.61 198.64,48.02 200.03,49.4 200.03,56.79 197.95,58.86 197.95,62.77 202.9,67.73 204.17,68.99 204.17,72.1 204.93,72.87 204.93,75.14 203.76,76.31 203.44,76.63 202.15,76.63 201.52,77.26 v3(201.52,77.27)
P_DDR4_SKIP#_1_10: length 3.5
  TOP w0.254: v3(201.63,74.08) 201.53,74.17 PR198.2
  BOTTOM w0.254: PU22.10 200.7,73.15 v3(201.63,74.08)
P_DDR4_SLEWA: length 7.9
  TOP w0.254: v3(192.08,27.24) 192.86,27.24 193.16,27.54 PU21.15
  TOP w0.381: PR157.1 PR159.2 190.75,23.76 191.26,24.27 191.26,26.42 v3(192.08,27.24)
  BOTTOM w0.381: v2(192.08,26.2) v3(192.08,27.24)
P_DDR4_TAO_DR1: length 4.4
  TOP w0.254: PC217.1 202.56,74.64 202.9,74.31 v3(202.9,74.11)
  BOTTOM w0.254: PU22.11 201.2,72.81 201.49,73.1 202.32,73.1 202.9,73.68 v3(202.9,74.11)
P_DDR4_THERM: length 6.7
  TOP w0.254: PU21.14 192.84,27.94 192.76,27.86 v3(191.62,27.86)
  TOP w0.381: PNTC5.2 PC239.1 PR189.1 190.63,26.86 v3(191.62,27.86)
  BOTTOM w0.381: v2(191.01,27.04) 191.01,27.29 191.57,27.86 v3(191.62,27.86)
P_DDR4_V5A_10: length 5.7
  TOP w0.254: v3(199.35,27.71) 199.34,27.71 198.72,28.34 PU21.28
  BOTTOM w0.109: v2(200.76,26.09) 200.36,26.5 PR194.2 199.39,27.75 v3(199.35,27.71) 198.93,28.13 PC234.1
P_DDR4_VCLK: length 8.6
  TOP w0.152: v3(198.88,30.19) 198.68,29.99 arc(198.18,29.65) PU21.31
  BOTTOM w0.109: v2(204.86,29.65) 204.72,29.79 203.45,29.79 202.89,29.24 202.17,29.24 201.55,29.85 201.04,29.85 200.92,29.73 200.53,29.73 199.87,30.39 PR180.2 199.34,30.5 199.04,30.19 v3(198.88,30.19)
P_DDR4_VDD: length 6
  TOP w0.254: PC233.1 196.67,33.64 PR195.2 196.93,33.39 196.93,32.1 v3(196.85,32.02) 196.63,31.8 PU21.2
  BOTTOM w0.381: v3(196.85,32.02) 197.51,32.68 v2(197.51,33.14)
P_DDR4_VDIO: length 4.8
  TOP w0.152: PR179.2 197.97,33.31 197.59,32.93 197.59,31.64 v3(197.41,31.46) 197.18,31.46 197.03,31.31 PU21.1
  BOTTOM w0.152: v2(196.44,31.08) 197.03,31.08 v3(197.41,31.46)
P_DDR4_VIN_10: length 3.5
  TOP w0.254: 192.79,26.56 193.36,27.14 PU21.16
  TOP w0.381: PR185.2 192.15,25.92 192.79,26.56
P_DDR4_VIN_SHAPE:
  vias: v2(194.94,74.69)
P_DDR4_VR_ON: length 4.9
  TOP w0.254: PU21.8 194.23,30.93 193.93,31.23 v3(193.5,31.23) 193.4,31.33 PR186.2
  BOTTOM w0.381: v3(193.5,31.23) 193.75,30.98 v2(194.54,30.98)
P_DDR4_VREF_10: length 9.5
  TOP w0.254: v3(199.64,26.69) 199.54,26.69 198.29,27.94 PU21.27
  TOP w0.381: PR169.1 189.69,33.57 PR166.1 189.54,33.09 v3(189.02,32.57) ; PR159.1 PNTC5.1 v3(188.98,24.78) ; PR165.1 v3(189.07,30.11)
  BOTTOM w0.109: v3(199.64,26.69) 199.14,27.19 PC235.1 PR184.2
PCH_HOT_L: length 113.2
  TOP w0.089: U1.AL76 122.04,63.77 121.74,64.08 121.74,64.87 121.2,65.4
  TOP w0.109: v2(77.72,25.8) 77.72,28.05 78.84,29.17 79.43,29.17 79.74,28.87 U13.12 81.38,28.87 82.13,29.62 v3(82.13,29.92) 82.22,29.83 R202.2 ; v1(120.59,67.2) 120.61,67.2 121.2,66.61 121.2,65.4
  TOP w0.152: U1.BF7 v1(128.58,30.81)
  T05 w0.089: 105.55,28.29 108.1,28.29 108.73,28.92 114.93,28.92 116.32,30.31 128.08,30.31 v1(128.58,30.81) 128.89,31.12 128.89,32.55 129.09,32.76 129.09,33.42 128.84,33.68 128.84,34.65 129.71,35.52 129.71,36.05 130.22,36.56 130.22,36.99 130.81,37.59 130.81,37.71 131.06,37.96 131.06,38.59 129.67,39.99 129.67,41.34 129.33,41.68 129.33,41.77 127.3,43.8 121.3,43.8 121.04,44.06 118.85,44.06 117.57,45.34 117.57,49.83 119.82,52.09 119.82,56.02 120.22,56.43 120.22,60.5 119.92,60.8 119.92,63.72 119.51,64.13 119.51,67.29 119.74,67.53 120.27,67.53 v1(120.59,67.2)
  T05 w0.097: 105.55,28.29 91.44,28.29 90.78,28.94 89.74,28.94 88.76,29.92 v3(82.13,29.92)
PCH_HOT_LVT3_L: length 27.8
  TOP w0.089: 58.77,35.21 58.25,35.21 v1(58.12,35.34)
  TOP w0.109: 58.77,35.21 60.41,35.21 60.45,35.25 65.13,35.25 66.62,33.76 72.91,33.76 73.11,33.96 74.96,33.96 76.85,32.07 76.85,29.17 76.55,28.87 U13.5 ; v1(58.12,35.34) 58.12,35.27 U31.A15
  BOTTOM w0.109: v1(58.12,35.34) 58.12,36.51 57.67,36.96 v2(57.67,37)
PCH_PWROK: length 94
  TOP w0.089: 122.76,25.85 122.76,27.93 U1.AN1
  TOP w0.109: U31.B7 v1(57.13,43.28) ; R97.2 v3(118.46,19.57) 119,19.57 120.77,21.34 120.77,22.51 121.5,23.24 121.97,23.24 122.96,24.24 122.96,25.55 122.76,25.76 122.76,25.85
  T05 w0.097: v3(118.46,19.57) 116.69,19.57 116.61,19.65 115.39,19.65 114.87,20.18 109.16,20.18 107.16,18.17 99.11,18.17 95.88,14.95 92.1,14.95 87.98,19.07 85.19,19.07 82.69,21.57 73.03,21.57 65.95,28.65 65.95,31.41 64.69,32.67 64.69,33.79 60.74,37.74 60.18,37.74 59.41,38.51 59.41,38.73 57.06,41.08 56.75,41.08 55.72,42.11 55.72,42.46 56.54,43.28 v1(57.13,43.28)
PD_BDXDE_SPARE1: length 18.8
  TOP w0.109: R264.1 117.24,71.24 117.24,69.74 116.96,69.46 R259.2 116.73,69.39 117.26,68.85 v1(117.26,68.85)
  TOP w0.152: U1.AC64 v1(118.77,56.64)
  T05 w0.089: v1(117.26,68.85) 118.8,67.31 118.8,60.7 118.41,60.3 118.41,57 v1(118.77,56.64)
  BOTTOM w0.089: 116.56,69.48 117.14,68.9 117.21,68.9 v1(117.26,68.85)
  BOTTOM w0.109: v2(116.54,69.89) 116.54,69.5 116.56,69.48
PD_BDXDE_SPARE2: length 9.6
  TOP w0.089: U1.AN78 122.87,64.51 122.87,65.05
  TOP w0.109: 122.87,65.05 122.87,66.87 120.76,68.98 120.16,68.98 119.78,69.36 R260.2 120.01,69.46 120.29,69.74 120.29,71.24 R265.1
PD_BDXDE_SPARE3: length 2.1
  TOP w0.152: U1.AG67 v1(120.8,58.44)
  BOTTOM w0.089: v1(120.8,58.44) 120.8,58.51 R266.1
  BOTTOM w0.108: R261.2 120.8,58.31 v1(120.8,58.44)
PD_BDXDE_SPARE4: length 2.4
  TOP w0.152: U1.AJ67 v1(121.79,58.44)
  BOTTOM w0.102: R267.1 121.94,57.4 121.47,57.87 R262.2
  BOTTOM w0.108: R262.2 121.28,57.92 v1(121.79,58.44)
PD_BIST_ENABLE: length 3.9
  TOP w0.152: U1.AM69 v1(123.27,59.3)
  BOTTOM w0.102: R287.2 124.75,57.13 R292.1 v2(123.87,58.37) 123.87,58.69 v1(123.27,59.3)
PD_CLKIN_CPY_N: length 2.2
  TOP w0.102: v1(116.51,42.73) 116.51,42.49 117.11,41.9 U1.Y30
  BOTTOM w0.102: v1(116.51,42.73) 116.32,42.73 R137.2
PD_CLKIN_CPY_P: length 3.6
  TOP w0.152: U1.AA30 118.88,42.82 v1(119.15,42.82)
  BOTTOM w0.102: R135.2 118,41.75 119.07,42.82 v1(119.15,42.82)
PD_CLKIN_DMI_N: length 3.2
  TOP w0.152: v1(113.83,43.57) 113.83,43.57 113.87,43.61 U1.N35
  BOTTOM w0.102: R142.2 113.86,42.29 113.86,43.5 113.83,43.54 v1(113.83,43.57)
  BOTTOM w0.135: v2(112.74,43.47) 112.85,43.57 v1(113.83,43.57)
PD_CLKIN_DMI_P: length 3.8
  TOP w0.152: U1.P33 114.37,43.27 v1(114.37,42.7)
  BOTTOM w0.102: v1(114.37,42.7) 114.37,41.98 R141.2 113.73,41.23 114.63,40.33 v2(114.82,40.33)
PD_CLKIN_DOT96_N: length 2.9
  TOP w0.135: U1.AB1 118.08,28.16 v1(118.51,27.73)
  BOTTOM w0.135: R140.2 119.08,27.52 118.86,27.73 v1(118.51,27.73) 118.34,27.56 118.34,26.95 v2(118.64,26.65)
PD_CLKIN_DOT96_P: length 4.4
  TOP w0.135: v1(117.47,27.7) 117.75,27.98 117.75,28.6 118.08,28.93 U1.AB3
  BOTTOM w0.102: v2(117.19,28.61) 117.06,28.61 116.51,28.05 R138.2 117.33,27.55 v1(117.47,27.7)
PD_CPU_TSTCLK_N: length 3.1
  TOP w0.152: U1.F54 v1(110.9,52.12)
  BOTTOM w0.102: 109.63,52.44 110.61,51.46 R145.2
  BOTTOM w0.109: v2(109.63,52.7) 109.63,52.44
  BOTTOM w0.135: R145.2 110.77,51.98 v1(110.9,52.12)
PD_CPU_TSTCLK_P: length 2.6
  TOP w0.152: U1.J54 v1(112.38,53)
  BOTTOM w0.135: R144.2 112.18,53.2 v1(112.38,53) 112.62,53.23 v2(112.62,54.14)
PD_DMI_TERMINATION_GPIO33: length 17.2
  TOP w0.109: R246.1 v3(119.73,19.59)
  TOP w0.152: U1.AN11 v1(122.77,32.68)
  T10 w0.102: v1(122.77,32.68) 122.77,31.36 120.78,29.36 120.78,26.06 119.73,25.02 v3(119.73,19.59)
  BOTTOM w0.109: R246.1 v3(119.73,19.59)
PD_GPIO52_CPUSV: length 30.3
  TOP w0.109: R300.1 v3(134.08,9.56)
  TOP w0.152: U1.BP16 v1(132.2,35.83)
  T10 w0.089: 133.09,21.61 133.09,21.61 133.09,27.88 132.3,28.66 132.3,31.95 132.58,32.23 132.58,32.55 132.32,32.82 132.32,33.69 132.58,33.95 132.58,34.37 132.2,34.76 v1(132.2,35.83)
  T10 w0.097: v3(134.08,9.56) 133.4,10.24 133.4,20.72 133.32,20.79 133.32,21.37 133.09,21.61
  BOTTOM w0.109: R300.1 v3(134.08,9.56)
PD_GPIO53_GSXDIN: length 33.3
  TOP w0.109: R247.1 v3(135.6,9.56)
  TOP w0.152: U1.BT20 v1(133.19,37.55)
  T10 w0.089: 134.59,21.61 134.59,23.38 133.87,24.09 133.87,31.04 134.07,31.24 134.07,31.74 134.56,32.23 134.56,32.67 134.29,32.95 134.29,33.61 134.56,33.89 134.56,34.45 134.29,34.73 134.29,35.19 134.56,35.47 134.56,36.05 134.18,36.43 134.18,36.74 133.37,37.55 v1(133.19,37.55)
  T10 w0.097: v3(135.6,9.56) 136.03,9.99 136.03,20.16 134.59,21.61
  BOTTOM w0.109: R247.1 v3(135.6,9.56)
