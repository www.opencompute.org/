# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VP5P0_VOUT: length 10.7
  TOP w0.381: PR248.1 v3(14.3,42.83)
  BOTTOM w0.381: v3(16.08,47.66) 16.08,49.75 PC5.1 ; v3(14.3,42.83) 18.24,46.77 18.24,48.74
  vias: v3(19.51,49.44) v3(19.51,48.68) v3(20.27,49.44) v3(20.27,48.68) v3(21.03,49.44) v3(21.03,48.68) v3(21.8,49.44) v3(22.56,49.44) v3(23.45,49.44) v3(24.28,49.44)
VP12P0: length 101.1
  TOP w0.254: v3(64.56,57.88) 64.67,57.98 PR279.1
  TOP w0.381: 22.5,33.22 J11.4 ; J11.4 23.91,34.63 ; J11.4 17.28,39.85 PR214.2 ; J11.4 21.09,34.63 ; J11.4 22.5,36.04 ; 79.32,86.67 79.62,86.67 83.97,82.32 PR132.1 ; 21.09,30.43 J11.3 ; J11.3 22.5,31.84 ; J11.3 22.5,29.02 ; J11.3 23.91,30.43
  T03 w0.381: v3(94.66,45.19) 94.19,44.72 91.91,44.72 91.7,44.92 77.96,44.92 77.13,45.76 75.92,45.76 73.84,47.84 v3(65.15,47.84)
  T05 w0.381: v3(64.56,57.88) 64.34,57.88 63.88,57.42 63.88,52.85 66.17,50.56 66.17,48.15 65.86,47.84 v3(65.15,47.84)
  P07 w0.381: 21.09,34.63 J11.4 ; J11.4 22.5,33.22 ; J11.4 23.91,34.63 ; J11.4 22.5,36.04 ; J11.3 23.91,30.43 ; J11.3 22.5,29.02 ; J11.3 21.09,30.43 ; J11.3 22.5,31.84
  T08 w0.381: J11.3 22.5,31.84 ; J11.3 22.5,29.02 ; J11.3 23.91,30.43 ; 22.5,33.22 J11.4 23.91,34.63
  BOTTOM w0.381: 21.09,34.63 J11.4 ; J11.4 22.5,33.22 ; J11.4 22.5,36.04 ; J11.4 23.91,34.63 ; J11.3 23.91,30.43 ; J11.3 21.09,30.43 ; J11.3 22.5,31.84 ; J11.3 22.5,29.02 ; v3(96.27,45.18) 96.95,45.18 v2(97.26,45.48)
  vias: v2(12.32,27.32) v2(17.53,27.19) v2(21.72,23.77) v2(152.6,93.36) v2(157.94,93.39) v2(162.99,93.31) v2(168.45,93.26) v3(2.29,44.72) v3(2.78,45.55) v3(3.43,44.85) v3(4.05,45.55) v3(4.7,44.85) v3(5.08,45.74) v3(5.95,44.91) v3(17.21,11.08) v3(17.21,10.32) v3(17.24,9.56) v3(17.24,8.8) v3(37.26,92.52) v3(37.26,91.63) v3(38.15,92.52) v3(38.15,91.63) v3(39.04,92.52) v3(39.04,91.63) v3(71.77,93.74) v3(71.77,92.98) v3(71.77,92.22) v3(72.53,93.74) v3(72.53,92.98) v3(72.53,92.22) v3(73.3,93.74) v3(73.3,92.98) v3(73.3,92.22) v3(74.02,88.05) v3(74.06,93.74) v3(74.06,93.03) v3(74.65,87.7) v3(74.82,93.74) v3(74.82,93.03) v3(75.29,88.03) v3(75.58,93.74) v3(75.58,93.03) v3(75.95,87.75) v3(76.34,93.74) v3(76.34,92.98) v3(76.25,90.34) v3(76.25,88.94) v3(76.5,89.65) v3(76.48,88.26) v3(76.45,87.24) v3(77.11,93.74) v3(77.11,92.98) v3(77.87,93.74) v3(77.87,92.98) v3(95.05,45.86) v3(95.43,45.2) v3(95.4,44.44) v3(95.91,45.86) v3(143.34,84.36) v3(143.34,83.47) v3(147.98,83.81) v3(148.95,83.81) v3(192.15,22.11) v3(193.13,22.26) v6(15.37,25.54) v6(16.76,25.54) v6(17.02,21.86) v6(18.15,24.9) v6(18.15,23.63) v6(18.15,22.36) v6(21.68,28.2) v6(21.68,26.93) v6(21.68,25.66) v6(22.95,28.2) v6(22.95,26.93) v6(22.95,25.66) v6(24.22,28.2) v6(24.22,26.93) v6(24.22,25.66) v6(142.57,94.02) v6(143.97,94.02) v6(145.37,94.02) v6(196.69,93.89) v6(198.09,93.89) v6(198.09,92.49) v7(2.37,46.53)
XDP_CPU_MBP_N0: length 2.6
  TOP w0.089: v1(116.6,61.9) U1.W75
  BOTTOM w0.089: 116.6,62.6 v1(116.6,61.9) ; 116.6,62.6 115.8,62.6 v2(115.49,62.3) ; 116.6,62.6 R181.2
XDP_CPU_MBP_N1: length 2.1
  TOP w0.152: v1(118.32,61) 118.62,61.3 U1.AD72
  BOTTOM w0.089: R180.2 118.67,62.15 118.79,62.03 118.79,61.47 v1(118.32,61)
XDP_CPU_MBP_N2: length 115.5
  TOP w0.089: U1.N78 114.02,64.45 114.02,66.1
  TOP w0.109: J12.9 15.12,64.36 15.44,64.05 15.44,64.04 v3(15.46,64.02) ; v1(113.48,66.87) 113.48,66.86 114.02,66.32 114.02,66.1
  T08 w0.097: v1(113.48,66.87) 113.02,67.34 113.02,68.15 111.4,69.77 106.54,69.77 103.46,66.68 96.39,66.68 96.37,66.7 85.09,66.7 83.17,64.78 77.59,64.78 76.94,65.43 69.08,65.43 68.72,65.79 68.12,65.79 67.91,65.57 63.69,65.57 63.04,66.22 48.47,66.22 46.99,64.75 38.77,64.75 38.54,64.98 29.71,64.98 28.85,64.12 22.78,64.12 22.34,63.68 19.8,63.68 18.8,62.68 17.8,62.68 16.46,64.02 v3(15.46,64.02)
  BOTTOM w0.109: R412.1 12.11,64.3 13.3,64.3 13.3,64.3 13.66,64.3 13.67,64.3 14.34,64.3 v2(14.45,64.19) 14.62,64.02 v3(15.46,64.02)
XDP_CPU_MBP_N3: length 120.2
  TOP w0.089: 112.87,65.55 113.42,65.01 113.42,63.94 113.29,63.81 113.29,63.46 113.63,63.12 U1.M75
  TOP w0.109: v1(111.96,67.97) 112.62,67.31 112.62,66.58 112.87,66.32 112.87,65.55 ; J12.11 15.4,64.86 16.1,64.17 v3(16.1,62.64)
  T08 w0.097: v1(111.96,67.97) 111.06,68.87 107.09,68.87 103.42,65.2 102.22,65.2 101.78,65.63 95.42,65.63 93.65,63.86 76.86,63.86 76.77,63.94 73.01,63.94 72.55,63.49 72.38,63.31 67.78,63.31 67.5,63.59 62.28,63.59 61.88,63.19 58.7,63.19 57.99,63.9 51.21,63.9 50.23,62.92 45.57,62.92 45.27,63.22 44.92,63.22 44.31,63.83 39.8,63.83 39.19,63.22 23.15,63.22 22.1,62.17 19.6,62.17 19.21,61.78 16.96,61.78 v3(16.1,62.64)
  BOTTOM w0.109: R413.1 15.48,64.91 16.1,64.3 v3(16.1,62.64)
XDP_CPU_MBP_N4: length 113.3
  TOP w0.089: 111.17,66.03 111.17,65.45 112.14,64.48 U1.J78
  TOP w0.109: 111.17,66.03 v1(110.21,67) ; J12.15 13.3,65.86 13.37,65.93 v3(13.52,65.93)
  T08 w0.097: v1(110.21,67) 109.36,66.16 106.83,66.16 103.74,63.07 102.69,63.07 102.55,63.2 95.11,63.2 93.55,61.64 64.8,61.64 64.8,61.64 64.56,61.64 64.4,61.48 56.36,61.48 56.18,61.66 51.94,61.66 51.71,61.42 44.95,61.42 44.67,61.7 23.83,61.7 22.24,60.11 14.03,60.11 12.76,61.39 12.76,65.17 v3(13.52,65.93)
  BOTTOM w0.109: v3(13.52,65.93) R414.1
XDP_CPU_MBP_N5: length 118.2
  TOP w0.089: v1(110.23,65.68) 111.58,64.33 111.58,64.08 111.78,63.88 111.78,63.22 111.65,63.09 U1.H75
  TOP w0.109: J12.17 11.71,66.33 12.82,66.33 13.41,66.91 v3(13.41,66.94)
  T08 w0.089: v1(110.23,65.68) 107.32,65.68
  T08 w0.097: 107.32,65.68 103.73,62.09 103.73,61.75 102.89,60.9 102.03,60.9 101.92,60.8 99.15,60.8 98.56,61.39 94.15,61.39 93.8,61.04 64.81,61.04 64.65,60.88 56.11,60.88 55.93,61.06 52.19,61.06 51.95,60.82 44.7,60.82 44.42,61.1 24.08,61.1 22.49,59.51 13.78,59.51 12.16,61.14 12.16,65.69 v3(13.41,66.94)
  BOTTOM w0.109: R415.1 v3(13.41,66.94) 13.77,66.58 v2(15.26,66.58)
XDP_CPU_MBP_N6: length 119.5
  TOP w0.089: U1.K75 112.64,63.12 112.3,63.46 112.3,63.96 112.43,64.09 112.43,64.5 111.4,65.53
  TOP w0.109: 111.4,65.53 111.4,66.49 v1(110.21,67.69) ; v3(14.32,67.09) 13.94,67.47 11.79,67.47 J12.21
  T08 w0.097: v1(110.21,67.69) 108.98,66.46 106.69,66.46 104.23,64 101.72,64 101.29,64.43 95.92,64.43 93.42,61.94 64.67,61.94 64.66,61.94 64.43,61.94 64.28,61.78 56.49,61.78 56.31,61.96 51.82,61.96 51.58,61.72 45.07,61.72 44.8,62 23.71,62 22.12,60.41 14.15,60.41 13.05,61.51 13.05,64.43 14.06,65.44 14.06,66.45 14.32,66.71 v3(14.32,67.09)
  BOTTOM w0.109: v3(14.32,67.09) 13.45,67.96 v2(13.04,67.96) R416.1
XDP_CPU_MBP_N7: length 120.5
  TOP w0.089: 110.94,65.6 110.94,65.3 111.8,64.44 111.8,64.23 112.04,63.99 112.04,63.21 U1.J76
  TOP w0.109: v3(14.83,67.61) 14.57,67.86 J12.23 ; 110.94,65.6 v1(110.23,66.31)
  T08 w0.097: v3(14.83,67.61) 14.23,67.61 13.89,67.27 13.89,66.82 13.52,66.45 13.43,66.45 12.46,65.48 12.46,61.26 13.9,59.81 22.37,59.81 23.96,61.4 44.55,61.4 44.83,61.12 51.83,61.12 52.07,61.36 56.06,61.36 56.24,61.18 64.53,61.18 64.68,61.34 93.67,61.34 94.45,62.12 99.01,62.12 99.09,62.04 103.2,62.04 107.03,65.87 109.79,65.87 v1(110.23,66.31)
  BOTTOM w0.109: R417.1 14.02,68.98 v2(14.33,68.67) 14.83,68.17 14.83,67.61 v3(14.83,67.61)
XDP_CPU_PRDY_L: length 113.1
  TOP w0.089: U1.L78 113.13,64.81 112.67,65.27
  TOP w0.109: v3(14.45,62.39) 14.45,62.64 13.73,63.36 J12.5 ; v1(111.93,67.28) 112.36,66.85 112.36,66.43 112.67,66.12 112.67,65.27
  T08 w0.097: v3(14.45,62.39) 15.36,61.48 19.33,61.48 19.73,61.87 22.23,61.87 23.28,62.92 39.31,62.92 39.92,63.53 44.18,63.53 44.79,62.92 45.15,62.92 45.45,62.62 50.36,62.62 51.33,63.6 57.87,63.6 58.57,62.89 62,62.89 62.41,63.29 67.28,63.29 67.72,62.85 93.06,62.85 95.55,65.33 101.66,65.33 102.09,64.9 103.86,64.9 107.53,68.57 110.65,68.57 v1(111.93,67.28)
  BOTTOM w0.109: R418.1 13.96,62.88 v3(14.45,62.39)
XDP_CPU_PREQ_L: length 114.9
  TOP w0.089: U1.K77 112.64,64.56 111.86,65.34 v1(111.86,65.96)
  TOP w0.109: v3(13.52,61.65) 13.96,62.09 13.96,62.54 13.64,62.86 J12.3
  T08 w0.097: v3(13.52,61.65) 13.52,61.56 14.27,60.82 19.52,60.82 19.97,61.27 22.47,61.27 23.5,62.3 44.92,62.3 45.2,62.02 50.6,62.02 51.58,63 57.53,63 58.23,62.29 62.25,62.29 62.65,62.69 66.97,62.69 67.41,62.25 93.31,62.25 95.79,64.73 101.41,64.73 101.85,64.3 104.11,64.3 106.6,66.78 108.72,66.78 110.01,68.08 110.37,68.08 111.02,67.42 111.02,66.79 v1(111.86,65.96)
  BOTTOM w0.109: R419.1 13.31,61.86 v3(13.52,61.65) 13.59,61.72 15.13,61.72 v2(15.58,61.26)
XDP_CPU_PRESENT_L: length 137
  TOP w0.089: v1(113.43,65.58) 113.63,65.38 U1.M77
  TOP w0.109: J12.60 3.64,76.86 3.03,76.25 3.03,76.24 v3(3.02,76.23)
  T08 w0.097: v1(113.43,65.58) 112.38,66.63 112.38,68.1 111.31,69.17 106.96,69.17 103.85,66.05 95.42,66.05 93.52,64.16 76.99,64.16 76.9,64.24 72.88,64.24 72.25,63.61 67.9,63.61 67.62,63.89 62.16,63.89 61.76,63.49 58.82,63.49 58.11,64.2 51.08,64.2 50.11,63.22 45.7,63.22 45.4,63.52 45.04,63.52 44.43,64.13 39.67,64.13 39.06,63.52 23.03,63.52 21.98,62.47 19.48,62.47 19.09,62.08 17.38,62.08 16.31,63.15 15.29,63.15 14.73,63.71 14.73,64.46 15.26,64.98 15.26,67.78 13.54,69.5 9.48,69.5 7.88,71.1 7.88,71.37 v3(3.02,76.23)
  BOTTOM w0.109: v3(3.02,76.23) 3.67,75.58 3.67,74.39 2.93,73.65 v2(2.93,73) 2.93,72.87 3.88,71.92 R420.1
XDP_CPU_PWRGD: length 15.4
  TOP w0.109: R405.2 19.02,60.49 16.48,63.03 v3(16.48,65.49) 16.48,67.22 13.3,70.39 13.3,71.53 12.98,71.86 J12.39
XDP_CPU_PWRGD_R: length 39.5
  TOP w0.109: R405.1 20.54,60.49 20.9,60.84 v3(20.92,60.84) ; v3(24.1,71.53) 23.97,71.41 v3(23.97,67.98) R402.2
  BOTTOM w0.109: v3(23.97,67.98) 23.97,66.94 22.19,65.16 22.19,62.01 21.05,60.87 20.95,60.87 v3(20.92,60.84) ; R404.2 40.73,66.2 41.01,66.48 41.01,69.98 40.42,70.58 39.57,70.58 38.24,71.91 37.08,71.91 34.92,74.06 26.62,74.06 v3(24.1,71.53)
XDP_CPU_TCK0: length 18.7
  TOP w0.109: R411.2 23.72,67.56 23.29,67.99 23.29,68.85 22.5,69.64 20.57,69.64 20.18,69.25 v3(18.41,69.25) 18.19,69.25 15.59,71.85 15.59,74.75 13.98,76.36 J12.57
XDP_CPU_TDI: length 126.1
  TOP w0.089: 116.35,66.06 116.1,65.81 U1.V78
  TOP w0.109: 116.35,66.06 116.35,66.47 v1(115.97,66.85)
  T08 w0.097: v1(115.97,66.85) 115.97,68.04 112.13,71.88 106.96,71.88 102.96,67.88 96.89,67.88 96.87,67.9 82.96,67.9 82.65,67.59 81.42,67.59 80.54,66.71 70.64,66.71 70.31,67.03 63.93,67.03 63.54,67.42 49.59,67.42 48.92,68.09 42.62,68.09 41.95,67.42 41.51,67.42 40.26,66.18 26.45,66.18 26.04,65.77 19.96,65.77 12.16,73.57 v3(8.1,73.57)
  BOTTOM w0.089: R175.2 116.48,64.48 116.48,65.19
  BOTTOM w0.102: v1(115.97,66.85) 116.48,66.34 116.48,65.19
  BOTTOM w0.109: v2(8.76,74.95) 8.76,74.23 v3(8.1,73.57) 8.1,73.22 7.66,72.79 R410.2
XDP_CPU_TDI_R: length 6.1
  TOP w0.109: J12.56 5.72,75.85 v3(7.44,75.85)
  BOTTOM w0.109: R410.1 6.5,73.4 7.03,73.93 7.73,73.93 7.99,74.18 7.99,75.32 7.46,75.85 v3(7.44,75.85)
XDP_CPU_TDO: length 232.2
  TOP w0.089: v1(114.7,65.6) 115.08,65.22 115.08,64.37 U1.T78
  T03 w0.097: v3(66.72,66) 65.91,65.2 65.91,59.83 63.74,57.66 63.74,45.65 64.8,44.59 68.45,44.59 68.84,44.21 76.66,44.21 77.54,43.33 90.79,43.33 97.23,36.9 97.23,31.77 99.09,29.91 v3(99.09,29.73)
  T08 w0.097: v3(8.6,71.41) 9.11,70.9 12.99,70.9 15.97,67.92 15.97,65.21 18.2,62.98 18.59,62.98 19.59,63.97 22.21,63.97 22.87,64.63 26.25,64.63 26.9,65.28 38.67,65.28 38.81,65.13 40.57,65.13 41.45,66.01 43.42,66.01 44.6,67.18 48.42,67.18 49.08,66.52 63.17,66.52 63.69,66 v3(66.72,66) 66.8,66.09 69.99,66.09 70.35,65.73 77.07,65.73 77.11,65.68 77.71,65.08 81.42,65.08 83.33,67 96.5,67 96.51,66.98 103.33,66.98 106.42,70.07 111.53,70.07 114.02,67.58 114.02,66.29 v1(114.7,65.6)
  BOTTOM w0.109: v3(8.6,71.41) 8.6,71.21 8.27,70.88 R403.2 6.25,70.58 5.94,70.26 5.71,70.26 5.7,70.26 5.18,70.26 5.17,70.26 4.79,70.26 4.44,70.62 R408.2 ; R462.1 134.29,21 128.04,21 127.6,20.55 126.91,20.55 125.73,21.73 106.27,21.73 99.09,28.92 v3(99.09,29.73)
XDP_CPU_TDO_R: length 7.7
  TOP w0.109: v3(3.02,74.85) 3.03,74.86 J12.52
  BOTTOM w0.109: R408.1 3.26,70.9 2.3,71.86 2.3,74.14 v3(3.02,74.85)
XDP_CPU_TMS: length 236.8
  TOP w0.089: 110.67,68.78 110.97,68.49 112.11,68.49 113,67.6 113,66.71 113.46,66.25 v1(113.46,66.24) 113.83,65.87 113.83,63.9 114.47,63.25 114.47,62.76 U1.R75
  TOP w0.109: R174.2 110.58,68.87 110.67,68.78 ; J12.58 4.15,76.36 4.03,76.25 v3(3.98,76.25)
  T03 w0.097: v3(61.77,65.79) 61.77,60.75 63.09,59.43 63.09,45.45 64.66,43.88 68.23,43.88 68.5,43.61 76.41,43.61 77.29,42.73 90.38,42.73 96.63,36.48 96.63,31.43 97.82,30.24 97.82,29.61 98.14,29.28 99.39,29.28 v3(99.85,29.73)
  T08 w0.097: v1(113.46,66.24) 112.72,66.98 112.72,68.03 111.28,69.47 106.84,69.47 103.75,66.38 96.27,66.38 96.25,66.4 85.21,66.4 83.3,64.48 77.38,64.48 76.73,65.13 68.96,65.13 68.6,65.49 68.24,65.49 68.03,65.27 63.57,65.27 63.05,65.79 v3(61.77,65.79) 51,65.79 49.66,64.45 39.57,64.45 38.94,63.82 22.9,63.82 22.46,63.38 19.92,63.38 18.92,62.38 17.67,62.38 16.58,63.47 15.4,63.47 15.03,63.84 15.03,64.25 15.56,64.77 15.56,67.91 12.87,70.6 8.8,70.6 8.17,71.23 8.17,72.05 v3(3.98,76.25)
  BOTTOM w0.109: R463.1 124.4,23.57 122.94,22.11 106.33,22.11 99.82,28.63 99.82,29.71 v3(99.85,29.73) ; v2(5.04,76.25) v3(3.98,76.25)
XDP_CPU_TRST_L: length 130.1
  TOP w0.089: v1(114.78,67) 112.62,69.16 R178.1 ; 115.62,65.77 115.62,64.07 115.95,63.74 115.95,63.46 115.74,63.26 115.74,62.74 U1.U75
  TOP w0.109: v3(8.65,73.12) 8.65,73.2 8.53,73.32 8.53,74.45 7.64,75.34 5.73,75.34 J12.54 ; v1(114.78,67) 115.13,66.65 115.13,66.26 115.62,65.77
  T08 w0.097: v3(8.65,73.12) 12.1,73.12 19.75,65.47 26.16,65.47 26.57,65.88 40.43,65.88 41.53,66.98 42.12,66.98 42.93,67.8 48.66,67.8 49.33,67.12 63.41,67.12 63.8,66.73 70.19,66.73 70.59,66.33 80.92,66.33 80.97,66.28 81.77,66.28 83.08,67.6 96.75,67.6 96.76,67.58 103.08,67.58 107.09,71.58 112.01,71.58 114.78,68.81 v1(114.78,67)
  BOTTOM w0.109: v2(9.49,73.67) 9.21,73.67 v3(8.65,73.12)
XDP_CPU_VCCOBS_AB: length 5.6
  TOP w0.305: J12.43 v3(13.5,72.86)
  BOTTOM w0.305: R399.2 11.65,72.04 C190.1 12.93,72.3 v3(13.5,72.86)
XDP_CPU_VCCOBS_CD: length 13.1
  TOP w0.109: v3(3.89,66.31) 4.06,66.48 4.06,70.08 3.02,71.13 3.02,72.3 3.58,72.86 J12.44
  BOTTOM w0.109: v3(3.89,66.31) C191.1 5.44,66.84 R400.2
XDP_PCH_OBSDATA_D1: length 7
  TOP w0.089: U1.BM1 131.89,28.16 131.89,24.45 v1(132.5,23.84)
  BOTTOM w0.089: v1(132.5,23.84) 133.06,24.4 TP5.1 134.11,23.78 v2(134.11,23.51)
XTAL_PCH_25M_IN: length 10.2
  TOP w0.152: U1.K2 112.64,28.06 112.82,27.88 R134.1 112.9,24.56 C37.1 v2(112.9,21.86) 112.9,19.37 Y3.1
XTAL_PCH_25M_OUT: length 12.3
  TOP w0.152: Y3.3 111.47,17.08 112.06,17.67 v2(112.06,20.72) C36.1 112.01,23.67 R134.2 112.01,25.28 112.36,25.64 112.36,27.99 U1.J1
N21407887: length 5.6
  TOP w0.109: v3(14.12,40.52) 15.33,41.73 PR215.2
  TOP w0.381: PR216.1 PR214.1 PR215.2
N31565706: length 3.5
  BOTTOM w0.109: v2(195.47,38.18) 195.47,39.26 D2.1
  BOTTOM w0.508: D2.1 196.79,39.63 R133.1
N50951665: length 4.5
  BOTTOM w0.109: v2(42.94,57.89) 43.22,58.17 R335.2 R337.1 43.32,60.23 U30.21
N50952118: length 8.4
  TOP w0.109: U27.7 67.56,72.17 67.21,71.82 v3(67.21,71.59) 67.21,71.1 67.41,70.9 ; 67.41,70.9 67.02,70.51 67.02,69.88 67.28,69.63 U27.5 ; 67.41,70.9 U27.6 68.57,70.91 R322.2
N50953882: length 6.6
  BOTTOM w0.109: U30.2 52.68,61.53 R334.2 R336.1 52.93,63 52.11,63 52.09,62.98 50.23,62.98 v2(49.83,63.38)
N50983122: length 4.7
  TOP w0.254: PC175.1 96.05,86.49 v3(96.39,86.49) 96.97,87.08 96.97,87.76 97.27,88.06 PU18.11
  BOTTOM w0.381: v3(96.39,86.49) 96.21,86.32 v2(95.2,86.32)
N50983135: length 4.3
  TOP w0.254: PU19.11 97.2,78.02 96.92,77.74 96.92,77.46 96.27,76.82 v3(96.26,76.82) 95.55,76.1 PC180.1
  BOTTOM w0.381: v3(96.26,76.82) v2(96.26,75.67)
N51016995: length 4.7
  TOP w0.109: U26.1 33.09,49.19 R315.2 32.68,47.15 32.25,47.58 v3(31.87,47.58) 31.79,47.67 R446.1
N51017052: length 3.6
  TOP w0.109: R319.1 v3(28.8,48.37) 28.8,49.69 28.59,49.9 U26.7
N51017088: length 4.9
  TOP w0.109: R445.2 35.31,48.86 R321.1 34.79,48.88 34.64,49.04 34.64,49.44 34.18,49.9 U26.2 v3(31.88,49.9)
N51062251: length 6.1
  TOP w0.109: v3(30.78,36.08) Y4.1 31.81,38.29 35.18,38.29 R361.2
N51103807: length 5.9
  BOTTOM w0.109: v2(55.22,58.82) 55.02,59.02 53.85,59.02 53.66,59.22 53.39,59.22 53.08,59.53 R331.2 C155.1 53.07,60.88 U30.3
N51110422: length 6.9
  TOP w0.109: v3(31.57,51.19) 32.21,50.55 U26.3 35.27,50.55 R320.1 35.38,50.55 35.64,50.82 36.58,50.82 36.93,51.17 R444.2
N51251897: length 3.7
  TOP w0.109: v3(149.47,13.24) 148.94,13.77 R31.2 146.04,13.77 D1.1
N51328604: length 31.3
  T03 w0.097: v3(167.82,11.9) 168.05,12.13 182.28,12.13 183.9,10.51 183.9,9.8 v3(185.17,8.53)
  BOTTOM w0.109: v3(185.17,8.53) 185.17,8.65 186.82,10.3 R214.2 R224.1 187.32,11.32 186.32,10.31 U21.6 ; U22.6 168.21,10.65 R223.2 167.77,11.09 167.77,11.85 v3(167.82,11.9) 167.02,11.9 166.62,11.5 v2(164.87,11.5)
N51706711: length 2.8
  TOP w0.109: Q4.3 59.27,54.25 58.9,54.62 D3.2 59.16,55.34 v3(59.9,55.34)
N51706727: length 3.9
  TOP w0.109: D4.2 57.51,55.03 58.26,54.27 v3(58.26,53.25) 57.72,52.71 Q4.6
N51706866: length 4.7
  TOP w0.109: Q5.6 55.59,54.36 55.6,54.38 D5.2 56.19,55.59 56.52,55.92 v3(56.52,57.93)
N51706875: length 5
  TOP w0.109: v3(52.93,51.53) 52.93,52.05 53.58,52.71 Q5.3 53.61,52.74 54.1,52.74 54.4,53.04 54.4,54.83 54.2,55.03 D6.2
N52503655: length 2.4
  TOP w0.109: PC2.1 30.81,93.15 v3(30.84,93.17)
  TOP w0.381: PC2.1 PR267.2
N52712988: length 12.5
  BOTTOM w0.381: J10.A69 85.35,16.82 v2(85.06,17.11) 85.06,17.14 R309.1
N52791405: length 8.8
  BOTTOM w0.109: R453.2 82.52,28.85 U8.13 79.75,28.85 76.45,32.15 v2(76.45,33.16)
N52791408: length 7.7
  BOTTOM w0.109: R454.2 82.66,29.49 81.95,29.49 81.94,29.5 U8.12 79.61,29.5 77.72,31.39 v2(77.72,33.16)
N52791411: length 6.6
  BOTTOM w0.109: v2(78.99,33.16) 78.99,30.88 79.72,30.15 U8.11 81.57,30.15 82.04,30.62 R455.2
N52791414: length 6.2
  BOTTOM w0.109: v2(80.26,33.16) 79.5,32.4 79.5,30.93 79.63,30.8 U8.10 81.46,30.8 82.3,31.64 R456.2
N52791852: length 8.8
  BOTTOM w0.109: v2(73.53,25.29) 74.17,25.92 75.69,25.92 76.2,26.43 76.2,28.46 75.81,28.85 U8.4 74.29,28.85 73.79,29.35 R457.1
N52791855: length 6.8
  BOTTOM w0.109: U8.5 75.8,29.5 76.52,28.78 76.52,25.5 R458.1 v2(74.93,25.19)
N52825916: length 3.7
  BOTTOM w0.109: Q6.3 v2(56.52,21.24) 57.18,21.24 57.2,21.23 R461.1
N53284246: length 18.7
  BOTTOM w0.109: J10.A6 20.35,10.25 24.2,14.1 24.2,17.61 24.89,18.3 24.89,18.69 25.3,19.09 R88.2 25.3,20.54 R447.1 25.25,20.59 24.72,21.11 24.72,21.89 v2(25.25,22.41)
N53284254: length 18.9
  BOTTOM w0.109: J10.A7 21.35,8.67 20.93,9.09 20.93,10.38 24.51,13.97 24.51,16.78 25.27,17.54 25.27,18.33 R92.2 26.06,19.78 R447.2 26.06,21.85 v2(26.57,22.35)
N53284256: length 15
  BOTTOM w0.109: J10.A5 19.35,11.04 20.16,11.85 20.16,15.12 v2(21.62,16.58) 23.52,18.48 R86.2
N53284262: length 17.2
  BOTTOM w0.109: R94.2 28.98,19.73 28.7,19.45 28.7,18.28 28.19,17.77 28.19,16.81 v2(27.95,16.57) 27.61,16.23 26.87,16.23 26.24,15.6 26.24,14.96 22.99,11.71 22.99,11.7 22.35,11.06 J10.A8
N54434897: length 2.8
  TOP w0.305: J3.4 204.43,5.06 v3(203.84,4.46)
  BOTTOM w0.305: v3(203.84,4.46) 203.73,4.36 R132.2
N54436589: length 3.2
  TOP w0.305: v3(201.29,4.59) 200.83,5.06 J3.2
  BOTTOM w0.305: v3(201.29,4.59) 201.07,4.36 R131.2
N54591271: length 3.2
  BOTTOM w0.109: v2(79.45,41.53) 79.44,41.55 R465.1 78.26,40.92 77.88,40.54 Q1.3

## Copper pours and planes (outline as drawn)
GND on TOP (solid shape): 152.53,3.19 149.86,3.19 149.86,7.51 152.53,7.51
GND on TOP (solid shape): 18.7,10.46 18.7,4.11 18.01,4.11 18.01,10.4 18.25,10.64 18.53,10.64
GND on TOP (solid shape): 21.7,10.46 21.7,4.11 20.99,4.11 20.99,10.38 21.25,10.64 21.53,10.64
GND on TOP (solid shape): 32.7,9.98 32.7,4.11 31.99,4.11 31.99,9.92 32.12,10.05 32.64,10.05
GND on TOP (solid shape): 48.7,10.46 48.7,4.11 47.99,4.11 47.99,10.38 48.25,10.64 48.53,10.64
GND on TOP (solid shape): 65.7,9.77 65.7,4.11 64.99,4.11 64.99,9.77 65.1,9.87 65.61,9.87
GND on TOP (solid shape): 96.7,10.46 96.7,4.11 95.99,4.11 95.99,10.38 96.25,10.64 96.53,10.64
GND on TOP (solid shape): 29.7,10.46 29.7,4.11 28.99,4.11 28.99,9.13 28.86,9.27 28.86,10.56 28.94,10.64 29.53,10.64
GND on TOP (solid shape): 45.7,10.2 45.7,4.11 44.99,4.11 44.99,8.91 44.37,9.53 44.37,10.4 44.48,10.51 45.4,10.51
GND on TOP (solid shape): 63.7,9.64 63.7,4.11 62.99,4.11 62.99,8.74 62.29,9.44 62.29,9.85 62.38,9.95 63.4,9.95
GND on TOP (solid shape): 69.99,93.61 69.99,83.45 69.36,82.82 63.01,82.82 62.37,83.45 62.37,93.61 63.01,94.25 69.36,94.25
GND on TOP (solid shape): 138.56,94.25 138.56,74.31 137.92,73.68 129.41,73.68 128.92,74.17 128.92,94 129.43,94.5 138.3,94.5
GND on TOP (solid shape): 39.07,76.87 39.07,74.79 39.02,74.79 39.02,73.87 39.07,73.87 39.07,71.66 38.81,71.41 37.04,71.41 36.44,72.01 36.44,76.87 36.82,77.25 38.69,77.25
GND on TOP (solid shape): 31.5,82.31 31.5,76.11 31.47,76.11 31.47,75.56 31.5,75.56 31.5,75.33 31.24,75.07 28.19,75.07 27.05,76.22 27.05,80.53 27.43,80.92 29.08,80.92 30.61,82.44 31.37,82.44
GND on TOP (solid shape): 38.7,9.54 38.7,4.11 38.7,4.11 38,4.11 38,4.11 38,8.3 37.93,8.37 37.78,8.37 37.71,8.3 37.71,4.11 37.7,4.1 37,4.1 36.99,4.11 36.99,9.72 37.15,9.87 38.37,9.87
GND on TOP (solid shape): 42.7,9.03 42.7,4.11 42.7,4.11 42,4.11 42,4.11 42,8.3 41.93,8.37 41.78,8.37 41.71,8.3 41.71,4.11 41.7,4.1 41,4.1 40.99,4.11 40.99,9.08 41.1,9.19 42.55,9.19
GND on TOP (solid shape): 69.7,9.54 69.7,4.11 69.7,4.11 69,4.11 69,4.11 69,8.3 68.93,8.37 68.78,8.37 68.7,8.3 68.7,4.11 68.7,4.1 68,4.1 67.99,4.11 67.99,9.72 68.15,9.87 69.37,9.87
GND on TOP (solid shape): 52.7,9.54 52.7,4.11 52.7,4.11 52,4.11 52,4.11 52,8.3 51.93,8.37 51.78,8.37 51.71,8.3 51.71,4.11 51.7,4.1 51,4.1 50.99,4.11 50.99,8.8 50.36,9.43 50.36,9.69 50.51,9.83 52.41,9.83
GND on TOP (solid shape): 62.1,74.57 62.1,72.28 61.98,72.15 57.02,72.15 56.97,72.17 52.28,72.17 52.15,72.3 52.15,73.57 52.4,73.82 54.55,73.82 54.63,73.74 56.25,73.74 56.33,73.82 56.39,73.82 57.13,74.57 57.91,74.57 58.29,74.95 61.72,74.95
GND on TOP (solid shape): 90.21,9.69 90.21,8.93 89.7,8.42 89.7,4.11 89.7,4.11 89,4.11 89,4.11 89,8.3 88.93,8.37 88.78,8.37 88.7,8.3 88.7,4.11 88.7,4.1 88,4.1 87.99,4.11 87.99,9.72 88.15,9.87 90.03,9.87
GND on TOP (solid shape): 93.7,9.54 93.7,4.11 93.7,4.11 93,4.11 93,4.11 93,8.3 92.93,8.37 92.78,8.37 92.7,8.3 92.7,4.11 92.7,4.1 92,4.1 91.99,4.11 91.99,8.77 91.48,9.28 91.48,9.71 91.64,9.87 93.37,9.87
GND on TOP (solid shape): 144.68,64.24 144.68,63.14 144.36,62.82 144.29,62.82 144.26,62.82 144.22,62.81 143.91,62.81 143.8,62.91 143.8,63.11 143.57,63.34 143.3,63.34 143.15,63.49 142.57,63.49 142.54,63.52 142.54,64.49 142.61,64.56 144.37,64.56
GND on TOP (solid shape): 47.45,73.44 47.45,69.53 47.42,69.53 47.42,68.97 47.45,68.97 47.45,68.34 46.97,67.86 46.97,64.66 46.71,64.4 45.7,64.4 45.44,64.66 45.44,66.16 45.54,66.26 45.54,68.72 45.44,68.82 45.44,68.87 45.3,69.01 45.3,73.2 45.67,73.57 47.32,73.57
GND on TOP (solid shape): 57.41,9.74 57.41,9.4 56.7,8.69 56.7,4.11 56.7,4.11 56,4.11 56,4.11 56,8.3 55.93,8.37 55.78,8.37 55.7,8.3 55.7,4.11 55.7,4.1 55,4.1 54.99,4.11 54.99,8.76 54.32,9.43 54.32,9.74 54.46,9.87 57.29,9.87
GND on TOP (solid shape): 61.41,9.71 61.41,9.43 60.7,8.72 60.7,4.11 60.7,4.11 60,4.11 60,4.11 60,8.3 59.93,8.37 59.78,8.37 59.7,8.3 59.7,4.11 59.7,4.1 59,4.1 58.99,4.11 58.99,8.72 58.29,9.43 58.29,9.71 58.44,9.87 61.26,9.87
GND on TOP (solid shape): 78.41,9.67 78.41,9.42 77.7,8.71 77.7,4.11 77.7,4.11 77,4.11 77,4.11 77,8.3 76.93,8.37 76.78,8.37 76.7,8.3 76.7,4.11 76.7,4.1 76,4.1 75.99,4.11 75.99,8.72 75.31,9.4 75.31,9.74 75.4,9.83 78.26,9.83
GND on TOP (solid shape): 194.44,91.75 194.44,89.27 194.24,89.06 193.22,89.06 193.15,89.14 193.15,89.24 193.04,89.34 193.04,89.82 192.87,90 191.95,90 191.44,89.49 190.78,89.49 190.63,89.65 190.63,90.59 190.06,91.15 189.42,91.15 189.12,91.45 189.12,91.96 189.37,92.22 193.98,92.22
GND on TOP (solid shape): 74.44,9.66 74.44,9.46 73.7,8.72 73.7,4.11 73.7,4.11 73,4.11 73,4.11 73,8.3 72.93,8.37 72.78,8.37 72.7,8.3 72.7,4.11 72.7,4.1 72,4.1 71.99,4.11 71.99,8.68 71.35,9.33 71.35,9.79 71.43,9.87 72.15,9.87 74.23,9.87
GND on TOP (solid shape): 81.78,9.57 81.78,8.51 81.78,8.51 81.78,8.46 81.7,8.39 81.7,4.11 81.7,4.11 81,4.11 81,4.11 81,8.3 80.93,8.37 80.78,8.37 80.7,8.3 80.7,4.11 80.7,4.1 80,4.1 79.99,4.11 79.99,8.7 79.29,9.41 79.29,9.59 79.4,9.69 81.66,9.69
GND on TOP (solid shape): 86.26,9.04 85.7,8.48 85.7,4.11 85.7,4.11 85,4.11 85,4.11 85,8.3 84.93,8.37 84.78,8.37 84.7,8.3 84.7,4.11 84.7,4.1 84,4.1 83.99,4.11 83.99,8.44 83.69,8.75 83.43,8.75 83.27,8.91 83.27,9.42 83.51,9.66 83.51,10.73 86.26,10.73
GND on TOP (solid shape): 25.78,56.15 25.78,52.59 25.53,52.34 20.07,52.34 19.28,53.13 11.24,53.13 10.77,52.66 10.77,49.15 10.35,49.15 10.35,50.59 9.97,50.97 9.97,51.89 9.99,51.91 9.99,52.82 9.92,52.89 9.92,53.21 9.77,53.21 9.6,53.38 2.1,53.38 1.73,53.76 1.73,56.17 2.09,56.53 25.4,56.53
GND on TOP (solid shape): 34.2,10.4 34.36,10.22 34.59,10.18 34.67,10.15 34.7,10.08 34.7,4.11 33.99,4.11 33.99,10.38 34.04,10.43 34.18,10.43
GND on TOP (solid shape): 53.42,87.67 53.42,79.98 53.34,79.9 51.56,79.9 51.26,80.2 51.26,82.46 50.75,82.97 45.6,82.97 44.75,82.11 37.08,82.11 36.83,82.37 36.83,85.13 37.08,85.38 44.17,85.38 44.17,85.26 45.75,85.26 45.75,85.36 49.92,85.36 49.92,85.38 49.99,85.38 50.12,85.51 50.12,87.54 50.37,87.79 53.29,87.79
GND on TOP (solid shape): 103.35,40.56 103.29,40.24 103.5,40 103.53,39.99 103.53,39.21 103.9,38.84 103.9,37.46 103.78,37.33 102.61,37.33 102.26,37.68 102.26,40.26 102.76,40.76 103.15,40.76
GND on TOP (solid shape): 28.64,87.44 28.78,87.44 28.86,87.4 28.88,87.31 28.86,87.05 28.94,86.81 28.95,86.8 28.95,86.54 27.46,86.54 27.46,86.47 27.41,86.42 27.41,85.38 27.28,85.25 23.65,85.25 21.73,83.33 20.07,83.33 19.81,83.58 19.81,86 20.07,86.25 23.11,86.25 23.62,86.76 23.62,86.76 24.13,87.27 26.04,87.27 26.04,87.24 27.26,87.24 27.26,87.27 27.26,87.79 27.69,88.22 28.64,88.22
GND on TOP (solid shape): 81.62,51.67 82.12,51.67 83.41,51.67 83.41,51.7 97.26,51.7 97.26,51.53 98.17,51.53 98.17,51.7 101.15,51.7 101.15,45.92 100.71,45.49 97.76,45.49 96.5,46.75 90.93,46.75 89.89,45.71 88.27,45.71 86.34,47.63 86.34,47.64 85.85,48.13 85.85,48.15 83.41,48.15 83.41,48.18 82.12,48.18 82.12,48.15 81.01,48.15 81.01,48.28 77.52,48.28 77.52,48.28 77.19,48.28 77.19,48.28 76.35,48.28 76.35,48.3 75.79,48.3 75.79,48.28 73.79,48.28 73.41,48.66 73.41,50.2 73.89,50.68 73.89,51.07 77.22,51.07 77.7,51.55 80.92,51.55 80.92,51.57 81.01,51.57 81.01,51.7 81.62,51.7
GND on TOP (solid shape): 75.01,69.9 75.02,69.82 75.04,69.75 75.06,69.7 75.08,69.66 75.1,69.62 75.15,69.55 75.18,69.52 75.22,69.49 75.26,69.46 75.31,69.43 75.35,69.41 75.41,69.38 75.47,69.37 75.55,69.36 75.7,69.21 75.7,68.97 75.83,68.84 76.19,68.73 76.47,68.96 76.49,68.99 76.55,68.99 76.8,68.74 76.8,67.6 76.93,67.47 78.58,67.47 78.58,66.45 71.47,66.45 71.47,67.47 73.12,67.47 73.25,67.6 73.25,68.23 73.2,68.27 73.2,68.36 73.12,68.36 72.36,69.12 72.36,69.86 72.38,69.86 72.38,70.42 72.48,70.52 74.39,70.52
GND on TOP (solid shape): outline of 91 points within 144.48,86.36 168.72,93.85
GND on TOP (solid shape): 209,95.56 209.26,95.46 209.37,95.2 209.37,1 209.26,0.74 209,0.63 123.13,0.63 123.13,10.75 122.67,11.87 121.55,12.34 100.15,12.34 100.15,12.97 121.55,12.97 123.12,12.32 123.77,10.75 123.77,1.27 208.73,1.27 208.73,16.8 207.74,17.79 207.74,21.65 208.73,22.64 208.73,85.12 207.74,86.11 207.74,90.2 208.73,91.19 208.73,94.93 1.27,94.93 1.27,91.09 2.25,90.11 2.25,86.27 1.27,85.28 1.27,22.64 2.25,21.65 2.25,17.65 1.27,16.67 1.27,12.97 14.68,12.97 14.68,12.34 1,12.34 0.74,12.44 0.64,12.7 0.64,95.2 0.74,95.46 1,95.56
GND on TOP (solid shape): outline of 122 points within 196.34,65.47 206.25,71.89
GND on TOP (solid shape): outline of 122 points within 142.75,60.8 167.31,82.14
GND on TOP (solid shape): 83.05,39.12 83.7,39.12 84.07,38.75 84.07,35.45 85.95,33.58 85.95,31.96 86.12,31.78 86.3,31.78 86.48,31.61 86.48,30.75 86.29,30.75 86.12,30.74 85.97,30.67 85.71,30.67 85.3,30.71 85.08,30.36 85.08,30.19 85.27,29.99 85.4,29.91 85.55,29.88 85.83,29.88 85.83,28.91 85.4,28.91 85.36,28.94 85.37,29 85.37,29.56 84.81,29.56 84.76,29.51 84.71,29.5 84.68,29.55 84.68,31.35 84.71,31.36 84.99,31.72 84.83,32.14 84.79,32.22 84.83,32.3 84.57,33.14 84.35,32.29 84.38,32.25 84.35,32.2 84.27,32.16 84.02,32.42 83.34,32.42 83.33,32.46 82.97,32.77 82.59,32.5 82.58,32.47 82.49,32.47 82.49,32.57 82.09,32.97 81.7,32.57 81.7,32.16 81.4,31.86 80.62,31.86 80.58,31.86 80.52,31.85 79.66,31.85 79.66,31.08 80.52,31.08 80.58,31.07 80.62,31.07 81.4,31.07 81.4,30.34 81.4,30.11 81.32,30.03 79.5,30.03 79.27,30.26 79.27,38.67 79.25,38.69 79.25,39.01 79.42,39.17 83,39.17
GND on TOP (solid shape): outline of 239 points within 0.7,83.2 10,93.2
GND on TOP (solid shape): outline of 265 points within 0,83.2 10,93.2
GND on TOP (solid shape): outline of 265 points within 0,14.69 10,24.69
GND on TOP (solid shape): outline of 265 points within 200,83.2 210,93.2
GND on TOP (solid shape): outline of 265 points within 200,14.7 210,24.7
GND on TOP (solid shape): outline of 259 points within 143.51,14.89 167.2,43.6
GND on TOP (solid shape): 122.53,50.21 122.53,50.18 122.65,50.05 122.65,45.99 122.64,45.98 122.64,44.19 122.96,43.88 122.96,42.53 122.92,42.52 122.68,42.25 122.77,41.91 122.85,41.83 122.88,41.75 122.67,41.41 122.77,41.11 122.87,41.01 122.89,40.93 122.85,40.86 122.79,40.81 122.73,40.74 122.63,40.63 122.61,40.66 122.28,40.66 122.2,40.71 122.19,40.8 122.21,41.07 122.07,41.28 122.07,41.45 122.22,41.84 121.93,42.15 121.91,42.15 121.73,42.34 121.73,42.36 121.34,42.7 121.05,42.27 121.05,42.27 121.05,42.08 121.41,41.73 121.41,40.93 121.37,40.92 121.1,40.67 121.19,40.32 121.26,40.24 121.29,40.16 121.07,39.81 121.17,39.51 121.47,39.21 121.49,39.17 121.49,39.11 121.01,39.11 120.89,39.23 120.83,39.28 120.75,39.32 120.62,39.45 120.62,39.46 120.54,39.61 120.41,39.72 120.38,39.73 120.38,39.8 120.41,39.82 120.63,40.14 120.47,40.49 120.42,40.57 120.63,40.97 120.42,41.37 120.47,41.45 120.63,41.8 120.4,42.12 120.39,42.13 120.1,42.42 120.1,42.46 119.97,42.74 119.59,42.85 119.55,42.93 119.55,50.03 119.86,50.34 122.4,50.34
GND on TOP (solid shape): outline of 406 points within 94.36,14.36 105.41,30.12
GND on TOP (solid shape): outline of 561 points within 81.77,59.98 109.6,95.52
GND on TOP (solid shape): outline of 271 points within 128.63,25.06 146.4,44.99
GND on TOP (solid shape): outline of 209 points within 128.22,59.06 142.97,64.56
GND on TOP (solid shape): outline of 1081 points within 127.16,42.88 142.11,58.9
GND on TOP (solid shape): outline of 2220 points within 173.91,59.85 195.66,86.52
GND on TOP (solid shape): outline of 3270 points within 173.76,14.38 198.34,49.06
GND on BOTTOM (solid shape): 18.7,9.62 18.7,4.11 18.01,4.11 18.01,9.7 18.15,9.84 18.48,9.84
GND on BOTTOM (solid shape): 31.7,10.46 31.7,4.11 30.99,4.11 30.99,10.38 31.25,10.64 31.53,10.64
GND on BOTTOM (solid shape): 34.7,9.8 34.7,4.11 33.99,4.11 33.99,9.8 34.12,9.92 34.58,9.92
GND on BOTTOM (solid shape): 47.7,10.46 47.7,4.11 46.99,4.11 46.99,10.38 47.25,10.64 47.53,10.64
GND on BOTTOM (solid shape): 65.7,10.46 65.7,4.11 64.99,4.11 64.99,10.38 65.25,10.64 65.53,10.64
GND on BOTTOM (solid shape): 29.23,10.4 29.23,9.09 28.7,8.57 28.7,4.11 28.31,4.11 28.31,10.53 28.42,10.64 28.99,10.64
GND on BOTTOM (solid shape): 51.13,10.42 51.13,9.69 50.7,9.26 50.7,4.11 49.99,4.11 49.99,10.38 50.25,10.64 50.92,10.64
GND on BOTTOM (solid shape): 68.42,9.66 68.42,9.2 67.7,8.49 67.7,4.11 66.99,4.11 66.99,9.76 67.12,9.89 68.19,9.89
GND on BOTTOM (solid shape): 69.99,93.61 69.99,86.65 69.34,86 63.12,86 62.37,86.74 62.37,93.61 63.01,94.25 69.36,94.25
GND on BOTTOM (solid shape): 98.49,10.51 98.49,4.11 97.99,4.11 97.99,8.42 97.74,8.67 97.74,10.58 97.87,10.7 98.29,10.7
GND on BOTTOM (solid shape): 36.7,10.46 36.7,4.11 35.99,4.11 35.99,8.65 36,8.65 36,10.38 36,10.39 36.25,10.64 36.53,10.64
GND on BOTTOM (solid shape): 54.61,70.76 54.61,68.39 54.56,68.34 54.56,68.04 54.23,67.71 49.28,67.71 49.15,67.83 49.15,68.73 51.56,71.14 54.23,71.14
GND on BOTTOM (solid shape): 54.69,9.82 54.69,4.11 53.99,4.11 53.99,8.3 53.92,8.37 53.78,8.37 53.7,8.3 53.7,4.11 52.99,4.11 52.99,9.83 53.14,9.97 54.54,9.97
GND on BOTTOM (solid shape): 58.69,9.82 58.69,4.11 57.99,4.11 57.99,8.3 57.92,8.37 57.78,8.37 57.7,8.3 57.7,4.11 56.99,4.11 56.99,9.82 57.15,9.97 58.54,9.97
GND on BOTTOM (solid shape): 62.69,10.45 62.69,4.11 61.99,4.11 61.99,8.3 61.92,8.37 61.78,8.37 61.7,8.3 61.7,4.11 60.99,4.11 60.99,10.38 61.25,10.64 62.51,10.64
GND on BOTTOM (solid shape): 71.69,10.11 71.69,4.11 70.99,4.11 70.99,8.3 70.92,8.37 70.78,8.37 70.7,8.3 70.7,4.11 69.99,4.11 69.99,10.09 70.21,10.3 71.5,10.3
GND on BOTTOM (solid shape): 75.69,9.82 75.69,4.11 74.99,4.11 74.99,8.3 74.92,8.37 74.78,8.37 74.7,8.3 74.7,4.11 73.99,4.11 73.99,9.77 74.17,9.95 75.56,9.95
GND on BOTTOM (solid shape): 87.69,10.45 87.69,4.11 86.99,4.11 86.99,8.3 86.92,8.37 86.78,8.37 86.7,8.3 86.7,4.11 85.99,4.11 85.99,10.38 86.25,10.64 87.51,10.64
GND on BOTTOM (solid shape): 167.46,91.96 167.46,90.72 167.36,90.62 162.89,90.62 162.89,90.64 161.98,90.64 161.98,90.62 160.68,90.62 160.36,90.94 160.36,91.8 160.62,92.06 167.36,92.06
GND on BOTTOM (solid shape): 91.99,9.74 91.99,8.76 91.69,8.47 91.69,4.11 90.99,4.11 90.99,8.3 90.92,8.37 90.78,8.37 90.7,8.3 90.7,4.11 89.99,4.11 89.99,8.46 89.73,8.72 89.73,9.74 89.88,9.89 91.84,9.89
GND on BOTTOM (solid shape): 25.78,56.15 25.78,52.98 25.65,52.85 19.05,52.85 18.8,53.1 17.86,53.1 17.86,53.15 16.94,53.15 16.94,53.1 16.46,53.1 16.46,53.15 15.54,53.15 15.54,53.1 14.99,53.1 14.73,53.36 14.73,56.02 15.24,56.53 25.4,56.53
GND on BOTTOM (solid shape): 83.82,10.68 83.82,8.91 83.69,8.78 83.69,4.11 82.99,4.11 82.99,8.3 82.92,8.37 82.78,8.37 82.7,8.3 82.7,4.11 81.99,4.11 81.99,8.44 81.3,9.14 81.3,9.68 81.99,10.37 81.99,10.38 82.44,10.83 83.67,10.83
GND on BOTTOM (solid shape): 79.56,10 79.6,10 79.67,9.96 79.69,9.9 79.69,4.11 78.99,4.11 78.99,8.3 78.92,8.37 78.78,8.37 78.7,8.3 78.7,4.11 77.99,4.11 77.99,9.92 78.09,10.02 79.52,10.02
GND on BOTTOM (solid shape): 94.8,10.63 94.96,10.59 95.12,10.63 95.13,10.64 95.51,10.64 95.69,10.45 95.69,4.11 94.99,4.11 94.99,8.3 94.92,8.37 94.78,8.37 94.7,8.3 94.7,4.11 93.99,4.11 93.99,10.38 94.25,10.64 94.78,10.64
GND on BOTTOM (solid shape): 75.73,69.17 75.73,69.15 75.83,68.86 76.12,68.74 76.15,68.72 76.17,68.69 76.17,68.36 76.04,68.23 72.61,68.23 72.36,68.49 72.36,69.86 72.38,69.86 72.38,70.42 72.48,70.52 74.39,70.52
GND on BOTTOM (solid shape): 40.68,10.03 40.64,9.99 40.63,9.98 40.47,9.73 40.66,9.5 40.69,9.49 40.69,4.11 39.99,4.11 39.99,8.3 39.92,8.37 39.78,8.37 39.7,8.3 39.7,4.11 38.99,4.11 38.99,10.02 39.1,10.13 40.59,10.13
GND on BOTTOM (solid shape): 44.69,10.45 44.69,4.11 43.99,4.11 43.99,8.3 43.92,8.37 43.78,8.37 43.7,8.3 43.7,4.11 42.99,4.11 42.99,8.42 43.15,8.57 43.15,9.05 42.99,9.2 42.99,9.49 43.03,9.5 43.23,9.74 43.03,9.99 42.99,10 42.99,10.38 43.17,10.56 44.58,10.56
GND on BOTTOM (solid shape): 97.3,41.9 97.3,39.87 97.05,39.62 95.02,39.62 93.7,38.31 93.7,31.5 93.8,31.4 93.8,31.4 93.96,31.24 96.19,31.24 97.18,30.25 97.18,28.18 96.76,27.76 95.67,27.76 94.06,29.37 92.15,29.37 91.79,29.74 91.79,30.01 91.8,30.02 91.91,30.4 91.79,30.77 91.79,34.25 91.46,34.58 91.46,35.56 90.95,36.06 89.94,36.06 89.81,36.19 89.81,41.9 89.82,41.91 89.82,42.19 90.05,42.43 96.78,42.43
GND on BOTTOM (solid shape): 138.3,94.5 138.56,94.25 138.56,85.18 138.56,85.17 138.54,85.02 138.56,84.87 138.56,84.86 138.56,79.57 138.47,79.49 138.47,77.88 138.56,77.8 138.56,76.22 137.16,74.82 132.33,74.82 132.08,75.07 132.08,77.61 131.32,78.38 122.81,78.38 122.56,78.63 122.56,78.88 122.56,78.89 122.56,80.16 122.56,80.17 122.56,81.04 122.68,81.17 131.19,81.17 131.32,81.3 131.32,85.36 131.19,85.49 122.68,85.49 122.56,85.61 122.56,88.15 122.68,88.28 131.32,88.28 131.44,88.41 131.44,92.22 131.06,92.6 117.86,92.6 117.6,92.85 117.6,93.87 118.24,94.5 122.94,94.5
GND on BOTTOM (solid shape): 131.9,53.69 133.04,53.69 133.09,53.64 133.09,53.16 133.12,53.16 133.4,52.88 133.4,51.84 131.97,51.84 131.92,51.79 131.92,51.25 131.87,51.25 131.87,50.5 131.89,50.39 131.91,50.31 131.92,50.28 131.92,49.29 131.92,49.28 131.89,49.16 131.87,49.06 131.87,48.3 131.92,48.3 131.92,47.98 132.02,47.87 133.32,47.87 133.35,47.85 133.35,46.41 133.14,46.21 132.05,46.21 131.95,46.11 131.95,45.02 132.35,44.61 132.35,44.05 132.17,43.87 131.01,43.87 130.93,43.95 130.93,44.77 130.73,44.98 130.36,44.98 130.32,45.02 130.32,45.83 130.23,45.92 130.25,45.92 130.25,46.83 130.22,46.83 130.22,47.29 130.25,47.29 130.25,48.2 130.22,48.2 130.22,48.66 130.25,48.66 130.25,49.58 130.22,49.58 130.22,50.03 130.27,50.03 130.27,50.95 130.22,50.95 130.22,51.4 130.27,51.4 130.27,52.32 130.22,52.32 130.22,52.78 130.27,52.78 130.27,53.7 131.88,53.7
GND on BOTTOM (solid shape): 82.04,28.13 82.04,27.82 81.63,27.41 79.88,27.41 79.74,27.28 79.65,27.28 79.65,26.52 79.86,26.52 79.9,26.47 81.65,26.47 81.81,26.32 81.81,25.46 81.3,24.95 80.43,24.95 80.34,25 80.34,25.1 80.09,25.66 79.63,25.25 79.57,25.15 79.46,25.17 79.14,25.48 79.14,25.66 79.15,25.77 79.14,25.88 79.14,27.13 79.52,27.52 79.52,28.18 79.7,28.35 81.81,28.35
GND on BOTTOM (solid shape): 209,95.56 209.26,95.46 209.37,95.2 209.37,1 209.26,0.74 209,0.63 123.13,0.63 123.13,10.75 122.67,11.87 121.55,12.34 100,12.34 100,12.97 121.55,12.97 123.12,12.32 123.77,10.75 123.77,1.27 208.73,1.27 208.73,16.54 207.74,17.53 207.74,22 208.73,22.99 208.73,85.28 207.74,86.27 207.74,90.33 208.73,91.32 208.73,94.93 1.27,94.93 1.27,91.22 2.25,90.23 2.25,86.27 1.27,85.28 1.27,22.77 2.25,21.78 2.25,17.69 1.27,16.7 1.27,12.97 14.68,12.97 14.68,12.34 1,12.34 0.74,12.44 0.64,12.7 0.64,95.2 0.74,95.46 1,95.56
GND on BOTTOM (solid shape): outline of 113 points within 117.93,39.23 123.16,51.15
GND on BOTTOM (solid shape): 126.56,52.38 126.56,51.51 126.59,51.51 126.59,45.75 126.46,45.63 126.37,45.63 126.35,45.64 126.06,45.75 125.73,45.63 125.69,45.64 125.53,45.73 125.35,45.75 125.32,45.75 125.09,45.98 125.1,46 125.08,46.2 124.98,46.38 124.97,46.41 124.98,46.45 125.1,46.75 124.99,47.05 124.98,47.09 124.99,47.12 125.1,47.43 124.98,47.73 124.96,47.76 124.98,47.79 125.08,48.07 124.98,48.38 124.99,48.41 125.1,48.71 124.99,49.01 124.98,49.04 125.08,49.36 124.97,49.64 124.95,49.68 124.97,49.71 125.08,50.02 124.95,50.32 124.94,50.33 124.94,50.42 124.95,50.43 125.05,50.73 124.94,51.02 124.94,51.47 125.95,52.48 126.46,52.48
GND on BOTTOM (solid shape): 209,95.56 209.26,95.46 209.37,95.2 209.37,1 209.26,0.74 209,0.63 123.13,0.63 123.13,10.75 122.67,11.87 121.55,12.34 100,12.34 99.92,12.33 98.83,11.9 98.35,10.83 98.35,8.79 97.78,8.79 97.78,10.85 98.44,12.38 100,12.97 107.07,12.97 121.57,12.97 123.13,12.31 123.77,10.75 123.77,1.27 208.73,1.27 208.73,16.8 207.74,17.79 207.74,21.65 208.73,22.64 208.73,85.12 207.74,86.11 207.74,90.2 208.73,91.19 208.73,94.93 198.36,94.93 198.34,94.95 142.08,94.95 142.06,94.93 1.27,94.93 1.27,91.09 2.25,90.11 2.25,86.27 1.27,85.28 1.27,22.64 2.25,21.65 2.25,17.65 1.27,16.67 1.27,12.97 14.68,12.97 14.68,12.34 1,12.34 0.74,12.44 0.64,12.7 0.64,95.2 0.74,95.46 1,95.56
GND on BOTTOM (solid shape): outline of 185 points within 179.16,81.44 194.44,92.09
GND on BOTTOM (solid shape): outline of 240 points within 0.68,83.2 10,93.2
GND on BOTTOM (solid shape): outline of 234 points within 73.41,45.48 96.5,67.09
GND on BOTTOM (solid shape): outline of 265 points within 0,83.2 10,93.2
GND on BOTTOM (solid shape): outline of 265 points within 0,14.69 10,24.69
GND on BOTTOM (solid shape): outline of 265 points within 200,83.2 210,93.2
GND on BOTTOM (solid shape): outline of 265 points within 200,14.7 210,24.7
GND on BOTTOM (solid shape): 104.16,92.43 104.16,89.85 104.12,89.77 104.04,89.75 103.61,89.37 104.04,88.99 104.12,88.96 104.16,88.89 104.16,79.73 104.11,79.64 104.01,79.63 103.48,79.28 104.01,78.93 104.11,78.92 104.16,78.84 104.16,78.53 102.29,76.67 102.28,76.67 102.17,76.6 102.11,76.49 102.1,76.48 100.76,75.13 100.74,75.13 100.46,75.1 100.17,75.04 97.56,75.04 97.16,75.45 97.16,75.99 97.19,76.07 97.28,76.09 97.77,76.18 98.11,76.55 98.11,76.56 98.52,76.97 98.52,76.97 98.94,77.91 98.26,78.68 98.24,79.11 98.04,79.48 98.01,79.56 98.05,79.63 98.29,80.75 97.28,81.29 97.19,81.31 97.16,81.39 97.16,85.48 97.2,85.56 97.3,85.57 98.63,86.44 97.3,87.32 97.2,87.33 97.16,87.41 97.16,87.47 97.19,87.54 97.26,87.57 98.2,88.47 97.38,89.47 97.31,89.51 97.29,89.59 97.28,89.87 97.16,90.13 97.16,91.96 98.43,93.23 103.36,93.23
GND on BOTTOM (solid shape): outline of 377 points within 185.47,59.47 202.44,78.65
GND on BOTTOM (solid shape): outline of 618 points within 185.47,16.99 198.47,47.51
GND on BOTTOM (solid shape): outline of 915 points within 19,76.11 34.88,93.89
GND on BOTTOM (solid shape): outline of 2458 points within 157.94,60.55 179.12,90.33
GND on BOTTOM (solid shape): outline of 2843 points within 157.57,10.68 178.99,44.05
GND on G02 (solid shape): outline of 100376 points within 0.64,0.63 209.37,95.56
GND on T03 (solid shape): 25.27,4.13 15.32,4.13 15.32,4.87 25.27,4.87
GND on T03 (solid shape): 98.36,4.13 28.42,4.13 28.42,4.77 98.36,4.77
GND on T03 (solid shape): 24.63,10.3 26.85,12.52 29.07,10.3 29.07,9.68 29.07,9.67 29.07,9.44 29.07,9.43 29.07,4.39 28.44,4.39 28.44,10.3 26.85,11.88 25.26,10.3 25.26,4.08 24.63,4.08
GND on T03 (solid shape): outline of 240 points within 200,83.2 209.33,93.2
GND on T03 (solid shape): outline of 240 points within 200,14.7 209.34,24.7
GND on T03 (solid shape): outline of 241 points within 0.66,83.2 10,93.2
GND on T03 (solid shape): outline of 241 points within 0.66,14.69 10,24.69
GND on T03 (solid shape): outline of 100 points within 0.64,0.63 209.37,95.56
GND on G04 (solid shape): outline of 98794 points within 0.64,0.63 209.37,95.56
GND on T05 (solid shape): 25.27,4.13 15.32,4.13 15.32,4.87 25.27,4.87
GND on T05 (solid shape): 98.36,4.13 28.42,4.13 28.42,4.77 98.36,4.77
GND on T05 (solid shape): outline of 240 points within 200,83.2 209.33,93.2
GND on T05 (solid shape): outline of 240 points within 200,14.7 209.34,24.7
GND on T05 (solid shape): outline of 241 points within 0.66,83.2 10,93.2
GND on T05 (solid shape): outline of 241 points within 0.66,14.69 10,24.69
GND on T05 (solid shape): outline of 100 points within 0.64,0.63 209.37,95.56
GND on P06 (solid shape): 25.27,4.13 15.32,4.13 15.32,4.87 25.27,4.87
GND on P06 (solid shape): 98.36,4.13 28.42,4.13 28.42,4.77 98.36,4.77
GND on P06 (solid shape): outline of 241 points within 0.66,83.2 10,93.2
GND on P06 (solid shape): outline of 241 points within 0.66,14.69 10,24.69
GND on P06 (solid shape): outline of 100 points within 0.64,0.63 209.37,95.56
GND on P06 (solid shape): outline of 24808 points within 125.95,0.92 209.14,93.2
GND on P07 (solid shape): 25.27,4.13 15.32,4.13 15.32,4.87 25.27,4.87
GND on P07 (solid shape): 98.36,4.13 28.42,4.13 28.42,4.77 98.36,4.77
GND on P07 (solid shape): outline of 240 points within 200,83.2 209.33,93.2
GND on P07 (solid shape): outline of 240 points within 200,14.7 209.34,24.7
GND on P07 (solid shape): outline of 241 points within 0.66,83.2 10,93.2
GND on P07 (solid shape): outline of 241 points within 0.66,14.69 10,24.69
GND on P07 (solid shape): outline of 229 points within 76.66,65.19 128.22,94.65
GND on P07 (solid shape): outline of 100 points within 0.64,0.63 209.37,95.56
GND on P07 (solid shape): outline of 1746 points within 78.72,73.59 113.57,92.75
GND on P07 (solid shape): outline of 10291 points within 128.24,55.66 199.48,94.52
GND on P07 (solid shape): outline of 15570 points within 129.51,2.53 197.89,44.61
GND on T08 (solid shape): 25.27,4.13 15.32,4.13 15.32,4.87 25.27,4.87
GND on T08 (solid shape): 98.36,4.13 28.42,4.13 28.42,4.77 98.36,4.77
GND on T08 (solid shape): outline of 240 points within 200,83.2 209.33,93.2
GND on T08 (solid shape): outline of 240 points within 200,14.7 209.34,24.7
GND on T08 (solid shape): outline of 241 points within 0.66,83.2 10,93.2
GND on T08 (solid shape): outline of 241 points within 0.66,14.69 10,24.69
GND on T08 (solid shape): outline of 100 points within 0.64,0.63 209.37,95.56
GND on G09 (solid shape): outline of 100840 points within 0.64,0.63 209.37,95.56
GND on T10 (solid shape): 25.27,4.13 15.32,4.13 15.32,4.87 25.27,4.87
GND on T10 (solid shape): 98.36,4.13 28.42,4.13 28.42,4.77 98.36,4.77
GND on T10 (solid shape): outline of 240 points within 200,83.2 209.33,93.2
GND on T10 (solid shape): outline of 240 points within 200,14.7 209.34,24.7
GND on T10 (solid shape): outline of 241 points within 0.66,83.2 10,93.2
GND on T10 (solid shape): outline of 241 points within 0.66,14.69 10,24.69
GND on T10 (solid shape): outline of 100 points within 0.64,0.63 209.37,95.56
GND on G11 (solid shape): outline of 104735 points within 0.64,0.63 209.37,95.56
SGND_VCORE on TOP (solid shape): 72.99,77.76 72.99,77 73,76.98 72.75,76.72 71.73,76.72 71.48,76.47 71.13,76.47 71.12,76.51 71.03,76.66 70.87,76.76 70.83,76.77 70.83,77 70.87,77.01 71.12,77.27 71.05,77.62 71.03,77.7 71.08,77.77 71.24,77.94 71.3,78.17 71.3,78.27 72.48,78.27
SGND_VCORE on BOTTOM (solid shape): outline of 967 points within 75.22,68.34 87.86,79.19
SGND_VP1P2_DDR4_VDD on BOTTOM (solid shape): outline of 1579 points within 188.82,20.97 200,36.68
SGND_VP1P05 on BOTTOM (solid shape): 67.64,55.52 71.82,55.52 72.01,55.33 72.01,52.99 72.01,52.99 72.01,52.76 72.01,52.76 72.01,51.1 71.98,51.1 71.98,50.66 71.88,50.56 69.7,50.56 69.7,50.61 69.49,50.61 69.49,50.71 68.94,50.71 68.94,50.61 68.73,50.61 68.73,50.56 68.56,50.56 68.56,50.61 68.35,50.61 68.35,50.71 67.79,50.71 67.79,50.61 67.64,50.61 67.44,50.81 67.43,50.83 67.39,50.97 67.31,51.09 67.31,54.57 67.11,54.77 67.11,54.78 67.03,54.9 66.93,54.98 66.9,55 66.9,55.95 66.94,55.99 67.17,55.99
VCC_CORE_VIN_SHAPE on TOP (solid shape): 98.23,89.87 97.31,89.87 97.31,90.25 97.87,90.25 97.87,90.37 97.31,90.37 97.31,90.75 97.87,90.75 97.87,90.87 97.31,90.87 97.31,91.25 97.87,91.25 97.87,91.37 97.31,91.37 97.31,91.75 97.87,91.75 97.87,91.87 97.31,91.87 97.31,92.25 97.87,92.25 97.87,92.37 97.31,92.37 97.31,92.75 98.23,92.75
VCC_CORE_VIN_SHAPE on TOP (solid shape): 98.23,79.83 97.31,79.83 97.31,80.22 97.87,80.22 97.87,80.33 97.31,80.33 97.31,80.72 97.87,80.72 97.87,80.83 97.31,80.83 97.31,81.22 97.87,81.22 97.87,81.34 97.31,81.34 97.31,81.72 97.87,81.72 97.87,81.84 97.31,81.84 97.31,82.22 97.87,82.22 97.87,82.34 97.31,82.34 97.31,82.72 98.23,82.72
VCC_CORE_VIN_SHAPE on TOP (solid shape): 93.72,92.5 96.69,92.5 96.69,92.73 97.97,92.73 97.97,89.93 97.19,89.93 96.66,90.38 96,90.14 95.97,90.11 95.9,90.14 95.79,90.16 95.72,90.16 94.31,90.16 94.24,90.16 94.14,90.14 94.04,90.11 93.97,90.08 93.9,90.05 93.83,90.01 93.74,89.94 93.69,89.89 93.64,89.84 93.6,89.78 93.55,89.7 93.51,89.63 93.48,89.55 93.45,89.45 93.44,89.38 93.36,89.3 93.36,88.7 93.26,88.33 93.36,87.96 93.36,87.95 93.36,87.6 93.21,87.13 93.37,86.67 93.27,86.03 93.71,85.54 93.72,85.54 93.96,85.3 94.73,85.3 94.82,85.3 94.91,85.32 94.99,85.3 95.03,85.22 95.37,84.57 96.1,84.5 96.97,84.5 97.04,84.47 97.07,84.4 97.09,84.19 97.18,83.99 97.18,83.98 97.18,83.82 97.97,83.04 97.97,79.9 97.3,79.9 96.92,80.28 96.92,80.53 96.54,80.91 94.96,80.91 94.74,81.04 94.5,81.08 94.08,81.08 94,81.17 94,82.44 93.62,82.82 84.46,82.82 82.31,84.97 82.31,90.69 82.69,91.07 92.87,91.07 93.17,91.37 93.17,92.39 93.51,92.73 93.72,92.73
VCCINT_CPLD on BOTTOM (solid shape): 49.68,43.19 49.68,42.65 49.83,42.5 51.23,42.5 51.35,42.37 51.35,40.75 51.31,40.67 51.23,40.65 50.77,40.3 51.23,39.94 51.31,39.92 51.35,39.84 51.35,39.12 51.33,39.1 51,39.1 50.67,39.43 49.85,39.43 49.52,39.43 49.46,39.5 49.41,39.56 49.34,39.61 48.84,40.11 48.84,43.37 48.94,43.47 49.4,43.47
(no net) on TOP: 29.08,80.92 30.61,82.44 31.37,82.44 31.5,82.31 31.5,75.33 31.24,75.07 28.19,75.07 27.05,76.22 27.05,80.53 27.43,80.92
(no net) on TOP: 45.19,66.33 43.99,66.33 43.39,66.94 43.39,68.72 41.66,70.45 41.66,72.28 42.04,72.66 44.02,72.66 44.26,72.43 44.28,72.43 44.66,72.04 44.66,69.79 44.91,69.53 44.91,68.92 45.24,68.6 45.24,66.39
(no net) on TOP: 68.7,8.3 68.78,8.37 68.93,8.37 69,8.3 69,4.11 69,4.11 69.7,4.11 69.7,4.11 69.7,9.54 69.37,9.87 68.15,9.87 67.99,9.72 67.99,4.11 68,4.1 68.7,4.11
(no net) on TOP: 72.7,8.3 72.78,8.37 72.93,8.37 73,8.3 73,4.11 73,4.11 73.7,4.11 73.7,4.11 73.7,8.72 74.44,9.46 74.44,9.66 74.23,9.87 72.15,9.87 71.43,9.87 71.24,9.69 71.24,9.43 71.99,8.68 71.99,4.11 72,4.1 72.7,4.11
(no net) on TOP: 80.7,8.3 80.78,8.37 80.93,8.37 81,8.3 81,4.11 81,4.11 81.7,4.11 81.7,4.11 81.7,8.39 81.78,8.47 81.78,9.57 81.66,9.69 79.4,9.69 79.29,9.59 79.29,9.41 79.99,8.7 79.99,4.11 80,4.1 80.7,4.11
(no net) on TOP: 87,61.89 96.47,61.89 98.82,59.54 98.82,54.12 99.84,53.1 100.98,53.1 101.36,52.72 101.36,52.21 101.24,52.09 87,52.09 84.71,54.37 84.71,59.6
(no net) on TOP: 83.82,44.85 84.07,45.1 89.79,45.1 90.93,46.24 96.11,46.24 96.75,45.61 96.75,44.14 96.26,43.65 92.86,43.65 89.36,40.15 86.36,40.15 85.6,39.39 84.07,39.39 83.82,39.64
(no net) on TOP: 141.99,8.91 141.99,4.72 144.91,4.72 144.91,8.91
(no net) on TOP: 152.53,3.19 152.53,7.51 149.86,7.51 149.86,3.19
(no net) on TOP: 102.26,40.26 102.76,40.76 103.15,40.76 103.53,40.38 103.53,39.21 103.9,38.84 103.9,37.46 103.78,37.33 102.61,37.33 102.26,37.68
(no net) on TOP: 105.41,15.26 104.39,14.24 97.28,14.24 95.12,16.4 95.12,23.77 94.36,24.53 94.36,29.99 94.49,30.12 97.03,30.12 97.66,29.48 105.03,29.48 105.41,29.1 ; 1 cut-out
(no net) on TOP: 167.31,82.14 165.37,82.14 165.31,82.08 164.8,82.08 163.15,80.43 163.15,79.66 162.51,79.03 160.23,79.03 159.16,80.1 144.98,80.1 142.75,77.87 142.75,73.28 149.32,66.71 155.03,66.71 155.67,66.07 155.67,62.77 155.65,62.77 155.18,62.3 152.83,62.3 152.6,62.07 152.6,61.23 152.71,61.12 163.53,61.12 163.85,60.8 167.31,60.8
(no net) on TOP: 98.19,92.73 98.19,90.06 98.06,89.93 94,89.93 93.36,89.3 93.36,86.38 94.12,85.61 95.39,85.61 96.13,84.88 96.97,84.88 97.18,84.67 97.18,83.82 98.19,82.82 98.19,79.9 97.3,79.9 96.92,80.28 96.92,80.53 96.54,80.91 94.25,80.91 94,81.17 94,82.44 93.62,82.82 84.34,82.82 82.31,84.85 82.31,90.69 82.69,91.07 92.87,91.07 93.17,91.37 93.17,92.39 93.51,92.73
(no net) on TOP: 10.35,49.14 10.35,50.59 9.84,51.1 9.84,53.14 9.6,53.38 2.1,53.38 1.73,53.76 1.73,56.17 2.09,56.53 25.4,56.53 25.78,56.15 25.78,52.59 25.53,52.34 20.07,52.34 19.28,53.13 11.24,53.13 10.77,52.66 10.77,49.15 10.36,49.15
