# Allegro board T77O994T01_015_20180530.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
(no net) on TOP: 45.55,89.06 46.82,87.79 46.82,85.89 36.91,85.89 36.66,86.14 36.66,88.51 36.86,88.71 39.85,88.71 40.18,89.04 40.18,91.23 40.36,91.41 44.81,91.41 45.55,90.67
(no net) on TOP: 47.4,66.36 48.57,66.36 49.26,67.06 49.26,67.07 49.38,67.07 49.63,67.33 50.14,67.33 50.39,67.58 50.39,72.41 50.37,72.43 50.37,73.31 50.24,73.44 47.98,73.44 47.73,73.19 47.73,72.96 47.75,72.94 47.75,67.6 47.35,67.2 47.35,66.41
(no net) on TOP: 16.99,4.1 16.99,8.3 16.92,8.37 16.79,8.37 16.71,8.3 16.7,8.3 16.7,4.11 16.7,4.11 16,4.11 16,4.11 16,8.3 15.93,8.37 15.78,8.37 15.71,8.3 15.71,4.11 15.7,4.1 15.21,4.1 15.21,12.94 14.42,13.72 11.32,13.72 10.51,14.54 10.51,35.08 11.56,36.13 23.86,36.13 24.86,35.12 24.86,25.38 24.51,25.04 19.13,25.04 18.76,24.67 18.76,19.03 17.37,17.64 17.37,12.53 17.7,12.19 17.7,4.1
(no net) on TOP: 152.19,41.6 152.19,38.2 152.59,37.8 152.59,25.69 152.33,25.43 148.81,25.43 148.44,25.06 147.98,25.06 143.51,20.59 143.51,15.64 144.25,14.89 164.94,14.89 167.2,17.15 167.2,43.5 167.1,43.6 159.08,43.6 158.7,43.22 151.84,43.22 151.59,42.96 151.59,42.2
(no net) on TOP: outline of 93 points within 128.44,25.06 146.4,44.99
(no net) on TOP: 9.72,48.81 10.86,48.81 10.99,48.94 10.99,49.06 11.26,49.33 11.26,49.82 11.24,49.83 11.24,52.24 11.62,52.62 13.91,52.62 14.42,52.11 14.42,48.3 14.16,48.05 9.84,48.05 9.72,48.18
(no net) on TOP: 83,39.17 83.05,39.12 83.7,39.12 84.07,38.75 84.07,35.45 85.95,33.58 85.95,31.96 86.12,31.78 86.3,31.78 86.48,31.61 86.48,29.04 86.35,28.91 85.11,28.91 84.68,29.34 84.68,31.76 84.02,32.42 82.14,32.42 81.4,31.68 81.4,30.11 81.32,30.03 79.5,30.03 79.27,30.26 79.27,38.67 79.25,38.69 79.25,39.01 79.42,39.17 ; 1 cut-out
(no net) on TOP: 26.38,32.42 29.69,32.42 29.81,32.29 29.81,30.77 29.69,30.64 27.65,30.64 27.15,31.15 26.26,31.15 26.13,31.28 26.13,32.16
(no net) on TOP: 205.44,71.89 206.25,71.08 206.25,69.07 205.9,68.72 204.19,68.72 203.74,68.26 203.74,65.75 203.46,65.47 198.08,65.47 196.34,67.2 196.34,70.76 197.48,71.89
(no net) on TOP: 6.09,44.42 6.26,44.58 6.26,45.53 6.59,45.86 6.59,47.18 6.38,47.39 2.03,47.39 1.84,47.2 1.84,44.59 2.01,44.42
(no net) on TOP: 36.44,76.87 36.82,77.25 38.69,77.25 39.07,76.87 39.07,71.66 38.81,71.41 37.04,71.41 36.44,72.01
(no net) on TOP: 56.12,70.13 56.52,69.74 61.72,69.74 62.1,70.12 62.1,71.39 61.85,71.64 57.03,71.64 56.88,71.79 54.7,71.79 54.7,70.39 54.96,70.13
(no net) on TOP: 35.39,74.71 35.39,84.74 35.13,85 32.34,85 31.96,84.62 31.96,74.71 32.34,74.33 35,74.33
(no net) on TOP: 193.22,89.06 194.24,89.06 194.44,89.27 194.44,91.75 193.98,92.22 189.37,92.22 189.12,91.96 189.12,91.45 189.42,91.15 190.06,91.15 190.63,90.59 190.63,89.65 190.78,89.49 191.44,89.49 191.95,90 192.87,90 193.04,89.82 193.04,89.24
(no net) on TOP: 176.24,14.38 173.96,16.67 173.96,17.05 174.02,17.11 173.76,17.11 173.76,43.78 178.96,43.78 178.96,43.77 179.55,44.36 179.55,48.17 180.43,49.06 198.21,49.06 198.34,48.93 198.34,46.25 188.77,36.67 188.77,15.61 187.55,14.38
(no net) on TOP: 62.99,8.74 62.99,4.11 63.7,4.11 63.7,9.64 63.4,9.95 62.38,9.95 62.27,9.84 62.27,9.46
(no net) on TOP: 151.25,88.03 151.25,89.94 151.15,90.04 144.58,90.04 144.22,89.69 144.22,86.25 144.51,85.96 148.86,85.96 149.07,86.17 149.07,87.63 149.48,88.03
(no net) on TOP: 16.34,46.64 15.81,47.17 15.81,52.11 16.17,52.47 19.05,52.47 19.81,51.71 25.53,51.71 26.04,51.2 26.04,47.39 25.86,47.39 25.86,47.36 21.54,47.36 21.54,48.17 21.42,48.17 21.42,46.71 21.35,46.64
(no net) on TOP: 51.69,64.53 54.99,64.53 55.12,64.66 55.12,66.69 54.99,66.82 51.69,66.82 51.56,66.69 51.56,64.66
(no net) on TOP: 9.46,50.74 9.46,52.11 9.48,52.12 9.48,52.61 9.45,52.64 6.14,52.64 5.89,52.39 2.16,52.39 1.97,52.2 1.97,48.19 2.03,48.12 6.27,48.12 6.58,48.43 6.58,50.41 6.91,50.74
(no net) on TOP: 144.45,64.61 144.45,64.61 144.76,64.3 144.76,63.58 144.75,63.57 144.75,63.2 144.27,62.72 143.98,62.72 143.8,62.9 143.8,63.11 143.57,63.34 143.3,63.34 143.15,63.49 142.57,63.49 142.54,63.52 142.54,64.49 142.67,64.61
(no net) on TOP: 55.7,8.3 55.78,8.37 55.93,8.37 56,8.3 56,4.11 56,4.11 56.7,4.11 56.7,4.11 56.7,8.69 57.45,9.43 57.45,9.71 57.29,9.87 54.46,9.87 54.32,9.74 54.32,9.43 54.99,8.76 54.99,4.11 55,4.1 55.7,4.11
(no net) on TOP: 118.03,54.66 117.72,54.96 114.91,54.96 114.63,54.68 114.63,54.27 114.75,54.15 115.97,54.15 116.05,54.07 116.05,53.18 116.07,53.16 116.35,53.16 116.53,52.98 116.76,52.98 116.91,53.13 117.19,53.13 117.32,53 117.55,53 117.7,53.16 117.7,53.41 117.57,53.54 117.57,53.92 117.95,54.3 118,54.3 118.03,54.33
(no net) on TOP: 31.99,4.11 32.7,4.11 32.7,9.98 32.64,10.05 32.12,10.05 31.99,9.92
(no net) on TOP: 51.71,8.3 51.78,8.37 51.93,8.37 52,8.3 52,4.11 52,4.11 52.7,4.11 52.7,4.11 52.7,9.54 52.41,9.83 50.51,9.83 50.36,9.69 50.36,9.43 50.99,8.8 50.99,4.11 51,4.1 51.71,4.11
(no net) on TOP: 76.7,8.3 76.78,8.37 76.93,8.37 77,8.3 77,4.11 77,4.11 77.7,4.11 77.7,4.11 77.7,8.71 78.43,9.43 78.43,9.66 78.26,9.83 75.4,9.83 75.28,9.71 75.28,9.43 75.99,8.72 75.99,4.11 76,4.1 76.7,4.11
(no net) on TOP: 17.99,4.11 18.7,4.11 18.7,10.46 18.53,10.64 18.25,10.64 17.99,10.38
(no net) on TOP: 44.99,4.11 45.7,4.11 45.7,10.2 45.4,10.51 44.48,10.51 44.37,10.4 44.37,9.53 44.99,8.91
(no net) on TOP: 143.29,84.75 143.03,84.49 143.03,83.51 143.03,83.51 143.03,83.38 143.84,82.57 143.84,82.21 144.48,81.58 148.67,81.58 149.15,82.06 149.15,84.19 148.59,84.75
(no net) on TOP: 21.81,42.71 21.56,42.96 21.56,45.89 22.07,46.39 25.88,46.39 26.26,46.01 26.26,42.96 26.01,42.71
(no net) on TOP: 36.94,92.96 37.08,93.11 39.45,93.11 39.6,92.95 39.6,89.6 39.5,89.5 37.12,89.5 36.94,89.68
(no net) on TOP: 98.57,41.67 101.51,41.67 101.86,42.02 101.86,44.54 101.67,44.72 98.7,44.72 98.57,44.59
(no net) on TOP: 72.48,70.52 74.39,70.52 75.91,68.99 76.55,68.99 76.8,68.74 76.8,67.6 76.93,67.47 78.58,67.47 78.58,66.45 71.47,66.45 71.47,67.47 73.12,67.47 73.25,67.6 73.25,68.23 72.36,69.12 72.36,70.39
(no net) on TOP: 69.99,83.45 69.99,93.61 69.36,94.25 63.01,94.25 62.37,93.61 62.37,83.45 63.01,82.82 69.36,82.82
(no net) on TOP: 33.99,4.11 34.7,4.11 34.7,10.4 34.67,10.43 34.04,10.43 33.99,10.38
(no net) on TOP: 102.25,82.82 109.36,82.82 109.49,82.69 109.49,78.63 109.36,78.5 107.33,78.5 105.58,80.25 102.12,80.25 102.12,82.69
(no net) on TOP: 34.88,87.28 34.88,90.84 34.34,91.37 31.22,91.37 31.19,91.35 30.43,91.35 30.18,91.09 30.18,90.05 29.36,89.23 29.36,87.14 29.54,86.96 34.55,86.96
(no net) on TOP: 95.99,4.11 96.7,4.11 96.7,10.46 96.53,10.64 96.25,10.64 95.99,10.38
(no net) on TOP: 185.94,91.2 186.83,91.2 186.96,91.07 186.96,88.79 186.83,88.66 184.29,88.66 184.26,88.69 184.24,88.68 183.99,88.68 183.99,89.7 184.5,90.2 185.51,90.2 185.82,90.51 185.82,91.07
(no net) on TOP: 57.02,72.12 56.97,72.17 52.28,72.17 52.15,72.3 52.15,73.57 52.4,73.82 56.39,73.82 57.13,74.57 57.91,74.57 58.29,74.95 61.72,74.95 62.1,74.57 62.1,72.28 61.98,72.15 57.02,72.15
(no net) on TOP: 173.78,44.42 173.78,48.8 173.78,48.8 173.78,60.15 173.78,60.17 173.79,60.17 173.81,60.18 178.99,60.18 179.95,59.22 198.86,59.22 200.12,57.96 200.12,50.45 199.48,49.82 180.56,49.82 178.99,48.24 178.99,44.42
(no net) on TOP: 64.99,4.11 65.7,4.11 65.7,9.77 65.61,9.87 65.1,9.87 64.99,9.77
(no net) on TOP: 22.75,92.46 22.75,90.33 22.83,90.25 24.85,90.25 25.09,90.49 25.09,92.3 24.4,92.99 23.28,92.99
(no net) on TOP: 102.25,92.73 109.24,92.73 109.49,92.47 109.49,87.77 109.36,87.65 107.08,87.65 106.57,88.15 106.57,89.42 105.71,90.28 102.12,90.28 102.12,92.6
(no net) on TOP: 54.05,87.89 53.14,88.81 53.14,92.97 53.55,93.38 57.36,93.38 57.48,93.25 57.48,80.23 57.15,79.9 54.1,79.9 54.05,79.95
(no net) on TOP: 47.99,4.11 48.7,4.11 48.7,10.46 48.53,10.64 48.25,10.64 47.99,10.38
(no net) on TOP: 191.36,23.15 191.36,21.37 191.61,21.12 193.26,21.12 193.52,21.37 193.52,23.15 193.26,23.4 191.61,23.4
(no net) on TOP: 36.08,77.98 35.84,78.22 35.84,79.29 36.09,79.54 40.67,79.54 40.79,79.41 40.79,77.98
(no net) on TOP: 188.36,91.71 186.07,91.71 185.94,91.58 185.94,91.46 186.96,91.46 187.21,91.2 187.21,91.19 187.32,91.09 187.32,88.51 186.96,88.15 186.33,88.15 186.33,87.01 186.45,86.88 191.23,86.88 192.84,88.49 192.84,89.11 192.74,89.21 191.89,89.21 191.55,88.88 190.15,88.88 190,89.03 190,90.63 189.89,90.73 189.34,90.73
(no net) on TOP: 122.65,50.08 122.65,45.99 122.64,45.98 122.64,44.19 122.96,43.88 122.96,39.87 122.2,39.11 120.16,39.11 119.55,39.72 119.55,50.03 119.86,50.34 122.4,50.34
(no net) on TOP: 80.14,39.51 79.38,40.28 78.11,40.28 73.41,44.97 73.41,47.64 73.66,47.9 77.24,47.9 77.32,47.97 80.62,47.97 80.62,45.98 80.59,45.95 79.29,45.95 79.16,45.83 79.16,45.41 79.4,45.18 80.24,45.18 80.24,45.17 80.39,45.03 80.39,44.09 80.77,43.7 82.3,43.7 82.42,43.58 82.42,39.89 82.04,39.51
(no net) on TOP: 101.87,77.1 101.93,77.05 103.18,77.05 104.01,76.22 109.09,76.22 109.6,75.71 109.6,73.52 99.87,63.79 98.89,63.79 98.76,63.66 98.76,61.76 99.01,61.5 100.28,61.5 100.41,61.38 100.41,60.11 100.28,59.98 98.89,59.98 95.84,63.03 87.58,63.03 87.07,63.54 87.07,66.46 88.85,68.23 93.95,68.23 96.36,70.65 96.36,72.96 95.52,73.8 91.01,73.8 86.12,78.69 86.12,81.3 86.38,81.55 93.36,81.55 93.49,81.42 93.49,81.41 93.92,80.98 93.92,80.17 93.49,79.74 93.49,75.2 94,74.69 96.28,74.69 98.57,76.98 98.57,83.14 97.56,84.15 97.56,84.54 97.72,84.69 98.1,84.69 98.57,85.16 98.57,92.85 98.44,92.98 93.87,92.98 93.86,92.97 93.42,92.97 92.66,92.22 81.94,92.22 81.77,92.39 81.77,95.29 82,95.52 101.24,95.52 101.87,94.88
(no net) on TOP: 37.71,8.3 37.78,8.37 37.93,8.37 38,8.3 38,4.11 38,4.11 38.7,4.11 38.7,4.11 38.7,9.54 38.37,9.87 37.15,9.87 36.99,9.72 36.99,4.11 37,4.1 37.71,4.11
(no net) on TOP: 157.6,83.19 157.81,82.97 159.08,82.97 160.12,84 166.74,84 167.11,84.37 171.47,84.37 172.09,84.98 172.09,93.26 171.78,93.56 169.65,93.56 169.24,93.16 169.24,90.74 168.7,90.21 158.13,90.21 157.6,89.67 ; 1 cut-out
(no net) on TOP: 23.11,86.25 24.13,87.27 27.26,87.27 27.26,87.79 27.69,88.22 28.88,88.22 28.98,88.12 28.98,86.57 28.91,86.5 27.49,86.5 27.41,86.42 27.41,85.38 27.29,85.25 23.65,85.25 21.73,83.33 20.07,83.33 19.81,83.58 19.81,86 20.07,86.25
(no net) on TOP: outline of 82 points within 114.32,44.03 130.91,94.5
(no net) on TOP: 128.92,94 129.43,94.5 138.3,94.5 138.56,94.25 138.56,74.31 137.92,73.68 129.41,73.68 128.92,74.17
(no net) on TOP: 71.73,76.72 72.75,76.72 73,76.98 72.99,77 72.99,77.76 72.48,78.27 71.09,78.27 70.83,78.01 70.83,76.74 70.84,76.47 71.48,76.47
(no net) on TOP: 20.99,4.11 21.7,4.11 21.7,10.46 21.53,10.64 21.25,10.64 20.99,10.38
(no net) on TOP: 28.99,4.11 29.7,4.11 29.7,10.46 29.53,10.64 28.94,10.64 28.72,10.42 28.72,9.41 28.99,9.13
(no net) on TOP: 102.12,79.64 104.88,79.64 105.34,79.19 105.34,78.32 105.26,78.25 103.14,78.25 103.01,78.37 102.12,78.37 102.12,78.63 103.14,78.63 103.27,78.76 103.27,79.26 103.14,79.39 102.12,79.39
(no net) on TOP: 41.71,8.3 41.78,8.37 41.93,8.37 42,8.3 42,4.11 42,4.11 42.7,4.11 42.7,4.11 42.7,9.03 42.55,9.19 41.1,9.19 40.99,9.08 40.99,4.11 41,4.1 41.71,4.11
(no net) on TOP: 48.76,86.05 48.76,92.28 49.36,92.87 51.13,92.87 51.26,92.75 51.26,88.43 51.13,88.3 49.79,88.3 49.39,87.91 49.39,86.05
(no net) on TOP: outline of 167 points within 127.16,42.88 142.97,64.56
(no net) on TOP: 187.77,81.72 187.42,82.08 187.42,85.89 187.44,85.89 188.05,86.5 191.61,86.5 195.7,83.9 195.04,88.7 195.04,92.19 194.38,92.85 189.25,92.85 188.36,91.96 185.94,91.96 185.82,92.09 185.82,92.26 186.8,92.26 186.85,92.31 186.85,94.24 187.48,94.88 187.48,94.88 198.86,94.88 199.85,93.89 199.85,82.46 199.12,81.72
(no net) on TOP: 23.75,87.62 23.39,87.27 19.66,87.27 19.34,87.58 19.34,92.12 19.81,92.58 21.19,92.58 21.42,92.35 21.42,89.86 21.59,89.69 22.89,89.69 22.9,89.69 27.14,89.69 27.56,89.27 27.56,88.56 26.97,87.98 26.97,87.72 26.85,87.6 24.43,87.6 24.41,87.62
(no net) on TOP: 178.4,90.33 178.4,82.73 178.24,82.57 173.75,82.57 173.63,82.69 173.63,85.63 173.24,86.02 173.28,86.07 173.28,93.41 176.4,93.41 178.26,91.55 178.26,90.48
(no net) on TOP: 152.82,60.32 152.73,60.23 152.73,54.52 151.84,53.63 151.48,53.63 151.32,53.47 151.32,50.81 150.74,50.23 150.74,48.81 150.8,48.75 151.92,48.75 152.29,48.39 152.29,46.84 151.59,46.14 151.59,44.36 152.23,43.72 154.26,43.72 154.51,43.98 155.4,43.98 155.65,43.72 157.56,43.72 157.81,43.98 167.22,43.98 167.22,53.13 167.33,53.23 167.86,53.23 168.42,52.67 168.65,52.67 168.72,52.75 168.72,54.98 168.62,55.08 168.37,55.08 168.04,54.75 167.38,54.75 167.2,54.93 167.2,59.43 167.05,59.58 162.74,59.58 162.56,59.75 162.56,60.09 162.33,60.32
(no net) on TOP: 98.57,39.88 98.72,40.02 101.36,40.02 101.62,39.76 101.62,37.59 99.1,37.59 98.57,38.11
(no net) on TOP: 151.5,86.1 152.64,86.1 152.78,86.24 152.78,89.29 153.4,89.91 155.69,89.91 156.2,89.41 156.2,85.6 155.94,85.34 151.63,85.34 151.5,85.47
(no net) on TOP: 101.15,51.7 101.15,45.92 100.71,45.49 97.76,45.49 96.5,46.75 90.93,46.75 89.89,45.71 88.27,45.71 86.34,47.63 86.34,47.64 85.85,48.13 85.85,48.15 77.47,48.15 77.34,48.28 73.79,48.28 73.41,48.66 73.41,50.69 73.79,51.07 77.22,51.07 77.85,51.7
(no net) on TOP: 115.21,51.28 115.21,52.12 115.34,52.24 117.12,52.24 118.21,51.15 118.21,50.62 118.08,50.49 117.05,50.49 116.86,50.68 116.57,50.68 116.4,50.85 116.05,50.85 115.95,50.74 115.74,50.74 115.64,50.85 115.26,50.85 115.13,50.72 115.01,50.72 114.96,50.77 114.96,51.25 114.98,51.28
(no net) on TOP: 45.44,68.87 45.3,69.01 45.3,73.2 45.67,73.57 47.32,73.57 47.45,73.44 47.45,68.34 46.97,67.86 46.97,64.66 46.71,64.4 45.7,64.4 45.44,64.66
(no net) on TOP: 92.7,8.3 92.78,8.37 92.93,8.37 93,8.3 93,4.11 93,4.11 93.7,4.11 93.7,4.11 93.7,9.54 93.37,9.87 91.64,9.87 91.48,9.71 91.48,9.28 91.99,8.77 91.99,4.11 92,4.1 92.7,4.11
(no net) on TOP: 152.21,86.36 152.49,86.36 152.55,86.42 152.55,89.95 152.61,90 152.61,90.33 153.11,90.84 168.66,90.84 168.72,90.91 168.72,93.28 168.15,93.85 145.37,93.85 145.37,93.76 144.48,92.87 144.48,90.84 144.64,90.68 150.61,90.68 151.63,89.66 151.63,88.39 152.13,87.88 152.13,86.43
(no net) on TOP: 39.59,72.17 39.61,77.28 40,77.66 41.65,77.66 41.77,77.54 41.77,77.03 41.65,76.9 41.39,76.9 41.4,71.83 41.4,71.37 41.39,71.37 41.39,70.81 41.1,70.52 39.85,70.52 39.59,70.77
(no net) on TOP: 54.75,74.05 54.7,74.1 54.7,75.29 57.66,78.25 61.09,78.25 61.21,78.12 61.21,75.58 60.96,75.33 58.17,75.33 57.91,75.07 57.15,75.07 56.12,74.05
(no net) on TOP: 179.16,60.23 178.85,60.55 173.91,60.55 173.91,82.14 177.26,82.14 179.29,84.17 179.29,86.01 179.8,86.52 184.88,86.52 185.01,86.39 185.01,82.71 186.28,81.44 193.75,81.44 195.66,79.54 195.66,60.61 195.15,60.1 189.83,60.1 189.58,60.36 185.9,60.36 185.39,59.85 181.45,59.85 181.07,60.23 ; 1 cut-out
(no net) on TOP: 102.23,88.41 102.23,88.66 103.39,88.66 103.39,89.3 103.27,89.42 102.23,89.42 102.23,89.68 105.05,89.68 105.3,89.42 105.31,89.42 105.31,88.5 105.22,88.41
(no net) on TOP: 59.7,8.3 59.78,8.37 59.93,8.37 60,8.3 60,4.11 60,4.11 60.7,4.11 60.7,4.11 60.7,8.72 61.44,9.46 61.44,9.69 61.26,9.87 58.44,9.87 58.26,9.69 58.26,9.46 58.99,8.72 58.99,4.11 59,4.1 59.7,4.11
(no net) on TOP: 142.03,46.96 142.03,45.18 141.91,45.05 141.78,45.05 141.52,45.31 141.52,47.34 141.27,47.59 140.89,47.59 140.89,47.98 141.02,48.1 141.27,48.1 141.52,48.36 141.52,48.99 141.4,49.12 141.14,49.12 140.89,49.37 140.89,49.63 141.02,49.75 141.27,49.75 141.4,49.88 141.4,50.52 140.89,51.02 140.89,51.4 141.02,51.53 141.27,51.53 141.4,51.66 141.4,52.29 141.02,52.67 140.89,52.67 140.89,53.06 141.02,53.18 141.4,53.18 141.52,53.31 141.52,53.74 141.07,54.2 140.28,54.2 139.82,54.66 139.82,55.01 139.44,55.39 139.44,55.65 139.54,55.75 139.92,55.75 140.76,54.91 141.19,54.91 141.52,55.24 141.52,56.03 141.78,56.28 141.98,56.28 142.03,56.23 142.03,51.66 142.29,51.4 142.29,51.15 142.03,50.9 142.03,48.36 142.41,47.98 142.41,47.34
(no net) on TOP: 96.95,30.88 97.38,30.45 101.7,30.45 103.01,31.77 103.01,35.19 102.12,36.08 98.19,36.08 96.41,34.31 91.71,34.31 91.46,34.05 91.46,32.15 92.34,32.15 93.05,31.44 93.05,31 93.17,30.88
(no net) on TOP: 59.56,28.72 62.61,28.72 62.87,28.97 62.87,32.15 62.61,32.4 59.56,32.4 59.31,32.15 59.31,28.97
(no net) on TOP: 89.3,31.11 89.3,33.52 89.18,33.65 88.29,33.65 88.03,33.9 86.25,33.9 84.71,35.45 84.71,37.99 86.36,39.64 89.53,39.64 92.96,43.07 94.39,43.07 94.7,42.76 94.7,38.08 94.45,37.84 92.04,37.84 91.23,37.03 91.23,31.11
(no net) on TOP: 51.26,82.46 50.75,82.97 45.6,82.97 44.75,82.11 37.08,82.11 36.83,82.37 36.83,85.13 37.08,85.38 49.99,85.38 50.12,85.51 50.12,87.54 50.37,87.79 53.29,87.79 53.42,87.67 53.42,79.98 53.34,79.9 51.56,79.9 51.26,80.2
(no net) on TOP: 88.7,8.3 88.78,8.37 88.93,8.37 89,8.3 89,4.11 89,4.11 89.7,4.11 89.7,4.11 89.7,8.42 90.21,8.93 90.21,9.69 90.03,9.87 88.15,9.87 87.99,9.72 87.99,4.11 88,4.1 88.7,4.11
(no net) on TOP: 84.7,8.3 84.78,8.37 84.93,8.37 85,8.3 85,4.11 85,4.11 85.7,4.11 85.7,4.11 85.7,8.48 86.63,9.41 86.63,10.52 86.43,10.73 83.23,10.73 82.91,10.41 82.91,9.27 83.43,8.75 83.69,8.75 83.99,8.44 83.99,4.11 84,4.1 84.7,4.11
(no net) on TOP, BOTTOM: 79.52,83.84 79.52,93.61 78.95,94.19 71.71,94.19 71.39,93.87 71.39,91.84 71.64,91.58 73.3,91.58 73.68,91.2 73.68,83.71 74.18,83.2 78.88,83.2
(no net) on BOTTOM: 62.37,86.74 62.37,93.61 63.01,94.25 69.36,94.25 69.99,93.61 69.99,86.65 69.34,86 63.12,86
(no net) on BOTTOM: 134.08,41.18 132.48,42.78 132.48,45.84 132.51,45.87 133.69,45.87 133.71,45.89 133.71,48.64 132.02,48.64 132.02,51.02 132.05,51.05 133.69,51.05 133.71,51.07 133.71,53.58 133.73,53.59 133.73,56.33 135.86,58.45 142.22,58.45 144.38,60.61 158.09,60.61 160.13,58.58 166.66,58.58 167.99,59.91 177.07,59.91 177.26,59.72 177.26,44.61 177.01,44.36 168.5,44.36 168.31,44.55 157.51,44.55 157.51,44.54 145.15,44.54 141.79,41.18
(no net) on BOTTOM: 188.51,44.04 185.47,44.04 185.47,38.36 187.09,38.36 187.17,38.29 187.17,36.69 187.06,36.58 185.47,36.58 185.47,16.99 188.51,16.99 188.51,36.36 189.83,36.36 190.47,36.99 197.96,36.99 198.47,37.5 198.47,46.78 197.74,47.51 191.09,47.51 189.2,45.63 189.2,44.72 ; 1 cut-out
(no net) on BOTTOM: 64.99,4.11 65.7,4.11 65.7,10.46 65.53,10.64 65.25,10.64 64.99,10.38
(no net) on BOTTOM: 85.07,75.07 86.46,76.47 87.73,76.47 87.86,76.34 87.86,74.5 86.59,73.23 86.59,69.48 85.45,68.34 80.62,68.34 79.86,69.1 76.43,69.1 75.22,70.31 75.22,76.02 75.16,76.09 75.16,76.34 78,79.19 80.62,79.19 81.13,78.68 81.13,76.22 82.27,75.07 ; 1 cut-out
(no net) on BOTTOM: 77.99,4.11 78.7,4.11 78.7,8.3 78.78,8.37 78.92,8.37 78.99,8.3 78.99,4.11 79.69,4.11 79.69,9.97 79.65,10.02 78.09,10.02 77.99,9.92
(no net) on BOTTOM: 163.67,85.48 163.67,86.27 164.56,87.16 168.04,87.16 168.38,87.49 168.38,89.98 168.73,90.33 173.69,90.33 173.96,90.06 173.96,89.19 174.45,88.7 174.45,85.39 175.23,84.62 175.23,82.9 175.86,82.27 179.12,82.27 179.12,61.42 178.66,60.97 178.66,60.55 176.36,60.55 175.76,61.15 160.05,61.15 157.94,63.25 157.94,79.75 ; 1 cut-out
(no net) on BOTTOM: 38.99,4.11 39.7,4.11 39.7,8.3 39.78,8.37 39.92,8.37 39.99,8.3 39.99,4.11 40.69,4.11 40.69,10.02 40.59,10.13 39.1,10.13 38.99,10.02
(no net) on BOTTOM: 72.48,70.52 74.39,70.52 76.17,68.74 76.17,68.36 76.04,68.23 72.61,68.23 72.36,68.49 72.36,70.39
(no net) on BOTTOM: 122.81,78.38 122.56,78.63 122.56,78.88 122.56,78.89 122.56,80.16 122.56,80.17 122.56,81.04 122.68,81.17 131.19,81.17 131.32,81.3 131.32,85.36 131.19,85.49 122.68,85.49 122.56,85.61 122.56,88.15 122.68,88.28 131.32,88.28 131.44,88.41 131.44,92.22 131.06,92.6 117.86,92.6 117.6,92.85 117.6,93.87 118.24,94.5 134.26,94.5 138.3,94.5 138.56,94.25 138.56,76.22 137.16,74.82 132.33,74.82 132.08,75.07 132.08,77.61 131.32,78.38
(no net) on BOTTOM: 73.41,45.48 73.41,47.26 73.53,47.39 78.61,47.39 78.87,47.13 78.87,45.48 78.74,45.36 73.53,45.36
(no net) on BOTTOM: 197.82,79.66 196.8,80.68 196.8,83.79 195.22,85.38 195.22,91.33 194.05,92.49 189.61,92.49 188.99,93.11 186.45,93.11 183.55,90.2 180.18,90.2 180.17,90.2 179.4,90.97 176.87,90.97 175.48,92.36 144.11,92.36 143.32,93.15 142.43,93.15 141.95,93.63 141.95,94.39 142.21,94.65 198.21,94.65 198.85,94.01 198.85,85 200.5,83.35 200.5,80.17 199.99,79.66 ; 1 cut-out
(no net) on BOTTOM: 85.99,4.11 86.7,4.11 86.7,8.3 86.78,8.37 86.92,8.37 86.99,8.3 86.99,4.11 87.69,4.11 87.69,10.45 87.51,10.64 86.25,10.64 85.99,10.38
(no net) on BOTTOM: 56.15,69.5 57.88,69.5 58.51,70.14 58.51,82.08 58.26,82.33 56.36,82.33 54.96,80.93 39.96,80.93 37.93,78.9 37.93,77.89 37.54,77.51 35.77,77.51 35.39,77.89 35.39,79.41 38.82,82.85 54.05,82.85 54.8,83.59 55.97,83.59 55.97,83.6 59.02,83.6 61.82,80.81 61.82,67.61 58.63,64.42 51.04,64.42 49.15,66.31 49.15,67.2 54.61,67.2 54.86,67.45 54.86,68.22
(no net) on BOTTOM: 33.99,4.11 34.7,4.11 34.7,9.8 34.58,9.92 34.12,9.92 33.99,9.8
(no net) on BOTTOM: 104.16,92.43 103.36,93.23 98.43,93.23 97.16,91.96 97.16,75.45 97.56,75.04 100.66,75.04 104.16,78.53
(no net) on BOTTOM: 19,93.25 19,84.36 27.26,76.11 31.07,76.11 34.88,79.92 34.88,92.62 33.61,93.89 19.64,93.89
(no net) on BOTTOM: 81.99,8.44 81.99,4.11 82.7,4.11 82.7,8.3 82.78,8.37 82.92,8.37 82.99,8.3 82.99,4.11 83.69,4.11 83.69,8.78 83.82,8.91 83.82,10.68 83.67,10.83 82.44,10.83 81.99,10.38 81.99,10.37 81.3,9.68 81.3,9.14
(no net) on BOTTOM: 49.99,4.11 50.7,4.11 50.7,9.26 51.13,9.69 51.13,10.42 50.92,10.64 50.25,10.64 49.99,10.38
(no net) on BOTTOM: 133.09,53.16 133.09,53.64 133.04,53.69 131.9,53.69 131.88,53.7 130.27,53.7 130.22,53.65 130.22,46.1 130.23,46.08 130.22,46.07 130.22,45.93 130.32,45.83 130.32,45.02 130.36,44.98 130.73,44.98 130.93,44.77 130.93,43.95 131.01,43.87 132.17,43.87 132.35,44.05 132.35,44.61 131.95,45.02 131.95,46.11 132.05,46.21 133.14,46.21 133.35,46.41 133.35,47.85 133.32,47.87 132.02,47.87 131.92,47.98 131.92,51.79 131.97,51.84 133.4,51.84 133.4,52.88 133.12,53.16
(no net) on BOTTOM: 161.38,14.13 157.57,17.94 157.57,42.71 158.92,44.05 172.76,44.05 172.97,43.85 176.89,43.85 177.63,43.11 178.99,43.11 178.99,17.08 178.56,16.65 178.56,12.34 176.91,10.68 173.1,10.68 172.09,11.7 172.09,13.88 171.83,14.13 ; 1 cut-out
(no net) on BOTTOM: 66.99,4.11 67.7,4.11 67.7,8.49 68.42,9.21 68.42,9.66 68.19,9.89 67.12,9.89 66.99,9.76
(no net) on BOTTOM: 35.99,4.11 36.7,4.11 36.7,10.46 36.53,10.64 36.25,10.64 35.99,10.38
(no net) on BOTTOM: 9.62,61.37 10.89,61.37 11.14,61.63 11.14,69.38 11.27,69.5 12.03,69.5 12.29,69.76 12.29,70.14 12.16,70.26 9.37,70.26 9.11,70.01 9.11,61.88
(no net) on BOTTOM: 17.99,4.11 18.7,4.11 18.7,9.62 18.48,9.84 18.15,9.84 17.99,9.69
(no net) on BOTTOM: 56.99,4.11 57.7,4.11 57.7,8.3 57.78,8.37 57.92,8.37 57.99,8.3 57.99,4.11 58.69,4.11 58.69,9.82 58.54,9.97 57.15,9.97 56.99,9.82
(no net) on BOTTOM: 94.22,45.48 88.38,45.48 88.37,45.49 88.03,45.49 86.31,47.2 86.31,47.26 85.47,48.1 85.47,48.17 73.89,48.17 73.41,48.66 73.41,50.69 73.79,51.07 77.22,51.07 77.83,51.68 83.04,51.68 84.45,53.1 84.45,63.77 83.44,64.79 82.44,64.79 82.44,66.01 82.5,66.08 82.5,66.2 83.39,67.09 86.82,67.09 87.07,66.84 87.07,65.31 88.24,64.15 88.24,51.83 88.37,51.7 96.5,51.7 96.5,46.5 96.37,46.37 95.11,46.37
(no net) on BOTTOM: 205.58,64.81 205.58,62.79 205.18,62.39 196.96,62.39 196.47,62.88 196.47,67.58 196.6,67.71 199.39,67.71 199.39,65.93 200.13,65.19 205.2,65.19
(no net) on BOTTOM: 15.99,8.31 16,8.3 16,4.11 16,4.11 16.7,4.11 16.7,4.11 16.7,8.3 16.71,8.3 16.79,8.37 16.92,8.37 16.99,8.3 16.99,4.1 17.7,4.1 17.7,11.15 17.7,11.16 17.7,13.83 17.75,13.88 17.75,17.43 18.7,18.38 21.81,18.38 22.23,18.8 22.23,20.88 24.86,23.51 24.86,35.24 23.74,36.36 13.43,36.36 11.65,34.58 11.65,30.64 11.27,30.26 11.27,14.87 12.41,13.72 15.51,13.72 15.99,13.24
(no net) on BOTTOM: 97.05,39.62 95.02,39.62 93.7,38.31 93.7,31.5 93.8,31.4 93.96,31.24 96.19,31.24 97.18,30.25 97.18,28.18 96.76,27.76 95.67,27.76 94.06,29.37 92.15,29.37 91.79,29.74 91.79,34.25 91.46,34.58 91.46,35.56 90.95,36.06 89.94,36.06 89.81,36.19 89.81,41.9 89.82,41.91 89.82,42.19 90.05,42.43 96.78,42.43 97.3,41.9 97.3,39.87
(no net) on BOTTOM: 117.07,42.31 116.35,43.02 116.35,43.05 114.17,43.05 114.05,43.16 114.05,45.6 112.72,46.93 112.72,49.96 112.92,50.16 112.92,50.18 116.81,50.18 116.81,48.86 115.77,48.86 115.57,48.66 115.57,48.13 115.97,47.72 115.97,45.97 116.38,45.56 117.8,45.56 117.8,43.32 117.53,43.04 117.53,42.36 117.47,42.31
(no net) on BOTTOM: 49.15,68.72 49.15,67.83 49.28,67.71 54.23,67.71 54.61,68.09 54.61,70.76 54.23,71.14 51.56,71.14
(no net) on BOTTOM: 14.73,53.36 14.73,56.02 15.24,56.53 25.4,56.53 25.78,56.15 25.78,52.98 25.65,52.85 19.05,52.85 18.8,53.1 14.99,53.1
(no net) on BOTTOM: 106.82,35.42 106.82,33.16 107.61,32.38 112.16,32.38 114.7,34.92 114.7,37.71 114.45,37.97 109.37,37.97
(no net) on BOTTOM: 187.8,82.71 187.8,81.44 189.58,81.44 189.58,83.98 187.42,83.98 187.04,83.6 186.02,83.6 186.02,83.35 187.17,83.35
(no net) on BOTTOM: 180.43,81.44 179.8,82.08 179.8,84.62 179.16,85.25 179.16,88.57 180.55,89.95 184.63,89.95 185.51,90.84 188.87,90.84 189.12,91.09 189.12,91.96 189.25,92.09 194.11,92.09 194.44,91.75 194.44,88.92 193.93,88.41 186.77,88.41 186.4,88.04 184.5,86.14 184.5,82.58 184.88,82.2 184.88,82.08 184.24,81.44 ; 1 cut-out
(no net) on BOTTOM: 122.09,36.79 122.39,36.79 122.85,36.34 122.85,36.06 122.72,35.93 121.66,35.93 121.61,35.98 121.61,36.31
(no net) on BOTTOM: 73.99,4.11 74.7,4.11 74.7,8.3 74.78,8.37 74.92,8.37 74.99,8.3 74.99,4.11 75.69,4.11 75.69,9.82 75.56,9.95 74.17,9.95 73.99,9.77
(no net) on BOTTOM: 52.99,4.11 53.7,4.11 53.7,8.3 53.78,8.37 53.92,8.37 53.99,8.3 53.99,4.11 54.69,4.11 54.69,9.82 54.54,9.97 53.14,9.97 52.99,9.83
(no net) on BOTTOM: 195.45,59.47 194.52,59.47 194.51,59.47 188.44,59.47 187.04,60.87 185.47,60.87 185.47,78.65 189.97,78.65 189.97,68.7 190.07,68.6 192.43,68.6 193.14,69.31 193.14,71.14 193.29,71.28 202.31,71.28 202.44,71.16 202.44,68.22 202.33,68.11 197.82,68.11 197.67,67.96 196.22,67.96 195.71,67.45 195.71,59.73
(no net) on BOTTOM: 167.75,89.95 168.02,89.68 168.02,87.64 167.92,87.54 164.16,87.54 162.64,86.01 160.1,86.01 158.19,87.92 156.8,87.92 156.42,88.3 156.42,89.7 156.67,89.95
(no net) on BOTTOM: outline of 121 points within 83.31,31.02 123.34,76.74 ; 5 cut-outs
(no net) on BOTTOM: 167.36,92.06 167.46,91.96 167.46,90.72 167.36,90.62 160.68,90.62 160.36,90.94 160.36,91.8 160.63,92.06
(no net) on BOTTOM: 187.14,44.42 187.14,45.22 187.04,45.32 185.47,45.32 185.47,59.09 198.71,59.09 200.23,57.57 200.23,57.57 200.36,57.44 205.31,57.44 205.58,57.17 205.58,54.31 199.5,48.23 189.77,48.23 188.66,47.12 188.66,45.15 187.93,44.42
(no net) on BOTTOM: 123.64,44.01 123.36,44.29 123.36,45.08 123.27,45.17 123.27,45.63 123.29,45.64 123.29,50.97 124.07,51.76 123.72,52.12 123.72,54.71 123.95,54.93 124.45,54.93 124.95,54.62 125.21,55.16 125.65,55.6 125.65,57.75 126.03,58.14 126.03,60.42 125.9,60.55 125.9,62.45 126.51,63.06 126.51,65.64 125.7,66.45 125.7,68.01 119.4,74.31 118.38,74.31 114.57,78.12 114.57,91.73 114.68,91.84 130.81,91.84 130.94,91.71 130.94,89.04 122.43,89.04 122.17,88.79 122.17,84.98 122.43,84.73 130.81,84.73 130.94,84.6 130.94,82.06 130.81,81.93 122.56,81.93 122.17,81.55 122.17,77.87 122.43,77.61 130.94,77.61 131.19,77.36 131.19,74.95 129.15,72.91 129.15,66.86 132.89,63.12 132.89,55.47 132.89,55.47 132.38,54.96 132.38,54.71 131.66,53.98 129.89,53.98 129.71,53.81 129.71,46.02 130.02,45.72 130.02,45.24 129.84,45.07 128,45.07 126.94,44.01 ; 2 cut-outs
(no net) on BOTTOM: 46.99,4.11 47.7,4.11 47.7,10.46 47.53,10.64 47.25,10.64 46.99,10.38
(no net) on BOTTOM: 103.01,35.55 103.01,31.13 102.38,30.5 97.16,30.5 96.1,31.55 94.97,31.55 94.6,31.92 94.1,31.92 93.98,32.04 93.98,35.83 94.21,36.06 102.51,36.06
(no net) on BOTTOM: 117.34,46.24 117.21,46.37 117.21,50.46 117.07,50.6 116.53,50.6 116.53,50.6 113.66,50.6 113.17,51.08 111.62,51.08 111.51,51.2 111.51,52.34 111.76,52.59 112.78,52.59 113.03,52.84 113.03,54.32 113.53,54.83 116.41,54.83 116.41,54.78 117.05,54.78 117.97,53.86 117.97,53.23 118.26,52.95 118.26,51.71 117.97,51.42 117.97,46.37 117.85,46.24
(no net) on BOTTOM: 93.99,4.11 94.7,4.11 94.7,8.3 94.78,8.37 94.92,8.37 94.99,8.3 94.99,4.11 95.69,4.11 95.69,10.45 95.51,10.64 94.25,10.64 93.99,10.38
(no net) on BOTTOM: 30.99,4.11 31.7,4.11 31.7,10.46 31.53,10.64 31.25,10.64 30.99,10.38
(no net) on BOTTOM: 125.95,52.48 126.46,52.48 126.59,52.36 126.59,45.75 126.46,45.63 125.44,45.63 124.94,46.13 124.94,51.47
(no net) on BOTTOM: 190.98,78.38 191.67,79.07 191.67,83.15 192.05,83.53 195.48,83.53 196.29,82.71 196.29,80.3 196.98,79.62 196.98,76.98 193.93,76.98 193.93,76.6 196.98,76.6 197.23,76.34 197.23,74.95 197.99,74.18 198.63,74.18 198.65,74.21 199.26,73.6 199.26,71.92 199.13,71.78 192.92,71.78 192.79,71.64 192.79,69.84 192.13,69.18 191.03,69.18 190.98,69.23
(no net) on BOTTOM: 48.94,43.47 49.4,43.47 49.68,43.19 49.68,42.65 49.83,42.5 51.23,42.5 51.35,42.37 51.35,39.12 51.33,39.1 51,39.1 50.67,39.43 49.52,39.43 48.84,40.11 48.84,43.37
(no net) on BOTTOM: 139.46,84.09 143.02,84.09 143.65,83.45 143.65,77.93 142.97,77.25 139.54,77.25 138.78,78.01 138.78,79.36 139.21,79.79 139.21,83.84
(no net) on BOTTOM: 60.99,4.11 61.7,4.11 61.7,8.3 61.78,8.37 61.92,8.37 61.99,8.3 61.99,4.11 62.69,4.11 62.69,10.45 62.51,10.64 61.25,10.64 60.99,10.38
(no net) on BOTTOM: 118.54,46.07 118.54,51.02 118.66,51.15 119.86,51.15 120.26,50.74 121.05,50.74 121.33,51.02 122.47,51.02 122.7,50.79 122.7,44.37 123.16,43.91 123.16,43.45 123.01,43.3 122.7,43.3 122.5,43.1 122.5,42.16 122.35,42.01 122.09,42.01 121.97,42.13 121.97,42.39 121.71,42.64 121.2,42.64 121.08,42.51 121.08,41.04 121.05,41.02 121.05,40.38 121.18,40.25 121.18,39.28 121.13,39.23 120.93,39.23 120.47,39.69 120.47,40.04 120.31,40.19 120.11,40.19 120.1,40.19 119.85,40.19 119.68,40.36 119.68,40.61 120.19,41.12 120.19,41.5 120.06,41.63 120.06,42.77 119.68,43.15 118.92,43.15 118.79,43.02 118.79,42.92 118.18,42.31 117.98,42.31 117.93,42.36 117.93,42.89 118.39,43.34 118.39,45.92
(no net) on BOTTOM: 67.31,50.94 67.69,50.56 71.88,50.56 72.01,50.69 72.01,55.39 71.88,55.52 67.64,55.52 67.17,55.99 66.94,55.99 66.9,55.94 66.9,54.98 67.31,54.57
(no net) on BOTTOM: 89.99,4.11 90.7,4.11 90.7,8.3 90.78,8.37 90.92,8.37 90.99,8.3 90.99,4.11 91.69,4.11 91.69,8.47 91.99,8.76 91.99,9.74 91.84,9.89 89.88,9.89 89.73,9.74 89.73,8.72 89.99,8.46
(no net) on BOTTOM: 14.86,51.32 14.73,51.45 14.73,52.34 14.99,52.59 18.29,52.59 19.05,51.83 25.78,51.83 26.04,51.58 26.04,48.4 25.78,48.15 18.67,48.15 17.53,49.29 17.53,50.82 17.02,51.32
(no net) on BOTTOM: 175.59,82.59 178.26,82.59 178.39,82.71 178.39,89.95 178.13,90.21 174.7,90.21 174.58,90.08 174.58,85.63 175.21,85 175.21,82.97
(no net) on BOTTOM: 79.7,28.35 81.81,28.35 82.04,28.13 82.04,27.82 81.63,27.41 79.88,27.41 79.75,27.29 79.75,26.63 79.9,26.47 81.65,26.47 81.81,26.32 81.81,25.46 81.3,24.95 79.67,24.95 79.14,25.48 79.14,27.13 79.52,27.52 79.52,28.18
(no net) on BOTTOM: 125.75,36.6 125.75,36.11 125.55,35.91 125.55,32.66 125.04,32.15 125.04,29.69 125.34,29.38 125.34,29 124.63,28.29 122.09,28.29 121.99,28.39 121.99,28.65 122.35,29 122.35,29.97 122.22,30.09 121.79,30.09 121.74,30.14 121.74,31.36 122.14,31.77 122.14,33.42 122.6,33.88 122.6,35.5 123.44,36.34 123.44,36.72 123.54,36.82 124.71,36.82 124.89,36.65 125.14,36.65 125.32,36.82 125.52,36.82
(no net) on BOTTOM: 22.05,45.5 25.23,45.5 25.61,45.12 25.61,42.96 25.23,42.58 22.18,42.58 21.8,42.96 21.8,45.25
(no net) on BOTTOM: 118,38.91 118,39.11 118.83,39.94 119.93,39.94 120.16,39.71 120.16,39.62 120.16,39.62 120.35,39.43 120.35,39.4 120.36,39.4 120.77,39 120.77,37.8 120.43,37.46 119.45,37.46
(no net) on BOTTOM: 97.78,10.85 98.44,12.38 100,12.97 121.55,12.97 123.12,12.32 123.77,10.75 123.77,1.27 208.73,1.27 208.73,16.8 207.74,17.79 207.74,21.65 208.73,22.64 208.73,85.12 207.74,86.11 207.74,90.2 208.73,91.19 208.73,94.93 1.27,94.93 1.27,91.09 2.25,90.11 2.25,86.27 1.27,85.28 1.27,22.64 2.25,21.65 2.25,17.65 1.27,16.67 1.27,12.97 14.68,12.97 14.68,12.34 1,12.34 0.74,12.44 0.64,12.7 0.64,95.2 0.74,95.46 1,95.56 209,95.56 209.26,95.46 209.37,95.2 209.37,1 209.26,0.74 209,0.63 123.13,0.63 123.13,10.75 122.67,11.87 121.55,12.34 100,12.34 99.92,12.33 98.83,11.9 98.35,10.83 98.35,8.79 97.78,8.79
(no net) on BOTTOM: 97.99,8.42 97.99,4.11 98.49,4.11 98.49,10.51 98.29,10.7 97.87,10.7 97.74,10.58 97.74,8.67
(no net) on BOTTOM: 189.07,20.97 188.82,21.22 188.82,36.61 189.32,37.12 191.35,37.12 191.87,36.59 199.49,36.59 200,36.08 200,32.27 198.35,30.62 198.35,28.72 198.25,28.72 198.12,28.59 198.12,26.94 197.36,26.18 196.34,26.18 195.71,25.54 195.71,21.23 195.45,20.97 ; 1 cut-out
(no net) on BOTTOM: 185.94,91.46 187.33,91.46 187.45,91.33 188.72,91.33 188.8,91.41 188.8,93.16 188.59,93.36 186.96,93.36 185.82,92.22 185.82,91.58
(no net) on BOTTOM: 69.99,4.11 70.7,4.11 70.7,8.3 70.78,8.37 70.92,8.37 70.99,8.3 70.99,4.11 71.69,4.11 71.69,10.11 71.5,10.3 70.21,10.3 69.99,10.09
(no net) on BOTTOM: 42.99,8.42 42.99,4.11 43.7,4.11 43.7,8.3 43.78,8.37 43.92,8.37 43.99,8.3 43.99,4.11 44.69,4.11 44.69,10.45 44.58,10.56 43.17,10.56 42.99,10.38 42.99,9.2 43.15,9.05 43.15,8.57
(no net) on BOTTOM: 28.31,4.11 28.7,4.11 28.7,8.57 29.23,9.09 29.23,10.4 28.99,10.64 28.42,10.64 28.31,10.53
(no net) on G02: 123.13,0.63 123.13,10.75 122.67,11.87 121.55,12.34 99.95,12.34 98.83,11.87 98.37,10.75 98.37,4.11 28.44,4.11 28.44,10.3 26.85,11.88 25.26,10.3 25.26,4.11 15.51,4.11 15.33,4.28 15.33,12.34 1,12.34 0.74,12.44 0.64,12.7 0.64,95.2 0.74,95.46 1,95.56 209,95.56 209.26,95.46 209.37,95.2 209.37,1 209.26,0.74 209,0.63 ; 68 cut-outs
(no net) on G02: 144.42,44.97 143.42,44.97 141.76,43.31 141.76,42.89 141.32,42.45 137,42.45 135.35,44.1 135.35,44.13 135.53,44.47 135.35,44.8 135.35,54.9 136.75,56.29 140.68,56.29 142.75,58.36 142.75,59.72 143.14,60.11 144.5,60.11 145,60.61 169.16,60.61 169.44,60.34 173.23,60.34 173.5,60.61 178.66,60.61 179.04,60.23 182.09,60.23 185.13,57.18 185.13,44.74 183.99,43.59 181.74,43.59 181.5,43.83 180.58,43.83 180.34,43.59 149.35,43.59 148.2,44.74 144.65,44.74
(no net) on T03: 112.54,92.34 108.09,87.9 108.09,79.01 107.46,78.37 104.28,78.37 103.65,79.01 103.65,87.9 102.38,89.17 73.94,89.17 73.25,88.48 73.25,76.31 73.21,76.27 73.21,75.43 72.23,74.46 68.19,74.46 66.77,75.88 53.41,75.88 52.98,76.31 52.98,77.81 56.23,81.06 56.23,88.17 55.23,89.17 19.19,89.17 17.68,87.66 17.68,78.07 15.72,76.11 15.72,72.42 17.75,70.39 23.34,70.39 26.81,66.91 26.81,47.86 26.81,47.85 26.81,43.53 25.99,42.71 20.26,42.71 9.03,53.93 9.03,84.62 10.42,86 10.42,87.38 17.29,94.25 138.15,94.25 138.55,94.65 141.6,94.65 141.87,94.39 141.87,92.48 141.73,92.34
(no net) on T03: 124.73,54.55 125.17,55.01 124.73,55.46 124.73,56.07 125.63,56.97 125.63,61.27 125.63,61.27 125.63,67.06 125.62,67.07 125.62,68.09 119.37,74.33 118.36,74.33 114.32,78.37 114.32,89.8 116.22,91.71 124.1,91.71 125.37,90.44 125.37,76.85 128.57,73.65 128.57,57.42 129.15,56.84 132.09,56.84 132.82,56.1 132.82,55.21 133.84,54.2 133.84,45.97 133.05,45.18 128.68,45.18 127.92,44.42 124.02,44.42 122.98,45.46 122.98,49.45 124,50.46 124.01,50.46 124.73,51.18
(no net) on T03: 121.13,56.38 123.72,53.79 123.72,51.2 123.71,51.2 122.19,49.67 122.19,45.91 125.17,42.92 125.17,41.53 124.28,40.63 124.28,36.77 123.67,36.16 122.7,36.16 121.06,37.81 121.06,37.83 120.76,38.14 120.76,42.25 119.68,43.33 118.89,43.33 118.49,42.92 109.98,42.92 109.33,43.58 107.56,43.58 106.93,42.95 99.56,42.95 94.23,48.28 94.23,56.79 95,57.55 98.93,57.55 99.31,57.17 99.44,57.04 99.44,51.96 101.22,50.18 101.22,48.28 101.73,47.77 110.87,47.77 111.91,46.73 117.98,46.73 118.74,47.49 118.74,56.13 118.99,56.38
(no net) on T03: 126.46,22.39 130.27,22.39 134.33,18.32 134.33,6.26 135.98,4.61 137.89,4.61 138.52,5.24 138.52,7.78 139.79,9.05 139.79,10.96 137.25,13.5 137.25,16.04 137.89,16.67 140.43,16.67 144.24,12.86 166.46,12.86 168.62,10.7 168.62,9.3 168.12,8.8 160.5,8.8 155.91,4.21 142.49,4.21 142.11,4.59 142.11,5.73 141.86,5.99 140.68,5.99 140.43,5.73 140.43,3.34 139.16,2.07 126.46,2.07 124.55,3.97 124.55,20.48
(no net) on T03: 102.19,32.17 102.44,31.91 102.44,31.28 101.81,30.64 98.76,30.64 98.5,30.9 98.5,31.91 98.76,32.17
(no net) on T03: 178.64,89.06 188.05,89.06 191.23,85.89 191.23,70.65 195.67,66.2 195.67,19.08 201.52,13.24 201.52,11.59 200.88,10.96 193.77,10.96 187.42,17.31 187.42,17.69 185.25,19.86 185.25,43.34 186.13,44.23 186.13,49.06 184.74,50.45 184.74,84.12 182.97,85.89 174.72,85.89 174.08,86.52 162.56,86.52 159.26,83.22 145.62,83.22 139.14,89.7 139.14,91.35 139.78,91.98 143.34,91.98 144.61,90.71 166.45,90.71 166.96,91.22 166.96,94.27 167.08,94.4 173.31,94.4 174.32,93.38 174.32,93.38
(no net) on T03: 117.93,54.6 117.93,51.33 117.2,50.6 114.77,50.6 114.58,50.79 114.58,54.35 115.21,54.99 117.55,54.99
(no net) on T03: 55.9,81.49 51.66,77.25 48.35,77.25 47.72,77.88 47.72,82.97 50.63,85.88 50.63,87.04 51.51,87.92 55.71,87.92 55.9,87.73
(no net) on T03: 208.36,70.9 208.36,28.74 207.72,28.1 201.76,28.1 201.25,28.61 201.25,57.42 198.25,60.42 198.25,67.58 198.75,68.09 200.87,68.09 201.25,68.47 201.25,70.39 202.63,71.77 207.49,71.77 ; 1 cut-out
(no net) on T03: 116.99,50.24 114.91,50.24 114.83,50.16 114.83,49.14 114.96,49.02 116.99,49.02 117.12,49.14 117.12,50.11
(no net) on T03: 119.74,42.9 119.43,42.9 119.43,41.24 119.2,41.02 118.13,41.02 118.12,41 117.12,41 116.16,40.04 116.16,34.1 117.52,32.74 118.13,32.12 121.89,32.12 122.91,33.14 127.53,33.14 127.91,33.52 127.91,39.87 127.28,40.51 126.44,40.51 126.41,40.48 125.22,40.48 124.74,40 124.74,36.7 123.72,35.68 122.32,35.68 121.94,36.06 121.94,36.54 120.73,37.75 120.73,41.91
(no net) on G04: 164.19,60.77 164.47,61.05 167.59,61.05 168.03,60.61 178.66,60.61 179.04,60.23 182.09,60.23 185.13,57.18 185.13,44.74 183.99,43.59 182.18,43.59 182.18,43.6 181.69,43.6 181.57,43.72 180.53,43.72 180.41,43.59 142.46,43.59 141.32,42.45 137,42.45 135.35,44.1 135.35,54.9 136.75,56.29 140.68,56.29 140.69,56.3 140.95,56.3 145.41,60.77
(no net) on G04: 123.13,0.63 123.13,10.75 122.67,11.87 121.55,12.34 99.95,12.34 98.83,11.87 98.37,10.75 98.37,4.11 28.44,4.11 28.44,10.3 26.85,11.88 25.26,10.3 25.26,4.11 15.33,4.11 15.33,12.34 1,12.34 0.74,12.44 0.64,12.7 0.64,95.2 0.74,95.46 1,95.56 209,95.56 209.26,95.46 209.37,95.2 209.37,1 209.26,0.74 209,0.63 ; 22 cut-outs
(no net) on T05: 130.07,55.75 130.07,45.21 129.82,44.95 126.13,44.95 125.62,44.44 125.12,44.44 124.47,45.09 121.57,45.09 120.52,46.15 120.52,50.9 120.93,51.3 120.93,60.32 120.86,60.38 120.86,62.42 120.23,63.05 120.23,70.04 121.44,71.25 121.43,71.26 121.43,72.28 119.4,74.31 119.09,74.31 114.32,79.09 114.32,90.44 115.59,91.71 124.73,91.71 125.37,91.07 125.37,76.85 128.16,74.06 128.16,60.83 128.16,60.83 128.16,59.81 128.55,59.43 128.55,59.18 128.16,58.8 128.16,57.65 ; 3 cut-outs
(no net) on T05: 114.77,50.6 117.91,50.6 118.05,50.74 118.05,51.12 117.78,51.4 117.78,54.43 117.22,54.99 115.21,54.99 114.96,54.73 114.96,51.71 114.94,51.7 114.94,51.42 114.7,51.18 114.7,50.67
(no net) on T05: 160.61,94.14 160.86,93.89 160.86,93.89 160.86,91.98 160.48,91.6 153.13,91.6 149.95,88.43 149.95,83.22 146.27,79.54 142.97,79.54 137.89,74.46 129,74.46 126.46,77 126.46,90.97 125.19,92.24 113.12,92.24 111.22,90.33 111.22,84.62 113.12,82.71 113.12,79.54 116.68,75.98 116.68,75.34 116.43,75.09 114.39,75.09 110.71,78.77 110.71,80.93 108.04,83.6 108.04,92.24 109.95,94.14 126.46,94.14 128.36,92.24 128.36,80.17 131.54,77 137.25,77 138.52,78.27 138.52,90.98 141.68,94.14
(no net) on T05: 198.45,33.94 204.55,33.94 205.18,33.31 205.18,30.64 204.55,30.01 199.85,30.01 197.82,32.04 197.82,33.31
(no net) on T05: 9.24,70.26 39.46,70.26 39.97,69.76 39.97,64.3 39.59,63.91 9.37,63.91 8.86,64.42 8.86,69.88
(no net) on T05: 114.37,50.16 114.37,49.04 114.47,48.94 116.94,48.94 117.01,49.02 117.01,50.11 116.85,50.27 116.54,50.27 116.4,50.13 116.12,50.13 116.01,50.25 115.65,50.25 115.57,50.16 115.34,50.16 115.26,50.24 114.45,50.24
(no net) on T05: 115.97,34.92 110.45,40.44 110.45,42.1 105.16,47.39 105.16,47.56 105.61,48.02 105.61,49.98 105.41,50.18 105.13,50.18 105.05,50.26 105.05,51.32 105.18,51.45 105.46,51.45 105.59,51.58 105.59,53.41 105.42,53.58 103.13,53.58 102.8,53.69 102.47,53.56 102.41,53.56 102,53.97 102,62.24 80.92,83.32 69.86,83.32 65.55,79.01 65.55,66.31 63.64,64.4 48.13,64.4 47.77,64.75 47.77,73.82 48,74.05 49.42,74.05 49.75,73.72 49.75,69.86 50.76,68.85 59.79,68.85 59.81,68.86 60.72,68.86 61.09,69.23 61.09,73.95 60.09,74.95 60.09,86.89 62.37,89.17 89.68,89.17 105.46,73.39 105.46,70.02 108.35,67.13 108.35,53.97 118.51,43.81 126.77,43.81 128.04,42.54 128.04,39.75 127.53,39.24 125.37,39.24 125.12,38.98 125.12,35.43 124.61,34.92 ; 1 cut-out
(no net) on T05: 112.42,50.54 108.99,53.97 108.99,64.38 108.99,64.39 108.98,64.4 108.98,67.71 106.7,69.99 106.7,73.42 90.31,89.8 61.61,89.8 59.38,87.57 59.38,75.07 60.58,73.87 60.58,69.74 60.33,69.49 58.8,69.49 50.94,69.48 50.31,70.12 50.31,85.36 59.2,94.25 94.12,94.25 114.58,73.8 114.58,65.27 114.26,64.96 114.26,57.63 113.87,57.63 113.87,56.95 114.58,56.95 114.58,50.79 114.32,50.54
(no net) on P06: 164.08,60.77 164.43,61.12 167.61,61.12 169,59.72 172.56,59.72 172.57,59.73 172.85,59.73 173.74,60.61 195.66,60.61 197.69,58.58 197.69,58.58 198.07,58.2 198.07,47.03 197.18,46.14 193.37,46.14 193.12,45.88 193.12,45.88 190.83,43.59 173.32,43.59 173.22,43.49 168.93,43.49 166.74,41.31 154.53,41.31 152.24,43.59 142.33,43.59 141.19,42.45 137,42.45 135.35,44.1 135.35,54.9 136.75,56.29 140.79,56.29 145.27,60.77
(no net) on P06: 110.1,40.25 114.3,40.25 114.58,40.53 120.57,40.53 120.85,40.25 120.85,38.86 119.96,37.97 119.15,37.97 118.87,37.69 117.95,37.69 117.62,37.36 117.62,33.9 117.37,33.65 109.88,33.65 109.37,34.16 109.34,34.18 98.82,34.18 98.44,34.56 98.44,37.48 99.2,38.24 108.09,38.24
(no net) on P06: 126.13,44.95 125.62,44.44 125.12,44.44 124.48,45.08 119.4,45.08 119.15,45.33 119.15,50.67 118.51,51.3 118.51,58.86 116.67,60.7 115.85,60.7 114.33,62.22 114.33,90.41 115.27,91.35 124.79,91.35 125.37,90.78 125.37,75.54 126.7,74.2 126.7,68.53 133.12,62.11 133.12,45.71 132.36,44.95
(no net) on P06: 110.38,57.02 111.27,56.13 117.37,56.13 117.88,55.62 117.88,51.43 117.87,51.42 117.87,51.07 117.47,50.67 106.43,50.67 105.81,51.29 105.81,53.32 105.38,53.76 101.09,53.76 99.33,55.51 99.33,57.17 98.68,57.82 95.83,57.82 95.83,57.82 93.81,57.82 93.36,58.27 93.36,61.61 94,62.25 98.82,62.25 101.99,59.07 108.35,59.07 110.38,57.04
(no net) on P06: 160.75,0.92 159.99,1.68 159.99,13.24 155.69,17.54 145.4,17.54 137.51,25.43 137.51,35.11 137.71,35.31 137.71,36.05 137.51,36.25 137.51,41.94 137.64,42.07 141.45,42.07 142.59,43.21 151.99,43.21 154.27,40.93 167.25,40.93 169.44,43.11 190.83,43.11 193.48,45.76 197.31,45.76 198.33,46.77 198.33,58.33 195.54,61.12 173.61,61.12 172.97,60.49 169,60.49 168.12,61.37 164.18,61.37 163.8,60.99 145.88,60.99 145.75,61.12 144.99,61.12 140.41,56.55 135.48,56.55 133.95,58.07 133.95,62.26 129.89,66.33 129.63,66.33 127.09,68.88 127.09,74.45 125.95,75.59 125.95,90.71 126.57,91.33 126.57,91.35 152.48,91.35 153.11,90.71 170.39,90.71 170.89,91.22 199.09,91.22 199.72,91.86 201.59,91.86 205.4,93.18 208.95,91.26 209.14,91.08 209.14,91.01 209.14,91.01 209.14,85.39 209.14,85.39 209.14,61.37 209.12,61.36 209.12,42.72 209.14,42.71 209.14,1.43 209.12,1.41 209.12,0.92 208.61,0.92 208.61,0.92 ; 3 cut-outs
(no net) on P06: 154.71,17.14 159.15,12.69 159.15,2.81 158.52,2.17 125.24,2.17 124.6,2.81 124.6,11.7 123.34,12.96 20.47,12.96 2.05,31.38 2.05,77.1 19.19,94.25 67.52,94.25 70.06,91.71 70.06,90.84 76.72,84.17 80.53,84.17 91.01,73.7 94.19,73.7 96.51,71.37 96.51,70.61 96.03,70.12 91.58,70.12 91.54,70.16 88.96,70.16 78.69,80.43 75.64,80.43 66.76,89.31 39.97,89.31 39.08,88.43 39.08,81.76 38.86,81.53 31.88,81.53 31.26,80.91 28.08,80.91 27.45,81.55 27.45,85.36 26.81,85.99 19.19,85.99 7.76,74.56 7.76,33.92 24.91,16.78 56.95,16.78 56.89,16.34 57.24,16.06 58.77,16.06 59.11,16.34 59.05,16.78 127.02,16.78 128.3,18.05 128.3,40 127.78,40.51 126.39,40.51 124.99,41.9 121.05,41.9 120.8,41.65 120.8,41.32 120.47,40.99 118.08,40.99 117.88,41.19 117.88,43.81 118.77,44.7 124.48,44.7 124.99,44.19 125.75,44.19 126.01,44.44 133.75,44.44 134.39,43.81 134.39,42.54 135.66,41.27 135.66,40.63 136.93,39.36 136.93,25.39 145.18,17.14 ; 6 cut-outs
(no net) on P06: 106.82,23.76 105.87,24.71 106.12,24.71 106.12,24.96 105.79,24.96 105.79,24.8 99.97,30.62 98.82,30.62 98.57,30.88 98.57,31.89 98.82,32.15 101.98,32.15 101.99,32.14 104.93,32.14 108.75,28.32 119.4,28.32 120.29,29.2 120.29,35.76 121.15,36.62 121.15,37.24 121.47,37.56 121.79,37.56 122.42,38.2 122.47,38.2 122.93,38.66 123.26,38.66 123.57,38.96 123.57,39.98 123.24,40.3 121.28,40.3 121.1,40.48 121.1,40.76 121.1,40.76 121.1,41.45 121.43,41.78 124.86,41.78 125.27,41.37 125.27,40.11 124.93,39.78 124.58,39.78 124.4,39.61 124.4,39.56 124.93,39.03 124.93,37.66 123.21,35.94 123.21,26.18 120.79,23.76 ; 3 cut-outs
(no net) on P06: 109.62,33.27 117.5,33.27 118.03,33.8 118.03,36.9 118.56,37.43 119.12,37.43 119.35,37.66 120.11,37.66 121.18,38.73 121.18,39.65 121.17,39.66 121.17,39.94 121.23,40 123.04,40 123.04,39.99 123.26,39.78 123.26,39.43 123.12,39.29 122.96,39.29 122.17,38.5 122.17,38.48 121.55,37.85 121.37,37.85 120.98,37.46 120.98,37.28 120.04,36.34 120.04,36.34 119.86,36.16 119.86,29.28 119.27,28.7 108.86,28.7 105.16,32.39 98.71,32.39 98.44,32.65 98.44,33.54 98.7,33.8 109.09,33.8 ; 2 cut-outs
(no net) on P06: 71.2,94.52 70.82,94.14 70.82,91.89 73.53,89.17 73.53,87.75 74.14,87.14 75.29,87.14 77.55,84.87 108.16,84.87 115.27,91.98 152.73,91.98 153.37,91.35 170.13,91.35 170.77,91.98 198.96,91.98 199.47,92.49 199.47,93.89 198.83,94.52
(no net) on P06: 15.38,27.57 15.38,46.62 8.4,53.61 8.4,67.58 17.29,76.47 27.45,76.47 31.37,80.39 39.94,80.39 40.86,81.31 40.86,88.04 41.37,88.55 66.88,88.55 75.45,79.98 78.63,79.98 89.76,68.85 101.11,68.85 103.01,66.94 103.01,63.13 102.38,62.5 99.2,62.5 98.56,63.14 83.97,63.14 77.61,56.78 77.61,45.35 99.84,23.13 122.06,23.13 123.58,24.65 123.58,35.78 125.27,37.47 125.27,39.21 125.48,39.43 125.48,40 125.74,40.25 127.55,40.25 127.81,40 127.81,18.68 127.78,18.68 126.51,17.41 25.54,17.41 ; 3 cut-outs
(no net) on P06: 107.85,50.31 118.26,50.31 118.51,50.06 118.51,45.04 114.1,40.63 103.02,40.63 102.76,40.38 102.76,40.36 101.62,39.22 95.65,39.22 95.02,39.86 95.02,47.62 94.94,47.7 94.94,54.55 95.65,55.26 98.7,55.26 99.14,54.81 99.14,54.8 102.31,51.63 102.31,48.03 102.48,47.86 105.4,47.86
(no net) on P07: 123.34,40.25 121.15,40.25 120.42,40.99 118.08,40.99 117.88,41.19 117.88,43.05 118.64,43.81 129.05,43.81 129.56,43.3 129.56,36.28 129.13,35.85 129.13,32.85 129.56,32.42 129.56,23.87 140.95,12.48 154.92,12.48 157.76,9.65 157.76,5.58 157.57,5.4 157.57,5.3 154.59,2.32 127.63,2.32 124.6,5.35 124.6,13.6 123.97,14.24 85.23,14.24 85.23,18.68 89.04,22.49 106.82,22.49 109.36,19.95 125.87,19.95 126.13,20.21 126.13,32.38 125.44,33.07 125.44,38.15
(no net) on P07: 77.17,81.57 78.82,81.57 88.85,91.6 98.25,91.6 99.9,93.25 125.43,93.25 126.83,91.86 126.83,69.63 124.41,67.22 124.41,65.31 124.67,65.06 125.81,65.06 128.22,67.47 128.22,92.87 126.44,94.65 80.92,94.65 80.01,93.74 80.01,86.32 76.66,82.97 76.66,82.08
(no net) on P07: 198.47,60.23 199.74,58.96 199.74,44.61 198.72,43.59 185.77,43.59 185.13,44.23 172.81,44.23 172.18,43.59 143.67,43.59 142.53,42.45 137,42.45 135.35,44.1 135.35,54.9 136.3,55.85 141,55.85 144.55,59.4 151.77,59.4 152.73,60.36 167.97,60.36 168.23,60.11 170.89,60.11 171.02,60.23 171.53,60.23 171.66,60.11 172.16,60.11 172.29,60.23 175.59,60.23
(no net) on P07: 113.57,75.83 113.24,75.5 109.99,75.5 109.96,75.52 104.17,75.52 102.44,73.8 95.25,73.8 94.97,73.52 91.6,73.52 91.29,73.82 89.92,73.82 86.19,77.56 81.18,77.56 78.72,80.02 78.72,80.78 89.16,91.22 98.5,91.22 100.03,92.75 110.95,92.75 113.57,90.13
(no net) on P07: 160.42,2.53 158.14,4.82 158.14,9.9 155.34,12.69 141.31,12.69 129.88,24.12 129.88,32.68 129.51,33.05 129.51,35.97 129.88,36.34 129.88,41.17 130.14,41.44 130.14,42.2 130.13,42.2 129.88,42.45 129.88,44 130.49,44.61 134.33,44.61 134.46,44.48 134.46,42.83 136.11,42.83 136.87,42.07 141.45,42.07 142.59,43.21 185.13,43.21 186.28,42.07 186.28,14.38 197.33,14.38 197.89,13.82 197.89,3.55 196.87,2.53
(no net) on P07: 109.37,34.16 98.82,34.16 98.44,34.54 98.44,37.48 99.2,38.24 108.11,38.24 110.13,40.25 114.3,40.25 114.58,40.53 120.59,40.53 120.85,40.28 120.85,38.86 119.96,37.97 117.88,37.97 117.62,37.71 117.62,33.9 117.37,33.65 109.88,33.65
(no net) on P07: 191.47,21.37 190.71,22.13 190.71,30.52 191.47,31.28 198.96,31.28 200.61,32.93 200.61,64.68 195.15,70.14 195.15,87.67 191.6,91.22 161.17,91.22 160.66,91.85 160.14,91.22 142.19,91.22 141.81,91.6 141.81,94.14 142.19,94.52 199.12,94.52 199.52,94.12 199.52,85.57 208.36,76.72 208.36,30.64 199.09,21.37
(no net) on P07: 110.38,57.02 111.27,56.13 117.37,56.13 117.66,55.84 117.66,50.86 117.47,50.67 106.46,50.67 105.81,51.32 105.81,53.32 105.38,53.76 101.09,53.76 99.33,55.51 99.33,57.17 98.7,57.79 95.83,57.79 95.82,57.8 93.81,57.8 93.36,58.25 93.36,61.61 94,62.25 98.82,62.25 101.99,59.07 108.35,59.07 110.38,57.04
(no net) on P07: 126.43,72.74 126.44,72.73 126.44,69.96 124.03,67.55 124.03,65.06 124.29,64.81 127.72,64.81 128.23,64.3 128.23,59.85 128.49,59.59 128.49,58.97 128.23,58.71 128.23,57.73 130.19,55.76 131.29,55.76 133.12,53.93 133.12,45.71 132.36,44.95 126.13,44.95 125.62,44.44 125.12,44.44 124.48,45.08 119.4,45.08 119.15,45.33 119.15,50.79 120.42,52.06 120.42,57.14 116.61,60.95 115.34,60.95 114.31,61.98 114.31,90.13 116.92,92.75 124.79,92.75 126.43,91.11
(no net) on P07: 23.52,13.12 23.52,11.57 22.71,10.76 20.45,10.76 20.12,11.09 20.12,13.2 19.56,13.76 19.56,15.61 22.02,18.07 22.07,18.07 23.04,19.04 23.04,19.6 24.99,21.56 29.77,21.56 30.38,20.95 30.38,19.98
(no net) on P07: 128.62,62.52 128.24,62.14 128.24,61.63 128.62,61.25 128.62,60.74 128.49,60.61 128.49,60.1 128.87,59.72 128.87,58.96 128.49,58.58 128.49,58.07 129.32,57.25 129.32,56.87 130.02,56.17 131.41,56.17 131.92,55.66 132.43,55.66 132.94,56.17 140.43,56.17 140.44,56.17 140.87,56.17 144.8,60.1 168.35,60.1 168.74,60.49 169.24,60.49 169.5,60.23 169.75,60.23 170.01,60.49 170.39,60.49 170.64,60.23 170.89,60.23 171.15,60.49 171.4,60.49 171.66,60.23 172.04,60.23 172.29,60.49 174.97,60.49 175.23,60.74 177.13,60.74 177.39,60.49 183.86,60.49 183.99,60.61 198.47,60.61 199.48,61.63 199.48,64.68 194.53,69.63 194.53,87.45 191.27,90.71 142.07,90.71 141.43,91.35 141.43,93.63 140.54,94.52 130.38,94.52 128.62,92.76
