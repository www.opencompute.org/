# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_OC_3_L: length 17.2
  TOP w0.089: U1.BG2 129.47,23.28 131.14,21.61
  TOP w0.109: 131.14,21.61 132.34,20.41 132.74,20.41 133.08,20.07 133.08,19.3 133.18,19.19 133.18,15.52 v3(132.56,14.89) R161.2
USB_OC_4_L: length 13.5
  TOP w0.089: 129.18,21.61 129.13,21.66 129.13,22.59 128.69,23.03 128.69,28.38 128.82,28.51 128.82,29.1 128.48,29.44 U1.BE4
  TOP w0.109: 129.18,21.61 130.32,20.46 130.32,19.41 v3(131.03,18.7) R162.2
USB_OC_5_L: length 13.3
  TOP w0.089: 130.58,21.61 130.58,21.76 129.26,23.08 129.26,28.67 129.05,28.87 129.05,29.36 U1.BF3
  TOP w0.109: 130.58,21.61 131.98,20.21 131.98,19.38 132.56,18.8 v3(132.56,18.7) R163.2
USB_OC_6_L: length 15.8
  TOP w0.089: 129.71,22.04 129.71,22.38 128.98,23.11 U1.BF1
  TOP w0.109: 129.71,22.04 131.66,20.09 131.66,15.52 v3(131.03,14.89) R164.2
USB_RBIAS: length 2.9
  TOP w0.152: U1.AG11 v1(120.79,32.67) U1.AJ11
  BOTTOM w0.102: v1(120.79,32.67) 120.58,32.67 119.66,31.74 R32.1
VFLTP1P05_CPU_VCCKRLCPLL: length 3.2
  TOP w0.381: U1.T56 v1(115.67,52.62)
  TOP w0.635: L2.1 99.47,42.03
  BOTTOM w0.305: C151.1 116.1,52.96 116.1,53.59 116.29,53.78 R1.2
  BOTTOM w0.381: v1(115.67,52.62) 115.88,52.83 C151.1
  vias: v3(101.24,43.96)
VFLTP1P05_CPU_VCCSCPLL: length 2.3
  TOP w0.381: U1.T46 v1(115.83,48.43)
  TOP w0.635: L3.1 99.65,38.88
  BOTTOM w0.254: C40.1 116.51,47.76 v1(115.83,48.43)
  vias: v3(101.11,39.64)
VFLTP1P05_PCH: length 42.7
  TOP w0.381: v1(119.03,39.77) 119.42,40.17 U1.AE27 ; v3(97.76,35.47) 97.16,36.06 L1.2
  T05 w0.381: v1(114.78,30.86) 113.35,29.43 110.42,29.43 109.45,30.4 98.95,30.4 97.54,31.8 97.54,35.25 v3(97.76,35.47)
  T08 w0.381: v1(114.78,30.86) 114.78,30.9 114.35,31.33 114.35,32.39 116.08,34.12 116.08,36.69 115.52,37.25 115.52,39.41 116.54,40.42 118.38,40.42 v1(119.03,39.77)
  BOTTOM w0.381: v2(98.62,36.33) v3(97.76,35.47) ; v1(114.78,30.86) 114.98,30.65 C178.1 C177.1
VFLTP1P05_PCH_VCCCLK: length 2.6
  TOP w0.305: v1(120.64,38.16) 120.64,38.16 U1.AG23 ; U1.AC21 118.35,37.48 v1(118.23,37.37)
  BOTTOM w0.381: C3812.1 118.35,37.25 v1(118.23,37.37)
  BOTTOM w0.635: L7.2 108.15,34.81
  vias: v1(111.37,34.1) v1(111.91,33.27) v2(109.31,36.33)
VP0P6_DDR4_VTT: length 52.2
  TOP w0.089: CN2.258 165.62,83.47
  TOP w0.381: 165.62,83.47 165.05,83.47 164.8,83.22 v3(164.8,82.59) 162.26,80.05 C139.1 C145.1 159.94,80.05 158.63,81.37 158.63,81.71 157.56,82.78 v3(157.56,83.35) ; v3(177.88,92.75) 179.56,94.42 185.45,94.42 186.22,93.66 PU11.5 ; PU11.3 186.92,92.09
  T05 w0.381: v3(157.56,83.35) 156.67,84.24 156.67,87.16 159.24,89.73 169.6,89.73 172.61,92.75 v3(177.88,92.75)
  BOTTOM w0.254: CN1.258 187.36,83.42
  vias: v3(187.93,82.96) v3(188.21,81.92) v3(188.34,92.35) v3(188.47,93.11) v6(187.45,92.85)
VP0P6_DDR4_VTT_EN_R: length 3.2
  TOP w0.109: PR38.1 181.48,92.22 v3(181.88,92.62) 181.91,92.59 PU11.7
  BOTTOM w0.109: v2(180.94,92.62) v3(181.88,92.62)
VP0P6_DDR4_VTT_REFIN: length 1.1
  BOTTOM w0.381: v2(184.52,90.69) 184.24,90.41 v3(184.24,89.72)
VP0P6_DDR4_VTT_REFOUT: length 3.3
  TOP w0.381: PU11.6 182.7,93.09 v3(182.26,93.53) 181.53,93.53 PC82.1
  BOTTOM w0.381: v2(183.2,93.53) v3(182.26,93.53)
VP1P2_DDR4_AB_VREFCA: length 43.3
  TOP w0.254: v1(175.99,59.89) 175.99,60.17 176.22,60.39 177.41,60.39 177.84,59.96 180.28,59.96 180.34,60.02 v1(180.79,60.02) ; 166.36,59.96 164.72,59.96 v1(164.68,59.92) ; 166.36,59.96 CN2.164 ; 166.36,59.96 169,59.96 v1(169.06,60.02)
  TOP w0.381: R191.1 R189.2 164.48,60.13 v1(164.68,59.92) ; v1(154.46,62.42) 154.46,62.7 154.05,63.11 R190.2 C137.1
  BOTTOM w0.109: v1(169.06,60.02) 169.61,60.02 170.01,60.42 170.35,60.42 170.61,60.16 170.86,60.16 171.11,60.42 171.46,60.42 171.69,60.19 171.98,60.19 172.21,60.42 173.2,60.42 ; CN1.164 185.33,59.91 185.05,60.19 184.57,60.19 184.34,60.42 183.94,60.42 183.71,60.19 183.42,60.19 183.19,60.42 182.85,60.42 182.59,60.16 182.34,60.16 182.09,60.42 181.74,60.42 181.35,60.02 v1(180.79,60.02)
  BOTTOM w0.254: v1(175.99,59.89) 175.18,60.7 C144.1 173.51,60.72 173.2,60.42
  BOTTOM w0.381: v1(154.46,62.42) 154.81,62.77 157.97,62.77 159.85,60.9 v2(159.85,59.92) 160.55,59.22 163.98,59.22 v1(164.68,59.92)
VP1P2_DDR4_VDD: length 165
  TOP w0.089: v1(145.09,47.55) 144.9,47.55 144.7,47.74 143.35,47.74 U1.CU43 142.84,47.76 142.42,47.34 142.29,47.34 ; v1(144.99,56.69) 144.96,56.67 U1.CU63 ; v1(144.99,58.68) 144.96,58.65 U1.CU67 142.84,58.65 142.34,59.14 U1.CP68 ; 142.29,51.28 142.39,51.28 142.78,51.66 143.07,51.66 143.13,51.72 U1.CU52 145.29,51.72 v1(145.7,51.31) ; U1.CU39 143.52,45.97 144.38,45.97 144.45,45.89 144.88,45.89 v1(145.08,45.69) ; U1.CU65 144.43,57.66 144.45,57.68 146.12,57.68 146.41,57.98 147.84,57.98 148.53,58.68 v1(148.55,58.68) ; U1.CU59 144.97,54.69 v1(145,54.73) ; v1(147.3,60.26) 146.69,59.65 144.28,59.65 144.27,59.63 143.34,59.63 U1.CU69 ; U1.CU48 144.81,49.74 v1(145.02,49.53)
  TOP w0.254: U1.CP62 U1.CP60 ; U1.CP55 U1.CT55
  TOP w0.305: CN2.154 165.25,57.47 165.19,57.52 ; CN2.160 168.32,58.97 v1(168.5,59.15)
  TOP w0.356: U1.CF60 v1(137.64,55.57) ; U1.CH45 v1(138.63,48.71) ; U1.CK52 v1(139.63,52.14) ; U1.CH49 v1(138.63,50.42) ; U1.CJ39 v1(139.13,46.13) ; U1.CG51 v1(138.14,51.28) ; U1.CH37 v1(138.63,45.27) ; v1(138.63,53.86) U1.CH56 ; U1.CH41 v1(138.63,46.99) ; U1.CL35 v1(140.12,44.41) ; U1.CG58 v1(138.14,54.72) ; U1.CG43 v1(138.14,47.85) ; U1.CG54 v1(138.14,53) ; U1.CH33 v1(138.63,43.56)
  TOP w0.381: PR193.2 v3(195.17,22.52) PR188.1 ; PU11.2 187.33,91.59 ; v3(195.2,20.21) 195.17,20.24 PR193.1 ; v3(202.28,57.99) 202.28,58.92 PR168.1
  T03 w0.254: v3(195.17,22.52) 195.24,22.6 196.04,22.6 196.36,22.92 198.12,22.92 200.89,25.69 200.89,47.41 198.71,49.59 194.11,49.59 v6(193.37,50.33)
  T10 w0.254: v1(172.41,57.02) 173.82,55.61 173.82,43.22 174.83,42.2 177.12,42.2 177.63,41.69 177.63,18.7 178.64,17.69 194.52,17.69 195.2,18.37 v3(195.2,20.21)
  BOTTOM w0.127: CN1.147 179.16,55.66 179.54,55.27 179.84,55.27 v1(180.23,54.88) ; v1(180.23,57.65) 179.74,57.16 CN1.153 ; v1(180.23,59.15) 179.7,59.15 179.21,58.66 CN1.159
  BOTTOM w0.254: v1(176.78,59.8) 176.92,59.66 CN1.163 ; 177.02,52.22 178.21,52.22 CN1.141 ; 177.1,49.16 CN1.129 ; CN1.142 187.39,52.41 ; 177.01,47.66 CN1.123 ; 177.07,50.66 CN1.135 ; 187.44,44.91 CN1.112 ; 177.11,46.16 CN1.117
  BOTTOM w0.305: v1(176.7,44.75) 176.74,44.72 178.21,44.72 CN1.111
  BOTTOM w0.381: v3(202.28,57.99) 202.28,57.44 PL14.2
  vias: v1(135.49,53.53) v1(135.66,46.99) v1(136.16,53) v1(136.65,48.71) v1(136.65,46.99) v1(136.65,45.27) v1(137.15,49.56) v1(137.15,47.85) v1(138.63,55.57) v1(139.63,55.57) v1(140.12,54.72) v1(141.11,54.72) v1(141.11,53) v1(141.11,51.28) v1(141.11,49.56) v1(141.11,47.85) v1(141.11,42.7) v1(145.78,53.33) v1(146.49,53.33) v1(146.5,45.69) v1(147.12,58.68) v1(147.12,56.69) v1(147.14,54.73) v1(147.14,51.31) v1(147.15,49.53) v1(147.2,53.33) v1(147.21,45.69) v1(147.25,47.55) v1(147.84,58.68) v1(147.91,53.33) v1(147.92,45.69) v1(148.01,60.26) v1(148.62,53.33) v1(148.72,60.26) v1(149.33,53.33) v1(149.44,58.68) v1(149.44,56.69) v1(149.45,54.73) v1(149.42,45.69) v1(149.46,49.53) v1(149.56,51.31) v1(149.56,47.55) v1(150.06,53.33) v1(150.32,60.26) v1(150.88,49.52) v1(151.57,58.68) v1(151.57,56.69) v1(151.58,54.73) v1(151.57,53.33) v1(151.7,51.31) v1(151.7,47.56) v1(151.68,45.73) v1(153.01,43.98) v1(168.5,57.65) v1(168.5,56.15) v1(168.5,54.88) v1(168.5,52.88) v1(168.54,51.15) v1(168.5,45.15) v1(169.03,44.52) v1(169.06,55.52) v1(169.62,57.65) v1(169.62,51.15) v1(170.18,57.02) v1(170.18,55.52) v1(170.18,52.02) v1(170.18,50.52) v1(170.18,49.02) v1(170.18,47.52) v1(170.18,46.02) v1(170.18,44.54) v1(170.73,57.65) v1(170.73,56.15) v1(170.73,54.88) v1(170.73,52.88) v1(170.73,51.15) v1(170.73,49.65) v1(170.73,48.15) v1(170.73,46.65) v1(170.73,45.15) v1(171.29,52.02) v1(171.29,44.52) v1(171.85,51.15) v1(172.41,55.52) v1(172.41,50.52) v1(172.97,52.88) v1(172.97,45.15) v1(175.92,54.53) v1(175.94,44.75) v3(153.72,43.98) v3(154.58,60.01) v3(156.26,43.98) v3(157,43.98) v3(157.56,59.99) v3(161.37,60.11) v3(162.26,60.11) v6(187.6,87.39) v6(187.8,57.56) v6(187.8,56.17) v6(187.8,54.77) v6(187.8,53.25) v6(187.79,51.72) v6(187.79,50.33) v6(188.99,87.39) v6(189.2,54.77) v6(189.2,53.25) v6(190.52,87.39) v6(190.59,54.77) v6(190.59,53.25) v6(191.99,54.77) v6(191.99,53.25) v6(193.39,57.56) v6(193.39,56.17) v6(193.39,54.77) v6(193.39,53.25) v6(193.37,51.72) v6(194.79,57.56) v6(194.79,56.17) v6(194.79,54.77) v6(196.18,57.56) v6(196.18,56.17) v6(196.18,54.77) v6(197.58,57.56) v6(197.58,56.17) v6(197.58,54.77) v6(198.8,55.39) v6(198.88,53.99) v6(198.88,52.47)
VP1P2_DDR4_VREF: length 25.5
  TOP w0.089: U1.CR52 142.5,51.72 142.64,51.86 142.96,51.86 142.96,51.86 142.98,51.86 143.03,51.91 143.03,51.91 143.19,52.07 143.48,52.07 143.64,51.91 145.52,51.91 145.61,51.81
  TOP w0.254: 145.61,51.81 150.32,51.81 150.74,52.23 150.74,52.48
  TOP w0.381: 150.74,52.48 150.74,53.23 v1(150.85,53.33) 150.85,53.65 151.21,54.01 151.72,54.01 152.25,54.54 152.25,58.92 151.92,59.25 C199.1 151.92,63.24 153.24,64.56 R190.1
  BOTTOM w0.089: 152.16,53.86 151.37,53.86 v1(150.85,53.33)
  BOTTOM w0.381: v2(152.39,53.86) 152.16,53.86
VP1P3: length 8.2
  TOP w0.381: v3(59.39,69.89) 59.39,69.42 59.14,69.18 56.21,69.18 55.87,69.52 PR15.1 ; U1.N51 v1(113.39,51.29) ; U1.N58 v1(113.88,53.87)
  T03 w0.508: v1(113.88,53.87) 113.84,53.83 113.84,51.75 v1(113.39,51.29)
  vias: v3(59.44,90.95) v3(60.2,69.92)
VP1P3_FB: length 3.3
  TOP w0.254: PR15.2 53.89,69.58 PR14.1 53.86,69.7 54.25,70.08 PU5.8
VP1P3_SS: length 2.4
  TOP w0.254: PC37.1 52.8,69.7 53.75,70.65 PU5.7
VP1P05: length 415.4
  TOP w0.254: U1.R58 v1(115.36,54.72) ; v1(116.63,50.83) U1.V51 v1(115.83,50.83) ; U1.T53 v1(115.83,51.63) ; U1.T48 v1(115.83,49.23) ; U1.V48 v1(116.63,49.23) ; U1.R49 v1(115.03,50.03) ; U1.R48 v1(115.03,49.23) ; U1.AK55 v1(122.23,52.43) ; U1.AR18 124.12,36.17 124.03,36.25 123.63,36.25 123.55,36.17 U1.AP18 ; U1.Y53 v1(117.43,51.63) ; v1(119.03,53.23) U1.AC55 118.54,52.74 118.54,52.13 U1.AC53 ; U1.AM53 v1(123.03,51.63) ; U1.Y56 v1(117.43,53.23) ; v1(116.63,53.24) 116.24,53.63 U1.V56 ; U1.AA58 v1(117.43,54.03) ; U1.V53 v1(116.63,51.63) ; U1.T51 v1(115.03,50.83) ; U1.AK53 v1(122.23,51.63) ; U1.AH55 v1(121.43,52.43)
  TOP w0.305: U1.T49 v1(115.83,50.03) ; U1.V49 v1(116.63,50.03)
  TOP w0.33: v1(123.04,36.57) 123.04,36.56 U1.AP18 ; U1.AP21 v1(123.03,38.17)
  TOP w0.381: v1(123.83,38.16) 124.23,37.77 U1.AR21 ; v1(123.83,38.16) 123.83,38.16 U1.AP21 ; v1(123.83,38.16) 124.23,38.57 U1.AR23 ; v3(198.48,32.78) 198.48,32.82 198.98,33.33 PR110.1 ; v3(108.69,71.01) 108.79,71.11 108.79,71.87 ; R115.1 111.55,70.29 v3(110.81,71.03) 110.58,70.8 R174.1 ; C125.1 68.55,29.7 v3(68.61,29.76) 68.63,29.78 68.63,30.06 68.79,30.22 U10.16 ; v3(139.53,83.6) 139.72,83.8 U7.1 ; v3(26.29,69.97) 27.19,69.97 27.64,69.51 C119.1 28.26,69.72 U14.1 ; R259.1 v3(116.73,71.01) ; C20.2 83.29,67.47 80.83,67.47 80.57,67.21 80.57,67.19 80.46,67.08 80.45,67.08 80.38,67.01 C25.2 79.67,67.01 78.71,67.97 U4.16 77.56,68.29 v3(77.56,68.65) ; C20.2 84.24,66.51 84.24,65.39 U2.6 ; C20.2 84.19,67.09 84.45,67.34 86.16,67.34 86.69,66.81 v3(86.69,64.68) ; v3(87.5,72.28) C29.1 87.52,71.53 U16.1 ; v3(25.61,66.9) 26.21,66.9 26.29,66.82 R110.1 ; R195.1 66.14,27.83 v3(65.74,27.42) ; R195.1 R194.1 R193.1 63.65,27.97 v3(63.09,27.97) ; R195.1 R196.1 ; PR196.1 PR175.1 PR197.2 69.77,45.08 v3(69.52,44.82) ; R200.1 R202.1 83.68,29.9 83.68,30.91 R201.1 ; R200.1 C54.1 ; R200.1 84.5,28.69 v3(85.09,29.28) ; R272.1 101.24,63.49 v3(102.87,63.49) R114.1 ; R117.1 C127.1 139.55,82.02 v3(139.84,82.31) ; R288.1 93.73,70.83 94.51,71.62 v3(95,71.62) ; R280.1 114.82,71.52 115.32,71.02 v3(115.71,71.02) R270.1 ; R251.1 v3(117.75,71.01) ; v3(119.78,71.01) R260.1 ; v3(83.76,57.03) 83.8,57.06 PL8.2 ; v3(73.17,39.23) PC151.1 ; v3(102.8,60.48) 102.83,60.48 102.85,60.49 103.43,60.49 R7.2 ; R8.2 v3(102.86,61.48) 102.46,61.88 101.24,61.88 R290.1 ; U13.16 81.57,31.47 82.09,31.99 v3(82.09,32.57) ; R116.1 143.42,79.92 142.54,79.04 v3(139.14,79.04) ; R401.1 20.28,63.64 21.09,63.64 21.56,64.11 v3(21.56,64.42) ; PU24.1 88.23,33.76 87.88,34.1 87.88,34.18 ; R281.1 114.82,75.59 v3(114.83,75.59) 113.98,75.59 R252.1 ; v3(107.21,75.1) R468.2 R469.2
  TOP w0.635: L3.2 93.66,38.88 ; L2.2 93.61,42.03
  T05 w0.381: v3(21.56,64.42) 23.59,62.39 23.59,57.18 26.87,53.91 26.87,47.78 25.61,46.52 25.61,33.58 v3(27.02,32.16)
  T05 w0.635: v3(198.48,32.78) 198.48,33.33 201.25,36.1 201.25,46.94 203.73,49.43 203.73,58.31 203.1,58.94 200.91,61.13 200.91,62.06 207.72,68.87 207.72,77.15 207.72,77.16 207.72,77.51 195.79,89.44 195.79,91.86 193.25,94.4 161.03,94.4 160.12,93.49
  T10 w0.381: v3(38.06,13.82) 36.2,15.69 36.2,19.07 33.78,21.48 33.78,25.4 v3(27.02,32.16) ; v3(146.3,10.68) 149.18,10.68 151.99,13.5 186.78,13.5 188.44,15.15 195.24,15.15 198.15,18.05 198.15,23.41 197.81,23.75 197.81,30.94 198.08,31.21 198.08,32.38 v3(198.48,32.78)
  BOTTOM w0.203: 115.84,63.64 116.08,63.41 R181.1 ; R180.1 118.02,61.66 118.02,62.23 117.68,62.57 R66.1 ; R122.1 123.06,64.16 R119.1
  BOTTOM w0.254: 122.87,54.66 122.87,55.18 123.49,55.8 124.38,55.8 124.76,56.18 R287.1 ; 122.87,54.66 R109.1 ; 122.87,54.66 122.31,54.1 120.7,54.1 ; 89.59,25.59 89.84,25.85 U5.1 ; 120.37,56.23 120.37,56.92 R261.1 ; v3(65.41,48.53) 65.79,48.91 65.79,49.26 PR272.1 ; 120.4,56.19 R262.1 ; v3(83.76,57.03) 83.82,57.09 PR299.1
  BOTTOM w0.305: 89.59,25.59 88.77,24.78 88.32,24.78 87.4,23.86 87.4,23.54 86.96,23.1 85.6,23.1 v3(84.92,23.78)
  BOTTOM w0.381: R400.1 6.49,67.47 v3(7.59,67.47) ; U8.16 82.73,26.9 C123.1 82.77,27.11 83.24,27.58 83.84,27.58 83.86,27.59 R15.2 R14.2 83.89,25.6 C23.1 84.45,25.59 84.92,25.12 v3(84.92,23.78) ; v3(38.06,13.82) 38.06,10.83 38.48,10.41 38.48,9.25 38.35,9.12 J10.A22 ; v3(74.59,71.1) 74.59,71.1 74.34,71.35 PR173.1 PR112.1 PR174.2 74.34,74.51 73.51,75.34 PC219.1 ; 119.1,65.09 119.1,63.88 R268.1 ; PR111.2 203.94,30.5 v3(203.94,30.5) ; v3(102.87,63.49) 102.72,63.64 101.41,63.64 100.19,62.43 R279.1 R258.1 100.19,59.69 100.41,59.47 102.19,59.47 102.8,60.08 v3(102.8,60.48) ; R119.1 122.23,64.62 121.68,65.17 121.68,69.7 120.98,70.39 120.48,70.39 119.86,71.01 v3(119.78,71.01) ; R111.1 84.58,29.79 v3(85.09,29.28) ; R403.1 4.95,71.38 R420.2 4.95,73.16 4.41,73.69 v3(3.9,73.69) ; R69.1 v3(146.3,10.68) ; PC162.1 198.6,32.66 v3(198.48,32.78) ; PR201.1 v3(203.93,31.51) ; v3(82.09,32.57) 82.09,33.18 82.47,33.56 R112.1 ; R417.2 10.9,69.51 11.51,70.11 R399.1 ; R18.1 93.96,28.59 93.68,28.86 91.77,28.86 v3(91.27,29.37) ; v3(26.29,69.97) 29.64,73.32 R198.1 ; U11.16 37.67,65.18 C117.1 v3(37.79,64.32)
  vias: v1(119.03,55.63) v1(119.03,54.83) v2(107.22,57.67) v2(113.81,52.57) v2(114.96,48) v2(115.21,43.68) v2(118.14,55.31) v2(120.16,53.08) v3(9.49,66.07) v3(9.49,65.36) v3(9.49,64.55) v3(9.62,68.11) v3(9.61,67.37) v3(39.37,68.85) v3(90.1,35.29) v3(90.09,34.54) v3(90.85,35.3) v3(90.85,34.54) v3(95.22,53.81) v3(96.01,57.31) v3(96.03,56.53) v3(96.03,55.77) v3(96,55.01) v3(96,54.24) v3(96.09,59.6) v3(96.09,58.82) v3(96.09,58.05) v3(96.35,60.36) v3(96.76,57.29) v3(96.76,56.53) v3(96.76,55.77) v3(96.76,55.01) v3(96.76,54.24) v3(96.76,53.48) v3(96.85,59.6) v3(96.89,58.82) v3(96.89,58.05) v3(97.23,60.36) v3(97.53,57.29) v3(97.53,56.53) v3(97.53,55.77) v3(97.53,55.01) v3(97.53,54.24) v3(97.53,53.48) v3(97.62,59.6) v3(97.65,58.82) v3(97.65,58.05) v3(98.29,57.29) v3(98.29,56.53) v3(98.29,55.77) v3(98.29,55.01) v3(98.29,54.24) v3(98.29,53.48) v3(98.42,58.82) v3(98.42,58.05) v3(114.85,76.41) v3(115.64,75.65) v5(89.64,33.62) v5(89.64,32.51) v5(89.64,31.39) v5(90.99,33.62) v5(90.99,32.51) v5(90.99,31.39)
VP1P5__PCH_FB: length 3.1
  TOP w0.254: PU6.8 48.82,66 49.15,65.67 PR12.1 49.73,66.64 PR16.2
VP1P05_ALERT: length 2.7
  TOP w0.254: PR109.2 71.38,48.56 71.38,49.67 71,50.05 PU27.32
VP1P05_B-RAMP: length 6.6
  TOP w0.254: PR303.2 70.87,56.89 v3(70.87,56.15) 70.2,55.48 PU27.11
  BOTTOM w0.109: v3(70.87,56.15) 71.3,55.71 71.88,55.71 72.81,54.79 v2(72.89,54.79)
  BOTTOM w0.254: v3(70.87,56.15) 71.12,56.15 71.98,57.01 PR285.1
VP1P05_BLEED: length 2.4
  TOP w0.381: PU24.7 91.92,31.26 93.24,29.94 93.59,29.94 PR57.2
VP1P05_BST_20: length 1.8
  TOP w0.254: PC333.2 81.52,45.86 PU26.9
VP1P05_BST_RC_20: length 1.3
  TOP w0.254: PC333.1 82.45,44.49 PR273.2
VP1P05_BSTR_20: length 3.1
  TOP w0.254: PU26.8 81.02,44.55 PR273.1
VP1P05_CCSN1+_10: length 0.8
  TOP w0.254: 82.19,61.36 PR291.2
VP1P05_CCSN1_10: length 28.4
  TOP w0.254: v3(83.82,59.71) 83.95,59.83 83.95,61.26 PR291.1 ; PU27.18 66.84,53.85 66.62,54.07 v3(66.21,54.07) 65.69,53.55 PC334.1
  T03 w0.254: v3(66.21,54.07) 66.4,53.88 67,53.88 67.32,54.2 67.32,55.8 67.31,55.81 67.31,56.23 67.32,56.24 67.32,56.28 71.37,60.34 81.48,60.34 82.65,59.17 83.57,59.17 83.82,59.43 v3(83.82,59.71)
  BOTTOM w0.254: PR287.1 82.98,58.97 PR299.2 83.82,59.7 v3(83.82,59.71)
VP1P05_CCSP1+_10: length 3.4
  BOTTOM w0.109: PR293.2 v2(82.96,54.61)
  BOTTOM w0.254: PR293.2 PR294.1
VP1P05_CCSP1_10: length 27.6
  TOP w0.254: v3(82.96,59.75) 82.92,59.79 82.58,59.79 81.38,61 PNTC8.2 ; PC334.2 65.7,54.64 66.6,54.64 66.65,54.59 v3(66.69,54.59) 66.69,54.58 66.75,54.52 66.75,54.5 67,54.25 PU27.17
  T03 w0.254: v3(66.69,54.59) 66.57,54.71 66.57,56.3 71.12,60.85 81.87,60.85 v3(82.96,59.75)
  BOTTOM w0.254: v3(82.96,59.75) 82.7,59.75 82.14,59.2 PR287.2 PR294.2
VP1P05_CGFB_10: length 2.2
  TOP w0.254: PR290.1 66.14,51.04 66.95,51.85 PU27.23
VP1P05_COMP_10: length 6.5
  TOP w0.254: PR298.1 67.94,47.57 67.28,46.9 PR276.2 66.83,47.01 PR301.2 PC338.2 66.83,49.14 67.46,49.77 68.11,49.77 68.6,50.26 PU27.26
VP1P05_COMP_RC_10: length 2
  TOP w0.109: v3(67.05,45.15) 66.93,45.27 PR276.1
  TOP w0.254: PC335.2 PR276.1
VP1P05_CVFB_10: length 3.4
  TOP w0.254: PR286.2 65.53,49.42 v3(66.8,50.69) 66.88,50.69 PU27.24
VP1P05_DROOP_10: length 5.2
  TOP w0.254: PU27.25 67.76,50.89 66.01,49.14 PC338.1 PR301.1 65.91,47.8 PC335.1
VP1P05_F-IMAX: length 8.4
  TOP w0.254: PU27.10 70.6,55.32 70.92,55.64 71.5,55.64 v3(72.01,56.15) 72.01,56.76 PR305.2 PR292.2
  BOTTOM w0.109: 72.1,56.15 72.62,55.62 73.36,55.62 v2(74.26,54.72)
  BOTTOM w0.254: PR269.1 73,57.01 72.14,56.15 v3(72.01,56.15)
VP1P05_GSNS: length 70.9
  TOP w0.254: v3(65.8,52.58) 65.78,52.57 PR290.2 ; v1(123.54,65.02) 123.64,64.94 123.64,63.95 123.53,63.84 U1.AP77
  T03 w0.254: v3(65.8,52.58) 65.48,52.9 65.48,56.58 67.94,59.05 67.94,60.26 72.21,64.53 83.79,64.53 84.79,63.54 88.11,63.54 89.2,64.63 105.18,64.63 106.02,63.8 121.03,63.8 122.25,65.02 v1(123.54,65.02)
  BOTTOM w0.254: PR278.1 65.76,52.62 v3(65.8,52.58)
VP1P05_IMON: length 3.6
  TOP w0.254: PR268.2 69.09,56.41 69.34,56.15 69.34,56.02 v3(69.34,56.02) 69.4,55.97 PU27.13
  BOTTOM w0.254: v3(69.34,56.02) 69.6,56.28 69.6,56.63 PC339.1
VP1P05_LX_40: length 5.2
  TOP w0.381: v3(81.53,56.99) 81.46,57.06 PL8.1
  TOP w0.508: 78.49,58.69 77.83,59.35 PC328.1
  BOTTOM w0.254: v3(81.53,56.99) 82.14,56.38 PR293.1
VP1P05_MODE: length 2.1
  TOP w0.254: PR284.1 73.56,52.65 PU27.4
VP1P05_O-USR: length 9.3
  TOP w0.254: PU27.9 71.55,54.8 v3(72.9,56.15) 73.76,57.01 PR271.2
  BOTTOM w0.109: v2(76.59,55.76) 75.92,56.44 74.88,56.44 74.59,56.15 v3(72.9,56.15)
  BOTTOM w0.254: v3(72.9,56.15) 73.18,56.43 73.43,56.43 74.02,57.01 PR296.1
VP1P05_OCP-I: length 5.2
  TOP w0.254: PU27.12 69.8,55.66 70.1,55.97 v3(70.1,56.15) 70.1,57.42 69.7,57.83 69.48,57.83 PR268.1
  BOTTOM w0.254: PR275.1 70.97,57.01 70.45,56.49 v3(70.1,56.15)
VP1P5_PCH: length 17.8
  TOP w0.203: U1.AW28 125.75,41.05 125.75,41.68 U1.AW30 125.99,41.93 126.48,41.93 U1.BA30 U1.BB30 127.65,41.55 U1.BD30
  TOP w0.254: U1.W20 117.3,37.26 v1(117.39,37.36) ; U1.AG19 v1(120.63,36.57) ; U1.AK28 121.74,41.06 121.74,41.67 U1.AK30 121.38,42.22 v1(121.38,42.36) ; U1.V33 115.93,43.23 115.37,42.67 v1(115.36,42.67) 115.36,42.16 114.84,41.65 114.84,41.29 v1(114.85,41.27) ; U1.AE30 v1(119.01,42.19) ; v1(119.03,41.37) 119.43,40.97 U1.AE28
  TOP w0.305: v1(126.01,43.4) 126.11,43.3 126.11,42.84 126.63,42.31 U1.BA30
  TOP w0.381: U1.AC28 v1(118.23,41.37) U1.AC30 ; U1.W28 v1(116.33,40.99)
  BOTTOM w0.254: R182.1 118.54,40.89 119.02,41.37 v1(119.03,41.37)
  BOTTOM w0.305: R30.1 126.17,43.56 v1(126.01,43.4)
  BOTTOM w0.381: v2(116.35,36.95) 116.86,36.95 117.27,37.36 v1(117.39,37.36) 117.79,36.96 R50.2 ; v1(116.33,40.99) 116.33,40.72 116.16,40.55 116.16,40.24 R160.1
  vias: v3(48.03,72.13) v3(48.82,72.08) v3(49.61,72.1)
VP1P05_PCH: length 193.1
  TOP w0.203: U1.AK18 v1(122.23,36.57)
  TOP w0.254: U1.AM16 122.72,35.45 122.72,36.08 U1.AM18 ; v1(122.23,39.77) U1.AK25 ; U1.AG27 120.05,39.99 120.05,39.55 U1.AG25 v1(120.63,38.97) ; U1.AP27 v1(123.03,40.57) U1.AM27 122.47,40.33 122,40.33 U1.AK27 ; U1.AP25 v1(123.03,39.77) ; U1.AR27 v1(124.63,40.57) 124.68,40.57 125.03,40.21 U1.AU27 125.17,40.3 125.7,40.3 U1.AW27
  TOP w0.305: U1.AK27 121.83,40.18 v1(121.44,40.57)
  TOP w0.33: U1.AC23 v1(118.23,38.97) U1.AC25 ; U1.AK21 v1(121.43,38.17) U1.AK23 ; U1.AM25 v1(122.23,39.77) ; v1(121.43,39.77) U1.AK25 ; U1.AH23 v1(120.63,38.97) ; U1.AM23 v1(122.23,38.97) ; U1.AE21 v1(119.83,38.17) ; v1(122.23,36.57) U1.AM18 ; U1.AH21 v1(121.43,37.37) ; v1(122.23,34.97) U1.AM14
  TOP w0.381: v3(68.16,45.31) 68.27,45.31 68.9,44.68 68.9,40.35 68.58,40.02 R213.1 ; U1.AE25 119.06,38.99 119.06,38.99 v1(119.03,38.96) ; v3(39.31,67.33) 39.31,64.09 38.61,63.39 37.39,63.39 34.88,60.88 v3(34.88,59.2) ; U1.BB25 v1(127.03,39.76)
  T03 w0.254: 102,31.89 107.44,31.89 110.12,34.57 113.76,34.57 114.97,33.35 117.94,33.35 119.15,32.15 119.94,32.15 120.32,32.53 120.32,32.86 120.7,33.24 122.88,33.24 123.41,32.71 125.01,32.71 125.51,32.21 125.99,32.21 126.07,32.28 126.35,32.28 v1(126.73,32.67) 127.1,33.03 127.1,33.29 127.62,33.81 127.62,34.27 128.04,34.69 128.14,34.69 128.75,35.3 128.75,36.05 129.2,36.49 129.2,36.88 128.77,37.31 128.77,37.75 129.21,38.19 129.21,38.59 128.75,39.05 128.75,39.37 128.32,39.81 127.08,39.81 v1(127.03,39.76)
  T03 w0.381: v3(99,34.45) 99,36.55 91.39,44.16 77.65,44.16 76.81,45 71.07,45 70.41,45.66 69.19,45.66 68.84,45.31 v3(68.16,45.31)
  T08 w0.381: v1(121.43,38.17) 121.4,38.17 120.6,37.37 119.71,37.37 119.08,36.74 119.08,34.58 118.42,33.93 116.71,33.93 115.82,33.04 115.82,31.64 116.28,31.18 116.28,29.81 115.7,29.23 107.06,29.23 103.51,32.78 102.02,32.78 v3(102.02,32.78)
  T10 w0.381: v3(68.16,45.31) 68.16,45.37 66.93,46.6 66.93,48.66 65.91,49.67 64.01,49.67 62.1,51.58 60.71,51.58 59.94,50.82 51.69,50.82 51.18,50.31 44.83,50.31 44.01,51.13 40.7,51.13 38.73,53.1 38.28,53.1 35.61,55.77 35.61,58.47 v3(34.88,59.2)
  BOTTOM w0.203: U1.AK25 121.83,39.56 121.63,39.77 v1(121.43,39.77) ; v1(122.23,38.97) 122.43,38.97 122.63,38.76 U1.AM23 ; U1.AM27 122.82,40.17 123.03,40.38 v1(123.03,40.57) ; v1(126.73,32.67) 126.73,33.02 R184.1 ; U1.AC25 118.63,39.18 118.47,39.02 118.28,39.02 v1(118.23,38.97)
  BOTTOM w0.254: C80.1 124.63,41.07 v1(124.63,40.57) ; C78.1 119.99,39.61 v1(120.63,38.97) ; v1(119.83,38.17) 119.27,38.73 v1(119.03,38.96) 119.03,38.95 118.65,38.57 U1.AC23 ; C77.1 121.84,40.43 121.7,40.57 v1(121.44,40.57) 121.66,40.79 C81.1 ; U1.AK25 v1(122.23,38.97)
  BOTTOM w0.305: C59.1 123.85,40.1 123.37,40.1 v1(123.03,39.77) ; U1.AK21 v1(121.43,38.17)
  BOTTOM w0.381: v3(39.31,67.33) 39.06,67.58 R197.1
  BOTTOM w0.635: L7.1 101.84,34.81
  vias: v2(97.16,31.89) v3(98.22,34.41) v3(98.25,33.51) v3(98.26,32.67) v3(98.28,31.9) v3(99,33.56) v3(99,32.8) v3(99,31.91) v3(99,31.15) v3(99.71,34.43) v3(99.71,33.54) v3(99.71,32.78) v3(99.71,31.89) v3(99.71,31.13) v3(100.47,34.43) v3(100.47,33.54) v3(100.47,32.78) v3(100.47,31.89) v3(100.47,31.13) v3(101.24,34.43) v3(101.24,33.54) v3(101.24,32.78) v3(101.24,31.89) v3(102.03,33.55)
VP1P05_PCH_SLEWRATE: length 2
  TOP w0.254: PU24.5 88.32,31.76 88.03,31.47 87.27,31.47 PC267.1
VP1P5_PCH_SS: length 2.4
  TOP w0.254: PU6.7 48.3,65.5 49.12,64.68 PC30.1
VP1P05_PWM1: length 2.2
  TOP w0.254: PU27.6 73.35,53.45 PR280.1
VP1P05_PWM1_R: length 16.6
  TOP w0.254: PU26.12 v3(84.09,47.52) ; PR280.2 v3(75.18,53.74)
  T03 w0.254: v3(75.18,53.74) 74.42,52.98 74.42,50.31 77.47,47.26 83.83,47.26 v3(84.09,47.52)
VP1P05_SB1_20: length 1.4
  TOP w0.508: PC328.2 PR304.1
VP1P05_SKIP: length 2.5
  TOP w0.254: PR289.1 73.15,54.75 72.25,53.85 PU27.7
VP1P05_SKIP#_1_10: length 16.6
  TOP w0.254: PR289.2 v3(75.18,54.75) ; PU26.10 82.02,46.52 v3(82.04,46.5)
  T03 w0.254: v3(75.18,54.75) 73.91,53.48 73.91,50.05 77.22,46.75 81.79,46.75 v3(82.04,46.5)
VP1P05_SLEWA: length 6.2
  TOP w0.254: PR282.2 67.06,56.78 v3(67.82,56.02) 67.86,56.02 68.6,55.29 PU27.15
  BOTTOM w0.109: v2(65.51,58.13) 65.84,57.79 65.84,57.62 66.45,57.01 PR274.1
  BOTTOM w0.254: PR274.1 67.82,56.12 v3(67.82,56.02)
VP1P05_TAO: length 3.8
  TOP w0.254: PU26.11 82.52,46.86 v3(82.8,46.57)
  BOTTOM w0.109: PC336.1 81.23,47.62 v2(80.96,47.35)
  BOTTOM w0.254: v3(82.8,46.57) 82.42,46.96 PC336.1
VP1P05_THERM: length 4.8
  TOP w0.254: PNTC7.2 68.08,56.53 v3(68.58,56.02) 69,55.61 PU27.14
  BOTTOM w0.254: v3(68.58,56.02) 68.96,56.4 PC332.1 PR300.1
VP1P05_V5A_10: length 6
  TOP w0.254: PU27.28 69.4,49.44 v3(69.52,49.32)
  BOTTOM w0.109: v2(70.51,48.52) 70.45,48.58 PR297.2
  BOTTOM w0.254: PR297.2 68.83,49.77 PC348.1 69.52,49.85 v3(69.52,49.32)
VP1P05_VCLK: length 2.8
  TOP w0.254: PR108.2 70.87,49.06 70.87,49.55 70.6,49.82 PU27.31
VP1P05_VDD: length 4.6
  TOP w0.109: v3(72.52,51.71) 72.37,51.85 PU27.2
  BOTTOM w0.109: v3(72.52,51.71) 73.33,51.71 v2(73.8,51.23)
  BOTTOM w0.254: PR295.2 72.52,52.77 v3(72.52,51.71) 72.54,51.68 PC347.1
VP1P05_VDIO: length 3.3
  TOP w0.254: PR107.2 72.26,49.23 v3(72.24,49.26) 72.26,49.28 72.26,50.18 71.55,50.89 PU27.1
VP1P05_VIN:
  vias: v3(73.61,45.99) v3(74.27,45.63) v3(77.86,46.13) v3(78.74,45.74)
VP1P05_VIN_10: length 4.5
  TOP w0.109: PR279.2 64.91,56.61 v3(64.59,56.93)
  TOP w0.254: PR279.2 66.35,55.92 66.85,55.92 67.97,54.8 PU27.16
VP1P05_VR_ON: length 5.5
  TOP w0.109: v3(75.21,57.95) 74.85,57.59 74.85,57.12 73.63,55.91 PR281.2
  TOP w0.254: PR281.2 73.51,55.77 71.99,54.25 PU27.8
VP1P05_VREF_10: length 12.4
  TOP w0.254: PR298.2 67.94,49.04 v3(68.05,49.14) 69,50.09 PU27.27
  TOP w0.381: PR282.1 PNTC7.1 68.68,58.44 70.36,58.44 70.74,58.06 PR303.1 PR305.1 ; PR305.1 PR292.1 PR271.1 ; PR305.1 71.75,58.56 71.7,58.61 v3(71.7,58.94)
  BOTTOM w0.254: PC329.1 68.07,49.17 v3(68.05,49.14)
VP1P05_VRHOT_L: length 3.1
  TOP w0.254: PU27.30 70.2,49.68 70.23,49.65 TP12.1 70.23,49.17 69.49,48.43 PR302.2
VP1P05_VSNS: length 75.5
  TOP w0.254: v1(123.59,65.81) 123.74,65.81 124.01,65.53 124.01,64.35 U1.AR78 ; v3(65.02,50.44) 64.9,50.31 64.01,50.31 63.7,50 PR286.1
  T03 w0.254: v3(65.02,50.44) 65.1,50.51 65.1,56.74 67.56,59.2 67.56,60.42 72.05,64.91 83.95,64.91 84.94,63.92 87.95,63.92 89.05,65.01 105.34,65.01 106.18,64.18 120.87,64.18 122.1,65.4 123.19,65.4 v1(123.59,65.81)
  BOTTOM w0.254: PR272.2 65.43,50.44 v3(65.02,50.44)
VP1P7: length 18.7
  TOP w0.254: U1.AA55 117.92,52.75 117.92,52.11 U1.AA53 v1(118.23,51.63) 118.28,51.59 118.99,51.59 U1.AE53
  TOP w0.305: U1.AE55 v1(119.03,52.43) U1.AE53
  TOP w0.381: PR42.1 v3(24.16,82.31)
  BOTTOM w0.381: v6(32.92,75.18) 27.81,75.18 24.16,78.83 v3(24.16,82.31)
  vias: v3(42.32,72) v3(42.37,71.16) v3(43.05,72.03) v3(43.81,72.05) v3(60.71,77.11) v3(60.71,76.34) v6(34.42,79.65) v6(34.42,78.12) v6(34.4,76.55) v6(34.45,75.18)
VP1P7_BOOT: length 2.3
  TOP w0.305: PU14.13 28.85,89.64 v3(29.09,89.88)
  TOP w0.381: PR267.1 29.29,90.08 v3(29.09,89.88)
VP1P7_COMP: length 3
  TOP w0.381: PU14.7 28.35,84.81 28.44,84.73 v3(28.44,84.69) 28.44,84.61 28.31,84.49 28.31,83.92 PR31.1 PC67.1
VP1P7_COMP_RC: length 1.1
  TOP w0.381: PC115.1 28.27,82.21 PR31.2
VP1P7_FB: length 4.6
  TOP w0.381: PC113.2 PR35.2 PR34.1 26.5,84.2 27,84.7 v3(27.03,84.7) 27.29,84.7 27.85,85.26 PU14.6
VP1P7_RT: length 2.6
  TOP w0.381: PR32.1 29.16,84.07 v3(29.71,84.62) 29.71,84.69 28.85,85.54 PU14.8
VP1P7_SNS: length 2.7
  TOP w0.381: PR42.2 25.61,81.39 PR35.1 PC113.1
VP1P7_SS: length 4.4
  TOP w0.381: PU14.9 29.57,86.64 30.49,86.64 30.87,86.26 v3(30.87,85.63) 30.87,84.4 30.35,83.88 PC114.1
VP1P7_SW: length 4.4
  TOP w0.381: PL16.1 32.7,87.14 PU14.10
  vias: v3(31.17,88.26)
VP1P7_VIN: length 3.4
  TOP w0.381: v3(24.03,88.61) 24.26,88.84 PU14.16
VP1P8_CPU_VCCIN: length 15.1
  TOP w0.254: v1(127.49,61.83) 127.78,62.12 U1.BD74 U1.BD76 U1.BD78 ; U1.BD36 128.03,44.97 U1.BD37 ; U1.BH37 129.84,45.26 v1(129.84,45.46) ; U1.AG55 U1.AG53 120.23,51.89 121.28,50.85 122.93,50.85
  TOP w0.381: PL13.2 v3(113.81,80.41) ; PL10.2 v3(113.81,89.55)
  BOTTOM w0.381: v3(113.81,89.55) 113.94,89.42 PR121.1 ; PR137.1 126.18,64.9 v1(126.18,66.49) ; PR128.1 113.94,80.28 v3(113.81,80.41)
  vias: v1(124.61,50.72) v1(124.63,50.01) v1(124.63,49.35) v1(124.63,48.08) v1(124.66,48.71) v1(124.66,47.42) v1(124.66,46.76) v1(124.66,46.07) v1(124.68,45.32) v1(125.4,45.31) v1(125.4,44.67) v1(125.48,53.23) v1(125.76,56.72) v1(125.76,55) v1(126.06,45.31) v1(126.25,61.01) v1(126.25,59.29) v1(126.25,57.58) v1(126.25,55.86) v1(126.5,61.83) v1(126.75,60.15) v1(126.75,58.44) v1(126.75,56.72) v1(126.75,55) v1(126.84,45.28) v1(127.05,53.16) v1(127.24,61.01) v1(127.24,59.29) v1(127.24,57.58) v1(127.24,55.86) v1(127.48,45.28) v1(127.74,60.15) v1(127.74,58.44) v1(127.74,56.72) v1(127.74,55) v1(127.83,53.16) v1(128.23,59.29) v1(128.23,57.58) v1(128.23,55.86) v1(128.23,54.17) v1(128.34,52.57) v1(128.39,51.86) v1(128.39,51.18) v1(128.42,50.54) v1(128.42,49.91) v1(128.42,49.27) v1(128.42,48.64) v1(128.42,48) v1(128.42,47.37) v1(128.42,46.73) v1(128.42,46.1) v1(128.39,45.46) v1(128.73,55) v1(129.1,45.46) v1(129.22,55.86) v1(129.72,55) v2(124.68,52.29) v2(125.22,54.17) v6(117.36,89.42) v6(117.36,88.03) v6(117.36,86.63) v6(117.36,85.23) v6(117.36,83.84) v6(117.36,82.44) v6(117.36,81.04) v6(117.36,79.64) v6(117.36,78.25) v6(117.36,76.85) v6(118.25,75.45) v6(118.76,89.42) v6(118.76,88.03) v6(118.76,86.63) v6(118.76,85.23) v6(118.76,83.84) v6(118.76,82.44) v6(118.76,81.04) v6(118.76,79.64) v6(118.76,78.25) v6(118.76,76.85) v6(119.65,75.45) v6(120.16,89.42) v6(120.16,88.03) v6(120.16,86.63) v6(120.16,85.23) v6(120.16,83.84) v6(120.16,82.44) v6(120.16,81.04) v6(120.16,79.64) v6(120.16,78.25) v6(120.16,76.85) v6(120.67,74.06) v6(121.05,75.45) v6(121.56,89.42) v6(121.56,88.03) v6(121.56,86.63) v6(121.56,85.23) v6(121.56,83.84) v6(121.56,82.44) v6(121.56,81.04) v6(121.56,79.64) v6(121.56,78.25) v6(121.56,76.85) v6(121.81,72.66) v6(122.06,74.06) v6(122.44,75.45) v6(123.21,72.66) v6(123.46,74.06) v6(123.84,75.45) v6(124.59,72.03) v6(125.09,74.06) v6(126.11,72.53) v6(126.11,70.76) v6(126.51,73.93)
VP2P5: length 1.1
  BOTTOM w0.381: v2(47.12,41.28) R365.2
VP2P5_DDR4_VPP: length 15.9
  TOP w0.381: R231.1 188.94,61.5 v3(188.94,62.27) ; R120.2 R118.1 v3(143.27,91.71) ; v3(159.08,83.43) 159.83,82.69 R235.1 R236.1 ; v3(139.4,89.95) 140.02,89.95 C30.1 140.27,89.99 U7.8 ; R121.2 v3(141.24,91.71) ; R237.1 159.69,84.24 v3(159.59,84.24)
  BOTTOM w0.381: R359.2 193.47,13.07 v3(193.39,13.16) ; v3(195.96,11.83) 195.96,11.93 U32.1 ; v3(201.14,13.33) 201.1,13.38 C156.1 200.38,13.35 199.64,13.35 199.52,13.22 U32.5 ; R230.1 v3(190.85,84.72) ; R229.1 v3(190.87,79.77)
  vias: v3(175.26,88.66) v3(176.02,88.66) v3(176.59,89.43) v3(176.91,88.79) v6(176.4,87.77)
VP2P5_DDR4_VPP_BST: length 3.7
  TOP w0.381: PU20.8 152.82,84.42 153.28,83.96 153.28,82.68 153.92,82.04 PR80.1
VP2P5_DDR4_VPP_BST_RC: length 1.4
  TOP w0.381: PC137.1 PR80.2
VP2P5_DDR4_VPP_FB: length 12.9
  TOP w0.381: PU20.6 151.05,83.06 v7(151.02,83.03) PR207.1 PR260.1 151.14,80.77 PR206.2
  BOTTOM w0.381: PC312.2 156.46,84.82 156.46,83.01 155.72,82.27 151.77,82.27 v7(151.02,83.03)
VP2P5_DDR4_VPP_FB_IN: length 0.9
  TOP w0.381: PR204.2 PR206.1
VP2P5_DDR4_VPP_L_RC: length 3.9
  BOTTOM w0.381: PR261.2 156.09,86.11 PC312.1 ; PR261.2 156.14,87.08 PC313.2 ; PR261.2 156.09,88.1 v2(155.53,88.67)
VP2P5_DDR4_VPP_SN: length 4.4
  BOTTOM w0.381: PR205.2 152.67,88.37 PC140.1 154.57,89.87 v2(155.21,90.51)
VP2P5_DDR4_VPP_SS: length 2.2
  TOP w0.381: PU20.5 149.75,84.42 v7(149.56,84.62)
  BOTTOM w0.381: PC316.1 149.84,84.9 v7(149.56,84.62)
VP2P5_DDR4_VPP_SW: length 13.1
  TOP w0.381: v3(153.75,85.63) 153.62,85.51 151.84,85.51 151.7,85.65 PU20.2 ; v3(153.75,85.63) 153.73,85.65 152.08,85.65 ; v3(153.75,85.63) 154.33,85.05 PC137.2
  BOTTOM w0.381: v3(153.75,85.63) 153.75,86.14 154.64,87.04 PR261.1 ; v3(153.75,85.63) 152.91,85.63 152.66,85.89 PR205.1 ; v3(153.75,85.63) 153.75,84.37 v2(153.72,84.34)
VP2P5_DDR4_VPP_VIN: length 1.2
  TOP w0.381: PU20.3 151.05,88.21
VP2P5_DDR4_VPP_VOUT: length 9.5
  TOP w0.381: 157.81,84.67 157.55,84.67 156.8,83.92 156.8,81.34 156.34,80.88 156.23,80.77 PR204.1
  BOTTOM w0.381: PC313.1 v3(157.9,85.63)
  vias: v3(164.97,87.9) v3(165.94,87.92) v3(166.83,87.92) v3(167.72,87.92)
VP3P3: length 471.2
  TOP w0.254: v3(78.51,79.47) 78.51,78.63 78.85,78.29 PU17.21 ; U1.AR14 124.23,34.58 v1(123.84,34.97) 123.84,34.97 123.45,35.37 U1.AP16 ; PU21.21 195.83,26.02 v3(195.5,25.7) 195.43,25.77 PU21.20 ; PU27.21 66.72,52.65 66.63,52.55 v3(66.62,52.55) 66.62,52.55 66.62,52.79 66.88,53.05 PU27.20
  TOP w0.305: U1.AR30 v1(123.83,42.17) ; v3(188.07,9.55) 187.97,9.45 U25.14 ; U25.8 v3(191.18,8.53) ; v3(192.02,3.95) 191.62,4.36 U25.1 ; U35.1 46.25,29.51 C124.1 ; v3(27.17,47.13) 27.47,47.43 PC307.1 27.91,48.31 27.51,48.71 U26.8 ; U25.22 185.69,5.36 185.37,5.05 v3(185.37,4.61)
  TOP w0.33: U1.AW18 v1(125.43,36.57) ; U1.AP12 123.8,33.4 v1(123.8,33.32) ; U1.AU18 v1(124.63,36.57) ; U1.AR16 v1(123.83,35.77) ; U1.AR28 v1(123.83,41.37) ; U1.AW23 v1(125.44,38.96)
  TOP w0.381: PR11.1 v3(41.94,68.2) ; PU24.3 87.19,32.76 PC264.1 86.76,32.68 v3(86.76,33.45) ; PR135.1 77.93,70.21 77.56,69.85 v3(77.56,69.38) ; R384.1 R385.1 43.18,56.28 v3(42.77,55.86) ; U12.5 72.81,26.04 C157.1 72.82,25.49 72.56,25.23 70.94,25.23 v3(70.76,25.41) 70.25,25.92 R101.1 ; PR242.1 v3(50.41,77.92) ; v3(27.31,92.39) 27.13,92.21 PR33.1 ; C124.1 v3(48.13,29.51) ; R382.2 57.48,59.35 R381.2 57.55,59.37 v3(58.17,59.99) ; U31.A3 v1(58.13,47.28) ; v3(45.59,51.83) 45.7,51.93 R438.1 ; U31.J11 v1(49.15,38.3) ; U18.5 32.9,44.47 C116.1 32.76,44.13 32.48,43.85 v3(31.21,43.85) ; U9.6 84.96,19.12 84.92,19.08 84.19,19.08 C152.1 v3(83.05,19.06) ; v3(85.09,64.58) 85.02,64.66 U2.5 ; Y4.4 v3(30.78,40.75) C118.1 ; v3(196.44,35.98) 196.44,35.25 PR195.1 ; U14.16 37.03,69.72 v3(37.05,69.74) C130.1 ; U34.6 36.85,56.66 C44.1 v3(36.72,55.71) ; PR21.1 v3(45.84,77.28) ; R68.1 126.91,7.63 127.64,6.9 v3(127.97,6.9) ; R162.1 v3(131.03,16.04) ; v3(59.82,58.82) 59.27,59.37 R380.2 ; v3(54.61,59.96) 54.61,59.83 54.99,59.45 R383.2 54.93,59.29 54.63,59.29 54.58,59.24 54.32,59.24 54.16,59.07 53.32,59.07 ; U19.5 66.51,41.56 66.77,41.82 67.18,41.82 C158.1 67.56,42.2 v3(68.02,42.2) ; v3(85.47,30.36) 85.47,30.35 85.55,30.27 PR26.1 ; U31.L9 v1(47.15,40.3) ; U31.T3 v1(41.88,46.79) ; v3(69.85,72) 70.33,72.49 C200.1 69.69,72.91 69.16,73.44 U27.8 ; v3(44.2,51.71) 43.66,52.24 R437.1 43.66,52.7 C164.1 ; v3(33.75,41.67) 33.75,41.67 33.78,41.67 33.72,41.74 33.72,41.99 33.5,42.21 33.5,42.56 ; v3(69.9,69.31) 70.48,69.89 R322.1 ; U31.H11 v1(51.13,38.3) ; R159.1 v3(134.08,16.04) ; v3(61.5,47.91) 61.5,47.91 62.03,47.38 C160.1 ; PR252.1 v3(39.7,80.05) ; R386.1 v3(35.04,57.55) ; v3(127.98,12.23) R74.1 R396.2 ; U31.F9 v1(53.13,40.3) ; U13.1 73.95,31.47 73.39,32.02 C131.1 v3(69.98,32.02) ; R368.1 v3(20.57,11.64) ; U31.P16 v1(44.15,33.3) ; v1(55.59,49.39) 55.64,49.34 U31.C1 ; R155.1 v3(22.45,68.23) ; R351.1 v3(184.43,11.34) ; v3(24.26,20.38) 24.26,20.92 23.72,21.46 J8.4 ; U4.1 71.82,68.39 C24.2 71.6,70.14 v3(71.09,69.63) ; U33.5 v3(54.44,28.48) ; R445.1 33.99,47.23 R315.1 33.9,46.67 v3(33.62,46.39) ; PR139.1 76.1,69.51 76.1,69.13 v3(76.11,69.12) ; R360.1 v3(36.16,49.29) ; C161.1 37.59,35.6 C165.1 40.72,36.72 40.9,36.54 v1(42.15,35.3) U31.T14 ; U31.A14 57.64,35.82 v1(57.23,36.23) ; R158.1 v3(129.51,12.23) ; v3(71.3,38.01) C209.1 69.19,38.01 68.79,37.61 U10.1 ; R450.1 49.08,55.41 49.33,55.16 49.54,55.16 49.55,55.15 v3(49.62,55.15) 50.36,55.15 R326.1 ; R327.1 50.43,56.42 50.04,56.8 49.75,56.8 v3(49.74,56.82) 49.6,56.68 49.01,56.68 49.01,57.61 48.89,57.74 U28.5 ; PR277.1 75.05,51.83 v3(75.23,51.65) ; PR191.1 180.42,90.25 v3(180.43,90.23) C32.1 181.98,90.23 182.85,91.09 PU11.10 ; v3(52.29,57.69) 51.76,58.22 U29.5 ; R76.1 v3(127.98,16.04) ; R398.1 20.63,66.46 v3(20.97,66.46) ; R161.1 v3(132.56,12.23) ; v1(55.85,33.18) 55.85,33.58 U31.C16 ; U31.H6 v1(51.13,44.28) ; U2.1 82.16,66.56 C19.2 82.02,66.71 v3(81.15,66.71) ; U31.J6 v1(49.15,44.28) ; R395.2 v3(182.12,6.75) ; R210.1 59.05,44.59 v3(58.93,44.47) ; U35.5 v3(44.07,26.44) ; v3(47.12,19.55) 46.89,19.32 46.05,19.32 45.56,18.83 J1.9 ; R62.1 v3(139.92,16.01) ; R165.1 v3(129.51,16.04) ; R99.1 v3(127.98,2.57) ; U31.P1 v1(44.15,49.28) ; R63.1 v3(132.56,2.57) ; U31.L8 v1(47.15,42.28) ; PR13.1 54.42,77.53 54.05,77.9 54.01,77.9 53.93,77.98 52.28,77.98 v3(52.12,78.14) ; R164.1 v3(131.03,12.23) ; v3(36.9,37.58) 36.89,37.58 36.87,37.56 36.63,37.56 36.07,38.13 R361.1 ; PR302.1 v3(68.08,46.49) ; R163.1 v3(132.56,16.04) ; R444.1 v3(38.61,52.21) ; U31.F8 v1(53.13,42.28) ; D7.2 v3(161.92,12.13)
  T03 w0.381: v3(103.91,58.97) 103.91,57.95 105.41,56.45 107.9,56.45 109.65,54.7 109.65,48.73 111.1,47.29 v1(111.4,47.29)
  T05 w0.381: v3(197.97,36.02) 198.05,36.1 198.71,36.1 199.84,37.23 200.36,37.75 200.36,47.31 201.74,48.69 201.74,57.55 199.85,59.44 199.85,62.25 206.08,68.48 206.08,68.49 206.83,69.25 206.83,77.14 195.42,88.55 182.11,88.55 v3(180.43,90.23) 180.42,90.24 180.42,91.63 178.54,93.51 172.3,93.51 169.31,90.52 152.93,90.52 v3(151.72,91.73)
  T08 w0.381: v3(39.7,80.05) 37.19,82.56 37.19,89 33.93,92.26 27.43,92.26 v3(27.31,92.39) ; v3(55.8,82.85) 55.8,80.89 53.94,79.03 49.36,79.03 47.61,77.28 v3(45.84,77.28)
  T10 w0.381: v3(99.16,64) 99.16,63.9 100.23,62.83 100.23,60.42 101.22,59.43 103.45,59.43 v3(103.91,58.97)
  BOTTOM w0.108: v1(125.43,36.57) 125.83,36.17 127.19,36.17 127.47,36.44 R89.1
  BOTTOM w0.203: R82.1 124.43,32.69 v1(123.8,33.32)
  BOTTOM w0.254: v1(123.8,33.32) 123.6,33.32 123.43,33.49 C43.1 ; U36.4 110.22,47.12 110.21,47.13 110.69,47.13 110.85,47.29 v1(111.4,47.29) ; R79.1 128.53,36.11 128.2,36.44 R89.1 ; U5.8 91.33,25.88 92.03,25.18 C120.1
  BOTTOM w0.305: 123.71,36.63 C153.1 123.71,35.89 v1(123.83,35.77) ; C120.1 93.15,24.8 v3(93.57,24.37) ; 186.92,12.59 187.17,12.59 C134.1 ; C41.1 123.8,42.21 v1(123.83,42.17) ; R214.1 188.24,9.72 v3(188.07,9.55) ; v3(43.94,63.09) 44.85,62.18 U30.24
  BOTTOM w0.381: v3(75.23,51.65) 75.02,51.86 74.96,51.86 PR295.1 ; R392.1 69.97,69.38 v3(69.9,69.31) ; v3(29.72,21.1) 29.72,20.77 30.96,19.52 32.84,19.52 R306.1 R307.1 ; v3(41.67,59.32) 42.2,59.32 R335.1 ; v3(79.38,24.65) v2(80.63,23.4) 81.09,22.94 D8.2 ; v3(127.03,21.71) 127.17,21.58 R60.1 ; R5.2 68.65,65.06 v3(68.42,65.06) ; R156.1 138.66,13.77 v3(139.39,13.05) 139.47,12.96 R297.1 ; R162.1 v3(131.03,16.04) ; v3(127.98,12.23) 127.2,12.23 R396.2 ; v3(151.72,91.73) 151.72,91.6 150.98,90.87 PR79.1 ; C22.1 43.93,63.1 v3(43.94,63.09) ; v1(53.13,42.28) 52.73,41.88 C169.1 ; 71.82,69.35 C24.2 ; 71.82,69.35 71.82,67.54 U3.8 ; 71.82,69.35 71.39,68.92 v3(71.09,68.92) ; R388.1 v3(68.29,80.08) ; R313.1 36.8,19.45 v3(36.8,19.83) ; R366.1 26.39,17.73 v3(24.96,16.31) ; C108.1 191.39,4.44 191.87,3.95 v3(192.02,3.95) ; v1(43.15,42.31) 42.8,42.66 R432.2 ; R161.1 v3(132.56,12.23) ; v3(55.21,62.52) 55.21,62.14 54.96,61.88 R334.1 ; C28.1 v3(47.12,19.55) ; v3(10.38,60.36) 9.24,60.36 8.35,61.25 5.3,61.25 2.76,63.79 2.76,68.99 3.52,69.76 R397.1 ; v3(75.18,39.28) 75.69,39.28 R341.1 ; C162.1 49.41,38.03 v1(49.15,38.3) ; PC80.1 191.11,8.59 v3(191.18,8.53) ; PR203.1 v3(197.97,36.02) ; R364.2 50.56,38.87 v1(51.13,38.3) 51.15,38.28 C168.1 ; R434.2 44.55,39.74 v1(44.12,39.31) 43.94,39.49 R436.2 ; U8.1 73.4,26.9 C103.1 72.87,28.11 73.52,28.75 v3(73.56,28.75) 73.63,28.75 74.18,28.2 U8.3 ; v1(51.13,44.28) 51.09,44.24 C170.1 ; PR209.1 76.48,77.67 77.18,78.37 78.87,78.37 PR155.1 78.87,78.86 78.51,79.21 v3(78.51,79.47) ; R424.2 61.11,47.52 v3(61.5,47.91) ; U32.6 198.62,10.7 C132.1 198.6,9.84 v3(198.57,9.81) ; v3(85.09,64.58) 84.8,64.3 R6.2 ; v1(47.15,40.3) 47.39,40.05 C163.1 ; C134.1 187.32,12.34 186.69,11.7 186.69,11.6 186.06,10.96 U21.5 ; R428.2 49.89,45.02 v1(49.15,44.28) 49.05,44.19 C166.1 ; C102.1 186.36,5.6 v3(185.37,4.61) ; v3(66.47,27.27) 67.82,25.92 R349.1 R348.1 ; v3(70.67,82.11) R393.1 69.97,82.15 R394.1 ; PR210.1 201.91,28.61 203.15,28.61 v3(203.79,29.25) ; R339.1 43.95,24.8 v3(42.64,24.8) 42.19,24.35 R340.1 ; v3(188.07,9.55) 187.93,9.41 C107.1 ; R4.2 81.6,66.71 v3(81.15,66.71) ; U20.20 180.94,3.57 180.96,3.54 181.43,3.54 181.45,3.52 C133.1 v3(182.88,3.52) ; v3(58.93,44.47) 58.7,44.24 R426.2 ; R165.1 v3(129.51,16.04) ; R157.1 v3(134.08,12.23) ; v1(53.13,40.3) 53.31,40.12 R430.2 ; 186.92,12.59 v3(186.69,12.59) ; v3(27.81,64.56) C121.1 27.93,65.18 U11.1 ; C167.1 46.55,42.73 47,42.28 v1(47.15,42.28) ; D2.2 193.94,38.93 v3(193.58,38.58) ; v3(167.76,9.2) 167.79,9.23 C154.1 167.84,10 U22.5 ; R316.2 v3(194.92,8.63) ; R331.1 54.4,59.87 54.48,59.96 v3(54.61,59.96) ; v3(30.05,23.08) 29.13,23.08 R367.1 ; R159.1 v3(134.08,16.04)
  vias: v3(25.25,21.33) v3(28.93,21.28) v3(39.85,71.29) v3(40.56,71.49) v3(40.97,70.83) v3(41.15,72) v3(54.99,87.52) v3(55.5,86.88) v3(60.07,32.15) v3(60.07,31.26) v3(64.54,53.84) v3(125.7,17.69) v3(127.22,20.99) v3(142.62,5.35) v3(143.51,5.35) v3(144.4,5.35) v3(188.34,13.22) v5(40.4,77.28) v5(41.54,77.28)
VP3P3_A: length 250.7
  TOP w0.203: U1.AU12 125.03,33.77 v1(124.63,34.17)
  TOP w0.305: U1.AG14 U1.AH14 121.03,34.56 121.41,34.18 121.42,34.18 v1(121.43,34.17) ; U1.AE12 119.43,33.72 v1(119.82,33.34) ; U1.AE18 119.32,36.06 119.32,35.47 U1.AE16 v1(119.83,34.97) ; C126.1 46.61,25.67 46.22,26.06 U35.8
  TOP w0.33: U1.AW25 125.44,39.75 v1(125.44,39.77) ; U1.AG30 119.73,42.27 v1(119.73,42.46) ; U1.AG18 v1(119.83,36.57) ; U1.AM12 v1(122.23,34.17) ; U1.AC14 v1(118.23,34.97) ; U1.AC19 v1(118.23,36.57) ; U1.AG28 v1(119.83,41.37)
  TOP w0.381: 63.85,43.32 63.86,43.32 63.87,43.31 64.77,43.31 65.5,42.58 66.86,42.58 67.16,42.88 R177.1 ; 63.85,43.32 C210.1 62.74,43.62 63.17,43.93 64.26,43.93 64.44,44.11 64.46,44.11 64.67,44.32 64.67,44.34 64.74,44.42 64.74,45.25 v3(64.36,45.64) ; 63.85,43.32 U17.5 ; R33.1 v3(134.08,2.57) ; v3(139.9,2.6) 139.9,2.62 139.21,3.31 R439.1 R36.1 ; R34.1 v3(141.7,12.1) ; R332.1 49.02,61.65 49.37,62.01 50.27,62.01 R333.1 50.28,62.27 50.35,62.33 50.35,62.35 50.46,62.46 50.48,62.46 52.04,64.02 v3(52.04,64.8) ; R29.1 v3(144.62,14.13) ; v3(95.83,71.85) 95.83,71.03 95.45,70.65 R207.1 ; U16.6 91.4,71.53 91.72,71.85 C205.1 92.73,71.85 v3(93.07,72.18) ; R442.1 R289.1 v3(138.65,6.89) ; PR73.1 39.48,81.32 37.2,79.04 v3(37.08,79.04) ; U15.16 36.89,32.13 C129.1 v3(36.93,32.92) ; v3(94.49,20.84) 94.49,19.54 R150.1 ; R204.1 v3(36.93,26.94) 36.93,26.94 38.74,26.94 39.93,28.13 41.85,28.13 43.31,26.68 43.31,26.22 44.59,24.93 C126.1 ; R31.1 v3(147.54,12.1) ; R35.1 v3(143.22,12.1) ; U1.AW25 v1(126.24,39.77) U1.BA25 ; R440.1 v3(129.51,2.57) ; R441.1 v3(131.03,6.89)
  T03 w0.381: v3(93.07,72.18) 93.27,72.38 95.3,72.38 v3(95.83,71.85)
  T05 w0.381: v3(31.18,24.87) 28.86,27.2 28.86,32.93 27.46,34.32 27.46,42.89 29.97,45.4 29.97,56.01 34.69,60.74 44.94,60.74 46.96,62.76 49.99,62.76 v3(52.04,64.8) ; v3(64.36,45.64) 63.5,46.5 63.5,51.2 63.05,51.65 63.05,57.88 58.73,62.2 58.73,62.81 58.01,63.53 55.98,63.53 v3(54.7,64.8)
  T10 w0.381: v3(54.7,64.8) 58.13,64.8 64.51,71.18 64.51,77.99 70.53,84.01 82.01,84.01 83.58,82.43 83.58,76.94 86.76,73.77 88.97,73.77 90.59,72.15 93.04,72.15 v3(93.07,72.18)
  BOTTOM w0.203: v1(124.63,34.17) 125.27,33.52 R77.1
  BOTTOM w0.254: C50.1 v1(118.23,36.57) ; v1(119.73,42.46) 119.53,42.26 C46.1 119.53,41.58 119.75,41.37 v1(119.83,41.37) ; R67.1 127.55,42.72 126.97,42.13 R70.1 ; R65.1 125.65,41.44 125.23,41.86 R80.1 ; v1(121.43,34.17) 121.42,34.18 120.56,34.18 C128.1
  BOTTOM w0.305: R65.1 125.34,41.32 125.17,41.15 125.17,40.03 v1(125.44,39.77) ; v1(118.23,34.97) 118.23,34.36 C48.1 ; v1(128.01,42.13) 127.78,42.36 R67.1 ; R91.1 127.34,39.06 126.31,39.06
  BOTTOM w0.356: U1.AE16 v1(119.83,34.97) ; U1.AG18 v1(119.83,36.57) ; C47.1 119.79,33.37 v1(119.82,33.34) ; v1(126.24,39.77) 126.31,39.7 C53.1 126.31,39.06
  BOTTOM w0.381: R296.1 R243.1 v3(135.6,6.89) ; v3(131.03,6.89) 130.3,7.63 R240.1 R98.1 ; R298.1 134.82,3.31 v3(134.08,2.57) ; v3(118.76,16.61) 119.73,17.58 R242.1 ; v1(128.01,42.13) 128.01,41.41 128.62,40.8 R73.1 128.64,40.45 129.75,40.45 R75.1 ; R241.1 v3(138.65,16.04) 138.25,16.04 137.51,16.77 R248.1 R249.1 ; v3(36.93,32.92) v3(36.93,26.94) 36.52,26.53 32.84,26.53 v3(31.18,24.87) 31.73,24.33 R338.1
  vias: v3(36.22,78.27) v3(36.3,79.06) v3(36.93,78.27) v3(52.93,64.8) v3(53.82,64.8) v3(132.56,6.89)
VP3P3_A_BLEED: length 4.7
  TOP w0.381: v3(42.91,81.39) 41.74,81.39 PR73.2 41.66,80.9 42.03,80.53 42.03,78.94 41.72,78.63 PU25.5
VP3P3_BAT: length 209.8
  TOP w0.33: U1.AW14 v1(125.44,34.96)
  TOP w0.381: R129.1 v3(197.61,14.62)
  T05 w0.381: v3(188.98,41.55) 189.23,41.55 190.4,40.37 190.4,8.49 191.13,7.76 191.13,4.84 190.12,3.83 190.12,1.81 ; 190.12,1.81 156.27,1.81 153.03,5.05 153.03,7.41 140.24,20.21 137.09,20.21 134.49,22.8 134.49,25.82 132.69,27.62 128.7,27.62 127.75,26.67 124.29,26.67 v1(124.11,26.86) 121.45,26.86 119.35,24.76 115.95,24.76 115.58,25.12 112.01,25.12 111.77,24.87 110.12,24.87 109.24,25.75 109.24,26.28 108.46,27.06 106.1,27.06 105.81,26.77 94.66,26.77 92.86,24.97 v3(92.86,24.1) ; 190.12,1.81 197.63,1.81 v3(198.63,2.81) 200.1,4.28 200.1,12.13 v3(197.61,14.62)
  T10 w0.305: v1(124.11,26.86) 123.92,26.86 123.37,27.41 123.37,29.86 124.04,30.52 124.04,30.82 124.75,31.54 124.75,32.64 125.44,33.32 v1(125.44,34.96)
  BOTTOM w0.381: v3(92.86,24.1) 90.88,22.11 C34.1 89.92,21.99 v2(86.92,21.99) D8.3 ; v3(188.98,41.55) 189.48,41.55 189.99,41.04 C104.1 193.8,41.04 194.23,41.47 D2.3 ; v1(124.11,26.86) 123.87,26.86 123.23,27.49 R273.1 R271.1 R78.1 ; R130.1 v3(198.63,2.81)
VP3P3_BAT_SOURCE: length 21.3
  T08 w0.508: BAT1.P3 205.75,38.03 196.55,38.03 v3(196.47,38.12)
  BOTTOM w0.381: v3(196.47,38.12) 196.47,38.04 196.95,37.56 R133.2
  BOTTOM w0.508: BAT1.P3 BAT1.P1
VP3P3_BST: length 3
  TOP w0.381: PU2.7 47.83,87.65 47.44,88.04 v3(47.44,88.21) 48.01,88.78 PR23.1
VP3P3_BSTR: length 2.6
  TOP w0.381: PR23.2 46.64,90.82 PC19.1 46.66,91.25 v6(46.19,91.72)
VP3P3_SF100: length 21.1
  TOP w0.381: D7.1 v3(166.12,12.13) ; v3(170.15,3.46) 171.07,3.46 171.47,3.86 J6.1
  T05 w0.381: v3(170.15,3.46) 170.15,3.61 170.43,3.9 170.43,4.59 171.08,5.24 171.08,6.6 173.36,8.88 173.36,12.36 172.3,13.43 167.41,13.43 v3(166.12,12.13)
VP3P3_SNUBBER: length 3.3
  BOTTOM w0.381: v2(51.21,92.57) 51.13,92.5 PC21.2 52.89,91.12 PR25.1
VP3P3_SPI: length 33.4
  TOP w0.381: R225.1 v3(168.67,7.74) ; v3(168.62,4.18) 168.4,4.41 R228.1 ; U23.8 v3(156.43,4.22) 156.35,4.31 155.6,4.31 C135.1 ; D7.3 v3(165.29,10.29)
  T05 w0.381: v3(156.43,4.22) 157.07,4.22 157.96,3.34 v3(166.82,3.34) 166.98,3.49 166.98,3.75 167.41,4.18 v3(168.62,4.18) 168.62,4.59 168.1,5.12 168.1,7.17 v3(168.67,7.74) 167.3,7.74 165.29,9.74 v3(165.29,10.29)
  BOTTOM w0.381: R227.1 C135.1 156.41,4.25 v3(156.43,4.22) ; v3(166.82,3.34) 166.95,3.46 C136.1 166.56,4.4 166.49,4.33 U24.8 ; v3(168.67,7.74) 168.5,7.91 v2(167.67,7.91)
VP3P3_SW: length 4.5
  TOP w0.381: PC19.2 PL2.1
  BOTTOM w0.381: PC21.1 51.13,89.44 v3(50.63,88.94)
VP3P3_VBAT_IN: length 4.3
  BOTTOM w0.109: R309.2 85.52,19.5 v2(85.75,19.27)
  BOTTOM w0.381: R309.2 84.07,20.71 83.75,21.04 D8.1
VP3P3_VFB: length 7.7
  TOP w0.381: PU2.2 47.83,80.46 48.21,80.08 PR22.2 PC18.2 PR24.1 46.13,79.42 45.04,79.42 44.98,79.36 44.51,79.36 v3(43.35,78.2)
VP3P3_VIN: length 3.1
  TOP w0.381: v3(42.29,88.55) 42.29,88.55 PC16.1 ; PR243.1 42.53,90.19 v3(42.54,90.19)
VP3P3_VREG5: length 2.2
  TOP w0.381: PU2.3 49.1,80.34 49.27,80.17 PC20.1
VP3P3_VSENSE: length 3.7
  TOP w0.381: PC18.1 PR22.1 48.21,77.36 PR21.2 48.4,77.02 49.27,77.02 v3(49.3,76.99)
VP5P0: length 116
  TOP w0.254: PU26.5 81.02,52.92 81.46,53.36 v3(81.79,53.36) 82.02,53.13 PU26.3 ; PC34.1 53.75,75.49 PU5.4 ; PU6.4 42.84,65.5 PC27.1
  TOP w0.305: v3(103.99,89.37) 103.8,89.56 PU18.5 ; PU19.5 103.62,79.53 v3(103.86,79.28) ; PU19.3 103.24,78.52 ; PU18.3 103.5,88.56
  TOP w0.381: PC27.1 v3(42.75,66.5) ; PR138.1 72.95,75.24 72.75,75.04 v3(72.75,75.04) ; PC166.1 199.67,66 v3(199.72,65.95) ; PR244.1 v3(4.78,43.85) ; PC34.1 v3(53.64,76.41)
  T05 w0.381: v3(70.51,79.42) 70.51,79.04 69.27,77.8 69.27,71.1 70.52,69.86 70.52,67.27 71.88,65.9 71.88,60.47 77.52,54.83 77.52,54.19 78.36,53.36 v3(81.79,53.36) 81.18,52.75 78.41,52.75 76.63,50.97 72.54,50.97 68.83,47.26 v3(68.83,46.12) ; v3(42.75,66.5) 42.75,65.52 38.73,61.5 34.37,61.5 29.94,57.06 v3(26.24,57.06)
  BOTTOM w0.305: v3(199.72,65.95) 199.7,65.98 PU22.5
  BOTTOM w0.381: v3(204.47,28.67) 203.56,27.75 PR194.1 ; PU22.3 200.7,66.54 200.1,65.95 v3(199.72,65.95) ; PC340.1 82.68,52.98 82.3,53.36 v3(81.79,53.36) ; PR297.1 v3(68.83,46.12) ; v3(22.4,43.15) 21.19,41.95 11.03,41.95 9.12,43.85 v3(4.78,43.85)
  vias: v3(22.33,44.24) v3(23.16,43.92) v3(23.39,92.52) v3(23.8,43.15) v3(23.88,44.59) v3(24.24,92.49) v3(24.31,43.92) v3(24.72,90.76) v3(24.94,43.15) v3(25.02,44.21) v3(140.03,94.27) v3(140.8,94.27) v3(141.56,94.27) v3(204.81,71.37)
VP5P0_BST: length 4.3
  TOP w0.254: PU1.8 11.42,47.13 11.56,47.27 v3(12.6,47.27) 12.82,47.05 12.82,46.55 12.31,46.03 PR9.1
VP5P0_BST_RC: length 1.4
  TOP w0.254: PC4.1 PR9.2
VP5P0_FB: length 11.3
  TOP w0.254: PU1.6 9.26,45.98 v3(9.23,45.95) 9.23,44.87 PR19.1 PR20.1 8.98,43.59 9.74,42.83 PR18.2
  BOTTOM w0.381: PC14.2 14.3,47.09 13.34,46.12 9.4,46.12 v3(9.23,45.95)
VP5P0_FB_IN: length 4.2
  TOP w0.254: PR248.2 11.39,42.83 PR18.1
  TOP w0.381: v3(12.04,39.91) 12.5,40.38 PR248.2
VP5P0_L_RC: length 4.9
  BOTTOM w0.381: 14.36,49.79 14.39,49.82 14.39,50.92 13.81,51.49 v2(13.81,52.42) ; 14.36,49.79 PC5.2 ; 14.36,49.79 PR249.2 14.31,48.81 PC14.1
VP5P0_SN: length 3.3
  BOTTOM w0.381: v2(9.15,52.73) 9.31,52.57 PC12.1 10.88,51.08 PR247.2
VP5P0_SS: length 5.1
  TOP w0.254: PC11.1 7.42,42.8 7.41,42.82 7.41,44.95 7.79,45.34 v7(7.79,45.91) 8.11,45.91 8.61,46.42 PU1.5
VP5P0_SW: length 13.1
  TOP w0.381: v3(12.6,51.45) 12.6,49.98 PL1.1 13.7,48.88 PC4.2 ; 9.91,49 9.91,48.46 ; 9.91,49 10.22,48.69 ; 9.91,49 PU1.2
  BOTTOM w0.381: v3(12.6,51.45) 13.5,50.55 PR249.1 13.04,49.29 PR247.1
VP5P0_VIN: length 1.2
  TOP w0.381: PU1.3 9.26,50.91
  vias: v3(6.11,50.93)
