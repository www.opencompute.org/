# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_A_BG0: length 60
  TOP w0.171: v1(140.62,43.56) U1.CM33
  T08 w0.152: v1(183.03,46.02) 183.03,45.64 182.92,45.53 182.68,45.53 182.52,45.69 182.33,45.69 182.08,45.45 181.75,45.45 181.53,45.66 181.17,45.66 180.89,45.38 180.71,45.38 180.15,45.95 171.97,45.95 171.69,46.23 171.68,46.23 171.41,46.5 171.19,46.5 171.12,46.43 171.12,46.43 170.92,46.23 170.55,46.23 170.35,46.43 170,46.43 169.8,46.23 169.44,46.23 169.18,46.5 168.38,46.5 166.51,44.63 165.55,44.63 165.37,44.81 165.37,45.1 165.19,45.28 164.94,45.28 164.76,45.1 164.76,44.81 164.58,44.63 164.33,44.63 164.15,44.81 164.15,45.1 163.97,45.28 163.72,45.28 163.54,45.1 163.54,44.81 163.36,44.63 163.11,44.63 162.93,44.81 162.93,45.1 162.75,45.28 162.5,45.28 162.32,45.1 162.32,44.81 162.14,44.63 161.89,44.63 161.71,44.81 161.71,45.1 161.53,45.28 161.28,45.28 161.1,45.1 161.1,44.81 160.92,44.63 160.67,44.63 160.49,44.81 160.49,45.1 160.31,45.28 160.06,45.28 159.88,45.1 159.88,44.81 159.7,44.63 159.45,44.63 159.27,44.81 159.27,45.1 159.09,45.28 158.84,45.28 158.66,45.1 158.66,44.81 158.49,44.63 158.23,44.63 158.05,44.81 158.05,45.1 157.88,45.28 157.62,45.28 157.44,45.1 157.44,44.81 157.27,44.63 157.01,44.63 156.83,44.81 156.83,45.1 156.66,45.28 156.4,45.28 156.23,45.1 156.23,44.81 156.05,44.63 155.79,44.63 155.62,44.81 155.62,45.1 155.44,45.28 155.18,45.28 155.01,45.1 155.01,44.81 154.83,44.63 154.58,44.63 154.4,44.81 154.4,45.1 154.22,45.28 153.97,45.28 153.79,45.1 153.79,44.81 153.61,44.63 152.81,44.63 151.68,43.5 140.89,43.5 140.84,43.56 v1(140.62,43.56)
  BOTTOM w0.089: 181.6,45.76 181.75,45.62 182.08,45.62 182.22,45.76
  BOTTOM w0.109: CN1.115 179.1,45.66 179.23,45.53 179.5,45.53 179.83,45.86 180.38,45.86 180.63,45.62 180.96,45.62 181.1,45.76 181.6,45.76 ; 182.22,45.76 182.77,45.76 v1(183.03,46.02)
DDR4_A_BG1: length 59.5
  TOP w0.102: U1.CD35 v1(137.15,44.41)
  T08 w0.089: v1(137.15,44.41) 137.82,43.92 137.84,43.9 arc(138.14,43.82) 138.44,43.9 arc(138.63,43.96) 138.83,43.9 arc(139.13,43.82) 139.43,43.9 arc(139.63,43.96) 139.83,43.9 arc(140.12,43.82) 140.42,43.9 140.42,43.91 arc(140.62,43.96) 140.82,43.9 arc(141.1,43.82) 141.39,43.89 141.94,43.89
  T08 w0.152: v1(183.59,45.15) 183.59,46.05 183.2,46.43 182.85,46.43 182.62,46.2 182.32,46.2 182.08,46.43 181.74,46.43 181.48,46.17 181.23,46.17 180.62,46.79 172.59,46.79 172.26,47.11 171.6,47.11 171.49,47 171.1,47 170.89,47.21 170.61,47.21 170.38,46.98 170.07,46.98 169.95,47.11 169.39,47.11 169.29,47.01 167.75,47.01 166.79,46.05 163.45,46.05 163.27,46.23 163.27,46.27 163.09,46.45 162.84,46.45 162.66,46.27 162.66,46.23 162.48,46.05 162.23,46.05 162.05,46.23 162.05,46.27 161.88,46.45 161.62,46.45 161.44,46.27 161.44,46.23 161.27,46.05 161.01,46.05 160.83,46.23 160.83,46.27 160.66,46.45 160.4,46.45 160.22,46.27 160.22,46.23 160.05,46.05 159.79,46.05 159.62,46.23 159.62,46.27 159.44,46.45 159.18,46.45 159.01,46.27 159.01,46.23 158.83,46.05 158.57,46.05 158.4,46.23 158.4,46.27 158.22,46.45 157.97,46.45 157.79,46.27 157.79,46.23 157.61,46.05 157.36,46.05 157.18,46.23 157.18,46.27 157,46.45 156.75,46.45 156.57,46.27 156.57,46.23 156.39,46.05 156.14,46.05 155.96,46.23 155.96,46.27 155.78,46.45 155.53,46.45 155.35,46.27 155.35,46.23 155.17,46.05 154.92,46.05 154.74,46.23 154.74,46.27 154.56,46.45 154.31,46.45 154.13,46.27 154.13,46.23 153.95,46.05 152.89,46.05 151.29,44.46 144.41,44.46 143.85,43.9 141.95,43.9 141.94,43.89
  BOTTOM w0.089: 181.52,45.55 181.66,45.41 182.16,45.41 182.3,45.55
  BOTTOM w0.109: 181.52,45.55 181.19,45.55 181.05,45.41 180.54,45.41 180.36,45.59 180,45.59 179.57,45.16 CN1.113 ; 182.3,45.55 183.19,45.55 v1(183.59,45.15)
DDR4_A_CKE0: length 54.4
  TOP w0.102: U1.CD32 v1(137.15,42.7)
  T03 w0.089: 142.82,45.2 142.51,45.2 141.08,43.77 141.08,43.45 140.86,43.24 140.82,43.21 arc(140.62,43.15) 140.42,43.2 140.42,43.21 arc(140.12,43.29) 139.83,43.21 arc(139.63,43.15) 139.43,43.21 arc(139.13,43.29) 138.83,43.21 arc(138.74,43.17) 138.63,43.16 138.14,43.12 137.83,43.04 v1(137.15,42.7)
  T03 w0.152: 142.82,45.2 143.04,45.41 144.62,45.41 144.8,45.23 167.4,45.23 167.75,45.57 168.67,45.57 168.76,45.48 169.21,45.48 169.32,45.6 169.85,45.6 169.89,45.56 170.49,45.56 170.52,45.59 170.81,45.59 171,45.56 171.59,45.56 171.83,45.59 177.12,45.59 177.31,45.4 177.31,44.72 177.45,44.58 179.54,44.58 179.66,44.69 179.66,44.91 179.53,45.04 178.01,45.04 177.88,45.16 177.88,45.42 178.05,45.59 180.35,45.59 180.56,45.47 180.82,45.16 180.82,44.55 v1(180.79,44.52)
  BOTTOM w0.171: v1(180.79,44.52) 180.02,44.52 179.66,44.16 CN1.109
DDR4_A_CKE1: length 54.4
  TOP w0.102: U1.CG32 v1(138.14,42.7)
  T03 w0.089: 141.01,43.12 140.97,43.07 140.91,43.04 arc(140.62,42.96) 140.33,43.04 140.32,43.04 arc(140.12,43.1) 139.92,43.04 arc(139.63,42.96) 139.33,43.04 arc(139.13,43.1) 138.93,43.04 arc(138.81,42.99) 138.68,42.97 v1(138.14,42.7)
  T03 w0.097: 141.01,43.12 141.28,43.12 141.48,43.32 141.48,43.73 142.71,44.96 143.11,44.96 143.24,45.09 144.53,45.09 144.7,44.92 150.27,44.92 ; 180.41,44.27 179.99,44.27
  T03 w0.102: v1(183.03,44.52) 182.92,44.62 181.51,44.62 180.98,44.09 180.59,44.09 180.41,44.27 ; 173.43,44.08 172.54,44.98 172.26,44.98 171.95,44.67 171.73,44.67 171.45,44.95 171.14,44.95 170.89,44.7 170.61,44.7 170.33,44.98 170.02,44.98 169.74,44.7 169.49,44.7 169.21,44.98 168.92,44.98 168.64,44.7 168.35,44.7 168.12,44.94 167.77,44.94 167.47,44.64
  T03 w0.152: 150.27,44.92 150.54,44.64 167.47,44.64 ; 173.43,44.08 173.56,43.96 174.51,43.96 174.64,44.08 174.64,44.34 174.51,44.47 174.26,44.47 174.13,44.59 174.13,44.97 174.24,45.08 174.66,45.08 175.66,44.08 179.81,44.08 179.99,44.27
  BOTTOM w0.171: CN1.110 184.66,44.41 184.32,44.06 183.95,44.06 183.76,44.26 183.28,44.26 v1(183.03,44.52)
DDR4_A_CS0_L: length 54.9
  TOP w0.102: U1.CL54 v1(140.12,53)
  T03 w0.097: v1(180.79,55.52) 180.79,55.51 181.33,55.51 181.75,55.94 181.75,56.32 181.51,56.56 181.17,56.56 181,56.38 180.57,56.38 180.4,56.55 179.95,56.55 179.78,56.71
  T03 w0.102: 168.92,55.98 169.19,55.98 169.46,55.7 169.74,55.7 170.02,55.98 170.33,55.98 170.61,55.7 170.89,55.7 171.17,55.98 171.45,55.98 171.73,55.7 172,55.7 172.28,55.98
  T03 w0.152: 179.78,56.71 174.71,56.71 174.44,56.44 174.44,55.66 174.24,55.46 173.92,55.46 173.81,55.57 173.81,56.15 173.62,56.34 173.1,56.34 172.74,55.98 172.28,55.98 ; 168.92,55.98 168.67,55.73 168.14,55.73 167.78,56.09 158.77,56.09 157.69,55.01 156.67,55.01 156.48,55.2 156.48,55.45 156.61,55.58 157.56,55.58 157.69,55.7 157.69,55.96 157.56,56.09 156.23,56.09 155.72,55.58 144.55,55.58 141.44,52.46 140.95,52.46 140.66,52.75 140.37,52.75 v1(140.12,53)
  BOTTOM w0.171: CN1.149 179.13,56.16 179.6,55.69 180.62,55.69 v1(180.79,55.52)
DDR4_A_CS1_L: length 54
  TOP w0.102: U1.CJ58 v1(139.13,54.72)
  TOP w0.109: v1(182.47,59.15) 181.94,59.15 181.3,58.52 v1(180.79,58.52)
  T03 w0.089: v1(139.13,54.72) 139.8,55.21 139.83,55.23 arc(139.97,55.37) 140.03,55.56 arc(140.03,55.6) 140.06,55.64 140.52,56.1 140.68,56.1
  T03 w0.152: 140.68,56.1 141.15,56.1 144.76,59.71 152.27,59.71 152.51,59.47 165.2,59.47 165.37,59.64 166.51,59.64 166.63,59.53 166.63,59.31 166.51,59.2 166.07,59.2 165.92,59.05 165.92,58.84 166.07,58.69 166.96,58.69 167.85,59.58 172.74,59.58 173.5,60.34 178.45,60.34 179.15,59.63 180.49,59.63 180.54,59.58 181.64,59.58 182.06,59.15 v1(182.47,59.15)
  BOTTOM w0.171: v1(180.79,58.52) 179.65,58.52 179.29,58.16 CN1.157
DDR4_A_DQ0: length 64
  TOP w0.089: U1.BY2 135.41,27.84 135.78,27.47 135.78,26.92 v1(135.38,26.52)
  T03 w0.097: v1(184.13,19.19) 183.66,19.19 183.53,19.07 183.53,18.3 183.66,18.18 184.29,18.18 184.45,18.02 184.45,17.92 184.28,17.75 179.38,17.75 177.27,15.64 173.97,15.64 173.15,14.82 166.76,14.82 166.2,15.38 146.04,15.38 145.64,15.78 139.79,21.63 137.72,21.63 137.01,22.34 137.01,23.83 136.27,24.58 136.27,25.62 v1(135.38,26.52)
  BOTTOM w0.109: v1(184.13,19.19) 184.42,18.9 CN1.8
DDR4_A_DQ1: length 64
  TOP w0.089: v1(135.38,25.75) 135.97,26.34 135.97,27.54 135.6,27.91 135.6,28.46 135.78,28.64 135.78,29.07 135.41,29.44 U1.BY4
  T03 w0.097: v1(179.58,16.65) 178.89,16.65 178.07,15.84 178.07,15.76 178.2,15.64 180.23,15.64 180.38,15.49 180.38,15.36 180.23,15.21 174.14,15.21 173.33,14.39 166.59,14.39 166.1,14.87 145.94,14.87 145.47,15.35 139.62,21.2 137.54,21.2 136.59,22.16 136.59,23.66 135.85,24.4 135.85,25.38 135.48,25.75 v1(135.38,25.75)
  BOTTOM w0.109: v1(179.58,16.65) 179.65,16.73 179.65,18.39 179.39,18.65 CN1.7
DDR4_A_DQ2: length 64.3
  TOP w0.089: U1.CD2 137.39,27.69 137.63,27.45 137.63,26.37 v1(138.22,25.78)
  T03 w0.097: v1(182.19,21.93) 181.71,21.46 180.92,21.46 180.6,21.77 179.39,21.77 178.59,20.97 173.34,20.97 173.24,20.87 173.24,20.69 173.34,20.59 175.02,20.59 175.14,20.47 175.14,20.33 175.02,20.21 172.86,20.21 172.77,20.31 172.77,21.25 172.64,21.38 172.31,21.38 172.23,21.3 172.23,20.59 172.05,20.41 167.83,20.41 164.96,17.55 164.87,17.55 164.86,17.54 148.19,17.54 148.18,17.55 147.94,17.8 139.96,25.78 v1(138.22,25.78)
  BOTTOM w0.109: CN1.20 184.8,21.9 184.65,22.05 184.65,22.32 184.56,22.41 183.88,22.41 183.79,22.32 183.79,21.5 183.66,21.38 182.74,21.38 v1(182.19,21.93)
DDR4_A_DQ3: length 64.2
  TOP w0.089: v1(138.24,26.49) 137.82,26.91 137.82,27.53 137.58,27.77 137.58,28.59 137.75,28.76 137.75,29.09 137.39,29.44 U1.CD4
  T03 w0.097: v1(183.19,21.93) 183.2,21.93 182.69,22.45 173.88,22.45 173.75,22.32 173.75,22.11 173.88,21.99 174.9,21.99 175.02,21.86 175.02,21.61 174.9,21.48 173.37,21.48 173.24,21.61 173.24,22.37 173.16,22.45 172.11,22.45 171.98,22.32 171.98,21.76 171.65,21.43 168.25,21.43 164.79,17.97 148.36,17.97 139.85,26.49 v1(138.24,26.49)
  BOTTOM w0.109: v1(183.19,21.93) 183.19,22.06 182.91,22.33 182.01,22.33 181.89,22.21 181.49,22.21 181.37,22.33 180.9,22.33 180.71,22.15 CN1.21
DDR4_A_DQ4: length 64.1
  TOP w0.089: v1(135.37,23.52) 134.8,24.09 134.8,27.74 134.92,27.85 U1.BW1
  T03 w0.097: v1(135.37,23.52) 135.37,23.31 135.73,22.94 135.73,21.81 137.19,20.35 139.26,20.35 145.59,14.02 165.75,14.02 166.23,13.54 173.71,13.54 174.53,14.36 184.16,14.36 185.4,15.6 v1(185.4,16.65)
  BOTTOM w0.109: v1(185.4,16.65) 185.09,16.96 185.09,17.72 185.27,17.9 CN1.4
DDR4_A_DQ5: length 64.1
  TOP w0.089: v1(135.38,24.23) 134.98,24.63 134.98,27.61 135.2,27.83 135.2,28.42 135.05,28.57 135.05,29.31 U1.BW3
  T03 w0.097: v1(135.38,24.23) 135.38,24.13 136.14,23.37 136.14,22 137.37,20.78 139.44,20.78 145.29,14.93 145.77,14.45 165.93,14.45 166.41,13.97 173.53,13.97 174.35,14.78 180.77,14.78 180.86,14.87 180.86,17.16 180.74,17.28 180.61,17.28 180.48,17.16 180.48,16.27 180.31,16.09 v1(179.17,16.09)
  BOTTOM w0.109: v1(179.17,16.09) 179.02,16.25 179.02,16.68 179.3,16.96 179.3,17.37 179.01,17.65 CN1.3
DDR4_A_DQ6: length 64.3
  TOP w0.089: v1(138.2,23.64) 137.24,24.6 137.24,27.29 136.9,27.64 U1.CC1
  T03 w0.097: v1(182.19,20.93) 181.65,20.39 181.05,20.39 180.73,20.07 179.76,20.07 179.26,19.57 177.53,19.57 177.44,19.48 177.44,19.29 177.53,19.19 178.32,19.19 178.45,19.07 178.45,18.93 178.35,18.84 175.89,18.84 175.54,19.19 174.01,19.19 173.88,19.07 173.88,18.91 173.98,18.81 175.02,18.81 175.14,18.69 175.14,18.55 175.02,18.43 167.11,18.43 165.36,16.69 147.09,16.69 140.13,23.64 v1(138.2,23.64)
  BOTTOM w0.109: v1(182.19,20.93) 182.58,20.93 183.04,20.48 183.65,20.48 183.74,20.56 183.74,21.04 183.83,21.14 184.07,21.14 184.16,21.05 184.16,20.65 184.25,20.56 184.55,20.56 184.66,20.67 184.66,20.79 184.77,20.9 CN1.16
DDR4_A_DQ7: length 64
  TOP w0.089: U1.CC3 136.98,29.36 136.98,28.72 137.19,28.51 137.19,27.62 137.44,27.38 137.44,25.12 v1(138.2,24.35)
  T03 w0.097: v1(138.2,24.35) 140.03,24.35 147.26,17.11 165.19,17.11 166.68,18.61 166.93,18.86 166.94,18.86 167.91,19.83 168.8,19.83 169.05,19.57 169.05,18.94 169.13,18.86 169.56,18.86 169.69,18.98 169.69,19.32 169.82,19.45 170.07,19.45 170.2,19.32 170.2,18.94 170.28,18.86 170.58,18.86 170.7,18.98 170.7,19.32 170.83,19.45 171.09,19.45 171.21,19.32 171.21,18.94 171.29,18.86 171.59,18.86 171.72,18.98 171.72,19.32 171.85,19.45 172.1,19.45 172.23,19.32 172.23,18.94 172.31,18.86 173.16,18.86 173.37,19.07 173.37,19.57 173.48,19.68 175.81,19.68 176.05,19.45 176.8,19.45 177.35,20 178.86,20 179.19,20.34 179.19,20.93 179.36,21.1 179.61,21.1 179.75,20.95 179.75,20.58 179.83,20.49 180.52,20.49 180.96,20.93 v1(181.19,20.93)
  BOTTOM w0.109: CN1.17 179.09,21.15 179.37,21.43 179.52,21.43 179.74,21.22 179.86,21.22 180.05,21.41 180.05,21.72 180.14,21.81 180.69,21.81 180.78,21.72 180.78,21.59 180.86,21.5 181.66,21.5 181.82,21.34 181.82,21.09 181.66,20.93 v1(181.19,20.93)
DDR4_A_DQ8: length 62.6
  TOP w0.102: U1.CC7 v1(136.65,31.54)
  T08 w0.089: 149.4,23.85 151.75,23.85
  T08 w0.097: 151.75,23.85 153.68,23.85 153.85,23.68 153.85,23.51 154.01,23.34 154.25,23.34 154.42,23.51 154.42,23.68 154.59,23.85 154.83,23.85 155,23.68 155,23.51 155.17,23.34 155.41,23.34 155.58,23.51 155.58,23.68 155.75,23.85 155.99,23.85 156.16,23.68 156.16,23.51 156.33,23.34 156.57,23.34 156.74,23.51 156.74,23.68 156.91,23.85 157.15,23.85 157.32,23.68 157.32,23.51 157.49,23.34 157.73,23.34 157.9,23.51 157.9,23.68 158.07,23.85 158.31,23.85 158.48,23.68 158.48,23.51 158.65,23.34 158.89,23.34 159.06,23.51 159.06,23.68 159.23,23.85 159.47,23.85 159.64,23.68 159.64,23.51 159.81,23.34 160.05,23.34 160.22,23.51 160.22,23.68 160.39,23.85 160.63,23.85 160.79,23.68 160.79,23.51 160.96,23.34 161.2,23.34 161.37,23.51 161.37,23.68 161.54,23.85 161.78,23.85 161.95,23.68 161.95,23.51 162.12,23.34 162.36,23.34 162.53,23.51 162.53,23.68 162.7,23.85 162.94,23.85 163.11,23.68 163.11,23.51 163.28,23.34 163.52,23.34 163.69,23.51 163.69,23.68 163.86,23.85 165.84,23.85 168.48,26.49 171.9,26.49 171.92,26.5 172.55,26.5 175.35,23.7 180.79,23.7 180.94,23.55 181.56,23.55 181.96,23.95 v1(182.19,23.95) ; v1(136.65,31.54) 136.83,31.54 139.97,28.39 144.85,28.39 149.4,23.85
  BOTTOM w0.109: CN1.28 185.2,23.9 185.09,23.79 185.09,23.5 185,23.41 184.7,23.41 184.6,23.51 184.6,24.24 184.48,24.36 182.86,24.36 182.45,23.95 v1(182.19,23.95)
DDR4_A_DQ9: length 62.7
  TOP w0.102: U1.CB9 v1(136.16,32.39)
  T08 w0.097: v1(136.16,32.39) 136.26,32.29 136.26,31.36 139.72,27.9 144.14,27.9 147.35,24.69 147.35,24.66 148.71,23.31 152.49,23.31 153.06,22.74 153.7,22.74 153.87,22.57 153.87,22.42 154.04,22.25 154.28,22.25 154.45,22.42 154.45,22.57 154.62,22.74 154.86,22.74 155.03,22.57 155.03,22.42 155.2,22.25 155.44,22.25 155.61,22.42 155.61,22.57 155.78,22.74 156.02,22.74 156.19,22.57 156.19,22.42 156.36,22.25 156.6,22.25 156.77,22.42 156.77,22.57 156.94,22.74 157.18,22.74 157.35,22.57 157.35,22.42 157.52,22.25 157.75,22.25 157.92,22.42 157.92,22.57 158.09,22.74 158.33,22.74 158.5,22.57 158.5,22.42 158.67,22.25 158.91,22.25 159.08,22.42 159.08,22.57 159.25,22.74 164.62,22.74 165.09,23.21 165.09,23.32 165.19,23.42 166.02,23.42 166.1,23.51 166.14,23.51 168.08,25.45 172.94,25.45 175.13,23.26 179.83,23.26 179.92,23.35 182.59,23.35 v1(183.19,23.95)
  BOTTOM w0.109: v1(183.19,23.95) 182.93,23.95 182.53,23.55 180.99,23.55 180.39,24.15 CN1.29
DDR4_A_DQ10: length 62.4
  TOP w0.102: U1.CM7 v1(140.62,31.54)
  T08 w0.097: v1(182.19,26.98) 181.85,27.32 181.31,27.86 180.89,27.86 180.16,28.6 179.65,28.6 179.45,28.8 179.45,29.17 179.19,29.43 177.85,29.43 177.69,29.27 177.69,28.8 177.49,28.6 175.64,28.6 172.28,31.95 167.59,31.95 166.98,31.33 156.38,31.33 156.21,31.5 156.21,31.8 156.04,31.97 155.8,31.97 155.63,31.8 155.63,31.5 155.46,31.33 155.22,31.33 155.05,31.5 155.05,31.8 154.88,31.97 154.64,31.97 154.47,31.8 154.47,31.5 154.3,31.33 154.06,31.33 153.89,31.5 153.89,31.8 153.72,31.97 153.48,31.97 153.31,31.8 153.31,31.5 153.14,31.33 152.9,31.33 152.73,31.5 152.73,31.8 152.56,31.97 152.32,31.97 152.15,31.8 152.15,31.5 151.98,31.33 151.74,31.33 151.57,31.5 151.57,31.8 151.4,31.97 151.16,31.97 150.99,31.8 150.99,31.5 150.82,31.33 150.58,31.33 150.41,31.5 150.41,31.8 150.25,31.97 150.01,31.97 149.84,31.8 149.84,31.5 149.67,31.33 149.43,31.33 149.26,31.5 149.26,31.8 149.09,31.97 148.85,31.97 148.68,31.8 148.68,31.5 148.51,31.33 148.27,31.33 148.1,31.5 148.1,31.8 147.93,31.97 147.69,31.97 147.52,31.8 147.52,31.5 147.35,31.33 147.11,31.33 146.94,31.5 146.94,31.8 146.77,31.97 146.53,31.97 146.36,31.8 146.36,31.5 146.19,31.33 145.95,31.33 145.78,31.5 145.78,31.8 145.61,31.97 145.37,31.97 145.2,31.8 145.2,31.5 145.03,31.33 144.79,31.33 144.62,31.5 144.62,31.8 144.45,31.97 144.21,31.97 144.04,31.8 144.04,31.5 143.87,31.33 143.63,31.33 143.47,31.5 143.47,31.8 143.3,31.97 143.06,31.97 142.89,31.8 142.89,31.5 142.72,31.33 142.48,31.33 142.31,31.5 142.31,31.8 142.14,31.97 141.9,31.97 141.73,31.8 141.73,31.5 141.56,31.33 140.92,31.33 140.72,31.54 v1(140.62,31.54)
  BOTTOM w0.109: CN1.41 179.2,27.15 179.34,27.01 179.34,26.74 179.58,26.51 180.09,26.51 180.18,26.42 180.18,26.09 180.29,25.97 180.51,25.97 180.6,26.06 180.6,26.42 180.69,26.51 181.71,26.51 v1(182.19,26.98)
DDR4_A_DQ11: length 62.7
  TOP w0.102: U1.CL9 v1(140.12,32.39)
  T08 w0.097: v1(140.12,32.39) 140.22,32.3 140.22,31.54 arc(140.3,31.29) 140.52,31.15 140.69,31.06 140.98,30.77 149.65,30.77 149.82,30.6 149.82,30.22 149.99,30.05 150.23,30.05 150.4,30.22 150.4,30.6 150.57,30.77 150.81,30.77 150.98,30.6 150.98,30.22 151.15,30.05 151.39,30.05 151.56,30.22 151.56,30.6 151.73,30.77 151.97,30.77 152.14,30.6 152.14,30.22 152.31,30.05 152.55,30.05 152.72,30.22 152.72,30.6 152.89,30.77 153.13,30.77 153.29,30.6 153.29,30.22 153.46,30.05 153.7,30.05 153.87,30.22 153.87,30.6 154.04,30.77 154.28,30.77 154.45,30.6 154.45,30.22 154.62,30.05 154.86,30.05 155.03,30.22 155.03,30.6 155.2,30.77 155.44,30.77 155.61,30.6 155.61,30.22 155.78,30.05 156.02,30.05 156.19,30.22 156.19,30.6 156.36,30.77 156.6,30.77 156.77,30.6 156.77,30.22 156.94,30.05 157.18,30.05 157.35,30.22 157.35,30.6 157.52,30.77 157.76,30.77 157.93,30.6 157.93,30.22 158.1,30.05 158.34,30.05 158.51,30.22 158.51,30.6 158.68,30.77 158.92,30.77 159.09,30.6 159.09,30.22 159.26,30.05 159.5,30.05 159.67,30.22 159.67,30.6 159.83,30.77 160.07,30.77 160.24,30.6 160.24,30.22 160.36,30.11 160.71,30.11 160.82,30.22 160.82,30.6 160.99,30.77 161.86,30.77 162.64,30 166.26,30 167.14,30.88 172.61,30.88 175.6,27.88 177.08,27.88 177.54,27.43 177.97,27.43 178.18,27.63 178.18,28.34 178.38,28.54 178.86,28.54 179.06,28.34 179.06,27.59 179.22,27.43 180.74,27.43 v1(181.19,26.98)
  BOTTOM w0.109: v1(181.19,26.98) 181.58,26.98 181.98,27.39 183.4,27.39 183.74,27.04 184.84,27.04 185.2,27.4 CN1.42
DDR4_A_DQ12: length 62.6
  TOP w0.102: v1(135.66,31.54) 135.86,31.42 U1.CA7
  T08 w0.097: v1(182.19,22.95) 182.32,22.81 182.32,22.57 182.2,22.44 181.07,22.44 180.64,22.01 177.51,22.01 177.18,22.35 173.33,22.35 172.26,23.41 168.04,23.41 167.59,22.97 167.59,22.35 165.33,20.09 164.03,20.09 154.41,20.09 152.5,18.18 149.85,18.18 141.19,26.84 139.17,26.84 135.66,30.35 v1(135.66,31.54)
  BOTTOM w0.109: v1(182.19,22.95) 182.45,22.69 182.67,22.69 182.76,22.78 182.76,23.26 182.87,23.37 183.21,23.37 183.45,23.61 183.9,23.61 183.99,23.52 183.99,23.07 184.1,22.96 184.63,22.96 184.83,22.75 185.12,22.75 185.27,22.9 CN1.24
DDR4_A_DQ13: length 62.1
  TOP w0.102: U1.BY9 v1(135.17,32.39)
  T08 w0.097: v1(135.17,32.39) 135.46,32.1 135.65,32.1 135.82,31.93 135.83,31.93 136.05,31.7 136.05,31.37 136.01,31.33 136.01,30.49 138.21,28.29 139.17,27.33 142.61,27.33 147.75,22.19 147.75,21.33 150.04,19.04 152.27,19.04 154.02,20.79 162.79,20.79 163.34,21.35 164.99,21.35 168.1,24.45 172.8,24.45 174.43,22.83 177.35,22.83 177.71,22.47 180.43,22.47 180.89,22.93 181.17,22.93 v1(181.19,22.95)
  BOTTOM w0.109: CN1.25 179.16,23.15 179.27,23.04 179.27,22.67 179.36,22.58 179.65,22.58 179.75,22.68 179.75,23.71 179.9,23.87 180.31,23.87 180.61,23.57 180.61,22.84 180.75,22.7 180.95,22.7 v1(181.19,22.95)
DDR4_A_DQ14: length 62.3
  TOP w0.102: U1.CK7 v1(139.63,31.54)
  T08 w0.089: 148.4,28.95 150.54,28.95
  T08 w0.097: 150.54,28.95 151.7,27.78 153.9,27.78 154.07,27.61 154.07,27.21 154.24,27.04 154.48,27.04 154.65,27.21 154.65,27.61 154.82,27.78 155.06,27.78 155.23,27.61 155.23,27.21 155.4,27.04 155.64,27.04 155.81,27.21 155.81,27.61 155.98,27.78 156.22,27.78 156.38,27.61 156.38,27.21 156.55,27.04 156.79,27.04 156.96,27.21 156.96,27.61 157.13,27.78 157.37,27.78 157.54,27.61 157.54,27.21 157.71,27.04 157.95,27.04 158.12,27.21 158.12,27.61 158.29,27.78 158.53,27.78 158.7,27.61 158.7,27.21 158.87,27.04 159.11,27.04 159.28,27.21 159.28,27.61 159.45,27.78 159.69,27.78 159.86,27.61 159.86,27.21 160.03,27.04 160.27,27.04 160.44,27.21 160.44,27.61 160.61,27.78 160.85,27.78 161.02,27.61 161.02,27.21 161.19,27.04 161.43,27.04 161.6,27.21 161.6,27.61 161.77,27.78 162.01,27.78 162.18,27.61 162.18,27.21 162.35,27.04 162.59,27.04 162.76,27.21 162.76,27.61 162.92,27.78 166.44,27.78 167.56,28.9 172.77,28.9 175.48,26.18 178.86,26.18 179.52,25.52 182.73,25.52 v1(183.19,25.98) ; 148.4,28.95 147.43,29.91 140.28,29.91 139.78,30.41 139.78,31.38 v1(139.63,31.54)
  BOTTOM w0.109: v1(183.19,25.98) 182.73,25.98 182.61,26.1 182.61,26.36 182.74,26.49 183.61,26.49 183.69,26.58 183.69,26.63 183.78,26.72 184.02,26.72 184.11,26.63 184.11,26.55 184.2,26.46 184.62,26.46 184.71,26.37 184.71,26.12 184.82,26 185,26 185.12,26.12 185.12,26.33 185.19,26.4 CN1.38
DDR4_A_DQ15: length 62.3
  TOP w0.102: U1.CJ9 v1(139.13,32.39)
  T08 w0.089: 149.1,29.43 151.15,29.43 ; 139.79,31.93 139.32,32.39 v1(139.13,32.39)
  T08 w0.097: 139.79,31.93 140.02,31.7 140.02,31.37 140.01,31.37 140.01,30.5 140.24,30.27 140.56,30.27 140.64,30.35 148.19,30.35 149.1,29.43 ; 151.15,29.43 152.1,28.48 152.83,28.48 153,28.65 153,29.1 153.17,29.27 153.41,29.27 153.58,29.1 153.58,28.65 153.75,28.48 153.99,28.48 154.16,28.65 154.16,29.1 154.33,29.27 154.57,29.27 154.73,29.1 154.73,28.65 154.9,28.48 155.14,28.48 155.31,28.65 155.31,29.1 155.48,29.27 155.72,29.27 155.89,29.1 155.89,28.65 156.06,28.48 156.3,28.48 156.47,28.65 156.47,29.1 156.64,29.27 156.88,29.27 157.05,29.1 157.05,28.65 157.22,28.48 157.46,28.48 157.63,28.65 157.63,29.1 157.8,29.27 158.04,29.27 158.21,29.1 158.21,28.65 158.38,28.48 158.62,28.48 158.79,28.65 158.79,29.1 158.96,29.27 159.2,29.27 159.37,29.1 159.37,28.65 159.54,28.48 159.78,28.48 159.95,28.65 159.95,29.1 160.12,29.27 160.36,29.27 160.53,29.1 160.53,28.65 160.7,28.48 161.84,28.48 162.01,28.65 162.01,29.08 162.18,29.25 166.61,29.25 167.55,30.2 168.98,30.2 169.31,29.87 172.54,29.87 175.78,26.62 179.41,26.62 179.55,26.49 181.68,26.49 v1(182.19,25.98)
  BOTTOM w0.109: CN1.37 179.74,26.15 179.86,26.03 179.86,25.5 179.95,25.41 181.47,25.41 181.6,25.54 181.6,26.13 181.7,26.24 181.94,26.24 v1(182.19,25.98)
DDR4_A_DQ16: length 61.2
  TOP w0.102: U1.CB13 v1(136.16,34.11)
  T03 w0.097: v1(181.19,29.4) 180.91,29.4 180.81,29.3 180.79,29.3 179.3,27.81 178.65,27.81 178.38,27.53 178.17,27.53 177.89,27.81 174.6,27.81 173.29,26.5 166.64,26.5 165.62,27.52 163.16,27.52 162.8,27.88 162.53,27.88 162.39,28.02 162.39,28.22 162.25,28.36 162.05,28.36 161.9,28.22 161.9,28.02 161.76,27.88 161.56,27.88 161.42,28.02 161.42,28.22 161.28,28.36 161.08,28.36 160.94,28.22 160.94,28.02 160.8,27.88 160.6,27.88 160.46,28.02 160.46,28.22 160.32,28.36 160.11,28.36 159.97,28.22 159.97,28.02 159.83,27.88 159.63,27.88 159.49,28.02 159.49,28.22 159.35,28.36 159.15,28.36 159.01,28.22 159.01,28.02 158.87,27.88 153.54,27.88 151.26,30.16 143.66,30.16 141.51,32.31 141.16,32.31 140.94,32.09 140.81,32.09 arc(140.56,32.12) 140.32,32.05 arc(140.12,31.99) 139.92,32.05 arc(139.63,32.13) 139.33,32.05 arc(139.13,31.99) 138.93,32.05 arc(138.63,32.13) 138.34,32.05 arc(137.94,32.05) 137.74,32.38 137.74,32.42 arc(137.66,32.7) 137.44,32.91 arc(137.3,33.05) 137.24,33.24 137.24,33.27 arc(137.16,33.56) 136.95,33.76 arc(136.81,33.91) 136.75,34.1 136.75,34.26 arc(136.76,34.34) 136.81,34.42 arc(136.99,34.67) 137.05,34.98 arc(136.65,35.37) 136.25,34.98 136.25,34.93 v1(136.16,34.11)
  BOTTOM w0.109: v1(181.19,29.4) 181.59,29.4 181.99,28.99 183.36,28.99 183.77,29.4 CN1.50
DDR4_A_DQ17: length 60.9
  TOP w0.102: U1.CC14 v1(136.65,34.97)
  T03 w0.097: v1(182.19,29.4) 181.66,28.87 180.97,28.87 180.49,28.39 180.49,28.11 179.09,26.72 174.91,26.72 173.67,25.47 168.34,25.47 167.85,25.97 163.31,25.97 162.6,26.67 161.66,26.67 161.51,26.82 161.51,26.94 161.37,27.08 161.17,27.08 161.03,26.94 161.03,26.82 160.89,26.67 160.69,26.67 160.55,26.82 160.55,26.94 160.41,27.08 160.21,27.08 160.07,26.94 160.07,26.82 159.93,26.67 159.73,26.67 159.58,26.82 159.58,26.94 159.44,27.08 159.24,27.08 159.1,26.94 159.1,26.82 158.96,26.67 158.76,26.67 158.62,26.82 158.62,26.94 158.48,27.08 158.28,27.08 158.14,26.94 158.14,26.82 158,26.67 157.79,26.67 157.65,26.82 157.65,26.94 157.51,27.08 157.31,27.08 157.17,26.94 157.17,26.82 157.03,26.67 156.83,26.67 156.69,26.82 156.69,26.94 156.55,27.08 156.35,27.08 156.21,26.94 156.21,26.82 156.06,26.67 155.86,26.67 155.72,26.82 155.72,26.94 155.58,27.08 155.38,27.08 155.24,26.94 155.24,26.82 155.1,26.67 152.98,26.67 150.28,29.38 143.84,29.38 141.34,31.88 140.82,31.88 arc(140.62,31.94) 140.42,31.88 arc(140.12,31.8) 139.83,31.88 arc(139.63,31.94) 139.43,31.88 arc(139.13,31.8) 138.83,31.88 arc(138.63,31.94) 138.44,31.88 arc(137.85,31.88) 137.55,32.37 137.55,32.41 arc(137.49,32.6) 137.35,32.74 arc(137.14,32.95) 137.05,33.23 137.05,33.26 arc(137,33.46) 136.85,33.6 arc(136.64,33.81) 136.56,34.09 136.56,34.4 arc(136.58,34.69) v1(136.65,34.97)
  BOTTOM w0.109: CN1.49 179.33,29.15 180,29.82 180.85,29.82 180.95,29.91 181.75,29.91 182.19,29.47 v1(182.19,29.4)
DDR4_A_DQ18: length 61
  TOP w0.102: U1.CL13 v1(140.12,34.11)
  T03 w0.097: v1(182.19,32.43) 182.16,32.4 181.78,32.4 181.27,31.89 181.05,31.89 180.57,32.38 173.14,32.38 172.65,31.89 167.76,31.89 166.03,33.62 161.04,33.62 160.9,33.76 160.9,34.02 160.76,34.16 160.56,34.16 160.42,34.02 160.42,33.76 160.27,33.62 159.87,33.62 159.73,33.76 159.73,33.99 159.59,34.13 159.39,34.13 159.25,33.99 159.25,33.76 159.11,33.62 158.91,33.62 158.77,33.76 158.77,33.99 158.63,34.13 158.43,34.13 158.29,33.99 158.29,33.76 158.14,33.62 157.94,33.62 157.8,33.76 157.8,33.99 157.66,34.13 157.46,34.13 157.32,33.99 157.32,33.76 157.18,33.62 156.98,33.62 156.84,33.76 156.84,33.99 156.7,34.13 156.5,34.13 156.36,33.99 156.36,33.76 156.21,33.62 156.01,33.62 155.87,33.76 155.87,33.99 155.73,34.13 155.53,34.13 155.39,33.99 155.39,33.76 155.25,33.62 155.05,33.62 154.91,33.76 154.91,33.99 154.77,34.13 154.57,34.13 154.42,33.99 154.42,33.76 154.28,33.62 154.08,33.62 153.94,33.76 153.94,33.99 153.8,34.13 153.6,34.13 153.46,33.99 153.46,33.76 153.32,33.62 153.12,33.62 152.98,33.76 152.98,33.99 152.84,34.13 152.64,34.13 152.49,33.99 152.49,33.76 152.35,33.62 152.15,33.62 152.01,33.76 152.01,33.99 151.87,34.13 151.67,34.13 151.53,33.99 151.53,33.76 151.39,33.62 151.19,33.62 151.05,33.76 151.05,33.99 150.91,34.13 150.71,34.13 150.56,33.99 150.56,33.76 150.42,33.62 150.22,33.62 150.08,33.76 150.08,33.99 149.94,34.13 149.74,34.13 149.6,33.99 149.6,33.76 149.46,33.62 149.26,33.62 149.12,33.76 149.12,33.99 148.97,34.13 148.77,34.13 148.63,33.99 148.63,33.76 148.49,33.62 148.29,33.62 148.15,33.76 148.15,33.99 148.01,34.13 147.81,34.13 147.67,33.99 147.67,33.76 147.53,33.62 147.33,33.62 147.19,33.76 147.19,33.99 147.04,34.13 146.84,34.13 146.7,33.99 146.7,33.76 146.56,33.62 146.36,33.62 146.22,33.76 146.22,33.99 146.08,34.13 145.88,34.13 145.74,33.99 145.74,33.76 145.6,33.62 144.71,33.62 144.04,34.28 140.29,34.28 v1(140.12,34.11)
  BOTTOM w0.109: CN1.62 184.8,32.4 184.65,32.55 184.65,32.82 184.56,32.91 183.88,32.91 183.79,32.82 183.79,32 183.66,31.88 182.74,31.88 v1(182.19,32.43)
DDR4_A_DQ19: length 61
  TOP w0.102: U1.CM14 v1(140.62,34.97)
  T03 w0.097: v1(183.19,32.43) 183.17,32.43 182.64,32.96 179.11,32.96 178.97,33.11 178.97,33.49 178.83,33.63 178.63,33.63 178.49,33.49 178.49,33.11 178.34,32.96 178.14,32.96 178,33.11 178,33.49 177.86,33.63 177.66,33.63 177.52,33.49 177.52,33.11 177.38,32.96 175.82,32.96 175.68,33.11 175.68,33.33 175.54,33.47 175.34,33.47 175.2,33.33 175.2,33.11 175.06,32.96 174.86,32.96 174.72,33.11 174.72,33.33 174.58,33.47 174.38,33.47 174.24,33.33 174.24,33.11 174.09,32.96 173.89,32.96 173.75,33.11 173.75,33.33 173.61,33.47 173.41,33.47 173.27,33.33 173.27,33.11 173.13,32.96 167.81,32.96 166.02,34.75 160.86,34.75 160.72,34.89 160.72,35.19 160.58,35.34 160.38,35.34 160.24,35.19 160.24,34.89 160.1,34.75 159.9,34.75 159.75,34.89 159.75,35.19 159.61,35.34 159.41,35.34 159.27,35.19 159.27,34.89 159.13,34.75 158.93,34.75 158.79,34.89 158.79,35.19 158.65,35.34 158.45,35.34 158.31,35.19 158.31,34.89 158.17,34.75 157.97,34.75 157.82,34.89 157.82,35.19 157.68,35.34 157.48,35.34 157.34,35.19 157.34,34.89 157.2,34.75 157,34.75 156.86,34.89 156.86,35.19 156.72,35.34 156.52,35.34 156.38,35.19 156.38,34.89 156.23,34.75 156.03,34.75 155.89,34.89 155.89,35.19 155.75,35.34 155.55,35.34 155.41,35.19 155.41,34.89 155.27,34.75 155.07,34.75 154.93,34.89 154.93,35.19 154.79,35.34 154.59,35.34 154.45,35.19 154.45,34.89 154.3,34.75 154.1,34.75 153.96,34.89 153.96,35.19 153.82,35.34 153.62,35.34 153.48,35.19 153.48,34.89 153.34,34.75 151.73,34.75 150.82,35.66 145.96,35.66 145.07,34.77 140.82,34.77 v1(140.62,34.97)
  BOTTOM w0.109: v1(183.19,32.43) 182.86,32.43 182.39,32.91 182.01,32.91 181.88,32.78 181.5,32.78 181.37,32.91 180.97,32.91 180.72,32.65 CN1.63
DDR4_A_DQ20: length 60.8
  TOP w0.102: U1.BY13 v1(135.17,34.11)
  T03 w0.097: v1(183.19,28.4) 182.01,27.5 181.63,27.12 181.63,26.8 181.37,26.54 181.1,26.54 179.21,24.65 178.79,24.65 178.65,24.51 178.65,24.23 178.51,24.09 178.31,24.09 178.17,24.23 178.17,24.51 178.03,24.65 175.28,24.65 174.07,23.45 163.04,23.45 162.01,24.48 147.45,24.48 143.88,28.05 139.66,28.05 136.62,31.08 136.38,31.08 136.15,31.31 136.15,31.7 135.67,32.18 135.67,32.6 136.1,33.03 arc(136.08,33.13) 136.06,33.23 136.06,33.26 arc(135.95,33.53) 135.67,33.64 135.54,33.64 135.17,34.01 v1(135.17,34.11)
  BOTTOM w0.109: CN1.46 185.1,28.4 184.66,28.84 183.81,28.84 183.37,28.4 v1(183.19,28.4)
DDR4_A_DQ21: length 61.1
  TOP w0.102: U1.CA14 v1(135.66,34.97)
  T03 w0.097: v1(182.19,28.4) 181.49,27.7 181.12,27.7 180.64,27.22 180.64,26.79 179.95,26.11 179.1,26.11 178.96,25.96 178.96,25.56 178.81,25.42 178.61,25.42 178.47,25.56 178.47,25.96 178.33,26.11 175.48,26.11 173.83,24.46 168.35,24.46 167.45,25.36 162.63,25.36 162.16,25.82 153.72,25.82 153.13,25.24 149.68,25.24 146.07,28.85 139.7,28.85 137.51,31.04 137.5,31.04 137.12,31.41 137.12,31.73 136.65,32.21 136.65,32.74 136.62,32.76 arc(136.55,32.84) 136.45,32.91 arc(136.31,33.05) 136.25,33.24 136.25,33.27 arc(136.25,33.35) 136.23,33.42 arc(136.16,33.57) 136.06,33.69 arc(136.01,33.73) 135.96,33.76 arc(135.81,33.91) 135.76,34.1 135.76,34.13 arc(135.75,34.23) 135.72,34.32 135.72,34.91 v1(135.66,34.97)
  BOTTOM w0.109: v1(182.19,28.4) 181.79,28.4 181.36,28.83 180.98,28.83 180.36,28.21 180.1,28.21 179.98,28.34 179.98,28.59 179.85,28.72 179.59,28.72 179.47,28.59 179.47,28.34 179.29,28.15 CN1.45
DDR4_A_DQ22: length 60.8
  TOP w0.102: U1.CJ13 v1(139.13,34.11)
  T03 w0.097: v1(139.13,34.11) 139.3,34.4 139.38,34.43 arc(139.49,34.29) 139.53,34.12 139.53,34.09 arc(139.83,33.59) 140.42,33.6 arc(140.52,33.64) 140.64,33.65 140.9,33.64 141.14,33.4 142.52,33.4 144.41,31.5 154.99,31.5 155.13,31.36 155.13,31.1 155.22,31 155.51,31 155.61,31.1 155.61,31.36 155.75,31.5 155.95,31.5 156.09,31.36 156.09,31.07 156.23,30.93 156.43,30.93 156.58,31.07 156.58,31.36 156.72,31.5 156.92,31.5 157.06,31.36 157.06,31.07 157.2,30.93 157.4,30.93 157.54,31.07 157.54,31.36 157.68,31.5 157.88,31.5 158.02,31.36 158.02,31.07 158.16,30.93 158.36,30.93 158.51,31.07 158.51,31.36 158.65,31.5 158.85,31.5 158.99,31.36 158.99,31.07 159.13,30.93 159.33,30.93 159.47,31.07 159.47,31.36 159.61,31.5 159.81,31.5 159.95,31.36 159.95,31.07 160.1,30.93 160.3,30.93 160.44,31.07 160.44,31.36 160.58,31.5 160.78,31.5 160.92,31.36 160.92,31.07 161.06,30.93 161.26,30.93 161.4,31.07 161.4,31.36 161.54,31.5 165.8,31.5 167.45,29.85 172.86,29.85 173.51,30.5 174.06,30.5 174.2,30.36 174.2,30.14 174.34,30 174.54,30 174.68,30.14 174.68,30.36 174.82,30.5 175.02,30.5 175.16,30.36 175.16,30.14 175.31,30 175.51,30 175.65,30.14 175.65,30.36 175.79,30.5 175.99,30.5 176.13,30.36 176.13,30.14 176.27,30 176.47,30 176.61,30.14 176.61,30.36 176.75,30.5 176.95,30.5 177.09,30.36 177.09,30.14 177.24,30 177.44,30 177.58,30.14 177.58,30.36 177.72,30.5 177.92,30.5 178.06,30.36 178.06,30.14 178.2,30 178.4,30 178.54,30.14 178.54,30.36 178.68,30.5 179.27,30.5 179.75,30.98 181.74,30.98 v1(182.19,31.43)
  BOTTOM w0.109: v1(182.19,31.43) 182.58,31.43 183.04,30.98 183.65,30.98 183.74,31.06 183.74,31.54 183.83,31.64 184.07,31.64 184.16,31.55 184.16,31.15 184.25,31.06 184.55,31.06 184.66,31.17 184.66,31.3 184.77,31.4 CN1.58
DDR4_A_DQ23: length 60.9
  TOP w0.102: U1.CK14 v1(139.63,34.97)
  T03 w0.097: v1(181.19,31.43) 180.82,31.43 180.31,31.93 179.37,31.93 179.22,31.79 179.22,31.23 179.08,31.09 178.88,31.09 178.74,31.23 178.74,31.79 178.6,31.93 178.4,31.93 178.26,31.79 178.26,31.23 178.12,31.09 177.92,31.09 177.78,31.23 177.78,31.79 177.64,31.93 174.93,31.93 174.79,31.79 174.79,31.23 174.65,31.09 174.45,31.09 174.31,31.23 174.31,31.79 174.17,31.93 173.64,31.93 172.58,30.88 167.58,30.88 166.36,32.1 163.22,32.1 163.08,32.24 163.08,32.45 162.94,32.59 162.74,32.59 162.6,32.45 162.6,32.24 162.46,32.1 162.26,32.1 162.12,32.24 162.12,32.45 161.98,32.59 161.78,32.59 161.63,32.45 161.63,32.24 161.49,32.1 161.29,32.1 161.15,32.24 161.15,32.45 161.01,32.59 160.81,32.59 160.67,32.45 160.67,32.24 160.53,32.1 158.1,32.1 157.96,32.24 157.96,32.56 157.82,32.7 157.62,32.7 157.48,32.56 157.48,32.24 157.34,32.1 157.14,32.1 157,32.24 157,32.56 156.86,32.7 156.66,32.7 156.51,32.56 156.51,32.24 156.37,32.1 156.17,32.1 156.03,32.24 156.03,32.56 155.89,32.7 155.69,32.7 155.55,32.56 155.55,32.24 155.41,32.1 155.21,32.1 155.07,32.24 155.07,32.56 154.93,32.7 154.73,32.7 154.58,32.56 154.58,32.24 154.44,32.1 154.24,32.1 154.1,32.24 154.1,32.56 153.96,32.7 153.76,32.7 153.62,32.56 153.62,32.24 153.43,32.05 145.03,32.05 143.24,33.84 140.64,33.84 arc(140.47,33.83) 140.32,33.76 arc(139.93,33.76) 139.72,34.1 139.72,34.13 arc(139.65,34.39) 139.48,34.59 139.46,34.68 v1(139.63,34.97)
  BOTTOM w0.109: v1(181.19,31.43) 181.66,31.43 181.82,31.59 181.82,31.84 181.66,32 180.86,32 180.78,32.09 180.78,32.22 180.69,32.31 180.14,32.31 180.05,32.22 180.05,31.91 179.86,31.72 179.74,31.72 179.52,31.93 179.37,31.93 179.09,31.65 CN1.59
DDR4_A_DQ24: length 56.2
  TOP w0.102: U1.CD20 v1(137.15,37.55)
  T08 w0.097: v1(182.19,34.45) 181.76,34.45 181.35,34.04 180.95,34.04 180.81,34.18 177.5,34.18 177.01,34.66 175.6,34.66 175.6,34.67 175.51,34.67 173.17,37 167.67,37 165.85,35.18 162.77,35.18 162.44,35.51 153.65,35.51 152.68,34.54 152.21,34.54 152.06,34.68 152.06,34.93 151.92,35.07 151.72,35.07 151.58,34.93 151.58,34.68 151.44,34.54 144.97,34.54 144.7,34.81 144.7,35.01 144.81,35.12 144.81,35.32 144.67,35.47 144.47,35.47 144.35,35.35 144.15,35.35 142.23,37.28 140.61,37.28 arc(140.46,37.26) 140.32,37.2 arc(140.12,37.15) 139.92,37.2 arc(139.63,37.28) 139.33,37.2 arc(139.13,37.15) 138.93,37.2 arc(138.63,37.28) 138.34,37.2 arc(138.14,37.15) 137.94,37.2 137.49,37.46 137.4,37.55 v1(137.15,37.55)
  BOTTOM w0.109: v1(182.19,34.45) 182.45,34.45 182.86,34.86 184.48,34.86 184.6,34.74 184.6,34.01 184.7,33.91 184.98,33.91 185.06,34 185.06,34.34 185.12,34.41 CN1.70
DDR4_A_DQ25: length 56.4
  TOP w0.102: U1.CB20 v1(136.16,37.55)
  T08 w0.097: v1(183.19,34.45) 182.79,34.05 181.64,34.05 181.43,33.84 179.98,33.84 179.8,33.67 175.48,33.67 173.16,35.99 167.8,35.99 166.57,34.75 153.87,34.75 153.23,34.11 144.54,34.11 141.78,36.86 141.09,36.86 140.98,36.98 140.82,37.03 arc(140.62,37.09) 140.42,37.03 arc(140.12,36.95) 139.83,37.03 arc(139.63,37.09) 139.43,37.03 arc(139.13,36.95) 138.83,37.03 arc(138.63,37.09) 138.44,37.03 arc(138.14,36.95) 137.84,37.03 137.68,37.13 137.07,37.13 v1(136.16,37.55)
  BOTTOM w0.109: v1(183.19,34.45) 182.75,34.45 182.35,34.05 181.02,34.05 180.41,34.65 CN1.71
DDR4_A_DQ26: length 56.5
  TOP w0.102: U1.CD28 v1(137.15,40.98)
  T08 w0.097: v1(137.15,40.98) 137.55,41.38 153.71,41.38 153.85,41.23 153.85,40.88 153.99,40.74 154.2,40.74 154.34,40.88 154.34,41.23 154.48,41.38 154.68,41.38 154.82,41.23 154.82,40.88 154.96,40.74 155.16,40.74 155.3,40.88 155.3,41.23 155.44,41.38 155.64,41.38 155.78,41.23 155.78,40.88 155.93,40.74 156.13,40.74 156.27,40.88 156.27,41.23 156.41,41.38 156.61,41.38 156.75,41.23 156.75,40.88 156.89,40.74 157.09,40.74 157.23,40.88 157.23,41.23 157.37,41.38 164.9,41.38 165.9,42.38 172.82,42.38 172.94,42.26 176.36,42.26 179.9,38.72 180.41,38.72 180.77,38.36 181.31,38.36 v1(182.19,37.48)
  BOTTOM w0.109: v1(182.19,37.48) 181.71,37.01 179.58,37.01 179.34,37.24 179.34,37.51 179.2,37.66 CN1.83
DDR4_A_DQ27: length 56.4
  TOP w0.102: U1.CB28 v1(136.16,40.98)
  T08 w0.097: v1(181.19,37.48) 181.04,37.48 180.32,38.2 179.4,38.2 177.42,40.18 173.81,40.18 172.59,41.4 166.26,41.4 164.81,39.94 161.08,39.94 160.94,40.08 160.94,40.48 160.8,40.63 160.6,40.63 160.46,40.48 160.46,40.08 160.31,39.94 160.11,39.94 159.97,40.08 159.97,40.48 159.83,40.63 159.63,40.63 159.49,40.48 159.49,40.08 159.35,39.94 159.15,39.94 159.01,40.08 159.01,40.48 158.87,40.63 158.67,40.63 158.53,40.48 158.53,40.08 158.38,39.94 145.05,39.94 144.43,40.56 138.22,40.56 arc(138.07,40.58) 137.94,40.63 arc(137.64,40.71) 137.35,40.63 arc(137.15,40.58) 136.95,40.63 136.92,40.65 v1(136.16,40.98)
  BOTTOM w0.109: v1(181.19,37.48) 181.19,37.5 181.59,37.91 CN1.84
DDR4_A_DQ28: length 56.3
  TOP w0.102: U1.CF18 v1(137.64,36.69)
  T08 w0.097: v1(182.19,33.45) 181.64,32.9 175.18,32.9 173.16,34.92 167.87,34.92 166.64,33.69 160.42,33.69 160.28,33.83 160.28,33.96 160.14,34.11 159.94,34.11 159.8,33.96 159.8,33.83 159.66,33.69 159.46,33.69 159.31,33.83 159.31,33.96 159.17,34.11 158.97,34.11 158.83,33.96 158.83,33.83 158.69,33.69 158.49,33.69 158.35,33.83 158.35,33.96 158.21,34.11 158.01,34.11 157.87,33.96 157.87,33.83 157.73,33.69 157.53,33.69 157.38,33.83 157.38,33.96 157.24,34.11 157.04,34.11 156.9,33.96 156.9,33.83 156.76,33.69 156.56,33.69 156.42,33.83 156.42,33.96 156.28,34.11 156.08,34.11 155.94,33.96 155.94,33.83 155.79,33.69 155.59,33.69 155.45,33.83 155.45,33.96 155.31,34.11 155.11,34.11 154.97,33.96 154.97,33.83 154.83,33.69 144.16,33.69 141.61,36.24 138.09,36.24 v1(137.64,36.69)
  BOTTOM w0.109: CN1.66 185.23,33.4 185.08,33.25 184.83,33.25 184.63,33.46 184.1,33.46 183.99,33.57 183.99,34.02 183.9,34.11 183.45,34.11 183.21,33.87 182.87,33.87 182.76,33.76 182.76,33.28 182.67,33.19 182.45,33.19 v1(182.19,33.45)
DDR4_A_DQ29: length 56.6
  TOP w0.102: U1.CC18 v1(136.65,36.69)
  T08 w0.097: v1(181.19,33.45) 181.49,33.45 181.89,33.85 182.52,33.85 182.72,33.65 182.72,32.32 182.34,31.95 174.9,31.95 172.95,33.9 168.13,33.9 166.55,32.33 158.14,32.33 157.21,33.26 143.56,33.26 141.4,35.43 137.84,35.43 137.61,35.66 137.61,36.03 136.94,36.69 v1(136.65,36.69)
  BOTTOM w0.109: v1(181.19,33.45) 181.19,33.6 180.94,33.85 179.67,33.85 179.48,33.65 CN1.67
DDR4_A_DQ30: length 56.6
  TOP w0.102: U1.CF26 v1(137.64,40.12)
  T08 w0.097: v1(137.64,40.12) 137.91,39.86 138.34,39.61 arc(138.48,39.47) 138.54,39.27 138.54,39.17 138.87,38.84 143.34,38.84 144.1,38.08 152.87,38.08 153.02,38.22 153.02,38.45 153.16,38.59 153.36,38.59 153.5,38.45 153.5,38.22 153.64,38.08 153.84,38.08 153.98,38.22 153.98,38.45 154.12,38.59 154.32,38.59 154.46,38.45 154.46,38.22 154.6,38.08 154.8,38.08 154.95,38.22 154.95,38.45 155.09,38.59 155.29,38.59 155.43,38.45 155.43,38.22 155.57,38.08 155.77,38.08 155.91,38.22 155.91,38.45 156.05,38.59 156.25,38.59 156.39,38.45 156.39,38.22 156.53,38.08 156.74,38.08 156.88,38.22 156.88,38.45 157.02,38.59 157.22,38.59 157.36,38.45 157.36,38.22 157.5,38.08 157.7,38.08 157.84,38.22 157.84,38.45 157.98,38.59 158.18,38.59 158.32,38.45 158.32,38.22 158.47,38.08 165.43,38.08 166.76,39.42 173.09,39.42 174.48,38.03 177.53,38.03 179.55,36.01 181.72,36.01 v1(182.19,36.48)
  BOTTOM w0.109: CN1.79 179.74,36.66 180.4,36 181.56,36 182.03,36.46 182.17,36.46 v1(182.19,36.48)
DDR4_A_DQ31: length 56.3
  TOP w0.102: U1.CC26 v1(136.65,40.12)
  T08 w0.097: v1(136.65,40.12) 137.42,40.45 137.44,40.47 arc(137.64,40.52) 137.84,40.47 138.06,40.34 138.17,40.23 138.17,40 138.34,39.83 138.44,39.77 arc(138.55,39.73) 138.67,39.72 138.71,39.69 143.91,39.69 144.24,39.35 160.07,39.35 160.21,39.21 160.21,38.99 160.35,38.85 160.55,38.85 160.69,38.99 160.69,39.21 160.83,39.35 161.03,39.35 161.17,39.21 161.17,38.99 161.31,38.85 161.52,38.85 161.66,38.99 161.66,39.21 161.8,39.35 162,39.35 162.14,39.21 162.14,38.99 162.28,38.85 162.48,38.85 162.62,38.99 162.62,39.21 162.76,39.35 162.96,39.35 163.1,39.21 163.1,38.99 163.25,38.85 163.45,38.85 163.59,38.99 163.59,39.21 163.73,39.35 163.93,39.35 164.07,39.21 164.07,38.99 164.21,38.85 164.41,38.85 164.55,38.99 164.55,39.21 164.69,39.35 165.38,39.35 166.43,40.41 172.81,40.41 173.65,39.56 177.07,39.56 179.66,36.98 182.69,36.98 v1(183.19,36.48)
  BOTTOM w0.109: v1(183.19,36.48) 183.19,36.58 183.52,36.91 CN1.80
DDR4_A_DQ32: length 58
  TOP w0.102: U1.CD66 v1(137.15,57.58)
  T08 w0.097: v1(181.19,62.4) 180.85,62.4 180.43,62.82 180.02,62.82 179.92,62.73 178.07,62.73 177.21,61.86 174.71,61.86 173.6,62.97 172.67,63.9 169.15,63.9 168.72,63.47 167.86,63.47 167.1,64.23 166.18,64.23 165.4,63.45 156.03,63.45 155.92,63.33 155.92,62.94 155.81,62.83 155.65,62.83 155.53,62.94 155.53,63.33 155.42,63.45 155.26,63.45 155.15,63.33 155.15,62.94 155.03,62.83 154.87,62.83 154.76,62.94 154.76,63.33 154.65,63.45 154.49,63.45 154.37,63.33 154.37,62.94 154.26,62.83 154.1,62.83 153.99,62.94 153.99,63.33 153.88,63.45 153.54,63.45 152.33,62.24 145.07,62.24 140.73,57.9 140.51,57.9 140.33,58.08 139.9,58.08 139.77,57.96 139.44,57.96 139.26,58.14 138.98,58.14 138.78,57.93 138.45,57.93 138.22,58.16 138.02,58.16 137.66,57.8 v1(137.15,57.58)
  BOTTOM w0.109: v1(181.19,62.4) 181.19,62.4 181.59,62.4 181.99,61.99 183.36,61.99 183.99,62.63 185.03,62.63 185.25,62.41 CN1.174
DDR4_A_DQ33: length 58.1
  TOP w0.102: U1.CB66 v1(136.16,57.58)
  T08 w0.097: v1(136.16,57.58) 136.71,57.82 137.14,58.25 137.14,58.6 137.4,58.86 141.06,58.86 144.89,62.69 152.13,62.69 153.34,63.9 157.96,63.9 158.13,64.07 158.13,64.1 158.3,64.27 158.54,64.27 158.71,64.1 158.71,64.07 158.88,63.9 159.12,63.9 159.29,64.07 159.29,64.1 159.46,64.27 159.7,64.27 159.87,64.1 159.87,64.07 160.03,63.9 160.27,63.9 160.44,64.07 160.44,64.1 160.61,64.27 160.85,64.27 161.02,64.1 161.02,64.07 161.19,63.9 161.43,63.9 161.6,64.07 161.6,64.1 161.77,64.27 162.01,64.27 162.18,64.1 162.18,64.07 162.35,63.9 162.59,63.9 162.76,64.07 162.76,64.1 162.93,64.27 163.17,64.27 163.34,64.1 163.34,64.07 163.51,63.9 164.86,63.9 165.86,64.89 172.28,64.89 174.02,63.15 179.75,63.15 179.88,63.28 180.57,63.28 180.89,62.96 181.63,62.96 v1(182.19,62.4)
  BOTTOM w0.109: v1(182.19,62.4) 182.5,62.4 182.6,62.5 182.6,62.8 182.49,62.92 180.95,62.92 180.85,62.82 180,62.82 179.34,62.16 CN1.173
DDR4_A_DQ34: length 58.2
  TOP w0.102: U1.CD72 v1(137.15,61.01)
  T08 w0.097: v1(137.15,61.01) 137.15,61.03 137.9,61.78 137.9,62.11 138.12,62.33 139.6,62.33 145.56,68.28 167.65,68.28 168.35,68.98 172.87,68.98 175.03,66.82 177.3,66.82 177.42,66.93 177.42,66.97 177.53,67.08 177.69,67.08 177.8,66.97 177.8,66.93 177.92,66.82 178.08,66.82 178.19,66.93 178.19,66.97 178.3,67.08 178.46,67.08 178.57,66.97 178.57,66.93 178.69,66.82 179.09,66.82 179.97,65.93 181.33,65.93 181.64,65.62 181.64,65.23 181.95,64.92 182.67,64.92 v1(183.19,65.43)
  BOTTOM w0.109: v1(183.19,65.43) 183.24,65.48 183.24,65.73 183.13,65.83 182.01,65.83 181.89,65.71 181.49,65.71 181.37,65.83 180.9,65.83 180.72,65.66 CN1.187
DDR4_A_DQ35: length 58.1
  TOP w0.102: U1.CB72 v1(136.16,61.01)
  T08 w0.089: 165.12,68.95 166.63,68.95
  T08 w0.097: 166.63,68.95 167.65,69.96 173.11,69.96 175.24,67.83 179.79,67.83 180.66,66.96 181.35,66.96 181.75,66.57 181.75,66.12 182.19,65.68 v1(182.19,65.43) ; v1(136.16,61.01) 136.88,61.73 136.88,61.96 137.81,62.89 139.28,62.89 145.34,68.95 165.12,68.95
  BOTTOM w0.109: v1(182.19,65.43) 182.74,64.88 183.66,64.88 183.79,65 183.79,65.82 183.88,65.91 184.56,65.91 184.65,65.82 184.65,65.55 184.79,65.41 CN1.186
DDR4_A_DQ36: length 58.2
  TOP w0.102: U1.CF64 v1(137.64,56.72)
  T08 w0.097: v1(183.19,61.4) 182.75,61.84 178,61.84 177.59,61.44 173.96,61.44 172.52,62.88 167.86,62.88 167.76,62.98 159.24,62.98 159.13,62.87 159.13,62.49 159.02,62.38 158.86,62.38 158.75,62.49 158.75,62.87 158.63,62.98 158.47,62.98 158.36,62.87 158.36,62.49 158.25,62.38 158.09,62.38 157.97,62.49 157.97,62.87 157.86,62.98 157.7,62.98 157.59,62.87 157.59,62.49 157.47,62.38 157.31,62.38 157.2,62.49 157.2,62.87 157.09,62.98 156.77,62.98 155.08,61.29 144.79,61.29 140.68,57.17 140.33,57.17 140.28,57.12 139.9,57.12 139.75,57.27 139.49,57.27 139.31,57.09 138.96,57.09 138.76,57.3 138.5,57.3 138.27,57.07 137.99,57.07 v1(137.64,56.72)
  BOTTOM w0.109: CN1.170 185.28,61.41 185.14,61.27 185.14,61.04 185.03,60.93 184.69,60.93 184.6,61.02 184.6,62.14 184.49,62.26 184.22,62.26 183.79,61.82 183.79,61.23 183.7,61.14 183.45,61.14 v1(183.19,61.4)
DDR4_A_DQ37: length 57.9
  TOP w0.102: U1.CC64 v1(136.65,56.72)
  T08 w0.097: v1(136.65,56.72) 136.91,56.46 137.13,56.46 137.31,56.28 140.82,56.28 144.39,59.86 144.39,60.28 144.97,60.86 158.33,60.86 160.02,62.56 162.91,62.56 163.02,62.44 163.02,62.29 163.14,62.17 163.3,62.17 163.41,62.29 163.41,62.44 163.52,62.56 167.58,62.56 168.22,61.92 172.64,61.92 173.67,60.89 174.1,60.89 174.21,60.77 174.21,60.44 174.32,60.33 174.48,60.33 174.6,60.44 174.6,60.77 174.71,60.89 174.87,60.89 174.98,60.77 174.98,60.44 175.1,60.33 175.26,60.33 175.37,60.44 175.37,60.77 175.48,60.89 177.73,60.89 178.15,61.31 180.18,61.31 180.53,60.95 181.02,60.95 181.46,61.4 v1(182.19,61.4)
  BOTTOM w0.109: v1(182.19,61.4) 181.79,61.4 181.36,61.83 180.5,61.83 180.39,61.72 180.39,61.24 180.3,61.15 179.99,61.15 179.89,61.24 179.89,61.59 179.81,61.68 179.51,61.68 179.4,61.57 179.4,61.31 179.27,61.18 178.35,61.18 CN1.169
DDR4_A_DQ38: length 57.8
  TOP w0.102: U1.CF71 v1(137.64,60.15)
  T08 w0.097: v1(181.19,64.43) 180.88,64.43 180.4,64.91 178.45,64.91 177.68,65.67 174.64,65.67 173.34,66.97 167.41,66.97 166.87,66.44 152.77,66.44 152.51,66.17 152.35,66.17 152.19,66.32 152.03,66.32 151.92,66.21 151.92,66.05 152.07,65.9 152.07,65.74 151.96,65.62 151.8,65.62 151.65,65.78 151.49,65.78 151.37,65.66 151.37,65.5 151.53,65.35 151.53,65.19 151.12,64.78 144.08,64.78 143.32,64.02 143.32,63.86 143.59,63.6 143.59,63.44 143.47,63.32 143.31,63.32 143.05,63.59 142.89,63.59 142.78,63.48 142.78,63.32 143.04,63.05 143.04,62.89 142.93,62.78 142.77,62.78 142.5,63.04 142.34,63.04 142.23,62.93 142.23,62.77 142.49,62.5 142.49,62.34 142.38,62.23 142.22,62.23 141.96,62.5 141.8,62.5 141.54,62.24 141.54,61.36 140.78,60.6 138.39,60.6 138.17,60.38 v1(137.64,60.15)
  BOTTOM w0.109: v1(181.19,64.43) 181.19,64.43 181.66,64.43 181.82,64.59 181.82,64.84 181.66,65 180.86,65 180.78,65.09 180.78,65.22 180.69,65.31 180.14,65.31 180.05,65.22 180.05,64.91 179.86,64.72 179.74,64.72 179.52,64.93 179.37,64.93 179.1,64.66 CN1.183
DDR4_A_DQ39: length 58.1
  TOP w0.102: U1.CC71 v1(136.65,60.15)
  T08 w0.089: 145.67,67.4 148.37,67.4 148.48,67.29 148.48,67.26 148.58,67.16 148.73,67.16 148.83,67.26 148.83,67.29 148.94,67.4 149.08,67.4 149.19,67.29 149.19,67.26 149.29,67.16 149.44,67.16 149.54,67.26 149.54,67.29 149.65,67.4 149.79,67.4 149.9,67.29 149.9,67.26 150,67.16 150.15,67.16 150.25,67.26 150.25,67.29 150.36,67.4 150.5,67.4 150.61,67.29 150.61,67.26 150.71,67.16 150.86,67.16 150.96,67.26 150.96,67.29 151.07,67.4 152.23,67.4
  T08 w0.097: v1(136.65,60.15) 137.22,60.58 137.33,60.58 137.58,60.83 137.58,61.07 137.96,61.45 140.65,61.45 141.06,61.85 141.06,62.78 145.67,67.4 ; 152.23,67.4 152.68,66.94 166.03,66.94 166.81,67.72 169.04,67.72 169.3,67.99 173.05,67.99 174.65,66.39 178.75,66.39 179.79,65.35 180.64,65.35 181.05,64.94 181.33,64.94 181.84,64.43 v1(182.19,64.43)
  BOTTOM w0.109: v1(182.19,64.43) 182.19,64.43 182.58,64.43 183.04,63.98 183.65,63.98 183.74,64.06 183.74,64.54 183.83,64.64 184.07,64.64 184.16,64.55 184.16,64.15 184.25,64.06 184.55,64.06 184.66,64.17 184.66,64.37 184.7,64.41 CN1.182
DDR4_A_DQ40: length 63
  TOP w0.102: U1.CL66 v1(140.12,57.58)
  T03 w0.089: 168.7,66.94 172.44,66.94 ; v1(140.12,57.58) 140.31,57.58
  T03 w0.097: 140.31,57.58 140.34,57.58 141.11,58.34 141.11,58.82 143.01,60.72 143.01,61.89 143.82,62.7 143.82,62.9 143.5,63.21 143.5,63.41 143.65,63.56 143.85,63.56 144.16,63.24 144.36,63.24 145.73,64.61 151.8,64.61 152.27,65.07 152.27,65.27 151.99,65.55 151.99,65.75 152.13,65.89 152.33,65.89 152.61,65.61 152.81,65.61 152.95,65.75 152.95,65.95 152.68,66.23 152.68,66.43 152.82,66.57 153.02,66.57 153.29,66.29 153.49,66.29 153.64,66.43 153.64,66.63 153.36,66.91 153.36,67.11 153.5,67.25 153.7,67.25 153.98,66.97 154.18,66.97 154.32,67.11 154.32,67.31 154.04,67.59 154.04,67.79 154.19,67.93 154.39,67.93 154.66,67.65 154.86,67.65 155.41,68.2 161.33,68.2 161.47,68.05 161.47,67.72 161.61,67.58 161.81,67.58 161.96,67.72 161.96,68.05 162.1,68.2 162.3,68.2 162.44,68.05 162.44,67.72 162.58,67.58 162.78,67.58 162.92,67.72 162.92,68.05 163.06,68.2 165.62,68.2 166.87,66.94 168.7,66.94 ; v1(183.19,67.45) 182.79,67.05 181.73,67.05 181.54,66.86 175.96,66.86 175.88,66.94 175.43,66.94 175.29,66.8 175.29,66.76 175.15,66.62 174.95,66.62 174.81,66.76 174.81,66.8 174.67,66.94 174.47,66.94 174.33,66.8 174.33,66.76 174.19,66.62 173.99,66.62 173.85,66.76 173.85,66.8 173.7,66.94 173.5,66.94 173.36,66.8 173.36,66.76 173.22,66.62 173.02,66.62 172.88,66.76 172.88,66.8 172.74,66.94 172.44,66.94
  BOTTOM w0.109: CN1.195 180.31,67.66 180.92,67.05 182.75,67.05 182.78,67.08 182.81,67.08 183.18,67.45 v1(183.19,67.45)
DDR4_A_DQ41: length 63.3
  TOP w0.102: U1.CJ66 v1(139.13,57.58)
  T03 w0.089: 146.36,67.43 146.61,67.69 147.2,67.69 ; 140.87,59.11 140.68,59.07 arc(140.21,58.79) 140.03,58.28 140.03,58.18 139.42,57.58 v1(139.13,57.58)
  T03 w0.097: 140.87,59.11 142.55,60.79 142.55,63.62 146.36,67.43 ; 147.2,67.69 148.38,67.69 148.52,67.83 148.52,68.21 148.66,68.35 148.86,68.35 149,68.21 149,67.83 149.14,67.69 149.34,67.69 149.48,67.83 149.48,68.21 149.62,68.35 149.82,68.35 149.96,68.21 149.96,67.83 150.11,67.69 150.31,67.69 150.45,67.83 150.45,68.21 150.59,68.35 150.79,68.35 150.93,68.21 150.93,67.83 151.07,67.69 151.27,67.69 151.41,67.83 151.41,68.21 151.55,68.35 151.75,68.35 151.9,68.21 151.9,67.83 152.04,67.69 152.59,67.69 154.16,69.25 160.34,69.25 160.48,69.4 160.48,69.72 160.62,69.86 160.82,69.86 160.96,69.72 160.96,69.4 161.1,69.25 161.3,69.25 161.44,69.4 161.44,69.72 161.58,69.86 161.78,69.86 161.93,69.72 161.93,69.4 162.07,69.25 162.27,69.25 162.41,69.4 162.41,69.72 162.55,69.86 162.75,69.86 162.89,69.72 162.89,69.4 163.03,69.25 168.67,69.25 168.96,68.97 172.32,68.97 173.5,67.79 177.16,67.79 177.56,67.39 180.56,67.39 180.89,67.06 181.35,67.06 181.74,67.45 v1(182.19,67.45)
  BOTTOM w0.109: CN1.194 185.13,67.41 185.09,67.37 185.09,67 185,66.91 184.7,66.91 184.6,67.01 184.6,67.74 184.48,67.86 182.86,67.86 182.45,67.45 182.19,67.45 v1(182.19,67.45)
