# Allegro board T77O994T01_015_20180530.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_B_ECC7: length 41.1
  TOP w0.089: U1.CR35 142.86,43.8 143.2,44.15 143.55,44.15 143.7,43.99 144.38,43.99 144.5,43.87 144.86,43.87 145.26,43.48 146.58,43.48 v1(147.28,42.78)
  TOP w0.109: CN2.104 167.82,42.96 167.91,42.87 167.91,42.46 168.03,42.34 168.27,42.34 168.36,42.43 168.36,42.73 168.45,42.82 168.69,42.82 168.78,42.73 168.78,42.43 168.87,42.34 169.29,42.34 169.44,42.49 169.66,42.49 170.1,42.93 v1(170.46,42.93)
  T10 w0.097: v1(147.28,42.78) 147.28,43.09 147.49,43.3 153.38,43.3 154.18,42.5 157.79,42.5 158.98,43.68 160.88,43.68 161.03,43.54 161.03,43.13 161.17,42.99 161.37,42.99 161.51,43.13 161.51,43.54 161.65,43.68 161.85,43.68 161.99,43.54 161.99,43.13 162.13,42.99 162.33,42.99 162.47,43.13 162.47,43.54 162.61,43.68 162.82,43.68 162.96,43.54 162.96,43.13 163.1,42.99 163.3,42.99 163.44,43.13 163.44,43.54 163.58,43.68 163.78,43.68 163.92,43.54 163.92,43.13 164.06,42.99 164.26,42.99 164.4,43.13 164.4,43.54 164.55,43.68 164.75,43.68 164.89,43.54 164.89,43.13 165.03,42.99 165.23,42.99 165.37,43.13 165.37,43.54 165.51,43.68 167.33,43.68 167.62,43.39 170,43.39 v1(170.46,42.93)
DDR4_B_ODT0: length 36.8
  TOP w0.089: U1.CV64 144.55,57.16 144.69,57.3 146.57,57.3 146.66,57.4 149.59,57.4 150.86,58.66 v1(150.86,58.68)
  TOP w0.109: v1(171.29,57.02) 172,57.23 172.3,57.43 172.42,57.46 173.47,57.71 174.28,57.71 174.42,57.72 CN2.155
  T05 w0.152: v1(150.86,58.68) 150.95,58.68 151.33,59.06 151.36,59.06 151.4,59.09 151.74,59.09 151.78,59.06 152.07,59.06 152.1,59.03 159.08,59.03 159.11,59.06 164.11,59.06 164.53,58.63 164.93,58.63 165.1,58.46 165.1,58.24 165.26,58.08 165.57,58.08 165.73,58.24 165.73,58.59 165.89,58.74 166.21,58.74 166.37,58.59 166.37,57.56 166.51,57.42 166.83,57.42 167,57.59 167,58.59 167.16,58.74 167.48,58.74 167.64,58.59 167.64,58.24 167.8,58.08 168.22,58.08 168.37,58.24 168.55,58.24 168.9,57.88 169.08,57.88 169.51,58.31 169.69,58.31 170.14,57.87 170.32,57.87 170.67,58.23 170.9,58.23 171.29,57.83 v1(171.29,57.02)
DDR4_B_ODT1: length 34.5
  TOP w0.089: v1(146.58,60.27) 146.15,59.84 144.22,59.84 144.2,59.82 143.65,59.82 143.49,59.98 143.19,59.98 142.85,59.64 U1.CR69
  TOP w0.171: v1(169.62,59.15) 170.36,59.49 170.62,59.59 170.75,59.61 171.08,59.54 171.49,59.59 171.97,59.6 173.63,59.21 174.28,59.21 174.42,59.22 CN2.161
  T05 w0.152: v1(146.58,60.27) 146.58,60.09 146.88,59.79 150.99,59.79 151.04,59.84 151.21,59.84 151.47,60.1 152.25,60.1 152.63,60.49 161.1,60.49 161.18,60.56 164.42,60.56 164.68,60.82 167.52,60.82 167.72,60.62 167.72,59.9 167.91,59.71 168.73,59.71 168.88,59.56 169.21,59.56 v1(169.62,59.15)
DDR4_B_PAR: length 41.8
  TOP w0.089: v1(150.16,54.73) 149.7,55.19 146.78,55.19 146.73,55.13 144.62,55.13 144.37,54.88 143.9,54.88 143.75,55.04 143.19,55.04 142.84,54.69 U1.CR59
  TOP w0.109: v1(169.62,52.88) 169.62,53.18 169.75,53.31 170.92,53.31 171.22,53 171.34,53 171.65,53.31 172.11,53.31 172.36,53.06 172.56,53.06 172.82,53.31 173.22,53.31 173.82,52.71 174.28,52.71 174.42,52.72 CN2.143
  T10 w0.152: v1(169.62,52.88) 169.17,53.32 167.72,53.32 166.55,54.5 165.81,54.5 165.54,54.23 165.54,53.4 165.27,53.13 164.89,53.13 164.63,53.4 164.63,54.23 164.36,54.5 163.98,54.5 163.71,54.23 163.71,53.4 163.44,53.13 163.06,53.13 162.8,53.4 162.8,54.23 162.53,54.5 160.45,54.5 160.09,54.14 159.54,54.14 159.18,54.5 158.62,54.5 158.26,54.14 157.71,54.14 157.35,54.5 156.79,54.5 156.44,54.14 155.88,54.14 155.52,54.5 154.51,54.5 154.24,54.23 154.24,53.5 153.97,53.23 153.59,53.23 153.33,53.5 153.33,54.23 153.06,54.5 152.41,54.5 151.97,54.06 150.82,54.06 v1(150.16,54.73)
DDR4_B_SA0: length 9.6
  TOP w0.089: CN2.256 167.22,82.97 167.47,83.22 167.47,84.24 166.96,84.74 165.62,84.74
  TOP w0.127: R235.2 161.16,82.76 162,83.6 163.14,83.6 163.45,83.91 R238.1 163.75,84.09 164.41,84.74 165.62,84.74
DDR4_B_SA1: length 7.5
  TOP w0.089: 165.62,84.11 165.65,84.11 165.78,83.97 CN2.260
  TOP w0.127: 165.62,84.11 164.67,84.11 163.76,83.2 163.76,82.62 R239.1 163.27,82.49 163.27,82.71 163.15,82.84 162.26,82.84 162,82.59 162,82.08 161.73,81.8 R236.2
DDR4_B_SA2: length 52.2
  TOP w0.127: v1(168.45,60.7) 168.21,60.46 166.5,60.46 CN2.166 ; R237.2 161.14,85.39 161.47,85.71 163.09,85.71 163.45,85.36 R449.1 163.64,85.11 v1(164.29,85.76)
  T05 w0.127: v1(164.29,85.76) 164.31,85.76 165.96,87.42 173.2,87.42 174.8,85.82 174.8,62.5 172.79,60.5 172.3,60.5 171.96,60.16 171.74,60.16 171.46,60.45 171.12,60.45 170.89,60.22 170.58,60.22 170.35,60.45 170.01,60.45 169.73,60.16 169.5,60.16 169.19,60.47 168.68,60.47 v1(168.45,60.7)
  BOTTOM w0.127: v2(167.28,60.49) 167.49,60.7 v1(168.45,60.7)
DDR4_SCL_1V05: length 7.7
  TOP w0.109: R117.2 R127.2 141.85,80.76 142.11,81.02 142.11,81.75 140.92,82.94 U7.2 140.92,84.69 140.58,85.02 v3(139.19,85.02)
DDR4_SCL_1V05_ST: length 39.5
  TOP w0.108: U1.CD58 v1(137.15,54.72)
  TOP w0.109: v3(140.99,82.18) 141.58,81.59 R127.1
  T10 w0.097: v3(140.99,82.18) 139.22,80.42 139.22,79.88 136.23,76.89 135.87,76.89 135.86,76.89 134.13,76.89 132.97,76.89 129.23,73.15 129.23,72.8 129.23,72.8 129.23,72.64 129.23,72.64 129.23,71.32
  T10 w0.102: 129.23,71.32 128.97,71.05 128.97,66.25 133.76,61.45 134.37,61.45 134.68,61.14 134.68,60.8 135.11,60.37 135.11,60.04 135.61,59.53 135.61,59.15 136.12,58.64 136.12,58.3 136.65,57.77 136.65,57.44 137.15,56.94 v1(137.15,54.72)
DDR4_SCL_2V5: length 60.5
  TOP w0.109: CN2.253 174.42,82.22 174.27,82.21 173.76,82.21 173.41,82.57 v1(173.25,82.57)
  T08 w0.097: v1(173.25,82.57) 173.21,82.61 166.48,82.61 164.92,81.06 163.72,81.06 163.37,80.7 163.35,80.7 161.42,78.78 143.59,78.78 140.35,82.01 v3(140.35,91.71)
  T08 w0.102: v1(173.25,82.57) 173.27,82.58 174.79,82.58 174.89,82.68 174.89,82.86 175,82.96 175.2,82.96 175.3,82.86 175.3,82.68 175.4,82.58 175.61,82.58 175.71,82.68 175.71,82.86 175.81,82.96 176.01,82.96 176.11,82.86 176.11,82.68 176.22,82.58 176.42,82.58 176.52,82.68 176.52,82.86 176.62,82.96 176.82,82.96 176.93,82.86 176.93,82.68 177.03,82.58 177.23,82.58 177.33,82.68 177.33,82.86 177.43,82.96 177.64,82.96 177.74,82.86 177.74,82.68 177.84,82.58 178.96,82.58 v1(179.45,83.07)
  BOTTOM w0.109: v3(140.35,91.71) 140.35,91.26 140.64,90.97 R128.2 ; v1(179.45,83.07) 179.45,82.57 179.05,82.17 CN1.253 176.97,82.17 v2(176.6,82.53)
DDR4_SCL_2V5_ST: length 4.4
  TOP w0.109: U7.7 v3(140.92,89.29) 140.92,89.83 R121.1
  BOTTOM w0.109: v2(140.66,88.35) 140.66,89.03 v3(140.92,89.29) 140.92,89.83 R121.1
DDR4_SDA_1V05: length 4.9
  TOP w0.109: U7.3 141.57,82.95 142.18,82.33 v3(142.18,82.33) 142.19,82.33 142.61,81.9 R125.2 R116.2
  BOTTOM w0.109: v3(142.18,82.33) 142.18,81.54 v2(141.98,81.34)
DDR4_SDA_1V05_ST: length 42.5
  TOP w0.108: U1.CC60 v1(136.65,55.57)
  TOP w0.109: v3(142.83,82.84) 143.42,82.24 R125.1
  T10 w0.102: v3(142.83,82.84) 142.47,83.2 140.12,83.2 138.75,81.83 138.75,80 135.99,77.23 132.89,77.23 128.66,73 128.66,66.09 133.72,61.04 133.72,60.89 134.15,60.46 134.15,60.03 134.7,59.47 134.7,59.04 135.16,58.59 135.16,57.07 v1(136.65,55.57)
DDR4_SDA_2V5: length 69.3
  TOP w0.089: v1(167.21,85.38) 167.72,84.87 167.72,82.84 167.35,82.47 CN2.254
  T08 w0.097: v1(167.21,85.38) 167.21,84.31 164.25,81.36 163.6,81.36 163.24,81 163.22,81 161.5,79.28 144.48,79.28 141.56,82.2 141.56,91.01 v3(142.26,91.71)
  T08 w0.102: v1(167.21,85.38) 167.9,86.07 184.86,86.07 v1(185.44,85.49)
  BOTTOM w0.109: R126.2 v3(142.26,91.71) ; CN1.254 185.41,82.42 185.12,82.71 185.12,85.17 v1(185.44,85.49) 185.44,86.95 v2(185.77,87.28)
DDR4_SDA_2V5_ST: length 6.2
  TOP w0.109: R120.1 142.26,89.69 v3(142,89.44) 142,89.36 141.57,88.93 U7.6
  BOTTOM w0.109: v2(140.92,87.03) 141.4,87.5 141.4,88.76 142,89.36 v3(142,89.44) 142.26,89.69 R120.1
DDR4_VRHOT_L: length 185.4
  TOP w0.109: v3(55.09,26.83) U33.2
  TOP w0.254: v3(199.3,29.35) 199.08,29.14 PU21.30
  T05 w0.097: v3(199.3,29.35) 199.3,28.78 196.85,26.32 194.3,26.32 192.71,24.73 192.71,15.97 193.85,14.82 193.85,9.08 v3(193.55,8.78) ; v3(81.03,19.17) 80.66,19.54 69.72,19.54 68.19,21.07 60.84,21.07 v3(55.09,26.83)
  T08 w0.097: v3(81.03,19.17) 81.46,19.17 82.62,18 83.66,18 84.28,18.62 98.02,18.62 98.86,19.46 105.55,19.46 106.23,20.14 107.43,20.14 107.62,19.96 108.61,19.96 109.22,20.56 116.06,20.56 116.67,19.95 116.83,19.95 118.41,18.38 118.41,18.21 120.41,16.22 123.04,16.22 126.21,13.05 126.77,13.05 127.38,12.44 127.38,8.41 127.37,8.4 127.37,8.2 128.41,7.16 128.41,6.95 129.7,5.67 139.91,5.67 141.59,3.99 154.62,3.99 155.53,4.89 165.4,4.89 166.39,5.88 170.18,5.88 170.89,5.17 182.45,5.17 184.96,7.68 189.15,7.68 190.42,8.95 193.37,8.95 v3(193.55,8.78)
  BOTTOM w0.109: v3(199.3,29.35) 199.89,29.35 200.02,29.23 PR210.2
DDR_RCOMP0: length 24.9
  TOP w0.089: R176.2 143.68,67.49 143.97,67.2 145.9,67.2 v1(146.55,66.55)
  TOP w0.108: U1.CC52 v1(136.65,52.14)
  T10 w0.102: 141.58,59.07 140.44,57.18 140.13,56.87 140.13,56.23 139.9,56 139.39,56 139.3,55.91 139.29,55.9 137.46,52.67 136.93,52.14 v1(136.65,52.14)
  T10 w0.127: v1(146.55,66.55) 146.53,66.53 145.1,66.53 141.58,63.01 141.58,59.07
  BOTTOM w0.089: v2(146.3,67.6) 146.3,66.8 v1(146.55,66.55)
DDR_RCOMP1: length 26.9
  TOP w0.089: R173.2 144.7,67.8 144.99,67.52 146.29,67.52 v1(147.24,66.57)
  TOP w0.108: U1.CD51 v1(137.15,51.28)
  T10 w0.102: v1(137.15,51.28) 136.44,51.66 136.19,51.91 136.19,52.2 136.5,52.67 136.66,53.32 137.05,54.04 137.59,54.58 138.1,55.47 138.27,55.82 138.36,55.9 138.86,56.36 138.99,56.49 140.39,58.9 141.17,59.68
  T10 w0.127: v1(147.24,66.57) 146.73,67.07 145,67.07 141.17,63.24 141.17,59.68
  BOTTOM w0.089: v1(147.24,66.57) 147.24,66.71 v2(147.87,67.34)
DDR_RCOMP2: length 26.3
  TOP w0.089: v1(147.47,65.92) 147.68,66.13 147.68,66.69 146.56,67.81 145.95,67.81 R172.2
  TOP w0.108: U1.CC49 v1(136.65,50.42)
  T10 w0.102: 144.95,65.61 144.52,65.18 ; v1(136.65,50.42) 137.41,50.89 138.23,52.31 140.33,55.89 140.51,56 140.91,56 141.18,56.27 143.02,60.12 143.02,63.68 143.81,64.48
  T10 w0.127: 144.95,65.61 145.26,65.92 v1(147.47,65.92) ; 144.52,65.18 143.81,64.48
  BOTTOM w0.089: v2(148.76,66.25) 148.43,65.92 v1(147.47,65.92)
DIFF_XCLK_BIASREF: length 2.7
  TOP w0.152: U1.AA18 v1(117.29,36.55)
  BOTTOM w0.089: R50.1 117.68,36.16 v1(117.29,36.55)
  BOTTOM w0.102: v2(116.48,35.55) 116.48,35.74 117,36.26 v1(117.29,36.55)
DMI_RCOMP_PCH: length 4.3
  TOP w0.152: U1.AA28 v1(117.32,41.24)
  BOTTOM w0.102: v2(115.46,38.86) 115.46,39.36 115.85,39.75 116.73,39.75 116.94,39.95 R160.2 116.94,40.87 v1(117.32,41.24)
FP_IBMC_PWRBTN_OUT_L: length 217.6
  TOP w0.089: U1.AW3 126.01,29.19 125.98,29.16 125.98,28.73 126.01,28.71 126.01,28.7 126.29,28.41 126.29,27.73 126.49,27.54 126.49,25.87 126.51,25.85 126.51,24.29
  TOP w0.109: v3(29,57.74) 28.36,58.38 28.36,59.69 26.67,61.37 20.54,61.37 20.16,60.99 19.61,60.99 19.21,61.4 C187.1 C193.1 18.53,62.37 17.06,63.84 17.06,67.27 13.68,70.65 13.68,71.92 13.24,72.36 J12.41 ; 126.51,24.29 125.7,23.48 125.7,21.39 126.92,20.17 126.92,14.24 R396.1 125.81,13.77 124.29,15.29 v3(123.33,15.29) ; v3(64.77,16.53) 65.25,16.05 65.25,10.65 64.35,9.75 J10.B48 ; U31.R1 v1(43.15,49.28)
  T05 w0.097: v1(43.15,49.28) 43.05,49.28 39.64,45.87 39.64,45.38 37.95,43.69 37.77,43.52 36.9,42.64 35.52,41.26 35.52,41.01 35.52,38.01 35.21,37.7 35.21,18.91 v3(35.31,18.81)
  T08 w0.097: v3(35.31,18.81) 36.56,17.55 63.74,17.55 v3(64.77,16.53) 65.41,17.16 84.33,17.16 85.19,18.02 98.27,18.02 98.91,18.66 103.28,18.66 105.47,16.47 105.96,16.47 106.3,16.81 106.3,18.6 106.17,18.72 106.17,19.09 106.92,19.84 107.31,19.84 107.58,19.57 108.76,19.57 109.36,20.18 114.36,20.18 114.88,19.65 116.71,19.65 118.11,18.25 118.11,16.65 118.85,15.92 122.71,15.92 v3(123.33,15.29) ; v3(29,57.74) 29.05,57.74 31.12,59.81 37.25,59.81 38.58,58.49 38.58,57.97 39.37,57.18 43.3,57.18 43.84,56.65 v3(43.93,56.65) 43.91,56.63 43.91,56.4 43.05,55.53 43.05,49.38 v1(43.15,49.28)
  BOTTOM w0.109: v3(43.93,56.65) 44.26,56.98 U30.16
G2_PCIE_RX0_N: length 52.9
  TOP w0.089: U1.D15 109.42,34.89 arc(109.21,34.85) 109.03,34.73 108.93,34.63 arc(108.85,34.57) 108.75,34.55 108.59,34.55 arc(108.49,34.57) 108.4,34.63
  TOP w0.135: v3(106.42,24.59) 106.41,24.59 arc(106.19,24.92) 106.11,25.31 106.11,32.55 arc(106.3,33.51) 106.85,34.32 106.89,34.36 arc(107.27,34.62) 107.71,34.7 108.21,34.7 arc(108.26,34.7) 108.31,34.69 arc(108.36,34.66) 108.4,34.63
  T10 w0.135: v3(77.32,10.43) 77.3,10.44 arc(77.22,10.56) 77.18,10.71 77.18,10.82 78.1,11.73 arc(78.83,12.22) 79.7,12.39 arc(81.09,12.67) 82.27,13.46 85.61,16.8 arc(86.7,17.52) 87.98,17.78 arc(88.79,17.94) 89.48,18.4 89.48,18.4 arc(90.86,19.32) 92.48,19.65 96.96,19.65 arc(97.2,19.69) 97.4,19.83 97.4,19.83 arc(97.69,20.03) 98.04,20.1 101.69,20.1 arc(103.46,20.45) 104.95,21.45 105.63,22.13 arc(105.95,22.61) 106.06,23.17 106.06,23.91 arc(106.12,24.19) 106.28,24.43 106.42,24.58 v3(106.42,24.59)
  BOTTOM w0.135: J10.A61 77.35,8.34 77.01,8.68 77.01,9.89 arc(77.06,10.11) 77.18,10.3 v3(77.32,10.43)
G2_PCIE_RX0_P: length 52.9
  TOP w0.135: v3(105.47,24.58) 105.49,24.6 arc(105.71,24.92) 105.78,25.31 105.78,30.51 arc(105.74,30.61) 105.65,30.65 arc(105.55,30.69) 105.51,30.78 105.51,31.05 arc(105.55,31.15) 105.65,31.19 arc(105.74,31.23) 105.78,31.32 105.78,31.59 arc(105.74,31.69) 105.65,31.73 arc(105.55,31.77) 105.51,31.86 105.51,32.13 arc(105.55,32.23) 105.65,32.26 arc(105.74,32.3) 105.78,32.4 105.78,32.55 arc(106,33.63) 106.61,34.55 arc(107.07,34.86) 107.61,34.96 108.6,34.96 U1.B15
  T10 w0.135: v3(76.49,10.43) 76.7,10.64 arc(76.77,10.74) 76.79,10.86 76.79,10.92 77.85,11.98 arc(78.7,12.55) 79.7,12.75 arc(80.96,12.99) 82.02,13.71 85.36,17.05 arc(86.56,17.85) 87.98,18.13 arc(88.66,18.27) 89.23,18.65 89.23,18.65 arc(90.72,19.65) 92.48,20 96.96,20 arc(97.06,20.02) 97.15,20.07 arc(97.55,20.35) 98.04,20.45 101.69,20.45 arc(103.32,20.77) 104.7,21.69 105.38,22.38 arc(105.63,22.74) 105.71,23.17 105.71,23.99 arc(105.65,24.31) v3(105.47,24.58)
  BOTTOM w0.135: J10.A60 76.35,8.37 76.68,8.7 76.68,9.89 arc(76.64,10.11) 76.52,10.3 v3(76.49,10.43)
G2_PCIE_RX1_N: length 49.5
  TOP w0.089: U1.C14 109.16,34.38 arc(109,34.27) 108.81,34.23 108.6,34.23 arc(108.54,34.22) 108.49,34.19 108.22,33.92 arc(108.07,33.81) 107.89,33.76
  TOP w0.135: 107.89,33.76 arc(107.87,33.76) 107.85,33.75 arc(107.76,33.7) 107.68,33.64 arc(107.62,33.56) 107.58,33.47 arc(107.57,33.41) 107.56,33.35 107.56,26.34 arc(107.6,26.15) v3(107.71,25.99)
  T10 w0.135: v3(81.27,10.26) 81.2,10.32 arc(81.07,10.52) 81.03,10.75 arc(81.03,10.75) 81.03,10.76 arc(81.06,10.94) 81.15,11.11 81.97,11.97 arc(82.56,12.37) 83.26,12.5 84.51,12.5 arc(85.79,12.76) 86.88,13.48 90.81,17.42 arc(92.04,18.24) 93.5,18.53 97.42,18.53 arc(97.75,18.6) 98.03,18.78 arc(98.22,18.91) 98.45,18.96 104.36,18.96 arc(105.33,19.15) 106.16,19.7 106.84,20.38 arc(107.34,21.13) 107.51,22.01 107.51,25.52 arc(107.51,25.55) 107.51,25.57 arc(107.57,25.8) v3(107.71,25.99)
  BOTTOM w0.135: J10.A65 81.35,8.38 81.02,8.71 81.02,9.64 arc(81.08,9.97) 81.27,10.25 v3(81.27,10.26)
G2_PCIE_RX1_P: length 49.5
  TOP w0.135: U1.A14 107.91,34.39 107.4,33.88 arc(107.27,33.7) 107.23,33.48 107.23,32.33 arc(107.21,32.28) 107.16,32.26 arc(107.11,32.23) 107.09,32.18 107.09,31.79 arc(107.11,31.74) 107.16,31.72 arc(107.21,31.7) 107.23,31.64 107.23,31.25 arc(107.21,31.2) 107.16,31.18 arc(107.11,31.16) 107.09,31.11 107.09,30.71 arc(107.11,30.66) 107.16,30.64 arc(107.21,30.62) 107.23,30.57 107.23,30.17 arc(107.21,30.12) 107.16,30.1 arc(107.11,30.08) 107.09,30.03 107.09,29.64 arc(107.11,29.58) 107.16,29.56 arc(107.21,29.54) 107.23,29.49 107.23,26.59 arc(107.2,26.42) 107.11,26.28 v3(106.83,26)
  T10 w0.135: v3(80.44,10.25) 80.44,10.25 80.5,10.36 80.65,10.67 arc(80.67,10.7) 80.67,10.74 arc(80.72,11.06) 80.89,11.35 80.88,11.33 81.72,12.22 arc(82.43,12.69) 83.26,12.85 84.51,12.85 arc(85.66,13.08) 86.63,13.73 90.56,17.66 arc(91.91,18.56) 93.5,18.88 97.42,18.88 arc(97.61,18.92) 97.78,19.03 arc(98.09,19.24) 98.45,19.31 104.36,19.31 arc(105.2,19.47) 105.91,19.95 106.59,20.63 arc(107.01,21.26) 107.16,22.01 107.16,25.66 v3(106.83,26)
  BOTTOM w0.135: J10.A64 80.35,8.46 80.68,8.79 80.68,9.65 arc(80.62,9.97) 80.44,10.24 v3(80.44,10.25)
G2_PCIE_TX0_AC_N: length 45.8
  TOP w0.135: v1(111.39,31.82) 111.68,32.11 U1.J9 ; C12.1 75.26,12.87 75.26,13.53 v3(75.41,13.67)
  T10 w0.089: v1(111.39,31.82) 111.18,31.82 110.33,30.97 110.33,30.68 arc(110.33,30.64) 110.33,30.61 arc(110.33,30.6) 110.33,30.6 arc(110.33,30.59) 110.33,30.58
  T10 w0.135: v3(75.41,13.67) arc(75.23,13.94) 75.17,14.25 arc(75.22,14.51) 75.37,14.73 80.59,19.94 arc(82.25,21.06) 84.22,21.45 86.69,21.45 arc(87.95,21.7) 89.01,22.41 arc(89.23,22.55) 89.48,22.6 98.9,22.6 arc(100.45,22.91) 101.76,23.79 101.84,23.87 106.62,28.65 arc(107.1,28.97) 107.66,29.08 108.83,29.08 arc(109.89,29.52) 110.33,30.58
G2_PCIE_TX0_AC_P: length 45.8
  TOP w0.135: C10.1 74.58,12.9 v3(74.58,13.67) ; v1(110.4,31.89) 110.62,32.11 U1.F9
  T10 w0.089: 109.98,30.58 109.98,30.6 110.14,30.77 110.14,31.05 110.73,31.64 110.73,31.77 110.61,31.89 v1(110.4,31.89)
  T10 w0.135: v3(74.58,13.67) arc(74.76,13.94) 74.82,14.25 arc(74.9,14.64) 75.12,14.97 80.34,20.19 arc(82.12,21.38) 84.22,21.8 86.69,21.8 arc(87.81,22.02) 88.76,22.66 arc(89.09,22.88) 89.48,22.95 98.9,22.95 arc(100.32,23.24) 101.52,24.04 106.38,28.9 arc(106.96,29.29) 107.66,29.43 108.83,29.43 arc(109.64,29.77) 109.98,30.58
G2_PCIE_TX0_N: length 6
  TOP w0.135: C12.2 75.41,11.6 75.04,11.23 75.04,8.82 75.35,8.51 J10.B59
G2_PCIE_TX0_P: length 6
  TOP w0.135: C10.2 74.4,11.52 74.71,11.21 74.71,8.83 74.35,8.47 J10.B58
G2_PCIE_TX1_AC_N: length 42.2
  TOP w0.135: C11.1 79.34,12.98 v3(79.34,13.93) ; U1.K7 112.21,31.25 v1(111.82,30.86)
  T10 w0.089: 111.29,28.82 111.42,28.94 arc(111.58,29.18) 111.63,29.46 111.63,29.73 arc(111.65,29.76) 111.68,29.78 arc(111.71,29.79) 111.72,29.82 111.72,30.09 arc(111.71,30.12) 111.68,30.13 arc(111.65,30.15) 111.63,30.18 111.63,30.63 arc(111.65,30.69) 111.68,30.75 111.79,30.86 v1(111.82,30.86)
  T10 w0.135: v3(79.34,13.93) 79.34,13.99 79.06,14.27 79.06,14.51 arc(79.13,14.84) 79.31,15.11 79.8,15.6 arc(80.7,16.2) 81.76,16.41 arc(82.92,16.64) 83.91,17.31 84.32,17.71 arc(85.73,18.65) 87.41,18.99 arc(87.74,19.01) 88.07,19.09 arc(88.43,19.26) 88.73,19.51 89.59,20.37 arc(91.13,21.39) 92.93,21.75 100.36,21.75 arc(100.38,21.75) 100.4,21.75 arc(101.27,21.92) 102,22.41 102.93,23.34 107.14,27.55 arc(107.79,27.99) 108.55,28.14 110.08,28.14 arc(110.57,28.24) 110.99,28.52 111.29,28.82
G2_PCIE_TX1_AC_P: length 42.2
  TOP w0.135: v3(78.52,13.93) 78.52,13.05 C9.1 ; v1(110.89,30.88) 111.26,31.25 U1.H7
  T10 w0.089: 111.13,29.08 111.2,29.16 arc(111.35,29.37) 111.4,29.63 111.4,30.13 arc(111.35,30.35) 111.23,30.54 v1(110.89,30.88)
  T10 w0.135: v3(78.52,13.93) 78.52,14.01 78.71,14.2 78.71,14.51 arc(78.8,14.97) 79.06,15.36 79.35,15.65 79.55,15.85 arc(80.56,16.52) 81.76,16.76 arc(82.79,16.97) 83.67,17.55 84.07,17.95 arc(85.6,18.98) 87.41,19.34 arc(87.69,19.36) 87.96,19.43 arc(88.24,19.56) 88.49,19.76 89.35,20.62 arc(90.99,21.71) 92.93,22.1 100.4,22.1 arc(101.13,22.25) 101.75,22.66 101.96,22.87 106.92,27.83 arc(107.65,28.32) 108.51,28.49 110.08,28.49 arc(110.5,28.57) 110.85,28.81 111.13,29.08
G2_PCIE_TX1_N: length 6.1
  TOP w0.135: J10.B63 79.35,8.09 arc(79.28,8.44) 79.08,8.74 79.02,8.81 79.02,11.31 arc(79.08,11.66) 79.28,11.97 C11.2
G2_PCIE_TX1_P: length 6.1
  TOP w0.135: J10.B62 78.35,8.2 arc(78.39,8.42) 78.52,8.61 78.68,8.77 78.68,11.33 arc(78.61,11.75) C9.2
G3_PCIE_RX0_N: length 65.8
  TOP w0.089: v1(111.89,38.39) 111.89,38.39 U1.J24
  T10 w0.135: v1(111.89,38.39) 111.79,38.29 arc(111.63,38.06) 111.57,37.79 111.57,37.76 arc(111.51,37.46) 111.34,37.21 109.03,34.9 arc(108.62,34.28) 108.47,33.56 108.47,33.25 arc(108.26,32.19) 107.67,31.3 107.61,31.24 102.5,26.14 arc(101.72,25.62) 100.81,25.43 87.34,25.43 arc(84.75,24.92) 82.55,23.45 81.81,22.71 74.31,15.2 arc(70.85,12.89) 66.77,12.08 64.92,12.08 arc(64.53,12) 64.2,11.79 64.18,11.76 arc(64.06,11.6) 64,11.42 arc(64.04,11.19) 64.17,10.99 v3(64.3,10.86)
  BOTTOM w0.135: J10.A48 64.35,8.36 64.01,8.7 64.01,10.16 arc(64.09,10.54) v3(64.3,10.86)
G3_PCIE_RX0_P: length 65.8
  TOP w0.089: v1(110.88,38.37) 110.94,38.43 110.94,38.93 U1.F24
  T10 w0.135: v1(110.88,38.37) 111.06,38.18 arc(111.18,38.01) 111.21,37.81 arc(111.17,37.6) 111.05,37.41 108.78,35.14 arc(108.29,34.42) 108.12,33.56 108.12,33.25 arc(107.94,32.33) 107.42,31.55 107.36,31.49 102.25,26.38 arc(101.59,25.94) 100.81,25.78 87.34,25.78 arc(84.62,25.24) 82.31,23.7 81.57,22.96 74.39,15.78 74.06,15.45 arc(70.71,13.22) 66.77,12.43 64.92,12.43 arc(64.4,12.33) 63.96,12.03 63.85,11.92 arc(63.69,11.7) 63.63,11.43 63.63,11.23 arc(63.59,11.03) v3(63.48,10.86)
  BOTTOM w0.135: J10.A47 63.35,8.4 63.68,8.74 63.68,10.36 arc(63.63,10.63) v3(63.48,10.86)
G3_PCIE_RX1_N: length 70.2
  TOP w0.089: v1(112.41,39.26) 112.38,39.29 U1.K26
  T10 w0.089: 111.08,38.9 111.11,38.87 111.47,38.87 arc(111.98,38.97) v1(112.41,39.26)
  T10 w0.135: 111.08,38.9 110.84,38.9 arc(110.65,38.86) 110.5,38.75 110.31,38.56 arc(110.14,38.31) 110.08,38.01 110.08,37.51 arc(110.03,37.26) 109.89,37.05 107.91,35.07 arc(107.57,34.58) 107.46,33.99 107.46,33.89 arc(107.28,33.01) 106.78,32.26 106.69,32.17 106.69,32.08 106.58,31.97 arc(105.04,30.46) 103.46,28.99 101.26,26.79 arc(100.74,26.44) 100.13,26.32 87.22,26.32 arc(84.4,25.76) 82.01,24.16 73.95,16.1 arc(70.48,13.78) 66.39,12.97 62.53,12.97 arc(61.7,12.82) 60.97,12.38 60.97,12.37 60.87,12.26 60.87,12.26 60.51,11.9 arc(60.41,11.75) 60.38,11.58 v3(60.38,10.84)
  BOTTOM w0.135: v3(60.38,10.84) 60.22,10.68 arc(60.12,10.53) 60.07,10.36 arc(60.07,10.33) 60.06,10.3 60.06,8.35 60.35,8.07 J10.A44
G3_PCIE_RX1_P: length 70.2
  TOP w0.089: U1.H26 111.39,39.26 v1(111.4,39.26)
  T10 w0.135: v3(59.55,10.84) 59.55,10.91 59.82,11.17 arc(59.97,11.4) 60.03,11.67 arc(60.07,11.89) 60.19,12.08 60.62,12.51 60.62,12.53 arc(60.67,12.58) 60.74,12.64 arc(61.57,13.14) 62.53,13.32 66.39,13.32 arc(70.35,14.11) 73.7,16.35 81.76,24.41 arc(84.27,26.08) 87.22,26.67 100.13,26.67 arc(100.61,26.77) 101.01,27.04 101.22,27.25 103.22,29.24 103.22,29.25 arc(104.8,30.71) 106.34,32.22 106.34,32.22 106.34,32.32 106.53,32.51 arc(106.96,33.15) 107.11,33.89 107.11,33.99 arc(107.25,34.71) 107.66,35.32 109.64,37.3 arc(109.7,37.4) 109.73,37.51 109.73,38.01 arc(109.81,38.44) 110.06,38.81 110.25,39 arc(110.52,39.18) 110.84,39.25 111.38,39.25 v1(111.4,39.26)
  BOTTOM w0.135: v3(59.55,10.84) 59.69,10.69 arc(59.72,10.65) 59.73,10.6 59.73,10.41 59.49,10.17 59.49,9.87 59.73,9.63 59.73,9.34 59.49,9.1 59.49,8.8 59.73,8.56 59.73,8.44 59.35,8.06 J10.A43
G3_PCIE_RX2_N: length 74.1
  TOP w0.089: U1.J28 111.89,40.16 v1(111.9,40.15)
  T10 w0.135: v3(56.26,10.81) 56.18,10.89 arc(56.03,11.11) 55.98,11.37 arc(55.99,11.43) 56.02,11.47 56.55,12 arc(58.75,13.47) 61.35,13.99 66.26,13.99 arc(70.12,14.75) 73.39,16.94 82.01,25.56 arc(83.84,26.78) 86,27.21 99.87,27.21 arc(100.33,27.3) 100.71,27.56 105.84,32.69 arc(106.21,33.19) 106.41,33.79 arc(106.43,33.91) 106.44,34.03 106.44,34.13 arc(106.6,34.94) 107.06,35.62 107.16,35.72 108.79,37.36 arc(108.99,37.65) 109.06,38.01 arc(109.16,38.52) 109.45,38.95 109.99,39.49 110.1,39.6 110.1,39.6 arc(110.23,39.68) 110.38,39.72 110.86,39.72 arc(111.42,39.83) v1(111.9,40.15)
  BOTTOM w0.135: J10.A40 56.35,8.39 56.01,8.72 56.01,10.09 56.02,10.1 56.01,10.23 56.01,10.39 arc(56.05,10.55) 56.14,10.69 v3(56.26,10.81)
G3_PCIE_RX2_P: length 74.1
  TOP w0.089: v1(110.76,40.16) 110.9,40.3 U1.F28
  T10 w0.135: v1(110.76,40.16) 110.67,40.07 110.38,40.07 arc(110.09,40.01) 109.85,39.84 109.74,39.74 109.21,39.2 arc(108.84,38.65) 108.71,38.01 arc(108.67,37.79) 108.54,37.6 106.91,35.97 106.81,35.87 arc(106.28,35.07) 106.09,34.14 arc(106.09,34.09) 106.09,34.05 arc(106.08,33.97) 106.07,33.89 arc(106.07,33.87) 106.07,33.85 arc(105.9,33.36) 105.59,32.94 100.46,27.81 arc(100.19,27.63) 99.87,27.56 86,27.56 arc(83.7,27.11) 81.76,25.81 76.88,20.92 76.78,20.92 76.59,20.92 76.35,20.69 76.35,20.4 76.12,20.16 75.83,20.16 75.59,19.93 75.59,19.64 75.35,19.4 75.07,19.4 74.83,19.16 74.83,18.88 74.59,18.64 74.3,18.64 74.07,18.4 74.07,18.11 73.14,17.18 arc(69.98,15.08) 66.26,14.34 61.35,14.34 arc(58.62,13.79) 56.3,12.25 55.77,11.72 arc(55.67,11.56) 55.63,11.37 55.63,11.28 arc(55.58,11.03) v3(55.44,10.81)
  BOTTOM w0.135: J10.A39 55.35,8.43 55.68,8.76 55.68,10.21 arc(55.68,10.27) 55.68,10.34 arc(55.59,10.59) v3(55.44,10.81)
G3_PCIE_RX3_N: length 78.8
  TOP w0.089: v1(112.41,41.02) 112.41,41.02 112.41,41.04 112.38,41.06 U1.K30
  T10 w0.135: v1(112.41,41.02) 112.34,40.95 arc(111.93,40.68) 111.45,40.58 110.41,40.58 arc(110.29,40.57) 110.16,40.56 arc(109.74,40.42) 109.38,40.16 109.33,40.1 108.78,39.55 108.48,39.25 arc(108.25,38.91) 108.17,38.51 arc(108.1,38.16) 107.9,37.86 107.13,37.09 106.11,36.07 arc(105.68,35.43) 105.53,34.68 105.53,34.49 arc(105.38,33.73) 104.95,33.09 100.7,28.85 arc(99.88,28.29) 98.9,28.1 84.02,28.1 arc(81.81,27.66) 79.93,26.4 70.58,17.06 arc(68.18,15.46) 65.35,14.89 58.29,14.89 arc(57.43,14.72) 56.7,14.23 55.65,13.18 arc(55.15,12.85) 54.56,12.73 arc(53.65,12.55) 52.87,12.03 52.45,11.6 arc(52.23,11.28) 52.15,10.9 52.15,10.9 52.17,10.88 arc(52.18,10.83) 52.21,10.78 v3(52.42,10.57)
  BOTTOM w0.135: v3(52.42,10.57) 52.31,10.47 arc(52.09,10.14) 52.01,9.75 52.01,8.76 52.35,8.42 J10.A36
G3_PCIE_RX3_P: length 78.7
  TOP w0.089: U1.H30 111.39,41.04 111.4,41.04 v1(111.4,41.02)
  T10 w0.135: v3(51.59,10.57) 51.72,10.7 arc(51.78,10.79) 51.8,10.9 51.8,10.9 arc(51.91,11.42) 52.2,11.85 52.63,12.28 arc(53.52,12.88) 54.56,13.08 arc(55.02,13.17) 55.4,13.43 56.45,14.48 arc(57.3,15.04) 58.29,15.24 58.49,15.44 58.83,15.44 59.03,15.24 59.37,15.24 59.57,15.44 59.91,15.44 60.1,15.24 60.45,15.24 60.64,15.44 60.98,15.44 61.18,15.24 61.52,15.24 61.72,15.44 62.06,15.44 62.26,15.24 65.35,15.24 arc(68.05,15.78) 70.34,17.31 79.68,26.65 arc(81.67,27.98) 84.02,28.45 98.9,28.45 arc(99.74,28.62) 100.46,29.09 104.53,33.17 104.53,33.17 104.79,33.43 arc(105.08,33.87) 105.18,34.38 105.18,34.54 arc(105.38,35.55) 105.95,36.41 107.65,38.11 arc(107.78,38.3) 107.82,38.51 arc(107.93,39.04) 108.23,39.49 108.54,39.8 109.08,40.35 109.14,40.4 arc(109.58,40.73) 110.11,40.9 arc(110.26,40.92) 110.41,40.93 111.18,40.93 arc(111.3,40.95) v1(111.4,41.02)
  BOTTOM w0.135: J10.A35 51.35,8.44 51.74,8.83 51.74,10.23 arc(51.7,10.41) v3(51.59,10.57)
G3_PCIE_TX0_AC_N: length 63.9
  TOP w0.089: U1.D30 109.32,41.82 arc(109.18,41.79) 109.06,41.71 108.96,41.61 108.29,40.94 108.26,40.92 arc(108.11,40.81) 107.92,40.77 107.66,40.77 arc(107.55,40.75) 107.45,40.68 arc(107.37,40.57) 107.35,40.44 107.35,40.31 v1(107.37,40.29)
  TOP w0.135: C8.1 62.46,13.28 62.12,13.62 62.12,15.84 62.45,16.17 v3(62.45,16.26)
  T10 w0.135: v3(62.45,16.26) 62.26,16.46 62.26,16.73 62.42,17.09 63.15,17.48 63.16,17.49 arc(63.92,17.84) 64.74,18.05 arc(64.93,18.08) 65.13,18.09 67.53,18.09 arc(69.93,18.56) 71.95,19.92 80.34,28.31 arc(80.95,29.22) 81.17,30.3 81.17,32.37 arc(81.27,32.89) 81.56,33.33 82.65,34.42 arc(84.78,35.84) 87.29,36.34 103.25,36.34 arc(104.32,36.55) 105.22,37.16 107.06,39 arc(107.19,39.19) 107.23,39.41 107.23,39.96 arc(107.27,40.14) v1(107.37,40.29)
G3_PCIE_TX0_AC_P: length 64
  TOP w0.089: v1(106.71,40.29) 106.71,40.29 arc(106.74,40.44) 106.82,40.57 106.92,40.66 arc(107.26,40.88) 107.66,40.96 107.92,40.96 arc(108.03,40.99) 108.13,41.05 108.15,41.07 108.52,41.44 arc(108.64,41.62) U1.B30
  TOP w0.135: v3(61.62,16.26) 61.79,16.1 61.79,15.78 61.52,15.51 61.52,15.24 61.79,14.98 61.79,14.7 61.52,14.44 61.52,14.16 61.79,13.9 61.79,13.62 61.44,13.28 C4.1
  T10 w0.135: v3(61.62,16.26) 61.62,16.33 61.9,16.61 61.9,16.73 61.94,16.88 62.15,17.34 62.58,17.57 62.98,17.79 62.98,17.79 arc(63.81,18.17) 64.68,18.4 arc(64.9,18.43) 65.13,18.44 67.53,18.44 arc(69.79,18.89) 71.71,20.17 80.09,28.56 arc(80.63,29.35) 80.82,30.3 80.82,32.37 arc(80.95,33.03) 81.32,33.58 82.4,34.67 arc(84.65,36.17) 87.29,36.69 103.25,36.69 arc(104.18,36.88) 104.97,37.41 106.81,39.25 arc(106.85,39.3) 106.86,39.36 106.86,39.92 arc(106.82,40.12) v1(106.71,40.29)
G3_PCIE_TX0_N: length 6.2
  TOP w0.135: J10.B46 62.35,8.45 62.01,8.78 62.01,11.61 C8.2
G3_PCIE_TX0_P: length 6.1
  TOP w0.135: J10.B45 61.35,8.45 61.68,8.78 61.68,11.81 C4.2
G3_PCIE_TX1_AC_N: length 66.9
  TOP w0.089: U1.C31 109.14,42.28 108.86,42.28 arc(108.68,42.24) 108.52,42.14 arc(108.37,42.04) 108.19,42 108.01,42 arc(107.91,41.98) 107.82,41.92 107.22,41.32 arc(107.01,41.14) 106.76,40.99 arc(106.71,40.97) 106.66,40.95 arc(106.57,40.92) 106.49,40.89 106.16,40.79 arc(106.13,40.78) 106.09,40.76 arc(106.07,40.75) 106.04,40.73 106.02,40.71 arc(105.98,40.68) 105.94,40.64 arc(105.88,40.48) v1(105.87,40.31)
  TOP w0.135: v3(58.52,16.49) 58.29,16.26 58.29,13.61 58.39,13.5 C7.1
  T10 w0.135: v1(105.87,40.31) 105.75,40.19 105.75,39.79 arc(105.7,39.35) 105.55,38.93 arc(105.51,38.86) 105.46,38.8 104.67,38.01 arc(103.89,37.49) 102.97,37.3 86.18,37.3 arc(84.42,36.95) 82.93,35.96 79.51,32.54 arc(78.11,30.45) 77.62,27.98 arc(77.48,27.25) 77.06,26.63 71.71,21.28 arc(69.92,20.09) 67.82,19.67 65.23,19.67 arc(61.49,18.95) 58.29,16.91 58.29,16.78 arc(58.3,16.73) 58.33,16.69 v3(58.52,16.49)
G3_PCIE_TX1_AC_P: length 67
  TOP w0.089: U1.A31 107.9,42.31 106.92,41.34 arc(106.81,41.24) 106.68,41.16 arc(106.64,41.14) 106.6,41.13 105.71,40.89 arc(105.69,40.88) 105.68,40.87 105.45,40.72 arc(105.41,40.67) 105.37,40.63 arc(105.27,40.48) v3(105.21,40.31)
  TOP w0.135: C3.1 57.38,13.38 57.54,13.54 57.8,13.54 57.96,13.71 57.96,14.27 57.78,14.44 57.78,14.67 57.96,14.85 57.96,15.15 57.81,15.31 57.81,15.69 57.96,15.85 57.96,16.23 v3(57.7,16.49)
  T10 w0.135: v3(57.7,16.49) 57.9,16.69 arc(57.93,16.74) 57.94,16.79 57.94,17.06 arc(61.29,19.25) 65.22,20.02 67.82,20.02 arc(69.79,20.41) 71.46,21.53 76.82,26.88 arc(77.15,27.39) 77.27,27.98 arc(77.79,30.58) 79.26,32.78 82.68,36.2 arc(84.28,37.28) 86.18,37.65 102.97,37.65 arc(103.75,37.81) 104.42,38.25 104.98,38.82 arc(105.25,39.23) 105.35,39.71 105.35,40.03 arc(105.32,40.16) 105.25,40.28 105.21,40.31 v3(105.21,40.31)
G3_PCIE_TX1_N: length 6.2
  TOP w0.135: J10.B42 58.35,8.45 58.01,8.78 58.01,11.37 58.4,11.78 C7.2
G3_PCIE_TX1_P: length 6.1
  TOP w0.135: J10.B41 57.35,8.45 57.68,8.78 57.68,11.55 57.65,11.58 57.38,11.83 C3.2
G3_PCIE_TX2_AC_N: length 70.6
  TOP w0.089: U1.D32 109.67,42.8 109.22,42.8 arc(109.19,42.8) 109.16,42.78 108.88,42.5 arc(108.85,42.48) 108.81,42.47 108.54,42.47 arc(108.34,42.51) 108.17,42.62 arc(108.17,42.63) 108.17,42.63 107.42,42.63 arc(107.31,42.61) 107.22,42.54 107.04,42.36 arc(106.46,41.96) 105.78,41.77 arc(105.73,41.77) 105.69,41.77 arc(105.63,41.77) 105.58,41.77
  TOP w0.127: 105.58,41.77 105.47,41.76 105.46,41.76 105.36,41.76 105.46,41.77 arc(105.4,41.76) 105.33,41.76 105.31,41.76 105.31,41.76 arc(105.11,41.72) 104.95,41.61 104.25,40.91 arc(104.21,40.85) 104.21,40.78 arc(104.22,40.75) 104.25,40.73 arc(104.33,40.61) 104.35,40.46 v1(104.35,40.32)
  TOP w0.135: v3(54.38,14.13) 54.36,14.11 arc(54.21,13.92) 54.11,13.69 54.11,13.64 arc(54.17,13.36) C6.1
  T10 w0.135: v3(54.38,14.13) 54.21,14.29 54.21,14.5 arc(54.34,15.14) 54.7,15.69 56.41,17.39 arc(60.65,20.23) 65.66,21.22 67.02,21.22 arc(69.89,21.79) 72.32,23.42 75.96,27.06 arc(76.43,27.76) 76.59,28.58 76.59,28.58 arc(77.03,30.78) 78.27,32.63 82.81,37.17 arc(84.16,38.07) 85.74,38.39 102.77,38.39 arc(103.22,38.48) 103.61,38.73 103.79,38.92 arc(104.06,39.32) 104.15,39.79 104.15,39.84 arc(104.18,39.96) 104.25,40.07 arc(104.33,40.19) v1(104.35,40.32)
G3_PCIE_TX2_AC_P: length 70.4
  TOP w0.089: 105.58,41.99 105.59,41.99 105.61,41.98 105.66,41.98 105.68,41.96 arc(105.72,41.96) 105.76,41.96 arc(106.38,42.13) 106.91,42.5 107.09,42.68 arc(107.24,42.78) 107.42,42.82 108.67,42.82 U1.B32
  TOP w0.127: 105.58,41.99 105.46,41.99 arc(105.4,41.99) 105.35,41.99 arc(105.33,41.99) 105.32,41.99 105.21,41.99 105.21,41.99 arc(104.98,41.94) 104.78,41.81 104.08,41.11 103.92,40.95 arc(103.84,40.83) 103.81,40.68 arc(103.7,40.53) 103.67,40.34 v1(103.64,40.34)
  TOP w0.135: C2.1 53.73,13.59 arc(53.76,13.63) 53.77,13.69 53.77,13.91 v3(53.55,14.13)
  T10 w0.135: v1(103.64,40.34) 103.64,40.34 arc(103.67,40.2) 103.75,40.09 103.78,40.05 103.8,40.02 103.8,39.79 arc(103.73,39.45) 103.54,39.16 103.36,38.98 arc(103.09,38.8) 102.77,38.74 85.74,38.74 arc(84.02,38.4) 82.56,37.42 78.03,32.88 arc(76.71,30.91) 76.24,28.58 76.24,28.58 arc(76.11,27.89) 75.71,27.3 72.07,23.66 arc(69.76,22.12) 67.02,21.57 65.66,21.57 arc(60.52,20.55) 56.16,17.64 55.93,17.41 55.57,17.41 55.37,17.22 55.37,17.04 55.37,16.85 55.17,16.65 54.8,16.65 54.61,16.45 54.61,16.28 54.61,16.09 54.46,15.93 arc(54.01,15.27) 53.86,14.5 53.55,14.19 v3(53.55,14.13)
G3_PCIE_TX2_N: length 6.4
  TOP w0.135: J10.B38 54.35,8.45 54.01,8.78 54.01,11.99 C6.2
G3_PCIE_TX2_P: length 6.6
  TOP w0.135: J10.B37 53.35,8.45 53.68,8.78 53.68,10.92 53.49,11.11 53.49,11.45 53.68,11.65 53.68,11.89 C2.2
G3_PCIE_TX3_AC_N: length 73.7
  TOP w0.089: 107.11,43.36 107.12,43.35 arc(107.5,43.09) 107.95,43 108.03,43 arc(108.2,43.03) 108.35,43.13 arc(108.54,43.26) 108.76,43.3 U1.C34
  TOP w0.135: v1(103.83,42.43) 103.81,42.46 103.81,42.77 arc(103.84,42.95) 103.94,43.1 103.94,43.1 arc(104.22,43.29) 104.55,43.36 107.11,43.36 ; C5.1 50.21,13.3 50.21,13.77 50.49,14.05 v3(50.49,14.11)
  T10 w0.135: v3(50.49,14.11) 50.24,14.35 50.24,14.36 50.24,14.49 arc(50.39,15.21) 50.79,15.82 52.96,17.98 arc(54.38,18.93) 56.06,19.27 56.38,19.27 arc(57.12,19.42) 57.76,19.84 arc(60.8,21.87) 64.38,22.58 65.89,22.58 arc(69.44,23.29) 72.45,25.3 74.81,27.66 arc(75.45,28.61) 75.67,29.73 arc(75.96,31.18) 76.78,32.41 82.27,37.9 arc(83.79,38.92) 85.6,39.28 97.77,39.28 arc(98.9,39.5) 99.86,40.14 100,40.28 arc(100.82,40.83) 101.79,41.02 102.51,41.02 arc(102.95,41.11) 103.32,41.36 103.62,41.66 103.62,42.07 103.73,42.17 arc(103.8,42.29) v1(103.83,42.43)
G3_PCIE_TX3_AC_P: length 73.4
  TOP w0.089: U1.A34 107.93,43.3 107.84,43.3 arc(107.53,43.36) 107.26,43.53 107.25,43.55 arc(107.09,43.65) 106.91,43.69
  TOP w0.135: 106.91,43.69 104.55,43.69 arc(104.07,43.59) 103.66,43.32 103.32,42.98 arc(103.24,42.85) 103.21,42.71 103.21,42.53 v1(103.12,42.44) ; v3(49.66,14.11) 49.88,13.89 49.88,13.5 C1.1
  T10 w0.135: v1(103.12,42.44) 103.12,42.41 arc(103.16,42.22) 103.26,42.06 103.27,42.05 103.27,41.81 103.07,41.6 arc(102.81,41.43) 102.51,41.37 101.79,41.37 arc(100.69,41.15) 99.75,40.53 99.61,40.39 arc(98.77,39.83) 97.77,39.63 85.6,39.63 arc(83.66,39.24) 82.02,38.14 76.53,32.65 arc(75.63,31.31) 75.32,29.73 arc(75.12,28.75) 74.56,27.91 72.2,25.55 arc(69.3,23.61) 65.89,22.93 64.38,22.93 arc(60.66,22.19) 57.51,20.09 arc(56.99,19.74) 56.38,19.62 56.06,19.62 arc(54.25,19.26) 52.71,18.23 51.83,17.35 51.55,17.35 51.31,17.1 51.31,16.83 51.07,16.59 50.79,16.59 50.55,16.34 50.55,16.07 arc(50.06,15.34) 49.89,14.49 arc(49.89,14.42) 49.89,14.35 49.89,14.33 v3(49.66,14.11)
G3_PCIE_TX3_N: length 6.3
  TOP w0.135: J10.B34 50.35,8.45 50.01,8.78 50.01,11.68 C5.2
G3_PCIE_TX3_P: length 6.6
  TOP w0.135: J10.B33 49.35,8.45 49.68,8.78 49.68,8.96 49.45,9.2 49.45,9.5 49.68,9.74 49.68,10.04 49.45,10.28 49.45,10.58 49.68,10.82 49.68,11.88 C1.2
GEMAC_WAKE_L: length 3.7
  TOP w0.109: R101.2 R53.1 ; R101.2 70.34,27.43 U12.4 ; R101.2 69.75,27.35 v2(69.09,26.69)
H_BDXDE_FIVR_FAULT: length 81.8
  TOP w0.109: v3(78.54,28.18) 78.54,28.08 79.05,27.57 U13.10 81.81,27.57 R200.2
  TOP w0.152: U1.AP69 v1(124.27,59.3)
  T08 w0.089: v1(124.27,59.3) 123.84,59.73 119.69,59.73 119.27,60.15 119.27,60.38 118.87,60.79 118.87,61.14 117.71,62.29 111.5,62.29 108.41,59.2 108.41,48.28 106.05,45.92 105.55,45.92
  T08 w0.097: v3(78.54,28.18) 78.54,28.04 79.03,27.55 90.55,27.55 94.28,31.28 94.28,36.35 99.04,41.11 99.04,44.91 100.05,45.92 105.55,45.92
  BOTTOM w0.109: v2(78.5,25.77) 78.5,27.65 78.5,27.66 78.5,28.14 v3(78.54,28.18)
H_BDXDE_PROCHOT_DISABLE: length 84.8
  TOP w0.109: U31.C10 v1(56.13,39.3)
  TOP w0.152: v1(127.03,34.17) U1.BB12
  T05 w0.089: v1(127.03,34.17) 126.29,33.43 125.7,33.43 125.02,32.75 123.43,32.75 123.12,33.07 120.65,33.07 120.41,32.83 120.41,32.73 119.97,32.29 119.39,32.29 118.62,33.07 114.24,33.07 114.03,32.86 112.3,32.86 112.14,32.7 109.36,32.7 105.55,36.51
  T05 w0.097: 105.55,36.51 104.56,37.5 v3(72.51,37.5)
  T08 w0.097: v1(56.13,39.3) 56.64,38.79 58.24,38.79 58.93,38.1 58.93,37.08 60.21,35.8 67.08,35.8 69.9,38.62 71.39,38.62 v3(72.51,37.5)
  BOTTOM w0.089: R81.2 125.6,30.09 126,30.5 126,31.53 125.87,31.65 125.87,31.99 126.35,32.46 126.35,33 126.57,33.22 126.57,33.7 v1(127.03,34.17)
H_EDGE_FAST_PROCHOT_L: length 139
  TOP w0.109: U31.B11 v1(57.13,38.3) ; v3(127.76,5.25) 127.98,5.03 R99.2
  TOP w0.152: v1(127.91,37.25) 127.9,37.26 127.9,37.3 U1.BB21
  T05 w0.097: v3(127.76,5.25) 127.76,5.75 129.73,7.72 131.32,7.72 132.99,9.38 132.99,9.74 132.53,10.19 128.4,10.19 127.23,11.36 127.23,12.49 123.59,16.12 119.82,16.12 119.19,15.5 97.7,15.5 96.35,14.14 91.77,14.14 87.67,18.24 84.88,18.24 82.69,20.43 70.62,20.43 70.58,20.47 70.55,20.47 68.39,22.62 64.26,22.62 61.29,25.6 61.29,33.59 57.13,37.74 v1(57.13,38.3)
  T10 w0.089: 127.51,21.61 127.51,25.64 127.09,26.06 127.09,31.38 126.83,31.65 126.83,32.22 127.16,32.54 127.16,33.48 127.6,33.93 127.6,34.37 128.02,34.79 128.12,34.79 128.58,35.25 128.58,35.96 127.91,36.63 v1(127.91,37.25)
  T10 w0.097: 127.51,21.61 127.51,21.36 127.65,21.22 127.65,20.81 127.26,20.41 127.26,6.75 127.76,6.24 v3(127.76,5.25)
H_FAST_PROCHOT_L: length 155
  TOP w0.108: U1.CC56 136.74,53.57 v1(136.17,54.15)
  TOP w0.109: v3(28.29,67.22) 28.04,67.22 R110.2 27.88,66.58 28.54,66.58 29.05,67.09 29.93,67.09 U14.5
  TOP w0.152: U1.AG71 v1(120.8,60.15)
  T05 w0.089: v1(120.8,60.15) 120.8,59.17 121.2,58.78 121.2,56.8 120.2,55.8 120.2,50.98 119.56,50.35 119.56,46.42 121.77,44.21 130.2,44.21 132.48,46.49 132.48,51.07 135.56,54.15 v1(136.17,54.15)
  T08 w0.089: 122.89,62.5 123.12,62.27 123.12,61.41 122.9,61.19 122.9,61.07 122.44,60.61 121.27,60.61 v1(120.8,60.15)
  T08 w0.097: v3(28.29,67.22) 28.73,67.66 37.64,67.66 38.18,68.19 40.09,68.19 41.13,69.23 49.05,69.23 49.96,68.32 63.91,68.32 64.3,67.93 70.69,67.93 71.01,67.6 79.91,67.6 80.79,68.49 82.28,68.49 83.46,69.67 96.37,69.67 97.26,68.78 102.59,68.78 106.59,72.78 112.89,72.78 113.54,72.13 114.42,72.13 114.94,71.6 119.79,71.6 120.21,71.19 120.21,70.44 121.56,69.08 121.56,63.82 122.89,62.5
HOST_TO_BMC_INT_L: length 62.8
  TOP w0.109: R356.2 47.71,53.51 46.96,54.26 v3(46.91,54.26) ; v3(32.91,15.15) 32.91,15.1 33.52,14.49 33.52,6.37 J10.B17
  T05 w0.097: v3(46.91,54.26) 46.48,54.69 46.23,54.69 46.19,54.69 45.9,54.98 45.12,54.98 38.07,47.93 38.07,47.02 33.76,42.72 33.76,42.29 31.76,40.29 29.97,40.29 29.58,39.91 29.58,35.56 31.14,34 31.14,27.92 33.7,25.35 33.7,17.09 32.91,16.3 v3(32.91,15.15)
  BOTTOM w0.109: v2(46.53,53.42) 46.91,53.8 v3(46.91,54.26)
HOST_TO_BMC_INT_L_R: length 6.9
  TOP w0.109: U31.J2 49.15,48.28 49.15,51.19 48.48,51.85 v3(48.37,51.85) 48.37,51.96 47.73,52.6 R356.1
  BOTTOM w0.109: v2(49.05,51) 48.37,51.68 v3(48.37,51.85)
HOST_TO_MB_BMC_RST_L: length 67.7
  TOP w0.109: R353.2 49.76,54.25 v3(49.75,54.26) ; J10.B15 31.35,8.24 30.92,8.67 30.92,9.74 32.49,11.31 32.49,14.86 v3(32.2,15.15)
  T05 w0.097: v3(32.2,15.15) 32.2,16.01 33.4,17.21 33.4,25.23 30.84,27.79 30.84,33.79 30.18,34.45 29.28,35.35 29.28,40.03 29.74,40.49 30.67,41.42 32.47,41.42 33.46,42.41 33.46,42.92 37.77,47.23 37.77,48.05 45,55.28 46.06,55.28 46.36,54.99 46.79,54.99 48.02,53.75 49.24,53.75 v3(49.75,54.26)
  BOTTOM w0.109: v2(31.93,16.55) 31.93,15.42 v3(32.2,15.15)
HOST_TO_MB_BMC_RST_L_R: length 5.5
  TOP w0.109: R353.1 50.2,52.26 50.2,51.23 v3(50.39,51.04) 50.64,50.78 U31.H1
  BOTTOM w0.109: v2(51.61,50.93) 50.49,50.93 v3(50.39,51.04)
HOST_TO_MB_I2C_RST: length 73
  TOP w0.109: J10.B11 25.1,6.45 25.1,12 26.01,12.92 27.75,12.92 v3(29.72,14.89) ; R354.2 50.78,54.04 v3(50.51,54.3)
  T05 w0.097: v3(29.72,14.89) 30.15,15.32 30.43,15.32 32.75,17.64 32.75,25.03 30.24,27.54 30.24,33.3 28.68,34.86 28.68,40.28 30.43,42.02 32.22,42.02 32.86,42.67 32.86,43.21 37.05,47.4 37.05,48.5 43.89,55.34 44.1,55.34 44.64,55.88 46.31,55.88 46.6,55.59 47.66,55.59 48.56,54.69 50.12,54.69 v3(50.51,54.3)
  BOTTOM w0.109: v2(29.28,16.64) 29.28,15.33 v3(29.72,14.89)
HOST_TO_MB_I2C_RST_R: length 6.6
  TOP w0.109: U31.H2 51.06,48.21 51.06,51.17 50.68,51.55 v3(50.68,51.68) 50.68,51.72 50.7,51.75 50.7,52.62 R354.1
  BOTTOM w0.109: v2(51.05,52.85) 51.05,52.02 50.72,51.68 v3(50.68,51.68)
HOST_TO_MB_PCIEX_RST_L: length 69.2
  TOP w0.109: v3(47.88,54.66) 48.73,54.66 R450.2 48.74,54.56 R355.2 ; J10.B12 28.6,6.45 28.6,12.99 30.48,14.87 v3(30.48,14.89)
  T05 w0.097: v3(30.48,14.89) 33.1,17.51 33.1,25.1 30.54,27.67 30.54,33.58 28.98,35.14 28.98,40.15 30.55,41.72 32.34,41.72 33.16,42.55 33.16,43.09 37.47,47.4 37.47,48.18 44.88,55.58 46.19,55.58 46.48,55.29 47.24,55.29 v3(47.88,54.66)
  BOTTOM w0.109: v2(30.3,17.62) 29.98,17.3 29.98,15.39 v3(30.48,14.89)
HOST_TO_MB_PCIEX_RST_L_R: length 6.2
  TOP w0.109: R355.1 49.75,51.69 v3(49.75,51.57) 49.64,51.46 U31.J1
  BOTTOM w0.109: v3(49.75,51.57) 49.75,50.45 v2(50.29,49.92)
HW_REV_ID0: length 6.5
  TOP w0.109: U31.E6 v1(54.13,43.3)
  BOTTOM w0.109: v1(54.13,43.3) 52.27,45.16 v2(52.27,45.51) 51.66,46.12 R428.1 R427.1
HW_REV_ID1: length 3
  TOP w0.109: U31.E7 v1(54.13,42.3)
  BOTTOM w0.109: v1(54.13,42.3) 53.98,42.14 R430.1 R429.1
I2C_EEPROM_SCL: length 4.6
  TOP w0.109: U26.6 28.67,50.55 29.33,51.21 v3(29.33,52.48) 29.33,52.84 29.08,53.09 R317.2
I2C_EEPROM_SDA: length 1.9
  TOP w0.109: U26.5 v3(27.51,51.87) 27.51,53.07 R318.2
I2C_IO_EXP_SCL: length 4
  BOTTOM w0.109: R328.2 42.74,61.14 v2(42.93,61.33) 43.56,61.33 44.01,60.88 U30.22
I2C_IO_EXP_SDA: length 6.2
  BOTTOM w0.109: U30.23 44.39,61.53 43.78,62.14 R329.2 41.43,62.23 41.43,62.63 40.56,63.51 v2(40.56,63.87)
I2C_TEMP_SENSOR_SCL: length 8
  TOP w0.109: U27.2 64.51,72.17 64.84,72.5 64.84,77.76 64.48,78.12 R324.2
I2C_TEMP_SENSOR_SDA: length 3.5
  TOP w0.109: R323.2 63.75,75.96 63.75,74.24 63.45,73.94 U27.1
INT0_PCH_GPIO6_N: length 136.6
  TOP w0.089: U1.AV11 125.26,31.8 v1(125.25,31.8)
  T03 w0.097: v3(93.09,11.32) 92.82,11.59 89.38,11.59 88.7,10.91 85.9,10.91 85.28,11.54 80.16,11.54 79.78,11.16 78.15,11.16 77.78,11.54 76.03,11.54 75.65,11.16 74.03,11.16 71.31,13.88 56.9,13.88 54.7,11.68 51.38,11.68 51.13,11.68 50.73,11.28 48.78,11.28 47.01,13.05 46.67,13.05 38.94,13.05 36.88,10.99 33.75,10.99 v3(33.07,10.31)
  T10 w0.089: v1(125.25,31.8) 125.25,31.45 124.63,30.82 124.63,27.12 124.84,26.91 124.84,21.61
  T10 w0.097: v3(122,15.39) 122.62,15.39 124.93,17.7 124.93,21.25 124.84,21.34 124.84,21.61
  BOTTOM w0.109: J10.A16 32.35,8.87 33.07,9.59 v3(33.07,10.31) 33.07,12.77 34.39,14.09 34.39,15.48 34.18,15.7 34.18,17.2 33.27,18.1 R306.2 ; v3(93.09,11.32) 92,12.41 92,15.64 95.2,18.84 v2(97.51,18.84) 105.11,18.84 109.63,14.32 120.92,14.32 v3(122,15.39)
INT1_PCH_GPIO7_N: length 112.6
  TOP w0.089: U1.AG2 120.56,25.08 119.27,23.79
  TOP w0.109: 119.27,23.79 118.54,23.79 117.43,22.67 117.43,20.54 v3(116.08,19.19)
  T08 w0.097: v3(34.95,16.57) 36.44,15.08 55.38,15.08 55.61,14.85 67.38,14.85 67.61,15.08 84.88,15.08 85.42,14.54 87.39,14.54 89.97,17.13 98.72,17.13 99.31,17.72 102.86,17.72 105.12,15.46 107.06,15.46 107.95,16.35 107.95,18.13 109.69,19.88 114.18,19.88 114.87,19.19 v3(116.08,19.19)
  BOTTOM w0.109: J10.A17 33.35,9.18 33.63,9.46 33.63,12.31 34.95,13.63 v3(34.95,16.57) 34.95,17.18 34.29,17.84 R307.2
INT2_PCH_GPIO1_N: length 122
  TOP w0.089: 122.33,26.4 122.33,28.56 122.2,28.69 122.2,29.11 122.54,29.45 U1.AM4
  TOP w0.109: v1(121.73,24.24) 122.33,24.84 122.33,26.4
  T03 w0.097: v3(120.52,15.3) 118.74,13.52 97.47,13.52 95.86,11.9 89.27,11.9 88.63,11.27 86.11,11.27 85.39,11.98 80.17,11.98 79.69,11.5 78.24,11.5 77.9,11.84 77.31,11.84 76.99,12.16 76.99,13.83 76.33,14.49 72.87,14.49 72.59,14.21 55.61,14.21 54.88,14.94 52.64,14.94 52.2,14.49 52.2,12.51 51.67,11.98 51.01,11.98 50.62,11.6 49,11.6 47.24,13.35 47.04,13.35 38.79,13.35 37.64,12.21 v3(36.96,12.21)
  T10 w0.089: v1(121.73,24.24) 121.73,23.83 120.52,22.62 120.52,21.75
  T10 w0.097: 120.52,21.75 v3(120.52,15.3)
  BOTTOM w0.109: J10.A21 37.35,11.82 v3(36.96,12.21) 36.45,12.72 v2(36.45,16.83) R313.2 ; v3(120.52,15.3) 120.52,15.92 121.39,16.78
INT3_PCH_GPIO12_N: length 105.3
  TOP w0.089: U1.BD26 128.61,39.83 129.03,40.25 131.04,40.25 v1(131.19,40.4)
  T03 w0.089: v1(131.19,40.4) 131.59,40 131.59,39.1 131.32,38.83 131.32,37.98 131.59,37.71 131.59,37.39 131.31,37.11 131.31,36.27 131.59,35.99 131.59,35.67 131.31,35.39 131.31,34.55 131.59,34.27 131.59,33.95 131.31,33.67 131.31,32.83 131.59,32.55 131.59,32.23 131.27,31.91 131.27,28.57 128.75,26.05 125.5,26.05 121.06,21.61
  T03 w0.097: 121.06,21.61 119.23,19.78 119.23,15.48 117.91,14.16 94.44,14.16 92.86,12.59 v3(92.86,12.48)
  T05 w0.097: v3(92.86,12.48) 90.11,12.48 89.62,11.99 89.34,11.99 88.64,11.29 82.99,11.29 82.04,12.24 73.28,12.24 69.64,15.88 68.03,15.88 v3(67.41,16.5)
  BOTTOM w0.109: J10.A53 69.35,8.77 69.06,9.07 69.06,14.86 v3(67.41,16.5) 67.82,16.91 R349.2
INT4_PCH_GPIO15_N: length 112.5
  TOP w0.089: U1.BA23 127.08,39.02 127.58,39.02 127.78,39.22 127.78,39.88 128.38,40.47 128.38,41.2 128.73,41.55 v1(128.73,41.82)
  T03 w0.089: 121.69,21.61 125.63,25.54 128.5,25.54 132.09,29.13 132.09,31.95 131.81,32.23 131.81,32.81 132.09,33.09 132.09,33.67 131.81,33.95 131.81,34.53 132.09,34.81 132.09,35.39 131.81,35.67 131.81,36.25 132.09,36.53 132.09,37.11 131.81,37.38 131.81,37.96 132.1,38.25 132.1,38.81 131.81,39.1 131.81,40.33 130.73,41.41 130.64,41.45 129.1,41.45 v1(128.73,41.82)
  T03 w0.097: 121.69,21.61 120.22,20.13 120.22,19.17 119.61,18.56 119.61,15.43 118.01,13.83 94.87,13.83 93.65,12.61 v3(93.65,12.39)
  T05 w0.097: v3(93.65,12.39) 93.65,12.26 93.44,12.05 90.17,12.05 89.81,11.69 89.46,11.69 88.77,10.99 82.86,10.99 81.91,11.94 73.16,11.94 69.52,15.58 67.06,15.58 v3(66.12,16.53)
  BOTTOM w0.109: J10.A52 68.35,8.55 68.67,8.87 68.67,13.97 v3(66.12,16.53) 66.67,17.08 R348.2
INT_TPM_N: length 78.9
  TOP w0.089: U1.AN3 123.03,28.82 122.57,28.35 v1(122.57,24.4)
  TOP w0.109: R305.1 R351.2 183.34,10.53 183.33,10.53 182.15,10.53 180.47,12.21 172.97,12.21 171.96,13.22 160.91,13.22 159.64,11.95 158.24,11.95 v3(157.99,12.21)
  BOTTOM w0.089: v1(122.57,24.4) 122.87,24.1 126.14,24.1 128.4,26.36 129.36,26.36 131.47,28.46 133.48,28.46 133.99,27.96 135.25,27.96 136.27,26.93 136.27,24.78 137.98,23.07 137.98,22.73 139.1,21.61
  BOTTOM w0.109: 139.1,21.61 144.69,16.02 154.18,16.02 v3(157.99,12.21)
IRQ_BMC_PCH_NMI_NOA1_CLK: length 8.4
  TOP w0.089: 130.26,28.66 130.26,27.29 130.15,27.18 130.15,23.93 v1(130.83,23.26)
  TOP w0.102: 130.26,28.66 130.12,28.8 130.12,29.09 130.46,29.43 U1.BJ4
  BOTTOM w0.089: v1(130.83,23.26) 130.7,23.13 TP7.1
IRQ_SERIAL: length 302.5
  TOP w0.109: R209.2 94.09,69.84 94.09,69.84 R207.2 94.59,69.31 94.15,68.87 v3(94.15,68.84) ; v3(81.66,18.05) 81.66,12.53 83.25,10.94 83.25,9.77 83.01,9.53 83.01,8.57 83.35,8.23 J10.B67
  TOP w0.152: U1.BU14 v1(133.68,34.97)
  T03 w0.089: 110.86,68.97 110.89,68.99 116.38,68.99 v1(116.53,68.84)
  T03 w0.097: 110.86,68.97 94.68,68.97 94.56,68.84 v3(94.15,68.84)
  T05 w0.089: v1(116.53,68.84) 116.93,69.25 117.54,69.25 118.89,67.9 120.44,67.9 120.98,67.36 120.98,61.46 120.77,61.25 120.77,60.67 120.42,60.31 120.42,56.28 120.01,55.88 120.01,51.06 119.37,50.43 119.37,50.05 119.29,49.96 118.15,49.96 118.06,49.87 118.06,49.7 118.15,49.61 119.29,49.61 119.37,49.52 119.37,49.33 119.29,49.24 117.84,49.24 117.75,49.15 117.75,48.97 117.84,48.88 119.29,48.88 119.37,48.79 119.37,48.62 119.29,48.53 117.84,48.53 117.75,48.44 117.75,48.26 117.84,48.17 119.29,48.17 119.37,48.08 119.37,47.91 119.29,47.82 117.84,47.82 117.75,47.73 117.75,47.55 117.84,47.46 119.29,47.46 119.37,47.37 119.37,47.19 119.29,47.11 117.84,47.11 117.75,47.02 117.75,46.84 117.84,46.75 119.29,46.75 119.37,46.66 119.37,46.48 119.29,46.39 117.84,46.39 117.75,46.31 117.75,46.13 117.84,46.04 119.29,46.04 119.37,45.95 119.37,45.77 119.29,45.68 117.84,45.68 117.75,45.59 117.75,45.42 117.84,45.33 119.29,45.33 119.37,45.24 119.37,44.34 119.48,44.24 119.97,44.24 120.06,44.33 120.06,45.08 120.15,45.17 120.33,45.17 120.42,45.08 120.42,44.33 120.51,44.24 121.12,44.24 121.34,44.02 131.43,44.02 131.72,44.31 131.72,44.8 131.95,45.02 132.51,45.02 132.77,45.28 132.77,45.96 132.85,46.05 135.17,46.05 135.25,46.14 135.25,46.32 135.17,46.41 132.85,46.41 132.77,46.5 132.77,46.68 132.85,46.76 135.17,46.76 135.25,46.85 135.25,47.03 135.17,47.12 132.85,47.12 132.77,47.21 132.77,47.4 132.85,47.49 136.16,47.49 136.25,47.58 136.25,47.76 136.16,47.84 132.85,47.84 132.77,47.93 132.77,48.11 132.85,48.2 136.16,48.2 136.25,48.29 136.25,48.47 136.16,48.56 132.85,48.56 132.77,48.64 132.77,48.82 132.85,48.91 136.16,48.91 136.25,49 136.25,49.18 136.16,49.27 132.85,49.27 132.77,49.36 132.77,49.53 132.85,49.62 136.16,49.62 136.25,49.71 136.25,49.89 136.16,49.98 132.85,49.98 132.77,50.07 132.77,50.24 132.85,50.33 136.16,50.33 136.25,50.42 136.25,50.6 136.16,50.69 132.85,50.69 132.77,50.78 132.77,50.97 134.39,52.59 134.58,52.59 134.67,52.51 134.67,51.18 134.76,51.1 134.94,51.1 135.03,51.18 135.03,52.51 135.12,52.59 135.29,52.59 135.38,52.51 135.38,51.18 135.47,51.1 135.65,51.1 135.74,51.18 135.74,52.51 135.83,52.59 141.43,52.59 141.77,52.25 143.6,52.25 143.69,52.16 143.69,51.98 143.6,51.9 141.77,51.9 141.68,51.81 141.68,51.63 141.77,51.54 143.6,51.54 143.69,51.45 143.69,51.27 143.6,51.18 141.77,51.18 141.68,51.1 141.68,50.92 141.77,50.83 143.6,50.83 143.69,50.74 143.69,50.56 143.6,50.47 141.77,50.47 141.68,50.38 141.68,50.21 141.77,50.12 143.6,50.12 143.69,50.03 143.69,49.85 143.6,49.76 141.77,49.76 141.68,49.67 141.68,49.5 141.77,49.41 143.6,49.41 143.69,49.32 143.69,49.14 143.6,49.05 141.77,49.05 141.68,48.96 141.68,48.78 141.77,48.7 143.6,48.7 143.69,48.61 143.69,48.43 143.6,48.34 141.77,48.34 141.68,48.25 141.68,48.07 141.77,47.98 143.6,47.98 143.69,47.9 143.69,47.72 143.6,47.63 141.77,47.63 141.68,47.54 141.68,47.36 141.77,47.27 143.6,47.27 143.69,47.18 143.69,47.01 143.6,46.92 141.77,46.92 141.68,46.83 141.68,46.65 141.77,46.56 143.6,46.56 143.69,46.47 143.69,46.29 143.6,46.21 141.8,46.21 141.33,45.74 134.77,45.74 133.73,44.69 133.73,42.59 133.2,42.05 133.2,41.6 133.68,41.11 133.68,40.76 133.27,40.35 133.27,39.87 133.63,39.51 133.63,38.94 133.29,38.61 133.29,37.98 133.57,37.71 133.57,37.14 133.22,36.79 133.22,36.41 133.68,35.94 v1(133.68,34.97)
  T05 w0.097: v3(71.22,34.74) 70.59,35.37 70.59,38.27 72.97,40.65 77.03,40.65 79.25,42.87 88.14,42.87 94.15,48.88 v3(94.15,68.84)
  BOTTOM w0.109: v3(71.22,34.74) 72.28,33.68 75.34,33.68 75.82,33.2 75.82,32.34 77.63,30.52 77.63,23.85 81.66,19.83 v3(81.66,18.05)
