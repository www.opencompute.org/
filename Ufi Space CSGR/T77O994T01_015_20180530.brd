# Allegro board T77O994T01_015_20180530.brd (continued)
## Nets (continued)
DDR4_B_ECC7: CN2.104(CB7_NC) U1.CR35(DDR1_ECC7)
DDR4_B_ODT0: CN2.155(ODT0) U1.CV64(DDR1_ODT0)
DDR4_B_ODT1: CN2.161(ODT1) U1.CR69(DDR1_ODT1)
DDR4_B_PAR: CN2.143(PARITY) U1.CR59(DDR1_PAR)
DDR4_B_SA0: CN2.256(SA0) R235.2 R238.1
DDR4_B_SA1: CN2.260(SA1) R236.2 R239.1
DDR4_B_SA2: CN2.166(SA2) R237.2 R449.1
DDR4_SCL_1V05: R117.2 R127.2 U7.2(SCLA)
DDR4_SCL_1V05_ST: R127.1 U1.CD58(DDR_SCL)
DDR4_SCL_2V5: CN1.253(SCL) CN2.253(SCL) R128.2
DDR4_SCL_2V5_ST: R121.1 R128.1 U7.7(SCLB)
DDR4_SDA_1V05: R116.2 R125.2 U7.3(SDAA)
DDR4_SDA_1V05_ST: R125.1 U1.CC60(DDR_SDA)
DDR4_SDA_2V5: CN1.254(SDA) CN2.254(SDA) R126.2
DDR4_SDA_2V5_ST: R120.1 R126.1 U7.6(SDAB)
DDR4_VRHOT_L: PR210.2 PU21.30(VR_HOT#) U33.2(A)
DDR_RCOMP0: R176.2 U1.CC52(DDR_RCOMP0)
DDR_RCOMP1: R173.2 U1.CD51(DDR_RCOMP1)
DDR_RCOMP2: R172.2 U1.CC49(DDR_RCOMP2)
DIFF_XCLK_BIASREF: R50.1 U1.AA18(DIFFCLK_BIASREF)
DMI_RCOMP_PCH: R160.2 U1.AA28(SOC_RCOMP)
FP_IBMC_PWRBTN_OUT_L: C187.1 C193.1 J10.B48(PRSNT2_3_L) J12.41 R396.1 U1.AW3(P\W\R\B\T\N\) U30.16(I/O_1.3) U31.R1(FM_CPLD_PWRBTN_BMC_N)
G2_PCIE_RX0_N: J10.A61(PCIE0_RX10_N) U1.D15(PCIE_RX_DN1)
G2_PCIE_RX0_P: J10.A60(PCIE0_RX10_P) U1.B15(PCIE_RX_DP1)
G2_PCIE_RX1_N: J10.A65(PCIE0_RX11_N) U1.C14(PCIE_RX_DN2)
G2_PCIE_RX1_P: J10.A64(PCIE0_RX11_P) U1.A14(PCIE_RX_DP2)
G2_PCIE_TX0_AC_N: C12.1 U1.J9(PCIE_TX_DN1)
G2_PCIE_TX0_AC_P: C10.1 U1.F9(PCIE_TX_DP1)
G2_PCIE_TX0_N: C12.2 J10.B59(PCIE0_TX10_N)
G2_PCIE_TX0_P: C10.2 J10.B58(PCIE0_TX10_P)
G2_PCIE_TX1_AC_N: C11.1 U1.K7(PCIE_TX_DN2)
G2_PCIE_TX1_AC_P: C9.1 U1.H7(PCIE_TX_DP2)
G2_PCIE_TX1_N: C11.2 J10.B63(PCIE0_TX11_N)
G2_PCIE_TX1_P: C9.2 J10.B62(PCIE0_TX11_P)
G3_PCIE_RX0_N: J10.A48(PCIE0_RX7_N) U1.J24(PE1_RX_DN0)
G3_PCIE_RX0_P: J10.A47(PCIE0_RX7_P) U1.F24(PE1_RX_DP0)
G3_PCIE_RX1_N: J10.A44(PCIE0_RX6_N) U1.K26(PE1_RX_DN1)
G3_PCIE_RX1_P: J10.A43(PCIE0_RX6_P) U1.H26(PE1_RX_DP1)
G3_PCIE_RX2_N: J10.A40(PCIE0_RX5_N) U1.J28(PE1_RX_DN2)
G3_PCIE_RX2_P: J10.A39(PCIE0_RX5_P) U1.F28(PE1_RX_DP2)
G3_PCIE_RX3_N: J10.A36(PCIE0_RX4_N) U1.K30(PE1_RX_DN3)
G3_PCIE_RX3_P: J10.A35(PCIE0_RX4_P) U1.H30(PE1_RX_DP3)
G3_PCIE_TX0_AC_N: C8.1 U1.D30(PE1_TX_DN0)
G3_PCIE_TX0_AC_P: C4.1 U1.B30(PE1_TX_DP0)
G3_PCIE_TX0_N: C8.2 J10.B46(PCIE0_TX7_N)
G3_PCIE_TX0_P: C4.2 J10.B45(PCIE0_TX7_P)
G3_PCIE_TX1_AC_N: C7.1 U1.C31(PE1_TX_DN1)
G3_PCIE_TX1_AC_P: C3.1 U1.A31(PE1_TX_DP1)
G3_PCIE_TX1_N: C7.2 J10.B42(PCIE0_TX6_N)
G3_PCIE_TX1_P: C3.2 J10.B41(PCIE0_TX6_P)
G3_PCIE_TX2_AC_N: C6.1 U1.D32(PE1_TX_DN2)
G3_PCIE_TX2_AC_P: C2.1 U1.B32(PE1_TX_DP2)
G3_PCIE_TX2_N: C6.2 J10.B38(PCIE0_TX5_N)
G3_PCIE_TX2_P: C2.2 J10.B37(PCIE0_TX5_P)
G3_PCIE_TX3_AC_N: C5.1 U1.C34(PE1_TX_DN3)
G3_PCIE_TX3_AC_P: C1.1 U1.A34(PE1_TX_DP3)
G3_PCIE_TX3_N: C5.2 J10.B34(PCIE0_TX4_N)
G3_PCIE_TX3_P: C1.2 J10.B33(PCIE0_TX4_P)
GEMAC_WAKE_L: R53.1 R101.2 U12.4(Y)
H_BDXDE_FIVR_FAULT: R200.2 U1.AP69(FIVR_FAULT) U13.10(2B2)
H_BDXDE_PROCHOT_DISABLE: R81.2 U1.BB12(SLP_WLAN_N_GPIO29_MGPIO3) U31.C10(H_BDXDE_PROCHOT_DISABLE)
H_EDGE_FAST_PROCHOT_L: R99.2 U1.BB21(GPIO24_MGPIO0) U31.B11(H_EDGE_FAST_PROCHOT_N_R)
H_FAST_PROCHOT_L: R110.2 U1.AG71(P\R\O\C\H\O\T\) U1.CC56(M\E\M\_\H\O\T\) U14.5(1A2)
HOST_TO_BMC_INT_L: J10.B17(PRSNT2_1_L) R356.2
HOST_TO_BMC_INT_L_R: R356.1 U31.J2(HOST_TO_MM_INT_L)
HOST_TO_MB_BMC_RST_L: J10.B15(PCIE0_TX0_N) R353.2
HOST_TO_MB_BMC_RST_L_R: R353.1 U31.H1(HOST_TO_BMC_RST_L)
HOST_TO_MB_I2C_RST: J10.B11(WAKE_L) R354.2
HOST_TO_MB_I2C_RST_R: R354.1 U31.H2(HOST_TO_MB_I2C_RST)
HOST_TO_MB_PCIEX_RST_L: J10.B12(RSVD_6) R355.2 R450.2
HOST_TO_MB_PCIEX_RST_L_R: R355.1 U31.J1(HOST_TO_MB_RST)
HW_REV_ID0: R427.1 R428.1 U31.E6(GND_19)
HW_REV_ID1: R429.1 R430.1 U31.E7(GND_20)
I2C_EEPROM_SCL: R317.2 U26.6(SCL)
I2C_EEPROM_SDA: R318.2 U26.5(SDA)
I2C_IO_EXP_SCL: R328.2 U30.22(SCL)
I2C_IO_EXP_SDA: R329.2 U30.23(SDA)
I2C_TEMP_SENSOR_SCL: R324.2 U27.2(SCL)
I2C_TEMP_SENSOR_SDA: R323.2 U27.1(SDA)
INT0_PCH_GPIO6_N: J10.A16(PCIE0_RX0_P) R306.2 U1.AV11(TACH2_GPIO6)
INT1_PCH_GPIO7_N: J10.A17(PCIE0_RX0_N) R307.2 U1.AG2(TACH3_GPIO7)
INT2_PCH_GPIO1_N: J10.A21(PCIE0_RX1_P) R313.2 U1.AM4(TACH1_GPIO1)
INT3_PCH_GPIO12_N: J10.A53(PCIE0_RX8_N) R349.2 U1.BD26(LAN_PHY_PWR_CTRL_GPIO12)
INT4_PCH_GPIO15_N: J10.A52(PCIE0_RX8_P) R348.2 U1.BA23(GPIO15)
INT_TPM_N: R305.1 R351.2 U1.AN3(TACH0_GPIO17)
IRQ_BMC_PCH_NMI_NOA1_CLK: TP7.1 U1.BJ4(GPIO8_OCS)
IRQ_SERIAL: J10.B67(PCIE0_TX12_N) R207.2 R209.2 U1.BU14(SERIRQ)
IRQ_SERIAL_ST: R209.1 U16.4(B)
IRQ_SERIRQ_DATA: R208.1 U1.AE75(SERIRQ_DATA)
IRQ_SERIRQ_DATA_ST: R208.2 U16.3(A)
IRQ_SERIRQ_DIR: R288.2 R293.1 U1.AD74(SERIRQ_DIR) U16.5(DIR)
JTAG_PCH_TCK: R185.1 R464.1 U1.BM3(JTAG_TCK_PCH)
JTAG_PCH_TDI: R462.2 U1.BM5(JTAG_TDI_PCH)
JTAG_PCH_TDO: TP3.1 U1.BK3(JTAG_TDO_PCH)
JTAG_PCH_TMS: R463.2 U1.BJ2(JTAG_TMS_PCH)
JTAG_TCK: J8.1 R86.1 R308.2 R369.1 U31.P3(TCK)
JTAG_TDI: J8.9 R48.2 R88.1 R368.2 U31.L6(TDI)
JTAG_TDO: J8.3 R49.2 R92.1 R366.2 U31.M5(TDO)
JTAG_TMS: J8.5 R47.2 R94.1 R367.2 U31.N4(TMS)
KR_EPHY_RBIAS: R1.1 U1.P56(LAN_RBIAS)
KR_EPHY_REFCLK_IN: C17.1 U1.J58(LAN_XTAL_IN) Y1.1
KR_EPHY_REFCLK_OUT: C18.1 U1.F58(LAN_XTAL_OUT) Y1.3
LAN_10GE_P0_MDIO_DIR_1V05: R279.2 R284.1 U1.E75(LAN_MDIO_DIR_CTL_0)
LAN_10GE_P1_MDIO_DIR_1V05: R278.2 R283.1 U1.N72(LAN_MDIO_DIR_CTL_1)
LAN_I2C0_SCL_1V05_R: R8.1 U1.R72(LAN_I2C_SCL0)
LAN_I2C0_SDA_1V05_R: R7.1 U1.U72(LAN_I2C_SDA0)
LAN_I2C1_SCL_1V05_R: R10.1 U1.P71(LAN_I2C_SCL1)
LAN_I2C1_SDA_1V05_R: R9.1 U1.T71(LAN_I2C_SDA1)
LAN_MDC0_I2C_CLK_1V05: R14.1 U1.U69(LAN_MDC0_LED0_1) U5.2(A1)
LAN_MDC0_I2C_CLK_3V3: J10.A9(3.3V_1) R451.2
LAN_MDC0_I2C_CLK_3V3_R: R451.1 U5.7(B1)
LAN_MDIO0_I2C_DATA_1V05: R15.1 U1.W69(LAN_MDIO0_LED0_0) U5.3(A2)
LAN_MDIO0_I2C_DATA_3V3: J10.A10(3.3V_2) R452.2
LAN_MDIO0_I2C_DATA_3V3_R: R452.1 U5.6(B2)
LAN_NCSI_RXD0: R290.2 R295.1 U1.Y71(LAN_NCSI_RXD0)
LAN_NCSI_RXD1: R272.2 R277.1 U1.W72(LAN_NCSI_RXD1)
LAN_NCSI_TRI_EN_L: R251.2 R256.1 U1.AD78(LAN_NCSI_TRI_EN_PECI_ID1)
LAN_SMBCLK: R469.1 U1.AM75(LAN_SMBCLK)
LAN_SMBDATA: R468.1 U1.AM77(LAN_SMBDATA)
LED_CPLD_1: Q5.5(G2) U31.B3(LED_CPLD[1])
LED_CPLD_1_R: D6.1(A) R383.1
LED_CPLD_2: Q5.2(G1) U31.C2(LED_CPLD[2])
LED_CPLD_2_R: D5.1(A) R382.1
LED_CPLD_3: Q4.2(G1) U31.A2(LED_CPLD[3])
LED_CPLD_3_R: D4.1(A) R381.1
LED_CPLD_4: Q4.5(G2) U31.B1(LED_CPLD[4])
LED_CPLD_4_R: D3.1(A) R380.1
LPC_FRAME_L: J1.3 J10.A68(PCIE0_RX12_P) R54.2 U31.T11(LPC_LFRAME_N)
LPC_FRAME_L_R: R54.1 U1.AH1(L\F\R\A\M\E\)
LPC_LAD0: J1.4 J10.A73(PCIE0_RX13_N) R58.2 U31.T10(LPC_LAD0)
LPC_LAD0_R: R58.1 U1.AF3(LAD0)
LPC_LAD1: J1.10 J10.A72(PCIE0_RX13_P) R57.2 U31.T9(LPC_LAD1)
LPC_LAD1_R: R57.1 U1.AG4(LAD1)
LPC_LAD2: J1.8 J10.B71(PCIE0_TX13_N) R56.2 U31.T8(LPC_LAD2)
LPC_LAD2_R: R56.1 U1.AL3(LAD2)
LPC_LAD3: J1.7 J10.B70(PCIE0_TX13_P) R55.2 U31.T7(LPC_LAD3)
LPC_LAD3_R: R55.1 U1.AF1(LAD3)
LVC1_LAN_NCSI_ARB_OUT: R270.2 R276.1 U1.AB78(LAN_NCSI_ARB_OUT)
LVC3_IRQ_CPU_CATERR_L: U10.7(2A2) U31.C8(FM_BDXDE_CATERR_LVT3_N)
LVC3_RISER1_ID4_N_PU: R165.2 U1.BD3(OC7_N_GPIO14)
LVC3_RST_CPU_RESET_L: C175.1 U13.6(2A1) U31.A11(FM_CPLD_BDXDE_RESET_N)
M2_ACT: J9.10(DAS/DSS) TP10.1
M2_CONFIG_0: J9.21(CONFIG_0) R392.2
M2_CONFIG_1: J9.69(CONFIG_1) R391.1 R393.2
M2_CONFIG_2: J9.75(CONFIG_2) R394.2
MANUFACTURING_DET_L: R91.2 U1.BB27(GPIO32)
ME_RCVR_L: J10.B79(PCIE0_TX15_N) R297.2 R301.1 U1.BP9(GPIO57_MGPIO5)
MUX_HDR_SEL_L: R222.1 U20.1(1\O\E\) U20.19(2\O\E\)
NC_LAN_JTCK: U1.G74(LAN_JTCK_SDP0_0)
NC_LAN_JTDI: U1.F76(LAN_JTDI_SDP1_0)
NC_LAN_JTDO: U1.B71(LAN_JTDO)
NC_LAN_JTMS: U1.C76(LAN_JTMS_SDP0_1)
NC_LAN_JTRST_N: U1.N69(LAN_JRST_N_SDP1_1)
NMI_EVENT_L: R333.2 U1.BP1(G\P\I\O\3\5\_\N\M\I\) U29.2(A)
NMI_EVENT_L_BUF: R330.2 U29.4(Y)
NMI_EVENT_L_R: R327.2 R330.1 U30.10(I/O_0.6)
P_CPU_ALERT: PR172.2 PU17.32(ALERT#)
P_CPU_B-RAMP_10: PR144.2 PR147.1 PU17.11(B-RAMP)
P_CPU_CCOMP+_10: PC190.1 PR150.2
P_CPU_CCOMP_10: PC190.2 PC191.2 PR134.2 PR151.1 PU17.26(COMP)
P_CPU_CCSN1+_10: PNTC2.1 PR119.2
P_CPU_CCSN1_10: PC168.1 PR118.1 PR119.1 PR121.2 PU17.18(CSN1)
P_CPU_CCSN2+_10: PNTC3.1 PR126.2
P_CPU_CCSN2_10: PC178.1 PR125.1 PR126.1 PR128.2 PR156.1 PU17.19(CSN2)
P_CPU_CCSP1+_10: PR117.1 PR120.2
P_CPU_CCSP1_10: PC168.2 PNTC2.2 PR117.2 PR118.2 PU17.17(CSP1)
P_CPU_CCSP2+_10: PR124.1 PR127.2
P_CPU_CCSP2_10: PC178.2 PNTC3.2 PR124.2 PR125.2 PR155.2 PU17.20(CSP2)
P_CPU_CGFB_10: PR153.1 PU17.23(GFB)
P_CPU_CPWM1_10: PR130.1 PU17.6(PWM1)
P_CPU_CPWM1_DR1_10: PR130.2 PU18.12(PWM)
P_CPU_CPWM2_10: PR131.1 PU17.5(PWM2)
P_CPU_CPWM2_DR2_10: PR131.2 PU19.12(PWM)
P_CPU_CPWM3_10: PR202.1 PU17.4(PWM3)
P_CPU_CTHWEM_10: PC192.1 PNTC4.2 PR133.1 PU17.14(THERM)
P_CPU_CVFB_10: PR154.2 PU17.24(VFB)
P_CPU_DR1_BST_20: PC165.2 PU18.9(BOOT)
P_CPU_DR1_BST_RC_20: PC165.1 PR114.2
P_CPU_DR1_BSTR_20: PR114.1 PU18.8(BOOT_R)
P_CPU_DR1_LX_40: PC167.1 PL10.1 PR120.1 PU18.6(VSW)
P_CPU_DR2_BST_20: PC186.2 PU19.9(BOOT)
P_CPU_DR2_BST_RC_20: PC186.1 PR115.2
P_CPU_DR2_BSTR_20: PR115.1 PU19.8(BOOT_R)
P_CPU_DR2_LX_40: PC177.1 PL13.1 PR127.1 PU19.6(VSW)
P_CPU_DROOP_10: PC191.1 PR134.1 PR150.1 PU17.25(DROOP)
P_CPU_ENABLE_10: PR152.2 PU17.8(VR_ON)
P_CPU_F-IMAX_10: PR145.2 PR148.1 PU17.10(F-IMAX)
P_CPU_IMON_10: PC193.1 PR143.2 PU17.13(IMON)
P_CPU_O-USR_10: PR146.2 PR149.1 PU17.9(O-USR)
P_CPU_OCP-I_10: PR141.1 PR143.1 PU17.12(OCP-I)
P_CPU_SB1_20: PC167.2 PR116.1
P_CPU_SB2_20: PC177.2 PR123.1
P_CPU_SKIP#_1_10: PR122.2 PU18.10(FCCM)
P_CPU_SKIP#_2_10: PR129.2 PU19.10(FCCM)
P_CPU_SKIP#_10: PR122.1 PR129.1 PU17.7(SKIP#)
P_CPU_SLEWA_10: PR140.1 PR142.2 PU17.15(SLEWA)
P_CPU_V5A_10: PC188.1 PR138.2 PU17.28(V5A)
P_CPU_VBAT_10: PR132.2 PU17.16(VBAT)
P_CPU_VCLK: PR171.2 PU17.31(VCLK)
P_CPU_VDD_10: PC187.1 PR139.2 PU17.2(VDD)
P_CPU_VDIO: PR170.2 PU17.1(VDIO)
P_CPU_VREF_10: PC189.1 PNTC4.1 PR142.1 PR144.1 PR145.1 PR146.1 PR151.2 PU17.27(VREF)
P_DDR4_ALERT: PR182.2 PU21.32(ALERT#)
P_DDR4_B-RAMP: PR165.2 PR176.1 PU21.11(B-RAMP)
P_DDR4_CCSN1+_10: PNTC6.1 PR163.2
P_DDR4_CCSN1_10: PC215.1 PR162.1 PR163.1 PR168.2 PU21.18(CSN1)
P_DDR4_CCSP1+_10: PR161.1 PR167.2
P_DDR4_CCSP1_10: PC215.2 PNTC6.2 PR161.2 PR162.2 PU21.17(CSP1)
P_DDR4_CGFB_10: PR187.1 PU21.23(GFB)
P_DDR4_COMP_10: PC238.2 PR183.2 PR184.1 PR190.2 PU21.26(COMP)
P_DDR4_COMP_RC_10: PC236.2 PR183.1
P_DDR4_CPWM1_DR1_10: PR181.2 PU22.12(PWM)
P_DDR4_CVFB_10: PR188.2 PU21.24(VFB)
P_DDR4_DR1_BST_20: PC241.2 PU22.9(BOOT)
P_DDR4_DR1_BST_RC_20: PC241.1 PR199.2
P_DDR4_DR1_BSTR_20: PR199.1 PU22.8(BOOT_R)
P_DDR4_DR1_LX_40: PC214.1 PL14.1 PR167.1 PU22.6(VSW)
P_DDR4_DROOP_10: PC236.1 PC238.1 PR190.1 PU21.25(DROOP)
P_DDR4_F-IMAX: PR166.2 PR177.1 PU21.10(F-IMAX)
P_DDR4_IMON: PC240.1 PR164.2 PU21.13(IMON)
P_DDR4_MODE: PR200.1 PU21.4(MODE)
P_DDR4_O-USR: PR169.2 PR178.1 PU21.9(O-USR)
P_DDR4_OCP-I: PR158.1 PR164.1 PU21.12(OCP-I)
P_DDR4_PWM1: PR181.1 PU21.6(PWM1)
P_DDR4_SB1_20: PC214.2 PR160.1
P_DDR4_SKIP: PR198.1 PU21.7(SKIP#)
P_DDR4_SKIP#_1_10: PR198.2 PU22.10(FCCM)
P_DDR4_SLEWA: PR157.1 PR159.2 PU21.15(SLEWA)
P_DDR4_TAO_DR1: PC217.1 PU22.11(TAO)
P_DDR4_THERM: PC239.1 PNTC5.2 PR189.1 PU21.14(THERM)
P_DDR4_V5A_10: PC234.1 PR194.2 PU21.28(V5A)
P_DDR4_VCLK: PR180.2 PU21.31(VCLK)
P_DDR4_VDD: PC233.1 PR195.2 PU21.2(VDD)
P_DDR4_VDIO: PR179.2 PU21.1(VDIO)
P_DDR4_VIN_10: PR185.2 PU21.16(VBAT)
P_DDR4_VIN_SHAPE: PC222.1 PC223.1 PC231.1 PC275.1 PL12.2 PU22.7(VIN)
P_DDR4_VR_ON: PR186.2 PU21.8(VR_ON)
P_DDR4_VREF_10: PC235.1 PNTC5.1 PR159.1 PR165.1 PR166.1 PR169.1 PR184.2 PU21.27(VREF)
PCH_HOT_L: R202.2 U1.AL76(P\C\H\H\O\T\_\C\P\U\) U1.BF7(SML1ALERT_N_PCHHOT_N_GPIO74) U13.12(1B2)
PCH_HOT_LVT3_L: U13.5(1A2) U31.A15(FM_PCH_HOT_LVT3_N)
PCH_PWROK: R97.2 U1.AN1(PCH_PWROK) U31.B7(PWRGD_PCH_PWROK)
PD_BDXDE_SPARE1: R259.2 R264.1 U1.AC64(RSVD9)
PD_BDXDE_SPARE2: R260.2 R265.1 U1.AN78(RSVD10)
PD_BDXDE_SPARE3: R261.2 R266.1 U1.AG67(RSVD11)
PD_BDXDE_SPARE4: R262.2 R267.1 U1.AJ67(RSVD12)
PD_BIST_ENABLE: R287.2 R292.1 U1.AM69(BIST_ENABLE)
PD_CLKIN_CPY_N: R137.2 U1.Y30(CLKIN_GND1_DN)
PD_CLKIN_CPY_P: R135.2 U1.AA30(CLKIN_GND1_DP)
PD_CLKIN_DMI_N: R142.2 U1.N35(CLKIN_GND2_DN)
PD_CLKIN_DMI_P: R141.2 U1.P33(CLKIN_GND2_DP)
PD_CLKIN_DOT96_N: R140.2 U1.AB1(CLKIN_GND3_DN)
PD_CLKIN_DOT96_P: R138.2 U1.AB3(CLKIN_GND3_DP)
PD_CPU_TSTCLK_N: R145.2 U1.F54(RSVD16)
PD_CPU_TSTCLK_P: R144.2 U1.J54(RSVD17)
PD_DMI_TERMINATION_GPIO33: R242.2 R246.1 U1.AN11(GPIO33)
PD_GPIO52_CPUSV: R296.2 R300.1 U1.BP16(GPIO52)
PD_GPIO53_GSXDIN: R243.2 R247.1 U1.BT20(GPIO53)
PD_LAN_NCSI_CLKIN_TXD0_1_EN: R17.1 U1.AA72(LAN_NCSI_CLK_IN) U1.AA75(LAN_NCSI_TX_EN) U1.W77(LAN_NCSI_TXD0) U1.Y78(LAN_NCSI_TXD1)
PD_REFCLK14IN: R143.2 U1.W9(REFCLK14IN)
PD_RSV1: R90.2 U1.AK66(RSVD1)
PD_RSV2: R93.2 U1.E72(RSVD2)
PD_TEST0: R171.2 U1.CU76(TEST0)
PD_TEST1: R170.2 U1.CM78(TEST1)
PD_TEST_CPU_TSTSTRAP: R147.2 R148.1 U1.E55(RSVD18)
PD_TEST_NOA_COMP: R169.2 U1.AA66(RSVD84)
PECI_PCH: R311.1 U1.BG16(PECI_PCH)
PECI_PCH_BMC: J10.A19(RSVD_1) R105.2 R311.2
PHY_BDXDE_WAKE_3V3_L: U12.2(A) U13.4(1A1)
PHY_BDXDE_WAKE_L: R51.1 R201.2 U13.13(1B1)
PHY_BDXDE_WAKE_L_ST: R51.2 U1.AD76(W\A\K\E\L\A\N\)
PHY_WAKE_L_ST: R53.2 U1.BA1(W\A\K\E\)
PM_SYNC_PCH: U1.BT9(PM_SYNC_PCH) U1.H77(PMSYNC_CPU)
PROCHOT_L: J10.B51(PCIE0_TX8_N) R220.2
PU_ADR_IN: R72.2 U1.AD66(ADR_IN)
PU_BDXDE_INTVRMEN: R273.2 U1.AP2(INTVRMEN)
PU_BDXDE_RI_L: R71.2 U1.BF11(R\I\)
PU_BDXDE_SPARE5: R114.2 U1.D71(RSVD13)
PU_BDXDE_SUSACK_L: R76.2 U1.AY4(S\U\S\A\C\K\)
PU_BMBUSY_N_GPIO0: R70.2 U1.BB28(BMBUSY_N_GPIO0)
PU_BMCINIT: R66.2 U1.AD69(BMCINIT)
PU_DDR3_4_STRAP: R280.2 R285.1 U1.AK69(DDR3_4_STRAP)
PU_DSWODVREN: R271.2 U1.AL1(DSWODVREN)
PU_EAR_L: R113.2 U1.AH62(E\A\R\)
PU_GPIO51_GSXDOUT: R240.2 R244.1 U1.BL18(GPIO51)
PU_GPIO72_BATLOW_L: R74.2 U1.BB4(GPIO72)
PU_INTRUDER_L: R78.2 U1.AK2(I\N\T\R\U\D\E\R\)
PU_NCTF4: R184.2 U1.BA18(NCTF_TP4)
PU_P2E_RCOMP: R182.2 U1.AA27(PCIE_RCOMP)
PU_PE_HP_SDA: R109.2 U1.AN67(PE_HP_SDA) U1.AR67(PE_HP_SCL)
PU_PIRQA_L: R73.2 U1.BG20(P\I\R\Q\A\)
PU_PIRQB_L: R75.2 U1.BF22(P\I\R\Q\B\)
PU_PIRQC_L: R46.1 R77.2 U1.AR11(P\I\R\Q\C\)
PU_PIRQD_L: R45.1 R80.2 U1.BH22(P\I\R\Q\D\)
PU_RSVD0: R67.2 U1.BL14(RSVD0)
PU_SAFE_MODE_BOOT: R291.2 U1.AF69(SAFE_MODE_BOOT)
PU_SATA_RCOMP: R30.2 U1.BB32(SATA_RCOMP)
PU_SGPIO22_SATA_CLOCK: R33.2 U1.BN14(SCLOCK_GPIO22)
PU_SGPIO38_PCH_SLOAD: R34.2 U1.BP13(SLOAD_GPIO38)
PU_SGPIO39_SATA_DATAOUT0: R36.2 U1.BU18(SDATAOUT0_GPIO39)
PU_SGPIO48_SATA_DATAOUT1: R35.2 U1.BT16(SDATAOUT1_GPIO48)
PU_TEST_NCTF_TP3: R65.2 U1.BA27(NCTF_TP3)
PWR_EN_CPU_VCCIN: PC304.1 PR152.1 PR239.1 PR241.1 R378.2
PWR_EN_VP0P6_DDR4_VTT: PC302.1 PR38.2 PR231.1 PR232.1 R379.2
PWR_EN_VP1P2_DDR4_VDD: PC301.1 PR186.1 PR228.1 PR229.1 R375.2
PWR_EN_VP1P3: PC36.1 PC298.1 PR223.1 PR224.1 PU5.5(EN) R376.2
PWR_EN_VP1P05: PC299.1 PR2.1 PR219.1 R372.2
PWR_EN_VP1P5_PCH: PC29.1 PC305.1 PR235.1 PR236.1 PU6.5(EN) R374.2
PWR_EN_VP1P05_PCH: PC303.1 PR233.1 PR234.1 PU24.2(EN) R373.2
PWR_EN_VP1P05VDD: PR281.1
PWR_EN_VP1P7: PC297.1 PR221.1 PR222.1 PU14.15(EN) R371.2
PWR_EN_VP2P5_DDR4_VPP: PC300.1 PR226.1 PR227.1 PU20.7(EN) R370.2
PWR_EN_VP3P3: PC296.1 PR1.1 PR218.1 PU2.1(EN)
PWR_EN_VP3P3_A: PC306.1 PR237.1 PR238.1 PU25.2(EN) R377.2
PWR_EN_VP5P0: PC295.1 PR216.2 PR217.1 PU1.7(EN)
PWR_ENST_CPU_VCCIN: R378.1 U31.A13(FM_CPLD_PVCCIN_EN)
PWR_ENST_VP0P6_DDR4_VTT: R379.1 U31.C15(FM_CPLD_P0V6_VTT_DIMM_EN)
PWR_ENST_VP1P2_DDR4_VDD: R375.1 U31.B14(FM_CPLD_P1V2_VDDQ_EN)
PWR_ENST_VP1P3: R376.1 U31.P12(FM_CPLD_PVCCKRHV_EN)
PWR_ENST_VP1P05: R372.1 U31.G16(FM_CPLD_PVCCIOIN_EN)
PWR_ENST_VP1P5_PCH: R374.1 U31.R12(FM_CPLD_P1V5_PCH_EN)
PWR_ENST_VP1P05_PCH: R373.1 U31.G11(FM_CPLD_P1V05_PROC_IO_EN_N) U31.J16(FM_CPLD_P1V05_PCH_EN)
PWR_ENST_VP1P7: R371.1 U31.T13(FM_CPLD_PVCCSCFUSESUS_EN)
PWR_ENST_VP2P5_DDR4_VPP: R370.1 U31.D15(FM_CPLD_P2V5_VPP_EN)
PWR_ENST_VP3P3_A: R377.1 U31.P15(FM_CPLD_P3V3_EN_N)
PWRGD_APWROK: R84.2 U1.BE13(APWROK) U31.B5(PWRGD_APWROK)
PWRGD_BDXDE_LAN: R203.1 R402.1 U1.AE77(LAN_PWRGOOD) U14.4(1A1)
PWRGD_CPLD_BDXDE_LAN: U14.13(1B1) U31.A6(PWRGD_CPLD_BDXDE_LAN)
PWRGD_CPU0: R95.2 R404.1 U1.BU11(PROCPWRGD_PCH) U1.CR39(DDR_PWRGOOD) U1.V76(PWRGOOD_CPU) U11.13(1B1)
PWRGD_CPU0_CPLD: J10.A11(PWRGD) U11.4(1A1) U31.C6(PWRGD_CPU0_CPLD)
PWRGD_CPU_VCCIN: PC326.1 PR135.2 PU17.3(PGOOD) U31.A12(PWRGD_PVCCIN) U31.N1(PWRGD_P1V8)
PWRGD_CPU_VCCIO_R: Q1.2(G1) R343.2
PWRGD_VP0P6_DDR4_VTT: PR191.2 PR234.2 PU11.9(PGOOD) U31.B16(PWRGD_P0V6_VTT_DIMM)
PWRGD_VP1P2_DDR4_VDD: PR203.2 PR232.2 PU21.3(PGOOD) U31.C14(PWRGD_P1V2_VDDQ)
PWRGD_VP1P3: PR13.2 PR219.2 PU5.3(PG) U31.P13(PWRGD_PVCCKRHV)
PWRGD_VP1P05: PR227.2 PR277.2 PU27.3(PGOOD) R343.1 U31.G15(PWRGD_PVCCIOIN) U31.H15(PWRGD_PVCCSCSUS) U31.H16(PWRGD_PVCCGBE)
PWRGD_VP1P5: PR11.2 PR238.2 PU6.3(PG) U31.T12(PWRGD_P1V5_PCH)
PWRGD_VP1P05_M: Q1.5(G2) Q1.6(D1) R341.2
PWRGD_VP1P05_PCH: PR26.2 PR236.2 PU24.6(PG) U31.F12(PWRGD_P1V05_PROC_IO) U31.J15(PWRGD_P1V05_PCH)
PWRGD_VP1P7: PC112.1 PR33.2 PR224.2 PU14.14(PWRGD) U31.R13(PWRGD_PVCCSCFUSESUS)
PWRGD_VP2P5_DDR4_VPP: PC322.1 PR79.2 PR229.2 PR265.1 PU20.4(PG) U31.D14(PWRGD_P2V5_VPP)
PWRGD_VP3P3: PR221.2 PR242.2 PU2.4(PG) U31.T15(PWRGD_P3V3_STBY)
PWRGD_VP3P3_A: C174.1 PR241.2 PR252.2 PU25.6(PG) U31.N16(PWRGD_P3V3)
PWRGD_VP5P0: PC13.1 PR17.1 PR218.2 PR244.2 PU1.4(PG)
PWRUP_RST_L: C173.1 R385.2 U31.N2(CPLD_RSMRST_N) U34.1(\\\\\\\\\\RESET)
RST_CPLD_CPU_RSMRST_L: R212.1 U18.2(A) U31.T4(RST_CPLD_CPU_RSMRST_N)
RST_PCIE_PCH_N_GPIO19: R241.2 R245.1 U1.BT3(SATA1GP_GPIO19)
RST_PLTRST_L: C171.1 R103.1 U1.BE24(P\L\T\R\S\T\) U31.B12(FM_BDXDE_PLTRST_N)
RST_PLTRST_LPC_L: J1.5 R103.2
RST_RSMRST_L: C172.1 R87.2 U1.AR7(R\S\M\R\S\T\) U1.AV4(DPWROK) U31.R4(RST_RSMRST_N)
RST_SRTCRST_L: C35.1 J3.1 R130.2 U1.AP4(S\R\T\C\R\S\T\)
RST_TPM_N: R310.1 R352.2 U1.BV20(GPIO50)
RTCRST_L: C33.1 J3.3 R129.2 R312.2 R461.2 U1.AP9(R\T\C\R\S\T\)
SATA0GP_GP21: TP6.1 U1.BR2(SATA0GP_GPIO21)
SATA3_SSD_RX_N: C202.1 J9.43(SATA-B-/PERN0)
SATA3_SSD_RX_P: C201.1 J9.41(SATA-B+/PERP0)
SATA3_SSD_TX_N: C203.1 J9.47(SATA-A-/PETN0)
SATA3_SSD_TX_P: C204.1 J9.49(SATA-A+/PETP0)
SATA_P2_RX_N: C202.2 U1.CA33(SATA_RX_DN0)
SATA_P2_RX_P: C201.2 U1.BY32(SATA_RX_DP0)
SATA_P2_TX_AC_N: C203.2 U1.BV28(SATA_TX_DN0)
SATA_P2_TX_AC_P: C204.2 U1.BW26(SATA_TX_DP0)
SATA_PRESENT_L_ST: J9.1(CONFIG_3) R389.1
SATA_SSD_PRESENT_L: R388.2 R389.2 R391.2
SATALED_L: D1.2(C) R29.2 U1.BF14(S\A\T\A\L\E\D\)
SFPP0_KR_RX0_AC_N: C16.1 J10.A30(PCIE0_RX3_N)
SFPP0_KR_RX0_AC_P: C14.1 J10.A29(PCIE0_RX3_P)
SFPP0_KR_RX0_N: C16.2 U1.N62(LAN_KR_RX0_N)
SFPP0_KR_RX0_P: C14.2 U1.R62(LAN_KR_RX0_P)
SFPP0_KR_TX0_N: J10.B28(PCIE0_TX3_N) U1.J62(LAN_KR_TX0_N)
SFPP0_KR_TX0_P: J10.B27(PCIE0_TX3_P) U1.F62(LAN_KR_TX0_P)
SFPP1_KR_RX1_AC_N: C15.1 J10.A26(PCIE0_RX2_N)
SFPP1_KR_RX1_AC_P: C13.1 J10.A25(PCIE0_RX2_P)
SFPP1_KR_RX1_N: C15.2 U1.T64(LAN_KR_RX1_N)
SFPP1_KR_RX1_P: C13.2 U1.P64(LAN_KR_RX1_P)
SFPP1_KR_TX1_N: J10.B24(PCIE0_TX2_N) U1.J66(LAN_KR_TX1_N)
SFPP1_KR_TX1_P: J10.B23(PCIE0_TX2_P) U1.F66(LAN_KR_TX1_P)
SKU_ID0: R431.1 R432.1 U31.P5(GND_101)
SKU_ID1: R433.1 R434.1 U31.P6(GND_102)
SKU_ID2: R435.1 R436.1 U31.P7(GND_103)
SLP3_CPU_L: R85.2 R96.1 U1.AC71(S\L\P\_\S\3\_\C\P\U\)
SLP3_L: R85.1 U1.AY2(S\L\P\_\S\3\) U30.18(I/O_1.5) U31.B9(FM_BDXDE_SLP3_N)
SLP4_L: U1.AW1(S\L\P\_\S\4\) U30.14(I/O_1.1) U31.C9(FM_BDXDE_SLP4_N)
SLPA_L: R83.2 U1.BB7(S\L\P\_\A\)
SMB_CPU_XDP_LVC3_CLK: J12.53 R409.2
SMB_CPU_XDP_LVC3_DAT: J12.51 R407.2
SMB_HOST_3V3SB_ALERT_L: J10.B10(3.3VAUX) R156.2 R188.1 U27.3(ALERT) U30.1(\\\\\\INT)
SMB_HOST_3V3SB_ALERT_L_ST: R188.2 U1.BH7(SMBALERT_N_GPIO11)
SMB_HOST_3V3SB_CLK: J10.B5(SMBCLK) R155.2 R187.1 R317.1 R324.1 R328.1 R409.1
SMB_HOST_3V3SB_CLK_ST: R187.2 U1.BN11(SMBCLK)
SMB_HOST_3V3SB_DAT: J10.B6(SMBDAT) R154.2 R186.1 R318.1 R323.1 R329.1 R407.1
SMB_HOST_3V3SB_DAT_ST: R186.2 U1.BJ13(SMBDATA)
SMB_INA230_ALRT_PROCHOT_L: R98.2 R100.1 U1.BC9(GPIO31_MGPIO2) U31.B10(SMB_INA230_ALRT_N_PROCHOT)
SMB_SMLINK0_3V3SB_ALRT: R64.2 U1.BL7(SML0ALERT_N_GPIO60_MGPIO4)
SMB_SMLINK0_3V3SB_CLK: J10.A76(PCIE0_RX14_P) R62.2 U1.BR7(SML0CLK)
SMB_SMLINK0_3V3SB_DAT: J10.A77(PCIE0_RX14_N) R63.2 U1.BN18(SML0DATA)
SMB_SMLINK1_3V3SB_CLK: R59.2 U1.BG9(SML1CLK_GPIO58_MGPIO11)
SMB_SMLINK1_3V3SB_DAT: R60.2 U1.BB11(SML1DATA_GPIO75_MGPIO12)
SMI_ACTIVE_L: R332.2 U1.BR4(G\P\I\O\2\0\_\S\M\I\) U28.2(A)
SMI_ACTIVE_L_BUF: R325.2 U28.4(Y)
SMI_ACTIVE_L_R: R325.1 R326.2 U30.11(I/O_0.7)
SPI_BUF_SSB_CLK: J6.4 R422.1 U20.14(1B3)
SPI_BUF_SSB_CLK_ST: R422.2 U23.6(SCLK) U24.6(SCLK)
SPI_BUF_SSB_CS0_L: J6.3 R228.2 U20.12(1B4) U23.1(CS#)
SPI_BUF_SSB_CS1_L: J6.7 R304.2 U20.9(2B1) U24.1(CS#)
SPI_BUF_SSB_HOLD_L: R227.2 U23.7(RESET#/SIO3) U24.7(RESET#/SIO3)
SPI_BUF_SSB_MISO: J6.5 R443.1 U20.18(1B1)
SPI_BUF_SSB_MISO_ST: R443.2 U23.2(SO/SIO1) U24.2(SO/SIO1)
SPI_BUF_SSB_MOSI: J6.6 R421.1 U20.16(1B2)
SPI_BUF_SSB_MOSI_ST: R421.2 U23.5(SI/SIO0) U24.5(SI/SIO0)
SPI_BUF_SSB_WP_L: R225.2 R226.1 U23.3(WP#/SIO2) U24.3(WP#/SIO2)
SPI_MUX_SSB_CS0_L: U20.8(1A4) U21.3(B0) U22.1(B1)
SPI_MUX_SSB_CS1_L: U20.11(2A1) U21.1(B1) U22.3(B0)
SPI_SSB_CLK: R217.1 R218.1 U1.BG13(SPI_CLK)
SPI_SSB_CLK_ST: R217.2 U20.6(1A3)
SPI_SSB_CS0_L: U1.BN7(S\P\I\_\C\S\0\) U21.4(A)
SPI_SSB_CS1_L: U1.BT13(S\P\I\_\C\S\1\) U22.4(A)
SPI_SSB_MISO: R40.1 R215.1 U1.BJ20(SPI_MISO_IO1)
SPI_SSB_MISO_ST: R215.2 U20.2(1A1)
SPI_SSB_MOSI: R39.1 R216.1 U1.BL11(SPI_MOSI_IO0)
SPI_SSB_MOSI_ST: R216.2 U20.4(1A2)
SRC1CLKRQB_GP18: TP8.1 U1.BN4(SRC1CLKRQ_N_GPIO18)
SUS_WARN_L: R82.2 U1.AY11(SUSWARN_N_SUSPWRDNACK_GPIO30)
SVID_CPU_ALERT_L: PR109.1 PR112.2 PR172.1 PR175.2 PR182.1 PR201.2 R108.2 R122.2
SVID_CPU_DIO: PR107.1 PR110.2 PR170.1 PR173.2 PR179.1 PR196.2 R106.2 R119.2
SYS_PWROK: C189.1 J12.47 R398.2 U1.BP5(SYS_PWROK) U30.19(I/O_1.6) U31.G1(XDP_CPU_SYSPWROK)
SYS_RESET_L: C188.1 J10.B31(PRSNT2_2_L) J12.48 R339.2 R342.2 R397.2 U30.17(I/O_1.4) U31.M9(SYS_RESET_N)
SYS_RESET_R_L: Q3.1(B) R342.1
TP_CPU_SLP_SUS_N: TP1.1 U1.AY7(S\L\P\_\S\U\S\)
TP_DDR0_DQS_DN9: U1.CA1(DDR0_DQS_DN9)
TP_DDR0_DQS_DN10: U1.CD9(DDR0_DQS_DN10)
TP_DDR0_DQS_DN11: U1.CF14(DDR0_DQS_DN11)
TP_DDR0_DQS_DN12: U1.CC22(DDR0_DQS_DN12)
TP_DDR0_DQS_DN13: U1.CC67(DDR0_DQS_DN13)
TP_DDR0_DQS_DN14: U1.CK67(DDR0_DQS_DN14)
TP_DDR0_DQS_DN15: U1.BR71(DDR0_DQS_DN15)
TP_DDR0_DQS_DN16: U1.BP66(DDR0_DQS_DN16)
TP_DDR0_DQS_DN17: U1.CK22(DDR0_DQS_DN17)
TP_DDR0_DQS_DP9: U1.CA3(DDR0_DQS_DP9)
TP_DDR0_DQS_DP10: U1.CF7(DDR0_DQS_DP10)
TP_DDR0_DQS_DP11: U1.CD13(DDR0_DQS_DP11)
TP_DDR0_DQS_DP12: U1.CF22(DDR0_DQS_DP12)
TP_DDR0_DQS_DP13: U1.CF67(DDR0_DQS_DP13)
TP_DDR0_DQS_DP14: U1.CM67(DDR0_DQS_DP14)
TP_DDR0_DQS_DP15: U1.BP72(DDR0_DQS_DP15)
TP_DDR0_DQS_DP16: U1.BR67(DDR0_DQS_DP16)
TP_DDR0_DQS_DP17: U1.CM22(DDR0_DQS_DP17)
TP_DDR1_DQS_DN9: U1.CH4(DDR1_DQS_DN9)
TP_DDR1_DQS_DN10: U1.CT9(DDR1_DQS_DN10)
TP_DDR1_DQS_DN11: U1.CR17(DDR1_DQS_DN11)
TP_DDR1_DQS_DN12: U1.CT25(DDR1_DQS_DN12)
TP_DDR1_DQS_DN13: U1.CR74(DDR1_DQS_DN13)
TP_DDR1_DQS_DN14: U1.CE76(DDR1_DQS_DN14)
TP_DDR1_DQS_DN15: U1.BU75(DDR1_DQS_DN15)
TP_DDR1_DQS_DN16: U1.BK76(DDR1_DQS_DN16)
TP_DDR1_DQS_DN17: U1.CR32(DDR1_DQS_DN17)
TP_DDR1_DQS_DP9: U1.CH2(DDR1_DQS_DP9)
TP_DDR1_DQS_DP10: U1.CV9(DDR1_DQS_DP10)
TP_DDR1_DQS_DP11: U1.CU17(DDR1_DQS_DP11)
TP_DDR1_DQS_DP12: U1.CV25(DDR1_DQS_DP12)
TP_DDR1_DQS_DP13: U1.CR76(DDR1_DQS_DP13)
TP_DDR1_DQS_DP14: U1.CE78(DDR1_DQS_DP14)
TP_DDR1_DQS_DP15: U1.BU77(DDR1_DQS_DP15)
TP_DDR1_DQS_DP16: U1.BK78(DDR1_DQS_DP16)
TP_DDR1_DQS_DP17: U1.CU32(DDR1_DQS_DP17)
TP_DDR_VREFDQ0: U1.CV51(DDR_VREFDQ0)
TP_DDR_VREFDQ1: U1.CT51(DDR_VREFDQ1)
TP_GPIO_4: U31.K2(GPIO_4)
TP_GPIO_23: U1.AL5(LDRQ1_N_GPIO23)
TP_GPIO_25: U1.BA5(GPIO25)
TP_GPIO_26: R308.1 U1.BB14(GPIO26)
TP_GPIO_61: U1.BB18(SUS_STAT_N_GPIO61)
TP_LDRQ_0: U1.AK4(L\D\R\Q\0\)
TP_NCTF_11: R167.1 U1.P11(NCTF_TP11)
TP_NCTF_TP09: U1.T37(NCTF_TP9)
TP_NCTF_TP10: U1.T35(NCTF_TP10)
TP_NCTF_TP12: U1.K11(NCTF_TP12)
TP_NCTF_TP13: U1.J20(NCTF_TP13)
TP_NCTF_TP14: U1.H11(NCTF_TP14)
TP_NCTF_TP15: U1.F20(NCTF_TP15)
TP_RSVD96: U1.BT62(RSVD96)
TP_RSVD97: U1.AR71(RSVD97)
TP_RSVD_3: U1.H71(RSVD3)
TP_RSVD_4: U1.K71(RSVD4)
TP_RSVD_5: U1.J69(RSVD5)
TP_RSVD_6: U1.F69(RSVD6)
TP_RSVD_7: U1.K64(RSVD7)
TP_RSVD_8: U1.H64(RSVD8)
TP_RSVD_14: U1.N54(RSVD14)
TP_RSVD_15: U1.L54(RSVD15)
TP_RSVD_19: U1.W66(RSVD19)
TP_RSVD_20: U1.Y64(RSVD20)
TP_RSVD_21: R166.1 U1.AP75(RSVD21)
TP_RSVD_22: U1.AM56(RSVD22)
TP_RSVD_23: U1.AP55(RSVD23)
TP_RSVD_24: U1.AM55(RSVD24)
TP_RSVD_25: U1.BL60(RSVD25)
TP_RSVD_26: U1.BJ62(RSVD26)
TP_RSVD_27: U1.V40(RSVD27)
TP_RSVD_28: U1.CA37(RSVD28)
TP_RSVD_29: U1.AP60(RSVD29)
TP_RSVD_30: U1.AP56(RSVD30)
TP_RSVD_31: U1.AK56(RSVD31)
TP_RSVD_32: U1.BL37(RSVD32)
TP_RSVD_33: U1.AG56(RSVD33)
TP_RSVD_34: U1.BP37(RSVD34)
TP_RSVD_35: U1.AE56(RSVD35)
TP_RSVD_36: U1.BT37(RSVD36)
TP_RSVD_37: U1.AC56(RSVD37)
TP_RSVD_38: U1.BW37(RSVD38)
TP_RSVD_39: U1.T42(RSVD39)
TP_RSVD_40: U1.T40(RSVD40)
TP_RSVD_41: U1.T44(RSVD41)
TP_RSVD_42: U1.BP58(RSVD42)
TP_RSVD_43: U1.R44(RSVD43)
TP_RSVD_44: U1.BP56(RSVD44)
TP_RSVD_45: U1.CB43(RSVD45)
TP_RSVD_46: U1.CB39(RSVD46)
TP_RSVD_47: U1.BM62(RSVD47)
TP_RSVD_48: U1.V39(RSVD48)
TP_RSVD_49: U1.Y33(RSVD49)
TP_RSVD_50: U1.BU60(RSVD50)
TP_RSVD_51: U1.Y37(RSVD51)
TP_RSVD_52: U1.BR60(RSVD52)
TP_RSVD_53: U1.V37(RSVD53)
TP_RSVD_54: U1.Y35(RSVD54)
TP_RSVD_55: U1.Y32(RSVD55)
TP_RSVD_56: U1.A66(RSVD56)
TP_RSVD_57: U1.C66(RSVD57)
TP_RSVD_58: U1.B54(RSVD58)
TP_RSVD_59: U1.D54(RSVD59)
TP_RSVD_60: U1.A55(RSVD60)
TP_RSVD_61: U1.C55(RSVD61)
TP_RSVD_62: U1.AE58(RSVD62)
TP_RSVD_63: U1.AG58(RSVD63)
TP_RSVD_64: U1.AE62(RSVD64)
TP_RSVD_65: U1.AM66(RSVD65)
TP_RSVD_66: U1.AE60(RSVD66)
TP_RSVD_67: U1.AN64(RSVD67)
TP_RSVD_68: U1.AK58(RSVD68)
TP_RSVD_69: U1.AP58(RSVD69)
TP_RSVD_70: U1.AC60(RSVD70)
TP_RSVD_71: U1.AC62(RSVD71)
TP_RSVD_72: U1.AG60(RSVD72)
TP_RSVD_73: U1.AH58(RSVD73)
TP_RSVD_74: U1.AG64(RSVD74)
TP_RSVD_75: U1.AH60(RSVD75)
TP_RSVD_76: U1.AM58(RSVD76)
TP_RSVD_77: U1.AM60(RSVD77)
TP_RSVD_78: U1.AP66(RSVD78)
TP_RSVD_79: U1.AR64(RSVD79)
TP_RSVD_80: U1.AP62(RSVD80)
TP_RSVD_81: U1.AM62(RSVD81)
TP_RSVD_82: U1.AK62(RSVD82)
TP_RSVD_83: U1.AJ64(RSVD83)
TP_RSVD_85: U1.N43(RSVD85)
TP_RSVD_86: U1.N47(RSVD86)
TP_RSVD_87: U1.R39(RSVD87)
TP_RSVD_88: U1.N39(RSVD88)
TP_RSVD_89: U1.C49(RSVD89)
TP_RSVD_90: U1.A49(RSVD90)
TP_RSVD_91: U1.Y60(RSVD91)
TP_RSVD_92: U1.Y62(RSVD92)
TP_SPI_SSB_IO2: U1.BF18(SPI_IO2)
TP_SPI_SSB_IO3: U1.BE20(SPI_IO3)
TP_TPM_GPIO: TP4.1 U25.6(GPIO)
TP_TSTCLK_SC_N: R3.2 U1.A73(RSVD93)
TP_TSTCLK_SC_P: R2.2 U1.A74(RSVD94)
TP_U34_4: TP9.1 U34.4(CT)
TP_XDP_CPU_TCK1: J12.55 TP11.1
TP_XDP_PCH_TCK: R448.2
TPM_BUF_SSB_CLK: R221.1 U20.7(2B2)
TPM_BUF_SSB_MISO: R183.1 U20.3(2B4)
TPM_BUF_SSB_MOSI: R192.1 U20.5(2B3)
TPM_CLK: R221.2 U25.19(SCLK)
TPM_CS_N: R102.2 R395.1 U25.20(CS#)
TPM_MISO: R183.2 U25.24(MISO)
TPM_MOSI: R192.2 U25.21(MOSI)
TPM_PIRQ#: R305.2 U25.18(PIRQ#)
TPM_PRSENCE: R316.1 R350.2 U25.7(PP)
TPM_RST#: R310.2 U25.17(RST#)
TPM_SSB_CLK_ST: R218.2 U20.13(2A2)
TPM_SSB_CS2_L: R102.1 U1.BJ9(S\P\I\_\C\S\2\)
TPM_SSB_MISO_ST: R40.2 U20.17(2A4)
TPM_SSB_MOSI_ST: R39.2 U20.15(2A3)
TXT_AGENT: R281.2 R286.1 U1.AM72(TXT_AGENT)
TXT_PLTEN: R282.1 U1.AP72(TXT_PLTEN)
U5_EN: R18.2 U5.5(OE)
U7_EN: R118.2 U7.5(EN)
U9_EN: R150.2 U9.2(OE)
U34_MR_L: R384.2 R387.1 R459.1 U34.3(\\\\MR)
U34_MR_R_L: R459.2 U31.P2(GND_99)
U34_SENSE: R386.2 U34.5(SENSE)
USB2_P2_DN: J10.B9(JTAG_TRST_L) R467.1
USB2_P2_DP: J10.B8(3.3V_3) R466.1
USB2_PCH_P0_DN: J10.B75(PCIE0_TX14_N) U1.AD3(USB2_DN0)
USB2_PCH_P0_DP: J10.B74(PCIE0_TX14_P) U1.AD1(USB2_DP0)
USB2_PCH_P1_DN: J10.A33(RSVD_3) U1.AK9(USB2_DN1)
USB2_PCH_P1_DP: J10.A32(RSVD_2) U1.AH9(USB2_DP1)
USB2_PCH_P2_DN: R467.2 U1.AE4(USB2_DN2)
USB2_PCH_P2_DP: R466.2 U1.AE2(USB2_DP2)
USB2_PCH_P3_DN: J10.A80(PCIE0_RX15_P) U1.AG7(USB2_DN3)
USB2_PCH_P3_DP: J10.A81(PCIE0_RX15_N) U1.AJ7(USB2_DP3)
USB_OC_0_L: R157.2 U1.BH1(OC0_N_GPIO59)
USB_OC_1_L: R158.2 U1.BE2(OC1_N_GPIO40)
USB_OC_2_L: R159.2 U1.BG4(OC2_N_GPIO41)
USB_OC_3_L: R161.2 U1.BG2(OC3_N_GPIO42)
USB_OC_4_L: R162.2 U1.BE4(OC4_N_GPIO43)
USB_OC_5_L: R163.2 U1.BF3(OC5_N_GPIO9)
USB_OC_6_L: R164.2 U1.BF1(OC6_N_GPIO10)
USB_RBIAS: R32.1 U1.AG11(USB2_RBIAS) U1.AJ11(USB2_RBIAS_N)
VFLTP1P05_CPU_VCCKRLCPLL: C39.1 C151.1 L2.1 R1.2 U1.T56(VCCKRLCPLL)
VFLTP1P05_CPU_VCCSCPLL: C40.1 C114.1 L3.1 U1.T46(VCCSCPLL)
VFLTP1P05_PCH: C177.1 C178.1 L1.2 U1.AE27(VCCAXCK1_05)
VFLTP1P05_PCH_VCCCLK: C3812.1 C3813.1 L7.2 U1.AC21(VCCCLK4) U1.AG23(VCCCLK1)
VP0P6_DDR4_VTT: C138.1 C139.1 C145.1 C146.1 CN1.258(VTT) CN2.258(VTT) PC78.1 PC79.1 PC83.1 PC84.1 PU11.3(VO) PU11.5(VOSNS)
VP0P6_DDR4_VTT_EN_R: PR38.1 PU11.7(EN)
VP0P6_DDR4_VTT_REFIN: PC81.1 PR36.2 PR37.1 PU11.1(REFIN)
VP0P6_DDR4_VTT_REFOUT: PC82.1 PU11.6(REFOUT)
VP1P2_DDR4_AB_VREFCA: C137.1 C144.1 CN1.164(VREFCA) CN2.164(VREFCA) R189.2 R190.2 R191.1
VP1P2_DDR4_VDD: C99.1 C100.1 C101.1 CN1.111(VDD_0) CN1.112(VDD_9) CN1.117(VDD_1) CN1.118(VDD_10) CN1.123(VDD_2) CN1.124(VDD_11) CN1.129(VDD_3) CN1.130(VDD_12) CN1.135(VDD_4) CN1.136(VDD_13) CN1.141(VDD_5) CN1.142(VDD_14) CN1.147(VDD_6) CN1.148(VDD_15) CN1.153(VDD_7) CN1.154(VDD_16) CN1.159(VDD_8) CN1.160(VDD_17) CN1.163(VDD_18) CN2.111(VDD_0) CN2.112(VDD_9) CN2.117(VDD_1) CN2.118(VDD_10) CN2.123(VDD_2) CN2.124(VDD_11) CN2.129(VDD_3) CN2.130(VDD_12) CN2.135(VDD_4) CN2.136(VDD_13) CN2.141(VDD_5) CN2.142(VDD_14) CN2.147(VDD_6) CN2.148(VDD_15) CN2.153(VDD_7) CN2.154(VDD_16) CN2.159(VDD_8) CN2.160(VDD_17) CN2.163(VDD_18) PC75.1 PC77.1 PC220.1 PC224.1 PC225.1 PC226.1 PC227.1 PC228.1 PC229.1 PC230.1 PC232.1(A) PC237.1(A) PC242.1(A) PC243.1 PC244.1 PC284.1(A) PL14.2 PR36.1 PR168.1 PR188.1 PR193.1 PR193.2 PU11.2(VLDOIN) R189.1 U1.CF60(VCCD33) U1.CG43(VCCD0) U1.CG51(VCCD1) U1.CG54(VCCD2) U1.CG58(VCCD3) U1.CH33(VCCD4) U1.CH37(VCCD5) U1.CH41(VCCD6) U1.CH45(VCCD7) U1.CH49(VCCD8) U1.CH56(VCCD9) U1.CJ39(VCCD12) U1.CK52(VCCD10) U1.CK60(VCCD11) U1.CL35(VCCD13) U1.CL58(VCCD34) U1.CP38(VCCD14) U1.CP40(VCCD15) U1.CP42(VCCD16) U1.CP44(VCCD17) U1.CP47(VCCD18) U1.CP49(VCCD19) U1.CP51(VCCD20) U1.CP53(VCCD21) U1.CP55(VCCD22) U1.CP58(VCCD23) U1.CP60(VCCD24) U1.CP62(VCCD38) U1.CP68(VCCD37) U1.CT55(VCCD25) U1.CU39(VCCD26) U1.CU43(VCCD27) U1.CU48(VCCD28) U1.CU52(VCCD29) U1.CU59(VCCD30) U1.CU63(VCCD31) U1.CU65(VCCD36) U1.CU67(VCCD32) U1.CU69(VCCD35)
VP1P2_DDR4_VREF: C199.1 R190.1 U1.CR52(DDR_VREF)
VP1P3: PC32.1 PC33.1 PC52.1 PR15.1 PU5.9(OUT1) PU5.10(OUT2) U1.N51(VCCKX4PLL) U1.N58(VCCKRHV)
VP1P3_FB: PR14.1 PR15.2 PU5.8(FB)
VP1P3_SS: PC37.1 PU5.7(SS)
VP1P05: C20.2 C23.1 C25.2 C29.1 C31.1 C54.1 C55.1 C56.1 C89.1 C90.1 C91.1 C92.1 C93.1 C94.1 C95.1 C96.1 C97.1 C98.1 C117.1 C119.1 C122.1 C123.1 C125.1 C127.1 J10.A22(PCIE0_RX1_N) L2.2 L3.2 PC146.1 PC147.1 PC148.1 PC151.1 PC152.1(A) PC162.1 PC218.1 PC219.1 PC247.1 PC248.1 PC249.1 PC250.1 PC252.1 PC255.1 PC256.1(A) PC266.1 PC292.1(A) PC323.1(A) PC324.1(A) PC325.1 PC349.1 PL8.2 PR110.1 PR111.2 PR112.1 PR173.1 PR174.2 PR175.1 PR196.1 PR197.2 PR201.1 PR272.1 PR299.1 PU24.1(VIN1) PU24.13(VIN2) R7.2 R8.2 R9.2 R10.2 R11.2 R14.2 R15.2 R18.1 R66.1 R69.1 R72.1 R109.1 R110.1 R111.1 R112.1 R113.1 R114.1 R115.1 R116.1 R117.1 R119.1 R122.1 R148.2 R174.1 R175.1 R180.1 R181.1 R193.1 R194.1 R195.1 R196.1 R198.1 R200.1 R201.1 R202.1 R251.1 R252.1 R258.1 R259.1 R260.1 R261.1 R262.1 R268.1 R269.1 R270.1 R272.1 R278.1 R279.1 R280.1 R281.1 R287.1 R288.1 R290.1 R291.1 R399.1 R400.1 R401.1 R403.1 R412.2 R413.2 R414.2 R415.2 R416.2 R417.2 R418.2 R419.2 R420.2 R468.2 R469.2 U1.AA58(VCCGBE0) U1.AC53(VCCIOIN1) U1.AC55(VCCIOIN0) U1.AH55(VCCIOIN3) U1.AK53(VCCIOIN5) U1.AK55(VCCIOIN2) U1.AM53(VCCIOIN4) U1.AP18(VCCIOIN6) U1.AP21(VCCIOIN7) U1.AR18(VCCIOIN8) U1.AR21(VCCIOIN9) U1.AR23(VCCIOIN10) U1.R48(VCCSCSUS5) U1.R49(VCCSCSUS4) U1.R58(VCCGBE10) U1.T48(VCCSCSUS3) U1.T49(VCCSCSUS2) U1.T51(VCCGBE9) U1.T53(VCCGBE8) U1.V48(VCCSCSUS1) U1.V49(VCCSCSUS0) U1.V51(VCCGBE7) U1.V53(VCCGBE6) U1.V56(VCCGBE5) U1.V58(VCCGBE4) U1.Y53(VCCGBE3) U1.Y56(VCCGBE2) U1.Y58(VCCGBE1) U2.6(VCCB) U4.16(VCCB) U5.1(VCCA) U7.1(VCCA) U8.16(VCCB) U10.16(VCCB) U11.16(VCCB) U13.16(VCCB) U14.1(VCCA) U15.1(VCCA) U15.2(1DIR) U15.3(2DIR) U16.1(VCCA)
VP1P5__PCH_FB: PR12.1 PR16.2 PU6.8(FB)
VP1P05_ALERT: PR109.2 PU27.32(ALERT#)
VP1P05_B-RAMP: PR285.1 PR303.2 PU27.11(B-RAMP)
VP1P05_BLEED: PR57.2 PU24.7(BLEED)
VP1P05_BST_20: PC333.2 PU26.9(BOOT)
VP1P05_BST_RC_20: PC333.1 PR273.2
VP1P05_BSTR_20: PR273.1 PU26.8(BOOT_R)
VP1P05_CCSN1+_10: PNTC8.1 PR291.2
VP1P05_CCSN1_10: PC334.1 PR287.1 PR291.1 PR299.2 PU27.18(CSN1)
VP1P05_CCSP1+_10: PR293.2 PR294.1
VP1P05_CCSP1_10: PC334.2 PNTC8.2 PR287.2 PR294.2 PU27.17(CSP1)
VP1P05_CGFB_10: PR290.1 PU27.23(GFB)
VP1P05_COMP_10: PC338.2 PR276.2 PR298.1 PR301.2 PU27.26(COMP)
VP1P05_COMP_RC_10: PC335.2 PR276.1
VP1P05_CVFB_10: PR286.2 PU27.24(VFB)
VP1P05_DROOP_10: PC335.1 PC338.1 PR301.1 PU27.25(DROOP)
VP1P05_F-IMAX: PR269.1 PR292.2 PR305.2 PU27.10(F-IMAX)
VP1P05_GSNS: PR278.1 PR290.2 U1.AP77(VSS_VCCGBE_SENSE)
VP1P05_IMON: PC339.1 PR268.2 PU27.13(IMON)
VP1P05_LX_40: PC328.1 PL8.1 PR293.1 PU26.6(VSW)
VP1P05_MODE: PR284.1 PU27.4(MODE)
VP1P05_O-USR: PR271.2 PR296.1 PU27.9(O-USR)
VP1P05_OCP-I: PR268.1 PR275.1 PU27.12(OCP-I)
VP1P5_PCH: PC25.1 PC26.1 PR16.1 PU6.9(OUT1) PU6.10(OUT2) R30.1 R50.2 R160.1 R182.1 U1.AC28(VCCVRM0) U1.AC30(VCCVRM7) U1.AE28(VCCVRM4) U1.AE30(VCCVRM3) U1.AG19(VCCADAC1_5) U1.AK28(VCCVRM2) U1.AK30(VCCVRM1) U1.AW28(VCCVRM9) U1.AW30(VCCVRM8) U1.BA30(VCCVRM5) U1.BB30(VCCVRM6) U1.BD30(SATA_IREF) U1.V33(SOC_IREF) U1.W20(ICLK_IREF) U1.W28(PCIE_IREF)
VP1P05_PCH: C57.1 C58.1 C59.1 C60.1 C61.1 C62.1 C63.1 C64.1 C65.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 L1.1 L7.1 PC265.1 PC293.1(A) PR57.1 PU24.9(VOUT1) PU24.10(VOUT2) PU24.11(VOUT3) PU24.12(VOUT4) R184.1 R197.1 R213.1 U1.AC23(VCCCLK7) U1.AC25(VCCCLK6) U1.AE21(VCCCLK5) U1.AE25(VCCCLK3) U1.AG25(VCCCLK0) U1.AG27(VCCIO6) U1.AH21(VCCIO10) U1.AH23(VCCCLK2) U1.AK18(VCCIO9) U1.AK21(VCC5) U1.AK23(VCC4) U1.AK25(VCC3) U1.AK27(VCCIO5) U1.AM14(VCCUSBPLL) U1.AM16(VCCIO8) U1.AM18(VCCIO7) U1.AM23(VCC2) U1.AM25(VCC1) U1.AM27(VCCIO4) U1.AP25(VCC0) U1.AP27(VCCIO3) U1.AR27(VCCIO2) U1.AU27(VCCIO1) U1.AW27(VCCIO0) U1.BB25(P1V05_PROC_IO)
VP1P05_PCH_SLEWRATE: PC267.1 PU24.5(SR)
VP1P5_PCH_SS: PC30.1 PU6.7(SS)
VP1P05_PWM1: PR280.1 PU27.6(PWM1)
VP1P05_PWM1_R: PR280.2 PU26.12(PWM)
VP1P05_SB1_20: PC328.2 PR304.1
VP1P05_SKIP: PR289.1 PU27.7(SKIP#)
VP1P05_SKIP#_1_10: PR289.2 PU26.10(FCCM)
VP1P05_SLEWA: PR274.1 PR282.2 PU27.15(SLEWA)
VP1P05_TAO: PC336.1 PU26.11(TAO)
VP1P05_THERM: PC332.1 PNTC7.2 PR300.1 PU27.14(THERM)
VP1P05_V5A_10: PC348.1 PR297.2 PU27.28(V5A)
VP1P05_VCLK: PR108.2 PU27.31(VCLK)
VP1P05_VDD: PC347.1 PR295.2 PU27.2(VDD)
VP1P05_VDIO: PR107.2 PU27.1(VDIO)
VP1P05_VIN: PC142.1 PC144.1 PC330.1 PC331.1 PL9.1 PU26.7(VIN)
VP1P05_VIN_10: PR279.2 PU27.16(VBAT)
VP1P05_VR_ON: PR281.2 PU27.8(VR_ON)
VP1P05_VREF_10: PC329.1 PNTC7.1 PR271.1 PR282.1 PR292.1 PR298.2 PR303.1 PR305.1 PU27.27(VREF)
VP1P05_VRHOT_L: PR302.2 PU27.30(VR_HOT#) TP12.1
VP1P05_VSNS: PR272.2 PR286.1 U1.AR78(VCCGBE_SENSE)
VP1P7: PC24.1 PC28.1 PC31.1 PC35.1 PC70.1 PC71.1 PC72.1 PC111.1 PL16.2 PR42.1 PU5.1(IN_1) PU5.2(IN_2) PU6.1(IN_1) PU6.2(IN_2) U1.AA53(VCCSCFUSESUS1) U1.AA55(VCCSCFUSESUS0) U1.AE53(VCCSCFUSESUS3) U1.AE55(VCCSCFUSESUS2)
VP1P7_BOOT: PR267.1 PU14.13(BOOT)
VP1P7_COMP: PC67.1 PR31.1 PU14.7(COMP)
VP1P7_COMP_RC: PC115.1 PR31.2
VP1P7_FB: PC113.2 PR34.1 PR35.2 PU14.6(VSENSE)
VP1P7_RT: PR32.1 PU14.8(RT/CLK)
VP1P7_SNS: PC113.1 PR35.1 PR42.2
VP1P7_SS: PC114.1 PU14.9(SS/TR)
VP1P7_SW: PC2.2 PL16.1 PU14.10(PH1) PU14.11(PH2) PU14.12(PH3)
VP1P7_VIN: PC68.1 PC69.1 PR251.1 PU14.1(VIN1) PU14.2(VIN2) PU14.16(VIN3)
VP1P8_CPU_VCCIN: C66.1 C67.1 C68.1 C69.1 C70.1 C71.1 C72.1 C73.1 C74.1 C82.1 C83.1 C84.1 C85.1 C86.1 C87.1 C88.1 PC38.1 PC39.1 PC40.1 PC41.1 PC44.1 PC45.1 PC46.1 PC47.1 PC48.1 PC173.1(A) PC179.1(A) PC185.1(A) PC194.1 PC195.1 PC196.1 PC199.1 PC200.1 PC201.1 PC202.1 PC203.1 PC204.1 PC205.1 PC206.1 PC208.1 PC209.1 PC211.1 PC212.1 PL10.2 PL13.2 PR121.1 PR128.1 PR137.1 U1.AG53(VCCIN57) U1.AG55(VCCIN58) U1.AV60(VCCIN0) U1.AW55(VCCIN1) U1.AW56(VCCIN2) U1.AW58(VCCIN3) U1.AW62(VCCIN4) U1.AW66(VCCIN5) U1.AW69(VCCIN6) U1.AW72(VCCIN7) U1.AW74(VCCIN8) U1.AW76(VCCIN9) U1.AW78(VCCIN10) U1.AY60(VCCIN11) U1.AY64(VCCIN12) U1.AY67(VCCIN13) U1.AY71(VCCIN14) U1.AY75(VCCIN15) U1.AY77(VCCIN16) U1.BA58(VCCIN17) U1.BA62(VCCIN18) U1.BA66(VCCIN19) U1.BA69(VCCIN20) U1.BA72(VCCIN21) U1.BA74(VCCIN22) U1.BA76(VCCIN23) U1.BA78(VCCIN24) U1.BB36(VCCIN25) U1.BB56(VCCIN26) U1.BB60(VCCIN27) U1.BB64(VCCIN28) U1.BB67(VCCIN29) U1.BB71(VCCIN30) U1.BB75(VCCIN31) U1.BB77(VCCIN32) U1.BC58(VCCIN33) U1.BC62(VCCIN34) U1.BC66(VCCIN35) U1.BC69(VCCIN36) U1.BC72(VCCIN37) U1.BD36(VCCIN38) U1.BD37(VCCIN39) U1.BD56(VCCIN40) U1.BD60(VCCIN41) U1.BD64(VCCIN42) U1.BD67(VCCIN43) U1.BD71(VCCIN44) U1.BD74(VCCIN45) U1.BD76(VCCIN46) U1.BD78(VCCIN47) U1.BE37(VCCIN48) U1.BE58(VCCIN49) U1.BE62(VCCIN50) U1.BF60(VCCIN51) U1.BG37(VCCIN52) U1.BG58(VCCIN53) U1.BH37(VCCIN54) U1.BH56(VCCIN55) U1.BJ56(VCCIN56)
VP2P5: R365.2
VP2P5_DDR4_VPP: C30.1 C140.1 C141.1 C147.1 C148.1 C156.1 CN1.255(VDDSPD) CN1.257(VPP_1) CN1.259(VPP_0) CN2.255(VDDSPD) CN2.257(VPP_1) CN2.259(VPP_0) PR254.2 PR266.2 R118.1 R120.2 R121.2 R229.1 R230.1 R231.1 R235.1 R236.1 R237.1 R359.2 U7.8(VCCB) U32.1(VCCA) U32.5(DIR)
VP2P5_DDR4_VPP_BST: PR80.1 PU20.8(VBST)
VP2P5_DDR4_VPP_BST_RC: PC137.1 PR80.2
VP2P5_DDR4_VPP_FB: PC312.2 PR206.2 PR207.1 PR260.1 PU20.6(VFB)
VP2P5_DDR4_VPP_FB_IN: PR204.2 PR206.1
VP2P5_DDR4_VPP_L_RC: PC312.1 PC313.2 PR261.2
VP2P5_DDR4_VPP_SN: PC140.1 PR205.2
VP2P5_DDR4_VPP_SS: PC316.1 PU20.5(SS)
VP2P5_DDR4_VPP_SW: PC137.2 PL15.1 PR205.1 PR261.1 PU20.2(SW)
VP2P5_DDR4_VPP_VIN: PC139.1 PC259.1 PC262.1 PR250.1 PR263.1 PU20.3(VIN)
VP2P5_DDR4_VPP_VOUT: PC257.1 PC258.1 PC263.1 PC313.1 PC318.1 PL15.2 PR204.1 PR254.1 PR259.1 PR266.1
VP3P3: C19.2 C21.2 C22.1 C24.2 C28.1 C32.1 C41.1 C42.1 C43.1 C44.1 C45.1 C102.1 C103.1 C107.1 C108.1 C116.1 C118.1 C120.1 C121.1 C124.1 C130.1 C131.1 C132.1 C133.1 C134.1 C152.1 C153.1 C154.1 C157.1 C158.1 C159.1 C160.1 C161.1 C162.1 C163.1 C164.1 C165.1 C166.1 C167.1 C168.1 C169.1 C170.1 C198.1 C200.1 C209.1 D2.2 D7.2 D8.2 J1.9 J2.1 J8.4 PC22.1 PC23.1 PC80.1 PC264.1 PC270.1 PC272.1 PC307.1 PL2.2 PR11.1 PR13.1 PR21.1 PR26.1 PR33.1 PR79.1 PR135.1 PR139.1 PR155.1 PR191.1 PR195.1 PR203.1 PR209.1 PR210.1 PR242.1 PR252.1 PR277.1 PR295.1 PR302.1 PU11.10(VIN) PU17.21(CSP3) PU21.20(CSP2) PU21.21(PU3) PU24.3(VCC) PU25.1(VIN1) PU25.3(VCC) PU25.9(VIN2) PU27.20(CSP2) PU27.21(PU3) R4.2 R5.2 R6.2 R59.1 R60.1 R62.1 R63.1 R64.1 R68.1 R71.1 R74.1 R76.1 R79.1 R81.1 R82.1 R83.1 R89.1 R99.1 R101.1 R154.1 R155.1 R156.1 R157.1 R158.1 R159.1 R161.1 R162.1 R163.1 R164.1 R165.1 R210.1 R214.1 R250.1 R297.1 R299.1 R306.1 R307.1 R313.1 R315.1 R316.2 R322.1 R326.1 R327.1 R331.1 R334.1 R335.1 R339.1 R340.1 R341.1 R348.1 R349.1 R351.1 R360.1 R361.1 R364.2 R366.1 R367.1 R368.1 R380.2 R381.2 R382.2 R383.2 R384.1 R385.1 R386.1 R388.1 R392.1 R393.1 R394.1 R395.2 R396.2 R397.1 R398.1 R424.2 R426.2 R428.2 R430.2 R432.2 R434.2 R436.2 R437.1 R438.1 R444.1 R445.1 R450.1 U1.AP12(VCCSUS3_34) U1.AP16(VCCSUS3_31) U1.AR14(VCCSUS3_30) U1.AR16(VCCSUS3_37) U1.AR28(VCCSUS3_33) U1.AR30(VCCSUS3_32) U1.AU18(VCCSUS3_35) U1.AW18(VCCSUS3_36) U1.AW23(VCCSUS3_38) U2.1(VCCA) U2.5(DIR) U3.8(VCC) U4.1(VCCA) U5.8(VCCB) U8.1(VCCA) U8.3(2DIR) U9.6(VDD) U10.1(VCCA) U11.1(VCCA) U12.5(VCC) U13.1(VCCA) U14.16(VCCB) U18.5(VCC) U19.5(VCC) U20.20(VCC) U21.5(VCC) U22.5(VCC) U25.1(NCI/VDD_1) U25.8(VDD_1) U25.14(NCI/VDD_2) U25.22(VDD_2) U26.8(VCC) U27.8(V+) U28.5(VCC) U29.5(VCC) U30.24(VDD) U31.A3(VCCIO2_1) U31.A14(VCCIO2_2) U31.C1(VCCIO1_1) U31.C16(VCCIO3_1) U31.F8(VCCIO2_3) U31.F9(VCCIO2_4) U31.H6(VCCIO1_2) U31.H11(VCCIO3_2) U31.J6(VCCIO1_3) U31.J11(VCCIO3_3) U31.L8(VCCIO4_1) U31.L9(VCCIO4_2) U31.P1(VCCIO1_4) U31.P16(VCCIO3_4) U31.T3(VCCIO4_3) U31.T14(VCCIO4_4) U32.6(VCCB) U33.5(VCC) U34.6(VDD) U35.1(VCCA) U35.5(DIR) U36.4(VDD) Y4.4(VDD)
VP3P3_A: C46.1 C47.1 C48.1 C49.1 C50.1 C51.1 C52.1 C53.1 C126.1 C128.1 C129.1 C185.1 C205.1 C206.1 C207.1 C208.1 C210.1 J9.2(3_3V_2) J9.4(3_3V_4) J9.12(3_3V_12) J9.14(3_3V_14) J9.16(3_3V_16) J9.18(3_3V_18) J9.70(3_3V_70) J9.72(3_3V_72) J9.74(3_3V_74) PC271.1 PR73.1 PU25.7(VOUT2) PU25.8(VOUT1) R29.1 R31.1 R33.1 R34.1 R35.1 R36.1 R65.1 R67.1 R70.1 R73.1 R75.1 R77.1 R80.1 R91.1 R98.1 R150.1 R177.1 R204.1 R207.1 R240.1 R241.1 R242.1 R243.1 R248.1 R249.1 R289.1 R296.1 R298.1 R332.1 R333.1 R338.1 R439.1 R440.1 R441.1 R442.1 U1.AC14(VCCCLK3_35) U1.AC19(VCCADACBG3_3) U1.AE12(VCCCLK3_34) U1.AE16(VCCCLK3_30) U1.AE18(VCCCLK3_31) U1.AG14(VCCCLK3_33) U1.AG18(VCC3_36) U1.AG28(VCC3_35) U1.AG30(VCC3_34) U1.AH14(VCCCLK3_32) U1.AM12(VCC3_33) U1.AU12(VCC3_32) U1.AW25(VCC3_31) U1.BA25(VCC3_30) U15.16(VCCB) U16.6(VCCB) U17.5(VCC) U35.8(VCCB)
VP3P3_A_BLEED: PR73.2 PU25.5(BLEED)
VP3P3_BAT: C34.1 C104.1 D2.3 D8.3 R78.1 R129.1 R130.1 R271.1 R273.1 U1.AW14(VCCRTC)
VP3P3_BAT_SOURCE: BAT1.P1(ANODE_1) BAT1.P3(ANODE_2) R133.2
VP3P3_BST: PR23.1 PU2.7(VBST)
VP3P3_BSTR: PC19.1 PR23.2
VP3P3_SF100: D7.1 J6.1
VP3P3_SNUBBER: PC21.2 PR25.1
VP3P3_SPI: C135.1 C136.1 D7.3 R225.1 R227.1 R228.1 R304.1 U23.8(VCC) U24.8(VCC)
VP3P3_SW: PC19.2 PC21.1 PL2.1 PU2.6(SW)
VP3P3_VBAT_IN: D8.1 R309.2
VP3P3_VFB: PC18.2 PR22.2 PR24.1 PU2.2(VFB)
VP3P3_VIN: PC15.1 PC16.1 PC17.1 PR243.1 PU2.8(VIN)
VP3P3_VREG5: PC20.1 PU2.3(VREG5)
VP3P3_VSENSE: PC18.1 PR21.2 PR22.1
VP5P0: PC27.1 PC34.1 PC166.1 PC176.1 PC213.1 PC340.1 PR10.2 PR138.1 PR194.1 PR244.1 PR245.2 PR251.2 PR297.1 PU5.4(BIAS) PU6.4(BIAS) PU18.3(EN) PU18.5(VDD) PU19.3(EN) PU19.5(VDD) PU22.3(EN) PU22.5(VDD) PU26.3(EN) PU26.5(VDD)
VP5P0_BST: PR9.1 PU1.8(VBST)
VP5P0_BST_RC: PC4.1 PR9.2
VP5P0_FB: PC14.2 PR18.2 PR19.1 PR20.1 PU1.6(VFB)
VP5P0_FB_IN: PR18.1 PR248.2
VP5P0_L_RC: PC5.2 PC14.1 PR249.2
VP5P0_SN: PC12.1 PR247.2
VP5P0_SS: PC11.1 PU1.5(SS)
VP5P0_SW: PC4.2 PL1.1 PR247.1 PR249.1 PU1.2(SW)
VP5P0_VIN: PC1.1 PC3.1 PC309.1 PR7.1 PR8.1 PU1.3(VIN)
VP5P0_VOUT: PC5.1 PC6.1 PC7.1 PC8.1 PC9.1 PC10.1 PL1.2 PR10.1 PR245.1 PR246.1 PR248.1
VP12P0: C186.1 J10.A2(12V_1) J10.A3(12V_2) J10.B1(12V_3) J10.B2(12V_4) J10.B3(12V_5) J11.3 J11.4 PC163.1 PC174.1 PC216.1 PC246.1 PC327.1 PL9.2 PL11.1 PL12.1 PR7.2 PR8.2 PR132.1 PR185.1 PR214.2 PR243.2 PR250.2 PR263.2 PR279.1
XDP_CPU_MBP_N0: R181.2 U1.W75(B\P\M\0\)
XDP_CPU_MBP_N1: R180.2 U1.AD72(B\P\M\1\)
XDP_CPU_MBP_N2: J12.9 R412.1 U1.N78(B\P\M\2\)
XDP_CPU_MBP_N3: J12.11 R413.1 U1.M75(B\P\M\3\)
XDP_CPU_MBP_N4: J12.15 R414.1 U1.J78(B\P\M\4\)
XDP_CPU_MBP_N5: J12.17 R415.1 U1.H75(B\P\M\5\)
XDP_CPU_MBP_N6: J12.21 R416.1 U1.K75(B\P\M\6\)
XDP_CPU_MBP_N7: J12.23 R417.1 U1.J76(B\P\M\7\)
XDP_CPU_PRDY_L: J12.5 R418.1 U1.L78(P\R\D\Y\)
XDP_CPU_PREQ_L: J12.3 R419.1 U1.K77(P\R\E\Q\)
XDP_CPU_PRESENT_L: J12.60 R420.1 U1.M77(D\E\B\U\G\_\E\N\)
XDP_CPU_PWRGD: J12.39 R405.2
XDP_CPU_PWRGD_R: R402.2 R404.2 R405.1
XDP_CPU_TCK0: J12.57 R411.2
XDP_CPU_TDI: R175.2 R410.2 U1.V78(JTAG_TDI_CPU)
XDP_CPU_TDI_R: J12.56 R410.1
XDP_CPU_TDO: R403.2 R408.2 R462.1 U1.T78(JTAG_TDO_CPU)
XDP_CPU_TDO_R: J12.52 R408.1
XDP_CPU_TMS: J12.58 R174.2 R463.1 U1.R75(JTAG_TMS_CPU)
XDP_CPU_TRST_L: J12.54 R178.1 U1.U75(JTAG_TRST_N_CPU)
XDP_CPU_VCCOBS_AB: C190.1 J12.43 R399.2
XDP_CPU_VCCOBS_CD: C191.1 J12.44 R400.2
XDP_PCH_OBSDATA_D1: TP5.1 U1.BM1(SATA5GP_GPIO49)
XTAL_PCH_25M_IN: C37.1 R134.1 U1.K2(XTAL25_IN) Y3.1
XTAL_PCH_25M_OUT: C36.1 R134.2 U1.J1(XTAL25_OUT) Y3.3
N21407887: PR214.1 PR215.2 PR216.1
N31565706: D2.1 R133.1
N50951665: R335.2 R337.1 U30.21(A0)
N50952118: R322.2 U27.5(A2) U27.6(A1) U27.7(A0)
N50953882: R334.2 R336.1 U30.2(A1)
N50983122: PC175.1 PU18.11(TAO)
N50983135: PC180.1 PU19.11(TAO)
N51016995: R315.2 R446.1 U26.1(A0)
N51017052: R319.1 U26.7(WP)
N51017088: R321.1 R445.2 U26.2(A1)
N51062251: R361.2 Y4.1(EN)
N51103807: C155.1 R331.2 U30.3(\\\\\\\\\RESET)
N51110422: R320.1 R444.2 U26.3(A2)
N51251897: D1.1(A) R31.2
N51328604: R214.2 R223.2 R224.1 U21.6(S) U22.6(S)
N51706711: D3.2(C) Q4.3(D2)
N51706727: D4.2(C) Q4.6(D1)
N51706866: D5.2(C) Q5.6(D1)
N51706875: D6.2(C) Q5.3(D2)
N52503655: PC2.1 PR267.2
N52712988: J10.A69(PCIE0_RX12_N) R309.1
N52791405: R453.2 U8.13(1B1)
N52791408: R454.2 U8.12(1B2)
N52791411: R455.2 U8.11(2B1)
N52791414: R456.2 U8.10(2B2)
N52791852: R457.1 U8.4(1A1)
N52791855: R458.1 U8.5(1A2)
N52825916: Q6.3(C) R461.1
N53284246: J10.A6(JTAG_TDI) R88.2 R447.1
N53284254: J10.A7(JTAG_TDO) R92.2 R447.2
N53284256: J10.A5(JTAG_TCK) R86.2
N53284262: J10.A8(JTAG_TMS) R94.2
N54434897: J3.4 R132.2
N54436589: J3.2 R131.2
N54591271: Q1.3(D2) R465.1

Pads without a net: CN1 162 165; CN2 162 165; H1 1; J1 6 11 12 13 14; J6 8; J8 6 7 8; J9 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 29 30 31 32 34 35 36 37 40 42 44 46 48 50 52 53 54 55 56 58 67; J12 4 6 10 12 16 18 22 24 27 28 29 30 33 34 35 36; PU18 1 2 4; PU19 1 2 4; PU21 5; PU22 1 2 4; PU24 8; PU26 1 2 4; PU27 5; U1 A9 A12 A16 A18 A23 A25 A27 A29 A36 A38 A40 A42 A44 A47 A51 A53 A58 A60 A62 A64 A68 A70 AA2 AA4 AA77 AC4 AC11 AD9 AF66 AM2 AN7 AR74 AR76 AU14 AW12 B5 B8 B10 B13 B17 B19 B21 B24 B26 B28 B35 B37 B39 B41 B43 B46 B50 B52 B57 B59 B63 B65 B67 B69 BA14 BD7 BE32 BF33 BG28 BH26 BJ28 BJ32 BL26 BL33 BM28 BM32 BN26 BN33 BP28 BP32 BR26 BR33 BT28 BT32 BU26 BU33 BV32 BW33 C3 C7 C9 C12 C16 C18 C23 C25 C27 C29 C36 C38 C40 C42 C44 C47 C51 C53 C58 C60 C62 C64 C68 C70 CD54 CF52 CH60 CJ32 CJ43 CK45 CL32 CL43 CM45 CM56 CR54 CR65 CR67 CT38 CT53 CT68 CU54 CV40 CV53 CV68 D8 D10 D13 D17 D19 D21 D24 D26 D28 D35 D37 D39 D41 D43 D46 D50 D52 D57 D59 D63 D65 D67 D69 E4 F13 F16 F32 F35 F39 F43 F47 F51 G5 H14 H18 H22 H33 H37 H41 H45 H49 H52 J5 J13 J16 J32 J35 J39 J43 J47 J51 K14 K18 K22 K33 K37 K41 K45 K49 K52 M2 M4 N1 N3 N9 N13 N16 N20 N24 N28 N32 P7 P14 P18 P22 P26 P30 R2 R4 R9 R13 R16 R20 R24 R28 R32 T1 T3 T7 T14 T18 T22 T26 T30 T67 U2 U4 V11 V67 V74 Y1 Y3 Y7; U4 7 10; U11 7 10; U12 1; U14 6 7 10 11; U15 5 6 7 10 11 12; U17 1; U18 1; U19 1; U25 3 4 5 10 11 12 13 15 25 26 27 28 29 30 31; U28 1; U29 1; U31 C3 C5 C7 C11 C12 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 E8 E9 E10 E11 E12 E13 E14 E15 F4 F5 F6 F7 F10 F11 F13 F14 F15 F16 G2 G3 G4 G6 G12 G13 G14 H3 H4 H12 H13 H14 J3 J4 J14 K3 K4 K5 K6 K11 K12 K13 K14 L2 L3 L4 L5 L7 L10 L11 L12 L13 L14 M2 M3 M4 M6 M7 M8 M10 M11 M12 M13 M14 N3 N5 N6 N7 N8 N9 N10 N11 N12 N13 N14 P4 P8 P9 P10 P11 P14 R5 R6 R7 R8 R9 R10 R11 R14 R16 T5 T6; U36 1 5

## Via types
v1: diameter 0.483, hole 0.203, TOP to BOTTOM, 1814 vias
v2: diameter 0.889, hole 0.445, TOP to BOTTOM, 413 vias
v3: diameter 0.508, hole 0.203, TOP to BOTTOM, 1931 vias
v4: diameter 0.457, hole 0.305, TOP to BOTTOM, 27 vias
v5: diameter 0.457, hole 0.254, TOP to BOTTOM, 85 vias
v6: diameter 1.016, hole 0.508, TOP to BOTTOM, 230 vias
v7: diameter 0.61, hole 0.254, TOP to BOTTOM, 8 vias
v8: diameter 0.508, hole 0.305, TOP to BOTTOM, 15 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
GND: length 2435.8
  TOP w0.089: CN2.86 167.98,38.46 167.98,38.46 ; 165.62,81.95 165.77,81.95 165.8,81.97 CN2.252 ; 174.42,74.72 CN2.223
  TOP w0.108: U1.CV14 143.71,34.39 143.61,34.49 142.93,34.49 U1.CT14 ; U1.BP3 132.94,29.93 133.29,30.28 133.57,30.28 133.92,29.94 U1.BU4 ; U1.AA19 U1.AA21 ; 127.98,29.94 127.6,29.56 ; v1(125.71,27.21) 125.71,28.04 125.71,28.75 U1.AV2 ; U1.CA78 135.91,63.86 135.87,63.82 135.87,63.14 U1.CA76 ; v1(135.29,22.76) 134.26,23.79 v1(134.26,27.21) ; U1.CV74 143.79,62.25 143.52,62.52 143.07,62.52 142.7,62.15
  TOP w0.127: 174.28,77.71 172.7,77.71 v1(172.46,77.95) ; v1(138.23,27.2) 138.23,27.41 137.89,27.76 U1.CE1 ; v1(172.46,67.45) 172.7,67.21 174.42,67.21 CN2.193 ; v1(168.46,24.97) 167.46,25.96 CN2.36 ; v1(168.46,31.43) 167.93,31.96 CN2.60 ; CN2.18 166.49,21.46 167.5,21.46 168.01,20.94 168.44,20.94 v1(168.46,20.93) ; CN2.94 167.89,40.46 v1(168.46,39.9) ; v1(168.46,66.45) 168.17,66.74 167.53,66.74 167.3,66.97 CN2.192 ; CN2.176 167.89,62.97 v1(168.46,62.4) ; CN2.218 167.88,73.47 v1(168.46,72.9) ; 174.28,72.21 173.41,72.21 173.1,71.9 v1(172.46,71.9) ; CN2.234 167.3,77.47 167.53,77.24 168.17,77.24 v1(168.46,76.95) ; v1(168.46,35.47) 168.46,35.54 167.53,36.46 166.49,36.46 CN2.78 ; 174.42,74.72 173.26,74.72 v1(172.46,73.92) ; v1(168.46,68.46) 168.42,68.5 168.42,68.85 168.04,69.23 167.64,69.23 167.4,69.47 CN2.202 ; CN2.44 166.49,27.96 168.13,27.96 168.46,27.64 v1(168.46,26.98) ; CN2.22 167.66,22.46 168.03,22.09 169.3,22.09 v1(169.46,21.93) ; CN2.86 168.17,38.46 168.39,38.24 168.39,37.54 v1(168.46,37.48) ; v1(172.46,63.42) 172.99,63.95 173.21,63.95 173.48,64.22 CN2.181 ; CN2.244 167.71,79.97 168.42,79.26 168.42,79 v1(168.46,78.97) ; CN2.52 167.89,29.96 v1(168.46,29.4)
  TOP w0.152: U1.CP77 141.94,63.44 142.29,63.08 142.29,62.56 142.7,62.15 142.7,61.82 142.39,61.51 142.01,61.51
  TOP w0.178: U1.AU3 125.14,29.32 125.14,28.33 U1.AU1
  TOP w0.203: U1.BA3 127.03,29.48 127.52,29.48 127.6,29.56 ; v1(131.69,30.9) 131.22,30.43 U1.BK5 U1.BH5 ; U1.BD14 128.64,35.09 129.6,35.09 v1(129.72,34.97) ; v1(146.19,32.77) 146.06,32.77 144.44,34.39 U1.CV14 ; U1.AH74 121.29,61.88 v1(121.55,61.88) U1.AK75 U1.AK77 ; U1.AF76 119.98,63.19 119.98,64.25 U1.AF78 ; U1.R69 114.5,59.58 114.06,59.15 113.31,59.15 U1.L69 ; 127.98,29.94 127.99,29.94 U1.BD5 128.26,30.43 128.34,30.35 128.9,30.35 U1.BF5 ; U1.U66 115.69,58.03 115.03,58.03 114.86,57.86 U1.R66
  TOP w0.254: U1.CV29 144.65,41.32 145.32,40.66 v1(145.83,40.66) ; PC37.2 51.98,70.17 52.56,70.74 v3(52.8,70.74) ; U1.B76 U1.B74 ; U1.L51 113.37,50.5 U1.M49 ; U1.V14 116.35,35.05 U1.W16 117.07,35.77 117.4,35.77 v1(117.4,35.77) ; R170.1 151.23,64.59 v1(150.47,65.35) ; v1(119.93,65.16) 120.06,65.03 U1.AF78 ; v1(134.26,27.21) 134.48,27.43 134.48,28.88 U1.BU2 U1.BU4 U1.BW5 ; U1.AH16 120.89,35.22 120.38,35.22 U1.AG16 ; U1.U13 U1.W13 117.09,33.82 117.22,33.95 U1.AA14 U1.AA12 U1.AC12 118.63,33.65 U1.AE11 ; U1.E5 110.16,30.83 U1.E7 ; v1(129.72,33.25) 129.72,32.84 128.99,32.12 128.98,32.11 U1.BE9 ; U1.CP1 142.47,27.68 v1(142.47,26.55) 141.22,27.79 U1.CM1 ; U1.CB58 136.65,54.79 U1.CA60 ; v1(111.39,61.01) 111.47,61.01 111.91,60.57 111.91,60.19 112.4,59.7 v1(112.4,59.29) ; U1.AU78 125.51,63.84 U1.AV77 U1.AV75 U1.AU76 ; U1.BM20 v1(132.69,36.69) ; v1(130.9,26.71) 130.96,26.76 U1.BK1 ; U1.AU23 124.93,38.68 124.93,39.26 U1.AU25 125.03,39.39 124.66,39.77 v1(124.64,39.77) 124.63,39.77 124.23,39.37 U1.AR25 ; U1.AG12 U1.AH12 121.11,33.69 121.76,33.69 U1.AK12 ; PR1.2 8.56,40.8 8.28,41.08 PC296.2 8.23,41.49 PC11.2 8.23,43.24 8.23,43.25 8.23,43.41 8.17,43.47 PR20.2 ; U1.CU21 U1.CR21 ; U1.CE5 U1.CE3 ; U1.AN76 U1.AN74 123.03,62.11 123.3,61.84 v1(123.52,61.84) ; v1(145.14,60.26) 145.05,60.17 144.1,60.17 U1.CV70 ; v1(115.92,26.82) 115.92,28.03 U1.V1 ; v1(125.53,30.76) 125.76,30.99 U1.AW9 ; U1.AK16 v1(122.23,35.77) ; v1(150.44,61.85) 151.03,61.85 151.23,62.05 R171.1 ; U1.AC2 v1(118.58,28.39) ; U1.V18 116.35,36.76 U1.U20 ; U1.AH3 U1.AH5 ; U1.AH5 121.01,30.43 121,30.42 120.6,30.42 120.59,30.43 U1.AF5 120,30.43 119.99,30.42 119.59,30.42 119.57,30.43 U1.AD5 ; U1.AH5 121.37,30.43 122.19,31.25 U1.AL7 ; v1(116.63,52.43) 116.62,52.44 116.61,52.44 116.23,52.82 U1.V55 ; v1(107.39,51.6) 107.39,50.96 107.65,50.71 108.11,50.71 108.68,50.14 U1.B48 108.55,49.87 107.56,49.87 v1(107.47,49.78) ; U1.BR11 v1(134.18,32.39) ; U1.AL7 122.29,31.18 U1.AN5 123.33,30.73 v1(123.54,30.73) 123.84,30.43 U1.AR5 U1.AR3 ; U1.AL7 122.44,31.25 122.79,31.59 U1.AM9 122.67,32.11 122.29,32.49 U1.AL11 122.08,32.97 v1(121.79,32.68) ; v1(110.79,33.09) 110.79,32.96 111.21,32.53 111.7,32.53 111.71,32.54 112.07,32.54 112.5,32.11 U1.L9 ; U1.L1 U1.L3 ; U1.L16 112.88,35.18 U1.M14 ; v1(120.63,35.77) U1.AH18 ; v1(113.63,30.66) 113.63,31 U1.M7 113.19,31.25 v1(112.9,31.54) ; PC30.2 49.13,63.87 49.04,63.96 v3(48.96,63.96) 48.91,64.02 48.23,64.02 47.74,64.51 47.74,65 PU6.6 ; U1.AH69 120.44,59.58 120,60.03 119.94,60.03 v1(119.81,60.15) ; U1.AU1 v1(125.01,27.67) ; v1(119.81,32.68) U1.AF9 119.81,31.74 U1.AE7 119.11,31.25 v1(118.82,30.96) ; U1.C20 U1.A20 104.86,37.36 v3(103.35,35.85) ; U1.AR1 123.87,28.05 123.87,27.84 123.87,27.83 v1(123.87,27.61) ; U1.AH25 v1(120.63,39.77) U1.AH27 ; v1(113.38,37.55) 113.37,37.55 U1.M22 ; U1.BA3 U1.BB2 127.99,28.45 U1.BD1 ; U1.BR14 v1(132.69,34.97) ; U1.E36 U1.E38 ; U1.AL71 U1.AL67 ; U1.M18 113.37,36.37 113.39,36.35 113.39,35.95 113.38,35.94 113.38,35.83 v1(113.37,35.82) ; U1.AR19 124.12,36.97 124.03,37.05 123.63,37.05 123.55,36.97 U1.AP19 123.29,37.11 122.78,37.11 U1.AM19 v1(122.23,37.37) ; U1.V30 116.21,41.55 115.85,41.2 U1.U28 ; U1.AG21 U1.AE19 ; v1(117.43,38.17) U1.AA21 ; v1(145.82,61.79) 144.6,61.79 144.3,61.49 U1.CV73 ; U1.T33 115.46,43.27 115.59,43.4 115.61,43.4 U1.V35 115.84,44.42 115.83,44.42 v1(115.83,44.43) ; U1.AE67 119.22,58.82 119.11,58.82 118.79,59.15 118.64,59.15 118.21,59.58 U1.AA69 ; v1(131.21,35.83) U1.BH18 ; U1.CU37 U1.CR37 ; U1.AH30 U1.AH28 ; U1.CP78 U1.CP77 ; U1.E70 110.16,60.55 110.57,60.96 110.57,60.97 U1.F72 110.9,60.31 111.4,59.81 v1(111.4,59.29) ; U1.BF5 U1.BH5 U1.BH3 ; U1.M52 U1.P52 ; U1.CT29 U1.CP29
  TOP w0.279: U1.BM69 v1(131.21,59.29) ; U1.BG69 v1(129.22,59.29) ; U1.BT69 v1(133.19,59.29) ; U1.BY69 v1(135.17,59.29) ; U1.BV69 v1(134.18,59.29) ; U1.BJ69 v1(130.21,59.29) ; U1.BP69 v1(132.2,59.29)
  TOP w0.305: U25.23 187.47,4.86 v5(188.72,6.11) 190.47,7.86 U25.9 ; U1.AF74 U1.AF76 ; v3(7.46,66.58) 7.18,66.86 J12.20 ; U1.J3 U1.K4 ; U1.K4 U1.L3 ; U1.K4 U1.L5 113.36,30.66 v1(113.63,30.66) 113.89,30.66 U1.N5 ; v1(110.55,49.78) 110.16,50.16 U1.E49 ; U25.32 v3(191.26,3.66) ; v3(7.46,68.23) 7.33,68.36 J12.26 ; U1.E74 110.9,61.38 U1.F72 ; U1.U9 115.85,31.81 116.35,31.32 U1.V7 ; U1.E20 U1.E18 110.16,36.08 U1.E16 U1.E14 110.16,34.1 U1.E12 ; U1.E20 U1.C20 ; U1.E20 U1.E23 U1.E25 110.16,39.63 U1.E27 110.16,40.62 U1.E29 U1.E31 U1.E34 U1.E36 ; J12.50 v3(7.55,74.36) ; v1(125.26,61.01) 125.26,61.7 125.01,61.94 U1.AU74 U1.AV75 ; v1(125.26,61.01) 125.26,61.01 U1.AV71 ; v1(125.26,61.01) 125.05,61.01 U1.AU72 ; J12.31 10.15,69.86 v3(9.87,70.14) ; U25.2 v3(192.04,4.86) ; U1.M18 112.88,36.9 U1.L20 ; v3(52.8,70.74) 53.25,71.19 PU5.6 ; U1.H56 111.38,53.59 110.67,53.59 v1(110.52,53.74) 110.16,54.1 U1.E58 ; U1.E49 109.86,50.23 109.67,50.04 U1.D48 ; U1.E49 110.16,50.52 U1.E51 110.16,51.51 U1.E53 ; J12.59 v3(9.75,76.86) ; v3(3.8,64.53) 3.8,65.07 4.08,65.36 J12.14 ; U1.T74 v1(114.62,61.88) ; U1.F3 v1(110.82,30.02) U1.E5 U1.D5 109.54,30.54 109.37,30.72 108.91,30.72 108.57,31.05 U1.A6 U1.A5 U1.A3 U1.B3 U1.B2 U1.C2 ; U1.F3 U1.F1 ; U1.F3 U1.E2 ; U1.L28 113.37,41.19 113.37,41.49 ; v1(116.89,34.54) 116.74,34.68 U1.V14 ; U1.F1 U1.E1 ; U1.F1 111.15,27.84 v1(111.15,27.5) ; v3(9.87,68.87) 9.87,68.85 10.29,68.43 10.31,68.43 10.38,68.36 J12.25 ; U1.AB5 118.05,30.4 117.13,30.4 U1.Y5 ; v3(7.46,63.66) 7.26,63.86 J12.8 ; U1.C2 U1.C1 U1.E1 ; U1.C2 U1.E2 ; U1.E78 U1.E77 U1.C77 ; U1.E78 U1.F78 ; U1.E78 U1.C78 ; U1.C77 U1.B77 ; U1.C77 U1.C78 ; U1.B77 U1.B76 ; U1.B77 U1.B78 ; U1.B77 U1.A77 107.94,65.06 v1(107.84,65.17) ; U1.M26 113.19,39.83 112.87,40.15 v1(112.85,40.13) ; J12.7 v3(13.48,63.86) ; U25.16 v3(186.97,9.54) ; v3(28.8,45.88) R319.2 ; U1.L58 113.37,53.93 U1.M56 ; U1.K67 U1.L66 ; U1.K67 U1.H67 ; U1.K67 112.38,59.27 v1(112.4,59.29) U1.L69 112.88,60.14 U1.M71 ; U1.L66 U1.M64 ; U1.L66 U1.N66 U1.R66 ; v1(112.9,31.54) 112.88,31.56 U1.L9 113.08,32.11 v1(113.37,32.41) U1.M11 113.16,32.97 v1(112.86,33.27) 112.88,33.29 U1.L13 112.88,34.19 U1.M14 ; J12.1 v3(13.53,62.36) ; U1.V5 U1.V3 ; U1.AV67 124.77,59.22 U1.AU69 ; J12.38 3.7,71.36 3.45,71.61 v3(3.45,71.64) ; U1.V22 116.35,37.75 115.93,37.34 U1.U20 ; v1(126.25,54.17) 126.63,53.79 U1.BA56 ; v3(9.87,74.58) 10.09,74.36 J12.49 ; v3(9.87,66.71) 10.03,66.86 J12.19 ; v1(119.83,56.59) 119.81,57.18 120.5,57.86 U1.AH66 ; U1.E1 U1.E2 ; U1.AR60 U1.AU62 124.79,56.15 125.22,56.57 125.22,56.96 U1.AV64 ; 110.16,32.46 v1(110.79,33.09) U1.E12 ; 110.16,32.46 U1.E9 ; 110.16,32.46 U1.E12 ; U1.B78 108.65,65.12 v1(108.6,65.17) ; U1.B78 U1.C78 ; U1.BF56 129.03,53.97 v1(129.22,54.16) ; v3(44.82,28.34) 44.72,28.44 U35.4 ; U1.C78 v1(109.36,65.17) ; U1.D48 U1.B48 ; U1.D48 U1.E47 v1(110.82,48.59) 110.48,48.25 U1.E44 U1.E42 U1.E40 110.16,45.98 U1.E38 ; v1(117.57,61.88) U1.Y74 U1.Y76 ; v1(110.66,55.57) 110.28,55.18 U1.E60 ; U1.AU28 U1.AU30 125.03,42.23 124.43,42.83 v1(124.43,42.84) ; v3(7.48,69.38) 7.48,69.48 7.1,69.86 J12.32 ; J12.37 v3(9.92,71.36) ; U1.V60 U1.T60 ; v1(113.38,55.87) U1.L62 ; U13.9 80.62,26.2 v3(80.67,26.15) ; J12.13 14.11,65.36 v3(14.57,65.82) ; U27.4 62.34,69.63 v3(62.1,69.87) ; v1(126.22,34.17) 126.63,33.77 U1.BA12 ; v1(118.82,30.96) 118.82,30.69 U1.AD5 ; J12.2 v3(7.46,62.36)
  TOP w0.33: U1.Y55 v1(117.43,52.43) ; v1(113.89,48.18) 113.62,48.18 U1.M45 ; U1.T39 v1(115.03,45.23) U1.R37 ; U1.V26 v1(116.35,39.26) U1.U24 ; v1(119.83,34.17) U1.AG12 ; U1.AC27 v1(118.23,39.77) ; U1.AA16 117.43,35.77 v1(117.4,35.77) ; v1(123.04,38.96) U1.AP23 ; U1.AR19 124.3,36.97 124.42,37.09 124.91,37.09 U1.AU19 ; U1.AP53 v1(123.83,51.63) U1.AR53 ; v1(121.43,53.23) U1.AH56 ; v1(112.85,40.13) 112.85,40.18 112.84,40.19 112.84,40.65 U1.L28 ; U1.V18 116.35,36.04 U1.U16 ; U1.AK19 v1(122.23,37.37) ; U1.M26 113.41,39.85 v1(113.87,40.12) ; U1.M60 U1.P60 U1.T60 ; U1.BA16 v1(126.23,35.77) ; v1(119.83,35.77) U1.AG16 ; U1.L16 113.11,35.77 113.32,35.77 v1(113.37,35.82) ; v1(116.63,48.43) U1.V44 ; U1.AM30 v1(122.23,42.17) ; U1.L39 v1(113.38,46.13) 113.37,46.13 U1.M41 ; U1.BA28 v1(126.23,41.37) ; U1.AA56 v1(118.23,53.23) ; U1.L43 v1(112.88,46.99) ; U1.L32 v1(113.38,42.7) ; U1.Y40 116.63,46.03 v1(116.63,46.03) ; U1.AC16 v1(118.23,35.77) ; U1.M37 v1(113.87,45.27) ; U1.AM28 v1(122.23,41.37) ; U1.L20 v1(113.38,37.55)
  TOP w0.356: U1.CJ16 v1(139.13,35.83) ; U1.CH18 v1(138.63,36.69) ; U1.CG66 v1(138.14,57.58) ; v1(113.38,42.7) 113.38,43.27 U1.M33 ; U1.CH64 v1(138.63,56.72) ; U1.CG16 v1(138.14,35.83) ; U1.CH67 v1(138.63,58.44) ; U1.CG24 v1(138.14,39.26) ; U1.N76 U1.N74 v1(114.62,61.88) ; U1.Y40 U1.Y42 U1.V42 ; U1.AV64 U1.AU66 U1.AV67 ; U1.E68 110.49,59.14 110.91,58.72 U1.H67 ; U1.CH71 v1(138.63,60.15) ; U1.H56 U1.K56 ; U1.CL16 v1(140.12,35.83) ; U1.CG20 v1(138.14,37.55) ; v1(129.22,40.98) U1.BF30 ; U1.CG69 v1(138.14,59.29) ; U1.CA71 v1(135.66,60.15) ; U1.V62 U1.V60 ; U1.B61 U1.D61 ; v1(118.23,39.77) U1.AA25 ; U1.CH22 v1(138.63,38.4)
  TOP w0.381: R302.2 v3(135.6,2.57) ; v1(134.67,31.54) 134.96,31.25 U1.BW7 135.17,30.68 U1.BW5 ; PU11.8 v5(184.19,92.09) ; U1.AB74 v1(117.57,61.88) ; U1.M22 112.88,38.61 U1.L24 ; v5(185.33,92.09) 185.33,92.36 185.56,92.59 PU11.4 ; U10.15 68.14,32.07 67.79,32.42 v3(67.49,32.42) U10.14 ; U1.AR53 U1.AU53 ; C189.2 C192.2 v3(20.78,64.4) ; v3(63.6,36.36) 63.71,36.36 64.06,36.71 U10.8 ; U1.K60 U1.H60 110.95,55.29 v1(110.66,55.57) ; U1.K60 U1.M60 ; U1.K60 112.38,54.92 U1.L58 113.37,54.92 U1.M60 ; PC183.2 93.7,80.38 v3(93.67,80.35) ; PR14.2 52.24,68.79 51.98,69.04 PC37.2 ; C140.2 C147.2 179.27,89.6 v3(180.34,88.54) ; R168.2 107.97,71.63 107.19,72.41 ; U1.U66 116.35,57.37 U1.V64 116,56.66 115.85,56.66 v1(115.81,56.63) ; R263.2 R284.2 v3(99.33,61.23) 99.14,61.23 98.61,61.76 98.61,61.78 98.54,61.85 R295.2 R277.2 ; R185.2 v3(135.6,12.1) ; U31.K10 v1(48.15,39.3) ; v3(158.32,83.43) 158.32,83.09 159.59,81.83 159.59,81.49 160.14,80.93 161.88,80.93 162.64,81.69 R239.2 ; v3(139.91,79.81) 139.55,80.16 C127.2 ; U1.AC58 U1.AA56 ; U1.AC58 v1(119.03,54.03) ; U1.AC58 U1.AA60 U1.AA62 ; C37.2 v3(113.71,22.88) 113.71,20.82 114.68,19.86 v3(114.68,17.03) 113.33,17.03 Y3.4 ; v1(115.61,30.75) 116.12,31.25 U1.V7 117.09,30.5 U1.Y5 116.8,30.43 U1.V5 115.92,30.43 v1(115.61,30.75) ; v1(115.61,30.75) 115.3,30.43 U1.T5 ; U1.J72 111.68,61.3 v1(111.39,61.01) 111.11,61.3 U1.F72 ; R256.2 v3(117.75,73.29) ; PR260.2 PR207.2 149.94,82.18 v3(149.94,83.09) ; C119.2 26.83,69.06 v3(26.26,68.49) 26.78,67.96 R203.2 ; v3(70.61,71.62) 70.68,71.62 71.15,72.08 C200.2 ; v3(99.28,54.14) 100.57,55.42 Y1.4 ; C129.2 v3(36.04,31.36) ; v3(36.04,31.36) 35.92,31.48 U15.15 ; v3(36.04,31.36) 35.5,30.83 U15.14 ; C159.2 63.04,26.94 v3(63.3,26.69) ; v3(55.85,52.07) 55.85,52.1 55.59,52.36 Q5.4 ; U7.4 v3(142.22,85.23) ; U1.BF67 129.02,58.72 v1(128.73,58.44) 128.73,58.44 U1.BE66 ; PC174.2 14.45,16.9 v3(14.45,16.04) ; PC174.2 16.1,16.87 v3(16.1,16.04) ; PC174.2 v3(15.26,16.04) ; U1.AE11 v1(119.81,32.68) ; C172.2 v3(36.18,47.39) 36.21,47.35 U18.3 ; v3(79.34,68.36) 79.6,68.36 80.1,67.85 C25.1 ; C209.2 v3(71.3,37.2) ; v3(68.22,38.05) 68.14,37.97 U10.2 ; U1.BY24 v1(135.17,39.26) ; U29.3 50.46,60.55 v3(49.76,59.85) ; PR160.2 204.76,69.74 v5(201.67,69.74) ; U1.E40 110.49,46.27 v1(110.74,46.53) ; U31.H7 v1(51.13,43.28) ; U15.8 v3(26.76,27.58) ; Q4.4 57.24,54.03 57.24,54.2 v3(56.59,54.86) ; U1.R54 114.92,52.65 114.92,51.82 114.96,51.79 v1(114.96,51.68) 114.54,51.68 U1.P52 ; v1(124.63,53.23) U1.AR56 ; v1(124.63,53.23) 125.03,52.83 U1.AU55 ; v1(124.63,53.23) 124.23,52.83 U1.AR55 ; v1(124.63,53.23) U1.AU56 ; U31.G8 v1(52.13,42.28) ; v3(31.98,68.82) 31.98,68.8 31.6,68.42 U14.3 ; U1.L47 113.37,48.78 U1.M45 ; v1(119.81,58.44) U1.AE67 ; U1.AL67 122.58,58.44 v1(122.79,58.44) ; v3(139.4,90.84) 139.53,90.97 C30.2 ; 151.08,17.2 MHS4.1 ; MHS4.1 151.08,25.2 ; MHS4.1 147.08,21.2 ; MHS4.1 155.08,21.2 ; PC175.2 94.25,85.99 v3(94,86.25) ; PC331.2 78.74,39.51 79.5,38.75 ; R369.2 19.56,12.15 v3(19.17,11.76) ; v3(73.63,27.69) 73.63,27.08 73.8,26.92 U13.8 ; v3(129.51,6.89) R244.2 129.47,7.66 128.02,7.66 R100.2 ; v3(11.89,53.94) 11.71,53.94 10.56,52.8 PU1.1 ; U31.G5 52.07,44.36 v1(52.07,44.34) ; U1.V42 116.22,47.23 115.83,46.85 v1(115.83,46.83) ; v3(111,73.6) 110.7,73.3 R257.2 ; v1(135.66,38.4) U1.CA22 ; v1(119.83,38.97) 119.83,38.97 U1.AE23 ; U1.R40 v1(115.03,46.83) U1.R42 ; R226.2 v3(168.67,6.72) ; U31.G10 v1(52.13,39.3) ; U1.AK19 121.69,36.82 121.18,36.82 U1.AH19 U1.AG21 ; U1.AE19 U1.AC18 v1(118.23,35.77) ; PC27.2 PC29.2 41.91,64.66 41.74,64.66 v3(41.23,65.18) ; C116.2 v3(31.21,44.61) ; C199.2 151.1,60.19 v1(151.04,60.26) ; v3(68.14,41.46) 68.14,41.24 67.95,41.05 C158.2 ; R245.2 R253.1 v3(137.13,16.04) ; U1.M49 113.48,50.03 v1(114.03,50.03) ; U13.2 75.84,30.82 76.17,31.15 76.17,31.78 75.68,32.27 v3(74.98,32.27) ; R247.2 R300.2 v3(134.08,6.89) ; U31.G9 v1(52.13,40.3) ; 101.08,67.2 MHS2.1 ; MHS2.1 97.08,71.2 ; MHS2.1 105.08,71.2 ; MHS2.1 101.08,75.2 ; v3(36.01,36.79) 36.71,36.79 C165.2 ; v3(36.01,36.79) 36.01,35.81 C161.2 ; v3(36.01,36.79) 35.53,37.26 Y4.2 33.18,36.29 32.23,35.34 v3(31.97,35.34) 30.37,35.34 29.3,36.41 v3(29.3,41.51) 29.85,42.05 31.84,42.05 32.13,41.76 C118.2 ; v3(104.76,58.18) 104.76,58.17 104.42,57.82 C18.2 ; R95.1 113.94,70.7 114.16,70.93 v3(114.16,71.01) 114.82,70.35 R17.2 ; U16.2 89.49,70.88 v3(89.81,71.2) ; v1(116.63,46.03) 117.03,45.63 U1.Y39 ; v3(63.85,29.88) 64.24,30.27 U10.9 ; R387.2 43.84,58.69 v3(43.99,58.83) 44.58,58.24 44.58,55.52 44.07,55.01 C173.2 43.21,54.4 42.65,53.84 C164.2 ; v3(58.9,52.07) 58.9,52.33 Q4.1 ; R246.2 R97.1 118.09,17.66 v3(117.68,18.07) ; C210.2 v3(60.88,43.32) ; U1.M30 113.37,41.49 ; R352.1 v3(185.29,9.59) ; U1.BG24 v1(129.22,39.26) U1.BF26 ; v1(124.45,22.69) 124.45,22.66 124.48,22.63 C27.2 124.48,20.96 125.11,20.34 125.11,17.8 124.6,17.29 120.92,17.29 120.54,17.67 120.54,20.37 C26.2 v1(121.39,22.56) ; U1.CD16 137.36,35.83 v1(137.15,35.83) ; v3(51.15,64.8) 50.55,65.41 PR12.2 ; R212.2 37.24,44.29 v3(36.8,43.85) 36.27,43.32 35.69,43.32 35.28,42.92 35.28,42.56 ; C160.2 64.01,47.13 v3(64.26,47.39) ; U13.3 73.96,30.17 C131.2 72.8,31.21 v3(71.99,30.4) 71.51,29.92 U12.3 ; C122.2 v3(26.65,29.77) ; PU20.1 152.35,88.18 151.97,88.55 v3(151.97,89.19) ; U31.A1 v1(58.13,49.28) ; v3(53.61,77.22) PC34.2 PC36.2 ; U1.W24 116.56,39.26 v1(116.35,39.26) ; U1.CE5 U1.CG5 v1(139.37,30.66) U1.CJ5 ; v3(93.97,76.31) 94,76.28 94.54,76.28 PC180.2 ; v3(167.77,3.57) 167.61,3.42 R222.2 ; U1.CB16 136.16,35.83 v1(136.16,35.83) ; U1.M60 113.37,55.86 v1(113.38,55.87) ; v3(80.67,26.15) 81.54,26.15 C54.2 ; U31.G7 v1(52.13,43.28) ; U1.AR12 124.23,33.77 v1(123.83,34.16) 123.43,34.56 U1.AP14 ; PR32.2 PC114.2 30.05,82.87 PC115.2 29.24,81.72 28.85,81.34 27.79,81.34 27.38,81.75 PC67.2 PR34.2 26.5,81.06 25.71,80.27 23.85,80.27 22.94,81.19 22.94,83.96 23.78,84.8 25.9,84.8 26.61,85.5 27.35,85.5 PU14.5 ; U1.BM16 v1(131.21,35.83) ; U1.BR64 v1(132.69,56.72) ; PC298.2 v3(18.54,80.92) ; U31.B2 v1(56.13,47.28) ; U14.2 31.16,69.07 v3(31.34,69.25) ; v3(115.71,73.29) R276.2 ; PR17.2 v3(4.91,42.83) ; v3(90.69,73.08) 91.88,73.08 C205.2 92.58,72.94 93.42,72.94 R293.2 ; U31.T16 v1(42.15,33.3) ; U31.T1 v1(42.15,49.28) ; C125.2 68.55,28.1 v3(68.04,27.59) ; R123.1 v3(109.57,71.08) ; U1.BE69 128.73,60.15 v1(128.73,60.15) U1.BF71 ; U4.8 73.48,63.42 v3(73.5,63.41) ; PC305.2 41.16,60.59 v3(41.68,60.07) ; U23.4 163.51,8.03 v3(163.45,8.1) ; U19.3 64.3,40.26 64.7,40.66 64.7,40.69 v3(64.8,40.78) ; v3(202.53,77.3) 202.56,77.27 PC217.2 ; U14.15 36.98,69.07 v3(37.05,68.99) 37.05,68.74 36.73,68.42 U14.14 ; U17.3 v3(65.88,45.28) ; v1(128.73,56.72) 129.02,57 U1.BF64 ; R301.2 v3(140.18,12.1) ; U1.CC5 v1(136.4,30.66) 136.14,30.66 U1.CA5 ; U1.E70 110.16,59.85 U1.E68 110.16,58.86 110.16,58.85 110.16,58.44 U1.E66 110.16,57.87 U1.E64 110.16,56.87 U1.E62 U1.D61 ; U1.L74 112.94,62.12 v1(112.63,61.8) U1.J74 ; PR24.2 v3(45.36,78.65) ; U1.K56 U1.M56 ; v1(140.4,30.66) 140.41,30.66 140.42,30.63 U1.CL5 ; v3(39.37,69.61) 39.24,69.74 C130.2 ; Y3.2 109.4,18.98 v3(109.36,18.94) ; U1.AE14 v1(119.83,34.17) ; U31.J10 v1(49.15,39.3) ; PU24.4 88.01,32.26 87.73,31.97 v3(87.7,31.97) ; J1.2 36.85,22.34 36.42,22.78 v3(36.42,23.66) ; U1.BT24 v1(133.19,39.26) ; U1.AL64 v1(122.79,56.72) ; U1.L62 112.88,56.51 U1.M64 ; U1.U9 115.36,32.6 U1.T11 115.37,32.97 115.85,33.45 U1.U13 ; U1.V46 v1(116.63,48.43) ; v1(132.2,39.26) U1.BP24 ; PR217.2 v3(18.8,42.65) ; PC213.2 v3(103.83,77.31) ; U1.BJ58 130.71,54.91 130.71,54.91 130.71,55 v1(130.71,55) 130.42,55.29 U1.BH60 ; v3(36.06,51.37) R320.2 35.25,51.34 34.78,51.34 34.64,51.2 U26.4 ; U1.BG62 v1(129.72,56.72) U1.BH64 ; v3(126.21,16.05) 126.46,16.3 R87.1 ; U1.R46 114.57,48.83 113.92,48.18 v1(113.89,48.18) ; v1(143.89,69.87) 143.89,69.66 R173.1 ; R172.1 R173.1 ; R173.1 R176.1 ; v3(98.95,84.85) 98.46,84.36 PC273.2 ; v3(82.57,19.84) 82.59,19.87 C152.2 ; PC20.2 v3(49.27,77.92) ; C171.2 62.67,37.73 v3(63.1,38.16) 62.51,38.75 C175.2 ; v3(85.31,65.87) 85.31,66.26 C20.1 ; C126.2 47.7,24.12 48.72,25.14 v3(48.72,25.81) ; PR192.2 v3(194.15,20.21) ; PR215.1 v3(15.75,39.46) ; PR187.2 v3(194.15,22.5) PR192.1 ; U1.BY20 v1(135.17,37.55) ; v3(56.36,26.83) 55.74,26.21 U33.3 ; C19.1 82.93,66.52 82.93,66.17 v3(83.26,65.84) 83.26,65.78 82.93,65.44 82.93,65 82.59,64.66 U2.2 ; U1.BH11 v1(129.72,33.25) ; Q5.1 53.58,54.19 52.81,54.96 v3(52.81,54.98) ; v3(102.4,65.63) 102.48,65.55 103.6,65.55 R3.1 R93.1 ; PC112.2 v3(28.07,92.87) ; J6.2 v3(171.47,11.62) ; C33.2 199.42,13.5 v3(199.9,13.99) ; R321.2 35.57,49.7 v3(36.18,50.31) R362.2 ; U1.T33 114.63,43.99 U1.R35 ; U1.V22 115.85,38.61 115.85,38.61 U1.U24 ; U1.CA18 v1(135.66,36.69) ; v1(132.69,36.69) U1.BR18 ; U28.3 47.59,59.18 v3(47.52,59.12) 47.61,59.12 48.08,58.66 48.08,57.47 48.16,57.39 48.16,56.72 48.2,56.68 ; 53.32,59.88 53.32,59.94 54.1,60.72 54.99,60.72 v3(55.5,60.21) ; U4.9 80.14,63.42 80.29,63.28 v3(80.41,63.28) ; U31.H9 v1(51.13,40.3) ; U1.AE71 v1(119.81,60.15) ; U31.R15 v1(43.15,34.3) ; J8.2 20.55,22.33 v3(20.55,21) ; R234.2 v3(188.96,59.72) ; v1(127.02,37.36) 127.41,36.97 U1.BB19 ; v5(200.9,69.74) 201.04,69.59 PC166.2 ; v1(111.4,59.29) 111.39,59.28 U1.H67 ; U1.AM21 v1(122.23,37.37) ; U31.K7 v1(48.15,43.28) ; PC81.2 v3(184.98,87.98) ; U31.K9 v1(48.15,40.3) ; v1(155.93,67.45) 155.83,67.35 C137.2 ; U1.BH14 v1(129.72,34.97) ; 106.82,71.33 R2.1 ; R238.2 R449.2 v3(161.89,85.11) ; U1.BE28 v1(129.22,40.98) ; C135.2 v3(156.43,3.44) ; PR20.2 PR19.2 ; PC82.2 v3(179.69,93.23) ; v3(71.31,26.19) 71.48,26.02 C157.2 ; v3(85.75,33.45) 85.57,33.27 PC264.2 85.57,31.9 PC267.2 85.49,31.24 v3(85.37,31.11) ; U1.BR22 132.73,38.39 v1(132.69,38.39) ; U31.R2 v1(43.15,48.28) ; U1.AW5 v1(125.53,30.76) U1.AU5 ; PR223.2 v3(16.89,81.55) ; v3(28.67,64.55) 28.67,64.93 28.91,65.17 U14.8 ; PC297.2 v3(45.84,75.76) ; PC11.2 8.72,42.71 v3(8.97,42.45) ; PC151.2 73.47,37.86 73.17,38.17 v3(73.17,38.24) ; PC176.2 104.21,87.47 v3(103.78,87.9) ; C187.2 C193.2 20.27,62.37 v3(20.8,62.9) ; R319.2 PC307.2 ; U1.V30 v1(116.33,42.11) U1.U32 ; PU25.4 v3(42.47,76.37) ; v1(135.17,35.83) 135.6,35.58 U1.BY16 ; U1.BL64 v1(130.71,56.72) ; v3(7.83,40.17) PR1.2 ; U1.AR60 v1(124.77,55) 124.77,55 U1.AU58 ; v1(115.35,35.83) U1.U16 ; v3(36.8,64.55) 36.18,65.17 U14.9 ; v1(131.21,32.39) U1.BM9 ; v3(47.2,73.44) 47.34,73.58 PR222.2 ; U31.A16 v1(58.13,33.3) ; R124.1 v3(118.76,71.01) ; v1(134.18,32.39) U1.BV9 ; C124.2 v3(48.13,28.69) ; U1.AG62 v1(120.63,55.63) ; C32.2 v3(180.43,89.42) ; v1(132.2,55.86) U1.BP62 ; U1.AH53 v1(121.43,51.63) ; Y1.2 103.25,57.74 v3(103.61,57.38) ; v1(134.18,39.26) U1.BV24 ; PR37.2 v3(183.33,87.98) ; PR235.2 v3(39.77,59.65) ; v3(30.48,24.6) 31.34,23.74 J8.10 ; U10.3 v3(67.49,38.01) ; R84.1 v3(131.03,2.57) ; U1.BJ24 v1(131.21,39.26) 131.7,38.98 U1.BM24 ; U1.AK60 v1(122.23,54.83) ; U31.J8 U31.K8 v1(48.15,42.28) ; R254.2 v3(135.6,16.04) ; v3(39.34,57.82) 39.55,57.61 U34.2 ; v3(31.24,46.24) 30.73,46.75 R446.2 ; U31.B15 v1(56.13,35.3) ; v3(86.69,72.28) C29.2 ; U1.AA23 v1(117.43,38.17) ; C36.2 111.22,23.59 110.67,23.59 110.24,23.16 v3(110.24,22.75) ; v3(104.78,53.64) 104.42,54 C17.2 ; v3(119.81,73.42) 120.65,72.58 R265.2 ; U1.L35 113.09,44.13 v1(113.38,44.41) ; R264.2 v3(116.73,73.29) ; U1.AE64 v1(119.83,56.59) ; C44.2 v3(35.03,56.53) ; 165.62,81.95 165.56,81.95 165.12,81.51 165.12,80.93 ; v1(116.35,59.88) 116.35,59.92 116.35,59.92 116.35,60.44 U1.V71 ; R166.2 v3(120.79,71.01) ; U1.BN60 v1(131.7,55) ; R178.2 112.62,70.37 v3(111.83,71.15) ; U15.9 v3(36.05,27.58) ; U1.BN64 v1(131.7,56.72) ; PC295.2 v3(15.78,42.71) ; v3(116.48,74.82) 116.45,74.84 R286.2 ; v3(93.73,20.84) 93.73,20.46 93.03,19.77 U9.4 ; U1.BW14 v1(134.67,34.97) ; v1(132.2,34.11) U1.BM13
  TOP w0.508: 72.07,79.57 PJ20.2 ; 72.07,79.57 71.88,79.57 70.84,78.53 v3(70.84,78.17) ; 72.07,79.57 v3(71.34,80.3) ; PR304.2 76.58,51.07 v3(77.22,50.44)
  G02 w0.381: 149.07,21.2 MHS4.1 ; MHS4.1 153.09,21.2 ; MHS4.1 151.08,19.19 ; MHS4.1 151.08,23.2 ; J11.1 17,31.84 ; J11.1 15.59,30.43 ; J11.1 17,29.02 ; J11.1 18.41,30.43 ; BAT1.P2 203.67,42.53 ; BAT1.P2 202.65,41.51 ; BAT1.P2 201.62,42.53 ; BAT1.P2 202.65,43.56 ; J11.2 18.41,34.63 ; J11.2 17,33.22 ; J11.2 17,36.04 ; J11.2 15.59,34.63 ; 99.07,71.2 MHS2.1 ; MHS2.1 103.09,71.2 ; MHS2.1 101.08,69.19 ; MHS2.1 101.08,73.2
  T03 w0.108: v1(135.29,22.76) 134.97,23.08 134.97,26.96 135.29,27.28 v1(135.38,27.28)
  T03 w0.254: v3(26.82,59.67) 26.84,59.67 27.24,60.07 29.72,60.07 36.25,53.54 37.85,53.54 38,53.69 39.22,53.69 39.37,53.54 41.47,53.54 41.93,54.01 44.96,54.01 45.22,53.75 45.64,53.75 45.64,53.75 51.24,53.75 51.55,53.44 52.3,53.44 52.44,53.58 53.31,53.58 53.31,53.58 54.02,53.58 54.02,53.58 56.43,53.58 59.77,50.23 59.77,50.23 60.98,49.02 60.98,45.74 v3(61.47,45.25) 61.47,45.25 61.47,44.89 63.77,42.59 65.67,42.59 66.37,42.59 67.5,41.46 v3(68.14,41.46) 68.36,41.24 76.8,41.24 79.98,38.07 79.98,32.52 v3(80.31,32.19) 80.31,31.03 83.03,28.31 83.03,24.91 v3(84.15,23.78) 84.71,24.34 85.26,24.34 86.46,23.13 97.3,23.13 102.62,28.45 108.72,28.45 109.58,27.6 v1(110.46,27.6) 110.83,27.97 111.35,27.97 111.62,27.69 111.62,26.59 110.55,25.52 v1(110.54,25.52) 110.08,25.52 108.5,27.1 103.18,27.1 97.85,21.77 85.88,21.77 85.34,22.31 83.44,22.31 81.64,24.11 81.64,24.52 81.64,25.19 v3(80.67,26.15) 80.8,26.28 80.8,28.55 78.58,30.77 78.58,37.37 v3(76.68,39.28) 76.06,39.9 67.1,39.9 66.22,40.78 v3(64.8,40.78) 63.42,40.78 v3(60.88,43.32) 60.88,43.32 59.63,44.57 59.63,47.68 58.13,49.18 v1(58.13,49.28) 58.13,49.78 v3(55.85,52.07) 55.69,52.23 53,52.23 52.86,52.09 52.16,52.09 52.15,52.09 51,52.09 50.69,52.4 44.66,52.4 44.57,52.48 42.83,52.48 42.45,52.11 39.12,52.11 39.12,52 38.82,51.71 38.4,51.71 38.1,52 38.1,52.11 36.8,52.11 v3(36.06,51.37) ; 98.02,17.8 102.56,22.34 107.34,22.34 107.75,22.75 v3(110.24,22.75) 113.58,22.75 v3(113.71,22.88) 114.86,24.02 116.17,24.02 117.14,25 117.14,25.75 v1(117.17,25.77) 117.17,25.8 116.7,26.27 115.63,26.27 115.18,25.83 v1(115.18,25.8) 115.11,25.72 113.51,25.72 112.01,24.22 107.09,24.22 106.81,23.95 106.71,23.95 v3(106.69,23.93) 105.14,23.93 v3(105.1,23.97) 102.19,23.97 97.36,19.14 85.11,19.14 83.52,17.54 79.53,17.54 79.36,17.71 ; v6(193.75,45.12) 198.71,45.12 200.23,43.6 200.23,25.92 197.86,23.56 194.89,23.56 194.15,22.82 v3(194.15,22.5)
  T03 w0.381: 98.02,17.8 97.94,17.72 86.08,17.72 84.38,16.02 78.64,16.02 77.56,17.1 40.17,17.1 34.52,11.45 v3(31.58,11.45) 31.58,9.78 v3(31.35,9.55) ; v3(26.82,59.67) 26.67,59.53 26.67,58.12 v3(26.79,58) 26.79,57.81 27.56,57.04 30.3,57.04 35.98,51.37 v3(36.06,51.37) ; v3(31.35,9.55) v3(32.35,9.55) v3(34.35,9.55) 35.27,9.55 v3(35.27,9.56) 36.46,9.56 v3(36.53,9.49) v3(37.91,9.49) 39.1,9.49 v3(39.16,9.55) 39.35,9.74 v3(40.72,9.74) 40.72,9.25 v3(41.18,8.8) v3(42.58,8.8) 42.97,9.19 v3(42.97,9.74) 44.51,9.74 v3(44.65,9.61) 44.65,9.58 v3(45.18,9.05) 46.58,9.05 v3(47.08,9.56) v3(48.29,9.56) 48.29,9.55 v3(50.61,9.55) v3(53.19,9.55) v3(54.51,9.55) v3(57.19,9.55) v3(58.51,9.55) v3(61.19,9.55) v3(62.51,9.55) v3(65.35,9.55) 65.75,9.16 67.82,9.16 v3(68.19,9.53) 69.47,9.53 v3(69.49,9.51) 70.18,9.51 v3(70.22,9.55) v3(71.49,9.55) v3(74.19,9.55) v3(75.51,9.55) v3(78.19,9.55) 79.36,9.55 v3(79.5,9.41) 81.36,9.41 v3(81.58,9.19) v3(83.52,9.19) 86,9.19 v3(86.07,9.11) 87.41,9.11 v3(87.47,9.05) v3(88.3,9.05) 89.46,9.05 v3(89.97,9.55) v3(91.75,9.55) 92.59,9.55 v3(92.6,9.54) 94.17,9.54 v3(94.19,9.55) 95.45,9.55 v3(95.47,9.53) 95.7,9.53 v3(96.23,10.07) 96.46,10.29 98.05,10.29 ; v3(31.35,9.55) v3(29.06,9.55) 28.92,9.69 28.92,11.85 30.45,13.37 34.26,13.37 39.46,18.57 78.5,18.57 79.36,17.71
  G04 w0.381: MHS2.1 103.09,71.2 ; MHS2.1 101.08,69.19 ; MHS2.1 99.07,71.2 ; MHS2.1 101.08,73.2 ; J11.2 17,36.04 ; J11.2 15.59,34.63 ; J11.2 17,33.22 ; J11.2 18.41,34.63 ; BAT1.P2 202.65,43.56 ; BAT1.P2 203.67,42.53 ; BAT1.P2 201.62,42.53 ; BAT1.P2 202.65,41.51 ; 151.08,19.19 MHS4.1 ; MHS4.1 151.08,23.2 ; MHS4.1 149.07,21.2 ; MHS4.1 153.09,21.2 ; J11.1 18.41,30.43 ; J11.1 15.59,30.43 ; J11.1 17,29.02 ; J11.1 17,31.84
  T05 w0.381: 97.78,10.29 96.46,10.29 v3(96.23,10.07) 95.7,9.53 v3(95.47,9.53) 95.45,9.55 v3(94.19,9.55) 94.17,9.54 v3(92.6,9.54) 92.59,9.55 v3(91.75,9.55) v3(89.97,9.55) 89.46,9.05 v3(88.3,9.05) v3(87.47,9.05) 87.41,9.11 v3(86.07,9.11) 86,9.19 v3(83.52,9.19) v3(81.58,9.19) 79.73,9.19 v3(79.5,9.41) 79.36,9.55 v3(78.19,9.55) v3(75.51,9.55) v3(74.19,9.55) v3(71.49,9.55) v3(70.22,9.55) 69.54,9.55 v3(69.49,9.51) 68.21,9.51 v3(68.19,9.53) 67.94,9.29 65.62,9.29 v3(65.35,9.55) v3(62.51,9.55) v3(61.19,9.55) v3(58.51,9.55) v3(57.19,9.55) v3(54.51,9.55) v3(53.19,9.55) v3(50.61,9.55) 48.29,9.55 v3(48.29,9.56) 48.28,9.55 47.09,9.55 v3(47.08,9.56) 46.58,9.05 v3(45.18,9.05) 45.18,9.08 v3(44.65,9.61) 43.83,8.8 v3(42.58,8.8) v3(41.18,8.8) 39.92,8.8 v3(39.16,9.55) 39.1,9.49 v3(37.91,9.49) v3(36.53,9.49) 36.46,9.56 v3(35.27,9.56) 35.27,9.55 v3(34.35,9.55) v3(32.35,9.55) v3(31.35,9.55) v3(29.06,9.55)
  P06 w0.381: BAT1.P2 203.67,42.53 ; BAT1.P2 202.65,43.56 ; BAT1.P2 201.62,42.53 ; BAT1.P2 202.65,41.51 ; MHS4.1 151.08,23.2 ; MHS4.1 151.08,19.19 ; MHS4.1 149.07,21.2 ; MHS4.1 153.09,21.2
  P07 w0.381: MHS4.1 151.08,23.2 ; MHS4.1 151.08,19.19 ; MHS4.1 149.07,21.2 ; MHS4.1 153.09,21.2
  T08 w0.108: v1(134.67,31.54) 135.27,30.93 135.27,29.95 136.8,28.43 v1(136.8,27.15)
  T08 w0.381: v3(29.06,9.55) v3(31.35,9.55) v3(32.35,9.55) v3(34.35,9.55) 35.27,9.55 v3(35.27,9.56) 36.46,9.56 v3(36.53,9.49) v3(37.91,9.49) 39.1,9.49 v3(39.16,9.55) 39.92,8.8 v3(41.18,8.8) v3(42.58,8.8) 43.83,8.8 v3(44.65,9.61) 44.65,9.58 v3(45.18,9.05) 46.58,9.05 v3(47.08,9.56) v3(48.29,9.56) 48.29,9.55 v3(50.61,9.55) v3(53.19,9.55) v3(54.51,9.55) v3(57.19,9.55) v3(58.51,9.55) v3(61.19,9.55) v3(62.51,9.55) v3(65.35,9.55) 65.64,9.26 67.92,9.26 v3(68.19,9.53) 69.47,9.53 v3(69.49,9.51) 70.18,9.51 v3(70.22,9.55) v3(71.49,9.55) v3(74.19,9.55) v3(75.51,9.55) v3(78.19,9.55) 79.36,9.55 v3(79.5,9.41) 79.73,9.19 v3(81.58,9.19) v3(83.52,9.19) 86,9.19 v3(86.07,9.11) 87.41,9.11 v3(87.47,9.05) v3(88.3,9.05) 89.46,9.05 v3(89.97,9.55) v3(91.75,9.55) 92.59,9.55 v3(92.6,9.54) 94.17,9.54 v3(94.19,9.55) 95.45,9.55 v3(95.47,9.53) 95.7,9.53 v3(96.23,10.07) 96.46,10.29 98.05,10.29
  G09 w0.381: 17,33.22 J11.2 ; J11.2 15.59,34.63 ; J11.2 17,36.04 ; J11.2 18.41,34.63 ; 151.08,19.19 MHS4.1 ; MHS4.1 151.08,23.2 ; MHS4.1 149.07,21.2 ; MHS4.1 153.09,21.2 ; J11.1 17,31.84 ; J11.1 18.41,30.43 ; J11.1 15.59,30.43 ; J11.1 17,29.02 ; MHS2.1 103.09,71.2 ; MHS2.1 101.08,73.2 ; MHS2.1 99.07,71.2 ; MHS2.1 101.08,69.19 ; 201.62,42.53 BAT1.P2 ; BAT1.P2 203.67,42.53 ; BAT1.P2 202.65,41.51 ; BAT1.P2 202.65,43.56
  T10 w0.254: v1(172.41,58.52) 174.45,56.48 174.45,43.6 175.09,42.96 177.37,42.96 178.26,42.07 178.26,19.09 179.02,18.32 193.9,18.32 194.15,18.58 v3(194.15,20.21) ; v3(38.63,11.06) 38.8,11.24 38.8,14.89 arc(39.08,16.29) 39.87,17.48 41.28,18.88 44.7,22.31 47.07,24.67 arc(47.84,25.32) v3(48.72,25.81) arc(48.84,25.86) 48.96,25.91 arc(49.95,26.2) 50.98,26.3 51.73,26.3 v3(51.84,26.41) 51.95,26.3 v3(53.98,26.3) 55.16,26.3 arc(55.77,26.42) 56.29,26.76 v3(56.36,26.83) 57.59,28.07 arc(57.81,28.38) v3(57.88,28.76) arc(58.54,28.89) 59.09,29.26 60.6,30.77 arc(61.07,31.47) 61.23,32.29 61.23,33.99 arc(61.93,35.66) v3(63.6,36.36) 63.6,36.71 68.14,41.24 v3(68.14,41.46) 70.81,44.13 79.21,44.13 arc(79.58,44.2) 79.89,44.41 arc(81.87,45.73) 84.2,46.19 86.37,46.19 arc(87.01,46.32) 87.54,46.68 arc(87.62,46.73) 87.72,46.75 v3(87.77,46.75) 88.51,46.75 arc(89.2,46.89) 89.78,47.28 90.24,47.73 v3(91.03,48.53) 91.65,49.14 v3(91.65,49.14) 92.03,49.52 arc(92.95,50.13) 94.04,50.35 94.67,50.35 arc(95.83,50.58) 96.82,51.24 98.98,53.4 arc(99.2,53.74) v3(99.28,54.14) 99.91,54.14 arc(100.25,54.2) 100.53,54.39 arc(101.23,54.86) 102.06,55.02 102.73,55.02 arc(102.9,55.06) 103.04,55.15 103.31,55.42 arc(103.53,55.75) 103.61,56.14 v3(103.61,57.38) 104.43,57.38 arc(105,57.44) 105.55,57.61 arc(106.04,57.87) 106.47,58.22 arc(106.72,58.39) 107.03,58.46 110.06,58.46 arc(110.53,58.55) 110.92,58.81 v1(111.4,59.29) ; v3(175.94,17.57) 173.24,14.87 148.2,14.87 139.94,23.13 v1(139.94,25.1) ; v1(109.36,65.17) v1(108.6,65.17) v1(107.84,65.17) 106.35,66.66 103.43,66.66 v3(102.4,65.63) 101.39,66.63 86.56,66.63 85.8,65.87 v3(85.31,65.87) 85.27,65.84 v3(83.26,65.84) 81.86,67.24 80.79,67.24 80.18,66.63 74.92,66.63 70.58,70.98 70.58,71.59 v3(70.61,71.62) 70.58,71.65 70.58,72.87 v3(69.85,73.6) 69.61,73.83 69.61,77.48 70.3,78.17 v3(70.84,78.17) 71.68,79 73.09,79 74.59,77.5 74.59,73.72 76.93,71.38 78.18,71.38 78.69,70.88 79.62,70.88 80.06,71.32 81.05,71.32 81.56,71.84 86.25,71.84 v3(86.69,72.28) 87.77,71.2 v3(89.81,71.2) 90.14,70.87 93.03,70.87 97.26,75.1 105.55,75.1 v3(109.57,71.08) 110.15,71.66 111.47,71.66 111.83,71.31 v3(111.83,71.15) 111.97,71.01 v3(114.16,71.01) 114.49,71.01 115.03,70.47 118.22,70.47 v3(118.76,71.01) 119.33,70.44 120.23,70.44 v3(120.79,71.01) 121.43,71.64 123.66,71.64 127.91,67.39 127.91,62.46 v1(128.48,61.88)
  T10 w0.381: v3(39.16,9.55) 37.98,9.55 v3(37.91,9.49) v3(36.53,9.49) 36.46,9.56 v3(35.27,9.56) 35.27,9.55 v3(34.35,9.55) v3(32.35,9.55) v3(31.35,9.55) v3(29.06,9.55) ; v3(39.16,9.55) 39.35,9.74 v3(40.72,9.74) 40.72,9.25 v3(41.18,8.8) v3(42.58,8.8) 42.97,9.19 v3(42.97,9.74) 44.51,9.74 v3(44.65,9.61) 44.65,9.58 v3(45.18,9.05) 46.58,9.05 v3(47.08,9.56) v3(48.29,9.56) 48.29,9.55 v3(50.61,9.55) v3(53.19,9.55) v3(54.51,9.55) v3(57.19,9.55) v3(58.51,9.55) v3(61.19,9.55) v3(62.51,9.55) v3(65.35,9.55) 65.7,9.21 67.87,9.21 v3(68.19,9.53) 69.47,9.53 v3(69.49,9.51) 70.18,9.51 v3(70.22,9.55) v3(71.49,9.55) v3(74.19,9.55) v3(75.51,9.55) v3(78.19,9.55) 79.36,9.55 v3(79.5,9.41) 81.36,9.41 v3(81.58,9.19) v3(83.52,9.19) 86,9.19 v3(86.07,9.11) 87.41,9.11 v3(87.47,9.05) v3(88.3,9.05) 89.46,9.05 v3(89.97,9.55) v3(91.75,9.55) 92.59,9.55 v3(92.6,9.54) 92.6,9.86 v3(92.03,10.43) 92.03,15.06 93.78,16.81 98.99,16.81 99.24,17.06 v3(99.64,17.06) 102.73,17.06 v3(103.07,16.72) 103.07,16.67 103.42,16.31 106.05,16.31 arc(106.88,16.48) 107.59,16.95 109.36,18.72 v3(109.36,18.94) 109.39,18.96 arc(109.56,19.22) 109.62,19.52 arc(109.68,19.83) 109.86,20.09 110.92,21.16 arc(111.24,21.37) 111.62,21.45 116.69,21.45 119.02,23.77 119.02,25.43 v1(119.13,25.54) ; v3(39.16,9.55) 38.98,9.74 arc(38.72,10.12) 38.63,10.58 v3(38.63,11.06)
  G11 w0.381: 151.08,19.19 MHS4.1 ; MHS4.1 151.08,23.2 ; MHS4.1 149.07,21.2 ; MHS4.1 153.09,21.2 ; J11.1 18.41,30.43 ; J11.1 17,31.84 ; J11.1 15.59,30.43 ; J11.1 17,29.02 ; 15.59,34.63 J11.2 ; J11.2 17,33.22 ; J11.2 17,36.04 ; J11.2 18.41,34.63 ; 101.08,69.19 MHS2.1 ; MHS2.1 103.09,71.2 ; MHS2.1 99.07,71.2 ; MHS2.1 101.08,73.2 ; BAT1.P2 202.65,43.56 ; BAT1.P2 203.67,42.53 ; BAT1.P2 201.62,42.53 ; BAT1.P2 202.65,41.51
  BOTTOM w0.127: CN1.57 179.2,31.15 179.48,31.43 v1(180.19,31.43) ; v3(184.7,81.97) 184.76,81.92 CN1.252 ; CN1.168 185.41,60.91 185.04,60.55 184.55,60.55 184.34,60.76 183.7,60.76 v1(183.59,60.65) ; v1(180.19,41.93) 179.58,41.93 179.31,41.66 CN1.99 ; CN1.226 184.71,75.41 v1(184.19,75.93) ; CN1.184 184.71,64.91 v1(184.19,65.43) ; v1(180.19,37.48) 179.52,38.16 CN1.85 ; 184.63,63.47 184.24,63.47 v1(184.19,63.42) 184.7,62.91 CN1.176 ; 184.63,63.47 185.07,63.91 CN1.180 ; 184.63,63.47 186.02,63.47 CN1.178 ; CN1.244 186.96,79.92 ; v1(180.19,20.93) 179.48,20.93 179.19,20.65 CN1.15 ; 184.19,73.91 v1(184.19,73.92) ; 184.19,73.91 CN1.220 ; 184.19,73.91 184.69,73.41 CN1.218 ; v1(180.19,24.97) 179.88,24.65 CN1.31 ; CN1.82 183.27,37.41 v1(183.19,37.48) ; 184.2,40.91 v1(184.19,40.92) ; 184.2,40.91 184.7,40.41 CN1.94 ; 184.2,40.91 CN1.96 ; CN1.10 184.71,19.4 v1(184.19,19.92) 184.73,19.92 185.22,20.4 CN1.14 ; CN1.43 179.52,27.65 v1(180.19,26.98) ; v1(184.19,21.93) 184.72,21.4 CN1.18 ; 186.96,80.92 CN1.248 ; v1(180.23,43.84) 180.05,43.66 CN1.107 ; CN1.73 179.88,35.16 v1(180.19,35.47)
  BOTTOM w0.203: U1.AM21 122.63,37.53 122.47,37.37 v1(122.23,37.37) ; U1.AH25 121.03,39.18 121.65,38.57 C61.2 ; C43.2 124.23,33.94 124.07,34.11 123.91,34.11 123.86,34.16 ; v1(126.22,34.17) 126.85,34.79 C38.2 ; R96.2 117.2,63.4 117.2,62.15 117.47,61.88 v1(117.57,61.88) ; 123.86,34.16 v1(123.83,34.16) ; 123.86,34.16 124.05,34.16 124.17,34.29 124.17,34.51 C42.2 ; v1(118.23,39.77) 118.05,39.77 117.83,39.55 U1.AA25 ; C76.2 120.15,37.05 119.52,37.05 U1.AE19
  BOTTOM w0.229: C38.2 126.85,35.3 126.38,35.77 v1(126.23,35.77)
  BOTTOM w0.254: U5.4 89.11,27.08 88.55,27.64 v3(88.55,29.36) ; C180.2 125.11,34.49 125.43,34.17 v1(126.22,34.17) ; C128.2 120.56,35.04 v1(119.83,35.77) ; C47.2 119.7,32.57 v1(119.81,32.68) ; v1(122.23,54.83) 122.23,55.15 122.93,55.85 R90.1 ; U1.AC16 v1(118.23,35.77) ; R141.1 112.93,40.21 v1(112.85,40.13) ; R37.1 127.83,43.85 128.13,43.55 v1(128.74,43.55) ; v1(125.26,61.01) 125.51,61.26 R282.2 ; C57.2 121.81,36.94 v1(122.23,37.37) U1.AM19 122.67,36.97 123.15,37.44 ; U36.2 110.87,44.31 111.2,44.65 113.14,44.65 v1(113.38,44.41) ; U1.AE19 119.35,36.89 119.35,36.25 C50.2 ; U1.AH18 121.03,35.94 120.86,35.77 v1(120.63,35.77) ; C151.2 117.03,52.83 v1(117.43,52.43) ; v1(121.55,61.88) 121.55,62.38 R274.2 ; J9.27 66.27,71.69 66.51,71.93 66.51,71.99 66.55,72.02 66.55,72.71 v3(66.77,72.93) ; U1.AK12 121.83,32.72 v1(121.79,32.68) ; U1.AM28 v1(122.23,41.37) ; U1.AH25 v1(120.63,39.77)
  BOTTOM w0.305: v3(66.77,77.88) 66.57,77.69 J9.51 ; v3(66.77,72.93) 66.51,73.19 J9.33 ; C80.2 v1(124.43,42.84) 124.43,43.34 124.2,43.57 C41.2 ; R140.1 118.66,28.32 v1(118.58,28.39) ; v3(67.18,68.41) 67.18,67.62 66.74,67.19 J9.9 ; J9.15 63.28,68.69 v3(62.1,69.87) ; C191.2 v3(3.8,64.53) ; R169.1 116.03,56.19 115.81,56.41 v1(115.81,56.63) ; 123.15,37.44 122.96,37.44 U1.AM21 ; 123.49,39.34 123.11,38.96 v1(123.04,38.96) ; C77.2 121.04,40.17 v1(120.64,40.57) ; v1(119.83,34.17) 119.82,34.18 C48.2 ; C183.2 127.75,38.09 v1(127.02,37.36) 126.31,38.07 C53.2 ; J9.39 66.54,74.69 v3(66.77,74.46) ; v1(115.92,26.82) 115.69,27.05 R138.1 ; C40.2 116.51,46.16 v1(116.63,46.03) ; J9.3 64.48,65.68 64.23,65.44 64.23,64.26 J9.S2 66.31,64.09 66.77,64.55 66.82,64.55 v3(66.9,64.63) ; v1(118.82,30.96) 118.85,31 R32.2 ; U1.AU19 124.77,37.23 124.77,37.58 C179.2 ; J9.45 v3(67.32,76.19) ; J9.57 v3(66.86,79.19) ; J9.73 64.33,83.19 v3(64.1,82.96) 64.38,82.69 J9.71 ; R142.1 112.93,42.42 113.21,42.7 v1(113.38,42.7) ; R135.1 116.73,42.11 v1(116.33,42.11) 116.33,41.68 116.06,41.41 116.04,41.41 116.01,41.38 115.77,41.38 R137.1 ; v1(116.89,34.54) 116.58,34.23 R143.1
  BOTTOM w0.356: C50.2 v1(119.83,35.77)
  BOTTOM w0.381: U21.2 v3(182.47,10.96) ; PR226.2 51.78,29.24 v3(51.4,29.62) 51.61,29.83 PC300.2 ; PR25.2 52.91,88.68 v3(51.64,87.41) ; v3(55.5,60.21) 54.82,60.89 C155.2 ; R283.2 112.52,61.91 v1(112.63,61.8) ; v1(125.57,65.5) 125.14,65.07 PR136.2 ; R431.2 41.22,43.25 v1(41.22,42.38) ; v1(48.15,39.3) 48.15,39.07 47.9,38.82 C163.2 ; C132.2 199.42,9.87 v3(199.38,9.84) ; PC12.2 v3(11.89,53.94) ; R179.2 114.7,61.97 v1(114.62,61.88) ; v1(122.79,56.72) 123,56.93 R267.2 ; R336.2 54.07,62.9 v3(54.45,62.52) ; v1(118.82,30.96) 118.58,30.72 v1(118.58,28.39) ; U32.2 195.58,13.22 v3(195.33,13.48) ; v3(41.68,30.57) 41.9,30.57 PC306.2 ; C133.2 v3(182.85,4.33) ; U8.14 81.63,28.2 81.81,28.02 81.33,27.55 U8.15 ; v3(71.31,26.19) 71.31,26.67 C103.2 ; v3(188.98,12.08) 188.72,12.34 C134.2 R224.2 ; R233.2 v3(190.85,85.74) ; PR278.2 65.02,51.58 v3(64.52,51.07) ; C207.2 C206.2 52.8,83.72 52.25,84.26 v3(51.03,84.26) ; PR228.2 64.13,34.02 v3(64.13,33.59) ; C78.2 120.14,40.57 v1(120.64,40.57) ; v3(31.34,69.25) 30.86,69.73 U11.8 ; v3(46.91,31.71) 46.9,31.71 46.35,32.27 C174.2 ; C31.2 123.06,53.21 121.46,53.21 v1(121.43,53.23) ; R337.2 42.38,60.15 41.76,60.15 v3(41.68,60.07) ; v1(49.15,36.3) 49.19,36.3 49.45,36.56 49.45,36.56 49.88,36.99 49.88,36.99 50.11,37.22 C162.2 ; v3(62.96,83.35) 62.96,84.36 63.39,84.79 J9.S1 ; Q1.4 79.45,39.65 78.96,39.16 78.96,38.77 78.55,38.35 Q1.1 77.34,38.35 76.68,39.02 v3(76.68,39.28) ; U8.2 73.77,27.55 v3(73.63,27.69) ; C24.1 74.14,70.14 74.64,69.63 v3(74.77,69.63) ; v1(51.13,43.28) 50.99,43.42 C170.2 ; Q2.2 35.58,22.81 v3(36.42,23.66) 37.23,22.84 Q3.2 ; Q6.2 54.93,23.7 55.52,24.3 R460.1 55.52,25.52 54.75,26.3 v3(53.98,26.3) ; v3(126.21,16.05) 126.46,16.3 R87.1 ; v1(55.14,39.28) 54.86,39.56 R429.2 ; v1(52.15,37.3) 51.56,36.71 C168.2 ; C182.2 135.68,29.94 v1(136.4,30.66) ; v3(52.81,54.98) 52.6,54.77 51.23,54.77 U30.12 ; C108.2 191.65,5.25 v3(192.04,4.86) ; v3(195.71,7.13) 195.33,6.75 R350.1 ; v3(93.73,20.84) 93.73,20.59 92.71,19.57 C34.2 ; v3(84.15,23.78) 83.9,24.04 C23.2 ; v1(110.82,48.59) 110.59,48.59 110.21,48.21 110.21,47.95 ; C188.2 7.12,69.74 v3(7.48,69.38) ; v3(149.56,92.24) 149.56,90.28 PC322.2 147.88,89.62 PR265.2 ; v3(80.67,26.15) 80.78,26.04 C123.2 ; v3(201.96,33.32) 201.29,32.66 PC162.2 ; R294.2 139.44,7.63 139.5,7.57 v3(139.71,7.57) ; v1(116.35,39.26) 116.35,38.47 115.59,37.71 C3813.2 ; PR237.2 42.43,29.05 v3(42.14,29.05) ; C167.2 48.02,43.16 v1(48.15,43.28) ; U22.2 172.48,10 v3(172.59,9.89) ; C146.2 190.85,81.78 v3(190.85,81.19) 190.45,80.79 R232.2 ; v1(119.81,58.44) 119.31,57.93 R149.2 ; U11.3 31.11,66.48 v3(31.34,66.71) 31.34,66.2 31.33,66.2 30.96,65.83 U11.2 ; R435.2 43.1,39.94 v1(43.1,39.31) ; v3(114.16,71.01) 114.78,71.62 R285.2 ; PC140.2 153,91.24 v3(153.5,91.73) ; PC301.2 62.97,33.89 v3(63.43,33.43) ; U11.14 36.69,66.48 v3(36.92,66.71) 36.92,66.07 36.68,65.83 U11.15 ; v3(34.31,69.45) 34.58,69.73 U11.9 ; v1(52.13,40.3) 51.92,40.51 C169.2 ; R145.1 110.77,49.99 v1(110.55,49.78) 110.02,49.78 109.75,50.05 R147.1 ; R185.2 v3(135.6,12.1) ; C93.2 112.01,48.86 v1(111.89,48.73) ; C154.2 166.98,9.23 v3(166.95,9.2) ; R132.1 v3(202.56,2.81) ; v3(7.83,46.9) 8.26,47.33 PC13.2 ; v3(70.84,78.17) 73.01,78.17 PC219.2 ; v3(102.85,62.63) R16.1 ; C22.2 v3(41.67,63.1) ; v3(149.94,83.09) 149.94,83.6 150.42,84.08 PC316.2 ; R144.1 110.9,53.36 v1(110.52,53.74) ; PC304.2 45.13,28.64 v3(44.82,28.34) 44.83,28.34 44.94,28.23 PR239.2 ; v3(61.47,45.25) 61.11,45.61 R423.2 ; PJ22.2 v3(64.52,55.51) ; v3(18.77,12.46) 18.57,12.67 18.57,16.48 v2(18.87,16.78) ; v3(94.31,24.42) 94.31,24.83 C120.2 ; v3(55.34,28.61) 55.06,28.89 PR231.2 54.65,29.9 PC302.2 ; U20.10 174.22,9.91 174.28,9.97 174.28,10.21 v3(175.13,11.07) ; C35.2 v3(197.61,2.81) ; v5(188.72,6.9) 188.75,6.92 C107.2 ; C148.2 179.47,89.43 179.47,89.41 v3(180.34,88.54) ; v3(37.59,34.53) 37.59,34.58 38.25,35.24 PR2.2 39.11,35.77 PC299.2 ; v3(156.22,7.99) 156.37,8.14 U24.4 ; R292.2 123.17,56.31 R90.1 ; PC303.2 57.24,31.35 v3(56.99,31.35) ; U1.AA23 117.71,38.57 117.43,38.28 v1(117.43,38.17) 117.64,37.96 118.44,37.96 C62.2 ; v2(142.51,88.07) 142.51,88.2 143.38,89.07 v3(143.4,89.07) ; U8.9 80.31,31.76 v3(80.31,32.19) ; v3(27.01,64.55) 27.01,64.64 27,64.65 C121.2 ; v3(191.92,11.8) PC80.2 v3(191.92,8.53) ; v3(57.88,28.76) 58.05,28.92 58.05,29.36 PR233.2 ; 186.96,79.92 v3(187.31,79.92) ; C190.2 10.38,74.07 v3(9.87,74.58) ; 123.15,37.44 C153.2 123.72,37.43 124.24,37.43 C179.2 ; C102.2 187.15,6.87 v5(187.99,6.87) ; v3(187.32,80.92) 186.96,80.92 ; v3(201.18,12.52) 201.14,12.56 C156.2 ; C28.2 v3(47.47,20.36) ; R275.2 118.82,70.94 v3(118.76,71.01) ; U3.4 80.19,63.5 v3(80.41,63.28) ; C136.2 167.76,3.58 v3(167.77,3.57) ; C166.2 48.26,46.22 v1(48.21,46.27) 49.07,47.13 R427.2 ; U8.8 v3(74.98,32.27) ; C51.2 v3(51.06,83.37) ; PC326.2 v3(61.82,40.17) ; v1(45.14,38.29) 45.97,39.13 R433.2 ; v3(129.51,11.21) 130.21,11.91 130.21,12.45 129.7,12.96 R255.2 ; v3(58.8,41.29) 58.7,41.39 R425.2 ; C117.2 38.61,65.05 v3(38.61,64.28) ; C138.2 190.96,83.45 v3(191.36,83.85) ; R167.2 114.19,31.23 v1(113.63,30.66) 114.17,30.12 C178.2 C177.2 114.17,28.62 114.58,28.21 v1(114.58,27.81) ; v1(119.81,60.15) 120.26,59.71 R266.2 ; J9.S2 63.17,64.09 v3(62.2,65.06) ; v3(199.64,2.81) R131.1
  vias: v1(103.15,39.86) v1(104.76,39.77) v1(106.26,39.81) v1(107.81,39.83) v1(117.35,26.46) v1(120.06,49.37) v1(120.06,48.66) v1(120.06,47.95) v1(120.06,47.24) v1(120.06,46.53) v1(121.33,49.5) v1(121.33,48.79) v1(121.33,48.08) v1(121.33,47.37) v1(121.33,46.65) v1(121.33,45.94) v1(121.33,45.23) v1(125.33,51.56) v1(125.36,50.85) v1(125.36,50.19) v1(125.36,49.5) v1(125.36,48.81) v1(125.36,48.15) v1(125.36,47.44) v1(125.36,46.81) v1(125.36,46.15) v1(129.72,41.84) v1(129.89,71.27) v1(129.94,66.47) v1(129.99,68.73) v1(130.71,41.84) v1(131.21,44.41) v1(131.62,53.06) v1(131.62,52.42) v1(131.62,51.76) v1(131.62,51.12) v1(131.62,50.49) v1(131.62,49.85) v1(131.62,49.22) v1(131.62,48.58) v1(131.62,47.95) v1(131.62,47.31) v1(131.62,46.68) v1(131.7,41.84) v1(132.18,72.08) v1(132.18,69.82) v1(132.18,67.69) v1(132.18,65.55) v1(132.2,44.41) v1(132.69,41.84) v1(133.19,44.41) v1(133.68,56.72) v1(133.68,41.84) v1(134.18,44.41) v1(134.18,34.11) v1(134.42,61.88) v1(134.67,41.84) v1(134.67,33.25) v1(135.03,69.03) v1(135.03,66.88) v1(135.17,61.01) v1(135.17,40.98) v1(135.42,71.69) v1(135.41,61.88) v1(135.38,24.99) v1(135.66,41.84) v1(135.66,40.12) v1(135.66,33.25) v1(136.16,44.41) v1(136.4,61.88) v1(136.65,43.56) v1(136.65,41.84) v1(136.65,33.25) v1(136.8,24.89) v1(137.21,68.65) v1(137.21,66.54) v1(137.39,61.88) v1(137.64,41.84) v1(137.74,70.71) v1(138.14,61.01) v1(138.14,40.98) v1(138.22,25.06) v1(138.38,61.88) v1(138.37,22.89) v1(138.63,41.84) v1(138.63,40.12) v1(138.63,33.25) v1(139.21,69.01) v1(139.39,72.33) v1(139.37,61.88) v1(139.63,41.84) v1(139.63,33.25) v1(140.01,67.87) v1(140.36,61.88) v1(140.51,66.57) v1(140.62,41.84) v1(140.62,33.25) v1(140.66,26.32) v1(140.84,70.66) v1(141.51,23.54) v1(141.6,69.45) v1(142.23,24.76) v1(142.26,68.3) v1(142.39,72.36) v1(143.14,21.9) v1(143.73,27.15) v1(144.02,24.96) v1(144.22,26.51) v1(144.48,64.23) v1(144.88,26) v1(145.44,25.42) v1(145.51,28.42) v1(145.62,23.42) v1(145.84,60.27) v1(145.83,42.78) v1(145.9,63.32) v1(145.96,65.35) v1(146.17,34.97) v1(146.29,38.66) v1(146.34,37.29) v1(146.67,63.3) v1(147.14,26.74) v1(147.47,28.44) v1(148,42.77) v1(148.02,40.66) v1(148.08,61.79) v1(148.33,35.1) v1(148.38,32.77) v1(148.5,38.65) v1(148.5,37.29) v1(148.76,25.09) v1(149.02,63.3) v1(149.2,26.69) v1(149.47,28.44) v1(149.61,60.26) v1(150.19,42.79) v1(150.19,40.66) v1(150.47,35.14) v1(150.54,32.79) v1(150.66,38.65) v1(150.66,37.29) v1(151.07,26.82) v1(152.38,40.66) v1(159.04,32.77) v1(159.1,25.22) v1(159.23,37.27) v1(161.08,61.84) v1(162.15,61.84) v1(163,42.36) v1(163.19,30.68) v1(163.7,28.39) v1(163.67,26.83) v1(163.78,80.53) v1(163.77,42.36) v1(163.83,32.99) v1(163.77,18.41) v1(163.88,73.65) v1(163.88,67.56) v1(163.93,64.49) v1(163.95,77.44) v1(163.95,75.91) v1(163.98,69.87) v1(164,37.25) v1(163.95,30.67) v1(163.95,24.54) v1(163.95,20.7) v1(164.12,35.78) v1(164.05,22.25) v1(164.42,61.88) v1(164.46,80.64) v1(164.54,42.37) v1(164.54,26.83) v1(164.53,18.41) v1(164.64,73.65) v1(164.64,67.56) v1(164.64,32.99) v1(164.59,28.39) v1(164.71,77.44) v1(164.71,75.91) v1(164.74,69.87) v1(164.74,64.49) v1(164.71,30.67) v1(164.71,24.54) v1(164.71,20.7) v1(164.82,22.25) v1(164.88,35.78) v1(165.18,61.88) v1(168.46,80.98) v1(168.46,74.93) v1(168.46,70.48) v1(168.46,64.43) v1(168.5,43.84) v1(168.46,41.93) v1(168.46,33.45) v1(168.46,22.95) v1(169.13,61.4) v1(169.46,79.98) v1(169.46,77.95) v1(169.46,75.93) v1(169.46,73.92) v1(169.46,71.9) v1(169.46,69.48) v1(169.46,67.45) v1(169.46,65.43) v1(169.46,63.42) v1(169.46,42.93) v1(169.46,40.92) v1(169.46,38.9) v1(169.46,36.48) v1(169.46,34.45) v1(169.46,32.43) v1(169.46,30.42) v1(169.46,28.4) v1(169.46,25.98) v1(169.46,23.95) v1(169.46,19.92) v1(169.62,60.65) v1(169.62,43.91) v1(170.18,60.02) v1(170.73,60.65) v1(170.73,59.15) v1(170.73,43.88) v1(171.29,60.02) v1(171.46,80.98) v1(171.46,78.97) v1(171.46,76.95) v1(171.46,74.93) v1(171.46,72.9) v1(171.46,70.48) v1(171.46,68.46) v1(171.46,66.45) v1(171.46,64.43) v1(171.46,62.4) v1(171.46,41.93) v1(171.46,39.9) v1(171.46,37.48) v1(171.46,35.47) v1(171.46,33.45) v1(171.46,31.43) v1(171.46,29.4) v1(171.46,26.98) v1(171.46,24.97) v1(171.46,22.95) v1(171.46,20.93) v1(171.85,60.65) v1(171.85,43.81) v1(172.41,60.02) v1(172.46,79.98) v1(172.46,75.93) v1(172.46,69.48) v1(172.46,65.43) v1(172.46,61.4) v1(172.46,42.93) v1(172.46,40.92) v1(172.46,38.9) v1(172.46,36.48) v1(172.46,34.45) v1(172.46,32.43) v1(172.46,30.42) v1(172.46,28.4) v1(172.46,25.98) v1(172.46,23.95) v1(172.46,21.93) v1(172.46,19.92) v1(179.53,60.62) v1(180.19,80.98) v1(180.19,78.97) v1(180.19,76.93) v1(180.19,74.93) v1(180.19,72.9) v1(180.19,70.48) v1(180.19,68.46) v1(180.19,66.43) v1(180.19,64.43) v1(180.19,62.4) v1(180.25,60.65) v1(180.23,56.15) v1(180.23,52.88) v1(180.23,45.15) v1(180.19,39.9) v1(180.19,33.45) v1(180.19,29.4) v1(180.19,22.95) v1(180.83,61.4) v1(181.19,79.98) v1(181.19,77.95) v1(181.19,75.93) v1(181.19,73.92) v1(181.19,71.9) v1(181.19,69.48) v1(181.19,67.45) v1(181.19,65.43) v1(181.19,63.42) v1(181.19,42.93) v1(181.19,40.92) v1(181.19,38.9) v1(181.19,36.48) v1(181.19,34.45) v1(181.19,32.43) v1(181.19,30.42) v1(181.19,28.4) v1(181.19,25.98) v1(181.19,23.95) v1(181.19,21.93) v1(181.19,19.92) v1(181.35,60.65) v1(181.35,51.15) v1(181.48,43.96) v1(181.91,60.02) v1(181.91,58.52) v1(181.91,57.02) v1(181.91,55.52) v1(181.91,50.52) v1(181.91,49.02) v1(181.91,47.52) v1(181.91,46.02) v1(182.47,60.65) v1(182.47,57.65) v1(182.47,56.15) v1(182.47,54.88) v1(182.47,52.88) v1(182.47,51.15) v1(182.47,49.65) v1(182.47,48.15) v1(182.47,46.65) v1(182.47,45.15) v1(182.47,43.93) v1(183.03,60.02) v1(183.19,80.98) v1(183.19,78.97) v1(183.19,76.93) v1(183.19,74.93) v1(183.19,72.9) v1(183.19,70.48) v1(183.19,68.46) v1(183.19,66.43) v1(183.19,64.43) v1(183.19,62.4) v1(183.19,41.93) v1(183.19,39.9) v1(183.19,35.47) v1(183.19,33.45) v1(183.19,31.43) v1(183.19,29.4) v1(183.19,26.98) v1(183.19,24.97) v1(183.19,22.95) v1(183.19,20.93) v1(183.59,59.15) v1(183.59,54.88) v1(183.59,51.15) v1(183.59,43.81) v1(184.15,60.02) v1(184.15,57.02) v1(184.15,55.52) v1(184.15,52.02) v1(184.15,50.52) v1(184.19,79.98) v1(184.19,77.95) v1(184.19,71.9) v1(184.19,69.48) v1(184.19,67.45) v1(184.19,61.4) v1(184.22,47.43) v1(184.19,42.93) v1(184.19,38.9) v1(184.19,36.48) v1(184.19,34.45) v1(184.19,32.43) v1(184.19,30.42) v1(184.19,28.4) v1(184.19,25.98) v1(184.19,23.95) v1(184.7,52.88) v1(184.7,51.15) v1(184.7,45.15) v2(86.39,53.69) v3(0.98,95.22) v3(0.98,81.25) v3(0.98,78.71) v3(0.98,76.17) v3(0.98,73.63) v3(0.98,71.09) v3(0.98,68.55) v3(0.98,66.01) v3(0.98,63.47) v3(0.98,60.93) v3(0.98,58.39) v3(0.98,55.85) v3(0.98,53.31) v3(0.98,50.77) v3(0.98,48.23) v3(0.98,45.69) v3(0.98,43.15) v3(0.98,40.61) v3(0.98,38.07) v3(0.98,35.53) v3(0.98,32.99) v3(0.98,30.45) v3(0.98,27.91) v3(0.98,25.37) v3(0.98,12.67) v3(3.52,95.22) v3(3.64,55.66) v3(4.03,12.67) v3(4.52,55.66) v3(6.06,95.22) v3(6.56,55.03) v3(6.57,12.67) v3(7.45,55.03) v3(8.6,95.22) v3(8.84,54.65) v3(9.11,12.67) v3(11.14,95.22) v3(11.65,12.67) v3(13.68,95.22) v3(14.19,12.67) v3(16.22,95.22) v3(16.59,54.51) v3(18.41,54.6) v3(18.35,9.55) v3(18.76,95.22) v3(20.02,55.92) v3(20.02,55.03) v3(21.1,54.98) v3(21.16,55.92) v3(21.3,95.22) v3(21.42,14.59) v3(21.44,10.18) v3(22.56,55.92) v3(22.69,54.9) v3(23.7,54.9) v3(23.68,14.59) v3(23.84,95.22) v3(26.38,95.22) v3(28.92,95.22) v3(31.46,95.22) v3(34,95.22) v3(36.54,95.22) v3(37.41,72.66) v3(37.59,75.58) v3(37.7,74.74) v3(37.7,73.97) v3(38.07,83.13) v3(38.48,75.58) v3(38.96,83.13) v3(39.08,95.22) v3(39.88,83.2) v3(40.51,83.96) v3(40.88,11.06) v3(40.97,83.09) v3(41.62,95.22) v3(41.96,83.13) v3(42.6,11.09) v3(42.85,83.13) v3(43.77,83.4) v3(44.16,95.22) v3(44.45,84.34) v3(44.89,11.1) v3(45.37,83.4) v3(45.57,72.38) v3(45.97,84.34) v3(46.3,72.38) v3(46.58,14.09) v3(46.7,95.22) v3(46.96,72.03) v3(47.14,11.09) v3(48.85,14.13) v3(49.24,95.22) v3(50.63,69.76) v3(50.88,10.55) v3(51.03,85.43) v3(51.24,14.08) v3(51.39,70.14) v3(51.78,95.22) v3(52.78,14.13) v3(53.13,10.58) v3(54.32,95.22) v3(54.73,10.81) v3(55.09,14.13) v3(56.86,95.22) v3(56.9,16.53) v3(57,10.81) v3(58.29,73.47) v3(58.84,10.84) v3(59.31,16.53) v3(59.4,95.22) v3(60.1,73.22) v3(60.52,73.82) v3(60.91,16.25) v3(61.09,10.84) v3(61.29,73.82) v3(61.94,95.22) v3(62.99,11.42) v3(63.17,16.27) v3(64.48,95.22) v3(64.74,11.46) v3(67.02,95.22) v3(69.56,95.22) v3(71.4,75.83) v3(72.1,95.22) v3(73.91,48.66) v3(73.86,13.71) v3(74.64,95.22) v3(75.02,68.87) v3(75.56,50.33) v3(75.7,68.52) v3(75.78,10.43) v3(76.2,13.71) v3(76.4,50.33) v3(77.18,95.22) v3(77.72,13.93) v3(78.03,10.43) v3(79.63,10.25) v3(79.72,95.22) v3(80.14,13.93) v3(82.02,10.28) v3(82.26,95.22) v3(82.38,93.76) v3(82.38,93) v3(83.14,93.76) v3(83.14,93) v3(83.9,93.76) v3(83.9,93) v3(84.66,93.76) v3(84.66,93) v3(84.8,95.22) v3(84.84,60.09) v3(84.84,59.33) v3(84.84,48.53) v3(85.42,93.76) v3(85.42,93) v3(85.6,48.53) v3(85.67,59.33) v3(85.93,60.11) v3(86.36,48.53) v3(86.57,59.47) v3(87.01,47.51) v3(87.25,58.82) v3(87.34,95.22) v3(87.33,60.11) v3(89.53,93.74) v3(89.46,65.97) v3(89.67,10.44) v3(89.88,95.22) v3(90.25,65.95) v3(90.92,50.08) v3(90.91,49.29) v3(91.14,65.95) v3(91.67,49.93) v3(91.82,35.14) v3(91.85,34.43) v3(91.9,65.95) v3(92.18,35.8) v3(92.42,95.22) v3(92.35,29.96) v3(92.54,35.14) v3(92.56,34.43) v3(93.04,93.76) v3(92.97,35.82) v3(93.3,35.14) v3(93.32,34.43) v3(93.81,93.76) v3(94.79,47.21) v3(94.96,95.22) v3(95.08,93.76) v3(96.42,30.55) v3(96.39,29.38) v3(96.47,93.76) v3(96.88,29.99) v3(97.23,93.76) v3(97.5,95.22) v3(98,93.76) v3(98.49,76.47) v3(98.95,86.38) v3(98.95,85.61) v3(99.25,76.47) v3(99.52,16.27) v3(99.71,86.38) v3(99.71,85.61) v3(99.71,84.85) v3(100.04,95.22) v3(100.02,76.47) v3(100.47,86.38) v3(100.47,85.61) v3(100.47,84.85) v3(100.78,76.47) v3(101.19,12.67) v3(101.4,86.35) v3(101.37,85.61) v3(101.37,84.83) v3(101.59,76.42) v3(101.85,16.32) v3(102.06,53.41) v3(102.11,51.5) v3(102.11,49.9) v3(102.11,48.15) v3(102.35,76.42) v3(102.42,42.43) v3(102.5,39.53) v3(102.58,95.22) v3(103.73,12.67) v3(104.55,42.42) v3(104.75,51.4) v3(105.12,95.22) v3(105.74,49.93) v3(105.79,48.02) v3(106.27,12.67) v3(106.56,25.31) v3(107.66,95.22) v3(108.04,25.32) v3(108.81,12.67) v3(110.2,95.22) v3(111.35,12.67) v3(112.74,95.22) v3(113.89,12.67) v3(115.28,95.22) v3(116.43,12.67) v3(117.82,95.22) v3(118.97,12.67) v3(120.36,95.22) v3(121.51,12.67) v3(122.9,95.22) v3(123.48,11.15) v3(123.48,8.61) v3(123.48,6.07) v3(123.48,3.53) v3(123.48,0.99) v3(125.19,0.99) v3(125.44,95.22) v3(127.73,0.99) v3(127.98,95.22) v3(130.27,0.99) v3(130.52,95.22) v3(132.81,0.99) v3(133.06,95.22) v3(135.35,0.99) v3(135.6,95.22) v3(137.13,2.57) v3(137.89,0.99) v3(138.14,95.22) v3(140.43,0.99) v3(140.68,95.22) v3(142.97,0.99) v3(143.22,95.22) v3(145.49,92.87) v3(145.51,0.99) v3(145.76,95.22) v3(146.51,92.87) v3(148.05,0.99) v3(148.3,95.22) v3(148.67,92.24) v3(150.24,6.75) v3(150.59,0.99) v3(150.7,92.24) v3(150.84,95.22) v3(151.26,6.75) v3(152.15,6.75) v3(153.13,0.99) v3(153.38,95.22) v3(155.67,0.99) v3(155.92,95.22) v3(156.11,42.97) v3(156.82,42.97) v3(157.07,61.38) v3(157.94,61.38) v3(158.19,67.6) v3(158.21,0.99) v3(158.46,95.22) v3(158.96,67.6) v3(159.39,42.96) v3(159.72,67.6) v3(160.15,42.96) v3(160.48,67.6) v3(160.66,91.35) v3(160.75,0.99) v3(161,95.22) v3(161.34,91.74) v3(163.29,0.99) v3(163.54,95.22) v3(165.83,0.99) v3(166.08,95.22) v3(168.37,0.99) v3(168.62,95.22) v3(170.91,0.99) v3(171.16,95.22) v3(173.45,0.99) v3(173.7,95.22) v3(175.94,78.38) v3(175.94,75.31) v3(175.94,72.79) v3(175.94,69.74) v3(175.94,64.38) v3(175.94,63.6) v3(175.94,62.33) v3(175.94,40.89) v3(175.94,38.76) v3(175.94,34.21) v3(175.94,29.51) v3(175.94,27.22) v3(175.94,24.15) v3(175.94,21.86) v3(175.94,20.24) v3(175.94,18.33) v3(175.99,68.42) v3(175.97,36.04) v3(176.04,31.34) v3(175.99,25.52) v3(175.99,0.99) v3(176.24,95.22) v3(176.32,67.3) v3(176.39,74.69) v3(176.63,63.95) v3(176.7,78.35) v3(176.7,76.63) v3(176.7,72.79) v3(176.7,69.74) v3(176.7,62.33) v3(176.7,40.86) v3(176.7,38.76) v3(176.73,36.04) v3(176.7,34.21) v3(176.7,31.03) v3(176.7,29.51) v3(176.7,27.22) v3(176.7,24.15) v3(176.7,21.86) v3(176.7,20.24) v3(176.7,18.36) v3(176.7,17.57) v3(176.8,75.34) v3(176.75,68.32) v3(176.75,25.52) v3(178.53,0.99) v3(178.78,95.22) v3(181.07,0.99) v3(181.32,95.22) v3(183.61,0.99) v3(183.86,95.22) v3(186.15,0.99) v3(186.4,95.22) v3(187.93,76.49) v3(187.93,75.6) v3(187.93,74.84) v3(187.93,73.06) v3(187.93,72.17) v3(188.01,78.12) v3(187.96,77.36) v3(187.96,73.93) v3(188.69,0.99) v3(188.94,95.22) v3(191.23,0.99) v3(191.48,95.22) v3(193.56,91.71) v3(193.56,90.95) v3(193.56,90.19) v3(193.77,0.99) v3(194.02,95.22) v3(194.33,91.71) v3(194.33,90.95) v3(194.33,90.19) v3(196.31,0.99) v3(196.56,95.22) v3(198.85,0.99) v3(199.1,95.22) v3(201.39,0.99) v3(201.64,95.22) v3(203.93,0.99) v3(204.18,95.22) v3(206.47,0.99) v3(206.72,95.22) v3(209.01,95.22) v3(209.01,82.52) v3(209.01,79.98) v3(209.01,77.44) v3(209.01,74.9) v3(209.01,72.36) v3(209.01,69.82) v3(209.01,67.28) v3(209.01,64.74) v3(209.01,62.2) v3(209.01,59.66) v3(209.01,57.12) v3(209.01,54.58) v3(209.01,52.04) v3(209.01,49.5) v3(209.01,46.96) v3(209.01,44.42) v3(209.01,41.88) v3(209.01,39.34) v3(209.01,36.8) v3(209.01,34.26) v3(209.01,31.72) v3(209.01,29.18) v3(209.01,26.64) v3(209.01,13.69) v3(209.01,11.15) v3(209.01,8.61) v3(209.01,6.07) v3(209.01,3.53) v3(209.01,0.99) v5(47.19,85.05) v5(47.19,84.14) v5(47.19,83.23) v5(48.46,85.05) v5(48.46,84.14) v5(48.46,83.23) v5(78.05,49.93) v5(78.82,49.93) v5(79.58,51.35) v5(79.58,50.64) v5(79.58,49.93) v5(79.58,49.22) v5(79.58,48.51) v5(80.52,49.93) v5(81.45,51.35) v5(81.45,50.64) v5(81.45,49.93) v5(81.45,49.22) v5(81.45,48.51) v5(82.22,49.93) v5(82.99,49.93) v5(98.76,90.99) v5(98.76,89.12) v5(98.76,80.96) v5(98.76,79.09) v5(99.47,90.99) v5(99.47,89.12) v5(99.47,80.96) v5(99.47,79.09) v5(100.18,92.53) v5(100.18,91.76) v5(100.18,90.99) v5(100.18,90.06) v5(100.18,89.12) v5(100.18,88.36) v5(100.18,87.59) v5(100.18,82.5) v5(100.18,81.73) v5(100.18,80.96) v5(100.18,80.03) v5(100.18,79.09) v5(100.18,78.32) v5(100.18,77.55) v5(100.89,90.99) v5(100.89,89.12) v5(100.89,80.96) v5(100.89,79.09) v5(101.6,90.99) v5(101.6,89.12) v5(101.6,80.96) v5(101.6,79.09) v5(187.93,6.11) v5(188.72,5.32) v5(188.72,4.54) v5(189.51,6.11) v5(190.3,6.11) v5(196.72,69.74) v5(197.49,69.74) v5(198.26,71.16) v5(198.26,70.45) v5(198.26,69.74) v5(198.26,69.03) v5(198.26,68.31) v5(199.2,69.74) v5(200.13,71.16) v5(200.13,70.45) v5(200.13,69.74) v5(200.13,69.03) v5(200.13,68.31) v6(21.21,83.96) v6(24.44,85.79) v6(25.76,85.86) v6(28.02,80.3) v6(28.02,78.78) v6(28.02,77.25) v6(29.42,80.3) v6(29.42,78.78) v6(29.42,77.25) v6(63.39,92.98) v6(63.39,91.46) v6(63.39,89.93) v6(63.39,88.41) v6(63.39,86.88) v6(64.91,92.98) v6(64.91,91.46) v6(64.91,89.93) v6(64.91,88.41) v6(64.91,86.88) v6(66.44,92.98) v6(66.44,91.46) v6(66.44,89.93) v6(66.44,88.41) v6(66.44,86.88) v6(87.14,79.39) v6(88.54,79.39) v6(88.54,77.99) v6(89.73,76.6) v6(89.93,79.39) v6(89.93,77.99) v6(91.13,76.6) v6(91.33,79.39) v6(91.33,77.99) v6(92.52,76.6) v6(92.73,79.39) v6(92.73,77.99) v6(132.02,80) v6(132.1,91.2) v6(132.1,89.8) v6(132.1,88.41) v6(132.1,87.01) v6(132.1,85.61) v6(132.1,84.22) v6(132.1,82.82) v6(132.1,81.42) v6(132.08,78.5) v6(133.49,91.2) v6(133.49,89.8) v6(133.49,88.41) v6(133.49,87.01) v6(133.49,85.61) v6(133.49,84.22) v6(133.49,82.82) v6(133.49,81.42) v6(133.49,80.03) v6(133.62,78.63) v6(134.89,91.2) v6(134.89,89.8) v6(134.89,88.41) v6(134.89,87.01) v6(134.89,85.61) v6(134.89,84.22) v6(134.89,82.82) v6(134.89,81.42) v6(134.89,80.03) v6(135.02,78.63) v6(136.29,91.2) v6(136.29,89.8) v6(136.29,88.41) v6(136.29,87.01) v6(136.29,85.61) v6(136.29,84.22) v6(136.29,82.82) v6(136.29,81.42) v6(136.29,80.03) v6(136.41,78.63) v6(137.68,91.2) v6(137.68,89.8) v6(137.68,88.41) v6(137.68,87.01) v6(137.68,85.61) v6(137.68,84.22) v6(137.68,82.82) v6(137.68,81.42) v6(137.68,80.03) v6(187.79,42.58) v6(187.79,41.18) v6(187.79,39.79) v6(187.79,38.39) v6(187.79,36.99) v6(187.79,35.6) v6(187.79,34.2) v6(187.91,62.9) v6(188.55,64.3) v6(189.06,40.42) v6(189.06,39.02) v6(189.06,37.63) v6(189.82,42.58) v6(190.45,65.19) v6(191.98,65.19) v6(192.99,42.45) v6(193.5,64.68) v6(193.5,63.28) v6(193.5,61.88) v6(193.75,43.72) v6(194.9,64.68) v6(194.9,63.28) v6(194.9,61.88) v6(196.42,42.64) v6(196.42,41.24) v6(197.82,42.64) v6(197.82,41.24) v8(27.6,87.89) v8(27.6,86.89) v8(28.1,87.39) v8(28.6,87.89) v8(28.6,86.89) v8(45.78,66.75) v8(45.78,65.25) v8(46.28,66) v8(46.78,66.75) v8(46.78,65.25) v8(53.5,73.51) v8(53.5,72.51) v8(54.25,73.01) v8(55,73.51) v8(55,72.51)
